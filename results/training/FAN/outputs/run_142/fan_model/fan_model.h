/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.66890234e-01f, 5.97879998e-02f, -1.46834344e-01f, 9.97067094e-02f, 7.99434185e-02f, -5.65471202e-02f, -2.28377283e-01f, 2.07438767e-02f, 3.32062319e-02f, -2.09968574e-02f,
  -3.34680900e-02f, 1.35090619e-01f, -2.82265693e-01f, 2.86207855e-01f, 2.12431863e-01f, -1.03474297e-01f, 2.74518847e-01f, 6.82630390e-02f, 4.20351997e-02f, 5.85847124e-02f,
  1.80694640e-01f, 2.57485330e-01f, 2.75750961e-02f, 1.51931450e-01f, 9.03358459e-02f, -8.07833597e-02f, 1.60032466e-01f, -1.75175503e-01f, 9.24403816e-02f, 1.08902246e-01f,
  6.83538616e-02f, -3.84438271e-03f, -6.05553687e-02f, 4.47825491e-02f, -3.87496613e-02f, -5.57189770e-02f, 5.29989786e-03f, -1.62861850e-02f, -8.08746088e-03f, -3.91688757e-02f,
  3.40031157e-03f, 9.35989842e-02f, 3.69413421e-02f, 3.21042798e-02f, 5.12103550e-02f, 1.41551101e-03f, -3.43870558e-03f, -3.06829121e-02f, -1.38311982e-02f, 3.30263861e-02f,
  -5.34131639e-02f, -3.06142494e-02f, -1.47893516e-04f, 1.76266469e-02f, -3.31436470e-02f, -4.65217233e-02f, 7.14313611e-03f, -2.97463946e-02f, -2.57253796e-02f, 3.96014191e-02f,
  5.55150136e-02f, -2.76439153e-02f, -1.27664944e-02f, 3.21036465e-02f, -1.05890920e-02f, 1.03607774e-02f, -4.04917002e-02f, -1.27545772e-02f, -2.62055360e-02f, -1.43449008e-02f,
  4.37274715e-03f, 7.81749748e-03f, 1.02838418e-02f, 2.91963331e-02f, -3.35543267e-02f, 1.90697201e-02f, -5.43620856e-03f, 3.02190278e-02f, 1.37492156e-04f, -1.35860983e-02f,
  2.14051455e-02f, -9.84339882e-03f, -5.05125709e-03f, -3.51792056e-04f, -5.19991592e-02f, -4.52297851e-02f, -7.97643035e-04f, 2.07125321e-02f, -3.95870842e-02f, -5.32814935e-02f,
  -9.51398537e-03f, 1.88739449e-02f, -3.00781764e-02f, 1.35797402e-02f, 2.90269386e-02f, 4.36538421e-02f, 8.17445144e-02f, 3.30673456e-02f, 5.99827664e-03f, 5.06400056e-02f,
  -3.00942026e-02f, -7.48608857e-02f, 2.65357294e-03f, 1.98674127e-02f, -3.70788537e-02f, 5.03328368e-02f, -5.22916354e-02f, 1.37988785e-02f, 7.46923545e-03f, 2.38479730e-02f,
  -4.27694768e-02f, 1.13660740e-02f, 3.17029506e-02f, -3.73329557e-02f, 7.10763857e-02f, 2.19899463e-03f, 3.13872099e-02f, -9.44096316e-03f, -5.79135399e-03f, -1.36188148e-02f,
  -1.77878141e-01f, -8.85409564e-02f, 1.28770232e-01f, -2.03817159e-01f, -1.24152862e-01f, -1.13387406e-01f, -7.96506926e-02f, -1.67540491e-01f, -6.67323265e-03f, -9.53120738e-02f,
  -1.32154062e-01f, 1.63039222e-01f, 1.38574421e-01f, -1.82720140e-01f, 6.10976182e-02f, 7.98501223e-02f, -1.07050337e-01f, -5.34288734e-02f, 5.73421344e-02f, -9.20257121e-02f,
  -9.94390547e-02f, -2.32711762e-01f, -1.28577184e-03f, -1.11562230e-01f, -1.21550195e-01f, -4.60374057e-02f, 4.95944964e-03f, 6.33648410e-02f, -1.31788850e-01f, 2.29252409e-02f,
  -7.36679044e-03f, -4.51981723e-02f, -3.32108289e-02f, 1.39850480e-02f, -2.57402584e-02f, -7.39936158e-02f, 5.37102968e-02f, 3.40941176e-02f, -2.70953868e-03f, -1.14232507e-02f,
  1.67354606e-02f, -1.88482273e-02f, -5.26568405e-02f, 7.58476779e-02f, -4.41429913e-02f, -9.10778418e-02f, 6.32966915e-03f, -3.12133748e-02f, 2.38865726e-02f, 1.35285836e-02f,
  4.23382260e-02f, -5.05723292e-03f, -3.30662802e-02f, 7.09872544e-02f, -5.58350654e-03f, 9.71646886e-03f, 6.49607480e-02f, 5.84105775e-02f, 9.92381480e-04f, 5.11133932e-02f,
  2.33983006e-02f, -8.23228620e-03f, -3.95621546e-02f, 1.35519281e-02f, -9.96099710e-02f, -6.60033971e-02f, -4.25202912e-03f, 2.28054263e-02f, -2.41370667e-02f, -6.57118112e-02f,
  -8.09379518e-02f, 2.79100472e-03f, -6.54053017e-02f, 1.52845653e-02f, 2.51595862e-02f, -1.19546065e-02f, -3.68881598e-03f, 5.50314272e-03f, -4.73568551e-02f, 1.86265092e-02f,
  -6.22355007e-03f, -9.75002884e-04f, -3.76838483e-02f, 4.31826636e-02f, 4.35056776e-04f, -1.32546062e-03f, -2.21863333e-02f, 4.40548249e-02f, 2.01286525e-02f, 1.80481821e-02f,
  -3.68236154e-02f, 6.52800081e-04f, 2.62920372e-02f, 3.12116165e-02f, 1.46628376e-02f, -4.12432328e-02f, -2.72954106e-02f, -2.37386692e-02f, 8.73014238e-03f, 2.15842389e-02f,
  -9.63900089e-02f, -2.71307882e-02f, 2.25029569e-02f, 3.07961721e-02f, 2.13370360e-02f, -3.78578901e-02f, 1.59533857e-03f, -2.50734459e-03f, -9.04000271e-03f, -1.38926674e-02f,
  -4.50771265e-02f, -4.20737006e-02f, 6.37893938e-03f, -1.69676691e-02f, -2.29562018e-02f, -2.43298896e-03f, -5.92094772e-02f, 3.82250883e-02f, 3.77310347e-03f, 5.10173179e-02f,
  8.86985213e-02f, -7.58490413e-02f, 1.41117021e-01f, -1.92532763e-02f, 7.87062719e-02f, -3.49590123e-01f, -3.44809085e-01f, 7.90592805e-02f, 1.75980628e-01f, -2.06230685e-01f,
  -1.18865408e-01f, 7.92938285e-03f, -7.17363432e-02f, -1.45776272e-01f, 7.16588348e-02f, -6.15707263e-02f, -7.84857571e-02f, -1.49728730e-01f, 8.13529715e-02f, -5.59191778e-02f,
  1.17697261e-01f, -1.89306155e-01f, 6.86842352e-02f, 5.17226048e-02f, -5.75149842e-02f, 6.68938458e-02f, 4.77869296e-03f, 1.16704674e-02f, -6.01332672e-02f, -6.85056522e-02f,
  4.58835810e-03f, -4.25407179e-02f, 3.74787897e-02f, 1.22455321e-02f, -5.11848368e-02f, -3.57716046e-02f, -6.68412223e-02f, -3.92743833e-02f, 1.70439351e-02f, -3.87954749e-02f,
  -5.47410026e-02f, 3.21446806e-02f, -4.52078581e-02f, 5.24687357e-02f, -6.81423396e-02f, 2.86308695e-02f, 3.20748501e-02f, 1.15916990e-02f, 7.44403852e-03f, 1.24333650e-02f,
  3.26329134e-02f, 7.24003315e-02f, 4.27257549e-03f, -1.55930044e-02f, 5.47806099e-02f, -4.39151637e-02f, -6.57437593e-02f, -3.80883887e-02f, -8.35719425e-03f, -9.05639213e-03f,
  -7.93027803e-02f, -1.01510296e-02f, -2.33561266e-02f, 2.06058770e-02f, 1.39015419e-02f, 4.04692702e-02f, -9.28206276e-03f, -2.53298208e-02f, 2.33932901e-02f, -8.16963911e-02f,
  5.96011132e-02f, 7.79131008e-03f, 1.02019152e-02f, -3.61584798e-02f, -2.88557783e-02f, -5.39016202e-02f, -1.09065212e-02f, -2.79041398e-02f, -1.74651053e-02f, 4.04864438e-02f,
  1.41568873e-02f, -1.44560719e-02f, 3.65117937e-02f, -7.69045437e-03f, -3.04757040e-02f, -1.19789233e-02f, -3.66648175e-02f, 1.75454430e-02f, -1.28410757e-02f, 8.69823433e-03f,
  -1.30847156e-01f, -6.73804656e-02f, 3.65762264e-02f, -2.44066305e-03f, 2.06960328e-02f, 4.65124846e-02f, 1.67116020e-02f, -3.10000330e-02f, 2.81194486e-02f, -5.11963945e-03f,
  -4.04506326e-02f, -5.14247604e-02f, 1.31650046e-02f, -4.32678200e-02f, 7.01369066e-03f, 8.45926534e-03f, -6.75151944e-02f, 6.71644360e-02f, 3.91975930e-03f, 4.26784232e-02f,
  -4.34819870e-02f, -4.21897173e-02f, -5.16459462e-04f, 5.13850562e-02f, -2.54483726e-02f, -1.97330490e-02f, 5.72584942e-02f, 7.11321458e-02f, -5.88606996e-03f, 1.76441204e-02f,
  2.35154659e-01f, 1.24355055e-01f, -6.46535680e-02f, 6.88925385e-02f, 1.77168041e-01f, -9.03776661e-02f, 1.13712139e-01f, 5.75561374e-02f, -1.07617667e-02f, 5.02452962e-02f,
  5.22418064e-04f, 8.32916722e-02f, -2.07634240e-01f, 8.21691006e-02f, 7.41429254e-02f, -1.69297472e-01f, 1.85016409e-01f, -8.69840290e-03f, 7.57565796e-02f, 1.31120652e-01f,
  9.19913203e-02f, 2.66063631e-01f, 3.63495871e-02f, 6.19138367e-02f, 1.39190510e-01f, 1.64258201e-02f, 1.19024217e-01f, -4.77923974e-02f, 1.16186306e-01f, 7.17815384e-02f,
  1.89524889e-01f, 4.78087808e-04f, 2.38262173e-02f, -2.75136400e-02f, 1.04742371e-01f, -4.10045348e-02f, -1.24508990e-02f, -5.46444766e-02f, 2.24370090e-03f, -3.11894510e-02f,
  -4.13331948e-02f, -3.49437855e-02f, 1.08851977e-02f, -7.78558478e-02f, -1.26776500e-02f, -6.85809106e-02f, -4.94940840e-02f, 1.36453379e-02f, -2.68906746e-02f, -7.48796761e-02f,
  -9.13463980e-02f, -3.78365256e-03f, -1.19342944e-02f, 1.46164335e-02f, 1.68740824e-02f, 8.06218833e-02f, -8.13047290e-02f, 3.57957743e-02f, 1.54148247e-02f, 5.39325438e-02f,
  -2.20670439e-02f, -1.33461726e-03f, -4.72562537e-02f, 3.46079352e-03f, 6.00026585e-02f, 8.44410509e-02f, -1.75049938e-02f, -3.44670713e-02f, -4.13366742e-02f, 6.15058839e-02f,
  -2.43275203e-02f, 5.53568034e-03f, -2.21048277e-02f, -7.87950903e-02f, -4.28946968e-03f, 6.60488084e-02f, 2.74263639e-02f, -4.03195620e-02f, -4.03694995e-02f, 4.01122645e-02f,
  1.55549686e-04f, -2.60779820e-02f, 3.93222906e-02f, 2.25395616e-03f, 4.09685858e-02f, -3.50206867e-02f, -1.14963263e-01f, -4.53122072e-02f, 5.11350110e-03f, 1.99019182e-02f,
  1.11166090e-01f, 2.23654643e-01f, 6.09116517e-02f, 3.20548452e-02f, 2.73537301e-02f, -2.46227626e-02f, 2.09980793e-02f, -9.39404708e-04f, 2.68391352e-02f, -3.96913625e-02f,
  2.56191548e-02f, -7.06143230e-02f, 7.73522481e-02f, -4.23507951e-03f, -6.75684167e-03f, 4.98639718e-02f, 5.48646264e-02f, 8.04260150e-02f, 1.36726722e-01f, 7.08182156e-02f,
  6.35711662e-03f, -1.65308882e-02f, -1.67172514e-02f, 6.05813563e-02f, 3.46628875e-02f, -2.92382352e-02f, 4.16853912e-02f, -3.27343121e-02f, 2.01487467e-02f, -4.47015464e-02f,
  1.37726188e-01f, -1.58482358e-01f, 5.95813990e-02f, -1.95356514e-02f, 1.07057758e-01f, 3.79645452e-02f, 2.85523362e-04f, 4.67521958e-02f, -5.17998785e-02f, -1.54113099e-01f,
  -9.68613178e-02f, -9.93623734e-02f, 2.86807790e-02f, -6.22616708e-02f, 3.01449865e-01f, 2.93743815e-02f, 1.12651005e-01f, -1.53813744e-02f, 1.10335909e-01f, 1.18575260e-01f,
  1.33757994e-01f, 1.08241566e-01f, 1.60359487e-01f, 1.07563473e-01f, 1.10038444e-01f, -9.63822156e-02f, -1.62053593e-02f, 9.01845619e-02f, 2.49274094e-02f, -8.67550001e-02f,
  -1.85239036e-02f, -5.71529604e-02f, -1.44856656e-02f, 3.54354642e-02f, 1.23376571e-01f, 3.29499021e-02f, 5.79590686e-02f, -7.55372718e-02f, -4.50812876e-02f, -3.51514034e-02f,
  1.96249317e-02f, 7.85729960e-02f, -5.14427423e-02f, -3.21607059e-03f, -2.33131908e-02f, -4.99114618e-02f, -1.25255249e-02f, 8.07635672e-03f, -2.34608743e-02f, 2.07708590e-02f,
  2.20751632e-02f, 4.28261459e-02f, 7.27284774e-02f, -7.79069439e-02f, 9.63543430e-02f, -9.50537215e-05f, -1.00300826e-01f, -2.40657236e-02f, -2.13664956e-02f, -3.82583998e-02f,
  1.34050054e-02f, -2.36430001e-02f, -3.14501412e-02f, 1.85145233e-02f, -5.10131456e-02f, -3.18542123e-02f, 2.63818167e-03f, 1.23976693e-02f, 3.55455242e-02f, 7.58760646e-02f,
  5.16624451e-02f, -2.51112394e-02f, 5.79900369e-02f, 1.01640606e-02f, 4.82743606e-02f, -7.04385638e-02f, -3.95640172e-03f, -5.68541773e-02f, -1.85976159e-02f, 4.27786224e-02f,
  -3.71408463e-02f, -3.25965770e-02f, -4.03357036e-02f, -1.73775703e-02f, 9.91387814e-02f, 5.81018515e-02f, -2.88612004e-02f, -5.72904013e-03f, -6.85636923e-02f, 3.40140648e-02f,
  -2.32393108e-02f, -8.98031071e-02f, -4.25983928e-02f, -1.02947615e-01f, -7.41374493e-03f, 8.93221647e-02f, -5.64614078e-03f, 7.19135106e-02f, -5.15338369e-02f, 4.59862873e-02f,
  -5.09557575e-02f, -1.79828443e-02f, 3.02541815e-03f, 5.26706316e-02f, 3.30760889e-02f, 1.10471563e-03f, -1.19902026e-02f, -1.98334884e-02f, 1.41371088e-02f, -4.08276990e-02f,
  8.18031430e-02f, -5.88788316e-02f, 6.21398445e-03f, 1.23305048e-03f, 3.54146548e-02f, 3.59300002e-02f, -2.72688121e-02f, 7.10580964e-03f, 4.05533575e-02f, -3.46748680e-02f,
  8.96501541e-03f, -2.07218319e-01f, 1.85949355e-01f, 3.09427790e-02f, 2.70600557e-01f, -3.26723792e-02f, 1.94253940e-02f, 3.38499174e-02f, -1.31876603e-01f, -2.52256274e-01f,
  -1.59258451e-02f, 4.43322621e-02f, 5.30124307e-02f, -2.21267834e-01f, 3.66865769e-02f, -1.73612982e-01f, -1.36823758e-01f, -6.49928972e-02f, 6.23248965e-02f, -2.10909708e-03f,
  2.03416795e-02f, -1.69258833e-01f, 3.59344482e-02f, 1.06532061e-02f, 1.17474504e-01f, 1.44825190e-01f, 2.59136725e-02f, 9.34415534e-02f, 8.15710202e-02f, 6.51385337e-02f,
  -7.04427138e-02f, -6.45591542e-02f, -4.74312082e-02f, -2.67360769e-02f, 1.95640512e-02f, 6.33384511e-02f, -2.46492345e-02f, -3.71813662e-02f, -7.56621212e-02f, 1.76710952e-02f,
  -4.48286831e-02f, 9.92131159e-02f, -7.55373985e-02f, -2.27672458e-02f, 1.26601765e-02f, 5.45043200e-02f, 3.20093408e-02f, 5.89974783e-02f, 1.06141843e-01f, -2.45613325e-03f,
  -3.34411822e-02f, 2.69411448e-02f, -2.48887856e-02f, -3.18582123e-03f, 1.17291696e-01f, 2.06022654e-02f, 3.44819166e-02f, 1.09061748e-01f, 3.10059879e-02f, -1.72301903e-02f,
  1.90600252e-03f, 1.21888341e-02f, 7.78205171e-02f, 1.13650169e-02f, 5.22802630e-03f, -4.74603996e-02f, -9.44244210e-04f, -4.76115160e-02f, 4.37659360e-02f, -1.00124918e-03f,
  -3.47547196e-02f, 7.03828856e-02f, -5.45882173e-02f, -1.09064318e-02f, -2.29765959e-02f, -7.96666741e-02f, 1.84527691e-02f, 5.99596463e-02f, 6.49283007e-02f, -3.90920751e-02f,
  -5.63200153e-02f, -1.60837155e-02f, -3.08195874e-02f, 2.22279225e-02f, 7.01829745e-03f, 5.20901978e-02f, 4.80716117e-02f, 6.91981763e-02f, 2.63142940e-02f, 1.20611526e-02f,
  -9.45957899e-02f, -2.33477578e-01f, -1.58862174e-02f, -1.62946656e-02f, -1.26256078e-01f, -3.57100666e-02f, -8.61034542e-02f, 5.99831808e-03f, -4.05335873e-02f, -6.07643761e-02f,
  6.32605404e-02f, -2.83079203e-02f, -2.31401306e-02f, -4.68255840e-02f, -6.81163371e-02f, -4.54815514e-02f, 2.86020096e-02f, -4.51774523e-02f, -8.00766051e-02f, 1.44690070e-02f,
  5.00339840e-04f, -3.99776809e-02f, -6.01375550e-02f, 3.21574742e-03f, 2.07928754e-03f, 1.89670231e-02f, 3.70590687e-02f, -3.88021208e-02f, 3.65447067e-02f, -8.52603614e-02f,
  -1.46907404e-01f, -2.96744496e-01f, -9.44065601e-02f, 3.66968922e-02f, -5.43448317e-04f, 3.36961597e-01f, 2.36671656e-01f, -1.30610466e-01f, 1.17072284e-01f, -2.05242378e-03f,
  9.08855870e-02f, -8.90622754e-03f, 6.86229616e-02f, 1.65251553e-01f, 3.51400375e-01f, 2.03506827e-01f, 1.55532837e-01f, 1.27022386e-01f, 3.77480909e-02f, -8.13590512e-02f,
  6.16737641e-02f, 1.12037115e-01f, 1.03108332e-01f, -1.35476902e-01f, -8.73111635e-02f, -1.77109048e-01f, -1.26795039e-01f, -9.17216018e-02f, -1.03725672e-01f, 1.04505233e-01f,
  6.89713359e-02f, -1.70654669e-01f, -8.95798951e-03f, -1.04767010e-02f, -1.81471184e-02f, -4.38029245e-02f, 7.95780122e-03f, 6.88811541e-02f, 3.66566889e-02f, 3.21914325e-03f,
  -6.58552255e-03f, 1.92813668e-02f, 2.41420977e-02f, 4.18490320e-02f, 1.09240441e-02f, -3.22955362e-02f, 5.52430190e-02f, 2.02630479e-02f, 2.77457968e-03f, -5.70693351e-02f,
  -5.93141885e-03f, 2.15592608e-03f, 2.62465682e-02f, 3.62566262e-02f, 3.13173905e-02f, 3.54787037e-02f, 2.05661990e-02f, 3.20822233e-03f, -1.94052067e-02f, 1.79937594e-02f,
  -3.35150696e-02f, 1.10143451e-02f, 1.06065515e-02f, 5.39531093e-03f, -1.36537300e-02f, -1.18725151e-02f, 6.60431832e-02f, 3.79602658e-03f, -8.15631822e-02f, -1.16661768e-02f,
  6.77969947e-04f, -3.77479158e-02f, -3.28788906e-02f, 5.28924121e-03f, 4.13173484e-03f, -1.47321941e-02f, 6.26778649e-03f, -5.47293536e-02f, 2.69645322e-02f, -4.79026092e-03f,
  1.03249541e-03f, -8.22748616e-03f, 8.83024093e-03f, -4.18587588e-02f, 7.21749738e-02f, 3.70582013e-04f, 4.41880748e-02f, -3.01863831e-02f, 3.37584354e-02f, 2.00975966e-02f,
  -1.15891270e-01f, -3.15269023e-01f, 2.11912319e-02f, -5.40747354e-03f, 1.76064279e-02f, 2.14283150e-02f, 6.04593242e-03f, -7.11040571e-02f, 7.89704360e-03f, -1.72932707e-02f,
  2.09165998e-02f, 1.42938662e-02f, -4.97944690e-02f, -3.47921103e-02f, 1.67286433e-02f, 5.53853698e-02f, -1.94510221e-02f, -1.18704950e-02f, -2.65229791e-02f, -6.85464293e-02f,
  -1.37148798e-01f, -4.46374416e-02f, 3.06439642e-02f, 2.31871419e-02f, -4.01356034e-02f, -4.49525118e-02f, -5.62018193e-02f, 1.99875124e-02f, -7.70932715e-03f, -1.05401101e-02f,
  4.25217077e-02f, 2.65103638e-01f, 9.79187191e-02f, 2.72671491e-01f, -4.97118384e-02f, 1.46155015e-01f, 7.77225718e-02f, 1.56464577e-01f, 1.29044160e-01f, 1.26439571e-01f,
  -3.92958224e-02f, 9.80672315e-02f, 8.39492977e-02f, 1.68867603e-01f, -1.33325532e-01f, 1.04149953e-01f, 1.66702226e-01f, 5.67333438e-02f, 1.29019599e-02f, 9.08599496e-02f,
  5.60839400e-02f, 1.08956784e-01f, 3.23235840e-02f, -3.86625417e-02f, 1.55345485e-01f, 6.27371371e-02f, -6.69341907e-02f, -9.01645198e-02f, 8.83312225e-02f, -4.41750027e-02f,
  -1.23354889e-01f, 5.29497815e-03f, -3.86090688e-02f, -3.91974375e-02f, -9.89533216e-02f, -4.59533632e-02f, -3.45007665e-02f, -3.01258136e-02f, 2.98401527e-02f, 3.18702236e-02f,
  1.25368433e-02f, 2.85459068e-02f, -7.37123713e-02f, -2.81100031e-02f, 6.81846142e-02f, -1.82725713e-02f, 8.27142745e-02f, 3.27410325e-02f, 1.00410603e-01f, -3.18966135e-02f,
  6.95225447e-02f, 9.79010314e-02f, 1.49281800e-01f, 7.35089332e-02f, 6.58773864e-03f, 1.25707407e-02f, 4.35637683e-02f, -5.36943041e-02f, -4.84777242e-03f, 2.55208723e-02f,
  3.06692366e-02f, -1.17951985e-02f, 7.77760567e-03f, 1.20503930e-02f, 8.43096816e-04f, -1.65443309e-02f, 6.26876801e-02f, -1.99076105e-02f, -3.33188027e-02f, -5.45103587e-02f,
  4.74471152e-02f, 2.76104845e-02f, 6.20663986e-02f, 4.96291593e-02f, 1.26942685e-02f, 2.22840887e-02f, -7.14301504e-03f, 4.46738396e-03f, 6.66314140e-02f, -3.28289978e-02f,
  3.73187065e-02f, -2.12837267e-03f, -2.74216086e-02f, 3.46272402e-02f, -3.70251499e-02f, 2.39356048e-02f, 4.64749858e-02f, 6.43976405e-02f, -7.62494653e-02f, -2.41758358e-02f,
  4.73929867e-02f, -6.90549165e-02f, -1.69485603e-02f, 1.06799426e-02f, 5.00902934e-05f, -5.46370782e-02f, -4.38717790e-02f, -5.62033989e-02f, 1.72524955e-02f, -2.99174972e-02f,
  -3.64113562e-02f, 9.38790217e-02f, -4.91617210e-02f, 4.34026159e-02f, 3.61052155e-02f, -7.98825547e-02f, -6.54782802e-02f, 3.37400623e-02f, 6.02966510e-02f, -1.35492822e-02f,
  1.83393378e-02f, -4.23077308e-02f, -7.97757134e-02f, 2.13377923e-02f, -1.73790567e-02f, 2.74106693e-02f, -4.99380268e-02f, 1.13184996e-01f, 8.08164701e-02f, 3.56615894e-02f,
  3.53240073e-01f, -2.84676880e-01f, 3.51126194e-02f, -1.78784803e-02f, 1.35517940e-01f, -1.00474432e-01f, 4.62927334e-02f, 1.27207547e-01f, -1.84407290e-02f, -1.24314539e-02f,
  5.63101284e-02f, 5.33453301e-02f, 7.47123808e-02f, -2.12944951e-02f, 4.64959927e-02f, -1.44852847e-01f, -1.21163949e-01f, -1.30246980e-02f, -1.10773832e-01f, -1.35408472e-02f,
  -1.27979994e-01f, -1.59420878e-01f, 1.05853993e-02f, -8.78827870e-02f, 2.14003436e-02f, 7.41063580e-02f, 6.55948818e-02f, 1.09894043e-02f, 2.35981233e-02f, 1.13093249e-01f,
  1.91767067e-02f, 2.40072459e-01f, 1.09903768e-01f, 4.55431379e-02f, 5.21933362e-02f, 3.05050816e-02f, 3.55885178e-02f, 3.20619605e-02f, -3.07535450e-03f, -6.09070901e-03f,
  -7.30198771e-02f, 3.77875417e-02f, 5.92243820e-02f, 8.63953773e-03f, -7.78885782e-02f, 7.33808205e-02f, -3.91065255e-02f, -7.78990537e-02f, -1.38429292e-02f, 3.15360650e-02f,
  2.35865954e-02f, -4.98081520e-02f, -2.50211693e-02f, -8.30368772e-02f, -7.87951648e-02f, 2.85619628e-02f, 3.27642076e-02f, -2.72157509e-02f, 1.77023839e-02f, 2.19959691e-02f,
  -4.85764854e-02f, 6.04066551e-02f, -1.53441764e-02f, 2.02487577e-02f, -2.13541873e-02f, 2.94837989e-02f, -2.75535472e-02f, 1.02982506e-01f, -9.88985896e-02f, 5.73507957e-02f,
  -4.45350297e-02f, 6.18558824e-02f, 8.44739601e-02f, -8.12137648e-02f, 3.39001510e-03f, 9.26741660e-02f, -6.95944801e-02f, 4.58834581e-02f, -2.21859328e-02f, 4.51934116e-04f,
  -5.14528267e-02f, -3.81555632e-02f, 8.83820131e-02f, 2.42669452e-02f, 3.11574694e-02f, -1.50921810e-02f, 3.96851078e-02f, 4.39793058e-02f, 6.22472279e-02f, -1.53529840e-02f,
  -7.07770651e-03f, 6.40952140e-02f, -1.45670278e-02f, -1.27189634e-02f, -1.80996675e-02f, 2.22402122e-02f, -6.91526458e-02f, -4.07634489e-02f, -3.94603051e-02f, -1.68950353e-02f,
  4.36864560e-03f, -1.43277990e-02f, -5.72092086e-02f, -1.21062277e-02f, -8.48538429e-02f, -4.43915874e-02f, 3.08527891e-02f, -9.98239890e-02f, 1.36749074e-02f, 1.70398299e-02f,
  -1.47241456e-02f, 5.17456718e-02f, 2.85152849e-02f, 7.75344372e-02f, -4.78965193e-02f, -2.26309826e-03f, -2.25250851e-02f, -5.20277545e-02f, 2.51807664e-02f, -7.07664862e-02f,
  -2.14787528e-01f, -4.07722294e-02f, -8.45339373e-02f, -1.97464898e-01f, -1.72509506e-01f, -1.31053209e-01f, 6.82616383e-02f, -1.68621570e-01f, -2.31707945e-01f, 7.85430297e-02f,
  -9.93760154e-02f, 2.65542716e-02f, 7.29759037e-02f, -2.04258487e-02f, -4.57199775e-02f, 2.27657147e-02f, -1.72077715e-01f, 8.39862749e-02f, -7.44031668e-02f, -3.08326185e-02f,
  -1.17126793e-01f, -3.37657258e-02f, -1.09263085e-01f, -2.92812213e-02f, -2.76209228e-02f, -2.37717088e-02f, 5.92733175e-02f, 9.21988487e-02f, -2.75396202e-02f, 2.54944358e-02f,
  -4.76556681e-02f, -4.43476178e-02f, 8.38325638e-03f, 1.18278503e-01f, 2.90069897e-02f, -3.54639739e-02f, 8.31194818e-02f, 2.24694908e-02f, 7.93445259e-02f, -2.67388485e-02f,
  1.10006057e-01f, -2.78819650e-02f, -2.21721996e-02f, -3.54396403e-02f, 1.87304951e-02f, 6.34261593e-03f, -3.48094665e-02f, 3.43427695e-02f, -6.47185696e-03f, -1.66878868e-02f,
  -5.14185010e-03f, -1.05598522e-02f, 1.34762228e-02f, 7.63673410e-02f, 5.09811193e-02f, -2.73615886e-02f, -2.89517697e-02f, 2.76309252e-03f, -8.63005966e-02f, 1.15962243e-02f,
  5.16989045e-02f, 5.31020612e-02f, -5.43485060e-02f, -2.09860168e-02f, 2.54993401e-02f, -4.31363210e-02f, -7.41086677e-02f, 1.82073656e-02f, -4.15570149e-03f, 5.95406536e-03f,
  -2.22918522e-02f, -6.32536709e-02f, 3.16137262e-02f, -3.95148620e-02f, 1.65628027e-02f, 1.11887241e-02f, -4.59297076e-02f, -5.56018911e-02f, -5.28678894e-02f, -2.05632746e-02f,
  2.18784455e-02f, -3.40874307e-02f, 5.44575937e-02f, -4.02233787e-02f, 5.78994816e-03f, 2.42828578e-02f, -5.38988598e-02f, -8.01829994e-02f, -6.73309714e-03f, -4.28659096e-02f,
  -6.27782643e-02f, -9.27745402e-02f, 2.50587948e-02f, -7.40547618e-03f, 1.23066016e-01f, -1.11386385e-02f, 2.24432210e-03f, -8.83874819e-02f, -3.61521915e-02f, -3.91183980e-02f,
  1.13176247e-02f, -4.68076766e-02f, -1.40340924e-02f, 2.93973815e-02f, -2.71303952e-03f, -1.07226655e-01f, 1.69503167e-02f, -2.81438092e-03f, 5.97815514e-02f, 6.76283985e-02f,
  1.10351503e-01f, -6.49125082e-03f, 5.84469698e-02f, -7.07302764e-02f, 3.21471654e-02f, 8.73883367e-02f, 3.70491034e-04f, -9.96298250e-03f, -6.48880526e-02f, -3.16642337e-02f,
  -1.53315067e-01f, -2.38672704e-01f, -6.19625002e-02f, 8.24178085e-02f, 4.09198888e-02f, 6.87894970e-02f, 1.43972963e-01f, -6.13031685e-02f, -3.06637824e-01f, 4.28329892e-02f,
  7.30217844e-02f, -7.19939619e-02f, -7.37418933e-03f, -2.19213646e-02f, -2.30986010e-02f, -1.73103020e-01f, 1.39745697e-01f, 6.44023940e-02f, -1.38025925e-01f, 1.28039017e-01f,
  2.75254920e-02f, 7.44501725e-02f, 1.10691208e-02f, -1.49128407e-01f, 2.48848870e-02f, -3.82637628e-03f, 2.05139816e-01f, 6.38250783e-02f, 2.85894543e-01f, 6.52495101e-02f,
  -7.03713000e-02f, -1.44355789e-01f, 1.05782431e-02f, -7.70936608e-02f, -4.56384989e-03f, 6.14642836e-02f, 8.01427811e-02f, 7.32731894e-02f, -3.16869505e-02f, -2.93148141e-02f,
  -2.48420406e-02f, -1.02804210e-02f, -1.12722563e-02f, 2.50638667e-02f, -7.59068578e-02f, -1.39042102e-02f, -9.50949192e-02f, -3.02112065e-02f, -1.26460148e-02f, -7.16953278e-02f,
  -1.17500275e-01f, 2.38796603e-02f, 6.39301762e-02f, 8.31438527e-02f, -4.30969298e-02f, -6.82048723e-02f, -5.34498729e-02f, 9.49658081e-02f, 5.52229211e-02f, -1.67224761e-02f,
  -5.78486994e-02f, 5.11300005e-03f, 3.89266945e-02f, 1.71650853e-02f, -2.48777140e-02f, -1.84899904e-02f, -2.99086124e-02f, 1.02763399e-02f, 5.06378105e-03f, -4.55371626e-02f,
  6.27489313e-02f, 8.39750562e-03f, 1.00757889e-01f, 8.53115879e-03f, 4.24061455e-02f, 1.09491646e-02f, 8.88231471e-02f, 3.82900648e-02f, -3.81203033e-02f, -2.32831109e-02f,
  1.40594281e-02f, 2.93688234e-02f, -7.19200373e-02f, 2.75641698e-02f, 2.59928424e-02f, -2.00983100e-02f, -1.11921346e-02f, -1.74527639e-03f, 5.51911909e-03f, 4.36488874e-02f,
  8.65363423e-03f, 4.97529209e-02f, -2.75034234e-02f, 1.47629390e-02f, 1.51720853e-03f, 7.21360417e-03f, -3.99399661e-02f, -3.02266143e-02f, -6.66415226e-03f, 7.68146850e-03f,
  8.17355067e-02f, 5.53487353e-02f, 3.26935276e-02f, 4.35772799e-02f, -2.27662432e-03f, -4.15416844e-02f, 3.18912901e-02f, 7.19652772e-02f, 1.37023345e-01f, -8.97468161e-03f,
  -9.55272652e-03f, -3.85987945e-02f, -7.30459690e-02f, -4.95051965e-02f, 4.87519614e-02f, 6.41509444e-02f, -1.23786954e-02f, -6.28865659e-02f, 2.88326051e-02f, -2.81815487e-03f,
  -3.39058459e-01f, -1.55305732e-02f, -6.20509125e-02f, -3.38165909e-02f, 2.75127683e-02f, -1.34557113e-01f, -2.83316851e-01f, 1.00225195e-01f, 6.89792447e-03f, -1.00948617e-01f,
  5.18815592e-02f, -9.17117447e-02f, 4.38725390e-02f, 1.29269823e-01f, 1.60507634e-01f, 1.54677168e-01f, -5.36201596e-02f, -7.24572763e-02f, 1.06313147e-01f, -1.02465175e-01f,
  3.30961458e-02f, 9.42000896e-02f, 1.07831642e-01f, 1.08764328e-01f, -1.18803270e-01f, -4.27622944e-02f, 9.86161008e-02f, 1.74810656e-03f, 2.06957534e-02f, 3.65574956e-02f,
  2.04832330e-02f, 7.54523277e-02f, 6.94220280e-03f, -1.63668091e-03f, -7.99927488e-02f, -1.00135021e-01f, -1.08095355e-01f, 3.84480171e-02f, 3.91289108e-02f, 3.13995518e-02f,
  -4.46196683e-02f, 7.81742781e-02f, 1.76114906e-02f, 1.44753801e-02f, -1.04967065e-01f, 3.14352140e-02f, 1.22530619e-02f, -4.60026972e-02f, 4.17444622e-03f, 1.33557201e-04f,
  -1.99738471e-03f, -3.75335738e-02f, -8.74233246e-02f, 2.55942661e-02f, 2.03301832e-02f, 3.48102413e-02f, -4.07430381e-02f, -8.33850633e-03f, -7.40394592e-02f, -1.76873486e-02f,
  -4.99083251e-02f, -3.74966674e-02f, -3.05532366e-02f, 3.37657221e-02f, 9.29152146e-02f, -3.60125070e-03f, -1.99648198e-02f, 9.54708830e-03f, -4.78872508e-02f, 2.27886476e-02f,
  2.02825144e-02f, -1.05066271e-02f, 2.12404113e-02f, -7.35507086e-02f, -5.73485419e-02f, -8.73866230e-02f, -3.58368643e-02f, -1.94823761e-02f, -9.03059617e-02f, 5.56036346e-02f,
  4.32195254e-02f, 7.58146262e-03f, -1.37808723e-02f, -5.48571870e-02f, 1.38079179e-02f, -4.55597974e-03f, 5.09742014e-02f, -3.39294709e-02f, 2.91750897e-02f, -4.66059037e-02f,
  -2.92669702e-02f, 1.01113535e-01f, 5.34731522e-02f, 3.04964185e-02f, -9.16293729e-03f, -4.55695912e-02f, -2.91850138e-02f, 3.30115552e-03f, 2.81785280e-02f, -4.40837517e-02f,
  -3.54904658e-03f, -5.24282902e-02f, -2.63879877e-02f, 1.37973204e-02f, 1.24623412e-02f, 3.10825352e-02f, -1.39385089e-03f, 2.10272451e-03f, -5.78069612e-02f, -1.91083364e-02f,
  -7.03618675e-02f, -4.09021135e-03f, -6.39631692e-03f, -8.91847070e-03f, -3.02088689e-02f, -5.71008958e-02f, -3.58447023e-02f, 1.28082009e-02f, 2.31342558e-02f, 7.43198209e-03f,
  1.77619562e-01f, -9.97368321e-02f, 1.52065441e-01f, 1.47222644e-02f, 1.36951029e-01f, 2.81569585e-02f, 1.06681958e-01f, 2.52806228e-02f, -1.59593727e-02f, -1.01665288e-01f,
  5.04042469e-02f, -8.22652970e-03f, -7.84322340e-03f, -3.39918770e-02f, 2.75322080e-01f, -1.11957267e-01f, 8.92810598e-02f, -2.88570039e-02f, -3.56854051e-02f, 1.64132193e-01f,
  5.36600174e-03f, 3.91276814e-02f, 1.36537594e-03f, -2.54516443e-03f, 1.08985655e-01f, -3.85423526e-02f, 1.26561493e-01f, -1.37676736e-02f, 1.12121245e-02f, 8.50276649e-02f,
  1.73733421e-02f, 2.23220000e-03f, 3.30552496e-02f, -4.91494089e-02f, 1.60554662e-01f, 1.99706499e-02f, 4.65016067e-02f, -1.36399092e-02f, 6.52516726e-03f, 6.23225681e-02f,
  -4.75893402e-03f, -4.54468839e-02f, -2.26141140e-02f, 1.57981087e-02f, -2.86266655e-02f, -8.04998130e-02f, -3.12742107e-02f, 2.90123001e-02f, -1.15197356e-04f, -4.23540659e-02f,
  -6.52556345e-02f, -5.74402772e-02f, -3.49573679e-02f, -8.13852623e-03f, 5.15631633e-03f, -5.45428768e-02f, -6.14476681e-04f, 1.17731262e-02f, 7.16274753e-02f, 7.76926172e-04f,
  -9.98191442e-03f, 5.82141168e-02f, 1.53341135e-02f, 4.59006503e-02f, -5.15804067e-03f, 4.13670987e-02f, -2.72666533e-02f, -2.66725533e-02f, -7.13042635e-03f, 2.98699667e-03f,
  5.65029047e-02f, 1.14400536e-02f, -2.47706678e-02f, -5.82403503e-02f, -4.74456809e-02f, -2.10350696e-02f, -2.22736076e-02f, 1.89646743e-02f, -3.86338821e-03f, 3.64266708e-02f,
  -1.99257955e-02f, 1.41784351e-03f, 2.66117305e-02f, -2.77396310e-02f, 5.17042279e-02f, -3.77099998e-02f, -8.97077173e-02f, -8.14630613e-02f, 2.27317642e-02f, 3.20204813e-03f,
  1.15116365e-01f, 1.85429782e-01f, -3.80557589e-02f, -2.60761231e-02f, -1.71843860e-02f, 1.69767719e-02f, 1.96057390e-02f, 6.91930503e-02f, 6.08434491e-02f, 4.23757471e-02f,
  1.89312324e-02f, 7.48485141e-03f, 7.49360770e-02f, -5.08048609e-02f, -2.26639193e-02f, 4.66072895e-02f, 5.00078164e-02f, -2.30921451e-02f, 6.13916740e-02f, 3.49928625e-02f,
  7.13787787e-03f, 4.43137996e-02f, -5.98209389e-02f, 2.11254396e-02f, -2.61517018e-02f, 8.65108054e-03f, 6.74735308e-02f, 3.28704230e-02f, -1.18350831e-03f, 6.76107407e-02f,
  1.95579365e-01f, -9.67942625e-02f, -2.19420761e-01f, 1.58786714e-01f, -1.57678537e-02f, -8.62002820e-02f, -6.64733276e-02f, 5.63600138e-02f, 1.21123968e-02f, 1.00002415e-01f,
  2.50909645e-02f, 1.07948534e-01f, -5.39181754e-02f, -9.29384027e-03f, 8.92669335e-02f, -8.04159641e-02f, 1.49351314e-01f, 2.88680624e-02f, -1.68357100e-02f, 4.54257429e-02f,
  -1.17760827e-03f, 7.64060542e-02f, -1.17706314e-01f, -1.04790339e-02f, -3.90268900e-02f, -6.21082149e-02f, 1.29730076e-01f, -1.09732680e-01f, 7.46739954e-02f, -7.56264180e-02f,
  2.19411892e-03f, -5.16598672e-03f, 1.21839046e-02f, -7.12550879e-02f, -6.31567463e-02f, 2.34486703e-02f, -3.69604975e-02f, -5.20645902e-02f, -3.14354412e-02f, 3.71337384e-02f,
  -1.93240009e-02f, -2.25053839e-02f, 2.12403405e-02f, 1.95395071e-02f, -3.32310274e-02f, 6.76911026e-02f, -2.52554473e-02f, 3.95876169e-02f, -3.25334184e-02f, 2.73111314e-02f,
  -2.61511537e-04f, 4.60160617e-03f, 2.74676885e-02f, 6.21248893e-02f, 1.67304520e-02f, -2.31655110e-02f, 2.27734298e-02f, -3.89915667e-02f, 6.56960607e-02f, 6.62158728e-02f,
  -1.25911804e-02f, -1.95914600e-02f, -2.70645842e-02f, -2.86397245e-02f, 4.77155391e-03f, -1.49140665e-02f, -1.68564729e-03f, 3.41750272e-02f, 6.15942338e-03f, 4.14836407e-02f,
  -2.50578485e-02f, -2.07779207e-03f, 4.77894358e-02f, 2.60091722e-02f, -3.59203592e-02f, 4.00217995e-03f, -7.70396506e-03f, 1.37951663e-02f, -2.16553900e-02f, -5.12289889e-02f,
  2.57475092e-03f, -1.79107729e-02f, 2.86447480e-02f, -1.63832977e-02f, -6.20811172e-02f, -4.69475500e-02f, 3.41742113e-02f, -3.46463956e-02f, -4.76063639e-02f, 2.55426904e-03f,
  -1.41726783e-03f, 7.87932947e-02f, -7.15093538e-02f, 7.84925893e-02f, -3.44385579e-02f, 6.04699440e-02f, -1.33547569e-02f, 7.03509292e-03f, -1.91146228e-02f, 5.66975251e-02f,
  6.92237243e-02f, 7.63634518e-02f, 5.66921048e-02f, 3.55596431e-02f, 6.07566151e-04f, -1.23380022e-02f, -4.22342075e-03f, -1.62599348e-02f, 1.49385175e-02f, 1.04443124e-02f,
  1.59207098e-02f, 5.97399957e-02f, 4.20366265e-02f, 1.17053032e-01f, 3.76474224e-02f, -2.30999868e-02f, 5.11611477e-02f, -2.96149985e-03f, 3.64244282e-02f, -1.84099581e-02f,
  3.77530903e-01f, -3.03968132e-01f, -2.18146041e-01f, 1.14376135e-02f, 1.36167854e-01f, 4.42302451e-02f, 9.87027511e-02f, -2.36631900e-01f, -9.53255668e-02f, -1.59381360e-01f,
  9.98425484e-02f, 7.25504756e-02f, -1.99576858e-02f, 2.30323579e-02f, 2.30873182e-01f, -1.20931035e-02f, -1.05567789e-02f, 8.31627697e-02f, -1.29371613e-01f, 2.44290829e-02f,
  7.24850371e-02f, 6.20916374e-02f, -3.26919071e-02f, -1.70220912e-01f, -6.10292628e-02f, -6.53777793e-02f, 1.15137495e-01f, -4.65209968e-03f, -8.02155025e-03f, -4.17424515e-02f,
  -4.70336899e-02f, -6.61936626e-02f, -1.30468411e-02f, -1.31017528e-02f, -5.99134155e-02f, 6.30865395e-02f, 1.30772172e-02f, 5.17464392e-02f, 5.37368357e-02f, 3.35275419e-02f,
  -1.91918630e-02f, 1.56104984e-02f, -1.37917409e-02f, 3.51799764e-02f, -1.31049277e-02f, -4.42468524e-02f, -2.14290954e-02f, -3.99488620e-02f, -5.79697639e-02f, -2.99079344e-02f,
  4.17154990e-02f, -3.35089378e-02f, -4.99422997e-02f, -5.46559505e-02f, 1.07632661e-02f, -6.97646961e-02f, 5.03811203e-02f, 3.54517139e-02f, 6.73147244e-03f, 1.88211128e-02f,
  -1.82534289e-02f, -5.02295308e-02f, -4.51351181e-02f, -4.59073037e-02f, -2.03388464e-02f, 8.38077720e-03f, -2.06224043e-02f, -3.08872387e-02f, 8.61297175e-02f, -1.67737268e-02f,
  1.88576095e-02f, -5.66536048e-03f, -6.50414899e-02f, 8.67724493e-02f, 1.90678667e-02f, -1.05168251e-02f, 8.62775221e-02f, 1.39893536e-02f, 4.88421693e-02f, 1.36785824e-02f,
  -1.45354290e-02f, 1.97818819e-02f, -9.22324602e-03f, -1.71658136e-02f, -5.60682006e-02f, 2.47114748e-02f, -4.11581919e-02f, -4.53379266e-02f, 1.24430528e-03f, -4.70489562e-02f,
  -4.38279100e-02f, 2.68941978e-03f, -8.03911462e-02f, 8.09740052e-02f, -4.63977605e-02f, -1.26382886e-02f, 9.29444563e-03f, -6.20107614e-02f, 3.74221690e-02f, 1.24125555e-02f,
  6.53583705e-02f, 2.20890455e-02f, -4.70344052e-02f, 5.03385672e-03f, -1.04591986e-02f, -1.59719009e-02f, 1.03525436e-02f, 5.42499870e-02f, 1.57235004e-03f, -4.67697866e-02f,
  4.25034054e-02f, 1.00068778e-01f, 2.44971197e-02f, -4.04412486e-02f, 9.11083445e-03f, 6.39673173e-02f, 3.98433879e-02f, -1.63190644e-02f, -1.50822792e-02f, 2.54438911e-02f,
  2.05336139e-01f, -2.37951756e-01f, 9.90318954e-02f, 4.86481674e-02f, -8.28049034e-02f, -9.53702554e-02f, -6.63076937e-02f, -3.17544006e-02f, -9.51084569e-02f, -1.87824275e-02f,
  7.73122311e-02f, -6.20587058e-02f, -4.90371175e-02f, 3.78179960e-02f, 4.45066839e-02f, -4.85555641e-02f, 4.67858501e-02f, 8.59684646e-02f, -3.81703004e-02f, 8.66958499e-02f,
  1.09496095e-05f, 1.51054719e-02f, 8.39665607e-02f, -2.44616177e-02f, 1.29937634e-01f, 3.83925326e-02f, -2.39920017e-04f, 4.44110036e-02f, 2.05306541e-02f, 4.45826957e-03f,
  9.32305530e-02f, 1.79622620e-01f, 1.67467132e-01f, 1.07965760e-01f, 4.31225300e-02f, -2.02208776e-02f, 4.62268852e-02f, -1.31346341e-02f, 6.21819757e-02f, -5.72375804e-02f,
  2.23307423e-02f, -1.32963164e-02f, -2.88548321e-02f, -1.05618099e-02f, 2.51133777e-02f, -2.56510358e-02f, -3.44780460e-02f, -1.36143733e-02f, 3.36044803e-02f, 8.47038906e-03f,
  -2.71966103e-02f, 2.43733637e-02f, 8.07337388e-02f, -1.10698491e-02f, 3.57278287e-02f, 9.34485346e-02f, -1.94746871e-02f, -2.06316132e-02f, -2.47154739e-02f, -1.62997879e-02f,
  -4.57765460e-02f, 1.63483433e-02f, 1.07119214e-02f, 2.36665234e-02f, -1.85399726e-02f, 3.93673182e-02f, 6.69512004e-02f, 4.37800549e-02f, -7.79256523e-02f, 2.65652663e-03f,
  -1.07625790e-01f, -3.68775129e-02f, 1.83101110e-02f, -3.37780616e-03f, -1.00283306e-02f, -1.66744720e-02f, -2.96099635e-04f, 2.58598346e-02f, -6.70342073e-02f, -1.93483033e-03f,
  5.25632575e-02f, 3.68700773e-02f, -7.56979063e-02f, -3.90057899e-02f, 4.27523442e-03f, -7.36192847e-03f, 5.04097082e-02f, 2.58615557e-02f, 2.33339276e-02f, 2.20612455e-02f,
  2.00949714e-01f, 1.67229816e-01f, 4.21101972e-02f, 4.23086062e-02f, 5.77456243e-02f, 1.43795880e-02f, 3.41506824e-02f, 1.11463284e-02f, 3.23891677e-02f, 6.06795922e-02f,
  3.06209791e-02f, 1.48537429e-02f, 1.71905831e-02f, 5.52143492e-02f, 6.13868795e-02f, -1.64851192e-02f, -4.45530098e-03f, 5.34134880e-02f, 2.31458358e-02f, 1.52536910e-02f,
  1.01110689e-01f, 3.27686258e-02f, 9.98792355e-04f, -5.02425665e-03f, -3.52175348e-02f, 2.83770915e-02f, -3.44490446e-02f, 3.85365151e-02f, -4.48866747e-02f, -3.10962740e-02f,
  -3.05016380e-04f, -9.47492197e-02f, -3.67794633e-01f, -1.99209064e-01f, 6.21899702e-02f, -2.07109451e-01f, -2.54606307e-01f, 2.29784716e-02f, -6.31458238e-02f, 1.31346554e-01f,
  3.81416306e-02f, -1.86557859e-01f, -5.04423305e-02f, -1.32878914e-01f, -2.57790238e-01f, -1.46959886e-01f, -3.67484204e-02f, -5.67641445e-02f, -3.23666483e-02f, 4.23354544e-02f,
  -3.22808586e-02f, 6.38310760e-02f, -1.90722093e-01f, 1.15175582e-01f, -6.30360171e-02f, -6.50560260e-02f, 7.07329437e-02f, -1.65545538e-01f, 4.42563556e-02f, -1.07788615e-01f,
  5.63789979e-02f, -2.85065686e-03f, -9.99472663e-03f, -5.46954535e-02f, 1.71307735e-02f, -5.22183701e-02f, 3.11818980e-02f, -7.07835406e-02f, 1.89040210e-02f, 2.25242805e-02f,
  -1.21835303e-02f, -5.69446385e-03f, 3.77936326e-02f, -2.56954189e-02f, 2.43703723e-02f, -7.13906735e-02f, -4.35688682e-02f, -1.29410233e-02f, -3.17901298e-02f, -1.11705117e-01f,
  -6.27125129e-02f, 3.57620493e-02f, -1.18979383e-02f, 4.15245928e-02f, -5.18552735e-02f, -8.84315521e-02f, -4.52682748e-02f, 3.43108773e-02f, -3.18266265e-02f, 6.86117709e-02f,
  4.46945569e-03f, -8.90608353e-04f, 2.04015635e-02f, -3.85295879e-03f, 4.47293222e-02f, 5.74255176e-02f, 2.50914954e-02f, 4.02831249e-02f, -2.97836661e-02f, 3.03013828e-02f,
  6.22051433e-02f, -2.84380559e-02f, 6.01816699e-02f, 4.15785675e-04f, -2.45191045e-02f, 3.30368020e-02f, -3.18474360e-02f, 3.23929973e-02f, 7.29928762e-02f, -2.25665532e-02f,
  -4.31499369e-02f, 3.32308672e-02f, -1.15976324e-02f, 2.08143331e-02f, -2.07615830e-02f, -1.77650303e-02f, 3.19060124e-02f, 1.68022905e-02f, -1.77041851e-02f, 5.03943600e-02f,
  1.43101454e-01f, 1.58728868e-01f, 5.36786057e-02f, 8.77898261e-02f, 3.47750708e-02f, 4.56167161e-02f, -1.21607125e-01f, -8.79790820e-03f, 3.01331170e-02f, -1.03859929e-03f,
  2.82137971e-02f, 2.34506372e-02f, 2.50315592e-02f, 1.96599634e-03f, 4.12591137e-02f, -1.29996368e-03f, -8.86722095e-03f, 6.84830770e-02f, 8.50934070e-03f, 7.40467235e-02f,
  2.41093785e-02f, -1.11230528e-02f, -5.61514124e-02f, -2.53966004e-02f, 1.62183568e-02f, 3.72504480e-02f, -3.42029263e-03f, -7.39004239e-02f, 8.69170576e-02f, -1.39135830e-02f,
  8.82015899e-02f, 6.69353306e-02f, -1.62134573e-01f, 2.16857456e-02f, 1.44011027e-03f, -3.46820801e-01f, -2.25401238e-01f, -7.74997100e-02f, 1.60732474e-02f, 1.22699894e-01f,
  -9.19547305e-03f, 3.42083946e-02f, 7.44588971e-02f, -8.33340287e-02f, -3.33050996e-01f, -1.36517733e-01f, -2.16715023e-01f, -2.16685832e-02f, -7.91242644e-02f, -3.18781435e-02f,
  -1.22382663e-01f, -2.50531584e-02f, -2.23670602e-01f, 2.09155455e-02f, -8.54176506e-02f, 7.78658390e-02f, 1.46020651e-01f, 2.24634167e-02f, -4.88278829e-02f, 7.69393072e-02f,
  -8.01409185e-02f, 7.47394189e-02f, -4.79934067e-02f, 1.35903768e-02f, -4.43726927e-02f, 1.61973517e-02f, 1.22720217e-02f, 4.15434688e-02f, 4.09960337e-02f, -5.71159609e-02f,
  2.72600837e-02f, 4.21257243e-02f, 1.21758748e-02f, 3.16932835e-02f, -5.37002236e-02f, 5.58703206e-03f, -1.13859763e-02f, 1.08825326e-01f, -2.01422907e-02f, -5.90310805e-02f,
  -7.68503547e-02f, -6.21236116e-02f, -6.63921162e-02f, -1.04857855e-01f, -5.61452471e-02f, 6.76801801e-02f, -7.10873157e-02f, -6.32497892e-02f, -3.31348069e-02f, -8.21693242e-02f,
  -6.85730949e-02f, -1.59543511e-02f, 1.63643081e-02f, 3.23113576e-02f, -4.65230234e-02f, 4.05834168e-02f, -2.17604600e-02f, 3.28021049e-02f, -4.89499159e-02f, -3.73061118e-03f,
  -7.41099641e-02f, 5.41634373e-02f, -1.39534036e-02f, -7.06081688e-02f, 2.49582455e-02f, 6.31584600e-02f, -3.18222009e-02f, 3.79847661e-02f, -8.83979425e-02f, -2.81714685e-02f,
  4.18854654e-02f, -7.58699775e-02f, -6.39335252e-03f, 1.21098468e-02f, 3.23200487e-02f, -2.16506515e-02f, -4.95829098e-02f, -2.64448952e-02f, 6.06557541e-02f, 1.90181134e-03f,
  6.98769987e-02f, 1.28048221e-02f, 1.04707619e-02f, -3.25160697e-02f, 1.80005878e-02f, -8.87775198e-02f, -3.82602029e-02f, -1.06566669e-02f, -2.42936052e-03f, 2.66185943e-02f,
  4.50837165e-02f, 1.80363115e-02f, -2.04368904e-02f, -1.92024074e-02f, -2.64411904e-02f, 1.56313255e-02f, 3.86474393e-02f, -3.39525193e-02f, -6.70877472e-02f, 2.22990736e-02f,
  2.18786616e-02f, 7.80483782e-02f, -5.42981923e-02f, -2.56243031e-02f, 8.86550080e-03f, 2.10792944e-02f, 3.51952593e-04f, 4.73144986e-02f, -5.14419284e-03f, -1.15257120e-02f,
  -2.09808618e-01f, 2.25043800e-02f, 9.67255831e-02f, -1.93230826e-02f, 2.24594414e-01f, 3.49890321e-01f, 2.74898261e-01f, 9.47692841e-02f, 1.71862230e-01f, -7.08679259e-02f,
  3.10739689e-02f, -1.88186869e-01f, 1.47930458e-01f, 2.37586536e-02f, -3.03049833e-02f, 1.84773594e-01f, 8.93033221e-02f, 3.67654376e-02f, 1.13201581e-01f, -5.83600737e-02f,
  -1.05127264e-02f, -4.92430404e-02f, 7.79962679e-03f, 3.77117097e-02f, -5.22202440e-02f, -1.00487702e-01f, -1.79196894e-01f, 4.19329256e-02f, -4.65462729e-02f, 9.88804698e-02f,
  3.47776376e-02f, 1.15025919e-02f, -9.13095921e-02f, -6.64784908e-02f, -4.94230948e-02f, 6.54440082e-04f, 6.08721785e-02f, -2.07190588e-02f, -7.86957145e-03f, 1.98472366e-02f,
  -4.47569229e-02f, 9.59360134e-03f, -4.16787975e-02f, -2.28152107e-02f, 1.10121239e-02f, -7.38379285e-02f, 3.85038219e-02f, 4.06893864e-02f, 4.59682569e-02f, 1.04516959e-02f,
  -4.83386479e-02f, 3.29992585e-02f, -8.62585567e-03f, 9.54787806e-03f, 9.69247660e-04f, 2.96998248e-02f, 4.40750383e-02f, 5.55445179e-02f, 5.60163595e-02f, 3.46415080e-02f,
  -1.47586716e-02f, 1.06920764e-01f, 3.64692300e-03f, -4.73876595e-02f, -2.03601364e-03f, 2.29809619e-02f, -1.45992376e-02f, -2.97465455e-02f, -3.06181535e-02f, 2.81122699e-02f,
  -2.65741348e-02f, -1.09888492e-02f, 5.06847631e-03f, 3.81299667e-02f, -7.05462322e-02f, -3.58704664e-02f, -4.55736332e-02f, 4.06185016e-02f, -4.31286320e-02f, -5.46232685e-02f,
  1.78877246e-02f, 2.16220673e-02f, -2.15836670e-02f, 9.98574030e-03f, 1.89941302e-02f, -9.60404892e-03f, -5.94063736e-02f, 1.31361922e-02f, 6.03420325e-02f, -2.41893567e-02f,
  9.89300981e-02f, 4.52629700e-02f, 3.38099934e-02f, 6.67427182e-02f, -2.93030590e-02f, 6.69879187e-03f, 3.75371729e-03f, -6.36091903e-02f, 9.57982242e-02f, 3.17777917e-02f,
  -3.41359526e-02f, -1.01595316e-02f, 1.94549728e-02f, -9.39100608e-03f, 2.63802800e-02f, 5.42163737e-02f, 4.81162556e-02f, 5.91309741e-02f, -1.08569838e-01f, 4.80799004e-03f,
  -3.30590247e-03f, -2.56514288e-02f, -3.57550047e-02f, -7.94102997e-02f, 2.11812388e-02f, 1.46651836e-02f, -9.12615955e-02f, 3.75082158e-02f, -2.41416972e-02f, 7.59202056e-03f,
  -2.66093522e-01f, 1.15994543e-01f, 3.82469967e-02f, -1.80322543e-01f, -1.25775158e-01f, -7.15520754e-02f, -2.85852514e-02f, -3.34253870e-02f, 1.91111267e-02f, 9.33821127e-02f,
  -1.37655199e-01f, -4.54811417e-02f, 2.40705796e-02f, -1.16685644e-01f, -2.06324428e-01f, 1.76586513e-03f, -1.05025366e-01f, 4.14482430e-02f, 6.83484524e-02f, -5.64443022e-02f,
  -8.97775814e-02f, -1.42139122e-01f, -1.00362360e-01f, 3.35672200e-02f, 4.80116569e-02f, 1.80119481e-02f, 3.26835997e-02f, 5.32591715e-02f, -6.16577230e-02f, 2.46099639e-03f,
  -2.56277081e-02f, 1.66706499e-02f, -3.77642438e-02f, -4.11768556e-02f, 5.75829931e-02f, 8.97760466e-02f, 6.00712374e-02f, -3.41962539e-02f, -7.16650262e-02f, -2.15681661e-02f,
  -2.48592049e-02f, -1.44916284e-03f, -4.08049934e-02f, 4.83576879e-02f, 5.15411347e-02f, -1.89842936e-02f, -5.21450303e-02f, 5.76160140e-02f, 5.02534732e-02f, -1.06514208e-02f,
  -7.96011090e-03f, 2.23726723e-02f, 4.20423709e-02f, 1.60595644e-02f, -1.11718308e-02f, -6.14255443e-02f, 5.35532720e-02f, -1.35204950e-02f, 5.85432835e-02f, 1.60338618e-02f,
  -3.53595726e-02f, 2.33577229e-02f, -1.50897922e-02f, -7.67508596e-02f, -6.99348226e-02f, 1.75339207e-02f, -2.69067790e-02f, 7.19967950e-03f, 2.47699432e-02f, 7.66315311e-02f,
  -3.53361964e-02f, -6.19742498e-02f, 1.89511273e-02f, -1.52764395e-02f, -7.36310706e-02f, 4.31591980e-02f, 6.42155409e-02f, 2.20043994e-02f, -7.19886972e-03f, 2.57742647e-02f,
  4.93518710e-02f, -2.52397899e-02f, 5.51418588e-03f, 2.60173418e-02f, -7.41088018e-02f, -3.67746712e-03f, -3.35194133e-02f, -3.11951339e-02f, 2.30792221e-02f, 5.38192177e-03f,
  -2.26439610e-02f, 2.16166843e-02f, 1.88043304e-02f, 3.46529111e-02f, 4.39558029e-02f, 9.76895541e-03f, 5.67316674e-02f, -2.72100437e-02f, 6.16458990e-03f, -4.17079739e-02f,
  -2.99363174e-02f, 4.77398932e-02f, 8.16921964e-02f, -7.65495608e-03f, -1.83073524e-02f, 7.81848207e-02f, -2.71089077e-02f, 5.91508970e-02f, 2.97127292e-02f, -4.67985235e-02f,
  -1.36296032e-02f, 3.84755954e-02f, 8.28584060e-02f, 5.74177690e-02f, -8.63469765e-02f, 4.42761220e-02f, 1.27838152e-02f, 5.85274957e-02f, -6.16628816e-03f, -8.69598426e-03f,
  2.35037431e-01f, 7.07514957e-02f, 2.59787798e-01f, 2.11388588e-01f, -4.18492220e-02f, -9.94892716e-02f, 4.08903994e-02f, 2.09977273e-02f, 7.68971723e-03f, -1.32987857e-01f,
  -1.21241555e-01f, 1.04929835e-01f, -1.85146764e-01f, -5.32410443e-02f, 2.61512306e-02f, -1.64970204e-01f, -3.51666324e-02f, 5.15414700e-02f, -3.99675779e-02f, 7.55844787e-02f,
  7.60998875e-02f, -1.32818729e-01f, 3.77175435e-02f, -9.86958668e-02f, 7.68912211e-02f, 8.23146775e-02f, 1.22754527e-02f, -4.16652039e-02f, 7.62134641e-02f, 5.55088511e-03f,
  -1.22819087e-02f, -1.45370252e-02f, 1.25978246e-01f, -1.93341151e-02f, -8.23620427e-03f, 9.96981375e-03f, 8.49384218e-02f, -4.90526371e-02f, 6.61082491e-02f, 5.63830882e-03f,
  2.47431695e-02f, -3.99189629e-02f, 6.98350072e-02f, -4.93582152e-02f, 2.00637467e-02f, 4.81405519e-02f, -7.41701946e-03f, 3.51911373e-02f, 4.94332537e-02f, 2.36982736e-03f,
  3.31292786e-02f, 2.25477722e-02f, -3.38858436e-03f, 3.19718756e-02f, 1.77288696e-03f, 3.11728311e-03f, 4.11177911e-02f, -1.74844582e-02f, 2.86403000e-02f, 3.01788636e-02f,
  1.30513292e-02f, 1.64564196e-02f, -1.48264924e-02f, -8.99638422e-03f, 2.12457534e-02f, 2.36925874e-02f, 1.04851779e-02f, -6.11214107e-03f, 8.66746381e-02f, -7.89115876e-02f,
  8.69070925e-03f, 7.34850243e-02f, -4.64799674e-03f, 3.65966968e-02f, 1.49789928e-02f, 3.47442329e-02f, 3.55063006e-02f, -3.55840921e-02f, 7.69624636e-02f, -1.24338595e-02f,
  -1.91573445e-02f, 4.95821564e-03f, 9.15357005e-03f, -4.98531386e-02f, -5.44244871e-02f, 2.36217137e-02f, -4.54216748e-02f, 1.95247177e-02f, 8.40072036e-02f, 4.05025110e-03f,
  -5.81551641e-02f, 2.03068797e-02f, -1.76002234e-02f, 4.36782949e-02f, -2.81599909e-02f, -4.10320889e-03f, 3.88497091e-03f, 2.30283849e-02f, 1.85010228e-02f, -3.08350567e-02f,
  1.11220311e-02f, 4.29370739e-02f, -4.75611649e-02f, 4.65288311e-02f, 1.99453235e-02f, 1.21591575e-02f, 3.87907401e-02f, 4.41815741e-02f, 1.28407003e-02f, 2.73881350e-02f,
  -6.80018887e-02f, -4.64840652e-03f, 1.80018321e-02f, -2.41921172e-02f, -5.81763946e-02f, -2.29846258e-02f, 4.41514142e-02f, 3.57345566e-02f, -6.07763417e-02f, 7.04979012e-03f,
  -1.32708803e-01f, 1.60509780e-01f, 5.27902246e-02f, 1.97439641e-01f, 2.83046812e-02f, 2.70069271e-01f, 2.73451030e-01f, 8.40329304e-02f, 9.97016951e-02f, 3.92141528e-02f,
  1.92708243e-02f, 5.20202555e-02f, 9.43682250e-03f, 1.80242643e-01f, 5.94369881e-02f, 7.29003642e-03f, 8.38266164e-02f, 7.32558668e-02f, -8.77369791e-02f, 4.68727946e-02f,
  -7.43201226e-02f, 5.04882969e-02f, 1.00086100e-01f, -7.35983485e-03f, 8.48294348e-02f, -7.15679377e-02f, -1.26464069e-01f, 2.04753187e-02f, -2.09610239e-02f, 2.49965061e-02f,
  9.59375054e-02f, 3.83898243e-02f, 4.82559018e-02f, 3.86944786e-02f, 8.70465264e-02f, 5.94492964e-02f, 1.62383169e-02f, 1.22605329e-02f, -5.75153716e-02f, 7.84874335e-02f,
  5.94787020e-03f, -2.17649303e-02f, 6.45546392e-02f, 3.75950076e-02f, -6.22484088e-02f, 1.34040648e-02f, -3.71330939e-02f, 1.13432251e-01f, 2.84868646e-02f, 2.08478272e-02f,
  4.63885032e-02f, -2.10292060e-02f, -4.64011766e-02f, 6.32505938e-02f, -1.99277904e-02f, 4.36852947e-02f, 2.30667870e-02f, -1.97636932e-02f, -1.50275917e-03f, 2.28835922e-02f,
  -1.10889144e-01f, -5.83581813e-02f, -3.00798845e-02f, -1.29683828e-02f, 1.45349503e-02f, -4.12651151e-02f, 6.83151465e-03f, -4.63660508e-02f, 1.83303398e-03f, 7.78995827e-03f,
  1.65201444e-02f, -3.69498357e-02f, 1.06243612e-02f, -1.92464422e-02f, 2.38874648e-02f, -1.71330404e-02f, -3.48978750e-02f, -1.93102099e-02f, -9.33959056e-03f, 2.66646128e-02f,
  -2.94492710e-02f, -8.33769888e-02f, 4.29119803e-02f, -8.12578667e-03f, -2.37422362e-02f, 2.86025666e-02f, -2.28112154e-02f, 2.68774061e-03f, -9.53283440e-03f, 2.18805093e-02f,
  -1.40286265e-02f, 9.91233159e-03f, 8.49695131e-02f, -4.18907404e-03f, 4.81850654e-02f, -4.21056943e-03f, 4.45256457e-02f, -4.20272537e-02f, -5.53890206e-02f, -1.03829699e-02f,
  -6.95980899e-03f, -1.33513426e-02f, -6.70424551e-02f, -1.66478287e-02f, -6.27200231e-02f, 1.35790110e-02f, -4.64937426e-02f, -2.01960411e-02f, -3.20428871e-02f, 1.37885073e-02f,
  -6.30001128e-02f, -6.71042129e-02f, -1.05661713e-02f, 6.22007884e-02f, 1.06059387e-02f, -5.22416411e-03f, 1.97834633e-02f, 7.26767583e-03f, -6.78315982e-02f, -1.52659370e-02f,
  -1.51441231e-01f, 6.29238738e-03f, -1.39425412e-01f, -1.65407181e-01f, 2.75322855e-01f, 2.96141468e-02f, -1.65347725e-01f, -9.02454555e-03f, -6.92443848e-02f, -1.42537385e-01f,
  -3.52860689e-02f, -5.14301434e-02f, -2.75149643e-02f, -1.76260874e-01f, 1.62371770e-01f, 4.51631099e-02f, -1.55668214e-01f, -9.08868685e-02f, 9.81374606e-02f, -3.74036320e-02f,
  6.14434145e-02f, 3.01681366e-02f, 2.03827079e-02f, 9.55861583e-02f, -5.28861135e-02f, -9.07692462e-02f, 2.14511547e-02f, 6.08239360e-02f, -5.18790632e-02f, 4.30908240e-02f,
  7.36828819e-02f, -2.50611007e-01f, -1.42193556e-01f, -8.86187404e-02f, 1.43351005e-02f, -1.79959536e-02f, -2.59901844e-02f, 6.45090863e-02f, -2.58705299e-02f, 2.07783245e-02f,
  2.95705032e-02f, 6.54985532e-02f, -1.52025344e-02f, 1.67627595e-02f, -2.75122710e-02f, 1.61487050e-02f, 5.62427118e-02f, 2.42228694e-02f, 2.78463457e-02f, 5.40054217e-02f,
  -2.90386584e-02f, -1.58795901e-02f, -1.50566753e-02f, -6.28320649e-02f, -3.52965333e-02f, -2.94072274e-02f, 6.32803841e-03f, -3.15061398e-02f, -4.88051921e-02f, -5.02550974e-02f,
  1.02513460e-02f, 2.47251149e-02f, 1.92743275e-04f, 3.14518064e-02f, -2.07333616e-03f, 4.82128300e-02f, 9.00856219e-03f, 2.01314036e-02f, 6.67777192e-03f, 1.60295237e-02f,
  -2.38800384e-02f, 1.06435902e-02f, -4.84360643e-02f, 4.54860926e-03f, 1.49949444e-02f, -4.94304746e-02f, 1.88245587e-02f, -1.47177214e-02f, -1.16830552e-02f, 5.29108569e-02f,
  -2.41876412e-02f, 1.83410347e-02f, 4.75470908e-03f, -1.37045514e-02f, -7.36857811e-03f, 1.77097246e-02f, 2.53022946e-02f, 7.50587322e-03f, -4.20877337e-02f, 5.78230433e-02f,
  -1.24992924e-02f, -2.27973714e-01f, 2.95807561e-03f, 1.35310991e-02f, -1.61315091e-02f, 2.82942429e-02f, 1.67143252e-03f, 9.86508373e-03f, -2.55537461e-02f, -4.03305702e-02f,
  3.67095023e-02f, -4.92703095e-02f, 3.26518714e-02f, 4.47554626e-02f, 7.17453137e-02f, -3.14943492e-02f, -2.69292202e-02f, 5.21999709e-02f, 2.62113959e-02f, 6.89499751e-02f,
  5.46966679e-02f, 3.52207981e-02f, -5.63828275e-03f, -8.81298855e-02f, 1.58192925e-02f, 4.30739857e-02f, -2.97541171e-02f, -3.95477749e-03f, 4.66351993e-02f, -1.00101596e-02f,
  -1.77181691e-01f, -6.11939617e-02f, -2.17494935e-01f, -1.60945132e-01f, 7.92959798e-03f, 1.57707348e-01f, -3.31105702e-02f, -6.69829026e-02f, -3.97656448e-02f, 6.52535930e-02f,
  2.13797204e-02f, -6.96190074e-02f, 5.91811538e-02f, -7.07989335e-02f, -4.34487760e-02f, 1.26841664e-01f, -7.56466538e-02f, -3.96161377e-02f, -6.34912774e-02f, -1.09936491e-01f,
  -5.00523224e-02f, -2.79445667e-02f, -3.76124904e-02f, 2.07730327e-02f, -1.31054997e-01f, -7.84756690e-02f, 3.88234742e-02f, 7.62701407e-02f, -2.55612526e-02f, 9.55067798e-02f,
  1.16971740e-02f, -1.82803478e-02f, -1.09225258e-01f, -1.84643921e-02f, 5.84692284e-02f, -2.39122473e-02f, -4.01607389e-03f, -2.35529542e-02f, -1.75168980e-02f, -2.62831943e-03f,
  2.44509913e-02f, -3.18418071e-02f, 9.41769779e-03f, 3.08323167e-02f, -4.03253995e-02f, -1.61630139e-02f, -3.44301090e-02f, -7.77157992e-02f, -1.91324018e-02f, -2.81570517e-02f,
  -3.28026898e-02f, -2.23444146e-03f, -4.22905162e-02f, 5.87319490e-03f, 2.06243768e-02f, -3.38296816e-02f, 1.81079078e-02f, -4.95075025e-02f, 3.21056582e-02f, -3.94473337e-02f,
  7.36994296e-02f, -3.72078991e-03f, -4.01302911e-02f, -3.39777842e-02f, -3.77845094e-02f, 3.43161114e-02f, 3.50032412e-02f, 2.53981277e-02f, -7.27959443e-04f, 4.72916998e-02f,
  2.87102498e-02f, 4.84093614e-02f, 4.77760918e-02f, 2.65696016e-03f, -2.69868504e-02f, 2.63814460e-02f, 5.94576560e-02f, -8.82547628e-03f, -1.11453850e-02f, -7.73046818e-03f,
  -3.13563645e-02f, 2.06794590e-03f, 5.12630790e-02f, 9.41731222e-03f, -2.87604760e-02f, 2.34325454e-02f, 2.27572676e-02f, 5.74293500e-03f, 1.18748946e-02f, 6.49294332e-02f,
  1.78212579e-02f, 5.31888157e-02f, -2.35909428e-02f, -1.85550991e-02f, 2.99085453e-02f, 4.80760075e-02f, 4.22141049e-03f, 1.10861808e-02f, 2.04767399e-02f, 1.38572967e-02f,
  -4.87956684e-03f, -2.31715813e-02f, 6.98231254e-03f, 3.94554585e-02f, -5.92639372e-02f, 4.88342755e-02f, 3.91695499e-02f, -2.03341041e-02f, 2.30775643e-02f, 1.27907013e-04f,
  2.91973706e-02f, -6.75593084e-03f, -1.76102296e-02f, 1.10370358e-02f, 4.98119667e-02f, -1.24198599e-02f, 2.50696875e-02f, -3.12442724e-02f, -2.93693636e-02f, -1.21683674e-03f,
  -3.51967067e-01f, 7.08940327e-02f, -1.82566345e-02f, -1.90521497e-02f, -9.45005119e-02f, -1.93691179e-01f, -6.42563328e-02f, -1.15546808e-01f, -2.97684729e-01f, 9.29800943e-02f,
  6.81965873e-02f, 1.30628869e-01f, 4.01947275e-02f, 1.40166283e-01f, -1.69248179e-01f, 5.88340824e-03f, -1.16676360e-01f, 3.74259241e-02f, -8.05096850e-02f, -7.96923116e-02f,
  -1.09994635e-01f, 4.45878990e-02f, 1.20796151e-01f, 1.06230631e-01f, 5.39930537e-02f, -3.78130041e-02f, 1.58473328e-01f, 5.84528930e-02f, 2.44531244e-01f, 6.57505020e-02f,
  -1.66703165e-01f, -6.78033829e-02f, 5.40885217e-02f, 7.13202497e-03f, -4.73898277e-02f, 1.42495520e-02f, 4.37961332e-02f, 2.83858031e-02f, -6.28660470e-02f, -4.30766605e-02f,
  1.78671088e-02f, 2.71152915e-03f, -2.23354320e-03f, -5.59740327e-02f, -1.08528048e-01f, -4.05499749e-02f, 5.97353764e-02f, -4.45065945e-02f, 3.06928214e-02f, 8.10652077e-02f,
  -2.67878827e-03f, 1.37614477e-02f, 5.44757023e-03f, 6.02277964e-02f, 7.79185593e-02f, 6.72530308e-02f, 4.54541948e-03f, 4.55939136e-02f, 1.99821722e-02f, -3.16581875e-02f,
  2.78998376e-03f, -7.57493638e-03f, -2.82229576e-02f, -2.18368582e-02f, 2.12967419e-03f, -9.11531691e-03f, -5.01230068e-04f, 2.11389512e-02f, 7.27158338e-02f, 5.10836951e-02f,
  -1.03524275e-04f, -1.28738647e-02f, 7.30865868e-04f, -1.91791877e-02f, -5.64981624e-02f, -3.44305746e-02f, -3.66242677e-02f, 4.99366410e-03f, -4.00209390e-02f, -3.27046891e-03f,
  -3.97249609e-02f, -1.78547129e-02f, 5.08649945e-02f, -5.30803995e-03f, -2.12221295e-02f, -8.68320465e-03f, 4.58650254e-02f, 1.78582817e-02f, 1.78231131e-02f, 3.92354429e-02f,
  -1.88371912e-01f, -1.22596044e-02f, -2.32861415e-02f, 8.52980837e-02f, 3.43104750e-02f, 5.68068437e-02f, -2.77642459e-02f, 5.58178909e-02f, -2.09187903e-02f, 5.47439279e-03f,
  -4.04258370e-02f, 3.88170965e-02f, -5.51568940e-02f, -1.28003291e-03f, 7.97688775e-03f, -7.01284930e-02f, -3.93530726e-02f, 1.28366174e-02f, -3.36253527e-03f, 4.46171574e-02f,
  7.53524229e-02f, -1.09227533e-02f, 3.36549953e-02f, -4.00212109e-02f, 4.59540449e-02f, 2.42158957e-02f, -7.16544017e-02f, 2.75553595e-02f, 6.09115558e-03f, 5.44921570e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.09444892e-02f, 3.51963669e-01f, 2.03060552e-01f, 3.45303178e-01f, -1.64133757e-01f, -1.81627840e-01f, 1.10445004e-02f, 6.84511208e-04f, -6.95495084e-02f, 1.31684169e-01f,
  -7.09050447e-02f, 1.44580141e-01f, -1.41614992e-02f, 1.67056799e-01f, -1.61159888e-01f, 3.23561095e-02f, 1.03994556e-01f, 1.24198742e-01f, -9.29629728e-02f, 1.28113434e-01f,
  6.93591461e-02f, -1.64367240e-02f, 1.57162726e-01f, -6.25286996e-02f, 2.05446463e-02f, 1.40745714e-01f, -1.24503532e-02f, -1.66204758e-02f, 7.71562159e-02f, -5.81921227e-02f,
  2.73611434e-02f, 3.76255400e-02f, 5.24735451e-02f, 1.59517303e-02f, -1.13294367e-03f, 2.37914012e-03f, 4.83874865e-02f, -3.16294432e-02f, -3.44664007e-02f, 4.77691069e-02f,
  -4.88719391e-03f, -7.63109252e-02f, 5.40804723e-03f, -6.78309100e-03f, -4.11259308e-02f, -3.50048859e-03f, -2.98826750e-02f, 1.00453850e-02f, 9.41708758e-02f, -1.53843290e-03f,
  7.63412714e-02f, 5.20762950e-02f, 1.75941363e-02f, 2.90219784e-02f, -9.28463507e-03f, -9.66408327e-02f, 1.09005757e-02f, 1.15587497e-02f, 4.70607765e-02f, -6.74673766e-02f,
  -5.24863675e-02f, -1.08658045e-03f, 4.85691521e-03f, -1.74369011e-03f, -1.10159079e-02f, 8.51853564e-03f, 2.84513086e-02f, -1.93956215e-02f, -3.11209727e-02f, -1.99484788e-02f,
  -6.67676479e-02f, 1.94908604e-02f, -3.24047282e-02f, -7.21104592e-02f, -4.16936465e-02f, 3.75413448e-02f, 3.43099982e-02f, -1.86514892e-02f, 9.53816622e-02f, 8.96002539e-03f,
  -6.99736774e-02f, -4.05367836e-02f, -3.61476536e-03f, 1.06495470e-02f, -1.98908336e-02f, -4.49301414e-02f, 2.03191955e-02f, 2.50428058e-02f, -9.46427509e-03f, -1.11816926e-02f,
  3.38347256e-03f, 1.28176501e-02f, 1.32829603e-03f, -1.95847787e-02f, 9.26877558e-02f, -4.99438867e-02f, 2.85516791e-02f, 2.08006725e-02f, 4.89691049e-02f, -5.75186461e-02f,
  7.47410133e-02f, -3.27317193e-02f, -1.37452697e-02f, -2.51182844e-03f, -1.63494740e-02f, 2.59221941e-02f, 6.67543113e-02f, -2.73672137e-02f, -1.08284643e-02f, 1.38710411e-02f,
  7.14909807e-02f, -4.14353348e-02f, 5.98362414e-03f, -2.06368342e-02f, -4.31526676e-02f, 5.08889183e-02f, -1.90263754e-03f, -2.12168097e-02f, -1.23298243e-02f, -1.94556117e-02f,
  2.95750648e-01f, -2.03366652e-01f, -3.37322690e-02f, 1.55407280e-01f, 7.83417001e-02f, -1.00181229e-01f, -1.03912847e-02f, 1.71642378e-02f, 5.95773347e-02f, -1.22620985e-01f,
  -5.04913256e-02f, -2.36666575e-01f, -1.60293370e-01f, 9.05130059e-02f, 4.52740751e-02f, -1.50229082e-01f, 7.88827389e-02f, -3.14538367e-02f, -6.20581489e-03f, 2.05154138e-04f,
  3.37806791e-02f, 1.31392494e-01f, -2.64292713e-02f, 8.26152712e-02f, 1.22276321e-01f, 4.96729463e-02f, 5.91875762e-02f, -9.60494503e-02f, 6.73082173e-02f, 5.74342981e-02f,
  -4.78941128e-02f, 2.46921089e-03f, 5.94831258e-03f, 1.27855856e-02f, 1.62300542e-02f, 4.22056094e-02f, 1.29265888e-02f, -3.20200585e-02f, -3.69051546e-02f, -4.75640707e-02f,
  -8.53861198e-02f, 1.60214808e-02f, 2.73311175e-02f, 7.58822560e-02f, 7.85160959e-02f, 1.44423102e-03f, 3.71371731e-02f, 4.73993421e-02f, 2.80129388e-02f, -8.76645967e-02f,
  -5.22173718e-02f, -1.95407029e-02f, 3.42014618e-02f, 6.57783672e-02f, -5.29231131e-02f, -4.35909256e-02f, -8.24777856e-02f, -9.81064215e-02f, -7.97386095e-03f, -5.03574274e-02f,
  -4.72916886e-02f, -1.24835372e-02f, -8.47018417e-03f, -1.95178725e-02f, 6.65228069e-02f, 2.10574605e-02f, -1.29051246e-02f, -7.50705525e-02f, 7.17359558e-02f, -6.36961535e-02f,
  2.94689611e-02f, 5.46081886e-02f, 3.27645689e-02f, -4.15675081e-02f, 8.35503265e-03f, 4.56275009e-02f, 4.34808806e-03f, 2.45491788e-02f, 1.30629893e-02f, 1.23943491e-02f,
  5.19943014e-02f, 1.78471413e-02f, -1.00156583e-01f, 3.30569223e-02f, 4.74815862e-03f, -4.62065870e-03f, 1.44869629e-02f, -3.33329365e-02f, 5.97865358e-02f, -1.39162838e-02f,
  2.03847210e-03f, -1.10675372e-01f, -7.99741074e-02f, 2.46464778e-02f, -5.02249599e-03f, 3.06182448e-02f, 4.33828682e-02f, -2.33272444e-02f, 8.21129605e-03f, -6.73379451e-02f,
  -4.62391824e-02f, -5.57096340e-02f, -3.82864475e-02f, 2.02534087e-02f, 3.59815871e-03f, -2.60559060e-02f, -5.66905551e-02f, -1.91310681e-02f, 4.29369994e-02f, -5.23998067e-02f,
  1.77928638e-02f, -1.26014143e-01f, 3.06043122e-02f, 2.94288304e-02f, -1.49164023e-03f, 3.61920185e-02f, -4.08613458e-02f, -1.74609534e-02f, -5.51013276e-02f, -6.39504567e-02f,
  2.04101458e-01f, -2.69766569e-01f, 1.19761482e-01f, 1.95517931e-02f, 2.54049391e-01f, 8.01025704e-02f, 6.98326603e-02f, 5.10528684e-02f, 6.21141903e-02f, -2.63792992e-01f,
  -5.43454066e-02f, -1.19918145e-01f, -1.42881721e-01f, 2.94653121e-02f, 1.85100660e-01f, 3.33287902e-02f, 2.87189595e-02f, 3.07975337e-02f, 5.75346872e-02f, 2.57060546e-02f,
  1.31836578e-01f, 1.18996590e-01f, 9.14531350e-02f, -1.65476166e-02f, 1.67900696e-02f, 7.17111351e-03f, -9.45027843e-02f, 3.16499397e-02f, -3.33072990e-02f, 8.61628354e-02f,
  4.71344916e-03f, -4.42757793e-02f, -7.42874891e-02f, -4.16758545e-02f, -2.17093676e-02f, -7.03597069e-02f, 8.67744070e-03f, 5.25742695e-02f, 2.65616854e-03f, -1.46026723e-02f,
  -1.13653177e-02f, 9.12912190e-03f, 1.51696615e-02f, 6.46975562e-02f, 5.83780883e-03f, 4.80001457e-02f, 5.39350929e-03f, -2.13756450e-02f, -1.11369370e-02f, 1.52237564e-02f,
  1.06540978e-01f, -5.00959195e-02f, -2.42529344e-02f, -1.76399071e-02f, 6.70976043e-02f, 5.59720304e-03f, 3.01444046e-02f, -2.80224555e-03f, -2.36805901e-02f, 3.23289074e-02f,
  1.13161638e-01f, -2.50130799e-02f, -1.49012618e-02f, 1.01227947e-02f, 8.55038781e-03f, 6.16624504e-02f, 4.69430722e-02f, 3.94509211e-02f, -2.34893374e-02f, 3.26892920e-02f,
  -4.33471315e-02f, -8.07901472e-02f, 3.55534665e-02f, -4.43080487e-03f, -8.02997053e-02f, 2.34599281e-02f, -1.72387939e-02f, -5.08616753e-02f, -3.70594226e-02f, 6.94311485e-02f,
  1.33584272e-02f, 3.13636735e-02f, -6.95083931e-04f, 7.47705325e-02f, -2.85376422e-02f, -4.77540446e-03f, -5.77701256e-02f, 2.11602938e-03f, -2.55271364e-02f, 6.89974055e-02f,
  -2.89634556e-01f, -2.39108980e-01f, -1.18785379e-02f, -2.18373388e-02f, -1.12802237e-02f, -8.89867023e-02f, -1.65162347e-02f, -1.50674433e-02f, -1.47506356e-01f, -3.20314392e-02f,
  -2.95923017e-02f, 2.78814603e-03f, -4.39546555e-02f, 2.13028863e-02f, -2.47816220e-02f, -4.19558845e-02f, -3.77286784e-02f, -1.12070866e-01f, -2.41750237e-02f, -1.99603587e-02f,
  -5.85283823e-02f, 8.58886726e-03f, 3.62510942e-02f, -2.16507465e-02f, -1.43830469e-02f, -2.95014679e-02f, -5.12611233e-02f, 1.49562610e-02f, 4.05690409e-02f, 1.26259234e-02f,
  -2.63978899e-01f, -1.96749553e-01f, 3.89127657e-02f, -2.26326004e-01f, 1.19562477e-01f, 8.12913571e-03f, -4.18120809e-02f, -1.70111388e-01f, -2.34205797e-01f, -2.38639697e-01f,
  -1.04048790e-03f, 4.69391905e-02f, -2.62690429e-02f, -1.32104397e-01f, 1.82305276e-01f, 1.18445233e-01f, -5.19024171e-02f, 5.92742953e-03f, 6.82877675e-02f, -8.12160131e-03f,
  7.66268671e-02f, -2.94970945e-02f, 1.07917599e-01f, 1.69123653e-02f, -2.16931757e-02f, -1.85872223e-02f, 1.19873984e-02f, 3.75329256e-02f, 1.02126841e-02f, 7.63171688e-02f,
  -4.92977612e-02f, -5.75456135e-02f, 5.86547144e-02f, -2.27467287e-02f, -5.29069752e-02f, -3.98963802e-02f, 8.52095038e-02f, 6.22186773e-02f, 1.42987827e-02f, 2.14796718e-02f,
  -2.69798562e-02f, -4.01689224e-02f, -3.26578915e-02f, 2.29674000e-02f, -5.53173795e-02f, -4.95671630e-02f, 5.17390072e-02f, 6.92203343e-02f, -3.47335562e-02f, 2.73415223e-02f,
  1.59538612e-02f, 3.01087368e-02f, -6.82387426e-02f, -4.49302280e-03f, 4.92817163e-02f, -1.45003200e-01f, 1.82378814e-02f, 3.47129405e-02f, 4.19327281e-02f, -2.53190827e-02f,
  5.09353057e-02f, 4.40775417e-02f, 4.70998287e-02f, -3.10139749e-02f, -9.45645422e-02f, -2.30859909e-02f, 1.52908480e-02f, 1.62865762e-02f, -5.03559411e-02f, -8.62528756e-02f,
  -2.62178127e-02f, 2.27114502e-02f, 3.34983841e-02f, -2.33846139e-02f, -5.02246022e-02f, 2.69498993e-02f, 5.06652854e-02f, 2.00608764e-02f, 5.78536354e-02f, -9.19736847e-02f,
  1.62936859e-02f, -5.55394217e-03f, 4.42922711e-02f, 3.43281627e-02f, 1.06241275e-02f, -9.01663899e-02f, -2.62209885e-02f, -4.95296344e-03f, -1.97509211e-02f, 6.26254678e-02f,
  -5.46109825e-02f, -1.05847925e-01f, -7.05889538e-02f, 1.07145114e-02f, 1.65281184e-02f, 4.72730622e-02f, 6.73310012e-02f, -1.05928004e-01f, -7.56236240e-02f, -1.44937085e-02f,
  -3.09927929e-02f, 1.33800423e-02f, 1.08548533e-02f, 2.98921764e-02f, 2.11606398e-02f, -6.43673912e-02f, -6.94208294e-02f, -3.11438367e-02f, -5.98409213e-02f, -2.74844486e-02f,
  2.30314061e-02f, 7.88062140e-02f, -1.07454052e-02f, 7.74801075e-02f, 5.10969991e-03f, -8.25146586e-02f, 1.11419432e-01f, -5.60086183e-02f, 3.84985320e-02f, -6.87647909e-02f,
  -1.85302719e-01f, 2.59829760e-01f, -9.37906653e-02f, 1.52664930e-01f, -1.12052150e-01f, 5.43277338e-02f, 4.59648706e-02f, -2.78046099e-03f, -1.21442609e-01f, 1.21189572e-01f,
  5.72239570e-02f, -4.69192825e-02f, 8.99880007e-02f, 2.71247566e-01f, 9.24604684e-02f, 2.13001430e-01f, 2.24640429e-01f, 6.06192984e-02f, 4.14710492e-02f, 5.86283244e-02f,
  7.23998770e-02f, 1.64271459e-01f, 1.91286579e-01f, 3.20508704e-02f, 5.66836707e-02f, -6.27257004e-02f, 1.92432806e-01f, -6.36272654e-02f, 3.93696725e-02f, 3.70349064e-02f,
  -4.86880392e-02f, -3.78573984e-02f, -2.63786707e-02f, -1.67966411e-02f, -1.41239827e-02f, -3.24826948e-02f, 3.02117448e-02f, -5.06520495e-02f, -8.68760869e-02f, 1.75966527e-02f,
  -5.95283583e-02f, 2.69394759e-02f, 5.55005204e-03f, 1.74391805e-03f, -5.06713055e-02f, -4.29932307e-03f, -2.56253742e-02f, 3.00202076e-03f, -6.21455573e-02f, -4.24998477e-02f,
  -4.82144114e-03f, 5.41366125e-03f, -2.57157851e-02f, -3.69652323e-02f, -9.01971161e-02f, 3.70136462e-02f, 6.10549748e-02f, -1.66028133e-03f, 4.99674566e-02f, -1.84273887e-02f,
  7.44398013e-02f, -4.98522371e-02f, 6.17422462e-02f, -3.82513516e-02f, 5.51377423e-02f, -8.84089340e-03f, 2.96880957e-02f, -1.92183908e-02f, -3.36559373e-03f, -3.75108398e-03f,
  -6.07923269e-02f, -7.09269866e-02f, -5.63968234e-02f, 1.83798000e-02f, -6.74697571e-03f, -2.14340296e-02f, -1.07937846e-02f, -4.76558656e-02f, -1.08644562e-02f, -7.26659000e-02f,
  2.71501802e-02f, 2.89862510e-03f, 1.11360932e-02f, 5.48682511e-02f, -2.77223345e-02f, 4.37323516e-03f, -3.65084037e-02f, 4.40881327e-02f, -1.58415502e-03f, -2.48713754e-02f,
  1.65047646e-01f, 1.70567423e-01f, -2.43328568e-02f, -5.68350479e-02f, -3.84848863e-02f, 4.30847257e-02f, 6.72502071e-02f, -9.32971016e-03f, 9.06746984e-02f, -1.65819265e-02f,
  -9.23452154e-03f, -4.49577486e-03f, -2.64087990e-02f, -5.43166175e-02f, 3.47948931e-02f, 3.11842728e-02f, 5.19101657e-02f, -3.86089608e-02f, 6.22636080e-02f, -4.22859862e-02f,
  5.24214618e-02f, 4.14479896e-02f, -2.85826772e-02f, 3.94449271e-02f, 3.91008146e-02f, -5.25718033e-02f, -7.42277429e-02f, -2.26083752e-02f, -1.56015102e-02f, 5.77274188e-02f,
  5.41900694e-02f, -2.46156275e-01f, -1.96407810e-01f, 7.51694990e-03f, 2.05281571e-01f, 1.07842930e-01f, -5.57356030e-02f, 4.94788326e-02f, -7.12741837e-02f, 3.08527779e-02f,
  -2.10925005e-02f, -1.82710811e-01f, -2.50781715e-01f, -6.61726445e-02f, -5.29517047e-02f, -1.65647030e-01f, 1.06424809e-01f, 2.86574401e-02f, -1.57290608e-01f, -6.53163344e-02f,
  -5.00660799e-02f, 3.98668237e-02f, -6.55630007e-02f, 1.28984526e-01f, 8.54300708e-02f, 8.18345398e-02f, 1.77914798e-01f, 1.44378887e-02f, 1.18753992e-01f, 1.26309052e-01f,
  -2.73027308e-02f, -4.49532941e-02f, 3.59789878e-02f, -8.19441229e-02f, 6.51910976e-02f, -4.60181735e-04f, 4.27790098e-02f, -8.83524772e-03f, 7.27683902e-02f, -7.48096034e-02f,
  -1.54948570e-02f, 3.02851014e-02f, 2.01556589e-02f, -3.50249745e-02f, 1.33318650e-02f, -4.85557131e-03f, -3.37250568e-02f, -8.43208749e-03f, -2.44931895e-02f, -8.08877870e-02f,
  -4.11490090e-02f, 1.35451378e-02f, -1.20507856e-03f, 4.26218435e-02f, -2.81295050e-02f, 2.00180449e-02f, 4.19536531e-02f, -4.54510823e-02f, 3.16607133e-02f, -7.66604021e-03f,
  -5.09731881e-02f, 3.58850858e-03f, -5.47233075e-02f, -6.59761727e-02f, -4.64604348e-02f, 6.35434315e-02f, -3.64550739e-03f, 2.69137751e-02f, -3.05405539e-02f, -9.65008698e-03f,
  2.95129865e-02f, -8.32985714e-02f, -2.36527529e-02f, 7.16650710e-02f, -2.03553704e-03f, -4.47974317e-02f, 3.57872844e-02f, -8.15141574e-02f, -6.28828211e-03f, 1.15936697e-02f,
  2.09683105e-02f, -1.36653557e-02f, -5.30886911e-02f, -8.86188634e-03f, -2.98523493e-02f, -5.26840612e-02f, 1.69117656e-02f, -6.92702159e-02f, -5.73948883e-02f, 5.04172631e-02f,
  6.10886421e-03f, -8.04275870e-02f, -3.97882313e-02f, 1.81230847e-02f, 5.17116114e-02f, 3.46188545e-02f, -5.17590195e-02f, 5.93157075e-02f, 1.94324069e-02f, -2.90231667e-02f,
  2.50733029e-02f, 4.45448048e-02f, 4.24181037e-02f, -6.00442290e-02f, 8.71880539e-03f, 4.90722712e-03f, -1.44095272e-02f, 5.26389703e-02f, 9.86752808e-02f, 4.14038971e-02f,
  4.51727174e-02f, -3.55605558e-02f, 6.91934377e-02f, 3.62825245e-02f, 2.00176183e-02f, 5.38314804e-02f, 3.97661049e-03f, 5.59169091e-02f, -1.39996903e-02f, 2.81982236e-02f,
  8.60089362e-02f, -6.66183904e-02f, -4.84425686e-02f, -3.16182263e-02f, -4.24069054e-02f, -9.41956714e-02f, -1.21297829e-01f, 1.98464841e-02f, -1.29260466e-01f, -3.92520577e-02f,
  -2.91228341e-03f, -3.03993057e-02f, -1.63200319e-01f, 5.89280464e-02f, 7.16972277e-02f, -1.90927789e-01f, 9.34311226e-02f, 5.75021543e-02f, -1.27121210e-01f, -6.49577379e-02f,
  1.99712534e-02f, 1.28349259e-01f, 1.45074949e-01f, 2.79907763e-01f, 1.52049968e-02f, 9.84597951e-02f, 1.88812479e-01f, 3.54245417e-02f, 1.46278456e-01f, 1.23210251e-01f,
  4.91382144e-02f, -3.99265215e-02f, 3.84660214e-02f, 2.57876832e-02f, -1.15204202e-02f, 4.35440289e-03f, 2.03294046e-02f, 3.89487930e-02f, -7.84561224e-03f, 2.46390533e-02f,
  3.52861919e-02f, -1.56248165e-02f, 1.12186708e-01f, -1.57744635e-03f, 3.78711671e-02f, 5.55460751e-02f, 2.08282061e-02f, 9.85548366e-04f, -5.74281886e-02f, -2.74196528e-02f,
  -7.30945766e-02f, -1.00078611e-02f, 3.80141810e-02f, -4.29585353e-02f, 4.22044378e-03f, -1.38004217e-02f, 7.85899386e-02f, 1.68285947e-02f, -7.14751147e-03f, 8.01092461e-02f,
  4.52164374e-02f, 5.49843162e-02f, -2.19198838e-02f, -3.67808156e-02f, -3.54116671e-02f, -8.17648098e-02f, -1.76909860e-04f, 8.15361086e-03f, -5.81191033e-02f, -9.85778570e-02f,
  -4.83843312e-02f, 5.86376376e-02f, -1.01949848e-01f, 1.96792334e-02f, 2.86933966e-02f, 1.84680577e-02f, 2.46160869e-02f, 1.06977830e-02f, 3.81609090e-02f, -4.39573936e-02f,
  -3.87775153e-02f, -1.54686844e-04f, 6.92037353e-03f, 1.31622399e-03f, -2.34861765e-02f, 3.91630009e-02f, 2.88854353e-02f, -2.86484919e-02f, -1.64827122e-03f, 5.42356707e-02f,
  -4.06932610e-04f, 8.97894576e-02f, -2.16022618e-02f, 7.22279400e-02f, -8.75647813e-02f, -3.39601673e-02f, 6.01371080e-02f, 1.06999082e-02f, 6.39985055e-02f, -4.32028584e-02f,
  -2.03093477e-02f, 8.41963962e-02f, 2.08126102e-02f, 5.89595586e-02f, 2.74865292e-02f, 1.69725213e-02f, -3.47047523e-02f, 2.65690628e-02f, 1.10822367e-02f, -3.42849307e-02f,
  1.57178175e-02f, -4.84492369e-02f, 5.23735471e-02f, 5.16123436e-02f, -2.09770575e-02f, -1.52330874e-02f, 6.43664552e-03f, 3.38538401e-02f, -4.61402945e-02f, -8.47051740e-02f,
  1.88852623e-01f, 2.47723758e-02f, 1.37435600e-01f, 2.81623632e-01f, -3.47674526e-02f, 1.60677673e-03f, 2.05060810e-01f, 1.07621010e-02f, 2.31929079e-01f, -8.53427574e-02f,
  -8.19018781e-02f, 5.83303627e-03f, 7.00636283e-02f, -8.98728147e-03f, 3.43699791e-02f, 5.90399094e-02f, 3.49351615e-02f, 3.35983597e-02f, 9.17924643e-02f, 1.80349723e-01f,
  1.46456137e-01f, 7.00290576e-02f, 1.92671046e-02f, -1.28507853e-01f, -1.56789776e-02f, 2.31023114e-02f, -8.93862396e-02f, 3.04471646e-02f, -1.04270704e-01f, -1.59909412e-01f,
  -2.81210542e-02f, 4.58352566e-02f, 1.01909004e-02f, 2.27031391e-02f, -1.30511902e-03f, -1.00144684e-01f, -2.50286218e-02f, 2.21425407e-02f, 4.40794453e-02f, -1.27261886e-02f,
  6.44504651e-02f, -8.11571404e-02f, 6.62764013e-02f, 3.52739878e-02f, 1.50545202e-02f, -4.60228026e-02f, 9.14380327e-03f, -2.76160520e-02f, 1.82752926e-02f, -7.36827776e-02f,
  3.36566307e-02f, 2.63658073e-02f, 5.56999147e-02f, -2.83527020e-02f, 2.22942960e-02f, -4.20295745e-02f, -9.88697074e-03f, 2.69974228e-02f, -4.56643216e-02f, -7.06130080e-03f,
  1.57146491e-02f, 3.50023471e-02f, -4.61101048e-02f, -3.32071669e-02f, 4.54283319e-02f, -1.14433831e-02f, 1.09121148e-02f, -1.30230766e-02f, 4.14341837e-02f, 1.00559629e-01f,
  5.00079729e-02f, -6.90919235e-02f, 1.05871245e-01f, 5.82602620e-02f, 3.93350199e-02f, 7.86698982e-03f, -3.70231643e-02f, -2.12155059e-02f, 2.78791375e-02f, 8.63291696e-03f,
  2.04507615e-02f, -9.18100551e-02f, -1.70354228e-02f, -7.14833364e-02f, 3.11077926e-02f, 5.13808355e-02f, 3.74187939e-02f, -1.91030074e-02f, 5.86867286e-03f, 5.37987724e-02f,
  -1.85821969e-02f, 1.26240909e-01f, 4.88424562e-02f, 4.85651614e-03f, 7.69758318e-03f, -6.16806671e-02f, 2.16482878e-02f, 1.23610990e-02f, 8.77034515e-02f, -3.76329049e-02f,
  1.20631196e-02f, 3.51641811e-02f, 4.22300883e-02f, -4.26553488e-02f, 1.93685237e-02f, -3.03390119e-02f, 4.89934906e-02f, 3.28175873e-02f, 2.36967225e-02f, -1.07896309e-02f,
  8.40687007e-03f, 4.89200503e-02f, 6.29546121e-02f, -7.25225266e-03f, 1.46487961e-02f, 7.51712844e-02f, 1.65864546e-02f, -2.62333583e-02f, -8.88093561e-02f, 3.20122913e-02f,
  4.06537391e-02f, 2.52222091e-01f, 1.75619468e-01f, 4.51477580e-02f, 3.24564762e-02f, -1.58240378e-01f, -6.74298331e-02f, 9.86708850e-02f, 5.44171929e-02f, 5.04090041e-02f,
  -2.13374346e-01f, 2.12379396e-01f, -9.88759473e-02f, -2.19131857e-02f, -3.40638310e-01f, -2.33567700e-01f, 2.22855397e-02f, 9.54985842e-02f, 6.13715872e-02f, 6.06023297e-02f,
  -8.76914337e-02f, -1.12327218e-01f, -3.53263989e-02f, -2.67065763e-02f, 1.88562661e-01f, 1.96029961e-01f, -6.62900358e-02f, -1.84428189e-02f, 1.39178112e-01f, -9.71470103e-02f,
  2.89631989e-02f, 7.06994236e-02f, 9.36264172e-02f, 3.20074707e-02f, -6.81755245e-02f, 1.34645915e-02f, 4.06614365e-03f, -3.91242653e-02f, -4.65663858e-02f, 4.08786312e-02f,
  7.15179294e-02f, 3.53139751e-02f, 3.57601382e-02f, -1.98971443e-02f, 9.55266356e-02f, 4.00492102e-02f, 9.54714939e-02f, 9.09583718e-02f, 9.23781004e-03f, 1.62807535e-02f,
  6.59800544e-02f, 3.23611721e-02f, 2.63350410e-03f, -1.95550676e-02f, 4.17749025e-02f, 6.94249105e-03f, 9.67930886e-04f, 2.70209480e-02f, 4.58251610e-02f, 5.79815172e-02f,
  5.29595558e-03f, -1.47762932e-02f, -6.30458295e-02f, 4.27670330e-02f, -1.24260960e-02f, 5.53126447e-02f, -1.84226017e-02f, -2.86859423e-02f, 1.95023157e-02f, 5.39442860e-02f,
  6.16475455e-02f, -2.40941951e-03f, -7.60765607e-03f, 4.38881889e-02f, 6.17942810e-02f, 2.35357955e-02f, 1.35733839e-02f, 2.85285208e-02f, 4.29562898e-03f, -1.94578972e-02f,
  8.38663131e-02f, -3.16822901e-02f, -6.77624624e-03f, 2.20604092e-02f, -4.10137288e-02f, -3.08947116e-02f, 4.24058475e-02f, 6.57028379e-03f, -9.86943487e-03f, -2.27858825e-03f,
  3.40319425e-02f, 4.49546613e-02f, -2.28652544e-03f, -4.62537585e-03f, 1.06683036e-03f, 2.42034327e-02f, -7.53866136e-02f, 6.72824157e-04f, -3.85546647e-02f, -3.15785445e-02f,
  6.80818036e-02f, -8.51908699e-03f, 3.90608460e-02f, 1.76701229e-02f, -2.28592977e-02f, 2.10324135e-02f, -1.36469668e-02f, -6.96932478e-03f, -1.10296737e-02f, -5.95764956e-03f,
  4.14836518e-02f, 3.40595767e-02f, -3.27647314e-04f, -2.13627536e-02f, 2.03478131e-02f, 3.79599109e-02f, 3.74046490e-02f, 6.09856285e-02f, 5.14187152e-03f, 1.70503873e-02f,
  -9.70398709e-02f, 2.94646155e-02f, -2.97708601e-01f, 1.59626588e-01f, 1.24913780e-02f, 2.32075974e-01f, 2.17807561e-01f, 1.05711825e-01f, -3.98268476e-02f, 1.45171329e-01f,
  1.78424284e-01f, -1.46384478e-01f, -9.33848228e-03f, 2.53941149e-01f, -8.69029947e-03f, 5.09341210e-02f, 1.93929479e-01f, 2.25796625e-01f, -3.79947834e-02f, -2.80066524e-02f,
  -7.89349228e-02f, 1.50297791e-01f, -5.09454012e-02f, 6.16526455e-02f, -3.51016084e-03f, -7.85261095e-02f, -2.04319544e-02f, -1.97692618e-01f, 9.30444524e-02f, 6.90576714e-03f,
  -5.21178432e-02f, -4.03065532e-02f, -2.24602073e-02f, -3.49737629e-02f, 2.61823703e-02f, 5.74449822e-02f, -3.46878208e-02f, -2.02836432e-02f, -9.67550874e-02f, -1.85434353e-02f,
  -1.37273045e-02f, -3.81023772e-02f, 8.93311054e-02f, -4.09359746e-02f, 1.45829935e-02f, -1.05957486e-01f, -3.95510122e-02f, -1.51727926e-02f, -2.11749300e-02f, -5.37576899e-02f,
  -2.42963191e-02f, 8.50018263e-02f, 5.59259998e-03f, -3.33959609e-02f, -9.70784426e-02f, 9.57191177e-03f, -5.41528873e-03f, -1.27955541e-01f, 3.99472713e-02f, 4.37822571e-04f,
  7.88027328e-03f, -6.14830330e-02f, 6.60766810e-02f, 4.68855500e-02f, -2.15616990e-02f, -7.24203736e-02f, 6.25865534e-02f, -1.15929451e-02f, -1.00928903e-01f, 4.31291293e-03f,
  4.14818451e-02f, 2.37956122e-02f, -1.89578794e-02f, 1.09260785e-03f, -5.68985716e-02f, -7.69520737e-03f, -2.24424843e-02f, 6.74550682e-02f, -3.54329385e-02f, 5.92601858e-02f,
  -3.98099944e-02f, 1.74384806e-02f, 2.32017785e-02f, 9.72963311e-03f, 9.55744907e-02f, -3.68455686e-02f, 7.88784698e-02f, -6.24771714e-02f, 1.74729377e-02f, 2.31725536e-03f,
  5.67250215e-02f, -8.76415446e-02f, 6.66252617e-03f, 3.68694253e-02f, -2.82278545e-02f, 2.58094445e-02f, -1.19180912e-02f, -3.62502411e-02f, -7.99411070e-03f, 9.95505136e-03f,
  -7.40942359e-02f, -1.25921024e-02f, -8.48416879e-04f, -8.09812825e-03f, -9.02636442e-03f, 7.74600804e-02f, -3.88654210e-02f, -6.28712475e-02f, 1.62572153e-02f, 3.62125039e-02f,
  4.00762521e-02f, 1.01577770e-02f, -1.33861424e-02f, -9.42023471e-03f, 5.24908267e-02f, -1.55449472e-03f, 4.63580899e-02f, -9.19925608e-03f, -1.64308362e-02f, -5.12693413e-02f,
  7.57383853e-02f, 2.77074128e-01f, 6.38059434e-03f, 1.43880591e-01f, 1.25786141e-01f, 2.50707954e-01f, 9.52403396e-02f, 3.93037051e-02f, 2.55425096e-01f, 6.79188594e-02f,
  -2.07780134e-02f, 1.39013454e-01f, -3.54027771e-03f, 1.94647849e-01f, -7.76076615e-02f, 1.16291173e-01f, 1.87932596e-01f, 1.99004933e-01f, 7.01884702e-02f, 2.61009187e-02f,
  -5.92472851e-02f, -1.28360409e-02f, -1.90288872e-01f, -1.48208946e-01f, -9.47863013e-02f, -1.16189390e-01f, -1.88806921e-01f, -1.56511053e-01f, -4.45521548e-02f, -4.20698076e-02f,
  1.87511295e-02f, 7.72410482e-02f, -5.43623082e-02f, -1.72495879e-02f, 5.86671717e-02f, 3.38681042e-02f, -1.24369217e-02f, -8.26432407e-02f, 5.07216947e-03f, 2.88969819e-02f,
  2.73408275e-02f, -5.44663295e-02f, 4.07333039e-02f, -4.26111706e-02f, -4.19543125e-03f, -3.90413180e-02f, 1.07912486e-02f, -4.84438539e-02f, 3.54380943e-02f, 4.29006517e-02f,
  -1.87786762e-03f, 1.32283231e-03f, 1.64444298e-02f, -9.58302233e-04f, 4.13360782e-02f, 8.06209370e-02f, 4.10163887e-02f, -2.10588276e-02f, 3.17940637e-02f, 1.57346159e-01f,
  3.45422165e-03f, 6.07193671e-02f, -5.21362871e-02f, -8.48949999e-02f, -3.89920659e-02f, -8.31233710e-02f, 3.72736566e-02f, -4.06425856e-02f, 2.77510341e-02f, 4.73585278e-02f,
  -4.52074893e-02f, -5.32539887e-03f, 1.16178570e-02f, -5.35765151e-03f, 9.97737870e-02f, 3.99160124e-02f, -1.09280376e-02f, -1.02472983e-01f, 2.97100302e-02f, -3.90667394e-02f,
  -4.37211990e-02f, 1.09410241e-01f, -1.09074131e-01f, -2.56938133e-02f, 9.27528087e-03f, -1.15235634e-02f, -1.75697692e-02f, 5.53740561e-03f, 2.06232499e-02f, 1.85206141e-02f,
  2.02502459e-01f, 1.86239004e-01f, 7.50821456e-02f, 8.92871693e-02f, 2.53004208e-03f, -8.10552612e-02f, -2.56982166e-02f, 4.32215519e-02f, -2.02725045e-02f, -1.51765589e-02f,
  6.14708662e-02f, 2.26403177e-02f, -5.23297023e-03f, -8.96855723e-03f, 5.13283499e-02f, -2.71013454e-02f, 2.88114082e-02f, -9.77788772e-03f, 1.29272053e-02f, 3.45742516e-02f,
  3.20816203e-03f, 5.33314757e-02f, -5.55026345e-02f, 7.52702635e-03f, 2.22025532e-02f, -4.86952737e-02f, 5.16015589e-02f, 3.65054794e-02f, 1.99916977e-02f, 4.46628854e-02f,
  1.90271344e-02f, -6.01244904e-02f, 7.95787573e-02f, 1.57339349e-01f, -1.40587330e-01f, -1.97785497e-01f, -1.41375124e-01f, 5.64408824e-02f, -1.00877307e-01f, -9.30434186e-03f,
  1.11059241e-01f, -4.60077636e-02f, 1.68036986e-02f, 1.12111956e-01f, 7.75704533e-02f, -4.44882102e-02f, 7.31529295e-02f, -2.54262928e-02f, 5.81192924e-03f, 1.08430624e-01f,
  1.62298858e-01f, 9.17652100e-02f, 1.61827430e-01f, 1.28376022e-01f, -5.64525798e-02f, 1.49469912e-01f, 3.01506400e-01f, 1.52587190e-01f, 1.96214974e-01f, 3.72725502e-02f,
  -2.21376158e-02f, 6.77259965e-03f, -1.67342555e-02f, -5.38759194e-02f, 1.23635843e-01f, -2.36052405e-02f, -6.57701567e-02f, -7.68170208e-02f, -3.07529829e-02f, 3.40995714e-02f,
  -6.81487694e-02f, 3.93337086e-02f, -3.07302605e-02f, 1.64732281e-02f, -2.10838243e-02f, -1.62229855e-02f, -5.64182969e-03f, -7.02977553e-02f, -6.62049651e-02f, 7.10324496e-02f,
  2.30850442e-03f, 2.01654118e-02f, 9.57560202e-04f, -9.40398313e-03f, -1.21168271e-02f, 5.41859772e-03f, -1.95799842e-02f, 6.30772859e-02f, 8.47511180e-03f, 7.42246583e-02f,
  1.64308511e-02f, 3.95955704e-02f, 2.68277675e-02f, -4.36677597e-02f, -5.42723760e-02f, -1.09880278e-02f, -1.29728811e-02f, 9.06124860e-02f, 1.52599132e-02f, 6.12703301e-02f,
  4.72362489e-02f, -1.32847866e-02f, -2.96469368e-02f, 4.93285768e-02f, 3.85327055e-03f, -4.72090393e-02f, -1.25620430e-02f, 4.06297669e-02f, 4.72535156e-02f, -5.86756915e-02f,
  -5.87069578e-02f, 7.60673061e-02f, 3.74476314e-02f, -3.11130285e-02f, -4.03938219e-02f, 1.19368479e-01f, 1.03639834e-01f, 1.22526707e-02f, 4.18165550e-02f, -6.07074834e-02f,
  2.88088061e-02f, 1.62606284e-01f, 1.50265824e-02f, -7.23848194e-02f, 2.67443620e-02f, -5.82362972e-02f, -6.26739562e-02f, -1.00586959e-03f, 4.79702652e-02f, 1.13840006e-01f,
  7.79159134e-03f, 6.75749173e-03f, 4.22197357e-02f, 1.79774407e-02f, 7.61362612e-02f, 5.29176891e-02f, 1.75828766e-02f, -7.68508296e-03f, 4.47182097e-02f, 9.04208794e-02f,
  2.30259802e-02f, -4.86972705e-02f, -4.23097946e-02f, -7.07541853e-02f, 1.34583175e-01f, -1.44760469e-02f, -1.58858970e-02f, 2.85080504e-02f, -3.11804470e-03f, -4.01118472e-02f,
  -1.19469389e-01f, 4.98587862e-02f, -1.19662546e-01f, 2.73062468e-01f, -2.21104041e-01f, 3.68452594e-02f, -4.09721583e-02f, 4.32344675e-02f, -8.68741199e-02f, 9.04353037e-02f,
  6.98900372e-02f, -1.58917993e-01f, 5.59702404e-02f, 2.88392097e-01f, 4.13249396e-02f, 1.49265841e-01f, 1.60825104e-01f, 1.18935391e-01f, 1.93815380e-02f, 1.41375199e-01f,
  1.08790502e-01f, 1.88427731e-01f, 1.45982832e-01f, 1.36295184e-01f, 3.98629755e-02f, 5.14350571e-02f, 8.65693837e-02f, 9.32995006e-02f, 1.31966203e-01f, -6.04032837e-02f,
  2.26989761e-02f, -2.59879921e-02f, 1.84192900e-02f, -8.79617780e-02f, 8.27491004e-03f, -3.49599645e-02f, 4.32060547e-02f, -6.87753558e-02f, -2.87861098e-02f, -4.77973046e-03f,
  -1.10810913e-01f, -4.15501222e-02f, 4.53459918e-02f, 3.79780084e-02f, -8.02839696e-02f, 3.15480083e-02f, -1.92359164e-02f, -3.98452319e-02f, -3.41290496e-02f, 1.36878742e-02f,
  -4.13058931e-03f, -1.71332099e-02f, -3.51301068e-03f, 7.84469545e-02f, 2.64259689e-02f, 4.15291414e-02f, 4.09423970e-02f, -9.02240500e-02f, -7.61492131e-03f, -3.61297615e-02f,
  -9.09722894e-02f, -8.22171848e-03f, -2.44422704e-02f, 8.82633962e-03f, -5.98977134e-02f, 8.53010044e-02f, -3.22942846e-02f, 4.75157723e-02f, 3.61587666e-03f, 8.75236094e-02f,
  2.72180494e-02f, 1.97510142e-02f, 3.00682653e-02f, -3.22059393e-02f, 4.07112949e-02f, 1.81671083e-02f, -8.28000978e-02f, 1.99667234e-02f, 4.36671898e-02f, 2.97315419e-02f,
  2.32130219e-03f, -4.21849973e-02f, 1.52573343e-02f, 2.07244959e-02f, 1.60629563e-02f, 4.83701052e-03f, 1.00702057e-02f, -3.64242907e-04f, -7.32823182e-03f, -4.67119031e-02f,
  4.90217917e-02f, 1.71985645e-02f, -4.96013761e-02f, -4.80001494e-02f, -2.26445179e-02f, -5.89122297e-04f, 2.17051283e-02f, 4.35837694e-02f, 8.61093774e-03f, -3.76269035e-02f,
  -1.13903275e-02f, -5.23191169e-02f, -2.22084988e-02f, -1.89657621e-02f, -2.32826918e-02f, -1.24351531e-02f, 6.63526207e-02f, -5.90595836e-03f, -4.97861532e-03f, 6.48035705e-02f,
  3.64458188e-04f, -1.88157018e-02f, -6.98911212e-03f, 1.69494748e-02f, 3.56202051e-02f, -2.54376307e-02f, -8.02034289e-02f, -9.17913392e-02f, 2.10675281e-02f, 2.71921773e-02f,
  1.28193438e-01f, -1.50837272e-01f, -2.15905115e-01f, -1.30928576e-01f, -2.14326516e-01f, -7.92882964e-02f, -2.73068279e-01f, -1.34836167e-01f, -1.15145214e-01f, -3.23312469e-02f,
  -1.44405663e-01f, -8.12617913e-02f, 1.00982897e-01f, -1.86111957e-01f, 1.00691579e-01f, 1.32793933e-01f, -9.38577801e-02f, -5.21010570e-02f, 4.27992083e-02f, -8.41406267e-03f,
  1.17406202e-02f, -6.53932765e-02f, -4.89782095e-02f, -1.31565526e-01f, -1.95867300e-01f, 6.70638634e-03f, 3.90442051e-02f, -3.73368785e-02f, -1.19731769e-01f, -9.72175375e-02f,
  -1.04777943e-02f, 1.06123045e-01f, -2.24051978e-02f, 6.50521144e-02f, -4.08051834e-02f, 5.49886860e-02f, -3.78141850e-02f, 1.64248869e-02f, 6.26424514e-03f, -6.62368089e-02f,
  7.65220542e-03f, 7.42122680e-02f, -3.35037895e-02f, 4.07337472e-02f, -1.89014096e-02f, -8.59656334e-02f, -5.57837356e-03f, 4.59998380e-03f, -1.53952492e-02f, 7.48880431e-02f,
  -4.77606058e-02f, 2.44038142e-02f, 3.74364927e-02f, 1.49606718e-02f, -4.34290767e-02f, 5.10790609e-02f, 6.58347905e-02f, 2.85584517e-02f, -9.01149511e-02f, -1.46995988e-02f,
  4.44147661e-02f, 2.32537389e-02f, -6.28935173e-02f, -4.76774238e-02f, -8.41962695e-02f, 9.16652381e-03f, -4.15944569e-02f, 2.84545477e-02f, -2.04668716e-02f, 5.31434640e-02f,
  -5.17455414e-02f, -5.09972014e-02f, -1.71682108e-02f, -2.97745951e-02f, 2.22812146e-02f, 5.43581471e-02f, 7.89620169e-03f, -4.79988083e-02f, 2.11635660e-02f, -1.07709514e-02f,
  -2.18373686e-02f, -3.19151506e-02f, -1.12692319e-01f, 1.37431780e-02f, -4.93084937e-02f, -1.31522929e-02f, -4.06101719e-02f, 3.31339007e-03f, -3.72201316e-02f, -2.80795824e-02f,
  9.54658389e-02f, -3.97067703e-02f, -1.20712696e-02f, -8.51184353e-02f, -1.46936870e-03f, -2.54564360e-02f, 2.70191696e-03f, -1.11643896e-02f, 1.66842435e-02f, -6.79056048e-02f,
  -4.87692542e-02f, 9.68257617e-03f, -1.59604251e-02f, 2.74605434e-02f, 3.98492254e-02f, -9.51010883e-02f, -3.01579982e-02f, -8.98121744e-02f, -2.47128541e-03f, -2.50564311e-02f,
  -5.93457632e-02f, -1.48306154e-02f, 8.71112421e-02f, 1.61515847e-02f, -1.11502334e-02f, 1.20870897e-03f, -8.46009329e-03f, 4.10958864e-02f, -2.84464601e-02f, -3.17370854e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.95680067e-01f, 5.63125201e-02f, 7.44149983e-02f, 1.12451389e-01f, 1.48874387e-01f, 6.11073114e-02f, 4.41935621e-02f, 1.36177763e-01f, 4.21360806e-02f, 8.19803774e-02f,
  9.56245065e-02f, 5.78107387e-02f, 1.88095607e-02f, -3.76905985e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.59907434e-02f, 1.86316308e-03f, 1.35428548e-01f, 4.52825055e-02f, 5.16783111e-02f, 6.19572140e-02f, -8.79422873e-02f, 5.41124567e-02f, 8.24443772e-02f, 6.49651289e-02f,
  -1.27565473e-01f, 4.24116366e-02f, 4.74522784e-02f, -5.89388534e-02f, -8.22660401e-02f, 4.34383042e-02f, -1.82949658e-02f, 2.61565968e-02f, -4.92419451e-02f, -7.82131392e-04f,
  -1.70499980e-02f, 1.23838656e-01f, -9.47508495e-03f, 5.30409366e-02f, -2.32256483e-02f, -1.22127652e-01f, 4.67116125e-02f, -2.14277506e-02f, -8.21960792e-02f, 1.41993523e-01f,
  6.93188310e-02f, 1.41810223e-01f, -1.24468006e-01f, 1.02093987e-01f, -4.86665703e-02f, 5.88220879e-02f, -1.08344608e-03f, 1.22338578e-01f, -7.05743432e-02f, 1.90986991e-01f,
  1.24527417e-01f, -4.98094596e-02f, -1.04541957e-01f, 1.95856602e-03f, -1.37752786e-01f, 1.09574765e-01f, 3.98734622e-02f, 4.72906902e-02f, -5.60282208e-02f, 6.05212972e-02f,
  -3.39083858e-02f, 1.05939887e-01f, 2.61237115e-01f, 1.30408764e-01f, -9.64904651e-02f, 9.86753032e-02f, 1.26449302e-01f, 1.14533290e-01f, -1.53140262e-01f, -1.38688654e-01f,
  -1.87651604e-01f, 5.58062643e-02f, -3.92335393e-02f, -8.65499079e-02f, -3.14886533e-02f, -4.58588963e-03f, -1.41244352e-01f, -7.86544979e-02f, -8.48699659e-02f, -9.87616251e-04f,
  -2.34858189e-02f, -8.98202360e-02f, -5.56443594e-02f, -5.15537523e-02f, -1.45816719e-02f, -5.22002727e-02f, -3.95089202e-02f, -2.98032667e-02f, 8.39859545e-02f, -1.22200251e-01f,
  7.98775256e-02f, -6.28817230e-02f, -2.74334159e-02f, 7.44597465e-02f, -1.09604053e-01f, -1.26115397e-01f, -1.18479982e-01f, -7.86619931e-02f, 6.81512663e-03f, 9.73270461e-02f,
  6.10609539e-02f, 3.99141461e-02f, 2.31029913e-02f, -4.95124795e-02f, 2.40951385e-02f, -8.20713639e-02f, 2.68941224e-02f, -5.35963252e-02f, 1.82560757e-02f, -2.15141624e-02f,
  2.02873200e-01f, -4.92259338e-02f, 7.59599498e-03f, -1.42969981e-01f, -8.28701556e-02f, -2.45355777e-02f, 9.05423239e-02f, 1.07921166e-02f, 4.60368991e-02f, -2.45240219e-02f,
  -1.14673991e-02f, 1.78653579e-02f, 1.92354340e-02f, 7.13413432e-02f, 1.52479634e-01f, -1.23568244e-01f, -2.05083966e-01f, -3.63137349e-02f, 1.11661896e-01f, -1.90632179e-01f,
  -8.67857710e-02f, 4.42609657e-03f, 4.52300161e-02f, -1.25955436e-02f, 9.68828518e-03f, 5.21394461e-02f, 8.41412321e-02f, -3.46771022e-03f, 4.52146493e-02f, -1.70468193e-04f,
  -2.57803146e-02f, 3.19103971e-02f, -5.34571707e-02f, -2.30279006e-02f, 1.64108858e-01f, -2.62677297e-02f, -1.39899865e-01f, 1.13283622e-03f, -3.14903148e-02f, 4.61930595e-02f,
  -7.15230256e-02f, 1.31791579e-02f, -1.86521059e-03f, -1.08897775e-01f, -1.56441294e-02f, -3.51036750e-02f, -8.08964893e-02f, 8.02166834e-02f, 1.26898699e-02f, -2.86473874e-02f,
  -6.83119893e-02f, 4.47419882e-02f, -3.62638645e-02f, -1.64506957e-02f, 1.58509240e-01f, -1.83298722e-01f, -8.05190429e-02f, -1.57797381e-01f, -4.59857024e-02f, 1.69018224e-01f,
  8.31209030e-03f, -1.04695059e-01f, 1.04827598e-01f, -8.96301791e-02f, 8.57609659e-02f, -1.34177625e-01f, -8.62535089e-02f, -7.99058974e-02f, -1.16263151e-01f, -5.66656403e-02f,
  -3.42754945e-02f, 1.39342010e-01f, 1.16013393e-01f, -1.05499431e-01f, 5.36328508e-03f, 2.40336731e-02f, 1.62146166e-01f, -7.30825514e-02f, -3.78628038e-02f, -1.38049528e-01f,
  -3.46824490e-02f, 1.44193219e-02f, 7.17806891e-02f, -9.68904495e-02f, -1.57190531e-01f, 2.48131882e-02f, -9.28949490e-02f, -2.12460328e-02f, 6.11752346e-02f, -2.15121195e-01f,
  -2.49309223e-02f, 2.15340286e-01f, -1.69071555e-01f, -1.03233963e-01f, -1.00132897e-01f, -1.01995759e-01f, 1.16043007e-02f, 9.43293273e-02f, -1.27834976e-01f, -5.55747524e-02f,
  4.41751778e-02f, -1.11004062e-01f, 5.11384942e-02f, -4.75392379e-02f, -8.49033818e-02f, -5.20292670e-02f, 4.17796299e-02f, -1.04844376e-01f, 6.91869631e-02f, -4.47228774e-02f,
  -7.13219121e-02f, -1.22256659e-01f, 3.72987539e-02f, -7.75616989e-02f, 4.10981998e-02f, -9.22320932e-02f, -1.83810294e-02f, 1.46674901e-01f, -4.56038341e-02f, -1.97735615e-02f,
  1.46487325e-01f, 7.75882006e-02f, -1.93533972e-02f, -3.52021828e-02f, 7.75720999e-02f, -3.09646297e-02f, -4.13671024e-02f, 1.55877760e-02f, 1.92645311e-01f, -2.64723524e-02f,
  1.21141158e-01f, 1.19279765e-01f, 2.94925682e-02f, 6.28932193e-02f, 8.01539943e-02f, -8.42326432e-02f, -1.20922737e-01f, -8.25119466e-02f, -1.05114564e-01f, 7.91872814e-02f,
  -2.43496932e-02f, 6.37713969e-02f, 3.12774964e-02f, 1.22316390e-01f, -1.25734899e-02f, -6.12843893e-02f, 1.08499825e-01f, -7.40476772e-02f, 5.37425689e-02f, -5.66091724e-02f,
  -8.62858146e-02f, 1.70170590e-01f, -1.87549088e-02f, 9.60052237e-02f, 2.03940228e-01f, 5.51359542e-02f, -1.94473222e-01f, -1.61359638e-01f, -7.79087469e-02f, 7.09979534e-02f,
  2.53863595e-02f, -3.28147672e-02f, -8.17924663e-02f, -5.45274019e-02f, 1.83345135e-02f, -7.48889074e-02f, -8.20010155e-02f, -1.24429569e-01f, -5.74112535e-02f, 4.85626096e-03f,
  -1.35147832e-02f, 8.31942260e-02f, -3.75107452e-02f, -4.14063446e-02f, 3.33204120e-02f, -2.26043426e-02f, -1.07566155e-01f, -1.17638998e-01f, 9.42036510e-02f, -6.84524551e-02f,
  5.79913370e-02f, 3.68099734e-02f, 4.45431992e-02f, -5.51393405e-02f, 1.11472160e-01f, -2.27366742e-02f, -8.73512626e-02f, -1.02506377e-01f, 1.95977986e-02f, 1.53973894e-02f,
  1.20358303e-01f, 1.42891094e-01f, 1.43867135e-01f, -1.26782551e-01f, 9.74932238e-02f, 8.27502534e-02f, 1.55681632e-02f, 1.85644016e-01f, 1.81935325e-01f, -6.38316944e-02f,
  -5.26124313e-02f, -2.57873200e-02f, -1.62069082e-01f, -4.93127294e-02f, 2.41974741e-02f, 1.37792617e-01f, 8.11223015e-02f, -5.44049451e-03f, -8.11614543e-02f, -1.00479290e-01f,
  1.56292021e-01f, 6.40613884e-02f, 3.18418592e-02f, -1.48444727e-01f, 7.21244216e-02f, 2.22880557e-01f, -4.67110276e-02f, 6.58214390e-02f, 6.97614923e-02f, 4.53685224e-02f,
  -3.47828642e-02f, 6.33413205e-03f, 3.77350263e-02f, 5.39638624e-02f, 4.30683680e-02f, 7.61079714e-02f, -1.36034295e-01f, 2.73887273e-02f, 1.70278043e-01f, 4.75589260e-02f,
  -3.36607881e-02f, -1.02326572e-01f, 9.74496827e-02f, 4.77786735e-02f, -6.62826374e-02f, 8.86227116e-02f, -8.69221762e-02f, 1.04815610e-01f, 1.05599344e-01f, -1.06035076e-01f,
  -3.98220085e-02f, 2.10295282e-02f, 1.51491687e-01f, -7.21956342e-02f, 1.99474208e-02f, -6.61462471e-02f, 2.27069557e-02f, 1.64884195e-01f, 9.17724818e-02f, 3.18390429e-02f,
  1.74087539e-01f, -1.73415706e-01f, -7.35827833e-02f, 1.61066309e-01f, 2.78249700e-02f, -2.21543778e-02f, -9.89972427e-02f, -2.41802149e-02f, 4.79361191e-02f, 7.37017319e-02f,
  8.22340921e-02f, 4.24126498e-02f, 7.83703551e-02f, -1.55230120e-01f, -4.29591760e-02f, 7.27062300e-02f, -1.34737387e-01f, 3.18953805e-02f, -1.34759635e-01f, -6.28476590e-02f,
  2.72268914e-02f, 1.35875672e-01f, 8.68513063e-02f, -4.60385066e-03f, -8.94680321e-02f, 5.61591089e-02f, 5.80956861e-02f, 3.93917449e-02f, 1.04478329e-01f, -1.60498574e-01f,
  -2.43538972e-02f, 1.11537851e-01f, -8.61703679e-02f, -1.52592391e-01f, -1.92053933e-02f, -2.06439756e-02f, -5.91234230e-02f, -9.10197869e-02f, 1.61344595e-02f, -2.78519988e-02f,
  2.07239509e-01f, 1.65439975e-02f, -4.82991114e-02f, -1.19337611e-01f, -5.08524681e-05f, 5.30422740e-02f, 1.42573584e-02f, -3.17213610e-02f, -6.00713715e-02f, 3.10693216e-02f,
  -5.96425869e-02f, 5.79153448e-02f, -7.47752115e-02f, -2.35057790e-02f, -4.14594263e-03f, -4.50435318e-02f, -6.33835718e-02f, 9.07671154e-02f, -1.00944296e-01f, -5.54865561e-02f,
  -3.25766988e-02f, -9.45035648e-03f, 4.95167822e-02f, 9.84170809e-02f, -6.32546693e-02f, 1.13630913e-01f, -2.15723589e-02f, 6.40651211e-02f, -1.40727624e-01f, -1.20729543e-01f,
  -9.45408121e-02f, -8.85290876e-02f, -5.65344002e-03f, 9.80330631e-02f, -6.63850009e-02f, -5.70267253e-02f, -1.29151806e-01f, 1.07934229e-01f, -5.71571616e-03f, -2.75832806e-02f,
  5.63175492e-02f, 6.10627569e-02f, 1.82005055e-02f, -2.40872741e-01f, -1.69927865e-01f, 1.07850328e-01f, 7.03225434e-02f, -3.06903403e-02f, -1.02040924e-01f, 1.18905038e-01f,
  -3.08676809e-02f, 1.41438711e-02f, -1.14856869e-01f, 3.69638763e-02f, 3.04979514e-02f, -1.54716894e-01f, -1.87220201e-01f, 3.86456028e-03f, 2.02431306e-01f, 1.52543157e-01f,
  3.51048671e-02f, 1.28194645e-01f, -8.22975039e-02f, -1.43544152e-01f, 1.39574977e-02f, 1.33888468e-01f, -1.05483286e-01f, 5.27161509e-02f, 1.12731785e-01f, 8.49983841e-02f,
  -8.25174060e-03f, 1.33347660e-02f, -1.02821372e-01f, -9.64105353e-02f, 7.16440305e-02f, -1.09593067e-02f, -1.08597383e-01f, 1.33020684e-01f, 7.66287744e-02f, 1.46778315e-01f,
  -9.77795944e-03f, 3.15472111e-03f, -1.73933834e-01f, -1.63326651e-01f, 5.99186942e-02f, -1.00473396e-01f, -2.39973634e-01f, -1.20314062e-01f, -3.12413536e-02f, 2.44464412e-01f,
  3.65258828e-02f, -9.89199243e-03f, 2.16435436e-02f, -1.52980208e-01f, 4.37776074e-02f, -3.33540998e-02f, -1.66519135e-01f, -5.59728034e-02f, -1.27068758e-01f, -2.64977038e-01f,
  -1.88216150e-01f, 1.22174285e-01f, 8.22999235e-03f, 3.24062817e-02f, 1.65932462e-01f, -1.48110464e-01f, -2.08916999e-02f, -1.63569693e-02f, 5.42256311e-02f, -1.11071348e-01f,
  1.33775353e-01f, 5.47873825e-02f, -8.42861738e-03f, -9.92767960e-02f, -9.85849425e-02f, 2.43487924e-01f, -4.90880683e-02f, -1.69992417e-01f, 1.13268085e-01f, -1.87749907e-01f,
  -1.06361113e-01f, -1.35822415e-01f, 1.35729536e-01f, 5.71887530e-02f, -1.47195637e-01f, 3.92952636e-02f, 1.11070588e-01f, -1.50558844e-01f, -6.97723478e-02f, -4.38239090e-02f,
  -6.29082248e-02f, -8.29185173e-02f, 2.30480265e-02f, -1.10088475e-02f, -5.37280738e-02f, 1.21682800e-01f, 1.10442400e-01f, 9.00317430e-02f, 1.87359322e-02f, 2.11922422e-01f,
  -5.31221479e-02f, 5.34819290e-02f, -1.05467096e-01f, -7.81748071e-02f, 5.72161712e-02f, 1.40888002e-02f, -1.16651915e-01f, 6.01246022e-02f, -1.15651727e-01f, -1.35847896e-01f,
  1.48284391e-01f, -1.00790430e-02f, -1.03033639e-01f, -3.37243900e-02f, 2.24373415e-01f, -3.30084823e-02f, -3.26062590e-02f, 1.31780148e-01f, -2.78130740e-01f, 1.00123771e-01f,
  1.60940140e-01f, 1.04655586e-01f, 1.05794072e-01f, -3.99641730e-02f, 1.07573904e-01f, 1.27833188e-01f, -5.19022383e-02f, 1.20547161e-01f, 7.79859871e-02f, -2.64961123e-01f,
  -9.95057672e-02f, -1.31045505e-01f, 2.36761034e-01f, 7.52355456e-02f, -1.89294368e-01f, -3.36101085e-01f, 1.70975044e-01f, -5.05234823e-02f, -4.21239324e-02f, 1.86350420e-01f,
  1.52292788e-01f, 1.49139270e-01f, 2.32170001e-01f, 1.39277905e-01f, 2.12034076e-01f, -2.06038021e-02f, 7.63393939e-02f, 1.48810059e-01f, 6.39200732e-02f, 1.67390388e-02f,
  -8.20052475e-02f, -4.69414219e-02f, -1.16497755e-01f, 5.95128313e-02f, -1.86851352e-01f, 2.73975674e-02f, 8.07328075e-02f, -3.50892544e-02f, -1.73012942e-01f, -3.85065982e-03f,
  -6.33872449e-02f, -1.25638902e-01f, 6.54113963e-02f, -5.14776222e-02f, -4.72980755e-04f, 1.19140722e-01f, -1.06857777e-01f, -4.09431979e-02f, -2.36676987e-02f, 2.58177612e-02f,
  9.98866409e-02f, 7.37015903e-03f, 4.89233620e-03f, 8.78559723e-02f, -1.23770297e-01f, -5.92570081e-02f, -8.58721361e-02f, -1.23484202e-01f, 9.86021906e-02f, -8.13515857e-02f,
  5.84849268e-02f, 4.12401073e-02f, 1.80206120e-01f, -6.73898384e-02f, -9.12907794e-02f, -2.34492511e-01f, -8.14817566e-03f, -1.74176037e-01f, -5.15896827e-03f, 7.26280129e-03f,
  8.22834298e-02f, 1.60361126e-01f, 1.05086789e-01f, -1.40657410e-01f, -4.21468839e-02f, 1.88890174e-01f, 2.83686906e-01f, -1.34179533e-01f, -1.09892257e-01f, 6.47438616e-02f,
  1.82732180e-01f, -2.38254234e-01f, -7.15347603e-02f, -2.15214286e-02f, 1.05217822e-01f, -8.50337818e-02f, -1.30824640e-01f, 1.40463114e-01f, 1.51517570e-01f, -8.08528289e-02f,
  7.66936736e-03f, 1.19761482e-01f, 7.47184902e-02f, 1.49345130e-01f, 6.37091696e-02f, 1.11495264e-01f, -1.65673509e-01f, 4.88397554e-02f, 8.38252530e-02f, 7.97869414e-02f,
  7.53227696e-02f, 3.01442426e-02f, 1.00032566e-02f, 9.93994717e-03f, 7.12444857e-02f, 8.48999992e-03f, -7.66947567e-02f, -5.34806168e-03f, -1.38862443e-03f, 1.98435299e-02f,
  -2.04508323e-02f, 5.92799904e-03f, 6.25640601e-02f, 6.20843060e-02f, 1.59595400e-01f, -6.04685359e-02f, 1.53135866e-01f, -1.82959214e-02f, -1.53667084e-03f, -8.97250697e-02f,
  6.03150241e-02f, -1.01259820e-01f, -2.70378180e-02f, -1.10078052e-01f, 1.73442349e-01f, 2.00930461e-01f, 5.97899742e-02f, 1.54955322e-02f, -1.00898974e-01f, -4.76049669e-02f,
  6.00337535e-02f, 5.08597642e-02f, 9.64022279e-02f, -9.73209292e-02f, 1.15667842e-01f, -5.38627291e-03f, 4.05854098e-02f, -3.01945582e-02f, 5.07061481e-02f, 2.63761789e-01f,
  2.30127439e-01f, -2.04789922e-01f, -8.49677399e-02f, 2.11873859e-01f, 1.46743342e-01f, -1.07051335e-01f, 4.21833731e-02f, -5.49338572e-02f, 1.87144905e-01f, -9.23846811e-02f,
  -1.45367622e-01f, 1.36924520e-01f, 1.09090775e-01f, 8.07055756e-02f, -5.71595468e-02f, 1.01971865e-01f, -4.10156921e-02f, -3.82339861e-03f, 6.32513175e-03f, -5.71279898e-02f,
  1.41201943e-01f, -9.03225243e-02f, -1.16294488e-01f, -3.21122222e-02f, 1.44993648e-01f, -1.27786130e-01f, -8.53221565e-02f, 3.43475640e-02f, 1.10100582e-01f, -8.38429257e-02f,
  8.58540386e-02f, -4.32566889e-02f, -5.48849851e-02f, 1.50279641e-01f, -6.60954863e-02f, -7.64037818e-02f, -1.09740399e-01f, 2.40947921e-02f, 9.00284052e-02f, 1.70532241e-01f,
  1.67980418e-02f, 9.13281217e-02f, -5.79937287e-02f, -3.76045555e-02f, -7.03442842e-02f, -1.36914596e-01f, 1.51871130e-01f, -1.62623078e-01f, -5.82488813e-02f, -1.52379289e-01f,
  9.29348767e-02f, -7.74532482e-02f, -5.58147617e-02f, -2.45221898e-01f, -1.01307854e-01f, -2.45825678e-01f, 1.44625315e-02f, 2.14526337e-02f, 2.64623780e-02f, 1.17617801e-01f,
  1.35166971e-02f, -6.18872084e-02f, -2.22211797e-02f, 9.62273926e-02f, 1.59208328e-01f, -1.22161739e-01f, -1.13953069e-01f, 1.90917484e-03f, 1.82704061e-01f, -1.94952920e-01f,
  2.49968073e-03f, -6.19766861e-02f, 7.37405494e-02f, 9.49886963e-02f, 1.06006652e-01f, 5.81590272e-02f, 1.79919794e-01f, 1.15374988e-02f, 6.77759126e-02f, 8.74706209e-02f,
  6.49649128e-02f, -9.14300531e-02f, 3.67790200e-02f, -5.16007543e-02f, -8.24514031e-02f, -3.47837768e-02f, 4.50510755e-02f, -5.19735999e-02f, 1.27985165e-01f, -5.47636896e-02f,
  -1.36044882e-02f, 4.22436744e-03f, 1.05075240e-01f, -2.67534852e-02f, 2.99641732e-02f, 7.35077709e-02f, -6.93115816e-02f, 1.89982802e-02f, -7.12483609e-03f, 5.90679236e-02f,
  6.43551573e-02f, -1.47905415e-02f, 1.22006740e-02f, 9.05599296e-02f, -5.07187881e-02f, 1.87884960e-02f, 1.03188358e-01f, 1.04812369e-01f, -6.01955131e-02f, 2.39621336e-03f,
  1.39672235e-01f, 6.16240967e-03f, -9.74572748e-02f, -5.17679192e-02f, 2.36808285e-02f, -1.54098049e-02f, 1.34031149e-02f, -4.18870896e-02f, -3.15497071e-02f, -2.43548021e-01f,
  -1.45605102e-01f, -6.70331940e-02f, -4.08345349e-02f, 1.10675603e-01f, 1.15365840e-01f, -1.75763801e-01f, -5.47121763e-02f, -4.61862236e-02f, 1.49927989e-01f, 1.16914839e-01f,
  2.06307340e-02f, -1.24178194e-01f, 1.41290277e-01f, -5.11399209e-02f, -6.78736577e-03f, 8.06210339e-02f, -4.71957847e-02f, 3.90752740e-02f, 1.34902447e-01f, 7.62294456e-02f,
  1.30593896e-01f, -1.58723027e-01f, 7.57283196e-02f, 1.23614356e-01f, 1.96529791e-01f, 6.31578788e-02f, 3.86054888e-02f, 5.17554060e-02f, 1.03167944e-01f, 1.41359344e-01f,
  8.84831622e-02f, 1.99420583e-02f, -8.66189003e-02f, 6.00521006e-02f, -1.78004801e-02f, -6.58857077e-02f, 4.70132567e-02f, -1.80022847e-02f, -2.44425833e-02f, 6.24641255e-02f,
  -3.69818471e-02f, 3.65155451e-02f, 4.96004373e-02f, 1.25092998e-01f, -5.75267188e-02f, 9.29018036e-02f, 5.40813170e-02f, -4.12248820e-02f, -2.55601685e-02f, 2.55597532e-01f,
  3.14256623e-02f, 9.92774367e-02f, 1.60660431e-01f, -8.11427236e-02f, -5.76425605e-02f, 5.79780936e-02f, -1.53273031e-01f, -9.89098623e-02f, 3.45889702e-02f, 6.95150048e-02f,
  -5.27386963e-02f, -3.87678444e-02f, 7.11322576e-02f, -4.88005765e-02f, -6.79075047e-02f, -1.02894507e-01f, 1.25417989e-02f, 3.56929153e-02f, -2.64565777e-02f, -5.28637692e-02f,
  -4.86765951e-02f, 2.16944981e-02f, 3.72960605e-02f, 8.24416876e-02f, 1.51764527e-01f, 8.87755528e-02f, -1.15106739e-01f, 5.63847162e-02f, 1.15676425e-01f, 1.32092252e-01f,
  7.53925666e-02f, -2.32708007e-01f, 4.79071401e-03f, 8.44218582e-02f, -1.27945170e-01f, -2.13457793e-01f, 3.89685817e-02f, 4.65622321e-02f, 1.04156442e-01f, 3.58483717e-02f,
  6.36852160e-02f, -7.09249973e-02f, -1.03413151e-03f, 3.01754624e-02f, 8.01300779e-02f, 2.48677041e-02f, -5.83356014e-03f, 7.92658981e-03f, 9.21780616e-02f, 2.94312015e-02f,
  -3.60861197e-02f, 6.16226383e-02f, -2.20916234e-02f, 7.70554831e-03f, 9.90623725e-04f, 2.42137220e-02f, -1.23919919e-02f, 3.81930992e-02f, 5.04692420e-02f, 2.93293260e-02f,
  -3.94862751e-03f, -5.20746037e-02f, 3.22677370e-04f, -9.91030186e-02f, 1.79900974e-02f, 9.72439125e-02f, 4.83251251e-02f, 4.18097973e-02f, -1.61976423e-02f, 7.61818141e-02f,
  -3.80404703e-02f, -2.94336956e-02f, -1.30266830e-01f, 4.78206538e-02f, -1.73693746e-02f, 1.45595789e-01f, 2.91417353e-02f, -7.14461878e-02f, -1.14724651e-01f, -1.67722423e-02f,
  -1.18455708e-01f, 1.71074141e-02f, 6.03286996e-02f, -5.78590147e-02f, -3.22955698e-02f, -5.41860834e-02f, -2.89076418e-02f, 1.09134391e-01f, 1.73165247e-01f, 8.96836724e-03f,
  -8.29010159e-02f, 1.00270532e-01f, 1.33099169e-01f, 8.83026719e-02f, -2.62945071e-02f, 4.45378572e-02f, 3.35590988e-02f, -7.87691996e-02f, -5.64407147e-02f, -5.40447906e-02f,
  7.81987980e-02f, 3.24340127e-02f, 1.00035734e-01f, 7.95640275e-02f, 1.63050339e-01f, 2.41259672e-03f, -1.44051880e-01f, -3.14371586e-02f, 9.93372649e-02f, 2.31785309e-02f,
  -5.06394217e-03f, -2.93004066e-02f, 1.12265244e-01f, 3.18663977e-02f, 6.54031560e-02f, 9.10836682e-02f, -4.38125692e-02f, 1.38045579e-01f, 5.33106700e-02f, -2.77561788e-02f,
  5.02516478e-02f, 1.79516040e-02f, 2.79914066e-02f, -1.12427836e-02f, 6.74472675e-02f, -1.16994366e-01f, -6.04877807e-02f, -8.14744271e-03f, 5.72985485e-02f, 5.31055257e-02f,
  7.08276927e-02f, -1.33786559e-01f, 4.43181992e-02f, 5.29880412e-02f, -4.16872986e-02f, 4.16844115e-02f, -1.62300482e-01f, 9.94575843e-02f, 3.51156704e-02f, 4.84899320e-02f,
  7.87307844e-02f, 1.82848843e-03f, -6.26360700e-02f, -1.16218761e-01f, -1.97015386e-02f, 1.77892260e-02f, -5.04914820e-02f, -1.07583165e-01f, -7.70524666e-02f, -7.77846128e-02f,
  -1.04353707e-02f, 6.41922355e-02f, 2.12666076e-02f, -6.13457821e-02f, -7.87932947e-02f, 1.23218052e-01f, 9.52624679e-02f, 1.02611348e-01f, 9.49134082e-02f, -7.38930181e-02f,
  1.60863310e-01f, 4.12752181e-02f, -9.16456804e-02f, -1.49095237e-01f, -1.15500510e-01f, -1.11795396e-01f, -2.75846366e-02f, -4.68823276e-02f, -3.62588512e-03f, -4.59501483e-02f,
  1.06982440e-01f, -5.91085106e-02f, 1.97399016e-02f, -1.71884149e-01f, 1.33584619e-01f, -2.85748783e-02f, -6.09974116e-02f, 1.71517450e-02f, 6.63651675e-02f, -1.05179124e-01f,
  8.21025372e-02f, 6.73388876e-03f, -6.58067688e-02f, -1.06414646e-01f, -5.34726083e-02f, -4.42566276e-02f, 8.41581374e-02f, 6.92470968e-02f, -1.23430610e-01f, 1.76050901e-01f,
  -1.46865666e-01f, -1.39121003e-02f, 1.39119223e-01f, 7.66183734e-02f, -2.00457215e-01f, -7.73475179e-03f, 2.07370758e-01f, 2.95479558e-02f, -1.25160858e-01f, -1.61982358e-01f,
  3.58660854e-02f, 5.79753965e-02f, 7.42888600e-02f, 6.49965256e-02f, -2.07978774e-05f, -9.96869653e-02f, -6.33292943e-02f, 1.12919845e-01f, -1.13729179e-01f, 1.41316215e-02f,
  1.21064082e-01f, -5.89213483e-02f, -8.41357931e-02f, -1.25676841e-01f, 3.84621061e-02f, 1.63089678e-01f, 1.44317979e-02f, -2.20700145e-01f, 1.61461443e-01f, 7.72075951e-02f,
  5.43115102e-02f, 7.23032579e-02f, -2.20628098e-01f, 1.47585839e-01f, 2.41701111e-01f, 9.22015831e-02f, 1.71396822e-01f, 3.27642038e-02f, 2.14644410e-02f, -6.96747750e-02f,
  -1.11280167e-02f, 1.23384252e-01f, 5.14008738e-02f, -9.91163589e-03f, -1.68807358e-01f, -1.75365736e-03f, 9.81203280e-03f, 5.17594852e-02f, -8.39973334e-03f, 3.81739996e-02f,
  1.69374386e-03f, 2.74884421e-02f, -8.24179873e-02f, 9.38032493e-02f, -1.71752796e-01f, -1.70679763e-02f, 1.24039888e-01f, -1.30256549e-01f, -6.58735260e-02f, 6.12698495e-03f,
  6.47452474e-02f, -6.38539270e-02f, 9.07163396e-02f, -1.64470121e-01f, 4.66554947e-02f, -1.71645969e-01f, -1.99639169e-03f, 6.34523854e-02f, 1.02658562e-01f, -4.59671617e-02f,
  -1.13244832e-01f, 1.05399817e-01f, 3.65987942e-02f, 2.07305014e-01f, -1.31828383e-01f, 1.55915633e-01f, -5.81500158e-02f, 2.32862800e-01f, 1.02654748e-01f, 1.41295791e-01f,
  6.55544922e-03f, 6.34549931e-02f, -7.64377713e-02f, -5.43610714e-02f, -3.03373002e-02f, 7.84414634e-03f, 6.26131520e-02f, 4.46782187e-02f, -1.72520354e-01f, 1.77798921e-03f,
  1.67068318e-02f, -3.29920538e-02f, -1.18145399e-01f, 6.99945018e-02f, 6.95923343e-02f, 3.00661791e-02f, 2.32990179e-03f, -3.75865512e-02f, -1.23025648e-01f, 7.47695863e-02f,
  -1.63902536e-01f, -4.39368598e-02f, 4.80245389e-02f, 8.44103172e-02f, 2.41591912e-02f, 6.27584159e-02f, -6.74868152e-02f, -9.49795172e-03f, 8.06168243e-02f, 9.68641713e-02f,
  -1.95485771e-01f, 1.55004160e-02f, 3.06634698e-02f, 8.18845816e-03f, 7.06400117e-03f, -2.57589221e-02f, -5.79019338e-02f, -2.17383020e-02f, 1.26177892e-01f, 2.89130230e-02f,
  5.72266765e-02f, 8.89809150e-03f, -1.04707547e-01f, 1.12742551e-01f, -1.10965475e-01f, 5.77416271e-03f, -1.22710980e-01f, -9.72858593e-02f, 2.41130348e-02f, -5.12294583e-02f,
  -2.17478663e-01f, -1.25185475e-01f, 1.35846781e-02f, 1.45580262e-01f, 1.11278124e-01f, -7.03855008e-02f, -2.48245932e-02f, -3.04999016e-02f, 3.72341610e-02f, -1.78296193e-01f,
  -8.99897516e-02f, -1.08674996e-01f, -1.73938021e-01f, -1.86877176e-01f, 6.67007000e-04f, 6.36634901e-02f, 9.52319130e-02f, 5.48288338e-02f, 1.76149607e-01f, 3.66788474e-04f,
  1.61496382e-02f, 1.26011878e-01f, 8.72078910e-02f, -2.47326512e-02f, -3.24294232e-02f, -2.53204200e-02f, -6.95611387e-02f, -1.02632999e-01f, -1.62082165e-01f, -3.52907032e-02f,
  1.21761277e-01f, 7.20803142e-02f, 7.18713701e-02f, -9.90104452e-02f, 1.23071022e-01f, -7.10801184e-02f, 6.34106025e-02f, 2.97513437e-02f, 1.22298419e-01f, 1.57069862e-02f,
  3.99557576e-02f, -9.26114470e-02f, 3.69969793e-02f, 3.01856715e-02f, 2.35524960e-02f, 5.64559223e-03f, -1.29852116e-01f, 3.31406146e-02f, -1.90086849e-02f, 1.96982715e-02f,
  -7.27956742e-02f, 3.65180075e-02f, -7.25736991e-02f, 9.23314393e-02f, 8.14080462e-02f, -1.97165962e-02f, -5.95478602e-02f, 1.15937158e-01f, -2.82007605e-02f, 1.83924772e-02f,
  -6.97207823e-02f, -1.41094223e-01f, -3.08762547e-02f, 1.31356433e-01f, -9.12129730e-02f, 6.93798214e-02f, 9.15869176e-02f, 1.01232842e-01f, 6.08475972e-03f, 6.91617802e-02f,
  -1.17890693e-01f, -8.87454376e-02f, -1.31282926e-01f, -8.91677812e-02f, -5.24471737e-02f, 1.51310274e-02f, 7.26553425e-02f, -9.13173556e-02f, -8.96646082e-02f, -3.06287892e-02f,
  -4.29371595e-02f, 1.27256423e-01f, 4.11659703e-02f, -1.21623287e-02f, -8.25566128e-02f, 3.42261754e-02f, -3.46813500e-02f, 1.44716486e-01f, 2.42935479e-01f, 2.11388916e-02f,
  -1.36695251e-01f, 7.30678737e-02f, 8.98118690e-02f, 3.16977352e-02f, 8.47840980e-02f, -1.31272614e-01f, 6.83676964e-03f, -4.61313175e-03f, -6.84491619e-02f, -1.25551596e-01f,
  7.78363273e-02f, 3.83947492e-02f, -5.66234924e-02f, 7.90562183e-02f, 5.74401319e-02f, 8.09760839e-02f, 4.79522757e-02f, -7.14830235e-02f, -3.15919332e-02f, 7.25400215e-03f,
  -1.54468296e-02f, 5.32407016e-02f, 1.41966287e-02f, 8.27762559e-02f, 2.05275249e-02f, 1.52312656e-04f, -7.52542540e-03f, -1.37153761e-02f, 1.28847823e-01f, 4.58279513e-02f,
  3.23573612e-02f, -1.13877051e-01f, 5.68997599e-02f, -1.12388302e-02f, 8.67056996e-02f, 6.18106760e-02f, -1.07280321e-01f, 7.09597301e-03f, 1.78962406e-02f, -1.40803203e-01f,
  -5.22861555e-02f, -7.86185563e-02f, -2.60918122e-02f, -1.02852620e-01f, 6.49345219e-02f, 4.26629260e-02f, 1.09519109e-01f, -9.67999697e-02f, 3.91570181e-02f, -7.29589835e-02f,
  9.24312323e-03f, 1.02173015e-01f, 1.73795298e-01f, 3.29643041e-02f, 7.46296346e-02f, -1.33566067e-01f, -5.44302650e-02f, 4.62234728e-02f, 7.31157064e-02f, 1.21875860e-01f,
  -5.78709729e-02f, -7.79624358e-02f, -1.44378617e-01f, -7.03606382e-02f, 3.09512541e-02f, 9.08518583e-02f, -9.22212675e-02f, -1.05783783e-01f, 1.30538672e-01f, 5.33886291e-02f,
  -7.82847926e-02f, 4.02592048e-02f, 6.10011145e-02f, 1.74058110e-01f, 1.08422443e-01f, -2.42896508e-02f, -1.44030616e-01f, -1.15037210e-01f, -2.34311447e-02f, -1.47748500e-01f,
  -5.82472011e-02f, -5.36187217e-02f, -5.97582683e-02f, -1.60932288e-01f, 1.86974421e-01f, 1.34334676e-02f, -5.80296814e-02f, 1.12104960e-01f, 3.98782864e-02f, -4.78568152e-02f,
  1.24846555e-01f, 1.41199604e-01f, -4.53357361e-02f, 7.69947618e-02f, 5.21823876e-02f, -1.31609719e-02f, -6.59590214e-03f, -1.72834005e-02f, -1.80308864e-01f, 1.05409555e-01f,
  -1.62200615e-01f, -8.10067132e-02f, 9.11441445e-02f, 8.68567303e-02f, -2.28634849e-01f, 8.83694887e-02f, 1.86434060e-01f, 1.36139449e-02f, -1.52671322e-01f, -1.01423897e-01f,
  5.80364279e-02f, -1.28223663e-02f, 4.67670970e-02f, -1.14559747e-01f, -6.32982254e-02f, -1.78100199e-01f, -1.24975562e-01f, 2.52610054e-02f, -9.67227221e-02f, -8.45397562e-02f,
  1.28242701e-01f, -1.63920835e-01f, -3.41930762e-02f, -1.73962310e-01f, 1.34722263e-01f, 3.20146792e-02f, -1.15727760e-01f, -2.67378867e-01f, 2.67387152e-01f, -1.22112945e-01f,
  -7.25606903e-02f, 1.65844440e-01f, -1.87484801e-01f, 2.61989951e-01f, 1.11714609e-01f, 1.10128954e-01f, 2.12984726e-01f, -3.11735757e-02f, 1.39968246e-01f, 9.60874092e-03f,
  1.95137799e-01f, 1.11879557e-01f, -1.86636636e-03f, 6.57352479e-03f, 2.16542259e-01f, 9.73495916e-02f, -2.62833238e-02f, 1.33292819e-03f, -2.49179080e-02f, 1.09489942e-02f,
  1.22905403e-01f, -6.47008866e-02f, 4.21738923e-02f, 2.92734299e-02f, -9.09021124e-03f, 6.69363514e-02f, -1.33305967e-01f, 1.09949589e-01f, 1.01787776e-01f, 9.40665975e-02f,
  -1.21712564e-02f, 4.86526154e-02f, -7.09783509e-02f, -1.11392379e-01f, 1.82943791e-01f, 1.31003007e-01f, -1.68583333e-01f, 2.12130602e-02f, 8.17722604e-02f, 1.33751586e-01f,
  1.47021376e-02f, 3.31877097e-02f, -2.95187626e-02f, -2.19704360e-01f, -9.88523811e-02f, -1.04034692e-01f, -5.40793240e-02f, -1.69753879e-02f, 1.50130996e-02f, -1.81198537e-01f,
  -1.73299819e-01f, 1.12126805e-01f, 1.10426405e-02f, 1.88658476e-01f, 9.50797424e-02f, -4.98667210e-02f, -9.89956111e-02f, -1.78388074e-01f, 2.90957354e-02f, -5.27404994e-02f,
  1.10832110e-01f, 4.41565476e-02f, -2.62197405e-01f, -1.28136486e-01f, -8.06534812e-02f, 2.28320301e-01f, -1.67707838e-02f, -2.40177542e-01f, 1.39359817e-01f, -2.51731247e-01f,
  -1.54919967e-01f, -1.67043731e-02f, 1.58143044e-01f, 1.18371375e-01f, 1.05601437e-01f, 1.05967969e-01f, 3.30447480e-02f, -1.80048153e-01f, 1.74641877e-01f, 8.30913484e-02f,
  -1.53525025e-01f, 4.79614586e-02f, 4.85877246e-02f, -1.79576520e-02f, -7.49541670e-02f, 4.79554245e-03f, -3.70015875e-02f, 3.74483578e-02f, 8.17905366e-02f, 8.27746391e-02f,
  -7.43033290e-02f, 6.08073846e-02f, -1.13588922e-01f, 1.30335957e-01f, -1.20245427e-01f, -8.76979344e-03f, -7.34125972e-02f, -2.61228923e-02f, 1.12764724e-01f, 4.02041338e-02f,
  -1.70889482e-01f, -6.48772269e-02f, 2.84894146e-02f, 5.85953295e-02f, 4.83375341e-02f, -1.26925111e-02f, -3.01385205e-03f, -7.66857117e-02f, -1.18634582e-01f, -1.54448360e-01f,
  -7.52688944e-02f, -1.33602738e-01f, -1.57146156e-02f, -1.80865362e-01f, -1.11382984e-01f, 1.07368082e-01f, 8.33899900e-03f, 1.16449542e-01f, 5.43895103e-02f, -4.65259925e-02f,
  -9.46238935e-02f, -7.69042894e-02f, 1.06710166e-01f, -1.76964458e-02f, 5.44429012e-02f, 1.78166833e-02f, -7.87600800e-02f, -1.71499565e-01f, -1.17691875e-01f, 2.00507000e-01f,
  9.44925994e-02f, -1.71024069e-01f, 2.52328743e-03f, -1.46644533e-01f, -9.12758186e-02f, -1.45150185e-01f, -1.54147968e-01f, -7.68288895e-02f, 6.45128489e-02f, -5.17189801e-02f,
  -4.13314179e-02f, 1.41348124e-01f, -2.19162516e-02f, 1.90847516e-02f, 1.21711239e-01f, -1.05125355e-02f, -1.18581302e-01f, 9.68268439e-02f, -9.80174728e-03f, -1.98866706e-02f,
  -1.18506350e-01f, 1.15448087e-02f, -5.04642539e-02f, -1.23560980e-01f, 1.10299110e-01f, -4.80475761e-02f, 4.36233655e-02f, 9.12163705e-02f, 4.71449457e-02f, 6.48634210e-02f,
  2.09181868e-02f, -1.72319576e-01f, 1.21551983e-01f, 8.48907158e-02f, -9.93392393e-02f, 3.72287892e-02f, 1.00813605e-01f, 5.14344461e-02f, -1.69666782e-01f, 1.25562966e-01f,
  6.49415031e-02f, 7.53944516e-02f, 1.39948502e-01f, -2.75210366e-02f, -8.65848437e-02f, 8.47717300e-02f, 1.20381624e-01f, 1.21167600e-01f, 9.31111798e-02f, -4.27626930e-02f,
  3.43760513e-02f, 2.94989385e-02f, -5.23385555e-02f, 1.28415480e-01f, 1.25340270e-02f, 1.35455474e-01f, -6.99626952e-02f, 3.29524465e-02f, 7.96826854e-02f, 1.80806831e-01f,
  -7.79987499e-02f, 4.37948853e-02f, -3.10592465e-02f, 6.01888373e-02f, 1.31163243e-02f, -1.08548075e-01f, -2.60778159e-01f, 9.53825116e-02f, -1.92026533e-02f, -2.52900664e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -1.00931399e-01f, 5.27418815e-02f, 9.45975408e-02f, -5.35994917e-02f, 3.62452604e-02f, 2.30676308e-03f, -8.34401250e-02f, 5.15766256e-02f, 1.50416449e-01f, 3.44526879e-02f,
  -1.06411204e-01f, -2.70904694e-02f, 1.77564528e-02f, 6.44556433e-02f, -9.83641762e-03f, 7.66464276e-03f, 8.90967548e-02f, 7.53602535e-02f, -4.54320908e-02f, 2.36405674e-02f,
  -4.24419455e-02f, 4.30608764e-02f, 2.05347184e-02f, -2.04518791e-02f, 9.63247791e-02f, 4.78921235e-02f, 3.21165635e-03f, 3.44183147e-01f, 4.05867510e-02f, 1.01386651e-01f,
  9.15548652e-02f, -1.29866958e-01f, 2.10347511e-02f, 1.28548697e-01f, -1.13993973e-01f, -9.07305479e-02f, 1.30408749e-01f, -1.86094046e-02f, 4.51254547e-02f, -7.35492185e-02f,
  1.60616472e-01f, -2.03132734e-01f, -3.96223776e-02f, -2.08004892e-01f, -7.58137256e-02f, 2.73423254e-01f, -2.01491900e-02f, -1.29005820e-01f, -2.34567359e-01f, 1.01210430e-01f,
  2.43022025e-01f, 1.20585315e-01f, 1.79620981e-01f, 4.62373346e-02f, -1.74694543e-03f, -4.56373394e-02f, 1.44025847e-01f, 1.44556418e-01f, 1.32908165e-01f, -1.02596648e-01f,
  -5.52572347e-02f, 2.81495720e-01f, 1.38751462e-01f, -2.27774829e-01f, 1.21765718e-01f, 1.15999952e-02f, 7.02430904e-02f, -6.66793361e-02f, 5.00491150e-02f, -5.80286309e-02f,
  2.38648415e-01f, 8.44249874e-02f, -5.98983057e-02f, 3.80771346e-02f, 1.89700827e-01f, 1.49701774e-01f, 9.30626020e-02f, 6.61062002e-02f, 1.00286670e-01f, -1.88128911e-02f,
  8.10306072e-02f, 5.04613109e-02f, -3.96469422e-02f, 1.61078349e-01f, 1.27348661e-01f, 1.06001899e-01f, 2.94484273e-02f, 1.32178634e-01f, -1.13124244e-01f, 2.02198029e-02f,
  5.44280559e-02f, -1.65907294e-02f, -1.18351392e-02f, 8.25462639e-02f, -3.01845521e-02f, 1.96595341e-01f, 1.61581635e-02f, -8.40629786e-02f, -8.67372975e-02f, -6.27105385e-02f,
  4.26711179e-02f, 5.86161688e-02f, 4.09932621e-03f, -6.89384565e-02f, -8.41355249e-02f, -1.14167787e-01f, -2.42271289e-01f, 1.64965570e-01f, 2.67805681e-02f, -6.53007701e-02f,
  1.49239555e-01f, 6.02806434e-02f, 9.94047336e-03f, -9.20358822e-02f, -4.10763249e-02f, 4.77123484e-02f, 1.09184980e-01f, 1.60569996e-01f, 8.41014385e-02f, 1.78547204e-02f,
  -2.01494060e-02f, 1.18798755e-01f, -1.38600916e-01f, 5.05931452e-02f, 1.03561088e-01f, -1.04484007e-01f, -2.26508151e-03f, -2.11220211e-03f, -2.25349702e-03f, 1.17611922e-02f,
  3.12946551e-02f, -3.93046513e-02f, 4.51192930e-02f, 3.21074687e-02f, 2.19290942e-01f, -3.35499365e-03f, 2.79379766e-02f, 4.21504043e-02f, 1.19443648e-02f, 1.00559026e-01f,
  5.74591234e-02f, -1.39956493e-02f, 5.99647053e-02f, -4.79304828e-02f, 5.85369617e-02f, 7.79803023e-02f, -1.41502678e-01f, 1.01450942e-01f, 1.16630390e-01f, -1.67208984e-02f,
  -1.39232390e-02f, 6.09092414e-02f, -3.73740122e-02f, 1.17212772e-01f, 9.18356702e-02f, 9.51419491e-03f, -3.70655805e-02f, 4.63385060e-02f, 1.20993098e-02f, 9.38975886e-02f,
  1.65342577e-02f, -7.73527846e-02f, -1.59679316e-02f, -9.42288190e-02f, 7.16730906e-03f, 2.99871862e-02f, 2.18888763e-02f, 1.69856206e-03f, -4.22641151e-02f, -1.08302832e-02f,
  -8.52764919e-02f, 8.84805918e-02f, 2.97779124e-02f, -1.67054906e-02f, 3.48201841e-02f, 9.31541100e-02f, 7.04064742e-02f, -7.37169981e-02f, -1.61166023e-02f, -1.03878072e-02f,
  2.35457048e-02f, 1.34059519e-01f, 4.71708216e-02f, -3.11858710e-02f, 6.28783107e-02f, 6.85527250e-02f, -1.38782188e-01f, -7.21661225e-02f, 1.97208837e-01f, 3.41987936e-03f,
  -1.56748295e-02f, 2.12999910e-01f, 1.46575138e-01f, 5.47934845e-02f, 3.39106247e-02f, 8.20936412e-02f, 1.40936196e-01f, 1.58895249e-03f, 6.58658594e-02f, 1.29721249e-02f,
  1.17697172e-01f, 1.92862041e-02f, 7.57731423e-02f, 8.12729746e-02f, 1.36975765e-01f, 1.23754986e-01f, 1.57678947e-01f, 8.68667960e-02f, 3.81485373e-02f, 1.56887844e-01f,
  -7.73125812e-02f, 1.30071610e-01f, 8.57080370e-02f, -2.66561564e-02f, 4.75433059e-02f, 7.38198459e-02f, -5.48047572e-02f, 3.08798291e-02f, -5.10141514e-02f, -1.41322955e-01f,
  1.35110036e-01f, -5.16581023e-03f, -9.91781726e-02f, -1.00776672e-01f, 9.82219055e-02f, -5.40007763e-02f, -5.16327135e-02f, -6.92103431e-02f, -1.99078456e-01f, 1.19763009e-01f,
  1.14617050e-01f, 4.31994945e-02f, -1.03408918e-02f, 2.19933590e-05f, 2.73324773e-02f, 1.40551776e-02f, -3.53120640e-02f, 2.40745414e-02f, 3.53561901e-02f, -1.44143984e-01f,
  -1.60996616e-02f, -1.63381144e-01f, 1.11200087e-01f, 5.12744449e-02f, -1.30147651e-01f, -1.88291997e-01f, 1.32852420e-01f, 4.47576344e-02f, 2.18786299e-02f, 1.19299814e-01f,
  5.50244860e-02f, 5.39584085e-02f, 3.01820874e-01f, 7.52459094e-02f, -3.13668288e-02f, 2.45210305e-02f, 1.23476297e-01f, 9.96885076e-02f, 3.90944444e-02f, 1.10215358e-01f,
  1.32684082e-01f, -4.94041666e-02f, -4.11325954e-02f, -2.60210801e-02f, -8.70297030e-02f, 1.52995721e-01f, 1.11057647e-01f, -5.00819609e-02f, 9.73068364e-03f, 1.29569203e-01f,
  1.71934962e-01f, 1.16500251e-01f, 5.50392419e-02f, 1.15999103e-01f, 3.19661349e-02f, 1.04166247e-01f, -7.26830512e-02f, 9.91368443e-02f, 4.95552272e-02f, 9.71629545e-02f,
  1.15963027e-01f, -9.76120159e-02f, -5.58717884e-02f, -2.00600773e-01f, -3.00546251e-02f, -1.47697940e-01f, -1.15465410e-01f, -2.78925970e-02f, 1.21405706e-01f, -1.57258049e-01f,
  9.90211964e-02f, 1.21480912e-01f, -8.48178118e-02f, -3.00795175e-02f, -5.54450303e-02f, -1.07910521e-01f, 1.02842068e-02f, 3.35125327e-02f, 4.62770239e-02f, -4.14559181e-04f,
  5.97927719e-02f, 3.53377387e-02f, 4.62887436e-02f, -1.46027759e-01f, 2.21194308e-02f, 7.43466243e-02f, 2.58044094e-01f, -1.63672313e-01f, -1.88253656e-01f, -9.92547721e-02f,
  2.42930725e-01f, -5.80048002e-02f, -5.05861342e-02f, 2.73191277e-02f, 1.73338965e-01f, 1.14366531e-01f, 1.00924492e-01f, 6.55836090e-02f, 2.25250259e-01f, 1.64648015e-02f,
  -1.02535605e-01f, -1.28466547e-01f, -2.25599274e-01f, -6.46698624e-02f, 4.39504348e-02f, 1.21690661e-01f, 1.33672178e-01f, -1.18904196e-01f, 5.26084639e-02f, 8.20429251e-03f,
  -1.39988780e-01f, 2.18243562e-02f, -2.47707986e-03f, 3.76034826e-02f, 7.15934411e-02f, -4.39791530e-02f, 4.56929281e-02f, -6.71909703e-03f, -1.67231888e-01f, 9.96868759e-02f,
  9.95238945e-02f, -2.23593876e-01f, 4.27322127e-02f, -3.29984277e-02f, 1.88804660e-02f, 1.17480345e-01f, 2.26199195e-01f, 9.42839831e-02f, -2.72269901e-02f, -5.05855009e-02f,
  5.25097437e-02f, 4.96165920e-03f, -4.03080285e-02f, 3.00051942e-02f, 1.17827512e-01f, -1.28982276e-01f, 2.57179718e-02f, -4.69205454e-02f, 7.35295713e-02f, 1.42928630e-01f,
  -4.81895506e-02f, 1.37728557e-01f, 1.51037499e-01f, -8.41114018e-03f, 3.32169197e-02f, -2.02734396e-03f, -1.61486685e-01f, 1.58243820e-01f, 9.79786217e-02f, -4.45955843e-02f,
  -2.25917622e-02f, -5.56283407e-02f, -2.60282531e-02f, 7.50701651e-02f, -2.15888564e-02f, -4.97436486e-02f, 6.79528564e-02f, -3.26464362e-02f, -7.10082753e-03f, -3.44921872e-02f,
  8.28348994e-02f, 4.26603258e-02f, -2.82852799e-02f, 2.72044957e-01f, -7.94501454e-02f, 7.66092688e-02f, 2.56445371e-02f, -7.91509300e-02f, -2.45263372e-02f, 2.30959635e-02f,
  -5.17200120e-03f, -1.25884190e-02f, 9.29914340e-02f, -1.12399980e-01f, 6.89867958e-02f, -2.79314667e-02f, 2.14251876e-02f, 1.21954329e-01f, 7.96647817e-02f, -1.75556932e-02f,
  1.75872371e-01f, 1.18076570e-01f, -4.74507511e-02f, -6.53122663e-02f, 7.03678876e-02f, -4.53356979e-03f, 9.79569480e-02f, 3.95480618e-02f, -3.60482521e-02f, 1.42765135e-01f,
  -1.79704711e-01f, 2.41615117e-01f, 1.64654344e-01f, 2.19801683e-02f, 3.95695828e-02f, -4.16206270e-02f, 1.62704006e-01f, 3.36679853e-02f, -2.11208701e-01f, -1.70616761e-01f,
  2.51602028e-02f, -8.57623760e-03f, 9.94242802e-02f, 6.08144654e-03f, 1.13675408e-01f, -1.32697433e-01f, -2.89560817e-02f, -1.83263123e-01f, -9.84600335e-02f, 1.93903327e-01f,
  1.43966088e-02f, -1.55598581e-01f, -2.02554762e-01f, -1.37148514e-01f, 1.41451627e-01f, 1.34616718e-01f, 4.69749086e-02f, -1.96412787e-01f, 3.77693661e-02f, 2.65869126e-02f,
  1.59499615e-01f, 3.60576324e-02f, 1.65618703e-01f, 4.04134803e-02f, 1.10571839e-01f, 1.51250288e-01f, 8.81093144e-02f, -1.23966925e-01f, 4.70479019e-02f, 1.25256166e-01f,
  5.60462065e-02f, -4.00661901e-02f, 8.05390477e-02f, 8.14256258e-03f, 9.77835059e-02f, 3.79918441e-02f, 1.48945615e-01f, -2.31200550e-02f, 6.60983399e-02f, 1.40553042e-01f,
  5.39344288e-02f, 9.71231386e-02f, 1.18104681e-01f, 1.02273457e-01f, 1.94299504e-01f, 1.16992846e-01f, -4.59877960e-02f, 7.04004103e-03f, 8.90045539e-02f, 7.56615922e-02f,
  1.64550096e-01f, 8.69723875e-03f, -2.67033912e-02f, 1.10926218e-01f, -1.11948282e-01f, 1.45924687e-01f, 6.68504136e-03f, 1.54747769e-01f, -1.71697661e-02f, 4.74042073e-02f,
  1.63086176e-01f, 6.70543239e-02f, -1.42724425e-01f, -7.22236186e-02f, -3.82233337e-02f, 8.90663415e-02f, -5.06800599e-03f, -5.70377335e-02f, -1.35885030e-02f, -1.50030479e-01f,
  -1.33012801e-01f, 6.81130290e-02f, -1.18522823e-01f, 5.13870716e-02f, 8.14949870e-02f, -1.14836983e-01f, -1.11019187e-01f, -1.19498201e-01f, 1.35093117e-02f, 1.82148874e-01f,
  1.92806989e-01f, -6.85890168e-02f, 9.41161290e-02f, 7.45059177e-02f, 8.19271728e-02f, 1.21304937e-01f, -1.44044776e-03f, -5.82535611e-03f, 1.79098234e-01f, 1.59813300e-01f,
  -1.16446512e-02f, -7.61405528e-02f, -1.13376781e-01f, -3.54683846e-02f, -1.06342174e-01f, -6.79866821e-02f, 3.46990749e-02f, 4.04437743e-02f, -8.39303806e-02f, -5.44981807e-02f,
  1.20664395e-01f, 3.77299376e-02f, 6.13174066e-02f, 5.23677357e-02f, 1.26727391e-02f, -1.26653947e-02f, 2.64799092e-02f, -2.85134856e-02f, 4.10609320e-02f, -8.90763849e-02f,
  -7.49823172e-04f, -7.82382563e-02f, 5.26466109e-02f, -9.51891914e-02f, 7.45775402e-02f, 4.61736023e-02f, 1.60749704e-01f, 1.65170386e-01f, -5.50350770e-02f, -1.03900746e-01f,
  1.66525140e-01f, 6.96220770e-02f, -2.26084571e-02f, -9.75273252e-02f, 3.64071727e-02f, -2.12443303e-02f, -3.05760652e-03f, 1.54533193e-01f, 5.53236194e-02f, 9.42947045e-02f,
  1.71672225e-01f, 8.18162635e-02f, 4.14032526e-02f, 6.29676208e-02f, 9.59566757e-02f, -1.09117500e-01f, -8.19929093e-02f, -1.23711735e-01f, -7.69116953e-02f, 1.14927292e-01f,
  4.84629497e-02f, 2.11616859e-01f, -5.07629476e-02f, 1.05082840e-01f, -2.69362740e-02f, -6.75686523e-02f, 7.56039545e-02f, 1.79839477e-01f, 2.34019727e-01f, -1.22718617e-01f,
  -1.88248027e-02f, 1.85339540e-01f, 2.31347121e-02f, 2.30966315e-01f, 1.79207891e-01f, 2.53411420e-02f, 1.01470150e-01f, 1.99024662e-01f, 1.36846453e-01f, 2.21998692e-01f,
  1.25734299e-01f, -1.29794632e-03f, -7.93590769e-02f, 2.46140771e-02f, -4.00779955e-02f, 7.68001974e-02f, -5.83487600e-02f, -3.85262184e-02f, 4.14374992e-02f, 6.79187030e-02f,
  6.49169460e-02f, 1.35315925e-01f, -7.44674429e-02f, 1.04005091e-01f, 2.01823384e-01f, 4.51586209e-04f, -9.84502509e-02f, 1.02757975e-01f, 1.32021755e-01f, -5.50672449e-02f,
  1.43835679e-01f, -1.86368763e-01f, -4.58968282e-02f, 3.42903808e-02f, -6.06741197e-02f, -2.64320880e-01f, 1.06758542e-01f, -2.43139550e-01f, 7.70745203e-02f, -3.17410342e-02f,
  1.72334522e-01f, 1.02680221e-01f, -1.59404844e-01f, -2.08272412e-01f, -2.77164578e-02f, -1.58059716e-01f, -1.55248512e-02f, 1.99105769e-01f, 2.49565572e-01f, -1.70611739e-01f,
  1.66845307e-01f, 1.22354969e-01f, -5.29497229e-02f, -8.67144167e-02f, 1.59877799e-02f, 2.64848381e-01f, 1.61834568e-01f, -9.40108821e-02f, -1.17139459e-01f, -8.80438164e-02f,
  -8.59995708e-02f, 1.60305873e-01f, 5.45597449e-03f, -1.81383714e-01f, 3.82603407e-01f, 2.32745036e-02f, -2.00758111e-02f, -6.56503737e-02f, -2.71704071e-03f, -1.88659161e-01f,
  -5.41044725e-03f, 5.26144207e-02f, 1.19888835e-01f, 5.44387009e-03f, -2.84482539e-02f, 7.78635442e-02f, 1.41431615e-01f, -7.20135402e-03f, 4.10897210e-02f, 7.65475631e-02f,
  1.34657919e-01f, 9.20211747e-02f, -3.55983339e-02f, -7.17937499e-02f, -6.98270500e-02f, -1.47898689e-01f, 1.13793656e-01f, -8.70461538e-02f, -5.27327433e-02f, -5.68396132e-03f,
  8.64596441e-02f, -1.90706644e-02f, -2.04140153e-02f, 5.39953522e-02f, 9.61094443e-03f, -1.58388400e-03f, 1.38660017e-02f, 1.81862414e-01f, -9.17876735e-02f, 1.58578111e-03f,
  1.16594862e-02f, 5.12560569e-02f, -9.13305506e-02f, -4.89552990e-02f, 8.67273957e-02f, -1.96124926e-01f, 2.95337707e-01f, -1.86150834e-01f, -1.61003515e-01f, -1.65118620e-01f,
  -1.89450830e-01f, -1.64331254e-02f, -3.96389328e-02f, 2.71073803e-02f, 1.38518751e-01f, -1.68070346e-01f, -3.58952135e-02f, 2.23012283e-01f, 4.20667492e-02f, 1.47458762e-01f,
  -5.42942323e-02f, -6.70108497e-02f, 4.30273404e-03f, 1.89432010e-01f, 4.70904931e-02f, -1.04307927e-01f, -1.93623547e-02f, -1.01533055e-01f, -2.74317265e-02f, -8.50514323e-02f,
  -1.40075400e-01f, -7.64533877e-02f, 4.05603945e-02f, 8.40488598e-02f, -1.55931711e-01f, 1.29214730e-02f, 3.39410156e-02f, -4.06585075e-02f, -1.55712571e-02f, 1.08254356e-02f,
  -3.17975767e-02f, 2.54944358e-02f, 4.12886441e-02f, 1.19564561e-02f, -8.54792669e-02f, 2.45652720e-02f, -1.92544796e-02f, -5.34343459e-02f, -4.51188907e-02f, 5.19669093e-02f,
  8.23349750e-04f, -1.80214085e-02f, 3.16939354e-02f, -5.28182872e-02f, -1.85594130e-02f, 2.39175148e-02f, 4.37542908e-02f, -1.75944995e-02f, 1.77405849e-02f, 5.71823232e-02f,
  -5.79391234e-02f, 1.31000504e-02f, 6.41387776e-02f, 4.53281589e-02f, -1.23549979e-02f, 7.28179887e-02f, -1.60766710e-02f, 6.66104490e-03f, -5.44923730e-02f, 6.83875754e-02f,
  8.43824893e-02f, 1.67630496e-03f, 3.79060209e-02f, 6.74604699e-02f, 2.87993178e-02f, -9.98799410e-03f, -6.35064542e-02f, -4.04955298e-02f, -7.46062025e-02f, 2.10312288e-02f,
  1.38888499e-02f, 3.82491648e-02f, -2.72813141e-02f, 7.20232874e-02f, -3.51623595e-02f, 6.27723932e-02f, 4.71248031e-02f, 5.81134632e-02f, -4.98575866e-02f, 1.38018608e-01f,
  1.26789212e-01f, -5.76843247e-02f, -1.82860866e-02f, 8.96712169e-02f, 4.91185160e-03f, -3.76902241e-03f, 8.62090960e-02f, -8.04459751e-02f, -1.11404270e-01f, -6.79739341e-02f,
  3.28375399e-02f, -4.73844446e-03f, 1.41745508e-01f, 1.36930451e-01f, 1.51761889e-01f, -1.01178493e-02f, 1.14231296e-01f, -2.03949083e-02f, -2.03941599e-03f, 1.21243887e-01f,
  1.18379198e-01f, 1.23625733e-01f, 3.48456064e-03f, 1.64838538e-01f, 6.48986623e-02f, 9.99515578e-02f, 6.40752912e-02f, -1.66490730e-02f, 1.66082710e-01f, 1.35218783e-03f,
  6.06568009e-02f, 6.78401664e-02f, 5.59354126e-02f, 1.52798399e-01f, -5.87452129e-02f, -6.99295327e-02f, 1.22677520e-01f, 1.67731792e-01f, 3.95687036e-02f, 7.74442777e-02f,
  -3.67661566e-02f, 1.30428851e-01f, -2.02073529e-02f, -1.08656473e-01f, -1.07461296e-01f, 1.44434601e-01f, 1.47311732e-01f, 2.52335966e-01f, 5.34710055e-03f, 3.17172222e-02f,
  2.68438860e-04f, 6.01276755e-02f, -1.53788880e-01f, -1.35938868e-01f, -8.64780918e-02f, 4.70972396e-02f, 4.81432676e-02f, -1.82765037e-01f, -1.60749167e-01f, 2.54965305e-01f,
  1.47166699e-01f, 6.45131022e-02f, -6.16371073e-02f, 1.74008399e-01f, 2.25060254e-01f, 4.97661196e-02f, -1.01978682e-01f, 1.79788657e-02f, 1.87028378e-01f, 1.97300036e-03f,
  -6.86756000e-02f, 1.54427439e-01f, -8.99838097e-03f, 2.35334337e-02f, 3.08949500e-02f, 7.78345913e-02f, 1.03683680e-01f, -3.07754055e-02f, -9.06943008e-02f, 8.37416723e-02f,
  1.22595944e-01f, 1.63969770e-02f, -1.19664166e-02f, -1.81596037e-02f, 8.70015398e-02f, 2.06884835e-02f, 8.09373558e-02f, 3.61507051e-02f, 4.90345545e-02f, 7.51587674e-02f,
  4.59807776e-02f, -6.91340640e-02f, 7.72043318e-02f, 1.12758502e-01f, 1.35298595e-01f, 2.25002244e-02f, 3.64731587e-02f, 1.63371712e-02f, -9.94215533e-02f, 1.53334424e-01f,
  4.64364402e-02f, 1.04837947e-01f, 1.75521836e-01f, -5.99905103e-02f, -3.63281034e-02f, 1.36518314e-01f, -1.52354747e-01f, 8.49434286e-02f, -1.26930326e-01f, 1.20267004e-01f,
  4.90226671e-02f, 7.94242546e-02f, 1.04631647e-01f, -3.77421938e-02f, 1.39018809e-02f, -1.25378951e-01f, -6.80258870e-02f, 9.01245475e-02f, -1.46321915e-02f, -3.33718546e-02f,
  -1.45268202e-01f, 4.02599275e-02f, 9.20233727e-02f, 1.68207809e-01f, 2.02444986e-01f, 1.19127566e-02f, 1.29295196e-02f, 1.43925816e-01f, 1.92901447e-01f, 1.11951046e-01f,
  1.27953634e-01f, -7.50933401e-03f, -8.17094278e-03f, 1.63942352e-01f, -8.68717674e-03f, -2.47931089e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -1.59870852e-02f, 1.49281189e-01f, 4.44425084e-02f, 7.19890222e-02f, 1.30023733e-01f, 5.80102541e-02f, 4.48742807e-02f, 9.28876251e-02f, 1.17011787e-02f, -3.49155888e-02f,
  6.08192198e-02f, -9.77431890e-03f, 7.24478588e-02f, 9.50614437e-02f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.95218679e-02f, -5.70193492e-02f, 5.72791919e-02f, -3.12643312e-02f, -1.72135934e-01f, 2.78017651e-02f, 4.69834656e-02f, -9.38249752e-02f, 1.84865706e-02f, -1.73912514e-02f,
  5.14643081e-02f, 1.02168538e-01f, 1.38685359e-02f, 5.35317361e-02f, -5.19207269e-02f, 7.18529746e-02f, 5.85992374e-02f, -3.80889550e-02f, -1.22368764e-02f, -3.52126844e-02f,
  -4.75436784e-02f, 4.60635200e-02f, -6.15903661e-02f, -8.91111325e-03f, -5.35620824e-02f, 6.82674125e-02f, -4.92326021e-02f, 9.40462947e-02f, -1.07798101e-02f, -8.77500139e-03f,
  -1.38906434e-01f, 1.08774245e-01f, 8.12861398e-02f, -5.64384386e-02f, -1.68237835e-01f, -1.63698301e-01f, -4.01942991e-02f, 7.60773895e-03f, -4.01271544e-02f, 3.10645215e-02f,
  -4.60061096e-02f, 7.21711814e-02f, -6.94065541e-02f, -1.87515151e-02f, -1.48537029e-02f, -5.48716299e-02f, 7.04509616e-02f, 1.44075200e-01f, 4.33279760e-02f, -8.03992748e-02f,
  -1.80167764e-01f, 6.64730743e-02f, 1.72373399e-01f, 1.40895927e-02f, -1.29949629e-01f, 1.41125038e-01f, -8.80370885e-02f, -8.03116113e-02f, -9.08282697e-02f, -2.84445345e-01f,
  3.60441543e-02f, -4.65980135e-02f, 1.15311161e-01f, -1.57556474e-01f, -6.60247803e-02f, -5.84784895e-02f, -1.20839663e-01f, -8.33579972e-02f, 2.38548592e-02f, -3.12105790e-02f,
  -9.22307447e-02f, -1.64373666e-02f, 1.29740730e-01f, -8.30488373e-03f, -6.48150370e-02f, -4.74512875e-02f, -2.48525850e-02f, -1.69911869e-02f, 1.32341143e-02f, -1.26398563e-01f,
  -9.71118361e-03f, -7.28497729e-02f, 1.96376368e-02f, 1.93932140e-03f, 1.44781368e-02f, 6.42976463e-02f, -7.80625418e-02f, 2.06215195e-02f, 1.12593910e-02f, 6.38206750e-02f,
  -4.06425111e-02f, -1.59625813e-01f, 1.83103122e-02f, -5.76713085e-02f, 2.01496571e-01f, -4.93684271e-03f, -5.92221282e-02f, 2.49779839e-02f, 2.35892553e-03f, -4.96319383e-02f,
  -1.07856646e-01f, 3.97435650e-02f, 1.89266756e-01f, 8.70299563e-02f, 1.81305766e-01f, -7.58022219e-02f, 1.33525863e-01f, -7.45775923e-02f, 1.78794369e-01f, -1.00059703e-01f,
  2.26460770e-03f, -1.63586475e-02f, 5.10345213e-02f, 1.44593986e-02f, 2.51040697e-01f, -1.61691979e-02f, -9.80244428e-02f, 4.85352762e-02f, 7.72830024e-02f, -1.69468299e-01f,
  1.67723656e-01f, 3.35047953e-02f, -4.17909847e-04f, 8.99160504e-02f, -1.27324343e-01f, 4.35830206e-02f, -5.49911670e-02f, 1.59829587e-01f, 3.92978899e-02f, 1.66922472e-02f,
  -1.60240754e-01f, -3.74659114e-02f, 2.64318287e-02f, -1.09153159e-03f, -1.27575994e-01f, 5.71010597e-02f, 7.93185830e-02f, -8.44788104e-02f, -7.67276529e-03f, 5.95146567e-02f,
  -9.96857509e-02f, -1.26328155e-01f, -6.98681846e-02f, -1.39162794e-01f, -3.04808822e-02f, 5.66377454e-02f, 1.44671816e-02f, 5.36848325e-03f, 5.18222190e-02f, -5.49941175e-02f,
  -5.16594499e-02f, -1.03138760e-01f, -5.16964346e-02f, 6.08719066e-02f, 3.20938453e-02f, -8.81444961e-02f, 8.32998380e-02f, 4.36232649e-02f, 1.72574759e-01f, 2.68730056e-02f,
  -1.55952945e-01f, 1.00893937e-01f, -1.09301314e-01f, -8.79877135e-02f, -1.75222065e-02f, 6.44226372e-02f, 8.12829509e-02f, -2.17994861e-02f, 4.90022264e-02f, 1.22911625e-01f,
  9.80644021e-03f, -1.09196924e-01f, 4.89599220e-02f, -3.46110985e-02f, 3.63839902e-02f, -1.66585539e-02f, -3.80271114e-02f, 7.92624801e-03f, 2.07615629e-01f, -7.58312494e-02f,
  2.01145913e-02f, 2.53982078e-02f, -3.28002172e-03f, 7.21242130e-02f, 9.34853479e-02f, 4.07325700e-02f, 1.35369403e-02f, 3.39940041e-02f, -1.25266761e-01f, 2.80605145e-02f,
  4.08713780e-02f, 1.79285780e-01f, -4.00144607e-02f, 1.00694057e-02f, 4.50243019e-02f, 6.21342100e-03f, 6.49312362e-02f, 4.26107273e-02f, 7.58584961e-02f, -2.21095439e-02f,
  9.70061810e-04f, 7.40602165e-02f, 3.63256074e-02f, 2.07429249e-02f, 4.12076712e-02f, 1.09754480e-01f, -6.74202964e-02f, -7.22086523e-04f, -4.72135395e-02f, 6.00563847e-02f,
  8.57617185e-02f, 5.07015316e-03f, -5.05977087e-02f, -1.14273943e-03f, 4.71845083e-02f, 1.92165729e-02f, -3.32732722e-02f, -4.55542244e-02f, -1.15624173e-02f, -7.40572810e-02f,
  9.04765427e-02f, 1.21109717e-01f, 3.47907059e-02f, -1.15988977e-01f, -9.04833749e-02f, -2.63170060e-02f, -5.09896949e-02f, 1.70246482e-01f, -3.49453166e-02f, -4.66119219e-03f,
  -2.73828879e-02f, -3.47224809e-02f, -2.96449270e-02f, -8.42823759e-02f, 1.28933936e-01f, -4.82815020e-02f, -4.87543270e-03f, 4.52187918e-02f, -1.34242743e-01f, -1.27757683e-01f,
  -1.61524832e-01f, 1.07368521e-01f, -9.84441265e-02f, -6.95363879e-02f, -9.88592505e-02f, 8.47094506e-02f, 1.30932257e-01f, 1.56833585e-02f, -1.31012693e-01f, -1.07008621e-01f,
  1.50528863e-01f, 9.62026790e-02f, -5.04778251e-02f, 6.00333549e-02f, 1.26983464e-01f, 4.26771641e-02f, -2.86204799e-04f, -1.77200884e-02f, 1.45741433e-01f, -1.32997800e-02f,
  -1.80496834e-02f, -7.50597045e-02f, 1.16598517e-01f, 5.01009971e-02f, -5.06723784e-02f, 1.69852842e-02f, -3.97398770e-02f, -1.10633187e-01f, 1.42627090e-01f, -1.28675578e-02f,
  3.63401882e-02f, 2.94034556e-03f, 3.90947685e-02f, -9.06184241e-02f, 2.78264238e-03f, 3.83655950e-02f, -5.53446934e-02f, 8.14394467e-03f, -1.22105302e-02f, 1.81553594e-03f,
  7.39825740e-02f, -6.88821152e-02f, -9.56221968e-02f, 8.17874297e-02f, -1.47976413e-01f, -7.66756013e-02f, -4.87928689e-02f, -9.50434208e-02f, 1.49625167e-01f, 9.01061520e-02f,
  9.41720530e-02f, 2.15123326e-01f, 5.18169589e-02f, 1.84570551e-02f, 2.30498035e-02f, 9.54895690e-02f, 4.67021689e-02f, -8.76115113e-02f, 6.37707952e-03f, 1.96910352e-01f,
  9.62097272e-02f, 7.71696717e-02f, -8.83978084e-02f, 5.02774157e-02f, 1.56051978e-01f, -1.47746488e-01f, -1.54161468e-01f, 3.91471237e-02f, -5.31005152e-02f, -4.70359474e-02f,
  2.70036668e-01f, -1.61475390e-01f, -1.56036034e-01f, -1.51816115e-01f, -8.62424895e-02f, 2.29670256e-01f, -3.80357765e-02f, -4.60179560e-02f, -8.87570903e-02f, 1.93675514e-02f,
  -4.50984016e-03f, 5.59877157e-02f, 6.66975528e-02f, 5.52220568e-02f, -3.98800708e-02f, 1.04822770e-01f, 3.31490822e-02f, 1.32844411e-02f, -1.69858299e-02f, 9.52249989e-02f,
  -1.93043929e-02f, 4.30354029e-02f, 6.45233272e-03f, 2.57402044e-02f, 8.29868019e-02f, 7.53386468e-02f, -9.96519532e-03f, 2.93229893e-02f, 3.31433117e-02f, 2.97379065e-02f,
  2.14170218e-02f, 9.81910229e-02f, 8.71513560e-02f, 1.05276614e-01f, 1.96649488e-02f, -1.08424276e-01f, 1.07903946e-02f, 9.62303281e-02f, 4.25278842e-02f, -1.33512961e-02f,
  -9.60183740e-02f, 1.22955041e-02f, 1.25595093e-01f, -1.62739322e-01f, 1.07097775e-01f, -2.38167960e-02f, 5.38899489e-02f, -5.11814728e-02f, -8.58353525e-02f, -2.54530814e-02f,
  -9.88462493e-02f, -3.99533510e-02f, -1.67435661e-01f, 1.06874295e-01f, -6.81907237e-02f, 4.43371534e-02f, 8.66673142e-02f, 1.00038841e-01f, 7.09165707e-02f, 1.51548600e-02f,
  -9.24681053e-02f, 1.10141464e-01f, -7.69593101e-03f, -2.57422961e-02f, -5.73074333e-02f, 1.45254694e-02f, -2.71425936e-02f, -1.13378018e-01f, -6.29695356e-02f, -1.65562615e-01f,
  1.69375911e-01f, -2.07449291e-02f, -7.24502001e-03f, -1.30824357e-01f, -2.14381032e-02f, 7.02213147e-04f, -1.28632724e-01f, 3.52957025e-02f, 7.43395016e-02f, -8.42326656e-02f,
  3.26418551e-03f, -1.97389182e-02f, -2.63511930e-02f, -4.91784364e-02f, 6.66276971e-03f, 8.74356180e-02f, -4.72614579e-02f, -6.35153204e-02f, 3.17269489e-02f, 1.60274208e-02f,
  -6.69684112e-02f, -3.13454866e-02f, -1.05515890e-01f, -4.74364646e-02f, 9.65406150e-02f, -6.47480786e-02f, -1.91670340e-02f, -6.41391799e-02f, -7.18365163e-02f, -4.30264585e-02f,
  -3.14916158e-03f, 5.19987568e-02f, 1.75304294e-01f, 2.51683574e-02f, -8.75456184e-02f, 6.33180961e-02f, 2.65142638e-02f, 1.73029050e-01f, 5.11451103e-02f, -1.30688623e-01f,
  1.24060184e-01f, 1.23237684e-01f, -1.10308319e-01f, 7.35033676e-02f, -3.48097421e-02f, 2.67231166e-01f, -1.74124748e-01f, 7.61269629e-02f, 9.58273187e-03f, -8.95907357e-02f,
  1.96826145e-01f, -1.06374450e-01f, -2.06216015e-02f, -1.73470333e-01f, 6.89417645e-02f, 1.05934910e-01f, -5.42404596e-03f, -5.13990745e-02f, 1.15368385e-02f, -4.73811068e-02f,
  1.43467918e-01f, 1.39414176e-01f, 1.52653024e-01f, -1.39379293e-01f, -6.87725693e-02f, 1.03108101e-01f, 8.49790350e-02f, 5.16294874e-02f, 6.14521019e-02f, 8.77337903e-02f,
  6.96435571e-02f, -1.20988665e-02f, -1.13109976e-01f, 7.16912560e-03f, -7.50771537e-02f, 1.18905297e-02f, -1.35692298e-01f, 3.46273966e-02f, 6.56033456e-02f, 9.58652869e-02f,
  1.22761212e-01f, 8.54664668e-02f, 1.12515120e-02f, 1.67405635e-01f, 2.67142616e-03f, -6.97103236e-03f, 8.29649798e-04f, -1.50987972e-02f, 8.40445980e-02f, -8.50482881e-02f,
  -6.24833144e-02f, 6.06774054e-02f, -9.45238769e-03f, 6.46108091e-02f, -1.37452164e-03f, 8.36229883e-03f, 4.77843406e-03f, -4.15416770e-02f, -1.90385371e-01f, 1.08501598e-01f,
  1.24805860e-01f, 1.89765781e-01f, 3.50651257e-02f, -8.52802247e-02f, 1.29561990e-01f, 1.45210892e-01f, -9.75114703e-02f, -4.52703377e-03f, 3.19385007e-02f, 1.93833858e-01f,
  -6.07945286e-02f, 4.80738468e-02f, -4.82734926e-02f, -7.50968307e-02f, 2.29489461e-01f, 1.83704309e-02f, 4.46419828e-02f, -1.26137510e-01f, -1.74269721e-01f, 1.67657331e-01f,
  4.28872257e-02f, 1.45925224e-01f, 5.31565510e-02f, -1.15055494e-01f, -4.73985597e-02f, 1.20241366e-01f, -4.19281013e-02f, -2.46063873e-01f, -5.73583581e-02f, -8.29580054e-02f,
  4.72754836e-02f, -2.20803246e-02f, 2.53903121e-02f, 2.32978482e-02f, -7.92393088e-02f, 3.56992073e-02f, 7.48331472e-02f, 7.07438886e-02f, -1.81254689e-02f, 1.42045155e-05f,
  -7.10701197e-02f, -3.58503237e-02f, 6.45307153e-02f, 1.20762110e-01f, -5.08624725e-02f, -2.14167759e-02f, -6.70736060e-02f, -2.61575785e-02f, -2.46488415e-02f, 1.20679535e-01f,
  2.04979293e-02f, -1.31373659e-01f, 1.25650197e-01f, -2.07047220e-02f, -7.63154998e-02f, -1.17004335e-01f, 2.60110609e-02f, -1.11866400e-01f, 2.19436511e-02f, -2.30926499e-02f,
  1.65728688e-01f, 4.30783108e-02f, -7.10216165e-02f, 8.09125379e-02f, -1.33387983e-01f, 8.93457234e-02f, -9.54278484e-02f, -1.17352694e-01f, 1.69231415e-01f, 1.88111588e-01f,
  -1.58275604e-01f, -4.09652032e-02f, -6.17461540e-02f, 2.14966089e-01f, -2.04997540e-01f, 2.59427782e-02f, -8.54292735e-02f, 8.54216237e-03f, 1.84573621e-01f, 1.12086339e-02f,
  -1.08672909e-01f, -8.05367082e-02f, -1.79058686e-02f, 6.53064400e-02f, 3.63340718e-03f, -1.28757441e-03f, -1.17143676e-01f, 1.18385158e-01f, 1.84476376e-01f, 8.15534294e-02f,
  4.76185977e-02f, -1.62404209e-01f, -3.87548581e-02f, 7.12867528e-02f, 1.06419012e-01f, -4.98253480e-02f, 9.63400304e-02f, 9.97143313e-02f, 6.84800446e-02f, 1.14755202e-02f,
  -3.58574167e-02f, 2.50026137e-02f, 6.27980800e-04f, 5.89830428e-02f, -8.19975585e-02f, 6.90478310e-02f, -2.78551448e-02f, -1.21856900e-02f, -3.31367478e-02f, -5.15884124e-02f,
  1.02466173e-01f, 1.53556755e-02f, 1.14056595e-01f, 2.95093413e-02f, -2.17448268e-03f, 8.63590464e-02f, -2.76734699e-02f, 4.47773077e-02f, 9.21410471e-02f, 8.23052973e-02f,
  5.93866929e-02f, -2.86018364e-02f, 3.32709700e-02f, 1.88929856e-01f, -2.99283564e-02f, 2.62147859e-02f, -1.22036457e-01f, -5.84815852e-02f, 1.75217271e-01f, -7.87105858e-02f,
  2.42370829e-01f, 1.77818492e-01f, 2.03144446e-01f, -2.72597969e-02f, -1.88014004e-02f, -7.18986094e-02f, -3.86011228e-02f, -4.74003069e-02f, -1.39490932e-01f, 1.59942985e-01f,
  2.51853783e-02f, 6.83719441e-02f, -9.54777598e-02f, 1.03277817e-01f, 8.78121331e-02f, 1.37437126e-02f, 1.12688765e-01f, 2.61300821e-02f, 4.40937690e-02f, -1.02337085e-01f,
  1.60912499e-01f, 4.83554155e-02f, 3.44839841e-02f, 2.41073361e-03f, -3.11795641e-02f, 1.24117555e-02f, 2.01846182e-01f, -1.08348653e-02f, -1.85884833e-01f, -5.47612943e-02f,
  7.53681585e-02f, -3.21167312e-03f, -5.51807694e-03f, -2.93573495e-02f, 2.67248368e-04f, -1.22491315e-01f, -8.11377317e-02f, -8.43116827e-03f, -1.20279685e-01f, -1.65863764e-02f,
  -5.09365872e-02f, -1.28845973e-02f, -5.92104495e-02f, -9.84900817e-03f, -3.26778293e-02f, 5.59742562e-02f, 2.80862618e-02f, 3.38492990e-02f, -1.00494429e-01f, -8.99311751e-02f,
  5.14765568e-02f, -1.07039444e-01f, -1.71526298e-02f, -2.12588217e-02f, 2.22960822e-02f, -6.17839396e-02f, 9.77508053e-02f, -3.25171128e-02f, 1.00056775e-01f, -1.09169073e-02f,
  -1.27000228e-01f, 1.05906270e-01f, 3.26039679e-02f, 1.21971138e-01f, 6.69085011e-02f, -9.11817104e-02f, 1.21667303e-01f, 5.64682372e-02f, -1.71360627e-01f, -3.95146832e-02f,
  -6.21924587e-02f, 2.10964799e-01f, -1.18558921e-01f, 6.15941994e-02f, -7.06240162e-02f, -5.96723240e-03f, 1.84162155e-01f, -6.92936704e-02f, -3.95174399e-02f, -1.01185560e-01f,
  -1.26600014e-02f, -3.34903337e-02f, 2.99047008e-02f, -9.91420746e-02f, 7.08552673e-02f, 5.59678897e-02f, 7.99905285e-02f, 6.51586577e-02f, -1.77392736e-02f, -2.19065368e-01f,
  -9.95251313e-02f, -3.85956839e-02f, 4.54339832e-02f, 2.82221544e-03f, 8.85484368e-02f, -7.40164518e-02f, -6.51846454e-02f, 1.20084360e-02f, 9.07473192e-02f, -5.85159175e-02f,
  -5.03275031e-03f, 2.62294449e-02f, 7.49049187e-02f, -5.79843111e-02f, -6.91914186e-02f, 8.79771411e-02f, -6.10754490e-02f, -8.21959518e-04f, -5.53636327e-02f, -1.25039637e-01f,
  -9.04224366e-02f, -2.28813458e-02f, 5.89645728e-02f, 3.82040180e-02f, 4.71126698e-02f, 1.26487680e-03f, -5.95328733e-02f, -1.26410335e-01f, -3.09281107e-02f, -3.32148969e-02f,
  -1.10709511e-01f, -1.27615243e-01f, 5.40972836e-02f, 1.77739337e-02f, 9.36032832e-02f, 7.46241361e-02f, -2.09371716e-01f, 2.05668762e-01f, -2.47994348e-01f, -1.15367897e-01f,
  -1.38926432e-01f, -3.69490311e-02f, -5.63702406e-03f, 7.56699815e-02f, 1.08171865e-01f, 1.23025380e-01f, 5.15642622e-03f, -7.02032298e-02f, 1.50700314e-02f, -9.05451551e-02f,
  1.31935373e-01f, 5.65290172e-03f, -5.27832955e-02f, -3.90276536e-02f, -7.08258571e-03f, -6.83278888e-02f, -6.80635218e-03f, 1.34236336e-01f, -7.47714415e-02f, 2.35482790e-02f,
  1.86036035e-01f, 1.50274515e-01f, 3.81415673e-02f, 8.64739493e-02f, -1.28809884e-01f, 2.98099127e-02f, 1.06777482e-01f, 4.48123217e-02f, -6.36731312e-02f, -5.00946529e-02f,
  7.34715909e-02f, 7.34730065e-02f, 6.63620904e-02f, -1.18688019e-02f, 1.62840694e-01f, -1.76690705e-02f, 8.70042667e-02f, 2.55478136e-02f, 1.18454650e-01f, 1.77131803e-03f,
  7.08188713e-02f, 5.85061163e-02f, -3.27130370e-02f, 9.59741920e-02f, -7.93859456e-03f, 6.43279627e-02f, -5.01668314e-03f, 4.27621491e-02f, -3.05336732e-02f, -6.23387359e-02f,
  1.11550093e-01f, 2.63042245e-02f, 3.96274664e-02f, -6.86341301e-02f, -4.94575389e-02f, 6.17317148e-02f, 5.26272319e-02f, 9.27132815e-02f, -1.45873234e-01f, -5.73450923e-02f,
  -6.74657449e-02f, -1.29285261e-01f, -6.37107268e-02f, 7.66465962e-02f, -5.47101125e-02f, -1.06231928e-01f, -1.46127880e-01f, 1.42285461e-02f, -1.22002706e-01f, -4.75778319e-02f,
  6.76876605e-02f, -4.78478801e-03f, -5.24492487e-02f, 9.95180532e-02f, -1.47931546e-01f, -1.27469987e-01f, -1.58707365e-01f, 7.07239360e-02f, -1.92968011e-01f, 9.33986455e-02f,
  6.32775128e-02f, -1.34888038e-01f, 3.67436036e-02f, 1.26328439e-01f, -1.70053557e-01f, -1.18969353e-02f, 1.69858024e-01f, -3.29244137e-02f, 4.51341048e-02f, 7.40826130e-02f,
  1.13825396e-01f, -2.74566445e-03f, 1.53599307e-01f, 6.57167882e-02f, 6.38346225e-02f, 5.42542711e-02f, 1.14544868e-01f, 3.66841145e-02f, -1.01664796e-01f, 8.34335014e-02f,
  -7.11413398e-02f, -3.46880592e-02f, -6.06581941e-02f, 1.93828065e-02f, -7.00112730e-02f, -1.71851087e-02f, 7.02151507e-02f, -3.18709128e-02f, -9.67845842e-02f, 2.29066014e-02f,
  1.90539397e-02f, -5.59394918e-02f, -7.13182986e-02f, -9.51035544e-02f, 1.84381511e-02f, -7.44623393e-02f, -2.96738558e-02f, -1.83596402e-01f, 9.77050737e-02f, -1.21974550e-01f,
  -2.07230588e-03f, 1.48608059e-01f, 7.09492937e-02f, -1.54138252e-01f, -1.35318115e-01f, 1.36481062e-01f, 8.07655081e-02f, 7.03717545e-02f, 9.15780813e-02f, -5.08955903e-02f,
  -1.15275271e-01f, -8.45124274e-02f, 3.04567926e-02f, -5.14759161e-02f, -5.30768409e-02f, -4.28296849e-02f, -1.31814986e-01f, 1.55111432e-01f, -2.36059427e-02f, -9.30284187e-02f,
  -6.58028200e-02f, -1.18188113e-01f, -4.94316444e-02f, -1.49191916e-01f, -8.09001029e-02f, 1.18771754e-01f, 7.26921484e-02f, 1.42447902e-02f, 4.76729050e-02f, -1.20887093e-01f,
  1.09963700e-01f, 2.24579528e-01f, -2.45441925e-02f, -1.48897553e-02f, -4.82749827e-02f, 1.06251976e-02f, 2.90132500e-02f, 5.05404882e-02f, -3.67159918e-02f, -3.70988883e-02f,
  3.76498923e-02f, -4.85120565e-02f, -4.62609939e-02f, -5.92472218e-02f, -6.54058754e-02f, -6.30801916e-02f, 9.86446626e-04f, -7.80590530e-03f, -4.89579551e-02f, -1.61439343e-03f,
  2.52179685e-03f, 1.74210183e-02f, -4.32274677e-03f, 3.12199853e-02f, -1.82927940e-02f, 4.24456112e-02f, -3.85510661e-02f, -1.18454561e-01f, 1.37232188e-02f, 7.23537058e-02f,
  -4.59062234e-02f, -1.19797345e-02f, 1.58169232e-02f, 6.79381862e-02f, 7.58884102e-02f, 8.21676254e-02f, -9.51251537e-02f, -5.95461912e-02f, 3.20913307e-02f, -1.50359543e-02f,
  5.43656610e-02f, 1.46267608e-01f, 5.95656522e-02f, -4.42651212e-02f, -1.25889748e-01f, -2.19844934e-02f, -1.12489291e-01f, 2.46954709e-02f, 3.17704156e-02f, -7.53806857e-03f,
  -1.04653150e-01f, 1.16285846e-01f, 2.09019659e-03f, -1.41101092e-01f, -1.11879990e-01f, -8.50739330e-03f, -1.61761045e-01f, 8.09380598e-03f, 2.52847541e-02f, -2.73691043e-02f,
  -3.21754105e-02f, 8.45042616e-02f, -1.30112112e-01f, -6.07139356e-02f, 6.92810863e-02f, -6.69003725e-02f, 2.13226234e-03f, -1.62998028e-02f, -3.06506418e-02f, -1.52655095e-01f,
  1.03606477e-01f, 4.46188152e-02f, 5.96890692e-03f, -5.51292934e-02f, -4.35276702e-03f, -4.97422256e-02f, 2.54572555e-02f, 3.40563282e-02f, 1.86741352e-02f, -7.09983781e-02f,
  -2.82385740e-02f, -4.95896600e-02f, -1.64829195e-02f, 2.98934430e-02f, 5.82123399e-02f, -5.31189777e-02f, -9.15930048e-02f, 1.10558076e-02f, -3.63147408e-02f, -4.91166580e-03f,
  -4.74587455e-02f, -2.14167416e-01f, -1.48909576e-02f, -2.75494903e-02f, -3.71645913e-02f, -5.48353828e-02f, 5.20081781e-02f, -4.37780879e-02f, 7.77385309e-02f, 3.90698761e-02f,
  -4.25398946e-02f, -5.43060228e-02f, -1.65462300e-01f, 2.09420860e-01f, 3.71274212e-03f, 4.00728770e-02f, -3.89247499e-02f, -5.62076867e-02f, -1.49868295e-01f, -7.43328780e-02f,
  -2.01229062e-02f, 6.77851215e-02f, 1.10473610e-01f, -2.94047222e-02f, -1.51373908e-01f, 1.17985949e-01f, 7.73244426e-02f, -2.02006057e-01f, -1.21884741e-01f, -1.17020682e-01f,
  -2.47351244e-01f, 1.60376802e-02f, -4.20052633e-02f, 1.25736713e-01f, 1.00154757e-01f, -1.01866638e-02f, -1.58304662e-01f, -6.29117191e-02f, 7.44075552e-02f, 5.46477623e-02f,
  -1.43145338e-01f, -4.40127589e-02f, -8.94169435e-02f, -5.71065433e-02f, 1.09784774e-01f, 8.18348452e-02f, 7.57483467e-02f, 1.53656080e-02f, 4.10640426e-02f, 2.41840146e-02f,
  7.25369230e-02f, -5.36918491e-02f, -2.77895853e-02f, 8.97158906e-02f, 1.20066464e-01f, 5.68699054e-02f, -1.21371159e-02f, 1.07977837e-01f, 2.35022474e-02f, -5.25576510e-02f,
  -2.39453316e-02f, 1.58474762e-02f, 5.88563718e-02f, 1.53361503e-02f, -5.77821210e-02f, -7.10199773e-02f, 5.81144318e-02f, -1.02520421e-01f, -1.17378779e-01f, -1.81929946e-01f,
  -7.94334859e-02f, 5.50738350e-02f, -3.96438502e-02f, 2.47590803e-02f, -9.83093157e-02f, -7.53191486e-02f, -8.64930972e-02f, 6.44106194e-02f, -1.37455478e-01f, 6.52356222e-02f,
  3.56165506e-02f, -6.73084855e-02f, -9.87558514e-02f, 2.63647232e-02f, 3.47393602e-02f, 5.51041700e-02f, 1.15342848e-02f, -3.73073779e-02f, -1.63515046e-01f, 1.26547590e-01f,
  -6.30255183e-03f, -2.16634031e-02f, -6.49071634e-02f, -1.11643754e-01f, -2.80379325e-01f, -2.64919586e-02f, 6.67497367e-02f, 1.11071728e-01f, 1.16466016e-01f, 1.08167119e-01f,
  -1.52713716e-01f, -1.58346653e-01f, 3.07248868e-02f, 1.17127612e-01f, -7.43861496e-02f, -1.69303510e-02f, 9.12905037e-02f, -1.41754761e-01f, 7.48055205e-02f, -4.43448732e-03f,
  1.00134350e-01f, -2.60731261e-02f, -9.10795256e-02f, -3.01849432e-02f, 3.37957079e-03f, 4.12323847e-02f, -6.32284507e-02f, 1.11284817e-03f, -3.33237927e-03f, 1.79350022e-02f,
  1.17865570e-01f, 6.26977831e-02f, 1.44158192e-02f, 1.05025917e-02f, -9.82143357e-02f, 8.47702250e-02f, 2.57194713e-02f, -8.17455649e-02f, 7.40152150e-02f, 3.30364741e-02f,
  -4.80828583e-02f, -1.29323965e-02f, -1.42022157e-02f, -2.16133166e-02f, -5.23901694e-02f, -2.15546712e-02f, 1.88261475e-02f, -6.86033815e-02f, -1.39186785e-01f, 2.53621396e-02f,
  8.87916237e-02f, 1.53551042e-01f, -4.29358380e-03f, -2.82508228e-02f, 6.64021596e-02f, 7.96682015e-02f, -1.35501593e-01f, 3.81085388e-02f, -6.47080839e-02f, 1.21239178e-01f,
  -5.67770042e-02f, 7.43264183e-02f, -5.33581004e-02f, -5.80958314e-02f, 1.07181564e-01f, 3.09001468e-03f, 1.05877981e-01f, -1.63465321e-01f, -2.27456868e-01f, 9.63407457e-02f,
  -2.51421686e-02f, -1.62922349e-02f, 7.23647922e-02f, -1.53641865e-01f, -2.92092282e-03f, 5.41229099e-02f, -3.88101041e-02f, -3.49778198e-02f, -7.26827094e-03f, -3.34791765e-02f,
  -8.10758919e-02f, -1.28771245e-01f, -1.23168193e-01f, -8.80365595e-02f, -1.66078960e-03f, -3.22567485e-02f, 6.31801262e-02f, 2.14042217e-02f, 5.10592535e-02f, -3.31495553e-02f,
  6.15751706e-02f, 5.24596125e-02f, 5.93958423e-02f, 7.93249998e-03f, 1.27553232e-02f, 7.23298118e-02f, -3.70540917e-02f, -6.73086718e-02f, -6.72468310e-03f, -4.85106744e-02f,
  6.26590401e-02f, -1.86727811e-02f, -3.28244306e-02f, -5.30799143e-02f, -4.32449505e-02f, -1.12302214e-01f, -1.02082707e-01f, -6.09361343e-02f, -7.99796358e-02f, -5.30846715e-02f,
  -5.31049818e-03f, 5.21674119e-02f, 5.66573665e-02f, -1.38619933e-02f, -8.77963901e-02f, 3.17682028e-02f, -1.13287680e-01f, 3.44831981e-02f, -1.07139528e-01f, -9.36141424e-03f,
  -1.52470544e-02f, 4.26430255e-02f, 4.91705723e-02f, -8.36487859e-02f, 1.29829317e-01f, -7.55379200e-02f, 6.11729957e-02f, -1.50757832e-02f, -9.88643542e-02f, -5.40663451e-02f,
  -9.12180170e-02f, 5.57601117e-02f, -7.01872557e-02f, -9.84641761e-02f, -3.94009538e-02f, 3.06800231e-02f, -3.92653942e-02f, -1.74284615e-02f, 1.39286006e-02f, 9.34533961e-03f,
  8.01018625e-02f, 1.33017197e-01f, -1.12086155e-01f, 5.36460727e-02f, 1.08098708e-01f, -6.11437596e-02f, 4.07168604e-02f, -3.70693915e-02f, 1.36339694e-01f, -2.91483030e-02f,
  -5.85607365e-02f, 6.01622202e-02f, 3.06733008e-02f, -4.91858199e-02f, -8.68397206e-03f, 1.01075307e-01f, 1.49518149e-02f, -1.49009330e-02f, 7.94645697e-02f, -1.28060738e-02f,
  3.15525979e-02f, -4.33059270e-03f, 2.21011601e-02f, 8.52759406e-02f, 1.11285578e-02f, -3.75436097e-02f, -1.75051782e-02f, 1.03220619e-01f, -5.79658188e-02f, -2.40869578e-02f,
  9.80934054e-02f, 6.77457154e-02f, -5.39914370e-02f, -3.73932607e-02f, -2.02725127e-01f, -1.15599453e-01f, -3.63930613e-02f, 1.96091551e-02f, 1.85772851e-01f, 1.54004857e-01f,
  -6.81084348e-03f, -3.93873006e-02f, -1.58172119e-02f, 3.31626125e-02f, 1.65541675e-02f, 9.63461474e-02f, -1.94194471e-03f, -5.06570786e-02f, 1.85783133e-02f, 1.71159342e-01f,
  1.02826864e-01f, -2.57692896e-02f, 3.21842469e-02f, 1.53962910e-01f, 2.30024859e-01f, -1.62124068e-01f, -1.48135692e-01f, 1.09109148e-01f, -1.54507896e-02f, 1.28336757e-01f,
  1.08850963e-01f, -1.38538092e-01f, 1.46080088e-02f, 7.35356193e-03f, -1.69746816e-01f, 1.96273863e-01f, -2.58047674e-02f, -7.03138113e-02f, -2.53178719e-02f, -6.93317205e-02f,
  -2.71784533e-02f, 7.78805604e-03f, -9.21065062e-02f, -4.88647744e-02f, 1.16063930e-01f, -5.70652112e-02f, -1.03035353e-01f, 4.31151725e-02f, -1.30891316e-02f, -5.52406944e-02f,
  -5.15880585e-02f, -2.76293289e-02f, 6.07357407e-03f, -1.18365865e-02f, -1.07042603e-02f, -4.21410464e-02f, 4.56489325e-02f, 2.55099051e-02f, -5.75478375e-02f, 6.84919953e-02f,
  7.27020353e-02f, -1.70957595e-02f, 2.88079157e-02f, -5.41133694e-02f, -3.64897698e-02f, 1.33841648e-03f, 1.12608299e-02f, -8.56615305e-02f, -3.91486920e-02f, -5.13068400e-02f,
  8.26405883e-02f, -6.05349839e-02f, -4.80539054e-02f, 1.37773946e-01f, 1.98076725e-01f, 1.24314420e-01f, 1.41357720e-01f, 9.96939912e-02f, 1.43311629e-02f, 1.64834503e-02f,
  1.11143999e-01f, 3.74253280e-02f, -3.92062068e-02f, 6.21253252e-02f, 6.37882799e-02f, -4.60328385e-02f, 5.64952418e-02f, -3.84085663e-02f, 2.96832975e-02f, -5.65622188e-02f,
  1.50321871e-01f, -1.03953518e-01f, -1.30143926e-01f, 7.85169452e-02f, 1.56595886e-01f, -1.99464574e-01f, 1.43768027e-01f, 1.00121416e-01f, 6.47858623e-03f, 1.32831082e-01f,
  -1.05067581e-01f, 2.74138292e-03f, -1.05875716e-01f, 8.32053572e-02f, -6.74057892e-03f, -7.53159076e-02f, 7.58917481e-02f, -3.47016379e-02f, -7.55832642e-02f, -1.63728232e-03f,
  2.30030203e-03f, 7.26432912e-03f, 2.11793017e-02f, 1.31893894e-02f, 9.00560711e-03f, -4.97672036e-02f, 6.40713349e-02f, 1.25194807e-02f, -5.39340600e-02f, -6.35993779e-02f,
  -4.68249358e-02f, 1.39981257e-02f, -3.25890630e-02f, -4.34853174e-02f, 2.46871170e-02f, 9.51286405e-02f, -2.49256771e-02f, -7.26113170e-02f, -2.48013152e-04f, 2.82363761e-02f,
  -7.15797022e-02f, -3.83764803e-02f, -1.10583432e-01f, -2.82392818e-02f, 6.94220066e-02f, -1.27887167e-02f, 4.95776869e-02f, -1.12951165e-02f, -4.81056012e-02f, -6.36782870e-02f,
  -5.34029156e-02f, -3.92620787e-02f, 1.01366356e-01f, 3.77302989e-02f, 4.95926179e-02f, -1.27103537e-01f, 8.69705826e-02f, 1.02788709e-01f, 1.45459518e-01f, -7.15407282e-02f,
  -1.20784014e-01f, 1.25208944e-01f, 1.22140445e-01f, 6.77137729e-03f, -1.18168704e-02f, -2.99821068e-02f, -5.28191850e-02f, -1.30094886e-02f, 3.12009733e-02f, -1.59045309e-01f,
  -3.64105105e-02f, -4.02730284e-03f, -1.07138410e-01f, 1.65311217e-01f, 2.35989857e-02f, -7.50776893e-03f, -1.77993271e-02f, 5.95233478e-02f, 9.80545431e-02f, 1.23790270e-02f,
  7.60143772e-02f, 4.29292805e-02f, -6.57882094e-02f, 6.66053668e-02f, 7.27170482e-02f, 5.20274751e-02f, -9.81696993e-02f, 1.31701678e-01f, -2.18911842e-03f, 7.47046247e-03f,
  3.23957801e-02f, 8.45325440e-02f, 6.80273026e-02f, 7.83346370e-02f, 5.59843071e-02f, -5.15930802e-02f, 8.52989852e-02f, 6.05567247e-02f, -2.34831367e-02f, 8.45645443e-02f,
  1.24716256e-02f, 9.15384442e-02f, 3.40475254e-02f, -5.92376590e-02f, 3.94028760e-02f, 3.68200876e-02f, -7.27309957e-02f, -8.19713697e-02f, -8.09260979e-02f, -2.36694259e-03f,
  7.76926875e-02f, -2.05818340e-01f, 1.66830905e-02f, 6.67647049e-02f, 3.55168097e-02f, -7.97315389e-02f, 5.29168360e-02f, -7.60061666e-02f, -1.55847725e-02f, -1.42906606e-01f,
  -7.19394535e-02f, -3.48620079e-02f, -1.31761860e-02f, 2.78801471e-03f, -9.08371434e-02f, 1.57323286e-01f, 6.06237128e-02f, -1.01039037e-02f, -6.49185404e-02f, 1.23311408e-01f,
  5.52900694e-02f, 1.91269852e-02f, -7.81015009e-02f, 2.05307994e-02f, -1.44800916e-01f, -1.46963328e-01f, -1.14722908e-01f, -1.03955790e-01f, 1.21914856e-01f, -6.14658855e-02f,
  -3.62692736e-02f, -1.36053652e-01f, -1.15689486e-01f, -2.38753203e-03f, -1.10759780e-01f, 2.99853622e-03f, 5.09548485e-02f, -2.20836010e-02f, -5.60850948e-02f, -1.42138880e-02f,
  -3.50045483e-03f, -6.57940507e-02f, -3.13756205e-02f, -7.89405331e-02f, -2.15595812e-02f, -8.89298692e-02f, 3.01759616e-02f, 8.32106620e-02f, 5.76391071e-02f, -6.91520050e-02f,
  -7.15792403e-02f, 1.50299864e-02f, 2.72183977e-02f, 6.33146763e-02f, 4.93701026e-02f, 6.31856024e-02f, 1.99731607e-02f, 3.96620929e-02f, 1.14781938e-01f, 1.14952765e-01f,
  4.96148579e-02f, 7.14857131e-02f, -1.05074145e-01f, -6.80888891e-02f, 1.03051990e-01f, -2.17906326e-01f, 1.77546233e-01f, 1.00467883e-01f, 7.17911199e-02f, -4.50744592e-02f,
  -1.51962172e-02f, -7.09509552e-02f, -1.33805677e-01f, -2.34741587e-02f, -2.40572859e-02f, 5.58528788e-02f, -1.59197040e-02f, 3.25017571e-02f, -9.93660390e-02f, -6.07250929e-02f,
  -2.48478949e-02f, 1.26772821e-01f, 8.58094022e-02f, 2.50474811e-02f, -1.91645063e-02f, -1.69192657e-01f, -7.92877153e-02f, 4.59345505e-02f, -5.75555414e-02f, -1.02078542e-01f,
  8.21106434e-02f, -9.45027098e-02f, 1.37822375e-01f, 6.72207400e-02f, -1.02458753e-01f, -4.23643664e-02f, 1.07176289e-01f, 5.12873940e-02f, -1.63364522e-02f, 6.85008988e-02f,
  -2.54713800e-02f, 1.13887966e-01f, 2.07220130e-02f, 5.44287488e-02f, -4.45203036e-02f, 2.72056647e-02f, 8.02586451e-02f, 1.42573535e-01f, -3.42979766e-02f, 8.40125531e-02f,
  2.55841855e-02f, 5.06164767e-02f, -2.73823850e-02f, 1.21506460e-01f, 5.59301674e-03f, -6.47415370e-02f, 2.97871679e-02f, 1.00994930e-01f, 1.98302716e-02f, -6.31032810e-02f,
  5.60496636e-02f, -2.13493761e-02f, 1.09416768e-02f, 1.53938038e-02f, 1.87377810e-01f, -1.24858762e-03f, 1.51817910e-02f, 8.68081599e-02f, -1.08971886e-01f, 1.60348397e-02f,
  -1.13386706e-01f, -1.63226768e-01f, 6.92293420e-02f, 7.52327219e-02f, -5.89845181e-02f, 4.65723835e-02f, 1.49388732e-02f, 1.75445750e-01f, -1.79266512e-01f, -3.40360403e-02f,
  -1.70278456e-02f, -1.28317708e-02f, 1.90240458e-01f, -6.99811056e-02f, -1.00958720e-01f, -9.48570818e-02f, 4.09736298e-02f, 1.10502705e-01f, 8.11193958e-02f, 4.35007922e-02f,
  -1.68135852e-01f, 9.21698064e-02f, 1.18455179e-01f, 7.15048611e-02f, 1.49679348e-01f, -2.79410481e-01f, 4.10415195e-02f, 6.40696883e-02f, 1.53616443e-01f, 4.73110415e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -3.63978222e-02f, -9.79401246e-02f, 3.95448394e-02f, -1.59105416e-02f, -1.80787787e-01f, 1.63075715e-01f, 1.49909228e-01f, -6.22315593e-02f, 3.81531864e-02f, 1.17492743e-01f,
  1.22287042e-01f, 5.57196476e-02f, 1.52657926e-01f, 3.04686148e-02f, -3.82129960e-02f, 1.62805915e-01f, 1.94913317e-02f, 4.56338711e-02f, 6.09481037e-02f, -3.26401033e-02f,
  8.59277919e-02f, 1.95516318e-01f, -4.69150282e-02f, 1.00365452e-01f, 7.13950321e-02f, 2.20985547e-01f, -1.54717386e-01f, 1.01249859e-01f, -1.82451248e-01f, -2.36158550e-01f,
  -1.20718949e-01f, 1.95757613e-01f, 2.13886753e-01f, -1.42445490e-01f, -1.31488755e-01f, -1.84462160e-01f, -3.38042863e-02f, 1.12366207e-01f, 1.32101744e-01f, 1.65785536e-01f,
  3.88838015e-02f, 6.04826994e-02f, -5.83355129e-02f, 2.37006228e-02f, 1.09664753e-01f, -9.79370996e-02f, 1.08103625e-01f, 2.56670862e-01f, 1.01344109e-01f, -2.58472878e-02f,
  -4.03700061e-02f, 2.60200888e-01f, 2.26998419e-01f, 4.27336730e-02f, -1.57154307e-01f, -1.17392547e-01f, 1.95980202e-02f, 1.84888080e-01f, -6.81815371e-02f, -2.26619691e-01f,
  1.74274534e-01f, -1.95041625e-03f, 2.09048212e-01f, 1.05206557e-01f, 2.11301282e-01f, 2.51377910e-01f, 1.08220898e-01f, 9.88282114e-02f, 9.17746872e-02f, -1.92378589e-03f,
  -3.36475321e-04f, -5.34626050e-03f, -1.26635998e-01f, 2.55528605e-03f, -3.32933441e-02f, 4.04604301e-02f, -1.66017972e-02f, 2.47985832e-02f, 2.12708265e-01f, 1.07981242e-01f,
  2.04354227e-02f, 9.73388180e-02f, 9.06046294e-03f, 1.80681273e-01f, 6.52355328e-02f, -8.11742321e-02f, 1.13970287e-01f, 1.21878535e-01f, 5.47457486e-02f, -7.77817965e-02f,
  -4.98134141e-05f, 1.50641307e-01f, 2.01610243e-03f, 8.58181342e-03f, -1.84416220e-01f, -1.39207989e-01f, 5.94287664e-02f, 6.73105270e-02f, 2.19490543e-01f, 2.18843699e-01f,
  2.65217394e-01f, 7.31160492e-02f, -7.18172267e-02f, -7.63641074e-02f, -7.76016414e-02f, 5.02168052e-02f, -1.80697367e-01f, 8.00816938e-02f, -1.98992968e-01f, 1.52718112e-01f,
  1.24951936e-01f, -6.67376071e-02f, 3.63647006e-02f, -1.91687390e-01f, 4.82755862e-02f, 1.22887179e-01f, 1.29338861e-01f, 1.90083310e-01f, 2.81235486e-01f, 1.42532632e-01f,
  -2.89527699e-04f, 5.14425598e-02f, 8.44612494e-02f, 1.53758228e-01f, 8.92878026e-02f, -6.95722252e-02f, -6.83358386e-02f, 6.94888411e-03f, 1.99508935e-01f, 1.72312871e-01f,
  5.85410073e-02f, 1.02655895e-01f, -1.66139659e-02f, 5.89245185e-02f, -2.12559886e-02f, 8.71027913e-03f, -1.64712951e-01f, 2.68458631e-02f, -2.22691447e-02f, 1.09502420e-01f,
  1.29123209e-02f, 5.82958981e-02f, 1.65203378e-01f, 1.05130158e-01f, 8.27480406e-02f, 3.43975797e-02f, -3.31437588e-02f, 9.82449502e-02f, 1.33814380e-01f, -2.08680332e-02f,
  -1.51439644e-02f, 1.10580377e-01f, 9.48199034e-02f, -4.24180701e-02f, -5.38500734e-02f, 7.76511580e-02f, -4.20647860e-02f, -6.80038556e-02f, -1.78065777e-01f, 3.48803587e-02f,
  2.08344951e-01f, 4.55189236e-02f, 1.49532259e-01f, 2.73907986e-02f, 2.42314517e-01f, 1.13880403e-01f, -2.70616505e-02f, 4.08980772e-02f, 8.84461030e-03f, 1.40059605e-01f,
  -2.34437302e-01f, 1.70015454e-01f, -7.40116537e-02f, 1.77846253e-02f, 2.15506867e-01f, 8.56903568e-02f, 1.51994914e-01f, -1.92848399e-01f, -2.63071675e-02f, 2.04519182e-01f,
  9.12114382e-02f, 1.53346628e-01f, 1.63827017e-01f, -6.45926222e-02f, 1.02536634e-01f, 1.72028273e-01f, -6.56933486e-02f, -6.95577934e-02f, 1.26578584e-01f, -7.73883685e-02f,
  -3.65810283e-02f, 7.47369230e-03f, 6.71548024e-02f, 1.57723367e-01f, 1.92851409e-01f, -7.41612865e-03f, -3.55693921e-02f, 3.55982371e-02f, 4.96689081e-02f, 1.43575773e-01f,
  -2.94015035e-02f, 4.84296456e-02f, 1.60589255e-02f, 8.27142224e-02f, 1.50777847e-01f, 9.77979079e-02f, 9.92408991e-02f, 1.23973168e-01f, 1.01112284e-01f, 6.48784041e-02f,
  2.08994709e-02f, 6.97307363e-02f, 1.17521055e-01f, 1.95212796e-01f, -4.41897660e-03f, 1.07237704e-01f, 1.06474020e-01f, -3.99967618e-02f, -3.08103170e-02f, 1.33886486e-01f,
  -1.63522869e-01f, -1.49921536e-01f, -1.35411799e-01f, -1.56509131e-01f, 3.44109923e-01f, -1.42353505e-01f, 3.19600761e-01f, 2.60786712e-01f, 2.57799119e-01f, 1.33729652e-01f,
  1.82303995e-01f, 1.29817262e-01f, 1.87586676e-02f, -1.65247515e-01f, -2.18559772e-01f, 3.25755239e-01f, 1.65526226e-01f, -5.48832305e-02f, -1.64574400e-01f, 3.16665202e-01f,
  3.01835597e-01f, -1.09907933e-01f, 1.07454546e-01f, 1.18222252e-01f, 1.12928063e-01f, 1.79556583e-03f, 1.01994731e-01f, -1.38473287e-01f, -3.74277830e-02f, 8.37495364e-03f,
  -2.20175385e-01f, 2.04353094e-01f, 1.83466092e-01f, -4.01044171e-03f, -2.22420603e-01f, -8.30654427e-02f, 2.21286371e-01f, 9.14302617e-02f, 1.03929922e-01f, 1.42123159e-02f,
  7.47690648e-02f, 1.54239878e-01f, 4.99863103e-02f, -6.45356178e-02f, -5.30538708e-02f, 1.09559044e-01f, 1.84651628e-01f, 1.28394946e-01f, -6.82069175e-03f, 1.67992219e-01f,
  1.33479223e-01f, 1.44005209e-01f, -1.27966348e-02f, 9.23424810e-02f, 4.60425988e-02f, 1.59342196e-02f, 4.97936979e-02f, -1.07388265e-01f, -2.55818404e-02f, -1.21172052e-03f,
  7.12492410e-03f, -8.79262313e-02f, -8.34813491e-02f, 6.14664629e-02f, 8.63258839e-02f, 7.05368817e-02f, -2.10917518e-01f, 6.06526658e-02f, -8.77956226e-02f, 2.14054018e-01f,
  -1.35225862e-01f, -1.18533753e-01f, 9.97732133e-02f, 9.84213352e-02f, -1.49595097e-01f, 2.04970222e-02f, 1.35031538e-02f, 2.74330199e-01f, -9.30783376e-02f, -6.67881370e-02f,
  -2.33226731e-01f, 4.51063514e-02f, 2.06706926e-01f, -5.55158816e-02f, -7.46347979e-02f, -1.85498700e-01f, -1.83758020e-01f, 1.21703640e-01f, 2.40133986e-01f, 1.94921538e-01f,
  3.71846221e-02f, 1.63437158e-01f, 5.12578078e-02f, 1.56344727e-01f, 1.41270280e-01f, -2.83985704e-01f, -9.91249573e-04f, -3.30368355e-02f, 3.07921112e-01f, -8.09540376e-02f,
  2.23447636e-01f, 1.94612235e-01f, 6.44044206e-02f, 9.08063203e-02f, 1.09255791e-01f, -2.82316003e-02f, 9.90612954e-02f, 2.29093358e-02f, -1.46237642e-01f, 1.26417100e-01f,
  2.76161637e-03f, -6.05031801e-03f, 5.51792197e-02f, 1.07805192e-01f, 1.68674096e-01f, 6.87905177e-02f, 1.23725189e-02f, 1.19454980e-01f, 5.88902719e-02f, 1.19396999e-01f,
  5.41686006e-02f, -2.40533929e-02f, 5.34404553e-02f, 1.17884584e-01f, -1.79104954e-02f, -1.72178537e-01f, -4.21831422e-02f, 6.22079633e-02f, 3.71273831e-02f, 4.89525869e-02f,
  -1.31465808e-01f, -1.23963602e-01f, 8.37867260e-02f, 2.10650980e-01f, 1.84343606e-01f, 9.31535661e-02f, 2.48775691e-01f, 1.00179821e-01f, -1.63607195e-01f, 2.78639663e-02f,
  4.47914377e-03f, 7.02072978e-02f, -1.46987841e-01f, 2.07489371e-01f, -1.00317374e-01f, 1.77320227e-01f, 1.34797648e-01f, -5.49185015e-02f, 2.57902928e-02f, -1.91349939e-01f,
  -9.44311842e-02f, 1.51425585e-01f, 1.21857077e-02f, 1.58133551e-01f, 2.92402625e-01f, -6.21190220e-02f, 1.08712584e-01f, 6.01747818e-02f, 4.10487354e-02f, 1.50986835e-01f,
  3.36431265e-02f, -5.58656529e-02f, -1.12260982e-01f, -3.71120647e-02f, 1.06188171e-02f, 1.36317775e-01f, 4.50614505e-02f, 1.37195066e-01f, 6.21213391e-02f, 1.19869314e-01f,
  1.83071762e-01f, 3.67840156e-02f, 1.28916159e-01f, 5.12770824e-02f, 3.93131897e-02f, 1.52882531e-01f, 7.45206103e-02f, 1.18139125e-01f, 1.37201592e-01f, 1.26525387e-01f,
  1.44062102e-01f, 1.56129032e-01f, 3.38498577e-02f, 1.50510684e-01f, -5.78615852e-02f, 1.80425346e-01f, 1.25232697e-01f, 6.61514401e-02f, 1.95941225e-01f, 1.16374735e-02f,
  -2.38217656e-02f, 1.68191314e-01f, 3.77994357e-03f, -4.53410856e-03f, -2.64988262e-02f, -6.45846948e-02f, 3.54869589e-02f, -4.25555080e-01f, -5.58887459e-02f, 1.50682449e-01f,
  -1.71429105e-02f, -2.70499408e-01f, 5.07584214e-02f, -1.21229559e-01f, -2.21186802e-01f, -2.21419260e-01f, -1.31374061e-01f, 1.83731690e-02f, -8.08688104e-02f, 6.82428852e-02f,
  -2.54546672e-01f, 8.34715590e-02f, -6.39724061e-02f, 2.78980523e-01f, 6.49754032e-02f, 1.37140602e-01f, 1.97350845e-01f, -1.83155715e-01f, -2.34760910e-01f, 3.39138865e-01f,
  -1.43972725e-01f, -3.66263688e-02f, 5.14576398e-02f, -3.84093933e-02f, 4.18459028e-01f, 9.08353850e-02f, 5.72033450e-02f, -1.61844995e-02f, 1.47842700e-02f, -4.08886932e-02f,
  1.43195745e-02f, -2.39247847e-02f, -1.58422261e-01f, 7.66216293e-02f, 2.22906712e-02f, -3.03660668e-02f, 4.91271773e-03f, 6.17369600e-02f, 2.65993904e-02f, 4.97701317e-02f,
  5.46600372e-02f, -2.83852927e-02f, -2.60595605e-02f, -1.88879278e-02f, 7.38892704e-02f, -1.53269898e-03f, 6.47125840e-02f, 2.22404134e-02f, 1.14530168e-01f, 2.09534809e-01f,
  -1.12025715e-01f, 5.00497967e-02f, 7.65134916e-02f, 1.75254658e-01f, -9.05228257e-02f, -6.46922924e-03f, -2.27326438e-01f, -2.90906519e-01f, 2.65848525e-02f, 1.78904712e-01f,
  2.86569268e-01f, -3.82762142e-02f, -5.18586300e-02f, -1.40307754e-01f, -3.24383029e-03f, 8.68854448e-02f, 2.49350324e-01f, 1.18665963e-01f, 8.98281559e-02f, -6.21709786e-03f,
  -7.24046901e-02f, 5.43852746e-02f, 2.04188704e-01f, -2.02046037e-01f, 4.38438058e-02f, 4.54665989e-01f, 3.18937391e-01f, -3.25897262e-02f, 1.83252558e-01f, 2.98262894e-01f,
  1.80115268e-01f, 1.51024461e-01f, -8.53878632e-02f, -7.37739876e-02f, 1.64749488e-01f, 2.56486773e-01f, -2.67055511e-01f, -1.71956629e-01f, 6.47551864e-02f, -6.66295514e-02f,
  1.21844925e-01f, 1.27447397e-01f, -7.92024285e-02f, -1.28161475e-01f, -4.55973372e-02f, 2.33112518e-02f, 1.26743808e-01f, -1.47279575e-02f, -3.13958712e-02f, 6.59990236e-02f,
  1.25123218e-01f, 2.57809344e-03f, 9.81263369e-02f, 6.47632927e-02f, 3.86205725e-02f, 4.77975011e-02f, -9.54769459e-03f, 3.33952941e-02f, 3.67588848e-02f, 7.98024386e-02f,
  8.63515884e-02f, -2.27847155e-02f, 5.79638183e-02f, -2.94450801e-02f, 4.13180068e-02f, 6.04227670e-02f, 4.38916907e-02f, 1.41780511e-01f, -1.53626323e-01f, -1.96861073e-01f,
  1.00985035e-01f, 4.17418443e-02f, 2.32719690e-01f, -1.90069973e-02f, -2.10145772e-01f, 1.21607631e-01f, -2.53881663e-01f, -6.09655082e-02f, -2.13058069e-01f, 1.12190969e-01f,
  1.54322967e-01f, 1.25024647e-01f, 1.30478933e-01f, 1.25068113e-01f, 1.38084933e-01f, -1.20831423e-01f, 1.10791184e-01f, -1.00038141e-01f, -8.76638107e-03f, -1.75685436e-01f,
  -1.51222751e-01f, 4.84422669e-02f, 2.49423474e-01f, 6.07116967e-02f, -7.25210980e-02f, 6.09628111e-02f, -4.64009866e-02f, -5.24404757e-02f, 2.74832994e-01f, 2.33052105e-01f,
  2.61630952e-01f, 1.31056115e-01f, -2.02441171e-01f, 1.55837879e-01f, 1.43087834e-01f, 3.13806176e-01f, -1.09673522e-01f, -2.21526008e-02f, 1.04704112e-01f, 5.77461571e-02f,
  9.15867388e-02f, 1.29402444e-01f, 1.41019002e-01f, 2.18738746e-02f, 1.36816993e-01f, 1.33070037e-01f, 5.90328500e-02f, -9.45107266e-03f, 1.78510204e-01f, 1.25940502e-01f,
  2.21440624e-02f, 1.14148699e-01f, 4.27737907e-02f, 1.82700716e-02f, 9.96608585e-02f, 1.27505943e-01f, 1.62759889e-02f, 1.01970062e-01f, 1.01641715e-01f, 1.09183319e-01f,
  6.32943138e-02f, 3.76396701e-02f, -7.40957856e-02f, 2.65231412e-02f, -8.85835290e-02f, -9.39356163e-03f, 8.11480507e-02f, -1.16152085e-01f, 8.17816146e-03f, -2.74970472e-01f,
  -1.44133409e-02f, 2.40594104e-01f, -1.68530405e-01f, -1.24482453e-01f, 1.60155684e-01f, 3.67990769e-02f, 1.98260322e-02f, -2.82351136e-01f, 1.68551058e-01f, -1.77398417e-02f,
  8.35574940e-02f, 3.65030020e-02f, -2.96442360e-01f, -2.41865609e-02f, -6.03195988e-02f, 2.77466238e-01f, -2.70051081e-02f, 5.51336929e-02f, -7.10398564e-03f, -1.45417452e-01f,
  3.26253176e-02f, -4.44132425e-02f, -1.88815176e-01f, -4.41946797e-02f, 1.00984856e-01f, 2.27906078e-01f, 1.92922488e-01f, 9.50561240e-02f, 3.98231335e-02f, 6.97976649e-02f,
  -4.33259942e-02f, -3.28970216e-02f, 2.44237278e-02f, 4.96877022e-02f, 1.49420202e-01f, 9.00458097e-02f, 1.57688081e-01f, -1.73243359e-02f, 1.00024827e-01f, 5.77589590e-03f,
  1.74586743e-01f, 5.28093278e-02f, 3.86386774e-02f, 1.60542086e-01f, 5.27119311e-03f, -2.17368789e-02f, -6.90233707e-02f, 1.15256570e-01f, 1.47648811e-01f, 3.87191437e-02f,
  1.67320371e-02f, -4.31234054e-02f, -5.24376743e-02f, -5.91771454e-02f, -3.09661366e-02f, 1.59726869e-02f, -1.33976698e-01f, -4.72252481e-02f, 1.18829198e-01f, 3.95210572e-02f,
  5.66004477e-02f, 6.41062856e-02f, -2.64354080e-01f, 2.37200841e-01f, -3.40016454e-01f, -2.80617792e-02f, -2.04557776e-01f, 5.86379841e-02f, -4.87074181e-02f, 1.69014260e-01f,
  1.38750046e-01f, 1.17175512e-01f, 2.08258837e-01f, -2.56005108e-01f, 7.25957449e-04f, 1.17889391e-02f, 2.53058802e-02f, -7.92681500e-02f, -2.08758920e-01f, 1.80955511e-02f,
  -4.60242741e-02f, 1.00040205e-01f, 1.00665286e-01f, 2.11511850e-01f, 5.90837635e-02f, 2.33453929e-01f, 3.13900113e-02f, 8.83671045e-02f, 3.40966702e-01f, 2.19526570e-02f,
  -2.29780868e-01f, 7.58595988e-02f, 3.80251169e-01f, 1.47088781e-01f, 1.63308829e-01f, 1.90254554e-01f, -1.10316560e-01f, 2.32619867e-02f, 1.54327154e-01f, -2.96205524e-02f,
  -5.27111962e-02f, 1.70195084e-02f, -3.35477628e-02f, -4.80528511e-02f, -1.50620854e-02f, 1.04736671e-01f, -1.10955745e-01f, -6.90321475e-02f, 1.42764896e-01f, 2.73125321e-02f,
  8.87046903e-02f, 1.03384353e-01f, -2.84200981e-02f, 5.52507788e-02f, 1.34509489e-01f, -3.33175324e-02f, 2.71632448e-02f, -2.71339007e-02f, 7.55849853e-02f, -7.11733699e-02f,
  5.80815449e-02f, 2.51733791e-03f, 1.46773383e-01f, 7.15140030e-02f, 1.05763581e-02f, -6.73235953e-02f, -1.09453902e-01f, 2.07059056e-01f, 1.25506774e-01f, 6.39582872e-02f,
  2.39622191e-01f, 1.67859599e-01f, -7.42943957e-02f, 1.78377461e-02f, 4.42602783e-02f, 1.94708258e-01f, -2.11065456e-01f, -1.63916394e-03f, -4.89884838e-02f, 3.49779576e-02f,
  1.43947199e-01f, -1.22987136e-01f, -4.73130345e-02f, -1.47564143e-01f, 4.02716160e-01f, 6.77248165e-02f, 1.69719219e-01f, 1.92784205e-01f, 2.32672036e-01f, 3.27005744e-01f,
  3.18508714e-01f, 2.34279469e-01f, 2.26051956e-01f, 3.81012261e-02f, -6.45859614e-02f, 3.20568942e-02f, 1.46491900e-01f, 2.00562313e-01f, -4.76158001e-02f, -1.24075204e-01f,
  -1.22114094e-02f, -3.57925449e-03f, -9.34138335e-03f, 1.89854339e-01f, 1.58396930e-01f, 6.59381673e-02f, 1.61689401e-01f, 1.30297184e-01f, 6.55810684e-02f, 1.11744359e-01f,
  8.22206810e-02f, 5.98417260e-02f, -7.03988820e-02f, -1.06416373e-02f, 9.93270986e-03f, 2.64372453e-02f, 9.26168114e-02f, 2.93640606e-02f, 1.77489445e-01f, 1.54077321e-01f,
  -8.27714875e-02f, 4.41967100e-02f, 2.97977980e-02f, 2.12573424e-01f, -2.17648447e-01f, -1.43429816e-01f, -1.80404410e-01f, -1.84362590e-01f, 1.26725569e-01f, 1.03486955e-01f,
  6.70071021e-02f, 6.14000000e-02f, -2.43187338e-01f, -1.95095107e-01f, -1.73964038e-01f, 1.51881114e-01f, 2.82490730e-01f, 1.42284811e-01f, 2.47621015e-01f, 7.62585143e-04f,
  2.47312412e-02f, -1.27386525e-01f, 2.20695257e-01f, -2.13593557e-01f, -3.58724073e-02f, 1.58572346e-01f, 2.80940421e-02f, 8.11621025e-02f, 1.55600905e-01f, 2.13201106e-01f,
  7.41537511e-02f, 1.65114045e-01f, 4.10286337e-02f, -1.41064286e-01f, 1.65238336e-01f, 2.55080551e-01f, 5.24831377e-02f, -3.17933261e-02f, -2.64608245e-02f, 7.02424422e-02f,
  3.06919485e-01f, 2.90714055e-01f, 9.28674042e-02f, 8.06822106e-02f, 2.17310399e-01f, 2.54811980e-02f, 1.12964660e-01f, 4.83378060e-02f, 1.51349142e-01f, 6.92542419e-02f,
  1.45244896e-02f, 1.15836181e-01f, 5.05196303e-03f, 3.37344743e-02f, 1.73540920e-01f, 1.31195575e-01f, 8.33974108e-02f, 6.99634627e-02f, 3.40954065e-02f, 2.68412102e-02f,
  9.31873173e-02f, 9.29702371e-02f, 4.85703424e-02f, 2.77570989e-02f, 5.27275354e-02f, 5.42955883e-02f, 2.84217335e-02f, -1.08180575e-01f, -3.16517241e-02f, -1.89671703e-02f,
  -2.26197526e-01f, -4.41919938e-02f, 6.15515672e-02f, -1.47639155e-01f, 1.20370150e-01f, 2.13762885e-03f, 3.12094521e-02f, 1.76260903e-01f, 3.18330973e-02f, -3.21877971e-02f,
  7.35483915e-02f, 5.30326255e-02f, 7.32143000e-02f, -1.90059707e-01f, 2.99585871e-02f, 1.55840218e-01f, 7.04756677e-02f, 6.54264018e-02f, -1.46514282e-01f, 8.43638629e-02f,
  1.27106920e-01f, -1.19363405e-02f, -9.51152146e-02f, 1.71776414e-01f, -2.41445992e-02f, 1.10731252e-01f, 1.73988864e-01f, -4.38003689e-02f, -8.64046514e-02f, -3.18328664e-02f,
  -2.06628237e-02f, 3.93087000e-01f, 8.99467394e-02f, -4.04467434e-02f, -7.52977142e-03f, 5.87824322e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.97119545e-03f, 8.03534538e-02f, 6.64414838e-02f, 1.09136375e-02f, 3.20107378e-02f, 1.05822265e-01f, 1.87437609e-01f, 3.80301774e-02f, 1.20658043e-03f, 1.12754159e-01f,
  1.21704698e-01f, 1.06935486e-01f, 8.73188376e-02f, 1.80563241e-01f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  3.47374640e-02f, 6.20043799e-02f, -1.44203752e-03f, -9.64396000e-02f, 1.08354747e-01f, -3.91233042e-02f, -1.28846914e-02f, -1.26803488e-01f, 1.95892695e-02f, -9.71017927e-02f,
  -4.19792347e-02f, -8.03620517e-02f, 7.75323287e-02f, -4.15377617e-02f, -2.92138699e-02f, -4.93189692e-02f, 6.95811510e-02f, -6.61157025e-03f, -5.31204306e-02f, 1.18771959e-02f,
  1.74660757e-01f, 1.61058590e-01f, -1.71580780e-02f, -1.70992538e-02f, 6.46199211e-02f, -4.85356450e-02f, -1.08840629e-01f, -1.02233164e-01f, -5.83767667e-02f, 1.46657109e-01f,
  1.48482531e-01f, -3.66382971e-02f, -1.51467668e-02f, -5.42139374e-02f, -2.54836231e-02f, -8.65202397e-02f, -1.50074705e-01f, 9.20765772e-02f, -5.64097725e-02f, -2.42093448e-02f,
  8.04789085e-03f, 1.01649344e-01f, 9.87272412e-02f, -4.53932211e-02f, 1.73907340e-01f, 7.07010105e-02f, 4.52867486e-02f, 7.55852833e-02f, -1.45241234e-03f, -4.87052184e-03f,
  8.53542984e-03f, 3.56437303e-02f, 9.75305215e-02f, 9.85387638e-02f, -5.46916761e-02f, 9.05867815e-02f, 4.84065972e-02f, 1.57384407e-02f, -1.34390190e-01f, 5.69706447e-02f,
  -1.21199012e-01f, -1.92177385e-01f, -8.48884732e-02f, 3.17580104e-02f, -1.36512890e-01f, -1.05542853e-01f, -1.26371071e-01f, -4.00507301e-02f, -5.30195097e-03f, -7.63095245e-02f,
  -7.07775876e-02f, 1.38791557e-03f, 1.72732100e-02f, 1.12164862e-01f, 2.86049154e-02f, -8.13087672e-02f, -2.05882620e-02f, 3.71292084e-02f, 3.12978104e-02f, 5.44105768e-02f,
  -1.90593135e-02f, 7.25015579e-03f, 3.62940915e-02f, 5.22960946e-02f, 4.35746573e-02f, -7.71903098e-02f, 3.77871804e-02f, 6.30958751e-02f, -6.39173687e-02f, -6.40779063e-02f,
  4.85701188e-02f, 2.87026707e-02f, 2.72195134e-02f, -1.44659027e-01f, -8.71319976e-03f, -2.79833563e-02f, -1.04422338e-01f, 6.36196584e-02f, -3.89200263e-02f, 3.54471430e-02f,
  1.03583112e-01f, -5.42933643e-02f, 8.70617852e-02f, 1.95708293e-02f, 9.03491080e-02f, -1.21493548e-01f, -1.75150573e-01f, 1.02707380e-02f, -6.59872741e-02f, -1.37205441e-02f,
  -2.62753554e-02f, -1.08525269e-01f, 4.22205999e-02f, -3.76377217e-02f, -6.82951808e-02f, -6.09961264e-02f, -1.02894649e-01f, -1.46792740e-01f, -4.17208411e-02f, -6.53163791e-02f,
  2.58513212e-01f, -6.93586543e-02f, 2.38107502e-01f, 2.63771769e-02f, 4.53720316e-02f, 5.29841334e-02f, 5.25894538e-02f, -2.28458811e-02f, 2.81994827e-02f, 4.87488732e-02f,
  6.98170299e-03f, 3.03243492e-02f, -5.09326234e-02f, 1.80082321e-02f, -1.23862270e-03f, -1.41871765e-01f, 3.85113433e-02f, 3.35528478e-02f, 2.70594098e-02f, -6.77966932e-03f,
  1.46972127e-02f, 3.88737209e-03f, 1.03839263e-01f, 4.75035533e-02f, -9.12772864e-02f, -1.14078246e-01f, 1.54901352e-02f, 7.71481683e-03f, -4.77782823e-02f, 1.62718687e-02f,
  -3.07321046e-02f, 3.68265784e-03f, -8.83169621e-02f, -5.07654017e-03f, -1.01916499e-01f, -1.74394548e-02f, -3.99205349e-02f, -3.47556695e-02f, -4.55798097e-02f, 1.29792973e-01f,
  9.54575986e-02f, 1.09225474e-01f, -9.44541115e-03f, 1.38147786e-01f, 5.49045578e-02f, -3.80987041e-02f, 3.09364982e-02f, 1.23385757e-01f, 1.09104887e-01f, 7.47050494e-02f,
  1.06897697e-01f, -1.01646483e-01f, -8.52751508e-02f, 6.84385523e-02f, -1.50455788e-01f, -8.41822624e-02f, -3.54453623e-02f, 4.89451662e-02f, -4.27945442e-02f, 1.72027826e-01f,
  7.14888945e-02f, -9.92466137e-02f, 1.84865713e-01f, 9.85371694e-02f, -1.91634387e-01f, -1.15043297e-01f, -1.01202196e-02f, -1.68434650e-01f, -3.77399178e-04f, 9.74220261e-02f,
  -1.67966962e-01f, -9.82269645e-02f, -9.80576500e-02f, -3.71318981e-02f, -6.01484962e-02f, 5.22546517e-03f, 2.82993726e-02f, -3.26725766e-02f, -4.41088155e-02f, -3.53367068e-02f,
  9.47832316e-02f, 4.05812413e-02f, 6.36544824e-02f, -3.30214463e-02f, 6.47747889e-02f, 1.84686054e-02f, -2.75440365e-02f, 9.07511935e-02f, 1.16344234e-02f, -9.78332236e-02f,
  1.93122495e-02f, -1.85858998e-02f, -1.05960250e-01f, 7.41623417e-02f, -1.82623956e-02f, -1.10638663e-01f, -3.14395577e-02f, 9.12051350e-02f, 1.04826376e-01f, 5.44622876e-02f,
  -8.87403935e-02f, -9.53110531e-02f, -1.13474898e-01f, 1.72169432e-02f, -5.40195499e-03f, 1.14986174e-01f, 3.20230164e-02f, -3.64336707e-02f, 1.52659953e-01f, -1.52867630e-01f,
  -3.15147899e-02f, -1.31642371e-01f, -1.10287756e-01f, 3.88128161e-02f, 6.49319887e-02f, -2.49045920e-02f, -2.48960257e-02f, 1.07914433e-01f, -7.36732483e-02f, -8.02290626e-03f,
  -1.65206995e-02f, 1.36965781e-01f, 7.73832202e-02f, 2.60210056e-02f, 6.92181587e-02f, 7.85511211e-02f, -2.44856998e-02f, -4.02047634e-02f, -1.53896138e-01f, 5.24625964e-02f,
  1.30903542e-01f, -1.22934118e-01f, -1.12614781e-01f, 1.66684091e-01f, 5.36653176e-02f, -2.72183958e-02f, -8.06221068e-02f, -9.26900283e-02f, -1.08222798e-01f, 4.87245508e-02f,
  -1.14174113e-01f, -5.26120514e-02f, 3.60815525e-02f, 1.31934052e-02f, 1.62054058e-02f, -1.84727125e-02f, -3.94964032e-02f, 5.88645367e-03f, -3.01847365e-02f, 5.79549037e-02f,
  3.80847161e-03f, 2.80829817e-02f, 4.46637720e-03f, -8.97200331e-02f, -1.90214701e-02f, 1.97109282e-02f, -1.38933793e-01f, 1.36148753e-02f, 5.64187020e-02f, 5.91777414e-02f,
  4.55354005e-02f, -6.41617924e-02f, 5.81540354e-02f, 3.42342816e-02f, 3.90196182e-02f, -2.84888446e-02f, -1.36091411e-01f, 5.73882312e-02f, 5.59051782e-02f, 1.44209238e-02f,
  1.49923004e-02f, 1.40542537e-01f, 2.07414050e-02f, 2.10390817e-02f, 6.20835051e-02f, 1.49496095e-02f, 1.33517280e-01f, 1.15659861e-02f, -1.82167906e-02f, 2.13593803e-02f,
  4.52032425e-02f, 4.44875844e-02f, 1.98471695e-02f, -1.70196950e-01f, -5.04507683e-02f, -1.30124196e-01f, -1.44288197e-01f, 1.05654925e-01f, 4.00791653e-02f, -3.85348052e-02f,
  2.91734561e-02f, 8.35363194e-02f, -1.08932577e-01f, -1.41365841e-01f, 1.23196945e-01f, -6.45787641e-02f, 3.78576890e-02f, 1.46598160e-01f, -1.20419092e-01f, -1.79419462e-02f,
  1.12308420e-01f, 7.58236274e-02f, 7.73053197e-03f, -2.69112606e-02f, 5.08567430e-02f, -1.36217941e-02f, -1.94123406e-02f, 6.98375776e-02f, -2.35395529e-03f, 5.04090637e-02f,
  -5.70406131e-02f, -6.07109815e-03f, 4.39776033e-02f, -1.39033888e-02f, 3.16691734e-02f, -1.25157153e-02f, 3.08156945e-02f, 9.51561183e-02f, -6.58593932e-03f, 9.49029326e-02f,
  1.20381892e-01f, 8.36625993e-02f, 1.16645750e-02f, 6.31113164e-03f, 8.55986103e-02f, -3.74018252e-02f, 4.33801711e-02f, -3.57801430e-02f, -1.77371614e-02f, 6.26428947e-02f,
  -7.30141811e-03f, -8.45567659e-02f, 1.23056591e-01f, -1.63348138e-01f, -1.13340519e-01f, -8.75076354e-02f, -8.27465579e-02f, 8.15667063e-02f, -1.14916369e-01f, -9.61365327e-02f,
  1.62582807e-02f, -6.57617822e-02f, -4.53540310e-02f, -1.06446603e-02f, 1.65013999e-01f, 1.93979666e-02f, 8.29755962e-02f, 8.03858135e-03f, -7.38319233e-02f, -4.66137752e-02f,
  1.15897529e-01f, -9.07461420e-02f, -6.85789883e-02f, -5.83871976e-02f, 4.85128723e-03f, -4.49152291e-02f, 1.91532150e-02f, 1.19675100e-01f, 4.11914885e-02f, 1.17947839e-01f,
  2.48365011e-03f, -1.11540407e-01f, 1.87918872e-01f, 1.31530046e-01f, -2.45895125e-02f, 5.96081354e-02f, 1.07388921e-01f, -8.58289655e-03f, -2.87687425e-02f, 8.02257508e-02f,
  -1.44536635e-02f, 4.85481843e-02f, -2.42206175e-02f, -8.14042985e-02f, -7.48805609e-03f, 3.26321013e-02f, 7.47413188e-02f, 5.78933246e-02f, 3.64856608e-02f, 2.09831651e-02f,
  7.53259063e-02f, 6.85986178e-03f, 6.85302913e-02f, 1.10997051e-01f, 1.00363465e-02f, 6.76598540e-03f, 9.06289592e-02f, -1.44326398e-02f, 4.82256971e-02f, -9.44730565e-02f,
  -7.46973678e-02f, 2.27400176e-02f, 1.08856998e-01f, 1.05424985e-01f, -1.26265865e-02f, 1.54271265e-02f, -4.31834869e-02f, -3.01129073e-02f, 4.37682569e-02f, 7.65194148e-02f,
  2.24770084e-02f, 1.63028166e-01f, 1.47212833e-01f, -6.03990164e-03f, 1.17273048e-01f, 1.61738858e-01f, 1.05597124e-01f, 5.90385236e-02f, -1.01322010e-02f, 8.78889486e-02f,
  -5.63506745e-02f, -4.47036028e-02f, -7.42766708e-02f, -7.55865052e-02f, -1.25543803e-01f, 9.78629012e-03f, -3.75002734e-02f, 7.71598667e-02f, -8.55931453e-03f, 2.25833938e-01f,
  -1.09162517e-01f, -1.68623149e-01f, 8.37698877e-02f, 4.29333225e-02f, 7.30641037e-02f, 4.73761335e-02f, -1.47887975e-01f, 1.34633482e-01f, 3.13515030e-02f, 3.69235426e-02f,
  -4.74994965e-02f, -2.51339637e-02f, -5.08765914e-02f, 3.87395807e-02f, 5.24937809e-02f, -7.92246535e-02f, 1.00976899e-01f, -4.80786748e-02f, 5.08974977e-02f, -3.74680618e-03f,
  3.29036862e-02f, 1.81508455e-02f, 5.06934747e-02f, -3.14087421e-03f, 4.06595506e-02f, 5.07626496e-02f, 1.03620086e-02f, -3.08959801e-02f, 1.28554944e-02f, 3.43861654e-02f,
  3.34933288e-02f, 1.50982512e-03f, 8.35781023e-02f, -1.62644107e-02f, -1.00251853e-01f, -6.86162636e-02f, -5.75029776e-02f, 1.77979954e-02f, 6.98385313e-02f, 5.42964302e-02f,
  7.15950355e-02f, 4.26961295e-03f, 1.23926640e-01f, 8.23652074e-02f, -1.20439216e-01f, -2.89019663e-02f, 1.31248711e-02f, 5.50976209e-02f, 7.01637790e-02f, 8.86285603e-02f,
  8.11579153e-02f, -1.28239751e-01f, 1.39512718e-01f, 9.66447592e-03f, -4.86374535e-02f, 3.83363627e-02f, 7.93669522e-02f, 4.18716222e-02f, -1.00768432e-02f, 2.00826958e-01f,
  1.73765406e-01f, 1.63434073e-01f, -5.37952483e-02f, 7.98444897e-02f, -3.63006257e-02f, 4.10196371e-02f, -1.42768279e-01f, -5.13879471e-02f, -9.95400473e-02f, 6.95223063e-02f,
  1.12370006e-03f, 4.49337512e-02f, 1.62643403e-01f, 1.88318510e-02f, 3.67049947e-02f, -9.24386680e-02f, 4.62216102e-02f, -2.17366796e-02f, 7.82045245e-04f, -1.00532748e-01f,
  4.22814637e-02f, 4.21154313e-02f, 6.70018941e-02f, -6.73376992e-02f, 4.18657176e-02f, 6.77560177e-03f, -1.44370878e-03f, 2.06751097e-02f, 1.98654039e-03f, -5.96222393e-02f,
  -3.42508592e-02f, -3.38005014e-02f, 1.08381107e-01f, 2.43065860e-02f, -1.81291308e-02f, -1.21314384e-01f, -1.31616816e-01f, 5.31904772e-02f, -6.48537837e-03f, 7.86640644e-02f,
  -1.02326356e-01f, -1.23028956e-01f, 5.18863946e-02f, 1.26231417e-01f, -5.65045960e-02f, 1.24437571e-01f, -7.71447122e-02f, -3.39777842e-02f, 3.96660380e-02f, 5.12528582e-04f,
  -1.61367074e-01f, 8.07199068e-03f, 3.09014525e-02f, -2.40002368e-02f, 3.24974433e-02f, -5.36878966e-03f, -9.31436475e-03f, 4.29029092e-02f, 1.04905516e-02f, 2.36379039e-02f,
  -3.98171879e-02f, 3.84256355e-02f, 1.46839350e-01f, -1.92873314e-01f, 3.68427970e-02f, -4.80687506e-02f, 6.87212572e-02f, -1.11321017e-01f, -9.61118042e-02f, 7.40805119e-02f,
  8.92333463e-02f, -1.01785176e-01f, 2.64977887e-02f, -6.41628280e-02f, 8.63384753e-02f, -5.30434623e-02f, -8.39501992e-02f, -2.09639594e-01f, -3.18999887e-02f, -1.08752446e-02f,
  -1.18443377e-01f, -7.09261447e-02f, -7.81603605e-02f, 2.03514546e-02f, -5.58395777e-03f, 1.05926245e-02f, -4.94571663e-02f, -7.23170489e-02f, -8.76440406e-02f, 5.00772661e-03f,
  -5.88090383e-02f, -1.27327945e-02f, -3.07666361e-02f, -9.43234712e-02f, 1.45142293e-02f, -1.20213609e-02f, -6.22177087e-02f, -2.01691012e-03f, 1.96381491e-02f, 5.66690750e-02f,
  -2.32509747e-02f, -1.72762685e-02f, 3.26955952e-02f, 3.78636308e-02f, -1.06171295e-02f, -1.28981292e-01f, -1.24447525e-01f, 7.19135031e-02f, -1.11162663e-01f, 7.91503489e-02f,
  -1.17793612e-01f, 1.75842810e-02f, 4.66718972e-02f, -1.69841032e-02f, 1.15435019e-01f, 8.87241662e-02f, 3.90228331e-02f, -1.00430802e-01f, -1.18473776e-01f, 6.35761246e-02f,
  -9.73862335e-02f, -6.86590653e-03f, 2.58358717e-02f, -4.52676341e-02f, -5.12410654e-03f, -4.40374389e-02f, -1.67100921e-01f, -1.68209821e-02f, -1.69616982e-01f, -2.05418870e-01f,
  -1.59957975e-01f, -4.92964983e-02f, 7.29464591e-02f, -1.38546377e-01f, 1.43831059e-01f, -3.28689255e-03f, -2.34092381e-02f, 3.64594981e-02f, 2.14654766e-02f, -8.02400038e-02f,
  -1.86812680e-03f, 2.68932134e-02f, -9.88526735e-03f, -1.19775139e-01f, 5.95015809e-02f, -2.94108503e-03f, -4.43847030e-02f, -4.00326177e-02f, -7.39739314e-02f, 1.43339500e-01f,
  -3.06593999e-02f, -8.43108967e-02f, -3.31644341e-02f, 1.15678608e-02f, -2.82294918e-02f, 1.62294437e-03f, -7.20772296e-02f, -7.20092445e-04f, 4.68640309e-03f, -9.44516342e-03f,
  3.35558355e-02f, 6.42683655e-02f, 9.53661650e-02f, -1.91534102e-01f, -5.61271161e-02f, 9.00836587e-02f, 1.28619209e-01f, 7.71598145e-02f, -9.77726281e-02f, -7.33436225e-03f,
  -5.18224686e-02f, 1.00137271e-01f, 5.02147600e-02f, -5.28623536e-03f, -9.96055678e-02f, 1.59960892e-02f, 1.22176796e-01f, -1.24044158e-01f, 1.61968283e-02f, -4.22287583e-02f,
  6.36981651e-02f, 4.27164920e-02f, 4.78919372e-02f, 6.65101856e-02f, 1.33596361e-01f, 7.59002101e-03f, 2.81094201e-02f, -6.10954650e-02f, -3.26925772e-03f, -1.81968771e-02f,
  -2.11204793e-02f, -4.81242724e-02f, -8.10935721e-03f, -1.84696525e-01f, 4.12206426e-02f, -1.18754730e-01f, -1.84735537e-01f, 5.49629144e-02f, 1.42294094e-02f, -1.05590969e-01f,
  1.22372806e-01f, -1.11191876e-01f, 1.84894606e-01f, -4.89661880e-02f, -1.32949799e-01f, -1.22911915e-01f, -2.93954555e-02f, 8.91480669e-02f, -1.39907628e-01f, 5.10068275e-02f,
  -8.42429399e-02f, 7.92905316e-02f, 7.78598785e-02f, 2.77991667e-02f, 8.02617967e-02f, -7.93219358e-03f, -1.05730169e-01f, 7.45478496e-02f, -1.98798180e-02f, 8.35708305e-02f,
  -3.64136063e-02f, -3.49255800e-02f, 6.77557383e-03f, 1.91948246e-02f, -1.40787572e-01f, -8.72761309e-02f, -5.39362431e-02f, 5.28328046e-02f, -3.05057485e-02f, 7.22498493e-03f,
  1.03050787e-02f, 4.59241010e-02f, 9.74233076e-02f, -1.28479838e-01f, -2.66708210e-02f, 9.66830030e-02f, -1.35947913e-01f, 1.14832655e-01f, 5.31245694e-02f, 2.93474086e-02f,
  2.33154371e-02f, -1.47872828e-02f, 1.50027946e-01f, 3.82416919e-02f, 4.98163104e-02f, 4.41269912e-02f, -7.26649389e-02f, 8.08464177e-03f, -1.98561862e-01f, 2.52981372e-02f,
  -7.50315934e-02f, -6.93162605e-02f, -1.97231695e-02f, 3.06387972e-02f, -1.26422092e-01f, 1.09921001e-01f, -4.82667610e-03f, -5.18719703e-02f, 5.07532470e-02f, 6.82011321e-02f,
  4.54741456e-02f, -1.38628125e-01f, -6.09363616e-03f, -5.04721552e-02f, -4.58949566e-04f, 2.27035373e-01f, -7.79093802e-02f, 5.35249859e-02f, -1.28684059e-01f, 1.52905062e-02f,
  5.63624874e-02f, 8.14435445e-03f, 2.87486408e-02f, 6.13211729e-02f, -3.46686020e-02f, -8.46570283e-02f, -3.54761742e-02f, 3.29073519e-02f, -7.79955387e-02f, -3.65358032e-02f,
  -1.16283763e-02f, -1.36355413e-02f, 5.61369620e-02f, 5.97493947e-02f, 3.11622750e-02f, -2.12737191e-02f, -1.33165820e-02f, 3.96752283e-02f, -4.28316556e-02f, 1.95040945e-02f,
  7.77500868e-03f, -9.72995088e-02f, -1.96287222e-02f, -3.44997682e-02f, -6.46026246e-03f, 3.94816883e-02f, -4.33772756e-03f, 9.20172110e-02f, -8.89353156e-02f, 3.97125334e-02f,
  -4.07623239e-02f, -6.94591692e-03f, -2.81923707e-03f, 7.98450708e-02f, 1.06211439e-01f, 2.75044795e-03f, 1.75856009e-01f, 7.58422539e-02f, 1.35727361e-01f, 1.50803402e-01f,
  1.33756483e-02f, -3.02592460e-02f, 7.12270737e-02f, 4.40163836e-02f, 1.40277529e-02f, -3.09899114e-02f, 9.44548345e-04f, -9.10954848e-02f, -1.29701659e-01f, 9.80175361e-02f,
  1.28666222e-01f, 1.04082925e-02f, 8.59536082e-02f, 1.75128341e-01f, -1.74998984e-01f, -9.40629169e-02f, -6.07765876e-02f, -5.02373278e-02f, 3.40113603e-02f, 2.98331752e-02f,
  -8.09273496e-02f, 5.15662059e-02f, -1.44142687e-01f, -8.76033083e-02f, -1.13204516e-01f, -6.09167153e-03f, -1.01507530e-01f, -2.88699288e-02f, -6.13701791e-02f, 2.34794319e-02f,
  9.57152471e-02f, -1.33123666e-01f, -4.87703681e-02f, -6.04555458e-02f, 3.70435901e-02f, 4.31019776e-02f, 2.92364135e-02f, -1.07824076e-02f, 5.26200384e-02f, -4.85631190e-02f,
  -7.74312988e-02f, 1.14719654e-02f, -1.30624369e-01f, 6.08780682e-02f, -3.60035733e-03f, -1.10892663e-02f, 1.05531685e-01f, -6.70518503e-02f, -2.36857757e-02f, -3.94557193e-02f,
  -6.89223483e-02f, 3.79033946e-02f, -3.38287512e-03f, -1.18143288e-02f, 7.51854777e-02f, 9.41637717e-03f, 5.64291440e-02f, 4.67351861e-02f, -5.82483523e-02f, -1.37912065e-01f,
  1.92135572e-02f, 1.94473974e-02f, -3.50275114e-02f, -2.18227692e-02f, 9.47429761e-02f, -1.04965687e-01f, 4.39591743e-02f, 2.64530703e-02f, -4.73986939e-03f, 1.28452834e-02f,
  -5.55326696e-03f, 1.76635273e-02f, -1.40856013e-01f, 4.52632718e-02f, 1.57216802e-01f, 1.45680100e-01f, -1.34272426e-01f, 1.18141159e-01f, -1.31473839e-01f, -6.05664887e-02f,
  5.03106639e-02f, -3.93603705e-02f, -2.83505350e-01f, 3.76306735e-02f, 1.48615176e-02f, 6.73070028e-02f, 1.17103413e-01f, 1.28200352e-01f, 6.73052371e-02f, 1.69758461e-02f,
  1.10713271e-02f, -4.22036052e-02f, 1.21833682e-01f, 4.47110794e-02f, 4.52440465e-03f, -1.58532381e-01f, 1.95628144e-02f, 1.23144407e-02f, -1.49971517e-02f, -4.89491634e-02f,
  -4.45869267e-02f, -3.08114607e-02f, 4.52107564e-02f, 8.41912627e-02f, -3.62293124e-02f, -3.45993526e-02f, -4.00848910e-02f, -1.52512044e-02f, 1.12615619e-02f, -1.78839974e-02f,
  5.03768623e-02f, -2.52858344e-02f, -5.51971681e-02f, -6.46473542e-02f, -8.12128559e-02f, 7.03762621e-02f, 1.02441885e-01f, -8.48677978e-02f, 1.88173890e-01f, -1.06722862e-01f,
  1.93465371e-02f, -1.68145858e-02f, -1.01556733e-01f, 3.32169421e-02f, -7.88200945e-02f, 2.29898118e-03f, -2.46238858e-02f, 8.56430680e-02f, 1.66060627e-01f, -1.64851304e-02f,
  1.37233377e-01f, 4.24906425e-02f, 2.55457368e-02f, -1.52301963e-03f, 5.55693060e-02f, -3.38275060e-02f, 6.48629367e-02f, 3.96845266e-02f, 1.45850927e-01f, 2.27498502e-01f,
  3.68324062e-03f, 1.51647301e-02f, -6.50929287e-02f, 6.80422634e-02f, -1.45176992e-01f, 1.33353518e-02f, -1.38864115e-01f, -6.68337718e-02f, 3.74273350e-03f, 1.46300539e-01f,
  8.08791667e-02f, 1.24115072e-01f, 4.94331159e-02f, 3.98590304e-02f, 4.31351513e-02f, 6.04734197e-02f, 1.11949462e-02f, 9.77913570e-03f, 1.98716559e-02f, -1.11832090e-01f,
  9.14486423e-02f, -7.75278956e-02f, 1.92741666e-03f, 5.04002497e-02f, 5.06536923e-02f, 4.40598056e-02f, -2.92705558e-02f, 7.16930479e-02f, 2.75604222e-02f, 2.33480278e-02f,
  6.16932362e-02f, 4.67840657e-02f, 2.50444133e-02f, -5.66642638e-03f, -5.95576279e-02f, -1.52959665e-02f, -6.60195872e-02f, 1.47824092e-02f, -6.88564107e-02f, 5.58124334e-02f,
  7.74230435e-02f, 6.23139553e-02f, 1.52920350e-01f, 4.05335762e-02f, 8.15803651e-03f, 5.96299246e-02f, -1.86003875e-02f, 4.30016331e-02f, -1.89061426e-02f, 5.75462840e-02f,
  5.41263036e-02f, 1.42898917e-01f, 9.31795985e-02f, -8.02713260e-02f, 8.12182948e-02f, 1.15944464e-02f, -2.62155980e-02f, -4.00147475e-02f, -4.67181467e-02f, 2.50038542e-02f,
  1.21810131e-01f, 9.92313549e-02f, 1.69786409e-01f, 1.18835256e-01f, 1.42761007e-01f, 2.41870731e-01f, -1.44633008e-02f, 4.83484752e-02f, -1.29580721e-02f, -7.68142045e-02f,
  -1.08526729e-01f, 8.76272544e-02f, -8.63121301e-02f, 5.00813052e-02f, -1.83129579e-01f, 2.00371295e-02f, -1.24797866e-01f, 3.70004475e-02f, -6.60509691e-02f, -7.23211467e-02f,
  -7.44477510e-02f, 1.20008461e-01f, 1.33509273e-02f, -7.00570717e-02f, -7.58754835e-02f, -4.27762195e-02f, -3.71117756e-04f, -2.76599973e-02f, -2.61805337e-02f, -4.40696850e-02f,
  9.58966538e-02f, 8.43604002e-03f, -5.56878448e-02f, 3.14130932e-02f, -5.53341396e-02f, 9.48779806e-02f, -8.80334824e-02f, 1.04885988e-01f, 4.03848886e-02f, -4.00066413e-02f,
  1.17643408e-01f, 1.17676510e-02f, 8.21499377e-02f, 1.17647395e-01f, -7.62532186e-03f, -8.05125982e-02f, -1.33948743e-01f, -1.66064858e-01f, -1.29693104e-02f, -9.97786522e-02f,
  -7.88899232e-03f, 8.43810737e-02f, 2.73380876e-02f, -1.50873438e-01f, -7.11256489e-02f, -7.23071992e-02f, -8.04675370e-02f, 5.55324778e-02f, -1.77042354e-02f, 4.41267602e-02f,
  1.14290886e-01f, 7.44434372e-02f, 5.54211345e-03f, -1.21183656e-01f, -3.30900140e-02f, 8.88823648e-04f, 2.00165007e-02f, 1.63552046e-01f, -1.38626337e-01f, -1.47723854e-01f,
  5.03463745e-02f, -4.16349061e-02f, 1.91952083e-02f, 1.61825404e-01f, -9.69266370e-02f, 3.52348783e-04f, 1.33536234e-01f, -2.97685228e-02f, 6.34471178e-02f, -8.79704282e-02f,
  5.48143722e-02f, 4.98166829e-02f, -9.84200276e-03f, -2.86309067e-02f, 3.07473820e-02f, 4.52335998e-02f, 4.60297205e-02f, 4.25196216e-02f, -9.24397707e-02f, -5.87031990e-02f,
  8.66673216e-02f, -7.16971457e-02f, -3.46376561e-02f, -6.55167699e-02f, 5.74936830e-02f, 2.44600121e-02f, 2.70514581e-02f, 1.79082938e-02f, -2.42514331e-02f, 6.67879283e-02f,
  -8.64694361e-03f, -1.80743448e-02f, 1.01658151e-01f, 2.85632759e-02f, 1.26742154e-01f, 4.39120792e-02f, -8.14232826e-02f, 9.62405354e-02f, -4.56189029e-02f, -9.94255319e-02f,
  1.01078354e-01f, -1.15588337e-01f, -8.64755586e-02f, -8.30097347e-02f, -4.76540625e-02f, -2.63359416e-02f, -1.39635429e-01f, -9.17154849e-02f, -7.02536479e-02f, -9.59355161e-02f,
  -8.99902880e-02f, 1.24381762e-02f, 1.37853310e-01f, -7.51846284e-02f, 1.16720021e-01f, 4.90799248e-02f, -7.22060129e-02f, 3.38782631e-02f, 1.82916239e-01f, -1.29524931e-01f,
  -1.60154343e-01f, 1.24822974e-01f, -8.66211578e-02f, -1.21420801e-01f, -6.19881526e-02f, 1.59246445e-01f, -2.74854130e-03f, 1.05834544e-01f, -8.06492344e-02f, -4.98536378e-02f,
  1.36763066e-01f, 7.43959993e-02f, 1.32773384e-01f, 1.05695799e-01f, 1.09321356e-01f, -3.23694833e-02f, 1.66102394e-01f, -1.08440863e-02f, 7.69417584e-02f, -1.70073099e-03f,
  4.35199514e-02f, 2.26968247e-02f, -4.90166619e-02f, -8.34347308e-03f, 6.56598955e-02f, 3.30839083e-02f, 2.09749583e-02f, 1.73514690e-02f, 4.87655737e-02f, -2.78777406e-02f,
  4.81697768e-02f, 1.11919991e-03f, 1.50411606e-01f, 1.00919716e-01f, 1.31506575e-02f, 1.20578229e-03f, 7.71533176e-02f, 8.09950829e-02f, -3.13726403e-02f, -1.38479739e-01f,
  1.29261811e-03f, 9.18123126e-02f, 8.92369822e-02f, -1.66761205e-01f, 6.65849596e-02f, -5.47870249e-02f, 7.75749087e-02f, -1.00212425e-01f, -1.30456686e-01f, -2.50995364e-02f,
  -1.44280374e-01f, -1.06964342e-01f, -7.29613453e-02f, 8.82154852e-02f, 6.21945933e-02f, -4.24219780e-02f, 5.40358275e-02f, -2.65858322e-02f, 4.92433980e-02f, 1.48526564e-01f,
  -2.54828986e-02f, 6.69222102e-02f, 1.60880119e-01f, 2.60779671e-02f, -2.25348659e-02f, 1.05401151e-01f, 1.18737914e-01f, 6.40121102e-02f, 3.92375030e-02f, 1.38760820e-01f,
  -1.41950741e-01f, 8.67485553e-02f, -1.07972182e-01f, -1.39128163e-01f, 2.36892551e-02f, -5.38691990e-02f, 7.44812191e-02f, -6.98020356e-03f, -8.08326229e-02f, 5.45689017e-02f,
  1.08353784e-02f, -1.15196034e-02f, 6.88654780e-02f, 5.32705076e-02f, 1.17237732e-01f, -1.88173026e-01f, -1.94085091e-02f, -6.02291822e-02f, -4.15593013e-02f, -7.82883260e-03f,
  -3.01099848e-02f, -1.19503558e-01f, -1.83570385e-02f, 4.12689373e-02f, -4.49551595e-03f, 2.25995909e-02f, 7.05665126e-02f, 2.18323153e-02f, -2.49426123e-02f, 9.49952751e-02f,
  2.42507132e-03f, -2.78018042e-02f, -8.54541548e-03f, -2.11780816e-02f, -1.10944353e-01f, 1.91614013e-02f, 9.25108343e-02f, 1.36801451e-02f, 2.11593553e-01f, -6.81015849e-02f,
  3.10909878e-02f, -7.65812770e-02f, -1.33831099e-01f, -3.80939543e-02f, -1.12840585e-01f, 7.77478740e-02f, -9.36764330e-02f, -7.59973973e-02f, 5.16578481e-02f, -8.61217007e-02f,
  1.91560313e-01f, 3.81223559e-02f, 1.00272872e-01f, 5.94308041e-03f, -1.71975624e-02f, 1.32725043e-02f, 5.79457320e-02f, 3.91119346e-03f, 9.42629874e-02f, 1.43481642e-01f,
  -1.79306552e-01f, -2.16927677e-02f, 4.51782905e-02f, 1.16713047e-01f, -3.96930128e-02f, 5.50624216e-03f, -2.02532262e-01f, -3.24749239e-02f, 7.54395723e-02f, -2.32111420e-02f,
  8.72392431e-02f, 4.12798785e-02f, 2.69982442e-02f, -3.00654601e-02f, 1.43434897e-01f, -2.28830427e-02f, -1.69634819e-02f, -1.56833977e-01f, -3.60955633e-02f, 1.09673940e-01f,
  7.16844499e-02f, 8.73273890e-03f, -8.02147482e-03f, -9.58232488e-03f, 2.95717064e-02f, 5.17870188e-02f, -8.38366672e-02f, 2.22170763e-02f, -3.41311842e-02f, 1.22408336e-03f,
  5.37316091e-02f, -8.70998576e-03f, 7.25058839e-02f, -1.27650693e-01f, -7.05203861e-02f, 7.01702461e-02f, -4.97217067e-02f, 5.02427779e-02f, -1.37848511e-01f, -1.01806521e-01f,
  -6.09797128e-02f, 1.10494852e-01f, 1.66817769e-01f, 6.92606866e-02f, -1.10118978e-01f, 5.59385158e-02f, 1.19405784e-01f, -7.42718205e-02f, 7.69859180e-02f, 8.92753229e-02f,
  2.17578799e-01f, 4.55571264e-02f, 3.59229222e-02f, -1.11242846e-01f, 9.01054814e-02f, 1.97318494e-02f, -1.23065524e-02f, -6.70349672e-02f, -5.77791333e-02f, 7.20774829e-02f,
  2.86584459e-02f, 1.98224522e-02f, 5.72213978e-02f, -2.21681044e-01f, 1.74047410e-01f, 1.31536990e-01f, -1.47997603e-01f, 1.08024282e-02f, -2.67930869e-02f, -1.32216558e-01f,
  1.71323065e-02f, 3.01592629e-02f, -1.23887703e-01f, 1.44579327e-02f, -1.63512304e-01f, -5.20509966e-02f, -1.02952337e-02f, 1.11954935e-01f, -5.99819468e-03f, -6.24889061e-02f,
  -1.20002657e-01f, 6.49734586e-02f, 4.51199450e-02f, -4.08070870e-02f, -1.18407391e-01f, 1.08519755e-01f, 1.14912935e-01f, -2.09646709e-02f, 6.14141561e-02f, 8.37552771e-02f,
  1.16574772e-01f, -8.73206109e-02f, -2.69840658e-02f, -1.28896264e-02f, -1.17818996e-01f, -2.95531228e-02f, -3.07611190e-02f, -4.53318916e-02f, 1.72323525e-01f, -7.12117851e-02f,
  1.53405130e-01f, -6.09965771e-02f, 1.35541642e-02f, 1.52631700e-01f, -1.24143317e-01f, -4.59237136e-02f, -5.33900633e-02f, -1.62619039e-01f, 1.34795070e-01f, 8.69968440e-03f,
  6.88940287e-02f, -6.80090711e-02f, 1.04856372e-01f, -1.05494365e-01f, -9.81751159e-02f, -7.06137791e-02f, -4.86335643e-02f, -2.80404370e-02f, 1.01949230e-01f, 7.46253729e-02f,
  8.00115466e-02f, -3.01927533e-02f, -1.07351400e-01f, -8.67604688e-02f, -1.37694851e-01f, 2.75140218e-02f, -6.23122156e-02f, 5.52616753e-02f, -1.91617325e-01f, 4.36274428e-03f,
  -1.77523702e-01f, -2.36746091e-02f, 2.20741667e-02f, 9.86126438e-02f, 1.68521870e-02f, 1.50235253e-03f, 4.74380888e-02f, 2.79760901e-02f, -1.64137632e-01f, -1.31046161e-01f,
  -6.26842901e-02f, 1.84322614e-02f, -8.20202604e-02f, -2.85851816e-03f, -1.12158351e-01f, 2.96575837e-02f, 2.56852210e-02f, 8.37164186e-03f, -7.25638121e-02f, 1.62898563e-02f,
  -2.75748298e-02f, 1.73465684e-02f, -5.83915832e-03f, 6.05312213e-02f, 1.67183746e-02f, -6.58466667e-02f, 2.92911381e-02f, 1.73399914e-02f, -1.37149721e-01f, 6.06016023e-03f,
  -1.21732033e-03f, 5.44982515e-02f, 5.48270792e-02f, 1.96185708e-02f, -8.95256177e-03f, -1.87972859e-02f, 8.45038965e-02f, 3.88902128e-02f, -7.26296455e-02f, -2.40085367e-02f,
  -2.08083555e-01f, -3.74194942e-02f, 4.16646264e-02f, -1.08403051e-02f, -2.48328503e-02f, 4.35880721e-02f, 9.65862125e-02f, 7.20995246e-03f, 4.92088422e-02f, 6.04528561e-02f,
  -4.12078761e-02f, -4.04586922e-03f, -6.96542189e-02f, -5.93550913e-02f, -3.38921100e-02f, -5.31185269e-02f, 4.38425764e-02f, -5.35731241e-02f, -2.46545583e-01f, 1.65110096e-01f,
  4.41413261e-02f, 5.19311540e-02f, -6.09119013e-02f, 7.82577917e-02f, 4.88679223e-02f, -1.14076041e-01f, 4.39516604e-02f, 3.80410552e-02f, -6.06021211e-02f, 3.97125110e-02f,
  -1.48559332e-01f, 1.12551063e-01f, 2.60616653e-02f, 4.38241586e-02f, -1.49198800e-01f, -1.64887588e-02f, 5.94938472e-02f, -1.10948622e-01f, 2.33658906e-02f, 6.23255558e-02f,
  2.07828637e-02f, 3.41968313e-02f, 2.42718589e-02f, -6.96462020e-02f, 4.44161147e-02f, 7.69946817e-03f, -2.01290380e-02f, -2.46478487e-02f, 5.17177917e-02f, 5.34062088e-02f,
  -9.67042595e-02f, 1.03793005e-02f, 6.68628663e-02f, 9.30656791e-02f, -1.76574647e-01f, 2.81137787e-02f, -3.09253801e-02f, 4.05919515e-02f, 1.11339875e-01f, 5.32250218e-02f,
  -1.34470880e-01f, 1.15830265e-02f, -3.72167192e-02f, -2.13293196e-03f, 1.19292699e-01f, -4.24666405e-02f, 4.22490910e-02f, -3.39230290e-03f, 5.81491143e-02f, -4.77146767e-02f,
  -1.54630408e-01f, -5.33115156e-02f, -9.72446203e-02f, -1.64741844e-01f, -6.58168271e-02f, -3.39300558e-02f, 3.21410336e-02f, 2.20046658e-02f, 2.15321872e-02f, -3.11757252e-02f,
  5.83767258e-02f, 8.57304037e-02f, 6.86556622e-02f, -1.47577122e-01f, 7.76805505e-02f, -1.13916593e-02f, -9.95344296e-02f, -2.80141309e-02f, 1.68897659e-02f, 7.66301826e-02f,
  1.92766324e-01f, 2.00236263e-03f, -1.84982672e-01f, 2.24108230e-02f, 2.09524602e-01f, -1.32172391e-01f, -1.17708696e-02f, -4.05285880e-02f, 1.65827405e-02f, -6.69319257e-02f,
  2.40099914e-02f, 1.56804956e-02f, -3.71191874e-02f, 9.55884345e-03f, -8.81535560e-02f, 8.79889205e-02f, -2.11828500e-02f, 2.85876286e-03f, -2.09575556e-02f, 1.64748654e-02f,
  -3.34703363e-02f, 1.42819704e-02f, -5.55191264e-02f, -1.65441483e-02f, 2.71571185e-02f, 2.17386726e-02f, -5.79891773e-03f, -2.49465127e-02f, 7.06431046e-02f, -5.64011000e-02f,
  -2.16474552e-02f, 4.19804528e-02f, 6.83054700e-02f, 6.74098805e-02f, 7.65491426e-02f, -8.72462839e-02f, -4.01513912e-02f, -5.97339943e-02f, -1.55617759e-01f, 5.65757602e-02f,
  -3.10839228e-02f, -4.75034751e-02f, 1.23282924e-01f, 8.13025888e-03f, 2.83481251e-03f, -2.97529325e-02f, 3.06895818e-03f, -2.71715820e-02f, -1.17468067e-01f, 1.25083745e-01f,
  -1.01882033e-01f, -1.92190856e-02f, 9.75388847e-03f, -1.21807987e-02f, -4.21889424e-02f, -4.33130600e-02f, -1.05049707e-01f, -1.26330763e-01f, -1.51413456e-01f, -1.26858160e-01f,
  -1.52193941e-02f, -1.60677627e-01f, 3.07278112e-02f, -4.78883423e-02f, 1.00230321e-01f, 3.15277763e-02f, 1.88340262e-01f, -5.11508808e-03f, -2.62925606e-02f, 1.69927385e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  8.59502181e-02f, -1.35147525e-02f, 9.86180268e-03f, -7.17151389e-02f, 1.11343868e-01f, 5.56714870e-02f, -9.65929255e-02f, -6.02110252e-02f, 2.91207358e-02f, 1.48246884e-01f,
  1.89371720e-01f, -1.34064764e-01f, -2.23292061e-03f, 2.55473666e-02f, 3.24237719e-02f, 9.66973752e-02f, -1.06782131e-01f, 1.12569984e-03f, 9.63548794e-02f, 4.72587794e-02f,
  2.76109260e-02f, 4.36139293e-02f, 4.64898709e-04f, -1.39104396e-01f, -2.69980758e-01f, 5.13563268e-02f, 2.56804302e-02f, 1.31593093e-01f, -6.03527501e-02f, -2.78973043e-01f,
  -3.84032167e-02f, 1.84198424e-01f, 3.21713053e-02f, 2.60560483e-01f, -9.62591544e-02f, 6.36821166e-02f, 1.73260257e-01f, -6.99487031e-02f, -4.10061553e-02f, -1.33851939e-03f,
  4.86079464e-03f, -3.81579623e-02f, -1.63973812e-02f, -3.30646522e-02f, -9.11320075e-02f, -6.75755600e-03f, -1.27747297e-01f, -7.04973564e-02f, -2.69858129e-02f, 1.53024301e-01f,
  6.32668212e-02f, 7.19179809e-02f, 1.18194394e-01f, -3.49491864e-01f, 3.17119420e-01f, -4.30599265e-02f, 7.70435184e-02f, 1.37368843e-01f, 2.49836862e-01f, -1.99724585e-01f,
  3.03336054e-01f, 2.67858654e-01f, 1.91493943e-01f, -1.27364188e-01f, -3.63831632e-02f, -2.40173817e-01f, -9.11499560e-02f, 2.62854695e-01f, -6.71526268e-02f, 5.66275716e-02f,
  1.99077800e-01f, 2.97945470e-01f, 2.29930520e-01f, 2.91974545e-02f, 7.25478157e-02f, 2.66738292e-02f, -5.47646033e-03f, -5.83359450e-02f, -2.74969667e-01f, -1.87993377e-01f,
  -2.39187409e-03f, 8.02201182e-02f, 1.35883257e-01f, -2.73456752e-01f, -1.82607800e-01f, 3.22061181e-02f, 1.49353854e-02f, 2.71702148e-02f, 1.05518162e-01f, 9.39561874e-02f,
  2.68148452e-01f, 5.79155274e-02f, -1.49226770e-01f, -6.95995018e-02f, -1.15683936e-01f, 1.18701858e-02f, 1.43605843e-01f, -3.25322663e-03f, 7.32505322e-02f, -1.44305304e-01f,
  7.15107769e-02f, -3.54644358e-01f, -3.18813413e-01f, -1.10145152e-01f, -3.83891135e-01f, -4.59185511e-01f, -1.20544411e-01f, -7.30433762e-02f, -2.01684255e-02f, -9.22705382e-02f,
  1.88947186e-01f, -2.77944142e-03f, -5.88108823e-02f, 1.61573142e-01f, 3.60393763e-01f, -1.23866953e-01f, 4.02267389e-02f, 2.81027615e-01f, -2.11394280e-01f, -2.77110618e-02f,
  -2.05380637e-02f, 7.23245263e-01f, 3.08045983e-01f, 3.35218385e-02f, -3.72741744e-03f, 2.17590109e-01f, 4.55190569e-01f, 3.62329222e-02f, 2.07748309e-01f, 8.07252228e-02f,
  1.22962877e-01f, 7.62799159e-02f, 6.16805032e-02f, 5.06697632e-02f, -9.83881652e-02f, -1.51210651e-01f, 3.58257256e-02f, -8.40553362e-03f, 1.33156344e-01f, -4.81889583e-02f,
  5.75051419e-02f, 9.29404199e-02f, 1.03842258e-01f, 6.32343814e-02f, -4.35688086e-02f, 5.80537207e-02f, 2.88952105e-02f, 5.39468043e-02f, 1.39979988e-01f, -8.42108671e-03f,
  1.27484053e-01f, -9.77277756e-02f, -1.10990092e-01f, -1.19377077e-01f, -8.02322030e-02f, -2.56026629e-03f, 6.26464039e-02f, -7.92031735e-02f, -2.27732081e-02f, 2.37619802e-01f,
  1.36103198e-01f, 2.05205142e-01f, -1.18039511e-01f, 1.68349922e-01f, 4.95503768e-02f, 1.54482871e-01f, 5.13810739e-02f, 4.89627235e-02f, 2.01197341e-01f, 1.34492382e-01f,
  2.29429305e-01f, -3.54676060e-02f, -7.39549892e-03f, 1.29178643e-01f, -1.95871577e-01f, -1.06724657e-01f, -7.15771392e-02f, 2.91024689e-02f, 3.27966735e-02f, 4.76082824e-02f,
  1.20191075e-01f, -1.34856343e-01f, 3.72035384e-01f, 2.73565590e-01f, -3.31160307e-01f, -7.99260065e-02f, 1.06250353e-01f, -1.92145601e-01f, 2.67893910e-01f, 1.87486768e-01f,
  6.18851855e-02f, -3.63050923e-02f, 3.65198553e-02f, 1.85120121e-01f, 1.99973032e-01f, -1.11120813e-01f, 1.74094006e-01f, 8.42755735e-02f, -1.92339569e-01f, -5.82054369e-02f,
  -2.20783010e-01f, 1.17423370e-01f, -2.40005136e-01f, 3.75391506e-02f, 2.36007035e-01f, -6.29297048e-02f, 1.49870858e-01f, 7.36580789e-02f, 1.11384362e-01f, 5.57205006e-02f,
  8.69036838e-02f, 3.57238412e-01f, 4.05264318e-01f, 1.02431372e-01f, 1.38966665e-01f, -1.89376399e-02f, 7.93901458e-02f, -3.10223460e-01f, 1.11345939e-01f, -3.39995250e-02f,
  3.09903324e-01f, 1.82753891e-01f, -1.02533117e-01f, -1.89971447e-01f, -1.55513734e-01f, -2.31552884e-01f, -2.53144324e-01f, -1.19690783e-01f, 4.32307236e-02f, 4.55914050e-01f,
  1.46544099e-01f, -1.11156978e-01f, 1.50305763e-01f, 1.78531513e-01f, -8.26244280e-02f, 3.17204773e-01f, 1.13558926e-01f, 1.24941550e-01f, 9.02413130e-02f, -2.14088080e-03f,
  -1.72257796e-01f, -2.78538853e-01f, 1.73334125e-02f, -1.45406410e-01f, -2.79761076e-01f, -1.72645435e-01f, -4.14209403e-02f, -1.15243485e-02f, 4.80144545e-02f, -2.93294966e-01f,
  5.12063980e-01f, 5.90517163e-01f, 4.44203287e-01f, -2.34253690e-01f, 3.26685041e-01f, 2.76046574e-01f, 2.38791462e-02f, 5.55800982e-02f, -9.20602120e-03f, 1.77826867e-01f,
  -1.15661077e-01f, -4.51742448e-02f, 3.19406837e-02f, 9.06230956e-02f, 2.25448146e-01f, -2.32168734e-01f, 6.00564517e-02f, 7.24952817e-02f, 1.38241956e-02f, 1.62968397e-01f,
  4.30445857e-02f, 6.76851496e-02f, 1.44762665e-01f, 4.57464010e-02f, 1.97350681e-02f, -4.90598120e-02f, -1.12564163e-02f, 6.04054369e-02f, 1.65403262e-02f, 2.02328712e-01f,
  1.73937544e-01f, -7.92912841e-02f, -1.85921669e-01f, -2.05586895e-01f, 5.42988367e-02f, 1.86751589e-01f, 2.48107344e-01f, -4.94175702e-02f, -1.34000117e-02f, -2.29641963e-02f,
  2.79341251e-01f, -5.26045151e-02f, -2.85789341e-01f, 1.28273591e-01f, 4.59290221e-02f, 4.53188308e-02f, -1.53816625e-01f, 1.45215034e-01f, 1.06713235e-01f, -2.22273901e-01f,
  2.85147242e-02f, -1.04152961e-02f, -3.62384021e-02f, 1.39621004e-01f, 8.20400715e-02f, 4.46404051e-03f, 1.13236569e-01f, 3.87521207e-01f, 2.98644125e-01f, 4.55771357e-01f,
  1.78747848e-02f, 3.57814372e-01f, 4.29796606e-01f, 1.37596512e-02f, -2.94184804e-01f, 1.38610289e-01f, -2.55917788e-01f, 2.44918793e-01f, -2.17747644e-01f, 3.18241358e-01f,
  -7.71674514e-02f, -2.48745531e-01f, -5.63618653e-02f, 5.91265485e-02f, -1.66149870e-01f, -5.65088801e-02f, -7.42290495e-03f, 1.70015901e-01f, 9.12925154e-02f, 5.90462275e-02f,
  9.97527987e-02f, 8.02247152e-02f, -8.81287158e-02f, 1.07233904e-01f, 6.67637661e-02f, 8.06464031e-02f, -5.35865091e-02f, -1.65061042e-01f, 2.24767569e-02f, 4.39838655e-02f,
  -2.52934933e-01f, -6.61479756e-02f, -6.27661496e-02f, 2.39864618e-01f, -6.13810606e-02f, -1.39304632e-02f, 1.19148213e-02f, 7.31769949e-02f, 2.21608818e-01f, -2.39785701e-01f,
  -8.50924253e-02f, 4.44108583e-02f, -1.54517516e-01f, 1.81260988e-01f, 2.61737276e-02f, 1.56021230e-02f, 6.04214929e-02f, 1.23073027e-01f, 9.35776904e-02f, 2.92699225e-02f,
  1.12647740e-02f, -8.11125264e-02f, -2.18029767e-01f, 7.46869221e-02f, -3.67740184e-01f, -2.68627498e-02f, -2.39880383e-01f, -8.10046569e-02f, -3.72075662e-02f, 1.16505042e-01f,
  -1.74410313e-01f, 1.83805525e-01f, -6.87808022e-02f, -2.62610435e-01f, 1.94693893e-01f, 3.27654555e-02f, 3.91922861e-01f, -3.48923564e-01f, 3.07663620e-01f, 8.21096972e-02f,
  3.32146108e-01f, 5.12973428e-01f, 6.65231794e-02f, -1.20311096e-01f, 2.74215341e-01f, 1.64565995e-01f, 1.64605275e-01f, -5.73296892e-03f, 8.33798051e-02f, 6.57960847e-02f,
  8.92078131e-02f, -1.70211375e-01f, 4.18134555e-02f, 3.48929465e-02f, 3.63521883e-03f, -4.74628359e-02f, 1.08634427e-01f, 3.17645818e-02f, -2.43768990e-02f, -2.64592245e-02f,
  4.00130823e-02f, 2.21646801e-02f, -2.47229841e-02f, -1.52717838e-02f, 2.03933954e-01f, 1.04194492e-01f, 8.08231905e-02f, -1.44946307e-01f, 2.01026611e-02f, 2.91392114e-02f,
  4.75989189e-03f, -3.86011153e-02f, -1.43139392e-01f, 8.31846222e-02f, 7.78681561e-02f, 1.93168018e-02f, 1.57666668e-01f, -6.72030635e-03f, -9.26730633e-02f, 1.99238583e-02f,
  1.14216609e-02f, 6.34056181e-02f, -2.05561727e-01f, -5.98752461e-02f, 6.08979128e-02f, 8.51777792e-02f, 2.01605201e-01f, 1.41544119e-02f, 1.94024429e-01f, 5.36433980e-02f,
  7.53590614e-02f, 3.04154605e-02f, -1.07339278e-01f, 1.01497531e-01f, 4.26347792e-01f, 1.81551166e-02f, 1.86491534e-01f, 6.57392889e-02f, 2.72642493e-01f, 9.35208946e-02f,
  -1.13828674e-01f, 3.23104203e-01f, -1.11092031e-02f, -6.07486889e-02f, 6.34831861e-02f, -9.71864238e-02f, 3.02035779e-01f, 8.41198340e-02f, 2.19312713e-01f, 1.99705437e-01f,
  -7.27889175e-03f, 7.23608285e-02f, 1.75520286e-01f, 2.76295170e-02f, 7.23184645e-02f, -1.37888521e-01f, 8.08898285e-02f, 1.14474848e-01f, 8.60284418e-02f, 5.19739790e-03f,
  1.06350109e-01f, 9.50223655e-02f, 1.37628749e-01f, 8.03270787e-02f, -2.46312097e-02f, 3.49640511e-02f, -6.32242160e-03f, -7.91935530e-03f, 1.31651968e-01f, 2.02289466e-02f,
  -9.04792920e-02f, 9.11856350e-03f, -8.48720148e-02f, 1.34016857e-01f, -4.93866764e-02f, -8.90981872e-03f, -1.56386733e-01f, -1.43923149e-01f, 1.62030578e-01f, 1.11530095e-01f,
  1.72087610e-01f, 1.36705369e-01f, -6.48004329e-03f, 1.15350932e-02f, 3.53786573e-02f, -5.88819310e-02f, -2.78204203e-01f, -7.23289549e-02f, -4.67363670e-02f, -7.09875748e-02f,
  6.53842613e-02f, -1.22049317e-01f, -4.16175537e-02f, -4.52049896e-02f, -1.63023144e-01f, 7.31274113e-02f, -4.32233550e-02f, 2.55995780e-01f, 4.20958996e-01f, 1.01476669e-01f,
  2.34783068e-01f, -1.24058381e-01f, 4.36035484e-01f, -4.26333472e-02f, 1.46376222e-01f, 3.58491570e-01f, -1.03985714e-02f, -3.57776321e-02f, 1.82674751e-01f, 1.14718668e-01f,
  2.67288893e-01f, -1.21044345e-01f, -1.72942057e-01f, -8.61787517e-03f, 1.48995623e-01f, -4.47358377e-02f, 2.11336445e-02f, 4.03543077e-02f, -1.26946103e-02f, 3.15922648e-02f,
  -7.68702105e-02f, 2.08972722e-01f, -3.56011465e-02f, 4.83769961e-02f, 6.43667504e-02f, -2.70653013e-02f, -3.46960276e-02f, 1.16955072e-01f, 3.93984206e-02f, 2.62357425e-02f,
  7.84943998e-02f, -3.23603339e-02f, -3.02462038e-02f, 4.18246277e-02f, 1.51633516e-01f, -1.84216037e-01f, 3.68145946e-03f, 1.60832927e-02f, 2.22905055e-01f, 1.41470775e-01f,
  2.53408141e-02f, 4.89264950e-02f, -2.00035349e-01f, -3.17426547e-02f, -1.51875138e-01f, -5.36106043e-02f, -4.45488170e-02f, -8.78968462e-02f, 2.72321880e-01f, -1.08976379e-01f,
  1.16071433e-01f, -1.70806080e-01f, -3.93798063e-03f, 5.02993166e-02f, -6.54922947e-02f, 1.68320239e-01f, 1.00235464e-02f, 7.75697753e-02f, 1.25583827e-01f, -8.42911899e-02f,
  -1.68625474e-01f, -8.00472200e-02f, -1.51931290e-02f, 7.70522747e-03f, -4.86391336e-02f, 2.57339869e-02f, 5.76497726e-02f, 1.84976105e-02f, -2.49876276e-01f, 1.09962888e-01f,
  2.67812788e-01f, -7.71814911e-03f, 2.79621840e-01f, 1.05497554e-01f, 2.77222872e-01f, 1.58424512e-01f, -9.59473327e-02f, 2.59506274e-02f, 2.12652728e-01f, -2.93684453e-02f,
  1.19834907e-01f, 6.80921450e-02f, 4.52830307e-02f, 4.55815718e-02f, -3.18408459e-02f, 1.90891176e-01f, -1.31139502e-01f, 1.96612954e-01f, 6.97846860e-02f, -1.11691887e-02f,
  4.11315709e-02f, 1.21743381e-01f, 8.85422826e-02f, 2.40120385e-02f, 1.06044158e-01f, -3.23471911e-02f, -9.70066153e-03f, 1.38276559e-03f, 1.65646136e-01f, -4.59576026e-02f,
  1.82328790e-01f, 3.04046483e-03f, 1.51637509e-01f, -5.34584932e-02f, 1.05305232e-01f, 1.75952122e-01f, -7.14076161e-02f, -3.18190485e-01f, -1.93138719e-01f, -2.14836761e-01f,
  1.03435069e-01f, -1.62829965e-01f, 1.01772964e-01f, -9.42147244e-03f, 1.39907598e-01f, -1.57163709e-01f, -3.58651131e-02f, 1.52561128e-01f, -1.09436780e-01f, 1.33765996e-01f,
  4.02790196e-02f, 4.15567821e-03f, 1.05509013e-01f, 9.54242200e-02f, -1.07741572e-01f, -1.05808049e-01f, -8.77527669e-02f, 3.13583165e-02f, -1.18869141e-01f, 1.36548385e-01f,
  -1.16019920e-01f, 5.82648888e-02f, 1.46488860e-01f, 3.18028666e-02f, -2.74737552e-02f, 2.53444135e-01f, 1.26160800e-01f, -1.16287962e-01f, 1.26174405e-01f, 3.34902257e-01f,
  -6.22398220e-02f, -3.87834385e-02f, 4.34445031e-02f, 9.88483876e-02f, -8.02640542e-02f, 1.08207926e-01f, 6.06985278e-02f, 1.13277204e-01f, 6.27746135e-02f, 7.85851013e-03f,
  4.45472226e-02f, -8.41935426e-02f, 1.92432124e-02f, -7.07219839e-02f, -1.46304011e-01f, 2.99423691e-02f, 4.29133214e-02f, 1.07490532e-01f, 5.60725257e-02f, -9.89295319e-02f,
  -6.22496866e-02f, 9.20184981e-03f, 8.42609107e-02f, -2.01155409e-01f, -1.02045454e-01f, -6.39254749e-02f, 1.38094425e-01f, 2.00412869e-01f, -1.97270159e-02f, -1.28485069e-01f,
  -1.60950363e-01f, 1.25594139e-01f, -1.57974474e-02f, 7.07847923e-02f, -3.03869918e-02f, -1.09309152e-01f, 1.65233389e-01f, -1.78218737e-01f, 4.10666876e-02f, -1.05845265e-01f,
  -1.33404121e-01f, -9.79650542e-02f, -1.65487304e-02f, 8.81874785e-02f, -4.34965780e-03f, 9.84888226e-02f, 1.32293865e-01f, -1.67208523e-01f, -9.07132179e-02f, -6.24790378e-02f,
  -3.82535309e-02f, -9.41417739e-02f, 4.72868700e-03f, -1.09500829e-02f, -6.82585407e-03f, 2.38674134e-02f, -2.16705054e-01f, 1.76855415e-01f, 2.94380754e-01f, -6.90793395e-02f,
  2.05205917e-01f, 1.81894273e-01f, 2.69669503e-01f, 1.66071430e-01f, -1.54799685e-01f, 2.66759396e-02f, 6.21552505e-02f, 8.89087543e-02f, 3.37827951e-02f, 8.41453448e-02f,
  6.01608381e-02f, -5.95032647e-02f, 6.01565950e-02f, 1.61135122e-01f, 1.24316499e-01f, 1.29267544e-01f, 4.53058258e-02f, 4.91241068e-02f, 6.52365386e-02f, 2.13279620e-01f,
  -3.28229107e-02f, 9.44861025e-02f, 1.17060117e-01f, -5.56210764e-02f, -1.41008884e-01f, -7.27697611e-02f, 2.14944124e-01f, -1.50858417e-01f, 8.87272507e-03f, -1.05052209e-02f,
  8.53528529e-02f, 8.15048218e-02f, -1.85183827e-02f, 5.10046892e-02f, -9.51905176e-02f, 1.76832870e-01f, 1.48860097e-01f, 1.11839756e-01f, 1.26385689e-01f, 1.98574051e-01f,
  2.09450498e-01f, -1.84924632e-01f, 2.76063114e-01f, -9.63220652e-03f, 1.63060188e-01f, 2.16634750e-01f, 1.96991250e-01f, -9.82598290e-02f, 1.24315210e-01f, 1.09081566e-01f,
  -8.04890096e-02f, -1.86613649e-01f, -1.52868703e-01f, 5.60159609e-03f, -1.59433857e-01f, 4.38301802e-01f, 2.82053620e-01f, 8.43624845e-02f, 2.40136340e-01f, 4.31089938e-01f,
  -4.05845404e-01f, -1.00115789e-02f, -1.46598816e-02f, -2.51210600e-01f, 1.56772092e-01f, 4.71927822e-01f, -2.89147859e-03f, 1.18895054e-01f, 1.04449436e-01f, 8.37681368e-02f,
  -6.48704767e-02f, 1.54910028e-01f, 2.39670947e-02f, -1.92165244e-02f, 4.36048284e-02f, 1.03479221e-01f, 1.12272002e-01f, -1.32789612e-01f, -7.61400966e-04f, 1.10869862e-01f,
  9.37566161e-02f, -1.24267144e-02f, 5.02311327e-02f, -9.80812684e-02f, 1.04378216e-01f, 4.23719026e-02f, 4.56085242e-02f, 3.40200542e-03f, 9.66638997e-02f, 1.02569044e-01f,
  -2.22426765e-02f, 1.55603722e-01f, 2.10248917e-01f, -3.41388285e-02f, 2.01055706e-02f, -1.58774197e-01f, -2.38382947e-02f, 2.54040509e-01f, 1.34183198e-01f, -8.58526751e-02f,
  1.61797762e-01f, -2.34885305e-01f, 1.54226810e-01f, -8.28939825e-02f, -2.01720804e-01f, -3.02461907e-02f, -1.24785490e-01f, -3.32640223e-02f, -1.56256452e-01f, -1.11283466e-01f,
  6.77944347e-02f, -8.83188695e-02f, 2.48988867e-01f, -4.50814515e-02f, 1.42551720e-01f, 8.96275714e-02f, -2.51964899e-04f, -7.28004030e-04f, 2.33365342e-01f, 1.75607905e-01f,
  2.49846578e-01f, 4.00212914e-01f, -1.30830348e-01f, 2.07315579e-01f, 7.59354010e-02f, 2.28634700e-01f, -1.71857908e-01f, 1.71338290e-01f, -1.82829842e-01f, -2.93803848e-02f,
  8.25433880e-02f, 2.21194223e-01f, 1.11715183e-01f, 1.10742085e-01f, 4.86768670e-02f, 7.58587047e-02f, 9.35889110e-02f, 1.54034421e-02f, 1.29970796e-02f, 6.95191771e-02f,
  1.01418279e-01f, -7.40936995e-02f, -2.38859262e-02f, 1.39454842e-01f, 6.53957278e-02f, 6.35269508e-02f, 1.23928986e-01f, 3.66032757e-02f, 1.05625354e-01f, 4.48412783e-02f,
  7.15244487e-02f, 1.79979540e-02f, 8.98171216e-02f, 1.11320227e-01f, -6.00876175e-02f, 1.83881000e-01f, 1.88459232e-01f, -4.14546616e-02f, -1.28765047e-01f, -2.43215203e-01f,
  1.03771210e-01f, 1.70307919e-01f, 2.31611311e-01f, -2.35008553e-01f, -9.18387398e-02f, -1.60934076e-01f, 1.89898998e-01f, -1.62778780e-01f, -2.30325565e-01f, 1.36022061e-01f,
  -3.09600886e-02f, -5.23173250e-02f, -1.56390712e-01f, 8.92054141e-02f, -2.16126442e-02f, -8.34940597e-02f, 6.13842160e-02f, -1.03169106e-01f, -1.10171186e-02f, 2.73338825e-01f,
  7.17947558e-02f, 1.09295575e-02f, 1.60912007e-01f, 1.98570341e-01f, 1.41499966e-01f, 3.33623976e-01f, -2.32531484e-02f, 9.75896195e-02f, 5.45850694e-01f, 9.44071487e-02f,
  -1.86332956e-01f, 3.71039480e-01f, -9.37881991e-02f, -1.07716352e-01f, 1.40034473e-02f, 2.84514219e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  1.09105203e-02f, 1.02636889e-01f, 2.17863191e-02f, 1.08404391e-01f, 7.29334950e-02f, 1.12763993e-01f, 3.99741977e-02f, 7.11259916e-02f, 7.47226775e-02f, 6.83655068e-02f,
  9.89865735e-02f, 5.25117777e-02f, 9.23617184e-02f, 8.97385404e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  4.91430350e-02f, -1.08380750e-01f, -2.14093074e-01f, 1.93517998e-01f, -1.84126899e-01f, 1.32903844e-01f, -3.50123256e-01f, -4.72172946e-02f, -1.78201512e-01f, -1.58410043e-01f,
  -3.16126376e-01f, -5.73333353e-02f, -1.30134881e-01f, -9.84278694e-02f, -7.58890361e-02f, -4.55863029e-02f, -1.68077409e-01f, -2.74806678e-01f, 1.56927004e-01f, 1.16735324e-02f,
  -7.69823836e-03f, 1.28287435e-01f, 2.67189126e-02f, -2.09611341e-01f, -2.14584067e-01f, 1.63111717e-01f, -1.43940106e-01f, 5.22482060e-02f, 3.43188308e-02f, 2.93918252e-01f,
  -1.25718057e-01f, -5.89885786e-02f, -2.61946142e-01f, -2.54907161e-01f, -3.50524522e-02f, -4.58283536e-02f, 9.35722888e-02f, 1.19916782e-01f, 2.39783838e-01f, 6.04287386e-02f,
  -1.78324386e-01f, -2.17800245e-01f, -1.82067007e-01f, 5.04624806e-02f, 9.56987143e-02f, 2.60515869e-01f, -7.92826787e-02f, 2.98054427e-01f, -1.85358539e-01f, 8.53775293e-02f,
  -3.12125653e-01f, -5.83974123e-01f, 2.01562822e-01f, -3.31238687e-01f, 3.04118037e-01f, -4.86865975e-02f, 5.83092384e-02f, -1.01023234e-01f, -3.77162963e-01f, -2.28509679e-01f,
  -2.79436857e-01f, 2.86835581e-01f, 1.70098990e-01f, -1.80111434e-02f, -1.63717836e-01f, 2.86095560e-01f, 2.18404904e-02f, 7.33724013e-02f, -1.19745871e-02f, 1.18129194e-01f,
  -2.49590918e-01f, 1.64032698e-01f, 1.76188469e-01f, -1.93271488e-01f, -9.62704234e-03f, 1.04250601e-02f, -5.93951680e-02f, -6.79692850e-02f, 2.42668852e-01f, -2.50427634e-01f,
  -2.16384381e-01f, -8.93561542e-02f, 1.99504346e-01f, -1.66602448e-01f, -2.29766205e-01f, -1.69122532e-01f, 2.99661737e-02f, 1.40215114e-01f, 1.11636735e-01f, -2.52724797e-01f,
  1.54091150e-01f, 1.39889285e-01f, 1.37175933e-01f, 1.47681698e-01f, 1.40621036e-01f, 1.12917475e-01f, 6.61522895e-02f, 1.35225177e-01f, -2.09567621e-01f, 8.46465752e-02f,
  2.58657664e-01f, 1.29645512e-01f, -1.83452055e-01f, -1.38716161e-01f, -1.44035161e-01f, -1.57018125e-01f, -1.78691506e-01f, -1.35993317e-01f, -1.46899015e-01f, 1.42165795e-01f,
  -2.80895710e-01f, -1.73744038e-01f, -2.06881374e-01f, -9.60934013e-02f, 1.52050510e-01f, -6.57752097e-01f, 3.47228080e-01f, 3.27028900e-01f, -3.12430531e-01f, -7.74333328e-02f,
  7.17502236e-02f, 1.21809408e-01f, 2.87366956e-02f, -1.62881851e-01f, 2.71141138e-02f, 2.16739148e-01f, -3.11182946e-01f, -3.69575948e-01f, -1.90902323e-01f, -1.05765969e-01f,
  9.38445032e-02f, -1.25024945e-01f, 1.41656697e-01f, -9.22136083e-02f, 2.07226187e-01f, -2.09063783e-01f, -1.75991878e-01f, 1.29581288e-01f, 5.93965501e-02f, 1.79435939e-01f,
  -1.77004382e-01f, -5.71125746e-02f, -1.96256131e-01f, 9.75952074e-02f, -2.01586057e-02f, 6.51256591e-02f, 2.99466979e-02f, 5.76328896e-02f, -1.45194650e-01f, 5.88189699e-02f,
  -6.19328097e-02f, -1.80880740e-01f, -1.09871812e-01f, 6.68659359e-02f, 8.25872943e-02f, -1.89437225e-01f, 1.19728729e-01f, 1.01667278e-01f, 1.35088548e-01f, -5.25696799e-02f,
  -2.14802101e-01f, 2.74414539e-01f, 1.52993724e-01f, -1.19359437e-02f, 2.06919253e-01f, -2.63236523e-01f, -7.90212899e-02f, -1.52681410e-01f, -9.08316448e-02f, 2.33743668e-01f,
  2.30308384e-01f, -2.30600461e-01f, -1.85849622e-01f, -3.04522187e-01f, -2.56063193e-02f, -3.06937605e-01f, 8.87356699e-02f, 2.47674629e-01f, 7.02652335e-02f, 7.42476732e-02f,
  2.91159153e-02f, 3.30429226e-01f, -2.53611863e-01f, 3.48808318e-01f, -1.23899654e-01f, -3.16026062e-02f, 1.09445052e-02f, -3.18017036e-01f, 1.33908182e-01f, -5.26499450e-01f,
  -3.31587166e-01f, -3.68148148e-01f, -1.86424494e-01f, 1.85957253e-01f, -1.73556805e-01f, -1.40796617e-01f, 3.50490212e-02f, 2.79327519e-02f, -7.45278969e-02f, -9.52826589e-02f,
  -1.75852180e-01f, -1.80371165e-01f, -2.01486334e-01f, 1.31356284e-01f, 2.17739306e-02f, 9.78539214e-02f, 6.42544031e-03f, -1.24300696e-01f, -1.33673966e-01f, 9.41967741e-02f,
  -1.44889086e-01f, 1.69400036e-01f, -2.01398104e-01f, 1.08917430e-01f, -1.81093037e-01f, 6.07954971e-02f, 2.33328864e-02f, 2.56678432e-01f, -1.33873727e-02f, -1.82177380e-01f,
  -1.77786067e-01f, -2.12285116e-01f, 1.11098699e-01f, 2.09868610e-01f, 1.82431683e-01f, 2.33633420e-03f, -2.23731533e-01f, 7.97052216e-03f, 8.73562172e-02f, 4.59487699e-02f,
  5.73941926e-03f, 2.25910693e-01f, 1.75398171e-01f, 2.41651267e-01f, -6.42877221e-02f, 1.85140967e-01f, 2.19156474e-01f, -6.10768422e-02f, 1.03675343e-01f, 2.69635350e-01f,
  -2.57784933e-01f, -2.07545727e-01f, -1.84021801e-01f, -7.24511087e-01f, -2.07098529e-01f, 3.28804195e-01f, 2.84694463e-01f, -4.75159436e-01f, -1.92977175e-01f, -3.90840411e-01f,
  -2.10832074e-01f, 7.59369209e-02f, -2.80019492e-01f, -3.16873372e-01f, 2.34344587e-01f, 3.12591851e-01f, -1.64546251e-01f, -3.51844989e-02f, 1.43677508e-02f, 1.06853396e-01f,
  -2.02168059e-02f, -2.14319944e-01f, 1.74691290e-01f, -2.65274882e-01f, 2.12829802e-02f, 3.30321640e-02f, -3.35084289e-01f, -1.15560450e-01f, 3.72191444e-02f, 7.94098675e-02f,
  -1.77859351e-01f, -2.41674379e-01f, 1.13892950e-01f, -1.56933069e-01f, -2.09571302e-01f, -3.01992506e-01f, 4.87088300e-02f, 1.62644051e-02f, 1.71337411e-01f, 1.08177274e-01f,
  -1.80746973e-01f, 2.24102706e-01f, -2.31438205e-01f, -1.21382512e-01f, 5.44934496e-02f, -1.65659755e-01f, -1.37625495e-02f, -9.63613018e-02f, 4.57653068e-02f, -3.45863849e-02f,
  1.77563161e-01f, -7.87204802e-02f, -1.55867219e-01f, -2.58826822e-01f, 2.37422325e-02f, -1.93957418e-01f, -1.48446053e-01f, 2.77214050e-01f, 2.70345241e-01f, -1.78176954e-01f,
  -5.43943755e-02f, -2.41449729e-01f, -1.93903998e-01f, -2.90865749e-01f, 2.88221002e-01f, 9.47547629e-02f, -4.21654075e-01f, -1.34257982e-02f, -3.95358145e-01f, -6.05406642e-01f,
  2.42214873e-01f, -2.76185960e-01f, 2.22960278e-01f, 2.05328196e-01f, -4.20521468e-01f, -1.04055434e-01f, -4.24278647e-01f, -3.11602980e-01f, 2.97741443e-01f, 1.96529701e-01f,
  2.39068672e-01f, -2.02004030e-01f, 2.62744516e-01f, -2.72858471e-01f, 1.10420123e-01f, 1.77857175e-01f, 2.06801504e-01f, -3.09484541e-01f, 2.49607246e-02f, 1.64903909e-01f,
  2.90576071e-01f, 2.04143107e-01f, 1.21948458e-01f, 2.74316669e-01f, -7.11664781e-02f, -1.63356230e-01f, -5.38394824e-02f, 3.28089386e-01f, -2.97782093e-01f, 1.61230639e-01f,
  9.29691121e-02f, 1.12674192e-01f, 1.46201970e-02f, 1.77914530e-01f, -2.37729639e-01f, 9.36326981e-02f, -1.94474012e-01f, 4.49097484e-01f, 1.00086182e-01f, -2.29959533e-01f,
  1.78405628e-01f, 5.28902858e-02f, 7.42844716e-02f, 2.75050491e-01f, 2.48588637e-01f, 6.81246594e-02f, -1.59575164e-01f, 2.78117806e-01f, -1.13077210e-02f, 2.78813183e-01f,
  -1.88252747e-01f, -2.88242251e-01f, -2.18228437e-02f, 3.03035583e-02f, -8.53846297e-02f, 3.80261660e-01f, -2.21694320e-01f, -3.94040704e-01f, 1.60021428e-02f, -1.68464303e-01f,
  9.81657393e-03f, -1.50625408e-01f, 1.97035093e-02f, -5.42596996e-01f, -9.29271206e-02f, -5.51499963e-01f, 2.06619486e-01f, 2.63961583e-01f, 4.22619581e-02f, -1.87560227e-02f,
  -8.70619863e-02f, 1.49091706e-01f, 3.94970402e-02f, -7.59799853e-02f, -1.95741579e-02f, 7.53833950e-02f, 1.13879383e-01f, -2.74910510e-01f, 5.49885295e-02f, -2.65949756e-01f,
  -1.89813584e-01f, 2.69548714e-01f, -2.37277597e-01f, 7.05369785e-02f, -2.61496574e-01f, -4.49571423e-02f, 1.35192154e-02f, 4.80153710e-02f, 2.17819765e-01f, -1.37698531e-01f,
  9.45868790e-02f, -2.51297742e-01f, 2.60076493e-01f, -4.98511903e-02f, 1.40483797e-01f, -5.56330495e-02f, -1.95265621e-01f, -2.62685210e-01f, 8.85730684e-02f, -1.94514841e-01f,
  1.97289810e-01f, -3.23593229e-01f, 8.29513893e-02f, -1.85036972e-01f, -1.19858840e-02f, -6.19468130e-02f, 3.24870124e-02f, 4.93753292e-02f, -2.26806030e-01f, 1.07602306e-01f,
  -2.90577620e-01f, -2.55033851e-01f, -6.71030162e-03f, 8.34416877e-03f, 2.11962014e-01f, -2.66696155e-01f, 1.21405318e-01f, 8.86788666e-02f, 2.37941965e-01f, 3.87505651e-01f,
  -1.91445947e-01f, 7.21132159e-02f, -4.22325209e-02f, -1.05527245e-01f, 2.35187829e-01f, 1.81135505e-01f, -1.05552645e-02f, -3.37990731e-01f, -4.28643912e-01f, -4.43325877e-01f,
  1.78304881e-01f, 1.00346610e-01f, -1.89928096e-02f, -2.83087671e-01f, 2.34943166e-01f, -1.27774402e-01f, -1.16967395e-01f, -4.61782873e-01f, 2.00082958e-01f, -3.83480974e-02f,
  1.75802246e-01f, 1.11973114e-01f, 4.85098809e-02f, 2.05731481e-01f, 2.36817971e-01f, 1.59077942e-01f, 1.29071295e-01f, 2.28021696e-01f, -2.26425022e-01f, -2.01008588e-01f,
  7.78518543e-02f, -1.45701706e-01f, 1.33072942e-01f, 1.89782679e-01f, 1.53412372e-01f, -6.51072711e-02f, 1.17085151e-01f, -3.64620821e-03f, 1.17316015e-01f, -1.73572645e-01f,
  2.62836646e-02f, -3.62171419e-02f, 1.25795722e-01f, -1.90544784e-01f, 1.80347875e-01f, -1.97438464e-01f, -1.81448057e-01f, -2.57890642e-01f, -1.52300373e-01f, 6.44712299e-02f,
  2.01438610e-02f, -1.21158227e-01f, -1.36191761e-02f, -1.84768159e-02f, 2.04258531e-01f, -2.71233648e-01f, -2.34844103e-01f, -2.76035190e-01f, 8.04416761e-02f, -2.12150216e-01f,
  -2.61352211e-01f, 1.62238345e-01f, -2.74236590e-01f, -2.05938041e-01f, -1.78014532e-01f, 1.58902064e-01f, -2.12006733e-01f, 1.94683939e-01f, 5.99360690e-02f, -1.80994555e-01f,
  -2.24060431e-01f, -1.82052851e-01f, 1.98577270e-01f, 4.52121109e-01f, -2.40175486e-01f, 5.88526502e-02f, -2.63338298e-01f, 1.18919864e-01f, -1.73455253e-01f, -2.70812392e-01f,
  -1.89486384e-01f, 2.43075907e-01f, -1.20847292e-01f, -2.49644071e-01f, -4.68387902e-02f, -1.64775968e-01f, -2.54370213e-01f, 8.28314647e-02f, 2.14491442e-01f, 1.05723359e-01f,
  9.30169038e-03f, 1.83357045e-01f, 4.27423529e-02f, -2.12782130e-01f, 9.89711508e-02f, 8.27704966e-02f, -2.06366286e-01f, 4.07551751e-02f, 7.01258779e-02f, -5.48322732e-03f,
  -1.12900339e-01f, -8.08089077e-02f, 5.23194745e-02f, 2.83499295e-03f, 1.17869325e-01f, -1.06001467e-01f, -2.34662313e-02f, 1.82281449e-01f, 2.31517687e-01f, 2.44699612e-01f,
  -1.47847816e-01f, 1.33861840e-01f, -1.12006329e-01f, 1.05669379e-01f, -6.08085375e-03f, -1.67685494e-01f, 1.01050071e-01f, -6.35029748e-02f, -8.02439600e-02f, 1.36667877e-01f,
  2.83376098e-01f, -1.88543096e-01f, 1.70533419e-01f, 6.52676309e-03f, -1.79243147e-01f, -2.00805813e-01f, -4.86715250e-02f, 1.87231928e-01f, 3.13223958e-01f, 2.95535535e-01f,
  2.27057904e-01f, 1.18345572e-02f, 1.69461086e-01f, 1.07294291e-01f, -3.90532501e-02f, -7.24616587e-01f, -2.48586312e-01f, 3.78670245e-01f, -4.89874542e-01f, 1.20931022e-01f,
  4.64197528e-03f, -2.15138644e-01f, -2.17417758e-02f, 2.62004107e-01f, -1.28102094e-01f, -3.71118397e-01f, 2.01655552e-01f, 1.54662579e-01f, -2.08072439e-02f, 2.11180985e-01f,
  -1.16205923e-01f, -2.04956532e-01f, 1.85606360e-01f, 1.26280606e-01f, 2.44674042e-01f, -1.61095276e-01f, 2.16402620e-01f, -2.54862368e-01f, -1.58168390e-01f, -8.75797942e-02f,
  5.36633357e-02f, 2.55894721e-01f, 7.79822841e-02f, -1.20923474e-01f, -2.71196306e-01f, 1.05802402e-01f, -7.74436966e-02f, 1.74545392e-01f, -1.54070407e-01f, 3.96939889e-02f,
  1.28804862e-01f, -1.38209745e-01f, -1.58717319e-01f, 9.42250863e-02f, -1.89031358e-03f, -1.20346747e-01f, -2.32561752e-01f, -1.89168379e-01f, -4.99203987e-02f, 2.00358450e-01f,
  -5.36951013e-02f, -1.02505870e-02f, -1.62043288e-01f, -2.34691292e-01f, -8.28901902e-02f, 1.49720132e-01f, -1.06756659e-02f, 1.32919535e-01f, -5.82644902e-02f, 4.97370325e-02f,
  2.24406108e-01f, -1.65233359e-01f, 2.68577665e-01f, -1.86573535e-01f, 2.64481485e-01f, 1.11115510e-02f, -3.54863882e-01f, 1.13842316e-01f, -2.02331066e-01f, 3.93079251e-01f,
  -3.39909077e-01f, -3.41833562e-01f, 8.71631503e-02f, -7.16655562e-03f, -4.69612004e-03f, 1.72030881e-01f, -7.02720582e-02f, -3.52670968e-01f, 1.70812771e-01f, 4.01125029e-02f,
  1.80257857e-01f, -3.83830592e-02f, -7.20730498e-02f, 2.06361949e-01f, 1.21447802e-01f, -2.88140446e-01f, -5.24247363e-02f, 1.87818825e-01f, 1.55284971e-01f, 1.80060074e-01f,
  2.17902660e-01f, 8.58613998e-02f, 1.10977441e-01f, 1.14567108e-01f, 1.90855324e-01f, 2.29825705e-01f, -5.71034998e-02f, 1.62604436e-01f, 1.32727176e-01f, -2.03954969e-02f,
  1.40160263e-01f, -5.91719225e-02f, 3.16894613e-02f, 2.08385944e-01f, 3.33028100e-02f, -2.18426511e-02f, 1.40002787e-01f, -2.44562164e-01f, 5.31209745e-02f, 1.02002852e-01f,
  1.38308018e-01f, 1.66719034e-01f, -2.15363368e-01f, -1.80774868e-01f, 2.41528340e-02f, 1.13224223e-01f, -3.67871784e-02f, 2.39787042e-01f, -2.70495832e-01f, -2.53462255e-01f,
  -1.07341871e-01f, 1.74636990e-01f, 2.28110746e-01f, -5.85263222e-02f, -2.68367082e-01f, -1.44004956e-01f, 2.72207975e-01f, 2.71538019e-01f, -8.87866020e-02f, 2.19139457e-01f,
  -2.18954653e-01f, -5.93953431e-01f, -1.49771318e-01f, 7.70112038e-01f, -3.08785617e-01f, -4.07668091e-02f, 1.61158480e-02f, -3.75606686e-01f, 2.77095497e-01f, 3.09734434e-01f,
  -3.64162959e-02f, -1.45398211e-02f, -1.57608882e-01f, -1.63694590e-01f, 9.38187391e-02f, -1.61117334e-02f, 4.40223366e-02f, -1.81268707e-01f, 5.08230850e-02f, 1.84334219e-01f,
  -9.04076621e-02f, -1.05391435e-01f, -1.29760027e-01f, -9.86117497e-02f, -2.15540943e-03f, 6.08863775e-03f, 6.36330545e-02f, -1.07752778e-01f, -1.27474532e-01f, -1.61129117e-01f,
  -1.53433103e-02f, 1.17519863e-01f, 1.48200586e-01f, 4.16614525e-02f, -4.31139991e-02f, -2.21496597e-01f, 8.20755810e-02f, -6.30793022e-03f, -6.32441267e-02f, -1.52129024e-01f,
  -2.54793137e-01f, -2.49023899e-01f, 1.71550825e-01f, 1.36253133e-01f, 8.48774463e-02f, 1.39748991e-01f, 8.62964466e-02f, -1.82361677e-01f, -1.48004040e-01f, -6.40468299e-02f,
  1.46942034e-01f, 2.41270989e-01f, 2.62914360e-01f, 7.54923150e-02f, 1.13504671e-01f, 2.44434297e-01f, 2.35081896e-01f, -7.44221583e-02f, 4.60667163e-02f, -2.55547047e-01f,
  2.55110025e-01f, 1.55347586e-01f, -6.99889511e-02f, -1.59642011e-01f, -4.35096085e-01f, 2.38030076e-01f, -2.67040640e-01f, -3.91856492e-01f, 9.77509990e-02f, -1.62641823e-01f,
  -8.46211836e-02f, -4.26103801e-01f, 1.88608423e-01f, 1.60827935e-01f, 2.90062547e-01f, 2.37560779e-01f, 6.30109981e-02f, -1.41864747e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -5.83224483e-02f, -7.44013190e-02f, 3.26149799e-02f, 1.18007855e-02f, 7.48760104e-02f, -8.98865089e-02f, -1.25301450e-01f, -1.75009500e-02f, 6.55928701e-02f, 3.74264754e-02f,
  3.58104408e-02f, -3.74275334e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    