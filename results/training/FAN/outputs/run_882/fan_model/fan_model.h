/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.37481892e-01f, -8.02000538e-02f, 1.41450763e-01f, -2.44435564e-01f, 9.16076601e-02f, 3.24026167e-01f, 2.63196111e-01f, 1.15208447e-01f, -5.91381378e-02f, 3.45837791e-03f,
  -6.19742051e-02f, -4.08274569e-02f, -7.94479921e-02f, 9.43444762e-03f, 1.43591434e-01f, 1.62248135e-01f, 3.64221260e-02f, 1.11775622e-01f, 3.02056015e-01f, 1.86619073e-01f,
  -8.30909878e-04f, -1.11442126e-01f, -9.84030515e-02f, 3.57113518e-02f, -1.69385061e-01f, -1.04773618e-01f, 1.08824605e-02f, -8.31241384e-02f, -1.42281121e-02f, -7.08421320e-02f,
  6.43479675e-02f, -1.21673033e-01f, 9.37104970e-02f, -1.02545857e-01f, -5.13758103e-04f, 8.02122131e-02f, 4.35992852e-02f, -2.66093807e-03f, -5.77334641e-03f, 8.41542035e-02f,
  -7.34266862e-02f, -7.86282420e-02f, 5.80629222e-02f, -2.53234338e-02f, 2.79035456e-02f, 4.37576063e-02f, 4.84575517e-02f, 8.67958516e-02f, 5.07498742e-04f, 2.20285747e-02f,
  -1.00136310e-01f, -5.44969589e-02f, 7.81560391e-02f, 5.08600436e-02f, 1.10408045e-01f, -1.10143274e-01f, -5.97480237e-02f, 3.49813029e-02f, -1.15575278e-02f, -1.07034519e-01f,
  3.04645989e-02f, -5.27101047e-02f, -5.34385145e-02f, -5.40124588e-02f, 1.37768015e-02f, 1.33091668e-02f, 8.72713048e-03f, -5.00013009e-02f, 1.77475214e-02f, -1.25532513e-02f,
  -1.31393166e-03f, 5.09385078e-04f, 8.20208434e-03f, -5.68057038e-02f, 1.19218733e-02f, -7.27755651e-02f, 2.29669996e-02f, 5.81675861e-03f, 5.43886470e-03f, 4.08097096e-02f,
  -8.06464627e-03f, 3.49416509e-02f, 3.47171202e-02f, 5.07041030e-02f, -8.79963022e-03f, -3.76607105e-03f, -4.29869406e-02f, 1.58455912e-02f, -1.18194120e-02f, -3.00899558e-02f,
  -9.75107551e-02f, 1.01951405e-03f, -2.56275646e-02f, -4.58129905e-02f, 2.66447775e-02f, 8.78985040e-03f, -6.20058291e-02f, 2.81986836e-02f, -4.79151309e-02f, 7.01436251e-02f,
  7.49298483e-02f, 3.72289717e-02f, -7.27563649e-02f, 6.58966079e-02f, 2.14440878e-02f, 1.03072725e-01f, -5.42440359e-03f, 6.53481036e-02f, 4.97343354e-02f, 5.91983125e-02f,
  3.00382692e-02f, 8.44220147e-02f, 1.39647685e-02f, 1.03410013e-01f, 6.83768094e-02f, 1.25565350e-01f, 5.09086959e-02f, 8.73586833e-02f, 1.47999525e-01f, 4.04260233e-02f,
  3.18184495e-02f, -1.78660050e-01f, 1.45852968e-01f, 1.21958934e-01f, 1.21879593e-01f, 3.90162803e-02f, 3.20466906e-02f, -1.64470207e-02f, 3.06555368e-02f, 3.29496153e-02f,
  -5.22732399e-02f, 5.00000715e-02f, -3.89792174e-02f, -1.22919314e-01f, 6.05103970e-02f, -2.90499870e-02f, -5.73115461e-02f, -1.73232369e-02f, 1.80506125e-01f, 9.73473955e-03f,
  -3.34903002e-02f, -6.74730763e-02f, -6.50973246e-02f, 2.96903234e-02f, 4.51528318e-02f, 9.32217985e-02f, -7.11207464e-02f, -1.00628257e-01f, 3.61243151e-02f, -1.54085323e-01f,
  1.80993989e-01f, -7.09781051e-02f, 1.88160986e-02f, -7.20018595e-02f, 9.63387713e-02f, 4.23726737e-02f, 9.06955376e-02f, -3.19108628e-02f, 6.98163733e-02f, -1.63361784e-02f,
  2.58022803e-03f, -4.65017967e-02f, -4.20818627e-02f, 5.37005067e-02f, 5.30737340e-02f, -7.39748180e-02f, 2.56290846e-02f, 6.25190884e-02f, 2.06657266e-03f, -2.21608598e-02f,
  -1.07565090e-01f, 4.45449986e-02f, 5.40397577e-02f, 1.81659143e-02f, -5.48131987e-02f, -5.58303595e-02f, -5.05026877e-02f, 1.27677843e-02f, 2.69440580e-02f, 7.05187693e-02f,
  -6.37985617e-02f, 6.11931346e-02f, 4.59474511e-02f, -5.19140996e-02f, 7.76190963e-03f, -5.90308569e-03f, 7.11900517e-02f, -1.40124308e-02f, 2.19216477e-02f, -5.72019666e-02f,
  2.07177941e-02f, 9.47968364e-02f, 1.78388357e-02f, 1.33752087e-02f, -1.39860073e-02f, -6.00688905e-02f, 6.68629557e-02f, -7.20800608e-02f, 8.36209115e-03f, -7.24742040e-02f,
  9.11068246e-02f, -2.56663691e-02f, 1.20458238e-01f, -5.51069677e-02f, -1.01676621e-02f, -2.74250396e-02f, 5.89165557e-03f, -3.39930579e-02f, -6.01157360e-02f, 7.99190030e-02f,
  6.40279204e-02f, -7.17590302e-02f, -1.76906101e-02f, 4.51133493e-03f, -5.52296359e-03f, -1.81238204e-02f, -6.60128370e-02f, -3.44242603e-02f, -2.81652100e-02f, -3.64617109e-02f,
  -2.50897277e-02f, 4.71224859e-02f, 6.88401461e-02f, 3.12573500e-02f, 1.70938335e-02f, -2.89269201e-02f, 2.66726222e-02f, 9.83092561e-02f, 7.48420656e-02f, -4.30543162e-02f,
  7.85062686e-02f, 2.10407421e-01f, 2.36221343e-01f, 1.33096904e-01f, 2.17111688e-02f, 1.05278179e-01f, 8.22583735e-02f, 7.56547507e-03f, 8.97212550e-02f, 2.18561381e-01f,
  5.34290016e-01f, 3.18932161e-02f, 1.49125047e-03f, -3.02031487e-02f, -4.63305563e-02f, 1.50458872e-01f, 2.96645254e-01f, 1.52712777e-01f, -7.49782249e-02f, 6.73854956e-03f,
  -1.62704781e-01f, -2.74421573e-01f, -1.75562486e-01f, -1.77921593e-01f, 8.47964659e-02f, 1.52704949e-02f, 7.63119906e-02f, 1.36937007e-01f, 7.28114247e-02f, -3.02335038e-03f,
  -1.24267563e-01f, 1.27624333e-01f, 1.97614759e-01f, 1.20412506e-01f, -1.41547099e-01f, -1.94684595e-01f, -1.07307352e-01f, 1.06562907e-02f, -4.42934670e-02f, -1.24577530e-01f,
  -1.74692765e-01f, 1.31856455e-02f, -1.08073493e-02f, 3.04972790e-02f, -4.73410562e-02f, 7.67548606e-02f, 3.52767110e-02f, 1.00558996e-02f, 4.04739007e-03f, -1.92400534e-02f,
  -2.18619220e-02f, 3.47424820e-02f, -4.14655507e-02f, -5.13015725e-02f, -4.30823304e-03f, 8.11279267e-02f, 1.06722698e-01f, 6.47608861e-02f, 5.31206354e-02f, -4.95751202e-02f,
  -1.75840691e-01f, -8.29627812e-02f, 4.78575490e-02f, -7.35625625e-02f, 3.75122502e-02f, -6.63981438e-02f, 1.60784628e-02f, -8.53645504e-02f, -2.09719874e-02f, 8.08746647e-03f,
  8.19078237e-02f, 2.61523500e-02f, -4.38292809e-02f, -1.46276578e-02f, 1.14544734e-01f, -8.69450048e-02f, -3.26876119e-02f, 3.60781252e-02f, 7.11139217e-02f, 9.76347029e-02f,
  -4.12874967e-02f, -2.05805227e-02f, 1.08017279e-02f, 7.26503134e-02f, -4.74559292e-02f, -7.52043128e-02f, -5.46274111e-02f, -1.31216552e-02f, 5.63546158e-02f, -3.06651592e-02f,
  -1.66993979e-02f, 1.62450690e-02f, -7.04738265e-03f, -6.20564148e-02f, -3.44810449e-02f, -7.02919811e-02f, -1.41136991e-02f, -3.94809283e-02f, 7.35975131e-02f, -1.24167921e-02f,
  1.89050026e-02f, -9.72411409e-02f, -2.28360780e-02f, 4.75341715e-02f, -3.40662561e-02f, -5.62411025e-02f, -2.11809073e-02f, -2.73031220e-02f, -6.83397949e-02f, 5.70682343e-03f,
  1.47084771e-02f, -7.09616812e-03f, -4.03904878e-02f, 3.71848941e-02f, 1.03522547e-01f, 6.09929077e-02f, 2.65829824e-02f, -9.12193060e-02f, 1.55050727e-02f, -3.96636911e-02f,
  -2.97731273e-02f, 9.02890563e-02f, 7.77430683e-02f, -1.43883061e-02f, -4.11632694e-02f, -3.30736563e-02f, -1.29253068e-03f, 4.55102362e-02f, 3.83660570e-02f, 2.47997314e-01f,
  -1.56848967e-01f, -7.95080662e-02f, -4.44086254e-01f, -2.82268859e-02f, 6.07714802e-02f, -8.68631005e-02f, -2.43522868e-01f, 6.11244179e-02f, 1.65455669e-01f, 4.42371378e-03f,
  1.68260843e-01f, 3.33139896e-01f, 1.94812492e-01f, 1.70623720e-01f, 6.60090744e-02f, -2.79304415e-01f, -1.91035271e-01f, -1.82732925e-01f, 7.10499510e-02f, 1.21846028e-01f,
  9.09553021e-02f, 5.90993688e-02f, -1.26372399e-02f, 9.67827439e-03f, 7.24143311e-02f, 2.26929829e-01f, -1.14288442e-01f, -6.07556142e-02f, 7.34277219e-02f, -8.63806456e-02f,
  -1.48615658e-01f, -1.00128628e-01f, 8.75144452e-02f, 8.55461210e-02f, -6.05878569e-02f, -6.23913184e-02f, -1.06415950e-01f, -6.94995522e-02f, 1.52781671e-02f, 3.29901837e-02f,
  -3.89099047e-02f, 6.46540150e-02f, 2.17399132e-02f, 2.27582324e-02f, 1.68333706e-02f, -2.09589172e-02f, -2.29520109e-02f, -2.86917258e-02f, -1.09385587e-01f, 5.55994920e-03f,
  5.09109907e-03f, -1.19659498e-01f, -1.42573088e-01f, -5.68724759e-02f, -1.81505755e-02f, 6.72086328e-02f, 2.11977051e-03f, -4.38311771e-02f, 2.33848915e-02f, -4.02156822e-02f,
  8.51789117e-02f, -3.89966331e-02f, -3.44555825e-02f, 5.65173142e-02f, 2.25877427e-02f, 6.68961257e-02f, -6.93536103e-02f, -6.39280630e-03f, 3.19715589e-02f, -2.80089583e-02f,
  5.68600185e-02f, -4.58386168e-02f, 1.31802456e-02f, -2.55126208e-02f, 1.03308916e-01f, -9.66773257e-02f, -4.96280901e-02f, -1.34829944e-02f, 1.62456241e-02f, 1.92844924e-02f,
  5.19677997e-03f, -5.12910634e-02f, 1.02973043e-03f, -1.72663759e-02f, 4.45103310e-02f, 1.56843495e-02f, -1.94721036e-02f, 4.78421822e-02f, 2.93479562e-02f, -7.88803771e-02f,
  2.33962268e-01f, -7.07322359e-02f, 3.78862917e-02f, 6.64162338e-02f, -3.18323858e-02f, -5.59157599e-03f, 5.21746054e-02f, 3.71014662e-02f, 1.02998056e-01f, -5.57043292e-02f,
  -1.35168349e-02f, 9.14913602e-03f, -4.76181954e-02f, -3.93394567e-02f, -2.25019585e-02f, -2.26966124e-02f, 4.50924970e-02f, 2.49339473e-02f, 7.58753568e-02f, -8.56631398e-02f,
  1.83317196e-02f, -6.04721066e-03f, 7.96152055e-02f, 3.50946225e-02f, -1.08146050e-03f, 4.06771190e-02f, -5.55983149e-02f, -5.28627934e-05f, 1.97026692e-03f, -7.56269544e-02f,
  2.89833965e-03f, -1.36558056e-01f, 9.99762788e-02f, -9.57637280e-02f, -7.42514580e-02f, 1.22505441e-01f, 6.73740059e-02f, 1.07448056e-01f, -2.11039223e-02f, -1.47437647e-01f,
  -1.47765145e-01f, 2.05333717e-03f, 6.76368997e-02f, 1.15268812e-01f, 2.03676239e-01f, -6.81742653e-02f, 6.06331555e-03f, 2.25352138e-01f, 2.36133158e-01f, -2.10000444e-02f,
  -1.14188619e-01f, -3.14319991e-02f, 3.27979103e-02f, 5.25698923e-02f, -2.08547875e-01f, -4.64048877e-04f, -6.00853330e-03f, -1.17021417e-02f, -1.26065817e-02f, -1.12080611e-01f,
  -2.44992346e-01f, 8.38227645e-02f, 4.24371883e-02f, -6.49343729e-02f, -8.96542221e-02f, 8.36363286e-02f, 1.42937452e-02f, 4.14154027e-03f, 4.76219058e-02f, -6.78527653e-02f,
  7.96776079e-03f, -2.44497303e-02f, 7.99248144e-02f, -1.20319230e-02f, -3.76258716e-02f, -1.94513351e-02f, 2.90672295e-02f, 6.79591894e-02f, -3.08222063e-02f, -5.55950329e-02f,
  -6.92517906e-02f, -8.04311857e-02f, 5.61809093e-02f, 1.18000604e-01f, 1.68707862e-01f, 9.45893377e-02f, 5.38428575e-02f, 8.12080353e-02f, 8.16880986e-02f, -1.91819295e-01f,
  -5.71885705e-03f, 1.99667193e-04f, 6.71174973e-02f, -5.71282394e-02f, 2.13935366e-03f, 3.84134636e-03f, 4.40394357e-02f, -6.26112372e-02f, 9.90178436e-03f, -6.19728193e-02f,
  9.06524900e-03f, -7.05788359e-02f, 1.48339532e-02f, -3.77695449e-02f, 2.70100683e-02f, 5.99803627e-02f, -2.02145819e-02f, -7.05959201e-02f, 6.11957014e-02f, -2.36769672e-02f,
  -1.00735081e-02f, 4.77659740e-02f, -4.02768776e-02f, 1.29827308e-02f, -2.22034063e-02f, 7.79586658e-02f, -9.96854436e-03f, 6.09479519e-03f, -2.53949482e-02f, -2.38486473e-02f,
  -2.49344319e-01f, 1.84571862e-01f, -5.35415746e-02f, 1.97311398e-02f, 2.63805757e-03f, -3.12556364e-02f, 1.18983584e-03f, -6.91433903e-03f, -7.14458674e-02f, 1.73243955e-02f,
  -9.45815817e-03f, 5.41451341e-03f, -5.77478334e-02f, -3.34968902e-02f, 8.07690769e-02f, -3.67181189e-02f, 8.40982608e-03f, 3.97697054e-02f, 1.95376389e-02f, -1.59417152e-01f,
  -7.36318231e-02f, 4.63663414e-02f, 1.19403303e-02f, -7.12835491e-02f, -1.03157081e-01f, -2.33057737e-02f, -7.73164257e-02f, -5.35536036e-02f, 1.31197020e-01f, -6.87181354e-02f,
  -2.63926595e-01f, 5.40072769e-02f, 1.38835132e-01f, -6.16180748e-02f, -8.12654495e-02f, -1.09100901e-01f, -1.61999121e-01f, -1.31532490e-01f, -4.54236753e-02f, 4.38491106e-02f,
  -1.12476349e-01f, -9.72378850e-02f, 1.01283845e-02f, -5.42283319e-02f, -5.55734932e-02f, 2.13120237e-01f, 3.17069530e-01f, 2.05385506e-01f, -1.54459789e-01f, -1.14188090e-01f,
  2.38531474e-02f, 4.37190011e-02f, -4.00659516e-02f, -4.77889366e-02f, 6.76576048e-04f, 8.18814561e-02f, 3.80975404e-03f, 1.20440930e-01f, 1.96440518e-02f, 3.17774504e-01f,
  1.93437412e-01f, -7.28976130e-02f, -1.76481269e-02f, 2.96262987e-02f, -5.07463440e-02f, -1.42670097e-02f, -4.54035029e-02f, 1.21293843e-01f, 1.71662066e-02f, -1.86604764e-02f,
  -2.91359741e-02f, -5.02841920e-02f, -5.21943904e-02f, 3.13519351e-02f, 2.02823598e-02f, 6.10447675e-02f, 2.15432793e-03f, 1.11198619e-01f, 4.94867526e-02f, -7.64752775e-02f,
  2.86787432e-02f, -9.57585275e-02f, -8.06421712e-02f, 5.23882508e-02f, 3.97664793e-02f, -8.02074149e-02f, -4.98608127e-02f, 9.99878719e-03f, 3.11231092e-02f, 1.32126093e-01f,
  7.20661646e-03f, 3.96635756e-02f, 2.76358351e-02f, -2.53472142e-02f, 6.18394725e-02f, 3.55437063e-02f, -2.60950271e-02f, -1.95448026e-02f, -5.39335050e-02f, -1.37638869e-02f,
  -3.99517827e-02f, -6.04328178e-02f, 3.90120409e-02f, -1.20553151e-02f, -2.49564275e-02f, 4.60708141e-02f, 3.02254427e-02f, 2.18183664e-03f, 2.10225713e-02f, 2.34536733e-02f,
  6.69052899e-02f, -2.13051587e-02f, -2.11158115e-02f, 5.94764426e-02f, -9.31295659e-03f, 1.22857712e-01f, 2.43642684e-02f, -2.44838018e-02f, 7.57693201e-02f, -4.22539301e-02f,
  -1.24966636e-01f, -7.94861391e-02f, 1.07206367e-01f, 9.12069231e-02f, 2.35593934e-02f, 5.33673801e-02f, -2.06662733e-02f, -5.14305905e-02f, 1.33731756e-02f, -1.64188147e-02f,
  -1.08751066e-01f, 4.01747487e-02f, 4.06599492e-02f, 2.67430265e-02f, -6.32853732e-02f, 9.86979716e-03f, -4.09020809e-03f, 5.96772097e-02f, -9.19553339e-02f, 4.47506048e-02f,
  4.23699245e-03f, -8.31596262e-04f, -8.58085006e-02f, -4.07262668e-02f, -3.57605405e-02f, 5.31098107e-03f, -8.59787408e-03f, -6.93149343e-02f, -1.48481652e-01f, -7.07066059e-02f,
  3.77442062e-01f, 2.46689379e-01f, -1.81148708e-01f, 1.79530874e-01f, -9.82025731e-03f, 4.90429997e-02f, 9.29767787e-02f, 1.70270763e-02f, 7.57357627e-02f, 1.22009046e-01f,
  1.31002873e-01f, -4.27739508e-02f, -1.46970019e-01f, -1.47185594e-01f, -5.19840606e-02f, 5.18724183e-03f, -7.02506229e-02f, -2.15764895e-01f, -2.31619120e-01f, -9.83302221e-02f,
  1.76278427e-02f, 1.20367110e-02f, -1.20953573e-02f, -5.71171641e-02f, 2.36722380e-02f, -1.42841756e-01f, -3.82022150e-02f, 3.32199112e-02f, -1.54964151e-02f, 1.03442715e-02f,
  -2.45854944e-01f, 1.56130165e-01f, -1.37445062e-01f, 5.80960065e-02f, -2.53849924e-02f, -1.09862862e-02f, -9.05497521e-02f, 4.84690554e-02f, 6.90749884e-02f, 4.06128317e-02f,
  3.30482721e-02f, 8.64787251e-02f, 6.20287135e-02f, -7.63693824e-02f, 9.57542285e-02f, 1.28212860e-02f, 7.66053572e-02f, -1.16984405e-01f, -5.89729920e-02f, 3.06662545e-02f,
  1.07889041e-01f, 3.60149629e-02f, 9.15678516e-02f, -7.45187998e-02f, 4.73418199e-02f, -1.09766565e-01f, 2.34716441e-02f, -1.78827923e-02f, 2.52136383e-02f, 8.53412040e-03f,
  -5.89146726e-02f, 1.19147962e-03f, 1.61118689e-03f, 7.86143243e-02f, -2.11661123e-02f, 9.36015043e-03f, -7.60573447e-02f, 3.45257260e-02f, -1.99856982e-02f, 1.70725286e-02f,
  -7.26262257e-02f, 3.11817974e-02f, -1.32636260e-02f, 5.15084304e-02f, -1.68414935e-02f, -3.05821095e-02f, 3.41188647e-02f, -3.65549757e-04f, 1.68240443e-02f, 3.53532284e-02f,
  3.81078273e-02f, -3.43208350e-02f, 5.18575870e-03f, -2.50489898e-02f, -5.47385700e-02f, 2.95178071e-02f, -2.28857156e-02f, -4.12546173e-02f, -9.43102222e-03f, 5.73809780e-02f,
  2.65755318e-03f, -9.17493924e-02f, -1.95556115e-02f, 5.56095084e-03f, 1.01912748e-02f, 4.83739004e-02f, -4.17174958e-02f, 2.45904010e-02f, -3.07276342e-02f, 1.14864400e-02f,
  -2.57044137e-02f, 5.24807610e-02f, 5.95230144e-03f, -1.59367323e-02f, -4.13344763e-02f, -2.02002954e-02f, 9.16255414e-02f, -2.00915672e-02f, -7.20414817e-02f, 1.04808792e-01f,
  6.91415444e-02f, -1.25591364e-02f, -5.18123736e-04f, -7.17938617e-02f, 2.83167381e-02f, -1.25966057e-01f, -1.15625635e-01f, -3.11817359e-02f, -9.87873897e-02f, 7.56568415e-03f,
  1.12665862e-01f, 3.18550140e-01f, 1.70291305e-01f, 4.84299324e-02f, -4.50603180e-02f, 1.95018068e-01f, 2.09472135e-01f, 1.56945273e-01f, -4.94366921e-02f, 5.56331351e-02f,
  -6.59992695e-02f, -2.60042936e-01f, -2.02252954e-01f, -1.45233542e-01f, 4.71373126e-02f, 1.36130601e-01f, 1.44246027e-01f, -2.61006020e-02f, -6.05954304e-02f, -4.48511429e-02f,
  -9.83619168e-02f, 2.96822079e-02f, -5.59422746e-02f, 3.97260487e-02f, -4.43847999e-02f, -2.02024743e-01f, -4.66987006e-02f, 1.98640134e-02f, 1.93086069e-03f, -9.48396772e-02f,
  -5.11433594e-02f, 2.17649624e-01f, -9.42523405e-02f, -4.71317396e-02f, -4.57100496e-02f, -5.52002341e-02f, 6.59350827e-02f, 9.20825545e-03f, -5.92407659e-02f, 5.65595105e-02f,
  -4.66003083e-02f, 2.18965951e-02f, -6.16572425e-02f, 7.01039582e-02f, 5.26086288e-03f, 3.03149056e-02f, -4.91898209e-02f, 6.76536784e-02f, -4.75786813e-02f, 1.04903892e-01f,
  -7.06289634e-02f, 9.11150873e-02f, 7.72342682e-02f, 6.65937737e-02f, 1.89127624e-02f, -3.67724225e-02f, 7.36597255e-02f, 4.74017784e-02f, -5.04961200e-02f, 4.13248576e-02f,
  -5.87321958e-03f, -1.57254431e-02f, 2.10879440e-03f, 2.13725679e-02f, -5.21792248e-02f, 1.65074002e-02f, 6.13674056e-03f, 8.78007058e-03f, -3.68140750e-02f, 4.15626280e-02f,
  4.05464061e-02f, -6.20311312e-02f, 2.21110079e-02f, -4.54052351e-02f, -8.27261582e-02f, 4.84924018e-02f, -6.42663194e-03f, 4.22648974e-02f, -8.92619118e-02f, 7.91537538e-02f,
  1.75980683e-02f, 9.95721295e-03f, 4.01039654e-03f, -4.16728854e-02f, -4.24218997e-02f, -1.94366314e-02f, -6.10421970e-03f, -3.10381074e-02f, 4.55585271e-02f, 4.43129949e-02f,
  -1.39368176e-01f, 1.67114101e-02f, -9.47257131e-02f, 1.64125413e-02f, 1.47898728e-02f, -3.11283469e-02f, -1.00164540e-01f, -5.31625487e-02f, -1.45898564e-02f, 7.01125339e-02f,
  7.17182308e-02f, 4.80799042e-02f, 7.73005337e-02f, -3.74454409e-02f, 1.52028725e-02f, 2.06057858e-02f, 3.12040560e-03f, -1.52077693e-02f, 6.84547275e-02f, 2.23957878e-02f,
  2.45706104e-02f, 2.65307445e-02f, 4.24314812e-02f, 4.95484546e-02f, -6.83693066e-02f, 4.02901806e-02f, -3.37780118e-02f, -2.88534537e-02f, 1.16805650e-01f, 2.98756850e-03f,
  2.50225216e-01f, 1.51456103e-01f, 7.97895901e-03f, 2.00471759e-01f, -1.55833233e-02f, -1.19928025e-01f, -1.43474042e-02f, -1.05998047e-01f, 8.80747959e-02f, 1.78712636e-01f,
  1.22669853e-01f, 1.07241772e-01f, 1.53316809e-02f, -8.41959417e-02f, -1.19731180e-01f, 3.81997414e-02f, 2.61283498e-02f, -8.66346061e-02f, -1.96128085e-01f, -1.83093041e-01f,
  -7.02148899e-02f, 1.26402348e-01f, -1.23220235e-01f, 2.41509788e-02f, 2.08862081e-01f, 1.51365414e-01f, 1.84900805e-01f, 1.70002729e-01f, -6.21224120e-02f, 3.02635610e-01f,
  1.81308046e-01f, 2.44421046e-02f, -9.81871933e-02f, 2.48355418e-02f, 4.67154682e-02f, 3.94027866e-02f, 3.17360796e-02f, 4.43379208e-02f, -4.91254851e-02f, 4.93804924e-03f,
  6.48767650e-02f, 4.73911315e-03f, 4.67437766e-02f, -9.01566818e-02f, 3.93526033e-02f, -5.26387990e-02f, -8.10133666e-02f, -8.89329165e-02f, -7.03100339e-02f, -2.77198739e-02f,
  4.17962186e-02f, -5.26944026e-02f, -1.07153341e-01f, -8.01356286e-02f, -6.86488673e-02f, -1.06247619e-01f, 7.84618035e-02f, -3.05729825e-02f, -2.60570943e-02f, 2.28842214e-01f,
  4.91711795e-02f, 1.33672990e-02f, -1.50102936e-02f, 2.75184843e-03f, 1.71825625e-02f, 2.22180877e-03f, 2.53518578e-02f, 2.93995766e-03f, -3.83660085e-02f, -7.24679558e-03f,
  9.73603968e-03f, -8.96479040e-02f, 5.39022200e-02f, 5.63008413e-02f, 6.61983415e-02f, 1.01182424e-02f, -7.13447407e-02f, 8.58158916e-02f, 6.36103600e-02f, 4.02815603e-02f,
  -8.94938111e-02f, -8.81686062e-02f, 2.51836237e-02f, -9.12419483e-02f, -4.42455672e-02f, -1.93524100e-02f, -6.41199276e-02f, 3.45627498e-03f, -4.07423675e-02f, 1.99923888e-02f,
  2.64356613e-01f, -1.90940067e-01f, 1.30062625e-01f, 1.46899102e-02f, -5.73019385e-02f, 3.20190862e-02f, 1.27729669e-01f, -4.74620759e-02f, -2.43543740e-02f, 9.08929110e-03f,
  -7.78974742e-02f, 1.44097256e-02f, 1.43797416e-02f, -5.54512516e-02f, -2.43624542e-02f, 5.80001669e-03f, 3.82654667e-02f, 3.62650529e-02f, -8.03289786e-02f, 1.21938987e-02f,
  -5.62591385e-03f, 5.48057677e-03f, 1.88337229e-02f, 3.82893085e-02f, 2.21741907e-02f, 2.95981299e-02f, 9.09991860e-02f, 3.16990539e-02f, -3.12931836e-02f, 3.08362633e-01f,
  2.58005768e-01f, -4.61778976e-02f, 1.72540113e-01f, 3.63203138e-02f, -1.39244109e-01f, -1.07311152e-01f, 1.32083192e-01f, 8.01007450e-02f, -5.61392158e-02f, 3.72344069e-02f,
  -1.32858410e-01f, 2.85806842e-02f, 6.44250214e-02f, -2.39501838e-02f, 1.89456314e-01f, 8.54326040e-02f, 1.51322065e-02f, 1.02589414e-01f, 1.49060175e-01f, -5.45523204e-02f,
  -1.58688184e-02f, -6.05409071e-02f, 1.12797208e-01f, 8.90156999e-03f, 5.24767153e-02f, -5.82068274e-03f, 7.20124021e-02f, 4.51806784e-02f, -1.67957530e-03f, 2.73133479e-02f,
  1.78945646e-01f, -9.78711471e-02f, 1.04366429e-01f, -1.06663153e-01f, -6.08549118e-02f, 7.62820942e-03f, 2.47812495e-02f, -8.37415364e-03f, 1.21558597e-02f, -3.07800807e-02f,
  -1.50172291e-02f, -9.30764154e-02f, -2.03642603e-02f, 8.80984869e-03f, 3.64408456e-02f, 9.52987224e-02f, 6.05279095e-02f, 8.61120000e-02f, 2.61058994e-02f, 5.31834085e-03f,
  -1.40824988e-01f, -7.43271932e-02f, -2.01690160e-02f, -8.65801498e-02f, -8.29380155e-02f, 2.01245416e-02f, 5.62516153e-02f, -6.03237227e-02f, 1.10269926e-01f, 2.20859677e-01f,
  -8.81778598e-02f, -2.58844327e-02f, -2.31387820e-02f, -6.17064051e-02f, 7.19083175e-02f, 3.78675275e-02f, -3.12875770e-02f, -2.40763500e-02f, -1.77999996e-02f, 6.27807230e-02f,
  -7.65285045e-02f, 2.62606107e-02f, -1.17086433e-02f, 3.04926243e-02f, -4.26697917e-02f, 2.37039495e-02f, 5.22931442e-02f, 4.25285883e-02f, 1.04163103e-02f, 5.19916229e-02f,
  -2.19715368e-02f, 2.80829482e-02f, -2.93642539e-03f, 3.04788575e-02f, 1.05670774e-02f, -4.04231213e-02f, -1.84585322e-02f, 1.36860302e-02f, -1.66303106e-02f, -9.73076448e-02f,
  1.39263347e-01f, -1.38019979e-01f, 1.61081418e-01f, 1.43206835e-01f, 6.96877241e-02f, -3.85208726e-02f, 3.39230001e-02f, 2.11131088e-02f, -4.29666191e-02f, 5.36464229e-02f,
  -5.29246852e-02f, 6.56767637e-02f, 4.22139615e-02f, -3.59694399e-02f, -1.32843843e-02f, -1.97797567e-02f, 2.97047035e-03f, 4.17494774e-02f, -5.20671308e-02f, -2.04270668e-02f,
  -1.99337453e-02f, 7.91123062e-02f, 1.52157083e-01f, 1.38767034e-01f, 3.23586166e-02f, 1.05385475e-01f, 8.34143013e-02f, 1.47929266e-01f, 1.29479751e-01f, 3.35438251e-01f,
  2.82169938e-01f, 4.71750088e-02f, -1.60866715e-02f, 1.51685640e-01f, 2.43477315e-01f, 9.82878059e-02f, 1.28354887e-02f, -2.33169063e-03f, -3.77708338e-02f, 1.16272412e-01f,
  -6.32952005e-02f, 8.10227320e-02f, 7.48635978e-02f, 2.11851653e-02f, 2.87532434e-02f, 1.27047628e-01f, 1.43114641e-01f, 2.09555104e-01f, 1.69235393e-01f, 2.39480779e-01f,
  2.20638618e-01f, 1.85641989e-01f, 1.45265862e-01f, 1.01725444e-01f, 2.61352900e-02f, 1.63753703e-01f, 8.61972198e-02f, 3.13040689e-02f, 1.42770529e-01f, 1.79212317e-01f,
  1.85650587e-01f, -9.95092653e-03f, -1.20453283e-01f, 2.27033403e-02f, -9.58859548e-02f, -4.08958234e-02f, -2.67555956e-02f, -1.30975157e-01f, -5.72619811e-02f, -7.96615854e-02f,
  4.79102544e-02f, -3.62457931e-02f, 2.63730194e-02f, 7.62489215e-02f, 2.50537340e-02f, 5.05944453e-02f, -1.39717674e-02f, 1.80111472e-02f, -1.25729054e-01f, -9.17964950e-02f,
  -6.77192435e-02f, -1.24317212e-02f, -1.08572088e-01f, -1.35268882e-01f, -1.62620112e-01f, 9.82649252e-02f, -1.74902320e-01f, -4.68558855e-02f, -1.30744517e-01f, -4.59925048e-02f,
  -1.78730488e-02f, -4.09749197e-03f, -3.01183220e-02f, -7.22711161e-03f, 1.11520857e-01f, -8.47569779e-02f, 4.78985496e-02f, 3.03407200e-02f, 6.20039664e-02f, -2.48472299e-02f,
  -6.37701675e-02f, 2.31167418e-03f, -9.21969023e-03f, -7.36369565e-02f, -1.00607257e-02f, 3.32204588e-02f, -7.02037141e-02f, -1.64846238e-02f, -7.86909163e-02f, 3.43335383e-02f,
  3.25977989e-02f, -5.38768172e-02f, 4.38220687e-02f, 1.41305709e-02f, -1.08667098e-01f, 4.04388011e-02f, -5.58214858e-02f, -4.26603761e-03f, 6.71547186e-03f, 1.21611496e-02f,
  5.57280704e-02f, -2.32585222e-01f, -2.64329407e-02f, 7.66972601e-02f, 7.38107637e-02f, -4.45875265e-02f, -4.74073254e-02f, -3.67305763e-02f, 4.47369441e-02f, 6.59968331e-02f,
  1.80139039e-02f, -1.27055645e-02f, 2.29654163e-02f, -2.84528304e-02f, 5.13632484e-02f, 8.82861316e-02f, 5.75801171e-03f, 9.09612998e-02f, 7.71198571e-02f, -3.31467576e-02f,
  -8.05151984e-02f, 8.51333663e-02f, 5.44566847e-02f, -1.08175143e-03f, -4.15888056e-02f, 5.31481728e-02f, -3.08078267e-02f, 3.01837232e-02f, 1.64534263e-02f, -7.20503107e-02f,
  1.92385137e-01f, 2.78553605e-01f, 8.57257545e-02f, 8.16386193e-02f, 1.00281365e-01f, -1.17792897e-01f, -2.26805918e-02f, 4.22751233e-02f, -7.02184662e-02f, 4.30334024e-02f,
  4.57201079e-02f, -1.17461957e-01f, -1.33686066e-01f, -1.17903799e-01f, -8.86072069e-02f, -2.52580997e-02f, 5.18749245e-02f, -7.88896307e-02f, -2.77591050e-01f, -2.32951075e-01f,
  -1.47514716e-01f, 2.29313429e-02f, -2.51407437e-02f, -4.88134138e-02f, 1.35171533e-01f, -1.63356140e-01f, 1.12906292e-01f, 7.75101483e-02f, 4.21631858e-02f, 8.50355551e-02f,
  9.75820422e-02f, 2.97589660e-01f, -9.63108838e-02f, -8.00343901e-02f, 1.22930489e-01f, 4.64690849e-02f, -5.95670342e-02f, 2.70378496e-02f, 8.78567621e-02f, 9.26279183e-03f,
  1.94676761e-02f, -4.63730805e-02f, -1.26306396e-02f, 6.74723983e-02f, 4.88177873e-02f, -5.11321835e-02f, 9.02330130e-02f, -1.41727086e-03f, -4.45004925e-03f, 9.75863636e-02f,
  7.75527656e-02f, 1.06791355e-01f, 1.77659258e-01f, -3.02313250e-02f, 2.01257486e-02f, 3.94400284e-02f, 5.83596826e-02f, 1.16743661e-01f, 6.90037608e-02f, 7.83170536e-02f,
  -1.14515193e-01f, -1.78938936e-02f, 1.56359019e-04f, 6.65870681e-02f, 6.18345710e-03f, 6.87275827e-03f, -4.30143178e-02f, 3.01489253e-02f, -1.30490195e-02f, -7.14176074e-02f,
  2.96602007e-02f, -2.87749097e-02f, 1.92888305e-02f, -7.83817098e-02f, -4.28932309e-02f, 7.51601458e-02f, -2.06360407e-02f, -4.63560484e-02f, 9.20945704e-02f, -1.16768731e-02f,
  4.61136550e-02f, -4.48601879e-02f, 7.98152536e-02f, 5.20047592e-03f, 3.32854353e-02f, -8.57274421e-03f, 2.02678517e-02f, 3.39930784e-03f, 5.19292429e-02f, -2.73144934e-02f,
  -1.31224230e-01f, -6.94655627e-03f, -7.27188587e-02f, -5.44751473e-02f, 2.82285511e-02f, 7.35534877e-02f, 4.05375548e-02f, 5.21606840e-02f, 2.02195216e-02f, -7.60392845e-02f,
  4.86367680e-02f, -1.43316565e-02f, 3.64867933e-02f, -4.61912677e-02f, -1.21796928e-01f, 5.73929492e-03f, 8.63024220e-02f, -9.32676941e-02f, -4.34581339e-02f, 1.09999344e-01f,
  -8.69455785e-02f, -4.99013290e-02f, -7.91375339e-02f, 4.44616154e-02f, -5.93740977e-02f, -1.37806267e-01f, -1.45627156e-01f, -1.68279428e-02f, -1.22878633e-01f, -4.65641618e-02f,
  -2.05843493e-01f, -1.53633907e-01f, 9.33393613e-02f, -2.48513281e-01f, -3.76678705e-02f, 2.86713600e-01f, 2.51087248e-01f, 6.74314052e-02f, -1.26506925e-01f, -3.27769443e-02f,
  -3.34014967e-02f, -6.26736581e-02f, -4.96799350e-02f, 4.89415303e-02f, 1.67568684e-01f, -1.30966557e-02f, -6.37021363e-02f, 7.39292726e-02f, 2.03898355e-01f, 2.17198893e-01f,
  -9.71272364e-02f, -1.66005582e-01f, -4.26241346e-02f, -3.15949805e-02f, -1.34513110e-01f, 6.96955388e-03f, -1.61108941e-01f, -1.70048729e-01f, -5.50810918e-02f, -4.47929919e-01f,
  4.63517150e-03f, -3.46847288e-02f, 1.66680217e-02f, -5.90386987e-02f, -3.05610783e-02f, -7.62238279e-02f, -4.27210424e-03f, -6.63782954e-02f, 7.25834817e-02f, -1.09929621e-01f,
  -7.22573604e-03f, 1.77491866e-02f, -1.67762593e-03f, 4.94558997e-02f, 2.64492035e-02f, 1.97258070e-02f, -6.37215227e-02f, 1.61400400e-02f, 4.32727598e-02f, -4.15623672e-02f,
  2.16193832e-02f, 2.83822399e-02f, 1.13824394e-03f, 8.58228058e-02f, 1.64316446e-01f, 6.74409047e-02f, 1.33505136e-01f, 1.39016872e-02f, 3.93415317e-02f, -2.17159331e-01f,
  -6.16079122e-02f, -3.62435021e-02f, 3.42059657e-02f, 1.95303578e-02f, 3.50541212e-02f, -1.17532369e-02f, -2.48698685e-02f, -2.78577618e-02f, 1.79850850e-02f, -4.67008613e-02f,
  -4.70620617e-02f, 1.47308093e-02f, 3.08262482e-02f, 3.61198150e-02f, 4.35865251e-03f, -5.96524663e-02f, 3.29513885e-02f, -6.19769853e-04f, 6.28141165e-02f, 2.88468087e-03f,
  -6.33736029e-02f, 4.35009673e-02f, -6.31439909e-02f, 1.10637192e-02f, 1.19919786e-02f, 2.13847179e-02f, 6.13988191e-02f, 2.63255388e-02f, -6.99634105e-02f, 4.77239452e-02f,
  -8.36712420e-02f, 2.81939745e-01f, -1.90958261e-01f, -4.18668464e-02f, -3.36461887e-02f, 3.01194414e-02f, 1.34770302e-02f, -6.42329082e-03f, -7.78296739e-02f, -3.97370681e-02f,
  1.08108506e-01f, 1.29049905e-02f, -3.05973645e-02f, -4.43898663e-02f, 9.29439887e-02f, 2.89327186e-02f, -6.03286289e-02f, -5.07957563e-02f, 7.51503278e-03f, 1.60974693e-02f,
  -3.39478403e-02f, 4.71139327e-02f, 4.93479744e-02f, 3.44124399e-02f, -3.33822332e-02f, 4.06547785e-02f, 7.14256382e-03f, 3.78020406e-02f, 1.28220722e-01f, -3.71298306e-02f,
  -5.53440392e-01f, -4.82826903e-02f, -2.29924157e-01f, 3.64183299e-02f, 1.31414607e-01f, 1.01359002e-01f, 1.39248386e-01f, 7.45416731e-02f, 3.05502415e-02f, -1.95145030e-02f,
  1.64635107e-01f, 1.73268959e-01f, 9.12255943e-02f, 1.17992118e-01f, -2.34947726e-02f, -1.20484754e-01f, -3.59077714e-02f, -1.90584317e-01f, -6.47822171e-02f, 1.16650626e-01f,
  1.31446436e-01f, -8.95782858e-02f, -1.82597056e-01f, 2.42350725e-05f, 6.32687733e-02f, 3.56262736e-02f, -8.20502490e-02f, -1.19191863e-01f, -8.24055355e-03f, 1.50986984e-02f,
  5.09662852e-02f, -1.31354690e-01f, 1.30517364e-01f, 4.61848266e-02f, 1.05057647e-02f, -6.50640205e-02f, -8.26594513e-03f, -7.91731551e-02f, -3.10256463e-02f, -6.53852597e-02f,
  4.41173539e-02f, -2.37117813e-04f, 2.81655695e-02f, 4.84055243e-02f, -5.70883341e-02f, 2.23837886e-02f, -6.06861003e-02f, -1.87976375e-01f, -6.80496246e-02f, 3.95647436e-02f,
  1.28805578e-01f, -7.40268603e-02f, -1.93503082e-01f, -3.19899432e-02f, -1.95265114e-02f, -1.18344299e-01f, -7.93124437e-02f, -9.65078846e-02f, -1.91307425e-01f, -8.94287601e-02f,
  7.62817115e-02f, 2.41253786e-02f, 2.08476651e-02f, -5.28365485e-02f, -1.43827125e-02f, 8.91678315e-03f, 9.22278501e-03f, 6.45681620e-02f, 2.97990702e-02f, -6.44923598e-02f,
  4.14828546e-02f, -1.01908684e-01f, -1.40466001e-02f, -3.82105112e-02f, 4.97099087e-02f, 6.13293126e-02f, -9.33425908e-04f, 8.75373855e-02f, -2.44761780e-02f, -3.33113931e-02f,
  -2.05741748e-02f, -4.82229292e-02f, 5.27257565e-03f, 2.18251348e-02f, -4.56021726e-02f, 2.45646071e-02f, -3.61990519e-02f, -8.71714950e-02f, -1.45650413e-02f, -9.60285291e-02f,
  -6.12908825e-02f, 5.02209878e-04f, 1.15337931e-02f, 7.48103810e-03f, 4.26999619e-03f, -2.27619875e-02f, 9.28336605e-02f, -6.47137016e-02f, 8.13610014e-03f, 7.75625557e-02f,
  8.10355470e-02f, -8.91101360e-03f, 4.61796336e-02f, 1.17680905e-02f, 2.24869680e-02f, 1.06333278e-01f, 1.14155062e-01f, -3.57296923e-03f, 6.17521722e-03f, -2.76732277e-02f,
  -4.84777354e-02f, -4.70373482e-02f, -1.39520541e-01f, -3.50379646e-02f, 1.53997615e-02f, -5.15234144e-03f, -3.64466161e-02f, -7.08751604e-02f, -1.84891492e-01f, -1.79281384e-01f,
  -1.32783279e-01f, 7.72809833e-02f, -5.10349032e-03f, -6.37197718e-02f, -8.56597722e-02f, -1.82829455e-01f, -1.01344004e-01f, -1.44569010e-01f, -8.02462827e-03f, -2.63087936e-02f,
  -1.08879812e-01f, -7.08684027e-02f, 5.12971506e-02f, -1.25863738e-02f, 5.56804426e-03f, -1.61654712e-03f, 1.66414157e-01f, 4.68533002e-02f, -7.47198686e-02f, -4.69591208e-02f,
  -2.37140190e-02f, -3.68470252e-02f, 3.84532697e-02f, -2.32919324e-02f, 1.20581426e-01f, 1.04771905e-01f, 1.54199436e-01f, 2.03250483e-01f, 2.10637242e-01f, 3.39725286e-01f,
  9.69815105e-02f, 6.06121048e-02f, 2.52432004e-03f, 4.88006137e-02f, 7.92184919e-02f, -5.60602099e-02f, 1.63316950e-02f, 1.29470807e-02f, 7.10228384e-02f, -6.49706051e-02f,
  8.21027830e-02f, 7.72538856e-02f, 3.80702429e-02f, -6.56158924e-02f, -8.36538058e-03f, -6.88690022e-02f, -4.93697338e-02f, 6.96329623e-02f, -7.54577853e-03f, 4.82870415e-02f,
  9.60471258e-02f, -6.33290485e-02f, 7.04782307e-02f, -4.06638123e-02f, 4.74416278e-02f, 1.59408734e-03f, -4.51661274e-03f, 1.11702695e-01f, -2.49352157e-02f, 2.25217834e-01f,
  -1.56581663e-02f, 2.65020411e-02f, 1.60578694e-02f, 6.42986968e-02f, -1.09673038e-01f, 5.02631254e-02f, 7.62817860e-02f, -2.77455733e-03f, 4.33083624e-02f, -3.17958626e-03f,
  -2.28628293e-02f, -9.01835412e-02f, 1.75720174e-02f, 1.04675159e-01f, -1.81209967e-02f, -8.14988688e-02f, 7.14600645e-03f, 2.03451188e-03f, -2.60083396e-02f, -1.01159245e-01f,
  -5.01588359e-02f, 8.20946544e-02f, -4.49413434e-03f, 1.82341542e-02f, 1.81911290e-02f, -3.05093564e-02f, -1.25227392e-01f, -2.00480353e-02f, -1.07503951e-01f, 3.03504337e-03f,
  -9.35902372e-02f, -1.25110656e-01f, -8.20382759e-02f, -3.77438068e-02f, -3.62206921e-02f, 4.51092273e-02f, -1.22569911e-02f, 3.17370854e-02f, -9.70434919e-02f, -1.37878526e-02f,
  2.49477234e-02f, -5.58935218e-02f, -4.77520190e-02f, 9.87927243e-03f, -4.97999229e-02f, -1.27285123e-01f, -1.29690558e-01f, -9.91197526e-02f, -2.67403033e-02f, -8.50789994e-02f,
  -1.22347526e-01f, -8.21951479e-02f, -1.97301969e-01f, -1.13555551e-01f, -6.55156234e-03f, -2.01166421e-01f, -8.78057033e-02f, -6.47507980e-02f, -4.94177043e-02f, -1.19525246e-01f,
  1.25449955e-01f, 6.93198070e-02f, 3.65258247e-01f, 2.63675064e-01f, 1.93340614e-01f, 1.78559393e-01f, 2.25348771e-01f, 2.44003478e-02f, 9.27214548e-02f, 2.24881060e-02f,
  7.19528347e-02f, -9.46657285e-02f, -2.25656610e-02f, 1.80953667e-02f, -1.37769714e-01f, 1.48150399e-01f, 1.38726503e-01f, 4.37508710e-03f, -9.47976410e-02f, -6.53900206e-02f,
  1.12680629e-01f, 2.26010084e-02f, -3.19817699e-02f, -5.82134686e-02f, 1.06564835e-01f, -1.61497425e-02f, 1.14988409e-01f, 1.00239456e-01f, 2.37914063e-02f, 1.10564232e-01f,
  4.51119989e-02f, 1.11794524e-01f, 7.42782131e-02f, -8.96478295e-02f, -3.74685763e-03f, -7.63704702e-02f, 5.87676466e-02f, -4.79033701e-02f, -5.30873276e-02f, 3.82787287e-02f,
  2.08360795e-02f, -1.62147895e-01f, 9.26282555e-02f, -9.23659280e-02f, -5.94029278e-02f, 1.51795484e-02f, 3.15859984e-03f, -2.23351531e-02f, -2.60423822e-03f, -1.46282148e-02f,
  6.19576871e-02f, 1.30342320e-02f, -3.43496166e-02f, 5.70322275e-02f, -5.83901182e-02f, 5.96371628e-02f, 5.17392643e-02f, -3.56683955e-02f, 1.84711944e-02f, -9.59894508e-02f,
  8.91299546e-02f, 5.18266968e-02f, -7.75632337e-02f, 7.92777389e-02f, -9.14836824e-02f, -1.78909395e-02f, 1.29966652e-02f, -8.09815526e-02f, -3.09979804e-02f, 2.12893225e-02f,
  -2.57978924e-02f, -4.37549576e-02f, 7.97528028e-03f, -3.85159208e-03f, 2.34645754e-02f, -1.53635312e-02f, -6.31068349e-02f, -3.22967060e-02f, 1.20237172e-02f, -6.74564540e-02f,
  -7.61063944e-04f, 1.34548452e-02f, -3.80199142e-02f, -1.38702214e-01f, 7.85754845e-02f, -2.13830452e-02f, -6.27655536e-02f, 5.92079153e-03f, 8.57452527e-02f, -1.17692789e-02f,
  -1.53570116e-01f, 1.34551420e-03f, -5.99685125e-02f, -5.00368923e-02f, 8.88048206e-03f, -5.70427217e-02f, 7.48234615e-02f, -2.44719163e-02f, -4.12925184e-02f, 2.31536683e-02f,
  4.28313017e-02f, -1.08620614e-01f, 2.81695998e-03f, -7.19063282e-02f, 1.74590722e-02f, -3.60720865e-02f, -6.29677027e-02f, 8.54219794e-02f, -4.16495912e-02f, 2.78120656e-02f,
  5.23085613e-03f, 3.16191129e-02f, -7.84604251e-03f, -1.11763021e-02f, 4.48397920e-02f, -1.54613443e-02f, -7.88790882e-02f, 5.32749221e-02f, -1.10153079e-01f, -1.23361267e-01f,
  1.60222962e-01f, 2.21145302e-01f, 7.33804330e-02f, 3.49947661e-02f, 1.35801017e-01f, 2.55321920e-01f, 3.73116463e-01f, 1.36415526e-01f, -3.17151062e-02f, 1.71287462e-01f,
  7.07900971e-02f, -1.57162398e-01f, 2.29140278e-02f, -4.43794392e-02f, 2.22827405e-01f, 2.95071602e-01f, 3.29499722e-01f, 1.89680904e-02f, 1.02647446e-01f, 2.22040564e-02f,
  -2.05326360e-02f, 1.10049218e-01f, 3.63700241e-02f, -1.18420526e-01f, -1.09832898e-01f, -1.05707988e-01f, 6.09138841e-03f, -1.18440427e-01f, -1.09346345e-01f, 5.11642955e-02f,
  -3.36002819e-02f, 4.82286960e-02f, -7.00549185e-02f, 5.08973673e-02f, -3.85197960e-02f, -6.71871984e-03f, -6.67368323e-02f, 1.17387222e-02f, -1.03308380e-01f, -8.20584670e-02f,
  -1.11390194e-02f, -5.38061671e-02f, 1.04540996e-01f, -5.19407839e-02f, 5.82929365e-02f, 2.28566993e-02f, 1.29703134e-01f, -3.88254710e-02f, 4.34520058e-02f, -2.93983910e-02f,
  2.72981003e-02f, 2.08812729e-02f, 2.67257672e-02f, 8.25981125e-02f, 6.35590702e-02f, 3.26632545e-03f, 1.57396365e-02f, -7.28062540e-02f, 2.47494108e-03f, 4.98602167e-02f,
  1.06271133e-01f, -3.85774188e-02f, 4.93296050e-02f, 1.68692842e-02f, -8.43523815e-03f, -3.17995548e-02f, -5.03601171e-02f, 2.03589536e-02f, 6.38054311e-02f, -5.19772805e-03f,
  -4.19831201e-02f, 2.67863851e-02f, 1.21710857e-03f, 1.42857015e-01f, -2.19264179e-02f, 4.03183326e-02f, -1.63497664e-02f, 4.89354245e-02f, 4.71054539e-02f, -5.58408499e-02f,
  -1.68100167e-02f, -7.42272511e-02f, -2.33010035e-02f, -4.28006835e-02f, 9.19604301e-03f, 6.15159795e-02f, -2.42198538e-02f, 1.29252924e-02f, -1.89000852e-02f, -5.74649908e-02f,
  -9.09422711e-02f, 1.64818317e-02f, 6.58662394e-02f, 7.54190888e-03f, -4.33716588e-02f, -8.87782872e-02f, 4.52478454e-02f, 2.89147981e-02f, -4.05485034e-02f, 1.04561010e-02f,
  -7.56859034e-02f, 3.90703641e-02f, 1.49298273e-02f, -8.20315406e-02f, -1.54269878e-02f, 4.21213619e-02f, -1.81465615e-02f, 4.05480862e-02f, -3.67272235e-02f, -7.30733573e-02f,
  4.45301831e-02f, 4.40420844e-02f, 6.00508451e-02f, -7.88937882e-02f, 1.32725956e-02f, -1.26165114e-02f, -1.12930639e-02f, -1.94035657e-02f, 1.21688442e-02f, 5.53801060e-02f,
  -1.94486797e-01f, 2.06492350e-01f, 2.82317817e-01f, 8.06826130e-02f, 4.77075800e-02f, 5.91793582e-02f, 1.03957830e-02f, -1.08299606e-01f, -1.63885787e-01f, -1.54415835e-02f,
  1.14634067e-01f, -6.29903972e-02f, -2.78387554e-02f, 8.00867081e-02f, 2.78648715e-02f, 1.00803688e-01f, 1.80614874e-01f, -2.53459048e-02f, -2.20497012e-01f, -1.76037014e-01f,
  -9.85759571e-02f, -9.16203707e-02f, 2.52222992e-03f, -1.13804974e-01f, 2.73394641e-02f, -4.86566871e-02f, 3.22763771e-02f, 1.15778260e-01f, 1.29824862e-01f, 2.93164670e-01f,
  2.03951392e-02f, 2.18572289e-01f, -6.34056181e-02f, -3.48569192e-02f, 1.73735619e-02f, -7.04162270e-02f, -6.22714423e-02f, 2.27289703e-02f, 1.32378172e-02f, 4.59692590e-02f,
  8.44003186e-02f, 9.90126356e-02f, 6.12055510e-02f, -4.96229418e-02f, -8.09859484e-03f, 1.32352356e-02f, 1.19406015e-01f, 9.16698873e-02f, 4.58043739e-02f, -3.02877724e-02f,
  1.39939904e-01f, 1.06675051e-01f, -4.20465842e-02f, -2.96324911e-03f, 5.54762222e-02f, -8.68060514e-02f, 4.17378619e-02f, -1.06545247e-01f, -1.55920997e-01f, -1.66405052e-01f,
  -4.80513982e-02f, -6.66011497e-02f, 2.81255729e-02f, -8.37794915e-02f, -1.84743572e-02f, -3.88737326e-03f, 7.96502233e-02f, 4.34226468e-02f, -4.56864797e-02f, 5.49800657e-02f,
  2.19983403e-02f, 4.06911746e-02f, 3.57049406e-02f, 7.39253387e-02f, -4.54695038e-02f, -1.99504606e-02f, -1.55732231e-02f, -5.65367751e-04f, 3.90758924e-02f, 6.81150630e-02f,
  -4.40232866e-02f, 3.14527452e-02f, 1.65034775e-02f, 5.82913756e-02f, 3.49484421e-02f, 2.91974954e-02f, 5.39463758e-03f, -3.58847454e-02f, -8.18601251e-02f, -3.09030861e-02f,
  -2.83771843e-01f, 1.48163319e-01f, -1.30803898e-01f, -5.20727709e-02f, -2.13414058e-02f, -5.42718768e-02f, 4.08569463e-02f, 1.74196530e-02f, 5.02787307e-02f, -1.04347803e-01f,
  5.74026518e-02f, -6.61222786e-02f, 6.77935109e-02f, 4.76087257e-03f, -9.15512964e-02f, -2.69140266e-02f, -2.11413354e-02f, 6.00867905e-02f, 9.41870548e-03f, -5.44488691e-02f,
  -4.14195135e-02f, -1.92988470e-01f, -2.25218907e-01f, -1.44596919e-01f, -5.57528958e-02f, -1.95064798e-01f, -1.14228413e-01f, -9.12147835e-02f, -2.61057138e-01f, -4.41571265e-01f,
  6.92630231e-01f, -2.57269233e-01f, 2.02720433e-01f, 1.83169782e-01f, -1.92421019e-01f, -2.22069800e-01f, -2.90874541e-01f, -9.26537588e-02f, 5.20904921e-02f, -1.43248051e-01f,
  -9.69864354e-02f, -8.15101489e-02f, 3.74943614e-02f, -1.70723032e-02f, 1.78797737e-01f, -7.01554567e-02f, 9.50693488e-02f, 3.22134078e-01f, 3.00359637e-01f, -1.31935999e-01f,
  -2.13774681e-01f, 1.28294915e-01f, 3.45481813e-01f, 1.76692948e-01f, -1.60584837e-01f, 3.82877104e-02f, -1.93038711e-03f, 6.79730400e-02f, -9.87403542e-02f, -1.61360726e-01f,
  6.94402605e-02f, 1.02752402e-01f, 4.24759462e-03f, 1.70870814e-02f, 8.02890025e-03f, 6.80006891e-02f, 1.82627402e-02f, 2.41672248e-02f, 2.89683845e-02f, 1.68010145e-02f,
  -3.81562248e-04f, -8.70511867e-03f, 3.28798257e-02f, -7.97815695e-02f, -5.91493445e-03f, -5.46564162e-03f, -5.25684990e-02f, 2.08866283e-01f, 1.81909502e-01f, -4.87252697e-02f,
  -2.33845145e-01f, -1.10908523e-01f, 1.41633069e-02f, -1.24714598e-01f, 8.93830881e-02f, 2.76760501e-03f, -1.21804662e-01f, -2.10621078e-02f, 2.73765381e-02f, 1.95055492e-02f,
  -9.20982938e-03f, 5.02781291e-03f, -4.97292392e-02f, 6.99633220e-03f, -1.15714232e-02f, 3.38087119e-02f, -5.66734001e-03f, -4.94064651e-02f, -1.41567392e-02f, 1.30530726e-02f,
  2.32394934e-02f, -4.75820377e-02f, 9.24175605e-03f, 3.14160995e-02f, -4.82088886e-02f, 3.39367799e-02f, -2.04071235e-02f, -3.17615345e-02f, 2.41335761e-02f, 7.28259236e-03f,
  1.70590542e-02f, 3.22817266e-02f, 7.65513760e-05f, 2.32679155e-02f, 6.65228022e-03f, 7.60397986e-02f, -1.23033077e-02f, -5.65044098e-02f, -4.86254282e-02f, 2.43471935e-02f,
  3.80631983e-02f, 7.00187907e-02f, 9.79534686e-02f, 6.37870058e-02f, -1.89723317e-02f, 8.16216506e-03f, -1.49968918e-02f, 3.77638116e-02f, 1.05930105e-01f, 2.51559541e-02f,
  -7.03260154e-02f, 8.27431604e-02f, 4.63536531e-02f, -6.14696816e-02f, 3.68585773e-02f, -6.37406111e-03f, -5.28745987e-02f, 8.07756186e-02f, -1.83913335e-02f, -1.06646352e-01f,
  -1.11697214e-02f, 2.37989333e-02f, 1.42201126e-01f, 5.97014725e-02f, -2.75101494e-02f, 1.04516976e-01f, -3.23766135e-02f, 3.79210408e-03f, 2.07175836e-01f, -5.29686548e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.77888750e-02f, 2.71731857e-02f, 8.21421668e-02f, 4.03817184e-02f, 9.48936306e-03f, -4.03729687e-03f, 6.79711327e-02f, 9.32860747e-02f, 8.08688477e-02f, 3.34379971e-02f,
  1.21335395e-01f, 6.88949451e-02f, -8.62517133e-02f, -6.79249093e-02f, -3.67639065e-02f, -9.56848860e-02f, -5.14149964e-02f, -1.35266967e-02f, -2.03944501e-02f, 5.52389398e-02f,
  -4.23224941e-02f, -3.19444723e-02f, 1.51133919e-02f, -6.12689480e-02f, -2.65036114e-02f, 1.43697727e-02f, -1.68918036e-02f, -4.56349887e-02f, -4.60582636e-02f, -1.06946491e-01f,
  4.19105440e-02f, 1.31474629e-01f, -6.02622703e-02f, -2.13083401e-02f, 2.91791502e-02f, -8.50704461e-02f, 2.66790874e-02f, -6.07902221e-02f, 1.89965889e-02f, -3.42243072e-03f,
  3.34773064e-02f, 6.31725490e-02f, 8.28327909e-02f, 4.60028574e-02f, 2.98774503e-02f, -1.96292568e-02f, 1.04188165e-02f, 3.24539542e-02f, 2.60075573e-02f, 5.90756349e-02f,
  -6.21849932e-02f, 6.06869943e-02f, -1.43009974e-02f, -1.66498404e-02f, 5.95447868e-02f, -8.28907117e-02f, -3.48486658e-03f, 5.46813011e-02f, -5.97951980e-03f, -6.50388282e-03f,
  7.26644918e-02f, -7.63461739e-02f, 4.59873565e-02f, 5.92451170e-02f, -3.83264162e-02f, -4.84142080e-02f, 8.12139511e-02f, 1.07329087e-02f, 1.93949863e-02f, 2.51530800e-02f,
  1.08227017e-03f, -2.23950911e-02f, -8.07500556e-02f, 1.32922046e-02f, 7.49736354e-02f, -6.60486147e-02f, -7.68807232e-02f, -6.78613260e-02f, -6.07973430e-03f, 4.78009880e-02f,
  7.68774226e-02f, 5.33893183e-02f, -5.60273752e-02f, 8.34476575e-02f, 3.87497582e-02f, 1.14523601e-02f, 4.01626778e-04f, 5.32794893e-02f, -4.51304577e-02f, 4.54497784e-02f,
  -4.03802209e-02f, 9.57047343e-02f, 4.72047627e-02f, -6.92283586e-02f, 8.55687708e-02f, 4.75319475e-02f, -1.96118969e-02f, -8.57506841e-02f, 4.27609943e-02f, -1.44226626e-02f,
  2.56389361e-02f, -2.64059640e-02f, 8.40835944e-02f, -7.13308752e-02f, -9.68113467e-02f, -7.11161504e-03f, -3.63967977e-02f, -3.96105275e-02f, -3.12746875e-02f, 6.56217113e-02f,
  -7.60841519e-02f, -8.19232166e-02f, -2.29190383e-03f, -7.25522041e-02f, 3.58478725e-02f, -4.02173884e-02f, -8.39243978e-02f, -5.27332239e-02f, -2.96658799e-02f, -3.41780782e-02f,
  -3.18684667e-01f, -1.18469775e-01f, -1.77570701e-01f, -2.94329375e-01f, -1.00041181e-01f, 3.65198515e-02f, 2.13909317e-02f, -9.32171196e-02f, -8.82000849e-02f, -1.76583275e-01f,
  2.75859591e-02f, 2.33380049e-02f, -2.45167948e-02f, 6.75887391e-02f, -8.39341655e-02f, -8.27522799e-02f, -1.27470464e-01f, -1.48086488e-01f, 1.13083430e-01f, -1.55014009e-03f,
  -8.50471407e-02f, -1.49344116e-01f, -1.33144960e-01f, -6.66118041e-02f, -1.56723514e-01f, -1.19234107e-01f, -1.67844236e-01f, -1.52426228e-01f, -2.46007182e-02f, -1.13878496e-01f,
  -2.11600158e-02f, 2.92455032e-02f, 4.18510176e-02f, -3.36950421e-02f, -2.89433636e-02f, -5.92609979e-02f, -6.11643083e-02f, -3.67235877e-02f, 2.75551081e-02f, 3.89566049e-02f,
  -1.33186337e-02f, 7.74838924e-02f, 4.76447493e-02f, 7.39853680e-02f, -3.72488843e-03f, 3.03615164e-03f, -7.33574480e-02f, -6.64835796e-02f, -8.16327855e-02f, -5.84508199e-03f,
  -5.19874226e-03f, 4.68872935e-02f, 2.88399700e-02f, -2.24694554e-02f, 2.48855259e-02f, 4.73394580e-02f, 2.27286504e-03f, 6.22244738e-02f, 1.31601840e-01f, 3.22594717e-02f,
  4.63069091e-03f, -2.28286884e-03f, 6.21117018e-02f, -2.66595427e-02f, 7.33338064e-03f, 2.61938199e-02f, 7.35785766e-03f, -7.30379373e-02f, -2.60942359e-03f, 1.28931776e-02f,
  -3.63965333e-02f, -5.79168946e-02f, -8.69782269e-03f, -7.90815875e-02f, -9.74100232e-02f, 4.13992256e-03f, -2.04348918e-02f, 6.03164509e-02f, 4.03289609e-02f, 2.54681241e-02f,
  -6.25733659e-02f, -8.57239589e-03f, -5.61677851e-02f, -6.10292284e-03f, 4.92332736e-03f, -4.34151553e-02f, 7.07518011e-02f, 9.99136567e-02f, 5.21239787e-02f, 1.03435084e-01f,
  3.79447341e-02f, -9.14270058e-03f, -4.28185239e-03f, 6.26648068e-02f, -7.83662423e-02f, 1.36755584e-02f, -1.23804688e-01f, 1.02975247e-02f, 3.88271250e-02f, 7.00935796e-02f,
  1.32375151e-01f, -6.22690059e-02f, -3.96122746e-02f, 1.61655340e-02f, -4.09491950e-05f, 4.95570414e-02f, -6.64964914e-02f, -1.23513252e-01f, 3.23182680e-02f, -4.63630855e-02f,
  -6.99639022e-02f, -1.91692021e-02f, -5.27238799e-03f, -2.43539121e-02f, 5.30740283e-02f, 5.29917441e-02f, 1.68860778e-02f, 1.28983840e-01f, 3.35420039e-03f, -4.18791659e-02f,
  7.03583807e-02f, 9.58987176e-02f, 1.67971402e-02f, 3.55994776e-02f, 2.40831580e-02f, 9.80689749e-02f, 1.05691373e-01f, -4.73222174e-02f, -2.20699385e-02f, -6.37814179e-02f,
  8.17087591e-02f, -1.02810510e-01f, -2.64769942e-02f, -6.30472898e-02f, 5.08163236e-02f, -9.73968431e-02f, -4.22616787e-02f, -2.35622898e-02f, -9.93836150e-02f, 7.03486502e-02f,
  -1.03300497e-01f, -2.62906589e-02f, 2.88523287e-02f, -9.97756347e-02f, -5.81222400e-02f, 2.23760717e-02f, 1.73877105e-02f, 9.13785398e-02f, -3.87522355e-02f, -5.50024509e-02f,
  -7.00370893e-02f, 1.18444130e-01f, -6.97694719e-04f, 1.23805860e-02f, -4.35241982e-02f, -9.59589407e-02f, 7.38949254e-02f, -1.43069383e-02f, -5.60803860e-02f, 4.34070975e-02f,
  7.22387135e-02f, 8.91048163e-02f, 1.24210687e-02f, -7.38860220e-02f, 7.08442405e-02f, 5.30622192e-02f, 1.55828241e-02f, 3.13034542e-02f, 1.04341641e-01f, 9.28467661e-02f,
  5.06096929e-02f, 8.41260552e-02f, 1.72951240e-02f, 1.00819260e-01f, -1.13176489e-02f, -4.18496206e-02f, -1.44429514e-02f, -6.39711842e-02f, 2.90601663e-02f, -8.64607394e-02f,
  -5.11560477e-02f, 3.76841091e-02f, 2.04427466e-02f, -5.52840307e-02f, -2.04355940e-02f, 2.10706331e-03f, 3.18646766e-02f, -6.63368776e-02f, 1.40505983e-03f, -2.04673372e-02f,
  6.16768524e-02f, 8.58681053e-02f, 4.18474115e-02f, 1.76788196e-02f, 4.16003242e-02f, 1.06968455e-01f, 4.80024964e-02f, -6.14976659e-02f, -2.86693033e-03f, -1.07232612e-02f,
  8.41199234e-02f, -6.81814551e-02f, 3.76494639e-02f, 1.18740480e-02f, -3.21170762e-02f, -8.23125392e-02f, -5.92746064e-02f, 1.11855425e-01f, 5.00699989e-02f, 9.53006651e-03f,
  2.56583113e-02f, 1.34684578e-01f, -1.85858291e-02f, 4.65874150e-02f, -7.95507282e-02f, 4.87406440e-02f, -8.31764936e-02f, 5.30797429e-02f, 9.63117704e-02f, -7.08141178e-02f,
  9.06853005e-02f, 7.93914590e-03f, 1.14734182e-02f, 6.61143363e-02f, -9.67638642e-02f, -3.84452939e-02f, 3.11805196e-02f, -3.42698731e-02f, 4.05725501e-02f, -1.63329020e-02f,
  7.31693357e-02f, -1.20406825e-04f, -4.17298675e-02f, 3.47479209e-02f, 8.32008943e-02f, 3.90953413e-04f, 5.52500673e-02f, -6.13226853e-02f, 5.94431441e-03f, 4.34323959e-03f,
  2.00561240e-01f, 1.07654683e-01f, -8.52022320e-02f, 1.03542678e-01f, 4.57205661e-02f, -5.38392588e-02f, 6.50225654e-02f, 6.71873093e-02f, -7.21541271e-02f, 2.96348203e-02f,
  -1.23466536e-01f, -6.63238689e-02f, -1.65347345e-02f, -1.41414657e-01f, -7.70334154e-03f, -2.60459003e-03f, -2.04296634e-02f, 3.37197147e-02f, -9.51824710e-02f, 4.27765064e-02f,
  -5.66687025e-02f, 1.15535192e-01f, 1.20460182e-01f, -6.29770160e-02f, 4.43361513e-02f, -7.99418688e-02f, -6.10513054e-02f, -8.40859115e-02f, 8.33893381e-03f, 5.47187515e-02f,
  1.79962702e-02f, -1.68625772e-01f, -1.19570354e-02f, -6.40671700e-02f, -1.11328308e-02f, -8.94580968e-03f, 3.15413997e-02f, -4.15911190e-02f, 5.13318889e-02f, 1.12259813e-01f,
  -1.62047967e-02f, -1.92898028e-02f, 2.24348120e-02f, -1.57664716e-02f, 4.05350514e-02f, -4.55188006e-02f, 6.98559433e-02f, -7.84293339e-02f, -4.48566265e-02f, 5.90103399e-03f,
  1.27583323e-02f, -7.50080422e-02f, -6.11192100e-02f, -1.76654030e-02f, -8.54328051e-02f, -9.63567123e-02f, -4.12225164e-02f, -1.10569417e-01f, 2.12538783e-02f, 1.41261920e-01f,
  -1.06252707e-03f, -1.14479445e-01f, -8.16353783e-02f, 7.43775070e-02f, -7.73111135e-02f, 4.08311561e-02f, 3.29680629e-02f, -4.77571748e-02f, 6.64800499e-03f, 1.18924968e-01f,
  7.38007203e-02f, -9.76372585e-02f, -4.52072173e-02f, 1.83938798e-02f, -7.90016800e-02f, -9.51868519e-02f, 4.36258949e-02f, -2.98306197e-02f, -6.81154951e-02f, -8.16113800e-02f,
  -5.92513308e-02f, 2.19115522e-02f, 5.31964488e-02f, -8.36748630e-02f, 5.12950793e-02f, -7.17669725e-03f, -1.05341654e-02f, -8.58457685e-02f, -5.53646497e-02f, 3.81834060e-02f,
  6.51009157e-02f, -2.29488984e-01f, 7.61152506e-02f, 2.44592708e-02f, -5.87214753e-02f, 7.25228153e-03f, -1.00282706e-01f, -9.22543034e-02f, -8.73984993e-02f, -8.09934810e-02f,
  2.00214330e-02f, -5.92147671e-02f, -1.75217241e-02f, 8.88635963e-02f, 9.62419137e-02f, 1.62007380e-02f, 9.07849595e-02f, 6.40812516e-02f, -5.90687059e-02f, -9.33775604e-02f,
  1.13892861e-01f, 1.61649346e-01f, 8.97364318e-02f, 8.81048664e-03f, -3.81351332e-03f, -5.78498049e-03f, 4.14129756e-02f, 3.34610566e-02f, 3.78896929e-02f, 2.53025830e-01f,
  2.16061369e-01f, 6.11864850e-02f, -6.63985685e-02f, 4.97652553e-02f, 9.30642933e-02f, -9.52040032e-02f, -4.39832546e-03f, -2.58667450e-02f, 8.95038992e-02f, 2.59397291e-02f,
  -2.20572110e-02f, -9.49498732e-03f, -4.45898762e-03f, -1.43356487e-01f, -8.41948241e-02f, -8.78703669e-02f, 2.33061090e-02f, -5.71137387e-03f, -7.67408088e-02f, 3.58956837e-04f,
  1.55410795e-02f, 8.94698501e-02f, 1.23203568e-01f, -4.08078395e-02f, -1.94153283e-02f, -1.53775513e-02f, -4.99404334e-02f, -2.10052766e-02f, 1.54387308e-02f, 3.74091789e-02f,
  2.94392067e-03f, -8.46421532e-03f, -7.91419521e-02f, -1.29640978e-02f, -1.74905676e-02f, -4.24242169e-02f, 2.26074196e-02f, 1.75073035e-02f, 8.50711241e-02f, 1.88268181e-02f,
  -1.03469707e-01f, 2.30520554e-02f, 2.25837976e-02f, -7.56458342e-02f, -3.06373145e-02f, 8.41462538e-02f, 8.13043397e-03f, 3.67211476e-02f, -6.03846721e-02f, -9.88656655e-02f,
  -8.86494145e-02f, 7.59439766e-02f, -2.83884536e-02f, 5.69091663e-02f, -3.87825295e-02f, -4.92656720e-04f, -4.28685211e-02f, 5.04934154e-02f, -4.82732877e-02f, 8.24310780e-02f,
  -9.47642177e-02f, 2.60212794e-02f, 3.11356075e-02f, -6.94931149e-02f, -6.53527826e-02f, 2.82183643e-02f, -3.73029634e-02f, -5.85865565e-02f, -3.62930670e-02f, -8.08536112e-02f,
  -2.27716975e-02f, -8.96518230e-02f, -5.26163951e-02f, -8.78578946e-02f, -4.70246784e-02f, 6.80996999e-02f, -1.04432017e-01f, 1.82380769e-02f, 4.65199910e-02f, 7.13634267e-02f,
  -8.64547640e-02f, 4.33671251e-02f, 6.49587065e-02f, 5.02851270e-02f, -6.65607303e-02f, 5.85432723e-02f, 6.76342472e-02f, 6.44566352e-03f, -3.44682671e-02f, 4.89670336e-02f,
  9.14721936e-02f, -6.16460405e-02f, -8.46944228e-02f, -1.59901683e-03f, -1.53447464e-02f, -8.07090625e-02f, -1.04021855e-01f, -3.08149680e-03f, -4.26394604e-02f, -1.04731098e-01f,
  -3.29406150e-02f, -5.53467460e-02f, -1.04633428e-01f, -5.80336861e-02f, -5.89899309e-02f, -3.77268381e-02f, -2.17471179e-02f, 1.58348195e-02f, -7.62918293e-02f, -4.26687524e-02f,
  3.38587239e-02f, -5.72878793e-02f, 4.22638096e-02f, 3.09638847e-02f, 5.37980795e-02f, -4.02194075e-03f, -6.17647870e-03f, 6.98440894e-02f, -1.58555675e-02f, 3.14687863e-02f,
  -4.34021801e-02f, -2.16852613e-02f, 1.48754075e-01f, -4.07723151e-02f, -9.36815590e-02f, -4.07739095e-02f, -1.44913852e-01f, -7.97527656e-02f, 3.59307043e-02f, -5.87136820e-02f,
  -9.75156724e-02f, -1.03303991e-01f, 1.05681859e-01f, 9.21111628e-02f, -1.22766728e-02f, -6.42648190e-02f, 9.10850093e-02f, 1.04957610e-01f, 1.63129374e-01f, 5.40141277e-02f,
  -7.03562424e-02f, 1.65312037e-01f, 2.20459133e-01f, 2.68218201e-02f, 1.88242216e-02f, 1.95897911e-02f, 7.60521740e-02f, 1.11702539e-01f, 9.95964278e-03f, 8.70375801e-03f,
  -1.11931406e-01f, 2.89203897e-02f, 8.25366080e-02f, 4.37789923e-03f, -3.84059437e-02f, -2.76983045e-02f, -3.41288373e-02f, 2.39561703e-02f, -3.08619030e-02f, 5.83100170e-02f,
  -1.62499901e-02f, -5.48619963e-02f, -3.22187245e-02f, -5.40783554e-02f, 5.94814084e-02f, 6.62151352e-02f, 6.40590712e-02f, 9.08112451e-02f, -2.69009639e-02f, 5.39288484e-03f,
  -6.79004341e-02f, -3.75430807e-02f, -5.73469922e-02f, -3.58447209e-02f, 7.28641376e-02f, -2.19647624e-02f, -9.84731168e-02f, -6.07179813e-02f, 7.70911798e-02f, -3.27765271e-02f,
  6.15549311e-02f, -1.28755867e-02f, 2.76552979e-02f, -4.18138737e-03f, -7.10520446e-02f, 2.24056356e-02f, 2.41181906e-02f, -6.05537258e-02f, 6.89840093e-02f, 5.90343215e-02f,
  7.74329305e-02f, -2.76801549e-03f, 3.81940627e-03f, -1.19145494e-02f, 9.51859653e-02f, -3.65366228e-02f, -4.39282246e-02f, 5.19044623e-02f, -5.50316647e-02f, -4.42215241e-02f,
  5.55229075e-02f, 7.08723366e-02f, 6.74329698e-03f, 9.04001370e-02f, -7.79467300e-02f, 9.35968757e-03f, -4.16147197e-03f, 5.26431501e-02f, -1.84628852e-02f, 7.79938176e-02f,
  1.10710440e-02f, 9.67514366e-02f, -4.15364318e-02f, -1.56465992e-02f, -3.05067357e-02f, 3.93192992e-02f, -8.04438740e-02f, -4.84819077e-02f, -1.26294596e-02f, -7.51425233e-03f,
  -5.49669154e-02f, 6.60137832e-02f, -4.21915427e-02f, -2.80841328e-02f, -8.28623027e-02f, -9.14052874e-02f, 6.93927854e-02f, 4.60652299e-02f, 2.36706305e-02f, -8.64557773e-02f,
  -2.87149809e-02f, -4.11007814e-02f, 2.98001394e-02f, -2.06305366e-02f, -1.03317723e-01f, -1.09686188e-01f, -4.77849320e-03f, -7.59456083e-02f, -3.69115844e-02f, -6.33210018e-02f,
  -7.41263852e-02f, -7.22063482e-02f, -1.71187386e-01f, -8.63018930e-02f, 7.69067928e-02f, -1.49111999e-02f, -5.04221544e-02f, 3.42554115e-02f, -4.61782664e-02f, -4.29650629e-03f,
  3.68467011e-02f, 6.69238344e-02f, 5.14025465e-02f, -4.74422611e-02f, -6.18292838e-02f, -1.47387668e-01f, -2.26098999e-01f, -9.84246731e-02f, -3.03557757e-02f, 1.94322377e-01f,
  6.32607937e-02f, 7.03792926e-03f, 6.10699877e-02f, 2.69634947e-02f, 6.07464509e-03f, -6.11225702e-02f, -1.24121539e-01f, 4.95499931e-02f, -2.60094646e-02f, -1.00597836e-01f,
  -1.45457029e-01f, -1.40390294e-02f, 1.08064286e-01f, 9.38587263e-02f, -1.11785419e-01f, 3.76662128e-02f, -5.52805066e-02f, 1.46953128e-02f, -7.45033026e-02f, 2.36186609e-02f,
  -1.88676827e-02f, 5.23459027e-03f, -2.65071727e-02f, 1.10455994e-02f, -7.03083426e-02f, 8.88938755e-02f, -1.57302048e-03f, -3.68833765e-02f, -6.59304708e-02f, 8.32122564e-02f,
  6.12829961e-02f, -3.69102210e-02f, -5.77054657e-02f, 2.20601670e-02f, -1.53640490e-02f, 6.68414980e-02f, 5.34282923e-02f, 6.39472455e-02f, 9.72828791e-02f, -5.85222989e-02f,
  -6.04769662e-02f, 6.36075204e-03f, 1.38969738e-02f, -4.78670299e-02f, -6.92787319e-02f, -1.46983778e-02f, -2.23858729e-02f, -3.86144333e-02f, -5.87761067e-02f, 5.99868856e-02f,
  7.54996901e-03f, -5.25875017e-02f, -9.71291121e-03f, 4.20723669e-02f, -1.76944199e-03f, -2.93170121e-02f, 2.48075910e-02f, -9.55878869e-02f, -6.39006644e-02f, -7.07535520e-02f,
  3.54724266e-02f, 5.10729104e-02f, -4.26590666e-02f, -8.56437068e-03f, -7.39907697e-02f, -4.68743294e-02f, -1.91490375e-03f, 7.92794898e-02f, 7.97358528e-02f, -1.58539135e-02f,
  -9.33211967e-02f, -6.23206161e-02f, -6.28369376e-02f, 7.01681152e-02f, -1.11305295e-03f, 5.47463410e-02f, 3.79970968e-02f, -8.59812349e-02f, 3.03398147e-02f, -3.40604708e-02f,
  -3.77583839e-02f, -4.92440239e-02f, 2.34274287e-02f, -5.73451407e-02f, 5.79593331e-02f, -5.44752218e-02f, -5.11082541e-03f, -7.25087598e-02f, -6.67124093e-02f, -2.42490377e-02f,
  -4.62222006e-03f, -3.75974923e-02f, 1.76220965e-02f, -7.44651258e-02f, 7.80051760e-03f, 1.98595896e-02f, -8.09959546e-02f, 1.90374609e-02f, -7.47866975e-03f, -1.24386460e-01f,
  2.68207878e-01f, -1.28277227e-01f, -3.57095122e-01f, 1.28663689e-01f, -7.39429845e-03f, -2.71160424e-01f, -3.03495616e-01f, 7.74971917e-02f, 8.73821527e-02f, -4.89220247e-02f,
  -5.56737445e-02f, 1.26396999e-01f, -8.32365602e-02f, -9.80051011e-02f, -2.64108419e-01f, -2.75981635e-01f, -2.57898599e-01f, -2.83145994e-01f, -2.14567304e-01f, 2.67487522e-02f,
  3.17071527e-02f, 6.17997795e-02f, -3.77528593e-02f, -1.69018116e-02f, 1.60375223e-01f, 5.45719415e-02f, -5.66406734e-02f, 6.80641085e-02f, -1.74039871e-01f, -1.41455904e-01f,
  -1.88146323e-01f, 6.17647506e-02f, -1.03556313e-01f, -7.06045777e-02f, -2.43710801e-02f, -2.06391998e-02f, -5.80621324e-02f, 6.04570583e-02f, 1.40022978e-01f, -2.69035399e-02f,
  4.21451777e-02f, 3.48848738e-02f, 6.95160255e-02f, 2.39466131e-02f, 8.93738419e-02f, -2.22331863e-02f, 8.10898915e-02f, -4.55004945e-02f, 5.34975715e-03f, -3.83271612e-02f,
  -7.72872800e-03f, -1.05158128e-01f, -8.98662210e-03f, 1.81329008e-02f, -2.84977108e-02f, 2.79605202e-02f, 8.50831047e-02f, 4.89595570e-02f, -4.45003845e-02f, 1.52273804e-01f,
  -9.33696255e-02f, -5.56468368e-02f, 6.99755847e-02f, 5.70602342e-03f, 2.28939019e-02f, 7.88338259e-02f, -2.13472508e-02f, 1.55762595e-03f, 2.25960612e-02f, 5.09367846e-02f,
  -1.76658146e-02f, -3.88500988e-02f, 6.26903027e-02f, 6.08538054e-02f, -3.46752629e-02f, 7.77666047e-02f, 6.90889210e-02f, -4.79577817e-02f, 2.88912598e-02f, -6.52206540e-02f,
  6.55958503e-02f, 6.93671266e-03f, -1.12993661e-02f, 4.89647090e-02f, -1.30268887e-01f, 2.05921521e-03f, -1.52846435e-02f, -3.29993851e-02f, 6.10455722e-02f, -4.06097993e-02f,
  2.57002056e-01f, -2.92628407e-01f, 6.17850609e-02f, 1.80447977e-02f, 4.01709341e-02f, 5.02152890e-02f, 2.78292466e-02f, 6.03645705e-02f, 1.63566973e-02f, -2.00877758e-03f,
  -1.11879697e-02f, -1.40051236e-02f, -4.09241170e-02f, -7.19701424e-02f, 7.48261735e-02f, 6.48398921e-02f, 3.99019122e-02f, 9.24245119e-02f, -3.22981388e-03f, 9.09441188e-02f,
  5.19486703e-02f, 7.94395059e-02f, 4.03492637e-02f, 3.07822637e-02f, 2.35132426e-02f, -3.82456593e-02f, -6.15293644e-02f, 6.37397915e-02f, -1.25707984e-01f, -6.47509191e-03f,
  2.85640746e-01f, 3.50282863e-02f, -5.02944849e-02f, 1.04728349e-01f, -1.17670029e-01f, -6.28279224e-02f, 2.02732403e-02f, 4.06273007e-02f, 3.52689927e-03f, -4.45962287e-02f,
  1.04149207e-01f, 1.33552924e-01f, 1.90789402e-01f, 8.79544616e-02f, 4.98698168e-02f, 6.23855926e-02f, -1.64611302e-02f, 5.87366410e-02f, 3.82353142e-02f, -3.74825113e-02f,
  -4.94974516e-02f, -3.49088907e-02f, -1.82967484e-02f, -5.49743474e-02f, -1.07324205e-01f, 1.81892887e-02f, -7.96169508e-03f, -5.09268269e-02f, -1.43548120e-02f, -5.81354424e-02f,
  -3.23423631e-02f, -4.96715568e-02f, 5.77955097e-02f, 5.27832508e-02f, 3.27525660e-02f, -1.88616794e-02f, 3.17933895e-02f, -3.59846167e-02f, 1.99963013e-03f, -2.14985535e-02f,
  3.78435254e-02f, -2.92037744e-02f, -3.61727886e-02f, 2.32604239e-02f, -7.71776512e-02f, 4.17788960e-02f, -6.19499683e-02f, 1.02874078e-02f, -7.58778527e-02f, 3.57594490e-02f,
  -3.68880369e-02f, -2.43238900e-02f, 2.02821158e-02f, 2.23843697e-02f, -5.46460859e-02f, 3.73607241e-02f, -3.77407745e-02f, -5.29695814e-03f, 3.50896940e-02f, -7.42859021e-02f,
  3.31692323e-02f, 6.66882992e-02f, 7.34787434e-02f, 5.45314103e-02f, 5.50953746e-02f, -4.06767391e-02f, -2.88112368e-02f, 1.54552320e-02f, 6.28384054e-02f, -3.47593129e-02f,
  -4.07661460e-02f, 1.24013955e-02f, 8.05019364e-02f, 5.73399700e-02f, -6.78342879e-02f, -1.18082389e-01f, 5.10626808e-02f, -1.81294084e-02f, -4.26451564e-02f, 6.10330403e-02f,
  8.65486488e-02f, -5.35506234e-02f, 6.44336641e-02f, 2.92455442e-02f, -9.00750905e-02f, -3.97428088e-02f, 2.31748950e-02f, -1.63974555e-03f, -5.79341091e-02f, -2.94332840e-02f,
  -3.62560004e-02f, 6.74038567e-03f, 4.12824936e-02f, 2.72358023e-02f, -4.65702266e-02f, -7.97295477e-03f, 1.94416903e-02f, -3.42658199e-02f, -1.00755505e-01f, -7.66627342e-02f,
  -1.46068900e-03f, 1.06363043e-01f, 1.04132161e-01f, -9.02229473e-02f, 1.46285892e-02f, 8.58056732e-03f, -4.04112004e-02f, -3.91040817e-02f, -3.66897509e-02f, 4.17706557e-03f,
  -7.17864782e-02f, -5.09997196e-02f, 1.26109228e-01f, 8.01791772e-02f, -5.83247542e-02f, 1.79215923e-01f, 4.74163033e-02f, 1.04248626e-02f, 6.00390285e-02f, 1.31023273e-01f,
  1.50973618e-01f, -2.41749510e-02f, 5.53203560e-02f, 1.53252343e-02f, -4.35993299e-02f, -2.33765900e-01f, -2.69667327e-01f, -2.12575018e-01f, -1.88630484e-02f, 3.53508741e-02f,
  2.12101676e-02f, -1.43415723e-02f, 7.84273073e-02f, 7.00739920e-02f, -7.60255307e-02f, 8.27029049e-02f, 6.96039125e-02f, 5.74345849e-02f, 3.86301279e-02f, -1.39206145e-02f,
  1.25073031e-01f, 1.17610313e-01f, 1.38642192e-01f, 2.94166449e-02f, 1.72758952e-01f, 3.53415636e-03f, 2.60079205e-02f, 6.29655570e-02f, 1.17088199e-01f, 2.56169587e-01f,
  2.73526192e-01f, 9.42312106e-02f, -5.57302423e-02f, 9.25629884e-02f, 1.17440239e-01f, 8.40862542e-02f, 4.84269224e-02f, 8.95903911e-03f, -3.33437063e-02f, 6.71699271e-02f,
  3.79720517e-02f, 1.33056790e-01f, -6.79441243e-02f, 8.29927251e-02f, -2.87148636e-02f, 5.12174666e-02f, 1.68557335e-02f, -7.11760446e-02f, 2.94321459e-02f, -4.07527946e-02f,
  -2.00134106e-02f, -8.88099000e-02f, 4.81167622e-03f, -1.25194937e-01f, -9.46672913e-03f, -1.19923711e-01f, -7.73902226e-04f, -6.56751320e-02f, -1.40015259e-01f, -5.85497776e-03f,
  4.85203303e-02f, -9.82729159e-03f, -5.93970492e-02f, -9.83037334e-03f, -3.71632949e-02f, -1.14090525e-01f, 1.56804621e-02f, 4.53935005e-02f, -1.04119815e-01f, 9.54880845e-03f,
  8.69221054e-03f, -1.10962791e-02f, -4.61811908e-02f, -3.26278922e-03f, 1.03351057e-01f, 2.26085950e-02f, 5.71209751e-02f, 4.09088209e-02f, -6.65272996e-02f, 5.67687973e-02f,
  -3.86288911e-02f, -5.36879376e-02f, 5.65384030e-02f, -6.74880669e-02f, -3.46743204e-02f, -7.32093975e-02f, 6.05040155e-02f, 1.99629199e-02f, -6.21424383e-03f, 1.25789374e-01f,
  -9.54608154e-03f, -1.01941250e-01f, 3.85652892e-02f, 3.97901721e-02f, 8.47176760e-02f, 1.97722819e-02f, 7.55679905e-02f, 2.13057138e-02f, 1.20317936e-01f, -1.09851444e-02f,
  -5.31196631e-02f, 2.42774729e-02f, 4.18749712e-02f, 4.05380428e-02f, 5.22927102e-03f, 7.48838335e-02f, 6.11128621e-02f, 5.95988985e-03f, -5.68863004e-02f, 3.69540416e-02f,
  1.07006552e-02f, -7.81931877e-02f, -8.76752287e-02f, -7.83774704e-02f, -1.08528636e-01f, -5.07539883e-02f, -6.28717616e-02f, -7.59493485e-02f, -6.07837066e-02f, -1.76398233e-02f,
  -1.25478193e-01f, 7.23700225e-03f, -1.16126552e-01f, -5.54944687e-02f, -3.22516896e-02f, -1.42413080e-02f, 3.53527232e-03f, 9.69210267e-02f, -1.34332981e-02f, 1.02951052e-03f,
  -2.53636669e-02f, -6.45692050e-02f, -1.35668427e-01f, 2.57275663e-02f, -1.03904426e-01f, -5.62252365e-02f, -1.26926765e-01f, -1.75518319e-01f, 5.54361939e-02f, 4.05496582e-02f,
  2.67836060e-02f, -1.32400483e-01f, -9.34311450e-02f, 2.09029708e-02f, 6.29351586e-02f, 6.19398989e-02f, -1.84011161e-02f, -2.55780816e-02f, 7.99244177e-03f, 2.16115024e-02f,
  -1.54411584e-01f, -8.71439930e-03f, -7.88270012e-02f, -1.37277722e-01f, 2.02488084e-03f, 2.84814779e-02f, 8.28200132e-02f, -1.98840182e-02f, 2.21215636e-02f, -2.51698848e-02f,
  4.29696441e-02f, 7.43938833e-02f, -3.81284505e-02f, -3.94869782e-03f, -7.99856484e-02f, -2.33973134e-02f, 1.76947769e-02f, -1.02286600e-01f, 2.16908883e-02f, -4.09909971e-02f,
  -1.16112895e-01f, 2.22824123e-02f, -9.07913893e-02f, 9.40228999e-03f, -5.06192334e-02f, 7.19736051e-03f, -6.13947995e-02f, 7.98656512e-03f, 3.30081284e-02f, 8.90264884e-02f,
  6.36066720e-02f, 2.76057757e-02f, -4.00013700e-02f, 6.68186322e-02f, -3.09045631e-02f, 5.30629382e-02f, -5.77341877e-02f, 3.33933309e-02f, 6.60607368e-02f, 6.02120645e-02f,
  5.42781800e-02f, -6.77962881e-03f, 2.14220840e-03f, -6.52547851e-02f, -6.59802696e-03f, 6.81103244e-02f, -4.08573747e-02f, -5.09514250e-02f, 4.25169319e-02f, 2.49424260e-02f,
  5.72162727e-03f, 5.66548258e-02f, 4.02679481e-02f, -9.02919844e-02f, -8.54482651e-02f, 2.08453350e-02f, -4.93821427e-02f, -3.05175297e-02f, -1.10221624e-01f, 4.61342484e-02f,
  -5.68019710e-02f, 2.80833486e-02f, -3.16178352e-02f, -6.49986044e-02f, 8.18155706e-02f, 1.04116189e-04f, 1.00806821e-02f, 3.48869711e-02f, 4.37912866e-02f, 2.38767490e-02f,
  -5.15960604e-02f, 5.30930609e-02f, -4.24941219e-02f, -8.67961198e-02f, -4.50551324e-02f, -3.80267538e-02f, -5.74684776e-02f, 2.82522496e-02f, -6.30669370e-02f, 9.97291580e-02f,
  -1.14816211e-01f, -9.13615003e-02f, -4.49713357e-02f, 9.16147791e-03f, 7.00231194e-02f, -3.02490797e-02f, 1.64763480e-02f, -2.29815338e-02f, 6.43624067e-02f, -8.49521682e-02f,
  -2.05714647e-02f, -6.31887838e-02f, -7.54014105e-02f, -1.84089374e-02f, 2.05275536e-01f, 2.05197945e-01f, 2.60226250e-01f, 8.28643963e-02f, -2.70662457e-02f, 1.17236741e-01f,
  7.77953118e-02f, 1.41928904e-02f, -5.01775704e-02f, -8.99847224e-02f, -8.22507143e-02f, 1.41516298e-01f, 3.92317623e-02f, -5.39684575e-03f, 5.59631139e-02f, -3.88035341e-03f,
  -1.15359463e-02f, 6.10385314e-02f, -3.91061753e-02f, -3.74024212e-02f, 6.93115816e-02f, -1.50851961e-02f, -4.40677442e-02f, 3.91949154e-02f, 1.07626580e-01f, -1.86427496e-02f,
  -1.16985492e-01f, 7.84376115e-02f, -4.93731946e-02f, -1.13521941e-01f, -4.59864736e-02f, 3.21596581e-03f, -9.48307663e-02f, -4.08888347e-02f, 3.98838185e-02f, 7.23909512e-02f,
  3.18354443e-02f, -1.02826320e-02f, -4.64523211e-02f, -6.17749617e-02f, 3.73520926e-02f, -8.25295597e-02f, -3.33794504e-02f, -1.03552006e-01f, 7.83208851e-03f, -8.55411440e-02f,
  8.19626302e-02f, 8.43588263e-03f, 4.37501771e-03f, 4.45541851e-02f, 8.60281885e-02f, -4.11681570e-02f, -1.20462291e-02f, 4.48972322e-02f, -2.54475717e-02f, -9.90530625e-02f,
  1.54749136e-02f, -2.95638070e-02f, 8.80128965e-02f, -8.66183341e-02f, 7.30498508e-02f, 1.12112788e-02f, -4.60539013e-02f, -7.54354149e-02f, 3.02406885e-02f, 3.55094448e-02f,
  -1.75568294e-02f, -6.67025819e-02f, 4.93404381e-02f, 7.38765523e-02f, -1.01394027e-01f, 7.19831288e-02f, 4.62668799e-02f, 6.76892921e-02f, -7.72162974e-02f, -5.73057830e-02f,
  6.28677681e-02f, -3.62354703e-02f, -5.62507063e-02f, 2.66228542e-02f, 2.89102457e-02f, 1.65399313e-02f, -5.10639092e-03f, 6.77651316e-02f, 4.97144312e-02f, 2.89398562e-02f,
  -6.84257299e-02f, 1.09109335e-01f, -4.35972139e-02f, 3.90847251e-02f, -8.54622349e-02f, 6.20526969e-02f, 3.81191000e-02f, 3.44960168e-02f, -4.29011770e-02f, 4.25006524e-02f,
  3.56940329e-02f, -5.15380092e-02f, -1.80022530e-02f, -3.06555000e-03f, 5.57351001e-02f, 8.67809206e-02f, 3.99122685e-02f, -3.99945341e-02f, -5.18529601e-02f, -4.24829051e-02f,
  -3.95304039e-02f, 8.08290541e-02f, 6.12006709e-02f, 9.35017839e-02f, 5.31478077e-02f, -8.74841884e-02f, -8.41260478e-02f, -3.98717187e-02f, 4.31529433e-02f, 1.60400942e-02f,
  1.25981539e-01f, -4.47446480e-02f, -1.23788804e-01f, 7.50723183e-02f, -9.71232057e-02f, -1.19860075e-01f, -9.68373865e-02f, -1.31232843e-01f, 4.47961763e-02f, 5.58936037e-02f,
  6.98532388e-02f, 4.58730571e-02f, 2.53357720e-02f, -5.55415861e-02f, -7.71481171e-03f, -1.41195878e-01f, -3.11167445e-02f, -1.21332310e-01f, -1.31671920e-01f, -1.06464818e-01f,
  4.96627651e-02f, 8.75238627e-02f, 1.08475551e-01f, 5.37762195e-02f, 1.06631614e-01f, -6.05124533e-02f, 8.55906531e-02f, 3.12646665e-02f, -6.83579221e-02f, 1.90443243e-03f,
  -1.17291570e-01f, -3.05596571e-02f, -6.14257455e-02f, 5.34942597e-02f, -8.32239464e-02f, -1.02082409e-01f, 3.51773715e-03f, -7.64818164e-03f, -9.46711749e-02f, -1.02677792e-01f,
  1.78417470e-02f, -5.61459847e-02f, -7.73249790e-02f, -2.21422687e-02f, 2.70341467e-02f, -4.00260575e-02f, -3.13553624e-02f, -1.12476550e-01f, -7.65308551e-03f, 4.42766659e-02f,
  4.59234640e-02f, -3.45743494e-03f, 4.81597558e-02f, 3.59376557e-02f, -3.53491530e-02f, -2.32780129e-02f, 1.27127664e-02f, -1.16707399e-01f, -6.71752021e-02f, 4.63771001e-02f,
  4.74728383e-02f, -5.20855002e-02f, -6.72495365e-03f, 5.20751905e-03f, -1.62957758e-02f, 9.99641605e-03f, 2.59674732e-02f, 2.68085171e-02f, 6.59623593e-02f, -6.35698363e-02f,
  5.52542461e-03f, 5.72723038e-02f, -4.06469963e-02f, 6.41339347e-02f, -4.19026688e-02f, -5.75729273e-03f, -5.97414002e-02f, 3.39259095e-02f, 6.17952570e-02f, 3.52045298e-02f,
  -3.28332037e-02f, 1.46989226e-02f, -3.08341049e-02f, 3.96433994e-02f, -1.67784542e-02f, 5.17008081e-02f, 3.04463729e-02f, -9.83323064e-03f, -4.05294411e-02f, -4.48099002e-02f,
  2.68407352e-02f, -1.14178441e-01f, 1.74796078e-02f, -7.46421963e-02f, -3.21843214e-02f, -9.35018584e-02f, 3.95317003e-03f, 4.51009423e-02f, -1.10075073e-02f, -7.28896037e-02f,
  2.75141269e-04f, 1.96914896e-02f, 6.89117908e-02f, -4.27729450e-02f, -4.17563766e-02f, 6.74744397e-02f, -6.51485920e-02f, 4.83612791e-02f, -6.10360466e-02f, -8.48232135e-02f,
  -9.60489083e-03f, 8.18585977e-02f, 7.36242831e-02f, 1.83378495e-02f, 1.90285854e-02f, -4.89503797e-03f, -2.32746266e-02f, 7.14814290e-02f, -7.72649348e-02f, -3.43715809e-02f,
  3.67736369e-02f, 2.47744676e-02f, -2.24066675e-02f, 8.19901973e-02f, 1.00666679e-01f, 1.37520894e-01f, 7.47446790e-02f, 1.25593945e-01f, 4.17280495e-02f, 3.50521021e-02f,
  -4.09548990e-02f, -1.19352881e-02f, 1.88775361e-02f, -1.75513253e-02f, 1.01114623e-01f, -9.64102242e-03f, 1.21122889e-01f, 1.11622857e-02f, 7.69250393e-02f, 4.92292754e-02f,
  3.37059423e-02f, 7.93210790e-02f, -1.08063504e-01f, 6.75146729e-02f, -1.42663363e-02f, 5.14976270e-02f, 9.00076628e-02f, -5.26433773e-02f, -4.67656478e-02f, 5.08903642e-04f,
  -8.40294063e-02f, -6.89492375e-02f, 8.76066685e-02f, 6.30057156e-02f, -9.20024067e-02f, -3.73090282e-02f, -1.50511228e-02f, 5.93377538e-02f, 2.83853728e-02f, -6.16485626e-02f,
  -8.69064257e-02f, -4.73220535e-02f, -4.39535640e-02f, 8.14429820e-02f, 2.45741531e-02f, 5.15752919e-02f, 8.47997218e-02f, 6.45799562e-02f, 5.45586236e-02f, 8.85445625e-02f,
  -3.21410759e-03f, 1.09866979e-02f, -6.03150688e-02f, 1.18247554e-01f, 7.45123029e-02f, -5.43392189e-02f, -4.83770994e-03f, 7.02936202e-02f, 3.14353444e-02f, -2.44151931e-02f,
  -1.12312948e-02f, 4.14269492e-02f, -7.44871423e-02f, -3.17952670e-02f, -1.87056344e-02f, 1.44041069e-02f, -3.94885764e-02f, -6.31219596e-02f, -6.32968768e-02f, 3.49617749e-02f,
  -4.23461720e-02f, -1.64176784e-02f, 3.18725333e-02f, -2.01775972e-02f, 5.31255491e-02f, 4.00944054e-02f, -4.03993502e-02f, 6.12027273e-02f, -5.18618822e-02f, 1.53217949e-02f,
  6.09026924e-02f, 8.57965127e-02f, -8.26875791e-02f, -1.77110136e-02f, 8.65021721e-02f, 4.24575023e-02f, -4.49859612e-02f, -4.83028740e-02f, -1.00514323e-01f, -8.84888619e-02f,
  4.55907285e-02f, 1.02364808e-01f, 9.74990204e-02f, 4.96316608e-03f, 1.22963600e-02f, 9.90923028e-03f, -4.82163057e-02f, -3.53976190e-02f, 8.81821141e-02f, 4.95866500e-02f,
  -9.00837854e-02f, 4.92376573e-02f, -5.21430708e-02f, -3.48970108e-02f, -2.00563204e-02f, 6.98361099e-02f, 2.68292520e-02f, 3.51189524e-02f, 5.41840494e-03f, -8.47844481e-02f,
  8.25314969e-02f, 1.06148487e-02f, -7.06411302e-02f, -4.18387577e-02f, -4.39259782e-02f, 2.85863448e-02f, 3.42081338e-02f, -6.83713332e-02f, 2.38012001e-02f, -3.75348143e-02f,
  -7.14935809e-02f, -8.82914439e-02f, 1.18530340e-01f, 2.37753205e-02f, 8.55845734e-02f, 1.89856291e-01f, 1.08912125e-01f, -2.36157253e-02f, -3.82169187e-02f, -1.49971675e-02f,
  5.33348843e-02f, 3.72021878e-03f, 6.21427782e-02f, -5.02035022e-02f, -2.12105475e-02f, 1.44521341e-01f, -2.04809606e-02f, 1.51587771e-02f, 2.11391479e-01f, 2.54364610e-02f,
  -1.43575864e-02f, -2.89056953e-02f, -1.58763826e-01f, -8.66121352e-02f, 6.53084274e-03f, 1.14577532e-01f, 6.09387236e-04f, 1.24807246e-02f, -6.58065900e-02f, -5.85365519e-02f,
  3.09174061e-01f, -5.02091795e-02f, 1.71742514e-01f, -3.93492505e-02f, 3.89072224e-02f, -8.32455307e-02f, 3.54990885e-02f, 1.20167192e-02f, -3.83291766e-02f, 2.22477783e-02f,
  -5.73637076e-02f, -7.54952878e-02f, -1.04240566e-01f, -1.20224245e-01f, -5.59346601e-02f, 2.70322431e-02f, -7.01000094e-02f, -5.48403412e-02f, 4.83845323e-02f, -9.28652212e-02f,
  -8.63357559e-02f, 2.55642198e-02f, 3.20679359e-02f, 7.45459199e-02f, 6.95971027e-02f, -4.20699194e-02f, -8.61993060e-02f, 6.81226002e-03f, -8.98182020e-02f, 1.53124360e-02f,
  2.04692520e-02f, 2.97393519e-02f, 1.05406623e-02f, 5.48112206e-02f, -7.72309452e-02f, 3.11835967e-02f, 5.17409444e-02f, 6.21326193e-02f, 4.54537906e-02f, 5.12919165e-02f,
  5.37410714e-02f, 7.61465877e-02f, 7.27346838e-02f, 6.35993332e-02f, 4.26843092e-02f, -8.27585757e-02f, 3.72389853e-02f, -4.20902893e-02f, -6.49143849e-03f, -6.47828206e-02f,
  -8.60667676e-02f, -5.81083074e-02f, -6.99190870e-02f, -1.28430063e-02f, -7.92995747e-03f, 8.08292404e-02f, 4.18436378e-02f, -9.47659537e-02f, -7.90331960e-02f, -2.63899975e-02f,
  1.98282778e-01f, -1.04988158e-01f, 7.29309171e-02f, -7.94930458e-02f, -4.13360968e-02f, -4.86352555e-02f, -4.40884195e-03f, -8.43896531e-04f, -1.01799846e-01f, 1.49221513e-02f,
  1.53689440e-02f, -9.38067213e-03f, 3.19842063e-02f, -9.20550674e-02f, 1.09572202e-01f, 4.16431911e-02f, -2.85643283e-02f, 9.96255055e-02f, 2.79689040e-02f, 5.00592180e-02f,
  -1.13750644e-01f, 2.60620918e-02f, 9.93193612e-02f, 1.68356910e-01f, 6.58781677e-02f, 8.24637711e-02f, 1.87221542e-01f, 1.22443371e-01f, 2.51970738e-02f, 1.96187079e-01f,
  2.33809114e-01f, 1.89676434e-01f, 6.67359680e-02f, 1.22602679e-01f, 4.68897857e-02f, 3.52390632e-02f, 2.29669705e-01f, 6.77479580e-02f, -4.13755234e-03f, 9.02242959e-02f,
  9.56913978e-02f, 8.23909566e-02f, -4.06495593e-02f, -1.42265800e-02f, 1.36211127e-01f, -3.37487198e-02f, -1.24961235e-01f, -4.80049103e-02f, 3.47275995e-02f, 4.01738063e-02f,
  3.69900316e-02f, 4.90623042e-02f, 3.22460942e-02f, 1.16083724e-02f, -1.05923153e-02f, -8.56057927e-02f, 6.71623871e-02f, 1.15124375e-01f, -8.01133085e-03f, -8.80232975e-02f,
  3.20519954e-02f, 2.75025219e-01f, -1.65608868e-01f, -8.89969170e-02f, -2.63493806e-02f, -1.00012310e-01f, -5.73426485e-02f, -4.58155051e-02f, 4.07430530e-02f, -7.90336877e-02f,
  -1.01405419e-02f, 1.59338787e-02f, -3.71424481e-02f, -7.65424296e-02f, 2.15711538e-02f, 2.64686793e-02f, 1.01996167e-02f, -6.57633394e-02f, -7.65446052e-02f, -4.12742682e-02f,
  -3.04240528e-02f, 7.48934895e-02f, -1.01107797e-02f, 9.56418663e-02f, -3.19293048e-03f, 3.20021361e-02f, 1.36075452e-01f, 4.25917236e-03f, -1.04608629e-02f, 4.38400321e-02f,
  1.58766359e-02f, 8.07264671e-02f, 1.76571123e-02f, -3.23977172e-02f, -6.35813326e-02f, -3.78225185e-02f, -4.23420854e-02f, -5.89586832e-02f, -3.41026001e-02f, 4.05513868e-02f,
  -1.27175180e-02f, 7.44296238e-02f, -7.31230229e-02f, -1.00291632e-01f, 7.27836275e-03f, 4.67914157e-02f, 3.47692072e-02f, -2.73200887e-04f, -3.17412354e-02f, -6.73069805e-02f,
  -3.47996801e-02f, -5.07688150e-02f, -4.01634015e-02f, -4.74189501e-03f, 8.72732997e-02f, 7.26973638e-02f, 3.72405872e-02f, -7.05354214e-02f, -3.52821089e-02f, 2.02338099e-02f,
  -1.07430279e-01f, 5.44560850e-02f, -5.06665148e-02f, -3.63276564e-02f, -6.14653602e-02f, 5.92458993e-02f, 7.30664656e-02f, -3.52374427e-02f, 6.85491040e-02f, -3.01404241e-02f,
  -4.53597941e-02f, 6.83664232e-02f, 6.78924695e-02f, 6.52213767e-02f, -1.99735761e-02f, -7.20536336e-02f, -6.98964624e-03f, -9.72178355e-02f, -2.66794972e-02f, 6.90001473e-02f,
  1.72385722e-02f, -6.48469254e-02f, -1.29342705e-01f, -3.54058221e-02f, -8.93871337e-02f, 3.15871201e-02f, -2.21683178e-02f, -4.60835695e-02f, -3.79510634e-02f, -7.14258477e-02f,
  -2.98903078e-01f, -4.56784330e-02f, -5.27052879e-02f, 4.83180881e-02f, 1.22263648e-01f, 1.85581475e-01f, 1.25610009e-01f, 8.11311975e-02f, 9.26936865e-02f, -6.30251169e-02f,
  -2.48178747e-02f, 5.08891083e-02f, 4.45371717e-02f, 7.23715127e-02f, 1.39091745e-01f, 1.86069116e-01f, 1.49410784e-01f, 9.38117951e-02f, -2.49296222e-02f, 1.90179758e-02f,
  4.09860946e-02f, 7.11090043e-02f, -9.15774181e-02f, 3.37460600e-02f, 7.34075829e-02f, 8.75296742e-02f, -6.66411966e-02f, -5.08787408e-02f, 1.51980400e-01f, 2.25748956e-01f,
  -2.13566437e-01f, -2.21648484e-01f, 6.56973794e-02f, -7.95070827e-02f, -2.97515932e-02f, 1.41379545e-02f, 4.85251620e-02f, -1.30228579e-01f, -1.76044125e-02f, -9.86971259e-02f,
  -6.31633401e-02f, -5.82251027e-02f, -6.46928847e-02f, -5.22399917e-02f, -6.50810152e-02f, 3.18525322e-02f, 4.28527780e-03f, -1.04810789e-01f, -1.06407009e-01f, -5.53952716e-02f,
  1.49406716e-01f, -1.42318346e-02f, -5.58554120e-02f, -8.49951580e-02f, 5.96507862e-02f, -1.20701138e-02f, -9.34671611e-02f, -5.68637401e-02f, -2.98653860e-02f, -4.08040769e-02f,
  2.74574682e-02f, 7.12661678e-03f, 1.23023624e-02f, 3.94540988e-02f, 6.19997382e-02f, 5.14859967e-02f, 1.16076194e-01f, -1.32366391e-02f, 9.85281840e-02f, -5.07994480e-02f,
  1.54114701e-02f, -1.33728445e-01f, -5.90172857e-02f, 5.96260279e-02f, 1.02399127e-03f, -7.26556480e-02f, 9.19354483e-02f, -7.89184198e-02f, -5.38896658e-02f, -8.39420184e-02f,
  4.64710891e-02f, -6.17857948e-02f, -1.95049532e-02f, 9.42779891e-03f, 8.20038393e-02f, 9.74471122e-03f, 4.33753207e-02f, 4.00607921e-02f, -2.73016375e-02f, -5.31604104e-02f,
  -1.39789864e-01f, -1.19018428e-01f, -4.50190529e-02f, 5.25294133e-02f, 1.20226555e-02f, -5.68449982e-02f, 3.13288793e-02f, 7.23435660e-04f, 5.67969829e-02f, -3.78497541e-02f,
  -3.85965779e-02f, -6.15858361e-02f, -5.30422963e-02f, 5.91548570e-02f, -1.11208491e-01f, -6.44006208e-02f, -7.03456849e-02f, -5.16730994e-02f, 2.51456797e-02f, -2.64998693e-02f,
  -2.16238946e-02f, 6.82237977e-03f, -1.43090010e-01f, -5.78966737e-02f, -4.06790115e-02f, -3.03318482e-02f, -2.08730623e-02f, -9.95394513e-02f, -1.65352106e-01f, -7.27255195e-02f,
  2.45944172e-01f, -1.18437344e-02f, 5.29192798e-02f, 1.31564528e-01f, 1.55647250e-03f, -6.86379746e-02f, 6.91381767e-02f, 6.75879568e-02f, 3.95823568e-02f, 7.03975186e-02f,
  1.75244287e-01f, 1.05525345e-01f, 7.36017153e-02f, 9.12238583e-02f, 1.02905497e-01f, -2.10550018e-02f, -9.13724899e-02f, 1.15305372e-02f, 9.95561853e-02f, 4.80212756e-02f,
  4.28603142e-02f, 6.10980615e-02f, 7.16100559e-02f, 9.87449735e-02f, 8.39827284e-02f, 7.83431083e-02f, -1.68491174e-02f, -1.20319361e-02f, -3.28868590e-02f, -9.14224312e-02f,
  1.82956263e-01f, 2.11068705e-01f, -2.65855994e-02f, 9.48382393e-02f, 1.09625682e-01f, -4.36831675e-02f, 8.19295868e-02f, -3.05875833e-03f, 2.27331389e-02f, 5.58490269e-02f,
  8.55829045e-02f, 1.02692604e-01f, 5.70516028e-02f, -1.07310666e-02f, 8.33560750e-02f, 6.62200004e-02f, 9.53903943e-02f, 2.06395909e-02f, -1.29189994e-02f, 7.64355958e-02f,
  5.44336848e-02f, 8.08548704e-02f, 3.41390967e-02f, 5.89612052e-02f, -4.00793552e-02f, 9.89209339e-02f, -2.62293927e-02f, 3.88614275e-02f, 7.78001472e-02f, 8.92672613e-02f,
  1.85308363e-02f, 2.34629828e-02f, 2.54026391e-02f, 7.49466866e-02f, -5.15672565e-02f, 4.66797389e-02f, -7.21335560e-02f, 6.77771717e-02f, 5.13997339e-02f, 9.62886901e-04f,
  3.69339585e-02f, 8.24657753e-02f, -1.34598929e-02f, 8.14360976e-02f, 5.32557182e-02f, -6.97497129e-02f, -3.96230966e-02f, 8.72730538e-02f, 1.52416304e-02f, 1.10928029e-01f,
  -4.04387824e-02f, 7.93928206e-02f, 1.59232877e-02f, 8.84828866e-02f, 8.64748563e-06f, 5.61657324e-02f, 2.93997563e-02f, 1.46873891e-02f, 1.33993337e-02f, 6.88866079e-02f,
  -7.77129531e-02f, 9.23992135e-03f, 2.54192203e-02f, 7.69606419e-03f, -2.41654133e-03f, 1.80827156e-02f, -1.66350026e-02f, 2.22649220e-02f, -5.10761291e-02f, -4.86636125e-02f,
  -1.53584862e-02f, 9.62826088e-02f, -6.95193484e-02f, -1.34644443e-02f, 7.12262187e-03f, 2.98658516e-02f, -3.04786232e-03f, 3.08082048e-02f, 2.52311882e-02f, 4.21206765e-02f,
  -1.24620326e-01f, 1.92564458e-03f, 2.96386983e-02f, -9.45551991e-02f, 3.27258604e-03f, 5.23492731e-02f, -9.68797281e-02f, -6.21161573e-02f, -5.90474717e-02f, -8.78662691e-02f,
  2.06396550e-01f, 2.54502706e-02f, -1.07601665e-01f, 2.37933144e-01f, -4.97946143e-02f, -1.56167015e-01f, -6.90575987e-02f, -7.31042549e-02f, 6.35572076e-02f, 6.78016171e-02f,
  5.24110859e-03f, -5.35161830e-02f, -6.36469349e-02f, -6.45358786e-02f, -1.92521274e-01f, -9.61940885e-02f, -1.57739460e-01f, -1.14071742e-01f, -1.68131948e-01f, -7.01308921e-02f,
  2.37496905e-02f, -3.40064950e-02f, -7.99880922e-02f, -2.61491481e-02f, -3.38455662e-02f, 3.85547951e-02f, -7.63088390e-02f, -7.19849467e-02f, -1.24748491e-01f, -1.06042318e-01f,
  -9.65759978e-02f, 9.99317169e-02f, -8.59200507e-02f, -3.62178460e-02f, -1.37472227e-02f, -7.63052702e-02f, 2.09435374e-02f, -8.56309310e-02f, -1.39224017e-02f, -3.36150564e-02f,
  -6.48429096e-02f, 5.12401089e-02f, 7.00231874e-03f, -4.51423675e-02f, -1.48621881e-02f, -1.10169455e-01f, -7.59006143e-02f, -7.96375424e-02f, -8.62423107e-02f, -1.35661259e-01f,
  -9.76607874e-02f, -1.26751140e-01f, -9.72928107e-02f, 1.94386318e-02f, 2.60047186e-02f, -6.66672364e-02f, 5.60391806e-02f, -1.20669216e-01f, 1.58368517e-02f, -6.50006253e-03f,
  3.66440192e-02f, 7.23790154e-02f, -8.44999030e-02f, -6.09027706e-02f, 7.31627122e-02f, -2.91038714e-02f, 3.54932174e-02f, -8.98171812e-02f, 7.21906349e-02f, 6.23010583e-02f,
  -5.32364175e-02f, -3.22035477e-02f, 1.60258617e-02f, 3.54991816e-02f, -3.91347893e-02f, 1.22198807e-02f, -6.44361228e-02f, -6.31864816e-02f, 1.53648527e-02f, 2.29990538e-02f,
  -3.97696160e-02f, -6.02060854e-02f, 8.65269899e-02f, -2.02900991e-02f, -8.54043942e-03f, -2.32596397e-02f, 3.51062207e-03f, -3.29182595e-02f, 2.83462405e-02f, 5.95859215e-02f,
  2.39227504e-01f, -9.96618867e-02f, 4.01534885e-02f, -1.10437684e-01f, -5.74326403e-02f, 5.21587804e-02f, 5.33636995e-02f, 4.30036848e-03f, 6.44639879e-02f, 3.85151431e-02f,
  -5.17169237e-02f, 3.45381200e-02f, 3.03325877e-02f, 2.79721208e-02f, -6.03460670e-02f, -1.27688318e-01f, -1.22747436e-01f, -1.03948992e-02f, -3.24720182e-02f, 4.31173518e-02f,
  -3.86396162e-02f, -3.49953622e-02f, -9.19687524e-02f, -8.79873857e-02f, -2.97223032e-02f, 3.93682420e-02f, 5.18103829e-03f, 4.07454073e-02f, -1.34009287e-01f, 8.05409253e-02f,
  -4.34882760e-01f, -5.63291274e-02f, 3.22995074e-02f, -4.18309830e-02f, -3.27245817e-02f, -2.01694034e-02f, 1.31600410e-01f, 8.64627734e-02f, -6.85085878e-02f, -1.97094516e-03f,
  -6.36753887e-02f, -6.84683472e-02f, -5.78550398e-02f, 8.89194161e-02f, 4.69049476e-02f, 1.44286439e-01f, -6.96811685e-03f, 6.43695071e-02f, -7.24873096e-02f, 1.04876049e-01f,
  -6.97663724e-02f, -1.67473592e-02f, -1.55009404e-01f, -4.48275395e-02f, 4.62515838e-02f, -6.89333826e-02f, 8.32923106e-04f, -7.75883421e-02f, 9.38427970e-02f, 1.78552233e-02f,
  2.77986765e-01f, -1.47177905e-01f, -3.85841578e-02f, -4.99008931e-02f, 6.81623258e-03f, -3.82139124e-02f, -9.87661257e-02f, -4.83875396e-03f, -7.92156681e-02f, 8.10227990e-02f,
  8.16415995e-02f, 3.22539993e-02f, 2.84077823e-02f, 5.90077117e-02f, 4.98550236e-02f, 5.71774617e-02f, 4.18053232e-02f, -7.44477287e-02f, -2.61975378e-02f, 4.98051755e-03f,
  1.03926316e-01f, -8.54957625e-02f, 2.50650831e-02f, 2.68311128e-02f, -7.64833689e-02f, -8.35462734e-02f, 1.21440798e-01f, 5.57339787e-02f, 1.48170702e-02f, -6.76570162e-02f,
  -2.41569467e-02f, 8.47194195e-02f, -7.52972960e-02f, 9.97475535e-03f, -1.72982607e-02f, -6.99361637e-02f, 9.43713486e-02f, 2.78823301e-02f, 2.13237666e-02f, 2.12153196e-02f,
  -5.49461991e-02f, 5.80251291e-02f, 6.14934713e-02f, -7.46160671e-02f, 3.80160511e-02f, -5.27389459e-02f, -8.93052965e-02f, -2.84519158e-02f, 9.07722712e-02f, -7.32568055e-02f,
  1.10653816e-02f, 9.19029564e-02f, 8.82982388e-02f, 2.20374744e-02f, 1.70421898e-02f, -3.23779657e-02f, -3.41576152e-02f, 2.84479242e-02f, 6.10071644e-02f, -2.41699871e-02f,
  1.83592364e-01f, -1.01484776e-01f, 4.19116346e-03f, 1.59674557e-03f, -3.39227798e-03f, -4.02017646e-02f, 7.73627684e-02f, 3.67725976e-02f, 2.61183828e-03f, 1.95330586e-02f,
  -1.33183887e-02f, 2.26918124e-02f, -5.05419932e-02f, 5.34003899e-02f, 6.67269230e-02f, 4.34205607e-02f, 3.84630114e-02f, -1.64369382e-02f, -2.16275565e-02f, 9.44705382e-02f,
  9.41612199e-02f, 1.13044409e-02f, 1.51359230e-01f, 6.05910942e-02f, -1.89490188e-02f, -3.79827134e-02f, 1.83295846e-01f, 1.74730346e-01f, 9.89251956e-02f, 4.19166647e-02f,
  -1.17399115e-02f, 2.22398445e-01f, 1.45706952e-01f, 2.10316047e-01f, 2.39849865e-01f, 2.75602728e-01f, 3.32025409e-01f, 1.33419916e-01f, 3.32674310e-02f, 1.63407445e-01f,
  7.80011863e-02f, -2.14065611e-02f, 8.52699429e-02f, -4.90371548e-02f, 9.25677493e-02f, 9.59679708e-02f, 9.20396373e-02f, -1.12779126e-01f, -1.36132669e-02f, 1.08009517e-01f,
  -6.28048554e-02f, 8.30672458e-02f, -9.72271711e-02f, 2.46846657e-02f, 6.08434007e-02f, -2.26256587e-02f, 1.08249776e-01f, -9.21506342e-03f, 1.07193356e-02f, -7.84552321e-02f,
  2.55042110e-02f, 1.71526298e-01f, -6.70716241e-02f, -1.52303785e-01f, 8.48422796e-02f, -1.51409343e-01f, 9.40278545e-03f, -1.65286571e-01f, 3.49681005e-02f, -4.54985537e-03f,
  4.24527861e-02f, -3.57375555e-02f, -2.40485948e-02f, -8.05141553e-02f, -1.08155506e-02f, -8.35509673e-02f, -1.31039530e-01f, 6.12079203e-02f, -5.57054691e-02f, -6.19531237e-02f,
  9.26002935e-02f, 7.42161497e-02f, 1.55563056e-01f, 6.24465197e-02f, 5.72872944e-02f, -4.51706201e-02f, 1.77100413e-02f, -8.51679221e-03f, 2.01759068e-03f, -3.92871946e-02f,
  -8.53921399e-02f, -1.74861718e-02f, 4.93913479e-02f, -4.18268004e-03f, 3.83186340e-02f, 1.64048970e-02f, 6.90517947e-02f, 9.52376202e-02f, -4.59788293e-02f, -4.44227047e-02f,
  9.40037891e-02f, 1.25511127e-04f, -1.24217505e-02f, 2.04450507e-02f, 2.49110200e-02f, -1.64406206e-02f, 7.68358484e-02f, 4.13170271e-02f, -8.90922174e-02f, -3.56614660e-03f,
  1.22636026e-02f, -1.55379502e-02f, 4.20360342e-02f, 8.75723828e-03f, -1.18087018e-02f, 5.76954801e-03f, -7.55940303e-02f, -4.15538438e-02f, -8.52395967e-02f, 2.96383817e-03f,
  -1.26633540e-01f, 5.70580624e-02f, -4.92006093e-02f, -7.80837145e-03f, 5.52401878e-02f, -1.13195568e-01f, 3.36006172e-02f, 1.81453442e-03f, -2.87155565e-02f, 4.14325483e-02f,
  8.54272302e-03f, 1.24443173e-02f, -2.68776668e-04f, 4.23854329e-02f, -6.57788515e-02f, -9.62853804e-03f, 2.38166712e-02f, 8.94501340e-03f, -9.75990891e-02f, 5.12557700e-02f,
  -3.33379731e-02f, -1.43784452e-02f, 4.36222106e-02f, -5.20768166e-02f, 7.25834072e-02f, -5.07517494e-02f, -9.86675844e-02f, 9.97505989e-03f, -2.17074808e-02f, -1.42811477e-01f,
  1.93941996e-01f, 5.40409610e-02f, 1.43820614e-01f, 6.49207681e-02f, 7.07642585e-02f, 1.11005448e-01f, 2.87496299e-03f, 6.25032187e-02f, 4.91356552e-02f, 6.29921556e-02f,
  -9.52896178e-02f, -3.14032622e-02f, -1.06754974e-01f, 2.31640209e-02f, 2.05233991e-02f, 7.65328249e-03f, 2.64265556e-02f, 7.79823288e-02f, 1.86820365e-02f, 1.29672483e-01f,
  -9.05314535e-02f, 4.10202891e-02f, -7.04174722e-03f, 4.49950285e-02f, 9.46934521e-02f, -5.25190756e-02f, 1.08810924e-01f, -1.54084526e-02f, 1.38291279e-02f, -1.13324812e-02f,
  8.71312022e-02f, 1.68968171e-01f, 3.33497301e-02f, -6.62547126e-02f, -6.25363812e-02f, 2.49955393e-02f, 3.92195769e-02f, -7.20966607e-02f, -7.84328654e-02f, -7.19901407e-03f,
  -5.46459332e-02f, -8.55682567e-02f, -1.98728424e-02f, 6.79659396e-02f, 8.08433965e-02f, 1.08237274e-01f, 1.71353333e-02f, 1.24448821e-01f, 5.37622236e-02f, 1.03100166e-01f,
  -9.62923318e-02f, -5.71879297e-02f, 1.05310360e-03f, -5.06539084e-02f, -1.92682333e-02f, 4.83133718e-02f, 5.14347553e-02f, 8.55786651e-02f, 3.65873389e-02f, 2.19101552e-02f,
  -1.14355795e-01f, 5.70080467e-02f, -1.99757814e-02f, 1.65404100e-02f, 3.97411995e-02f, 2.45169345e-02f, -5.40887639e-02f, -9.09304619e-03f, 7.64075592e-02f, -1.78028047e-02f,
  1.08699305e-02f, 5.32644242e-02f, 6.90910965e-02f, 6.25031963e-02f, -6.17433228e-02f, 2.63077952e-02f, 1.97999552e-02f, 1.28800785e-02f, -4.63710949e-02f, -1.52252764e-02f,
  8.69491249e-02f, -4.95221764e-02f, 1.54651487e-02f, -1.45115820e-03f, 5.82528338e-02f, 7.57883266e-02f, -6.05669059e-02f, -2.89698932e-02f, -6.52610958e-02f, -6.68480545e-02f,
  -7.39979148e-02f, 8.29665139e-02f, 1.64349433e-02f, 1.22758318e-02f, 7.61997476e-02f, 1.87153704e-02f, 5.81385978e-02f, 1.29803997e-02f, 4.89058085e-02f, 8.90247151e-02f,
  -6.19786382e-02f, 2.23143995e-02f, -4.04630639e-02f, 9.39253643e-02f, 4.96053472e-02f, -1.90345962e-02f, -6.57788590e-02f, 4.90519181e-02f, -7.59680383e-03f, -5.34007512e-02f,
  -5.26642352e-02f, 3.98633666e-02f, -3.12306341e-02f, -7.70401731e-02f, 7.01784417e-02f, -8.61662850e-02f, 8.80689025e-02f, 8.53994638e-02f, -2.22181659e-02f, -7.38329887e-02f,
  5.86878732e-02f, -1.95835769e-01f, -1.20601207e-01f, -1.43215775e-01f, -1.63356170e-01f, -9.62235481e-02f, -2.24767625e-01f, -3.16570960e-02f, -1.15608044e-01f, -2.14181855e-01f,
  7.54388236e-03f, 1.46589771e-01f, 1.56693831e-01f, 1.67402223e-01f, 2.26945654e-01f, -1.74596757e-01f, -1.50122896e-01f, 1.56069934e-01f, 2.81361967e-01f, 1.25727236e-01f,
  -8.40793177e-02f, -1.11730034e-02f, 9.26850438e-02f, 1.11689799e-01f, -1.40790820e-01f, -4.49259020e-02f, -7.33920410e-02f, -1.63369879e-01f, -1.40715182e-01f, -1.88717663e-01f,
  4.05650996e-02f, -1.87576823e-02f, 1.10700607e-01f, 1.55876987e-02f, -9.02516395e-02f, 7.85376951e-02f, -3.26650180e-02f, 4.58111018e-02f, -2.97759809e-02f, -1.06165782e-01f,
  -3.29901278e-02f, -1.03388345e-02f, -2.92336345e-02f, -5.46797588e-02f, -9.53166634e-02f, 5.22098839e-02f, -8.82547407e-04f, -3.48482579e-02f, 7.73260146e-02f, -8.75966847e-02f,
  -9.17334780e-02f, -2.83851214e-02f, -3.91198210e-02f, 2.04992928e-02f, 2.16471422e-02f, 1.55761456e-02f, -4.59742639e-03f, -6.25543669e-02f, 6.10219426e-02f, -2.30455190e-01f,
  -4.46230918e-02f, 2.05566827e-02f, 2.54382361e-02f, 4.66679633e-02f, -6.61747456e-02f, -4.82877083e-02f, 6.70547113e-02f, 3.45643423e-02f, -5.46629466e-02f, 7.50876665e-02f,
  3.72024588e-02f, -4.35871854e-02f, -4.39703800e-02f, 2.48409733e-02f, -2.54935957e-02f, 2.77847704e-02f, 1.12164253e-02f, -9.43425391e-03f, 5.17745316e-02f, -7.31587783e-02f,
  9.30541977e-02f, -3.80231924e-02f, -7.16813952e-02f, -1.31156268e-02f, -7.95105174e-02f, -1.03259869e-02f, -6.37423098e-02f, 3.01791113e-02f, 1.06603047e-02f, 2.61036530e-02f,
  7.66326785e-02f, 1.56062260e-01f, -1.14493392e-01f, 1.17832147e-01f, -7.73115233e-02f, -3.88855785e-02f, -2.61830501e-02f, 9.70644951e-02f, -1.36125339e-02f, -7.93193206e-02f,
  7.11789206e-02f, 1.21976756e-01f, 4.17356603e-02f, 3.03834602e-02f, -3.12328674e-02f, 2.46915761e-02f, -6.89002275e-02f, -2.20478904e-02f, 2.57207770e-02f, 2.05156542e-02f,
  -9.58912366e-04f, 3.61943729e-02f, 6.09054379e-02f, 4.81835101e-03f, -9.95137841e-02f, 1.88064724e-01f, 8.36624950e-03f, 1.02374824e-02f, 5.67896925e-02f, -8.92054588e-02f,
  7.32906982e-02f, -3.54991145e-02f, -2.23078862e-01f, -4.34847176e-02f, -1.27114028e-01f, -1.22432008e-01f, -9.23253819e-02f, 1.62781421e-02f, 7.74313062e-02f, -8.02900270e-02f,
  -4.04327400e-02f, 7.90918171e-02f, 5.26958220e-02f, 1.50376484e-02f, 3.81548926e-02f, -1.94956735e-01f, -2.29716018e-01f, -1.58867523e-01f, -6.15373962e-02f, 4.91499044e-02f,
  3.05233728e-02f, 6.71477839e-02f, 9.09511298e-02f, 3.10107227e-02f, 1.79769974e-02f, 6.72430396e-02f, -8.50458294e-02f, -9.14054587e-02f, -9.06584486e-02f, -2.21414909e-01f,
  -3.27993572e-01f, 1.36332467e-01f, 2.62575578e-02f, 1.02952063e-01f, 3.56199965e-02f, 4.82503930e-03f, 4.25231345e-02f, 1.13789402e-01f, 7.88119286e-02f, -4.67456132e-02f,
  9.51561183e-02f, -3.76054160e-02f, 7.51063079e-02f, -1.14772264e-02f, 2.05006730e-02f, 1.53451841e-02f, 9.98670757e-02f, -3.91772166e-02f, 2.17740834e-02f, 6.58664256e-02f,
  -6.60001189e-02f, -9.26567838e-02f, 5.93256988e-02f, 1.46942109e-01f, 5.13713136e-02f, -4.63886634e-02f, 5.97665794e-02f, 9.29593369e-02f, 9.07933712e-02f, 1.15413532e-01f,
  4.40924205e-02f, 1.42271817e-02f, -8.23462680e-02f, 1.11999974e-01f, -1.14125302e-02f, 4.56038453e-02f, 5.59284650e-02f, -6.55471012e-02f, -2.66126804e-02f, -5.29548787e-02f,
  1.45613654e-02f, 3.39100510e-03f, 4.98692617e-02f, -1.22766988e-02f, -1.13168962e-01f, -9.55707431e-02f, -7.92613998e-02f, 8.20181817e-02f, -9.38622728e-02f, 7.86024183e-02f,
  -7.07812235e-02f, -3.89061519e-03f, 1.84400100e-02f, 1.88805815e-02f, -5.88036925e-02f, 1.03452876e-02f, -4.73192409e-02f, 5.59989475e-02f, 7.38421977e-02f, -4.06229831e-02f,
  3.49914283e-02f, -3.69054787e-02f, -7.15351924e-02f, 1.12020403e-01f, 2.31800228e-03f, -3.99122126e-02f, -7.31383190e-02f, 3.84789682e-03f, 1.76709448e-03f, -7.19674453e-02f,
  6.84967712e-02f, -1.38846561e-02f, -4.73212972e-02f, 6.69351816e-02f, -2.63261013e-02f, -4.90921699e-02f, 9.36699361e-02f, 5.06486557e-02f, 2.29886491e-02f, -3.01716365e-02f,
  -5.06305993e-02f, 7.17134103e-02f, -1.64015088e-02f, 2.08986923e-02f, 6.40601246e-03f, 8.64316151e-02f, 2.77552642e-02f, -1.43376272e-02f, -3.01072287e-04f, 2.39560450e-05f,
  -1.66994298e-03f, -3.28403525e-02f, 1.88479602e-01f, 9.11119208e-03f, -1.25919655e-01f, -6.73923343e-02f, -8.31604153e-02f, -5.95415048e-02f, -2.20935401e-02f, -1.69206727e-02f,
  -7.13026449e-02f, -3.79525940e-04f, 9.02071744e-02f, 1.22111142e-01f, 6.64511248e-02f, 9.70533863e-02f, -2.33485885e-02f, 1.93886518e-01f, 1.81557402e-01f, 1.89365987e-02f,
  -2.15651933e-03f, 7.36741573e-02f, 3.73972170e-02f, 9.08639356e-02f, -6.22652508e-02f, 1.05718896e-01f, -8.44366774e-02f, 6.27225116e-02f, 6.98777614e-03f, 7.23657757e-02f,
  9.32274684e-02f, -6.31269440e-02f, 4.85847592e-02f, -5.06495945e-02f, -1.87331121e-02f, 8.39534253e-02f, 2.68042609e-02f, -3.06507368e-02f, -2.48046927e-02f, -6.03083372e-02f,
  -8.01613703e-02f, -7.74730742e-02f, -3.73622850e-02f, 9.38059296e-03f, -1.25429314e-02f, 6.00747913e-02f, -2.16643754e-02f, 6.20825626e-02f, 8.81697051e-03f, 8.50573927e-02f,
  1.00452667e-02f, -2.40988377e-02f, -6.48550838e-02f, 1.17517961e-02f, 1.58210024e-02f, 1.33342817e-01f, 6.05800487e-02f, -9.35185552e-02f, 1.64307968e-03f, 7.89325684e-02f,
  3.72740887e-02f, 7.24456757e-02f, -8.39669853e-02f, 6.61908835e-02f, -5.32305799e-02f, -6.98436126e-02f, -1.49026886e-02f, -6.51638433e-02f, 2.85954438e-02f, -7.04711229e-02f,
  2.10612211e-02f, -7.68888295e-02f, -6.85257763e-02f, -8.25962890e-03f, -5.00047095e-02f, -1.93645880e-02f, 7.40516707e-02f, -5.34728356e-02f, -5.62677979e-02f, 2.96461023e-02f,
  1.80802066e-02f, -6.84034359e-03f, 4.14806604e-02f, -3.74558265e-03f, -7.27145821e-02f, -9.16634500e-03f, -7.01968223e-02f, -8.85238647e-02f, -5.61436154e-02f, -5.83363253e-05f,
  -6.07741289e-02f, -5.28613513e-04f, 1.26488477e-01f, 9.81205851e-02f, 1.54398428e-02f, -6.60905167e-02f, 8.96161869e-02f, 8.10105503e-02f, 8.85164365e-02f, 2.51339674e-02f,
  9.44534037e-03f, 1.10115036e-01f, -7.78608490e-04f, -7.46776834e-02f, 8.45927373e-02f, -7.00636953e-02f, -6.78057671e-02f, 7.46372864e-02f, 1.17360942e-01f, -2.04699486e-02f,
  5.13999835e-02f, 2.64364369e-02f, 1.39910176e-01f, 1.93020627e-02f, 7.60082826e-02f, 1.85246959e-01f, 1.30682439e-01f, -3.50260921e-02f, 6.72662929e-02f, -3.58639061e-02f,
  3.03079605e-01f, -2.51477081e-02f, -5.30467965e-02f, -1.12003740e-03f, 3.94068025e-02f, -4.45066430e-02f, -2.52194330e-02f, 7.45883584e-02f, 1.40557960e-01f, 6.93449825e-02f,
  1.35571897e-01f, 1.67208031e-01f, 9.41364765e-02f, 1.41572297e-01f, 1.53155953e-01f, -1.84085146e-02f, -1.02340318e-01f, 5.78532591e-02f, 6.27770945e-02f, -9.09906402e-02f,
  -1.36273146e-01f, -8.40375647e-02f, -2.32036486e-02f, 9.42398421e-03f, -1.74170002e-01f, 1.85909234e-02f, -2.05599219e-02f, -8.29984695e-02f, -8.14004168e-02f, -1.09075464e-01f,
  -1.22500457e-01f, 1.25137761e-01f, 8.78861770e-02f, 1.06134430e-01f, 9.58011579e-03f, -7.72578567e-02f, 4.83142063e-02f, -1.39337406e-01f, 6.99056536e-02f, -2.20607016e-02f,
  3.04127461e-03f, 6.69687018e-02f, 8.96642283e-02f, 2.90003326e-02f, -7.96797499e-02f, 4.70189657e-03f, 4.50639334e-03f, -1.94444191e-02f, -7.99180195e-02f, -9.88055095e-02f,
  -4.40096110e-02f, -4.47734706e-02f, 1.95377823e-02f, -6.62271529e-02f, 5.75286783e-02f, 6.54699504e-02f, -3.67435627e-02f, -7.85354152e-02f, 6.60690069e-02f, -5.34202382e-02f,
  -1.83374863e-02f, -9.76273715e-02f, -9.40543264e-02f, 1.07531413e-01f, -4.67079543e-02f, 5.56754284e-02f, 7.76398182e-02f, 1.37907993e-02f, 6.44553825e-02f, -1.16990723e-01f,
  -4.32947464e-02f, 5.09348102e-02f, 4.81807590e-02f, 3.74940261e-02f, -1.04266077e-01f, -3.37092094e-02f, -2.35040821e-02f, -6.08611926e-02f, 5.23031615e-02f, -4.71392879e-03f,
  -1.84233971e-02f, -4.96524721e-02f, 2.91611608e-02f, -5.27937822e-02f, -6.43567741e-02f, 2.89934911e-02f, 3.29857208e-02f, 7.07478970e-02f, 1.78047791e-02f, 3.03176194e-02f,
  2.09030649e-03f, 9.00152847e-02f, 4.62109037e-02f, 7.44603872e-02f, -3.48931807e-03f, 3.15027609e-02f, 1.04973525e-01f, -9.97465476e-03f, -2.20393594e-02f, -8.17082915e-03f,
  5.68220913e-02f, -3.24712209e-02f, -8.51060227e-02f, -1.04807481e-01f, -7.38297626e-02f, 5.38358185e-03f, 3.95688266e-02f, -2.60965968e-03f, 5.76656312e-02f, 3.13623786e-05f,
  -1.51730170e-02f, 7.40287229e-02f, 1.65719762e-01f, 4.85343449e-02f, 2.71256641e-03f, 1.62650555e-01f, -4.55832444e-02f, 4.51151282e-02f, 4.64616492e-02f, 1.36716170e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.00632434e-03f, 1.81161582e-01f, -5.57202548e-02f, 1.05447970e-01f, -1.13461614e-02f, 2.50119977e-02f, -2.05206834e-02f, 1.28689945e-01f, 1.54069826e-01f, 2.04260111e-01f,
  7.22146928e-02f, 9.10597220e-02f, 9.77703035e-02f, -6.60778955e-03f, 1.93812907e-01f, 1.19503252e-01f, 1.29812825e-02f, 8.30627978e-02f, 9.13402289e-02f, 1.02692455e-01f,
  1.37084559e-01f, 6.27028346e-02f, 2.74867862e-01f, 1.20618299e-01f, 1.29052967e-01f, 1.25384629e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  7.17316121e-02f, 2.70550437e-02f, 1.81629032e-01f, 1.90931782e-02f, 1.22480005e-01f, -1.10608272e-01f, -1.48846107e-02f, 1.34738833e-01f, 1.48801148e-01f, -4.36727926e-02f,
  3.17796655e-02f, -1.59093011e-02f, -3.67577225e-02f, 1.92094594e-02f, -7.02148974e-02f, -4.11846340e-02f, -2.74779238e-02f, -1.14685684e-01f, -1.93271175e-01f, 6.63332865e-02f,
  1.16030127e-01f, -1.21283859e-01f, 1.70711398e-01f, 1.64172158e-01f, 1.69177145e-01f, -3.02477092e-01f, -1.31198496e-01f, -2.51352508e-02f, 1.55502185e-01f, 2.12686256e-01f,
  -3.01278949e-01f, -1.44334510e-01f, 3.37078273e-02f, 1.08183473e-01f, -5.32303005e-02f, -1.16671935e-01f, -1.20881319e-01f, 1.98660403e-01f, -6.64417297e-02f, 1.68961316e-01f,
  -1.62962481e-01f, -5.03293127e-02f, -1.28709227e-01f, -2.75450069e-02f, -1.31080121e-01f, -1.85325220e-01f, 1.23413779e-01f, -5.69179505e-02f, -1.61285445e-01f, -1.88749388e-01f,
  -1.66174117e-02f, -8.05115104e-02f, 1.99061185e-01f, -7.46214539e-02f, 2.49330208e-01f, 2.35727504e-02f, -1.98439837e-01f, 8.21129084e-02f, -2.76114438e-02f, 9.28133354e-03f,
  2.70918846e-01f, -1.21071748e-01f, 3.05872768e-01f, 4.53352034e-02f, 5.16322143e-02f, -1.01394420e-02f, 6.59267232e-02f, 2.52592355e-01f, -6.16642600e-03f, 7.75178373e-02f,
  1.87920734e-01f, 6.64929068e-03f, 9.57686603e-02f, 1.12495720e-01f, -6.95111826e-02f, 5.35075255e-02f, 8.73694271e-02f, -9.40482095e-02f, -7.34609962e-02f, 1.21477477e-01f,
  -8.77144560e-03f, -5.32225892e-02f, -5.20209372e-02f, 7.45936334e-02f, 2.36540940e-02f, 4.41027693e-02f, -2.87483364e-01f, 1.30883515e-01f, 2.80068040e-01f, -1.06315330e-01f,
  1.33057609e-01f, -2.38963872e-01f, 3.62900943e-02f, 1.82397291e-01f, 1.20244369e-01f, -1.52036384e-01f, -1.51708364e-01f, 1.17791057e-01f, 1.31814897e-01f, 1.11061983e-01f,
  3.86888981e-01f, 2.78045446e-01f, -9.15219486e-02f, -1.28852800e-01f, -7.45410696e-02f, 2.74437740e-02f, 2.39508916e-02f, 8.77283290e-02f, -1.72703937e-01f, -2.12062761e-01f,
  -8.17493722e-02f, -7.61157498e-02f, 3.39316466e-04f, 3.68246101e-02f, -1.35684341e-01f, 1.46425873e-01f, 5.43573350e-02f, -7.04251900e-02f, -3.40417810e-02f, 1.00731499e-01f,
  2.20408663e-02f, -6.20826557e-02f, 3.52839120e-02f, 1.26921445e-01f, 5.56207672e-02f, -1.97789684e-01f, 1.96202084e-01f, -2.53595356e-02f, 9.15578380e-02f, -2.12087765e-01f,
  2.95506939e-02f, 1.47705108e-01f, 4.78316359e-02f, -1.35176063e-01f, 9.37947780e-02f, 1.16503328e-01f, 3.49698700e-02f, 2.49100160e-02f, 2.50818934e-02f, -2.00763810e-03f,
  -2.68518478e-01f, -1.23341449e-01f, -3.07766516e-02f, 1.41159788e-01f, 2.19788536e-01f, -3.18331793e-02f, -2.48626947e-01f, 1.18397139e-01f, -1.55735433e-01f, 7.31289433e-03f,
  -1.71751186e-01f, 1.43157452e-01f, 2.31956810e-01f, -4.30606306e-02f, 5.30741699e-02f, -1.44513145e-01f, -2.35014439e-01f, 1.26457691e-01f, -5.30277425e-03f, -2.00232379e-02f,
  -6.36304542e-02f, 2.01726273e-01f, 1.20366558e-01f, 5.39228842e-02f, 3.93452257e-01f, -7.57202432e-02f, -1.15427598e-01f, -8.94626155e-02f, 6.13618037e-03f, 3.31529304e-02f,
  -6.01602830e-02f, 2.04999924e-01f, -3.14109921e-02f, -3.22451144e-01f, -9.72053036e-02f, -6.12932295e-02f, -5.01903892e-03f, -6.71783388e-02f, -1.51524190e-02f, -1.23128276e-02f,
  -1.29928425e-01f, 2.90327631e-02f, 8.29180479e-02f, -9.45148095e-02f, -2.20272884e-01f, 1.24478199e-01f, 2.11749505e-02f, -1.07175037e-01f, -1.06535286e-01f, -1.45881116e-01f,
  -4.23711725e-02f, -1.85685068e-01f, -1.14032701e-01f, 3.67918401e-03f, -6.48881197e-02f, 7.45440200e-02f, 4.93063107e-02f, 3.14716175e-02f, -2.73773167e-02f, 1.65044069e-01f,
  7.12850736e-03f, 1.26206189e-01f, -2.82001793e-02f, 1.94807556e-02f, -1.35813486e-02f, -2.28490252e-02f, -1.29044876e-01f, -1.41778551e-02f, 1.28494352e-01f, -1.84013590e-03f,
  1.34245530e-01f, -2.10371152e-01f, 3.96269411e-02f, -4.24274504e-02f, 4.55774218e-02f, -2.21837014e-01f, 1.88872352e-01f, 6.69211373e-02f, -1.25906333e-01f, 2.05479249e-01f,
  -5.50279990e-02f, 6.86495975e-02f, 1.01620331e-01f, -3.36319655e-01f, -9.01518483e-03f, 1.81831583e-01f, 4.19147722e-02f, -8.89529735e-02f, 8.49626064e-02f, -2.19731536e-02f,
  -2.04183161e-01f, -2.11642787e-01f, -9.87694338e-02f, 1.11805014e-01f, -1.72577240e-02f, -4.01563160e-02f, -9.29061770e-02f, -6.07488006e-02f, -4.30111326e-02f, 2.16832027e-01f,
  -8.33094567e-02f, 1.14263026e-02f, 1.57839343e-01f, 5.78908846e-02f, 2.48905141e-02f, -2.03261331e-01f, 2.07174808e-01f, 9.83861461e-02f, -5.86832650e-02f, 3.81025933e-02f,
  -1.98753566e-01f, -1.80060230e-02f, -1.89606473e-01f, -5.51040545e-02f, 4.32972871e-02f, -8.75071883e-02f, 1.26551807e-01f, 2.37531122e-02f, -5.29564209e-02f, -8.26785415e-02f,
  1.84104443e-02f, -1.41665146e-01f, -1.54977553e-02f, -1.53391268e-02f, -2.39553034e-01f, -8.21072832e-02f, -3.01676858e-02f, -2.13005543e-02f, 6.50644600e-02f, -1.55844092e-01f,
  -2.78685968e-02f, -1.21129982e-01f, -2.36826584e-01f, 1.74555019e-01f, -3.18663865e-02f, -1.24922521e-01f, -1.40559658e-01f, -9.71595049e-02f, 2.39980012e-01f, 7.06488788e-02f,
  -1.82198778e-01f, -9.33911800e-02f, -1.17791489e-01f, -3.30855697e-01f, -2.19658807e-01f, -4.25617456e-01f, -1.35329291e-01f, 2.40925938e-01f, -7.11462572e-02f, -9.88629833e-02f,
  -1.98917791e-01f, -3.43199670e-01f, 3.93458940e-02f, 1.13587327e-01f, -5.43966442e-02f, -2.17342246e-02f, -9.41324886e-03f, -2.79065296e-02f, 8.44507813e-02f, -7.26966932e-03f,
  2.00022399e-01f, 1.49978653e-01f, 3.09069902e-02f, -5.48136942e-02f, 8.23009014e-02f, -2.59883124e-02f, 4.20440622e-02f, -1.32132933e-01f, -2.74466038e-01f, -1.75959185e-01f,
  8.28704238e-02f, -1.84991539e-01f, -3.54915224e-02f, -1.00281745e-01f, -1.05888084e-01f, 1.58908207e-03f, 1.92136690e-01f, 3.35812837e-01f, 3.21761854e-02f, 5.06111532e-02f,
  -9.02509168e-02f, 1.62317440e-01f, -1.01199634e-01f, 1.76406857e-02f, 1.07385576e-01f, 1.62465364e-01f, 3.65687311e-02f, -5.50838634e-02f, 1.47858644e-02f, 8.34660381e-02f,
  1.07041247e-01f, -3.88452671e-02f, 1.63346201e-01f, 4.48730029e-02f, 4.92543764e-02f, -4.23347987e-02f, 6.73656687e-02f, 1.01231948e-01f, 3.33753228e-02f, -8.00662041e-02f,
  1.42683834e-01f, -4.00059186e-02f, 1.38756767e-01f, 7.82406330e-03f, -1.09261453e-01f, -2.11406946e-01f, -2.49388471e-01f, 2.29749996e-02f, 1.33249804e-01f, -4.98377420e-02f,
  -2.44064078e-01f, -1.43587012e-02f, -9.67143103e-03f, -2.16634154e-01f, -1.78704143e-01f, -2.94948488e-01f, -3.46988291e-01f, 1.40280379e-02f, 3.39549333e-02f, 5.40613011e-02f,
  -8.84153470e-02f, 6.62991256e-02f, 1.00819327e-01f, -6.12461902e-02f, -5.43472394e-02f, 2.25535810e-01f, 4.90365410e-03f, -8.27993639e-03f, -4.02849652e-02f, 6.92318827e-02f,
  5.39941862e-02f, -3.39727923e-02f, -5.79386670e-03f, -1.63617462e-01f, -1.03913456e-01f, -1.59808472e-01f, 6.67872354e-02f, 9.03379992e-02f, -4.12762687e-02f, -1.17078774e-01f,
  2.39606842e-01f, -1.27277132e-02f, 4.75168638e-02f, 1.44131565e-02f, -9.16592479e-02f, -6.28067926e-02f, 4.51443493e-02f, 1.23515166e-01f, 9.73601267e-02f, 1.71434358e-02f,
  8.53006393e-02f, -1.22267986e-03f, -1.94467138e-02f, -1.04045302e-01f, -4.79574017e-02f, 5.97558022e-02f, -1.06188700e-01f, -3.92207354e-02f, -7.76294619e-02f, 1.64022893e-01f,
  -6.64299726e-02f, -8.43628049e-02f, -1.57840475e-01f, -2.89445240e-02f, -1.77418161e-02f, -2.93029696e-01f, 4.17095013e-02f, -8.12686309e-02f, 1.27961421e-02f, 2.55003482e-01f,
  1.31004140e-01f, -1.52413025e-01f, -2.58563697e-01f, 5.49806990e-02f, 3.11434776e-01f, -3.94490361e-02f, 2.42427588e-01f, 9.59138498e-02f, 1.15214037e-02f, 5.63675836e-02f,
  3.59791160e-01f, -4.69761133e-01f, 1.36028439e-01f, 9.99090746e-02f, -6.07839338e-02f, -1.23838954e-01f, 8.78457054e-02f, -1.15014911e-01f, 7.41888061e-02f, -7.35395476e-02f,
  -1.15241855e-01f, -7.92170018e-02f, 1.44389704e-01f, 1.61415026e-01f, 8.47985148e-02f, 8.84111598e-02f, -6.16776012e-02f, 6.76818416e-02f, 1.58939242e-01f, 2.05811462e-03f,
  -1.45206954e-02f, 1.97518945e-01f, 2.02685952e-01f, -1.70625690e-02f, -2.22219735e-01f, -1.23553969e-01f, 1.10906875e-02f, -7.66178593e-02f, -5.15958481e-02f, 6.13533705e-02f,
  -7.41317123e-02f, -1.17666349e-01f, -5.15092202e-02f, -6.39789030e-02f, 5.56111410e-02f, -1.06571749e-01f, 8.98043066e-02f, -5.90211004e-02f, 6.51432946e-02f, -6.05815575e-02f,
  2.27663919e-01f, -1.25814721e-01f, 1.31652460e-01f, -6.41127154e-02f, 4.93425913e-02f, 5.70302736e-03f, 1.55299708e-01f, -8.91335532e-02f, 1.89932764e-01f, 3.06826949e-01f,
  -7.92196319e-02f, -2.31931537e-01f, -2.56927818e-01f, 2.23695576e-01f, 1.34492874e-01f, 2.78138686e-02f, 2.57458631e-02f, -3.56639400e-02f, -1.09027289e-02f, -6.47682101e-02f,
  7.62129128e-02f, -2.25713104e-01f, -5.96344545e-02f, 1.27449691e-01f, -3.47516686e-01f, -9.04489458e-02f, 7.44595891e-03f, -6.09055022e-03f, -8.08714777e-02f, 2.03917444e-01f,
  1.27397284e-01f, -1.89544842e-01f, -6.24035187e-02f, 2.39228055e-01f, -4.92859297e-02f, -6.46086857e-02f, 6.07979298e-02f, -6.15674770e-03f, 1.34031653e-01f, 8.73768330e-02f,
  1.92562747e-03f, 9.16333050e-02f, -1.10020369e-01f, -6.12661950e-02f, 1.17392749e-01f, 1.52467471e-02f, -2.56749354e-02f, 6.51863366e-02f, -1.27435967e-01f, -5.99969141e-02f,
  -2.34784290e-01f, -1.00418590e-01f, -8.87524560e-02f, -2.78176572e-02f, -1.39719561e-01f, 5.23890518e-02f, -1.25315964e-01f, 6.32604992e-04f, 9.01829675e-02f, -5.87650314e-02f,
  9.90576074e-02f, 2.27688299e-03f, -8.35615173e-02f, -5.13429642e-02f, -9.45521891e-02f, -3.65939476e-02f, -1.35232480e-02f, 1.80423290e-01f, -7.96567202e-02f, 1.43177673e-01f,
  1.46114469e-01f, -2.19061390e-01f, -1.37662426e-01f, -3.07249604e-04f, -8.64115655e-02f, -4.46448065e-02f, 1.02054089e-01f, 2.12386429e-01f, 7.92290792e-02f, 1.64515615e-01f,
  -3.25428784e-01f, 6.05806671e-02f, 3.38672489e-01f, -2.32062101e-01f, 6.25553504e-02f, 2.28862926e-01f, 8.88602063e-02f, 3.83802019e-02f, 2.16745242e-01f, -1.79140553e-01f,
  1.20311759e-01f, -1.10589512e-01f, -7.39006251e-02f, 1.21677935e-01f, 1.02150328e-01f, -3.93374786e-02f, 4.03667614e-02f, 2.02862516e-01f, -2.74588969e-02f, 3.81449461e-02f,
  -5.21216318e-02f, -2.37858780e-02f, 8.24598670e-02f, -8.87696519e-02f, -2.13492870e-01f, 2.45481706e-03f, 1.36423320e-01f, 1.99766308e-02f, 1.84702620e-01f, -9.33064520e-02f,
  -1.81335118e-02f, -8.37932453e-02f, -8.07757452e-02f, -1.01152584e-02f, -1.13238223e-01f, -1.93397954e-01f, 9.31280330e-02f, -6.38084486e-02f, 2.48176288e-02f, 1.50607020e-01f,
  8.60442370e-02f, 5.74058443e-02f, -5.99716716e-02f, -5.68223894e-02f, 2.00377554e-01f, -9.51467641e-03f, 1.72685713e-01f, 1.10310093e-01f, -8.80124345e-02f, -3.98287289e-02f,
  1.16315469e-01f, 3.05340979e-02f, 2.82017827e-01f, -4.63556200e-02f, 1.19879872e-01f, 1.79327294e-01f, 1.25625115e-02f, 3.08250040e-01f, -3.52691174e-01f, 6.85671791e-02f,
  1.50121897e-01f, 1.39862597e-01f, 9.73537788e-02f, 7.22180158e-02f, -1.10559650e-02f, 1.91524416e-01f, 2.04284154e-02f, -6.75026402e-02f, -2.70574212e-01f, 6.70534149e-02f,
  1.97333097e-01f, 2.98245430e-01f, 4.36877795e-02f, 4.37753834e-02f, 2.28103995e-02f, 1.60203222e-03f, 7.61826187e-02f, 2.38677680e-01f, 7.35713616e-02f, -8.07165727e-02f,
  -1.73357621e-01f, -2.50459760e-01f, -9.73865762e-02f, 1.63642615e-01f, -2.61750463e-02f, 8.72353911e-02f, -4.07215804e-02f, -6.06818572e-02f, 7.75723485e-03f, 1.93454158e-02f,
  -1.22764327e-01f, -1.64918393e-01f, -9.63707864e-02f, -1.06332310e-01f, 6.58570081e-02f, 1.65014103e-01f, -1.51792288e-01f, -5.84007762e-02f, 6.69663325e-02f, -1.99360251e-01f,
  2.29867138e-02f, -4.78045410e-03f, 2.84982435e-02f, 1.17324656e-02f, 1.25559613e-01f, 1.23372167e-01f, 2.91909333e-02f, 1.57666188e-02f, 1.01648420e-01f, 1.02380417e-01f,
  4.59701158e-02f, -5.39103076e-02f, 2.39401251e-01f, -1.31578017e-02f, 9.09847543e-02f, 5.98208159e-02f, -1.12859458e-01f, 1.32029623e-01f, 2.44277045e-01f, -6.28626570e-02f,
  5.77238798e-02f, -1.36966884e-01f, 2.51188904e-01f, -1.66537330e-01f, -1.40403643e-01f, -3.77369449e-02f, 2.24241931e-02f, 5.96529245e-02f, -1.33988708e-01f, -3.57357651e-01f,
  3.96936433e-03f, 1.58772409e-01f, 2.16308132e-01f, -2.36143738e-01f, -1.28213480e-01f, -8.22405219e-02f, -1.05194703e-01f, -3.37431580e-01f, 7.29350299e-02f, 2.71947514e-02f,
  8.16456601e-02f, 8.75350013e-02f, -1.22038715e-01f, -1.39008656e-01f, 7.43733943e-02f, 3.01861286e-01f, 5.16636111e-02f, -1.88925937e-01f, 1.53228089e-01f, -6.08981401e-02f,
  -2.35982779e-02f, -2.87594553e-02f, 1.10339768e-01f, 1.05718233e-01f, -1.65515095e-01f, -2.56817956e-02f, 2.11031005e-01f, 3.26145515e-02f, 1.08697325e-01f, -1.33963212e-01f,
  1.94896255e-02f, 1.87367767e-01f, -2.39539631e-02f, 1.04226485e-01f, -1.38860017e-01f, -5.40748686e-02f, -1.22960798e-01f, -1.75736025e-02f, 1.36982454e-02f, 1.16400616e-02f,
  1.13214836e-01f, 1.46038666e-01f, 1.74687818e-01f, 9.74027673e-04f, -1.43560946e-01f, 2.35031061e-02f, -7.42415339e-02f, 4.34498303e-02f, -1.25542894e-01f, -1.39783680e-01f,
  1.03740945e-01f, -6.52394220e-02f, 8.93488005e-02f, 1.49399146e-01f, -3.68394442e-02f, 2.59182721e-01f, -2.80130142e-03f, -1.60126299e-01f, 7.51911178e-02f, 1.61958754e-01f,
  1.96821913e-01f, 2.01232761e-01f, 2.30940551e-01f, 1.49152607e-01f, 5.81739433e-02f, -1.13299444e-01f, -6.25755042e-02f, -1.08392492e-01f, 1.32726863e-01f, 1.26670614e-01f,
  -1.75890684e-01f, -3.65819782e-03f, -3.77164930e-02f, -1.03388257e-01f, -1.06092796e-01f, 1.71006739e-01f, 1.21942014e-01f, -9.82147008e-02f, -2.62794998e-02f, 9.90025848e-02f,
  1.28746361e-01f, 1.95069671e-01f, 6.19062632e-02f, 1.89433172e-02f, 7.42529407e-02f, -7.21934140e-02f, 2.52167764e-03f, -8.56402516e-02f, 1.93972532e-02f, 6.75049648e-02f,
  -5.01706079e-02f, 7.13365749e-02f, -2.17702445e-02f, 9.05742049e-02f, -1.49839699e-01f, -1.34636432e-01f, -7.11411387e-02f, 2.99414434e-02f, -1.25259981e-01f, -1.33860009e-02f,
  -3.29313539e-02f, -1.81272611e-01f, -5.27043045e-02f, 4.11652327e-02f, 2.12103240e-02f, -1.94289923e-01f, 1.98217124e-01f, -3.10236067e-02f, 2.32527647e-02f, -1.05468377e-01f,
  3.43015976e-02f, 1.06027029e-01f, -1.99788192e-04f, -1.42004535e-01f, -2.91040540e-02f, 1.56253502e-01f, 2.47518286e-01f, -3.20411511e-02f, 1.24040805e-01f, 2.64909267e-01f,
  2.76666544e-02f, 4.87079136e-02f, -1.56261533e-01f, 2.51990080e-01f, 2.71622669e-02f, 1.21256657e-01f, 1.31903291e-01f, 9.54210162e-02f, 5.64208180e-02f, -1.20884128e-01f,
  -2.86404580e-01f, -1.35713732e-02f, 8.75862539e-02f, 7.40021542e-02f, -2.70747513e-01f, 2.97843695e-01f, -7.37335905e-03f, -1.09049290e-01f, 4.37266789e-02f, -1.34491771e-02f,
  1.60092816e-01f, -4.17588167e-02f, 6.12543263e-02f, 2.16108963e-01f, 1.15352362e-01f, 8.88744518e-02f, -4.91201319e-02f, -1.10902106e-02f, -5.37868449e-03f, -4.92922217e-02f,
  -5.80336414e-02f, 1.01191357e-01f, -2.63927341e-01f, 2.36891493e-01f, 1.85603544e-01f, -1.35523140e-01f, 1.57915473e-01f, 9.01701450e-02f, 1.53139308e-01f, 1.04745209e-01f,
  7.57354836e-04f, 6.13035075e-03f, -2.98431478e-02f, -9.56738070e-02f, -1.54726237e-01f, -5.36083989e-02f, -9.54525545e-03f, 8.08044821e-02f, 2.40013432e-02f, 6.38602003e-02f,
  -1.41544417e-01f, -8.34944844e-02f, -6.15379252e-02f, -7.15881661e-02f, -1.04645118e-01f, -1.74378008e-01f, 5.55426143e-02f, -1.79974034e-01f, -8.57299268e-02f, -5.50827309e-02f,
  4.29983549e-02f, 2.58485138e-01f, 4.43472117e-02f, 9.47773010e-02f, 1.17781572e-01f, 1.59969162e-02f, -7.35119507e-02f, -1.01267733e-01f, -5.92239052e-02f, -7.11110607e-02f,
  1.16637036e-01f, -2.38360390e-02f, -3.55861336e-01f, 1.93705529e-01f, 1.71548992e-01f, -7.90761188e-02f, -1.69783548e-01f, -1.07872620e-01f, -2.99528271e-01f, -3.17793489e-01f,
  -1.25278950e-01f, 2.12014511e-01f, -2.64659282e-02f, 1.58069238e-01f, -1.38298601e-01f, 3.73639092e-02f, 1.31117120e-01f, 7.75789991e-02f, -1.27346069e-01f, -2.27031752e-01f,
  7.51961097e-02f, 1.54604480e-01f, -5.39502464e-02f, 8.76768529e-02f, 1.86195508e-01f, -1.61505818e-01f, 1.36063516e-01f, -1.68186814e-01f, -8.54285285e-02f, 1.59555122e-01f,
  1.13674633e-01f, -1.62861999e-02f, -1.27818193e-02f, 1.65700719e-01f, -6.55273274e-02f, 2.46120263e-02f, -1.63797125e-01f, 9.32215303e-02f, -1.11806445e-01f, 7.56711215e-02f,
  -5.82477711e-02f, -1.15293168e-01f, -1.32004976e-01f, -1.36571720e-01f, 1.73884526e-01f, 1.21582098e-01f, -2.13607810e-02f, -9.38678384e-02f, 1.21991627e-01f, -2.99099647e-02f,
  -1.51718587e-01f, 5.14799170e-02f, 9.31501314e-02f, 1.08656541e-01f, 2.43868921e-02f, -1.48985283e-02f, 1.73057139e-01f, 3.54660153e-01f, -3.16713929e-01f, -1.48560554e-01f,
  2.48089600e-02f, 2.44235635e-01f, 1.92283526e-01f, 4.71508540e-02f, 1.29577979e-01f, 1.85188025e-01f, 7.57327154e-02f, -1.33659810e-01f, -4.09571141e-01f, -1.03307612e-01f,
  8.52250606e-02f, 2.00564548e-01f, -1.08585306e-01f, 3.75199109e-01f, 5.15209436e-02f, -1.10528588e-01f, 1.48791417e-01f, 1.61409542e-01f, 1.46596774e-01f, 1.09784737e-01f,
  -1.47247240e-01f, 1.18874125e-01f, 8.57159197e-02f, 6.17771670e-02f, -1.64062351e-01f, -1.03694141e-01f, 2.52770744e-02f, -1.09189346e-01f, 7.53120780e-02f, 1.72336563e-01f,
  -2.35128850e-01f, 1.26228347e-01f, 8.36739391e-02f, -7.86997825e-02f, 7.35519975e-02f, 1.83493078e-01f, -1.03321865e-01f, 4.52953167e-02f, 1.18198238e-01f, 6.78141639e-02f,
  -4.04068492e-02f, -8.30961391e-02f, 5.16848341e-02f, 1.22934962e-02f, -1.58079043e-02f, -6.51635379e-02f, -1.30134240e-01f, 2.07285006e-02f, 1.67066783e-01f, -6.96301684e-02f,
  2.13163450e-01f, -2.08841506e-02f, 1.07429154e-01f, 9.95181948e-02f, 7.31855929e-02f, 1.06679294e-02f, 1.20287009e-01f, -4.14017364e-02f, -8.46428722e-02f, 9.04592276e-02f,
  1.12200536e-01f, 1.39027685e-01f, -4.56993915e-02f, -1.35787472e-01f, 4.30961140e-02f, -5.17557971e-02f, 1.35220087e-03f, 8.85808095e-02f, 2.29729459e-01f, 6.20688386e-02f,
  -1.59999043e-01f, 1.04986846e-01f, 4.81590815e-02f, 9.87204686e-02f, -8.35422724e-02f, -1.10308968e-01f, -1.63279355e-01f, -5.48148155e-02f, -1.16766825e-01f, 7.34927952e-02f,
  -1.13038749e-01f, 1.06156208e-01f, 7.92599693e-02f, 1.39477879e-01f, 1.07656531e-02f, -2.49830678e-01f, 3.74548249e-02f, 8.31485838e-02f, -9.53686684e-02f, 8.66815597e-02f,
  -1.14498854e-01f, 7.24792480e-03f, 8.65479559e-02f, -7.53295841e-03f, -4.48186919e-02f, -1.98258564e-01f, -3.68698165e-02f, 1.89906061e-02f, -1.81038141e-01f, -6.55270368e-02f,
  2.41262652e-02f, 2.16071736e-02f, 1.09104671e-01f, -1.58824682e-01f, -1.31465131e-02f, 7.04893991e-02f, -4.21952968e-03f, 6.76012337e-02f, 8.15725997e-02f, 1.14288948e-01f,
  1.45348787e-01f, -8.12355652e-02f, -3.42638977e-02f, 1.08519673e-01f, 1.17723219e-01f, 5.26993424e-02f, 9.03751925e-02f, 1.13023579e-01f, 9.50922742e-02f, -1.20910415e-02f,
  -8.49800035e-02f, 1.71535127e-02f, 4.62070806e-03f, -2.22076420e-02f, 1.22678690e-01f, 4.84406874e-02f, 2.81784743e-01f, 1.25881098e-02f, -3.16014826e-01f, 1.44237429e-01f,
  -1.32319659e-01f, -1.61471859e-01f, -1.38229588e-02f, -3.52887779e-01f, -7.55800605e-02f, 1.67443588e-01f, 1.45505760e-02f, -3.11831295e-01f, -9.11664441e-02f, -2.30784282e-01f,
  -3.49878907e-01f, 2.67120842e-02f, -2.99764238e-02f, 1.02904707e-01f, 9.40434914e-03f, -7.63137564e-02f, 5.45152202e-02f, 7.32598454e-02f, 1.09923199e-01f, 2.95323759e-01f,
  4.21913452e-02f, -1.30472723e-02f, 1.28517091e-01f, 6.56682104e-02f, 1.35688961e-01f, -4.48145829e-02f, -1.52239092e-02f, -6.65884167e-02f, -9.32492018e-02f, -3.61489691e-02f,
  1.82025701e-01f, -1.23769745e-01f, -6.51899129e-02f, -1.27674967e-01f, -7.42550427e-03f, 8.20218697e-02f, -6.68107644e-02f, 2.11914331e-01f, -2.03102473e-02f, -5.46867363e-02f,
  2.28220429e-02f, 1.24639548e-01f, 1.90380719e-02f, -3.99980098e-02f, 3.49565074e-02f, 1.05808966e-01f, 4.71628569e-02f, -2.03953147e-01f, -2.90165581e-02f, 1.80861056e-02f,
  -1.49887726e-01f, 3.04490682e-02f, -5.27083091e-02f, 7.79813454e-02f, 9.89109948e-02f, 4.28965650e-02f, -1.06521370e-02f, 7.58442329e-04f, 7.28096589e-02f, -1.84370488e-01f,
  1.54705986e-01f, -8.15902650e-02f, 8.09148028e-02f, -2.47693911e-01f, -3.41233820e-01f, -1.77134171e-01f, -1.51306227e-01f, -8.43135640e-02f, -2.06719160e-01f, 1.02892205e-01f,
  2.08233222e-01f, 1.55540183e-01f, -7.15927593e-03f, -2.89026886e-01f, -2.19767503e-02f, -7.46461749e-02f, -3.81171256e-02f, 1.79443896e-01f, 6.06056154e-02f, -1.25099465e-01f,
  -1.08744547e-01f, 1.22633345e-01f, 1.29134670e-01f, -8.91946852e-02f, 3.36367078e-02f, 1.65546626e-01f, 1.04516402e-01f, -1.38994470e-01f, 7.54055604e-02f, 2.98643508e-03f,
  -1.90111753e-02f, -9.46069881e-02f, -8.62896442e-02f, 5.01900204e-02f, 3.95537680e-03f, 1.84098572e-01f, -1.62194036e-02f, -1.37270272e-01f, -1.39759323e-02f, -1.20669201e-01f,
  1.62744567e-01f, -7.36526772e-02f, -6.93098977e-02f, -1.03701554e-01f, 3.61248702e-02f, 4.63342629e-02f, -2.84802094e-02f, -6.73187897e-02f, -9.86934230e-02f, -8.87742415e-02f,
  1.04439189e-03f, -2.27396920e-01f, -1.42803609e-01f, -8.20224509e-02f, -7.55843371e-02f, -5.35182580e-02f, -8.10556412e-02f, -2.58049928e-02f, -1.24875635e-01f, 6.14583232e-02f,
  -3.88572700e-02f, -5.24708554e-02f, 2.17099264e-02f, -2.97241867e-01f, 8.08165595e-02f, -1.41627073e-01f, 9.36639160e-02f, -7.88380206e-02f, -4.14023213e-02f, 1.27194449e-01f,
  -2.31304523e-02f, 2.40254283e-01f, -7.06917122e-02f, -4.92958166e-02f, 2.73282915e-01f, 1.75683558e-01f, 1.33575380e-01f, 1.13642849e-01f, 2.28364825e-01f, -1.97315410e-01f,
  1.04919098e-01f, -8.26451406e-02f, -9.80909616e-02f, -3.01584066e-03f, -1.28898434e-02f, -1.60186693e-01f, 9.39571783e-02f, 9.73375328e-03f, -1.10238502e-02f, 7.68835917e-02f,
  -4.76060286e-02f, 9.99317914e-02f, -8.16579536e-02f, 1.03666052e-01f, 4.07807417e-02f, 1.21497624e-01f, 1.89452827e-01f, 5.67910727e-03f, 1.01718687e-01f, -2.08452251e-02f,
  1.23398997e-01f, -6.63378313e-02f, -2.25604430e-01f, -2.59315223e-02f, -3.33180279e-02f, 3.05992290e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.97346860e-01f, 9.48408395e-02f, 1.96998090e-01f, 1.15445212e-01f, 2.02871397e-01f, 2.18779892e-01f, 2.02303931e-01f, 3.47828120e-02f, -1.91022664e-01f, -2.61427294e-02f,
  5.18663563e-02f, 2.05032051e-01f, 1.11754294e-02f, -2.89827734e-02f, 1.56068131e-01f, 2.11600438e-01f, 1.34120792e-01f, 1.57349050e-01f, -1.27342060e-01f, -5.40496111e-02f,
  -1.27989158e-01f, -5.97184477e-03f, 7.28456490e-03f, 2.27630287e-01f, -1.02116734e-01f, -3.36984023e-02f, 6.92606643e-02f, -5.02148032e-01f, -2.60812551e-01f, -2.46992931e-01f,
  8.97252839e-03f, 3.93412113e-01f, -6.19455911e-02f, -7.78934956e-02f, -1.58157617e-01f, -2.23211840e-01f, 1.17035195e-01f, 2.15179890e-01f, 1.17960135e-02f, 2.64937639e-01f,
  1.09113835e-01f, -1.73917592e-01f, -8.01881924e-02f, -9.35563166e-03f, 6.10534586e-02f, -1.83700994e-01f, 5.80253452e-02f, -1.01018317e-01f, 6.97338805e-02f, -1.15622364e-01f,
  -1.38676181e-01f, -6.63734153e-02f, -1.65443003e-01f, 1.64169557e-02f, 2.93827616e-02f, 1.38532519e-01f, -9.57217291e-02f, -1.08177319e-01f, -1.44484937e-01f, 2.21451838e-02f,
  3.01899403e-01f, 2.05751613e-01f, 9.17057842e-02f, 5.17077148e-02f, 1.31129986e-02f, 1.36791080e-01f, -3.91286537e-02f, 1.72306836e-01f, 1.38504386e-01f, 1.17342845e-02f,
  -1.19568463e-02f, 1.54615864e-01f, -5.70804300e-03f, -5.95858693e-02f, -7.66090453e-02f, 9.30557102e-02f, 7.30461581e-03f, -3.87622081e-02f, 1.43503934e-01f, 1.39273614e-01f,
  -2.98000220e-02f, 8.74321908e-02f, 7.08531076e-03f, -8.64410475e-02f, 3.40314284e-02f, -1.49245381e-01f, -1.53431460e-01f, -1.71374425e-01f, 2.11909041e-01f, 1.26209715e-02f,
  6.51021153e-02f, -7.85486996e-02f, -1.69884861e-02f, 9.03847963e-02f, 1.95690140e-01f, -5.19627053e-03f, -6.26240000e-02f, 6.78464323e-02f, 5.63441776e-02f, -1.05575016e-02f,
  7.61284605e-02f, 5.46895266e-02f, 8.79442394e-02f, 6.13661483e-03f, 7.10450113e-02f, -9.52037722e-02f, -2.29923967e-02f, -2.81533953e-02f, 2.07879823e-02f, 5.82049824e-02f,
  3.52321528e-02f, 3.40814181e-02f, 3.27012911e-02f, -1.64657831e-02f, -1.10174462e-01f, -1.16670214e-01f, -4.36727963e-02f, -5.00894710e-02f, 1.43685549e-01f, -9.63483676e-02f,
  1.27666295e-01f, 2.98038311e-02f, -4.76392284e-02f, 1.42265810e-02f, -1.44618884e-01f, 7.34392032e-02f, 2.21954621e-02f, 8.83718207e-02f, 5.32680340e-02f, -6.57451302e-02f,
  -8.42754543e-02f, 4.28043008e-02f, 6.97411746e-02f, 1.28728449e-01f, 5.78252226e-02f, 7.55181387e-02f, 2.09128261e-01f, -9.02182758e-02f, -9.46526788e-03f, -1.11035807e-02f,
  1.23982146e-01f, 1.63657114e-01f, 1.64362922e-01f, 2.01689810e-01f, -5.96227571e-02f, -1.17204681e-01f, -3.59566137e-02f, -2.24452373e-02f, 6.40549064e-02f, -7.50430375e-02f,
  -9.45375562e-02f, -1.76103696e-01f, 9.84947830e-02f, -1.39156953e-01f, -2.97708008e-02f, 1.81906804e-01f, 1.00871339e-01f, -2.01216251e-01f, 1.79858536e-01f, -1.94245158e-03f,
  1.21861279e-01f, -2.96013784e-02f, -1.47971854e-01f, -1.58328816e-01f, 1.81487545e-01f, -2.25179374e-01f, 8.73055756e-02f, 1.43544227e-01f, 8.41969997e-02f, 3.96892056e-02f,
  -8.47007148e-03f, -7.87394568e-02f, -1.07731238e-01f, 5.26259057e-02f, 3.15127596e-02f, 7.78781250e-02f, 1.48545392e-02f, -3.28048989e-02f, 4.51513529e-02f, -1.04383394e-01f,
  7.31245577e-02f, 2.76010819e-02f, -9.91652347e-03f, 7.62612224e-02f, 1.39456674e-01f, 1.32036731e-01f, -3.30403037e-02f, 3.79295163e-02f, 3.88629697e-02f, 1.71583295e-02f,
  -6.82378858e-02f, -4.41344529e-02f, 1.10846192e-01f, -6.53204843e-02f, 1.28422931e-01f, 1.01610184e-01f, 3.24252173e-02f, -1.29430890e-01f, 1.54968217e-01f, 1.56291008e-01f,
  8.51626620e-02f, 1.29237518e-01f, -1.25129744e-01f, 9.02161300e-02f, -5.33045083e-02f, -9.45394337e-02f, 4.51077195e-03f, 2.09173821e-02f, -1.07798107e-01f, 3.69714573e-02f,
  1.42955026e-02f, 8.04644376e-02f, -9.59839895e-02f, 7.11150244e-02f, 9.06243920e-02f, 1.13830380e-01f, 2.26535246e-01f, 8.34705159e-02f, -2.00666133e-02f, 1.40598178e-01f,
  1.41060531e-01f, 1.71559170e-01f, -5.61614372e-02f, -1.46660462e-01f, -9.22591090e-02f, 1.14999406e-01f, 4.51809680e-03f, 1.23155396e-02f, 2.55657639e-02f, 6.39003217e-02f,
  -9.02002398e-03f, -1.16270952e-01f, -5.08057065e-02f, -4.03360638e-04f, 4.79052141e-02f, 1.19372115e-01f, -1.35384291e-01f, 5.05053699e-02f, -3.93193588e-02f, -1.04860375e-02f,
  -6.22310676e-02f, -3.37074837e-03f, 1.03281677e-01f, 1.39705241e-01f, 1.10240569e-02f, 1.10752106e-01f, 1.74190938e-01f, -3.97818945e-02f, 3.59597914e-02f, 1.34914830e-01f,
  1.49907693e-01f, -2.43020169e-02f, -7.07778931e-02f, 4.34365235e-02f, 8.86628777e-02f, 3.91850993e-02f, 8.09536576e-02f, 1.50420576e-01f, -3.28776203e-02f, -6.22362718e-02f,
  -7.36718476e-02f, -7.38764703e-02f, -2.21746378e-02f, 1.12074122e-01f, 1.78949177e-01f, 5.66548668e-02f, 8.23024809e-02f, 3.51142883e-02f, -2.13047862e-02f, 2.18046740e-01f,
  1.75751925e-01f, -3.52935381e-02f, 9.82273370e-02f, -5.63187934e-02f, 1.67994365e-01f, 1.02923997e-01f, 1.20084107e-01f, -1.29104093e-01f, 4.14376818e-02f, -8.79888833e-02f,
  -5.01905121e-02f, -1.21670984e-01f, -1.41522422e-01f, 1.08895034e-01f, 4.09435444e-02f, -1.54963061e-01f, -1.58405960e-01f, 5.31014800e-02f, 5.78546803e-03f, 9.35500413e-02f,
  -1.26371026e-01f, -9.89162549e-02f, -1.78124234e-01f, 3.87317017e-02f, 6.66823760e-02f, 8.23302045e-02f, -1.17543958e-01f, -4.00667489e-02f, -1.05591714e-01f, 2.76451409e-02f,
  -6.81571439e-02f, 1.11674406e-02f, -1.24435620e-02f, 1.03658125e-01f, 2.91537717e-02f, -1.17538624e-01f, -1.00950897e-01f, 3.81868370e-02f, 1.90208659e-01f, 7.58842602e-02f,
  -1.57030746e-01f, 6.19352683e-02f, 1.56304181e-01f, -6.09317096e-03f, 1.17364842e-02f, -1.34357333e-01f, 1.70590982e-01f, -1.10402726e-01f, -1.68314483e-02f, -1.00472070e-01f,
  1.72715083e-01f, 4.93878089e-02f, 1.89582780e-01f, -9.35044065e-02f, -3.27647515e-02f, 9.91375148e-02f, 2.61204928e-01f, 1.37172848e-01f, -1.75170079e-01f, 9.37663987e-02f,
  -1.68714553e-01f, 2.03498676e-01f, -8.84181540e-03f, 3.61814052e-02f, 8.84141549e-02f, -2.99737379e-02f, 1.62900090e-01f, 1.42074719e-01f, -4.56324667e-02f, 1.13248557e-01f,
  -2.19778195e-02f, 2.59655297e-01f, 1.76151916e-01f, 2.13146552e-01f, -2.24759147e-01f, 6.93631172e-02f, 1.58610567e-02f, -4.27191406e-02f, 1.16880648e-02f, -5.40286526e-02f,
  -1.55187562e-01f, 1.61867201e-01f, -4.73681930e-03f, -2.99539387e-01f, -1.34372115e-01f, 8.83754045e-02f, -2.20950842e-01f, 3.36172163e-01f, -7.96884969e-02f, 1.57234609e-01f,
  -2.78095994e-02f, -3.16153802e-02f, -8.10979977e-02f, -7.54616633e-02f, 7.53220245e-02f, 7.57364109e-02f, 2.24622220e-01f, -5.91073893e-02f, 9.48931873e-02f, 9.01566222e-02f,
  1.27643317e-01f, 7.34658614e-02f, -9.91355255e-02f, 1.35285314e-02f, 1.16825782e-01f, 1.36301070e-01f, -2.89999545e-02f, -2.52286434e-01f, 2.63293199e-02f, -1.09664397e-02f,
  1.74458370e-01f, 1.86544523e-01f, 1.39324844e-01f, 2.51840711e-01f, -6.57828897e-02f, -4.25135419e-02f, 8.95140786e-03f, -2.74526272e-02f, 8.67761150e-02f, -4.12659682e-02f,
  -3.74709629e-02f, 7.51309022e-02f, -8.44892021e-03f, 9.62996483e-02f, -2.43010055e-02f, -1.20161638e-01f, 3.33990641e-02f, 1.94624404e-03f, 1.57554716e-01f, -8.78898129e-02f,
  -1.36468783e-01f, 1.50594816e-01f, 5.33185340e-02f, -4.80437502e-02f, 3.20784040e-02f, 6.02569878e-02f, -7.41053969e-02f, -8.29165503e-02f, -7.08300695e-02f, 1.11009032e-01f,
  -4.68547232e-02f, 2.69491207e-02f, -1.12840749e-01f, -1.21716499e-01f, 1.47714585e-01f, 7.73946568e-02f, 1.40064023e-02f, -4.21727709e-02f, -3.43061164e-02f, -4.34518233e-02f,
  3.74657824e-03f, -3.68090346e-02f, -5.69008142e-02f, 6.54970249e-03f, 1.35758802e-01f, 1.18189037e-01f, 6.21481054e-02f, 2.94421874e-02f, 1.30733892e-01f, 1.27221659e-01f,
  4.48127985e-02f, 1.70032342e-03f, 1.30603954e-01f, 5.08645587e-02f, 1.07606821e-01f, -8.78578331e-03f, -4.93640378e-02f, 1.24913685e-01f, 2.76221074e-02f, 1.06414080e-01f,
  1.01769269e-01f, 8.28822479e-02f, 1.34488449e-01f, -7.56090879e-02f, -7.69156888e-02f, 1.25653028e-01f, -1.28906935e-01f, 2.29220726e-02f, -8.44953060e-02f, -6.95176646e-02f,
  -6.04539141e-02f, 3.22527066e-03f, -4.98627573e-02f, 4.08429317e-02f, 5.73505461e-02f, -4.46363864e-03f, 1.04921162e-01f, 9.02704298e-02f, -3.96814495e-02f, -4.61866967e-02f,
  -1.10577747e-01f, 7.78135210e-02f, 3.32649015e-02f, 6.62857220e-02f, 7.44214654e-03f, -8.81588757e-02f, 8.39799270e-02f, -1.57826960e-01f, 3.19634825e-02f, 4.69793268e-02f,
  1.37830451e-01f, -1.11616053e-01f, -1.19568951e-01f, -1.16515812e-02f, -5.23181036e-02f, 1.09464586e-01f, 3.37448269e-02f, 1.25263080e-01f, -2.74723805e-02f, 1.68279354e-02f,
  1.02470711e-01f, 6.43692464e-02f, 5.37961684e-02f, 1.71498228e-02f, 5.20681671e-04f, -1.99665576e-02f, 7.19027082e-03f, -1.31686598e-01f, -1.13836460e-01f, 8.62284973e-02f,
  -3.61959040e-02f, 7.53260106e-02f, 1.10088393e-01f, 1.33287832e-01f, 9.00331587e-02f, -5.59438728e-02f, -9.50825959e-02f, -4.37357426e-02f, 5.77991456e-02f, -1.14220195e-01f,
  1.02841288e-01f, 8.90617371e-02f, -8.64814669e-02f, 1.72682151e-01f, 1.56776402e-02f, -1.23940848e-01f, 1.75670296e-01f, -4.22923788e-02f, -5.29209822e-02f, -3.08351293e-02f,
  -1.11461177e-01f, 4.43036966e-02f, 1.77306205e-01f, 4.96657714e-02f, 3.66539769e-02f, -1.45855965e-02f, 1.04286298e-01f, 2.07432926e-01f, 1.88360468e-01f, 9.52614397e-02f,
  2.63597131e-01f, 5.46784289e-02f, -3.42536457e-02f, 1.17147990e-01f, 2.74744093e-01f, 6.34000544e-03f, 1.81739926e-01f, 9.11838487e-02f, -1.55901983e-01f, -2.92618889e-02f,
  -1.09439373e-01f, 6.70086741e-02f, 1.67151421e-01f, 2.50075161e-01f, -1.99198574e-01f, 2.89088547e-01f, -2.18671814e-01f, 1.42965510e-01f, 1.04931310e-01f, -1.97538972e-01f,
  7.78673142e-02f, 1.80445328e-01f, 5.52479029e-02f, 1.61025256e-01f, -1.31169215e-01f, -8.63899440e-02f, 2.26105511e-01f, 1.70959041e-01f, 1.05460569e-01f, 2.56611586e-01f,
  6.74547032e-02f, -2.59718299e-02f, -1.52319195e-02f, -1.73099995e-01f, 3.00028529e-02f, 9.75110009e-02f, -5.92026226e-02f, 2.95965113e-02f, 1.60654590e-01f, -2.23545611e-01f,
  -6.66044280e-02f, 1.90680981e-01f, 3.01287286e-02f, 1.18552253e-01f, 7.22087026e-02f, 9.15277079e-02f, 1.29050106e-01f, 1.62442416e-01f, 3.25936563e-02f, -1.32143021e-01f,
  3.37405622e-01f, 2.21143663e-01f, 1.60267696e-01f, -6.81401864e-02f, -6.82710409e-02f, 2.37889931e-01f, -6.66432455e-02f, 1.44309759e-01f, 8.70687608e-03f, 1.26580909e-01f,
  1.35073498e-01f, 1.12638324e-01f, 1.09562956e-01f, 2.26770222e-01f, 2.67710760e-02f, 1.14298426e-01f, 1.46297410e-01f, 1.40779674e-01f, -1.36722580e-01f, 2.28931874e-01f,
  -4.90705594e-02f, 1.95939183e-01f, 2.57987261e-01f, 1.98202003e-02f, 2.08833590e-01f, -2.64636159e-01f, -9.35719088e-02f, -1.43451527e-01f, -1.28624082e-01f, -1.57549486e-01f,
  4.40182760e-02f, 1.63637817e-01f, -1.37630060e-01f, 1.52060851e-01f, -8.01100731e-02f, 1.08935095e-01f, 1.44429043e-01f, -2.67136633e-01f, 8.91919900e-03f, 2.56351233e-01f,
  8.22205245e-02f, -2.07409799e-01f, 2.89076984e-01f, 1.33147225e-01f, -1.10330231e-01f, 4.08384874e-02f, -6.34551514e-04f, 6.25260249e-02f, -9.39824269e-04f, 1.38321042e-01f,
  -6.35042638e-02f, -2.34505553e-02f, 5.56537993e-02f, 3.74216646e-01f, -1.19367488e-01f, -7.18047172e-02f, 1.37337625e-01f, -2.52863336e-02f, -1.65082872e-01f, 1.32267997e-01f,
  -7.01987594e-02f, 8.71601701e-02f, 4.20005992e-02f, -3.68114151e-02f, -1.65057480e-01f, 6.59732744e-02f, -1.04890555e-01f, -5.00258133e-02f, 7.83558488e-02f, 2.81790216e-02f,
  -3.70129682e-02f, -9.63307321e-02f, -1.19696349e-01f, 5.75664034e-03f, -1.66886859e-02f, 3.15330997e-02f, 5.29337786e-02f, 9.00548548e-02f, 5.83454594e-02f, -9.28779915e-02f,
  1.16283327e-01f, -9.61322412e-02f, -1.52090155e-02f, 7.87049904e-02f, 3.69528532e-02f, -6.96748942e-02f, -3.02712228e-02f, 7.59428460e-03f, -6.90821335e-02f, -8.10587406e-02f,
  -5.49253784e-02f, 1.18581438e-02f, 1.77783016e-02f, 9.83649120e-02f, -1.21189160e-02f, -7.42133260e-02f, 1.13434806e-01f, -1.26596585e-01f, 1.04742646e-01f, -7.63608962e-02f,
  1.49918180e-02f, -4.89039952e-03f, -1.33104771e-01f, 6.35529384e-02f, 2.59432457e-02f, 9.00211856e-02f, 5.94714992e-02f, -1.03965268e-01f, 1.08189076e-01f, 3.42725813e-02f,
  5.14894612e-02f, 1.14014640e-01f, 1.12037227e-01f, -6.91760257e-02f, 2.30855402e-02f, 6.05324991e-02f, 9.39635839e-03f, -1.25411972e-01f, -2.33308766e-02f, -9.10178348e-02f,
  1.20544896e-01f, 1.07929744e-01f, 1.14872091e-01f, 9.66687221e-03f, 8.04630741e-02f, 1.30397230e-01f, 1.41755566e-02f, -5.32404706e-02f, 1.40142471e-01f, -7.62530565e-02f,
  -1.20211080e-01f, 1.35553539e-01f, -1.18394554e-01f, 2.91412435e-02f, 6.56277910e-02f, -3.04988446e-03f, 1.95890572e-02f, 1.73271727e-02f, -4.72171456e-02f, -6.76414222e-02f,
  6.10816553e-02f, 1.47212727e-03f, -8.38001072e-02f, -1.14024267e-01f, -6.07126355e-02f, -5.88385686e-02f, 1.14875980e-01f, -6.55199960e-02f, -1.02462377e-02f, 3.56738716e-02f,
  -1.94715872e-01f, 9.97708216e-02f, 8.75922665e-02f, -4.78186049e-02f, -1.24531507e-01f, 5.05883805e-02f, 1.19854778e-01f, 3.81421857e-02f, -1.33923128e-01f, -2.43535377e-02f,
  -3.54927108e-02f, -4.76367958e-02f, -1.04749631e-02f, -1.04523525e-01f, 5.30593917e-02f, 2.86716390e-02f, -7.89807960e-02f, 9.42372680e-02f, 6.10418767e-02f, -1.35446638e-01f,
  -8.22138488e-02f, -8.48127306e-02f, 1.53309256e-01f, 9.69312191e-02f, 2.08307821e-02f, -1.10439025e-01f, 1.11440353e-01f, -4.65681171e-03f, 1.59901544e-01f, 1.84760675e-01f,
  -1.10562235e-01f, 9.14250687e-03f, 1.80912595e-02f, 1.01992019e-01f, 1.37606248e-01f, -5.15706465e-02f, -1.69844627e-02f, -8.86372626e-02f, -5.49174584e-02f, 4.63265516e-02f,
  6.57206029e-02f, -7.57288337e-02f, 7.74791390e-02f, 3.23192775e-02f, 6.66543916e-02f, 2.49719411e-01f, -3.22793461e-02f, 1.13851815e-01f, 9.39621478e-02f, -6.74940646e-02f,
  1.59583196e-01f, 1.78994313e-01f, -3.56055237e-02f, 2.03855082e-01f, 3.00115291e-02f, 1.39789939e-01f, 1.77962765e-01f, 1.07413933e-01f, 1.03458546e-01f, 1.62046671e-01f,
  -7.63398111e-02f, 5.16344681e-02f, -5.58331907e-02f, 9.70924497e-02f, 2.01944321e-01f, 1.47008076e-02f, 1.98233202e-02f, 1.90893501e-01f, 1.04494914e-02f, 1.09474383e-01f,
  -4.50682919e-03f, -3.76264825e-02f, 1.32092476e-01f, -3.23060334e-01f, 5.66267222e-02f, 5.67717012e-03f, 2.48099461e-01f, 1.58361822e-01f, -2.06488833e-01f, 2.46323004e-01f,
  -3.57627645e-02f, 3.44310254e-02f, 1.31391259e-02f, -1.23388976e-01f, -1.28206909e-01f, 1.31540686e-01f, 1.37488535e-02f, 1.95647150e-01f, -9.27760452e-02f, 2.19263434e-02f,
  -4.45653461e-02f, 3.64647619e-02f, 3.99964601e-02f, -8.99326578e-02f, -4.99972627e-02f, -6.13714494e-02f, -6.59958720e-02f, -6.43154085e-02f, 4.90878709e-04f, -1.40667871e-01f,
  1.04936391e-01f, -1.05948754e-01f, -2.60812733e-02f, 6.53787032e-02f, -7.88028240e-02f, 5.22540808e-02f, 7.46297464e-02f, 1.23756841e-01f, 2.53204823e-01f, -1.94868326e-01f,
  1.21511899e-01f, -1.44685894e-01f, 2.05484927e-02f, 1.56255946e-01f, 1.46610439e-01f, 7.64094619e-03f, 6.47739023e-02f, 6.02032989e-03f, 9.23051238e-02f, 1.23092353e-01f,
  -2.32322793e-02f, 5.75041063e-02f, 1.67899281e-01f, 1.05299495e-01f, 5.19219749e-02f, 2.24258244e-01f, 2.01087818e-01f, -4.46853526e-02f, 4.44841385e-02f, 5.93653657e-02f,
  2.35234812e-01f, -4.47953455e-02f, 8.93182606e-02f, 7.69344484e-03f, 2.17014298e-01f, -2.00126410e-01f, 7.54139246e-03f, 1.59654498e-01f, -4.75151017e-02f, 1.57998934e-01f,
  -1.26625001e-01f, -2.08694696e-01f, -1.17856115e-01f, 1.36401691e-02f, 2.15699106e-01f, -1.03223890e-01f, 4.31694649e-02f, 8.89271870e-03f, 1.24125341e-02f, -2.07321033e-01f,
  -3.66583094e-02f, 9.77168977e-02f, -9.20552462e-02f, 4.08349931e-02f, 1.50493041e-01f, -1.60859097e-02f, 1.28709197e-01f, 2.12335631e-01f, 1.10840097e-01f, -3.67987603e-02f,
  -3.70437242e-02f, 9.97559279e-02f, 2.72393338e-02f, -5.00433445e-02f, -4.49213125e-02f, -3.58510315e-02f, -3.34988087e-02f, 3.52774747e-02f, 2.51273096e-01f, -1.39772706e-02f,
  -8.71550888e-02f, -8.03903937e-02f, -1.19601525e-01f, 8.58101621e-02f, -1.53553247e-01f, -4.33019921e-02f, 2.08473966e-01f, 1.00607835e-01f, 1.47788450e-01f, -9.92105231e-02f,
  1.64161518e-01f, -5.00719212e-02f, 1.33116141e-01f, 2.37357244e-03f, 4.75066155e-02f, 2.80003726e-01f, 1.43089788e-02f, -1.20097660e-02f, 2.36154959e-01f, 1.40352637e-01f,
  2.49580648e-02f, -9.75324139e-02f, 6.56906515e-02f, 3.81501988e-02f, 9.95376259e-02f, -1.67432919e-01f, -4.18579653e-02f, 1.34616002e-01f, 1.20338276e-01f, 1.87167212e-01f,
  -8.54804963e-02f, 1.59275327e-02f, 1.26695663e-01f, 3.70146446e-02f, 4.08646017e-02f, -1.38460636e-01f, 7.08498731e-02f, -1.19536407e-01f, -1.04125246e-01f, -1.11692231e-02f,
  3.18593271e-02f, -3.76746468e-02f, -1.06473222e-01f, 2.74170369e-01f, 7.88969174e-02f, -6.99130399e-03f, 1.15340147e-02f, -5.67727350e-02f, -5.56226214e-03f, 1.29272401e-01f,
  2.04364285e-02f, 2.34066457e-01f, 2.31006578e-01f, -8.43681023e-02f, -1.20872214e-01f, -3.24256122e-02f, 4.86213006e-02f, 3.53459939e-02f, -8.36392343e-02f, 2.61329353e-01f,
  -3.06380112e-02f, 7.72227347e-02f, 1.75087214e-01f, -1.83635175e-01f, 1.57892928e-01f, 1.81970373e-02f, 1.75125942e-01f, 2.64232129e-01f, -3.98424491e-02f, 1.91960290e-01f,
  1.15325257e-01f, 1.85196564e-01f, 1.10607274e-01f, -3.40954848e-02f, -2.65708566e-02f, 9.93773416e-02f, -4.41652387e-02f, -2.60770191e-02f, 6.03726618e-02f, 4.05472629e-02f,
  2.24911571e-02f, 1.63981333e-01f, 1.29724098e-02f, -1.44927830e-01f, -3.64602747e-04f, -1.38101608e-01f, -1.74695879e-01f, -3.82076502e-02f, 1.59579460e-02f, -3.90780196e-02f,
  -1.23999543e-01f, -2.36840602e-02f, 1.07355401e-01f, 1.36913404e-01f, 3.22237313e-02f, -2.45785248e-02f, -2.58091949e-02f, -9.23194140e-02f, -2.01439798e-01f, -2.63706110e-02f,
  -2.14995071e-01f, -3.47292721e-02f, 2.55440533e-01f, 1.49240032e-01f, 1.21607564e-01f, 8.52983370e-02f, 1.99817926e-01f, -2.04957142e-01f, -1.00194864e-01f, 6.19044108e-03f,
  1.25215486e-01f, -9.59674045e-02f, 5.63479662e-02f, -8.65603462e-02f, -2.53628418e-02f, 1.21777952e-01f, 1.95557177e-02f, -9.12124068e-02f, -1.74503983e-03f, 3.09033152e-02f,
  -5.14263995e-02f, 1.49395764e-01f, 7.09660426e-02f, -9.57101732e-02f, 3.68884653e-01f, -1.53581247e-01f, 6.90249503e-02f, 1.53349489e-01f, 2.39873037e-01f, 8.41900110e-02f,
  9.05839447e-03f, 4.37201932e-02f, 5.04431762e-02f, 1.03936411e-01f, 3.65353189e-02f, 1.75574794e-01f, 1.04335651e-01f, 8.24728236e-02f, -1.87215465e-03f, 4.95866425e-02f,
  7.15452014e-03f, -5.49749695e-02f, 5.67273535e-02f, 6.23084046e-02f, 1.93227585e-02f, -1.05501488e-01f, 2.17156604e-01f, 9.69628692e-02f, 5.02497666e-02f, -4.76840250e-02f,
  -7.74495825e-02f, 8.45679641e-02f, 2.80606478e-01f, 1.48504525e-02f, -1.41477749e-01f, 8.07054043e-02f, 2.10593402e-01f, 3.79470512e-02f, -1.81065112e-01f, 1.91135123e-01f,
  -6.01520799e-02f, 2.72117667e-02f, -2.04718392e-02f, -4.32974994e-02f, -7.76246339e-02f, -1.74551293e-01f, 9.33298096e-02f, 1.33813769e-01f, 1.56280413e-01f, -7.55043402e-02f,
  7.23599792e-02f, -3.36882658e-02f, -4.50628512e-02f, 1.91199500e-02f, 1.14551522e-01f, 3.22771110e-02f, -8.44999775e-03f, 3.26127410e-02f, 6.39641806e-02f, 2.03505620e-01f,
  -6.64336085e-02f, 7.73570463e-02f, 3.45683992e-02f, 8.45977217e-02f, 1.28920689e-01f, -5.19455858e-02f, -1.63297206e-01f, 1.11760616e-01f, 9.54237059e-02f, 9.18486640e-02f,
  -8.32303986e-03f, -9.01666582e-02f, 2.08504289e-01f, -9.86531004e-02f, 8.84700492e-02f, 1.65478989e-01f, -7.23966435e-02f, 3.70684527e-02f, 1.17067419e-01f, -5.49092889e-02f,
  1.78142190e-01f, 1.41577169e-01f, 6.59428388e-02f, 7.41949975e-02f, 1.31735101e-01f, 1.30663648e-01f, 1.40719160e-01f, -8.41333792e-02f, 1.71829313e-01f, 1.59369364e-01f,
  1.43565387e-01f, 2.31970251e-02f, 9.20553729e-02f, 6.00798279e-02f, 1.30024955e-01f, -1.62332401e-01f, -9.74448919e-02f, 3.24904352e-01f, 2.38700241e-01f, 3.81362177e-02f,
  -1.33929446e-01f, 1.76849917e-01f, -9.89886820e-02f, -2.51953453e-01f, -1.30015478e-01f, -4.27999161e-02f, 2.18647271e-01f, 6.77944496e-02f, -2.97004133e-01f, 1.23921618e-01f,
  1.33033553e-02f, -1.18165649e-01f, 9.56425294e-02f, 8.30138475e-03f, -2.39954829e-01f, 6.87847584e-02f, -4.76143323e-02f, 2.74975691e-02f, -8.01095441e-02f, -1.01342119e-01f,
  -7.47671202e-02f, -9.11603495e-02f, 5.10023758e-02f, 3.12699862e-02f, 1.08571552e-01f, 5.44061325e-02f, -5.83806597e-02f, 6.74707964e-02f, -6.21242784e-02f, -1.20274104e-01f,
  3.37275833e-01f, 6.05408847e-02f, 5.05773611e-02f, -1.63783878e-01f, -3.52591127e-02f, 1.40027404e-01f, -4.61670719e-02f, -2.08399408e-02f, 2.55205870e-01f, -9.60620120e-02f,
  1.20712042e-01f, 1.05268009e-01f, -6.56351075e-02f, 7.10193291e-02f, 1.38858482e-01f, 3.08816254e-01f, -2.70811897e-02f, 1.44972607e-01f, 5.58517613e-02f, 1.53869346e-01f,
  2.20196053e-01f, 8.89037736e-03f, 7.78035596e-02f, 2.32317984e-01f, 9.23872143e-02f, 2.43330643e-01f, 1.22036643e-01f, 4.21659082e-01f, 7.16086328e-02f, 1.84494972e-01f,
  4.05206025e-01f, -3.36732715e-01f, -1.03332207e-01f, -4.32628483e-01f, 2.11934522e-01f, -1.85614511e-01f, 2.16691643e-01f, -1.56613007e-01f, -3.36821675e-01f, 2.83066422e-01f,
  -1.16958104e-01f, -1.40354559e-01f, 1.34855211e-01f, -4.70182031e-01f, 1.71978325e-01f, 3.23668122e-01f, -1.20467015e-01f, -3.50933373e-01f, 1.67318493e-01f, 9.39229056e-02f,
  -8.00027698e-02f, -5.07832430e-02f, -1.59143537e-01f, -1.94539391e-02f, 1.26523795e-02f, 1.07426666e-01f, -1.24109417e-01f, 2.56165504e-01f, -4.06683460e-02f, 3.94263834e-01f,
  -1.22828707e-02f, -1.85364038e-01f, 9.90681574e-02f, -3.01845483e-02f, -2.13580746e-02f, -1.45547345e-01f, -1.60411745e-01f, 2.28355199e-01f, 1.90911651e-01f, 1.40253287e-02f,
  -2.35893101e-01f, -6.41584303e-03f, -1.94894254e-01f, -3.59304771e-02f, 2.18396679e-01f, 3.47681493e-02f, 2.68753115e-02f, -8.35751146e-02f, -7.27540478e-02f, -3.16480845e-02f,
  1.38824716e-01f, 1.69605792e-01f, 6.21472411e-02f, 1.59250535e-02f, 6.99162334e-02f, 2.04713130e-03f, -3.51434574e-02f, 2.35788226e-02f, 5.09657450e-02f, -4.30536494e-02f,
  -5.58916517e-02f, 1.62127346e-01f, 1.47054479e-01f, 2.72466801e-02f, 5.64965717e-02f, 1.47452146e-01f, 4.03946601e-02f, 1.19287506e-01f, -2.09042624e-01f, 7.59782940e-02f,
  1.86579246e-02f, -3.97763662e-02f, 1.73454046e-01f, -1.39621615e-01f, -6.95198327e-02f, 1.57271802e-01f, 3.66082564e-02f, 1.25464410e-01f, -5.24331704e-02f, 9.48026627e-02f,
  1.10496871e-01f, 1.46128625e-01f, 1.42984828e-02f, -1.03562303e-01f, 6.68930337e-02f, 4.94477376e-02f, 8.91712755e-02f, -7.28435740e-02f, -3.16986479e-02f, 7.35998005e-02f,
  -4.52908836e-02f, -3.42529491e-02f, -8.52665678e-03f, -8.76934379e-02f, -5.31557798e-02f, 4.48066890e-02f, -4.32432927e-02f, -5.94741516e-02f, 7.67833963e-02f, 1.05687022e-01f,
  8.58943388e-02f, -3.12058777e-02f, -5.13187684e-02f, 1.38776422e-01f, 1.62012979e-01f, 7.57121146e-02f, -3.47649790e-02f, 2.18148064e-02f, 6.00241534e-02f, -8.92588422e-02f,
  2.11698815e-01f, 1.65673092e-01f, 1.00058720e-01f, 1.89877123e-01f, 2.07390442e-01f, 1.91642225e-01f, 1.72873348e-01f, 1.18310474e-01f, -1.25649109e-01f, 5.90354241e-02f,
  -1.80604219e-01f, 1.82835281e-01f, 8.19180682e-02f, 5.01932986e-02f, -3.73773370e-03f, -6.64418116e-02f, 1.81274358e-02f, 1.67169705e-01f, -4.56159674e-02f, 1.58795953e-01f,
  2.08666995e-02f, -1.67680487e-01f, 1.54331967e-01f, -1.53902158e-01f, -1.97296664e-01f, 3.48182172e-02f, -1.04602732e-01f, -6.61471561e-02f, -2.01367680e-02f, -1.72904730e-01f,
  -1.77520052e-01f, 4.15419526e-02f, 2.93541342e-01f, 1.18779885e-02f, -8.03385377e-02f, -2.20868021e-01f, -8.49495605e-02f, -3.46174687e-01f, -8.90187547e-02f, 3.73111188e-01f,
  -5.94569035e-02f, 3.58627141e-02f, -1.28857732e-01f, -1.08331636e-01f, 1.14732787e-01f, 1.66241437e-01f, 9.42748711e-02f, 7.77457841e-03f, 6.07746542e-02f, 1.45552173e-01f,
  -4.94730659e-02f, -2.10008640e-02f, 9.56892073e-02f, 5.10262921e-02f, 2.17470676e-01f, -2.28042193e-02f, 7.45032281e-02f, 1.82770938e-01f, -4.62622643e-02f, -7.61966314e-03f,
  1.24801233e-01f, 3.69652212e-02f, 1.22684605e-01f, 8.53983779e-03f, 1.86714306e-01f, 6.08809479e-02f, -1.34163778e-02f, 8.59946758e-02f, 4.90050167e-02f, 1.03636784e-02f,
  1.90216571e-01f, -1.55272204e-02f, -9.83220786e-02f, 6.85915947e-02f, 1.42196074e-01f, 9.59205627e-02f, 1.05608135e-01f, 6.93483800e-02f, 1.60375535e-01f, 7.26687610e-02f,
  5.88132925e-02f, 1.05548598e-01f, 1.87468193e-02f, 2.98707951e-02f, 1.01460591e-01f, 1.21456340e-01f, 4.48455364e-02f, 2.71372795e-01f, -2.65327506e-02f, -1.72139004e-01f,
  -1.27358600e-01f, -2.28441313e-01f, -1.02061689e-01f, 2.97048017e-02f, -6.78199381e-02f, 2.32058689e-01f, 2.73833517e-02f, 3.82357985e-02f, -1.05243772e-01f, -7.24329147e-03f,
  -3.11989859e-02f, 1.94266126e-01f, -1.84843075e-02f, 1.28150240e-01f, -8.62775072e-02f, -9.32042226e-02f, -1.23166591e-01f, 1.75172150e-01f, -3.69454846e-02f, -1.18991800e-01f,
  1.23448685e-01f, 5.67865893e-02f, -1.86283875e-03f, 4.14327383e-02f, -3.87346521e-02f, 1.27201244e-01f, -5.77178448e-02f, -7.76498020e-02f, 7.84176439e-02f, -4.24207933e-02f,
  -1.04782082e-01f, -7.00890273e-02f, -7.90631697e-02f, 1.55930638e-01f, 1.58850282e-01f, 5.53804636e-02f, 7.61478953e-03f, 5.39389029e-02f, -7.41919205e-02f, -1.06864102e-01f,
  -4.84414212e-02f, 8.95295963e-02f, 1.36412084e-02f, 1.04511127e-01f, 1.94806345e-02f, 1.14358045e-01f, 3.02268919e-02f, 3.14266980e-02f, 1.16766684e-01f, 1.65036216e-01f,
  1.70363307e-01f, -3.52245965e-03f, 1.32433325e-01f, 7.15820342e-02f, 1.52133167e-01f, -5.50176017e-02f, 4.99180369e-02f, 1.80754304e-01f, 1.07004330e-01f, 2.74810225e-01f,
  -2.66053289e-01f, -5.16391397e-02f, -1.85114592e-02f, -3.23641151e-02f, 2.66097397e-01f, 3.10611073e-03f, 1.11934334e-01f, 3.81255709e-02f, -7.02847447e-03f, 4.61737588e-02f,
  -7.61899203e-02f, -6.06692880e-02f, 1.76627100e-01f, 1.38721749e-01f, -1.19905025e-01f, -5.44438884e-02f, -2.96650659e-02f, 9.48359743e-02f, -8.71751606e-02f, -4.13619541e-02f,
  -4.18329611e-02f, 3.60398293e-02f, -1.24493539e-01f, 9.81460065e-02f, -5.07739596e-02f, -2.64496412e-02f, -7.75249282e-05f, 2.10640699e-01f, -3.10752299e-02f, 1.80625636e-02f,
  1.65751830e-01f, -6.12901039e-02f, -1.09823123e-02f, -2.29157880e-02f, -7.99706578e-03f, 1.42870948e-01f, 3.99892367e-02f, -7.08875880e-02f, -1.54487014e-01f, -2.29848679e-02f,
  1.06404647e-01f, 8.27358570e-03f, 7.46708363e-02f, 7.38467276e-02f, 1.68384686e-01f, 1.64237350e-01f, -4.22998816e-02f, 1.69406772e-01f, 8.86832252e-02f, 1.68730736e-01f,
  2.84380823e-01f, 2.22894892e-01f, 2.78339446e-01f, 2.86671311e-01f, 2.83347666e-01f, 2.86955595e-01f, 2.30114907e-01f, 9.71756727e-02f, 3.07293892e-01f, 7.87126273e-02f,
  2.95037538e-01f, 6.06512986e-02f, 1.39124040e-03f, 3.13132972e-01f, -1.14123240e-01f, 5.74725755e-02f, 2.70693172e-02f, -1.08097218e-01f, 7.49946292e-03f, 6.69021159e-02f,
  2.60163277e-01f, -6.49456009e-02f, -2.48851240e-01f, -1.33680552e-01f, -2.04356015e-01f, -2.13944092e-01f, -1.04536317e-01f, 1.65431112e-01f, -4.01741326e-01f, 4.09210354e-01f,
  -3.23989205e-02f, -2.45921984e-01f, -1.25956163e-01f, 3.06511819e-01f, 1.47175223e-01f, 2.16438666e-01f, -5.99168576e-02f, -1.04185328e-01f, 1.18197739e-01f, 1.61605328e-01f,
  -5.60539067e-02f, -9.95545089e-02f, 1.64508089e-01f, 1.04783572e-01f, 2.50981208e-02f, -1.87805712e-01f, -4.19271067e-02f, 2.20038574e-02f, 1.44811738e-02f, -2.18782993e-03f,
  -2.41404504e-01f, -2.47963215e-03f, 4.89593036e-02f, 6.14702143e-03f, 9.20962095e-02f, -2.41166796e-04f, -1.02110483e-01f, 4.30451185e-02f, 9.62238386e-02f, -7.45788962e-02f,
  3.39597128e-02f, 6.55536801e-02f, -4.75725122e-02f, -2.16400847e-02f, -4.92025800e-02f, -1.11424699e-01f, 9.98252481e-02f, -4.63609323e-02f, 6.71194643e-02f, -1.12645589e-01f,
  3.60532887e-02f, 8.76060277e-02f, 8.98554102e-02f, 3.67079601e-02f, -9.24894214e-02f, -7.74732307e-02f, 3.09994780e-02f, 1.12419073e-02f, 8.26479346e-02f, -7.88569003e-02f,
  6.56831264e-02f, 5.63795045e-02f, 6.89623803e-02f, 9.25428942e-02f, -1.44246355e-01f, -2.94055287e-02f, 4.76538762e-02f, -6.41256794e-02f, 1.72897428e-02f, -2.50627054e-03f,
  -1.10422105e-01f, -5.02897575e-02f, -5.45689575e-02f, 1.36461656e-03f, 1.06037389e-02f, 2.43057385e-02f, -1.14055626e-01f, -5.42117096e-02f, 3.77545506e-02f, 6.83758184e-02f,
  -5.50130382e-03f, -8.89056697e-02f, 1.25714853e-01f, 1.85011160e-02f, -8.95854831e-02f, -7.75126275e-03f, 1.35992169e-01f, 3.98546010e-02f, -1.03772648e-01f, -2.16364190e-02f,
  1.07328467e-01f, 6.76397756e-02f, -8.29111505e-03f, -1.53956134e-02f, 5.55952303e-02f, -1.18380688e-01f, 6.08880557e-02f, -1.15218088e-01f, 1.19628608e-02f, 5.32205850e-02f,
  5.47079705e-02f, -1.01807732e-02f, -3.34136561e-02f, -1.01875767e-01f, 1.08128496e-01f, 1.11328013e-01f, 1.29987836e-01f, -1.43023033e-03f, -5.11756446e-03f, 1.62724093e-01f,
  -1.13541566e-01f, 3.16941142e-02f, 1.57333851e-01f, 1.17834836e-01f, 8.95780995e-02f, -1.44269004e-01f, 5.43371476e-02f, 1.44927874e-01f, 1.07187994e-01f, 8.61045048e-02f,
  1.30843073e-01f, 8.61230642e-02f, 3.94679159e-02f, 7.22160935e-02f, -1.46050289e-01f, -1.91789512e-02f, -1.99367367e-02f, 6.00926392e-03f, -2.43212804e-02f, 4.67295833e-02f,
  -4.24250327e-02f, -1.61188319e-02f, -1.35797366e-01f, -5.35516925e-02f, 7.35116228e-02f, 9.17803571e-02f, -7.37869442e-02f, 2.47089654e-01f, 9.20709521e-02f, -5.56321777e-02f,
  1.78334303e-02f, 6.39834106e-02f, 1.35104716e-01f, -1.39236957e-01f, -7.95506611e-02f, 7.55613968e-02f, 1.42685413e-01f, -6.80155531e-02f, 2.43619233e-02f, 1.06627740e-01f,
  3.79968970e-03f, 4.31709699e-02f, 9.11207125e-02f, 1.61609471e-01f, -5.65990061e-02f, 5.89672402e-02f, 1.37073189e-01f, -2.07007006e-01f, 1.67326063e-01f, 4.04283106e-02f,
  -1.96417794e-02f, 6.95353150e-02f, 4.11737412e-02f, 2.24377975e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.03647418e-01f, -2.93368585e-02f, -9.81332734e-03f, 1.12243570e-01f, 2.74123475e-02f, 3.37658934e-02f, 3.48302871e-02f, 5.97817264e-02f, 1.40425906e-01f, 1.97761044e-01f,
  -1.22047802e-02f, 1.24204986e-01f, 5.45901712e-03f, 1.91303924e-01f, 6.13718033e-02f, 5.48187159e-02f, 1.41298160e-01f, 3.15861702e-02f, 1.33772418e-01f, 2.20534489e-01f,
  1.36519283e-01f, 9.67159495e-03f, 2.31901571e-01f, 1.35960743e-01f, -7.12893009e-02f, 1.79581314e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  8.47888459e-03f, -4.13537711e-01f, -3.20195466e-01f, -2.11539000e-01f, -5.57142615e-01f, -8.99205282e-02f, 2.36805588e-01f, 6.06412143e-02f, 1.79645106e-01f, -4.17366266e-01f,
  -3.29927981e-01f, -5.36176562e-02f, 1.39111608e-01f, -1.04758479e-01f, -3.05855960e-01f, -4.32286188e-02f, -2.01932967e-01f, -1.53876558e-01f, 5.02064936e-02f, -7.48945698e-02f,
  -4.00606602e-01f, -1.34371966e-01f, -3.11075479e-01f, 9.91801848e-04f, 1.55171171e-01f, 4.02486548e-02f, 1.21557280e-01f, 7.55269378e-02f, -1.96633801e-01f, 2.46900637e-02f,
  -2.59274423e-01f, 6.01281114e-02f, 3.72273386e-01f, -1.57481655e-01f, -2.10316822e-01f, 3.06302891e-03f, 1.38123274e-01f, -6.80075139e-02f, 3.22859198e-01f, -1.69170722e-01f,
  -2.01166376e-01f, -8.52613375e-02f, -2.06315275e-02f, 3.19712967e-01f, 1.03374995e-01f, 3.00863385e-03f, -8.67030472e-02f, -2.66194552e-01f, 6.58645928e-02f, 4.21634048e-01f,
  -7.44092092e-02f, 1.65910184e-01f, 1.03543617e-01f, 1.66035429e-01f, 1.76009208e-01f, -1.52787462e-01f, -1.31219462e-01f, -4.95704003e-02f, 3.23184103e-01f, 1.13755837e-01f,
  -1.70580775e-01f, -3.40965003e-01f, -3.54793407e-02f, 4.93319929e-02f, -3.68222408e-02f, 2.55981684e-02f, -3.11532795e-01f, -7.26125240e-02f, -3.22994739e-01f, -1.46196723e-01f,
  -2.22252309e-01f, 1.58624530e-01f, -4.27814364e-01f, 1.59125909e-01f, 6.77631050e-02f, 8.26585107e-03f, -9.89757776e-02f, 4.81275469e-02f, 2.74747998e-01f, -1.78590175e-02f,
  -2.73540735e-01f, 2.47366190e-01f, -1.70905098e-01f, 5.69334686e-01f, 1.79836201e-03f, -3.20008218e-01f, -3.29834163e-01f, 3.21901828e-01f, -2.36380454e-02f, -3.04960072e-01f,
  -1.61400065e-01f, -4.06394839e-01f, -3.83069426e-01f, 8.53553340e-02f, -4.40633669e-02f, 3.71262431e-01f, -1.27124354e-01f, 1.51263639e-01f, -1.21822990e-01f, 2.14122739e-02f,
  -1.01191238e-01f, 1.55808134e-02f, 2.02258706e-01f, -9.95621160e-02f, -2.12344334e-01f, 3.05553526e-03f, 1.19968340e-01f, 5.85682809e-01f, -1.38412759e-01f, 1.97412699e-01f,
  4.35225517e-01f, -2.03880146e-01f, 8.01671073e-02f, 6.84973150e-02f, 1.00153141e-01f, -1.39470115e-01f, 4.85577464e-01f, -1.23410545e-01f, -1.52039947e-02f, 2.41050556e-01f,
  -3.70671213e-01f, -5.61151095e-02f, -4.51269075e-02f, 1.63206547e-01f, -2.21903428e-01f, -5.99944498e-03f, 9.74200293e-02f, 4.47153866e-01f, -4.90096509e-02f, -1.86317727e-01f,
  4.83002551e-02f, 3.99173014e-02f, 3.80639941e-01f, 1.09869599e-01f, 3.77815180e-02f, -1.50602534e-01f, 2.16629684e-01f, 1.11017875e-01f, 2.38366187e-01f, -1.90865055e-01f,
  5.69228828e-02f, -1.11891441e-01f, 1.68549448e-01f, -6.44626543e-02f, 3.74585003e-01f, -1.26250342e-01f, -2.02828616e-01f, 9.76185203e-02f, 4.16614503e-01f, 3.55384648e-01f,
  1.15980454e-01f, 4.30382669e-01f, 1.97754607e-01f, -2.97112495e-01f, -3.76362562e-01f, 1.57222301e-02f, 2.04593372e-02f, 1.36312442e-02f, -4.14598107e-01f, -1.84175670e-01f,
  -3.56942415e-01f, -2.29838878e-01f, 1.80279911e-01f, 1.80498883e-01f, 2.23608449e-01f, -3.85629922e-01f, 4.78395075e-01f, -1.25190355e-02f, -1.58178192e-02f, -1.73160702e-01f,
  3.22338790e-02f, -1.37819022e-01f, -1.21006258e-01f, -2.35165972e-02f, 8.17998685e-03f, 1.63125873e-01f, 5.22228749e-03f, -8.77925605e-02f, 1.16540723e-01f, -1.30793601e-01f,
  6.20962866e-02f, -8.28709975e-02f, -1.14502497e-02f, -5.57187311e-02f, 3.28516901e-01f, -1.05930835e-01f, -3.14168334e-01f, 3.72345924e-01f, -1.90841913e-01f, 4.99421209e-01f,
  -7.72689190e-03f, -1.21216856e-01f, 2.65402913e-01f, 3.49049926e-01f, 3.12767625e-01f, 1.54646590e-01f, 1.52300820e-01f, 3.02340358e-01f, -2.89801180e-01f, 1.67005405e-01f,
  2.32735321e-01f, 2.65381545e-01f, 9.70609765e-03f, -5.94004504e-02f, -4.05364901e-01f, 1.62982911e-01f, -2.80895501e-01f, 1.84942126e-01f, 1.24888338e-01f, -4.93130535e-02f,
  2.13519167e-02f, -1.03952587e-01f, -1.05611049e-01f, 3.30039084e-01f, -3.66069913e-01f, 4.44216251e-01f, 2.81592645e-02f, 3.79581243e-01f, -2.74174213e-01f, -6.79489784e-03f,
  -1.63267493e-01f, 5.05140901e-01f, -1.04827978e-01f, -5.12450397e-01f, 1.83929116e-01f, -1.70354217e-01f, 8.05528369e-03f, 3.19431365e-01f, 3.09040666e-01f, -8.51893052e-02f,
  6.37277246e-01f, 1.04816712e-01f, 1.14483461e-01f, -2.17805862e-01f, -1.47989988e-01f, 1.32511005e-01f, -1.18193552e-01f, -4.63146046e-02f, -1.74224645e-01f, -1.95874162e-02f,
  -5.39375842e-02f, -8.99117962e-02f, 1.63311437e-01f, -1.84078347e-02f, -3.83670151e-01f, -2.48565879e-02f, -3.43991905e-01f, -7.13394955e-03f, -3.02817225e-01f, 1.66161433e-01f,
  3.90704840e-01f, 1.24324359e-01f, 6.73736781e-02f, -4.07697886e-01f, 2.61311531e-02f, -2.63897866e-01f, -5.98248243e-02f, 3.37133676e-01f, -6.42130673e-02f, 3.15038651e-01f,
  1.68465767e-02f, 1.22279644e-01f, -7.19372034e-02f, 8.22765231e-02f, -8.30773637e-02f, -1.50825635e-01f, -3.87857854e-01f, 3.48206470e-03f, 2.59886980e-01f, 3.35903883e-01f,
  5.48243895e-02f, 8.84878337e-02f, -1.35284811e-01f, -5.73545881e-02f, 1.55104712e-01f, -2.02974781e-01f, -2.20572263e-01f, -4.94915426e-01f, -6.50603101e-02f, 6.11524105e-01f,
  2.57218838e-01f, 2.90732950e-01f, 1.13049880e-01f, 3.22432607e-01f, -4.53618556e-01f, 8.72838125e-02f, -2.31153909e-02f, -1.14791356e-01f, -1.60939485e-01f, -2.89672583e-01f,
  -2.86092311e-01f, 3.78992736e-01f, 6.84579685e-02f, 7.89175108e-02f, -1.06716260e-01f, 2.20574453e-01f, 4.15614843e-01f, 4.06225678e-03f, 2.07423083e-02f, -4.03286934e-01f,
  1.73144966e-01f, -1.21397465e-01f, -1.16856501e-01f, 1.24657549e-01f, 1.53345466e-01f, 1.90902919e-01f, -2.03509688e-01f, 1.82061076e-01f, -8.66404250e-02f, -2.98554562e-02f,
  -3.24687660e-02f, -3.29142869e-01f, 7.94184983e-01f, -4.79835644e-02f, 5.98255321e-02f, -1.56589508e-01f, 7.57646188e-03f, -5.79184532e-01f, 1.70145743e-02f, -3.29046650e-03f,
  3.35270911e-01f, 1.63331509e-01f, -2.12539345e-01f, 1.27535805e-01f, 4.35595751e-01f, -1.65435448e-02f, 1.49668545e-01f, -3.35980207e-01f, 2.63715595e-01f, 1.81444392e-01f,
  -2.92221546e-01f, 1.02443881e-01f, 7.27779865e-02f, 3.54185909e-01f, 4.60279398e-02f, 2.23159373e-01f, -3.69742095e-01f, -3.41227688e-02f, -2.48649001e-01f, -3.79235148e-01f,
  -2.75998592e-01f, -3.01304966e-01f, 1.59803003e-01f, 7.89561346e-02f, 3.35210264e-01f, -4.44522917e-01f, 4.62015569e-01f, -2.73665059e-02f, 1.65959388e-01f, 1.02597713e-01f,
  3.45292658e-01f, 3.49028111e-01f, 7.93644860e-02f, 1.97718576e-01f, 1.26142949e-01f, 3.74216944e-01f, -2.92819202e-01f, -3.09202254e-01f, -3.14871818e-01f, -1.34238586e-01f,
  1.93273202e-02f, 6.11367449e-02f, 1.81773584e-02f, 1.84624225e-01f, 4.93041500e-02f, 1.45625830e-01f, -1.15097351e-01f, 6.72089867e-03f, 6.73221573e-02f, -5.24319783e-02f,
  -2.59127319e-01f, 3.85044724e-01f, 2.93932676e-01f, -1.18806019e-01f, 1.59791365e-01f, -2.32692346e-01f, 9.87569150e-03f, -1.99543595e-01f, 6.88330606e-02f, -2.37375423e-01f,
  8.97419304e-02f, 5.83389699e-01f, 7.21889734e-02f, 1.80773139e-01f, 4.36515398e-02f, -4.83021170e-01f, -2.61426922e-02f, -1.20879710e-01f, -3.78026783e-01f, -4.64207828e-02f,
  1.74433723e-01f, -6.79688603e-02f, 5.43298759e-02f, -1.87975585e-01f, -2.01675177e-01f, -1.45817235e-01f, 1.40074313e-01f, -3.81999314e-01f, -1.05242886e-01f, 7.19880462e-02f,
  -1.11979835e-01f, 1.43722326e-01f, 2.58522838e-01f, 7.77656585e-02f, 2.42396280e-01f, 1.99946314e-01f, 4.71121103e-01f, -3.41096401e-01f, -4.54887509e-01f, -7.77073875e-02f,
  -2.45268583e-01f, 2.69379109e-01f, 3.01706254e-01f, -5.71818054e-01f, 3.32751811e-01f, 2.32857898e-01f, -2.44333357e-01f, 4.14926201e-01f, -5.32400236e-03f, -5.41572630e-01f,
  -2.62636721e-01f, -6.40098229e-02f, -1.94670647e-01f, 1.46010309e-01f, -4.11793962e-02f, 3.05920392e-01f, -1.19446427e-01f, -2.13049538e-02f, -1.58248022e-01f, -1.19387999e-01f,
  -8.30612928e-02f, 5.29882193e-01f, -5.23888767e-02f, -1.79355636e-01f, 8.40359405e-02f, -3.72120559e-01f, 5.75537831e-02f, -3.38466823e-01f, -2.06878901e-01f, -1.89653784e-01f,
  1.84228539e-01f, 5.66465147e-02f, -3.50028515e-01f, -9.05169249e-02f, 2.99418010e-02f, 2.63558745e-01f, -3.66611928e-02f, 7.52450505e-05f, 8.35545883e-02f, -1.31181926e-01f,
  -4.06411365e-02f, 1.91981673e-01f, 1.43151402e-01f, -2.88448539e-02f, -5.16510785e-01f, -9.30316299e-02f, 5.71196415e-02f, 2.80913204e-01f, 8.60724002e-02f, 2.49812379e-02f,
  -1.25327542e-01f, 2.09317997e-01f, -1.39678001e-01f, 2.37206966e-02f, -7.24676773e-02f, 6.88997656e-02f, -2.36974835e-01f, 3.40033591e-01f, 1.40627846e-01f, 4.59935367e-01f,
  2.31608525e-01f, -3.52184564e-01f, -4.34756726e-01f, 4.08178955e-01f, -2.32996181e-01f, 2.00903654e-01f, -1.18437530e-02f, -5.66602424e-02f, -1.04723588e-01f, -3.79656255e-01f,
  9.74746272e-02f, -2.84900934e-01f, -1.35010421e-01f, -4.27442431e-01f, -7.18612000e-02f, 4.82820839e-01f, -3.04847509e-01f, 6.28258288e-02f, -2.63237627e-03f, 3.34577143e-01f,
  -1.43932894e-01f, -2.03806505e-01f, -1.50471833e-03f, -1.08121850e-01f, 2.77487844e-01f, -1.63390085e-01f, 9.59272236e-02f, -4.16826867e-02f, -2.11765498e-01f, -4.00101356e-02f,
  -2.13156547e-02f, 6.12239182e-01f, 9.53690857e-02f, -3.81623209e-02f, -2.82227993e-01f, 1.65510729e-01f, 2.18655035e-01f, -6.65738136e-02f, 7.53937364e-02f, -4.84686762e-01f,
  7.59449527e-02f, -3.82623151e-02f, -7.19138682e-02f, -2.54937798e-01f, 1.58699691e-01f, -1.30456105e-01f, -2.61513084e-01f, 7.49465153e-02f, 4.11648676e-02f, -4.69061583e-02f,
  -1.62742004e-01f, -3.52105170e-01f, 2.57417440e-01f, -2.40306154e-01f, 2.67246645e-03f, 2.29822844e-01f, -7.15433359e-02f, 2.49503851e-02f, 3.07608321e-02f, -1.94470566e-02f,
  5.88850293e-04f, 2.31412221e-02f, 3.26514363e-01f, -8.66203383e-02f, -7.90915266e-02f, -4.38313246e-01f, 1.85180902e-01f, -3.77673030e-01f, 2.85762638e-01f, -3.07783931e-01f,
  3.41225952e-01f, -1.79233506e-01f, 1.75013959e-01f, 2.75776774e-01f, 2.08754480e-01f, 3.70657921e-01f, 3.36683393e-01f, 8.34331289e-02f, -1.87007889e-01f, -2.70102799e-01f,
  -3.09004933e-01f, -4.02853489e-02f, -8.08391273e-02f, -5.73802255e-02f, -1.43383101e-01f, 4.28711809e-02f, -9.17221233e-02f, -4.92123179e-02f, 3.77727926e-01f, -3.95655155e-01f,
  1.12620205e-01f, 5.98285794e-02f, 3.66066635e-01f, -3.13902289e-01f, -3.05693358e-01f, -2.83792783e-02f, -2.31666565e-01f, 4.75522757e-01f, -5.96718907e-01f, 3.17885339e-01f,
  -3.71772408e-01f, 1.05707280e-01f, 5.39921105e-01f, 4.19736981e-01f, -5.90692796e-02f, 1.95775792e-01f, 1.21517861e-02f, 1.69256344e-01f, 1.83247343e-01f, -3.40227157e-01f,
  9.83500779e-02f, 1.24272443e-01f, -1.31800234e-01f, -1.00806698e-01f, -2.75469780e-01f, 3.56927097e-01f, 3.83996844e-01f, 9.67848077e-02f, 2.02795938e-01f, -1.62703738e-01f,
  3.59268606e-01f, 6.93080649e-02f, 2.84576893e-01f, 1.35271341e-01f, 6.17843568e-02f, -4.60184030e-02f, 4.54242676e-02f, 1.16701685e-01f, 4.19732630e-01f, -2.09513500e-01f,
  4.58200788e-03f, 2.39895314e-01f, -1.04409441e-01f, 3.11345279e-01f, 1.36610180e-01f, -1.98205300e-02f, 5.37188128e-02f, -8.77152197e-03f, -3.21219474e-01f, -1.44050449e-01f,
  -6.90867007e-02f, -3.82010378e-02f, 3.04106921e-01f, 3.23970526e-01f, -4.04808104e-01f, 8.88227150e-02f, 3.75097431e-02f, -9.44881290e-02f, -3.65001708e-02f, -3.59744281e-01f,
  -1.95730180e-02f, 2.02607378e-01f, -4.03989524e-01f, 6.30709410e-01f, -5.17599545e-02f, 3.70340534e-02f, -6.56173527e-02f, 1.52071282e-01f, -2.05286041e-01f, -5.09563051e-02f,
  2.65021145e-01f, -2.99265176e-01f, 7.94155419e-01f, -1.56590417e-01f, -1.61768138e-01f, -2.71485984e-01f, -2.46616498e-01f, -1.82671085e-01f, 1.66732237e-01f, -1.09689742e-01f,
  -3.59221131e-01f, 4.07034494e-02f, -9.14769024e-02f, 8.72061774e-02f, 1.45190984e-01f, -3.40450853e-01f, -3.60153355e-02f, 1.19682580e-01f, -2.96551615e-01f, 1.65272444e-01f,
  -1.96201578e-01f, -6.74291253e-02f, -3.26486602e-02f, -1.53066427e-01f, 1.19263016e-01f, -1.04446009e-01f, 1.00958116e-01f, -1.87125534e-01f, 1.12357186e-02f, 3.83444637e-01f,
  -3.29819441e-01f, -2.74839669e-01f, -1.23496149e-02f, -2.49486789e-01f, 3.82256240e-01f, -3.17393333e-01f, 1.92004833e-02f, -2.99862921e-01f, -6.92162290e-02f, 1.97421625e-01f,
  7.06606209e-02f, -1.42924204e-01f, 2.66971081e-01f, -3.63020420e-01f, 4.31749433e-01f, 1.03960648e-01f, 1.64746463e-01f, -1.36270642e-01f, -4.03307021e-01f, -1.04131460e-01f,
  2.82927632e-01f, -3.02629406e-03f, 4.69370306e-01f, -3.72937918e-01f, 2.76639946e-02f, -2.46467069e-02f, -3.77365232e-01f, -1.77667677e-01f, -5.96478395e-02f, -1.65501148e-01f,
  4.51684654e-01f, 1.08318694e-01f, -2.23494768e-01f, -7.52908364e-03f, -5.90920299e-02f, 4.18203533e-01f, 9.43664089e-02f, -1.23669254e-03f, 2.44053558e-01f, -7.30906650e-02f,
  9.50605273e-02f, 1.41917139e-01f, -6.32956773e-02f, -1.05484970e-01f, 4.81798910e-02f, -9.70542524e-03f, 2.79983312e-01f, 1.46767914e-01f, -1.46372765e-01f, -1.92251392e-02f,
  5.30663393e-02f, 1.56619310e-01f, 1.16990730e-01f, -2.62040347e-01f, 1.97369754e-01f, 7.99998641e-02f, -1.20632626e-01f, -1.48157656e-01f, -1.01453759e-01f, 1.67069770e-02f,
  2.64780104e-01f, -1.97975561e-01f, 6.22722693e-02f, -6.56708956e-01f, 3.54591221e-01f, -1.53704407e-02f, -2.07699150e-01f, -1.43044159e-01f, -4.74085271e-01f, 2.31996402e-01f,
  2.01911658e-01f, 1.42528728e-01f, 3.67227465e-01f, 5.54643646e-02f, 4.34051231e-02f, 3.27945262e-01f, -4.88409549e-01f, 3.68114799e-01f, -1.56660587e-01f, -2.27435693e-01f,
  -4.44980413e-01f, -1.81318894e-01f, 5.98144159e-02f, -1.31595861e-02f, -5.68136293e-03f, -1.29115954e-01f, -1.67197995e-02f, -2.19702169e-01f, 1.35253072e-01f, -1.39326754e-03f,
  5.38568795e-01f, 2.22984347e-02f, 1.27638236e-01f, 1.10695988e-01f, -1.59808204e-01f, -8.00108835e-02f, 2.99413323e-01f, -7.75752366e-02f, 2.60596454e-01f, -2.03325287e-01f,
  -6.11523688e-01f, 2.62050778e-01f, -3.78992647e-01f, -4.84837368e-02f, 1.43906370e-01f, -1.79970205e-01f, -3.41769904e-02f, 2.32013732e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -9.70898420e-02f, 1.13956025e-02f, -1.31704658e-01f, 6.43424541e-02f, -6.39289021e-02f, 1.17213570e-01f, 7.48021528e-02f, 5.32235168e-02f, -1.26679063e-01f, -1.56873912e-01f,
  -3.65947885e-03f, 9.17983353e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    