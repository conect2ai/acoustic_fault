/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.03727146e-02f, 1.69115961e-01f, -2.75456369e-01f, -4.09619045e-03f, 1.27744213e-01f, 2.00357497e-01f, -2.31313720e-01f, 1.07832462e-01f, -9.11392942e-02f, 6.21623993e-02f,
  2.58955527e-02f, 4.28861715e-02f, 5.18443398e-02f, 9.39044431e-02f, -1.85163375e-02f, -4.57003480e-03f, -4.32788357e-02f, -2.82530524e-02f, 3.72085981e-02f, -5.92654236e-02f,
  -1.07596062e-01f, 1.11300886e-01f, -2.87961721e-01f, -6.65866071e-03f, -6.28211722e-02f, -1.11210287e-01f, 4.99532931e-02f, -2.55770385e-02f, 1.36639467e-02f, 5.12761511e-02f,
  4.75860909e-02f, -7.22850934e-02f, -8.40315297e-02f, 2.96638533e-02f, 6.98675821e-03f, 1.82596426e-02f, -9.70320869e-03f, -1.04850397e-01f, -4.44206484e-02f, -3.96540156e-03f,
  1.32307764e-02f, 1.25074998e-01f, -6.59744069e-02f, -5.21615632e-02f, -4.68675680e-02f, -4.06246781e-02f, 2.45285276e-02f, -1.09557994e-02f, -3.21723334e-02f, -1.12212971e-02f,
  -2.47986782e-02f, -4.22819331e-02f, -1.25863433e-01f, -8.06159377e-02f, -5.10588400e-02f, -5.81109710e-02f, -3.87703218e-02f, -3.83800059e-03f, 4.34831865e-02f, 3.26515846e-02f,
  -1.06707945e-01f, -6.08098577e-04f, -4.05761227e-02f, 4.79954993e-03f, 7.73403794e-02f, 9.54041481e-02f, 9.61672142e-03f, 9.01210755e-02f, 8.17940533e-02f, -3.68340984e-02f,
  2.09328695e-03f, -6.93981349e-02f, 7.56386966e-02f, -5.70032746e-02f, -1.40709267e-03f, -1.01172430e-02f, -4.43443507e-02f, 1.14454404e-01f, -7.61625320e-02f, 5.32239527e-02f,
  6.83955997e-02f, 1.08368240e-01f, 2.74241506e-03f, -2.40775533e-02f, -2.62092589e-03f, -8.35130289e-02f, 1.35563418e-01f, -2.83103529e-02f, -5.50094210e-02f, -4.38680835e-02f,
  2.92810380e-01f, 1.83837861e-01f, -4.58339490e-02f, 9.23864096e-02f, 2.21002661e-02f, 4.20426056e-02f, -2.94433199e-02f, 9.34802964e-02f, -7.62966126e-02f, -6.26781806e-02f,
  5.32248951e-02f, 1.28660291e-01f, 1.90945584e-02f, -9.82559025e-02f, -5.40746078e-02f, 5.63215949e-02f, 7.01301498e-03f, 3.18786651e-02f, 5.65114431e-02f, -1.03058005e-02f,
  -4.22993079e-02f, 5.02219424e-03f, -6.95297271e-02f, -1.25272974e-01f, 1.10105379e-02f, -4.75969203e-02f, -1.07936366e-02f, -5.02916761e-02f, 3.87967713e-02f, 5.73449954e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.52302074e-01f, -4.60164636e-01f, 4.43174616e-02f, 2.65302241e-01f, 3.89848500e-01f, 3.88402313e-01f, 6.39159143e-01f, -1.14577658e-01f, 2.37128586e-02f, -4.60771292e-01f,
  2.47098226e-02f, -6.17431141e-02f, -4.03910913e-02f, -1.53127268e-01f, 7.03867912e-01f, 1.03957869e-01f, -1.65362041e-02f, -2.93125901e-02f, 7.23833963e-02f, -2.01655179e-01f,
  7.27102235e-02f, -1.06989153e-01f, 1.50812939e-02f, -4.19162810e-01f, -6.27031103e-02f, -1.83693111e-01f, -1.00873308e-02f, 5.41131012e-02f, -1.54105291e-01f, 1.70327589e-01f,
  -1.28512681e-01f, -5.14183156e-02f, -4.35369229e-03f, -2.82190740e-01f, 5.38583249e-02f, -2.27290224e-02f, 6.08829670e-02f, 1.56101882e-01f, 3.98524292e-02f, 1.84591953e-02f,
  -1.75537020e-01f, -1.00037515e-01f, 7.73872202e-03f, -4.45619784e-02f, 7.50195533e-02f, -1.00756548e-01f, 1.90250110e-02f, -5.32430178e-03f, -1.60864800e-01f, -1.37735680e-02f,
  -1.07696652e-01f, -1.18141666e-01f, -3.92159633e-02f, -1.56491771e-01f, -5.83824106e-02f, -2.48015653e-02f, 4.85585593e-02f, 1.77270412e-01f, -8.17828067e-03f, 4.57779691e-02f,
  -5.39796948e-02f, 1.69190526e-01f, -6.10888703e-03f, -5.73658906e-02f, -3.09867226e-02f, -4.90331687e-02f, -6.37545213e-02f, 5.67549095e-02f, -4.92211804e-02f, 2.79983319e-02f,
  -6.02691341e-03f, -5.84482066e-02f, 1.67945940e-02f, 7.35606328e-02f, -5.86212426e-02f, -1.21883198e-03f, -7.76701793e-02f, -4.72595869e-03f, -2.33457536e-02f, -8.86086188e-03f,
  -3.73579636e-02f, 5.06928265e-02f, -8.41695815e-02f, 1.65728666e-02f, 4.13371772e-02f, 3.70106474e-02f, -1.58473730e-01f, -1.14181243e-01f, 4.92314324e-02f, 8.03281367e-02f,
  -3.69549006e-01f, -3.67946148e-01f, -1.57089699e-02f, -1.78980753e-01f, -1.38789460e-01f, -5.85818954e-04f, 2.77786758e-02f, -2.29325294e-02f, -6.36299774e-02f, -1.16124965e-01f,
  4.18538377e-02f, 5.11920592e-03f, -1.52290538e-01f, 3.91965806e-02f, -1.20770363e-02f, 8.53284076e-03f, 1.37265816e-01f, 5.05878665e-02f, -2.66653802e-02f, -1.38842538e-01f,
  -1.05304629e-01f, -4.23229374e-02f, 2.49897456e-03f, 1.53408488e-02f, 2.52243108e-03f, 4.68806364e-02f, -2.75241081e-02f, -1.61199793e-02f, -3.90753821e-02f, -1.42299712e-01f,
  -4.35545415e-01f, -6.72475547e-02f, -4.10385609e-01f, -3.66889477e-01f, 1.69182837e-01f, -3.40226263e-01f, -1.25610173e-01f, 3.81990783e-02f, 9.94946510e-02f, 2.70748556e-01f,
  2.65230751e-03f, 2.56561413e-02f, 4.40635800e-01f, -7.44914770e-01f, -4.99627888e-01f, -2.34850034e-01f, -6.35665536e-01f, -4.49751794e-01f, -5.55227846e-02f, -7.94240534e-02f,
  -1.99461266e-01f, -2.69978315e-01f, -4.20593858e-01f, 2.17148125e-01f, -3.72926295e-01f, 1.67729974e-01f, 1.43954039e-01f, 1.36844888e-01f, -1.92463756e-01f, -8.60961378e-02f,
  -7.60359466e-02f, 3.59732628e-01f, -5.15142158e-02f, 4.70327660e-02f, -1.04550272e-01f, -1.08843111e-02f, -7.78628290e-02f, 1.43545344e-01f, 9.39899758e-02f, 3.91944312e-02f,
  5.72995879e-02f, 7.33819976e-02f, -3.22119743e-02f, -2.83244587e-02f, 2.79140770e-02f, 1.03408851e-01f, -1.65125906e-01f, 1.37691861e-02f, -3.97628546e-02f, -9.23602134e-02f,
  -2.91622337e-02f, -6.03843890e-02f, -2.51069844e-01f, -8.37676227e-02f, -8.30371380e-02f, 3.52057889e-02f, -6.45590499e-02f, 4.39625010e-02f, -3.71482633e-02f, 3.09004113e-02f,
  3.21883895e-02f, -4.85597588e-02f, -8.33475143e-02f, -2.20070016e-02f, 3.11454348e-02f, 5.59172332e-02f, -6.75713047e-02f, 8.29418376e-02f, -4.88822116e-04f, -5.04780449e-02f,
  -4.31584381e-02f, -2.35001110e-02f, -1.16726859e-02f, -1.27030477e-01f, -1.04034081e-01f, -8.71694821e-04f, -8.62762406e-02f, 5.55851012e-02f, -7.74612576e-02f, -1.11362599e-01f,
  1.62290677e-01f, -1.96530893e-02f, 1.16925277e-01f, 9.54366382e-03f, 2.70077176e-02f, 6.30304124e-03f, 2.41644811e-02f, -3.60843390e-02f, -2.55219527e-02f, -4.51985337e-02f,
  3.54680344e-02f, 2.11443514e-01f, 1.10037185e-01f, 1.12096913e-01f, 9.86561403e-02f, -5.04770502e-02f, -1.40515119e-01f, -6.88730851e-02f, -7.17192590e-02f, 1.60300136e-02f,
  6.33050203e-02f, 1.12899721e-01f, -5.98771647e-02f, -1.68871880e-02f, -5.28298877e-02f, -1.10600501e-01f, 2.82912944e-02f, 4.13623191e-02f, -8.15910622e-02f, 1.18146334e-02f,
  7.55368918e-02f, 1.53114825e-01f, 4.59881052e-02f, 4.97026518e-02f, 1.69977341e-02f, 1.09640509e-01f, 5.57073951e-02f, 8.18536878e-02f, 4.60718619e-03f, 8.40816051e-02f,
  4.50366765e-01f, 6.30020425e-02f, 5.68870902e-01f, 2.77747847e-02f, 3.26282203e-01f, -2.58408040e-01f, -2.38828823e-01f, 1.82002351e-01f, 3.76745045e-01f, -1.28743798e-01f,
  -1.81131512e-01f, 6.76947385e-02f, -2.08732739e-01f, -9.54257101e-02f, -5.32551289e-01f, -3.74137312e-01f, -4.16982949e-01f, -2.90805608e-01f, 1.00465640e-01f, 2.51948014e-02f,
  -2.77073923e-02f, -4.18666542e-01f, -9.41859856e-02f, -6.31812364e-02f, 2.38535121e-01f, 1.17407165e-01f, -3.20362896e-01f, -4.13970947e-02f, -7.35158026e-02f, 5.59569113e-02f,
  3.98017988e-02f, 1.40518904e-01f, -3.78701612e-02f, 3.96084636e-02f, -8.07898864e-02f, -1.34755865e-01f, -1.45545557e-01f, -5.06584570e-02f, 1.18260875e-01f, 4.80064824e-02f,
  1.87022053e-02f, -5.82677610e-02f, -1.28055170e-01f, -7.31971413e-02f, 7.96421766e-02f, 1.95963189e-01f, 1.53524354e-01f, 9.12049115e-02f, 8.91904384e-02f, 1.58646435e-01f,
  8.10784250e-02f, 1.55372182e-02f, -1.52334524e-02f, -3.70090865e-02f, 5.67671731e-02f, -1.57349240e-02f, 6.50197119e-02f, -1.18907606e-02f, 7.40144178e-02f, 1.37831047e-01f,
  -2.79432144e-02f, -1.79963470e-01f, 1.19699366e-01f, 4.02694494e-02f, 2.38996707e-02f, 1.72940359e-01f, -6.94008619e-02f, -1.17158934e-01f, 3.13978605e-02f, -5.82108460e-02f,
  8.28564540e-02f, -1.17133996e-02f, 1.15098529e-01f, 7.35455900e-02f, -8.51523280e-02f, 9.71591249e-02f, -1.34437025e-01f, -2.09977608e-02f, -3.41562554e-02f, -7.15259761e-02f,
  -1.57663263e-02f, -1.43845603e-01f, 8.65707621e-02f, 1.70032319e-04f, -8.22500139e-02f, 1.77398813e-03f, -8.73154774e-03f, 1.49527282e-01f, 8.12138524e-03f, -8.37732479e-02f,
  -8.86818886e-01f, -5.56640685e-01f, -6.33742288e-02f, 5.76795414e-02f, -3.13208774e-02f, 9.18833539e-02f, -5.30589670e-02f, 1.44482449e-01f, -1.57334477e-01f, 7.68315718e-02f,
  1.10419691e-01f, 1.11444024e-02f, -8.43177512e-02f, -1.48196891e-02f, -1.67851090e-01f, -2.94477046e-02f, -1.20806240e-01f, -2.84760982e-01f, -1.80596873e-01f, -3.92890312e-02f,
  8.83661996e-05f, -1.16509274e-01f, 8.16744268e-02f, -3.65641266e-02f, -1.01735711e-01f, -2.65623406e-02f, -1.02144796e-02f, -2.77863489e-03f, -1.64392903e-01f, -6.62311465e-02f,
  -9.24354792e-01f, 1.89657640e-02f, -3.25516999e-01f, 1.16203301e-01f, -3.04639339e-01f, -4.94095057e-01f, -6.06787801e-02f, -2.19770297e-01f, 1.46939121e-02f, 4.28648204e-01f,
  9.64214802e-02f, 3.63022350e-02f, 2.44566470e-01f, 2.69754883e-02f, -5.63662350e-01f, 9.39382985e-02f, -3.09903264e-01f, -2.86227614e-02f, -1.13970719e-01f, -3.78874123e-01f,
  -2.35302001e-01f, 2.92289965e-02f, -6.02610409e-02f, -6.84716329e-02f, -2.50644296e-01f, -3.49987149e-02f, 2.76478350e-01f, 2.16885991e-02f, 6.96532894e-04f, 1.55188367e-02f,
  -2.89501905e-01f, 1.48653924e-01f, -1.25510782e-01f, 2.33498011e-02f, -3.37929964e-01f, -1.61064550e-01f, 2.27101333e-02f, -7.63408989e-02f, 4.81695421e-02f, -8.63397121e-02f,
  -1.22099780e-01f, -5.24473675e-02f, -5.00804894e-02f, 1.08746737e-01f, -2.81143561e-02f, -7.63236731e-02f, -2.73424443e-02f, 6.19535111e-02f, 5.65986568e-03f, -6.46284446e-02f,
  7.40684196e-02f, 4.08604145e-02f, 5.96000999e-02f, 1.00653823e-02f, 2.36449894e-02f, 5.73099740e-02f, 1.01609677e-01f, -2.52647027e-02f, -5.01775853e-02f, -1.31399885e-01f,
  -1.29698828e-01f, -1.44522479e-02f, 1.48535907e-01f, -7.86509588e-02f, -2.46898346e-02f, 8.12249109e-02f, 1.45334555e-02f, 5.83640151e-02f, 2.92884298e-02f, 6.62766257e-03f,
  1.92151649e-03f, -1.16015587e-03f, 1.03875987e-01f, -6.31087348e-02f, -6.44925684e-02f, -5.46771139e-02f, 1.09375734e-02f, -4.82461527e-02f, 2.15787534e-02f, 5.69584370e-02f,
  3.70356962e-02f, 5.60998218e-03f, 1.39323592e-01f, 4.80029248e-02f, -1.55007113e-02f, 1.94845125e-02f, -7.35310391e-02f, 1.64824184e-02f, 7.32687116e-02f, 2.67032739e-02f,
  -2.91004986e-01f, -2.49946386e-01f, 1.56367011e-02f, -1.97042674e-02f, -6.71237195e-03f, -1.08721167e-01f, 2.87932027e-02f, -7.52501786e-02f, 1.58548243e-02f, -2.31022611e-01f,
  -2.92450786e-02f, 6.91535845e-02f, -6.25066534e-02f, 2.96446308e-02f, 3.19393761e-02f, -8.12923610e-02f, 8.34261160e-03f, -2.97917053e-02f, -1.16140343e-01f, -4.72759940e-02f,
  6.52343407e-02f, 5.91703970e-03f, 8.25229138e-02f, 1.51077071e-02f, 1.85055450e-01f, 4.74309921e-02f, -1.09866992e-01f, -7.26394430e-02f, -1.17096290e-01f, -1.15529753e-01f,
  4.03687030e-01f, 2.57487208e-01f, 5.17817318e-01f, 3.57451707e-01f, -3.54195833e-01f, 1.82171762e-01f, 2.22710371e-01f, -9.27951485e-02f, 4.58625257e-01f, 3.22871692e-02f,
  -2.83318371e-01f, 5.74805737e-01f, 7.46214464e-02f, 1.12406546e-02f, -4.06383015e-02f, -9.31461230e-02f, 1.17098689e-01f, 1.25938043e-01f, 9.17873606e-02f, 2.11223945e-01f,
  7.62400627e-02f, -4.72941667e-01f, -1.29785582e-01f, -5.56169868e-01f, 3.78294289e-02f, 6.27939478e-02f, -5.84021449e-01f, -2.76736557e-01f, -1.64735332e-01f, -2.20400825e-01f,
  -5.51895984e-02f, 4.05102931e-02f, 7.14017078e-02f, 1.68292016e-01f, -2.76558325e-02f, -4.76444028e-02f, 3.84424776e-02f, -7.84655809e-02f, 1.94365531e-01f, 2.50188913e-02f,
  7.48288408e-02f, 1.77601382e-01f, 2.15910319e-02f, -9.16000679e-02f, -5.64409308e-02f, 5.28196841e-02f, 1.86605960e-01f, 2.92955972e-02f, 1.53098047e-01f, 1.24206670e-01f,
  9.36371312e-02f, 1.23264581e-01f, 1.63920745e-01f, 4.00621928e-02f, 3.69944535e-02f, 1.25420898e-01f, 1.39102370e-01f, 3.53583731e-02f, 3.61173935e-02f, -2.11184565e-02f,
  -2.01885849e-01f, -7.28871301e-02f, 3.84870614e-03f, -5.98672852e-02f, -8.97115842e-03f, -1.82745665e-01f, -4.27344404e-02f, -1.29134610e-01f, 1.45031497e-01f, -5.35463579e-02f,
  -6.57026609e-03f, -5.02728410e-02f, -4.95336019e-03f, 5.52758276e-02f, -1.30994990e-03f, -4.92953882e-03f, -3.68607789e-02f, 4.90534268e-02f, -3.13177891e-02f, 3.34950797e-02f,
  4.19013435e-03f, 4.35934849e-02f, -1.05449200e-01f, -1.23440050e-01f, 3.19470987e-02f, -2.22255178e-02f, 9.31289792e-02f, 1.24273501e-01f, -4.61712852e-03f, -5.34932576e-02f,
  -2.67476980e-02f, 1.08386509e-01f, -6.82638288e-02f, 9.41648409e-02f, -5.00938185e-02f, -7.24758022e-03f, -4.74333242e-02f, 5.73579408e-02f, 6.41219988e-02f, -5.04007079e-02f,
  -2.22860146e-02f, 3.91478352e-02f, 1.32920638e-01f, -8.63294974e-02f, 8.51007737e-03f, 1.71259157e-02f, 1.10583551e-01f, -1.67273898e-02f, -4.30575944e-02f, -7.83551261e-02f,
  -1.65865745e-03f, 4.83494848e-02f, 2.22411714e-02f, -8.12398195e-02f, 2.80406838e-03f, -2.57077813e-02f, 1.33894123e-02f, 1.86356343e-02f, -1.01611435e-01f, 9.43586305e-02f,
  -1.11370444e-01f, -3.14803928e-01f, 2.99568832e-01f, -3.44620198e-01f, -1.49768099e-01f, -1.43616885e-01f, 5.50179705e-02f, -3.82820040e-01f, -3.04402173e-01f, -1.55131519e-01f,
  -1.20720737e-01f, 1.96491718e-01f, 4.95834798e-01f, -2.47090220e-01f, 6.50444031e-01f, 4.04527217e-01f, -1.86973780e-01f, -4.41243723e-02f, -1.24196835e-01f, -4.10189480e-01f,
  -5.48210107e-02f, -3.73247713e-01f, 2.90524393e-01f, -3.64409447e-01f, -9.24228802e-02f, -2.73201257e-01f, 1.84714392e-01f, 8.99277702e-02f, -2.69487053e-01f, 1.18687078e-01f,
  -2.71078587e-01f, -3.07181269e-01f, -7.66706020e-02f, 4.34162393e-02f, -1.57674491e-01f, 2.69393306e-02f, 9.00661796e-02f, 1.93059221e-01f, -1.11331448e-01f, 2.51522679e-02f,
  1.05880678e-01f, 5.34993857e-02f, -1.40702546e-01f, 4.14771847e-02f, -1.76229164e-01f, -1.54976308e-01f, 9.84506682e-02f, -2.48095039e-02f, -7.34155253e-02f, 1.13562144e-01f,
  1.08297735e-01f, -4.61369045e-02f, -5.91563582e-02f, -1.34624401e-02f, 2.88293548e-02f, -5.85542992e-02f, 6.41797110e-02f, 2.19035849e-01f, 1.00330813e-02f, -8.36477876e-02f,
  -8.48689601e-02f, -1.03929557e-01f, -3.40434536e-02f, -1.31046414e-01f, -1.22029841e-01f, -1.16132744e-01f, -2.20220368e-02f, 3.55874375e-02f, 1.45307574e-02f, -1.77749582e-02f,
  -1.14986956e-01f, -8.20242316e-02f, -1.24939822e-01f, -4.36150953e-02f, -5.97598106e-02f, -6.40437379e-02f, 5.23244180e-02f, 6.38847649e-02f, -3.04719433e-03f, 4.10851613e-02f,
  3.69594991e-02f, 1.21491536e-01f, 7.15289861e-02f, 7.92056397e-02f, -1.17253438e-01f, 1.04286008e-01f, 2.22958233e-02f, 7.68581554e-02f, -4.40536141e-02f, 1.10711202e-01f,
  -9.04615298e-02f, -3.81355077e-01f, -4.01715785e-02f, -3.42905298e-02f, 4.42772266e-03f, 1.62753891e-02f, -1.35980487e-01f, -1.46456897e-01f, -8.58846232e-02f, -3.77823003e-02f,
  -1.36037901e-01f, 1.40031502e-01f, -9.20132548e-02f, 4.81312722e-02f, -5.17808460e-02f, -4.37870249e-02f, 1.43326540e-02f, 3.01499218e-02f, -1.86674118e-01f, -9.34583247e-02f,
  3.35105881e-02f, 7.50350431e-02f, 1.80956036e-01f, -1.22663014e-01f, -3.48675661e-02f, 7.11169690e-02f, -9.87157226e-02f, -5.51239736e-02f, 1.76528990e-01f, 3.74376550e-02f,
  2.57709771e-01f, 6.71331957e-02f, -4.98658955e-01f, -7.82456920e-02f, -1.10891186e-01f, 6.08517468e-01f, 3.19845319e-01f, -2.39125043e-01f, -3.84530365e-01f, 4.02202547e-01f,
  2.69319803e-01f, -8.97112265e-02f, -1.25403181e-01f, 4.50738043e-01f, 7.29170144e-02f, 4.87750396e-02f, 5.61903656e-01f, 2.54826188e-01f, -3.69294852e-01f, 1.11624874e-01f,
  -2.48594433e-01f, 5.10762870e-01f, -1.52641386e-01f, 3.62720452e-02f, 2.06702650e-01f, -4.34868157e-01f, -3.11716087e-03f, -2.99457282e-01f, 2.88347065e-01f, 2.05787405e-01f,
  3.29010151e-02f, -3.52322171e-03f, -9.11846012e-02f, -1.87894050e-02f, 6.46416396e-02f, 2.23685447e-02f, 4.39626165e-02f, 9.22911093e-02f, -2.12537527e-01f, -1.09503292e-01f,
  3.19184177e-02f, -8.91291574e-02f, 8.15073785e-04f, -8.48488435e-02f, -5.24019562e-02f, -1.19993269e-01f, -1.72856510e-01f, 1.59399733e-02f, -6.18016832e-02f, 6.08994290e-02f,
  -1.42871782e-01f, -1.39023617e-01f, -1.04966223e-01f, 2.65786238e-03f, -2.41450623e-01f, -2.25522574e-02f, 1.49359018e-01f, -1.72431041e-02f, -1.27310306e-03f, -1.13223372e-02f,
  8.86630565e-02f, 9.05064959e-03f, 2.25612503e-02f, 9.15325582e-02f, 1.66660186e-03f, -2.72109006e-02f, 8.60083848e-02f, -2.65792856e-04f, -7.89040327e-02f, 9.50906202e-02f,
  -5.34176752e-02f, -5.13628908e-02f, 3.11265774e-02f, -2.96527110e-02f, 1.58824503e-01f, 2.76470883e-03f, -1.57254636e-02f, 1.56459048e-01f, -2.65058912e-02f, -5.88263124e-02f,
  -5.67277595e-02f, -7.66936541e-02f, -2.12098844e-02f, -1.09206187e-02f, 4.45858091e-02f, -1.93775892e-01f, 3.53255644e-02f, 1.04981763e-02f, -6.43406957e-02f, 7.57484185e-03f,
  2.95052510e-02f, 2.15536039e-02f, 7.33076874e-03f, 1.43239452e-02f, -2.53304765e-02f, 1.17221773e-01f, 1.68227833e-02f, 1.11822002e-01f, -4.43381146e-02f, 1.02380581e-01f,
  1.69263184e-01f, -3.55668068e-02f, -1.10366464e-01f, -2.57294951e-03f, -8.81296769e-02f, 1.81193307e-01f, 6.69736788e-02f, -1.27643928e-01f, -7.67536312e-02f, 9.07819569e-02f,
  1.05692800e-02f, 6.50625005e-02f, -5.14836684e-02f, -6.03857413e-02f, 4.84949239e-02f, 5.02431132e-02f, -6.23622723e-02f, 4.65735458e-02f, -7.50628114e-02f, 8.49574525e-03f,
  -1.03737879e+00f, 6.04469717e-01f, 5.00006557e-01f, -4.53587919e-01f, -1.82675853e-01f, 5.33855438e-01f, 1.07069463e-01f, 2.23190725e-01f, 5.92933930e-02f, 7.69240484e-02f,
  -2.50872821e-01f, -1.57540604e-01f, 4.50390764e-02f, -5.47105111e-02f, 1.04010269e-01f, 2.11207852e-01f, 9.67728645e-02f, -1.38264880e-01f, 2.07746811e-02f, -8.81808922e-02f,
  -5.32486513e-02f, -1.49735332e-01f, 4.37321886e-03f, 9.59721580e-03f, -2.02999815e-01f, -4.31929082e-02f, -2.79363543e-01f, 5.99069335e-02f, -2.07441464e-01f, 1.15654774e-01f,
  -5.30891895e-01f, -2.71854430e-01f, -2.80197978e-01f, 1.95197850e-01f, -1.07637942e-02f, -1.40033305e-01f, 1.03682116e-01f, -4.84565198e-02f, -1.30325213e-01f, -3.70335802e-02f,
  -1.45883620e-01f, -3.42424475e-02f, -6.18307330e-02f, 6.46214262e-02f, -1.55998245e-02f, -6.72792792e-02f, 8.53276774e-02f, -6.04648180e-02f, -1.65704027e-01f, -1.41446620e-01f,
  1.53852794e-02f, 2.65477062e-03f, -1.14913866e-01f, 1.84124663e-01f, 1.45824114e-02f, 1.44846840e-02f, 2.67125010e-01f, -7.80054554e-02f, 3.41839828e-02f, 9.47175100e-02f,
  1.33588776e-01f, -4.59522475e-03f, 8.59816968e-02f, 9.07690451e-03f, -7.21390471e-02f, -1.54278260e-02f, -9.13786069e-02f, -1.38576597e-01f, 6.83495915e-03f, -3.17152366e-02f,
  2.86689624e-02f, -8.73593315e-02f, 4.63063829e-03f, -7.67435180e-03f, 1.93465909e-03f, 5.61292060e-02f, -6.45090714e-02f, -1.31026506e-01f, -3.53521071e-02f, -8.62704813e-02f,
  -1.09229358e-02f, 1.45478006e-02f, -6.43390194e-02f, 5.25487810e-02f, -1.77510872e-01f, -1.33513734e-01f, -7.38617629e-02f, -1.32654637e-01f, -5.03523834e-02f, -3.12205665e-02f,
  4.04322259e-02f, 2.05090135e-01f, -2.70912290e-01f, -8.23501125e-02f, 2.46897340e-02f, -1.46268427e-01f, 2.80009340e-02f, -1.93669796e-02f, 2.52168439e-02f, 1.92875057e-01f,
  4.58123442e-03f, -9.46688727e-02f, 6.83603063e-02f, -3.30934078e-02f, 5.99453263e-02f, -3.91760804e-02f, -3.81423496e-02f, 5.68177328e-02f, -7.27246404e-02f, -6.65634274e-02f,
  -4.45334204e-02f, -5.66005334e-02f, 4.69654873e-02f, -1.40624180e-01f, -5.04851453e-02f, -1.14096761e-01f, -1.87256895e-02f, 7.49039557e-03f, -1.02744393e-01f, 1.51478991e-01f,
  -1.82277486e-02f, 5.01653314e-01f, 2.10707173e-01f, 9.62993652e-02f, -4.62877750e-02f, -4.31545287e-01f, -4.44094211e-01f, 1.37058705e-01f, -6.17896497e-01f, 3.02197546e-01f,
  4.12109829e-02f, 1.57335997e-01f, -7.53073767e-02f, -2.73821563e-01f, -5.60745955e-01f, -5.93924999e-01f, -2.70413339e-01f, 1.37437601e-02f, -2.96019197e-01f, 4.44837809e-01f,
  -2.09021429e-03f, -1.10462248e-01f, 1.53547734e-01f, 2.59329379e-01f, 2.21046969e-01f, 6.36616290e-01f, 3.99808526e-01f, 1.48147255e-01f, 4.27165329e-01f, -2.29633152e-01f,
  -3.28725725e-01f, -1.23295948e-01f, 1.55772015e-01f, -4.72943522e-02f, 2.22327054e-01f, 2.42315978e-01f, 9.76345837e-02f, -1.91277459e-01f, 1.03398096e-02f, -5.24659865e-02f,
  6.50074407e-02f, -5.93274236e-02f, -1.44493923e-01f, 3.30325924e-02f, -1.31467566e-01f, 8.81891474e-02f, 1.85485035e-02f, -1.60236768e-02f, 8.30082968e-02f, 3.44067849e-02f,
  4.26221415e-02f, 8.81189629e-02f, 1.64916992e-01f, 4.20915000e-02f, 9.77431312e-02f, -7.77224302e-02f, 7.96907954e-03f, 1.62246898e-01f, -1.65289715e-01f, -4.29384150e-02f,
  4.35562842e-02f, -3.49373743e-02f, -3.40900123e-02f, -1.95478231e-01f, -8.91672149e-02f, -7.36861452e-02f, 1.80923997e-03f, 3.21258269e-02f, -1.13662235e-01f, -2.13017240e-02f,
  1.62269883e-02f, 3.35465930e-02f, -2.82002300e-01f, 6.18576892e-02f, 3.72675061e-02f, 4.20382321e-02f, 2.15384718e-02f, 1.02994539e-01f, 1.05815426e-01f, 2.56816447e-02f,
  -1.19129181e-01f, -3.68380100e-02f, 6.95777461e-02f, 1.23872934e-02f, -1.14549711e-01f, 2.23404944e-01f, -1.48311481e-02f, -3.77162918e-02f, 3.07559762e-02f, 3.42499800e-02f,
  1.79467127e-01f, 1.97065562e-01f, -4.32529487e-02f, -1.42244101e-01f, -8.88638049e-02f, -1.53388560e-01f, -1.91950843e-01f, 5.32193892e-02f, 1.03720531e-01f, -8.88995677e-02f,
  2.64110804e-01f, 2.98627801e-02f, -7.90219940e-03f, 5.50723672e-02f, -2.35038437e-02f, 2.71952227e-02f, 4.09802981e-02f, 1.28670171e-01f, 1.05025947e-01f, 2.06444919e-01f,
  2.58629262e-01f, 3.56117939e-03f, -1.02385759e-01f, -2.49114148e-02f, 5.53963892e-02f, 1.26451418e-01f, 2.74553485e-02f, 1.98364437e-01f, 1.59455359e-01f, 4.49561328e-03f,
  5.56482971e-01f, -4.17417079e-01f, 1.69584677e-01f, 5.68629682e-01f, 2.20333323e-01f, -1.39985770e-01f, -2.07296744e-01f, 3.70931238e-01f, 2.61660784e-01f, -4.14800227e-01f,
  1.10096492e-01f, -1.46638170e-01f, -5.03907979e-01f, 3.94412726e-01f, 2.79266000e-01f, -2.49799997e-01f, 2.96643078e-01f, 1.31859139e-01f, 3.12851630e-02f, 5.49852178e-02f,
  4.38011795e-01f, 4.72219139e-01f, 2.99188375e-01f, 1.81733698e-01f, 2.01619372e-01f, 1.70647666e-01f, 2.51752920e-02f, -2.53698528e-01f, 3.53648841e-01f, 1.14071108e-02f,
  -9.37403664e-02f, 4.64081541e-02f, 1.79668760e-03f, -1.97561771e-01f, -1.37318950e-02f, -1.55841231e-01f, -2.07770839e-01f, -1.11396089e-01f, -7.86808971e-03f, 3.62644903e-02f,
  -1.24718115e-01f, 1.53877035e-01f, 1.56401411e-01f, -4.04748619e-02f, -7.26322308e-02f, 1.32889524e-01f, 1.16872057e-01f, 3.58705013e-03f, -2.36018579e-02f, 3.05978134e-02f,
  7.64870867e-02f, 7.86635466e-03f, 8.75702966e-03f, 4.41959240e-02f, -3.01055983e-03f, 8.46029222e-02f, 5.39918877e-02f, -6.06486239e-02f, -1.60265043e-02f, 8.97865370e-02f,
  2.77661532e-02f, -1.28763869e-01f, -7.41154328e-02f, -2.84792278e-02f, 1.55815212e-02f, 9.75662097e-02f, -2.31068023e-02f, -5.69839589e-02f, -1.07835270e-01f, -1.00371558e-02f,
  5.49586602e-02f, 8.48011002e-02f, -2.61874311e-03f, 4.93801683e-02f, -2.58030798e-02f, -5.03542349e-02f, -2.20706686e-02f, 2.74996161e-02f, -8.10406208e-02f, 1.85575098e-01f,
  -3.89723331e-02f, -6.39599264e-02f, -1.21368326e-01f, -7.60824932e-03f, 7.61695132e-02f, -4.73585278e-02f, -5.45627177e-02f, -4.29964662e-02f, -3.84744927e-02f, -1.78964697e-02f,
  -5.73364735e-01f, -1.40600264e-01f, -1.58447772e-01f, -9.03985724e-02f, -4.13419195e-02f, -1.20155066e-02f, 1.24429747e-01f, 2.71103438e-02f, -1.47068828e-01f, 6.73988014e-02f,
  -1.13326758e-01f, 3.04965228e-02f, -4.37019952e-02f, 1.05334140e-01f, -5.66964447e-02f, 6.69655353e-02f, -7.00128153e-02f, -3.13416384e-02f, -3.40686105e-02f, -4.16735467e-03f,
  1.17606837e-02f, -2.94119325e-02f, -1.10141486e-02f, 3.46776582e-02f, -3.34954485e-02f, 6.70471936e-02f, 1.42053068e-01f, -5.16053848e-03f, 6.50544390e-02f, -5.78994378e-02f,
  -6.11760616e-01f, 2.17759043e-01f, -4.31631029e-01f, -3.35774034e-01f, -3.22406977e-01f, -5.81547022e-01f, -4.32558149e-01f, -3.15660506e-01f, -6.35911673e-02f, 5.04941083e-02f,
  2.63555907e-03f, 1.05850920e-01f, 2.66319066e-01f, -9.56482813e-02f, -1.60891801e-01f, 3.27146441e-01f, -2.50511855e-01f, -2.06728086e-01f, 2.53663898e-01f, -2.38632128e-01f,
  -1.16921455e-01f, -1.90861478e-01f, 2.28670612e-02f, -4.51889895e-02f, -2.72778958e-01f, -8.54829103e-02f, -1.69210341e-02f, -5.77477319e-03f, -1.06908686e-01f, -5.09799924e-03f,
  -3.20062220e-01f, -2.33244240e-01f, -3.46666425e-02f, -3.93270962e-02f, -1.82395309e-01f, -1.46042526e-01f, -3.75819094e-02f, -2.49917358e-02f, -1.06701627e-01f, 3.85449152e-03f,
  5.85526712e-02f, 1.66248623e-02f, 1.05937505e-02f, -1.38225164e-02f, -7.26259798e-02f, -2.17729788e-02f, 3.33706029e-02f, 3.75180207e-02f, 3.65661643e-02f, 1.14403404e-01f,
  4.21168096e-02f, 4.34356593e-02f, -1.29295036e-01f, 4.17196564e-02f, -2.01047342e-02f, -9.06004831e-02f, -2.01295912e-02f, 2.40533669e-02f, -9.75461155e-02f, -1.42701939e-01f,
  7.71621987e-02f, 1.13358013e-01f, -7.22821951e-02f, -1.72701944e-02f, -6.96183071e-02f, -3.14797573e-02f, -1.83587149e-01f, -1.62996873e-02f, 1.46109909e-01f, 6.23280890e-02f,
  3.39630730e-02f, -1.15565725e-01f, -3.41718383e-02f, -6.47293553e-02f, 9.98699442e-02f, -7.21284673e-02f, 4.11922447e-02f, -2.35377867e-02f, 5.79081289e-02f, -3.76897939e-02f,
  -1.87717248e-02f, -4.69835885e-02f, -6.91780001e-02f, 3.12642707e-03f, -6.03047125e-02f, 9.58933979e-02f, 5.77861853e-02f, -6.94548562e-02f, -6.70940727e-02f, -1.02471486e-01f,
  -6.49288714e-01f, -5.87071896e-01f, 6.74955621e-02f, -1.76877961e-01f, -1.27441492e-02f, -9.69637409e-02f, 8.83675292e-02f, 1.22220524e-01f, -2.93409098e-02f, -7.80510828e-02f,
  -3.60903107e-02f, -5.48951738e-02f, -1.32965133e-01f, -2.46052556e-02f, 9.79770795e-02f, -6.29234388e-02f, 2.43318472e-02f, 3.91021967e-02f, -1.32583469e-01f, -1.19975014e-02f,
  -1.04887791e-01f, -4.02340144e-02f, 1.79877765e-02f, 2.81973910e-02f, -7.95914084e-02f, -6.95670620e-02f, -1.12934513e-02f, 1.78029567e-01f, -1.48213431e-01f, -4.91270213e-04f,
  3.32901418e-01f, -1.65021345e-01f, 1.13503955e-01f, 1.68247193e-01f, -1.60604522e-01f, -3.84274513e-01f, -6.18666410e-01f, 1.37319446e-01f, -2.50442088e-01f, -3.21762890e-01f,
  -5.32984436e-02f, -3.86037789e-02f, -3.51426631e-01f, 3.21270347e-01f, 2.49779299e-01f, -4.67724264e-01f, 1.68573439e-01f, -4.54809777e-02f, -3.47365737e-01f, 8.99297819e-02f,
  2.40241751e-01f, 3.02401155e-01f, 4.04358178e-01f, 5.64737499e-01f, 1.92121848e-01f, 4.24585253e-01f, 4.56132919e-01f, -1.21945171e-02f, 5.20129383e-01f, 1.95407107e-01f,
  -6.91343993e-02f, -5.41015752e-02f, 5.12725823e-02f, 1.61274940e-01f, -7.10314661e-02f, 1.50798649e-01f, -4.27450091e-02f, -4.63391282e-02f, 2.22810432e-02f, -3.67059112e-02f,
  -7.22975954e-02f, 1.03508711e-01f, 3.34550738e-02f, 7.73472190e-02f, 1.13240764e-01f, 3.31618339e-02f, 3.41386385e-02f, -1.66310538e-02f, -8.91526565e-02f, -3.18986960e-02f,
  -6.80207387e-02f, 3.30520198e-02f, 3.09569072e-02f, 4.83591445e-02f, 9.61348116e-02f, 3.71323936e-02f, 3.98862287e-02f, -6.27790242e-02f, 8.48829076e-02f, 1.74529608e-02f,
  7.27868080e-02f, -9.98107865e-02f, 1.86537765e-02f, -9.23512280e-02f, -7.81399664e-03f, -1.23434514e-01f, 1.09773148e-02f, 1.84475761e-02f, -2.26026736e-02f, 3.25354300e-02f,
  -3.39281447e-02f, 5.00470772e-02f, -1.44242076e-02f, -6.33324357e-03f, 7.65137225e-02f, -3.33118737e-02f, -1.73831824e-02f, 4.33164872e-02f, -4.44680229e-02f, -1.71097666e-01f,
  -1.38309076e-01f, 1.07833883e-02f, -4.01734896e-02f, -4.82587051e-03f, 3.49976383e-02f, 4.77348045e-02f, 2.40951315e-01f, 1.18695319e-01f, -1.17067993e-01f, -1.05104700e-01f,
  5.27364612e-02f, 9.68796238e-02f, -6.02791049e-02f, 3.79728042e-02f, -2.08218694e-01f, -8.64955932e-02f, -2.75772605e-02f, 1.33142009e-01f, 1.65625960e-01f, -1.71540044e-02f,
  1.41561195e-01f, 1.38189374e-02f, -1.42868292e-02f, 9.54243317e-02f, 2.56685466e-01f, -5.47086261e-02f, 6.77276263e-03f, 3.45675424e-02f, 1.15261570e-01f, 8.74926522e-02f,
  -2.06215959e-02f, -2.99386829e-01f, 1.80245861e-01f, -8.52403268e-02f, 3.06516364e-02f, -1.14834972e-01f, -5.65902665e-02f, 1.46429881e-01f, 7.63742998e-02f, 8.13483819e-03f,
  -4.31933641e-01f, 6.10698342e-01f, -1.35026127e-01f, 4.57746297e-01f, -2.98587501e-01f, 1.59964740e-01f, 1.18175685e-01f, 2.18755588e-01f, -3.07869837e-02f, 3.36917281e-01f,
  3.48300993e-01f, -1.29085869e-01f, 4.58417714e-01f, 3.76303524e-01f, 1.17523246e-01f, 5.12033999e-01f, 4.18590248e-01f, 2.67525822e-01f, 7.54317045e-02f, 3.66460621e-01f,
  2.62678206e-01f, 3.22127014e-01f, 4.97216165e-01f, 1.40648276e-01f, 1.01250480e-03f, 1.69550516e-02f, 2.56142080e-01f, -1.55038938e-01f, 2.17444971e-01f, -7.05622509e-02f,
  7.89247230e-02f, 4.33850326e-02f, -1.51686475e-01f, -1.40428573e-01f, -3.96018624e-02f, -6.26543090e-02f, -1.83886476e-02f, -1.96192458e-01f, 7.37335756e-02f, 1.68145806e-01f,
  -1.07866608e-01f, 1.46253733e-04f, 4.58204038e-02f, -1.05066355e-02f, -1.06733613e-01f, -9.32470802e-03f, 2.68476792e-02f, 6.34069815e-02f, 1.81436792e-01f, -4.50447202e-02f,
  3.93072702e-02f, 1.39370963e-01f, 1.75350085e-01f, 8.91281292e-02f, 8.85440130e-03f, 1.07084677e-01f, 1.32558644e-01f, 3.88438739e-02f, 2.87076458e-02f, -3.12755294e-02f,
  4.75067161e-02f, 4.55774851e-02f, -2.35134969e-03f, -7.93581381e-02f, -4.15535457e-02f, -6.97887912e-02f, 8.12263861e-02f, 1.55330719e-02f, -1.45765468e-01f, 7.08956420e-02f,
  -3.32828052e-02f, 2.33392194e-02f, 2.59371847e-02f, 1.03524409e-01f, -2.45094560e-02f, 1.29753407e-02f, -1.10042721e-01f, -1.10486615e-03f, 8.85492098e-03f, -2.03079302e-02f,
  -9.12524834e-02f, -5.04511073e-02f, 4.15956937e-02f, -3.95961199e-03f, 1.25162512e-01f, 9.71008316e-02f, 8.80762562e-02f, 1.47443283e-02f, 1.29356027e-01f, -1.54182231e-02f,
  3.00406218e-01f, 3.28392267e-01f, -3.80781963e-02f, -7.99699649e-02f, -1.30693018e-02f, -2.05681622e-01f, -3.99717921e-03f, 2.33538672e-02f, 1.75801948e-01f, -4.13702689e-02f,
  6.49357727e-03f, 6.13712445e-02f, 6.36894628e-02f, -7.66143501e-02f, -3.17911394e-02f, 1.01538800e-01f, 3.07340741e-01f, -4.34570983e-02f, 8.04276764e-02f, 4.55297157e-02f,
  4.35225666e-02f, 3.29909623e-02f, 9.94296893e-02f, -3.04518528e-02f, -2.20244564e-02f, 1.32915646e-01f, -2.45375503e-02f, 8.34236518e-02f, 3.13216336e-02f, 1.15305977e-02f,
  -1.04072952e+00f, 2.60122180e-01f, 5.49089134e-01f, -5.59118271e-01f, 1.72950476e-01f, 2.97050923e-01f, -5.26204892e-02f, -4.95999940e-02f, -4.42434847e-01f, -1.98015407e-01f,
  -1.17253542e-01f, -7.41746426e-02f, 2.96796411e-01f, -2.31896475e-01f, 6.90499842e-02f, 1.06145017e-01f, -2.46203557e-01f, -1.01138309e-01f, 1.56669736e-01f, -1.16916813e-01f,
  6.30167946e-02f, -1.03329614e-01f, 3.67694139e-01f, 9.53922570e-02f, 8.25745314e-02f, -9.15183052e-02f, -5.59680089e-02f, 3.02642167e-01f, 3.01038399e-02f, 1.36226743e-01f,
  -7.79768899e-02f, -2.90449023e-01f, 1.36951804e-01f, 1.12821013e-01f, -9.59514901e-02f, 1.27990648e-01f, -2.86494698e-02f, 1.45946339e-01f, 9.80237201e-02f, -9.04704928e-02f,
  -6.95948005e-02f, 2.38054199e-03f, -1.50157467e-01f, 5.20062968e-02f, 2.55547874e-02f, 1.99318960e-01f, 1.24249391e-01f, 4.90955897e-02f, 1.09744206e-01f, 2.70274192e-01f,
  1.93343550e-01f, 5.03147393e-02f, -1.82891414e-02f, -9.55688879e-02f, 1.78486884e-01f, 1.07273534e-02f, -1.25004143e-01f, -1.08019672e-02f, -3.65933031e-02f, -1.40996203e-01f,
  6.43289685e-02f, 6.66681752e-02f, 2.55650990e-02f, 8.02349150e-02f, -1.48361465e-02f, -6.99138492e-02f, -2.86987354e-03f, -9.42106843e-02f, 2.48865224e-02f, -6.34768382e-02f,
  -1.27932876e-01f, -9.89728235e-03f, -1.08607657e-01f, -4.61988822e-02f, -9.08142775e-02f, -9.24975947e-02f, 1.33643374e-01f, 1.28326789e-01f, -1.26222506e-01f, -1.40723720e-01f,
  3.30429487e-02f, -5.03300689e-02f, -9.30324662e-03f, 6.35452569e-02f, 1.10676229e-01f, 1.06004409e-01f, -3.25445160e-02f, 8.60794112e-02f, 5.95371649e-02f, -3.03230062e-02f,
  -7.11825415e-02f, -4.46224332e-01f, 1.05639406e-01f, -2.60454994e-02f, -1.14857033e-01f, 8.49992111e-02f, 6.97828904e-02f, 1.59164965e-01f, -1.20985053e-01f, -3.65688764e-02f,
  -1.23595009e-02f, -1.04321301e-01f, -4.24607955e-02f, 1.70218255e-02f, -1.18228141e-02f, 4.26357388e-02f, -9.35754851e-02f, -8.78629833e-02f, 1.80691127e-02f, 5.11898249e-02f,
  -4.38027270e-02f, -9.96406674e-02f, -1.07956842e-01f, -6.45816326e-02f, -7.34999403e-02f, -7.53469300e-03f, -1.32926464e-01f, 3.56748290e-02f, -2.57930569e-02f, 3.06416508e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.87756097e-01f, 1.75664052e-01f, 5.23679256e-01f, 2.15473682e-01f, 5.00481069e-01f, 2.02794060e-01f, 3.03891450e-01f, 8.05933475e-01f, 8.28537524e-01f, 2.35782847e-01f,
  4.03079018e-02f, 1.20804630e-01f, 2.79384464e-01f, 4.40160543e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.50404498e-01f, 1.99634343e-01f, 3.94979529e-02f, 5.21893561e-01f, -1.68437615e-01f, 3.21128219e-01f, -3.54900897e-01f, 3.10567375e-02f, 5.09125233e-01f, -2.26503506e-01f,
  -1.81007862e-01f, -2.53930330e-01f, 3.68759453e-01f, -2.37125739e-01f, 9.00957882e-02f, -2.42409125e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  6.99943602e-01f, 9.95191872e-01f, 1.05610073e-01f, 1.31141320e-01f, -5.02553582e-01f, 1.69775516e-01f, 3.98617625e-01f, -3.01800072e-01f, 5.76648235e-01f, 4.81645703e-01f,
  6.67703807e-01f, 1.15185775e-01f, -5.49758613e-01f, 4.04584497e-01f, 2.88335651e-01f, -4.88995999e-01f, 1.53223991e-01f, -3.49808127e-01f, 5.04045844e-01f, -2.86706239e-01f,
  3.15389074e-02f, -8.27287212e-02f, -8.85038301e-02f, 8.61700058e-01f, -3.43251139e-01f, -2.02777863e-01f, 9.61891562e-02f, -1.22533664e-01f, 3.33187521e-01f, -1.10666402e-01f,
  -2.86880493e-01f, 3.47205877e-01f, -3.98681201e-02f, -6.80298448e-01f, 6.19584441e-01f, 1.44192427e-02f, 6.01069629e-01f, -2.03792006e-01f, 3.95357400e-01f, 3.61595631e-01f,
  -5.59129082e-02f, -4.16580498e-01f, -3.88093404e-02f, 4.66168731e-01f, 1.46959662e-01f, 1.12399109e-01f, -5.17269135e-01f, -2.10586525e-02f, -4.72658388e-02f, 5.07295787e-01f,
  2.05747232e-01f, -7.58915663e-01f, -6.27075791e-01f, -5.70977747e-01f, -7.11060643e-01f, -3.26949894e-01f, 7.23531187e-01f, -2.97005355e-01f, 1.45261839e-01f, 4.28302884e-01f,
  -5.00107169e-01f, 8.88929784e-01f, 6.02822118e-02f, -4.03176397e-01f, 5.87192893e-01f, -1.73150629e-01f, -4.92458493e-01f, 7.40309060e-01f, 7.06467986e-01f, 7.31963992e-01f,
  -1.94259062e-01f, -1.85246721e-01f, 8.74644332e-03f, 3.92523199e-01f, 4.18526351e-01f, -4.08919960e-01f, 5.57207227e-01f, -3.07364941e-01f, -1.15436204e-01f, 6.92378700e-01f,
  5.38165450e-01f, -1.06210358e-01f, 6.89905286e-01f, 4.25875366e-01f, -3.98905963e-01f, -4.23528343e-01f, 4.68256205e-01f, 5.57917058e-01f, -2.21655890e-01f, 4.42720503e-01f,
  -7.73124397e-01f, 7.52143702e-03f, -5.95146641e-02f, 1.88089423e-02f, 3.89260091e-02f, 1.59583926e-01f, 9.26358532e-03f, -5.08764625e-01f, 3.65059078e-01f, 1.86690688e-01f,
  -2.57187843e-01f, -4.00733024e-01f, 2.05015659e-01f, 6.00969493e-01f, 2.66419966e-02f, -2.59676218e-01f, 3.68772715e-01f, -1.81462541e-01f, -1.92489132e-01f, -5.02281375e-02f,
  -4.03490901e-01f, -6.00142553e-02f, 1.31823793e-01f, -3.08083873e-02f, 6.91244006e-01f, 6.84451878e-01f, 5.03950238e-01f, 3.92257243e-01f, -2.53470540e-01f, 6.48899615e-01f,
  -4.73928154e-01f, -2.79638618e-01f, -2.70078450e-01f, 7.87697732e-01f, 8.98679972e-01f, 1.39956608e-01f, -6.00513697e-01f, -1.27143979e-01f, 3.02912295e-01f, -5.71608186e-01f,
  3.27791095e-01f, -4.01551664e-01f, 7.47979879e-02f, 1.27082825e-01f, 3.89825284e-01f, 7.35222995e-01f, 7.37864733e-01f, 7.31888294e-01f, 4.19262610e-02f, -1.95419520e-01f,
  1.79616347e-01f, -1.25283852e-01f, 7.44951308e-01f, 7.52742827e-01f, 9.10187587e-02f, 4.63533372e-01f, -3.17690000e-02f, -3.22553635e-01f, -5.60898900e-01f, 7.48304546e-01f,
  -4.86382157e-01f, 1.37076840e-01f, 3.71124268e-01f, -2.22699314e-01f, 1.71295688e-01f, 4.61875573e-02f, 2.63923943e-01f, 4.28744346e-01f, 8.31078768e-01f, -1.86191365e-01f,
  4.99923378e-01f, -2.06429720e-01f, 2.60047436e-01f, -2.76196897e-01f, 4.10442054e-01f, -4.96248275e-01f, 9.37367260e-01f, -3.49145561e-01f, -1.43191695e-01f, 2.38084093e-01f,
  4.72983420e-01f, 6.16774142e-01f, -2.09543303e-01f, 5.34141958e-01f, -5.76312989e-02f, -2.98474878e-01f, 1.41030019e-02f, 3.80709708e-01f, -5.76063812e-01f, 2.21078351e-01f,
  -2.83053398e-01f, 9.74491090e-02f, -6.68861508e-01f, 8.99551287e-02f, -5.71747959e-01f, 3.46186221e-01f, 6.88802540e-01f, -1.86168924e-02f, -2.75407046e-01f, 1.54835761e-01f,
  2.62235820e-01f, 6.62455738e-01f, 1.74620226e-01f, -1.09328590e-01f, -8.85778014e-03f, -8.34272653e-02f, 8.33093345e-01f, 7.29060592e-03f, 4.83905375e-01f, -2.73920238e-01f,
  -6.55206144e-01f, 9.76593941e-02f, 1.03802836e+00f, 2.33215332e-01f, -1.92322925e-01f, 4.04274464e-01f, 6.46898746e-02f, -1.82668015e-01f, 8.23750377e-01f, 1.22354358e-01f,
  -2.53224462e-01f, 3.45255345e-01f, 5.12762785e-01f, 5.84861219e-01f, 1.44074157e-01f, 9.83541757e-02f, 2.40114614e-01f, 7.62665987e-01f, 2.78963059e-01f, -3.82038206e-01f,
  3.41723949e-01f, -1.57988027e-01f, 3.18312317e-01f, 7.46631444e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  5.64432740e-01f, 3.88343036e-01f, 5.99259615e-01f, 3.03342342e-02f, 2.74933577e-01f, 5.91303229e-01f, 5.67255557e-01f, 1.07429111e-02f, 5.25558114e-01f, 5.43359704e-02f,
  3.28276128e-01f, 1.54897884e-01f, 6.76227987e-01f, 7.25112796e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.47137004e-02f, 8.11655149e-02f, 2.32499957e-01f, -1.68924734e-01f, 9.12387222e-02f, 4.81407017e-01f, -1.46064870e-02f, -5.69471065e-03f, -4.09593023e-02f, 7.25175738e-02f,
  -8.92865658e-02f, -3.31793755e-01f, -1.99080661e-01f, -3.51139098e-01f, -1.24963850e-01f, -1.36769712e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -1.62549868e-01f, -9.74047258e-02f, 1.92253903e-01f, 4.33275593e-04f, 2.04703063e-01f, 1.94677323e-01f, 4.88637149e-01f, -2.43931383e-01f, 1.98532879e-01f, 5.40804505e-01f,
  -6.44050241e-01f, 1.84095040e-01f, 5.02906859e-01f, 5.02489746e-01f, 6.15683377e-01f, -9.43532139e-02f, 8.22876096e-02f, -3.71924520e-01f, -7.31067836e-01f, 5.56256413e-01f,
  5.30709684e-01f, -4.99508649e-01f, 5.24125099e-01f, 2.49293864e-01f, 2.36254960e-01f, 6.78845227e-01f, 3.26205075e-01f, -6.66302025e-01f, -1.05204679e-01f, 1.68210536e-01f,
  4.40717340e-01f, 1.71270847e-01f, -2.98284054e-01f, -1.81865722e-01f, -1.72902927e-01f, 7.65652239e-01f, 7.41009772e-01f, 4.13632035e-01f, 7.17374533e-02f, 4.77941960e-01f,
  7.44440317e-01f, 4.12565738e-01f, 1.47090912e-01f, -3.86671394e-01f, 4.20498490e-01f, -8.64633262e-01f, -2.84005757e-02f, -1.69486031e-01f, -3.50369185e-01f, 5.66674411e-01f,
  5.81394792e-01f, -2.30649784e-01f, -4.26517129e-01f, -1.43139020e-01f, 4.19642538e-01f, -3.67716819e-01f, -3.63911241e-01f, -7.57361114e-01f, 7.34785914e-01f, 5.70153058e-01f,
  1.59530863e-01f, 1.67706862e-01f, 5.06079257e-01f, 6.10633969e-01f, 1.79057628e-01f, 4.61877257e-01f, 5.17895162e-01f, 1.66654855e-01f, -2.44156510e-01f, 4.09747273e-01f,
  -8.94455686e-02f, -1.60931766e-01f, 2.50455379e-01f, -4.21826988e-01f, -3.18717211e-01f, 3.73021752e-01f, -2.63930075e-02f, 1.11110532e+00f, 4.95564014e-01f, 1.30087864e-02f,
  -2.34353289e-01f, -6.02456808e-01f, 2.38904014e-01f, -1.05235778e-01f, 2.21793965e-01f, 6.01148069e-01f, -3.20995033e-01f, -3.78832102e-01f, -2.13919133e-01f, 1.85389027e-01f,
  -2.17656165e-01f, 2.86679000e-01f, 7.93791771e-01f, -2.22702265e-01f, 8.22434247e-01f, -2.58011103e-01f, -3.81546944e-01f, -8.36322486e-01f, -4.88740653e-02f, 1.49773002e-01f,
  4.39111382e-01f, 1.95681825e-01f, -6.99693263e-02f, 2.29261398e-01f, -6.55692592e-02f, 6.99994802e-01f, -1.64245665e-01f, 5.57667136e-01f, 2.67625809e-01f, 2.01143743e-03f,
  3.09354067e-01f, -3.82606506e-01f, 1.93939388e-01f, -2.89721876e-01f, -4.44664694e-02f, 7.05233872e-01f, -9.91756245e-02f, -8.13395202e-01f, -2.95204371e-01f, 8.64811182e-01f,
  6.25673771e-01f, 1.83509544e-01f, 6.24132514e-01f, -7.46530071e-02f, -2.25923404e-01f, -2.06465662e-01f, -2.98782408e-01f, 3.06304425e-01f, 2.50047594e-01f, 2.85015136e-01f,
  6.86695635e-01f, -9.76955965e-02f, -2.65606761e-01f, 9.02249038e-01f, -8.77119541e-01f, 6.70521975e-01f, -4.79337037e-01f, -1.22931011e-01f, 5.89574993e-01f, 6.91619158e-01f,
  3.54304612e-01f, -8.63025904e-01f, -1.70180619e-01f, -1.00543089e-01f, -1.74587265e-01f, 7.59864271e-01f, -1.04045151e-02f, -1.81638733e-01f, -1.07406802e-01f, 5.42586625e-01f,
  5.83853602e-01f, -1.16930142e-01f, -3.69861722e-01f, 6.69762611e-01f, 1.72222890e-02f, 3.61442477e-01f, -5.92834130e-02f, -4.87796038e-01f, -2.32579023e-01f, 3.64978820e-01f,
  3.45501721e-01f, -7.76966751e-01f, -7.91908726e-02f, 3.99765164e-01f, 8.63220632e-01f, -2.97378331e-01f, -1.61022171e-01f, 5.98802090e-01f, 4.74776000e-01f, -2.33568296e-01f,
  6.08631611e-01f, -6.56049252e-01f, 8.95579338e-01f, -7.16124892e-01f, 3.14272344e-01f, 2.24004373e-01f, 6.86476052e-01f, -2.55465627e-01f, 5.57749808e-01f, -4.72754449e-01f,
  -1.22773856e-01f, 1.23402931e-01f, 6.04880095e-01f, 3.99522871e-01f, -2.07580961e-02f, -1.91135406e-01f, -2.63842940e-01f, -7.35789597e-01f, 6.90750241e-01f, 2.02463150e-01f,
  3.52892607e-01f, 4.98386264e-01f, -2.99619883e-01f, 6.91727877e-01f, 2.78920591e-01f, 3.40966322e-02f, -1.60565406e-01f, 4.35202181e-01f, 4.29839075e-01f, 3.50984365e-01f,
  -3.38893592e-01f, 6.31964207e-01f, 1.22603543e-01f, 5.71301162e-01f, -4.32214290e-01f, -4.60571945e-01f, -2.86034226e-01f, 4.55525815e-01f, -6.15983188e-01f, 2.45753258e-01f,
  -4.68606532e-01f, -3.26851830e-02f, -8.00724551e-02f, -3.87306064e-01f, 7.08884478e-01f, -1.10612147e-01f, -5.93049824e-01f, 2.78802752e-01f, 5.22741616e-01f, 2.11309537e-01f,
  -5.57124376e-01f, 3.12025666e-01f, -5.29964209e-01f, 6.61882102e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -1.98529646e-01f, 3.18486810e-01f, 2.05066040e-01f, 4.90511328e-01f, 5.49846236e-03f, 6.01481013e-02f, -2.78971922e-02f, 5.03370941e-01f, 1.10516764e-01f, 5.34202941e-02f,
  4.45984721e-01f, 2.31387109e-01f, -1.21891163e-01f, 2.79520392e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -3.16013426e-01f, -4.81027246e-01f, -4.69729394e-01f, -5.22103548e-01f, -4.08097327e-01f, 5.49226820e-01f, -6.09283149e-01f, -6.83023691e-01f, -5.92916943e-02f, -7.69375218e-03f,
  1.52995959e-01f, 2.05538958e-01f, -4.56385016e-01f, -7.59920239e-01f, 2.95619398e-01f, 6.00447953e-01f, 2.05196619e-01f, 1.05728877e+00f, -4.70465630e-01f, -3.52795720e-01f,
  -2.81412393e-01f, 4.26495343e-01f, 2.68124402e-01f, -1.81886271e-01f, -5.77445924e-01f, -6.55430317e-01f, 7.67782032e-01f, 1.11884698e-01f, -6.01984203e-01f, -3.00573558e-01f,
  3.56568456e-01f, -7.44494081e-01f, -2.48685241e-01f, 7.01522112e-01f, 2.56233841e-01f, -7.79238582e-01f, 4.23159361e-01f, -6.00030661e-01f, -9.59980115e-02f, 4.33911085e-01f,
  3.48551810e-01f, -6.24353588e-01f, 2.99054354e-01f, 2.44448647e-01f, -6.62199259e-02f, -1.63858421e-02f, -2.75484890e-01f, -1.37181252e-01f, -1.80519432e-01f, 9.28919092e-02f,
  1.49475589e-01f, 3.23399752e-01f, -7.27672219e-01f, -1.92085370e-01f, -3.53798240e-01f, -3.02181244e-01f, -4.19397414e-01f, -4.61154252e-01f, -2.43430167e-01f, 4.28595483e-01f,
  -7.68645227e-01f, 1.88085794e-01f, 3.52557153e-01f, 3.71830940e-01f, -6.85223490e-02f, 2.46380027e-02f, -8.21946859e-01f, 2.76625454e-01f, 3.47471349e-02f, 1.90467745e-01f,
  -1.52502796e-02f, -8.87782931e-01f, -5.22815883e-01f, 2.72142172e-01f, -9.96477067e-01f, -1.85499847e-01f, 2.21931830e-01f, 9.70797688e-02f, -1.15608545e-02f, 5.00679970e-01f,
  2.69400746e-01f, -4.68792886e-01f, -5.11212587e-01f, -4.25493598e-01f, -1.27719700e-01f, 1.34261027e-01f, -4.73689318e-01f, -3.21321666e-01f, -4.91233319e-01f, 3.63403052e-01f,
  3.21567416e-01f, -5.42194307e-01f, 3.42769831e-01f, 5.90317249e-01f, -1.76586300e-01f, -4.49252665e-01f, 3.79416436e-01f, -2.97069073e-01f, 9.75429118e-02f, 2.32525453e-01f,
  2.34415963e-01f, -1.18458664e+00f, -5.60633302e-01f, 3.11064184e-01f, 4.90654081e-01f, -2.04582945e-01f, -4.04841930e-01f, -7.46555388e-01f, 4.62002486e-01f, -2.10277170e-01f,
  -8.19255352e-01f, -3.27023149e-01f, -1.38032302e-01f, 1.15894429e-01f, 2.46865273e-01f, 1.10680886e-01f, 3.90208066e-01f, -8.36842239e-01f, 3.36456932e-02f, -6.47557259e-01f,
  5.68463445e-01f, 2.31439531e-01f, -5.48222184e-01f, 3.00880641e-01f, -3.57503444e-01f, -5.16165614e-01f, 3.68302912e-01f, 2.85250902e-01f, 5.68860490e-03f, -2.75478512e-01f,
  1.89673811e-01f, -1.73541099e-01f, -5.77118933e-01f, 2.87779510e-01f, 4.20456856e-01f, 3.22700799e-01f, 4.23697263e-01f, -2.66642988e-01f, 2.25592345e-01f, -6.82410717e-01f,
  -4.56915915e-01f, -1.51703268e-01f, -1.55540451e-01f, -4.38102968e-02f, -1.22825764e-01f, 2.73445070e-01f, -5.56285083e-01f, 3.87348384e-01f, 4.19328660e-01f, -4.99732554e-01f,
  3.17309618e-01f, -6.45050168e-01f, -4.11488600e-02f, 5.43485343e-01f, -1.33350179e-01f, -5.04069924e-01f, 3.95856112e-01f, -1.09732378e+00f, -1.71634197e-01f, -6.44549012e-01f,
  1.14554122e-01f, -4.26612198e-01f, 1.95790797e-01f, -4.88471925e-01f, -5.90699375e-01f, 4.66455430e-01f, 6.65767193e-01f, -3.26111555e-01f, -9.55305994e-01f, -4.33013320e-01f,
  -6.23650253e-01f, -5.34969233e-02f, -7.31459677e-01f, 6.47781551e-01f, -2.05295589e-02f, -2.80258536e-01f, -3.02208215e-01f, -9.29904580e-02f, 7.29040056e-02f, -9.10307281e-03f,
  1.31920114e-01f, 4.03228134e-01f, -6.61198571e-02f, 2.28941739e-01f, -1.79160222e-01f, -4.34949279e-01f, -9.47619557e-01f, -3.67152572e-01f, 4.31744188e-01f, 3.26995701e-02f,
  -2.81683773e-01f, -3.98883641e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.56811655e-01f, -3.12496871e-02f, 8.59294832e-02f, -1.08627245e-01f, 2.84780324e-01f, 3.58177096e-01f, 3.51494610e-01f, -3.96596342e-02f, -2.85759687e-01f, -1.98897615e-01f,
  1.46500602e-01f, 6.01123013e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    