/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.45459431e-01f, -1.55975714e-01f, 1.03780791e-01f, -5.54621071e-02f, 4.63190265e-02f, -8.99023712e-02f, 1.29082561e-01f, -1.91875741e-01f, -1.68038800e-01f, -2.35590547e-01f,
  -1.19002685e-01f, 1.94641307e-01f, -1.40739620e-01f, 2.52318289e-02f, 1.09251589e-01f, -4.26732264e-02f, 2.17611659e-02f, -1.13305435e-01f, -8.08930025e-02f, -8.66086632e-02f,
  2.93726474e-02f, -2.36459356e-02f, 1.35059744e-01f, 3.63988355e-02f, 1.06855437e-01f, 7.09540397e-02f, -4.05088514e-02f, -3.38289589e-02f, 5.18749934e-03f, 4.14223224e-02f,
  -4.10836674e-02f, -4.55808900e-02f, 5.35621122e-02f, -2.41813827e-02f, -2.02235635e-02f, -8.56423527e-02f, -7.86529705e-02f, -9.25791264e-03f, 7.12601990e-02f, -3.10696755e-02f,
  -2.56904643e-02f, 7.76356691e-03f, 6.93535432e-02f, 3.13200839e-02f, 2.04427522e-02f, 1.42015526e-02f, -5.10789938e-02f, 1.22304773e-02f, -1.07014300e-02f, 2.64320504e-02f,
  -4.50646132e-02f, -2.22015055e-03f, -3.39380465e-02f, -5.93626872e-03f, 1.27795311e-02f, -1.00046527e-02f, -7.07246512e-02f, 1.03162654e-01f, -1.08230464e-01f, 1.94923338e-02f,
  1.01442382e-01f, -2.54207551e-02f, 6.56154156e-02f, -1.10969104e-01f, 8.33420735e-03f, -4.33491394e-02f, -3.56881097e-02f, -2.35365555e-02f, -1.13533242e-02f, -9.65936407e-02f,
  -2.42480543e-03f, 6.01344183e-02f, -8.02704692e-02f, -3.84542234e-02f, -5.58749540e-03f, 5.79980463e-02f, -1.62331928e-02f, -4.97573093e-02f, -3.97422798e-02f, 9.58133861e-02f,
  -6.46735774e-03f, -9.28589925e-02f, 9.67932865e-02f, -2.89314296e-02f, 7.72274807e-02f, 1.08501166e-02f, -8.63971785e-02f, 3.07433661e-02f, 5.05329818e-02f, 7.44986087e-02f,
  -3.43944818e-01f, -4.08358365e-01f, 9.97230317e-03f, -5.62356114e-02f, 2.83106733e-02f, 4.64215986e-02f, 1.10996962e-02f, 7.92199075e-02f, -1.35358617e-01f, -2.10874211e-02f,
  -7.79696181e-02f, -6.71863407e-02f, -1.77414957e-02f, 1.14681117e-01f, 9.20520630e-03f, -1.02256328e-01f, -5.42044640e-02f, -1.58332437e-02f, -2.49025859e-02f, -4.58999500e-02f,
  1.77491996e-02f, -2.98150536e-02f, 2.87978742e-02f, 4.50986950e-03f, -1.17558604e-02f, 2.92002764e-02f, 9.19717699e-02f, 9.29558184e-03f, 1.14505701e-02f, 1.69378873e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.13253510e-01f, 5.54655381e-02f, 1.32717654e-01f, -2.28835419e-02f, -2.57037103e-01f, -5.81554212e-02f, -1.93041712e-01f, -1.99050292e-01f, -5.00376701e-01f, 1.89031184e-01f,
  -8.37854296e-02f, 2.62336427e-04f, -1.42117620e-01f, -1.95554763e-01f, -4.58018243e-01f, -3.39262784e-01f, -4.69500758e-02f, 2.91267298e-02f, -1.47643378e-02f, 2.39433542e-01f,
  2.01080844e-01f, -1.70150995e-01f, -3.72683331e-02f, 2.13485025e-02f, 1.31815553e-01f, 4.33763921e-01f, 1.19575314e-01f, 1.16441630e-01f, 2.06782550e-01f, -2.26347327e-01f,
  -7.41942301e-02f, -1.83847532e-01f, 2.67141014e-02f, -6.67808056e-02f, 6.37766868e-02f, 1.57209337e-01f, 9.99126360e-02f, -1.04652494e-01f, -3.53487618e-02f, -3.87367755e-02f,
  1.02507107e-01f, 4.08730321e-02f, 5.54011110e-03f, -9.37265605e-02f, 8.68104547e-02f, -4.21061665e-02f, -1.40990177e-02f, -8.94698780e-03f, -7.33116567e-02f, 1.18905485e-01f,
  1.13480359e-01f, 1.15467787e-01f, 1.28749730e-02f, 3.82077806e-02f, -7.35168392e-03f, 4.34020534e-03f, 1.36277080e-01f, 1.36840180e-01f, 2.79239919e-02f, 6.43133372e-02f,
  9.21620056e-02f, 9.37628523e-02f, 9.76818353e-02f, -3.78239937e-02f, 6.16520783e-03f, -2.76891910e-03f, -3.90383191e-02f, 3.72888148e-03f, -8.04641284e-03f, -1.14260659e-01f,
  4.15209271e-02f, 9.31840912e-02f, -6.60864636e-02f, -7.93449022e-03f, 1.56024098e-01f, -4.70069535e-02f, 6.59170821e-02f, 8.22592452e-02f, 1.66399151e-01f, -1.97156817e-02f,
  -1.62497893e-01f, 5.52747771e-02f, 1.00668125e-01f, 1.33955209e-02f, 2.22985223e-02f, 2.76963096e-02f, -2.53024581e-03f, 1.38143763e-01f, -1.20916307e-01f, -4.10027504e-02f,
  -2.75870156e-03f, 1.54275298e-01f, -7.95857683e-02f, -3.13509628e-02f, -7.99310952e-02f, 4.21983376e-02f, -4.43745106e-02f, -5.95637299e-02f, 8.55048820e-02f, 1.08204959e-02f,
  1.58217117e-01f, 3.10456045e-02f, -1.20608648e-02f, -1.13576509e-01f, -5.26104271e-02f, 6.53064027e-02f, 2.90818028e-02f, -3.14090811e-02f, -2.82763001e-02f, 5.30650467e-02f,
  -2.99422871e-02f, -8.08698311e-03f, -6.21328950e-02f, -1.52037144e-01f, 1.12361670e-01f, 1.25852019e-01f, -5.20829391e-03f, 1.71743199e-01f, 2.10462604e-02f, -5.05971275e-02f,
  -1.16152716e+00f, 3.73773336e-01f, 1.40244618e-01f, -4.60061908e-01f, 2.48677552e-01f, 6.01644590e-02f, -1.34007156e-01f, 2.55724549e-01f, -2.81256795e-01f, 9.07820556e-03f,
  -1.63781811e-02f, -1.47564203e-01f, 2.33174995e-01f, -1.26211494e-01f, -4.93418038e-01f, -3.67785394e-02f, -1.12417005e-01f, -1.99098364e-01f, 3.98364216e-02f, 1.38685048e-01f,
  -1.75756082e-01f, -1.44815138e-02f, 3.60225663e-02f, 3.42816025e-01f, 1.29563063e-01f, 1.19555853e-01f, -4.71396297e-02f, 3.43547910e-01f, -1.35730967e-01f, -1.37658324e-02f,
  -1.90392658e-01f, 1.07639588e-01f, 1.23349890e-01f, 1.24739353e-02f, -1.16941379e-02f, 6.62370324e-02f, -2.40230616e-02f, -6.84676915e-02f, 7.00104386e-02f, 3.99619043e-02f,
  -1.79890934e-02f, -4.43478720e-03f, -1.08529441e-01f, 6.66758344e-02f, 1.11854419e-01f, 7.47274980e-02f, 8.93290415e-02f, 4.02478315e-03f, 5.27782701e-02f, 1.73117965e-02f,
  -7.60074332e-02f, -4.22282405e-02f, -1.17712483e-01f, -7.11743832e-02f, -1.10735767e-01f, 7.23144114e-02f, -2.48758197e-02f, -1.77572332e-02f, -3.58628370e-02f, -1.25309587e-01f,
  5.44083007e-02f, 3.62492986e-02f, 1.04040883e-01f, -6.55211583e-02f, -1.41460091e-01f, -2.67206021e-02f, -4.43453975e-02f, -1.39729381e-02f, -2.97598517e-03f, -3.11229564e-02f,
  -1.90887794e-01f, -1.37250014e-02f, -6.95424229e-02f, -3.42523567e-02f, -6.59776777e-02f, -7.35587031e-02f, 2.13206783e-02f, 5.93486317e-02f, -7.85346851e-02f, 5.18973470e-02f,
  5.37805259e-02f, -7.99815208e-02f, -6.14934005e-02f, -6.61686435e-03f, 5.41085079e-02f, -2.39560809e-02f, 6.81345239e-02f, 1.62182078e-02f, -5.40150404e-02f, -3.55426520e-02f,
  -2.74708092e-01f, -1.50015175e-01f, 3.94700468e-02f, -1.44983411e-01f, -3.89520042e-02f, 3.33237015e-02f, 8.17988766e-04f, -9.50628135e-04f, 2.80118119e-02f, 9.87006351e-02f,
  3.27083133e-02f, 3.51130813e-02f, -9.50031057e-02f, -3.94651294e-02f, -3.58928330e-02f, -1.33052379e-01f, -1.05128139e-01f, 5.38902432e-02f, -1.40186027e-01f, 3.14218327e-02f,
  -7.98579901e-02f, 3.17742443e-03f, -6.22816235e-02f, 8.29387177e-03f, -3.19396472e-03f, 2.74495762e-02f, -8.31566676e-02f, 1.16686188e-02f, -3.62240872e-03f, 5.56175150e-02f,
  -1.06805456e+00f, 1.19119063e-01f, -3.95810641e-02f, -9.17910337e-02f, 1.25642836e-01f, 3.36844862e-01f, -1.14937179e-01f, 1.42088667e-01f, -3.43839705e-01f, 7.05120564e-02f,
  -1.10529222e-01f, -2.26183310e-01f, -1.98898882e-01f, 1.41096085e-01f, 1.49537742e-01f, 1.72947943e-01f, 3.67184609e-01f, -5.78221940e-02f, 1.97240293e-01f, -1.58358827e-01f,
  9.26112309e-02f, 5.28266914e-02f, 1.48266733e-01f, 2.89896518e-01f, -2.19374135e-01f, -1.16924681e-01f, -9.86054838e-02f, 6.90597817e-02f, 1.57955661e-01f, 1.44066393e-01f,
  -2.78370768e-01f, -4.34792370e-01f, -3.17495644e-01f, 2.06815675e-02f, -3.88925970e-02f, -2.03973413e-01f, -4.68977168e-03f, -6.73918054e-02f, -1.91368103e-01f, -1.23162761e-01f,
  -1.26664817e-01f, 4.07818593e-02f, 1.19391516e-01f, -3.25984471e-02f, -1.43291712e-01f, 1.70213021e-02f, 8.73527154e-02f, 7.18927830e-02f, -1.15487282e-03f, -5.74318366e-03f,
  5.81606776e-02f, 1.38606697e-01f, -1.80972874e-01f, 3.85545753e-02f, 3.77064198e-02f, -1.29512772e-01f, 6.30003512e-02f, 5.65105751e-02f, 1.64239705e-02f, 3.38993371e-02f,
  1.23314954e-01f, -1.18434904e-02f, -1.78604685e-02f, -1.08027697e-01f, 3.28902081e-02f, 2.08165832e-02f, 2.88629625e-02f, -6.03236221e-02f, 4.02016304e-02f, 6.40630275e-02f,
  1.09811582e-01f, -2.09383704e-02f, 1.35896787e-01f, -2.09826585e-02f, -1.12302611e-02f, -1.47123840e-02f, 6.02947436e-02f, 9.89661217e-02f, 7.29770283e-04f, 1.56661987e-01f,
  -8.11717883e-02f, 4.49367203e-02f, 5.95982336e-02f, -9.34700295e-02f, -2.95441635e-02f, 3.40664200e-02f, -7.26286173e-02f, 1.32956952e-02f, -9.82646272e-02f, 1.15511797e-01f,
  -2.61448264e-01f, -1.95227027e-01f, -7.06473067e-02f, 8.00356269e-02f, 1.95624337e-01f, 1.04427785e-01f, 1.24198869e-01f, -3.55405100e-02f, 1.43540561e-01f, -7.49798343e-02f,
  1.82231870e-02f, 6.32220879e-02f, -1.00112878e-01f, -8.87358040e-02f, 2.21453048e-02f, 4.38902974e-02f, -9.50927734e-02f, -3.66242938e-02f, -8.08258951e-02f, 1.18408009e-01f,
  1.60414279e-02f, 4.66068946e-02f, 1.27207682e-01f, 8.49594027e-02f, -1.46658886e-02f, 4.71127033e-02f, 3.21476907e-02f, 2.83173379e-02f, 1.46070018e-01f, -5.06832227e-02f,
  -5.01864254e-01f, 4.23067838e-01f, -3.56406868e-01f, 5.51338434e-01f, 5.04886769e-02f, 1.90899521e-01f, 2.97608495e-01f, 2.44099930e-01f, 1.23615332e-01f, 4.17298734e-01f,
  1.50540411e-01f, 5.99414669e-03f, -8.42245147e-02f, 6.45882070e-01f, 2.45312721e-01f, 4.57886495e-02f, 4.83722031e-01f, 2.51907289e-01f, 2.20337193e-02f, 1.40217423e-01f,
  4.33414988e-02f, 5.02893746e-01f, 2.17347562e-01f, 9.62376595e-02f, 2.50748694e-01f, -1.57908127e-01f, 1.25841558e-01f, -2.16059119e-01f, 1.89410239e-01f, 1.43381894e-01f,
  3.14449556e-02f, -1.14710897e-01f, -1.42017871e-01f, -5.73874451e-02f, -4.28734496e-02f, -6.95147514e-02f, 3.78236710e-03f, -1.43732682e-01f, -8.86715725e-02f, 4.55084518e-02f,
  -4.49357815e-02f, -8.54100734e-02f, 1.53998449e-01f, -1.06562972e-02f, -8.26474056e-02f, -1.09400481e-01f, 2.42141727e-02f, 4.67217341e-02f, -6.67527989e-02f, -3.01677641e-02f,
  2.20908727e-02f, 7.79441968e-02f, -2.97652930e-02f, -9.67198052e-03f, -7.56232664e-02f, 6.24820404e-02f, 8.26179162e-02f, -6.35857433e-02f, -1.96313132e-02f, 6.99000210e-02f,
  -1.80803947e-02f, -4.17587124e-02f, 8.55589807e-02f, 9.60908011e-02f, -3.44561934e-02f, -9.25227255e-03f, -3.95935997e-02f, -8.06038529e-02f, -5.82282096e-02f, 8.63440633e-02f,
  3.84048745e-02f, -2.41374634e-02f, -1.63269751e-02f, -1.63165517e-02f, -2.90146228e-02f, 5.88915981e-02f, -8.42140391e-02f, 3.38761732e-02f, -9.57008824e-02f, -1.93096660e-02f,
  2.84339078e-02f, -6.79984093e-02f, 4.83726263e-02f, 6.07193373e-02f, -6.22640327e-02f, -9.87348258e-02f, 1.09364633e-02f, -2.18940265e-02f, -7.83780813e-02f, -4.37054373e-02f,
  3.72957110e-01f, 1.78552568e-01f, -1.50405488e-03f, 1.95988361e-02f, -1.53292099e-03f, 5.49368225e-02f, 1.09531358e-01f, 5.65857552e-02f, 5.34602962e-02f, 1.90247670e-02f,
  -1.11662991e-01f, -1.26753729e-02f, -9.02628377e-02f, -4.32987586e-02f, 1.13260178e-02f, 4.75300327e-02f, -6.87268674e-02f, -4.00779210e-03f, 9.96996388e-02f, 5.65138161e-02f,
  6.02086447e-02f, -4.48922180e-02f, -3.01355515e-02f, -1.46913920e-02f, -1.05306059e-02f, -1.69672188e-03f, -4.05917987e-02f, -5.82448058e-02f, 1.79924387e-02f, -1.30776856e-02f,
  2.40135372e-01f, -6.87677553e-03f, 8.77834558e-02f, 1.38946593e-01f, -3.02100062e-01f, -6.55247211e-01f, -6.46395504e-01f, -1.93353325e-01f, -1.56829372e-01f, -2.19383776e-01f,
  -1.60472572e-01f, 1.29850060e-01f, 9.59146917e-02f, -1.04810126e-01f, 2.39109769e-01f, 1.14029080e-01f, 1.04155555e-01f, -7.80338198e-02f, 1.18503422e-01f, 2.39840806e-01f,
  4.09121960e-01f, 5.15121259e-02f, 3.75624537e-01f, 7.59549737e-02f, -2.20109932e-02f, 2.40697742e-01f, 4.91337389e-01f, -1.55696347e-02f, -7.79142305e-02f, -1.58043459e-01f,
  -9.96468514e-02f, 6.53652623e-02f, 2.32565193e-03f, 7.76872365e-03f, 1.77140400e-01f, 2.58471984e-02f, -2.10290705e-03f, -8.07688236e-02f, -1.08654223e-01f, 6.54422818e-03f,
  9.33752805e-02f, 6.39453232e-02f, -6.90543130e-02f, -9.71325785e-02f, -1.34634539e-01f, -2.85881534e-02f, 1.12182185e-01f, -7.06104413e-02f, -9.29676965e-02f, 1.19942360e-01f,
  -6.23178622e-03f, -1.20023713e-02f, -4.00782749e-03f, -6.51923288e-03f, 6.14759773e-02f, -5.70055023e-02f, -9.22983699e-03f, 1.07178744e-02f, 2.33135466e-02f, -5.84597364e-02f,
  3.25528495e-02f, -2.28366007e-05f, -3.43198553e-02f, -1.64351508e-01f, -3.40753119e-03f, 3.60747497e-03f, 3.92695367e-02f, -2.28219349e-02f, 9.36360732e-02f, 8.37410316e-02f,
  -1.02091655e-01f, 1.32348454e-02f, -5.58183901e-02f, 1.50783770e-02f, -2.00156327e-02f, 1.40673332e-02f, -3.09240795e-03f, -1.03621095e-01f, 1.00277387e-01f, -1.74867436e-01f,
  -1.96794476e-02f, -1.01012424e-01f, 4.06821333e-02f, -7.27926716e-02f, 7.70016527e-03f, 7.22423941e-02f, 1.00909218e-01f, 7.77074844e-02f, -4.53321524e-02f, -1.72246955e-02f,
  7.66645595e-02f, 2.54070014e-01f, -5.41279577e-02f, -8.24530497e-02f, -5.11323549e-02f, 8.49154498e-03f, 2.95525473e-02f, 5.76624200e-02f, 1.38827516e-02f, -2.25356733e-03f,
  1.66431203e-01f, -4.24967892e-02f, 6.77229911e-02f, 2.71922164e-02f, -5.80475517e-02f, -1.15861408e-02f, 7.92187229e-02f, 6.94561303e-02f, 1.76273864e-02f, 6.95868954e-02f,
  4.56795618e-02f, -4.74415459e-02f, 1.09418347e-01f, -7.19693303e-02f, -9.05594528e-02f, 1.23259932e-01f, -1.26445860e-01f, 8.08116123e-02f, -1.98214129e-02f, -3.69383655e-02f,
  2.37476557e-01f, -3.99819970e-01f, -1.36816218e-01f, 4.42148685e-01f, 3.68732661e-01f, -2.70456493e-01f, -1.71004027e-01f, 1.47587642e-01f, 4.93503690e-01f, -3.29185575e-01f,
  4.13422585e-02f, -2.21716091e-01f, -6.22462273e-01f, 1.31830767e-01f, -1.71383902e-01f, -3.41438055e-01f, 1.10790074e-01f, -1.25438258e-01f, 2.94138253e-01f, -3.37918736e-02f,
  2.62172669e-01f, 2.46820569e-01f, -8.19329694e-02f, -8.06932151e-03f, 1.97231635e-01f, 1.79981038e-01f, -1.35179632e-03f, -2.08622158e-01f, 4.31837104e-02f, -8.44572559e-02f,
  1.81002617e-01f, 1.33557290e-01f, -6.81521967e-02f, -7.98174888e-02f, 6.73613399e-02f, 3.32976580e-02f, -1.05229497e-01f, -1.46994799e-01f, -6.10721344e-03f, 1.14739360e-02f,
  -1.40014619e-01f, -1.92865115e-02f, 1.17387779e-01f, -6.61841407e-02f, 1.39838055e-01f, 6.92295879e-02f, 8.85200426e-02f, 8.73658108e-04f, -1.97473820e-02f, 4.11819853e-02f,
  8.54126215e-02f, 1.16634697e-01f, 6.61380962e-02f, -1.46930948e-01f, 3.01051512e-02f, 1.78853318e-01f, 1.72091648e-02f, -7.61367157e-02f, 4.46576737e-02f, 1.75674316e-02f,
  -1.28610924e-01f, -4.02756408e-02f, 4.42026258e-02f, 8.07150304e-02f, 2.51600519e-02f, 7.61825889e-02f, -4.77004535e-02f, 7.47348517e-02f, 1.25604123e-01f, 4.51687276e-02f,
  9.56627578e-02f, 6.66980892e-02f, 9.02866125e-02f, 5.08213118e-02f, 4.62196507e-02f, 7.07456172e-02f, -3.86577658e-02f, 5.87952286e-02f, 7.42146745e-02f, -1.00336205e-02f,
  3.64982486e-02f, 5.72432317e-02f, -1.30863702e-02f, 5.44531383e-02f, -3.72450463e-02f, -5.23058772e-02f, 1.15562320e-01f, -1.90259721e-02f, 4.69674543e-02f, -2.25501992e-02f,
  -4.73216623e-01f, -2.96827614e-01f, -8.03906843e-02f, 1.74451023e-02f, -9.05496553e-02f, 2.27894187e-02f, 7.76911154e-02f, 1.26268528e-03f, -4.04066592e-02f, 5.76169081e-02f,
  1.01718798e-01f, 1.74021810e-01f, -9.00663137e-02f, 4.21629734e-02f, -7.04397485e-02f, 8.01704824e-03f, -8.46953392e-02f, 5.16724773e-03f, -3.33364196e-02f, -1.06099628e-01f,
  -1.60677522e-01f, -7.33827427e-02f, -3.04827560e-02f, 1.31931335e-01f, 7.75476024e-02f, 3.44354697e-02f, -2.06297264e-02f, 2.83993483e-02f, -4.81730811e-02f, -9.90004987e-02f,
  -3.96564566e-02f, 2.00525951e-02f, -6.78440809e-01f, -3.02772552e-01f, 5.70310187e-03f, 3.11994374e-01f, 4.07114029e-02f, 1.26762494e-01f, -1.50790557e-01f, 5.94910204e-01f,
  3.58952373e-01f, -1.53214246e-01f, 1.40169645e-02f, 1.70767054e-01f, -5.21434426e-01f, 2.09415536e-02f, 1.91456273e-01f, 1.21546455e-01f, -1.23395719e-01f, 1.89011730e-02f,
  -9.15040076e-02f, 4.47953969e-01f, -5.59992671e-01f, 2.62249976e-01f, 1.30405754e-01f, -2.00215951e-01f, 1.64791629e-01f, -1.68058455e-01f, -1.64949838e-02f, -9.88513678e-02f,
  -2.87173633e-02f, 1.09990854e-02f, -5.23778908e-02f, -1.16903588e-01f, 1.24791916e-02f, 4.03708667e-02f, -2.57804953e-02f, -2.86114812e-02f, -8.86858925e-02f, 1.66611699e-03f,
  2.94935368e-02f, 1.55350724e-02f, 6.16600476e-02f, -1.03197448e-01f, 1.05385557e-01f, -5.01783527e-02f, -8.88382867e-02f, -4.57781255e-02f, -1.00624271e-01f, 1.56976841e-02f,
  -1.30861536e-01f, -8.49410519e-02f, -4.95475456e-02f, -6.17487393e-02f, -1.82270840e-01f, 6.28785975e-03f, 2.81660911e-02f, -1.55331552e-01f, 5.59395701e-02f, -7.14732632e-02f,
  2.07352340e-02f, 8.34188461e-02f, 7.68944770e-02f, 3.22049297e-02f, -5.42428084e-02f, 5.31303138e-02f, -1.10963434e-02f, 1.91134792e-02f, -9.72364172e-02f, 1.11847304e-01f,
  -6.02244623e-02f, -4.00726683e-02f, 4.95061465e-02f, -1.60659309e-02f, 5.11242310e-03f, 1.86189972e-02f, -6.22705631e-02f, 6.13162629e-02f, -4.64373082e-02f, -3.09055280e-02f,
  4.07399461e-02f, -8.91426113e-03f, 1.13224000e-01f, 7.51612037e-02f, -7.70145878e-02f, -1.21636316e-01f, 4.34096642e-02f, -2.53447164e-02f, 8.84390846e-02f, -4.54827994e-02f,
  7.20461383e-02f, 2.80342877e-01f, -1.01918513e-02f, 9.27684922e-03f, 6.60858601e-02f, 5.86560667e-02f, -6.07687905e-02f, 4.88800481e-02f, -9.77463871e-02f, 4.66192365e-02f,
  1.03106506e-01f, -5.75417653e-02f, 4.81620543e-02f, -2.26904210e-02f, -1.18090726e-01f, 1.62380800e-01f, 1.70334931e-02f, 1.20322872e-02f, -2.34572962e-02f, -2.19130274e-02f,
  5.95460869e-02f, 6.34438992e-02f, -6.45190850e-02f, 6.72722235e-02f, 1.09907307e-01f, 1.19148158e-01f, -7.63570368e-02f, -4.78846170e-02f, -5.07810228e-02f, -6.32598698e-02f,
  1.60189375e-01f, 3.44569564e-01f, 2.60269761e-01f, -2.20839866e-02f, 5.55187389e-02f, -2.63805926e-01f, -1.62431031e-01f, 1.79797441e-01f, 3.49449962e-01f, 1.41224405e-02f,
  -1.69223502e-01f, 3.37781549e-01f, -2.02728659e-01f, 1.14008054e-01f, -4.88649517e-01f, -2.68060446e-01f, -6.33637533e-02f, 2.83431131e-02f, 3.85666974e-02f, -1.22157708e-02f,
  9.22141410e-03f, -3.42921168e-01f, -7.49300718e-02f, 2.55618189e-02f, 2.13357255e-01f, 1.91870436e-01f, -3.61557931e-01f, 2.55565420e-02f, -6.58170804e-02f, -5.37380110e-04f,
  1.60739437e-01f, 1.23086713e-01f, 7.43430629e-02f, 2.42865663e-02f, -4.35137637e-02f, -1.38582379e-01f, -3.02825924e-02f, -5.15039675e-02f, -1.13179116e-02f, -5.66641465e-02f,
  8.57691616e-02f, 2.97146570e-02f, 4.24215458e-02f, 1.13056883e-01f, 5.28145656e-02f, 5.98281808e-02f, 1.03338532e-01f, 1.41520917e-01f, 2.00887233e-01f, 2.43955031e-01f,
  8.39806274e-02f, 1.93709344e-01f, 2.28373948e-02f, -6.72127027e-03f, 5.02822064e-02f, -2.88170222e-02f, -8.25363398e-02f, -4.97303111e-03f, 4.13561612e-02f, 2.65083611e-02f,
  3.34304571e-02f, -5.90498671e-02f, -6.58063889e-02f, 1.43785805e-01f, -9.57600493e-03f, -3.17932628e-02f, -5.09065427e-02f, -7.61466250e-02f, -3.01401205e-02f, -7.99799338e-02f,
  6.44163403e-04f, 9.13481489e-02f, -5.87989129e-02f, -7.89108351e-02f, 8.91554076e-03f, -1.26164891e-02f, -2.42141634e-02f, -7.69864991e-02f, 6.91416338e-02f, -4.78133559e-02f,
  -7.65948743e-03f, -1.03953667e-01f, 2.37407386e-02f, 2.96086129e-02f, -1.08577386e-01f, -4.34845500e-02f, 9.79110971e-02f, 1.36233076e-01f, 8.59104022e-02f, -4.29185815e-02f,
  -2.05580682e-01f, -4.37066227e-01f, -1.03200249e-01f, 6.18844628e-02f, 1.91312283e-02f, -2.40846071e-02f, 6.20931946e-03f, 2.87061892e-02f, -8.42583776e-02f, -1.44862738e-02f,
  -4.77880538e-02f, -1.09856918e-01f, -3.70630734e-02f, -3.56667750e-02f, -9.03137401e-02f, -8.40889215e-02f, -9.99773517e-02f, -1.72608793e-01f, -1.98954970e-01f, 4.24765423e-02f,
  8.44543725e-02f, -9.85047221e-02f, -5.49988337e-02f, -9.09888744e-02f, -6.78598881e-02f, -9.70857814e-02f, 1.10891066e-03f, 3.29495892e-02f, -7.58536011e-02f, -6.86557591e-02f,
  -7.99714506e-01f, 2.35166714e-01f, -3.07032585e-01f, 1.77743405e-01f, -2.49472901e-01f, -1.02204867e-01f, 3.96917667e-03f, -1.31182194e-01f, 3.89854237e-02f, 2.62794644e-01f,
  1.38787389e-01f, -1.09331153e-01f, 2.13435590e-01f, 2.40059465e-01f, -2.14660242e-01f, 2.79263020e-01f, -9.90043278e-04f, 1.06639368e-02f, -2.28958521e-02f, -5.88913038e-02f,
  -1.50783256e-01f, -2.22923197e-02f, -1.74871713e-01f, -9.62441787e-02f, -4.45869446e-01f, -8.14841539e-02f, 1.09064449e-02f, -1.68152124e-01f, -5.63693605e-02f, -1.44144550e-01f,
  -4.60755348e-01f, -9.01783854e-02f, -9.71633643e-02f, -1.76573157e-01f, -1.51138753e-01f, -1.48281112e-01f, -1.09777577e-01f, 1.68366879e-02f, -2.79053114e-02f, -1.50054069e-02f,
  -8.12854022e-02f, -1.19218966e-02f, 9.79400203e-02f, 8.93903077e-02f, -2.41983254e-02f, -1.06344149e-01f, -4.33224402e-02f, 1.37985713e-04f, 4.32555340e-02f, 3.23707499e-02f,
  -7.37442225e-02f, -2.01078970e-02f, 1.20274415e-02f, -1.40943294e-02f, -7.49171153e-02f, 1.27700185e-02f, 1.26796141e-01f, -1.05241083e-01f, -1.74804106e-01f, 2.33019516e-02f,
  4.62414138e-02f, 6.80219829e-02f, -9.10382196e-02f, 5.62804975e-02f, -3.86862294e-03f, 4.28447053e-02f, 4.91988212e-02f, 2.95869689e-02f, -5.65135218e-02f, -7.53289312e-02f,
  -3.78364995e-02f, 5.22166230e-02f, 2.97944210e-02f, -4.40540165e-02f, 4.32805270e-02f, 6.74439222e-02f, -2.69279983e-02f, -9.59781632e-02f, 4.75556590e-02f, -3.34104449e-02f,
  -9.75454506e-03f, 3.61944661e-02f, 1.85041353e-01f, 4.44849469e-02f, -8.35798588e-03f, -1.57932285e-02f, 3.88315432e-02f, 4.54987586e-02f, -4.07279432e-02f, -8.54559690e-02f,
  -3.29128861e-01f, -1.84336454e-01f, -8.14470425e-02f, -1.05663322e-01f, 1.66650116e-02f, -6.03605360e-02f, 8.85266811e-02f, -7.96164423e-02f, 3.47417295e-02f, -8.11472349e-03f,
  -5.65503351e-02f, -2.17443537e-02f, -9.40134153e-02f, 1.73491612e-01f, 3.67940441e-02f, 3.50235179e-02f, -1.32748932e-02f, -4.20193337e-02f, -8.52562413e-02f, -7.35602248e-03f,
  3.37094883e-03f, -7.82956779e-02f, 6.60997406e-02f, 1.95082296e-02f, 3.85610871e-02f, -7.04955161e-02f, -9.39337015e-02f, 5.09908348e-02f, -8.19748491e-02f, -6.10532518e-03f,
  5.22188604e-01f, -1.48697374e-02f, 1.48758605e-01f, 1.58861563e-01f, 4.05050635e-01f, 4.57902461e-01f, 5.58614492e-01f, 1.45157248e-01f, 5.67152798e-01f, -7.27278143e-02f,
  2.15035062e-02f, 1.79901794e-01f, 1.48797091e-02f, 1.40515819e-01f, 4.10406977e-01f, 8.35829303e-02f, 2.70967305e-01f, 1.02795348e-01f, 2.15240151e-01f, 1.54786706e-01f,
  6.79711252e-02f, 7.36984015e-02f, -2.02702984e-01f, -2.55694687e-01f, -3.24147195e-02f, -1.45029604e-01f, -4.53063279e-01f, 8.87421221e-02f, -4.19426769e-01f, 2.60859132e-01f,
  1.38309095e-02f, -2.54629366e-02f, -1.41988322e-01f, -4.69118580e-02f, -3.42917964e-02f, -2.70492509e-02f, -5.81665412e-02f, -6.56427583e-03f, 1.09239370e-01f, 8.47469941e-02f,
  -4.12553512e-02f, 5.86119406e-02f, -4.11399826e-02f, 1.06786797e-02f, 4.98530976e-02f, -1.41130924e-01f, -8.86731315e-03f, -1.14293568e-01f, 2.29857564e-02f, 7.11811334e-03f,
  -7.90665597e-02f, -9.18856263e-02f, -6.00286536e-02f, -1.57554336e-02f, -6.94184750e-02f, -5.23367524e-02f, -6.97800294e-02f, -6.16680719e-02f, 1.90169662e-02f, 1.10822827e-01f,
  8.12184960e-02f, 8.56784806e-02f, -8.83593932e-02f, -4.93426360e-02f, 6.68444112e-02f, -9.42097753e-02f, -5.78278415e-02f, 1.59826339e-03f, 1.56882145e-02f, -6.82544932e-02f,
  6.60997722e-03f, 1.66314900e-01f, 4.39229533e-02f, -2.49270461e-02f, 8.52278620e-02f, 9.41502899e-02f, -1.40077705e-02f, -2.41532326e-02f, 6.85091764e-02f, 4.64484543e-02f,
  -1.60172969e-01f, 7.16559365e-02f, -2.27762870e-02f, -2.51624528e-02f, 5.35563217e-04f, 5.54997958e-02f, -6.66014329e-02f, 3.56281251e-02f, -4.47226353e-02f, 1.22495808e-01f,
  1.66446730e-01f, 2.48902321e-01f, 3.99985351e-02f, -6.14730716e-02f, -1.23410918e-01f, -1.15404852e-01f, -1.99380945e-02f, -1.09670140e-01f, 1.55220494e-01f, -3.11547257e-02f,
  -3.43376808e-02f, 7.44071901e-02f, 1.71425082e-02f, -4.94613387e-02f, -3.23018841e-02f, 3.46359275e-02f, -1.08000068e-02f, 7.11020082e-02f, 3.12714353e-02f, -1.06827199e-01f,
  -4.18112017e-02f, 3.58791463e-02f, 1.01796210e-01f, 1.40595762e-02f, 3.80542502e-02f, -6.53264597e-02f, -4.45152447e-02f, 1.05528533e-02f, 5.85410232e-03f, 7.19274953e-02f,
  5.57526052e-01f, -1.66736007e-01f, 2.70009786e-01f, 2.81085908e-01f, 1.74184382e-01f, 2.28832647e-01f, 2.52801478e-01f, 1.32605627e-01f, 2.99673975e-01f, -2.50944614e-01f,
  -2.16211975e-01f, 2.38208443e-01f, 8.31247121e-03f, -6.84142932e-02f, 1.05208598e-01f, -1.60332639e-02f, 4.61013578e-02f, -3.09364703e-02f, 6.82444349e-02f, 5.49480505e-02f,
  7.41489604e-02f, -9.87745747e-02f, 3.19259567e-03f, -3.41476798e-01f, 3.34396474e-02f, 2.19732132e-02f, -3.14146549e-01f, -9.76688564e-02f, -1.71602711e-01f, -1.08492754e-01f,
  -1.40004441e-01f, 3.41438837e-02f, -1.15839481e-01f, -1.25197414e-02f, -9.89490673e-02f, -2.36241147e-03f, 3.59611176e-02f, 3.89832892e-02f, 3.74327451e-02f, 1.91897333e-01f,
  6.55910075e-02f, -3.85768190e-02f, 5.26112802e-02f, 1.03290595e-01f, -3.41294557e-02f, -9.13400669e-03f, 2.04385504e-01f, 7.99148232e-02f, -6.95466623e-02f, 1.67665809e-01f,
  2.29005322e-01f, -1.50776692e-02f, -5.24972938e-02f, -1.69880748e-01f, -1.00291014e-01f, 1.63309500e-02f, 1.25678763e-01f, 1.05082635e-02f, -8.20125788e-02f, -3.03794220e-02f,
  -1.87562287e-01f, 8.45978111e-02f, 1.83251186e-03f, 2.89962292e-02f, -1.29906029e-01f, 3.48062366e-02f, 4.31961976e-02f, -1.99710075e-02f, -1.67202391e-02f, 1.15821570e-01f,
  -1.90402362e-02f, -1.17943831e-01f, 8.52035135e-02f, -4.29208055e-02f, -7.52981678e-02f, -4.17261012e-02f, -8.56565461e-02f, 2.15934701e-02f, -7.04769371e-03f, -6.28050715e-02f,
  2.05307469e-01f, 8.02519098e-02f, -1.11690961e-01f, -6.87636137e-02f, -4.08947580e-02f, 1.12376343e-02f, 2.48404406e-02f, -9.75976512e-02f, -3.82982008e-02f, -5.53003363e-02f,
  -2.53440738e-01f, -1.27175778e-01f, -1.33439183e-01f, 3.32488827e-02f, -2.55110450e-02f, -1.80861294e-01f, 5.08035533e-02f, 6.31971238e-03f, -9.23456177e-02f, -4.77833413e-02f,
  8.58484507e-02f, 2.26474088e-02f, -4.85177301e-02f, 1.95711963e-02f, -6.63027018e-02f, -3.30269821e-02f, -7.26715177e-02f, -7.87979662e-02f, -6.38665929e-02f, 1.94921829e-02f,
  1.05268739e-01f, -3.16453390e-02f, 1.89616159e-02f, -9.39530358e-02f, -2.15872616e-01f, -5.80804944e-02f, 1.85074076e-01f, 1.97699647e-02f, -8.44322816e-02f, -8.29593018e-02f,
  -2.29063600e-01f, -1.25044947e-02f, -5.04069567e-01f, -1.98677614e-01f, -3.58605891e-01f, -5.67597151e-01f, -2.42258817e-01f, -2.44504109e-01f, 3.75848450e-02f, 4.20755446e-01f,
  1.79039314e-01f, 1.85775310e-01f, 4.27332073e-01f, -2.25866556e-01f, -3.14006627e-01f, 1.80916339e-01f, -4.94079977e-01f, -2.91912518e-02f, 9.11497232e-03f, -9.57376510e-02f,
  -1.97045967e-01f, 8.29647034e-02f, -2.81339854e-01f, 1.69328183e-01f, -2.67054915e-01f, -4.29941108e-03f, 1.97969362e-01f, -3.79459597e-02f, -2.11922660e-01f, -6.34686574e-02f,
  6.53670123e-03f, 1.63835064e-01f, -9.28125605e-02f, 8.30237269e-02f, -1.20311946e-01f, -1.76484168e-01f, -1.01487845e-01f, -3.22233550e-02f, 7.97116291e-03f, -1.18014410e-01f,
  1.49957407e-02f, 2.52881777e-02f, -1.06572742e-02f, -7.93696195e-02f, -5.63725494e-02f, -5.09493910e-02f, -7.53552616e-02f, -1.27581730e-01f, 7.86100626e-02f, -8.28099027e-02f,
  -1.51729900e-02f, -1.42062113e-01f, -1.98922008e-01f, -1.49475541e-02f, -7.40047172e-02f, -1.07439570e-01f, 1.01853302e-02f, 1.16417550e-01f, -3.45447473e-02f, -1.25781462e-01f,
  -1.66812822e-01f, 3.21311317e-02f, 1.47689357e-01f, -4.61772569e-02f, 1.40909571e-02f, -2.23340560e-03f, -4.27557342e-02f, -6.79816231e-02f, -1.04828104e-01f, -1.21358978e-02f,
  4.62665148e-02f, 1.60492092e-01f, -5.70439473e-02f, -7.95520023e-02f, -7.05374256e-02f, 4.84460033e-02f, -5.10166921e-02f, 1.76797807e-01f, -9.51714218e-02f, 2.54237428e-02f,
  1.02696650e-01f, -7.85008166e-03f, 8.94817561e-02f, -2.03157648e-01f, 7.96638802e-02f, 1.07715409e-02f, -1.64841458e-01f, -1.62701413e-01f, 8.13168362e-02f, -3.66008729e-02f,
  2.85086352e-02f, -5.68689667e-02f, 1.81411430e-01f, 3.17877680e-02f, 4.43593264e-02f, 2.05972362e-02f, -1.06477313e-01f, -4.80196700e-02f, -1.33848980e-01f, 4.74617407e-02f,
  -2.50821486e-02f, 1.03090368e-01f, -1.12098763e-02f, 2.27123126e-02f, 3.41588855e-02f, -1.21494979e-01f, 4.98051047e-02f, -1.19448043e-02f, -1.46131560e-01f, -5.32480106e-02f,
  9.17600468e-02f, 1.22297123e-01f, 3.20336968e-03f, 7.48822093e-02f, 1.17725981e-02f, 7.36856759e-02f, 2.14234944e-02f, 7.57207051e-02f, 2.58809864e-03f, 1.78512316e-02f,
  9.04304758e-02f, 1.95737809e-01f, -4.34153304e-02f, -3.75839442e-01f, -9.25637111e-02f, 1.27176285e-01f, -1.40919447e-01f, 9.11668390e-02f, 2.97784477e-01f, -6.54433146e-02f,
  -3.91428098e-02f, 2.04360560e-02f, 2.84847438e-01f, -3.36533427e-01f, 2.92060077e-01f, 2.69705951e-01f, 3.02506201e-02f, -2.32677072e-01f, 1.11424938e-01f, -2.12253019e-01f,
  -1.15687758e-01f, -5.59189260e-01f, -3.17040175e-01f, -1.87604219e-01f, -5.46040177e-01f, -2.80695975e-01f, -1.57998204e-01f, -1.28534481e-01f, -2.59024203e-01f, 1.89901367e-02f,
  5.03956303e-02f, 9.09861326e-02f, -4.93707173e-02f, 1.77199885e-01f, 5.04624322e-02f, 9.02255299e-04f, -2.57377028e-02f, 4.02564369e-02f, 4.05258546e-03f, 5.03659435e-02f,
  -6.63959756e-02f, -5.29012159e-02f, -1.04456134e-02f, -8.77567753e-02f, 4.72463928e-02f, 6.05544113e-02f, 1.31094353e-02f, -1.22285463e-01f, -1.26310602e-01f, 1.23464637e-01f,
  -1.37481526e-01f, -1.05600327e-03f, -2.94474941e-02f, 1.17521897e-01f, -6.22963458e-02f, -3.54415141e-02f, -1.10443868e-02f, -1.42562598e-01f, 5.07566780e-02f, 1.63516134e-01f,
  1.57364264e-01f, 8.40104148e-02f, -3.90640013e-02f, 4.71160635e-02f, -1.36185259e-01f, -1.73868716e-01f, -1.51794152e-02f, -1.46788225e-01f, -7.58851320e-02f, -1.92552015e-01f,
  -1.57805458e-01f, 4.56386246e-02f, -2.60088779e-02f, 3.26143466e-02f, 1.48311816e-02f, -7.61877820e-02f, 7.87984654e-02f, -7.44506195e-02f, 9.70690101e-02f, 1.37363240e-01f,
  -1.19745567e-01f, 9.32492167e-02f, -1.01543434e-01f, -1.31032094e-02f, 6.91150203e-02f, -7.47851804e-02f, -1.21220499e-01f, -4.16139141e-03f, -3.64182852e-02f, -1.16950504e-01f,
  8.48992541e-02f, 1.31032646e-01f, 4.67224568e-02f, 2.51944624e-02f, -3.44182849e-02f, 3.44865732e-02f, -8.80319998e-02f, 1.20509453e-01f, 1.18576147e-01f, 9.68789831e-02f,
  -6.38902336e-02f, -1.62696928e-01f, 2.99627916e-03f, -4.78366651e-02f, -2.87223663e-02f, 9.29492414e-02f, -1.01464078e-01f, 1.71833634e-01f, -1.90309491e-02f, 9.18534920e-02f,
  -1.80161625e-01f, 6.10746071e-02f, -6.55369833e-02f, -6.40924200e-02f, -1.38197839e-01f, -9.88648236e-02f, -9.87050757e-02f, 2.35215705e-02f, -9.59794074e-02f, 1.04504690e-01f,
  4.16484661e-02f, -1.10412993e-01f, -1.29735753e-01f, 2.99859077e-01f, 3.67951430e-02f, -1.27539605e-01f, -3.55903566e-01f, 2.14856118e-01f, -2.00358376e-01f, -1.33080944e-01f,
  1.92710653e-01f, -1.36190802e-01f, -1.80234462e-01f, 4.15267676e-01f, 4.06107903e-01f, -1.96192548e-01f, 3.23575914e-01f, 1.02156103e-02f, 2.26452649e-02f, 2.91667819e-01f,
  2.36760885e-01f, 5.07965267e-01f, 2.83999681e-01f, 6.36741698e-01f, 2.50123560e-01f, 2.20335886e-01f, 4.35783476e-01f, 1.71916455e-01f, 4.72936958e-01f, 1.01277001e-01f,
  7.27270618e-02f, -1.84862502e-02f, -7.03168064e-02f, -8.17510858e-03f, 9.41415802e-02f, 7.07536116e-02f, -7.08632767e-02f, 4.98093888e-02f, -1.33560486e-02f, 1.00027867e-01f,
  -1.55795798e-01f, 1.32070230e-02f, -1.78785529e-02f, 1.50839522e-01f, 1.48049593e-01f, -9.25405941e-04f, 3.24750170e-02f, 3.21302190e-02f, -4.36614566e-02f, 1.10319167e-01f,
  -1.92935206e-02f, -2.06051879e-02f, -4.32463884e-02f, -1.24604078e-02f, -1.54882744e-02f, -4.75326069e-02f, -3.97653058e-02f, -4.16040868e-02f, -8.24277252e-02f, -5.04624285e-02f,
  3.98434736e-02f, 4.92220894e-02f, -7.81335011e-02f, -1.08705364e-01f, 6.92179129e-02f, -5.16520552e-02f, 8.83926302e-02f, -5.51011181e-03f, -9.18398201e-02f, 7.89382495e-03f,
  1.38643235e-02f, 1.53370768e-01f, -4.39577848e-02f, 4.27316763e-02f, 7.05473050e-02f, -5.77569753e-02f, 4.11665812e-02f, 2.11768858e-02f, -4.31466335e-03f, 2.40074862e-02f,
  5.12340926e-02f, 2.58676261e-01f, -4.64862026e-02f, -9.05278325e-02f, -5.53752370e-02f, -2.66686212e-02f, 1.40112877e-01f, -8.12076777e-03f, 2.28204783e-02f, -6.85270056e-02f,
  8.54579136e-02f, 2.27340907e-01f, -8.60803872e-02f, -1.06255807e-01f, -5.25321774e-02f, -7.60636851e-02f, -6.72503114e-02f, 6.95040673e-02f, 1.72351915e-02f, 2.64292974e-02f,
  1.52843729e-01f, 3.14498097e-02f, 6.65842742e-02f, 1.07079163e-01f, -1.16073182e-02f, 1.36011392e-01f, -2.62905546e-02f, -4.26306836e-02f, 4.77702916e-03f, 1.82623744e-01f,
  7.60209486e-02f, -6.34100288e-02f, -1.06774390e-01f, -7.59188235e-02f, -5.33614121e-02f, -4.79852483e-02f, 2.46259663e-02f, -3.78337987e-02f, 2.29674671e-02f, -3.90013345e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.67266184e-01f, 2.41819739e-01f, 4.79671419e-01f, 2.11928636e-01f, -3.88616860e-01f, -1.39514565e-01f, 3.24376285e-01f, 1.90150440e-01f, 3.73608656e-02f, 5.17629445e-01f,
  4.79073733e-01f, -1.50858546e-02f, 1.93217754e-01f, 1.14570543e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.21484011e-01f, -5.18438891e-02f, 1.51047125e-01f, 3.19159806e-01f, 9.79499668e-02f, -1.01905636e-01f, -3.83329064e-01f, -4.00033414e-01f, 2.59149849e-01f, 2.87374914e-01f,
  1.90212011e-01f, -2.26940513e-01f, -7.36465678e-02f, -8.47819000e-02f, -1.81474417e-01f, -1.42241076e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.99491131e-01f, -3.14286768e-01f, 9.71332043e-02f, -5.14004827e-01f, -6.97254241e-02f, 5.58414817e-01f, 7.13998795e-01f, 2.91202039e-01f, -7.00291172e-02f, -3.05037290e-01f,
  5.06837368e-01f, 3.05110186e-01f, 2.52384059e-02f, -6.24042749e-02f, 3.74438316e-01f, 4.28987473e-01f, -1.38098160e-02f, 9.06625837e-02f, -3.19749057e-01f, -1.29705071e-01f,
  1.35753214e-01f, 1.68729186e-01f, -3.01115483e-01f, 5.17530203e-01f, -4.56829488e-01f, 7.92888226e-04f, 1.49403960e-01f, 4.98497695e-01f, 4.63052869e-01f, -5.76957408e-03f,
  6.34607971e-01f, 3.05829793e-01f, 5.11818640e-02f, 7.61321843e-01f, -8.01159889e-02f, -1.93266943e-01f, 3.21216583e-01f, 3.05853397e-01f, -5.86629689e-01f, 2.14638695e-01f,
  -5.18772826e-02f, 1.10083930e-02f, -4.20220941e-02f, 6.62746489e-01f, 7.70924270e-01f, -2.39232123e-01f, 5.21561801e-01f, 2.24609345e-01f, 1.14933349e-01f, 1.81177370e-02f,
  -5.78144491e-01f, 2.47011125e-01f, 1.87749892e-01f, -1.10669620e-01f, -1.33618084e-03f, 8.03171515e-01f, 4.79936227e-02f, 4.79057282e-01f, 3.42949331e-01f, -2.37715036e-01f,
  2.41935197e-02f, 6.86715722e-01f, 2.46041253e-01f, -2.10322306e-01f, 2.63560086e-01f, -4.83268768e-01f, 1.42531041e-02f, 5.58570862e-01f, 3.33760411e-01f, -3.20871651e-01f,
  -2.96984702e-01f, 1.61651343e-01f, 5.60526438e-02f, 6.89350665e-01f, -4.31301119e-03f, 9.77624804e-02f, 3.76766682e-01f, 1.69318616e-01f, 2.81920046e-01f, 1.82393063e-02f,
  5.69273651e-01f, 1.26386553e-01f, 6.31179810e-01f, -1.64413944e-01f, -7.66309425e-02f, -2.16148823e-01f, -1.25828400e-01f, -4.47053254e-01f, 5.87904751e-01f, 1.69893041e-01f,
  -3.75618786e-01f, 3.67422253e-01f, 5.92269778e-01f, 1.03284322e-01f, -5.02282232e-02f, -3.22109312e-02f, 2.72183597e-01f, -5.26043236e-01f, -2.16811776e-01f, 3.09192568e-01f,
  1.18465148e-01f, 6.64395690e-01f, -2.84636229e-01f, -1.60942465e-01f, 6.34003460e-01f, 2.36619823e-03f, 4.96637791e-01f, 1.32741481e-01f, 1.60606906e-01f, 5.63108027e-01f,
  1.10470116e-01f, -2.15297744e-01f, 2.80899733e-01f, -4.64042544e-01f, 5.35305560e-01f, -5.86099364e-02f, 5.17275155e-01f, 4.32426572e-01f, 2.58028120e-01f, -1.35670543e-01f,
  1.79855183e-01f, -4.18218017e-01f, 6.93530142e-02f, 1.37883782e-01f, 2.05875129e-01f, -1.60454661e-01f, 4.17839438e-01f, 5.67724705e-01f, 1.85303092e-01f, -5.67642510e-01f,
  -3.16147983e-01f, 5.87819695e-01f, 5.52362263e-01f, 5.29600203e-01f, 4.69509184e-01f, -3.07471842e-01f, -2.81313032e-01f, -1.04120575e-01f, 6.76003098e-01f, -3.39999855e-01f,
  -1.95560604e-01f, 4.58647728e-01f, 4.29670662e-01f, 7.79289827e-02f, 2.40425348e-01f, -2.84767330e-01f, 7.15273917e-02f, -5.64542711e-01f, -3.81795168e-01f, -2.27300569e-01f,
  4.03055698e-01f, 6.07388675e-01f, -2.40084410e-01f, 2.48229250e-01f, 3.19095105e-02f, 6.16102874e-01f, 4.08375740e-01f, 5.35907388e-01f, 3.06042373e-01f, -5.77238441e-01f,
  1.65317059e-01f, 5.91005981e-01f, -1.18704647e-01f, 2.94261098e-01f, 3.80450845e-01f, 1.70406356e-01f, 2.68432856e-01f, 8.19289684e-01f, -8.19540977e-01f, 3.09291631e-01f,
  -9.87721607e-02f, -1.78307295e-01f, 2.56824315e-01f, -3.16470891e-01f, 1.32935485e-02f, 5.51647604e-01f, 4.62041080e-01f, -2.72096574e-01f, 1.32581741e-01f, -3.60503763e-01f,
  4.60612863e-01f, 6.91406190e-01f, 1.17118716e-01f, -4.95964400e-02f, 6.40591741e-01f, -2.95410007e-01f, 3.57022524e-01f, 4.33036804e-01f, 5.39391153e-02f, -1.29277036e-01f,
  -1.81643471e-01f, 5.57470202e-01f, 2.38011509e-01f, 1.15307674e-01f, 4.09952044e-01f, -1.62470445e-01f, -3.44800383e-01f, 1.30750924e-01f, -2.84338236e-01f, 5.30465879e-02f,
  -1.45436466e-01f, 6.99040890e-01f, -2.30541438e-01f, -3.56970638e-01f, 9.95242819e-02f, -1.20515205e-01f, -2.90291548e-01f, -2.39168257e-01f, 6.89272806e-02f, -7.63290584e-01f,
  -1.84782818e-02f, 8.13711405e-01f, 5.77496350e-01f, 4.17513877e-01f, 6.04707412e-02f, 1.01344123e-01f, 1.12533547e-01f, 4.90114331e-01f, 4.95224625e-01f, 3.64827141e-02f,
  -7.24586332e-03f, 1.54770419e-01f, 3.65416765e-01f, 4.12077844e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -1.38710320e-01f, 3.03513318e-01f, 6.45174682e-01f, 3.21476981e-02f, 6.35940135e-01f, 5.71480215e-01f, 6.29411414e-02f, 1.22332439e-01f, 1.83818176e-01f, -1.11284383e-01f,
  1.94882024e-02f, 2.38922805e-01f, -1.21044360e-01f, 3.58012855e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -8.51050615e-02f, -1.58037528e-01f, -9.58101731e-03f, -1.66680515e-01f, 5.84305786e-02f, 3.45866531e-01f, -3.43331069e-01f, -4.13204700e-01f, 2.90132016e-01f, -1.20301746e-01f,
  -3.69114615e-02f, -4.46634024e-01f, 1.18899718e-01f, 2.48272046e-01f, 1.65694788e-01f, -1.33879155e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  3.59447420e-01f, 2.33865350e-01f, -1.77914515e-01f, 6.20779693e-01f, 5.77506661e-01f, 4.29763764e-01f, 6.05636597e-01f, -2.10468560e-01f, 9.26329121e-02f, -1.79457754e-01f,
  4.06857699e-01f, 1.03381068e-01f, 5.22916853e-01f, -1.30215287e-01f, 1.99052632e-01f, 6.24145746e-01f, 4.71522838e-01f, 2.28909016e-01f, 2.91672826e-01f, -7.27492571e-02f,
  8.44591856e-03f, -5.26893735e-01f, 4.22531404e-02f, 6.31437421e-01f, 3.69204104e-01f, 5.35046458e-01f, 1.80195510e-01f, -2.96506852e-01f, -7.30269253e-01f, 5.13079584e-01f,
  -3.70059222e-01f, 8.28526169e-02f, -2.36116871e-01f, -3.32328528e-01f, 5.27380228e-01f, -3.67128223e-01f, -5.39928555e-01f, -3.87494892e-01f, -4.66339111e-01f, -1.16448747e-02f,
  -7.27665648e-02f, 6.19307995e-01f, 1.85901195e-01f, -2.08968014e-01f, 5.33984303e-01f, 2.46607155e-01f, -1.09785674e-02f, 3.39433014e-01f, 7.73585796e-01f, 3.38803142e-01f,
  -3.49648952e-01f, 1.23678900e-01f, 5.71864903e-01f, -1.30935356e-01f, 5.33872783e-01f, 5.85279763e-01f, -2.01022074e-01f, 3.11196476e-01f, -2.64511317e-01f, 1.54597908e-01f,
  2.69346833e-01f, -1.00965248e-02f, 8.94160569e-01f, 2.92214248e-02f, 5.60811520e-01f, -4.11737025e-01f, 2.85228401e-01f, 3.39602709e-01f, 7.23382175e-01f, -3.38272125e-01f,
  -9.21631679e-02f, 6.08010828e-01f, 2.49863341e-01f, 5.06272912e-01f, -2.12800622e-01f, 1.07025385e-01f, -1.18485041e-01f, 2.53087044e-01f, -3.54992986e-01f, 6.50180504e-02f,
  -3.29141736e-01f, -9.17048156e-02f, 4.19871330e-01f, 3.13573554e-02f, -3.45499605e-01f, 2.56547779e-01f, 5.99357821e-02f, -3.90420407e-01f, 1.09337293e-01f, 5.85269988e-01f,
  8.46056819e-01f, 2.67371267e-01f, 3.36937964e-01f, 1.28940150e-01f, -5.82720459e-01f, 4.42225724e-01f, -1.84356689e-01f, 6.55854493e-02f, 4.18541849e-01f, 7.55704939e-03f,
  -1.05487533e-01f, 6.02716982e-01f, 2.26647764e-01f, -3.71771812e-01f, 5.36730528e-01f, 2.25656480e-01f, 6.82532668e-01f, 1.88074127e-01f, 3.89798768e-02f, -7.94218928e-02f,
  -6.74467683e-01f, 3.80963355e-01f, -2.06601977e-01f, -1.82902381e-01f, 4.47551422e-02f, 4.45078239e-02f, -2.98605952e-02f, 7.18472660e-01f, 2.63117731e-01f, 2.88446277e-01f,
  4.83082533e-01f, -2.65761107e-01f, 3.03310473e-02f, 7.59883046e-01f, -2.77958155e-01f, 5.33301793e-02f, 6.81161582e-01f, 2.54139185e-01f, 4.50528890e-01f, 7.32202053e-01f,
  -2.67781615e-01f, -5.10644019e-01f, -2.54098475e-01f, 1.50517091e-01f, 4.26408559e-01f, 6.84268951e-01f, 5.41918993e-01f, 2.33433232e-01f, 3.28941345e-01f, 4.57957992e-03f,
  -5.88949323e-01f, 4.97327745e-01f, 5.33358991e-01f, 4.73789990e-01f, 7.92063892e-01f, 5.13769388e-01f, 1.72306940e-01f, -1.61640927e-01f, 2.73760736e-01f, -2.57435262e-01f,
  2.36436635e-01f, -1.46877453e-01f, 8.29790980e-02f, 5.53936720e-01f, 1.02433309e-01f, -5.34407258e-01f, 1.59705564e-01f, 5.92122138e-01f, -3.32374305e-01f, 3.78795415e-01f,
  1.56446159e-01f, -4.77072179e-01f, 2.50904895e-02f, 6.89591348e-01f, 2.81876951e-01f, 3.34562898e-01f, 2.30408907e-01f, 2.70122826e-01f, -3.66595447e-01f, -9.75629166e-02f,
  2.23927826e-01f, 7.57696033e-01f, 8.51922333e-01f, -8.21735989e-03f, 1.88108310e-01f, 2.48434395e-03f, 1.90101936e-01f, -3.13151240e-01f, 3.29018123e-02f, -2.16237426e-01f,
  4.26846594e-01f, -4.62430626e-01f, -3.01470250e-01f, 3.09446365e-01f, 2.43777320e-01f, 4.35667813e-01f, -2.51201212e-01f, -6.44083768e-02f, -4.16459024e-01f, 4.36187893e-01f,
  -5.84875822e-01f, 2.36900281e-02f, 1.65318802e-01f, -7.93008983e-01f, 8.22786927e-01f, 7.25268304e-01f, 5.87095499e-01f, -1.93421766e-02f, -3.85091245e-01f, -4.01748419e-01f,
  1.57863662e-01f, 4.70934302e-01f, 1.31171227e-01f, 3.16126019e-01f, 6.62397742e-02f, 6.11784756e-01f, -6.05567336e-01f, 2.37565205e-01f, 1.64611250e-01f, 6.70072556e-01f,
  -3.74107897e-01f, -1.41758636e-01f, -3.15186977e-01f, 2.54841268e-01f, 4.23442274e-01f, -7.58799389e-02f, 4.54387963e-02f, 1.22879885e-01f, 4.12509561e-01f, -3.08307588e-01f,
  3.96359324e-01f, -1.51051149e-01f, 5.53271353e-01f, 5.32633960e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  3.20371717e-01f, 2.69615769e-01f, -1.37622610e-01f, 6.43954813e-01f, 3.96133423e-01f, -3.45531404e-02f, -9.46199447e-02f, -1.53392196e-01f, 4.46265429e-01f, 1.47851616e-01f,
  -5.78314550e-02f, 3.50043803e-01f, -2.01227397e-01f, 2.73161322e-01f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  3.45763355e-01f, -7.44341984e-02f, -3.01858373e-02f, -8.09449516e-03f, -2.39904746e-01f, 3.23934853e-01f, -9.57193673e-02f, 1.31755825e-02f, -2.37791017e-01f, -2.16440827e-01f,
  -1.23653769e-01f, 3.23570907e-01f, 2.92868197e-01f, -4.27922726e-01f, 5.56959491e-03f, 1.94979444e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -1.48379141e-02f, -5.82428694e-01f, 3.56682599e-01f, -4.03341204e-01f, -5.72022378e-01f, 4.27333534e-01f, 3.09676170e-01f, 7.03742057e-02f, 1.86825410e-01f, 5.61212301e-01f,
  -3.68343920e-01f, -1.76412120e-01f, 7.59968519e-01f, -1.01602435e-01f, 5.44150770e-01f, -4.61422056e-01f, 6.94001913e-02f, -6.09250426e-01f, 3.30122173e-01f, 1.89500287e-01f,
  6.07975014e-02f, 7.62449205e-01f, 2.23404020e-01f, -2.63015896e-01f, -3.33902448e-01f, -4.97329682e-01f, 8.29135925e-02f, 2.57404655e-01f, 1.05763786e-01f, 2.42545336e-01f,
  -2.11552903e-01f, 1.39473110e-01f, -5.97120821e-01f, -8.17681670e-01f, 1.33390725e-01f, 4.17408288e-01f, -3.33395451e-01f, 4.77382302e-01f, 3.47605020e-01f, -3.28616858e-01f,
  -3.99053007e-01f, 4.98488218e-01f, 4.96682614e-01f, -2.35109597e-01f, 3.51185113e-01f, 3.91376615e-01f, -1.18310347e-01f, -2.33496249e-01f, 2.96405822e-01f, 1.39029816e-01f,
  5.19467175e-01f, 4.34317999e-03f, -3.68037462e-01f, 3.57799888e-01f, -2.89411008e-01f, 1.61648840e-01f, 4.17268425e-01f, 2.36132413e-01f, 5.32002032e-01f, 3.91169876e-01f,
  -3.52757275e-01f, -2.05520526e-01f, -3.27662587e-01f, 7.70069122e-01f, -2.06589118e-01f, -1.56781077e-01f, -2.33991623e-01f, 6.14960074e-01f, -4.08220559e-01f, 3.13086897e-01f,
  4.79314268e-01f, -3.31378639e-01f, -9.38890278e-02f, 4.35363084e-01f, 6.53566420e-01f, 3.52063507e-01f, -4.78428125e-01f, 5.77580631e-01f, -8.55168179e-02f, -2.15034053e-01f,
  4.03264761e-01f, 6.51680529e-01f, 2.24735573e-01f, -1.64785907e-01f, 7.80478418e-01f, -5.90160847e-01f, 1.39598384e-01f, 7.27280736e-01f, 7.08382308e-01f, 2.15587720e-01f,
  -8.39168206e-02f, 2.40021765e-01f, 1.91326335e-01f, 5.67779168e-02f, 3.96762967e-01f, 1.78480521e-01f, -3.94649446e-01f, -3.26578975e-01f, 3.88857931e-01f, -2.47958213e-01f,
  -3.91240090e-01f, 1.96009055e-01f, 2.46933654e-01f, 5.46306651e-03f, 1.37353092e-01f, 2.59346426e-01f, -3.08070511e-01f, -2.93938350e-02f, 5.12869656e-01f, -4.18322273e-02f,
  3.55868965e-01f, -2.99439609e-01f, -5.05858846e-02f, -6.55276299e-01f, -1.56781867e-01f, 3.03188205e-01f, 7.11262345e-01f, 5.28690636e-01f, 4.36182439e-01f, 2.78482944e-01f,
  -2.07569331e-01f, -4.06868935e-01f, -5.23052774e-02f, 4.79619920e-01f, 2.27925658e-01f, 1.28783330e-01f, 8.96793902e-02f, 9.47162211e-02f, -1.57010630e-01f, 1.65308356e-01f,
  -2.79249310e-01f, 6.39402270e-01f, 3.75784099e-01f, -3.37627620e-01f, 2.31167227e-01f, 5.14675438e-01f, 5.03141642e-01f, -2.61819605e-02f, 1.93464458e-01f, 2.01968879e-01f,
  -2.55058199e-01f, 2.49269143e-01f, 3.82190943e-01f, -1.59368113e-01f, 7.60577098e-02f, -3.73075120e-02f, 3.36808681e-01f, 3.46240252e-01f, -2.69940704e-01f, -2.34701455e-01f,
  -2.19715476e-01f, 2.50336498e-01f, 5.97133279e-01f, 5.30143499e-01f, 5.89501798e-01f, -1.57021061e-01f, 7.97619075e-02f, -2.33443916e-01f, -1.75046355e-01f, 4.93509859e-01f,
  2.89044797e-01f, 2.08735019e-01f, 2.33878180e-01f, 5.71735442e-01f, 2.19258621e-01f, -9.90239456e-02f, 3.42904031e-01f, -8.61259773e-02f, -8.42278972e-02f, -3.12338024e-01f,
  -1.30553460e-02f, 5.78828573e-01f, -9.57111120e-02f, 6.39016986e-01f, 7.39489615e-01f, -3.60928148e-01f, -1.24992535e-01f, -3.65274727e-01f, 5.64850152e-01f, -3.25464010e-01f,
  -1.19741082e-01f, 6.59383476e-01f, 5.72173484e-02f, -1.02765433e-01f, -7.76681006e-02f, 2.52202690e-01f, 2.11921081e-01f, 8.82025212e-02f, 4.74942446e-01f, -2.31009200e-01f,
  -3.36035192e-01f, 6.52097225e-01f, 2.33384341e-01f, 8.59279931e-01f, 1.10537931e-02f, 1.57856762e-01f, 3.20205003e-01f, -1.20141804e-01f, -2.01452181e-01f, 1.72003984e-01f,
  -3.51842903e-02f, 1.32091910e-01f, 3.30723196e-01f, 1.60401985e-01f, 5.89813702e-02f, 1.73465222e-01f, 2.60378383e-02f, 1.42025992e-01f, 3.01319689e-01f, -3.18237878e-02f,
  3.21589023e-01f, -2.94121653e-01f, -1.24040470e-01f, -3.79478335e-01f, -1.14558876e-01f, 3.97664100e-01f, 4.30868328e-01f, 3.78325403e-01f, -1.64571583e-01f, -9.70436633e-02f,
  1.72141194e-01f, -2.89601445e-01f, 1.75512880e-01f, 2.40624025e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  3.18517655e-01f, 2.13128999e-01f, 4.37226743e-01f, 1.05783872e-01f, 2.72129446e-01f, -1.91547051e-01f, 7.43150041e-02f, 1.92890037e-02f, 3.75525258e-03f, 1.17462508e-01f,
  1.13746755e-01f, 3.54348212e-01f, 6.28721528e-03f, 5.56564890e-03f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -1.61252022e-01f, -2.90087074e-01f, -6.40683711e-01f, -5.43924093e-01f, -4.75323975e-01f, 3.58856648e-01f, 7.14189559e-02f, 2.38330290e-01f, -4.84603703e-01f, -4.10198599e-01f,
  2.41588190e-01f, 5.63124530e-02f, 1.75189510e-01f, -6.00605488e-01f, 1.37242496e-01f, 6.85106963e-02f, -4.36702430e-01f, -5.08942157e-02f, -2.03161657e-01f, -3.59545648e-02f,
  -1.14972435e-01f, -4.60309476e-01f, 5.10228992e-01f, 1.54625505e-01f, -4.74022776e-01f, 1.38771012e-01f, 1.52199373e-01f, -2.99600780e-01f, 2.28809401e-01f, -1.11998224e+00f,
  2.82558024e-01f, -6.87503278e-01f, 2.90397462e-02f, 3.10504109e-01f, 3.01797360e-01f, 3.88299562e-02f, -9.07248914e-01f, -5.37717976e-02f, -4.32932466e-01f, 3.03953409e-01f,
  6.75213784e-02f, 6.80107772e-02f, -2.55113751e-01f, -7.52593637e-01f, 3.25383276e-01f, -1.40026780e-02f, 4.96634617e-02f, -1.87702067e-02f, 1.35252997e-01f, -6.77294314e-01f,
  -7.28612319e-02f, -5.24662316e-01f, -2.57661462e-01f, 3.63270849e-01f, 7.19077885e-02f, 1.71617985e-01f, -5.49046397e-01f, -9.95877385e-01f, -2.80398160e-01f, 3.17614347e-01f,
  -6.85776651e-01f, -1.07177561e-02f, 3.14865053e-01f, 8.25017914e-02f, 5.60844596e-03f, 9.72668171e-01f, 1.40385451e-02f, 2.00724602e-01f, -1.97448000e-01f, 2.99020976e-01f,
  -2.67520249e-01f, 2.24278361e-01f, -1.66026488e-01f, 1.18231930e-01f, -6.85787275e-02f, 4.46267538e-02f, -2.57066965e-01f, 3.48812230e-02f, -1.96278751e-01f, -8.36236519e-04f,
  4.38978046e-01f, -7.08889246e-01f, 3.57271224e-01f, -2.51866281e-01f, 1.78585067e-01f, 3.55365910e-02f, 2.48207226e-01f, -1.32718772e-01f, -3.58704142e-02f, -1.01110913e-01f,
  4.67733704e-02f, -2.25580454e-01f, 2.70495057e-01f, -3.51180851e-01f, -4.38990176e-01f, -8.18830878e-02f, -2.35667795e-01f, -1.93972215e-01f, 4.58626509e-01f, -2.21864879e-01f,
  2.68255711e-01f, -6.12808228e-01f, -5.42136490e-01f, 1.21552430e-01f, 3.76752645e-01f, -9.04495120e-02f, -4.04965609e-01f, -5.39487004e-01f, -3.13783020e-01f, 1.03945650e-01f,
  -5.67583382e-01f, 6.25220463e-02f, 3.70524004e-02f, -3.68312091e-01f, 3.61492097e-01f, -7.10687637e-01f, -4.75392222e-01f, -3.33372712e-01f, -6.89998090e-01f, 3.17360520e-01f,
  2.23080829e-01f, -5.12317777e-01f, 1.66734308e-01f, 1.65910751e-01f, -4.33677584e-01f, -2.36897752e-01f, -1.74850821e-01f, 3.73065084e-01f, -1.25157610e-01f, -1.59706861e-01f,
  -6.13921881e-01f, -4.12280113e-01f, -8.47914040e-01f, -4.50476408e-01f, -4.75600690e-01f, 3.74866903e-01f, -6.74750924e-01f, 4.34588671e-01f, 2.20577270e-01f, -3.12316060e-01f,
  2.48389423e-01f, -5.23588955e-01f, 1.19900890e-01f, -4.73179482e-02f, 2.60255933e-01f, 8.80541086e-01f, 2.15281591e-01f, 4.33047205e-01f, 3.93802255e-01f, -7.27137744e-01f,
  2.69907564e-01f, -6.30594671e-01f, 7.93878585e-02f, 4.24363196e-01f, -4.53775287e-01f, -1.02515352e+00f, 2.64968965e-02f, 5.52403107e-02f, -4.94572788e-01f, -6.56897724e-01f,
  3.71447563e-01f, -4.05905247e-01f, -8.26113582e-01f, 2.02034637e-01f, 6.28888160e-02f, 4.36773837e-01f, 4.44449246e-01f, -2.33831987e-01f, -1.25812757e+00f, 2.84920543e-01f,
  2.88025830e-02f, 6.83813319e-02f, -2.01364473e-01f, -1.36730541e-02f, -1.25620633e-01f, -3.37938726e-01f, 3.63262445e-02f, 2.76892688e-02f, 8.13391432e-02f, 1.71332300e-01f,
  4.98384655e-01f, 2.13591516e-01f, 8.93327370e-02f, -6.23586237e-01f, -1.83759376e-01f, 1.18699603e-01f, -6.63013577e-01f, -1.84079334e-01f, -8.53444815e-01f, 4.05037224e-01f,
  9.37052518e-02f, -2.98816383e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.35046729e-01f, -1.73816215e-02f, 1.29500162e-02f, 4.54382561e-02f, 2.49199554e-01f, -8.94372761e-02f, 9.76261646e-02f, 6.77039474e-02f, -1.49596885e-01f, 1.20982721e-01f,
  -2.98960209e-02f, 1.09798320e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    