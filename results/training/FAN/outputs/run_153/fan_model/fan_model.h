/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.10527921e-01f, -2.30081737e-01f, -3.05170923e-01f, -8.04471225e-03f, 2.42232438e-02f, -1.92478284e-01f, -4.90139723e-02f, -3.52944992e-02f, -3.07914871e-03f, 9.32759121e-02f,
  9.39415023e-02f, -1.07577801e-01f, -4.18154560e-02f, -3.88457030e-02f, -2.58469850e-01f, -6.80189356e-02f, 6.71304911e-02f, 9.92323458e-02f, -6.75647855e-02f, -1.09986579e-02f,
  2.25672610e-02f, 1.67792048e-02f, -1.44071087e-01f, -5.11527397e-02f, 5.01476880e-03f, 3.46778296e-02f, 1.68086737e-01f, -2.22238645e-01f, -2.40239222e-02f, -7.05575943e-02f,
  4.83215414e-02f, 5.72806923e-04f, -2.54542939e-03f, -5.70953041e-02f, -1.41703263e-02f, 2.34575532e-02f, 1.41299143e-02f, -6.21022731e-02f, -4.52957302e-03f, -3.47247571e-02f,
  8.69297534e-02f, -1.46615668e-03f, -1.60556415e-03f, -4.39299121e-02f, 4.42429483e-02f, -4.54685709e-04f, -4.26158234e-02f, 4.52149920e-02f, -2.21857801e-02f, 3.64367254e-02f,
  1.29525336e-02f, 8.59946609e-02f, 1.32644489e-01f, 2.27995683e-02f, -1.22797219e-02f, 2.35039201e-02f, -2.76305862e-02f, -2.93991379e-02f, 2.45820154e-02f, 1.99097842e-02f,
  7.77726099e-02f, 2.04499811e-02f, 4.66546565e-02f, -3.55043970e-02f, -5.40897511e-02f, -1.04076182e-02f, 8.62528197e-03f, 3.50697599e-02f, -4.85294238e-02f, -2.92429607e-02f,
  -3.84546770e-03f, -4.41663489e-02f, 2.60113366e-02f, -3.66406925e-02f, 4.78601195e-02f, 6.14016727e-02f, 1.26159042e-02f, -2.73178946e-02f, 2.05501681e-03f, -4.64073904e-02f,
  4.48288284e-02f, -3.91903892e-02f, -6.66126162e-02f, 8.59099627e-02f, -1.70250665e-02f, -8.41222331e-03f, -1.72330998e-02f, -4.13768589e-02f, 3.49095603e-03f, 2.95905885e-03f,
  -1.83993895e-02f, -2.28760630e-01f, -9.92910042e-02f, 8.61081015e-03f, -1.04205333e-01f, -6.10238500e-02f, -1.91884004e-02f, 2.44105496e-02f, -5.44773357e-04f, -7.48664290e-02f,
  2.63362844e-02f, 4.75051366e-02f, 8.03408101e-02f, -2.96162162e-02f, -4.45306227e-02f, -5.82797341e-02f, 6.13346733e-02f, -3.81407258e-03f, 4.35879380e-02f, -4.44204137e-02f,
  2.40330994e-02f, 3.07207126e-02f, -2.92886868e-02f, -1.19945528e-02f, 7.24818408e-02f, 8.52956250e-02f, -2.03857291e-02f, 5.15537485e-02f, 6.20421357e-02f, 1.42192310e-02f,
  4.37013447e-01f, -7.75909796e-02f, -9.83553380e-02f, 1.47796795e-01f, 3.17107886e-01f, -1.49780929e-01f, -9.57690552e-02f, 2.29024753e-01f, 1.05451308e-01f, -6.49736896e-02f,
  8.74284953e-02f, -1.61765680e-01f, -1.07974023e-01f, -5.69131784e-02f, -2.24961266e-01f, -3.06811810e-01f, -7.57504627e-02f, -6.05350062e-02f, -5.49572520e-02f, 1.07786812e-01f,
  1.32321820e-01f, 1.41052410e-01f, -8.88942704e-02f, 1.60337240e-01f, 2.82534838e-01f, 1.47835970e-01f, 3.07036117e-02f, 3.23987082e-02f, -1.07581597e-02f, -6.19516484e-02f,
  5.48571460e-02f, 1.57362893e-01f, 5.98592274e-02f, -1.41247967e-02f, 7.98164159e-02f, 1.35357287e-02f, 2.45983601e-02f, -1.27754644e-01f, -8.49699154e-02f, -3.78764123e-02f,
  -4.27568592e-02f, 2.78975125e-02f, -7.64257926e-03f, -4.45269123e-02f, 8.93722773e-02f, -2.17594821e-02f, -2.90265121e-02f, -3.05507202e-02f, -1.71527360e-02f, 2.07852945e-02f,
  -5.64569719e-02f, -3.26101072e-02f, 1.00358352e-02f, -3.65479738e-02f, -1.16213216e-02f, -1.84418540e-02f, -6.51629418e-02f, -2.00888570e-02f, -2.44448371e-02f, 2.39085332e-02f,
  -1.55236106e-02f, 3.42498068e-03f, -4.29383069e-02f, -5.63240610e-02f, -3.48238051e-02f, 7.75271878e-02f, -9.65350792e-02f, -2.69201379e-02f, 3.04262131e-03f, 2.21030489e-02f,
  7.72132352e-02f, 3.52093540e-02f, 4.72068079e-02f, -3.73502150e-02f, -4.37688874e-03f, 2.26912647e-03f, -4.66339402e-02f, 3.47742662e-02f, 9.66891274e-02f, 3.78730521e-02f,
  1.97922550e-02f, 3.72326409e-04f, 6.29971921e-02f, -1.03771780e-02f, -3.56720649e-02f, -4.22515608e-02f, 6.59739897e-02f, 3.38817909e-02f, -2.21119449e-02f, 2.02106871e-02f,
  9.07109529e-02f, 9.88033712e-02f, 3.86902294e-03f, 2.22035218e-02f, -4.77584079e-02f, -2.77249292e-02f, -7.38505051e-02f, 4.47089560e-02f, -3.48082967e-02f, 2.65159644e-02f,
  2.21558399e-02f, 1.30841078e-03f, 5.20244092e-02f, 3.62927429e-02f, -1.70010421e-02f, 3.16113867e-02f, -1.31986942e-02f, 2.75553595e-02f, -5.24026388e-03f, 4.39064801e-02f,
  6.54926822e-02f, -3.50159651e-04f, -5.59237003e-02f, 6.76311478e-02f, 3.60963792e-02f, 1.28564313e-02f, 3.38732004e-02f, -1.07695004e-02f, -3.96937579e-02f, -6.15205579e-02f,
  -3.40715677e-01f, 2.47277543e-01f, -3.02563250e-01f, -2.55341649e-01f, 6.82094917e-02f, -1.71669915e-01f, -2.08082393e-01f, 1.15204424e-01f, -5.84478676e-02f, 2.35498071e-01f,
  1.43213585e-01f, -4.94284555e-02f, 1.87912777e-01f, 1.12246826e-01f, -1.73059016e-01f, 1.20859720e-01f, -1.26647025e-01f, -9.63411257e-02f, 1.31092500e-02f, 7.16194659e-02f,
  -9.69822630e-02f, 2.51977623e-01f, -4.09464240e-02f, 2.11356267e-01f, -5.58891930e-02f, -8.47821981e-02f, 1.84027329e-01f, -5.58001474e-02f, -2.33231690e-02f, 1.25818690e-02f,
  -4.89004068e-02f, 1.10211484e-01f, -2.65309699e-02f, -7.51657225e-03f, -2.53158771e-02f, 2.04275027e-02f, -8.31424072e-02f, -3.12586278e-02f, -2.98033152e-02f, 9.39059351e-03f,
  -4.27825414e-02f, 5.47580905e-02f, -2.69048437e-02f, -4.45980392e-03f, -1.21102156e-02f, -3.74036469e-02f, -3.17505375e-02f, -3.55592705e-02f, 2.44113468e-02f, -2.84062661e-02f,
  -3.28587778e-02f, -2.01491211e-02f, -4.69975844e-02f, 4.45318297e-02f, -6.86957091e-02f, -1.01362905e-02f, -4.22410257e-02f, -4.62597199e-02f, -1.32750571e-02f, 1.40964556e-02f,
  4.41893749e-02f, 5.66253113e-03f, 2.57078204e-02f, 4.39160457e-03f, 3.03103607e-02f, 4.41957377e-02f, 5.07043973e-02f, 4.81092148e-02f, -7.58569166e-02f, 3.87136266e-02f,
  -5.16034849e-03f, 1.01869283e-02f, 2.83064898e-02f, -2.05886196e-02f, -1.30940890e-02f, 8.57048295e-03f, -4.86288555e-02f, 3.91777791e-02f, -7.78527260e-02f, -4.68601994e-02f,
  4.98704575e-02f, -5.60543733e-03f, -1.50852865e-02f, 3.84606868e-02f, 1.47742573e-02f, -1.10408477e-02f, 6.86966106e-02f, -1.08613716e-02f, 5.63182356e-03f, -5.89814521e-02f,
  7.40434602e-02f, 1.60697564e-01f, 2.09070742e-02f, -2.92702690e-02f, -1.72835775e-02f, 7.22240098e-03f, -2.16654297e-02f, 6.35010516e-03f, 3.20113786e-02f, 7.98693597e-02f,
  -6.43861741e-02f, 3.02467793e-02f, -2.39979639e-03f, -5.55928200e-02f, -3.91130373e-02f, 5.90483546e-02f, -2.78814975e-02f, 8.90685432e-03f, -3.66850793e-02f, 9.40397605e-02f,
  8.53936304e-04f, 1.84657201e-02f, -1.76475048e-02f, 3.49202752e-02f, -1.52418986e-02f, 8.99444055e-03f, -6.33774623e-02f, -1.70896351e-02f, -2.31894758e-02f, -1.06746759e-02f,
  -1.80784613e-01f, 9.17455032e-02f, -3.21331881e-02f, -4.67984341e-02f, 4.32850197e-02f, 6.18249364e-02f, 5.34016825e-02f, 2.21026137e-01f, 2.75176734e-01f, -2.14197990e-02f,
  1.74147487e-01f, -3.88591975e-01f, 2.40538329e-01f, -8.84000510e-02f, -2.02364594e-01f, 2.24190921e-01f, -4.86927368e-02f, -1.78449273e-01f, 1.66229263e-01f, -4.59872559e-02f,
  2.03990657e-02f, -1.29091725e-01f, -1.63152926e-02f, -4.67130914e-02f, -1.65257722e-01f, -3.69881913e-02f, -3.26732427e-01f, -2.79280618e-02f, -2.72680521e-01f, -1.14960000e-01f,
  7.20688552e-02f, 1.47645250e-01f, 1.11300042e-02f, -5.11280224e-02f, 4.47622165e-02f, 3.23900990e-02f, -1.39614016e-01f, -8.19153115e-02f, 5.61992712e-02f, 1.78452476e-03f,
  -4.78123389e-02f, -6.26137853e-02f, 1.64419804e-02f, -5.52359037e-02f, 1.79302401e-03f, 9.12658963e-03f, -1.00549823e-02f, 1.58496816e-02f, -4.53344285e-02f, 5.32772802e-02f,
  3.64490114e-02f, 4.51996624e-02f, -3.18831652e-02f, -4.41446551e-04f, -3.00423503e-02f, 4.08420758e-03f, -8.06249119e-03f, -6.49014413e-02f, -5.81904203e-02f, 2.54698470e-03f,
  -7.91100319e-03f, 4.94951569e-02f, -9.85339470e-03f, 8.06694292e-03f, -2.52154097e-03f, 1.87147912e-02f, -1.13055911e-02f, 2.53200321e-03f, -1.89506111e-03f, -7.56358216e-03f,
  -1.14240330e-02f, -2.23580450e-02f, 7.79609531e-02f, -3.97379557e-03f, -1.88185629e-02f, 7.25508407e-02f, -7.68049657e-02f, -5.97257987e-02f, 5.35499677e-02f, 3.69188078e-02f,
  3.12803872e-02f, -2.96913348e-02f, 3.08157187e-02f, 5.94808394e-03f, 9.24508348e-02f, 2.19968483e-02f, -2.54286395e-04f, -1.88556761e-02f, 8.74905139e-02f, -5.86067550e-02f,
  -5.42531535e-02f, -9.22789797e-02f, 2.57276110e-02f, -2.07884647e-02f, 3.93323973e-02f, -2.89058890e-02f, 3.34991924e-02f, -4.77306247e-02f, -4.99677658e-02f, 1.14006214e-02f,
  -5.83874285e-02f, -5.54561103e-03f, -8.99610519e-02f, 7.95873702e-02f, -8.08140412e-02f, 2.36791559e-02f, -4.73490618e-02f, -3.37695852e-02f, -4.08067591e-02f, -2.79032066e-02f,
  -2.91264560e-02f, 3.51162329e-02f, -2.36996100e-03f, 5.92147969e-02f, -1.90119501e-02f, -2.84132976e-02f, 2.57047117e-02f, -3.11508286e-03f, -6.94836676e-03f, 9.53040645e-03f,
  -3.96586657e-02f, 5.31526089e-01f, -1.24865277e-02f, 2.82370776e-01f, -2.46496443e-02f, 2.16180146e-01f, 7.48238638e-02f, 1.77782848e-01f, 1.62151784e-01f, 1.34117916e-01f,
  -2.55786907e-02f, 7.48638213e-02f, -1.30644947e-01f, 2.58662701e-01f, -5.52060530e-02f, 1.02477349e-01f, 2.15355530e-01f, 5.91281615e-02f, 6.24818653e-02f, 9.06709954e-02f,
  4.97938246e-02f, 1.29813150e-01f, 4.60019074e-02f, 5.92958219e-02f, 1.01495720e-01f, 1.81509499e-02f, -2.29523152e-01f, -9.69966277e-02f, 9.25237611e-02f, -4.76663746e-02f,
  1.58058833e-02f, 6.64977357e-02f, -1.87818182e-03f, -9.19764042e-02f, -9.94701609e-02f, -7.61044845e-02f, -5.42543530e-02f, -3.58160846e-02f, -1.26472628e-02f, 4.88139056e-02f,
  -1.58228483e-02f, 4.04496826e-02f, 6.19136058e-02f, 4.70038736e-03f, 3.98625843e-02f, 4.29972410e-02f, 9.78013277e-02f, 3.88561152e-02f, 1.20601736e-01f, 9.20704901e-02f,
  1.23591118e-01f, 8.06591585e-02f, 2.26008575e-02f, 5.02173118e-02f, 1.70654524e-02f, 8.00064430e-02f, 1.58369988e-02f, -4.72201258e-02f, 4.64836210e-02f, 9.06084105e-02f,
  1.85798146e-02f, -5.93870953e-02f, -1.24731064e-02f, 1.28782610e-03f, 1.87159646e-02f, -5.95605224e-02f, 7.18427449e-02f, -8.39154497e-02f, -5.90254646e-03f, 5.50259650e-03f,
  4.31863451e-03f, 1.99750271e-02f, 1.75882746e-02f, 3.04996502e-02f, -1.11905765e-02f, 4.11560722e-02f, -3.57843228e-02f, -4.50893790e-02f, 6.59122765e-02f, -1.33402934e-02f,
  -6.11417554e-03f, 2.01641973e-02f, 2.08574142e-02f, -4.03752774e-02f, 3.35454531e-02f, -3.99312899e-02f, 1.89209171e-02f, 7.62427300e-02f, 5.21837035e-03f, -8.34625810e-02f,
  -5.48001491e-02f, -1.34906292e-01f, 8.47840589e-03f, 5.39004132e-02f, -1.49945365e-02f, 4.86116223e-02f, 2.86920811e-03f, 3.69214378e-02f, -1.23093454e-02f, -5.67528270e-02f,
  -2.89311893e-02f, 2.00152071e-03f, -5.64775839e-02f, -1.36051150e-02f, 2.25455244e-03f, 3.95012181e-03f, -7.91309029e-02f, -2.31301114e-02f, -8.63775015e-02f, 6.56401564e-04f,
  -6.84275329e-02f, -3.02047897e-02f, -3.13191339e-02f, -4.59637865e-03f, -6.16306886e-02f, -5.59168085e-02f, -4.15939391e-02f, 6.75878450e-02f, -1.60099324e-02f, -3.71459639e-03f,
  3.32979381e-01f, 4.72752377e-02f, -1.92458764e-01f, 2.48491988e-01f, 5.89637868e-02f, 1.41750544e-01f, 1.35848626e-01f, 3.72062176e-02f, 1.20619923e-01f, 9.87789854e-02f,
  4.09909301e-02f, 1.20435804e-02f, -1.97814122e-01f, 2.79330373e-01f, 8.83769169e-02f, -1.38555244e-01f, 2.88406551e-01f, 1.86720967e-01f, 8.31054896e-03f, 1.71731979e-01f,
  3.51382978e-02f, 2.79491633e-01f, -1.33576438e-01f, -4.40592878e-02f, 1.13990635e-01f, -6.18302003e-02f, 6.79941252e-02f, -2.34325245e-01f, 1.40235841e-01f, -5.16436175e-02f,
  1.47849321e-01f, 2.54240818e-02f, 3.23630981e-02f, -2.09431294e-02f, 3.32522616e-02f, 3.34484391e-02f, -3.84640992e-02f, -9.58837122e-02f, -6.85646161e-02f, -1.57779120e-02f,
  -9.83878225e-03f, 5.98050132e-02f, 4.15608585e-02f, -1.23491697e-02f, 2.69818287e-02f, -1.22797554e-02f, 1.03913303e-02f, 1.27693135e-02f, -4.24578339e-02f, -1.58465300e-02f,
  -1.29859764e-02f, -2.01744791e-02f, 3.25676948e-02f, 1.68805420e-02f, -6.82215691e-02f, 3.46067473e-02f, 4.07687854e-03f, -7.32025579e-02f, 3.27639282e-02f, 6.72580749e-02f,
  -8.81308243e-02f, -1.49300247e-02f, -4.86587472e-02f, 4.75177765e-02f, -4.84023150e-03f, 6.97009172e-03f, 1.25314882e-02f, -3.28794532e-02f, -1.55719239e-02f, 2.16205902e-02f,
  9.05285254e-02f, 1.45760821e-02f, -1.13918306e-02f, 4.85979803e-02f, 2.35917103e-02f, 6.29584342e-02f, 2.52778474e-02f, 3.56159620e-02f, 5.30673787e-02f, -1.27520524e-02f,
  -1.47321625e-02f, 1.34545537e-02f, 6.80639036e-03f, -2.41467021e-02f, -1.09014381e-02f, -6.00716285e-02f, 2.70411689e-02f, 1.52332094e-02f, -5.15770391e-02f, 9.24134441e-03f,
  3.38807315e-01f, 1.64951652e-01f, -2.00994704e-02f, 2.98634060e-02f, 2.23856159e-02f, 5.80437966e-02f, 4.33212556e-02f, 2.82326359e-02f, -3.44495312e-03f, 1.85062587e-02f,
  5.16777821e-02f, 3.27911749e-02f, -2.10756366e-03f, 5.60905449e-02f, 1.28146093e-02f, 1.29119949e-02f, 1.95380002e-02f, 7.29280636e-02f, 1.20080516e-01f, 5.46960607e-02f,
  3.19341905e-02f, 3.04722525e-02f, -3.08086071e-02f, 2.69040298e-02f, 2.92434245e-02f, -6.25677349e-04f, 6.67281747e-02f, -2.43985802e-02f, -1.01627447e-02f, 1.43507272e-02f,
  4.45837319e-01f, -3.61362338e-01f, 3.09440374e-01f, 2.30078802e-01f, -1.55967668e-01f, -3.09361160e-01f, -5.08327328e-04f, -1.12221017e-01f, 1.03188477e-01f, -1.62561134e-01f,
  -7.24239349e-02f, 7.08649606e-02f, 4.49268892e-02f, -9.04427841e-02f, 1.49761096e-01f, 7.33695179e-02f, -3.26080360e-02f, -6.43837005e-02f, -4.69756238e-02f, 1.96800847e-02f,
  6.99317828e-02f, -1.29877716e-01f, 1.93778038e-01f, -2.67239332e-01f, 1.56561136e-02f, 4.31973301e-02f, 9.29135978e-02f, 3.04702297e-02f, -2.94485688e-02f, -8.21557641e-02f,
  2.97526852e-03f, 4.00624648e-02f, 4.63788956e-02f, 4.52224957e-03f, 6.98708743e-03f, 6.60011470e-02f, 5.33636473e-02f, 6.15210235e-02f, 4.78186868e-02f, -1.17236273e-02f,
  -1.08475490e-02f, -4.23822850e-02f, -3.33737433e-02f, -1.50617026e-02f, -7.18639640e-04f, -1.72307529e-02f, 2.32165726e-03f, 3.66675248e-03f, -6.59752488e-02f, 7.41015971e-02f,
  9.58630443e-03f, 4.45759334e-02f, 3.32449414e-02f, -1.45638725e-02f, -3.27641028e-03f, -3.39680761e-02f, -2.85204640e-03f, 4.58209105e-02f, -3.67906354e-02f, -5.73867895e-02f,
  -7.31336605e-03f, 3.07215820e-03f, -1.57250240e-02f, 4.94102947e-02f, -7.36849681e-02f, 1.97059177e-02f, -1.58693865e-02f, 3.65340803e-03f, 1.87309254e-02f, -8.11357313e-05f,
  2.29335874e-02f, 4.53468375e-02f, -3.27525921e-02f, 6.75355420e-02f, -1.48791708e-02f, 3.82045023e-02f, 2.68587377e-02f, 2.05787420e-02f, 8.00211057e-02f, 4.95522805e-02f,
  6.69191964e-03f, -8.83537065e-03f, 1.77056137e-02f, -3.42420004e-02f, -3.62465791e-02f, 2.87870578e-02f, -2.79899873e-02f, -8.01391527e-03f, 3.32136378e-02f, 1.32367844e-02f,
  -1.29630044e-01f, -1.32821977e-01f, 3.08085792e-02f, -5.07390052e-02f, -2.32350025e-02f, -3.36622968e-02f, -3.06151453e-02f, -2.07548402e-02f, -9.11419690e-02f, -1.88615955e-02f,
  -1.64619386e-02f, 9.45545174e-03f, 2.23935060e-02f, -3.82753164e-02f, 7.46965501e-03f, -1.88771766e-02f, 5.97958192e-02f, -2.89726332e-02f, -7.62541872e-03f, -3.41916829e-02f,
  5.72809018e-02f, 1.57606266e-02f, 1.18877701e-02f, -1.12389974e-01f, -3.74916419e-02f, -1.07248162e-03f, -4.98533510e-02f, -3.37870345e-02f, 1.14328507e-02f, -8.05698056e-03f,
  -5.62452665e-03f, -3.36719930e-01f, -1.36259004e-01f, -1.59663945e-01f, 2.27231339e-01f, 1.57674894e-01f, -6.32043509e-03f, -6.73048943e-02f, -3.42652947e-01f, -1.80452392e-01f,
  1.25341281e-01f, -1.62776083e-01f, -3.19692604e-02f, -9.00466517e-02f, 4.11216199e-01f, -9.46745649e-02f, 3.47845443e-02f, -6.28526360e-02f, -4.47292030e-02f, -3.32855037e-03f,
  -6.26274524e-03f, 2.34635964e-01f, 1.56964615e-01f, 8.96970853e-02f, 4.35843319e-02f, -1.20805085e-01f, 2.66401052e-01f, -3.07023805e-03f, 1.55064389e-01f, 1.67263970e-01f,
  6.68237656e-02f, -1.56110927e-01f, -5.61409779e-02f, -4.67405878e-02f, 7.64305964e-02f, 1.55925658e-02f, 1.01394884e-01f, 6.91338107e-02f, 2.86933854e-02f, -3.50475796e-02f,
  -1.61534678e-02f, 5.76084368e-02f, -7.40455166e-02f, 2.35647243e-02f, -4.64614816e-02f, -4.40632775e-02f, 2.01876485e-03f, 4.39673737e-02f, -8.22069272e-02f, -2.42810100e-02f,
  -3.68392542e-02f, -7.49872590e-04f, 1.08898319e-02f, 3.39599997e-02f, 1.54820690e-02f, -1.46438442e-02f, -1.44517403e-02f, 7.16718286e-02f, -2.24715378e-02f, -3.00071929e-02f,
  2.18066256e-02f, -4.69364971e-02f, -6.55802526e-03f, -2.67157331e-03f, -1.47243720e-02f, 1.78807154e-02f, -1.97970737e-02f, 1.30440593e-01f, 1.12149520e-02f, 5.30711636e-02f,
  7.33517855e-02f, -4.93308529e-02f, -8.27062596e-03f, -3.34563963e-02f, -3.64231057e-02f, -2.24638004e-02f, 3.47192548e-02f, 3.08482535e-03f, -2.99479906e-02f, 2.25641709e-02f,
  9.25944000e-03f, 1.39448745e-02f, 9.95833520e-03f, 2.81007383e-02f, 2.04612445e-02f, -3.14657912e-02f, -1.52622219e-02f, -2.67783981e-02f, 2.05206219e-02f, 7.70889968e-02f,
  1.23939395e-01f, 1.85840372e-02f, -1.86243113e-02f, 8.14238638e-02f, -4.35898975e-02f, 3.52014564e-02f, -5.45387603e-02f, -5.40312976e-02f, 2.31643915e-02f, -7.50598917e-03f,
  8.79217237e-02f, -1.75664723e-02f, 2.84456722e-02f, -3.20267193e-02f, 5.83242662e-02f, 3.12743289e-03f, 5.64690046e-02f, -9.53007210e-03f, 1.53439313e-01f, 6.20101057e-02f,
  2.22012810e-02f, 3.06525901e-02f, -1.93174381e-03f, 2.13140645e-03f, -4.99386201e-03f, 4.95146997e-02f, 3.90348001e-03f, -1.04944199e-01f, 7.92719200e-02f, -6.31099865e-02f,
  4.93578076e-01f, -2.53111184e-01f, -6.23351336e-02f, 1.86116785e-01f, 9.89563093e-02f, 1.51647270e-01f, 1.15796722e-01f, -6.40151575e-02f, 2.97826558e-01f, -3.12756717e-01f,
  -1.80374369e-01f, 9.54297408e-02f, -1.89398289e-01f, -1.34612685e-02f, 3.87638032e-01f, -5.95521219e-02f, 1.22080892e-01f, 1.19426429e-01f, 4.55322973e-02f, -4.57326472e-02f,
  1.06074370e-01f, -1.71298906e-02f, -1.00806326e-01f, -9.71282944e-02f, -5.05853305e-03f, -2.73539424e-02f, -1.36102825e-01f, -4.53748927e-02f, -6.20114729e-02f, 8.59290883e-02f,
  1.45649705e-02f, -4.01253020e-03f, -3.81158218e-02f, 1.53961722e-02f, -1.58768278e-02f, -1.53742358e-03f, -2.51186471e-02f, 5.70447855e-02f, 7.34116510e-02f, -1.52661372e-02f,
  2.35414598e-03f, 3.53233293e-02f, 6.39627203e-02f, 1.68247595e-02f, 5.61843514e-02f, 2.83123506e-03f, 8.57988838e-03f, -2.32763719e-02f, -2.25679465e-02f, 6.66416669e-03f,
  -3.76699381e-02f, -8.77946056e-03f, 1.82787888e-02f, -8.44786409e-03f, 4.61397097e-02f, 6.89131618e-02f, 3.66953248e-03f, 1.48770250e-02f, 2.91879326e-02f, 1.15161315e-01f,
  -9.56240017e-03f, 1.43203111e-02f, -3.57953198e-02f, -5.72092161e-02f, 8.76578968e-03f, -2.64541488e-02f, 2.55673588e-03f, -2.29167361e-02f, 2.22669356e-02f, 1.97798666e-03f,
  -2.14425735e-02f, 9.46456939e-03f, 3.64917479e-02f, 8.08471232e-04f, -3.32807265e-02f, -2.76227342e-03f, 8.15696782e-04f, -4.06043641e-02f, 5.48771536e-03f, -4.15179878e-03f,
  -3.39013562e-02f, 4.64912467e-02f, -2.24648863e-02f, -3.01524922e-02f, -1.34378048e-02f, 2.02709483e-03f, -6.82338327e-02f, -5.16094826e-02f, -2.22254954e-02f, 1.39955431e-02f,
  5.25240228e-03f, -6.93083555e-02f, -3.28011177e-02f, 2.09805313e-02f, 3.03101353e-03f, -4.20769863e-02f, 1.76768024e-02f, 4.84298207e-02f, 2.49619596e-02f, -2.23027114e-02f,
  3.70224714e-02f, -6.05266169e-02f, -4.99734655e-02f, 4.12726328e-02f, 8.81985482e-03f, -7.70902932e-02f, -1.75874420e-02f, -2.76946754e-04f, 1.21215843e-02f, -3.13744061e-02f,
  -1.66125316e-02f, 3.56431901e-02f, 2.77950838e-02f, 1.08454218e-02f, 9.53591242e-03f, 2.83620157e-03f, 7.08296522e-02f, 1.57977510e-02f, -6.39757700e-03f, -5.43648982e-03f,
  3.59108865e-01f, -3.45902056e-01f, 1.02463312e-01f, -2.01571792e-01f, 2.11620018e-01f, 1.39109001e-01f, -5.30293584e-02f, -6.77071735e-02f, -8.40912312e-02f, -3.45638365e-01f,
  -3.72235626e-02f, 5.59702031e-02f, -9.47791860e-02f, -8.60658064e-02f, 3.33000541e-01f, -6.15202375e-02f, -8.86969715e-02f, -1.69741318e-01f, 3.98284644e-02f, -9.60540473e-02f,
  4.86146957e-02f, -2.96483766e-02f, 8.28910992e-02f, -6.35553002e-02f, 3.49899121e-02f, -9.18941274e-02f, -1.25447139e-01f, -6.46070018e-03f, -1.96060948e-02f, 1.46498933e-01f,
  1.17119059e-01f, -9.72496569e-02f, 6.27556397e-03f, 5.64805679e-02f, -2.93857604e-02f, -3.23085152e-02f, 2.15364783e-03f, 5.76810837e-02f, 5.78662828e-02f, -4.20972556e-02f,
  -1.84895284e-02f, 2.07710527e-02f, 3.29692336e-03f, -2.11388082e-03f, -1.47038577e-02f, -6.13248628e-03f, 4.07199189e-02f, 7.15336800e-02f, -4.57607806e-02f, 3.20292301e-02f,
  7.37878401e-03f, 4.51010019e-02f, -2.00814717e-02f, -5.52624352e-02f, 1.04240188e-02f, -1.28794564e-02f, -1.96963195e-02f, -1.44661926e-02f, -3.93726155e-02f, -3.61225009e-02f,
  -3.79686765e-02f, -4.41882201e-02f, 2.05532424e-02f, 7.93103948e-02f, 2.01957244e-02f, 2.84029059e-02f, -1.93725564e-02f, 1.10572781e-02f, -8.28377809e-03f, -8.94399732e-03f,
  2.09900700e-02f, -1.38578359e-02f, 5.14304359e-03f, -1.61088780e-02f, -3.54893059e-02f, -6.98718999e-04f, 2.50380579e-03f, -5.45690209e-03f, -5.12699336e-02f, 5.53454459e-02f,
  7.63520692e-03f, -2.46289670e-02f, -4.41179909e-02f, -3.41164023e-02f, -4.74169515e-02f, 1.52290557e-02f, -4.03860584e-03f, 1.36410240e-02f, -1.89856533e-02f, 8.16555321e-02f,
  -1.61627114e-01f, -3.21533084e-01f, -3.06984726e-02f, -5.85368574e-02f, -4.89453599e-02f, 5.55441529e-03f, 6.81124441e-03f, 3.37552540e-02f, -1.93097237e-02f, -8.75823013e-03f,
  -2.88975071e-02f, -1.58184674e-02f, -2.37335060e-02f, 4.77286568e-03f, -5.44557767e-03f, -1.84609331e-02f, -7.15948865e-02f, 2.23317984e-02f, 1.92779228e-02f, -2.16559637e-02f,
  -5.33276945e-02f, -7.68891498e-02f, 3.32925618e-02f, -4.74821515e-02f, -8.54310840e-02f, 8.72559659e-03f, -3.62455733e-02f, 1.59836728e-02f, -1.61182247e-02f, -4.46172468e-02f,
  2.07425579e-02f, -3.35960239e-01f, -1.45772859e-01f, -3.79126608e-01f, 2.10266590e-01f, 2.12103039e-01f, -8.67299289e-02f, -1.15256235e-01f, -2.75760382e-01f, -1.11004524e-01f,
  1.11913525e-01f, -8.04625750e-02f, -4.98145558e-02f, -1.67516142e-01f, 3.43410701e-01f, 2.89275385e-02f, -3.44518796e-02f, -3.51880230e-02f, -4.32584621e-02f, -9.98624116e-02f,
  -2.67532598e-02f, 1.64487392e-01f, -1.38824405e-02f, 1.08306035e-01f, -3.73763926e-02f, -1.06524251e-01f, 8.84510279e-02f, 1.68682672e-02f, -2.27351021e-03f, 1.96157873e-01f,
  -1.29880207e-02f, -1.45272329e-01f, -2.66909730e-02f, 1.74393859e-02f, 1.61611121e-02f, 3.76161858e-02f, 4.50473987e-02f, 7.90590197e-02f, -1.19902305e-02f, -3.55623476e-02f,
  4.56275083e-02f, -9.30704456e-03f, -2.94757020e-02f, 6.71411529e-02f, 4.23956988e-03f, -2.60170344e-02f, 2.71968514e-04f, -2.63057761e-02f, -9.41472352e-02f, 1.79119166e-02f,
  -7.48503506e-02f, -3.14125270e-02f, 1.24461967e-02f, 6.97812589e-04f, 2.81651155e-03f, -2.51757074e-02f, 1.21402461e-02f, 1.25621613e-02f, -1.24287419e-02f, -1.81249306e-02f,
  1.05420403e-01f, -1.13226483e-02f, -2.93370876e-02f, -1.97858158e-02f, -1.14391884e-02f, 8.42926651e-03f, 3.86094116e-02f, 6.28716648e-02f, -3.51208225e-02f, 6.67435527e-02f,
  -2.62306966e-02f, -3.57427187e-02f, -1.80466380e-02f, -2.33631465e-03f, -1.90926101e-02f, -1.48450444e-02f, 5.72559610e-02f, 4.24766354e-02f, -6.88520893e-02f, 4.65031639e-02f,
  1.29141174e-02f, 4.64471281e-02f, -4.64366041e-02f, 3.60063091e-02f, 2.16510557e-02f, 2.10935739e-03f, -7.54816690e-03f, -3.41900624e-02f, -4.08393331e-02f, 5.13283089e-02f,
  4.58854251e-02f, -1.35058472e-02f, 1.70973348e-04f, 3.02526094e-02f, -2.91704815e-02f, 2.79631894e-02f, 4.25941274e-02f, -1.45676415e-02f, 3.28063257e-02f, 1.15190763e-02f,
  4.15691510e-02f, -3.45525108e-02f, 1.69399753e-02f, 1.14289951e-02f, 2.19767187e-02f, -5.14997076e-03f, -2.51519196e-02f, 7.81529211e-03f, 6.99068829e-02f, 4.39041927e-02f,
  1.06823718e-05f, 4.95978147e-02f, -1.19744688e-02f, 3.06393877e-02f, -3.39385401e-03f, 3.66359614e-02f, 2.29937937e-02f, -8.37651864e-02f, 7.90447146e-02f, -5.04363887e-03f,
  -4.06652004e-01f, 7.56972432e-02f, -1.02012463e-01f, 1.17690321e-02f, -2.78342217e-01f, -2.95164496e-01f, -1.32363990e-01f, -9.89041701e-02f, 2.35995248e-01f, 1.22985482e-01f,
  -7.47862235e-02f, -6.16902635e-02f, 1.23469681e-01f, -5.59993535e-02f, -2.91998953e-01f, 2.85298944e-01f, -1.63857266e-02f, 4.06588390e-02f, 5.93796484e-02f, -1.61959842e-01f,
  -1.14952974e-01f, -1.31637022e-01f, -1.01970315e-01f, -8.50702003e-02f, -2.71438718e-01f, -4.89699282e-02f, -3.61602148e-03f, 1.26468614e-02f, -1.50981024e-01f, -6.72662556e-02f,
  2.66908891e-02f, 5.01091033e-02f, 1.03179114e-02f, 7.99111798e-02f, -1.25850260e-01f, -4.91217412e-02f, -6.37688562e-02f, -2.02942919e-02f, 2.80312542e-02f, 5.81857562e-03f,
  6.71974793e-02f, -5.54262362e-02f, 1.98788885e-02f, 1.94982011e-02f, 3.62019353e-02f, -3.12830620e-02f, -3.10572907e-02f, 9.23102442e-03f, 1.45252617e-02f, -1.32281199e-01f,
  -4.22916710e-02f, -2.04543956e-02f, -3.18067595e-02f, 8.41576830e-02f, -4.77540009e-02f, 7.27169635e-03f, -3.34288962e-02f, -1.22542411e-01f, 9.79455784e-02f, -5.98078519e-02f,
  -5.95628284e-02f, -3.13136750e-03f, -6.91960007e-02f, 2.85427589e-02f, -2.32876018e-02f, -9.35241580e-03f, 2.83879880e-02f, -2.13074032e-02f, -9.41050798e-03f, -4.27012406e-02f,
  6.33055670e-03f, -3.22341733e-02f, -1.07021760e-02f, -9.16602463e-02f, -5.98948598e-02f, 2.63751578e-02f, -8.24157894e-03f, -1.92233548e-02f, -2.98242718e-02f, -3.45268771e-02f,
  7.19494298e-02f, 7.03652799e-02f, -3.15310545e-02f, 3.97854112e-02f, 3.10387034e-02f, -7.21890703e-02f, 1.58735961e-02f, -2.03585867e-02f, 2.58699562e-02f, -5.43970764e-02f,
  6.54695090e-03f, 2.73855403e-02f, 2.57019121e-02f, -5.32027008e-03f, 1.73509285e-01f, -4.06040139e-02f, 8.64907876e-02f, -4.64046374e-02f, 2.04975456e-02f, 8.41568317e-03f,
  -8.05763975e-02f, 4.58760094e-03f, 6.14929870e-02f, 2.30387188e-02f, 3.26414369e-02f, -7.41768181e-02f, 3.91004384e-02f, 8.54226798e-02f, 2.55159400e-02f, -5.32123148e-02f,
  -4.50098291e-02f, -1.05897300e-02f, 3.14974487e-02f, -4.06947769e-02f, 6.49148449e-02f, -3.24344747e-02f, -5.68642505e-02f, -4.62506600e-02f, -3.65700223e-03f, 4.61296700e-02f,
  1.34484962e-01f, 4.61061895e-02f, 2.47235984e-01f, -3.70968170e-02f, -7.59946406e-02f, 1.77045345e-01f, 2.32618496e-01f, 2.81910822e-02f, 2.21915573e-01f, 5.07307723e-02f,
  -5.76346219e-02f, 6.48752823e-02f, 6.21399246e-02f, -1.88880548e-01f, -7.70801678e-02f, -1.07398987e-01f, -2.31981039e-01f, -1.77686334e-01f, -2.07295656e-01f, -1.62205264e-01f,
  -2.23161131e-01f, -3.49937916e-01f, -1.61689833e-01f, -2.59406805e-01f, -1.72074825e-01f, -1.18231745e-02f, -7.55716115e-02f, 4.26904559e-02f, -1.07459888e-01f, -5.57393022e-02f,
  -8.85073096e-02f, -3.66328508e-02f, 4.02506478e-02f, 2.39440482e-02f, 1.12743499e-02f, 7.21980482e-02f, -1.32572027e-02f, 2.38839276e-02f, 2.86185499e-02f, 1.92221943e-02f,
  5.99676743e-02f, -4.49041463e-02f, -2.58047134e-02f, 1.48351761e-02f, 6.14824109e-02f, 7.64373504e-03f, -3.00596841e-02f, 5.33410255e-03f, 1.33199366e-02f, 1.69846939e-03f,
  -1.07968440e-02f, 3.34301069e-02f, 5.29297255e-02f, 3.14949565e-02f, 3.44395153e-02f, 3.89311686e-02f, 6.12519346e-02f, -1.61462312e-03f, -9.62372497e-03f, 1.04111090e-01f,
  7.21191522e-03f, 3.17083597e-02f, -3.88541631e-02f, 6.04425836e-03f, -4.20423299e-02f, 3.82107683e-02f, 3.09841800e-02f, -2.97203120e-02f, 2.24841442e-02f, -2.05031261e-02f,
  2.93311346e-02f, -2.37954799e-02f, -1.09898830e-02f, 5.42617626e-02f, -2.41467524e-02f, 1.41848987e-02f, -3.97914238e-02f, -2.07334999e-02f, 2.45783441e-02f, -2.33355165e-02f,
  -1.59388408e-02f, 6.90063462e-02f, -6.06823266e-02f, -3.53386514e-02f, 2.54376419e-02f, 2.84071993e-02f, 2.41984446e-02f, 5.87764867e-02f, 1.14327632e-02f, -1.62224285e-02f,
  -2.28705760e-02f, 1.91503502e-02f, -6.26794472e-02f, -4.27241772e-02f, -1.10563105e-02f, -4.69444692e-02f, -6.53081089e-02f, -6.24713115e-02f, 1.69908479e-02f, 1.40834218e-02f,
  -6.09147362e-03f, -1.44736385e-02f, 7.74187595e-02f, -8.84008012e-04f, -6.01290762e-02f, 4.87537347e-02f, 3.83158922e-02f, 2.58641168e-02f, 2.23665871e-02f, -5.83012663e-02f,
  8.68255971e-04f, -2.50326972e-02f, 1.09145204e-02f, -1.06404439e-01f, -4.96057831e-02f, 4.64503514e-03f, -1.28922528e-02f, 4.23741825e-02f, -4.89648432e-02f, 4.67071868e-02f,
  1.05216414e-01f, 2.48728886e-01f, 1.91890717e-01f, -9.52464342e-02f, 1.98243052e-01f, 2.26115614e-01f, -6.36539310e-02f, 2.13137984e-01f, 2.26636827e-01f, -1.52908608e-01f,
  -1.75206095e-01f, -1.26879588e-02f, -1.32546589e-01f, -1.22897074e-01f, -2.51510352e-01f, -1.57904550e-01f, 1.60479899e-02f, -1.60940625e-02f, 2.50779837e-01f, -3.40056345e-02f,
  1.66374534e-01f, -2.25663006e-01f, -5.87044805e-02f, 1.09885491e-01f, 1.16972476e-01f, 1.91978231e-01f, -2.58884072e-01f, 1.11118108e-01f, -9.35517326e-02f, 1.13115711e-02f,
  7.71586522e-02f, -1.12017700e-02f, 3.79166454e-02f, -7.22430041e-03f, 6.52166232e-02f, 1.48652624e-02f, -5.89688383e-02f, -5.88136427e-02f, 1.92520935e-02f, 7.33174384e-03f,
  -4.91507491e-03f, -8.14806968e-02f, -9.50087421e-03f, -4.25093547e-02f, 2.54051518e-02f, 1.77688969e-04f, 2.67481357e-02f, 5.78717031e-02f, -1.27270790e-02f, 2.12775376e-02f,
  2.42519956e-02f, 1.02472119e-01f, 1.97432861e-02f, -6.95061833e-02f, 3.81180160e-02f, 4.55771834e-02f, 5.21457847e-03f, 3.94080393e-03f, 1.64300129e-02f, 4.45916429e-02f,
  3.83116864e-02f, 5.15055135e-02f, -6.93504438e-02f, -5.72916679e-02f, -1.43076414e-02f, 7.41281584e-02f, 2.41553411e-02f, -9.04171821e-03f, 6.07384220e-02f, 4.02386151e-02f,
  -3.40863247e-03f, -2.43864357e-02f, 5.34661971e-02f, 1.53909931e-02f, -4.49498324e-03f, -6.11003339e-02f, -3.21877934e-02f, -2.39245836e-02f, -4.94932011e-03f, 4.18429375e-02f,
  -4.93874289e-02f, -2.59159040e-02f, 1.28243538e-02f, 5.84428664e-03f, -4.71058711e-02f, -1.39166787e-02f, -2.39899717e-02f, 7.00756023e-03f, 3.03324368e-02f, 4.53173965e-02f,
  -1.28335645e-02f, 1.39798805e-01f, 8.17088336e-02f, -1.73730794e-02f, -2.30758321e-02f, -2.71779206e-02f, -4.01969887e-02f, 7.25694448e-02f, 3.11093032e-02f, -1.02827847e-02f,
  4.25158776e-02f, -7.94157479e-03f, -2.07431391e-02f, -4.53676954e-02f, -6.53851256e-02f, -4.97195683e-02f, -7.49413297e-02f, 1.78698953e-02f, -4.88809831e-02f, 5.00149503e-02f,
  -5.43667935e-02f, 1.39494929e-02f, -2.55796704e-02f, 2.33730860e-02f, -1.56653440e-03f, -1.37480712e-02f, 6.93685189e-02f, -1.97801813e-02f, -4.41544838e-02f, 2.09164396e-02f,
  2.57098943e-01f, 6.62735701e-02f, 2.98917830e-01f, 2.69489497e-01f, 2.42685769e-02f, -1.89934596e-01f, 5.68418764e-02f, 1.02109835e-01f, 2.98532814e-01f, -2.43856654e-01f,
  -8.64967108e-02f, 3.62365365e-01f, 1.42165557e-01f, -1.55709460e-01f, 8.10447857e-02f, -1.36934454e-02f, -2.35895589e-01f, -1.71232447e-02f, 1.58778459e-01f, 1.52971536e-01f,
  5.79704940e-02f, -9.05750021e-02f, 4.30061109e-02f, -3.44097167e-02f, 5.10766581e-02f, 6.37722462e-02f, -1.03921019e-01f, 1.74199909e-01f, -2.85676092e-01f, -7.28328228e-02f,
  -1.03330098e-01f, 1.46776199e-01f, -9.11445469e-02f, -7.96201080e-02f, -1.29149169e-01f, -4.18942198e-02f, -7.31049255e-02f, 8.08524340e-02f, 1.57163187e-03f, -4.08461271e-03f,
  1.11073395e-02f, 1.00832274e-02f, -7.24134445e-02f, 2.58766785e-02f, -1.98757518e-02f, -1.86221022e-02f, -6.64891824e-02f, -8.01795200e-02f, 1.61958143e-01f, 7.20523149e-02f,
  3.95520553e-02f, -1.28660530e-01f, -6.25112429e-02f, -9.90953743e-02f, -1.67231746e-02f, -6.79958910e-02f, -2.54937969e-02f, -2.03436818e-02f, -1.13996305e-01f, 1.63925681e-02f,
  6.50970340e-02f, 3.54201384e-02f, -4.36878614e-02f, 2.56197266e-02f, 2.09983755e-02f, -7.33104646e-02f, -1.91949680e-02f, -3.45661491e-02f, -7.21819103e-02f, 5.69694676e-02f,
  -9.10893306e-02f, 7.71900592e-03f, -5.44102769e-03f, -6.37815073e-02f, 2.35655159e-02f, -4.78748744e-03f, -7.48925358e-02f, -6.89486191e-02f, -6.80094659e-02f, 5.21587674e-03f,
  1.26904503e-01f, -5.29564433e-02f, 3.88780497e-02f, -3.19890305e-02f, -9.06139705e-03f, 5.88444658e-02f, -2.70276656e-03f, -3.22327539e-02f, 3.74158733e-02f, -9.57999006e-03f,
  -1.02954924e-01f, 1.38962984e-01f, -4.50248905e-02f, -1.20902315e-01f, 4.28440459e-02f, -5.53245321e-02f, 4.17509563e-02f, -5.25645986e-02f, 7.23192692e-02f, 2.75547840e-02f,
  -6.96242377e-02f, -3.98714840e-02f, -5.99158891e-02f, -3.07453889e-02f, -5.27086034e-02f, 1.43464608e-03f, 4.58013974e-02f, -2.33127251e-02f, -5.76120466e-02f, -5.19220680e-02f,
  -4.77026254e-02f, 6.80026412e-03f, -3.61423157e-02f, -6.20808266e-02f, -1.35125652e-01f, 9.77726467e-03f, 9.51915458e-02f, -9.12090912e-02f, -9.00291279e-02f, 2.96559352e-02f,
  -4.50511247e-01f, 1.38019085e-01f, -3.25609475e-01f, 8.87122974e-02f, -3.02802846e-02f, 2.33957961e-01f, 1.00799292e-01f, 7.97123387e-02f, -2.54531913e-02f, 3.22461426e-01f,
  1.02523573e-01f, -1.41953364e-01f, -6.10103346e-02f, 2.63346910e-01f, 2.13763583e-02f, 4.45237346e-02f, 3.46093446e-01f, 1.56071305e-01f, -8.53328630e-02f, 7.11575672e-02f,
  -4.15706597e-02f, 3.53253275e-01f, -1.77132338e-01f, 2.07688853e-01f, -4.46625128e-02f, -1.11299440e-01f, 9.46490914e-02f, -1.39422014e-01f, 1.93407044e-01f, -2.71735452e-02f,
  -1.42639363e-03f, -1.42714158e-01f, -6.40720949e-02f, -9.30793732e-02f, 2.22594664e-02f, -1.24207726e-02f, -2.93675866e-02f, -2.60799378e-02f, -6.58902675e-02f, -3.69228721e-02f,
  -2.84916349e-02f, -6.55345097e-02f, 6.22337162e-02f, 5.45278750e-02f, -4.41172011e-02f, -3.53538021e-02f, -6.99648783e-02f, -7.88924769e-02f, 1.42504126e-02f, -1.25085995e-01f,
  -8.93813893e-02f, -6.73457794e-03f, -4.26448695e-02f, 4.49971259e-02f, -5.09018041e-02f, -3.67144831e-02f, 2.44376082e-02f, -4.21133973e-02f, 4.19454947e-02f, 5.31647690e-02f,
  -1.81969143e-02f, 5.69410846e-02f, -4.94285533e-03f, -4.44508307e-02f, -5.02251927e-03f, -5.85090816e-02f, 5.99556714e-02f, -1.19092260e-02f, -4.83049415e-02f, -1.45308720e-02f,
  5.94012178e-02f, -3.30814570e-02f, 2.52729300e-02f, 8.41599773e-04f, 5.93935251e-02f, -3.45196426e-02f, -6.79495856e-02f, -2.04677433e-02f, -2.21606474e-02f, -3.20138335e-02f,
  -3.78864892e-02f, 1.26690725e-02f, -1.00237690e-03f, -2.01024604e-03f, 3.93780842e-02f, -1.32068200e-02f, 3.47723141e-02f, -7.21189603e-02f, -2.86730332e-03f, 7.87578989e-03f,
  2.28238583e-01f, 3.09561521e-01f, 1.86799169e-02f, 6.61998689e-02f, 1.32413469e-02f, 1.48889516e-02f, 9.98543855e-03f, 1.46468570e-02f, 1.56650711e-02f, 4.78503555e-02f,
  1.43134771e-02f, 1.78349745e-02f, 2.73740422e-02f, -2.06799917e-02f, 9.44975615e-02f, 8.03230628e-02f, 5.10911271e-02f, 3.16291377e-02f, 3.64609845e-02f, 6.06834255e-02f,
  3.34651135e-02f, -7.80629413e-03f, 5.66516165e-03f, 4.13093641e-02f, 7.21069723e-02f, 3.12200449e-02f, -7.52758700e-04f, -2.68484075e-02f, 6.95098983e-03f, 8.52502584e-02f,
  1.32383108e-01f, -1.17395394e-01f, 3.52315694e-01f, 7.62715414e-02f, -1.73744261e-01f, -2.54864730e-02f, -3.90543267e-02f, -2.12977096e-01f, 2.60230273e-01f, -2.91447222e-01f,
  -1.80809289e-01f, 3.10621172e-01f, -5.24602272e-02f, -1.78055897e-01f, 3.91305089e-01f, 1.07297458e-01f, 5.92299737e-02f, 3.48104835e-02f, 1.60032794e-01f, 1.93641800e-02f,
  1.07037514e-01f, -3.20968688e-01f, 4.31132168e-02f, -1.98029429e-01f, -2.34453052e-01f, 7.41942227e-02f, -2.18700394e-01f, -5.42973261e-03f, -1.72619060e-01f, -1.43218543e-02f,
  1.27304913e-02f, -4.22279872e-02f, -3.02667487e-02f, 6.70326352e-02f, -2.22915038e-02f, -9.82037038e-02f, 2.13555414e-02f, -4.79042158e-02f, 6.43881783e-02f, -1.37432329e-02f,
  -1.05574187e-02f, -1.25152627e-02f, 1.49891684e-02f, 2.93318219e-02f, -4.74088341e-02f, 1.51298856e-02f, -7.26822810e-03f, 7.48964213e-03f, -6.13231212e-03f, -9.13811941e-03f,
  2.17279736e-02f, 2.69679856e-02f, 4.75401692e-02f, 2.95110838e-03f, 7.53763467e-02f, 2.74316799e-02f, 6.61058649e-02f, 6.99383691e-02f, -3.64602893e-03f, 1.68838017e-02f,
  -7.46208280e-02f, 9.04342160e-02f, -3.07660084e-02f, -2.24795267e-02f, 4.49895067e-03f, -6.61122277e-02f, -5.16909547e-03f, -4.45407741e-02f, 7.82388747e-02f, -3.18925902e-02f,
  1.60550121e-02f, -1.75916578e-03f, -3.34189609e-02f, -4.59523834e-02f, -3.99001166e-02f, 1.17403613e-02f, 7.25319237e-02f, -4.43905033e-02f, 3.45002711e-02f, -2.80389804e-02f,
  -4.65599857e-02f, 7.70121962e-02f, -2.43184320e-03f, -7.94767663e-02f, 9.89747047e-03f, -7.04955449e-03f, -3.92405801e-02f, -1.81005858e-02f, -8.63425806e-03f, 8.89638066e-03f,
  1.81050245e-02f, 3.37314308e-02f, 2.04989426e-02f, 2.96955463e-02f, 1.65712982e-02f, -8.10756311e-02f, -1.98217239e-02f, 3.96585139e-03f, 2.04146244e-02f, 3.38701271e-02f,
  4.89368513e-02f, -4.76956628e-02f, 4.76597100e-02f, -1.51933376e-02f, 7.94805288e-02f, -8.51580352e-02f, 2.61068810e-02f, -1.22358883e-02f, -2.17533894e-02f, 4.41732779e-02f,
  -8.00087303e-02f, -2.77811810e-02f, 3.45992409e-02f, -3.34802317e-03f, -4.43270877e-02f, -5.79845943e-02f, -1.05228217e-03f, 2.17613615e-02f, -6.24779724e-02f, 1.75752733e-02f,
  2.73655266e-01f, -1.85156614e-01f, 1.13388360e-01f, 1.75150365e-01f, 2.33824506e-01f, 1.53898895e-01f, 3.03763691e-02f, 1.37821347e-01f, 8.23654681e-02f, -1.60033360e-01f,
  3.79709736e-03f, -1.38823902e-02f, -1.83662578e-01f, 1.03329681e-01f, 1.32035986e-01f, -1.71344936e-01f, 2.01726198e-01f, -2.81295516e-02f, 2.32918444e-03f, 1.04854874e-01f,
  1.29988477e-01f, 2.34033610e-03f, 6.27068207e-02f, 1.19400918e-02f, 1.62039235e-01f, 5.06782457e-02f, -8.63507614e-02f, -1.25626341e-01f, 1.02952093e-01f, 1.51127866e-02f,
  -4.27931212e-02f, 9.20602679e-03f, -4.45736386e-02f, -4.07443196e-02f, 7.68203884e-02f, -8.25442933e-03f, -5.77275977e-02f, -2.91196406e-02f, -3.17970407e-03f, 8.40963945e-02f,
  -1.72241032e-02f, 8.36061165e-02f, 5.17113097e-02f, -9.80894044e-02f, -3.33852656e-02f, 3.79912332e-02f, 4.61038761e-02f, 6.71102256e-02f, 6.49444610e-02f, 6.20020777e-02f,
  1.50657063e-02f, 9.03791785e-02f, 2.54601650e-02f, 3.38118002e-02f, 5.62093668e-02f, 4.17459719e-02f, 3.05484496e-02f, -3.47435325e-02f, 4.28753197e-02f, 1.00199834e-01f,
  -7.81666636e-02f, -4.39831205e-02f, 4.33739722e-02f, 3.93847153e-02f, 2.77684089e-02f, 7.06973672e-02f, 8.29236303e-03f, -7.78337382e-03f, 8.74058437e-03f, -4.83910320e-03f,
  1.17983744e-01f, 2.17611492e-02f, -4.19888012e-02f, 5.15526496e-02f, -2.30724867e-02f, 5.51666431e-02f, -3.04287542e-02f, 4.78164293e-02f, 3.82839404e-02f, 1.98306069e-02f,
  -6.17232267e-03f, 1.73897818e-02f, -3.86287533e-02f, 1.54381506e-02f, -8.38076603e-03f, -5.77458851e-02f, 3.40852775e-02f, 4.17374708e-02f, -3.23161408e-02f, 4.66156527e-02f,
  -1.44480065e-01f, -1.31942883e-01f, -6.92572370e-02f, 1.95292570e-03f, -4.97092493e-02f, 2.06775367e-02f, 1.56171899e-02f, 9.12516788e-02f, -8.67766216e-02f, 3.80478874e-02f,
  1.08964667e-02f, 4.45528068e-02f, -1.14755239e-02f, -7.07767811e-03f, -4.43740375e-02f, 1.71604231e-02f, -2.64897454e-03f, -6.05572797e-02f, -2.76983622e-02f, 7.29328021e-05f,
  -1.58616714e-02f, 2.63020047e-03f, 2.94588525e-02f, 2.68525295e-02f, 1.71462186e-02f, 4.09818031e-02f, -1.49694616e-02f, 1.52400220e-02f, 5.02717756e-02f, 7.78820412e-03f,
  4.08327013e-01f, -2.54512101e-01f, -9.06124711e-02f, 1.46945119e-01f, 6.32031709e-02f, 2.66209513e-01f, 1.97312817e-01f, -1.26188204e-01f, 3.57911363e-02f, -2.28981942e-01f,
  -1.36795202e-02f, 7.21660033e-02f, -1.98715553e-01f, 1.81266874e-01f, 3.25244874e-01f, -8.68667960e-02f, 1.37393117e-01f, 1.56397805e-01f, -5.27028888e-02f, 1.20536042e-02f,
  7.46117532e-02f, 3.13609093e-02f, -3.32448296e-02f, -1.19943388e-01f, 8.27577189e-02f, -7.72793442e-02f, -1.02728620e-01f, -1.35013387e-01f, 9.59180370e-02f, 1.03479929e-01f,
  5.56284562e-02f, -7.75184110e-02f, -6.35769740e-02f, 3.71966213e-02f, -2.24907268e-02f, 4.46982682e-02f, 1.40183335e-02f, 5.48609858e-03f, 6.60523912e-03f, -1.18961614e-02f,
  3.52769271e-02f, 1.92769393e-02f, 1.45194763e-02f, 2.40675500e-03f, 8.80131423e-02f, 1.59197785e-02f, 1.01792160e-02f, 3.11286002e-02f, -5.36254793e-02f, 4.18882780e-02f,
  7.80621963e-03f, -1.13503076e-03f, 2.00383794e-02f, -1.21858791e-02f, -3.17230225e-02f, -3.16212862e-03f, 2.37061568e-02f, 8.53687525e-03f, 6.80016354e-03f, 5.76948635e-02f,
  -3.96337509e-02f, -1.93832722e-02f, 4.94953291e-03f, -2.39452161e-02f, -1.11226737e-02f, -1.90046169e-02f, 4.43698950e-02f, 3.96739319e-02f, 8.38256814e-03f, 4.67711408e-03f,
  3.03839855e-02f, 3.43585610e-02f, 5.63555248e-02f, 6.05238788e-02f, -8.85040127e-03f, -5.02951164e-03f, 1.23580294e-02f, 1.41505664e-02f, -3.97743657e-02f, 2.25235503e-02f,
  -4.39737476e-02f, 5.12873009e-02f, -1.99366156e-02f, 8.94383993e-04f, 3.02086379e-02f, -1.45856403e-02f, -1.94131266e-02f, -7.84329511e-03f, -2.24748421e-02f, 2.18501221e-02f,
  -1.76639073e-02f, -2.16479421e-01f, -9.14357603e-02f, 2.77746804e-02f, -3.77335027e-02f, 3.09403171e-03f, 3.84746753e-02f, 3.66947614e-02f, -5.78827504e-03f, 2.10616621e-03f,
  -1.16215413e-02f, 7.59060727e-03f, -1.32537377e-03f, 4.02596518e-02f, -1.09849602e-03f, -3.32978107e-02f, -2.11775266e-02f, -2.15688422e-02f, -2.42670812e-02f, -2.40351595e-02f,
  -2.02006269e-02f, 3.39002386e-02f, -3.26253548e-02f, -1.76605936e-02f, 1.87569503e-02f, -3.27296630e-02f, 6.70792982e-02f, -2.81815957e-02f, 2.59879831e-04f, -3.72596760e-03f,
  -2.60269552e-01f, 1.12998471e-01f, -3.38849485e-01f, -1.61018685e-01f, -1.40196666e-01f, -1.90406293e-01f, -2.46153697e-01f, -9.77593362e-02f, -3.21066171e-01f, 3.34946960e-01f,
  5.77485822e-02f, 1.77922938e-02f, -2.17858050e-02f, 1.41303614e-01f, -2.47496426e-01f, -7.46035129e-02f, 7.98779652e-02f, 4.86644879e-02f, -1.48815498e-01f, -7.26411343e-02f,
  -1.95082948e-01f, 8.29665735e-02f, -1.70081884e-01f, 1.91196486e-01f, 2.17551999e-02f, 4.34846580e-02f, 2.63043672e-01f, -1.61593258e-01f, 1.90777302e-01f, -4.96583991e-02f,
  -7.41736516e-02f, -1.28870592e-01f, 2.09707674e-02f, 1.77358668e-02f, 7.02824667e-02f, -3.48369777e-02f, -2.86575947e-02f, -8.53855461e-02f, -4.65854444e-02f, -1.00111589e-02f,
  7.97662213e-02f, -3.91227789e-02f, 3.19977328e-02f, -2.00781487e-02f, -1.37328058e-01f, -3.78368907e-02f, -2.88050789e-02f, -4.53481562e-02f, -1.15913786e-02f, -1.28857881e-01f,
  -1.11493744e-01f, -3.18858400e-02f, -3.50128599e-02f, 7.90772811e-02f, -6.31985515e-02f, -2.86458731e-02f, -7.91903138e-02f, 5.29174395e-02f, 1.30558750e-02f, -3.26673798e-02f,
  -4.50115316e-02f, -8.72190893e-02f, 2.01151669e-02f, -7.50477016e-02f, 6.28658244e-03f, -2.17321478e-02f, 5.00346497e-02f, 3.81235741e-02f, 4.60690968e-02f, 3.09500191e-02f,
  2.73282658e-02f, 8.35744292e-03f, 2.63913125e-02f, -7.36714900e-02f, 2.69263778e-02f, -4.34024557e-02f, -2.75879502e-02f, 5.92847839e-02f, -2.02447688e-03f, 1.49533283e-02f,
  1.08616725e-02f, -6.95669726e-02f, 7.42207617e-02f, -4.22137231e-02f, -1.80349424e-02f, -1.96237508e-02f, -3.09385136e-02f, -5.30082025e-02f, -4.11595553e-02f, 3.40350084e-02f,
  1.65886953e-01f, 1.03207633e-01f, 9.20997933e-02f, 2.19571739e-02f, 1.04159184e-01f, 9.44584459e-02f, -5.70275076e-02f, 1.25004336e-01f, -7.14598149e-02f, 2.02447828e-02f,
  1.36864902e-02f, 7.07906038e-02f, 4.70510423e-02f, -5.64503185e-02f, -4.90865596e-02f, -1.17910486e-02f, -6.59264326e-02f, 6.78279996e-02f, 7.12575689e-02f, 1.76245738e-02f,
  3.91797461e-02f, 2.17912085e-02f, -2.46185679e-02f, 7.03318864e-02f, 8.87891054e-02f, 1.24418572e-01f, 7.02395737e-02f, -3.87934186e-02f, 5.60915507e-02f, -5.27739665e-03f,
  -3.59596759e-02f, -2.42048591e-01f, -2.22277269e-01f, -2.21180171e-01f, -3.53194377e-03f, 4.14032042e-01f, 2.44386569e-01f, -6.65030181e-02f, -5.07624783e-02f, 1.06150704e-02f,
  -2.60157902e-02f, -2.09367514e-01f, 7.40529224e-02f, -2.01366976e-01f, 2.70316631e-01f, 1.49061099e-01f, 5.58776930e-02f, -4.41264398e-02f, -1.00504972e-01f, -3.68351452e-02f,
  -1.60109811e-02f, -4.32847776e-02f, -8.82452577e-02f, -1.34698123e-01f, -4.94658388e-02f, -1.73134416e-01f, 3.25559713e-02f, -3.20231915e-02f, -9.55365524e-02f, 4.17885520e-02f,
  3.29634100e-02f, -1.89795703e-01f, -6.40572384e-02f, -3.68849421e-03f, 7.98795968e-02f, 7.02451393e-02f, 7.24924505e-02f, 2.71912646e-02f, -5.75065576e-02f, -5.59304170e-02f,
  3.04869059e-02f, 3.03707551e-03f, -2.24187616e-02f, -3.85837927e-02f, 1.38568208e-02f, -9.70056802e-02f, -5.93659133e-02f, -1.16919540e-02f, -4.76448350e-02f, -1.59072820e-02f,
  -7.81590790e-02f, -6.01367187e-03f, 5.79304062e-03f, 1.37151722e-02f, 1.96635518e-02f, -5.90518117e-02f, 3.67870666e-02f, 5.35391085e-02f, 1.50414994e-02f, -4.46395874e-02f,
  4.34632711e-02f, -2.34379880e-02f, 3.51077504e-03f, -5.95653206e-02f, -3.86080481e-02f, -1.39918029e-02f, 4.95406836e-02f, 7.05991685e-02f, -2.98516937e-02f, 1.83481481e-02f,
  6.56587183e-02f, -4.88533750e-02f, -3.00438516e-02f, 1.53112393e-02f, -7.67434202e-03f, 1.26596587e-02f, -5.74366096e-03f, -6.56349882e-02f, 5.50546087e-02f, -4.58079688e-02f,
  -5.83668128e-02f, 4.26357165e-02f, 2.57171988e-02f, 1.36936709e-01f, 5.98833375e-02f, -2.97948625e-02f, -2.48662066e-02f, 1.90597661e-02f, -3.23373862e-02f, 7.86048174e-02f,
  1.57448083e-01f, 4.80778962e-02f, 3.74559313e-02f, 2.70564593e-02f, -4.34610061e-02f, 6.30199388e-02f, -6.28476441e-02f, -5.16537651e-02f, 9.73207224e-03f, 5.18677868e-02f,
  -4.66148965e-02f, 8.78468603e-02f, 5.65733342e-03f, -2.24724598e-02f, -2.32872814e-02f, -2.36194730e-02f, 3.97327878e-02f, 1.81554370e-02f, 2.42205728e-02f, 4.72126994e-03f,
  3.74407470e-02f, 1.18330522e-02f, 2.40350235e-02f, 5.66073395e-02f, 3.52186523e-02f, 5.00988625e-02f, -1.63431745e-02f, -4.15680856e-02f, -2.59893434e-03f, -6.05356414e-03f,
  2.51338452e-01f, 3.28528553e-01f, -9.22028050e-02f, 3.41380797e-02f, -1.48878405e-02f, -7.88768381e-02f, -4.44910713e-02f, 2.59699430e-02f, 2.16689125e-01f, 1.46414354e-01f,
  -5.70673756e-02f, 2.91632712e-01f, -1.84971038e-02f, -1.06353663e-01f, -7.29668960e-02f, -4.07104082e-02f, -1.05336607e-01f, 1.04104444e-01f, -2.68479362e-02f, 8.29902664e-02f,
  -8.85048509e-02f, 9.69576538e-02f, -2.77211785e-01f, -4.50081825e-02f, -3.64116319e-02f, 1.21003892e-02f, -4.09426279e-02f, -9.53552499e-02f, -3.98425311e-02f, -5.71526820e-03f,
  2.93360949e-02f, 7.69879296e-02f, -4.70261909e-02f, 1.41785648e-02f, -9.82186943e-02f, -5.21854982e-02f, -7.11961985e-02f, -2.31562518e-02f, -2.20795479e-02f, -3.55259851e-02f,
  3.57054248e-02f, 2.69090533e-02f, 2.47111507e-02f, 1.20573379e-02f, 1.46706235e-02f, 5.43440599e-03f, -6.08855765e-03f, -3.70939858e-02f, 2.16023121e-02f, -6.38901293e-02f,
  -1.90692879e-02f, -5.42353876e-02f, -8.52896497e-02f, -4.14700992e-02f, 1.73499193e-02f, -1.65782925e-02f, -5.25293425e-02f, -8.32357556e-02f, 2.25403719e-02f, -2.69032195e-02f,
  -4.60207723e-02f, 8.86441208e-03f, -1.56755820e-02f, 2.88424250e-02f, 3.50814126e-02f, -1.76872909e-02f, 3.12447455e-02f, -1.47413341e-02f, 1.96126923e-02f, 2.56891716e-02f,
  -1.47816464e-02f, 2.21527331e-02f, -7.34784156e-02f, 2.51600817e-02f, 2.96591073e-02f, 5.54103125e-03f, -3.34374746e-03f, 2.64240801e-02f, -2.24136133e-02f, -5.14867753e-02f,
  9.15996432e-02f, -1.64262857e-02f, 4.29013669e-02f, -1.23529574e-02f, -1.14843640e-02f, 1.83411408e-02f, 1.47375360e-03f, 2.61098109e-02f, -2.13948563e-02f, 7.78224040e-03f,
  2.61303246e-01f, 3.27792019e-01f, 5.49929067e-02f, 5.94892502e-02f, 5.73644228e-02f, -6.80158362e-02f, -1.30455457e-02f, -7.84538966e-03f, 1.02779329e-01f, -6.74844459e-02f,
  -1.60442311e-02f, -5.98583370e-02f, -1.57243609e-02f, -2.64586564e-02f, -2.13550427e-03f, 3.10303215e-02f, 2.95978617e-02f, 4.91090901e-02f, 2.24427674e-02f, 3.71306427e-02f,
  1.17336856e-02f, 1.59818009e-02f, -1.31387012e-02f, -5.43246157e-02f, -9.04238410e-03f, 7.10142851e-02f, 1.07753277e-01f, 1.53063601e-02f, 2.74124537e-02f, 2.21277196e-02f,
  3.68965864e-02f, -2.00817902e-02f, -1.70501232e-01f, -1.12304501e-01f, 3.15293193e-01f, 3.06329168e-02f, -1.42628044e-01f, 7.83902332e-02f, -2.43199825e-01f, -1.30472645e-01f,
  1.29992843e-01f, -3.07665020e-02f, -9.12251100e-02f, -8.39049444e-02f, 1.62569713e-02f, -2.83544868e-01f, -1.13380022e-01f, -7.67475739e-02f, -1.50083918e-02f, 7.55625740e-02f,
  -1.90460607e-02f, 7.10467622e-02f, -2.59460174e-02f, 1.36587068e-01f, 1.50732294e-01f, 1.34992957e-01f, 1.05355248e-01f, -1.75115019e-02f, 1.72448054e-01f, 2.74779964e-02f,
  1.20857872e-01f, -7.26123750e-02f, 1.05456732e-01f, 7.94707704e-03f, 1.54893339e-01f, -1.91434436e-02f, -8.81355330e-02f, -3.54354605e-02f, 3.86342481e-02f, 1.82594936e-02f,
  1.93965540e-03f, 6.82517439e-02f, 2.53305379e-02f, -3.33820581e-02f, -2.83480063e-02f, 4.37217765e-02f, 8.26072767e-02f, 4.16228063e-02f, 1.67608932e-02f, 2.51538167e-03f,
  4.34196852e-02f, 7.37238228e-02f, 2.08324157e-02f, 2.33043311e-03f, 1.29290484e-02f, 4.64901589e-02f, -1.04116485e-01f, 1.19111732e-01f, 5.68138435e-02f, 5.62477857e-02f,
  -8.20179656e-03f, -4.12341431e-02f, -1.03574311e-02f, -7.93002322e-02f, 1.42476205e-02f, 5.09400219e-02f, -3.61841246e-02f, -7.00194538e-02f, 4.44820384e-03f, 1.18867615e-02f,
  6.40466958e-02f, -2.67870408e-02f, 2.81929714e-03f, 4.05035615e-02f, -4.16772477e-02f, -1.03887498e-01f, -5.43240784e-03f, 5.75430691e-02f, 7.55733997e-02f, 2.82910969e-02f,
  -1.03923231e-01f, 4.96618031e-03f, 1.21362239e-01f, -3.90346795e-02f, -3.58598232e-02f, 7.91794807e-02f, -3.13281715e-02f, -4.35087904e-02f, -2.85924766e-02f, 6.36079609e-02f,
  1.42771125e-01f, -1.90737043e-02f, 7.20588639e-02f, 1.02339178e-01f, -7.65940845e-02f, 3.29701342e-02f, -1.89066693e-01f, -4.39505763e-02f, 7.58792832e-02f, -1.19679570e-01f,
  6.87257349e-02f, 4.70666066e-02f, 7.07671279e-03f, -2.90285014e-02f, -1.57802738e-02f, 8.33938550e-03f, -8.28096941e-02f, 3.15452814e-02f, 3.32118385e-02f, 8.86683241e-02f,
  5.93086034e-02f, 1.70016717e-02f, -4.05131141e-03f, 4.49235402e-02f, 1.76239088e-02f, 4.42343727e-02f, 4.23333310e-02f, 7.08881393e-02f, 2.58047264e-02f, -5.88928834e-02f,
  1.68941781e-01f, -2.31295690e-01f, 1.82173979e-02f, -8.16601813e-02f, 6.78281114e-02f, 3.27518255e-01f, 2.69278198e-01f, -5.66669041e-03f, 1.61929160e-01f, -1.23456471e-01f,
  -1.10090882e-01f, -2.08504423e-01f, 4.08643372e-02f, -1.25272393e-01f, 2.70095944e-01f, 1.33400261e-01f, 7.77177662e-02f, -7.45291961e-03f, 6.51795194e-02f, -6.73996890e-03f,
  8.55425820e-02f, 1.22090932e-02f, 4.24439833e-02f, -1.27267137e-01f, -4.86473478e-02f, -1.78355247e-01f, -1.35510385e-01f, -7.73636326e-02f, -2.49370784e-01f, -6.05883598e-02f,
  -7.68300472e-03f, -1.12732776e-01f, -5.51318051e-04f, 4.09696391e-03f, 3.09683718e-02f, -6.17898582e-03f, -1.04591064e-02f, -9.70334373e-03f, -2.09390707e-02f, 5.99124609e-03f,
  -2.48726178e-02f, -1.17190760e-02f, 2.33492511e-03f, 1.22217657e-02f, -2.34131725e-03f, -6.92183897e-02f, 1.32155251e-02f, -2.85110865e-02f, -4.30130549e-02f, 5.31808566e-03f,
  4.81774919e-02f, -1.56965032e-02f, -3.57284620e-02f, -6.72807470e-02f, 2.68859236e-04f, -2.32058614e-02f, 7.35687390e-02f, 3.39695774e-02f, 1.40085500e-02f, 2.63801776e-02f,
  -1.23638436e-02f, 2.89732032e-02f, 8.22432190e-02f, 2.02749502e-02f, 2.49468293e-02f, 6.78932946e-03f, -3.51646990e-02f, -2.28445772e-02f, -3.16934325e-02f, -4.50515916e-04f,
  -4.02547140e-03f, 7.25966878e-03f, -9.49776918e-03f, 5.70094623e-02f, 1.39361192e-02f, -2.33604759e-02f, 3.58915180e-02f, -6.02696203e-02f, 1.87530499e-02f, 3.44757959e-02f,
  -5.07205352e-02f, 2.15833243e-02f, 9.10969730e-03f, -5.59622683e-02f, 4.69575971e-02f, 1.95521340e-02f, -7.12577254e-02f, -1.86681692e-02f, -3.80677879e-02f, 3.02917678e-02f,
  4.74285632e-02f, -1.03991013e-02f, -1.35018053e-02f, -6.41259700e-02f, -4.19692323e-02f, -3.20981592e-02f, 2.04333793e-02f, 1.69425327e-02f, -2.29044799e-02f, 2.70240810e-02f,
  -4.12902422e-02f, -1.92279946e-02f, 3.89070949e-03f, -8.59972555e-03f, -2.49990709e-02f, 8.35931152e-02f, -2.79061012e-02f, -3.07088587e-02f, 3.81015148e-03f, -8.69241655e-02f,
  -3.34375910e-02f, -1.33482348e-02f, 8.20349809e-03f, 5.43383136e-02f, -5.38174659e-02f, -5.12630977e-02f, -4.48247939e-02f, 3.81968357e-03f, -4.94371541e-02f, -7.38029554e-03f,
  -2.39484608e-01f, 3.08541805e-02f, 1.31542563e-01f, -1.56113788e-01f, 1.20375544e-01f, 1.14663124e-01f, 1.82516500e-01f, 3.20927869e-03f, 7.76636750e-02f, -3.24914753e-02f,
  7.92654157e-02f, -1.39503926e-01f, 3.41352075e-01f, -5.30848242e-02f, -1.38671761e-02f, 2.88335860e-01f, -1.32923707e-01f, 2.43571810e-02f, -5.86066535e-03f, -1.19721584e-01f,
  -1.76509097e-02f, -1.53640389e-01f, 9.49805379e-02f, -6.44657910e-02f, -6.64722621e-02f, -1.04188316e-01f, -2.27339610e-01f, 5.03600985e-02f, -2.01265976e-01f, -4.98333238e-02f,
  2.58988906e-02f, -2.14215130e-01f, 9.55320746e-02f, -5.95804378e-02f, -4.18567359e-02f, 3.72931436e-02f, -6.65392652e-02f, 7.79762715e-02f, 7.81718828e-03f, -1.61837377e-02f,
  4.61909212e-02f, -3.65415402e-02f, -7.13414252e-02f, 4.28176019e-03f, -5.19764125e-02f, -1.78124476e-02f, -2.21278369e-02f, 6.65348917e-02f, 5.12057915e-02f, 5.34007996e-02f,
  4.92287613e-02f, 4.84967679e-02f, 4.28197952e-03f, -7.09245279e-02f, -1.94889177e-02f, -2.30267290e-02f, -3.74214202e-02f, 2.30453238e-02f, -7.29646161e-02f, -1.14954710e-01f,
  -7.17882207e-03f, 3.93080525e-03f, 4.77328338e-02f, 2.85621820e-04f, 1.43498334e-03f, -2.66196448e-02f, -4.89595793e-02f, -3.21451686e-02f, 1.05625410e-02f, 1.82935614e-02f,
  9.90428496e-04f, -3.16093639e-02f, -6.94085658e-02f, 3.93884033e-02f, -4.09054048e-02f, -5.26959449e-02f, 3.55221145e-02f, -4.75389473e-02f, 6.26125792e-03f, 1.04436409e-02f,
  -2.99463794e-02f, -2.87101809e-02f, 4.89834463e-03f, 3.92224230e-02f, -3.07073221e-02f, 2.52510398e-03f, -7.24782497e-02f, -1.44850360e-02f, 3.53603214e-02f, 7.10423589e-02f,
  -2.04270601e-01f, -4.30860102e-01f, 4.09901701e-02f, -6.50617927e-02f, -3.18361372e-02f, -8.51575099e-03f, 2.56228298e-02f, -1.91247147e-02f, -9.99843180e-02f, -9.67581477e-03f,
  1.17231859e-02f, -3.30183506e-02f, -1.05315179e-01f, 1.51330577e-02f, 1.90746002e-02f, -2.88992058e-02f, 4.11308892e-02f, -3.72972079e-02f, -7.79436678e-02f, -5.62321506e-02f,
  -3.38246152e-02f, -6.04999550e-02f, -2.13530231e-02f, -5.63852198e-04f, -2.95449533e-02f, -4.99003045e-02f, -7.16216341e-02f, -1.03331655e-02f, -2.01121755e-02f, 3.86668555e-02f,
  -1.23710103e-01f, 2.26230904e-01f, -2.63205111e-01f, -1.03318200e-01f, 1.06553331e-01f, 6.90196753e-02f, -6.40055537e-02f, 7.58222267e-02f, -1.08412780e-01f, 3.35049659e-01f,
  1.07190467e-01f, -1.01750270e-01f, -1.17399238e-01f, 3.00385594e-01f, -4.36719269e-01f, -1.47845387e-01f, 4.00835974e-03f, -3.55453137e-03f, -9.44997892e-02f, 1.05830796e-01f,
  -8.11965540e-02f, 2.25881442e-01f, -1.76483184e-01f, 2.53552467e-01f, 1.66795969e-01f, -1.13629969e-02f, -1.46918250e-02f, -1.00421831e-01f, 1.94217920e-01f, 5.03453091e-02f,
  3.68296281e-02f, 2.18078457e-02f, 4.90903109e-02f, 1.98216364e-02f, 2.89391931e-02f, 8.93256962e-02f, -5.45488345e-03f, -3.17319259e-02f, -8.86636600e-02f, 1.43799204e-02f,
  2.27103513e-02f, -2.55123395e-02f, 9.44369361e-02f, 2.89259870e-02f, 1.01172790e-01f, -5.14874654e-03f, 1.07009383e-02f, -7.34263659e-03f, -3.33361421e-03f, -2.44549084e-02f,
  -2.29858942e-02f, 2.26559080e-02f, -2.28259675e-02f, -1.49772828e-03f, -9.95595604e-02f, -5.07508740e-02f, -1.33759277e-02f, -5.49043454e-02f, -2.51190085e-02f, 3.47041860e-02f,
  1.07774781e-02f, -4.75955606e-02f, -3.44508588e-02f, 6.37927353e-02f, 5.04219951e-03f, 3.15172449e-02f, 3.03648375e-02f, 2.57473290e-02f, -5.39744496e-02f, -2.50482503e-02f,
  3.67085226e-02f, 6.50706142e-03f, 1.03486918e-01f, 2.88804621e-02f, 2.06514392e-02f, 4.68951389e-02f, -7.17975497e-02f, 5.08269891e-02f, 1.02805635e-02f, 1.29645020e-02f,
  -3.93150188e-02f, -8.01671203e-03f, 3.83450165e-02f, 7.31003331e-03f, 3.18703387e-04f, -7.56659210e-02f, 3.92969251e-02f, -1.13808233e-02f, -9.67003964e-03f, -1.88740082e-02f,
  -4.55682259e-03f, 6.42233249e-03f, -1.64445378e-02f, 4.53327298e-02f, -2.67476179e-02f, 5.65931275e-02f, -3.80273908e-02f, 1.34242065e-02f, -3.11785508e-02f, 7.34742582e-02f,
  3.81090678e-02f, 3.80429327e-02f, -2.43039504e-02f, 1.04427356e-02f, -2.47709062e-02f, -1.49854021e-02f, -2.62226025e-03f, 5.36462711e-03f, 3.18358243e-02f, 1.71228517e-02f,
  7.75032584e-03f, 1.27480011e-02f, 4.43167286e-03f, -1.20479416e-03f, 4.46477160e-02f, -2.24450994e-02f, -9.91627946e-03f, -4.12445888e-03f, 8.74615461e-02f, -5.22937514e-02f,
  -2.03826487e-01f, -2.29773782e-02f, -4.71279137e-02f, 5.36244810e-02f, 2.85973042e-01f, -2.27018714e-01f, -2.99229622e-01f, 2.16229901e-01f, -3.08339242e-02f, -2.78003998e-02f,
  5.55675291e-02f, -2.86932409e-01f, -1.09606974e-01f, -3.72738168e-02f, -2.47438729e-01f, -2.03702614e-01f, -1.94768250e-01f, -1.47098452e-01f, -3.80391181e-02f, -2.63503753e-02f,
  -2.03406643e-02f, 1.58771172e-01f, 7.08712935e-02f, 2.46139869e-01f, 1.77198604e-01f, 1.57739758e-01f, 1.41988516e-01f, 7.10040629e-02f, 1.24487519e-01f, -1.74666885e-02f,
  -3.86735983e-02f, 1.15947820e-01f, 6.50482625e-02f, 5.46126103e-04f, -2.13073064e-02f, -2.44454853e-02f, -9.29875448e-02f, -8.28625858e-02f, -5.92628233e-02f, -2.68482487e-03f,
  -8.35458040e-02f, 3.59420963e-02f, -6.38902467e-03f, 6.80920854e-02f, 3.16729732e-02f, 6.55457750e-02f, 7.22081363e-02f, -8.76369700e-03f, 7.63696134e-02f, 2.46656630e-02f,
  2.16815737e-03f, -2.33011544e-02f, -4.32028510e-02f, -1.03570439e-01f, -2.62320582e-02f, -8.68010800e-03f, -1.56548731e-02f, -4.50374857e-02f, -1.31164892e-02f, -8.20363127e-03f,
  -1.53841134e-02f, 1.10777374e-02f, 1.42453024e-02f, 2.67607272e-02f, -3.79658374e-03f, 1.46528989e-01f, -5.43344133e-02f, 2.01323517e-02f, 5.41784056e-02f, -4.52830121e-02f,
  3.00473645e-02f, 2.58848350e-02f, 5.02681397e-02f, -3.50928213e-03f, -8.93949764e-04f, 5.64677641e-03f, -7.22418576e-02f, -3.98561172e-02f, 3.27422842e-02f, 5.07407971e-02f,
  5.21767549e-02f, -5.17452322e-02f, 5.94173558e-03f, 5.23021212e-04f, -2.69063786e-02f, 4.69343783e-03f, 1.37442023e-01f, 4.73728441e-02f, 8.96428805e-03f, 2.76177526e-02f,
  -1.86800793e-01f, -1.23936541e-01f, 1.03110606e-02f, 3.67939705e-03f, -3.06275804e-02f, 5.81029691e-02f, -3.55372243e-02f, 1.24094104e-02f, -8.37860927e-02f, 8.37926660e-03f,
  7.05247223e-02f, 8.12439434e-03f, 1.49441753e-02f, 3.24944183e-02f, -1.22225070e-02f, -2.93825492e-02f, -8.66215080e-02f, 1.26485778e-02f, -3.68631408e-02f, 2.39764638e-02f,
  6.69491813e-02f, -2.69854516e-02f, 2.51214914e-02f, -5.70240850e-03f, 4.09643576e-02f, -2.18128064e-03f, -5.67444526e-02f, 1.86789948e-02f, -4.50999849e-03f, -5.79690002e-02f,
  3.79721105e-01f, -1.35462105e-01f, -1.43049061e-01f, 1.78601131e-01f, 1.58790082e-01f, -2.51484603e-01f, -2.58845776e-01f, 9.69872624e-02f, 2.52380490e-01f, -1.65119439e-01f,
  -1.27798200e-01f, 1.38912175e-03f, -1.35870457e-01f, -1.21855065e-01f, 1.12360805e-01f, -5.27793765e-02f, -2.60231216e-02f, -8.00327063e-02f, 7.30400681e-02f, 3.19531932e-02f,
  1.19457021e-01f, -4.20502536e-02f, -1.25432059e-01f, -2.65754070e-02f, -1.16658788e-02f, 5.03842570e-02f, 2.22533438e-02f, -9.97117385e-02f, -2.79126316e-02f, -9.75321159e-02f,
  -1.19707681e-01f, 1.54077113e-01f, -8.65564309e-03f, -6.97090849e-02f, 2.99747121e-02f, -2.27531046e-02f, -6.69045746e-02f, -8.03296193e-02f, -3.67550217e-02f, 2.41948795e-02f,
  -1.33890826e-02f, 1.77700911e-02f, 3.09097748e-02f, -1.04585327e-02f, 6.74671382e-02f, 1.19319828e-02f, 2.05424018e-02f, 1.36106396e-02f, 6.13214070e-05f, 6.56030849e-02f,
  1.25333806e-02f, -1.81673262e-02f, 6.36440143e-02f, -3.23418416e-02f, 5.86075224e-02f, -2.27566008e-02f, -4.65037003e-02f, 1.81111787e-02f, 3.23526040e-02f, 4.28153686e-02f,
  5.93455732e-02f, -3.00668320e-03f, 1.49281342e-02f, -3.87601391e-03f, 1.57875307e-02f, 4.15306687e-02f, 3.90807129e-02f, -5.25323674e-02f, -2.79069412e-02f, -1.84958726e-02f,
  5.74709661e-02f, 7.09836408e-02f, -5.97601794e-02f, 2.44348440e-02f, 6.61397651e-02f, 1.44476872e-02f, -1.98909920e-03f, -8.03726092e-02f, 1.04484120e-02f, -4.10170946e-03f,
  1.04072562e-04f, -5.94064966e-03f, -2.11053584e-02f, -1.38938259e-02f, -5.03558293e-02f, 1.73839927e-02f, -3.03768348e-02f, -8.38436186e-03f, -4.16629426e-02f, -1.54042272e-02f,
  -3.03882658e-02f, 1.88239664e-02f, -4.10138927e-02f, -2.68103704e-02f, -3.41961719e-02f, 7.24327564e-02f, 1.81319769e-02f, 8.16224329e-03f, -2.36808266e-02f, 3.32223251e-02f,
  6.90679476e-02f, 1.61218196e-02f, -1.19350189e-02f, 5.35105960e-03f, 2.55405623e-02f, -2.51182765e-02f, -3.72237936e-02f, -3.56856803e-03f, 1.40260104e-02f, 3.33660049e-03f,
  -1.77573785e-02f, -2.94908676e-02f, -2.02367338e-03f, 3.40265930e-02f, 4.33467701e-02f, -4.53443900e-02f, 2.60147788e-02f, 2.12296154e-02f, 3.45587842e-02f, -8.43018014e-03f,
  1.03045650e-01f, -2.28003412e-01f, -2.89246649e-01f, 8.73173848e-02f, 3.10960084e-01f, -1.80686172e-02f, -3.09057552e-02f, 9.07581300e-02f, -1.52164459e-01f, -7.48032629e-02f,
  1.80407479e-01f, -1.95587873e-01f, -1.29739434e-01f, 1.18373539e-02f, -3.87988724e-02f, -2.39828870e-01f, 2.02459265e-02f, -1.44849457e-02f, -1.92210022e-02f, 1.48868665e-01f,
  3.09744161e-02f, 3.70791614e-01f, -2.21398175e-02f, 1.69577733e-01f, 2.00680181e-01f, 1.30514624e-02f, 2.42352128e-01f, -2.67997961e-02f, 1.73191935e-01f, 1.28151732e-03f,
  8.61063674e-02f, -9.38743632e-03f, 4.36961465e-02f, -1.14954963e-01f, 6.35000244e-02f, -7.26566371e-03f, -8.98841675e-03f, 8.96042585e-03f, 1.46911209e-02f, -3.33936303e-03f,
  5.31833572e-03f, 1.35602141e-02f, 9.52971540e-03f, -6.03534989e-02f, -2.52596568e-02f, -1.25569301e-02f, 1.59442145e-02f, 2.29464434e-02f, -7.96074513e-03f, -6.75959140e-02f,
  -1.19620465e-01f, -6.36838600e-02f, -5.24920858e-02f, -1.07826153e-02f, -6.69534281e-02f, -2.06029806e-02f, -5.02800271e-02f, 3.77830653e-03f, 5.23470342e-02f, 3.32722603e-03f,
  2.88198702e-02f, -8.53976514e-03f, -1.56512782e-02f, 1.73039306e-02f, 2.33316999e-02f, 4.36702333e-02f, -7.48782307e-02f, 3.08504608e-02f, -4.78180014e-02f, 2.58266851e-02f,
  5.29599153e-02f, -3.71124456e-03f, -3.76926851e-03f, -5.45690320e-02f, 1.99767593e-02f, -9.31907352e-03f, -6.18306212e-02f, -1.99189279e-02f, -4.48219758e-03f, 3.47939692e-02f,
  -1.76083688e-02f, -3.26642841e-02f, -1.16887465e-02f, 2.92774718e-02f, -5.11960946e-02f, -2.11326554e-02f, -2.17690170e-02f, -8.64775404e-02f, -8.69129290e-05f, 8.64733234e-02f,
  1.36580154e-01f, 6.64661685e-03f, 3.62438075e-02f, 7.45194852e-02f, 3.90654467e-02f, 3.86416749e-03f, -3.86713147e-02f, -2.48437319e-02f, -2.59536784e-02f, -6.33427128e-03f,
  2.47303303e-02f, 6.28037602e-02f, 1.23994974e-02f, 3.91918756e-02f, 1.03735803e-02f, 5.78008313e-03f, 1.16902916e-02f, 2.42648665e-02f, 8.57756585e-02f, 7.05593452e-02f,
  8.08796212e-02f, 7.05478787e-02f, -1.87584702e-02f, 7.42564797e-02f, 7.60206208e-02f, -1.28651457e-02f, 4.36207838e-02f, -6.14383072e-02f, 5.16370460e-02f, -4.73091491e-02f,
  -2.34236434e-01f, 1.80063263e-01f, -1.42285436e-01f, -8.99493694e-02f, -2.01991931e-01f, -1.20051511e-01f, -9.04834718e-02f, -1.59955427e-01f, -3.27118218e-01f, 2.64031887e-01f,
  1.13480827e-02f, 9.72477645e-02f, 7.65127018e-02f, 1.11013271e-01f, -3.86233516e-02f, 1.20819867e-01f, 1.39426619e-01f, 1.60410494e-01f, -1.55635364e-02f, -2.75990507e-03f,
  1.88601725e-02f, 2.13456020e-01f, 1.64296433e-01f, 1.02042496e-01f, 5.79733960e-02f, 1.90904886e-02f, 2.42280409e-01f, -7.75024761e-03f, 1.31965935e-01f, 3.80373783e-02f,
  -2.13592662e-03f, -5.90936430e-02f, 4.10623215e-02f, -5.12214042e-02f, 2.84264870e-02f, 1.61672793e-02f, 3.38373706e-02f, -1.34120043e-02f, -8.80532488e-02f, -2.61228941e-02f,
  3.66653614e-02f, -5.52509241e-02f, 1.11341989e-03f, -1.26808621e-02f, -1.05246484e-01f, -9.39926431e-02f, -4.07196581e-02f, -3.21973674e-02f, -6.02785461e-02f, -4.96785827e-02f,
  -5.65496646e-02f, -6.87317178e-02f, -4.78829630e-02f, 1.18594114e-02f, -3.22305225e-02f, -4.58485484e-02f, -4.21612822e-02f, 2.32003238e-02f, 6.91570854e-03f, -1.41163226e-02f,
  8.74406323e-02f, 1.16019249e-02f, 4.16966379e-02f, 8.53525940e-03f, -3.14465128e-02f, -3.31714749e-02f, 1.90361701e-02f, 2.95901019e-02f, -7.93221891e-02f, 1.20014632e-02f,
  -5.31888157e-02f, -1.50306476e-02f, -6.20431527e-02f, -9.19745415e-02f, 3.19873802e-02f, 4.12895828e-02f, 3.43951513e-03f, -3.45871858e-02f, 2.00967900e-02f, 3.33880521e-02f,
  -5.47917709e-02f, -6.32488802e-02f, 2.89189983e-02f, -3.77882645e-02f, 1.18872989e-02f, -2.32201386e-02f, -2.88231429e-02f, -9.41776782e-02f, -3.34346741e-02f, 7.02564418e-02f,
  1.15896270e-01f, 2.09243402e-01f, 6.38565272e-02f, -3.01685967e-02f, 3.58342417e-02f, 8.83549377e-02f, 9.37592424e-03f, -5.65901548e-02f, 2.65600774e-02f, -1.48705477e-02f,
  3.94285694e-02f, -2.66114213e-02f, 7.88789764e-02f, -6.81542680e-02f, 3.88280861e-02f, -5.49420062e-03f, 5.41633815e-02f, 6.44072704e-03f, 1.35479078e-01f, 7.37432316e-02f,
  1.52286422e-02f, 2.66684801e-03f, -8.47372320e-03f, -3.29764956e-03f, 7.57320784e-03f, 3.03601343e-02f, 1.63796637e-02f, -2.00839024e-02f, -2.21363362e-02f, 4.00671028e-02f,
  4.85100567e-01f, -3.09446245e-01f, 6.30698167e-03f, 1.15513109e-01f, 2.70171434e-01f, -1.23553656e-01f, -2.59945065e-01f, 5.41359512e-03f, 7.91266859e-02f, -3.09729934e-01f,
  -3.60843129e-02f, -1.74864098e-01f, -7.69861341e-02f, -9.17725042e-02f, 3.67056102e-01f, 2.84973346e-02f, 2.13942155e-02f, -1.41099542e-01f, 1.41657621e-01f, 7.60652050e-02f,
  1.97208896e-01f, 1.14846870e-01f, 3.09853181e-02f, 3.84020247e-02f, 1.10031674e-02f, -2.63153333e-02f, 3.99371982e-02f, -6.98557571e-02f, -1.31212965e-01f, -8.36484730e-02f,
  -4.82832193e-02f, 5.97150251e-02f, -1.02850022e-02f, -7.11495131e-02f, 4.93879318e-02f, -1.71396155e-02f, -7.91203901e-02f, 1.60209034e-02f, 5.56698740e-02f, 3.82383205e-02f,
  -9.55464505e-03f, 6.73394799e-02f, -7.59208924e-04f, 2.94344984e-02f, 4.68999669e-02f, -4.87267599e-02f, -2.71486435e-02f, -3.98626775e-02f, -3.75581309e-02f, -2.03439705e-02f,
  -1.93850615e-03f, 1.42439548e-02f, 7.36053288e-02f, -4.35890146e-02f, 4.27772067e-02f, -5.27535193e-03f, -1.28225572e-02f, -1.61947068e-02f, -4.23515169e-03f, 2.96092052e-02f,
  4.53838073e-02f, -2.24856231e-02f, 2.14965250e-02f, 2.06891098e-03f, 9.59412660e-03f, 6.64812922e-02f, 5.23752086e-02f, -2.19889507e-02f, -3.97305414e-02f, -2.51916554e-02f,
  4.20508161e-02f, 6.25101179e-02f, -3.78757790e-02f, 3.41172218e-02f, -2.67099682e-03f, -9.91463382e-03f, 4.94551398e-02f, -7.78245255e-02f, -9.87894367e-03f, -1.19205937e-02f,
  -5.45635484e-02f, 4.99695167e-02f, -1.15134262e-01f, -1.50128817e-02f, -2.09368989e-02f, 8.92256736e-04f, -4.06081695e-03f, -5.70899732e-02f, 4.22261562e-03f, 5.81668727e-02f,
  -6.97295070e-02f, -1.04311369e-01f, -3.16882208e-02f, -7.18529373e-02f, -9.79469046e-02f, 3.58958729e-02f, 3.51960994e-02f, 6.46556839e-02f, -4.18972373e-02f, 4.98452373e-02f,
  8.22959747e-03f, -5.77782355e-02f, -2.27743052e-02f, -1.31423967e-02f, 2.58221682e-02f, -3.85225452e-02f, -5.87506443e-02f, -7.25834295e-02f, -6.75318111e-03f, -2.15519331e-02f,
  -3.31991427e-02f, -6.31759828e-03f, 1.52311390e-02f, 1.75920036e-02f, 2.62701176e-02f, -9.50955227e-02f, -1.78471468e-02f, 6.41577691e-02f, 3.51111256e-02f, -2.22448129e-02f,
  4.01683271e-01f, 2.79257093e-02f, -3.17672998e-01f, 1.75111592e-01f, 1.58827841e-01f, -6.87267631e-03f, -5.00216521e-02f, 1.17170855e-01f, 1.06342487e-01f, 2.94507165e-02f,
  7.56993592e-02f, 6.47078902e-02f, -2.55003005e-01f, 8.33629817e-02f, -7.56696612e-02f, -2.22088769e-01f, 4.84205373e-02f, 8.07215050e-02f, 1.60308573e-02f, 4.83179986e-02f,
  -2.26263013e-02f, 1.64862931e-01f, -2.29467452e-01f, -1.15354536e-02f, 3.47355306e-02f, -2.59692711e-03f, -8.84102508e-02f, -2.02768877e-01f, 1.18843175e-01f, 7.76539892e-02f,
  1.37607738e-01f, 1.07366160e-01f, -3.66621427e-02f, -2.50853430e-02f, 1.82139911e-02f, -3.91667821e-02f, -3.56898829e-02f, -9.09941420e-02f, -5.36077935e-03f, 1.11876484e-02f,
  -3.06110661e-02f, 5.29640205e-02f, 9.28963944e-02f, -1.13563433e-01f, 1.79371871e-02f, 2.78781485e-02f, -9.25556384e-03f, 2.15679798e-02f, 2.76805256e-02f, -3.49356756e-02f,
  -8.94092098e-02f, 6.51593972e-03f, -2.10272148e-02f, 5.13968877e-02f, -4.37823497e-02f, 5.77300414e-02f, -4.45384420e-02f, -2.63565965e-02f, 8.77853390e-03f, 1.08377881e-01f,
  -6.07666327e-03f, -5.53912260e-02f, -3.88023295e-02f, 6.96509182e-02f, -1.21977245e-02f, 5.09464107e-02f, -7.11612925e-02f, 4.87093031e-02f, -4.04178584e-03f, 6.89186230e-02f,
  7.97181278e-02f, 5.23016527e-02f, 2.59808768e-02f, -4.32058759e-02f, -1.68899987e-02f, 6.01788498e-02f, -4.79948670e-02f, -1.46325948e-02f, -3.03384382e-03f, 7.60616362e-02f,
  -5.51981619e-03f, -2.13696603e-02f, -3.53962407e-02f, -3.58406305e-02f, 8.13547522e-02f, -6.81273490e-02f, -5.18747717e-02f, -5.72726205e-02f, -3.24919559e-02f, -8.08080286e-02f,
  2.37325002e-02f, -2.71855220e-02f, 4.18003276e-02f, 1.37483463e-01f, 4.38231602e-03f, 2.48223804e-02f, -1.25479244e-03f, 6.02667034e-02f, -1.16846403e-02f, -1.61249768e-02f,
  -8.47433321e-03f, 2.03337111e-02f, 3.66878090e-03f, 4.10432294e-02f, -4.39705811e-02f, -1.41969807e-02f, -2.35921461e-02f, 8.10495764e-03f, 4.77695093e-03f, 2.89394204e-02f,
  -5.67605607e-02f, -8.55255593e-03f, -4.02563624e-02f, 5.18909246e-02f, 5.82056232e-02f, 5.25745265e-02f, 9.56201106e-02f, 3.26708257e-02f, -3.18075456e-02f, -5.24749011e-02f,
  -2.37076152e-02f, -2.64720589e-01f, -1.22379787e-01f, -2.22828895e-01f, 1.56301036e-01f, 3.85602623e-01f, 2.56146938e-01f, -3.35453600e-02f, -2.06796452e-01f, 7.02969879e-02f,
  1.99253485e-01f, -2.87971586e-01f, 9.69561040e-02f, 2.85256580e-02f, 1.65279031e-01f, 1.02028154e-01f, 8.11255500e-02f, 1.97921321e-02f, -1.31013766e-01f, -1.22008689e-01f,
  -3.44692990e-02f, 1.00368977e-01f, 3.97501066e-02f, -3.97365093e-02f, 1.02097653e-01f, -1.74072281e-01f, 3.78426723e-02f, -3.88652794e-02f, 3.08504310e-02f, 7.12910965e-02f,
  1.11592039e-01f, -1.20819137e-01f, -3.98774445e-02f, -2.31699012e-02f, 5.04568666e-02f, 1.73736294e-03f, 4.42438610e-02f, 4.97967415e-02f, -3.49671617e-02f, 7.83565640e-03f,
  -5.68331343e-05f, -2.58942298e-03f, -4.78916988e-02f, -1.95870046e-02f, -4.72908653e-02f, -9.53352638e-03f, -3.53940986e-02f, 5.78015819e-02f, -8.63900781e-02f, 4.88518998e-02f,
  2.31602206e-03f, 5.70337847e-02f, 1.54752973e-02f, -2.22138576e-02f, -1.19014625e-02f, -2.08337847e-02f, -4.26263958e-02f, 3.85588519e-02f, 1.92288831e-02f, -6.60906434e-02f,
  3.22576649e-02f, -3.04003935e-02f, 1.81853399e-02f, 3.72487567e-02f, 1.78566948e-02f, 3.49249281e-02f, -2.68030446e-02f, 4.50808480e-02f, -4.74632978e-02f, 6.33852109e-02f,
  2.08589528e-02f, -4.74269083e-03f, -1.25948824e-02f, 6.82718353e-03f, 3.92357260e-03f, -3.31125185e-02f, -5.44267613e-03f, -1.36587210e-02f, -2.39222012e-02f, 4.34473120e-02f,
  -2.27200799e-03f, 4.75085527e-03f, -7.98068382e-03f, 5.58946170e-02f, 7.99057707e-02f, -1.70666259e-02f, -5.46039455e-02f, 3.66935618e-02f, -6.11774810e-03f, 3.19372825e-02f,
  -4.06135730e-02f, -2.21974090e-01f, -1.18723642e-02f, -4.94140051e-02f, -2.12898236e-02f, 7.98757300e-02f, -7.67520163e-03f, 2.37983204e-02f, -4.28651124e-02f, 2.15485860e-02f,
  4.29772772e-02f, -1.78569630e-02f, -1.95505307e-03f, 1.87898278e-02f, -2.25404482e-02f, 2.48779282e-02f, -3.54214422e-02f, 6.43969688e-05f, 1.72800720e-02f, -6.13611415e-02f,
  2.43256241e-03f, 2.43469011e-02f, -2.22250093e-02f, 1.22607229e-02f, 4.79323696e-03f, 3.29797342e-02f, -2.10182313e-02f, -7.70216733e-02f, 4.02663052e-02f, -1.63315479e-02f,
  -3.81968141e-01f, -6.05433173e-02f, -1.12219378e-01f, -3.69401672e-03f, 1.44647881e-01f, 3.60384732e-01f, 7.16389269e-02f, 7.23450705e-02f, 8.31257701e-02f, 1.19834356e-01f,
  2.38940284e-01f, -1.04825674e-02f, -6.69688508e-02f, 2.97642946e-01f, 1.54640540e-01f, 6.99087679e-02f, 2.60428220e-01f, 1.69933230e-01f, -1.02013201e-01f, -9.78299454e-02f,
  -2.19876654e-02f, 2.06888273e-01f, -4.15116735e-02f, 4.49208431e-02f, -7.65314475e-02f, -2.16479108e-01f, -9.34865028e-02f, -1.26131862e-01f, 9.42640230e-02f, 8.02171156e-02f,
  -7.21679106e-02f, -7.02966973e-02f, -3.97788249e-02f, 1.26189534e-02f, 5.16410684e-03f, -8.70863944e-02f, -1.40507102e-01f, 2.45452467e-02f, -7.20810443e-02f, 3.21519785e-02f,
  -5.00952229e-02f, -2.57248860e-02f, 9.35373232e-02f, 3.74419093e-02f, -1.29630798e-02f, -1.95819549e-02f, 2.24305652e-02f, 3.44181918e-02f, -8.87237564e-02f, -3.71749289e-02f,
  6.16969541e-02f, -7.05660284e-02f, 4.47725914e-02f, 2.84281820e-02f, 1.20479958e-02f, 6.92517906e-02f, 4.63370467e-03f, -3.07763424e-02f, 1.46417916e-02f, 1.23402607e-02f,
  -1.24603277e-02f, -5.91206886e-02f, 4.40040156e-02f, -6.91457000e-03f, 3.97324413e-02f, -5.85243516e-02f, 2.91123576e-02f, 5.73311374e-03f, -1.10117644e-01f, -1.29319094e-02f,
  7.97489658e-02f, -2.05564331e-02f, -2.62295734e-02f, 7.77550833e-03f, -6.22377219e-03f, -5.27687073e-02f, -3.61898728e-02f, -3.21693122e-02f, 5.35404794e-02f, -1.11988280e-03f,
  -5.50859086e-02f, 2.40367707e-02f, 8.17838982e-02f, -4.79217730e-02f, 3.51606533e-02f, 3.37144919e-02f, 1.83273479e-02f, 1.61692854e-02f, 2.81431507e-02f, -5.63218445e-03f,
  -8.68539810e-02f, -3.37499343e-02f, 6.06287457e-02f, 1.08074825e-02f, -2.40523950e-04f, 7.49821067e-02f, -3.42399522e-04f, 4.32337373e-02f, 5.20220166e-03f, 3.89631987e-02f,
  -1.75183434e-02f, -4.71355990e-02f, -5.12919761e-02f, -3.16542462e-02f, 6.60538999e-03f, 8.88843387e-02f, -2.91647464e-02f, -4.86374274e-02f, 4.87332642e-02f, -8.60460326e-02f,
  -2.49078386e-02f, -1.89989083e-03f, 3.91230173e-02f, 3.13834511e-02f, -7.29366811e-03f, -7.05265580e-03f, 2.72997338e-02f, -3.79659645e-02f, -2.83239763e-02f, 7.25712627e-03f,
  -2.27642030e-01f, 3.13236207e-01f, 1.27930552e-01f, -2.28302404e-01f, -7.03986958e-02f, -1.84757605e-01f, -2.14794964e-01f, -3.28065967e-03f, 6.44217208e-02f, 1.39234632e-01f,
  -2.76412666e-01f, 2.33757019e-01f, -1.81932561e-02f, -1.59169689e-01f, -3.15197080e-01f, -3.25492909e-03f, -1.63242176e-01f, -7.05584660e-02f, 5.96643798e-02f, -7.09594712e-02f,
  -7.80728012e-02f, -2.02695310e-01f, -8.71514454e-02f, 1.57445952e-01f, -2.85310112e-02f, 2.11169243e-01f, -1.43247008e-01f, 8.52337331e-02f, -3.11016887e-02f, 6.70130458e-03f,
  -2.37565562e-02f, -2.66074762e-02f, 5.54202721e-02f, 6.25284910e-02f, -6.53054267e-02f, -2.07480527e-02f, -2.69497335e-02f, 1.33960303e-02f, -6.37233406e-02f, -8.21640133e-04f,
  1.81138478e-02f, -3.21249403e-02f, 3.78598981e-02f, 2.88466439e-02f, 1.02605252e-02f, 3.57345119e-02f, 2.68095694e-02f, 7.86926504e-03f, -1.72783285e-02f, 9.22697969e-03f,
  -4.00248580e-02f, -1.41226472e-02f, -3.73753197e-02f, 1.23912864e-03f, -8.10264493e-04f, 1.15671130e-02f, 1.36316335e-02f, 4.58582751e-02f, 4.28136140e-02f, 2.30125915e-02f,
  7.32884882e-03f, -6.89958036e-03f, -1.19727161e-02f, 5.72804958e-02f, -6.38288185e-02f, 2.32359935e-02f, -2.60332115e-02f, -1.09703131e-02f, 3.52403782e-02f, -2.14186944e-02f,
  -5.72780669e-02f, 1.27514414e-02f, -3.21906134e-02f, -4.26149415e-03f, -5.40723614e-02f, 3.81192118e-02f, 1.49470139e-02f, 8.41282681e-03f, -6.91781146e-03f, -2.52528656e-02f,
  -1.92266051e-02f, -3.19576971e-02f, 2.21852195e-02f, -4.88783640e-04f, -1.04296459e-02f, 2.06081737e-02f, -4.27444279e-02f, -1.11846591e-03f, 2.20060889e-02f, -1.11824773e-01f,
  -6.39034435e-02f, 8.08615121e-04f, 6.96634920e-03f, 3.46717089e-02f, 5.40365465e-02f, 4.17851247e-02f, 3.19493450e-02f, 7.34284669e-02f, -9.23353340e-03f, -3.96695100e-02f,
  3.21553573e-02f, -4.11800342e-03f, -4.24131751e-03f, -2.19394416e-02f, -3.46630439e-02f, -3.32219228e-02f, -5.57232052e-02f, 1.69630498e-02f, -3.79874222e-02f, -3.62508781e-02f,
  -3.08392607e-02f, 2.60306546e-03f, 1.44291930e-02f, 2.45378688e-02f, -3.19663249e-02f, -8.57504550e-03f, 2.56379247e-02f, 3.48052792e-02f, -5.49569763e-02f, 4.67141420e-02f,
  -3.17356110e-01f, 7.99879581e-02f, -9.80011225e-02f, -3.17918837e-01f, 6.15044124e-02f, 1.53114855e-01f, 5.84748574e-02f, 9.55903977e-02f, -9.75122452e-02f, 1.23644240e-01f,
  1.38100728e-01f, -2.50255734e-01f, 4.45012510e-01f, -2.76897967e-01f, -3.20811659e-01f, 1.95141733e-01f, -1.21216573e-01f, -7.41927326e-02f, 1.70117542e-02f, -4.26837057e-02f,
  -7.65432715e-02f, -1.83983415e-01f, 3.73828434e-03f, -1.09900010e-03f, -2.18791485e-01f, 4.84421523e-03f, -1.29184306e-01f, 8.27260837e-02f, -2.75391757e-01f, -9.28888619e-02f,
  -1.59020610e-02f, -6.33745939e-02f, -3.34458314e-02f, 7.51842419e-03f, -1.01723811e-02f, 7.65699744e-02f, -5.00025786e-02f, 2.27419324e-02f, 5.02218641e-02f, 3.66603322e-02f,
  -9.74524673e-03f, -9.73218679e-02f, -2.35645510e-02f, 4.51330245e-02f, -9.56930295e-02f, -1.03215963e-01f, -7.21586570e-02f, 1.49282278e-03f, -3.97933945e-02f, -4.13370542e-02f,
  -1.92226358e-02f, -2.84612868e-02f, -6.35692775e-02f, 1.24078505e-02f, 2.63893809e-02f, 1.33926850e-02f, -7.36005306e-02f, -7.66811473e-03f, -7.68378675e-02f, -1.07182875e-01f,
  8.61260574e-03f, 1.14189118e-01f, -2.14476790e-03f, -2.00357828e-02f, -1.24112051e-03f, 1.72909778e-02f, -1.65753234e-02f, -1.84339453e-02f, -5.53188771e-02f, 1.33014908e-02f,
  -4.59192926e-03f, 4.14568074e-02f, -2.80275606e-02f, 3.32382470e-02f, -1.38659850e-02f, -1.48880873e-02f, 8.31407532e-02f, 4.11932580e-02f, -1.14855245e-02f, -1.58272032e-03f,
  -1.90107673e-02f, -1.25064058e-02f, -1.52611481e-02f, -1.29410354e-02f, 3.45087494e-03f, -1.35774566e-02f, -3.43947373e-02f, -1.19647747e-02f, 8.42916220e-02f, 7.18476251e-02f,
  -1.13314549e-02f, -3.03446874e-02f, 1.14207171e-01f, -3.64843607e-02f, 1.54347215e-02f, 9.22308397e-03f, -1.67081412e-02f, -5.53990193e-02f, -1.05298832e-01f, -1.31253330e-02f,
  1.70914177e-02f, 2.15041917e-02f, -3.07861972e-03f, -8.98338482e-03f, -7.58263515e-03f, -2.71509849e-02f, 3.56106088e-02f, 1.93004422e-02f, -3.42100114e-02f, 1.64161157e-02f,
  4.19445634e-02f, 6.67084828e-02f, 3.39980572e-02f, -1.34049617e-02f, 1.85615402e-02f, 1.62373483e-02f, -2.18413547e-02f, 5.71290217e-02f, 1.82167571e-02f, 2.39538364e-02f,
  1.13706447e-01f, -2.36286208e-01f, -3.33455235e-01f, -1.45239681e-01f, 8.68170708e-02f, -9.23159868e-02f, 1.89246878e-01f, -1.18451804e-01f, 8.59554484e-02f, 7.34270960e-02f,
  5.66531941e-02f, 2.77061854e-02f, 1.78836569e-01f, -2.14072108e-01f, -1.50539860e-01f, 4.96322662e-02f, -1.58451691e-01f, 5.25640696e-02f, 4.69349399e-02f, -4.82775122e-02f,
  -4.03892510e-02f, -3.82562727e-03f, -1.03450358e-01f, -5.49264066e-02f, -1.43146321e-01f, -1.00436352e-01f, 7.66380131e-03f, 8.86810571e-02f, -2.32862458e-01f, -2.07166392e-02f,
  -9.20652077e-02f, -1.01770423e-02f, -8.59273076e-02f, -9.39460658e-03f, -4.69356254e-02f, 2.84427330e-02f, -1.32037848e-02f, 8.21668357e-02f, 3.39334384e-02f, -2.17372626e-02f,
  3.01385932e-02f, 3.48918559e-03f, -8.08660779e-03f, 1.00708254e-01f, 2.79512666e-02f, -7.60258958e-02f, -8.10271222e-03f, -7.61937574e-02f, -3.39532979e-02f, -1.18312594e-02f,
  -2.91108321e-02f, -9.01884511e-02f, -8.25887918e-03f, -3.81009467e-03f, 2.73174420e-02f, -5.06922929e-03f, -4.16810773e-02f, -1.43521270e-02f, -4.52923477e-02f, -4.69453027e-03f,
  4.70600789e-03f, 9.50465575e-02f, -1.09201819e-02f, -3.22776176e-02f, 6.97788503e-03f, -3.67671028e-02f, 2.41055246e-02f, 1.18891727e-02f, 1.02859950e-02f, 3.89130972e-02f,
  1.42888445e-02f, -2.70883832e-02f, 1.71625372e-02f, 2.35054307e-02f, 1.83209905e-03f, 1.52864708e-02f, 6.03273287e-02f, 4.61173952e-02f, -7.33898729e-02f, -4.11910303e-02f,
  2.16074679e-02f, -9.41977743e-03f, 5.04728081e-03f, -1.83289368e-02f, -4.38861623e-02f, 7.19951745e-03f, -4.09317240e-02f, -7.13655129e-02f, 1.58904862e-04f, 5.49981631e-02f,
  -8.49139318e-02f, 2.91615035e-02f, 1.50753772e-02f, 2.08242629e-02f, 1.07157370e-02f, -2.06560944e-03f, -3.35224755e-02f, -8.13476592e-02f, -3.54315690e-03f, 4.48185988e-02f,
  2.22047269e-02f, 3.45970877e-02f, 1.86027680e-02f, -1.77065786e-02f, -3.26729715e-02f, -6.24733791e-02f, 6.30010962e-02f, 4.55585644e-02f, 8.23871791e-03f, -1.27962530e-02f,
  1.10345660e-02f, 7.70272538e-02f, 2.98668314e-02f, 3.19913924e-02f, 1.36988107e-02f, 6.11470304e-02f, 6.63048634e-03f, 8.51067435e-03f, -1.59358513e-02f, -4.83705513e-02f,
  4.61793303e-01f, -4.95165586e-01f, -2.78440863e-01f, 1.54885069e-01f, 1.13640614e-01f, 1.08867146e-01f, 3.93990278e-02f, -5.75343370e-02f, 1.76964089e-01f, -2.56944358e-01f,
  -6.39276728e-02f, -4.92354706e-02f, -7.96634406e-02f, -1.23260170e-02f, 4.63091612e-01f, 1.07618213e-01f, 1.21835880e-01f, 4.83632050e-02f, 1.19925255e-03f, -1.35961056e-01f,
  4.36571687e-02f, 8.09792951e-02f, -7.80711621e-02f, -4.76361662e-02f, -6.31377101e-02f, -1.24463372e-01f, -4.65616211e-03f, -5.70999123e-02f, -1.14113107e-01f, 5.88119775e-02f,
  -1.25031732e-02f, -1.51552465e-02f, -7.28057027e-02f, 7.86849856e-03f, 2.08325982e-02f, -2.19274741e-02f, -3.92237455e-02f, 9.38121751e-02f, 4.54218984e-02f, -2.51616538e-02f,
  5.69281727e-02f, 2.50760335e-02f, 3.13290469e-02f, 6.40966073e-02f, -3.11007425e-02f, -3.66950780e-02f, -5.61328642e-02f, -5.13519384e-02f, -5.51252514e-02f, -6.88850135e-03f,
  -2.99868882e-02f, -4.68047149e-02f, 1.22988475e-02f, -4.05826084e-02f, 6.74004331e-02f, 1.62772723e-02f, 1.05785939e-03f, 1.50491130e-02f, 3.01508531e-02f, 4.36685868e-02f,
  7.27773160e-02f, 4.01193202e-02f, 2.30257269e-02f, -4.96728308e-02f, 4.44823839e-02f, -3.13095339e-02f, -1.54684726e-02f, 8.96266662e-03f, -1.63613539e-02f, -1.20088970e-02f,
  1.18946806e-02f, 1.18676890e-02f, -7.55404704e-04f, 1.68384258e-02f, -1.48521026e-03f, -4.80864793e-02f, 1.31745683e-02f, -8.36071931e-03f, 8.36241059e-03f, -4.71671410e-02f,
  3.01299933e-02f, 1.49808023e-02f, -4.32726033e-02f, 4.20517474e-03f, 1.44321034e-02f, 3.16826776e-02f, -8.67703639e-04f, -5.79938479e-02f, -4.26525623e-02f, 6.00439534e-02f,
  1.70882151e-03f, -1.62496582e-01f, -3.98897426e-03f, -4.22075428e-02f, -5.21443747e-02f, 6.86963741e-03f, 2.97132786e-02f, -1.18996622e-02f, 3.94598395e-02f, -2.93132942e-02f,
  2.32378472e-04f, -4.97901775e-02f, -5.20275123e-02f, 6.28642216e-02f, 6.10400252e-02f, -2.52057537e-02f, -2.47633662e-02f, 4.40301420e-03f, 2.93358415e-02f, -5.32974713e-02f,
  -3.26592252e-02f, -6.76307231e-02f, 6.58710971e-02f, 3.88962775e-02f, 2.94783525e-03f, -2.57676207e-02f, -1.41377458e-02f, 6.33701012e-02f, -8.07763077e-03f, 3.60711664e-02f,
  -3.05006653e-01f, 2.85099268e-01f, 9.80087444e-02f, -1.05702199e-01f, 1.60011470e-01f, -5.81249371e-02f, -6.84355050e-02f, 2.27215916e-01f, -2.21814811e-01f, 1.25344068e-01f,
  -1.12626344e-01f, -1.39513105e-01f, -3.17674503e-02f, -1.68060839e-01f, -3.80891651e-01f, -2.72921324e-01f, -1.70007721e-01f, -1.34384081e-01f, -1.87179849e-01f, 3.41847092e-02f,
  -6.08875081e-02f, 5.74774295e-03f, 1.92388088e-01f, 2.49846607e-01f, 1.66999310e-01f, 1.70316383e-01f, 1.38775036e-01f, 1.68209955e-01f, 1.43566236e-01f, -4.67255376e-02f,
  -2.71098297e-02f, -8.02883692e-03f, 1.07967578e-01f, 2.53546820e-03f, 1.35009885e-02f, 2.75657494e-02f, -5.99808898e-03f, -3.32810096e-02f, -1.42755220e-02f, 2.06573289e-02f,
  -6.19448684e-02f, -4.77542309e-03f, -5.09166382e-02f, -3.14815827e-02f, 3.82694229e-02f, 1.32772850e-03f, -3.35104531e-03f, 4.88762707e-02f, 5.11163399e-02f, -3.97162475e-02f,
  4.31216555e-03f, -4.88822795e-02f, -4.50421907e-02f, -8.17839876e-02f, -1.64761525e-02f, -5.84869720e-02f, 7.40082841e-03f, 2.08075475e-02f, -4.68045138e-02f, -7.00494647e-02f,
  1.18497573e-03f, -1.98745821e-02f, 5.93325570e-02f, 1.62100345e-02f, 1.00745615e-02f, 1.30657768e-02f, -5.04143052e-02f, 8.36844742e-03f, -3.68564241e-02f, -1.96999852e-02f,
  -2.40467023e-02f, 1.53784752e-02f, -5.66918403e-04f, -4.36307304e-03f, -3.97397578e-02f, 1.89117920e-02f, 2.29662322e-02f, -3.25478390e-02f, 4.49012453e-03f, 4.02835831e-02f,
  -8.29756446e-03f, -9.76207387e-03f, 3.42869982e-02f, 4.04333882e-02f, 4.27508960e-03f, 7.25385221e-03f, -1.21793626e-02f, 5.48575819e-02f, 1.01860156e-02f, 4.02310304e-03f,
  -3.21412319e-03f, 6.06534705e-02f, 4.64046560e-02f, -2.40937732e-02f, -3.56140621e-02f, 6.23725820e-03f, -4.83454466e-02f, 1.28392642e-02f, 3.42152081e-02f, -2.16684025e-02f,
  7.74872378e-02f, 3.83931808e-02f, 2.63579637e-02f, -4.80309241e-02f, -1.91933960e-02f, 3.38688828e-02f, -4.20061313e-02f, -1.47501100e-02f, 2.64340490e-02f, -2.46279612e-02f,
  6.45200983e-02f, -5.28607368e-02f, -1.98853798e-02f, 9.99602228e-02f, -8.70815013e-03f, 1.06374864e-02f, 1.81486998e-02f, -1.03088329e-02f, -1.88793428e-02f, -2.91346461e-02f,
  1.23821288e-01f, 2.24833563e-01f, -1.56246826e-01f, -4.09458345e-03f, -1.54469699e-01f, -5.29516488e-02f, -8.58135819e-02f, 3.64615619e-02f, 1.85268432e-01f, 1.74617931e-01f,
  -2.12369096e-02f, -7.15409592e-02f, 5.65766022e-02f, 7.10776523e-02f, 1.74435169e-01f, 1.85377255e-01f, 2.23884806e-01f, 4.12713224e-03f, -2.38038856e-03f, -1.80611067e-04f,
  -4.86510582e-02f, 7.18477145e-02f, -9.00984406e-02f, -1.36093013e-02f, -6.45645782e-02f, -5.84087707e-02f, 6.59341961e-02f, -1.59243762e-01f, -2.90612578e-02f, -2.57858876e-02f,
  2.99604866e-03f, -5.03792129e-02f, -6.46294132e-02f, -2.64018402e-03f, 3.15910147e-04f, -6.65253177e-02f, -2.74960902e-02f, -6.86388686e-02f, -7.13512907e-03f, 9.71036716e-05f,
  -1.16488338e-02f, -7.90072903e-02f, 4.93246177e-03f, -8.46800394e-03f, -9.57946014e-03f, -2.52190186e-03f, -7.49822333e-02f, -2.00239196e-02f, -5.82575947e-02f, -1.11331329e-01f,
  -1.04410566e-01f, -9.89268441e-03f, -5.21838106e-02f, 3.80795822e-02f, -1.03365473e-01f, -8.85546133e-02f, -5.11535332e-02f, -1.89850777e-02f, 6.87967539e-02f, -5.48614562e-03f,
  6.59724995e-02f, 1.86102092e-02f, -5.63791096e-02f, 1.41995698e-02f, -1.77716333e-02f, -5.58662340e-02f, 8.47516879e-02f, -5.65200970e-02f, -3.16130780e-02f, 6.94437847e-02f,
  -6.33776188e-02f, -1.54543677e-02f, 4.67763394e-02f, -8.08911119e-03f, -2.55274493e-02f, -4.11698781e-03f, -1.02253728e-01f, -4.34549637e-02f, -1.13634504e-02f, -3.24273221e-02f,
  1.62383299e-02f, 5.80595201e-03f, 2.55001225e-02f, -2.19789706e-02f, 3.84982415e-02f, -1.60049144e-02f, -2.95710582e-02f, -3.51067958e-03f, 2.59591546e-02f, 6.11559711e-02f,
  2.35978588e-01f, 2.12119505e-01f, -1.85279234e-04f, -3.79693247e-02f, 3.21862474e-02f, 5.69610298e-02f, 6.08550496e-02f, 2.00606161e-03f, 9.71794873e-02f, 3.95306535e-02f,
  -3.56285125e-02f, -3.06713339e-02f, 4.99825478e-02f, -4.42930460e-02f, 1.05097899e-02f, 3.23413126e-03f, -2.63756011e-02f, 9.17646438e-02f, 5.84911443e-02f, 1.95782892e-02f,
  1.63636953e-02f, 1.93087775e-02f, -7.44415075e-02f, -4.99788076e-02f, -5.20610157e-03f, 2.10383702e-02f, 5.25303856e-02f, -3.58746238e-02f, 1.13083534e-02f, 4.18530330e-02f,
  -1.47256285e-01f, -1.67213753e-01f, -5.75255044e-02f, -1.76200777e-01f, 1.53109327e-01f, 7.95182213e-02f, 1.01987422e-01f, 3.90359648e-02f, -2.02947125e-01f, -1.45867705e-01f,
  1.98405668e-01f, -2.00118184e-01f, 1.53125182e-01f, 1.52655005e-01f, 7.17890561e-02f, 8.67012814e-02f, -1.24504492e-01f, -8.69827792e-02f, -1.03491791e-01f, -1.13084078e-01f,
  1.49583155e-02f, 1.05390839e-01f, 1.74022734e-01f, 8.55177548e-03f, 4.53697778e-02f, -1.21694706e-01f, -4.73153405e-02f, 7.35873589e-03f, -9.14987028e-02f, 4.71092202e-02f,
  1.95021659e-01f, -8.39262828e-02f, 2.55287886e-02f, 2.50737416e-03f, -7.22638331e-03f, -6.88513415e-03f, 9.65685397e-03f, 8.09611604e-02f, -6.23743143e-03f, -2.92563438e-02f,
  1.92667339e-02f, -4.77492400e-02f, -6.82447329e-02f, -2.48846672e-02f, -2.62014065e-02f, -8.83549675e-02f, 3.10128052e-02f, 5.65323830e-02f, 1.87243726e-02f, 7.37160370e-02f,
  6.27196357e-02f, 2.17831992e-02f, -5.05683720e-02f, -4.42522876e-02f, -1.44212693e-02f, -5.38145974e-02f, -7.13348165e-02f, 3.22597474e-02f, -2.90736202e-02f, -6.90467358e-02f,
  -7.90441334e-02f, -8.21229368e-02f, 4.37377095e-02f, 5.39126843e-02f, 1.34745194e-02f, 6.28223717e-02f, -3.05016786e-02f, 5.24041727e-02f, -7.00288638e-02f, 1.99475326e-02f,
  -3.05533856e-02f, 5.59967058e-03f, -2.54431483e-03f, -6.33672997e-02f, -2.82006469e-02f, -3.47507671e-02f, -1.93538256e-02f, -4.45648581e-02f, -4.88198213e-02f, 7.08399788e-02f,
  -1.14818849e-02f, -4.38374057e-02f, 4.36515473e-02f, 1.08835667e-01f, 1.30101247e-02f, 1.94092300e-02f, -5.00288606e-02f, 3.40621397e-02f, 4.22829688e-02f, -1.67957731e-02f,
  -6.96030185e-02f, -3.49352598e-01f, -2.24966202e-02f, -4.21400368e-02f, -3.81884836e-02f, 4.04112488e-02f, -9.86992847e-03f, -4.95504513e-02f, -1.21954329e-01f, -4.70187105e-02f,
  -6.05609715e-02f, -1.08883111e-02f, -3.47612016e-02f, -3.24569270e-02f, 1.65710375e-02f, 7.48409610e-03f, -3.88643630e-02f, -9.19993594e-02f, -7.39634112e-02f, -3.48791033e-02f,
  -4.48128358e-02f, -5.64944521e-02f, -5.25710396e-02f, -9.06153861e-03f, -2.84782052e-02f, -1.64504256e-02f, -9.83059928e-02f, -4.47157882e-02f, -6.49292246e-02f, -6.99946599e-04f,
  -1.73876584e-01f, 2.10733086e-01f, -7.09639350e-03f, -2.57979363e-01f, -2.84491777e-02f, 1.31614015e-01f, 1.73063353e-02f, 1.36733323e-01f, -7.35766254e-04f, 1.58684298e-01f,
  -7.97525048e-02f, 1.58679053e-01f, 1.68676227e-01f, -1.74287081e-01f, -2.40912735e-01f, -9.60840210e-02f, -2.16811180e-01f, 1.13052437e-02f, 6.89860955e-02f, 2.21411302e-03f,
  -1.13066897e-01f, -2.24893779e-01f, -1.63641945e-01f, 5.84815182e-02f, -2.56878212e-02f, 5.00283130e-02f, -1.08146019e-01f, 7.20414370e-02f, -1.17849655e-01f, -6.52439892e-02f,
  8.25055391e-02f, 4.72848564e-02f, -1.20274359e-02f, 4.61283848e-02f, -5.91293573e-02f, 4.42037638e-03f, -1.47420717e-02f, 3.29166930e-03f, -1.97211001e-02f, 7.29486272e-02f,
  3.03004682e-02f, 3.27899754e-02f, -4.67430353e-02f, -3.13947834e-02f, 1.64555516e-02f, 3.87805924e-02f, -4.10102447e-03f, 1.34770051e-02f, 1.21524513e-01f, -2.36215442e-02f,
  2.67106500e-02f, -2.91170496e-02f, -3.35452147e-02f, 1.65511167e-03f, -8.54010507e-03f, 2.30725817e-02f, -6.26560822e-02f, -1.91608770e-03f, 1.58930419e-03f, -4.09319773e-02f,
  -9.91589800e-02f, -1.30168041e-02f, -2.97730672e-03f, -1.01495590e-02f, -4.79387455e-02f, -4.30618934e-02f, -3.55047137e-02f, -2.74213459e-02f, -5.80041111e-02f, 2.80536339e-03f,
  -4.44943309e-02f, 2.06070524e-02f, 4.93742432e-03f, 5.85553120e-04f, -7.49020129e-02f, -3.75013947e-02f, -3.04925535e-02f, 2.35178676e-02f, -9.37296748e-02f, 1.94185157e-03f,
  5.19568771e-02f, 1.11636864e-02f, 4.93002050e-02f, 6.29136164e-04f, 4.93958667e-02f, -6.25768211e-03f, 5.86122759e-02f, 1.83366481e-02f, 1.03818476e-02f, 7.22734444e-03f,
  7.99931288e-02f, 3.89410034e-02f, 3.55948731e-02f, 1.22770384e-01f, -1.23117678e-02f, 2.96855848e-02f, -3.41557935e-02f, -5.48276817e-03f, 1.56664066e-02f, 9.09064524e-03f,
  2.01446470e-04f, 1.05505530e-02f, 2.30046501e-03f, -9.64269042e-03f, -2.90750172e-02f, -1.88159645e-02f, -3.70396934e-02f, -1.39487814e-02f, -3.36023904e-02f, 5.87075353e-02f,
  5.68387844e-02f, -2.93742083e-02f, -1.14644496e-02f, -2.88237371e-02f, -4.14893478e-02f, -1.06740519e-02f, 2.41753403e-02f, 1.42764384e-02f, -1.28952600e-02f, -1.58596430e-02f,
  -2.81658977e-01f, 8.03754106e-02f, 9.21761170e-02f, -2.41624445e-01f, 1.07943557e-01f, -9.07131359e-02f, -2.65721977e-01f, 1.54026067e-02f, 1.85720131e-01f, -7.56993517e-02f,
  -1.10471070e-01f, -1.25731483e-01f, 5.40936701e-02f, -2.79730886e-01f, -2.88431495e-01f, 8.15395440e-04f, -1.88387513e-01f, -1.59601867e-01f, 2.26212308e-01f, -1.36988685e-01f,
  4.90359263e-03f, -2.34789893e-01f, -1.68109775e-01f, 1.27837941e-01f, -1.64511815e-01f, 1.20463759e-01f, -1.29183501e-01f, 1.95518732e-01f, -1.68574244e-01f, -2.25373618e-02f,
  -9.83652547e-02f, -1.38656244e-01f, 2.35882420e-02f, 6.06769063e-02f, -7.13706538e-02f, 5.12899458e-03f, -2.06231680e-02f, 3.93096693e-02f, 8.01214576e-02f, 2.44905073e-02f,
  -3.90155800e-02f, -3.33436877e-02f, -9.07904748e-03f, 6.84871748e-02f, 8.91356468e-02f, 6.27335161e-04f, -4.06746306e-02f, 3.38231325e-02f, 4.48757932e-02f, -1.51544306e-02f,
  -3.00250761e-02f, -2.63957120e-02f, -8.95093940e-03f, -4.35798392e-02f, 5.83605170e-02f, 2.61271019e-02f, 7.66460374e-02f, -1.40760494e-02f, -1.02430403e-01f, 1.92442201e-02f,
  -4.14441191e-02f, 1.55837297e-01f, 1.42368861e-02f, -1.63052380e-02f, -9.65966191e-03f, 7.13127991e-03f, 1.33492108e-02f, -4.12902795e-02f, 6.51788712e-02f, -7.08537549e-02f,
  -1.73604321e-02f, 1.05335582e-02f, -1.79318096e-02f, 3.14681306e-02f, -3.22096236e-02f, -2.36860998e-02f, 2.33861874e-03f, -1.77283883e-02f, 3.39990556e-02f, -3.05403071e-03f,
  -2.48181056e-02f, 4.58777100e-02f, -8.77753925e-03f, 1.93332192e-02f, 2.07884219e-02f, -4.20057923e-02f, 9.66256857e-02f, -3.68946642e-02f, 1.01142675e-02f, -9.21810791e-03f,
  -1.64381906e-01f, -1.33563727e-01f, 4.50896956e-02f, -6.53996505e-03f, 1.49586601e-02f, -8.78966600e-03f, 4.95214760e-02f, 8.74194354e-02f, -2.84742992e-02f, -3.65608223e-02f,
  1.78696308e-02f, 3.93888354e-02f, -7.03891218e-02f, 2.13429555e-02f, -4.22524698e-02f, 1.33347651e-02f, -4.91708331e-02f, 4.45847251e-02f, -7.86698982e-02f, 6.43101707e-02f,
  -5.65128587e-02f, 5.58439363e-03f, 7.82083347e-03f, -4.86002974e-02f, -7.11740274e-03f, -4.12198752e-02f, -6.22808188e-02f, 6.92960545e-02f, -5.88006824e-02f, 6.09042384e-02f,
  2.65187263e-01f, 1.28879234e-01f, -7.26582408e-02f, -2.15164293e-03f, -1.35162592e-01f, 1.10225260e-01f, 1.54171318e-01f, -1.46992177e-01f, 2.17018142e-01f, -2.25734785e-02f,
  -8.40049386e-02f, 2.33595103e-01f, 6.44303439e-03f, -2.13619880e-02f, 8.96576867e-02f, 1.22251444e-01f, 6.91267028e-02f, 1.77461252e-01f, -1.98620223e-02f, -2.32964810e-02f,
  -2.68791001e-02f, -1.10151425e-01f, -7.53534287e-02f, -2.32727662e-01f, -6.71691671e-02f, -1.93467513e-02f, -2.26102501e-01f, -1.13075271e-01f, -1.10863559e-01f, 8.12869333e-03f,
  5.73527217e-02f, 1.95292998e-02f, -2.27542482e-02f, 4.82473783e-02f, -1.60578620e-02f, 2.14759186e-02f, 2.42762454e-02f, 1.54929506e-02f, -3.00370976e-02f, -6.50050724e-03f,
  8.45759884e-02f, -4.88811731e-02f, -2.66481023e-02f, -8.40099230e-02f, 1.02537356e-01f, -2.77012512e-02f, 3.60644720e-02f, 1.86715126e-02f, -2.00406145e-02f, 6.69182336e-04f,
  -1.83759991e-03f, 2.43558194e-02f, 1.75640415e-02f, 4.44683097e-02f, -1.11051099e-02f, 1.78121123e-02f, -4.15225998e-02f, 3.23590375e-02f, 4.98702116e-02f, 9.53294151e-03f,
  4.56248000e-02f, -4.83552814e-02f, -3.79384011e-02f, -1.53151946e-02f, 2.72556744e-03f, -3.20015885e-02f, 3.41691636e-03f, -2.93901954e-02f, 3.98291945e-02f, 8.04615021e-03f,
  -4.24332395e-02f, -5.22018597e-03f, -5.33185573e-03f, 2.17485446e-02f, -2.72557717e-02f, 5.76921478e-02f, 9.38951224e-03f, -2.61787083e-02f, -4.79133287e-03f, -1.96347572e-02f,
  -3.51797678e-02f, 3.41645330e-02f, 7.72875873e-03f, -2.21712925e-02f, 3.22150365e-02f, -2.60472223e-02f, -6.04552589e-02f, -3.65616865e-02f, 3.14676948e-02f, -4.41402495e-02f,
  1.10224597e-01f, -1.44681260e-01f, -3.36428173e-03f, 6.39149249e-02f, 2.13665869e-02f, -9.41894203e-03f, -2.75597833e-02f, 2.25057080e-02f, 3.06495558e-02f, -4.30827290e-02f,
  1.70033739e-03f, 9.45048127e-03f, -6.84392033e-03f, 8.17355700e-03f, -1.04964804e-02f, -2.53510587e-02f, 1.67746041e-02f, 1.13609638e-02f, -1.13857146e-02f, -8.53660107e-02f,
  -6.39371127e-02f, 6.52415529e-02f, -1.35510284e-02f, 1.01668071e-02f, -2.54846793e-02f, 2.43366249e-02f, -3.68326670e-03f, 1.17620779e-02f, -7.97723755e-02f, -6.84030447e-03f,
  -4.71093386e-01f, 1.81526795e-01f, -7.30496421e-02f, -1.00004546e-01f, -1.08540915e-01f, 3.25664759e-01f, 2.25204393e-01f, 2.26406939e-02f, -6.70540705e-02f, 2.61594057e-01f,
  1.25970989e-01f, -1.49958640e-01f, 1.75370693e-01f, 2.80084789e-01f, 8.82309973e-02f, 2.31979445e-01f, 1.52139232e-01f, 6.58873543e-02f, -4.14498597e-02f, -5.01175113e-02f,
  -6.71309233e-02f, 2.46665388e-01f, 8.48810449e-02f, 1.42614320e-01f, -6.51183538e-04f, -1.39461726e-01f, -8.62598419e-03f, -5.21284193e-02f, 3.19165029e-02f, 3.92876863e-02f,
  1.49860620e-01f, -4.12767977e-02f, -3.65166292e-02f, -2.65370961e-02f, 1.27826007e-02f, -3.75635922e-02f, -1.05393799e-02f, 1.50424859e-03f, -2.89125834e-02f, -1.35957282e-02f,
  -3.27706598e-02f, -3.46664281e-04f, 3.48446816e-02f, -2.07760818e-02f, -1.42257055e-02f, -4.69135605e-02f, 1.34131433e-02f, -2.60884389e-02f, 1.15513150e-02f, -2.89189331e-02f,
  -1.03167603e-02f, 2.55837142e-02f, -4.17868048e-02f, 4.24982496e-02f, -5.28786331e-02f, -1.74486847e-03f, 2.69611664e-02f, -5.72790802e-02f, -1.98808480e-02f, -2.34599113e-02f,
  -4.02664952e-02f, 1.12687908e-02f, -4.05152794e-03f, 4.40648105e-03f, 3.12166419e-02f, -3.87224555e-02f, 7.96281919e-03f, 3.11187673e-02f, -3.75046693e-02f, 4.14505005e-02f,
  -2.32216809e-02f, -5.48298471e-02f, 8.73037241e-03f, 5.46851836e-04f, -4.92946245e-03f, 6.85992138e-03f, -3.73544097e-02f, 1.46048795e-03f, -4.92162369e-02f, -1.72155499e-02f,
  2.31784228e-02f, -1.23805702e-02f, 5.02916053e-02f, -2.51361597e-02f, 9.62142199e-02f, -1.28905643e-02f, 4.40820446e-03f, -3.36751938e-02f, 2.66476106e-02f, -1.76372658e-02f,
  1.11445144e-01f, 4.70771044e-02f, 3.56711484e-02f, 4.68297265e-02f, 1.25221396e-02f, -4.28333208e-02f, 1.66666880e-02f, 4.96125733e-03f, -7.65333837e-03f, -1.24418391e-02f,
  -3.47885787e-02f, -2.65529174e-02f, -3.74704152e-02f, -1.61635442e-04f, 1.15803294e-02f, 4.21404839e-02f, 1.78797152e-02f, -5.59497103e-02f, -3.79262120e-02f, 5.27797965e-03f,
  -1.44498004e-02f, -1.78966653e-02f, -3.25359707e-03f, 2.96886582e-02f, 1.48141002e-02f, 1.50810694e-02f, -2.77123824e-02f, 3.01043969e-03f, -8.54270160e-03f, 1.21882251e-02f,
  3.72276276e-01f, 2.80501485e-01f, -4.53496799e-02f, -4.18598130e-02f, 9.58559737e-02f, 2.64000177e-01f, -4.04158570e-02f, 1.12113379e-01f, 2.24473730e-01f, 9.71937478e-02f,
  -1.29723191e-01f, 1.38551995e-01f, -1.19648688e-01f, 5.40952310e-02f, -1.42964959e-01f, -8.77908319e-02f, 4.93982099e-02f, 5.57213500e-02f, 1.09909736e-02f, 9.38663781e-02f,
  -6.90750312e-03f, 1.66020226e-02f, -2.25191981e-01f, 2.82567609e-02f, 1.31504014e-01f, 6.09291345e-02f, -2.26190343e-01f, -1.04646295e-01f, 6.89473152e-02f, -3.93984802e-02f,
  1.10996000e-01f, -3.58805321e-02f, 5.81155345e-03f, 9.89970658e-03f, 5.11575937e-02f, 9.39284638e-03f, -1.96362641e-02f, -1.08185254e-01f, -9.74680632e-02f, -1.87335275e-02f,
  3.01313270e-02f, 2.83624679e-02f, 1.14279278e-02f, -1.10246260e-02f, 1.14168838e-01f, 3.70476209e-02f, 5.33189662e-02f, 4.96397205e-02f, 4.13082354e-02f, -2.10181680e-02f,
  2.06479616e-02f, 1.80607811e-02f, 2.08816342e-02f, 1.13232601e-02f, -3.13928835e-02f, 4.29072306e-02f, -2.48956513e-02f, -5.11621423e-02f, 9.01451707e-02f, 4.19314206e-02f,
  -1.17624871e-01f, 1.08911628e-02f, -1.55496197e-02f, 1.50441565e-02f, 1.09522780e-02f, -1.33040668e-02f, -1.56918429e-02f, -6.79766461e-02f, 4.12775315e-02f, 1.37693528e-02f,
  6.35882020e-02f, -9.29946918e-03f, 1.78073514e-02f, 2.51495261e-02f, -5.86393895e-03f, 1.72205046e-02f, -3.43942754e-02f, 6.53221682e-02f, 4.61770892e-02f, 9.34454985e-03f,
  -4.39588688e-02f, 5.42276092e-02f, 4.76658903e-02f, -3.42495181e-03f, -3.13290097e-02f, -5.04915044e-02f, 2.24737525e-02f, 5.17745055e-02f, -5.62046282e-02f, -6.04922175e-02f,
  2.92858899e-01f, 1.19406044e-01f, 9.73146036e-03f, 5.65370880e-02f, 3.97242457e-02f, 4.04285751e-02f, -2.95186341e-02f, 8.56336951e-02f, 6.14165552e-02f, -2.22532898e-02f,
  -7.19242916e-03f, 3.70492251e-03f, 4.14039083e-02f, 4.84792031e-02f, -4.80681136e-02f, -1.08266780e-02f, -8.00712034e-02f, 1.10991010e-02f, -4.51235622e-02f, 1.66770071e-02f,
  -7.91941881e-02f, -4.49349135e-02f, -2.04970986e-02f, 5.12950309e-02f, -3.55479233e-02f, -2.96386257e-02f, 6.40606731e-02f, 1.98360835e-03f, -7.27487868e-03f, 9.98672005e-03f,
  4.96656924e-01f, -1.87471569e-01f, 1.28067240e-01f, 1.77664682e-01f, 2.29604900e-01f, 1.75365638e-02f, 1.41264107e-02f, 1.95155516e-01f, 1.34025931e-01f, -5.39565794e-02f,
  1.45471275e-01f, -7.04971328e-02f, -8.32645521e-02f, 9.52671841e-02f, -1.45518873e-02f, -2.01710090e-01f, 1.63196281e-01f, 7.81142041e-02f, -7.08263144e-02f, 2.01099887e-01f,
  6.72010481e-02f, 4.63625379e-02f, 5.92967235e-02f, -2.69597694e-02f, 2.00631201e-01f, 6.61156848e-02f, -3.02672796e-02f, -1.02519020e-01f, 7.21153393e-02f, -5.31871021e-02f,
  7.62849674e-02f, 2.08185643e-01f, 1.23123415e-01f, 5.11985049e-02f, 1.12235226e-01f, -3.54384026e-03f, 4.76177521e-02f, -7.19529912e-02f, -3.10129579e-02f, 2.59249043e-02f,
  -2.76815053e-02f, 4.70891595e-03f, 4.32534628e-02f, -5.44592664e-02f, 5.91096506e-02f, 4.99116927e-02f, -5.09959273e-02f, 2.74135601e-02f, -2.40406170e-02f, 1.28595168e-02f,
  -2.39707325e-02f, -1.97293796e-02f, 1.82688888e-02f, 9.57512390e-03f, 2.28828769e-02f, -6.20074421e-02f, -3.14341262e-02f, 1.58782341e-02f, 4.01292853e-02f, 5.73184974e-02f,
  3.30407396e-02f, 1.36166168e-02f, -5.47237415e-03f, 2.68684328e-03f, 2.63035316e-02f, 3.27088982e-02f, -5.73215447e-02f, -1.70292165e-02f, -5.18025458e-02f, 1.64152011e-02f,
  4.19965796e-02f, 2.52585970e-02f, 2.61048432e-02f, -3.81163694e-02f, 9.02239326e-03f, 1.57958753e-02f, -1.94908455e-02f, 3.22219878e-02f, 5.52271567e-02f, 3.90518308e-02f,
  -4.97363210e-02f, -4.65657189e-02f, 2.81398166e-02f, 3.48684490e-02f, -1.49296112e-02f, -4.59007099e-02f, 3.38014439e-02f, 9.66354832e-03f, 2.91611794e-02f, 8.81063845e-03f,
  5.33208437e-02f, 5.87057434e-02f, 2.95179505e-02f, -1.39117213e-02f, -7.03938445e-03f, 3.83846015e-02f, -3.62992398e-02f, 5.13672195e-02f, -1.69447623e-02f, 4.76424284e-02f,
  8.68721828e-02f, 2.01773141e-02f, 1.05973501e-02f, 1.09380176e-02f, -2.66013145e-02f, 1.14254132e-02f, 1.81542069e-03f, -6.08843192e-03f, 6.15355708e-02f, 2.28244700e-02f,
  3.60412560e-02f, 1.73923913e-02f, -2.20852587e-02f, 6.09704815e-02f, 5.87217323e-02f, 1.47770403e-03f, 5.28435595e-02f, 5.65562630e-03f, -7.12500233e-03f, 1.13186883e-02f,
  4.98146564e-01f, -8.67391378e-02f, 1.99493859e-03f, 3.08329791e-01f, -3.78844850e-02f, 5.47020808e-02f, 2.68849432e-01f, -1.85646601e-02f, 5.86648807e-02f, -1.44424960e-01f,
  2.16315866e-01f, -6.47867844e-02f, 8.92121345e-02f, 2.25770772e-01f, 3.56178373e-01f, 1.25148147e-01f, 2.94228643e-01f, 6.07930794e-02f, -5.97693175e-02f, 1.22791462e-01f,
  3.85639966e-02f, 1.66947871e-01f, 1.60905212e-01f, -2.25177124e-01f, 4.87905703e-02f, -1.26679197e-01f, 5.11349328e-02f, -1.89025953e-01f, 2.91137826e-02f, -2.00911183e-02f,
  -4.94235270e-02f, 6.20486774e-02f, 2.42321547e-02f, -1.50717691e-01f, 9.97517928e-02f, 3.17877382e-02f, -2.53813099e-02f, -3.77438441e-02f, 1.04199862e-02f, -1.75848100e-02f,
  -3.75935733e-02f, -4.35891226e-02f, -4.83641326e-02f, -4.22837920e-02f, -1.46392817e-02f, -6.36072233e-02f, 5.41076530e-03f, 5.60259372e-02f, -4.81593385e-02f, 3.95465605e-02f,
  6.74525425e-02f, -8.93181469e-03f, 2.84413304e-02f, 2.64762319e-03f, -1.67603847e-02f, -2.52826847e-02f, 9.19403415e-03f, -5.13378605e-02f, -2.26192605e-02f, 3.43878269e-02f,
  2.51999721e-02f, -1.97947565e-02f, 3.13027538e-02f, -6.05800748e-02f, 2.27486584e-02f, -6.23029657e-02f, -2.58722622e-02f, 7.80428527e-03f, -1.22074513e-02f, 4.60175276e-02f,
  1.55776273e-02f, -1.61013715e-02f, -1.68623719e-02f, 6.10794965e-03f, 6.80526718e-02f, -9.66240931e-03f, -1.99246835e-02f, -2.39819335e-03f, 2.29110289e-02f, 2.58981325e-02f,
  -5.47148362e-02f, 4.60861549e-02f, -4.01856378e-03f, -4.13294546e-02f, 1.20554445e-03f, -4.78532575e-02f, -2.57758051e-02f, -4.02914640e-03f, 4.56787366e-03f, 1.14267699e-01f,
  9.78414714e-02f, 7.55756795e-02f, 1.94643531e-03f, -9.02580693e-02f, -6.20813668e-02f, 5.33094890e-02f, 6.77414890e-03f, -3.85577418e-02f, -3.31330262e-02f, 2.87943035e-02f,
  -2.30966993e-02f, -2.48743016e-02f, -4.22955118e-02f, -2.02921173e-03f, -3.31001803e-02f, 2.38256790e-02f, 6.81311116e-02f, -3.23712197e-03f, 1.89027507e-02f, -3.99282761e-02f,
  1.90878119e-02f, -5.35310768e-02f, 1.10535277e-02f, -4.49991263e-02f, -2.68375943e-03f, -6.43378170e-03f, 4.45049517e-02f, -1.43691674e-02f, 2.75583435e-02f, -4.89874743e-02f,
  -4.75070745e-01f, 3.48138660e-01f, -1.83497053e-02f, -2.12811053e-01f, -1.45034850e-01f, -9.63427201e-02f, -3.11044782e-01f, -2.13932559e-01f, -4.10536796e-01f, 1.28024533e-01f,
  -1.66375026e-01f, -3.68244275e-02f, -1.20645143e-01f, -4.34469767e-02f, -7.08125010e-02f, 9.16236565e-02f, -1.76764149e-02f, -6.06358796e-02f, -1.01720653e-01f, -3.83597985e-02f,
  -1.01979561e-01f, 8.88592899e-02f, 7.00536510e-03f, 1.41726285e-01f, -1.12394415e-01f, 3.83402817e-02f, 1.61331192e-01f, -3.60507378e-03f, 7.33294263e-02f, -5.19798025e-02f,
  -1.25441477e-01f, -3.31270456e-01f, -1.21626027e-01f, -8.19402412e-02f, -4.47770618e-02f, -5.59921972e-02f, 2.10934505e-02f, 2.78727598e-02f, -4.22880389e-02f, -3.22998203e-02f,
  1.81950182e-02f, 7.48939142e-02f, -3.56504060e-02f, -3.93456072e-02f, 3.56990173e-02f, -3.91389765e-02f, 2.34564021e-02f, -4.76869978e-02f, -2.40753801e-03f, 2.80246790e-02f,
  -4.99791540e-02f, 5.60551398e-02f, -1.67600457e-02f, 2.19401699e-02f, -1.87251866e-02f, -6.26408786e-04f, 7.25957751e-02f, -2.53732558e-02f, 7.05484524e-02f, -5.69678284e-02f,
  -3.94419022e-02f, 1.71585884e-02f, 8.52548853e-02f, 1.98938102e-02f, -3.57419588e-02f, 5.08549670e-03f, 6.54795244e-02f, 6.75575659e-02f, -2.81645637e-02f, 5.91659918e-02f,
  -1.05826259e-02f, -9.16523766e-03f, -6.54903725e-02f, 1.14315087e-02f, 2.62628915e-03f, -6.83343261e-02f, 6.10606484e-02f, 1.73125807e-02f, -6.76228330e-02f, 3.18462052e-03f,
  -7.46074766e-02f, 1.09754223e-02f, -6.27101138e-02f, -1.81457158e-02f, 1.23978434e-02f, -1.67265423e-02f, 1.52638704e-02f, 2.71619856e-02f, -1.23895695e-02f, -2.65581161e-02f,
  6.73441356e-03f, 7.34137138e-03f, -4.57362868e-02f, -2.50391737e-02f, 1.36413872e-01f, 5.26490360e-02f, -2.57263817e-02f, 4.27336209e-02f, 7.39080906e-02f, -4.88580763e-02f,
  9.06565879e-03f, -1.99861601e-02f, 4.69050147e-02f, 7.17504472e-02f, 8.59604552e-02f, 3.54800781e-04f, 2.15832088e-02f, -1.86346117e-02f, 2.69012116e-02f, 7.13299140e-02f,
  9.66467708e-02f, -3.19471397e-03f, 4.52818945e-02f, -1.06966577e-01f, 2.23740395e-02f, 1.12195574e-02f, -9.64451768e-03f, 4.38209064e-02f, 8.99586529e-02f, 6.29314482e-02f,
  -2.13215034e-02f, -3.15340102e-01f, -1.97425410e-01f, 3.53083163e-01f, -1.75215006e-02f, 5.64476736e-02f, 2.17252880e-01f, -1.56341922e-02f, 1.44642457e-01f, 1.47309199e-01f,
  2.93338239e-01f, -7.59344250e-02f, -4.25745249e-02f, 2.25212410e-01f, 2.64702648e-01f, 8.27350616e-02f, 2.46519640e-01f, 1.11316562e-01f, -1.60901770e-01f, -8.29274021e-03f,
  7.35931396e-02f, 2.21833259e-01f, 6.46387339e-02f, -6.86013326e-02f, -5.63236773e-02f, -1.41519517e-01f, 7.12872893e-02f, -7.91998878e-02f, 5.59046827e-02f, 4.37809601e-02f,
  -4.64872532e-02f, 1.38150290e-01f, -2.80103274e-02f, -3.35607715e-02f, 1.33172469e-02f, -2.19838265e-02f, -1.27537306e-02f, -1.58439502e-02f, 2.67113373e-02f, -3.28785516e-02f,
  -6.07375056e-02f, -1.79438274e-02f, 2.49468349e-03f, 6.77090064e-02f, -6.13481961e-02f, -7.94582441e-02f, -5.67606501e-02f, -4.56450544e-02f, -5.93813509e-02f, -5.90428077e-02f,
  2.16416828e-02f, -6.10700436e-02f, 4.57315557e-02f, 2.19192076e-02f, 5.29870624e-03f, 1.69886369e-02f, 7.78636057e-03f, -5.28228842e-02f, -4.90574129e-02f, 3.56310047e-02f,
  2.74842959e-02f, 6.41774312e-02f, 5.06494846e-03f, -4.71416861e-02f, 2.07552942e-03f, -6.86300620e-02f, 2.61902660e-02f, -5.67702278e-02f, 3.99672277e-02f, -1.47587042e-02f,
  6.08172780e-03f, -1.96863394e-02f, 5.95973916e-02f, 9.23666209e-02f, 9.33163017e-02f, 5.04853809e-03f, -4.84667383e-02f, -4.69547696e-03f, -1.20795108e-02f, -2.18729128e-05f,
  3.02222259e-02f, 2.08920129e-02f, 4.51923907e-03f, -3.58497314e-02f, 4.74574976e-02f, 5.86563274e-02f, 3.65818962e-02f, -3.88443843e-02f, 1.01653105e-02f, 5.48752584e-02f,
  1.50645003e-01f, 1.83986261e-01f, 7.08067641e-02f, 9.14525799e-03f, 1.06730231e-03f, 1.75263584e-02f, 8.09783265e-02f, -5.21957166e-02f, 6.07304797e-02f, 3.09203323e-02f,
  3.16070169e-02f, 7.13683851e-03f, 1.15590543e-02f, 2.01708451e-02f, 2.92155258e-02f, 8.01872909e-02f, 4.03986126e-02f, 6.78550452e-02f, 5.34954891e-02f, -4.01033871e-02f,
  2.55671535e-02f, -5.32699376e-02f, 5.07244319e-02f, 3.60923330e-03f, -2.27053482e-02f, 3.45260985e-02f, -2.94975266e-02f, 4.30888217e-03f, -2.34276820e-02f, 2.72540431e-02f,
  -5.48941083e-02f, -4.28780735e-01f, -1.13998912e-02f, -1.19322732e-01f, 1.30311921e-01f, -7.02105649e-03f, 1.72416028e-02f, -8.16457346e-02f, 8.94542411e-02f, -1.87098905e-01f,
  2.26778276e-02f, -2.14750424e-01f, 4.30364236e-02f, -2.78879672e-01f, 2.43316237e-02f, -7.17021571e-03f, -1.32289693e-01f, -1.53103471e-01f, 4.12514620e-02f, -7.98171461e-02f,
  1.05832075e-03f, -1.25191852e-01f, -8.43884945e-02f, -3.40289176e-02f, -1.51294902e-01f, -5.73725812e-02f, 3.84089835e-02f, 8.19435641e-02f, -1.98585734e-01f, -4.26121168e-02f,
  -3.40887532e-02f, 6.45790435e-03f, -7.07499776e-03f, -8.66369344e-03f, 1.91080756e-02f, -6.44329982e-03f, -8.87127593e-04f, 1.06572751e-02f, 1.19615361e-01f, -1.33421281e-02f,
  -3.06617073e-03f, -1.14267524e-02f, -6.56380802e-02f, -8.24462716e-03f, -3.52204574e-04f, 1.66772101e-02f, -2.59051118e-02f, 3.16805695e-03f, -1.20516419e-02f, -8.68757367e-02f,
  -8.69083218e-03f, -4.24590670e-02f, 1.01416400e-02f, -2.26789284e-02f, 7.46984780e-02f, 7.94290751e-02f, -5.43605676e-03f, -5.15226163e-02f, -5.46199083e-02f, -2.92557967e-03f,
  -6.10239320e-02f, 1.86238438e-02f, -3.52362394e-02f, -1.79482158e-02f, -8.05492979e-03f, 1.25684380e-03f, -4.14732210e-02f, -3.95351425e-02f, 4.60993536e-02f, 2.36325935e-02f,
  1.16365226e-02f, -6.72145784e-02f, 1.27370488e-02f, 1.83558892e-02f, 2.52731959e-03f, -3.98300737e-02f, 4.46795225e-02f, -9.45547130e-03f, 4.95629981e-02f, 4.83174957e-02f,
  -1.65170822e-02f, 3.88043374e-02f, -1.25605268e-02f, -2.35797884e-03f, -4.06246185e-02f, 4.80485708e-02f, -3.34753543e-02f, -4.16681729e-02f, 4.92939614e-02f, -2.60305293e-02f,
  -1.07906848e-01f, -1.55504704e-01f, -9.29380825e-04f, -1.53905647e-02f, 6.02852404e-02f, -5.49180582e-02f, -1.87703613e-02f, -4.42915410e-02f, -1.89636275e-02f, 3.39403935e-02f,
  -2.61722784e-02f, 3.38888764e-02f, 5.40995365e-03f, 5.67727908e-02f, -3.12930904e-02f, 9.45228804e-03f, 4.62954231e-02f, 6.01448566e-02f, 4.49470766e-02f, -4.19737510e-02f,
  -2.00033318e-02f, 4.37384248e-02f, -1.44174527e-02f, 5.19737899e-02f, -4.02567238e-02f, 5.59156574e-02f, -5.74801490e-03f, -3.25744450e-02f, -1.65617429e-02f, -4.39549983e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.09442428e-01f, -1.45672709e-01f, 1.69951543e-01f, 1.10362902e-01f, -5.98519184e-02f, 3.20801437e-02f, 4.37229574e-01f, -3.99854481e-01f, -3.87718230e-01f, -1.11941405e-01f,
  -4.73674983e-02f, 3.29501033e-01f, 1.95297331e-01f, -2.68867344e-01f, 6.22825138e-02f, -1.08009867e-01f, -2.01993555e-01f, 1.53865814e-01f, -1.36203110e-01f, 6.43070117e-02f,
  -1.12199761e-01f, -2.74503440e-01f, 1.17330968e-01f, -3.66595209e-01f, 3.81652936e-02f, 6.87751696e-02f, 8.20580199e-02f, 2.14868069e-01f, 2.75672078e-02f, 1.41069919e-01f,
  -1.07333876e-01f, -1.03179514e-01f, 4.60664928e-02f, -1.01210438e-01f, -4.62369621e-02f, 4.12890203e-02f, 8.06635395e-02f, 2.03026146e-01f, 1.11514315e-01f, -1.47580095e-02f,
  8.63867551e-02f, -7.01714605e-02f, -1.19807892e-01f, 4.63746935e-02f, -3.55840959e-02f, -4.51913290e-02f, -3.97189371e-02f, -4.98847626e-02f, -3.98440892e-03f, 1.17514171e-02f,
  2.03150921e-02f, -4.49801385e-02f, -6.69882670e-02f, 7.65266642e-02f, 6.63115680e-02f, -5.23464493e-02f, 2.64452845e-02f, 1.95424363e-01f, -1.10456115e-02f, -1.76513996e-02f,
  -4.79597524e-02f, -4.87986729e-02f, -3.13764513e-02f, -1.46638099e-02f, -7.85039514e-02f, 8.43924563e-03f, 4.02781516e-02f, -3.43457833e-02f, 6.07475415e-02f, -1.76701769e-02f,
  -6.68362305e-02f, 5.55659123e-02f, -1.02919094e-01f, 5.11668026e-02f, -5.96763641e-02f, -2.01874934e-02f, 1.70213938e-01f, 5.89733124e-02f, 3.29351872e-02f, -9.30217188e-03f,
  3.13483551e-02f, -2.39027925e-02f, 6.21621050e-02f, 3.84049565e-02f, -6.55730069e-02f, 3.93953212e-02f, -4.38935161e-02f, 6.70567155e-02f, -3.07214702e-03f, 6.95089921e-02f,
  -6.01081699e-02f, -1.13521643e-01f, -2.75421012e-02f, 1.80627708e-03f, 5.53808846e-02f, -4.03348468e-02f, -1.99817177e-02f, -1.12510756e-01f, 3.36857289e-02f, -8.99685100e-02f,
  -3.88888456e-02f, 1.14245750e-01f, -6.22921586e-02f, 6.70397878e-02f, -1.12087261e-02f, -2.29537729e-02f, 4.41580862e-02f, 2.78239120e-02f, 4.61225137e-02f, -2.85239350e-02f,
  6.50457591e-02f, 9.63671729e-02f, -4.32161614e-02f, -9.57014784e-03f, -3.72320898e-02f, 7.32574537e-02f, 1.86687447e-02f, -5.21776676e-02f, 8.23237225e-02f, 3.46001796e-02f,
  -4.27069008e-01f, -7.91293606e-02f, -1.68248758e-01f, -1.87440738e-01f, 2.46086076e-01f, -2.81470492e-02f, 4.55920175e-02f, -8.07961449e-03f, -8.72259066e-02f, 8.61523524e-02f,
  1.75922051e-01f, -2.81830113e-02f, 8.60897526e-02f, -8.86199921e-02f, -3.36004078e-01f, -1.67313054e-01f, -4.26032513e-01f, -1.41402006e-01f, -7.46340007e-02f, -6.12026751e-02f,
  -1.14260927e-01f, 8.57552961e-02f, -2.52541989e-01f, 2.10952356e-01f, 8.67129490e-02f, 1.13940783e-01f, 6.18746504e-02f, 4.23316121e-01f, -3.16140912e-02f, 2.21950993e-01f,
  -5.86831756e-02f, 1.69591829e-01f, -7.33032376e-02f, 1.56315900e-02f, -8.44760984e-02f, 4.81709316e-02f, 2.14050412e-02f, 1.19692519e-01f, 5.50722964e-02f, -4.58937176e-02f,
  3.61584709e-03f, 8.86517167e-02f, 3.41971740e-02f, 8.94380808e-02f, 5.54240830e-02f, -1.86944492e-02f, 6.30153418e-02f, -8.61357227e-02f, -2.74081212e-02f, -4.86878157e-02f,
  -2.64842976e-02f, -9.02338773e-02f, -2.79475432e-02f, -2.81911343e-02f, 3.03653181e-02f, 5.60169779e-02f, -1.68554097e-01f, 2.82355826e-02f, -4.45432179e-02f, -2.97465529e-02f,
  1.56810414e-02f, 5.98420501e-02f, 2.93800943e-02f, -6.77100569e-02f, 2.07327008e-02f, 1.51267797e-02f, -7.61215016e-02f, 1.57573577e-02f, 5.25986180e-02f, -5.42661548e-02f,
  4.47044102e-03f, 3.46726440e-02f, 2.46269461e-02f, -8.14518332e-02f, 2.96016894e-02f, -7.32236281e-02f, -2.37287693e-02f, 7.33200787e-03f, -6.33546785e-02f, -5.49897477e-02f,
  1.34469848e-02f, 1.47559093e-02f, 3.61533165e-02f, -3.08504291e-02f, -3.07302754e-02f, 1.13713904e-03f, 1.46117872e-02f, -5.81351966e-02f, -6.57881722e-02f, 1.01445101e-01f,
  -6.67926073e-02f, 8.31316710e-02f, 7.54966140e-02f, 5.05219139e-02f, -1.77442115e-02f, -1.43989455e-02f, 1.39972568e-03f, -4.96168956e-02f, -4.94144857e-02f, -1.24519970e-02f,
  -1.02185002e-02f, 2.73271613e-02f, -4.66832519e-02f, -1.85914468e-02f, -1.68159921e-02f, -1.06006600e-01f, 4.42177020e-02f, -5.88964252e-03f, -1.24121569e-01f, -4.53327736e-03f,
  -1.44606195e-02f, 1.24756537e-01f, 7.19932467e-02f, -1.64575949e-02f, -1.15120290e-02f, -5.78035600e-03f, -5.97034134e-02f, 6.75570369e-02f, 1.05006143e-01f, 1.81433652e-02f,
  -1.22832261e-01f, -2.69850641e-01f, -2.58039713e-01f, 8.28086361e-02f, 3.91389787e-01f, -2.40693279e-02f, 8.07955489e-02f, 1.64506331e-01f, 1.20570652e-01f, 8.41859914e-03f,
  -7.02418089e-02f, -3.96329999e-01f, -2.48913124e-01f, -2.23852485e-01f, -3.15681159e-01f, -4.04293418e-01f, -1.79933652e-01f, -2.00970873e-01f, -7.80439451e-02f, -9.62045044e-02f,
  4.34829155e-03f, 1.87746376e-01f, -1.45080596e-01f, 3.13397735e-01f, 1.26074851e-01f, 1.91076025e-01f, 1.06705129e-01f, 1.96805060e-01f, 3.90418097e-02f, 4.13180888e-02f,
  6.19862154e-02f, -8.45550373e-02f, 4.52734642e-02f, 4.11202721e-02f, 2.08675973e-02f, 9.79915261e-03f, -1.20235672e-02f, -7.84465447e-02f, 6.20452091e-02f, 1.04263925e-03f,
  -5.87268546e-02f, 5.49864843e-02f, -8.35568532e-02f, -1.09260269e-02f, 1.69166759e-01f, 1.91910993e-02f, -4.07497622e-02f, 7.23715127e-03f, 2.77296565e-02f, -2.05240592e-01f,
  -1.53028026e-01f, -1.59800202e-01f, -6.87775761e-03f, -6.15566336e-02f, -5.04863262e-02f, -1.65976770e-02f, -1.03514222e-02f, -1.07426852e-01f, -7.03464448e-02f, 6.92981156e-03f,
  -2.07233075e-02f, 3.90308313e-02f, -6.62449598e-02f, 5.91615625e-02f, -1.92938969e-02f, 7.01961219e-02f, 8.78008753e-02f, -6.89688465e-03f, 7.28668422e-02f, 3.18120196e-02f,
  1.03017375e-01f, 4.71474864e-02f, 3.06521337e-02f, 1.73266307e-02f, -7.76730180e-02f, 8.38591903e-02f, 4.92550805e-02f, -1.49134532e-01f, 5.35756443e-03f, -5.67027442e-02f,
  8.97582397e-02f, 6.41105464e-03f, -5.17383441e-02f, 3.52597870e-02f, 5.96639775e-02f, -4.35961150e-02f, -3.60883563e-03f, -4.11689095e-02f, 2.13492308e-02f, -2.80250944e-02f,
  -5.17954677e-02f, -1.76227942e-01f, 5.17853675e-03f, 5.49352355e-02f, 5.45226708e-02f, 2.46888734e-02f, 2.36183852e-02f, 2.50807311e-02f, 7.71264806e-02f, -3.35530154e-02f,
  5.64371534e-02f, 7.54908025e-02f, 2.81534716e-02f, -5.24201393e-02f, 5.00733592e-02f, -5.03116334e-03f, -4.95167375e-02f, 1.26519933e-01f, 1.28087938e-01f, -2.53491160e-02f,
  5.04474901e-02f, -6.83721155e-02f, 1.20356880e-01f, 9.95557234e-02f, 1.65934749e-02f, -1.03383360e-03f, -1.29039809e-02f, 3.71566750e-02f, -2.86908429e-02f, -3.20105702e-02f,
  2.70215303e-01f, -2.59886533e-02f, -1.23619281e-01f, -2.36928523e-01f, 6.08796217e-02f, 3.84162664e-01f, 2.65982509e-01f, -9.16127786e-02f, -1.24179780e-01f, 4.35695834e-02f,
  -1.30928156e-03f, 4.26113140e-03f, 1.25254005e-01f, -8.39913338e-02f, 1.78361416e-01f, 7.57552087e-02f, 4.47341651e-02f, 1.09547399e-01f, -1.18759528e-01f, 6.22196123e-02f,
  -3.97597253e-02f, 1.67845219e-01f, -1.61517173e-01f, -8.87559205e-02f, 5.23414277e-02f, -1.75833836e-01f, -8.63137692e-02f, 3.74152847e-02f, -1.54483065e-01f, 4.14282046e-02f,
  3.58002596e-02f, 1.54540176e-02f, -4.94998693e-02f, -1.42998630e-02f, 6.22333214e-02f, 8.13185126e-02f, 9.25425738e-02f, 1.36875868e-01f, -6.39439225e-02f, 1.68618318e-02f,
  8.15775469e-02f, -2.45622117e-02f, 4.45940681e-02f, -6.84772804e-02f, -6.34962646e-03f, -8.94104168e-02f, -1.07353881e-01f, -3.41547653e-02f, -1.00268379e-01f, 3.00460141e-02f,
  -4.40262854e-02f, -3.00409440e-02f, -7.20990896e-02f, -3.18941139e-02f, -6.74278587e-02f, -8.83372352e-02f, 3.09727713e-03f, 3.43572907e-02f, -7.65117910e-03f, 7.42925182e-02f,
  3.34210284e-02f, 1.08168483e-01f, 7.30871111e-02f, -2.19515730e-02f, 5.26337922e-02f, -5.28488904e-02f, 3.77243534e-02f, 1.62389521e-02f, -5.47428103e-03f, -8.81750882e-03f,
  -3.70980315e-02f, 1.79693140e-02f, 2.56073624e-02f, -2.52347849e-02f, 7.62200728e-02f, -6.99833129e-03f, 6.63084984e-02f, -5.95735246e-03f, -5.22883027e-04f, -8.75222031e-03f,
  -8.91852453e-02f, 1.71231091e-04f, 8.50960705e-03f, -6.27171174e-02f, 8.85140337e-03f, -2.10543498e-02f, -3.65150394e-04f, -1.63367391e-02f, -8.54294151e-02f, 8.85632187e-02f,
  9.65811089e-02f, 3.22227687e-01f, -6.63944557e-02f, -3.09131220e-02f, -2.86746081e-02f, 7.71290213e-02f, 5.24698533e-02f, 3.93421613e-02f, -2.69520096e-02f, 1.29186645e-01f,
  1.36511950e-02f, -4.57074009e-02f, 6.84196129e-02f, -5.48508056e-02f, -7.61247054e-02f, -1.45709971e-02f, 6.46170676e-02f, -4.51346301e-02f, 2.54342761e-02f, -3.91331017e-02f,
  -7.99746513e-02f, 6.98245391e-02f, 4.36146818e-02f, 1.50115108e-02f, -3.70258838e-02f, 4.70768102e-02f, 6.58779815e-02f, -5.70858121e-02f, 7.60598034e-02f, 3.33067924e-02f,
  -2.38517493e-01f, 3.98596823e-01f, -4.04316902e-01f, 7.41887316e-02f, 1.21207967e-01f, -3.15797687e-01f, -1.04453072e-01f, 1.49188921e-01f, 1.00671232e-01f, 3.45628947e-01f,
  5.12170732e-01f, 9.24751684e-02f, 3.33340138e-01f, 4.43832844e-01f, -1.81023329e-01f, 2.02509671e-01f, -5.95050789e-02f, -7.43782967e-02f, 3.04309763e-02f, 1.32651955e-01f,
  -1.20576106e-01f, 4.74783838e-01f, -3.07599176e-02f, 1.98524013e-01f, 1.13473445e-01f, -1.31390497e-01f, 1.36296004e-01f, 4.73041013e-02f, 5.94336400e-03f, 6.60508871e-02f,
  6.76466152e-02f, 3.07933003e-01f, -8.56716707e-02f, -1.29349068e-01f, -1.33387893e-01f, -1.92675427e-01f, -1.90720052e-01f, 1.66757759e-02f, 1.62003879e-02f, 5.05837798e-03f,
  -6.71338663e-02f, 5.76162226e-02f, -3.61896306e-02f, 4.60375138e-02f, -1.28122764e-02f, -6.78029284e-02f, 5.13835549e-02f, -4.98651192e-02f, 4.25778255e-02f, 1.18065509e-03f,
  4.76193018e-02f, -6.15255609e-02f, -4.98547517e-02f, 1.49575397e-02f, 2.53113117e-02f, 1.04041375e-01f, -1.26510203e-01f, -9.68704149e-02f, -6.70515671e-02f, -6.80845976e-02f,
  -1.52907735e-02f, -1.09214513e-02f, 2.37815510e-02f, 7.29961693e-02f, 5.33984005e-02f, -3.27543654e-02f, 8.56578201e-02f, -4.97313291e-02f, -6.38159066e-02f, 3.40815187e-02f,
  -4.62867022e-02f, -2.13398673e-02f, 5.48257716e-02f, -3.62486951e-02f, -1.76249035e-02f, 2.93283518e-02f, -2.60213744e-02f, 5.60407192e-02f, -1.19362354e-01f, -2.76999362e-02f,
  9.06568468e-02f, 1.82957910e-02f, -3.83434654e-03f, -8.26754570e-02f, -6.67437911e-03f, 6.23596050e-02f, 1.94953512e-02f, -2.57443283e-02f, -6.57004258e-03f, -7.76089057e-02f,
  7.39292502e-02f, 1.31160498e-01f, 4.88316864e-02f, 3.16118374e-02f, -2.28051357e-02f, -9.02392119e-02f, -6.05559573e-02f, 7.16220774e-03f, 3.75313312e-02f, 2.44444376e-03f,
  -3.14476974e-02f, -1.35590672e-01f, -9.27346423e-02f, 1.23588666e-02f, -6.13824278e-02f, 7.76897371e-02f, 5.37757576e-02f, -7.14974254e-02f, -2.49982942e-02f, -1.33810390e-03f,
  -1.12401554e-02f, 5.28209023e-02f, -1.76435396e-01f, 3.97875644e-02f, -4.16155718e-02f, 3.53850350e-02f, 7.66611937e-03f, -3.53642292e-02f, 2.66861990e-02f, 5.12547651e-03f,
  -2.21828327e-01f, -3.13575953e-01f, 1.60697877e-01f, 2.34457552e-01f, -5.49396649e-02f, -2.33900622e-01f, -2.15772510e-01f, -1.68698490e-01f, -1.80892274e-01f, -4.48672533e-01f,
  -2.47986928e-01f, 1.89627782e-01f, -3.28124911e-01f, 2.57419944e-01f, 3.50867093e-01f, -1.20252162e-01f, 8.16791430e-02f, 4.58429195e-02f, 6.45017028e-02f, -6.36543781e-02f,
  1.67760804e-01f, 1.56777993e-01f, 3.36903512e-01f, 2.80998558e-01f, 1.77123293e-01f, 2.19363615e-01f, 2.73219615e-01f, 2.30221272e-01f, 3.38456661e-01f, 1.92045644e-01f,
  -7.91318789e-02f, -8.53457972e-02f, 5.09701036e-02f, 2.96578035e-02f, -7.29543865e-02f, -8.14665407e-02f, -1.24821384e-02f, 1.09296709e-01f, 1.29452065e-01f, 1.54196350e-02f,
  -1.07714841e-02f, 1.67242121e-02f, 1.18177995e-01f, 7.99498484e-02f, -8.48938525e-02f, 8.39812085e-02f, 3.13380808e-02f, -6.08785562e-02f, -4.60725725e-02f, -8.26244578e-02f,
  -8.54280889e-02f, -2.52930410e-02f, -4.59139831e-02f, 4.24228385e-02f, 4.88801859e-02f, -7.52870440e-02f, 5.75452708e-02f, 6.33924976e-02f, 3.24626081e-02f, 8.32077414e-02f,
  -1.08310811e-01f, 2.22778856e-03f, 2.76574399e-02f, 9.28434730e-02f, -6.05026819e-02f, -1.64510999e-02f, 3.31156738e-02f, -5.46121271e-04f, 2.73650941e-02f, -7.09147304e-02f,
  -7.33467424e-03f, 4.55190837e-02f, -9.28367954e-03f, -5.57479933e-02f, -2.58313343e-02f, -2.60149892e-02f, 5.95393553e-02f, 5.74567541e-02f, -2.43626814e-02f, 3.24422233e-02f,
  2.83943005e-02f, -2.46681422e-02f, -4.65159304e-02f, 3.89503464e-02f, -8.44193995e-02f, -4.30406630e-02f, 4.60242527e-03f, -1.22786164e-01f, -8.08804389e-03f, 1.29813865e-01f,
  -1.60203770e-01f, -2.90296935e-02f, 4.71455418e-02f, -2.96487920e-02f, 4.73780222e-02f, -2.59837508e-02f, 5.17185107e-02f, -2.64674015e-02f, -6.87286817e-03f, -7.72053492e-04f,
  -8.55154097e-02f, 9.18714982e-03f, -5.19108064e-02f, 2.70677339e-02f, 6.26305342e-02f, -1.02744542e-01f, -2.17326060e-02f, -4.83887680e-02f, 5.74789681e-02f, 3.82423215e-02f,
  -1.69518925e-02f, -4.05798331e-02f, 3.55968811e-03f, 8.03157911e-02f, 1.73238106e-04f, -2.15113014e-02f, -4.60006483e-03f, -4.03656699e-02f, 1.06107667e-01f, 5.21926209e-02f,
  -7.26635516e-01f, -2.59570718e-01f, 2.51292568e-02f, -4.83281687e-02f, -1.63329661e-01f, 2.01338828e-01f, 1.86098054e-01f, -1.41508847e-01f, -2.29738042e-01f, 5.50245456e-02f,
  9.06749591e-02f, -1.49971098e-01f, 8.45518894e-03f, 2.71557808e-01f, 1.93883792e-01f, 1.99749023e-01f, 2.27457508e-01f, 1.65089458e-01f, -2.78521585e-03f, -1.09059677e-01f,
  3.69087118e-03f, 1.61451608e-01f, 2.47118354e-01f, 2.67676413e-02f, 1.03438415e-01f, -4.30837162e-02f, 2.73186490e-02f, 1.69670079e-02f, 2.55488545e-01f, 2.08134934e-01f,
  -1.85546413e-01f, -3.84224355e-01f, -8.74144286e-02f, -1.77092887e-02f, -4.47980165e-02f, -1.88945495e-02f, 2.09385566e-02f, 5.40389866e-02f, -3.57079208e-02f, -1.17290150e-02f,
  -8.98478553e-02f, 2.25364529e-02f, 7.24749127e-03f, -1.59571022e-02f, -1.53148547e-01f, -2.81660799e-02f, -1.21246949e-02f, 2.85791066e-02f, -2.36654971e-02f, 3.77002023e-02f,
  1.00471973e-02f, 4.18772399e-02f, 5.01252078e-02f, 1.55242682e-01f, 2.11848579e-02f, 3.01971901e-02f, 8.30387473e-02f, -3.65885086e-02f, -3.42691280e-02f, -3.66188353e-03f,
  7.05502927e-02f, 8.01730156e-02f, -1.38506010e-01f, 3.63689885e-02f, -1.23352241e-02f, 1.45759523e-01f, 3.31047736e-02f, 3.89047689e-03f, 2.57996265e-02f, -3.50436606e-02f,
  5.68768792e-02f, -2.35362183e-02f, -8.76506343e-02f, 6.72507333e-03f, 3.60595323e-02f, 1.62414201e-02f, 9.22224447e-02f, -4.24565934e-02f, 6.55235909e-03f, 9.07510892e-02f,
  -2.13880297e-02f, -3.96265909e-02f, 6.17077202e-02f, 1.03169633e-02f, 3.50684263e-02f, -2.59627067e-02f, 4.68894280e-03f, -2.43830797e-03f, -6.51457608e-02f, 6.15143217e-04f,
  -5.17621040e-01f, -4.94667172e-01f, -9.49786790e-03f, -2.58608870e-02f, 4.89386357e-02f, -8.20267498e-02f, -1.97426118e-02f, -2.63757389e-02f, -1.41000077e-01f, -7.90260509e-02f,
  -7.45635927e-02f, 1.39536381e-01f, -7.40765706e-02f, 5.36192618e-02f, 3.63409221e-02f, -1.56831276e-02f, -6.97500333e-02f, -3.29464711e-02f, -1.12181768e-01f, -5.74400835e-02f,
  -4.27119173e-02f, -4.60631996e-02f, 1.20641328e-01f, 5.87683469e-02f, 1.53424982e-02f, 5.04711224e-03f, -1.44630551e-01f, -4.08130884e-02f, 2.16266103e-02f, 7.05219582e-02f,
  4.23544586e-01f, 2.15001628e-01f, 2.96704829e-01f, 3.40416998e-01f, 1.15232579e-01f, 1.58794411e-02f, 1.08300813e-01f, 1.54956028e-01f, 5.36088109e-01f, -2.01504901e-01f,
  -1.71630725e-01f, 1.04398593e-01f, -2.86684483e-01f, 1.84555948e-01f, -2.74618208e-01f, -2.16797873e-01f, 1.74931735e-01f, 2.44286191e-02f, 1.83174074e-01f, 8.21587965e-02f,
  1.27954185e-01f, -3.85186285e-01f, -4.41188142e-02f, -2.19230011e-01f, 1.65688440e-01f, 1.80591255e-01f, -4.74086285e-01f, -1.07511044e-01f, -7.11111128e-02f, -1.66003332e-01f,
  1.78679302e-01f, 1.29122630e-01f, 1.69844165e-01f, 1.14537187e-01f, 1.35534868e-01f, 9.86652100e-04f, -6.88448846e-02f, -1.00892127e-01f, 9.04159099e-02f, 6.91520497e-02f,
  4.48427685e-02f, -9.35427472e-02f, 1.77726280e-02f, -7.45452121e-02f, 1.68888509e-01f, 1.17155828e-01f, 1.37220785e-01f, 1.63157538e-01f, 2.13735197e-02f, 2.15903055e-02f,
  1.96258664e-01f, 1.61785021e-01f, 1.06214076e-01f, -3.41525413e-02f, 4.09248695e-02f, 1.12745874e-01f, -3.88892804e-05f, -1.36523833e-02f, 9.79001448e-02f, 5.81091829e-02f,
  -1.12289712e-01f, 1.86555050e-02f, -2.59456541e-02f, 8.27821046e-02f, -2.77344678e-02f, 5.65509424e-02f, 2.61588651e-03f, -8.54075849e-02f, 1.15163542e-01f, -4.19545136e-02f,
  4.38545458e-02f, 5.69949225e-02f, 1.24943249e-01f, 1.28520966e-01f, 1.19378278e-02f, 7.70730600e-02f, -8.66935477e-02f, 1.77027918e-02f, 1.07099459e-01f, 2.27533327e-03f,
  -1.04592673e-01f, -5.88888079e-02f, 2.76041753e-03f, -4.04821802e-03f, -1.23693617e-02f, -2.53343470e-02f, -1.06206611e-02f, 4.26553600e-02f, 4.89203818e-02f, -1.62072673e-01f,
  1.25325909e-02f, -3.23053867e-01f, 7.78771639e-02f, 9.78355706e-02f, 2.00999398e-02f, -4.37145866e-02f, 3.67918238e-02f, 9.81845707e-02f, -7.37601593e-02f, -9.31894854e-02f,
  -3.97205129e-02f, 8.56218860e-02f, -9.20520537e-03f, -2.72074062e-02f, -1.02746129e-01f, -1.68567821e-02f, -5.96474521e-02f, -4.31502907e-04f, -9.56284031e-02f, -9.18914601e-02f,
  -2.74247564e-02f, 6.65079197e-03f, -8.34144448e-05f, 8.49823728e-02f, 4.97679226e-02f, -7.21795410e-02f, -6.87717926e-03f, 3.60125192e-02f, -8.57138559e-02f, -5.24078570e-02f,
  -2.01117411e-01f, 2.32813153e-02f, 8.09917152e-02f, 3.89787182e-02f, -1.06857412e-01f, -3.06115657e-01f, -4.51587379e-01f, -2.45879609e-02f, -9.40906554e-02f, -2.89830089e-01f,
  -1.80739015e-01f, 4.30291444e-02f, 8.22418034e-02f, -4.03471244e-03f, 3.40886563e-01f, 1.84478268e-01f, 1.78581327e-01f, 4.03313376e-02f, 2.47446924e-01f, 1.10988311e-01f,
  1.82446599e-01f, 7.35698268e-02f, 3.58485311e-01f, 2.14180872e-01f, 1.79017950e-02f, 1.50973752e-01f, 2.85322934e-01f, 8.83776024e-02f, -8.16876255e-03f, 3.61630768e-02f,
  1.77402468e-03f, 3.39392573e-02f, 4.56243642e-02f, 2.53705531e-02f, 1.16158187e-01f, -1.30622283e-01f, -4.34949175e-02f, -5.48285209e-02f, 8.43870360e-03f, -4.04925756e-02f,
  2.19570752e-03f, 1.06821731e-01f, 1.85940255e-04f, -6.49346337e-02f, -1.60983086e-01f, 2.82876682e-03f, 8.26420635e-02f, 2.51851566e-02f, 2.65050195e-02f, -3.50341685e-02f,
  1.48956163e-03f, -2.26096120e-02f, -8.39044899e-03f, 1.03100695e-01f, 8.57763514e-02f, -8.38550180e-02f, -4.27183025e-02f, -1.26490090e-02f, -5.98502904e-02f, -5.26920669e-02f,
  6.48794398e-02f, -1.06520893e-03f, -5.91515936e-02f, -3.40316221e-02f, 8.38359520e-02f, -3.51624787e-02f, -4.62692343e-02f, 1.43750906e-02f, 1.47473067e-02f, -1.51742268e-02f,
  -2.67294198e-02f, -9.07269586e-03f, -1.58368163e-02f, -1.03513315e-01f, -4.28657932e-03f, -6.44961968e-02f, 4.12496887e-02f, 2.19316557e-02f, -3.71514645e-04f, -4.00362303e-03f,
  -2.50751469e-02f, -4.57259044e-02f, 2.01705787e-02f, -2.09826254e-03f, -9.67317261e-03f, -1.19553860e-02f, -1.27819767e-02f, 7.40077160e-03f, 6.64650872e-02f, 7.57404268e-02f,
  1.71527058e-01f, 2.32238904e-01f, 3.40171047e-02f, -2.48628147e-02f, 1.37441069e-01f, 1.92054156e-02f, 4.98497076e-02f, 8.12299922e-03f, 6.83645681e-02f, 3.08907945e-02f,
  -2.48656189e-03f, 3.68947126e-02f, 1.36109637e-02f, -5.54442145e-02f, 4.11325209e-02f, 3.88072021e-02f, 2.97008324e-02f, 8.96353647e-02f, 5.21397255e-02f, 1.18078128e-01f,
  5.99433221e-02f, -4.39637117e-02f, 5.03306948e-02f, 7.98072889e-02f, -6.17358871e-02f, -5.60679808e-02f, -7.69791827e-02f, -5.21540530e-02f, 8.33811760e-02f, 2.19834223e-02f,
  -4.44365591e-01f, 1.84464574e-01f, 1.00117281e-01f, -3.55661869e-01f, 7.12182447e-02f, 7.33262077e-02f, -2.44388580e-01f, 3.22114490e-02f, -1.22783169e-01f, -1.75171658e-01f,
  -1.47175029e-01f, -3.54957283e-02f, 1.00270025e-01f, -1.62512779e-01f, 1.04762018e-01f, 1.75866961e-01f, -2.65947729e-01f, -1.41622201e-01f, 9.94060114e-02f, -2.04005927e-01f,
  -7.47954519e-03f, -1.60306230e-01f, 5.12946099e-02f, 1.07080072e-01f, -1.05738357e-01f, -8.09503272e-02f, -4.41810638e-02f, 1.72586635e-01f, -1.22423880e-01f, 5.88968135e-02f,
  -1.34933382e-01f, -3.09600651e-01f, -2.54970342e-01f, -8.06549862e-02f, -8.57736841e-02f, -4.20200080e-02f, -7.52551556e-02f, 3.34693654e-03f, -1.20879501e-01f, -1.57569610e-02f,
  3.82620059e-02f, 9.49382111e-02f, -2.50875186e-02f, 2.77266316e-02f, -2.84582786e-02f, -2.11054785e-03f, 9.19287503e-02f, -2.65728775e-02f, 2.96606347e-02f, 4.87213172e-02f,
  6.16765432e-02f, -5.95860835e-03f, -2.75225043e-02f, 3.22575159e-02f, 1.06655322e-01f, -1.68604124e-02f, -2.82669459e-02f, 4.91134822e-02f, -1.80755872e-02f, -1.28390556e-02f,
  1.91096701e-02f, -7.20671751e-03f, -9.06808861e-03f, -1.09614199e-02f, -3.03409379e-02f, -2.65349895e-02f, -7.61889741e-02f, -3.21491882e-02f, -1.66305564e-02f, -8.54660233e-04f,
  -2.77126189e-02f, 1.53962281e-02f, -4.38169241e-02f, -6.97357729e-02f, -3.37940119e-02f, -1.02757253e-01f, -1.42567437e-02f, -8.30479432e-03f, 2.64326520e-02f, 2.35714503e-02f,
  -9.90856253e-03f, 5.09115458e-02f, 2.20564809e-02f, 2.72232387e-03f, -3.09822112e-02f, 2.78488453e-02f, -1.11416522e-02f, -1.80148371e-02f, -4.71143611e-02f, 1.27707813e-02f,
  -2.52875090e-01f, -2.87762552e-01f, -6.66946843e-02f, -1.13516040e-01f, -6.25375584e-02f, 4.66806255e-03f, 1.48956124e-02f, -1.78163941e-03f, -8.87151435e-02f, -2.81780045e-02f,
  -5.13439476e-02f, -4.34839278e-02f, -2.62488797e-02f, -5.28358808e-03f, 5.47487959e-02f, 1.58415940e-02f, -2.42668111e-02f, -3.64166647e-02f, -6.97441101e-02f, -9.51311365e-03f,
  -2.27883905e-02f, -8.47221911e-02f, 5.63208573e-02f, 1.76876299e-02f, -1.69137567e-02f, -8.09654966e-02f, -1.38387494e-02f, 8.68826061e-02f, -4.92855301e-03f, 3.10842246e-02f,
  3.68925661e-01f, -1.25534594e-01f, -2.46229425e-01f, -1.22153334e-01f, 1.67756900e-01f, 1.68905109e-01f, -1.63773581e-01f, 2.05010504e-01f, -3.48216385e-01f, -2.55071279e-02f,
  1.07546389e-01f, -2.98664272e-01f, -2.43333474e-01f, 1.25316354e-02f, 1.69125292e-02f, -3.10877830e-01f, 2.00802043e-01f, 4.98708971e-02f, 1.83331333e-02f, 2.94000149e-01f,
  1.02483273e-01f, 3.50274861e-01f, 9.82555151e-02f, 3.12546730e-01f, 1.70001492e-01f, 2.34986335e-01f, 3.55272532e-01f, -2.37586014e-02f, 2.13065401e-01f, -4.36310917e-02f,
  -8.83556008e-02f, -7.33226165e-02f, -9.65364873e-02f, -8.16889554e-02f, 1.75850973e-01f, 9.65941027e-02f, 4.16398756e-02f, -1.76708568e-02f, -9.30363499e-03f, -7.48494565e-02f,
  -3.48149277e-02f, -1.66945755e-02f, 8.92344490e-02f, -5.35741672e-02f, 8.31278339e-02f, -5.30461408e-02f, 8.82124156e-03f, -2.89687440e-02f, -1.75833404e-01f, -2.97169071e-02f,
  -6.26861006e-02f, 2.04316694e-02f, 4.49763909e-02f, -8.15188661e-02f, -2.75282636e-02f, 8.23019296e-02f, -3.28429928e-03f, -7.57190511e-02f, 7.13502057e-03f, 2.39000600e-02f,
  1.37163594e-01f, 6.36468604e-02f, 5.08197211e-02f, -7.90763944e-02f, -7.03962594e-02f, -1.58879515e-02f, 2.74996571e-02f, -1.20181339e-02f, -8.66299346e-02f, -3.52644436e-02f,
  1.28482329e-02f, 1.16183804e-02f, -6.54321983e-02f, 2.77177542e-02f, 8.08465183e-02f, 5.26291840e-02f, 4.25999518e-03f, 3.31104454e-03f, -4.15076874e-02f, -2.75897160e-02f,
  -1.04831479e-01f, 9.77626145e-02f, -7.54277334e-02f, 8.85872841e-02f, -3.03516653e-03f, -1.15873688e-03f, 7.53272772e-02f, 7.09371828e-03f, 1.42640469e-03f, 1.30609190e-02f,
  9.44205746e-02f, 2.49293387e-01f, -2.83405762e-02f, -5.48173860e-02f, -1.37670889e-01f, 4.53311168e-02f, -1.10925466e-01f, 6.14059530e-02f, 1.32458098e-02f, 4.12933640e-02f,
  1.76479474e-01f, 6.39944226e-02f, 7.35688359e-02f, 1.67905316e-02f, -1.52589874e-02f, 1.08813688e-01f, 1.22666033e-02f, -6.25437200e-02f, 1.14220986e-02f, 1.52907163e-01f,
  1.50537983e-01f, 1.50002867e-01f, -4.23103496e-02f, -1.95136499e-02f, 8.59840289e-02f, 1.96240731e-02f, 1.28019139e-01f, 1.25908405e-02f, 4.67247330e-02f, -1.08372860e-01f,
  1.27094477e-01f, 1.05711319e-01f, -2.47018158e-01f, -1.04713365e-01f, -1.91000253e-01f, 1.59147009e-01f, 4.62194793e-02f, -1.66338980e-02f, -2.04497069e-01f, 3.30283523e-01f,
  1.19477294e-01f, -1.74099311e-01f, 1.99211001e-01f, 2.09546387e-02f, -1.45706087e-02f, 5.21575473e-02f, 1.74064487e-01f, -1.79898422e-02f, -1.08830325e-01f, 2.69738644e-01f,
  -9.34457406e-03f, 2.09361389e-01f, -3.56400982e-02f, 1.65893912e-01f, 8.93615782e-02f, -4.84037958e-02f, 1.97267964e-01f, -1.38786465e-01f, 3.41206193e-02f, -8.87534469e-02f,
  -9.79446098e-02f, 2.17834283e-02f, -2.16476694e-02f, -2.21020654e-02f, 1.38917968e-01f, 6.15678839e-02f, 3.69781405e-02f, -7.67401308e-02f, -1.23138182e-01f, -3.06580998e-02f,
  6.16833977e-02f, -8.48728865e-02f, 1.80310979e-02f, -1.03229567e-01f, -4.52014059e-02f, -3.47904228e-02f, -7.29362145e-02f, -1.58622675e-02f, -4.47237492e-02f, 3.23423520e-02f,
  -5.04355021e-02f, -6.05336837e-02f, 9.98129621e-02f, -3.01015098e-02f, -4.54902239e-02f, -1.92966536e-02f, 5.00808358e-02f, 1.44501030e-02f, 4.97214757e-02f, -1.16010318e-02f,
  2.65810508e-02f, 9.06891376e-02f, 1.06163897e-01f, -1.37560060e-02f, -9.72468522e-04f, 4.90395427e-02f, 1.15626249e-02f, 1.84606984e-02f, 9.47121764e-04f, 8.85602981e-02f,
  -2.64174845e-02f, -5.34214042e-02f, 4.09944206e-02f, 4.10874300e-02f, 4.70189750e-02f, -3.56948115e-02f, -3.12056057e-02f, -5.26696332e-02f, 4.18242998e-02f, 1.47626512e-02f,
  -4.57411669e-02f, 2.26605833e-02f, -6.46177027e-03f, -2.51644626e-02f, 2.26912275e-03f, -4.19521444e-02f, 6.14178181e-02f, -1.32158138e-02f, -1.96095966e-02f, -1.03458315e-02f,
  1.63941175e-01f, 3.30095500e-01f, 2.86744237e-02f, -1.16309576e-01f, 1.00127449e-02f, 1.33695304e-01f, 2.74415128e-03f, 5.80715621e-03f, 9.22690891e-03f, 8.27879906e-02f,
  6.75717667e-02f, -7.54131190e-03f, 2.09729031e-01f, -7.43362904e-02f, -4.20653448e-02f, 2.07439899e-01f, 9.26595777e-02f, -5.43258712e-02f, 9.13253427e-02f, 4.83663194e-02f,
  5.36446534e-02f, 7.79752061e-02f, 2.51538027e-02f, -3.13527547e-02f, 4.47474159e-02f, 8.40804949e-02f, 7.50225484e-02f, -2.56647225e-02f, -7.23285088e-03f, -2.88896393e-02f,
  8.45404051e-04f, -1.79126307e-01f, 1.57190282e-02f, -4.98087555e-02f, 6.29015863e-02f, 1.05836168e-01f, -1.01224415e-01f, -1.19541615e-01f, -2.84565002e-01f, 5.17418347e-02f,
  -1.28367335e-01f, -4.98680547e-02f, -3.65856767e-01f, -2.22687170e-01f, -2.34903291e-01f, -4.25602764e-01f, 5.18087484e-03f, -4.22076657e-02f, -2.61306316e-01f, 1.90057561e-01f,
  -3.72960530e-02f, -1.35718971e-01f, -7.41590634e-02f, 1.13323294e-01f, 1.44179285e-01f, 3.09973687e-01f, 3.24304909e-01f, 5.06930538e-02f, 3.15111727e-01f, -3.44551094e-02f,
  -2.89070848e-02f, -1.53618991e-01f, -5.10406792e-02f, 1.37254186e-02f, 1.50234863e-01f, 1.55922785e-01f, 1.65386915e-01f, -7.01049864e-02f, -2.23245937e-02f, -4.27887179e-02f,
  8.18686858e-02f, -8.75351951e-03f, -4.73663732e-02f, -1.15223318e-01f, -1.58910435e-02f, -1.92748979e-02f, -2.79292203e-02f, 1.91013329e-02f, -5.13694398e-02f, -6.96829110e-02f,
  -7.72600621e-02f, 8.12842250e-02f, 6.74983934e-02f, 9.54592526e-02f, 4.47918773e-02f, -4.36607152e-02f, 1.17761984e-01f, 1.83869168e-01f, -3.24935913e-02f, 8.57163742e-02f,
  9.15486552e-03f, 1.18085362e-01f, -5.80921285e-02f, -1.64628968e-01f, -8.20720941e-02f, -6.71518520e-02f, -8.07217211e-02f, -2.69624516e-02f, -6.88178167e-02f, -4.19533253e-03f,
  5.32412231e-02f, -2.21700072e-02f, -1.69678092e-01f, 1.30747855e-01f, 7.39723220e-02f, -5.12076728e-02f, 4.29607928e-02f, 8.65002349e-02f, 1.15512550e-01f, -5.73176667e-02f,
  -1.01605743e-01f, 5.08176573e-02f, 5.38237095e-02f, 3.77824679e-02f, -1.06705956e-01f, 9.33783799e-02f, 5.48506938e-02f, 3.03634088e-02f, 1.20378472e-02f, 3.27003002e-02f,
  1.67103156e-01f, 1.51407093e-01f, -3.95440198e-02f, -3.31814550e-02f, -6.14859201e-02f, 1.56382937e-02f, -1.96950376e-01f, 3.34705487e-02f, 6.19573221e-02f, -3.84527259e-02f,
  1.91794306e-01f, 7.46889636e-02f, 1.90294057e-01f, 7.91401602e-03f, 4.15977500e-02f, 9.82721969e-02f, 6.13747835e-02f, 1.06435508e-01f, 3.72560062e-02f, 1.07708320e-01f,
  1.65845916e-01f, 6.78082407e-02f, -9.05444995e-02f, 7.40606710e-02f, 8.95726606e-02f, 1.06453240e-01f, 1.24996118e-02f, 9.97413099e-02f, -3.00387647e-02f, 3.12366392e-02f,
  -5.30437469e-01f, 4.70421582e-01f, 2.82896459e-01f, -1.77440375e-01f, 2.08082110e-01f, 6.77718580e-01f, 1.72353864e-01f, 3.82315576e-01f, 1.68150574e-01f, 1.75087705e-01f,
  1.42336458e-01f, -1.92822859e-01f, 1.13743819e-01f, 1.30187646e-01f, 2.82159925e-01f, 2.68890411e-01f, 2.53201813e-01f, 1.20942108e-01f, 3.73553522e-02f, -5.95751815e-02f,
  -6.81525171e-02f, 2.33993623e-02f, 3.53358202e-02f, 3.95392254e-03f, -5.86478263e-02f, -2.02272877e-01f, -2.46716574e-01f, 2.33608875e-02f, -2.65305750e-02f, 1.22034565e-01f,
  1.39023159e-02f, -2.01991588e-01f, -7.65401870e-02f, 1.01296067e-01f, 3.46177481e-02f, -1.01647452e-01f, -2.77828742e-02f, 8.48713610e-03f, -8.17339122e-02f, 6.65630624e-02f,
  -1.08905889e-01f, 3.64136212e-02f, -6.34684563e-02f, 4.03842516e-02f, 5.21507822e-02f, -9.39789170e-04f, 9.59047526e-02f, 6.41770959e-02f, 1.04941763e-01f, 5.22224382e-02f,
  8.60589743e-02f, 4.02915925e-02f, 5.72308945e-03f, 8.37505907e-02f, 4.58356179e-03f, -4.94259875e-03f, 4.95871641e-02f, 4.81810123e-02f, 2.13551242e-02f, 5.10233045e-02f,
  -6.35746494e-03f, 4.52869385e-02f, 3.29806767e-02f, -3.83800059e-03f, -3.75520401e-02f, -5.59892133e-02f, -2.76835561e-02f, -1.58756804e-02f, -6.62810355e-02f, -1.98909007e-02f,
  -6.65540695e-02f, -4.88455445e-02f, -4.22499143e-03f, -6.23502536e-03f, -6.29143938e-02f, -3.68809700e-02f, -3.24264616e-02f, -6.49463460e-02f, 5.04305633e-03f, -2.02218108e-02f,
  -5.30559458e-02f, 6.02864735e-02f, -1.32162310e-02f, -4.85838652e-02f, 3.46233994e-02f, 1.84910954e-03f, 8.34815111e-03f, 4.39032167e-02f, -4.97040376e-02f, -4.42545228e-02f,
  2.70886600e-01f, 2.25863814e-01f, -2.82050557e-02f, -2.80656293e-02f, -9.96857323e-03f, 5.44637628e-02f, 4.70157489e-02f, 4.73738723e-02f, 1.12689815e-01f, 8.61300435e-03f,
  -4.00357917e-02f, -7.56611302e-02f, -5.50935883e-03f, -2.84860767e-02f, -2.83907373e-02f, 1.56441867e-01f, -9.86968204e-02f, -3.33115049e-02f, 2.77256276e-02f, -4.56812717e-02f,
  -9.45451707e-02f, -2.96235625e-02f, -4.24741358e-02f, -6.15544319e-02f, -5.00569791e-02f, -1.13126174e-01f, -2.91192550e-02f, -1.02104612e-01f, -4.74459352e-03f, 6.38789088e-02f,
  -4.99178112e-01f, 2.77671944e-02f, -3.57218623e-01f, -2.87694126e-01f, -4.60540242e-02f, -2.84072101e-01f, -1.69057801e-01f, -1.20554492e-01f, -9.09330770e-02f, 2.59033352e-01f,
  7.10069239e-02f, -2.76996851e-01f, 2.11204499e-01f, -2.33375743e-01f, -3.40701640e-01f, 3.00523005e-02f, -2.32919276e-01f, -1.26227856e-01f, -7.96024799e-02f, -1.95946395e-01f,
  -2.47126505e-01f, -5.79314418e-02f, -1.79350317e-01f, 7.82742202e-02f, -2.14314222e-01f, -2.77315825e-02f, 2.76794791e-01f, 2.82923412e-03f, -1.25188068e-01f, -5.42058758e-02f,
  -2.18946263e-02f, -6.62384480e-02f, -6.39235452e-02f, -7.09487721e-02f, -8.41239020e-02f, 2.32086610e-02f, 1.26031954e-02f, -3.91913652e-02f, -2.53640451e-02f, -1.13621026e-01f,
  1.38587691e-02f, -1.22245830e-02f, -9.01663825e-02f, 2.73429211e-02f, -1.57330111e-02f, -3.31108160e-02f, -4.44527762e-03f, 7.66577991e-03f, -5.73245622e-02f, -1.04717858e-01f,
  -6.60918206e-02f, -1.00912666e-02f, 2.29274156e-03f, 4.41716835e-02f, -3.38318869e-02f, 3.00986655e-02f, 2.17548069e-02f, 3.24456990e-02f, -3.52642052e-02f, -3.58750708e-02f,
  -7.10212532e-03f, -4.37512733e-02f, -7.01527251e-03f, 3.36857438e-02f, -1.58323776e-02f, 7.00457320e-02f, -2.13315785e-02f, 1.70614421e-02f, 3.73769030e-02f, 2.02698130e-02f,
  1.14179198e-02f, -1.00045122e-01f, 1.40311965e-03f, -8.49878415e-03f, -2.15441007e-02f, -3.26951109e-02f, -3.16319875e-02f, -1.20325834e-02f, -2.74180043e-02f, -2.45191026e-02f,
  3.64647619e-02f, 1.94411613e-02f, 4.98064235e-02f, 5.70305102e-02f, 7.78080570e-03f, 2.77108811e-02f, 7.60790054e-03f, -5.40772378e-02f, 1.36987371e-02f, 8.69441405e-03f,
  3.18632498e-02f, -2.75193211e-02f, 1.63259823e-02f, 3.53063866e-02f, 1.11090941e-02f, 2.48584934e-02f, -2.55038366e-02f, -5.83590493e-02f, -3.67662050e-02f, -3.87704819e-02f,
  4.42913212e-02f, 4.59385104e-02f, 2.30056364e-02f, -1.69122759e-02f, -7.65357260e-03f, 2.72890404e-02f, 6.85650185e-02f, 7.48244151e-02f, 1.63711421e-02f, 5.22994762e-03f,
  3.08458880e-02f, 2.88344845e-02f, 2.80909967e-02f, -1.48240570e-02f, -3.62271219e-02f, 8.40668306e-02f, -2.52751037e-02f, 4.36220318e-02f, 2.48869974e-03f, 4.83348928e-02f,
  -1.28092557e-01f, 2.18788963e-02f, -9.92653072e-02f, 4.98109549e-01f, -3.56615692e-01f, 7.28251180e-04f, 1.48433387e-01f, -1.70217291e-01f, 2.78236777e-01f, 2.97226727e-01f,
  2.25121647e-01f, -3.71038131e-02f, -3.76985483e-02f, 5.25748551e-01f, -3.19130689e-01f, 2.42313817e-01f, 3.66025478e-01f, 3.59134674e-01f, -4.83057201e-02f, 1.04741313e-01f,
  2.21844716e-03f, -1.31001626e-03f, -9.17732045e-02f, -2.46522427e-01f, -1.28174797e-01f, -1.11843109e-01f, -1.88478440e-01f, -3.23782295e-01f, 1.05693720e-01f, -2.33162597e-01f,
  -6.84854537e-02f, 7.60009289e-02f, -1.56762656e-02f, -1.22377194e-01f, 3.34846079e-02f, 3.35398726e-02f, 2.72447988e-02f, -1.08804591e-01f, -3.96293923e-02f, -1.02897524e-03f,
  3.72546054e-02f, -4.06870022e-02f, 5.02856299e-02f, -4.74071726e-02f, -6.91096904e-03f, -2.70357747e-02f, 8.48395452e-02f, 1.05601773e-01f, -9.04831439e-02f, 2.76292698e-03f,
  9.08945873e-02f, 4.40699421e-02f, 1.03093393e-01f, 7.89324194e-03f, -7.59056881e-02f, 5.31377010e-02f, 3.26939709e-02f, -8.75660256e-02f, -9.62980688e-02f, -1.18619129e-02f,
  -2.20476296e-02f, -2.15975922e-02f, 3.86851281e-02f, -1.46500105e-02f, -5.21781817e-02f, -3.29632387e-02f, 7.48812854e-02f, -3.46862227e-02f, -6.36645257e-02f, -1.23591244e-01f,
  -3.31210159e-03f, -5.00168428e-02f, -7.89839923e-02f, 1.31008876e-02f, 1.33837715e-01f, 8.57231766e-02f, -5.10748774e-02f, 9.18327831e-03f, 5.58762159e-03f, 3.26157250e-02f,
  -5.54861538e-02f, 3.04630864e-03f, -3.76641154e-02f, -2.61899307e-02f, -2.26840489e-02f, -1.21734403e-01f, 6.53353557e-02f, 1.00249760e-01f, 7.38167912e-02f, -1.61757618e-01f,
  -2.08543003e-01f, -1.69386402e-01f, -5.93157895e-02f, -7.23209009e-02f, -2.30605025e-02f, 2.14223694e-02f, 7.78485909e-02f, -3.32582518e-02f, -2.14594036e-01f, 4.88996692e-03f,
  2.09319172e-03f, 1.22001059e-01f, -1.33019701e-01f, 2.87750233e-02f, 1.66073442e-02f, -1.01518566e-02f, 1.04029663e-01f, 2.20111217e-02f, -8.49453062e-02f, -9.20569450e-02f,
  1.31770931e-02f, -4.90363629e-04f, -2.75820009e-02f, 3.08931172e-02f, 9.89837945e-02f, -4.64965776e-02f, 2.18085423e-02f, -1.19250985e-02f, -6.80921823e-02f, 5.83983324e-02f,
  -8.00248086e-02f, 3.55902284e-01f, -1.00736879e-01f, -1.62059247e-01f, 2.96311988e-03f, -2.50376880e-01f, -2.26904109e-01f, 1.07155414e-02f, 7.78357908e-02f, 1.14029199e-01f,
  -5.49557246e-02f, 2.49736771e-01f, 1.30275190e-01f, -1.05800286e-01f, -1.37666464e-01f, 1.02372512e-01f, -2.42768720e-01f, -1.05900645e-01f, 5.75135872e-02f, -2.09131733e-01f,
  -7.55653679e-02f, -2.25053981e-01f, -1.36719838e-01f, -1.18219040e-01f, -1.51137084e-01f, 2.70559099e-02f, -1.59080356e-01f, -1.54804848e-02f, -1.23054780e-01f, 6.56139851e-02f,
  -1.04003042e-01f, -2.18451664e-01f, -1.70453563e-02f, -2.90574916e-02f, -1.43023401e-01f, -9.94825140e-02f, -9.95841324e-02f, 4.31587324e-02f, -5.59130386e-02f, -2.80022826e-02f,
  1.12144023e-01f, 8.54922831e-02f, 2.31781788e-02f, 8.84836316e-02f, -2.54016067e-03f, 7.63222128e-02f, 1.62766706e-02f, -1.47534115e-02f, 5.80565743e-02f, 1.14879526e-01f,
  6.85935915e-02f, 9.96293779e-03f, -8.91734809e-02f, -3.95458825e-02f, -2.72845328e-02f, -5.59058785e-02f, -4.20986637e-02f, 1.44065702e-02f, -3.87671813e-02f, -7.71609470e-02f,
  -6.45300448e-02f, -6.29904717e-02f, 1.49845788e-02f, 5.73871564e-03f, 2.55499892e-02f, 4.09115255e-02f, 1.35984616e-02f, 1.06813824e-02f, -1.59545764e-02f, -6.16006041e-03f,
  1.54142175e-02f, 2.94794068e-02f, -1.38505951e-01f, -1.18830495e-01f, 3.26711051e-02f, 8.70890263e-03f, -2.16062348e-02f, 3.27694938e-02f, 1.53772961e-02f, -5.08217365e-02f,
  4.21580672e-03f, -6.48212805e-02f, 3.49793844e-02f, 8.09071679e-03f, -4.58877794e-02f, -2.93393135e-02f, 3.24640819e-03f, 1.45234158e-02f, -8.26924369e-02f, -5.09039834e-02f,
  -2.36271560e-01f, -3.96120697e-01f, 5.00182956e-02f, 3.09330784e-02f, 2.63067707e-02f, -1.77401975e-02f, -3.76866795e-02f, -2.66273059e-02f, -1.30624801e-01f, -8.36344734e-02f,
  -5.74709177e-02f, -1.47322882e-02f, -9.38320383e-02f, 4.07246698e-04f, 7.50738829e-02f, -1.87617559e-02f, 7.64534250e-03f, 8.56805185e-04f, -1.34788260e-01f, 6.58490062e-02f,
  2.14194953e-02f, -9.33532789e-03f, 4.08560820e-02f, -6.09823205e-02f, -7.52677023e-02f, -2.37479135e-02f, -3.06725502e-02f, 8.84884149e-02f, -8.23507532e-02f, 5.85201057e-03f,
  -3.31835359e-01f, -1.54018745e-01f, -3.03793997e-01f, 7.11098537e-02f, 3.51933064e-04f, 2.33993344e-02f, -1.59069955e-01f, 9.19167474e-02f, -3.15608770e-01f, 4.86550182e-02f,
  2.46368110e-01f, -8.31933543e-02f, -6.85524493e-02f, 2.93445498e-01f, 1.13419779e-01f, -2.65485160e-02f, 3.02223086e-01f, 1.47849381e-01f, 2.74034757e-02f, 1.48665428e-01f,
  1.71136394e-01f, 3.50122869e-01f, 1.97068691e-01f, 2.93578982e-01f, 8.34855884e-02f, 1.14250384e-01f, 2.53478199e-01f, 1.52137717e-02f, 4.04291570e-01f, 1.02866665e-01f,
  -3.52408527e-03f, -6.27604797e-02f, -3.30175683e-02f, -8.52830708e-02f, 7.91937262e-02f, 4.73401919e-02f, -2.08582636e-02f, 2.68824697e-02f, -4.48653847e-02f, 6.30336329e-02f,
  -1.18296906e-01f, 3.38480361e-02f, -1.85591839e-02f, -3.88602838e-02f, 1.26672853e-02f, -6.07466884e-02f, -2.93148924e-02f, -8.25681016e-02f, 8.29023495e-03f, -4.74731736e-02f,
  -1.14853472e-01f, -2.45005433e-02f, -2.12443117e-02f, -3.17464881e-02f, -8.60542580e-02f, -4.34643514e-02f, -4.18157279e-02f, -1.58745833e-02f, -5.48969060e-02f, 1.93483233e-02f,
  -6.44038096e-02f, -1.58321951e-02f, 3.38480622e-02f, 4.74405056e-03f, 5.76193891e-02f, 5.22724465e-02f, 4.56950292e-02f, 6.39383122e-02f, 1.78797003e-02f, 4.66628857e-02f,
  4.04730327e-02f, -2.24019419e-02f, 3.55252251e-02f, -7.99265038e-03f, 3.23421843e-02f, -4.48823012e-02f, -7.86539225e-04f, 1.25056542e-02f, -3.61250937e-02f, 6.88901767e-02f,
  -6.29789159e-02f, 2.15281937e-02f, 1.79557275e-04f, -2.92292386e-02f, 3.81135033e-03f, -1.99936125e-02f, 8.75746310e-02f, 1.45212794e-02f, 2.90668476e-02f, 1.76510643e-02f,
  1.08764388e-01f, 9.56672877e-02f, 2.97215898e-02f, 3.37013826e-02f, -9.83939273e-04f, 8.85347947e-02f, -6.61830232e-02f, 2.26292219e-02f, -1.42695466e-02f, 2.15968713e-02f,
  1.58251617e-02f, -1.38331214e-02f, 2.69265212e-02f, 4.20868322e-02f, 1.28479704e-01f, 2.17364589e-03f, 9.35663993e-04f, 1.27638159e-02f, 3.71525213e-02f, 9.90712866e-02f,
  -5.46417385e-02f, -5.40793575e-02f, -1.56937297e-02f, -3.11253257e-02f, 6.65973499e-03f, 1.73555147e-02f, 1.04045579e-02f, -3.30583975e-02f, 3.35217379e-02f, -1.95458662e-02f,
  -3.34347576e-01f, 2.97240376e-01f, 1.22317918e-01f, 3.86998355e-01f, -4.07249987e-01f, -2.39271283e-01f, 1.36583038e-02f, 8.76831729e-03f, 1.70564905e-01f, 1.00486062e-01f,
  -2.21570507e-02f, -1.07908651e-01f, 1.80180505e-01f, 1.56125471e-01f, 2.15182658e-02f, 2.74035215e-01f, 3.54833663e-01f, 1.19365221e-02f, 1.61466300e-01f, 1.00571349e-01f,
  1.94267362e-01f, -6.18389994e-03f, 2.45117813e-01f, -7.36640394e-02f, -9.57452953e-02f, 1.21096395e-01f, 2.33507723e-01f, 3.60068381e-02f, -5.44825010e-02f, -1.49110496e-01f,
  -7.82207623e-02f, 1.47785798e-01f, -5.29720411e-02f, 2.33344287e-02f, 9.96577442e-02f, -1.08879879e-01f, -5.41811921e-02f, -9.28855166e-02f, 2.58320533e-02f, 7.77098089e-02f,
  -1.88196860e-02f, -6.48745149e-02f, -3.16238925e-02f, -5.18347882e-02f, -1.15963578e-01f, -6.10532574e-02f, -5.80469407e-02f, 7.09591899e-03f, 7.35148229e-03f, -7.03581423e-02f,
  3.29505205e-02f, 3.90170924e-02f, 4.99025546e-02f, 1.46612093e-01f, 1.30726874e-01f, 4.25748266e-02f, 2.52081621e-02f, 3.38930711e-02f, 7.28869392e-03f, 5.40268756e-02f,
  -1.29845776e-02f, 4.10934128e-02f, 1.46628683e-02f, -1.15035541e-01f, 4.46355939e-02f, 1.20174959e-01f, -4.31756750e-02f, -5.52112013e-02f, 4.48516533e-02f, -9.47275548e-04f,
  6.40762672e-02f, -1.93641568e-03f, -2.14026403e-02f, -2.98567228e-02f, 2.88637802e-02f, -7.30084081e-04f, -2.84528378e-02f, -1.03760764e-01f, 1.00334853e-01f, -4.23015282e-02f,
  7.93509558e-02f, -1.83617026e-02f, -2.63539329e-02f, -2.09603347e-02f, -7.88895227e-03f, 1.49487164e-02f, 3.49487588e-02f, 2.32446915e-03f, -4.53464733e-03f, 5.23637841e-03f,
  2.35043213e-01f, 3.94588411e-01f, 9.91820320e-02f, -8.97174850e-02f, 5.34957573e-02f, -1.40169278e-01f, -9.38327238e-03f, 6.84624538e-02f, 1.70980915e-01f, -1.89981759e-02f,
  -1.46212112e-02f, 1.84205435e-02f, -3.41498703e-02f, -4.99901660e-02f, -5.14899753e-03f, 1.11303017e-01f, 1.21035181e-01f, 1.24323979e-01f, 9.94447693e-02f, -1.44587737e-03f,
  -4.12463695e-02f, 1.89832114e-02f, 5.41020744e-02f, 5.38369156e-02f, -4.57027592e-02f, 1.14557929e-02f, -8.59357268e-02f, -4.19535227e-02f, -5.21040931e-02f, 1.11827344e-01f,
  6.52953982e-02f, 3.98209915e-02f, 1.85910344e-01f, -8.21920708e-02f, -1.20683774e-01f, -9.28427055e-02f, -3.01282573e-02f, -2.43216425e-01f, -2.13494062e-01f, -7.89914206e-02f,
  -1.58652082e-01f, 3.27861637e-01f, 1.60210118e-01f, -2.17871338e-01f, 1.44238010e-01f, 1.60969421e-01f, -1.74032167e-01f, -4.27784249e-02f, -1.88482091e-01f, -1.15397476e-01f,
  -1.01560779e-01f, -2.60156095e-01f, 7.70346895e-02f, -3.22455466e-01f, -1.21979564e-01f, -7.96473622e-02f, -5.91676980e-02f, 2.31089871e-02f, -1.34130478e-01f, -2.43003890e-02f,
  -1.70693859e-01f, -2.07533374e-01f, 1.17935412e-01f, 2.45081466e-02f, -3.97091433e-02f, 7.17525929e-02f, 1.31772846e-01f, 1.12504594e-01f, -4.70953025e-02f, 1.30166665e-01f,
  1.08322158e-01f, -1.07381575e-01f, -1.14309520e-01f, 5.47609814e-02f, -6.07212484e-02f, -8.93657729e-02f, -3.32011357e-02f, 3.50477378e-04f, 8.08686018e-02f, 2.75242445e-03f,
  9.01567042e-02f, 8.30774605e-02f, -1.00244574e-01f, 8.82164612e-02f, 2.73853764e-02f, -1.65618271e-01f, 1.14065774e-01f, 2.11887568e-01f, 1.00755095e-01f, -7.93167800e-02f,
  -1.38677182e-02f, 2.10466385e-02f, 1.09645344e-01f, -3.45119014e-02f, -7.97015131e-02f, -8.70246291e-02f, 2.97566503e-02f, 1.09520350e-02f, 5.09260269e-03f, -4.78281230e-02f,
  -1.49870962e-02f, 1.34645849e-01f, -3.26654613e-02f, 1.49116712e-02f, -3.74101512e-02f, 3.49942483e-02f, 4.51574614e-03f, -6.01323182e-03f, -4.38725166e-02f, -7.31678456e-02f,
  -9.39743668e-02f, -9.63229463e-02f, -7.24233910e-02f, 8.34318623e-02f, 3.89461741e-02f, 4.89381962e-02f, -2.74969656e-02f, 8.29798579e-02f, -1.15802940e-02f, 2.45844126e-02f,
  -2.38938108e-01f, -2.45071739e-01f, -4.49298732e-02f, -3.09429434e-03f, 3.90399694e-02f, 3.42213660e-02f, -2.94370092e-02f, -5.23700798e-03f, -1.91061888e-02f, -2.62816083e-02f,
  -8.26490000e-02f, 1.13126196e-01f, -5.51675223e-02f, 3.96928526e-02f, -3.66427228e-02f, -5.92067055e-02f, -1.53926471e-02f, -2.12021526e-02f, 3.22520994e-02f, -7.64492080e-02f,
  -5.14866188e-02f, 5.23249910e-05f, -2.82120276e-02f, 1.19376667e-02f, 5.08274734e-02f, 7.65106222e-03f, 3.41374166e-02f, 7.58797377e-02f, 6.59709945e-02f, -2.49134609e-03f,
  1.77309848e-02f, -6.03339672e-02f, -1.45428255e-01f, 1.50441885e-01f, 1.24560364e-01f, -3.78600061e-01f, -3.17462273e-02f, 1.34648038e-02f, 2.90989995e-01f, 4.42896150e-02f,
  7.46696293e-02f, -2.12086186e-01f, 7.30138794e-02f, -4.04563583e-02f, -3.62757117e-01f, 8.41188803e-03f, -2.43606314e-01f, -3.40144970e-02f, 1.53999835e-01f, -1.70142010e-01f,
  -4.69748266e-02f, 9.36607346e-02f, -1.61441132e-01f, 4.74082306e-02f, 1.11140534e-01f, 1.10934950e-01f, -7.89691806e-02f, -1.47848378e-03f, -1.04928233e-01f, -8.07758272e-02f,
  -1.49501830e-01f, 2.13096082e-01f, -2.64270548e-02f, 2.78487336e-02f, -1.41867697e-01f, -3.04842703e-02f, -2.06637591e-01f, -1.46052176e-02f, -1.23996595e-02f, 5.75796142e-02f,
  -9.97290984e-02f, 9.05907154e-03f, 8.46091732e-02f, 2.12118670e-01f, 4.88105156e-02f, 8.32265988e-02f, 2.07870919e-03f, -1.00338683e-01f, 5.14586493e-02f, -8.83329883e-02f,
  1.79330306e-03f, -1.86947212e-02f, -1.82390109e-01f, -1.58021599e-02f, -3.66654582e-02f, 7.23176748e-02f, -1.00491665e-01f, -1.27670661e-01f, -7.32857659e-02f, -4.08290476e-02f,
  1.02822758e-01f, -1.39749348e-01f, -6.76941779e-03f, 1.01040408e-01f, 2.44040564e-02f, 4.18954678e-02f, -1.24124829e-02f, -6.25201166e-02f, 5.68662286e-02f, -1.03533685e-01f,
  1.91178024e-02f, -5.60501777e-02f, 1.00603916e-01f, 2.00821310e-02f, 1.94762927e-02f, -1.00419289e-02f, -3.11618093e-02f, 1.11741416e-01f, -2.77081002e-02f, 8.83386005e-03f,
  2.36899033e-02f, -1.51134148e-01f, 6.52168505e-03f, -2.55068075e-02f, -8.78233090e-02f, 4.60310467e-02f, -1.59703400e-02f, 9.72642750e-02f, -4.78709154e-02f, 7.73649942e-03f,
  -4.46894050e-01f, -2.43497729e-01f, -1.00743651e-01f, 4.92718741e-02f, -1.09209500e-01f, -2.12045126e-02f, -1.33164555e-01f, 2.43962239e-02f, -6.11060448e-02f, 4.83611673e-02f,
  -8.10564756e-02f, 2.78705992e-02f, -2.33678296e-02f, 6.96717203e-02f, -6.92541525e-02f, 6.28716052e-02f, -6.88802600e-02f, -4.56211939e-02f, -1.86129019e-01f, -1.44529477e-01f,
  -8.35692585e-02f, 8.19478109e-02f, -1.58364326e-01f, 6.64188191e-02f, -2.64664013e-02f, -8.91519804e-03f, -6.18764907e-02f, 3.68346982e-02f, 4.58301567e-02f, -8.83948803e-02f,
  -8.10989216e-02f, -1.83722340e-02f, -3.50210994e-01f, -1.38456389e-01f, -1.49525687e-01f, -1.36795089e-01f, -2.13235259e-01f, 4.78637852e-02f, 2.32145414e-01f, 2.19145060e-01f,
  -1.49290651e-01f, 1.89606264e-01f, 1.80696771e-01f, -3.27514857e-01f, 2.99761966e-02f, 1.88312083e-01f, -2.15548053e-01f, -8.37840959e-02f, 4.13841456e-02f, 2.15367898e-02f,
  -3.07326075e-02f, -9.69719663e-02f, -2.68145293e-01f, 8.48355070e-02f, -3.38177294e-01f, -1.17219977e-01f, -1.59671679e-01f, -7.83003420e-02f, -3.33650529e-01f, -8.80063176e-02f,
  -1.64995313e-01f, 6.30191043e-02f, -1.92652524e-01f, -1.09222345e-02f, -3.87054086e-02f, -3.33632790e-02f, 2.83241104e-02f, -2.76717711e-02f, -4.13905270e-03f, 1.41494926e-02f,
  1.36133283e-01f, 1.72438249e-01f, 8.00572261e-02f, 3.25146168e-02f, 3.45452949e-02f, -7.00330958e-02f, -3.93940583e-02f, -1.63627997e-01f, -1.32856101e-01f, -8.52971897e-02f,
  -1.41037703e-01f, -3.46506722e-02f, -9.86672938e-02f, 9.02151093e-02f, -1.12617895e-01f, -7.84577876e-02f, 3.86082642e-02f, -9.58503634e-02f, -6.23876555e-03f, -8.31327029e-03f,
  -3.52319069e-02f, -3.31444331e-02f, -3.39944102e-03f, 6.22454174e-02f, 2.13871505e-02f, -3.57226990e-02f, 5.14447950e-02f, 1.30693503e-02f, 5.09474836e-02f, -7.79231042e-02f,
  -2.09774673e-02f, -1.48577373e-02f, 7.85695165e-02f, -3.67589220e-02f, -2.37589777e-02f, 1.13078490e-01f, 4.64390330e-02f, 5.05978949e-02f, 8.44904929e-02f, 9.75217577e-03f,
  -1.36350365e-02f, -7.23100007e-02f, -1.29377274e-02f, -2.49391980e-02f, -1.42035065e-02f, 1.41433194e-01f, 2.78886482e-02f, -8.31103697e-02f, -1.38724572e-03f, -8.18531290e-02f,
  -5.71837537e-02f, 9.18227956e-02f, -1.84314698e-02f, 7.22193345e-02f, 3.49322483e-02f, -9.05377418e-03f, 4.67048511e-02f, 1.40589187e-02f, -1.69638544e-02f, 3.86109687e-02f,
  3.93600315e-02f, 3.44606191e-02f, 9.89958923e-03f, -2.22746264e-02f, 1.64029062e-01f, -3.53535567e-03f, 2.23340783e-02f, 8.34182277e-02f, -4.24351497e-03f, 1.11438725e-02f,
  4.38878452e-03f, 1.68520644e-01f, 1.24629967e-01f, 7.91965798e-02f, 1.83735210e-02f, 6.79448713e-03f, 6.50084838e-02f, -7.05256015e-02f, -5.23081273e-02f, -9.32719652e-03f,
  3.79834294e-01f, -1.87499866e-01f, 3.87774482e-02f, 3.17360461e-01f, 2.78514534e-01f, -1.75284922e-01f, -2.18204726e-02f, 2.10823342e-01f, 2.17143402e-01f, -2.93455958e-01f,
  6.07429519e-02f, -1.58613831e-01f, -3.08179855e-01f, 2.41148740e-01f, 4.18089271e-01f, -1.20853670e-01f, 4.17200208e-01f, -1.77519973e-02f, 1.38368040e-01f, 2.22379595e-01f,
  3.01017702e-01f, 2.95240223e-01f, 2.53858089e-01f, 1.30369589e-01f, 1.33634612e-01f, 1.75726980e-01f, 1.57431155e-01f, -6.88965321e-02f, 3.48419063e-02f, 4.36975397e-02f,
  -1.55491130e-02f, 1.05538480e-01f, 3.72494608e-02f, -9.60179120e-02f, 5.73373102e-02f, -7.70329610e-02f, -4.46922667e-02f, -1.45818349e-02f, 2.52681915e-02f, -7.60778710e-02f,
  -6.19147085e-02f, -2.07930873e-03f, -2.12743618e-02f, -7.31935725e-02f, 9.27755535e-02f, 5.71315475e-02f, -2.80569009e-02f, -3.89395393e-02f, -4.54476569e-03f, -4.41647358e-02f,
  -5.87759726e-02f, -7.85499811e-02f, 5.95528074e-02f, 2.38190964e-02f, 6.77879453e-02f, 6.19325899e-02f, -3.37972045e-02f, -6.67019710e-02f, -5.99048138e-02f, 1.05266057e-01f,
  4.35498469e-02f, -5.14762215e-02f, -5.06935678e-02f, -4.22164463e-02f, 1.17661357e-02f, 6.62885979e-02f, 2.89848763e-02f, -5.95393311e-03f, -3.21899205e-02f, -2.20354013e-02f,
  6.05223961e-02f, 6.32747337e-02f, 2.61945184e-02f, -5.65036684e-02f, 3.32803726e-02f, 7.58762211e-02f, -3.60130444e-02f, -7.98698738e-02f, 4.90092747e-02f, 1.27856610e-02f,
  1.22144930e-02f, 9.25763771e-02f, -8.62533152e-02f, 3.20610479e-02f, 1.82395820e-02f, -1.61225665e-02f, -3.57456841e-02f, -2.28776727e-02f, 6.78675948e-03f, 2.65364666e-02f,
  -2.69787479e-02f, 8.80335346e-02f, 4.63374984e-03f, -1.93683468e-02f, -3.53504382e-02f, 2.93713976e-02f, 8.12493488e-02f, 4.22026776e-02f, 9.29789022e-02f, 7.95085076e-03f,
  7.43572414e-02f, -4.28227969e-02f, -3.69590856e-02f, 8.66054092e-03f, -6.44312501e-02f, 6.13754280e-02f, -1.96866374e-02f, 2.50135381e-02f, 1.08817272e-01f, 3.66032775e-03f,
  -4.01036348e-03f, -4.97233905e-02f, 7.88708553e-02f, 1.02326982e-01f, 1.05433883e-02f, -4.83274832e-02f, 2.38495935e-02f, 1.31519642e-02f, 5.14077628e-03f, 2.99659166e-02f,
  -6.30124062e-02f, -1.65551528e-01f, -4.28907603e-01f, 5.17434590e-02f, -1.25258565e-01f, 1.50108933e-01f, 3.45643699e-01f, -7.64382705e-02f, -1.21611744e-01f, 2.63923585e-01f,
  3.18168849e-01f, -5.60865887e-02f, 1.71714187e-01f, 4.85194236e-01f, 8.82286299e-03f, 2.34396473e-01f, 2.64776468e-01f, 2.62541860e-01f, -1.19692467e-01f, -3.52238044e-02f,
  -1.01789474e-01f, 2.70277709e-01f, 6.92526028e-02f, -1.41891569e-01f, 2.31547579e-02f, -2.20085010e-01f, 1.09743796e-01f, -1.65654570e-01f, 1.40628397e-01f, 9.44823176e-02f,
  1.03962466e-01f, -6.38367832e-02f, 2.88226962e-04f, 5.67523669e-03f, -1.42569523e-02f, 4.25393842e-02f, 2.26823967e-02f, 1.90082006e-02f, 6.83400705e-02f, -5.35088144e-02f,
  8.76459032e-02f, -1.55724129e-02f, 2.19358429e-02f, -6.83926195e-02f, -4.88386713e-02f, -2.28575673e-02f, -6.07497208e-02f, -2.53230426e-02f, -4.65329699e-02f, -1.21106422e-02f,
  -9.25383866e-02f, -4.95174639e-02f, 7.42127979e-03f, -5.88422269e-03f, -4.93000038e-02f, -1.88370571e-02f, 1.56970453e-02f, -9.50094834e-02f, -1.03106037e-01f, -1.26031280e-01f,
  -4.20435816e-02f, -2.40726285e-02f, -5.31298481e-02f, 5.87959997e-02f, -5.54832295e-02f, 4.14386690e-02f, 8.69784951e-02f, 7.01935366e-02f, -4.63409014e-02f, 5.33951595e-02f,
  -2.07780045e-03f, -3.83262597e-02f, 4.44978811e-02f, 2.45837700e-02f, 3.57509851e-02f, -8.15508235e-03f, -9.17862542e-03f, 4.02771346e-02f, 1.71501003e-03f, -5.80346882e-02f,
  7.53494725e-02f, -1.60430931e-02f, 1.56764165e-02f, 1.00099690e-01f, 4.55296226e-02f, -7.14587374e-03f, 8.54521990e-02f, -2.71477215e-02f, 9.87974629e-02f, -6.97806105e-02f,
  7.78053775e-02f, -2.86922038e-01f, 3.29611674e-02f, 4.12613675e-02f, -2.24324707e-02f, -9.14392546e-02f, 1.22630624e-02f, -9.04942974e-02f, 6.53313706e-03f, -9.07737762e-02f,
  -4.61461432e-02f, 2.43031736e-02f, -5.32756597e-02f, 5.90277575e-02f, -1.43641215e-02f, -2.75460146e-02f, 1.15813762e-01f, -1.07501065e-02f, 5.11432625e-02f, -7.60758296e-02f,
  7.55762355e-03f, -1.02372300e-02f, 2.73359455e-02f, -2.95284875e-02f, 2.16449741e-02f, -2.59564398e-03f, -5.48234656e-02f, -5.99082038e-02f, -2.03403309e-02f, -2.10907646e-02f,
  -6.73473328e-02f, 6.29657924e-01f, 4.21388716e-01f, 1.54167920e-01f, -1.20182686e-01f, -4.42563802e-01f, -2.34263718e-01f, 2.50254959e-01f, -1.03069898e-02f, 2.36369416e-01f,
  -6.24696910e-02f, 2.81019419e-01f, 2.73491954e-03f, 7.06103891e-02f, -5.19626737e-01f, -3.10219318e-01f, -1.61500409e-01f, -3.10469363e-02f, -1.04186140e-01f, 7.77656138e-02f,
  -1.26357749e-01f, -2.22027823e-01f, 6.62737340e-02f, 3.13342288e-02f, 1.97131723e-01f, 2.78383970e-01f, -2.56121461e-03f, 7.88675323e-02f, 1.29548356e-01f, -8.63249078e-02f,
  -7.40675628e-02f, 1.84467897e-01f, 2.20769167e-01f, -2.58464999e-02f, -7.74482265e-02f, 2.35584322e-02f, 1.12687044e-01f, -6.23222515e-02f, -1.00542039e-01f, -4.91627008e-02f,
  1.65627375e-02f, -4.67750244e-03f, 1.33291213e-02f, -7.32566416e-02f, 6.51299208e-02f, 9.62462425e-02f, 6.49290308e-02f, 8.77787545e-02f, 9.44470987e-02f, 7.57700950e-02f,
  8.96873549e-02f, 7.48026744e-02f, 6.66003600e-02f, -4.16848361e-02f, 5.57059273e-02f, 3.95213440e-02f, -6.77915886e-02f, 1.06757641e-01f, 3.95743176e-02f, 3.49298865e-02f,
  -2.00040229e-02f, -8.27017725e-02f, 2.09832750e-02f, 6.59516826e-02f, -1.66737344e-02f, 3.61028574e-02f, -2.05396302e-02f, 5.23390528e-03f, -2.90000327e-02f, 2.81224903e-02f,
  -5.06146885e-02f, 4.10088338e-02f, -2.35030185e-02f, -6.66155741e-02f, 2.15086318e-03f, 1.34543860e-02f, -1.65810306e-02f, 1.66172534e-02f, -4.95835654e-02f, 1.96158532e-02f,
  5.46237268e-02f, -1.20584451e-01f, -2.59869825e-02f, -1.09072896e-02f, -8.08184221e-02f, 5.03372820e-03f, 4.88841161e-02f, 4.16806266e-02f, 2.99625043e-02f, -5.55300936e-02f,
  -1.42664894e-01f, 4.36596312e-02f, 3.35082151e-02f, -3.84908989e-02f, 2.14592577e-03f, 6.07493669e-02f, -6.26983587e-03f, 5.17247692e-02f, -3.14576626e-02f, -6.92477152e-02f,
  7.17586353e-02f, 2.22798008e-02f, -2.00322103e-02f, -2.56817918e-02f, -3.56463231e-02f, -1.47480797e-02f, 4.99613024e-03f, -8.92889574e-02f, 5.80722168e-02f, 1.00354627e-01f,
  1.77300587e-01f, -4.01970670e-02f, 4.94747087e-02f, -3.09082922e-02f, 2.31859274e-02f, -4.04952513e-03f, -8.16314248e-04f, 4.13026623e-02f, -3.99615616e-02f, 3.15568298e-02f,
  2.48715758e-01f, -1.50993720e-01f, 3.06661651e-02f, -3.06921095e-01f, 6.49781600e-02f, -1.30831540e-01f, -3.47415030e-01f, -1.73869357e-01f, -3.96183096e-02f, -2.35471517e-01f,
  -1.10964425e-01f, -1.16729453e-01f, 3.84745263e-02f, -1.73393518e-01f, 2.32223049e-01f, 1.88253716e-01f, -1.88151732e-01f, -2.30150685e-01f, 1.54400155e-01f, -2.60894895e-01f,
  -6.36979714e-02f, -2.31618151e-01f, 6.44600317e-02f, -2.47051373e-01f, -2.30814844e-01f, -1.49022311e-01f, -1.44588202e-03f, -1.05327204e-01f, -2.06057027e-01f, -2.19188537e-02f,
  2.50137271e-03f, 1.71637744e-01f, 1.25092581e-01f, 7.76664391e-02f, 3.74408811e-02f, -2.60615963e-02f, -1.07246317e-01f, -3.70719209e-02f, 4.06999290e-02f, -7.33956136e-03f,
  -1.04330279e-01f, 1.91661867e-03f, -4.26592864e-02f, -2.63020899e-02f, -7.41242245e-03f, -3.31741944e-02f, 1.01291068e-01f, 8.77860114e-02f, -1.09502047e-01f, 1.35216475e-01f,
  -3.87138799e-02f, 8.01116824e-02f, 5.21168932e-02f, -5.67558929e-02f, 3.86962071e-02f, -4.32163663e-02f, -2.20794627e-03f, -4.85852957e-02f, -8.79023038e-03f, 2.11379994e-02f,
  -5.32029122e-02f, -6.03839010e-02f, 2.62614768e-02f, 4.89615090e-02f, 1.00335088e-02f, 3.61107737e-02f, -6.05345331e-02f, 6.58416003e-02f, 2.07499824e-02f, -2.29919120e-03f,
  3.53929661e-02f, 3.86895910e-02f, 7.28588775e-02f, -5.32488339e-02f, -3.46110500e-02f, 9.98342931e-02f, 5.36944438e-03f, -3.80811319e-02f, -5.93460500e-02f, 4.54000980e-02f,
  -6.68497160e-02f, -7.44106807e-03f, 6.31307671e-03f, -3.83223630e-02f, -5.35395630e-02f, 6.11487664e-02f, 3.35255750e-02f, 9.11581144e-02f, 1.13495797e-01f, -9.79561731e-02f,
  -7.14616990e-03f, -1.09426782e-01f, -1.84273422e-02f, -4.08307128e-02f, 3.44886221e-02f, 9.38160047e-02f, 2.79558096e-02f, -5.69869615e-02f, -2.09150519e-02f, 1.65642388e-02f,
  -8.64508823e-02f, -1.01542123e-01f, -1.40939113e-02f, 1.26382886e-02f, -1.94498405e-01f, 4.65975180e-02f, -1.39229640e-01f, -1.00751244e-01f, -9.89571661e-02f, 2.60593202e-02f,
  -8.71102735e-02f, 2.18086578e-02f, -4.87179831e-02f, -7.22662136e-02f, -1.91765308e-01f, -3.09977382e-02f, 1.03968745e-02f, -4.51437831e-02f, -8.06511343e-02f, 2.28754128e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.90078580e-01f, 3.28872293e-01f, 3.69544327e-01f, 3.33463550e-01f, 3.26589257e-01f, 1.79716468e-01f, 2.57570416e-01f, 3.46163124e-01f, 2.03120649e-01f, 2.03005955e-01f,
  4.68012989e-01f, 2.56608784e-01f, 1.99294761e-01f, 3.26142311e-01f, 3.46007526e-01f, 1.78065628e-01f, 2.32909247e-01f, 2.92852491e-01f, 2.61956394e-01f, 3.48954290e-01f,
  2.53835082e-01f, 1.91976383e-01f, 3.38024855e-01f, 1.56631470e-01f, 4.23984945e-01f, 2.50723273e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  8.30308124e-02f, -3.92277211e-01f, -1.58247560e-01f, 8.45845938e-02f, -5.96880838e-02f, 2.23206624e-01f, 2.13414012e-03f, 3.25582065e-02f, -1.46004111e-01f, -2.30600357e-01f,
  -5.87355606e-02f, -1.24905653e-01f, 2.82673333e-02f, -1.79945409e-01f, -3.22738618e-01f, -2.62048006e-01f, -5.75312898e-02f, -7.36428648e-02f, 1.34420022e-01f, -1.08500771e-01f,
  -1.72268469e-02f, -1.03669902e-02f, -2.64701813e-01f, 6.60730302e-02f, -8.91333520e-02f, -1.47830531e-01f, -6.58741745e-04f, -2.45431304e-01f, 2.83876415e-02f, -1.66251436e-01f,
  -3.40409249e-01f, 6.34335726e-02f, -5.62902018e-02f, -2.77258009e-01f, 1.36679839e-02f, 3.90374251e-02f, -6.96327537e-02f, -5.25105298e-02f, -1.06448792e-02f, 5.08193567e-04f,
  1.62757607e-03f, -9.14812535e-02f, 7.63662681e-02f, 3.37777450e-03f, -3.72758895e-01f, -5.89059070e-02f, -1.66448280e-01f, 1.15112886e-01f, -2.07756311e-02f, -7.24270716e-02f,
  3.12828086e-02f, 1.97126135e-01f, -2.54476458e-01f, 7.82637149e-02f, 3.57027858e-01f, 3.66413221e-02f, 1.11193784e-01f, -2.90435981e-02f, -1.53014153e-01f, -4.15622294e-01f,
  -3.15080464e-01f, -2.81135947e-01f, 4.02154773e-01f, -2.13876396e-01f, -3.81362617e-01f, -3.08497131e-01f, 1.43788755e-01f, -3.28912973e-01f, -2.45951325e-01f, -1.82731926e-01f,
  2.85190642e-01f, 1.12702183e-01f, -2.87793577e-01f, -3.09033841e-01f, -3.38727981e-02f, 3.87418300e-01f, 7.90927783e-02f, -1.71512887e-01f, -2.51739800e-01f, -2.85689205e-01f,
  3.02473366e-01f, -2.97208011e-01f, -3.64532799e-01f, 2.45116070e-01f, 2.14558676e-01f, -8.49247128e-02f, 3.15410614e-01f, -4.79680486e-02f, -2.98988849e-01f, 7.58534670e-02f,
  9.65015590e-02f, 2.98449278e-01f, -1.65895477e-01f, -1.52286932e-01f, 4.00526747e-02f, 4.37584706e-02f, -3.48248601e-01f, -2.07011238e-01f, 1.56370997e-01f, 2.58625448e-01f,
  2.77411699e-01f, -1.09436467e-01f, -1.25901178e-01f, -3.48875523e-01f, -1.96106285e-01f, -1.47376344e-01f, 2.14930475e-01f, -2.54823864e-01f, 5.94537497e-01f, -1.61262199e-01f,
  -9.07470360e-02f, -1.76319823e-01f, -4.11493927e-01f, 1.81679189e-01f, -1.03449255e-01f, 1.28311783e-01f, 2.18324602e-01f, 6.53761864e-01f, -1.09180868e-01f, 1.72094077e-01f,
  4.36037809e-01f, -1.02051549e-01f, 7.01063573e-02f, -2.91991711e-01f, -5.33227444e-01f, 5.49118876e-01f, -7.45900422e-02f, -1.49811864e-01f, -1.17933206e-01f, 1.97085306e-01f,
  9.48609710e-02f, 1.38804331e-01f, -1.13876961e-01f, -4.24836487e-01f, -1.71451926e-01f, 4.32090536e-02f, 2.18039945e-01f, 8.26114044e-02f, -4.80839722e-02f, 4.04150300e-02f,
  3.06066778e-03f, 1.09129027e-01f, 4.86939251e-02f, -1.42775938e-01f, -2.17547733e-03f, -2.56181788e-02f, 6.01476580e-02f, 1.89518541e-01f, -6.72891960e-02f, 9.31316987e-02f,
  2.93060243e-01f, -2.35375538e-02f, 7.40354434e-02f, -3.37985493e-02f, 7.61266574e-02f, 1.67273149e-01f, 1.45420153e-02f, 1.76866297e-02f, 1.45856440e-02f, -1.94803819e-01f,
  -5.80331497e-02f, -2.92437494e-01f, -6.82841837e-02f, 2.06002682e-01f, 1.66651104e-02f, 4.88401018e-02f, 1.28704935e-01f, -9.81550887e-02f, 1.62658334e-01f, 2.25167036e-01f,
  -4.44004387e-01f, 2.22514480e-01f, -1.69167593e-01f, -2.88363602e-02f, -1.06596537e-01f, -2.48023570e-01f, -1.74106479e-01f, -1.59510970e-01f, -7.82742277e-02f, 2.14675874e-01f,
  2.13224664e-01f, 2.42029548e-01f, -3.13588887e-01f, 2.24798203e-01f, 2.02545732e-01f, -3.81246150e-01f, 4.28648710e-01f, 2.42865786e-01f, -6.25239164e-02f, 3.39119166e-01f,
  -5.09354532e-01f, -3.44420135e-01f, -2.28397459e-01f, -4.68600065e-01f, 9.66404080e-02f, -4.36076313e-01f, 1.21324591e-03f, 4.59737420e-01f, 4.07190800e-01f, 2.21648976e-01f,
  4.52967674e-01f, 4.09298599e-01f, 1.10639721e-01f, -2.68058509e-01f, 4.79755580e-01f, -2.17795357e-01f, -8.39233175e-02f, 4.96599853e-01f, 2.82864511e-01f, 2.36261822e-02f,
  3.80965739e-01f, 3.57657015e-01f, -2.32904125e-02f, -3.55891079e-01f, -4.67868298e-01f, 9.01182834e-03f, 1.78206250e-01f, -2.09428832e-01f, 2.72749245e-01f, 6.50993288e-02f,
  -2.17308670e-01f, -2.93753207e-01f, 2.20100835e-01f, 3.67565632e-01f, 5.50693512e-01f, 1.50489554e-01f, 2.47651428e-01f, -7.02157095e-02f, -7.62748793e-02f, -3.11180741e-01f,
  -3.64813298e-01f, -2.90904343e-01f, -1.84674785e-01f, 3.47469687e-01f, 3.96731943e-01f, -6.91085160e-01f, -2.51614839e-01f, -4.64829683e-01f, -2.38868296e-01f, -1.71158165e-01f,
  5.11523604e-01f, 3.64780247e-01f, -9.45515931e-02f, 3.16153467e-01f, -4.05866146e-01f, -1.27519146e-01f, -2.83033699e-01f, 1.95474505e-01f, -3.54224622e-01f, -3.43135625e-01f,
  -3.21760267e-01f, -3.45273703e-01f, -2.73901299e-02f, 3.04113239e-01f, -3.33088517e-01f, 1.28708571e-01f, 4.35564816e-02f, -1.09624989e-01f, 9.18577611e-02f, -3.20312440e-01f,
  3.68581526e-03f, -3.31068635e-02f, 9.87144485e-02f, -2.79299200e-01f, -1.80039451e-01f, -6.31555468e-02f, -1.50813147e-01f, -7.14034960e-02f, -2.04860017e-01f, 2.38791406e-02f,
  -1.40919453e-02f, 1.14881903e-01f, -4.97739017e-02f, -2.00490788e-01f, -3.44956905e-01f, 1.48521513e-01f, 5.97305000e-02f, -1.59730121e-01f, -3.25643942e-02f, 1.37713134e-01f,
  -2.22407088e-01f, -6.38250560e-02f, -1.72671899e-01f, 5.51235564e-02f, -2.45083645e-01f, 2.28005514e-01f, -1.05376013e-01f, -1.37904361e-01f, 1.15149163e-01f, -4.39036824e-02f,
  -6.21921010e-02f, -3.45113367e-01f, -7.12026283e-02f, -2.34414026e-01f, -6.74597844e-02f, -6.65930957e-02f, 5.32217398e-02f, -2.42664874e-01f, -3.03412396e-02f, -6.57360777e-02f,
  8.97762477e-02f, -3.04028671e-02f, -8.69605318e-03f, 7.05919340e-02f, 8.46929178e-02f, -4.03016806e-02f, 9.45265889e-02f, 1.10423766e-01f, -7.61869252e-02f, -2.46083662e-01f,
  -2.33564779e-01f, -2.47396603e-02f, 1.74097151e-01f, 1.78031586e-02f, 3.59970108e-02f, 2.42625490e-01f, 3.16561878e-01f, 2.67653346e-01f, -1.81621239e-02f, -3.02588165e-01f,
  -1.79144785e-01f, -3.88962448e-01f, 3.72676373e-01f, 4.31549251e-02f, 2.46875152e-01f, 2.56902218e-01f, 1.42245054e-01f, -4.99115288e-02f, -2.11031660e-01f, 1.49453849e-01f,
  -1.64831907e-01f, -2.85275757e-01f, 1.48308352e-01f, 1.47080123e-01f, 6.00456670e-02f, 1.34129241e-01f, -3.19650024e-02f, 1.86051518e-01f, 2.64360100e-01f, 1.46319002e-01f,
  3.39248896e-01f, -7.40429014e-02f, -5.03310822e-02f, -2.02732667e-01f, 2.37054497e-01f, -9.37179178e-02f, -1.56669542e-01f, 6.58492073e-02f, -1.36982009e-01f, -1.38185412e-01f,
  -1.26259595e-01f, -3.84599157e-02f, -1.89836130e-01f, 9.32632089e-02f, -1.16456456e-01f, 1.50705919e-01f, 2.44716749e-01f, 8.72809067e-03f, -2.44628176e-01f, 1.18553691e-01f,
  4.12900448e-01f, -2.92334467e-01f, -5.17218769e-01f, 5.54288208e-01f, 4.56473917e-01f, -1.45066753e-01f, 2.07105651e-02f, -1.32500023e-01f, 2.69680351e-01f, -4.79864329e-01f,
  2.48371333e-01f, -4.26582664e-01f, -1.53468519e-01f, -4.55281138e-02f, -1.16322212e-01f, 4.03016388e-01f, -4.82962608e-01f, -2.28865683e-01f, -6.82129487e-02f, -5.17788231e-02f,
  3.51125479e-01f, 1.27191231e-01f, -2.69935042e-01f, -2.20184565e-01f, 2.87574902e-02f, 1.15394011e-01f, -3.18967193e-01f, -2.16358062e-02f, 1.82496369e-01f, -9.04338658e-02f,
  -1.74054548e-01f, -1.34525988e-02f, -1.51032507e-01f, -1.32525340e-01f, -1.82586238e-02f, -2.10744455e-01f, 8.66116136e-02f, -9.63285472e-03f, 6.88573569e-02f, 7.70622194e-02f,
  -1.50838286e-01f, -1.29020989e-01f, -2.80427396e-01f, 7.30786473e-02f, -3.07335798e-02f, -7.92552307e-02f, 1.73250481e-01f, -6.90763444e-02f, -1.20698929e-01f, -2.91180480e-02f,
  -1.95642486e-01f, -3.55821475e-02f, 2.65816182e-01f, 1.52936295e-01f, -3.45613398e-02f, -1.20644122e-02f, -4.17442694e-02f, 1.08448796e-01f, -2.17563748e-01f, -1.49152339e-01f,
  -9.13450569e-02f, -1.56828269e-01f, -7.89834112e-02f, 1.08778611e-01f, 1.68400239e-02f, -2.52987355e-01f, -3.38757604e-01f, 1.93970334e-02f, 6.72375485e-02f, 5.30983731e-02f,
  -5.08807413e-02f, -3.37017268e-01f, -8.56478289e-02f, -1.73028365e-01f, -1.30302394e-02f, -8.97540525e-02f, 1.13965765e-01f, 2.73538470e-01f, 3.77794653e-01f, -7.47406036e-02f,
  -2.34203339e-01f, -1.82458982e-01f, -3.05636108e-01f, -1.61538437e-01f, -1.64275646e-01f, -1.61704004e-01f, 3.87191534e-01f, 6.29404709e-02f, -6.94816038e-02f, 2.74069190e-01f,
  -8.51231907e-03f, -3.04871500e-01f, -2.21821949e-01f, -9.33069289e-02f, 2.98232973e-01f, -4.51022834e-01f, 1.91225886e-01f, -2.86706705e-02f, -3.27438742e-01f, 3.59565675e-01f,
  3.28746587e-01f, 2.58730054e-01f, -8.26098919e-02f, -1.32496962e-02f, -6.42448962e-02f, -9.27938968e-02f, -6.87470734e-02f, -3.01139623e-01f, -5.71157113e-02f, 1.29329458e-01f,
  8.63296315e-02f, 2.58532286e-01f, -9.62355956e-02f, 2.93609679e-01f, -2.14066043e-01f, 1.33228660e-01f, -2.42383014e-02f, -1.75138731e-02f, -2.54448533e-01f, -1.93347037e-02f,
  -1.06389813e-01f, -2.89125770e-01f, -6.66091442e-02f, -1.31543830e-01f, 9.28742364e-02f, 1.34489208e-01f, -5.95325530e-02f, 6.48295581e-01f, 2.39829794e-01f, -2.03949556e-01f,
  5.68754196e-01f, -2.13351637e-01f, -2.93287396e-01f, -3.81699353e-01f, -3.32021058e-01f, 2.32135028e-01f, -6.01993799e-01f, -2.71385908e-01f, -7.06094921e-01f, -4.77787375e-01f,
  3.71577919e-01f, -8.89539495e-02f, 3.07250053e-01f, -2.97232091e-01f, -1.54555202e-01f, -1.24067567e-01f, 5.04924715e-01f, 2.25264281e-01f, -4.21051458e-02f, 4.52185422e-03f,
  2.93401390e-01f, -2.00923249e-01f, -1.07155405e-01f, -1.22059949e-01f, 2.83129871e-01f, -9.76177901e-02f, 5.59006967e-02f, -2.06927717e-01f, 4.82715368e-02f, 8.93380865e-02f,
  2.01615915e-01f, 8.16716328e-02f, -7.72615373e-02f, 2.26873234e-01f, -3.76591831e-01f, 1.36307329e-01f, 1.58541679e-01f, 2.19087720e-01f, 2.54428148e-01f, 1.23736463e-01f,
  1.56550705e-01f, 1.41349301e-01f, 2.00306609e-01f, -1.41486987e-01f, 1.73840806e-01f, 1.21430129e-01f, -2.09604532e-01f, 2.60080010e-01f, 2.77254909e-01f, 8.51822458e-03f,
  -1.97971776e-01f, -1.44977570e-01f, 9.38372985e-02f, -2.68710285e-01f, 5.51408418e-02f, 2.04006866e-01f, 1.80627450e-01f, 4.14941600e-03f, 1.49810240e-01f, 2.00384259e-01f,
  2.35603034e-01f, 6.56152368e-02f, -4.03661169e-02f, -5.12847640e-02f, -3.45383286e-02f, 1.20325923e-01f, 8.72379541e-02f, 5.42050488e-02f, -2.03587443e-01f, 1.05172344e-01f,
  -1.59060936e-02f, -1.42886760e-02f, 9.19306874e-02f, -4.53916788e-01f, -3.22721094e-01f, 3.30851227e-02f, 3.08727294e-01f, 2.98423797e-01f, -4.09211963e-01f, -2.66097903e-01f,
  1.08426899e-01f, -4.00971472e-01f, 2.95699269e-01f, 1.38497621e-01f, -5.93216270e-02f, -1.98688418e-01f, 4.14415628e-01f, -1.25517026e-01f, -1.49164706e-01f, 8.23067725e-02f,
  1.21641010e-02f, -3.45369458e-01f, -4.06713545e-01f, 1.66466132e-01f, -4.02031988e-01f, -3.42656532e-03f, 3.08266789e-01f, 3.15158755e-01f, -1.73814371e-01f, 8.69249254e-02f,
  -3.25404853e-01f, -1.93256050e-01f, -1.75849959e-01f, -6.71162903e-02f, -3.50815654e-01f, 2.32809052e-01f, 3.97957921e-01f, 3.43244255e-01f, 4.18449223e-01f, -3.46066028e-01f,
  -4.34908837e-01f, 4.01710093e-01f, -1.27393067e-01f, 3.14625710e-01f, 2.21432269e-01f, 4.18928862e-01f, -1.38193548e-01f, 3.42329800e-01f, -1.00777417e-01f, -2.92369843e-01f,
  -5.09401321e-01f, 3.26814920e-01f, -4.65273827e-01f, 2.28352174e-02f, -3.63346428e-01f, -8.52195844e-02f, -2.97443837e-01f, -1.83302518e-02f, -2.68872261e-01f, 1.68007612e-01f,
  3.62946451e-01f, -7.21944682e-03f, 3.63788903e-01f, 5.25356054e-01f, 8.88109356e-02f, -9.98487324e-02f, -3.41208845e-01f, 6.08974278e-01f, -1.43327475e-01f, -5.54089665e-01f,
  9.11048129e-02f, 9.39091668e-02f, -2.41160437e-01f, 3.96998785e-02f, -2.56771564e-01f, -2.91204393e-01f, -1.89837456e-01f, -5.50246000e-01f, -3.44505534e-02f, 2.48323798e-01f,
  -2.27716938e-02f, 4.07738127e-02f, 1.75509259e-01f, -4.38065901e-02f, -5.34966681e-03f, 4.78128567e-02f, 2.55629092e-01f, -1.54724969e-02f, -4.83289128e-04f, 2.10230723e-01f,
  3.09584159e-02f, 3.00352555e-02f, 1.68328881e-01f, -7.54457805e-03f, 1.19466640e-01f, 1.60832569e-01f, 1.06697388e-01f, 2.10063845e-01f, 1.48119107e-01f, 1.05225131e-01f,
  8.14210176e-02f, -8.75067562e-02f, -1.92858577e-01f, 2.46140477e-03f, 1.43511454e-02f, 2.01775178e-01f, -3.23710948e-01f, 1.98916182e-01f, 9.35619622e-02f, 2.08234757e-01f,
  3.03367287e-01f, 1.33373395e-01f, 2.32327312e-01f, 1.26584649e-01f, 3.58177960e-01f, -1.26285434e-01f, -9.32336673e-02f, 3.13342839e-01f, -3.32854874e-03f, -6.40427023e-02f,
  -1.23358123e-01f, -1.59035400e-02f, 2.54433453e-01f, -1.68987766e-01f, 1.63337246e-01f, -7.52680600e-02f, 2.60636002e-01f, 2.45340779e-01f, 1.43147171e-01f, 1.34475306e-01f,
  2.28915825e-01f, -3.36804897e-01f, -1.93343759e-01f, -2.05491886e-01f, -2.78705526e-02f, 2.22179234e-01f, 3.76589298e-01f, -2.47158691e-01f, -3.56449187e-01f, 3.79123241e-01f,
  -4.29722846e-01f, -2.27638438e-01f, 3.10286790e-01f, 3.53695422e-01f, 3.32485974e-01f, 3.58917415e-01f, 6.96168959e-01f, 5.78356504e-01f, -1.56694382e-01f, 6.97105750e-02f,
  -4.28965390e-01f, 2.14887828e-01f, 4.60842431e-01f, -2.50064641e-01f, 2.13933393e-01f, -2.29364529e-01f, -2.84821123e-01f, -3.22933078e-01f, -5.95430881e-02f, -3.65503341e-01f,
  -6.16188496e-02f, -2.25607917e-01f, -2.81195994e-02f, -3.53687316e-01f, 4.14823502e-01f, -1.13048805e-02f, 1.36808589e-01f, 1.39319688e-01f, 3.24884176e-01f, -4.63582277e-01f,
  4.36093479e-01f, -5.17775893e-01f, 1.30298600e-01f, 4.61408719e-02f, 2.66363263e-01f, 2.46417522e-01f, 2.82197237e-01f, -5.30201122e-02f, 1.86869472e-01f, -4.08419311e-01f,
  2.97229379e-01f, -1.53732404e-01f, -8.89398530e-02f, -5.00449501e-02f, -1.91442877e-01f, 2.45291084e-01f, -3.56513083e-01f, -9.17314515e-02f, -5.66285372e-01f, 1.42653316e-01f,
  3.38120013e-02f, -3.70720714e-01f, -4.00006890e-01f, 1.24050163e-01f, -6.43825829e-02f, 4.08285230e-01f, -4.37637925e-01f, 1.22251526e-01f, -1.47315040e-01f, -5.15354335e-01f,
  4.10315335e-01f, -1.11506723e-01f, -3.29033136e-01f, 5.18881202e-01f, -9.10007656e-02f, -2.22665563e-01f, -6.74999774e-01f, -4.47240829e-01f, 1.43220052e-01f, -9.88846049e-02f,
  -1.97597176e-01f, 1.07154630e-01f, 1.98570505e-01f, 9.04002860e-02f, 6.76187500e-03f, 2.16240957e-01f, -2.79172719e-01f, -3.24535929e-02f, 1.69220388e-01f, 4.26996984e-02f,
  1.80436522e-01f, -1.34766415e-01f, -8.41582865e-02f, 2.32677069e-02f, 2.33546682e-02f, -3.38558763e-01f, -1.27860442e-01f, -3.87648761e-01f, 2.49106869e-01f, 1.54475152e-01f,
  2.08499152e-02f, -8.98156986e-02f, 1.91065431e-01f, 5.03712893e-02f, 8.41534585e-02f, -1.10499516e-01f, 1.28117695e-01f, -4.21175092e-01f, -2.90506899e-01f, 8.72459263e-02f,
  1.88992217e-01f, -5.97037710e-02f, -3.88423316e-02f, 1.11172125e-01f, 2.01578751e-01f, -9.16258916e-02f, -9.47425067e-02f, 1.41783923e-01f, 1.38298661e-01f, 9.52270254e-02f,
  5.78515865e-02f, -6.15977049e-02f, 8.17015693e-02f, 2.18746781e-01f, -2.04117641e-01f, -1.30514279e-01f, -5.10360897e-01f, 1.08739473e-01f, 4.63206545e-02f, 2.29087085e-01f,
  4.84353483e-01f, -1.99578941e-01f, 4.09900099e-01f, 1.99099258e-01f, 1.86256737e-01f, 2.68049359e-01f, -2.16531813e-01f, 1.30648762e-01f, 2.85685152e-01f, -2.74442971e-01f,
  -2.24504188e-01f, 1.69647038e-01f, 1.99931964e-01f, 1.99721605e-01f, -2.67173052e-01f, -2.71668304e-02f, 2.06172302e-01f, 6.19006269e-02f, -2.41565511e-01f, 1.50067322e-02f,
  -2.31335804e-01f, -1.07968539e-01f, 4.16198701e-01f, 1.39978454e-01f, -2.39914373e-01f, 3.54040682e-01f, 4.59946871e-01f, 2.62154222e-01f, -2.79784560e-01f, 5.14114380e-01f,
  3.13136399e-01f, 2.48396695e-02f, -8.53528678e-02f, -1.32379636e-01f, -2.04897881e-01f, 8.33190903e-02f, 3.75211954e-01f, 9.80122983e-02f, -2.46506557e-01f, 1.20814584e-01f,
  -2.90977776e-01f, 9.50542092e-02f, 5.30674942e-02f, -3.82250965e-01f, 1.42075479e-01f, 4.09266472e-01f, 1.88899577e-01f, -1.69636562e-01f, 7.63225853e-02f, 4.23407227e-01f,
  -3.39822590e-01f, -2.97656357e-01f, 4.99192953e-01f, -1.75085202e-01f, -1.72650203e-01f, -1.91870704e-01f, -3.62380236e-01f, 6.06324852e-01f, -2.64295369e-01f, -3.76315773e-01f,
  6.36520237e-02f, -8.96808431e-02f, -2.47472957e-01f, -3.30774128e-01f, -1.49222866e-01f, 4.47682709e-01f, -4.27167445e-01f, -4.50102687e-01f, -1.13904878e-01f, -4.52371776e-01f,
  5.05774558e-01f, -9.83807594e-02f, 5.18590748e-01f, -1.70493379e-01f, -3.96542460e-01f, 1.37955353e-01f, -9.46162939e-02f, -1.22608347e-02f, -7.63964579e-02f, -1.63342685e-01f,
  -2.45817319e-01f, -3.31140608e-02f, -5.18254973e-02f, 7.02312915e-03f, 2.81136129e-02f, 1.75763723e-02f, 5.12308553e-02f, -2.64033854e-01f, -3.00563239e-02f, -3.70649584e-02f,
  -3.29648480e-02f, -2.16767922e-01f, -4.24951650e-02f, -1.23871535e-01f, 8.69310796e-02f, -4.57536876e-02f, -5.89631870e-02f, 4.22569849e-02f, -2.35911272e-02f, 7.10788891e-02f,
  1.71709824e-02f, -1.42897695e-01f, 3.35385464e-03f, -1.82119593e-01f, -8.36581662e-02f, -1.11913107e-01f, -6.11985140e-02f, 9.32230428e-02f, -1.30196467e-01f, -1.61807775e-01f,
  -8.44130740e-02f, -1.39577076e-01f, -9.17531922e-02f, -2.62100510e-02f, -2.82972530e-02f, -3.65875326e-02f, -2.56502815e-02f, 3.28749754e-02f, -1.06852189e-01f, -1.84992794e-02f,
  -1.28224865e-01f, -9.25980732e-02f, -8.99175629e-02f, 8.47727805e-02f, 8.20820481e-02f, -5.28673306e-02f, -6.77227378e-02f, 2.77753264e-01f, -1.23386674e-01f, 1.73492700e-01f,
  -1.17291979e-01f, -2.42786333e-01f, -7.26125166e-02f, 2.85594910e-01f, -9.58303511e-02f, 5.62846251e-02f, 2.39599615e-01f, 2.27926508e-01f, 1.18447416e-01f, -7.58738890e-02f,
  -2.02840060e-01f, 2.90408265e-02f, -1.24950312e-01f, 2.86411256e-01f, -2.03289673e-01f, -1.21885747e-01f, 1.14017151e-01f, 5.11975121e-03f, 9.23836529e-02f, -8.70237947e-02f,
  2.98226788e-03f, -2.16632888e-01f, -2.70404547e-01f, -5.67512624e-02f, 3.09351832e-01f, -1.65273532e-01f, 1.16355754e-01f, 3.19011271e-01f, -7.11569563e-02f, -1.61802411e-01f,
  -2.63838619e-01f, 1.96409822e-01f, -2.05216140e-01f, 2.28583723e-01f, 3.31241786e-01f, -1.96624100e-01f, 2.03112036e-01f, -9.65295956e-02f, 4.05580848e-02f, 7.53604993e-02f,
  1.48008078e-01f, -2.25753382e-01f, -1.58812866e-01f, -1.94759130e-01f, -1.84759334e-01f, 1.80108130e-01f, -1.62540838e-01f, 6.87663779e-02f, -1.96237098e-02f, -1.82155877e-01f,
  -2.19719499e-01f, -2.92978082e-02f, -1.59006566e-01f, 7.74585307e-02f, -1.98765218e-01f, -2.82925874e-01f, 3.22405159e-01f, 3.03220570e-01f, -1.79810986e-01f, -8.75489712e-02f,
  -1.17981784e-01f, -3.03034246e-01f, 3.88244838e-01f, -1.17851198e-01f, 3.37144107e-01f, -1.31809741e-01f, -3.15666111e-05f, 3.50971669e-01f, 1.99308991e-01f, 4.74390805e-01f,
  -1.54209033e-01f, -2.05183327e-01f, -2.95943439e-01f, 5.65457225e-01f, 2.88908370e-02f, 3.24017741e-02f, 3.60368863e-02f, -1.05357096e-01f, 4.77188732e-03f, -2.14919262e-02f,
  -3.80269028e-02f, -3.93754952e-02f, 5.02287559e-02f, -2.44238134e-02f, -6.74408972e-02f, 1.93954518e-04f, -1.21336088e-01f, -1.78863257e-02f, -8.54106173e-02f, -6.55033290e-02f,
  3.84053737e-02f, 1.80802315e-01f, 3.06766648e-02f, -2.11871173e-02f, -2.84104735e-01f, -2.72738095e-02f, 5.53698726e-02f, -1.14672035e-01f, -2.38089353e-01f, -1.49509916e-02f,
  -1.99923385e-02f, -4.29375321e-02f, 1.02923056e-02f, -1.21787764e-01f, -4.10941504e-02f, 6.90307543e-02f, -2.28678122e-01f, -2.51787063e-03f, 7.25142509e-02f, -1.29447430e-01f,
  -2.02287942e-01f, 6.71558976e-02f, 2.15461478e-02f, -2.86359023e-02f, -1.54351428e-01f, 7.45419459e-03f, -8.69579241e-02f, -2.10889518e-01f, -5.98054305e-02f, -7.08912015e-02f,
  -4.23947610e-02f, -8.04718733e-02f, 1.29432365e-01f, -7.31718764e-02f, -1.77624926e-01f, -2.27555573e-01f, 2.63855428e-01f, 1.66716412e-01f, -1.52458400e-01f, 7.05622286e-02f,
  1.18010394e-01f, 2.82674819e-01f, -3.63925938e-03f, -2.17745706e-01f, -2.38048688e-01f, -3.30225497e-01f, -3.37282158e-02f, -1.51160106e-01f, -1.27727464e-01f, 4.00539249e-01f,
  -1.33538023e-02f, 4.51887026e-02f, 6.49173558e-02f, -3.27422172e-01f, -8.66205841e-02f, -2.85740495e-01f, 9.94317830e-02f, 2.06626449e-02f, -2.01484919e-01f, -1.15120836e-01f,
  -1.80701524e-01f, 2.60459155e-01f, 1.49099216e-01f, 9.53674242e-02f, 1.36960387e-01f, 1.58651039e-01f, -1.70420066e-01f, -2.64135450e-01f, -2.79300779e-01f, -1.19906582e-01f,
  -1.93251401e-01f, -2.24534124e-01f, -1.89605176e-01f, 2.68266171e-01f, 1.29255489e-01f, -1.86291382e-01f, -2.22882688e-01f, -2.33460873e-01f, -2.99754977e-01f, -1.30287826e-01f,
  -2.23806635e-01f, 1.47641897e-01f, 2.22280696e-01f, 6.43756092e-02f, 1.50607333e-01f, -7.07160830e-02f, -1.22497186e-01f, -1.78234234e-01f, -3.36377710e-01f, -2.50530690e-01f,
  2.39106908e-01f, 3.42406988e-01f, -2.81891346e-01f, -3.39587003e-01f, 4.56638247e-01f, -7.19751269e-02f, 2.17431948e-01f, 1.18100092e-01f, 1.35359690e-02f, -2.60452718e-01f,
  -2.10865319e-01f, -1.04925662e-01f, -1.60326019e-01f, 2.64960557e-01f, 5.76912761e-01f, -1.91102237e-01f, -1.41788408e-01f, -1.70492947e-01f, 3.83068383e-01f, -3.77972901e-01f,
  2.88422078e-01f, -2.03604728e-01f, 6.24778792e-02f, 8.67046788e-02f, -2.27430463e-01f, 2.29849175e-01f, 4.40722853e-02f, 2.08682373e-01f, -1.15158997e-01f, -2.67107096e-02f,
  -2.32593641e-02f, -2.16340244e-01f, 1.88978929e-02f, 2.58882809e-02f, 1.90900132e-01f, 1.44981191e-01f, -9.54400096e-03f, -6.58655763e-02f, -1.43506214e-01f, 2.01624140e-01f,
  -1.00234777e-01f, -1.61354378e-01f, -9.81231704e-02f, 2.60138651e-03f, -1.67435536e-03f, -1.12700939e-01f, -1.16447113e-01f, -2.84492314e-01f, -7.99378455e-02f, 5.79568483e-02f,
  1.55342788e-01f, 2.08918661e-01f, 5.79618141e-02f, 5.07312156e-02f, -3.14647965e-02f, 1.27832934e-01f, -6.67392835e-02f, 2.50451475e-01f, 9.87121537e-02f, -8.43212828e-02f,
  -2.41925307e-02f, -5.29862680e-02f, -1.50234420e-02f, 8.69057849e-02f, 8.27451646e-02f, 1.03115432e-01f, 1.11903153e-01f, -1.31401718e-01f, 2.86907434e-01f, -5.54688741e-03f,
  2.37896949e-01f, 1.50377378e-01f, 5.69931418e-03f, -1.15204014e-01f, -3.73544127e-01f, -1.98317766e-01f, -3.08438390e-01f, -5.52027583e-01f, -3.83299977e-01f, 4.27786499e-01f,
  4.49646354e-01f, 2.94082344e-01f, 2.64543325e-01f, 4.16763693e-01f, -2.59076625e-01f, 3.00357372e-01f, -3.29562873e-01f, 2.77454555e-01f, -4.01819199e-01f, 1.40820235e-01f,
  4.55740802e-02f, 2.41330490e-01f, -1.59466803e-01f, 2.92600304e-01f, -2.03871831e-01f, -6.40186667e-02f, 8.13761428e-02f, 3.12175244e-01f, -2.78626859e-01f, -4.34670389e-01f,
  -2.66685605e-01f, -6.89378679e-02f, -3.28119785e-01f, 2.62810085e-02f, -4.06201839e-01f, 3.11366200e-01f, -1.63603038e-01f, -3.57944369e-01f, 1.07852526e-01f, 3.04893315e-01f,
  8.35163593e-02f, -3.66125166e-01f, -2.27692649e-01f, 3.53820562e-01f, -1.99542940e-01f, -1.71274230e-01f, 2.22666129e-01f, -1.22946650e-01f, -3.93425018e-01f, -1.82152931e-02f,
  3.33155334e-01f, -4.31466401e-01f, 1.23851210e-01f, 2.50307620e-01f, 6.34826541e-01f, 2.03566939e-01f, -4.10093307e-01f, 2.71506429e-01f, -9.38491076e-02f, 1.76048279e-01f,
  2.20181748e-01f, -3.36685091e-01f, -2.53454149e-01f, -2.13727672e-02f, -3.12733829e-01f, -3.04311782e-01f, -1.57357126e-01f, -3.03288311e-01f, -2.50118941e-01f, -5.58701396e-01f,
  -3.92810814e-02f, -2.64146268e-01f, -2.47967735e-01f, 4.71804440e-01f, -3.85206670e-01f, -2.85652041e-01f, -2.26795569e-01f, 1.80913866e-01f, -1.70422524e-01f, 7.13442627e-04f,
  -8.72558802e-02f, -6.76603839e-02f, 8.56818482e-02f, 1.26026809e-01f, -2.27728561e-01f, 2.39567667e-01f, -1.40303411e-02f, 1.41776994e-01f, 1.76556353e-02f, -2.44980790e-02f,
  3.22667770e-02f, 8.84567425e-02f, 1.16094947e-01f, 8.48588869e-02f, -2.29193480e-03f, 1.91596691e-02f, -8.37758631e-02f, 1.78186670e-01f, 8.54294971e-02f, -2.54950911e-01f,
  1.64234295e-01f, 1.21084437e-01f, -1.98564634e-01f, 1.09233811e-01f, 1.26506090e-01f, -2.16869563e-02f, 9.56408381e-02f, 6.25590310e-02f, -9.79684666e-02f, 5.46829626e-02f,
  1.55193090e-01f, 1.60566956e-01f, 5.98687790e-02f, -2.92213392e-02f, 5.92694469e-02f, 3.96102332e-02f, 9.58390981e-02f, -3.44415866e-02f, -1.73470020e-01f, -8.75970498e-02f,
  2.19557546e-02f, 1.50110886e-01f, 2.44247660e-01f, 4.52631488e-02f, 4.67968136e-02f, 4.50914912e-02f, 1.37674093e-01f, -4.63703051e-02f, -3.61168720e-02f, 1.20705284e-01f,
  2.15938333e-02f, 2.88517863e-01f, 2.50503331e-01f, 1.57679498e-01f, -9.21443105e-02f, -4.28128421e-01f, 9.89949405e-02f, -2.57186353e-01f, 2.66251922e-01f, -2.99783915e-01f,
  -2.82437176e-01f, 2.05089748e-01f, -1.54288411e-01f, 1.59898013e-01f, 6.55967370e-02f, -3.28494906e-01f, 2.65194178e-01f, -2.00829223e-01f, -2.03701913e-01f, -3.11875284e-01f,
  1.65274873e-01f, 3.22866738e-01f, 3.34478393e-02f, 2.92155415e-01f, -1.71131402e-01f, -3.49536449e-01f, 1.91873387e-01f, 2.93005377e-01f, -1.18625639e-02f, 3.57748300e-01f,
  1.09145261e-01f, -2.70865530e-01f, 2.67123505e-02f, 1.39396846e-01f, -2.41121158e-01f, 4.93281186e-02f, 3.65744144e-01f, 2.65218139e-01f, -2.18552932e-01f, 1.76180840e-01f,
  -9.97132584e-02f, -2.19256878e-01f, 3.21969360e-01f, 2.18520626e-01f, -2.75865465e-01f, -2.09086925e-01f, 4.12771702e-02f, 6.71276748e-02f, -4.05239046e-01f, 2.97470868e-01f,
  -1.56197861e-01f, 3.08588266e-01f, 1.21293515e-01f, 2.27640405e-01f, 3.78269047e-01f, 6.71839118e-02f, -4.91983145e-01f, -4.38165247e-01f, -3.94824564e-01f, -3.74191552e-01f,
  -3.55038226e-01f, -2.14867964e-01f, 3.44432026e-01f, 2.90979028e-01f, 5.91375232e-01f, -2.47123182e-01f, 3.57337803e-01f, -2.87441909e-01f, -5.84069490e-01f, 1.96688101e-01f,
  -1.21062554e-01f, -2.56909996e-01f, -2.99216896e-01f, -2.77867001e-02f, -4.37148035e-01f, -1.63021713e-01f, 5.07776253e-02f, -3.49507570e-01f, 1.11829698e-01f, 1.42529830e-01f,
  2.11083051e-02f, 1.17628723e-01f, 4.76699602e-03f, 1.36306897e-01f, 7.31217489e-02f, -2.49930173e-01f, 9.74722654e-02f, 7.08684400e-02f, -2.47628555e-01f, 1.07202046e-01f,
  1.20388288e-02f, -9.24286544e-02f, 4.39644605e-02f, -8.59661996e-02f, 1.13165244e-01f, 7.88337365e-02f, 1.27614185e-01f, 1.75059274e-01f, -1.37257293e-01f, -1.10828904e-02f,
  1.38413295e-01f, -1.40925935e-02f, 1.52174979e-01f, 1.23129450e-01f, 1.45872936e-01f, 1.11793958e-01f, 7.16510937e-02f, 1.56026095e-01f, 3.45599763e-02f, 9.24311404e-04f,
  -1.39006361e-01f, -7.90701732e-02f, -1.92873120e-01f, 8.39447305e-02f, -2.14847382e-02f, -1.47772416e-01f, 1.20530918e-01f, 6.56422302e-02f, -2.62378585e-02f, 8.82506371e-02f,
  1.40461907e-01f, 2.91902144e-02f, -1.23290092e-01f, -1.22262180e-01f, 1.39846846e-01f, 9.55839008e-02f, 1.36389866e-01f, -1.39934704e-01f, -7.50694945e-02f, 1.02358088e-01f,
  1.18873082e-01f, -3.20418894e-01f, -2.79708654e-01f, 3.41065168e-01f, 1.70412455e-02f, 1.96523681e-01f, -3.36426675e-01f, -5.97236492e-02f, -6.72132820e-02f, -3.07931989e-01f,
  -6.27536923e-02f, 2.60879278e-01f, 1.70618117e-01f, 1.36435673e-01f, -3.37770104e-01f, 1.48195520e-01f, 1.72782615e-01f, -2.66800039e-02f, -2.16178130e-02f, -3.26851368e-01f,
  1.58553347e-01f, 3.78658660e-02f, -3.37642819e-01f, -9.07317400e-02f, 1.50791720e-01f, -3.56261097e-02f, 5.73101491e-02f, -2.67996937e-01f, -3.75246108e-02f, -3.13456059e-01f,
  1.57409221e-01f, -2.57314771e-01f, -3.17883462e-01f, 3.23462158e-01f, -1.80418983e-01f, -2.01237589e-01f, -3.39778394e-01f, 2.68400520e-01f, -2.11969748e-01f, -2.72039264e-01f,
  3.23381007e-01f, 7.21946284e-02f, 2.82140642e-01f, -2.89302230e-01f, 3.11530203e-01f, 2.33743683e-01f, -2.48463824e-01f, 6.03782246e-04f, -3.57677251e-01f, -3.75315547e-01f,
  3.17834616e-01f, -3.78027499e-01f, -2.64692903e-01f, -2.49777973e-01f, -1.94080859e-01f, -5.03417291e-02f, -7.71923885e-02f, 5.81283689e-01f, -3.22145551e-01f, -2.95526892e-01f,
  -1.45240068e-01f, -2.57230759e-01f, 1.68740734e-01f, -4.62765962e-01f, -4.15484041e-01f, 1.71690539e-01f, 1.34773910e-01f, -2.08185017e-01f, -2.24736139e-01f, 3.17361146e-01f,
  -1.28961857e-02f, -1.99631661e-01f, -4.33372676e-01f, -1.47059903e-01f, 6.39257371e-01f, -2.21351832e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.56222279e-02f, 4.15123813e-02f, -6.67631850e-02f, 2.66307089e-02f, -1.38535844e-02f, 5.34833521e-02f, 6.63101599e-02f, -4.60482500e-02f, 1.23505173e-02f, 4.25721891e-02f,
  -3.74409407e-02f, -1.18232509e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    