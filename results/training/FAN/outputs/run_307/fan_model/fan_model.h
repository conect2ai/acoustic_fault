/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.07404667e-01f, -1.03533253e-01f, 1.34895802e-01f, 3.00631285e-01f, -3.81508246e-02f, -5.92106357e-02f, 8.84137154e-02f, 7.19411820e-02f, 1.54726490e-01f, -1.72824308e-01f,
  1.40430441e-03f, 6.70461804e-02f, -1.57286286e-01f, 1.60733178e-01f, 3.26657236e-01f, -1.15714900e-01f, 1.12197302e-01f, -6.14668168e-02f, 4.12066802e-02f, 7.80193657e-02f,
  1.71898350e-01f, -5.71028590e-02f, 8.25276077e-02f, -7.15280399e-02f, 8.84438753e-02f, 3.15111689e-02f, 3.53643000e-02f, 2.91379187e-02f, -2.20068209e-02f, 9.48144495e-02f,
  3.32786776e-02f, -9.87404361e-02f, 8.60996917e-02f, -7.73159042e-02f, -2.59505957e-02f, -6.20801747e-02f, 6.23288844e-03f, 4.88189375e-03f, 3.56968530e-02f, 1.02048824e-02f,
  -2.68867146e-02f, 7.01146200e-02f, -1.61485299e-02f, -2.31193919e-02f, 5.63901700e-02f, -1.53820440e-02f, 8.85151234e-03f, 3.63435410e-02f, 2.19309870e-02f, 8.13636556e-02f,
  -1.23360530e-02f, 4.50075157e-02f, -2.00270191e-02f, -9.42369625e-02f, 1.53295724e-02f, -3.07870451e-02f, -1.59651637e-02f, -1.16918352e-04f, -1.71931796e-02f, 2.56257541e-02f,
  -4.27103601e-02f, -9.09004919e-03f, 2.84948330e-02f, 6.59743920e-02f, 6.20200336e-02f, -1.43835433e-02f, -1.98177584e-02f, 5.32046556e-02f, 3.91329825e-02f, 2.80710626e-02f,
  6.30778745e-02f, 6.41800985e-02f, 3.69768105e-02f, 2.22574845e-02f, -4.51629758e-02f, -1.41396066e-02f, 3.07895951e-02f, -6.87180459e-02f, 3.17205973e-02f, 2.35894346e-03f,
  2.51885708e-02f, 5.84913529e-02f, -2.60967817e-02f, -5.50100841e-02f, -5.11336178e-02f, -2.45834086e-02f, 4.18832339e-02f, -3.90727520e-02f, -8.33947957e-03f, -9.35309846e-03f,
  -1.05373219e-01f, -6.35837093e-02f, 1.66076180e-02f, 3.42777148e-02f, -5.80461957e-02f, -6.48247777e-03f, 2.77129598e-02f, -5.28944135e-02f, 2.25505922e-02f, -1.21420110e-02f,
  -8.35705176e-02f, -1.30843185e-02f, -7.91067407e-02f, 3.76388729e-02f, 2.32186448e-03f, -4.09033857e-02f, -7.00813681e-02f, 4.37985845e-02f, 3.92086916e-02f, -6.64674938e-02f,
  -3.20448354e-02f, -7.98394531e-02f, -1.68468002e-02f, -3.42239961e-02f, -1.55443829e-02f, -2.81367954e-02f, -3.66030596e-02f, 7.68236397e-03f, 1.29749170e-02f, -2.60472372e-02f,
  1.51437633e-02f, -4.71980065e-01f, -1.37556031e-01f, -3.72767180e-01f, 2.15840012e-01f, -1.70365125e-02f, -4.73720878e-02f, -5.41074648e-02f, -1.70616344e-01f, -1.57311663e-01f,
  1.35469213e-02f, -2.36185387e-01f, -3.52795981e-02f, -3.36252868e-01f, 1.97318956e-01f, -6.94133490e-02f, -2.40193039e-01f, -1.73682496e-01f, 4.54074070e-02f, -1.07113227e-01f,
  1.89896524e-02f, -7.41371959e-02f, -4.46478464e-02f, 3.90866771e-02f, -1.64297670e-02f, 2.04255022e-02f, 8.31243768e-02f, 2.04112783e-01f, -2.93780994e-02f, 8.48606229e-02f,
  -9.64781269e-03f, -1.25606433e-01f, -9.70503539e-02f, 3.99808139e-02f, -4.31970656e-02f, -3.18430476e-02f, 1.03815710e-02f, 1.09244309e-01f, 6.72995970e-02f, 2.68124565e-02f,
  -2.01496258e-02f, 5.52058294e-02f, -1.66967157e-02f, 2.45364029e-02f, 6.62388280e-02f, 2.47781686e-02f, -1.47838183e-02f, 1.76922716e-02f, -1.73144240e-03f, -4.77063656e-03f,
  -1.31040150e-02f, -6.94397837e-02f, -4.37034555e-02f, -7.70140439e-02f, 4.55738865e-02f, -1.68689173e-02f, -8.48116800e-02f, -5.84138092e-03f, -2.59248428e-02f, -1.42016644e-02f,
  8.21588840e-03f, 2.91169975e-02f, 3.18527259e-02f, 2.45369729e-02f, -2.32828241e-02f, 1.62013061e-02f, -6.26637880e-03f, 3.44645679e-02f, 2.92808674e-02f, 4.54247929e-03f,
  -1.87945385e-02f, 1.15043884e-02f, 2.28518881e-02f, -4.79623228e-02f, -7.09922165e-02f, -6.23709522e-03f, 2.61964370e-02f, -4.58561182e-02f, -1.60452724e-03f, 3.30276191e-02f,
  -5.60649857e-02f, 3.60834673e-02f, -1.41578075e-02f, 1.18748117e-02f, -2.42958274e-02f, 2.18268558e-02f, 9.81930457e-03f, -3.25621814e-02f, 1.79446358e-02f, 1.18846791e-02f,
  -5.86593598e-02f, -1.30083516e-01f, 6.93297200e-03f, -1.77176017e-02f, -1.68753527e-02f, 7.80376568e-02f, -2.72019282e-02f, -3.98316011e-02f, -5.22116274e-02f, -3.90995815e-02f,
  -5.05529623e-03f, -1.97172929e-02f, -1.56349670e-02f, 5.77357486e-02f, -1.24107869e-02f, -1.93268564e-02f, -2.61578448e-02f, -2.94421855e-02f, -1.07040638e-02f, -8.40286911e-03f,
  2.42567994e-02f, 4.93304171e-02f, 5.12994863e-02f, 5.61520718e-02f, -2.59083770e-02f, -1.79417839e-03f, 1.86959747e-02f, 1.08346455e-02f, 5.16104773e-02f, -1.48669956e-02f,
  -8.26347172e-02f, 1.21756375e-01f, 9.68089700e-02f, -5.02057234e-03f, -2.00171486e-01f, -1.05274439e-01f, 6.34817332e-02f, -1.19035155e-01f, -1.21357583e-01f, -2.22313181e-02f,
  1.13579854e-01f, -2.73583978e-02f, 2.94769198e-01f, 3.85053153e-03f, 2.30886132e-01f, 2.50133872e-01f, 3.32426317e-02f, 4.82154312e-03f, -1.18626013e-01f, 2.54228972e-02f,
  -4.70236652e-02f, 1.08398035e-01f, 2.18013704e-01f, -1.04014240e-01f, 2.11207266e-03f, -8.41486230e-02f, 1.67629525e-01f, 3.06891520e-02f, -4.75585423e-02f, -3.19046788e-02f,
  -2.90479232e-02f, 3.67862061e-02f, 4.83142808e-02f, -3.49623226e-02f, -2.98401080e-02f, 3.41618657e-02f, -1.48059474e-02f, 3.23047861e-02f, -6.37195334e-02f, 5.08880652e-02f,
  6.78353161e-02f, -1.33594619e-02f, -3.80800962e-02f, 1.15186805e-02f, -7.05650151e-02f, -4.19490896e-02f, -4.29029316e-02f, 1.64360572e-02f, -1.38646485e-02f, 7.87760131e-03f,
  1.02887070e-02f, -5.86595945e-02f, 1.14551680e-02f, -4.00529727e-02f, 1.81163021e-03f, -9.01001692e-02f, -4.11600154e-03f, 9.13715512e-02f, -5.34132458e-02f, -3.87096889e-02f,
  4.28967997e-02f, -3.51351462e-02f, 5.69966547e-02f, -2.75627486e-02f, 6.23960756e-02f, -1.86753292e-02f, -1.37531515e-02f, 9.22761261e-02f, -6.28747344e-02f, -7.58413412e-03f,
  2.11180141e-03f, -4.60210331e-02f, 9.17517487e-03f, -1.41356699e-02f, -1.44459084e-02f, 4.11125608e-02f, 3.97987850e-02f, -8.37311614e-03f, -1.12156374e-02f, -5.08360453e-02f,
  4.63101082e-02f, 1.19564487e-02f, 1.20323487e-02f, -1.75263975e-02f, 1.21150007e-02f, 1.94888655e-02f, 3.42009999e-02f, 2.66119428e-02f, -2.15963908e-02f, 8.28550458e-02f,
  3.67898196e-02f, 1.05527014e-01f, 9.07576829e-03f, -3.20365205e-02f, -2.62953974e-02f, -1.57016851e-02f, -3.15908194e-02f, -3.43152098e-02f, 1.22635886e-02f, 2.51307059e-03f,
  -1.71309840e-02f, -3.51436697e-02f, -3.24261189e-02f, -5.29509485e-02f, -2.90315896e-02f, 1.16004013e-01f, 2.32289266e-02f, -2.14802902e-02f, -1.61513649e-02f, -4.20619100e-02f,
  2.90743541e-02f, -7.89502729e-03f, -1.97022595e-02f, 3.22599597e-02f, -2.96202060e-02f, 7.47474954e-02f, -3.48516293e-02f, -6.22223914e-02f, 4.32729535e-02f, -3.16089243e-02f,
  1.12388596e-01f, -3.12214419e-02f, 2.15799227e-01f, -8.48085955e-02f, 3.18983980e-02f, -7.78137287e-03f, 1.36723761e-02f, 1.92998629e-02f, 9.42580551e-02f, -1.77311838e-01f,
  -2.48539403e-01f, 2.57469684e-01f, -1.53157875e-01f, -9.27525461e-02f, -5.88034540e-02f, -1.83044374e-01f, -1.57066643e-01f, -3.34707275e-02f, -4.15848121e-02f, -3.70936468e-02f,
  1.02270134e-02f, -1.76069856e-01f, -3.63464952e-02f, -1.01595573e-01f, 8.87541845e-02f, 9.54723656e-02f, -1.76902398e-01f, 5.04939780e-02f, 1.69940926e-02f, -4.96786088e-02f,
  2.27894522e-02f, -8.99459049e-03f, 1.65151030e-01f, -2.86343088e-03f, -7.27785286e-03f, 5.86060286e-02f, 5.60745485e-02f, 7.32736140e-02f, -2.15559639e-02f, 8.81811604e-02f,
  -2.13007201e-02f, 8.99963360e-03f, 2.20491905e-02f, -3.58146243e-02f, 1.52964354e-03f, 6.08316669e-03f, 5.33395223e-02f, -4.55314517e-02f, -2.81001069e-02f, 6.48243874e-02f,
  5.95913269e-02f, -8.83479230e-03f, 7.17267618e-02f, 8.69757216e-03f, 8.81785527e-02f, 6.04397692e-02f, 1.01555400e-01f, 7.09537640e-02f, -3.36592039e-03f, -4.19876464e-02f,
  1.23375446e-01f, -3.11865676e-02f, -1.41991712e-02f, -1.67348161e-02f, -5.77454567e-02f, -3.73959765e-02f, -2.01394539e-02f, -2.32514627e-02f, 2.74640787e-02f, -4.78429496e-02f,
  -2.70636585e-02f, 3.58608514e-02f, 2.13984549e-02f, -2.24990882e-02f, -6.10143766e-02f, 1.43989315e-02f, 3.45498882e-02f, -1.44446986e-02f, 1.93162411e-02f, -1.86723843e-02f,
  -5.91863738e-03f, 1.20338742e-02f, -1.43580213e-02f, -2.95693632e-02f, 3.84977907e-02f, 3.02372668e-02f, 6.96683535e-03f, 5.89748397e-02f, 2.46399436e-02f, 7.34308502e-03f,
  -3.23106289e-01f, -2.18506351e-01f, -5.15225269e-02f, -6.82233498e-02f, -9.37290639e-02f, -6.87503908e-03f, -9.10971537e-02f, -3.56534831e-02f, -1.11572921e-01f, -6.30539730e-02f,
  1.73355844e-02f, -3.71205211e-02f, 1.20324474e-02f, 1.58643126e-02f, 2.19177436e-02f, 3.20383497e-02f, -1.06254742e-01f, -7.38603994e-03f, -1.19179906e-02f, -4.90395278e-02f,
  -9.74168479e-02f, 3.23937163e-02f, -2.95604076e-02f, 1.34181809e-02f, 1.79032795e-02f, -3.23303696e-03f, -1.14094624e-02f, 3.48030254e-02f, -2.57665720e-02f, -4.88517098e-02f,
  -1.33868799e-01f, 8.31980556e-02f, 2.36636624e-01f, 4.73215827e-04f, -1.40536666e-01f, 1.27659172e-01f, 4.82091382e-02f, 1.76944453e-02f, 1.70048073e-01f, 9.64287221e-02f,
  -4.53442037e-02f, -5.89889325e-02f, 1.15356401e-01f, -1.44362748e-01f, -2.60533005e-01f, 1.30124569e-01f, -1.43255353e-01f, -2.38672569e-02f, 1.09509841e-01f, -3.04914303e-02f,
  -3.27180699e-02f, -2.63622999e-01f, -3.98709550e-02f, -1.03024274e-01f, -1.46952182e-01f, 6.00560568e-02f, -3.79217565e-01f, 6.39902204e-02f, -1.54685676e-01f, -9.28737745e-02f,
  1.08766504e-01f, 2.13893335e-02f, 3.33219990e-02f, 5.95283248e-02f, -3.04022860e-02f, -9.41341668e-02f, 3.96088464e-03f, 5.49217202e-02f, 3.94779630e-02f, 1.96846407e-02f,
  -1.79566033e-02f, -6.48365915e-03f, -3.41821089e-02f, -7.23593682e-02f, 1.01385899e-02f, 5.18575795e-02f, -3.47387302e-03f, 4.54146229e-02f, 6.08469918e-02f, 3.36496569e-02f,
  1.14682510e-01f, 8.11948627e-03f, -4.02710363e-02f, -7.36735165e-02f, -5.37999384e-02f, -1.94500927e-02f, 2.57532275e-03f, -3.67767480e-03f, -1.71915796e-02f, 1.71913151e-02f,
  -3.14213410e-02f, 8.71709723e-04f, -1.49214026e-02f, -3.14606316e-02f, 8.78940895e-03f, 4.11803089e-02f, -4.28332686e-02f, -5.51072462e-03f, 5.10653853e-02f, -2.20879912e-02f,
  -3.37168165e-02f, -1.12671275e-02f, 3.59822400e-02f, 3.75473462e-02f, -4.42950428e-03f, 2.36143786e-02f, -2.78629493e-02f, 6.66349754e-02f, 6.94550574e-02f, -9.34871286e-03f,
  7.62682222e-03f, -4.46456820e-02f, -1.00756092e-02f, -5.34041179e-03f, 7.26747066e-02f, 4.69727851e-02f, -3.82476151e-02f, 7.38129094e-02f, 6.04709610e-02f, -4.59818505e-02f,
  -7.64574185e-02f, -2.46929109e-01f, 2.06285864e-02f, 3.06043290e-02f, 1.45543739e-02f, -8.76878761e-03f, -9.49872192e-03f, -4.26296145e-02f, 4.08191420e-03f, 1.81763824e-02f,
  -2.74301157e-03f, -9.97505523e-03f, -3.15879956e-02f, 3.54456790e-02f, 5.48203737e-02f, -5.52319810e-02f, -2.63936780e-02f, -3.33457142e-02f, -1.54950097e-01f, -9.62269753e-02f,
  -7.34637454e-02f, 3.43524590e-02f, -4.53363769e-02f, 2.39977539e-02f, 1.63007025e-02f, -1.88919324e-02f, 1.68902464e-02f, 1.17870197e-02f, -3.45506370e-02f, -1.12299826e-02f,
  -3.68593514e-01f, 1.47122994e-01f, 2.10298494e-01f, -9.62177366e-02f, -1.49528325e-01f, -9.18947067e-03f, -3.09825465e-02f, -5.32890521e-02f, -5.65296151e-02f, 1.14148594e-01f,
  -5.74971810e-02f, 1.79072637e-02f, -5.33790216e-02f, 1.97639018e-01f, -1.99776888e-01f, 7.33556449e-02f, -6.96885213e-02f, -3.97483185e-02f, 7.46149123e-02f, -1.55611992e-01f,
  -9.64503363e-02f, 6.17460173e-04f, 5.22816144e-02f, 9.89922509e-02f, 5.57902940e-02f, -3.86077017e-02f, -1.51119545e-01f, -7.05034472e-03f, 7.72729367e-02f, 6.78025782e-02f,
  -3.79408412e-02f, -1.78840727e-01f, 3.30177508e-03f, -8.23050141e-02f, -5.22792563e-02f, -5.04642259e-03f, -7.93594494e-02f, -1.74950939e-02f, -1.11117708e-02f, 5.49987704e-03f,
  -2.34370548e-02f, -4.81726341e-02f, 3.20291892e-02f, 8.15262925e-03f, -5.18379137e-02f, 6.76705465e-02f, 2.77789347e-02f, 5.12004308e-02f, 1.02036469e-01f, -1.40578616e-02f,
  2.41554324e-02f, 3.36893015e-02f, -2.27833390e-02f, -4.93116863e-03f, 4.65258248e-02f, 1.46622853e-02f, 4.51621786e-02f, 3.54425646e-02f, -6.61541894e-02f, -7.14416504e-02f,
  -8.29973072e-02f, -4.94582094e-02f, 7.71397576e-02f, 2.10359711e-02f, 9.18507650e-02f, -3.66736278e-02f, 1.61142517e-02f, 7.47737335e-03f, 3.11944559e-02f, -2.71611027e-02f,
  1.29142283e-02f, -6.84160590e-02f, -4.91789989e-02f, 7.34092528e-03f, 4.23524305e-02f, -7.14144185e-02f, 7.25677656e-03f, -6.33371323e-02f, 6.87661916e-02f, -2.95963045e-02f,
  -1.00383041e-02f, -5.53700365e-02f, -2.89937742e-02f, -3.88127416e-02f, -7.85784423e-03f, -3.00876480e-02f, -5.85424788e-02f, -2.88592950e-02f, -4.07767706e-02f, -4.26910408e-02f,
  -1.53791726e-01f, -3.56487185e-01f, 3.19985375e-02f, -2.73055807e-02f, 6.47933483e-02f, -3.81611697e-02f, 1.35609750e-02f, 1.81975104e-02f, -3.53814624e-02f, -6.46616668e-02f,
  1.00382483e-02f, -1.95428506e-02f, -3.97873297e-02f, 1.08184861e-02f, -3.83577077e-03f, -5.93727939e-02f, 1.65664945e-02f, 1.11852083e-02f, -1.13724396e-01f, 1.95826180e-02f,
  -8.45269784e-02f, -3.84050570e-02f, 4.83003072e-02f, -2.29317788e-02f, -5.80444746e-02f, -2.42280178e-02f, -6.30795360e-02f, -3.47005315e-02f, -3.32754143e-02f, 3.92799489e-02f,
  6.41803294e-02f, -1.51277527e-01f, -1.61388163e-02f, -1.53557360e-01f, 1.09105650e-02f, -3.11349690e-01f, -2.99508691e-01f, -1.44265935e-01f, -2.15803012e-01f, -1.53254017e-01f,
  -7.75916725e-02f, -8.64966437e-02f, -1.00008741e-01f, -2.96620041e-01f, -2.39218652e-01f, -2.28163525e-01f, -1.88909382e-01f, -1.33239189e-02f, 2.51277126e-02f, -3.20350379e-02f,
  -1.98835935e-02f, -2.22142681e-01f, -5.99894337e-02f, -3.56415696e-02f, -6.51872754e-02f, 1.45904332e-01f, 7.44915009e-02f, 9.13621485e-02f, 2.34354683e-03f, -4.77618724e-02f,
  -1.05480462e-01f, -2.10856386e-02f, 4.80299182e-02f, 4.92261238e-02f, 3.87113839e-02f, 1.27603352e-01f, 6.92473948e-02f, -1.08036501e-02f, -2.89211478e-02f, -5.09163961e-02f,
  1.03790984e-02f, 1.28395320e-03f, -1.04522482e-02f, -2.53774039e-02f, 9.16314870e-03f, 5.92094101e-02f, -6.55103251e-02f, -2.38863030e-03f, -7.20559061e-02f, -1.74069032e-02f,
  -6.51773289e-02f, 1.38033601e-03f, 1.44653944e-02f, 6.41917717e-03f, 1.16189308e-02f, -5.51456138e-02f, -2.75807939e-02f, 6.49822950e-02f, 5.26438691e-02f, -2.18093619e-02f,
  -9.76097956e-03f, 1.60375144e-02f, -2.42589231e-04f, 2.14812439e-02f, -2.88191345e-02f, 3.48687656e-02f, -4.88112681e-02f, 6.17405921e-02f, -2.09177006e-03f, -4.79619093e-02f,
  2.49587502e-02f, -4.64099646e-02f, 2.73175389e-02f, -3.99197564e-02f, 2.15255823e-02f, -2.06655450e-02f, 3.27850059e-02f, -7.19705084e-03f, 2.99570356e-02f, 2.04421524e-02f,
  5.65105863e-02f, 3.01904138e-02f, -2.53696255e-02f, 8.49935263e-02f, -1.48952538e-02f, 8.14704318e-03f, -2.60608774e-02f, 2.52131354e-02f, -9.66951996e-03f, 1.85933691e-02f,
  -1.22583993e-01f, -2.88579483e-02f, -9.13049057e-02f, -2.05181967e-02f, -2.69167442e-02f, -2.30897553e-02f, 1.16054844e-02f, -4.98687197e-03f, -2.00629104e-02f, -3.02514154e-02f,
  8.40500370e-02f, 2.18668859e-02f, 2.30664518e-02f, 5.92772383e-03f, -3.95403104e-03f, -7.72361308e-02f, 7.21624345e-02f, 4.84053195e-02f, 3.32658249e-03f, -1.32804248e-03f,
  2.21544951e-02f, -1.21841459e-02f, 5.21173477e-02f, -2.43377462e-02f, 6.58371225e-02f, 2.90424400e-03f, 3.38611081e-02f, 2.73417346e-02f, -6.09781966e-03f, -3.64124477e-02f,
  -1.05840713e-01f, 1.28845245e-01f, 1.48130193e-01f, -1.82885993e-02f, -5.53718247e-02f, 1.15665250e-01f, 3.40912104e-01f, -1.63640499e-01f, 1.71621278e-01f, 5.59534319e-02f,
  -1.88208297e-02f, 6.37535974e-02f, 2.50789821e-01f, -4.60061356e-02f, 7.79375359e-02f, 2.23073125e-01f, -6.80551976e-02f, 5.79253621e-02f, 6.72632232e-02f, -1.12008646e-01f,
  -7.67897293e-02f, -1.23234518e-01f, 5.36587946e-02f, -1.38578311e-01f, -7.35571533e-02f, -1.72793806e-01f, -3.48151147e-01f, 4.21583764e-02f, -1.72837377e-01f, -5.30328564e-02f,
  4.60226089e-02f, 9.81551036e-02f, 5.91291599e-02f, -8.11878033e-03f, -5.65440096e-02f, -4.46025245e-02f, 6.69735894e-02f, 3.53408139e-03f, 1.11316796e-02f, -3.52852652e-03f,
  -3.34729883e-03f, -7.64881121e-03f, 1.59310848e-02f, -2.98531372e-02f, 3.79477069e-02f, -4.22352739e-02f, 6.81345863e-03f, -5.78864850e-02f, 2.97081545e-02f, 1.22557068e-02f,
  4.51306514e-02f, -6.88096359e-02f, -7.64573440e-02f, -2.31961533e-02f, -6.57258276e-03f, 2.37955302e-02f, -5.15283383e-02f, 1.27098383e-03f, -9.02800187e-02f, 2.60538631e-03f,
  -2.97547840e-02f, -4.61709015e-02f, -2.05893200e-02f, -1.35477597e-03f, 2.93567427e-05f, 3.43824178e-02f, -3.19367796e-02f, -2.17038356e-02f, 1.47995502e-02f, 2.02129334e-02f,
  -2.93452796e-02f, 1.68462936e-02f, -5.28936125e-02f, 2.23606713e-02f, -8.00418258e-02f, 1.64836477e-02f, -3.36145014e-02f, 5.45035364e-05f, -2.35307533e-02f, 3.15485448e-02f,
  1.00925140e-01f, 1.17874483e-03f, 5.86379692e-02f, -3.73884514e-02f, 1.38875050e-02f, 5.40777110e-03f, -7.22822919e-02f, 1.37500139e-02f, 4.83202226e-02f, -1.62044540e-02f,
  -1.14670783e-01f, -8.76064152e-02f, 8.42157453e-02f, 3.63295674e-02f, 1.29732424e-02f, -6.76850080e-02f, 4.81623895e-02f, -1.61732901e-02f, -1.95785407e-02f, -2.65202373e-02f,
  -7.40866214e-02f, 2.10252181e-02f, -1.12033658e-01f, 2.38313954e-02f, -3.21519747e-02f, -4.41320688e-02f, -5.72553314e-02f, 4.53605363e-03f, -5.33121862e-02f, -6.72520101e-02f,
  -4.77528647e-02f, -4.02633622e-02f, 3.96422520e-02f, -7.01560639e-03f, -8.36988911e-02f, -2.08794116e-03f, 3.83460335e-03f, 3.60500142e-02f, -1.03916712e-01f, 1.50559340e-02f,
  -4.77114558e-01f, 3.49004894e-01f, 1.18296042e-01f, -1.33496076e-01f, 3.29373740e-02f, 5.37119210e-02f, 2.27701776e-02f, 1.78802609e-01f, 1.91337243e-01f, 1.99977770e-01f,
  9.36126933e-02f, -1.43206537e-01f, 1.43683881e-01f, 1.48210898e-01f, -1.85745731e-01f, 2.60674298e-01f, 8.38536546e-02f, 5.32613229e-03f, 1.91535249e-01f, -1.12220891e-01f,
  -4.47497778e-02f, 5.48429191e-02f, -3.94718200e-02f, 1.10566579e-01f, -2.24287920e-02f, -1.81903765e-02f, -2.58075356e-01f, -5.27210301e-04f, -8.01136270e-02f, -1.92158986e-02f,
  1.26076072e-01f, 9.89895463e-02f, 1.54880807e-02f, 7.08139092e-02f, -2.16171518e-02f, -7.08413646e-02f, -7.37733543e-02f, -3.92899774e-02f, 6.65422017e-03f, 7.79791623e-02f,
  -7.06235915e-02f, 1.00251138e-02f, 5.10243103e-02f, 3.34058478e-02f, -5.07736549e-05f, 1.73953548e-03f, 6.68419376e-02f, 1.89556312e-02f, -4.09003068e-03f, 4.85015102e-02f,
  1.82188004e-02f, 2.62696240e-02f, 6.25093579e-02f, 1.33528821e-02f, -7.46387849e-03f, 7.50144422e-02f, 3.80255766e-02f, -8.53459835e-02f, -6.20961981e-03f, 3.47381011e-02f,
  2.56626271e-02f, 2.92021818e-02f, 7.25711090e-03f, 4.93237153e-02f, -6.35367818e-04f, 3.59310769e-02f, 4.81447997e-03f, 2.04126090e-02f, -3.74250561e-02f, 3.80952773e-03f,
  -2.35445779e-02f, -1.50879251e-03f, 8.94789547e-02f, -1.16191255e-02f, -6.55946434e-02f, -4.21216711e-02f, -3.28400955e-02f, 1.05065499e-02f, -1.82220973e-02f, -4.57596360e-03f,
  4.40338664e-02f, 1.24183232e-02f, 4.09226827e-02f, -4.22984641e-03f, 8.26790556e-02f, -4.47749943e-02f, 1.78414211e-02f, 1.81983653e-02f, -5.21306396e-02f, -1.21168353e-01f,
  1.53595547e-03f, 1.26659304e-01f, -2.25337893e-02f, 1.51586337e-02f, -4.85771038e-02f, -4.26065363e-02f, 1.93893295e-02f, 1.80546194e-02f, 1.33880721e-02f, 1.06848367e-02f,
  -4.31620292e-02f, -5.88796698e-02f, -3.40831140e-03f, -5.80134466e-02f, -3.71000655e-02f, 8.00349489e-02f, -8.66391584e-02f, -3.59994918e-02f, -2.66368464e-02f, -2.61973101e-03f,
  -2.79158633e-02f, -2.57418044e-02f, -5.83291575e-02f, -1.93525571e-02f, 4.12566960e-02f, -7.79342726e-02f, -1.03414893e-01f, -2.23257300e-02f, 6.66127680e-03f, 2.59305984e-02f,
  3.72785985e-01f, -6.01464286e-02f, 2.91564107e-01f, -9.94426534e-02f, -6.26428649e-02f, -2.27610856e-01f, -1.08350934e-02f, -7.07819015e-02f, 1.59742117e-01f, -2.27476090e-01f,
  -2.51833498e-01f, 1.12264857e-01f, 8.72596651e-02f, -2.89223522e-01f, 2.25408629e-01f, 7.37787634e-02f, -1.46745995e-01f, -8.83000344e-02f, 8.76356587e-02f, -3.83138284e-02f,
  4.59536426e-02f, -2.79465616e-01f, 8.47311690e-02f, -2.21842587e-01f, -7.46970549e-02f, -1.04928259e-02f, -6.87727481e-02f, 2.64165252e-02f, -3.01401824e-01f, -5.36943860e-02f,
  -2.81252880e-02f, -1.08821644e-02f, -2.17835698e-02f, 6.97905123e-02f, -3.80798150e-03f, 2.65706126e-02f, 2.91128382e-02f, 2.61135437e-02f, 5.45041040e-02f, 1.72519907e-02f,
  1.74046922e-02f, 1.70901082e-02f, -7.59651139e-02f, 4.46186513e-02f, 3.57587747e-02f, 7.10799545e-03f, -2.28960142e-02f, -5.33557013e-02f, -1.91795279e-03f, -3.68498638e-02f,
  7.05639645e-02f, -7.40954187e-03f, -4.64735813e-02f, 5.42908311e-02f, 2.29927227e-02f, -5.76617718e-02f, 4.04130742e-02f, -1.27600953e-02f, 5.93854440e-03f, 2.14573625e-03f,
  -3.20817418e-02f, 1.65626034e-02f, 4.02836129e-02f, -4.80316058e-02f, -1.14721162e-02f, -9.36822817e-02f, -7.99889714e-02f, -5.12661152e-02f, 1.62552111e-02f, -4.75092828e-02f,
  -5.34587018e-02f, -3.42812575e-02f, 9.46098845e-03f, -2.47442443e-02f, -7.10576074e-03f, -4.91650254e-02f, 1.74272768e-02f, -1.72101948e-02f, 3.04795895e-02f, -2.58245785e-02f,
  1.46777583e-02f, 2.03571767e-02f, 1.01172077e-02f, -1.96874887e-02f, -2.84734759e-02f, 3.25526297e-02f, -5.48479632e-02f, 1.53041659e-02f, -4.00083549e-02f, -3.02552413e-02f,
  -1.61183789e-01f, 2.12656315e-02f, 8.75130482e-03f, 2.09031180e-02f, 9.57240292e-04f, -2.54998431e-02f, 4.57082093e-02f, -1.36377830e-02f, 8.00965354e-03f, 4.83953841e-02f,
  -1.34216651e-04f, 1.36846246e-03f, 5.50738759e-02f, -6.03317618e-02f, -9.84363141e-04f, -2.53459923e-02f, 2.81187333e-02f, -4.17712051e-03f, -5.25432415e-02f, 8.06423835e-03f,
  -6.65833652e-02f, 1.17636761e-02f, 5.14151603e-02f, -2.06514355e-02f, -3.76018919e-02f, 7.73803368e-02f, -4.78315242e-02f, 9.34991986e-02f, 2.21967883e-02f, 4.33849543e-02f,
  -1.13138862e-01f, -7.01198801e-02f, -7.10082799e-02f, -2.36705150e-02f, -1.43043667e-01f, 2.77423989e-02f, 6.81384802e-02f, -1.18517794e-01f, -1.23746291e-01f, 2.67818049e-02f,
  -1.99423097e-02f, 1.03722535e-01f, -9.47421342e-02f, 1.36250362e-01f, 8.96062702e-02f, 4.04192843e-02f, 1.12366684e-01f, 1.19625308e-01f, 1.57308746e-02f, -6.00743992e-03f,
  -4.54169512e-02f, 9.90858022e-03f, 9.10559297e-02f, 3.59533653e-02f, -6.23641908e-02f, 1.42420130e-02f, 3.44615616e-02f, -8.11725110e-02f, 1.47473350e-01f, 8.75516832e-02f,
  1.02085903e-01f, -1.45930365e-01f, -6.66918829e-02f, 3.50788683e-02f, -4.00458463e-02f, -2.94655189e-02f, 6.57151118e-02f, 6.46148920e-02f, -9.24727786e-03f, -2.51463931e-02f,
  -3.40553336e-02f, 6.57908097e-02f, 2.52777878e-02f, -7.29958937e-02f, -7.12315515e-02f, 4.33213525e-02f, 7.05407327e-03f, 4.84871715e-02f, -3.64659578e-02f, -2.40252004e-03f,
  -1.83480140e-02f, -1.16120689e-02f, -3.22780833e-02f, 9.70854536e-02f, -2.67039668e-02f, -1.43255275e-02f, 7.12532699e-02f, -1.26680015e-02f, -1.56332627e-02f, 9.59972013e-03f,
  2.44660061e-02f, -4.24699783e-02f, -3.94356810e-02f, -2.32583359e-02f, -1.66352410e-02f, -7.20163574e-03f, -3.61371972e-02f, 8.71880427e-02f, -4.24710214e-02f, 5.35733849e-02f,
  -1.89032312e-02f, 3.03082522e-02f, -3.19317007e-03f, -3.46805267e-02f, 8.81954283e-03f, 5.47966100e-02f, 2.57838443e-02f, 5.64730912e-02f, 4.93697636e-02f, 8.37982073e-02f,
  5.36066294e-02f, -3.71563025e-02f, 2.67003253e-02f, 3.25189233e-02f, -2.67094485e-02f, -7.14535080e-03f, 1.79193038e-02f, -5.98618016e-02f, 3.08850110e-02f, -1.11270035e-02f,
  4.27111834e-02f, -1.19465224e-01f, -5.39613515e-02f, 3.76283526e-02f, 2.28681639e-02f, -2.60844864e-02f, 4.71089641e-03f, 2.50105932e-02f, -4.94105136e-03f, -3.53396684e-03f,
  -2.17457432e-02f, 3.12397559e-03f, -4.68629934e-02f, 7.84969553e-02f, 3.41804959e-02f, -3.05475872e-02f, 4.23093587e-02f, 1.95802953e-02f, 5.54532744e-03f, -1.29755959e-03f,
  -5.42314202e-02f, -3.90737243e-02f, 6.13594353e-02f, 3.35105062e-02f, 5.68439625e-02f, 1.43042365e-02f, -6.71373978e-02f, -2.26060022e-02f, -3.18702273e-02f, -1.09568164e-02f,
  -2.20123604e-01f, -2.35214364e-02f, 2.26402834e-01f, -1.78046837e-01f, -2.29030848e-01f, -1.84977390e-02f, 5.30590974e-02f, -1.66354924e-01f, -9.04493853e-02f, -7.49528185e-02f,
  -7.68710449e-02f, 1.18387774e-01f, 2.34357759e-01f, -1.58293936e-02f, 2.20314696e-01f, 3.45927984e-01f, -6.46713600e-02f, -5.47496378e-02f, 6.31092163e-03f, -1.70213193e-01f,
  4.78961170e-02f, -1.43824980e-01f, 1.83829501e-01f, -1.18311130e-01f, -1.53654590e-01f, -1.24408044e-01f, -9.92848873e-02f, 1.06049456e-01f, -1.24058336e-01f, 6.62783980e-02f,
  -2.47241091e-02f, -1.24558911e-01f, 6.58409521e-02f, 5.54106086e-02f, -5.78420609e-02f, -6.32515922e-02f, -1.63963288e-02f, 1.24160171e-01f, 1.63720734e-02f, -1.41008999e-02f,
  4.05197479e-02f, -6.17677756e-02f, -3.22644413e-02f, 2.21689027e-02f, -5.48002720e-02f, -2.65897904e-02f, 6.79072663e-02f, 6.42087385e-02f, -6.69297297e-03f, 5.41735440e-02f,
  5.68871610e-02f, 8.55272636e-02f, -2.98083350e-02f, 2.39836355e-03f, 5.41785322e-02f, 5.80126680e-02f, 2.02341489e-02f, 4.61703986e-02f, -6.71232194e-02f, -3.06172799e-02f,
  -4.79440624e-03f, 1.54605061e-02f, 3.11955456e-02f, -9.04601961e-02f, -1.03561459e-02f, -5.68482019e-02f, 3.75265963e-02f, 1.38620380e-02f, 1.96057907e-03f, -3.96174714e-02f,
  -1.82364918e-02f, -5.19183651e-02f, 1.64099932e-02f, -3.26385684e-02f, 1.35432882e-02f, -3.84706631e-02f, 2.37910859e-02f, -2.28527468e-02f, -3.72553729e-02f, -5.38944558e-04f,
  6.49454910e-03f, -8.32740963e-03f, 3.38401459e-03f, 1.39652602e-02f, -2.75398064e-02f, 3.97546813e-02f, 2.12419759e-02f, 2.85114367e-02f, -3.12908031e-02f, 4.12887335e-02f,
  -1.55504629e-01f, -1.93767220e-01f, -1.05063781e-01f, -1.02774315e-01f, -1.60150230e-02f, 5.06788529e-02f, 4.84460741e-02f, -2.00081393e-02f, 4.86749522e-02f, -1.07886111e-02f,
  -5.08056208e-02f, 1.23030068e-02f, -2.94670463e-02f, -1.70872398e-02f, 2.34010909e-02f, 2.61223186e-02f, -2.87343729e-02f, -2.72495281e-02f, -9.85185057e-02f, 1.50990179e-02f,
  -7.13678002e-02f, -7.05916584e-02f, 2.12114397e-02f, -6.39446080e-02f, -7.78292418e-02f, -3.21856956e-03f, -1.03857711e-01f, 3.00019775e-02f, 6.73180223e-02f, 7.20165670e-02f,
  -1.00990221e-01f, 5.98350866e-03f, 4.27974723e-02f, -7.25186840e-02f, 7.66967386e-02f, 1.07007310e-01f, 1.23411380e-01f, -6.08283132e-02f, -2.26489872e-01f, 7.26125389e-02f,
  6.12989105e-02f, -1.62178531e-01f, -9.08950493e-02f, 1.26356736e-01f, -1.65655702e-01f, -1.20513678e-01f, 6.08805940e-02f, 1.56280994e-02f, -1.42556444e-01f, 3.53402388e-03f,
  -5.91078997e-02f, -1.00623677e-03f, 8.88044536e-02f, 1.07949033e-01f, 1.86634958e-01f, 2.18906850e-02f, 5.71699347e-03f, -1.43320737e-02f, 1.34357393e-01f, -9.10600720e-05f,
  1.25688344e-01f, -9.06949863e-02f, 7.19960555e-02f, 7.35288486e-03f, 3.46035548e-02f, 9.95900109e-02f, 2.07076054e-02f, -9.10748076e-03f, 1.92767829e-02f, -4.50907461e-03f,
  -5.53883985e-03f, 4.45193164e-02f, -6.97450414e-02f, -4.18501124e-02f, 3.98583077e-02f, -1.34817436e-02f, -8.81848566e-04f, 7.33386874e-02f, -8.78809544e-04f, 1.91331301e-02f,
  -2.70705596e-02f, -2.32207887e-02f, -1.70637947e-02f, -3.83218192e-02f, -2.89654881e-02f, 4.35320213e-02f, -1.48497140e-02f, 1.72391592e-03f, -4.50148620e-02f, -5.17802089e-02f,
  -9.35569331e-02f, -1.73809864e-02f, -1.45870598e-03f, -1.10895038e-02f, -1.96451284e-02f, 3.22282985e-02f, -5.90452738e-02f, -3.33134793e-02f, -2.34408081e-02f, -9.71447676e-03f,
  -2.29741773e-03f, -3.31742316e-02f, -2.17089560e-02f, -1.31559176e-02f, -3.40080373e-02f, -1.16911530e-02f, -2.51761302e-02f, -3.17035168e-02f, 2.59959083e-02f, -3.45042460e-02f,
  5.26823513e-02f, -5.29616401e-02f, 4.91003506e-02f, 5.43152820e-03f, -3.46291922e-02f, -3.50467637e-02f, 5.91084063e-02f, -4.81928550e-02f, 2.85367798e-02f, -4.20615971e-02f,
  -9.87325981e-02f, -2.49587223e-01f, -3.92766949e-03f, 5.36967777e-02f, 1.28836585e-02f, 4.82215360e-02f, -1.24079278e-02f, -4.29777056e-02f, -6.39624521e-02f, -1.14320852e-02f,
  -2.64768265e-02f, -5.00493310e-02f, 1.99948661e-02f, 1.50075713e-02f, -5.67751750e-03f, 1.60163902e-02f, 4.33937786e-03f, -2.02234704e-02f, -5.51364794e-02f, 3.22558954e-02f,
  4.41421308e-02f, -1.92011222e-02f, 2.60639749e-02f, 3.76675203e-02f, 5.45958281e-02f, 2.47690491e-02f, -5.80526739e-02f, 2.40684953e-02f, -5.63366637e-02f, 2.67700106e-03f,
  -5.23553267e-02f, -2.43563101e-01f, -6.06295727e-02f, -1.19689144e-01f, 1.48072049e-01f, -2.77140569e-02f, -3.46128345e-02f, 4.40469086e-02f, 1.78464323e-01f, -2.61067420e-01f,
  -1.99216716e-02f, -1.90195248e-01f, -7.98098072e-02f, -1.08264357e-01f, 1.37734994e-01f, 1.71922185e-02f, -8.20320919e-02f, -9.27137583e-02f, 1.40419364e-01f, -7.89424554e-02f,
  1.35114253e-01f, -7.81412330e-03f, -3.83224338e-02f, 4.49693166e-02f, -9.22051445e-02f, -4.46757153e-02f, -9.33711752e-02f, 4.56350110e-02f, -1.69418111e-01f, -4.02257852e-02f,
  -7.78594613e-02f, 2.23486386e-02f, -2.61205342e-02f, 2.04529837e-02f, 4.46200110e-02f, -1.35592118e-01f, -2.57087983e-02f, -7.76643008e-02f, 2.78203655e-02f, 2.51363274e-02f,
  1.00793205e-02f, -3.56863588e-02f, -3.51419114e-02f, 2.98053753e-02f, 4.22527678e-02f, -1.43828597e-02f, 4.70727459e-02f, -9.08733904e-03f, 3.64088789e-02f, 6.68582097e-02f,
  -2.58398950e-02f, 9.58795100e-03f, -1.93781145e-02f, -9.57515687e-02f, 4.98995744e-02f, 2.77785584e-02f, -6.79659471e-03f, 1.98040903e-02f, -3.84638868e-02f, -5.81837036e-02f,
  4.68136631e-02f, 2.91891061e-02f, -4.36511487e-02f, -3.34880035e-03f, 1.51969502e-02f, -2.12374590e-02f, 2.35906597e-02f, 3.83121297e-02f, -2.65910849e-02f, 4.01367359e-02f,
  1.19615784e-02f, 5.22789359e-03f, 3.24488990e-02f, 6.45541102e-02f, 2.90599577e-02f, -3.64223383e-02f, -2.26593222e-02f, -1.47407083e-02f, 7.71009028e-02f, -6.13982826e-02f,
  4.94689532e-02f, 5.98848425e-02f, -5.55300452e-02f, -2.52552107e-02f, -2.58782394e-02f, -2.81860810e-02f, -6.35262057e-02f, -1.53920650e-02f, -2.28897892e-02f, 7.23315999e-02f,
  7.04927146e-02f, -3.40907020e-03f, -3.63116880e-04f, -2.47177761e-02f, 2.72356216e-02f, 4.02998514e-02f, -2.34509408e-02f, 2.61366479e-02f, 6.37162942e-03f, 4.58963066e-02f,
  -1.46753490e-02f, -4.97768596e-02f, -3.67028229e-02f, -2.70823413e-03f, -8.40379577e-03f, 2.26844158e-02f, -8.47968608e-02f, -1.71902427e-03f, -1.33535371e-03f, 1.52182737e-02f,
  -1.35749381e-03f, 4.41517457e-02f, 5.10523170e-02f, 3.74853350e-02f, -1.27540743e-02f, 6.59644511e-03f, -9.89749935e-03f, -5.26712723e-02f, -2.19283532e-02f, 4.69861962e-02f,
  1.58501416e-01f, 3.48939374e-02f, -6.35828301e-02f, 1.63650468e-01f, -1.25627592e-01f, 1.24046624e-01f, 1.94223061e-01f, -1.13096446e-01f, -5.75293079e-02f, 1.20072797e-01f,
  3.40725556e-02f, 9.03559178e-02f, 1.33838719e-02f, 3.69399130e-01f, 2.86464006e-01f, 1.52377844e-01f, 3.00754875e-01f, 2.26294428e-01f, -7.43406042e-02f, 1.63383279e-02f,
  3.79695557e-03f, 2.87318736e-01f, -4.79114391e-02f, -1.73116714e-01f, 2.49829087e-02f, -2.31259257e-01f, -7.59809688e-02f, -1.79855406e-01f, 8.90533812e-03f, 4.50615697e-02f,
  1.34770200e-01f, 4.05518264e-02f, -8.47226754e-02f, 3.13037373e-02f, 3.35384626e-03f, -2.10534781e-02f, 6.15521297e-02f, 6.65786564e-02f, -9.08889174e-02f, 2.06371929e-04f,
  -6.64620921e-02f, -7.86057711e-02f, 3.29735652e-02f, -3.06301145e-03f, 5.54629117e-02f, -6.65405067e-03f, -1.94688700e-02f, -5.02448343e-02f, -4.53488901e-02f, 2.12844498e-02f,
  -2.98376717e-02f, 5.47599280e-03f, 1.83233283e-02f, 4.08596136e-02f, -9.22674686e-02f, 6.84878081e-02f, 3.47479582e-02f, -6.39785528e-02f, 1.09007850e-03f, 1.48150874e-02f,
  5.22641912e-02f, 3.26322541e-02f, 2.83232861e-04f, -8.14327598e-03f, 1.50635745e-02f, 1.55505789e-02f, 5.35810664e-02f, 1.55826192e-02f, 3.66825350e-02f, 4.28913161e-03f,
  1.43349981e-02f, 9.92581714e-03f, 4.23699059e-02f, 3.42398845e-02f, 4.68512587e-02f, 2.96248347e-02f, 1.27821229e-02f, 2.62085386e-02f, -2.69701332e-02f, -4.83263750e-03f,
  1.10821929e-02f, 5.44907078e-02f, -3.83297019e-02f, 1.56009989e-02f, 5.30421734e-03f, 2.90037686e-04f, 2.75628753e-02f, -1.07370522e-02f, -1.32681485e-02f, -3.59638296e-02f,
  -2.33159177e-02f, -8.74727815e-02f, -4.26727124e-02f, 7.24252593e-03f, 1.37940692e-02f, 6.51306361e-02f, 3.19347158e-02f, -6.79959655e-02f, 6.33721948e-02f, -6.85994513e-03f,
  5.89148067e-02f, 2.66790204e-02f, -1.49242468e-02f, 2.42404323e-02f, -3.05329561e-02f, 1.44988699e-02f, 4.62182797e-02f, -6.60652248e-03f, 4.60287407e-02f, -3.30811292e-02f,
  -4.58476469e-02f, 2.18468029e-02f, -4.55821604e-02f, -4.45520021e-02f, 7.14057833e-02f, -2.68113744e-02f, -6.18132278e-02f, -1.22968368e-02f, 5.13513247e-03f, 1.28595438e-02f,
  2.13516150e-02f, 1.64388865e-01f, 3.19413334e-01f, 2.49805644e-01f, -1.15656473e-01f, -1.24098480e-01f, 9.89704803e-02f, 5.56394458e-04f, 4.44370322e-02f, 5.87388985e-02f,
  -8.84361938e-02f, 1.48024186e-01f, -8.23340341e-02f, 8.86024311e-02f, -1.67468250e-01f, -1.19188353e-01f, -3.12496107e-02f, 2.27253549e-02f, -6.70121014e-02f, 1.07830063e-01f,
  3.43959443e-02f, -9.26685184e-02f, 1.02106616e-01f, -6.40223920e-02f, 1.58406466e-01f, 1.24812081e-01f, -1.09436862e-01f, 5.91804460e-02f, 4.23432402e-02f, -3.89522240e-02f,
  -1.20982360e-02f, 2.79804058e-02f, 1.28537178e-01f, 2.21103970e-02f, -2.07699207e-03f, -2.13323701e-02f, -3.60424886e-03f, -3.48880030e-02f, -4.62441742e-02f, -2.17338167e-02f,
  4.70060594e-02f, -7.05169328e-03f, 1.51807070e-02f, -1.38010513e-02f, 1.48854395e-02f, -2.51369253e-02f, -3.06351874e-02f, 3.61534171e-02f, 7.22534508e-02f, 8.63960106e-03f,
  1.58162303e-02f, -1.16613768e-02f, 7.25257471e-02f, -2.82201096e-02f, 5.71833067e-02f, 6.29163682e-02f, 5.70271797e-02f, -1.59701910e-02f, -7.45876282e-02f, -2.70089414e-02f,
  -6.50613680e-02f, 3.14231701e-02f, 1.66510567e-02f, 3.09232511e-02f, 1.43219791e-02f, 1.84980854e-02f, 1.81057937e-02f, 3.93700860e-02f, -1.92564726e-02f, -3.10657285e-02f,
  3.92220616e-02f, 3.35671157e-02f, -3.09462100e-03f, -1.95951667e-02f, -4.04453650e-02f, 3.18695605e-02f, 4.88427505e-02f, 3.79607570e-03f, -1.17420508e-02f, 1.68850310e-02f,
  -1.40809780e-02f, 4.10746448e-02f, 1.33757982e-02f, -2.07555089e-02f, 4.50510755e-02f, 1.52720874e-02f, 3.58360596e-02f, -1.55304987e-02f, 3.82270850e-02f, -2.36521065e-02f,
  -1.06927276e-01f, 1.19477119e-02f, -3.28302048e-02f, -3.10034156e-02f, 2.70344988e-02f, -3.71375717e-02f, 6.43109530e-02f, 4.02255021e-02f, 3.28040719e-02f, -3.24635021e-02f,
  -4.03355621e-02f, 1.14917783e-02f, -7.75200501e-02f, -9.72847175e-03f, 7.04789683e-02f, -1.46952691e-02f, -1.11415926e-02f, -2.03689728e-02f, 3.33316177e-02f, -8.62269290e-03f,
  2.94462107e-02f, -6.98920526e-03f, 2.16314550e-02f, -1.85929276e-02f, -3.84781584e-02f, -3.77587713e-02f, 2.74296887e-02f, 2.89754029e-02f, -2.17499919e-02f, -2.55945846e-02f,
  -3.21464449e-01f, 1.10818155e-01f, 1.31331563e-01f, -2.14404166e-01f, -2.00331032e-01f, -7.10073337e-02f, -4.88792136e-02f, -2.05778897e-01f, -2.50815213e-01f, 7.79609978e-02f,
  -1.92717481e-02f, 1.02164216e-01f, 2.88234264e-01f, 6.39657974e-02f, -3.44316363e-02f, 1.58879235e-01f, -1.76894590e-01f, -3.50768529e-02f, -1.82361417e-02f, -1.03260361e-01f,
  -1.18207540e-02f, -6.32006302e-02f, 1.87923238e-01f, 5.09376079e-03f, -1.19064234e-01f, -2.60603707e-02f, 1.39883161e-01f, 1.03102691e-01f, 1.07851803e-01f, 8.53927210e-02f,
  1.12491157e-02f, -5.86240403e-02f, -1.91186182e-03f, 6.15957677e-02f, -7.94645995e-02f, -5.84180988e-02f, 6.61052018e-02f, 3.82629521e-02f, -3.96209583e-02f, -1.01215644e-02f,
  7.74810165e-02f, -2.84005366e-02f, -3.58361080e-02f, 3.73811685e-02f, -4.41639870e-02f, 2.34102886e-02f, 2.59183925e-02f, -1.91030633e-02f, 1.53422002e-02f, 2.66076885e-02f,
  3.49415503e-02f, 4.63065654e-02f, -8.61654133e-02f, 1.24806212e-03f, -1.91231852e-03f, -3.98454890e-02f, 5.90184592e-02f, 1.00865826e-01f, 4.38532420e-02f, -7.64122084e-02f,
  -5.73520958e-02f, 1.50562655e-02f, 1.09025147e-02f, 7.81869888e-02f, -7.04349652e-02f, -5.82217099e-03f, 4.71020564e-02f, 5.13882302e-02f, 1.59552656e-02f, 8.48269463e-02f,
  -7.53818527e-02f, -1.10219815e-03f, -6.57207891e-02f, 6.21822812e-02f, -8.42059106e-02f, 5.57663676e-04f, -2.56058276e-02f, -5.74944401e-03f, -6.82053640e-02f, -1.54195158e-02f,
  3.98892798e-02f, -4.54348065e-02f, 9.22400206e-02f, 6.24281466e-02f, -2.37194297e-04f, 3.52954678e-02f, -4.31200899e-02f, 3.12731750e-02f, 4.55523431e-02f, -1.44120147e-02f,
  -5.07328659e-02f, -2.31706470e-01f, 4.39334624e-02f, 5.16527034e-02f, 1.01249509e-01f, 1.99063041e-04f, -4.66540083e-02f, -2.68290322e-02f, 1.41116623e-02f, -8.74196663e-02f,
  -8.70975778e-02f, 8.59620702e-03f, -7.07435012e-02f, -3.31258122e-03f, 9.96608287e-02f, -3.22732888e-02f, -2.94834115e-02f, -6.04128540e-02f, -6.89850971e-02f, 1.70834884e-02f,
  5.64122200e-02f, -4.54579294e-02f, 2.51720287e-02f, -4.31422964e-02f, -2.84396540e-02f, 4.26449403e-02f, -9.27033797e-02f, 3.83982025e-02f, 4.21392657e-02f, -1.98143218e-02f,
  -4.25914884e-01f, 1.75467759e-01f, -1.51611626e-01f, -1.97876588e-01f, -7.85164014e-02f, 1.01970909e-02f, -1.33379057e-01f, -6.09486699e-02f, -2.14193121e-01f, 9.37323943e-02f,
  -1.34206533e-01f, -2.80468874e-02f, -2.94555891e-02f, -1.31219134e-01f, -3.18034738e-01f, 2.28339843e-02f, -1.67205557e-01f, -6.70105144e-02f, 5.64046390e-02f, -8.02420974e-02f,
  -1.26297727e-01f, -2.70263553e-02f, -7.90983140e-02f, 4.31108847e-02f, -1.00270145e-01f, 5.47248386e-02f, 8.47362280e-02f, 1.47674069e-01f, 1.07577287e-01f, 4.06176969e-02f,
  -6.63538799e-02f, 2.11220160e-02f, -7.93662444e-02f, -5.02765998e-02f, -3.37688811e-02f, 6.21225126e-03f, 5.31086884e-02f, -3.57929841e-02f, 1.22356433e-02f, -9.18206759e-03f,
  -3.80079821e-02f, 1.46059794e-02f, -1.87034495e-02f, 3.80491875e-02f, -6.65198341e-02f, -7.74778724e-02f, -1.35850441e-02f, -1.18311746e-02f, 2.26320978e-02f, 2.81547513e-02f,
  5.10762483e-02f, 3.42424936e-03f, -5.15841693e-02f, 9.74679366e-03f, -6.44677058e-02f, -9.26496536e-02f, 5.73351271e-02f, -1.08442670e-02f, 1.45358378e-02f, -5.07901087e-02f,
  -3.86775322e-02f, 6.79065427e-03f, 3.37772630e-02f, -6.58693239e-02f, 3.74551788e-02f, -2.88262628e-02f, 4.11108173e-02f, 3.45652252e-02f, 1.55722713e-02f, -7.89081212e-03f,
  2.43046638e-02f, -2.23055140e-05f, -1.57564748e-02f, 5.72537817e-02f, 1.93339810e-02f, -1.44402748e-02f, 7.02634305e-02f, 5.45788817e-02f, -4.29018922e-02f, -2.11438760e-02f,
  -8.89344316e-04f, 2.95185316e-02f, 9.95518547e-03f, 1.66075416e-02f, 1.97466215e-04f, -5.18551208e-02f, -5.16661536e-03f, -3.97754759e-02f, 4.72820411e-03f, 6.26314729e-02f,
  -1.76005717e-02f, 9.55638662e-02f, -7.44082546e-03f, 2.00891867e-02f, 1.12522766e-02f, -1.39878988e-02f, -2.57930551e-02f, -4.09983881e-02f, 3.43154557e-02f, -2.72821486e-02f,
  7.20380619e-02f, 2.74510309e-02f, 5.07827960e-02f, -7.62626603e-02f, 3.72851156e-02f, 4.29820791e-02f, 2.21155044e-02f, 1.28799397e-03f, 4.55642715e-02f, -4.66485582e-02f,
  -1.54096587e-02f, 4.14384007e-02f, -7.39439344e-03f, 3.20558585e-02f, -3.33483294e-02f, 2.85712015e-02f, 8.95345304e-03f, 7.31070936e-02f, 4.66866456e-02f, -1.42243979e-02f,
  7.75201805e-03f, -8.47763792e-02f, 3.18985492e-01f, 2.52007954e-02f, 7.60812685e-02f, 1.69794913e-02f, -1.77557729e-02f, 5.21832379e-03f, -2.13976074e-02f, -3.54537457e-01f,
  2.71144677e-02f, -1.20514380e-02f, 2.54359879e-02f, -9.86266509e-02f, 1.13056347e-01f, 6.23427890e-02f, 5.16707776e-03f, -1.49036512e-01f, 1.39171898e-01f, -8.65078047e-02f,
  3.68101746e-02f, -1.28128275e-01f, 1.79335371e-01f, 3.52162197e-02f, 4.29371074e-02f, 6.07149228e-02f, -1.17177896e-01f, 7.84527510e-02f, -1.25384321e-02f, 1.07042864e-01f,
  1.01520546e-01f, -5.83867617e-02f, -4.64312918e-02f, 1.52945854e-02f, 3.39845307e-02f, 1.55788753e-02f, -3.48731577e-02f, 6.52032569e-02f, 1.10151909e-01f, -6.59550130e-02f,
  -9.36979726e-02f, -3.41036431e-02f, -3.57439206e-03f, 8.71133059e-02f, 1.89387314e-02f, 3.33133861e-02f, 4.98455316e-02f, 5.87887177e-03f, -4.74647433e-02f, 7.00952113e-02f,
  1.01877376e-01f, -1.11490220e-03f, 1.13423849e-02f, 1.32597769e-02f, 9.13254321e-02f, -3.28315832e-02f, -2.18354780e-02f, 5.80395013e-02f, -2.06800681e-02f, 2.09044237e-02f,
  -9.51661915e-02f, 4.59169559e-02f, -3.26816626e-02f, 8.37465599e-02f, 2.41747219e-02f, 3.18517536e-02f, 4.24760655e-02f, -2.93703154e-02f, 4.98941988e-02f, 2.00570561e-02f,
  -6.76762592e-03f, 1.98949841e-04f, 4.73615564e-02f, -1.68959498e-02f, -1.56610347e-02f, 1.35872075e-02f, 2.83700135e-02f, -3.82221080e-02f, -4.68562469e-02f, 8.49240124e-02f,
  -9.07977447e-02f, -5.86118065e-02f, -3.33522111e-02f, -2.27755923e-02f, -1.16956094e-02f, 3.01354919e-02f, -6.99961260e-02f, 1.12721920e-02f, 7.76676647e-03f, 4.94816117e-02f,
  -1.01805799e-01f, -2.08007053e-01f, 9.21417400e-02f, 1.02436938e-03f, -1.22037390e-02f, -1.00689158e-01f, -2.02540052e-03f, 2.06210316e-04f, -2.68349759e-02f, 3.00283800e-03f,
  2.94008236e-02f, 3.95085067e-02f, -4.81912494e-02f, -5.77703118e-02f, -1.97615474e-02f, 3.01816482e-02f, 6.23478089e-03f, -1.96673116e-03f, 4.75945231e-03f, 4.57118936e-02f,
  -3.00755538e-02f, -3.34952492e-03f, -1.05766524e-02f, 1.04388525e-03f, -6.24070466e-02f, 4.43771593e-02f, 2.60190107e-02f, -1.34798419e-02f, 3.11664138e-02f, 3.10707930e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.76537603e-01f, 9.08184573e-02f, -1.75425678e-01f, -2.33190507e-01f, 4.42079753e-02f, -3.77854288e-01f, -3.30086321e-01f, -3.75123806e-02f, 6.59647435e-02f, -5.41175008e-02f,
  -1.60104632e-02f, 1.07776076e-01f, 9.72981974e-02f, -2.23776892e-01f, -1.90227866e-01f, 3.20910774e-02f, -3.68530035e-01f, -2.11454958e-01f, 2.25864910e-02f, -1.35662198e-01f,
  -1.62810579e-01f, -9.02966112e-02f, -1.05271406e-01f, 9.87815857e-02f, -2.23183870e-01f, -1.14823952e-02f, 9.47159380e-02f, 9.49840024e-02f, -2.07066298e-01f, -4.42009941e-02f,
  -4.52127419e-02f, -6.83164224e-03f, -2.26320662e-02f, 1.03107132e-02f, -1.22444361e-01f, -1.07168287e-01f, -1.29418656e-01f, 4.58119437e-02f, -1.67857129e-02f, -1.04644179e-01f,
  -2.63610985e-02f, 5.20622581e-02f, -3.52566503e-02f, 5.89507855e-02f, 3.66020687e-02f, 2.99558900e-02f, -2.68608760e-02f, 4.32260847e-03f, -5.05097397e-02f, 2.36469712e-02f,
  -5.89687973e-02f, -4.45573255e-02f, -2.32066177e-02f, -6.56571016e-02f, -7.38536865e-02f, -9.52807590e-02f, 6.17204513e-03f, 4.93949726e-02f, -6.10745996e-02f, -1.77212916e-02f,
  -4.93323989e-02f, -4.54039546e-03f, -9.24349427e-02f, 2.77818702e-02f, -1.72481593e-02f, 5.65773249e-02f, -4.52029258e-02f, 3.43110785e-02f, -4.68563922e-02f, 8.00214708e-03f,
  2.58127619e-02f, 8.44717994e-02f, -2.04995684e-02f, -1.07965223e-01f, 1.51991863e-02f, -4.31441553e-02f, 3.73019092e-02f, -1.65115390e-02f, -9.12741944e-02f, 3.15141492e-03f,
  6.30683824e-03f, -1.09735429e-01f, -8.39796104e-03f, -5.57997636e-02f, -4.52425331e-02f, 8.28130171e-02f, 5.05169965e-02f, -5.16090961e-03f, 7.39668384e-02f, -2.32416596e-02f,
  -5.62601164e-02f, -1.05590045e-01f, -6.67396188e-03f, 5.95876127e-02f, -4.57940681e-04f, 6.46275980e-03f, -9.24732462e-02f, -3.32236178e-02f, -5.35718985e-02f, -1.58699751e-02f,
  -1.52580934e-02f, 5.87846059e-03f, 2.84476411e-02f, -5.11725582e-02f, -9.22441259e-02f, 2.66524982e-02f, -4.08790261e-03f, -8.81788135e-03f, -1.25881014e-02f, 1.17340367e-02f,
  3.28383297e-02f, 4.39605257e-03f, -2.38804910e-02f, 2.91210599e-02f, -4.85437512e-02f, -5.24381101e-02f, -1.10467076e-02f, 8.81764200e-03f, -8.72276258e-03f, 1.89248398e-02f,
  1.33370265e-01f, -1.07765459e-01f, -1.45664765e-02f, 6.48334622e-03f, -6.13573156e-02f, -8.25272575e-02f, -1.60201505e-01f, 3.96790244e-02f, 9.97292027e-02f, -6.08151369e-02f,
  2.40707994e-02f, -1.67291854e-02f, -1.09675139e-01f, -5.05896956e-02f, 1.68058336e-01f, 9.49019268e-02f, -1.14130750e-01f, 2.61017885e-02f, 2.63465643e-02f, -4.89177257e-02f,
  5.70881590e-02f, -6.71374127e-02f, 2.02007350e-02f, -9.25077349e-02f, -1.20785110e-01f, 3.68842967e-02f, 5.70342615e-02f, -1.19337320e-01f, -1.33496910e-01f, 2.60056853e-02f,
  5.71771674e-02f, -5.96472956e-02f, -7.69335553e-02f, -8.61916766e-02f, -1.82625465e-03f, 7.26521164e-02f, -1.85671486e-02f, -7.18289316e-02f, 7.21910596e-02f, -1.58415046e-02f,
  4.88644652e-02f, 3.90458368e-02f, 3.81502435e-02f, -7.10476935e-02f, -8.07565171e-03f, -6.01704270e-02f, 6.77281693e-02f, -3.14491615e-02f, -8.01039487e-02f, 8.52694139e-02f,
  6.34588255e-03f, 6.25194460e-02f, -6.35308102e-02f, 8.17237422e-02f, 4.03440781e-02f, 5.12509309e-02f, -8.51468649e-03f, 2.87091192e-02f, -5.70773296e-02f, 1.59581006e-02f,
  -8.70192796e-02f, 2.31473371e-02f, -2.88787559e-02f, 6.26185685e-02f, 4.17468511e-02f, 2.92824418e-03f, -2.76617035e-02f, -6.94578737e-02f, 2.98975576e-02f, -2.44139582e-02f,
  8.38815048e-02f, -2.43576113e-02f, -1.53122973e-02f, -7.61362910e-02f, -2.63506919e-02f, 9.65541825e-02f, -5.76266609e-02f, -6.53921887e-02f, -9.30961035e-03f, 3.50333638e-02f,
  -4.25318303e-03f, -9.91859101e-03f, -9.68366861e-02f, -7.12469816e-02f, 6.02398627e-02f, -3.54376324e-02f, 5.68282418e-02f, 5.05568050e-02f, 1.06438147e-02f, -4.43087891e-02f,
  -5.64112775e-02f, -8.94996598e-02f, -6.05668947e-02f, 7.72638693e-02f, -6.56346306e-02f, -6.23604655e-02f, 2.53545474e-02f, -1.84739903e-02f, 6.73201925e-04f, 6.80278614e-02f,
  -6.98426366e-02f, -3.99726443e-02f, -7.26813674e-02f, -3.31088044e-02f, -6.36469647e-02f, 1.24421520e-02f, -4.40328978e-02f, -1.94393788e-02f, 4.96275760e-02f, 4.83196415e-02f,
  -9.29278061e-02f, -6.45100474e-02f, 1.92580670e-02f, 9.54733044e-02f, 7.01890439e-02f, -2.70629637e-02f, -5.83093725e-02f, 4.58132625e-02f, -6.38616979e-02f, 6.26276881e-02f,
  2.38325819e-03f, 1.82523027e-01f, 9.42333192e-02f, 1.76841885e-01f, -1.35515958e-01f, -1.09068200e-01f, -1.32203743e-01f, 1.23007253e-01f, 3.48625332e-02f, -9.20724589e-03f,
  3.65353487e-02f, 1.23403102e-01f, 3.72048952e-02f, 1.35269165e-01f, -2.37584896e-02f, -1.99916493e-02f, 8.11647065e-03f, 1.20839570e-02f, -2.18086108e-03f, 1.84271988e-02f,
  -1.38874101e-02f, 1.12863397e-02f, 1.45345137e-01f, -3.71740386e-02f, 7.98004344e-02f, 6.57541975e-02f, 1.27660278e-02f, 7.32104704e-02f, -7.44042313e-03f, -7.92620331e-02f,
  3.47241983e-02f, 3.85600775e-02f, -3.34998928e-02f, -7.81992897e-02f, 2.87187696e-02f, 2.47498471e-02f, -1.41707035e-02f, 5.05880034e-03f, 1.64033268e-02f, 3.08721829e-02f,
  6.63534328e-02f, 1.17355064e-02f, 6.29100204e-02f, 1.73549093e-02f, -6.95993081e-02f, 3.41275521e-02f, 1.03839971e-01f, -4.94867675e-02f, -5.06965220e-02f, 5.19357882e-02f,
  9.97020155e-02f, -4.78510484e-02f, 4.51269448e-02f, 9.41015687e-03f, 3.06099132e-02f, -1.13456594e-02f, 1.69440508e-02f, -7.45542347e-02f, -3.57442871e-02f, 8.90212432e-02f,
  2.47633811e-02f, 6.83487877e-02f, 3.99649553e-02f, 7.21384659e-02f, -3.29429694e-02f, -1.50003731e-02f, 2.38339975e-02f, 5.08971550e-02f, 8.40144511e-03f, 5.29301539e-02f,
  -4.84308489e-02f, 5.33106588e-02f, -9.19573288e-03f, -3.64461076e-03f, -7.10967854e-02f, 6.87389821e-02f, -2.63982662e-03f, 3.62666845e-02f, -5.05771525e-02f, 4.89776209e-02f,
  -7.26775154e-02f, 5.63782714e-02f, 3.00351344e-02f, 4.69467752e-02f, -7.35641224e-03f, 5.41249551e-02f, 7.18329176e-02f, 2.56293230e-02f, 6.36283755e-02f, 2.29866169e-02f,
  -5.44943623e-02f, 1.79454982e-02f, 9.19243991e-02f, 3.16209793e-02f, 8.32413957e-02f, -6.94937110e-02f, 6.83535412e-02f, 7.62968957e-02f, -2.95988582e-02f, 6.37973770e-02f,
  2.53518671e-02f, 4.94057238e-02f, 1.11320857e-02f, -8.51472560e-03f, 1.43932388e-03f, -1.32076638e-02f, 1.01583786e-02f, -2.55400855e-02f, -5.56778535e-02f, 1.23231545e-01f,
  1.80708785e-02f, -4.09714319e-02f, 2.29231771e-02f, -2.71755625e-02f, -4.71618697e-02f, 1.94512401e-02f, 2.04868196e-03f, 4.19282988e-02f, -1.12508694e-02f, -1.82600245e-02f,
  -6.06697202e-02f, 2.07082823e-01f, 4.62819077e-02f, 8.91721323e-02f, -6.88185319e-02f, -3.61477852e-01f, -2.61519790e-01f, 6.71625212e-02f, -1.07577868e-01f, 9.53423604e-02f,
  -1.56546850e-02f, 9.88622531e-02f, 1.04160659e-01f, -3.71357724e-02f, -1.33306116e-01f, -1.66674137e-01f, -4.33921032e-02f, -2.06630632e-01f, -7.88045228e-02f, 7.40226433e-02f,
  2.79038772e-03f, 1.20584041e-01f, 4.75787558e-02f, 1.97266698e-01f, 8.57750326e-02f, 2.40059704e-01f, 2.44219691e-01f, 1.95340857e-01f, 1.87486559e-02f, -5.39249033e-02f,
  -4.81933765e-02f, 1.16546810e-01f, -2.60628723e-02f, -8.03273097e-02f, 1.47515964e-02f, -1.91074871e-02f, -7.51567557e-02f, -5.33441128e-03f, 1.67179387e-02f, 1.15967654e-02f,
  -4.38223630e-02f, -1.37838321e-02f, -7.59920776e-02f, -1.31855542e-02f, -7.33309612e-02f, -3.85316871e-02f, 1.01571731e-01f, -5.95146231e-02f, 5.49656041e-02f, 6.80903159e-03f,
  -9.35455691e-03f, 7.23328292e-02f, 4.92988527e-02f, 1.05120358e-03f, -9.97546688e-03f, 2.57466696e-02f, -6.43733218e-02f, -3.25167924e-02f, -3.66249345e-02f, 4.39658351e-02f,
  7.83947781e-02f, 6.10224030e-04f, -8.07312205e-02f, -1.52338501e-02f, -5.54074608e-02f, -4.78250254e-03f, -5.72118796e-02f, 5.97577877e-02f, -4.18226495e-02f, 4.61611780e-04f,
  -5.80015145e-02f, 1.94004849e-02f, 2.14663241e-02f, 3.60606574e-02f, -2.80661359e-02f, 2.79576681e-03f, -2.35863123e-03f, 8.22919607e-02f, -5.82884848e-02f, -1.13326393e-03f,
  2.84503791e-02f, 1.09378370e-02f, 1.79709718e-02f, 3.78962867e-02f, -1.08496763e-01f, 6.84449300e-02f, 7.52267092e-02f, -6.63566813e-02f, 5.70769347e-02f, -8.89217705e-02f,
  -1.97907686e-02f, 2.13063180e-01f, -2.15410478e-02f, 7.27780312e-02f, 2.65821535e-03f, -8.12414885e-02f, -1.30281933e-02f, -3.97367664e-02f, 1.07637584e-01f, -6.88541541e-03f,
  4.98150140e-02f, -5.11457548e-02f, -9.48143825e-02f, -3.44642065e-03f, 6.32668554e-04f, -3.02032493e-02f, 1.44404629e-02f, -7.61973998e-03f, 5.63013889e-02f, 4.25273925e-02f,
  3.75316143e-02f, -1.56027665e-02f, 2.98574250e-02f, -2.94114593e-02f, 4.33977433e-02f, 7.24579915e-02f, -4.93405154e-03f, 3.06124315e-02f, 2.97958753e-03f, 1.26020676e-02f,
  5.08536957e-02f, 3.45437229e-02f, 1.09434254e-01f, 6.13267720e-02f, 1.52741417e-01f, 1.94528908e-01f, 1.05987377e-01f, 1.46229953e-01f, 2.64022112e-01f, -5.72346523e-02f,
  6.19596057e-02f, -5.93288392e-02f, 5.70988618e-02f, 5.91254793e-03f, -4.34678122e-02f, -5.01613878e-02f, 7.75165483e-02f, 9.66815427e-02f, 5.35547808e-02f, 5.45650581e-03f,
  -5.17836632e-03f, -6.89702034e-02f, -1.40834227e-01f, -1.47852421e-01f, -1.30309626e-01f, -8.69727358e-02f, -8.38630795e-02f, -3.97317559e-02f, -1.88517887e-02f, 3.94747928e-02f,
  -1.50716463e-02f, -5.87439444e-03f, -6.38569221e-02f, 5.66692576e-02f, 1.88946445e-02f, 7.27027282e-03f, -8.60480666e-02f, 5.54564502e-03f, 1.11809215e-02f, -3.45396660e-02f,
  6.48628697e-02f, 6.83881203e-03f, 3.88474874e-02f, 5.91715723e-02f, 4.77968976e-02f, -7.61446729e-02f, 3.23477983e-02f, -7.01786727e-02f, 4.80073243e-02f, 5.09906709e-02f,
  -2.00338960e-02f, 6.04154021e-02f, -4.48229350e-02f, 1.34920515e-02f, -5.55582307e-02f, -4.23172936e-02f, 7.17838779e-02f, -2.64230631e-02f, -1.54405953e-02f, -1.40312593e-03f,
  8.35476592e-02f, -8.62634741e-03f, -6.77900985e-02f, -1.89995375e-02f, 7.83957243e-02f, 1.83112528e-02f, 4.73078899e-02f, 1.63066119e-03f, 1.59905907e-02f, -3.63681242e-02f,
  -6.57238215e-02f, -8.40335432e-03f, -3.61255705e-02f, 6.47780448e-02f, 7.34557956e-02f, -4.44091745e-02f, -8.17900002e-02f, -2.81733982e-02f, -2.06959695e-02f, -4.35477234e-02f,
  8.52976218e-02f, 1.73517354e-02f, -6.15358949e-02f, -6.00347063e-03f, -6.76447004e-02f, 3.18699144e-02f, 5.72541654e-02f, -6.00130670e-03f, 2.17983220e-02f, -5.85212186e-02f,
  4.24594507e-02f, 7.90435895e-02f, -1.24760261e-02f, 4.96373363e-02f, 2.60434672e-02f, 8.83986130e-02f, -4.62497957e-02f, -2.83116233e-02f, 4.63706329e-02f, 5.84543832e-02f,
  1.07409526e-02f, -6.68575019e-02f, 7.09457472e-02f, 4.15827744e-02f, 5.23869544e-02f, 9.39827878e-03f, 5.03831133e-02f, 4.77756746e-02f, 2.32831179e-03f, 1.24058397e-02f,
  -4.08438034e-02f, 9.73567888e-02f, -7.97062367e-02f, -6.56923726e-02f, 6.80147484e-02f, 8.13382566e-02f, 8.65588523e-03f, 5.22435308e-02f, 5.61223812e-02f, -9.43131372e-03f,
  -7.35266954e-02f, 3.50698195e-02f, -1.13053121e-01f, -6.46115020e-02f, 3.81699540e-02f, 5.45446202e-03f, -9.29971337e-02f, -4.96839955e-02f, -3.24370973e-02f, 3.54687758e-02f,
  2.36725416e-02f, -1.10447608e-01f, 8.26568902e-03f, -6.72344491e-02f, -6.85974211e-02f, 5.46885207e-02f, -5.94753958e-03f, -8.82692263e-03f, -8.97459537e-02f, -4.85558733e-02f,
  1.01443455e-02f, -6.75647557e-02f, 6.63827285e-02f, 7.10119903e-02f, 1.67511962e-02f, 4.43952642e-02f, 3.27434540e-02f, -5.32204136e-02f, -5.55498563e-02f, 4.58684564e-02f,
  -1.09614573e-01f, -5.81206009e-02f, -9.82602127e-03f, -9.81835201e-02f, -1.06420338e-01f, -2.27313209e-02f, 7.36345798e-02f, 3.79509255e-02f, -4.42732461e-02f, 1.64558571e-02f,
  2.46934593e-02f, -2.53213551e-02f, 9.38945711e-02f, -4.86485921e-02f, 7.46117830e-02f, -5.78216501e-02f, 6.09657280e-02f, -3.66454571e-02f, 2.95556709e-02f, -3.74030098e-02f,
  -2.20171479e-03f, -2.41748011e-03f, 1.01656802e-02f, 6.55385256e-02f, 3.91727164e-02f, 4.98611741e-02f, -9.53414068e-02f, 2.90289763e-02f, -9.68847722e-02f, 2.18031351e-02f,
  1.59286521e-02f, 3.84638570e-02f, -7.16635808e-02f, 5.51811457e-02f, 6.77061006e-02f, 2.97405738e-02f, 6.62896608e-04f, -3.25072883e-03f, 3.04457382e-03f, -7.47736096e-02f,
  -2.30578668e-02f, 7.99545832e-03f, 1.37284724e-02f, -3.02578639e-02f, -6.66599050e-02f, 6.49885014e-02f, -5.03342897e-02f, -6.30207285e-02f, 5.82900345e-02f, 1.72666293e-02f,
  -3.50150801e-02f, 4.14872691e-02f, 6.26812801e-02f, 4.10399288e-02f, -5.14261574e-02f, -7.67611042e-02f, 1.25155831e-02f, 4.74352054e-02f, 9.13764015e-02f, 3.78510170e-02f,
  -2.69863550e-02f, -9.07088742e-02f, 4.67082150e-02f, -2.00443957e-02f, 2.75378171e-02f, -6.81933612e-02f, -4.29000752e-03f, 4.16559093e-02f, 2.76253261e-02f, -5.88959530e-02f,
  4.42301929e-02f, -1.38248373e-02f, 5.04038818e-02f, 8.94120429e-03f, 4.49783029e-03f, -7.95721635e-02f, 2.92601474e-02f, 1.03471391e-01f, -2.81101875e-02f, -8.72465074e-02f,
  1.54794203e-02f, 7.02930316e-02f, 6.18472137e-02f, 2.03569159e-02f, 2.91285515e-02f, -6.44396618e-02f, -1.46058407e-02f, -6.29729545e-03f, 7.14909658e-02f, 2.00459026e-02f,
  1.27529576e-01f, -9.06250030e-02f, -2.02789575e-01f, -8.39177892e-02f, -6.58933073e-02f, -1.17667265e-01f, -2.37314031e-01f, -1.31403180e-02f, -3.93213071e-02f, 8.52367505e-02f,
  -3.46572138e-02f, 9.50617492e-02f, 7.44897500e-02f, -2.31565349e-02f, 1.20367501e-02f, 1.14875481e-01f, -1.77729547e-01f, -1.19518816e-01f, 9.51208770e-02f, -7.32826144e-02f,
  -8.19589070e-04f, -5.43327071e-03f, -1.21327914e-01f, -4.80518751e-02f, -2.65619848e-02f, -5.80244744e-03f, 7.35143796e-02f, -4.53697294e-02f, -1.29683748e-01f, -6.38554841e-02f,
  -1.62224714e-02f, 8.82001817e-02f, 5.00018103e-03f, 1.27784694e-02f, 2.21217144e-02f, 3.48784868e-03f, -9.87940505e-02f, -1.45523185e-02f, 5.90905063e-02f, 2.14346568e-03f,
  2.77096755e-03f, 5.26622012e-02f, 1.11827605e-04f, 9.71492659e-03f, 5.04920185e-02f, -5.65731749e-02f, -2.84827501e-02f, -8.96640196e-02f, 5.42336591e-02f, 3.33993859e-03f,
  -1.07496701e-01f, -3.51815335e-02f, -4.39224280e-02f, -7.41266757e-02f, -4.61954623e-02f, 5.57567067e-02f, -1.26295099e-02f, -4.39626537e-02f, 1.79541833e-03f, 2.98630856e-02f,
  8.10365528e-02f, -6.43995404e-02f, 9.04730186e-02f, 1.26382895e-02f, -6.47006482e-02f, 3.94490995e-02f, -6.32486343e-02f, -4.17568460e-02f, 2.10857745e-02f, -2.03897692e-02f,
  -8.84760842e-02f, 5.17822951e-02f, 7.32176378e-02f, 6.39978517e-03f, -5.92488088e-02f, 3.70798185e-02f, -3.77393253e-02f, -5.42672575e-02f, -1.08821601e-01f, 1.40963653e-02f,
  -6.74943179e-02f, 8.42148289e-02f, -1.26578845e-02f, 1.16035780e-02f, 3.31922844e-02f, -4.40428313e-03f, -1.62895839e-03f, -3.71582173e-02f, -1.00167617e-02f, -5.11504970e-02f,
  -4.74302880e-02f, 1.38328578e-02f, -6.53274998e-04f, 9.83627364e-02f, 5.87944277e-02f, 1.77013897e-03f, 3.73328254e-02f, -8.10527653e-02f, 4.11102995e-02f, 5.83776347e-02f,
  -3.74034606e-02f, -5.38069010e-02f, -6.72739148e-02f, 8.80671218e-02f, -7.93305710e-02f, -9.35268104e-02f, 8.65938663e-02f, -2.91818124e-03f, -3.18242833e-02f, -7.69946128e-02f,
  -8.25614780e-02f, -2.42740270e-02f, 1.04587458e-01f, -7.29364306e-02f, -4.23315503e-02f, 4.52315062e-02f, 5.97616211e-02f, 2.62063909e-02f, -5.51146194e-02f, -7.06500486e-02f,
  8.00159350e-02f, 3.01467627e-01f, 1.03294201e-01f, 1.54688284e-01f, -9.21143368e-02f, -2.51875669e-01f, 1.15599902e-02f, 6.50695562e-02f, 1.61269382e-01f, 6.38675317e-02f,
  1.15784627e-04f, 2.47735292e-01f, -1.97045412e-02f, 3.15889642e-02f, -2.71321595e-01f, -1.03613913e-01f, -5.16294688e-02f, -6.67744204e-02f, 5.40370569e-02f, 9.61311162e-02f,
  -7.66729787e-02f, -2.08317433e-02f, 2.00729929e-02f, -4.82837446e-02f, 2.79212259e-02f, 1.61627650e-01f, 5.60621470e-02f, 7.62937441e-02f, -3.05676013e-02f, 9.85455979e-03f,
  -1.06079713e-01f, 1.01024538e-01f, 3.35300788e-02f, 5.28032295e-02f, 6.60178193e-04f, -1.15166731e-01f, -4.31842394e-02f, -2.51545031e-02f, -7.53583163e-02f, 4.99573536e-02f,
  5.98773025e-02f, -6.55267388e-02f, 4.38385308e-02f, 3.83078605e-02f, -9.44301579e-03f, 7.53383487e-02f, 9.91756171e-02f, 6.19150884e-02f, -2.67496090e-02f, -4.89359312e-02f,
  -4.60598730e-02f, 2.91147828e-02f, -3.12616751e-02f, -2.60082353e-02f, 5.26410639e-02f, 4.31397595e-02f, 4.39139605e-02f, -1.24988910e-02f, 6.50446340e-02f, 2.20878907e-02f,
  -8.06041248e-03f, 4.14992087e-02f, 5.20087406e-02f, -1.44579997e-02f, 3.21667753e-02f, -6.45833686e-02f, 1.89888272e-02f, -2.84291524e-02f, -2.50011273e-02f, -2.63002682e-02f,
  6.45790324e-02f, 8.25529844e-02f, -2.54341513e-02f, -3.26906480e-02f, 3.61149535e-02f, 7.76422024e-02f, 1.16723850e-02f, 8.11671540e-02f, -7.63073415e-02f, -4.21405360e-02f,
  -1.17178494e-02f, -3.81754003e-02f, 7.94500113e-02f, -5.14825545e-02f, -1.28366305e-02f, -4.33022045e-02f, 5.96354203e-03f, -1.93145592e-02f, -8.12457725e-02f, -8.25088620e-02f,
  -4.25264351e-02f, 1.74408153e-01f, 5.78747084e-03f, -1.44349001e-02f, 5.63726127e-02f, -3.02999225e-02f, 7.84861222e-02f, 5.39839780e-03f, 7.09985942e-02f, 2.47870088e-02f,
  -4.34362553e-02f, -8.94772783e-02f, 5.25951646e-02f, 7.66926911e-03f, -1.94985438e-02f, -2.58263052e-02f, 1.23102227e-02f, 8.16603974e-02f, -4.92879897e-02f, -2.90173106e-02f,
  7.07977861e-02f, -1.05073228e-02f, -4.04599346e-02f, 2.83656530e-02f, -3.76591720e-02f, -6.77868649e-02f, 3.92812723e-03f, 5.76718105e-03f, -4.66778912e-02f, -2.73263827e-02f,
  1.13234244e-01f, 6.66670129e-02f, 1.00536048e-01f, -4.13463488e-02f, -2.49342360e-02f, 3.39904055e-02f, 1.01131515e-03f, 4.82763238e-02f, -1.63217355e-02f, 1.23152219e-01f,
  4.68848413e-03f, 1.12410389e-01f, 1.77274514e-02f, 1.03957327e-02f, -4.38228808e-02f, -1.60628691e-01f, -2.48329155e-02f, 6.48946548e-03f, 4.50306982e-02f, 6.96878806e-02f,
  5.66157401e-02f, -3.57352383e-02f, -9.33860540e-02f, -2.85892580e-02f, -1.31987119e-02f, 1.44792929e-01f, 1.06735351e-02f, 1.32884169e-02f, -3.62767791e-03f, 2.96954121e-02f,
  1.56310964e-02f, 9.41290781e-02f, 7.58226886e-02f, -4.59412076e-02f, 4.03556265e-02f, -4.44573835e-02f, 6.51328340e-02f, 5.00717163e-02f, 5.41586541e-02f, 3.99038233e-02f,
  6.35122433e-02f, -1.00545689e-01f, -5.66458479e-02f, -4.13129106e-02f, 4.61410284e-02f, 7.51631185e-02f, -6.61747456e-02f, -6.94061071e-02f, 1.16556631e-02f, -2.15314720e-02f,
  9.95429698e-03f, 6.65585026e-02f, 4.09948826e-02f, 9.90988463e-02f, 8.01133290e-02f, -3.44537199e-02f, -7.20047578e-02f, 1.00204840e-01f, -1.10603487e-02f, -1.36642205e-02f,
  -4.31135809e-03f, 7.44353160e-02f, 1.36221619e-03f, -5.78114204e-02f, -3.16890329e-02f, -3.59072536e-02f, 5.50896525e-02f, 3.92717831e-02f, 5.26958182e-02f, -6.31364733e-02f,
  5.73671125e-02f, 3.30798626e-02f, 4.25158925e-02f, -7.51766637e-02f, 4.24335971e-02f, 5.27742691e-02f, 6.41183257e-02f, -7.70972893e-02f, -2.73459814e-02f, -8.61116946e-02f,
  -4.61269543e-02f, 4.07973602e-02f, 2.00088434e-02f, -2.45546773e-02f, -7.50595331e-02f, -7.81316906e-02f, 5.82688749e-02f, -5.00205047e-02f, 5.18937856e-02f, 9.58462432e-03f,
  1.49538144e-02f, 7.95120969e-02f, 5.46405353e-02f, 5.71113005e-02f, -4.45383787e-02f, -4.63794842e-02f, 1.07577872e-02f, -2.38663945e-02f, 7.56295323e-02f, 8.44595507e-02f,
  5.53503372e-02f, 6.74793795e-02f, -1.96549986e-02f, -2.70035714e-02f, -7.41186813e-02f, 9.02287588e-02f, 7.17959851e-02f, 9.54168737e-02f, 7.00370446e-02f, -4.71374355e-02f,
  -7.04290494e-02f, -1.65408812e-02f, 7.59766847e-02f, 4.84327674e-02f, -7.72245973e-02f, 4.89159897e-02f, -1.15102204e-02f, -7.38693576e-04f, 2.11724658e-02f, 8.90990626e-03f,
  -1.54016048e-01f, -1.28839552e-01f, -2.39481062e-01f, -9.33771357e-02f, -8.99025649e-02f, -2.91464329e-01f, -1.63558736e-01f, -1.05692491e-01f, 1.31917775e-01f, 8.37368295e-02f,
  1.19368192e-02f, -4.03876491e-02f, 1.19071729e-01f, -2.14050964e-01f, -8.39395896e-02f, 2.85123475e-02f, -2.61660099e-01f, -6.23354465e-02f, -2.45919917e-02f, -1.62990510e-01f,
  -1.08114816e-01f, -6.58584908e-02f, -1.79435402e-01f, -5.34365922e-02f, -7.44752884e-02f, -5.61997704e-02f, 3.55716571e-02f, 1.38106514e-02f, -7.13825747e-02f, 2.07751207e-02f,
  -9.32792053e-02f, -6.45055100e-02f, 7.11858878e-03f, -5.95141239e-02f, -1.18033051e-01f, 3.13171372e-02f, -1.17049646e-02f, 5.28622344e-02f, -7.42019713e-02f, -2.45848820e-02f,
  2.95414962e-02f, -8.21909830e-02f, -6.47169203e-02f, 1.12434834e-01f, 1.39537612e-02f, -2.95347888e-02f, -5.18670157e-02f, 2.18763128e-02f, -7.22995698e-02f, -3.02342679e-02f,
  1.12416910e-03f, -2.86574978e-02f, -4.11568135e-02f, -2.62559857e-02f, -2.27836315e-02f, 5.04986197e-03f, 2.95968284e-03f, -5.41652851e-02f, -5.23966216e-02f, -8.01971778e-02f,
  -1.10688638e-02f, 3.17810252e-02f, 2.31037922e-02f, -3.33649889e-02f, 5.84389456e-02f, -5.34329424e-03f, 4.45831791e-02f, 2.78231744e-02f, -5.03235981e-02f, -4.14793901e-02f,
  -4.07390222e-02f, -5.09058870e-02f, -2.65837321e-03f, -1.02484174e-01f, -9.33229998e-02f, 5.49902022e-02f, -4.05606553e-02f, 6.76196665e-02f, 5.93605787e-02f, -5.86949512e-02f,
  -5.61128603e-03f, 5.66741936e-02f, -3.18919830e-02f, -1.27005475e-02f, -2.81473957e-02f, 2.10202187e-02f, -1.74267702e-02f, -9.39641520e-02f, 3.78694721e-02f, 4.78172414e-02f,
  -1.11980692e-01f, -8.30393136e-02f, 9.08321217e-02f, -6.06420599e-02f, -3.38324171e-04f, -9.58740264e-02f, 2.97130346e-02f, -1.00886866e-01f, -2.24576294e-02f, 3.16905715e-02f,
  4.15906720e-02f, 5.81689700e-02f, -1.02082603e-01f, 6.77312165e-02f, 8.78614560e-02f, -1.02957720e-02f, -3.95781100e-02f, 5.82330152e-02f, 1.21623687e-02f, 5.80045432e-02f,
  2.68281475e-02f, 5.39801456e-03f, -3.68937873e-03f, -3.11796106e-02f, 7.72418901e-02f, 5.09144925e-02f, -3.36023862e-03f, -6.84118047e-02f, 1.96336992e-02f, -1.38341794e-02f,
  9.40041989e-02f, -2.40321711e-01f, 1.27249435e-01f, 8.32782015e-02f, 2.11009502e-01f, 1.06582910e-01f, 3.27874981e-02f, -1.14587121e-01f, 1.70114879e-02f, -2.60120422e-01f,
  -8.45148936e-02f, 3.06296404e-02f, 1.21588737e-01f, -1.82596937e-01f, 1.93703637e-01f, -4.59804013e-02f, -1.39211133e-01f, -1.07601985e-01f, -3.38204391e-02f, -6.50622621e-02f,
  2.69266143e-02f, -1.83221892e-01f, 5.37256151e-02f, -2.83899933e-01f, -8.89164880e-02f, -2.60857008e-02f, -7.70301446e-02f, -6.98068365e-02f, -1.57013163e-01f, 2.33294554e-02f,
  3.10020819e-02f, -4.21191156e-02f, -2.68755034e-02f, -6.01989403e-02f, -1.56497899e-02f, 3.78526449e-02f, 2.59972289e-02f, 8.69674534e-02f, 5.23917452e-02f, 8.82655308e-02f,
  -7.17519149e-02f, 8.60306621e-03f, -7.05170929e-02f, 7.30583370e-02f, 9.68160760e-03f, 4.93854508e-02f, 9.45142210e-02f, -3.45284082e-02f, 7.23109543e-02f, 5.25924228e-02f,
  3.83638777e-02f, -3.98732424e-02f, 9.06768367e-02f, -5.35519943e-02f, 1.79229176e-03f, 4.98507656e-02f, 6.69714436e-02f, 2.69722082e-02f, -4.76549491e-02f, -4.19494733e-02f,
  -1.26147315e-01f, -7.50186667e-02f, 8.99208784e-02f, -2.13471125e-03f, 7.01486245e-02f, 1.42324539e-02f, 1.68501877e-03f, -4.53592166e-02f, 3.79272401e-02f, -5.24994582e-02f,
  5.35530970e-02f, -2.79181339e-02f, -5.55176809e-02f, 6.94019869e-02f, -4.72766608e-02f, 2.23880019e-02f, -3.56368795e-02f, 7.15931877e-02f, 8.60494561e-03f, 3.72622944e-02f,
  2.95504602e-03f, -3.88628431e-02f, 1.95087474e-02f, 9.98541862e-02f, 6.49578348e-02f, -9.03593563e-03f, -3.16255959e-03f, -4.60078334e-03f, -2.18203920e-03f, -4.93078530e-02f,
  -7.25273788e-02f, -2.64148206e-01f, -5.85979633e-02f, -2.20843460e-02f, -3.87358665e-02f, -9.35571641e-02f, -5.61227649e-03f, -4.46458198e-02f, -4.19288408e-03f, -5.75496443e-02f,
  -7.34769255e-02f, -3.80326174e-02f, 5.51289832e-03f, -2.28975471e-02f, -4.12313864e-02f, -3.98292504e-02f, 7.17792334e-03f, -4.67681512e-03f, -2.68463884e-03f, -5.02141304e-02f,
  -5.18466868e-02f, -4.80985716e-02f, 9.96020995e-03f, -8.43592882e-02f, -7.87749514e-02f, -2.82098297e-02f, -1.93448621e-04f, -4.97140735e-02f, -5.50039997e-03f, -6.76433891e-02f,
  -2.76184566e-02f, 1.23896981e-02f, 2.09023476e-01f, -3.24010551e-02f, -8.03556480e-03f, 7.37929437e-03f, 4.57326435e-02f, 1.06881060e-01f, -1.21974424e-02f, 1.66878253e-02f,
  -7.14804828e-02f, 6.60924613e-02f, 6.81458861e-02f, 1.77110247e-02f, 1.05346918e-01f, -1.00774296e-01f, -1.14805453e-01f, 6.63022846e-02f, 3.44965048e-02f, -9.49937552e-02f,
  -1.17074229e-01f, -1.33732259e-01f, 1.17925636e-01f, 4.72839847e-02f, 9.43682194e-02f, -6.25593439e-02f, -8.76461864e-02f, 9.13268700e-02f, -4.01272438e-02f, 1.65225361e-02f,
  -7.26104975e-02f, -7.04844715e-03f, 2.87045520e-02f, 1.29249245e-01f, 4.85344194e-02f, -5.62866405e-02f, -1.84981935e-02f, -1.68083038e-03f, -3.71012464e-02f, 5.69892153e-02f,
  4.46339957e-02f, 2.28622593e-02f, -1.01696374e-02f, 5.11947721e-02f, -5.31984074e-03f, 3.01426537e-02f, 2.70696767e-02f, 3.71372104e-02f, -2.99019422e-02f, 8.86884332e-02f,
  1.25175685e-01f, 8.46030414e-02f, -1.38390623e-02f, -7.14292005e-02f, -5.60069531e-02f, -6.13073036e-02f, -4.29718941e-02f, 1.03774555e-01f, -5.75014018e-02f, 2.89461091e-02f,
  1.07114807e-01f, 6.03195541e-02f, -8.17589164e-02f, -6.23017587e-02f, -1.94630902e-02f, 1.48518402e-02f, 4.27589454e-02f, 2.87744775e-02f, 5.26327863e-02f, 4.27090190e-02f,
  -2.51068678e-02f, -5.08297980e-03f, 3.88332978e-02f, 6.67535001e-03f, 6.14131279e-02f, 9.95748304e-03f, -5.81290945e-02f, -4.38808538e-02f, -9.28200409e-02f, 2.57409532e-02f,
  -4.73045669e-02f, 3.13578509e-02f, 2.41571665e-02f, -8.51782560e-02f, -5.76412454e-02f, -7.11319596e-02f, -2.05752440e-02f, 2.22032405e-02f, 5.86446561e-03f, 7.44380578e-02f,
  -5.30420244e-02f, 4.82352898e-02f, -8.73628333e-02f, 1.04689166e-01f, 2.05562450e-02f, 7.28851259e-02f, -7.40643591e-02f, -9.49517712e-02f, 2.20285654e-02f, 1.88098475e-02f,
  8.01280737e-02f, 1.81662589e-02f, 1.96061637e-02f, 6.13939343e-03f, -4.33754586e-02f, 3.66476574e-03f, -6.95457160e-02f, -3.06892172e-02f, 3.83775979e-02f, -6.54811878e-03f,
  1.18480939e-02f, -3.97999436e-02f, 1.04555465e-01f, -2.30181925e-02f, 7.10289553e-02f, -5.85099123e-02f, -6.27756864e-02f, -2.67582703e-02f, 8.85005072e-02f, -3.36058461e-03f,
  1.73719510e-01f, 9.94744673e-02f, 8.57316777e-02f, -3.45617495e-02f, -1.64240390e-01f, -1.50903895e-01f, -1.67228609e-01f, -9.77542549e-02f, 5.20677306e-02f, 1.59263477e-01f,
  -1.07949428e-01f, 3.59967440e-01f, -7.93383792e-02f, -5.31396493e-02f, -2.36343384e-01f, -7.53333792e-02f, -1.40063256e-01f, 5.05928956e-02f, -3.80039075e-03f, 9.58444923e-03f,
  -5.60479946e-02f, -2.63399869e-01f, -8.61203969e-02f, -1.56514883e-01f, -4.50746343e-02f, 5.40573522e-02f, -5.34886345e-02f, -9.58123580e-02f, 1.56159941e-02f, -1.03473276e-01f,
  -3.65656354e-02f, 1.25038862e-01f, 5.74289300e-02f, 1.65265203e-01f, -2.05955394e-02f, -7.23411962e-02f, 2.97507513e-02f, 6.06855494e-04f, 2.71242093e-02f, 3.74832936e-02f,
  7.02266842e-02f, 4.75815572e-02f, 2.25046538e-02f, 4.86555025e-02f, 9.57048833e-02f, 7.12829605e-02f, 7.87601992e-02f, 6.00932091e-02f, 1.07446477e-01f, 9.28554311e-02f,
  4.88184625e-03f, 1.17563121e-01f, -4.35523689e-03f, 8.61105621e-02f, -4.42869850e-02f, -9.82372835e-03f, -4.86882553e-02f, 6.51412085e-02f, 7.69447535e-02f, 6.03462085e-02f,
  -1.67375226e-02f, -4.23245272e-03f, 1.99879818e-02f, 4.62830104e-02f, 5.95667213e-02f, -1.52559942e-02f, 3.78717035e-02f, -2.99207550e-02f, -1.81661430e-03f, 5.17891422e-02f,
  -2.05609743e-02f, -9.80875175e-03f, -1.35348057e-02f, 3.62775549e-02f, 2.24788468e-02f, 3.66171054e-03f, 5.67855351e-02f, -7.12485760e-02f, 6.06968254e-02f, 1.53204100e-02f,
  -1.04676560e-02f, -1.05159730e-01f, 2.06648447e-02f, -5.23484051e-02f, -6.96018264e-02f, -2.58768220e-02f, 3.18782367e-02f, -2.90452242e-02f, -4.33555767e-02f, 3.03227473e-02f,
  -1.30091995e-01f, -8.88677239e-02f, 8.48269612e-02f, 1.15984874e-02f, 4.62646484e-02f, 4.61581163e-02f, -2.70785764e-02f, 3.47381569e-02f, 2.19115373e-02f, -4.82342616e-02f,
  2.96800584e-02f, -8.25542212e-03f, 1.27250161e-02f, -7.97752757e-03f, -7.39148781e-02f, -9.48568806e-02f, -4.49115746e-02f, 2.38083284e-02f, 5.26734442e-02f, -1.12275826e-03f,
  9.88159999e-02f, 5.36222495e-02f, -3.13117951e-02f, -3.19850780e-02f, -5.37145287e-02f, 3.15428190e-02f, -1.20542375e-02f, -3.47801037e-02f, 5.93517534e-02f, 5.51583283e-02f,
  1.36898542e-02f, -1.65406056e-02f, -2.16706306e-01f, -1.63783595e-01f, -3.10192555e-02f, -9.56188589e-02f, 3.53671610e-02f, -2.92134229e-02f, -1.29975140e-01f, 7.44778663e-03f,
  7.43245110e-02f, 7.73896724e-02f, 1.39043346e-01f, -4.42637280e-02f, -7.58481398e-03f, 1.76220015e-01f, -2.17790082e-02f, 2.25878996e-03f, -3.16766812e-03f, -3.64739187e-02f,
  -1.44899879e-02f, 8.53226706e-02f, 5.16676642e-02f, -4.92590107e-02f, -1.03613734e-02f, 1.78371370e-02f, 7.98288286e-02f, -8.67624581e-02f, -9.18624997e-02f, -5.58766760e-02f,
  -7.93116167e-03f, 1.12133555e-01f, 1.29758520e-02f, 4.18621227e-02f, 4.75220531e-02f, 1.06092095e-01f, -2.47087982e-02f, 4.18661200e-02f, -1.04627006e-01f, 5.95027097e-02f,
  9.12971571e-02f, -3.62087078e-02f, -1.65503006e-02f, -2.22991277e-02f, -3.79007719e-02f, -1.27510831e-01f, -1.14137098e-01f, -3.63574103e-02f, -1.16209835e-02f, 7.71773010e-02f,
  -9.11711529e-02f, 3.93738188e-02f, 2.16171555e-02f, -9.00110696e-03f, 1.33158090e-02f, -6.52398840e-02f, -5.34161963e-02f, -6.66880533e-02f, 6.96819350e-02f, -6.55022189e-02f,
  -2.39851810e-02f, 5.22693284e-02f, -1.49612697e-02f, 7.85841048e-02f, -3.04780081e-02f, 1.71213876e-02f, 5.68430014e-02f, -7.81025589e-02f, -2.56109145e-02f, -4.38188016e-02f,
  4.08173874e-02f, 3.09658721e-02f, 1.02294631e-01f, -3.61506157e-02f, -2.12687850e-02f, -4.51368503e-02f, -5.52396439e-02f, 1.64960828e-02f, 3.60091180e-02f, 7.80364051e-02f,
  2.97712698e-03f, -7.93430656e-02f, -5.68834320e-03f, 4.73644026e-02f, 1.09500894e-02f, -8.99586305e-02f, 7.71599934e-02f, 3.58825289e-02f, -3.32209282e-02f, -3.65729779e-02f,
  2.08292063e-02f, 4.37312499e-02f, -1.17687203e-01f, -2.67588235e-02f, 1.62022952e-02f, -5.22213019e-02f, 6.95138797e-02f, 2.69105174e-02f, -4.75616381e-02f, -1.03491485e-01f,
  -9.56730917e-02f, -5.04772589e-02f, -8.00113603e-02f, -1.84274558e-02f, -3.82932201e-02f, -2.29797792e-02f, 4.25921232e-02f, -3.40186246e-02f, -7.71561563e-02f, -4.02775407e-02f,
  -3.60575989e-02f, 8.05366598e-03f, -1.05660623e-02f, 6.37809560e-03f, 6.21222481e-02f, -6.80633113e-02f, 5.77755123e-02f, 2.91676819e-02f, 6.43192679e-02f, -4.30946201e-02f,
  -1.21631371e-02f, 1.00059174e-01f, 1.93704776e-02f, 5.55517003e-02f, -7.96093196e-02f, -1.66554630e-01f, -4.03160080e-02f, -8.26273710e-02f, 6.32219240e-02f, 4.81150784e-02f,
  7.44442968e-03f, 2.23520100e-02f, -9.83905979e-03f, 1.01507917e-01f, 2.95044966e-02f, 2.68201753e-02f, -3.66444327e-02f, -9.02634189e-02f, 4.69352491e-02f, 9.60229188e-02f,
  3.15848775e-02f, 2.58532446e-02f, 5.04143462e-02f, -3.64213921e-02f, -5.09369671e-02f, 2.67103612e-02f, 2.46195700e-02f, 5.62526062e-02f, 1.36075169e-01f, -6.24351650e-02f,
  4.94349040e-02f, 1.37840107e-01f, -5.44461198e-02f, 6.07296228e-02f, 2.00500693e-02f, 1.61773600e-02f, 3.47934142e-02f, 7.29479045e-02f, 2.51701716e-02f, 2.60647405e-02f,
  -1.72588993e-02f, 6.22203089e-02f, 3.95704992e-02f, -4.56602350e-02f, -4.95649576e-02f, 9.92285162e-02f, -1.01555921e-02f, -1.63568240e-02f, 9.48592499e-02f, -3.27129290e-02f,
  2.21072789e-02f, 9.29255132e-03f, 8.35370421e-02f, -6.48368299e-02f, -5.92555441e-02f, 6.56675920e-02f, -1.11391291e-03f, 1.09933294e-01f, 9.81038213e-02f, -5.28336279e-02f,
  1.04825556e-01f, -4.20839116e-02f, 2.28173882e-02f, -7.82473832e-02f, 1.31755508e-02f, -5.17702475e-02f, -1.48877557e-02f, 4.38172892e-02f, 7.94074759e-02f, -1.04859136e-02f,
  -6.97101057e-02f, 2.84299199e-02f, -8.46760999e-03f, 4.51067574e-02f, 2.79035140e-03f, 9.03262645e-02f, 4.23510633e-02f, 1.54467430e-02f, -6.20895363e-02f, 4.95840535e-02f,
  -2.56501622e-02f, -6.38210624e-02f, -6.92647183e-03f, 7.39300326e-02f, 5.79423681e-02f, -5.70194498e-02f, 1.23749431e-02f, 7.75905922e-02f, -1.62768755e-02f, -6.63432479e-02f,
  7.67837688e-02f, 1.23000696e-01f, -2.00710655e-03f, 8.05269107e-02f, -3.17526683e-02f, -1.70708727e-02f, 9.94558558e-02f, 2.94282157e-02f, 7.52881095e-02f, 3.73091623e-02f,
  9.61721987e-02f, -1.79513022e-02f, -5.29803336e-02f, 1.96984503e-02f, 2.32727379e-02f, 2.79121902e-02f, 9.33080018e-02f, -5.12713902e-02f, -1.89995393e-02f, 1.07783619e-02f,
  1.11177368e-02f, -8.01787805e-03f, 6.60563335e-02f, 5.93190789e-02f, -5.23441564e-03f, -3.06161214e-03f, -4.37410921e-03f, -6.05814084e-02f, -4.17683050e-02f, 1.83994509e-02f,
  1.54879957e-01f, -3.25084686e-01f, -3.95682603e-02f, 1.35357946e-01f, 2.37178996e-01f, 5.99307790e-02f, -2.88831815e-02f, -1.09585151e-01f, -2.51643509e-02f, -2.10718647e-01f,
  -5.63514009e-02f, 7.90323876e-03f, -2.38327324e-01f, 1.11086510e-01f, 2.80598760e-01f, -3.19160968e-02f, 7.90105388e-02f, 8.90775863e-03f, -3.80462296e-02f, -7.63475969e-02f,
  6.98023289e-02f, 1.82721719e-01f, 2.55372599e-02f, 2.60975100e-02f, 7.88644105e-02f, -3.46552096e-02f, 1.04402579e-01f, -4.31623831e-02f, 1.34177133e-01f, 1.15549847e-01f,
  1.08737551e-01f, -1.15886787e-02f, 4.78165783e-02f, 8.35065171e-02f, -6.44570887e-02f, -4.44641113e-02f, 2.11369079e-02f, 7.95798935e-03f, 1.06429003e-01f, 5.26486617e-03f,
  -3.46837305e-02f, 6.46676123e-02f, 1.16058819e-01f, 5.97199462e-02f, 2.53962446e-02f, 6.22349493e-02f, 5.61723020e-04f, 1.62339788e-02f, -2.82888245e-02f, -2.11298969e-02f,
  -2.63056979e-02f, -5.87989278e-02f, -3.83111611e-02f, -5.76298572e-02f, -5.02628163e-02f, -1.69965681e-02f, -1.52436094e-02f, -9.13156047e-02f, -4.96340096e-02f, 5.13975397e-02f,
  1.67181976e-02f, 8.81271958e-02f, -1.03745490e-01f, -2.08065435e-02f, 1.20966937e-02f, 4.99388613e-02f, 4.13800329e-02f, -1.11139290e-01f, -3.90093997e-02f, -3.19008231e-02f,
  -1.82448104e-02f, -2.15728488e-02f, 1.40816579e-03f, -2.50975415e-03f, 4.04207334e-02f, 1.08440015e-02f, 1.05049536e-01f, 2.99726184e-02f, -9.99805257e-02f, -6.09518588e-02f,
  7.37001747e-02f, -3.01005375e-02f, 2.96393386e-03f, -7.35466462e-03f, 4.41107489e-02f, 7.76528148e-03f, -5.24838045e-02f, -7.07327873e-02f, -2.58274022e-02f, -1.17764240e-02f,
  -1.47328526e-01f, -2.67747670e-01f, -9.05647874e-02f, -5.83040854e-03f, -1.19681783e-01f, 3.61724347e-02f, 4.75716144e-02f, 5.02561368e-02f, -7.06967339e-02f, 2.48493184e-03f,
  3.25164641e-03f, 1.08800195e-02f, 3.15034278e-02f, -1.23967119e-02f, 3.71305421e-02f, 6.84115803e-03f, 4.11703140e-02f, 5.85742295e-02f, 3.60042974e-02f, -4.60656993e-02f,
  -3.10101565e-02f, -3.65168527e-02f, -9.57950111e-03f, -2.65922304e-02f, -3.63121778e-02f, -4.11135331e-02f, -1.21920295e-02f, -5.99700622e-02f, -2.25827866e-03f, -4.68311943e-02f,
  2.14027882e-01f, 5.65264560e-02f, 4.08760570e-02f, 2.24378720e-01f, 3.73504311e-02f, -1.91858076e-02f, -1.12276711e-01f, -4.71521392e-02f, -9.01101753e-02f, -2.20495835e-02f,
  -9.44141820e-02f, 1.76090211e-01f, -2.81395376e-01f, 6.23049811e-02f, 1.55371139e-02f, -1.55191734e-01f, -3.36885899e-02f, 8.41739103e-02f, -1.00372983e-02f, 3.27002108e-02f,
  -6.22771196e-02f, -5.00692539e-02f, -4.93134744e-03f, 5.25734648e-02f, 1.50384843e-01f, 1.51591793e-01f, -4.00636252e-03f, -1.29149109e-01f, 1.52311593e-01f, -2.63405088e-02f,
  6.43168986e-02f, 3.83844115e-02f, 7.01687410e-02f, 7.44536668e-02f, -2.02270821e-02f, -2.12059654e-02f, 1.61726028e-02f, 8.12953711e-02f, 5.10202199e-02f, -3.69613096e-02f,
  5.54508418e-02f, 9.23873112e-02f, 1.41319141e-01f, 9.41234455e-03f, 2.35178899e-02f, -2.28314268e-04f, 1.27139822e-01f, -9.35771782e-03f, 3.89092602e-02f, 2.61901375e-02f,
  1.05597213e-01f, -3.67283486e-02f, -7.49116167e-02f, -6.51209289e-03f, 2.13940884e-03f, 5.26850950e-03f, 1.03272825e-01f, 7.98277333e-02f, -3.49776782e-02f, 5.88532686e-02f,
  1.59814637e-02f, -9.37181339e-02f, -2.22906340e-02f, -5.03371023e-02f, -1.52645372e-02f, 2.19470989e-02f, 2.55657285e-02f, 9.19362716e-03f, -6.45991340e-02f, -6.59699664e-02f,
  1.34540023e-02f, -2.79129967e-02f, 2.19560675e-02f, -7.00937659e-02f, 4.81242612e-02f, -6.48471410e-04f, 7.21030124e-03f, -5.32447882e-02f, 8.15882757e-02f, 1.91208068e-02f,
  1.88630763e-02f, 6.62467927e-02f, 5.65731861e-02f, 3.60587649e-02f, -5.59988804e-02f, 4.83862720e-02f, 3.36702503e-02f, -1.82095859e-02f, -5.66891022e-02f, -4.24238574e-03f,
  -5.88901080e-02f, -1.78271666e-01f, 1.15871625e-02f, 7.89168850e-02f, 3.86516191e-02f, 6.92653880e-02f, -8.69303884e-04f, 1.40064061e-02f, -7.16259405e-02f, -3.12061738e-02f,
  6.93600327e-02f, -7.05214068e-02f, -7.69215003e-02f, -5.79251647e-02f, 6.95925113e-03f, 2.64876503e-02f, -1.78140588e-02f, 1.24998074e-02f, 1.91689637e-02f, 5.56825772e-02f,
  -1.94108933e-02f, 9.11355093e-02f, 4.51110005e-02f, 9.82157812e-02f, 7.37731382e-02f, 2.56945007e-02f, 3.47701162e-02f, -6.87335655e-02f, 2.59540547e-02f, 5.55336699e-02f,
  1.67973578e-01f, -3.44447494e-01f, -3.72857414e-02f, 1.42860204e-01f, 1.84142634e-01f, 1.02287129e-01f, 2.26148948e-01f, -5.43363690e-02f, -1.48104429e-01f, -2.48225853e-01f,
  1.00652665e-01f, 3.06858197e-02f, -7.12625012e-02f, 5.91806360e-02f, 1.93411082e-01f, -9.63359997e-02f, -2.01453175e-02f, 9.49911848e-02f, -1.10787980e-01f, -8.23648199e-02f,
  4.89177555e-02f, 4.51378375e-02f, 5.58845140e-02f, -3.56824929e-03f, 2.25630905e-02f, -1.13134317e-01f, 4.50909100e-02f, 6.19605258e-02f, 1.43065289e-01f, 9.65668336e-02f,
  -3.01291305e-03f, -1.20737381e-01f, -6.03284575e-02f, -2.46346947e-02f, -2.26932415e-03f, -1.28866928e-02f, -3.11853308e-02f, 8.45534503e-02f, 6.36232421e-02f, -9.56066698e-02f,
  7.58994743e-02f, -4.02804203e-02f, -3.70578505e-02f, -5.57796992e-02f, 4.53714607e-03f, 1.23932387e-03f, 7.68000782e-02f, -2.40543042e-03f, 4.44217250e-02f, -4.09176163e-02f,
  -2.68446747e-04f, 2.43489444e-02f, 6.86157793e-02f, -1.04885465e-02f, -5.02127130e-03f, -2.74793785e-02f, -1.76006258e-02f, 7.82727376e-02f, 1.66254379e-02f, -6.83324188e-02f,
  9.76018235e-02f, -1.33000705e-02f, 6.30840287e-02f, 6.32609054e-02f, 7.02887625e-02f, 3.46657671e-02f, 8.85757152e-03f, 1.03024267e-01f, -5.18424064e-02f, -1.32263405e-02f,
  -4.11641486e-02f, -4.71564010e-03f, -7.78127983e-02f, 4.60928194e-02f, 3.69888395e-02f, -3.52086388e-02f, -1.32474313e-02f, 1.06076216e-02f, -1.22968487e-01f, -8.82160384e-03f,
  1.06922397e-02f, 4.25505862e-02f, -6.72242865e-02f, 8.39250535e-02f, 8.11358448e-03f, -8.93587992e-03f, -5.85150067e-03f, -4.19417098e-02f, 5.00297584e-02f, 6.54620081e-02f,
  -1.79957420e-01f, -2.14293465e-01f, -7.17257783e-02f, -1.02352276e-02f, 4.64397809e-03f, -1.02977365e-01f, -3.92143242e-02f, -7.64570683e-02f, -8.96232501e-02f, 4.70147096e-02f,
  -3.85022908e-02f, 4.65982631e-02f, 9.86143202e-03f, -2.82100588e-02f, -4.34708260e-02f, -1.08654685e-01f, -7.48560503e-02f, -7.32679889e-02f, -9.68934819e-02f, 1.39634253e-03f,
  -4.04004976e-02f, 1.58786755e-02f, 2.37107929e-02f, 1.61094125e-02f, 6.31955191e-02f, 7.35283569e-02f, 1.51121700e-02f, 5.46423905e-02f, -6.07828237e-03f, -7.89597351e-03f,
  1.93951968e-02f, 6.75762519e-02f, 1.52678981e-01f, -9.85025167e-02f, -6.22954294e-02f, -3.48271690e-02f, -1.16186500e-01f, -1.21862993e-01f, -6.49863482e-02f, -6.45569563e-02f,
  -1.76455423e-01f, 1.82919443e-01f, -1.39645282e-02f, -7.26326779e-02f, -4.04612608e-02f, -7.08045065e-02f, -1.10077374e-01f, 3.12672146e-02f, 9.04103667e-02f, 5.71406027e-03f,
  3.41932401e-02f, -2.94397026e-02f, 9.45144594e-02f, -5.20985313e-02f, -4.21072841e-02f, 6.83889017e-02f, 5.35013825e-02f, 3.92497070e-02f, -1.67433601e-02f, 7.60865659e-02f,
  1.43746492e-02f, 4.45874743e-02f, -2.41261348e-02f, 1.27059147e-02f, -4.70289700e-02f, 5.27512692e-02f, 1.37972683e-01f, -2.25915387e-02f, 3.26973647e-02f, 6.08081296e-02f,
  9.23383757e-02f, -6.05959184e-02f, 2.88955923e-02f, 4.45714146e-02f, -5.31846583e-02f, -5.07321618e-02f, 1.02758221e-01f, 1.22233339e-01f, 6.42847940e-02f, 1.03579663e-01f,
  9.80530083e-02f, 1.19504206e-01f, -4.18005437e-02f, 3.89705710e-02f, -4.42364886e-02f, -6.11579269e-02f, -7.35634342e-02f, 9.68759730e-02f, -6.69830218e-02f, -6.19404688e-02f,
  -9.76123475e-03f, -1.00458123e-01f, -2.89141405e-02f, 4.03784364e-02f, -3.73833366e-02f, 4.18813415e-02f, -1.86842552e-03f, 2.44253385e-03f, -6.66248053e-02f, 1.34572955e-02f,
  -3.91241908e-02f, -3.91974896e-02f, -9.37747434e-02f, 2.97636800e-02f, -7.40105361e-02f, -6.58538863e-02f, 4.12062593e-02f, -2.30904352e-02f, -9.67470370e-03f, 9.81920883e-02f,
  1.99741069e-02f, 8.14603791e-02f, -4.11879411e-03f, -1.48907546e-02f, -1.86752051e-03f, 9.64609981e-02f, -5.91430962e-02f, -4.89515290e-02f, -6.72551021e-02f, -3.12937312e-02f,
  -1.51956938e-02f, -8.70138556e-02f, -2.97753252e-02f, 6.39879778e-02f, -5.21479771e-02f, -5.70876859e-02f, -5.01966476e-02f, 4.15671431e-03f, -1.30458511e-02f, -5.40616214e-02f,
  -8.90684387e-05f, 1.53051978e-02f, -4.51696105e-02f, 5.65585941e-02f, 5.94404265e-02f, 8.80772434e-03f, -7.53905699e-02f, 3.08990926e-02f, 2.72208415e-02f, 1.27958637e-02f,
  -1.94268636e-02f, -2.43497267e-02f, -1.83958020e-02f, -6.49802461e-02f, 7.74225742e-02f, 2.14595832e-02f, -4.39937934e-02f, 1.84233878e-02f, -2.19831355e-02f, -6.79436605e-03f,
  -8.19578692e-02f, -5.73613681e-02f, -2.76682097e-02f, -8.93743262e-02f, 4.39986400e-02f, 1.79386605e-02f, -5.33859394e-02f, -2.70732529e-02f, -1.96679950e-01f, -1.25788212e-01f,
  -1.07720815e-01f, 2.86757611e-02f, -1.92480534e-02f, 1.88739654e-02f, 2.14385465e-01f, 8.05587247e-02f, -8.76199678e-02f, -4.84152660e-02f, 5.42585775e-02f, -1.43364340e-01f,
  -7.08946586e-02f, -3.91967893e-02f, 3.45185474e-02f, -2.58226320e-02f, -2.84670088e-02f, -4.85196933e-02f, 2.09762678e-02f, 1.79745611e-02f, -3.72721814e-02f, 1.19245365e-01f,
  -7.18398839e-02f, 1.93710253e-02f, 7.01946765e-02f, -1.46538736e-02f, -2.04299949e-02f, -2.05269153e-03f, -3.17182727e-02f, 1.05733208e-01f, -5.99329472e-02f, -7.54748611e-03f,
  1.33244367e-02f, 5.86473122e-02f, -8.28209296e-02f, -3.15728001e-02f, -9.38141942e-02f, -1.94882713e-02f, -5.52256666e-02f, -2.12944075e-02f, -9.57137197e-02f, 5.41356243e-02f,
  2.90219933e-02f, -7.78400376e-02f, -9.56900865e-02f, 6.34474074e-03f, 7.47213215e-02f, -9.33813974e-02f, 6.81275129e-02f, 4.31559142e-03f, 5.07730655e-02f, 8.80190432e-02f,
  6.61895722e-02f, -3.50690819e-02f, -7.21675679e-02f, 3.69169451e-02f, 4.98671010e-02f, -7.08361641e-02f, 1.94145192e-03f, -5.89483157e-02f, -3.10256016e-02f, -8.06539599e-03f,
  3.95196378e-02f, -2.52854135e-02f, -2.79521663e-02f, 4.91503999e-02f, 8.79777148e-02f, -1.89886149e-02f, 7.73808658e-02f, -1.29367178e-02f, 3.65442317e-03f, 5.60168289e-02f,
  -6.27799109e-02f, -7.36383051e-02f, 7.49057829e-02f, -5.68178929e-02f, -2.91602239e-02f, 2.60991789e-02f, 2.64789313e-02f, 5.31809554e-02f, 3.12893908e-03f, -5.54224178e-02f,
  -9.68472809e-02f, -1.04476683e-01f, 1.52516998e-02f, 2.46583745e-02f, 7.68020898e-02f, 1.12765625e-01f, 3.84738371e-02f, -6.72468217e-03f, 6.07228316e-02f, -5.89877851e-02f,
  -2.76405495e-02f, 4.13609901e-03f, -5.08340523e-02f, -1.55854123e-02f, 6.16637692e-02f, 1.29095903e-02f, -4.49332558e-02f, -5.98708093e-02f, 7.10582063e-02f, -3.38553451e-04f,
  -1.60796773e-02f, -5.41639328e-03f, 8.05385187e-02f, -5.59454039e-02f, -2.44651455e-02f, -6.22554123e-02f, -1.69106498e-02f, -4.94277403e-02f, -6.83254078e-02f, 6.69577345e-02f,
  -1.23320529e-02f, 3.68904732e-02f, 6.40797764e-02f, 1.35495455e-03f, -5.53296553e-03f, -6.73086196e-02f, -1.43400714e-01f, 5.99268377e-02f, -1.47523612e-01f, -9.03597772e-02f,
  9.95543450e-02f, -1.78781990e-02f, -4.78444993e-02f, -1.09290905e-01f, 1.07501246e-01f, -6.85426742e-02f, 4.91463207e-02f, 3.82411554e-02f, 4.10497934e-02f, 6.91715106e-02f,
  1.18598059e-01f, 5.11474870e-02f, 2.03232467e-01f, 1.35898843e-01f, 9.48579144e-03f, 1.39928371e-01f, 2.29365855e-01f, 1.07611857e-01f, 1.23201959e-01f, 6.34298101e-02f,
  1.17283016e-02f, 1.82687975e-02f, 3.42784859e-02f, -4.08808738e-02f, -4.50849067e-03f, 5.59969693e-02f, -5.71912676e-02f, -6.73606172e-02f, 1.00131882e-02f, 3.37753706e-02f,
  1.90962153e-03f, 2.40043830e-02f, 2.35278457e-02f, -5.89494705e-02f, 5.78485103e-03f, 7.02293962e-02f, 1.63648166e-02f, -4.99952137e-02f, -2.88869645e-02f, 6.51686192e-02f,
  8.67845584e-03f, 1.38616785e-02f, -7.24915415e-02f, 2.72533949e-02f, 2.19721086e-02f, 6.54855818e-02f, 8.75998810e-02f, -6.78646639e-02f, -7.12476224e-02f, 8.79636407e-02f,
  -8.64736140e-02f, 2.45167222e-02f, -1.62061621e-02f, -2.74655484e-02f, 2.32469160e-02f, 6.37585446e-02f, 2.23109424e-02f, -3.22346240e-02f, -2.93688774e-02f, 5.68378009e-02f,
  -5.35528623e-02f, 4.27488461e-02f, 2.64126733e-02f, 1.65024623e-02f, -6.14964627e-02f, -8.52844641e-02f, -5.81630282e-02f, -7.77159035e-02f, 4.15651873e-02f, -5.48452735e-02f,
  3.46220955e-02f, 1.70281641e-02f, -1.08526449e-03f, 5.80278710e-02f, -3.08655854e-02f, -7.07402639e-03f, -2.23631691e-02f, -5.78964967e-03f, 3.19314040e-02f, 1.17899232e-01f,
  -4.30583134e-02f, 2.31765974e-02f, -4.03606519e-02f, -4.76946123e-02f, -3.05440370e-03f, -6.98518977e-02f, -5.45022041e-02f, -2.59537133e-03f, -6.04487881e-02f, -7.04523474e-02f,
  5.59494346e-02f, 4.16622460e-02f, -8.58749636e-03f, 6.20316528e-02f, -3.79583761e-02f, 6.67328387e-02f, -5.44881895e-02f, -6.38718978e-02f, -1.39018372e-02f, 4.50727753e-02f,
  1.12495590e-02f, 6.81051426e-03f, -3.69683206e-02f, 1.19428979e-02f, 5.85929528e-02f, 7.61224553e-02f, 1.09667024e-02f, 2.30632466e-03f, 6.27496466e-02f, -6.89421082e-03f,
  -3.12469542e-01f, 1.26018018e-01f, 7.08552822e-02f, -2.66146004e-01f, 9.38461125e-02f, -8.69955048e-02f, -5.40150553e-02f, 1.02916293e-01f, -1.02464072e-01f, 2.07604151e-02f,
  5.46955056e-02f, -1.58879384e-02f, 8.35023448e-02f, -6.01347163e-02f, -2.03109667e-01f, -6.78963661e-02f, -1.10667348e-01f, -2.93271546e-03f, 2.13494319e-02f, 3.21952179e-02f,
  -4.45633894e-03f, -2.75453441e-02f, 1.66206155e-02f, 2.35945135e-01f, 4.01995853e-02f, -2.35551270e-03f, -2.11753044e-02f, 1.93577215e-01f, -3.66994999e-02f, -3.37481722e-02f,
  -1.32277116e-01f, -1.19147435e-01f, -3.08021475e-02f, 2.79406924e-02f, -9.47638601e-03f, 6.70653358e-02f, -1.52231762e-02f, -3.74750905e-02f, -2.63746176e-02f, -2.00267397e-02f,
  4.03701663e-02f, 4.82540801e-02f, 6.19539581e-02f, 9.81812105e-02f, -6.09278940e-02f, 6.16417155e-02f, 9.12795216e-02f, -1.44807147e-02f, 6.34428561e-02f, 5.51251844e-02f,
  7.20622167e-02f, 2.06302386e-02f, -4.16257456e-02f, 4.72776070e-02f, -7.94922188e-02f, 5.85913323e-02f, -1.16863765e-01f, -9.55023170e-02f, 5.66614745e-03f, -4.60717082e-02f,
  9.30581391e-02f, -8.78662243e-02f, 2.75884196e-02f, -3.12077031e-02f, -3.75563726e-02f, -6.71800822e-02f, 3.50865023e-03f, -8.39625970e-02f, 2.15951372e-02f, 7.31064901e-02f,
  6.59699785e-03f, -5.30383587e-02f, 6.95659369e-02f, -1.24913978e-03f, -2.33459417e-02f, -1.39322598e-03f, -3.52896564e-03f, 5.58502078e-02f, -3.78160700e-02f, 1.96546745e-02f,
  -4.58229631e-02f, 4.87296581e-02f, 2.38504424e-03f, 2.47153882e-02f, -5.18366210e-02f, 1.14211664e-02f, 5.12685552e-02f, 2.63318531e-02f, 6.85941651e-02f, -3.98922758e-03f,
  -2.16233218e-03f, -1.40676394e-01f, 4.08205613e-02f, 2.08450761e-02f, 2.08865255e-02f, -5.73214963e-02f, 4.75555137e-02f, 4.94149588e-02f, -4.93105911e-02f, -1.36199864e-02f,
  2.16309773e-03f, 1.39180887e-02f, -7.62825236e-02f, -9.52064618e-02f, -4.89699617e-02f, -1.21278457e-01f, -5.07321618e-02f, -3.98195051e-02f, -8.39876086e-02f, 7.10235834e-02f,
  -5.82574531e-02f, -2.31613964e-02f, -3.77566777e-02f, -4.52552624e-02f, 4.41666916e-02f, -8.32750127e-02f, -8.34697261e-02f, 3.71596664e-02f, -6.48533031e-02f, -4.89818044e-02f,
  2.55727470e-01f, 1.19341783e-01f, 3.19480956e-01f, 4.31313902e-01f, 5.65273948e-02f, -2.50012368e-01f, -6.71133175e-02f, 1.03160694e-01f, 3.19053054e-01f, -1.95625678e-01f,
  -4.50889692e-02f, 9.24861357e-02f, -4.76107858e-02f, 8.10700580e-02f, -9.91267487e-02f, -3.77004445e-02f, 8.36960077e-02f, 1.07344212e-02f, 8.23199451e-02f, 1.27024740e-01f,
  2.19677195e-01f, -1.04876705e-01f, 1.44356743e-01f, -1.02327049e-01f, 1.38610348e-01f, 1.28683060e-01f, -2.76350882e-02f, -4.36274521e-02f, 3.44818830e-02f, -1.86944246e-01f,
  -2.54096836e-02f, 1.91276550e-01f, 4.86518182e-02f, 3.04890927e-02f, 1.09530516e-01f, -8.59546959e-02f, -8.69728550e-02f, -1.09284379e-01f, 5.09693995e-02f, -6.44283071e-02f,
  -9.81371757e-03f, -1.15312755e-01f, 1.63851883e-02f, -2.22062115e-02f, 1.01044327e-01f, 9.97153670e-02f, 8.44587013e-02f, 1.69019848e-01f, 8.39849785e-02f, 4.61088866e-02f,
  9.66977701e-02f, 1.86292008e-02f, 9.06184167e-02f, -1.81340892e-02f, 3.14960722e-03f, 5.56190647e-02f, -3.20361033e-02f, -3.26179713e-02f, -4.05411832e-02f, -9.48887784e-03f,
  2.61568534e-03f, 3.59803215e-02f, -3.65217067e-02f, 4.91173891e-03f, -3.46846692e-02f, 2.67015174e-02f, 3.82525660e-02f, -5.15860878e-02f, 2.02300064e-02f, -4.36017327e-02f,
  5.60894888e-03f, 4.39040503e-03f, -1.73553247e-02f, 1.87450834e-02f, 3.70402746e-02f, -3.67453024e-02f, -2.65176538e-02f, 2.79300828e-02f, 9.30965692e-02f, 8.41443986e-02f,
  -2.24524736e-02f, -3.81080806e-02f, -7.91082345e-03f, -9.64391045e-03f, -5.26556969e-02f, 1.60114188e-02f, 2.76652873e-02f, 4.23568487e-02f, 7.12605566e-02f, 5.44285141e-02f,
  -4.40090075e-02f, -3.82599570e-02f, 4.06731926e-02f, -9.08579398e-03f, -6.73243254e-02f, 2.16161963e-02f, -4.47066836e-02f, -2.98369434e-02f, -1.45520215e-04f, 4.03322615e-02f,
  -2.50114296e-02f, 5.82152605e-02f, -3.62208821e-02f, -4.65195114e-03f, -7.80598223e-02f, 1.27551369e-02f, -1.03347143e-02f, -1.07484847e-01f, -2.95850411e-02f, -2.88364179e-02f,
  -6.73772395e-02f, -5.90410233e-02f, 1.36905648e-02f, 4.05915529e-02f, -7.39344358e-02f, -8.51774439e-02f, -6.83869720e-02f, 1.77716618e-04f, -2.30327602e-02f, 7.91888626e-04f,
  2.28363723e-01f, -4.26207483e-02f, 2.06680223e-02f, 1.31406352e-01f, -4.59958464e-02f, -1.21337101e-01f, -5.86764477e-02f, 1.04812577e-01f, -1.19272158e-01f, 4.51111719e-02f,
  1.71937406e-01f, 1.30402043e-01f, -1.12206861e-03f, 2.13820979e-01f, 1.68735385e-01f, -6.27054945e-02f, 1.28538772e-01f, 8.03308785e-02f, 5.84863797e-02f, 1.70525238e-01f,
  1.36086076e-01f, 2.01074630e-01f, 2.13064015e-01f, 6.36910871e-02f, 6.26666471e-02f, 1.70105681e-01f, 3.50569226e-02f, -4.53470498e-02f, 1.59784973e-01f, 6.22552074e-03f,
  -6.25615492e-02f, -3.45588289e-02f, 6.89568929e-03f, -1.83950700e-02f, 8.04067031e-02f, -4.12339047e-02f, -8.96002948e-02f, -6.02675304e-02f, 7.61370286e-02f, 5.54416999e-02f,
  -1.28832132e-01f, 5.92744239e-02f, 4.04607430e-02f, -1.75258927e-02f, 8.57327424e-04f, 5.26770540e-02f, 3.68761048e-02f, 3.85976247e-02f, -3.19702774e-02f, 8.81915465e-02f,
  -7.72160478e-03f, 4.14678827e-02f, 3.75510566e-02f, -1.03537671e-01f, -2.92271208e-02f, -4.99573689e-05f, -1.26881525e-02f, 5.68630397e-02f, 4.55517285e-02f, 1.90551840e-02f,
  9.04007852e-02f, -7.67044872e-02f, -8.41097347e-03f, -5.52666076e-02f, -3.16328295e-02f, 3.35569377e-03f, -6.59087151e-02f, 1.08253751e-02f, 4.23222780e-02f, 6.64160997e-02f,
  6.43021464e-02f, -1.27289826e-02f, 1.73741300e-02f, -7.11637456e-03f, -7.21079931e-02f, -7.92652071e-02f, -4.29759882e-02f, 5.32273091e-02f, 5.43439426e-02f, 1.24678211e-02f,
  -9.47155356e-02f, 1.17310439e-03f, -5.73914833e-02f, 4.14865091e-03f, 7.31972754e-02f, -2.19035521e-02f, -4.58831340e-02f, 3.47822532e-02f, -5.71446680e-02f, -3.55824246e-03f,
  1.42029272e-02f, 1.03308357e-01f, 1.10968344e-01f, -4.56814431e-02f, -3.14569473e-02f, -2.51545403e-02f, 2.01818887e-02f, 7.35442787e-02f, -2.43756995e-02f, -4.27862741e-02f,
  3.44611518e-02f, 3.37542072e-02f, 6.48432225e-02f, 6.85406998e-02f, -2.98364297e-03f, -6.80191368e-02f, -7.93469697e-03f, -2.65216753e-02f, 3.68978381e-02f, 9.46614519e-02f,
  6.89549819e-02f, -3.39225419e-02f, -5.67088425e-02f, 5.18022524e-03f, -2.03012023e-02f, -8.04302923e-04f, 5.92927709e-02f, -2.97734737e-02f, 1.03266938e-02f, -4.01064269e-02f,
  4.62123677e-02f, -1.45436868e-01f, 9.05840397e-02f, -8.97860900e-02f, -1.82753541e-02f, 1.24159247e-01f, 3.50336909e-01f, -1.72822401e-01f, -2.55243778e-01f, 3.16811018e-02f,
  1.61456212e-01f, -6.29781857e-02f, 1.65352061e-01f, -7.43246228e-02f, 2.33369038e-01f, 1.21813439e-01f, 4.54623289e-02f, 1.62249997e-01f, -1.10966109e-01f, -1.49240196e-01f,
  -7.37964064e-02f, 4.07552496e-02f, 2.19111711e-01f, -2.21866399e-01f, 5.72938984e-03f, -4.41313088e-02f, -7.94507097e-03f, 1.72269911e-01f, -1.12543024e-01f, -2.87165865e-02f,
  4.75454591e-02f, -2.53118686e-02f, -1.85292289e-02f, -6.81988150e-02f, 6.83174049e-03f, 9.97953396e-03f, 9.00689363e-02f, 1.41911671e-01f, 2.39315610e-02f, -1.51300514e-02f,
  3.35290283e-02f, -3.65166552e-02f, -1.03230089e-01f, 3.66503000e-02f, -1.31471306e-01f, -6.22755326e-02f, -7.00790957e-02f, -1.19176246e-02f, 5.09660803e-02f, 3.05945612e-02f,
  2.88404189e-02f, 6.39471561e-02f, -8.37666448e-03f, 3.77337821e-02f, -3.15355882e-02f, -5.26723042e-02f, 2.85335612e-02f, 8.58800113e-03f, -3.00841220e-02f, -8.66581649e-02f,
  1.24933030e-02f, 4.25801845e-03f, 1.28654344e-02f, 4.03580703e-02f, -7.89140612e-02f, 6.31226376e-02f, 1.35126486e-02f, -2.06790622e-02f, 7.85887428e-03f, 7.53544271e-03f,
  -1.65687259e-02f, 9.59893242e-02f, -9.67045408e-03f, -1.36211878e-02f, 3.94466370e-02f, -6.63844347e-02f, 4.48506363e-02f, -3.12287491e-02f, 6.78819269e-02f, 3.63288149e-02f,
  1.91521216e-02f, 5.15487716e-02f, 6.42365078e-03f, 1.97470784e-02f, -4.80214506e-02f, 7.51663819e-02f, -5.05035520e-02f, 2.02302113e-02f, 4.35271002e-02f, 1.37602255e-01f,
  -2.09456049e-02f, -1.31470367e-01f, 2.37107072e-02f, -6.99421577e-03f, -1.12961121e-02f, -1.42747536e-02f, -8.21851119e-02f, -5.93716167e-02f, -1.58313680e-02f, 3.60433608e-02f,
  9.74638760e-02f, -1.87241752e-02f, 2.86269840e-02f, -5.97703494e-02f, -2.32560877e-02f, -7.96970874e-02f, 6.93071410e-02f, -3.15308012e-02f, 5.13334163e-02f, -3.52965929e-02f,
  -1.23779161e-03f, 7.69104213e-02f, -1.65657736e-02f, -2.82358173e-02f, -3.78629714e-02f, 1.50230648e-02f, -9.75636020e-03f, -2.86335200e-02f, -5.43775037e-02f, -1.17717013e-02f,
  -6.78325817e-02f, 1.33054167e-01f, 1.89543143e-01f, 6.56443387e-02f, 1.02422815e-02f, -2.33277842e-01f, -1.60257459e-01f, 6.58286735e-02f, 3.86186317e-02f, 2.90320124e-02f,
  1.10214658e-01f, 1.18152052e-01f, 4.49370295e-02f, -3.67039591e-02f, -1.79769203e-01f, -7.48389168e-03f, -9.74462479e-02f, -1.11733198e-01f, 2.80351210e-02f, 2.51445007e-02f,
  -7.47360522e-03f, 4.96973023e-02f, 3.85415517e-02f, 1.38952777e-01f, 1.47509091e-02f, 1.26343817e-01f, 5.33836819e-02f, 1.07962966e-01f, 2.56535467e-02f, -2.79138889e-02f,
  -3.34557444e-02f, 5.19281626e-02f, 3.47517133e-02f, -7.09964111e-02f, 2.00443491e-02f, -8.75875205e-02f, 2.07794160e-02f, -8.55916813e-02f, 2.69239005e-02f, 7.37144705e-03f,
  -7.18232021e-02f, -7.83683360e-02f, 7.94303045e-03f, 5.79023967e-03f, -1.11296298e-02f, 1.13608107e-01f, 3.27289402e-02f, -4.70612496e-02f, 5.97989894e-02f, 4.60011475e-02f,
  4.88511547e-02f, -2.69923192e-02f, -8.45821798e-02f, -2.31572613e-02f, 4.92310971e-02f, 7.20911250e-02f, 1.65896192e-02f, 3.96978222e-02f, -5.45101762e-02f, -3.58207361e-03f,
  -4.70806360e-02f, -5.70043512e-02f, 6.00849167e-02f, 4.54781689e-02f, -4.92454916e-02f, 7.80937523e-02f, -7.05430284e-02f, 1.89279914e-02f, 8.00544843e-02f, 3.06883547e-02f,
  4.59871553e-02f, 6.82574660e-02f, 4.81320769e-02f, 2.66122837e-02f, 8.55728984e-02f, 1.61687732e-02f, -9.49430242e-02f, -7.57456571e-02f, 2.04954557e-02f, 1.18135093e-02f,
  3.43815237e-02f, -3.36153768e-02f, 4.35879491e-02f, -6.61395267e-02f, 1.06338747e-02f, -5.25427163e-02f, -4.94371541e-02f, -1.43222092e-02f, -5.46562858e-02f, 7.95066357e-02f,
  5.90170175e-03f, 2.12526456e-01f, -4.65267561e-02f, -6.81486800e-02f, -7.99942911e-02f, -8.44156276e-03f, -1.45766884e-02f, 2.55601499e-02f, 6.69733584e-02f, -1.96817517e-02f,
  1.30185299e-02f, 3.15994062e-02f, 5.71433492e-02f, 2.47604586e-02f, 1.97866000e-02f, -6.91074354e-04f, 2.68074907e-02f, -2.25255173e-02f, 4.27761227e-02f, 8.26904550e-02f,
  -3.83277722e-02f, 3.63384336e-02f, 7.29941949e-02f, -5.59921116e-02f, -7.55656958e-02f, 3.54775903e-03f, -6.21259920e-02f, 3.08855530e-03f, 4.82056942e-03f, 4.10963744e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.43001124e-01f, -3.93304452e-02f, -1.16588054e-02f, 2.02356562e-01f, 1.80225626e-01f, 2.80128624e-02f, 7.20581114e-02f, 1.13969013e-01f, 1.26121387e-01f, 7.07499534e-02f,
  1.90275401e-01f, 1.19804092e-01f, 1.98932856e-01f, 3.66085917e-02f, 4.19337191e-02f, 7.11375400e-02f, 1.96266145e-01f, 1.82790637e-01f, 1.24854289e-01f, 2.89446060e-02f,
  9.56981108e-02f, 7.26141036e-02f, 2.00854406e-01f, 1.02202594e-01f, 2.27166116e-01f, 1.20162442e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -3.35477628e-02f, 5.76268025e-02f, -1.16330190e-02f, -4.87356586e-03f, -2.32590869e-01f, -4.45244908e-02f, 5.41432165e-02f, -5.31959198e-02f, 1.70620868e-03f, -1.51576802e-01f,
  -1.63030475e-01f, -1.32567614e-01f, -3.79120186e-02f, -5.35135269e-02f, 2.59312540e-02f, 4.72587347e-03f, 1.71487331e-02f, 6.25374839e-02f, 3.40104513e-02f, 3.52423370e-01f,
  2.06545085e-01f, -1.40236482e-01f, 1.63879156e-01f, -6.40636459e-02f, 1.15657728e-02f, 1.90333962e-01f, -1.68999843e-02f, -3.96345794e-01f, 1.50132596e-01f, 2.63799187e-02f,
  8.03705454e-02f, -4.63107601e-02f, 3.39548551e-02f, 3.08887456e-02f, 8.46279934e-02f, -5.41047044e-02f, -7.03942403e-02f, 1.79349765e-01f, 2.74186209e-02f, 9.08840597e-02f,
  8.27243254e-02f, 4.59642634e-02f, -1.74695492e-01f, 1.95762590e-02f, -5.27549945e-02f, -2.10306328e-02f, -1.04536869e-01f, -8.25484470e-02f, 1.95885107e-01f, -6.42655045e-03f,
  5.88121079e-03f, -1.27248287e-01f, -3.19882371e-02f, 2.64677018e-01f, 1.99491233e-01f, 2.22580835e-01f, 9.54515934e-02f, 7.89429918e-02f, 5.96063770e-02f, -2.25448966e-01f,
  1.22651361e-01f, 1.08244292e-01f, -2.47668773e-02f, -2.16152221e-02f, -6.92687929e-02f, -1.89640641e-01f, -5.99390492e-02f, -1.05883501e-01f, -4.20325883e-02f, 2.69447230e-02f,
  -2.29360014e-01f, -9.57666859e-02f, 2.54067173e-03f, -2.96520203e-01f, -3.84198758e-03f, -1.21498518e-01f, -1.83963366e-02f, 8.36853758e-02f, -5.23953419e-03f, -2.09422320e-01f,
  3.18936519e-02f, -4.30121496e-02f, 1.66161060e-02f, 1.26417682e-01f, -1.02599204e-01f, 3.18302959e-01f, -5.43691106e-02f, -2.68888474e-01f, -1.29944935e-01f, 1.96762055e-01f,
  -1.51105255e-01f, -1.92349330e-01f, 2.97041703e-02f, 3.08437906e-02f, -3.25250551e-02f, -4.30996045e-02f, -1.18405983e-01f, 1.35925546e-01f, -1.45696104e-01f, 1.61609918e-01f,
  -1.06112041e-01f, -6.86572567e-02f, 1.97849065e-01f, 2.50263624e-02f, 1.39398217e-01f, 2.10928142e-01f, -1.46057948e-01f, -2.31595170e-02f, -5.03371917e-02f, 1.16444729e-01f,
  -3.03216535e-03f, 1.26997501e-01f, -7.59131983e-02f, -7.36251995e-02f, -8.64043310e-02f, 1.56062901e-01f, 5.86429611e-03f, -2.58033611e-02f, -1.28446221e-01f, 5.79846129e-02f,
  8.05616900e-02f, 2.03574382e-04f, 1.13777295e-01f, -1.03475124e-01f, 8.93746242e-02f, 1.03523098e-01f, 1.29469439e-01f, 1.29427267e-02f, 1.38026789e-01f, 3.55226658e-02f,
  1.10055253e-01f, 1.40362708e-02f, 8.19970816e-02f, -1.03458494e-01f, -5.46210818e-02f, 2.40184054e-01f, -1.36960700e-01f, 9.19397846e-02f, -4.69002724e-02f, 1.24571063e-01f,
  5.87673560e-02f, 8.66934136e-02f, -8.89475271e-02f, 1.23510242e-01f, 1.35244802e-01f, 1.22613288e-01f, -9.22930017e-02f, -2.84281999e-01f, -9.59949046e-02f, 1.08780086e-01f,
  -1.22665457e-01f, 1.33953318e-01f, 3.42980981e-01f, -1.81124851e-01f, 2.79654294e-01f, 3.58737767e-01f, -2.06826597e-01f, 7.17755258e-02f, 1.76207185e-01f, 9.72714275e-02f,
  -2.23874792e-01f, 1.31715178e-01f, 7.78518021e-02f, 2.35217258e-01f, 9.74933356e-02f, 2.66026091e-02f, 2.03970950e-02f, -2.24204138e-01f, 5.18940277e-02f, 1.24440594e-02f,
  1.57025270e-02f, 1.70196481e-02f, 5.69830164e-02f, 1.44702941e-01f, 2.30676178e-02f, -1.08912839e-02f, -2.23567829e-01f, 7.54097998e-02f, -1.13883458e-01f, 4.27342504e-02f,
  4.80488129e-02f, -1.97523713e-01f, -1.13186762e-01f, -3.69990841e-02f, -1.41684309e-01f, -5.49791344e-02f, -1.53522521e-01f, 2.17724279e-01f, -1.24527410e-01f, -5.47206141e-02f,
  1.65564597e-01f, 1.29617825e-02f, 1.47988603e-01f, -1.15193345e-01f, -7.70497993e-02f, 7.97586292e-02f, 1.08186163e-01f, -4.84391153e-02f, -1.44979775e-01f, 1.72070265e-01f,
  6.43018410e-02f, 1.26850829e-01f, 1.25557899e-01f, 4.83979508e-02f, -8.82721841e-02f, -1.24224760e-01f, 7.87122995e-02f, 1.41561493e-01f, -5.30503541e-02f, 1.33603394e-01f,
  5.92476316e-02f, -9.95672643e-02f, -2.53523380e-01f, -1.39877483e-01f, 1.53423389e-02f, 2.54679203e-01f, -4.39060666e-02f, -1.44876689e-01f, 8.01931173e-02f, 3.30534205e-02f,
  1.05680801e-01f, -6.11051396e-02f, -1.35757878e-01f, -7.07865134e-03f, 2.38694046e-02f, 4.95706312e-02f, 1.91417888e-01f, -3.96276005e-02f, 2.33173128e-02f, -2.10486516e-01f,
  4.96346429e-02f, -1.50745539e-02f, 7.54331946e-02f, -1.56647831e-01f, 1.48373127e-01f, -1.26283541e-02f, -8.69372785e-02f, 1.56067908e-01f, 1.43903226e-01f, -5.02031036e-02f,
  -1.58535317e-01f, -9.53256041e-02f, 1.39617324e-01f, 7.24365413e-02f, -1.56809986e-02f, -1.95109427e-01f, 3.84814292e-02f, -1.72642753e-01f, -3.12582850e-02f, -1.89399943e-01f,
  -8.85551125e-02f, -4.18349989e-02f, 3.41367163e-02f, -1.06904574e-01f, 1.59642696e-02f, 9.14930925e-02f, -5.74219562e-02f, -7.05455095e-02f, -4.71427925e-02f, -3.51520516e-02f,
  1.46048933e-01f, -1.45076320e-01f, 1.23965973e-02f, 1.02736436e-01f, -9.13601369e-02f, 9.71439555e-02f, 5.85940219e-02f, -1.43849263e-02f, -3.80641818e-02f, 4.02169116e-02f,
  1.66738573e-02f, 1.29611954e-01f, 9.48547721e-02f, 5.74436262e-02f, -7.80689120e-02f, -1.22451924e-01f, 1.52750120e-01f, 8.74733925e-02f, -5.87377213e-02f, 6.74849600e-02f,
  2.01842979e-01f, 2.38734826e-01f, -3.67346890e-02f, -1.18338294e-01f, -1.88671306e-01f, -6.90727830e-02f, 1.69212013e-01f, 2.52575397e-01f, -8.91412720e-02f, -2.21957088e-01f,
  -3.70633192e-02f, 2.53423691e-01f, 1.43585518e-01f, 1.54171079e-01f, -4.58684638e-02f, -7.31866881e-02f, -5.62716685e-02f, 1.05425693e-01f, -6.06418177e-02f, 6.95285760e-03f,
  -1.30193651e-01f, 4.93460335e-02f, 4.06768285e-02f, -2.02654488e-02f, 9.38796550e-02f, 5.53107597e-02f, -3.54016609e-02f, -2.19117999e-02f, -1.54539630e-01f, 8.60733166e-02f,
  -1.23787507e-01f, 1.91765502e-01f, 1.09193437e-01f, -4.86160964e-02f, 4.23375256e-02f, 1.01224206e-01f, -6.58676028e-02f, 9.87504423e-02f, 1.41962782e-01f, -1.97327826e-02f,
  2.20924318e-02f, -3.95781845e-02f, -3.93304229e-02f, 5.59699573e-02f, 2.49091517e-02f, -8.16781446e-02f, -2.61892110e-01f, -1.26872703e-01f, -5.83580807e-02f, -1.10166587e-01f,
  -4.56707776e-02f, 4.87280898e-02f, -1.05797537e-01f, 6.36206120e-02f, -2.62617886e-01f, 7.39990398e-02f, 1.51357753e-02f, -1.22484662e-01f, 6.09882735e-02f, -6.60568923e-02f,
  -1.00406550e-01f, 6.94143921e-02f, -3.32437485e-01f, -2.23648146e-01f, -1.29013360e-01f, 1.64717674e-01f, -2.52432495e-01f, -1.69939511e-02f, -2.98006505e-01f, -5.68755232e-02f,
  -3.05685550e-01f, 9.03599858e-02f, -2.07423851e-01f, 1.42413229e-01f, -1.22776613e-01f, -3.16197947e-02f, 3.17627005e-02f, -3.35989922e-01f, 7.19630346e-02f, 2.89205238e-02f,
  -1.01832509e-01f, 2.50031799e-01f, 6.43526539e-02f, 1.51748685e-02f, -3.02423853e-02f, 1.56495348e-02f, 3.99787277e-02f, 1.59512058e-01f, -3.02400202e-01f, -6.30291626e-02f,
  -7.40379840e-02f, 1.22416243e-01f, -2.38985047e-02f, 3.32619399e-02f, -6.49615452e-02f, -5.10698231e-03f, -1.40635036e-02f, 4.27645631e-02f, 4.63565029e-02f, 7.36096352e-02f,
  -2.42313191e-01f, 1.13318078e-01f, 2.59518661e-02f, -1.76587664e-02f, -5.45335701e-03f, -1.40799778e-02f, 1.33009300e-01f, 3.20256464e-02f, 1.06520101e-01f, 1.46925926e-01f,
  2.70381430e-03f, 5.96890561e-02f, -2.56611146e-02f, -1.77687220e-02f, 6.43918887e-02f, -1.18873669e-02f, -4.58519086e-02f, 1.88508071e-02f, 3.09595908e-03f, -3.91201526e-02f,
  -1.25681251e-01f, -1.40204325e-01f, -3.37460414e-02f, -5.64700626e-02f, 3.32638502e-01f, -2.97107399e-01f, 2.21069127e-01f, 2.73332037e-02f, -7.03804120e-02f, 1.63871258e-01f,
  -1.77175835e-01f, 6.19008318e-02f, -5.92092089e-02f, -1.00535564e-01f, -4.50086780e-02f, 5.90323694e-02f, 4.54781614e-02f, -3.59498858e-01f, -4.41186838e-02f, -1.14747129e-01f,
  -3.77265960e-02f, -6.72051981e-02f, 2.92040050e-01f, 1.69418141e-01f, -1.70257509e-01f, -7.80769587e-02f, 6.08736314e-02f, -8.23840424e-02f, 7.46225193e-02f, -1.82828109e-03f,
  2.38870885e-02f, 2.11384282e-01f, 5.61675727e-02f, -1.38639044e-02f, 4.85759228e-02f, 4.59323358e-03f, -3.14201787e-02f, 2.10838228e-01f, 3.62932645e-02f, 1.68320358e-01f,
  -3.63025889e-02f, 3.69313136e-02f, -6.77724257e-02f, 8.11792091e-02f, -1.64584830e-01f, -1.51819527e-01f, -1.88877478e-01f, -2.84670033e-02f, -1.31448478e-01f, 1.27636015e-01f,
  6.07937016e-02f, 2.11424500e-01f, -8.26026499e-02f, -1.11584172e-01f, -3.96264866e-02f, 1.08686276e-01f, -8.32463503e-02f, 1.47616640e-01f, -7.05666319e-02f, -7.42784422e-03f,
  -3.80577669e-02f, 3.74461859e-02f, -5.65650389e-02f, 1.24778792e-01f, 4.39588614e-02f, -1.30410343e-01f, -1.31268933e-01f, -1.61096156e-01f, 3.56806755e-01f, -1.84879348e-01f,
  1.20038372e-02f, -1.63381975e-02f, -7.74079412e-02f, 2.61574328e-01f, -9.13957730e-02f, 3.22253704e-02f, 1.56293139e-01f, -8.61607864e-02f, -5.70460074e-02f, -1.30570158e-01f,
  2.61012793e-01f, -3.96788985e-01f, -1.42959237e-01f, -6.65988326e-02f, 2.09019542e-01f, 1.94849685e-01f, 2.06842124e-01f, 3.94426897e-04f, -4.96517159e-02f, 2.06269007e-02f,
  5.31405844e-02f, 1.00499168e-01f, 1.25319615e-01f, -6.47181943e-02f, -3.27315368e-02f, 2.61974968e-02f, 1.07704047e-02f, 1.00681670e-01f, -9.01424810e-02f, -1.04807287e-01f,
  -9.50401351e-02f, -7.93291479e-02f, -1.51947811e-01f, -3.19027267e-02f, 6.81519061e-02f, -2.38393117e-02f, 1.26179665e-01f, 1.45314902e-01f, 8.94181132e-02f, -1.66145518e-01f,
  -1.75019488e-01f, -2.45973188e-02f, 1.59376245e-02f, 7.98438564e-02f, -6.72317073e-02f, -4.87148575e-02f, -6.39991388e-02f, 1.50276601e-01f, 4.77692038e-02f, -6.50983453e-02f,
  9.20278579e-02f, 1.59057885e-01f, -5.15803471e-02f, -7.87694529e-02f, 7.52476826e-02f, -5.52667938e-02f, -9.26470235e-02f, 1.03114806e-01f, -5.94167337e-02f, -8.87479484e-02f,
  1.49572529e-02f, -4.06445675e-02f, 5.58520257e-02f, -2.17129111e-01f, 1.64144412e-02f, -1.00758396e-01f, -6.41620904e-02f, 1.55488044e-01f, -2.54797578e-01f, -4.60614786e-02f,
  -2.27478534e-01f, -2.19697058e-02f, -3.11974734e-01f, 1.47664875e-01f, 5.45336194e-02f, -1.00321420e-01f, -7.67666474e-02f, -2.64154434e-01f, 4.40316349e-02f, 8.71357787e-03f,
  -1.20657593e-01f, 4.29568589e-02f, -2.67162193e-02f, 8.96645412e-02f, 9.48137324e-03f, -2.59830337e-02f, -6.67920783e-02f, -6.92331120e-02f, -4.18170653e-02f, -1.10799305e-01f,
  -6.51724786e-02f, -4.95267473e-02f, -1.79155648e-01f, 2.69353483e-02f, -1.08611345e-01f, 5.67836910e-02f, -6.81468425e-03f, -1.67923514e-02f, -1.40638277e-01f, -1.61706969e-01f,
  1.27065510e-01f, 5.00315726e-02f, 3.77819054e-02f, 9.76371691e-02f, -2.69021075e-02f, -3.73232551e-02f, -2.54940148e-02f, -1.20289132e-01f, -1.07994527e-01f, 1.00418374e-01f,
  -1.26268834e-01f, -6.74982592e-02f, -8.32296833e-02f, -2.46000409e-01f, -2.11063400e-03f, -8.30520466e-02f, 7.23298565e-02f, -1.41295910e-01f, -1.13506563e-01f, -5.10171242e-02f,
  -5.71010485e-02f, 7.50739947e-02f, 3.04869954e-02f, -7.24627152e-02f, -4.68578823e-02f, 2.78590798e-01f, 3.71527150e-02f, 1.82303160e-01f, -2.55164564e-01f, -3.24347287e-01f,
  -2.27219835e-01f, -1.68336928e-01f, -2.30003729e-01f, -2.30558008e-01f, -7.44919032e-02f, 1.31950835e-02f, 3.61332893e-02f, -3.55523340e-02f, -3.47372070e-02f, 1.87222987e-01f,
  4.48712222e-02f, -1.24315925e-01f, -2.80111313e-01f, 1.47728249e-02f, -2.12401316e-01f, 1.06215298e-01f, -1.06669158e-01f, 3.62938121e-02f, 1.14385650e-01f, -9.72196907e-02f,
  2.50210688e-02f, -4.86832000e-02f, -1.07077226e-01f, -1.57207608e-01f, -4.90935333e-02f, -1.16890244e-01f, -5.52716218e-02f, 2.99153067e-02f, 6.86003417e-02f, 1.34757400e-01f,
  -7.87591934e-02f, 1.53766945e-01f, -1.12205163e-01f, 4.47461102e-03f, 9.00187492e-02f, -1.39370695e-01f, 3.69926915e-03f, 2.38430589e-01f, 1.49944901e-01f, 4.34661210e-02f,
  8.02595839e-02f, -4.11338061e-02f, 2.39634831e-02f, -1.07474267e-01f, -1.06138855e-01f, 2.87673362e-02f, -1.14651151e-01f, -9.23022330e-02f, -1.47548690e-01f, -1.65268764e-01f,
  -6.50608689e-02f, -1.49648888e-02f, -1.48014307e-01f, 7.17868209e-02f, -8.92252997e-02f, -5.15151247e-02f, -3.67349908e-02f, 1.02375507e-01f, 1.21437289e-01f, 7.00812191e-02f,
  -1.71265364e-01f, -8.60516652e-02f, -2.08059147e-01f, -1.27909705e-01f, 1.51304990e-01f, -1.91088483e-01f, -1.75043061e-01f, 1.89870343e-01f, -3.04317445e-01f, 2.51414388e-01f,
  -1.67327970e-02f, 2.31540743e-02f, -1.49304699e-02f, 2.95202523e-01f, -6.61149547e-02f, 1.23883314e-01f, 7.09762648e-02f, 2.41553634e-02f, -1.48716241e-01f, 1.48163214e-02f,
  1.00830622e-01f, 1.06269337e-01f, -1.21306211e-01f, 2.71280836e-02f, -2.79073492e-02f, -6.07423969e-02f, -4.52093221e-02f, 2.77460199e-02f, -1.83502659e-01f, -8.37369561e-02f,
  -1.67757660e-01f, 8.12931955e-02f, 5.46321161e-02f, 1.88018426e-01f, 2.13679019e-02f, -1.06770553e-01f, 3.80494557e-02f, 5.23380935e-04f, 2.97050923e-02f, -1.16915777e-01f,
  -8.73357803e-02f, 4.91496362e-02f, -2.26800386e-02f, -1.57415763e-01f, 2.09860235e-01f, 2.76132282e-02f, 5.78621253e-02f, -7.83282816e-02f, 8.70533064e-02f, -1.07900895e-01f,
  -2.30325654e-01f, 1.14286736e-01f, 8.80828500e-02f, -2.74718314e-01f, 5.42549081e-02f, -7.10270703e-02f, 7.95976371e-02f, 6.37032315e-02f, -9.43685323e-02f, -8.56568385e-03f,
  -8.59244242e-02f, 1.80884913e-01f, -1.13089606e-02f, -1.83636487e-01f, 6.13889657e-02f, 1.27493724e-01f, -4.88314182e-02f, -2.26427108e-01f, -8.84655863e-02f, -8.95780250e-02f,
  2.48073209e-02f, 1.71641763e-02f, -2.70123910e-02f, -3.34289186e-02f, 1.71137780e-01f, 1.13428727e-01f, 3.29625271e-02f, 1.10665426e-01f, -2.60857254e-01f, 1.95018994e-03f,
  1.01767316e-01f, -2.32770126e-02f, -9.64917988e-02f, 5.32972030e-02f, -1.69187039e-01f, -1.89638630e-01f, 5.08866869e-02f, -7.39211589e-03f, 8.12302306e-02f, -2.10184634e-01f,
  6.59430400e-03f, -8.92014056e-02f, 1.12038463e-01f, 6.18417524e-02f, 9.85603128e-03f, 1.56202376e-01f, -2.75835376e-02f, -1.07125729e-01f, -8.64811167e-02f, -5.06974570e-02f,
  1.09021910e-01f, 1.24826036e-01f, 7.84988925e-02f, 6.17355630e-02f, -2.44047970e-01f, 6.01881668e-02f, 2.12114766e-01f, -2.25788742e-01f, -5.01523912e-02f, -2.95044314e-02f,
  -5.20104319e-02f, -1.15452101e-02f, 3.25495601e-02f, -8.50581154e-02f, -1.00640543e-01f, -2.07230374e-02f, 6.98893145e-02f, -1.38780862e-01f, 2.87788156e-02f, 8.80052894e-02f,
  2.04774737e-02f, 1.92282293e-02f, -4.71987715e-03f, 1.25055518e-02f, -4.82145064e-02f, 1.34528458e-01f, -8.71952996e-02f, -2.47435659e-01f, -4.15611453e-02f, 1.93448961e-01f,
  -9.98984948e-02f, 6.55538961e-02f, -9.55230966e-02f, -4.97405194e-02f, 1.82309151e-01f, -1.95465554e-02f, 4.23119180e-02f, 6.88895434e-02f, 6.72722757e-02f, -2.08880961e-01f,
  -4.40441146e-02f, 2.40222141e-02f, -5.42662255e-02f, 2.11717501e-01f, 5.48258834e-02f, -2.06104115e-01f, 2.39726394e-01f, 6.87683583e-04f, -9.55381989e-02f, 1.45276546e-01f,
  -4.48325370e-03f, 1.95745146e-03f, 1.19895503e-01f, 1.28091797e-01f, -7.32193142e-02f, 2.30300084e-01f, -5.46157174e-02f, -9.37531814e-02f, 1.54672101e-01f, 1.07425608e-01f,
  -5.81823923e-02f, -1.37179360e-01f, -1.02674235e-02f, -1.61739826e-01f, -9.58119854e-02f, -8.61432478e-02f, -1.49006635e-01f, 6.19715527e-02f, -2.04059839e-01f, -2.39908218e-01f,
  -3.82487699e-02f, -2.44961232e-02f, -1.03233531e-01f, 9.96134356e-02f, -8.92868415e-02f, 1.00978360e-01f, -1.13717347e-01f, 9.38355252e-02f, -1.16870783e-01f, 6.98975995e-02f,
  -3.23386453e-02f, -2.45036229e-01f, -1.63949326e-01f, -9.67641473e-02f, 7.90040046e-02f, 9.75337923e-02f, -3.20147902e-01f, -9.00673941e-02f, 8.62499550e-02f, 4.02705036e-02f,
  1.28676593e-01f, -2.70193905e-01f, 1.12470202e-01f, -9.29847360e-02f, -2.51755446e-01f, -1.18900053e-01f, 8.62990841e-02f, 3.91050763e-02f, -1.38020292e-01f, 1.85930699e-01f,
  -4.33308870e-01f, 2.63948515e-02f, -1.90965444e-01f, 2.19335750e-01f, -2.36136150e-02f, -3.96035612e-03f, -2.27464959e-01f, -4.05512564e-02f, 1.62913084e-01f, -2.39275098e-01f,
  2.30813563e-01f, -8.94918367e-02f, -1.09680377e-01f, 1.05657123e-01f, 2.22161394e-02f, 9.26740915e-02f, 8.52564201e-02f, -1.35178268e-01f, 2.78866962e-02f, 2.11033478e-01f,
  -2.96896428e-01f, -9.99259949e-02f, -9.65898335e-02f, 1.46183237e-01f, -1.36314020e-01f, -3.84393707e-02f, 3.36966813e-02f, -1.87204182e-02f, 3.49431522e-02f, -3.52872424e-02f,
  -7.84056708e-02f, 1.09501809e-01f, -3.14461470e-01f, 9.24532041e-02f, -1.56811744e-01f, -1.04808711e-01f, -5.31380363e-02f, -9.98418182e-02f, 4.68447469e-02f, -1.36635881e-02f,
  1.40365139e-01f, 3.67162079e-02f, 1.10471226e-01f, 7.00062513e-02f, 9.36995149e-02f, 1.78267788e-02f, -1.61914796e-01f, -6.24080226e-02f, 1.06681161e-01f, -1.22908980e-01f,
  -1.91067606e-02f, -1.21595219e-01f, -5.13414219e-02f, 7.42543712e-02f, -5.65699264e-02f, -1.90275669e-01f, 3.45594622e-02f, 1.98444705e-02f, 2.08600387e-01f, 2.77014941e-01f,
  3.54527712e-01f, 3.19913298e-01f, 1.50496528e-01f, 8.61366279e-03f, -1.52683511e-01f, 1.35603115e-01f, 9.31471512e-02f, 3.07713300e-01f, -1.42559662e-01f, -2.95284390e-01f,
  1.25879705e-01f, 3.34760070e-01f, 1.77543357e-01f, 4.07366082e-02f, 1.87465772e-01f, -6.01578541e-02f, -6.06546598e-03f, 6.73842058e-02f, -8.53554681e-02f, 1.53171420e-01f,
  -4.87787612e-02f, 4.55208868e-03f, -7.22487941e-02f, 2.24237859e-01f, -7.67432060e-03f, 1.20491929e-01f, 1.49156839e-01f, 6.66167811e-02f, 2.28265654e-02f, -1.04254633e-01f,
  -1.51953045e-02f, 6.82773301e-03f, 1.44113675e-01f, 3.31088044e-02f, 8.51858594e-03f, 1.21273026e-01f, 8.78771618e-02f, -9.21950266e-02f, 9.74272266e-02f, 1.79115608e-02f,
  -2.51567602e-01f, -1.15337018e-02f, -1.35817885e-01f, -8.83001648e-03f, -1.09553330e-01f, 2.73020286e-02f, 6.34367764e-02f, -1.77979693e-01f, 4.06794399e-02f, 1.36672273e-01f,
  -3.15815471e-02f, 1.10363588e-02f, 9.06935930e-02f, 2.16272902e-02f, -7.09156319e-02f, -2.77007166e-02f, -8.17063672e-04f, -1.93274066e-01f, -8.11372250e-02f, 1.68559387e-01f,
  1.56397998e-01f, -1.31623313e-01f, -1.82366353e-02f, -1.45365177e-02f, -1.67919546e-01f, 2.30330199e-01f, -3.15953285e-01f, -2.07153410e-01f, -1.04381762e-01f, -1.18658170e-01f,
  -3.04405302e-01f, 1.47664294e-01f, 1.39704764e-01f, -1.94025159e-01f, -2.27369107e-02f, -2.07590103e-01f, -1.11011863e-01f, -7.06229433e-02f, -6.67044744e-02f, 2.05672234e-02f,
  9.94146839e-02f, 7.99408033e-02f, -1.13641590e-01f, 9.64708924e-02f, 2.20075902e-02f, 7.74137750e-02f, 1.63294573e-03f, -9.51788649e-02f, 2.23646257e-02f, -3.00349463e-02f,
  -1.32457718e-01f, -1.74924850e-01f, -5.11348546e-02f, 6.81582987e-02f, 1.42639920e-01f, 1.25536904e-01f, -1.08329892e-01f, -3.11414599e-02f, 1.63454503e-01f, 1.06241284e-02f,
  1.06384568e-01f, 2.03657717e-01f, -8.70608389e-02f, 8.41529444e-02f, 4.78177033e-02f, -7.47357160e-02f, -1.06862439e-02f, 4.04081643e-02f, 1.91291571e-01f, -1.69454560e-01f,
  1.55164152e-01f, -7.62303267e-03f, 2.43119411e-02f, -7.09507093e-02f, 1.34711698e-01f, -2.76971404e-02f, 1.31735444e-01f, 3.42057273e-02f, 1.09606199e-01f, -1.33677302e-02f,
  -1.02983266e-02f, 1.57997042e-01f, -2.49585835e-03f, -1.66752562e-01f, 1.14453308e-01f, 2.30271414e-01f, 1.05029821e-01f, 2.43037239e-01f, 2.07689732e-01f, -1.75496832e-01f,
  3.10971171e-01f, 1.74566239e-01f, 1.28219619e-01f, 8.80659372e-02f, 3.08109075e-01f, -2.16768105e-02f, 5.23569174e-02f, -2.21024118e-02f, 5.09417169e-02f, 3.15812171e-01f,
  -1.23866778e-02f, 1.67596459e-01f, -5.57591841e-02f, -2.15765908e-02f, 8.15122053e-02f, -1.41655385e-01f, 2.87770052e-02f, 3.70913818e-02f, -3.04877702e-02f, -4.77536246e-02f,
  -4.69746366e-02f, 8.75442401e-02f, 1.90554261e-01f, -9.28425044e-03f, 1.04381144e-01f, 1.41758651e-01f, -1.03987053e-01f, 1.12990756e-02f, -1.17788151e-01f, 7.34078735e-02f,
  -2.50075907e-02f, 2.09752079e-02f, -1.34988457e-01f, 1.27363622e-01f, -1.29781082e-01f, -8.40062797e-02f, 1.89027533e-01f, -4.24119458e-02f, 1.25372350e-01f, -7.63445124e-02f,
  3.82589065e-02f, 9.73362476e-02f, 2.40171596e-01f, 1.48103580e-01f, 5.83167709e-02f, 2.10910682e-02f, 1.40490323e-01f, 8.59432146e-02f, 1.62244603e-01f, 4.71207201e-02f,
  2.15292230e-01f, 6.81657717e-02f, -7.66279455e-03f, 1.69921115e-01f, 1.60763085e-01f, 1.05962060e-01f, 1.23939812e-01f, 9.36070308e-02f, -1.30546257e-01f, -2.14918014e-02f,
  1.53900869e-02f, -4.31413352e-02f, -2.06907183e-01f, -7.02688247e-02f, 6.90922216e-02f, -2.23849043e-01f, 7.19839334e-02f, -8.17543864e-02f, -1.53812528e-01f, 6.83646575e-02f,
  -1.35179102e-01f, 2.45057046e-01f, 6.53147548e-02f, -2.62233675e-01f, -1.80802658e-01f, -3.15964036e-02f, -2.47977301e-01f, -4.70185429e-02f, -8.09409171e-02f, -1.00311100e-01f,
  2.38069683e-01f, -5.84960319e-02f, -1.18137971e-01f, -4.67493082e-04f, 1.80965081e-01f, -4.87025045e-02f, -8.37340392e-03f, 1.10879049e-01f, 8.03708434e-02f, 1.04932496e-02f,
  2.75173713e-03f, -7.62017369e-02f, 7.41457790e-02f, 8.75192434e-02f, -8.11615959e-02f, -4.07703705e-02f, 5.46717122e-02f, -7.42394179e-02f, 3.27124558e-02f, 1.51134789e-01f,
  2.06674293e-01f, -2.43424270e-02f, 1.73067346e-01f, 1.12728015e-01f, -1.33718744e-01f, -1.71218932e-01f, -8.33376423e-02f, 2.03401577e-02f, 3.02182566e-02f, 8.38266835e-02f,
  -1.39420867e-01f, -1.36965320e-01f, 4.22503762e-02f, 2.67788731e-02f, 1.47591218e-01f, -3.50950956e-02f, 3.89241241e-02f, -1.44874573e-01f, 1.99540034e-01f, 2.17466414e-01f,
  -3.60814333e-02f, -3.79155837e-02f, -1.65329531e-01f, 1.11480087e-01f, 1.67823896e-01f, -6.25651702e-02f, 3.76502514e-01f, -7.66865164e-02f, -2.03044880e-02f, -1.27332443e-02f,
  -6.94914237e-02f, 2.07872227e-01f, 2.37235829e-01f, 4.00771260e-01f, -2.76840866e-01f, 6.61344752e-02f, 8.40547383e-02f, 3.23467642e-01f, -1.10841766e-01f, -5.08721161e-04f,
  -1.45176679e-01f, -1.28682792e-01f, -6.03802204e-02f, -2.27396294e-01f, -7.83436820e-02f, -3.20665427e-02f, -6.60425201e-02f, -4.38587070e-02f, -1.26597598e-01f, -2.04579711e-01f,
  -4.66725118e-02f, 1.22116126e-01f, 1.23931646e-01f, 5.58060296e-02f, -1.14105865e-01f, 1.10660560e-01f, 1.34364456e-01f, 2.25614756e-01f, 1.51700854e-01f, 1.86793774e-01f,
  4.01980914e-02f, -1.36942444e-02f, -2.47657120e-01f, 1.27378523e-01f, 2.70180702e-01f, 2.84461416e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  6.07368127e-02f, 1.93039179e-02f, 1.51319087e-01f, 1.88088372e-01f, 6.34381920e-02f, 1.94828346e-01f, 6.66001812e-04f, -6.36524260e-02f, 1.60969511e-01f, -1.14358976e-01f,
  -5.95833100e-02f, -3.70689332e-02f, -3.65466550e-02f, 6.17117397e-02f, 6.99483901e-02f, -1.09532941e-02f, 6.25694590e-03f, -1.13483202e-02f, -8.22694879e-03f, -1.39199972e-01f,
  1.37104943e-01f, 7.75427418e-03f, 4.34494056e-02f, -7.18559623e-02f, -1.58086240e-01f, 1.41493514e-01f, -2.03086644e-01f, -1.18389100e-01f, -5.48610352e-02f, 6.78390786e-02f,
  -1.57411128e-01f, -8.98226444e-03f, 7.43866265e-02f, -1.22729920e-01f, 7.71886762e-03f, 8.84534270e-02f, 1.68853879e-01f, -1.20427415e-01f, 2.59084761e-01f, 1.65561244e-01f,
  -8.57589468e-02f, 1.38698608e-01f, -1.03745706e-01f, 6.39289944e-03f, 4.21053767e-02f, 5.23889847e-02f, -6.30201548e-02f, 1.05296224e-01f, 1.62351355e-02f, -1.16929002e-01f,
  1.57720596e-01f, -4.83430475e-02f, -1.04918823e-01f, 2.19214670e-02f, -4.30659391e-02f, -1.75844096e-02f, 1.34797513e-01f, 3.64555679e-02f, -5.61161600e-02f, -2.14829352e-02f,
  -3.25263682e-04f, 2.57659387e-02f, -9.15416926e-02f, 1.16077691e-01f, 9.59400460e-02f, 5.67800552e-02f, 1.36636987e-01f, -8.85576289e-03f, -1.78386946e-03f, 1.15779109e-01f,
  6.76655173e-02f, 2.95876384e-01f, 1.01932265e-01f, 3.22839141e-01f, 1.23841017e-01f, 1.80790186e-01f, 1.03079677e-01f, 1.26545597e-02f, 2.25159377e-01f, 9.65577513e-02f,
  -6.03038073e-03f, 1.26191750e-01f, 1.02019608e-01f, 5.52345142e-02f, -2.38404423e-02f, -1.33878693e-01f, 3.43570292e-01f, 2.79878378e-01f, 1.30002737e-01f, 1.53756201e-01f,
  1.12547316e-01f, 1.84457302e-01f, 1.67579606e-01f, -1.65051088e-01f, -1.34372875e-01f, -4.11168449e-02f, -1.35814667e-01f, -3.38641763e-01f, 2.79814094e-01f, -1.87120020e-01f,
  5.56565449e-02f, 1.26140431e-01f, 1.28659725e-01f, -5.24597242e-02f, 7.82532990e-02f, 2.12848842e-01f, 1.26217544e-01f, 2.54455023e-03f, -9.99274403e-02f, 2.14368463e-01f,
  1.34442136e-01f, -1.44671589e-01f, 1.20673710e-02f, 4.62772660e-02f, 3.10466439e-01f, -1.48020387e-02f, -3.96568980e-03f, -8.26781020e-02f, 4.97221127e-02f, -1.84449613e-01f,
  8.87574553e-02f, 4.44432795e-02f, -5.74657880e-02f, 2.09305376e-01f, 3.92420083e-01f, 9.39818248e-02f, -1.96568117e-01f, 1.92786172e-01f, 3.43349911e-02f, -9.43341404e-02f,
  9.76992473e-02f, 2.29494795e-01f, 2.61319578e-02f, 2.14002118e-01f, -1.32062614e-01f, 1.48320489e-03f, 1.01335876e-01f, -1.44973576e-01f, 1.39414117e-01f, -2.47927103e-02f,
  -5.84942438e-02f, 1.12959914e-01f, -5.33632375e-02f, -5.89665063e-02f, 1.80162229e-02f, 2.04152480e-01f, 1.91588491e-01f, -2.75857355e-02f, 1.71936601e-01f, -2.86740903e-02f,
  4.32159081e-02f, -2.01473609e-01f, -2.29177192e-01f, 8.96000415e-02f, -3.78056504e-02f, -8.93178582e-02f, -5.93453236e-02f, 5.02295904e-02f, -8.77268612e-03f, -9.35017765e-02f,
  4.69606668e-02f, 1.24030933e-01f, -1.33509701e-02f, 4.94050197e-02f, -4.36524078e-02f, -1.62956551e-01f, 3.65205780e-02f, -2.11339118e-03f, -1.17880210e-01f, -8.92676413e-02f,
  1.68256924e-01f, -4.56923284e-02f, 1.88469648e-01f, -7.99005553e-02f, 6.68975785e-02f, 8.34797174e-02f, -2.52811275e-02f, 3.34916078e-02f, 1.41899288e-01f, 8.26122090e-02f,
  4.68489788e-02f, 1.09491460e-01f, 1.26857489e-01f, -1.18060485e-02f, 5.61421216e-02f, 7.59060532e-02f, -6.34097680e-02f, -1.79608360e-01f, -2.13664249e-01f, 1.29602756e-02f,
  9.58285704e-02f, -9.49772373e-02f, -1.02588482e-01f, 6.00036494e-02f, 5.28045325e-03f, -2.33866312e-02f, 1.38393015e-01f, -6.39855340e-02f, 3.15732264e-04f, 8.43437240e-02f,
  1.94159746e-01f, 5.14377607e-03f, 2.98683550e-02f, 1.81701109e-02f, 7.90946633e-02f, -8.08514189e-03f, 1.04306303e-01f, -9.96269584e-02f, -1.43005431e-01f, -3.94583307e-02f,
  -3.62574197e-02f, 2.27850694e-02f, 2.60767411e-03f, 8.11153725e-02f, 3.87505367e-02f, 6.03062138e-02f, -5.10347113e-02f, -1.39221653e-01f, -5.47699220e-02f, -1.11906968e-01f,
  1.14730664e-01f, -1.79528356e-01f, -1.51889935e-01f, -1.17166936e-01f, 1.80061445e-01f, -8.10886994e-02f, -3.67502831e-02f, -1.41563281e-01f, -1.99519232e-01f, 7.29773119e-02f,
  -1.24724545e-01f, 1.21259630e-01f, -1.53439986e-02f, 5.78405708e-03f, 9.23916399e-02f, -6.77618012e-02f, -5.09921089e-02f, -1.00800551e-01f, -5.58462106e-02f, 6.98903874e-02f,
  8.46627355e-02f, -8.95684958e-02f, -5.78150079e-02f, -7.65989125e-02f, 1.07237212e-02f, 9.83664989e-02f, -7.27896094e-02f, 1.48321584e-01f, 2.93017309e-02f, 7.03414679e-02f,
  -1.33376628e-01f, -1.25718892e-01f, 2.43079334e-01f, -1.28361613e-01f, 9.49039012e-02f, -7.40208998e-02f, -6.70708567e-02f, -1.48435747e-02f, 1.53277233e-01f, 7.22721666e-02f,
  1.15586571e-01f, 6.32270202e-02f, 3.39247137e-02f, 3.14202383e-02f, -2.21518632e-02f, 1.88836902e-02f, 1.30403444e-01f, 1.17463835e-01f, 1.48791134e-01f, 1.02783211e-01f,
  9.47622061e-02f, -6.96568042e-02f, 8.17962214e-02f, 1.35929391e-01f, 4.19125184e-02f, 8.89770910e-02f, -2.57662050e-02f, -2.60459900e-01f, 2.83567220e-01f, 4.41962481e-02f,
  4.23178039e-02f, 2.73031622e-01f, -1.74534455e-01f, -2.60250181e-01f, -1.80304587e-01f, 9.72935334e-02f, -1.21606849e-01f, 1.58450201e-01f, -1.80068359e-01f, -1.60266548e-01f,
  1.46315508e-02f, -2.06846744e-02f, 9.15899128e-02f, 7.98712224e-02f, -1.67094395e-01f, -2.87802853e-02f, 9.21701174e-03f, -6.87551945e-02f, -8.93806815e-02f, -1.60851758e-02f,
  -1.59374475e-01f, 2.94180885e-02f, -1.46577489e-02f, -3.17218830e-03f, 9.67815891e-02f, 1.19422143e-02f, 2.02729538e-01f, -5.63234687e-02f, 6.10633418e-02f, 1.22013092e-01f,
  2.97263324e-01f, 1.42724916e-01f, 1.61216468e-01f, -9.05128568e-02f, 6.96892887e-02f, 1.09519899e-01f, 1.32339314e-01f, -1.04572199e-01f, 8.69935229e-02f, -5.21611720e-02f,
  6.72079250e-02f, 1.27217859e-01f, 7.75371818e-03f, 2.20950723e-01f, -6.90333769e-02f, 1.08091511e-01f, 1.28841594e-01f, 6.73453063e-02f, 4.13533412e-02f, 6.30742013e-02f,
  -4.09266092e-02f, -1.39451772e-01f, -6.38510287e-02f, 1.21261343e-01f, 2.43578702e-01f, -4.04596468e-03f, 1.13018222e-01f, -1.17842825e-02f, 1.54628113e-01f, -2.96696275e-02f,
  3.29323232e-01f, 1.88352451e-01f, 1.43439025e-01f, 1.47449896e-01f, -2.89968289e-02f, 3.77637371e-02f, 2.33803928e-01f, 4.56289090e-02f, 3.18478972e-01f, -9.92862061e-02f,
  3.21907490e-01f, -1.11570716e-01f, 9.29936394e-02f, -2.21359178e-01f, -2.18593791e-01f, 1.03539333e-01f, 2.90731322e-02f, 2.02622190e-01f, 3.25319082e-01f, -1.57322008e-02f,
  -1.00394264e-01f, -9.01960880e-02f, 6.75220415e-02f, -1.95531398e-02f, 1.64921477e-01f, -1.00274816e-01f, -7.45341107e-02f, 2.41263226e-01f, 2.94991404e-01f, 1.91534698e-01f,
  8.42806399e-02f, 1.78358108e-01f, 1.08827218e-01f, -3.93653512e-02f, -1.80670798e-01f, -4.45966013e-02f, 1.21583082e-01f, 2.26405308e-01f, 3.98663282e-02f, 1.44763649e-01f,
  -1.21582352e-01f, -1.13419048e-01f, 7.93846548e-02f, 1.16911903e-01f, 1.34247886e-02f, 1.45058185e-01f, 2.24006996e-02f, -2.13871095e-02f, 2.01173779e-02f, -9.66060981e-02f,
  8.88118893e-02f, 1.26824677e-01f, 1.97809070e-01f, 2.64255524e-01f, 1.67260915e-01f, 2.20229819e-01f, 2.32705891e-01f, 1.30379066e-01f, 1.63991109e-01f, 1.67153612e-01f,
  -3.03917434e-02f, -1.29852831e-01f, 1.58615872e-01f, -3.55126001e-02f, 1.11517563e-01f, -8.26568305e-02f, -5.58959134e-02f, 1.95469633e-01f, -1.45885006e-01f, 5.00153415e-02f,
  2.62569897e-02f, 1.11464292e-01f, 1.03471084e-02f, -2.53933161e-01f, -1.94284558e-01f, 4.10756059e-02f, 1.07535452e-01f, -2.88374782e-01f, 1.69084951e-01f, -1.28920019e-01f,
  1.89572647e-01f, 1.30737662e-01f, 9.30640325e-02f, -8.93547907e-02f, 8.02658498e-02f, 2.18113154e-01f, 5.12892641e-02f, 7.47552738e-02f, -4.54828516e-02f, 1.44345969e-01f,
  6.93452060e-02f, -4.89075109e-02f, -4.09434661e-02f, 1.16455548e-01f, -2.29831468e-02f, -6.55940995e-02f, -2.22766865e-02f, -1.58061191e-01f, -1.03328899e-01f, -1.97963133e-01f,
  -3.68668102e-02f, -4.10347916e-02f, 1.75915435e-01f, 2.47387677e-01f, 1.90592691e-01f, -5.72752953e-02f, -1.92714244e-01f, 3.00864518e-01f, 1.36108711e-01f, 6.51020780e-02f,
  1.13506727e-01f, 2.28181295e-02f, 1.80606153e-02f, -5.32352328e-02f, 1.01818055e-01f, 1.82897195e-01f, 1.34640783e-01f, 1.43474028e-01f, 6.26192316e-02f, -1.17579438e-01f,
  8.48794449e-03f, 5.75263835e-02f, 2.70598710e-01f, 4.59830239e-02f, 6.00979552e-02f, 1.21802948e-01f, 1.19401731e-01f, 2.50614360e-02f, 2.98957050e-01f, 4.92909104e-02f,
  1.49591744e-01f, -1.52571523e-03f, -1.39673367e-01f, -4.67867665e-02f, 1.08477339e-01f, -1.38621464e-01f, 2.87071079e-01f, -5.98874204e-02f, 1.24505639e-01f, 7.89921135e-02f,
  1.80019110e-01f, -1.33853137e-01f, 4.84766625e-02f, 9.42225382e-02f, -1.95667744e-01f, 3.08641613e-01f, 4.92344536e-02f, -5.08430451e-02f, -1.95720587e-02f, -1.49647981e-01f,
  1.17566630e-01f, -3.71409208e-02f, -3.94970700e-02f, -1.37357548e-01f, 3.63351516e-02f, -5.34291342e-02f, 2.40963176e-01f, 1.04235888e-01f, -1.03374280e-01f, -6.64730445e-02f,
  -1.09917499e-01f, 2.17739493e-01f, 6.17164224e-02f, 3.74080651e-02f, 1.30667284e-01f, 1.31283358e-01f, -8.81314650e-02f, 6.39996305e-02f, 1.57341167e-01f, -4.12046947e-02f,
  1.52323067e-01f, -8.15273896e-02f, -8.03505629e-02f, 1.81267947e-01f, 1.08921669e-01f, 1.94233015e-01f, 2.30106831e-01f, 1.45947054e-01f, 1.99755818e-01f, 1.29094645e-01f,
  1.22164814e-02f, 1.92770645e-01f, 1.02719940e-01f, 1.94943234e-01f, 7.85860717e-02f, 1.41677871e-01f, 9.66374353e-02f, 2.81536877e-01f, -5.04096039e-02f, -4.31734584e-02f,
  7.72118941e-02f, 3.03011209e-01f, 1.48398138e-03f, -1.66229010e-01f, 1.97007388e-01f, 1.20111287e-01f, -6.41389713e-02f, -3.42497587e-01f, 8.59558806e-02f, -1.02245428e-01f,
  2.11275682e-01f, 6.86302632e-02f, -8.80436227e-02f, -6.75633401e-02f, 2.00602040e-01f, 2.89361209e-01f, -5.65022826e-02f, -3.27559114e-01f, -3.24193925e-01f, 9.05802622e-02f,
  -1.96201161e-01f, 9.55442041e-02f, -1.09431110e-02f, -2.17902914e-01f, 1.50089487e-01f, -1.33640822e-02f, 1.82878245e-02f, -1.50938809e-01f, -3.63757461e-02f, 4.32380661e-03f,
  2.04563946e-01f, -1.28876548e-02f, -1.32972421e-02f, -8.45474079e-02f, -6.05471656e-02f, 3.72610182e-01f, 2.23096520e-01f, 2.96663195e-01f, -7.09771067e-02f, 2.97456626e-02f,
  5.69367521e-02f, -2.47642472e-01f, 1.11199021e-01f, 9.86225903e-02f, 1.59555510e-01f, -1.65384263e-01f, 2.10081309e-01f, 1.33499578e-01f, 1.54823929e-01f, 8.76401812e-02f,
  4.39703278e-02f, 5.40358014e-02f, 1.34124709e-02f, 9.72460330e-05f, 1.11676931e-01f, 6.23380952e-02f, 2.41638198e-01f, -4.77656201e-02f, 2.52956122e-01f, 5.19928075e-02f,
  -5.26599437e-02f, 1.70691743e-01f, 1.06390297e-01f, 1.19351007e-01f, -4.98369476e-03f, 1.46813378e-01f, 1.91269383e-01f, 1.51024386e-01f, -5.89495711e-02f, -1.00788318e-01f,
  -5.30239847e-03f, -2.64783408e-02f, -1.41807050e-01f, -1.81806773e-01f, -8.80411863e-02f, -7.42209796e-03f, 1.50038339e-02f, 1.10120334e-01f, -1.94549467e-02f, 1.23488776e-01f,
  -1.61824062e-01f, -1.01479627e-01f, -3.46147642e-02f, -5.34484200e-02f, -6.98203146e-02f, 5.27227856e-02f, 1.01201229e-01f, -5.07473461e-02f, 1.08600661e-01f, -5.36063053e-02f,
  1.30332172e-01f, -2.13143587e-01f, 3.60046187e-03f, -1.23661563e-01f, 4.38639298e-02f, 7.25297779e-02f, -8.47709849e-02f, 9.83693898e-02f, -9.60627198e-02f, 1.87787309e-01f,
  -4.33486514e-02f, 2.39625335e-01f, 1.12686194e-01f, 7.25796372e-02f, 1.72773618e-02f, 6.39941990e-02f, -1.21209823e-01f, 1.51935577e-01f, 1.87002853e-01f, -5.66523476e-03f,
  -5.77013940e-02f, 4.30255644e-02f, -4.28117253e-03f, -6.53514341e-02f, -1.18505590e-01f, -2.37553883e-02f, 4.41878997e-02f, -8.98452401e-02f, -7.85874017e-03f, -9.18260440e-02f,
  4.01576534e-02f, 8.14116150e-02f, 1.02422863e-01f, -3.06766462e-02f, 1.48076760e-02f, -1.09655470e-01f, -2.76394952e-02f, -5.33563718e-02f, -6.43642768e-02f, 3.38632166e-02f,
  4.71963584e-02f, 1.09784678e-01f, 5.24146073e-02f, 7.02033564e-02f, 1.78781468e-02f, -4.69355099e-02f, 1.16571113e-01f, -1.10114127e-01f, -7.07937926e-02f, -9.72884148e-02f,
  6.94481209e-02f, -7.91948363e-02f, 1.24646716e-01f, -6.59517497e-02f, -4.28964868e-02f, 1.74354792e-01f, 1.36558712e-01f, -5.60453348e-02f, 1.76852062e-01f, 1.48010492e-01f,
  2.46115960e-02f, 5.32238074e-02f, -5.43810800e-02f, 8.87469724e-02f, 1.92166880e-01f, -8.07399452e-02f, 5.33974683e-03f, 1.52348895e-02f, 1.85921252e-01f, 1.40549868e-01f,
  1.61629423e-01f, -3.29493023e-02f, -3.19107287e-02f, 2.13561561e-02f, 1.65842623e-02f, -2.82171071e-02f, 9.13864002e-02f, 1.68970078e-01f, 1.16440080e-01f, -3.85936797e-02f,
  1.90119091e-02f, -2.90250462e-02f, 5.04785813e-02f, -4.77072783e-02f, 6.46005422e-02f, 1.50277376e-01f, 9.63822082e-02f, 4.07863110e-02f, -5.31265363e-02f, 1.33352861e-01f,
  1.45331562e-01f, -8.65810663e-02f, -1.09470524e-01f, 6.49225488e-02f, 1.34153441e-01f, -1.44167647e-01f, 9.33589712e-02f, -4.68458533e-02f, 2.94847675e-02f, 8.60689431e-02f,
  1.96168363e-01f, 1.29785031e-01f, 2.08492298e-02f, 2.12709546e-01f, 2.51104206e-01f, 2.11557344e-01f, 1.00889072e-01f, 2.19496191e-02f, -1.83850974e-01f, 1.63976625e-01f,
  -1.77242324e-01f, -4.07833338e-01f, -1.13778196e-01f, 1.12596862e-01f, 1.27839178e-01f, -1.38403149e-02f, 3.94334868e-02f, -9.50592458e-02f, 1.69749647e-01f, 1.18547082e-02f,
  -1.37858689e-01f, 2.04364836e-01f, -7.10830390e-02f, 5.86170219e-02f, 1.30470589e-01f, 3.03890705e-01f, -1.88495249e-01f, -7.12053254e-02f, -1.32741615e-01f, -2.70951763e-02f,
  -5.79396747e-02f, 6.43126667e-02f, 1.16876997e-01f, 9.73753706e-02f, -1.25238821e-01f, -4.35311608e-02f, 1.52155645e-02f, 1.01574346e-01f, 3.10770776e-02f, 2.64409065e-01f,
  1.88271284e-01f, 7.87579939e-02f, 1.72367930e-01f, -1.14520676e-01f, 2.64165979e-02f, 1.79429621e-01f, 2.54050136e-01f, 6.02535270e-02f, 1.02690220e-01f, -1.02098443e-01f,
  -8.42376947e-02f, -3.18218507e-02f, -6.32958114e-02f, -8.13754275e-02f, -1.06078023e-02f, -5.04932813e-02f, -1.54157681e-03f, 8.42293445e-03f, 2.24853419e-02f, 1.09143347e-01f,
  1.18447326e-01f, 3.45881172e-02f, -3.28786895e-02f, 7.52241611e-02f, 6.47665262e-02f, 3.00044045e-02f, 6.04743920e-02f, -2.89154407e-02f, -4.86303717e-02f, -1.05730906e-01f,
  -1.87352747e-02f, 2.40750853e-02f, 1.25896171e-01f, 5.49675338e-02f, 4.00238112e-02f, -1.15366049e-01f, -1.45925939e-01f, 4.92059216e-02f, -1.03287213e-02f, 5.90598583e-02f,
  -1.48942053e-01f, -2.26384914e-03f, 1.06890179e-01f, 9.85828117e-02f, 1.37931556e-01f, 3.28431539e-02f, 9.12163854e-02f, -8.40246081e-02f, -6.63936734e-02f, 4.97314073e-02f,
  2.94421390e-02f, 8.62276331e-02f, 1.04901142e-01f, 4.01747972e-02f, 7.45980293e-02f, -5.20150177e-02f, 9.12800729e-02f, 5.47648408e-03f, 5.54026179e-02f, 1.20900497e-02f,
  9.83420536e-02f, 1.19680367e-01f, -1.11237867e-02f, 1.27868101e-01f, -2.18859296e-02f, -7.33896624e-04f, -1.49710020e-02f, -9.30467471e-02f, -6.30954430e-02f, -4.24320884e-02f,
  -6.42793626e-02f, -3.09039671e-02f, -3.93577442e-02f, 2.76762452e-02f, 1.66610889e-02f, 1.86992556e-01f, 8.11627805e-02f, 1.45168215e-01f, -1.15901396e-01f, -1.15046084e-01f,
  2.09581032e-02f, -1.13896683e-01f, 6.17897548e-02f, -9.04561952e-02f, 1.37357950e-01f, 2.47989297e-02f, 1.83815025e-02f, 1.32395804e-01f, 1.86565191e-01f, 2.16364339e-01f,
  5.60701406e-03f, 2.38140840e-02f, 1.75103158e-01f, -4.23539616e-02f, 2.41569403e-04f, -1.95644468e-01f, 2.85927523e-02f, 3.83522063e-02f, -7.66908899e-02f, -2.22493976e-01f,
  -6.57434314e-02f, 1.19257845e-01f, -1.67077377e-01f, -1.04526088e-01f, -3.93181108e-02f, 1.64885044e-01f, -1.72085389e-01f, -1.04465738e-01f, -3.12305167e-02f, 3.46456915e-02f,
  7.17630610e-02f, -1.88042838e-02f, -3.70265879e-02f, -9.13937539e-02f, 8.93404856e-02f, 8.45296234e-02f, -6.62161503e-03f, -3.11197266e-02f, -5.08254441e-03f, 1.29938528e-01f,
  4.30346616e-02f, 6.88091591e-02f, 4.02228571e-02f, 1.19367532e-01f, -7.98885990e-03f, 2.69939989e-01f, 1.67608380e-01f, 2.32103899e-01f, -2.53866222e-02f, 2.05242902e-01f,
  -5.81741408e-02f, -1.42084599e-01f, -2.77141005e-01f, 5.45885079e-02f, 2.14018121e-01f, 1.13899549e-02f, 7.71729350e-02f, 1.94471732e-01f, 1.44432724e-01f, 1.34134278e-01f,
  2.01268703e-01f, -9.60991085e-02f, 1.30356297e-01f, 6.40457449e-03f, -1.00305341e-02f, 1.09221917e-02f, 1.85797095e-01f, 8.48063007e-02f, 3.16785052e-02f, 1.26207873e-01f,
  6.98933229e-02f, 6.38618022e-02f, 1.32746756e-01f, 1.03747047e-01f, 1.37465164e-01f, -3.07014644e-01f, 2.85497636e-01f, 1.61880270e-01f, -1.51738571e-02f, -6.05801940e-02f,
  2.62019992e-01f, 1.97632670e-01f, 3.59993465e-02f, 2.82594264e-01f, -1.37138203e-01f, 1.74197089e-02f, 1.90809667e-01f, -1.03249319e-01f, 1.06130935e-01f, -1.69945240e-01f,
  -1.90373376e-01f, 2.99440742e-01f, 2.59157389e-01f, -1.71591248e-02f, 4.30494457e-01f, 1.20035589e-01f, 5.73783778e-02f, 6.85140640e-02f, 8.05358812e-02f, 2.22069636e-01f,
  1.14662729e-01f, 5.31105548e-02f, -4.31914628e-02f, 2.87227571e-01f, -6.95205554e-02f, -1.74937174e-02f, 6.28924221e-02f, 2.22998425e-01f, 6.85798153e-02f, 1.17446072e-02f,
  -1.32910445e-01f, -9.33076292e-02f, 6.60282969e-02f, 3.55399437e-02f, 8.94214660e-02f, 2.68438578e-01f, -1.76197991e-01f, -1.01168238e-01f, 7.45633319e-02f, 1.53595611e-01f,
  -1.02820717e-01f, 3.71309929e-02f, 3.81693207e-02f, 9.13601518e-02f, 4.75437939e-02f, -8.04175213e-02f, -5.36567420e-02f, 2.92898417e-02f, 1.15255248e-02f, 9.31322724e-02f,
  -9.04505923e-02f, -1.11968659e-01f, 9.11770239e-02f, -1.21921703e-01f, -9.11764335e-03f, -6.91120923e-02f, -1.42732978e-01f, 6.43743761e-03f, -3.92502248e-02f, 1.18716426e-01f,
  4.17380296e-02f, 7.09636211e-02f, 1.23336919e-01f, 6.11722730e-02f, -3.29444334e-02f, 1.13649711e-01f, 1.00938641e-01f, 9.51559618e-02f, 1.16032287e-01f, 4.85643074e-02f,
  1.77353527e-02f, 1.06497183e-02f, 1.19390001e-03f, -1.03277773e-01f, -5.40267788e-02f, -4.90994006e-02f, -6.62384555e-02f, -1.09836156e-03f, -3.79731245e-02f, 3.94258238e-02f,
  -7.74164572e-02f, 2.04877909e-02f, -6.55896142e-02f, 1.99580695e-02f, -9.41148251e-02f, 1.16809115e-01f, -5.08561321e-02f, 5.62047549e-02f, 5.49483821e-02f, -5.54389469e-02f,
  -1.07230678e-01f, -6.03821538e-02f, -7.23413974e-02f, 1.15320720e-01f, 1.19230468e-02f, 1.23403437e-01f, -1.15545511e-01f, -1.29379690e-01f, -3.36650647e-02f, 5.34344539e-02f,
  -3.00940294e-02f, 1.07662249e-02f, 1.14703745e-01f, -6.11671396e-02f, 7.80455247e-02f, -8.24871510e-02f, -5.86166941e-02f, 1.02866709e-01f, -8.59960467e-02f, 9.63717923e-02f,
  1.20681703e-01f, 5.50565645e-02f, -7.77897239e-02f, 1.41329840e-01f, 8.41958225e-02f, -4.42761835e-03f, 1.99512355e-02f, 1.08301982e-01f, 1.26492709e-01f, 8.02810043e-02f,
  4.84336317e-02f, 1.10231042e-01f, 1.54112622e-01f, -8.99351574e-03f, -1.84797898e-01f, 3.01767103e-02f, -4.15782519e-02f, 1.51985273e-01f, 1.44931078e-01f, -2.62132019e-01f,
  1.84689268e-01f, 2.64358044e-01f, 3.31639275e-02f, 1.00444250e-01f, 1.90358832e-01f, -3.04531846e-02f, 7.22143874e-02f, -2.83418540e-02f, 2.17631236e-02f, 1.51046470e-01f,
  1.27466664e-01f, 1.00418646e-02f, -2.92243920e-02f, 9.20980703e-03f, -4.89946157e-02f, 8.80951136e-02f, 1.60638615e-01f, 3.00742369e-02f, -1.02559544e-01f, 1.57001447e-02f,
  9.56266075e-02f, -6.10206798e-02f, -2.46955846e-02f, 1.01438969e-01f, 9.02790427e-02f, 8.73122141e-02f, 7.19184801e-02f, -1.52585119e-01f, -5.19598648e-02f, -1.00206420e-01f,
  -2.51956172e-02f, 5.05336225e-02f, 8.72958899e-02f, 9.35652107e-02f, -7.40746334e-02f, 1.25588104e-01f, -5.60769551e-02f, -7.21754208e-02f, 1.08879402e-01f, 8.46944749e-02f,
  -1.04502417e-01f, 6.43285140e-02f, -9.69156995e-02f, 2.09642742e-02f, -6.50014058e-02f, 4.83800732e-02f, -3.34336609e-02f, -1.17185287e-01f, -6.68834597e-02f, -1.17317848e-01f,
  -2.93760244e-02f, -8.37046504e-02f, -2.25468408e-02f, 1.20007180e-01f, 3.71713862e-02f, -4.47132774e-02f, -1.06042095e-01f, 1.07375212e-01f, -9.44612995e-02f, 8.74973387e-02f,
  1.12040468e-01f, -8.39614049e-02f, -4.93750945e-02f, 2.30452120e-02f, -9.04124379e-02f, 6.49414882e-02f, 8.52098018e-02f, 9.28662345e-02f, -8.11336562e-04f, 8.73455405e-02f,
  1.17828786e-01f, 7.86021799e-02f, -3.25887017e-02f, -9.67298225e-02f, 1.06741086e-01f, -1.07275443e-02f, -7.67108649e-02f, 1.20902404e-01f, 1.02990568e-02f, -1.14204101e-01f,
  -8.95933062e-02f, 7.82641321e-02f, -3.91824991e-02f, -1.15966700e-01f, 1.01291038e-01f, 9.57159773e-02f, -2.82692034e-02f, -9.52231586e-02f, -6.64200410e-02f, 1.20141551e-01f,
  -2.01498121e-02f, -4.72101234e-02f, -1.22317143e-01f, -5.71421012e-02f, -1.06873095e-01f, 1.22061528e-01f, -1.09087527e-01f, -1.22214660e-01f, -7.83362463e-02f, -2.15117782e-02f,
  -1.17778331e-01f, 1.12131499e-01f, -8.13172311e-02f, 2.28466410e-02f, -5.08456044e-02f, -1.04021445e-01f, -1.00744218e-01f, 1.55907432e-02f, -1.18621930e-01f, 1.06714077e-01f,
  6.02105632e-04f, 9.12477300e-02f, -4.55106981e-02f, -1.03189200e-01f, -2.82410812e-02f, -2.30762661e-02f, 1.17258377e-01f, -1.20005041e-01f, -3.16536985e-02f, 1.36324149e-02f,
  -1.21353231e-01f, 1.42029878e-02f, -1.05320707e-01f, 7.35303015e-02f, -3.99188250e-02f, 2.53602862e-02f, 4.66803163e-02f, -1.14669220e-03f, 6.34801537e-02f, 7.49741495e-03f,
  2.73601580e-02f, 7.73266852e-02f, 2.05960087e-02f, -9.53353345e-02f, 5.02016582e-02f, 4.63793874e-02f, -9.96608362e-02f, 1.12250231e-01f, -1.77513324e-02f, 9.07596201e-02f,
  3.36905643e-02f, -3.05009577e-02f, 5.61914481e-02f, 7.22540095e-02f, -8.64363462e-02f, 9.38867480e-02f, -5.41031174e-02f, -1.03244551e-01f, -1.14329226e-01f, 7.97240958e-02f,
  -1.15421938e-03f, 6.44567013e-02f, -3.66710126e-02f, -4.25747894e-02f, 5.15658073e-02f, 4.34472365e-03f, 3.97347361e-02f, 3.78343463e-02f, -8.09691772e-02f, -9.09927040e-02f,
  -9.62893106e-03f, -8.67728591e-02f, 1.23440184e-01f, -3.20092365e-02f, -3.79752740e-02f, -7.54635632e-02f, 2.09634695e-02f, -4.44298331e-03f, 9.60405841e-02f, -9.36534908e-03f,
  1.24621995e-01f, 6.77752681e-03f, 2.72405952e-01f, 2.43216813e-01f, -5.60169145e-02f, 2.36559048e-01f, -1.54420510e-02f, 8.16753134e-02f, 1.64716735e-01f, 4.64019887e-02f,
  1.39614284e-01f, 6.25401512e-02f, 7.54643753e-02f, 2.34849021e-01f, 9.83119570e-03f, 3.65547538e-02f, -1.68736670e-02f, -6.61640316e-02f, 2.21058756e-01f, 3.84107113e-01f,
  2.69740701e-01f, -1.66841090e-01f, 2.80491889e-01f, 1.67601019e-01f, 1.78702295e-01f, 7.56927859e-03f, 3.12040895e-01f, 1.01594262e-01f, -8.02541375e-02f, -1.19476885e-01f,
  5.79635128e-02f, 7.95404240e-02f, 4.56023775e-02f, 7.23870620e-02f, 2.92460527e-03f, 6.99617192e-02f, 1.18523493e-01f, -1.46006808e-01f, 1.18779086e-01f, -1.21025756e-01f,
  3.03749405e-02f, 1.48013905e-01f, 2.98508666e-02f, -5.28291985e-02f, 1.35388672e-01f, 2.09904075e-01f, 1.80172652e-01f, 5.93129955e-02f, -6.70863912e-02f, -2.12703701e-02f,
  -6.61945865e-02f, 8.39301348e-02f, 7.84867704e-02f, -1.89709030e-02f, -1.11966684e-01f, -2.40749400e-02f, 1.29937798e-01f, -1.22790495e-02f, 1.37933820e-01f, -1.37262633e-02f,
  7.27800361e-04f, 9.31689441e-02f, 9.33568832e-03f, -1.20770983e-01f, -1.18089784e-02f, -5.45600168e-02f, 8.82519856e-02f, -6.76961839e-02f, 1.01108484e-01f, -1.01952687e-01f,
  4.08598185e-02f, -9.14352760e-02f, -1.09000139e-01f, -5.31488396e-02f, -3.04280650e-02f, -6.01214655e-02f, -7.87188038e-02f, -1.38270902e-03f, 5.14200218e-02f, 1.21584415e-01f,
  9.73625761e-03f, 2.28599142e-02f, -7.60948732e-02f, -8.16610157e-02f, 7.12685883e-02f, -2.31347792e-02f, 9.98160318e-02f, -1.03592932e-01f, -3.92910391e-02f, -1.24162421e-01f,
  1.17662534e-01f, -7.52126202e-02f, -3.49310227e-02f, -1.03943944e-01f, 8.44818652e-02f, -5.72215728e-02f, 2.60831118e-02f, -7.41208568e-02f, -9.95062143e-02f, -3.16874608e-02f,
  -1.23597689e-01f, -3.72535512e-02f, 8.97943452e-02f, -5.85287400e-02f, -1.76434778e-02f, 4.24717218e-02f, 1.96862034e-02f, -1.17564037e-01f, -5.80351129e-02f, 5.93993738e-02f,
  -1.06447220e-01f, 1.07539877e-01f, 1.15098804e-01f, -6.22502305e-02f, -6.57458827e-02f, 8.44370797e-02f, 6.09216243e-02f, 1.00996360e-01f, -7.52277160e-03f, -7.53685161e-02f,
  -8.16689953e-02f, -5.00644259e-02f, -5.92174195e-02f, -8.24445412e-02f, -7.83396885e-02f, -1.60810165e-02f, 3.21753323e-02f, -1.03991628e-01f, 3.85336503e-02f, -1.19231783e-01f,
  5.45395948e-02f, -9.36729088e-03f, -5.86262718e-02f, -1.12107970e-01f, -4.43029143e-02f, -1.01998024e-01f, -8.59512687e-02f, 2.64197011e-02f, -1.04665138e-01f, 1.82875358e-02f,
  2.09454149e-02f, -2.17513405e-02f, 7.72542208e-02f, -8.79316851e-02f, -1.90864783e-02f, 1.10884354e-01f, 2.63712811e-03f, 8.09816942e-02f, -9.08076018e-02f, -8.21072757e-02f,
  1.03523262e-01f, 5.57811335e-02f, -1.06230199e-01f, 6.95601664e-03f, -3.38151888e-03f, 4.99950070e-03f, 8.70868284e-03f, -1.26169413e-01f, 3.29914642e-03f, -9.99864936e-02f,
  -9.72701386e-02f, 3.94118130e-02f, 4.08490598e-02f, -7.83120915e-02f, -1.23760328e-01f, -7.08031207e-02f, 1.34061212e-02f, 1.16378255e-01f, 1.12674169e-01f, 6.34764060e-02f,
  -8.84118211e-03f, -1.01556562e-01f, -9.90785882e-02f, -2.49280804e-03f, -1.07782803e-01f, 3.70931663e-02f, 4.83549424e-02f, -1.01354502e-01f, -8.71270597e-02f, -1.10818766e-01f,
  -2.13356353e-02f, 2.51160823e-02f, -4.44396399e-02f, 5.01802750e-02f, 1.13816768e-01f, -3.77606824e-02f, 4.60412763e-02f, -1.03511751e-01f, 2.20634528e-02f, -1.68050140e-01f,
  8.84809643e-02f, -5.16780205e-02f, -1.09378323e-01f, 2.65174173e-03f, 1.85386594e-02f, -1.10630393e-01f, 1.59654617e-01f, -1.32395968e-01f, 1.49404347e-01f, 1.54838204e-01f,
  4.69407775e-02f, 1.85355674e-02f, 5.35630286e-02f, -2.35356405e-01f, 8.51063952e-02f, 1.71757907e-01f, 1.54806972e-01f, -4.00573313e-02f, -3.26603919e-01f, 4.57938984e-02f,
  7.91679248e-02f, 6.85650855e-02f, -6.05364842e-03f, 2.19857067e-01f, -1.80491403e-01f, -1.09934829e-01f, 2.45433003e-01f, -8.57373103e-02f, -9.78962779e-02f, -1.37177959e-01f,
  -1.84053898e-01f, 1.35273347e-02f, 2.03686878e-01f, 1.30138576e-01f, 1.35362595e-01f, -7.83824623e-02f, 1.22300863e-01f, 1.36770085e-01f, 2.30843708e-01f, 2.11710006e-01f,
  9.75869372e-02f, -5.49690872e-02f, 1.64522409e-01f, 3.06434989e-01f, 1.30843833e-01f, 1.28225937e-01f, -5.41043766e-02f, 7.65994042e-02f, 4.52741265e-01f, 1.11408606e-02f,
  1.22703165e-01f, -3.82749736e-02f, 2.88379729e-01f, -1.44711554e-01f, 2.46379361e-01f, -1.63506772e-02f, 7.32547864e-02f, 7.57576153e-02f, 1.94395289e-01f, 1.69882327e-01f,
  -1.86319590e-01f, 1.35074064e-01f, 7.55598471e-02f, 1.00281745e-01f, 1.98839143e-01f, -8.43622014e-02f, -1.39904484e-01f, 1.33499339e-01f, 3.86238806e-02f, 1.14884369e-01f,
  1.44240797e-01f, 8.13398231e-03f, 1.86935425e-01f, 2.73322463e-01f, 1.05504043e-01f, 1.70383845e-02f, 7.61824921e-02f, 8.99958685e-02f, 1.30131915e-01f, 1.03331275e-01f,
  4.41879332e-02f, -7.98913538e-02f, -4.02388275e-01f, 2.02842772e-01f, -2.00302169e-01f, -2.10894480e-01f, 5.84904142e-02f, -2.87142545e-01f, -3.05769444e-02f, 2.56394476e-01f,
  -7.69789368e-02f, 3.70395440e-03f, -2.47320265e-01f, -1.09389678e-01f, -1.96230233e-01f, 2.08852485e-01f, -6.19726032e-02f, -2.09059760e-01f, -2.26126492e-01f, -1.15999497e-01f,
  -2.34942697e-02f, -3.03762127e-02f, 1.08980864e-01f, 2.89297968e-01f, 1.50440529e-01f, -1.18296012e-01f, 1.00884154e-01f, 2.40965053e-01f, 3.03233862e-02f, -7.02493545e-03f,
  -1.77108943e-01f, 7.90942386e-02f, 1.12589613e-01f, 1.82670236e-01f, 2.31105685e-01f, 1.95763521e-02f, 6.17195666e-02f, -1.82279676e-01f, 1.06112234e-01f, -7.15578720e-02f,
  -4.89947423e-02f, -6.31016567e-02f, 2.89128810e-01f, 1.86374202e-01f, -1.24655977e-01f, 2.48237848e-01f, -8.21167789e-03f, -6.36454597e-02f, 6.31999150e-02f, -1.73212904e-02f,
  -7.21514598e-02f, 1.09080061e-01f, 8.57787728e-02f, -1.17361903e-01f, -6.24895282e-02f, 1.61347410e-03f, -5.13428263e-02f, -5.82172498e-02f, -1.02528639e-01f, 8.96695107e-02f,
  -2.09671687e-02f, 2.81082876e-02f, -1.11203700e-01f, 1.08027689e-01f, -8.97356793e-02f, 1.05636055e-02f, 8.22331011e-02f, 2.26477478e-02f, 1.70982815e-02f, 2.86554713e-02f,
  2.78789401e-02f, 8.69885534e-02f, 7.91962966e-02f, 1.02036536e-01f, -5.88894635e-02f, -5.91983087e-02f, -5.69879524e-02f, -8.33468214e-02f, -9.10741687e-02f, -1.03420600e-01f,
  -5.37372194e-02f, 1.28892139e-02f, -5.13721816e-02f, 1.21370211e-01f, -8.21348466e-03f, -1.14988305e-01f, -2.65346523e-02f, 4.58694482e-03f, -2.84706857e-02f, 8.65980089e-02f,
  6.25067204e-02f, 8.02835729e-03f, 2.58016475e-02f, -1.00926794e-01f, -7.37213343e-02f, 1.18538029e-02f, -1.06232285e-01f, -9.39839855e-02f, -1.08591102e-01f, 1.54792648e-02f,
  -8.91228393e-02f, -9.59940404e-02f, -1.30240051e-02f, 1.25137076e-01f, -5.12770154e-02f, -1.59153845e-02f, 6.68092296e-02f, 2.83446605e-03f, 1.77986752e-02f, -3.67519744e-02f,
  -1.29511639e-01f, 2.83416025e-02f, -1.33652896e-01f, 1.22358557e-03f, -6.03470840e-02f, 5.42456433e-02f, -3.14364620e-02f, -1.11167943e-02f, -1.18566878e-01f, 2.68924590e-02f,
  8.87569115e-02f, -1.01711065e-01f, -1.43160164e-01f, 6.90453947e-02f, -7.50416815e-02f, -4.97902669e-02f, 3.35402228e-02f, 4.33361717e-02f, 2.71954183e-02f, 4.37089056e-02f,
  3.97735797e-02f, -2.45802868e-02f, 8.45440477e-02f, -7.32104480e-02f, -1.44652994e-02f, -8.14381614e-02f, -1.67387351e-02f, 8.50933269e-02f, -7.92097002e-02f, -7.65321031e-03f,
  8.95128399e-02f, 5.81765994e-02f, 1.71419345e-02f, 3.25580835e-02f, -1.52535215e-02f, 3.63521986e-02f, 3.23626027e-02f, 7.73127601e-02f, -8.76664296e-02f, 1.17542550e-01f,
  4.36479300e-02f, 3.70562635e-02f, -1.07466809e-01f, 9.12145898e-02f, 7.90132359e-02f, 6.38186261e-02f, -5.14544062e-02f, -4.28842530e-02f, -6.39545545e-02f, 8.10384154e-02f,
  -1.21239066e-01f, -9.83445812e-03f, -1.21160947e-01f, 1.80800371e-02f, -1.52226090e-02f, -7.64089376e-02f, 1.06476948e-01f, -3.26219127e-02f, 6.10311404e-02f, 1.77162830e-02f,
  -9.42543224e-02f, -4.58441116e-02f, -5.47586642e-02f, 9.53053236e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -5.28182574e-02f, 3.22433375e-03f, 2.20058724e-01f, -2.30175466e-03f, 3.23757203e-03f, 1.74508095e-01f, 1.90394253e-01f, 7.07020238e-02f, 4.07221615e-02f, 8.74512792e-02f,
  1.97481420e-02f, 9.86180753e-02f, -1.24746757e-02f, 2.84517846e-05f, 1.42536104e-01f, 1.10587507e-01f, 3.24943401e-02f, -2.49188598e-02f, 1.76186729e-02f, 1.77909732e-01f,
  -1.14937998e-01f, 5.67756873e-03f, 1.26278728e-01f, 1.81800142e-01f, 1.13053642e-01f, -7.88319856e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.44270673e-01f, 2.96034813e-01f, -7.21987009e-01f, 9.59941149e-02f, 9.47970450e-02f, 2.67139554e-01f, -7.77873471e-02f, -3.02513152e-01f, 1.41217798e-01f, 2.09862858e-01f,
  8.27547088e-02f, 1.21432103e-01f, 3.56842056e-02f, 2.87968665e-01f, 1.11738838e-01f, -2.39248544e-01f, -8.23150575e-02f, 2.00180367e-01f, -2.50985712e-01f, -4.31235939e-01f,
  -3.36356759e-02f, 2.77116001e-01f, 1.90152586e-01f, 1.99847773e-01f, 2.37486675e-01f, -4.89268035e-01f, -4.41166401e-01f, -3.04214001e-01f, -1.04474738e-01f, 4.58355069e-01f,
  3.09411436e-01f, 3.05854708e-01f, 2.80066788e-01f, 2.52017319e-01f, -4.15696561e-01f, 4.92658406e-01f, 2.12635547e-01f, 5.05869091e-01f, 4.01038416e-02f, -4.06838119e-01f,
  -1.18746646e-01f, 3.35558690e-02f, -1.02522798e-01f, -2.77709574e-01f, -3.12755346e-01f, -3.65068704e-01f, -6.11715950e-02f, 1.06612220e-01f, -1.25335336e-01f, -2.08386585e-01f,
  9.98605341e-02f, -3.04925404e-02f, 3.16805363e-01f, 4.78825270e-04f, 2.66307086e-01f, -3.90255488e-02f, -7.52741247e-02f, 1.78191930e-01f, 1.14578828e-02f, -5.31270616e-02f,
  -1.95830688e-01f, 1.47051111e-01f, 3.36110778e-02f, 6.76498711e-02f, 3.42281699e-01f, 1.42108276e-01f, 3.14559996e-01f, 2.92298079e-01f, 1.41832367e-01f, -1.46947309e-01f,
  1.68118432e-01f, -1.25780970e-01f, 8.71620476e-02f, 9.89146307e-02f, 1.31402984e-01f, -1.10680945e-01f, 6.78709522e-02f, 1.35161340e-01f, 3.88829187e-02f, 2.36205518e-01f,
  3.44688118e-01f, -1.72114953e-01f, 1.86570659e-01f, -1.85028672e-01f, 2.16122687e-01f, 3.24201316e-01f, -3.12083662e-02f, -2.80608088e-01f, 4.76246297e-01f, -1.45460755e-01f,
  -2.51538098e-01f, 1.61863431e-01f, 4.49920118e-01f, 3.04707825e-01f, 5.20102859e-01f, -9.61095244e-02f, 5.65348923e-01f, -6.28378212e-01f, -3.94653641e-02f, -3.58071208e-01f,
  1.87142938e-01f, 2.37382323e-01f, -1.07521832e-01f, -4.82254684e-01f, 2.30622426e-01f, 8.02589133e-02f, -2.29408398e-01f, -2.97773689e-01f, -3.25775862e-01f, -1.82557359e-01f,
  1.03500038e-02f, 4.15110320e-01f, 3.52148116e-02f, -2.02536717e-01f, -3.11317332e-02f, 3.00752938e-01f, -1.39954954e-01f, -5.15483245e-02f, -2.10854828e-01f, 7.16890544e-02f,
  3.30070890e-02f, -4.83618140e-01f, -2.86454428e-02f, -2.67616287e-02f, -1.79920606e-02f, 5.33198953e-01f, -8.34204257e-03f, 3.99494991e-02f, -3.97144854e-01f, 1.23243835e-02f,
  -4.02932614e-02f, -9.29050893e-02f, 5.35187498e-02f, 1.42429247e-01f, -5.38463742e-02f, 1.48819357e-01f, -1.00541385e-02f, 5.49025051e-02f, 9.12625045e-02f, 4.86736139e-03f,
  -2.82440007e-01f, 2.15014547e-01f, 6.89943358e-02f, -1.93418413e-01f, 5.81356473e-02f, 1.10984378e-01f, -4.99079302e-02f, 4.21015769e-01f, -7.67075345e-02f, -4.88970101e-01f,
  -3.72495890e-01f, 6.38080761e-02f, 1.39153332e-01f, 1.43744394e-01f, -1.21135607e-01f, 2.68456936e-01f, 3.93755585e-01f, 3.73665154e-01f, -2.00879589e-01f, -2.98714370e-01f,
  1.93814412e-01f, -1.85515687e-01f, 5.00411630e-01f, -3.57113749e-01f, 6.80199936e-02f, 3.00310850e-01f, 7.49800727e-02f, -3.44257444e-01f, 1.16357960e-01f, -1.93036482e-01f,
  3.40777695e-01f, -4.04573560e-01f, -3.21803331e-01f, 2.26911865e-02f, 4.73432153e-01f, 2.44886309e-01f, -5.26817292e-02f, 3.78762841e-01f, 6.33276030e-02f, 4.50374514e-01f,
  -2.31845364e-01f, -1.10842250e-01f, -1.12562120e-01f, 5.25151417e-02f, -1.01494335e-01f, -3.16892415e-01f, 7.84432665e-02f, 4.37267534e-02f, -2.77873367e-01f, -2.41794899e-01f,
  8.67732521e-03f, -3.78018175e-03f, -2.27460176e-01f, 1.35836914e-01f, -4.51232463e-01f, -2.91212499e-02f, -9.68017578e-02f, 2.04169497e-01f, -2.45488286e-01f, -1.06885947e-01f,
  8.62545073e-02f, -4.35469091e-01f, -1.36039823e-01f, -6.52427822e-02f, -1.20482601e-01f, -7.04796836e-02f, -2.79714108e-01f, 1.60117865e-01f, 9.73060727e-02f, 2.50188380e-01f,
  2.12673657e-02f, -1.21248290e-01f, -1.67465031e-01f, 4.45131689e-01f, 7.43846074e-02f, 2.18755379e-01f, 1.54497355e-01f, 2.52424508e-01f, 2.59280145e-01f, -1.28872201e-01f,
  1.43642753e-01f, -1.89478487e-01f, -3.81159991e-01f, 4.04624015e-01f, 2.95995086e-01f, 3.32026668e-02f, -5.19235022e-02f, 1.89846322e-01f, -4.52762663e-01f, -3.17159414e-01f,
  4.12320532e-02f, 3.33447903e-01f, -3.02693993e-01f, 2.32731029e-02f, -2.70662278e-01f, 2.16198042e-01f, 4.06166017e-01f, -2.18309611e-01f, -4.62821513e-01f, -4.11988288e-01f,
  7.70144388e-02f, -2.54231423e-01f, 1.03258327e-01f, -2.49509007e-01f, 5.38337290e-01f, -3.10387947e-02f, 1.30254740e-03f, -1.14694297e-01f, -4.28756848e-02f, 6.65189251e-02f,
  1.03427216e-01f, -3.15873623e-02f, 1.05362572e-02f, 6.49567395e-02f, -6.57951459e-02f, -1.29182143e-02f, 2.30836242e-01f, -2.84801602e-01f, -7.07859546e-02f, 1.63067076e-02f,
  -9.62536484e-02f, -2.14628249e-01f, 1.34311125e-01f, 1.32939070e-01f, 1.64117560e-01f, -1.84984058e-01f, 9.98400599e-02f, 5.77454679e-02f, 2.45341077e-01f, 3.24929267e-01f,
  6.66624755e-02f, -2.96743531e-02f, -2.38913000e-01f, 3.76247883e-01f, 4.71740402e-02f, -1.54333502e-01f, -2.30789810e-01f, 3.79638165e-01f, -1.11147642e-01f, 2.38708302e-01f,
  -4.83010054e-01f, 1.08080439e-01f, 3.26173335e-01f, -1.34488299e-01f, -3.72706205e-01f, -8.05359185e-02f, 2.63807535e-01f, -1.93232730e-01f, -4.24350053e-01f, 3.39286655e-01f,
  -2.14305788e-01f, 2.01108009e-01f, -4.95566018e-02f, 3.30745131e-01f, -2.63755113e-01f, 2.23934382e-01f, -3.06434602e-01f, -8.64360183e-02f, -1.06629543e-01f, 4.11301970e-01f,
  1.80942252e-01f, 3.61903965e-01f, -2.63434917e-01f, 1.33360758e-01f, 9.60549042e-02f, -3.45195830e-02f, -9.40943435e-02f, -2.04680398e-01f, 3.15099418e-01f, -6.84931353e-02f,
  3.47382754e-01f, 5.50830886e-02f, -1.81027651e-02f, 4.10944879e-01f, -8.62071589e-02f, 1.81743093e-02f, -3.43549669e-01f, -3.52736801e-01f, 4.77066077e-02f, -7.81112686e-02f,
  1.37475476e-01f, -8.44008476e-03f, 1.66904047e-01f, -1.45235941e-01f, -5.02448939e-02f, 3.91383380e-01f, 8.54726881e-02f, 1.42375216e-01f, -1.05275176e-02f, 2.09209606e-01f,
  2.77219802e-01f, 1.20416127e-01f, 2.41702572e-01f, 1.90083489e-01f, 9.61082876e-02f, -2.26961039e-02f, 2.07631364e-01f, -2.37799674e-01f, 1.53319538e-01f, -4.44106698e-01f,
  -4.49414968e-01f, 4.72861648e-01f, 4.90610987e-01f, -4.84439939e-01f, -3.47239017e-01f, -2.29732379e-01f, -2.32099846e-01f, -1.60916999e-01f, -1.64454311e-01f, -5.47921732e-02f,
  -5.84692433e-02f, 1.80508360e-01f, -4.55925316e-01f, -6.74055874e-01f, -4.06994849e-01f, 1.13603421e-01f, 1.36810869e-01f, -3.95459592e-01f, -1.88886806e-01f, 1.04433842e-01f,
  8.30601528e-02f, -2.96472386e-02f, -2.17806444e-01f, -1.80381741e-02f, 5.45578264e-02f, -5.95187247e-02f, 4.05935258e-01f, -9.03812051e-02f, -1.52667657e-01f, -3.38995546e-01f,
  -2.46366374e-02f, 2.47567762e-02f, -2.46901736e-01f, -8.26532301e-03f, 3.13361764e-01f, 2.74956156e-03f, 3.78507236e-03f, 1.76210046e-01f, 3.07047125e-02f, -1.18850172e-01f,
  -3.56151126e-02f, 2.51709074e-01f, -4.50672731e-02f, 6.21524416e-02f, 6.40113354e-02f, -9.16319713e-02f, -6.09839261e-02f, 1.66519389e-01f, 7.46441856e-02f, -2.35797897e-01f,
  -9.39983353e-02f, -2.66837757e-02f, 1.46412775e-01f, 2.00477526e-01f, -9.87673104e-02f, -4.04427275e-02f, -1.38572574e-01f, -4.04757261e-01f, 1.10402727e-03f, 8.03557634e-02f,
  1.36341080e-01f, -1.88967273e-01f, 1.12263575e-01f, 1.97470143e-01f, -2.95205444e-01f, -6.31081641e-01f, 1.13664038e-01f, -1.59133002e-01f, -3.28917593e-01f, 1.64699674e-01f,
  1.27893314e-01f, 2.75760412e-01f, 7.62650464e-03f, -3.07286620e-01f, -1.72939956e-01f, -2.46553034e-01f, -2.88401157e-01f, -2.28636876e-01f, 3.97739023e-01f, -5.66275383e-04f,
  1.26524538e-01f, -4.92394745e-01f, -1.52214050e-01f, 2.46746898e-01f, -2.17198223e-01f, 4.79926288e-01f, -7.07751652e-03f, -1.43327385e-01f, 1.32664621e-01f, 3.55742663e-01f,
  7.05060184e-01f, 9.23475921e-02f, -1.53393701e-01f, -5.56808002e-02f, -1.37308553e-01f, -1.71990678e-01f, -4.93112236e-01f, 1.46922112e-01f, -2.27870390e-01f, 1.04578897e-01f,
  1.09012879e-01f, 8.86677280e-02f, 8.06416124e-02f, 1.22052468e-02f, -3.38349372e-01f, -1.49972424e-01f, -7.58088306e-02f, -1.15142748e-01f, -5.65999746e-02f, -1.10386506e-01f,
  5.45520708e-02f, 6.43982589e-02f, -6.53058439e-02f, -4.95628566e-02f, -2.82630533e-01f, -3.05953883e-02f, -1.62040904e-01f, -9.65962335e-02f, -7.25725591e-02f, -2.09540613e-02f,
  -2.55089402e-01f, 6.30789697e-02f, -7.29901716e-02f, -4.32990715e-02f, -6.79628551e-02f, 1.37468323e-01f, -2.14976311e-01f, 1.33146882e-01f, 3.93502533e-01f, -4.18282479e-01f,
  -1.99698851e-01f, -6.33132979e-02f, -4.08574678e-02f, 2.00401336e-01f, 3.04572463e-01f, -2.42742598e-01f, 5.89370914e-03f, 5.61832599e-02f, 2.30649665e-01f, 3.14528644e-01f,
  9.37664360e-02f, 6.00120910e-02f, -1.84361592e-01f, 3.93780731e-02f, -4.44954842e-01f, -2.84123391e-01f, 2.97989875e-01f, -2.40156785e-01f, 3.12544912e-01f, -2.40536127e-02f,
  -2.09079325e-01f, 5.11404634e-01f, -3.90987307e-01f, 6.09155744e-02f, -1.60991862e-01f, -1.26599567e-02f, 2.93537647e-01f, -9.95580703e-02f, 2.74491869e-02f, 2.04100341e-01f,
  4.59166974e-01f, 8.93070996e-02f, -3.38530242e-02f, -5.79897277e-02f, -4.87327278e-02f, -1.51089743e-01f, -1.47403842e-02f, -2.02504862e-02f, 3.39068115e-01f, -2.91559875e-01f,
  1.16791138e-02f, -7.08610937e-02f, 1.06772520e-01f, -2.24971995e-01f, -1.98234040e-02f, 7.28472918e-02f, 3.27344500e-02f, -1.93181131e-02f, -2.46671423e-01f, 1.37745179e-02f,
  7.60772303e-02f, -1.26746595e-01f, -4.33506723e-03f, -1.18564345e-01f, -5.81135973e-02f, -8.53900835e-02f, 1.69371188e-01f, -1.03243507e-01f, -5.65882633e-03f, -8.51946175e-02f,
  -3.69063132e-02f, 1.74174175e-01f, 5.32756686e-01f, -2.37009585e-01f, -3.00622880e-02f, 3.48835252e-02f, 2.00677410e-01f, -5.50148964e-01f, -2.14957386e-01f, 2.67107822e-02f,
  4.04405236e-01f, 7.03927726e-02f, -3.40458274e-01f, -7.11606741e-02f, -2.58132339e-01f, -2.19542325e-01f, 4.37780142e-01f, -3.94728571e-01f, 8.85467529e-02f, -1.88558295e-01f,
  6.52161166e-02f, 2.14385584e-01f, -2.53861129e-01f, -6.95122480e-02f, -1.45756468e-01f, -2.92438865e-01f, 2.97825217e-01f, -1.49393991e-01f, -3.02796394e-01f, -1.28329070e-02f,
  1.23980511e-02f, 4.52427238e-01f, -4.40315939e-02f, -2.64848411e-01f, -2.10905299e-01f, 6.13867864e-02f, 9.41125304e-02f, -1.32650202e-02f, 9.42563564e-02f, -3.08777928e-01f,
  -1.03962369e-01f, -1.50288185e-02f, 4.76606131e-01f, 5.01310885e-01f, -1.11254871e-01f, -5.50615368e-03f, -9.36001167e-02f, 9.53032300e-02f, 2.42924407e-01f, -6.37660921e-02f,
  -1.34737894e-01f, -1.40137464e-01f, -7.55956769e-02f, 8.53583291e-02f, -4.81997728e-02f, 2.03170255e-01f, -2.17539251e-01f, 1.30540766e-02f, 9.46370065e-02f, -4.14122045e-01f,
  6.81156516e-02f, 1.66976810e-01f, -3.75594378e-01f, -2.52329171e-01f, -1.79368615e-01f, 2.79376566e-01f, 9.96170044e-02f, -2.14432124e-02f, -1.90728202e-01f, 2.75195837e-01f,
  -2.03069180e-01f, -1.01403803e-01f, -2.51691669e-01f, -3.30752850e-01f, 1.49820462e-01f, -2.02883765e-01f, 2.29079157e-01f, 5.47309592e-02f, -3.43196750e-01f, 1.49048910e-01f,
  -2.02795997e-01f, 2.17502415e-01f, 2.17758454e-02f, 3.09627563e-01f, -1.42909959e-01f, -3.13697189e-01f, 1.09592259e-01f, 5.92992641e-02f, 7.01977545e-03f, 3.81299257e-01f,
  -3.10119927e-01f, 4.64344412e-01f, 2.32235178e-01f, 2.95337379e-01f, 1.30888715e-01f, 5.54472268e-01f, 6.31633354e-03f, 2.96340466e-01f, -2.03700677e-01f, 5.26741035e-02f,
  -1.95193723e-01f, -8.61859322e-03f, -1.23578005e-01f, 2.13411972e-01f, -9.21353772e-02f, -6.91771954e-02f, -3.89983207e-01f, -5.78659475e-01f, 9.83071402e-02f, 1.92978326e-02f,
  2.68766820e-01f, 2.00919986e-01f, 1.74805865e-01f, 1.88537370e-02f, 2.98720263e-02f, -8.94638076e-02f, -4.62749116e-02f, 1.02300942e-01f, -1.94704439e-02f, 1.76802948e-01f,
  1.04264617e-01f, 1.95793524e-01f, 2.81967700e-01f, 1.30680306e-02f, 1.77947819e-01f, 7.70726949e-02f, 1.53150737e-01f, 3.06276847e-02f, 4.84439246e-02f, -2.63589799e-01f,
  3.24165612e-03f, -9.40049887e-02f, 1.14741415e-01f, 2.88269401e-01f, 4.48632777e-01f, 3.36079389e-01f, 4.94608253e-01f, 4.27367449e-01f, -3.14569026e-01f, -2.56858677e-01f,
  4.04661745e-02f, 1.27264813e-01f, 5.92177033e-01f, 2.56325334e-01f, 4.06855702e-01f, -4.34222698e-01f, 2.35397711e-01f, -4.43212241e-01f, 3.04801971e-01f, 1.49771750e-01f,
  1.30112067e-01f, -8.64665136e-02f, 3.05288106e-01f, -1.19505405e-01f, 3.67140919e-01f, -1.33814871e-01f, -4.16171700e-01f, 1.46463677e-01f, -1.82602182e-01f, 9.58171263e-02f,
  7.06154034e-02f, 1.47118226e-01f, 2.02058509e-01f, 8.19181800e-02f, -1.89899534e-01f, 7.33336061e-02f, 6.41620681e-02f, -3.52826476e-01f, 3.68993543e-02f, 2.02197917e-02f,
  -4.60652374e-02f, -2.53308147e-01f, -1.01473548e-01f, 6.94917813e-02f, 2.53051445e-02f, 8.37563723e-03f, 1.08031053e-02f, -9.34773833e-02f, -1.06982522e-01f, -1.46096393e-01f,
  1.02498509e-01f, -4.83197831e-02f, -1.33557796e-01f, -3.48079264e-01f, -1.69994503e-01f, -1.29892513e-01f, 9.26928297e-02f, -9.36151072e-02f, -3.89913887e-01f, -1.05195520e-02f,
  1.15195643e-02f, -9.92090255e-02f, -6.64992109e-02f, 1.27903029e-01f, -9.08849686e-02f, 9.18903276e-02f, 3.05989653e-01f, 3.55453603e-02f, -2.51784086e-01f, -4.51285169e-02f,
  -2.70407587e-01f, -4.36218642e-03f, -2.75324136e-01f, -5.41042648e-02f, -1.57454520e-01f, -1.14154778e-01f, -3.63695383e-01f, 4.26755667e-01f, 6.30822079e-03f, -7.20496029e-02f,
  1.13986433e-01f, 4.15261894e-01f, -1.04202703e-01f, 6.62925839e-01f, -1.64983958e-01f, -4.09001810e-03f, 5.11443496e-01f, -2.60935426e-01f, 1.15913209e-02f, -3.02176159e-02f,
  -2.17417344e-01f, -2.99611956e-01f, -2.20664162e-02f, -1.41701818e-01f, 7.80886412e-02f, -1.16323076e-01f, -3.61876428e-01f, 9.46173817e-02f, -4.71792556e-03f, 4.55504507e-02f,
  6.94165193e-03f, 3.52947921e-01f, 7.12770671e-02f, 9.38224345e-02f, 6.61899626e-01f, 1.72750019e-02f, 4.98721516e-03f, 1.09590195e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  5.53678274e-02f, 1.29449725e-01f, -2.81404927e-02f, -1.09305851e-01f, -1.58374675e-03f, 4.34909835e-02f, 4.38359529e-02f, -1.30495325e-01f, -1.41515762e-01f, -1.97604045e-01f,
  -4.86271977e-02f, -5.16908206e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    