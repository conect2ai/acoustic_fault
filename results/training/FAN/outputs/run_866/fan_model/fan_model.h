/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.55018723e-01f, -2.12271601e-01f, -1.81257561e-01f, -1.36053786e-01f, -1.43503100e-01f, -1.88093066e-01f, -2.30861634e-01f, -3.53242457e-02f, -5.96349537e-02f, -9.97764692e-02f,
  -8.49793926e-02f, 7.20963106e-02f, 2.27751866e-01f, 2.45280042e-01f, 1.86542347e-01f, -5.43579645e-02f, -1.46928905e-02f, 9.45577845e-02f, 1.72921464e-01f, -5.69887422e-02f,
  -2.86704563e-02f, -1.99050158e-02f, 2.40332764e-02f, -9.86655876e-02f, -1.57585874e-01f, -7.30264410e-02f, -3.44051197e-02f, -5.21035530e-02f, -1.78009525e-01f, -3.53775412e-01f,
  -3.47553566e-02f, -3.88507247e-01f, 1.46033913e-01f, -2.57536415e-02f, 6.22783303e-02f, -4.40156944e-02f, -2.15463322e-02f, -1.37780830e-02f, 1.52311511e-02f, 3.61993536e-02f,
  -3.31137478e-02f, 3.10694668e-02f, -1.47904232e-02f, 9.17492956e-02f, -1.87701173e-02f, -1.14704454e-02f, 9.27029699e-02f, -3.07428129e-02f, 3.28522064e-02f, -2.06846222e-02f,
  -3.87616567e-02f, -2.27176815e-01f, -7.98087344e-02f, 3.58409882e-02f, -5.45155182e-02f, 7.02688172e-02f, -9.79120471e-03f, -1.62024394e-01f, -4.76959348e-02f, -1.95143044e-01f,
  -1.03436448e-02f, -7.32496977e-02f, -2.37733237e-02f, -2.22685151e-02f, 3.20856385e-02f, -7.88264256e-03f, -4.06798609e-02f, 6.00947067e-02f, -6.32419214e-02f, 4.86512259e-02f,
  1.74223967e-02f, 1.70821939e-02f, 9.28336158e-02f, -7.30588064e-02f, 1.34384399e-02f, -6.64878683e-03f, -8.14086795e-02f, 7.61613175e-02f, 5.30297309e-02f, 1.50087271e-02f,
  -2.15640888e-02f, -1.48396185e-02f, -3.65954377e-02f, -3.59124057e-02f, -4.08889502e-02f, 1.75236445e-02f, -6.35129288e-02f, 9.35825855e-02f, 2.85136141e-02f, -1.61774214e-02f,
  3.29465657e-01f, 1.74105212e-01f, -7.45199919e-02f, -1.86985023e-02f, -6.75684810e-02f, 8.89770463e-02f, -1.83992032e-02f, 3.20467465e-02f, 6.44075079e-03f, -1.38213234e-02f,
  1.91882662e-02f, -6.00670539e-02f, 2.55702902e-02f, -1.32834930e-02f, 7.14222761e-03f, 2.46825651e-03f, 6.22339770e-02f, 3.39742154e-02f, 2.30997410e-02f, 2.36451421e-02f,
  7.93039426e-02f, 4.38290788e-03f, 1.15533918e-02f, 1.25970200e-01f, 4.86730505e-03f, -6.61653727e-02f, 9.85653251e-02f, 3.00854146e-02f, -2.37605702e-02f, 1.00443430e-01f,
  3.40136923e-02f, -1.80455774e-01f, -1.17254563e-01f, -4.36479785e-02f, -3.44071239e-02f, 5.28552234e-02f, 6.45659938e-02f, 1.07740000e-01f, 1.48778498e-01f, -1.29760634e-02f,
  5.94756454e-02f, 2.77703088e-02f, 1.30959600e-01f, -2.85013821e-02f, 1.18277371e-01f, -3.07116043e-02f, -9.13858935e-02f, -1.56827673e-01f, -2.29871273e-02f, 6.87718466e-02f,
  -2.76985765e-02f, -1.71545416e-01f, -1.13086112e-01f, -1.76573340e-02f, -7.39888847e-02f, 1.00510463e-01f, -9.70916636e-03f, -7.57485777e-02f, -1.33030385e-01f, -1.71460539e-01f,
  8.43011886e-02f, -1.40176222e-01f, 1.31489232e-01f, 6.56865314e-02f, -1.54758185e-01f, 1.00094259e-01f, 5.47802961e-03f, 8.50091316e-03f, 1.97526552e-02f, -7.45467618e-02f,
  -7.03085139e-02f, -2.38070469e-02f, -6.63254708e-02f, -1.01888061e-01f, 3.64325941e-02f, 3.15209962e-02f, 2.45910008e-02f, -6.04232661e-02f, -8.01643804e-02f, 5.64842336e-02f,
  -6.43297732e-02f, -1.03588477e-01f, -1.22133978e-01f, 2.68788692e-02f, 6.56070933e-02f, -5.37148304e-02f, 3.11033558e-02f, -3.22898626e-02f, -1.70446355e-02f, 9.33194309e-02f,
  6.69494718e-02f, -4.37143110e-02f, 1.32149430e-02f, 5.50947711e-02f, 5.71834273e-04f, 1.05759855e-02f, 2.78780819e-03f, -2.15256237e-03f, -5.62060848e-02f, 4.55066413e-02f,
  -5.93227595e-02f, -3.95951271e-02f, -8.98960454e-04f, 8.98886546e-02f, -4.61334288e-02f, -6.91868737e-02f, 2.59278864e-02f, -1.70050208e-02f, -5.29359765e-02f, -3.58383469e-02f,
  -5.40349334e-02f, -3.93158607e-02f, 3.03118639e-02f, -8.77958611e-02f, -8.10137615e-02f, -8.60918984e-02f, -1.86439566e-02f, 1.20539041e-02f, 8.24747011e-02f, -3.47869247e-02f,
  1.31412268e-01f, -9.75331739e-02f, 8.41486827e-02f, 4.21976075e-02f, 6.45465851e-02f, -1.21216048e-02f, -7.27129430e-02f, 4.95360121e-02f, -7.27376789e-02f, 9.92009975e-03f,
  1.05312644e-02f, 8.43243152e-02f, 3.01896092e-02f, 1.08134458e-02f, 2.89596152e-02f, 3.56013849e-02f, 3.07391603e-02f, -7.15803057e-02f, 9.38150063e-02f, -3.98397557e-02f,
  -5.22169061e-02f, 4.33227718e-02f, 1.52905047e-01f, 7.97239989e-02f, 1.27441734e-01f, 1.56122476e-01f, 7.57653862e-02f, 1.87318161e-01f, 2.21071675e-01f, 2.94367164e-01f,
  4.73238170e-01f, 1.46692812e-01f, 4.20870781e-02f, 5.07585220e-02f, -4.68033329e-02f, -2.35305861e-01f, -1.64500773e-01f, -1.40311822e-01f, -6.58212155e-02f, -3.63382474e-02f,
  -3.13195139e-02f, -3.19547169e-02f, -4.41569202e-02f, -5.75260334e-02f, 5.02017029e-02f, -1.22704908e-01f, -7.56584806e-03f, 6.99066445e-02f, -9.30292606e-02f, -5.18568717e-02f,
  -5.82812726e-03f, 1.53146341e-01f, 1.13777876e-01f, 4.00103405e-02f, 6.25815839e-02f, -1.01431563e-01f, -3.94108742e-02f, 9.01762098e-02f, 1.14251208e-02f, 1.30148470e-01f,
  -3.91719826e-02f, 2.50293851e-01f, -1.15975015e-01f, 6.21049553e-02f, -5.91989979e-02f, 1.61834303e-02f, -1.63309630e-02f, 3.82969528e-03f, 6.82767034e-02f, 1.16104921e-02f,
  4.08543497e-02f, 1.16313227e-01f, 1.02147639e-01f, 4.24366817e-02f, -3.34502608e-02f, -1.31133208e-02f, 5.44414809e-03f, 1.37043953e-01f, 2.02814974e-02f, 6.79892823e-02f,
  6.98310211e-02f, 1.02776505e-01f, 3.25456113e-02f, 1.21873058e-02f, -3.27186771e-02f, 8.54880437e-02f, -5.02481405e-03f, 4.19643745e-02f, 4.76978272e-02f, -6.85801543e-03f,
  -8.14241767e-02f, 3.02125681e-02f, 2.86418889e-02f, 3.37721221e-02f, -5.66516742e-02f, -5.47989272e-02f, -4.35037352e-02f, -2.73604952e-02f, 3.60134384e-03f, 6.82149129e-03f,
  -3.50167230e-02f, -5.17349243e-02f, 5.36229461e-02f, -3.35954614e-02f, 2.64094700e-03f, -1.36490492e-02f, 4.24964540e-02f, -8.46723914e-02f, 4.29400913e-02f, 4.77080122e-02f,
  3.60515676e-02f, -3.52750620e-04f, -2.33117855e-04f, -6.74008429e-02f, 9.27370191e-02f, -2.62941569e-02f, 8.68259184e-03f, 6.10980168e-02f, 5.05750347e-03f, 3.95690016e-02f,
  -2.51735628e-01f, 9.20274034e-02f, -9.72010344e-02f, 6.04726039e-02f, 3.95789370e-02f, -2.78125945e-02f, -3.20937075e-02f, 4.02412117e-02f, 2.62980778e-02f, 7.27561582e-03f,
  4.62226719e-02f, 2.08328348e-02f, -6.79758415e-02f, 2.84169596e-02f, 8.55591614e-03f, -3.51300114e-03f, -2.34539099e-02f, -9.77004878e-03f, 2.11599246e-02f, -3.81004140e-02f,
  -4.58219089e-03f, -1.75965145e-01f, -1.11889936e-01f, -2.66570240e-01f, -9.06910449e-02f, -1.93173945e-01f, -2.02256590e-01f, -1.89675316e-01f, -1.36266008e-01f, -3.09756666e-01f,
  2.52999216e-01f, 2.76099235e-01f, 2.80848026e-01f, 8.93448740e-02f, 5.50954789e-03f, 1.37134299e-01f, 2.12150246e-01f, 1.22069672e-01f, -1.26980260e-01f, 1.99081330e-03f,
  -1.58792213e-01f, -3.18456709e-01f, -1.10807121e-01f, -1.75432801e-01f, 3.35187316e-02f, 2.88222611e-01f, 2.34376654e-01f, 1.52468428e-01f, -4.30961214e-02f, -1.19030938e-01f,
  1.17871992e-03f, -3.84664834e-02f, -1.74509753e-02f, 3.89678851e-02f, -1.43002644e-01f, -9.50814262e-02f, 9.77862850e-02f, -4.63748351e-02f, -1.41586550e-02f, -3.17240171e-02f,
  -3.08875591e-02f, 1.67863443e-01f, -1.12257756e-01f, -1.76979881e-02f, -1.12101898e-01f, 3.99431176e-02f, 1.24923699e-02f, 1.05570778e-02f, -6.91213384e-02f, 8.37780461e-02f,
  -1.24038301e-01f, -9.73067731e-02f, -2.70908531e-02f, -2.59837825e-02f, 5.48773818e-02f, 1.51257515e-02f, 9.88761857e-02f, 1.01637721e-01f, 1.08225748e-01f, 4.36382517e-02f,
  -2.78421417e-02f, -8.84449389e-03f, 1.07074276e-01f, 9.64185148e-02f, -1.91115402e-02f, 3.12545076e-02f, -2.98859365e-02f, 1.40484124e-02f, 4.39915136e-02f, 2.10915595e-01f,
  -5.52566312e-02f, -4.26315628e-02f, -9.32288636e-03f, 4.25188206e-02f, 5.04522920e-02f, -6.12856410e-02f, -4.53658327e-02f, -3.39007005e-02f, -5.02242483e-02f, -4.33306023e-03f,
  2.34227395e-03f, 3.14845592e-02f, -8.89650881e-02f, 6.09654598e-02f, -1.65624887e-01f, 7.42795020e-02f, -4.88764346e-02f, 5.53351920e-03f, -3.71573381e-02f, 5.47623038e-02f,
  3.68225090e-02f, -3.11198682e-02f, 5.13452478e-03f, -1.60170030e-02f, 2.50631217e-02f, 7.65296593e-02f, -1.88041609e-02f, -3.82280052e-02f, -9.11138766e-03f, 5.76487482e-02f,
  -1.29520327e-01f, 9.33687240e-02f, 7.14527220e-02f, -2.39604954e-02f, -1.20676029e-02f, -2.02102251e-02f, -1.73655357e-02f, -3.62867974e-02f, -2.63495054e-02f, 3.72745655e-02f,
  -3.85208577e-02f, -1.25457877e-02f, -3.68383080e-02f, -3.47525789e-03f, 2.04009172e-02f, -1.06607586e-01f, -1.70243299e-03f, 2.49622427e-02f, -2.67150383e-02f, -5.08561768e-02f,
  8.55900496e-02f, 1.55798674e-01f, 1.72096938e-01f, 3.63293365e-02f, 1.82467569e-02f, 5.54654337e-02f, -1.52389435e-02f, -4.18534204e-02f, 9.91876647e-02f, 1.68970838e-01f,
  5.54219663e-01f, -2.79765427e-01f, -1.22402117e-01f, 1.60833851e-01f, 5.33514321e-02f, 5.16743138e-02f, -5.63433692e-02f, 1.99450314e-01f, 2.09434137e-01f, 3.47210877e-02f,
  2.34495476e-02f, -3.09379660e-02f, 5.73589234e-03f, -8.40688646e-02f, -5.16547710e-02f, -1.75618559e-01f, -6.64053708e-02f, -4.24198583e-02f, 3.18463631e-02f, -6.18735738e-02f,
  -1.44089803e-01f, 7.08352849e-02f, 7.34842494e-02f, -6.04012012e-02f, -1.86518624e-01f, -3.10684796e-02f, -1.76907924e-03f, -9.71320570e-02f, -2.39787340e-01f, -3.18451226e-01f,
  -2.09777504e-01f, -1.21095218e-01f, 9.81821120e-02f, 4.47333306e-02f, 3.58475596e-02f, 4.38215621e-02f, -5.86260594e-02f, -6.23603798e-02f, 5.13240658e-02f, -8.11813250e-02f,
  -7.52265751e-02f, 9.13339704e-02f, -3.47496308e-02f, -1.59390196e-01f, -4.34908271e-02f, -3.52263637e-02f, 1.39021948e-02f, -6.81953207e-02f, 1.44843208e-02f, -3.63682397e-02f,
  -8.70488063e-02f, -1.54531375e-01f, 4.80950810e-02f, -8.84737670e-02f, -2.51171575e-03f, 4.74714115e-02f, -1.32015310e-02f, 1.72961988e-02f, 4.60579321e-02f, 4.99828495e-02f,
  3.23984548e-02f, 7.16679962e-03f, -2.51801964e-02f, -7.65824914e-02f, 1.87437553e-02f, -3.68410274e-02f, -5.74662797e-02f, -7.49357492e-02f, -5.05439006e-02f, 2.86871530e-02f,
  3.11443172e-02f, -4.16968800e-02f, -3.14811827e-03f, 9.24021588e-05f, -1.24428393e-02f, -1.51016777e-02f, -5.03771231e-02f, -4.73716855e-02f, -3.05288881e-02f, 6.42123893e-02f,
  1.16398819e-02f, 1.94836352e-02f, -6.32804167e-03f, -5.54706194e-02f, -5.23847267e-02f, -6.07503504e-02f, 8.63954891e-03f, 1.27149774e-02f, 9.42155793e-02f, 7.33571425e-02f,
  3.28817010e-01f, 7.39587098e-02f, -1.46625545e-02f, 1.15077775e-02f, 4.18557785e-02f, 5.50830476e-02f, 5.90577442e-03f, 1.00546638e-02f, -1.33923842e-02f, 1.41030969e-02f,
  -2.44102515e-02f, 4.59803306e-02f, 7.62334019e-02f, 2.65334137e-02f, 7.00061023e-02f, 3.98615189e-02f, 6.97575659e-02f, -8.15531611e-03f, 8.07352457e-03f, -1.69035811e-02f,
  1.19636729e-01f, 6.44715056e-02f, 1.97190553e-01f, 4.89544198e-02f, 6.36549145e-02f, 2.47494966e-01f, 1.13677241e-01f, 1.06004849e-01f, 2.07126930e-01f, 2.54621565e-01f,
  9.51536894e-02f, -1.38857439e-01f, -4.38975841e-01f, -2.28910018e-02f, -1.74892649e-01f, -1.20398521e-01f, -2.53130704e-01f, -1.45634621e-01f, 1.17878348e-01f, -8.04659873e-02f,
  2.26768196e-01f, 3.45996141e-01f, 1.60061941e-01f, 1.03143476e-01f, -9.35897306e-02f, -3.02932233e-01f, -5.01632750e-01f, -3.18400532e-01f, -7.27135912e-02f, 8.19262713e-02f,
  7.36501291e-02f, -3.00132558e-02f, -4.62620966e-02f, -4.61375974e-02f, 3.84785235e-02f, 4.33989614e-02f, -1.90671116e-01f, -5.13313599e-02f, 8.31354037e-03f, -1.52733013e-01f,
  4.08648513e-02f, 1.17331721e-01f, 2.23514512e-02f, 1.46480173e-01f, -1.56918839e-02f, 4.70355265e-02f, 2.87778000e-03f, -3.05187460e-02f, 4.07881737e-02f, -4.84904367e-03f,
  6.93426803e-02f, 1.16304919e-01f, 1.41454516e-02f, 7.39870891e-02f, -1.02097295e-01f, 7.88969919e-02f, -8.78330618e-02f, -1.19900055e-01f, -4.25399542e-02f, -2.25440692e-02f,
  3.32082137e-02f, 1.18280940e-01f, -6.64222240e-02f, -9.03181359e-02f, -1.10257730e-01f, 1.99120790e-02f, -3.10048349e-02f, 1.03299826e-01f, -3.38574164e-02f, -2.31575277e-02f,
  -2.88450476e-02f, -4.37118597e-02f, 3.71877737e-02f, 7.94600025e-02f, 2.86734663e-02f, -1.80841458e-03f, 4.79325373e-03f, -6.85975887e-04f, -7.60308281e-02f, 6.15117257e-04f,
  1.12300890e-03f, 3.18164416e-02f, -1.00566208e-01f, -4.98074181e-02f, -6.92406744e-02f, -4.34424123e-03f, -2.31004767e-02f, -1.19754160e-02f, 6.08687429e-03f, -7.21613457e-03f,
  5.00042811e-02f, 2.12481432e-02f, -5.39056733e-02f, 4.15421724e-02f, 1.00188646e-02f, -1.27336606e-01f, 8.92957672e-02f, 3.94147038e-02f, 4.47789393e-02f, 6.38541952e-02f,
  1.68161169e-01f, 7.21281441e-03f, 6.43422529e-02f, -4.20710444e-02f, -3.46593857e-02f, 2.81649306e-02f, 9.26890150e-02f, -6.33657798e-02f, 1.70528084e-01f, 1.78262927e-02f,
  3.69283818e-02f, 2.76979189e-02f, -5.26101291e-02f, 1.02567975e-03f, -7.05334395e-02f, -9.03693214e-03f, -5.47833145e-02f, -1.52508297e-03f, -3.54545191e-02f, 2.41673309e-02f,
  -8.60775542e-03f, 1.53424153e-02f, 6.14410862e-02f, -1.36144478e-02f, 6.05719164e-02f, 8.50394443e-02f, -9.98446792e-02f, -1.31290723e-02f, 1.23424847e-02f, -1.43094242e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.86550438e-01f, 7.31531754e-02f, 2.70815372e-01f, -2.44884834e-01f, -6.50619417e-02f, 2.52574962e-03f, 1.45227648e-02f, -1.29885718e-01f, -1.17915154e-01f, 2.15089358e-02f,
  6.87419949e-03f, -1.17121063e-01f, -3.17676924e-02f, -9.55642760e-03f, -2.09418893e-01f, 8.85117203e-02f, -7.73733435e-03f, -1.63469285e-01f, -2.90151715e-01f, -2.44959250e-01f,
  -2.88355291e-01f, -4.11369622e-01f, -3.42434675e-01f, -1.52075872e-01f, 8.05427954e-02f, 7.61880632e-03f, 7.52509162e-02f, 2.49474384e-02f, 4.86143567e-02f, -4.00474072e-02f,
  3.90658766e-01f, -6.73543960e-02f, -9.77145508e-02f, -2.15398163e-01f, -1.06010959e-02f, -2.69487798e-02f, 3.07514053e-02f, -5.32618575e-02f, -6.49483204e-02f, -5.40158451e-02f,
  -1.00793533e-01f, -5.72484471e-02f, -1.05855316e-01f, -8.80002156e-02f, -8.39655772e-02f, -1.13674857e-01f, -1.04730085e-01f, -2.91539561e-02f, 1.13543779e-01f, 1.58285633e-01f,
  -4.70019206e-02f, -4.49758209e-02f, -4.40585762e-02f, 3.47150564e-02f, 3.31644118e-02f, -1.06039196e-01f, 5.17792292e-02f, 2.23198868e-02f, 1.86064526e-01f, -5.87714650e-03f,
  7.22747063e-03f, 4.88724187e-02f, -3.49368108e-03f, 4.35227230e-02f, -1.19976431e-01f, 9.62930396e-02f, 3.62182297e-02f, -1.04888789e-01f, 1.93218738e-02f, -7.88149908e-02f,
  -1.75596215e-02f, 1.37562126e-01f, 5.62067591e-02f, -1.46498922e-02f, 9.75862294e-02f, -4.54719551e-02f, -3.25086713e-02f, -3.23936716e-02f, -1.01139117e-03f, -9.56049487e-02f,
  6.30987389e-03f, -2.62391847e-02f, 8.26982334e-02f, 1.14924219e-02f, 7.76085705e-02f, -5.18999435e-02f, -9.86882225e-02f, 3.62508409e-02f, 3.81706320e-02f, -3.26608457e-02f,
  3.71630751e-02f, -5.75864874e-02f, 9.02727470e-02f, -1.07441045e-01f, 4.45160754e-02f, 3.33786346e-02f, 3.78705934e-02f, -6.85611293e-02f, -3.06181684e-02f, 6.74546957e-02f,
  -2.94878101e-03f, -2.84455474e-02f, 9.16478038e-02f, -4.82492745e-02f, -2.97860373e-02f, -1.03831805e-01f, -1.46553308e-01f, -9.26021934e-02f, 4.86761034e-02f, 9.54790320e-03f,
  -7.13687912e-02f, -7.74525777e-02f, -1.35243222e-01f, 7.49112070e-02f, 1.03079267e-01f, -9.78319943e-02f, 9.51318741e-02f, 8.96631926e-02f, 2.03756150e-02f, -4.49413918e-02f,
  -1.29074514e-01f, 2.62133330e-01f, -2.96882261e-02f, -2.94935554e-02f, 3.30063179e-02f, 1.17604800e-01f, 3.06278765e-01f, 1.39651120e-01f, -2.37307083e-02f, 2.07091961e-02f,
  5.47382608e-02f, -1.60031959e-01f, -1.65817484e-01f, -6.44421354e-02f, 8.70130807e-02f, 2.15124980e-01f, -1.21272653e-02f, -1.85690835e-01f, -8.37397501e-02f, 6.04496449e-02f,
  1.53133404e-02f, 8.95548090e-02f, -4.04003188e-02f, -1.69731546e-02f, -1.18499711e-01f, -1.03525929e-01f, -1.48375211e-02f, -2.38021389e-02f, -4.95742001e-02f, -4.08102386e-02f,
  -1.83306426e-01f, -2.40823641e-01f, -7.88767040e-02f, 3.14627215e-02f, -7.49373809e-02f, 1.61236729e-02f, 3.91814113e-03f, -1.04079703e-02f, 4.92778644e-02f, 2.21742876e-02f,
  -3.33336219e-02f, -4.35770638e-02f, -1.14735305e-01f, -7.27127132e-04f, -8.36150572e-02f, -5.41543849e-02f, 4.95300218e-02f, -5.85973077e-02f, -7.11359233e-02f, -9.29437801e-02f,
  2.73942985e-02f, 2.86168270e-02f, -3.47270817e-02f, 6.98978603e-02f, -1.16726637e-01f, -3.96972969e-02f, -1.97500773e-02f, -1.00617990e-01f, -8.01177844e-02f, 4.50086072e-02f,
  1.22763649e-01f, -1.18765384e-01f, 2.55466271e-02f, -1.11690089e-01f, -1.03049904e-01f, -4.74577807e-02f, -9.81722623e-02f, 8.00758675e-02f, 4.59032692e-02f, -1.43529978e-02f,
  7.66815059e-03f, -3.95903774e-02f, -9.55812633e-02f, -2.02739425e-02f, 2.84123290e-02f, 2.04082001e-02f, 7.24403411e-02f, 1.73528623e-02f, -5.81160486e-02f, -4.50590849e-02f,
  -1.32933944e-01f, -9.81190521e-03f, -8.99754986e-02f, -1.68971121e-02f, 5.74943163e-02f, 2.34057792e-02f, -3.50028239e-02f, 4.27653231e-02f, -1.39275277e-02f, -2.16866992e-02f,
  -9.61916894e-03f, -1.46139368e-01f, -4.07768413e-02f, -1.10014990e-01f, -1.14264868e-01f, 3.49271670e-02f, 1.47515284e-02f, -4.30935472e-02f, 6.94533885e-02f, -2.15132572e-02f,
  -3.17622982e-02f, 1.10951615e-02f, -2.80361548e-02f, 4.67773993e-04f, 2.90865451e-02f, 1.15809903e-01f, 1.25422344e-01f, -6.62399754e-02f, 2.67316736e-02f, -4.81956378e-02f,
  1.82288066e-01f, 7.56074712e-02f, 1.19647823e-01f, 1.09714635e-01f, 5.45189120e-02f, -1.08846314e-01f, 6.15724474e-02f, 8.76266360e-02f, 2.65440773e-02f, 2.86815077e-01f,
  2.48401258e-02f, 1.79874703e-01f, -1.13697469e-01f, 3.58783267e-02f, 1.81912422e-01f, 1.38545871e-01f, 5.97971529e-02f, -9.58384946e-02f, -9.06237289e-02f, 1.30881891e-01f,
  2.93154567e-01f, 2.02684645e-02f, -8.77722651e-02f, -2.96341721e-02f, -2.25933596e-01f, -9.93516371e-02f, -1.60073265e-02f, -1.09409086e-01f, -2.40209401e-01f, 1.03710875e-01f,
  1.36988178e-01f, 1.00077480e-01f, -9.53713283e-02f, -7.71152368e-03f, 3.07331271e-02f, 1.26221448e-01f, 4.97354753e-02f, 1.61177233e-01f, 1.80430502e-01f, -8.56873579e-03f,
  4.80377860e-02f, 8.06350932e-02f, -9.79923531e-02f, 4.97698039e-02f, 1.46758229e-01f, -1.02921680e-01f, 7.19397468e-03f, 1.76786408e-02f, 2.16477904e-02f, 4.81809191e-02f,
  1.39493868e-01f, -2.18344126e-02f, 2.63704602e-02f, 2.63125673e-02f, -2.97448561e-02f, -9.97999609e-02f, -1.49129122e-01f, -2.26773322e-01f, -5.99776506e-02f, -5.11500090e-02f,
  1.16345249e-01f, 2.11321250e-01f, 5.35815023e-03f, -6.37466535e-02f, -4.11358662e-03f, -1.15742851e-02f, 2.10100245e-02f, -1.15464889e-01f, -1.26263365e-01f, -6.89912587e-02f,
  -9.12563875e-02f, -9.96708125e-02f, -6.95984587e-02f, -1.26977451e-02f, 4.25372459e-02f, -6.62438422e-02f, -4.64757569e-02f, -5.42244948e-02f, 5.10833561e-02f, -8.50114226e-02f,
  -7.32548684e-02f, -1.47895538e-03f, -1.10238552e-01f, -9.68056619e-02f, 3.49145569e-02f, -3.03155370e-02f, -3.84118296e-02f, -9.83840972e-02f, 2.79301312e-02f, -3.40363272e-02f,
  5.67999408e-02f, -6.72683418e-02f, 5.47686331e-02f, -1.52889624e-01f, -4.72026132e-02f, -2.58031227e-02f, -5.28294146e-02f, 2.13038865e-02f, 1.72746852e-02f, -9.37379431e-03f,
  -7.64924437e-02f, -9.84206051e-02f, -4.60832529e-02f, 7.47125875e-03f, -2.86144298e-02f, -4.38025147e-02f, 1.04123466e-01f, -4.99123968e-02f, 6.13880297e-03f, -3.72893028e-02f,
  1.48123410e-03f, -3.86079177e-02f, 8.80765393e-02f, -7.47091249e-02f, -4.15006541e-02f, -7.04128593e-02f, -1.07932864e-02f, -1.07364781e-01f, -1.24335602e-01f, -3.92623618e-03f,
  6.17613345e-02f, -1.09547541e-01f, -6.10876940e-02f, -2.01456502e-01f, -1.01608552e-01f, -1.31379431e-02f, -1.39361143e-01f, -1.21204823e-01f, -1.66279495e-01f, -1.65470958e-01f,
  4.87699285e-02f, -4.52987589e-02f, 1.27555728e-01f, 8.72551184e-03f, 5.46659809e-03f, 1.52478322e-01f, 7.45271742e-02f, -1.71038806e-02f, 8.60491842e-02f, -8.06000456e-02f,
  -1.57859907e-01f, -1.98084369e-01f, -9.05979872e-02f, -1.36802763e-01f, -8.47775862e-02f, 6.50651902e-02f, 7.84766227e-02f, 1.56164337e-02f, 1.30465403e-01f, 3.15353647e-02f,
  -9.60403234e-02f, 6.19524904e-02f, 7.10713342e-02f, 1.90925337e-02f, -2.47790944e-02f, 6.93946108e-02f, 1.23594195e-01f, 1.06353901e-01f, 9.43572074e-02f, 1.32708475e-01f,
  1.02151614e-02f, 9.68900416e-03f, -9.76263061e-02f, -1.31094605e-01f, 1.86064634e-02f, -4.32653874e-02f, 2.50625312e-02f, 1.51258186e-02f, -6.06829114e-02f, -3.40369008e-02f,
  -5.46150692e-02f, 8.33027810e-02f, 2.94986665e-02f, 7.34813958e-02f, 6.74807727e-02f, 1.26779586e-01f, 8.89965817e-02f, 1.14631288e-01f, 7.64834583e-02f, -2.10194308e-02f,
  -6.54973686e-02f, 5.81292696e-02f, 1.37811258e-01f, 9.70046520e-02f, 1.60814766e-02f, -2.05313158e-03f, -5.69426045e-02f, 6.05613105e-02f, -7.60937342e-03f, 5.79321161e-02f,
  -4.91686128e-02f, 2.00067628e-02f, 4.61459458e-02f, -4.57849354e-02f, -6.97989091e-02f, -4.90949564e-02f, 9.18263718e-02f, -2.53495760e-02f, -7.36267194e-02f, -5.85856214e-02f,
  3.71923968e-02f, -1.11619629e-01f, 2.66602566e-03f, -9.10362080e-02f, 1.64213907e-02f, 7.29397237e-02f, 1.02265194e-01f, 5.44626825e-02f, -3.26930452e-03f, -2.41364669e-02f,
  -8.84646103e-02f, -3.44707891e-02f, 1.96760632e-02f, 5.89825884e-02f, -5.31019866e-02f, -1.63627397e-02f, 7.25490898e-02f, -1.46711757e-02f, 2.18473338e-02f, -4.01112735e-02f,
  -3.92552553e-04f, -4.53566052e-02f, -3.49975266e-02f, 1.28917536e-02f, 9.72859636e-02f, 2.42049750e-02f, -8.67830962e-03f, -6.27009152e-03f, 5.66764316e-03f, 1.15637287e-01f,
  1.66185480e-02f, -4.37058546e-02f, 1.18061677e-02f, -3.35125066e-02f, 5.56406118e-02f, 6.26132488e-02f, 1.53373554e-02f, 9.72370058e-02f, 4.07520197e-02f, 7.55394995e-02f,
  3.15764174e-02f, -4.92764451e-03f, 3.85657884e-02f, 8.52412134e-02f, -2.48872954e-02f, -1.70212276e-02f, 7.62887150e-02f, 5.39426059e-02f, 6.22688122e-02f, 2.99221091e-02f,
  6.62013814e-02f, 1.65985040e-02f, -1.29468367e-01f, -6.40493911e-03f, -6.20154664e-02f, 9.23868082e-03f, 6.21505529e-02f, 8.67273957e-02f, -7.60172680e-02f, -9.93800089e-02f,
  2.19365172e-02f, 9.94916931e-02f, -4.68260199e-02f, 3.13845463e-02f, 5.83882891e-02f, -3.87783125e-02f, -1.43268928e-01f, -2.80908104e-02f, -9.00445655e-02f, 3.52104707e-03f,
  -8.86057690e-03f, 2.13450398e-02f, -3.21312360e-02f, -1.92567166e-02f, -6.93051443e-02f, -1.00078851e-01f, -6.70154095e-02f, -2.44511999e-02f, -3.37917544e-02f, -1.00321874e-01f,
  -4.93530445e-02f, 7.38802701e-02f, 5.01375906e-02f, -7.84975588e-02f, -2.92755105e-02f, -3.91975008e-02f, 1.72852783e-03f, -1.15207195e-01f, 1.15685426e-02f, -2.69116722e-02f,
  7.53528103e-02f, 6.85533211e-02f, 1.36112524e-02f, -5.58951981e-02f, -3.21661308e-02f, -4.93274517e-02f, -8.93745273e-02f, -8.79391879e-02f, -3.14519778e-02f, -4.98076640e-02f,
  3.41122635e-02f, 2.15364322e-02f, 8.68145451e-02f, -6.12353832e-02f, -1.76413544e-02f, 6.89576864e-02f, -1.07532561e-01f, 9.02285241e-03f, -5.34127764e-02f, -5.04430830e-02f,
  -5.83145209e-02f, 7.02730715e-02f, -2.32424587e-02f, 8.15907773e-03f, 5.06903976e-02f, -1.65079813e-02f, 3.10382620e-02f, -3.92084941e-02f, 5.34057431e-02f, -7.68794268e-02f,
  -4.27961238e-02f, -8.38608742e-02f, 8.63066763e-02f, 2.14391155e-03f, 1.60260368e-02f, -8.97468254e-02f, -2.36811060e-02f, -6.17904142e-02f, -6.29149899e-02f, -3.37467715e-02f,
  3.74723971e-02f, 2.28908099e-02f, 3.65005732e-02f, 8.39713141e-02f, 2.17077453e-02f, 3.26017328e-02f, -3.03574465e-02f, -2.93066241e-02f, -6.86681345e-02f, 6.24593683e-02f,
  -1.20999128e-01f, 7.10310414e-02f, 2.86291726e-02f, 3.71551923e-02f, -9.48099196e-02f, 1.95747968e-02f, 7.60907009e-02f, 6.08874075e-02f, 8.22202116e-02f, -2.84972340e-02f,
  7.10096434e-02f, -5.51793315e-02f, 7.67794028e-02f, 5.92921972e-02f, -1.75472721e-03f, -5.29061183e-02f, -5.65678552e-02f, 6.97159301e-03f, -5.45454659e-02f, 5.06673567e-02f,
  -9.00878757e-02f, -1.07061550e-01f, -4.28730585e-02f, 1.73780918e-02f, 5.57770990e-02f, 2.77179200e-02f, 1.40261222e-02f, 2.77658422e-02f, 1.36875287e-02f, -1.44222053e-02f,
  2.62158185e-01f, -1.32831901e-01f, 1.24206580e-01f, 5.89608215e-02f, 1.34461269e-01f, -1.41222998e-01f, -1.32211149e-01f, -2.20254704e-01f, 7.27789253e-02f, -8.55569076e-03f,
  2.39666939e-01f, 1.47440344e-01f, 1.79299057e-01f, 1.34081051e-01f, 6.92978576e-02f, -5.55296130e-02f, -6.30678311e-02f, 4.76993434e-02f, 1.59924507e-01f, 1.02969958e-02f,
  -2.49737152e-03f, 1.67650253e-01f, 1.80469185e-01f, 6.72952682e-02f, 3.22337374e-02f, 1.86625123e-01f, 5.83610125e-02f, 1.47505388e-01f, 3.12453285e-02f, -1.30797829e-02f,
  2.22451672e-01f, 8.29360783e-02f, 6.69255108e-02f, -1.54727334e-02f, 1.74676869e-02f, -9.59455445e-02f, 5.54183722e-02f, -3.20732780e-02f, -1.76789630e-02f, -1.53299630e-01f,
  6.65010065e-02f, -5.19504696e-02f, -4.19537984e-02f, -9.27693024e-02f, 8.39588121e-02f, 2.66332310e-02f, 4.52002920e-02f, -7.37875998e-02f, -8.69478658e-02f, -3.55803571e-03f,
  4.34702337e-02f, 1.41397193e-01f, 4.28702980e-02f, -1.36842400e-01f, -9.89556611e-02f, 8.77760798e-02f, 1.44431088e-02f, -4.99627739e-02f, 4.37680036e-02f, -1.08578175e-01f,
  1.80193856e-01f, 6.50752783e-02f, 1.77391917e-01f, -2.69905925e-02f, -1.84068049e-03f, 6.24321587e-02f, 1.18675902e-02f, 4.85058725e-02f, 9.06197540e-03f, -1.21472366e-02f,
  5.58573902e-02f, 6.70934170e-02f, 8.31462815e-03f, 9.49012954e-03f, 1.03919476e-01f, 7.91835040e-02f, 4.66119405e-03f, -2.51757652e-02f, 5.77008836e-02f, 9.39770490e-02f,
  1.47679806e-01f, 5.38216792e-02f, 7.68888071e-02f, -3.54989804e-02f, -4.05500829e-02f, 1.14601836e-01f, -6.29215734e-03f, 9.94367376e-02f, 1.11864522e-01f, 1.17308006e-01f,
  7.08352923e-02f, 1.08826973e-01f, 6.90396801e-02f, -3.22214030e-02f, 5.59944697e-02f, 3.45394574e-02f, -7.80210644e-02f, 2.00082753e-02f, 4.81691174e-02f, -3.77078392e-02f,
  5.78405559e-02f, 9.86832157e-02f, 4.43387218e-02f, -6.93655685e-02f, -2.07961444e-02f, -3.30149904e-02f, 5.72842024e-02f, -6.08571880e-02f, -3.14850062e-02f, -8.08808208e-02f,
  -1.33440569e-01f, -6.13305308e-02f, 1.99625101e-02f, -1.01273865e-01f, -1.02700315e-01f, 1.23946577e-01f, 2.43309401e-02f, -1.08731300e-01f, -5.21056615e-02f, -6.56718090e-02f,
  -1.12464115e-01f, -2.77390510e-01f, -1.06914453e-01f, -6.42798543e-02f, -8.62292275e-02f, -9.61944535e-02f, -2.77253598e-01f, -1.58666655e-01f, -1.07417531e-01f, -1.37103677e-01f,
  2.17186976e-02f, 1.05765751e-02f, -5.59462346e-02f, 8.11832584e-03f, -1.28324389e-01f, -1.06746994e-01f, -8.51231590e-02f, 5.63171990e-02f, 7.45337903e-02f, 1.38624590e-02f,
  -6.09226115e-02f, 6.58878759e-02f, 4.33888845e-02f, 8.20150971e-02f, -8.31776187e-02f, -7.34638348e-02f, -3.25281322e-02f, -4.70853411e-02f, -1.04426383e-03f, -1.34315938e-01f,
  -3.06923479e-01f, -2.47969106e-01f, 6.55571744e-02f, 7.33038411e-02f, -6.13640472e-02f, -5.79840839e-02f, 1.89525094e-02f, -1.25301722e-02f, -8.46444815e-02f, -6.34663776e-02f,
  -1.37481308e-02f, -4.15017866e-02f, -8.20904598e-02f, -4.09433246e-02f, -2.12359130e-02f, -1.89367421e-02f, -1.44166267e-02f, 2.94807386e-02f, -7.03568161e-02f, 9.95680038e-03f,
  5.88600012e-03f, -1.38339922e-01f, -1.23448692e-01f, -1.06002420e-01f, -4.53597084e-02f, -6.67273551e-02f, -1.07671842e-01f, -8.60004872e-02f, -9.32083577e-02f, -1.66733548e-01f,
  -5.28711267e-02f, -5.40992850e-03f, 8.28467775e-03f, 3.49093415e-03f, 5.69345206e-02f, 1.72604211e-02f, -2.37885639e-02f, -2.86522396e-02f, 4.39229272e-02f, 7.18120858e-02f,
  5.90633648e-03f, 1.50529388e-02f, -2.52922866e-02f, 3.52462865e-02f, -5.98099679e-02f, -7.50287250e-02f, -8.14644694e-02f, 3.70263704e-03f, -1.83214583e-02f, -1.34812212e-02f,
  -5.88415526e-02f, 1.89567283e-02f, -3.47563028e-02f, 1.30996760e-02f, 5.77826835e-02f, 1.14105723e-03f, -7.00553209e-02f, -8.89306590e-02f, -3.97405960e-02f, -4.45103720e-02f,
  -5.37818782e-02f, 5.53264022e-02f, -1.76222980e-01f, -5.94515987e-02f, -6.45982325e-02f, 1.03104442e-01f, -1.66647474e-03f, 7.35423341e-03f, 2.50890516e-02f, -9.56343859e-02f,
  5.75495027e-02f, -5.59688993e-02f, -1.18324928e-01f, -7.40742162e-02f, 3.81505601e-02f, -2.54519470e-02f, -1.35346344e-02f, -1.34765469e-02f, -3.60311307e-02f, 2.22820025e-02f,
  5.97518533e-02f, 2.89189233e-03f, -1.58199415e-01f, -1.44315168e-01f, -1.31156236e-01f, -7.12576061e-02f, -1.71075299e-01f, -1.51011184e-01f, -1.19996704e-01f, -9.96001884e-02f,
  -1.98670655e-01f, 1.89323425e-01f, 2.25791186e-01f, -1.79603528e-02f, -6.09011091e-02f, 3.10386736e-02f, 4.74753305e-02f, -1.00064002e-01f, -2.32718214e-02f, 5.15686162e-02f,
  5.52978478e-02f, -1.83506608e-01f, -1.33889481e-01f, -2.01215416e-01f, -5.01643568e-02f, -2.20247470e-02f, -4.06998582e-02f, -9.06432420e-02f, -2.78949648e-01f, -1.58867031e-01f,
  -2.43682370e-01f, -2.14481816e-01f, -2.48186484e-01f, -1.29173160e-01f, -2.05691922e-02f, -1.11932838e-02f, 1.33667022e-01f, 7.10923895e-02f, 1.60610396e-02f, 3.30036618e-02f,
  1.95691556e-01f, 1.65044799e-01f, -8.61348659e-02f, -9.97141749e-02f, 6.26675785e-02f, -2.72614304e-02f, 9.05452005e-04f, 8.19339007e-02f, 5.02156056e-02f, 1.23516634e-01f,
  8.97111371e-02f, -4.61916290e-02f, 2.59425249e-02f, -8.79472867e-02f, -4.02176157e-02f, -1.37688778e-02f, 9.00320187e-02f, -2.28669420e-02f, -6.70051202e-02f, -1.47667509e-02f,
  -4.86185923e-02f, 3.03556714e-02f, -3.51477377e-02f, 9.88244712e-02f, 3.11847776e-02f, 6.79187849e-03f, 1.54361576e-01f, 9.50281769e-02f, 8.67597833e-02f, 1.06304158e-02f,
  -1.04541682e-01f, 1.03509054e-01f, -2.06002966e-02f, -7.35211372e-03f, -8.61265734e-02f, 9.62833539e-02f, 8.36555660e-03f, 3.79637070e-02f, -5.64382933e-02f, 2.25458499e-02f,
  2.95675602e-02f, 1.48297757e-01f, -3.11035011e-02f, -5.59294177e-03f, 4.99695167e-03f, 9.16105211e-02f, 9.48306452e-03f, 5.51411090e-03f, -4.44780551e-02f, 9.87142622e-02f,
  1.92861594e-02f, 3.04157846e-02f, 1.12069562e-01f, -6.07328229e-02f, 2.55889463e-04f, 1.14298001e-01f, 8.35892707e-02f, -1.97085645e-02f, -5.65495901e-02f, -8.36772937e-03f,
  5.55628240e-02f, -1.00360103e-01f, -3.14739905e-03f, -3.46851684e-02f, -4.85826358e-02f, 7.61597604e-02f, 1.39943715e-02f, -8.08134302e-02f, 3.43295373e-02f, 1.77909676e-02f,
  6.98742121e-02f, 2.57942658e-02f, 6.21826053e-02f, 5.26578724e-02f, -7.73611069e-02f, -8.82609282e-03f, -9.03141722e-02f, 2.94710360e-02f, -9.09544826e-02f, 7.54893199e-02f,
  5.98126687e-02f, -6.53357282e-02f, 7.04271579e-03f, -7.47793764e-02f, 4.08822522e-02f, -1.32649258e-01f, 8.13592076e-02f, 1.45231802e-02f, -6.97961599e-02f, -4.15255092e-02f,
  -3.82686704e-01f, -1.03667766e-01f, -2.57671684e-01f, -1.83694512e-01f, -3.77175026e-02f, 2.56283917e-02f, 1.44569919e-01f, 1.66687384e-01f, 5.64571247e-02f, -1.38335392e-01f,
  -1.02858491e-01f, -1.54624358e-01f, -2.26092607e-01f, -1.20103270e-01f, -3.63063707e-04f, -4.90825996e-02f, -1.51076332e-01f, -1.82419255e-01f, -8.36841241e-02f, -3.63643393e-02f,
  -2.25941185e-02f, -2.60283411e-01f, -2.94747591e-01f, -2.35895559e-01f, -1.60776153e-01f, -2.95855373e-01f, -2.73329645e-01f, -2.53797293e-01f, -1.90114513e-01f, -1.64841205e-01f,
  -1.65161729e-01f, 1.14829009e-02f, 4.60407361e-02f, 2.83053610e-02f, -9.04986082e-05f, 8.65101516e-02f, 3.33714858e-02f, -1.13678686e-01f, 3.12090311e-02f, 1.03946915e-02f,
  -1.06390625e-01f, 5.48978262e-02f, -1.33882478e-01f, 6.36506900e-02f, -7.35739172e-02f, 6.82735220e-02f, 7.46575966e-02f, -1.43961236e-01f, -8.75388607e-02f, 3.94655876e-02f,
  -1.41443182e-02f, -1.56248584e-01f, -1.95630133e-01f, 6.58907667e-02f, 4.51224074e-02f, -7.36473277e-02f, -1.15203209e-01f, -4.10356857e-02f, 2.10029893e-02f, -9.39871222e-02f,
  5.07790335e-02f, 3.55635844e-02f, -3.47584113e-02f, 4.86318953e-02f, 4.90349382e-02f, -6.73306435e-02f, -5.21965697e-02f, -4.36720364e-02f, -2.92773023e-02f, 1.64447837e-02f,
  -4.95313294e-02f, -4.44470793e-02f, 6.05320521e-02f, -6.37048855e-02f, -7.39060193e-02f, 2.72420011e-02f, 1.69432499e-02f, 1.30318562e-02f, -7.11987028e-03f, 4.20297123e-03f,
  -4.51282263e-02f, 5.55152744e-02f, 4.13755188e-03f, 7.43557736e-02f, 3.79018188e-02f, 4.98540215e-02f, 6.10635020e-02f, 1.43141091e-01f, 3.44836898e-02f, 1.24819845e-01f,
  -2.14954257e-01f, -2.11171824e-02f, -5.08859791e-02f, 4.38838825e-02f, -4.27963324e-02f, -4.17940971e-03f, -2.29397006e-02f, 2.80392412e-02f, -5.68541288e-02f, 8.42121616e-03f,
  1.51951229e-02f, -5.39872684e-02f, 2.59060375e-02f, -3.94843332e-02f, -4.96398211e-02f, 6.24420866e-02f, -2.48273499e-02f, -7.50671625e-02f, -4.46268991e-02f, 8.10894594e-02f,
  3.48625705e-02f, -7.59192631e-02f, -1.78841233e-01f, 2.78263207e-04f, -8.20683762e-02f, -1.46426216e-01f, -1.27163649e-01f, -9.40591246e-02f, 2.26090271e-02f, -3.60034667e-02f,
  5.18517382e-02f, -1.69045618e-03f, -4.53572832e-02f, -4.56514657e-02f, 2.56755743e-02f, -4.68283333e-02f, 7.99602941e-02f, -3.54134701e-02f, -2.58882763e-04f, 1.02964886e-01f,
  5.12201674e-02f, -2.27947230e-03f, -2.17350237e-02f, -4.76719961e-02f, 5.64223081e-02f, 2.14531254e-02f, 3.66166048e-02f, -4.34343815e-02f, -6.24846183e-02f, -4.82929163e-02f,
  8.24405774e-02f, 8.35690349e-02f, 3.81167009e-02f, -2.40495875e-02f, 6.34994507e-02f, -5.50100915e-02f, 6.63158745e-02f, -6.01676702e-02f, -5.84470630e-02f, 4.17314060e-02f,
  8.60432461e-02f, -7.06387460e-02f, 1.04191143e-03f, -1.48265250e-02f, -8.01528916e-02f, -1.23582706e-01f, -1.17173314e-01f, -1.50262564e-01f, -1.81367639e-02f, -1.99952796e-02f,
  -4.89870571e-02f, 8.73091258e-03f, -8.52734819e-02f, 3.57077122e-02f, -4.15404374e-03f, 2.99332291e-02f, 9.21797659e-03f, -4.52169627e-02f, -4.92031612e-02f, -1.27601400e-01f,
  4.26219329e-02f, -2.69292165e-02f, -1.14272498e-01f, 3.43890488e-02f, -1.48090333e-01f, -8.24055076e-02f, -9.94994491e-02f, -8.92475247e-02f, -3.36716771e-02f, 8.52627754e-02f,
  6.55080676e-02f, 6.87671527e-02f, 2.06914337e-04f, 5.10394387e-02f, -3.95201370e-02f, 5.40987961e-03f, -3.25022340e-02f, 3.75144668e-02f, 9.00546834e-02f, -3.22832428e-02f,
  -6.53542206e-03f, -9.91050526e-02f, 4.90303598e-02f, 3.46422903e-02f, 1.33632701e-02f, -3.02214622e-02f, -2.97397580e-02f, -3.29018570e-02f, -6.27985373e-02f, -4.07852940e-02f,
  -2.18964666e-02f, 3.28381248e-02f, 7.89428800e-02f, -1.08398587e-01f, 9.50069458e-04f, -6.25884086e-02f, 7.68679753e-02f, -8.01125020e-02f, -8.04788396e-02f, -5.91380633e-02f,
  2.78627932e-01f, -9.20621008e-02f, 7.46646300e-02f, 3.08337715e-02f, 3.55358757e-02f, 3.49446908e-02f, -5.18300347e-02f, -2.51797173e-04f, -6.90711141e-02f, 1.50049133e-02f,
  1.88549664e-02f, -7.38098696e-02f, 7.05788285e-02f, -7.87198320e-02f, 1.28538400e-01f, -5.00428937e-02f, -4.72876132e-02f, 8.68045017e-02f, -2.65484024e-02f, -2.67958492e-02f,
  8.34717751e-02f, 5.43533787e-02f, 1.85916618e-01f, -9.03966185e-03f, 5.49960360e-02f, 2.52151899e-02f, 4.53395620e-02f, 4.17709984e-02f, -3.82817388e-02f, 2.60322392e-01f,
  2.87257910e-01f, 1.00139380e-01f, -8.83635730e-02f, -9.53312591e-03f, -1.10339969e-01f, -1.14250474e-01f, 2.67984662e-02f, -5.37765659e-02f, -4.44725379e-02f, 6.12410530e-02f,
  8.76095667e-02f, -2.37997454e-02f, -3.81773897e-02f, -1.10390700e-01f, -1.08993359e-01f, 9.28615332e-02f, 8.30431357e-02f, -5.76020293e-02f, -1.31630868e-01f, -8.45784415e-03f,
  1.14234343e-01f, 1.12008946e-02f, 1.44910172e-01f, 3.93011160e-02f, 9.39707905e-02f, 3.21563184e-02f, 5.78920841e-02f, 1.06503524e-01f, 6.23679869e-02f, 8.83156136e-02f,
  -6.33204728e-02f, 1.81504358e-02f, -1.62852168e-01f, 4.09285026e-03f, 3.66420001e-02f, 6.32726625e-02f, 7.79332519e-02f, 1.46686621e-02f, -6.02077842e-02f, 1.13302305e-01f,
  -3.15819215e-03f, -1.22951688e-02f, -3.51650529e-02f, 7.27082714e-02f, 8.26096386e-02f, -9.69283730e-02f, 2.57570595e-02f, 4.35202522e-03f, -5.65274060e-03f, 1.17440298e-02f,
  2.80410517e-02f, 5.66623881e-02f, -7.87087008e-02f, -7.00265616e-02f, 5.20806154e-03f, -9.19163749e-02f, 4.62916903e-02f, -1.07107006e-01f, -9.35546756e-02f, 1.59411281e-01f,
  3.61372270e-02f, 8.06936100e-02f, -6.15309961e-02f, 9.48370621e-02f, 8.83635599e-03f, -9.64978710e-02f, -6.06280938e-02f, -6.77140504e-02f, -2.01385021e-02f, -4.98416200e-02f,
  5.01343980e-02f, 7.83148259e-02f, -9.75668132e-02f, -5.26711382e-02f, -5.12524992e-02f, -2.62522586e-02f, 3.05907857e-02f, -4.11838517e-02f, 3.87644768e-02f, 2.77123023e-02f,
  -5.03682671e-03f, -7.97192603e-02f, 5.23869395e-02f, -9.48107168e-02f, 3.02108657e-02f, -8.26746523e-02f, 1.72074754e-02f, -7.53232390e-02f, -3.77095379e-02f, 6.46296591e-02f,
  1.21389061e-01f, -1.72861159e-01f, -2.92713959e-02f, -1.00511676e-02f, -7.82561153e-02f, 1.38206705e-02f, -7.83193111e-03f, -1.08375445e-01f, -1.06471680e-01f, 6.88538328e-02f,
  -3.13301124e-02f, 4.60538752e-02f, 1.59186125e-02f, 6.81828260e-02f, 1.56963672e-02f, -4.31363881e-02f, 5.89600913e-02f, 2.83848736e-02f, -5.16361892e-02f, -3.36325280e-02f,
  3.51218903e-03f, -2.47408729e-02f, 1.89560484e-02f, -2.01762971e-02f, -7.12506026e-02f, -1.24574922e-01f, -5.31827137e-02f, -6.07185923e-02f, -1.08942404e-01f, 4.85533699e-02f,
  8.94656703e-02f, -1.84598893e-01f, 2.77381726e-02f, 5.97194247e-02f, -1.05169035e-01f, -3.00450847e-02f, -1.21965505e-01f, -4.28987741e-02f, -8.52923021e-02f, -6.89456388e-02f,
  7.36270025e-02f, 5.68180531e-02f, 1.52123913e-01f, 7.43873566e-02f, 5.10089211e-02f, -8.75343159e-02f, -5.47171151e-03f, 7.91637376e-02f, 3.64579633e-02f, -6.77588657e-02f,
  -2.26902906e-02f, -1.34204526e-03f, 4.80105057e-02f, -9.22521502e-02f, -4.49471697e-02f, -1.60721391e-02f, 3.20342407e-02f, -9.52661186e-02f, -9.26726162e-02f, 2.01123822e-02f,
  2.70584881e-01f, 3.97303030e-02f, -2.12752633e-03f, 3.90626453e-02f, 7.50659704e-02f, -6.87496662e-02f, -6.07677214e-02f, -2.61037853e-02f, 7.83418771e-03f, -1.19745255e-01f,
  -2.61149742e-02f, 6.75672516e-02f, 2.23670295e-03f, -1.78713873e-02f, 2.80442066e-04f, -7.81203434e-02f, -2.03049742e-02f, 2.14956887e-02f, 4.56237011e-02f, -2.85490640e-02f,
  2.03101225e-02f, -6.24296665e-02f, 7.77731016e-02f, -6.54877350e-02f, -1.97275020e-02f, 1.04695685e-01f, 6.74481019e-02f, 3.93713675e-02f, 5.80424778e-02f, 3.84985767e-02f,
  -1.67280827e-02f, -2.76742391e-02f, -3.09660416e-02f, -2.55974196e-02f, -7.33129904e-02f, 4.81936261e-02f, 2.06802730e-02f, 1.62968729e-02f, -6.49154484e-02f, 6.20633624e-02f,
  5.53288730e-03f, -8.78069997e-02f, -7.46131614e-02f, -9.12602097e-02f, 6.20052814e-02f, -2.71223150e-02f, 3.56001295e-02f, -1.61852650e-02f, -3.28786373e-02f, -2.45223269e-02f,
  7.81925768e-03f, -8.86378065e-02f, -1.21411152e-01f, 2.09920970e-03f, 3.15527171e-02f, -2.95149200e-02f, -8.42630789e-02f, 2.82634329e-02f, 3.35931219e-02f, -1.08321838e-01f,
  4.87821698e-02f, -4.75806072e-02f, 1.43119302e-02f, 3.66816670e-02f, 1.36167668e-02f, 7.16639012e-02f, 1.10528365e-01f, -6.21470325e-02f, -5.62082417e-02f, 3.04499362e-02f,
  5.68624809e-02f, -3.07942294e-02f, -4.80430387e-02f, 1.18408529e-02f, 1.24471068e-01f, 8.36488605e-02f, -1.37356505e-01f, 1.02709375e-01f, -5.79429567e-02f, 6.49766764e-03f,
  -7.26450011e-02f, -2.09033806e-02f, 1.38728276e-01f, -6.38646483e-02f, -6.57069907e-02f, 1.17932528e-01f, 1.12438932e-01f, -3.96103086e-03f, 9.26300734e-02f, -4.61118780e-02f,
  3.27932805e-01f, -6.38132617e-02f, -3.35279673e-01f, 2.26255521e-01f, -1.31830812e-01f, -2.79540986e-01f, -2.94832230e-01f, -3.06430459e-02f, 6.26500621e-02f, -1.02131158e-01f,
  3.26100737e-02f, -9.08628032e-02f, -1.27515540e-01f, -3.03666234e-01f, -3.39631319e-01f, -4.61551726e-01f, -2.97925621e-01f, -4.75123942e-01f, -4.52247411e-01f, -2.14962453e-01f,
  -7.10297301e-02f, -1.22076133e-02f, -1.25496268e-01f, -1.37265414e-01f, 1.16302863e-01f, 3.03628352e-02f, -8.39610025e-02f, -1.16864480e-01f, -1.45026654e-01f, -9.73523483e-02f,
  -2.98294395e-01f, 1.56302512e-01f, -1.11718342e-01f, -8.61917622e-03f, -1.73575655e-02f, 4.03153747e-02f, -1.12170115e-01f, 6.86744079e-02f, 5.44032864e-02f, -7.93228820e-02f,
  4.91837077e-02f, -8.16973001e-02f, 2.93313079e-02f, -1.94978882e-02f, -3.06214523e-02f, -1.01885889e-02f, -7.82072823e-03f, -1.59543857e-01f, -9.80847478e-02f, -8.52884650e-02f,
  4.73722704e-02f, -1.12947926e-01f, -6.58499822e-02f, -8.30821916e-02f, 5.09705069e-03f, -8.56058821e-02f, 1.18395610e-05f, 7.85439759e-02f, -1.19547047e-01f, 1.28415436e-01f,
  -3.48280482e-02f, -3.62068713e-02f, 3.89775075e-03f, 7.20098466e-02f, 2.78157219e-02f, 8.07742104e-02f, -5.95573522e-02f, -2.34053768e-02f, -2.44149454e-02f, -2.56190484e-04f,
  1.60214922e-03f, 3.29888202e-02f, 1.49212340e-02f, 2.70654913e-02f, -4.64296378e-02f, -3.82556841e-02f, -1.18348049e-02f, -6.00056574e-02f, -4.08818014e-03f, -5.99449240e-02f,
  -1.50825204e-02f, -1.46810496e-02f, 7.91051462e-02f, -3.76935415e-02f, -6.47372901e-02f, -1.44985970e-02f, 1.61018427e-02f, 2.56270915e-02f, 4.86779213e-02f, -4.39646356e-02f,
  2.27611706e-01f, -1.62203595e-01f, -4.45613116e-02f, 3.78065109e-02f, -4.67843600e-02f, -3.52379531e-02f, 1.09840095e-01f, -6.07633628e-02f, -1.32916048e-02f, -8.84533301e-02f,
  4.88592200e-02f, -8.05505738e-02f, -5.74345589e-02f, -8.25796053e-02f, -2.97289193e-02f, -7.89527968e-03f, -9.10407230e-02f, -5.43376105e-03f, -3.24734822e-02f, 6.39047325e-02f,
  -3.31427567e-02f, -3.48301306e-02f, -7.43787810e-02f, -7.14324266e-02f, 1.70562975e-02f, -1.14811264e-01f, -1.38488248e-01f, 4.54890309e-03f, -1.30831048e-01f, -3.77110690e-02f,
  -3.74611408e-01f, -4.96652909e-02f, 1.00534916e-01f, -2.31686532e-02f, 1.92139268e-01f, 5.80256507e-02f, -1.57401294e-01f, -9.28238630e-02f, -1.27690569e-01f, 5.76256625e-02f,
  1.47734573e-02f, 9.25946906e-02f, -5.43117011e-03f, 2.68530603e-02f, -6.53142333e-02f, 1.48417596e-02f, 1.67926624e-01f, 9.96584892e-02f, -1.46251163e-02f, 1.19173247e-02f,
  3.43003497e-02f, 9.94263403e-03f, -8.90058726e-02f, -6.05559051e-02f, -8.25536717e-03f, 7.35002533e-02f, 8.24944228e-02f, -7.01103546e-03f, 1.51897565e-01f, 7.95406476e-02f,
  -1.08533591e-01f, -1.81766346e-01f, -7.00510889e-02f, 8.89447331e-02f, 9.82549787e-02f, -3.48925292e-02f, -6.40943646e-02f, 2.17371769e-02f, -3.85414399e-02f, -9.11896005e-02f,
  3.40860300e-02f, 5.25368266e-02f, -5.69063127e-02f, -1.04971088e-01f, -1.29042063e-02f, -1.19193107e-01f, -5.93278185e-02f, -4.06590067e-02f, -1.16831921e-01f, -1.50046527e-01f,
  1.40209630e-01f, 6.17699213e-02f, -8.50306898e-02f, -1.05028063e-01f, -1.12396128e-01f, -2.87481304e-02f, -6.17324151e-02f, -4.04582210e-02f, -6.80148229e-02f, -1.74609840e-01f,
  -2.54617725e-02f, -3.46466601e-02f, 6.29754364e-02f, -8.89156982e-02f, 4.14299369e-02f, -1.84982382e-02f, 1.00070231e-01f, -2.17598081e-02f, 1.74082387e-02f, 5.20399250e-02f,
  4.48395051e-02f, -8.66304338e-02f, 4.76687960e-02f, -2.68040653e-02f, 5.93698695e-02f, 1.19345468e-02f, 9.95908957e-03f, -8.12359974e-02f, 4.61606830e-02f, 2.11652759e-02f,
  -5.13064489e-02f, -4.33802940e-02f, -5.07797673e-02f, 3.99043374e-02f, -6.71060234e-02f, 9.24526621e-03f, -3.19436938e-02f, -5.66041060e-02f, -3.04960757e-02f, -4.02177265e-03f,
  -1.73021555e-01f, 1.79032728e-01f, -1.00457229e-01f, -7.51418620e-02f, 4.25564758e-02f, 3.93973626e-02f, 1.13668730e-02f, 1.33783212e-02f, -6.96320385e-02f, -1.45601243e-01f,
  3.24392915e-02f, -1.38635382e-01f, 9.07350797e-03f, 3.03254202e-02f, 1.28470957e-02f, -2.82380059e-02f, -3.75921987e-02f, -6.89082369e-02f, -6.29343763e-02f, -1.27885252e-01f,
  6.93714991e-02f, -1.87924638e-01f, -2.22794279e-01f, -1.61387563e-01f, -6.52774610e-03f, -3.74032371e-02f, -1.71930984e-01f, -2.12721333e-01f, -1.84178501e-01f, -2.42078736e-01f,
  -2.28754878e-01f, 6.94563836e-02f, 1.53441280e-01f, -3.05753320e-01f, -1.22100346e-01f, 5.91845848e-02f, 6.47788197e-02f, -5.27951866e-02f, -2.57860810e-01f, -1.29058152e-01f,
  7.62818847e-03f, -5.71683981e-02f, -1.53135904e-03f, -3.23863514e-02f, 1.24341354e-01f, -4.03939560e-02f, -4.29138355e-02f, 2.20840890e-02f, -6.43628687e-02f, -5.26981708e-03f,
  -3.45372744e-02f, -1.42486647e-01f, -8.30354914e-02f, -9.01444703e-02f, -1.13531098e-01f, -1.19974911e-01f, -3.59831192e-02f, -5.33614494e-02f, 5.85724674e-02f, -9.46441516e-02f,
  -8.65994990e-02f, -1.80722903e-02f, 7.94708729e-02f, 6.19028807e-02f, 4.20409106e-02f, -9.61863995e-02f, 2.05901638e-02f, -7.74202943e-02f, -7.97573361e-04f, -4.20799144e-02f,
  -8.87192339e-02f, -4.22000550e-02f, -5.93911000e-02f, -8.15437213e-02f, 1.58084799e-02f, 3.68771446e-03f, -7.15013146e-02f, 2.98697520e-02f, 4.41602990e-02f, 1.36847515e-02f,
  3.57785113e-02f, 9.86532122e-02f, 1.07400022e-01f, 2.90342011e-02f, 9.69797298e-02f, 7.44218752e-02f, -6.03481382e-02f, 5.39172441e-02f, 3.68488654e-02f, -1.85250625e-01f,
  -3.25478837e-02f, 3.13495249e-02f, -3.28491479e-02f, -5.76882437e-02f, 6.12738803e-02f, -6.39780536e-02f, 6.89477324e-02f, -7.91176632e-02f, 6.40263315e-03f, -6.13478459e-02f,
  9.98717174e-02f, -3.58454436e-02f, 1.70163605e-02f, -2.15305798e-02f, 4.93563861e-02f, -5.02335504e-02f, 5.51314577e-02f, -4.16900665e-02f, -2.14813603e-03f, 7.77048469e-02f,
  6.74158558e-02f, 5.74299172e-02f, -8.38978663e-02f, -2.79540326e-02f, 4.91715968e-03f, 8.15601200e-02f, -2.84836907e-02f, 6.14811890e-02f, -8.65108371e-02f, 3.01085114e-02f,
  -3.33433688e-01f, 4.04965669e-01f, -1.11951865e-01f, -9.50349048e-02f, 1.98404957e-02f, 8.13619867e-02f, -9.79006067e-02f, 7.09268153e-02f, -7.23536089e-02f, -5.19812331e-02f,
  1.23613030e-01f, -5.84023483e-02f, -2.74858661e-02f, -3.04295756e-02f, -1.24802478e-02f, -2.38647573e-02f, 4.27317917e-02f, -1.06470130e-01f, 1.07591227e-01f, -1.58803910e-02f,
  9.62907970e-02f, -1.07107952e-01f, -1.35051403e-02f, -1.31635159e-01f, -7.26559758e-02f, 9.17331595e-03f, -9.70056504e-02f, -2.85109729e-02f, 2.69199908e-02f, -1.29041180e-01f,
  1.47152454e-01f, 8.70007798e-02f, 3.59656185e-01f, 1.58285245e-01f, -1.36950493e-01f, -3.09465289e-01f, -3.57947379e-01f, -1.97582781e-01f, 8.39381441e-02f, -4.80308905e-02f,
  -5.79331182e-02f, -1.26555473e-01f, -9.02509168e-02f, -1.59541503e-01f, -1.74063981e-01f, -1.15014978e-01f, -4.16891053e-02f, 5.50012961e-02f, -7.64662921e-02f, -1.74213037e-01f,
  -2.05623478e-01f, 9.13795531e-02f, 5.05251214e-02f, 9.26914737e-02f, 5.70826232e-02f, -4.14121859e-02f, 9.94635299e-02f, 1.19198032e-01f, 6.94861189e-02f, 1.46909878e-01f,
  1.44264340e-01f, 2.88229942e-01f, -1.03281394e-01f, -1.01921797e-01f, 1.53044825e-02f, -7.45683685e-02f, -6.00996353e-02f, 1.70760289e-01f, -4.52410877e-02f, -4.97553982e-02f,
  -6.21381076e-03f, -1.03987575e-01f, 1.11315483e-02f, 2.41837278e-02f, -6.69197887e-02f, -1.20450445e-01f, -5.91564775e-02f, 1.37611434e-01f, 7.36800730e-02f, -4.90094870e-02f,
  -1.00567482e-01f, -1.22053206e-01f, -7.43142366e-02f, -1.13424301e-01f, 1.09725937e-01f, 7.32600316e-03f, 6.62992708e-03f, -4.59800810e-02f, 1.11321770e-02f, 7.31767416e-02f,
  1.02963001e-02f, -2.82712393e-02f, -2.80378554e-02f, -5.51228859e-02f, -5.52799143e-02f, -5.13544818e-03f, 4.44707423e-02f, -2.69524865e-02f, 1.18856616e-02f, 7.61008880e-04f,
  -6.69383854e-02f, -4.61715870e-02f, 1.23406621e-02f, 9.77733880e-02f, 2.90268231e-02f, 1.00080460e-01f, -1.22277908e-01f, 1.51178231e-02f, -2.11159158e-02f, 9.02300850e-02f,
  -2.94036791e-02f, 1.06045436e-02f, 9.11611840e-02f, -2.17514057e-02f, -4.33543734e-02f, 1.30499396e-02f, -7.57639334e-02f, -3.76635566e-02f, 2.82117929e-02f, 6.21450394e-02f,
  -6.89118207e-02f, -9.80383977e-02f, -1.05823338e-01f, -5.46701103e-02f, 7.76303783e-02f, 1.23281479e-02f, 3.06436755e-02f, 3.83904874e-02f, 6.64024428e-02f, -1.11069627e-01f,
  -6.08735457e-02f, -9.95824113e-02f, 2.37537548e-02f, -7.74030620e-03f, -1.04031742e-01f, -1.31180838e-01f, -6.26042560e-02f, -1.08116679e-01f, -1.08086564e-01f, -4.29603644e-02f,
  -4.43988815e-02f, -1.53556183e-01f, -1.74639329e-01f, -1.47913441e-01f, -2.45947838e-02f, -2.63929129e-01f, -2.20283359e-01f, -1.43792763e-01f, -3.09715509e-01f, -2.00840056e-01f,
  4.21781987e-01f, 4.88327205e-01f, 2.33667642e-01f, 1.24923564e-01f, -6.36724532e-02f, 1.79455340e-01f, 3.16717505e-01f, 2.34268144e-01f, 1.30863070e-01f, 1.71253115e-01f,
  8.91272500e-02f, -2.12688614e-02f, -5.54681337e-03f, 1.46932974e-01f, 1.97276771e-01f, 2.14694485e-01f, 2.00834334e-01f, 1.76657617e-01f, 1.37153432e-01f, -2.71755978e-02f,
  -1.90019365e-02f, 1.46710023e-01f, 1.43592939e-01f, 5.60712107e-02f, 3.38228010e-02f, -1.36524681e-02f, 6.81783184e-02f, 3.23906019e-02f, 1.30565971e-01f, 1.23772651e-01f,
  -9.73556936e-02f, 2.84193844e-01f, -2.03374743e-01f, -2.38949999e-01f, -1.25916839e-01f, 9.30200964e-02f, -9.66180637e-02f, -7.51221776e-02f, 2.65153870e-02f, -4.15163413e-02f,
  -7.99092799e-02f, -6.25763461e-02f, -7.98382461e-02f, 2.30322704e-02f, 3.72471958e-02f, 4.64263547e-04f, -4.73229289e-02f, 1.01058036e-01f, 5.66995330e-02f, -4.89386767e-02f,
  -5.89202195e-02f, -1.01008862e-01f, -5.68543337e-02f, 2.87507270e-02f, 7.93926418e-02f, -1.84082985e-01f, 1.07454434e-01f, 1.17145054e-01f, -2.14356519e-02f, 1.11314416e-01f,
  -1.04429126e-02f, -1.25932340e-02f, 7.35436231e-02f, -1.16893249e-02f, 3.02824620e-02f, -2.99628675e-02f, 2.94853244e-02f, 4.14718091e-02f, -5.17496141e-03f, -4.20541428e-02f,
  1.00820534e-01f, 4.03309651e-02f, 7.04854280e-02f, 5.64424582e-02f, -3.40948626e-02f, -3.06112226e-02f, 4.38539200e-02f, -3.47620845e-02f, 3.09720845e-03f, -8.09543878e-02f,
  -1.86509769e-02f, 8.15146044e-03f, -3.59364115e-02f, 2.23072506e-02f, -5.74992634e-02f, -3.73469032e-02f, -4.43966314e-03f, -7.02049956e-02f, 3.57481241e-02f, 4.52818945e-02f,
  -2.90096164e-01f, -2.03017950e-01f, -5.60767092e-02f, 3.62007543e-02f, 2.44341083e-02f, -6.93309456e-02f, 1.85624100e-02f, 2.95996908e-02f, -3.54570933e-02f, -3.10959723e-02f,
  2.34403275e-02f, 3.66284139e-02f, -2.80632377e-02f, -5.06032072e-02f, -7.90183395e-02f, -1.01868145e-01f, -1.03893399e-01f, -6.56503364e-02f, -4.59661521e-02f, -6.95268363e-02f,
  -5.81368171e-02f, -1.08981922e-01f, -1.15251921e-01f, -1.26257107e-01f, -6.15498349e-02f, -2.55884081e-01f, -9.85117480e-02f, -2.19019607e-01f, -1.76546246e-01f, -6.79597259e-02f,
  -3.94884273e-02f, 1.18825428e-01f, -2.03034282e-01f, 1.45443410e-01f, -6.70975223e-02f, -2.69386172e-01f, -2.57740974e-01f, -2.51651168e-01f, 1.29774809e-01f, 1.77665845e-01f,
  1.84155162e-02f, 7.14292526e-02f, -5.32727987e-02f, -1.41300574e-01f, -3.44298959e-01f, -1.03067197e-02f, 5.72624207e-02f, -1.93383008e-01f, -4.72846955e-01f, -2.40455985e-01f,
  -1.90154240e-02f, -1.24011286e-01f, -1.35147050e-01f, 8.86420812e-03f, 2.81351984e-01f, 1.19375408e-01f, 1.32083684e-01f, 1.40387416e-01f, 1.05985492e-01f, 2.56579816e-01f,
  4.79093008e-03f, -9.50358286e-02f, -1.75508305e-01f, 7.54735544e-02f, 1.76124349e-02f, 3.30424565e-03f, 5.98307289e-02f, -4.73584533e-02f, -1.15270689e-02f, 5.80086410e-02f,
  -6.68058693e-02f, -1.29614375e-03f, -9.66322348e-02f, 5.12390137e-02f, -3.34943980e-02f, -1.22783884e-01f, -8.41270760e-02f, -1.38162881e-01f, -1.80446357e-01f, -4.52513434e-02f,
  1.40739560e-01f, -1.15623914e-01f, -2.31772959e-01f, -3.29455249e-02f, -2.65997779e-02f, -1.34980783e-01f, -1.30761176e-01f, -1.06352322e-01f, -1.08723536e-01f, 1.73051715e-01f,
  9.42596421e-02f, 2.10528523e-02f, -6.71978714e-03f, 1.88190900e-02f, 5.55245131e-02f, -3.36281545e-02f, 5.25629744e-02f, 4.68925387e-03f, 1.83910858e-02f, -5.42168505e-02f,
  4.78062965e-02f, -5.07054850e-02f, 7.68257529e-02f, 1.67437959e-02f, 3.23281176e-02f, -3.21076699e-02f, 4.88404557e-02f, -9.60018393e-03f, -6.88939020e-02f, 7.93075934e-02f,
  -8.70796852e-03f, 2.01686081e-02f, 8.59803632e-02f, -6.63512945e-03f, -5.31006977e-02f, 4.98542003e-02f, 3.12779972e-04f, -1.56605579e-02f, -6.96799010e-02f, -2.47955117e-02f,
  2.26807669e-02f, -2.81147957e-01f, 5.48197702e-02f, 1.58291291e-02f, 9.47748274e-02f, 8.88173729e-02f, 8.13669786e-02f, 1.46934632e-02f, -1.33695612e-02f, -6.96466491e-02f,
  -1.47932932e-01f, -2.46782470e-02f, -2.79006884e-02f, -3.86371231e-03f, -9.40352976e-02f, -2.50040175e-04f, 3.73546258e-02f, -3.17952149e-02f, -7.85056949e-02f, 4.32883762e-02f,
  -1.37678264e-02f, -1.47040188e-01f, -1.41938701e-01f, -5.82402237e-02f, -7.64311664e-03f, -2.95423958e-02f, -1.09894499e-01f, -1.39526978e-01f, -2.12015674e-01f, 3.94467711e-02f,
  3.60901564e-01f, 3.54782373e-01f, -8.05244874e-03f, -3.03620715e-02f, -2.20066458e-01f, -2.66534477e-01f, -7.17270523e-02f, -6.85704425e-02f, -1.72087308e-02f, 1.28949508e-01f,
  -7.29086548e-02f, -1.55902222e-01f, -1.12122595e-01f, -5.63013460e-03f, -1.07375979e-01f, 1.72656760e-01f, 8.29935521e-02f, 5.72674312e-02f, -1.04432620e-01f, -6.75870627e-02f,
  -6.81293309e-02f, -2.54379176e-02f, 1.31502807e-01f, 5.27390540e-02f, 2.12226957e-01f, -4.95454334e-02f, 5.22649810e-02f, 3.75147611e-02f, 3.75810191e-02f, 3.35891455e-01f,
  1.74557015e-01f, 1.78552225e-01f, -1.24952346e-01f, 3.81362401e-02f, 3.07072420e-02f, 8.40506852e-02f, 1.09786354e-01f, 1.06137075e-01f, -1.03523888e-01f, 1.10603824e-01f,
  -7.04634562e-02f, 7.15030879e-02f, 5.99174062e-03f, -3.05100810e-02f, 6.68365881e-02f, 2.59400345e-02f, 1.11221932e-01f, -2.45540962e-02f, 3.20796259e-02f, 5.10447286e-02f,
  -4.58905511e-02f, -1.14632964e-01f, -1.13134846e-01f, -1.34981990e-01f, -6.51651174e-02f, -1.43120274e-01f, -4.56283391e-02f, 1.13646239e-01f, -7.91942850e-02f, 2.94682115e-01f,
  2.31757220e-02f, -4.14630696e-02f, -3.97164449e-02f, 6.61312714e-02f, -1.11073926e-02f, 5.77651486e-02f, 1.04153775e-01f, -3.30856778e-02f, 1.82092972e-02f, 7.38864914e-02f,
  -4.50311378e-02f, -3.57382782e-02f, 8.38478878e-02f, 8.26706458e-03f, 3.37726399e-02f, 4.78963591e-02f, -4.88246977e-02f, 3.34677808e-02f, 1.88330915e-02f, 2.13477947e-02f,
  6.23512045e-02f, -7.52061531e-02f, -3.42487879e-02f, -4.54504974e-02f, 4.67300862e-02f, 2.08433867e-02f, 1.30263031e-01f, -4.41404842e-02f, -7.09685148e-04f, 1.33001972e-02f,
  -1.64248064e-01f, -4.23988640e-01f, 7.12984204e-02f, 1.07638530e-01f, -7.58586004e-02f, 4.56135496e-02f, -8.40174556e-02f, -3.43682021e-02f, 1.01439795e-02f, -1.63395200e-02f,
  -4.64722104e-02f, 5.34085110e-02f, -2.08763313e-02f, -5.08885533e-02f, -4.23343144e-02f, -4.59818897e-04f, 8.29873011e-02f, -4.52526323e-02f, -5.34890629e-02f, -3.27812396e-02f,
  -1.39437467e-02f, -7.38377199e-02f, -1.81972027e-01f, -1.67185813e-01f, 2.00084243e-02f, -2.02852845e-01f, -1.04469568e-01f, -3.14287618e-02f, -2.44737919e-02f, 1.50861014e-02f,
  -9.88779217e-02f, 9.31567475e-02f, -3.46880317e-01f, -1.97694615e-01f, -1.96101427e-01f, -3.36246192e-02f, -7.45823681e-02f, -6.64139614e-02f, -5.27249649e-03f, -7.06976280e-02f,
  -2.86285765e-03f, 6.36458248e-02f, 5.47397770e-02f, 6.22576918e-04f, -3.10250204e-02f, -1.88286249e-02f, -1.01620793e-01f, -1.60301372e-01f, -9.55674350e-02f, 1.08030945e-01f,
  1.64260745e-01f, 8.13147798e-02f, 1.75616033e-02f, -9.95721072e-02f, -1.62564348e-02f, -7.18647838e-02f, -9.58147943e-02f, -3.21427248e-02f, -9.87351537e-02f, -1.41725525e-01f,
  -2.24919505e-02f, -9.96476784e-02f, 2.88140159e-02f, 9.01488662e-02f, -1.43820241e-01f, -3.94566655e-02f, 3.40003707e-02f, -1.45797491e-01f, -5.81440255e-02f, -7.51642436e-02f,
  1.70243680e-02f, 1.12758800e-02f, -5.65941110e-02f, -7.66126961e-02f, 3.11416779e-02f, -4.69669234e-03f, 5.37237898e-02f, -1.23795249e-01f, -1.32551700e-01f, -7.79927103e-03f,
  3.21614444e-02f, -1.33449778e-01f, -1.55655935e-01f, -1.01633032e-03f, -1.03711970e-01f, -7.60797635e-02f, 3.13815065e-02f, -9.42272618e-02f, -4.64440919e-02f, 3.27239223e-02f,
  6.14895783e-02f, -1.44030731e-02f, -2.55507212e-02f, 6.09714501e-02f, 5.97896092e-02f, 4.81963046e-02f, -1.35762710e-02f, -2.28960495e-02f, 6.78081736e-02f, -5.01953401e-02f,
  3.13426331e-02f, 3.90683487e-02f, 8.34623203e-02f, 8.23313743e-02f, 6.39529079e-02f, -6.87438296e-03f, -1.41139189e-02f, 8.06998536e-02f, -1.40338354e-02f, 4.87927115e-03f,
  1.02007098e-01f, -4.67812344e-02f, 3.48087028e-02f, 3.24259810e-02f, -5.82678877e-02f, -8.35005566e-02f, 2.41561271e-02f, 7.79112987e-03f, -7.85587654e-02f, -6.76243156e-02f,
  3.01081151e-01f, -2.40384489e-02f, 3.80999851e-03f, 6.57385364e-02f, -3.72680053e-02f, -8.01564902e-02f, -7.50381723e-02f, -9.17025357e-02f, -1.21360488e-01f, 9.00839269e-02f,
  2.90515684e-02f, -6.15641661e-02f, 2.37310492e-02f, 4.68752235e-02f, 2.86549935e-03f, 1.01906983e-02f, 4.22946587e-02f, -1.01557434e-01f, 2.82252841e-02f, -7.01518133e-02f,
  7.71528780e-02f, 6.09727651e-02f, 1.81318875e-02f, 5.75281754e-02f, 1.50868874e-02f, 5.45156412e-02f, 2.72774510e-02f, -1.49570517e-02f, 8.60527158e-02f, 2.81006634e-01f,
  -4.85988677e-01f, 7.35638216e-02f, 3.68083492e-02f, -3.14330727e-01f, 2.63558626e-02f, 2.98001289e-01f, 2.03569278e-01f, 1.35768920e-01f, -3.80490236e-02f, 1.01785054e-02f,
  2.28683930e-02f, -5.50916530e-02f, -4.95978594e-02f, 2.29784939e-02f, -1.03808669e-02f, 1.23019151e-01f, -4.28730920e-02f, -5.20221256e-02f, -1.04153492e-02f, 4.89101596e-02f,
  1.25334859e-02f, -2.40516499e-01f, -2.60275543e-01f, -6.09635897e-02f, -5.87317906e-02f, -1.74659669e-01f, -5.99659346e-02f, -1.46864563e-01f, -3.14470381e-02f, -1.28269255e-01f,
  -2.01262623e-01f, 1.55953085e-02f, -3.28571796e-02f, -9.58747566e-02f, -8.27886313e-02f, -8.88692439e-02f, -1.07783005e-01f, -2.21063551e-02f, -8.98285210e-02f, -9.48720649e-02f,
  3.98766957e-02f, -7.65519887e-02f, 1.54302549e-02f, 6.86295629e-02f, -1.09017476e-01f, 6.20111311e-03f, 3.43311168e-02f, -1.59643441e-02f, 4.73232567e-02f, 7.69268647e-02f,
  1.11960046e-01f, 1.02039392e-03f, 2.99940514e-03f, 6.42531365e-02f, -2.31731813e-02f, 4.71404940e-02f, 4.57674526e-02f, -4.57350127e-02f, 3.41393799e-02f, -2.56902933e-01f,
  3.81736718e-02f, 2.52495462e-04f, 7.74839567e-03f, -4.86464761e-02f, 5.20693921e-02f, 2.58675087e-02f, -6.47381246e-02f, -2.56661267e-04f, 3.52377370e-02f, -1.08394153e-01f,
  8.03846270e-02f, 3.69409211e-02f, 4.39190716e-02f, -5.97845949e-02f, -6.13022745e-02f, -1.19218212e-02f, 8.21579769e-02f, 2.83891615e-02f, 7.09330961e-02f, 3.28312777e-02f,
  2.59684641e-02f, -8.85190442e-03f, -4.08871733e-02f, -5.96795231e-02f, 4.83613126e-02f, -5.75614423e-02f, 3.36808078e-02f, -3.88760604e-02f, 3.10869459e-02f, -1.92728974e-02f,
  -3.01943302e-01f, 1.39237612e-01f, -3.55032980e-02f, -1.03651453e-02f, -9.36536491e-02f, 4.59092073e-02f, -1.08248815e-01f, -1.59070231e-02f, 1.07798642e-02f, -3.12095061e-02f,
  2.58879680e-02f, -5.60436919e-02f, -1.22036062e-01f, 4.84066196e-02f, 4.87303548e-03f, 2.79561896e-02f, -5.76137155e-02f, -3.76613885e-02f, 7.12454319e-02f, -5.29259816e-02f,
  -4.01640423e-02f, 1.09241800e-02f, -6.42941520e-02f, -5.07220849e-02f, -8.97651538e-02f, -7.01102912e-02f, -6.65597245e-02f, -1.57736391e-01f, -9.48792100e-02f, -1.78874403e-01f,
  1.49670690e-01f, -2.05498800e-01f, 8.97585601e-02f, 1.71594709e-01f, 1.78441197e-01f, 2.44082823e-01f, 1.63221076e-01f, 1.73197463e-01f, 1.54785365e-01f, 5.10373674e-02f,
  -1.22641161e-01f, -1.21775374e-01f, -1.55248031e-01f, -8.74192640e-02f, -9.97570008e-02f, 7.54314428e-03f, 2.47863308e-02f, -7.93470163e-03f, 1.36864588e-01f, 5.48255676e-03f,
  9.48351249e-02f, 8.23109075e-02f, 4.93852273e-02f, -2.86355540e-02f, -9.56472903e-02f, -8.49345922e-02f, -1.05896369e-02f, 2.42591351e-02f, -4.43638265e-02f, -6.68888241e-02f,
  -1.81419432e-01f, -1.22460164e-01f, 1.19806252e-01f, -1.06955789e-01f, -1.53536558e-01f, -9.67299193e-02f, -4.66137379e-02f, -8.59071240e-02f, -1.06903292e-01f, 7.51688257e-02f,
  8.16666055e-03f, -9.20382887e-02f, -3.73509675e-02f, 2.39245296e-02f, 7.21037388e-02f, -6.77687675e-02f, -1.18326522e-01f, 1.27906511e-02f, -9.51301083e-02f, -5.55057004e-02f,
  -6.83465153e-02f, -7.10895704e-03f, -6.92280829e-02f, -3.37033123e-02f, -1.43980280e-01f, -8.96037742e-02f, -1.22815080e-01f, -3.13937180e-02f, 2.36390494e-02f, 2.60483138e-02f,
  -7.01953145e-03f, -4.08675112e-02f, -9.21159144e-03f, -5.14059886e-02f, 5.14736436e-02f, 4.64188717e-02f, 9.26834047e-02f, 9.82367620e-03f, 2.36872025e-02f, -6.52373880e-02f,
  6.53644875e-02f, 2.84424033e-02f, -1.88212041e-02f, 6.14523441e-02f, -9.50650349e-02f, -2.76570879e-02f, 1.67729144e-04f, 2.49559861e-02f, 1.90527632e-03f, 8.93397350e-03f,
  5.65462448e-02f, -3.76561098e-02f, -9.02628005e-02f, -5.60784601e-02f, -1.15473822e-01f, -8.23561624e-02f, -6.57378638e-04f, -7.73140639e-02f, -2.57843304e-02f, 8.62193182e-02f,
  -6.48817942e-02f, -2.99210642e-02f, 6.59974292e-02f, 3.11762951e-02f, -3.42052244e-02f, -6.80052163e-03f, -4.34096009e-02f, 6.88951556e-03f, 2.03105994e-02f, 7.42680505e-02f,
  -5.71564361e-02f, 6.64438680e-02f, -9.00514126e-02f, 2.26238538e-02f, 6.02176487e-02f, 9.17463005e-03f, -7.19952956e-03f, 8.11554864e-02f, -2.54819938e-03f, -1.27858460e-01f,
  -4.52338457e-02f, 1.17349267e-01f, 1.22079752e-01f, 1.68761358e-01f, 2.47729360e-03f, 1.69730365e-01f, 1.65883228e-02f, 1.01913951e-01f, 1.92059025e-01f, 2.92763978e-01f,
  -8.77818465e-02f, 1.14173867e-01f, 4.79873940e-02f, -1.05812944e-01f, 4.15808707e-02f, 3.36854272e-02f, 6.64252713e-02f, -1.03789799e-01f, -4.18763980e-02f, 7.57015720e-02f,
  3.91813293e-02f, 4.01346721e-02f, -7.59587856e-03f, 2.79515050e-02f, 5.05076628e-03f, -2.55486779e-02f, 5.09866215e-02f, -1.42806107e-02f, -1.21811479e-01f, -1.04326859e-01f,
  2.08374951e-02f, 6.28338158e-02f, -1.39544114e-01f, -1.64224043e-01f, -1.11205965e-01f, 3.25125642e-02f, -8.45823996e-03f, -8.89720023e-02f, 2.71033787e-04f, -9.46463719e-02f,
  2.89550841e-01f, -1.37715131e-01f, -6.20133206e-02f, -1.34183422e-01f, -5.00845723e-02f, -6.77040443e-02f, 6.79664221e-03f, -2.53778566e-02f, -9.89954621e-02f, 4.60044779e-02f,
  3.46056744e-02f, -5.09768762e-02f, -9.31534097e-02f, -4.46743444e-02f, -8.86330828e-02f, 2.08891914e-04f, -1.40425891e-01f, -4.72283252e-02f, -1.13434531e-02f, -9.97312963e-02f,
  -2.76665613e-02f, -9.39202309e-03f, 9.98745859e-02f, -7.03271851e-02f, -1.29401863e-01f, -9.27396268e-02f, 5.11778556e-02f, -1.27719119e-01f, -1.05998382e-01f, 7.20317289e-02f,
  -1.73994172e-02f, -1.29394075e-02f, 2.31396244e-03f, 1.03088178e-01f, 8.73839632e-02f, -4.93946392e-03f, 2.93602608e-02f, 7.93159455e-02f, 5.59107307e-03f, 9.68435332e-02f,
  -5.62364049e-02f, 8.30118135e-02f, 9.64599848e-03f, -4.36454751e-02f, 3.00876610e-02f, -3.72465737e-02f, -1.16369585e-02f, 7.79648945e-02f, 8.82185698e-02f, -7.79057890e-02f,
  3.02949306e-02f, 5.14723128e-03f, 4.94238809e-02f, 3.45390779e-03f, 1.30161298e-02f, -1.52614387e-02f, 4.65877466e-02f, -9.97994021e-02f, 2.75822561e-02f, -4.32285964e-02f,
  2.45176345e-01f, -2.24737264e-02f, 8.69267136e-02f, -8.73716250e-02f, -1.45429978e-02f, -1.09574772e-01f, 8.91042501e-02f, -1.25159815e-01f, -1.24959402e-01f, -7.92665854e-02f,
  -1.61915086e-02f, -1.13478117e-02f, 3.53585929e-02f, -1.99049506e-02f, 1.11593962e-01f, 4.82343510e-02f, -2.55895406e-02f, 9.68386768e-04f, -6.57785311e-02f, -7.48404264e-02f,
  -3.74716632e-02f, 1.42897412e-01f, 1.09729104e-01f, 7.86035061e-02f, 2.16843523e-02f, -4.84675821e-03f, 1.62433848e-01f, 1.17629543e-01f, 4.62393798e-02f, 2.03290030e-01f,
  1.44749030e-01f, -1.72826666e-02f, 3.47191185e-01f, 7.16372952e-02f, 4.39574510e-01f, 4.95065600e-01f, 5.16660750e-01f, 2.09749207e-01f, 7.62165785e-02f, 9.86798257e-02f,
  -1.10115431e-01f, -2.64746130e-01f, -2.41359159e-01f, -2.34409392e-01f, -1.61124498e-01f, 6.95527345e-02f, 8.07244405e-02f, -4.79200482e-02f, 2.69924104e-02f, 2.19312534e-02f,
  7.07473829e-02f, 1.11911356e-01f, 5.78986183e-02f, -3.68362330e-02f, 5.65478317e-02f, -1.50701866e-01f, -1.58271957e-02f, 1.22163542e-01f, -7.43565932e-02f, -1.08667932e-01f,
  -1.78619042e-01f, 1.62480161e-01f, -1.98438135e-03f, -1.84353977e-01f, -1.11953914e-02f, -9.67675075e-02f, -7.28842104e-03f, -4.75513842e-03f, 1.26567530e-02f, -3.72496657e-02f,
  -3.45239826e-02f, -1.15978584e-01f, -1.28810003e-01f, -3.38423364e-02f, 1.27247244e-01f, 7.87830055e-02f, -1.41070172e-01f, -1.49888501e-01f, -1.31002814e-01f, -1.47821948e-01f,
  -1.22312233e-01f, 2.71690693e-02f, 1.90189004e-01f, 8.15306082e-02f, -3.01758591e-02f, -1.45867869e-01f, -4.16026972e-02f, -1.40282020e-01f, 1.63879227e-02f, -3.44154164e-02f,
  -6.01797514e-02f, -3.67012694e-02f, -2.67243776e-02f, 8.75190869e-02f, -5.82606606e-02f, 6.89995959e-02f, 2.96785850e-02f, -2.52207574e-02f, 9.82013121e-02f, 1.09602824e-01f,
  -7.70408241e-03f, 3.87385227e-02f, 4.68662642e-02f, 5.65097928e-02f, 3.02923191e-02f, 1.08024627e-02f, 3.75253372e-02f, -5.68639226e-02f, -4.79332311e-03f, 2.92266924e-02f,
  -1.22553785e-03f, 1.08625693e-02f, 8.16526711e-02f, -5.80405304e-03f, 5.43517806e-03f, -1.63461547e-02f, -6.20177574e-02f, -5.13493121e-02f, 2.83795036e-02f, 4.51779477e-02f,
  -9.18902159e-02f, 1.67915329e-01f, -1.56228408e-01f, -1.61490679e-01f, 8.61556605e-02f, -9.13963243e-02f, -1.16300641e-03f, -1.29875630e-01f, -4.76665385e-02f, 5.44664897e-02f,
  -4.26234975e-02f, -3.15466560e-02f, 1.85829420e-02f, -5.97038597e-04f, 1.51603922e-01f, 1.09754406e-01f, 1.43248923e-02f, -2.34920513e-02f, -8.41872841e-02f, -9.14806500e-03f,
  -4.33116965e-02f, 1.74096078e-01f, 1.91872999e-01f, 1.54878190e-02f, -9.44606587e-02f, -2.00824086e-02f, 8.09487924e-02f, 3.18966247e-02f, 1.65089190e-01f, 1.32183090e-01f,
  -3.89961839e-01f, 9.36188027e-02f, -8.34480971e-02f, -3.26543808e-01f, -1.53602749e-01f, -7.29744434e-02f, 5.55267967e-02f, -1.26180435e-02f, -6.35351390e-02f, 5.80709167e-02f,
  7.03731254e-02f, -1.68881997e-01f, -1.47230238e-01f, 4.08715829e-02f, 8.22974443e-02f, 9.86467153e-02f, -6.87303022e-03f, -2.25764930e-01f, -2.16044068e-01f, -8.19880217e-02f,
  -2.10538562e-02f, -2.63165027e-01f, -1.68508813e-01f, -1.80087745e-01f, -1.64457634e-01f, -9.48708653e-02f, -9.04731452e-02f, -1.85538828e-01f, -9.26611200e-02f, -1.57841608e-01f,
  2.67108291e-01f, -1.94693744e-01f, -7.51234442e-02f, 3.15664560e-02f, -8.60813633e-02f, 2.44295821e-02f, -6.60512075e-02f, -6.53122365e-02f, 5.64704500e-02f, -1.37156742e-02f,
  -8.35967585e-02f, -1.10656157e-01f, -1.30463973e-01f, 4.46451418e-02f, -1.11582182e-01f, -6.15750104e-02f, 1.53035959e-02f, 6.44995868e-02f, -3.42845507e-02f, 1.44402087e-01f,
  9.43387300e-02f, 2.19866894e-02f, -4.90444340e-02f, 7.05687255e-02f, -2.93379184e-02f, -2.21912749e-02f, -1.79406181e-02f, 2.53394078e-02f, 6.84556961e-02f, 1.46186963e-01f,
  -1.37742367e-02f, 2.17186473e-02f, -3.73951904e-02f, -4.98868525e-02f, 1.56852938e-02f, -1.85486535e-03f, -5.94909489e-02f, -2.68574990e-02f, -7.04235956e-03f, 8.36953148e-02f,
  9.04545262e-02f, -1.89772043e-02f, 8.80862698e-02f, 5.52644208e-02f, 8.38204250e-02f, -6.24817796e-02f, -3.68393995e-02f, 5.37769217e-03f, -5.10030687e-02f, 3.69230174e-02f,
  1.52752222e-02f, -1.16531951e-02f, 1.46184405e-02f, -2.82021463e-02f, 5.60394190e-02f, 3.08506042e-02f, -4.67315875e-02f, 2.45954245e-02f, 9.98345762e-03f, -3.16270553e-02f,
  6.41087368e-02f, -7.66053647e-02f, -1.63399968e-02f, -8.80162418e-02f, 6.18369132e-03f, 2.01300196e-02f, 2.66980510e-02f, 1.12585546e-02f, -6.84627518e-03f, -7.76971430e-02f,
  -3.40468287e-02f, 7.30482191e-02f, -7.15520745e-03f, 9.40433219e-02f, 4.98933084e-02f, -4.49536834e-03f, 4.08243062e-03f, -1.94561053e-02f, 4.75821421e-02f, 4.34947610e-02f,
  2.16908172e-01f, -1.37584833e-02f, 2.79057492e-02f, 6.63413852e-02f, 5.47652580e-02f, 3.03383097e-02f, 8.05724189e-02f, 9.01829302e-02f, 1.22951910e-01f, 2.37361893e-01f,
  4.41590667e-01f, -1.07549191e-01f, -4.68901187e-01f, 9.86012146e-02f, -7.76433945e-03f, -1.11220717e-01f, 4.46075434e-03f, 2.54598558e-02f, 1.84461649e-03f, 6.66745827e-02f,
  -1.07862875e-01f, -6.34596348e-02f, -8.83884635e-03f, -5.38260192e-02f, -1.56574950e-01f, -1.35706171e-01f, -5.29068261e-02f, -1.91167697e-01f, -1.55820891e-01f, 7.35700876e-02f,
  1.25601869e-02f, 2.84960736e-02f, 1.55511662e-01f, 7.18307272e-02f, -4.58781309e-02f, -1.49837032e-01f, -1.45089835e-01f, -4.52500470e-02f, -1.63068265e-01f, -7.92479888e-02f,
  -4.02398974e-01f, -1.18172407e-01f, -6.64563850e-02f, 1.16079457e-01f, -1.62324771e-01f, 6.80341274e-02f, -1.04957996e-02f, -5.27666435e-02f, -3.28697674e-02f, 2.26966515e-02f,
  -7.36223832e-02f, -8.17818791e-02f, -1.12703510e-01f, 6.00506831e-03f, -2.17296612e-02f, -1.17025375e-01f, 5.38559668e-02f, -4.03810851e-02f, -1.34397998e-01f, -6.83848187e-02f,
  4.40822728e-03f, -1.38291836e-01f, -1.68270037e-01f, -3.94989364e-02f, -8.74864161e-02f, -1.28024742e-01f, -1.52380496e-01f, -5.42496368e-02f, -9.88445804e-02f, 5.38587198e-02f,
  9.05986279e-02f, -3.20311054e-03f, -7.29249716e-02f, -8.81083123e-03f, 1.31957456e-01f, 4.25959527e-02f, 2.72219349e-02f, 5.10058179e-02f, 3.17526958e-03f, -5.21289036e-02f,
  -6.17966577e-02f, 6.34464324e-02f, 5.96999489e-02f, -4.50290553e-02f, -4.36848104e-02f, -3.05800159e-02f, -1.92442387e-02f, 1.05472207e-01f, 4.96699549e-02f, 3.31315808e-02f,
  3.33306491e-02f, -3.30867022e-02f, 3.27782929e-02f, 3.63387950e-02f, -1.33033767e-01f, 5.03802747e-02f, -5.44651933e-02f, 7.52435699e-02f, 3.48147824e-02f, -3.51660550e-02f,
  2.15653136e-01f, -7.30768442e-02f, 6.00949936e-02f, 1.01170473e-01f, -1.03324272e-01f, 8.23478866e-03f, -1.84461102e-02f, -7.11720437e-03f, -9.92703512e-02f, -2.94087231e-02f,
  -1.26590272e-02f, 3.14581878e-02f, -7.22692301e-03f, -7.95650706e-02f, 1.92850805e-03f, 1.77399497e-02f, 8.53263587e-02f, 8.49483535e-02f, -1.28592988e-02f, 9.47162956e-02f,
  1.98333888e-04f, 2.05731004e-01f, 2.57876098e-01f, 4.49721664e-02f, -7.83438683e-02f, -1.85778588e-02f, 1.65719874e-02f, 7.74095431e-02f, 3.51635031e-02f, 2.49331295e-01f,
  9.06651095e-02f, 3.57021540e-01f, 2.05922592e-02f, 1.02842391e-01f, 2.82478426e-03f, 1.61282629e-01f, 2.20750794e-01f, 1.63687453e-01f, 4.47504828e-03f, 2.64152884e-02f,
  4.13347892e-02f, -1.40667886e-01f, -3.75803001e-03f, -1.18918613e-01f, -5.53902797e-02f, 1.54526055e-01f, 3.12241521e-02f, -5.94695546e-02f, -1.79234713e-01f, -1.41567051e-01f,
  7.66972080e-02f, -1.95376296e-03f, -1.04245373e-04f, 1.35920327e-02f, -5.92831783e-02f, -9.35173705e-02f, -2.14107577e-02f, 7.96984509e-02f, -4.27540392e-02f, 1.88165868e-03f,
  -1.87921315e-01f, 1.34509474e-01f, -1.60570249e-01f, -9.41589195e-03f, -6.29741326e-02f, -6.81495368e-02f, 1.39509020e-02f, 2.62601580e-02f, 6.20797276e-02f, -5.58502302e-02f,
  6.17019832e-03f, 2.92699854e-03f, -9.48552936e-02f, -9.67709795e-02f, -5.68397492e-02f, -8.41953680e-02f, -9.53769218e-03f, -8.35577697e-02f, -7.38321766e-02f, -9.50272754e-02f,
  -3.56606469e-02f, -3.20210084e-02f, 7.92809129e-02f, 5.20263612e-02f, -3.01105119e-02f, -2.71625724e-02f, -5.49582131e-02f, -8.17640498e-02f, 1.77586582e-02f, 2.23357212e-02f,
  -2.64097117e-02f, 2.77750865e-02f, -5.14691472e-02f, 8.80146846e-02f, 5.43989278e-02f, -4.81093302e-02f, -1.39049487e-02f, -1.63038392e-02f, -1.22636585e-02f, 4.43618037e-02f,
  -1.02267161e-01f, -2.43742298e-02f, -9.51761827e-02f, 2.67918035e-02f, -2.67522614e-02f, 7.65684173e-02f, 1.04130529e-01f, -2.46498920e-02f, 6.05516806e-02f, -3.86176519e-02f,
  -2.97047794e-02f, -2.39419639e-02f, -1.43862399e-03f, 6.21179231e-02f, -5.78156160e-03f, -6.24035858e-02f, 5.49559481e-02f, -7.65083581e-02f, 3.69321480e-02f, 1.13936000e-01f,
  -1.00466296e-01f, 6.56880531e-03f, -1.40779272e-01f, -1.19421497e-01f, -9.69197899e-02f, -2.21990049e-02f, -6.66928887e-02f, 2.37621535e-02f, -8.91622677e-02f, -2.14677816e-03f,
  -5.52947447e-02f, -9.39146131e-02f, 1.10600829e-01f, 5.07243089e-02f, -8.87486786e-02f, -6.04711063e-02f, 1.48710683e-01f, 2.96909399e-02f, -1.09160528e-01f, -7.64962584e-02f,
  5.00467755e-02f, 4.85077053e-02f, -9.12048966e-02f, -9.34540555e-02f, -3.36817168e-02f, -1.10353857e-01f, 5.39047271e-02f, 1.88914163e-03f, -7.25258738e-02f, 1.56834885e-01f,
  -5.66621982e-02f, -3.03425342e-02f, -1.23395555e-01f, 2.79701263e-01f, 1.84454873e-01f, 1.94606408e-01f, 1.60176352e-01f, 2.54075944e-01f, 2.78380692e-01f, 1.26469508e-01f,
  2.01221302e-01f, 2.34973505e-01f, 3.20806921e-01f, 2.75443166e-01f, 1.52258158e-01f, 2.33674124e-01f, 2.17025295e-01f, -2.72458028e-02f, 1.26844570e-01f, 7.01101944e-02f,
  2.05133468e-01f, 6.33865520e-02f, -1.54012620e-01f, 1.48118269e-02f, 6.03794493e-02f, 1.36194780e-01f, 5.49885891e-02f, -5.53564653e-02f, -3.71627063e-02f, 1.32920086e-01f,
  -1.75219446e-01f, -2.13367790e-01f, 2.63202917e-02f, 3.67730260e-02f, -1.82124078e-01f, -3.70565914e-02f, -1.40496409e-02f, -9.49023664e-02f, 1.40777035e-02f, -2.84772757e-02f,
  1.08910548e-02f, 3.65488641e-02f, -5.02416342e-02f, 1.89776081e-04f, -1.32055625e-01f, 9.04927310e-03f, 6.48379326e-03f, -1.49682676e-02f, -8.60462897e-03f, 1.78890657e-02f,
  6.65857643e-02f, -1.26124814e-01f, -1.11165844e-01f, -7.39617273e-02f, 7.18207806e-02f, -7.53845135e-03f, -3.60690951e-02f, -8.79441295e-03f, -1.21228456e-01f, -2.42203251e-02f,
  1.09371640e-01f, 2.62109116e-02f, 2.42237616e-02f, 3.00667975e-02f, 5.76748811e-02f, -5.69476075e-02f, 2.29303315e-02f, 1.19583346e-02f, -1.11511219e-02f, -8.73566940e-02f,
  1.00868315e-01f, -4.32285443e-02f, 5.07922694e-02f, -1.53314066e-03f, 4.08590809e-02f, 1.08134709e-02f, 3.88286076e-02f, -1.30138723e-02f, -6.49745539e-02f, 2.11422443e-02f,
  1.02181090e-02f, 9.19568818e-03f, -1.14685602e-01f, 6.97884848e-03f, -4.25250307e-02f, 4.38291654e-02f, -4.90081497e-02f, -9.37364772e-02f, 8.77634808e-03f, 3.84307373e-03f,
  5.62334247e-02f, 3.89944017e-02f, 8.05064663e-02f, 8.16731602e-02f, -1.00867935e-01f, -4.64503728e-02f, 8.28423500e-02f, -1.16749436e-01f, -9.49297473e-02f, -1.24828387e-02f,
  -8.85168165e-02f, -9.09590200e-02f, -4.32382226e-02f, 1.47379683e-02f, -5.46915121e-02f, -7.08628371e-02f, 5.71521111e-02f, 1.19546175e-01f, 1.29817054e-01f, 4.45275120e-02f,
  3.56196030e-03f, 5.50599992e-02f, 8.13236460e-02f, 1.17237896e-01f, 5.29524349e-02f, -3.93188384e-04f, -1.13840327e-01f, 3.30386572e-02f, 6.36392506e-03f, 3.50591615e-02f,
  3.00279465e-02f, -7.63513222e-02f, -1.57438777e-02f, -3.66477147e-02f, 7.84649998e-02f, 1.22918814e-01f, 1.24907218e-01f, -5.22236340e-02f, 2.80322563e-02f, -4.17279527e-02f,
  3.60584147e-02f, 1.64174987e-03f, -6.62422031e-02f, -1.79394439e-01f, -5.73677756e-02f, -2.05236435e-01f, -1.20012008e-01f, -1.81061238e-01f, -7.16501996e-02f, -1.15719669e-01f,
  -1.21676035e-01f, -3.51402499e-02f, -1.26923054e-01f, -7.27263093e-02f, -1.21823803e-01f, -1.79090917e-01f, -1.63586274e-01f, -6.63029104e-02f, -1.01016641e-01f, -1.26076058e-01f,
  8.44469592e-02f, 7.25308806e-02f, 2.41794139e-02f, -8.12322423e-02f, 4.56083603e-02f, -7.16282008e-03f, -2.05796901e-02f, 2.16283295e-02f, 1.20154478e-01f, 1.15065528e-02f,
  4.24724817e-02f, -1.15606086e-02f, 8.47587287e-02f, 5.75329252e-02f, 3.23207267e-02f, -1.25685064e-02f, -3.22395675e-02f, -2.48472504e-02f, -5.46979867e-02f, 4.53654118e-02f,
  -2.77936291e-02f, 7.37799928e-02f, 4.82371002e-02f, 5.18616959e-02f, 3.00394092e-02f, -9.18288529e-02f, 5.29697835e-02f, 1.06151380e-01f, -9.74249393e-02f, -2.42229532e-02f,
  -2.55648699e-02f, 8.30077659e-03f, 1.09201325e-02f, -7.19360039e-02f, 5.78759238e-02f, 5.96874878e-02f, -1.99618898e-02f, -5.23387571e-05f, 5.04999273e-02f, 3.16292271e-02f,
  -3.62506583e-02f, -3.69731657e-04f, 5.50790355e-02f, -1.03444703e-01f, -8.01786780e-03f, -4.12798598e-02f, 2.30092965e-02f, -2.47246139e-02f, 4.11500335e-02f, -3.41452695e-02f,
  4.30445187e-02f, -6.59887493e-02f, 3.06061041e-02f, 3.44935395e-02f, 5.29973619e-02f, -5.82774617e-02f, 4.05246168e-02f, -4.19391394e-02f, 7.86385406e-03f, -6.97611421e-02f,
  -4.83393818e-02f, 5.39296381e-02f, -1.12966642e-01f, -7.97245726e-02f, -7.33574387e-04f, 7.58191198e-02f, -9.66253574e-04f, 5.69823831e-02f, -3.85835581e-02f, 7.42706284e-02f,
  2.43172999e-02f, 8.81027430e-03f, 6.70085028e-02f, 8.28207508e-02f, 9.35317203e-02f, 7.89538100e-02f, 1.65786799e-02f, 4.56469972e-03f, -5.32064587e-02f, 1.01499811e-01f,
  5.61427288e-02f, -6.94543868e-02f, 1.95449442e-02f, -2.80247014e-02f, 1.00797983e-02f, -2.18592938e-02f, -1.27356499e-02f, 4.76963557e-02f, -8.66197608e-03f, -4.88410108e-02f,
  1.78276986e-01f, -6.05553314e-02f, 2.62289047e-01f, -6.33850247e-02f, -2.47210994e-01f, -2.37467572e-01f, -2.04178795e-01f, -1.67915508e-01f, -1.57198384e-01f, -9.32730660e-02f,
  -7.93033764e-02f, -7.88884014e-02f, 7.43618682e-02f, 1.00017689e-01f, 1.81756079e-01f, 4.34981287e-02f, 6.01180196e-02f, 3.18560302e-01f, 1.13176309e-01f, 1.07640713e-01f,
  2.18428317e-02f, 7.75197074e-02f, 8.18972513e-02f, 8.91306549e-02f, -5.84202632e-02f, 7.19063506e-02f, 9.76156592e-02f, -2.74257734e-02f, 5.68623692e-02f, 1.76685870e-01f,
  2.06895515e-01f, 4.61142808e-02f, 6.83380887e-02f, -7.89744481e-02f, -4.14830707e-02f, 6.66833296e-02f, 1.76951848e-02f, 8.55084583e-02f, 1.82979777e-02f, 6.16763122e-02f,
  3.03601902e-02f, -2.70700478e-03f, 4.84310202e-02f, -4.12689149e-02f, 6.43406296e-03f, -3.54924216e-03f, 1.01331189e-01f, 1.04822680e-01f, -3.26972939e-02f, -7.34521728e-03f,
  -1.29739478e-01f, -1.47093222e-01f, -8.39284882e-02f, -1.79855768e-02f, 3.26324850e-02f, -3.86121050e-02f, -2.41203643e-02f, -6.79973587e-02f, 7.49654099e-02f, 2.17191316e-02f,
  1.61349550e-02f, 5.17066056e-03f, -3.82819436e-02f, 1.70976035e-02f, -7.90256113e-02f, -2.32040808e-02f, -5.49463183e-02f, -2.20408919e-03f, -9.40879583e-02f, -2.41756882e-03f,
  -1.00973882e-01f, -1.96438376e-02f, -1.51872998e-02f, -7.67723694e-02f, 4.10865620e-02f, 6.84580505e-02f, -8.66912976e-02f, 3.77757177e-02f, 1.51552213e-02f, 1.42534105e-02f,
  7.50763714e-02f, 9.43415537e-02f, 3.21128070e-02f, 6.82103261e-02f, -5.80088049e-02f, -3.98191586e-02f, -4.41673547e-02f, -1.82215648e-03f, -5.19546680e-02f, -7.67038837e-02f,
  -1.50005102e-01f, 8.63633025e-03f, 2.49158014e-02f, 1.11984238e-01f, -1.11744918e-01f, 9.10762027e-02f, 1.99650992e-02f, -5.95822334e-02f, -3.72281931e-02f, -5.36169019e-03f,
  2.65182294e-02f, -1.34102376e-02f, -3.28304805e-02f, 5.02856262e-02f, -9.54137221e-02f, 5.24322651e-02f, -1.65447816e-02f, 6.84339777e-02f, -6.80747405e-02f, -8.61860141e-02f,
  2.31216531e-02f, 1.90389585e-02f, -1.07879534e-01f, -1.50566800e-02f, 1.24534881e-02f, 5.20351063e-03f, -7.32580125e-02f, 4.58964780e-02f, 2.74577178e-02f, -7.43383914e-02f,
  -6.52137473e-02f, 6.98008239e-02f, -8.46467614e-02f, -1.80612326e-01f, 2.08592275e-03f, 6.70379996e-02f, 1.40379071e-01f, 3.61963212e-02f, -7.61089697e-02f, 9.51872617e-02f,
  9.20590758e-02f, -1.30309477e-01f, -1.54575601e-01f, 1.26052811e-03f, -8.01263005e-02f, -2.19479799e-02f, 4.42105569e-02f, -4.71583866e-02f, -2.85357535e-02f, 4.39452603e-02f,
  -8.77566785e-02f, -1.46708950e-01f, -1.88599885e-01f, -2.29354147e-02f, -7.21106380e-02f, -7.96546810e-04f, -1.32250175e-01f, -1.05624244e-01f, 1.21000506e-01f, 4.86674486e-03f,
  1.70369614e-02f, 1.20031200e-02f, -2.65819561e-02f, 8.69029574e-03f, 6.14134334e-02f, 4.88730147e-02f, 3.95380035e-02f, -1.08544089e-01f, -6.42927736e-02f, -2.69355699e-02f,
  -7.33056143e-02f, -2.18314733e-02f, 2.79463008e-02f, -8.71551782e-02f, -8.04576427e-02f, 5.11389375e-02f, -5.98457158e-02f, -5.86028695e-02f, -6.65486185e-03f, 1.09176993e-01f,
  1.35821387e-01f, -3.20247710e-02f, -5.50772622e-02f, -1.02698214e-01f, -5.74326217e-02f, -5.96814826e-02f, -2.51332130e-02f, -1.12226523e-01f, 4.42665489e-03f, -1.11793071e-01f,
  9.29368511e-02f, -2.20771749e-02f, 7.98802003e-02f, 5.76176234e-02f, -7.51423985e-02f, 2.43459772e-02f, -3.22099589e-02f, 6.89019859e-02f, -7.34223872e-02f, -3.41494009e-02f,
  -3.02651711e-02f, 9.61548761e-02f, -8.80557075e-02f, -2.18497422e-02f, -6.95916414e-02f, 8.35332498e-02f, -4.83122561e-03f, 6.16265163e-02f, -3.07940859e-02f, 6.36743531e-02f,
  -2.37187129e-02f, -5.40832197e-03f, -3.98114808e-02f, 2.48795599e-02f, -6.83306064e-03f, -9.41791385e-02f, -5.50747849e-02f, -2.87818722e-02f, -7.51253664e-02f, -3.10749095e-02f,
  -2.39141673e-01f, 1.37932897e-01f, 1.60769187e-02f, -6.58913329e-02f, -4.16101590e-02f, -5.40431142e-02f, 5.05620018e-02f, -2.97693573e-02f, -1.33003639e-02f, 1.85651556e-02f,
  1.24205425e-01f, -6.76278621e-02f, -9.24269110e-02f, 5.30725047e-02f, -1.21087078e-02f, -5.49433157e-02f, -3.58643103e-03f, -5.48438914e-02f, -3.44773121e-02f, -2.40206104e-02f,
  1.89869516e-02f, -3.46172936e-02f, -5.10020331e-02f, -8.76181293e-03f, 2.36726720e-02f, -5.85857220e-02f, -9.20961574e-02f, -2.01955391e-03f, -4.24329229e-02f, -5.83662465e-02f,
  -7.44252577e-02f, -1.50413767e-01f, 5.30490018e-02f, 5.11650816e-02f, 8.70945305e-02f, -3.35879624e-02f, -1.09089732e-01f, 2.23745685e-03f, 1.27606839e-01f, -1.04238957e-01f,
  4.64556850e-02f, 1.54704794e-01f, 1.51469395e-01f, 7.43153766e-02f, 1.66936055e-01f, 6.14092499e-02f, 6.79122955e-02f, 2.17904016e-01f, 6.01017736e-02f, -2.65839715e-02f,
  1.14007816e-01f, 8.36830363e-02f, 2.12892722e-02f, 2.22765356e-02f, 1.05166614e-01f, 1.67146698e-01f, 2.41896771e-02f, -1.97640546e-02f, -1.03599634e-02f, 7.18376189e-02f,
  -1.79400623e-01f, -1.30635962e-01f, 1.69122487e-01f, 6.49142861e-02f, -1.22674974e-02f, -4.36138250e-02f, -1.01474732e-01f, 3.08279339e-02f, 3.75845022e-02f, 4.17832024e-02f,
  6.09815009e-02f, -7.56007507e-02f, -6.12762384e-02f, -6.73435107e-02f, -7.25977272e-02f, -1.86844785e-02f, -5.22283502e-02f, -4.40727510e-02f, 5.84337972e-02f, -1.75537653e-02f,
  7.63852224e-02f, -1.03073634e-01f, 8.61520879e-03f, -5.71758673e-03f, 3.74800302e-02f, -7.36200809e-03f, 2.42365245e-02f, -9.51471552e-02f, -9.46564376e-02f, -1.16584100e-01f,
  5.51334769e-02f, 3.14998031e-02f, -6.72070635e-03f, 3.73467021e-02f, 5.85268512e-02f, -6.22730926e-02f, 6.88865036e-02f, 6.99785128e-02f, -1.47497961e-02f, -7.77266473e-02f,
  -7.25953802e-02f, 9.65143815e-02f, -4.15126793e-02f, 8.51405337e-02f, 1.25733986e-02f, -3.49609442e-02f, 6.74545616e-02f, 1.89712401e-02f, -6.55058771e-02f, 3.02605219e-02f,
  -7.01568574e-02f, -4.24477272e-02f, -4.20674635e-03f, -3.87711376e-02f, 3.85084487e-02f, -5.01856282e-02f, 1.63483676e-02f, -3.85438725e-02f, 1.10861035e-02f, 4.23804410e-02f,
  -1.23754948e-01f, 3.95510010e-02f, -9.16263182e-03f, -5.82696721e-02f, -2.85163685e-03f, 3.17669846e-02f, -6.48589581e-02f, -8.32490809e-03f, -4.67933565e-02f, 5.03021330e-02f,
  -8.82736519e-02f, -6.48100628e-03f, -3.89608368e-03f, 1.72858369e-02f, 2.30553988e-02f, 1.07714161e-02f, -8.01217854e-02f, -1.13756936e-02f, -1.35911796e-02f, -1.88969951e-02f,
  -7.44449571e-02f, -1.04188509e-01f, 7.52817094e-02f, 6.55977875e-02f, 3.34818661e-02f, 1.14143044e-01f, -4.18543220e-02f, 4.56264615e-02f, -6.52641729e-02f, -1.58528656e-01f,
  -4.61020740e-03f, 1.47532925e-01f, 8.37430060e-02f, -1.05957329e-01f, 9.54507291e-02f, 3.47641669e-02f, 1.56343624e-01f, -4.52936180e-02f, -1.17309108e-01f, -5.10358661e-02f,
  1.01032984e-02f, -6.71234429e-02f, -5.11540733e-02f, 2.11071465e-02f, -2.70093661e-02f, 1.12732753e-01f, -8.06600414e-03f, -7.86443427e-02f, 4.61402684e-02f, 8.20469558e-02f,
  5.34005910e-02f, -1.36045605e-01f, -4.69570123e-02f, -1.71821658e-02f, -1.19566418e-01f, -8.39290395e-02f, 2.03724559e-02f, 5.29911518e-02f, 9.88570303e-02f, -6.29930869e-02f,
  2.66663760e-01f, 1.40605032e-01f, -1.14843793e-01f, -6.65359050e-02f, 5.17965108e-02f, -1.92057155e-03f, 3.27962711e-02f, 2.48811170e-02f, -1.15193211e-01f, -3.66063006e-02f,
  4.32859771e-02f, 8.67479891e-02f, 9.69846323e-02f, -3.41818854e-02f, -2.42306888e-02f, 6.52331635e-02f, 4.10540076e-03f, -8.77149329e-02f, 5.16273566e-02f, 1.06413156e-01f,
  -6.62258789e-02f, 4.56666388e-02f, -1.34753843e-03f, 2.27704849e-02f, -6.79147243e-02f, 3.36648747e-02f, 7.39123672e-02f, 7.17505887e-02f, 3.42666619e-02f, -1.56905949e-02f,
  -3.48675437e-02f, 2.53584720e-02f, 5.63527225e-03f, 6.40790686e-02f, 9.23820734e-02f, -4.41978499e-02f, 6.83505535e-02f, 6.07834682e-02f, 6.22176826e-02f, -4.87424135e-02f,
  -8.05251747e-02f, 9.41526238e-03f, 3.45777012e-02f, -3.20179164e-02f, -1.95498811e-03f, 1.44604556e-02f, 9.98769328e-02f, 7.51703158e-02f, -6.07380196e-02f, -6.38382286e-02f,
  1.42806033e-02f, 3.21628340e-02f, 1.65069439e-02f, -2.93302517e-02f, 8.47585872e-02f, -8.09501037e-02f, 6.07977062e-02f, 6.45910203e-02f, -5.85689768e-02f, -3.23703550e-02f,
  -6.79830387e-02f, 4.22335118e-02f, 3.75487357e-02f, -1.40308112e-01f, -4.61054780e-02f, -6.02033176e-02f, -9.60966945e-02f, -1.45958900e-01f, -8.21733549e-02f, 1.74265355e-02f,
  -4.74040806e-02f, -4.74523641e-02f, 2.05161935e-03f, 5.96662126e-02f, -2.67174654e-03f, -2.85567436e-02f, 6.53025359e-02f, 4.26731929e-02f, 1.90120526e-02f, 9.47360098e-02f,
  -6.76852539e-02f, 5.99150136e-02f, -3.75839844e-02f, -8.63612443e-02f, -2.42297240e-02f, -1.34780686e-02f, -3.95353511e-02f, -1.08641721e-02f, 7.41653889e-02f, 3.93952429e-02f,
  -4.90732819e-01f, -6.86256960e-02f, -1.30598396e-02f, -2.13672981e-01f, 1.14981979e-01f, 1.53012365e-01f, 6.90957084e-02f, -1.50116496e-02f, -1.29110321e-01f, -2.20701173e-02f,
  2.03175191e-03f, -9.81488731e-03f, 4.58331779e-02f, -3.73485796e-02f, 9.89811718e-02f, 1.29870564e-01f, 1.82710454e-01f, -1.25449458e-02f, -6.14058785e-02f, 4.86842133e-02f,
  4.55716737e-02f, -4.85690981e-02f, -2.37154216e-01f, 1.70287152e-03f, -4.24634144e-02f, 1.03675097e-01f, 2.10551769e-02f, 5.86360507e-02f, 5.94469458e-02f, 6.68760538e-02f,
  -1.82741566e-03f, -2.40154505e-01f, 1.50945624e-02f, -4.54313159e-02f, -9.12377983e-02f, 1.92506760e-02f, -1.61220487e-02f, -8.54432136e-02f, -1.04279645e-01f, -8.73300992e-03f,
  6.42234758e-02f, -7.70298690e-02f, -1.19552929e-02f, -1.30727636e-02f, -7.77899548e-02f, -6.46212250e-02f, -5.02250306e-02f, -1.18180543e-01f, 2.37490702e-03f, -1.16851494e-01f,
  -9.30381182e-04f, -1.08254559e-01f, -1.12291276e-01f, -3.28783952e-02f, -9.11715329e-02f, -9.33716744e-02f, -1.05755419e-01f, -8.20492115e-03f, -1.52125821e-01f, -7.19159171e-02f,
  6.98688775e-02f, 2.07945444e-02f, -6.41888157e-02f, -3.43427695e-02f, -2.25711074e-02f, -3.54895182e-02f, 3.76514681e-02f, 1.60069056e-02f, 1.95356086e-02f, 5.31523861e-02f,
  -6.92819506e-02f, 4.45608497e-02f, 4.49760929e-02f, 4.60922383e-02f, -6.78461269e-02f, 5.44982962e-02f, -7.85895512e-02f, 7.61186257e-02f, 2.19416805e-03f, 4.98633310e-02f,
  -2.86404528e-02f, 3.07874642e-02f, -9.62603390e-02f, -1.03702592e-02f, 2.35660169e-02f, 2.99555119e-02f, 5.66323586e-02f, 5.77878207e-02f, 6.98413700e-03f, -1.19797014e-01f,
  -1.80540800e-01f, 7.75496569e-03f, -6.54842705e-02f, 1.24400882e-02f, 3.13147753e-02f, -6.59290031e-02f, 1.93242338e-02f, -8.04528370e-02f, 1.48380231e-02f, -1.36649814e-02f,
  -3.53465639e-02f, 2.12146174e-02f, -5.22155240e-02f, -4.63407971e-02f, -1.23060502e-01f, -1.05738573e-01f, -5.74114406e-03f, 3.29865254e-02f, -2.55848188e-02f, -1.43494368e-01f,
  -5.98771460e-02f, -1.46785378e-01f, -2.10713610e-01f, -1.17099360e-01f, -1.60178348e-01f, -1.94432512e-01f, -5.15334727e-03f, -8.58410746e-02f, -1.49907127e-01f, -1.04141384e-01f,
  2.15696648e-01f, -4.12954777e-01f, -9.45767611e-02f, -5.83429970e-02f, -3.18294376e-01f, -3.67005438e-01f, -5.43459177e-01f, -1.99295625e-01f, -7.19642863e-02f, -3.52501869e-01f,
  -2.86982983e-01f, 4.56994809e-02f, 9.19800922e-02f, 1.62963182e-01f, 1.37720957e-01f, -2.83558935e-01f, -1.98462129e-01f, 2.17941418e-01f, 2.52711028e-01f, 1.30246788e-01f,
  -3.95010337e-02f, 1.29607901e-01f, 3.31676722e-01f, 1.96517408e-01f, -5.66714294e-02f, -5.62373223e-03f, 1.87877435e-02f, 5.31387776e-02f, -1.37084574e-01f, -1.15234092e-01f,
  -2.27081224e-01f, -3.19142528e-02f, 1.10000037e-01f, 6.07085451e-02f, -1.04552414e-02f, 2.28350633e-03f, -9.30121765e-02f, -1.43702244e-02f, -8.29340983e-03f, 9.94385220e-03f,
  -9.73972157e-02f, 3.07241175e-02f, 2.18184926e-02f, 4.60323691e-02f, -3.84380966e-02f, -8.58633667e-02f, 2.38564946e-02f, 2.02776328e-01f, 5.11112735e-02f, -2.01482582e-03f,
  -1.05168052e-01f, -9.26177874e-02f, 4.10314230e-03f, -1.41415656e-01f, 6.38829023e-02f, 4.12350297e-02f, -2.30604410e-02f, -2.01541604e-03f, 5.08245640e-02f, -1.90134421e-01f,
  -9.91989225e-02f, -5.50591089e-02f, 1.23587325e-02f, 2.79680938e-02f, 5.33064641e-02f, -9.20808390e-02f, -4.27404307e-02f, 7.04433816e-03f, 5.70433252e-02f, -4.85293344e-02f,
  9.41318795e-02f, 1.81625821e-02f, 8.58942047e-02f, -1.33458013e-02f, 2.23769043e-02f, 3.92850973e-02f, 4.54557277e-02f, -3.31695229e-02f, 1.95565391e-02f, 6.20634407e-02f,
  -1.18329069e-02f, 6.91327825e-02f, 3.31748836e-02f, 6.99188188e-02f, -4.20660414e-02f, 3.50266397e-02f, 9.75193642e-03f, -1.14548840e-02f, 4.86386269e-02f, -3.73522043e-02f,
  -5.03816940e-02f, 8.73369202e-02f, -1.27004594e-01f, 3.80677544e-02f, -1.87853619e-01f, 7.02983281e-03f, -1.51103526e-01f, 4.41888198e-02f, -6.90385327e-02f, -1.20907664e-01f,
  -1.18964165e-01f, 4.29278500e-02f, -1.73740506e-01f, -1.76042113e-02f, -5.43516763e-02f, -8.73361975e-02f, -1.56219244e-01f, 2.34253723e-02f, -2.01743860e-02f, -1.62209854e-01f,
  -9.01508406e-02f, -1.29968062e-01f, -1.36658490e-01f, -9.71184075e-02f, -2.76103020e-02f, -1.22796688e-02f, -1.91562653e-01f, -1.45293042e-01f, -1.32461280e-01f, -3.07173073e-01f,
  -1.79552048e-01f, -5.33145308e-01f, -2.54326731e-01f, -2.52262682e-01f, 3.04124691e-02f, 9.76487994e-02f, 4.91891727e-02f, 1.12941995e-01f, -7.13353083e-02f, -3.04295868e-01f,
  -1.31823629e-01f, -3.63130830e-02f, -1.76124036e-01f, -8.84637833e-02f, 5.25974892e-02f, -1.91931710e-01f, -1.67057216e-01f, 4.38496359e-02f, 3.18021506e-01f, 2.90939748e-01f,
  9.00449976e-02f, -1.62157312e-01f, 1.54979303e-02f, -2.63135228e-02f, -9.39226821e-02f, -1.19964719e-01f, -2.65958905e-01f, -1.65490434e-01f, -1.30678222e-01f, -2.38754526e-01f,
  -2.13219374e-01f, -3.62604037e-02f, 1.20062545e-01f, -3.08615565e-02f, -8.67019445e-02f, 1.72256287e-02f, 3.83661091e-02f, -2.04964168e-02f, -5.44173867e-02f, -7.62511045e-02f,
  -8.67829248e-02f, -3.35815772e-02f, -5.76713607e-02f, 3.53799015e-02f, 7.26325214e-02f, -3.20992395e-02f, -1.50886612e-04f, -6.95397407e-02f, 8.29525143e-02f, 7.36226812e-02f,
  -1.94495451e-02f, 4.80147712e-02f, -1.34374350e-02f, -4.78869155e-02f, 1.31952260e-02f, 2.60984171e-02f, -9.36860889e-02f, 1.39221281e-01f, 1.05310902e-02f, -1.38700709e-01f,
  1.96065083e-02f, -2.53601689e-02f, 4.50143442e-02f, 4.82775718e-02f, -5.79330660e-02f, -6.35774434e-02f, 1.77165791e-02f, 4.17623520e-02f, 4.67308350e-02f, -5.25162704e-02f,
  6.40732795e-02f, 8.57158564e-03f, -8.37426558e-02f, -5.11361137e-02f, 8.35476536e-03f, 4.40041535e-02f, 1.75172556e-02f, -5.03948294e-02f, -4.62198555e-02f, 1.50444554e-02f,
  -6.31745011e-02f, 3.59069481e-02f, 4.72109579e-02f, -4.86006029e-02f, 3.13541144e-02f, -3.06969024e-02f, -5.69019243e-02f, 2.23427080e-02f, 1.62023883e-02f, 2.56419033e-02f,
  -1.83702514e-01f, 1.42431185e-01f, -7.62709305e-02f, 8.12724605e-02f, -2.90666390e-02f, -5.15779555e-02f, -6.25691190e-02f, -3.10538076e-02f, -4.87151258e-02f, 6.46172017e-02f,
  1.15901411e-01f, -2.01306846e-02f, -6.53627515e-02f, 9.39273909e-02f, 1.42436355e-01f, 1.22303426e-01f, -1.42454684e-01f, 3.19780745e-02f, 5.24526574e-02f, -1.07952625e-01f,
  -3.92862335e-02f, 4.10693279e-03f, -2.06770729e-02f, 5.67012653e-02f, 1.30524546e-01f, 5.48849925e-02f, -1.42795164e-02f, 8.35030712e-03f, 3.36830951e-02f, -2.11811110e-01f,
  -1.63798034e-02f, 2.27843583e-01f, -2.24542003e-02f, 7.07997829e-02f, 4.16473448e-02f, -9.66951698e-02f, -6.20393679e-02f, -7.76996836e-02f, 5.42864576e-02f, 1.06241263e-01f,
  9.25367922e-02f, 1.31778624e-02f, -1.30611593e-02f, -1.74866155e-01f, -7.12925792e-02f, -4.78547178e-02f, -3.53267305e-02f, -1.55559197e-01f, -2.51048267e-01f, -1.73541620e-01f,
  6.68671876e-02f, 1.20836616e-01f, 5.83029203e-02f, 4.52347696e-02f, 2.10573822e-01f, -1.05519965e-02f, 9.00082737e-02f, 7.49430135e-02f, 8.78958404e-02f, 2.50859648e-01f,
  7.04819486e-02f, 5.24244942e-02f, -1.41181692e-01f, 2.62468029e-02f, 1.00127943e-01f, 1.14981672e-02f, -8.63353387e-02f, 2.74951681e-02f, 1.67180207e-02f, -6.47368953e-02f,
  9.72702578e-02f, 1.66848972e-02f, -2.65436471e-02f, -8.51721764e-02f, -9.52950418e-02f, -1.29961237e-01f, -1.04842708e-01f, -1.92412436e-01f, -8.82547572e-02f, -1.92778967e-02f,
  6.35404736e-02f, 3.45500931e-02f, -1.28347605e-01f, -5.24720550e-02f, -1.57405123e-01f, -1.07851233e-02f, -3.19272354e-02f, 1.45869115e-02f, -2.16168519e-02f, -4.47219200e-02f,
  -1.54142538e-02f, 4.29432169e-02f, -1.31180119e-02f, 3.17593813e-02f, 2.16390081e-02f, 3.05773448e-02f, 7.08914176e-02f, -5.67802088e-03f, -4.70342711e-02f, 9.03452039e-02f,
  4.04491350e-02f, 4.04145196e-02f, 4.50682342e-02f, 6.65278509e-02f, -7.74535239e-02f, 1.03099473e-01f, 3.09918020e-02f, 3.81968133e-02f, -7.88722336e-02f, -8.31167325e-02f,
  -5.82265966e-02f, -6.54752031e-02f, 1.53894564e-02f, 4.14704755e-02f, 5.73107228e-02f, -8.86202976e-02f, -9.28393453e-02f, -3.50789987e-02f, 2.62892488e-02f, 5.82667664e-02f,
  8.94463155e-03f, -1.39702827e-01f, 2.89161336e-02f, -4.26354967e-02f, 6.45482838e-02f, -6.24213889e-02f, 8.44708383e-02f, 3.18289250e-02f, 2.83538383e-02f, -9.29966271e-02f,
  -2.30257940e-02f, -1.49309441e-01f, 7.84011744e-03f, -7.40685090e-02f, -4.92530987e-02f, -1.11595549e-01f, 1.01059318e-01f, -1.92669798e-02f, -1.53478339e-01f, -6.58606142e-02f,
  4.82309461e-02f, -2.03280542e-02f, -1.43753305e-01f, -1.32537454e-01f, -1.25419945e-01f, -1.02447763e-01f, -1.27808489e-02f, -1.40913367e-01f, -2.20920697e-01f, -9.91157889e-02f,
  -1.18466534e-01f, -7.88009018e-02f, -5.54443933e-02f, 2.48361066e-01f, 2.65103757e-01f, 3.31083648e-02f, -6.53419942e-02f, 4.22697701e-02f, 5.43813109e-02f, 1.52176488e-02f,
  3.17511670e-02f, 1.98255092e-01f, 1.02721214e-01f, 1.44073457e-01f, -1.04472883e-01f, 1.14105381e-01f, 2.34710380e-01f, 1.71779767e-01f, 3.94663550e-02f, 1.49486020e-01f,
  1.17199890e-01f, 1.81579769e-01f, 9.71739814e-02f, 2.35650651e-02f, 2.25374788e-01f, 1.42709106e-01f, 8.07959139e-02f, 1.26948237e-01f, 9.94375721e-02f, 2.77187765e-01f,
  1.16153277e-01f, -2.77856767e-01f, 9.78366584e-02f, 2.27641668e-02f, -3.37304845e-02f, -4.47323639e-03f, 5.63466661e-02f, -5.86133152e-02f, -1.62636936e-02f, -2.24731881e-02f,
  -5.43260276e-02f, -6.46973327e-02f, 1.58831589e-02f, -7.42937773e-02f, 2.31332667e-02f, -4.77132685e-02f, -1.20400704e-01f, -1.78858995e-01f, -5.31570241e-02f, -9.37243253e-02f,
  1.30625263e-01f, -3.82673852e-02f, -1.10967271e-01f, -1.44193947e-01f, -9.17868912e-02f, 1.53043680e-02f, -1.43820435e-01f, -1.31807365e-02f, -1.77615523e-01f, 7.03338860e-03f,
  8.83753896e-02f, -5.17354645e-02f, 1.28793763e-02f, -3.71010192e-02f, -4.59842160e-02f, 1.07920356e-01f, -6.66482747e-03f, 4.87156771e-02f, -2.15921365e-02f, -4.94260825e-02f,
  -2.69111851e-03f, 7.31327608e-02f, 7.43319616e-02f, -1.03617907e-02f, 6.51024953e-02f, 6.31045699e-02f, -2.09905356e-02f, -7.98260048e-02f, 4.41125222e-02f, -1.64030753e-02f,
  -3.82544547e-02f, 7.61075541e-02f, -4.50203335e-03f, -3.73545028e-02f, -4.64780815e-02f, 5.82697392e-02f, 2.31746323e-02f, 4.61209379e-02f, 4.58683409e-02f, 9.64727066e-03f,
  -5.37538715e-02f, -1.81161523e-01f, 1.29476145e-01f, -7.18909055e-02f, -1.76273733e-02f, -1.18530229e-01f, 2.71073380e-03f, -6.75177723e-02f, 1.06774736e-02f, -6.87435716e-02f,
  -1.13222830e-01f, -2.17394847e-02f, 5.27213374e-03f, -4.84433658e-02f, -3.04126926e-02f, 6.69558942e-02f, -3.74129252e-03f, 7.37987608e-02f, -1.68248825e-02f, 7.75590306e-04f,
  -6.05474114e-02f, -1.55847818e-02f, 3.77166234e-02f, 3.63542093e-03f, 2.52417009e-02f, 1.90988984e-02f, -3.19348089e-03f, 7.09555531e-03f, -3.08274291e-02f, -5.15840575e-02f,
  4.18008208e-01f, 2.50275463e-01f, 1.28562152e-01f, 8.55604038e-02f, 1.60815150e-01f, 2.23989904e-01f, 2.95557261e-01f, 1.74869597e-01f, 8.15490186e-02f, 1.13373488e-01f,
  2.05685318e-01f, -1.23858057e-01f, 2.77469531e-02f, -5.46797849e-02f, 5.66653796e-02f, 3.41167264e-02f, -1.66180506e-01f, -2.39443835e-02f, 5.55613898e-02f, 5.79111697e-03f,
  -9.53645632e-03f, -7.31940120e-02f, 1.07324325e-01f, -8.85079354e-02f, -1.18529588e-01f, -1.95475519e-01f, 5.99922054e-02f, -3.54712037e-03f, 7.53864273e-02f, -2.24823415e-01f,
  -6.07679076e-02f, 3.50491047e-01f, -1.96493119e-01f, -9.62919444e-02f, 3.30905281e-02f, -3.77455577e-02f, 5.04952706e-02f, -5.22873290e-02f, 7.06948340e-02f, -1.66565906e-02f,
  -3.15200351e-02f, -7.22837355e-03f, -6.11929931e-02f, -6.68591261e-02f, 2.29440257e-02f, -3.65388696e-03f, -2.07362156e-02f, -6.65972531e-02f, -9.86126810e-02f, 4.84109521e-02f,
  2.02314686e-02f, 1.64199322e-01f, 2.18083724e-01f, -4.33031283e-02f, -2.04787925e-02f, -8.00292566e-02f, 1.24128632e-01f, -3.83205414e-02f, 1.23196498e-01f, -5.40532470e-02f,
  -9.42257494e-02f, 1.74030513e-02f, -4.36478592e-02f, 1.28918374e-02f, -1.63427703e-02f, -9.93299186e-02f, -1.77797128e-03f, -8.38066265e-02f, -7.09441453e-02f, -8.16370919e-03f,
  -1.14733959e-03f, 6.33563995e-02f, 7.10145608e-02f, -1.66909080e-02f, -1.26104370e-01f, -3.90627049e-02f, 3.96897696e-04f, -1.33917723e-02f, 5.16506992e-02f, 1.65073816e-02f,
  -6.81778863e-02f, -5.75135201e-02f, 5.54830255e-03f, 3.20999101e-02f, -4.14517000e-02f, 4.19374146e-02f, -2.12271921e-02f, 3.16397771e-02f, -2.13764980e-02f, -8.27842429e-02f,
  -2.19216391e-01f, 1.33356765e-01f, -1.16137922e-01f, -1.07211292e-01f, 5.54317683e-02f, -3.46222743e-02f, 3.52583565e-02f, -2.72603855e-02f, -6.16950467e-02f, 4.58673239e-02f,
  -1.49908168e-02f, -1.85439568e-02f, -1.97892375e-02f, 2.15870924e-02f, -7.01371953e-02f, -8.16995054e-02f, -4.66817170e-02f, 2.71902722e-03f, -1.60886478e-02f, 5.80446422e-02f,
  -5.68035766e-02f, -7.80129284e-02f, 2.74706353e-02f, -7.29423314e-02f, 4.34707180e-02f, -2.08352655e-02f, -1.05201341e-01f, -3.09784841e-02f, 2.47638989e-02f, -7.24887252e-02f,
  -9.91497189e-02f, 7.16399029e-02f, 4.34140526e-02f, 1.97176803e-02f, -5.04256077e-02f, -5.42970486e-02f, 9.99345034e-02f, 1.11324228e-01f, -2.36494578e-02f, -1.58413891e-02f,
  -7.32882554e-03f, -1.20533332e-02f, 1.78059321e-02f, -5.32393306e-02f, 9.18367412e-03f, 7.02452436e-02f, 6.21457435e-02f, 2.36212765e-03f, -7.20822737e-02f, -6.13655057e-03f,
  -4.63648513e-02f, 5.40520400e-02f, 3.58340442e-02f, -6.69347197e-02f, 2.74813380e-02f, -6.12983070e-02f, 5.24515137e-02f, -1.61430184e-02f, 6.06151558e-02f, -8.69640112e-02f,
  -1.06684029e-01f, 4.26972546e-02f, -6.95647076e-02f, 7.83213824e-02f, 8.47122371e-02f, 6.51860982e-02f, -3.07894796e-02f, 2.57724319e-02f, 1.12562021e-02f, 7.55691752e-02f,
  1.14810660e-01f, 3.53397854e-06f, 6.16759509e-02f, 1.14371240e-01f, 1.28119767e-01f, 1.18416384e-01f, 1.27265438e-01f, 1.93058997e-02f, -5.29142469e-02f, 2.17590723e-02f,
  2.13918760e-02f, 3.79765569e-03f, 2.73988601e-02f, 9.43098441e-02f, 5.53196371e-02f, -1.09225936e-01f, -4.17427830e-02f, -7.49249831e-02f, 4.65656146e-02f, 1.08887136e-01f,
  -2.58014612e-02f, 3.91058587e-02f, -4.21996936e-02f, -1.00954007e-02f, -7.39443228e-02f, -5.96558899e-02f, 2.00580303e-02f, 1.10159643e-01f, 3.12069692e-02f, 1.03448920e-01f,
  9.16739255e-02f, -4.98943962e-02f, 8.48468989e-02f, 8.21176842e-02f, -4.87622358e-02f, -6.02602065e-02f, -9.87510663e-03f, -1.07316719e-02f, -3.25122960e-02f, 1.12190925e-01f,
  -1.69641171e-02f, 5.51709570e-02f, 8.40938538e-02f, 1.03009967e-02f, -7.78362527e-02f, 4.62996028e-02f, 9.18613095e-03f, -6.70318604e-02f, 8.52178782e-02f, -5.65468930e-02f,
  1.99299306e-01f, 5.41987419e-02f, -1.15794629e-01f, -6.93414807e-02f, -5.12000285e-02f, -6.52983636e-02f, 5.17807959e-04f, 7.44854733e-02f, 6.36219904e-02f, -4.28925343e-02f,
  1.02544576e-01f, 5.44157531e-03f, 1.05216391e-01f, 4.80699055e-02f, -4.20713872e-02f, -3.41118462e-02f, 1.15674518e-01f, -2.54810676e-02f, -3.19371447e-02f, 1.15998998e-01f,
  5.30869886e-02f, -1.04033247e-01f, 1.19742202e-02f, -2.53618229e-02f, 7.42499065e-03f, -2.49069259e-02f, 5.34146838e-02f, -8.22633356e-02f, 7.98529293e-03f, 1.41429931e-01f,
  4.87825811e-01f, -2.61413395e-01f, -3.78013961e-02f, 3.63737531e-02f, -1.03695564e-01f, -1.11336514e-01f, -1.59613267e-01f, -1.30958244e-01f, 5.09953722e-02f, 4.85490588e-03f,
  6.48338348e-02f, 2.55797505e-01f, 2.45995820e-01f, 2.85135716e-01f, 1.98982984e-01f, -1.54794306e-02f, -1.54136673e-01f, 2.02773154e-01f, 2.40413457e-01f, -1.96264386e-02f,
  -7.71425664e-02f, -1.15488715e-01f, 1.31117806e-01f, -1.17904358e-01f, -2.63110578e-01f, -6.74933253e-04f, -1.20576799e-01f, -5.95682189e-02f, -1.73309326e-01f, -2.60152102e-01f,
  -2.18165472e-01f, -3.61582674e-02f, 1.67013153e-01f, 1.64239570e-01f, -1.20685190e-01f, 4.54684794e-02f, 1.22877071e-02f, 2.49420796e-02f, -1.97492093e-02f, -8.33066404e-02f,
  3.86541225e-02f, -5.66957667e-02f, 7.05737844e-02f, -1.00564972e-01f, -6.25842363e-02f, 2.58340947e-02f, 5.30184023e-02f, 3.52948941e-02f, 3.32436599e-02f, -6.26516640e-02f,
  -8.32662731e-02f, -1.23010222e-02f, -9.85954236e-03f, 3.87576483e-02f, 9.15643722e-02f, 1.58002779e-01f, -4.06489894e-02f, 4.62890277e-03f, 1.35176584e-01f, -1.32580265e-01f,
  -2.62398347e-02f, 1.05807655e-01f, 2.68482435e-02f, -4.20726500e-02f, 5.00859367e-03f, 9.05944481e-02f, -9.40091014e-02f, -3.50646451e-02f, 1.18018232e-01f, 2.63822656e-02f,
  -5.73748834e-02f, 8.87838081e-02f, 4.23171371e-02f, 3.66393402e-02f, -2.25478485e-02f, -1.55398063e-02f, -4.21544611e-02f, 4.63781133e-02f, 3.36419865e-02f, -3.63702923e-02f,
  8.21420699e-02f, -6.42356426e-02f, -4.84908335e-02f, -6.38017654e-02f, 4.56757732e-02f, 4.04040515e-02f, 3.82057391e-02f, 6.35378212e-02f, -2.29102392e-02f, -1.08780526e-01f,
  -1.82766914e-01f, 4.30538774e-01f, -2.63625793e-02f, 4.44489643e-02f, -4.15370017e-02f, -1.05670309e-02f, 6.04591928e-02f, -1.08197480e-01f, -3.38319875e-02f, -8.35723877e-02f,
  -3.90118174e-02f, 5.97789809e-02f, -4.64338660e-02f, -9.35888886e-02f, 8.00992548e-03f, -5.01955450e-02f, -8.93843621e-02f, 9.25393403e-02f, -1.22710345e-02f, -1.52469561e-01f,
  -4.75845560e-02f, 3.40469666e-02f, 2.01606676e-01f, 1.19568750e-01f, 4.51981276e-02f, 2.24048391e-01f, 2.22348534e-02f, -6.29406944e-02f, 1.96030647e-01f, -8.11455864e-03f,
  6.56301230e-02f, 1.18194431e-01f, -8.34577978e-02f, -6.58506602e-02f, -2.30909109e-01f, -1.93834022e-01f, -1.81487203e-02f, -8.23569447e-02f, 7.77802020e-02f, -8.68103728e-02f,
  -8.38612691e-02f, -3.44137810e-02f, -3.62527254e-03f, -4.86011850e-03f, 1.55045077e-01f, 2.13920921e-02f, 4.49159332e-02f, 9.28904414e-02f, 8.21520090e-02f, 8.91764536e-02f,
  1.46251693e-01f, 1.81739420e-01f, 1.69941366e-01f, 1.61020935e-01f, -2.99871396e-02f, 4.75060381e-02f, 1.31537132e-02f, 8.26774612e-02f, -7.21606314e-02f, 1.07452817e-01f,
  3.21528427e-02f, -2.13644043e-01f, 2.14151833e-02f, 1.80597659e-02f, -3.24347392e-02f, -6.12752773e-02f, -6.63928390e-02f, 4.80957478e-02f, 5.56284189e-02f, -3.32278796e-02f,
  -9.57570970e-02f, -7.33621567e-02f, -1.04096465e-01f, 1.83082875e-02f, 9.10299420e-02f, -6.06279001e-02f, 4.01642025e-02f, 1.24943219e-02f, 2.24621929e-02f, -7.96912089e-02f,
  7.48344185e-03f, -1.25794083e-01f, -1.16927430e-01f, -7.00519308e-02f, 1.14897611e-02f, -1.16708234e-01f, -8.98248330e-02f, -1.12767234e-01f, 4.67913896e-02f, 4.29034866e-02f,
  8.67531002e-02f, 2.66641355e-03f, -8.62698779e-02f, 5.01159765e-03f, 7.05893636e-02f, -1.31424721e-02f, 1.95360370e-02f, 1.22843962e-02f, 1.23023495e-01f, 6.48824945e-02f,
  -5.47250137e-02f, 2.86267810e-02f, -4.98477668e-02f, 2.56407037e-02f, -3.28828096e-02f, 4.89575602e-03f, 6.99811056e-02f, 1.29896387e-01f, -4.88185175e-02f, -9.34507698e-02f,
  -4.74112220e-02f, -1.15163207e-01f, -3.52712721e-02f, -4.51488141e-03f, -5.03191575e-02f, -3.99450436e-02f, 5.02248779e-02f, -7.09271356e-02f, -4.51107882e-02f, 3.19000743e-02f,
  2.30158895e-01f, -5.96714914e-02f, 1.17874332e-02f, 1.15966655e-01f, -1.16025694e-02f, 2.40999591e-02f, 5.48271015e-02f, -1.97405219e-02f, 4.45618556e-04f, 7.06792846e-02f,
  -6.54617772e-02f, 6.35125563e-02f, 6.43727556e-02f, -5.86403273e-02f, -7.40400180e-02f, -8.76082201e-03f, 9.40144584e-02f, -2.64724940e-02f, 1.10782802e-01f, 1.36243049e-02f,
  1.12662494e-01f, -2.15855911e-02f, 9.15197283e-02f, 3.25762033e-02f, -9.26818997e-02f, 2.65416056e-02f, -2.93453336e-02f, 8.77277777e-02f, -5.67499734e-02f, 1.79269329e-01f,
  7.24145249e-02f, 3.49762589e-02f, 3.98820033e-03f, 1.47720218e-01f, 2.20662798e-03f, -2.09410280e-01f, -2.33805075e-01f, -1.17061980e-01f, -6.24439828e-02f, 2.28905044e-02f,
  1.28001809e-01f, 1.01810239e-01f, 6.16012625e-02f, 6.80628791e-02f, -5.98745272e-02f, -1.97093673e-02f, -2.73497794e-02f, 1.69881992e-02f, 2.00196798e-03f, -7.65556544e-02f,
  -6.03842996e-02f, 2.80176345e-02f, 4.29311469e-02f, 1.01726100e-01f, 7.99433514e-02f, 1.58130214e-01f, 1.38084844e-01f, -5.75526245e-03f, 1.36421563e-03f, -7.71747017e-03f,
  -7.86123499e-02f, 5.52520677e-02f, 2.10973304e-02f, 1.33054376e-01f, 9.68249664e-02f, 6.59367740e-02f, -4.59712464e-03f, 1.13816909e-01f, 1.19387098e-01f, 6.01004362e-02f,
  3.95302847e-02f, 1.14991657e-01f, -1.34041039e-02f, 8.22587982e-02f, -2.86596492e-02f, -3.24780196e-02f, -2.04120260e-02f, -8.38712901e-02f, -3.37913744e-02f, -5.81044005e-04f,
  1.22607939e-01f, 4.95281406e-02f, -1.13749124e-01f, -9.85015854e-02f, 5.19279651e-02f, 2.93876305e-02f, -9.17202886e-03f, 2.76914500e-02f, 5.57539351e-02f, 2.27736998e-02f,
  2.53391247e-02f, -5.99260032e-02f, -2.80621070e-02f, -2.89121866e-02f, -5.22472635e-02f, -6.05261214e-02f, -9.43528637e-02f, -7.14530349e-02f, -6.12175837e-02f, -8.58621672e-02f,
  2.72546448e-02f, -6.60481378e-02f, -5.35209179e-02f, -3.51138003e-02f, -5.15376925e-02f, -5.77008426e-02f, -1.05798692e-02f, -9.76667330e-02f, -7.93359503e-02f, -4.96880822e-02f,
  2.84387879e-02f, -6.82415888e-02f, 8.22048336e-02f, -8.05407017e-03f, 1.99468322e-02f, 2.84761097e-02f, -5.07013611e-02f, -4.99831550e-02f, 4.75987978e-02f, 8.28557089e-03f,
  7.34072505e-03f, -1.69692859e-02f, -3.39641166e-03f, -4.63055670e-02f, 1.30057991e-01f, 5.74554950e-02f, 8.39875787e-02f, 4.96889390e-02f, 1.23801768e-01f, -2.14860160e-02f,
  6.93628192e-02f, 7.85459355e-02f, 8.35762173e-02f, -1.32991560e-02f, -3.24853994e-02f, -3.91311347e-02f, 5.22709526e-02f, 4.84732762e-02f, -1.57872606e-02f, 1.87200017e-03f,
  6.52236715e-02f, -5.83456792e-02f, 2.90623903e-02f, -4.57013138e-02f, -4.08121310e-02f, -5.85449953e-03f, -1.04970299e-01f, 4.63394001e-02f, -9.41085815e-02f, 1.00070154e-02f,
  -2.75620997e-01f, 1.74206123e-01f, -1.56787440e-01f, 1.72668263e-01f, 6.24871887e-02f, -3.81761268e-02f, 4.68164273e-02f, 2.04366427e-02f, 5.04715741e-02f, 1.52211562e-01f,
  1.54581934e-01f, 2.26249006e-02f, 9.72410366e-02f, -9.91724432e-02f, -6.57209530e-02f, 5.15627377e-02f, 6.94315359e-02f, -1.27202183e-01f, -2.27113202e-01f, -1.92036763e-01f,
  9.25137624e-02f, 3.55751137e-03f, -1.82859764e-01f, -5.11019006e-02f, 1.61710218e-01f, 2.05502272e-01f, 5.39288931e-02f, 2.97068618e-02f, -3.69653404e-02f, 2.15753898e-01f,
  -1.40426755e-01f, -2.25564480e-01f, -1.45586863e-01f, 9.26778018e-02f, 5.98651730e-02f, -2.00040545e-02f, -1.15449585e-01f, -1.15769699e-01f, 4.20796722e-02f, 6.49606064e-03f,
  1.03706121e-02f, -1.21078156e-01f, 4.76440638e-02f, -3.85377519e-02f, -1.01642482e-01f, -4.29185182e-02f, -1.52348250e-01f, -1.86764717e-01f, -7.95084015e-02f, -1.55902088e-01f,
  2.34401878e-02f, -1.34627493e-02f, -9.42910016e-02f, -9.07538608e-02f, -1.58317864e-01f, -1.28206685e-01f, -9.86193419e-02f, -3.47724669e-02f, -9.94157270e-02f, -4.61837575e-02f,
  -7.79139027e-02f, -3.06080598e-02f, 5.29316347e-03f, 6.55768514e-02f, 1.32965418e-02f, 5.82029857e-02f, -3.69802443e-03f, 7.52092525e-02f, -8.13128054e-02f, 5.93191981e-02f,
  -8.41628760e-03f, -9.80163664e-02f, -7.34543502e-02f, -9.05981734e-02f, -2.96298647e-03f, -5.49346954e-03f, 2.24972470e-03f, -2.06043012e-02f, -2.62167584e-03f, 3.03151049e-02f,
  -5.98957241e-02f, -8.78431201e-02f, 3.24176550e-02f, 7.22204298e-02f, 2.52688713e-02f, -6.15019836e-02f, 5.94644109e-03f, -9.47717279e-02f, 3.69910598e-02f, -7.90604204e-02f,
  1.60493955e-01f, -1.80554196e-01f, 2.70456299e-02f, -3.99274118e-02f, -3.45670804e-02f, -6.02944344e-02f, -1.04281679e-02f, 3.06447092e-02f, 6.86286204e-03f, -4.61146683e-02f,
  -7.26541951e-02f, 5.41969808e-03f, 5.32668922e-03f, 4.52154875e-02f, -1.57342106e-02f, -9.68910828e-02f, 8.53930786e-02f, -6.48206621e-02f, -2.48843431e-03f, -4.70210873e-02f,
  1.23204909e-01f, -1.15390942e-01f, -2.02089071e-01f, -8.78673568e-02f, 1.40322959e-02f, 1.22029625e-03f, -2.30380837e-02f, -1.51716754e-01f, -1.98614836e-01f, -1.22026801e-01f,
  -2.58847952e-01f, 1.08489357e-01f, -7.54868835e-02f, 6.39867187e-02f, 1.53265744e-01f, 1.61053866e-01f, 2.90226012e-01f, 2.06943765e-01f, 1.45030782e-01f, -2.36313418e-02f,
  -5.01440130e-02f, -1.17307141e-01f, -7.22507238e-02f, -4.54300195e-02f, -2.00510062e-02f, 8.25809836e-02f, 1.65006742e-01f, -5.24011478e-02f, 1.74763706e-02f, 2.63510849e-02f,
  1.61491007e-01f, 3.78336571e-02f, -4.65001771e-03f, -4.87706102e-02f, 4.55695130e-02f, -2.46883929e-02f, -2.68800855e-02f, 4.77582440e-02f, -4.11673523e-02f, 2.04504724e-03f,
  -2.44456708e-01f, 1.07978359e-02f, 1.02908775e-01f, -1.23880254e-02f, 1.92667041e-02f, -7.67449439e-02f, 6.35597669e-03f, -1.05326712e-01f, 2.33825035e-02f, 3.08477357e-02f,
  3.74102071e-02f, -5.86870164e-02f, 2.70875022e-02f, -3.08123920e-02f, 4.06155474e-02f, 6.71048984e-02f, 5.68147562e-02f, 1.08037647e-02f, 1.48311639e-02f, 5.26451245e-02f,
  -4.69518490e-02f, -7.42511228e-02f, 7.52224820e-03f, 9.55512300e-02f, 8.16074759e-02f, -1.47633888e-02f, -3.15152556e-02f, -3.92691605e-03f, 4.49548550e-02f, -8.44963342e-02f,
  2.10071635e-02f, 4.22510691e-02f, -6.91679446e-03f, 9.30101871e-02f, -4.46776636e-02f, 8.22393596e-02f, 1.03220627e-01f, 1.35244569e-02f, 7.77128488e-02f, -1.79897435e-02f,
  -6.88353404e-02f, -3.79708745e-02f, -4.10736687e-02f, -1.11901462e-01f, -1.27649447e-02f, -1.33846980e-02f, -5.26898429e-02f, 2.70049646e-02f, -5.99226356e-02f, -2.26530209e-02f,
  5.50729334e-02f, 4.82818559e-02f, 8.32487922e-03f, -3.51039693e-02f, -3.48454900e-02f, 7.49940872e-02f, -4.96447384e-02f, 1.35687515e-02f, -4.58663590e-02f, -6.66882321e-02f,
  -1.94331035e-02f, 1.21345818e-01f, 5.08526564e-02f, 4.53120321e-02f, -8.98968242e-03f, -1.31854676e-02f, -8.45870376e-02f, -6.42140862e-03f, 1.15795687e-01f, -2.10056305e-02f,
  9.54652056e-02f, 2.43502744e-02f, 8.36376548e-02f, -5.37436863e-05f, -2.31549460e-02f, -7.85610974e-02f, 7.63399573e-03f, 1.13286963e-02f, 6.06485456e-02f, 8.74393806e-02f,
  8.09530392e-02f, -4.95375954e-02f, -1.97402500e-02f, -4.38128449e-02f, -5.23804016e-02f, -4.98454906e-02f, 2.13345326e-02f, 1.95163731e-02f, -8.80640820e-02f, -3.87938172e-02f,
  -6.65887073e-02f, 2.12689396e-02f, -1.01107396e-01f, -4.35005240e-02f, -2.65078023e-02f, 6.52377084e-02f, 8.09015334e-02f, -2.35290900e-02f, 4.70960625e-02f, 8.30046553e-03f,
  3.41988616e-02f, -7.55050406e-03f, 2.83006486e-02f, -4.31249291e-02f, 1.38503965e-02f, -1.57124940e-02f, -6.96536503e-04f, 5.49268946e-02f, -7.35347420e-02f, 1.16037078e-01f,
  1.22906499e-01f, -3.43840476e-03f, 1.43064605e-02f, -2.44051740e-02f, 1.60613693e-02f, -9.29803699e-02f, -9.84048024e-02f, -6.48795860e-04f, 3.77835669e-02f, -1.37065053e-01f,
  1.04725681e-01f, -1.35575682e-01f, 6.52771518e-02f, 1.54581815e-02f, 3.01491693e-02f, -6.82655945e-02f, 2.53740102e-02f, 2.82004476e-02f, 1.20074023e-03f, -5.55255897e-02f,
  -1.21724956e-01f, -9.13359448e-02f, -3.85040753e-02f, 6.17747940e-02f, 2.39270665e-02f, 2.20970269e-02f, 3.79462205e-02f, -9.39553529e-02f, -3.88564095e-02f, -4.57453243e-02f,
  4.07545082e-02f, -2.40821075e-02f, -4.78987359e-02f, 8.11249539e-02f, -9.79939476e-02f, -7.30774254e-02f, 8.23656619e-02f, -9.57701802e-02f, 4.03395714e-03f, 7.65824616e-02f,
  4.58419807e-02f, -3.15552130e-02f, -2.00289693e-02f, 2.34701708e-02f, 2.84719653e-03f, -2.41381377e-02f, 9.25110355e-02f, -2.63520479e-02f, -5.40654659e-02f, 5.96650206e-02f,
  4.39879075e-02f, -6.16156384e-02f, 8.11719820e-02f, -4.51167077e-02f, 4.70970757e-02f, -6.61997125e-02f, -8.17839056e-02f, -5.75095750e-02f, -8.27104673e-02f, -6.85764924e-02f,
  -1.44117940e-02f, -2.68398598e-02f, -4.79834117e-02f, 5.59056923e-03f, -7.81798735e-02f, -5.15447445e-02f, -7.06358477e-02f, 7.85045698e-02f, -4.19304818e-02f, -9.09953639e-02f,
  1.38673186e-01f, -6.33257478e-02f, -2.86203418e-02f, -4.52024937e-02f, -1.15795746e-01f, 1.15619013e-02f, 1.66893806e-02f, 3.89851332e-02f, -9.91505105e-04f, 1.18398285e-02f,
  -1.12071648e-01f, -5.60177043e-02f, 5.48506379e-02f, 7.17851392e-04f, 1.19916551e-01f, 4.21543326e-03f, -3.07861455e-02f, 6.99312286e-03f, -5.90735935e-02f, -5.92233129e-02f,
  6.21713661e-02f, 9.53598693e-02f, 1.14737647e-02f, -3.91905792e-02f, 1.62499566e-02f, 1.15773864e-01f, 1.37072671e-02f, 7.95946736e-03f, 7.64284506e-02f, 2.22300485e-01f,
  7.92332292e-02f, -3.09880376e-01f, 1.03386790e-01f, 4.34977300e-02f, 2.00554952e-01f, 2.20077902e-01f, 8.09886679e-02f, 7.38222897e-02f, 5.80937415e-02f, -6.74413741e-02f,
  -1.49169207e-01f, -1.81871563e-01f, -1.00928701e-01f, -3.29011418e-02f, -4.67357077e-02f, 1.47827938e-01f, 1.90961763e-01f, 1.82830289e-01f, 8.76622424e-02f, -1.12778945e-02f,
  -4.12620790e-02f, -1.18974663e-01f, -3.11831217e-02f, -2.97535565e-02f, -1.94394484e-01f, -5.19803427e-02f, -1.29373476e-01f, -1.19798154e-01f, -4.56776237e-03f, -1.33303121e-01f,
  -6.42141327e-02f, -1.03617564e-01f, 9.17338803e-02f, -1.50983974e-01f, -7.97445923e-02f, 4.49201241e-02f, 4.66203839e-02f, -4.87129800e-02f, -4.14487906e-02f, -4.55899872e-02f,
  -9.45868790e-02f, -9.82408226e-02f, -1.33042485e-01f, -1.05454020e-01f, -5.11347242e-02f, -3.99079584e-02f, -5.26941270e-02f, 1.37651749e-02f, -1.06832255e-02f, -1.25911981e-01f,
  -1.06976792e-01f, -6.39973655e-02f, 1.22101001e-01f, -5.19050099e-02f, 1.28634647e-02f, 6.66159689e-02f, 1.49028432e-02f, -6.38574585e-02f, 6.49270415e-02f, 1.50855095e-03f,
  7.45098293e-02f, 6.02013990e-02f, -9.82379820e-03f, 5.08380122e-02f, -3.10744494e-02f, 7.01548457e-02f, 7.63304830e-02f, 9.15296562e-03f, 2.06686649e-02f, -1.06133483e-01f,
  -7.94372782e-02f, 4.01033312e-02f, 4.40517589e-02f, -7.25934580e-02f, -9.04541910e-02f, -6.70274645e-02f, -2.24284511e-02f, -6.36885464e-02f, -4.32577394e-02f, 1.79618392e-02f,
  -1.19698793e-01f, 2.55605206e-02f, -6.56825826e-02f, -2.96497717e-02f, 4.78530563e-02f, -4.39413115e-02f, 2.22854316e-02f, -8.36518183e-02f, -1.14985043e-02f, 5.84629029e-02f,
  -4.96707447e-02f, 1.77543297e-01f, 4.79555503e-03f, -1.01608500e-01f, 3.77212018e-02f, -7.94676617e-02f, -4.11844552e-02f, -3.93322781e-02f, 1.64103566e-03f, -9.69274864e-02f,
  -9.81010050e-02f, -9.90494713e-02f, -1.07959561e-01f, -6.54178113e-02f, 1.43409491e-01f, 1.01821467e-01f, 6.59497979e-04f, 7.66431738e-04f, 3.97410467e-02f, 3.03307846e-02f,
  5.48292845e-02f, 2.20255286e-01f, 1.25515670e-01f, 1.69604406e-01f, 3.37230647e-03f, 2.36104995e-01f, 1.01917081e-01f, 1.21889710e-01f, 1.83719754e-01f, 1.08572476e-01f,
  1.89672679e-01f, 1.00522026e-01f, -1.08604869e-02f, -2.04940513e-01f, -2.96329200e-01f, -1.77754790e-01f, -2.19180044e-02f, -3.22142541e-02f, -1.14331007e-01f, -7.01396316e-02f,
  1.18757606e-01f, 2.00960115e-01f, 2.09553197e-01f, 9.15572792e-02f, 1.44218758e-01f, 3.38138826e-02f, -3.80944740e-03f, 7.65499175e-02f, 1.62279055e-01f, 1.14253044e-01f,
  -8.73745605e-02f, 1.62773728e-02f, 6.60169348e-02f, 5.43955751e-02f, 1.09147066e-02f, 3.55428234e-02f, -1.29208595e-01f, 2.80367630e-03f, -4.18986520e-03f, -3.08039635e-02f,
  4.36614364e-01f, 8.94254074e-02f, -1.00384526e-01f, -1.09076560e-01f, -1.19764715e-01f, 3.80605869e-02f, 9.69802961e-02f, -7.35651627e-02f, 8.70084018e-03f, -6.79020807e-02f,
  -1.26888836e-02f, -7.83584826e-03f, -8.82883519e-02f, -5.52297458e-02f, -1.78602692e-02f, -9.64791328e-02f, -9.34342071e-02f, 6.48589339e-03f, -4.86414693e-02f, -8.37777480e-02f,
  -2.75675766e-02f, -6.09076358e-02f, -5.68151288e-03f, -1.08463407e-01f, 6.12414740e-02f, 2.80701462e-03f, 3.80497575e-02f, -1.93706825e-02f, 5.85171860e-03f, 6.60734996e-02f,
  2.50238739e-03f, 2.79855095e-02f, -5.21369055e-02f, -2.41109915e-02f, 6.45099357e-02f, -1.75673664e-02f, 1.42231267e-02f, -5.31582453e-04f, 4.80257906e-02f, -3.10142641e-03f,
  4.35070507e-02f, 1.58527289e-02f, -5.39306588e-02f, -8.90624896e-03f, -5.71789816e-02f, -8.22490901e-02f, -1.26152532e-02f, -6.72860164e-03f, -3.73942852e-02f, 1.62430201e-02f,
  -2.76601724e-02f, -6.55692071e-02f, -1.04536749e-01f, 6.09080978e-02f, -1.06573686e-01f, -4.87778336e-03f, 3.80118452e-02f, -1.06103525e-01f, -8.21611471e-03f, -8.42619240e-02f,
  5.05373031e-02f, -6.25031115e-03f, 1.93130746e-01f, 1.16024651e-01f, -5.69679635e-03f, -6.15190119e-02f, 3.09903733e-02f, -1.09044388e-02f, -7.82780051e-02f, 8.02124962e-02f,
  -1.98593293e-03f, 3.42654698e-02f, 4.79711294e-02f, 3.48763750e-03f, 5.87255880e-02f, 5.63520705e-03f, 1.91861428e-02f, 1.29101388e-02f, 5.26163401e-03f, -1.97596475e-02f,
  -1.08864866e-01f, -2.76983976e-02f, 1.08156770e-01f, -7.87239894e-03f, -1.74780432e-02f, 7.42521212e-02f, 1.07225500e-01f, -4.47048396e-02f, 8.29468071e-02f, -4.33898391e-03f,
  2.65812337e-01f, 5.93439862e-02f, -1.10040359e-01f, 5.84766045e-02f, -6.27134591e-02f, -1.34701312e-01f, -8.75105262e-02f, 5.36597781e-02f, 1.08100481e-01f, 2.50622425e-02f,
  6.07760139e-02f, -2.27152240e-02f, 1.48215413e-01f, 3.21369395e-02f, -4.52714553e-03f, 6.49239272e-02f, 2.24815682e-02f, -3.59668909e-03f, -3.39296423e-02f, -3.52182761e-02f,
  1.42867053e-02f, 2.70268638e-02f, 1.25059977e-01f, -4.78068041e-03f, 3.10232826e-02f, -5.45993075e-02f, -7.61006325e-02f, -7.36395642e-02f, -8.38425010e-02f, 9.87210646e-02f,
  -1.68521643e-01f, -7.78310448e-02f, -3.44877578e-02f, 8.14681202e-02f, -5.16865067e-02f, 2.87012681e-02f, 7.09850565e-02f, -1.89711414e-02f, -3.30048054e-02f, 6.93715066e-02f,
  -3.87366395e-03f, -4.71279863e-03f, -6.82834312e-02f, -5.83847752e-03f, -2.94498429e-02f, -4.76250798e-03f, -8.16513821e-02f, 7.73216411e-02f, 1.51264761e-02f, -2.05230191e-02f,
  -6.17642477e-02f, -8.29887167e-02f, -3.66241373e-02f, 5.57219051e-02f, 1.14666438e-02f, 5.27057052e-03f, -1.12341389e-01f, -2.57059354e-02f, 3.33308205e-02f, 9.31685269e-02f,
  -1.06856547e-01f, -4.03946787e-02f, -5.47775477e-02f, 4.46386151e-02f, 6.01510853e-02f, 8.00981671e-02f, 1.74170418e-03f, -4.24811020e-02f, 5.06888665e-02f, 6.62347302e-02f,
  -5.29505946e-02f, 4.05895337e-02f, -7.78572261e-02f, 8.28818232e-02f, 2.31886562e-02f, -8.56544673e-02f, -4.19722497e-03f, -7.61014968e-02f, -4.40975018e-02f, 3.03114695e-03f,
  -6.91735744e-02f, -7.84320757e-02f, 4.36919630e-02f, -2.03098841e-02f, 2.46416102e-03f, -6.46948963e-02f, -1.02244042e-01f, -3.38541493e-02f, 5.88464551e-02f, 2.19778698e-02f,
  -3.20667997e-02f, -3.58051360e-02f, -4.87504993e-03f, 3.75672802e-02f, -1.34105273e-02f, 6.69848770e-02f, 6.84232870e-03f, 7.77177140e-02f, -2.20253970e-02f, -1.21372372e-01f,
  -4.62861918e-02f, -9.33715999e-02f, 3.92847694e-02f, -3.96587662e-02f, 1.71009533e-03f, 4.59966175e-02f, 7.27696791e-02f, 1.34992013e-02f, -9.73041654e-02f, -9.03260559e-02f,
  -5.26073724e-02f, 8.65044221e-02f, 1.80538759e-01f, 1.42737583e-03f, 3.51988040e-02f, 1.64629802e-01f, -6.38476163e-02f, 4.08497043e-02f, 1.13167688e-01f, 7.24217370e-02f,
  8.79556909e-02f, -2.26547811e-02f, 9.14263800e-02f, 1.02825478e-01f, 1.69412658e-01f, 1.10319324e-01f, 1.71965137e-01f, 8.12794715e-02f, 5.46678118e-02f, 1.15682758e-01f,
  9.95842367e-02f, 9.77364480e-02f, -8.79557803e-02f, -1.14190571e-01f, -1.14083610e-01f, 4.18253466e-02f, 4.12919186e-02f, -4.36390974e-02f, 7.11944466e-03f, 1.07932813e-01f,
  -4.73860763e-02f, 3.42942984e-03f, -8.49256217e-02f, -6.20539533e-03f, 6.20223619e-02f, 9.27813202e-02f, 2.09222399e-02f, 1.07413255e-01f, 9.40321665e-03f, 1.46200845e-03f,
  2.02351883e-01f, -1.84266772e-02f, 5.87862208e-02f, -9.07087103e-02f, 9.86246318e-02f, -5.25336638e-02f, -6.13368005e-02f, 1.09338015e-02f, -4.31909412e-02f, -5.62434681e-02f,
  1.31953154e-02f, -7.28413612e-02f, 5.69424359e-03f, 1.54143386e-02f, -2.86421869e-02f, -7.10367933e-02f, -9.47392806e-02f, -5.13206162e-02f, 1.14608621e-02f, 2.85728239e-02f,
  -9.56238285e-02f, 1.00594591e-02f, -2.36151181e-02f, -9.79194567e-02f, -1.81193501e-02f, -7.29893818e-02f, 2.33083442e-02f, 4.92076157e-03f, 2.71414295e-02f, -8.82215127e-02f,
  6.42094016e-02f, 9.55650061e-02f, -2.35010032e-03f, 2.61046290e-02f, 9.53123271e-02f, -1.55799964e-03f, 2.45252959e-02f, 1.29354492e-01f, 1.79453213e-02f, 5.51896766e-02f,
  -7.94048607e-02f, 9.16872621e-02f, 2.81941029e-03f, 6.36444390e-02f, -4.63663675e-02f, 5.27040847e-02f, 6.43239021e-02f, 4.62479740e-02f, -1.57944541e-02f, -3.71134840e-02f,
  4.23886739e-02f, 2.85212304e-02f, 8.51584077e-02f, 2.68878099e-02f, 3.07890289e-02f, 9.02348757e-02f, -3.97641324e-02f, 7.72594213e-02f, 1.02806218e-01f, 6.59101456e-02f,
  1.60043076e-01f, -9.90065187e-03f, 4.93828207e-03f, 1.51146455e-02f, 6.79517910e-02f, -7.05371797e-02f, 9.58181471e-02f, 1.33853750e-02f, -5.64563721e-02f, -2.99418774e-02f,
  2.44189315e-02f, 6.38412982e-02f, 7.45311379e-02f, 4.25147563e-02f, -2.36047395e-02f, 3.03544812e-02f, 3.25357318e-02f, -2.79365648e-02f, 8.93572625e-03f, 5.20258807e-02f,
  -8.59935805e-02f, 1.32749051e-01f, 1.03618942e-01f, 7.76384175e-02f, -1.04569970e-02f, 7.66925961e-02f, 8.14856067e-02f, -5.82292303e-02f, -5.21865673e-03f, 1.17538489e-01f,
  1.63433582e-01f, -1.70496210e-01f, -1.94691449e-01f, -9.39780995e-02f, -1.50757238e-01f, -2.92555600e-01f, -3.08413178e-01f, -1.56310439e-01f, -1.38080329e-01f, -1.69781208e-01f,
  -1.39931709e-01f, -6.27238257e-03f, -1.27662588e-02f, -5.44469133e-02f, 1.14228874e-01f, -1.20908402e-01f, -1.13981970e-01f, 3.41671258e-02f, 3.77251655e-02f, -1.37457386e-01f,
  -1.42590478e-01f, -5.55519126e-02f, 6.24589510e-02f, 4.14079465e-02f, -1.08797818e-01f, 3.08909500e-03f, -6.76330999e-02f, -7.03199208e-02f, -1.63197324e-01f, -1.48863524e-01f,
  -7.34661594e-02f, -3.26455757e-02f, 9.98469908e-03f, 9.30286050e-02f, -1.22901291e-01f, -7.80523792e-02f, -9.55942497e-02f, -4.35962975e-02f, -2.54277941e-02f, -5.92062436e-02f,
  -1.38202071e-01f, -5.35362028e-02f, -1.75755881e-02f, 5.64504089e-03f, 1.31886592e-03f, 4.53579687e-02f, -5.21386154e-02f, -9.49142501e-03f, -5.65110780e-02f, -1.48053631e-01f,
  -1.51191831e-01f, -2.15726346e-02f, 2.71427296e-02f, -1.05016634e-01f, -5.34255095e-02f, -9.68632177e-02f, -1.44444570e-01f, -6.26846552e-02f, -1.09863259e-01f, 4.75537889e-02f,
  -8.60363990e-02f, -3.04048583e-02f, -1.08259484e-01f, -1.35337645e-02f, -6.07944876e-02f, -6.25247508e-02f, 5.63411489e-02f, -2.61994880e-02f, 6.52595907e-02f, 3.56705673e-02f,
  2.68523162e-03f, -5.41257411e-02f, -6.48383647e-02f, 2.82167718e-02f, 6.29079044e-02f, 5.80723584e-02f, 1.19406227e-02f, -3.87926735e-02f, -6.42677676e-03f, 9.69620496e-02f,
  8.15225840e-02f, 6.31353930e-02f, 3.15476730e-02f, 4.92180847e-02f, -3.68934125e-02f, -6.15308359e-02f, -6.62597865e-02f, -2.85871886e-02f, 4.83383909e-02f, -5.06230704e-02f,
  1.75224334e-01f, -1.45808935e-01f, -6.55115023e-03f, 1.41890347e-01f, -5.25047956e-03f, -2.64982805e-02f, -5.06416708e-02f, 2.60227956e-02f, -1.61404107e-02f, 6.63914979e-02f,
  -8.01654905e-03f, 8.33978206e-02f, 3.27722989e-02f, 8.65272246e-03f, 7.16606081e-02f, 2.24100836e-02f, 3.74318808e-02f, 3.00827511e-02f, 2.69600078e-02f, -1.41352221e-01f,
  -7.53719658e-02f, 4.88200597e-02f, 2.46569812e-01f, 1.93385445e-02f, -8.49301443e-02f, 1.22510165e-01f, 1.19318619e-01f, 5.50526641e-02f, 1.62750512e-01f, 9.98657346e-02f,
  4.72230852e-01f, -2.62009166e-03f, -3.01938891e-01f, -2.98702512e-02f, -1.04248665e-01f, -1.98656142e-01f, -1.28000844e-02f, -6.62333891e-02f, 6.93341158e-03f, -5.68912365e-02f,
  4.87548113e-02f, 9.84733850e-02f, 8.27919040e-03f, -5.14620468e-02f, 7.93700293e-02f, -1.17108516e-01f, -2.19203383e-01f, -4.15832810e-02f, -9.96087119e-02f, -4.89255935e-02f,
  -6.16181456e-02f, 1.82928313e-02f, 3.97407860e-02f, -2.72092782e-02f, -1.12445213e-01f, -1.68611541e-01f, -1.15277119e-01f, -1.86545756e-02f, -1.26159653e-01f, -5.73394112e-02f,
  -2.60710150e-01f, 3.13811041e-02f, 3.38601097e-02f, 1.33563936e-01f, -6.36508465e-02f, 6.68516979e-02f, 7.66705871e-02f, 3.22622024e-02f, 7.75413588e-02f, -6.57712892e-02f,
  -3.47062834e-02f, 3.15094776e-02f, 8.55403468e-02f, -5.31457253e-02f, 6.76612854e-02f, 7.28016794e-02f, -8.03185925e-02f, 1.55968945e-02f, 9.91706625e-02f, -2.32728310e-02f,
  2.52528898e-02f, 7.20843971e-02f, 7.02130720e-02f, 9.68942791e-02f, -6.32585734e-02f, 1.16471551e-01f, -4.78920452e-02f, -4.32727113e-02f, -4.56781164e-02f, -1.57821532e-02f,
  -4.39609811e-02f, -5.28937876e-02f, 5.09461481e-03f, 9.35093611e-02f, -1.08685717e-02f, 5.97775839e-02f, 1.04856938e-02f, 9.86707304e-03f, -1.57134719e-02f, 4.18976955e-02f,
  -5.10717742e-02f, -5.99182360e-02f, 8.78985673e-02f, -4.85975742e-02f, 4.97436970e-02f, -7.48497695e-02f, 6.38775574e-03f, 2.23972485e-03f, 1.15580605e-02f, 1.30428066e-02f,
  -1.51579920e-02f, -5.76390810e-02f, -6.15931079e-02f, 1.82749629e-02f, 3.42209414e-02f, 4.32605222e-02f, -2.06796154e-02f, 3.89741510e-02f, 3.35956141e-02f, 2.02406850e-03f,
  -8.09610114e-02f, 7.85888061e-02f, 3.42090614e-02f, 3.08447238e-02f, -5.11633717e-02f, -4.00114767e-02f, -4.18734923e-02f, -2.82011274e-02f, -8.23001005e-03f, -3.23901027e-02f,
  -4.83189523e-02f, -8.53610598e-03f, 2.45757457e-02f, -8.86503328e-03f, 5.57021685e-02f, 6.17210492e-02f, 8.39166269e-02f, -1.03040142e-02f, 8.53070840e-02f, -7.15684146e-02f,
  -2.69855335e-02f, 9.01279077e-02f, 1.78582072e-01f, -3.01738493e-02f, 1.07557952e-01f, 2.38769352e-02f, -7.08586797e-02f, 1.00047300e-02f, 1.83199905e-02f, 1.56764507e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.82493776e-01f, 3.14416707e-01f, 2.12366357e-01f, -1.10712356e-03f, -4.31087017e-02f, 2.68040866e-01f, 7.80745074e-02f, 1.94016859e-01f, 3.05630583e-02f, 1.12456329e-01f,
  1.10815056e-01f, 6.30343556e-02f, 2.83249736e-01f, 1.47976235e-01f, 1.29091501e-01f, 2.60765582e-01f, 1.93160295e-01f, 3.55828136e-01f, 2.49528393e-01f, 1.41704619e-01f,
  1.01946995e-01f, 2.08404914e-01f, 2.68601745e-01f, 3.77924174e-01f, 1.22695357e-01f, 2.51004755e-01f, 1.59832969e-01f, 1.10419266e-01f, 9.50092226e-02f, 2.50926703e-01f,
  4.60662134e-02f, 1.67486891e-01f, 4.59551699e-02f, 5.92428409e-02f, 3.11247945e-01f, 1.85167268e-01f, 1.60460696e-01f, 1.33078769e-01f, 1.53097272e-01f, 3.14975046e-02f,
  2.59684265e-01f, 1.49137333e-01f, 6.22788779e-02f, 1.82160199e-01f, 2.37814188e-02f, 8.95917937e-02f, 3.15120399e-01f, 2.85765469e-01f, 5.34705669e-02f, 2.12789670e-01f,
  2.41049156e-01f, 1.60825551e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -2.38353267e-01f, -8.73606950e-02f, -1.71913236e-01f, -6.15975559e-01f, -1.35017425e-01f, -4.94664222e-01f, -5.78165241e-02f, 1.42118156e-01f, 2.95370761e-02f, -3.08498204e-01f,
  2.10909784e-01f, -7.60550005e-03f, -3.27461034e-01f, -2.46305525e-01f, 1.87635154e-03f, 1.24490969e-01f, 1.57594427e-01f, -1.90143168e-01f, 3.96632344e-01f, -3.75009149e-01f,
  5.40653944e-01f, -1.31151050e-01f, -1.28947362e-01f, 4.23593111e-02f, 5.34823060e-01f, -1.86093539e-01f, -6.82478920e-02f, -1.82281509e-01f, -1.89375833e-01f, -2.13579118e-01f,
  -2.23326638e-01f, 2.47726724e-01f, 1.39548153e-01f, -5.82293943e-02f, -3.42246503e-01f, 9.69560724e-03f, -1.26039144e-02f, 1.85786560e-01f, -2.36827180e-01f, -2.40631640e-01f,
  2.76784152e-01f, -1.68113202e-01f, -1.82271972e-02f, 9.87132713e-02f, -1.69038460e-01f, -3.89062949e-02f, 5.58074534e-01f, 7.96544492e-01f, -2.78923690e-01f, -1.31831646e-01f,
  -1.29188048e-02f, 1.63750052e-01f, -5.32515496e-02f, 1.98642798e-02f, 5.00415899e-02f, -1.44018918e-01f, 1.95023924e-01f, -1.46026425e-02f, -1.92560479e-01f, -7.49421939e-02f,
  -1.54890701e-01f, -2.07619056e-01f, 1.11258186e-01f, 1.27122745e-01f, -1.01564348e-01f, 2.51572039e-02f, 3.18827838e-01f, 3.53029400e-01f, -2.19289139e-01f, -3.23505759e-01f,
  1.55547962e-01f, 3.37966204e-01f, -1.80695236e-01f, -6.31091744e-02f, 4.35051233e-01f, 4.50406224e-01f, -3.53431761e-01f, -3.64617705e-01f, -2.57146567e-01f, -3.02117407e-01f,
  1.85525328e-01f, 3.38814378e-01f, -2.01780256e-02f, -2.86287606e-01f, 9.46891680e-03f, -5.76408133e-02f, -2.64180124e-01f, 2.21114859e-01f, 8.81644189e-02f, -2.00003088e-01f,
  9.33823064e-02f, -3.02401304e-01f, 3.65057558e-01f, -4.65961426e-01f, -3.25060129e-01f, 4.38554250e-02f, -5.22122718e-02f, 1.35523472e-02f, -1.11037502e-02f, -1.79409876e-01f,
  -7.57470354e-02f, 1.69728935e-01f, -2.74187863e-01f, 4.13101733e-01f, -1.27974432e-02f, 8.85029882e-02f, -6.57574683e-02f, 2.57880390e-01f, -1.03187822e-01f, -2.22975522e-01f,
  2.49976471e-01f, 1.71852186e-01f, -2.77581125e-01f, 1.80918634e-01f, 1.96042880e-01f, -2.57136583e-01f, 1.00975764e+00f, -5.35068139e-02f, 4.58223559e-02f, -2.53722608e-01f,
  -2.66171098e-01f, -8.14303234e-02f, 1.79585516e-01f, 3.63205254e-01f, 2.99026370e-01f, 6.55157492e-02f, 6.13028884e-01f, 4.77960140e-01f, 2.97248125e-01f, 1.11984223e-01f,
  2.40290672e-01f, 2.58966029e-01f, 4.33380544e-01f, 4.36396152e-01f, 6.13352060e-01f, -4.58078325e-01f, 4.09597844e-01f, -1.24150366e-01f, -2.86754221e-01f, -3.12360764e-01f,
  -1.01536259e-01f, -6.35345131e-02f, -3.33343059e-01f, -1.72317028e-02f, -1.15963377e-01f, 2.17051789e-01f, 4.12712067e-01f, -1.42785281e-01f, -3.56915295e-01f, -7.87683651e-02f,
  -1.58594638e-01f, 7.72316456e-02f, -3.02424341e-01f, 3.63189727e-01f, 3.36041629e-01f, 2.82903880e-01f, -3.08296412e-01f, -2.13631943e-01f, -3.18976611e-01f, -7.03005120e-02f,
  -6.03185818e-02f, -2.24908754e-01f, -1.82547778e-01f, -2.61474699e-01f, -1.64340571e-01f, -2.22852319e-01f, -1.51974842e-01f, -2.93067336e-01f, -2.45186433e-01f, 3.27671677e-01f,
  -1.39846966e-01f, 2.76996255e-01f, -1.85387671e-01f, 1.11445092e-01f, 8.53589296e-01f, 7.05938339e-02f, -1.17921673e-01f, -1.00174762e-01f, -2.37468347e-01f, 1.49430215e-01f,
  3.49662751e-01f, 2.13681787e-01f, 1.56306893e-01f, -1.62895501e-01f, -7.17579722e-02f, -6.96241185e-02f, -1.03477733e-02f, -1.65668249e-01f, -1.03207842e-01f, -1.89958155e-01f,
  9.36011299e-02f, -1.50935248e-01f, 2.91608404e-02f, 3.68336029e-02f, 1.19524617e-02f, -5.34712709e-02f, -1.38461143e-01f, 3.04771215e-01f, 1.17113777e-01f, -2.88470052e-02f,
  -1.01678990e-01f, -2.70991819e-03f, -4.60183501e-01f, 1.21906094e-01f, 5.54113805e-01f, 3.07530433e-01f, 1.06261589e-01f, 4.13030088e-02f, 6.78214207e-02f, -3.11600477e-01f,
  6.97081834e-02f, 1.05237395e-01f, 6.59951329e-01f, -1.61783084e-01f, -6.52192384e-02f, -2.05697730e-01f, -4.21847999e-01f, 1.48880035e-01f, 5.75173855e-01f, -3.04474622e-01f,
  -2.61087239e-01f, -6.94449060e-03f, 4.63138260e-02f, 2.51391926e-03f, 7.45798707e-01f, -1.10816583e-01f, -7.45148212e-02f, 7.49014616e-02f, 5.49737275e-01f, -3.11197847e-01f,
  9.93739516e-02f, -1.50849819e-01f, 9.54020172e-02f, -1.47982799e-02f, 4.72298294e-01f, -1.31599501e-01f, 1.40829012e-01f, 3.96376371e-01f, -5.04589319e-01f, 2.97541469e-01f,
  -7.80419111e-02f, -1.44218445e-01f, 8.43574200e-03f, 4.23804298e-02f, -2.01915409e-02f, -1.28735393e-01f, -2.14198828e-01f, 5.09392805e-02f, 1.26509070e-02f, 2.65284535e-02f,
  2.59613931e-01f, -1.40930668e-01f, -1.70317665e-01f, -6.05150387e-02f, -3.85126233e-01f, -1.52626246e-01f, 2.39721150e-03f, 1.28399655e-01f, 4.04551812e-02f, -2.88830340e-01f,
  1.70778289e-01f, -1.20660566e-01f, 1.68897629e-01f, 6.59185797e-02f, -5.56621701e-02f, -1.29283085e-01f, 1.09383963e-01f, 3.83504897e-01f, 6.58801198e-01f, -1.91602647e-01f,
  2.51577068e-02f, 1.44192442e-01f, -5.69010153e-02f, -1.12309746e-01f, -7.74174929e-03f, 4.88946289e-01f, 1.98650911e-01f, -1.79023325e-01f, 4.55038846e-02f, 7.02117607e-02f,
  7.40222812e-01f, -1.15209997e-01f, -2.18274385e-01f, 5.82298934e-01f, -2.62453616e-01f, 6.11678243e-01f, 2.46434212e-01f, -2.58642197e-01f, -6.10313043e-02f, -2.01528043e-01f,
  -1.17394120e-01f, -1.18368700e-01f, 1.46097466e-01f, -3.13947082e-01f, -1.70237105e-02f, 1.31099135e-01f, 1.92451671e-01f, -1.27736226e-01f, -1.41856402e-01f, -2.31227890e-01f,
  -1.58534899e-01f, -1.52289808e-01f, -1.78068057e-01f, -2.97992647e-01f, 2.02502429e-01f, -2.82728851e-01f, 6.24319836e-02f, 1.59094900e-01f, -1.22323938e-01f, -2.43455499e-01f,
  1.35700718e-01f, 2.77993739e-01f, -1.17169224e-01f, -1.97125942e-01f, -1.75913259e-01f, -2.04672992e-01f, 6.61613420e-02f, 2.73792315e-02f, -9.50931460e-02f, -2.24997342e-01f,
  4.04054195e-01f, 1.56534761e-01f, 4.81832534e-01f, 2.44482383e-01f, -1.13356367e-01f, 3.45370859e-01f, 2.38503501e-01f, 2.70599812e-01f, -3.81465256e-01f, 1.32660761e-01f,
  7.40127802e-01f, 2.06027955e-01f, -3.67355317e-01f, 4.40121174e-01f, 8.21178779e-02f, -2.20077038e-01f, -4.45832759e-02f, -3.42841744e-02f, 5.07409349e-02f, -1.83493510e-01f,
  1.46196812e-01f, 3.37103814e-01f, 3.02792370e-01f, -2.85629451e-01f, 3.96315515e-01f, -2.71656662e-01f, -2.56604105e-01f, -2.80503690e-01f, -2.74001360e-02f, 3.47921968e-01f,
  1.98898807e-01f, 4.40711826e-01f, -2.86892027e-01f, 1.85930490e-01f, 1.79343894e-01f, 1.22990198e-01f, 2.16649979e-01f, 7.77268529e-01f, 3.16987723e-01f, 1.98051110e-01f,
  -3.47847790e-02f, -2.79383987e-01f, -4.95391265e-02f, -6.99998811e-02f, -2.32120112e-01f, -2.80079842e-01f, -2.76267320e-01f, -4.85133201e-01f, 9.72441286e-02f, 2.69769784e-02f,
  4.68447758e-03f, 2.30793148e-01f, -1.50533304e-01f, 3.87283921e-01f, 1.02412023e-01f, 2.21680045e-01f, 7.45139495e-02f, 2.38617226e-01f, -1.06737278e-01f, -1.91628054e-01f,
  2.94384450e-01f, 6.13043793e-02f, 2.34878436e-01f, 2.96343327e-01f, -1.10511623e-01f, -1.03968002e-01f, -3.33111793e-01f, 1.93591326e-01f, -1.34367466e-01f, 2.72879489e-02f,
  -5.28100669e-01f, -1.33214876e-01f, 3.57407659e-01f, 4.89053726e-01f, -4.69174176e-01f, -3.83997649e-01f, -1.58911869e-01f, -1.63968861e-01f, -3.29827309e-01f, 1.80040091e-01f,
  -1.39320731e-01f, -1.29634291e-01f, -3.34877402e-01f, 1.28452852e-02f, -9.93841738e-02f, -4.71123680e-02f, 2.65517324e-01f, 6.05528429e-02f, -3.57158333e-01f, -3.58299971e-01f,
  -1.47257045e-01f, 4.24131542e-01f, 6.71521842e-01f, -3.44292857e-02f, 8.26508880e-01f, -2.26154611e-01f, -2.96064228e-01f, -2.74914891e-01f, -1.49803177e-01f, -4.32557136e-01f,
  -7.53721073e-02f, -1.50707230e-01f, 7.38276765e-02f, -1.77068770e-01f, -3.57524484e-01f, 4.75679040e-01f, -1.09007403e-01f, -8.63492936e-02f, 4.52390872e-03f, -1.24043837e-01f,
  2.35795960e-01f, -1.78220659e-01f, 1.14869036e-01f, -1.27954647e-01f, -7.92357326e-02f, -7.03143626e-02f, -1.43418610e-01f, 2.62361884e-01f, 5.31869009e-02f, -2.79389232e-01f,
  -1.07684985e-01f, -1.54281035e-01f, -3.47346008e-01f, 3.38415414e-01f, 9.39675793e-02f, -1.84799850e-01f, 4.47713807e-02f, -2.53551137e-02f, 4.17100713e-02f, -1.58142433e-01f,
  -1.89711824e-02f, -1.49823576e-01f, -4.26642269e-01f, -3.32665056e-01f, 4.00134102e-02f, -1.98195577e-01f, -1.51010782e-01f, 1.99234635e-02f, -1.77080095e-01f, -2.93758571e-01f,
  -3.51374187e-02f, 2.04393744e-01f, 9.19328853e-02f, 3.40001355e-03f, -1.11514619e-02f, -4.63284910e-01f, -1.08941317e-01f, 1.85405444e-02f, -1.89737361e-02f, 1.06333219e-01f,
  -1.05236620e-01f, -1.02900594e-01f, -2.39193544e-01f, 3.61973733e-01f, -6.94080889e-02f, -4.01359677e-01f, 1.10783530e-02f, 1.65154979e-01f, -1.00069657e-01f, -5.25053889e-02f,
  2.23265216e-01f, -5.27417958e-02f, -3.20043266e-02f, 8.03246628e-03f, -2.08410665e-01f, -1.38938934e-01f, 2.33873010e-01f, 5.34703195e-01f, -2.36168593e-01f, -3.05753350e-01f,
  -4.23359610e-02f, 2.22633898e-01f, -1.24072187e-01f, 5.19074678e-01f, -2.66177475e-01f, 7.71977827e-02f, 2.58846581e-01f, 2.88644642e-01f, -3.15216213e-01f, 3.68148051e-02f,
  -1.27238378e-01f, 9.72758532e-02f, -1.45103902e-01f, 5.65642715e-01f, 4.48498338e-01f, -1.36696771e-02f, 5.93179883e-03f, -1.57210544e-01f, -9.65778679e-02f, 5.50410002e-02f,
  -1.96276262e-01f, -1.36757582e-01f, 2.68441588e-01f, 1.23192854e-01f, -8.50099549e-02f, -3.53578627e-02f, -1.98298022e-01f, -2.86048092e-02f, -4.48441863e-01f, 2.32299984e-01f,
  -3.05475920e-01f, 5.53612709e-01f, 3.18876028e-01f, -5.64974844e-01f, -1.04475133e-01f, 1.06494397e-01f, -1.77965507e-01f, 2.74458855e-01f, -1.42448857e-01f, 9.90136713e-03f,
  -1.11291274e-01f, -1.23430490e-01f, -1.09768979e-01f, 1.47178754e-01f, -8.40083659e-02f, 1.08208530e-01f, -4.66781199e-01f, -1.55813709e-01f, -2.31097385e-01f, -1.27815306e-01f,
  -2.45211557e-01f, -2.95658648e-01f, -1.46685451e-01f, -2.79177368e-01f, -6.43823072e-02f, 6.48203015e-01f, 1.55697122e-01f, 8.40914071e-01f, -2.98124462e-01f, 1.50926679e-01f,
  -2.12601125e-02f, -1.46910489e-01f, -1.34865567e-02f, -1.89641323e-02f, -5.45781776e-02f, 1.45087820e-02f, 5.04364632e-03f, -1.88759059e-01f, -2.38963172e-01f, 2.13185281e-01f,
  -2.73360103e-01f, 2.56399691e-01f, -9.29685310e-03f, -1.37881681e-01f, -5.94503954e-02f, -4.74333130e-02f, -2.75938988e-01f, -2.38497764e-01f, 6.43745363e-02f, 1.01401955e-01f,
  6.57892704e-01f, -1.98839977e-01f, 7.99923465e-02f, 3.10761005e-01f, 7.74680376e-02f, -1.89320207e-01f, 2.81781614e-01f, -1.52117297e-01f, -1.80744067e-01f, 7.70959333e-02f,
  -1.67373046e-01f, 3.02869499e-01f, -5.86446583e-01f, -3.85119915e-01f, 4.17706043e-01f, -4.41805661e-01f, -2.77836800e-01f, 5.57942092e-01f, -2.63746768e-01f, -2.08741382e-01f,
  5.44358492e-01f, -9.93997604e-02f, 3.51989940e-02f, 5.09683192e-01f, 4.86066490e-02f, -4.09011431e-02f, -3.85821670e-01f, 3.81868482e-02f, 1.93843156e-01f, 1.85276464e-01f,
  3.53458941e-01f, 3.27534616e-01f, -6.17615283e-02f, 2.05252439e-01f, -3.86388749e-01f, 5.26665926e-01f, 1.90620020e-01f, -2.92220004e-02f, -2.74101496e-01f, -2.75036752e-01f,
  3.27001465e-03f, -4.04082984e-01f, -2.60624617e-01f, -2.01073457e-02f, -9.83842537e-02f, -1.19311303e-01f, -7.86064789e-02f, -2.75387689e-02f, 9.65234116e-02f, 1.15610614e-01f,
  1.53792342e-02f, 6.93385303e-02f, -8.17552656e-02f, -2.41771340e-01f, 5.31184494e-01f, 4.29203510e-01f, -2.50607044e-01f, -1.02963999e-01f, -2.19571739e-01f, -4.67197895e-02f,
  3.58133137e-01f, 3.16505522e-01f, -2.73876965e-01f, -4.88019399e-02f, -3.67751956e-01f, 4.74778973e-02f, -5.02560288e-02f, 2.01796144e-01f, -1.17418379e-01f, 5.47049791e-02f,
  -3.42799157e-01f, 2.86826841e-03f, -5.72580755e-01f, 1.88754603e-01f, 2.70552665e-01f, 8.62082615e-02f, 5.91905594e-01f, 4.65510517e-01f, -5.03060997e-01f, -2.80601859e-01f,
  -4.13664617e-02f, 1.79198474e-01f, 5.61174035e-01f, 1.49512544e-01f, -1.11171857e-01f, -5.19222356e-02f, -1.48098990e-02f, -4.32252930e-03f, -3.61358166e-01f, 1.58136889e-01f,
  -1.58471078e-01f, 2.51918644e-01f, -8.34908262e-02f, 2.47457251e-01f, -3.30772102e-01f, -2.35630363e-01f, -2.21766546e-01f, -2.21039861e-01f, -1.92282572e-01f, -1.98732197e-01f,
  -8.30240324e-02f, 3.39117020e-01f, -1.70549944e-01f, -8.65055248e-02f, 5.39823353e-01f, -9.49643254e-02f, 4.61343169e-01f, -2.82407343e-01f, -1.14366680e-01f, -1.62392780e-01f,
  3.80419567e-02f, 1.41326457e-01f, -1.13647699e-01f, -7.44199902e-02f, 1.39183372e-01f, 9.11232084e-02f, -2.79870957e-01f, -1.24611802e-01f, -6.28321096e-02f, -5.54680638e-03f,
  -2.70594925e-01f, 6.76211417e-02f, -3.10730785e-01f, 2.60509074e-01f, -1.82188869e-01f, -5.17071038e-02f, -1.43284038e-01f, 2.72133768e-01f, -2.25150045e-02f, 4.67817694e-01f,
  -1.47720888e-01f, 1.96124017e-01f, 2.27773070e-01f, -3.51388365e-01f, -3.06502789e-01f, -5.16018346e-02f, -2.73674377e-03f, -2.51993835e-02f, 3.07749122e-01f, -3.17458212e-02f,
  -4.46320087e-01f, -2.27503642e-01f, 3.72619987e-01f, 4.10554081e-01f, -1.15560196e-01f, -2.01643169e-01f, -8.27806070e-02f, 1.91718012e-01f, 3.19717050e-01f, 1.24765225e-01f,
  1.39180586e-01f, 4.63686734e-02f, -2.87248671e-01f, 3.34836692e-01f, -2.06673026e-01f, -7.96144679e-02f, 6.59283698e-02f, -1.10207938e-01f, 4.65790257e-02f, -5.55896014e-02f,
  1.96533039e-01f, 9.02121216e-02f, 4.87718552e-01f, -4.75861818e-01f, -6.73011094e-02f, -1.46426260e-01f, 8.75847265e-02f, -1.16176076e-01f, 1.32769898e-01f, 6.05057597e-01f,
  -1.92288503e-01f, -1.64500639e-01f, 4.66146439e-01f, -4.05197263e-01f, 1.92183971e-01f, -2.29647726e-01f, 7.79278949e-02f, -2.41379201e-01f, 2.76416510e-01f, -1.64936945e-01f,
  -3.50722045e-01f, -7.07133114e-02f, 1.65041804e-01f, -5.05378902e-01f, 7.42734849e-01f, 1.76539123e-01f, -1.60892576e-01f, -3.27163935e-01f, -1.37140915e-01f, -1.35269552e-01f,
  1.89115867e-01f, -8.50785226e-02f, -1.29623398e-01f, -4.07973044e-02f, -2.09670335e-01f, 1.99032411e-01f, -2.43478894e-01f, 9.71007124e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.82691985e-01f, 1.53600723e-01f, 1.04104988e-01f, -1.30764872e-01f, -7.91239589e-02f, 1.45164669e-01f, 1.18603282e-01f, -1.76457107e-01f, -5.05984053e-02f, 7.14885369e-02f,
  1.39013574e-01f, 9.38989595e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    