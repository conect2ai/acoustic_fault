/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  9.71493661e-01f, -8.62387493e-02f, -3.33902806e-01f, 3.16541463e-01f, -2.33578339e-01f, -2.95966804e-01f, -4.29502696e-01f, -1.07284881e-01f, 1.25130266e-01f, 1.87574886e-03f,
  -4.14703824e-02f, 3.16461980e-01f, 2.30585188e-01f, 1.01579413e-01f, 4.38890979e-02f, -2.78106153e-01f, -1.43997148e-01f, 1.65316716e-01f, 2.08638042e-01f, 1.48152724e-01f,
  3.11717335e-02f, 7.70696402e-02f, 3.15753043e-01f, 4.91713360e-02f, -1.00331329e-01f, 6.33502752e-02f, -1.65141329e-01f, -4.05766107e-02f, -2.28630304e-01f, -3.88833433e-02f,
  4.82378192e-02f, 1.26959398e-01f, -2.77637504e-02f, 5.98894656e-02f, -1.27146795e-01f, 1.54378816e-01f, -2.28198972e-02f, 2.25820392e-02f, 1.96918845e-02f, -2.47000325e-02f,
  -6.27012327e-02f, -6.05901610e-03f, 1.35873156e-02f, -2.84319315e-02f, -6.09944984e-02f, -3.68046872e-02f, -9.72051080e-03f, 5.70647791e-02f, 2.97596827e-02f, -3.75287347e-02f,
  -3.22123021e-02f, -3.76499146e-02f, -3.73093076e-02f, -1.21075779e-01f, 8.42393638e-05f, -2.00673677e-02f, -1.36714503e-01f, 1.62112731e-02f, -2.84985658e-02f, 9.59344730e-02f,
  -1.54893314e-02f, 3.99504676e-02f, -5.83561882e-02f, -3.34823737e-03f, 4.71290983e-02f, -3.54736410e-02f, 1.55137898e-02f, -2.33752597e-02f, -9.54591390e-03f, 3.63349542e-02f,
  -4.42870408e-02f, -6.41166698e-03f, -5.72567433e-02f, 6.76816702e-02f, 3.66094410e-02f, -4.26928066e-02f, 1.77197270e-02f, 1.34338113e-02f, -1.25872456e-02f, -2.50013731e-03f,
  6.21630475e-02f, -1.18621951e-02f, -1.68725718e-02f, -7.10933236e-03f, -1.50653515e-02f, 2.39278562e-02f, -1.19158123e-02f, -1.79151632e-02f, -1.05105741e-02f, -1.16664767e-02f,
  1.06648527e-01f, -2.11531445e-01f, 1.89635396e-01f, 5.71353659e-02f, 4.76241019e-03f, -5.44697307e-02f, 1.31663363e-02f, -3.04534892e-03f, -2.65328642e-02f, -2.71605477e-02f,
  -1.21452543e-03f, 4.56817970e-02f, -5.54051101e-02f, 4.14478257e-02f, 3.01706214e-02f, 3.32461223e-02f, -2.48596054e-02f, 1.53059646e-01f, -4.61679026e-02f, -9.57293063e-02f,
  -3.14076431e-02f, -6.65233331e-03f, 1.58890173e-01f, -1.64645966e-02f, -1.08028054e-02f, 1.49170861e-01f, -8.07386041e-02f, 4.58259601e-04f, -6.62180304e-04f, 4.03650142e-02f,
  2.16131926e-01f, -3.16503108e-01f, -3.38238865e-01f, -1.54065445e-01f, -5.78400157e-02f, -5.50437793e-02f, -1.63102642e-01f, 1.26243220e-03f, 1.82973802e-01f, -1.06137328e-01f,
  -1.01628207e-01f, 1.82046130e-01f, 7.54392967e-02f, -2.35228930e-02f, -1.08431049e-01f, -1.64048418e-01f, -3.75591934e-01f, -7.00837299e-02f, 1.47864744e-01f, 4.72851507e-02f,
  -6.66250587e-02f, -4.99725156e-02f, -3.26135270e-02f, -8.20019916e-02f, -7.10175782e-02f, 4.07670587e-02f, -8.24085698e-02f, 1.21882018e-02f, -7.15686306e-02f, -3.61858338e-01f,
  -1.09105460e-01f, -1.03025585e-01f, 1.11037277e-01f, -5.38668633e-02f, -5.93207814e-02f, 8.99816006e-02f, -4.91628889e-03f, -3.06360214e-03f, 2.19837241e-02f, -1.91532522e-02f,
  -7.52415601e-03f, 7.29718851e-03f, -7.67454356e-02f, -9.73652676e-03f, -3.44313681e-02f, -5.32703139e-02f, 1.49499066e-03f, -1.28667414e-01f, -8.14608634e-02f, -2.61712763e-02f,
  -2.39446878e-01f, -1.56696230e-01f, -2.62580086e-02f, -2.48989761e-02f, 1.26309320e-02f, -7.56833181e-02f, -9.05824155e-02f, 1.30744306e-02f, 3.11119501e-02f, -3.74851711e-02f,
  -5.75748719e-02f, 1.10820517e-01f, 1.36974066e-01f, -1.62168778e-02f, 3.29563692e-02f, 6.59231469e-02f, -2.46851910e-02f, 3.22938450e-02f, 2.82093398e-02f, 3.65248471e-02f,
  -6.43616468e-02f, -7.03164637e-02f, -2.61304080e-02f, -7.44996369e-02f, -7.60434708e-03f, 1.43172238e-02f, 4.38034069e-03f, -7.53119355e-03f, 4.99943644e-02f, 1.95090845e-03f,
  5.91508932e-02f, 7.61649013e-02f, 3.50894919e-03f, -5.15652709e-02f, -1.00318361e-02f, -1.05901785e-01f, 7.04780519e-02f, 5.16253822e-02f, 3.73652689e-02f, 7.36330301e-02f,
  3.32943469e-01f, 1.56756174e-02f, 4.21061777e-02f, 8.06946009e-02f, 1.14995521e-02f, 1.77271105e-02f, 2.42912546e-02f, 3.60688791e-02f, 6.10566027e-02f, 8.49445462e-02f,
  5.38357534e-03f, 6.90333694e-02f, -3.83658968e-02f, 1.08476870e-01f, 1.12995170e-02f, 5.87249286e-02f, 4.15087007e-02f, -2.22087260e-02f, 1.29304025e-02f, -2.51077488e-02f,
  1.42481141e-02f, 1.49707645e-01f, 1.56047374e-01f, 1.55308887e-01f, 1.56897247e-01f, 1.56226471e-01f, 1.03955925e-01f, 8.72509852e-02f, 1.07021980e-01f, 6.57449514e-02f,
  6.48667336e-01f, -1.89360306e-01f, -4.38805297e-02f, 2.06706122e-01f, -2.41040573e-01f, -2.07732782e-01f, -2.43001595e-01f, 8.32343772e-02f, 1.45040467e-01f, -3.01398002e-02f,
  -1.03585944e-01f, 8.75108987e-02f, 5.78404590e-02f, 8.02494586e-02f, 7.88774714e-02f, -8.96856114e-02f, -5.94853498e-02f, 1.19836137e-01f, 4.71496247e-02f, -1.23773851e-02f,
  -8.96677971e-02f, 3.43214311e-02f, 1.97451517e-01f, 5.60891815e-02f, -5.19091114e-02f, -9.12841558e-02f, -9.82859209e-02f, -1.02962442e-01f, -2.18206972e-01f, -1.69919804e-01f,
  6.43362990e-03f, 1.20405883e-01f, 5.03558144e-02f, -5.85427135e-02f, -3.45988572e-02f, 9.77215320e-02f, 3.30737233e-02f, 9.45154428e-02f, 6.80922419e-02f, 5.76855317e-02f,
  -2.83049848e-02f, 2.90590301e-02f, 3.33261229e-02f, -6.38364330e-02f, 4.60775159e-02f, 1.36792073e-02f, 1.02240898e-01f, 1.64828882e-01f, 1.98374391e-02f, -2.66373679e-02f,
  -2.79315621e-01f, -2.45229423e-01f, -3.15158255e-02f, 1.70764774e-02f, 8.33912194e-02f, 3.19593288e-02f, -1.23488575e-01f, 3.89438495e-02f, 8.55181366e-02f, 1.71707198e-01f,
  1.54455574e-02f, -3.09295058e-02f, -4.64848094e-02f, 6.54386207e-02f, -5.98210515e-03f, -2.43471414e-02f, 4.20062579e-02f, -8.21984559e-02f, 1.68618523e-02f, -1.84377655e-04f,
  5.32143451e-02f, -1.51106920e-02f, 4.56589907e-02f, 2.98704188e-02f, 3.58625897e-03f, -8.16698000e-03f, 1.20394630e-02f, 2.32546031e-02f, -3.07928165e-03f, -9.03150532e-03f,
  4.86534415e-03f, -3.26030306e-03f, -3.84609103e-02f, -6.88768700e-02f, -2.89710499e-02f, -1.18867289e-02f, 1.52137631e-03f, 2.95036789e-02f, 6.03519529e-02f, 1.50934169e-02f,
  3.21483612e-01f, 1.75469518e-02f, 1.17545113e-01f, 2.64585260e-02f, -3.31052542e-02f, -1.30804600e-02f, 3.79580930e-02f, 6.87922090e-02f, -3.48220058e-02f, 3.63651589e-02f,
  -2.89971177e-02f, 6.47776723e-02f, -2.14134790e-02f, 9.24535003e-03f, 6.40450278e-03f, 6.78686574e-02f, -8.34623650e-02f, -4.68699522e-02f, 3.20706926e-02f, 1.70924366e-02f,
  -6.57754838e-02f, 1.06219977e-01f, 9.79266912e-02f, 7.03485981e-02f, -1.46039026e-02f, -1.69611089e-02f, 2.37329826e-02f, -1.39258746e-02f, -1.63982622e-02f, 1.53788641e-01f,
  -4.07303929e-01f, -4.53390151e-01f, -3.55234623e-01f, -1.87708765e-01f, 2.03997456e-02f, -1.06949292e-01f, -2.78837055e-01f, -6.90768734e-02f, -1.65497195e-02f, -1.04946487e-01f,
  2.97569513e-01f, 3.32657993e-01f, 3.32458347e-01f, 2.66051322e-01f, 1.09508023e-01f, -3.73237550e-01f, -3.33754987e-01f, -5.39952330e-02f, 7.65285045e-02f, 1.84999958e-01f,
  1.81918174e-01f, -1.16732210e-01f, 5.25178947e-02f, 4.34674174e-02f, -2.10678391e-02f, 7.44386092e-02f, -1.19923353e-01f, -1.51741490e-01f, 9.59846154e-02f, -3.08994323e-01f,
  5.20132780e-02f, -3.68715346e-01f, 2.31660798e-01f, 1.77653819e-01f, 8.79453048e-02f, -3.64688300e-02f, 3.46820196e-03f, -2.35094950e-02f, 1.13519475e-01f, -1.05027013e-01f,
  3.56220594e-03f, 4.07127738e-02f, -2.40011420e-02f, 8.36571231e-02f, -3.70714068e-02f, 4.25854065e-02f, -2.34841630e-02f, -5.99546917e-02f, -8.25839415e-02f, 5.27810156e-02f,
  1.42287314e-01f, -9.26863775e-02f, -1.11841924e-01f, 3.87951522e-03f, -1.17132232e-01f, 1.47293553e-01f, -7.64790829e-03f, -4.25206535e-02f, -1.49939626e-01f, -3.12142104e-01f,
  1.14819966e-01f, -9.80170220e-02f, -3.83106358e-02f, 1.48504041e-02f, 6.99552447e-02f, -1.45840982e-04f, -4.92209122e-02f, 4.84611914e-02f, -1.34805022e-02f, -9.13516060e-02f,
  6.80315569e-02f, 1.07694147e-02f, 5.26239164e-02f, -2.26280633e-02f, 4.14199941e-02f, -9.24585015e-02f, -7.68534541e-02f, 7.01420531e-02f, 1.30997136e-01f, -3.74298729e-02f,
  3.26826028e-03f, 2.66463105e-02f, 1.33510334e-02f, -1.64927766e-02f, -2.67073195e-02f, -4.71715778e-02f, -5.42305000e-02f, 4.70770709e-02f, -4.80896831e-02f, -3.78757939e-02f,
  2.31209472e-01f, 2.09200263e-01f, -3.22688604e-03f, -3.40551473e-02f, -1.52825117e-01f, 3.27608362e-02f, 2.88619399e-02f, -3.15877534e-02f, 9.11306143e-02f, -1.86547153e-02f,
  1.03739845e-02f, -2.33479924e-02f, 3.33610475e-02f, 8.43959022e-03f, 3.79419886e-02f, 7.72128301e-03f, 3.31015550e-02f, -6.07593283e-02f, 4.80049923e-02f, -6.25765324e-02f,
  8.64997692e-03f, -9.08788219e-02f, 1.18234135e-01f, 2.52775359e-03f, -1.21908197e-02f, 1.06229633e-02f, -7.41949817e-03f, 1.10706780e-02f, 2.62460317e-02f, -9.21059400e-02f,
  6.41796827e-01f, -6.73702881e-02f, -9.17534009e-02f, 1.02077223e-01f, -3.11145812e-01f, -1.95493385e-01f, -8.88944194e-02f, 1.05333947e-01f, 1.47369474e-01f, -1.38079122e-01f,
  -9.38070491e-02f, -1.32050395e-01f, 3.69431265e-02f, -3.70279662e-02f, 2.29945272e-01f, -1.32179275e-01f, -1.60508249e-02f, 9.82433036e-02f, 1.11134022e-01f, -2.31700465e-02f,
  -4.34221514e-02f, 9.90207493e-02f, 2.38620460e-01f, 6.80991933e-02f, -2.15003580e-01f, -2.24474952e-01f, -1.66427359e-01f, 1.73664819e-02f, -1.24797560e-01f, -2.93816775e-01f,
  -3.89340609e-01f, 1.79243341e-01f, -2.08766535e-02f, 1.10622220e-01f, -1.24066994e-01f, 1.27973974e-01f, -4.66035046e-02f, 1.19106457e-01f, 4.87681776e-02f, 4.21336927e-02f,
  -1.01717012e-02f, 2.71149706e-02f, 2.80183349e-02f, -4.34790961e-02f, 9.51719061e-02f, 1.20184748e-02f, 9.46689993e-02f, 2.66559422e-01f, 6.11333661e-02f, -4.47776802e-02f,
  -1.19723648e-01f, -1.42982692e-01f, 1.88169628e-02f, 1.02598511e-01f, 4.02653590e-02f, 5.06762788e-02f, 8.47997591e-02f, 1.20224133e-01f, 1.77195311e-01f, 9.78501663e-02f,
  -8.00866708e-02f, -3.66567145e-03f, -1.74486712e-02f, 4.15610075e-02f, -4.27313484e-02f, 3.62551259e-03f, -4.33435515e-02f, -1.81430504e-02f, 1.30359912e-02f, -3.82656269e-02f,
  5.17699122e-02f, -5.11263218e-03f, -4.67081089e-03f, 3.66435908e-02f, -6.23080656e-02f, -3.12133017e-03f, 4.68085846e-03f, -3.13843898e-02f, -3.01365461e-03f, 5.53475171e-02f,
  1.00920193e-01f, -2.42933631e-03f, -4.07834863e-03f, 8.18790402e-03f, 1.49218608e-02f, 5.86638451e-02f, -1.33538879e-02f, 9.45936795e-03f, 3.40128900e-03f, -1.01225860e-02f,
  6.81954622e-02f, 1.95929661e-01f, -1.62327453e-01f, 3.89827713e-02f, -6.37299642e-02f, -5.15643135e-02f, -8.81500915e-02f, -2.85991058e-02f, -5.41562550e-02f, 3.29431868e-03f,
  8.39494728e-03f, 2.63507422e-02f, -5.87324761e-02f, 4.55891006e-02f, -5.34890294e-02f, -6.49253055e-02f, -4.89679053e-02f, -1.10207886e-01f, 3.28282937e-02f, -3.91224511e-02f,
  7.20525300e-03f, -4.79505248e-02f, -1.09950826e-01f, -1.40164346e-01f, 2.72933692e-02f, -1.06408209e-01f, -1.81683049e-01f, -1.75896317e-01f, 2.58640964e-02f, -1.46149993e-01f,
  4.98178974e-02f, -2.74900168e-01f, 2.18057007e-01f, -1.69078961e-01f, 1.20180540e-01f, 2.26979852e-01f, 1.85399517e-01f, 1.26578376e-01f, -2.77987476e-02f, -5.38885295e-02f,
  3.61597240e-02f, 3.07586379e-02f, 1.49959087e-01f, 1.21118635e-01f, 1.52866051e-01f, -1.26458658e-02f, -5.50464019e-02f, 1.46705076e-01f, 2.17250720e-01f, 1.00131352e-02f,
  -1.61709905e-01f, -1.13681525e-01f, -5.95220067e-02f, -1.56899691e-01f, -2.68827349e-01f, 1.70265511e-02f, -1.46660388e-01f, -1.42026365e-01f, -8.50383937e-02f, -4.13856387e-01f,
  6.83262199e-02f, -1.01990096e-01f, 5.73994070e-02f, -3.97119746e-02f, -1.53149078e-02f, 3.53220627e-02f, 2.89388141e-03f, -6.46664575e-02f, -1.05304874e-01f, 1.07869115e-02f,
  -8.42824876e-02f, -1.01642795e-01f, -1.15007795e-01f, -1.23052470e-01f, -1.25097528e-01f, -2.42460473e-03f, -9.93220434e-02f, -5.48534058e-02f, 1.79144349e-02f, -5.97616173e-02f,
  1.46504575e-02f, 3.74005213e-02f, 1.23415001e-01f, 3.01086940e-02f, 2.83957608e-02f, 1.02783784e-01f, -7.39350542e-02f, -1.05844304e-01f, 1.18794076e-01f, -2.27550313e-01f,
  -2.44218912e-02f, 5.41935526e-02f, 3.37108113e-02f, -5.92912287e-02f, 1.69790275e-02f, 5.08819856e-02f, 3.84554570e-03f, 1.71536244e-02f, 4.75016981e-02f, -7.23588541e-02f,
  6.80007832e-03f, 1.11691974e-01f, 1.05242350e-03f, -4.66965474e-02f, -3.53890122e-03f, -6.34915521e-03f, 3.22327279e-02f, -8.84271264e-02f, -1.17988950e-02f, -2.05191188e-02f,
  -5.92365069e-03f, 5.21116555e-02f, -8.58971402e-02f, -3.63016059e-03f, -6.23728596e-02f, 3.32891606e-02f, -4.72674407e-02f, 3.40593047e-03f, 3.92872430e-02f, 4.03318964e-02f,
  -3.84176001e-02f, 2.63277650e-01f, -1.99641176e-02f, -1.18970647e-01f, -5.47144637e-02f, -6.98714480e-02f, -2.64828000e-02f, -8.62674192e-02f, 6.20486913e-03f, -4.47148234e-02f,
  2.91853547e-02f, 1.77698750e-02f, 2.96844505e-02f, -5.74755259e-02f, 6.43903837e-02f, -1.32084852e-02f, -5.52249625e-02f, 5.11440225e-02f, 1.32982433e-01f, -3.96708809e-02f,
  -6.94619939e-02f, 1.18516386e-01f, 1.49493366e-01f, 1.71862170e-01f, 1.34497195e-01f, 1.84902266e-01f, 1.10333920e-01f, 1.04513824e-01f, 1.77880645e-01f, -3.52183767e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.96061099e-01f, 5.34537137e-01f, 1.57326013e-01f, -1.37259796e-01f, -1.18618049e-01f, -2.74406761e-01f, -5.37033342e-02f, -1.16962880e-01f, -3.97162177e-02f, 9.22305062e-02f,
  6.38653934e-02f, -2.16000378e-01f, 2.45743655e-02f, -1.54328540e-01f, -1.33971006e-01f, 1.46931499e-01f, 5.54599278e-02f, -2.61310577e-01f, -5.70684552e-01f, -5.23978829e-01f,
  -1.86293259e-01f, -3.11068147e-01f, -2.63664126e-01f, -1.40167579e-01f, 4.72999364e-02f, -7.85147846e-02f, 2.19584897e-01f, -1.01924986e-01f, -1.39045045e-02f, 1.05573582e-02f,
  1.83095858e-01f, -2.60748770e-02f, -2.29755610e-01f, -1.07564248e-01f, -1.04582142e-02f, -1.26678050e-02f, -4.65706997e-02f, 2.37436779e-02f, -8.28792155e-03f, -9.92332026e-03f,
  -9.11967680e-02f, -2.91829091e-02f, -1.15778491e-01f, -1.48302212e-01f, -6.97238669e-02f, -1.49600416e-01f, -2.20385194e-03f, -1.24348395e-01f, -1.17908880e-01f, -3.29848714e-02f,
  -3.38353552e-02f, -1.10085152e-01f, -4.56207842e-02f, -1.24599617e-02f, -2.72335242e-02f, -1.14121377e-01f, 1.22021817e-01f, -7.45879039e-02f, -1.20528594e-01f, 2.27228016e-01f,
  4.36905678e-03f, 1.17412589e-01f, -2.92688403e-02f, 6.35635257e-02f, 2.02115085e-02f, 4.99164760e-02f, 5.65451346e-02f, 5.72893135e-02f, -3.38221379e-02f, 3.46227400e-02f,
  6.04105107e-02f, 5.19961827e-02f, 8.40790123e-02f, 9.75965708e-02f, 6.36464432e-02f, 4.62309644e-02f, -1.06830774e-02f, 6.91412166e-02f, 7.42876604e-02f, -5.78208268e-02f,
  2.33936054e-03f, -5.92346340e-02f, 2.33480521e-02f, -1.76552944e-02f, 4.75461073e-02f, 4.95964326e-02f, 2.36248486e-02f, -6.89469650e-02f, -2.99591478e-02f, -8.45160037e-02f,
  2.94077843e-01f, -1.89989582e-01f, 1.67006835e-01f, -1.01131141e-01f, -2.79412400e-02f, 2.48791277e-02f, 1.23021051e-01f, 1.38280652e-02f, 6.11658171e-02f, -4.64827232e-02f,
  -1.44867092e-01f, -1.07842432e-02f, 9.70300585e-02f, -1.57741960e-02f, -1.60664052e-01f, -6.09780066e-02f, 9.75443497e-02f, -6.00814726e-03f, -9.06458348e-02f, 1.21076547e-01f,
  9.56063271e-02f, -5.06725609e-02f, 8.02085325e-02f, 9.97176021e-02f, 3.84532772e-02f, -1.20198153e-01f, 7.08282068e-02f, -6.37050543e-05f, 3.51960026e-02f, 3.41762900e-01f,
  2.26604208e-01f, -1.47556648e-01f, -7.06249382e-03f, 2.30112821e-01f, 5.25951432e-03f, -3.48720282e-01f, -6.04577482e-01f, -2.40479007e-01f, 4.33306284e-02f, -9.10938978e-02f,
  1.87988523e-02f, 2.87362952e-02f, -4.75155264e-02f, -1.83734179e-01f, -2.88258523e-01f, -3.90381694e-01f, -2.24458456e-01f, -2.06681639e-01f, -1.62554100e-01f, -1.42562315e-01f,
  -8.42759162e-02f, 1.62358090e-01f, 1.58174351e-01f, 4.73366417e-02f, 2.50937611e-01f, 1.37336046e-01f, 1.94281310e-01f, 2.32940406e-01f, -3.56528796e-02f, 2.34287828e-01f,
  2.61990563e-03f, 3.05009902e-01f, -2.03698620e-01f, 1.03326641e-01f, 1.61711514e-01f, -6.15641512e-02f, -1.11569323e-01f, 1.62044451e-01f, 2.16385629e-03f, -1.99506506e-02f,
  1.31975755e-01f, -2.01786356e-03f, -4.88367444e-03f, -2.53680497e-02f, -1.32929623e-01f, -1.55866072e-01f, 1.65528115e-02f, -5.90089001e-02f, -1.60605833e-02f, -7.11855069e-02f,
  -1.04784943e-01f, 2.12907046e-02f, -1.08212695e-01f, -1.47984222e-01f, 8.85794982e-02f, -7.75918514e-02f, -7.01483414e-02f, 1.27109975e-01f, 1.55192893e-02f, 6.99266940e-02f,
  -1.83726959e-02f, 1.70128215e-02f, -5.76926023e-02f, -2.53224112e-02f, -1.02514304e-01f, 1.91397313e-02f, -3.17221023e-02f, -5.13025224e-02f, 1.27476675e-03f, 9.81930410e-04f,
  5.48028350e-02f, -2.51742601e-02f, -7.62363197e-03f, 7.67753050e-02f, 7.68254418e-03f, -4.88187745e-03f, 3.28457379e-03f, -5.53497635e-02f, -1.45683689e-02f, 7.18446299e-02f,
  -2.11067237e-02f, 4.16578073e-03f, 8.80242288e-02f, 5.46260960e-02f, -7.45619740e-03f, 2.69983131e-02f, -4.20621522e-02f, 3.14066112e-02f, 7.41211921e-02f, 7.37058073e-02f,
  -8.26530829e-02f, -1.96522653e-01f, -1.17404915e-01f, -1.26488626e-01f, 5.44840433e-02f, -2.11188570e-02f, 1.11137293e-01f, -7.05109611e-02f, 1.03750773e-01f, -1.03445329e-01f,
  -9.33781490e-02f, -1.03129044e-01f, -2.09421720e-02f, -1.32340550e-01f, -6.74609467e-02f, -7.30645582e-02f, -1.42917514e-01f, -7.22101256e-02f, -1.12602398e-01f, -2.22560111e-02f,
  -1.43365428e-01f, -3.48757118e-01f, -3.66310418e-01f, -2.81634480e-01f, -7.68007413e-02f, -2.74952084e-01f, -2.79226542e-01f, -1.84775010e-01f, -4.39703375e-01f, -4.43245292e-01f,
  3.06104850e-02f, 1.38821036e-01f, -2.00328350e-01f, 1.02251507e-01f, 1.21718511e-01f, -1.64743308e-02f, 1.26370400e-01f, 2.40942493e-01f, 2.59182602e-01f, 7.51838088e-02f,
  -7.68372715e-02f, -9.72187594e-02f, -1.36729240e-01f, -7.98005164e-02f, -9.94263291e-02f, 1.73888668e-01f, 1.68764755e-01f, -3.66549343e-02f, -1.98246032e-01f, 5.73504157e-03f,
  1.17837206e-01f, 8.72957930e-02f, 6.66123703e-02f, 1.52240619e-01f, 1.33043446e-03f, 5.53546362e-02f, 9.74836946e-02f, -3.80377807e-02f, -4.98594604e-02f, 7.11590424e-02f,
  -5.02198398e-01f, -4.83207963e-02f, -1.16133533e-01f, 5.12277484e-02f, -1.85409293e-01f, 7.04216957e-02f, 2.33139638e-02f, 5.69515340e-02f, 2.10243855e-02f, 8.97614658e-02f,
  6.24144101e-04f, -8.57807025e-02f, -6.27883002e-02f, 1.03060305e-02f, -3.55248749e-02f, 5.22178486e-02f, 2.06156801e-02f, 6.31355122e-02f, -6.88075498e-02f, -2.42516361e-02f,
  -6.39897212e-02f, -1.09761879e-01f, -9.97420959e-03f, -1.31884338e-02f, -1.16080120e-02f, -1.84586659e-01f, -7.25580156e-02f, -8.08717385e-02f, -8.51822346e-02f, 7.49124661e-02f,
  -5.44323213e-02f, -3.74093391e-02f, 3.39553691e-02f, 3.84119377e-02f, -5.50328083e-02f, 3.47260050e-02f, -3.47172283e-02f, -3.00270412e-02f, -1.00861769e-02f, -3.00154416e-03f,
  -3.13708000e-02f, -1.18454061e-01f, 5.16753010e-02f, 8.06151927e-02f, -3.81868035e-02f, 1.54540529e-02f, 6.11620322e-02f, -5.30236866e-03f, -9.43898037e-02f, 9.73254219e-02f,
  -2.19471473e-02f, 5.93542820e-03f, 5.27627505e-02f, 2.02038679e-02f, -7.34400526e-02f, 3.24050477e-03f, -4.42317873e-02f, -2.93184295e-02f, 2.70985197e-02f, 1.20254427e-01f,
  2.40948275e-01f, -2.61855006e-01f, 8.98821205e-02f, -2.04341318e-02f, -2.82705799e-02f, 3.98998670e-02f, -9.29125324e-02f, -2.64148141e-04f, -3.93281989e-02f, 9.57264379e-02f,
  -6.52804226e-02f, 1.68651063e-02f, 1.28019555e-02f, 6.97870478e-02f, 9.46411341e-02f, -5.62487580e-02f, -2.72658337e-02f, 5.92130832e-02f, 2.79820394e-02f, -1.77531242e-02f,
  1.30216226e-01f, 1.33157849e-01f, 4.43232395e-02f, 1.30750015e-01f, -2.97095124e-02f, -1.12913810e-02f, -6.90723956e-02f, 1.25988007e-01f, 8.00513849e-02f, 3.92829895e-01f,
  4.16510880e-01f, -4.66165781e-01f, 3.61477613e-01f, 2.06128191e-02f, 2.32274756e-01f, 2.04375312e-01f, -9.89342853e-02f, -1.43904565e-02f, 2.18087677e-02f, -4.93236519e-02f,
  -1.80795416e-01f, -1.11514576e-01f, 6.65280074e-02f, -5.46241887e-02f, 7.95889273e-02f, -2.85165049e-02f, 4.76866262e-03f, 3.84798735e-01f, 4.77370262e-01f, 4.07218635e-02f,
  -4.50011231e-02f, 2.86981389e-02f, 1.44428492e-01f, -5.95313087e-02f, -5.28451949e-02f, 1.48218579e-03f, -4.63683829e-02f, 4.10890440e-03f, -1.75843135e-01f, -1.34525493e-01f,
  1.43730968e-01f, -1.89573929e-01f, 2.51094013e-01f, -4.11774367e-02f, -1.16975591e-01f, -8.66634846e-02f, 9.08225775e-02f, 1.73626021e-02f, -6.39686063e-02f, -2.01200731e-02f,
  8.80200602e-03f, -8.50345641e-02f, -2.00643744e-02f, -1.49683446e-01f, 4.27459404e-02f, -1.99876130e-02f, -1.11655340e-01f, 1.90633256e-02f, -9.13675353e-02f, -1.10744521e-01f,
  -3.09885114e-01f, -2.62783095e-02f, 9.27811190e-02f, -1.14841297e-01f, -1.20547250e-01f, 1.42501742e-01f, -5.56183867e-02f, -5.40905446e-02f, 6.85585067e-02f, -1.43485576e-01f,
  1.70916561e-02f, 7.51044899e-02f, 7.37235919e-02f, 3.22966315e-02f, 2.40495577e-02f, 1.35747604e-02f, 8.18866119e-02f, -3.09663564e-02f, 6.87879398e-02f, 3.16378884e-02f,
  1.93073619e-02f, 4.57494184e-02f, -2.26121349e-03f, 6.17929772e-02f, 3.56394723e-02f, -1.91193484e-02f, 1.63626112e-02f, -1.44034490e-01f, 7.81099647e-02f, 2.82600299e-02f,
  -2.22225916e-02f, 6.28471300e-02f, 1.47455307e-02f, 5.07357297e-03f, -1.24934614e-01f, 4.82026264e-02f, 9.64457402e-04f, -9.42512602e-03f, -4.50078957e-02f, -2.20402982e-02f,
  -1.44828439e-01f, 1.60487652e-01f, 6.29206300e-02f, -2.82065123e-02f, 3.71556692e-02f, -5.04807457e-02f, -8.41521695e-02f, -1.22928293e-02f, -8.05973783e-02f, -1.56306997e-02f,
  -4.44294214e-02f, -1.10014072e-02f, -1.00893334e-01f, 1.86179932e-02f, 2.09057748e-01f, 8.89685005e-02f, -4.49117832e-02f, 7.46579245e-02f, -1.20136522e-01f, -5.01697920e-02f,
  -1.63762316e-01f, 1.72943607e-01f, 3.01580876e-01f, 1.79836467e-01f, 2.70035788e-02f, 2.48770520e-01f, 1.06521726e-01f, 5.32934070e-02f, 2.32596725e-01f, 1.18416056e-01f,
  -4.29020643e-01f, -6.98030144e-02f, 1.56571090e-01f, -1.75060630e-01f, -7.42710233e-02f, -3.86829413e-02f, -1.15899086e-01f, -2.61347413e-01f, -1.38868466e-01f, -8.11174288e-02f,
  2.36790795e-02f, 6.31471723e-02f, -5.05498350e-02f, -6.66815508e-03f, -2.00539064e-02f, 8.57490897e-02f, 7.75622204e-02f, 1.40810430e-01f, 4.59655784e-02f, -5.84561564e-02f,
  5.91536649e-02f, -2.52902582e-02f, 8.21142457e-04f, 6.48191422e-02f, 1.19162090e-02f, 1.18911728e-01f, 6.13092817e-03f, -2.29585823e-03f, 1.54813394e-01f, -1.98469721e-02f,
  -7.58013595e-03f, -3.37955296e-01f, -3.04912906e-02f, 6.34536743e-02f, 9.43534002e-02f, -8.91098678e-02f, -1.02417126e-01f, 3.93459126e-02f, 9.31049988e-04f, -1.05823420e-01f,
  4.82736230e-02f, -4.49803397e-02f, -1.05731674e-02f, 1.14182578e-02f, -3.47250402e-02f, -3.51791866e-02f, -7.37704188e-02f, 2.06828350e-03f, 9.55999196e-02f, -2.05679890e-02f,
  3.65580083e-03f, 5.78360958e-03f, -1.53729513e-01f, 2.69307401e-02f, 1.08794970e-02f, 2.01550685e-02f, -1.33371651e-01f, -1.08513460e-01f, 2.53267046e-02f, -2.23985046e-01f,
  7.65958428e-03f, 6.77791461e-02f, -3.76975238e-02f, -5.90168126e-02f, 1.34652434e-02f, 5.09843864e-02f, -3.97147648e-02f, -4.64328602e-02f, -3.11896969e-02f, 6.33546636e-02f,
  -3.73403318e-02f, 1.07904859e-02f, 2.05412377e-02f, 1.04847625e-02f, 4.96699773e-02f, 2.12924872e-02f, 8.21840912e-02f, -5.58685996e-02f, 9.24607590e-02f, 1.44961625e-02f,
  -2.45359484e-02f, -5.54221794e-02f, -6.42068638e-03f, 5.23312390e-02f, 6.66801929e-02f, 1.32005617e-01f, -2.41415575e-02f, -1.42949633e-02f, 3.92658450e-02f, -7.58604556e-02f,
  -1.99310884e-01f, 2.64681339e-01f, -5.23635373e-02f, -1.48334950e-01f, -3.26571390e-02f, 1.15454160e-01f, 2.92671248e-02f, -2.68794503e-02f, 2.30621939e-04f, -7.30780140e-02f,
  -4.82645780e-02f, -6.90072924e-02f, -7.39322677e-02f, 3.11203636e-02f, -1.95545536e-02f, -8.73235166e-02f, -2.84851119e-02f, 2.65257042e-02f, 7.05453306e-02f, -6.63999468e-02f,
  -4.98646796e-02f, -1.54040977e-01f, -1.24858208e-01f, -6.12292066e-02f, -8.16209465e-02f, -1.13170736e-01f, -4.21154983e-02f, -1.03852682e-01f, -4.73109670e-02f, -2.01180935e-01f,
  -4.26735103e-01f, -4.75929826e-01f, 4.32513170e-02f, -3.28777432e-01f, -1.16011515e-01f, -1.05874818e-02f, -2.60326803e-01f, 2.16912525e-03f, -8.06188509e-02f, -3.31157357e-01f,
  -7.90060014e-02f, -8.27753097e-02f, -5.40856943e-02f, 1.09459519e-01f, 2.48539969e-02f, -2.46035069e-01f, -1.43736407e-01f, 1.30370677e-01f, 2.84514695e-01f, -3.95686086e-03f,
  -2.20573358e-02f, -9.33867693e-02f, 2.60241348e-02f, 1.33553892e-01f, -2.02521846e-01f, -3.24402973e-02f, -1.83704626e-02f, -1.43557861e-01f, -9.15122498e-03f, -3.38777870e-01f,
  -1.48882255e-01f, -1.77292615e-01f, 1.98565200e-01f, -1.83322597e-02f, -8.54622200e-03f, -7.26360530e-02f, -2.41199955e-02f, 2.30637267e-02f, -4.72834706e-02f, -6.42049387e-02f,
  1.81866456e-02f, 5.85367568e-02f, -1.12703957e-01f, 4.11882997e-02f, -6.75586760e-02f, 1.25675099e-02f, 2.54366052e-04f, 1.64795831e-01f, 7.72629231e-02f, -3.11074778e-03f,
  -1.02713831e-01f, -2.10573062e-01f, -1.50423825e-01f, 2.98574977e-02f, -2.46905331e-02f, 9.86251384e-02f, -7.21479356e-02f, 2.83614676e-02f, 1.04130954e-01f, -1.94268361e-01f,
  9.14417300e-03f, -4.63186167e-02f, 6.22702800e-02f, 6.18397482e-02f, -8.01184550e-02f, 3.69926170e-02f, -2.99463533e-02f, 3.52424458e-02f, 6.52020052e-02f, -6.25203997e-02f,
  1.08294167e-01f, -1.09604723e-03f, -5.97096188e-03f, -2.11251415e-02f, -4.62962501e-02f, 6.29369840e-02f, -4.68863323e-02f, -1.22833187e-02f, 5.50564155e-02f, -6.63590208e-02f,
  1.99711174e-02f, 2.24883188e-04f, -3.41246813e-03f, 8.49395245e-02f, 2.35717986e-02f, -2.54368335e-02f, 3.07212342e-02f, -3.17168906e-02f, 1.03806918e-02f, -6.36283755e-02f,
  -5.79444952e-02f, 3.18728149e-01f, -1.69066221e-01f, -9.26352665e-02f, -1.10730805e-01f, 5.42129092e-02f, -7.96409547e-02f, 4.69407402e-02f, 1.38047347e-02f, -1.46318541e-03f,
  4.45917528e-03f, -5.52752502e-02f, -1.38472915e-01f, 6.24875724e-02f, 3.41101550e-05f, -5.73098436e-02f, -7.70197362e-02f, -5.15814833e-02f, 1.21904435e-02f, 2.73903888e-02f,
  -2.93857288e-02f, -2.46352300e-01f, -2.15857670e-01f, -1.02489211e-01f, -1.38583019e-01f, -1.17340893e-01f, -7.69568086e-02f, -1.36818245e-01f, -1.65494338e-01f, -3.58142227e-01f,
  -3.06802183e-01f, -3.53561714e-02f, -2.94846967e-02f, 1.47272915e-01f, 2.49868017e-02f, -1.17612313e-02f, 2.07159221e-02f, 1.50528252e-02f, -6.26623109e-02f, -1.15748189e-01f,
  -7.49948546e-02f, 1.96586028e-02f, 1.38039425e-01f, 7.49188364e-02f, 1.13464907e-01f, 1.64946318e-01f, 1.75312340e-01f, 1.56196967e-01f, 9.59937423e-02f, -4.67879623e-02f,
  4.19710651e-02f, 1.02412730e-01f, 5.37663512e-02f, -2.82865930e-02f, 2.18127808e-03f, 1.08807713e-01f, 2.67972052e-02f, 1.02575317e-01f, 1.48186544e-02f, 2.37416372e-01f,
  -1.78208232e-01f, -1.46511212e-01f, 1.06334873e-01f, -2.78818775e-02f, -9.88810360e-02f, -1.06459178e-01f, 3.15368325e-02f, -1.98916793e-02f, 4.23532724e-02f, -8.33015144e-02f,
  -5.65002300e-02f, -7.89048150e-02f, -6.37339205e-02f, -9.07657146e-02f, -1.22496955e-01f, 1.97483189e-02f, -3.08070295e-02f, -5.08393273e-02f, -1.20764561e-02f, -1.56832799e-01f,
  9.46561620e-02f, 3.28791551e-02f, -1.97165366e-02f, -9.63917226e-02f, -3.64565849e-02f, -7.05670565e-02f, -6.03776723e-02f, -7.61911422e-02f, -1.35209590e-01f, -8.25597495e-02f,
  -2.95198057e-02f, -4.49113883e-02f, 4.38582636e-02f, 2.21632756e-02f, 1.01751070e-02f, -6.07401431e-02f, 1.19090125e-01f, 9.26548094e-02f, 5.00061512e-02f, 3.08238622e-02f,
  4.31441553e-02f, -8.16870073e-04f, -4.21657823e-02f, 6.91512451e-02f, 3.81415859e-02f, -3.69292684e-02f, 4.92017120e-02f, 6.41232952e-02f, -5.78503348e-02f, -1.02464683e-01f,
  -3.40213962e-02f, -3.13175507e-02f, -4.69400734e-02f, 5.59477396e-02f, 6.83487430e-02f, 5.65903485e-02f, -6.07280731e-02f, 3.11701950e-02f, 1.41894072e-02f, -3.83949652e-02f,
  -1.60305738e-01f, 5.70426695e-02f, -5.21832593e-02f, 2.89972760e-02f, 3.80091816e-02f, -4.53228084e-03f, -7.63594508e-02f, -6.81904331e-02f, -6.76521063e-02f, -4.08597477e-02f,
  -1.82299103e-04f, -9.46592167e-02f, -2.61206608e-02f, -3.06162219e-02f, -5.19319028e-02f, -8.07433128e-02f, -4.77321446e-03f, 4.82661556e-03f, 9.89956502e-03f, -1.62443772e-01f,
  7.18697309e-02f, -5.89776784e-02f, -7.34492615e-02f, 1.63661335e-02f, -4.82689217e-03f, -8.63446966e-02f, -1.33088872e-01f, -2.12825872e-02f, -1.00780651e-01f, -1.15381628e-01f,
  4.27224517e-01f, 4.12692353e-02f, -1.14110291e-01f, 1.88313708e-01f, -7.79001787e-02f, -3.53312135e-01f, -3.61432731e-01f, -3.30962956e-01f, -2.65330970e-02f, 1.44866303e-01f,
  2.07086280e-01f, 3.24756980e-01f, 1.43812090e-01f, 1.08875021e-01f, -1.53907746e-01f, -1.67972952e-01f, 5.04309824e-03f, 8.41302946e-02f, 4.89680246e-02f, 9.86053944e-02f,
  2.80720532e-01f, 2.22421929e-01f, 2.95834661e-01f, 1.20215021e-01f, 1.63686320e-01f, 1.99638218e-01f, 6.37144893e-02f, 1.02493875e-01f, 2.07563058e-01f, 2.97234088e-01f,
  2.67108470e-01f, -1.45807520e-01f, -2.46929331e-03f, 2.14794800e-01f, 1.07015304e-01f, 9.48274806e-02f, 2.89183259e-02f, -5.19828759e-02f, 1.24430107e-02f, 3.52043435e-02f,
  1.47747040e-01f, 5.54970540e-02f, -4.92536984e-02f, -3.35431993e-02f, 2.24280301e-02f, -9.39478446e-03f, 1.82117671e-02f, -1.28360301e-01f, -7.23417103e-02f, 5.21194749e-02f,
  1.05958492e-01f, 1.06161572e-01f, -1.22267298e-01f, -1.80461884e-01f, -1.74297631e-01f, 1.49914667e-01f, -1.14061773e-01f, -1.05047682e-02f, -2.14956641e-01f, 9.19217942e-04f,
  5.97928092e-02f, -1.59003157e-02f, 7.62224719e-02f, 4.18033227e-02f, 4.40532975e-02f, -3.20634283e-02f, 2.84366421e-02f, 4.78328615e-02f, -4.81668748e-02f, 5.13130799e-04f,
  -6.92133307e-02f, 5.75407669e-02f, -9.27889440e-03f, -6.47422671e-02f, 1.01702861e-01f, 4.90533561e-02f, 4.95677367e-02f, -4.12037000e-02f, 5.52587360e-02f, -1.46618774e-02f,
  1.83282811e-02f, -1.09894741e-02f, 9.08141062e-02f, -4.45321389e-02f, 1.77602526e-02f, 3.09687126e-02f, 1.04277931e-01f, 5.76251857e-02f, 8.06983635e-02f, 2.66534407e-02f,
  -3.78784537e-02f, -1.65178046e-01f, 8.14721733e-02f, 7.50834495e-03f, 2.35079378e-02f, -2.62802579e-02f, 2.48067752e-02f, 5.82321025e-02f, 4.05701138e-02f, -3.42420191e-02f,
  -7.20262527e-02f, -4.46709171e-02f, -1.94108915e-02f, -1.80717651e-02f, -4.61229086e-02f, -1.29263803e-01f, -3.42980330e-03f, 8.37232471e-02f, -1.16573945e-02f, -8.50317031e-02f,
  -7.54322633e-02f, -1.00117229e-01f, -1.08707584e-01f, -2.32327014e-01f, -1.41039938e-01f, 7.44004771e-02f, -3.83512825e-02f, -1.72855496e-01f, -2.28275999e-01f, -1.01364091e-01f,
  -2.31569767e-01f, 3.24686140e-01f, 1.15027197e-01f, -8.17763731e-02f, 3.04216295e-01f, 3.62037122e-01f, 5.21477282e-01f, 6.56903610e-02f, -4.51112390e-02f, 1.65543944e-01f,
  4.09084201e-01f, -1.50157313e-03f, 1.03994966e-01f, 8.18472356e-02f, -4.27680053e-02f, 1.24350518e-01f, -3.80331576e-02f, -1.77360281e-01f, -1.77668080e-01f, -3.62956114e-02f,
  8.20315555e-02f, -3.84194702e-02f, -2.50407279e-01f, -1.98771775e-01f, -2.82095950e-02f, -4.11522109e-03f, 7.80118480e-02f, 5.70320413e-02f, 2.47911975e-01f, 1.94090756e-03f,
  2.38015652e-01f, 1.79248571e-01f, -2.01106325e-01f, -9.32201520e-02f, 9.99946743e-02f, -1.91706732e-01f, 4.30351235e-02f, -1.58965439e-01f, 1.43732121e-02f, -5.22387289e-02f,
  1.00401185e-01f, 7.65786916e-02f, 4.30845916e-02f, -1.23673249e-02f, -6.12879880e-02f, -5.41487848e-03f, -1.74395606e-01f, -2.61288494e-01f, -1.61451384e-01f, -5.35934903e-02f,
  1.71781927e-01f, 1.06521159e-01f, 1.26189813e-02f, 6.36382774e-02f, -1.24225497e-01f, -4.75555956e-02f, -3.28061879e-02f, -2.91956738e-02f, -1.58994237e-03f, -2.24905252e-01f,
  2.88838651e-02f, 7.98945799e-02f, 2.84582525e-02f, -8.12007766e-03f, 5.68282465e-03f, -5.69162890e-02f, -1.60663761e-02f, 8.45813602e-02f, -9.78190568e-04f, -5.91977946e-02f,
  1.10596335e-02f, 1.82221439e-02f, -3.74484658e-02f, -2.46408060e-02f, -5.34154139e-02f, 3.79396677e-02f, 5.62826954e-02f, 1.70317274e-02f, -4.24244478e-02f, -4.33269478e-02f,
  -8.02555233e-02f, -8.44902173e-02f, -7.45966658e-02f, -5.68712167e-02f, 3.47357579e-02f, -6.73613548e-02f, -4.52832580e-02f, 4.14222628e-02f, -5.85815497e-02f, 1.35788629e-02f,
  -1.73172355e-01f, 2.54113734e-01f, -1.11609645e-01f, -1.66062161e-01f, 2.75782160e-02f, 5.27878711e-03f, 1.44508928e-02f, 3.79440486e-02f, 6.57161325e-02f, -2.54317764e-02f,
  8.06167498e-02f, -1.34830698e-01f, 1.01825800e-02f, -7.10125789e-02f, -6.62226900e-02f, -2.60316785e-02f, 2.03785021e-02f, -8.77120048e-02f, -5.04367612e-02f, -1.83035191e-02f,
  -1.11839123e-01f, -7.68611729e-02f, -1.77174523e-01f, -1.77352756e-01f, -1.36465460e-01f, -1.66766301e-01f, -4.11747955e-02f, -2.15344071e-01f, -1.32898870e-03f, -2.36585632e-01f,
  -1.73472226e-01f, -8.92009214e-02f, 8.82708002e-03f, -1.80690169e-01f, -3.85234319e-02f, -8.66704881e-02f, 1.10762632e-02f, -1.21991463e-01f, -1.81887820e-01f, -7.57698566e-02f,
  9.17686336e-03f, 8.19086134e-02f, -1.94803625e-02f, -1.04446206e-02f, -1.31521150e-01f, -3.90832201e-02f, -9.71802324e-02f, -1.86645538e-01f, 5.16872406e-02f, 3.14576142e-02f,
  8.21792148e-03f, -8.66234601e-02f, -1.82923719e-01f, -1.50297433e-01f, -1.27042113e-02f, 7.61892721e-02f, 4.17918190e-02f, 1.47957457e-02f, -5.57761919e-03f, 4.24968451e-02f,
  3.69302183e-01f, 1.01077596e-04f, 1.83047634e-03f, -9.19975564e-02f, -5.90856038e-02f, -3.49134579e-02f, 2.02942342e-02f, 3.35587375e-03f, 2.12476421e-02f, 4.26696688e-02f,
  5.22342771e-02f, -9.36269574e-03f, 2.85508614e-02f, 8.46808478e-02f, -3.64406966e-02f, -2.49922834e-02f, 5.01288217e-04f, -7.01941401e-02f, -6.68985471e-02f, 3.78813669e-02f,
  -2.50998099e-04f, -3.81081179e-02f, 2.77793035e-02f, 9.14620757e-02f, 1.27115706e-02f, -3.36170979e-02f, 1.87568039e-01f, 1.18206285e-01f, 6.72161952e-02f, 1.04720786e-01f,
  -1.49898855e-02f, -9.22865048e-02f, -6.02643341e-02f, 3.04652601e-02f, -6.13674745e-02f, -7.00864121e-02f, 3.91883701e-02f, 1.21351052e-02f, 2.43938132e-03f, -5.77621348e-02f,
  2.92359125e-02f, 3.15753929e-02f, -2.20246315e-02f, -1.68788619e-02f, 6.64244965e-02f, 8.74085426e-02f, 4.27255221e-02f, -5.95066175e-02f, 6.75018877e-02f, 2.61198748e-02f,
  -3.55983563e-02f, 9.30108428e-02f, -7.61632696e-02f, 9.33468267e-02f, 4.03384566e-02f, 2.77722776e-02f, 8.28139111e-03f, -3.80230024e-02f, -5.00556566e-02f, -1.24500327e-01f,
  2.29206875e-01f, -1.46497503e-01f, 4.39461432e-02f, -1.04030058e-01f, -1.25973718e-02f, 4.80258465e-02f, -3.80028188e-02f, -1.16350003e-01f, -1.27248541e-02f, 5.93299568e-02f,
  5.94196189e-03f, 3.24281789e-02f, 2.79517006e-02f, -2.62231342e-02f, -5.42087369e-02f, 7.76130185e-02f, -1.48843721e-01f, 5.43285757e-02f, -7.40550980e-02f, -2.58707106e-02f,
  1.99849792e-02f, -2.32391134e-02f, -4.05249633e-02f, 8.03894624e-02f, 7.51405060e-02f, -6.88137263e-02f, 2.11894125e-01f, 1.20761536e-01f, 3.37544247e-03f, -4.95758243e-02f,
  -2.97796637e-01f, -2.14792818e-01f, -3.56796712e-01f, -2.67294109e-01f, -5.92860510e-04f, 1.19127408e-01f, 8.84228423e-02f, -1.30143128e-02f, -2.18497515e-02f, -8.19495618e-02f,
  -7.13104531e-02f, -9.67874452e-02f, -1.41830713e-01f, -8.59064683e-02f, -1.26803577e-01f, -8.66286531e-02f, -2.04736233e-01f, -3.96938860e-01f, -2.44649380e-01f, 2.67183539e-02f,
  -2.02304646e-01f, -2.07660824e-01f, -3.29891205e-01f, -2.63176650e-01f, -1.78395689e-01f, -2.98107326e-01f, -3.98550898e-01f, -2.76097357e-01f, -1.51370153e-01f, -4.25768971e-01f,
  -2.84568638e-01f, -5.67760901e-04f, 1.34365205e-02f, 3.21613625e-03f, -3.39937136e-02f, 2.24836823e-02f, -6.84922189e-02f, 1.07765105e-02f, -5.96537180e-02f, 5.42739779e-02f,
  -7.24038556e-02f, 2.86358166e-02f, 3.48686837e-02f, -2.50355452e-02f, 3.00959777e-02f, 6.51816428e-02f, 5.93147017e-02f, -5.30050546e-02f, -8.58595818e-02f, 2.40743384e-02f,
  2.54532192e-02f, 1.23740099e-02f, -8.74738097e-02f, 4.44138683e-02f, -2.93851662e-02f, -1.39069363e-01f, -9.38098431e-02f, -4.80726771e-02f, -3.79244275e-02f, -1.78955868e-01f,
  4.59005982e-02f, 6.21694140e-02f, 5.52237630e-02f, 5.73936775e-02f, 1.78020280e-02f, -1.95839293e-02f, -2.82618143e-02f, -9.61837098e-02f, 6.86568627e-03f, 5.12477010e-03f,
  -7.22898766e-02f, 4.59378548e-02f, -3.47400457e-02f, 1.86282618e-03f, -2.10642889e-02f, -5.69337122e-02f, 2.98175421e-02f, 7.43894186e-03f, -1.44870728e-01f, -1.04442537e-01f,
  1.48426639e-02f, -4.20831740e-02f, 8.04492924e-03f, 3.62337194e-02f, -8.90781078e-03f, 5.03038242e-02f, -3.87244928e-03f, 1.04764685e-01f, 7.59856701e-02f, 1.03308991e-01f,
  -2.11172834e-01f, -6.33607209e-02f, -7.33450660e-03f, 2.57289652e-02f, -9.22960788e-02f, -4.21164976e-03f, -1.09309837e-01f, 6.33592159e-02f, -2.92892624e-02f, 1.49534903e-02f,
  3.72188538e-02f, -3.89048271e-02f, -9.01459605e-02f, 6.86155930e-02f, 8.90547689e-03f, 2.72373911e-02f, -9.06261951e-02f, -1.52601108e-01f, -6.18240349e-02f, 9.53716189e-02f,
  -5.59439249e-02f, -1.22554190e-01f, -2.06760496e-01f, -1.08804926e-01f, -3.71751934e-02f, -1.90749213e-01f, -2.16710180e-01f, -3.46626788e-02f, -1.92493677e-01f, -2.30968118e-01f,
  -2.60203481e-01f, 1.19181368e-02f, 8.09427872e-02f, 2.15896592e-02f, 5.71380593e-02f, -2.42119417e-01f, -2.11081371e-01f, -1.85134500e-01f, -1.17403775e-01f, -1.27924629e-03f,
  1.81736052e-01f, 1.82016566e-01f, 1.04688257e-01f, -2.95506250e-02f, -2.47192249e-01f, -1.02230385e-01f, -3.99698578e-02f, -1.26229972e-01f, -3.21837842e-01f, -2.95299619e-01f,
  -7.45199919e-02f, -3.20070870e-02f, -2.09175736e-01f, -9.16691869e-02f, 9.40376446e-02f, 1.39534652e-01f, 1.78372145e-01f, -3.71411890e-02f, 2.44863909e-02f, 9.12714526e-02f,
  3.59627217e-01f, -3.26439589e-02f, -1.11331739e-01f, -4.27323803e-02f, 2.46868040e-02f, -5.53975888e-02f, -3.17333080e-02f, -4.03151400e-02f, -7.09951371e-02f, 5.65085895e-02f,
  1.20900735e-01f, -1.83550194e-02f, 1.16820246e-01f, -4.54174280e-02f, -4.03409079e-02f, -8.49276707e-02f, -1.34210899e-01f, -5.80397062e-02f, -3.04211434e-02f, -5.44523634e-03f,
  6.69955462e-02f, -9.67000797e-02f, 9.32746753e-03f, -6.03171624e-02f, -4.13151234e-02f, 7.90583789e-02f, -1.47692421e-02f, -3.51946130e-02f, -4.96560056e-03f, -5.59070185e-02f,
  -9.98520404e-02f, 9.88820102e-03f, -2.32996698e-02f, -1.20473718e-02f, -3.74311246e-02f, 1.14433676e-01f, 1.47454115e-02f, -4.09760065e-02f, 2.81077400e-02f, 4.39267838e-03f,
  -5.28063439e-02f, -4.07052832e-03f, -9.07994621e-03f, -1.10621396e-02f, 3.68053722e-03f, -1.13516741e-01f, -1.02617545e-02f, -1.33954972e-01f, -1.17691830e-01f, -5.98291494e-02f,
  -5.69199445e-03f, 6.77930564e-02f, 5.61643131e-02f, 2.48108129e-03f, 3.25295627e-02f, -4.54659648e-02f, -2.72795428e-02f, -4.87968437e-02f, 3.70816626e-02f, 1.63273811e-02f,
  2.82834351e-01f, -2.40718141e-01f, 4.14100699e-02f, -3.93592566e-02f, 5.29564805e-02f, -2.36697625e-02f, 9.03395042e-02f, -9.05704796e-02f, -2.79745907e-02f, 4.99258973e-02f,
  -4.00990061e-02f, -6.68387711e-02f, 9.11177993e-02f, 3.51805650e-02f, -1.00621559e-01f, -8.49849507e-02f, -1.14717260e-01f, 4.33079451e-02f, -2.04501122e-01f, -4.84548993e-02f,
  -2.71965377e-02f, -1.59504816e-01f, -1.07639998e-01f, -9.81991086e-03f, 3.52790467e-02f, 8.91134366e-02f, 3.35597321e-02f, 1.45668229e-02f, -8.55482221e-02f, -1.33741274e-02f,
  1.31924585e-01f, -1.76439911e-01f, -7.20774591e-01f, -3.51868898e-01f, -2.59408742e-01f, -1.77623212e-01f, -1.39937490e-01f, 5.12132309e-02f, -1.32598400e-01f, -2.36022055e-01f,
  -4.71992791e-02f, 2.23468170e-02f, -4.32027727e-02f, 3.25875729e-02f, 1.04168184e-01f, -2.37146586e-01f, -3.50515217e-01f, -1.87402114e-01f, -8.81978124e-02f, 7.03352615e-02f,
  1.02299765e-01f, -1.45100296e-01f, 1.03936836e-01f, -3.17805298e-02f, -1.72138497e-01f, -1.33557379e-01f, -4.15573806e-01f, -1.96687445e-01f, -1.78231418e-01f, -3.49077642e-01f,
  -5.35097182e-01f, -5.51966354e-02f, -1.27993785e-02f, 1.77966058e-01f, -1.15549140e-01f, 7.78795965e-03f, -8.49311948e-02f, -9.50249881e-02f, 5.57708032e-02f, -5.87210245e-02f,
  -3.39448405e-03f, 1.35886332e-03f, 1.68347228e-02f, -5.15583493e-02f, -1.32201210e-01f, 5.19613586e-02f, -9.20497812e-03f, -3.77094969e-02f, -8.87280926e-02f, 3.56314741e-02f,
  4.12987210e-02f, 7.08523020e-03f, -4.74935956e-02f, 4.68365736e-02f, 1.32269030e-02f, -4.44926359e-02f, -8.75026882e-02f, 3.09298262e-02f, -5.08688912e-02f, 4.75328974e-03f,
  -9.93933529e-03f, -5.18068112e-02f, -7.38938600e-02f, 6.02998445e-03f, 2.04026792e-02f, -8.70804861e-03f, -4.31838632e-02f, 6.18636161e-02f, 6.25929981e-02f, -7.17166392e-03f,
  -3.24820094e-02f, -4.37070243e-02f, 7.12152272e-02f, -2.81002559e-02f, 1.29877897e-02f, -4.11904268e-02f, 8.42605680e-02f, -1.33121461e-02f, 1.64536964e-02f, 9.06936452e-03f,
  4.19872254e-02f, -2.47393660e-02f, -9.33914855e-02f, 5.96623980e-02f, -1.81338806e-02f, -1.16606094e-02f, 8.33112821e-02f, 3.31865288e-02f, -1.45878736e-02f, 6.55208621e-03f,
  -1.43333673e-01f, 1.53468758e-01f, -4.15997431e-02f, 1.88464165e-01f, -1.85897097e-01f, -5.49038984e-02f, 1.85249541e-02f, -2.47286836e-04f, -3.55605148e-02f, 4.70638536e-02f,
  -5.54716680e-03f, -2.24709325e-02f, 2.25830780e-04f, -3.22431140e-03f, -6.59998059e-02f, -3.03938814e-05f, 4.22718786e-02f, -5.55289574e-02f, -1.72031729e-03f, -8.60971138e-02f,
  4.16654572e-02f, 1.05120502e-01f, 1.96585774e-01f, -3.48589979e-02f, 8.79422482e-03f, 1.51359513e-01f, -8.69060755e-02f, 1.74712315e-02f, 1.00143671e-01f, 1.51126593e-01f,
  -6.08755887e-01f, 3.09189986e-02f, -1.29353553e-01f, -1.36152893e-01f, 2.47746091e-02f, 2.13330597e-01f, 2.67271668e-01f, 1.56409696e-01f, -4.07255776e-02f, 6.90483749e-02f,
  2.14260984e-02f, -8.50104541e-02f, -2.17911527e-02f, 1.32916376e-01f, 7.17065558e-02f, 2.90921658e-01f, 2.01355502e-01f, 7.30934963e-02f, 3.69953774e-02f, -7.13590235e-02f,
  1.36982873e-01f, -9.42243189e-02f, -1.44351318e-01f, -2.29590572e-02f, -9.47556272e-02f, 7.05082566e-02f, 1.26419719e-02f, -3.74803133e-02f, 7.04372600e-02f, -8.57070740e-03f,
  -2.34802321e-01f, -2.79376745e-01f, 5.68798482e-02f, -1.13995247e-01f, -4.03304510e-02f, -7.76244253e-02f, -1.66850770e-03f, -1.23600684e-01f, -3.42337452e-02f, 4.74341260e-03f,
  -7.32703507e-02f, -1.00990489e-01f, -6.58280775e-02f, -8.25058967e-02f, -8.87045115e-02f, -1.02591410e-01f, 2.57697795e-02f, -7.35925287e-02f, -3.34514566e-02f, 2.36408096e-02f,
  3.47656547e-03f, -1.45207733e-01f, -1.84204563e-01f, 1.74324159e-02f, 3.62248123e-02f, -8.68358910e-02f, -1.76630303e-01f, -1.06487393e-01f, -8.85508507e-02f, -2.07315817e-01f,
  2.88522132e-02f, -4.22932357e-02f, -2.56790165e-02f, 2.82844920e-02f, -2.30480060e-02f, -3.09285484e-02f, 3.76889408e-02f, 3.26641947e-02f, -2.74880230e-02f, -3.93399363e-03f,
  4.11535464e-02f, -6.21335916e-02f, -4.82203998e-02f, 5.60353277e-03f, -7.04110712e-02f, -1.46693597e-02f, 3.79225016e-02f, -7.51360692e-03f, 4.13809754e-02f, 6.49779737e-02f,
  4.11641113e-02f, 7.69705623e-02f, -8.29012915e-02f, 6.02309480e-02f, 8.43743309e-02f, 2.78800372e-02f, 3.22103761e-02f, 5.92315122e-02f, 2.24005990e-02f, 6.20154962e-02f,
  -2.27471948e-01f, 2.32074052e-01f, -3.30393016e-03f, -9.76580530e-02f, -2.50953846e-02f, -5.79672009e-02f, -5.07595502e-02f, -2.39940099e-02f, -1.21318512e-02f, -2.93683801e-02f,
  -9.12075043e-02f, 4.28530201e-03f, -7.44215697e-02f, 5.10370322e-02f, 1.05521018e-02f, -6.66826591e-02f, 4.19515669e-02f, 5.94019443e-02f, -2.14708112e-02f, -1.11070886e-01f,
  -4.78863977e-02f, -5.19169681e-03f, -1.49048299e-01f, -6.14720099e-02f, -1.00386068e-01f, -6.07643835e-02f, -1.16630167e-01f, -1.52578028e-02f, -1.00862861e-01f, 4.48493659e-03f,
  -1.18529148e-01f, -2.10323378e-01f, 9.20448601e-02f, 4.10473868e-02f, -2.90624890e-03f, 2.39664204e-02f, -5.53992912e-02f, 1.04236096e-01f, 5.53196594e-02f, -1.99391432e-02f,
  5.05577587e-02f, 2.07097605e-01f, 2.38398701e-01f, 2.15135485e-01f, 2.72482723e-01f, 1.10098623e-01f, 6.87278807e-02f, 2.15201050e-01f, 1.74469739e-01f, -1.08485036e-01f,
  -4.54864316e-02f, -1.33387893e-01f, -5.82249388e-02f, -1.11585893e-02f, -1.53629735e-01f, 1.25448450e-01f, -6.59817383e-02f, -2.46598246e-03f, -6.03887960e-02f, -5.33466563e-02f,
  -1.52809665e-01f, -1.21221997e-01f, 5.78472354e-02f, 1.26130149e-01f, -2.71177292e-02f, -3.20498869e-02f, -3.63672525e-02f, -6.51133731e-02f, -7.04677925e-02f, -5.84622324e-02f,
  1.49085755e-02f, -1.16265379e-02f, -6.83569387e-02f, -3.38329263e-02f, -9.38649923e-02f, -3.35504487e-02f, -7.47877285e-02f, 1.44376799e-01f, 3.12746204e-02f, 7.76463822e-02f,
  4.74645421e-02f, -7.53393918e-02f, -8.01722556e-02f, 4.84305322e-02f, 6.51130602e-02f, 1.74137130e-01f, 9.59561300e-03f, -7.51059279e-02f, 1.18694961e-01f, -1.16727352e-01f,
  -9.86841135e-03f, 8.78473669e-02f, 1.24316171e-01f, 6.46247435e-03f, 1.99785549e-02f, 6.09132722e-02f, 3.92305031e-02f, -7.79276341e-02f, 5.71713150e-02f, -4.74212430e-02f,
  7.43605718e-02f, 1.88436341e-02f, 6.48428947e-02f, 2.84783207e-02f, 3.35271619e-02f, 2.48148479e-02f, 3.42069194e-02f, 8.60390719e-03f, 3.19630429e-02f, 6.85418583e-03f,
  4.55315746e-02f, 3.76851903e-03f, 4.18520309e-02f, -1.65987946e-02f, -4.21255901e-02f, 2.11177021e-02f, -1.58673469e-02f, -9.39760953e-02f, -4.59366129e-04f, -2.55841445e-02f,
  -7.14271814e-02f, 2.12137237e-01f, 6.68664873e-02f, 4.08591330e-02f, -3.36553231e-02f, 1.67414844e-02f, 1.85420197e-02f, -1.30649999e-01f, -1.36532113e-01f, -1.86087154e-02f,
  -3.64789180e-02f, -3.53636518e-02f, 2.00405344e-02f, -7.60064051e-02f, -1.45092711e-01f, -8.89002755e-02f, -1.18245713e-01f, 1.46307155e-01f, 7.97733366e-02f, -3.57829146e-02f,
  3.51530798e-02f, 1.07891602e-03f, 2.23722906e-04f, 1.72384664e-01f, 1.91571619e-02f, 1.27775356e-01f, 3.04040816e-02f, -1.90297477e-02f, 2.96297744e-02f, 4.98106144e-03f,
  1.71802923e-01f, 1.37325302e-01f, -3.38305175e-01f, 7.95713291e-02f, -6.68069646e-02f, -3.27916220e-02f, 4.78492007e-02f, 4.19726148e-02f, 4.61909361e-02f, 1.40108392e-01f,
  -1.35720046e-02f, -1.49130612e-03f, 5.28242067e-02f, -9.45946798e-02f, -4.39579459e-03f, 8.48627016e-02f, 4.43788208e-02f, -6.05902076e-02f, 4.29115165e-03f, -6.13222755e-02f,
  7.11384639e-02f, 7.31536672e-02f, 9.74964797e-02f, 1.72518417e-02f, -1.29539713e-01f, -9.26568210e-02f, -1.06475428e-01f, -1.26645550e-01f, -7.07934722e-02f, -1.90108985e-01f,
  -7.39943013e-02f, -2.94096261e-01f, 3.09983045e-02f, 1.53833628e-02f, -1.71903923e-01f, -5.35921454e-02f, -1.33568466e-01f, -1.95684582e-01f, -8.09857845e-02f, -3.95803712e-02f,
  -7.80661255e-02f, -3.96801531e-02f, -1.86587080e-01f, -1.27724379e-01f, -7.86342658e-03f, -1.77844856e-02f, -5.16868345e-02f, -1.84385702e-01f, -1.13776855e-01f, -2.68937469e-01f,
  -1.60992190e-01f, -2.36904606e-01f, -1.20073497e-01f, -2.51580253e-02f, -1.62309825e-01f, -9.61295068e-02f, -1.03388421e-01f, -2.55559444e-01f, -1.61618426e-01f, 9.36260968e-02f,
  4.33042571e-02f, -5.53207025e-02f, -5.01460992e-02f, 8.37362483e-02f, 9.06653628e-02f, 2.02200767e-02f, -3.38220410e-02f, 1.03788428e-01f, 2.46468447e-02f, 1.10457793e-01f,
  1.28678987e-02f, 3.41632999e-02f, -2.37592496e-02f, 1.37030156e-02f, 2.24682279e-02f, -9.11205932e-02f, -1.18669551e-02f, 1.03800692e-01f, 2.13977750e-02f, 9.04495269e-02f,
  -7.37453531e-03f, -1.36771232e-01f, 1.02281449e-02f, -7.73020685e-02f, -1.16134420e-01f, 1.55418599e-02f, -7.03812614e-02f, -3.35775428e-02f, 1.54776750e-02f, -1.04000382e-02f,
  5.53621233e-01f, -1.39155731e-01f, 1.43252313e-01f, 2.70574763e-02f, -6.35354891e-02f, -3.44093405e-02f, 1.95461884e-02f, -8.20446908e-02f, -1.24284983e-01f, 4.35041748e-02f,
  -1.50764406e-01f, 4.35768068e-03f, -5.44031383e-04f, 2.35074032e-02f, 1.22138426e-01f, 3.14137712e-02f, 1.79833621e-01f, -8.24762210e-02f, -5.67348488e-02f, -1.01675512e-02f,
  6.78071603e-02f, 2.38413423e-01f, 3.66143346e-01f, 2.39624649e-01f, -3.51233184e-02f, 1.94622397e-01f, 1.65258154e-01f, 1.46823928e-01f, 9.33906659e-02f, 5.66744685e-01f,
  -1.40098989e-01f, -6.43259957e-02f, -3.24442387e-01f, 1.22927263e-01f, 2.03243479e-01f, 7.27556199e-02f, -1.19160891e-01f, 1.11269422e-01f, 2.09712759e-01f, 2.39867657e-01f,
  2.24246442e-01f, 3.01540434e-01f, 1.03715099e-01f, 1.30771160e-01f, -8.10213983e-02f, 3.44697386e-02f, -1.66869815e-02f, -1.66295320e-01f, -1.72215179e-01f, 8.88301432e-02f,
  8.99692401e-02f, 6.28974959e-02f, -1.04911188e-02f, 6.68563619e-02f, 2.20638096e-01f, 1.79205924e-01f, 7.89416954e-02f, 8.47438350e-02f, 9.10926014e-02f, 1.50686651e-01f,
  -2.24199578e-01f, -1.06932610e-01f, 4.59875949e-02f, 8.02485049e-02f, 6.04275279e-02f, -9.26357955e-02f, -8.33679810e-02f, -1.91780291e-02f, -5.39461989e-03f, 2.30723731e-02f,
  9.31477845e-02f, 9.55307707e-02f, 9.74837877e-03f, 5.28165251e-02f, -2.89705629e-03f, -6.29057810e-02f, -1.51477177e-02f, -1.99747682e-02f, -6.11961558e-02f, -5.09084463e-02f,
  6.81420490e-02f, -3.93261164e-02f, -6.07129782e-02f, 2.85937954e-02f, -8.81872103e-02f, 1.39088959e-01f, 3.00769731e-02f, 8.66157338e-02f, -8.23490918e-02f, 4.27809581e-02f,
  1.77746755e-03f, -7.17925802e-02f, 4.25464213e-02f, 3.50248627e-02f, 7.28651881e-02f, 5.68769760e-02f, 5.06118813e-04f, -8.14270135e-03f, -5.13896719e-03f, 5.87760024e-02f,
  1.21338600e-02f, 6.79213740e-03f, -1.95307862e-02f, -6.24604635e-02f, 1.96769964e-02f, 5.85065316e-03f, 5.17587923e-03f, -9.71757025e-02f, 4.88918610e-02f, 4.14228961e-02f,
  1.05533507e-02f, -7.15570822e-02f, -7.92750418e-02f, -7.26365447e-02f, 4.31036651e-02f, -3.36530246e-03f, 2.43623983e-02f, 8.43513757e-03f, 2.31736526e-02f, 5.89935258e-02f,
  2.15392902e-01f, -3.73904109e-02f, 1.25300944e-01f, -2.78233159e-02f, -4.14059982e-02f, 3.88376862e-02f, 1.12592228e-01f, -3.19941901e-02f, 2.02163458e-02f, 9.17646438e-02f,
  1.84799153e-02f, -6.27610832e-02f, 3.26065198e-02f, 3.23304124e-02f, -1.86051466e-02f, -8.05181488e-02f, 2.13720519e-02f, 6.10372759e-02f, 1.17447279e-01f, 7.58009031e-02f,
  5.02814725e-03f, -7.57707655e-02f, -3.01005784e-02f, 2.33798381e-02f, 9.95530561e-03f, 1.72262930e-03f, -9.48828831e-02f, -3.34738605e-02f, -1.24672242e-01f, -8.71494487e-02f,
  9.67475250e-02f, -4.06404674e-01f, 1.05381824e-01f, -7.85196573e-02f, -5.10926954e-02f, -2.03314528e-01f, -4.08446938e-01f, -2.47780904e-01f, -8.70926380e-02f, -2.74899036e-01f,
  -1.08973362e-01f, 2.63408273e-01f, 2.20298141e-01f, 1.97198465e-01f, 6.56182021e-02f, -1.01396292e-01f, -1.48123935e-01f, 1.97293848e-01f, 3.66772175e-01f, 5.05947173e-02f,
  -2.78592464e-02f, 7.14862794e-02f, 5.47174625e-02f, 5.76620288e-02f, -1.70316473e-01f, 3.30782421e-02f, -5.03859334e-02f, -6.49164021e-02f, -1.21423669e-01f, -2.74742186e-01f,
  8.64388049e-02f, -9.24949870e-02f, 1.97844118e-01f, -1.11981044e-02f, 7.98675045e-02f, 4.10188138e-02f, 3.47805629e-03f, 6.66045174e-02f, -8.10480490e-02f, -1.02561392e-01f,
  -1.28093234e-03f, 1.10285439e-01f, 1.23805210e-01f, -5.11611775e-02f, -3.56357847e-03f, -1.19301360e-02f, 1.32558658e-03f, 4.05266583e-02f, -1.03261964e-02f, -1.14281461e-01f,
  -9.91436690e-02f, -2.56337542e-02f, 1.55390352e-02f, 2.60491967e-02f, 9.53121558e-02f, 1.76682651e-01f, -1.07011035e-01f, -2.38738488e-02f, 1.03127830e-01f, -8.14614967e-02f,
  -8.80490169e-02f, 2.63197757e-02f, -2.89206672e-02f, 6.19481653e-02f, 4.65134252e-03f, -4.19610962e-02f, -2.89840996e-02f, -3.06512732e-02f, -3.39508476e-03f, -5.40653057e-03f,
  -4.52271961e-02f, 8.72851256e-03f, 4.14509103e-02f, -6.13765940e-02f, 7.01940060e-02f, 3.09468620e-02f, 5.76650873e-02f, -7.92440176e-02f, 1.06241414e-02f, 2.54393443e-02f,
  3.20347026e-02f, -1.93235725e-02f, 3.23452950e-02f, -3.71485315e-02f, -9.39852521e-02f, 6.47748820e-03f, -8.30611680e-03f, -3.72243375e-02f, 1.37334596e-02f, -2.66483165e-02f,
  2.94515621e-02f, 3.50326389e-01f, -8.34426433e-02f, 1.11966424e-01f, -8.24648738e-02f, -7.71540031e-02f, 4.45255004e-02f, -2.90186517e-02f, 7.80028403e-02f, -7.94704333e-02f,
  -2.85164807e-02f, 1.44563466e-01f, 5.94694074e-03f, -9.32784453e-02f, 1.25757098e-01f, 3.90626863e-03f, -1.40517414e-01f, 5.45158312e-02f, -7.34249828e-03f, -1.84849486e-01f,
  -2.11338356e-01f, -4.88753580e-02f, 1.42793477e-01f, 9.87880975e-02f, -1.20041922e-01f, 2.82330871e-01f, 1.12156987e-01f, 5.55475764e-02f, 1.33660346e-01f, -8.41447860e-02f,
  6.32073581e-01f, 4.22553331e-01f, 3.92853945e-01f, 1.92299172e-01f, 2.87873060e-01f, 3.34367633e-01f, 5.21545231e-01f, 2.84578443e-01f, -7.42658526e-02f, 1.94301963e-01f,
  2.80607879e-01f, -2.51860898e-02f, -8.98683518e-02f, 1.00529576e-02f, 6.75441399e-02f, 4.11336310e-03f, -1.16075687e-01f, 2.46291254e-02f, 3.72024179e-02f, 1.10405996e-01f,
  -9.76856239e-03f, -2.06501596e-02f, 2.05305532e-01f, 2.96302903e-02f, -6.26095757e-02f, -2.03766122e-01f, -2.58571822e-02f, 1.73078313e-01f, -3.37307192e-02f, -2.26240173e-01f,
  2.30171941e-02f, 4.12039608e-01f, -1.70353711e-01f, -2.05623209e-01f, 1.00223698e-01f, -4.47322726e-02f, -3.51590198e-03f, -1.46545740e-02f, -4.37254794e-02f, -4.24334109e-02f,
  -1.12230383e-01f, 4.90134209e-02f, -7.51876011e-02f, -3.91544662e-02f, 1.67105913e-01f, -9.93517507e-03f, -5.60474060e-02f, 4.15098071e-02f, 8.79845247e-02f, -3.91123965e-02f,
  -1.01734489e-01f, 1.54357523e-01f, 2.52873838e-01f, 7.00299516e-02f, 7.69174993e-02f, -4.54162098e-02f, 8.25016052e-02f, -4.36428795e-03f, 6.72904179e-02f, -2.49303970e-02f,
  -1.03875257e-01f, -1.65820792e-02f, 5.39880134e-02f, 4.91989441e-02f, -8.07848759e-03f, 8.17764830e-03f, -7.60360360e-02f, 1.71726868e-02f, 4.73828688e-02f, 7.87346289e-02f,
  1.18957954e-02f, 5.14148772e-02f, 6.27128631e-02f, -1.99404862e-02f, -4.09793630e-02f, 6.85216784e-02f, 7.74614438e-02f, -3.42778377e-02f, 9.01346952e-02f, -1.83401015e-02f,
  2.83381939e-02f, 1.20331496e-02f, 1.06799051e-01f, 2.63637938e-02f, 3.90773341e-02f, 4.92767841e-02f, 1.55163780e-02f, 1.60400737e-02f, 1.79773327e-02f, 2.61900704e-02f,
  -2.75551707e-01f, 1.45739660e-01f, -1.86507568e-01f, -1.37392879e-01f, -5.49647473e-02f, -8.79061744e-02f, -9.77724604e-03f, -1.21763989e-01f, -5.15901707e-02f, -3.62223089e-02f,
  3.90581856e-03f, -4.46902867e-03f, 8.39310661e-02f, -6.25133188e-03f, -2.36045066e-02f, -9.26632732e-02f, 3.12814303e-02f, -2.61855908e-02f, -1.50812730e-01f, -1.11430019e-01f,
  -1.24886706e-01f, -5.44620194e-02f, 2.46165451e-02f, -5.94210997e-02f, -1.56447604e-01f, -1.08306862e-01f, 1.80311650e-02f, -1.43809929e-01f, 9.54853594e-02f, -1.32111698e-01f,
  -1.27332032e-01f, 1.06992170e-01f, 2.79064387e-01f, 2.53379811e-02f, -2.91405529e-01f, -1.69191867e-01f, -1.08264811e-01f, 1.66304186e-01f, 7.09397122e-02f, 8.51786137e-03f,
  -2.34573036e-01f, 1.33174472e-02f, 1.31879821e-01f, 2.87126452e-01f, 4.01759207e-01f, 2.16550499e-01f, 2.68970698e-01f, 3.86481285e-01f, 2.85195380e-01f, -1.22610535e-02f,
  -1.85195487e-02f, 1.42193466e-01f, 1.71172947e-01f, 2.48324811e-01f, 1.86040625e-01f, 9.63738635e-02f, 2.01567382e-01f, 5.69986440e-02f, 3.47304754e-02f, 1.67932034e-01f,
  3.99395078e-02f, -1.17307000e-01f, 5.95239662e-02f, -1.12081639e-01f, -1.79509982e-01f, -2.06604488e-02f, -8.62444043e-02f, 7.87913501e-02f, -4.44650315e-02f, 1.65788066e-02f,
  -1.39111549e-01f, -1.15161873e-01f, -7.17854127e-02f, -2.39671618e-02f, -3.28080617e-02f, -6.62244633e-02f, 1.60766810e-01f, 2.11876243e-01f, 1.43845648e-01f, -2.51708180e-02f,
  -1.43638253e-01f, -1.92523107e-01f, -1.43277630e-01f, 6.38410598e-02f, 5.15193827e-02f, -3.72815412e-05f, -6.01577535e-02f, -3.56847420e-02f, -9.45114437e-03f, 1.25967145e-01f,
  -1.93393454e-02f, 3.80102210e-02f, -2.17404719e-02f, 1.08055742e-02f, 5.52823618e-02f, 1.92863848e-02f, -3.10499221e-02f, -6.52156398e-02f, 5.45417070e-02f, 7.68998712e-02f,
  -1.57702882e-02f, 1.88144464e-02f, 9.54013243e-02f, -2.45431028e-02f, 2.12101042e-02f, -2.89044119e-02f, -5.72040342e-02f, 7.94943273e-02f, -9.44214780e-03f, -7.81083852e-02f,
  -2.92287786e-02f, -4.58796555e-03f, -4.79011796e-03f, 6.62628934e-02f, 6.54639378e-02f, 8.45637396e-02f, -3.98413055e-02f, 2.58221701e-02f, -4.90457676e-02f, -1.04898229e-01f,
  -2.14575846e-02f, -1.18649609e-01f, 2.07974836e-02f, 5.41692600e-02f, -1.09814778e-01f, 1.39716296e-02f, -1.97789986e-02f, -8.21940750e-02f, -6.19660802e-02f, 1.15699239e-01f,
  -7.22133964e-02f, -2.78584380e-02f, 3.70619185e-02f, 6.75052404e-02f, -1.20495372e-01f, -1.04968317e-01f, -1.57042697e-01f, -4.80717001e-03f, 8.41369329e-04f, -5.33072948e-02f,
  1.40311215e-02f, -1.67256460e-01f, -2.31233016e-01f, -8.38297680e-02f, -5.40822893e-02f, -7.97465295e-02f, -4.35948931e-02f, -5.67541551e-03f, -1.26020506e-01f, -4.59740497e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  3.52627397e-01f, 3.72955084e-01f, 2.98240125e-01f, 4.72010195e-01f, 2.27037311e-01f, 2.44871810e-01f, 1.09422781e-01f, 2.93623179e-01f, 4.36356932e-01f, 5.79244979e-02f,
  -4.95332014e-03f, 2.52669424e-01f, 1.05436094e-01f, 1.45385906e-01f, 2.88738161e-01f, 4.04715180e-01f, 2.15444505e-01f, 3.39393348e-01f, 2.05083638e-01f, 4.04268593e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  1.29367679e-01f, -5.37747979e-01f, -2.15424344e-01f, -6.55732632e-01f, -2.48313397e-01f, -1.31949306e-01f, 7.88840652e-02f, 3.98503728e-02f, 2.12108850e-01f, 5.36208302e-02f,
  2.25318879e-01f, -1.02645360e-01f, -6.39242828e-01f, 3.72809887e-01f, 2.84961909e-02f, -2.60623246e-01f, -1.71635613e-01f, 6.48161054e-01f, -1.58323169e-01f, -8.28349367e-02f,
  -4.96967554e-01f, 2.08184496e-01f, 7.42816687e-01f, -2.89371669e-01f, 6.58842862e-01f, -2.24685162e-01f, -1.15106769e-01f, -1.26654729e-01f, 2.07439125e-01f, 1.64220870e-01f,
  -1.66824516e-02f, -1.50078207e-01f, -5.21481931e-01f, -4.74850655e-01f, -1.18537776e-01f, 1.74543798e-01f, 1.80937663e-01f, -2.55940318e-01f, 7.60375023e-01f, 3.90672078e-03f,
  6.55341506e-01f, 7.11856902e-01f, 3.39628398e-01f, 6.37189865e-01f, -3.55776340e-01f, -4.80193913e-01f, -2.70596117e-01f, 5.26440263e-01f, -3.38839322e-01f, -3.39780115e-02f,
  -8.52684006e-02f, 1.28689572e-01f, 8.99649113e-02f, -2.25469753e-01f, -4.31876024e-03f, -7.59465098e-02f, 8.74016106e-01f, -1.07509241e-01f, 5.16578555e-01f, 1.19626634e-01f,
  2.61434801e-02f, 6.42992735e-01f, 4.35928255e-01f, 1.85708910e-01f, 3.05232733e-01f, 3.49607289e-01f, 1.28713533e-01f, 3.76457751e-01f, -6.64226785e-02f, 3.43275905e-01f,
  -7.64719695e-02f, -2.86219448e-01f, 1.62922055e-01f, 3.99303079e-01f, 5.08527398e-01f, 1.90864932e-02f, -2.57661015e-01f, 2.43856147e-01f, -2.70145893e-01f, 2.47599140e-01f,
  5.80834985e-01f, 8.10899019e-01f, 2.45173320e-01f, 2.93345023e-02f, -5.20064950e-01f, -1.61238462e-01f, -5.22734106e-01f, -1.53769672e-01f, -1.73101753e-01f, 7.27526248e-02f,
  3.20390493e-01f, -3.94921511e-01f, -1.31658554e-01f, 6.82074785e-01f, -4.60840195e-01f, 2.80240893e-01f, -8.10733259e-01f, 3.71044636e-01f, -2.30271727e-01f, 9.43849236e-02f,
  1.23378851e-01f, -2.13824853e-01f, -7.43579149e-01f, 3.32568660e-02f, -6.64541185e-01f, 3.79943877e-01f, -4.31538403e-01f, 2.52773672e-01f, 2.72395611e-01f, -5.44185638e-01f,
  3.23294438e-02f, -2.79567242e-01f, 3.66172045e-01f, 4.28710401e-01f, -1.35141999e-01f, -1.77592978e-01f, 5.07276595e-01f, 1.16586216e-01f, 6.30896986e-01f, -1.91502854e-01f,
  2.22808674e-01f, 4.64082092e-01f, 6.71725497e-02f, -1.78355440e-01f, -1.65956527e-01f, -3.60080630e-01f, -2.54086375e-01f, -3.38381618e-01f, 2.04474211e-01f, 1.12418577e-01f,
  4.85419706e-02f, 1.88895121e-01f, 4.76954952e-02f, 1.96422875e-01f, -5.64218938e-01f, 4.37131137e-01f, 1.28808692e-01f, 2.64621973e-02f, -2.99322754e-01f, -2.95456350e-01f,
  7.92458236e-01f, 9.74069297e-01f, 2.79816866e-01f, -2.81158060e-01f, -4.44635265e-02f, 8.71865451e-02f, -2.39061877e-01f, -3.55030954e-01f, -2.94809997e-01f, 1.15922287e-01f,
  4.52836901e-01f, 4.94175196e-01f, -3.76830697e-01f, -3.63239408e-01f, -2.51623318e-02f, -4.14498746e-01f, 3.07634473e-01f, -2.40768075e-01f, 4.47751582e-02f, -3.86779934e-01f,
  2.79002100e-01f, 2.18612731e-01f, 6.98781610e-02f, 6.22950137e-01f, 4.72476989e-01f, 4.10048038e-01f, 5.28559029e-01f, 5.74802995e-01f, 5.26938260e-01f, 1.95803002e-01f,
  3.72960716e-01f, -2.26672724e-01f, 5.22738338e-01f, -4.06815231e-01f, 6.76095247e-01f, -4.22315389e-01f, -6.90801442e-02f, -3.47073972e-01f, -1.23568349e-01f, 1.44657657e-01f,
  -1.25401502e-03f, -3.23465258e-01f, -1.19260699e-02f, -1.89645067e-01f, 4.92426902e-01f, 6.04168028e-02f, -3.90466332e-01f, 1.01314020e+00f, 2.11154625e-01f, -5.39291263e-01f,
  -9.14407447e-02f, -5.28537072e-02f, -2.24644586e-01f, -2.67065108e-01f, 4.04653430e-01f, -6.89106226e-01f, 1.45744532e-01f, -1.88315183e-01f, 5.82633913e-01f, -7.83886313e-01f,
  4.85877365e-01f, -8.48458827e-01f, 6.22602344e-01f, -7.92442322e-01f, -1.61470518e-01f, 3.45651269e-01f, 1.83700249e-01f, -1.06107153e-01f, -3.03431898e-01f, -4.28100020e-01f,
  4.69445996e-02f, 4.29393113e-01f, -4.83576924e-01f, -5.85494414e-02f, -3.72332186e-01f, -3.33953321e-01f, -1.45810544e-01f, -2.64909834e-01f, -1.90039799e-01f, -1.17216259e-01f,
  -1.35283291e-01f, -2.47792050e-01f, -6.28860295e-02f, 6.83809042e-01f, -9.70349705e-04f, -4.36952442e-01f, -5.87575316e-01f, -1.94626421e-01f, -1.05265878e-01f, -1.91515788e-01f,
  -4.66118306e-01f, -2.39783660e-01f, -3.90255779e-01f, -1.90561384e-01f, -2.49186516e-01f, -1.37862563e-01f, -1.17971845e-01f, -4.38240200e-01f, 3.24297458e-01f, -2.97905147e-01f,
  6.54916763e-02f, -1.01251304e-01f, 5.94343781e-01f, -1.78805485e-01f, 3.04502547e-01f, -1.84436411e-01f, -2.56723940e-01f, 1.65631734e-02f, -1.15813330e-01f, 7.49875247e-01f,
  3.94901425e-01f, -1.09954104e-01f, 3.42876881e-01f, -2.47787878e-01f, -4.60837573e-01f, 4.04833764e-01f, 3.83135289e-01f, 3.25094879e-01f, 3.45215619e-01f, 2.11819902e-01f,
  4.40946251e-01f, -2.78062932e-02f, -7.23348632e-02f, 6.17087424e-01f, 1.77645221e-01f, -9.10008073e-01f, -3.87224942e-01f, 4.18942839e-01f, -5.98403275e-01f, -4.47289616e-01f,
  2.94104993e-01f, 1.11093366e+00f, -2.82741457e-01f, -1.99613184e-01f, 1.16019957e-01f, -3.48472089e-01f, -2.92188495e-01f, -1.32595167e-01f, -3.82241219e-01f, -2.20414117e-01f,
  -4.84613031e-01f, -2.62594800e-02f, -8.67375955e-02f, 3.90988350e-01f, -4.12515342e-01f, 1.39715075e-01f, 1.95895538e-01f, -1.66171595e-01f, -1.11982681e-01f, 8.12961385e-02f,
  -6.92038089e-02f, 6.85861290e-01f, 1.08727895e-01f, -1.23258345e-01f, 3.87930781e-01f, -3.83467168e-01f, -3.73016924e-01f, 1.30184919e-01f, -4.34165180e-01f, -5.12756348e-01f,
  -9.44595039e-02f, 6.93917572e-01f, -3.15305531e-01f, -2.58835107e-02f, 1.88940182e-01f, -3.70830208e-01f, 1.70945898e-01f, 1.13337421e+00f, 2.62221068e-01f, 1.96819399e-02f,
  -2.81086117e-01f, 4.05455679e-01f, 3.12670507e-02f, -1.63063392e-01f, -2.04681009e-01f, -3.11867118e-01f, 3.09651464e-01f, -1.23562112e-01f, -4.78734374e-01f, -5.35882473e-01f,
  3.44001800e-01f, -4.78142910e-02f, 2.02900752e-01f, -2.29976937e-01f, -7.30358124e-01f, 2.09215328e-01f, -4.45643306e-01f, 4.32545215e-01f, -1.34987547e-03f, 8.34580183e-01f,
  -7.85260439e-01f, 3.25097948e-01f, 6.91304922e-01f, -5.03672779e-01f, -3.01282555e-01f, 1.18545987e-01f, -5.80441691e-02f, -6.38390705e-02f, -7.09914118e-02f, -1.49687350e-01f,
  1.03024676e-01f, 4.61922944e-01f, -4.08471346e-01f, 6.07160091e-01f, -4.65865642e-01f, -1.54947072e-01f, 2.45063808e-02f, 5.22294462e-01f, -3.57014686e-01f, 1.76018655e-01f,
  -2.09433690e-01f, 8.10703784e-02f, 3.81372720e-02f, 4.43294086e-02f, 1.65446579e-01f, -4.03662831e-01f, 2.09604606e-01f, 9.80527923e-02f, -3.44846606e-01f, -5.12991011e-01f,
  -3.78714621e-01f, -3.69295746e-01f, 2.85539240e-01f, 1.95334479e-02f, -6.12280741e-02f, 1.23226894e-02f, -1.99648231e-01f, -1.22788928e-01f, -3.03050399e-01f, -3.04113984e-01f,
  -1.24645434e-01f, -3.78930211e-01f, 7.72819340e-01f, 9.38733146e-02f, -1.65109977e-01f, -1.57027557e-01f, -1.51565418e-01f, -2.16505587e-01f, -2.02786282e-01f, -2.65299052e-01f,
  -3.06271076e-01f, -7.52148777e-02f, 1.08767021e+00f, -4.81553733e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.94802415e-01f, -5.93407825e-02f, 4.03488912e-02f, 5.63702844e-02f, -2.64292300e-01f, 3.80604416e-02f, 5.45861237e-02f, 5.37152886e-02f, 2.50951797e-01f, 6.31678104e-02f,
  1.48101285e-01f, 1.52018324e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    