/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.54748881e-02f, 1.18064277e-01f, 1.16536632e-01f, 1.01146609e-01f, -1.16867339e-02f, -4.07563858e-02f, 1.51509508e-01f, -3.18188407e-02f, 1.36819273e-01f, -3.13458182e-02f,
  -1.02246068e-01f, 9.25271586e-02f, -2.88291331e-02f, 9.76133719e-02f, -7.43745863e-02f, 1.00353569e-01f, -1.16694532e-01f, 1.00588307e-01f, 5.76535575e-02f, 7.77230188e-02f,
  -5.93114309e-02f, -3.04526966e-02f, -6.86768815e-02f, -1.08456813e-01f, 2.23858259e-03f, 2.14808397e-02f, -2.91523606e-01f, -3.12899076e-03f, -6.96807429e-02f, -1.08720534e-01f,
  9.46283415e-02f, 1.69463962e-01f, -5.93100069e-03f, 2.06047613e-02f, 4.52916604e-03f, -6.06694967e-02f, 3.65026481e-02f, -6.20572604e-02f, 3.76322828e-02f, 6.76552206e-02f,
  1.00652911e-01f, -6.91025192e-03f, 6.32569194e-02f, -8.36151689e-02f, 8.67364556e-02f, -2.17592660e-02f, -3.41424160e-02f, -4.36400622e-02f, 8.87112971e-03f, -5.13285808e-02f,
  8.93961452e-03f, -2.81963851e-02f, 1.13308933e-02f, 1.02982009e-02f, 7.45121166e-02f, -6.78635463e-02f, 1.23766745e-02f, 5.86328544e-02f, 2.98670009e-02f, 7.92774651e-03f,
  2.20692884e-02f, 7.01138675e-02f, 5.99478837e-03f, 4.32231687e-02f, -1.26278559e-02f, -2.00617351e-02f, -2.80886944e-02f, -5.70466034e-02f, 2.90836412e-02f, -3.47527489e-02f,
  7.10160360e-02f, -2.42389366e-02f, -6.99822679e-02f, -3.71250091e-03f, 7.26252645e-02f, -2.07172520e-02f, 3.47446017e-02f, -3.53136621e-02f, 7.75753940e-03f, 2.66087912e-02f,
  2.86703426e-02f, -2.59073339e-02f, -1.43521940e-02f, 4.41519618e-02f, 1.56158013e-02f, -1.53104002e-02f, 4.08623852e-02f, -1.40329236e-02f, 1.20259210e-01f, 3.69707979e-02f,
  -1.03565037e-01f, -8.92082378e-02f, 2.84227356e-02f, 3.33876573e-02f, 1.75660364e-02f, 1.47110922e-02f, -1.79962143e-02f, 1.35255242e-02f, -6.35490268e-02f, -3.86309288e-02f,
  1.89293288e-02f, 1.54303657e-02f, -4.47550341e-02f, 2.63898429e-02f, -1.71071477e-02f, -3.24008912e-02f, 3.72548588e-02f, 3.37333567e-02f, 2.08268408e-02f, -9.79815573e-02f,
  -3.77112329e-02f, 2.63165720e-02f, 5.61322868e-02f, 3.19049172e-02f, 8.39155987e-02f, 9.85627323e-02f, -1.62439086e-02f, -9.45041180e-02f, -4.30541001e-02f, 5.47062978e-02f,
  -2.12879956e-01f, 2.98560299e-02f, 2.01001279e-02f, -5.89516386e-03f, -3.84511724e-02f, -1.60083883e-02f, 1.33887500e-01f, 1.37350513e-02f, -7.35790581e-02f, 1.44262165e-01f,
  5.55725731e-02f, 2.91242879e-02f, -8.16147123e-03f, 1.19179906e-03f, 3.82520119e-03f, 1.57045387e-02f, 6.99980408e-02f, 7.07447007e-02f, 4.38305475e-02f, 1.08479246e-01f,
  -2.78897546e-02f, 1.40603900e-01f, 1.04223356e-01f, -7.57417455e-02f, 9.52174813e-02f, -1.24290157e-02f, 7.06984475e-02f, 3.07451412e-02f, 3.27010974e-02f, 8.67405683e-02f,
  -1.47723639e-02f, 6.50313199e-02f, 4.05779593e-02f, -4.50088866e-02f, 9.15727764e-02f, -6.40034378e-02f, 3.25760245e-02f, -7.03751715e-03f, -1.61450021e-02f, 3.72745618e-02f,
  4.75448044e-03f, -6.18916079e-02f, 1.75044034e-03f, 5.04705943e-02f, -1.21139223e-02f, -6.00633360e-02f, 2.38778368e-02f, 4.55886982e-02f, 5.66016622e-02f, -6.69357330e-02f,
  -4.92868461e-02f, 5.83180450e-02f, 4.83201668e-02f, 5.95071204e-02f, -2.48551723e-02f, 5.36829196e-02f, -2.15640627e-02f, 2.58428454e-02f, -2.19095331e-02f, -5.10675041e-03f,
  -5.08799106e-02f, -1.40113905e-01f, 3.34101990e-02f, 1.72078945e-02f, 1.14389278e-01f, -1.69240162e-02f, -2.75719934e-03f, 4.35665213e-02f, 6.33573532e-02f, 5.60379848e-02f,
  -7.51533508e-02f, -8.93538061e-04f, -1.14282714e-02f, -5.58299348e-02f, -3.61350477e-02f, 1.69417765e-02f, 1.87561605e-02f, -5.46018146e-02f, 9.95153859e-02f, -5.05807213e-02f,
  2.83728037e-02f, -5.92399016e-02f, 7.86334276e-02f, 4.81918119e-02f, 1.75583530e-02f, 3.89998183e-02f, 5.35859913e-03f, 5.59601188e-02f, 4.14241515e-02f, 2.30920017e-02f,
  1.08207949e-02f, 9.35788155e-02f, 3.49964760e-02f, -3.43073085e-02f, 1.92310102e-02f, 4.11440209e-02f, -5.10889962e-02f, -3.40795368e-02f, 6.45649508e-02f, 1.46847460e-02f,
  -9.08630639e-02f, 5.13784513e-02f, -8.94643459e-03f, 2.22940790e-03f, 7.87311718e-02f, -3.79214175e-02f, -8.80926289e-03f, 4.42273468e-02f, 7.60249197e-02f, 1.34265330e-02f,
  3.13172936e-02f, 7.01537281e-02f, 6.47154078e-02f, -8.46627653e-02f, -2.02348009e-02f, -4.28697132e-02f, 3.63613553e-02f, -3.12947147e-02f, 8.89668241e-02f, 2.72128545e-03f,
  2.96950907e-01f, -1.81481525e-01f, 5.61997704e-02f, 7.07694218e-02f, -4.75128926e-02f, 1.98921472e-01f, 1.44086838e-01f, -1.03650494e-02f, 1.66956987e-02f, 9.35652852e-03f,
  1.90765038e-01f, -1.27970085e-01f, 1.10307023e-01f, 1.26099542e-01f, 2.75311291e-01f, 1.45999789e-01f, 1.91695601e-01f, 4.65702973e-02f, 1.31696552e-01f, 2.44877711e-02f,
  8.51555467e-02f, 1.62946343e-01f, 1.17474154e-01f, 5.22116385e-02f, 9.05825570e-03f, -3.30732912e-02f, 6.60779849e-02f, -2.73513291e-02f, 2.37348601e-02f, 1.10421345e-01f,
  1.16281301e-01f, 9.54677910e-02f, -1.64959989e-02f, -6.99620601e-03f, 6.08169064e-02f, -7.46336505e-02f, -3.81367020e-02f, 4.61166948e-02f, 1.71743128e-02f, -7.34529924e-03f,
  -3.47519405e-02f, -7.44639849e-03f, 3.72144915e-02f, 1.39733534e-02f, -8.61228928e-02f, -7.65995532e-02f, -7.24558756e-02f, -1.88099332e-02f, -1.85673386e-02f, 4.36084531e-02f,
  -2.57429704e-02f, -4.20823321e-03f, -2.18502544e-02f, 6.06045825e-03f, 2.47157663e-02f, 4.57611270e-02f, 2.00889371e-02f, -5.35667129e-03f, -1.08927544e-02f, -3.40065323e-02f,
  1.03338929e-02f, 1.59027297e-02f, -1.00101260e-02f, -1.48701770e-02f, -4.53668600e-03f, 3.32219061e-03f, -1.70754697e-02f, 9.52943601e-03f, -1.76030137e-02f, 1.19114751e-02f,
  -1.73429362e-02f, 4.34942283e-02f, 5.00244349e-02f, -2.02877051e-03f, 9.47294664e-03f, 3.13651152e-02f, 9.09337308e-03f, -5.73059209e-02f, 1.42310851e-03f, 2.29620561e-02f,
  -1.65141206e-02f, 1.79674570e-02f, -1.91655830e-02f, -3.56291397e-03f, -5.94739579e-02f, 3.05346698e-02f, -3.83440172e-03f, 1.81195363e-02f, 1.80193428e-02f, 1.81855559e-02f,
  -9.03839245e-02f, -4.29700315e-02f, 3.40550728e-02f, -3.53438668e-02f, -1.14184953e-02f, 2.36283168e-02f, 5.38197812e-03f, 4.50537167e-02f, 1.28567442e-02f, 5.86387143e-02f,
  -7.89644793e-02f, -1.51323313e-02f, -2.18217000e-02f, 1.73723791e-02f, 4.21103463e-02f, 5.51092401e-02f, -7.71914888e-03f, -5.28412797e-02f, 3.82051952e-02f, -4.54403013e-02f,
  -3.29544321e-02f, 1.63758565e-02f, 6.51817303e-03f, 1.56902485e-02f, 1.07050966e-02f, -3.23879980e-02f, -3.25397812e-02f, -3.26036923e-02f, -3.26117054e-02f, -3.60590070e-02f,
  1.11393288e-01f, -1.03576772e-01f, -1.99568402e-02f, -6.37535229e-02f, 3.52938101e-02f, 1.15486920e-01f, 3.80675703e-01f, -4.56940420e-02f, 2.57870346e-01f, 2.15334445e-02f,
  2.53371298e-02f, 4.94121574e-02f, 1.49263635e-01f, 1.16512679e-01f, 1.34034172e-01f, 2.39032909e-01f, 1.29227964e-02f, 2.93461345e-02f, 1.41660348e-01f, -3.48491408e-02f,
  9.51570272e-02f, -2.93757990e-02f, -6.12692907e-02f, -2.27887988e-01f, -1.70576215e-01f, -7.34099522e-02f, -2.08219349e-01f, -3.01789530e-02f, -2.66948432e-01f, 2.65024276e-03f,
  1.84924766e-01f, 1.17560618e-01f, 4.86794002e-02f, 1.97161548e-02f, -7.06229806e-02f, -7.87479728e-02f, 7.07766786e-02f, -3.28518711e-02f, 8.14310089e-02f, 2.30152123e-02f,
  1.22077502e-02f, -1.51205494e-03f, -1.53007805e-02f, -4.04923931e-02f, -8.26846343e-03f, -4.29336308e-03f, 6.68634921e-02f, 4.15364951e-02f, 2.86673289e-02f, -1.23929773e-02f,
  1.06126964e-02f, -6.03527315e-02f, -9.01101753e-02f, -2.93169133e-02f, 3.82396393e-02f, 4.21760008e-02f, 3.68255936e-02f, 7.33371824e-03f, -4.51879427e-02f, 4.19749729e-02f,
  -1.27778957e-02f, -9.97597128e-02f, -8.60600397e-02f, -6.73929006e-02f, 2.06060950e-02f, 1.49939070e-03f, 3.28324810e-02f, -2.16635279e-02f, 5.54214455e-02f, 9.00539570e-03f,
  -7.15174992e-03f, -1.80867929e-02f, 3.59226391e-02f, 1.11293882e-01f, 6.27698982e-03f, 9.07968208e-02f, -2.06657220e-02f, -1.07447775e-02f, 9.22540762e-03f, 9.10264626e-03f,
  2.17977855e-02f, -7.13617599e-04f, -4.26446944e-02f, -1.51168667e-02f, 1.56281404e-02f, 1.68424976e-05f, -2.61548311e-02f, 4.55419794e-02f, -6.11752793e-02f, -3.68672423e-02f,
  -8.71193036e-02f, -1.07414067e-01f, 1.59100909e-02f, -1.12176733e-02f, 4.74708006e-02f, -2.12193392e-02f, -2.85481121e-02f, 2.80201118e-02f, -1.05453238e-01f, 5.97758219e-02f,
  1.52524672e-02f, 9.23937280e-03f, -3.57561335e-02f, -4.64992132e-03f, -3.07107028e-02f, -2.18565781e-02f, -9.18687228e-03f, -5.33786893e-04f, 8.07989575e-03f, 5.21674082e-02f,
  -6.97235018e-02f, 1.02283113e-01f, 3.36261094e-02f, 9.05934907e-03f, -5.37465699e-02f, -6.09217957e-02f, -1.08569833e-02f, -3.32502834e-02f, -2.50779539e-02f, 4.66579236e-02f,
  3.77365112e-01f, -2.45542452e-01f, -1.63864866e-01f, 3.15689176e-01f, 1.01015866e-01f, -1.28975347e-01f, 1.06334575e-02f, 1.77602977e-01f, 1.45192713e-01f, -1.53657362e-01f,
  6.33108243e-03f, -2.03602165e-01f, -2.29671061e-01f, 1.86154902e-01f, 6.80350885e-02f, -2.48385072e-01f, 1.18414126e-01f, -3.48261409e-02f, -6.55042455e-02f, 1.17618954e-02f,
  1.40017897e-01f, 1.41894892e-01f, -4.94103543e-02f, 1.05416149e-01f, 8.41157883e-03f, 9.39930677e-02f, 3.64994407e-02f, -2.30439529e-01f, 1.26670286e-01f, -9.90734063e-03f,
  8.87139589e-02f, 1.14434868e-01f, 1.10446572e-01f, 4.28622253e-02f, 4.68520112e-02f, -2.85500512e-02f, -5.38421832e-02f, 7.24926475e-04f, -1.54934712e-02f, -2.36482229e-02f,
  -6.00954890e-02f, -6.99139026e-04f, 8.68314356e-02f, 3.20439637e-02f, 6.04670644e-02f, 5.66559806e-02f, 3.51079367e-02f, -1.07422452e-02f, -1.23260508e-03f, -7.64216110e-02f,
  -2.23789848e-02f, -1.86098050e-02f, -1.62059925e-02f, -5.41068502e-02f, 3.35058235e-02f, -1.85206980e-02f, -4.32884060e-02f, -1.82005148e-02f, -9.02587641e-03f, 2.84435553e-03f,
  1.58182066e-02f, 2.89135724e-02f, 1.19135361e-02f, 2.70003118e-02f, 1.02559039e-02f, 3.23080160e-02f, 3.07544377e-02f, 3.41927889e-03f, 5.97128086e-02f, 1.15817823e-02f,
  6.20892495e-02f, 1.70002058e-02f, 5.13921641e-02f, -2.38711480e-02f, 3.41322571e-02f, 2.25709323e-02f, 3.25746182e-03f, -1.84847098e-02f, -2.44157761e-02f, 1.93811152e-02f,
  -2.74371495e-03f, 1.86302401e-02f, -4.36871760e-02f, -4.60131578e-02f, -7.58827478e-03f, 8.16254294e-04f, -1.21676205e-02f, -2.83049867e-02f, 2.71494361e-03f, -1.06651997e-02f,
  -1.20904267e-01f, -2.75929589e-02f, 3.46838012e-02f, -2.57171988e-02f, -1.96005590e-02f, 8.29682779e-03f, -1.03396447e-02f, 1.33481370e-02f, -2.65052263e-02f, 4.18038741e-02f,
  -3.91009673e-02f, 3.18933949e-02f, -2.83291005e-02f, -4.88282880e-03f, -6.19665831e-02f, -2.50588022e-02f, -2.82058362e-02f, -6.55808346e-03f, 5.55651411e-02f, -1.43675739e-03f,
  5.27475728e-03f, 1.58196390e-02f, -2.77517922e-02f, 9.99680310e-02f, 7.54975826e-02f, -2.25553801e-03f, 7.07236230e-02f, -3.13829146e-02f, -1.82778910e-02f, -9.07206628e-03f,
  -3.98805261e-01f, 6.31827191e-02f, 1.16597146e-01f, -7.76686147e-02f, -1.72731698e-01f, 1.46094142e-02f, 2.39562780e-01f, -8.70696977e-02f, -9.84724686e-02f, -4.79533821e-02f,
  9.98853296e-02f, -1.69407442e-01f, 1.66923523e-01f, 9.48293433e-02f, 4.14879210e-02f, 7.33855516e-02f, -5.34400828e-02f, -8.37446675e-02f, -1.44130394e-01f, -2.34962985e-01f,
  -3.89381475e-03f, -1.48632944e-01f, 1.00549750e-01f, -3.37321684e-02f, -7.48287439e-02f, 3.46699879e-02f, -1.07872523e-02f, 1.17068410e-01f, -5.03363051e-02f, 5.53413704e-02f,
  1.33642972e-01f, 2.27579828e-02f, 5.24862148e-02f, 4.53688577e-02f, 4.76967730e-02f, 9.23076943e-02f, 7.71892741e-02f, 8.61478224e-02f, 3.95532362e-02f, 2.07463955e-03f,
  -5.35180718e-02f, -2.74981614e-02f, 2.61481814e-02f, -1.02282308e-01f, -7.96785951e-02f, -1.67750951e-03f, -2.24614516e-02f, -1.60841586e-03f, 3.49609442e-02f, -3.34878266e-02f,
  3.95534039e-02f, 2.33364180e-02f, -5.69912419e-02f, -3.32922973e-02f, 6.03513084e-02f, 3.45837395e-03f, -2.35957205e-02f, 8.55251588e-03f, -8.39391500e-02f, 1.04852235e-02f,
  -6.43324554e-02f, -4.26095463e-02f, 2.43073911e-03f, -6.30181581e-02f, 5.35248604e-04f, 5.35872504e-02f, -3.82081605e-02f, -1.86840296e-02f, -1.09673694e-01f, -9.62902308e-02f,
  3.08305211e-03f, -5.69119714e-02f, 2.18344592e-02f, -7.04729557e-02f, -4.30638157e-02f, -8.38182941e-02f, -8.81962553e-02f, 2.45878124e-03f, -1.31399930e-02f, 6.21283129e-02f,
  -5.53720556e-02f, -3.44441682e-02f, -1.87198091e-02f, -3.84693034e-02f, 5.50076142e-02f, 5.70231723e-03f, -8.69461223e-02f, -2.24889666e-02f, -1.51637348e-03f, 8.41605291e-02f,
  -3.24710347e-02f, -1.08741418e-01f, 4.98001836e-02f, -2.70218290e-02f, -5.70858549e-03f, -4.46084253e-02f, -8.10486972e-02f, -8.12337268e-03f, 4.97611659e-03f, 1.18610719e-02f,
  -1.79941542e-02f, -3.22672650e-02f, 2.16154102e-02f, -1.96253173e-02f, -1.27136856e-02f, 9.64414254e-02f, 4.94086444e-02f, -4.63276245e-02f, -3.57856564e-02f, -6.96186488e-03f,
  -2.02329573e-03f, -4.22551595e-02f, 2.46187579e-02f, -6.07880056e-02f, -1.22321285e-01f, 4.44314629e-02f, -5.19352406e-03f, 3.30943428e-02f, -4.82613072e-02f, -2.89056599e-02f,
  -3.27074081e-02f, 1.96961462e-01f, 1.78329602e-01f, 4.75819670e-02f, -2.34109890e-02f, -9.00983438e-02f, 3.44614647e-02f, 1.95321053e-01f, 1.56463146e-01f, -6.88444078e-02f,
  -5.27679846e-02f, 6.52871504e-02f, 3.78511436e-02f, -7.93380439e-02f, -7.39130154e-02f, 5.46097942e-02f, 3.94075923e-03f, -1.25463217e-01f, 3.85594256e-02f, -3.77098285e-02f,
  4.99098711e-02f, -4.85038050e-02f, 9.13112890e-03f, 4.25239094e-02f, 1.79455876e-02f, 3.99090350e-02f, -7.31189623e-02f, -5.10092825e-02f, -5.32934256e-02f, -8.98813922e-03f,
  -8.12430009e-02f, 1.47418063e-02f, 1.94033969e-03f, 1.91661697e-02f, -7.89584592e-02f, 7.49021349e-03f, -4.33939807e-02f, -1.14684235e-02f, 9.26877931e-03f, 3.01822391e-03f,
  -5.89266978e-02f, -3.38856839e-02f, -3.77094448e-02f, 7.25014284e-02f, 2.11182367e-02f, 6.95341453e-02f, 4.73595271e-03f, 2.70964243e-02f, 4.39875387e-02f, 4.10679877e-02f,
  1.41701251e-02f, 4.56545465e-02f, -4.38511707e-02f, -4.79517840e-02f, 6.94427863e-02f, 2.49307677e-02f, -2.49422789e-02f, 4.50851358e-02f, -1.03822947e-02f, 2.29642683e-05f,
  4.62825857e-02f, 1.82449482e-02f, -3.93262357e-02f, -8.96612555e-02f, -3.79181691e-02f, -6.84234574e-02f, 4.46582176e-02f, 1.24528660e-02f, 5.43886088e-02f, -3.97157632e-02f,
  -4.10666727e-02f, 7.91630521e-02f, 3.92723717e-02f, 3.03967968e-02f, 3.50910723e-02f, 4.16158102e-02f, -3.36993597e-02f, 1.24419332e-02f, -3.04516833e-02f, -6.32872209e-02f,
  -2.79752333e-02f, -4.43514325e-02f, 2.76363306e-02f, -3.36321518e-02f, -6.21087253e-02f, 2.78160702e-02f, -4.50607613e-02f, 4.57409881e-02f, -8.37362409e-02f, -3.81756723e-02f,
  -4.42926325e-02f, 9.49097797e-02f, -2.34464146e-02f, -3.18768770e-02f, 4.53356653e-02f, 2.27849502e-02f, 6.97725341e-02f, 6.30416125e-02f, 9.19576287e-02f, 5.00180982e-02f,
  -1.89617611e-02f, 5.34957536e-02f, -2.20358390e-02f, 5.84322736e-02f, -2.78185662e-02f, -3.62020801e-03f, -3.89087833e-02f, -3.60138416e-02f, 1.12872599e-02f, 6.12033866e-02f,
  -2.15463527e-02f, -1.12496745e-02f, -1.52853616e-02f, 4.97379377e-02f, 3.96299101e-02f, -5.77894710e-02f, 4.41476703e-02f, -3.12639028e-02f, 1.07214348e-02f, 4.75314222e-02f,
  -7.38521963e-02f, -1.31857380e-01f, 3.11894327e-01f, 1.87511384e-01f, -1.62736163e-01f, 8.90288427e-02f, 3.82031538e-02f, -1.46598816e-01f, 1.94955692e-01f, -2.87897527e-01f,
  -2.63538480e-01f, -3.28560509e-02f, 1.84000470e-03f, 1.94623079e-02f, 6.29667640e-02f, 1.43037558e-01f, -1.34790882e-01f, -3.62598104e-03f, -4.44776900e-02f, -1.43077120e-01f,
  3.41823734e-02f, -1.86265185e-01f, 1.19807377e-01f, -1.42329872e-01f, -6.38136193e-02f, 1.01587370e-01f, -5.07710576e-02f, -3.42534259e-02f, -1.18624508e-01f, -6.47695214e-02f,
  -2.47032847e-02f, 3.27839050e-03f, 8.46491978e-02f, 6.22360669e-02f, -8.89635906e-02f, -3.28564309e-02f, -7.96864852e-02f, 4.31044176e-02f, 1.62481386e-02f, 1.53868031e-02f,
  -2.74299346e-02f, -2.87430286e-02f, 1.24939345e-02f, 2.81098504e-02f, 7.03110844e-02f, 5.63524701e-02f, 1.41237415e-02f, -2.88316328e-02f, 1.88403893e-02f, 5.32596111e-02f,
  3.72171290e-02f, 1.58860870e-02f, 5.78172207e-02f, -3.89121799e-03f, 1.41849993e-02f, 5.19791711e-03f, 6.33044317e-02f, -3.14752124e-02f, 7.71404803e-02f, -4.77524893e-03f,
  -9.92634520e-02f, 3.02750580e-02f, 6.91467524e-02f, 2.25473829e-02f, 3.63131464e-02f, -5.01133613e-02f, 1.72474999e-02f, -7.78590096e-03f, 8.01263079e-02f, -3.30987424e-02f,
  -1.43390419e-02f, 1.01955924e-02f, -1.15715303e-02f, 1.99027695e-02f, -5.03081735e-03f, 5.55629991e-02f, 2.09268462e-02f, -3.18980254e-02f, 5.38788997e-02f, 2.39643408e-03f,
  6.42263740e-02f, -2.05226820e-02f, 7.96751231e-02f, -2.79643550e-03f, 1.39369983e-02f, 2.60376651e-02f, -3.42240557e-02f, -5.25538949e-03f, 2.67699473e-02f, -1.76459458e-02f,
  -2.22813904e-01f, -1.65547773e-01f, -2.39200480e-02f, -1.13776298e-02f, 1.75454523e-02f, -2.26829220e-02f, 4.65464182e-02f, -4.68951985e-02f, -2.05816850e-02f, -1.93396825e-02f,
  -2.98673436e-02f, 5.09843528e-02f, -3.15104090e-02f, 1.91114340e-02f, 2.93535180e-02f, -5.95390461e-02f, 4.20534685e-02f, 3.01932190e-02f, -3.05212364e-02f, -2.86952704e-02f,
  -1.04247015e-02f, -5.14944382e-02f, -2.96431687e-02f, -3.31102014e-02f, -2.74094306e-02f, -1.76251717e-02f, 4.14942764e-02f, 9.62286664e-04f, -1.87812950e-02f, 5.43734543e-02f,
  3.80084187e-01f, 4.75627407e-02f, 1.70666203e-01f, 2.04140991e-01f, 1.22151554e-01f, 4.77081761e-02f, 1.78531483e-01f, 3.50608304e-02f, 3.23766917e-01f, -1.71202183e-01f,
  -1.66943129e-02f, 2.22986519e-01f, -1.73758436e-02f, -1.08414970e-01f, 3.77070278e-01f, -6.80534318e-02f, -1.78358719e-01f, -8.16213489e-02f, 9.35396329e-02f, -8.80149081e-02f,
  5.12796827e-02f, -9.25756097e-02f, -2.22326443e-02f, -1.56839281e-01f, -2.76066139e-02f, -1.37892514e-02f, -9.48750004e-02f, 9.12604108e-02f, -6.43863305e-02f, 7.00283125e-02f,
  -4.22089659e-02f, -9.91933867e-02f, -6.37721270e-02f, -7.24064782e-02f, -1.97586808e-02f, -4.00142968e-02f, 9.69199371e-03f, 6.12379797e-02f, -2.20117718e-02f, 4.53019999e-02f,
  9.42469016e-03f, -6.21160539e-03f, 1.83876920e-02f, 2.46566795e-02f, -7.27129579e-02f, -3.85602862e-02f, 4.81381491e-02f, -5.52450120e-02f, 8.75429958e-02f, -3.21958773e-02f,
  -4.30902373e-03f, -7.49274865e-02f, 6.33613253e-03f, -8.90540481e-02f, 1.83577314e-02f, -4.72219959e-02f, 2.21107304e-02f, 6.38023317e-02f, -1.07038021e-02f, 5.92521429e-02f,
  -6.90180510e-02f, 9.79500357e-03f, -3.48719731e-02f, -2.15292610e-02f, 3.24215367e-02f, -1.20288404e-02f, -4.01427550e-03f, -1.15629286e-02f, 6.36504665e-02f, -9.58390608e-02f,
  2.41907444e-02f, -3.48203331e-02f, -1.52692851e-02f, -5.31343892e-02f, -4.05955426e-02f, -6.91446513e-02f, -4.43865322e-02f, -1.41952047e-02f, -6.81421608e-02f, 1.30274501e-02f,
  -2.63820123e-02f, 2.23437529e-02f, -7.53250346e-02f, -7.42351413e-02f, 2.65328549e-02f, 4.02228720e-02f, 4.89657512e-04f, -4.34902981e-02f, -2.46495884e-02f, 7.46274181e-03f,
  -3.35193425e-02f, 7.63054267e-02f, 2.07934119e-02f, -3.09881642e-02f, 3.53172161e-02f, -5.44016138e-02f, -3.55397649e-02f, -1.67004410e-02f, 5.18978760e-02f, 5.47774062e-02f,
  -2.95525864e-02f, 5.74161531e-03f, 2.76731830e-02f, 3.37520242e-02f, 2.23909244e-02f, -5.17967753e-02f, -2.21662428e-02f, 3.99117246e-02f, -2.22139526e-02f, 3.46853919e-02f,
  -1.07705733e-02f, 3.92964259e-02f, 2.35128049e-02f, -1.47037590e-02f, -3.19513530e-02f, 5.43935085e-03f, -3.15673463e-02f, -2.73500904e-02f, 6.30827108e-03f, 1.84618477e-02f,
  3.92901689e-01f, 5.69977909e-02f, 9.98524651e-02f, 1.47815585e-01f, 1.43556297e-01f, 8.60421136e-02f, -4.92751226e-02f, 2.21143261e-01f, 2.58512944e-01f, 8.26406032e-02f,
  1.06038563e-01f, 1.01030558e-01f, -8.38995501e-02f, -5.17427223e-04f, -5.55559248e-02f, -2.12169826e-01f, 1.00552756e-02f, 9.51375738e-02f, -2.46591065e-02f, 8.50748941e-02f,
  -2.33323406e-02f, 2.39428785e-02f, -1.79889768e-01f, 7.61811584e-02f, 2.11930349e-02f, 2.06111163e-01f, 1.67949572e-02f, 3.22138797e-03f, 6.12461604e-02f, 7.40687773e-02f,
  2.32453775e-02f, 2.07264617e-01f, 3.68326269e-02f, 1.05740586e-02f, 3.50890458e-02f, -2.48559914e-03f, -2.35391483e-02f, -1.63715251e-03f, 4.65994561e-03f, 2.76349578e-02f,
  -4.98336852e-02f, 8.67924392e-02f, 7.89888874e-02f, 3.39133516e-02f, 1.60476957e-02f, 8.36977437e-02f, -3.23533155e-02f, -1.11201452e-02f, 8.70689005e-03f, -4.43451814e-02f,
  5.46999238e-02f, -9.16934311e-02f, -3.32069099e-02f, -6.37127757e-02f, -2.70437971e-02f, 4.50479239e-02f, -3.89177585e-03f, -2.11080685e-02f, 2.24628840e-02f, 4.32102084e-02f,
  -2.55426504e-02f, 4.20660861e-02f, 3.32803987e-02f, 8.34449902e-02f, -2.75235586e-02f, 7.16979653e-02f, -1.81095544e-02f, 3.15847509e-02f, -2.52282172e-02f, -2.91254371e-03f,
  3.79199199e-02f, -1.29814511e-02f, 1.44029304e-03f, -5.24552688e-02f, 3.53582157e-03f, -4.90500741e-02f, -9.47554931e-02f, 1.00979209e-02f, -1.75864492e-02f, 4.51836176e-02f,
  4.79528855e-04f, 1.60284732e-02f, 6.91177184e-03f, -8.18015262e-02f, 8.50354135e-02f, -2.04199906e-02f, -6.65363222e-02f, -3.76270935e-02f, 1.48115084e-02f, 1.23159876e-02f,
  3.83506157e-02f, 2.60744005e-01f, 5.58015034e-02f, 4.92058396e-02f, -3.91148254e-02f, -4.83925268e-02f, -4.18654159e-02f, -2.66675819e-02f, 5.94764715e-03f, -1.23546245e-02f,
  1.44927045e-02f, -4.50706147e-02f, 5.16230129e-02f, -2.05430072e-02f, -2.59514339e-02f, 1.52486116e-02f, 1.89829916e-02f, -5.25730625e-02f, 2.90086046e-02f, 3.17459740e-02f,
  -3.26596685e-02f, 5.99212348e-02f, 1.07558295e-02f, 1.17760785e-02f, -6.90383986e-02f, -3.67958620e-02f, 7.36795738e-02f, 1.41397975e-02f, -1.30949197e-02f, -1.73148476e-02f,
  -6.15180612e-01f, -2.09501565e-01f, -1.92176789e-01f, -1.57190293e-01f, 9.09244716e-02f, -1.51087597e-01f, -1.58458829e-01f, 2.35819314e-02f, -7.33194575e-02f, -5.40160714e-03f,
  1.24583125e-01f, -1.01735666e-01f, 1.15738817e-01f, -2.27705181e-01f, -5.13659827e-02f, -4.56748268e-04f, -2.18275726e-01f, -6.51883483e-02f, -7.07783410e-03f, 5.11257723e-02f,
  -6.04073182e-02f, 6.51392266e-02f, -1.23688012e-01f, 5.93868755e-02f, -6.33104518e-02f, 1.31323105e-02f, 2.12765336e-01f, 1.34832218e-01f, -5.38246986e-03f, -3.93937491e-02f,
  -9.32393521e-02f, 1.39449880e-01f, -3.53099294e-02f, -2.30295490e-02f, 4.80980128e-02f, 1.91643164e-02f, -5.65020461e-03f, 4.12169695e-02f, 1.09291226e-02f, 5.07459417e-03f,
  2.94902036e-03f, 5.94125390e-02f, -6.81990683e-02f, 9.41157527e-03f, -2.58904453e-02f, -3.39487083e-02f, -8.47673118e-02f, -7.44368806e-02f, -4.26873751e-02f, 5.25447652e-02f,
  -1.45108365e-02f, -6.74677417e-02f, -3.06606367e-02f, -1.01326495e-01f, -3.66260931e-02f, -1.45087903e-03f, -9.64269694e-03f, -4.47734594e-02f, 1.21756261e-02f, -3.93618494e-02f,
  -7.07850158e-02f, -3.47592030e-03f, -2.64619365e-02f, 3.06397240e-04f, -1.09856300e-01f, 4.05103154e-02f, -1.68441404e-02f, 3.75229046e-02f, -1.33929811e-02f, -1.47692924e-02f,
  -3.91334854e-03f, -1.78728141e-02f, 4.81480844e-02f, -2.33679526e-02f, 1.01257139e-03f, 5.84663171e-03f, -2.76405439e-02f, 3.91060812e-03f, -8.24267268e-02f, -2.35553575e-03f,
  4.33343984e-02f, -2.44385190e-03f, 1.78064741e-02f, 4.81452513e-03f, 3.05406936e-02f, -1.42139019e-04f, 2.34842952e-03f, -5.48538342e-02f, -4.55530621e-02f, 1.93527676e-02f,
  7.49540180e-02f, 1.31066754e-01f, -3.23206186e-02f, 2.49049533e-02f, -3.58619578e-02f, -4.01879475e-03f, 6.45713601e-03f, -1.23561285e-02f, 4.90393676e-03f, 1.51816383e-02f,
  3.69773284e-02f, -3.34149376e-02f, 7.20061809e-02f, 1.33275501e-02f, 2.38643913e-03f, 2.96797808e-02f, 8.92144740e-02f, 2.50823032e-02f, 2.90571041e-02f, 1.16308383e-03f,
  -5.51254675e-03f, 2.74558682e-02f, -1.72652137e-02f, 3.95640768e-02f, 3.54173407e-03f, -1.97298191e-02f, 1.98576245e-02f, 5.10397702e-02f, 1.87764149e-02f, -2.97127943e-03f,
  1.55482724e-01f, -4.24289405e-01f, 8.02283585e-02f, -7.38991946e-02f, 2.58910239e-01f, -1.44600710e-02f, 1.55910596e-01f, -1.22317754e-01f, -1.13845930e-01f, -3.22113723e-01f,
  -3.06311026e-02f, -1.04072772e-01f, 1.88153740e-02f, -1.22503333e-01f, 1.86115742e-01f, -7.77070820e-02f, -2.82865972e-03f, -1.06120825e-01f, -1.03359809e-02f, -8.03814605e-02f,
  -1.48084732e-02f, 2.82893106e-02f, 1.81391180e-01f, -1.98485292e-02f, 7.67617971e-02f, -7.32890368e-02f, 2.60119047e-03f, 1.16085708e-01f, -5.03455549e-02f, -3.57082672e-02f,
  3.88492234e-02f, -5.36234975e-02f, -5.81357218e-02f, -5.03505161e-03f, 2.91506369e-02f, 3.56142521e-02f, 2.41199657e-02f, 5.88301644e-02f, 4.71003838e-02f, -1.63337328e-02f,
  -1.57576595e-02f, 8.96211527e-03f, -2.26230994e-02f, 2.03429051e-02f, 6.14324249e-02f, 3.72214466e-02f, 2.36974316e-04f, 7.32797533e-02f, -9.81402956e-03f, -1.08506931e-02f,
  -1.54730147e-02f, 1.34242699e-02f, 2.35803332e-02f, -3.56592387e-02f, 4.14689779e-02f, -4.91491193e-03f, -5.94851524e-02f, -7.25747552e-03f, -3.37857846e-03f, -1.32921794e-02f,
  -1.01810349e-02f, -5.21135293e-02f, -3.01946402e-02f, 2.87100188e-02f, -8.20731521e-02f, -4.33876701e-02f, -7.99138192e-03f, 3.37697081e-02f, -2.91506518e-02f, -2.34646909e-02f,
  5.31328991e-02f, -4.32664081e-02f, -1.38024036e-02f, -1.70725212e-02f, -1.45031484e-02f, -6.40326813e-02f, 7.00454041e-03f, 5.18003432e-03f, 2.65237875e-02f, 2.32668910e-02f,
  3.10814530e-02f, -2.73286998e-02f, 1.77208055e-02f, 4.50462848e-02f, -1.49838552e-02f, 9.96270450e-04f, -1.73120499e-02f, -3.54314372e-02f, 1.02560474e-02f, 3.48637290e-02f,
  -2.13873327e-01f, -2.93255180e-01f, 8.35172646e-03f, 4.28772308e-02f, -4.88639474e-02f, -6.28989860e-02f, 4.46126126e-02f, -4.87529561e-02f, -5.19114733e-02f, -2.86271772e-03f,
  -1.32731758e-02f, 1.57527961e-02f, -2.80935746e-02f, 1.37809198e-02f, -4.56318352e-03f, -4.08134051e-02f, 2.62017921e-02f, -8.61923918e-02f, -1.13471765e-02f, 5.75451693e-03f,
  -2.18289085e-02f, 3.30200493e-02f, 1.59296207e-03f, -2.26681102e-02f, -3.49336118e-02f, 4.31244485e-02f, 1.31597873e-02f, 3.10472166e-03f, 2.65514548e-03f, 9.59178526e-03f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.34711608e-02f, -3.51334304e-01f, -3.93183112e-01f, -1.48800805e-01f, -3.24300528e-02f, -3.93235505e-01f, -3.10323060e-01f, -1.85076222e-01f, 9.86424312e-02f, -5.22352289e-03f,
  -2.31490403e-01f, 1.43134102e-01f, 1.73274502e-02f, -2.46509865e-01f, 1.19803071e-01f, 9.90446359e-02f, -3.53436083e-01f, -9.63535830e-02f, 8.01187195e-03f, -2.47500390e-01f,
  7.79438838e-02f, -2.24384531e-01f, -1.44377962e-01f, -1.67204842e-01f, -3.14597785e-01f, 1.40587464e-02f, 1.46619692e-01f, -2.46822145e-02f, -7.28969127e-02f, -2.85944827e-02f,
  -2.15456430e-02f, 9.28123221e-02f, -2.41975076e-02f, -5.19947335e-03f, -8.20607319e-02f, -1.08047441e-01f, 1.58803686e-02f, 7.66738132e-03f, 3.63255255e-02f, 5.73547464e-03f,
  -4.37293276e-02f, -3.24291177e-02f, -2.32725888e-02f, -3.06655746e-02f, -3.72741632e-02f, 6.77880794e-02f, -2.01776735e-02f, -3.03098708e-02f, -1.54020101e-01f, -3.21772061e-02f,
  -1.17008403e-01f, -6.01498585e-04f, -8.47850814e-02f, 6.82564154e-02f, 6.98606223e-02f, -9.76097807e-02f, 5.04396297e-02f, 4.86802822e-03f, -3.62306871e-02f, 8.36268160e-03f,
  -7.18841213e-04f, 3.02585438e-02f, -8.12466294e-02f, -2.69510280e-02f, -4.18348797e-02f, 1.08131766e-02f, -3.41557190e-02f, 7.26642683e-02f, -2.74465512e-02f, 7.18472875e-05f,
  -1.45712188e-02f, 3.46968397e-02f, -2.91781593e-02f, -3.76171134e-02f, -7.71679431e-02f, 6.23555761e-03f, -1.97852869e-02f, 1.36736445e-02f, -4.80249263e-02f, -5.94828685e-04f,
  3.46562192e-02f, 4.18490991e-02f, -3.97814773e-02f, -4.44260947e-02f, -3.69549096e-02f, 8.13726336e-02f, -1.16568590e-02f, -3.28093432e-02f, -3.60797904e-02f, 2.39798632e-02f,
  -1.02083772e-01f, -6.20790869e-02f, 6.99903145e-02f, -6.18985593e-02f, 3.57973129e-02f, -2.90139802e-02f, -3.16300988e-02f, -9.41495318e-03f, -6.56541362e-02f, -5.73504046e-02f,
  -2.95732655e-02f, 8.01228732e-02f, 1.84052922e-02f, 2.82377396e-02f, -1.74121689e-02f, -4.90681715e-02f, 1.82432085e-02f, -6.16067369e-03f, 1.97360013e-02f, 5.17040957e-03f,
  3.00476374e-03f, 3.50351855e-02f, 1.10016853e-01f, -2.90607959e-02f, -1.07706222e-03f, -3.16279344e-02f, 3.08307223e-02f, 1.52330357e-03f, 6.00953475e-02f, 3.97163704e-02f,
  1.26967072e-01f, -7.59458244e-02f, 1.43861651e-01f, 2.48783335e-01f, -2.36811176e-01f, -4.93179172e-01f, -2.76106417e-01f, -4.37954664e-02f, -5.34760058e-02f, -1.16710611e-01f,
  5.29092364e-02f, -7.08762482e-02f, 2.53911298e-02f, 1.43014118e-01f, 1.41800433e-01f, -7.73224682e-02f, 9.45122465e-02f, -6.72717616e-02f, 1.05329836e-02f, 6.09386861e-02f,
  1.36547580e-01f, 1.47401104e-02f, 3.13113004e-01f, 2.08094031e-01f, -6.59136251e-02f, 1.99337348e-01f, 2.44730651e-01f, -1.81883667e-02f, 1.54498562e-01f, 1.53512554e-02f,
  -9.43184718e-02f, 7.01427013e-02f, 9.84804109e-02f, 9.16772243e-03f, -4.41769026e-02f, -7.84200355e-02f, 1.18887322e-02f, -2.94770896e-02f, 1.81263778e-02f, 5.79967126e-02f,
  -3.90732288e-02f, 2.37675812e-02f, -2.89066173e-02f, -6.94987923e-02f, -4.10604384e-03f, 1.32528082e-01f, 3.79326195e-02f, -2.38247178e-02f, -7.46279061e-02f, 5.70561104e-02f,
  -7.88531452e-03f, -1.00296855e-01f, -1.38319694e-02f, -2.06153132e-02f, 9.23677012e-02f, 2.18606880e-03f, -5.26134595e-02f, -1.33773778e-02f, -1.03624783e-01f, 4.72173654e-03f,
  8.25086143e-04f, -4.57520671e-02f, -4.90960889e-02f, 2.14678589e-02f, 3.83288860e-02f, 3.58442664e-02f, -4.39545475e-02f, -1.08434046e-02f, 7.39625543e-02f, -2.27207020e-02f,
  1.13695897e-02f, 6.77617965e-03f, 5.11825457e-03f, -5.89029230e-02f, 2.70321243e-03f, -5.29353060e-02f, -3.62177403e-03f, 3.64137702e-02f, 6.81571662e-02f, -2.70897970e-02f,
  -2.17144471e-02f, 1.54824359e-02f, -4.90950942e-02f, 2.45918473e-03f, 2.79956963e-03f, -4.68625640e-03f, 4.98862229e-02f, -7.15964148e-03f, 7.51538053e-02f, -5.41467741e-02f,
  -3.84089313e-02f, 1.81430131e-01f, 1.69467274e-02f, -5.47272526e-02f, 3.64515781e-02f, -2.17053574e-02f, 2.81226244e-02f, -2.49227490e-02f, 8.11651200e-02f, 3.82791949e-03f,
  4.53487709e-02f, -4.87293974e-02f, -6.36562333e-02f, 4.91234772e-02f, 1.82821229e-02f, -3.97185944e-02f, 2.29130350e-02f, 7.08893016e-02f, -7.21408403e-04f, 2.17861608e-02f,
  -1.06310956e-02f, 4.81420197e-03f, -2.83917855e-03f, -1.13645205e-02f, -5.30612795e-03f, -3.48352678e-02f, 6.67291880e-02f, 1.60191469e-02f, 2.59207059e-02f, 1.78041328e-02f,
  -3.09549332e-01f, 1.73395023e-01f, -1.44131199e-01f, -9.63324308e-02f, -1.46990037e-02f, -9.27679241e-02f, 1.33272801e-02f, -1.03737585e-01f, -3.49881575e-02f, 5.25360405e-02f,
  -8.36260468e-02f, 6.56659249e-03f, 7.44092166e-02f, 4.63531055e-02f, -2.03515872e-01f, -2.94783767e-02f, 3.43014635e-02f, -1.15919232e-01f, 8.22059363e-02f, 1.41848540e-02f,
  -2.32205354e-03f, -3.38797718e-02f, 1.30612794e-02f, 8.31523165e-02f, 2.55617145e-02f, -3.39339934e-02f, -1.26851648e-01f, -2.99277529e-02f, 5.90837188e-02f, 1.99078992e-02f,
  -7.42505640e-02f, -1.41786695e-01f, -1.45884752e-01f, -3.02075651e-02f, -7.67150596e-02f, -6.86502829e-02f, -6.38476089e-02f, -2.48876419e-02f, -8.21208283e-02f, -1.34818004e-02f,
  -6.86570406e-02f, -7.01408935e-05f, 1.02300930e-03f, 5.22930697e-02f, 1.30944736e-02f, -1.05273584e-02f, -2.11766008e-02f, 7.51409605e-02f, -5.16034327e-02f, 1.50241051e-02f,
  3.33899073e-02f, -5.05394973e-02f, -3.35436091e-02f, -4.39346880e-02f, 4.76569356e-03f, 2.65615787e-02f, 1.89033709e-02f, 4.15465347e-02f, -3.65001112e-02f, -1.11600151e-02f,
  8.30813348e-02f, 2.42052861e-02f, -7.05184117e-02f, 9.77575630e-02f, 2.42456347e-02f, -4.06206436e-02f, 3.11439484e-02f, -4.44939211e-02f, 1.38616879e-02f, 4.14196625e-02f,
  5.05083501e-02f, 7.41007403e-02f, -1.22249924e-01f, 1.11200698e-02f, -2.71240622e-02f, -8.94675627e-02f, 1.66505184e-02f, 7.81003833e-02f, -2.48591527e-02f, 6.27993122e-02f,
  1.86834019e-02f, 1.02568559e-01f, -7.94761106e-02f, -1.31641611e-01f, 5.02732135e-02f, 3.08026709e-02f, 1.96157396e-02f, -2.21995590e-03f, -4.15527672e-02f, -4.52480093e-02f,
  -2.33901590e-01f, -8.15283954e-02f, -1.30123556e-01f, -6.36461228e-02f, 2.47241985e-02f, -8.67405832e-02f, -4.00556028e-02f, -1.40081327e-02f, 7.51904175e-02f, 4.42953557e-02f,
  -5.80242537e-02f, -4.33331691e-02f, -5.15312403e-02f, 4.09297310e-02f, 4.79449444e-02f, -7.70625146e-03f, -9.69766304e-02f, -4.83698323e-02f, 1.52704911e-02f, 1.42371852e-03f,
  -4.54177149e-02f, 3.35953496e-02f, -1.55455312e-02f, -8.22555199e-02f, -2.81448923e-02f, 2.30992530e-02f, -9.17133614e-02f, -4.19836156e-02f, -2.42102407e-02f, 8.43940601e-02f,
  -5.01078144e-02f, 3.18553060e-01f, 1.60794720e-01f, 1.20112233e-01f, -5.06895455e-03f, -1.24590388e-02f, -4.46244963e-02f, -1.89123172e-02f, 7.37331286e-02f, 1.06324404e-02f,
  -9.71901882e-03f, 3.12599212e-01f, 1.19333835e-02f, -2.64054425e-02f, -2.90197343e-01f, -1.40013486e-01f, -1.31874621e-01f, 1.26590189e-02f, 9.07865018e-02f, 6.78446889e-02f,
  -9.66380164e-02f, -7.78179169e-02f, 8.76227953e-03f, 3.40082236e-02f, 9.04853418e-02f, -5.66417128e-02f, -1.22070819e-01f, 1.11172318e-01f, -6.51229098e-02f, 9.89487022e-03f,
  -8.25019851e-02f, 1.80839412e-02f, 1.49121568e-01f, -1.92287266e-02f, -2.59993691e-02f, -6.83477372e-02f, 7.18032047e-02f, 4.25685979e-02f, -1.64141897e-02f, 9.73023474e-02f,
  9.88024920e-02f, 1.11044962e-02f, 2.22578794e-02f, -1.84319715e-03f, -5.58706652e-03f, 2.40485966e-02f, -4.61992156e-03f, 9.80711821e-03f, 1.06329568e-01f, 7.18619227e-02f,
  3.86852995e-02f, -2.13775579e-02f, -4.28015813e-02f, -8.56780112e-02f, -9.17214006e-02f, -1.41372299e-02f, 5.75054549e-02f, 4.83531225e-03f, -1.36302216e-02f, -2.31691301e-02f,
  -1.15596414e-01f, -4.30695117e-02f, -2.58817896e-02f, -6.33889362e-02f, -6.32601231e-02f, -1.91077013e-02f, 6.02861419e-02f, -5.88324517e-02f, 1.76978912e-02f, -5.04117496e-02f,
  -8.23102221e-02f, 1.87969711e-02f, 4.46148813e-02f, -5.83904190e-03f, -3.91618796e-02f, 6.95762411e-02f, -6.19045049e-02f, 1.66916056e-03f, -1.36258742e-02f, 6.07907539e-03f,
  -6.55572042e-02f, -2.79649757e-02f, -3.34134139e-02f, 2.02642698e-02f, -7.27907717e-02f, -3.65435593e-02f, -1.68281347e-02f, 1.82875395e-02f, 3.48006077e-02f, -8.69644880e-02f,
  -4.65879850e-02f, -1.83775336e-01f, 1.89021451e-03f, -4.73547578e-02f, 2.38457359e-02f, 5.51931970e-02f, -1.91000383e-02f, -1.54359797e-02f, -5.35181202e-02f, -2.69620325e-02f,
  -2.02683546e-02f, -3.14280130e-02f, -2.69703381e-02f, 1.61311571e-02f, -2.66848728e-02f, -3.59570906e-02f, 3.44166681e-02f, -3.33110802e-02f, -5.19543774e-02f, 9.03742760e-03f,
  7.82831237e-02f, 5.08344434e-02f, -5.41512966e-02f, 5.67706600e-02f, 6.12266874e-03f, -4.80978237e-03f, 4.34588231e-02f, 2.56087091e-02f, -5.78290150e-02f, -2.19079666e-02f,
  2.30887700e-02f, 5.50752645e-03f, -3.39650549e-02f, -9.53243859e-03f, 2.78575085e-02f, -6.90958127e-02f, 2.89365333e-02f, 7.93754868e-03f, -9.66429040e-02f, 9.08030197e-02f,
  -6.82419837e-02f, -6.18323945e-02f, 4.18112837e-02f, 2.96104327e-02f, 8.68971087e-03f, -3.14436443e-02f, 8.28691013e-03f, 3.61305177e-02f, -8.12926739e-02f, 1.00078523e-01f,
  1.20521393e-02f, -5.14749549e-02f, -7.77699202e-02f, 1.19365193e-01f, -4.24959064e-02f, 7.96442181e-02f, 1.40417472e-01f, 6.03388175e-02f, 4.64732014e-02f, -1.69665497e-02f,
  -4.00731340e-02f, -2.95216907e-02f, -2.11250014e-03f, -1.76341552e-02f, 1.07897580e-01f, -9.28559341e-03f, -3.53863575e-02f, -3.67947854e-02f, 7.60057047e-02f, 2.50859540e-02f,
  -2.34690197e-02f, 4.38736342e-02f, 5.56379184e-02f, 1.11349272e-02f, 5.59535511e-02f, -5.54440282e-02f, -6.45615682e-02f, 8.33286252e-03f, 2.24438533e-02f, -1.27618223e-01f,
  -3.28316987e-02f, 7.24848062e-02f, 2.48605721e-02f, 7.12509751e-02f, -5.10859443e-03f, -1.48655325e-02f, 9.53661129e-02f, 2.56108455e-02f, -4.90661897e-03f, -1.45684346e-03f,
  8.50437060e-02f, -3.57076265e-02f, -9.56069585e-03f, -1.01722352e-01f, 2.03271527e-02f, -2.48548649e-02f, 4.46568727e-02f, 6.02927543e-02f, -7.56377205e-02f, 7.10284859e-02f,
  2.80974228e-02f, 7.43407980e-02f, -1.08439229e-01f, 5.13709672e-02f, 1.25906959e-01f, -4.94397618e-02f, -2.86913849e-02f, 1.22905582e-01f, -2.64387149e-02f, 6.16788026e-03f,
  3.74555141e-02f, -1.43747812e-03f, 5.61903790e-02f, 6.67175883e-03f, 6.03417754e-02f, 6.30602241e-02f, -8.80536139e-02f, -3.82695273e-02f, -3.71981710e-02f, -3.29429284e-02f,
  6.36297092e-02f, 9.88711864e-02f, 2.27763671e-02f, 3.08696292e-02f, -8.54888484e-02f, 1.37284875e-01f, -4.26117033e-02f, 4.21394706e-02f, -4.37016971e-02f, -6.37650713e-02f,
  7.22981542e-02f, 1.51132103e-02f, 1.94327757e-02f, 9.32422280e-02f, 2.52806116e-02f, -9.70150158e-02f, 5.23849763e-02f, 2.74003074e-02f, 9.28459391e-02f, -1.53192403e-02f,
  -6.98999465e-02f, 1.72523230e-01f, 1.36333838e-01f, -5.83497882e-02f, 5.07123545e-02f, 2.62968764e-02f, 8.39111954e-02f, -2.55706199e-02f, -6.55142143e-02f, 4.00175825e-02f,
  -5.22420779e-02f, 6.26881840e-04f, -4.21072096e-02f, -9.04657841e-02f, -1.35577992e-01f, -9.73138809e-02f, -4.18806337e-02f, -3.91257135e-03f, 6.97458833e-02f, -4.13853154e-02f,
  1.14076205e-01f, 6.08370602e-02f, 7.36224949e-02f, -7.42406994e-02f, 6.80285543e-02f, 2.26255767e-02f, -1.44660175e-02f, 3.15793231e-02f, -1.08872160e-01f, -6.14725240e-02f,
  -3.74074616e-02f, -2.68673175e-03f, -3.96362729e-02f, 7.71558844e-04f, -6.26650378e-02f, -1.30403657e-02f, -5.51856160e-02f, -1.14193060e-01f, -1.23655297e-01f, -5.39345331e-02f,
  -4.03632373e-02f, 4.01815884e-02f, -3.13234739e-02f, -4.90563363e-02f, 5.32028191e-02f, -2.59726099e-03f, 1.96562540e-02f, -2.77271960e-03f, -6.13498166e-02f, 6.01457432e-02f,
  -1.54518168e-02f, 5.35334349e-02f, -2.17257831e-02f, 7.09892735e-02f, 3.68404612e-02f, -1.89836752e-02f, 2.87494101e-02f, 7.79843256e-02f, 1.14735374e-02f, -3.49026197e-03f,
  5.68651874e-03f, 3.50608192e-02f, -5.28198015e-03f, -1.10363644e-02f, -3.73116508e-02f, -7.49342591e-02f, -5.31115942e-02f, 2.40059625e-02f, 6.19482854e-03f, -1.07086943e-02f,
  -3.08936778e-02f, 3.26454826e-02f, 8.38600844e-02f, -2.02417169e-02f, -1.53705955e-03f, 2.25512013e-02f, 3.85404974e-02f, 2.96688452e-02f, -3.65665704e-02f, 5.14883362e-02f,
  2.42030453e-02f, 8.93929452e-02f, 9.81659163e-03f, -1.45582827e-02f, 6.19766824e-02f, -5.74789234e-02f, 5.21122627e-02f, -4.05312143e-02f, -7.98745640e-03f, -7.46033713e-02f,
  4.14261892e-02f, 5.69529869e-02f, 3.77502888e-02f, 5.43969609e-02f, 1.47656217e-01f, -2.96883583e-02f, 8.15368369e-02f, 5.37278783e-03f, -7.46269291e-03f, -1.24904707e-01f,
  -6.29544333e-02f, 2.23455927e-03f, 4.53634821e-02f, 1.00304522e-01f, 3.61032225e-02f, -4.20300327e-02f, -5.63047156e-02f, -4.20696586e-02f, -8.76914635e-02f, -8.57229680e-02f,
  -1.06899321e-01f, 9.47071761e-02f, -8.09680521e-02f, -1.40207717e-02f, -5.62985726e-02f, 4.02917787e-02f, -2.17635762e-02f, -2.02979427e-02f, -3.27163339e-02f, -5.68773784e-03f,
  -8.47825184e-02f, 6.02598265e-02f, 5.25180399e-02f, 9.12125334e-02f, 3.62751111e-02f, -8.01686496e-02f, 9.18823555e-02f, -4.82450128e-02f, -2.14393437e-02f, 4.92638946e-02f,
  -8.82677641e-03f, 8.65057111e-02f, -4.80970144e-02f, 1.00881539e-01f, -9.83766839e-03f, -1.54431090e-01f, -1.32214859e-01f, -8.80747288e-03f, -2.25353874e-02f, 3.15588862e-02f,
  -8.96991119e-02f, 8.65857676e-02f, 1.34023517e-01f, 6.88318983e-02f, 1.97968304e-01f, 6.72624856e-02f, 1.64224997e-01f, -2.60969158e-02f, 7.29064345e-02f, 7.60673173e-03f,
  5.32137156e-02f, 4.37400490e-02f, 5.01365438e-02f, -7.64703527e-02f, -1.13312071e-02f, 8.18893462e-02f, 8.64554271e-02f, -4.89175096e-02f, -7.55078867e-02f, -5.78299537e-02f,
  -8.31038356e-02f, -5.00759222e-02f, -7.20450804e-02f, -4.08183970e-02f, -1.45483925e-03f, -1.08672962e-01f, -8.36853385e-02f, 4.10137326e-02f, 6.68132231e-02f, 3.85302044e-02f,
  1.85103957e-02f, 5.23219407e-02f, 5.72216287e-02f, -5.59122227e-02f, 2.25061700e-02f, 4.28352989e-02f, 2.13580448e-02f, -1.81780327e-02f, 6.06216397e-03f, 6.79402240e-03f,
  2.17341091e-02f, -2.03132462e-02f, -1.10414261e-02f, -5.17426543e-02f, -3.22191007e-02f, 2.23449860e-02f, -4.20708507e-02f, -4.15672399e-02f, 2.05765739e-02f, 1.06946237e-01f,
  -9.21067521e-02f, 1.05778441e-01f, 5.61601594e-02f, 4.98220064e-02f, -4.55347933e-02f, -7.27886409e-02f, 3.93661037e-02f, -3.08289099e-02f, -3.11299507e-02f, -8.01093578e-02f,
  4.60303351e-02f, -2.69574486e-02f, 6.96372148e-03f, 3.55945267e-02f, 4.51213829e-02f, 9.20750499e-02f, 2.43651518e-03f, -9.95665565e-02f, -4.81198579e-02f, -3.40519957e-02f,
  3.91547233e-02f, 1.70318019e-02f, 1.36695160e-02f, -2.07613148e-02f, -4.67374846e-02f, 1.03992950e-02f, 6.64338246e-02f, 8.09581131e-02f, 7.16258166e-03f, -2.96076369e-02f,
  1.88396089e-02f, 1.60863742e-01f, -4.42593731e-02f, 6.47136495e-02f, 4.86494601e-02f, 1.05242785e-02f, 1.84423346e-02f, -5.33788949e-02f, -2.46214550e-02f, -8.40815604e-02f,
  2.64338404e-02f, 1.32015320e-02f, -5.01697510e-02f, 3.32144797e-02f, 2.72815619e-02f, 2.41173874e-03f, 1.09513208e-01f, -9.00579467e-02f, -8.78317561e-03f, 8.61124247e-02f,
  -4.59791049e-02f, -1.12222601e-02f, 5.82703203e-02f, -6.79521710e-02f, -3.57317924e-02f, 2.47256849e-02f, -8.43122005e-02f, 3.68182287e-02f, 1.61028951e-02f, 6.52894750e-02f,
  -1.70981631e-01f, -6.00526631e-02f, 4.17519696e-02f, 6.02924787e-02f, -3.05448502e-01f, -1.18080921e-01f, 6.46966174e-02f, -8.35267641e-03f, 6.43175095e-02f, 2.23713338e-01f,
  1.82850093e-01f, -2.74249334e-02f, 1.50009319e-01f, 9.01149288e-02f, 7.23183826e-02f, 2.66089197e-02f, 5.31826615e-02f, 1.54226184e-01f, -1.01869822e-01f, -1.38394326e-01f,
  -8.08652937e-02f, -9.59342048e-02f, -4.64414656e-02f, -3.61012258e-02f, -3.94193195e-02f, 1.73480937e-03f, 6.98918104e-02f, -5.97362183e-02f, 5.77735482e-03f, 6.39233887e-02f,
  -1.21961810e-01f, -1.23517089e-01f, -5.75013086e-02f, 4.93023358e-03f, -1.18757291e-02f, 1.78430527e-02f, -4.25679721e-02f, -1.64397079e-02f, 2.13608313e-02f, -2.29111034e-02f,
  1.15907259e-01f, 2.55918987e-02f, 4.38033864e-02f, 5.96118383e-02f, -5.43983728e-02f, 3.96776274e-02f, 5.37885092e-02f, -2.21354328e-02f, -5.02969883e-02f, 2.59259902e-02f,
  4.38543744e-02f, -6.47570863e-02f, -1.82504263e-02f, 4.06651571e-02f, -1.01560369e-01f, 5.71756344e-03f, 2.15476081e-02f, -2.36799847e-02f, -6.78348243e-02f, -1.30127864e-02f,
  9.39149857e-02f, 1.50546832e-02f, 3.94985937e-02f, -7.83489347e-02f, -2.18936447e-02f, 6.89968653e-03f, 3.53250131e-02f, 6.66199848e-02f, -2.09989287e-02f, -2.73939371e-02f,
  3.74822468e-02f, -5.64552844e-02f, -5.69564849e-02f, 4.95228171e-02f, 1.33991297e-02f, 1.90434176e-02f, -6.34736568e-02f, 6.51154220e-02f, -1.37687009e-02f, -5.76535938e-03f,
  -2.32792906e-02f, 6.35033920e-02f, -3.94801013e-02f, 2.12805960e-02f, -6.10222481e-02f, -6.72887033e-03f, -7.31336847e-02f, 4.64515537e-02f, 4.71353270e-02f, -3.34814079e-02f,
  -1.98611081e-01f, -1.45483807e-01f, 8.86033922e-02f, -9.85916425e-03f, -3.26227322e-02f, -1.78959183e-02f, 6.95332885e-02f, -6.75681904e-02f, -4.86621782e-02f, -7.62792379e-02f,
  4.11930531e-02f, -2.59896107e-02f, 2.42312849e-02f, 3.53345904e-03f, -6.85412064e-02f, -5.31474203e-02f, -1.64181736e-04f, -3.76159213e-02f, -1.36767058e-02f, -5.56669608e-02f,
  -1.52567960e-02f, 6.56072572e-02f, 7.74164721e-02f, 5.60796820e-02f, 6.19898960e-02f, 1.20903961e-02f, -6.46895394e-02f, 3.09859309e-03f, -4.74241786e-02f, -5.40194102e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  -4.38579530e-01f, -2.93506294e-01f, 3.07040121e-02f, 9.95113030e-02f, -3.72925252e-02f, -1.01162326e-02f, 6.26007542e-02f, 2.38088006e-03f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  4.80744243e-02f, -1.40991390e-01f, -3.94281894e-02f, -5.30579612e-02f, 2.09072586e-02f, 4.16402593e-02f, -9.83725265e-02f, 2.14912668e-01f, -4.89727929e-02f, -1.31491095e-01f,
  -2.36081883e-01f, 1.04191020e-01f, 2.20443338e-01f, 1.13076739e-01f, -1.00599706e-01f, 3.29190679e-02f, -2.52525151e-01f, 8.97856876e-02f, 5.65157495e-02f, 1.80325121e-01f,
  -1.80686545e-02f, 2.55366657e-02f, 1.15122698e-01f, -2.16430351e-01f, 2.83778489e-01f, -1.96217209e-01f, 3.99409570e-02f, 1.28266841e-01f, -1.77708209e-01f, -1.18036501e-01f,
  -1.85127541e-01f, 2.02563018e-01f, -1.04877457e-01f, -1.30784452e-01f, -1.64032266e-01f, 1.10139184e-01f, -5.26961051e-02f, -9.08517316e-02f, -7.73670226e-02f, -3.22114110e-01f,
  -4.38659266e-02f, -1.03254709e-02f, -1.68777406e-01f, 7.93815255e-02f, -1.50605395e-01f, -1.74242202e-02f, -2.37870872e-01f, -8.31995904e-02f, 1.76629245e-01f, 1.43636212e-01f,
  1.49492249e-01f, -1.85386285e-01f, -1.54774696e-01f, -7.53543302e-02f, 3.21810067e-01f, -5.01342118e-02f, 5.35235047e-01f, 2.27741152e-02f, -1.44528300e-01f, 1.09246835e-01f,
  8.93985033e-02f, -1.91799272e-02f, 1.57100558e-02f, -1.40725404e-01f, -2.01808289e-01f, -1.07715979e-01f, 3.20122167e-02f, 4.09676619e-02f, 1.12726659e-01f, 1.57219410e-01f,
  -1.31160587e-01f, -1.33287624e-01f, 1.35201916e-01f, 1.62332952e-01f, 1.75971780e-02f, 1.33661970e-01f, 2.20080137e-01f, 1.94813326e-01f, 1.37728706e-01f, 7.64686475e-03f,
  3.60096805e-02f, 5.94654940e-02f, 7.43359253e-02f, 5.77309355e-02f, 2.29482185e-02f, 1.81848109e-01f, -1.73281118e-01f, -2.09528968e-01f, 1.05028218e-02f, 1.35618478e-01f,
  -2.20627829e-01f, 1.84910938e-01f, 6.92715347e-02f, -2.01541185e-02f, 2.04275981e-01f, 9.43884403e-02f, -5.55295907e-02f, -2.98771918e-01f, 1.30178392e-01f, -2.02142060e-01f,
  -3.62839729e-01f, 4.84012179e-02f, -1.05610199e-01f, -2.23944504e-02f, -4.92301444e-03f, 2.58268490e-02f, 1.46619290e-01f, -8.80699828e-02f, -1.90046132e-01f, 1.51559804e-03f,
  2.32949272e-01f, -1.29777923e-01f, 1.80180594e-01f, -8.16155300e-02f, -4.96831872e-02f, -1.41015247e-01f, 2.03757137e-01f, -1.28383815e-01f, -3.95092852e-02f, 3.62944186e-01f,
  -1.41059712e-01f, 5.63621759e-01f, -1.07963629e-01f, -1.81059897e-01f, -4.09488082e-02f, -3.52180534e-04f, 2.27440149e-01f, 3.57875079e-02f, 7.28811473e-02f, -8.45272318e-02f,
  -6.85947984e-02f, -1.82194598e-02f, -8.36428404e-02f, -1.29919782e-01f, -2.04461113e-01f, 8.55333656e-02f, -1.30471483e-01f, -1.29182376e-02f, 1.88441038e-01f, -1.24309808e-01f,
  -1.38808191e-01f, -1.03855312e-01f, 2.06542298e-01f, 1.01674378e-01f, -9.40658897e-02f, -8.77374932e-02f, -6.16101362e-02f, 5.87562099e-02f, 9.63411108e-02f, 6.84487121e-03f,
  -1.67456314e-01f, -3.95035781e-02f, -3.45523864e-01f, -2.90407658e-01f, -1.95234329e-01f, -1.70114025e-01f, 1.35966554e-01f, 4.62757312e-02f, -5.68555892e-02f, -3.06265522e-02f,
  -1.17419660e-02f, -2.12230250e-01f, -2.83684373e-01f, -1.91439405e-01f, 1.10494293e-01f, -2.76256621e-01f, 3.73159237e-02f, 9.54150874e-03f, -2.79071838e-01f, -1.88401923e-01f,
  5.13676368e-03f, 1.00247562e-01f, 2.15708930e-02f, 1.57231480e-01f, 9.29112360e-02f, 1.03159845e-01f, 1.10039778e-01f, 1.69884428e-01f, -2.35128775e-01f, -6.33403212e-02f,
  -3.85756761e-01f, -2.50047177e-01f, 3.02447706e-01f, -1.21480256e-01f, 4.01591599e-01f, -2.38704503e-01f, 6.04692921e-02f, -1.72528192e-01f, 4.68414575e-02f, 1.99272096e-01f,
  5.01170158e-02f, 3.37392122e-01f, 1.54367447e-01f, -1.59468964e-01f, -9.67448857e-03f, -1.80309966e-01f, -1.31633118e-01f, 4.99864295e-02f, 1.10969037e-01f, 4.25711600e-03f,
  -1.13438368e-01f, -1.26748636e-01f, 8.75964314e-02f, 3.39005068e-02f, 1.21040888e-01f, -5.32480441e-02f, -1.16060384e-01f, 1.88152026e-02f, 7.37499297e-02f, 4.80778627e-02f,
  1.17199540e-01f, 1.28195643e-01f, 2.20434949e-01f, 2.01476607e-02f, -9.23407525e-02f, 1.31895483e-01f, 1.05194584e-01f, 1.71373323e-01f, 8.36028531e-02f, 6.11715950e-02f,
  -3.49593945e-02f, -1.17765181e-01f, -9.77192223e-02f, -1.83936447e-01f, -4.53243367e-02f, -3.55250537e-02f, 4.94546480e-02f, -5.94627559e-02f, -8.30666274e-02f, -1.83376715e-01f,
  1.04276347e-03f, 2.11957619e-01f, -8.61672238e-02f, -8.99476185e-02f, -1.31514534e-01f, -1.03850454e-01f, 2.66978174e-01f, -6.07554615e-02f, -1.07654713e-01f, 2.55188137e-01f,
  -2.32053339e-01f, 2.41769761e-01f, 2.44837150e-01f, 4.20329630e-01f, 2.27725565e-01f, 1.14757173e-01f, -3.38384300e-01f, 2.58693378e-02f, 5.71166072e-03f, -3.33225191e-01f,
  2.06566095e-01f, 2.46498778e-01f, -1.35536700e-01f, 2.06799611e-01f, 1.50778871e-02f, 1.62564576e-01f, -2.63815671e-01f, -1.12656124e-01f, 3.73274833e-02f, -3.59837711e-01f,
  -1.61397502e-01f, 9.82178450e-02f, -1.21913143e-01f, 1.48184136e-01f, 1.41269833e-01f, 1.11534327e-01f, 5.49328066e-02f, -1.81833476e-01f, 9.91929397e-02f, -5.19382618e-02f,
  4.49891910e-02f, -9.90670398e-02f, 1.30235136e-01f, -1.36054173e-01f, 7.88095035e-03f, -1.82965379e-02f, 2.41521910e-01f, 3.54288846e-01f, -3.35967153e-01f, -1.12627655e-01f,
  -2.71690845e-01f, 2.65976846e-01f, -2.86495805e-01f, -3.32401060e-02f, 6.32071197e-02f, 1.05258174e-01f, -1.28200695e-01f, -6.58985004e-02f, -3.21707092e-02f, -1.40724748e-01f,
  4.74928841e-02f, 8.18952620e-02f, 2.19455063e-01f, -6.75102510e-03f, 1.12479046e-01f, -1.84028909e-01f, -1.87772363e-02f, -1.76279724e-01f, -2.57115178e-02f, 4.29367013e-02f,
  -1.34601220e-01f, 1.66036829e-01f, -1.23626597e-01f, 1.43606469e-01f, 7.54326135e-02f, 1.32101640e-01f, 1.76734492e-01f, 9.57143754e-02f, -1.67110607e-01f, 3.91011424e-02f,
  2.55888313e-01f, -6.08043298e-02f, 3.88057828e-01f, 1.54890195e-01f, 8.83595124e-02f, -1.90750510e-01f, -1.86363354e-01f, -1.53071359e-01f, 1.90455094e-01f, -2.63714208e-03f,
  7.65734836e-02f, 3.03992089e-02f, -3.04183990e-01f, -1.46085396e-01f, 1.40651807e-01f, 3.08814049e-01f, 1.20155849e-01f, -1.93860140e-02f, 2.18575150e-01f, 1.81543604e-01f,
  -3.85692716e-01f, 2.24127069e-01f, -3.17114219e-02f, -3.90091278e-02f, -3.59423816e-01f, -1.50932282e-01f, 1.99899703e-01f, -5.76240011e-02f, 4.25259061e-02f, -2.53526896e-01f,
  -1.03705704e-01f, 2.16776654e-01f, 5.37984632e-02f, -1.96174964e-01f, -8.45531449e-02f, 1.97568342e-01f, 1.38880704e-02f, 3.38887960e-01f, 1.21115193e-01f, 6.12741932e-02f,
  1.77151605e-01f, -2.84024835e-01f, -2.43375078e-01f, 1.10391662e-01f, -9.24074501e-02f, -1.58462733e-01f, -1.36640063e-02f, 2.90628940e-01f, 5.80109432e-02f, -1.42237708e-01f,
  -2.06252765e-02f, 2.12731525e-01f, 1.94987766e-02f, 2.68785119e-01f, -1.93370730e-02f, -4.25834432e-02f, -1.18677177e-01f, -3.18442762e-01f, 2.18111247e-01f, -3.39196235e-01f,
  -1.28498189e-02f, -3.86347353e-01f, 1.18205853e-01f, 2.02167079e-01f, -1.43503025e-01f, -1.88903078e-01f, -2.07626045e-01f, 2.96805222e-02f, -1.84617847e-01f, -4.40167002e-02f,
  2.11661592e-01f, -1.89142764e-01f, 1.84369385e-01f, -2.81674862e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.84897447e-01f, 1.53007567e-01f, -5.55055961e-03f, 3.11305016e-01f, 3.88708264e-01f, 1.85432211e-02f, 1.05412312e-01f, -4.09856252e-02f, -1.86677147e-02f, -1.44464344e-01f,
  6.68515787e-02f, 2.22672120e-01f, 1.78595647e-01f, 1.48749754e-01f, -1.53740719e-01f, -8.01445469e-02f, -5.76943196e-02f, 1.54790178e-01f, 6.17458932e-02f, -1.65022146e-02f,
  -1.84502453e-01f, -1.79940194e-01f, 1.63788617e-01f, -3.01975310e-01f, 3.82025689e-01f, -1.26121417e-01f, 2.17084199e-01f, -1.71523448e-02f, -1.95350230e-01f, 2.22953513e-01f,
  9.52196028e-03f, 2.30080932e-01f, 1.05138645e-01f, -3.60288359e-02f, 7.56298378e-02f, 2.63523106e-02f, 1.09196588e-01f, 7.63147548e-02f, -1.15401603e-01f, 4.59269136e-02f,
  5.83961001e-03f, -1.64574292e-02f, 1.86320487e-02f, -9.88580883e-02f, -9.47489440e-02f, -3.51033434e-02f, -1.27460121e-03f, -7.62167200e-02f, -1.68218967e-02f, -6.11021789e-03f,
  -1.22143812e-01f, -2.36462299e-02f, -1.31842464e-01f, -1.74242049e-01f, 1.23543385e-02f, 1.12980545e-01f, 2.91274726e-01f, -1.32552266e-01f, -8.67708400e-02f, -1.66398779e-01f,
  -4.97576818e-02f, -7.93768391e-02f, 6.89373687e-02f, -1.34696290e-01f, 2.07952838e-02f, -3.27286758e-02f, 4.02920358e-02f, -1.25893086e-01f, 1.60330579e-01f, -4.44143862e-02f,
  -8.54013041e-02f, 4.48375456e-02f, 3.08458328e-01f, 2.81176567e-01f, -1.07728861e-01f, 2.90505022e-01f, -1.72081426e-01f, -7.22285658e-02f, 5.00941910e-02f, -2.29366645e-01f,
  1.10609099e-01f, -7.71597549e-02f, -2.40952194e-01f, -2.26252660e-01f, 7.41540045e-02f, 2.72524953e-02f, 1.80352151e-01f, -1.32573560e-01f, -1.15299016e-01f, 4.73565310e-02f,
  -2.09747344e-01f, -2.97102422e-01f, 2.22587809e-01f, -1.38878942e-01f, -4.05427776e-02f, -6.81314841e-02f, -1.50239274e-01f, 1.04057327e-01f, -8.10044333e-02f, 8.59175697e-02f,
  -1.31451979e-01f, 5.55868484e-02f, 6.20544665e-02f, 9.47077870e-02f, 8.44699070e-02f, -1.86508894e-03f, 2.26791665e-01f, -1.11390382e-01f, -1.66930869e-01f, -1.40351444e-01f,
  7.60909170e-02f, 1.68635651e-01f, 1.13137409e-01f, 1.27220064e-01f, -3.54504655e-03f, 1.84165433e-01f, 1.00126885e-01f, -1.39912769e-01f, 6.45870566e-02f, 3.85052770e-01f,
  8.67816582e-02f, -6.96540028e-02f, -1.52547643e-01f, 9.80886817e-02f, 8.60515684e-02f, 1.76989213e-01f, 1.00605272e-01f, 1.85458902e-02f, -2.28674989e-03f, 1.04505956e-01f,
  -3.85474823e-02f, -9.45609286e-02f, 1.53906509e-01f, 4.54075448e-02f, 1.25178978e-01f, -6.55064732e-02f, 6.11197688e-02f, -9.76710469e-02f, -2.23933429e-01f, 3.44255529e-02f,
  1.72880858e-01f, -3.94882970e-02f, -2.29914233e-01f, -2.38886386e-01f, 1.31188735e-01f, -6.58790171e-02f, -3.53347473e-02f, 4.29075994e-02f, -2.05789030e-01f, 8.53234157e-02f,
  1.85619608e-01f, -1.32081583e-01f, 2.68264472e-01f, 1.85222849e-01f, 2.64997804e-03f, 2.59654284e-01f, 1.09192319e-01f, -7.07107708e-02f, 3.72654423e-02f, 5.05923554e-02f,
  -9.97416154e-02f, 4.95577492e-02f, -9.23166201e-02f, 4.12750617e-02f, 1.44257531e-01f, -1.55548245e-01f, 4.68457080e-02f, 1.32523894e-01f, 4.21883585e-03f, 1.43895810e-02f,
  6.81090727e-02f, 4.90380377e-02f, 1.43923700e-01f, 1.26735881e-01f, 1.98618948e-01f, 1.84779868e-01f, -8.99120569e-02f, -6.22023419e-02f, -1.44309804e-01f, -1.54603794e-02f,
  2.66176522e-01f, -1.30090192e-01f, 5.85769676e-02f, -4.85217758e-02f, 3.48377109e-01f, 2.38837212e-01f, -1.96198210e-01f, -1.33219495e-01f, 1.54507309e-01f, 1.24500223e-01f,
  2.43650675e-01f, 1.99313685e-01f, 1.49868011e-01f, 8.16711187e-02f, -4.21118699e-02f, -1.63233057e-01f, -1.54290274e-02f, 6.29573986e-02f, 8.74205977e-02f, -2.05712784e-02f,
  -5.10397553e-02f, 4.60275970e-02f, -1.30416572e-01f, -2.48841599e-01f, -5.39410338e-02f, 1.01782463e-01f, 1.95638135e-01f, 1.28713474e-01f, 8.45773146e-02f, -3.11153177e-02f,
  -2.34500676e-01f, 1.98575333e-01f, 7.50033855e-02f, 1.44206107e-01f, -1.05224466e-02f, 2.45359823e-01f, 4.75584194e-02f, 1.19237982e-01f, -6.50644377e-02f, 7.09579363e-02f,
  -9.41920951e-02f, 7.09689185e-02f, -1.86569184e-01f, 8.28228891e-02f, -1.04511566e-01f, 1.29762128e-01f, 2.03605205e-01f, -2.61713602e-02f, -1.85712948e-01f, 7.41729736e-02f,
  8.94441679e-02f, -1.19801819e-01f, 7.44593441e-02f, 3.14167082e-01f, 3.52216214e-02f, 1.80883527e-01f, -7.50126243e-02f, -1.37512490e-01f, 8.80814418e-02f, -1.79137409e-01f,
  1.10925898e-01f, -1.61427036e-01f, -1.41402036e-02f, -5.25644328e-03f, 1.20404340e-01f, 2.45050415e-01f, -6.43825009e-02f, -1.51575163e-01f, -9.69006047e-02f, 2.86417902e-01f,
  -1.54102668e-01f, -1.73435569e-01f, 1.04251523e-02f, -6.33594394e-02f, 4.96378653e-02f, 1.24622338e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.54464811e-01f, 1.24070235e-01f, 2.30159432e-01f, -4.63520288e-02f, -7.48758987e-02f, 1.04001276e-01f, 4.70014289e-02f, 1.95306584e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.08205592e-02f, -3.30730304e-02f, -1.44320540e-02f, 4.33008187e-02f, 1.62362456e-01f, -9.05935094e-02f, 4.01163027e-02f, -7.21477643e-02f, 1.28160790e-01f, 5.76695614e-02f,
  -1.92691416e-01f, 1.34876132e-01f, -4.53598537e-02f, -2.91365057e-01f, 1.29443765e-01f, -1.25488462e-02f, 1.86708272e-01f, -2.64117241e-01f, 6.63492605e-02f, 3.05981696e-01f,
  3.93278956e-01f, -3.19554538e-01f, -9.72238183e-02f, -4.12096493e-02f, -4.18070853e-01f, -2.18759507e-01f, -1.90026127e-02f, 8.83666500e-02f, 1.23139620e-02f, 8.32849964e-02f,
  2.33482003e-01f, 1.59015000e-01f, -1.25928193e-01f, -8.12222362e-02f, 5.45784645e-02f, 6.87810592e-03f, 2.79659390e-01f, 2.65470415e-01f, -6.26532286e-02f, 3.69967222e-02f,
  -5.65445870e-02f, -7.85898492e-02f, 3.31749380e-01f, -1.25694558e-01f, -2.85566747e-01f, -3.36790502e-01f, -1.46271527e-01f, 2.41380811e-01f, 2.94719011e-01f, -1.78624541e-01f,
  -8.97799581e-02f, -1.85048148e-01f, -1.42893136e-01f, -1.74980849e-01f, -3.65773320e-01f, -3.26280981e-01f, -1.86597630e-01f, 1.28469348e-01f, -2.57951245e-02f, 1.03935994e-01f,
  -4.03053403e-01f, -1.89672887e-01f, 5.48049398e-02f, -1.87518492e-01f, -1.54165611e-01f, -1.45557672e-01f, 9.87181887e-02f, -4.98185642e-02f, 9.87169072e-02f, 1.32763252e-01f,
  -1.79210380e-01f, -2.47248039e-01f, -2.44609639e-01f, 6.85795993e-02f, -7.66647682e-02f, 2.79544853e-02f, -1.85145527e-01f, 2.92005628e-01f, -1.67026088e-01f, 1.39049456e-01f,
  -3.13161202e-02f, 9.45938528e-02f, -1.12860471e-01f, -3.73121351e-01f, 4.41636220e-02f, 3.35265845e-02f, 2.07597747e-01f, 2.67724186e-01f, -2.61225492e-01f, 2.13289652e-02f,
  3.90087485e-01f, 8.20939913e-02f, 2.34732293e-02f, -1.19475182e-03f, -8.80648196e-02f, 1.66119151e-02f, 1.21498667e-01f, -4.81786840e-02f, 5.31146601e-02f, 1.77804649e-01f,
  -3.74918096e-02f, 4.89086322e-02f, 7.28010759e-02f, 2.83004403e-01f, 6.54065385e-02f, -4.12240103e-02f, -3.82296480e-02f, -6.29172893e-03f, 2.25195453e-01f, 5.65635338e-02f,
  -1.13127448e-01f, -4.18964148e-01f, 1.29047751e-01f, 2.39733413e-01f, -2.26776287e-01f, 1.22999899e-01f, 1.03950202e-01f, -1.76694617e-01f, -6.60914853e-02f, 2.11287197e-02f,
  3.62691075e-01f, -1.89036787e-01f, -1.76942050e-02f, -2.40939468e-01f, 1.12555817e-01f, 7.22599849e-02f, -1.05272584e-01f, -3.06116957e-02f, -8.60850811e-02f, 1.18725173e-01f,
  6.70536188e-03f, 1.43111944e-01f, -1.44362152e-01f, 1.45409092e-01f, -4.31083702e-02f, -3.28821354e-02f, -1.73149124e-01f, 6.40528351e-02f, -1.01136647e-01f, -5.29182367e-02f,
  7.23456591e-02f, 1.65013179e-01f, -1.58541471e-01f, 4.08305936e-02f, -2.27809586e-02f, 4.55893666e-01f, -1.39819950e-01f, -2.28647992e-01f, -4.39223707e-01f, 1.51971087e-01f,
  -4.21797335e-01f, -3.48112464e-01f, 1.58114776e-01f, 7.91874006e-02f, -8.83170515e-02f, -2.21327916e-02f, -3.11968215e-02f, 2.35790610e-01f, 2.09623307e-01f, -3.10357809e-02f,
  9.74320695e-02f, 1.57867223e-01f, 2.89885420e-02f, -2.80040298e-02f, 9.29669738e-02f, 1.79356903e-01f, -8.05843771e-02f, 2.70779669e-01f, -3.93185429e-02f, 1.65392846e-01f,
  -2.51341611e-02f, -1.89974353e-01f, 5.89111783e-02f, -2.00837165e-01f, 1.08413957e-01f, -2.54408240e-01f, -7.12315217e-02f, 2.53070090e-02f, 5.46142198e-02f, 3.64537269e-01f,
  -1.32864058e-01f, 1.15144573e-01f, -5.34431696e-01f, -3.88343692e-01f, 3.13884079e-01f, -1.03842840e-01f, -3.68632346e-01f, 8.17300975e-02f, 4.45774272e-02f, -6.98896125e-02f,
  -4.16026413e-02f, -2.25154147e-01f, 2.01591089e-01f, 1.39418885e-01f, 2.23459214e-01f, 2.14855000e-01f, 1.12894930e-01f, 2.55985081e-01f, 1.66232601e-01f, 1.02165736e-01f,
  -1.40813619e-01f, 5.17680869e-02f, 2.25418448e-01f, -1.34823518e-02f, -1.00412585e-01f, -3.83051306e-01f, -2.69620746e-01f, 1.34737387e-01f, 2.12137029e-03f, -2.79630214e-01f,
  1.87030956e-02f, 1.59830913e-01f, 8.63895714e-02f, -1.20100953e-01f, -4.00869429e-01f, -3.27248335e-01f, -2.27380306e-01f, -1.28056332e-01f, -1.67184934e-01f, 1.28709570e-01f,
  -2.91410953e-01f, -1.81503624e-01f, 1.53126284e-01f, -1.16176441e-01f, -2.80292481e-01f, -2.01328143e-01f, 1.30082980e-01f, -1.79592031e-03f, -3.34320986e-03f, -7.93687850e-02f,
  9.10500512e-02f, -6.41205683e-02f, -2.04363003e-01f, -2.66983449e-01f, 9.47335735e-02f, -5.40223606e-02f, -1.45410329e-01f, 2.16935650e-01f, -2.90617906e-02f, 1.77420065e-01f,
  1.10849902e-01f, 2.91574597e-01f, 1.10144541e-01f, -3.32400426e-02f, 8.37854762e-03f, 7.96516165e-02f, 8.24531019e-02f, 2.16689825e-01f, 4.84344102e-02f, -5.48499562e-02f,
  1.82779655e-01f, 7.06339404e-02f, -1.04453802e-01f, 2.73880899e-01f, -8.48078355e-02f, -1.89944915e-02f, 1.80203587e-01f, -6.65812045e-02f, -1.34651423e-01f, 6.54389933e-02f,
  -3.99944633e-02f, 1.51655376e-02f, 6.43488318e-02f, 1.06849000e-01f, -1.25933617e-01f, -1.92415446e-01f, -1.79085173e-02f, -1.61494359e-01f, 2.20667422e-01f, -7.54130930e-02f,
  6.48771226e-02f, -1.51878834e-01f, 7.28992671e-02f, 2.32556701e-01f, -3.28256413e-02f, 9.92075354e-02f, -2.57830918e-01f, -4.55878340e-02f, -2.48030603e-01f, -7.13093430e-02f,
  1.48600832e-01f, 6.99047819e-02f, 6.48384243e-02f, 1.33005291e-01f, -1.52433157e-01f, 1.07353032e-01f, 7.97593743e-02f, -2.57603198e-01f, -1.58480853e-02f, 4.80766669e-02f,
  -2.17265770e-01f, -3.87763679e-01f, 1.89364880e-01f, -1.18649311e-01f, 1.95591506e-02f, -1.95226520e-01f, -4.10699919e-02f, 7.33608082e-02f, -3.50024588e-02f, 3.14514816e-01f,
  -1.75216913e-01f, -1.41767129e-01f, 1.35226086e-01f, 2.64936835e-01f, -1.52322128e-01f, 4.04158570e-02f, -1.86694995e-01f, -4.04384732e-01f, 3.14438671e-01f, -1.69180438e-01f,
  3.88965249e-01f, 4.77565855e-01f, -3.09745729e-01f, -2.22913638e-01f, 1.08289741e-01f, -1.08284086e-01f, -7.36511871e-02f, -8.96024927e-02f, -1.37115613e-01f, 1.50573745e-01f,
  -6.12932481e-02f, 7.25273713e-02f, -8.60020816e-02f, -2.22993731e-01f, -6.17606118e-02f, 1.92764491e-01f, -9.43181142e-02f, -6.18933793e-03f, 1.93127930e-01f, 1.32634178e-01f,
  1.41602024e-01f, 1.07750654e-01f, -7.93409497e-02f, -2.82733768e-01f, -1.15222007e-01f, 1.74261227e-01f, -1.39701720e-02f, -4.08379704e-01f, 1.74530268e-01f, -2.36792207e-01f,
  1.69949010e-01f, -2.60233253e-01f, 7.50737488e-02f, -4.12316509e-02f, -2.32275069e-01f, 7.16562718e-02f, 2.05598280e-01f, -1.19243860e-02f, -2.09274575e-01f, -2.49515727e-01f,
  2.32702568e-02f, 2.05868453e-01f, -4.69575683e-03f, -1.36567116e-01f, -8.50609466e-02f, 1.30184777e-02f, 4.69693020e-02f, 2.07804665e-02f, 1.71785459e-01f, -8.22685361e-02f,
  1.13089085e-02f, 1.33522390e-03f, 1.92624584e-01f, 1.96716219e-01f, -5.07095940e-02f, -1.27992123e-01f, -1.90993026e-01f, 3.38323057e-01f, -2.18751188e-02f, -1.71276405e-01f,
  3.43668312e-02f, -4.19843057e-03f, 5.42518906e-02f, -1.97093770e-01f, 5.21376319e-02f, -2.62634344e-02f, -2.92892128e-01f, -1.60283536e-01f, -1.50890261e-01f, 2.33017579e-01f,
  -1.97576448e-01f, 6.48194179e-02f, 7.19761252e-02f, 1.82638407e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.16622441e-01f, 7.14792013e-02f, -1.39536873e-01f, 8.87049437e-02f, -1.84718877e-01f, -1.41036391e-01f, 1.58552766e-01f, -1.34364933e-01f, -1.63800105e-01f, 1.44876957e-01f,
  -6.48780316e-02f, -1.17953040e-01f, -1.43062666e-01f, 6.31589890e-02f, -2.10342091e-02f, 6.81248168e-03f, 5.59848791e-04f, -4.40739430e-02f, -1.57010153e-01f, 2.78917458e-02f,
  1.44319087e-01f, -2.85090338e-02f, 8.07075053e-02f, 5.20598032e-02f, -1.33433282e-01f, -1.03923865e-01f, -8.91190171e-02f, 5.99112920e-02f, 1.88117936e-01f, 1.96404621e-01f,
  -9.37215611e-02f, 1.26097426e-01f, 3.25103886e-02f, 5.05874790e-02f, 1.57171696e-01f, -1.80277780e-01f, -3.51386331e-02f, 8.36536214e-02f, 1.42179996e-01f, -6.89793080e-02f,
  -3.40629891e-02f, 6.93579018e-02f, -2.42423236e-01f, 7.39891035e-03f, -2.21591473e-01f, -9.73663181e-02f, 2.53577381e-01f, 4.16341610e-02f, -1.12355933e-01f, -1.10085547e-01f,
  -4.39074822e-03f, -2.18341455e-01f, -5.51261120e-02f, 1.52257681e-01f, 1.99343845e-01f, 3.17919374e-01f, -1.64322585e-01f, 1.00424998e-01f, 3.31499934e-01f, -2.97555663e-02f,
  -8.37438852e-02f, 1.13186799e-01f, 1.51792303e-01f, 1.09561682e-01f, 1.67324707e-01f, 1.91986874e-01f, 1.98777542e-01f, -7.22981524e-03f, 3.73117834e-01f, 3.75913262e-01f,
  6.53919652e-02f, 1.71494812e-01f, 1.27195895e-01f, 6.45179227e-02f, 3.17041636e-01f, 1.33173600e-01f, -4.23722953e-01f, -3.08420599e-01f, 5.78378662e-02f, 5.41888714e-01f,
  -7.19217286e-02f, -2.84411907e-01f, -1.10095851e-01f, -1.41153887e-01f, 3.05028051e-01f, -1.76802233e-01f, -2.75685310e-01f, 6.06697649e-02f, -2.28169084e-01f, 1.16342068e-01f,
  1.09014526e-01f, 3.67567778e-01f, -1.52804390e-01f, 2.75966167e-01f, 2.40823999e-01f, 3.52943361e-01f, -9.03473422e-02f, -8.36337730e-02f, 1.80203654e-02f, -1.59265622e-02f,
  1.47334129e-01f, -1.42612904e-01f, 1.92271813e-03f, -1.39408112e-02f, -7.67913759e-02f, -1.42894432e-01f, -2.18640398e-02f, -6.12733029e-02f, -1.00866802e-01f, 7.70175681e-02f,
  -1.01466089e-01f, -1.21757928e-02f, 5.24745956e-02f, 1.72061011e-01f, 1.42716795e-01f, 4.11750637e-02f, 1.42717227e-01f, -1.38072610e-01f, -7.37249404e-02f, 1.15068749e-01f,
  1.29680559e-01f, -9.27727576e-03f, 6.49315864e-02f, -2.29213480e-02f, 1.73323721e-01f, -1.34224743e-01f, -1.26102433e-01f, 6.60055131e-02f, -6.57733902e-02f, 2.43988156e-01f,
  1.03926219e-01f, 8.87977406e-02f, 4.17061907e-04f, 3.38488854e-02f, 8.55682194e-02f, -9.21826139e-02f, 4.68244292e-02f, 1.49563495e-02f, -9.38691497e-02f, -1.68208610e-02f,
  2.86279097e-02f, 3.82149294e-02f, -2.11570993e-01f, 8.85082930e-02f, -1.61779806e-01f, -1.30960653e-02f, -2.74891425e-02f, -9.28949863e-02f, -2.54526258e-01f, 2.97569279e-02f,
  6.88063130e-02f, 3.75666805e-02f, 2.08508253e-01f, -1.26192391e-01f, 1.42581880e-01f, -1.11343302e-01f, 1.77539989e-01f, -2.03098744e-01f, -1.53967693e-01f, 7.91414529e-02f,
  7.39479484e-03f, -3.39955501e-02f, 3.54705863e-02f, 7.09190965e-02f, -9.54218581e-02f, -6.03869632e-02f, 1.96259499e-01f, 1.51585385e-01f, -4.23691906e-02f, -3.18808816e-02f,
  7.00754672e-02f, 4.75373305e-02f, 1.15578987e-01f, -1.67041436e-01f, 1.69912368e-01f, 2.09226653e-01f, -2.73668505e-02f, -1.54510494e-02f, 2.55365148e-02f, -6.04550131e-02f,
  -7.41526932e-02f, -1.66260861e-02f, -5.95871024e-02f, 1.07657164e-01f, -1.65630043e-01f, -1.08241491e-01f, 1.56942904e-01f, -6.62868544e-02f, 1.06864702e-02f, 6.19345531e-02f,
  4.63199504e-02f, 2.29343414e-01f, 4.70564142e-02f, -4.02107984e-02f, 3.45828310e-02f, 1.29572913e-01f, 8.14011693e-02f, 1.05374850e-01f, -8.04167539e-02f, 1.46721363e-01f,
  2.20494226e-01f, 1.51940614e-01f, 2.10734755e-01f, 2.32063130e-01f, -1.36029869e-01f, -1.43127143e-01f, -4.48451117e-02f, 7.78577477e-02f, 1.73605084e-02f, -2.65828460e-01f,
  2.19482839e-01f, 1.31900072e-01f, 2.38756612e-01f, -1.33598328e-01f, -8.42997357e-02f, 3.18544284e-02f, -1.02785610e-01f, -8.69364142e-02f, 4.59780991e-02f, 5.13780280e-04f,
  -4.08445634e-02f, 6.54923636e-03f, 1.71141207e-01f, 9.15655121e-02f, -1.72239572e-01f, -6.54853582e-02f, 1.60448700e-01f, -1.04450889e-01f, -1.24978043e-01f, 1.07469939e-01f,
  -1.58297896e-01f, -2.73273699e-02f, -1.25683948e-01f, 1.60879716e-01f, -1.25636056e-01f, -5.76664284e-02f, -2.84145679e-02f, 1.01986252e-01f, 9.09604728e-02f, 1.75158307e-01f,
  -5.87718040e-02f, 1.59170106e-01f, -1.40469551e-01f, 7.11923689e-02f, 1.31851703e-01f, -1.08474120e-02f, -1.59085602e-01f, -4.77709882e-02f, 7.29120523e-02f, -1.50901601e-01f,
  -3.69905271e-02f, 3.96676920e-03f, -1.21704496e-01f, 1.33814197e-02f, -3.37262191e-02f, 1.42403036e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  5.19719012e-02f, -2.54065432e-02f, 3.95189226e-01f, -5.35572544e-02f, 2.68967688e-01f, 9.83293578e-02f, -9.76094082e-02f, -1.46163687e-01f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -5.61387874e-02f, -2.31761366e-01f, 1.90906987e-01f, -1.88774481e-01f, -5.17340982e-03f, 1.55364290e-01f, 5.38887978e-01f, 2.61260271e-01f, -6.50188550e-02f, 2.18604267e-01f,
  -1.18497044e-01f, 1.49753869e-01f, -1.66828156e-01f, -4.93820101e-01f, 1.45077094e-01f, -1.13498986e-01f, -2.60510650e-02f, -3.35860729e-01f, -4.67890024e-01f, 7.71701783e-02f,
  -2.90146917e-01f, 2.98518687e-01f, -2.19959058e-02f, -1.28483802e-01f, 1.68931615e-02f, 2.49428719e-01f, -1.15284726e-01f, 9.58246440e-02f, 1.57041952e-01f, 1.29077241e-01f,
  -1.09732956e-01f, -1.44194052e-01f, 1.60860009e-02f, 1.84453562e-01f, -1.71196416e-01f, -1.55239597e-01f, -3.75589252e-01f, 4.70101684e-02f, 1.80978462e-01f, 7.50745013e-02f,
  -1.44964457e-01f, 5.73070832e-02f, -3.72307301e-01f, -2.33568832e-01f, 2.81221032e-01f, 1.86448246e-01f, 4.85603660e-02f, 1.54182956e-01f, -2.07559332e-01f, -1.22124523e-01f,
  9.69359130e-02f, 1.82196766e-01f, 1.89007565e-01f, 2.64995873e-01f, 1.73872545e-01f, 8.87446776e-02f, -2.66967453e-02f, -4.86432239e-02f, 1.43617794e-01f, -1.21489074e-02f,
  -3.18998009e-01f, 1.20469242e-01f, 4.44139503e-02f, 1.65597767e-01f, -1.41029283e-01f, 1.78184211e-01f, -3.32723260e-02f, 2.59437054e-01f, -5.11932895e-02f, -1.44585446e-01f,
  -5.01196623e-01f, -2.66142011e-01f, -1.74873739e-01f, -2.49608204e-01f, -1.38639510e-01f, 1.59629993e-02f, 1.50157571e-01f, 5.65204442e-01f, -4.62997332e-02f, -1.57026604e-01f,
  2.72456467e-01f, -1.13720587e-02f, 3.55557114e-01f, 1.84533983e-01f, 1.44853160e-01f, 1.08310536e-01f, 3.26541513e-01f, 4.32232350e-01f, -1.82190403e-01f, -1.63683638e-01f,
  2.85809696e-01f, -1.99561566e-02f, -1.35401845e-01f, 7.80265331e-02f, 6.35722876e-02f, 2.13945787e-02f, -2.31187511e-02f, -4.88684699e-02f, 1.84311457e-02f, 1.93056867e-01f,
  -1.13812558e-01f, 8.62217173e-02f, -1.53516397e-01f, -1.73962712e-01f, -1.05776593e-01f, -1.04002848e-01f, 4.62653935e-02f, -2.69134015e-01f, 4.29386675e-01f, 2.05030024e-01f,
  1.16231263e-01f, -1.62744209e-01f, -3.55048746e-01f, -2.14997426e-01f, -2.80656200e-02f, 1.07761875e-01f, -1.29073747e-02f, 4.96937513e-01f, 3.90396595e-01f, 2.66462684e-01f,
  1.93217341e-02f, 1.10641606e-01f, 3.08102012e-01f, 1.16838843e-01f, -1.33965109e-02f, 4.68788631e-02f, 2.71624237e-01f, -1.01306863e-01f, -1.14596048e-02f, 1.48520142e-01f,
  -1.41579688e-01f, -1.63242891e-01f, 3.24150100e-02f, -3.03834230e-01f, -6.53144643e-02f, 1.03004783e-01f, 2.75271893e-01f, -4.26646806e-02f, 2.47996580e-02f, 2.49897718e-01f,
  -5.20661883e-02f, 2.03178182e-01f, -4.34553564e-01f, 2.78514117e-01f, 6.52231798e-02f, 4.68699843e-01f, 3.79824132e-01f, -2.88240165e-01f, 3.14821392e-01f, -3.68197888e-01f,
  -5.34412153e-02f, -1.32326171e-01f, 7.50025734e-02f, -2.46507734e-01f, -1.63933471e-01f, 1.37511864e-01f, -2.12920411e-03f, -1.28145754e-01f, -3.92339099e-03f, -1.12315658e-02f,
  1.11284636e-01f, 1.38007835e-01f, -9.64080729e-03f, 2.43339296e-02f, 3.24196890e-02f, 2.53120754e-02f, -4.00861233e-01f, -1.33199990e-01f, -1.65270269e-02f, 3.06505382e-01f,
  4.18329746e-01f, 1.48719892e-01f, 3.27504307e-01f, 2.25116730e-01f, -3.28762740e-01f, -6.72326013e-02f, -2.08022222e-01f, 5.02247810e-01f, 4.77468848e-01f, -2.09957615e-01f,
  -9.43292305e-02f, -2.90916502e-01f, 1.16897210e-01f, 1.56606555e-01f, -4.56281379e-02f, -1.86360702e-01f, 1.01880409e-01f, 9.53059494e-02f, -2.31765911e-01f, 5.67933843e-02f,
  2.01342791e-01f, 8.54573548e-02f, -3.93491268e-01f, -1.86665699e-01f, 1.23795070e-01f, -2.47659549e-01f, -1.05154486e-02f, -1.39490023e-01f, 3.94813642e-02f, 1.05901763e-01f,
  2.72648074e-02f, -1.70347407e-01f, -5.19932806e-01f, -1.64210498e-01f, -9.73482281e-02f, 1.69410706e-01f, -1.81774482e-01f, 2.03305513e-01f, 3.83176297e-01f, 1.33208394e-01f,
  2.58020997e-01f, 8.36491510e-02f, 2.76048511e-01f, -3.91278774e-01f, -3.18448007e-01f, -1.99221060e-01f, -6.72268867e-02f, -2.55957693e-01f, 6.83061257e-02f, -4.32217348e-04f,
  -7.39165172e-02f, 7.72538409e-02f, 1.06685139e-01f, 1.38685003e-01f, -2.07158342e-01f, -1.38847202e-01f, -4.47895601e-02f, -2.04741508e-01f, -5.61475717e-02f, -2.58474946e-01f,
  8.55885297e-02f, 2.25241587e-01f, 2.81788945e-01f, -9.22174081e-02f, 1.43055379e-01f, 1.72951356e-01f, -3.64265442e-01f, -2.43020236e-01f, -3.85676980e-01f, 2.76454926e-01f,
  3.63044530e-01f, 1.60044804e-01f, 1.47064358e-01f, -7.09920600e-02f, 2.19395280e-01f, -5.62170088e-01f, -2.96519607e-01f, -4.59261626e-01f, -2.43482273e-02f, -2.42945462e-01f,
  -3.39785665e-01f, 1.13990396e-01f, 8.15462694e-02f, -1.67289972e-02f, -2.03906059e-01f, -9.39404443e-02f, 2.63510793e-01f, 8.24833885e-02f, -9.23667997e-02f, -1.09611824e-01f,
  -8.51440579e-02f, 2.42190555e-01f, 5.46090826e-02f, -3.08537066e-01f, -1.96305141e-01f, 3.51224333e-01f, 7.29673803e-02f, -4.25806791e-02f, 3.00257415e-01f, 3.70771050e-01f,
  -9.31106582e-02f, 2.27547083e-02f, -5.03417253e-01f, -5.18486984e-02f, 3.72583091e-01f, -1.97207347e-01f, -2.95140684e-01f, 1.79441839e-01f, 3.90667200e-01f, 4.22546774e-01f,
  -7.04845712e-02f, -1.73878565e-01f, 2.08504319e-01f, -7.20578432e-02f, -2.53477064e-03f, -8.61657336e-02f, 3.00493628e-01f, -1.61715344e-01f, 1.63078204e-01f, 1.56167001e-01f,
  -1.95777938e-01f, 2.55619194e-02f, -8.77544377e-03f, -8.42639878e-02f, -1.79670349e-01f, 1.22871608e-01f, -5.16329519e-03f, -5.03506996e-02f, 1.89033359e-01f, -1.60527959e-01f,
  5.39478242e-01f, 2.95499891e-01f, -7.22381771e-02f, -2.87418902e-01f, -3.05977762e-01f, 4.44019958e-02f, 2.87230372e-01f, -3.01678739e-02f, 9.43710357e-02f, 6.57394752e-02f,
  3.15434515e-01f, 4.84589159e-01f, -4.55767438e-02f, -1.42313866e-02f, 5.80462515e-01f, -1.16659790e-01f, -1.70645460e-01f, 8.82491097e-02f, 1.67750329e-01f, 1.16861686e-01f,
  -1.67694435e-01f, -1.37755111e-01f, -1.50048524e-01f, -1.44587010e-01f, -1.79948047e-01f, 3.25862080e-01f, 6.10891245e-02f, 3.20002958e-02f, 3.00656799e-02f, 1.97035074e-01f,
  -5.57676442e-02f, 1.36730418e-01f, -1.65275261e-01f, -5.54746628e-01f, -2.70091474e-01f, 3.61539125e-01f, -2.73916930e-01f, 3.03351492e-01f, -2.97555357e-01f, 1.21243022e-01f,
  -2.02362332e-02f, -3.39890063e-01f, -3.38069290e-01f, -4.36262339e-01f, 8.65547732e-03f, -3.96922119e-02f, -5.36761165e-01f, -1.06153183e-01f, 1.24667391e-01f, -1.21358648e-01f,
  -7.34346285e-02f, -1.69205919e-01f, -5.44155501e-02f, 1.24626882e-01f, -8.27981904e-02f, -1.34480312e-01f, -2.53457785e-01f, -2.75313616e-01f, -2.33599246e-01f, -1.88391432e-01f,
  -3.95761311e-01f, -1.16154313e-01f, -2.89804310e-01f, -1.57460451e-01f, -1.21244885e-01f, 4.63091940e-01f, 4.33339149e-01f, -4.06026840e-01f, -1.07146174e-01f, -4.43338037e-01f,
  -3.58809978e-02f, 2.81099558e-01f, -9.17714760e-02f, 4.43615615e-01f, 2.86310494e-01f, 3.23803693e-01f, 1.78147584e-01f, 5.38669936e-02f, 2.86907256e-01f, -1.47663623e-01f,
  -1.75017774e-01f, -1.13884807e-01f, 4.95864898e-02f, 2.19138470e-02f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  2.54196614e-01f, -4.32956591e-02f, -2.16044873e-01f, 9.45294723e-02f, 3.17921907e-01f, -3.48176450e-01f, -2.58291334e-01f, 6.25781715e-02f, 5.41861020e-02f, -2.51263708e-01f,
  3.24183375e-01f, 4.02361788e-02f, -1.76618230e-02f, 1.95689574e-01f, -6.69232309e-02f, 1.80966169e-01f, 3.36225331e-01f, 1.99954346e-01f, 1.71601161e-01f, -1.28079355e-01f,
  2.41480634e-01f, -2.64248759e-01f, -1.72477365e-02f, -1.68338537e-01f, -1.28290019e-04f, -2.95220967e-02f, 1.82848901e-01f, 4.58055554e-04f, 2.12277442e-01f, -1.65247068e-01f,
  -4.82714772e-02f, -1.70342013e-01f, 1.28735065e-01f, -3.38160135e-02f, -1.15139708e-01f, -1.88512430e-01f, -6.84321299e-02f, 1.24954969e-01f, 1.49351224e-01f, -4.96671312e-02f,
  1.56673059e-01f, 2.99767852e-01f, 1.95158139e-01f, 6.79021701e-04f, 3.41169566e-01f, -1.99593037e-01f, -3.82291108e-01f, 1.96591705e-01f, 1.00093856e-02f, 4.16484386e-01f,
  2.17357785e-01f, -1.98177025e-01f, 7.94949383e-02f, -2.43381009e-01f, -1.42532438e-01f, -9.58949886e-03f, 2.59928815e-02f, -1.46034166e-01f, 5.31278811e-02f, -1.10481583e-01f,
  -2.10308805e-01f, 7.77845606e-02f, 1.00875892e-01f, 1.31473020e-01f, -8.18844363e-02f, -1.73733775e-02f, 2.46844217e-02f, -2.73467340e-02f, -1.85424402e-01f, -2.41647195e-02f,
  6.30560750e-03f, 1.02004215e-01f, -8.05358514e-02f, -4.21068668e-02f, -1.55251756e-01f, 1.14572845e-01f, -7.23018646e-02f, -1.26945615e-01f, -2.06924215e-01f, -2.71434970e-02f,
  -5.38466759e-02f, 2.44105384e-02f, -1.89330846e-01f, 2.19713107e-01f, 1.67867869e-01f, 1.15362510e-01f, -1.66658163e-02f, -3.15981060e-02f, 6.96216300e-02f, 1.21595718e-01f,
  6.80585057e-02f, -1.60308689e-01f, 1.08692974e-01f, -1.39980361e-01f, 6.18199992e-04f, 9.27628577e-02f, -1.50402218e-01f, -6.23923689e-02f, 1.38341323e-01f, -1.24514364e-01f,
  -9.30741057e-02f, -1.87007532e-01f, -9.96699259e-02f, -1.40258729e-01f, -2.97907591e-02f, -2.08199292e-01f, -1.83799919e-02f, -1.43312573e-01f, 1.39866143e-01f, -8.13964903e-02f,
  -7.89981708e-02f, -1.44186690e-01f, -7.21120387e-02f, -1.59728587e-01f, -1.02942906e-01f, 2.01533828e-02f, -1.47191480e-01f, 1.19769491e-01f, 1.50738567e-01f, 7.06550255e-02f,
  1.07390985e-01f, 9.26999524e-02f, -2.75673997e-02f, 4.15156595e-02f, -3.06512304e-02f, -1.56613305e-01f, -1.21606067e-01f, 7.41513893e-02f, -4.37821262e-02f, -1.63572073e-01f,
  1.07306100e-01f, 1.09532647e-01f, -5.04497550e-02f, -1.23311346e-02f, -4.08779196e-02f, 9.31417048e-02f, -2.47795537e-01f, -3.16420645e-01f, -6.76335767e-02f, 1.28904611e-01f,
  7.58213326e-02f, -7.35680535e-02f, 5.18513806e-02f, -1.33630469e-01f, -1.77605361e-01f, -1.15863562e-01f, -2.92811751e-01f, 1.42314211e-01f, 1.53632298e-01f, 2.57693321e-01f,
  1.49656951e-01f, 1.24815561e-01f, 1.76200017e-01f, 7.61038810e-02f, 7.72986785e-02f, 1.44119874e-01f, -9.92748588e-02f, 5.81086650e-02f, 1.12870768e-01f, 1.45695657e-01f,
  -1.03014685e-01f, 6.42456412e-02f, -7.77442157e-02f, -1.24488302e-01f, -1.02239668e-01f, 2.63814311e-02f, -3.23358215e-02f, 3.79990973e-02f, 2.65110433e-02f, 6.46153232e-03f,
  8.85359496e-02f, -1.73120126e-01f, 1.37024969e-02f, -9.17075276e-02f, 4.80354689e-02f, -3.05899046e-02f, -1.49065942e-01f, -1.39808983e-01f, 2.36963425e-02f, 3.02139986e-02f,
  1.23952731e-01f, 2.60937829e-02f, -1.09661348e-01f, -2.42796503e-02f, 3.92168760e-02f, -1.36152893e-01f, -4.91436385e-02f, -1.50615141e-01f, 2.19793990e-03f, -1.54286355e-01f,
  9.22244042e-02f, -4.58844379e-02f, 4.67473209e-01f, 3.63743186e-01f, 2.14096397e-01f, 1.90475464e-01f, 5.57045281e-01f, 2.67981797e-01f, 2.14483842e-01f, 1.10756144e-01f,
  3.45162213e-01f, 4.42799121e-01f, 5.05841017e-01f, 2.70670474e-01f, -3.36572617e-01f, -2.87475914e-01f, 1.00625403e-01f, 3.90271127e-01f, -4.72088382e-02f, 2.74407029e-01f,
  3.21456164e-01f, -3.24377745e-01f, 5.69694825e-02f, -3.29836935e-01f, 5.62411211e-02f, -9.90275145e-02f, 2.64518009e-03f, 3.07605993e-02f, -1.73719272e-01f, -1.20970555e-01f,
  2.03807846e-01f, -9.24565867e-02f, 7.32769370e-02f, -1.67204633e-01f, 2.05280762e-02f, 3.19831699e-01f, 2.40266114e-01f, 6.47563636e-02f, 1.69486597e-01f, 3.54044497e-01f,
  2.25783363e-01f, 1.98500052e-01f, 2.50561275e-02f, 1.60139948e-02f, 1.14256819e-03f, 1.55028924e-01f, 1.90447439e-02f, 1.48505285e-01f, 9.37690213e-03f, -2.35085577e-01f,
  -1.52174905e-01f, -2.71211535e-01f, -9.77065414e-02f, -4.60350849e-02f, -2.26150438e-01f, 3.35423410e-01f, 3.62057209e-01f, 4.58622158e-01f, 8.72859673e-04f, 2.35516027e-01f,
  8.57251525e-01f, -3.38497944e-02f, 1.88982919e-01f, 2.23704189e-01f, 2.93771505e-01f, 1.70803308e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  -2.65932623e-02f, 3.42236936e-01f, -3.13562453e-02f, 9.69991758e-02f, -8.07934701e-02f, -1.06581807e-01f, 1.49388224e-01f, 1.87101945e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  3.17718387e-01f, 8.42809230e-02f, 4.10065323e-01f, -2.42665842e-01f, -5.49512446e-01f, 5.47190309e-01f, -8.24067518e-02f, -4.85943258e-01f, 2.70843804e-01f, 5.88645041e-01f,
  7.82965124e-01f, -2.00753793e-01f, -5.94593525e-01f, 2.15811352e-03f, -2.71259993e-01f, -5.11912465e-01f, 1.08019292e-01f, 9.66501981e-02f, 5.65784276e-01f, 3.91877264e-01f,
  -5.30526996e-01f, -1.13837227e-01f, 2.14396343e-01f, -2.81606495e-01f, 4.37517017e-01f, 3.25335503e-01f, 6.24736063e-02f, 9.49910879e-02f, -1.84228614e-01f, 1.06699437e-01f,
  1.70862928e-01f, -6.17633164e-01f, -5.22741536e-03f, -3.46964560e-02f, 3.04655612e-01f, 3.30154777e-01f, 1.50238425e-01f, 5.08064210e-01f, -1.16903685e-01f, -2.09238291e-01f,
  -9.90416273e-04f, 7.00260475e-02f, -3.18821669e-01f, 7.03418195e-01f, 6.21599853e-01f, 7.08271563e-02f, -1.05844490e-01f, 5.39039314e-01f, -6.39641404e-01f, 2.79901743e-01f,
  -3.65996599e-01f, -8.47580850e-01f, 2.52061993e-01f, 7.13806570e-01f, -7.04906762e-01f, -6.26629293e-02f, -2.36640334e-01f, -4.86049712e-01f, -1.77368209e-01f, -3.87527980e-02f,
  -2.93899477e-01f, -1.46681860e-01f, 3.00058424e-01f, 4.56587821e-01f, 2.75746495e-01f, -2.42319643e-01f, -1.45403787e-01f, -3.84722471e-01f, -1.49666935e-01f, 2.88159460e-01f,
  6.09411001e-02f, -1.60543278e-01f, -6.27618670e-01f, -2.75600106e-01f, -2.46242862e-02f, -3.55226994e-01f, 1.14328235e-01f, 4.07354563e-01f, 5.21360636e-01f, -8.19588602e-02f,
  -4.66986746e-01f, 1.44520327e-01f, -1.94644466e-01f, 1.01534218e-01f, 7.75277391e-02f, -2.02670306e-01f, 3.62023264e-01f, 6.35740697e-01f, -7.47170597e-02f, -2.20902935e-01f,
  1.01021722e-01f, -2.04283938e-01f, 1.06048565e-02f, -6.90600798e-02f, -5.43753445e-01f, 5.59358120e-01f, -6.94711804e-02f, -4.56997126e-01f, -7.82700360e-01f, -6.74871624e-01f,
  -1.32925026e-02f, 3.25521946e-01f, 1.19684227e-01f, -3.26878428e-01f, 3.33732017e-03f, -2.21556455e-01f, -4.53822047e-01f, -2.99546510e-01f, 4.32558864e-01f, -6.54781237e-02f,
  -4.77417596e-02f, -4.09835100e-01f, 2.44171157e-01f, -1.47703812e-02f, 3.37996542e-01f, 1.74595818e-01f, -3.66131514e-01f, -6.71231329e-01f, 5.44125497e-01f, 4.08913553e-01f,
  9.69558805e-02f, 1.98742151e-01f, -2.32828557e-01f, -3.55517007e-02f, -1.88252833e-02f, 1.63751364e-01f, 4.93759334e-01f, -6.58381999e-01f, -2.29845092e-01f, -2.47102007e-01f,
  3.55949551e-01f, 3.66957814e-01f, -3.35504651e-01f, -2.25930259e-01f, 4.56634641e-01f, 3.25245023e-01f, 6.19053006e-01f, 4.77719992e-01f, 5.25212228e-01f, -5.84840029e-02f,
  -6.34278059e-01f, -2.78492928e-01f, 3.74153018e-01f, -6.43274903e-01f, 3.86139303e-01f, 4.42154169e-01f, 1.65781192e-03f, 1.01525581e+00f, 2.76789572e-02f, 6.33331418e-01f,
  -3.94723147e-01f, -8.24684203e-02f, 4.80103195e-01f, -6.54034764e-02f, -7.61471093e-02f, -1.42146572e-01f, -4.13566679e-02f, -4.54677716e-02f, 5.78113019e-01f, -2.36228585e-01f,
  4.51906353e-01f, 2.67272443e-01f, 7.40834475e-01f, 3.33379239e-01f, 3.83194178e-01f, -5.34259737e-01f, 1.68600202e-01f, 5.60943663e-01f, -2.20256835e-01f, -4.32467163e-01f,
  5.36953628e-01f, -1.90336227e-01f, -5.72092354e-01f, 2.77989864e-01f, -4.60347496e-02f, 1.85219541e-01f, 2.04207480e-01f, 2.18236357e-01f, -2.17666894e-01f, -3.71716291e-01f,
  3.22050720e-01f, 6.57388866e-01f, -7.83605933e-01f, -3.23451430e-01f, -2.03060418e-01f, 3.99340540e-01f, -1.43859074e-01f, -2.19409075e-02f, -1.58934146e-01f, -1.66757271e-01f,
  3.18201214e-01f, 1.37836397e-01f, 1.05448104e-01f, 1.03950717e-01f, -1.00512460e-01f, -3.43736053e-01f, 5.27938485e-01f, -7.23179996e-01f, 2.75155693e-01f, -6.66749895e-01f,
  -4.68083948e-01f, -1.40665695e-01f, -7.51483977e-01f, 6.75111353e-01f, -7.28330970e-01f, 6.52090907e-02f, 5.90710998e-01f, 3.25526208e-01f, -1.05645232e-01f, -2.14916188e-02f,
  -3.02262485e-01f, -5.25072515e-01f, 5.81311211e-02f, -2.13248372e-01f, -2.86557794e-01f, 4.01882708e-01f, -3.17150354e-01f, 1.05346479e-01f, -1.07638374e-01f, 1.28050476e-01f,
  -2.66411483e-01f, -1.00583710e-01f, -2.74655700e-01f, 4.67293769e-01f, 1.46780297e-01f, 3.96478564e-01f, 2.15122312e-01f, 1.09930197e-02f, 2.04664260e-01f, -9.95403454e-02f,
  -4.02972847e-01f, -3.25115383e-01f, -5.74273467e-01f, -1.93218589e-01f, -2.50062317e-01f, -2.92104751e-01f, 2.93878764e-01f, 3.62736657e-02f, -5.40281713e-01f, -6.39517128e-01f,
  -1.64413955e-02f, -6.39370978e-01f, 5.30375779e-01f, 7.22253144e-01f, -4.77306157e-01f, -7.09249496e-01f, 6.77352548e-01f, -4.65064824e-01f, -1.66513592e-01f, 9.92234983e-03f,
  2.67045617e-01f, 1.78157181e-01f, 1.35934725e-01f, -1.02857992e-01f, -6.36501849e-01f, -2.86908716e-01f, -5.10932386e-01f, 1.27842724e-01f, 1.82363644e-01f, -3.34281772e-01f,
  -5.04681706e-01f, 1.95164323e-01f, -4.70735013e-01f, -5.75492024e-01f, 4.11500156e-01f, -4.18970734e-01f, -6.32425547e-01f, -1.00650571e-01f, 3.13191146e-01f, -1.26566708e-01f,
  1.58635224e-03f, 3.71139556e-01f, -1.90807790e-01f, -4.90330458e-01f, -1.00093566e-01f, -1.62165791e-01f, 3.33711773e-01f, 1.93174049e-01f, -2.40790874e-01f, 6.92989111e-01f,
  -1.47730410e-01f, -2.99307048e-01f, 1.66645974e-01f, 9.55334529e-02f, 3.77085000e-01f, -2.94196848e-02f, -6.81461871e-01f, 3.71526867e-01f, -6.80320740e-01f, 1.20259449e-01f,
  -2.29445860e-01f, 3.78749073e-01f, -1.46053396e-02f, -4.86274779e-01f, 2.90363610e-01f, 6.60368621e-01f, 1.44138008e-01f, -5.75850129e-01f, -5.63748121e-01f, 2.56898344e-01f,
  -3.71412218e-01f, -1.42168999e-01f, 7.96512067e-01f, 3.50701392e-01f, 5.12001693e-01f, 1.46159111e-02f, 8.82474482e-02f, -3.26024920e-01f, 3.81076634e-01f, 5.78674078e-02f,
  -5.86867511e-01f, -3.01822454e-01f, 5.51395357e-01f, 1.70704573e-01f, 1.10954657e-01f, -1.36023328e-01f, -5.38338013e-02f, -1.21844718e-02f, -2.02267706e-01f, 1.34782687e-01f,
  -6.50886178e-01f, -2.46760577e-01f, -4.68244225e-01f, 1.54910266e-01f, 2.01004595e-01f, 1.32501900e-01f, 1.43197523e-02f, 6.64486468e-01f, 3.43560308e-01f, 2.05141991e-01f,
  3.95580471e-01f, 1.13841484e-03f, 5.23779690e-01f, -2.74815142e-01f, -3.14499557e-01f, -7.65729994e-02f, -7.37917602e-01f, -6.41302764e-01f, -3.97305906e-01f, -6.15144670e-02f,
  -5.75894833e-01f, -7.64412642e-01f, 2.13925019e-01f, -2.55453825e-01f, 9.70837250e-02f, -3.68776858e-01f, -1.09605491e-01f, -1.61044717e-01f, -1.79588199e-01f, 1.25245064e-01f,
  3.55727464e-01f, 2.38871556e-02f, 2.30499044e-01f, 1.71741992e-01f, -4.63376075e-01f, 3.16846848e-01f, 5.24981439e-01f, 2.78276801e-01f, -9.64057520e-02f, 8.27716529e-01f,
  1.98799625e-01f, 6.87106013e-01f, 3.47232193e-01f, -4.00019109e-01f, 5.38924634e-01f, -1.15623288e-01f, -6.24900103e-01f, 1.12059176e-01f, 2.68455237e-01f, 5.76234639e-01f,
  -4.05107886e-01f, -1.16500013e-01f, 5.97762764e-01f, 4.30190533e-01f, 4.12403792e-01f, -1.41044021e-01f, -1.68059513e-01f, 3.85911703e-01f, -1.16970748e-01f, 7.40756616e-02f,
  -1.01899430e-01f, -1.46112218e-01f, 2.13117510e-01f, -1.60297960e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -6.48863614e-02f, -6.14391966e-03f, -1.38255000e-01f, 7.33884126e-02f, -1.19487643e-01f, -2.00074222e-02f, -1.71566725e-01f, 1.33751482e-01f, 3.00731771e-02f, -9.78129283e-02f,
  1.23067498e-01f, -4.87378798e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    