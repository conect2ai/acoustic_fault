/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.05334567e-02f, -6.36279210e-02f, -5.70209771e-02f, -1.90483239e-02f, 5.19220792e-02f, 5.86817451e-02f, 2.36605659e-01f, 5.74039854e-03f, -6.71814978e-02f, 1.15920752e-01f,
  2.59168167e-02f, 4.96332394e-03f, -1.06198475e-01f, -9.89937037e-02f, 2.06401721e-02f, 1.64730191e-01f, 9.45087373e-02f, 9.71625075e-02f, 1.00747608e-01f, -3.01656704e-02f,
  -4.65283915e-03f, 1.41904518e-01f, -7.98043311e-02f, 7.67699033e-02f, -6.55810386e-02f, -2.88485438e-02f, -1.15189888e-01f, -1.46151185e-01f, -4.37425300e-02f, -5.55799119e-02f,
  -2.49054208e-01f, -1.44829825e-01f, -5.26011176e-02f, 7.27288648e-02f, -4.61781397e-02f, 2.69493423e-02f, -4.81996872e-02f, -9.51369945e-03f, 8.05980936e-02f, -5.93658276e-02f,
  -6.31001666e-02f, 3.19312885e-02f, -1.27973524e-03f, 4.12924699e-02f, 5.81149347e-02f, 2.46375857e-04f, -7.47648906e-03f, 3.12904129e-03f, 8.29158723e-02f, -4.52097543e-02f,
  7.19082803e-02f, 3.71540524e-02f, 7.62753859e-02f, -1.22870877e-02f, 7.89223984e-02f, -4.70910855e-02f, -1.63584992e-01f, -1.44990653e-01f, -3.22123468e-02f, -1.90552041e-01f,
  -4.99638021e-02f, 9.53016952e-02f, 8.21903870e-02f, -3.48004848e-02f, 8.58931690e-02f, 5.60898557e-02f, 6.29937053e-02f, 1.28337085e-01f, 4.34528813e-02f, 6.67664334e-02f,
  1.11986235e-01f, 7.28415996e-02f, 2.87249479e-02f, 1.03966475e-01f, 7.18816444e-02f, 9.65589955e-02f, 8.59314650e-02f, 1.10922106e-01f, 4.16040942e-02f, 8.53579789e-02f,
  9.25147682e-02f, -3.28632537e-03f, 4.99498062e-02f, 1.41612396e-01f, 1.48714274e-01f, 1.20960558e-02f, 3.57047617e-02f, 1.01598822e-01f, -5.39560104e-03f, 4.73634936e-02f,
  1.60863046e-02f, -6.12863898e-02f, -1.36730792e-02f, -4.17316891e-03f, 9.34075937e-02f, 2.23906338e-02f, 5.69950938e-02f, 2.36607939e-02f, -5.38793281e-02f, 3.83171886e-02f,
  3.72238690e-03f, -4.50524278e-02f, -5.81464469e-02f, 3.58790858e-03f, 1.07217059e-02f, -5.46440892e-02f, 5.10816649e-03f, 6.96500065e-03f, -1.49394833e-02f, 3.51746157e-02f,
  3.06728501e-02f, 4.95555028e-02f, 8.35910290e-02f, -7.66629055e-02f, -4.66194265e-02f, 1.02006748e-01f, -1.31037891e-01f, -5.64115271e-02f, 1.90708321e-02f, -1.13162631e-02f,
  3.09660733e-02f, 3.04170400e-01f, 1.03395082e-01f, 7.83504397e-02f, -7.14859962e-02f, -1.89068437e-01f, 1.42461136e-01f, -3.99809591e-02f, -6.82045594e-02f, 2.57622421e-01f,
  1.40236184e-01f, -6.15340546e-02f, 7.11025484e-03f, 3.20301764e-02f, 6.98421523e-02f, 2.28055641e-01f, 2.97174543e-01f, 7.09279925e-02f, -3.86927038e-01f, -2.27691174e-01f,
  -7.55816989e-04f, -3.87813784e-02f, 2.94519346e-02f, -1.08006418e-01f, 1.27422020e-01f, -2.40389556e-01f, 6.84501678e-02f, 6.12412244e-02f, -5.76427253e-03f, 3.24231654e-01f,
  5.18727414e-02f, 8.23090002e-02f, -6.38540164e-02f, 1.82247795e-02f, -7.49951601e-02f, -9.20614377e-02f, -3.61369960e-02f, 1.19339570e-01f, 2.38060122e-04f, 7.44000301e-02f,
  3.58706759e-03f, 1.11768125e-02f, 6.06859960e-02f, 4.39190445e-03f, -1.04775047e-02f, -6.88543096e-02f, 6.70504645e-02f, 6.65874183e-02f, 7.32740015e-02f, 5.38459653e-03f,
  -2.93814689e-02f, 8.55471864e-02f, 6.08847067e-02f, -5.88515513e-02f, -7.97921866e-02f, -4.21164781e-02f, 2.30937563e-02f, -1.99607690e-03f, -3.99950184e-02f, 1.08927302e-01f,
  -6.57418370e-02f, -3.64202112e-02f, -1.93177313e-02f, -2.93558929e-02f, -5.29036000e-02f, -4.60298620e-02f, -6.63300604e-03f, -6.57939613e-02f, -8.05089399e-02f, 7.25617036e-02f,
  -2.99933609e-02f, 2.56411843e-02f, -6.04590774e-03f, -1.86077710e-02f, 2.90002245e-02f, -3.47660459e-03f, 2.66095940e-02f, -9.32460576e-02f, 4.62974189e-03f, -5.36515415e-02f,
  3.38612270e-04f, -2.49648318e-02f, -3.63697074e-02f, -1.52368266e-02f, 3.70534174e-02f, -3.88275385e-02f, -4.57538813e-02f, -3.18088643e-02f, -5.40243685e-02f, -4.59452234e-02f,
  -1.91391692e-01f, -3.17262672e-02f, 7.52147883e-02f, 1.90086402e-02f, -6.26084059e-02f, -3.02559417e-02f, 4.24262807e-02f, -3.34537514e-02f, 7.19359741e-02f, -4.71699797e-02f,
  -5.42330183e-03f, -4.92447056e-02f, 9.79095101e-02f, 3.49737667e-02f, 1.47111863e-02f, -7.20341131e-02f, 9.16770548e-02f, -9.87726524e-02f, -1.50905317e-02f, 2.38168929e-02f,
  2.72244476e-02f, -1.88132480e-01f, -2.76431262e-01f, -4.06850539e-02f, -5.49496301e-02f, -2.50033200e-01f, -1.36585861e-01f, -1.04264267e-01f, -5.44884913e-02f, -1.49289325e-01f,
  3.95641357e-01f, -2.43427083e-01f, -2.69675441e-02f, -2.41935700e-02f, -1.15540095e-01f, -2.51723409e-01f, -3.84032220e-01f, -1.78848848e-01f, -5.54001294e-02f, -1.68184653e-01f,
  -2.01324627e-01f, -4.51185480e-02f, -2.42024846e-02f, 7.75252655e-02f, 6.70049340e-02f, -1.16586998e-01f, 1.16789080e-01f, 4.21459258e-01f, 2.69351691e-01f, -9.27405432e-02f,
  7.41914362e-02f, 2.92945117e-01f, 3.61761361e-01f, 1.22103930e-01f, 9.19718891e-02f, 1.26296639e-01f, 7.68181728e-03f, 4.55185175e-02f, 1.11893043e-01f, 3.35124373e-01f,
  -1.05466172e-02f, -8.08541775e-02f, -2.00412478e-02f, 2.98089776e-02f, 2.69545875e-02f, -1.41375978e-02f, 3.70934680e-02f, 5.23643866e-02f, -1.09349452e-01f, -6.28977129e-03f,
  -8.41424689e-02f, 7.03063458e-02f, -2.24527176e-02f, 6.49347231e-02f, -1.80011000e-02f, -4.33837966e-04f, -6.91590309e-02f, 9.18092728e-02f, 5.38754761e-02f, -1.95865422e-01f,
  -4.90112714e-02f, -4.89814766e-03f, -5.06299958e-02f, -1.44930676e-01f, -4.36152779e-02f, 3.30942944e-02f, -5.14527112e-02f, -8.32104832e-02f, 1.16163127e-01f, -1.69851761e-02f,
  6.96967356e-04f, -3.64129283e-02f, -1.51541708e-02f, 1.16824382e-03f, 3.53483781e-02f, 9.49522108e-03f, 2.69610044e-02f, 8.17032233e-02f, 3.15849110e-02f, -4.48412588e-03f,
  -5.68427518e-02f, 3.07081118e-02f, -7.78522948e-03f, -1.34090753e-02f, 6.75643831e-02f, 4.90063382e-03f, 2.18339767e-02f, 2.98290085e-02f, 9.38349683e-03f, 6.62306100e-02f,
  1.20568551e-01f, -3.19808722e-02f, 2.10722126e-02f, 2.66056098e-02f, 9.13344100e-02f, 8.26324001e-02f, 5.40100299e-02f, 6.39728904e-02f, -8.73945355e-02f, -9.87671092e-02f,
  -1.31536156e-01f, -1.67481024e-02f, -2.09290460e-02f, 1.63868219e-02f, -3.22991498e-02f, -8.74655247e-02f, -1.25625223e-01f, -3.35045569e-02f, 2.69370154e-02f, -2.98059061e-02f,
  -4.83979546e-02f, -1.14457078e-01f, -1.11814111e-01f, -4.22191657e-02f, -5.08020259e-02f, -6.66450709e-02f, -3.00488304e-02f, -1.03580160e-03f, -3.00842337e-02f, -3.91690135e-02f,
  -6.42946586e-02f, 1.28527135e-02f, -1.33371606e-01f, -1.24408916e-01f, -1.26272976e-01f, 1.19662419e-01f, -7.06470758e-02f, -6.05914854e-02f, 8.69959369e-02f, -1.17394499e-01f,
  -7.64256239e-01f, 1.98654443e-01f, 2.09709272e-01f, -3.45536098e-02f, 9.88420472e-02f, -1.06809929e-01f, -1.30548961e-02f, -4.63164449e-02f, 6.84201196e-02f, 1.13575369e-01f,
  -1.06688045e-01f, -8.65079165e-02f, 5.30406088e-02f, -6.79530483e-03f, -1.55820772e-01f, 1.36720225e-01f, 2.38467574e-01f, -3.66597697e-02f, -2.45225415e-01f, -1.93008199e-01f,
  1.04027011e-01f, 3.02296188e-02f, -1.73182279e-01f, -1.00845084e-01f, 3.22468609e-01f, 5.05592562e-02f, 1.97847456e-01f, -2.80162157e-03f, 9.36797261e-02f, 4.43450123e-01f,
  -2.31785001e-03f, -6.01254357e-03f, 1.93505846e-02f, 1.03533892e-02f, 1.50035009e-01f, -4.57820483e-03f, -3.70908086e-03f, 6.45134747e-02f, 2.22382247e-02f, 7.43171647e-02f,
  5.79580069e-02f, 7.17256293e-02f, 7.37520084e-02f, 9.07284841e-02f, 2.27681901e-02f, -8.37027654e-02f, 7.23875836e-02f, 3.18073705e-02f, 9.00379568e-02f, 3.45404483e-02f,
  1.51026279e-01f, 3.00677512e-02f, -6.36866540e-02f, 3.77328135e-02f, 4.08484749e-02f, 9.40377563e-02f, 7.86161199e-02f, 3.39706913e-02f, 8.63404125e-02f, 2.53429823e-02f,
  6.67074919e-02f, 3.60454209e-02f, 1.73883978e-02f, 1.77138001e-02f, -6.92501292e-02f, 4.23062034e-02f, -1.77769661e-02f, 2.93714972e-03f, 3.42135169e-02f, 3.73678585e-03f,
  3.62551995e-02f, 2.21997313e-02f, 8.99471343e-02f, -3.90070975e-02f, 1.69883464e-02f, -1.34267416e-02f, -5.44165634e-02f, 2.05402076e-02f, 8.41258317e-02f, -7.61579350e-02f,
  5.38402386e-02f, -6.68825433e-02f, -4.13634721e-03f, 3.71114910e-02f, 3.64157669e-02f, 1.15567939e-02f, 5.00922315e-02f, -3.14878635e-02f, 2.50757523e-02f, 3.09861396e-02f,
  -1.47064418e-01f, 1.42406654e-02f, 2.80129667e-02f, -5.84652834e-02f, 1.79814808e-02f, 1.15696779e-02f, 2.34573521e-02f, 3.30412015e-02f, 1.21370899e-02f, 4.89034178e-03f,
  -1.02788568e-01f, -2.13870369e-02f, -1.08963242e-02f, 2.31395271e-02f, -2.14506243e-03f, -3.17228921e-02f, -1.64885465e-02f, -5.07609546e-02f, 2.46994011e-02f, -1.57609268e-03f,
  -8.23355280e-03f, -3.67748970e-03f, -1.71211913e-01f, -7.07040653e-02f, 5.02687395e-02f, -1.12124316e-01f, -1.57706887e-02f, -2.34669149e-02f, -1.76049173e-01f, -8.41930211e-02f,
  -4.66276497e-01f, -3.68375368e-02f, 1.79731056e-01f, -1.99289292e-01f, 2.83565700e-01f, 3.09750587e-01f, 4.69265103e-01f, 9.01889801e-02f, -1.43617630e-01f, 2.50408441e-01f,
  1.27226710e-01f, -2.90887475e-01f, -2.83182830e-01f, -1.89555436e-01f, -1.65926546e-01f, 3.13237458e-01f, 1.34834692e-01f, -1.35384470e-01f, -9.59922075e-02f, 1.73492849e-01f,
  1.14819780e-01f, -8.69350955e-02f, -1.94411412e-01f, -2.34818712e-04f, 2.02914089e-01f, 8.01528841e-02f, 1.00691177e-01f, 7.00358599e-02f, 1.20014369e-01f, -8.36233981e-03f,
  3.65072638e-02f, -3.49994041e-02f, -6.09191367e-03f, -1.47792041e-01f, 9.36139077e-02f, -1.39925405e-01f, 6.38239086e-02f, -3.69725339e-02f, 4.16851006e-02f, -6.16133399e-02f,
  -7.29790628e-02f, -1.14030533e-01f, -9.53023359e-02f, 9.62646957e-03f, 1.13500118e-01f, 8.27413239e-03f, 1.03935422e-02f, -1.55872628e-01f, -4.09925096e-02f, 6.55345917e-02f,
  -2.03779805e-02f, -2.09005475e-02f, 1.01534806e-01f, 1.16607293e-01f, -8.49325135e-02f, -3.08667887e-02f, -6.64346293e-03f, 1.23963952e-02f, 4.86306474e-03f, 4.87595201e-02f,
  6.39616847e-02f, 5.38097471e-02f, -9.84753715e-04f, -6.72979746e-04f, -1.84654165e-02f, 1.74316876e-02f, -6.24014288e-02f, -4.19725329e-02f, -3.23363543e-02f, 1.27959862e-01f,
  -2.68452670e-02f, -3.05870478e-03f, 4.68418701e-03f, 1.47595955e-02f, 4.34440887e-03f, 1.53047098e-02f, 2.31444817e-02f, -1.52083952e-02f, -1.45077622e-02f, 5.11574410e-02f,
  -4.31193225e-02f, 5.50074875e-02f, 2.10648943e-02f, -8.43390226e-02f, -2.83861011e-02f, -3.44609208e-02f, -7.72977769e-02f, -1.87015552e-02f, -2.10900400e-02f, -5.51130064e-02f,
  1.42291203e-01f, -1.36422977e-01f, 8.11197013e-02f, -1.40264273e-01f, 5.61723821e-02f, -5.14720455e-02f, 3.67782973e-02f, -5.67052476e-02f, 2.72140484e-02f, -7.76583254e-02f,
  -4.48890179e-02f, -2.18839608e-02f, 9.62737110e-03f, 7.93805346e-02f, 6.60198256e-02f, 2.05456447e-02f, -1.08965319e-02f, 1.79146824e-03f, -4.72622141e-02f, 1.05279833e-01f,
  1.14889201e-02f, 1.06780767e-01f, 4.66301590e-02f, -5.57947159e-02f, -4.00110595e-02f, -3.06234509e-02f, 1.50724202e-01f, 8.59864578e-02f, 2.15613749e-02f, 2.44733915e-01f,
  -2.70609349e-01f, -6.71847939e-01f, 2.44316667e-01f, -4.63042893e-02f, 9.76896286e-02f, 1.15524940e-01f, -1.25182807e-01f, -1.61030099e-01f, -5.23206294e-02f, -1.69269145e-01f,
  -2.44254068e-01f, 1.87825114e-01f, 6.29539862e-02f, 1.99198872e-01f, -7.25689381e-02f, 3.26143648e-03f, 6.13425523e-02f, 2.46462539e-01f, 4.03800815e-01f, 8.46508294e-02f,
  5.50740138e-02f, -9.14597064e-02f, -2.17577711e-01f, -1.17850844e-02f, -4.54886816e-02f, 2.84299403e-01f, -1.73351001e-02f, -1.15277916e-01f, -7.38966465e-02f, -2.78746728e-02f,
  1.40985727e-01f, -2.60310352e-01f, 1.87183008e-01f, -7.18565881e-02f, -8.47750828e-02f, 1.34243732e-02f, 1.26698852e-01f, -4.54067141e-02f, 3.80669325e-03f, -3.30937020e-02f,
  2.09516138e-02f, -1.73338391e-02f, 1.30156390e-02f, 2.41063302e-03f, 2.64911409e-02f, -2.99805822e-03f, -1.22247495e-01f, -6.44274801e-02f, -6.42154440e-02f, -4.41770814e-02f,
  -5.43377325e-02f, -5.04871719e-02f, -9.71797556e-02f, 3.53010595e-02f, 1.02969836e-02f, 1.82316050e-01f, -4.32254151e-02f, -1.69670079e-02f, 8.56152326e-02f, -1.31214336e-01f,
  -3.15193720e-02f, 7.75498664e-03f, 1.01469629e-01f, -3.55794141e-03f, 2.31771264e-02f, -6.43125623e-02f, 1.75921824e-02f, 2.82178055e-02f, 3.75102013e-02f, 5.89530729e-02f,
  1.53649068e-02f, 2.05828901e-02f, 9.31873452e-03f, -5.18388860e-02f, 2.42274310e-02f, 3.53315137e-02f, 3.43433358e-02f, -5.49854748e-02f, -4.61942703e-02f, -7.91679919e-02f,
  6.38875365e-03f, -8.11901595e-03f, -3.24047580e-02f, 4.03317921e-02f, -7.72128329e-02f, -1.08480912e-04f, 1.43041145e-02f, -5.44707216e-02f, 2.07847934e-02f, -1.60114542e-02f,
  2.26285681e-03f, 1.03559367e-01f, 2.87879612e-02f, 1.48193007e-02f, -7.21095596e-03f, -1.88195091e-02f, -1.36042302e-02f, 2.13869363e-02f, 4.40077744e-02f, -1.34161655e-02f,
  -4.95808907e-02f, 2.53993962e-02f, -6.14660867e-02f, -3.49460579e-02f, 4.78474982e-02f, 3.19689400e-02f, -1.31558189e-02f, 6.38983175e-02f, -1.67025011e-02f, 9.44661498e-02f,
  -4.80929017e-02f, 5.23153767e-02f, 1.98329166e-02f, 2.86033396e-02f, 5.17770238e-02f, 7.37300143e-02f, 1.18436620e-01f, 4.12436984e-02f, 7.38501921e-02f, -1.04427664e-02f,
  -6.41319513e-01f, -3.02471220e-01f, 1.14146344e-01f, -3.20226997e-01f, -2.55393274e-02f, 1.44744217e-01f, -1.64536655e-01f, -9.05989669e-03f, -4.52581383e-02f, -8.52340013e-02f,
  1.17000826e-01f, 1.72999799e-01f, 1.27958849e-01f, 2.23083064e-01f, -1.41772749e-02f, -1.95423126e-01f, -1.95074067e-01f, -8.32317956e-03f, 1.32582411e-01f, 1.64389893e-01f,
  5.47839217e-02f, -1.40749812e-01f, -1.83443446e-02f, 2.89036185e-02f, -7.06519140e-03f, 1.70818105e-01f, 7.86999017e-02f, -2.01676413e-02f, 1.63015738e-01f, -1.53658614e-01f,
  1.14217058e-01f, -4.09023762e-01f, 1.05218455e-01f, -9.35255289e-02f, -1.67116206e-02f, -7.81050920e-02f, 4.96428162e-02f, -8.33916813e-02f, -1.27585053e-01f, -2.89806370e-02f,
  -1.47757083e-01f, -4.16424386e-02f, -3.89601514e-02f, 4.29425156e-03f, -1.48084223e-01f, -2.46637091e-02f, -5.46438023e-02f, -1.89780831e-01f, -4.83169295e-02f, -2.20109858e-02f,
  2.32042801e-02f, -6.44273981e-02f, -3.99923176e-02f, -5.14382944e-02f, -9.85646471e-02f, -1.93816349e-02f, 6.92347810e-02f, -6.48571029e-02f, 1.30607978e-01f, -1.55980512e-01f,
  -4.97696660e-02f, 1.00641670e-02f, 9.27487016e-02f, -1.94634981e-02f, -6.94890991e-02f, 7.55497888e-02f, -1.14287948e-02f, 4.17155176e-02f, 3.80216050e-03f, 2.31140908e-02f,
  4.80020456e-02f, 2.68755946e-03f, 1.14047118e-02f, -8.21311697e-02f, 1.17859870e-01f, -7.14771636e-03f, 7.05784000e-03f, 3.20442840e-02f, 5.15293516e-02f, 4.70345728e-02f,
  -8.01055357e-02f, 2.28870418e-02f, -3.29922065e-02f, -3.75317712e-03f, 4.81066816e-02f, -6.75899386e-02f, 4.36185412e-02f, 8.82716626e-02f, 3.34199257e-02f, 5.54775214e-03f,
  2.32740752e-02f, 1.97899546e-02f, -4.27153371e-02f, 7.54555746e-04f, -8.74402225e-02f, -8.02480653e-02f, -1.59048773e-02f, -2.68679596e-02f, -1.34902611e-01f, 2.04008701e-03f,
  5.76891601e-02f, -1.00038256e-02f, -2.88720708e-02f, 8.23327713e-03f, 4.65151062e-03f, 1.15188109e-02f, -1.28356768e-02f, -3.02370694e-02f, 5.11147920e-03f, -2.25372938e-03f,
  -6.61582723e-02f, -1.26792058e-01f, -7.43315071e-02f, 3.69820260e-02f, -3.15770917e-02f, 1.01595856e-02f, 4.24298868e-02f, -6.89230189e-02f, 6.53461814e-02f, -1.36970893e-01f,
  3.41061085e-01f, 1.18413977e-01f, -3.16163808e-01f, -3.85120846e-02f, -3.95675421e-01f, -4.05148864e-01f, -4.65486169e-01f, -5.70002906e-02f, 1.36430144e-01f, -1.10046349e-01f,
  1.05062105e-01f, 3.12419146e-01f, 2.55270660e-01f, 2.52389342e-01f, -1.90965878e-03f, -1.56127244e-01f, -2.42277950e-01f, 6.89495280e-02f, 3.52673046e-02f, -3.55561376e-02f,
  -4.89590736e-03f, -2.58388910e-02f, 2.30524182e-01f, 9.08016711e-02f, -1.52843341e-01f, 3.76067583e-05f, -2.20120415e-01f, 4.97865379e-02f, 6.86690733e-02f, -5.84959760e-02f,
  1.49814978e-01f, -2.16363251e-01f, -6.97158352e-02f, 1.52501851e-01f, 6.92217425e-02f, 9.07752588e-02f, 7.46074948e-04f, 4.64485921e-02f, 4.99787480e-02f, 5.46632595e-02f,
  3.75671834e-02f, 1.51401758e-01f, 4.71741296e-02f, 8.97331238e-02f, -1.69990547e-02f, -4.11443338e-02f, 1.52526826e-01f, 1.03339553e-01f, 1.17749400e-01f, 4.85832021e-02f,
  -1.03909452e-03f, 3.25952023e-02f, -1.06225088e-02f, -5.30233197e-02f, -7.75849912e-03f, 9.51312408e-02f, 6.13019522e-03f, 4.65346202e-02f, 1.05527632e-01f, 1.04425222e-01f,
  6.55502230e-02f, -3.19333188e-02f, -1.51598960e-01f, -8.76398906e-02f, 1.72289796e-02f, 4.72821202e-03f, -4.03057821e-02f, -3.02566588e-02f, -1.66116860e-02f, 4.69236411e-02f,
  -5.52017465e-02f, -8.49680007e-02f, 4.10620570e-02f, -1.04211211e-01f, 1.40900128e-02f, -4.98696640e-02f, -6.45367801e-02f, 2.83465069e-03f, 4.75551412e-02f, -6.93806186e-02f,
  1.04903327e-02f, -7.43532255e-02f, -8.57833326e-02f, 3.77008622e-03f, 8.63814577e-02f, -2.24877521e-02f, -2.02023964e-02f, -2.77528726e-03f, -3.77963460e-03f, -9.12287608e-02f,
  5.15692718e-02f, 3.84770930e-02f, 1.69818792e-02f, 3.18546891e-02f, -1.16571479e-01f, 8.70606676e-02f, -2.25344915e-02f, -1.47068873e-02f, -5.89356339e-03f, 7.89622366e-02f,
  -9.44611430e-02f, -1.28465309e-03f, -6.71868818e-03f, -4.57588434e-02f, -3.50101851e-02f, -4.42759395e-02f, 8.67442265e-02f, -5.06754071e-02f, 6.45551160e-02f, -4.96612974e-02f,
  4.15539220e-02f, 2.39254832e-02f, -8.53322521e-02f, -2.98742168e-02f, 3.78148817e-02f, -4.60505188e-02f, -8.69691297e-02f, -3.54798064e-02f, -6.81029353e-03f, -2.96369139e-02f,
  3.70131105e-01f, -2.89276361e-01f, -4.25532274e-02f, -4.17544097e-02f, -5.69269620e-02f, -6.65792031e-03f, -3.57646123e-02f, -7.33384117e-02f, -7.41992425e-03f, -1.69342041e-01f,
  -1.04681052e-01f, 6.56788200e-02f, 8.24434832e-02f, -1.36070335e-02f, 5.45167774e-02f, -1.19764835e-01f, -8.18477869e-02f, 2.22416624e-01f, 4.21781868e-01f, 2.13472798e-01f,
  1.86411534e-02f, 1.10667869e-02f, -5.77085763e-02f, 5.97461984e-02f, -2.19806373e-01f, 1.23345301e-01f, -1.96509182e-01f, -1.92245707e-01f, -2.58631706e-02f, -2.14736715e-01f,
  3.93381491e-02f, -4.29032743e-02f, 1.98099405e-01f, -4.72786650e-02f, -9.92561970e-03f, 1.04746073e-01f, 2.37977598e-02f, 1.46384435e-02f, -6.26324490e-03f, -4.92088199e-02f,
  1.04163159e-02f, -1.00087449e-02f, 8.56085569e-02f, -2.86567863e-02f, 4.55638617e-02f, 1.71143617e-02f, -5.58592007e-02f, 2.70911586e-02f, -6.24736436e-02f, -6.78156391e-02f,
  -7.83202276e-02f, 4.00582999e-02f, -6.59600869e-02f, -1.60389356e-02f, 6.10763691e-02f, 1.85540703e-03f, -1.20422304e-01f, 5.81196137e-02f, 1.00916391e-02f, -5.28296381e-02f,
  2.11436823e-02f, 3.83231007e-02f, -4.13590018e-03f, 4.87897061e-02f, 4.28808741e-02f, 5.47203943e-02f, -4.36638370e-02f, -7.85739273e-02f, 6.77483901e-02f, -8.91270712e-02f,
  -2.26551015e-03f, -5.08381054e-02f, 4.14140448e-02f, -2.70955320e-02f, -1.26006790e-02f, -1.06535658e-01f, -6.00870773e-02f, -4.24344428e-02f, -3.59480269e-02f, 2.80975015e-03f,
  3.45856138e-02f, -1.04880910e-02f, -1.31243905e-02f, -8.49554501e-03f, -9.44823176e-02f, 1.48367789e-02f, 1.43036405e-02f, -4.39498276e-02f, -8.27614870e-03f, 9.39955469e-03f,
  -5.85284382e-02f, -6.18053554e-03f, 5.42538278e-02f, 3.00700478e-02f, -3.68893296e-02f, -1.25294730e-01f, -6.31784499e-02f, -5.80402883e-03f, -1.08522475e-02f, 2.80280616e-02f,
  -5.16415350e-02f, 6.05170354e-02f, 2.26177052e-02f, -1.61606949e-02f, 1.15499467e-01f, -4.65184711e-02f, 2.32099788e-03f, 6.00459985e-02f, 3.97550389e-02f, -7.14522973e-02f,
  -1.04121067e-01f, 1.85926203e-02f, 1.53820217e-01f, -4.97312248e-02f, 9.08887461e-02f, 1.04519106e-01f, 1.95572115e-02f, 4.71146367e-02f, -3.46183330e-02f, 4.40792590e-02f,
  -2.52842605e-01f, -2.00396761e-01f, 8.04995298e-02f, -3.02038610e-01f, -1.67022228e-01f, -1.16651654e-01f, -5.01356840e-01f, -2.23473646e-02f, 3.28888395e-03f, -3.36436898e-01f,
  -1.30835790e-02f, 3.10252368e-01f, 2.68960893e-01f, 2.86029726e-01f, 1.53717369e-01f, -3.52669030e-01f, -3.22368234e-01f, 1.35994507e-02f, 2.70502716e-01f, -3.42912041e-02f,
  -1.34082600e-01f, -2.10992619e-01f, 2.20245274e-04f, 5.12474179e-02f, -2.25316405e-01f, 2.17803344e-02f, -1.34643883e-01f, -5.24767935e-02f, -4.36937883e-02f, -3.29915792e-01f,
  6.58513382e-02f, -1.19693957e-01f, 3.29335146e-02f, 5.14524244e-02f, -9.98953134e-02f, -4.94030826e-02f, -1.31322473e-01f, 1.25787053e-02f, -1.19725682e-01f, -3.03707225e-03f,
  -8.96493495e-02f, -6.46788105e-02f, 2.82989126e-02f, 2.03880221e-02f, -1.95830781e-02f, -4.24711443e-02f, 2.02826448e-02f, -4.48224880e-02f, 1.81945134e-02f, -1.00934640e-01f,
  -8.22322369e-02f, -2.16775909e-01f, 1.36409164e-03f, 3.36139016e-02f, -2.07659528e-02f, 2.93541737e-02f, 8.61500564e-04f, 2.07142364e-02f, 1.09972581e-01f, -4.61115278e-02f,
  -7.41031617e-02f, 2.67548673e-02f, -2.22855527e-02f, -9.85950883e-03f, -2.30904911e-02f, 6.15133569e-02f, 2.81240474e-02f, 1.62766688e-02f, 1.39756035e-02f, -2.40393318e-02f,
  8.54859203e-02f, -3.34968157e-02f, 1.54894544e-02f, 7.76271820e-02f, -2.69073690e-03f, -1.19282948e-02f, -5.45692854e-02f, 3.34364399e-02f, 9.57688391e-02f, 1.65595040e-02f,
  4.08100411e-02f, -3.53783779e-02f, -9.81205050e-03f, 5.81673868e-02f, -4.13773283e-02f, 7.87318498e-02f, 1.99351981e-02f, 1.94325391e-02f, 8.81103724e-02f, -8.87534395e-02f,
  1.43320143e-01f, 1.66071162e-01f, -1.57741159e-01f, -1.18307881e-01f, -9.40359086e-02f, -1.08883254e-01f, -1.54701203e-01f, -6.30401745e-02f, -5.19651473e-02f, -1.10435992e-01f,
  2.74739694e-02f, -2.70620100e-02f, -7.00846268e-03f, -7.52688497e-02f, -7.54256472e-02f, -9.67207476e-02f, -2.00288057e-01f, -9.48618874e-02f, -1.31283998e-01f, -1.38196498e-01f,
  -1.65663183e-01f, -1.96306869e-01f, -5.44531345e-02f, -4.65167500e-02f, -9.01777968e-02f, -9.43074226e-02f, -4.65461127e-02f, -3.54009978e-02f, -1.79219022e-02f, -1.68981403e-01f,
  2.79702228e-02f, -3.08288395e-01f, -3.90296966e-01f, 1.05151445e-01f, 8.42078589e-03f, -5.98022565e-02f, 6.04646876e-02f, 3.60353217e-02f, 1.34139568e-01f, -1.17391184e-01f,
  -9.60129574e-02f, 1.85958400e-01f, 7.34115839e-02f, -2.26528384e-03f, -3.23163457e-02f, -3.49706155e-03f, -7.40250424e-02f, -1.18240885e-01f, 7.87922591e-02f, 8.19321722e-02f,
  2.82344103e-01f, 4.34464104e-02f, -7.59379268e-02f, 5.37101924e-02f, 2.47611552e-02f, 2.02216238e-01f, -8.12205821e-02f, -1.73318893e-01f, -1.69198424e-01f, -2.71141917e-01f,
  -2.41417021e-01f, -3.63301724e-01f, 8.17947239e-02f, 2.49162875e-02f, -1.26062602e-01f, -6.88817874e-02f, 1.40123609e-02f, -1.02880061e-01f, -1.14183307e-01f, -9.14948881e-02f,
  -1.51083484e-01f, -1.06227778e-01f, -5.19957161e-03f, 6.14607939e-04f, -1.27011597e-01f, -3.58412787e-02f, -1.57695189e-01f, -1.26443475e-01f, -1.04627326e-01f, -7.32742026e-02f,
  -8.61368887e-03f, -2.20519677e-01f, -2.13227242e-01f, -1.42212793e-01f, -7.45160058e-02f, -5.92750274e-02f, -1.47002161e-01f, -1.62390262e-01f, -1.03171960e-01f, -1.55778214e-01f,
  2.77266093e-02f, -1.24792665e-01f, -1.47939073e-02f, 1.15033193e-02f, 1.04224361e-01f, -1.91281959e-02f, 4.17167954e-02f, 2.64118556e-02f, 8.89360346e-03f, 6.98015988e-02f,
  -2.62109432e-02f, 3.23766768e-02f, -6.71970323e-02f, 3.12235802e-02f, 3.38307992e-02f, -5.72693236e-02f, 2.13535912e-02f, -1.65557675e-03f, -6.11143224e-02f, 6.62114471e-02f,
  -4.91066314e-02f, -9.90756080e-02f, 2.96686459e-02f, -6.70029316e-03f, -6.36156872e-02f, 1.73411816e-02f, -7.63700753e-02f, 5.47521263e-02f, -6.25486225e-02f, -5.65713495e-02f,
  2.18385801e-01f, -2.14718655e-01f, 1.48156611e-02f, 1.14181042e-02f, -9.60060507e-02f, -2.62249261e-02f, -4.01373953e-02f, -7.98406824e-02f, -3.57162207e-02f, 1.75638963e-02f,
  -2.58083958e-02f, -4.28556558e-03f, -1.00852586e-01f, -1.19814411e-01f, 1.12056300e-01f, -2.47665625e-02f, 3.88719216e-02f, 5.86648136e-02f, -1.51402242e-02f, -9.05526355e-02f,
  1.71722043e-02f, 7.42285252e-02f, 1.56153336e-01f, -1.06503884e-03f, -8.70134309e-02f, 1.18121736e-01f, 7.37991706e-02f, 6.61759153e-02f, 1.57208353e-01f, 3.41060460e-01f,
  3.78716141e-01f, 3.89949292e-01f, 2.02277362e-01f, -5.71081191e-02f, -2.20055506e-01f, -4.49625514e-02f, 4.49205458e-01f, 5.40438257e-02f, -1.78631052e-01f, 1.95804447e-01f,
  1.65307783e-02f, -3.51132631e-01f, -1.69288218e-01f, -2.35644341e-01f, 1.01565085e-01f, 2.57315487e-01f, -2.42536869e-02f, -2.78801494e-03f, 6.26847334e-03f, 4.58953604e-02f,
  2.77032852e-02f, 6.25882111e-03f, -6.70563336e-03f, -6.95915744e-02f, -3.97124328e-02f, -7.29159489e-02f, 1.31542787e-01f, 1.89456567e-02f, 1.73600137e-01f, 5.56068085e-02f,
  3.09824526e-01f, 9.01750699e-02f, -8.71246085e-02f, 1.88473519e-03f, -3.51296552e-02f, 4.15191278e-02f, 1.89820513e-01f, 1.56070553e-02f, -4.26254459e-02f, 1.15229301e-01f,
  -7.51550272e-02f, 2.63314620e-02f, 3.39241885e-03f, -3.05885673e-02f, 1.34802125e-02f, -6.64076954e-02f, -1.87461339e-02f, -2.66515668e-02f, 3.73637900e-02f, -1.66400825e-03f,
  -1.08662203e-01f, -1.24422424e-02f, -4.19853115e-03f, 5.60306422e-02f, 5.38812093e-02f, -1.28554359e-01f, 8.25672522e-02f, 3.79996351e-03f, 9.06052589e-02f, 8.96008685e-02f,
  -8.00509378e-03f, -9.13459882e-02f, -9.50587392e-02f, -3.50243524e-02f, -7.11796060e-02f, -1.22364471e-02f, 3.24696489e-03f, -5.75124286e-04f, -1.00396927e-02f, 2.33853348e-02f,
  -4.58680615e-02f, -9.74191800e-02f, -1.93580575e-02f, 7.13534951e-02f, -3.21690999e-02f, -3.05634271e-02f, 8.25505108e-02f, -4.75245118e-02f, -3.47622745e-02f, -1.04168624e-01f,
  -5.86363487e-02f, 1.42156938e-02f, 9.10185557e-03f, 1.10631268e-02f, -4.31958400e-02f, -1.20950237e-01f, -5.88390306e-02f, -1.20048240e-01f, -8.76386389e-02f, -5.68964705e-02f,
  1.19903184e-01f, -1.44486785e-01f, 1.91247061e-01f, -1.80226564e-02f, 4.50181030e-02f, 3.17552872e-02f, -1.18034557e-02f, 5.78496978e-02f, -6.83326423e-02f, 3.88436653e-02f,
  3.29990499e-02f, 9.45568755e-02f, 8.16272274e-02f, 4.06336598e-02f, 4.35921773e-02f, 4.37023155e-02f, -6.69831932e-02f, -1.63122732e-02f, -3.00089084e-02f, 1.52289774e-02f,
  6.61598668e-02f, -2.92537850e-03f, 6.83925301e-02f, 4.81162965e-02f, 2.73552407e-02f, 2.92066615e-02f, 1.04249738e-01f, 1.16040692e-01f, 6.00537360e-02f, 3.57798636e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.40290871e-01f, -2.26009950e-01f, -2.17925936e-01f, 3.28944087e-01f, 3.38689327e-01f, -2.16510415e-01f, -7.04858243e-01f, -5.06984293e-01f, 3.17449421e-01f, 2.43430901e-02f,
  8.32276344e-02f, 3.21666390e-01f, 1.00687556e-01f, -1.56645998e-01f, -4.76856291e-01f, -1.80913866e-01f, 1.38137773e-01f, -5.31018786e-02f, -3.16117913e-01f, -2.98245937e-01f,
  1.71481282e-01f, 1.31030500e-01f, -2.47142911e-01f, -3.28611702e-01f, 3.46458524e-01f, 2.05229312e-01f, 8.26300979e-02f, 1.13543399e-01f, -1.37760162e-01f, 7.20083594e-01f,
  3.35680038e-01f, -8.83175135e-02f, -6.42126799e-02f, 4.62879278e-02f, 1.06464334e-01f, -9.13755298e-02f, -1.15907170e-01f, 4.79481518e-02f, 1.44291580e-01f, -3.95715423e-02f,
  2.44427562e-01f, 1.49807692e-01f, 1.83500066e-01f, 6.56085387e-02f, 4.95688617e-02f, -1.32673115e-01f, -1.73089728e-01f, -3.13145995e-01f, -3.05894613e-01f, -1.82430938e-01f,
  1.14748999e-01f, 1.47023741e-02f, -2.96010435e-01f, -4.63235080e-01f, -2.97323823e-01f, 1.92752555e-01f, -9.74938944e-02f, 3.90663520e-02f, -3.94746929e-01f, 6.87540770e-02f,
  1.27854757e-02f, 1.45265803e-01f, 1.46460012e-01f, 8.80431384e-03f, -2.26498768e-02f, 6.78336918e-02f, 5.49846068e-02f, 2.90339105e-02f, -4.53958288e-02f, -1.25140563e-01f,
  3.67015004e-02f, 4.76734191e-02f, 5.77858090e-02f, -2.92733945e-02f, 1.89341838e-03f, 2.23173182e-02f, 2.49459837e-02f, -1.85057297e-01f, -2.06784159e-01f, 8.52128211e-03f,
  -4.97287735e-02f, 6.12750687e-02f, 1.29580304e-01f, 3.39436792e-02f, -1.07058734e-01f, -1.32377625e-01f, 8.96536931e-02f, -3.66798490e-02f, -6.73433095e-02f, -2.52220570e-03f,
  7.03845024e-02f, -2.04904243e-01f, 1.91781923e-01f, -1.39730200e-01f, 9.06384587e-02f, 6.62109256e-02f, -3.00171748e-02f, -4.74197790e-02f, 7.22270086e-02f, -5.81558198e-02f,
  -4.88894470e-02f, 2.22233608e-02f, -8.41263458e-02f, -6.90303445e-02f, 1.10954762e-01f, -4.99066226e-02f, 4.15232144e-02f, 2.11171247e-02f, -6.43263832e-02f, 1.00009860e-02f,
  -1.21282831e-01f, -3.11749548e-01f, -1.48794800e-01f, -1.06477082e-01f, -8.99981358e-04f, -8.69869441e-02f, -1.35843426e-01f, -4.21704128e-02f, -2.17858732e-01f, -2.87047803e-01f,
  -6.58287108e-01f, -8.72269124e-02f, 5.54453611e-01f, -5.63774765e-01f, 1.54906154e-01f, 2.86910206e-01f, 4.93988067e-01f, -1.85751561e-02f, -4.88378406e-01f, 1.31818771e-01f,
  6.86117634e-02f, -2.78075188e-01f, -1.27606124e-01f, 6.36823401e-02f, 1.36584133e-01f, 3.31486374e-01f, 5.24016805e-02f, 1.02360481e-02f, 2.80648470e-01f, 3.48624915e-01f,
  -8.64923298e-02f, -1.84251457e-01f, -2.24243477e-01f, -1.46875456e-01f, -3.23026121e-01f, -8.22528526e-02f, -6.31128624e-02f, 7.23303407e-02f, 2.00915456e-01f, -4.68407273e-01f,
  3.44494104e-01f, -7.57866055e-02f, 4.75723715e-03f, -1.23485319e-01f, 3.70878614e-02f, -1.86783716e-01f, -4.74747419e-02f, -1.86913237e-01f, -3.80061343e-02f, -1.22615993e-02f,
  -7.99137875e-02f, 6.13144897e-02f, -1.57206580e-01f, 7.80005828e-02f, -9.61525291e-02f, -1.83877796e-02f, -2.48316228e-02f, -5.90917729e-02f, -7.70460367e-02f, 1.52059987e-01f,
  4.66926582e-02f, 5.49670011e-02f, 1.38733253e-01f, 8.50487575e-02f, 1.22796427e-02f, 2.20838524e-02f, 3.81764397e-02f, -2.62198672e-02f, 4.36475761e-02f, -2.64162779e-01f,
  3.32470424e-02f, 2.03528814e-02f, 1.04381731e-02f, 2.36694757e-02f, -1.62916202e-02f, -8.03525839e-03f, 1.50055522e-02f, -2.07622778e-02f, -6.80364145e-04f, -1.51693216e-02f,
  -1.59650370e-02f, 6.30904213e-02f, -8.63282010e-02f, 7.54704401e-02f, -6.97287992e-02f, -3.41884978e-02f, 2.71538217e-02f, 1.15234200e-02f, -4.94553782e-02f, -1.39045224e-01f,
  5.13596646e-03f, -7.53400102e-02f, 2.21260004e-02f, 3.98944542e-02f, 6.48849010e-02f, -6.12135008e-02f, -8.62876698e-02f, 5.36453584e-03f, -7.31909052e-02f, -4.29645833e-03f,
  -3.62512887e-01f, 2.41752759e-01f, -4.36733365e-02f, -1.42077297e-01f, -4.69422676e-02f, 2.27581505e-02f, -1.17692962e-01f, -4.22981046e-02f, 1.09022884e-02f, 6.49758130e-02f,
  4.99638841e-02f, 2.13032123e-02f, 5.53388000e-02f, -2.15371866e-02f, 6.82829618e-02f, 5.95876947e-02f, -8.23374838e-02f, -5.64345568e-02f, -1.43592684e-02f, -1.05811208e-01f,
  9.18213837e-03f, -9.48175490e-02f, -5.42285964e-02f, 6.09164266e-03f, -1.24859162e-01f, 1.02220900e-01f, 2.64028996e-01f, 1.18358053e-01f, 1.11107998e-01f, 7.50496387e-02f,
  -4.29799736e-01f, -6.98801056e-02f, -4.86361235e-02f, -1.47570893e-01f, 3.99540961e-02f, 2.28754967e-01f, 3.13144177e-02f, 3.23970348e-01f, 7.64160231e-02f, -1.65330559e-01f,
  8.20102543e-02f, 1.06012598e-01f, -2.50294268e-01f, -5.87062463e-02f, -4.13193554e-02f, -2.97877669e-01f, -4.17835146e-01f, -1.48931101e-01f, 3.06300581e-01f, 5.16495228e-01f,
  1.35495245e-01f, -5.02683669e-02f, -2.44181957e-02f, 1.09011687e-01f, -2.14128107e-01f, -1.21372603e-01f, -4.22592998e-01f, -3.17839026e-01f, -3.41394655e-02f, -7.95636117e-01f,
  -4.51993853e-01f, 3.21458161e-01f, 2.16327891e-01f, -7.06771612e-02f, -6.99422732e-02f, 2.16621980e-01f, 2.05158368e-01f, 1.78930033e-02f, 3.40545326e-02f, -1.85569599e-02f,
  -9.77816805e-03f, 2.16204658e-01f, -8.58305546e-04f, 1.33176640e-01f, 1.47247121e-01f, 1.46660119e-01f, 1.86008647e-01f, -2.11995887e-03f, -2.15115458e-01f, 1.25589520e-01f,
  2.74965577e-02f, -2.25473419e-01f, -2.44359136e-01f, 3.15621160e-02f, 1.66092843e-01f, 1.36576146e-01f, 5.01777753e-02f, 8.37749913e-02f, 1.05218589e-01f, -4.42363620e-01f,
  2.50443425e-02f, -1.13865182e-01f, 1.19614132e-01f, 9.16763991e-02f, -7.21918643e-02f, 4.01590168e-02f, -6.22885749e-02f, -9.31841284e-02f, -9.36260074e-02f, -2.06998307e-02f,
  3.55971232e-02f, -6.17275424e-02f, -6.30349899e-03f, -7.25340471e-02f, -3.27063464e-02f, -3.02622449e-02f, -1.10714577e-01f, -7.20066652e-02f, -1.06725298e-01f, -4.01316583e-02f,
  3.22798938e-02f, -1.46806031e-01f, 4.45277616e-02f, 4.62304913e-02f, -5.03303716e-04f, -6.02064729e-02f, -3.78001668e-02f, 1.87639028e-01f, 1.55342773e-01f, 2.63339788e-01f,
  5.47151044e-02f, 6.33684322e-02f, -2.08052501e-01f, 1.74134046e-01f, -1.05544135e-01f, -1.85573936e-01f, -1.14049681e-01f, -8.59490111e-02f, 2.51159091e-02f, -3.82074267e-02f,
  7.97213018e-02f, -1.81118339e-01f, -1.20814167e-01f, -7.32796937e-02f, 4.58346587e-03f, 1.51981980e-01f, -1.62622139e-01f, -1.69962376e-01f, -1.46382809e-01f, -1.15384243e-03f,
  -5.72672039e-02f, -1.44833371e-01f, -2.22777218e-01f, -3.05235922e-01f, -7.65374862e-03f, -1.14910483e-01f, -2.27524325e-01f, -2.11284667e-01f, -2.56525248e-01f, -4.91829932e-01f,
  3.60247314e-01f, -4.07731652e-01f, 1.67754218e-01f, 2.78697431e-01f, 1.31660372e-01f, 2.62333184e-01f, -2.04861257e-02f, -1.47231738e-03f, 8.84709805e-02f, -5.46158552e-02f,
  -7.15574995e-03f, 1.28651068e-01f, 2.43196711e-02f, -7.24332465e-04f, 1.09984586e-02f, -5.34242019e-02f, 3.24311256e-02f, 1.82148457e-01f, 1.96681008e-01f, 9.57622379e-02f,
  -2.26425081e-01f, -2.48229071e-01f, -2.20290586e-01f, -1.26149431e-01f, -2.35948369e-01f, 1.40290782e-01f, -2.21076850e-02f, -1.67768121e-01f, -1.05151206e-01f, -1.55442432e-01f,
  2.91328877e-01f, 1.36188880e-01f, 2.41582498e-01f, 2.08260920e-02f, -1.96425747e-02f, -1.05355114e-01f, 8.42952207e-02f, -3.72348689e-02f, 6.21773414e-02f, 9.20031145e-02f,
  -1.96700264e-02f, -1.07566835e-02f, -1.28896177e-01f, -1.34267449e-01f, 2.62810360e-03f, -9.98045504e-02f, -1.55663475e-01f, -9.23436210e-02f, 3.04052662e-02f, -4.49786149e-02f,
  -7.65715837e-02f, 9.23274457e-02f, 2.01220617e-01f, 1.73876792e-01f, 7.31150359e-02f, 6.08880073e-02f, 6.26824051e-02f, 4.28779833e-02f, 2.68942956e-02f, -1.16581410e-01f,
  3.52588519e-02f, -5.80787361e-02f, 7.76195377e-02f, -3.88665348e-02f, -6.52253106e-02f, 1.30491495e-01f, 6.82317000e-03f, -4.56316359e-02f, -3.89690995e-02f, -1.05950594e-01f,
  -8.68940800e-02f, 9.59515348e-02f, 9.69058648e-02f, 3.94560844e-02f, -9.41019505e-02f, 5.10201603e-02f, 4.69560847e-02f, 1.75736174e-02f, -1.19904645e-01f, -1.31755203e-01f,
  -2.14830916e-02f, 4.28162850e-02f, -4.18598577e-02f, -2.52950966e-01f, -1.30146950e-01f, -1.98297314e-02f, -2.80013890e-03f, -1.29108816e-01f, -1.62337646e-01f, -4.87324037e-02f,
  3.83432239e-01f, 1.46896943e-01f, 9.07717273e-02f, -7.07457513e-02f, -6.70233667e-02f, -5.87074347e-02f, -4.82585914e-02f, -1.13360092e-01f, 6.53636903e-02f, 8.79348516e-02f,
  2.01357901e-02f, 5.56754135e-02f, -1.29225105e-01f, -1.08740628e-01f, 1.57158300e-02f, 5.10979667e-02f, -6.38828278e-02f, 1.19877011e-01f, 8.55065212e-02f, 1.01260141e-01f,
  -2.22947188e-02f, 2.54941314e-01f, 3.59265476e-01f, 2.23336279e-01f, 2.00419262e-01f, 3.34110260e-01f, 1.41938984e-01f, 6.05493411e-02f, 1.75488338e-01f, -7.66487941e-02f,
  8.23444784e-01f, -2.40248203e-01f, 4.86192614e-01f, 4.63435769e-01f, 2.80193109e-02f, 1.09425448e-01f, 3.95149626e-02f, 1.37581766e-01f, 2.62549073e-01f, 6.98705316e-02f,
  1.99086472e-01f, 2.27291986e-01f, 2.94912994e-01f, 3.26767892e-01f, 2.55769551e-01f, 1.37121752e-01f, 1.73270926e-01f, 4.87380981e-01f, 3.43242437e-01f, 3.14543217e-01f,
  2.65258830e-02f, -6.74221590e-02f, 1.40347093e-01f, 2.28233784e-01f, -6.11915663e-02f, 2.45292261e-01f, 8.17332640e-02f, -5.64828701e-02f, -1.89976040e-02f, 1.81086078e-01f,
  1.37655988e-01f, -8.45720544e-02f, 1.46697059e-01f, -1.55663520e-01f, -1.90909803e-01f, -1.55309573e-01f, -8.68425705e-03f, -8.81872550e-02f, -1.26964897e-01f, -1.01540372e-01f,
  -9.56380367e-02f, -1.18493438e-01f, -1.26836956e-01f, -1.35460064e-01f, -1.50925979e-01f, -1.36235073e-01f, -1.89173251e-01f, 5.39653301e-02f, 1.94817275e-01f, -1.34010077e-01f,
  -2.67741792e-02f, -1.03127211e-01f, 6.74753189e-02f, 1.35017142e-01f, 8.83128941e-02f, 2.11642105e-02f, -1.08451992e-01f, -1.60201136e-02f, -5.75095266e-02f, 5.33616841e-02f,
  5.32721460e-01f, 3.07263702e-01f, 1.12235874e-01f, -5.37407622e-02f, -5.40699475e-02f, -2.40832511e-02f, -3.95905692e-03f, 9.86332819e-02f, 1.82798192e-01f, -5.48156537e-02f,
  7.67738000e-03f, 1.57883272e-01f, 2.65533645e-02f, 9.37951207e-02f, -1.04059260e-02f, 1.35284029e-02f, -1.43420085e-01f, -7.14648589e-02f, -9.89260077e-02f, -1.00626603e-01f,
  4.86417636e-02f, -1.80401374e-02f, -2.57254355e-02f, -6.63529336e-02f, -8.12752992e-02f, 7.09188357e-02f, 1.07737064e-01f, -1.42102838e-01f, -3.37751918e-02f, -4.32434073e-03f,
  -4.02693212e-01f, 2.16873839e-01f, 2.44303033e-01f, 6.42972738e-02f, -3.87703557e-03f, -7.98856765e-02f, 3.50138284e-02f, -1.04458712e-01f, -1.53992489e-01f, 2.86873933e-02f,
  -1.29709616e-01f, 1.06677994e-01f, -1.02557167e-01f, 4.77557164e-03f, -3.61838080e-02f, -1.16445944e-01f, -1.05996773e-01f, 9.21667591e-02f, 1.45308627e-02f, -4.37866338e-02f,
  -5.76411933e-02f, 1.12002991e-01f, 1.16184540e-01f, 8.96788090e-02f, 1.36011709e-02f, 2.87913419e-02f, -1.29654095e-01f, -1.54624302e-02f, 6.77047819e-02f, -8.53934139e-02f,
  -8.89509022e-01f, 6.98491409e-02f, -1.99597344e-01f, 1.85014978e-01f, 3.59766245e-01f, 2.02719927e-01f, 2.86103249e-01f, -1.04532808e-01f, 3.55814472e-02f, 1.18663743e-01f,
  -1.28640354e-01f, 2.04287078e-02f, 2.88990494e-02f, 1.16667047e-01f, -1.13429472e-01f, 2.98553467e-01f, 5.25683701e-01f, -7.86177814e-02f, -2.90665776e-01f, -4.86369012e-03f,
  2.12350532e-01f, 3.10832877e-02f, -4.66018647e-01f, -1.25725031e-01f, 2.91070849e-01f, 1.36147767e-01f, 7.46707469e-02f, -1.15024693e-01f, 2.15733618e-01f, 5.17452300e-01f,
  -2.65347958e-01f, -3.67557168e-01f, 2.37959385e-01f, -3.22724506e-02f, -1.28823459e-01f, -2.89450526e-01f, -1.27013013e-01f, -1.92240961e-02f, 8.51426944e-02f, -7.23419413e-02f,
  2.76398081e-02f, -1.67556494e-01f, 2.92187333e-01f, 7.50991106e-02f, 1.33535974e-02f, -1.31268844e-01f, -2.25940153e-01f, -5.35708249e-01f, -2.54889011e-01f, -7.06930533e-02f,
  5.39890587e-01f, 2.56766621e-02f, -3.59561294e-01f, 1.31029442e-01f, 1.03808679e-01f, -2.39562243e-01f, -2.46866524e-01f, -3.14319789e-01f, -4.42276835e-01f, -3.27623993e-01f,
  7.73551241e-02f, -1.39571130e-01f, 3.63425352e-03f, -2.89087445e-02f, -4.28362414e-02f, 7.17848390e-02f, 2.25406870e-01f, 1.22856542e-01f, 2.04073355e-01f, 3.25429067e-02f,
  -1.82977822e-02f, 1.17169417e-01f, -4.73329909e-02f, -1.80453137e-01f, 2.52383053e-02f, -1.74075603e-01f, 4.89406958e-02f, 1.72098950e-02f, -8.15716460e-02f, -1.57220215e-01f,
  8.36869106e-02f, -1.83349848e-01f, -6.80907890e-02f, -7.29277730e-02f, 1.11248761e-01f, -1.32781655e-01f, 2.27637142e-01f, -9.59798247e-02f, -1.76105425e-02f, -1.10051237e-01f,
  -7.07757920e-02f, 2.76248485e-01f, -7.49254078e-02f, -6.16711266e-02f, 1.14289187e-01f, -8.68588313e-02f, 1.84880719e-01f, -8.07195902e-02f, -1.45712912e-01f, -8.21890980e-02f,
  -1.47394076e-01f, -1.83733925e-01f, 2.36930344e-02f, -3.43895779e-04f, -1.05561301e-01f, -6.68453053e-02f, 7.48800114e-02f, 6.47876039e-02f, 2.18849197e-01f, -3.52720590e-03f,
  6.68261014e-03f, 5.54196462e-02f, -2.13121578e-01f, 1.29117012e-01f, 1.94308192e-01f, -9.14917737e-02f, -2.09335208e-01f, -1.41832400e-02f, -3.91213261e-02f, 1.04129113e-01f,
  -8.54216039e-01f, 2.52092779e-01f, -1.01431036e+00f, -5.05056977e-01f, -6.69511676e-01f, -1.08464830e-01f, 1.31595461e-02f, 3.05637509e-01f, 2.98405671e-03f, 1.44966869e-02f,
  1.87149830e-02f, -9.17279944e-02f, -1.20114081e-01f, -8.39319676e-02f, -3.35731171e-02f, -9.89822447e-02f, -4.27217722e-01f, -9.18189943e-01f, -6.82251811e-01f, -7.61442259e-02f,
  1.20323896e-02f, -6.77450061e-01f, -6.11783743e-01f, -1.45037487e-01f, 7.70267844e-02f, 5.83416186e-02f, -1.57506749e-01f, -2.60912269e-01f, -3.63433058e-03f, -3.29823464e-01f,
  -4.13335562e-01f, -2.25002050e-01f, -6.03322573e-02f, 6.71277195e-02f, -1.54243290e-01f, 1.44743562e-01f, -2.04326566e-02f, 1.68603957e-02f, 1.64056093e-01f, 1.00450218e-02f,
  -1.57428280e-01f, 5.07216640e-02f, -2.38256842e-01f, 4.39841896e-02f, -2.20507979e-01f, 1.31488554e-02f, -3.17574143e-02f, -7.21913502e-02f, 8.70321989e-02f, 2.88278729e-01f,
  8.96882415e-02f, -3.63746397e-02f, -3.59357819e-02f, 1.83536917e-01f, 2.10486442e-01f, -8.90391916e-02f, 2.28829905e-01f, 1.94036871e-01f, 4.29324210e-02f, 1.77907631e-01f,
  9.28061530e-02f, 3.14124376e-02f, -2.30075810e-02f, -1.06286183e-02f, 1.73171423e-02f, 7.12930337e-02f, -3.87899764e-02f, 9.52602699e-02f, -3.11773550e-03f, -1.62639115e-02f,
  7.38038123e-02f, -6.41713962e-02f, -6.90432861e-02f, -1.70582041e-01f, -1.39178382e-02f, -8.35523605e-02f, -1.05574336e-02f, -5.92757612e-02f, 4.50228900e-02f, 5.37977256e-02f,
  6.90229684e-02f, 9.92445275e-02f, -5.60158901e-02f, -7.83300325e-02f, -5.86349480e-02f, -6.65531456e-02f, -1.04193889e-01f, 3.07595897e-02f, -2.98637040e-02f, 5.09847775e-02f,
  -9.31711793e-02f, -1.71997979e-01f, -1.02352761e-02f, 2.77377844e-01f, -6.44189715e-02f, 1.29246205e-01f, -1.29881054e-01f, 7.86532015e-02f, -5.45393154e-02f, -1.13721803e-01f,
  2.47342139e-02f, 8.57463293e-03f, -1.89564675e-01f, 1.00899719e-01f, -4.90473397e-02f, -4.97380495e-02f, 1.76726475e-01f, -8.17901120e-02f, 3.24178152e-02f, 1.69448331e-01f,
  1.77208275e-01f, 2.37762108e-01f, 1.06948659e-01f, 6.33278489e-02f, 8.25750232e-02f, -8.27234611e-02f, -5.39498068e-02f, 1.40233859e-01f, 4.75722700e-02f, 3.04636747e-01f,
  -2.16591179e-01f, -4.32057112e-01f, 3.80921029e-02f, -1.38534352e-01f, 5.02907746e-02f, -3.03371176e-02f, -7.64018595e-01f, -7.17990845e-02f, 2.38312736e-01f, -5.09806454e-01f,
  -2.18436494e-01f, 3.48483115e-01f, 2.08095033e-02f, 6.81903139e-02f, -1.91907629e-01f, -6.66582048e-01f, -1.73807144e-01f, 2.63381183e-01f, 5.71147501e-01f, 2.08091438e-01f,
  7.36702532e-02f, 3.12900782e-01f, 3.54278743e-01f, 1.87419340e-01f, -1.50718480e-01f, 6.41182661e-02f, -4.56483476e-02f, 8.40215757e-02f, 2.28315797e-02f, -2.29826182e-01f,
  -2.06298992e-01f, -2.69703001e-01f, 1.18213192e-01f, 6.12851381e-02f, 6.25812784e-02f, -1.50964037e-01f, -1.26838788e-01f, -5.47811501e-02f, 3.57443281e-02f, -7.99853355e-02f,
  -6.74628764e-02f, -8.08330029e-02f, 1.77821562e-01f, 1.76080033e-01f, -3.49027254e-02f, -6.16669320e-02f, -1.48138134e-02f, 1.83184922e-01f, -8.75311121e-02f, -1.08861234e-02f,
  -3.33303353e-04f, 1.20247319e-01f, 1.79879740e-01f, -5.95504092e-03f, -1.72214702e-01f, 1.57864615e-01f, -1.93470106e-01f, 6.35139346e-02f, -4.42891615e-03f, -1.29922733e-01f,
  5.90631459e-03f, -3.26455422e-02f, -4.91840467e-02f, -1.38936028e-01f, -1.62694268e-02f, -3.02553754e-02f, 4.69212718e-02f, -4.29099379e-03f, -3.91022861e-02f, -7.51474574e-02f,
  -2.22802889e-02f, -5.37996320e-03f, -1.64762195e-02f, -6.46986142e-02f, 7.35605210e-02f, -3.55475186e-03f, 1.75329130e-02f, -1.99671574e-02f, 5.83671778e-02f, -3.98517177e-02f,
  6.79813921e-02f, 6.87065199e-02f, -4.77635153e-02f, 1.70964941e-01f, 1.06868625e-01f, -7.94728920e-02f, -1.38385100e-02f, -1.02744855e-01f, -9.29373503e-02f, -1.05703726e-01f,
  -1.19206823e-01f, 2.69817680e-01f, -2.38329530e-01f, 2.53347214e-02f, -1.66337192e-01f, 1.69165686e-01f, -3.29040289e-02f, 2.88498364e-02f, -5.20426705e-02f, -1.01981089e-01f,
  4.93782870e-02f, 8.35641772e-02f, -1.30689800e-01f, 7.85282552e-02f, 3.02274954e-02f, -7.29551390e-02f, -2.34305486e-01f, 9.92265418e-02f, 1.62797362e-01f, 8.06926638e-02f,
  1.49482876e-01f, -9.43385959e-02f, -2.32732639e-01f, -2.76463956e-01f, 7.79544115e-02f, -1.22249812e-01f, -9.53594446e-02f, -3.74192074e-02f, -1.47121251e-01f, -5.88344455e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  5.71325347e-02f, 5.88698328e-01f, 7.78284995e-03f, -1.27476647e-01f, 3.53837818e-01f, 1.26254931e-01f, 7.08677709e-01f, 1.28785387e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.98014006e-02f, -1.73741743e-01f, 2.03775004e-01f, -1.22814335e-01f, -3.37841990e-03f, 2.53225237e-01f, 2.24651545e-01f, -2.21508160e-01f, 7.86714926e-02f, 5.57011999e-02f,
  -7.14855418e-02f, -2.42783520e-02f, 4.38031601e-03f, -4.96687442e-02f, 1.20201863e-01f, -2.61595309e-01f, 7.50489980e-02f, 1.20830648e-01f, -2.03724340e-01f, -2.61179116e-02f,
  8.91448781e-02f, -3.08742344e-01f, 2.89056510e-01f, 1.41746700e-01f, 3.59912306e-01f, -3.82791847e-01f, -3.77273560e-01f, -1.04317367e-01f, -1.22103028e-01f, 2.69023538e-01f,
  -9.72033292e-02f, -2.33010188e-01f, 3.69740874e-02f, 1.84587389e-02f, 7.22402930e-02f, 7.18028396e-02f, 1.63235348e-02f, -1.98114917e-01f, 3.93241495e-02f, -7.21975118e-02f,
  2.72140175e-01f, 5.19464351e-02f, -1.80220470e-01f, -7.66088963e-02f, -3.62875909e-02f, 3.21743637e-02f, -4.05058376e-02f, -3.06058168e-01f, 1.11309187e-02f, -2.77560651e-01f,
  -2.19822705e-01f, -8.74188691e-02f, 2.51612402e-02f, -6.82936832e-02f, 1.73965782e-01f, 2.06817567e-01f, -2.07354035e-02f, -3.11099917e-01f, -1.73320323e-01f, -1.10261910e-01f,
  2.47531101e-01f, -5.20089805e-01f, -1.42887533e-01f, -2.47898832e-01f, -7.96128213e-02f, 1.62718713e-01f, 2.69194357e-02f, -3.38885158e-01f, 1.44718617e-01f, 1.68869615e-01f,
  2.63214782e-02f, -7.42657632e-02f, 7.74466172e-02f, -6.19200505e-02f, -1.14773382e-02f, 1.34798497e-01f, -2.03880221e-01f, 1.19825885e-01f, -8.50919932e-02f, 3.19703110e-02f,
  -7.73594454e-02f, -4.21797425e-01f, -9.52250417e-03f, 2.62588888e-01f, -4.64451402e-01f, -1.24142073e-01f, 1.76083073e-01f, -2.83379376e-01f, 4.29551750e-01f, -7.63738513e-01f,
  -2.60357380e-01f, 1.47523163e-02f, 1.38280675e-01f, 2.45897979e-01f, 1.71985373e-01f, -1.44952759e-01f, 1.32061005e-01f, 2.90999293e-01f, 1.17234267e-01f, 9.71386805e-02f,
  2.15713128e-01f, -4.25085723e-02f, 4.07272280e-04f, 1.82828024e-01f, 8.72015953e-02f, 1.71601489e-01f, -1.14973322e-01f, -2.62545701e-02f, -3.11417114e-02f, -1.83840690e-03f,
  1.80705756e-01f, -2.41171140e-02f, -1.91800058e-01f, -8.36825669e-01f, -2.10368354e-02f, 4.00773026e-02f, -3.04207474e-01f, -7.85371438e-02f, -1.78878278e-01f, 1.90506801e-01f,
  5.95220737e-02f, -4.57480848e-02f, 5.19657314e-01f, 1.56079344e-02f, -1.24945082e-01f, -2.46469051e-01f, 1.30250156e-01f, 4.15202886e-01f, 2.35761926e-02f, 2.15077177e-01f,
  6.23339741e-03f, 1.60226807e-01f, 2.58397251e-01f, 8.75932500e-02f, 1.72052309e-01f, -5.62955998e-02f, 2.81691641e-01f, 2.24707127e-01f, -1.09943055e-01f, 9.03011933e-02f,
  3.28255296e-02f, 1.89443007e-01f, -5.68275899e-02f, 2.69034237e-01f, 3.53638828e-01f, -6.53219283e-01f, -2.18081787e-01f, -1.96277440e-01f, -3.28386426e-01f, -2.56143987e-01f,
  -1.48539975e-01f, 3.42532657e-02f, 5.86807311e-01f, -2.13758558e-01f, -5.36302179e-02f, -3.56350392e-02f, -2.53686547e-01f, 5.65901518e-01f, 1.40940696e-01f, -4.08278376e-01f,
  -6.74592555e-02f, 2.56686248e-02f, 3.36151980e-02f, -2.42106751e-01f, 1.38533667e-01f, 3.12655509e-01f, 2.26034373e-01f, 3.45716402e-02f, 1.12758726e-02f, -1.94356982e-02f,
  1.01788223e-01f, -3.74430306e-02f, -4.26226966e-02f, -1.16311386e-01f, 4.46498580e-02f, -1.45909443e-01f, -2.22795382e-01f, -1.84425846e-01f, -1.38353273e-01f, 2.08329871e-01f,
  2.12687746e-01f, 3.19387242e-02f, -4.30518128e-02f, -7.50562474e-02f, 2.74697840e-01f, -6.18018210e-01f, 2.42175609e-01f, 2.03127012e-01f, 5.01797609e-02f, -7.32833818e-02f,
  7.94269741e-02f, 4.00018841e-01f, -3.10679502e-03f, -1.44901052e-01f, -1.22604735e-01f, 6.08940199e-02f, -4.01753560e-02f, -3.15226734e-01f, -2.29084250e-02f, -2.15379498e-03f,
  -1.12984672e-01f, -1.53092831e-01f, -2.22848713e-01f, 9.78857428e-02f, -3.43876705e-02f, -4.20499668e-02f, -2.41991222e-01f, -1.13090582e-01f, 2.48746261e-01f, -2.28744835e-01f,
  -3.05889517e-01f, -1.24414578e-01f, -8.09640288e-02f, 1.64369796e-03f, 1.46942124e-01f, 2.56719530e-01f, -1.85528055e-01f, -1.88873671e-02f, 2.22902671e-01f, 1.33027792e-01f,
  -2.05308080e-01f, -1.11136355e-01f, 1.90748408e-01f, -7.24979192e-02f, 7.43188662e-03f, 1.26380399e-01f, 1.86216250e-01f, -2.13046856e-02f, 3.44806500e-02f, 5.22989631e-01f,
  1.04625516e-01f, -3.92757691e-02f, -8.06767419e-02f, 6.00466989e-02f, 3.24198902e-02f, -2.37725824e-02f, 6.32493198e-02f, -2.12210223e-01f, -3.75829712e-02f, -1.87480167e-01f,
  2.42865711e-01f, 1.72757044e-01f, -5.97757176e-02f, 7.32186064e-02f, 3.44309568e-01f, -8.27482045e-02f, 2.93079138e-01f, 8.97509605e-02f, 1.40414268e-01f, -1.05245717e-01f,
  2.58422107e-01f, 2.59802848e-01f, 5.84373511e-02f, 4.88833943e-03f, 5.27845472e-02f, -1.65777430e-02f, -8.60332996e-02f, 1.08983420e-01f, 8.02983195e-02f, 1.49162337e-01f,
  1.01238884e-01f, -2.55514413e-01f, -4.80587929e-02f, -5.67507558e-02f, -2.07875799e-02f, 1.95229668e-02f, -1.29072353e-01f, 8.51898268e-02f, -8.89048949e-02f, -2.23112538e-01f,
  -1.66773856e-01f, -8.15524310e-02f, 1.39832780e-01f, 2.00119205e-02f, 5.60960174e-02f, -9.86929685e-02f, -2.29976758e-01f, -1.14832669e-01f, 2.14502007e-01f, 7.95719400e-03f,
  8.32578465e-02f, -6.35716692e-02f, 2.14430779e-01f, -2.19150841e-01f, -2.60672113e-03f, 4.98887002e-02f, 3.92823875e-01f, -2.50505596e-01f, 4.06530835e-02f, 1.41961258e-02f,
  -1.25622422e-01f, 2.16717556e-01f, 4.36067358e-02f, -2.37051263e-01f, -2.26402674e-02f, -5.90367056e-02f, 3.31503563e-02f, -5.71381710e-02f, 2.58684065e-02f, -7.79346526e-02f,
  2.83781290e-02f, 2.50959218e-01f, 1.27391800e-01f, 3.43206897e-02f, 4.66717631e-02f, -2.27160901e-01f, -2.06827018e-02f, -2.47700900e-01f, -1.54789209e-01f, 8.32586512e-02f,
  -1.37198254e-01f, 4.62951176e-02f, 2.17375845e-01f, -5.54173738e-02f, 1.12942822e-01f, 2.08546564e-01f, 7.72889256e-02f, 2.02475831e-01f, -3.07653934e-01f, 1.51920870e-01f,
  2.72627473e-02f, 2.25583576e-02f, -2.68611535e-02f, -1.11321084e-01f, 7.00757802e-02f, 1.24885321e-01f, 3.15265357e-02f, -9.37567726e-02f, -1.06324935e-02f, -1.38729855e-01f,
  5.36358096e-02f, -7.28644133e-02f, -5.66922016e-02f, -1.02637380e-01f, 6.93037212e-02f, -1.82403848e-01f, -1.61913484e-01f, 2.90881723e-01f, 1.11926630e-01f, 1.49877176e-01f,
  -1.79058105e-01f, 1.61058784e-01f, -2.61461157e-02f, -1.42624661e-01f, 5.38471565e-02f, -3.02863032e-01f, 7.94464648e-02f, 9.80792567e-02f, -1.97452456e-01f, -2.07510144e-01f,
  -1.38325527e-01f, 4.70860392e-01f, -3.97940539e-02f, 4.94187251e-02f, -1.19785398e-01f, -2.01366339e-02f, -7.96087924e-03f, -8.39303359e-02f, -5.50346449e-02f, -1.17098512e-02f,
  -2.26007029e-01f, -1.16884544e-01f, -2.36292835e-02f, -5.64129911e-02f, -7.12781325e-02f, 7.38668665e-02f, 4.60471287e-02f, 1.52811417e-02f, -7.97133148e-02f, 9.21821371e-02f,
  1.50686443e-01f, 1.64383158e-01f, -1.70586228e-01f, 1.01448648e-01f, -5.45106940e-02f, -1.65145338e-01f, 1.25022233e-01f, -5.39875269e-01f, -7.40453303e-02f, -8.03659633e-02f,
  2.69695073e-01f, -5.61055243e-01f, -1.24254532e-01f, 4.20755148e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.00172269e-01f, 9.04323310e-02f, 6.19022409e-03f, 3.43436718e-01f, 3.05206954e-01f, 9.27903317e-03f, 1.43216982e-01f, 4.76341993e-01f, 4.82432783e-01f, 3.66737209e-02f,
  1.21819980e-01f, 1.95574373e-01f, -4.66210917e-02f, -2.53305435e-01f, 7.86302239e-03f, -1.54542491e-01f, -7.20870122e-02f, -1.77798092e-01f, 3.28082182e-02f, 1.98498294e-01f,
  2.82277644e-01f, 9.35461074e-02f, 4.44771439e-01f, 2.46973455e-01f, 9.40976292e-03f, 1.21165834e-01f, 4.56287652e-01f, 3.34097035e-02f, 2.72336930e-01f, -2.33794704e-01f,
  7.71069825e-01f, -1.19018771e-01f, 8.46811831e-02f, 1.23874523e-01f, 6.15729511e-01f, -4.66748595e-01f, -5.05238734e-02f, 5.81064045e-01f, 4.96765435e-01f, -2.36395016e-01f,
  5.16803801e-01f, 1.08937144e-01f, 2.96707571e-01f, 3.62418592e-01f, 3.07524592e-01f, -2.15110302e-01f, 2.43306488e-01f, -5.22407591e-01f, -5.92899978e-01f, 1.53691307e-01f,
  -3.38296175e-01f, 1.20830692e-01f, 5.98224640e-01f, 1.51460581e-02f, 6.84687614e-01f, -2.76753247e-01f, 8.07024464e-02f, -4.46960390e-01f, -2.80007303e-01f, -2.45809495e-01f,
  1.52090713e-01f, 7.98954189e-01f, 2.95063555e-02f, -2.51507133e-01f, 2.19655484e-02f, -3.45706306e-02f, 2.63899975e-02f, -1.03808358e-01f, -5.80934584e-02f, 1.38121694e-01f,
  -9.44280624e-03f, 8.07140097e-02f, 3.11654210e-01f, 2.59813108e-03f, 2.72073805e-01f, 1.78057715e-01f, -2.76222616e-01f, -7.22488523e-01f, -1.19712971e-01f, -5.51530182e-01f,
  -3.98138940e-01f, 7.21484005e-01f, 2.62858063e-01f, 3.52425545e-01f, 8.01871836e-01f, 5.58917522e-01f, 4.49062645e-01f, 3.57500076e-01f, -2.18524382e-01f, 7.71567822e-02f,
  2.33882040e-01f, -2.18360633e-01f, -6.10355437e-02f, -1.92195520e-01f, 4.81493957e-02f, 2.76465178e-01f, -9.58841592e-02f, 1.18267983e-01f, -1.27399758e-01f, 1.04722150e-01f,
  1.82504028e-01f, 4.06844944e-01f, 3.61626297e-01f, 2.07542777e-01f, -1.34882614e-01f, 1.11046255e-01f, 3.28636676e-01f, -2.17731334e-02f, -1.66819602e-01f, 1.35044171e-03f,
  2.92387843e-01f, 5.85927784e-01f, 1.93473816e-01f, 3.82375300e-01f, 7.91568816e-01f, 1.33538817e-03f, -2.07951382e-01f, 1.69879735e-01f, -5.62589645e-01f, -7.85228610e-01f,
  3.62372905e-01f, 3.76564354e-01f, 4.71210808e-01f, -3.04997236e-01f, -3.24748099e-01f, 4.00472075e-01f, 2.47957230e-01f, 7.82684028e-01f, 2.33366758e-01f, 9.02931914e-02f,
  4.06503856e-01f, 3.48601788e-01f, -7.50345364e-02f, 1.11524157e-01f, 1.82664096e-01f, -4.42297198e-02f, 3.93818438e-01f, 2.83025056e-01f, 2.12273806e-01f, 2.59700000e-01f,
  2.08473161e-01f, -1.18765645e-01f, -1.55968726e-01f, 8.69675074e-04f, 3.83418411e-01f, 3.26710552e-01f, -2.48238165e-02f, -4.18209255e-01f, 3.40716839e-01f, -4.72958744e-01f,
  4.40216035e-01f, 2.15479031e-01f, -4.26512152e-01f, 9.60227549e-01f, -5.31779416e-02f, -6.56105429e-02f, -1.18875280e-01f, 6.20471060e-01f, 9.33910534e-02f, -4.69213843e-01f,
  5.64067736e-02f, 1.08089671e-01f, -1.52906373e-01f, 1.47507032e-02f, 3.52667689e-01f, 5.10745406e-01f, 2.06957221e-01f, 3.08266073e-01f, 5.01544893e-01f, 2.44935140e-01f,
  3.01017016e-01f, 1.40723586e-01f, -3.36133808e-01f, 5.77925742e-01f, 2.01137066e-01f, 4.29636985e-01f, -2.85018176e-01f, -3.91280264e-01f, -1.53389156e-01f, 2.92204112e-01f,
  -1.44603938e-01f, -2.48203073e-02f, -4.11395222e-01f, -1.22663379e-01f, 8.40418458e-01f, -4.81999069e-01f, -3.70166212e-01f, -9.88932997e-02f, -1.13966748e-01f, 6.14369996e-02f,
  -7.37159774e-02f, 2.01788157e-01f, 8.76887515e-02f, 2.52229035e-01f, -1.27194077e-01f, 2.05740165e-02f, 4.37340647e-01f, 3.16810966e-01f, 8.81649777e-02f, 6.89625502e-01f,
  2.78094947e-01f, 3.41201305e-01f, 1.00173682e-01f, 6.45403415e-02f, -1.10303506e-01f, -1.02596827e-01f, 5.73048741e-02f, -6.37584701e-02f, -2.64457196e-01f, -4.70088720e-01f,
  1.19584523e-01f, 2.11860225e-01f, 2.22002760e-01f, 1.15763068e-01f, 1.30669042e-01f, -1.80550277e-01f, 2.46930495e-01f, -2.56275952e-01f, 4.73644108e-01f, -1.93678528e-01f,
  3.02191496e-01f, -6.71954304e-02f, 5.64247847e-01f, 3.01378280e-01f, 7.09085688e-02f, -4.50174809e-02f, 1.66792095e-01f, 1.88734289e-02f, -1.18945792e-01f, 3.12160671e-01f,
  2.54697680e-01f, -1.08419976e-03f, 1.92418635e-01f, 2.94348836e-01f, 2.14787126e-01f, -1.29816011e-01f, -6.48316592e-02f, -1.84680104e-01f, 1.34479642e-01f, -1.40310839e-01f,
  -2.41000876e-01f, 2.77810186e-01f, -3.19637746e-01f, 7.53336102e-02f, 5.18927038e-01f, -1.75830111e-01f, -1.16720013e-01f, 6.48163930e-02f, -4.79841888e-01f, 1.26429424e-01f,
  1.82682667e-02f, 4.13147956e-01f, 3.24591309e-01f, -3.75916094e-01f, -1.59340173e-01f, 5.20882010e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.41124770e-01f, 6.89041466e-02f, 1.92707628e-01f, -4.52158526e-02f, 9.94306132e-02f, 4.46022183e-01f, 4.59775448e-01f, 2.19548360e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  6.32004961e-02f, 4.21951264e-01f, 2.65022099e-01f, -9.81768873e-03f, -4.62964661e-02f, -3.65162492e-02f, 5.16741037e-01f, -3.05427939e-01f, 8.19267854e-02f, -2.38651216e-01f,
  3.99691135e-01f, 1.30910859e-01f, -8.60327110e-02f, 6.19219020e-02f, 1.78666219e-01f, -4.70064841e-02f, -2.61276364e-01f, -2.86426097e-01f, -1.18461259e-01f, -3.83233309e-01f,
  2.78694719e-01f, -2.62806445e-01f, -1.32240355e-01f, -2.23050676e-02f, 1.70819297e-01f, 8.04362819e-02f, 2.95493066e-01f, -1.16881132e-01f, -7.33154267e-02f, -3.14446092e-01f,
  2.60157697e-02f, 3.55415642e-01f, 6.39993027e-02f, -2.69653559e-01f, 1.13249935e-01f, -9.27313864e-02f, 9.89817977e-02f, 3.94284457e-01f, 2.56703585e-01f, 1.78213805e-01f,
  5.82167171e-02f, 2.46569142e-01f, -6.30803779e-02f, -3.72135907e-01f, 1.79322883e-01f, 1.34105429e-01f, -5.74820638e-01f, -3.84138197e-01f, -1.43047124e-01f, -4.08426076e-01f,
  -1.37844503e-01f, -3.68847668e-01f, 9.89992172e-02f, 1.69411451e-02f, -3.68701294e-02f, -8.24732557e-02f, 2.22810909e-01f, -2.15487167e-01f, 2.89063007e-01f, -6.36114478e-02f,
  2.01931059e-01f, -1.90548107e-01f, -3.00789893e-01f, 1.75588340e-01f, -1.35852590e-01f, -3.02260280e-01f, 1.30400404e-01f, -1.69346988e-01f, -3.23431641e-01f, 2.09660754e-01f,
  -3.96785773e-02f, 2.25094199e-01f, -4.70230868e-03f, -4.67807092e-02f, -1.89127117e-01f, -4.14418906e-01f, -1.08054087e-01f, 4.45970565e-01f, -9.27316695e-02f, 4.70670164e-01f,
  1.88280404e-01f, 7.11318776e-02f, -6.36814654e-01f, -1.05702430e-01f, -5.16590141e-02f, 3.99792045e-02f, -3.23348969e-01f, 6.73581839e-01f, -9.67687815e-02f, -1.94898441e-01f,
  -2.51734167e-01f, 2.80402124e-01f, -1.18815273e-01f, 1.95730790e-01f, 1.76761016e-01f, -7.29377056e-03f, -1.79948956e-01f, -2.85541892e-01f, -5.70826940e-02f, -1.39527664e-01f,
  -3.27539705e-02f, 2.79991686e-01f, 1.64735839e-01f, 2.29979590e-01f, 2.41013646e-01f, 4.18789357e-01f, 1.01688601e-01f, -3.96746367e-01f, 1.16583943e-01f, 5.22212572e-02f,
  -2.93415394e-02f, -7.36149400e-02f, 2.48217940e-01f, -2.02404767e-01f, -1.10352293e-01f, 2.75189787e-01f, 4.70767021e-01f, -3.48799706e-01f, -4.97147411e-01f, -1.83865100e-01f,
  2.82211244e-01f, -1.61517560e-01f, -9.74422395e-02f, 7.89093040e-03f, 2.76237488e-01f, -1.42045438e-01f, -1.13503933e-01f, -5.40259555e-02f, -9.65001956e-02f, 4.08269688e-02f,
  4.37642075e-02f, -5.95895797e-02f, -1.55909479e-01f, 1.77991986e-01f, -1.31407291e-01f, 1.15589634e-01f, 5.33216372e-02f, -9.49607864e-02f, 1.13879470e-02f, -5.00611007e-01f,
  1.75631270e-01f, 5.93175232e-01f, -2.37230398e-02f, 4.75128978e-01f, 1.67528197e-01f, 3.63281429e-01f, -2.69749790e-01f, -3.22837919e-01f, -1.64936349e-01f, 3.78775030e-01f,
  -2.39612848e-01f, 4.23989981e-01f, -1.92105658e-02f, 4.31440413e-01f, -1.92774162e-01f, -1.63405880e-01f, 5.76485097e-02f, 5.47289476e-02f, 4.03401442e-02f, -2.45106608e-01f,
  9.78396088e-02f, -3.37198943e-01f, -9.17976573e-02f, -2.61190951e-01f, -2.00910226e-01f, -3.08949918e-01f, -3.04218531e-01f, -1.28822774e-01f, 8.99846386e-03f, -7.85612166e-02f,
  -1.27501309e-01f, -1.34105146e-01f, -3.70930105e-01f, 2.16043949e-01f, 6.96683377e-02f, 4.33289945e-01f, -1.11282043e-01f, 3.63488317e-01f, -5.28679132e-01f, 7.30750561e-02f,
  -2.11762786e-01f, -1.23731866e-02f, -2.10731998e-01f, 5.33165872e-01f, 2.28682929e-03f, -4.90897000e-02f, 1.45318314e-01f, 2.02447385e-01f, -1.99214801e-01f, 6.11617044e-02f,
  3.18619817e-01f, -2.32817158e-01f, 3.66073698e-02f, -3.15900892e-01f, 3.16558480e-01f, -3.51454807e-03f, 5.29879443e-02f, -8.17547888e-02f, 1.21902287e-01f, -9.64697078e-02f,
  4.49658670e-02f, 4.88080690e-03f, -1.37105852e-01f, -9.29827020e-02f, -4.09346640e-01f, 2.99478993e-02f, -1.68566033e-02f, 2.04319701e-01f, -9.13701195e-04f, 4.22339998e-02f,
  9.43673924e-02f, 9.66869891e-02f, 3.02755088e-01f, 1.07873946e-01f, -1.54360786e-01f, -6.19382299e-02f, 2.78082699e-01f, -2.33543172e-01f, -7.51269832e-02f, -3.45516980e-01f,
  -7.09217414e-02f, -9.42930803e-02f, 4.25810635e-01f, -3.18220377e-01f, 8.00741613e-02f, -2.31747419e-01f, 3.72595847e-01f, 2.19390869e-01f, 7.95112401e-02f, -3.79038185e-01f,
  -8.04545060e-02f, -2.93552279e-02f, -1.10960796e-01f, -3.03679079e-01f, 1.80224746e-01f, 2.84307659e-01f, -7.95139611e-01f, -2.11273402e-01f, -1.52264550e-01f, 5.47984838e-02f,
  -3.15356553e-01f, -2.02619702e-01f, 3.81313339e-02f, -2.68604219e-01f, -2.68132985e-01f, 2.51156151e-01f, 2.13844568e-01f, -1.37599304e-01f, -2.57429779e-02f, -2.01059535e-01f,
  1.68542951e-01f, -1.37671649e-01f, -1.62437424e-01f, 1.15500450e-01f, 6.39530122e-02f, 1.22416588e-02f, 3.91771048e-01f, 2.19829723e-01f, 5.57083860e-02f, -9.91592109e-02f,
  8.78472999e-02f, 1.99219435e-01f, -4.75927562e-01f, -2.12686315e-01f, 2.71202251e-03f, 9.45794359e-02f, -3.23331654e-01f, 1.81149036e-01f, 1.53842181e-01f, 5.40933549e-01f,
  -1.52457103e-01f, 3.86293620e-01f, 3.93867940e-01f, 3.47137988e-01f, -2.12059706e-01f, -2.59193987e-01f, -9.02370274e-01f, 7.18149483e-01f, -2.93891519e-01f, 1.42461658e-01f,
  -2.34543672e-03f, -1.81413189e-01f, -1.82307467e-01f, -2.02650517e-01f, -1.72706917e-01f, 6.11239821e-02f, 7.51333833e-02f, 8.84032398e-02f, 2.55722135e-01f, -1.00518219e-01f,
  2.17001200e-01f, 3.57215852e-01f, 7.03462660e-02f, 7.95497373e-02f, 3.95274013e-01f, 1.89091742e-01f, -1.82831198e-01f, 6.22552782e-02f, 8.88124704e-02f, 3.45528454e-01f,
  -4.97420490e-01f, 9.20564160e-02f, 1.19636461e-01f, 4.65290844e-01f, 1.95017263e-01f, 1.95317641e-01f, 6.46609366e-02f, -8.04709364e-03f, 1.25567615e-01f, 1.95092574e-01f,
  -7.30086342e-02f, -1.19315341e-01f, 7.87443295e-03f, -3.41550618e-01f, -4.52282816e-01f, -1.40633687e-01f, 7.32148811e-02f, 1.65408134e-01f, 1.76570997e-01f, -2.98419535e-01f,
  3.33106928e-02f, 7.23701939e-02f, -9.70277116e-02f, 2.24619001e-01f, 1.94916856e-02f, -3.37382853e-01f, -2.03446195e-01f, 9.96244103e-02f, 4.63952757e-02f, -3.26642811e-01f,
  8.30795020e-02f, 2.52900243e-01f, -1.42859668e-01f, -6.70936584e-01f, 1.50801092e-02f, -8.11635554e-02f, -2.51455933e-01f, -2.75730729e-01f, 3.26010197e-01f, -1.61638990e-01f,
  3.82890224e-01f, -5.62924564e-01f, 4.49107885e-01f, -1.05832539e-01f, 3.07593551e-02f, 1.65300202e-02f, 2.05214947e-01f, 4.30927500e-02f, -2.32361302e-01f, 2.61151623e-02f,
  4.52321097e-02f, -3.58137250e-01f, 2.40387395e-02f, -3.18945408e-01f, -6.46435991e-02f, -1.43705666e-01f, 8.58563557e-02f, -3.26441437e-01f, -5.42651415e-01f, -4.11395460e-01f,
  -9.41262173e-04f, -5.29923856e-01f, -4.34264302e-01f, -9.83257219e-02f, -2.63312608e-02f, 2.08164435e-02f, 2.42119879e-01f, -1.51544586e-01f, -2.86914587e-01f, 1.41270861e-01f,
  -2.15422899e-01f, 3.21053416e-02f, -4.81535822e-01f, -1.49387000e-02f, 1.69959217e-01f, -8.79275873e-02f, -7.95747191e-02f, 3.71641755e-01f, 1.94175661e-01f, 6.45786300e-02f,
  -1.83805555e-01f, -2.82857180e-01f, 5.26588112e-02f, 4.94180284e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -2.93585032e-01f, -6.74920321e-01f, 5.74808538e-01f, 3.90674084e-01f, 3.88901263e-01f, 2.44582355e-01f, -4.41067457e-01f, 2.76380330e-01f, -1.77818555e-02f, -3.16158414e-01f,
  -2.98379362e-01f, -1.24616995e-01f, -7.69760907e-01f, -4.91420001e-01f, -2.92463303e-01f, 4.30801719e-01f, -5.89757025e-01f, -3.00630152e-01f, -6.22845702e-02f, 4.33939919e-02f,
  -6.21268339e-02f, -2.42933214e-01f, 3.70675862e-01f, -3.08128208e-01f, 4.42432076e-01f, 1.68975398e-01f, 9.47527349e-01f, 5.72262287e-01f, 2.59903222e-01f, -2.31911853e-01f,
  5.58220208e-01f, -6.33836985e-02f, 2.04916880e-01f, 2.32856378e-01f, -8.46180618e-01f, -1.32302719e-03f, -2.92467475e-01f, -1.69643074e-01f, -5.37925959e-01f, 5.41200638e-01f,
  3.32359344e-01f, -1.19080268e-01f, 2.70107597e-01f, -2.63209432e-01f, 8.12180817e-01f, -5.29698968e-01f, 6.28078878e-01f, -5.30332804e-01f, 6.11183718e-02f, -8.51405114e-02f,
  -2.04858258e-01f, -1.28094945e-02f, -1.86460644e-01f, 6.63585663e-02f, 4.46711868e-01f, 1.23400554e-01f, -1.00185812e+00f, 8.61486912e-01f, -4.04439747e-01f, 5.20604134e-01f,
  4.72695500e-01f, 3.23421240e-01f, -7.73381442e-02f, -4.35781628e-01f, 4.38497752e-01f, 4.50955212e-01f, 2.44144604e-01f, 2.30560943e-01f, 8.64313394e-02f, -5.85400283e-01f,
  -3.15028369e-01f, -8.06360766e-02f, 7.85011239e-03f, 1.50941452e-02f, 2.93823421e-01f, 8.22709143e-01f, -9.59555805e-02f, -4.42140341e-01f, 9.81476188e-01f, 1.60657719e-01f,
  6.99448436e-02f, 7.84364164e-01f, -1.55874249e-02f, 4.53447968e-01f, -4.75840449e-01f, -1.77692264e-01f, 5.67327082e-01f, -1.16472222e-01f, 2.51130909e-01f, 3.64109576e-01f,
  4.01152857e-02f, 3.38397473e-01f, -1.00220799e+00f, 8.89204443e-01f, 3.61270934e-01f, 2.07712919e-01f, 8.05129290e-01f, 7.43727505e-01f, 2.53458709e-01f, -1.45662827e-02f,
  4.44473088e-01f, 6.04930520e-01f, 6.86676800e-01f, 4.09949273e-01f, 4.03946757e-01f, 4.26726311e-01f, 3.80495012e-01f, 6.97765172e-01f, 1.45799354e-01f, 6.76744044e-01f,
  -1.75692752e-01f, 8.36241961e-01f, 4.37281489e-01f, 5.58837429e-02f, 9.63378623e-02f, -1.18074499e-01f, -3.71669441e-01f, 8.60579252e-01f, -4.64782327e-01f, -5.73501348e-01f,
  -7.52096921e-02f, 6.74171269e-01f, 1.04932800e-01f, -9.59067047e-01f, 3.68463367e-01f, 5.29974878e-01f, 1.41492814e-01f, -1.69917047e-01f, -4.75097567e-01f, 1.42739564e-01f,
  -1.69255584e-01f, -1.98358893e-01f, -3.27590734e-01f, 4.25072126e-02f, 5.62992990e-01f, -6.64677262e-01f, -6.19120479e-01f, 1.28523156e-01f, 3.92769724e-01f, -4.60357852e-02f,
  5.30260444e-01f, -1.33669972e-01f, 9.15515840e-01f, 4.61637199e-01f, 1.29087532e+00f, 6.08711421e-01f, 5.60573339e-01f, 4.66272295e-01f, 7.45924950e-01f, -7.11551070e-01f,
  -4.34453607e-01f, -4.64100420e-01f, 4.97911066e-01f, -1.67887270e-01f, -3.26868623e-01f, 5.63588560e-01f, 1.97015360e-01f, 1.61355823e-01f, 6.65996909e-01f, -9.50972915e-01f,
  -2.05159754e-01f, -2.86303729e-01f, 2.10547045e-01f, -1.24470510e-01f, 2.15394929e-01f, -4.81745824e-02f, -1.48476005e-01f, -9.13121521e-01f, 1.80793792e-01f, -3.87069255e-01f,
  -1.44317091e-01f, -6.72850162e-02f, 3.41399789e-01f, 5.45989610e-02f, -3.94476801e-01f, -3.53427567e-02f, -2.15774179e-01f, 1.27715811e-01f, 1.91490784e-01f, 4.53585610e-02f,
  -1.90813631e-01f, -2.70216614e-01f, -1.59961671e-01f, -1.98417932e-01f, 1.94754243e-01f, 6.26215994e-01f, 6.20098233e-01f, 1.14249766e-01f, 4.34174865e-01f, -7.56885767e-01f,
  4.27085042e-01f, 2.22551510e-01f, 4.06256288e-01f, 3.92897055e-02f, 8.58430713e-02f, -3.49964872e-02f, -1.52841255e-01f, -3.13364983e-01f, 3.84887755e-01f, -5.13486505e-01f,
  4.27749813e-01f, -3.09893429e-01f, 4.51428294e-01f, 3.00248414e-01f, 1.96405686e-02f, 2.96442360e-01f, 5.18542707e-01f, 2.87325680e-01f, -2.77273953e-01f, 7.56074131e-01f,
  -4.35886770e-01f, -3.19729000e-01f, -3.92592520e-01f, 3.20384741e-01f, -6.03034317e-01f, -2.53180303e-02f, 3.92065674e-01f, 7.35871017e-01f, 3.16257239e-03f, -9.40392375e-01f,
  -8.15659389e-02f, 1.96218431e-01f, 3.97256166e-01f, 3.54339182e-01f, 2.71009445e-01f, 4.03133243e-01f, -2.46368930e-01f, 2.92089522e-01f, 6.78146034e-02f, -3.61852556e-01f,
  2.86765397e-01f, -5.57931781e-01f, -1.58880070e-01f, -9.46401134e-02f, 5.24447501e-01f, -1.49622396e-01f, -1.60698276e-02f, -3.77002239e-01f, 2.27913171e-01f, -5.53941905e-01f,
  -2.27691785e-01f, 5.30352164e-03f, -3.51222157e-01f, 4.29614633e-01f, 2.05637459e-02f, -1.34000871e-02f, -4.14593160e-01f, -4.66470510e-01f, 4.06417310e-01f, 8.02930295e-01f,
  4.67368066e-01f, -6.14817381e-01f, 4.70664173e-01f, 2.53116731e-02f, -1.76370233e-01f, 1.35044143e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  4.12157290e-02f, 2.57545322e-01f, 3.24163765e-01f, 5.92835665e-01f, 1.84350833e-01f, -7.73406848e-02f, 2.24827975e-01f, 1.51480854e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -8.54130208e-01f, 7.74102360e-02f, 5.59953868e-01f, 3.39350581e-01f, -4.38349426e-01f, -4.74156708e-01f, -9.74340364e-02f, 1.46710929e-02f, -1.83721215e-01f, -4.04181331e-01f,
  -6.86421394e-01f, -5.25604069e-01f, -6.67378232e-02f, -1.38261139e-01f, -2.88410157e-01f, 4.56940323e-01f, 3.01093072e-01f, -8.49434957e-02f, -7.67134205e-02f, 4.31026042e-01f,
  -1.74441278e-01f, -5.66753149e-01f, 8.42050388e-02f, 6.93026602e-01f, 2.73879290e-01f, -3.08649272e-01f, -2.53666602e-02f, -8.38721931e-01f, 7.43092149e-02f, 4.27711695e-01f,
  -5.72013855e-01f, -6.99820518e-01f, -2.27705941e-01f, 3.32052261e-01f, 1.63475633e-01f, 4.49035168e-01f, 8.77395719e-02f, 6.80575252e-01f, 3.70056689e-01f, 1.18077502e-01f,
  -6.15667939e-01f, -1.06252179e-01f, -3.45166087e-01f, -4.14166629e-01f, -2.71216094e-01f, 2.37203732e-01f, -3.60506475e-02f, -2.71627754e-01f, -1.81911245e-01f, 4.19047147e-01f,
  3.22954684e-01f, 2.46569782e-01f, 4.19700176e-01f, -5.58515787e-01f, 3.30613762e-01f, 8.75944555e-01f, 2.11946219e-01f, -4.68908757e-01f, 1.19395033e-01f, -2.78680027e-01f,
  -8.15867662e-01f, 1.71471834e-01f, 3.63159508e-01f, 1.99550629e-01f, 1.55392587e-01f, -1.87104166e-01f, -2.72229403e-01f, -3.05342406e-01f, 3.39948267e-01f, -6.15498245e-01f,
  2.96231806e-01f, 4.69960980e-02f, 4.27083194e-01f, 1.52321383e-01f, 2.35655725e-01f, -1.25570118e-01f, -2.95665592e-01f, -1.98310122e-01f, 3.34760994e-01f, -4.45626557e-01f,
  -4.37924713e-02f, -1.28579035e-01f, -4.28222239e-01f, 5.94537795e-01f, 2.60259300e-01f, -3.73642564e-01f, 2.47945234e-01f, 7.98191607e-01f, 5.21556437e-01f, -2.09167331e-01f,
  4.33028817e-01f, -6.25960231e-01f, -1.02879715e+00f, -2.34864339e-01f, -4.01230663e-01f, -3.83650094e-01f, 5.14702857e-01f, 7.33516961e-02f, -3.65457118e-01f, -3.82450610e-01f,
  6.55101895e-01f, 1.69699162e-01f, -2.23447785e-01f, -4.96919453e-01f, -1.53536439e-01f, 2.14732826e-01f, 6.07845858e-02f, -7.30345324e-02f, 5.50538078e-02f, 5.10017574e-01f,
  8.13102841e-01f, -3.74304831e-01f, 1.26882866e-01f, 6.81622744e-01f, 3.01026702e-01f, -1.00841868e+00f, -2.09722072e-01f, 3.15506876e-01f, -6.91709757e-01f, -2.96502948e-01f,
  2.61727035e-01f, -4.26499575e-01f, -6.21843934e-01f, -8.33901823e-01f, 3.79882395e-01f, 2.69166708e-01f, -8.93853426e-01f, -7.63465405e-01f, 7.14855373e-01f, -3.88667017e-01f,
  3.77835810e-01f, -1.36504337e-01f, -2.49082699e-01f, -9.22984406e-02f, -2.24006727e-01f, 2.00709969e-01f, -1.46888286e-01f, -3.01214844e-01f, -9.15495083e-02f, 1.83146209e-01f,
  1.17711395e-01f, -6.79507196e-01f, 6.19005203e-01f, 9.19786930e-01f, -5.24411976e-01f, 7.43784308e-02f, 1.76577017e-01f, -9.49029773e-02f, -2.80553371e-01f, 9.28290725e-01f,
  7.92268157e-01f, -4.39003766e-01f, -1.66059047e-01f, -1.69661507e-01f, 3.60971421e-01f, -9.37472761e-01f, 4.60011750e-01f, -2.86464930e-01f, -2.14597136e-01f, -2.22403198e-01f,
  -3.04336458e-01f, -4.50788066e-02f, 7.32551813e-02f, 1.97745502e-01f, 4.79200363e-01f, 4.78462577e-01f, -5.06085753e-01f, -8.32569152e-02f, 5.86340487e-01f, 2.29318812e-01f,
  4.17308718e-01f, 4.33426559e-01f, 1.00411080e-01f, -2.30859429e-01f, -6.86678350e-01f, 3.51290256e-01f, 6.48384213e-01f, 1.57537073e-01f, 4.87671167e-01f, -4.80085790e-01f,
  -6.37449503e-01f, 1.56485930e-01f, -1.86641410e-01f, -5.30769348e-01f, -2.19337732e-01f, -4.25668746e-01f, -3.74342985e-02f, 1.43987402e-01f, 3.27822208e-01f, -1.78253523e-03f,
  9.04756188e-02f, -6.94700181e-02f, 4.22821283e-01f, -5.10256998e-02f, -6.11215472e-01f, -8.17414280e-03f, -7.61604980e-02f, -9.35057327e-02f, 3.24203283e-01f, 2.33036757e-01f,
  -7.22005486e-01f, -3.22499394e-01f, -4.90142196e-01f, 9.09753516e-02f, -4.40927476e-01f, -8.09645176e-01f, -2.14233845e-02f, -5.67130566e-01f, 4.07686830e-02f, 5.49113512e-01f,
  -7.45316893e-02f, 2.55906254e-01f, -3.33258480e-01f, 3.33781570e-01f, -5.94650984e-01f, -4.75422084e-01f, -5.11691451e-01f, -5.00242710e-01f, 2.10792318e-01f, 3.93159956e-01f,
  -7.10162163e-01f, -6.04250133e-01f, 3.32815588e-01f, -6.64943039e-01f, 2.36237347e-01f, 1.38990864e-01f, 2.44380593e-01f, -3.54221672e-01f, -7.28016138e-01f, -6.42299429e-02f,
  -4.80725348e-01f, -4.36568767e-01f, 2.53866464e-02f, 7.01949894e-02f, -1.20748110e-01f, 1.02254339e-01f, -7.18944371e-01f, -4.95097071e-01f, 5.75585216e-02f, -1.98777527e-01f,
  3.16333584e-02f, -6.39762223e-01f, -3.87254804e-01f, -7.67440200e-02f, -7.98264444e-02f, -3.95846426e-01f, -3.32460225e-01f, 3.69241476e-01f, -3.37283224e-01f, 1.00481653e+00f,
  -2.22699016e-01f, -3.54047239e-01f, -7.96267688e-01f, -2.17497528e-01f, 3.98044705e-01f, 1.94308653e-01f, -2.43572012e-01f, -6.43137634e-01f, -4.86637473e-01f, -1.86640382e-01f,
  -1.54509195e-04f, -6.24481916e-01f, 2.88764954e-01f, -3.78641129e-01f, 4.53512400e-01f, 5.83513640e-02f, -5.52830815e-01f, 4.72727805e-01f, 3.06507707e-01f, 2.86727518e-01f,
  -2.67410427e-01f, 3.71627599e-01f, -4.08364415e-01f, -3.55877936e-01f, -8.06375682e-01f, -3.94905895e-01f, -1.78085398e-02f, -5.43661654e-01f, 6.06253818e-02f, -1.17947310e-01f,
  -5.85056841e-01f, -3.98313731e-01f, -7.99292743e-01f, 3.27489376e-01f, -1.28772032e+00f, 2.60964632e-01f, 1.03942350e-01f, 4.16861594e-01f, -2.90713996e-01f, 1.26596019e-02f,
  2.34711885e-01f, -5.40545762e-01f, 2.75675923e-01f, 1.01600841e-01f, 1.17126487e-01f, 2.14484051e-01f, 2.21576527e-01f, 5.40197909e-01f, 6.21922910e-01f, 2.23211110e-01f,
  3.33505780e-01f, 1.50992483e-01f, 2.43185014e-01f, -2.91292757e-01f, 2.02118412e-01f, 1.64510116e-01f, -6.97316587e-01f, -1.99650928e-01f, 7.35469282e-01f, 2.09046274e-01f,
  2.14014545e-01f, 4.70205456e-01f, -8.99290204e-01f, 8.22012007e-01f, 5.22190571e-01f, 7.92196915e-02f, -1.06656663e-01f, -7.44040370e-01f, -2.58207053e-01f, -2.78320938e-01f,
  -2.57703483e-01f, -4.03596520e-01f, -4.82456893e-01f, -7.05692708e-01f, -6.72661841e-01f, 1.49031654e-01f, -2.62256294e-01f, 6.46084547e-01f, -6.96888566e-01f, 4.30692226e-01f,
  2.42081076e-01f, -5.09760201e-01f, 1.98049948e-01f, 2.75464684e-01f, -4.42458868e-01f, 5.52982464e-02f, -6.00846171e-01f, -9.22544003e-01f, 5.74327707e-01f, 1.82054371e-01f,
  1.10246405e-01f, -3.04836072e-02f, 9.89651144e-01f, -5.92868209e-01f, 5.61457157e-01f, -4.47866499e-01f, -8.99981916e-01f, -3.11847538e-01f, -2.41933450e-01f, -5.92111237e-02f,
  -1.14767277e+00f, 4.51208740e-01f, 3.62864435e-01f, 3.35036755e-01f, 5.91980159e-01f, 2.45523170e-01f, 6.40184283e-01f, 4.67783213e-01f, 2.17381090e-01f, 4.60398525e-01f,
  4.96234924e-01f, -2.72780418e-01f, 1.37237245e-02f, -4.40901220e-01f, 5.88778138e-01f, 9.43261623e-01f, 5.09970129e-01f, 1.54159948e-01f, 4.21317697e-01f, -7.20485389e-01f,
  8.26506793e-01f, 1.55101597e-01f, 6.73998535e-01f, 8.18856716e-01f, -3.18785459e-01f, -4.04346347e-01f, 8.41743797e-02f, -5.15535831e-01f, -8.63428533e-01f, 6.99108720e-01f,
  -5.35582006e-01f, -4.98381108e-01f, -1.07857995e-02f, -4.83185023e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.68068737e-01f, -3.11290264e-01f, 3.99475470e-02f, 2.79702097e-02f, 1.83853716e-01f, -2.53828526e-01f, -6.85493723e-02f, 3.45332287e-02f, 2.31415257e-01f, 8.74721184e-02f,
  2.26921067e-01f, 3.77307624e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    