/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.27452193e-02f, -9.82275307e-02f, -3.78377020e-01f, 1.85956061e-01f, 6.50087520e-02f, -1.21758386e-01f, -1.06515743e-01f, 1.94492385e-01f, -1.62691966e-01f, 8.64411220e-02f,
  2.77325898e-01f, -3.87835920e-01f, -1.63129494e-01f, 1.29508182e-01f, -2.04552442e-01f, -1.59200922e-01f, -3.38642560e-02f, 2.91085560e-02f, -2.08653942e-01f, 6.29014969e-02f,
  1.48962149e-02f, 2.87354022e-01f, -4.43272144e-02f, 5.63883968e-02f, 1.41644150e-01f, -9.52697266e-03f, 1.75764054e-01f, -1.47817835e-01f, 1.72294319e-01f, 2.39952914e-02f,
  5.72326109e-02f, 6.66930750e-02f, 6.25247657e-02f, -3.35547850e-02f, 1.01694673e-01f, 5.04151918e-02f, 6.67109096e-04f, -1.08531751e-01f, -9.22208726e-02f, -5.84111661e-02f,
  -4.32683192e-02f, -6.04991522e-03f, 8.10371339e-03f, -2.68111099e-02f, -2.01626844e-03f, 6.94114342e-03f, -4.21775766e-02f, -2.55977362e-02f, -6.38102889e-02f, -2.61757430e-02f,
  -3.91423702e-02f, -1.36710983e-02f, -4.98206262e-03f, -5.00812717e-02f, -7.70056993e-02f, -7.55135864e-02f, -4.60056290e-02f, -6.12271344e-03f, -1.18696997e-02f, -2.19732244e-02f,
  2.41870480e-03f, -4.56656963e-02f, 3.76143716e-02f, 6.54149130e-02f, -3.99503037e-02f, 1.11334704e-01f, -2.64492817e-02f, 3.42333168e-02f, -2.39182729e-03f, 7.85516854e-03f,
  1.29095525e-01f, 8.21997672e-02f, 1.45327374e-02f, 5.20678237e-02f, 1.66483782e-02f, 6.48553446e-02f, -3.52527574e-02f, 6.35919422e-02f, 7.27500319e-02f, 2.93694623e-02f,
  -7.78863207e-02f, 1.25346254e-04f, -4.42986423e-03f, 5.34262061e-02f, -2.64384188e-02f, -1.06113262e-01f, 3.81673910e-02f, -2.44623348e-02f, 3.52218971e-02f, 4.95143756e-02f,
  9.03823748e-02f, 5.02511766e-03f, -6.90481067e-02f, 2.79590506e-02f, -1.11366175e-01f, 3.83215472e-02f, -8.60804841e-02f, 7.51571134e-02f, -8.39475915e-02f, 7.02326074e-02f,
  1.06306285e-01f, 1.28760189e-01f, -1.14949755e-02f, 4.72952873e-02f, 3.44035961e-02f, 1.04601443e-01f, 1.06639545e-02f, -2.70309374e-02f, 1.08777963e-01f, 7.51682967e-02f,
  1.03694730e-01f, 4.42675594e-03f, -4.44715880e-02f, 7.70316049e-02f, 1.49313778e-01f, 4.10727151e-02f, 6.58700913e-02f, -6.58397004e-02f, 8.77071768e-02f, -6.96872696e-02f,
  4.42683250e-02f, -1.27379835e-01f, -3.13391924e-01f, -3.93378213e-02f, -2.64831007e-01f, 1.78393483e-01f, 1.70290217e-01f, -1.60830021e-01f, -9.40347165e-02f, 1.65055811e-01f,
  1.91131517e-01f, -2.46587008e-01f, 9.23568085e-02f, 1.92762867e-01f, -9.98254120e-03f, 1.32873803e-01f, 1.24464452e-01f, 5.30335009e-02f, -1.11435018e-01f, -9.10715573e-03f,
  -1.02220424e-01f, 1.60302043e-01f, 6.82713762e-02f, -2.56766248e-02f, -5.69328554e-02f, -1.34784609e-01f, 2.94255674e-01f, -1.43065393e-01f, -1.91275962e-02f, 2.22364459e-02f,
  3.74032035e-02f, 1.15613248e-02f, -6.04393445e-02f, -3.47877368e-02f, 1.05591789e-02f, 3.84630300e-02f, -1.75085757e-02f, -7.26335542e-03f, 1.63659155e-02f, -5.22623807e-02f,
  -2.70714075e-03f, -1.08403876e-01f, -2.91848164e-02f, -1.09061204e-01f, -7.40734935e-02f, -6.37385175e-02f, -7.57857859e-02f, 3.55420895e-02f, -1.64322387e-02f, -3.63896191e-02f,
  -6.70708120e-02f, 1.56994467e-03f, 2.36441065e-02f, 2.79877391e-02f, -8.74109417e-02f, -7.58643374e-02f, 5.74337784e-04f, -1.01413533e-01f, 1.53480619e-02f, 2.79116873e-02f,
  4.51397188e-02f, -2.86286324e-02f, -1.53167006e-02f, 9.52167623e-03f, 1.93490237e-02f, 8.26412290e-02f, -2.88491007e-02f, 1.32705837e-01f, -5.25833555e-02f, 3.00661922e-02f,
  9.06257555e-02f, -1.66439656e-02f, -3.26767075e-03f, -4.75978479e-02f, -2.44573299e-02f, 1.35529144e-02f, -1.08930878e-02f, -7.30878189e-02f, -2.43297704e-02f, 5.87283224e-02f,
  4.44633588e-02f, 7.74723962e-02f, -8.62008259e-02f, 1.01246737e-01f, -1.13498420e-02f, -7.44219795e-02f, -3.77322026e-02f, -3.67773846e-02f, 5.35238709e-04f, 1.09256282e-02f,
  9.07200277e-02f, -8.61614123e-02f, -1.71223208e-02f, -1.09070577e-01f, 5.50030470e-02f, -2.18143947e-02f, 6.99040443e-02f, -2.81636603e-03f, -6.11227937e-03f, 3.26994993e-02f,
  -1.24014460e-01f, -2.56753974e-02f, -2.21940558e-02f, 8.67731273e-02f, 6.27084374e-02f, 5.85545823e-02f, 6.98633268e-02f, -6.51177857e-03f, 3.55067253e-02f, -2.88533582e-03f,
  9.54342633e-03f, -1.64271891e-02f, 7.74860829e-02f, -3.76563333e-03f, 1.13818771e-03f, 5.02841584e-02f, -3.00737154e-02f, 7.31405010e-03f, 2.17736675e-03f, -1.32215070e-03f,
  4.37664568e-01f, -1.50950640e-01f, -3.53572108e-02f, 1.03125148e-01f, 1.36446491e-01f, 2.00314090e-01f, 1.46813050e-01f, -2.88476814e-02f, -5.29835820e-02f, -1.89879626e-01f,
  5.68896644e-02f, 7.16638193e-02f, -1.02237254e-01f, -1.29577205e-01f, 3.21165025e-01f, -1.42425478e-01f, 8.22723210e-02f, 7.94186629e-03f, -1.23167217e-01f, 5.72054721e-02f,
  -1.25119637e-03f, 9.15046409e-03f, -7.01229274e-02f, -4.20303792e-02f, 3.90940346e-02f, 1.94648877e-02f, 1.15496412e-01f, -2.39352928e-03f, -1.68040115e-02f, -9.95371584e-03f,
  -2.30146777e-02f, -1.51669487e-01f, -1.88959716e-03f, -4.44762483e-02f, 2.47670803e-02f, 3.62587944e-02f, 1.43751027e-02f, 5.92823029e-02f, 9.43184923e-03f, -2.28110161e-02f,
  3.96903930e-03f, 7.96997473e-02f, 9.93584655e-03f, 1.00989779e-02f, 7.10355267e-02f, -2.09312886e-02f, -3.34971659e-02f, -1.57492533e-02f, -5.14357351e-02f, 5.45192603e-03f,
  4.71060909e-02f, -2.81216670e-02f, 5.72814327e-03f, 2.47975942e-02f, -6.33476957e-05f, -4.32422757e-02f, 2.20630039e-02f, 1.06674584e-03f, 3.73101868e-02f, -2.47459933e-02f,
  1.70047581e-02f, 2.57204138e-02f, -2.67514121e-02f, -1.13896681e-02f, -5.97856287e-03f, -5.84764928e-02f, -8.65078357e-04f, -1.49943782e-02f, -1.80557743e-02f, -3.69600719e-03f,
  -1.29743302e-02f, 5.87321958e-03f, -3.49464901e-02f, 3.56303155e-02f, 1.14590470e-02f, -1.03984829e-02f, 4.47319224e-02f, 2.50214692e-02f, -1.34183671e-02f, -2.12445799e-02f,
  -2.95332745e-02f, -6.36865059e-03f, -3.88812423e-02f, 7.59883365e-03f, -2.82101426e-02f, 2.02034004e-02f, -5.64516298e-02f, -7.74127766e-02f, 3.20594609e-02f, 7.65272900e-02f,
  -5.17896153e-02f, -5.54590439e-03f, -8.26182738e-02f, 4.31605056e-02f, -1.22633986e-02f, 1.91735309e-02f, -6.31907210e-02f, 6.90165628e-03f, -8.00125003e-02f, -3.62679106e-03f,
  9.68772098e-02f, 1.93009190e-02f, -1.73562933e-02f, 3.10058650e-02f, -2.04374660e-02f, 1.95543766e-02f, 2.45481562e-02f, -2.20493553e-03f, 5.71614727e-02f, -4.77800518e-02f,
  1.91020090e-02f, 7.98725560e-02f, 1.74803864e-02f, 2.80307513e-03f, 3.73471417e-02f, 8.08523148e-02f, 3.16772684e-02f, 3.02388649e-02f, 5.50028086e-02f, -1.06212739e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.25471631e-01f, 6.25543475e-01f, -2.82279879e-01f, 3.41192752e-01f, -3.44662458e-01f, 5.20447433e-01f, 4.35469061e-01f, -1.44076169e-01f, 4.37770672e-02f, 4.90863740e-01f,
  1.45166963e-01f, 2.04655170e-01f, 1.51743695e-01f, 5.59621274e-01f, -2.89905369e-01f, 3.45455080e-01f, 3.40374857e-01f, 3.68927538e-01f, -1.31826960e-02f, 6.30595461e-02f,
  -2.52678208e-02f, 3.25346500e-01f, 5.49727445e-03f, 1.95749681e-02f, 2.07840919e-01f, -1.58266529e-01f, -1.46738842e-01f, -2.19153017e-01f, 4.10571620e-02f, 4.52516833e-03f,
  1.05871342e-01f, 5.54988012e-02f, -2.57060789e-02f, -4.70788330e-02f, 1.59563366e-02f, -6.73210844e-02f, -6.02000132e-02f, -9.74973068e-02f, -2.01047540e-01f, 5.14828973e-02f,
  1.16410032e-01f, -2.39617042e-02f, 9.83574837e-02f, -9.42309499e-02f, 7.06249801e-03f, -8.07650909e-02f, 5.00113964e-02f, 1.79867889e-03f, 4.27586362e-02f, 1.30159259e-01f,
  2.21056305e-02f, -2.08202936e-02f, 1.55521482e-02f, 8.15799311e-02f, -1.20597519e-01f, -3.03348601e-02f, -1.50988856e-02f, -6.51165694e-02f, -6.77418057e-03f, -2.09869072e-03f,
  -5.45679266e-03f, -4.76783887e-03f, 1.17524471e-02f, 4.88265269e-02f, 7.06889033e-02f, -2.31211502e-02f, 9.16542113e-02f, -1.53729180e-02f, -6.27146810e-02f, 8.79832581e-02f,
  1.50406379e-02f, -7.27913976e-02f, 4.63997871e-02f, -9.73957125e-03f, 1.26253143e-01f, 7.89247006e-02f, -6.62689516e-03f, 9.33815166e-03f, 1.21986177e-02f, -2.87984796e-02f,
  -3.58064147e-03f, -6.57093972e-02f, 6.57824427e-02f, 2.44689528e-02f, -1.70763372e-03f, -1.77567769e-02f, 7.34946951e-02f, -2.67166626e-02f, 3.38150770e-03f, -1.22758970e-02f,
  2.54163980e-01f, -2.50643622e-02f, 4.71659936e-02f, 1.02996200e-01f, 3.17595638e-02f, -3.59415412e-02f, -4.32076827e-02f, -3.24969664e-02f, 6.63378984e-02f, 6.68171570e-02f,
  7.05175549e-02f, 1.39433488e-01f, -1.36556759e-01f, -4.80866842e-02f, -6.29783645e-02f, 1.41011387e-01f, -1.34164039e-02f, -5.80773279e-02f, -2.05161963e-02f, -5.89889996e-02f,
  -9.94963348e-02f, 1.60067361e-02f, -5.38204871e-02f, 8.72239769e-02f, 3.25085223e-02f, 8.39279369e-02f, -4.26653661e-02f, -6.02236912e-02f, -8.75754729e-02f, -2.79206131e-02f,
  6.16838336e-01f, -2.76202947e-01f, 3.40250544e-02f, 1.00565948e-01f, -1.40478119e-01f, -9.93676260e-02f, 2.59668171e-01f, -2.82685697e-01f, -2.57683367e-01f, -2.60331005e-01f,
  1.08482361e-01f, 1.27055421e-01f, 2.98901170e-01f, -1.25724271e-01f, 5.79279006e-01f, 2.57706672e-01f, -2.45747250e-02f, 9.18089524e-02f, -6.84526190e-02f, 8.96486938e-02f,
  1.13219351e-01f, -2.61871312e-02f, 1.06597051e-01f, -4.57163364e-01f, -2.35897265e-02f, -1.71038926e-01f, 6.70671016e-02f, -8.67551267e-02f, -2.17626974e-01f, 7.70114064e-02f,
  8.08316469e-02f, 9.35677961e-02f, -3.73194664e-04f, -3.09325829e-02f, -3.97779141e-03f, -2.56872782e-03f, 6.85331821e-02f, 1.66836053e-01f, -7.21851885e-02f, -1.27646491e-01f,
  1.21829212e-01f, 1.93707831e-02f, -9.96421427e-02f, -6.44340133e-03f, -7.24149793e-02f, -1.87479466e-01f, -3.25017013e-02f, -1.31742299e-01f, -3.39827649e-02f, 5.38403094e-02f,
  -3.18772607e-02f, -1.20196696e-02f, 1.23590631e-02f, 3.50992801e-03f, -2.47511938e-02f, -2.22859886e-02f, 8.20545554e-02f, 7.18887299e-02f, -1.08486533e-01f, 3.93468440e-02f,
  3.73108126e-02f, 7.34482408e-02f, 1.34629324e-01f, 1.03465244e-02f, 7.13261887e-02f, -3.47324684e-02f, 1.30316660e-01f, 6.09011622e-03f, 1.70788411e-02f, -1.12126041e-02f,
  -1.12249136e-01f, 1.58266649e-02f, -2.80576013e-02f, -2.31812354e-02f, 3.52877118e-02f, 1.41885858e-02f, 7.66180530e-02f, -3.11097484e-02f, -4.75026928e-02f, -1.63483083e-01f,
  1.47992373e-02f, -3.97044607e-02f, -6.90076426e-02f, -6.70768395e-02f, -1.20478272e-02f, -2.86797695e-02f, -4.84248661e-02f, -1.18691241e-02f, -2.07266826e-02f, 2.98229177e-02f,
  6.02067001e-02f, 2.38641817e-02f, -9.43669081e-02f, -2.04094443e-02f, -6.47467524e-02f, -1.17382243e-01f, -1.75834335e-02f, -1.70554742e-01f, 1.36528770e-02f, -3.69005539e-02f,
  -1.41362861e-01f, -5.41464724e-02f, 5.73965535e-02f, -4.87736911e-02f, 1.57205779e-02f, -5.22554666e-03f, 1.37452513e-01f, -1.30464092e-01f, -9.49314609e-02f, 1.17297079e-02f,
  -3.36376997e-03f, 3.56560275e-02f, 7.35308975e-02f, -1.69011161e-01f, -4.53551821e-02f, 1.12477958e-01f, -1.07956924e-01f, -4.93872762e-02f, 3.53902355e-02f, -8.60598236e-02f,
  2.43553802e-01f, 1.05675675e-01f, -3.22046876e-01f, 3.73159975e-01f, 4.64307219e-02f, -2.03854308e-01f, -5.58554649e-01f, 2.16940612e-01f, -1.91812485e-01f, 1.78697005e-01f,
  8.85993838e-02f, 8.88445973e-02f, -2.29520842e-01f, 4.18662578e-01f, 3.25572014e-01f, -3.13436836e-01f, 3.66990685e-01f, -5.16018532e-02f, -2.88971048e-02f, 3.79145712e-01f,
  2.67125010e-01f, 5.81329882e-01f, 7.54908845e-02f, 3.85338366e-01f, 2.69728631e-01f, 3.89372073e-02f, 4.91634697e-01f, -3.69308025e-01f, 5.36941469e-01f, 1.64851174e-01f,
  -5.69355488e-02f, 5.96770681e-02f, -8.21063668e-02f, -1.20732971e-01f, 1.10740975e-01f, -3.55918594e-02f, -1.68866720e-02f, -7.78163150e-02f, -3.74525860e-02f, 7.61025995e-02f,
  -5.34242056e-02f, 6.79713935e-02f, 9.96308699e-02f, 5.00614122e-02f, 7.18864501e-02f, 1.43726915e-02f, 1.10796943e-01f, 1.85972787e-02f, -3.19242068e-02f, 1.03058882e-01f,
  -1.25248000e-01f, -7.95124006e-03f, 1.72579940e-02f, 2.96331029e-02f, -6.63552433e-03f, 1.11683495e-01f, 4.17443961e-02f, -3.05653829e-02f, -6.14797138e-02f, 1.00235313e-01f,
  4.35486017e-03f, -2.90614534e-02f, 5.19538252e-03f, -2.56438851e-02f, 5.23210242e-02f, -2.89449487e-02f, 2.99607664e-02f, -8.71131420e-02f, 4.73055355e-02f, 7.30724931e-02f,
  -1.55051555e-02f, -2.99664401e-03f, 4.68410365e-02f, -4.70329039e-02f, -1.88538078e-02f, 3.39973345e-02f, -6.09273314e-02f, 3.75335775e-02f, -1.07173167e-01f, -4.40937690e-02f,
  -7.96136037e-02f, 1.55707896e-02f, -2.20805239e-02f, 1.17187155e-03f, 4.68822084e-02f, 7.79594630e-02f, 2.06726596e-01f, 9.44354013e-02f, -5.42056710e-02f, -6.98379576e-02f,
  1.29694641e-01f, 2.59382039e-01f, -3.89657542e-02f, 8.44820961e-02f, -4.87071536e-02f, 1.06673896e-01f, -6.67294711e-02f, 8.19776207e-02f, 2.85132267e-02f, -6.14458956e-02f,
  9.32396501e-02f, -9.57977325e-02f, 1.58928245e-01f, -8.75282511e-02f, -5.37762372e-03f, 1.51325883e-02f, -2.85066217e-02f, 6.68280339e-03f, 1.01084439e-02f, 1.21229447e-01f,
  -1.90938753e-03f, 5.25878742e-02f, 3.07290931e-04f, -3.93646769e-02f, 1.07376650e-01f, -1.18585646e-01f, -2.65158676e-02f, -2.32810806e-02f, 2.03805249e-02f, 2.30894722e-02f,
  1.34697825e-01f, 5.44779420e-01f, -4.43382598e-02f, -2.88552403e-01f, 5.55460341e-02f, -2.22062632e-01f, -1.41662806e-01f, 1.67093948e-01f, -2.09839374e-01f, 4.80200052e-01f,
  -3.87878753e-02f, 1.18668839e-01f, 1.54369865e-02f, -3.96692693e-01f, -7.82646656e-01f, -4.68925864e-01f, -3.65117162e-01f, -1.40185714e-01f, -2.70391226e-01f, 2.81611294e-01f,
  -1.61137253e-01f, -1.16450958e-01f, -4.02984738e-01f, 1.64836243e-01f, 2.05503806e-01f, 2.98891813e-01f, 2.80115485e-01f, 9.79007557e-02f, 1.94001377e-01f, -1.70685410e-01f,
  -3.77387628e-02f, -1.65708940e-02f, 3.58633585e-02f, -7.34874755e-02f, 9.57630724e-02f, 2.94550899e-02f, 4.94189076e-02f, -2.35537738e-01f, -2.50855852e-02f, -5.85547090e-02f,
  5.58656640e-02f, -6.45187274e-02f, -1.41739413e-01f, -1.22073255e-01f, 6.36716709e-02f, -4.13101539e-02f, -3.58953141e-02f, 2.08391622e-02f, -2.61374973e-02f, -1.18788429e-01f,
  -7.00102374e-02f, -3.33164334e-02f, 1.74930673e-02f, 5.84592205e-03f, -4.70815673e-02f, -7.48662576e-02f, 1.02016544e-02f, -2.86037605e-02f, 4.14040014e-02f, 3.12441401e-02f,
  -5.29769622e-03f, 9.04685482e-02f, -8.86250585e-02f, -3.25213037e-02f, -9.43633541e-03f, 1.92202590e-02f, 1.52570605e-02f, 9.00533721e-02f, 5.60140945e-02f, 1.06969848e-01f,
  1.34122103e-01f, 1.15206307e-02f, -6.52151508e-03f, 7.63347819e-02f, 1.14305303e-01f, 1.05598429e-02f, -2.63986383e-02f, 2.82569509e-02f, -1.37013286e-01f, 1.88312754e-02f,
  -2.17852257e-02f, -7.44235516e-02f, -2.12955773e-02f, -1.82914827e-02f, -1.30118936e-01f, 5.83324283e-02f, 1.84733868e-02f, -2.21317839e-02f, -1.10991366e-01f, 5.27757555e-02f,
  1.95993185e-01f, 3.06270689e-01f, 1.65083669e-02f, 4.35566762e-03f, 3.79679091e-02f, 1.66669544e-02f, -3.01168654e-02f, 4.52620499e-02f, 3.86180729e-02f, -6.80063739e-02f,
  9.56777856e-02f, 1.17152065e-01f, 1.81776628e-01f, -1.33097723e-01f, 4.50398512e-02f, 3.72050591e-02f, 1.25547126e-01f, 6.45606667e-02f, 1.67564452e-01f, 2.48689651e-02f,
  8.42597336e-02f, 1.32744715e-01f, -3.65210176e-02f, 4.74406593e-02f, 8.06687213e-03f, 6.55083209e-02f, 9.67486650e-02f, 1.91307347e-02f, -1.66945159e-03f, 3.75284776e-02f,
  -3.25535268e-01f, 5.42633176e-01f, -2.23003387e-01f, 3.47103089e-01f, -1.73933096e-02f, 5.07410944e-01f, 3.23083967e-01f, 3.29002738e-01f, 3.79793704e-01f, 3.28944832e-01f,
  1.03750154e-01f, 2.08981812e-01f, 2.41072997e-01f, 3.31022799e-01f, 2.87291855e-01f, 3.80292892e-01f, 3.04171145e-01f, 2.16524780e-01f, 3.95373106e-02f, 8.61982703e-02f,
  -2.95527838e-02f, 1.58693627e-01f, -1.36345744e-01f, -1.83451697e-01f, -2.57506311e-01f, -2.36670032e-01f, -1.37135953e-01f, -3.40093136e-01f, -1.13152690e-01f, -9.22322497e-02f,
  -1.83205530e-01f, -1.31629005e-01f, -1.03910968e-01f, -6.12847172e-02f, 4.13213000e-02f, -1.27461171e-02f, -4.62000333e-02f, -1.15120679e-01f, 3.26306447e-02f, 5.52726798e-02f,
  7.65379593e-02f, -6.55376390e-02f, 3.85732055e-02f, 3.69554125e-02f, 6.95058778e-02f, -1.22991011e-01f, -6.31046072e-02f, -4.03622873e-02f, 9.09310058e-02f, -4.71991748e-02f,
  -2.28201523e-02f, 4.14912626e-02f, -2.25496273e-02f, -1.19804153e-02f, -6.28137067e-02f, 6.22585900e-02f, 1.13735892e-01f, -1.08586945e-01f, 1.69745222e-01f, 1.60074487e-01f,
  -1.61674190e-02f, 5.07186316e-02f, -1.97728388e-02f, -4.37843874e-02f, -1.56233227e-02f, -1.12558477e-01f, 7.31242150e-02f, -2.56838258e-02f, -2.14490257e-02f, -3.83589230e-02f,
  9.04474966e-03f, 1.25082284e-01f, 5.13780266e-02f, 7.69601166e-02f, -3.05668712e-02f, -3.69947739e-02f, 1.56812929e-02f, 2.40902919e-02f, 2.91632973e-02f, 3.88933755e-02f,
  -6.61746180e-03f, 4.27185558e-03f, -4.07595448e-02f, -6.11442998e-02f, -2.93083601e-02f, 3.41519888e-04f, 2.52366010e-02f, -1.47373020e-03f, -1.94371138e-02f, -6.95887357e-02f,
  4.64527667e-01f, 5.28003454e-01f, -2.21473295e-02f, -7.56996498e-02f, 5.40832169e-02f, 2.71501373e-02f, 3.92627232e-02f, -3.92371826e-02f, 9.92910266e-02f, -4.98231165e-02f,
  4.20566350e-02f, 5.38108405e-03f, 3.04918992e-03f, -4.73913774e-02f, 4.69617657e-02f, 1.47205934e-01f, 8.12610015e-02f, 2.91054733e-02f, 1.21576943e-01f, -3.30747217e-02f,
  -7.88988695e-02f, 4.16103378e-02f, -3.34151834e-02f, -1.17396817e-01f, 2.53749732e-02f, 3.34642874e-03f, 8.56457725e-02f, 5.15864044e-03f, 3.96849122e-03f, 1.20838873e-01f,
  7.51288950e-01f, -2.35244557e-01f, 1.77210178e-02f, 7.28615880e-01f, 2.42326394e-01f, 1.95330027e-02f, -1.04255475e-01f, 3.62990260e-01f, 9.20031726e-01f, -2.62697637e-01f,
  -2.14171410e-01f, 1.55978724e-01f, -4.28637743e-01f, 1.92173034e-01f, -2.67944485e-02f, -2.30328128e-01f, 3.85641247e-01f, 6.12585880e-02f, 2.28741869e-01f, 1.36086971e-01f,
  3.20502788e-01f, -1.86512813e-01f, -3.12768668e-01f, -3.31926286e-01f, 1.65331393e-01f, 7.28955418e-02f, -3.59243751e-01f, -4.47421551e-01f, -2.10244805e-01f, -1.53320625e-01f,
  2.29434192e-01f, 1.27853155e-01f, 5.63823730e-02f, -2.90931296e-02f, -1.56082315e-02f, -5.00154905e-02f, -8.84324759e-02f, -2.28283986e-01f, 1.12144321e-01f, 2.64301170e-02f,
  5.58865666e-02f, 5.84200537e-03f, 1.07106477e-01f, -8.47585276e-02f, 1.36618093e-01f, 8.99646133e-02f, 1.67863816e-01f, 1.11689322e-01f, 7.86796287e-02f, 1.33294817e-02f,
  8.66186991e-02f, 9.94965136e-02f, 2.18992934e-01f, -3.25895362e-02f, 3.81386392e-02f, 1.56624094e-01f, 1.01555027e-02f, -1.75705820e-01f, 4.11386864e-04f, 1.67398080e-01f,
  -5.79296835e-02f, -9.83987227e-02f, -2.48899171e-03f, 2.77038142e-02f, -1.15356557e-02f, 9.53010917e-02f, 3.80141623e-02f, -4.50228266e-02f, 8.41146708e-02f, -3.95986699e-02f,
  -2.69937310e-02f, 7.75859728e-02f, 1.58944562e-01f, 2.27255933e-02f, 4.17822674e-02f, 6.65905476e-02f, 2.41720164e-03f, -1.37117952e-01f, -1.17487404e-02f, 1.05021045e-01f,
  -4.96745706e-02f, 1.70699373e-01f, -2.39815176e-01f, 1.53450156e-02f, 6.26042560e-02f, -1.11745946e-01f, -3.11865262e-03f, 6.26794770e-02f, 1.35646658e-02f, -7.43120834e-02f,
  -1.42677173e-01f, -3.60918880e-01f, -1.03978276e-01f, -6.39646724e-02f, 6.28147423e-02f, -1.41844405e-02f, 7.33135492e-02f, 5.27944043e-02f, -4.08829972e-02f, 1.41590044e-01f,
  -1.46655217e-02f, -4.35030125e-02f, 3.02756019e-02f, 4.43839207e-02f, -9.36280563e-02f, -1.33558307e-02f, 1.80992798e-03f, 1.73638295e-02f, 7.10127829e-03f, 4.94517852e-03f,
  -1.26549810e-01f, 9.52591561e-03f, -4.83032968e-03f, -1.78738106e-02f, 2.70827878e-02f, -8.26260597e-02f, 1.36232853e-01f, 1.00360299e-02f, 3.29509319e-04f, 5.30221732e-03f,
  -1.88026235e-01f, 1.28205791e-01f, -3.34031194e-01f, -3.57755840e-01f, -3.26622725e-01f, -4.68174249e-01f, -5.82496464e-01f, -1.45034131e-03f, 4.75024253e-01f, 5.71456775e-02f,
  -9.24029276e-02f, 4.10201550e-01f, 3.31091344e-01f, -3.46825123e-01f, 1.53040349e-01f, 1.88546956e-01f, -5.29256463e-01f, -2.57290512e-01f, 8.46575126e-02f, -3.05901110e-01f,
  -1.13654472e-01f, -3.15652996e-01f, -3.10938001e-01f, -1.69742227e-01f, -3.55653197e-01f, -1.71520948e-01f, -1.39851958e-01f, -3.23760539e-01f, -3.74475747e-01f, -6.13488108e-02f,
  -2.12835118e-01f, -2.66182721e-02f, -1.81748956e-01f, -6.52153865e-02f, -1.22533463e-01f, -4.89686988e-02f, -2.09830865e-01f, 6.33652508e-03f, 2.59073675e-02f, -4.39212061e-02f,
  8.33963007e-02f, 4.07110527e-02f, -2.08791718e-02f, 1.07422285e-01f, -5.09387292e-02f, -8.73408541e-02f, -2.17330419e-02f, -1.37478933e-01f, 3.68859246e-02f, -3.05312127e-03f,
  5.15756421e-02f, -7.77131245e-02f, -1.79204494e-01f, 1.01998188e-01f, -2.29957059e-01f, -5.42460382e-02f, 4.16132621e-02f, -2.77263634e-02f, -4.35431302e-02f, -1.69819687e-02f,
  -1.24290906e-01f, 5.50481491e-03f, -6.20774142e-02f, 8.13725498e-03f, -4.11825553e-02f, 8.02046135e-02f, 5.65495342e-02f, 9.78549644e-02f, 4.41448065e-03f, -3.11679952e-02f,
  3.09384279e-02f, 9.27189440e-02f, 4.51660249e-03f, -2.78907456e-02f, 3.60012427e-02f, -3.82739790e-02f, -3.24203796e-03f, -8.16076547e-02f, -9.99401230e-03f, -4.30567786e-02f,
  -2.96247494e-03f, -1.68854389e-02f, -6.99604228e-02f, -2.77526323e-02f, -1.18643358e-01f, -5.88142406e-03f, 2.87825987e-02f, -4.48584445e-02f, -3.32016125e-02f, -4.98371087e-02f,
  -1.55970439e-01f, -1.42746329e-01f, 1.92790441e-02f, 3.94344777e-02f, 4.92394827e-02f, 1.39501505e-02f, 7.43758157e-02f, 3.50011699e-02f, -1.91244468e-01f, 1.91420093e-02f,
  -1.84227079e-01f, -3.58878672e-02f, -1.78595092e-05f, 1.61804371e-02f, 1.23268709e-01f, 1.21168420e-01f, -2.43696012e-02f, 4.60786335e-02f, -7.02671334e-02f, -7.57298544e-02f,
  -6.96056485e-02f, 1.88608095e-01f, 1.69154629e-01f, -8.32705423e-02f, 7.79677629e-02f, -1.16101846e-01f, 6.84331283e-02f, 2.12694202e-02f, 6.82741078e-03f, 1.25983488e-02f,
  2.47682363e-01f, 3.05188805e-01f, 3.03623587e-01f, 5.35578489e-01f, -2.01647803e-01f, -5.25812566e-01f, -4.71031249e-01f, 1.16676472e-01f, -2.07706057e-02f, -2.18600243e-01f,
  -1.74437091e-02f, 3.24632913e-01f, -6.71571419e-02f, 3.32330674e-01f, 1.79415524e-01f, -1.89940140e-01f, 4.24623042e-02f, 1.38985395e-01f, 1.58589035e-01f, 3.69304605e-02f,
  1.05335943e-01f, -5.78127652e-02f, 3.66511077e-01f, 1.81708634e-02f, 3.09648812e-02f, 4.73706037e-01f, 3.30139965e-01f, -4.52662930e-02f, 3.12318981e-01f, -7.10093006e-02f,
  -1.83365986e-01f, 2.77863890e-02f, 1.21399269e-01f, 4.92751831e-03f, 3.71319242e-02f, -1.60219237e-01f, -3.50034088e-02f, -7.08035231e-02f, 7.88401216e-02f, 8.31409171e-02f,
  2.79029529e-03f, 2.93173408e-03f, -9.91983153e-03f, -3.34584750e-02f, -3.50765102e-02f, 1.94531232e-01f, -1.12530682e-02f, 1.19956722e-02f, 3.10186371e-02f, -3.49607095e-02f,
  9.23390407e-03f, 1.70814041e-02f, 1.66635774e-02f, 8.37321803e-02f, 6.12204485e-02f, 4.19155583e-02f, -4.88161817e-02f, 7.88884610e-02f, 1.20655313e-01f, -3.36369202e-02f,
  5.02744038e-03f, -1.17022023e-01f, -1.55723482e-01f, -5.01346141e-02f, 6.04613721e-02f, -3.41076925e-02f, 3.17334151e-03f, 8.49244893e-02f, -8.47513005e-02f, -9.84011218e-02f,
  -4.04948182e-02f, 7.10147768e-02f, 5.06950133e-02f, -1.40375763e-01f, 3.21009010e-02f, -5.05935811e-02f, 5.72087392e-02f, 3.91332246e-02f, 3.97302816e-03f, 8.88804346e-02f,
  1.10200804e-03f, 6.06635734e-02f, -7.02378377e-02f, 4.70577553e-02f, 4.19583842e-02f, -6.09212331e-02f, 8.62029642e-02f, 2.98986305e-03f, -1.83815490e-02f, -7.84022138e-02f,
  9.53849554e-02f, 3.08214545e-01f, -1.22401990e-01f, -6.59288242e-02f, 5.96431568e-02f, -3.73003148e-02f, 7.39901364e-02f, 4.70756851e-02f, 2.28171423e-01f, 5.03427386e-02f,
  2.39436980e-02f, -4.24829647e-02f, -8.76169801e-02f, 2.36746315e-02f, -8.47120397e-03f, -6.60461709e-02f, 9.98136103e-02f, 3.52646448e-02f, 1.45235792e-01f, 1.25769839e-01f,
  8.66418630e-02f, -1.20437339e-01f, 6.70593455e-02f, -9.34055224e-02f, -2.35161185e-02f, -4.82944325e-02f, 4.60955389e-02f, 4.83449688e-03f, 7.61074573e-02f, 9.72255543e-02f,
  6.44900799e-01f, 6.71500742e-01f, 3.35331112e-01f, 1.94139972e-01f, -4.80302721e-01f, -1.04926294e-02f, 1.67586468e-02f, 1.20365389e-01f, -4.35945392e-02f, 2.60818362e-01f,
  -2.49279588e-01f, 4.10940200e-01f, -2.04080015e-01f, 3.98134530e-01f, -2.29008824e-01f, -1.06423043e-01f, 7.29838833e-02f, 6.91674352e-02f, -1.62580758e-01f, 2.60016054e-01f,
  -2.11373158e-03f, -1.67006895e-01f, 3.10331360e-02f, -1.71691328e-01f, 1.86966524e-01f, 1.33873552e-01f, -3.55947524e-01f, -1.46257356e-01f, 1.95924297e-01f, -5.24487309e-02f,
  1.30101427e-01f, -9.49378405e-03f, 1.68281630e-01f, 6.55720904e-02f, -1.39647853e-02f, -4.13957499e-02f, 9.10350010e-02f, 6.00853469e-03f, -1.70764834e-01f, 5.86375855e-02f,
  2.84403600e-02f, -7.93105178e-03f, 1.04804887e-02f, -1.44293234e-01f, -1.94525588e-02f, -1.40153393e-02f, 6.73621818e-02f, 1.10629037e-01f, 1.54940560e-01f, 8.65631551e-02f,
  1.27338678e-01f, 2.53898203e-02f, -1.75782740e-02f, 1.02109034e-02f, 6.09141123e-03f, -8.03689882e-02f, 7.50741065e-02f, 6.62338883e-02f, 8.72869641e-02f, 2.51103733e-02f,
  -6.65781945e-02f, -5.57689816e-02f, 2.40325183e-02f, 4.45382036e-02f, -3.25341411e-02f, 8.08767378e-02f, -7.06730783e-02f, -9.22538340e-02f, 2.57297996e-02f, 1.77855622e-02f,
  1.93371344e-02f, -6.52275011e-02f, 3.28329057e-02f, -6.72068894e-02f, 4.00995612e-02f, 3.66521068e-02f, -3.17961872e-02f, 2.98821218e-02f, 7.10035637e-02f, -3.05427816e-02f,
  -6.45322800e-02f, 1.99727379e-02f, -1.11353561e-01f, 9.39301103e-02f, -8.70628804e-02f, -1.77233238e-02f, 5.31735383e-02f, 4.37744074e-02f, -1.13620861e-02f, -2.19832920e-02f,
  -6.03609122e-02f, -3.44062261e-02f, 6.25562668e-02f, 4.59633619e-02f, 2.36818031e-03f, 6.58653583e-03f, -1.00704141e-01f, 1.22985028e-01f, -2.12553851e-02f, -1.04069933e-01f,
  1.64883782e-03f, -1.17833860e-01f, 2.88403444e-02f, 5.27861528e-02f, -1.89240202e-02f, 5.22631891e-02f, -1.96672976e-02f, -6.76115602e-02f, -1.08986028e-01f, 6.29390702e-02f,
  -4.92229126e-02f, 9.22045261e-02f, -4.56635957e-04f, -9.13760439e-03f, 5.77446967e-02f, -3.51987295e-02f, -8.83039609e-02f, -1.89774577e-02f, -1.15314510e-03f, -5.00605293e-02f,
  1.56053051e-01f, -2.98758686e-01f, -2.03228608e-01f, 3.73705715e-01f, 4.46588367e-01f, 4.60012645e-01f, 6.68666139e-02f, 2.49729663e-01f, 3.79807889e-01f, -1.43729702e-01f,
  -8.38555247e-02f, 1.77526638e-01f, -6.00034893e-01f, 2.66462654e-01f, 3.30999434e-01f, -3.76454800e-01f, 5.50967932e-01f, 2.09374979e-01f, 1.27055004e-01f, 3.94264609e-02f,
  2.95079164e-02f, 3.09625894e-01f, -1.30121604e-01f, 2.69488752e-01f, 1.33683473e-01f, 5.84016703e-02f, -9.10642818e-02f, -1.05371296e-01f, 1.88919157e-01f, 2.61291027e-01f,
  2.05558743e-02f, -9.60590318e-02f, 1.45314649e-01f, 1.06005520e-02f, -9.70315537e-04f, -7.18896091e-02f, -4.37256582e-02f, -1.17635489e-01f, -4.44166847e-02f, -1.01505980e-01f,
  -1.01107575e-01f, 7.04202503e-02f, 6.53048232e-02f, -2.65452778e-04f, 4.02740110e-03f, 3.54986377e-02f, -4.06801999e-02f, -5.06864078e-02f, -4.66530919e-02f, -1.31692916e-01f,
  -8.28551948e-02f, -8.00798982e-02f, -7.80882388e-02f, 1.49735929e-02f, -3.31328474e-02f, -1.05354171e-02f, 2.94714458e-02f, 4.09155823e-02f, -2.80874763e-02f, 9.98077840e-02f,
  8.61552730e-02f, -4.17893529e-02f, -7.88481683e-02f, -1.52003765e-02f, -1.58574563e-02f, 8.92216489e-02f, -9.65623371e-03f, -1.38548434e-01f, 6.71627969e-02f, 5.92265353e-02f,
  6.70442358e-02f, 7.01536685e-02f, -2.12751273e-02f, -6.20820280e-03f, 9.93549153e-02f, 3.46701418e-04f, -6.46007657e-02f, -2.10517459e-02f, -2.07969770e-02f, -3.98407802e-02f,
  -5.65502653e-03f, 2.06377022e-02f, -2.74268035e-02f, -9.82630476e-02f, -2.64872946e-02f, 1.97856163e-04f, 4.88008931e-02f, -7.24013671e-02f, -8.23680609e-02f, -2.75023058e-02f,
  1.52455807e-01f, 1.82808518e-01f, 8.21425840e-02f, 9.08572897e-02f, -5.32608060e-03f, 2.34244280e-02f, 1.51000917e-01f, 1.67747468e-01f, 8.22959170e-02f, 2.62825061e-02f,
  2.33518109e-02f, 5.55490851e-02f, -2.66983155e-02f, -2.68786810e-02f, 5.19365147e-02f, -2.11062562e-02f, -2.02532351e-01f, 1.99762136e-01f, 1.63911715e-01f, 5.29278442e-02f,
  -9.38079413e-03f, -9.71338805e-03f, 2.06273999e-02f, 9.73490551e-02f, 2.14443486e-02f, -1.36121601e-01f, 5.79598621e-02f, 1.65336505e-02f, -2.81403273e-01f, -2.60288874e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  3.55773330e-01f, 2.76282519e-01f, 4.20977660e-02f, 6.39579177e-01f, 1.73513487e-01f, 3.31864953e-01f, 1.75500259e-01f, 1.97039858e-01f, 2.86219329e-01f, 1.67678699e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.78583801e-01f, 2.32452452e-01f, -6.32892624e-02f, 1.91220909e-01f, -2.25951329e-01f, -3.02109659e-01f, 1.94931716e-01f, -4.17386770e-01f, -2.38108248e-01f, -4.11891520e-01f,
  3.21628958e-01f, -2.09884811e-02f, 3.16551149e-01f, -1.78658620e-01f, -4.60723370e-01f, 3.42668861e-01f, 2.70172097e-02f, 5.16396835e-02f, -2.80674160e-01f, -5.39270580e-01f,
  -8.38461593e-02f, 5.57377279e-01f, 2.30545253e-01f, 2.68031955e-01f, 2.24007919e-01f, -3.55322480e-01f, 1.25084534e-01f, -8.93484801e-02f, 2.66950935e-01f, 4.40186262e-01f,
  3.85663599e-01f, 2.36167029e-01f, 3.71186621e-02f, 4.65373367e-01f, 4.63944972e-01f, 2.11043805e-01f, -1.94731459e-01f, 5.47751009e-01f, -1.34845763e-01f, 9.47235227e-02f,
  1.93028554e-01f, 8.98225754e-02f, 2.95494556e-01f, -2.73135155e-01f, -4.44069535e-01f, 2.19853610e-01f, 1.45502657e-01f, 9.03571844e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.00144726e-01f, -5.14977336e-01f, 4.44275826e-01f, 2.95808792e-01f, -1.63106933e-01f, -8.22070479e-01f, 7.57158399e-01f, -6.58293962e-02f, -1.34210423e-01f, 6.03183329e-01f,
  3.09163064e-01f, 5.93168259e-01f, 6.05354086e-03f, -1.70376062e-01f, 5.50439298e-01f, 1.25362873e-01f, -8.81902874e-02f, -6.14358544e-01f, 4.63856198e-02f, 5.95337212e-01f,
  3.32056195e-01f, -3.78215909e-01f, 8.94545376e-01f, -2.10000977e-01f, 1.19071357e-01f, -3.36039633e-01f, 5.29265344e-01f, -3.23269755e-01f, -2.74544150e-01f, -5.08053660e-01f,
  -6.56123832e-02f, 2.36965269e-02f, 3.96933019e-01f, 5.63075900e-01f, 3.93738627e-01f, -1.04932654e+00f, -4.52126473e-01f, -2.59084642e-01f, 2.89855242e-01f, 1.34535685e-01f,
  3.98827791e-01f, -1.93360209e-01f, 8.60257030e-01f, -4.98287648e-01f, 8.61234426e-01f, 6.21883690e-01f, -1.67720336e-02f, -8.27073678e-03f, -6.45562336e-02f, -7.61059761e-01f,
  1.30616665e-01f, 7.56053269e-01f, 4.87562567e-01f, -3.13217752e-02f, 5.60391247e-01f, 6.04233682e-01f, 5.34612358e-01f, 3.09101403e-01f, 4.97252047e-01f, -3.66278797e-01f,
  -2.31021598e-01f, 1.64418504e-01f, 3.32856119e-01f, -1.35359272e-01f, 6.26106784e-02f, 3.95138323e-01f, 1.99939594e-01f, 8.50195706e-01f, 3.46816391e-01f, 9.03639853e-01f,
  -2.45478570e-01f, 3.79390270e-03f, 9.53897536e-01f, 3.62395495e-01f, 4.80214417e-01f, 8.34678769e-01f, -7.74769038e-02f, 5.57820082e-01f, -1.84428290e-01f, 1.00194657e+00f,
  2.14600876e-01f, 8.98655355e-01f, 3.65830481e-01f, 1.80908456e-01f, -1.14989489e-01f, 2.90937513e-01f, -1.34253800e-01f, 6.15006506e-01f, 8.70220438e-02f, 4.39351887e-01f,
  -4.45004731e-01f, 3.87705922e-01f, 7.46577919e-01f, 1.48265302e-01f, -6.56212151e-01f, 2.20337883e-02f, 2.65068978e-01f, 5.74941993e-01f, 3.33436847e-01f, -5.92161044e-02f,
  -7.21742451e-01f, -1.10976493e+00f, -1.93933323e-01f, -3.56642067e-01f, 2.25415930e-01f, 7.57291734e-01f, -2.82394230e-01f, -4.27735656e-01f, 6.33433998e-01f, 4.22016263e-01f,
  1.40917882e-01f, -2.73308665e-01f, 5.96528471e-01f, 5.08918911e-02f, 8.62041712e-01f, -3.48368287e-01f, -4.22447205e-01f, -3.09076488e-01f, -5.12765199e-02f, -4.81821030e-01f,
  -6.40496790e-01f, 5.07716000e-01f, 6.46143481e-02f, 8.80472660e-01f, -1.88509941e-01f, -2.08362520e-01f, 4.80786294e-01f, 4.36159857e-02f, 1.33036777e-01f, -3.63257527e-01f,
  4.36752945e-01f, -3.09008695e-02f, -2.45109499e-02f, -4.86226603e-02f, -1.60581127e-01f, -6.16380930e-01f, 1.30878329e-01f, 3.57378393e-01f, -1.81792766e-01f, 2.45229915e-01f,
  -2.75960386e-01f, 6.83154821e-01f, 5.10829806e-01f, -1.33167580e-01f, 2.79226124e-01f, 5.20577908e-01f, 5.78491390e-01f, -1.02428675e+00f, 5.12359999e-02f, 4.71953511e-01f,
  6.12074673e-01f, 3.21727276e-01f, 1.42221116e-02f, -1.48189500e-01f, 9.16585028e-01f, 4.40846652e-01f, 6.01855457e-01f, 5.27588248e-01f, 8.66726100e-01f, 5.36195695e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  4.02765095e-01f, -2.68513430e-02f, 6.65928662e-01f, 9.33496356e-02f, 9.25372019e-02f, 4.10292506e-01f, 5.42847335e-01f, 7.03893542e-01f, -1.28515601e-01f, 2.69057482e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.58474818e-01f, 1.19114444e-01f, 2.18931466e-01f, 1.25619814e-01f, -2.40053535e-01f, -2.70349830e-01f, 2.64862359e-01f, 3.77021074e-01f, 3.35878357e-02f, -1.14416026e-01f,
  -1.04191132e-01f, 2.14039862e-01f, 2.92179763e-01f, -3.23120415e-01f, -2.78560609e-01f, -2.67091215e-01f, 3.47835064e-01f, -3.83530781e-02f, 4.07850891e-01f, -1.15111768e-01f,
  2.97264308e-01f, 2.15724707e-01f, -4.23254162e-01f, -1.57445595e-01f, 9.25189555e-02f, -4.25996810e-01f, 3.47774290e-03f, 9.29758772e-02f, -2.84753859e-01f, 1.97421953e-01f,
  2.80466020e-01f, 3.05262208e-01f, -1.68446705e-01f, -1.57486975e-01f, -3.22204322e-01f, 7.87791908e-02f, 2.16636002e-01f, 9.22441706e-02f, 1.30733609e-01f, 1.37532473e-01f,
  2.44142070e-01f, 2.40085810e-01f, 1.94654644e-01f, -4.06325430e-01f, -2.57780999e-01f, -2.71062970e-01f, -9.89054739e-02f, -1.08243972e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  4.58263233e-02f, 1.26234472e-01f, 1.31919712e-01f, -1.82678789e-01f, 3.51614296e-01f, -1.03798665e-01f, -3.66492778e-01f, -5.58812857e-01f, 9.24561024e-01f, -4.09120500e-01f,
  -3.74859214e-01f, 3.54426950e-01f, 4.79023427e-01f, -2.11318716e-01f, -2.20700815e-01f, 6.60667121e-01f, -4.24628913e-01f, 1.72066465e-01f, 5.54345012e-01f, 3.08826655e-01f,
  1.08677936e+00f, 5.45657933e-01f, 6.11889005e-01f, 6.71392024e-01f, 2.05987498e-01f, 2.52950847e-01f, -3.45490545e-01f, -4.68552232e-01f, -6.46531701e-01f, 7.41196096e-01f,
  3.59428793e-01f, 8.31388831e-01f, -9.39532280e-01f, -7.88725317e-01f, -1.00327682e+00f, -6.45441651e-01f, -6.06976092e-01f, 8.61075819e-02f, 2.12524787e-01f, -2.39569291e-01f,
  1.93094894e-01f, 9.58255827e-02f, 3.97039980e-01f, -1.82292134e-01f, 3.00924361e-01f, 4.36051339e-01f, 1.01068819e+00f, 1.73123553e-01f, 3.03884953e-01f, 4.52764213e-01f,
  1.96586683e-01f, 1.11036623e+00f, 6.30920455e-02f, -2.95438796e-01f, 6.07409060e-01f, 1.10278940e+00f, 2.58632749e-01f, 7.52396166e-01f, -2.70497829e-01f, 4.12290603e-01f,
  -8.07143077e-02f, -1.59044415e-01f, -6.01015747e-01f, 1.19462572e-01f, 5.15445322e-02f, 4.27960396e-01f, 1.80163667e-01f, 1.01688349e+00f, -3.72870207e-01f, -8.28875422e-01f,
  9.29393947e-01f, 1.65860772e-01f, 8.80182922e-01f, 1.06249131e-01f, -3.14761907e-01f, -1.85114250e-01f, 1.18548894e+00f, 2.71092355e-01f, 6.58564627e-01f, 2.10998371e-01f,
  -4.20380682e-01f, -8.22231472e-01f, -6.57729268e-01f, -1.01302493e+00f, 2.28957191e-01f, 2.65701320e-02f, -3.68823856e-01f, 1.70453954e-02f, -3.97562645e-02f, 2.99389362e-01f,
  9.07135427e-01f, 1.07083142e+00f, -1.48078389e-02f, -6.86503947e-02f, -1.98545426e-01f, 2.27981910e-01f, 7.96454489e-01f, 1.90293893e-01f, 4.87415195e-01f, 6.61389589e-01f,
  5.41153193e-01f, 4.24433887e-01f, 2.41974831e-01f, -7.81362653e-02f, 2.39794329e-01f, -7.33898655e-02f, 9.33019519e-01f, -5.21153659e-02f, -7.42297113e-01f, 2.59472251e-01f,
  -5.33092499e-01f, 6.71170175e-01f, -8.36875319e-01f, -8.19231451e-01f, -9.04466450e-01f, 7.41991848e-02f, 3.68963987e-01f, 3.95849079e-01f, -1.56500831e-01f, 4.18465018e-01f,
  9.03413594e-01f, 4.59938496e-01f, 5.25079846e-01f, -3.14232595e-02f, -1.40007228e-01f, -8.54263544e-01f, 1.51329339e-01f, 6.17030323e-01f, 8.13808501e-01f, 7.46689022e-01f,
  9.01440918e-01f, -4.51246142e-01f, -7.11079836e-01f, 1.01492457e-01f, 6.99381113e-01f, -9.40376639e-01f, -8.74053594e-03f, -6.55141532e-01f, 3.56076002e-01f, 5.17191827e-01f,
  9.69449878e-01f, 1.25156629e+00f, 2.40432546e-01f, 1.37033656e-01f, 5.44746995e-01f, 6.88216984e-01f, 8.03093374e-01f, -4.41912487e-02f, 8.41217458e-01f, 3.69002432e-01f,
  -4.83429044e-01f, -2.53855009e-02f, 1.04673827e+00f, -1.28513157e-01f, -7.03236222e-01f, 4.94253546e-01f, 3.09265792e-01f, 3.36208157e-02f, -5.32012641e-01f, 2.34120831e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  2.04002514e-01f, 2.86203265e-01f, -8.03754777e-02f, -4.11696769e-02f, 1.80815347e-02f, 4.71923679e-01f, 8.17757696e-02f, 2.79720258e-02f, 5.70885718e-01f, 3.78221065e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  2.97268450e-01f, -2.34320417e-01f, -2.48992279e-01f, 8.59673142e-01f, -6.43425941e-01f, 3.79222006e-01f, -6.62252486e-01f, 4.03372079e-01f, -7.84199655e-01f, 5.69191396e-01f,
  2.07327396e-01f, -1.08255959e+00f, 5.92699610e-02f, -1.23248264e-01f, -7.91414917e-01f, -1.43722951e-01f, 2.88230717e-01f, -3.13467458e-02f, 2.76915245e-02f, -5.18794298e-01f,
  -8.56317341e-01f, 2.87164692e-02f, -1.13545513e+00f, 1.53989837e-01f, -5.13836481e-02f, 3.26679707e-01f, -4.63101715e-01f, 3.13952893e-01f, 1.92107290e-01f, 1.88899860e-01f,
  -8.26734066e-01f, -8.89397860e-01f, -3.59617472e-01f, 8.60705674e-02f, 1.34173105e-03f, -2.12749153e-01f, 6.01503849e-01f, 8.54854882e-01f, -8.23992550e-01f, -8.44514728e-01f,
  -2.20423654e-01f, -9.86734986e-01f, -1.05001438e+00f, 4.53196168e-01f, 7.19817281e-01f, 2.83002883e-01f, -1.87875435e-01f, -6.54440582e-01f, -7.82834291e-01f, 1.97590850e-02f,
  -2.44311079e-01f, 5.73651135e-01f, -7.18006849e-01f, 1.31223142e-01f, 1.35544345e-01f, -9.79457796e-01f, -5.72087348e-01f, 3.16797495e-02f, 4.86470520e-01f, -5.94104350e-01f,
  -1.17553020e+00f, -1.13809860e+00f, 4.49871659e-01f, 2.15041041e-01f, 9.00091529e-01f, 2.27266386e-01f, 5.43309867e-01f, 4.31103528e-01f, 9.29563820e-01f, -8.16922188e-01f,
  7.50337243e-02f, 8.19447637e-02f, -7.31758714e-01f, 1.17418021e-01f, 5.12489025e-03f, -1.11555564e+00f, 5.56724109e-02f, -7.45278239e-01f, 3.54460627e-01f, 7.47503877e-01f,
  -5.46123147e-01f, 1.88749313e-01f, 3.30908060e-01f, -2.59040892e-01f, 8.77592921e-01f, 1.10785842e+00f, 8.78450125e-02f, 2.64462531e-01f, -1.49915487e-01f, -1.74649239e-01f,
  -6.22393452e-02f, -6.27506435e-01f, 4.36762899e-01f, -1.67623274e-02f, -1.70522928e-01f, -1.57249555e-01f, -4.05485779e-02f, -1.58457607e-01f, -2.24631727e-01f, -4.32616919e-01f,
  5.42376816e-01f, -6.21170819e-01f, -7.01665521e-01f, -9.85197164e-03f, -5.53814888e-01f, -2.28372902e-01f, -7.35972941e-01f, 1.82057545e-01f, 7.63247490e-01f, -9.65384424e-01f,
  4.91909564e-01f, -8.22667241e-01f, -4.93669420e-01f, -7.60201290e-02f, -2.00036079e-01f, 5.53665876e-01f, 2.45057166e-01f, 5.28281108e-02f, 3.09174150e-01f, -8.92375410e-01f,
  -4.09303844e-01f, 3.91080379e-01f, 4.47309436e-03f, 2.10283875e-01f, -3.14549029e-01f, -3.73941101e-02f, -2.48791516e-01f, 3.05530310e-01f, -2.22305432e-01f, 2.27175668e-01f,
  -2.24527523e-01f, -2.73374468e-01f, -5.16454041e-01f, 1.27510801e-01f, 2.12901965e-01f, -6.21216178e-01f, 4.50107515e-01f, -5.92839718e-01f, 2.92505473e-02f, 2.38264188e-01f,
  -4.16659206e-01f, 3.57803404e-01f, -4.18933064e-01f, -4.79561418e-01f, 3.00549626e-01f, 1.43396392e-01f, 5.58813035e-01f, -6.91211402e-01f, 4.26248848e-01f, -4.38879102e-01f,
  4.97630358e-01f, 2.39125013e-01f, -7.01991677e-01f, -6.12996161e-01f, -1.50356686e+00f, 5.60544550e-01f, -1.16414838e-01f, -4.68725571e-03f, -2.41560385e-01f, 7.77417302e-01f,
  3.78911883e-01f, 1.47911876e-01f, -1.41599432e-01f, 4.75612640e-01f, -7.13577032e-01f, -5.26020885e-01f, -9.57061291e-01f, -8.90090883e-01f, 5.05787194e-01f, -6.24188066e-01f,
  -1.77489966e-01f, 4.88012940e-01f, -4.81543034e-01f, -7.03039885e-01f, 5.51922679e-01f, -8.92071187e-01f, -3.90932739e-01f, 8.64904672e-02f, -3.28030616e-01f, -4.17397201e-01f,
  1.93634629e-01f, -1.46321893e-01f, -4.41358626e-01f, 7.21738994e-01f, 4.38636869e-01f, -1.04605603e+00f, 1.87441126e-01f, -6.98772132e-01f, -5.94047487e-01f, -3.77027243e-01f,
  1.43308237e-01f, -4.42004889e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.29745817e-02f, 2.08521396e-01f, 1.17312476e-01f, 1.26293674e-01f, 1.41542554e-01f, -2.79575616e-01f, -2.62104310e-02f, -1.71995640e-01f, -3.24660987e-02f, 4.91606504e-01f,
  2.58440793e-01f, 5.16971350e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    