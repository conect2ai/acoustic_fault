/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.19663440e-01f, -3.97283882e-01f, 1.67502895e-01f, -2.68945456e-01f, 2.15230420e-01f, 1.92013174e-01f, 9.65986028e-03f, 2.32226215e-02f, -2.19777063e-01f, -2.64379531e-01f,
  -1.23730160e-01f, -1.82429790e-01f, -1.84034854e-02f, -2.63899833e-01f, 3.45287472e-01f, -4.12579663e-02f, -5.62836006e-02f, -9.32072848e-02f, -3.57039459e-02f, -1.33048385e-01f,
  -6.87178671e-02f, -1.07627690e-01f, 1.40700191e-01f, -1.04705930e-01f, -9.19909868e-03f, -1.75542459e-02f, -1.10326214e-02f, 6.57686368e-02f, 6.86423928e-02f, 9.84715819e-02f,
  1.59802828e-02f, -2.32607946e-01f, 1.41637651e-02f, -1.72066744e-02f, 6.55825511e-02f, 9.97442901e-02f, 9.83526707e-02f, 1.11323223e-01f, 6.88200891e-02f, 2.37020757e-02f,
  7.04753473e-02f, 1.23645104e-01f, -6.40777797e-02f, -1.80551820e-02f, -3.72175761e-02f, 2.45538875e-02f, 1.16799772e-01f, 7.43322745e-02f, 5.01495004e-02f, 1.19016536e-01f,
  3.48261781e-02f, 1.37338832e-01f, 1.08524293e-01f, 1.06260097e-02f, 1.47724614e-01f, 7.88139645e-03f, 6.99012652e-02f, 6.06713481e-02f, 5.35374954e-02f, 4.95564826e-02f,
  -7.46777607e-03f, -4.84635830e-02f, -4.49038558e-02f, -9.97291878e-03f, -7.04349354e-02f, 1.16032828e-02f, -4.74962294e-02f, 8.94808993e-02f, -2.03192960e-02f, 2.84199473e-02f,
  1.78399421e-02f, -2.24977210e-02f, -2.97932606e-02f, 8.15027580e-02f, -1.83411222e-02f, -4.42950130e-02f, 1.92999821e-02f, 3.69900391e-02f, -8.34793318e-03f, 4.70260270e-02f,
  -5.20290574e-03f, 1.83326136e-02f, -8.31111744e-02f, 1.09234676e-01f, -2.98235901e-02f, 3.60275283e-02f, -4.73466404e-02f, 5.01779914e-02f, -3.05555239e-02f, 5.80751523e-02f,
  -1.34935603e-01f, -2.58531630e-01f, -5.17384298e-02f, 2.71839526e-04f, -8.49719346e-02f, 5.46690589e-03f, -3.04752000e-04f, 7.59371324e-03f, -5.53728081e-02f, 1.07773626e-02f,
  2.56060939e-02f, -1.39149837e-02f, -1.23136895e-04f, 8.56310781e-03f, -3.85349914e-02f, -1.66928563e-02f, -1.35804247e-02f, -4.53149639e-02f, -4.77108173e-02f, -2.74402741e-02f,
  9.84972715e-03f, 2.15287860e-02f, 1.78224295e-02f, 9.69828144e-02f, -1.92991272e-02f, 1.26700429e-02f, -6.19231649e-02f, 2.28751600e-02f, 1.77542530e-02f, -1.11146666e-01f,
  -3.12021196e-01f, 3.04566417e-03f, 4.88358736e-03f, 6.53023422e-02f, -2.54582614e-01f, 2.20118791e-01f, 7.69628584e-02f, -1.95610896e-01f, -1.24533558e-02f, 1.17167860e-01f,
  -7.28752045e-03f, 1.84744000e-01f, 1.24027066e-01f, 9.19689462e-02f, 4.42274690e-01f, 2.15965301e-01f, 3.75325441e-01f, 1.83773011e-01f, 2.03081649e-02f, 1.50015756e-01f,
  -2.58973632e-02f, -4.80070114e-02f, -4.05398533e-02f, -2.11867839e-01f, -3.68865550e-01f, -1.20653547e-01f, -7.54634431e-03f, -1.36830136e-01f, -2.11041793e-03f, 2.68069431e-02f,
  -1.22426916e-02f, -1.00167073e-01f, -8.71184096e-02f, 7.90758729e-02f, 2.18472835e-02f, -2.96222158e-02f, 6.90872297e-02f, -3.37055735e-02f, 1.92291271e-02f, -2.34353123e-03f,
  -6.30501285e-02f, 4.18620594e-02f, -3.38116325e-02f, -5.75034842e-02f, -1.12215482e-01f, -6.37797937e-02f, -5.94431683e-02f, -1.37597755e-01f, 1.30348504e-02f, -5.76710403e-02f,
  -4.08360735e-02f, 6.86901510e-02f, 8.17823857e-02f, -2.87790634e-02f, -4.60862294e-02f, 1.20418929e-02f, 9.46405679e-02f, 1.60133727e-02f, 4.13381793e-02f, -5.10890782e-02f,
  -8.68338645e-02f, 9.86030996e-02f, 2.09390000e-02f, 3.93976904e-02f, -5.08609861e-02f, 1.95694957e-02f, 7.71429855e-03f, 3.56157869e-02f, -1.87438726e-02f, 4.44315560e-03f,
  8.38976949e-02f, -5.49750812e-02f, -4.63145338e-02f, 1.02477251e-02f, -1.72273703e-02f, 4.94685657e-02f, 7.12903142e-02f, -2.22673081e-02f, 3.08447750e-03f, -6.91469610e-02f,
  1.30729694e-02f, 6.19279146e-02f, -1.60432272e-02f, -2.82301214e-02f, 1.18564088e-02f, -3.05699874e-02f, 2.61691287e-02f, -9.18789357e-02f, -1.20801413e-02f, -1.63150728e-02f,
  1.48098052e-01f, 2.40561292e-01f, -2.66394131e-02f, 2.08739452e-02f, 2.28333715e-02f, 2.51475964e-02f, 9.60044488e-02f, 6.97896117e-03f, 1.20127849e-01f, -4.32115421e-02f,
  7.27699250e-02f, -4.80639413e-02f, 1.34023979e-01f, 2.36381609e-02f, 6.61129737e-03f, -2.76350789e-02f, 1.31863430e-01f, 7.38441944e-02f, 7.47192428e-02f, 2.84626707e-02f,
  7.70198414e-03f, -7.40997568e-02f, 2.54742429e-02f, 2.33533252e-02f, 1.85884126e-02f, 1.95090682e-03f, -6.04918487e-02f, -2.86528096e-02f, 9.44775939e-02f, 1.46736801e-01f,
  3.38715702e-01f, -2.60913782e-02f, 2.84606397e-01f, 3.32584202e-01f, -1.11157417e-01f, -4.44804616e-02f, 3.23692501e-01f, -1.27544478e-01f, 3.36620718e-01f, -1.79499075e-01f,
  -2.35750511e-01f, 2.86326855e-01f, -2.52001490e-02f, -2.81005263e-01f, 4.90157157e-02f, -1.95010915e-01f, -7.32140690e-02f, 7.16266409e-02f, 8.44064541e-03f, 1.72214255e-01f,
  5.78538664e-02f, -3.21367413e-01f, 7.97790103e-03f, -2.71477818e-01f, 9.12554860e-02f, 1.36113927e-01f, -1.17415510e-01f, 7.61645958e-02f, -1.40117511e-01f, -1.38196871e-01f,
  -1.71250239e-01f, -9.98804811e-03f, 7.00898021e-02f, -2.90811323e-02f, -4.27653082e-02f, 5.32506919e-03f, 3.21298987e-02f, 4.39028442e-02f, 6.00333745e-03f, 1.71012536e-03f,
  2.34888084e-02f, 4.28925157e-02f, -7.28141665e-02f, -7.53752142e-02f, -3.70919751e-03f, -6.90382719e-02f, -4.35497761e-02f, -3.82248238e-02f, 5.23475558e-02f, 4.09747697e-02f,
  9.64280143e-02f, -5.48993722e-02f, 3.53662334e-02f, -1.36546586e-02f, 1.17052086e-01f, -6.12163506e-02f, -1.64115534e-03f, 5.36013544e-02f, -5.14040934e-03f, -7.52122775e-02f,
  1.77003052e-02f, 6.73151016e-02f, 2.55023148e-02f, -6.18602671e-02f, -3.58997583e-02f, -9.37849954e-02f, 3.88985537e-02f, -2.43373457e-02f, 1.69150438e-02f, -5.77384606e-02f,
  -4.55930792e-02f, 4.37814705e-02f, -5.51879480e-02f, -1.27662029e-02f, 1.07884360e-02f, -3.71167203e-03f, 1.76397022e-02f, 1.43989064e-02f, 7.05212951e-02f, -2.66890246e-02f,
  -1.80637632e-02f, 5.73460758e-02f, -8.41434896e-02f, 7.68041657e-03f, -1.08635560e-01f, 8.65003839e-03f, -3.76590714e-02f, -2.67934669e-02f, 2.60712281e-02f, 4.73409370e-02f,
  3.33202183e-02f, 1.69309527e-01f, -2.20244993e-02f, -3.26006413e-02f, -1.04525313e-02f, -6.12358935e-02f, 1.02226743e-02f, -4.89047617e-02f, 3.80927101e-02f, 1.54938437e-02f,
  5.12669832e-02f, 1.76260024e-02f, 3.59669775e-02f, 1.66802574e-02f, -4.99017909e-02f, -8.20346735e-03f, 4.47451472e-02f, 9.79788452e-02f, 6.15375601e-02f, -2.13381574e-02f,
  -6.28416464e-02f, 5.31215034e-02f, 2.92125065e-02f, -3.84016521e-03f, -2.96512456e-03f, 2.73807067e-02f, 9.28534716e-02f, 2.38791592e-02f, -3.88082042e-02f, 7.72285834e-02f,
  -2.35108569e-01f, 4.31295902e-01f, 2.29479223e-02f, -5.89695238e-02f, 3.75954323e-02f, 3.11515033e-01f, -4.33550440e-02f, 1.61656141e-01f, -2.27529898e-01f, 1.78447440e-01f,
  6.42905477e-03f, -2.80538332e-02f, -1.47011429e-01f, 1.82576239e-01f, 5.02348319e-02f, -2.35660702e-01f, 2.92428672e-01f, 7.57686198e-02f, -2.42428094e-01f, 9.10523310e-02f,
  -1.22094415e-01f, 2.53325731e-01f, 9.80748832e-02f, 1.38084620e-01f, 1.23426825e-01f, 6.73397165e-03f, 9.14059207e-02f, -1.30741179e-01f, 1.96020275e-01f, 8.17181319e-02f,
  9.30542424e-02f, -7.96778724e-02f, -2.77649728e-03f, -7.61923343e-02f, 1.01762779e-01f, 1.63427216e-03f, -3.24122161e-02f, -2.74889208e-02f, -3.02688330e-02f, 2.60038208e-02f,
  -6.45485148e-02f, 4.56671640e-02f, 2.02099048e-02f, 2.11005453e-02f, -4.56141718e-02f, 4.48979549e-02f, 7.29789911e-03f, 1.50772631e-01f, -9.30737611e-03f, -5.22063114e-02f,
  -8.73830467e-02f, 6.63465708e-02f, 3.48624103e-02f, 6.20863517e-04f, 2.52231024e-02f, 9.05709062e-03f, 8.05786774e-02f, -3.74737717e-02f, 7.99357705e-03f, 3.86354849e-02f,
  6.82641342e-02f, -3.96151729e-02f, -1.45567916e-02f, -2.00900920e-02f, 4.14981507e-02f, 4.20262218e-02f, -2.00936086e-02f, -1.75424665e-02f, -1.10386889e-02f, 8.03065002e-02f,
  -3.63016725e-02f, -3.44068445e-02f, 3.22728790e-02f, -3.83762717e-02f, -1.99442562e-02f, -6.30682195e-03f, -9.01056640e-03f, 1.02993108e-01f, -4.30887341e-02f, 3.56499925e-02f,
  -7.94329047e-02f, 4.05358337e-03f, 2.01531015e-02f, -4.00768369e-02f, -9.02689435e-03f, -1.50664812e-02f, 3.50280181e-02f, 2.71956958e-02f, -3.42232808e-02f, 3.28759812e-02f,
  6.85498118e-02f, 1.79757282e-01f, -6.34874478e-02f, 4.81910910e-03f, -3.27894166e-02f, 5.83659746e-02f, 1.32472552e-02f, 8.12216178e-02f, -1.73791242e-03f, 6.51940610e-03f,
  5.29623590e-03f, -8.16371106e-03f, -2.88559757e-02f, 6.78961799e-02f, 3.28341387e-02f, -3.65411527e-02f, -3.50153446e-02f, 3.05236559e-02f, 6.34727702e-02f, 7.92958215e-02f,
  7.39286616e-02f, 8.17541685e-03f, 2.05527749e-02f, -5.74499667e-02f, 3.68853807e-02f, 2.68149450e-02f, 1.12995960e-01f, -2.88151987e-02f, -1.28719490e-02f, -3.12536210e-02f,
  -3.82625848e-01f, 1.15155779e-01f, 8.39703605e-02f, -2.86414117e-01f, -2.85187393e-01f, 9.33547392e-02f, -2.38021165e-01f, -1.67530179e-02f, 8.47614706e-02f, 1.77470297e-02f,
  -1.18184738e-01f, -4.98812571e-02f, 2.58862883e-01f, -1.22313187e-01f, 9.42648128e-02f, 3.00847083e-01f, -9.00823474e-02f, -1.84432283e-01f, 1.11383870e-01f, -2.91237921e-01f,
  -4.56947684e-02f, -2.12939709e-01f, -5.53769385e-03f, 5.92133813e-02f, -2.06241623e-01f, -7.12418035e-02f, -1.09040700e-01f, 9.10030603e-02f, -1.71373576e-01f, -1.75809432e-02f,
  5.53349257e-02f, -2.88638212e-02f, -6.96316883e-02f, 8.62660352e-03f, -3.28278281e-02f, -1.03713252e-01f, -6.98262677e-02f, -1.99366291e-03f, -2.04277579e-02f, -1.60774272e-02f,
  -5.86594306e-02f, -8.53578523e-02f, -3.82253304e-02f, 2.51120254e-02f, -3.49749587e-02f, -1.07320771e-02f, 1.97770223e-02f, -1.95405632e-02f, -6.83391392e-02f, -2.27338783e-02f,
  -3.61601897e-02f, 7.11512864e-02f, 6.08869679e-02f, 4.39559296e-03f, 2.53815632e-02f, 1.94881056e-02f, -2.21356098e-02f, -7.36587420e-02f, 2.27524638e-02f, -3.22860070e-02f,
  -7.49187320e-02f, 4.35400866e-02f, -2.81476974e-02f, 8.51869583e-02f, 3.51736359e-02f, -5.11929356e-02f, 5.11866249e-02f, -5.08514754e-02f, -2.38807965e-02f, -3.47362719e-02f,
  -6.80927560e-02f, -3.49577144e-02f, -1.07630696e-02f, -5.83198927e-02f, -7.56030083e-02f, -4.62715141e-02f, -3.04734260e-02f, 3.56718246e-03f, -3.18904445e-02f, 1.97323766e-02f,
  1.40055940e-02f, 1.91150513e-02f, -2.85716932e-02f, -3.52322124e-02f, 1.06076868e-02f, 1.81971397e-02f, 3.07769496e-02f, 4.40637097e-02f, 4.67276946e-02f, -4.20913994e-02f,
  6.42559081e-02f, 1.19482353e-01f, 6.30692691e-02f, 1.02872765e-02f, 8.44523907e-02f, 3.17151174e-02f, 8.53536502e-02f, -6.79607256e-05f, -8.03702883e-03f, 6.93439394e-02f,
  -1.27163306e-01f, -2.75200140e-02f, 1.04809023e-01f, -3.27334777e-02f, 7.18704611e-02f, -3.61898765e-02f, -4.11071262e-04f, 1.29244504e-02f, 8.86921014e-04f, -4.70327847e-02f,
  -6.83866292e-02f, -1.03949994e-01f, 1.13902176e-02f, -6.09854683e-02f, -7.53990337e-02f, -4.96746488e-02f, -1.08142581e-03f, -7.12830946e-02f, 1.23755880e-01f, 1.80538222e-02f,
  -4.00581032e-01f, -9.44784209e-02f, -9.68600288e-02f, -4.77960221e-02f, -6.24513254e-02f, -3.00364971e-01f, -1.46283180e-01f, -9.73004401e-02f, -1.87681556e-01f, 9.14071575e-02f,
  1.30877420e-01f, -2.17353348e-02f, 2.23350257e-01f, -8.97566974e-02f, -2.80553084e-02f, 1.79714710e-01f, -2.65907884e-01f, -4.47640978e-02f, 2.89727910e-03f, -5.01901656e-02f,
  -1.24505393e-01f, -8.27085599e-03f, 1.40067682e-01f, -2.02997494e-02f, -2.50762463e-01f, 2.44170483e-02f, 2.58134484e-01f, 2.09572345e-01f, -5.21234684e-02f, 6.02438264e-02f,
  -1.70911774e-01f, -9.78606171e-04f, -5.35606071e-02f, -3.58783863e-02f, -5.20807281e-02f, -4.97804880e-02f, -6.88826814e-02f, 1.07032552e-01f, 5.30150570e-02f, -2.77988259e-02f,
  8.23814571e-02f, -3.47986259e-02f, -1.99480820e-02f, 5.15861250e-02f, -1.41031712e-01f, 4.17340770e-02f, -1.64881740e-02f, -4.68124971e-02f, -3.96894887e-02f, -1.87116617e-03f,
  -7.57987499e-02f, -3.84385623e-02f, -6.07272200e-02f, 2.31056344e-02f, -1.81007534e-02f, -5.66680096e-02f, 1.40986759e-02f, -1.59435291e-02f, 5.80403432e-02f, -1.08227074e-01f,
  -1.10632107e-01f, 8.58827010e-02f, 1.58573815e-03f, -3.40762809e-02f, -1.89983798e-03f, 2.54269131e-02f, 1.03651071e-02f, 3.70997265e-02f, -1.98582113e-02f, 2.54830681e-02f,
  -1.27894944e-02f, 1.19375251e-02f, 2.46160943e-02f, -4.79305238e-02f, -6.83237985e-03f, -3.32340375e-02f, 5.00364527e-02f, 5.35502210e-02f, -5.34366965e-02f, -3.05704121e-02f,
  1.51922598e-01f, -3.08822524e-02f, 6.94782659e-02f, 3.78172053e-03f, -2.02372856e-03f, 7.60828983e-03f, -1.48995151e-03f, -6.43473193e-02f, 8.48214775e-02f, 2.28066258e-02f,
  7.62142017e-02f, 1.22435175e-01f, -1.16370097e-02f, 2.96242461e-02f, 1.35101210e-02f, -2.20070537e-02f, 2.05444638e-04f, -1.69115424e-01f, 7.07794875e-02f, 2.85974964e-02f,
  -4.40601669e-02f, 4.95102331e-02f, -5.42738009e-03f, 2.73688622e-02f, -8.38544313e-03f, -4.87739891e-02f, 8.10389146e-02f, 6.43510371e-02f, 4.14070487e-02f, -2.12146640e-02f,
  7.78234079e-02f, 6.68715127e-03f, 4.63364422e-02f, -1.92711095e-03f, -3.67785953e-02f, 8.98468122e-02f, -4.37005870e-02f, -7.33912885e-02f, 1.87646411e-02f, 5.63169792e-02f,
  -4.33103204e-01f, 3.97850007e-01f, 2.26821043e-02f, -1.68934748e-01f, -1.58452332e-01f, -1.16043732e-01f, -5.26681393e-02f, -9.71313007e-03f, 4.94295582e-02f, 1.93612635e-01f,
  3.72182764e-02f, 2.70612001e-01f, 1.80535525e-01f, 1.09858327e-02f, -4.11124170e-01f, 1.15614615e-01f, -2.22301483e-01f, -5.60982036e-04f, -4.11387682e-02f, -5.32295741e-02f,
  -2.38322485e-02f, -9.16370098e-03f, -1.31449550e-01f, 1.38646781e-01f, -8.36441666e-02f, 6.34072572e-02f, -2.00207308e-01f, 1.22168399e-01f, -1.03538953e-01f, -5.07602394e-02f,
  -3.61353867e-02f, 1.61865145e-01f, 2.63265651e-02f, 3.97780724e-02f, -1.33402139e-01f, -8.01082179e-02f, -1.06286798e-02f, 1.93347260e-02f, -5.36440164e-02f, -2.99720187e-03f,
  1.50775611e-02f, 4.67864498e-02f, 8.69782269e-02f, 2.31319126e-02f, -4.67717201e-02f, -4.68550883e-02f, 2.26944201e-02f, -9.76041034e-02f, 7.37193078e-02f, -8.75016004e-02f,
  -3.28598991e-02f, -6.29035234e-02f, -8.96611884e-02f, -9.06476565e-03f, 2.55900435e-02f, 5.81582263e-02f, -7.58970063e-03f, -6.40830994e-02f, 4.21280339e-02f, -1.02320150e-01f,
  6.64666742e-02f, 2.98831314e-02f, 1.42137418e-02f, -1.97391491e-02f, 6.69550477e-03f, 2.61028744e-02f, 3.65669862e-03f, 9.90464445e-03f, 2.00339872e-02f, 2.18581781e-03f,
  9.35350358e-03f, -3.05930059e-02f, -3.21855024e-02f, -1.20593663e-02f, 1.93465464e-02f, 9.27502662e-03f, -1.29894735e-02f, 1.09413080e-01f, -7.43377283e-02f, -1.02560394e-01f,
  3.83573771e-02f, -7.08096661e-03f, 5.63163497e-03f, -4.63314876e-02f, -2.05858387e-02f, -9.17772725e-02f, 2.13591605e-02f, 3.53420042e-02f, 2.13953704e-02f, -6.03470877e-02f,
  1.27129450e-01f, 2.01035738e-01f, 8.95815119e-02f, -7.87875708e-03f, 9.41731930e-02f, -2.63088085e-02f, 2.52611507e-02f, -3.53221432e-04f, 5.69451191e-02f, -4.11722511e-02f,
  1.51785333e-02f, -4.20604125e-02f, -3.29773240e-02f, -9.35406908e-02f, -5.33466525e-02f, 4.08895947e-02f, 4.96006683e-02f, -5.80391614e-03f, -5.52821197e-02f, 2.22153030e-02f,
  2.24913959e-03f, 1.42614711e-02f, 2.90375743e-02f, 5.52247874e-02f, -1.68277062e-02f, 5.53622050e-03f, 1.23911332e-02f, 3.42140645e-02f, -3.48161743e-03f, 2.08192915e-02f,
  6.89786598e-02f, 1.97888240e-01f, 8.15970674e-02f, -1.55448705e-01f, -1.65424004e-01f, -2.78147995e-01f, -2.77529120e-01f, -2.36186367e-02f, -1.60414144e-01f, 6.76389635e-02f,
  -1.52192280e-01f, 1.14037916e-01f, 1.68197602e-01f, -1.40020102e-01f, -3.13855171e-01f, -9.14890468e-02f, -2.86177784e-01f, -2.02655956e-01f, -3.54973297e-03f, -5.13106622e-02f,
  -9.58024561e-02f, -1.71889335e-01f, -7.55415261e-02f, 3.44392657e-02f, -2.59849690e-02f, 1.87000275e-01f, 1.86594769e-01f, 2.71891385e-01f, -1.14048235e-02f, -9.83816758e-02f,
  -1.46108598e-01f, 1.16578959e-01f, 6.10258207e-02f, 6.20736852e-02f, 2.02964470e-02f, 9.76445973e-02f, 1.10506773e-01f, 1.23389699e-02f, 3.71183082e-02f, -4.13876027e-02f,
  1.59915328e-01f, 2.96330769e-02f, -7.40593299e-02f, 1.87192801e-02f, 8.92766267e-02f, 5.71191050e-02f, 1.36793442e-02f, -1.00644052e-01f, 5.40709347e-02f, 7.44003206e-02f,
  -5.23151159e-02f, -1.95725150e-02f, -7.32744634e-02f, -5.29451249e-03f, -3.79932055e-04f, 5.70469946e-02f, 3.71264033e-02f, 1.32154366e-02f, 1.29773039e-02f, -1.97630338e-02f,
  8.31150860e-02f, 4.93953303e-02f, -6.36748895e-02f, 9.45098698e-02f, -3.93232815e-02f, -1.81183666e-02f, -2.26608794e-02f, 3.87952700e-02f, 8.17982852e-02f, 4.51439666e-03f,
  -1.01237319e-01f, 1.22855222e-02f, 2.38608569e-02f, -2.93478612e-02f, -1.12437177e-02f, 4.52342555e-02f, 2.87229288e-02f, 4.51636128e-02f, -6.22042529e-02f, -4.20376733e-02f,
  1.10429369e-01f, -5.41206412e-02f, -3.77903730e-02f, 1.42387882e-01f, 5.86567586e-03f, -1.04472831e-01f, 2.02624239e-02f, 7.21909897e-03f, -1.79533400e-02f, -9.69269313e-03f,
  -9.07622501e-02f, 6.95928186e-02f, -1.04975387e-01f, -1.55674024e-02f, -5.77620864e-02f, -1.12168223e-01f, -3.84415686e-02f, -1.41229928e-01f, 1.62058073e-04f, -2.76929066e-02f,
  -1.33550400e-02f, 7.34871253e-02f, -5.11967018e-02f, 2.27397168e-03f, -9.01671797e-02f, -1.14843376e-01f, 9.09620523e-02f, 2.61884890e-02f, 9.30103473e-03f, -2.45354660e-02f,
  3.06452289e-02f, 4.03425172e-02f, 2.02076882e-02f, -6.06603064e-02f, -4.63622212e-02f, -1.22147091e-02f, -4.70043533e-02f, 7.06154406e-02f, 1.05792373e-01f, -6.57005906e-02f,
  -1.87662750e-01f, 1.49466053e-01f, -4.91202101e-02f, -1.67078927e-01f, 4.33252491e-02f, 2.31341958e-01f, 3.03365022e-01f, -7.54354447e-02f, -3.23331170e-02f, 1.21634655e-01f,
  1.61381394e-01f, -2.97407418e-01f, 4.16858703e-01f, -7.69544169e-02f, 4.83765267e-02f, 3.63814414e-01f, -4.64438386e-02f, -5.53913005e-02f, -2.98624560e-02f, -6.62004873e-02f,
  -1.55695647e-01f, -5.38755096e-02f, -1.63115840e-02f, -1.40824065e-01f, 1.07581215e-02f, -1.93164885e-01f, -1.54899180e-01f, 3.35461870e-02f, -1.66254357e-01f, -4.22801077e-02f,
  6.90230578e-02f, -1.42261475e-01f, 4.92484905e-02f, -4.77223359e-02f, 6.36635534e-03f, 2.75162328e-03f, -4.25998047e-02f, -2.85433838e-04f, -9.69772227e-03f, -8.99781566e-03f,
  -1.85378231e-02f, -1.46505252e-01f, -3.18705104e-02f, 4.59853783e-02f, -3.10742594e-02f, -9.64737758e-02f, -3.82635510e-03f, -6.44770712e-02f, 1.44863669e-02f, 1.56145534e-02f,
  3.72460112e-02f, 2.70494483e-02f, -1.20752479e-03f, -4.39611822e-02f, -2.94085708e-03f, 1.44965714e-02f, -6.92221522e-02f, 8.33726525e-02f, -1.80342179e-02f, -7.64690386e-03f,
  -2.79457178e-02f, 7.56198019e-02f, 6.80497438e-02f, 7.84889981e-02f, 1.37305604e-02f, -2.12620180e-02f, -4.38147457e-03f, 1.89062729e-02f, -6.16970919e-02f, 4.27752100e-02f,
  -5.35158366e-02f, -5.51061854e-02f, -9.42582339e-02f, -2.80385115e-03f, -9.90992635e-02f, -7.58357719e-02f, -2.74127722e-02f, -1.02562569e-02f, 5.30362874e-02f, 2.12998930e-02f,
  -3.81185450e-02f, 5.51071987e-02f, 1.98260807e-02f, 4.85380962e-02f, 1.67908847e-01f, 2.22900771e-02f, -2.43297406e-02f, 2.18178146e-04f, 5.76181635e-02f, 2.73223617e-03f,
  6.95913732e-02f, -9.80719179e-02f, 4.24390174e-02f, -1.90046262e-02f, -3.34231332e-02f, -3.32981534e-02f, 3.95840127e-03f, -1.64552685e-02f, 6.22702725e-02f, -4.38786997e-03f,
  3.19780856e-02f, -1.10724196e-02f, -1.33556411e-01f, -3.11747622e-02f, -4.45588455e-02f, 7.00011328e-02f, 3.64552289e-02f, -6.52579591e-02f, -9.24132094e-02f, -8.37981924e-02f,
  -7.35167786e-02f, 1.44165074e-02f, -4.69698720e-02f, 1.02301382e-01f, -9.00529101e-02f, 2.54961313e-03f, 2.80720717e-03f, -5.27565852e-02f, -8.44405033e-03f, -3.79664935e-02f,
  -3.17732036e-01f, 4.52538207e-02f, -1.71619654e-01f, -6.31350204e-02f, -8.40577558e-02f, 2.56817877e-01f, -2.28025824e-01f, 3.47930901e-02f, -8.72623846e-02f, 2.24578738e-01f,
  2.40757149e-02f, -2.87408292e-01f, -1.20424569e-01f, 1.94394186e-01f, 1.76660687e-01f, 1.73184499e-01f, 3.04240376e-01f, 4.42117825e-02f, -5.39388023e-02f, -2.60052364e-02f,
  -9.46789142e-03f, 1.83554769e-01f, -1.99355539e-02f, 2.49958470e-01f, -2.09738478e-01f, -5.26654050e-02f, 8.62556696e-02f, -1.61289647e-01f, 2.63992757e-01f, -7.55832391e-03f,
  1.75926555e-02f, -1.34351775e-01f, -5.30433580e-02f, 6.89331740e-02f, 8.56077820e-02f, 2.59000938e-02f, -5.65575436e-02f, -1.06207401e-01f, -1.37392417e-01f, 3.10017299e-02f,
  -6.57891482e-02f, 2.82151625e-02f, 1.10205270e-01f, 3.93768474e-02f, -1.01174518e-01f, 9.30021610e-03f, -3.31162624e-02f, -2.57336199e-02f, -7.92475268e-02f, -5.66964187e-02f,
  -6.08962476e-02f, 8.47392455e-02f, 1.06996214e-02f, 4.86120507e-02f, -1.10148326e-01f, -5.95925488e-02f, 5.45386737e-03f, -7.79078081e-02f, 7.42312446e-02f, 2.66331574e-03f,
  4.61536869e-02f, 6.27823323e-02f, -7.61282369e-02f, 7.38130370e-03f, -5.98368794e-02f, 2.08423939e-02f, -6.28028214e-02f, -1.53222615e-02f, -1.19939178e-01f, -6.34618243e-03f,
  7.13414848e-02f, 1.03126159e-02f, -5.38199916e-02f, 5.64304702e-02f, 5.53953536e-02f, -4.47946554e-03f, -7.06405640e-02f, 5.31784184e-02f, 7.87861925e-03f, -4.80841361e-02f,
  2.10524611e-02f, 1.52699091e-02f, -4.27512825e-02f, 2.70277970e-02f, 2.10547186e-02f, -2.43452508e-02f, -9.57754266e-04f, -5.86861819e-02f, -7.99858794e-02f, -2.63841674e-02f,
  1.80991009e-01f, 1.88751936e-01f, -1.83576066e-02f, 3.37121151e-02f, 3.95556204e-02f, -5.27471490e-02f, 6.72339946e-02f, 5.89543544e-02f, 1.81289781e-02f, 3.16237025e-02f,
  7.08635151e-02f, -4.07545008e-02f, 7.92820379e-02f, 3.75237752e-04f, 8.79577547e-02f, 4.30138223e-02f, 7.87216499e-02f, 9.51609090e-02f, 1.95588320e-02f, 2.97188926e-02f,
  1.22602256e-02f, -4.28415053e-02f, -2.69750878e-03f, -2.69767996e-02f, 1.03638031e-01f, -1.21104969e-02f, -6.67164624e-02f, 7.24035352e-02f, 6.73439773e-03f, 1.18611373e-01f,
  -1.95984170e-01f, 1.56213418e-01f, 2.34096169e-01f, -1.78245343e-02f, -1.76894829e-01f, -4.54630852e-02f, 3.23635340e-01f, -1.63303301e-01f, 2.13121146e-01f, 1.30953833e-01f,
  -1.99165091e-01f, 3.30550641e-01f, 2.83587605e-01f, -2.23002344e-01f, -8.42350498e-02f, 1.29997522e-01f, -2.16465309e-01f, 1.43201044e-02f, -2.90119927e-02f, -1.95386693e-01f,
  -1.15739815e-01f, -2.65827805e-01f, -1.10341214e-01f, -2.15090424e-01f, -2.93098629e-01f, -6.60180897e-02f, -2.38004506e-01f, 1.54139891e-01f, -1.60734579e-01f, -9.43244770e-02f,
  6.45009726e-02f, -6.86692016e-04f, 6.93947524e-02f, 1.21469267e-01f, -1.28733754e-01f, -4.01163585e-02f, 6.87597394e-02f, 1.11340128e-01f, 1.03229128e-01f, 4.44150120e-02f,
  1.04958333e-01f, 6.97516650e-02f, 1.79724284e-02f, 4.00638692e-02f, -8.42191279e-02f, 7.02989176e-02f, -1.09728433e-01f, -4.98454571e-02f, 6.73528761e-02f, -6.73614442e-02f,
  7.36899767e-03f, -2.56560203e-02f, -3.14993374e-02f, 3.50110941e-02f, -4.29323018e-02f, -2.86739711e-02f, 8.20182711e-02f, 9.48291197e-02f, -9.08091106e-03f, 8.48523062e-03f,
  -8.44293907e-02f, -1.57416444e-02f, 2.65776156e-03f, -5.23723252e-02f, 1.01079587e-02f, -1.67445261e-02f, 8.56948178e-03f, -5.53370528e-02f, 2.44222069e-03f, -4.02054377e-02f,
  -3.05559672e-03f, -1.16062704e-02f, 2.27305926e-02f, -3.55125293e-02f, -9.63234250e-03f, -5.94369210e-02f, 4.09969687e-02f, -1.12120174e-02f, 2.09147925e-03f, 4.12527733e-02f,
  9.46251824e-02f, 2.00771727e-02f, 1.50818508e-02f, 1.21963387e-02f, 1.22283902e-02f, -1.91005562e-02f, -4.20374982e-02f, -5.66549646e-03f, 2.15065479e-02f, -5.97188547e-02f,
  -5.44990748e-02f, -1.20262720e-01f, 9.59785953e-02f, 8.39639306e-02f, 7.48391673e-02f, -1.01113975e-01f, 4.07380871e-02f, -9.77242962e-02f, 1.51661197e-02f, -1.72647480e-02f,
  -9.30364579e-02f, -1.36697032e-02f, -1.01127759e-01f, -4.47846465e-02f, 4.48050164e-02f, -5.75177856e-02f, 8.05491135e-02f, 7.34380484e-02f, -1.06259054e-02f, 7.31706200e-03f,
  -4.23227847e-02f, -6.93571614e-03f, -3.82357347e-03f, -7.67787248e-02f, -7.03507662e-02f, 1.58945955e-02f, -8.79060663e-03f, 7.67029598e-02f, -1.13220990e-01f, 7.63424039e-02f,
  -1.25184190e-02f, 6.54628919e-03f, 1.07387774e-01f, -1.31861970e-01f, 2.51338452e-01f, 1.82451293e-01f, 6.19663969e-02f, 1.25510752e-01f, -1.26838684e-01f, -1.13174501e-04f,
  -1.89328134e-01f, -1.01431563e-01f, -1.73581570e-01f, -1.97525054e-01f, -3.11538309e-01f, -2.96831578e-01f, -2.63518184e-01f, -1.80012450e-01f, -1.82273388e-01f, 8.39486271e-02f,
  -4.74574938e-02f, -1.54745113e-02f, 3.05271819e-02f, 2.35266089e-01f, 3.52951974e-01f, 2.41672590e-01f, -5.74103445e-02f, 1.82011172e-01f, 1.29241437e-01f, -4.11203541e-02f,
  -4.43547107e-02f, -8.90149400e-02f, 7.52735063e-02f, -2.37472206e-02f, 9.89599973e-02f, 6.09606430e-02f, -3.14114466e-02f, -1.22983428e-02f, 7.17825815e-02f, 5.92552796e-02f,
  5.86197600e-02f, 8.65081176e-02f, 4.22012433e-02f, 4.92719896e-02f, 6.85260519e-02f, 6.05778843e-02f, 3.80893573e-02f, 2.34704949e-02f, 2.31374409e-02f, -3.92029807e-02f,
  7.92570859e-02f, -2.88457964e-02f, -2.21767891e-02f, -2.16597933e-02f, -1.16353435e-02f, -1.47875939e-02f, 2.18058634e-03f, 1.29931480e-01f, 2.15362199e-02f, 3.77525613e-02f,
  4.60058227e-02f, -5.36534823e-02f, -4.58741933e-02f, -4.75447848e-02f, -1.00029893e-01f, 1.21429386e-02f, -1.19998910e-01f, 8.39731768e-02f, 3.45545709e-02f, 3.98403183e-02f,
  1.98713467e-02f, 3.68715189e-02f, -5.75573035e-02f, 1.05114616e-01f, -3.21756490e-03f, -1.91682950e-02f, -3.96880973e-03f, 1.62072317e-03f, 8.81770328e-02f, -1.42667377e-02f,
  -4.04578596e-02f, -4.76455912e-02f, 7.53399450e-03f, 6.37827069e-02f, -1.17064461e-01f, 1.35926917e-01f, 4.37381603e-02f, 5.67899458e-02f, -6.01726212e-02f, 6.89183250e-02f,
  -1.60840362e-01f, -1.01163355e-03f, 5.35981953e-02f, 4.02532443e-02f, -1.44940406e-01f, -1.04326390e-01f, -9.38143730e-02f, 3.77578028e-02f, 4.90757339e-02f, -9.46327299e-02f,
  1.23670630e-01f, 3.61490473e-02f, -5.63191250e-02f, -5.30492030e-02f, -2.21427046e-02f, -5.63168935e-02f, -6.08514175e-02f, -1.44620519e-02f, 6.72484795e-03f, 2.48935726e-02f,
  2.23124195e-02f, 1.51573777e-01f, 1.87344477e-02f, 8.08268487e-02f, 1.03858627e-01f, 4.46058325e-02f, -3.35948765e-02f, 5.58445118e-02f, -2.82990339e-04f, -6.43584691e-03f,
  -4.34324354e-01f, 1.41727403e-01f, -1.42606914e-01f, -4.34038728e-01f, 1.47270367e-01f, -1.91820025e-01f, -2.26886958e-01f, 1.23732023e-01f, -2.82585829e-01f, 2.14240238e-01f,
  -4.35464308e-02f, -2.11178958e-01f, 9.43926200e-02f, -2.29601771e-01f, -3.53771955e-01f, -4.20818366e-02f, -3.48545700e-01f, -1.55716330e-01f, 3.65045555e-02f, -1.52128145e-01f,
  -1.86848670e-01f, 5.93539625e-02f, -8.29092562e-02f, 3.50077868e-01f, 3.50423879e-03f, 4.32443917e-02f, 1.23326838e-01f, 2.07843482e-01f, -6.97433129e-02f, 1.63460895e-01f,
  5.07663600e-02f, 1.68733168e-02f, -5.61081152e-03f, 3.37366685e-02f, -3.66658531e-02f, 5.36713451e-02f, -5.80020361e-02f, 6.59155399e-02f, -9.28465128e-02f, -3.22757065e-02f,
  2.90294886e-02f, -2.64485199e-02f, 1.39352251e-02f, 1.34549262e-02f, 9.68583208e-03f, -1.86529383e-02f, -7.10565923e-03f, -4.18826453e-02f, 4.89126779e-02f, -5.98041601e-02f,
  -5.21579459e-02f, -3.50448042e-02f, -1.07808933e-01f, 1.20023573e-02f, -9.53058824e-02f, -6.90550283e-02f, 3.08279879e-02f, -1.85216945e-02f, 4.39296430e-03f, 3.62825813e-03f,
  -2.51335949e-02f, 2.30417326e-02f, 9.19876620e-03f, 7.24201202e-02f, -2.71818563e-02f, -3.45934965e-02f, 2.41315905e-02f, -1.20979091e-02f, -1.24195535e-02f, -1.82783157e-02f,
  -7.46194497e-02f, -1.63662229e-02f, 2.75045708e-02f, -1.20700337e-02f, -1.78030245e-02f, 1.57217365e-02f, -3.00109740e-02f, -2.98342332e-02f, -7.09936395e-02f, -5.66762276e-02f,
  1.00473732e-01f, -6.31206706e-02f, 2.25207116e-02f, -4.15440276e-03f, -2.00613067e-02f, 4.00293171e-02f, -3.63010052e-03f, 1.45957470e-02f, 5.25417849e-02f, -4.49462868e-02f,
  -9.27115530e-02f, -1.41575053e-01f, 6.15599845e-03f, 1.63672511e-02f, -1.20574310e-02f, -2.02002916e-02f, -5.70844784e-02f, -1.27518224e-02f, 9.42052752e-02f, 9.94575908e-04f,
  -9.59532559e-02f, -2.89368648e-02f, -4.36122343e-02f, -2.88598668e-02f, -1.33416709e-02f, 7.04133660e-02f, -9.01612341e-02f, 1.45640755e-02f, -1.65497903e-02f, -2.88955327e-02f,
  -1.02697909e-02f, -8.87004510e-02f, 6.10320792e-02f, 5.00135683e-02f, 1.00609306e-02f, -3.35899778e-02f, -7.85863325e-02f, 9.92183834e-02f, -5.36849983e-02f, 1.30593348e-02f,
  1.05946653e-01f, -9.57597643e-02f, 5.36379665e-02f, 7.75096267e-02f, 1.78852737e-01f, -2.07054719e-01f, -3.21320087e-01f, -4.22827974e-02f, 1.24334797e-01f, -2.33833835e-01f,
  -1.44275397e-01f, 3.16730082e-01f, -2.66511708e-01f, 2.19264030e-01f, -1.26779303e-01f, -6.64846078e-02f, -1.65301427e-01f, 3.15361917e-02f, 1.07132010e-01f, -1.69515863e-01f,
  7.43164644e-02f, 7.67180994e-02f, 1.52013212e-01f, 9.83284712e-02f, 1.54926032e-01f, 1.51076093e-01f, -2.03645229e-01f, 9.54120606e-02f, 1.58236340e-01f, 9.61986184e-02f,
  -4.32407632e-02f, -3.23739499e-02f, 1.00585476e-01f, 7.06745610e-02f, 3.86977056e-03f, 1.93600189e-02f, -8.00453052e-02f, 7.63799772e-02f, 6.32421747e-02f, -6.95827883e-03f,
  1.19353505e-02f, 2.75510121e-02f, 4.53822128e-02f, -5.58493510e-02f, -1.26667134e-02f, 1.17316067e-01f, 8.19204226e-02f, 1.68427173e-02f, 1.31253168e-01f, 1.36552453e-01f,
  2.96535771e-02f, 3.16013508e-02f, 1.38920620e-02f, -3.55236195e-02f, 3.30741927e-02f, -2.00101752e-02f, 1.38119742e-01f, -2.87937690e-02f, -1.55488728e-02f, 1.43103325e-03f,
  1.77517757e-02f, 4.21806350e-02f, 7.86349624e-02f, 3.34397145e-02f, -2.37478185e-02f, 5.41390851e-02f, -3.67712677e-02f, 9.83048528e-02f, 8.36836174e-02f, -3.58186215e-02f,
  -5.54754958e-02f, 8.05606693e-02f, -4.59244512e-02f, -1.71004739e-02f, -1.59067381e-02f, -1.20135751e-02f, -4.70234826e-02f, 3.54182683e-02f, 4.79569798e-03f, 3.13615128e-02f,
  6.45114705e-02f, -3.23481299e-02f, -4.34729736e-03f, 6.99814186e-02f, -1.08365595e-01f, -1.67986915e-01f, 1.16708264e-01f, -2.78798416e-02f, -1.36381194e-01f, -1.11730516e-01f,
  -2.03231245e-01f, -3.16378236e-01f, 4.87800539e-02f, -1.07466467e-02f, -6.03199936e-02f, -3.59014012e-02f, 1.44793004e-01f, 9.49132591e-02f, -1.55710056e-01f, -6.95561394e-02f,
  -3.18944152e-03f, 8.62972438e-03f, -3.83065864e-02f, 1.71200205e-02f, -1.69223372e-03f, -6.91705123e-02f, -4.14619781e-02f, 4.40227939e-03f, -8.96701738e-02f, -4.57087122e-02f,
  -1.07075900e-01f, -7.22051552e-03f, 6.60325438e-02f, 2.12431457e-02f, 8.26212689e-02f, -1.51175022e-01f, 7.05672130e-02f, 6.35005757e-02f, -1.16581498e-02f, 3.57959308e-02f,
  -7.73160085e-02f, 1.59865290e-01f, 5.13557941e-02f, -1.52362376e-01f, -1.13200936e-02f, 1.12251729e-01f, -2.20196545e-01f, 4.89086509e-02f, 1.39734775e-01f, -3.18901449e-01f,
  -3.02579492e-01f, -8.09002817e-02f, -2.37939566e-01f, -9.55225527e-02f, 4.50022727e-01f, 1.00636728e-01f, 6.82946965e-02f, -1.69173926e-02f, 2.30864659e-01f, -2.15661913e-01f,
  7.73881227e-02f, -1.28909975e-01f, -1.14192605e-01f, 1.05956785e-01f, -1.04987450e-01f, -7.32597113e-02f, -7.54412711e-02f, 6.46652281e-02f, -6.34793490e-02f, 1.79799020e-01f,
  4.87925522e-02f, 6.09062277e-02f, 1.53597742e-02f, 5.31122983e-02f, -4.45588864e-02f, -1.03352457e-01f, -5.97438850e-02f, -6.12685271e-02f, -3.36968638e-02f, -1.42893940e-02f,
  -2.33931094e-02f, -2.83108149e-02f, 1.02580555e-01f, 1.26147151e-01f, -6.89865574e-02f, -6.65130839e-02f, 5.55836037e-02f, -9.63989347e-02f, 7.71352127e-02f, -3.67863327e-02f,
  -6.20874427e-02f, -9.73505750e-02f, -7.54417181e-02f, 9.99265350e-03f, 6.44819811e-02f, 6.69550225e-02f, -2.28949580e-02f, -1.04457773e-01f, 9.93555263e-02f, 4.41820920e-02f,
  1.48974657e-01f, -1.85744949e-02f, -1.94469746e-02f, -1.39205486e-01f, 8.24119970e-02f, 3.21822539e-02f, 1.18258242e-02f, -2.10508350e-02f, 2.67148986e-02f, -5.95472418e-02f,
  -5.75542934e-02f, 2.30961759e-02f, 1.28548175e-01f, -5.58242984e-02f, -3.79282758e-02f, 2.87471432e-02f, 5.17882630e-02f, 1.64679915e-03f, -4.64199930e-02f, -3.53456363e-02f,
  8.88117701e-02f, 1.07495658e-01f, -1.07821897e-01f, -1.19801112e-01f, 9.47770178e-02f, -2.01324355e-02f, -2.17552874e-02f, 7.39677101e-02f, -2.51541939e-02f, 4.77366634e-02f,
  -1.55597953e-02f, 9.54503864e-02f, 4.04074155e-02f, -6.76793307e-02f, 1.13551676e-01f, 2.40801498e-02f, 1.24542907e-01f, 1.18720837e-01f, 6.44663647e-02f, -5.07199392e-02f,
  -1.02722585e-01f, -1.02156602e-01f, -1.71141550e-02f, 6.67627007e-02f, 8.52100253e-02f, -5.11546759e-03f, -9.50916205e-03f, -2.56499145e-02f, 1.91081539e-02f, -3.40159833e-02f,
  -8.38271827e-02f, -1.14745982e-01f, 3.00686490e-02f, -4.40572388e-02f, -7.83826187e-02f, -5.67307658e-02f, 8.38956609e-02f, 5.38059771e-02f, 1.20671997e-02f, -4.79759537e-02f,
  1.81533694e-01f, -2.99699302e-03f, -2.77265847e-01f, 2.52559096e-01f, 7.44265243e-02f, -1.81975350e-01f, -1.29676685e-01f, 1.86859474e-01f, -1.23359494e-01f, 1.65633336e-01f,
  1.70029759e-01f, -7.48552266e-04f, -2.94654727e-01f, 2.87111074e-01f, -2.49077186e-01f, -2.47997358e-01f, 1.05336107e-01f, 1.66009352e-01f, -1.15744703e-01f, 1.16345659e-01f,
  7.95862302e-02f, 1.80361673e-01f, 1.43550653e-02f, 1.16238289e-01f, 2.57871062e-01f, 5.97437397e-02f, 2.46234789e-01f, -7.99274296e-02f, 2.10713208e-01f, 2.03532279e-02f,
  -8.39481130e-02f, 1.33059248e-01f, 2.46546902e-02f, -4.37871926e-02f, 2.22448371e-02f, 5.95504455e-02f, 3.73049104e-03f, 1.47847878e-03f, -6.40740991e-02f, 8.78377445e-03f,
  -2.04769038e-02f, 1.58540625e-02f, 1.98358716e-03f, -3.70353088e-02f, 4.16595303e-02f, -1.73350275e-02f, -6.61653727e-02f, -6.24715611e-02f, 3.86094041e-02f, 1.35634290e-02f,
  -3.31253931e-02f, 8.55219811e-02f, 5.69385551e-02f, 3.36678699e-02f, -3.72884572e-02f, -7.74689168e-02f, 1.79975536e-02f, 2.21727639e-02f, 4.45081107e-02f, 2.77525745e-02f,
  3.49551402e-02f, 1.89089812e-02f, 5.50547987e-02f, 1.87227374e-03f, -8.89007002e-02f, -6.09352859e-03f, -1.41903879e-02f, 1.66033972e-02f, -7.00094551e-02f, 2.07168385e-02f,
  1.48155140e-02f, 5.40124737e-02f, 5.29043823e-02f, 2.54337881e-02f, 8.16601738e-02f, 7.30526121e-03f, -6.02542609e-02f, 2.56423615e-02f, -3.14425081e-02f, -7.48068243e-02f,
  7.13323429e-02f, -5.75638041e-02f, -9.88121517e-03f, 1.23786554e-01f, 1.23456931e-02f, -7.89272040e-02f, 8.77453089e-02f, -1.56989265e-02f, -2.15279404e-02f, -6.34044176e-04f,
  5.47433309e-02f, 1.91396579e-01f, -5.68008497e-02f, -9.83493961e-03f, -9.67624038e-02f, -1.53342318e-02f, -5.76410443e-02f, -3.14634368e-02f, -6.08478971e-02f, 2.62123737e-02f,
  9.13874581e-02f, 9.16663483e-02f, 1.16590634e-01f, -9.21474025e-03f, 2.25804653e-02f, -5.65209351e-02f, 5.58424294e-02f, -2.33034194e-02f, 6.01381846e-02f, 6.91832602e-02f,
  1.11921534e-01f, -3.14778686e-02f, 1.01857949e-02f, 3.02492455e-02f, 6.76004067e-02f, 3.05541325e-02f, -1.02850944e-02f, -7.90023059e-02f, 1.07622832e-01f, 3.80214304e-03f,
  2.51270771e-01f, 3.91338393e-02f, -2.07923800e-02f, -1.18323497e-01f, 4.10276949e-02f, -4.21579838e-01f, -2.90941030e-01f, -7.94984698e-02f, 8.71119276e-03f, 3.40138003e-02f,
  -3.21207911e-01f, 3.42365429e-02f, -1.90193638e-01f, -3.39336276e-01f, -3.71614575e-01f, -3.31369698e-01f, -2.65665144e-01f, -2.18658194e-01f, 4.81096208e-02f, 8.05158075e-03f,
  -1.08772449e-01f, -8.33647624e-02f, -1.30038738e-01f, 1.61049202e-01f, 9.08043534e-02f, 2.25885838e-01f, 1.24768645e-01f, 1.37439072e-01f, -9.21447501e-02f, 3.31898667e-02f,
  5.53979911e-02f, 1.29967377e-01f, -2.07977816e-02f, 5.76514117e-02f, 4.18394106e-03f, 8.67061391e-02f, -1.42721913e-03f, 9.62891504e-02f, -1.44229848e-02f, -2.31135897e-02f,
  1.12915924e-02f, -3.52586769e-02f, 6.06122753e-03f, 2.91090589e-02f, 1.06858676e-02f, 7.87943080e-02f, -6.91115484e-02f, -9.28447917e-02f, -3.23220342e-02f, 1.78213662e-03f,
  -1.58013284e-01f, -8.79295990e-02f, -1.56162694e-01f, -5.98946065e-02f, 1.04068639e-02f, -5.96885085e-02f, -9.08693448e-02f, 9.01863258e-03f, -4.88365581e-03f, 2.24505775e-02f,
  3.81454220e-03f, 3.18579227e-02f, -1.72697566e-02f, 5.36471605e-02f, -3.48761454e-02f, 7.56393000e-02f, -5.18779084e-02f, 7.14768171e-02f, 1.00948811e-01f, -2.14618035e-02f,
  -7.04997480e-02f, 1.27379466e-02f, 7.75179407e-03f, -2.68676337e-02f, 2.94903778e-02f, 3.03522404e-02f, 2.43169758e-02f, 5.99936396e-02f, -5.65950526e-03f, -1.75918825e-02f,
  -5.91575308e-03f, -6.71837181e-02f, -6.00032741e-04f, 4.23499085e-02f, -1.11862838e-01f, 4.28013057e-02f, -2.94618066e-02f, -5.01721539e-02f, -9.54573229e-03f, -5.15040345e-02f,
  -7.21308663e-02f, 2.05123262e-03f, 1.60618667e-02f, 1.27464514e-02f, 3.01795267e-02f, 1.70248207e-02f, -2.65266914e-02f, 1.60994604e-02f, 6.73468933e-02f, 3.22523080e-02f,
  7.14405105e-02f, 5.26773557e-02f, 6.75579160e-03f, 2.47348435e-02f, -3.11077144e-02f, -9.88832042e-02f, -5.15538044e-02f, 6.70484975e-02f, -8.14590305e-02f, 2.36069318e-02f,
  3.77146527e-02f, 4.34379391e-02f, 5.12394980e-02f, 8.85748714e-02f, 1.40411332e-02f, -6.53683096e-02f, 1.12093531e-01f, 3.91734019e-02f, 9.82502196e-03f, -1.00978389e-02f,
  3.78625482e-01f, -1.37615934e-01f, -5.43169724e-03f, 2.75883883e-01f, 1.01061352e-02f, 1.25343591e-01f, 1.59269780e-01f, 7.12556317e-02f, 1.14740290e-01f, -2.55549729e-01f,
  1.99088901e-02f, 4.05920930e-02f, -2.79982120e-01f, 2.00371370e-01f, 3.54272038e-01f, -1.99120909e-01f, 1.69256568e-01f, 1.20856784e-01f, -1.44856900e-01f, 1.21896192e-01f,
  1.93546027e-01f, 2.00024217e-01f, 3.85608450e-02f, -6.86094388e-02f, 8.17754492e-02f, 8.22452083e-02f, -6.74270317e-02f, -1.33598387e-01f, 2.17524052e-01f, -7.94362091e-03f,
  2.18879163e-01f, 8.75449255e-02f, -5.47489244e-03f, -8.45577866e-02f, 7.34100789e-02f, -3.85613404e-02f, -4.27874736e-03f, -7.72981197e-02f, -9.77298766e-02f, -6.87916651e-02f,
  -7.01425299e-02f, 3.28185372e-02f, 4.40853685e-02f, -1.16357937e-01f, 2.35849675e-02f, -4.33428250e-02f, -4.96545695e-02f, -1.05624916e-02f, -4.79594767e-02f, -1.25517771e-02f,
  4.44527380e-02f, 2.20573489e-02f, 4.24649008e-02f, -1.45581439e-02f, -5.88093437e-02f, 3.59279773e-04f, 2.99523193e-02f, 1.06676035e-02f, 1.05491273e-01f, 6.16215169e-02f,
  -9.85121876e-02f, -2.66889259e-02f, -4.48288359e-02f, 4.49299291e-02f, 3.93976681e-02f, 7.77684674e-02f, 7.14632636e-03f, 1.66020300e-02f, -2.61114351e-03f, 3.58804390e-02f,
  7.99046531e-02f, 6.21499829e-02f, 6.33835094e-03f, -2.74279863e-02f, -1.78519804e-02f, 1.88252628e-02f, -2.76456550e-02f, 5.18903807e-02f, 4.18226495e-02f, 1.42451609e-02f,
  -5.67869097e-02f, 2.57254373e-02f, 7.26275593e-02f, -2.24555582e-02f, -4.33796309e-02f, 6.70858484e-04f, -5.83551824e-02f, -2.37536710e-02f, -5.90261780e-02f, 3.77148613e-02f,
  6.61543384e-02f, 2.25634813e-01f, -9.36891660e-02f, 7.34357610e-02f, -1.38706183e-02f, 5.02159167e-03f, -2.70325341e-03f, -5.08608185e-02f, 2.77381744e-02f, 4.83657084e-02f,
  -1.21179469e-01f, 1.70019139e-02f, 6.97435886e-02f, -2.61507020e-03f, -2.43100128e-03f, 6.17963932e-02f, 5.43045029e-02f, 2.18108781e-02f, 8.50146636e-02f, 6.20949194e-02f,
  -2.82212272e-02f, -1.79522741e-03f, -3.95621210e-02f, -3.96435633e-02f, -2.12515499e-02f, 3.24917771e-02f, 1.29942924e-01f, -4.65542488e-02f, -5.13977148e-02f, -1.11123342e-02f,
  1.40749186e-01f, -2.42426857e-01f, 3.14294040e-01f, 2.39567548e-01f, 9.31927282e-03f, -2.42196515e-01f, 6.92296177e-02f, 3.02155176e-03f, 1.57822996e-01f, -3.32903475e-01f,
  -6.64260089e-02f, 2.40803182e-01f, 2.88776439e-02f, -1.49045542e-01f, -1.17632426e-01f, -1.41780421e-01f, -1.98352978e-01f, -1.08538806e-01f, 1.49433792e-01f, 2.74597984e-02f,
  4.57075760e-02f, -1.42915785e-01f, 3.32350619e-02f, -7.70840123e-02f, 4.73374836e-02f, 2.03017026e-01f, -1.54886499e-01f, 8.71334001e-02f, -1.46482870e-01f, 6.18355861e-03f,
  -1.74704373e-01f, 1.79174557e-01f, -1.30233550e-02f, 9.00380760e-02f, -1.07534140e-01f, -1.34034827e-01f, 6.25386164e-02f, 1.06578939e-01f, 7.92783722e-02f, 6.30587116e-02f,
  5.70686609e-02f, -5.37898205e-02f, 4.17937897e-02f, 1.27034606e-02f, -2.09654309e-03f, 5.36689125e-02f, -4.37534899e-02f, 3.38484123e-02f, 1.01742364e-01f, -1.05766300e-02f,
  1.84308328e-02f, 3.31026246e-03f, -2.38448307e-02f, 4.10249308e-02f, 9.60013419e-02f, 8.79611298e-02f, 8.04819316e-02f, 2.39177002e-03f, -2.13268586e-02f, -8.14271271e-02f,
  1.00948080e-01f, -8.14610198e-02f, 7.13662878e-02f, -3.61517034e-02f, 8.68847743e-02f, 4.46192026e-02f, -2.59193275e-02f, 3.28537486e-02f, 8.84663220e-03f, 5.88854551e-02f,
  -1.17029674e-01f, 1.77963276e-03f, 5.66522256e-02f, -2.42524520e-02f, 4.05576974e-02f, 2.36961097e-02f, 5.27512692e-02f, -4.48648445e-02f, -6.94868192e-02f, 3.44697647e-02f,
  -1.79349575e-02f, -2.79743932e-02f, -4.49029319e-02f, -4.37836237e-02f, 1.45427007e-02f, 1.12508135e-02f, -1.65549517e-02f, 9.39452499e-02f, 1.10428132e-01f, -1.67492777e-02f,
  -2.42331147e-01f, -3.21650296e-01f, -1.05850630e-01f, -4.50676642e-02f, -5.98825961e-02f, -5.34124114e-02f, 1.61638632e-02f, -2.54174583e-02f, -2.15696953e-02f, 1.47324689e-02f,
  -2.23917551e-02f, 1.29902204e-02f, -6.08004332e-02f, -4.56407014e-03f, -2.15662573e-03f, -4.97956295e-03f, -3.02583966e-02f, -1.17204562e-01f, -9.26638767e-02f, -8.52516294e-02f,
  -6.51650354e-02f, 4.47828956e-02f, 6.81346059e-02f, -8.05694088e-02f, -4.52671945e-02f, -8.23671743e-02f, 1.47791877e-02f, 6.65373504e-02f, 4.14048042e-03f, -6.69702217e-02f,
  -1.10310614e-01f, -2.48719752e-02f, -3.88604343e-01f, -1.90995440e-01f, 1.73162431e-01f, 1.38174355e-01f, 6.20353669e-02f, -3.32550183e-02f, -1.61581710e-01f, 1.14612855e-01f,
  2.13943794e-01f, -2.93851197e-01f, 6.17382769e-03f, 3.95053476e-02f, 1.12063484e-02f, -1.68119967e-01f, 1.61243770e-02f, -5.62955216e-02f, -1.62133351e-01f, 3.24017406e-02f,
  -1.38555050e-01f, 2.83456773e-01f, -2.21343309e-01f, 1.90730840e-01f, 1.77548781e-01f, -1.10358208e-01f, 2.22234964e-01f, -8.55063200e-02f, 1.62953004e-01f, 6.01295158e-02f,
  1.39010578e-01f, -7.25201890e-02f, -1.02667674e-01f, -8.05989355e-02f, 6.94065765e-02f, 7.34011382e-02f, -1.08873034e-02f, -8.07746425e-02f, -4.79128398e-02f, -1.19555861e-01f,
  -3.56928930e-02f, 3.05663589e-02f, 1.47806229e-02f, -3.91452350e-02f, 3.33765373e-02f, -9.16393399e-02f, -1.08255170e-01f, 3.92187238e-02f, -1.16467483e-01f, -3.37301344e-02f,
  -1.24586388e-01f, -6.97184280e-02f, -1.25226125e-01f, -2.60515604e-02f, -9.64430645e-02f, -8.43574330e-02f, -7.39680529e-02f, -2.04783157e-02f, 1.00872837e-01f, -3.30798961e-02f,
  -7.53501058e-02f, 6.55795112e-02f, -2.92362534e-02f, 4.11486886e-02f, -4.96503599e-02f, -4.68726270e-02f, -1.29996249e-02f, 2.65163016e-02f, -2.60990132e-02f, 9.33258310e-02f,
  3.50330845e-02f, -5.21251708e-02f, 1.27336504e-02f, -1.78606734e-02f, 4.44565490e-02f, -3.15385647e-02f, -2.16741655e-02f, 3.37528959e-02f, 3.36406343e-02f, -1.34762991e-02f,
  -5.02355695e-02f, 3.25440383e-03f, 1.10659458e-01f, 6.51022419e-02f, -5.24245836e-02f, -5.80913154e-03f, 3.06082834e-02f, -6.78939670e-02f, -2.01925635e-02f, 5.67209646e-02f,
  2.45615691e-01f, 1.17170744e-01f, 6.98536560e-02f, 5.55880517e-02f, 3.99617665e-02f, 3.09583195e-03f, -1.24585643e-01f, -1.37796381e-03f, 2.46229284e-02f, -1.43087460e-02f,
  3.08908224e-02f, 9.72968526e-03f, 8.11774358e-02f, 3.95126306e-02f, 6.64918823e-03f, 1.38464421e-02f, 6.64542466e-02f, -7.76815740e-03f, 1.49513766e-01f, 5.84293343e-02f,
  5.92390709e-02f, 1.30875092e-02f, -1.44047402e-02f, 5.70318885e-02f, 5.45016490e-02f, 6.26117736e-02f, 1.08609591e-02f, -4.41970192e-02f, -3.02666309e-03f, 2.35803928e-02f,
  -3.28806967e-01f, 4.12380993e-01f, 2.52597332e-02f, -4.41519588e-01f, -2.02124435e-02f, -2.51014888e-01f, -3.03635806e-01f, -3.65338027e-02f, -8.71198997e-02f, 2.17326194e-01f,
  -1.65660694e-01f, 9.58875865e-02f, 1.72118142e-01f, -1.17903084e-01f, -3.52898717e-01f, 7.28166923e-02f, -1.43020004e-01f, -1.67921275e-01f, 3.36998329e-02f, -1.71398818e-02f,
  -8.49953219e-02f, -2.57912338e-01f, -1.15816712e-01f, 1.99353740e-01f, -1.22725461e-02f, 1.94515195e-02f, -3.15611064e-02f, 5.20426556e-02f, -2.17253640e-02f, -5.34958243e-02f,
  -1.66169062e-01f, -1.48014247e-01f, 3.42817120e-02f, 4.78921272e-02f, -3.88192497e-02f, 5.58777899e-02f, -5.10789342e-02f, 1.39980495e-03f, -2.50667334e-02f, -6.62601665e-02f,
  4.71209772e-02f, -8.79186243e-02f, -6.13446273e-02f, 3.72742936e-02f, 1.62640084e-02f, -2.77543478e-02f, 2.20911857e-02f, 3.51601318e-02f, -1.50879305e-02f, -4.17720266e-02f,
  3.92898880e-02f, 2.74573173e-02f, 2.91290302e-02f, -7.37791182e-03f, 3.33348103e-02f, -2.25108154e-02f, -1.82486884e-02f, 7.22927824e-02f, -5.82933612e-02f, -8.27868506e-02f,
  -5.98353520e-02f, 8.94185677e-02f, 4.08389904e-02f, -5.89541197e-02f, -4.63147312e-02f, -1.56869404e-02f, 6.01180382e-02f, -9.04289447e-03f, 4.94099744e-02f, -8.80944135e-04f,
  -8.73514190e-02f, 3.75610404e-02f, -6.02096245e-02f, 2.21270937e-04f, -8.85770284e-03f, -5.29397912e-02f, 8.36922750e-02f, -2.67302375e-02f, -4.63593891e-03f, -6.64227009e-02f,
  -8.51850212e-03f, -4.47157063e-02f, 4.64227200e-02f, -1.38930408e-02f, 1.81650203e-02f, -1.53931780e-02f, 1.26591742e-01f, 1.23620946e-02f, -8.10373276e-02f, -9.35223848e-02f,
  -3.16491872e-02f, -9.70399454e-02f, -4.68010455e-02f, -1.02925099e-01f, 1.12285446e-02f, 4.85390499e-02f, 8.38810727e-02f, 5.05477041e-02f, -2.22803447e-02f, -4.38778922e-02f,
  8.53003561e-02f, 2.89239436e-02f, 5.96622974e-02f, 4.48443089e-03f, 8.13608989e-03f, 3.74545790e-02f, -1.79482065e-02f, 1.69629026e-02f, -8.48953798e-02f, 3.02710421e-02f,
  -4.81218733e-02f, 3.35341394e-02f, -1.16163027e-02f, 1.21526420e-02f, -1.52207185e-02f, -7.31439842e-03f, -3.96715887e-02f, 5.66450367e-03f, -5.31536154e-02f, 1.13813557e-01f,
  2.64053047e-01f, 3.02431732e-01f, 2.27783695e-01f, -1.17312990e-01f, 2.85046715e-02f, 2.37342343e-01f, 1.39673546e-01f, 2.27200449e-01f, 9.40838531e-02f, -2.28311680e-02f,
  -6.68387115e-02f, 2.20509440e-01f, 6.70713931e-02f, -4.48779436e-03f, -2.26283878e-01f, -1.89866841e-01f, -9.87451896e-02f, -4.77331057e-02f, 1.35383569e-02f, 1.38422549e-02f,
  -5.57563789e-02f, -1.20399944e-01f, -6.49202764e-02f, -4.35058586e-02f, 2.11793020e-01f, 8.12875926e-02f, -1.64813191e-01f, 1.54763712e-02f, -9.61844102e-02f, 2.60943975e-02f,
  1.77986845e-01f, 1.66951030e-01f, 8.55214298e-02f, 2.10958924e-02f, -4.01004404e-03f, -4.94370200e-02f, 1.24900557e-01f, -1.44053549e-02f, 6.49029166e-02f, 4.25914526e-02f,
  3.04916650e-02f, 6.03677817e-02f, -2.57171392e-02f, -5.97457439e-02f, 5.80121540e-02f, 1.43806562e-01f, -1.77505764e-03f, 5.71390241e-02f, 1.60037488e-01f, -5.04057258e-02f,
  1.03581570e-01f, 8.83294865e-02f, 2.14354564e-02f, 2.40341201e-02f, -1.12048937e-02f, 7.59060681e-02f, -9.92101654e-02f, 1.39678493e-02f, 1.04860015e-01f, 7.67632276e-02f,
  -3.11823897e-02f, -1.63078219e-01f, -2.57270057e-02f, -4.90404945e-03f, 3.44798490e-02f, -1.69892167e-03f, 2.97777336e-02f, -3.37784365e-02f, -1.07510895e-01f, -8.63807858e-04f,
  7.45962723e-04f, -2.65147490e-03f, -9.55824368e-03f, 1.35941738e-02f, -1.07610144e-01f, 8.42225030e-02f, -7.99614638e-02f, 2.64519863e-02f, 4.36279811e-02f, -6.31077290e-02f,
  1.38474023e-02f, 6.27525896e-02f, 7.73530304e-02f, 2.14593317e-02f, 8.04896727e-02f, -2.14923639e-02f, 7.26311579e-02f, 1.10049479e-01f, 1.21173831e-02f, -5.10864742e-02f,
  7.67326877e-02f, 2.08390988e-02f, 1.88857578e-02f, 1.00089535e-01f, -3.11891306e-02f, 9.03314166e-03f, -1.17352642e-01f, -3.19836102e-02f, 3.42514142e-02f, -5.22201210e-02f,
  -6.81318343e-02f, -3.81675805e-03f, 2.78809462e-02f, -3.79944366e-04f, 4.78874333e-02f, -3.96766849e-02f, -9.15451795e-02f, -6.21970743e-02f, 6.63710199e-03f, 7.26740211e-02f,
  -3.46162133e-02f, -4.78774030e-03f, -3.86102796e-02f, -6.94812089e-02f, -1.66573543e-02f, -3.22720818e-02f, -5.57161942e-02f, 2.79657301e-02f, -9.52728167e-02f, -1.28583506e-01f,
  6.77145720e-02f, 2.65630662e-01f, -1.47110105e-01f, -1.26134098e-01f, 3.99944223e-02f, -4.54961732e-02f, 7.53913820e-03f, 1.23241477e-01f, -1.26813695e-01f, 3.50287408e-01f,
  3.46422613e-01f, -3.07908237e-01f, 1.48744106e-01f, 3.59040022e-01f, -2.32277036e-01f, 6.38180822e-02f, 2.49982495e-02f, 7.40594640e-02f, -5.92909008e-02f, 7.71483928e-02f,
  3.63580976e-03f, 2.29136527e-01f, 1.29387602e-01f, 1.03159837e-01f, 2.47862071e-01f, -2.35417455e-01f, 5.81684336e-02f, -9.65569913e-02f, 1.13274381e-01f, -3.87033522e-02f,
  -1.29748974e-03f, 1.26138285e-01f, 4.63451408e-02f, -8.72734785e-02f, 2.54513659e-02f, 7.48961046e-02f, -7.55236596e-02f, -6.57554790e-02f, -2.12836382e-03f, 3.63721512e-03f,
  -2.97571775e-02f, -6.06380589e-02f, -8.93553644e-02f, 6.20190687e-02f, 5.68154231e-02f, 3.79142985e-02f, 1.71163544e-01f, 4.76499163e-02f, 1.57976095e-02f, 1.49552122e-01f,
  3.25945741e-03f, -3.67467888e-02f, 4.81423456e-03f, -9.66275260e-02f, -4.91840616e-02f, 2.25305017e-02f, -4.07590345e-02f, 1.21972598e-02f, -4.49127667e-02f, -6.13367483e-02f,
  1.11660510e-02f, -8.34742785e-02f, 1.27441287e-01f, 8.12916458e-02f, -7.44926184e-02f, 1.08050041e-01f, 8.32941325e-04f, 4.95391013e-03f, 2.45660567e-03f, -5.63789718e-03f,
  -4.01100703e-03f, -4.29592356e-02f, 8.80708694e-02f, 3.04423887e-02f, 7.51338154e-02f, -6.34727255e-02f, -8.35849196e-02f, -8.98602977e-02f, 6.29965663e-02f, 3.67459804e-02f,
  3.97111773e-02f, -1.35094360e-01f, 4.35121022e-02f, -1.77747477e-02f, -1.93242058e-02f, 3.02343804e-04f, 1.01510689e-01f, -6.17089234e-02f, 1.20338999e-01f, -1.18675850e-01f,
  2.99786236e-02f, -6.44513965e-02f, -8.39544181e-03f, -9.90859717e-02f, -1.14160769e-01f, 6.47575632e-02f, 6.72008842e-02f, 8.01919866e-03f, 3.12150456e-02f, 4.43631522e-02f,
  -4.94230837e-02f, 7.45779499e-02f, -7.76340589e-02f, -1.92201196e-03f, -3.91921960e-02f, 1.00672275e-01f, -8.09385478e-02f, -1.86042907e-03f, -1.19645625e-01f, -3.59622426e-02f,
  -1.78846288e-02f, 2.04429626e-02f, -7.18116313e-02f, -4.69498988e-03f, -1.22903660e-01f, -1.46514401e-02f, -1.39112115e-01f, 4.64309789e-02f, 2.20264979e-02f, -9.15436745e-02f,
  -2.72649825e-01f, 6.35909215e-02f, -2.29529999e-02f, 1.73580498e-01f, -1.89886302e-01f, -2.23638117e-01f, -2.70315170e-01f, -1.57277584e-02f, -2.44605556e-01f, 2.65622102e-02f,
  -2.39995629e-01f, 1.28144309e-01f, -2.00157240e-01f, 7.56389648e-02f, -3.29915643e-01f, -1.33123398e-01f, 1.42981380e-01f, 2.23336130e-01f, 7.34634921e-02f, 9.22563300e-02f,
  1.53854430e-01f, 1.07251965e-01f, 2.36090228e-01f, 7.95625299e-02f, 1.59324974e-01f, 1.29408360e-01f, 1.60366550e-01f, 4.92216535e-02f, 1.96560517e-01f, -7.07458705e-02f,
  -8.69907811e-02f, -1.92039654e-01f, -4.68572713e-02f, 2.43193172e-02f, -6.95981607e-02f, 1.76748969e-02f, 5.45352772e-02f, -6.44708052e-02f, -2.54562180e-02f, -2.37890356e-03f,
  3.10518146e-02f, -7.73193920e-03f, 5.02708703e-02f, -7.90495723e-02f, -6.63690194e-02f, 3.09107695e-02f, 2.23670192e-02f, 4.90503013e-02f, 4.26508076e-02f, -3.15792970e-02f,
  -6.66039214e-02f, 3.38651501e-02f, 4.78756465e-02f, 3.39764692e-02f, -8.59879553e-02f, -1.07007533e-01f, -3.04433913e-03f, -7.43659362e-02f, 9.39057954e-03f, -2.47337725e-02f,
  -3.69103365e-02f, 4.66643535e-02f, 1.29365891e-01f, 4.33956385e-02f, -9.67678726e-02f, -1.49525870e-02f, 2.17186920e-02f, 2.80531161e-02f, 6.52424693e-02f, -6.92804456e-02f,
  8.30263793e-02f, 2.13285089e-02f, 5.47242700e-04f, 1.61242764e-02f, 5.69441803e-02f, 3.15242037e-02f, 2.57496126e-02f, 6.52335808e-02f, 5.98987900e-02f, -8.11196025e-03f,
  -5.50584048e-02f, 2.00742818e-02f, 2.09774193e-03f, 8.35155249e-02f, -5.37900440e-02f, -1.04030333e-02f, 4.12712842e-02f, -1.86276417e-02f, 1.02088256e-02f, 6.99236393e-02f,
  -4.85505387e-02f, 5.02544791e-02f, 1.13224778e-02f, -2.14890949e-02f, 8.99238586e-02f, -4.50436734e-02f, -1.06002502e-02f, -2.86680143e-02f, 3.45956832e-02f, -5.10545261e-02f,
  3.66841629e-02f, 5.31987883e-02f, 9.90303531e-02f, -1.69794988e-02f, 1.35978516e-02f, -1.25170231e-01f, 5.55624031e-02f, -7.59971067e-02f, 6.20055012e-02f, 5.56394905e-02f,
  7.11800456e-02f, 1.07349735e-02f, 1.21986745e-02f, 3.47411856e-02f, 1.03255630e-01f, -6.76192492e-02f, 2.88303178e-02f, 5.68686984e-02f, 7.92049542e-02f, 3.78297083e-02f,
  -2.99930247e-03f, -4.32970598e-02f, 1.29192406e-02f, -1.06931008e-01f, -2.58074999e-01f, 1.47900820e-01f, 6.33362085e-02f, -2.75263369e-01f, 3.22768949e-02f, -1.22911036e-01f,
  -1.38233691e-01f, 2.28183404e-01f, 5.46831749e-02f, 3.63210514e-02f, 3.22731793e-01f, 2.80739665e-01f, 1.28920808e-01f, 2.69933075e-01f, 3.75455730e-02f, -7.30327368e-02f,
  -6.62392601e-02f, -2.44150355e-01f, -8.36451948e-02f, -3.61631930e-01f, -1.60610169e-01f, -1.10132635e-01f, -2.67486483e-01f, -1.15559436e-01f, -1.58595175e-01f, 4.94279787e-02f,
  1.14166170e-01f, -8.73217955e-02f, -1.73744559e-01f, 1.62492320e-01f, 3.83468298e-03f, -4.62081805e-02f, 1.26703680e-01f, 1.05627282e-02f, 6.02207780e-02f, -1.45891802e-02f,
  5.27537055e-02f, 9.19821113e-03f, 4.78484109e-03f, -5.43360747e-02f, -8.62067118e-02f, -1.49444211e-02f, 6.28246218e-02f, 4.74932082e-02f, 8.39939155e-03f, -4.00298880e-03f,
  2.93513644e-03f, 1.04487531e-01f, 6.33354038e-02f, 7.29738995e-02f, -8.29833187e-03f, 6.85614869e-02f, 5.61404489e-02f, 2.03028563e-02f, 2.31376830e-02f, -9.62085724e-02f,
  2.42075440e-03f, -3.20394523e-02f, -8.06584656e-02f, 4.04623337e-02f, -5.81651032e-02f, -1.23559594e-01f, -1.71688236e-02f, 5.79096042e-02f, -1.12757301e-02f, -5.43978177e-02f,
  -1.95627399e-02f, -4.43797633e-02f, 3.66929248e-02f, -5.85796572e-02f, -8.62246230e-02f, -3.75415646e-02f, 7.41590858e-02f, 5.69616817e-02f, -4.21162918e-02f, 1.57601185e-04f,
  -2.77125519e-02f, -6.73682429e-03f, 8.90072715e-03f, 1.38044385e-02f, 2.20571854e-03f, -1.09901391e-02f, -9.03267972e-03f, 2.22872179e-02f, 2.03653122e-04f, 1.74340121e-02f,
  1.63881943e-01f, -1.53966755e-01f, 1.88403782e-02f, 2.00463869e-02f, -5.39173111e-02f, -1.64872594e-02f, -6.08770326e-02f, 2.45495662e-02f, 1.57921687e-02f, 3.03603080e-03f,
  -6.35499060e-02f, -7.49843940e-02f, 7.56845549e-02f, 8.22704583e-02f, 5.21042645e-02f, -4.26205918e-02f, -6.60316870e-02f, -5.24883568e-02f, -1.06561869e-01f, 4.26338874e-02f,
  -9.27193612e-02f, 2.63710953e-02f, -7.11312518e-02f, -2.57090926e-02f, -5.45495562e-03f, -1.54313687e-02f, 3.78463343e-02f, -3.51032205e-02f, 4.55371588e-02f, 3.53621058e-02f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.67362601e-01f, 2.72810608e-01f, 1.81705534e-01f, 2.96912104e-01f, -4.76581343e-02f, 5.54297343e-02f, -2.41556972e-01f, 7.31449723e-02f, 4.12519090e-02f, -9.48591977e-02f,
  -2.67423749e-01f, 2.08496734e-01f, -5.11444807e-01f, 2.79841691e-01f, 3.02893549e-01f, -3.16571862e-01f, 4.01129067e-01f, 3.03478986e-01f, -2.60028392e-02f, 2.16830745e-01f,
  9.17710364e-02f, 3.21627349e-01f, 5.60003370e-02f, 2.59825051e-01f, 2.63604939e-01f, 1.47448882e-01f, 2.39158809e-01f, -1.55380115e-01f, 4.46455181e-01f, 1.43924564e-01f,
  -5.22570759e-02f, -3.81962918e-02f, 1.18918880e-03f, -2.39847153e-02f, 3.54726240e-02f, -3.33980806e-02f, -5.34486361e-02f, -4.68794182e-02f, -1.53241009e-01f, -5.33831865e-02f,
  -4.44725640e-02f, 8.47054720e-02f, 5.60433269e-02f, 8.14069435e-02f, 1.41989470e-01f, 1.63737640e-01f, 9.14362296e-02f, -3.76294665e-02f, 3.41401808e-02f, -5.34930453e-03f,
  -7.46039599e-02f, -7.58381635e-02f, 8.66783485e-02f, 1.19704649e-01f, -1.80898067e-02f, 1.63227931e-01f, 1.59344539e-01f, 7.71753564e-02f, 2.36619025e-01f, 2.62725204e-01f,
  -1.20394573e-01f, 8.80563632e-02f, 5.79149500e-02f, 5.95559133e-03f, 1.82861015e-01f, -6.22301735e-02f, 2.66226381e-02f, -1.20203078e-01f, 4.06704433e-02f, 6.94363145e-03f,
  9.64430869e-02f, 1.35148808e-01f, 3.07810735e-02f, -1.39504522e-02f, -6.47447929e-02f, 1.11449093e-01f, -1.18749283e-01f, -8.45318139e-02f, 2.08296552e-02f, -8.03891569e-02f,
  -6.32259808e-03f, 5.69987968e-02f, -1.05711073e-01f, -1.96315199e-01f, 3.76878157e-02f, -3.19228880e-02f, 6.60604797e-03f, 3.82723473e-02f, -3.03474851e-02f, -1.04794756e-01f,
  1.37918919e-01f, 2.43070781e-01f, -4.49923873e-02f, -4.48406301e-02f, -2.16596480e-02f, 8.42334926e-02f, 1.15402795e-01f, -3.26273590e-02f, 1.66787088e-01f, 8.01035389e-02f,
  -5.37784165e-03f, -1.23818763e-01f, -8.02913681e-02f, 3.48175466e-02f, 1.12094142e-01f, 1.06933735e-01f, 3.41379195e-02f, 6.80705300e-03f, 8.88902992e-02f, 9.11812782e-02f,
  -3.11276410e-02f, -1.97625682e-01f, 2.48135775e-02f, 2.55175643e-02f, 8.29520915e-03f, -4.96619120e-02f, -1.96733209e-03f, 1.48143061e-02f, -8.28573033e-02f, 1.68658420e-02f,
  1.67866573e-01f, -1.30354390e-02f, -1.29549295e-01f, -2.12467536e-01f, -5.00106951e-03f, 3.98741454e-01f, 4.63592887e-01f, -1.41612500e-01f, -3.51391196e-01f, 2.06528842e-01f,
  9.63350013e-02f, 8.82518757e-03f, 2.44312420e-01f, 2.44295344e-01f, 3.37770849e-01f, 2.79629797e-01f, 1.50853947e-01f, 1.82682157e-01f, -1.64006516e-01f, 4.49660048e-02f,
  4.09075543e-02f, 3.50875527e-01f, 6.27973676e-02f, -1.70689598e-01f, 2.23271459e-01f, -3.46156925e-01f, 6.64274469e-02f, 3.04453764e-02f, -1.19149625e-01f, 1.29421070e-01f,
  9.65060890e-02f, -2.11000219e-02f, -8.37394595e-02f, -8.17028582e-02f, 4.17964067e-03f, 8.29314664e-02f, 1.48871362e-01f, 1.40310705e-01f, -7.79444575e-02f, 9.68204215e-02f,
  1.27903402e-01f, -7.24471062e-02f, -5.41660935e-02f, -1.87465940e-02f, -2.60889214e-02f, -1.27717271e-01f, -8.72193351e-02f, -1.24026224e-01f, -6.99136257e-02f, 3.51496227e-03f,
  3.00606862e-02f, -7.01948628e-02f, -8.55401307e-02f, -6.45908266e-02f, -7.78355300e-02f, -2.96859350e-02f, 6.24760389e-02f, 1.38310418e-01f, 5.59227467e-02f, -2.12064330e-02f,
  1.37417736e-02f, 8.34790319e-02f, 1.46568239e-01f, -1.49592187e-03f, 4.64429855e-02f, -4.20310646e-02f, -4.23139483e-02f, 7.43168667e-02f, -4.77303155e-02f, 9.01579577e-03f,
  2.21026354e-02f, -1.92788877e-02f, -6.78104609e-02f, 1.61884085e-03f, -1.46185691e-02f, 1.90887395e-02f, 7.22100213e-02f, -9.04427748e-03f, -7.44569525e-02f, -7.97095597e-02f,
  -2.04270128e-02f, 1.31005617e-02f, 1.03496648e-01f, -3.88459302e-02f, 1.16423577e-01f, 1.19062616e-02f, -6.40614480e-02f, -4.24455777e-02f, -1.51035666e-01f, -3.51431686e-03f,
  3.55233140e-02f, 1.07829668e-01f, -2.95042526e-02f, -4.50422689e-02f, 3.24716233e-02f, 7.93066248e-02f, -3.20587009e-02f, 1.98509991e-02f, -3.02285645e-02f, 6.20155782e-02f,
  7.08703175e-02f, -6.74940124e-02f, -4.50216755e-02f, -6.49280623e-02f, -1.43928394e-01f, -4.65728976e-02f, 9.12769288e-02f, -9.13895816e-02f, -1.41106211e-02f, -5.11927158e-02f,
  -4.69703525e-02f, 6.11676686e-02f, -1.30288512e-01f, -3.86649892e-02f, -1.87759593e-01f, 5.48866503e-02f, -7.00231493e-02f, -5.43850251e-02f, 1.25487238e-01f, -2.49492507e-02f,
  8.84231646e-03f, 3.38660568e-01f, 2.95761794e-01f, 1.10461406e-01f, -1.58510119e-01f, 2.90141869e-02f, -3.59378755e-02f, -2.42735930e-02f, -1.33186683e-01f, -1.98156983e-01f,
  -2.47347444e-01f, 2.52776802e-01f, 3.09968531e-01f, -1.85637400e-02f, 1.10090472e-01f, -9.32934508e-02f, 1.02338456e-02f, 6.15971275e-02f, -5.13539556e-03f, 2.66305655e-01f,
  1.51134491e-01f, -2.57432699e-01f, 3.66498083e-01f, -8.33347738e-02f, 1.77624017e-01f, 2.02302009e-01f, -2.52390683e-01f, 2.07960084e-01f, 1.68211818e-01f, -6.59487471e-02f,
  -3.15484740e-02f, 5.42439381e-03f, 9.56594571e-02f, 5.41478023e-02f, 5.82964271e-02f, 3.19966720e-03f, 1.11385539e-01f, 3.28149125e-02f, -4.12738994e-02f, 3.61878946e-02f,
  1.14423946e-01f, -6.97785169e-02f, 8.26957002e-02f, 9.49071720e-02f, 2.74475534e-02f, 6.84457868e-02f, 8.82931277e-02f, 1.35435611e-01f, 4.37165238e-02f, 1.33125588e-01f,
  2.05476642e-01f, 2.23960638e-01f, 9.14477780e-02f, 7.85098150e-02f, 4.04036455e-02f, -2.05569230e-02f, -3.07793133e-02f, 1.96376041e-01f, 9.33930427e-02f, 1.89142320e-02f,
  -3.00699696e-02f, -1.37830377e-01f, -4.24968898e-02f, 3.07916626e-02f, -9.62172225e-02f, -1.18945822e-01f, -1.93234300e-03f, -1.41658023e-01f, -7.85971507e-02f, 3.65129486e-03f,
  -7.49687180e-02f, 1.07792459e-01f, -1.31669939e-01f, -2.03799885e-02f, -1.74547285e-02f, -4.17767838e-02f, 1.15734227e-01f, -6.52883295e-03f, 3.11743263e-02f, 5.49396165e-02f,
  -1.41872644e-01f, -2.61366479e-02f, -6.40912205e-02f, -5.64154349e-02f, -1.30515873e-01f, 7.36480355e-02f, -2.54100673e-02f, 7.83895850e-02f, -3.12556215e-02f, 2.57077545e-01f,
  -3.51115887e-04f, 5.34991957e-02f, -4.11296897e-02f, 1.89841334e-02f, -3.71121578e-02f, 3.12822312e-02f, -1.12184242e-03f, 2.09586206e-03f, -1.88758839e-02f, 5.47803789e-02f,
  4.78663556e-02f, 2.00361665e-02f, -9.13196653e-02f, 3.57245132e-02f, 1.09504931e-01f, -4.70851883e-02f, 2.22966950e-02f, 8.24969336e-02f, 7.56943002e-02f, -5.22448123e-02f,
  8.18247721e-02f, -1.43657774e-01f, -2.65878011e-02f, 2.64422316e-02f, -2.17552315e-02f, -1.17176354e-01f, -3.16605680e-02f, 4.86816000e-03f, 1.15047880e-01f, 9.10150632e-02f,
  -1.22852318e-01f, 4.20538098e-01f, 3.57413203e-01f, -5.01664616e-02f, -1.24978110e-01f, -1.33413628e-01f, -1.95447400e-01f, 2.81306744e-01f, -1.04859760e-02f, 3.26600164e-01f,
  -1.19533092e-01f, 1.94682866e-01f, 1.37378424e-02f, -2.67996304e-02f, -4.87270623e-01f, -3.51666868e-01f, -1.85147747e-01f, -3.19716781e-02f, -1.30926609e-01f, 1.68116912e-01f,
  -2.82007158e-01f, -3.25003028e-01f, -9.93639454e-02f, -1.56965390e-01f, 2.01376572e-01f, 2.88853526e-01f, -5.64088337e-02f, 3.52483913e-02f, 2.47774571e-01f, -1.32848546e-01f,
  7.07148835e-02f, 1.27532095e-01f, 2.67234445e-01f, 1.46414593e-01f, 2.60371044e-02f, 3.92299704e-02f, 1.41432688e-01f, -1.00124091e-01f, -1.32249385e-01f, -5.40003888e-02f,
  7.49954879e-02f, -5.59184067e-02f, 7.07690418e-02f, -1.16539158e-01f, -1.27458610e-02f, 1.62796080e-01f, 4.80402522e-02f, 9.31943655e-02f, 4.16901782e-02f, 9.41110030e-02f,
  6.67961985e-02f, 9.78690460e-02f, 1.28260842e-02f, 5.00342511e-02f, -2.25412957e-02f, 5.84780574e-02f, 9.91027430e-03f, 1.35825396e-01f, 5.02380654e-02f, -4.75555025e-02f,
  -4.17008586e-02f, -1.12485297e-01f, 4.74178307e-02f, 5.50455973e-02f, -1.05076790e-01f, 2.29158755e-02f, 1.05582783e-02f, 4.57092188e-03f, -5.16973399e-02f, 2.91302744e-02f,
  -4.65394743e-02f, 1.38438761e-01f, -1.12323388e-01f, 4.34618853e-02f, -9.01743919e-02f, 5.73912449e-02f, -6.34479597e-02f, 1.55253033e-03f, -7.88600817e-02f, 1.21824861e-01f,
  3.17059108e-03f, -1.45843150e-02f, -5.24521060e-02f, 6.87249005e-02f, -2.77743191e-02f, 2.67921854e-02f, 5.07858470e-02f, 1.02996370e-02f, 3.24760377e-02f, -1.01005591e-01f,
  8.46578553e-02f, 8.38781893e-02f, 1.32660031e-01f, -6.06008060e-02f, 1.23489916e-01f, -1.78186372e-02f, -5.49640507e-02f, 3.62360440e-02f, -7.25277746e-03f, -5.92957810e-02f,
  9.29196700e-02f, -3.67461406e-02f, 2.75332294e-02f, -1.30638495e-01f, -3.30898166e-02f, 5.22800460e-02f, -3.48533466e-02f, -6.69954112e-03f, 9.84565541e-03f, 7.27747679e-02f,
  1.42080849e-02f, -5.25824577e-02f, -9.89958271e-02f, -1.95536479e-01f, 5.96211199e-03f, 2.56757271e-02f, -2.62032952e-02f, -7.42582558e-03f, 2.16803104e-02f, 3.99118513e-02f,
  1.26190647e-01f, -4.80223000e-01f, 1.02085136e-01f, 1.83163732e-01f, 7.82862678e-02f, -2.54665136e-01f, -1.28823459e-01f, -2.34743461e-01f, -2.74818111e-02f, -4.18609619e-01f,
  6.83816969e-02f, 1.42409548e-01f, -3.95274647e-02f, -7.15864301e-02f, 4.42689389e-01f, 2.60475099e-01f, -1.37303889e-01f, 2.37977761e-03f, 6.10146224e-02f, -9.47114229e-02f,
  1.14728823e-01f, -7.70214275e-02f, 2.42987230e-01f, -3.24187815e-01f, -2.94256330e-01f, -8.94118939e-03f, 1.39707908e-01f, 2.09072027e-02f, -1.85579255e-01f, 1.90463021e-01f,
  -1.05344124e-01f, -5.17472923e-02f, -8.46532583e-02f, -3.93758267e-02f, -1.04504287e-01f, -7.12049529e-02f, 5.69462851e-02f, 1.54368967e-01f, 2.97174100e-02f, -6.09542541e-02f,
  8.88248347e-03f, -1.58107709e-02f, -6.09780103e-02f, 1.33099943e-01f, -1.28274798e-01f, -1.23217992e-01f, -1.31685229e-03f, -4.50866036e-02f, 5.48907854e-02f, 5.33653535e-02f,
  -5.48679894e-03f, -4.37622471e-03f, 8.75157937e-02f, -7.22865909e-02f, 1.71637446e-01f, 4.23112698e-02f, 7.06780851e-02f, 4.21215408e-02f, -7.77205974e-02f, 3.86767127e-02f,
  -4.45799790e-02f, 1.11923389e-01f, 2.06689443e-02f, 2.44789626e-02f, -2.01201309e-02f, 7.11359307e-02f, -8.80223066e-02f, 2.12994702e-02f, 5.96666262e-02f, -5.67453690e-02f,
  1.52319893e-02f, 5.38038760e-02f, -2.89398525e-02f, -1.43212244e-01f, 2.23375279e-02f, -1.38288401e-02f, 4.55225930e-02f, 6.60900399e-02f, -1.54382475e-02f, 3.50189246e-02f,
  2.88752280e-02f, 2.96364482e-02f, -3.18297036e-02f, -2.58886740e-02f, 4.13730228e-03f, 3.14089209e-02f, 3.00406739e-02f, -1.27931193e-01f, -4.28262241e-02f, 8.05213749e-02f,
  -2.81854898e-01f, -2.25375220e-01f, 1.96576845e-02f, -3.19062173e-02f, -6.89426064e-02f, -4.27347049e-02f, 4.18096967e-02f, -1.07336894e-01f, -1.68643281e-01f, 6.05936442e-03f,
  -5.35814315e-02f, 5.00734001e-02f, -9.67521518e-02f, 2.69950740e-02f, 1.79301593e-02f, -2.06999630e-02f, 8.19133073e-02f, 5.27223460e-02f, 1.31848187e-03f, -4.91083972e-02f,
  1.34196403e-02f, -1.05943091e-01f, 1.01706244e-01f, 2.53275316e-02f, 1.68096051e-02f, 5.52451909e-02f, -1.26575539e-02f, 1.77985039e-02f, 3.49297673e-02f, -1.19757662e-02f,
  2.84936458e-01f, 4.34795111e-01f, 3.71460766e-01f, 2.86496311e-01f, -3.21414411e-01f, 7.63821527e-02f, -4.52909358e-02f, 4.30082493e-02f, 2.62373269e-01f, 1.86405092e-01f,
  -3.78340989e-01f, 4.96346951e-01f, -2.26024985e-01f, 1.74241394e-01f, -2.15837196e-01f, -1.79089412e-01f, 1.86934561e-01f, 1.57337457e-01f, 3.24435672e-03f, 7.82556832e-02f,
  -9.63368081e-03f, -3.58379871e-01f, -1.82229936e-01f, -2.01899990e-01f, -1.44845918e-02f, 1.32308289e-01f, -3.49669069e-01f, -2.82324702e-01f, 7.66350776e-02f, -8.45144540e-02f,
  -1.03713915e-01f, 6.63888678e-02f, 3.60360071e-02f, 9.46862772e-02f, 3.82425226e-02f, -1.78324338e-02f, 1.25315553e-02f, -6.39361590e-02f, -4.46661748e-02f, 1.80461273e-01f,
  1.22835882e-01f, 8.55109245e-02f, 7.17599317e-02f, -5.57535477e-02f, 8.19390863e-02f, 1.02200285e-01f, 9.95346904e-02f, -5.03168777e-02f, 1.55516103e-01f, 2.02414505e-02f,
  2.14680925e-01f, 1.14179991e-01f, 6.68062642e-02f, 2.35979147e-02f, -5.30339032e-02f, -5.14214896e-02f, 2.65487544e-02f, 8.52590576e-02f, 5.00647053e-02f, 1.05376855e-01f,
  3.16447648e-03f, 3.79751660e-02f, -3.59276384e-02f, 5.30918455e-03f, -1.39558256e-01f, -5.50544709e-02f, 8.96612033e-02f, -5.79509465e-03f, 9.72686708e-02f, 1.05200382e-02f,
  -2.38992330e-02f, 4.27562892e-02f, -3.72825600e-02f, -8.63337517e-03f, -4.47291918e-02f, 3.03391740e-02f, -7.71350637e-02f, 3.76904458e-02f, 4.23939191e-02f, -6.00349624e-04f,
  -1.26076847e-01f, -1.98011193e-02f, -1.31766377e-02f, -2.96937115e-02f, -6.15253858e-02f, -5.59828691e-02f, 5.16557358e-02f, 8.03488365e-04f, -1.48205563e-01f, -6.05400018e-02f,
  5.57124093e-02f, 1.97944894e-01f, 1.72056560e-03f, 4.64748293e-02f, 5.83096631e-02f, 3.02044093e-03f, 9.92344171e-02f, 2.15174779e-01f, -3.30520235e-02f, 1.85811948e-02f,
  5.65647148e-02f, 6.74229637e-02f, -9.37037542e-03f, 1.32712023e-03f, -6.95441738e-02f, 2.43486501e-02f, 2.45272275e-02f, 8.37269425e-02f, -4.78399657e-02f, -6.20657727e-02f,
  -3.94747406e-02f, -5.62532106e-03f, 9.22873765e-02f, -5.03795035e-02f, 4.34546173e-02f, -4.35938574e-02f, 2.42016651e-03f, 1.73670407e-02f, -1.61311254e-01f, 7.42557645e-02f,
  9.89867970e-02f, 1.77526683e-01f, -7.71640614e-03f, -2.39849567e-01f, -1.30619586e-01f, -4.76671085e-02f, -1.75310224e-01f, -8.08457881e-02f, -1.05231106e-01f, 3.45636845e-01f,
  -1.86070859e-01f, 2.77919620e-01f, -9.06252414e-02f, -2.86767483e-01f, -4.85651851e-01f, -4.13406700e-01f, -2.26402730e-01f, -3.76859009e-02f, -3.37863229e-02f, 2.13774100e-01f,
  -1.86573520e-01f, -2.68804729e-01f, -2.95795739e-01f, 6.80345297e-02f, 2.48742253e-01f, 3.26870769e-01f, -8.43417719e-02f, 5.56093529e-02f, 2.44417101e-01f, -1.31922543e-01f,
  -6.21525869e-02f, 1.99410059e-02f, 7.18644336e-02f, 3.91058996e-02f, -3.29924189e-02f, 7.93885663e-02f, 9.60581973e-02f, -7.14961216e-02f, -6.17523640e-02f, 2.43392084e-02f,
  7.85618797e-02f, -3.29958834e-03f, -7.19511434e-02f, -2.89240740e-02f, 2.07746923e-01f, 9.25707296e-02f, -1.68854825e-03f, 4.58074361e-02f, 6.99424073e-02f, -3.05085257e-03f,
  7.69806001e-03f, -2.06838865e-02f, 7.27920830e-02f, -7.88841471e-02f, -3.72070223e-02f, 9.25044715e-03f, 8.45934078e-02f, 2.22189575e-02f, 7.55095407e-02f, 2.82320343e-02f,
  -4.20931354e-02f, 4.62587830e-03f, -5.49401008e-02f, -7.90758729e-02f, -5.17404862e-02f, -4.91968319e-02f, -5.35988212e-02f, -9.34709087e-02f, 1.74045488e-02f, 1.16527537e-02f,
  2.06322200e-03f, 9.59895775e-02f, 4.54791263e-03f, 3.82206514e-02f, 1.92288104e-02f, 7.93249235e-02f, 1.70327630e-02f, 9.54592302e-02f, -4.92869318e-02f, 1.96956424e-03f,
  -7.16426969e-02f, 2.50006318e-02f, 1.62815081e-03f, 7.13827461e-02f, -1.53669804e-01f, -4.10713740e-02f, 1.15063377e-01f, 1.58170275e-02f, -1.36426371e-02f, -9.90634114e-02f,
  -3.55370063e-03f, 4.29429933e-02f, -5.02173267e-02f, -7.58820074e-03f, 1.60517059e-02f, 2.81190071e-02f, -6.77608922e-02f, 5.06132543e-02f, -6.65182471e-02f, -6.39941096e-02f,
  4.90538031e-02f, -1.46750147e-02f, 4.33811881e-02f, -6.85225949e-02f, -4.84926924e-02f, 7.08629668e-04f, 2.12207865e-02f, 3.61777246e-02f, 2.29053460e-02f, 7.19187334e-02f,
  1.76924542e-01f, 1.76513180e-01f, 1.51791014e-02f, 7.64651373e-02f, 6.41038567e-02f, 5.91725111e-02f, 4.91594560e-02f, 8.41910467e-02f, 2.42142100e-02f, -9.84189473e-03f,
  -7.69371018e-02f, 9.06888768e-02f, 5.61669290e-01f, -1.09761998e-01f, 2.05574304e-01f, 3.37934852e-01f, -2.76791185e-01f, 1.69208542e-01f, -1.66760534e-01f, -1.58012033e-01f,
  -1.59750640e-01f, 1.94206655e-01f, -3.93476546e-01f, 2.44612992e-01f, 1.04948685e-01f, -3.59663427e-01f, 4.24244292e-02f, -2.64419407e-01f, -7.17997476e-02f, -8.08957368e-02f,
  3.73963155e-02f, -3.95258904e-01f, 7.93894306e-02f, 8.93344078e-03f, 9.19864029e-02f, 1.15019359e-01f, -3.15253705e-01f, -1.57663077e-01f, 1.85297072e-01f, 3.41313183e-02f,
  9.94027127e-03f, -5.34736738e-02f, 8.55356902e-02f, 9.54766199e-02f, 5.18112183e-02f, -1.17662840e-01f, -3.57092582e-02f, -1.17408670e-01f, -5.97464070e-02f, 6.10375516e-02f,
  2.89277248e-02f, 1.75505161e-01f, 7.47579187e-02f, -1.33165449e-01f, 1.30253866e-01f, 2.12563723e-02f, 1.33350909e-01f, 4.84299920e-02f, 8.76264125e-02f, 2.35187933e-01f,
  1.94674470e-02f, 3.07171464e-01f, 2.48645380e-01f, 7.11535364e-02f, 4.63570170e-02f, 1.25331551e-01f, 8.56950730e-02f, 1.39779106e-01f, 1.15647763e-01f, 1.86317950e-01f,
  1.17246658e-01f, -7.26546422e-02f, 2.48490125e-02f, 4.67922948e-02f, -4.19433787e-02f, -1.07934857e-02f, -7.44640678e-02f, 1.89483743e-02f, -2.92203204e-05f, 4.04671729e-02f,
  1.18211303e-02f, 3.77002805e-02f, -7.14067146e-02f, -4.40628156e-02f, -1.22787841e-01f, 8.52488726e-02f, 9.18150786e-03f, -6.90830722e-02f, -9.52356607e-02f, 4.14750017e-02f,
  -2.12425455e-01f, 3.12930830e-02f, 2.75886040e-02f, 6.77439943e-02f, 1.14878930e-01f, -5.92408106e-02f, -2.39221118e-02f, 8.77085999e-02f, 4.44043055e-02f, -1.92846239e-01f,
  -4.11233127e-01f, -4.49461013e-01f, -5.83736263e-02f, -1.02781869e-01f, -1.35262638e-01f, 1.53771415e-02f, -9.00413617e-02f, -3.40460502e-02f, -1.11037046e-02f, -8.86816680e-02f,
  5.47808185e-02f, -7.57141446e-04f, -6.17639627e-03f, -9.73964408e-02f, -1.05826773e-01f, -1.19053133e-01f, -1.72147870e-01f, -1.29364431e-01f, -5.24656437e-02f, -4.12856042e-02f,
  -9.01859924e-02f, -1.06406800e-01f, 1.75143078e-01f, 6.53708354e-02f, -9.03614908e-02f, 4.77630645e-02f, -5.78235947e-02f, -5.48924357e-02f, -1.06305219e-02f, 3.70911807e-02f,
  -1.19691506e-01f, -4.02125120e-01f, 1.15600109e-01f, 4.71314341e-01f, -3.32963198e-01f, -3.84197496e-02f, 4.79839623e-01f, -3.33013177e-01f, -2.19936863e-01f, -5.12360483e-02f,
  2.81369179e-01f, 4.38543148e-02f, 1.70879439e-01f, 3.24660450e-01f, 1.99149579e-01f, 1.39354751e-01f, 2.52400875e-01f, 2.41382584e-01f, -1.26795307e-01f, -1.64990291e-01f,
  -1.78425163e-02f, 9.51278061e-02f, 1.74654067e-01f, -3.42041075e-01f, -1.51269333e-02f, -1.75125405e-01f, 1.16707847e-01f, -6.49639815e-02f, 1.59471080e-01f, 9.06997249e-02f,
  -2.67644882e-01f, -1.34569034e-01f, 1.37725294e-01f, -9.76643264e-02f, -1.27184987e-01f, 1.24425203e-01f, 1.51133254e-01f, 1.34600982e-01f, 1.18342340e-01f, 7.01371580e-03f,
  -4.34373505e-02f, -8.24025124e-02f, -1.34250209e-01f, -1.23277185e-02f, -1.30821213e-01f, -7.82687683e-03f, -5.40869683e-02f, 4.61695995e-03f, -2.23125070e-02f, 6.40355889e-03f,
  1.20855965e-01f, 3.69345397e-02f, 9.57199186e-03f, 2.55212504e-02f, -9.56381392e-03f, 1.36709167e-02f, 9.81665477e-02f, 6.13294281e-02f, -1.28816441e-01f, -3.61321121e-02f,
  8.98053944e-02f, -3.29267681e-02f, 2.92006638e-02f, 4.01988029e-02f, 9.01905969e-02f, 2.27414612e-02f, 1.09117799e-01f, 7.18235895e-02f, -2.78537255e-03f, 1.37191350e-02f,
  -5.97318448e-02f, 2.62711104e-02f, 8.67973417e-02f, 1.54162301e-02f, 4.51681279e-02f, -2.82770535e-03f, 6.41257316e-02f, -1.08939528e-01f, -8.33336785e-02f, 5.09503894e-02f,
  2.54787356e-02f, -4.73428797e-03f, -2.06056703e-02f, 4.38207388e-03f, 5.46347834e-02f, 5.93883730e-02f, 1.76319794e-03f, -2.59210002e-02f, 7.72132948e-02f, -1.19396979e-02f,
  -5.46800971e-01f, -3.29110056e-01f, -6.20539077e-02f, -2.02130098e-02f, 1.27473176e-01f, -8.69381800e-02f, 4.08647284e-02f, -1.41697943e-01f, -6.43397346e-02f, -7.58317336e-02f,
  -1.07696719e-01f, 5.99657111e-02f, -7.37977177e-02f, 1.68799888e-03f, 1.34170260e-02f, -4.24604118e-02f, 9.53400657e-02f, -2.51185670e-02f, 8.59684870e-02f, -1.28147528e-01f,
  2.81599108e-02f, 1.94885209e-02f, 5.59009425e-02f, -1.20755278e-01f, 5.15553020e-02f, 3.63139249e-02f, -1.39059812e-01f, -7.16048181e-02f, -3.28782648e-02f, -1.36994608e-02f,
  3.85264546e-01f, 1.73767209e-01f, 3.57138127e-01f, 5.07810771e-01f, -8.95169675e-02f, -3.75466764e-01f, -2.39570946e-01f, 2.59372294e-01f, 3.82845670e-01f, -2.65368164e-01f,
  -1.20064974e-01f, 8.47248659e-02f, -1.73629299e-01f, 1.34234102e-02f, -2.98419923e-01f, -2.49675717e-02f, -1.54155478e-01f, -1.67390138e-01f, 9.33038592e-02f, 7.00742453e-02f,
  3.50744992e-01f, -2.14742899e-01f, 8.90338346e-02f, -2.53485003e-03f, 3.05368185e-01f, 2.99350798e-01f, 2.24097241e-02f, -1.72086641e-01f, 6.78575262e-02f, -3.71568292e-01f,
  -1.21109523e-01f, 1.50595576e-01f, 1.07462563e-01f, -7.25765675e-02f, 2.06322055e-02f, -5.01263551e-02f, -1.33159133e-02f, -9.27679017e-02f, 1.56354380e-03f, -3.76467332e-02f,
  1.68483537e-02f, 1.03405394e-01f, 3.53056416e-02f, -8.64373222e-02f, -1.60055012e-02f, 1.76586732e-01f, 1.42933577e-01f, 8.99373740e-02f, 4.66822945e-02f, 1.96942568e-01f,
  9.52929705e-02f, 8.93343687e-02f, 3.89555842e-02f, -8.07243213e-02f, 1.35024890e-01f, -7.41714165e-02f, -6.18597642e-02f, -6.29158169e-02f, -7.32582249e-03f, 1.31469533e-01f,
  -5.07060215e-02f, -4.94373823e-03f, -7.22244605e-02f, -5.50103094e-03f, -1.33719910e-02f, 6.56505376e-02f, -5.83188571e-02f, -8.20283405e-03f, 1.86295845e-02f, -6.28536046e-02f,
  1.93989016e-02f, 2.87907477e-02f, 1.70747098e-02f, 5.78939915e-02f, 6.17534630e-02f, 4.21576723e-02f, -8.37450624e-02f, -2.20927931e-02f, 8.02114159e-02f, 3.24898548e-02f,
  -1.21449888e-01f, -7.23348558e-02f, 3.70541662e-02f, 8.90117418e-03f, -1.43225387e-01f, 1.15772970e-01f, 2.13732664e-02f, 1.45263642e-01f, 4.05638739e-02f, -3.92028391e-02f,
  -2.37581804e-01f, 3.61989625e-02f, -2.48256307e-02f, -8.82440209e-02f, -4.60243188e-02f, -2.05149092e-02f, 4.64328118e-02f, 4.85941954e-03f, -1.90880783e-02f, -5.35521246e-02f,
  2.01198962e-02f, -3.28636765e-02f, -2.22883970e-02f, 7.72146955e-02f, -2.22315341e-01f, 3.27581316e-02f, -5.34203276e-02f, -9.02713388e-02f, -1.66147083e-01f, 3.26764360e-02f,
  1.11803077e-01f, 2.88282316e-02f, -8.73047039e-02f, 1.67131016e-03f, 4.18172181e-02f, 2.75440365e-02f, 2.90411408e-03f, 4.30423729e-02f, 7.47602209e-02f, -7.36348107e-02f,
  9.46390443e-03f, -2.27511063e-01f, -2.66002387e-01f, -3.97831738e-01f, 1.03733599e-01f, -2.69834638e-01f, -2.91709810e-01f, -1.59526363e-01f, -1.75211012e-01f, 6.55872375e-02f,
  -5.10106459e-02f, -2.31718466e-01f, -1.36679888e-01f, -3.84490401e-01f, -1.55559927e-01f, -1.09902009e-01f, -2.53670007e-01f, -2.62286037e-01f, -8.64048526e-02f, -1.05684377e-01f,
  2.65420936e-02f, -9.72084552e-02f, -1.66840181e-01f, 1.56557903e-01f, -2.58318394e-01f, 1.47923261e-01f, 2.92240977e-01f, -6.16781078e-02f, -2.68023531e-03f, 1.80048160e-02f,
  -8.95378143e-02f, 9.50918905e-03f, -3.86447571e-02f, -1.16193570e-01f, 1.29819345e-02f, 1.47686929e-01f, 3.80699858e-02f, -5.81169352e-02f, 1.76633280e-02f, -9.87117514e-02f,
  6.15566932e-02f, 5.55215366e-02f, 5.33514610e-03f, -7.08143935e-02f, -2.29701959e-02f, 4.77619953e-02f, -7.92621598e-02f, 7.20357448e-02f, -1.04052521e-01f, -1.14756413e-01f,
  -1.56987309e-01f, -6.30659163e-02f, 5.03437258e-02f, -1.33724818e-02f, -3.22336666e-02f, 5.49721234e-02f, 6.78835735e-02f, -2.20515691e-02f, -8.91342852e-03f, 5.67324795e-02f,
  5.53111807e-02f, 1.71129167e-01f, -1.52634745e-02f, -5.28191263e-03f, -7.15295132e-03f, 7.15902867e-03f, -9.36468542e-02f, -5.76114580e-02f, 3.86911593e-02f, 2.36617066e-02f,
  -5.49528375e-02f, -1.35354862e-01f, 8.77369121e-02f, 2.98914053e-02f, 5.26165515e-02f, 1.19406879e-02f, 7.84612671e-02f, -2.49869134e-02f, 3.05377087e-03f, -1.06501959e-01f,
  -6.10941648e-02f, 5.87335378e-02f, -5.81189580e-02f, 3.13131623e-02f, -7.19017982e-02f, -6.11955971e-02f, 5.74759878e-02f, -9.17180926e-02f, 4.68252897e-02f, -1.26906130e-02f,
  3.38643081e-02f, 2.06939615e-02f, -2.47292686e-02f, -1.05681971e-01f, -1.29918184e-03f, 5.78652062e-02f, -1.00579783e-01f, -1.09693885e-01f, -1.00700803e-01f, 2.87974328e-02f,
  1.35875985e-01f, 6.31237924e-02f, 8.08823854e-02f, -5.39702028e-02f, 6.62994236e-02f, 7.03928061e-03f, 7.45434985e-02f, 1.11918502e-01f, 1.56760123e-02f, 3.81677151e-02f,
  1.64493993e-02f, 9.35892016e-02f, 6.71247765e-02f, -7.65866861e-02f, -3.12259723e-03f, 9.38712060e-02f, 5.59459031e-02f, -5.43606877e-02f, 3.17689124e-03f, -2.81563587e-02f,
  2.11110055e-01f, 6.53401315e-02f, 2.83766001e-01f, 4.11691546e-01f, 2.60039359e-01f, 2.28929698e-01f, 1.50582120e-01f, 3.30395430e-01f, 4.29016352e-01f, -1.73086390e-01f,
  -5.37072122e-02f, -3.13402385e-01f, -2.09852621e-01f, 1.70475066e-01f, -5.05277701e-02f, 7.14342445e-02f, 2.86395758e-01f, -7.95594528e-02f, 3.82979453e-01f, 2.04262197e-01f,
  2.69778728e-01f, 8.78845528e-03f, -8.26133937e-02f, -3.88239361e-02f, -1.57213621e-02f, 5.55026382e-02f, -3.10018629e-01f, -1.23504825e-01f, -3.42773318e-01f, -1.83829993e-01f,
  9.37926546e-02f, 2.05422983e-01f, -8.73002112e-02f, 1.55377025e-02f, 1.80493593e-01f, -1.36236265e-01f, -1.39977723e-01f, -9.24452916e-02f, -6.20989352e-02f, 2.75294743e-02f,
  2.44664568e-02f, -1.11428097e-01f, 1.51622863e-02f, -6.37837499e-02f, 4.48509492e-02f, 7.58484751e-02f, 8.21579769e-02f, 1.80270672e-01f, 3.22844507e-03f, 3.42902802e-02f,
  4.34191450e-02f, 5.93019696e-03f, 4.49808426e-02f, -1.62223838e-02f, -1.90825779e-02f, 3.93969864e-02f, -2.42648721e-02f, -1.07105365e-02f, 1.26437368e-02f, -8.56144261e-03f,
  -9.00425613e-02f, 4.04759962e-03f, -4.05218154e-02f, -6.72102422e-02f, 1.14820071e-01f, 3.22918743e-02f, -3.45119983e-02f, 6.40996918e-02f, 2.32208505e-01f, 7.76252151e-02f,
  5.78737408e-02f, 9.64763612e-02f, 2.35783458e-01f, -5.40923141e-03f, 9.70824659e-02f, -2.71601751e-02f, -3.83925997e-02f, 1.05869271e-01f, 8.96800607e-02f, 9.35283154e-02f,
  3.24717648e-02f, -6.67150393e-02f, 2.69372221e-02f, -5.72557598e-02f, -2.83334553e-02f, 5.20841591e-02f, 1.68983251e-01f, 1.13625541e-01f, 3.54433879e-02f, -3.11698597e-02f,
  6.13571843e-03f, 1.12734295e-01f, -6.84199184e-02f, -2.48770770e-02f, 7.09530264e-02f, -9.18085352e-02f, 1.08844660e-01f, 2.00643949e-02f, -8.78196806e-02f, -5.47591448e-02f,
  2.09763609e-02f, -4.89507616e-02f, -1.06751308e-01f, -1.49449259e-01f, -1.92590311e-01f, 9.39342454e-02f, 3.37797813e-02f, -3.82945649e-02f, -1.59154907e-01f, -7.77331218e-02f,
  -3.14749703e-02f, 4.66970690e-02f, -8.94686114e-03f, 6.55276328e-02f, 5.35608307e-02f, -1.36329472e-01f, -1.49356751e-02f, -5.09195961e-02f, -7.79952928e-02f, -1.64769515e-02f,
  -6.62303090e-01f, -1.20990776e-01f, -2.37924337e-01f, -2.76019841e-01f, 3.76626968e-01f, 5.16346633e-01f, -2.56394595e-01f, -2.52161231e-02f, -5.56826830e-01f, -8.71304497e-02f,
  8.97899717e-02f, -3.24611634e-01f, -3.01288128e-01f, -8.09713528e-02f, 1.12501889e-01f, -1.43567279e-01f, 1.57380283e-01f, -1.10695995e-01f, -2.74667054e-01f, -2.51142383e-01f,
  -8.53126720e-02f, 2.80020148e-01f, -1.95317522e-01f, 2.16507345e-01f, -9.66601595e-02f, -1.14428312e-01f, 1.27442732e-01f, -5.55375814e-02f, 2.50207752e-01f, 1.20339856e-01f,
  -1.07504398e-01f, -2.64901578e-01f, -2.15750501e-01f, -1.23036774e-02f, 6.34251311e-02f, -4.56702076e-02f, -3.82761322e-02f, -7.15550408e-02f, -5.15233390e-02f, -6.71661645e-02f,
  -1.84066862e-01f, -6.94608390e-02f, 9.42131877e-02f, -2.48458944e-02f, 4.28692922e-02f, 9.72543582e-02f, 1.26003167e-02f, 5.74776232e-02f, -5.95400371e-02f, -2.54716165e-02f,
  2.58176681e-02f, 7.91923329e-02f, -6.01311848e-02f, 1.28005162e-01f, 8.69625285e-02f, 6.41784370e-02f, -2.84366608e-02f, -3.52212153e-02f, 8.42996016e-02f, -8.36440027e-02f,
  -2.59244312e-02f, -1.08317964e-01f, -5.99416122e-02f, 9.75333825e-02f, 2.41818139e-03f, 6.69061095e-02f, -7.85138458e-02f, 1.83940202e-01f, 3.63590196e-03f, -4.33190167e-03f,
  1.08250037e-01f, -1.81724131e-02f, -1.32153451e-01f, 8.95221829e-02f, 5.51434159e-02f, -7.53117055e-02f, -8.97574127e-02f, -3.04354038e-02f, 1.67877357e-02f, 9.41464007e-02f,
  -1.30884886e-01f, 9.65697914e-02f, 9.95787443e-04f, -3.82443331e-02f, 3.50577459e-02f, -1.16427243e-02f, 3.98050696e-02f, -6.22163787e-02f, -5.67746423e-02f, -6.03670850e-02f,
  -2.68780068e-02f, -6.42660111e-02f, -4.62000296e-02f, 1.55330002e-01f, 8.79679397e-02f, 5.83780296e-02f, 1.43099036e-02f, 8.12126324e-02f, 2.36935150e-02f, 1.06846262e-02f,
  9.12199095e-02f, 2.47511291e-03f, 9.88038182e-02f, 3.08778193e-02f, -2.29040794e-02f, 5.76604456e-02f, 3.68794575e-02f, -1.11118078e-01f, 8.94410014e-02f, 2.19496816e-01f,
  1.07813485e-01f, 8.25531930e-02f, 1.44725889e-01f, 1.66002974e-01f, 5.36249392e-02f, 2.70081479e-02f, -4.04665321e-02f, -1.49573624e-01f, 1.44593328e-01f, 1.16478443e-01f,
  -1.35563165e-01f, -3.15145880e-01f, 3.53182942e-01f, -9.01170000e-02f, 1.48404995e-02f, 2.23691478e-01f, 2.11050212e-01f, 9.44419801e-02f, -2.12016135e-01f, -3.87465000e-01f,
  -1.72341298e-02f, -1.97264612e-01f, 2.11290956e-01f, -2.99590468e-01f, 3.07479948e-01f, 1.73930734e-01f, -1.22037061e-01f, -6.41435757e-02f, 2.90650040e-01f, 2.38575459e-01f,
  2.40465507e-01f, -6.46473393e-02f, 4.59776074e-01f, 6.40048161e-02f, 1.38889581e-01f, -2.89169028e-02f, 4.02779318e-02f, 3.09837073e-01f, -7.25430623e-02f, -1.28478289e-01f,
  -1.67163625e-01f, -1.44915795e-02f, -2.13650279e-02f, -2.70411447e-02f, 1.46014437e-01f, 2.59524006e-02f, 1.07520401e-01f, 1.34631157e-01f, 9.35267508e-02f, 1.37539446e-01f,
  8.24252591e-02f, 1.55423418e-01f, -1.48671076e-01f, 2.90882792e-02f, -1.05210058e-01f, -5.65676540e-02f, 8.08877349e-02f, 8.46333057e-02f, -1.40694100e-02f, 1.09286755e-01f,
  2.03349963e-01f, 6.04573078e-02f, 3.43481265e-02f, -5.17561212e-02f, 1.16415709e-01f, -7.28553981e-02f, -7.85664693e-02f, 2.83331685e-02f, -7.37356171e-02f, -7.74608701e-02f,
  -4.05917643e-03f, -7.77029619e-02f, 2.59346154e-04f, -4.52252328e-02f, -4.33865190e-02f, 1.89585350e-02f, 2.96507310e-02f, -2.81561632e-02f, 6.78314269e-02f, -1.53173087e-02f,
  2.07140110e-02f, 1.22862890e-01f, 4.49575409e-02f, 9.78668258e-02f, -1.03868179e-01f, -1.59836859e-01f, 1.65553585e-01f, 1.59594230e-02f, -2.44635418e-02f, 4.32135053e-02f,
  8.76599848e-02f, 4.41188216e-02f, 4.77477498e-02f, 4.91787381e-02f, -1.03008978e-01f, 1.00081503e-01f, 5.43901511e-02f, -8.03112388e-02f, 8.87190253e-02f, 6.81790039e-02f,
  -1.36672348e-01f, -8.75285715e-02f, -6.75447583e-02f, -1.53538436e-01f, -3.44353542e-02f, 4.31209765e-02f, 2.79051568e-02f, -8.98789540e-02f, 3.62093397e-03f, 9.05743986e-02f,
  5.12861051e-02f, 9.56443623e-02f, -2.16816172e-01f, 3.81544568e-02f, 6.17305050e-03f, 1.41835928e-01f, 9.42703150e-03f, -5.99177554e-02f, -5.20472303e-02f, 2.84852255e-02f,
  -4.40136008e-02f, -3.73694077e-02f, -1.33413114e-02f, -5.11685237e-02f, -1.77293479e-01f, -7.10099787e-02f, 4.82933708e-02f, -3.82166505e-02f, -4.40745987e-02f, -2.35861316e-02f,
  -4.12005186e-01f, 1.50432646e-01f, -2.11712703e-01f, 1.03110187e-01f, -2.16269672e-01f, -2.95059174e-01f, -1.43678049e-02f, -1.90535560e-01f, -6.63760155e-02f, 4.04096246e-01f,
  7.88702145e-02f, 2.18214914e-02f, 4.28488618e-03f, 3.05210054e-01f, -3.89009088e-01f, 1.06227122e-01f, 1.20841660e-01f, 2.49718621e-01f, -4.70368937e-03f, -1.93893239e-01f,
  -1.17849015e-01f, -5.23560029e-03f, 8.41805711e-03f, -2.40370080e-01f, -7.09979683e-02f, -1.07159041e-01f, 1.61077946e-01f, -1.85878202e-01f, 2.43919045e-01f, 1.21888660e-01f,
  -2.21954912e-01f, -2.03069851e-01f, 1.43966541e-01f, -4.71795276e-02f, -1.00506708e-01f, -1.94191486e-02f, 1.33336624e-02f, -1.05168350e-01f, -5.15619069e-02f, 1.66427381e-02f,
  8.09915736e-02f, -7.42579028e-02f, 3.11494339e-02f, -3.78192291e-02f, 4.97157611e-02f, -2.29550917e-02f, -3.71687748e-02f, 7.31037483e-02f, -5.34772091e-02f, -2.70498917e-02f,
  -5.97558655e-02f, -2.70694941e-02f, -6.68876916e-02f, 2.00025052e-01f, 1.96354073e-02f, -1.44362701e-02f, -2.06826180e-02f, -2.99965777e-02f, -1.13477357e-01f, -5.72327711e-02f,
  -2.01600767e-03f, -5.39711723e-03f, -1.04398485e-02f, -2.98724715e-02f, -1.38657205e-02f, 1.02529274e-02f, 4.17983644e-02f, 4.66417987e-04f, 4.55132127e-02f, -9.72731188e-02f,
  -1.62803326e-02f, 5.77700362e-02f, -5.86704984e-02f, 5.05948579e-03f, 2.75292285e-02f, 3.52070220e-02f, -1.14866212e-01f, 1.88605059e-02f, 7.60919228e-02f, 2.76710223e-02f,
  1.76646058e-02f, -1.26494005e-01f, 1.90480612e-02f, 1.03963040e-01f, -4.84564016e-03f, -3.15426923e-02f, 8.39692950e-02f, -2.11519916e-02f, 5.79304509e-02f, -8.43129978e-02f,
  -4.69369411e-01f, -4.76166338e-01f, -2.17856336e-02f, 1.47849135e-02f, -3.08289267e-02f, 4.02067415e-02f, 1.18494257e-01f, 1.17185293e-02f, -1.38555154e-01f, -1.92695290e-01f,
  -3.58902407e-03f, 1.59990832e-01f, -1.25587136e-01f, 1.06017843e-01f, 3.98256555e-02f, -3.16558406e-02f, 5.75861894e-02f, 3.51821072e-02f, -1.18967541e-01f, -1.04962409e-01f,
  -3.55798900e-02f, -1.07547067e-01f, -4.16143611e-02f, 9.64883119e-02f, 1.85396433e-01f, -9.39839482e-02f, -4.41162288e-02f, 2.84121893e-02f, -1.40203506e-01f, 1.13452598e-01f,
  5.79347134e-01f, -8.70114006e-03f, -2.37971351e-01f, 3.30425292e-01f, 1.87514037e-01f, -9.90913361e-02f, 3.20841223e-01f, 2.94154555e-01f, 3.93805861e-01f, 1.26070097e-01f,
  -1.07788444e-02f, 4.11984287e-02f, 5.81267551e-02f, 1.36442371e-02f, -2.07244068e-01f, -1.58208519e-01f, -1.59092829e-01f, 1.18996687e-02f, 3.42953414e-01f, 1.60738844e-02f,
  -5.79301901e-02f, 2.74502281e-02f, -1.52279094e-01f, -7.78705627e-02f, 1.73773163e-03f, 1.34475634e-01f, -3.16093922e-01f, 2.08844375e-02f, -1.58586308e-01f, -2.92662084e-02f,
  1.04131334e-01f, 3.72197539e-01f, 8.90879054e-03f, 4.36802059e-02f, -1.08277924e-01f, -3.93589400e-02f, -7.63005391e-02f, -4.74734455e-02f, 1.85570091e-01f, 4.98835109e-02f,
  -1.01002365e-01f, -1.37708196e-02f, 1.00366794e-01f, -6.65821880e-03f, 1.25114873e-01f, -4.52238545e-02f, 3.02150473e-02f, -1.02292284e-01f, 7.94501975e-02f, -7.08877072e-02f,
  -2.73758192e-02f, 1.04794959e-02f, -4.02461691e-03f, 1.11720219e-01f, -1.06927797e-01f, 1.24914639e-01f, -1.14930861e-01f, -1.75309584e-01f, -6.44523576e-02f, 2.52216700e-02f,
  -9.70747694e-03f, -6.86119171e-03f, 8.58952627e-02f, 1.68598101e-01f, -3.75033095e-02f, -1.34079643e-02f, 5.48115186e-02f, 3.80318277e-02f, 1.35759145e-01f, -9.09580756e-03f,
  6.39834329e-02f, 1.07417896e-01f, 1.12444274e-01f, -2.83523351e-02f, -1.19610513e-02f, 1.08394220e-01f, -7.23718181e-02f, -4.54445183e-02f, 2.13407073e-03f, -2.50120256e-02f,
  7.57976994e-02f, -7.68463165e-02f, 4.44545187e-02f, -8.60579759e-02f, 8.97320174e-03f, 1.07811518e-01f, -1.46986805e-02f, -4.38881777e-02f, -7.48397782e-03f, -1.27403170e-01f,
  -1.94274634e-01f, -9.54892263e-02f, 1.32126197e-01f, 7.26168081e-02f, -8.62220526e-02f, -5.52829579e-02f, -9.01350081e-02f, 1.87782047e-03f, -3.09744552e-02f, 1.27883226e-01f,
  2.04788477e-04f, 3.30147743e-02f, -1.16554692e-01f, 3.19812167e-03f, -1.79323077e-01f, -2.40044352e-02f, -3.43750082e-02f, -7.72864297e-02f, -1.30793020e-01f, -1.91385657e-01f,
  -7.30863959e-02f, 5.32957539e-03f, -2.29171831e-02f, 4.74458151e-02f, -8.77110809e-02f, -1.10052107e-02f, -8.36652070e-02f, 2.06854679e-02f, -2.54288875e-02f, -3.48727517e-02f,
  -4.84918147e-01f, -2.04060316e-01f, 1.56593353e-01f, -4.29372750e-02f, 3.00452262e-02f, -1.17124327e-01f, -3.19774270e-01f, -1.15226477e-01f, -1.68020979e-01f, -4.43580270e-01f,
  -2.23575205e-01f, -1.08492449e-01f, -1.69549793e-01f, 1.77277714e-01f, 4.66614187e-01f, 9.36172716e-03f, 3.28796208e-01f, 1.01220734e-01f, 2.44185552e-01f, 3.41703109e-02f,
  2.95922846e-01f, 2.91664869e-01f, 4.22543257e-01f, 3.89114439e-01f, 1.80033997e-01f, 2.33029008e-01f, 2.00148076e-01f, 4.20816630e-01f, 3.96601021e-01f, 2.49394432e-01f,
  2.33473699e-03f, -2.80882478e-01f, 1.41353579e-03f, 1.80692896e-01f, -2.64148675e-02f, -1.02538519e-01f, 8.44414383e-02f, 1.02121858e-02f, 1.17835663e-01f, 6.54420778e-02f,
  -1.15930019e-02f, 6.85851201e-02f, 3.98732796e-02f, 5.89336753e-02f, 6.72708601e-02f, 7.28178620e-02f, 8.35888982e-02f, 4.81158532e-02f, 4.33535799e-02f, -2.01504365e-01f,
  -5.45573421e-03f, -4.75132428e-02f, -5.55438325e-02f, 5.25356308e-02f, 9.25998315e-02f, -2.73463074e-02f, 1.31606236e-02f, -1.42889712e-02f, -1.31722614e-02f, 2.49492824e-02f,
  -1.06293730e-01f, -5.78015298e-02f, 9.24843457e-03f, 1.39002949e-02f, -8.82143825e-02f, -3.20408344e-02f, -2.57950518e-02f, 1.91373788e-02f, 2.42113061e-02f, -6.55110478e-02f,
  2.79326010e-02f, -6.12970814e-02f, 1.06708370e-02f, -9.52480808e-02f, -1.32809252e-01f, -3.78621072e-02f, 5.84835000e-02f, 4.41226214e-02f, -4.33298610e-02f, -5.05245067e-02f,
  -2.29708459e-02f, 9.28068608e-02f, -7.49084260e-03f, 3.55265029e-02f, -5.79251535e-02f, -7.54002333e-02f, 2.92815100e-02f, -1.25726461e-01f, 3.02061252e-02f, 1.13953307e-01f,
  -5.26856035e-02f, 5.22267781e-02f, 3.62942442e-02f, 1.09376624e-01f, -1.68564878e-02f, -2.59860642e-02f, 1.69495970e-01f, 1.19934730e-01f, 5.75635172e-02f, 2.60779355e-02f,
  9.26440861e-03f, 8.07515830e-02f, -1.17116429e-01f, 4.39806357e-02f, 2.01764286e-01f, -1.50620624e-01f, -1.54737886e-02f, -3.44500355e-02f, -3.48290652e-02f, 1.55802414e-01f,
  -3.20386998e-02f, -2.49248985e-02f, -1.24849239e-03f, 5.07899597e-02f, -2.58047208e-02f, -8.88098627e-02f, -1.89058930e-01f, -5.16298749e-02f, 1.42533004e-01f, -6.16627857e-02f,
  5.73336482e-01f, -1.25305802e-01f, 3.36960882e-01f, 7.31263906e-02f, 9.51225460e-02f, 1.58297762e-01f, 2.30246142e-01f, -2.14400709e-01f, -2.20806792e-01f, -2.06162989e-01f,
  -1.16214082e-01f, 2.45210141e-01f, -5.04507385e-02f, 9.30756032e-02f, 4.99483570e-02f, -2.61322856e-01f, -5.62041588e-02f, -5.51347174e-02f, -3.44819054e-02f, 3.71203832e-02f,
  -2.59710625e-02f, -3.86215240e-01f, 4.26100045e-02f, -3.90779763e-01f, 3.61711085e-01f, 7.96707347e-02f, -3.15745533e-01f, 2.09018320e-01f, -1.68570206e-01f, 2.55701616e-02f,
  1.69787303e-01f, -1.60736755e-01f, 1.50639936e-01f, -1.47393597e-02f, 9.05021466e-03f, 1.16343610e-01f, 9.61708650e-02f, 1.32732213e-01f, -2.55932417e-02f, -4.72422550e-03f,
  1.03250526e-01f, 4.84206993e-03f, 1.48705924e-02f, 1.32184038e-02f, 7.59122223e-02f, -1.39073376e-02f, 5.38025461e-02f, 1.58926293e-01f, 3.75614725e-02f, 1.92785099e-01f,
  9.64062661e-02f, 2.11309910e-01f, 4.19116803e-02f, -1.59342214e-01f, -4.15707752e-02f, 5.40216975e-02f, 7.15254694e-02f, 1.11715645e-01f, -3.46469879e-02f, -4.83870618e-02f,
  -1.01347826e-01f, 1.80738177e-02f, -6.77871779e-02f, 1.38832431e-03f, 2.70019919e-02f, -7.36285672e-02f, 5.58730960e-02f, 5.24535961e-02f, 3.79026271e-02f, -4.80843112e-02f,
  -7.30515122e-02f, 3.51247862e-02f, -1.47334440e-02f, -5.86243272e-02f, 1.48300547e-02f, 9.46832970e-02f, 1.02505505e-01f, 1.91631168e-02f, -4.78413925e-02f, 1.29956052e-01f,
  -1.00484928e-02f, -1.37223557e-01f, -8.51127282e-02f, -1.50993858e-02f, 3.72567177e-02f, -1.01738863e-01f, -1.23115972e-01f, 8.68254527e-02f, -1.34465829e-01f, 8.43860507e-02f,
  -8.94522667e-02f, -3.36838812e-01f, -1.16571017e-01f, -2.79846159e-03f, -6.20422363e-02f, 1.76030070e-01f, 7.63936415e-02f, -6.84593199e-03f, -1.01334870e-01f, -9.76237133e-02f,
  -2.92708222e-02f, 2.41847453e-03f, 3.60908583e-02f, 1.18775025e-03f, -7.06685632e-02f, -9.25377160e-02f, -7.79398158e-02f, -5.87218478e-02f, -1.26370247e-02f, -5.16957380e-02f,
  4.57644016e-02f, -9.22906026e-02f, -7.95574207e-03f, -8.54811296e-02f, -9.82006788e-02f, 5.57221994e-02f, 5.28967902e-02f, -7.95066655e-02f, -7.89535418e-02f, -1.33253306e-01f,
  -5.90861797e-01f, 3.73920083e-01f, -1.10372245e-01f, -3.38627771e-02f, -1.17720813e-01f, 1.53889015e-01f, 1.94931045e-01f, -4.10180166e-02f, -1.32362902e-01f, 3.05042088e-01f,
  1.73430219e-01f, -1.09242991e-01f, 2.33326808e-01f, 3.05000514e-01f, -4.84419107e-01f, 3.66789460e-01f, 2.59764463e-01f, 1.64841071e-01f, -7.99961090e-02f, -1.24102503e-01f,
  -1.07490942e-01f, 1.14410073e-01f, 1.67593464e-01f, 1.04995951e-01f, 8.50950629e-02f, -2.13058263e-01f, -9.84330475e-02f, -1.24836847e-01f, 1.86840713e-01f, 4.89813797e-02f,
  -3.82079542e-01f, -3.90254885e-01f, -8.68530199e-02f, -7.72223473e-02f, -1.47888973e-01f, -6.79290146e-02f, -8.63982514e-02f, -7.07236901e-02f, -1.99280158e-02f, -7.69412145e-02f,
  1.34298075e-02f, -8.12624618e-02f, 8.29749852e-02f, -3.45631801e-02f, -3.31688719e-03f, 5.01979515e-02f, 2.14821786e-01f, 1.44485980e-01f, -1.25457940e-03f, 1.16247669e-01f,
  6.25890791e-02f, 1.71458088e-02f, 4.01743017e-02f, 7.64592811e-02f, 9.72041190e-02f, -2.95613371e-02f, -4.12346758e-02f, -2.37231143e-02f, -5.01732267e-02f, 3.74117866e-02f,
  -8.70848894e-02f, -5.90584204e-02f, -6.01991378e-02f, 1.97403021e-02f, -2.25244518e-02f, 1.02011800e-01f, 5.52700944e-02f, -6.19146265e-02f, 2.12159492e-02f, 1.37717292e-01f,
  3.11854202e-03f, -2.58881971e-02f, -3.73618789e-02f, -1.02338651e-02f, -3.05904541e-02f, -9.91169438e-02f, -6.70834482e-02f, 5.17709441e-02f, 8.10613111e-03f, -5.22915944e-02f,
  -1.61137450e-02f, 1.43762948e-02f, 1.17707849e-01f, 8.29565823e-02f, -1.58152673e-02f, 1.36971744e-02f, 6.55285418e-02f, 7.23014101e-02f, 5.82992435e-02f, -5.59399985e-02f,
  -4.94091421e-01f, -4.06354517e-01f, -1.26717821e-01f, -1.52194230e-02f, -1.67238980e-03f, 5.90329571e-03f, -3.17811221e-02f, -2.95145791e-02f, 9.91145521e-03f, -7.81477988e-02f,
  -3.82913016e-02f, 2.52064411e-02f, -9.06113312e-02f, 5.76912686e-02f, -6.14269525e-02f, 6.66264398e-03f, -1.32668942e-01f, -5.13694398e-02f, -1.61986575e-01f, -2.91884430e-02f,
  -4.87079434e-02f, -6.97708279e-02f, 2.77223829e-02f, 1.49535790e-01f, -1.28392838e-02f, 2.00099889e-02f, -1.28134653e-01f, 7.34539106e-02f, -8.13813657e-02f, 4.20856364e-02f,
  2.08784133e-01f, -1.22464612e-01f, -3.58524412e-01f, 3.02780330e-01f, 2.30111465e-01f, 4.20527041e-01f, 2.71357030e-01f, 1.33184046e-01f, 2.89983302e-01f, 1.68507397e-01f,
  5.48671424e-01f, -1.64211258e-01f, -7.10385367e-02f, 5.59218824e-01f, 1.17796607e-01f, 1.74413413e-01f, 4.14066017e-01f, 3.44434351e-01f, -9.97529030e-02f, 1.47729263e-01f,
  1.85713157e-01f, 3.53020906e-01f, -1.64053775e-03f, -2.81536847e-01f, 1.08095147e-01f, -3.65055442e-01f, -4.47179899e-02f, -4.56227809e-01f, 1.02111295e-01f, 7.15203758e-04f,
  2.63977218e-02f, -3.85831818e-02f, -1.50780171e-01f, -1.31296739e-01f, -2.42129639e-02f, -4.28260341e-02f, -1.94061518e-01f, -1.35083988e-01f, -1.68258399e-02f, 3.86544429e-02f,
  6.27704263e-02f, -7.39642456e-02f, 1.10781401e-01f, -8.29737335e-02f, -2.35578641e-02f, -3.80725116e-02f, 2.32897371e-01f, 1.24333918e-01f, 7.00898841e-03f, 2.77948659e-02f,
  -2.46764603e-03f, 1.03838049e-01f, 5.20252697e-02f, 2.65858658e-02f, 1.34373650e-01f, 1.08817361e-01f, -1.38650596e-01f, -5.59482947e-02f, 1.37145936e-01f, 2.00407184e-03f,
  -7.20541775e-02f, -1.58246279e-01f, -8.13826844e-02f, -5.67312464e-02f, 1.63598871e-03f, -6.01988286e-02f, 1.00676127e-01f, -1.33737819e-02f, -1.01976760e-01f, 2.34692786e-02f,
  1.41273439e-01f, 1.07573949e-01f, 8.84342846e-03f, 2.29684394e-02f, 1.09769173e-01f, -4.91897911e-02f, -3.16886045e-02f, 1.13291308e-01f, 6.72842562e-02f, 1.25739112e-01f,
  -9.52280089e-02f, 3.90760191e-02f, 3.32171395e-02f, -1.30887777e-02f, 3.00718192e-02f, -5.31982817e-02f, 1.53906187e-02f, 7.51702935e-02f, 1.60226747e-01f, -1.25493422e-01f,
  7.59898201e-02f, -3.03355992e-01f, -2.99711130e-03f, 2.45841257e-02f, -1.63340434e-01f, -5.81814572e-02f, -2.67743543e-02f, 7.08771423e-02f, -2.45487094e-01f, 3.62463966e-02f,
  1.14586605e-02f, 5.75346462e-02f, -2.20907852e-02f, 5.72806187e-02f, -7.21489415e-02f, 7.53879175e-02f, 5.99495322e-02f, -4.13439050e-02f, 7.20575824e-02f, -7.56717846e-02f,
  2.24139709e-02f, 5.64241596e-02f, -8.01195651e-02f, 8.02913979e-02f, 1.42551899e-01f, 3.04421298e-02f, 2.81470176e-03f, -8.43969658e-02f, 2.42840797e-02f, 4.30253632e-02f,
  -6.24505132e-02f, -4.03829515e-01f, -2.31180742e-01f, -1.23090342e-01f, 2.49580875e-01f, 1.22065738e-01f, -6.69681728e-02f, -1.15848176e-01f, -3.49023640e-01f, -2.04887152e-01f,
  -2.25167666e-02f, -2.30677411e-01f, -1.51513115e-01f, -2.25625828e-01f, 1.61548063e-01f, -2.88179338e-01f, -1.73491493e-01f, -1.33198455e-01f, -1.70527473e-01f, -1.86791644e-01f,
  -9.64882001e-02f, -1.04615390e-01f, -2.83058733e-01f, 1.07704803e-01f, 8.61078277e-02f, -2.56589018e-02f, 3.14730018e-01f, 1.55781806e-01f, 1.56047776e-01f, 5.17235287e-02f,
  -9.30108801e-02f, -2.36357257e-01f, -1.67431772e-01f, -5.70415556e-02f, 6.48400933e-03f, 6.15590736e-02f, 5.71749359e-02f, 1.59393642e-02f, 9.54467505e-02f, -1.63974717e-01f,
  1.48288876e-01f, 1.40807154e-02f, -4.05561030e-02f, 8.43992978e-02f, -1.74735561e-02f, 6.38281787e-03f, 5.27311899e-02f, -5.89574613e-02f, -1.10193245e-01f, -1.11778811e-01f,
  -2.14319661e-01f, 2.35119481e-02f, 4.38087583e-02f, -6.77333474e-02f, 3.53449136e-02f, 1.30373053e-02f, -9.51508358e-02f, 1.01353101e-01f, 4.00798507e-02f, -8.79661590e-02f,
  4.19923104e-02f, 4.11110464e-03f, -2.11753193e-02f, -1.22132339e-02f, -6.00290075e-02f, 1.51615173e-01f, 9.99600068e-02f, 9.53805223e-02f, 7.32113048e-02f, 1.04198582e-01f,
  1.42741501e-01f, 8.69900212e-02f, -4.19680923e-02f, -7.16132596e-02f, -1.17689550e-01f, -3.03646084e-02f, 5.57341576e-02f, 1.64792091e-02f, -4.55738418e-02f, 1.17997706e-01f,
  -4.80365865e-02f, -1.55622838e-02f, -6.88421279e-02f, 1.00744538e-01f, -7.79918134e-02f, 1.78188905e-02f, 3.22796851e-02f, -3.24531868e-02f, -3.22412774e-02f, 5.82112074e-02f,
  1.19142033e-01f, -1.57902226e-01f, -2.06681281e-01f, 7.55967423e-02f, -8.20910260e-02f, 1.61012769e-01f, -1.15843266e-01f, 3.52101475e-02f, -3.45103629e-02f, -7.67340213e-02f,
  1.19231030e-01f, 2.36275084e-02f, 4.35714610e-02f, 1.94952227e-02f, 6.91407733e-03f, -5.75268231e-02f, 9.33293179e-02f, 8.55152607e-02f, 4.82396744e-02f, 7.94083774e-02f,
  1.00604147e-01f, 1.55907264e-02f, 3.97246098e-03f, 8.18166956e-02f, 5.84609583e-02f, 1.51340470e-01f, 5.64812962e-03f, 3.71374898e-02f, 1.41010582e-01f, 1.65963394e-03f,
  -6.04519010e-01f, -2.74713457e-01f, 3.45697135e-01f, -3.51845354e-01f, -1.11140415e-01f, 3.92468274e-01f, 3.52439463e-01f, -4.34515066e-02f, -2.92157769e-01f, -1.76414937e-01f,
  3.98403853e-02f, -1.86862499e-01f, 3.34819824e-01f, 9.63953808e-02f, 3.91002119e-01f, 2.98498631e-01f, 6.06810637e-02f, 9.27193910e-02f, -6.34056851e-02f, -1.31632879e-01f,
  -2.12054495e-02f, -1.57420233e-01f, 3.18390459e-01f, -2.74831444e-01f, -9.92857292e-02f, -2.78775692e-01f, -1.58967488e-02f, 1.62425756e-01f, -5.12559824e-02f, 5.48071042e-02f,
  -2.09468335e-01f, -2.63784319e-01f, -1.26593947e-01f, 9.90785286e-02f, -4.18089852e-02f, 5.12613580e-02f, 4.57110927e-02f, 1.26267523e-01f, 6.66670548e-03f, -2.95932628e-02f,
  -6.17703274e-02f, 7.11076558e-02f, -1.92441389e-01f, 7.18866587e-02f, -8.60230997e-02f, -3.59225050e-02f, 3.50171886e-02f, 5.18853515e-02f, 8.25717598e-02f, 8.48327875e-02f,
  1.23534366e-01f, 5.26334867e-02f, 3.79212275e-02f, 4.97950427e-03f, 3.38260643e-02f, 3.41902189e-02f, 5.67123741e-02f, 7.81542584e-02f, -8.09395835e-02f, 1.18556377e-02f,
  8.23677052e-03f, 1.79082286e-02f, -6.67966604e-02f, -7.77819157e-02f, 4.97598685e-02f, 2.61554727e-04f, -4.64822501e-02f, -1.24645969e-02f, 4.71025147e-02f, 5.10195969e-03f,
  2.65187360e-02f, -6.80353343e-02f, -2.75291521e-02f, -2.72880029e-02f, -2.67833495e-03f, -1.10743448e-01f, 4.92924191e-02f, -6.99998215e-02f, 5.78511134e-02f, 3.70396823e-02f,
  -8.16347301e-02f, 1.08671049e-02f, 7.93718174e-02f, -8.47855699e-04f, 7.93997897e-05f, 7.20580593e-02f, -4.81864475e-02f, 7.38647059e-02f, 1.49693787e-02f, 3.87306362e-02f,
  -3.48909378e-01f, -4.30865258e-01f, -1.80653587e-01f, -1.30348071e-01f, -1.08980514e-01f, -1.14263833e-01f, -9.62065011e-02f, -1.09317996e-01f, -6.27533272e-02f, -5.50828204e-02f,
  -7.53409266e-02f, 9.99777112e-03f, -7.98171293e-03f, 2.81109586e-02f, 2.25894339e-02f, -1.53659889e-02f, -1.01133168e-01f, -4.18565162e-02f, -1.44535244e-01f, -7.26222396e-02f,
  -7.25534260e-02f, -4.40936908e-02f, 1.06152020e-01f, -5.52078560e-02f, -7.07047060e-02f, -2.23238263e-02f, -1.46879166e-01f, 1.70497205e-02f, 4.50544953e-02f, 7.89384730e-03f,
  -8.93609300e-02f, 1.47358522e-01f, -4.20734465e-01f, -4.60433029e-02f, -9.79125872e-02f, -4.28174995e-03f, 3.34646225e-01f, 2.99617592e-02f, 1.57702997e-01f, 3.66060853e-01f,
  2.07088917e-01f, 3.42086740e-02f, 3.54984134e-01f, 2.18884677e-01f, -6.28267467e-01f, 3.72251235e-02f, 5.19454740e-02f, 2.62040108e-01f, -1.23123519e-01f, 1.81394637e-01f,
  -1.28005609e-01f, 2.27406755e-01f, -1.89527676e-01f, 1.30952209e-01f, 8.60387273e-03f, -9.95233878e-02f, -1.39373019e-01f, 1.93179380e-02f, -1.31774247e-01f, -1.19985737e-01f,
  7.79484510e-02f, 3.93750519e-02f, -9.49685425e-02f, -6.15766123e-02f, 3.05672232e-02f, -3.15389186e-02f, 7.38049820e-02f, -1.89512283e-01f, -1.25769317e-01f, 1.09954886e-02f,
  1.26936063e-01f, -3.45192999e-02f, 3.58031094e-02f, -5.26879244e-02f, 9.46508870e-02f, -1.11105360e-01f, -8.09810534e-02f, -1.99488342e-01f, 5.89818060e-02f, 3.18455347e-03f,
  -4.36101817e-02f, -8.65025297e-02f, 4.60279882e-02f, -4.39274758e-02f, -1.77754730e-01f, 3.86498496e-02f, 1.79966781e-02f, -1.07437097e-01f, -7.49218687e-02f, -6.87199831e-02f,
  -8.20550695e-03f, 3.99131551e-02f, 9.18235481e-02f, 4.00140882e-02f, -7.10198358e-02f, -8.28078017e-03f, 9.02140215e-02f, 1.02805674e-01f, 2.69765574e-02f, 3.96840312e-02f,
  4.27825861e-02f, 3.32234241e-02f, 1.46284163e-01f, 7.06067532e-02f, -5.02550043e-02f, 1.05828919e-01f, -6.17509261e-02f, 1.18898898e-01f, -9.30757895e-02f, -6.45195916e-02f,
  2.54998952e-02f, 5.43670803e-02f, -2.45538261e-02f, 1.49663195e-01f, 1.09318674e-01f, 2.39495821e-02f, 1.30291834e-01f, -9.04806480e-02f, -4.18786295e-02f, -3.86074111e-02f,
  9.66082141e-02f, 2.74427384e-02f, -9.92647186e-03f, 3.52439471e-02f, 8.06169808e-02f, -3.44071463e-02f, 1.05106413e-01f, -9.02277529e-02f, -1.24173939e-01f, 1.14976577e-01f,
  -1.29601523e-01f, 2.06712529e-01f, 3.68422270e-02f, 1.78802311e-02f, 2.07939576e-02f, -7.90763423e-02f, 2.51064509e-01f, -5.00681959e-02f, -6.77103326e-02f, -7.37813935e-02f,
  1.60543583e-02f, 2.02863634e-01f, 6.21590205e-02f, 7.53793046e-02f, 5.66021129e-02f, 9.17568132e-02f, 8.94042999e-02f, -9.99352261e-02f, -1.37904719e-01f, -3.74231152e-02f,
  2.37892538e-01f, 3.03101689e-01f, 5.74439988e-02f, 1.14838079e-01f, -1.73831969e-01f, -2.48579547e-01f, -1.20971113e-01f, -2.88798481e-01f, 1.14157870e-01f, 2.57351667e-01f,
  -3.75617385e-01f, 4.83123332e-01f, -2.02069908e-01f, -2.96953410e-01f, -3.52775276e-01f, -3.55018049e-01f, -1.26228435e-02f, 1.99241787e-01f, 7.02543929e-02f, 9.97436121e-02f,
  -1.42535716e-01f, -3.32583904e-01f, -1.89668611e-01f, -1.91970080e-01f, 1.23917963e-02f, 2.78249651e-01f, -1.52977541e-01f, -1.87740147e-01f, 2.62668967e-01f, -8.36466104e-02f,
  -1.33152276e-01f, 5.11071384e-02f, 9.70814452e-02f, 4.34847102e-02f, 1.04406290e-02f, -2.24978179e-02f, 9.72973555e-02f, -1.89634431e-02f, -2.95316353e-02f, 6.46021292e-02f,
  1.11504152e-01f, 1.53557450e-01f, -3.22534405e-02f, -3.28514129e-02f, -8.73946305e-03f, -2.62519415e-03f, 5.19273058e-02f, 2.17826795e-02f, 7.65173063e-02f, 6.56853765e-02f,
  1.08936884e-01f, 4.23889905e-02f, 2.99333292e-03f, 1.70989066e-01f, -3.21995243e-02f, -1.68748852e-02f, 1.79201543e-01f, 7.17605203e-02f, 2.18699738e-01f, 1.18324466e-01f,
  5.56879267e-02f, 2.41668951e-02f, -3.55118550e-02f, 3.73763181e-02f, 4.70040664e-02f, 4.95663881e-02f, 6.94764256e-02f, -6.78022811e-03f, -1.88140068e-02f, 3.65436487e-02f,
  -1.70165896e-02f, 1.19738206e-01f, 1.40452981e-02f, 6.24155961e-02f, -7.71327391e-02f, -2.61134841e-02f, -9.62722898e-02f, 1.47286832e-01f, 2.24058796e-02f, -9.33494717e-02f,
  3.63181680e-02f, -1.87954120e-02f, 1.44389674e-01f, -5.10452613e-02f, -1.37474135e-01f, 7.31314532e-03f, 4.60589975e-02f, 5.56177460e-02f, -1.65579364e-01f, -4.19556014e-02f,
  2.60388535e-02f, 2.05369651e-01f, 1.26143731e-02f, 1.08319156e-01f, 3.88093032e-02f, 4.17691953e-02f, 3.18234898e-02f, 3.48124988e-02f, 6.97212219e-02f, -6.04960844e-02f,
  6.87481984e-02f, 1.25076234e-01f, 8.78989026e-02f, 4.44693081e-02f, 4.89719994e-02f, -2.01315179e-01f, -3.57362144e-02f, -4.47329454e-04f, 3.28927897e-02f, 2.51277760e-02f,
  8.00270215e-02f, 1.06545292e-01f, 1.77304838e-02f, 1.10887878e-01f, 3.29895243e-02f, 2.13929862e-02f, 1.76237285e-01f, 1.01139933e-01f, 2.57092714e-02f, 8.29431862e-02f,
  4.02048111e-01f, -1.08837053e-01f, -1.79844618e-01f, 4.04638015e-02f, -1.92221440e-02f, -1.67730153e-01f, -3.18873852e-01f, 1.04804799e-01f, -6.92568794e-02f, -2.14169025e-02f,
  1.35186911e-01f, 1.00536704e-01f, -1.91120684e-01f, 2.82295436e-01f, 5.50785601e-01f, -1.44395575e-01f, 3.93317223e-01f, 4.01107930e-02f, 3.35947350e-02f, 3.29404026e-01f,
  1.42587081e-01f, 3.39389473e-01f, 4.45598029e-02f, 1.75970420e-01f, 3.31684053e-01f, -5.63533157e-02f, 3.00894558e-01f, -2.09126487e-01f, 2.76424527e-01f, 8.15273896e-02f,
  -1.12378933e-01f, 1.76092520e-01f, -3.76308896e-02f, -4.84753363e-02f, -6.99101016e-02f, -8.58740062e-02f, -1.47712782e-01f, -8.95367488e-02f, -9.51322392e-02f, -6.61201775e-02f,
  -8.24208707e-02f, 3.24981920e-02f, 6.89598620e-02f, 2.49217041e-02f, 3.81715670e-02f, -2.36067572e-03f, -4.68141679e-03f, -1.13564573e-01f, -1.02124125e-01f, 1.35818245e-02f,
  -1.08029824e-04f, -8.81492272e-02f, 4.45325533e-03f, 1.10767018e-02f, 9.65338387e-03f, 1.44070357e-01f, -5.58676757e-02f, -1.24893792e-01f, 1.76623918e-03f, -2.62316782e-02f,
  1.66011199e-01f, -8.83290023e-02f, 1.97841646e-03f, -3.42741795e-02f, 1.06630595e-02f, -1.21803276e-01f, 1.04131691e-01f, 5.22050485e-02f, -7.47223645e-02f, -6.94079176e-02f,
  4.23422903e-02f, 5.75334998e-03f, 1.59393307e-02f, -4.03576121e-02f, 1.04627684e-01f, 2.77887471e-02f, 2.57399976e-02f, 1.07889930e-02f, -7.96801522e-02f, -9.55085736e-03f,
  -3.03191431e-02f, 5.56143671e-02f, -8.71844664e-02f, -4.73028794e-02f, 1.44057221e-05f, 1.43794632e-02f, 1.22776583e-01f, -2.02658549e-02f, -9.43248346e-02f, 9.94876400e-02f,
  1.05763540e-01f, 2.25898981e-01f, -6.38577063e-03f, -1.42731126e-02f, -6.95368573e-02f, -2.34807879e-02f, -2.85033267e-02f, 6.37040194e-03f, 9.44614857e-02f, -4.99164388e-02f,
  2.44688569e-03f, 4.50568981e-02f, 3.52682695e-02f, 6.46665022e-02f, 1.93628334e-02f, 9.11331400e-02f, 9.52197090e-02f, -3.16925696e-03f, 1.41505599e-01f, 9.54457745e-02f,
  1.88997351e-02f, 8.84344205e-02f, 8.96373838e-02f, -9.30525735e-02f, 8.27416703e-02f, 1.49858994e-02f, 1.60049573e-01f, 4.98347692e-02f, 7.21681416e-02f, -3.11742313e-02f,
  7.35011175e-02f, 1.31799802e-01f, -3.38775627e-02f, 2.74533391e-01f, -2.33150385e-02f, 1.84058934e-01f, 4.11701083e-01f, 1.68287233e-01f, 2.59301066e-01f, 5.96153922e-02f,
  2.78770551e-02f, 3.53689454e-02f, 1.08475916e-01f, 1.40409663e-01f, 3.08218062e-01f, 7.47885108e-02f, 4.28332955e-01f, 1.53187811e-01f, 1.27290770e-01f, 6.30934983e-02f,
  2.56761730e-01f, 1.62967771e-01f, -9.27904770e-02f, -3.93499136e-02f, 3.68974395e-02f, -1.40871972e-01f, 4.40511927e-02f, -2.15609729e-01f, -2.31547188e-03f, 1.41090527e-01f,
  6.39945716e-02f, 1.60744712e-01f, 1.41788926e-02f, 1.73188280e-02f, -9.69181582e-02f, -2.03294724e-01f, -5.35012260e-02f, -2.47790609e-02f, 3.37005630e-02f, -1.16132675e-02f,
  2.08516489e-03f, -4.25098650e-02f, 6.96571469e-02f, -2.75815949e-02f, -5.15440889e-02f, -1.84591085e-01f, -3.22121009e-02f, -9.80177000e-02f, -4.53245714e-02f, -5.83066009e-02f,
  -9.89817083e-02f, -3.53471711e-02f, 7.02431500e-02f, 1.16840489e-01f, 1.25159949e-01f, 1.00977518e-01f, 4.41903472e-02f, -6.92605823e-02f, -5.63501343e-02f, 1.40153900e-01f,
  5.06895371e-02f, 1.75000668e-01f, -8.02801922e-03f, -9.24126431e-02f, 5.02938870e-03f, -9.93131101e-02f, 4.32477482e-02f, -4.65004593e-02f, -1.91654544e-02f, -4.17530648e-02f,
  -9.88837406e-02f, -4.62313853e-02f, -4.25148383e-02f, 9.69962217e-03f, 1.05777614e-01f, -1.18774354e-01f, -1.96147170e-02f, -1.26048073e-01f, -1.63370054e-02f, -1.19202487e-01f,
  6.83514178e-02f, 1.16567023e-01f, -3.64230350e-02f, -1.24845766e-01f, 7.66521394e-02f, -6.79482445e-02f, 7.95428455e-02f, 7.12142065e-02f, 1.30628434e-03f, 5.78799434e-02f,
  1.77340880e-01f, 4.27053183e-01f, 2.70293821e-02f, -6.19299673e-02f, -4.34841439e-02f, 5.85355982e-03f, 4.86406460e-02f, 4.11796197e-02f, 9.49505568e-02f, 1.59657612e-01f,
  7.32204691e-02f, -6.05683811e-02f, -1.07942574e-01f, 2.46714894e-02f, -1.91789363e-02f, 9.74283442e-02f, 4.04148214e-02f, 6.06611669e-02f, 1.79896921e-01f, 1.68312751e-02f,
  -2.03724690e-02f, 2.59705335e-02f, 1.04481332e-01f, -5.53401224e-02f, 1.91182494e-02f, -2.88675390e-02f, 9.70965028e-02f, -1.57391243e-02f, -3.63696478e-02f, 7.02939183e-02f,
  2.44369179e-01f, 2.96260059e-01f, -4.60780859e-01f, -2.45652556e-01f, 1.93393722e-01f, 4.78944451e-01f, 2.65247315e-01f, 2.18860537e-01f, -1.19997516e-01f, 3.08967680e-01f,
  1.87209427e-01f, -1.09568812e-01f, 2.11951882e-01f, -1.03319146e-01f, 4.53692153e-02f, -4.84179147e-02f, 9.54162776e-02f, 2.15749532e-01f, -1.66919082e-01f, 1.63273811e-01f,
  -9.75912961e-04f, 3.44914407e-01f, -3.75808150e-01f, 1.87657192e-01f, 5.13034239e-02f, -2.31630698e-01f, -3.75028066e-02f, -1.41250327e-01f, -8.19382295e-02f, 9.76750180e-02f,
  1.51666533e-02f, -7.50301108e-02f, -8.09347257e-02f, -1.71778947e-01f, -1.41046643e-02f, 9.14398730e-02f, -9.61977467e-02f, 8.33411962e-02f, -5.94969206e-02f, 2.32409798e-02f,
  2.58287489e-01f, -1.33337164e-02f, 2.84046456e-02f, 9.24980326e-04f, 1.09013781e-01f, 8.73482041e-03f, -4.08344381e-02f, -1.96868014e-02f, -4.75962237e-02f, 1.67600941e-02f,
  -7.79168904e-02f, -2.73223780e-02f, 4.71634455e-02f, -6.53388500e-02f, 2.78711878e-02f, -8.91149119e-02f, -9.26883742e-02f, 1.21082701e-02f, 1.30510449e-01f, 8.37391242e-02f,
  4.39331532e-02f, 1.17199466e-01f, 1.17491391e-02f, -1.62229538e-01f, 1.49170801e-01f, 1.54388938e-02f, 2.79577952e-02f, -1.36583537e-01f, -7.38453679e-03f, 6.52213022e-02f,
  -9.76926833e-02f, -7.30351061e-02f, 2.98962854e-02f, 6.43974692e-02f, 7.59206200e-03f, -4.60648537e-02f, 9.03720185e-02f, 6.25702273e-03f, -6.61459714e-02f, -3.23600811e-03f,
  -8.54823962e-02f, 1.12047531e-01f, 7.66113326e-02f, -3.65703553e-02f, 2.14333255e-02f, -8.05346761e-03f, 6.65075257e-02f, -8.67984667e-02f, -3.71939130e-02f, 1.42501295e-01f,
  7.09251389e-02f, 2.51058012e-01f, -2.27171965e-02f, -1.03891850e-01f, 8.79961706e-04f, 2.06202462e-01f, 2.03199610e-02f, 4.55068834e-02f, 1.23584841e-03f, 1.61890566e-01f,
  1.96071237e-01f, -2.93088406e-02f, 1.34434983e-01f, -6.45816326e-02f, -8.16232059e-03f, 2.05074385e-01f, 1.33748487e-01f, -3.99621613e-02f, 5.77689260e-02f, 1.24530874e-01f,
  -3.68685387e-02f, 1.31169081e-01f, 1.07428521e-01f, 6.97385743e-02f, 6.94799572e-02f, -5.02583086e-02f, 1.39827520e-01f, -3.97442318e-02f, 1.21682830e-01f, -6.92001581e-02f,
  2.18801811e-01f, -2.94646442e-01f, -2.45245412e-01f, 9.31916684e-02f, 2.33099088e-02f, -1.79220103e-02f, -2.89431363e-02f, 3.20324041e-02f, -4.18274552e-01f, -1.31668791e-01f,
  2.87989557e-01f, 1.30649209e-01f, -1.85008153e-01f, 3.82643044e-01f, 4.79007572e-01f, -6.83028698e-02f, 2.38839865e-01f, 2.69574672e-01f, -1.10847525e-01f, -1.85778458e-02f,
  1.14222974e-01f, 4.10001099e-01f, 9.88063365e-02f, 1.06952511e-01f, 1.90497890e-01f, 1.51306214e-02f, 2.84884840e-01f, -3.86929810e-02f, 3.41524392e-01f, 2.60924250e-01f,
  4.28694375e-02f, -3.20876911e-02f, 6.47000130e-03f, -5.06841429e-02f, 1.86003875e-02f, -3.61687317e-02f, -3.70334201e-02f, 2.97933191e-01f, 6.01617470e-02f, -4.56916094e-02f,
  9.88813192e-02f, 1.31443992e-01f, 9.80983600e-02f, 2.51631569e-02f, -6.09179735e-02f, -1.00981846e-01f, -8.26332793e-02f, -5.70197701e-02f, -5.78083396e-02f, -5.69661744e-02f,
  -1.43818513e-01f, 5.61638512e-02f, 8.63207355e-02f, 6.05778657e-02f, -1.26727462e-01f, -1.06609546e-01f, -3.44924666e-02f, -3.81468944e-02f, 7.33193532e-02f, 2.46366449e-02f,
  1.00542605e-01f, -6.64625466e-02f, -2.56255381e-02f, 2.58888714e-02f, -5.14109023e-02f, -1.42073426e-02f, 2.64768880e-02f, 2.87677348e-02f, 2.01084632e-02f, -6.47269934e-02f,
  -8.45993012e-02f, -1.15878892e-03f, 6.53192997e-02f, 6.66073011e-03f, 2.73529552e-02f, 3.05540091e-03f, -1.81507245e-02f, 1.00548029e-01f, -2.24908099e-01f, 3.52689959e-02f,
  9.74982679e-02f, 2.93930862e-02f, -5.71635962e-02f, 3.13397795e-02f, -2.90848482e-02f, -7.22090974e-02f, 9.06519685e-03f, -4.75691147e-02f, 2.56468114e-02f, 2.16408484e-02f,
  4.11369726e-02f, 1.37889814e-02f, -8.58150274e-02f, 9.27462243e-03f, -7.72363693e-02f, 1.39022162e-02f, 4.48740162e-02f, 2.41534300e-02f, 1.08970799e-01f, 1.44216139e-02f,
  9.52196717e-02f, -1.32397525e-02f, 1.68507540e-04f, 4.38384674e-02f, 1.12010673e-01f, -1.21975943e-01f, -7.31367916e-02f, 1.68477502e-02f, -2.75948588e-02f, 1.27190322e-01f,
  -2.45217048e-02f, 2.96765175e-02f, 9.53162983e-02f, -1.01416096e-01f, -4.09079120e-02f, 2.72000413e-02f, -5.49498014e-02f, 3.30451727e-02f, 1.13757394e-01f, 1.22187719e-01f,
  2.24240586e-01f, -1.17749237e-01f, 3.86478335e-01f, 2.78091785e-02f, 1.88858286e-01f, 4.08067971e-01f, 3.73440593e-01f, 2.44177997e-01f, 2.83241093e-01f, -2.09722459e-01f,
  -3.10653597e-01f, -1.15236245e-01f, -2.20779032e-02f, -2.83764303e-01f, 4.63364154e-01f, 2.64577568e-01f, 1.34223774e-02f, -2.21313268e-01f, -1.05105594e-01f, -1.26168966e-01f,
  -1.69952605e-02f, -3.85357261e-01f, -1.61096349e-01f, -3.26696277e-01f, -3.12366247e-01f, -2.08245337e-01f, -4.53185886e-01f, 2.39765402e-02f, -2.20836133e-01f, -2.20720340e-02f,
  7.85615742e-02f, -1.28819674e-01f, -3.80151527e-04f, -6.90731257e-02f, -8.37308615e-02f, 1.14812054e-01f, 5.21468446e-02f, 4.79049496e-02f, -1.82380583e-02f, -1.29542872e-02f,
  -9.74057317e-02f, -1.32030640e-02f, 1.17315007e-02f, 6.59165606e-02f, -4.06293087e-02f, -6.50074892e-03f, -8.41521472e-02f, -9.05393809e-02f, -1.43837988e-01f, 7.51273707e-02f,
  2.74441894e-02f, -5.86104318e-02f, 1.40424082e-02f, -1.25198051e-01f, -3.15830782e-02f, -1.28128171e-01f, 6.40206933e-02f, 6.67533875e-02f, 8.25305730e-02f, -4.31586206e-02f,
  -1.02115721e-01f, 1.54374257e-01f, 2.61212345e-02f, 7.43300617e-02f, 2.34137867e-02f, -5.29609323e-02f, -1.01118395e-02f, 5.40354252e-02f, 7.69289210e-02f, 4.40613702e-02f,
  -4.58800383e-02f, 7.40577504e-02f, 3.64083834e-02f, 1.18490256e-01f, -1.38295218e-01f, 4.57792431e-02f, 1.99360237e-03f, 1.37913600e-01f, -5.11360988e-02f, -9.16539356e-02f,
  2.53278296e-02f, 9.61735286e-03f, -1.07852720e-01f, -4.52221483e-02f, 6.32228330e-02f, 5.17521345e-04f, -1.23344451e-01f, 5.98126948e-02f, -1.64986715e-01f, -8.43935981e-02f,
  1.42680466e-01f, -1.53588921e-01f, -1.29469797e-01f, -9.99854878e-02f, 5.82580715e-02f, -9.17394981e-02f, 1.00025855e-01f, 1.16091162e-01f, 1.61488689e-02f, 5.31135909e-02f,
  -1.06278971e-01f, -6.89623654e-02f, -1.33996770e-01f, 1.61995575e-01f, 1.23905055e-02f, -3.07015907e-02f, -4.26049754e-02f, -1.34999797e-01f, -8.20006616e-03f, -1.29640354e-02f,
  -1.55855626e-01f, -6.59395903e-02f, 4.14134655e-03f, -2.38104731e-01f, -1.41356274e-01f, -1.06526904e-01f, 1.02843098e-01f, 5.94471544e-02f, -4.52118516e-02f, -7.31463507e-02f,
  -5.79071343e-01f, 6.27491593e-01f, 3.42918217e-01f, -1.65313691e-01f, 1.17247790e-01f, -1.69345900e-01f, -1.39990196e-01f, 2.10115224e-01f, 6.03292324e-02f, 2.47947305e-01f,
  8.08775425e-02f, 1.95554972e-01f, 2.13524073e-01f, 1.68610364e-01f, -3.46033573e-01f, -6.12058602e-02f, -1.09512612e-01f, -5.30306958e-02f, -9.80819296e-03f, -1.67513177e-01f,
  -8.38699490e-02f, -3.15859467e-02f, -3.60732637e-02f, 2.56286323e-01f, 1.53120428e-01f, 5.88011742e-02f, -2.66486079e-01f, 2.69531935e-01f, 5.87165058e-02f, 1.13591924e-01f,
  -5.15307248e-01f, -2.73078322e-01f, -1.25186384e-01f, -9.23476815e-02f, -2.13176474e-01f, -2.25885063e-01f, -8.78869668e-02f, -2.11509913e-02f, -2.30193194e-02f, -4.58290689e-02f,
  -3.46869081e-02f, 1.31869853e-01f, -2.83233766e-02f, 5.34924865e-02f, 5.77847881e-04f, 5.83840683e-02f, 6.10802248e-02f, 2.47895997e-03f, 1.83334544e-01f, 2.21269834e-03f,
  1.83173269e-01f, 1.25590459e-01f, -8.96862894e-02f, -1.05092801e-01f, -1.67520400e-02f, 7.69100189e-02f, -5.28471284e-02f, -3.54172811e-02f, 6.40094653e-02f, -2.37173196e-02f,
  -2.53890455e-02f, -8.32637548e-02f, -1.03201335e-02f, -7.14131771e-03f, -3.30400094e-02f, 1.03828385e-01f, 6.95981979e-02f, -3.14171165e-02f, 1.03312591e-02f, -7.82231838e-02f,
  3.03159840e-02f, -1.34033496e-02f, -1.24023288e-01f, -1.33055001e-01f, -4.21574116e-02f, -6.25275895e-02f, -6.94281831e-02f, 3.38080376e-02f, -3.48369218e-02f, -5.81797697e-02f,
  -3.76659632e-02f, -1.09213255e-02f, 3.95969525e-02f, 4.08837348e-02f, -4.81574945e-02f, -6.88553303e-02f, -1.34100011e-02f, 4.70813513e-02f, -9.78814811e-02f, -1.56140804e-01f,
  -5.41945994e-01f, -4.09581125e-01f, -1.59857646e-01f, 1.76900793e-02f, 5.81693947e-02f, -9.56840143e-02f, -5.35273217e-02f, 9.30589798e-04f, -1.98800296e-01f, -5.86664230e-02f,
  1.84670016e-02f, 3.28183100e-02f, -5.11672609e-02f, -2.83295792e-02f, 1.12638634e-03f, -1.01069488e-01f, -6.30083382e-02f, -4.28675264e-02f, -1.88182443e-01f, 6.36091130e-03f,
  8.61935541e-02f, -3.39384265e-02f, -1.28920197e-01f, -1.03398986e-01f, -8.38210881e-02f, -1.04870893e-01f, -1.32904798e-01f, 6.92429766e-02f, -1.04844294e-01f, 8.60690847e-02f,
  -3.23917836e-01f, 2.89198965e-01f, -2.07188487e-01f, -1.66397199e-01f, -1.78545237e-01f, -4.34453547e-01f, -2.67049164e-01f, 3.43569517e-02f, 5.80786094e-02f, 1.56305119e-01f,
  2.22126454e-01f, -9.27624255e-02f, 2.32452214e-01f, -1.76197022e-01f, -3.39118242e-01f, 9.21009257e-02f, -2.68013537e-01f, -1.24016240e-01f, -5.76532306e-03f, -1.26159415e-01f,
  -1.14548996e-01f, -1.21005205e-02f, -1.24989469e-02f, 1.26820460e-01f, -1.99022561e-01f, 1.37433335e-01f, 2.28556529e-01f, 2.04854444e-01f, -1.08016178e-01f, -1.53411822e-02f,
  -2.06687972e-01f, 1.60107329e-01f, 7.37138093e-02f, -1.58403352e-01f, -2.11090848e-01f, -7.00276494e-02f, -8.53297636e-02f, 1.66060384e-02f, 2.13721804e-02f, -8.71992186e-02f,
  -6.33317456e-02f, 2.85260845e-02f, -1.23523911e-02f, 9.06750038e-02f, -8.92608892e-03f, 7.06706271e-02f, -9.45627689e-02f, -5.27779348e-02f, -5.33680469e-02f, -1.42547861e-01f,
  7.75880471e-04f, -5.97908609e-02f, -1.10361531e-01f, 2.49615707e-03f, -1.45542659e-02f, -2.08677128e-02f, -1.35555506e-01f, -1.07020155e-01f, -2.34934967e-02f, 5.24631888e-02f,
  -8.61595571e-02f, 6.56309258e-03f, -9.23108160e-02f, 1.32324755e-01f, 6.50877953e-02f, 1.91693213e-02f, 7.62778148e-02f, 1.61486585e-02f, 2.41065938e-02f, -8.16544238e-03f,
  -6.78482056e-02f, 5.73277660e-02f, 7.59418448e-03f, -1.51568800e-01f, -9.89983603e-02f, 1.85254253e-02f, -1.44872382e-01f, -1.79484952e-02f, -3.01624555e-02f, -3.15042548e-02f,
  1.60477877e-01f, -1.08993016e-01f, 5.19729406e-02f, -4.24022507e-03f, -6.82214350e-02f, 5.65803014e-02f, 2.50688214e-02f, -2.39973702e-02f, 2.85297763e-02f, -7.63247237e-02f,
  -2.43338957e-01f, 1.18840955e-01f, 8.06806684e-02f, 8.95423442e-03f, 9.60310549e-02f, -5.18091694e-02f, 2.12344732e-02f, 4.93692495e-02f, 9.81609672e-02f, -1.39195984e-02f,
  -1.41366079e-01f, -8.76596048e-02f, -5.19198328e-02f, -1.16495416e-02f, -5.61534353e-02f, -8.64456818e-02f, -9.06131882e-03f, 1.10604772e-02f, -1.79431569e-02f, 8.80185366e-02f,
  2.09670868e-02f, -3.63431461e-02f, 2.82212235e-02f, -5.21886796e-02f, 7.16461241e-02f, 1.16116807e-01f, -4.16432321e-03f, -6.96169073e-03f, 4.67425436e-02f, -6.12331694e-03f,
  -6.84371531e-01f, -7.07653686e-02f, 3.93185675e-01f, -4.79924023e-01f, -6.85659721e-02f, 2.93223500e-01f, 3.83752584e-01f, -1.45432055e-01f, -2.98079789e-01f, 2.25584377e-02f,
  6.42609522e-02f, -2.06583098e-01f, 2.56200165e-01f, -4.91649881e-02f, 1.68354586e-01f, 3.94685805e-01f, -7.25646988e-02f, 8.71286467e-02f, 9.02388536e-04f, -1.84289530e-01f,
  -4.85772006e-02f, -1.71539903e-01f, 3.63797307e-01f, -1.25888705e-01f, -2.66448632e-02f, -2.19585925e-01f, -5.54660447e-02f, 1.37789235e-01f, -5.73662184e-02f, 9.03618038e-02f,
  -8.33898261e-02f, -3.28628033e-01f, 1.12386927e-01f, 2.35753339e-02f, 2.75547318e-02f, -2.42415275e-02f, 8.16598460e-02f, 1.60532236e-01f, -1.06342897e-01f, -2.89895013e-02f,
  2.10873522e-02f, -2.58308146e-02f, -1.98123157e-01f, -4.88880426e-02f, -1.43076673e-01f, -4.66148220e-02f, 1.20043442e-01f, -1.91478152e-02f, 3.98930945e-02f, 1.62432566e-01f,
  1.60789579e-01f, 1.53968083e-02f, 1.01131119e-01f, 4.57520001e-02f, 1.04589481e-02f, -4.68863435e-02f, 1.68035090e-01f, 1.47270728e-02f, -3.43336090e-02f, -9.90503728e-02f,
  7.26310760e-02f, 4.65872586e-02f, 1.49082571e-01f, -3.19291092e-02f, -1.99725991e-03f, -5.88551862e-03f, 7.22528845e-02f, -2.21703555e-02f, -6.47244453e-02f, 1.44052859e-02f,
  -3.94113734e-02f, 4.91081853e-04f, -4.85949405e-02f, -1.58281028e-02f, 2.31614597e-02f, -1.32314712e-02f, 9.88545418e-02f, 9.53917392e-03f, -2.90842019e-02f, -7.56735951e-02f,
  2.47789584e-02f, -4.03322764e-02f, 5.25660217e-02f, 1.24836124e-01f, 1.20423175e-01f, -6.84453757e-04f, 9.68504537e-05f, 3.52619328e-02f, -7.37454072e-02f, 4.97370064e-02f,
  -1.79925039e-01f, -4.47606444e-01f, 3.51184346e-02f, -2.94348393e-02f, 4.65402640e-02f, 1.54403904e-02f, -4.98396792e-02f, -1.13138869e-01f, -1.22855663e-01f, -7.39570558e-02f,
  -8.41757059e-02f, 3.81437168e-02f, -6.95161074e-02f, -1.45854726e-02f, -2.49131786e-04f, 7.54797012e-02f, -2.17343364e-02f, -8.52522254e-03f, -5.71377799e-02f, -1.61212802e-01f,
  -6.93046749e-02f, -5.13756052e-02f, 4.32782881e-02f, -8.30121338e-02f, 2.46473178e-02f, -3.67811657e-02f, -1.61917001e-01f, -6.62274212e-02f, -5.92244081e-02f, -4.41017039e-02f,
  -1.60344876e-02f, 1.72653809e-01f, -3.42478603e-01f, -3.74388508e-02f, -1.19745649e-01f, 3.06143641e-01f, 2.51730084e-01f, -2.92147603e-02f, -1.16966665e-01f, 3.73420268e-01f,
  3.16649288e-01f, -2.14984685e-01f, 1.85441181e-01f, 1.16538495e-01f, -3.68925899e-01f, 2.77713597e-01f, 2.95008570e-01f, 2.00888187e-01f, -4.12976965e-02f, 2.51584947e-01f,
  -1.48363203e-01f, 3.18617851e-01f, -1.98982313e-01f, 9.09823179e-02f, 8.57573599e-02f, -1.60433605e-01f, 5.31335920e-02f, -1.15176283e-01f, 8.16581845e-02f, -8.10151324e-02f,
  1.03640214e-01f, -4.55591939e-02f, -3.57401371e-02f, 8.00044835e-03f, 1.11176409e-01f, 1.25762194e-01f, 8.38782266e-02f, -7.49986321e-02f, -1.66648269e-01f, -1.81559734e-02f,
  8.52981731e-02f, -4.83409092e-02f, 8.01907033e-02f, -1.46060362e-01f, -1.00173764e-01f, -6.53237924e-02f, -9.97178331e-02f, -3.83904763e-02f, -6.63412437e-02f, -1.43790478e-02f,
  -6.72143549e-02f, -6.15717545e-02f, -3.62476259e-02f, -7.20032379e-02f, -7.10988194e-02f, -5.19981980e-02f, -1.90335028e-02f, -4.55850288e-02f, 2.52262112e-02f, 1.66062992e-02f,
  -1.34729613e-02f, 1.13345742e-01f, 8.02850500e-02f, 1.01467587e-01f, -6.40073791e-02f, 5.80890886e-02f, -1.39347529e-02f, -8.04483052e-03f, 3.53018194e-02f, 9.46383327e-02f,
  3.32711786e-02f, -1.00609653e-01f, -8.75139702e-03f, -1.78995579e-02f, 5.46032116e-02f, -6.24229498e-02f, -7.65193778e-04f, 8.10854360e-02f, 1.01277404e-01f, -6.36308044e-02f,
  -2.75509804e-02f, 7.21617118e-02f, 9.87081081e-02f, -4.32049520e-02f, 1.14926159e-01f, -1.18735798e-01f, 1.08477451e-01f, -4.28467691e-02f, 5.31664938e-02f, -9.36087668e-02f,
  8.85127559e-02f, 1.08374223e-01f, 5.93147092e-02f, -5.18987291e-02f, -9.07616392e-02f, 1.30418271e-01f, 5.84402494e-02f, -2.63473596e-02f, -5.38430586e-02f, 6.29550591e-02f,
  1.50946602e-02f, -1.78511608e-02f, 1.17129944e-01f, -1.65975496e-01f, -6.77894875e-02f, 1.86622187e-01f, 3.71723734e-02f, -1.24455951e-01f, -1.67597376e-03f, -1.01239458e-01f,
  8.93127173e-03f, 1.19296946e-01f, -2.31504347e-02f, -6.77796379e-02f, -1.65433791e-02f, 1.28780559e-01f, 1.00613065e-01f, -1.44236237e-02f, 5.40305786e-02f, -1.05556801e-01f,
  -8.50404277e-02f, -3.83640766e-01f, -3.64102811e-01f, -2.08148256e-01f, 1.01878621e-01f, 2.97490448e-01f, -1.48466468e-01f, -4.66713272e-02f, -3.56064767e-01f, 1.45034879e-01f,
  2.47710034e-01f, -4.18704748e-01f, -3.35341960e-01f, 1.58173889e-01f, -5.62238954e-02f, -2.52191871e-01f, 2.23518342e-01f, 1.51855171e-01f, -1.43997073e-01f, 4.79261158e-03f,
  -1.79777890e-02f, 2.20051751e-01f, -1.76941305e-01f, 1.50104135e-01f, 1.58335611e-01f, -1.40472099e-01f, 2.75838703e-01f, -2.01709405e-01f, 2.40053341e-01f, 1.49211407e-01f,
  2.52066106e-01f, -5.27778603e-02f, 1.95992030e-02f, -4.48187217e-02f, 2.15611547e-01f, 1.50550097e-01f, 1.63820580e-01f, -8.63493681e-02f, -7.36508220e-02f, -7.80992582e-02f,
  -6.14002021e-03f, -1.45008147e-01f, -1.62359685e-01f, -3.35640237e-02f, 7.12171420e-02f, 1.61697343e-02f, -9.58418846e-02f, -6.30558133e-02f, -8.38439316e-02f, -2.95812726e-01f,
  -1.58454642e-01f, -1.16579741e-01f, 7.32929958e-03f, -4.61608395e-02f, -1.94860443e-01f, -1.51564732e-01f, -3.96438912e-02f, -8.46730992e-02f, -2.31201779e-02f, 4.35182033e-03f,
  1.28157046e-02f, 3.47283408e-02f, 2.09692903e-02f, -2.19704979e-03f, 1.09786868e-01f, 3.58074047e-02f, 4.25475277e-02f, -1.04429079e-02f, -1.04499936e-01f, 9.18185413e-02f,
  7.24354908e-02f, -1.62408367e-01f, -2.00485475e-02f, 9.98819545e-02f, 8.01777989e-02f, 7.21990913e-02f, -4.08539549e-02f, 2.08263956e-02f, -4.04485948e-02f, 1.11191943e-01f,
  -3.40819061e-02f, 4.61647920e-02f, -1.19449422e-02f, 6.62795007e-02f, -9.80359223e-03f, -1.37677953e-01f, 1.01141177e-01f, 2.32163798e-02f, -1.38864852e-02f, 1.39358521e-01f,
  2.38248974e-01f, -1.58092916e-01f, -8.56109336e-02f, 1.05854377e-01f, -3.19495015e-02f, 1.48572847e-01f, 3.97470361e-03f, -1.30984455e-01f, 6.72409981e-02f, -3.81109528e-02f,
  2.65041552e-02f, 7.92655274e-02f, 4.34376299e-02f, 3.95066850e-02f, 5.28564379e-02f, -4.02954929e-02f, -9.65337455e-03f, 4.14466634e-02f, 1.08138099e-01f, 6.17864868e-03f,
  5.66160232e-02f, 5.41133471e-02f, -1.59357592e-01f, -4.23323549e-02f, 1.84003618e-02f, 4.61724512e-02f, -4.94122431e-02f, -2.30884328e-02f, 8.74802470e-02f, -8.43319297e-02f,
  3.31034571e-01f, -3.20476800e-01f, 2.35866889e-01f, 3.18427622e-01f, 1.15701266e-01f, 1.57489553e-01f, 2.72232652e-01f, -7.36892410e-03f, 4.02662963e-01f, -3.66779596e-01f,
  -2.48466551e-01f, -4.37436327e-02f, 1.22475773e-01f, -2.65420198e-01f, 4.16323513e-01f, 2.58650303e-01f, -5.94633602e-05f, -9.19159874e-03f, 1.23533942e-01f, -1.96619481e-01f,
  -7.76746348e-02f, -3.76307398e-01f, 2.62772106e-02f, -3.86162788e-01f, -3.27408582e-01f, -1.19140670e-01f, -1.99981943e-01f, -3.14754285e-02f, -3.25077355e-01f, 8.04144144e-02f,
  -6.61423150e-03f, -3.36305983e-02f, -4.33860272e-02f, -2.36910619e-02f, -5.15089333e-02f, -1.25982175e-02f, 1.33631051e-01f, 9.91003439e-02f, 1.89141825e-01f, 1.32775962e-01f,
  -6.99431002e-02f, 2.66339630e-02f, -1.05782077e-01f, 5.13667203e-02f, 7.73485303e-02f, 3.11160032e-02f, -5.87353669e-03f, -9.55674946e-02f, -4.63765487e-02f, -4.55451984e-04f,
  1.28612116e-01f, -3.33983265e-02f, -5.23085557e-02f, -4.65840697e-02f, -2.34143361e-02f, 4.84997891e-02f, 1.43529713e-01f, 6.08785562e-02f, 4.93742488e-02f, 1.01503991e-01f,
  -1.38590783e-01f, 2.30360404e-02f, 2.10488681e-02f, 1.02174177e-03f, -2.83316313e-03f, 2.57045478e-02f, 5.05308919e-02f, -3.91478986e-02f, 2.28203572e-02f, -1.62124056e-02f,
  1.07552104e-01f, 5.85579500e-02f, 9.74763185e-02f, 1.57548890e-01f, -5.09416088e-02f, -2.81578880e-02f, 7.34940497e-03f, -2.32142322e-02f, -2.35591345e-02f, -1.20940410e-01f,
  -6.59554824e-02f, 1.08631231e-01f, 2.86534410e-02f, 1.49488434e-01f, -8.50308985e-02f, 1.22730017e-01f, -1.42924026e-01f, -9.92100872e-03f, 8.57420545e-03f, -6.30820841e-02f,
  -1.50164664e-01f, -3.20578575e-01f, -1.72648117e-01f, -1.44099101e-01f, -5.63242808e-02f, -1.81527480e-01f, 8.70778784e-02f, -6.00551777e-02f, -5.87152280e-02f, -5.81377074e-02f,
  -2.95811687e-02f, -3.16129019e-03f, 6.19452037e-02f, 1.60580397e-01f, -3.90624851e-02f, 1.27612520e-03f, -6.27875626e-02f, -1.89826801e-01f, -1.15654051e-01f, -5.36670350e-02f,
  -6.75744936e-02f, 8.58695507e-02f, 5.81219159e-02f, -8.69390368e-02f, -1.07971244e-01f, -6.44478276e-02f, -5.62504306e-02f, -5.58684487e-03f, 1.06497243e-01f, -6.90041203e-03f,
  -7.92155385e-01f, 3.94238800e-01f, 9.74576250e-02f, -4.58470196e-01f, 2.85508692e-01f, 6.86721802e-02f, -4.61153626e-01f, 2.57576644e-01f, -1.26630468e-02f, -4.72823530e-02f,
  -1.74858719e-01f, 1.54057592e-02f, 2.38851339e-01f, -2.54424185e-01f, -2.22989962e-01f, -3.11081554e-03f, -2.49920279e-01f, -2.73104548e-01f, 1.09552309e-01f, -8.28367397e-02f,
  -5.41359335e-02f, -2.08831057e-01f, -1.82965755e-01f, 3.45171601e-01f, -1.33558139e-01f, -9.39844921e-02f, -3.08918297e-01f, 3.38960648e-01f, -1.92751303e-01f, 1.89966649e-01f,
  -4.67975825e-01f, -1.43717200e-01f, -1.23368293e-01f, 6.88100085e-02f, -8.88245329e-02f, -5.09960838e-02f, -2.41930056e-02f, 2.07868032e-02f, 7.19037801e-02f, 1.53114319e-01f,
  -1.05884559e-01f, 1.37305692e-01f, 6.98125213e-02f, 6.94022626e-02f, 1.44839929e-02f, 1.01749353e-01f, 7.97442123e-02f, -6.99387565e-02f, -2.00707950e-02f, 1.38144404e-01f,
  -2.42280997e-02f, -4.70525995e-02f, -9.90147069e-02f, -7.30239525e-02f, 1.25654444e-01f, 8.88239313e-03f, -2.03954484e-02f, -2.09677313e-02f, 1.00115295e-02f, -2.24704184e-02f,
  8.04310068e-02f, 9.87720639e-02f, 2.11672988e-02f, -4.40764204e-02f, -6.71497136e-02f, 9.83918309e-02f, 9.06613618e-02f, -9.62851420e-02f, 6.16285503e-02f, -8.02116320e-02f,
  -1.20803975e-01f, -5.74735813e-02f, -2.30183508e-02f, -1.19339623e-01f, 8.93720053e-03f, -4.22907695e-02f, -6.10402673e-02f, 2.30949167e-02f, -6.34248331e-02f, -7.45311677e-02f,
  4.29229960e-02f, -4.27732952e-02f, 3.13614383e-02f, 3.51536237e-02f, 8.53911415e-02f, 7.27482140e-02f, 8.00278559e-02f, -1.38666153e-01f, 1.02367856e-01f, -2.42853519e-02f,
  -5.78419507e-01f, -4.21141535e-01f, -7.53332227e-02f, -8.33642483e-02f, 1.06756739e-01f, 9.38041285e-02f, 2.52269395e-02f, 9.62710232e-02f, 8.32573103e-04f, 1.58667248e-02f,
  9.33428258e-02f, -4.70664538e-02f, -8.30248818e-02f, -7.25610852e-02f, -1.34716369e-02f, -2.89348122e-02f, -2.06731230e-01f, -1.48853272e-01f, -4.34085652e-02f, 8.94308612e-02f,
  -2.58705728e-02f, 2.85220612e-02f, 7.18373731e-02f, -1.03062697e-01f, -1.08705930e-01f, -2.63734944e-02f, -7.92843699e-02f, 6.88414574e-02f, -4.33277637e-02f, 1.02319837e-01f,
  6.91029504e-02f, -5.66228032e-02f, -1.62481084e-01f, -1.35421589e-01f, -1.69668302e-01f, 3.45912784e-01f, 4.42754537e-01f, -2.05038980e-01f, -2.43266389e-01f, 8.32707211e-02f,
  9.60026011e-02f, -7.03435317e-02f, 2.35417962e-01f, 2.85116494e-01f, 3.19515675e-01f, 3.87146056e-01f, 1.94674090e-01f, 1.83108777e-01f, -1.30266801e-01f, 4.28275019e-03f,
  -1.59162924e-01f, 3.58767688e-01f, 2.13817805e-01f, -1.02467678e-01f, 2.05002278e-01f, -3.62286657e-01f, 5.84140420e-02f, -3.14322710e-02f, 1.87997241e-02f, 7.31518045e-02f,
  3.52845117e-02f, 9.68859124e-04f, 3.86903547e-02f, -4.54844069e-03f, 5.36584891e-02f, 4.82099950e-02f, 6.04160540e-02f, 1.71879530e-01f, -6.46170005e-02f, -5.21941036e-02f,
  1.57556430e-01f, -1.84927993e-02f, 2.07260419e-02f, -3.90108451e-02f, -1.29079476e-01f, -1.46171749e-01f, -1.64131999e-01f, -1.55791551e-01f, -7.99775496e-02f, 8.48618969e-02f,
  6.67929873e-02f, -7.72805661e-02f, 1.21655706e-02f, -2.16740649e-02f, -2.58218739e-02f, -2.48108804e-02f, 9.74604860e-03f, 1.44909471e-01f, -6.71768486e-02f, -6.55319616e-02f,
  2.80290120e-03f, -2.47329753e-02f, 1.19345151e-01f, 4.12848145e-02f, 1.12974338e-01f, -7.43371174e-02f, 5.66973835e-02f, -5.04664220e-02f, -1.09626159e-01f, 1.18494667e-01f,
  -2.33963523e-02f, 9.45921615e-03f, 1.50254183e-02f, 4.95910905e-02f, 7.83280656e-02f, 4.19450589e-02f, 1.03672221e-01f, -3.97316320e-03f, -1.29557416e-01f, -1.28826797e-01f,
  -3.58429812e-02f, -9.42837000e-02f, -3.83072458e-02f, 1.64341882e-01f, 8.83693397e-02f, -1.88221373e-02f, -6.53438196e-02f, 1.61588602e-02f, -8.31850767e-02f, 1.20951653e-01f,
  4.76755835e-02f, 1.71817750e-01f, -3.35534997e-02f, 1.16031423e-01f, 7.44542181e-02f, 1.75503772e-02f, 3.38045917e-02f, -1.42531702e-02f, 6.25265688e-02f, 5.44575676e-02f,
  -1.84051739e-03f, 4.57124822e-02f, -2.96691209e-02f, -1.10835053e-01f, -8.28761160e-02f, -1.45411342e-02f, 1.18265204e-01f, -1.70077920e-01f, 6.42346814e-02f, -6.92414716e-02f,
  -4.30262722e-02f, 7.09527805e-02f, -2.13414263e-02f, -3.45545597e-02f, 9.85884573e-03f, 8.03548768e-02f, 4.40733247e-02f, 7.85275083e-03f, 6.57908022e-02f, -4.38544825e-02f,
  3.87386501e-01f, -3.50206606e-02f, 2.43020937e-01f, 3.26650918e-01f, 1.09836467e-01f, 2.17339262e-01f, 3.19327444e-01f, 1.46212548e-01f, 6.32715881e-01f, -4.11462933e-01f,
  -2.33473122e-01f, 3.10166001e-01f, -1.05259053e-01f, -2.74021357e-01f, 2.99939271e-02f, 6.36250526e-02f, 2.16824874e-01f, 3.40701669e-01f, 2.78463185e-01f, -2.67114281e-03f,
  1.15709133e-01f, -3.54713947e-01f, -2.44233876e-01f, -3.20590228e-01f, -6.73218817e-02f, 1.40384678e-02f, -4.74310875e-01f, 1.06654920e-01f, -4.12019074e-01f, -7.55078122e-02f,
  -5.35757728e-02f, 1.47865117e-01f, -1.12613618e-01f, -2.01353207e-02f, -1.78734791e-02f, 1.40712142e-01f, -2.31836680e-02f, 3.13024931e-02f, 1.20357141e-01f, -1.46486446e-01f,
  1.36910096e-01f, -1.51111126e-01f, -1.27087766e-02f, -6.35621920e-02f, 1.82677448e-01f, -8.44130442e-02f, 1.05631212e-02f, -2.87284721e-02f, 3.50193568e-02f, 8.16788003e-02f,
  -6.92523420e-02f, 4.59826514e-02f, -7.93380961e-02f, -2.12992541e-03f, -1.22122429e-02f, 5.15844226e-02f, 7.50095351e-03f, -2.63218265e-02f, -8.65325555e-02f, 3.01521793e-02f,
  7.09945261e-02f, 6.42647520e-02f, -1.34364650e-01f, -1.07041143e-01f, -3.29422690e-02f, -1.11600883e-01f, -6.75691664e-02f, -1.76787272e-01f, -1.68841332e-02f, -1.35706514e-01f,
  -4.10124771e-02f, -7.33034238e-02f, 1.07622057e-01f, -5.97408637e-02f, 5.47409244e-02f, 9.68617797e-02f, -9.09201577e-02f, 3.82323787e-02f, 8.57752934e-02f, 4.10694033e-02f,
  4.66891117e-02f, 8.90736356e-02f, -1.30117059e-01f, -2.02844255e-02f, -6.03674315e-02f, -2.49782056e-02f, -1.60545364e-01f, -5.42184003e-02f, 1.16715983e-01f, -2.66342051e-02f,
  1.59384608e-01f, 1.57757998e-01f, -5.10859080e-02f, -1.63169324e-01f, 7.60777518e-02f, -1.21968724e-01f, 5.96860275e-02f, 2.38807611e-02f, 1.80998132e-01f, -6.46685511e-02f,
  -6.72091320e-02f, -1.02612615e-01f, -3.05213798e-02f, -4.41207252e-02f, 5.90580292e-02f, -2.06409723e-01f, 5.66315874e-02f, 1.73292622e-01f, -1.25746429e-02f, 2.73756720e-02f,
  -5.09484187e-02f, -4.11213078e-02f, -8.14979374e-02f, -5.13694920e-02f, -2.36388352e-02f, -1.16972491e-01f, 1.85937639e-02f, -6.64856657e-02f, 8.04180503e-02f, 4.99014743e-03f,
  -5.14768660e-01f, 5.54091334e-02f, 2.25882381e-01f, -2.52668291e-01f, 6.27896786e-02f, 7.01768100e-02f, -1.15978658e-01f, 1.78847939e-01f, -2.63933450e-01f, 1.46584913e-01f,
  2.01556891e-01f, -3.15107286e-01f, 2.38114610e-01f, -2.66010255e-01f, -1.82723388e-01f, 3.99417244e-02f, -1.62359402e-01f, -1.73054233e-01f, -9.46071744e-02f, 1.37213081e-01f,
  -1.58839762e-01f, -1.02981307e-01f, 2.94518560e-01f, 1.58028424e-01f, -2.72526164e-02f, 4.47468534e-02f, 2.32158735e-01f, 2.36521095e-01f, -1.89203799e-01f, -7.73399025e-02f,
  5.70160113e-02f, 1.08598977e-01f, 2.09576383e-01f, 7.36146569e-02f, 1.80434927e-01f, 4.61018384e-02f, 4.09323256e-03f, 4.29395996e-02f, -1.06956393e-01f, -7.37583339e-02f,
  -1.16131440e-01f, 7.11950054e-03f, -1.72478527e-01f, -5.00038192e-02f, -7.83726573e-02f, -7.57218674e-02f, 9.70717892e-02f, -2.40535587e-02f, 5.87863438e-02f, 1.32266432e-02f,
  3.02410219e-02f, -3.77160572e-02f, -1.43600432e-02f, -4.85067517e-02f, -2.68148296e-02f, 6.44536838e-02f, -4.03868258e-02f, 1.15977384e-01f, -7.27766231e-02f, -4.87359706e-03f,
  6.11880235e-02f, -1.70493238e-02f, 2.85421293e-02f, 8.65097865e-02f, 8.71223956e-02f, 5.49102994e-03f, -9.51412246e-02f, 5.80665842e-02f, -4.82399762e-03f, 5.78099675e-03f,
  6.63081706e-02f, 7.03267008e-02f, 2.65702493e-02f, -9.99457613e-02f, -7.98759460e-02f, -9.19309482e-02f, -7.43951532e-04f, 1.71010226e-01f, -3.09381746e-02f, 1.19022600e-01f,
  5.67180365e-02f, -8.64464119e-02f, -5.35331890e-02f, 3.15601262e-03f, 2.74120718e-02f, 7.22142011e-02f, -5.06158508e-02f, -2.83938348e-02f, 4.87980992e-03f, 3.88755128e-02f,
  1.52955949e-01f, 2.53254890e-01f, 1.43880039e-01f, 1.79801211e-02f, 5.79142235e-02f, 9.89749059e-02f, -2.28224266e-02f, -4.52815415e-03f, -8.24406892e-02f, -4.44402033e-03f,
  -1.23285450e-01f, -9.08561517e-03f, -1.10384032e-01f, -8.55306536e-02f, 5.57890013e-02f, 2.06483543e-01f, 1.16020799e-01f, -2.21179184e-02f, 2.10183680e-01f, 3.12371366e-02f,
  1.68500721e-01f, 1.85306370e-02f, -1.48109600e-01f, -1.63031951e-01f, -3.08729094e-02f, 8.35498050e-02f, 2.42636390e-02f, 7.48432502e-02f, -1.32752266e-02f, -3.42098363e-02f,
  4.45845932e-01f, -4.63092774e-01f, 4.95360494e-02f, 3.74258488e-01f, 3.63343686e-01f, -2.02806458e-01f, 5.35320565e-02f, 1.03705510e-01f, 3.16162109e-01f, -4.94623810e-01f,
  -1.02070689e-01f, -1.13424003e-01f, -3.23759168e-01f, 1.37158915e-01f, 2.77624846e-01f, -3.40649813e-01f, 1.79606210e-02f, -5.79915941e-02f, 1.93588391e-01f, -1.05596863e-01f,
  3.00466299e-01f, 1.46467060e-01f, 1.28324896e-01f, -1.05460085e-01f, 1.75477266e-01f, 1.07361242e-01f, 7.48185962e-02f, -1.17529154e-01f, 5.35980463e-02f, 8.98569375e-02f,
  -1.09625071e-01f, 2.14666113e-01f, 7.32210875e-02f, -7.56556541e-02f, -1.12005109e-02f, 6.91689253e-02f, -5.41927516e-02f, -4.84501086e-02f, 2.16625959e-01f, -6.39245659e-02f,
  -5.34613431e-02f, 1.01727806e-01f, 4.20190543e-02f, -4.19748686e-02f, 1.30475789e-01f, 1.19050242e-01f, 2.56661978e-02f, -7.94113353e-02f, 1.78547334e-02f, -1.30297281e-02f,
  -3.77821214e-02f, -6.46769777e-02f, 1.25089260e-02f, -9.95820537e-02f, 9.38614309e-02f, 1.19705111e-01f, 7.82547668e-02f, -2.72473483e-03f, -6.71769828e-02f, 1.56875178e-01f,
  -8.80912319e-03f, -1.79878883e-02f, -2.40397565e-02f, 1.55727016e-02f, -3.48578542e-02f, 8.16606581e-02f, -6.98873997e-02f, -4.65028174e-03f, -6.28007352e-02f, -5.25573231e-02f,
  3.48194502e-02f, 3.00525371e-02f, 5.73212877e-02f, 3.96334901e-02f, 3.63124982e-02f, 9.52841118e-02f, 2.85293814e-02f, -3.48847248e-02f, 1.07535506e-02f, 8.19943771e-02f,
  1.23834219e-02f, -7.70909712e-03f, -7.93624967e-02f, 5.84837645e-02f, -1.21911289e-02f, -5.64981438e-02f, -5.66471228e-03f, -4.50205337e-03f, 2.83285398e-02f, -1.37069039e-02f,
  -4.07824069e-01f, -6.92253828e-01f, -6.51309490e-02f, -5.33552207e-02f, -1.19637683e-01f, -1.11752503e-01f, -2.13597696e-02f, 4.76552807e-02f, -1.20962225e-01f, 5.44821359e-02f,
  -2.66325139e-02f, 2.89606899e-02f, -1.13820005e-02f, 2.45312316e-04f, -5.81723778e-03f, -1.12473376e-01f, -4.38864492e-02f, -3.54327671e-02f, -5.67493662e-02f, -2.79506836e-02f,
  6.08018637e-02f, -5.73293567e-02f, 1.13126032e-01f, 1.17864594e-01f, 6.33371025e-02f, -2.69232951e-02f, 3.73051688e-02f, 1.36944326e-02f, -1.16143130e-01f, -8.06119516e-02f,
  -5.94784319e-01f, 4.89837043e-02f, -2.33734369e-01f, -4.43189830e-01f, 3.97414982e-01f, 3.06834459e-01f, -7.17904940e-02f, 3.92162949e-01f, 7.76269808e-02f, 2.63851136e-01f,
  2.25881889e-01f, 5.48248552e-03f, 9.18199420e-02f, -2.95926422e-01f, -3.10217798e-01f, -3.72932315e-01f, -3.61912370e-01f, -1.71938896e-01f, -6.56934083e-02f, -1.55444145e-01f,
  -1.92438707e-01f, -3.07972413e-02f, -3.54533672e-01f, 4.59526628e-01f, 7.57373422e-02f, -2.83398889e-02f, 1.66872501e-01f, 3.12973708e-01f, 3.10401455e-03f, 9.51499641e-02f,
  -6.41764700e-02f, 5.81198409e-02f, 7.60578662e-02f, 4.04411554e-02f, -8.22065473e-02f, 6.24650195e-02f, 6.60850927e-02f, 1.83959454e-02f, -9.23275128e-02f, -8.81322995e-02f,
  -1.18491657e-01f, 1.60523001e-02f, 4.02930453e-02f, 1.19252160e-01f, 9.80294049e-02f, 1.89265776e-02f, -3.27006504e-02f, 7.82366470e-02f, -5.57414815e-02f, -2.12117031e-01f,
  -1.49384424e-01f, 1.06533794e-02f, 6.97915778e-02f, -1.20874636e-01f, 7.34328181e-02f, -1.45303784e-02f, -7.31047690e-02f, 2.99959052e-02f, -7.48949870e-02f, 6.04568608e-02f,
  4.45269234e-02f, -1.46345450e-02f, 3.33297811e-02f, -9.95355919e-02f, 7.16084763e-02f, 4.90835384e-02f, 7.33463019e-02f, 2.37945225e-02f, -3.64853591e-02f, 7.41089806e-02f,
  1.05640858e-01f, 5.76457903e-02f, 7.26683298e-04f, -5.52862994e-02f, -4.83069904e-02f, -7.04472661e-02f, 1.17948093e-02f, 1.01886921e-01f, -1.62503526e-01f, 5.96608371e-02f,
  1.24300309e-01f, -6.69972673e-02f, 3.66541781e-02f, 1.52312145e-01f, -7.30976239e-02f, 1.66724473e-01f, 7.55630210e-02f, 3.66383791e-02f, -1.61217898e-02f, 2.16703024e-02f,
  6.80676848e-02f, 8.89539942e-02f, 1.73402861e-01f, 1.55465364e-01f, -5.89093799e-03f, 9.11909565e-02f, 9.75574255e-02f, 1.52167603e-01f, 1.32072777e-01f, 1.99030831e-01f,
  4.66682203e-03f, 6.34368584e-02f, 1.22820154e-01f, 1.41737387e-01f, -1.02473445e-01f, 2.29307860e-01f, 1.64884310e-02f, 5.00355922e-02f, 9.06521752e-02f, 1.30425438e-01f,
  2.84110121e-02f, -9.27429367e-03f, -1.24979965e-01f, 7.21542835e-02f, 7.10945129e-02f, 1.89228296e-01f, 4.87577543e-02f, 5.57802133e-02f, -1.06309682e-01f, -2.29726192e-02f,
  2.49875873e-01f, -1.90054402e-01f, -2.72828102e-01f, -1.87836081e-01f, 1.26420155e-01f, 1.15190431e-01f, 1.65391117e-01f, 3.44052687e-02f, 7.48688877e-02f, 1.86319441e-01f,
  3.38275880e-01f, 2.28810310e-01f, 2.70460010e-01f, 1.72369882e-01f, 7.46209547e-02f, -3.09025291e-02f, -6.85304925e-02f, 1.42116040e-01f, -3.45598869e-02f, 5.75670749e-02f,
  -1.81188494e-01f, 2.63076872e-01f, -1.85702294e-01f, 9.54145044e-02f, 1.32625356e-01f, -1.65204465e-01f, -1.78886473e-01f, 1.45752952e-01f, 1.11143112e-01f, 4.35385048e-01f,
  -1.01691829e-02f, -3.85810435e-02f, 1.69572253e-02f, -2.28612591e-02f, -4.79431748e-02f, -9.97547954e-02f, -3.18818986e-02f, 3.90081368e-02f, 3.76657769e-02f, 1.02020271e-01f,
  7.59996325e-02f, -4.95390221e-02f, 5.38161881e-02f, -1.00314461e-01f, -6.79993108e-02f, 1.24882542e-01f, 1.44630354e-02f, -6.41524568e-02f, 7.81102153e-03f, -1.65525377e-01f,
  8.51991899e-06f, -7.98677877e-02f, -9.01486278e-02f, -1.02134056e-01f, -7.49746338e-02f, 5.01952088e-03f, -1.86924711e-01f, -1.15384288e-01f, -9.24540535e-02f, 1.65727921e-02f,
  9.69669968e-02f, -7.76216686e-02f, -1.21219166e-01f, -2.69585010e-02f, 3.92254256e-03f, -9.91426557e-02f, -5.44914161e-04f, 6.40873834e-02f, -1.40955392e-02f, -5.38066123e-03f,
  -4.46739383e-02f, 2.72697094e-03f, 1.46583505e-02f, -1.21668587e-02f, -8.18221122e-02f, -5.49047925e-02f, 9.11899358e-02f, 1.03908382e-01f, -1.48324281e-01f, -6.86372444e-02f,
  1.31213844e-01f, -1.65417325e-02f, 1.34460890e-04f, -9.81676728e-02f, -1.51631562e-02f, 1.81569010e-01f, 7.19168708e-02f, -9.84352827e-02f, 1.43036604e-01f, 8.27042237e-02f,
  -9.29712653e-02f, 3.12306210e-02f, 8.51301383e-03f, 8.67557377e-02f, 1.40096862e-02f, -1.69426892e-02f, -1.19137771e-01f, -1.60284013e-01f, 7.58032873e-02f, -2.62617450e-02f,
  -1.02777459e-01f, -1.33002654e-01f, -4.08860072e-02f, 8.84067267e-03f, -3.68256569e-02f, 1.10279500e-01f, -1.32044088e-02f, 8.36272240e-02f, -1.88762392e-03f, -9.51090176e-03f,
  5.34219295e-02f, 9.98065844e-02f, 6.33511543e-02f, 4.21330519e-02f, -1.18627688e-02f, 5.12048416e-02f, 3.41444649e-02f, -9.16611776e-02f, -6.00634888e-02f, -1.76573247e-01f,
  5.21742761e-01f, -4.22560245e-01f, -2.98063725e-01f, 2.64864743e-01f, 3.86158854e-01f, 9.38064083e-02f, 9.30233076e-02f, 1.09590910e-01f, -1.24937966e-01f, -1.76280677e-01f,
  4.56070960e-01f, -1.88660830e-01f, -1.26552612e-01f, 4.91871536e-01f, 4.30047840e-01f, -2.05864280e-01f, 4.11695480e-01f, 8.23379904e-02f, -9.53432098e-02f, 2.25613102e-01f,
  2.12236136e-01f, 3.82330537e-01f, 8.94715339e-02f, -7.94059783e-02f, 3.38386565e-01f, -9.45002213e-02f, 7.22718537e-02f, -2.99768329e-01f, 6.94792196e-02f, 1.99807093e-01f,
  1.51448786e-01f, 1.99129313e-01f, 8.20571706e-02f, -1.53271303e-01f, 6.85062185e-02f, -4.67242720e-03f, -7.62808248e-02f, 9.37775970e-02f, 1.01299898e-03f, 3.58948559e-02f,
  -1.87547330e-03f, 4.67403531e-02f, 1.35339126e-01f, -3.46491225e-02f, -3.67857628e-02f, -5.11455629e-03f, -2.87963194e-03f, -3.44978869e-02f, -3.34705226e-02f, 6.16195463e-02f,
  -7.56529942e-02f, 2.99724899e-02f, 9.75622535e-02f, -8.24788436e-02f, 1.15082162e-02f, -4.42354940e-02f, -6.28122911e-02f, -7.14866957e-03f, 1.29634393e-02f, 3.67072620e-03f,
  8.60527009e-02f, -6.03885092e-02f, 4.89619896e-02f, 1.32315774e-02f, -1.12703837e-01f, 4.54078726e-02f, -8.60658810e-02f, 2.21440243e-03f, -7.98281431e-02f, 1.87887345e-02f,
  -8.34309682e-03f, 8.99223313e-02f, -2.07830463e-02f, 2.45817229e-02f, 1.13606397e-02f, -3.96819115e-02f, -1.20999902e-01f, 5.32866418e-02f, 3.33948173e-02f, 6.66700527e-02f,
  -3.92924957e-02f, -5.13734482e-02f, -4.79712524e-02f, 9.65578109e-02f, -3.51575948e-02f, -1.97670329e-02f, -1.07901432e-02f, 2.92713381e-02f, 4.22938243e-02f, -8.74162652e-03f,
  -2.42595732e-01f, -2.98559427e-01f, -4.12630998e-02f, -5.75565994e-02f, -1.56436384e-01f, 1.34508327e-01f, -7.37741143e-02f, 5.75123169e-03f, -1.00458711e-01f, 5.52290007e-02f,
  2.65590847e-02f, -5.69652282e-02f, -9.48117003e-02f, 1.64543718e-01f, -4.24699765e-03f, -3.78096178e-02f, -3.62890139e-02f, -6.84866831e-02f, 1.03554532e-01f, -2.57620700e-02f,
  -1.07426215e-02f, 7.44101927e-02f, 7.02653639e-03f, 4.22823280e-02f, -1.34589868e-02f, 2.39258707e-02f, -1.88302081e-02f, -4.40581031e-02f, -4.86347228e-02f, -1.25667438e-01f,
  -3.38225484e-01f, -5.18180013e-01f, 1.48699701e-01f, -2.04937309e-01f, 1.31824434e-01f, 3.79777580e-01f, -1.44207016e-01f, -7.40777999e-02f, -4.07328635e-01f, -6.86084479e-02f,
  -1.64905265e-01f, -2.69216597e-01f, -1.04559377e-01f, -2.56331801e-01f, 2.74344295e-01f, -2.44366109e-01f, -1.15443334e-01f, 2.47005932e-02f, -1.57886714e-01f, 2.55943865e-01f,
  3.57088074e-02f, -5.74004874e-02f, 2.04405650e-01f, 2.39223152e-01f, 2.81514060e-02f, 2.10270450e-01f, 3.78981352e-01f, 3.04308414e-01f, 2.50139952e-01f, 1.25911599e-02f,
  -2.24380150e-01f, -1.91044822e-01f, -3.56427170e-02f, -3.12774139e-03f, 2.01608613e-01f, 2.35188305e-02f, 5.80856875e-02f, 6.61216537e-03f, -1.01453811e-01f, 3.60108688e-02f,
  7.17338733e-03f, 1.10090949e-01f, 1.09619107e-02f, -8.67005736e-02f, -1.04185373e-01f, -9.30085406e-03f, -1.25376564e-02f, 7.02220947e-02f, -1.68398228e-02f, -4.69960794e-02f,
  -2.81791445e-02f, 4.43659984e-02f, 2.05113320e-03f, 5.68673126e-02f, -3.35173383e-02f, 5.70254400e-02f, 5.23122028e-02f, 1.28395677e-01f, -1.70647025e-01f, 1.29878148e-01f,
  4.85056341e-02f, 4.39902768e-02f, 1.56878859e-01f, -1.45854309e-01f, -5.02311252e-02f, -1.21480480e-01f, 1.24652581e-02f, -6.24146387e-02f, -4.46922369e-02f, -1.09921791e-01f,
  5.36346808e-02f, -8.62483401e-04f, -1.96838126e-01f, -6.69407332e-03f, 2.68344097e-02f, -1.08851224e-01f, 5.69031946e-02f, -3.96320000e-02f, 2.59428602e-02f, 1.01296954e-01f,
  -2.62914449e-01f, -1.70805119e-02f, 1.53255492e-01f, 4.27555777e-02f, -5.23847621e-03f, 7.71118030e-02f, -7.07426667e-02f, 1.32254120e-02f, 5.05292118e-02f, 9.95459035e-02f,
  6.21309541e-02f, 2.23177120e-01f, -1.00516498e-01f, -2.05224454e-01f, -2.41694488e-02f, 5.02153412e-02f, -2.00921088e-01f, -6.03073686e-02f, 1.26011238e-01f, -1.42841386e-02f,
  8.13432708e-02f, 7.97201395e-02f, 9.71232951e-02f, -1.55949395e-03f, 3.83323617e-02f, -1.29229696e-02f, 6.74292147e-02f, -4.16818820e-02f, 1.02185503e-01f, 1.10240579e-01f,
  4.13797833e-02f, 8.26469362e-02f, 1.15692345e-02f, 2.25312486e-01f, 6.39554637e-04f, 5.38734207e-03f, 5.87544814e-02f, 6.03632964e-02f, 6.21876977e-02f, 6.52424991e-02f,
  -3.28947842e-01f, 3.36472392e-01f, 4.19701785e-01f, 3.76855195e-01f, 5.85571118e-02f, 4.21069384e-01f, 2.57433802e-01f, 3.50430220e-01f, 4.98548418e-01f, 2.39936844e-01f,
  -1.23032093e-01f, -4.82608639e-02f, -1.27871022e-01f, 3.35835785e-01f, -3.62505585e-01f, 3.05622458e-01f, 4.17065740e-01f, 2.45827675e-01f, 4.11073342e-02f, -6.78147301e-02f,
  -7.67831951e-02f, -2.55703777e-01f, -1.03293397e-01f, -2.30858415e-01f, -2.00764239e-02f, -7.11852498e-03f, -3.81141514e-01f, -2.27545738e-01f, -5.38453087e-02f, -7.56799579e-02f,
  -1.83029518e-01f, 3.89831997e-02f, -5.81580363e-02f, 1.23640463e-01f, 6.60947431e-03f, 8.98480490e-02f, -3.99382450e-02f, -7.46894106e-02f, -7.87165202e-03f, 3.32489423e-02f,
  -4.41489182e-02f, 1.04292240e-02f, -5.00379018e-02f, -5.83009683e-02f, 2.24854082e-01f, 4.28509079e-02f, 1.36472464e-01f, 1.94637150e-01f, 5.24290353e-02f, 7.24607259e-02f,
  7.90114999e-02f, 1.88512787e-01f, 9.91317332e-02f, 6.90855831e-02f, -1.14341639e-02f, 1.41709119e-01f, 1.74242511e-01f, -9.75262746e-03f, 5.97400367e-02f, 7.07683638e-02f,
  6.81308806e-02f, 1.88041240e-01f, 1.09304031e-02f, 7.61147812e-02f, 1.06621971e-02f, -3.40459310e-02f, -1.24856620e-03f, -2.15982363e-01f, 8.17849766e-03f, -9.43048596e-02f,
  1.43059967e-02f, 2.28341781e-02f, 9.98437852e-02f, 1.07912190e-01f, 1.77839492e-02f, 8.13408867e-02f, 1.38706379e-02f, 6.55013621e-02f, -1.69608481e-02f, 3.84322405e-02f,
  -7.03293607e-02f, 1.16824415e-02f, -6.51249290e-02f, 3.12459953e-02f, 2.72480473e-02f, -2.38890341e-03f, -4.92609944e-03f, 1.21643260e-01f, 1.11811899e-01f, -1.72906265e-01f,
  1.18659821e-03f, -7.28201568e-02f, -5.40156625e-02f, -6.30218312e-02f, -4.77625206e-02f, 4.13775630e-03f, 2.00368334e-02f, 6.10744320e-02f, -2.85878708e-03f, 7.59059340e-02f,
  5.04230149e-03f, 8.76158625e-02f, -6.80261999e-02f, 3.23294997e-02f, -3.97981098e-03f, -3.06617972e-02f, -3.33871767e-02f, -5.35918921e-02f, -1.15094826e-01f, 1.99436713e-02f,
  -8.00066367e-02f, -3.06358691e-02f, 6.66774483e-03f, -1.53910331e-02f, 6.68945443e-03f, -1.89435855e-01f, -7.97684565e-02f, -1.77870062e-03f, -1.41388597e-02f, -2.14994922e-02f,
  6.86887011e-04f, 2.31503183e-03f, -9.72411558e-02f, 4.46321405e-02f, -1.16008967e-01f, 2.77152099e-02f, -7.73694068e-02f, 1.52288854e-01f, 3.01981896e-01f, -4.78022877e-04f,
  -1.67980477e-01f, 1.51924463e-02f, -2.98256651e-02f, -3.07249516e-01f, 2.66344756e-01f, 2.91244596e-01f, -1.52382374e-01f, -1.81615546e-01f, 1.32384881e-01f, -1.04177989e-01f,
  6.41388819e-02f, -2.68632054e-01f, -2.25113705e-01f, -1.58599719e-01f, -3.92011374e-01f, -6.97799399e-02f, -2.58149385e-01f, -1.25431448e-01f, -3.25150222e-01f, -1.32417396e-01f,
  -7.92563558e-02f, 1.64153829e-01f, -3.45228687e-02f, 5.04627340e-02f, -3.00065130e-02f, -2.93761846e-02f, -9.56258550e-02f, -8.88647162e-04f, 1.03698365e-01f, 3.86196114e-02f,
  -6.35783225e-02f, 1.18484542e-01f, 1.07915029e-01f, -2.19733603e-02f, 2.67920867e-02f, -1.05528750e-01f, 5.51251471e-02f, -5.43327928e-02f, -9.91824567e-02f, -1.36015981e-01f,
  -1.66781604e-01f, -8.84696934e-03f, -9.29162428e-02f, -2.18125097e-02f, -9.32890996e-02f, 3.54167670e-02f, 7.20021278e-02f, -9.36613753e-02f, -1.02866761e-01f, 4.14507873e-02f,
  -1.02530867e-01f, -2.24147197e-02f, 3.10653243e-02f, 8.29291418e-02f, 1.50759786e-01f, -4.33775224e-02f, 4.77945507e-02f, -2.89200759e-03f, 1.58282906e-01f, -1.37851983e-01f,
  -5.34546636e-02f, -5.14967069e-02f, 1.42163813e-01f, -1.07094549e-01f, -1.34986490e-01f, 1.42307103e-01f, -8.32671672e-02f, -4.20755297e-02f, -4.48781736e-02f, 2.75774300e-02f,
  -2.69016549e-02f, 3.07065323e-02f, -6.62601599e-03f, -5.46211898e-02f, 6.40358180e-02f, 8.84347484e-02f, -4.18819673e-02f, -1.32846057e-01f, 1.84941583e-03f, -1.46597266e-01f,
  1.19290240e-01f, 3.19545805e-01f, 1.30842432e-01f, 4.75780182e-02f, 1.82494689e-02f, 2.72814780e-02f, 3.89174893e-02f, -4.39303890e-02f, 7.99554288e-02f, 1.33191139e-01f,
  1.16158202e-02f, -2.86445562e-02f, -3.33361840e-03f, -1.13617722e-02f, 2.53360569e-02f, 9.14525837e-02f, -1.30584285e-01f, 9.65237711e-03f, -3.58306728e-02f, -2.03799903e-01f,
  -2.42676780e-01f, -1.04008419e-02f, 6.52356893e-02f, 1.04536571e-01f, -8.85026455e-02f, 2.33513722e-03f, -6.78671384e-03f, -3.88714448e-02f, -1.26846999e-01f, 4.01738137e-02f,
  4.38690990e-01f, -3.87819737e-01f, -1.79285035e-01f, -1.94722647e-03f, 3.81263107e-01f, 4.01188284e-01f, 1.96638212e-01f, -7.96552524e-02f, -1.83372870e-01f, -3.65044296e-01f,
  -2.08958983e-02f, -1.54674515e-01f, -2.19868481e-01f, 2.56526947e-01f, 3.99847567e-01f, -6.17028102e-02f, 2.80430168e-01f, -5.07478043e-02f, 2.36863233e-02f, 1.27435490e-01f,
  9.58386958e-02f, 3.23328525e-01f, 1.82318136e-01f, 1.30759301e-02f, 3.54453564e-01f, -1.97412297e-01f, -7.06752911e-02f, -1.49609149e-01f, -1.48562521e-01f, 1.33046985e-01f,
  1.51846483e-01f, -5.61527461e-02f, 9.01290327e-02f, 8.95939209e-03f, 3.34605686e-02f, 9.81972665e-02f, -6.62368461e-02f, 1.18453756e-01f, 1.27297595e-01f, -9.02773142e-02f,
  -1.17750868e-01f, -2.42249519e-02f, -1.07419819e-01f, 1.27009720e-01f, 4.44877818e-02f, -1.45179285e-02f, -3.43718566e-02f, 1.82516966e-02f, -1.83185950e-01f, 1.75699573e-02f,
  3.41273518e-03f, -2.12231770e-01f, 2.72704326e-02f, -9.79116857e-02f, -9.89125744e-02f, -1.51772633e-01f, -1.14111595e-01f, -4.93262708e-02f, -1.40759096e-01f, -5.06508350e-02f,
  -3.25259008e-02f, 3.89814898e-02f, 1.31533176e-01f, -1.39921866e-02f, 8.45747907e-03f, 5.74900694e-02f, 1.50028514e-02f, -1.08887993e-01f, -9.63200703e-02f, 2.26283371e-02f,
  -1.19051762e-01f, 4.27067988e-02f, 4.69546132e-02f, 1.95376854e-02f, 9.28642526e-02f, 7.86306262e-02f, -2.07424033e-02f, -5.20410649e-02f, 1.79547278e-04f, -7.41651952e-02f,
  1.50389969e-02f, -7.66812684e-03f, 9.85799804e-02f, -1.43095076e-01f, -1.12903714e-01f, -5.94673539e-03f, 2.25847624e-02f, -7.77600780e-02f, 2.84043197e-02f, 2.52953847e-03f,
  -4.05789651e-02f, -2.77543187e-01f, 6.57557417e-03f, -1.25146464e-01f, -2.35701706e-02f, 8.57421234e-02f, 3.94137502e-02f, -3.44714262e-02f, -2.11051628e-02f, 3.86445709e-02f,
  -1.63629127e-03f, -6.28313124e-02f, -5.76503873e-02f, 9.36983386e-04f, -2.18356345e-02f, 3.23897153e-02f, -9.51819420e-02f, -2.19374541e-02f, -1.59245193e-01f, -1.01327412e-01f,
  -7.66031742e-02f, -1.99261919e-01f, -3.34999003e-02f, 4.73164506e-02f, -4.58071865e-02f, -1.37033373e-01f, 7.38853589e-02f, -4.22140509e-02f, -7.36450031e-02f, -1.26605332e-01f,
  -4.42088574e-01f, 2.46009618e-01f, 4.55602795e-01f, -3.48210841e-01f, 2.70834535e-01f, 3.19691896e-01f, 1.19968742e-01f, 2.58987080e-02f, -3.14395130e-01f, -2.83070982e-01f,
  -1.96294725e-01f, 1.26323909e-01f, 1.16900556e-01f, -2.22276792e-01f, 8.78624395e-02f, -3.97484116e-02f, -2.78717279e-01f, -2.60837108e-01f, 1.77669659e-01f, -1.63352996e-01f,
  1.64979156e-02f, -1.69598252e-01f, 2.30915323e-01f, -3.20291072e-02f, -5.27104363e-02f, -1.17418021e-01f, -2.96004087e-01f, 1.75282091e-01f, -4.12924811e-02f, 1.57448441e-01f,
  -3.45729262e-01f, -3.30297589e-01f, -2.07556635e-01f, -1.58234522e-01f, -1.37812749e-01f, -1.11432709e-01f, -7.01459423e-02f, 3.20788212e-02f, -1.18489988e-01f, 7.55205704e-03f,
  -1.00037819e-02f, 4.63459902e-02f, -1.40427344e-03f, -8.46350864e-02f, -5.34345172e-02f, -5.21969348e-02f, 1.94503337e-01f, 5.77255152e-02f, 1.01406612e-01f, 1.80036694e-01f,
  7.70018920e-02f, 1.30172461e-01f, -3.71734761e-02f, -7.70005956e-02f, 8.08827654e-02f, -6.22420944e-02f, 7.55070001e-02f, 6.01655170e-02f, 4.37903926e-02f, -1.59965344e-02f,
  5.95626011e-02f, -4.11154665e-02f, 9.27069932e-02f, 1.84012372e-02f, -1.62542623e-03f, -2.23132614e-02f, -1.13911629e-01f, 4.64443564e-02f, -7.56845847e-02f, 1.37243327e-02f,
  5.88870794e-03f, -5.64298183e-02f, 5.34659587e-02f, -4.85130735e-02f, 2.12798431e-03f, -2.71476768e-02f, -1.09286541e-02f, -5.85472118e-03f, 4.67127524e-02f, 9.77673158e-02f,
  -5.20578809e-02f, 1.08849965e-01f, 2.04388215e-03f, -5.77135496e-02f, -3.10257655e-02f, -1.72907967e-04f, -5.00665940e-02f, -2.76596658e-02f, -4.05124649e-02f, 1.03337681e-02f,
  -3.53831351e-01f, -3.88563663e-01f, -1.72148004e-01f, -1.60921693e-01f, -1.16808541e-01f, -9.42943990e-03f, -5.84186688e-02f, -3.95848565e-02f, -6.72292709e-02f, -1.23548903e-01f,
  -6.75308183e-02f, -5.03826886e-02f, 2.31018756e-02f, -1.19151726e-01f, -6.27207989e-03f, -3.99297662e-02f, -4.18795981e-02f, -7.68696740e-02f, -1.18446440e-01f, -9.36395600e-02f,
  -3.48558351e-02f, -1.42475635e-01f, -1.15917744e-02f, -1.77930500e-02f, -6.18540682e-02f, 8.81788073e-05f, -2.89989985e-03f, 3.39447670e-02f, 9.29498076e-02f, 4.13859561e-02f,
  -5.44943094e-01f, 1.50365546e-01f, -3.14320415e-01f, 1.86767355e-01f, -8.76467451e-02f, 2.58542061e-01f, 2.57125318e-01f, -1.23957535e-02f, 7.17189163e-02f, 3.31459701e-01f,
  2.15487361e-01f, -2.89333761e-02f, -8.42162892e-02f, 4.23956186e-01f, 1.74181506e-01f, 2.80679375e-01f, 3.69548023e-01f, 1.61862031e-01f, -5.60439192e-02f, -2.58020490e-01f,
  -1.07608296e-01f, 2.67436713e-01f, 1.09255284e-01f, -3.43122669e-02f, -1.43060952e-01f, -2.70617664e-01f, -5.80557808e-02f, -2.42333919e-01f, 3.18876714e-01f, 1.41805455e-01f,
  -4.43294235e-02f, -3.54796439e-01f, 3.72242369e-02f, -1.31256267e-01f, -6.75554052e-02f, -9.14343372e-02f, -3.24180350e-03f, 2.32128799e-02f, 3.95983458e-03f, -1.14138452e-02f,
  -1.55858859e-01f, -1.27479523e-01f, 1.83514096e-02f, 2.57481337e-02f, -3.73646878e-02f, 7.00629503e-02f, -6.39617443e-02f, 5.90676032e-02f, -4.47036810e-02f, -2.36459300e-02f,
  -1.13433916e-02f, 3.96023542e-02f, -1.72270574e-02f, 1.67858630e-01f, 2.30930150e-02f, 1.04645044e-01f, 9.26377103e-02f, -2.00354844e-01f, 9.95022357e-02f, 1.31267225e-02f,
  9.41416714e-03f, -1.14522152e-01f, 6.44807816e-02f, -2.02638824e-02f, 6.11760318e-02f, 1.15299970e-01f, 1.41979933e-01f, 8.13390613e-02f, 7.85480440e-03f, 1.23704178e-02f,
  1.22293010e-02f, 5.24849333e-02f, -5.17453700e-02f, 6.29841611e-02f, 5.70232049e-02f, -1.31435636e-02f, -1.08034484e-01f, -9.03323963e-02f, -3.69367446e-03f, 8.38933587e-02f,
  8.76487326e-03f, 7.26871789e-02f, 2.03013271e-02f, -3.76673192e-02f, 1.60834089e-01f, 4.59231623e-03f, -3.21123004e-02f, 3.79344039e-02f, 2.01258827e-02f, -5.06709553e-02f,
  -1.63580645e-02f, -8.29767212e-02f, 4.90647629e-02f, 1.64534822e-02f, -2.54208799e-02f, 4.79890220e-02f, 9.82197374e-02f, -4.48582657e-02f, -1.07401367e-02f, -7.89723545e-02f,
  -1.87113341e-02f, 7.31348768e-02f, -1.06352260e-02f, -1.51313245e-02f, -3.48822353e-03f, -3.05828582e-02f, -1.17831724e-02f, 2.20204107e-02f, 4.73903529e-02f, -1.42336920e-01f,
  2.86660586e-02f, -1.11448780e-01f, -1.18951350e-02f, -5.36413155e-02f, 7.91981444e-02f, 7.32740238e-02f, -1.64677575e-02f, -1.09131336e-01f, 1.43135870e-02f, 6.08989969e-02f,
  -5.44081807e-01f, 9.30963680e-02f, 3.56730461e-01f, 1.39225006e-01f, -3.51410061e-01f, -2.03230940e-02f, 3.62122715e-01f, -2.06442773e-01f, -1.48095071e-01f, 2.96458483e-01f,
  8.63804594e-02f, -4.43664193e-02f, 2.21982032e-01f, 2.34062850e-01f, -1.98769718e-01f, 3.47780496e-01f, 1.88150436e-01f, 1.80333436e-01f, 5.94340712e-02f, -2.01816127e-01f,
  -1.92001849e-01f, -1.48286417e-01f, 3.06305557e-01f, -1.32347792e-01f, -7.03474954e-02f, -9.22642574e-02f, 3.53030376e-02f, 1.82199538e-01f, -7.16127604e-02f, -3.64047587e-02f,
  -1.51684150e-01f, -1.80013299e-01f, 4.34026867e-03f, -4.69285101e-02f, -1.06179155e-01f, 6.90535679e-02f, 1.10725418e-01f, 2.30639633e-02f, 1.16056092e-01f, 2.40351819e-03f,
  -9.66300666e-02f, -8.22422206e-02f, -4.81231473e-02f, -1.97756402e-02f, -1.47961214e-01f, -5.27478047e-02f, -1.11902215e-01f, -1.58390552e-02f, 2.11214740e-02f, 2.42723506e-02f,
  3.45085785e-02f, -7.70567656e-02f, 7.40382522e-02f, 6.04085699e-02f, -3.43209282e-02f, 2.08319426e-02f, 1.02035031e-01f, 3.19057959e-03f, -8.91770720e-02f, -1.59268916e-01f,
  9.66271851e-03f, -1.39605757e-02f, 4.26720791e-02f, -1.25439884e-02f, -9.54263732e-02f, -1.56577677e-02f, -2.67494563e-03f, -1.91501677e-02f, 5.17324731e-02f, -1.20199919e-01f,
  -1.47290200e-01f, -9.25845951e-02f, -8.08169991e-02f, 1.14300989e-01f, -4.02021892e-02f, 1.70427747e-02f, 1.54922530e-01f, -1.13622405e-01f, -4.21138369e-02f, 6.76503405e-03f,
  -1.16858622e-02f, 5.26966304e-02f, -6.16851114e-02f, 1.55002170e-03f, -4.75637056e-02f, 6.44163042e-02f, -2.39155944e-02f, 3.32767852e-02f, 1.26438558e-01f, -6.38043657e-02f,
  -2.83105850e-01f, -3.43357809e-02f, 4.65891836e-03f, -1.76230162e-01f, -3.11164837e-02f, -4.47358564e-02f, -2.38522328e-02f, -2.61343569e-02f, -9.49343219e-02f, -3.13945413e-02f,
  3.74410748e-02f, -3.50170806e-02f, -8.36926177e-02f, 7.51897022e-02f, 9.68431309e-02f, 5.76364063e-02f, 5.14075272e-02f, -8.65174085e-02f, -3.28929238e-02f, 4.49524075e-02f,
  4.69490923e-02f, 6.65223226e-02f, 1.49507523e-01f, -1.52897770e-02f, 3.30305099e-02f, 9.51335207e-02f, -2.10586399e-01f, 3.80954496e-03f, -2.44955346e-02f, 1.54003084e-01f,
  1.65386751e-01f, 2.68445641e-01f, 3.24017435e-01f, 8.10711011e-02f, -2.71874696e-01f, -3.64516795e-01f, -3.38570684e-01f, 1.55455083e-01f, -1.71232477e-01f, -9.55948383e-02f,
  1.83126342e-03f, -1.54871389e-01f, 1.77651450e-01f, -2.75409650e-02f, -4.14586626e-02f, -1.89906463e-01f, 1.22581653e-01f, -8.93503986e-03f, 9.02526900e-02f, 3.79997820e-01f,
  1.95859954e-01f, -4.51478139e-02f, 1.98578581e-01f, 2.05724612e-01f, 2.26778239e-01f, 3.41962099e-01f, 3.50827426e-01f, 1.41156003e-01f, 9.41943079e-02f, -2.01173097e-01f,
  2.72257663e-02f, 1.49290308e-01f, 1.85214758e-01f, -1.73364833e-01f, 1.77376732e-01f, 2.76920777e-02f, -4.27611321e-02f, -5.96355610e-02f, -4.79801465e-03f, 7.49894381e-02f,
  -7.25963265e-02f, -6.65077344e-02f, -1.01005934e-01f, -1.30962804e-01f, -6.60089925e-02f, 6.37507811e-02f, -1.14149578e-01f, -1.44238062e-02f, -1.67628989e-01f, 1.07089795e-01f,
  9.19460598e-03f, -8.69478732e-02f, 2.62554120e-02f, -5.58229387e-02f, -2.41124276e-02f, -1.23068597e-02f, -1.23295322e-01f, 5.39168008e-02f, -3.53053622e-02f, -1.48760360e-02f,
  4.00314070e-02f, 4.81112413e-02f, 2.54459381e-02f, 9.64957699e-02f, -6.26873691e-03f, 9.95490048e-03f, -7.52006397e-02f, 2.89847106e-02f, 4.32231501e-02f, -3.23943123e-02f,
  -4.50687623e-03f, 3.66247795e-03f, -1.74020007e-01f, -1.21661179e-01f, 5.97475432e-02f, -6.37854487e-02f, -7.20805228e-02f, 1.05412407e-02f, 1.30861580e-01f, 2.06957627e-02f,
  -7.10678622e-02f, -4.40199114e-02f, -4.25793417e-02f, -4.23899628e-02f, -1.73586950e-01f, 7.07512572e-02f, 6.11960217e-02f, -5.89694493e-02f, 1.31967887e-01f, -4.78611998e-02f,
  1.18456185e-01f, 1.95340589e-01f, 4.36026081e-02f, -1.49029419e-01f, 4.12532687e-02f, 1.60531551e-02f, -3.03927157e-02f, -4.44639847e-02f, 1.09944388e-01f, 1.75940637e-02f,
  1.12080097e-01f, 1.25272632e-01f, 2.84860525e-02f, -1.12780131e-01f, 3.54888663e-02f, 7.40308464e-02f, -9.48145613e-03f, -1.17740914e-01f, -1.23096012e-01f, 1.94385365e-01f,
  8.21418390e-02f, -8.74850899e-02f, -2.03355793e-02f, -4.90863062e-02f, -1.26229832e-02f, -4.43601348e-02f, -1.82570203e-03f, 7.62171745e-02f, -9.42888632e-02f, -4.39601466e-02f,
  -3.99632193e-02f, 2.64639407e-01f, -3.14969033e-01f, -2.97325253e-01f, -2.78065294e-01f, 1.21478304e-01f, 1.72230080e-01f, -1.61857069e-01f, -9.29213315e-02f, 3.13688219e-01f,
  -3.28550935e-02f, -8.54832157e-02f, 2.80814886e-01f, 2.58106086e-02f, 5.20431846e-02f, 3.94241601e-01f, 1.29093930e-01f, 4.74708825e-02f, 5.03848270e-02f, 4.34285179e-02f,
  -1.31811708e-01f, 2.28902876e-01f, -2.31462970e-01f, -7.34996870e-02f, -1.89650699e-01f, -2.39003584e-01f, -1.18343987e-01f, -2.29356214e-01f, -2.12390035e-01f, -1.35999605e-01f,
  -4.08863425e-02f, -5.21845669e-02f, -7.32849911e-02f, 2.19972990e-02f, 3.48067004e-03f, -6.94733560e-02f, -1.21046923e-01f, 2.42675152e-02f, -9.72035229e-02f, -8.31851587e-02f,
  4.30308506e-02f, 1.96016222e-01f, 1.25902399e-01f, -1.15540009e-02f, -1.32061884e-01f, -9.30094346e-02f, -1.61523819e-02f, -9.39694885e-03f, 2.48119421e-02f, 1.40532246e-02f,
  -8.96937400e-02f, -7.23445788e-02f, -2.12455899e-01f, 3.47862020e-02f, -2.05416143e-01f, -6.05227873e-02f, 6.40728474e-02f, -6.88385814e-02f, -4.33388399e-03f, 1.24806128e-02f,
  -9.24794897e-02f, -1.87426452e-02f, 1.44591346e-01f, -9.56560224e-02f, 8.85245800e-02f, -9.57502704e-03f, -7.18118716e-03f, 4.09019850e-02f, 2.12266855e-02f, -5.58713684e-03f,
  -7.55619432e-04f, -9.85555723e-03f, 6.09224550e-02f, 5.85574135e-02f, -1.31672127e-02f, 7.12697953e-02f, -1.14121102e-01f, 2.66527291e-02f, -9.66622382e-02f, -9.38241780e-02f,
  -5.48273027e-02f, 1.41286990e-02f, 9.79351625e-02f, -3.78321223e-02f, 4.25681137e-02f, -1.31127238e-01f, -7.74068236e-02f, -2.37325337e-02f, 1.30703643e-01f, -2.47182306e-02f,
  2.34342348e-02f, 1.10960841e-01f, 1.05821818e-01f, 1.66944116e-01f, -9.23987702e-02f, 3.44763771e-02f, 1.58814266e-02f, -7.19073042e-02f, 1.93330441e-02f, 6.90856129e-02f,
  -2.47858502e-02f, 5.85347936e-02f, -1.01097152e-01f, 7.51715247e-03f, 9.17396415e-03f, 7.28485212e-02f, -4.30659316e-02f, -1.96239678e-03f, -5.94866350e-02f, -1.35451676e-02f,
  7.42914453e-02f, 1.12327486e-01f, 8.73262659e-02f, 1.18192114e-01f, -8.00330713e-02f, 8.39686766e-02f, 9.28181857e-02f, -4.97115515e-02f, -9.45237800e-02f, 8.72997791e-02f,
  -4.93717730e-01f, 4.85009730e-01f, -1.30576149e-01f, 9.53654647e-02f, -2.18929067e-01f, 6.80274010e-01f, 4.40124512e-01f, 1.80004552e-01f, 2.83096611e-01f, 2.55363792e-01f,
  3.51349998e-04f, 1.67171031e-01f, -8.46030470e-03f, 3.21804672e-01f, -1.24488762e-02f, 2.64692247e-01f, 3.36123228e-01f, 3.17526877e-01f, 2.50426847e-02f, -8.25924426e-02f,
  -1.69917285e-01f, 1.11189172e-01f, -1.35290697e-01f, -1.10672750e-01f, -5.88397272e-02f, -1.93434879e-01f, -2.64160156e-01f, -2.19309315e-01f, 7.56148025e-02f, 6.88913986e-02f,
  -1.02285162e-01f, -2.93283373e-01f, -2.13347495e-01f, -1.45311665e-03f, -1.84002534e-01f, -5.83334938e-02f, -9.90340188e-02f, -1.34355389e-02f, -1.38354957e-01f, -3.17100585e-02f,
  -2.26813238e-02f, -3.16649530e-04f, -6.42504394e-02f, -5.65786362e-02f, 3.68571132e-02f, -5.82157187e-02f, 2.06923876e-02f, 4.59617898e-02f, 7.73411766e-02f, -5.43110259e-02f,
  8.27675611e-02f, 9.40321609e-02f, -7.98436329e-02f, 1.38614446e-01f, -4.47849035e-02f, 2.25085150e-02f, 1.14512801e-01f, 8.32325593e-02f, 1.76665932e-01f, 1.84568644e-01f,
  3.38843353e-02f, -2.08284743e-02f, 1.05682842e-01f, 2.68118680e-02f, -3.96130420e-02f, -5.22156358e-02f, 4.69215401e-02f, 2.16684435e-02f, -5.07054329e-02f, 3.27664316e-02f,
  2.05216072e-02f, -6.60526659e-03f, 2.30829120e-02f, 6.10943791e-03f, 3.57315503e-02f, 5.99882565e-02f, -3.57249491e-02f, 8.76556430e-03f, 1.48653552e-01f, 4.67304662e-02f,
  -3.96313071e-02f, 2.82228971e-03f, 1.53863905e-02f, -8.16199556e-02f, 1.03588477e-01f, -6.37685508e-02f, -5.58699965e-02f, 3.73013951e-02f, -5.69299124e-02f, -7.56328600e-03f,
  4.85249758e-01f, 3.34109187e-01f, 2.98595671e-02f, -5.02425060e-02f, -7.04433024e-02f, -3.29800881e-02f, -6.54511601e-02f, -7.61676356e-02f, 1.16839550e-01f, -2.49314792e-02f,
  -1.21401995e-01f, -7.42342845e-02f, 1.55323269e-02f, 3.59735510e-04f, 9.34162736e-02f, 1.62028581e-01f, -1.38002429e-02f, -1.08520780e-02f, 6.55423626e-02f, -4.15604338e-02f,
  -1.35172857e-02f, -6.18236437e-02f, 4.33901846e-02f, -4.33198437e-02f, -5.20218797e-02f, -3.09675615e-02f, -1.61249731e-02f, -1.30857110e-01f, 3.81916016e-03f, 6.35549873e-02f,
  -6.88819945e-01f, 4.79588032e-01f, -1.11363508e-01f, -1.93115801e-01f, 4.09726381e-01f, 3.38214755e-01f, -1.95883825e-01f, 3.01736802e-01f, 2.42238477e-01f, -2.74200559e-01f,
  -2.58913249e-01f, -1.60661526e-02f, -3.25148888e-02f, -9.52226520e-02f, -2.51933094e-02f, 2.73287818e-02f, -5.44653721e-02f, -5.58419246e-03f, 4.41305757e-01f, -8.32696408e-02f,
  1.41419843e-01f, -1.55235723e-01f, -1.72517881e-01f, 2.81916529e-01f, -2.25676656e-01f, -8.47623274e-02f, -3.58465523e-01f, 1.55830130e-01f, -3.14137459e-01f, 1.73400939e-01f,
  -2.87357390e-01f, -1.39880136e-01f, -3.30573529e-01f, -1.85665920e-01f, -2.40816876e-01f, -7.48312995e-02f, -1.15391761e-01f, 5.33445738e-02f, 3.59061435e-02f, 4.78367992e-02f,
  -1.61274359e-01f, 1.93534140e-02f, 1.93427280e-01f, 9.66029465e-02f, -1.20827137e-03f, -3.18585262e-02f, -3.32236141e-02f, -1.62844956e-01f, 1.02070346e-01f, 8.79163519e-02f,
  -3.46410531e-03f, 5.23582706e-03f, -2.21753210e-01f, 1.40732974e-02f, -1.13648921e-01f, -4.91503552e-02f, 3.04731447e-02f, -1.53436810e-02f, -1.38359785e-01f, -1.26736220e-02f,
  -1.56067479e-02f, 2.46513531e-01f, -9.14479420e-02f, -5.20791113e-02f, 7.06904382e-03f, 8.10223669e-02f, -4.29714546e-02f, 1.04320925e-02f, -6.60200696e-03f, -7.38523304e-02f,
  -3.53834406e-02f, 2.89544687e-02f, 3.14949639e-02f, 1.39809445e-01f, -4.16616201e-02f, -1.13862805e-01f, -1.67293236e-01f, -4.89362851e-02f, 2.68627354e-03f, -9.80460346e-02f,
  4.24422286e-02f, 3.27073522e-02f, -2.39250204e-03f, 1.56243220e-02f, -4.41778973e-02f, -5.30588105e-02f, 4.68406267e-02f, -5.70419021e-02f, 7.07588047e-02f, 1.06873631e-01f,
  -1.78095978e-02f, 1.40125424e-01f, -9.26691666e-02f, -9.57473889e-02f, 1.09694891e-01f, 1.42193893e-02f, 1.20276213e-01f, -5.71701974e-02f, -6.06956193e-03f, 2.50415727e-02f,
  -1.54415414e-01f, -7.05677941e-02f, -6.83277398e-02f, 6.76504076e-02f, 1.67207811e-02f, -9.88329481e-03f, -1.25886142e-01f, 6.48635626e-02f, -5.29788435e-02f, 6.31965324e-02f,
  -7.44646713e-02f, 5.92353418e-02f, -9.68970284e-02f, 2.36448608e-02f, -1.91534199e-02f, -2.10088164e-01f, 7.15248585e-02f, 8.33574906e-02f, -9.65855792e-02f, 2.22682729e-01f,
  1.93024904e-01f, 1.34987175e-01f, -3.05600435e-01f, -6.52969033e-02f, 4.45810482e-02f, 4.45526868e-01f, 3.00715178e-01f, 1.70237094e-01f, 2.28207618e-01f, 2.68969804e-01f,
  1.94426984e-01f, 5.35497032e-02f, 1.15712592e-02f, 2.60154635e-01f, 1.26246050e-01f, 3.07796061e-01f, 3.40886563e-01f, 2.65903980e-01f, 8.44901279e-02f, 2.00640976e-01f,
  -1.99571848e-02f, 3.04875374e-01f, -2.29114741e-01f, -4.94264886e-02f, 1.83623296e-03f, -2.50424474e-01f, -1.66562334e-01f, -1.99640021e-01f, 5.17458543e-02f, 1.03387469e-02f,
  4.32040766e-02f, 7.57309347e-02f, -3.74829993e-02f, -5.96090630e-02f, 2.49504717e-03f, -7.28098676e-02f, -2.13040859e-02f, -1.59656733e-01f, -6.38459623e-02f, 2.29365565e-02f,
  4.95392680e-02f, 7.74067193e-02f, 1.37170151e-01f, 4.54016365e-02f, 3.83575037e-02f, -3.63154337e-02f, -6.01515062e-02f, -6.67493865e-02f, 1.90581381e-02f, -6.05422407e-02f,
  2.69128047e-02f, -2.34102868e-02f, 6.89747855e-02f, -4.89917658e-02f, -1.73859240e-03f, 7.85711557e-02f, 3.03372648e-02f, -9.43102539e-02f, 8.18730220e-02f, 2.39798818e-02f,
  -4.48863618e-02f, 9.26093236e-02f, 1.07421979e-01f, 2.21607052e-02f, -7.15307817e-02f, -1.63043551e-02f, -3.42597775e-02f, -1.52114648e-02f, -7.51527548e-02f, 2.03151163e-02f,
  -1.11235201e-01f, -1.21535674e-01f, 4.68844473e-02f, 4.34179939e-02f, 7.86681175e-02f, 7.64994547e-02f, -1.53524848e-02f, 1.50881270e-02f, -1.70925073e-02f, -2.10472289e-02f,
  -8.26686993e-02f, 7.75602609e-02f, -3.72980013e-02f, -4.31081727e-02f, -5.82642816e-02f, -5.26689067e-02f, 1.59126073e-02f, -4.40383330e-02f, -4.81696390e-02f, -7.72390738e-02f,
  1.31179258e-01f, 1.91562414e-01f, -6.34761527e-02f, 5.78755587e-02f, -1.09913185e-01f, 1.17240377e-01f, 7.76212588e-02f, 8.78520906e-02f, -2.37716250e-02f, 1.36928573e-01f,
  -5.07609099e-02f, 3.58848572e-02f, 6.81609884e-02f, 1.15422010e-02f, -2.47238073e-02f, 1.04178898e-01f, 2.32395548e-02f, -4.15527336e-02f, -4.74138446e-02f, -2.82219686e-02f,
  -8.07470158e-02f, 2.03523695e-01f, 1.18146744e-02f, 1.19612321e-01f, -5.22006713e-02f, 1.88972556e-03f, 8.82973820e-02f, -4.98917848e-02f, -1.13256365e-01f, 2.50082668e-02f,
  9.44719464e-02f, 6.83874357e-03f, 2.11928755e-01f, -2.19186574e-01f, 7.59505704e-02f, -3.17966461e-01f, -3.00787121e-01f, -2.54819423e-01f, 1.17999770e-01f, -2.26623163e-01f,
  -7.02008232e-02f, 2.59297848e-01f, 7.75084794e-02f, -2.88602352e-01f, -6.60230592e-02f, 4.63254899e-02f, -3.86196464e-01f, -1.86672375e-01f, 9.01678018e-03f, -2.19194680e-01f,
  -2.49133885e-01f, -2.66439497e-01f, -1.13826320e-01f, -2.01572508e-01f, -1.73647255e-01f, -1.03621490e-01f, -3.00703824e-01f, 5.59581518e-02f, -2.15433478e-01f, 7.45994970e-02f,
  6.63731396e-02f, 1.61707118e-01f, 1.99939266e-01f, 1.19579984e-02f, -1.09551683e-01f, 5.77921327e-03f, 1.04077673e-02f, -2.33374792e-03f, -4.28037271e-02f, 2.25320030e-02f,
  -2.34924499e-02f, -8.59726965e-03f, -1.80869177e-01f, 1.77217975e-01f, 6.39407933e-02f, -1.66828930e-02f, 7.17385486e-02f, 3.81207876e-02f, 1.50517225e-01f, 2.08436608e-01f,
  1.37480482e-01f, 8.63566250e-02f, 1.28517263e-02f, -3.33510488e-02f, 9.69231352e-02f, -5.67498840e-02f, -3.48922238e-02f, 6.52440190e-02f, -1.06404148e-01f, -6.97003603e-02f,
  -1.12348497e-01f, -1.01406477e-01f, 7.13918358e-02f, 1.19863920e-01f, 1.31425768e-01f, 1.23183668e-01f, 9.59069878e-02f, 9.18498039e-02f, -4.30190787e-02f, -5.94605692e-02f,
  -3.18036228e-02f, 8.05381387e-02f, -4.65368070e-02f, -8.23827088e-02f, -2.12215453e-01f, 4.78202626e-02f, 9.24102888e-02f, -1.17284261e-01f, -6.86570033e-02f, -1.35053694e-01f,
  -5.56439348e-02f, -9.81309637e-02f, 7.84736723e-02f, -2.89390441e-02f, -1.26463458e-01f, 1.90377772e-01f, -6.64932802e-02f, 8.40010792e-02f, 6.15987293e-02f, -2.12309742e-03f,
  -1.62863135e-01f, -1.32151991e-01f, -8.23885575e-02f, 1.11290686e-01f, 6.57729059e-02f, 2.86310129e-02f, -8.62630606e-02f, -1.61708668e-01f, -1.09733418e-01f, -1.65140733e-01f,
  -2.42011681e-01f, -1.68290913e-01f, -1.54275835e-01f, 5.03344238e-02f, -6.06611595e-02f, -1.76512171e-02f, -1.50570318e-01f, 2.34954488e-02f, -5.35152964e-02f, -1.42145216e-01f,
  -1.72710985e-01f, -9.48383883e-02f, 1.96568407e-02f, -2.22617071e-02f, -1.52042300e-01f, 4.96060774e-03f, -1.02535479e-01f, 4.74960096e-02f, -4.94956821e-02f, -5.64493760e-02f,
  -2.45657116e-02f, -3.42527032e-01f, -4.46128756e-01f, 2.20809877e-01f, 3.80466044e-01f, 1.38797611e-01f, 2.11180091e-01f, 1.55059099e-01f, -9.55904201e-02f, 6.08672313e-02f,
  -2.73329262e-02f, -4.68569070e-01f, -2.44147554e-01f, -2.89267331e-01f, -2.96100646e-01f, -4.11938787e-01f, -1.10516936e-01f, -1.49910972e-01f, -2.79066980e-01f, -1.84154287e-02f,
  -1.57139439e-03f, 9.78447199e-02f, -8.87362510e-02f, 1.90284908e-01f, 3.04607183e-01f, 1.91489637e-01f, 3.12429935e-01f, 3.22201140e-02f, 1.08951412e-01f, 8.02960768e-02f,
  -6.27597347e-02f, -1.95521548e-01f, -1.56146763e-02f, 1.23584695e-01f, 9.40039977e-02f, 2.56563306e-01f, 6.83624893e-02f, -4.73063961e-02f, 2.02388354e-02f, -5.76634891e-02f,
  -5.66696329e-03f, 2.96465284e-03f, -1.89733077e-02f, -9.48941857e-02f, 9.86238047e-02f, 5.00539318e-03f, -1.68271840e-01f, 6.91281855e-02f, -7.63104632e-02f, -2.54309744e-01f,
  -3.25251110e-02f, -6.83758035e-02f, 1.27875447e-01f, -1.39692903e-01f, -1.11467086e-01f, -5.11226095e-02f, 4.29207683e-02f, -7.92206824e-03f, 3.05326711e-02f, 6.32121041e-02f,
  4.50595059e-02f, 3.40844020e-02f, -3.29099149e-02f, -6.72484487e-02f, -1.28635556e-01f, 1.45802528e-01f, -5.17492043e-03f, -7.33204465e-03f, -3.11409533e-02f, 2.56479196e-02f,
  -6.00651093e-03f, 8.67903531e-02f, -1.03220493e-02f, 3.73117849e-02f, -3.38432305e-02f, 1.33875534e-01f, 4.64464687e-02f, -1.00150123e-01f, -2.86073536e-02f, -5.28261736e-02f,
  9.23594236e-02f, 1.11081721e-02f, -2.84624361e-02f, 7.87670687e-02f, -1.09276086e-01f, -1.31975591e-01f, 6.08865283e-02f, -1.20337596e-02f, 9.99124497e-02f, 5.79087622e-02f,
  -2.35879123e-02f, -1.05213314e-01f, 4.12443280e-02f, -1.54402955e-02f, -1.15150750e-01f, 4.53289710e-02f, -5.79700992e-03f, -7.16899261e-02f, -4.71070334e-02f, -1.32294307e-02f,
  1.53469920e-01f, 1.91423237e-01f, 7.16103241e-02f, -1.44192502e-01f, 7.53026530e-02f, 1.22868352e-01f, 8.90467092e-02f, 4.99776006e-02f, 1.76340267e-01f, 5.15364285e-04f,
  1.19288713e-01f, -9.91824269e-02f, 1.34353176e-01f, 1.55072868e-01f, 3.18682520e-03f, 4.41177301e-02f, 4.64944541e-02f, -3.77464816e-02f, -6.06533140e-02f, -9.25034110e-05f,
  3.24950486e-01f, 3.20362091e-01f, 4.68553789e-03f, 1.73491970e-01f, -7.92998914e-03f, 1.91172063e-01f, 1.31040558e-01f, -1.88093752e-01f, -2.57216722e-01f, 1.69923916e-01f,
  -1.48991659e-01f, 3.29108030e-01f, -1.23885170e-01f, 3.39823589e-02f, -1.40045211e-01f, -3.19568276e-01f, 8.19438919e-02f, 9.44389403e-02f, -1.90222383e-01f, 3.78739625e-01f,
  -1.65085807e-01f, 9.44157839e-02f, -2.43258879e-01f, -1.30739629e-01f, 3.22382569e-01f, 3.38127792e-01f, 6.42520413e-02f, 5.52731901e-02f, 2.33677551e-01f, -2.65037734e-02f,
  -1.16303690e-01f, -3.52910273e-02f, 5.12119234e-02f, 1.02246270e-01f, 8.76907911e-03f, 5.10484762e-02f, 1.21258557e-01f, -5.29136993e-02f, -5.09973913e-02f, 5.13390414e-02f,
  1.17986955e-01f, 1.14498444e-01f, 9.02701244e-02f, -1.11471593e-01f, 9.38369036e-02f, 5.06236851e-02f, 7.27894381e-02f, 1.30621120e-01f, 7.62404650e-02f, 1.24868751e-02f,
  1.52200237e-01f, 1.02219917e-02f, 4.94503006e-02f, 1.65227339e-01f, 2.21910924e-02f, 1.46106500e-02f, 1.90821305e-01f, 1.58858299e-01f, 4.57954258e-02f, 6.52201623e-02f,
  1.28179267e-01f, 5.72489388e-02f, 7.95677975e-02f, -5.82635030e-02f, 1.95968002e-02f, -1.12602320e-02f, -1.47883415e-01f, -9.44800004e-02f, 2.80968435e-02f, 6.15125783e-02f,
  8.53509456e-02f, 6.58557639e-02f, -1.27777502e-01f, -3.55939195e-02f, 1.12991989e-01f, -4.99071516e-02f, 1.93216954e-03f, 2.14700624e-01f, 8.31493065e-02f, -1.61267966e-01f,
  4.66052536e-03f, -1.18612433e-02f, 6.20580688e-02f, -1.82217866e-01f, -1.10425815e-01f, 8.63750428e-02f, -7.52638578e-02f, -2.20065899e-02f, -3.12652178e-02f, -1.77701831e-01f,
  3.83135565e-02f, 2.40921140e-01f, 9.12028644e-03f, 2.59799901e-02f, 4.16855216e-02f, 1.26051635e-01f, -9.91052464e-02f, 8.61782879e-02f, 1.38794705e-01f, -7.03907311e-02f,
  9.55009013e-02f, 1.54890111e-02f, 1.37694210e-01f, 1.68076247e-01f, 2.93811206e-02f, 1.07414149e-01f, 7.02007860e-02f, 1.05843127e-01f, 2.54263040e-02f, 1.53972790e-01f,
  8.44302848e-02f, 5.22782765e-02f, 1.54368309e-02f, -2.07276605e-02f, 1.42356962e-01f, -1.71413608e-02f, 1.58446625e-01f, 9.08940658e-02f, 9.54138301e-03f, 6.01148605e-02f,
  -1.69703230e-01f, -1.47234872e-01f, -3.34774971e-01f, -2.60116220e-01f, 2.91727871e-01f, 5.65566480e-01f, -1.20145440e-01f, -2.75032818e-02f, -3.34550381e-01f, 2.02965513e-01f,
  1.97554648e-01f, -2.53812343e-01f, -3.43947172e-01f, -4.01356816e-02f, -6.24526925e-02f, -2.29157731e-01f, 2.08696216e-01f, 2.57060230e-02f, -7.97782764e-02f, -1.39982272e-02f,
  -1.01351157e-01f, 8.33213106e-02f, -2.55754918e-01f, 2.62743831e-01f, 1.58321738e-01f, -2.98712961e-03f, 1.88818574e-01f, -5.38426191e-02f, 3.92986774e-01f, 4.11216617e-02f,
  5.73695414e-02f, -2.41307586e-01f, -1.20356135e-01f, -7.90588111e-02f, 5.61550148e-02f, 9.67354923e-02f, 2.03592926e-01f, -5.11542335e-02f, 6.62890822e-03f, -1.94446400e-01f,
  -2.02997718e-02f, -2.88966503e-02f, -9.13832784e-02f, 5.11513688e-02f, 2.30689440e-03f, 4.37163822e-02f, 1.31697366e-02f, -3.67912762e-02f, -3.69311273e-02f, -1.10254526e-01f,
  -2.30839029e-01f, -7.58059770e-02f, 6.65497705e-02f, 1.12926243e-02f, 6.89872131e-02f, 8.47048461e-02f, 1.06087059e-01f, 2.95581874e-02f, 1.44956917e-01f, -8.28477088e-03f,
  1.05160236e-01f, 5.36340959e-02f, -7.68489018e-02f, -1.58961266e-02f, -7.09892511e-02f, 5.24347499e-02f, 1.39409408e-01f, 2.70462893e-02f, 1.71686038e-02f, -4.96668555e-03f,
  4.75774333e-02f, 9.36906859e-02f, 9.51978788e-02f, 1.06148981e-02f, -3.05125657e-02f, -3.62255760e-02f, -1.70228984e-02f, -3.02827377e-02f, 5.46617210e-02f, -7.22377151e-02f,
  -2.63856929e-02f, 3.55774835e-02f, 7.82657601e-03f, -3.91980167e-03f, -3.20353508e-02f, -7.03707486e-02f, 2.29021423e-02f, 7.41786370e-03f, -1.45864077e-02f, 3.62560079e-02f,
  1.71895936e-01f, 2.01059625e-01f, -9.09453258e-02f, -6.88785613e-02f, -4.56131920e-02f, -1.00063616e-02f, -2.95962505e-02f, 6.40808344e-02f, 6.77833408e-02f, 5.68649843e-02f,
  8.00136700e-02f, 4.54016700e-02f, 2.39347041e-01f, -1.22065827e-01f, 4.20933515e-02f, 3.23625505e-02f, 8.94037932e-02f, -3.59079102e-03f, 1.12849332e-01f, 5.08497395e-02f,
  -4.27495651e-02f, 8.28336105e-02f, -1.09344028e-01f, 8.41647536e-02f, 9.28679705e-02f, -4.45934609e-02f, 1.28307432e-01f, -1.15304112e-01f, 6.85446411e-02f, -3.36252414e-02f,
  -2.04802245e-01f, -8.54776129e-02f, 3.44047785e-01f, 2.50828713e-01f, -1.76598877e-01f, -1.90415874e-01f, 8.69592279e-02f, -1.48875087e-01f, -1.86701298e-01f, -1.85391620e-01f,
  6.48045819e-03f, 3.74207705e-01f, -1.35264575e-01f, 2.23311007e-01f, 4.04112071e-01f, 9.35684517e-02f, -7.19093233e-02f, -1.55770499e-02f, -1.36469528e-02f, 6.10286742e-02f,
  6.17279895e-02f, 1.62680551e-01f, 2.33158305e-01f, -5.38352765e-02f, 1.96851447e-01f, 3.53189200e-01f, 3.77117872e-01f, 3.15375030e-01f, 2.58445591e-01f, 3.67156357e-01f,
  -2.60635793e-01f, 1.64922010e-02f, -2.29696155e-01f, -1.30708799e-01f, -1.95375588e-02f, -5.40629663e-02f, 1.40986070e-01f, 1.72049433e-01f, 1.72178939e-01f, 1.63973290e-02f,
  1.49795497e-02f, 4.66894209e-02f, 8.92696977e-02f, -9.31403786e-03f, -2.02171609e-01f, 1.34473909e-02f, -1.68289095e-02f, -2.26899996e-01f, -9.55066830e-03f, -7.90122300e-02f,
  -1.35551710e-02f, -1.86418772e-01f, -6.51657134e-02f, 6.08897675e-03f, 3.00891012e-01f, -1.96692064e-01f, -3.07975411e-02f, 2.10661255e-02f, 7.24884793e-02f, 4.80479710e-02f,
  3.40570025e-02f, -3.04823392e-03f, -1.97645593e-02f, 1.63617600e-02f, -7.10927173e-02f, -1.22731738e-01f, -4.80748229e-02f, 4.77124937e-02f, 9.22481567e-02f, 3.19099352e-02f,
  -8.06661248e-02f, 9.79217235e-03f, -1.04495011e-01f, -1.58015236e-01f, 1.16043231e-02f, 2.75871996e-03f, 1.01405635e-01f, 1.72436901e-03f, -2.62082051e-02f, 4.79899980e-02f,
  6.90030158e-02f, -1.13418857e-02f, 1.13771610e-01f, -2.20974013e-02f, -1.37463465e-01f, 5.15657142e-02f, 1.98084056e-01f, -1.13258027e-01f, 5.64771779e-02f, 1.33210078e-01f,
  3.31274793e-02f, 2.71917999e-01f, 3.09766363e-02f, -2.10567474e-01f, 7.81782493e-02f, -1.30161587e-02f, -4.51550782e-02f, -1.23303689e-01f, 1.89452216e-01f, 4.74672094e-02f,
  -1.67141721e-01f, 6.61651194e-02f, -8.36454239e-03f, -4.80912765e-03f, -1.30007621e-02f, 1.06971942e-01f, 5.76025508e-02f, 5.33609129e-02f, -6.28855303e-02f, -7.79809803e-02f,
  -5.61862849e-02f, 4.91678864e-02f, 8.28962401e-02f, 2.80224402e-02f, -1.05159432e-01f, 2.79626157e-02f, -3.02124284e-02f, -1.50770858e-01f, 6.06740005e-02f, 5.70150428e-02f,
  -4.29852080e-05f, 4.96575654e-01f, 1.74209952e-01f, 5.25293112e-01f, 1.33404002e-01f, -4.14912522e-01f, -3.20988894e-01f, 1.21523663e-01f, -3.14817727e-01f, -1.81345373e-01f,
  2.73275763e-01f, -1.81451350e-01f, -6.97649596e-03f, 3.87364656e-01f, -1.88575983e-01f, 2.17259586e-01f, 7.67129660e-02f, -2.44157091e-02f, -4.89167571e-02f, 2.83461779e-01f,
  5.32446578e-02f, 2.60625720e-01f, 2.94004619e-01f, 1.01743944e-01f, 1.14946119e-01f, 1.57905534e-01f, 4.06991318e-02f, -1.16747126e-01f, 6.13239184e-02f, -2.51776516e-01f,
  3.21055693e-03f, 1.34213299e-01f, -1.09519124e-01f, -1.45813689e-01f, -6.19978495e-02f, -2.74235215e-02f, -1.76002592e-01f, -2.06568927e-01f, -8.16148669e-02f, -1.93580478e-01f,
  -9.55641121e-02f, 3.16299424e-02f, -8.84000733e-02f, -9.58451182e-02f, 1.14905261e-01f, -8.06234553e-02f, 5.04968036e-03f, -2.02020422e-01f, 9.55663919e-02f, 1.01371676e-01f,
  1.10166952e-01f, 7.91837275e-02f, -1.97669007e-02f, -1.01996474e-01f, -5.77661791e-04f, -7.35637825e-03f, -1.02297671e-01f, -5.32193780e-02f, 2.68581733e-02f, -1.16427662e-02f,
  -8.23037326e-02f, -1.26019903e-02f, 2.14896783e-01f, -5.67509281e-03f, -3.19615640e-02f, 1.52534870e-02f, -2.51480266e-02f, 3.48540302e-03f, -9.47076902e-02f, 7.70629197e-02f,
  -8.91249403e-02f, 1.73810139e-01f, 1.03813671e-01f, -1.06258638e-01f, -7.01093897e-02f, -1.79423001e-02f, -4.81602922e-02f, -5.31649068e-02f, -1.24756552e-01f, 3.22953947e-02f,
  -6.37486996e-03f, 1.33464988e-02f, -4.56524491e-02f, -9.55130160e-02f, -7.99164325e-02f, -8.92906561e-02f, 1.44459382e-01f, 4.76364009e-02f, -4.48198169e-02f, -4.72380221e-03f,
  3.54862250e-02f, 1.35653675e-01f, -1.58694595e-01f, -7.81939849e-02f, -1.09719060e-01f, 6.36978447e-02f, -1.66554675e-01f, 3.58015783e-02f, -1.01189628e-01f, -8.62376466e-02f,
  -1.03347994e-01f, -6.09344542e-02f, -1.34744078e-01f, -3.19935270e-02f, 3.35641135e-03f, -6.97303936e-02f, 2.66268309e-02f, -3.81695889e-02f, -8.90545640e-03f, -6.00360818e-02f,
  1.26577646e-01f, -3.17220204e-02f, 8.85540992e-03f, 2.13332716e-02f, 4.80958410e-02f, -8.54131579e-02f, -5.23877740e-02f, -1.19821355e-02f, 9.02963430e-02f, -3.66744250e-02f,
  1.30199134e-01f, -2.84617811e-01f, -1.99476674e-01f, -1.89047992e-01f, 6.36058450e-02f, -9.82337594e-02f, -2.08240300e-01f, -1.40812561e-01f, -3.56545985e-01f, -1.76203564e-01f,
  -4.40347008e-02f, 1.57716982e-02f, -2.36261403e-03f, -3.91413003e-01f, -1.35384127e-02f, -9.95342657e-02f, -2.70559162e-01f, -1.08712733e-01f, -1.35796443e-01f, -1.86839681e-02f,
  -1.83643252e-01f, -2.79262811e-01f, -1.49625972e-01f, -1.07903294e-01f, -2.13407040e-01f, 1.39262423e-01f, 3.76737714e-01f, -3.01935505e-02f, -1.69268046e-02f, -6.21820539e-02f,
  -8.84784386e-02f, -1.99317381e-01f, -2.12071091e-02f, -8.26404244e-02f, 6.30141646e-02f, 7.21928999e-02f, -2.92382501e-02f, -2.13110466e-02f, -1.09761477e-01f, -2.08291728e-02f,
  9.54015628e-02f, 9.36668180e-03f, -1.39216427e-02f, -5.70687233e-03f, 2.56756824e-02f, -1.07579187e-01f, -5.18093146e-02f, 1.24840237e-01f, -6.02339208e-02f, 5.76206762e-03f,
  -3.28770801e-02f, 8.22260603e-02f, 3.57671604e-02f, 1.02826864e-01f, 3.33986885e-04f, 4.21615280e-02f, 6.26485422e-02f, 2.97898620e-01f, -5.23538291e-02f, 1.98198985e-02f,
  4.87418706e-03f, 1.17821179e-01f, 6.83283284e-02f, -1.67105272e-01f, -1.26265824e-01f, -1.11141384e-01f, -4.00113082e-03f, -1.23903923e-01f, 2.63348836e-02f, -1.25347912e-01f,
  4.52235527e-02f, -4.30291370e-02f, -7.99877122e-02f, 6.29769191e-02f, 1.04737833e-01f, -8.85239840e-02f, -8.73910040e-02f, 6.62931055e-02f, 1.33396327e-01f, 6.83203414e-02f,
  -9.53986198e-02f, -3.40671726e-02f, 6.34627491e-02f, 1.04731932e-01f, -6.28903210e-02f, 2.15886801e-01f, 4.13637870e-04f, 1.73605569e-02f, 5.94242625e-02f, -3.64214554e-03f,
  8.64049941e-02f, 7.79009014e-02f, -9.51463133e-02f, -4.78697568e-03f, 1.56347491e-02f, -1.75866652e-02f, -1.19901419e-01f, -1.14252977e-02f, 6.30727708e-02f, -8.13682377e-02f,
  1.60923809e-01f, 7.46523738e-02f, 7.61470795e-02f, 1.18874069e-02f, -1.28846347e-01f, 2.90505327e-02f, -3.10420115e-02f, 7.27476105e-02f, -5.89730730e-03f, 1.08347580e-01f,
  1.05304278e-01f, 8.93081725e-02f, -6.69151396e-02f, -3.19975764e-02f, 1.07049577e-01f, 2.11832672e-01f, 1.43371224e-01f, 8.26227143e-02f, 4.03725496e-03f, 2.07916759e-02f,
  3.90734166e-01f, 3.59730721e-01f, 9.90599319e-02f, 1.51801839e-01f, -2.18528420e-01f, -8.40194970e-02f, -1.61756665e-01f, -3.41415815e-02f, 3.03074718e-01f, 7.70901889e-02f,
  -1.51567802e-01f, 2.29374975e-01f, -8.86376798e-02f, 1.52883753e-01f, 3.95669341e-01f, 5.29536679e-02f, 3.46652895e-01f, -1.41190807e-03f, 1.29308939e-01f, 2.76104480e-01f,
  2.35183969e-01f, 2.88783878e-01f, -1.42001510e-02f, 7.76634738e-02f, 8.40594843e-02f, -5.73387742e-02f, 1.10832984e-02f, -1.76641434e-01f, 6.97360709e-02f, -7.16164410e-02f,
  -2.86916289e-02f, 2.08137125e-01f, -4.25390713e-02f, 2.00124886e-02f, 2.33693235e-02f, -4.46899757e-02f, -2.54019210e-03f, -5.51747531e-02f, -6.55264268e-03f, -8.28363076e-02f,
  2.12128282e-01f, 1.69484038e-02f, 2.59419959e-02f, -8.24033991e-02f, 6.44613728e-02f, 9.31485593e-02f, 2.95031331e-02f, 1.52896093e-02f, -3.09642637e-03f, 9.33574140e-02f,
  9.73246396e-02f, -2.63970345e-02f, 1.62658274e-01f, 5.94158508e-02f, 1.34334783e-03f, 1.90653965e-01f, 4.18759957e-02f, 1.82839725e-02f, -1.78522728e-02f, 2.65098035e-01f,
  1.08139999e-01f, -3.07822041e-02f, 9.60312858e-02f, -7.51652122e-02f, 7.47195110e-02f, 4.36909124e-02f, 5.42092063e-02f, -1.19729988e-01f, -3.10598873e-02f, -1.77934878e-02f,
  -6.15466423e-02f, -4.28129621e-02f, -2.16965936e-02f, 1.89648010e-02f, 1.86453119e-01f, 1.24659933e-01f, -1.10281095e-01f, -3.15189622e-02f, 7.49557838e-02f, 1.29833454e-02f,
  -5.36075495e-02f, 3.54523002e-03f, -5.41699976e-02f, -1.28150761e-01f, -7.69982189e-02f, -8.91827717e-02f, 7.71873370e-02f, 2.85472665e-02f, -5.29293530e-02f, -9.22620445e-02f,
  1.50037944e-01f, 2.72209078e-01f, -2.72999089e-02f, 6.38218150e-02f, 4.01068553e-02f, 1.12638324e-01f, 1.38987675e-01f, 1.12019926e-01f, 1.58223480e-01f, 7.08688945e-02f,
  1.10912114e-01f, -2.56153550e-02f, 9.84562561e-03f, -3.09440531e-02f, -1.98289193e-02f, 2.48185739e-01f, 1.26414120e-01f, 7.07144141e-02f, 1.44456225e-02f, 6.08612373e-02f,
  -7.71719366e-02f, 1.08505711e-02f, 9.40192714e-02f, 8.10690597e-02f, 6.29512444e-02f, 1.39656439e-01f, -3.75736244e-02f, -9.64100137e-02f, -5.55747189e-03f, 3.80897671e-02f,
  1.64845243e-01f, -2.13847652e-01f, -2.15916350e-01f, -2.77597934e-01f, -2.41980717e-01f, -5.82473688e-02f, 8.92558247e-02f, -2.92576820e-01f, -2.10490018e-01f, -6.50905296e-02f,
  -1.90724358e-01f, 2.05161162e-02f, 3.02647769e-01f, -3.34954768e-01f, 2.73429334e-01f, 2.69268155e-01f, -1.10609412e-01f, 1.69485033e-01f, -1.90417275e-01f, -2.16488779e-01f,
  -7.20415115e-02f, -1.41553432e-01f, 1.31292552e-01f, -2.87302852e-01f, -2.87867665e-01f, -2.79885113e-01f, 7.91968703e-02f, -1.63450047e-01f, -3.05207849e-01f, -9.60860401e-02f,
  -8.47291648e-02f, -1.98664114e-01f, -9.62123647e-02f, 5.90760373e-02f, -7.95098916e-02f, 6.46387506e-03f, 1.64870843e-02f, 1.13683276e-01f, -9.55443010e-02f, -3.59711275e-02f,
  1.42784568e-03f, 1.47446236e-02f, -9.77665782e-02f, 1.21040903e-01f, -1.95586309e-02f, -2.04295427e-01f, 1.40239717e-02f, -2.69032996e-02f, -1.31415904e-01f, 6.44071326e-02f,
  -6.82563037e-02f, -1.10538617e-01f, -3.27839404e-02f, 6.70642778e-02f, -1.20573514e-03f, -1.42405853e-01f, 4.72454689e-02f, 3.09762415e-02f, -8.61079618e-02f, -1.08844392e-01f,
  8.28483701e-02f, 2.57635266e-02f, -1.88062303e-02f, -4.67598513e-02f, -3.05030383e-02f, -2.41029412e-02f, 4.47554402e-02f, 9.54368487e-02f, 8.19482431e-02f, 2.13275235e-02f,
  -6.03579730e-02f, -3.10559254e-02f, -9.80524421e-02f, 1.24852315e-01f, -5.05166426e-02f, -8.99101570e-02f, 2.24964060e-02f, -8.60144943e-02f, -8.97243917e-02f, -8.52824096e-03f,
  4.89084013e-02f, -2.26070527e-02f, 1.00767110e-02f, 5.16238958e-02f, 1.30918948e-03f, 4.90774773e-02f, -1.21550411e-02f, 9.09473151e-02f, -1.03944086e-01f, 9.79106426e-02f,
  -1.12008728e-01f, -2.43060380e-01f, -7.85281733e-02f, -1.23684546e-02f, 1.09077487e-02f, -1.95196196e-02f, 2.59976145e-02f, -1.12609580e-01f, -6.22877628e-02f, 1.11322394e-02f,
  -5.41717410e-02f, 8.99452493e-02f, -1.11077234e-01f, -5.48276491e-02f, -9.73768067e-03f, -1.00766733e-01f, 5.12425862e-02f, -3.23896180e-03f, 8.03444162e-02f, -7.52932653e-02f,
  1.10193744e-01f, -2.09249128e-02f, 1.43725753e-01f, -4.64346372e-02f, 2.86066160e-03f, -2.67455466e-02f, -2.64560245e-03f, -5.39851040e-02f, 1.92150418e-02f, 8.42506438e-03f,
  -6.78992569e-02f, -3.65812063e-01f, -1.02685146e-01f, 4.77296203e-01f, 2.82331020e-01f, -3.40374202e-01f, -4.13210899e-01f, 2.45202959e-01f, 4.64288220e-02f, -4.75701302e-01f,
  -1.67716280e-01f, -3.61846119e-01f, -3.77039254e-01f, 1.65571749e-01f, 2.53298968e-01f, -1.35062397e-01f, 3.48373026e-01f, -4.67581907e-03f, 3.15875053e-01f, 3.08431119e-01f,
  4.89971906e-01f, 3.97201538e-01f, 3.37127179e-01f, 3.37187886e-01f, 2.31405482e-01f, 1.49582326e-01f, 2.75183201e-01f, 2.06242520e-02f, 1.48613811e-01f, -1.74426943e-01f,
  -2.45314129e-02f, 3.80739272e-02f, -2.48897839e-02f, -3.76750492e-02f, -6.14573655e-05f, -1.01400837e-01f, -2.82236431e-02f, -1.20113716e-01f, 1.09673806e-01f, -2.71583954e-03f,
  -7.77758360e-02f, 1.83821887e-01f, 9.80777517e-02f, 2.25078571e-03f, -3.45241316e-02f, 1.01832315e-01f, 1.02579139e-01f, 5.74652925e-02f, 6.97440468e-03f, 1.74293779e-02f,
  4.47214022e-02f, 4.31657992e-02f, 5.88230267e-02f, -1.38675468e-02f, 4.02468480e-02f, 1.78043414e-02f, -2.93183718e-02f, -1.05631523e-01f, -6.02494576e-04f, -6.74553216e-02f,
  -4.96890061e-02f, -7.00560957e-02f, -7.62542263e-02f, 3.51789370e-02f, -1.75997429e-02f, -4.78715748e-02f, 1.49640697e-03f, -7.68351778e-02f, 3.38956974e-02f, -1.20585166e-01f,
  1.02261513e-01f, 4.96745743e-02f, 3.54184322e-02f, 3.41533199e-02f, 7.86226094e-02f, 4.43546250e-02f, 6.71284646e-03f, 1.16544135e-01f, 8.05767104e-02f, 6.76731989e-02f,
  7.77468905e-02f, 8.37908909e-02f, -6.76142201e-02f, 1.45287603e-01f, -1.78107936e-02f, -4.85501178e-02f, 3.56272943e-02f, -4.58335988e-02f, 1.11097634e-01f, 7.71177486e-02f,
  -1.17000483e-01f, -2.32140735e-01f, -5.31804562e-02f, 5.17576411e-02f, -2.23219600e-02f, 7.21537769e-02f, 8.72020721e-02f, 4.06690650e-02f, -1.04864858e-01f, -4.69780527e-02f,
  9.56917033e-02f, 3.38066295e-02f, -3.01232263e-02f, -7.46283028e-03f, 2.79746242e-02f, 6.69067120e-03f, 4.38097082e-02f, -1.23250440e-01f, -5.76445274e-02f, 9.64792445e-02f,
  6.31503314e-02f, 1.72161479e-02f, -2.30699927e-02f, 1.56582594e-01f, 3.70875746e-02f, -1.50260523e-01f, 3.40304375e-02f, -8.42614546e-02f, 6.24552518e-02f, -3.77362501e-03f,
  -2.26210058e-01f, 3.32058042e-01f, 1.72658637e-03f, -3.24091107e-01f, -1.21044256e-01f, -1.99777633e-01f, -2.49510884e-01f, 6.85155243e-02f, 2.22377583e-01f, 3.10570091e-01f,
  -1.30918369e-01f, 2.27045029e-01f, 2.59575784e-01f, -6.33170009e-02f, -2.31620446e-01f, 6.20282479e-02f, -2.32758924e-01f, -1.58452794e-01f, 8.59171003e-02f, -1.81733832e-01f,
  -7.96064213e-02f, -9.11003873e-02f, -2.70368904e-01f, 7.42401555e-02f, -2.75710940e-01f, -3.25036608e-02f, -3.57827067e-01f, -8.93645808e-02f, -2.75272936e-01f, -7.56217465e-02f,
  -2.68113673e-01f, -2.46465668e-01f, -2.65524864e-01f, -1.64172590e-01f, -2.76117418e-02f, -1.03148043e-01f, -2.29933262e-01f, 1.72640644e-02f, -1.04081184e-01f, 1.14075840e-01f,
  2.09444895e-01f, 2.43165763e-03f, -4.36197110e-02f, 1.04523100e-01f, 2.48490367e-02f, -4.99121174e-02f, -3.08058131e-02f, -2.24814519e-01f, -1.16358697e-02f, -8.75009075e-02f,
  1.66428700e-01f, -1.86560564e-02f, -4.25514579e-02f, -3.98035124e-02f, -2.25468516e-01f, -1.33462533e-01f, -1.30727842e-01f, -5.58625199e-02f, -5.71308695e-02f, -3.56711596e-02f,
  -5.22444099e-02f, -1.50032386e-01f, 7.47007132e-03f, 7.38012046e-03f, 6.91153333e-02f, 1.20951347e-01f, 5.17418012e-02f, 2.64494997e-02f, -6.03823252e-02f, 2.36903597e-02f,
  2.79474873e-02f, -5.99285103e-02f, 1.37687743e-01f, 3.93549986e-02f, 3.14623630e-03f, 1.82740703e-01f, -1.08584575e-01f, 2.05980250e-04f, 9.38275680e-02f, -1.62996110e-02f,
  -1.32292658e-01f, -1.28942251e-01f, 4.20391969e-02f, 4.06675274e-03f, 4.19699587e-02f, 8.20140094e-02f, 3.51736955e-02f, 1.62350625e-01f, 4.78455126e-02f, -8.80016237e-02f,
  -3.53468925e-01f, -3.08424622e-01f, -1.46939814e-01f, -6.94283992e-02f, -6.38098344e-02f, 5.29340580e-02f, -6.39613345e-02f, 2.99131274e-02f, -6.77055642e-02f, 3.61800566e-02f,
  1.46772265e-01f, 8.20079893e-02f, 2.97959205e-02f, 3.98975536e-02f, -5.41764731e-03f, -1.12313420e-01f, -1.35621682e-01f, -7.20648374e-03f, -2.10633531e-01f, -1.23481400e-01f,
  3.36615816e-02f, 3.05897743e-03f, 2.13507026e-01f, -5.69804087e-02f, 1.20193686e-03f, 5.37252575e-02f, -7.96639733e-03f, -7.33422488e-02f, -6.99818879e-02f, -7.70355090e-02f,
  1.44406259e-01f, -1.85356006e-01f, -3.27871323e-01f, -2.02967197e-01f, 5.66764176e-02f, -4.52009767e-01f, -3.49949569e-01f, -5.60535565e-02f, 1.44550294e-01f, 1.28072262e-01f,
  -3.90383638e-02f, -6.15360253e-02f, 1.42168671e-01f, -3.78683299e-01f, -4.81542617e-01f, -1.28902867e-01f, -4.55786943e-01f, -2.85256177e-01f, 8.03284571e-02f, -1.20164432e-01f,
  -1.31725088e-01f, -3.41677889e-02f, -2.83693612e-01f, 3.06922168e-01f, -1.45519376e-01f, 1.37085199e-01f, 2.47227058e-01f, 2.82960504e-01f, -2.60189563e-01f, -6.98498636e-02f,
  -9.12098661e-02f, 4.00958173e-02f, -1.40031919e-01f, -3.11733317e-02f, -9.29762125e-02f, -1.01561891e-02f, -1.48635358e-02f, -8.72407630e-02f, 2.90753897e-02f, -6.96772113e-05f,
  -4.18073637e-03f, 1.03349529e-01f, -5.41542023e-02f, 1.98064551e-01f, 1.75691068e-01f, 1.20009575e-02f, -5.45020215e-02f, -4.40166481e-02f, 3.99716608e-02f, -1.19455412e-01f,
  -1.77408293e-01f, -6.07356578e-02f, -3.52817494e-03f, -1.10368626e-02f, -7.94170797e-02f, -8.07714686e-02f, -1.80712506e-01f, -1.83778420e-01f, 5.45693114e-02f, -1.20146917e-02f,
  5.26128672e-02f, 4.38113101e-02f, 7.76268989e-02f, 1.50574714e-01f, -5.04882038e-02f, -3.85090858e-02f, 8.58479366e-02f, 5.57009839e-02f, 1.16187811e-01f, -3.78076844e-02f,
  1.09321021e-01f, -7.08636120e-02f, 4.92618755e-02f, 4.35853470e-03f, -7.95423761e-02f, 3.89540079e-03f, 3.83152030e-02f, 1.15683801e-01f, -1.19454011e-01f, -8.17207992e-02f,
  8.05059150e-02f, -7.28314668e-02f, 6.72199056e-02f, 2.77479552e-02f, -1.03221007e-01f, -2.39497423e-02f, 1.43138707e-01f, -3.48900519e-02f, -3.88113894e-02f, 2.48835888e-02f,
  -1.11185916e-01f, -3.51521443e-03f, 3.45290303e-02f, 8.17696378e-02f, -1.27840325e-01f, -1.93627067e-02f, -4.02066484e-02f, -8.03134218e-02f, -8.72765034e-02f, 1.33316815e-01f,
  -3.14366557e-02f, 7.32073784e-02f, 9.23544317e-02f, 2.95673460e-02f, -9.57449153e-02f, -8.86943862e-02f, -3.99498791e-02f, 5.60400784e-02f, -1.11433983e-01f, -7.34446123e-02f,
  1.38508961e-01f, 7.17023909e-02f, 1.98493246e-02f, 3.32609825e-02f, 1.31587595e-01f, 1.97974611e-02f, 4.33748737e-02f, 1.01041697e-01f, 5.58884181e-02f, -6.53873608e-02f,
  3.91594350e-01f, 5.23033291e-02f, 2.20032468e-01f, 3.17796469e-01f, 9.54984799e-02f, 9.98712257e-02f, 2.86207795e-01f, 1.62360042e-01f, 5.60536504e-01f, -3.14333051e-01f,
  -1.01984262e-01f, -1.47765711e-01f, -1.95624322e-01f, -9.23445448e-02f, -1.09308064e-01f, -1.50227427e-01f, 2.28794307e-01f, -3.09490412e-02f, 2.79313564e-01f, 1.02630623e-01f,
  1.63094208e-01f, -3.55952770e-01f, -3.59798484e-02f, -3.43904585e-01f, 9.07793939e-02f, 2.76493549e-01f, -3.28433573e-01f, -7.24616041e-03f, -3.11900139e-01f, -8.05481672e-02f,
  1.22344993e-01f, 1.35200605e-01f, 9.64657813e-02f, 1.10349052e-01f, 7.67022520e-02f, -8.38224739e-02f, 6.55011274e-03f, -9.43976864e-02f, 1.41539261e-01f, -2.95399819e-02f,
  2.64426833e-03f, -1.59047887e-01f, 2.61825789e-02f, -2.68017761e-02f, 2.19853178e-01f, 7.87754953e-02f, 1.55086160e-01f, 2.21890897e-01f, 5.65285869e-02f, -4.60748300e-02f,
  1.36141689e-03f, 2.16660672e-03f, 1.60953522e-01f, -2.00827885e-02f, 1.29083395e-01f, 2.33699217e-01f, 7.61918770e-03f, -1.98767215e-01f, 1.05772555e-01f, 3.83974835e-02f,
  -1.20197766e-01f, 1.09705590e-02f, -1.50293577e-02f, 5.43252602e-02f, 4.96263318e-02f, 9.74365398e-02f, -7.54929483e-02f, -4.14366536e-02f, 8.73195902e-02f, -4.49146032e-02f,
  1.16788179e-01f, 1.14749838e-02f, 7.02497512e-02f, 1.01830550e-01f, -3.93882208e-02f, 3.93398218e-02f, -1.22567460e-01f, -1.16645381e-01f, 8.26480463e-02f, 8.78902245e-03f,
  2.39213966e-02f, 1.42643750e-01f, -1.12861522e-01f, -1.07364222e-01f, -2.40742005e-02f, -2.34535150e-02f, -1.00009069e-01f, -1.23924859e-01f, 5.65036722e-02f, -9.71870199e-02f,
  -5.26709408e-02f, -3.06786373e-02f, 1.70829639e-01f, -8.20096117e-03f, -6.80736750e-02f, -7.83155337e-02f, -5.41628897e-02f, 2.35009217e-03f, 6.44492880e-02f, -4.77982759e-02f,
  -2.34282929e-02f, 3.22851464e-02f, -4.15452607e-02f, -1.01382963e-01f, 3.74087412e-03f, 3.18831578e-03f, 5.90515658e-02f, 1.66580617e-01f, 5.10793328e-02f, -1.06967948e-01f,
  1.96949625e-03f, 7.78905451e-02f, -9.39375442e-03f, 1.16697274e-01f, 7.95215517e-02f, -5.07246964e-02f, -1.10461622e-01f, 4.17634472e-02f, -9.15344656e-02f, 1.57221183e-02f,
  6.08547851e-02f, -4.40104544e-01f, 2.04794724e-02f, 5.52234463e-02f, 6.44150823e-02f, 3.59790027e-02f, 1.90368068e-04f, -3.34034503e-01f, -1.43643811e-01f, -3.63512367e-01f,
  -1.99366152e-01f, 3.38759363e-01f, -2.69478142e-01f, 5.63814724e-03f, 4.95916307e-01f, -4.28634137e-02f, -5.49500212e-02f, 9.39496756e-02f, -6.41906559e-02f, -2.33599007e-01f,
  3.91315147e-02f, -1.03785090e-01f, 1.03746958e-01f, -2.08831146e-01f, -1.84526846e-01f, -8.54304656e-02f, 8.42137933e-02f, 4.28770334e-02f, 1.79189727e-01f, 2.22140953e-01f,
  -2.72003771e-03f, -3.59388649e-01f, -8.27737227e-02f, 3.33074927e-02f, -2.61690497e-01f, 1.22019099e-02f, 1.86972111e-01f, 2.16579765e-01f, 1.27680913e-01f, 7.06144720e-02f,
  5.66490218e-02f, 2.48632669e-01f, -7.28464546e-03f, 1.81057319e-01f, 9.91019830e-02f, 6.35350272e-02f, 5.97786717e-02f, 9.48454370e-04f, -4.23021913e-02f, 4.51131165e-03f,
  -1.06986955e-01f, -7.12702125e-02f, -1.59276590e-01f, 8.35483372e-02f, -3.12890485e-02f, 1.22868335e-02f, 1.23220235e-01f, 1.63818389e-01f, 4.92682457e-02f, 7.01851621e-02f,
  -1.18998855e-01f, 2.50453758e-03f, -2.48750877e-02f, -3.90411280e-02f, -4.33290750e-02f, 3.53959128e-02f, 1.27965942e-01f, -5.24748117e-02f, 4.15514223e-02f, 1.42882881e-03f,
  -5.76552302e-02f, 2.22337767e-02f, -1.78417955e-02f, -6.72042146e-02f, -7.29992464e-02f, -4.39746380e-02f, 1.60029352e-01f, -2.07235059e-03f, -4.24184836e-02f, -3.83695774e-03f,
  6.90223416e-03f, 4.41822633e-02f, -4.22181450e-02f, -2.42391117e-02f, -7.88895935e-02f, -2.01057214e-02f, -5.30138873e-02f, -7.50195757e-02f, -8.16433728e-02f, 2.80538183e-02f,
  2.56513301e-02f, -3.85064453e-01f, -5.13465814e-02f, 1.50632039e-01f, 6.31312504e-02f, -2.22494733e-02f, 8.30972791e-02f, -8.31248462e-02f, 4.06430811e-02f, -4.60665002e-02f,
  1.27546415e-02f, 2.56660655e-02f, 8.96189827e-03f, 7.72109330e-02f, 1.20903343e-01f, -1.02539234e-01f, 3.88327390e-02f, 1.52308093e-02f, 7.15893134e-02f, -1.14471596e-02f,
  -6.20180368e-02f, 4.79738303e-02f, 6.07525744e-02f, -7.43417889e-02f, -1.46668786e-02f, 5.50523167e-03f, -3.74067435e-03f, -4.66511175e-02f, -4.20656521e-03f, -3.94432954e-02f,
  -4.37087774e-01f, 2.47438461e-01f, -1.03409775e-01f, 3.00134718e-01f, -1.22282505e-01f, -2.32242614e-01f, 9.43609178e-02f, 1.75395031e-02f, -7.80116990e-02f, 3.87145698e-01f,
  1.88947380e-01f, -2.01422244e-01f, 2.27867663e-01f, 3.59379917e-01f, -1.86557278e-01f, 3.09852697e-03f, 4.74969536e-01f, 8.30376893e-02f, -8.90120566e-02f, 1.36973277e-01f,
  -1.53574245e-02f, 2.03967154e-01f, 2.28339404e-01f, 6.83361664e-02f, 1.47475004e-01f, -5.29611968e-02f, 3.78680080e-01f, -1.15837634e-01f, 3.74911189e-01f, -1.17292784e-01f,
  1.12715855e-01f, 6.57019988e-02f, -8.15094337e-02f, -1.68318734e-01f, 1.19155832e-01f, -2.61210445e-02f, 2.13624351e-02f, -6.54988438e-02f, -8.51733163e-02f, 1.28255310e-02f,
  -7.46906549e-02f, -8.96583050e-02f, -2.00920664e-02f, -1.20401777e-01f, -1.49813935e-01f, -3.26208696e-02f, -1.08333603e-01f, 1.33344186e-02f, -3.51892747e-02f, -1.38075501e-01f,
  -1.75699126e-02f, 9.30434540e-02f, 1.47236079e-01f, 1.05274044e-01f, -1.56570282e-02f, -1.21435508e-01f, 8.19293410e-02f, 1.96922775e-02f, 3.17277759e-02f, -9.13902894e-02f,
  -1.02407411e-02f, 3.25768143e-02f, -3.53378318e-02f, -2.31025089e-02f, -6.97542578e-02f, 3.39586623e-02f, 9.27090365e-03f, -3.46749974e-03f, -9.60304216e-02f, 1.13237947e-01f,
  4.50528450e-02f, -9.67581198e-02f, 6.51686788e-02f, -1.23541988e-03f, -1.62961837e-02f, 4.04674634e-02f, -7.29818866e-02f, -5.14173582e-02f, 8.33684299e-03f, 1.88182257e-02f,
  1.02324225e-01f, -7.62201995e-02f, 1.20777846e-03f, 1.22606926e-01f, 5.23490310e-02f, -6.11006655e-02f, 1.08245956e-02f, -1.66938268e-02f, 3.11590172e-02f, 2.77714916e-02f,
  2.31460735e-01f, 1.89135149e-01f, 4.30277884e-02f, 2.00069696e-02f, 6.77505210e-02f, -8.38503018e-02f, 1.39260842e-02f, 1.98904295e-02f, 2.80615389e-02f, 1.06245950e-02f,
  9.34271440e-02f, 4.08123173e-02f, 1.51989579e-01f, -2.39387546e-02f, 8.30891803e-02f, 8.18293020e-02f, 1.32178858e-01f, 9.91285443e-02f, 1.83494002e-01f, 3.16340439e-02f,
  7.62713626e-02f, -1.07863642e-01f, 9.73235816e-03f, -3.21868099e-02f, 7.61593208e-02f, 7.16254339e-02f, -1.08801700e-01f, -3.05187460e-02f, 1.03246802e-02f, 1.62966684e-01f,
  4.63518977e-01f, -2.28651866e-01f, 1.08895503e-01f, 3.53556395e-01f, 2.23453760e-01f, 2.61086643e-01f, 3.39286298e-01f, 1.34256721e-01f, 4.89807248e-01f, -2.93054640e-01f,
  -1.87024713e-01f, -1.13582999e-01f, -1.89790886e-03f, -1.85805634e-01f, 4.32220489e-01f, 1.18600331e-01f, 2.80738801e-01f, 1.94111481e-01f, 2.27319270e-01f, 6.29964769e-02f,
  1.90362692e-01f, -9.76195261e-02f, -2.03717694e-01f, -2.98987806e-01f, -4.79138084e-02f, -1.96704060e-01f, -3.47047180e-01f, 3.01253218e-02f, -4.09324259e-01f, 1.07969359e-01f,
  -6.07104264e-02f, 9.78761911e-02f, -4.39399965e-02f, -1.26773417e-01f, 3.38930334e-03f, -2.03422131e-03f, -5.50960153e-02f, 2.30872612e-02f, 1.64894029e-01f, -4.35035378e-02f,
  5.00673167e-02f, -1.15409710e-01f, 2.26715952e-02f, 1.06992060e-02f, 1.14902608e-01f, -1.05041534e-01f, -1.30313903e-01f, -6.51277527e-02f, -5.13828248e-02f, -4.48502228e-02f,
  -2.88788769e-02f, -2.12426856e-02f, 6.54210076e-02f, -7.58086368e-02f, 2.47399583e-02f, -2.55290456e-02f, -1.04157515e-01f, 3.86970304e-02f, -4.10098247e-02f, 7.58370087e-02f,
  4.49552834e-02f, 1.15204141e-01f, -6.25433326e-02f, 7.22484887e-02f, -5.31289680e-03f, 1.72540974e-02f, -7.69124329e-02f, -9.55379233e-02f, 5.32919578e-02f, -9.44974720e-02f,
  2.72515211e-02f, -6.62554950e-02f, 7.82039613e-02f, -1.93276741e-02f, 7.17132315e-02f, 7.88103566e-02f, -3.58599797e-02f, -2.65434152e-03f, 6.77982345e-02f, 1.27500007e-02f,
  9.90837067e-02f, 1.43157586e-05f, -9.41440389e-02f, -1.81940682e-02f, -6.13445081e-02f, -4.56725098e-02f, -4.53951061e-02f, -7.59962108e-03f, 5.34124905e-03f, 7.24613443e-02f,
  5.20924702e-02f, 7.53120035e-02f, -7.02648461e-02f, -1.26781657e-01f, -5.69607913e-02f, -1.41009111e-02f, 1.83434784e-02f, -5.67282438e-02f, 7.65568838e-02f, 2.76160035e-02f,
  -6.05242467e-03f, -2.48626024e-02f, -5.01688570e-02f, -8.22545812e-02f, 6.06540684e-03f, -7.13058412e-02f, 2.20843758e-02f, 6.89343661e-02f, 7.56898075e-02f, -1.61202818e-01f,
  -6.18780069e-02f, 4.84328298e-03f, -4.06530276e-02f, 4.18547578e-02f, -5.87458163e-02f, 5.60364909e-02f, 4.79542129e-02f, 3.47000896e-03f, 5.26537038e-02f, -4.82877865e-02f,
  -6.17367662e-02f, 3.18352431e-01f, 2.53340364e-01f, 2.45930165e-01f, -3.52864832e-01f, -4.35921252e-01f, -3.00464243e-01f, -3.66226174e-02f, 8.74359161e-02f, -1.83412269e-01f,
  -2.65489638e-01f, 2.93474287e-01f, -5.15061654e-02f, 3.44609655e-02f, 2.55473256e-01f, 1.53185204e-01f, 3.61953117e-02f, -1.42338768e-01f, 2.12451220e-01f, 5.24581484e-02f,
  5.94823398e-02f, -2.37150952e-01f, 3.42337906e-01f, -1.07137568e-01f, -1.97816808e-02f, 2.15241194e-01f, 2.67964393e-01f, -9.68395248e-02f, 4.30467092e-02f, -1.46396421e-02f,
  5.47573939e-02f, 1.32799923e-01f, 1.10751770e-01f, 1.16979770e-01f, 2.90196408e-02f, -2.31044926e-02f, -9.34636220e-02f, 3.12741920e-02f, -6.62965104e-02f, 3.30924727e-02f,
  -9.81128067e-02f, -4.33991812e-02f, 9.98346284e-02f, -1.62645802e-01f, -2.48978585e-01f, 9.20251980e-02f, 1.41751617e-01f, 3.55737768e-02f, 1.70933917e-01f, -1.92579962e-02f,
  4.03969698e-02f, 6.62750304e-02f, 4.12463807e-02f, 1.14633575e-01f, 1.86412707e-01f, -5.27231172e-02f, -1.17917573e-02f, 1.14378616e-01f, 7.20574111e-02f, 1.24494612e-01f,
  4.00479995e-02f, 4.43648696e-02f, -3.60419378e-02f, -2.74765845e-02f, 7.44113559e-03f, -2.40036808e-02f, -1.33716557e-02f, -1.67283881e-02f, -5.52436197e-03f, 3.69978547e-02f,
  -3.31639461e-02f, 9.38238800e-02f, -1.18074976e-01f, -6.49100691e-02f, -7.77616873e-02f, -5.05318902e-02f, -2.74810959e-02f, -7.07367659e-02f, -2.28781737e-02f, 1.43008873e-01f,
  3.27197928e-03f, -1.42157555e-01f, 1.25611052e-01f, -2.47008260e-02f, -7.17008933e-02f, 8.92721415e-02f, 9.99626964e-02f, 8.96260664e-02f, 8.48864317e-02f, 1.16751768e-01f,
  1.81339711e-01f, 3.44583988e-01f, 1.17221080e-01f, 1.13893583e-01f, 1.24642424e-01f, 4.09143493e-02f, -6.81675524e-02f, 1.01367854e-01f, 2.33993277e-01f, -2.19603349e-02f,
  -1.64614975e-01f, -3.46142054e-02f, 6.31415024e-02f, -1.78302124e-01f, 6.58353344e-02f, 7.68660679e-02f, 9.91001651e-02f, 6.55092299e-02f, 1.73469678e-01f, 3.88584994e-02f,
  4.74748835e-02f, -8.47755149e-02f, 4.25129235e-02f, 5.88836242e-03f, -9.25991535e-02f, 1.19125575e-01f, -5.90102784e-02f, 1.24906249e-01f, 3.42995599e-02f, 1.37728035e-01f,
  -4.91898417e-01f, 2.35547051e-01f, -1.04345620e-01f, 1.04023077e-01f, -3.02085519e-01f, -3.12266290e-01f, -5.39341494e-02f, -8.84661004e-02f, 1.33814380e-01f, 3.95468146e-01f,
  3.40440124e-01f, -1.23935781e-01f, 2.65792191e-01f, 1.88131362e-01f, -5.07487833e-01f, 4.03245896e-01f, -7.52246976e-02f, 3.84602360e-02f, -4.79720160e-02f, -4.74655218e-02f,
  1.48636438e-02f, 1.06922403e-01f, -3.43417861e-02f, 2.31394634e-01f, -3.12185317e-01f, -9.32592899e-02f, 2.05876771e-02f, -5.99875338e-02f, -1.54701173e-01f, -3.18330973e-01f,
  -4.50677186e-01f, 4.30610124e-03f, -9.46711227e-02f, -1.92708522e-01f, -6.27619624e-02f, -1.46831736e-01f, -1.77246556e-01f, -3.57736573e-02f, -2.16560960e-02f, 3.78992036e-02f,
  -6.41797110e-02f, -2.48016585e-02f, 7.87433386e-02f, 1.41559497e-01f, -1.14174843e-01f, -2.12094802e-02f, -1.63699433e-01f, -2.22622454e-02f, -6.85312822e-02f, -1.56128466e-01f,
  -6.17244989e-02f, 2.45395955e-02f, 1.37077819e-03f, 6.99385852e-02f, -1.39254287e-01f, -6.06479831e-02f, -2.61601862e-02f, -4.89499941e-02f, -1.06434092e-01f, -4.27844040e-02f,
  4.74102125e-02f, 3.17060761e-02f, -1.39230147e-01f, -1.71318382e-03f, 1.17123403e-01f, 3.06399483e-02f, 1.30332503e-02f, 9.07925814e-02f, -2.18977574e-02f, 1.00625101e-02f,
  1.50974356e-02f, -6.77848905e-02f, -5.32283783e-02f, -7.98855275e-02f, 6.34353906e-02f, -5.04606478e-02f, -1.72783155e-02f, 3.18826288e-02f, 9.78972316e-02f, 1.81533918e-02f,
  7.40730092e-02f, -1.03495300e-01f, 4.68628258e-02f, -8.09496418e-02f, -9.13856626e-02f, -1.01921827e-01f, 3.70967500e-02f, -8.08164850e-02f, -1.40352875e-01f, -3.04995477e-02f,
  -5.24625540e-01f, -1.44062415e-01f, -1.46429211e-01f, -1.92962959e-01f, -4.97783758e-02f, -4.76106489e-03f, 7.53905773e-02f, -4.38691080e-02f, -7.19181374e-02f, 2.20435988e-02f,
  2.81046461e-02f, -4.35468964e-02f, -3.08838636e-02f, 6.02541380e-02f, 9.39830020e-02f, -6.94866329e-02f, -1.32572968e-02f, 1.23977378e-01f, -1.66312680e-01f, -8.24549794e-02f,
  7.25141093e-02f, 8.47158059e-02f, -9.63360304e-04f, -1.34800246e-03f, -7.03043565e-02f, -5.80189042e-02f, -2.75708809e-02f, -5.28133698e-02f, -1.85119241e-01f, -4.07816730e-02f,
  1.69195995e-01f, 2.34496724e-02f, -2.51362681e-01f, -2.32908614e-02f, -7.22732544e-02f, -4.67051603e-02f, -1.86989948e-01f, 2.85959207e-02f, -4.17306781e-01f, 1.46166563e-01f,
  1.58322737e-01f, -1.37055824e-02f, -2.17680916e-01f, 3.49746346e-01f, 3.19589913e-01f, -2.10719630e-01f, 2.52490580e-01f, 2.91342616e-01f, -1.66082457e-02f, 1.90285400e-01f,
  1.01697266e-01f, 3.51392806e-01f, 8.68532136e-02f, 2.76169300e-01f, 2.38078475e-01f, 1.99621886e-01f, 2.55898386e-01f, -3.45054865e-02f, 3.05597037e-01f, 1.99404478e-01f,
  1.00479916e-01f, -4.89587784e-02f, -7.17228651e-02f, 7.60609284e-02f, 4.62015159e-03f, -2.93973964e-02f, 9.92633253e-02f, 1.52959973e-01f, -7.71551430e-02f, 1.24270022e-02f,
  -6.10214248e-02f, -1.76232792e-02f, 7.13504851e-02f, -1.60016328e-01f, 1.04816653e-01f, -1.20295621e-01f, -1.09516054e-01f, -4.98801209e-02f, -2.89750546e-02f, 6.94501847e-02f,
  -1.30610973e-01f, 3.72452997e-02f, -2.26667076e-02f, -8.70988816e-02f, -1.68017596e-01f, -1.05881087e-01f, -9.16915983e-02f, -1.85382762e-03f, 6.12685084e-03f, -7.18649030e-02f,
  3.08132283e-02f, -1.15119573e-02f, -2.36318391e-02f, -3.01160160e-02f, -3.29411849e-02f, -9.13145393e-03f, 6.11792803e-02f, 1.01221666e-01f, -4.02810499e-02f, -4.11421359e-02f,
  -6.82160482e-02f, -1.17139712e-01f, 2.66749337e-02f, 2.77992748e-02f, 1.10584512e-01f, -1.30011244e-02f, 2.64371186e-02f, 6.56635761e-02f, -1.14576206e-01f, 7.22588971e-02f,
  -5.24796452e-03f, 4.07711603e-02f, -6.43951446e-02f, 1.22662812e-01f, 8.65383074e-02f, -1.91776648e-01f, 8.03111121e-02f, 1.05577958e-04f, -7.33195469e-02f, -1.70835555e-02f,
  4.89450954e-02f, 1.26283884e-01f, 4.55102138e-03f, -9.75839198e-02f, -9.81613770e-02f, 1.31415566e-02f, 2.56318748e-02f, 7.75618926e-02f, -2.51541268e-02f, -4.46312688e-02f,
  9.00382027e-02f, -3.96293327e-02f, 7.52570927e-02f, -4.82025705e-02f, -4.37114015e-02f, -7.52700791e-02f, -2.72163916e-02f, 6.43599872e-03f, -1.12844139e-01f, 1.83270022e-01f,
  4.00456227e-02f, -6.92656487e-02f, -1.26460446e-02f, -2.09359378e-01f, -7.48499036e-02f, 5.32483198e-02f, -6.10096268e-02f, -4.64255884e-02f, 1.33027032e-01f, -1.38685806e-02f,
  6.35162964e-02f, 2.81546593e-01f, 1.48893250e-02f, 1.21670336e-01f, -5.35179138e-01f, -2.77673870e-01f, -1.69019371e-01f, -7.53184855e-02f, 2.47341037e-01f, 2.94115216e-01f,
  -1.70267299e-01f, 1.58708379e-01f, 2.01434493e-01f, 5.73223755e-02f, -2.34050658e-02f, 4.28219557e-01f, 7.85870478e-02f, 1.90035164e-01f, -1.08589031e-01f, -1.38481647e-01f,
  -4.58510779e-02f, -3.65193754e-01f, -2.06951518e-02f, -3.96015108e-01f, -2.34678119e-01f, -3.73911113e-02f, -1.40806571e-01f, -2.98217446e-01f, -3.65068465e-02f, -1.46701515e-01f,
  -5.79370335e-02f, -8.64310861e-02f, 5.76760024e-02f, 7.44003206e-02f, -2.01692674e-02f, 6.96782023e-02f, -3.48458141e-02f, -1.30379856e-01f, -1.55252799e-01f, 7.72109777e-02f,
  2.31797155e-02f, -1.16400816e-01f, -8.85303915e-02f, -3.96827608e-02f, -8.46455395e-02f, 3.38106789e-02f, 2.56764255e-02f, 1.28052741e-01f, -1.39660910e-01f, 6.88682422e-02f,
  1.36737078e-01f, 2.13801451e-02f, 4.60740514e-02f, 1.28081843e-01f, -4.51870561e-02f, -1.32582456e-01f, 9.38557182e-03f, -7.95661937e-03f, 1.23410128e-01f, 3.66095244e-03f,
  2.20615696e-02f, -1.01931125e-01f, 3.68602201e-02f, -1.04915023e-01f, -5.88184744e-02f, -8.28507766e-02f, 6.09614626e-02f, -3.64943035e-02f, 7.57473856e-02f, -1.62103802e-01f,
  -1.49110585e-01f, 2.13642698e-02f, -8.82727876e-02f, 1.02573611e-01f, 4.30852883e-02f, 1.94249094e-01f, 1.43978661e-02f, -4.94291186e-02f, 1.40828416e-01f, 2.24110652e-02f,
  -2.66984571e-02f, 1.01709878e-03f, 5.16851805e-02f, -7.99352080e-02f, 5.53947827e-03f, -2.59353742e-02f, 9.41303596e-02f, 1.64650276e-01f, -5.46231493e-03f, -2.11876407e-01f,
  -1.97924480e-01f, -3.63074839e-01f, -5.69077814e-03f, 6.74102549e-03f, 3.22791375e-02f, 1.09090939e-01f, -5.53991422e-02f, 8.92456546e-02f, -2.17983171e-01f, -1.21124741e-02f,
  4.88973781e-02f, 1.23345450e-01f, -1.76453721e-02f, -8.51483420e-02f, -2.62370240e-02f, -1.14700180e-02f, 1.16067175e-02f, 9.74372178e-02f, -1.53538376e-01f, 1.29948976e-02f,
  -2.33918685e-03f, 6.81807920e-02f, 2.01774649e-02f, 8.79918318e-03f, 3.16736177e-02f, -5.79058230e-02f, -1.22032445e-02f, 8.71643648e-02f, -1.64041340e-01f, -4.19713035e-02f,
  -6.60839379e-02f, -1.59852784e-02f, -2.25610510e-01f, -3.89056742e-01f, -1.87348023e-01f, -1.07719287e-01f, -9.55255628e-02f, -2.58097082e-01f, -7.00980052e-02f, -1.84662774e-01f,
  -3.20665091e-01f, 3.77568677e-02f, 5.25984883e-01f, -3.29913557e-01f, 4.21519220e-01f, 3.47137511e-01f, -3.79715055e-01f, -2.03187749e-01f, 6.07800037e-02f, -9.93180126e-02f,
  -6.96944743e-02f, -1.47250012e-01f, 8.43846798e-02f, -1.52500346e-01f, -3.11837047e-01f, -3.43141496e-01f, -1.65589317e-03f, -3.67051102e-02f, -4.51701432e-01f, -3.49434800e-02f,
  -8.29197839e-02f, -4.07810926e-01f, -7.61126578e-02f, -2.73668710e-02f, -2.44360641e-01f, 3.26249823e-02f, -5.79939187e-02f, 8.32512155e-02f, -8.99936929e-02f, 1.74298196e-03f,
  1.56964958e-01f, 1.32925391e-01f, -9.64404568e-02f, 2.00761482e-01f, -2.71917414e-02f, -1.31200805e-01f, -1.39050409e-02f, -1.44746229e-01f, 2.82359067e-02f, 2.72711907e-02f,
  1.62987094e-02f, -2.83081625e-02f, -7.95814171e-02f, -7.14402795e-02f, 6.02921993e-02f, -1.18440829e-01f, 9.30191427e-02f, 4.50452529e-02f, -1.07737735e-01f, -1.22757867e-01f,
  -3.61644179e-02f, -1.38716102e-02f, -1.10288307e-01f, -7.32570365e-02f, -1.20821275e-01f, -5.35868146e-02f, 1.91910975e-02f, -3.77413332e-02f, 6.75847828e-02f, 6.65857941e-02f,
  4.00657626e-03f, -6.37060329e-02f, -6.83704019e-02f, 3.70138645e-04f, -9.55502465e-02f, 9.65259410e-03f, 4.12965491e-02f, 3.41925249e-02f, -2.57935245e-02f, 1.45734325e-02f,
  -1.85886268e-02f, -7.24529475e-02f, -4.39856946e-02f, -2.76258085e-02f, 1.76888648e-02f, 1.21875383e-01f, -4.63185087e-02f, -3.30711040e-03f, -1.77224278e-01f, 1.03434294e-01f,
  -7.28285685e-02f, -4.67345476e-01f, 6.32248223e-02f, -3.07118073e-02f, 6.11789636e-02f, -4.37941886e-02f, 3.06752007e-02f, 3.40082683e-02f, -1.08909369e-01f, -1.47863626e-01f,
  -2.37422496e-01f, 1.93701442e-02f, -1.21300235e-01f, -4.70250333e-03f, 1.10526986e-01f, -9.93026048e-02f, 7.05522206e-03f, -6.26650378e-02f, -6.99261352e-02f, -4.95071337e-03f,
  1.05059355e-01f, -1.10078668e-02f, 9.27488282e-02f, -4.18158099e-02f, -1.95351732e-03f, -9.41305235e-02f, -5.21904677e-02f, 2.37659756e-02f, -7.76405931e-02f, -4.91981469e-02f,
  3.95843297e-01f, -2.70845473e-01f, -9.42281708e-02f, 4.10638511e-01f, 1.45955086e-01f, 4.98802364e-02f, 1.44897460e-03f, 2.39394918e-01f, 2.73995668e-01f, -8.67535397e-02f,
  2.54699285e-03f, -2.06938624e-01f, -3.71083200e-01f, 3.97273719e-01f, -1.98491916e-01f, -3.21635365e-01f, 3.42538774e-01f, 1.54429704e-01f, 1.79128096e-01f, 1.13211561e-03f,
  7.85833746e-02f, 1.34442240e-01f, -1.70257673e-01f, 1.15353160e-01f, 9.11947638e-02f, 1.29836097e-01f, -1.51730895e-01f, -2.00312108e-01f, 1.79023504e-01f, 4.90712784e-02f,
  -1.43567175e-01f, 8.83487687e-02f, 7.50955567e-02f, -2.24411841e-02f, -6.55247271e-02f, -9.37987119e-02f, -1.40338257e-01f, -6.86131418e-02f, -8.24206546e-02f, 4.44498733e-02f,
  -4.06165868e-02f, 7.04826638e-02f, 1.03360660e-01f, -6.43618330e-02f, 1.43201903e-01f, -1.66028098e-03f, 7.35228434e-02f, 7.35451654e-02f, 1.41369216e-02f, -2.73126978e-02f,
  4.20608260e-02f, 6.19643964e-02f, 2.20393408e-02f, 5.83063401e-02f, 2.96445396e-02f, 1.06655940e-01f, 9.29712430e-02f, -7.13984072e-02f, 6.33520782e-02f, 1.62650853e-01f,
  -2.54746596e-03f, -7.78290480e-02f, -1.22727960e-01f, 3.28755081e-02f, -1.38204941e-03f, 7.61506781e-02f, -8.89835693e-03f, -1.03863828e-01f, -2.13438235e-02f, -8.54784921e-02f,
  1.59680918e-01f, 9.49902609e-02f, 9.96073931e-02f, -2.35877410e-02f, 1.06625326e-01f, 7.37057626e-02f, -2.61472259e-03f, -2.37114504e-02f, 9.44346189e-02f, 3.52676585e-02f,
  1.25895804e-02f, 1.18659437e-02f, -1.96181890e-02f, -6.01943582e-02f, 3.22540216e-02f, -5.26271760e-02f, 2.93872934e-02f, 1.68308727e-02f, 3.17011215e-02f, -1.46656066e-01f,
  -5.30392647e-01f, -4.66423124e-01f, -5.52115329e-02f, 5.43112792e-02f, -9.95721966e-02f, -1.14113063e-01f, -4.73312736e-02f, 1.38979644e-01f, -9.84445959e-02f, 1.54900514e-02f,
  -9.95553583e-02f, 2.90624592e-02f, -1.13066696e-01f, -2.53807218e-03f, -1.28605187e-01f, 5.42802960e-02f, -1.19790629e-01f, -7.03892037e-02f, -5.71412332e-02f, -5.32962754e-02f,
  -9.82307643e-02f, 1.26335090e-02f, 3.43407015e-03f, -1.74421426e-02f, 1.28126089e-02f, 7.21561606e-04f, -1.33377299e-01f, 5.03595211e-02f, -2.16516387e-02f, 2.92720869e-02f,
  -5.48391402e-01f, 1.54446855e-01f, -3.76198441e-02f, -4.23563242e-01f, 3.32774132e-01f, -8.23972672e-02f, -8.53837356e-02f, 3.89178932e-01f, -1.56957582e-02f, 7.68121853e-02f,
  -2.26697568e-02f, -3.14213514e-01f, 2.07657129e-01f, -2.72325486e-01f, -4.22097981e-01f, -1.47631690e-01f, -4.40518737e-01f, -3.09337586e-01f, -1.99053250e-02f, -1.54586256e-01f,
  -8.41696039e-02f, 1.20913222e-01f, -1.17700659e-01f, 3.41100216e-01f, 1.47278801e-01f, 1.69839442e-01f, 7.08201826e-02f, 3.46264333e-01f, -1.51512966e-01f, 1.11894235e-01f,
  -2.50277892e-02f, 6.07697405e-02f, 1.78194731e-01f, 6.94317594e-02f, -8.27359334e-02f, -2.18921639e-02f, -9.06914696e-02f, 7.19515160e-02f, -5.56213669e-02f, -3.91716585e-02f,
  -1.11187115e-01f, -7.13292062e-02f, -1.18897855e-01f, 9.98436511e-02f, 5.68558201e-02f, 2.63641085e-02f, -6.99475855e-02f, -1.12019507e-02f, 1.12205101e-02f, -5.01691811e-02f,
  -3.17401476e-02f, -2.25094065e-01f, -3.98267768e-02f, -1.24695569e-01f, -1.00612512e-03f, -5.62148355e-02f, -8.32336992e-02f, -5.18822260e-02f, -1.18808798e-01f, -6.63017780e-02f,
  2.54734233e-02f, -7.92577416e-02f, 8.22123364e-02f, 1.17300957e-01f, 3.74436006e-02f, 7.25478530e-02f, -1.35219008e-01f, -8.77970606e-02f, 4.99616051e-03f, -5.83902821e-02f,
  -1.36104092e-01f, 3.58129106e-02f, 1.79627419e-01f, -2.45186929e-02f, -1.05930120e-01f, -1.42034413e-02f, -1.25764996e-01f, -3.94799560e-03f, -3.43572535e-02f, -6.58673095e-03f,
  -1.84559990e-02f, -1.23447832e-02f, 1.06982365e-01f, -8.12387913e-02f, -2.57643070e-02f, 6.93703666e-02f, -4.83317561e-02f, 2.81789359e-02f, -9.35423002e-02f, -7.01943040e-02f,
  4.11945134e-02f, 6.82035014e-02f, 2.17576504e-01f, 1.05301633e-01f, -4.32710685e-02f, -1.30408958e-01f, -8.50516260e-02f, 4.36882265e-02f, 7.45141599e-03f, 1.44499108e-01f,
  -1.13606416e-02f, -9.58280414e-02f, -7.28518739e-02f, 1.24840088e-01f, -2.97343805e-02f, 3.73440385e-02f, -2.11069658e-02f, 3.05867884e-02f, 7.52145648e-02f, -4.51373719e-02f,
  -4.46142070e-03f, -1.22951858e-01f, 3.02762855e-02f, 8.86303782e-02f, 1.62095076e-03f, -4.98352796e-02f, -1.22735044e-02f, 8.31315592e-02f, -4.12960164e-02f, -6.57097027e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  4.19158369e-01f, 3.12081337e-01f, 3.83452445e-01f, 4.22965765e-01f, 3.01317453e-01f, 3.03496808e-01f, 2.87523955e-01f, 3.91072690e-01f, 3.47119510e-01f, 4.65106040e-01f,
  3.46353471e-01f, 1.80406019e-01f, 3.90570283e-01f, 3.78398120e-01f, 1.28568605e-01f, 3.39009523e-01f, 2.33797356e-01f, 4.51801002e-01f, 2.71850675e-01f, 1.68640867e-01f,
  4.73483950e-01f, 3.18853348e-01f, 3.71967882e-01f, 3.60918522e-01f, 1.85813889e-01f, 3.70781422e-01f, 3.88575941e-01f, 1.50988996e-01f, 3.87638062e-01f, 2.02574179e-01f,
  2.38195315e-01f, 3.40204209e-01f, 3.07626039e-01f, 3.33140254e-01f, 4.75643992e-01f, 2.62545526e-01f, 4.00259137e-01f, 4.12980080e-01f, 3.55433583e-01f, 2.64924288e-01f,
  3.36127937e-01f, 1.91656247e-01f, 3.39839101e-01f, 5.43148518e-01f, 4.25001591e-01f, 2.40524292e-01f, 3.21518630e-01f, 3.34803253e-01f, 2.08125532e-01f, 4.23513234e-01f,
  2.09299624e-01f, 3.63034636e-01f, 4.25138593e-01f, 3.74594957e-01f, 2.77623683e-01f, 3.19246858e-01f, 2.62708813e-01f, 4.17757362e-01f, 3.46362412e-01f, 1.89553499e-01f,
  3.73827159e-01f, 2.58912057e-01f, 4.29857820e-01f, 2.63869315e-01f, 2.71793395e-01f, 3.71593714e-01f, 3.22661161e-01f, 3.63038927e-01f, 4.09189641e-01f, 2.90811837e-01f,
  3.39700967e-01f, 2.63263494e-01f, 2.32590422e-01f, 3.79793674e-01f, 3.01086068e-01f, 3.83356035e-01f, 3.06033075e-01f, 5.00791192e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -9.57416818e-02f, -1.89251050e-01f, -1.78717464e-01f, -8.61789361e-02f, 8.89920741e-02f, 6.22602105e-02f, -3.36105712e-02f, 2.72868592e-02f, -1.38822719e-01f, -1.80489287e-01f,
  1.18929215e-01f, -1.28181323e-01f, 8.84642005e-02f, -1.69101670e-01f, -1.35598496e-01f, 1.58006959e-02f, -2.10767150e-01f, -2.87862699e-02f, -8.46456550e-03f, -2.04733480e-02f,
  -2.32851133e-02f, -2.34969810e-01f, -1.78692862e-01f, 9.64742526e-02f, -6.62844554e-02f, -1.13845505e-01f, 1.14173330e-01f, -2.02923372e-01f, -6.52310848e-02f, 1.43948227e-01f,
  2.39772528e-01f, 1.66323245e-01f, -2.37989753e-01f, 2.04368308e-01f, 1.73615813e-01f, 9.83269513e-02f, -1.78656429e-01f, 1.23686157e-01f, -4.06729393e-02f, -3.15019220e-01f,
  9.77690890e-02f, -9.34140012e-03f, -2.96806097e-01f, -1.63139120e-01f, 5.82943149e-02f, 1.92674831e-01f, -2.32306808e-01f, 1.85625479e-01f, 6.58430979e-02f, 6.12930469e-02f,
  -3.17704856e-01f, 1.33770540e-01f, -2.76821524e-01f, 6.87591732e-02f, -1.19792148e-01f, -3.20936352e-01f, -3.39230776e-01f, -2.99612373e-01f, 3.76155376e-01f, -2.90215522e-01f,
  -3.40459615e-01f, -1.41487449e-01f, -9.40145738e-03f, -1.50934860e-01f, 4.18514043e-01f, -9.85678062e-02f, -2.64147431e-01f, -1.73781157e-01f, 4.22611535e-01f, 1.65795296e-01f,
  -3.34680468e-01f, 2.13302076e-01f, 3.07763129e-01f, -2.80505657e-01f, -4.43203062e-01f, -2.35403050e-02f, -1.39629275e-01f, -1.56939149e-01f, -5.16899824e-01f, 5.09848781e-02f,
  5.35886772e-02f, 3.13075900e-01f, 2.69765526e-01f, 1.84161812e-01f, -1.79151744e-01f, -3.97931963e-01f, 2.68097430e-01f, -5.15080750e-01f, 8.57106298e-02f, -2.47848347e-01f,
  -4.61470753e-01f, -2.04170048e-01f, -1.41714752e-01f, -4.01057571e-01f, 2.56067455e-01f, -1.91039741e-01f, -3.14995050e-01f, -2.54399300e-01f, 4.12043989e-01f, 4.35405314e-01f,
  -5.61306207e-03f, 2.48562038e-01f, 2.07859516e-01f, -3.62567186e-01f, 4.51682992e-02f, -2.45945483e-01f, -3.97513285e-02f, -3.15623671e-01f, -7.21459463e-02f, -1.92970380e-01f,
  7.48486444e-03f, -3.05728883e-01f, -1.47738218e-01f, 1.88163206e-01f, -3.62318665e-01f, -5.92668764e-02f, -3.29145193e-01f, -1.87995806e-01f, -2.56233096e-01f, 4.45033908e-01f,
  -4.51175749e-01f, -2.87805665e-02f, 4.21977907e-01f, -2.39456315e-02f, 3.12913060e-01f, -6.08529709e-02f, 1.03813477e-01f, -2.10167781e-01f, 9.14526582e-02f, 1.11146845e-01f,
  9.67180878e-02f, -2.06190094e-01f, 3.33651602e-02f, -3.04810312e-02f, 7.22932518e-02f, -2.28106648e-01f, 1.62540957e-01f, 4.07727286e-02f, -2.33622923e-01f, 1.76674917e-01f,
  -4.86025261e-03f, 1.43003032e-01f, 1.59264103e-01f, -5.26501127e-02f, -1.96909264e-01f, -1.00062534e-01f, -1.99249402e-01f, -2.92579919e-01f, 4.54059429e-02f, 1.74323261e-01f,
  -8.79003331e-02f, -3.01203169e-02f, 1.88303575e-01f, -1.71112731e-01f, 4.63041328e-02f, -3.25506330e-01f, 2.55760133e-01f, -1.86944589e-01f, -2.33541131e-01f, -1.87436700e-01f,
  1.15495501e-02f, 6.53005093e-02f, 1.95451632e-01f, -3.75934273e-01f, -2.29958951e-01f, -5.77685721e-02f, -2.81387657e-01f, -7.28280023e-02f, 3.29025805e-01f, -2.27530256e-01f,
  2.94298917e-01f, -4.32815403e-01f, 4.12076652e-01f, -2.77714193e-01f, 1.22150980e-01f, 3.42131317e-01f, -2.10644364e-01f, 4.47698869e-02f, 1.32008135e-01f, 3.44326943e-01f,
  -1.52426645e-01f, -2.83477277e-01f, -2.69938052e-01f, -2.67721593e-01f, -5.10234386e-02f, -1.56735033e-01f, -1.82498351e-01f, -2.07506388e-01f, 3.81613523e-02f, -3.24773863e-02f,
  1.21296145e-01f, -2.29016542e-01f, -1.07650243e-01f, 3.21306884e-02f, -3.28670055e-01f, 1.18989117e-01f, 5.50047436e-04f, 3.42916727e-01f, -3.75920683e-02f, -3.22570294e-01f,
  8.54485407e-02f, -1.34786919e-01f, 3.03904980e-01f, 1.79662362e-01f, 4.40519422e-01f, 2.71955132e-01f, -1.72959715e-01f, -4.22601670e-01f, -3.49972665e-01f, -3.96323353e-01f,
  1.88310042e-01f, 1.32388875e-01f, -5.18317103e-01f, -2.99060285e-01f, 3.17805827e-01f, -3.50831032e-01f, -3.69996518e-01f, -4.57913995e-01f, 1.26815572e-01f, 4.17428613e-01f,
  3.79234672e-01f, -2.89511323e-01f, -1.30924553e-01f, -1.79029226e-01f, 3.59251589e-01f, -2.22926766e-01f, 2.27815926e-01f, -5.52138925e-01f, -9.55689978e-03f, 1.38210326e-01f,
  2.37203911e-01f, -8.56312141e-02f, 2.99191713e-01f, -9.06745866e-02f, -7.66271576e-02f, 1.77108973e-01f, 1.85850158e-01f, -3.16321820e-01f, 1.75790817e-01f, -7.15266988e-02f,
  9.11250412e-02f, 2.03608274e-02f, -2.44901791e-01f, -5.72333694e-01f, 9.07204747e-02f, -5.56297362e-01f, -2.52257377e-01f, 1.88234486e-02f, -9.89423692e-02f, -4.86544549e-01f,
  -5.51941514e-01f, 2.77260333e-01f, -3.88353080e-01f, -4.93273847e-02f, 2.25930419e-02f, -2.17656240e-01f, 3.21221240e-02f, -1.04136325e-01f, 2.19627246e-02f, -1.19848654e-01f,
  -1.91826940e-01f, 1.54217007e-02f, -2.08735839e-01f, -4.32444513e-02f, -1.51814789e-01f, -8.75411779e-02f, -1.47150904e-01f, -2.06434995e-01f, -8.74530971e-02f, -2.20118806e-01f,
  -2.89647821e-02f, -1.47032574e-01f, -4.83330823e-02f, -2.31956139e-01f, 2.65928544e-02f, -9.60488096e-02f, -2.07439199e-01f, -2.27954164e-01f, -5.02709337e-02f, -1.16065256e-01f,
  -1.39991855e-02f, 1.91491485e-01f, 1.04781248e-01f, -2.72354156e-01f, 1.95145264e-01f, -1.49986058e-01f, -1.14447415e-01f, -1.87081710e-01f, -2.63366729e-01f, -2.37958714e-01f,
  2.81937331e-01f, -8.31186101e-02f, 8.41224641e-02f, 2.38311291e-02f, 2.86045134e-01f, 1.58419251e-01f, 1.41877756e-01f, 2.82667466e-02f, 1.29279971e-01f, 3.68180014e-02f,
  -2.15965677e-02f, -1.12811141e-01f, -2.29073003e-01f, -2.35887051e-01f, 1.82783082e-01f, 3.60984541e-02f, 2.23351210e-01f, -2.40977734e-01f, -2.92367280e-01f, -2.27165744e-01f,
  2.04991221e-01f, -1.46812826e-01f, -2.04082653e-01f, 2.06308424e-01f, 1.91680238e-01f, -2.00579435e-01f, 1.87477544e-02f, -3.21851641e-01f, 3.30242187e-01f, -1.87785327e-01f,
  7.76909590e-02f, -2.23510638e-01f, 4.41582114e-01f, -7.82253146e-02f, -2.47144446e-01f, -1.12271663e-02f, 2.86891341e-01f, -5.17350547e-02f, -3.09059560e-01f, -1.22707330e-01f,
  1.94850892e-01f, -5.32107837e-02f, -4.73720580e-01f, 3.69456470e-01f, -1.51318625e-01f, -9.39847007e-02f, -9.45307761e-02f, -2.19259217e-01f, -3.51561964e-01f, 2.92756855e-01f,
  -2.35507697e-01f, -3.53764510e-04f, -6.75500855e-02f, -2.18884110e-01f, -3.55742782e-01f, 2.60609090e-01f, -2.54266486e-02f, -1.98268853e-02f, 2.70098984e-01f, 2.31045410e-01f,
  -4.19546634e-01f, -9.55867171e-02f, 2.54583091e-01f, -2.13355407e-01f, 2.24259540e-01f, -1.95136815e-01f, -3.35638940e-01f, -2.80525953e-01f, -2.95262933e-01f, 1.55651653e-02f,
  -1.88484982e-01f, -2.66400009e-01f, 2.61731923e-01f, -9.93072707e-03f, 2.30027825e-01f, 3.33122388e-02f, -1.50582865e-01f, -1.21665165e-01f, -1.46416843e-01f, -3.39838386e-01f,
  3.50588590e-01f, -2.23646015e-01f, -1.64632708e-01f, -2.67576128e-01f, 4.28534836e-01f, -1.33033141e-01f, -2.74520844e-01f, -3.72694850e-01f, -2.05146104e-01f, 2.46509209e-01f,
  -1.88371941e-01f, -3.00764650e-01f, 2.99003303e-01f, -2.87161283e-02f, 3.00336834e-02f, -5.18394969e-02f, 1.49976425e-02f, 1.93348862e-02f, 8.27986524e-02f, -7.49509260e-02f,
  -4.21967566e-01f, -2.58346021e-01f, 3.97508331e-02f, -4.18552496e-02f, -4.21904214e-02f, 5.47926277e-02f, -3.65536481e-01f, -2.25986503e-02f, 7.84661844e-02f, 1.41539678e-01f,
  -3.07811890e-02f, -2.93473631e-01f, -5.95064163e-02f, 1.61849931e-01f, -2.63813704e-01f, -1.61109835e-01f, -1.96209513e-02f, -3.10353898e-02f, -1.61612574e-02f, -3.18400651e-01f,
  -2.79719710e-01f, -2.05345020e-01f, -2.69402057e-01f, 2.81780779e-01f, 2.78141707e-01f, 2.57276446e-01f, 1.80442572e-01f, 3.87775116e-02f, -2.23506555e-01f, 2.18972147e-01f,
  2.27583230e-01f, 1.45213053e-01f, 1.62658781e-01f, -7.53080845e-02f, -9.28530172e-02f, 3.41592133e-01f, -1.38859883e-01f, 1.92979351e-01f, 6.97215572e-02f, -8.68812352e-02f,
  3.22165675e-02f, 7.56579190e-02f, -3.26775499e-02f, -3.31517577e-01f, -2.19228312e-01f, -2.48574302e-01f, -2.68236876e-01f, 1.36304125e-01f, -5.41652963e-02f, -1.74717054e-01f,
  1.26467302e-01f, -4.24922884e-01f, -1.84956387e-01f, 2.91356188e-03f, -5.89233264e-02f, -1.34931400e-01f, -7.28273690e-02f, -4.75550354e-01f, 1.73740432e-01f, 3.18291277e-01f,
  -3.54101866e-01f, -3.58887911e-01f, 1.22037135e-01f, -2.75612444e-01f, -1.54743403e-01f, -4.56749201e-01f, 2.91030854e-01f, 2.62783412e-02f, -5.58810234e-02f, -7.98688922e-03f,
  3.37911472e-02f, -1.84589103e-01f, -5.28500557e-01f, 3.87495726e-01f, 4.28006053e-01f, -8.74294862e-02f, -1.45761501e-02f, -3.87307554e-01f, -4.82361585e-01f, 3.98762077e-01f,
  -5.85803278e-02f, -1.45900697e-01f, 2.07946017e-01f, -1.26182914e-01f, 3.62651944e-01f, 3.08652639e-01f, -9.50324014e-02f, -5.29405534e-01f, -2.58152574e-01f, -2.12756190e-02f,
  -2.21525148e-01f, 9.80289876e-02f, -4.00052458e-01f, 3.54758352e-02f, -3.18120718e-01f, 6.57313541e-02f, -2.46312067e-01f, 3.14034313e-01f, -1.62869573e-01f, 2.59398133e-01f,
  -1.69242829e-01f, -2.20507890e-01f, -2.96818763e-01f, -1.12673163e-01f, 3.34800839e-01f, -3.62377018e-01f, -1.19907729e-01f, -2.76085466e-01f, -7.86153972e-02f, 3.23946685e-01f,
  3.10572565e-01f, -2.19183207e-01f, -2.87351668e-01f, -2.44164169e-01f, -2.53986120e-01f, -2.07678676e-01f, 3.60033810e-01f, -3.63477409e-01f, -3.45473468e-01f, 5.27197383e-02f,
  1.23884222e-02f, 4.39465731e-01f, -2.75122859e-02f, 2.65300900e-01f, 1.34693056e-01f, 1.71542481e-01f, -1.56293839e-01f, 1.62055314e-01f, 8.97195265e-02f, 1.38496652e-01f,
  -4.43404019e-02f, 1.88049585e-01f, 3.33093330e-02f, 1.10010907e-01f, 1.67297229e-01f, 8.33255947e-02f, -4.89586592e-02f, -1.57250807e-01f, 3.18563968e-01f, 4.87868488e-02f,
  1.59100175e-01f, 1.06069811e-01f, 6.24676328e-03f, -9.82865691e-02f, 1.41771898e-01f, -1.35891855e-01f, 1.25177547e-01f, 3.79294783e-01f, 6.07032329e-02f, -3.98086786e-01f,
  6.24682792e-02f, 3.79734784e-01f, -4.03158516e-02f, 1.56895131e-01f, -9.82640833e-02f, 1.98646024e-01f, 1.38653755e-01f, -8.49592965e-03f, 1.53866678e-01f, 4.69867140e-01f,
  4.15250808e-02f, 2.91193455e-01f, -2.71924317e-01f, -3.82665545e-01f, -4.10705537e-01f, -1.71187781e-02f, -2.43471712e-01f, 3.59335423e-01f, 1.35942757e-01f, 2.09043100e-02f,
  -5.13547175e-02f, 1.42086640e-01f, -1.62634999e-01f, -1.07005075e-01f, 2.29139075e-01f, 1.24518864e-01f, -3.60838711e-01f, -7.03251362e-02f, -2.53458172e-01f, 4.37517345e-01f,
  -4.17648941e-01f, -1.71622232e-01f, -1.66161895e-01f, 4.25910167e-02f, 2.84681678e-01f, 3.49854380e-01f, -2.55131006e-01f, -2.38770872e-01f, 4.20278311e-01f, -3.10617778e-02f,
  2.18551874e-01f, -2.89343596e-01f, -1.64331585e-01f, 3.67112607e-01f, -4.62983042e-01f, -4.52970535e-01f, -1.79397970e-01f, -3.11170757e-01f, -1.92547366e-01f, -2.58706629e-01f,
  2.02650309e-01f, 2.69646347e-01f, -2.09779948e-01f, 3.82336825e-01f, -6.06508963e-02f, 8.87547433e-02f, -8.09240565e-02f, 3.35750073e-01f, -5.85339405e-02f, -1.67939425e-01f,
  3.42384398e-01f, -4.02508914e-01f, 8.01291242e-02f, -1.70169055e-01f, -3.62013608e-01f, 2.86822289e-01f, 2.20678389e-01f, 7.84743875e-02f, 1.20673627e-01f, 4.19533104e-01f,
  -2.55851243e-02f, 1.53847069e-01f, 1.13065906e-01f, 2.35508066e-02f, 1.17562719e-01f, 2.78928190e-01f, -2.21739605e-01f, 9.75389928e-02f, -3.92367214e-01f, -4.80502367e-01f,
  1.97947267e-02f, -3.89844552e-02f, -7.27255121e-02f, -2.27797687e-01f, -2.24714011e-01f, -1.25374243e-01f, 2.68685222e-01f, 1.87298164e-01f, -5.18283844e-01f, -7.44698569e-02f,
  -1.52246013e-01f, -2.14880303e-01f, -4.14767057e-01f, 9.01704282e-02f, -1.24010228e-01f, 6.60690442e-02f, -7.12259337e-02f, 7.28813782e-02f, -4.80305664e-02f, 1.38129279e-01f,
  5.01111448e-02f, -1.32746160e-01f, 1.16768949e-01f, 2.52593428e-01f, 1.30121320e-01f, 7.86838904e-02f, 6.77932426e-02f, 1.77505553e-01f, 1.57549948e-01f, 1.38655454e-01f,
  2.79243421e-02f, 1.34876296e-01f, -3.07161268e-02f, 9.13394317e-02f, -1.03433490e-01f, 1.96217984e-01f, 1.13017619e-01f, 6.74337223e-02f, 2.92526543e-01f, 1.68503881e-01f,
  1.51576236e-01f, 8.34391192e-02f, 1.66237995e-01f, 1.62602484e-01f, 5.69850020e-02f, -2.99678683e-01f, 3.90552491e-01f, 3.90237480e-01f, -1.67037267e-02f, 2.05054134e-01f,
  -1.72619119e-01f, 1.62512079e-01f, -3.81321013e-01f, 4.90574017e-02f, 2.65436351e-01f, 2.97407657e-01f, -3.26659441e-01f, -3.67521405e-01f, -2.20442310e-01f, 2.37589300e-01f,
  -2.09167734e-01f, -3.26797754e-01f, 6.71598837e-02f, -2.50308782e-01f, -1.55954435e-01f, -1.16958171e-01f, 8.84451717e-02f, -3.41383100e-01f, -1.73474833e-01f, 2.15722293e-01f,
  2.12454811e-01f, -8.48074071e-03f, 3.22407857e-02f, -2.17670634e-01f, -4.09690797e-01f, 2.62645930e-01f, -6.48700073e-02f, -4.85499859e-01f, -1.76857561e-01f, -2.66542852e-01f,
  -2.63920993e-01f, 2.85681635e-01f, -5.34955025e-01f, -3.99954170e-01f, -2.71975696e-01f, 9.99520943e-02f, 1.23889698e-02f, -3.40302229e-01f, -2.60627687e-01f, -5.99520616e-02f,
  -3.59981716e-01f, -2.96171874e-01f, 2.05023602e-01f, 2.16703191e-01f, -5.12267910e-02f, 2.86200196e-01f, 1.44036889e-01f, -3.84685814e-01f, 2.41925552e-01f, -3.16860199e-01f,
  -3.98176253e-01f, -3.50364506e-01f, 5.04232347e-02f, -4.49175805e-01f, 1.41962126e-01f, -1.56466633e-01f, 7.16629922e-02f, 3.94185483e-01f, -3.23810935e-01f, -4.04447168e-01f,
  -2.29257718e-01f, 3.13831726e-03f, -5.84429741e-01f, 1.40699064e-02f, 3.34658712e-01f, 3.13373417e-01f, -4.26076889e-01f, -3.03912312e-01f, 2.87110880e-02f, 2.75170282e-02f,
  -3.58335912e-01f, 2.66698807e-01f, 3.37374985e-01f, 3.75900209e-01f, 2.08870143e-01f, -5.16607881e-01f, -4.95458215e-01f, 2.19854891e-01f, -8.20891783e-02f, 2.25896358e-01f,
  -3.06542367e-01f, -1.16880603e-01f, 2.50228763e-01f, 1.18023843e-01f, -4.80390787e-01f, 1.20776437e-01f, -2.10578635e-01f, 2.35622361e-01f, 9.04951524e-03f, -1.90369606e-01f,
  3.31562996e-01f, 2.37828836e-01f, 4.96951193e-02f, -2.53445923e-01f, 1.68479919e-01f, 6.70570210e-02f, -6.84889555e-02f, -3.84136111e-01f, 2.17602141e-02f, -1.27355769e-01f,
  2.19772886e-02f, -3.23797055e-02f, 2.15896964e-03f, -1.61920354e-01f, -1.05716892e-01f, -9.29229707e-02f, 1.06429055e-01f, 3.89694981e-02f, 5.18581532e-02f, -1.33394644e-01f,
  -1.90196037e-01f, 1.29183829e-01f, 4.99990657e-02f, 1.73122793e-01f, -9.87020973e-03f, -9.07735601e-02f, -1.55377135e-01f, -7.03572184e-02f, -1.23667516e-01f, 1.03274941e-01f,
  -4.07465659e-02f, -5.09285852e-02f, -5.95016517e-02f, 1.14250965e-01f, -3.52417529e-01f, 1.83428109e-01f, -3.46789509e-01f, -2.83000946e-01f, -3.13031793e-01f, -3.71192575e-01f,
  -1.56425014e-01f, 1.15134632e-02f, -2.54240960e-01f, -1.96590781e-01f, 1.58984303e-01f, 2.64385771e-02f, 2.21909821e-01f, -8.54543895e-02f, -4.90210950e-02f, 1.27788000e-02f,
  1.63156971e-01f, 1.91006884e-01f, -1.79503962e-01f, -2.33578071e-01f, 1.59058645e-01f, 5.40064424e-02f, -1.77969262e-01f, -2.64621913e-01f, -1.83014274e-01f, -3.44224900e-01f,
  -2.13546008e-01f, -4.47514445e-01f, 7.79389888e-02f, -1.76635921e-01f, -3.44453186e-01f, 1.47027403e-01f, -3.21275555e-02f, 3.68064404e-01f, -6.44303188e-02f, 4.67346370e-01f,
  -2.14895412e-01f, 8.16108212e-02f, -1.84057578e-01f, 4.05831158e-01f, -2.48395786e-01f, 9.61049125e-02f, -2.27800950e-01f, 2.81790227e-01f, -4.22606729e-02f, -1.52046621e-01f,
  -1.34460092e-01f, -2.86314607e-01f, -6.57904223e-02f, 2.85093840e-02f, -2.16671482e-01f, -4.60681409e-01f, 1.68704376e-01f, -3.56175095e-01f, -1.31620854e-01f, -4.16048855e-01f,
  -1.17431797e-01f, 4.86030802e-03f, 3.34151834e-01f, -1.88188046e-01f, -3.97926480e-01f, 2.45084271e-01f, -2.50507712e-01f, 4.86798823e-01f, -6.64924085e-02f, -1.41159162e-01f,
  3.39840561e-01f, -1.60017326e-01f, 9.60575864e-02f, 1.86187387e-01f, 2.90049940e-01f, -9.06767175e-02f, -2.52318382e-01f, -4.13672715e-01f, 5.79833537e-02f, -3.26996058e-01f,
  -4.21520770e-01f, -6.14062622e-02f, 1.48368245e-02f, -1.71989128e-02f, 3.85782957e-01f, -2.93276519e-01f, -4.12165761e-01f, -6.14710569e-01f, -2.44870298e-02f, -3.27389091e-01f,
  1.07033765e-02f, -3.96903962e-01f, 3.15080076e-01f, -1.44969851e-01f, 1.22774735e-01f, 4.30459827e-01f, -8.70032459e-02f, -2.05701366e-01f, 3.61383706e-01f, -2.10651770e-01f,
  -2.75596827e-01f, -5.05281687e-01f, 1.36139672e-02f, -3.69391799e-01f, 4.22762185e-01f, 1.28950790e-01f, -1.13622621e-01f, 9.20552015e-02f, -1.10437460e-01f, -3.19599003e-01f,
  -1.87684029e-01f, -1.35660127e-01f, 9.97558460e-02f, -1.59613639e-02f, -2.00878307e-01f, 3.59386429e-02f, -1.15103209e-02f, -1.16352640e-01f, -1.10422671e-02f, -2.15484381e-01f,
  1.37358075e-02f, -1.41033635e-01f, -2.33079717e-01f, -3.32471100e-03f, 2.86422111e-02f, -5.06435856e-02f, -1.16968811e-01f, -2.02565521e-01f, -4.72292826e-02f, -2.61582136e-01f,
  -3.40409502e-02f, 6.33765236e-02f, 5.31519540e-02f, 2.33359560e-02f, -1.87854826e-01f, 1.61252588e-01f, 2.03713268e-01f, 3.43396626e-02f, 2.46016562e-01f, -1.88267887e-01f,
  1.32600553e-02f, -1.75018031e-02f, -2.23445743e-01f, 8.66850987e-02f, -1.33818702e-03f, 2.48979747e-01f, 3.99074890e-03f, 1.39785692e-01f, -1.74928039e-01f, 8.12673792e-02f,
  -1.05058111e-01f, 2.36593992e-01f, -2.23839864e-01f, -2.02162370e-01f, 8.42791647e-02f, 2.65099019e-01f, -9.01621506e-02f, -1.69724062e-01f, -1.10773720e-01f, -2.59828568e-01f,
  2.78651565e-01f, -7.51512423e-02f, -7.30070397e-02f, -1.63068354e-01f, -2.10609540e-01f, 1.55799314e-01f, 2.79969364e-01f, -3.33432734e-01f, -3.58464243e-03f, -1.64240092e-01f,
  1.39419705e-01f, 3.73619646e-02f, -3.85765731e-02f, -3.00286174e-01f, -3.47712815e-01f, -1.32295713e-01f, 1.44696131e-01f, -1.18367262e-01f, -3.17114413e-01f, 1.81034699e-01f,
  6.16934448e-02f, -1.89506877e-02f, -1.39439747e-01f, -2.89399493e-02f, 9.41365808e-02f, -3.57237667e-01f, 2.62868226e-01f, -1.13955081e-01f, -1.14145890e-01f, -4.16486897e-02f,
  2.09548146e-01f, 1.40294999e-01f, -2.07907543e-01f, 5.95515482e-02f, -8.34746286e-02f, 2.22972855e-02f, -2.64844298e-01f, -1.47132456e-01f, -2.76943594e-01f, -1.84496596e-01f,
  -2.98161089e-01f, 2.82181472e-01f, -2.44889930e-01f, -1.56470214e-03f, -2.24044576e-01f, -2.15873271e-01f, -1.53960228e-01f, 1.73757702e-01f, -2.84383893e-01f, 5.25270924e-02f,
  -7.12384284e-03f, 3.17290545e-01f, -2.77036816e-01f, -2.07194641e-01f, -2.73072422e-01f, 1.71408150e-02f, -2.13558197e-01f, 3.14563125e-01f, 5.86708710e-02f, 2.96463192e-01f,
  6.49356097e-02f, 2.86386341e-01f, 2.61382908e-01f, -1.13815166e-01f, 2.05343693e-01f, -1.13524050e-01f, 5.84115600e-03f, 2.32279003e-01f, 6.06926233e-02f, -1.31150723e-01f,
  3.69757265e-01f, 3.63049269e-01f, -2.26265103e-01f, -2.13854492e-01f, -2.42385808e-02f, -1.01565175e-01f, -1.36270304e-03f, -7.72532150e-02f, -9.06540900e-02f, -1.54097751e-01f,
  -9.86573193e-03f, 8.97844732e-02f, -1.60016760e-01f, -1.32411331e-01f, -1.29971504e-01f, 8.05309787e-02f, -1.13814004e-01f, -4.64233011e-02f, 4.18946985e-03f, -2.57943332e-01f,
  -1.34206191e-02f, -4.44026738e-02f, -9.93933305e-02f, -5.21999709e-02f, 1.01369493e-01f, 6.41907826e-02f, 3.90143953e-02f, -2.00952038e-01f, -1.57004997e-01f, -2.34755471e-01f,
  1.02934219e-01f, 1.37130067e-01f, 1.14135638e-01f, -8.00216421e-02f, 2.43267700e-01f, 1.58045553e-02f, 9.60566550e-02f, -2.20229775e-01f, -3.10415309e-02f, -1.87689155e-01f,
  -1.02341607e-01f, -1.31407350e-01f, -7.42404014e-02f, -2.28977054e-02f, 1.75098568e-01f, -3.13220359e-02f, 1.68122292e-01f, 1.14892460e-01f, -6.83330968e-02f, -8.48550498e-02f,
  -1.41624957e-01f, 8.32139328e-02f, 2.11243898e-01f, -3.32571507e-01f, 3.17831635e-01f, -1.40941247e-01f, 2.51648337e-01f, 1.11101702e-01f, 9.40422043e-02f, -1.45546272e-02f,
  -1.82064325e-01f, -2.59692073e-01f, 2.64119785e-02f, 3.43668699e-01f, -1.45263284e-01f, 8.84163901e-02f, -3.80872399e-01f, 1.94991842e-01f, -2.82730252e-01f, -3.52879524e-01f,
  2.75546491e-01f, -3.50359529e-01f, -3.08552086e-01f, -2.94146180e-01f, -2.32465640e-01f, -1.66906416e-01f, -3.94023895e-01f, 5.37323207e-02f, 3.26992959e-01f, 1.86195210e-01f,
  -2.04384759e-01f, 1.87299207e-01f, -2.45233119e-01f, -1.23209156e-01f, 2.85070419e-01f, -1.24456264e-01f, -1.36929452e-01f, -3.01720172e-01f, -2.11905658e-01f, -2.07063913e-01f,
  -7.35019706e-03f, -1.50884673e-01f, 1.06285527e-01f, -9.55651626e-02f, -2.71638423e-01f, -2.28719458e-01f, 9.68404561e-02f, 1.28463402e-01f, -2.09482983e-01f, -8.46462622e-02f,
  -2.59817094e-01f, -2.44720176e-01f, -1.62897229e-01f, 1.02543592e-01f, 3.59468937e-01f, -2.74996161e-01f, -2.86680877e-01f, -2.26549044e-01f, -2.93897629e-01f, -2.69019693e-01f,
  -2.63903469e-01f, 1.38509214e-01f, -2.40788221e-01f, 3.01067173e-01f, 3.42934877e-01f, -6.35134280e-02f, 2.26901188e-01f, -1.55343056e-01f, 3.17224473e-01f, -1.93665564e-01f,
  -2.53243834e-01f, -2.43726149e-01f, -3.48213255e-01f, 3.21982443e-01f, -2.33452410e-01f, 3.87669533e-01f, 2.08615705e-01f, 2.12885857e-01f, -4.45995368e-02f, -3.34349722e-01f,
  -2.56582260e-01f, 1.27930415e-03f, -1.63802415e-01f, 1.48520589e-01f, 3.92195061e-02f, 2.82738097e-02f, 1.97615817e-01f, 3.11144497e-02f, -7.10495561e-02f, 2.83596162e-02f,
  1.01103567e-01f, -3.70538533e-02f, 1.14090949e-01f, 3.57201807e-02f, -1.22785792e-02f, 2.62807007e-03f, 2.68225316e-02f, -3.40708122e-02f, -9.12040193e-03f, 1.97491184e-01f,
  1.51504790e-02f, 3.03031225e-02f, 2.16131075e-03f, 1.49190763e-03f, -1.10615268e-01f, 8.74024555e-02f, -6.39915317e-02f, 2.45696977e-01f, 1.49946347e-01f, 3.27182263e-01f,
  -2.72588551e-01f, -1.04674414e-01f, 1.53928161e-01f, -1.63777485e-01f, -9.61213261e-02f, 1.89690843e-01f, -3.15353036e-01f, 2.92820007e-01f, -2.17201672e-02f, -3.11432421e-01f,
  -1.13012634e-01f, -9.80897397e-02f, -2.06778139e-01f, -1.38166323e-01f, 7.61375427e-02f, 2.59179860e-01f, -9.96212289e-02f, -3.19341630e-01f, -7.46343881e-02f, -2.25877285e-01f,
  -3.04029137e-01f, 2.30540574e-01f, -5.05804777e-01f, 3.18859994e-01f, 2.30490997e-01f, -3.37690920e-01f, 3.96968216e-01f, -4.35837835e-01f, -2.84145981e-01f, -1.11892454e-01f,
  3.80561769e-01f, -5.47354639e-01f, -2.74634749e-01f, -3.46120685e-01f, -2.18501776e-01f, 3.17295492e-01f, -1.24421865e-01f, -2.96840996e-01f, -4.69672605e-02f, 2.96442866e-01f,
  -2.40552709e-01f, -9.61265117e-02f, 2.24645153e-01f, 3.43764663e-01f, -2.16854051e-01f, -1.04521215e-01f, -2.82540947e-01f, -1.00963831e-01f, -4.15393002e-02f, 1.38134003e-01f,
  2.53945827e-01f, -2.34512240e-01f, -2.38553002e-01f, 3.57311815e-01f, -2.93763727e-01f, -1.63995400e-01f, 3.50993961e-01f, -3.98575634e-01f, 2.87840933e-01f, 9.79012102e-02f,
  -1.20029505e-02f, 6.07812637e-03f, -3.42980742e-01f, 2.38272145e-01f, 2.36945301e-02f, 1.70015961e-01f, -5.16879678e-01f, -2.42026493e-01f, 2.66911149e-01f, 2.34988883e-01f,
  -1.70039818e-01f, 1.98427439e-01f, -2.51160860e-01f, -1.46383151e-01f, -4.20997649e-01f, -4.72982049e-01f, -3.77009183e-01f, 1.67702898e-01f, -1.32777646e-01f, -7.59972353e-03f,
  -1.49360105e-01f, 3.45901281e-01f, -4.94903803e-01f, 1.62114814e-01f, -4.96558100e-01f, 3.08101743e-01f, -3.91411185e-01f, -3.03026736e-01f, -3.58106047e-01f, -1.26146451e-01f,
  3.45784754e-01f, -2.14083567e-01f, 1.86287180e-01f, -1.09146200e-01f, -3.89998645e-01f, -1.16068885e-01f, -2.18239829e-01f, 2.32280836e-01f, -2.96099663e-01f, -3.67240578e-01f,
  1.23813733e-01f, 1.48896679e-01f, 6.90081492e-02f, 2.71497946e-02f, 2.13439167e-02f, 1.61452875e-01f, 1.79312959e-01f, 4.49196389e-03f, 2.12942332e-01f, 1.58392802e-01f,
  1.95759848e-01f, -1.70578152e-01f, -1.81338619e-02f, 6.48630261e-02f, -8.95577073e-02f, 6.39128163e-02f, 8.64023790e-02f, 2.52614945e-01f, 1.13172997e-02f, -1.45587027e-01f,
  4.63386960e-02f, 2.19440579e-01f, 2.01906431e-02f, 1.40782282e-01f, 7.87444040e-02f, 8.19779187e-02f, -2.86987238e-03f, -6.21148339e-03f, 1.04310066e-01f, -1.08310744e-01f,
  2.16095462e-01f, 1.62488922e-01f, 2.21894026e-01f, -8.55928212e-02f, 1.60847262e-01f, -3.00548702e-01f, 2.87378967e-01f, 2.61230290e-01f, -3.13877165e-01f, -2.25897223e-01f,
  2.97409207e-01f, 2.65718549e-01f, -1.84341088e-01f, -3.08635443e-01f, 3.47444117e-01f, 2.01469779e-01f, -3.39021161e-02f, -1.02717720e-01f, 2.40301922e-01f, -2.33596444e-01f,
  -1.73035413e-01f, -1.62242308e-01f, -1.11938655e-01f, 1.48206428e-01f, -2.84684241e-01f, -2.06764877e-01f, 3.00725043e-01f, -1.99388430e-01f, -2.67108291e-01f, -5.56819327e-02f,
  3.47872376e-01f, -3.26273322e-01f, 3.76460254e-01f, 1.25635833e-01f, -2.57987440e-01f, -4.44893718e-01f, -1.90954670e-01f, -2.49642238e-01f, -4.52771753e-01f, -2.52912134e-01f,
  4.02092814e-01f, -2.32876182e-01f, 1.23331547e-01f, 5.67364618e-02f, -2.11915627e-01f, -1.55744031e-01f, 2.73222804e-01f, -2.20953509e-01f, -2.92156845e-01f, -4.17520881e-01f,
  -2.00760132e-03f, -1.96269095e-01f, 2.07139969e-01f, 3.17999572e-01f, -1.79406166e-01f, -1.07731715e-01f, -2.92544037e-01f, -9.91942957e-02f, 2.08034083e-01f, -1.92361444e-01f,
  3.28715771e-01f, -1.50026217e-01f, -2.77657419e-01f, 4.67033148e-01f, -1.76558122e-01f, -3.61525536e-01f, -4.26786870e-01f, -4.02320564e-01f, -7.49701187e-02f, -1.07254870e-01f,
  1.02399841e-01f, -1.38082117e-01f, -2.34665692e-01f, -2.63174236e-01f, -1.50178209e-01f, -3.77389669e-01f, 4.36324924e-01f, 2.51747489e-01f, 5.00716209e-01f, -1.84057325e-01f,
  -2.26041734e-01f, 4.26556915e-01f, -2.38590240e-01f, -1.81887999e-01f, -1.61828995e-01f, -8.00144002e-02f, 1.81461886e-01f, -1.56199247e-01f, -1.95765495e-01f, 1.71021253e-01f,
  -1.26610652e-01f, -4.52365994e-01f, -1.58504575e-01f, -4.52054515e-02f, -4.30253118e-01f, -3.68840426e-01f, -2.82606035e-01f, 1.99528962e-01f, 7.59604946e-02f, 8.86562690e-02f,
  -1.31901592e-01f, 7.73827136e-02f, 2.74182986e-02f, -5.31688631e-02f, -1.14070205e-02f, 8.36130753e-02f, -1.45107619e-02f, -3.39677744e-02f, -1.40904291e-02f, -5.02416678e-02f,
  1.22858793e-01f, -4.21354687e-03f, -8.47779494e-03f, 9.38990489e-02f, 6.01415224e-02f, 1.55105874e-01f, -4.37418446e-02f, -9.65161845e-02f, 2.45118737e-02f, -1.68842107e-01f,
  6.51480556e-02f, 1.65949669e-02f, 1.36049688e-01f, -1.54735833e-01f, -1.94534793e-01f, 2.57430226e-01f, 1.06401749e-01f, -1.84112638e-01f, -2.90336579e-01f, 1.43641710e-01f,
  2.76062012e-01f, -2.54388034e-01f, -2.51648128e-01f, 2.10918099e-01f, 2.55973458e-01f, -1.65709138e-01f, 2.23627418e-01f, -2.39633754e-01f, 1.23605557e-01f, 2.76886851e-01f,
  5.02027106e-03f, 1.24016613e-01f, -2.19391406e-01f, 2.72055149e-01f, 2.11509824e-01f, -8.74054134e-02f, 2.83071280e-01f, 9.63194296e-02f, 8.84484947e-02f, -2.16179356e-01f,
  3.76913011e-01f, 3.68726343e-01f, -2.95320451e-01f, 4.19942737e-01f, 3.88914555e-01f, 3.58165413e-01f, -4.14153971e-02f, 3.34940493e-01f, -3.05391848e-01f, -1.08863503e-01f,
  -3.58446628e-01f, -3.12040329e-01f, 1.99057236e-01f, 1.42117277e-01f, -2.77192771e-01f, 3.43024373e-01f, 8.29488318e-03f, -2.96193391e-01f, -1.92328364e-01f, -3.90964657e-01f,
  5.36778290e-03f, 4.74011272e-01f, -3.33134025e-01f, -3.98768991e-01f, -2.81239986e-01f, -2.72799999e-01f, -8.07149634e-02f, 1.86251491e-01f, -1.39504656e-01f, -2.06722885e-01f,
  -7.93582276e-02f, -2.56551772e-01f, -4.95275632e-02f, -6.90365732e-02f, -3.54392618e-01f, 2.14571118e-01f, -3.43281835e-01f, -8.57428238e-02f, -3.00617933e-01f, -1.22385077e-01f,
  -1.28738940e-01f, -2.46456429e-01f, 2.41999283e-01f, -3.04797441e-01f, -2.89493889e-01f, 1.17053308e-01f, -2.51275778e-01f, 3.49639431e-02f, 8.14711526e-02f, -3.96927088e-01f,
  -2.41449233e-02f, -3.26103300e-01f, -3.32569510e-01f, 1.73721582e-01f, -2.39674300e-01f, 3.72200131e-01f, -1.94097251e-01f, -2.36718148e-01f, 1.39150038e-01f, 1.85323153e-02f,
  1.10097537e-02f, -2.23674685e-01f, -4.89089191e-01f, 1.20270126e-01f, -1.30542800e-01f, 2.12984174e-01f, -2.57358756e-02f, -1.04276843e-01f, -2.87213624e-01f, 1.69179767e-01f,
  -1.58576831e-01f, 5.39747514e-02f, 3.71897370e-01f, -3.26758057e-01f, 1.53474733e-01f, -3.87069196e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.63296517e-02f, 1.70425978e-02f, 6.74107019e-03f, -8.98620673e-03f, -2.97481986e-03f, 9.87823009e-02f, 7.53389746e-02f, -2.23576501e-02f, 8.76371656e-03f, 6.85133189e-02f,
  9.42678377e-02f, 1.14395022e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    