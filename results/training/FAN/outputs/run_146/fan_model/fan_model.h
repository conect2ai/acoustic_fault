/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.74049690e-01f, -6.14527464e-02f, -1.06877707e-01f, -1.63190663e-02f, -1.18881263e-01f, -2.62964785e-01f, 9.86882970e-02f, -4.14884426e-02f, -2.76160240e-01f, 1.40617505e-01f,
  2.05092654e-01f, -1.05669126e-01f, 3.35456491e-01f, -1.00633316e-01f, -1.24836542e-01f, 1.55183136e-01f, -2.25955799e-01f, 3.92660610e-02f, -5.48638701e-02f, -7.47155175e-02f,
  -1.80053767e-02f, -4.90617231e-02f, 5.16006723e-02f, -1.45761311e-01f, -7.07613528e-02f, 2.37524952e-03f, 2.71233916e-01f, 1.37085006e-01f, 4.12660986e-02f, 1.73583825e-03f,
  4.04487438e-02f, -1.40963778e-01f, -2.61132307e-02f, -6.03346489e-02f, -8.38306826e-03f, 5.25314473e-02f, 1.01198524e-01f, -3.48873585e-02f, -6.68478981e-02f, -1.23987287e-01f,
  1.51670799e-01f, -3.89245641e-03f, -3.74770239e-02f, -8.59181881e-02f, -1.29316747e-01f, -1.93563491e-01f, -4.32978645e-02f, -5.96900582e-02f, -3.63464989e-02f, 5.02623199e-03f,
  -6.46698326e-02f, -9.61095244e-02f, -6.63305894e-02f, -6.90156445e-02f, -3.84529382e-02f, -5.28337508e-02f, 2.60109156e-02f, 6.83905557e-04f, -6.83098361e-02f, -1.74883097e-01f,
  -3.33760455e-02f, 1.05631150e-01f, -5.66343032e-03f, -7.06877140e-03f, -2.11093463e-02f, 7.94282705e-02f, 5.71999699e-02f, 9.52522364e-03f, -6.13707900e-02f, 1.06993198e-01f,
  -2.61162175e-03f, -1.65497232e-02f, 7.11373314e-02f, -1.87840275e-02f, 1.29806213e-02f, 9.73650664e-02f, 2.73551163e-03f, 1.27775013e-01f, 4.84237522e-02f, 1.02738664e-01f,
  8.89353901e-02f, -4.60370444e-02f, 1.19334310e-01f, -5.44359349e-03f, -5.20902537e-02f, 2.30307113e-02f, 1.52961329e-01f, -8.52133147e-03f, 3.17902528e-02f, 5.97030148e-02f,
  3.40002440e-02f, 3.10792290e-02f, 6.89524831e-03f, -2.80278251e-02f, 6.46484196e-02f, -9.79767591e-02f, -5.96266612e-02f, -1.02185875e-01f, -7.17824548e-02f, -1.61145478e-01f,
  -3.26478370e-02f, 7.09342435e-02f, 7.20708892e-02f, -6.70432821e-02f, -4.73997146e-02f, 2.83000804e-02f, 1.20570779e-01f, 6.14560395e-02f, -9.24379937e-03f, 6.94003180e-02f,
  3.15650851e-02f, -8.45871344e-02f, -9.86286812e-03f, -7.50885755e-02f, 5.18318377e-02f, 1.28416494e-01f, -6.05742037e-02f, -7.59216100e-02f, 2.47692000e-02f, -1.40789179e-02f,
  -4.09621239e-01f, 2.51681149e-01f, -3.97683047e-02f, -2.74088830e-01f, 8.00213739e-02f, -1.90299898e-02f, -1.96283728e-01f, -1.20875522e-01f, -1.82128325e-01f, 1.97021723e-01f,
  -1.27032489e-01f, 5.52210994e-02f, 7.33285844e-02f, -2.57613093e-01f, -3.73759419e-01f, 5.60484715e-02f, -2.92605519e-01f, -9.57761928e-02f, -1.86865032e-02f, -1.61916420e-01f,
  -1.26024365e-01f, -6.69946596e-02f, -1.92179099e-01f, 1.03002861e-01f, -5.00733554e-02f, -2.37386264e-02f, -6.78272173e-02f, 1.08993493e-01f, -2.65985411e-02f, 1.64504856e-01f,
  -8.57308786e-03f, -1.37543604e-01f, -4.71014902e-02f, -4.26766314e-02f, -1.46525458e-01f, 2.20012777e-02f, 2.48475131e-02f, 6.34732889e-03f, -9.17911083e-02f, -3.23260874e-02f,
  1.26062930e-01f, 2.54130810e-02f, -2.18109973e-02f, -5.84068708e-03f, 2.30266023e-02f, -7.50407996e-03f, -3.36055011e-02f, -6.15513064e-02f, -6.61900565e-02f, -3.56412632e-03f,
  3.55051793e-02f, -1.22236484e-03f, -5.46390563e-02f, 3.81842144e-02f, 6.35137632e-02f, 2.97157597e-02f, 7.47573152e-02f, 9.82889757e-02f, 5.76779135e-02f, 3.29839885e-02f,
  2.88770292e-02f, -7.48091489e-02f, -1.59899071e-01f, -3.94852236e-02f, -7.18680099e-02f, -3.55198346e-02f, -1.14172369e-01f, -3.56530696e-02f, -1.68118365e-02f, 2.55616028e-02f,
  -8.52730945e-02f, -2.29743216e-02f, -1.29278237e-02f, -1.67463943e-01f, -2.68917661e-02f, -4.45118472e-02f, -2.53998414e-02f, 1.30723789e-01f, 5.81327900e-02f, -5.45389801e-02f,
  -7.79641718e-02f, 1.26639875e-02f, 4.85526323e-02f, 4.55024987e-02f, -9.93299782e-02f, 1.37098162e-02f, 4.26248945e-02f, 3.96757871e-02f, -5.87121993e-02f, -1.50849968e-02f,
  -8.71907026e-02f, -1.77071333e-01f, -5.56639992e-02f, -4.21984904e-02f, -2.19712071e-02f, 1.27728144e-02f, -4.84515205e-02f, -2.77888533e-02f, -4.77621853e-02f, -5.64297549e-02f,
  2.61311550e-02f, -1.26878051e-02f, 1.41256368e-02f, -1.23214014e-01f, 1.07451841e-01f, 4.50326316e-02f, -5.83665119e-03f, -7.64417201e-02f, -2.70609818e-02f, 7.03159580e-03f,
  -6.38254592e-03f, -7.56827369e-02f, 7.05737919e-02f, 7.00857341e-02f, 6.40477017e-02f, 5.46485893e-02f, -2.91648656e-02f, 6.69468865e-02f, 2.45201085e-02f, 1.17823623e-01f,
  3.10796686e-03f, 1.93873532e-02f, 1.39786035e-01f, 7.26514086e-02f, -4.93561067e-02f, -1.75559297e-01f, -1.28401324e-01f, -1.80537015e-01f, -1.58939674e-01f, -1.84720736e-02f,
  -1.98686495e-01f, 2.60448039e-01f, -3.19528133e-01f, 1.23280711e-01f, 1.44712046e-01f, -1.72457308e-01f, 3.04738637e-02f, 1.99172311e-02f, 3.71411294e-02f, 1.30735971e-02f,
  -8.12977105e-02f, 2.50762831e-02f, 6.74912855e-02f, 4.13962603e-02f, 1.18321389e-01f, 7.02907192e-03f, 2.74417460e-01f, -1.20973904e-02f, 2.81143367e-01f, 1.43223405e-01f,
  -8.30185264e-02f, -1.12865074e-02f, 4.00621779e-02f, 4.80924435e-02f, -3.16018686e-02f, -1.01399392e-01f, 8.06061085e-03f, -6.21234775e-02f, -1.36402035e-02f, -6.06714608e-03f,
  -2.82896608e-02f, 2.47715022e-02f, 5.98587282e-02f, -6.22469112e-02f, -7.87720755e-02f, 3.64750028e-02f, 1.76563174e-01f, 9.02421623e-02f, 9.35225561e-02f, -7.86983073e-02f,
  6.47963658e-02f, -2.90886816e-02f, 4.13943641e-02f, 4.73802313e-02f, 1.37840092e-01f, 6.02685399e-02f, 5.22924513e-02f, 8.64767805e-02f, 3.47410627e-02f, 8.46329033e-02f,
  -4.30279709e-02f, -8.91814940e-03f, -1.87389962e-02f, -5.48480190e-02f, 3.23481858e-04f, -4.31786887e-02f, -1.12473899e-02f, -3.24039944e-02f, -1.15494847e-01f, -1.94637496e-02f,
  3.80826890e-02f, -5.58683053e-02f, 3.15497853e-02f, -3.34507637e-02f, -5.94965145e-02f, 1.04742078e-02f, -3.68333310e-02f, 1.40239447e-01f, -1.20627604e-01f, -2.33803932e-02f,
  -1.31163197e-02f, 7.30675412e-03f, 8.27841982e-02f, 1.62989311e-02f, 2.16908362e-02f, 1.36762802e-02f, 6.45315275e-02f, 9.42765325e-02f, -9.22587439e-02f, 1.11230509e-02f,
  -3.70507278e-02f, 2.39161607e-02f, -9.49672237e-02f, 2.31169723e-02f, 6.16240837e-02f, -3.03693954e-02f, -1.28987178e-01f, 3.75110582e-02f, -3.31410989e-02f, -1.38386693e-02f,
  1.97145361e-02f, -6.34985790e-02f, 1.18639447e-01f, -5.58110848e-02f, -2.39187293e-02f, 1.86304785e-02f, 1.70284137e-01f, 8.96072164e-02f, 1.25379283e-02f, -1.69484038e-02f,
  5.84560558e-02f, -1.03654258e-01f, -7.68301426e-04f, 2.62065604e-02f, 6.79481449e-03f, -6.51407707e-03f, -8.68177228e-03f, 1.01688482e-01f, 6.27213437e-03f, -4.18085493e-02f,
  8.19907933e-02f, -3.84185970e-01f, -2.16062874e-01f, 7.20120966e-02f, 1.59906238e-01f, 1.50890350e-01f, 1.47571817e-01f, -1.38155401e-01f, -1.12984352e-01f, -1.50079936e-01f,
  2.38549605e-01f, -2.46938750e-01f, -1.31008029e-01f, 1.80873707e-01f, 2.23881751e-01f, 4.63975631e-02f, 5.15684336e-02f, 4.98163002e-03f, -1.34010047e-01f, -4.54013310e-02f,
  5.23114204e-02f, 2.75448054e-01f, 4.53639254e-02f, -6.46627620e-02f, 2.31031366e-02f, -2.35222518e-01f, 1.18246041e-01f, -6.47133067e-02f, 6.51592910e-02f, -1.66798476e-02f,
  1.25205845e-01f, -5.60580939e-03f, -7.64522552e-02f, 2.22256891e-02f, 6.59830272e-02f, 6.27714992e-02f, 2.02135835e-02f, 8.97805691e-02f, 9.75948293e-03f, 7.71189667e-03f,
  -3.32286060e-02f, 4.29741144e-02f, -3.63695286e-02f, -1.62307024e-01f, 4.84161340e-02f, -4.01730426e-02f, -1.19037824e-02f, 8.95525701e-03f, -1.69509500e-02f, 3.76008824e-02f,
  4.47515808e-02f, -1.00323576e-02f, 6.76055774e-02f, 9.37148742e-03f, -2.88770869e-02f, 8.29806365e-03f, -2.97281109e-02f, -2.09072884e-02f, -5.73247783e-02f, -7.20986277e-02f,
  2.12691911e-02f, 4.82599530e-03f, 1.92348734e-02f, 1.08760577e-02f, 9.18203220e-02f, 8.77828076e-02f, 5.12507781e-02f, 7.50200897e-02f, -7.15533644e-02f, 2.94744968e-02f,
  5.97168580e-02f, -2.15622578e-02f, 2.43024360e-02f, -4.80601471e-03f, -4.22952063e-02f, -3.81578319e-03f, -8.34237318e-03f, -6.75374568e-02f, -4.23741788e-02f, -1.50780268e-02f,
  -2.36041248e-02f, 8.46646652e-02f, 1.66422734e-03f, 5.79182208e-02f, 8.82885978e-02f, -9.12662297e-02f, 8.70854855e-02f, -3.17135602e-02f, -1.96172651e-02f, -1.05818249e-02f,
  3.54908146e-02f, -1.52708262e-01f, -6.56821728e-02f, 2.07432248e-02f, 2.90706996e-02f, -8.03309828e-02f, -4.62997183e-02f, -1.74075533e-02f, -6.30123392e-02f, 6.49062693e-02f,
  1.75014958e-02f, -7.31688598e-03f, -4.14805487e-02f, -6.67559355e-02f, 5.94969001e-03f, 3.48633192e-02f, 5.00348695e-02f, 3.11520882e-02f, 1.79742109e-02f, 1.22506768e-01f,
  9.07496363e-02f, 4.54427376e-02f, -3.71047179e-03f, -1.31608648e-02f, 4.78104316e-02f, 7.70143345e-02f, -3.47354859e-02f, -2.18207054e-02f, 5.21276258e-02f, -4.21531871e-02f,
  -1.41581565e-01f, -1.55352682e-01f, 5.63568994e-03f, 1.19684748e-01f, 9.24939662e-02f, 9.82504338e-02f, -1.47180986e-02f, 4.71576750e-02f, -1.13848686e-01f, -1.22851253e-01f,
  1.36916116e-01f, -1.56310320e-01f, -7.09582716e-02f, 1.58141211e-01f, 1.12801515e-01f, -1.33842006e-01f, 1.09662123e-01f, 2.15262920e-02f, -5.13152629e-02f, 2.45410744e-02f,
  1.13977730e-01f, 5.65702245e-02f, 2.22343594e-01f, -3.54851829e-03f, -2.56832615e-02f, 9.49465558e-02f, 1.98444083e-01f, -1.03417411e-02f, 2.01293021e-01f, 7.68577382e-02f,
  8.63409266e-02f, -8.00895542e-02f, -6.70401677e-02f, -5.20008281e-02f, 2.31012329e-02f, 5.16583584e-03f, 6.58960640e-02f, 8.09284672e-02f, 1.64457019e-02f, -2.72900108e-02f,
  2.48649586e-02f, 5.26522733e-02f, 1.88440811e-02f, 8.23330507e-02f, 5.61352670e-02f, 1.70116033e-02f, -2.58521438e-02f, 6.28594533e-02f, -6.01837076e-02f, 1.86402444e-02f,
  -8.63227621e-02f, -2.22041626e-02f, 3.63933714e-03f, 3.66996303e-02f, 4.63918000e-02f, -2.12486275e-03f, -3.30858901e-02f, 6.87745735e-02f, 5.21014929e-02f, -7.38622993e-02f,
  5.44493366e-03f, -1.67791881e-02f, -1.76806878e-02f, 3.65053751e-02f, -1.94303151e-02f, -5.61571121e-02f, -5.00050746e-02f, 3.44228819e-02f, -7.96904638e-02f, -6.93576187e-02f,
  2.17563454e-02f, -2.51216926e-02f, -6.49328902e-02f, 1.18190795e-03f, -5.39392466e-03f, 4.69057411e-02f, 5.08881472e-02f, 1.66951828e-02f, 4.76041157e-03f, 5.71062453e-02f,
  -2.11385339e-02f, -7.27520790e-04f, -8.75316709e-02f, -3.73849049e-02f, 1.92016661e-02f, -2.37172376e-02f, -7.56875500e-02f, 4.11810949e-02f, 3.23180668e-02f, 8.03214088e-02f,
  3.51737789e-03f, -1.28186360e-01f, -6.83116913e-02f, -8.12075436e-02f, -1.15718104e-01f, -1.76220555e-02f, 4.28374857e-02f, 1.12228105e-02f, -2.93717645e-02f, -2.53158305e-02f,
  1.28889054e-01f, -5.39279878e-02f, -1.00503400e-01f, 2.52837986e-02f, 4.68426123e-02f, -7.46958926e-02f, -9.58519951e-02f, -1.91345494e-02f, 1.00877702e-01f, 8.59820619e-02f,
  4.17800657e-02f, -5.66142164e-02f, -4.82336655e-02f, -2.12191977e-02f, 4.94286455e-02f, -3.54908369e-02f, 6.76715225e-02f, -8.52830522e-03f, -1.74392611e-02f, -2.80000120e-02f,
  -2.20118284e-01f, -2.72764653e-01f, 1.18600339e-01f, -1.59897804e-02f, 1.62368521e-01f, -1.40853792e-01f, -1.71536863e-01f, -3.02379136e-03f, -1.05796926e-01f, -1.93209216e-01f,
  1.55817270e-01f, -1.29503399e-01f, 9.69248340e-02f, -6.55184686e-02f, 2.77295917e-01f, 1.21474035e-01f, 1.19818084e-01f, -8.74639079e-02f, 4.04981002e-02f, -1.60734262e-02f,
  2.97902208e-02f, 6.10577315e-02f, 3.15932721e-01f, -3.10683809e-03f, 3.54427807e-02f, -3.26391496e-02f, 9.21141580e-02f, 7.09632486e-02f, -3.82416844e-02f, 8.79206434e-02f,
  -9.61029381e-02f, -4.85095680e-02f, 8.26341882e-02f, -4.13296511e-03f, 3.96995470e-02f, 2.68951361e-03f, 1.67499948e-02f, 1.10219650e-01f, 3.15707438e-02f, 4.01667729e-02f,
  1.04749791e-01f, 9.43410173e-02f, 7.37355426e-02f, 7.73874149e-02f, 3.61659080e-02f, 1.00632511e-01f, 2.20946390e-02f, 1.73417386e-02f, 5.40112257e-02f, 6.32544160e-02f,
  -6.82248622e-02f, 7.73530751e-02f, 1.10783614e-01f, 3.52675021e-02f, 1.29576966e-01f, 2.16595996e-02f, 4.22408506e-02f, 1.12740949e-01f, 2.58609299e-02f, 1.10407155e-02f,
  1.19601414e-02f, -5.38810268e-02f, 2.90272981e-02f, -5.18250698e-03f, -6.29481897e-02f, 1.20482296e-01f, -4.96520475e-02f, 1.02610737e-01f, -1.22218422e-04f, -4.86200899e-02f,
  2.04413421e-02f, -1.17389765e-02f, 7.02365441e-03f, -6.12108558e-02f, -7.27385329e-03f, -7.64059871e-02f, 1.22944392e-01f, 1.71324890e-02f, -2.27260366e-02f, 9.72004309e-02f,
  7.77606368e-02f, -1.17067680e-01f, -9.99700930e-03f, 6.15007393e-02f, -1.18193924e-02f, 1.10951401e-01f, -2.94642672e-02f, 9.51099992e-02f, 2.55910531e-02f, 1.72663271e-01f,
  -1.68737531e-01f, -6.67948797e-02f, 1.66103821e-02f, -4.43662181e-02f, 7.59380590e-03f, 8.32984000e-02f, 4.62656878e-02f, 8.98910239e-02f, -2.00276002e-02f, -9.15299654e-02f,
  7.08486289e-02f, 6.33074939e-02f, -5.30740805e-02f, -1.31246196e-02f, 5.23051433e-02f, 1.02906607e-01f, -6.36162907e-02f, 7.11699799e-02f, 9.29105952e-02f, -5.04877791e-02f,
  -2.03820900e-03f, 7.75330737e-02f, 1.66398093e-01f, -2.57418863e-02f, 7.71626085e-02f, -5.82334064e-02f, -1.35554718e-02f, -6.31907431e-04f, 1.57508522e-01f, 1.13211460e-01f,
  -6.24135211e-02f, -2.24732935e-01f, 1.15633741e-01f, 2.27712512e-01f, -3.37023795e-01f, -1.40974090e-01f, 3.06117255e-02f, -2.56649524e-01f, 1.72988132e-01f, -1.33107930e-01f,
  -8.33695456e-02f, 1.60987899e-01f, -1.10212699e-01f, 1.09201260e-01f, 2.12861836e-01f, 1.44822925e-01f, 2.09579557e-01f, 1.19521290e-01f, 1.26119599e-01f, 3.63377854e-02f,
  5.94051071e-02f, -1.97685063e-01f, -8.19778666e-02f, -2.45487019e-01f, -3.08166146e-01f, -5.63421324e-02f, -1.08268738e-01f, -1.26754597e-01f, -6.48023039e-02f, 2.76097246e-02f,
  -3.30546163e-02f, -2.21474059e-02f, -6.03901036e-02f, 3.26933935e-02f, -1.30631886e-02f, -4.60291542e-02f, 1.30914543e-02f, -5.15606999e-02f, -9.31319222e-02f, -5.28696850e-02f,
  -4.51999232e-02f, -1.04161076e-01f, 5.44389486e-02f, 1.21794112e-01f, -1.31171912e-01f, -6.72592446e-02f, 3.74911986e-02f, 6.05381057e-02f, -9.47797000e-02f, -2.69551203e-02f,
  -3.36850099e-02f, 4.94442433e-02f, 1.20293356e-01f, 2.96707321e-02f, 1.26843099e-02f, 1.17200010e-01f, 1.39114857e-01f, 1.96181238e-02f, -1.57448903e-01f, -3.80386673e-02f,
  -5.06437905e-02f, 8.00928175e-02f, 3.39661650e-02f, -3.36440816e-03f, 1.57711301e-02f, 3.00989747e-02f, 6.36383817e-02f, -4.86477576e-02f, 4.33152355e-02f, -9.37166512e-02f,
  -1.89176649e-02f, -1.38464915e-02f, 6.38584346e-02f, 3.49578038e-02f, -1.70438923e-02f, 9.14384723e-02f, -3.28585804e-02f, 4.64085974e-02f, -4.87595610e-02f, -7.13541508e-02f,
  1.90628553e-03f, -3.61718498e-02f, -1.23925116e-02f, -5.82024548e-03f, -4.17514965e-02f, -1.65993664e-02f, 1.39956713e-01f, -2.14459989e-02f, -4.97418009e-02f, 5.25457924e-03f,
  -1.03661023e-01f, 2.01066528e-02f, -2.31064521e-02f, -1.38477162e-01f, 2.95023085e-03f, -6.23017251e-02f, 1.88600011e-02f, -1.80363364e-03f, -1.42614722e-01f, 9.02328268e-02f,
  4.20091115e-02f, -4.03807014e-02f, 5.11344895e-02f, 1.47843868e-01f, -1.90207828e-02f, -4.05915789e-02f, 1.14630878e-01f, 9.52671170e-02f, -4.50158939e-02f, 1.23025030e-02f,
  -2.54634172e-02f, -1.46999187e-03f, -5.79542294e-03f, -1.35314435e-01f, -1.33220498e-02f, 6.59726635e-02f, 3.62672918e-02f, 6.84601218e-02f, -5.59383770e-03f, -4.18578386e-02f,
  -4.22873884e-01f, 1.44584477e-01f, -1.60513058e-01f, 4.56657037e-02f, 1.38291031e-01f, -4.65146452e-02f, -4.46355417e-02f, 3.24730203e-02f, -1.50401518e-01f, 2.30442330e-01f,
  1.91160068e-01f, -1.53304219e-01f, 9.55594257e-02f, 2.29585826e-01f, -6.06858060e-02f, 4.35087010e-02f, 1.80201367e-01f, 9.68502536e-02f, -1.70455605e-01f, -1.05527332e-02f,
  -2.48406697e-02f, 2.38933116e-01f, 6.98618442e-02f, 2.03262955e-01f, 1.96742564e-01f, -1.36288047e-01f, 2.97113776e-01f, -3.37538645e-02f, 3.00853103e-01f, 1.07705653e-01f,
  -6.86415359e-02f, -1.90298602e-01f, -1.34684995e-01f, -1.47370249e-01f, 2.97546797e-02f, -4.54462245e-02f, 1.48769785e-02f, 2.73492448e-02f, -1.35616884e-01f, -3.91865931e-02f,
  3.71010303e-02f, 5.61765917e-02f, 6.88574463e-02f, -7.32015148e-02f, 7.83685669e-02f, 1.68262403e-02f, 8.32307525e-03f, -9.75740701e-03f, 7.26800561e-02f, 1.30556254e-02f,
  4.08617556e-02f, 1.26956508e-01f, 3.20586003e-02f, 6.43100962e-02f, -1.26937749e-02f, 9.23423842e-02f, -7.89526664e-03f, 5.64329363e-02f, 8.52136016e-02f, 3.59716304e-02f,
  1.05893753e-01f, -1.56745203e-02f, -2.06836872e-03f, -5.76116191e-03f, -5.18345609e-02f, 8.33503678e-02f, -7.97343999e-02f, -4.04114909e-02f, -8.48764777e-02f, 7.23062530e-02f,
  -4.30644769e-03f, -6.86356500e-02f, 4.27368768e-02f, 1.35819789e-03f, 8.20161253e-02f, -6.89028502e-02f, 1.03860311e-01f, 9.16725956e-03f, -6.86058849e-02f, -3.68798301e-02f,
  -4.35981080e-02f, 1.81092729e-03f, -2.77951639e-02f, 1.10199573e-02f, 1.63219068e-02f, -1.65400375e-02f, 1.21200405e-01f, 5.52469806e-04f, 5.58682457e-02f, 1.79192293e-02f,
  7.73478001e-02f, 2.13417877e-02f, -1.40698344e-01f, -1.08459510e-01f, -6.84908330e-02f, 9.62069929e-02f, -6.63865730e-02f, 2.51875725e-02f, 2.11062972e-02f, -2.66878437e-02f,
  1.40839204e-01f, 2.39547454e-02f, -8.49495530e-02f, -7.50235170e-02f, 1.17628500e-01f, 6.11624457e-02f, 2.47490462e-02f, -4.77312133e-02f, 1.66866943e-01f, 1.05280474e-01f,
  1.65854707e-01f, 3.88681218e-02f, 7.26431012e-02f, 1.04547650e-01f, 1.37635291e-01f, 1.14098802e-01f, -1.03560790e-01f, 3.18208598e-02f, 1.34807378e-01f, 2.07652152e-01f,
  -1.90383881e-01f, -3.44725579e-01f, 6.80551007e-02f, -6.08659722e-02f, 1.40951216e-01f, -7.73122683e-02f, 3.58689912e-02f, -4.58061509e-02f, 2.69957278e-02f, -2.90835917e-01f,
  1.86651364e-01f, -4.51988652e-02f, 4.21384983e-02f, -6.41834736e-02f, 2.39763573e-01f, 2.30882630e-01f, -2.40025073e-01f, -1.16444312e-01f, 1.37819663e-01f, -1.37260705e-01f,
  7.13901222e-02f, -7.23749623e-02f, 2.14633271e-01f, 7.13798106e-02f, -1.09545685e-01f, -1.02216095e-01f, -5.14628924e-02f, 1.97798401e-01f, -1.13797642e-01f, 1.35680094e-01f,
  -1.56929508e-01f, -3.49366628e-02f, -8.82683247e-02f, -1.84976682e-02f, -8.47913325e-02f, -1.18049711e-01f, -4.54705171e-02f, 4.59178984e-02f, 8.10311884e-02f, 4.61361632e-02f,
  3.17583350e-03f, -6.03432879e-02f, -6.83178846e-03f, 1.14513688e-01f, -7.72249699e-02f, 3.30995545e-02f, 8.92306790e-02f, 4.74467948e-02f, 6.53300881e-02f, 4.85198312e-02f,
  7.73425698e-02f, 6.86544478e-02f, 2.01888103e-02f, 5.87189607e-02f, 1.57109201e-01f, 2.86471490e-02f, 8.04804731e-03f, 2.53340658e-02f, -4.93078493e-02f, -6.19811229e-02f,
  1.68650374e-01f, -4.75423299e-02f, 3.50863785e-02f, -8.09283629e-02f, -1.16095215e-03f, 1.01525132e-02f, -4.97860508e-03f, -1.77742764e-02f, -9.88122523e-02f, -1.80128515e-02f,
  -7.77723938e-02f, -1.29326448e-01f, -4.24490497e-02f, 2.23371424e-02f, -4.54642884e-02f, -9.91805419e-02f, -7.45298564e-02f, -8.99907798e-02f, -3.99940014e-02f, 3.31849121e-02f,
  -3.38641293e-02f, -1.22411326e-01f, -6.20926768e-02f, -2.26356853e-02f, 4.95661385e-02f, 5.12125678e-02f, -1.00464053e-01f, -6.03122786e-02f, 4.11059335e-03f, 5.39758168e-02f,
  -3.55986118e-01f, -3.76619041e-01f, -1.28129646e-02f, -8.00366104e-02f, -3.22580487e-02f, -3.36036235e-02f, 2.66611092e-02f, -7.35209137e-02f, -2.65734107e-03f, 5.95978983e-02f,
  -9.65498686e-02f, -9.47626904e-02f, -3.08443862e-03f, -3.10518853e-02f, 1.78213660e-02f, -3.56564038e-02f, -2.82767788e-02f, -2.54055765e-03f, -8.94360803e-03f, -8.72892514e-02f,
  1.17922453e-02f, 3.77289616e-02f, 9.66935158e-02f, 5.51612861e-02f, 6.29751235e-02f, 3.15759555e-02f, -7.28969201e-02f, 4.89517190e-02f, 4.11233082e-02f, -7.36571103e-02f,
  -1.27021119e-01f, -2.55969107e-01f, -9.77149308e-02f, -1.77129701e-01f, -4.77534682e-02f, -3.16077411e-01f, -1.03294253e-01f, -1.05603561e-01f, 1.28805395e-02f, -4.92086858e-02f,
  6.70531392e-02f, 1.27280047e-02f, 3.05210382e-01f, -2.44406715e-01f, 1.09297251e-02f, 2.00514898e-01f, -2.48173922e-01f, -2.35293191e-02f, 8.21799189e-02f, -1.41233936e-01f,
  -3.08877020e-03f, 1.50565384e-02f, -4.33014967e-02f, -8.24125931e-02f, -8.97182748e-02f, 2.89552240e-03f, 5.75948060e-02f, 1.52823448e-01f, -2.31037363e-01f, 5.62109202e-02f,
  -4.54917364e-02f, 6.15797266e-02f, 8.53678957e-03f, -3.60786021e-02f, -5.62766083e-02f, -5.67254238e-02f, -6.87258318e-02f, 1.54759124e-01f, 7.77528882e-02f, 1.43761495e-02f,
  1.12017319e-01f, 7.68127218e-02f, 1.74121186e-02f, 1.91123098e-01f, -3.10566928e-02f, -2.65986804e-04f, -1.74455289e-02f, -1.06906882e-02f, -3.19776535e-02f, 2.55473536e-02f,
  7.11553544e-03f, -3.31196794e-03f, -1.15132287e-01f, 7.91054517e-02f, 2.50394139e-02f, 3.70877748e-03f, -1.53081924e-01f, -5.66770614e-04f, 4.16547842e-02f, -8.37331340e-02f,
  4.86440100e-02f, -8.30487013e-02f, -1.18931383e-02f, 3.23982649e-02f, -2.75346711e-02f, -3.71617526e-02f, -3.68262567e-02f, 7.52219092e-03f, -8.35979208e-02f, -3.24446373e-02f,
  -4.33450192e-02f, -9.68458429e-02f, 3.86502482e-02f, 6.54653227e-03f, -1.37641495e-02f, -4.55510840e-02f, 5.72539605e-02f, 9.27698538e-02f, -7.49754459e-02f, -5.26384637e-02f,
  1.13693103e-01f, -1.69442073e-01f, -5.31273186e-02f, 4.90226410e-02f, 2.87088733e-02f, 1.10371932e-01f, 2.41644904e-02f, -3.63581628e-02f, -3.78072672e-02f, -4.63211499e-02f,
  -9.75441337e-02f, -9.26619247e-02f, 5.42360097e-02f, -3.06064747e-02f, -4.46378766e-03f, -1.12349510e-01f, -1.68242268e-02f, 9.52337217e-03f, 1.01329885e-01f, -1.10680750e-02f,
  6.74548373e-02f, -6.30562231e-02f, -3.36246863e-02f, -2.40471605e-02f, 6.14544228e-02f, -1.72063917e-01f, -5.23008965e-02f, 1.19585879e-02f, 1.96944028e-02f, -7.31282309e-02f,
  -1.29416240e-02f, 2.45409664e-02f, -1.37724560e-02f, -8.96839425e-02f, -4.49055247e-02f, -8.35059118e-03f, -1.41426280e-01f, -3.32101174e-02f, 4.69387360e-02f, 3.98397855e-02f,
  2.83538938e-01f, -2.11833254e-01f, 1.97754070e-01f, 3.49833593e-02f, -1.28700256e-01f, -1.51221335e-01f, -1.18006915e-01f, -1.33470297e-01f, -2.00647354e-01f, -1.25436068e-01f,
  -1.34760052e-01f, 2.25523189e-01f, -5.91988824e-02f, -4.15461548e-02f, 3.91856320e-02f, -1.28599837e-01f, -6.59632385e-02f, -4.02901715e-05f, -5.90847507e-02f, 1.42944008e-01f,
  1.32672682e-01f, 4.93711680e-02f, 2.09108457e-01f, 2.44798250e-02f, 1.31091490e-01f, 2.46429369e-01f, 1.80528656e-01f, 5.81652485e-02f, 1.22198753e-01f, -8.75106454e-03f,
  1.10252298e-01f, 2.85991970e-02f, 1.39844462e-01f, -3.23495944e-03f, 1.04195110e-01f, 1.31833747e-01f, 1.39806643e-01f, 1.12382837e-01f, 6.40997663e-02f, -1.30450487e-01f,
  2.10718960e-01f, 6.74638972e-02f, 4.36414145e-02f, -1.97438020e-02f, -3.15849222e-02f, -2.50403453e-02f, -1.02409728e-01f, -3.21407877e-02f, -7.71629140e-02f, 1.01392061e-01f,
  -4.45310920e-02f, -1.65774729e-02f, -5.12238294e-02f, 9.50090028e-03f, 6.19764328e-02f, -6.51334226e-02f, 6.99443147e-02f, 1.15244910e-01f, -6.54847622e-02f, -1.71267688e-02f,
  -1.83931850e-02f, 1.33697912e-01f, -8.08248669e-03f, -1.96483098e-02f, 7.00578913e-02f, 2.90828161e-02f, 1.42877176e-02f, 1.78241711e-02f, -9.30384398e-02f, -5.08988351e-02f,
  -2.83046793e-02f, -5.12001365e-02f, -1.13046743e-01f, 1.15459636e-02f, 6.82998970e-02f, 9.21212360e-02f, -1.53070530e-02f, 7.16961846e-02f, 4.05912474e-02f, 3.28858616e-03f,
  -1.17309816e-01f, -1.82553589e-01f, -1.71130318e-02f, -1.21359555e-02f, -1.42020419e-01f, -4.67628092e-02f, 3.00381202e-02f, 1.46736652e-02f, -6.40004650e-02f, 1.96767040e-02f,
  -5.77147258e-03f, 5.28163798e-02f, 1.06191812e-02f, 2.67354015e-04f, 4.54827026e-02f, -5.13493195e-02f, 2.07545534e-02f, 4.04703617e-03f, 3.34720239e-02f, -8.08167830e-02f,
  2.02193320e-01f, 8.27032980e-03f, 4.02754918e-02f, 1.59600540e-03f, -2.50350349e-02f, -7.35540986e-02f, 8.69497657e-02f, 4.14678920e-03f, -3.55766527e-02f, 1.48159683e-01f,
  3.81185263e-02f, 4.98119593e-02f, -2.16354150e-02f, -2.77172960e-02f, -1.88930761e-02f, 1.57186370e-02f, 6.96899369e-02f, 8.01772922e-02f, -1.01945974e-01f, -7.76835382e-02f,
  2.57661015e-01f, -1.45068541e-01f, 3.81029189e-01f, 7.78194517e-02f, -4.61869687e-02f, -2.31098086e-01f, -2.37397179e-01f, -1.50351286e-01f, -7.32344240e-02f, -4.75296170e-01f,
  -2.07100272e-01f, -3.84990796e-02f, -1.77115321e-01f, -3.41837376e-01f, 3.08700595e-02f, -6.60753250e-02f, -3.38612199e-01f, -2.05400214e-01f, 5.69270030e-02f, -1.10706938e-02f,
  1.51436880e-01f, -3.69584531e-01f, 8.12471658e-02f, -1.73232183e-01f, -1.35400742e-01f, 3.23459208e-02f, -4.92257364e-02f, -4.31741998e-02f, -2.67448843e-01f, -1.07921094e-01f,
  1.52835129e-02f, 1.49348721e-01f, -3.52576515e-03f, 1.17464133e-01f, 1.22750346e-02f, 1.87508110e-02f, 9.10182968e-02f, 5.42939678e-02f, 1.18443193e-02f, -2.18582060e-02f,
  -3.49005572e-02f, -1.99606419e-02f, -1.20181888e-01f, -1.64413989e-01f, -1.16591426e-02f, 7.87690002e-03f, 4.25073057e-02f, 8.72919708e-02f, -3.99644114e-03f, 5.68147264e-02f,
  3.35585438e-02f, -4.11002291e-03f, 3.07113044e-02f, -9.64685306e-02f, 1.36084082e-02f, 5.14667891e-02f, 2.61014514e-02f, -2.22169552e-02f, -9.68552306e-02f, -3.10702324e-02f,
  -2.01185290e-02f, 1.33796394e-01f, 3.73055711e-02f, 2.19363812e-02f, 6.02494106e-02f, 6.26298636e-02f, -8.78189355e-02f, 8.63051973e-03f, 6.37587905e-02f, 3.19485627e-02f,
  2.41041984e-02f, -3.58396247e-02f, -2.82903221e-02f, -6.25998601e-02f, -9.83033404e-02f, 6.30348772e-02f, 1.18035235e-01f, -1.20254144e-01f, -4.76615168e-02f, -7.37285167e-02f,
  5.93830179e-03f, 7.00931102e-02f, -3.23978104e-02f, 6.32402003e-02f, -1.79146193e-02f, -1.26798358e-02f, 3.86704095e-02f, 1.91113278e-02f, -2.16883756e-02f, -1.29715115e-01f,
  -1.98572010e-01f, -1.84221759e-01f, -3.18807699e-02f, -3.87056395e-02f, 4.29670811e-02f, 2.66022142e-02f, 1.86938997e-02f, -5.80919869e-02f, -6.48071542e-02f, 5.38787842e-02f,
  2.50891820e-02f, -8.21260363e-02f, 1.72227826e-02f, -1.15973793e-01f, -1.09009765e-01f, -2.19834177e-03f, 7.43231922e-02f, -5.00041731e-02f, -3.39684188e-02f, 2.68083240e-04f,
  -2.79747928e-03f, -7.26944730e-02f, -6.43456578e-02f, -1.40974343e-01f, -7.04256892e-02f, -2.22423654e-02f, -3.86091396e-02f, 1.03816658e-01f, -1.38728052e-01f, -1.31969213e-01f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.00524592e-01f, 2.98250541e-02f, 4.67859745e-01f, -2.79645056e-01f, 1.92836925e-01f, 4.62597400e-01f, 1.84905753e-02f, 2.37485543e-02f, -3.85023773e-01f, -1.04196772e-01f,
  2.58338749e-02f, -2.91050528e-03f, 5.17699793e-02f, -7.37879947e-02f, 2.01321363e-01f, -7.06738606e-02f, -1.49332121e-01f, -6.74989969e-02f, -5.38505130e-02f, -1.98188514e-01f,
  -1.38509333e-01f, -2.03774005e-01f, 1.26268238e-01f, -1.59801751e-01f, 2.45700870e-02f, -3.57693844e-02f, -1.79654747e-01f, 1.09111905e-01f, -2.05389038e-02f, 6.92799687e-02f,
  7.74011249e-03f, -2.49669865e-01f, -5.13354838e-02f, 4.73279655e-02f, 5.52960150e-02f, -4.61481847e-02f, 2.99497452e-02f, 7.26021379e-02f, -6.26072660e-02f, 5.71079887e-02f,
  1.03749305e-01f, 1.09127359e-02f, 2.74765654e-03f, 2.17917711e-02f, 2.57693673e-03f, 6.59952238e-02f, 1.60543367e-01f, 7.78023079e-02f, 6.50738776e-02f, 1.27238765e-01f,
  6.67235926e-02f, 2.23459348e-01f, 2.04849333e-01f, 7.71115199e-02f, 1.08443923e-01f, 8.78748968e-02f, -6.90093786e-02f, 1.15168216e-02f, 1.12984397e-01f, 6.77740946e-02f,
  -1.19459286e-01f, -1.03822500e-01f, 5.63578084e-02f, 1.02806643e-01f, -3.19860317e-02f, 5.16080745e-02f, 3.29337195e-02f, -1.71485101e-03f, 2.57602651e-02f, 1.18278578e-01f,
  -2.44198050e-02f, -2.62689535e-02f, -9.63307321e-02f, -2.42798664e-02f, -1.81860253e-02f, -1.34884283e-01f, 8.75861272e-02f, 9.24984068e-02f, -2.15573609e-02f, 1.24689110e-01f,
  9.00580455e-03f, 2.91662179e-02f, -5.47170416e-02f, 5.69525808e-02f, 7.60290846e-02f, 3.30995256e-03f, -2.18240656e-02f, 6.91807494e-02f, -3.15599479e-02f, 1.36186659e-01f,
  4.43016998e-02f, -2.53923535e-01f, -1.05954811e-01f, -8.79893359e-03f, -9.32972692e-03f, 6.24598376e-02f, -1.31952465e-02f, 5.09295464e-02f, -3.23915035e-02f, -1.02447523e-02f,
  7.83060342e-02f, -5.39586395e-02f, 1.31840006e-01f, -7.45662255e-04f, -4.53699380e-02f, 9.46412906e-02f, -6.81754574e-02f, 5.53902239e-02f, 1.25807270e-01f, 2.01144405e-02f,
  1.05961092e-01f, 2.29552016e-02f, 1.15666248e-01f, -5.26134744e-02f, -1.59853831e-01f, 1.81168705e-01f, -8.61537606e-02f, -7.66963884e-02f, 9.80813801e-02f, 6.94708750e-02f,
  -2.52075475e-02f, -4.55433205e-02f, 1.30014420e-01f, 1.55040562e-01f, -1.77407116e-01f, -1.88327789e-01f, -1.54382408e-01f, -2.16219649e-01f, -1.36586472e-01f, -1.86826646e-01f,
  -2.10915923e-01f, 2.88288504e-01f, -3.76361787e-01f, 2.29282424e-01f, 2.44302928e-01f, -2.11265847e-01f, 1.28125221e-01f, 3.04471683e-02f, -2.73412131e-02f, -7.56371021e-02f,
  -1.14366911e-01f, -1.31617552e-02f, 1.31989062e-01f, 1.74798649e-02f, 1.13659434e-01f, 7.81312436e-02f, 2.11401179e-01f, 2.45317095e-03f, 3.32631856e-01f, 2.65060127e-01f,
  -1.33502847e-02f, -4.22725938e-02f, 1.17942607e-02f, 1.05763778e-01f, -7.14437068e-02f, -3.22676674e-02f, 1.11647770e-01f, 4.01403382e-02f, -1.34425880e-02f, 4.82899435e-02f,
  1.97906159e-02f, 1.10563509e-01f, 9.69696566e-02f, 3.02293338e-02f, -3.54211181e-02f, 7.37085193e-02f, 9.20273960e-02f, -5.79199940e-03f, 1.30437091e-01f, 1.38324255e-03f,
  -3.91099304e-02f, -4.42123860e-02f, 5.63140586e-02f, 1.21448010e-01f, 1.01157971e-01f, -4.50340509e-02f, 9.33089778e-02f, 5.00544086e-02f, 7.77718276e-02f, 6.51387423e-02f,
  1.90103874e-02f, -8.56233239e-02f, -6.18550703e-02f, -9.71695185e-02f, -2.58850176e-02f, -3.31085385e-03f, -6.03427291e-02f, -4.05961499e-02f, 5.91249540e-02f, -9.35819373e-02f,
  -2.23518424e-02f, -2.36856118e-02f, 9.91236512e-03f, -8.70911255e-02f, -3.57474647e-02f, -6.76987767e-02f, -6.99904859e-02f, 1.08009487e-01f, -7.00927973e-02f, -5.20937778e-02f,
  -2.55133379e-02f, 6.71131685e-02f, 4.38656338e-04f, 4.59796973e-02f, -2.03727916e-01f, -6.90600425e-02f, 1.28540829e-01f, 1.10938556e-01f, -1.00182749e-01f, 9.13627818e-02f,
  9.60320458e-02f, 9.72217545e-02f, 3.54859643e-02f, 4.44579124e-02f, 4.59513105e-02f, -8.42687208e-03f, 1.89313535e-02f, 1.58457905e-01f, 3.06435842e-02f, 3.38425562e-02f,
  7.98006877e-02f, 1.96499489e-02f, -4.56375293e-02f, 3.23775448e-02f, 8.28908458e-02f, 2.34585833e-02f, 5.36357202e-02f, 1.37917288e-02f, 1.00820780e-01f, 7.48935267e-02f,
  4.90245558e-02f, -1.88679203e-01f, 1.01342618e-01f, -1.90981980e-02f, 9.62329879e-02f, 9.25061852e-03f, -8.10530186e-02f, -8.72798916e-03f, 9.25317854e-02f, 6.35068044e-02f,
  -3.88460129e-01f, -1.82838276e-01f, 3.81895572e-01f, -2.53241092e-01f, 1.96061581e-01f, 1.67047694e-01f, 1.28010094e-01f, -2.29903728e-01f, -3.67102355e-01f, -2.08985701e-01f,
  9.66653600e-02f, -1.09827712e-01f, 1.82230383e-01f, 1.96965295e-03f, 2.04881191e-01f, 2.49566793e-01f, -1.10352367e-01f, -1.18106492e-01f, 4.16491441e-02f, -1.80276167e-02f,
  7.18395039e-02f, -2.76818834e-02f, 2.83055305e-01f, -9.29475427e-02f, -1.89899039e-02f, -1.63471177e-01f, -1.21992812e-01f, 2.41945103e-01f, -1.54622629e-01f, -1.31504657e-02f,
  -3.23539078e-02f, -1.85428470e-01f, 8.04033577e-02f, -4.67080157e-03f, -5.44629283e-02f, 4.64182943e-02f, -1.17614334e-02f, 1.25162169e-01f, 2.21484844e-02f, 6.11224864e-03f,
  3.07099689e-02f, -9.94341299e-02f, -1.17066115e-01f, 2.51721125e-02f, -2.77043208e-02f, -2.99491510e-02f, 7.72286355e-02f, 7.63241947e-02f, 4.55659218e-02f, 4.74411696e-02f,
  1.10673212e-01f, 5.93254417e-02f, 1.18353814e-02f, -7.72899538e-02f, 1.60368100e-01f, -1.14773856e-02f, 1.00597702e-01f, -8.05214862e-04f, -6.75122887e-02f, -7.52733871e-02f,
  -2.05546301e-02f, 1.14168571e-02f, 1.05280936e-01f, -3.19872312e-02f, 8.98958929e-03f, -5.12017384e-02f, 5.97213507e-02f, 4.08440754e-02f, -3.66681591e-02f, 7.10041896e-02f,
  -4.94460315e-02f, -3.67980227e-02f, -2.83719543e-02f, -2.69484967e-02f, 1.22386534e-02f, 1.47364279e-02f, 1.18126854e-01f, -7.54469493e-03f, -3.19998153e-02f, -3.05169635e-02f,
  2.71569192e-03f, -1.05828699e-02f, 5.42594157e-02f, 7.15513006e-02f, -6.20348752e-02f, 5.89370839e-02f, -6.64238185e-02f, 7.12700235e-03f, -4.59650122e-02f, 7.79640973e-02f,
  -2.51741678e-01f, -3.47286731e-01f, -5.37261516e-02f, -1.18288063e-02f, 3.85494046e-02f, -3.78361829e-02f, 8.17454904e-02f, -5.61593547e-02f, -1.38737643e-02f, 4.82984334e-02f,
  -7.68103004e-02f, -4.85788770e-02f, -6.83321953e-02f, -5.89574873e-03f, -1.85024384e-02f, -7.07128691e-03f, 8.50320235e-03f, 7.85762817e-02f, 1.66158956e-02f, -1.69423565e-01f,
  -6.53636977e-02f, -7.10972026e-02f, -4.96369638e-02f, -7.48813301e-02f, 3.35395560e-02f, -2.33641881e-02f, 6.44851662e-03f, -3.36630382e-02f, 1.70243718e-02f, 9.92546393e-06f,
  -5.73936880e-01f, 4.12314534e-01f, 6.95154592e-02f, 6.74709678e-02f, -5.13240732e-02f, 4.53339636e-01f, 1.93768263e-01f, 2.28360280e-01f, 2.81702548e-01f, 1.21688105e-01f,
  5.87703064e-02f, -8.48157853e-02f, 8.07442740e-02f, 1.90166831e-01f, -2.04906836e-02f, 3.40467066e-01f, 2.28175268e-01f, 9.15681645e-02f, 3.19955945e-01f, -3.00532401e-01f,
  1.92795657e-02f, -2.09690146e-02f, -1.38158619e-01f, -1.28196046e-01f, -1.64470658e-01f, -1.23289645e-01f, -2.61503786e-01f, -4.51266207e-02f, -9.58927814e-03f, 1.22420348e-01f,
  9.39839892e-03f, -1.17621481e-01f, -1.38245881e-01f, 9.30912048e-03f, -1.16370864e-01f, -7.75283501e-02f, -2.77571436e-02f, -2.56698858e-02f, -1.53103098e-02f, 6.78983927e-02f,
  -5.23996279e-02f, 2.80257910e-02f, 1.00660816e-01f, 2.06846781e-02f, -1.28999241e-02f, -6.70084581e-02f, -2.26316825e-02f, 6.48522153e-02f, 5.07293902e-02f, 2.52922028e-02f,
  4.64815795e-02f, 7.07208440e-02f, -3.27761360e-02f, 1.23942956e-01f, 2.27383487e-02f, 9.01310369e-02f, 1.54644862e-01f, -6.69819862e-02f, 1.47086363e-02f, 4.73642275e-02f,
  6.33647293e-03f, 3.09224334e-02f, 2.55937539e-02f, -6.86386302e-02f, -3.48846032e-03f, -6.91328198e-03f, 8.39222455e-04f, -9.57165509e-02f, -4.01234254e-02f, -1.55111045e-01f,
  -9.52272341e-02f, 4.19990234e-02f, 1.07178077e-01f, 1.07661746e-02f, 4.54516262e-02f, 8.50430205e-02f, 3.37609090e-02f, 6.57284632e-02f, -2.35076360e-02f, -2.89320778e-02f,
  1.29983984e-02f, -4.58332151e-03f, -3.14240754e-02f, -2.96330033e-03f, -1.58904362e-02f, 2.70147528e-02f, 1.39061928e-01f, -3.04834098e-02f, -1.77647937e-02f, -5.40232286e-02f,
  1.56968281e-01f, 2.23935083e-01f, 5.01724556e-02f, 2.37674005e-02f, -2.36260761e-02f, -1.72283687e-02f, -1.76061355e-02f, 4.04287204e-02f, 3.71920392e-02f, 4.00777087e-02f,
  -5.86418156e-03f, -2.27245335e-02f, -9.10460278e-02f, -4.49061058e-02f, 5.53448871e-03f, 2.58981716e-02f, -3.60319167e-02f, 4.42880280e-02f, 7.73301348e-02f, 2.53087673e-02f,
  -6.36371151e-02f, -4.20117304e-02f, -1.09266102e-01f, 8.64666328e-03f, 3.91651920e-05f, -6.14384795e-03f, -1.17302455e-01f, 1.57617554e-02f, 4.53899689e-02f, 1.44862859e-02f,
  3.89385134e-01f, -2.99200892e-01f, -2.52873957e-01f, 2.37805456e-01f, 3.17627162e-01f, 3.55669677e-01f, 2.32047796e-01f, 2.85388857e-01f, 2.97735214e-01f, 1.31857703e-02f,
  2.47188404e-01f, -2.07154542e-01f, -1.99810803e-01f, 6.65969178e-02f, 8.08467865e-02f, -8.08764473e-02f, 2.61708796e-01f, 1.06498413e-01f, 7.45629594e-02f, 7.86272883e-02f,
  6.75138161e-02f, 1.97484449e-01f, -1.22377828e-01f, 7.73746297e-02f, 1.84297591e-01f, -6.26065359e-02f, -6.54078946e-02f, -1.56264156e-01f, 1.37571348e-02f, -5.86664900e-02f,
  -2.54059471e-02f, 7.53167644e-02f, 6.76116943e-02f, -3.80449221e-02f, 7.75322244e-02f, 1.06903896e-01f, 1.16861127e-02f, 1.83329638e-02f, -2.13116109e-02f, 2.55542714e-02f,
  4.31781029e-03f, 3.08162905e-03f, 1.20366216e-01f, -7.99690932e-02f, 1.03772096e-01f, 1.57473415e-01f, -2.74544340e-02f, 1.62236646e-01f, 1.30076706e-01f, 5.39708091e-03f,
  -1.03379555e-01f, 8.12618360e-02f, 4.73634861e-02f, -2.29508691e-02f, -3.05016357e-02f, 6.38436377e-02f, -1.95808917e-01f, -5.07127084e-02f, 9.35273096e-02f, 6.59347102e-02f,
  9.28412825e-02f, -1.05331749e-01f, -9.68528260e-03f, -1.03297502e-01f, -1.30528003e-01f, 6.12896904e-02f, 5.32347150e-02f, -1.74519885e-02f, -2.58422755e-02f, 3.05394605e-02f,
  8.60450119e-02f, 5.49309403e-02f, 1.22540250e-01f, -5.00652604e-02f, -6.44283146e-02f, 3.31766764e-03f, 1.15348427e-02f, -5.44552542e-02f, 1.31929725e-01f, 5.56517951e-02f,
  3.63834426e-02f, -4.53739576e-02f, -2.97198892e-02f, 8.65117460e-02f, 3.02035343e-02f, -1.21765383e-01f, 2.47546565e-02f, -2.66337796e-04f, -9.03313532e-02f, 6.35455400e-02f,
  -3.67188863e-02f, -4.08297181e-02f, 6.48929626e-02f, -4.44610938e-02f, -4.71480787e-02f, 1.50404751e-01f, 8.85310546e-02f, 1.93699211e-01f, -2.73842411e-03f, 1.61326125e-01f,
  1.25256971e-01f, -9.84465331e-03f, 5.76017536e-02f, -4.69369255e-02f, -5.88461943e-02f, 1.43334091e-01f, -1.09858751e-01f, 6.69663474e-02f, 1.51558772e-01f, 3.98426577e-02f,
  -1.14689977e-03f, 1.84537843e-01f, 3.26260589e-02f, 1.44741133e-01f, 4.66167405e-02f, -6.15174277e-03f, -4.48805317e-02f, -7.74731487e-03f, 6.66704625e-02f, 6.69265762e-02f,
  -4.89041843e-02f, 9.17782113e-02f, -1.98342472e-01f, -2.86872327e-01f, 1.87030770e-02f, -3.12041044e-01f, -1.80276841e-01f, 3.54732759e-02f, 1.15273617e-01f, 7.25654438e-02f,
  -5.64524345e-02f, 4.92825955e-02f, 8.88977572e-02f, -1.56445250e-01f, -1.84951454e-01f, 1.14365384e-01f, -4.37169582e-01f, -2.07516626e-01f, 1.35399118e-01f, -1.88782513e-01f,
  -1.47975549e-01f, -1.56835958e-01f, -1.73986003e-01f, 7.69531205e-02f, -2.10704222e-01f, -1.56763867e-01f, -2.66878754e-02f, 1.01633765e-01f, -1.90684676e-01f, 2.42066439e-02f,
  3.45335193e-02f, 1.85306862e-01f, 1.58443730e-02f, 5.42007620e-03f, -1.71931714e-01f, -1.17879741e-01f, -1.74642459e-01f, 4.50350530e-03f, 8.06276947e-02f, 2.38231737e-02f,
  -1.42745942e-01f, -1.48265650e-02f, -1.21500259e-02f, 5.26305512e-02f, -8.47201273e-02f, -9.73220449e-03f, 1.41006708e-02f, 3.98318097e-02f, 7.36974040e-03f, -7.42587447e-02f,
  -6.77622389e-03f, -8.19399580e-03f, -5.43418676e-02f, -1.95214956e-03f, -4.15039994e-02f, 6.16520271e-02f, -8.35444182e-02f, -4.67601828e-02f, -7.91541785e-02f, -3.85974012e-02f,
  -6.03476129e-02f, -4.44144160e-02f, 6.03166856e-02f, 3.07871457e-02f, 9.19646397e-02f, 5.22660986e-02f, 2.56389827e-02f, -5.08396812e-02f, 4.29581292e-03f, -3.45243961e-02f,
  -3.92279997e-02f, -1.15367314e-02f, 6.63381219e-02f, -5.00645973e-02f, -1.38057142e-01f, 2.65215826e-03f, -7.99203571e-03f, -1.26342401e-01f, -1.81556299e-01f, -1.22441771e-02f,
  3.10609490e-02f, -6.78709298e-02f, 6.15395233e-02f, -6.45550415e-02f, -2.40211394e-02f, 2.39035115e-02f, -5.35267778e-02f, -4.71596681e-02f, 6.03414476e-02f, -1.31556183e-01f,
  -7.51049146e-02f, -2.62954254e-02f, 9.56334621e-02f, 6.38537258e-02f, 6.90811500e-02f, 4.86894213e-02f, -1.02922589e-01f, -5.79514354e-02f, -6.01524189e-02f, 8.01648647e-02f,
  -1.89964727e-01f, -7.63084888e-02f, -1.12298876e-01f, 6.73835725e-02f, -5.32265678e-02f, -7.39916116e-02f, -9.78125185e-02f, 4.34953906e-02f, -6.42400458e-02f, -6.01037452e-03f,
  2.58499701e-02f, -1.18012084e-02f, -1.33852027e-02f, 1.99227128e-02f, -3.58754955e-02f, -2.46695820e-02f, 2.81889178e-02f, 7.78227970e-02f, -8.86071101e-02f, -1.24447331e-01f,
  2.89016843e-01f, 8.65228325e-02f, -1.42017633e-01f, -7.56568164e-02f, -1.56156585e-01f, -4.43902500e-02f, -1.60585970e-01f, -1.23428077e-01f, -1.78344414e-01f, 7.52317160e-02f,
  -1.39933318e-01f, 5.35817742e-02f, -2.19218142e-04f, 1.85355201e-01f, 2.07510576e-01f, 1.27552256e-01f, 1.53680891e-01f, -7.89234713e-02f, 1.75688080e-02f, 1.65748060e-01f,
  1.65027529e-01f, 3.88840199e-01f, 1.99058622e-01f, 2.24236518e-01f, 1.57843471e-01f, -2.52278056e-03f, 1.50857106e-01f, -1.01227917e-01f, 2.22166479e-02f, -2.02965215e-02f,
  1.36753805e-02f, 6.56484663e-02f, 3.05096414e-02f, -3.51150148e-02f, 8.14783722e-02f, 2.88069472e-02f, 4.06342372e-02f, -5.28192334e-02f, -9.55935642e-02f, -9.54733640e-02f,
  2.87531167e-02f, 5.48720807e-02f, 9.33912769e-03f, 1.98399518e-02f, -5.42135388e-02f, -1.14091106e-01f, 2.09770463e-02f, -7.51322284e-02f, -3.51209678e-02f, 7.97805041e-02f,
  5.91659546e-02f, -3.63277830e-02f, -1.90794263e-02f, 2.01459508e-02f, -7.51705542e-02f, -7.50914142e-02f, 1.56037454e-02f, -6.60940036e-02f, -9.47117433e-02f, 2.46281195e-02f,
  6.76618293e-02f, 1.19784571e-01f, 2.76635531e-02f, -1.13065630e-01f, 4.23981063e-02f, -1.03540577e-01f, -4.42795306e-02f, -3.18435952e-02f, -5.88909201e-02f, 5.17275408e-02f,
  -6.45784289e-02f, -4.68505137e-02f, -4.24632877e-02f, 2.45601907e-02f, 1.47624165e-01f, 1.27736539e-01f, -1.02339387e-01f, -6.38735592e-02f, -3.88460904e-02f, -8.50839689e-02f,
  -1.74762041e-04f, 3.29377092e-02f, -8.73900130e-02f, -3.22885774e-02f, -5.97364679e-02f, -4.88519967e-02f, 1.02556765e-01f, 8.62556219e-04f, -1.25711694e-01f, -4.66825441e-02f,
  9.17473137e-02f, 1.80935055e-01f, -4.81624603e-02f, -4.55188863e-02f, -1.84304118e-02f, 6.63750693e-02f, 1.38856426e-01f, -1.19990914e-03f, 8.73846840e-03f, 1.11346230e-01f,
  4.24309410e-02f, -7.20279813e-02f, 3.09089758e-03f, 1.41893970e-02f, -1.14605486e-01f, -4.46657948e-02f, 1.24905854e-02f, -9.08545107e-02f, -7.75345564e-02f, 4.85213660e-02f,
  -6.00061576e-05f, -2.76539735e-02f, -1.49628818e-02f, -2.60631181e-02f, -2.68935598e-02f, 3.22609805e-02f, -1.48079218e-02f, -4.40636184e-04f, -6.57328889e-02f, -9.03728232e-02f,
  1.57371342e-01f, 4.70392257e-02f, 2.20550820e-01f, -1.34065533e-02f, -1.19150199e-01f, -2.45161340e-01f, -1.82174802e-01f, 2.05561165e-02f, -2.99609452e-01f, -1.51680782e-01f,
  3.48948017e-02f, 2.90556736e-02f, 1.61104426e-01f, 1.23819381e-01f, 1.27134666e-01f, 1.34335637e-01f, -1.61167815e-01f, -1.33409619e-01f, -1.93327814e-02f, 8.27486441e-02f,
  5.83492965e-02f, 1.51092643e-02f, 4.05976981e-01f, 8.41336101e-02f, 7.63853043e-02f, 1.36082113e-01f, 1.23805769e-01f, 1.35742947e-01f, -7.74205476e-02f, 1.15696095e-01f,
  -4.64590006e-02f, 2.05959320e-01f, 7.23732784e-02f, -3.07495911e-02f, 9.58332643e-02f, 8.09318013e-03f, 5.53564914e-02f, 7.72707239e-02f, -5.19541427e-02f, -6.74918815e-02f,
  -1.11938072e-02f, 6.00151997e-03f, 3.44012678e-02f, -3.38688027e-03f, -1.64729789e-01f, -1.58968121e-01f, -5.27576543e-02f, -6.50313422e-02f, -6.41710609e-02f, 8.16965103e-02f,
  6.96598515e-02f, -9.67614055e-02f, 1.29448681e-03f, 3.80620137e-02f, 3.92288752e-02f, -1.00388259e-01f, -2.98506916e-02f, 1.36626381e-02f, -1.12297155e-01f, -6.46991134e-02f,
  8.95203874e-02f, -1.39974341e-01f, -1.07453942e-01f, -1.15975231e-01f, -7.67095312e-02f, -1.41733894e-02f, -6.75607473e-02f, 1.93782467e-02f, 2.52749510e-02f, -5.03341928e-02f,
  -1.08897544e-01f, -1.13666601e-01f, -7.70144165e-02f, -1.24285072e-02f, -2.85100546e-02f, 7.74293840e-02f, 9.21522379e-02f, 6.41495883e-02f, -7.95589760e-02f, -1.74667295e-02f,
  -2.51602270e-02f, 1.29807647e-02f, -1.02107242e-01f, 1.70593075e-02f, -2.21978739e-01f, -9.90092680e-02f, 3.61197479e-02f, 2.46119201e-02f, 1.31833507e-02f, 6.36007860e-02f,
  8.20145160e-02f, 2.14183494e-01f, 3.57736535e-02f, -1.10094704e-01f, 1.31685920e-02f, -1.08993156e-02f, -4.87857638e-03f, 3.19249108e-02f, -3.16914357e-03f, 4.89907973e-02f,
  1.60174500e-02f, -7.03569874e-02f, -7.92324916e-02f, 4.92673442e-02f, -1.30205542e-01f, -1.07419498e-01f, -4.48080152e-02f, -1.52712464e-01f, 1.32067064e-02f, 9.60957482e-02f,
  4.32286896e-02f, -8.33563507e-02f, 1.17774783e-02f, -8.06824863e-02f, -5.07709896e-03f, 3.49005088e-02f, 4.88442660e-04f, -5.84250763e-02f, -2.00571865e-02f, -2.91614514e-02f,
  1.41374961e-01f, -3.96185577e-01f, -2.16888078e-02f, 2.28248417e-01f, 5.36537170e-02f, -2.27381244e-01f, -1.85816079e-01f, 7.91975018e-03f, 1.59406811e-01f, -2.02596173e-01f,
  1.07928425e-01f, -8.48504994e-03f, -8.78763422e-02f, 4.27429564e-02f, 2.25291684e-01f, 5.65311089e-02f, -5.10659367e-02f, -2.91011054e-02f, 2.64802545e-01f, -1.03151172e-01f,
  1.97532311e-01f, -6.11936674e-02f, -7.45374933e-02f, -1.71266824e-01f, -8.40962604e-02f, -1.81203950e-02f, 1.08532906e-01f, -1.95110157e-01f, -9.41110682e-03f, 5.19826710e-02f,
  -1.77979797e-01f, -2.93238740e-02f, -1.26432344e-01f, -1.16534896e-01f, -6.66993409e-02f, -4.97246012e-02f, 1.11836232e-02f, 4.26509269e-02f, -3.19674350e-02f, -1.09999269e-01f,
  -7.72403479e-02f, 1.55735120e-01f, 7.23496079e-02f, 5.89236766e-02f, -1.17010549e-01f, -7.10773543e-02f, 1.36375129e-01f, -5.58168292e-02f, -6.51184609e-03f, 1.40406623e-01f,
  -1.02040224e-01f, -1.33911669e-02f, 2.91130431e-02f, 1.63362194e-02f, 3.42787690e-02f, 9.59716514e-02f, 4.38407399e-02f, -1.18329255e-02f, 1.12598846e-02f, 8.24099407e-02f,
  3.96916866e-02f, 5.57524748e-02f, -4.37029228e-02f, -9.04646441e-02f, -1.22807883e-02f, 4.68033850e-02f, -7.68949687e-02f, -4.62662205e-02f, -7.53877833e-02f, -6.78188652e-02f,
  -4.44847085e-02f, -4.10674177e-02f, -6.69557303e-02f, -2.77893189e-02f, 8.89835879e-03f, 3.08102891e-02f, -7.88805112e-02f, 1.01552233e-01f, -1.01486981e-01f, 1.69489477e-02f,
  2.53864750e-02f, -2.29116958e-02f, -5.15502691e-02f, 1.25751765e-02f, -3.16423140e-02f, -1.48406904e-02f, -4.16904502e-02f, 7.44688958e-02f, -3.42623182e-02f, -3.87503430e-02f,
  -3.94386470e-01f, -3.59244764e-01f, -1.52205348e-01f, -5.62246479e-02f, -1.16400078e-01f, -6.31995350e-02f, 4.47418727e-02f, 3.21398415e-02f, -1.93246230e-01f, -4.54470180e-02f,
  4.10176668e-04f, -5.74424192e-02f, -4.01570275e-02f, 8.43172893e-02f, -1.73672467e-01f, 2.61873892e-03f, 2.19665188e-02f, -8.06302875e-02f, -4.12621498e-02f, 8.42820555e-02f,
  -6.17498197e-02f, -8.48015100e-02f, -4.54893596e-02f, 9.35589895e-03f, 1.37198251e-02f, -5.13690785e-02f, 1.95566732e-02f, 4.66081239e-02f, 1.54931145e-03f, -6.62716255e-02f,
  -5.20045459e-01f, 4.42898005e-01f, -4.10136115e-03f, 4.71656322e-02f, -8.37717876e-02f, 4.84079659e-01f, 2.39968225e-01f, 1.91825360e-01f, 3.10715020e-01f, 3.33211422e-01f,
  1.82468206e-01f, 2.04870738e-02f, 1.62592530e-01f, 2.43911043e-01f, 6.27994537e-02f, 4.15173262e-01f, 3.01883936e-01f, 1.71473935e-01f, 7.14796856e-02f, -1.98949024e-01f,
  1.03985053e-02f, 1.19199909e-01f, 2.41482127e-02f, 9.51688960e-02f, -7.18810037e-02f, -1.76382557e-01f, -1.23902366e-01f, -1.37015894e-01f, 8.59962702e-02f, 1.67788118e-01f,
  -3.52346376e-02f, -1.53197855e-01f, -4.57426682e-02f, 7.99014270e-02f, -9.65841562e-02f, -2.00149372e-01f, -1.69843528e-02f, -5.97431771e-02f, -1.35072336e-01f, 7.51584917e-02f,
  -2.35874858e-03f, 1.79395676e-02f, 1.19577006e-01f, 4.59185056e-03f, -5.45634106e-02f, 2.88631152e-02f, 6.62672287e-03f, 9.70115587e-02f, 1.81303769e-02f, -2.64105294e-02f,
  6.35972768e-02f, 1.39760152e-01f, -4.26611230e-02f, 1.69270799e-01f, 8.36314783e-02f, 1.45340875e-01f, 1.81832984e-01f, -6.26368299e-02f, 1.63288176e-01f, 8.85653272e-02f,
  -4.85694371e-02f, -5.11379540e-02f, -4.34861034e-02f, 2.76035517e-02f, -5.63004129e-02f, -4.55004349e-03f, 4.64626849e-02f, -3.96661088e-02f, -2.55786367e-02f, 4.95301299e-02f,
  5.43446001e-03f, 8.62425100e-03f, 4.43147644e-02f, -1.26205282e-02f, 8.92679840e-02f, 7.78476568e-03f, 1.63028657e-03f, 2.08811350e-02f, 7.64650758e-03f, 9.80574079e-03f,
  -1.07498989e-02f, 2.75141075e-02f, 3.21462564e-02f, -7.98864476e-03f, 7.41724744e-02f, -2.81928037e-03f, 1.74824428e-02f, -7.06863776e-02f, -2.26644520e-02f, -6.86716065e-02f,
  2.21654683e-01f, 2.97011673e-01f, 3.71571183e-02f, 3.11203822e-02f, -3.15651000e-02f, -2.44857837e-02f, -7.78904930e-02f, 6.11426793e-02f, 7.90288001e-02f, 4.76582721e-02f,
  -1.46768931e-02f, 1.71090200e-04f, -2.24330388e-02f, -4.80813570e-02f, 3.16406600e-02f, 1.43799722e-01f, -1.03532830e-02f, 4.27290574e-02f, 9.42119583e-02f, 3.26188579e-02f,
  1.87784024e-02f, -2.49169357e-02f, -1.12745026e-02f, 9.03355628e-02f, 3.59569862e-02f, 1.11934975e-01f, -5.37954308e-02f, 2.00566277e-02f, 8.68887678e-02f, 1.21650405e-01f,
  -4.54366207e-01f, 2.35600740e-01f, -2.32397676e-01f, 1.91938377e-03f, -1.98220223e-01f, -1.97972935e-02f, 2.60918796e-01f, 2.02422552e-02f, 3.01905721e-01f, 4.16963607e-01f,
  1.69816211e-01f, 9.31629986e-02f, 2.91605622e-01f, 1.72489733e-01f, -2.72049397e-01f, 2.34572232e-01f, 3.03810239e-02f, 4.54209223e-02f, 7.68100917e-02f, 4.57946062e-02f,
  -1.69639170e-01f, 1.60370842e-01f, -1.88843876e-01f, -3.69061790e-02f, -2.18204647e-01f, -2.35250354e-01f, -1.11074306e-01f, -1.75711326e-02f, -1.47864014e-01f, -1.65213607e-02f,
  -2.18734875e-01f, -1.96101621e-01f, -1.19805962e-01f, -7.48703331e-02f, -2.12220013e-01f, -8.10281634e-02f, -1.91473991e-01f, 1.40151083e-02f, 3.46749648e-02f, 6.86153620e-02f,
  5.57418028e-03f, -6.81043044e-02f, 3.04218568e-02f, 1.27282277e-01f, 9.89729241e-02f, 4.01610993e-02f, -6.57093152e-02f, -2.76885219e-02f, 1.11416042e-01f, -1.50996655e-01f,
  3.23072560e-02f, -9.39214155e-02f, -2.35077390e-03f, -2.61334446e-03f, -9.56144631e-02f, 6.93297833e-02f, -9.37225297e-03f, -7.55655393e-02f, -5.52078970e-02f, -1.14031762e-01f,
  -4.98326644e-02f, 6.67762384e-02f, 4.51587923e-02f, 8.84602815e-02f, -3.14459279e-02f, -1.68130130e-01f, 9.00761038e-03f, -4.79395688e-02f, 9.32621211e-02f, 3.16110738e-02f,
  -3.10466662e-02f, -9.16430447e-03f, -4.71663401e-02f, 3.73643748e-02f, 5.66305295e-02f, 8.88379887e-02f, 6.40689805e-02f, -4.71972525e-02f, -1.03469223e-01f, -1.06672391e-01f,
  5.27849644e-02f, 4.24102917e-02f, 2.95261890e-02f, -2.68175900e-02f, -4.74404283e-02f, 5.10095619e-03f, 2.28639990e-02f, -5.01119681e-02f, 4.08691876e-02f, 2.04557180e-02f,
  -9.15761665e-02f, -1.15258299e-01f, 8.04725662e-02f, -5.88821657e-02f, 7.33657880e-03f, 3.14579234e-02f, -1.01969857e-02f, -9.15717930e-02f, 3.33343633e-02f, 5.75996414e-02f,
  -4.95414324e-02f, -2.77918056e-02f, -9.15679783e-02f, 5.81000187e-02f, 9.16031376e-02f, -2.53945161e-02f, -6.40662445e-04f, 2.16133483e-02f, -8.81465711e-03f, -6.25508428e-02f,
  -6.48006285e-03f, 3.32828723e-02f, 4.31590229e-02f, 2.53678951e-02f, -8.32424164e-02f, 5.18294238e-02f, -1.39618784e-01f, 6.73198998e-02f, -1.13920659e-01f, -7.21623152e-02f,
  -3.43451738e-01f, 1.50910780e-01f, 9.61590267e-04f, -1.08229041e-01f, -3.99679571e-01f, 1.26346186e-01f, 2.15569660e-01f, 2.50497311e-02f, 5.98392589e-03f, 9.80925560e-02f,
  4.46069166e-02f, -7.88677931e-02f, 2.57422775e-01f, -4.09088135e-02f, -1.69480801e-01f, 3.55915964e-01f, 9.86609980e-02f, 8.94348845e-02f, 1.65596977e-02f, -5.50436974e-02f,
  -2.60497004e-01f, -1.84011832e-01f, 6.35913163e-02f, -1.10302351e-01f, -2.94482887e-01f, -5.23342788e-02f, -3.02529097e-01f, -1.61951497e-01f, -2.35644594e-01f, -1.70867980e-01f,
  8.35803971e-02f, -8.75957012e-02f, 9.11351293e-02f, 2.24650040e-01f, 6.99127764e-02f, -3.05446424e-02f, 8.16480257e-03f, 1.06719658e-01f, -5.21027623e-03f, 1.93083826e-02f,
  2.38953121e-02f, 3.74601744e-02f, -1.80788804e-02f, -1.69556975e-01f, -1.36254728e-01f, -8.06378424e-02f, 8.05117786e-02f, 6.57464638e-02f, 1.47290215e-01f, -1.57942116e-01f,
  5.21006174e-02f, 8.93714465e-03f, -5.06458469e-02f, 2.32697297e-02f, -2.22821720e-02f, 3.87356207e-02f, 2.84237713e-02f, -5.57280220e-02f, -2.14838162e-02f, -1.57267570e-01f,
  -9.77095887e-02f, -2.80572586e-02f, -2.10429523e-02f, 3.42995450e-02f, -6.97417036e-02f, 2.27854569e-02f, -4.76665199e-02f, -5.24561219e-02f, 1.44299194e-02f, -1.49529823e-03f,
  3.36004607e-02f, -2.65998282e-02f, 4.44625616e-02f, -4.14065272e-02f, -1.24865882e-01f, 2.97493283e-02f, 9.01606455e-02f, -8.89200997e-03f, -4.49819006e-02f, 7.12489337e-02f,
  -1.38899162e-02f, 5.05484380e-02f, 7.66513795e-02f, 2.78286822e-02f, 1.66260421e-01f, -9.42320004e-02f, -2.38148645e-02f, -2.47854330e-02f, 1.72178447e-01f, -1.97049342e-02f,
  1.44678414e-01f, 3.69522534e-02f, 1.04277216e-01f, 1.82105720e-01f, 9.17432755e-02f, -8.11691135e-02f, -6.78517818e-02f, 5.73540181e-02f, -5.27304001e-02f, 1.30380914e-02f,
  1.48400210e-03f, 1.37692377e-01f, -3.84180620e-02f, -8.22230652e-02f, 1.02006555e-01f, 2.81646438e-02f, 5.04091904e-02f, 1.15386359e-01f, 9.08029154e-02f, -6.13122731e-02f,
  7.98526481e-02f, 3.06352507e-02f, 4.50466610e-02f, -1.09231127e-02f, 2.31806356e-02f, 5.55610843e-03f, -8.74041244e-02f, 4.91404496e-02f, -6.17069751e-02f, 5.28072640e-02f,
  -1.11514013e-02f, -3.63579169e-02f, 2.67357588e-01f, 2.53223535e-02f, -4.31121551e-02f, 3.32079120e-02f, -3.82582955e-02f, -1.27331659e-01f, -2.51033723e-01f, -1.44826174e-01f,
  -1.43486820e-02f, 1.83824450e-01f, -7.68401399e-02f, -1.75089046e-01f, -2.20148608e-01f, -3.76312971e-01f, -5.97448535e-02f, 1.62042782e-01f, -8.74503553e-02f, 1.44295678e-01f,
  -2.90485378e-02f, -4.02105093e-01f, 2.10583378e-02f, -1.13375105e-01f, 1.03238314e-01f, 2.82214284e-01f, -6.00813255e-02f, 1.20808870e-01f, 1.30526617e-01f, 1.36302719e-02f,
  4.54856232e-02f, -9.40260887e-02f, 5.08623943e-02f, 2.11729817e-02f, 3.62475850e-02f, 9.29449499e-02f, 4.37027216e-02f, 3.09731904e-03f, 4.36630473e-02f, -7.11048841e-02f,
  1.01173045e-02f, 6.92213699e-02f, -1.38412521e-04f, 1.17169432e-02f, 7.30772968e-03f, 4.31175493e-02f, -2.92854123e-02f, 1.11250132e-01f, -3.39771211e-02f, 7.70999864e-02f,
  7.04258904e-02f, 8.02612603e-02f, 9.00783688e-02f, 6.92657754e-02f, 9.82795581e-02f, 4.53741811e-02f, 9.37254652e-02f, 1.05090693e-01f, -1.98098756e-02f, 2.92910598e-02f,
  -2.53206212e-02f, -1.41319171e-01f, -1.32591754e-01f, -6.27736524e-02f, -1.14638574e-01f, 1.51539044e-02f, -1.30875960e-01f, -9.30781439e-02f, 6.51950985e-02f, -4.92594317e-02f,
  4.96879499e-03f, -4.38790694e-02f, -6.53409883e-02f, 2.43257843e-02f, -9.42660868e-02f, -1.08114868e-01f, 1.61284998e-01f, 1.53670460e-01f, 1.42458305e-01f, 6.23498745e-02f,
  -3.36395390e-02f, 9.04900432e-02f, 1.46196812e-01f, 3.30192186e-02f, -9.17612091e-02f, -1.79812945e-02f, 1.79167427e-02f, 6.82846755e-02f, -7.55822435e-02f, 7.69281238e-02f,
  1.34701148e-01f, 1.39657697e-02f, 4.65619713e-02f, 2.06523901e-03f, -2.81690024e-02f, 5.25142357e-04f, -1.79804876e-01f, -2.02985131e-03f, 7.64418617e-02f, -2.25654036e-01f,
  9.82935950e-02f, 1.28492087e-01f, -1.09533453e-02f, 1.34479821e-01f, 5.62236086e-02f, 5.07188924e-02f, -2.48513464e-02f, 6.98753893e-02f, 3.70872915e-02f, 2.13570118e-01f,
  9.64833647e-02f, -3.01593984e-03f, -4.21966054e-02f, 1.95182282e-02f, 7.60666430e-02f, 1.18360780e-01f, 7.42287263e-02f, -7.37381168e-03f, 8.33210498e-02f, 3.87352109e-02f,
  -6.34645998e-01f, 1.07910216e-01f, 3.71846676e-01f, -4.44539189e-01f, -7.72655979e-02f, 2.91703910e-01f, 1.09648734e-01f, -9.21901539e-02f, -2.20711976e-01f, 7.06132082e-03f,
  3.11486702e-02f, -1.57342359e-01f, 3.68269265e-01f, -1.12338699e-01f, 2.00487688e-01f, 3.82347286e-01f, -8.17100406e-02f, -5.16868755e-02f, -7.44208694e-02f, -1.98174417e-01f,
  -2.65014009e-03f, -1.94750145e-01f, 2.96622455e-01f, -1.54728606e-01f, -1.83932245e-01f, -1.59838423e-01f, -1.97632834e-01f, 1.29476488e-01f, -2.34315187e-01f, 2.28001568e-02f,
  -8.65410268e-02f, -2.96508640e-01f, 4.32157367e-02f, -7.38657126e-03f, -1.42597079e-01f, 2.30550636e-02f, -6.41642213e-02f, 6.02504350e-02f, -4.99414988e-02f, -8.14571008e-02f,
  1.47327008e-02f, 7.75238499e-02f, -2.06017673e-01f, 1.25826940e-01f, -3.67108025e-02f, -4.14886773e-02f, 2.90172007e-02f, -1.20920604e-02f, 1.63945425e-02f, 5.59105575e-02f,
  1.77158386e-01f, 6.38815314e-02f, 3.18218172e-02f, 2.72487830e-02f, 9.66585875e-02f, 1.63958799e-02f, 1.08832054e-01f, 5.56362905e-02f, -9.65046659e-02f, -1.66192144e-01f,
  2.34279577e-02f, 2.67071296e-02f, 1.19720042e-01f, 6.55649006e-02f, -8.35769549e-02f, -2.63376441e-03f, 5.98140098e-02f, 8.78261179e-02f, 5.03054224e-02f, 3.85310315e-02f,
  2.46233828e-02f, 5.27730361e-02f, -3.73901539e-02f, -1.68909051e-03f, 4.93610054e-02f, 1.29308784e-02f, 1.12482242e-01f, -8.82405043e-02f, 2.05236189e-02f, -4.03932519e-02f,
  -8.54383688e-03f, -1.21941399e-02f, 1.91062670e-02f, 1.30639195e-01f, 9.33146328e-02f, 7.13603124e-02f, 1.36770140e-02f, 5.84268458e-02f, -8.69062841e-02f, 2.82322858e-02f,
  -2.07117394e-01f, -3.04531217e-01f, 5.85350990e-02f, -8.66474584e-02f, 1.48773212e-02f, 5.74139059e-02f, 2.64056288e-02f, -3.43518183e-02f, -1.18777417e-01f, -7.80866221e-02f,
  -7.22293556e-02f, 4.49908664e-03f, -5.08320332e-02f, 4.57712449e-02f, 6.88761175e-02f, 3.36037688e-02f, -4.62140106e-02f, -3.21408804e-03f, -1.49056753e-02f, -8.01067799e-02f,
  4.31745732e-03f, -5.22367805e-02f, 1.25441715e-01f, -1.27545968e-01f, 1.08141772e-01f, -7.03541338e-02f, -9.84118879e-02f, 3.14975753e-02f, -3.35389301e-02f, 2.35216133e-02f,
  3.33783701e-02f, -8.62049125e-03f, -2.52759214e-02f, 8.26210156e-02f, -6.82427082e-03f, -2.30299488e-01f, -2.01297447e-01f, 2.25246977e-02f, 3.33249211e-01f, -1.45937249e-01f,
  -3.55857573e-02f, -3.10830753e-02f, -5.32403924e-02f, -2.53954262e-01f, 6.87942877e-02f, -1.20020851e-01f, 8.47963467e-02f, -1.25749841e-01f, 1.78726017e-01f, 4.53811139e-02f,
  7.06802458e-02f, -2.55149871e-01f, -1.61854029e-01f, -1.58801809e-01f, -2.21253648e-01f, -4.77351174e-02f, -8.84810649e-03f, -8.51113498e-02f, -2.07204282e-01f, -2.49446160e-03f,
  -3.30079608e-02f, -5.97899873e-03f, -7.63003994e-03f, -5.70461415e-02f, 1.35588929e-01f, -6.81912974e-02f, -1.29185185e-01f, -2.02111170e-01f, 6.34354055e-02f, 3.13256644e-02f,
  4.49289083e-02f, -6.55060858e-02f, -6.28338289e-03f, -1.80257142e-01f, -1.42000895e-02f, 7.45468885e-02f, 2.69952491e-02f, 1.77833810e-01f, -2.32329126e-02f, 1.73269417e-02f,
  3.57215628e-02f, 1.08943976e-01f, 2.35899463e-01f, 6.47068694e-02f, 1.53868780e-01f, 1.53860785e-02f, -3.51032168e-02f, 8.64563789e-03f, 7.10569918e-02f, 1.06600039e-02f,
  2.59125084e-02f, 9.02778655e-02f, -1.16002470e-01f, -5.09556755e-02f, 2.84348126e-03f, 1.05103165e-01f, 8.70129839e-03f, 1.86967961e-02f, 1.18929468e-01f, -3.12467245e-03f,
  2.69630868e-02f, -9.85739827e-02f, 3.58630046e-02f, -4.67333645e-02f, -4.72431704e-02f, -9.81987864e-02f, -5.45400232e-02f, -9.16387141e-03f, 8.58690515e-02f, 6.36632964e-02f,
  -1.74701065e-01f, -1.54036274e-02f, 2.58695018e-02f, -5.08227125e-02f, -8.21979716e-02f, -6.08711131e-02f, -9.67787802e-02f, 2.13269833e-02f, 5.85334748e-02f, 1.19990580e-01f,
  1.21514320e-01f, 1.76949859e-01f, 6.36133775e-02f, -1.81424040e-02f, 4.68930081e-02f, 4.12746705e-02f, -3.23122777e-02f, -7.28048244e-03f, 8.87496918e-02f, -7.38961846e-02f,
  9.99109671e-02f, 3.87517735e-02f, 9.53077674e-02f, -1.12198316e-01f, 6.76633045e-02f, 3.75295095e-02f, 8.02462641e-03f, 1.44890860e-01f, 1.52329281e-01f, 9.80563182e-03f,
  -7.37578608e-03f, 7.79360756e-02f, 1.91625044e-01f, 1.52004689e-01f, 1.09353706e-01f, 7.89043680e-02f, 6.58120662e-02f, 9.66972560e-02f, 6.28079697e-02f, 1.09619856e-01f,
  -2.13052183e-01f, 1.70014411e-01f, -5.91501594e-03f, 1.63667083e-01f, 5.51225841e-02f, 4.85265478e-02f, -2.72740543e-01f, 1.91998586e-01f, -2.59081870e-01f, -2.56991178e-01f,
  -5.34434505e-02f, -6.51074126e-02f, -1.49175778e-01f, 2.41418332e-01f, 1.53412297e-01f, 8.83322358e-02f, 3.24218959e-01f, 1.75143972e-01f, 2.64916420e-01f, 2.56598800e-01f,
  3.14325213e-01f, 2.86124110e-01f, 3.44388157e-01f, 4.30744290e-01f, 2.83230245e-01f, 2.75439292e-01f, 9.46443528e-02f, 9.51533541e-02f, 2.64788032e-01f, -1.15692295e-01f,
  -1.05802037e-01f, -5.47947884e-02f, -1.45357609e-01f, -1.30980462e-01f, -3.56476456e-02f, -7.75433853e-02f, -7.76332244e-02f, -9.74065438e-02f, 2.55047996e-02f, 4.25329655e-02f,
  -4.81535913e-03f, 1.45549804e-01f, 9.64733884e-02f, -1.08044289e-01f, -5.04569337e-02f, 4.96180803e-02f, 2.03497693e-01f, 2.64912900e-02f, 5.53605035e-02f, 8.52237567e-02f,
  1.05333067e-01f, 1.30726323e-01f, 3.83615531e-02f, 1.90778822e-01f, 7.26523697e-02f, -2.63080262e-02f, -8.52276385e-02f, -3.78336422e-02f, 1.40249759e-01f, -8.10830202e-03f,
  4.19214973e-03f, -7.07577839e-02f, 1.43215671e-01f, 5.27093299e-02f, 3.14128846e-02f, -3.91590185e-02f, 6.07687607e-03f, 1.00609558e-02f, -3.53668481e-02f, -4.72588502e-02f,
  1.13943465e-01f, 1.47744313e-01f, -7.14749545e-02f, -1.01762757e-01f, -4.21046698e-03f, -1.83575407e-01f, 5.01947254e-02f, -6.87364023e-03f, 4.40561250e-02f, 8.48619118e-02f,
  -8.01493004e-02f, 2.18875464e-02f, 1.36020714e-02f, -2.30967775e-02f, -1.68655219e-03f, -3.49842422e-02f, 1.08304119e-03f, -1.19362563e-01f, 1.77751049e-01f, 1.76503494e-01f,
  -1.26491800e-01f, -1.05079841e-02f, -5.76863028e-02f, -2.59981230e-02f, 2.82238647e-02f, 9.24981907e-02f, -5.74814938e-02f, 9.15020555e-02f, 1.61757041e-02f, -1.06964624e-02f,
  -8.89830408e-04f, -2.21034754e-02f, -9.82586220e-02f, -5.70970289e-02f, 8.63422975e-02f, -2.88835708e-02f, -3.78781818e-02f, -5.80084175e-02f, -2.47719064e-02f, 8.23609829e-02f,
  8.74563083e-02f, 7.72400796e-02f, 1.12755865e-01f, 9.52304304e-02f, 8.33566487e-02f, -1.35156319e-01f, 5.48038892e-02f, -7.46099576e-02f, 1.41333312e-01f, 5.34300169e-04f,
  -1.09309874e-01f, -7.49781802e-02f, 1.23871408e-01f, 2.06129164e-01f, -1.00583613e-01f, -9.77834016e-02f, -6.62257224e-02f, -1.37325719e-01f, 1.66521460e-01f, -1.68924019e-01f,
  -2.95943379e-01f, 1.52126327e-01f, -3.70621651e-01f, -4.70128842e-03f, 6.95895404e-02f, -2.69798458e-01f, 3.22267175e-01f, 6.98918626e-02f, -2.64036767e-02f, 1.35835797e-01f,
  -5.34872413e-02f, -9.75079760e-02f, -1.15177520e-01f, 3.25120054e-02f, -9.73793790e-02f, 2.13646382e-01f, 1.55722471e-02f, 5.96026964e-02f, 3.01724732e-01f, 8.81663635e-02f,
  -5.89833409e-02f, -7.76897743e-02f, -5.26723079e-03f, 1.47588342e-01f, 9.43361595e-03f, -1.21207677e-01f, 9.76343080e-02f, -1.69707779e-02f, 1.05381757e-01f, 5.95965236e-02f,
  1.62990112e-02f, 1.51855990e-01f, 9.61071774e-02f, -2.61934679e-02f, 2.33903870e-01f, 1.18403770e-01f, 1.14058658e-01f, -8.07952583e-02f, 6.61028102e-02f, -1.83934197e-01f,
  -1.01137497e-01f, -1.64298173e-02f, 1.04974248e-01f, 1.01200618e-01f, 1.78946555e-01f, 2.06258655e-01f, 1.09398708e-01f, 1.00545801e-01f, 9.11110714e-02f, 1.35002226e-01f,
  -1.12925194e-01f, -7.62973204e-02f, -6.96853846e-02f, -7.85215721e-02f, -2.13518203e-03f, -1.13945203e-02f, 3.51480581e-02f, -1.00160636e-01f, 6.26571476e-02f, -2.29114611e-02f,
  1.08226493e-01f, -1.39406137e-02f, 6.08498752e-02f, 3.29450518e-02f, -9.99476239e-02f, -2.12092493e-02f, 4.92045470e-02f, 5.06825410e-02f, 3.40497196e-02f, -9.64110568e-02f,
  -2.38664463e-01f, 2.27374360e-02f, 6.20657615e-02f, -4.25485522e-02f, -4.41135690e-02f, 6.43909499e-02f, -6.94604591e-02f, -3.26913074e-02f, -1.17069416e-01f, -2.19627265e-02f,
  1.13289639e-01f, 8.21912959e-02f, 3.41631025e-02f, 1.35349751e-01f, 1.66826919e-02f, -5.47811575e-02f, 1.36286602e-03f, 1.04145572e-01f, 1.49306133e-01f, -1.69837058e-01f,
  -2.17434671e-02f, 1.19183101e-01f, 3.69326025e-02f, -4.22733463e-02f, 1.72395840e-01f, 1.08388461e-01f, 9.23134834e-02f, 1.29263392e-02f, 1.46995544e-01f, -4.99338731e-02f,
  -8.99990499e-02f, -4.08455804e-02f, 1.68928266e-01f, 1.68267995e-01f, 5.83201051e-02f, 5.86597957e-02f, -1.88737288e-02f, 1.02185868e-01f, 1.16042758e-03f, 1.69114530e-01f,
  2.49025255e-01f, 1.50056183e-01f, 4.85521043e-03f, 1.21283874e-01f, -1.95375040e-01f, -1.35071561e-01f, -1.89573899e-01f, 6.57554269e-02f, -5.16398586e-02f, 8.38266164e-02f,
  4.20576334e-02f, 1.59380496e-01f, 1.14868097e-01f, 2.14518905e-01f, -8.03457350e-02f, -5.68131171e-03f, 1.37388363e-01f, 3.28982733e-02f, -3.72792408e-02f, 5.61648719e-02f,
  1.80880710e-01f, 9.34142992e-02f, 2.61378855e-01f, -2.83250446e-03f, 1.20617025e-01f, 1.35395795e-01f, 1.36377648e-01f, -1.01108111e-01f, 1.05768189e-01f, -2.26233955e-02f,
  2.05107406e-02f, 9.88053977e-02f, 5.51845916e-02f, -3.70380729e-02f, -3.44645530e-02f, -4.70853820e-02f, 2.51636300e-02f, -2.68593431e-02f, -1.21267363e-01f, 2.52092388e-02f,
  3.53594944e-02f, 7.08875433e-02f, -3.01418384e-03f, 2.26204023e-02f, -1.63473226e-02f, -3.80982049e-02f, 8.13461095e-02f, 3.86446565e-02f, 1.81642324e-02f, 1.59057736e-01f,
  1.33282766e-02f, 2.05448307e-02f, 1.00275636e-01f, 2.83044875e-02f, 7.74714649e-02f, -3.57990153e-02f, 7.80491531e-03f, 6.21626675e-02f, 3.81389447e-02f, 4.37968373e-02f,
  7.45444372e-02f, 1.97108034e-02f, -6.28648996e-02f, -4.50803749e-02f, -9.31291878e-02f, -3.16192396e-02f, -4.70561814e-03f, 2.13569030e-02f, 5.27602155e-03f, -4.68970276e-02f,
  -2.61695217e-02f, -4.47257608e-02f, -4.23634276e-02f, 8.54716729e-03f, 1.03432946e-01f, 6.85362667e-02f, -4.27764356e-02f, 6.29758742e-03f, -1.49301533e-02f, -8.45172182e-02f,
  -7.07653388e-02f, -5.26667796e-02f, -8.43740010e-04f, 9.24886540e-02f, -1.30282104e-01f, 9.22412127e-02f, 1.88502565e-01f, 7.04647601e-02f, -8.50625187e-02f, 4.51652450e-04f,
  4.18573357e-02f, 1.23476617e-01f, -5.26641309e-02f, -9.11891684e-02f, -1.05551980e-01f, -1.93611681e-02f, -2.47897990e-02f, 1.70594975e-02f, 4.08481359e-02f, 8.42099916e-03f,
  1.16536990e-01f, -5.89362718e-02f, 1.11481361e-02f, 6.76125214e-02f, -6.59675822e-02f, 6.10566624e-02f, 6.06816858e-02f, -3.96853015e-02f, 1.16276734e-01f, 1.17985830e-01f,
  4.13244367e-02f, -1.27024814e-01f, 3.08233369e-02f, -9.44287106e-02f, 6.53024241e-02f, 4.20677066e-02f, -4.91114780e-02f, 8.68763775e-02f, 5.75677790e-02f, 2.78574806e-02f,
  -1.38924941e-01f, 2.56511499e-04f, -3.26572895e-01f, -2.19307378e-01f, 1.45819277e-01f, -3.32925677e-01f, -2.76781827e-01f, 3.25714312e-02f, -5.52781522e-02f, 1.50848955e-01f,
  1.24934122e-01f, -2.40682304e-01f, 1.27262712e-01f, -2.85355508e-01f, -5.24305999e-01f, -1.66869447e-01f, -3.90965432e-01f, -2.51385659e-01f, -4.34590094e-02f, -6.61406592e-02f,
  -8.71905833e-02f, -6.77713156e-02f, -2.30480626e-01f, 3.05129826e-01f, -1.05375081e-01f, 6.59942627e-02f, 1.85650334e-01f, 2.36221865e-01f, -4.04841341e-02f, -9.33737680e-02f,
  -1.76038727e-01f, 1.19666196e-01f, -5.78620471e-02f, -8.16112533e-02f, -3.94574925e-02f, 9.33497325e-02f, -1.75471529e-02f, -1.26160979e-01f, -1.71457930e-03f, 6.13074517e-03f,
  2.94608753e-02f, 6.60238788e-02f, -2.28745956e-02f, 3.32597457e-02f, 4.85421605e-02f, 2.80915312e-02f, -7.95801822e-03f, 5.02849056e-04f, 4.36812416e-02f, -1.06319249e-01f,
  -2.85782721e-02f, -3.73281650e-02f, 1.14540212e-01f, 3.12382146e-03f, 3.85902226e-02f, -1.87871279e-03f, -8.52391571e-02f, -2.74002012e-02f, -1.87261181e-03f, -1.02717653e-02f,
  4.59032953e-02f, 2.26367638e-02f, -5.93372434e-02f, -7.49728903e-02f, -1.75359808e-02f, 5.32231247e-03f, 4.22393158e-02f, -1.01341512e-02f, 4.96516600e-02f, -4.06004339e-02f,
  6.15737289e-02f, -6.22690022e-02f, -1.11764707e-02f, -8.15190002e-02f, -8.49943012e-02f, -5.02562672e-02f, -3.93718816e-02f, 7.10264593e-03f, -3.34272459e-02f, -6.55591786e-02f,
  3.59549895e-02f, -2.05178186e-02f, -3.64859006e-03f, 6.18026108e-02f, -1.31844878e-01f, 3.97053622e-02f, 1.47599265e-01f, -2.79251002e-02f, -7.34281614e-02f, 3.39923762e-02f,
  5.46225207e-03f, 2.12070793e-01f, -7.72954989e-03f, 5.88625707e-02f, 3.09972223e-02f, 4.00008932e-02f, -1.47793576e-01f, -7.19718412e-02f, 3.17280665e-02f, 1.13837346e-01f,
  2.49650031e-02f, 2.53099180e-03f, 1.12303816e-01f, -4.05969750e-03f, 3.74043807e-02f, -6.56166077e-02f, 1.55408457e-01f, 1.18127674e-01f, 9.60236415e-02f, 4.80157100e-02f,
  1.25539407e-01f, 1.05064400e-01f, 1.05119631e-01f, 4.27623875e-02f, 7.58176148e-02f, 8.43899101e-02f, 2.39185933e-02f, -3.34399403e-03f, 1.24037102e-01f, -3.29191275e-02f,
  1.08090959e-01f, 3.78483117e-01f, 1.87865868e-01f, -4.38700803e-02f, 9.21460316e-02f, -3.09914142e-01f, -8.43485966e-02f, 7.99383968e-02f, 1.01411551e-01f, 1.14553086e-01f,
  -3.03274095e-01f, 2.39118651e-01f, -2.13774033e-02f, -1.86918199e-01f, -3.84982765e-01f, -2.58041263e-01f, -2.58074969e-01f, -2.25676849e-01f, -8.58267117e-03f, -1.27791688e-01f,
  -6.92282021e-02f, -3.17530006e-01f, -7.29115084e-02f, 2.31567621e-02f, 1.59633413e-01f, 1.77947834e-01f, -1.85347423e-01f, 6.58091009e-02f, -4.90533151e-02f, -4.44129370e-02f,
  -4.40691151e-02f, 1.79713711e-01f, 9.46964100e-02f, 4.51425575e-02f, -5.60852624e-02f, 2.89925747e-02f, -3.17223631e-02f, -3.64488699e-02f, 5.75303584e-02f, 4.46479470e-02f,
  1.10759981e-01f, 6.43453300e-02f, -5.56867104e-03f, -1.61384214e-02f, 1.29917189e-01f, 8.13735947e-02f, 3.35323922e-02f, -1.08688939e-02f, 1.61680594e-01f, 2.44136453e-02f,
  2.95265242e-02f, 5.84235750e-02f, -2.04073294e-04f, 2.77837366e-03f, -2.73202620e-02f, 1.50609225e-01f, -5.69924973e-02f, -1.80185791e-02f, 5.31898718e-03f, 4.73068841e-02f,
  6.83235005e-02f, -9.54357013e-02f, -9.89483297e-02f, -4.61179437e-03f, -4.80331182e-02f, 6.68576211e-02f, -1.24425869e-02f, -5.36040999e-02f, -1.81875902e-03f, -3.36811244e-02f,
  -5.40755652e-02f, 3.48731428e-02f, 1.11406650e-02f, -5.30346530e-04f, -4.43010479e-02f, 2.56763119e-02f, -3.91070098e-02f, 2.16481034e-02f, -1.02309428e-01f, -5.47826104e-02f,
  -2.51028687e-02f, -1.05700262e-01f, 1.82019547e-03f, 4.50667478e-02f, -6.79459572e-02f, 9.26640909e-03f, 1.51760690e-03f, 6.36632293e-02f, -7.07468763e-02f, -1.96772829e-01f,
  -3.88749063e-01f, -3.26700836e-01f, -4.81405072e-02f, 5.14643192e-02f, -5.21224178e-02f, -6.34687990e-02f, -6.31617382e-02f, 3.82245216e-03f, -9.48161855e-02f, -6.23544566e-02f,
  9.54493806e-02f, 3.84558365e-02f, -6.72857836e-02f, -7.83179328e-02f, -1.35686457e-01f, -7.30187148e-02f, -4.99879234e-02f, -1.52743325e-01f, -8.76737535e-02f, -1.41544595e-01f,
  -3.51716168e-02f, -8.33839476e-02f, 2.03342959e-02f, 1.13247566e-01f, 1.03687346e-02f, 3.22229788e-02f, -8.62902254e-02f, 2.88266931e-02f, -9.70176384e-02f, 7.61842122e-03f,
  -2.63260871e-01f, 2.44204774e-01f, -1.84476569e-01f, -3.16692233e-01f, 6.10687248e-02f, -2.32030913e-01f, -3.45522553e-01f, -9.82282981e-02f, 1.97749231e-02f, 1.60616562e-02f,
  -5.73730506e-02f, 5.79197891e-02f, 1.83926553e-01f, -2.04769060e-01f, -1.17559936e-02f, 1.83354050e-01f, -3.03645581e-01f, -2.58820593e-01f, 9.97863114e-02f, -2.12736532e-01f,
  -6.98278397e-02f, -1.28308102e-01f, -1.09451130e-01f, 6.30255789e-02f, -2.42600203e-01f, -7.09850267e-02f, -2.61623114e-02f, 9.32876915e-02f, -1.74746215e-01f, 3.90517637e-02f,
  -4.87094223e-02f, -1.96659610e-01f, -1.83150962e-01f, -1.11316413e-01f, -1.56365022e-01f, -1.07401870e-01f, -1.18552156e-01f, 2.65841447e-02f, -4.69867960e-02f, -9.30714905e-02f,
  1.10864900e-01f, 1.52152568e-01f, 4.83128388e-04f, 1.24769457e-01f, -1.16332807e-02f, -2.12825201e-02f, 7.07208067e-02f, -7.69042075e-02f, -4.82028052e-02f, 6.36379197e-02f,
  4.20424230e-02f, -1.30559187e-02f, -9.41384658e-02f, -1.20221339e-01f, -8.55048373e-03f, -5.50175793e-02f, -1.87193565e-02f, 7.17510935e-03f, -9.39251184e-02f, 1.55968601e-02f,
  -5.00918515e-02f, -1.24015119e-02f, -3.36503214e-03f, 2.76400093e-02f, 2.51659993e-02f, 7.89839998e-02f, 8.56934115e-03f, 2.29191501e-02f, -2.55062841e-02f, 5.32642081e-02f,
  8.64911526e-02f, -1.65721364e-02f, -5.22609502e-02f, -8.98386911e-02f, 1.80649310e-02f, -4.17412855e-02f, -3.82671431e-02f, 1.21502541e-02f, 5.60161918e-02f, -6.65347725e-02f,
  3.09357103e-02f, 1.25281401e-02f, -1.40935145e-02f, 3.79907712e-02f, -9.55110267e-02f, 2.06390824e-02f, 4.25520018e-02f, -1.31719941e-02f, -5.68221100e-02f, 5.04831746e-02f,
  -1.33556947e-01f, -3.05467367e-01f, -2.60450207e-02f, -1.01067901e-01f, -3.54754850e-02f, -4.44153436e-02f, 3.86017561e-02f, -5.27566411e-02f, -9.43612307e-02f, -1.28263742e-01f,
  -3.69132534e-02f, -8.96434337e-02f, -1.60578992e-02f, -9.87433828e-03f, 9.76120159e-02f, -7.03545883e-02f, -2.77591795e-02f, -3.62834260e-02f, -1.47132710e-01f, 3.44198607e-02f,
  -2.16216240e-02f, -7.50471428e-02f, 2.30161287e-02f, -8.82808492e-02f, -8.42227116e-02f, -1.83310900e-02f, -1.20698512e-01f, 5.46196401e-02f, -5.93467280e-02f, 8.22342709e-02f,
  1.86946034e-01f, -1.07779145e-01f, -4.23682146e-02f, 2.10057907e-02f, -2.12719887e-01f, 1.27911523e-01f, 4.45679873e-01f, -2.69722790e-01f, -2.23476425e-01f, 1.15073569e-01f,
  -4.16735075e-02f, 4.52634729e-02f, 2.89436072e-01f, 2.14020908e-01f, 1.46316767e-01f, 2.61074334e-01f, 1.17967345e-01f, 2.08031818e-01f, -1.64656878e-01f, 2.33379025e-02f,
  -6.05028234e-02f, 1.26030594e-01f, 2.32340276e-01f, -2.11748719e-01f, 1.13389708e-01f, -1.59339383e-01f, -1.47891939e-02f, -1.10948719e-02f, -5.98615855e-02f, 2.52192710e-02f,
  2.84216851e-02f, -1.15353875e-01f, 4.33369428e-02f, -2.94365026e-02f, 3.05547677e-02f, 1.08029917e-01f, 1.12700947e-01f, 1.13711625e-01f, -4.22862805e-02f, -2.57814638e-02f,
  2.31972579e-02f, 9.04507190e-02f, -1.47190064e-01f, 2.32601934e-03f, -5.63818999e-02f, -1.29535943e-01f, -1.15301512e-01f, -1.08166754e-01f, -2.97793448e-02f, 4.12898846e-02f,
  1.10791259e-01f, -4.30080518e-02f, -2.41194014e-02f, 2.01795995e-02f, -7.20984414e-02f, -1.05842285e-01f, 1.95462648e-02f, 9.37631447e-03f, -1.41629782e-02f, -5.02521172e-02f,
  -8.34612995e-02f, 6.05502799e-02f, -2.50919862e-03f, 2.71180309e-02f, -2.61403546e-02f, 4.92248102e-04f, -1.48855231e-03f, -3.15508060e-02f, -2.50534844e-02f, 1.15222916e-01f,
  -2.03965511e-03f, -8.56918376e-03f, -4.41083051e-02f, 6.98716864e-02f, 2.46054828e-02f, 1.19036958e-02f, 8.93623307e-02f, 2.46593375e-02f, 3.22595648e-02f, -2.92127356e-02f,
  3.77439409e-02f, -2.56497436e-03f, 3.25106345e-02f, -1.20438496e-02f, 2.59289853e-02f, 4.30492172e-03f, 3.03558111e-02f, 1.05224792e-02f, -1.04915477e-01f, 4.38839160e-02f,
  2.99859955e-03f, -1.69137448e-01f, -2.89962161e-02f, -2.15029269e-02f, 2.65529398e-02f, 1.40390650e-03f, 2.95907706e-02f, -1.05703317e-01f, -1.25149652e-01f, -8.67485907e-03f,
  -4.12068367e-02f, 7.88704902e-02f, -9.67435539e-02f, -6.58893585e-02f, -8.64312723e-02f, -1.32578477e-01f, 1.27995789e-01f, -1.05363168e-01f, -4.46595773e-02f, -1.34388581e-01f,
  7.50325993e-02f, -1.99309066e-02f, 1.52077720e-01f, 4.95730937e-02f, 1.13576790e-02f, 6.83607683e-02f, -1.35760888e-01f, -8.91960338e-02f, -3.36499996e-02f, -4.42520976e-02f,
  9.79993418e-02f, 2.78445393e-01f, 7.92533383e-02f, 1.23856358e-01f, -8.32853839e-02f, -4.80145067e-01f, -1.73739344e-01f, 7.59723037e-02f, 6.39807880e-02f, 9.71115679e-02f,
  -1.13978215e-01f, 2.88356751e-01f, 9.21628028e-02f, -1.00693069e-01f, -5.06941378e-01f, -1.37891099e-01f, -3.09373528e-01f, -2.65635047e-02f, 9.27020460e-02f, 1.88895445e-02f,
  -1.11013622e-04f, -2.25169122e-01f, -8.01519379e-02f, 1.90319866e-01f, 4.63650674e-02f, 2.85460174e-01f, -3.48540843e-02f, 2.22795874e-01f, -9.52486135e-03f, -1.29213035e-01f,
  -9.83504280e-02f, 2.16181114e-01f, 1.12112150e-01f, -1.82210878e-02f, -7.54992962e-02f, 1.51763484e-01f, 1.31627202e-01f, -1.71769261e-02f, 7.30063468e-02f, -4.78744023e-02f,
  7.30130672e-02f, 1.26920845e-02f, 1.28296360e-01f, -4.83666770e-02f, 8.64139199e-03f, 9.88432840e-02f, -8.35187435e-02f, -1.53146982e-01f, 3.25570107e-02f, 7.50527158e-03f,
  1.48334242e-02f, -6.97839856e-02f, -9.17253718e-02f, 2.53899731e-02f, -1.57691698e-04f, 6.57341536e-03f, -8.21707100e-02f, -9.02009830e-02f, 9.58025269e-03f, 5.28659150e-02f,
  4.02314700e-02f, 3.35658789e-02f, 1.10273428e-01f, 2.84617543e-02f, 3.65547501e-02f, 1.77560747e-01f, 1.31299332e-01f, 5.81222363e-02f, 6.60405457e-02f, 1.52497673e-02f,
  -1.32622784e-02f, 1.41465142e-01f, 2.67103855e-02f, 2.47284621e-02f, 1.10254474e-01f, 5.69010191e-02f, -6.58784062e-02f, -6.72384650e-02f, -4.39401297e-03f, 9.16358382e-02f,
  5.96596226e-02f, -1.84001178e-02f, 9.69949514e-02f, -5.09150773e-02f, -1.01364315e-01f, -1.13954665e-02f, 5.34395687e-02f, 7.37113471e-04f, -4.23779115e-02f, -1.72614008e-02f,
  -1.80769861e-01f, 7.68758506e-02f, 1.08689040e-01f, 5.75785190e-02f, 9.63614956e-02f, 6.50851568e-03f, 3.87426205e-02f, -5.48874065e-02f, 2.34745760e-02f, -2.08560713e-02f,
  -6.30179793e-02f, 1.63596526e-01f, -2.43928060e-02f, -8.44046846e-02f, -9.15709659e-02f, -4.89402860e-02f, -4.11311574e-02f, -2.04218477e-02f, -1.17381245e-01f, 1.93059463e-02f,
  2.16793492e-02f, 9.94310994e-03f, 1.15587667e-01f, 6.50959387e-02f, 5.62148355e-02f, 8.79160478e-04f, 3.82854715e-02f, -1.05728634e-01f, -9.23822075e-03f, 4.61747833e-02f,
  -2.65605569e-01f, 3.49413216e-01f, 3.04735094e-01f, 1.00636147e-01f, -2.82766998e-01f, 1.98206812e-01f, 6.04537055e-02f, -1.18650578e-01f, 2.77388506e-02f, -3.84382643e-02f,
  -2.65969992e-01f, 1.75186619e-01f, -1.12893060e-01f, 1.46507978e-01f, 2.35656679e-01f, 1.31823406e-01f, 7.38807544e-02f, 1.24818563e-01f, 7.47278184e-02f, 5.05059063e-02f,
  6.28863052e-02f, -4.35874350e-02f, 1.54660165e-01f, 7.00545684e-02f, 7.40379542e-02f, 2.79017746e-01f, -4.95758653e-02f, 2.44357347e-01f, 2.42736757e-01f, 1.59414887e-01f,
  -8.00459310e-02f, -3.75751704e-02f, -9.23671052e-02f, -1.20337509e-01f, -1.04005896e-01f, -1.91694014e-02f, 9.26249027e-02f, 3.30619365e-02f, -6.20877370e-02f, -5.57158627e-02f,
  -1.02983803e-01f, -6.06238795e-03f, 6.85477778e-02f, 4.85623218e-02f, -1.01839446e-01f, 7.36018317e-03f, -3.83005776e-02f, -1.37649134e-01f, -5.51662035e-02f, -1.32217973e-01f,
  3.08209285e-02f, -1.51360437e-01f, -4.05333787e-02f, 6.37932494e-02f, 1.70717891e-02f, -6.29532477e-03f, 1.52272955e-01f, -4.56772447e-02f, 6.35307580e-02f, 5.92154749e-02f,
  -8.90480876e-02f, 4.08486985e-02f, -5.08815050e-02f, 8.30536056e-03f, -2.69798413e-02f, 5.85751273e-02f, -2.98925536e-03f, -8.54400992e-02f, 4.11180742e-02f, -2.16627121e-02f,
  -1.51234880e-01f, 2.92409286e-02f, -5.39654456e-02f, -3.22402455e-02f, 1.07861631e-01f, -1.62796881e-02f, -4.78064083e-02f, -2.36672610e-02f, 1.03102155e-01f, 8.36659074e-02f,
  1.97785869e-02f, 1.90443941e-03f, 6.65642098e-02f, -8.91498998e-02f, 3.83290313e-02f, -2.72325538e-02f, 6.54127076e-02f, -4.28895503e-02f, 1.34504214e-02f, -6.61288388e-03f,
  2.06463501e-01f, 3.54984850e-01f, -1.17262136e-02f, -1.67165965e-01f, 2.65296642e-02f, 3.71872298e-02f, 6.40893131e-02f, 1.15674630e-01f, 1.06854737e-01f, -5.03302515e-02f,
  -2.42766649e-01f, 1.82158388e-02f, 8.68004654e-03f, 1.26205513e-03f, 3.06377094e-02f, 1.32282395e-02f, -6.38470501e-02f, -4.49139662e-02f, -6.36839569e-02f, 2.80108079e-02f,
  -9.36757922e-02f, -9.51206982e-02f, -4.29249508e-03f, -3.52565199e-03f, -8.70530307e-02f, -2.14996301e-02f, -4.91397306e-02f, -8.39097127e-02f, -9.40301176e-03f, 9.76575017e-02f,
  -1.24845058e-01f, -9.78226587e-02f, 1.44775227e-01f, 3.59730899e-01f, 7.29074236e-03f, -3.22516859e-01f, -1.30689427e-01f, -1.06919318e-01f, 6.39978051e-02f, -3.76859218e-01f,
  -1.28342574e-02f, -8.56229663e-02f, -1.84601918e-01f, 1.68262243e-01f, 1.58905685e-01f, -3.71288247e-02f, 3.13241892e-02f, -6.49891570e-02f, 6.23110160e-02f, -1.51031569e-01f,
  3.34397703e-02f, 2.01830752e-02f, 1.73063084e-01f, 3.13898772e-02f, -9.67249572e-02f, 1.86354816e-01f, 1.91826627e-01f, 1.69637069e-01f, 1.55782863e-01f, 2.72516876e-01f,
  -8.56507346e-02f, 1.95198894e-01f, 4.92696278e-02f, 5.17799966e-02f, -6.42767847e-02f, -1.45968035e-01f, 2.70291511e-03f, 5.50577790e-02f, 1.20486200e-01f, 2.39849836e-02f,
  -4.77433093e-02f, 6.29867688e-02f, 6.22080155e-02f, 2.52001882e-02f, -1.68291864e-03f, 7.26691484e-02f, 1.01072356e-01f, -1.03331655e-01f, 7.25921988e-02f, -1.00887187e-01f,
  -7.86113441e-02f, -4.91305767e-03f, 7.40572363e-02f, 1.53009325e-01f, 2.37589389e-01f, 4.22368422e-02f, 2.59487797e-02f, 1.52936447e-02f, 3.06885019e-02f, 2.88785510e-02f,
  2.99119782e-02f, -5.47148883e-02f, -1.44313514e-01f, -8.06387812e-02f, -1.64305102e-02f, 1.17188916e-01f, -1.05338991e-02f, -3.43941748e-02f, 9.98858735e-02f, -1.94217358e-02f,
  5.41415699e-02f, 3.81649681e-03f, -5.63232452e-02f, -9.65928882e-02f, 2.59690481e-04f, -1.63448736e-01f, -6.83697909e-02f, 4.01131399e-02f, -6.74679875e-02f, -9.89187136e-02f,
  5.92369847e-02f, 3.21261361e-02f, 3.24534364e-02f, -2.16938071e-02f, -1.46096185e-01f, 1.03517435e-04f, 2.97040027e-02f, -6.65940717e-03f, -5.14043607e-02f, 9.65369716e-02f,
  1.61275089e-01f, 2.70974249e-01f, 1.13100588e-01f, 9.60877091e-02f, 9.87697989e-02f, -5.86705208e-02f, -2.82843038e-02f, 4.01220471e-02f, 2.07453966e-01f, -4.26360592e-02f,
  -6.50639609e-02f, 5.75343780e-02f, -5.46549708e-02f, 1.01082074e-02f, 7.72995725e-02f, -7.72025585e-02f, 8.04583207e-02f, 1.26685739e-01f, 1.64777219e-01f, 5.41325733e-02f,
  3.60781588e-02f, -9.10203457e-02f, 9.11560580e-02f, -3.77901159e-02f, 9.51717868e-02f, 1.89204402e-02f, -1.52413025e-01f, -4.46512178e-02f, 1.74303934e-01f, 8.01953524e-02f,
  1.19024493e-01f, 1.89068571e-01f, -1.30635589e-01f, -3.19617391e-02f, -1.84760869e-01f, 3.11926514e-01f, 1.58686966e-01f, -2.35758210e-03f, -1.19728737e-01f, 3.08744162e-01f,
  1.37404501e-01f, -3.64265889e-02f, 1.00948155e-01f, 3.59560221e-01f, 3.63506563e-02f, 3.18397999e-01f, 2.39053532e-01f, 1.46549061e-01f, -1.85228232e-02f, 7.79545456e-02f,
  -3.02596148e-02f, 4.15285349e-01f, 6.02213759e-03f, 1.01895973e-01f, 1.83613032e-01f, -1.06641822e-01f, -9.51284990e-02f, -1.54622495e-01f, 3.39800119e-02f, -7.77311325e-02f,
  9.03016329e-02f, 3.58603485e-02f, 9.54982452e-03f, 5.59835434e-02f, 8.96834806e-02f, 7.21911490e-02f, 2.85330247e-02f, -3.13951597e-02f, -9.42526236e-02f, -5.48828393e-02f,
  6.48122877e-02f, 7.27204382e-02f, 4.20046523e-02f, -7.65234903e-02f, -3.74809615e-02f, -3.96962278e-02f, 5.68668032e-03f, -1.27395496e-01f, -4.57995087e-02f, 5.32115735e-02f,
  -3.51831783e-03f, 5.52717894e-02f, -1.02174982e-01f, -4.49019000e-02f, -7.80663639e-02f, -1.58010982e-02f, 4.27432954e-02f, -3.73049378e-02f, 8.14280286e-02f, -2.45857649e-02f,
  -5.46050519e-02f, 9.19976681e-02f, 1.44009441e-01f, 9.21766311e-02f, -2.68558995e-03f, -7.98596740e-02f, -4.58063334e-02f, -2.57381480e-02f, -7.70326257e-02f, 1.14891946e-01f,
  -6.83336053e-03f, 2.99960785e-02f, 2.34728539e-03f, 3.17915976e-02f, 8.78306106e-02f, 7.27426410e-02f, -1.73328514e-03f, 2.11390071e-02f, -2.51450837e-02f, 1.64910164e-02f,
  8.74311011e-03f, 1.58948936e-02f, -2.24156100e-02f, -5.70753887e-02f, 1.13254823e-01f, -6.17195033e-02f, 6.95465952e-02f, 2.19088849e-02f, -4.24149330e-04f, -7.27941543e-02f,
  6.08461313e-02f, -6.78228065e-02f, 1.09089604e-02f, -1.55602087e-04f, -6.00159168e-03f, 7.98590705e-02f, 1.33974478e-01f, 6.12125769e-02f, -3.16540115e-02f, 8.93588811e-02f,
  3.84710059e-02f, -4.84539308e-02f, -1.11677656e-02f, -6.20589666e-02f, -1.66792899e-01f, 5.61398081e-02f, 6.11167401e-02f, -1.16200775e-01f, -1.52248308e-01f, -3.60720344e-02f,
  -5.46327159e-02f, -4.35733423e-03f, -3.60724069e-02f, -2.86015552e-02f, -6.78127483e-02f, -2.03382596e-03f, -2.62375381e-02f, 3.64345908e-02f, -3.20103429e-02f, -3.78265642e-02f,
  4.18967634e-01f, -3.26899767e-01f, -2.50550598e-01f, 3.26875836e-01f, 3.18833679e-01f, 1.56193703e-01f, 9.45515037e-02f, 2.26802409e-01f, 1.22330382e-01f, -1.38864741e-02f,
  3.68102610e-01f, -2.38974258e-01f, -1.61595106e-01f, 3.56470823e-01f, 3.27114314e-01f, -6.08403385e-02f, 3.19279134e-01f, 1.35099217e-01f, 6.15456663e-02f, 1.67307571e-01f,
  1.78244263e-01f, 4.23750579e-01f, -2.90223453e-02f, 9.09533203e-02f, 2.74130255e-01f, -1.07778668e-01f, 1.24136485e-01f, -2.43071869e-01f, 1.98061094e-01f, -9.52916965e-02f,
  3.83601412e-02f, 1.11674659e-01f, 2.26962008e-02f, -1.07723854e-01f, 1.47619978e-01f, 5.12149408e-02f, -2.53002308e-02f, 6.91138506e-02f, -3.55290957e-02f, 1.34246591e-02f,
  -4.87625375e-02f, 9.61361900e-02f, 9.94025171e-02f, -3.06715593e-02f, 5.55900782e-02f, 1.81855053e-01f, 9.25729889e-03f, 3.09706237e-02f, -5.56986360e-03f, 8.28682482e-02f,
  4.34888452e-02f, 4.95120883e-02f, 5.95307238e-02f, 2.11264081e-02f, 1.10711474e-02f, 7.65649453e-02f, -1.09308816e-01f, 7.41267717e-03f, 8.10471773e-02f, 1.53713003e-01f,
  1.62345603e-01f, -2.07731262e-01f, 6.47535846e-02f, -7.71480352e-02f, -2.85038166e-02f, 5.51998578e-02f, 2.16681119e-02f, -1.23499602e-03f, -1.43171579e-01f, 8.44754800e-02f,
  2.79658083e-02f, 1.09693095e-01f, 1.01554722e-01f, -2.51231268e-02f, 3.20630297e-02f, -1.41775936e-01f, -1.74976476e-02f, 1.33609883e-02f, 7.03710243e-02f, 7.89678767e-02f,
  -1.11115083e-01f, -8.76251832e-02f, -4.59937230e-02f, -5.61234243e-02f, -2.95454822e-02f, -8.95229429e-02f, -1.08360278e-03f, 1.64227262e-02f, 4.31082472e-02f, -5.69105670e-02f,
  -8.75138640e-02f, -8.55589956e-02f, -7.26087671e-03f, -3.97846382e-03f, -1.51957776e-02f, 1.53331473e-01f, 1.23894490e-01f, 2.00059354e-01f, -1.03434846e-01f, 3.56943607e-02f,
  1.54467635e-02f, -5.30657172e-02f, -4.76956442e-02f, 8.06468874e-02f, -5.89202680e-02f, 1.32330447e-01f, -7.78550133e-02f, 2.33279541e-02f, 8.03961605e-02f, 4.37918156e-02f,
  -9.92496870e-03f, 1.28647625e-01f, 7.59086339e-03f, 1.23061486e-01f, 1.39263244e-02f, -4.07479368e-02f, -3.64922769e-02f, -5.68490364e-02f, -3.12480293e-02f, -2.07413337e-03f,
  -4.12699997e-01f, -4.68052849e-02f, 6.56607747e-02f, -2.59475820e-02f, -5.53862572e-01f, 1.08618438e-01f, 1.31327286e-01f, -7.02225938e-02f, 1.55579865e-01f, 2.23274633e-01f,
  -1.72653049e-01f, -7.20202401e-02f, 2.30280027e-01f, 6.07466809e-02f, 2.23713711e-01f, 4.58558977e-01f, 1.85152382e-01f, 1.25635788e-01f, -7.59339929e-02f, -1.63981289e-01f,
  -1.14843950e-01f, -7.04660267e-02f, 8.70424509e-02f, -1.69157147e-01f, -3.31366062e-01f, -1.45873770e-01f, -1.43343791e-01f, -1.66178524e-01f, -8.34642500e-02f, -1.04863025e-01f,
  -1.38363212e-01f, -1.58219069e-01f, -1.88840572e-02f, 1.12215295e-01f, -8.08466077e-02f, -3.35994065e-02f, 6.70853853e-02f, -1.28365699e-02f, -5.19488789e-02f, -6.97035417e-02f,
  3.51098105e-02f, -8.99500102e-02f, -1.25439435e-01f, 6.08581603e-02f, -4.75928597e-02f, -3.09131183e-02f, -1.71694651e-01f, -8.81512389e-02f, -1.15915900e-02f, -2.03167293e-02f,
  4.62061800e-02f, -4.01220378e-03f, 6.55110506e-03f, 1.41945779e-01f, -1.71274990e-01f, -8.02689046e-02f, 2.11053103e-01f, -1.41600102e-01f, -7.44013637e-02f, -1.29907280e-01f,
  7.60798976e-02f, 1.48150641e-02f, -5.36195040e-02f, -3.82677279e-02f, -5.20135649e-02f, 2.67919507e-02f, 1.18639216e-01f, 3.68205942e-02f, 2.08875141e-03f, -4.56837937e-02f,
  -1.77536532e-01f, -8.89284983e-02f, -1.90955736e-02f, 6.69764429e-02f, 1.02237873e-01f, 1.44991785e-01f, -1.97711121e-02f, -1.53364107e-01f, 1.33430824e-01f, 6.82484955e-02f,
  2.22358499e-02f, 3.03296875e-02f, -2.31014505e-01f, 3.68092917e-02f, 2.57575382e-02f, -7.38066584e-02f, -2.21741456e-03f, 4.08626050e-02f, 1.96214411e-02f, -1.26884907e-01f,
  -9.99393016e-02f, -1.43817086e-02f, -5.53178005e-02f, -1.28771946e-01f, 1.06109930e-02f, 5.02986275e-02f, 1.34581894e-01f, -5.45469485e-02f, 4.20139842e-02f, -2.17386754e-03f,
  1.32469356e-01f, -2.79215537e-02f, 4.55798991e-02f, 2.16731355e-02f, 1.24241352e-01f, -4.76070754e-02f, 1.17944935e-02f, 3.27908359e-02f, -1.80631746e-02f, -7.92425722e-02f,
  2.17096116e-02f, -4.53641899e-02f, 9.44884792e-02f, -9.65269096e-03f, 9.49621294e-03f, 1.96071453e-02f, -9.47002694e-02f, 7.35832029e-04f, -8.72839466e-02f, -1.58113223e-02f,
  -2.55678117e-01f, -2.30222031e-01f, 1.67403534e-01f, -4.02191401e-01f, -4.27046791e-02f, 1.55134976e-01f, -1.23420753e-01f, -1.28586426e-01f, -2.91457355e-01f, -1.96939826e-01f,
  -2.08530426e-01f, -5.23574613e-02f, 1.66693807e-01f, -2.74130225e-01f, 5.08719862e-01f, 1.43441826e-01f, -1.36774436e-01f, -6.09125197e-02f, -1.13478400e-01f, -2.60118365e-01f,
  -3.19556817e-02f, -2.58776397e-01f, 1.75602302e-01f, -1.61684677e-01f, -2.24398628e-01f, -1.00566313e-01f, 1.74028143e-01f, 2.05394939e-01f, -1.25491440e-01f, 6.29816428e-02f,
  -1.70267001e-01f, -2.79968500e-01f, -1.80319369e-01f, -4.99666259e-02f, 6.34676404e-03f, 3.56784910e-02f, 1.07052729e-01f, -3.56214843e-03f, -8.84701684e-02f, 2.30711475e-02f,
  1.74573570e-01f, -2.85545643e-02f, -9.10246000e-02f, 1.16098359e-01f, -6.28869683e-02f, -8.08146447e-02f, -4.44583222e-02f, -1.09210521e-01f, -1.15483336e-01f, -8.88397265e-03f,
  -3.28182988e-03f, 7.29857013e-02f, 3.67265614e-03f, 6.64664656e-02f, 2.29856302e-03f, -6.08037114e-02f, -3.30132693e-02f, 1.88146651e-01f, 1.88598279e-02f, -1.71154588e-02f,
  8.47643465e-02f, 5.35466745e-02f, 5.00768535e-02f, 1.06930593e-02f, -2.63867885e-01f, -7.78357759e-02f, 4.04119231e-02f, -9.20470878e-02f, 2.67387014e-02f, 5.84669299e-02f,
  -3.47471200e-02f, 1.30537912e-01f, -4.09752093e-02f, -4.00685286e-03f, 5.02826972e-03f, 1.45212281e-03f, -4.82292585e-02f, -1.06466055e-01f, -8.36049840e-02f, 8.36767405e-02f,
  -4.71847169e-02f, 3.67106433e-04f, -3.59415375e-02f, 3.79391667e-03f, -2.98068747e-02f, 1.30318791e-01f, -4.87225428e-02f, -4.71713506e-02f, 4.61631129e-03f, 1.70136824e-01f,
  -1.26427054e-01f, -1.66960254e-01f, -1.83802068e-01f, -1.97651565e-01f, -2.50979923e-02f, 1.30990580e-01f, 3.80694009e-02f, -1.83160856e-01f, 4.09660600e-02f, 1.07450015e-03f,
  8.82111713e-02f, 6.69850633e-02f, 7.04227313e-02f, 2.02018656e-02f, 2.96284282e-03f, -2.69346815e-02f, -4.34045419e-02f, -5.89312240e-02f, 2.99158692e-02f, -1.30199745e-01f,
  -1.22637331e-01f, -8.26068297e-02f, 9.97364819e-02f, 2.92884074e-02f, 1.87928192e-02f, 1.07344612e-02f, -6.31114691e-02f, -3.84108014e-02f, 1.60950616e-01f, 5.92577942e-02f,
  -4.31846172e-01f, 4.77921277e-01f, 9.29451063e-02f, -1.34869423e-02f, 1.04293630e-01f, -5.62924035e-02f, 1.48606515e-02f, -4.30984572e-02f, 1.29894286e-01f, 9.24606845e-02f,
  -4.55837063e-02f, 1.28025964e-01f, 2.69284137e-02f, 1.53072149e-01f, -4.44071442e-01f, 7.17955902e-02f, -2.37916107e-03f, -2.50831507e-02f, 9.42914337e-02f, 4.47509997e-02f,
  -8.99964292e-03f, -6.98317587e-02f, 5.03191501e-02f, 1.91425443e-01f, 2.06650272e-02f, 3.35830636e-02f, -2.78494239e-01f, 5.82060171e-03f, 2.64793318e-02f, 7.50275701e-03f,
  -1.76609367e-01f, -8.09178054e-02f, -1.76162809e-01f, -1.61857113e-01f, -2.42295396e-02f, -4.09140587e-02f, -8.55925605e-02f, -1.32906372e-02f, -6.61150888e-02f, -2.06427667e-02f,
  4.37948890e-02f, -2.52239499e-02f, -4.30005305e-02f, -9.17853266e-02f, 1.40369199e-02f, -3.62972659e-03f, 2.36761533e-02f, -4.33358923e-02f, 4.49471064e-02f, 9.53740403e-02f,
  1.16693035e-01f, -3.52279916e-02f, 6.13943227e-02f, -8.32573045e-03f, -3.35739627e-02f, 6.44817427e-02f, 3.53016593e-02f, -5.51866405e-02f, -9.04712975e-02f, 4.78250794e-02f,
  -1.38072483e-02f, 3.20339389e-02f, 3.00105056e-03f, -1.00608073e-01f, -7.46986270e-03f, 2.66185366e-02f, 7.19695613e-02f, -8.08247700e-02f, -3.51445898e-02f, -3.41403335e-02f,
  -5.88307492e-02f, 5.27836792e-02f, 8.64923894e-02f, -2.00159606e-02f, 4.46407124e-02f, 7.52448812e-02f, -1.10422261e-02f, -8.32521692e-02f, 1.85211673e-02f, -2.29289830e-02f,
  -5.71683459e-02f, 1.14202425e-01f, 3.22301723e-02f, -3.50786000e-02f, -2.87601873e-02f, -5.34258410e-02f, -4.65784520e-02f, 5.87070435e-02f, -1.03635423e-01f, -1.38848290e-01f,
  -3.91390711e-01f, -3.26955795e-01f, -2.02489063e-01f, -8.18548575e-02f, -1.29341315e-02f, -6.58276677e-02f, 3.54431905e-02f, 7.65021145e-03f, -1.14833593e-01f, -9.35201496e-02f,
  1.37659125e-02f, 2.76434477e-02f, -3.55783887e-02f, -3.67347188e-02f, -9.93899107e-02f, -1.15433462e-01f, -5.75531982e-02f, -9.35245156e-02f, -1.91465423e-01f, -7.95511454e-02f,
  9.34574660e-03f, -7.11010769e-02f, 4.86104600e-02f, 2.69462187e-02f, -2.80658938e-02f, -1.74416397e-02f, -1.02500468e-01f, 3.58416536e-03f, -1.63954765e-01f, 8.97714403e-03f,
  -1.53813183e-01f, 1.15403056e-01f, -8.37335959e-02f, -1.53308824e-01f, -2.63649791e-01f, -1.12894811e-01f, -2.05800399e-01f, 3.14356871e-02f, 1.29103556e-01f, 2.77239323e-01f,
  -1.23016588e-01f, 2.65874743e-01f, 1.80405170e-01f, -1.75298706e-01f, 2.01510951e-01f, 2.48389423e-01f, -1.52831733e-01f, -5.12534101e-03f, 5.45988306e-02f, 5.23547307e-02f,
  6.51759282e-02f, -1.83113068e-01f, -4.74348739e-02f, 8.11450332e-02f, -2.03501925e-01f, 3.42152547e-03f, 1.39585380e-02f, -2.03092039e-01f, -1.58437282e-01f, -2.02919811e-01f,
  -9.28652063e-02f, -5.89811504e-02f, -5.98618537e-02f, -1.40725881e-01f, 9.38672759e-03f, -2.07007434e-02f, -5.23586348e-02f, 1.79008246e-04f, -8.17880407e-02f, -2.62378138e-02f,
  6.17912486e-02f, 4.01265696e-02f, 9.96844545e-02f, 1.49287522e-01f, -2.79200435e-01f, -8.62419307e-02f, -7.91597590e-02f, -2.17624202e-01f, -9.29570720e-02f, -4.36616279e-02f,
  -1.35825038e-01f, -4.59843501e-02f, -2.19563693e-01f, -1.06656961e-01f, -1.16586246e-01f, -2.02327326e-01f, 8.00696090e-02f, -7.92254210e-02f, -2.16305424e-02f, -1.15970830e-02f,
  -7.70687126e-03f, 5.58531992e-02f, 5.64581156e-03f, 1.42199427e-01f, -1.06333904e-02f, -5.01739159e-02f, -2.53489316e-02f, -4.40545660e-03f, -8.68714824e-02f, -9.57035571e-02f,
  -6.08419627e-02f, -1.13435246e-01f, -1.05130240e-01f, -3.00535802e-02f, 2.54470408e-02f, 1.99720919e-01f, -3.94830368e-02f, 7.66345114e-02f, -3.82011232e-04f, 1.67556494e-01f,
  2.21424192e-01f, -1.68022320e-01f, -3.30820773e-03f, -1.17091835e-01f, -4.04754989e-02f, 9.50491875e-02f, -2.02446729e-01f, -1.03620207e-02f, 9.84700769e-02f, -5.05309775e-02f,
  -6.84074014e-02f, 4.27561328e-02f, -4.35582697e-02f, -1.54463172e-01f, 5.24432622e-02f, 4.89315651e-02f, 4.42167819e-02f, 2.33205613e-02f, -1.07707992e-01f, 1.84691586e-02f,
  -2.35301442e-02f, -1.78523734e-03f, -3.46422084e-02f, 3.83273549e-02f, -2.47744247e-02f, 4.17528376e-02f, -3.63691896e-02f, 9.86692496e-03f, -1.19258672e-01f, -1.15842915e-04f,
  -6.76418990e-02f, -3.45137529e-02f, 4.25442234e-02f, -3.02420035e-02f, -1.15114830e-01f, -1.28582612e-01f, 1.71443790e-01f, -7.94190615e-02f, -1.66467860e-01f, 5.19707911e-02f,
  2.88617402e-01f, -2.70167738e-01f, 3.26604769e-02f, 4.67714816e-01f, 1.67438984e-01f, -8.80847648e-02f, 2.10048124e-01f, 3.35784629e-02f, 3.52085739e-01f, -2.24214986e-01f,
  2.50931919e-01f, -2.75691301e-01f, 8.99846127e-05f, 1.07746966e-01f, 5.83505165e-03f, -7.37122074e-02f, 1.08067140e-01f, -6.33130595e-03f, 1.26483887e-01f, 1.20175727e-01f,
  7.04812557e-02f, -1.66569110e-02f, 4.53319289e-02f, -2.22295061e-01f, 1.32469192e-01f, -7.07739964e-02f, -5.40317819e-02f, -3.63213606e-02f, -1.35006294e-01f, -1.24836266e-01f,
  1.54806703e-01f, 1.84096470e-01f, 6.80937320e-02f, -3.51617672e-02f, 6.43156692e-02f, -9.21652019e-02f, -1.28892362e-01f, -8.08777139e-02f, 2.01883405e-01f, 8.50433037e-02f,
  -4.12619077e-02f, -2.45911703e-02f, -6.29450679e-02f, -4.09120768e-02f, 1.68639600e-01f, 1.31320938e-01f, 7.23601803e-02f, 9.94878337e-02f, 2.03985372e-03f, -2.36877520e-02f,
  6.61272556e-02f, 9.29220170e-02f, 6.16724789e-02f, -9.91682261e-02f, 9.83530004e-03f, 9.88828018e-02f, -1.33856416e-01f, -6.67110607e-02f, 1.75662879e-02f, -2.35841200e-02f,
  -1.70246929e-01f, 1.77041981e-02f, 8.65305588e-02f, 1.98109478e-01f, 9.35500935e-02f, 8.00711513e-02f, 1.77536998e-02f, -6.86997995e-02f, -1.65884737e-02f, 3.93685512e-03f,
  4.30569462e-02f, 7.96567369e-03f, 5.07147275e-02f, -3.21616009e-02f, 1.20742461e-02f, -2.56805420e-02f, -6.59537641e-03f, -9.50670391e-02f, 1.19304433e-01f, 6.85306937e-02f,
  -2.92918319e-03f, -3.83339473e-03f, -1.00018308e-02f, 5.27994297e-02f, 6.20711222e-02f, 1.11750245e-01f, -7.45922923e-02f, 5.37202060e-02f, 2.20439687e-01f, -9.17436481e-02f,
  -1.30118607e-02f, -3.43137473e-01f, -2.04575304e-02f, 3.42509449e-02f, -7.31824636e-02f, -8.14199001e-02f, -2.16214149e-03f, -9.95054021e-02f, -3.75165418e-02f, -2.48273890e-02f,
  -1.20686609e-02f, 3.54914181e-02f, -4.30825837e-02f, -4.13788259e-02f, 5.63994534e-02f, -5.73718874e-03f, -2.59693451e-02f, -3.04308534e-02f, -2.71196980e-02f, -7.05009401e-02f,
  -3.42276208e-02f, 8.24127793e-02f, -4.32497263e-02f, 1.23824708e-01f, -1.00785986e-01f, -1.20719306e-01f, -2.65124440e-02f, 7.24088103e-02f, -7.39821568e-02f, -4.06228006e-02f,
  1.23366080e-01f, -2.52174526e-01f, 2.21841797e-01f, 2.11892605e-01f, -9.63568687e-02f, 1.77992396e-02f, 3.66812170e-01f, -2.29514599e-01f, 1.07867941e-01f, -1.84259936e-01f,
  -2.49043137e-01f, 3.05195123e-01f, 1.61652416e-02f, -7.18284771e-02f, 3.48745644e-01f, 8.93017203e-02f, 3.69051807e-02f, 5.66790476e-02f, -4.83761691e-02f, -2.20558438e-02f,
  5.22780530e-02f, -3.22186723e-02f, 7.10144937e-02f, -1.59970015e-01f, -6.03520796e-02f, 1.11408114e-01f, -1.79607570e-02f, 1.50047252e-02f, 4.97507975e-02f, 1.36012182e-01f,
  -1.91753954e-01f, -2.18970589e-02f, -6.23533875e-02f, -1.03116527e-01f, -1.78547472e-01f, -2.98717022e-02f, 2.32974023e-01f, 9.15776938e-02f, -4.28053215e-02f, -1.03987627e-01f,
  1.11367315e-01f, 4.49804105e-02f, -3.20458561e-02f, 1.19143263e-01f, -1.15639597e-01f, -7.45770931e-02f, -8.76010805e-02f, -3.01370263e-01f, 3.53105552e-02f, -1.50761325e-02f,
  1.82806198e-02f, -1.48127884e-01f, -1.63271919e-01f, 2.93697473e-02f, 6.22480139e-02f, -9.58015919e-02f, 2.16203451e-01f, 5.42251170e-02f, -2.12220810e-02f, -3.25113684e-02f,
  -6.16513938e-03f, 9.96296033e-02f, -1.13580720e-02f, -1.24373548e-02f, -4.96983230e-02f, -6.44737259e-02f, 8.23040754e-02f, 3.75536308e-02f, 2.29907339e-03f, -1.11038841e-01f,
  -1.33341789e-01f, -6.18993901e-02f, -4.63181026e-02f, -9.61044338e-03f, 1.24653354e-02f, 1.57657638e-01f, 7.86507502e-02f, -4.37732860e-02f, -7.56845772e-02f, -9.20405835e-02f,
  1.38361767e-01f, 5.66007979e-02f, -1.54065058e-01f, -4.94557470e-02f, -4.70941104e-02f, 6.45698160e-02f, -1.04839675e-01f, -1.78972783e-03f, -1.90659426e-02f, -9.49315280e-02f,
  -1.10362828e-01f, 1.06002904e-01f, -8.88638478e-03f, -2.08116472e-01f, -5.74414656e-02f, -9.26375091e-02f, 1.72647730e-01f, -1.91607922e-02f, 5.85075654e-02f, 5.64771006e-03f,
  3.42227854e-02f, -4.72587049e-02f, 1.87717732e-02f, 5.27025908e-02f, -8.47160965e-02f, 9.24054533e-03f, 1.67865813e-01f, -1.17034927e-01f, -3.29902605e-03f, -1.04641430e-01f,
  -1.30116060e-01f, -2.27169860e-02f, -2.94822045e-02f, -4.11948115e-02f, 2.04028431e-02f, -4.09238711e-02f, 5.22046052e-02f, -8.42248350e-02f, 1.34233506e-02f, -1.11843154e-01f,
  -2.59518772e-01f, -2.59400215e-02f, -3.38607490e-01f, -2.28459805e-01f, 6.09350689e-02f, -3.42433780e-01f, -2.16294289e-01f, -1.83959957e-02f, 1.11265115e-01f, 1.37802005e-01f,
  1.50426075e-01f, -1.22697251e-02f, 1.77181020e-01f, -2.50966936e-01f, -4.21260148e-01f, 1.64789408e-02f, -4.32968765e-01f, -1.72963366e-01f, 5.97606376e-02f, -7.78374597e-02f,
  -1.48945138e-01f, -1.51862754e-02f, -2.15370730e-01f, 1.97778523e-01f, -2.20406249e-01f, -6.10419773e-02f, 9.56806839e-02f, 1.20499767e-01f, -2.29954794e-01f, 9.64410417e-03f,
  -1.27031818e-01f, 1.66993216e-01f, -9.74493325e-02f, -7.98205733e-02f, -8.60715955e-02f, 3.85111496e-02f, -7.45755732e-02f, -8.20896178e-02f, 5.07169105e-02f, 5.69489300e-02f,
  3.27088870e-02f, 7.92452022e-02f, 6.32607043e-02f, 4.05896120e-02f, -1.32933620e-03f, -1.81206670e-02f, -5.45723177e-03f, -5.24112694e-02f, 9.46118906e-02f, -1.00802638e-01f,
  -4.02941220e-02f, -6.05521500e-02f, 9.44561232e-03f, 9.28887203e-02f, -2.13863458e-02f, 1.75972562e-02f, -1.02571189e-01f, -2.35778019e-02f, -2.25921310e-02f, -1.77871122e-03f,
  -1.89751014e-02f, 1.31003326e-02f, 1.16661750e-02f, -2.70514376e-02f, 4.46186699e-02f, -9.84507613e-03f, 1.32183777e-02f, 1.28044281e-03f, 1.62236374e-02f, -8.55319649e-02f,
  5.37563413e-02f, -6.52118027e-02f, 1.05127394e-02f, -8.84563029e-02f, -1.10977322e-01f, -5.79889826e-02f, -4.08871695e-02f, 2.58434750e-02f, -6.82674870e-02f, -8.31117779e-02f,
  1.33055419e-01f, -2.06199326e-02f, 6.82706460e-02f, 2.92217974e-02f, -9.25432965e-02f, 1.79870706e-02f, 7.14613944e-02f, -3.47003601e-02f, -3.05416659e-02f, 5.26309907e-02f,
  -8.13285708e-02f, 1.30730450e-01f, 4.00410891e-02f, 7.38612115e-02f, 4.35684808e-03f, 2.63591316e-02f, -9.14845914e-02f, -8.00648034e-02f, -2.17444655e-02f, 1.29867986e-01f,
  -1.08559199e-01f, -6.99498085e-03f, 6.11991510e-02f, -3.30597125e-02f, -2.00439561e-02f, -1.40695676e-01f, 6.46531731e-02f, 8.33560228e-02f, 6.48382753e-02f, 1.37783084e-02f,
  1.42341152e-01f, 6.24145232e-02f, 1.28880158e-01f, 4.46761958e-02f, 8.41218531e-02f, -2.34115846e-03f, -3.00928168e-02f, 1.27634639e-02f, 4.62686494e-02f, 4.54999804e-02f,
  -2.70565540e-01f, 1.30367741e-01f, 5.22378311e-02f, 2.31367499e-01f, -1.13537244e-01f, -2.36733705e-01f, -6.17525391e-02f, 1.62275970e-01f, -1.52128264e-01f, 1.18615620e-01f,
  1.97246596e-01f, -7.16741309e-02f, 1.51968703e-01f, -1.45931495e-03f, -2.21440449e-01f, -4.67692912e-02f, 2.33401433e-02f, 1.10149682e-01f, 3.75371613e-02f, 1.86186805e-01f,
  8.81847441e-02f, 2.37726420e-02f, 2.43446216e-01f, 1.49440557e-01f, -2.14137714e-02f, 2.57351518e-01f, 3.11500311e-01f, 1.29146606e-01f, 2.62898982e-01f, -2.08559081e-01f,
  -6.57412112e-02f, 1.79126393e-02f, -1.51907708e-02f, -2.70283576e-02f, 4.10597026e-03f, 7.38054216e-02f, 5.07272854e-02f, 3.75640430e-02f, 6.98676184e-02f, 1.40512466e-01f,
  4.40012775e-02f, 5.14317676e-02f, -6.40841052e-02f, -1.22651316e-01f, -1.74536154e-01f, -2.03685705e-02f, -2.51913033e-02f, -9.94635224e-02f, 1.90194473e-02f, -7.96830878e-02f,
  1.13736525e-01f, 2.57647857e-02f, -1.01680078e-01f, -2.07232293e-02f, 6.06339099e-03f, -1.37510290e-02f, -1.45426649e-03f, 4.27794792e-02f, -5.47720157e-02f, -6.87732249e-02f,
  -1.17209934e-01f, 4.21668254e-02f, 9.34234783e-02f, 7.56426677e-02f, -4.36375178e-02f, 7.17346743e-02f, -8.60128105e-02f, -4.17890586e-03f, -7.98317343e-02f, 4.89189010e-03f,
  1.11994088e-01f, 6.34629205e-02f, -3.75672150e-03f, 7.74851888e-02f, 4.60609831e-02f, -8.11686143e-02f, 6.47980720e-02f, 4.02633380e-03f, 1.59702357e-02f, 1.05003573e-01f,
  1.03957929e-01f, -3.89670469e-02f, 5.19200787e-02f, -7.07179606e-02f, 5.01807360e-03f, 1.27914831e-01f, 3.94226488e-04f, -5.34948483e-02f, 1.61399961e-01f, 1.66802797e-02f,
  1.06843635e-01f, 2.08646432e-01f, 3.73326614e-02f, -6.09212480e-02f, -7.56215164e-03f, 4.58755754e-02f, -6.12140968e-02f, -2.60302294e-02f, 3.56596708e-02f, -7.54514486e-02f,
  3.36541757e-02f, 9.81558561e-02f, -1.07783884e-01f, -2.03720197e-01f, -5.58548607e-02f, 8.61418340e-03f, 1.23795785e-01f, 1.05464965e-01f, 1.41599283e-01f, 6.53516203e-02f,
  2.35941619e-01f, 2.62237638e-02f, -6.48875684e-02f, -9.29091871e-02f, 2.83206664e-02f, 1.06434643e-01f, -5.43852448e-02f, -1.04166359e-01f, -2.89740432e-02f, 3.56575064e-02f,
  2.71387547e-02f, -1.71002448e-01f, -6.15597926e-02f, 1.99095383e-01f, 1.93976089e-01f, -2.60965209e-02f, -2.26640463e-01f, 6.01804256e-02f, 1.36627287e-01f, -1.90000728e-01f,
  1.31490845e-02f, 9.86150727e-02f, -4.01902050e-01f, 2.21137971e-01f, 4.63477671e-02f, -2.94030249e-01f, 1.82974085e-01f, 1.58924803e-01f, -3.79193714e-03f, -5.36308682e-04f,
  1.70064807e-01f, 1.31221473e-01f, 2.66931877e-02f, 2.67657459e-01f, 5.38389571e-02f, 7.83178285e-02f, -1.49981165e-02f, -9.39152464e-02f, 1.63725019e-01f, 5.72026484e-02f,
  3.03174499e-02f, 5.69796795e-03f, -3.55962813e-02f, 7.15013221e-02f, -6.79941922e-02f, -4.49312031e-02f, -8.08342546e-02f, -5.41719310e-02f, 2.49969605e-02f, -1.95751023e-02f,
  -8.20236355e-02f, 7.37390220e-02f, 4.12980579e-02f, -6.88960627e-02f, 1.38911262e-01f, 1.61711082e-01f, 3.18919942e-02f, -1.48735298e-02f, 1.15347944e-01f, 1.37076732e-02f,
  -6.03216933e-03f, 1.30785018e-04f, -2.98169777e-02f, 5.09234741e-02f, -3.16476040e-02f, 9.40408930e-02f, 2.53371038e-02f, -1.23369247e-02f, 3.74583006e-02f, 1.31623715e-01f,
  4.65670004e-02f, -6.04771711e-02f, -3.54591310e-02f, -8.84713531e-02f, -8.03814530e-02f, -2.09153835e-02f, 1.89105961e-02f, 6.18280657e-02f, -3.85687426e-02f, -1.14129558e-01f,
  4.54993360e-02f, 1.72106817e-03f, -5.72979264e-02f, 2.68486124e-02f, -1.53112700e-02f, 8.75998288e-02f, -3.49894240e-02f, -9.55739915e-02f, -4.52203304e-02f, -2.52354220e-02f,
  -6.70736330e-03f, 9.40793008e-02f, -7.29093328e-02f, 1.03884879e-02f, 9.43337679e-02f, -1.14387132e-01f, -7.31105655e-02f, -3.83311957e-02f, 4.16678116e-02f, -5.48549034e-02f,
  -1.69006392e-01f, -2.51409471e-01f, -6.08385950e-02f, 6.61746413e-02f, -1.49732400e-02f, 5.99536337e-02f, 8.37460160e-02f, 7.72388726e-02f, -1.64249763e-02f, 3.22214561e-03f,
  2.34693494e-02f, -8.26190487e-02f, -5.79831228e-02f, 3.59049067e-03f, 3.62244770e-02f, -1.83216911e-02f, -4.95907366e-02f, 1.85349062e-02f, 4.06791866e-02f, 4.70090471e-02f,
  9.53485519e-02f, -3.38115953e-02f, 7.00213760e-02f, 4.96437252e-02f, 5.96345291e-02f, -6.41503185e-02f, 5.73482253e-02f, 3.08325402e-02f, -8.27509984e-02f, 4.50996198e-02f,
  -2.28376478e-01f, 2.64056563e-01f, 4.28796792e-03f, -9.64804515e-02f, -2.11426243e-03f, -2.89446950e-01f, -7.20863342e-02f, 1.46776170e-01f, 1.77961245e-01f, 1.24227010e-01f,
  1.60922389e-02f, 1.41434027e-02f, 1.80038676e-01f, -2.00739890e-01f, -4.38480377e-01f, -1.60205498e-01f, -2.47834370e-01f, -5.38788699e-02f, -6.70862198e-02f, 2.53594313e-02f,
  -1.87488720e-01f, -2.78406054e-01f, -3.79535668e-02f, 4.45580781e-02f, -8.69326219e-02f, 5.73925897e-02f, -1.11322336e-01f, 9.43647027e-02f, -7.80817643e-02f, -2.52507199e-02f,
  7.43013918e-02f, 2.24176511e-01f, 1.04864568e-01f, 6.27853423e-02f, 2.94621065e-02f, -1.04111686e-01f, -8.27695206e-02f, 4.21015359e-03f, 7.28226081e-02f, 7.25125447e-02f,
  7.44189546e-02f, -8.36660042e-02f, -2.28654686e-02f, -4.10787724e-02f, 8.43921304e-02f, 3.46672758e-02f, 2.81034578e-02f, 4.31292430e-02f, 1.37328580e-01f, -1.24800384e-01f,
  4.65265214e-02f, 5.54626174e-02f, -2.30886769e-02f, 1.02892153e-01f, 3.74393910e-02f, 1.68842338e-02f, -1.18091099e-01f, -1.57764461e-02f, 1.70877371e-02f, -3.55755761e-02f,
  -2.14169919e-02f, -8.28591213e-02f, -1.55271841e-02f, 1.08846255e-01f, -2.02963091e-02f, 9.95739773e-02f, -2.94291247e-02f, 6.36139363e-02f, -3.56065482e-02f, -1.02797495e-02f,
  -1.50542883e-02f, -2.23978516e-03f, 3.21954601e-02f, -1.27810001e-01f, -1.88783854e-01f, -4.44958843e-02f, -2.69573042e-03f, -2.83074509e-02f, 3.62028666e-02f, -7.48231355e-03f,
  9.63577405e-02f, -6.01484068e-02f, 1.18893199e-01f, 3.97365987e-02f, 4.83352877e-02f, 3.46016921e-02f, -1.23265289e-01f, -3.57776731e-02f, 5.44359423e-02f, -5.44410460e-02f,
  1.43941632e-02f, 1.66699830e-02f, 1.73885390e-01f, 1.43167540e-01f, 4.86312918e-02f, -1.27154872e-01f, -1.77089557e-01f, 1.91186685e-02f, 5.03464267e-02f, -7.07434639e-02f,
  2.70855315e-02f, 8.12230706e-02f, -5.23517095e-02f, -7.90699720e-02f, 1.50693417e-01f, -1.20030232e-01f, -2.29700990e-02f, 1.05315015e-01f, 9.82999057e-02f, -7.23184692e-03f,
  6.46068156e-02f, 6.79291189e-02f, 5.12028746e-02f, 8.82632062e-02f, 8.34267661e-02f, 1.05355509e-01f, -4.62350063e-02f, 8.87458846e-02f, 4.94958088e-02f, 5.89942113e-02f,
  2.47681528e-01f, 1.66620165e-01f, 1.39361948e-01f, 1.40050977e-01f, -2.50381619e-01f, -1.80064693e-01f, -1.60006538e-01f, -3.95592824e-02f, 2.31169879e-01f, -2.68227495e-02f,
  -2.46051624e-01f, 2.30442017e-01f, 2.94203814e-02f, -2.07216471e-01f, 3.88239957e-02f, 6.69011101e-02f, -7.40999915e-03f, 7.39895478e-02f, 3.88567545e-03f, 1.37204928e-02f,
  -7.95805976e-02f, -4.58122015e-01f, -8.51391703e-02f, -2.21242264e-01f, -2.90325314e-01f, -7.56984809e-03f, -3.49478126e-01f, -2.35550910e-01f, -1.45798281e-01f, -4.14024144e-02f,
  -8.18011388e-02f, -9.32735391e-03f, 1.12727135e-01f, 9.41993520e-02f, 5.30031845e-02f, -3.04571615e-04f, -3.32249105e-02f, -9.96841043e-02f, -4.04171795e-02f, 1.18959866e-01f,
  1.31959647e-01f, 5.83145069e-03f, 1.55721232e-03f, -2.15958674e-02f, 2.88652536e-02f, 9.76388622e-03f, 3.30478214e-02f, 1.08398229e-01f, 1.14712594e-02f, 2.70355344e-02f,
  1.07871808e-01f, 4.95851114e-02f, 6.27129674e-02f, 8.69105384e-02f, 1.10982135e-01f, -9.41354316e-03f, 1.03654668e-01f, 6.62613511e-02f, 2.47403653e-03f, 7.86224157e-02f,
  -3.72951142e-02f, -8.80643651e-02f, -8.27204660e-02f, -5.97836152e-02f, -1.35687023e-01f, -6.09584749e-02f, 6.77127345e-03f, -9.02458206e-02f, 7.75549933e-02f, -1.27644747e-01f,
  8.23248830e-03f, 3.66157591e-02f, -9.95214954e-02f, 2.42244322e-02f, -7.60490000e-02f, 3.05213425e-02f, -1.33687938e-02f, -3.72214534e-04f, 9.98770595e-02f, 8.69456157e-02f,
  -1.04912020e-01f, 4.23325561e-02f, 5.95153160e-02f, -5.04629388e-02f, -1.26037791e-01f, 4.74238135e-02f, 3.65366526e-02f, 1.96196865e-02f, -6.74436763e-02f, 6.92353770e-02f,
  9.31672007e-02f, 1.35819688e-01f, 5.35991043e-02f, 1.02701344e-01f, 6.60142824e-02f, 5.34981452e-02f, -1.40889049e-01f, 6.75390959e-02f, 7.19954520e-02f, 4.59359474e-02f,
  -1.10579906e-02f, 7.83625096e-02f, 6.06651269e-02f, -5.23017868e-02f, 8.23337957e-02f, -2.77812760e-02f, -1.07387649e-02f, 1.25323400e-01f, 7.72505403e-02f, 4.10522558e-02f,
  -5.04231751e-02f, 6.56098947e-02f, 2.01680794e-01f, 6.18987624e-03f, 1.51280016e-01f, 3.20321880e-02f, -4.44676504e-02f, 1.07948452e-01f, 1.04537159e-01f, 1.40624419e-01f,
  -5.84367365e-02f, 4.15412188e-02f, 2.16929913e-01f, 1.61617979e-01f, 8.90459344e-02f, 1.89508915e-01f, 2.09907100e-01f, 1.93776548e-01f, 2.52539784e-01f, 1.59914512e-02f,
  3.42736840e-02f, -9.51730087e-02f, -1.81041248e-02f, 1.65883735e-01f, -1.21955648e-01f, 1.43579036e-01f, 9.40458477e-02f, -1.51239866e-02f, 6.80823484e-03f, -4.56472859e-02f,
  -6.05850853e-02f, -1.77799329e-01f, -2.31602527e-02f, -2.65902698e-01f, 9.78682563e-02f, -3.88737060e-02f, -1.49436414e-01f, -2.21244037e-01f, -3.70769687e-02f, -1.17805205e-01f,
  -1.30224049e-01f, 6.86404258e-02f, -9.15529802e-02f, -6.43646047e-02f, -6.62591532e-02f, -6.84833154e-02f, 7.84994382e-03f, -4.78678681e-02f, -1.07169881e-01f, 2.92268284e-02f,
  -9.51920077e-02f, 7.23773986e-02f, -1.06233977e-01f, -9.36508775e-02f, -2.65713241e-02f, 4.82356772e-02f, 1.44966945e-01f, 8.78617838e-02f, 5.74038550e-02f, 1.70748368e-01f,
  6.45289794e-02f, 3.52348723e-02f, 1.43242255e-01f, 4.68449295e-02f, -4.63560112e-02f, 5.17895967e-02f, 6.95151985e-02f, 5.59557742e-03f, -4.90761437e-02f, 2.07625423e-02f,
  6.80498257e-02f, 3.94195393e-02f, -6.09811954e-02f, -1.36706054e-01f, -4.87823486e-02f, 5.66358271e-04f, -4.63432446e-02f, -8.39876682e-02f, -1.13189958e-01f, -2.66103093e-02f,
  1.18142394e-02f, -1.07159063e-01f, 4.85272370e-02f, 6.74986690e-02f, -3.13247442e-02f, 7.79421953e-03f, -5.65453880e-02f, 1.10150799e-01f, -1.64935726e-03f, -4.85180095e-02f,
  -3.28425467e-02f, -1.16450014e-02f, 8.64449218e-02f, -6.59487471e-02f, -9.96690765e-02f, -3.83215472e-02f, -5.54054715e-02f, 2.79297531e-01f, -6.61768913e-02f, -2.06108183e-01f,
  -3.51433665e-01f, -3.01028609e-01f, -1.37030616e-01f, -3.03179678e-02f, -1.98091969e-01f, -4.26876582e-02f, -7.08849076e-03f, 2.56954487e-02f, -1.40492469e-01f, 1.11481827e-02f,
  -6.08452894e-02f, 1.91028062e-02f, -1.19238541e-01f, -1.39320232e-02f, -1.41215578e-01f, -6.92296475e-02f, -6.12319410e-02f, -1.53220728e-01f, -8.51753578e-02f, -5.44756874e-02f,
  -5.06205894e-02f, -1.70616180e-01f, -5.36598936e-02f, 2.92526688e-02f, -5.85832410e-02f, -7.72921816e-02f, -1.51201710e-01f, 3.92246805e-02f, -1.21268138e-01f, -4.42964137e-02f,
  -7.01920629e-01f, 5.61269462e-01f, 2.70300210e-01f, -8.79030824e-02f, -1.72813430e-01f, 1.41534343e-01f, 1.07943237e-01f, 5.13303373e-03f, 6.11945689e-02f, 2.48094305e-01f,
  -1.30289853e-01f, 1.46187901e-01f, 1.24640867e-01f, 1.41292095e-01f, -4.17422920e-01f, 2.25539908e-01f, 2.05592196e-02f, 2.09428947e-02f, 2.84235179e-02f, -4.93208654e-02f,
  -7.93133900e-02f, -9.50891972e-02f, 4.03937064e-02f, 1.52137861e-01f, -7.22415522e-02f, 1.47345038e-02f, -2.55025893e-01f, 7.47800991e-02f, -3.92814651e-02f, 4.62392420e-02f,
  -2.58525103e-01f, -3.24773103e-01f, -1.83960974e-01f, -1.14016533e-01f, -8.22431967e-02f, -1.69473469e-01f, -3.34072709e-02f, -1.11633062e-01f, -1.32821247e-01f, -2.50887945e-02f,
  1.15360720e-02f, 8.69576074e-03f, -8.64541307e-02f, 8.32096934e-02f, -6.06231205e-02f, -4.40464020e-02f, -3.74152660e-02f, -1.15232281e-01f, -1.07083336e-01f, 3.93948182e-02f,
  2.59452283e-01f, 5.90507276e-02f, -6.05185889e-02f, -6.43008798e-02f, -8.84175673e-02f, -5.42820022e-02f, 1.16311304e-01f, -7.61593804e-02f, -7.10617155e-02f, -5.42550869e-02f,
  -3.17525305e-03f, -7.02280700e-02f, -3.14893946e-02f, -2.35881023e-02f, 3.11840158e-02f, 1.02570280e-01f, 7.19750077e-02f, -4.30994742e-02f, 3.22886296e-02f, -1.83938984e-02f,
  -8.53592455e-02f, -1.70298945e-02f, -1.02600511e-02f, 2.10326258e-02f, 1.65635169e-01f, 9.21200588e-02f, -9.88208577e-02f, -6.81849271e-02f, 1.18421569e-01f, 7.87786096e-02f,
  -6.30675033e-02f, 5.11990907e-03f, 4.03234623e-02f, -4.92284186e-02f, -1.69357006e-02f, -1.29556898e-02f, 5.55105023e-02f, 5.64729190e-03f, -1.09197907e-01f, -1.26301289e-01f,
  -3.70092481e-01f, -2.69577831e-01f, -9.07317996e-02f, -2.68917114e-01f, -5.06630726e-02f, -3.12820934e-02f, 4.51173894e-02f, -3.95846441e-02f, -5.01471981e-02f, -6.26429617e-02f,
  -1.84835214e-02f, 5.94537240e-03f, -1.60584226e-02f, 2.91625764e-02f, 1.39265910e-01f, -9.22435522e-02f, -2.14916561e-02f, -1.22838743e-01f, -1.92431450e-01f, -1.01824915e-02f,
  -9.02281422e-03f, -5.31623401e-02f, 3.23132286e-03f, -6.91632330e-02f, -5.66207133e-02f, -1.05807632e-01f, -1.46724105e-01f, -2.65250038e-02f, -1.82567820e-01f, 1.08856298e-02f,
  1.37230277e-01f, 8.63944218e-02f, 2.30065376e-01f, 2.10362643e-01f, 1.31288648e-01f, -1.98721111e-01f, -1.35119855e-01f, 2.99082905e-01f, 1.31653935e-01f, -2.77262926e-01f,
  -3.48956659e-02f, -1.84084490e-01f, 5.26271984e-02f, 5.58054447e-02f, 3.15845534e-02f, 2.18272787e-02f, 2.53081530e-01f, -1.03841707e-01f, 2.13009194e-01f, 1.79490596e-01f,
  2.38267094e-01f, 1.30890653e-01f, 2.79521585e-01f, 1.34159476e-01f, 2.77982652e-01f, 1.11988910e-01f, 6.52882978e-02f, -4.69367467e-02f, -6.82763532e-02f, -1.35263249e-01f,
  -9.64596123e-02f, 1.83675781e-01f, 8.55567008e-02f, -1.53180540e-01f, 7.88559467e-02f, -1.41865477e-01f, -1.76641941e-02f, -6.40111789e-02f, -9.44798216e-02f, -1.49226815e-01f,
  1.77964512e-02f, 6.54941574e-02f, 2.64574401e-02f, 1.35550015e-02f, 4.03908826e-02f, 7.34384060e-02f, 1.04394510e-01f, 2.99805067e-02f, 7.97544047e-03f, 2.00257450e-01f,
  4.25436608e-02f, -3.08461562e-02f, -3.67334671e-02f, 2.43255701e-02f, 1.88102916e-01f, 5.49956672e-02f, -3.21103483e-02f, 7.42532387e-02f, 3.51956040e-02f, 8.45971052e-03f,
  1.86467201e-01f, 1.22068767e-02f, -1.47721365e-01f, -4.19959389e-02f, -9.28627700e-02f, -2.98577435e-02f, -2.25129992e-01f, -1.22257665e-01f, -8.21434185e-02f, -4.37716544e-02f,
  -3.90551612e-02f, -3.33891511e-02f, 2.19841097e-02f, -4.83811982e-02f, -9.87998117e-03f, 1.25765353e-02f, -1.08384155e-01f, -4.32593282e-03f, 7.54202232e-02f, 1.98520105e-02f,
  1.41862081e-02f, 9.32981819e-03f, -4.60218266e-02f, 1.61190834e-02f, -1.67137980e-01f, 2.98528420e-03f, 1.62340909e-01f, 9.61421803e-02f, -6.80060452e-03f, 1.21081144e-01f,
  -8.31404626e-02f, 9.46574882e-02f, -1.16305677e-02f, -1.17032051e-01f, -9.46696773e-02f, -1.07152618e-01f, 3.91481295e-02f, 3.19304094e-02f, -8.71720165e-02f, -2.68088970e-02f,
  9.90122333e-02f, -3.01046222e-02f, -2.04726040e-01f, -5.00768833e-02f, -4.70449403e-02f, 6.72524842e-03f, -1.06170237e-01f, -7.15102404e-02f, 4.01152149e-02f, 1.86697081e-01f,
  -8.50593613e-04f, -8.11936781e-02f, -4.99815345e-02f, 5.68322875e-02f, 9.61089581e-02f, 3.04790417e-04f, -4.28782515e-02f, 8.97700340e-02f, -1.73136462e-02f, 5.02876081e-02f,
  2.30865970e-01f, 3.67350668e-01f, 1.93020597e-01f, 1.40002936e-01f, -1.44999489e-01f, -2.89230287e-01f, -1.74343571e-01f, -4.96538263e-03f, 1.23453815e-03f, 1.39112890e-01f,
  -1.97330996e-01f, 2.58895487e-01f, -2.63935290e-02f, 4.26004492e-02f, -3.22514415e-01f, -4.56680916e-02f, -8.78526643e-02f, 9.20046121e-02f, 2.51939278e-02f, -7.07689524e-02f,
  3.28750499e-02f, -3.05481106e-01f, 2.83269435e-02f, -1.63229749e-01f, 7.39547834e-02f, 1.74127042e-01f, -1.81278773e-02f, -1.76729597e-02f, 1.89487170e-02f, -1.13656349e-01f,
  -1.23064313e-02f, 1.83793362e-02f, 7.16898143e-02f, 3.68443802e-02f, -7.89705515e-02f, 1.14377886e-02f, 1.44125730e-01f, -5.47547303e-02f, 2.16636620e-02f, 4.66345735e-02f,
  1.30370721e-01f, -9.41852573e-03f, 1.53511213e-02f, -3.81301679e-02f, 9.27401260e-02f, 1.58092365e-01f, 6.46352917e-02f, 4.19176035e-02f, 6.57188427e-03f, 1.96141690e-01f,
  -6.87857857e-03f, 1.22454755e-01f, 1.18152192e-02f, 6.18173275e-03f, -1.59933306e-02f, -3.27832587e-02f, -5.70252240e-02f, 5.46156466e-02f, 9.66968313e-02f, 6.52010664e-02f,
  3.14172916e-02f, -6.17705695e-02f, 1.31098481e-04f, 8.32948238e-02f, -1.14746742e-01f, 1.40790083e-02f, -6.70128688e-02f, 2.13351510e-02f, 3.02043781e-02f, 3.90924849e-02f,
  -3.85148264e-02f, 9.44644064e-02f, -1.03472620e-01f, 5.62196895e-02f, 3.61148007e-02f, -2.71657500e-02f, -3.81483547e-02f, 1.09112814e-01f, 2.38614958e-02f, 4.44458984e-02f,
  -8.45529065e-02f, -7.82236457e-02f, -2.88046664e-04f, -3.89964436e-03f, -4.82978560e-02f, 1.09848641e-02f, -4.32187598e-03f, 1.14063486e-01f, 2.02488564e-02f, -5.84758930e-02f,
  -1.39914304e-01f, -2.07684845e-01f, -1.43302217e-01f, -3.13424803e-02f, -4.10822220e-02f, 4.32590730e-02f, -2.53570057e-03f, -4.99218144e-03f, -1.69875156e-02f, -4.71061803e-02f,
  9.38186571e-02f, -2.35273261e-02f, 2.80079264e-02f, -6.93669990e-02f, -9.33025628e-02f, -2.17421521e-02f, -1.89046338e-02f, -1.79668665e-02f, -9.80032235e-02f, 1.60778947e-02f,
  4.94139865e-02f, 3.33519801e-02f, 4.84183580e-02f, -6.47045895e-02f, -3.76235717e-03f, -3.48886512e-02f, -1.70037504e-02f, 4.79152016e-02f, -2.42552273e-02f, 5.71480431e-02f,
  -2.66417742e-01f, 2.73641527e-01f, 4.77671355e-01f, -2.70642579e-01f, 1.43583059e-01f, 3.59017164e-01f, -1.46715576e-03f, 1.13458012e-03f, -2.15462551e-01f, -9.14964974e-02f,
  -1.40331447e-01f, 2.21802518e-01f, 1.89352199e-01f, -4.29678634e-02f, 8.95865113e-02f, 2.68100984e-02f, -6.57523796e-02f, -3.29203419e-02f, 1.50436118e-01f, -3.45513448e-02f,
  -1.00021161e-01f, -2.61052400e-01f, 1.80726394e-01f, -4.09866981e-02f, 6.84857368e-02f, 1.06182625e-03f, -3.94284040e-01f, 1.66624829e-01f, -8.07372406e-02f, 1.07147992e-01f,
  8.65124986e-02f, -2.35929355e-01f, 1.68895170e-01f, 4.53952700e-02f, -1.35545759e-02f, -2.86700651e-02f, -1.60943009e-02f, 9.30914581e-02f, -6.46913722e-02f, 1.02071203e-01f,
  7.95969740e-02f, 5.79276271e-02f, 5.36324689e-03f, 1.56718194e-02f, 9.29991230e-02f, 1.73124060e-01f, 1.31628200e-01f, 1.74544334e-01f, 1.63118348e-01f, 9.34933126e-02f,
  1.54634327e-01f, 2.90199012e-01f, 1.01893716e-01f, -3.64216007e-02f, 7.51782358e-02f, 1.69928093e-02f, 3.52733731e-02f, 4.47174683e-02f, 1.38163328e-01f, 8.15107226e-02f,
  -9.17648897e-02f, -1.59595639e-01f, 6.95293024e-02f, 6.03262968e-02f, -9.98825114e-03f, -4.68461439e-02f, 8.67864788e-02f, 1.86082833e-02f, 2.80498341e-02f, 9.60353240e-02f,
  2.65843165e-03f, 1.14018291e-01f, -7.66744241e-02f, -5.49833253e-02f, -1.12692885e-01f, -1.55557469e-01f, 7.85730556e-02f, 2.54422892e-03f, 2.61074305e-02f, -1.04181301e-02f,
  -6.55423328e-02f, -6.52372837e-02f, -5.92842288e-02f, -3.30093727e-02f, 1.04284231e-02f, 7.00971931e-02f, 5.47896437e-02f, 9.47470367e-02f, 9.38239228e-03f, 1.79470271e-01f,
  1.73956379e-02f, -3.39833170e-01f, -5.07671125e-02f, 3.64785232e-02f, 3.19414027e-02f, 9.20173377e-02f, -2.64214817e-02f, 2.53033265e-02f, 7.18207797e-03f, 2.04849187e-02f,
  -2.44604219e-02f, -5.28792813e-02f, 8.64803791e-02f, -2.76528485e-02f, -2.17515789e-03f, 1.16915450e-01f, -1.22211732e-01f, 9.95224938e-02f, 8.00013989e-02f, -1.59663074e-02f,
  2.80209817e-02f, -7.35231265e-02f, -2.56772470e-02f, -6.33160993e-02f, -1.00388266e-01f, 1.23270132e-01f, -1.20763384e-01f, -5.49486987e-02f, 1.33956552e-01f, 7.17474371e-02f,
  -4.87429112e-01f, 2.94080347e-01f, 6.26410320e-02f, -2.66749471e-01f, -7.74577484e-02f, 1.32384002e-01f, -3.18409130e-02f, 1.13428995e-01f, -2.79197603e-01f, 2.66886711e-01f,
  1.83201417e-01f, -2.84381181e-01f, 2.52303779e-01f, 4.36323248e-02f, -3.93929213e-01f, -6.77261560e-04f, 2.89405957e-02f, 8.85976553e-02f, -1.96342453e-01f, 7.68521801e-02f,
  -1.54685825e-01f, -1.08079478e-01f, 2.21306950e-01f, 1.08211208e-02f, 2.10604817e-02f, 4.07122709e-02f, 2.12786213e-01f, -3.60321440e-03f, 3.25685516e-02f, -9.47469994e-02f,
  1.43157333e-01f, 4.98274267e-02f, 1.46725029e-01f, 1.96282789e-02f, 1.24037750e-01f, 5.13860062e-02f, 7.22072721e-02f, 3.41682360e-02f, -1.41196683e-01f, -5.24843968e-02f,
  -5.84950782e-02f, -6.38606176e-02f, -1.14016600e-01f, -1.36161968e-01f, -1.25565350e-01f, -6.91315830e-02f, -1.32374540e-02f, 7.72454143e-02f, -2.66317017e-02f, -2.48366557e-02f,
  -1.58111937e-03f, -6.23066314e-02f, -6.52824491e-02f, -1.77627560e-02f, -4.78192009e-02f, -7.06492690e-03f, -3.15448269e-02f, 2.90658288e-02f, 4.45707664e-02f, -1.26753435e-01f,
  -9.31683108e-02f, -2.18596458e-02f, -2.35545132e-02f, 1.00511044e-01f, -5.55046722e-02f, 6.06818795e-02f, -5.86679801e-02f, 4.57016891e-03f, -4.26843874e-02f, 2.20453553e-02f,
  -4.27954569e-02f, -8.35824832e-02f, -2.33355109e-02f, -1.12457080e-02f, -8.35177079e-02f, -2.35565659e-02f, 2.37776842e-02f, 2.35224795e-02f, -1.27010539e-01f, 1.03003800e-01f,
  1.02220282e-01f, -2.72168834e-02f, -1.25682667e-01f, 5.30819744e-02f, 5.91387525e-02f, -1.59828775e-02f, -1.13095991e-01f, -2.76459251e-02f, 2.15658143e-01f, -7.11124018e-02f,
  1.57161251e-01f, -4.32083197e-02f, 1.33189827e-01f, -5.98271899e-02f, 4.10367176e-02f, 9.07783210e-03f, -4.36356012e-03f, 3.38029154e-02f, 1.21739134e-02f, -5.76878898e-02f,
  2.47475076e-02f, -1.06717283e-02f, 2.50999127e-02f, 5.45999920e-03f, -7.15125948e-02f, 6.78463057e-02f, -6.03608079e-02f, -5.70128933e-02f, -5.32153575e-03f, -2.90165609e-03f,
  -2.58119609e-02f, -1.20539159e-01f, -1.27158493e-01f, -5.27902208e-02f, 3.25300023e-02f, -3.70581895e-02f, 6.15489930e-02f, -2.85185110e-02f, -4.14815359e-02f, 5.92872268e-04f,
  -4.47150379e-01f, -2.50173777e-01f, -4.37987857e-02f, 1.87306032e-01f, -2.26163253e-01f, -1.49685681e-01f, 1.70604587e-02f, -6.26749843e-02f, -2.32577935e-01f, 1.88993901e-01f,
  2.97553241e-01f, -2.94327021e-01f, 1.13570830e-02f, 4.67995316e-01f, 1.85348410e-02f, 2.47907922e-01f, 3.03243905e-01f, 1.45641640e-01f, 1.30496278e-01f, -1.02757663e-01f,
  1.05686449e-01f, 1.62682623e-01f, 2.00502649e-01f, 1.23052150e-01f, 7.41247237e-02f, 5.23111001e-02f, 1.70040414e-01f, 3.39190997e-02f, 2.10088775e-01f, -1.06546193e-01f,
  -9.26516131e-02f, 6.00280166e-02f, 5.26741706e-02f, -4.18376997e-02f, 8.35979730e-02f, 1.10962488e-01f, -3.59126106e-02f, 3.31864059e-02f, 1.84454806e-02f, -3.76471598e-03f,
  -1.43440381e-01f, -6.70396313e-02f, 7.74425566e-02f, -2.73179971e-02f, -4.63756584e-02f, 1.63436849e-02f, -3.40664387e-02f, -1.55507645e-03f, -1.36752009e-01f, 5.03846183e-02f,
  3.65767069e-02f, 3.93563770e-02f, 4.22584824e-02f, 1.02746569e-01f, 3.59247848e-02f, -3.66105288e-02f, 3.66552453e-03f, -3.80227566e-02f, 1.52711710e-02f, 6.88518733e-02f,
  6.85621127e-02f, -7.55929276e-02f, 1.09315366e-02f, -9.53923166e-02f, 8.25499836e-03f, 1.27886400e-01f, 5.60363904e-02f, 7.66575485e-02f, -1.80419050e-02f, 4.26659919e-02f,
  1.74278840e-02f, 1.59183946e-02f, -9.71326753e-02f, 3.10072452e-02f, 9.22866464e-02f, -3.64796706e-02f, -4.39710505e-02f, -7.60713145e-02f, -7.11910892e-03f, 7.57315755e-02f,
  -1.32926047e-01f, -5.05934209e-02f, 1.60072297e-02f, -5.63270971e-02f, 5.91003615e-03f, -9.04412568e-02f, 3.91868502e-02f, -6.75523505e-02f, -2.91593671e-02f, -2.17528250e-02f,
  -2.99571753e-01f, -1.03399150e-01f, -6.63758889e-02f, -4.22929265e-02f, 7.05581829e-02f, 1.22184977e-01f, 9.88695025e-02f, 4.31750380e-02f, -1.86302755e-02f, 1.39356416e-04f,
  -6.32060021e-02f, 5.94580993e-02f, -1.00396246e-01f, 3.44555005e-02f, -2.97931712e-02f, 3.83864832e-03f, -8.53403658e-02f, -6.59563914e-02f, -1.53559774e-01f, -1.66082364e-02f,
  4.24394347e-02f, 2.43439432e-02f, 6.43901154e-02f, -6.63088216e-03f, -3.27780540e-03f, -4.32793349e-02f, -6.68937340e-02f, -3.99757847e-02f, 3.56941186e-02f, 9.82705727e-02f,
  3.89010817e-01f, 1.42706707e-01f, 1.32177010e-01f, 3.73250514e-01f, 1.42246217e-01f, 1.22611858e-02f, 2.30318159e-01f, 1.35982007e-01f, 5.08404016e-01f, -1.92331567e-01f,
  -4.37335931e-02f, 6.24362603e-02f, -5.88893443e-02f, -6.41967282e-02f, 9.85788032e-02f, -1.35636581e-02f, 2.40649179e-01f, 4.74695340e-02f, 3.20476979e-01f, 1.08474106e-01f,
  1.97440401e-01f, -1.30587175e-01f, -6.30454868e-02f, -1.42490268e-01f, 1.29980668e-01f, 1.22818667e-02f, -2.25202382e-01f, -3.69712934e-02f, -2.60666937e-01f, 3.29543441e-03f,
  -3.87241468e-02f, 1.47456393e-01f, -3.55259664e-02f, -8.08285475e-02f, 6.83379546e-02f, -3.28784063e-02f, -8.17876309e-02f, -6.23493865e-02f, 8.09700266e-02f, -7.47017711e-02f,
  -2.21595615e-02f, -1.05267785e-01f, -4.58244570e-02f, 1.26706725e-02f, 1.47216856e-01f, 1.95437465e-02f, -3.52431126e-02f, -1.64624245e-04f, 2.39087716e-02f, -3.04837562e-02f,
  7.41104260e-02f, 4.57006469e-02f, 2.31826361e-02f, -1.66034937e-01f, -9.48630422e-02f, 7.30709806e-02f, -8.75934202e-04f, -7.68833756e-02f, -4.63861898e-02f, 5.11779226e-02f,
  1.99886747e-02f, 1.16742969e-01f, -1.79315954e-02f, 6.67577088e-02f, 1.91545077e-02f, 5.01748919e-02f, 5.92170730e-02f, -1.35191903e-01f, -2.92889345e-02f, -5.32441363e-02f,
  2.64668018e-02f, 2.91084982e-02f, 1.00092985e-01f, 3.35392542e-03f, 1.78652659e-01f, 1.00286201e-01f, -9.20633674e-02f, -1.17644757e-01f, 8.76593441e-02f, 9.33729634e-02f,
  1.47982268e-02f, -4.79433164e-02f, 1.12781413e-02f, 5.23414873e-02f, 1.49865616e-02f, 1.21890390e-02f, 1.63898095e-02f, -7.03793776e-04f, 3.60345282e-02f, -5.06002419e-02f,
  -6.60388637e-03f, 8.11725035e-02f, -7.41570070e-02f, -6.58155158e-02f, 1.89690012e-02f, -5.82656413e-02f, 4.60355803e-02f, -1.13899522e-01f, 8.61186832e-02f, -1.14092445e-02f,
  -2.20151693e-02f, -5.58825731e-02f, 3.02832071e-02f, -8.17158744e-02f, -2.17913277e-02f, -2.16928730e-03f, -7.55131617e-02f, -2.50513991e-03f, 2.78220177e-02f, -4.42844816e-02f,
  -6.45379052e-02f, 2.83737294e-02f, -1.02622464e-01f, 4.44768257e-02f, -1.03567906e-01f, -7.86295235e-02f, 1.26220956e-02f, -5.92058077e-02f, -9.25261453e-02f, -6.69597685e-02f,
  2.24126413e-01f, -4.42565411e-01f, 2.56202966e-01f, 3.40624809e-01f, 1.46738067e-01f, -2.67670192e-02f, 3.18089545e-01f, -1.09161809e-01f, -4.59920466e-02f, -4.17449355e-01f,
  -5.61266802e-02f, 7.26195127e-02f, -2.30757624e-01f, 1.02355234e-01f, 3.96427870e-01f, -2.88609564e-01f, 5.48735447e-02f, -4.08090279e-02f, 8.64410624e-02f, 5.01950197e-02f,
  2.46979713e-01f, 9.48441923e-02f, 1.80939689e-01f, -7.46574700e-02f, 1.07851177e-01f, 9.00209546e-02f, 1.19101509e-01f, 2.63734367e-02f, 1.70630381e-01f, 1.85237661e-01f,
  -2.06692562e-01f, 1.28327459e-02f, 7.14725768e-03f, -7.69783631e-02f, -1.09155767e-01f, -1.01241264e-02f, 1.82025339e-02f, 9.15270373e-02f, 2.22123247e-02f, -4.65700999e-02f,
  -9.13315266e-02f, -1.34477974e-03f, 5.16566932e-02f, 2.94155907e-02f, -8.31767246e-02f, -3.19229178e-02f, 1.69200897e-02f, -1.31890878e-01f, 8.12012330e-02f, 1.00702100e-01f,
  -1.18058815e-03f, -1.37956306e-01f, -5.80613203e-02f, 4.40458255e-03f, 6.77171797e-02f, 1.98302809e-02f, 9.62655768e-02f, 9.56568792e-02f, -6.42100163e-03f, 2.28590723e-02f,
  5.97676029e-03f, 9.72752199e-02f, 3.35965604e-02f, -8.04564059e-02f, -7.79362395e-02f, 1.18615687e-01f, -1.88694000e-02f, 1.31380223e-02f, -1.39855191e-01f, -1.63181186e-01f,
  -8.79243389e-02f, -4.05964181e-02f, -1.65492103e-01f, 2.52470300e-02f, 7.85972476e-02f, 1.06786706e-01f, 1.57635231e-02f, -1.61876753e-02f, -1.62935123e-01f, 5.81839867e-02f,
  6.47620037e-02f, 4.28377464e-03f, -1.18502460e-01f, 3.84969525e-02f, -1.31475348e-02f, -1.80545487e-02f, -1.02384202e-01f, 2.63928566e-02f, -3.06502916e-02f, 1.16791159e-01f,
  -4.78266448e-01f, -2.41274342e-01f, -1.07090808e-01f, -6.93807676e-02f, -4.00346369e-02f, -7.39997849e-02f, 1.04961216e-01f, -7.52325654e-02f, -1.01596013e-01f, 2.05001161e-02f,
  -6.79862499e-02f, -1.80030279e-02f, -1.53868482e-01f, -2.38355733e-02f, -1.10640571e-01f, -4.46531139e-02f, 6.54754788e-02f, -1.31380066e-01f, 3.79827223e-03f, -6.99055046e-02f,
  1.29459659e-02f, -9.08687562e-02f, -3.32873799e-02f, 9.77529865e-03f, 6.46686107e-02f, -1.99730843e-02f, 7.65481144e-02f, -2.02306081e-02f, -3.52352932e-02f, -1.27674401e-01f,
  -4.22345221e-01f, 9.82886702e-02f, -3.56726833e-02f, -3.41463923e-01f, 2.69771487e-01f, 1.90809265e-01f, -5.46342880e-02f, 2.39380822e-01f, -9.56276208e-02f, 1.42880306e-02f,
  -2.50144035e-01f, -3.41048509e-01f, 6.42300770e-03f, -3.25076401e-01f, -1.99658334e-01f, -9.47605148e-02f, -1.83130026e-01f, -3.34529012e-01f, 1.03952803e-01f, -2.46944264e-01f,
  -4.90691774e-02f, 1.52219713e-01f, 6.92603588e-02f, 4.09468174e-01f, 2.28957221e-01f, 8.77516195e-02f, -3.83181907e-02f, 2.01463163e-01f, -3.18806283e-02f, 9.17181075e-02f,
  -1.45548237e-02f, -1.55325755e-01f, 8.49241912e-02f, 1.30597442e-01f, 7.79831931e-02f, -5.24084084e-02f, -7.34560564e-02f, 9.92712006e-02f, -3.91687918e-03f, 8.83030370e-02f,
  1.66174863e-02f, 2.68445909e-01f, -6.65263087e-02f, 1.67532876e-01f, 4.39668633e-02f, 1.34474069e-01f, 1.63326144e-01f, 1.54135292e-02f, 1.14163034e-01f, 2.79869884e-02f,
  8.02162569e-03f, -1.60102528e-02f, -5.87935895e-02f, -9.09132604e-03f, -9.99763533e-02f, -7.02176057e-03f, -1.82443287e-03f, -1.01733819e-01f, -2.91329585e-02f, -4.18580361e-02f,
  3.48977335e-02f, 6.73953891e-02f, -5.43798432e-02f, 3.12135164e-02f, -5.61195984e-02f, 5.32694273e-02f, -6.90725073e-02f, -1.82405990e-02f, 4.38671969e-02f, 9.58251208e-03f,
  6.89592510e-02f, -1.42894704e-02f, 2.66055763e-02f, 4.34091762e-02f, -4.88985851e-02f, -9.52266343e-03f, -4.24597822e-02f, -1.97219457e-02f, 4.61839698e-03f, -9.08367038e-02f,
  4.80250269e-02f, -6.86202422e-02f, 1.03832865e-02f, 1.54035121e-01f, -1.11036887e-02f, 4.87110913e-02f, 1.21414877e-01f, 3.87049392e-02f, -2.38894802e-02f, -6.17686473e-02f,
  -1.66986063e-01f, -2.16562361e-01f, 7.37553835e-02f, 1.45487666e-01f, -5.39610721e-02f, 3.20948400e-02f, 1.52598526e-02f, 8.01954418e-02f, -3.58534814e-03f, 4.29724902e-02f,
  8.27533528e-02f, 3.23449150e-02f, -1.37199387e-02f, -3.28898802e-02f, -9.66078863e-02f, 1.12646082e-02f, -7.59463534e-02f, -1.02875151e-01f, 5.97830787e-02f, -1.22821704e-02f,
  6.77303821e-02f, 8.09701916e-04f, -4.32458371e-02f, 1.77840829e-01f, -1.05518393e-01f, -9.05192867e-02f, -1.82065532e-01f, -1.75682064e-02f, -3.68657336e-02f, -7.17106462e-02f,
  -5.49092531e-01f, 2.91174382e-01f, -2.69824564e-01f, 2.50951573e-02f, 5.42709120e-02f, 2.32804250e-02f, 9.98859406e-02f, -4.74047698e-02f, 1.65171374e-03f, 3.99018615e-01f,
  3.50153536e-01f, -1.31499812e-01f, 1.61131456e-01f, 3.02635014e-01f, -1.88272163e-01f, 2.37087041e-01f, 1.39604196e-01f, 1.59617499e-01f, -8.14491957e-02f, -1.05337352e-01f,
  -1.82059959e-01f, 2.36929238e-01f, -3.48330401e-02f, -2.08906755e-02f, 1.44717032e-02f, -2.74331570e-01f, 7.47598037e-02f, -1.81691095e-01f, 1.67435467e-01f, 3.95022929e-02f,
  -1.13486148e-01f, -2.11047664e-01f, -7.80646950e-02f, -1.90831378e-01f, -6.88368604e-02f, -4.15394790e-02f, -1.80213451e-01f, -1.18721038e-01f, -1.06568135e-01f, 3.56388725e-02f,
  -1.72524210e-02f, -4.51239496e-02f, 8.14511850e-02f, 3.80710140e-03f, 5.48457950e-02f, 1.34134805e-02f, 7.99995661e-02f, 6.69527352e-02f, 1.61240827e-02f, 6.67764321e-02f,
  -3.73595506e-02f, 7.12241009e-02f, 4.87773716e-02f, 9.89414006e-02f, 6.54550269e-02f, 1.10724766e-03f, -3.66763771e-02f, -1.44634144e-02f, 2.76038218e-02f, 3.51080149e-02f,
  -6.78866683e-03f, -1.04357444e-01f, -3.32131749e-03f, 8.13354328e-02f, 8.93300772e-02f, 1.86692514e-02f, 1.87221002e-02f, 2.82686576e-02f, -4.44220193e-03f, 6.11224882e-02f,
  5.66589162e-02f, -1.32598821e-03f, 1.49668865e-02f, -5.22176214e-02f, -7.12788254e-02f, -1.10792696e-01f, -5.53573035e-02f, -1.05613680e-03f, -1.62175968e-02f, -7.19390139e-02f,
  2.32468103e-03f, 6.63046632e-03f, 7.64443800e-02f, 7.55621493e-02f, 3.30009833e-02f, 2.44495943e-02f, 1.37252314e-02f, 9.87518113e-03f, 3.92583944e-02f, -4.56567435e-03f,
  -9.27092358e-02f, -2.29961678e-01f, -2.16729310e-03f, -4.91598360e-02f, -3.75291593e-02f, 1.00394621e-01f, -1.49871223e-02f, -4.87512685e-02f, 9.55672562e-03f, -8.36188532e-03f,
  -3.61863002e-02f, 3.57966870e-02f, -5.70630692e-02f, 6.93998784e-02f, 3.13576013e-02f, 1.13455258e-01f, -1.31967012e-02f, 2.03753244e-02f, 2.25550681e-02f, -1.72302276e-02f,
  -4.35711779e-02f, -5.95639274e-02f, 6.94537070e-03f, 4.42720726e-02f, 7.69924074e-02f, 5.02899289e-03f, -4.44728062e-02f, 7.11054578e-02f, 4.74565327e-02f, 4.90147769e-02f,
  1.13443248e-02f, 6.52547777e-02f, -3.21308136e-01f, 2.56665587e-01f, -3.00682455e-01f, 8.82892124e-03f, 2.70266026e-01f, -9.15251821e-02f, 8.63769501e-02f, 4.21626329e-01f,
  2.20601976e-01f, -1.31838083e-01f, 2.22572491e-01f, 4.22364384e-01f, -6.65188357e-02f, 3.28031749e-01f, 3.19108963e-01f, 2.13596299e-01f, -1.73260629e-01f, 9.23981667e-02f,
  -1.15369055e-02f, 3.79992634e-01f, 1.98007585e-03f, -9.62718055e-02f, 3.35743688e-02f, -2.38248184e-01f, -1.26580112e-02f, -2.59249240e-01f, 8.12304169e-02f, -1.65782228e-01f,
  5.72821908e-02f, 2.19681025e-01f, -3.36485468e-02f, 5.43367118e-02f, 4.68080752e-02f, 5.23606427e-02f, 6.87563345e-02f, -4.50818837e-02f, 2.50509791e-02f, -1.33634498e-02f,
  7.21471831e-02f, 8.21806565e-02f, 3.72466445e-02f, -8.27359110e-02f, -1.14554361e-01f, -8.44816566e-02f, 1.02995960e-02f, -1.99097842e-01f, -7.28111668e-03f, -1.18259219e-02f,
  -2.00118832e-02f, -7.41860121e-02f, 4.13556248e-02f, 5.56403808e-02f, -8.51515532e-02f, 3.03696226e-02f, 2.47600824e-02f, -8.36523026e-02f, -3.86529900e-02f, -3.70718949e-02f,
  -6.43482581e-02f, 1.64250776e-01f, 1.46720245e-01f, 7.35679790e-02f, 3.84465529e-04f, -5.89558035e-02f, 8.08902308e-02f, 8.96250457e-02f, -1.80055760e-02f, 8.78882259e-02f,
  -3.56207713e-02f, 3.72854024e-02f, 4.70269797e-03f, 8.65504239e-03f, 1.00630745e-01f, 4.91561219e-02f, -8.12478513e-02f, 1.70900486e-02f, 6.93465471e-02f, -4.66145538e-02f,
  5.40759824e-02f, 1.49328843e-01f, 3.70712695e-03f, -1.67894401e-02f, 1.17727429e-01f, -3.14383842e-02f, 1.05088413e-01f, -5.69189191e-02f, -3.72595601e-02f, -8.69274065e-02f,
  1.35768160e-01f, 1.93698376e-01f, 1.09675623e-01f, 2.66726706e-02f, 3.40422504e-02f, -2.17387341e-02f, 9.22514051e-02f, -3.92269008e-02f, 4.70003337e-02f, 2.46343724e-02f,
  -1.37518877e-02f, 3.68178412e-02f, -6.74464554e-02f, -4.98367622e-02f, 1.18642105e-02f, 1.00398511e-01f, 2.27442205e-01f, -1.12752996e-01f, -1.13047808e-02f, -8.19258168e-02f,
  -6.13805689e-02f, -2.77487673e-02f, 3.60359028e-02f, 1.61926672e-02f, 1.53063303e-02f, -1.43974437e-03f, -8.18128437e-02f, -1.08993813e-01f, 5.10962401e-03f, 7.96516542e-04f,
  -2.34526582e-02f, -2.29415491e-01f, -2.39829183e-01f, 1.20333862e-02f, 1.72845170e-01f, -9.00571607e-03f, -1.69879198e-01f, -2.83842720e-02f, -9.86213461e-02f, -4.62699793e-02f,
  9.80041996e-02f, 9.10682008e-02f, -2.62684256e-01f, 2.00213104e-01f, 1.55809924e-01f, -6.66941479e-02f, -6.51887478e-03f, 1.97273046e-01f, 4.72650528e-02f, -1.39119104e-01f,
  -1.59551688e-02f, 1.30545199e-01f, 2.32940670e-02f, 7.72386640e-02f, -2.94127432e-03f, -4.09572162e-02f, 1.23865321e-01f, 1.65286809e-02f, 2.43043974e-01f, 2.20290005e-01f,
  5.25634810e-02f, -1.61404118e-01f, -6.85080215e-02f, 2.11213976e-02f, -1.42156318e-01f, -7.27869570e-02f, -2.92129954e-03f, 6.71915933e-02f, -2.49414779e-02f, -3.79056693e-03f,
  7.04881474e-02f, 1.06744319e-01f, 1.35906503e-01f, 4.34806943e-02f, -1.45579595e-03f, 8.41207355e-02f, -1.06658600e-02f, 4.92407940e-02f, -2.75226720e-02f, -2.11529136e-02f,
  -1.27268329e-01f, -4.14843671e-03f, -4.12992574e-02f, -1.61745325e-02f, -1.12494372e-01f, -1.30301686e-02f, -5.12195565e-02f, -1.38509087e-02f, 1.62226781e-02f, 4.87019029e-03f,
  -4.34648804e-02f, -1.39102871e-02f, -4.33472842e-02f, 4.89912815e-02f, -1.21472292e-01f, 4.74429913e-02f, 5.89048862e-03f, -1.02351559e-02f, 2.26097237e-02f, 2.48375144e-02f,
  4.15906422e-02f, -7.40286941e-03f, 1.42573878e-01f, -1.77056098e-03f, -3.96595560e-02f, 2.57885978e-02f, 5.59651665e-02f, 6.61877990e-02f, -6.01553582e-02f, 8.88954177e-02f,
  1.04340166e-01f, 1.30963167e-02f, 6.53809682e-02f, 2.21838616e-02f, 2.76712719e-02f, -3.70427743e-02f, 2.01147841e-03f, 3.25612165e-02f, -3.15112509e-02f, 2.77611502e-02f,
  -8.64473805e-02f, -3.02147657e-01f, -8.85334313e-02f, 1.57063268e-02f, 1.91811919e-02f, -2.47202814e-02f, -8.59593134e-03f, 4.61359359e-02f, -8.63077343e-02f, -1.81644633e-02f,
  6.69900700e-02f, 9.92776081e-03f, 1.18012577e-01f, 4.37401235e-02f, 3.22940014e-02f, -1.13176042e-02f, 2.54380088e-02f, 1.68205813e-01f, 8.50299187e-03f, 3.94295380e-02f,
  6.06647925e-03f, 1.02248481e-02f, 4.36491258e-02f, -4.57825251e-02f, -3.52475382e-02f, -9.09448136e-03f, -1.53799187e-02f, 5.86231127e-02f, -2.54205912e-02f, 6.06705584e-02f,
  -1.94695264e-01f, -1.81425646e-01f, -2.35770926e-01f, -1.43394873e-01f, -8.98875296e-03f, -4.65986766e-02f, -1.28635652e-02f, -1.43502191e-01f, -1.90213487e-01f, 1.98164240e-01f,
  4.34057750e-02f, -1.63785741e-01f, 2.00164504e-02f, -3.15255791e-01f, -3.88969094e-01f, -2.26720512e-01f, -8.56480375e-02f, 1.41803017e-02f, -1.21006526e-01f, -1.95091742e-03f,
  -1.81233957e-01f, -1.36720955e-01f, -1.96069241e-01f, 1.10169515e-01f, -9.34314430e-02f, 4.54708971e-02f, 2.09876701e-01f, 1.01285642e-02f, 2.17525605e-02f, -1.07304633e-01f,
  -1.19083010e-01f, -8.11348483e-02f, -9.83008891e-02f, -2.64430139e-02f, 4.49427254e-02f, 7.50254244e-02f, 1.26742169e-01f, -6.23878278e-02f, -7.26187974e-02f, 2.46738736e-02f,
  4.19157781e-02f, -1.90426465e-02f, -1.38157219e-01f, -1.07339211e-01f, -7.26532191e-02f, -5.36423288e-02f, -2.79798452e-02f, 7.84487650e-02f, 4.25139442e-03f, -7.53003284e-02f,
  -3.42351161e-02f, -2.96436250e-02f, 1.23473816e-01f, 5.02868891e-02f, 1.64600816e-02f, 3.29599679e-02f, -5.46156205e-02f, -1.85875669e-02f, 6.61180960e-03f, -1.36334551e-02f,
  -3.58287655e-02f, 7.84589574e-02f, -5.42636588e-02f, -1.13119900e-01f, 2.51378398e-02f, -3.08345016e-02f, 1.83475018e-03f, 4.75494936e-02f, 3.13589536e-02f, -1.57694034e-02f,
  1.02441959e-01f, -1.11390501e-01f, 9.44556370e-02f, 5.99748902e-02f, -1.74703319e-02f, -4.28788848e-02f, 2.61292104e-02f, -4.46954928e-02f, -5.79242110e-02f, -6.82538524e-02f,
  -2.32759193e-02f, 7.92447478e-02f, 7.76201040e-02f, 3.28191854e-02f, 2.80499347e-02f, -1.09135330e-01f, 1.41858816e-01f, -3.46869975e-02f, 4.70450483e-02f, 8.99637043e-02f,
  5.44672981e-02f, 1.26134112e-01f, -4.03671041e-02f, 3.84066477e-02f, -6.16816059e-02f, 5.72752282e-02f, -1.10673562e-01f, -4.91200499e-02f, -4.99458313e-02f, 1.20020106e-01f,
  8.73902813e-03f, -2.99829170e-02f, 1.57959685e-01f, -1.05917536e-01f, -1.41308410e-02f, -9.55411699e-03f, 1.94173038e-01f, 1.49082556e-01f, 5.83214089e-02f, 4.91489805e-02f,
  1.63014993e-01f, 6.35104030e-02f, 9.24050957e-02f, 5.94024323e-02f, 1.02256343e-01f, 1.44375503e-01f, -1.06716737e-01f, 2.53542848e-02f, 7.55279735e-02f, 2.86363140e-02f,
  5.90739362e-02f, 1.02383293e-01f, -2.36371726e-01f, -6.75139800e-02f, -2.55137570e-02f, 2.59233981e-01f, 1.03303559e-01f, -2.16233488e-02f, -2.80963331e-01f, 3.41784596e-01f,
  2.62923062e-01f, -2.32951835e-01f, 1.57756105e-01f, 2.46052906e-01f, -1.58731699e-01f, 7.01534078e-02f, 2.68595546e-01f, 1.62768394e-01f, -1.06549680e-01f, 1.36689603e-01f,
  -3.00400425e-03f, 3.28108758e-01f, -3.28365937e-02f, 1.47736683e-01f, 2.49956086e-01f, -6.68669865e-02f, 2.89409786e-01f, -1.49085164e-01f, 1.52545899e-01f, -4.30498943e-02f,
  -1.03513310e-02f, 3.35741825e-02f, -1.72993205e-02f, -2.61142589e-02f, 7.03716129e-02f, 1.03616044e-01f, 1.37062311e-01f, -3.93724628e-02f, -1.77441999e-01f, -1.18886448e-01f,
  1.58098135e-02f, -9.33274105e-02f, 5.39212637e-02f, -1.23826720e-01f, -2.66250428e-02f, 8.31092056e-03f, -8.82608220e-02f, -5.76019734e-02f, -7.96303228e-02f, 5.52872233e-02f,
  -6.06217645e-02f, 4.02104817e-02f, -5.93612157e-02f, 3.86916474e-02f, -1.08998999e-01f, -5.83138056e-02f, -4.65604216e-02f, 8.00569579e-02f, 4.58819531e-02f, -5.45373857e-02f,
  6.37176037e-02f, 1.40743941e-01f, 5.07359616e-02f, 1.13937864e-02f, -5.14860637e-03f, 1.17565580e-02f, -3.35588865e-02f, -3.27496193e-02f, -1.26988024e-01f, 1.58371091e-01f,
  -3.51736061e-02f, -7.61415362e-02f, -1.08873181e-01f, 6.43128231e-02f, 1.09200560e-01f, 5.71611002e-02f, -9.69677493e-02f, 3.20419781e-02f, 4.41098921e-02f, 1.81502476e-02f,
  -3.46397124e-02f, 2.06849426e-02f, -5.03112860e-02f, 2.26292051e-02f, 2.26067230e-02f, -1.69380885e-02f, 1.41819976e-02f, 1.66322663e-02f, -5.22100218e-02f, 2.26844358e-03f,
  1.12887956e-01f, 6.84740618e-02f, -7.89887235e-02f, -1.34091526e-01f, -3.68437618e-02f, 7.80700371e-02f, 6.01135865e-02f, 1.60121801e-03f, -6.32582381e-02f, 3.42605077e-02f,
  1.00133017e-01f, -4.85753976e-02f, 8.49595442e-02f, 9.72827710e-03f, -1.42749220e-01f, 1.47541508e-01f, 5.52434549e-02f, -1.65311500e-01f, 1.16033629e-02f, 8.20706189e-02f,
  4.39005494e-02f, 4.80370447e-02f, -7.28847980e-02f, -3.22208069e-02f, -3.14386338e-02f, 5.30333817e-02f, 4.40423265e-02f, 1.85910426e-02f, 2.03663320e-03f, -5.80553934e-02f,
  4.07878757e-01f, -3.94191295e-01f, -1.18408181e-01f, 2.02951670e-01f, 5.61992414e-02f, -1.44426420e-01f, 2.70970136e-01f, -1.77511141e-01f, 3.45694691e-01f, -3.52468967e-01f,
  -6.07620813e-02f, -9.31870416e-02f, 9.67345461e-02f, -2.49835253e-01f, 3.96622866e-01f, 1.34626001e-01f, 2.98173595e-02f, -3.98024917e-02f, 1.00472338e-01f, 1.82266533e-02f,
  5.86905330e-02f, -1.36518911e-01f, -5.11780195e-02f, -3.24922979e-01f, -1.25019535e-01f, -2.18806416e-01f, -1.38689354e-01f, 1.48989889e-03f, -3.23745161e-01f, -4.60129678e-02f,
  -4.06707413e-02f, 5.24839200e-02f, -5.20032756e-02f, 5.19695207e-02f, 2.72006448e-02f, 3.94468047e-02f, -7.29321390e-02f, -4.88496153e-03f, 1.84952483e-01f, 4.52593304e-02f,
  -3.28851603e-02f, -1.55617623e-03f, -4.94721048e-02f, -1.36501221e-02f, 1.52292907e-01f, 5.21159694e-02f, -3.08916792e-02f, -4.81815077e-02f, -4.71060537e-02f, 1.09049045e-02f,
  2.94732619e-02f, 8.11019167e-03f, 1.17456637e-01f, -1.70310159e-04f, 2.27576587e-02f, -1.47470552e-02f, -5.32795116e-02f, 1.33888433e-02f, -6.80995807e-02f, 5.05709797e-02f,
  -1.03718899e-01f, 7.97788054e-02f, 7.32665583e-02f, -7.83491135e-03f, 6.73119053e-02f, 7.45710954e-02f, 2.91405674e-02f, -1.99411493e-02f, 4.88737598e-02f, -1.44355511e-02f,
  6.58620149e-02f, 8.09515174e-03f, 1.34736719e-02f, 2.30259495e-03f, 1.25440545e-02f, -6.52032048e-02f, 1.53865479e-02f, -1.46399498e-01f, 4.54627872e-02f, -3.58319730e-02f,
  -7.78679401e-02f, -1.54154724e-03f, 1.03957504e-01f, 2.46784817e-02f, -7.75102060e-04f, 8.84119770e-04f, -3.85536649e-03f, 3.16972025e-02f, -3.39206792e-02f, 1.25085250e-01f,
  2.93438733e-02f, -1.64905265e-01f, -1.04757315e-02f, -2.32937858e-02f, 1.54017489e-02f, -3.13977785e-02f, -6.36855559e-03f, -7.79931098e-02f, 2.76249126e-02f, -4.47429530e-02f,
  -1.55725941e-01f, 8.13137442e-02f, -2.63030566e-02f, 9.53721232e-04f, 1.14510342e-01f, -5.13152545e-03f, -2.97131781e-02f, -1.03725880e-01f, 5.49529912e-03f, -7.94037580e-02f,
  -4.55950350e-02f, 9.60729346e-02f, 1.22125201e-01f, 7.35886469e-02f, -6.47605807e-02f, 5.44089265e-02f, -4.77847680e-02f, -4.58728671e-02f, 8.13771933e-02f, 1.08554877e-01f,
  -1.65583313e-01f, -1.16282620e-01f, -1.89170130e-02f, -9.22257528e-02f, 6.66243732e-02f, 1.09477721e-01f, -2.04176772e-02f, 9.13342535e-02f, -1.92022756e-01f, 1.00859486e-01f,
  9.66198090e-03f, -6.34480491e-02f, -3.15891951e-02f, -2.62418121e-01f, -2.51128525e-01f, -2.96180725e-01f, -1.01077594e-01f, -2.39165314e-02f, -1.34541735e-01f, 1.80481628e-01f,
  8.91636610e-02f, -2.99363788e-02f, 3.46335582e-02f, 2.63186365e-01f, 4.23990982e-03f, 2.96115279e-01f, 1.99010134e-01f, 8.43951181e-02f, 1.78412557e-01f, -3.24416719e-03f,
  -1.56747460e-01f, -1.49710730e-01f, -1.82791762e-02f, -8.23307410e-02f, 5.92667237e-02f, 8.97418484e-02f, 5.88369630e-02f, -2.78937072e-02f, -1.46520674e-01f, -1.13039121e-01f,
  8.87769237e-02f, 5.10504516e-03f, 7.98327383e-03f, -9.90898348e-03f, -3.11313439e-02f, -5.84292039e-02f, -1.69311464e-02f, -5.62506206e-02f, -1.45812869e-01f, 4.86164242e-02f,
  -1.97758302e-02f, 9.58463084e-03f, -3.49879786e-02f, 2.18297802e-02f, 1.18768007e-01f, 2.80996822e-02f, 1.23567544e-01f, 2.02569172e-01f, -7.90012553e-02f, 6.59861937e-02f,
  1.05130821e-01f, 6.80384040e-02f, -3.40655595e-02f, -1.57906398e-01f, -8.57367218e-02f, -5.13010547e-02f, -1.50909007e-01f, -3.69913802e-02f, -8.19778442e-02f, -4.43841182e-02f,
  2.37194356e-03f, -3.40731069e-02f, -2.01500580e-01f, 2.11058147e-02f, 7.19278008e-02f, 2.09577288e-03f, 1.93144903e-02f, 1.33677840e-01f, 1.04118533e-01f, 4.64489534e-02f,
  -1.53717980e-01f, -1.46477614e-02f, 3.96110937e-02f, 3.68681736e-02f, -1.25786543e-01f, 1.46689698e-01f, 2.30855048e-02f, 1.97983496e-02f, -3.85458916e-02f, 1.02560617e-01f,
  1.10949516e-01f, 1.73488975e-01f, -2.68901046e-02f, -8.71262103e-02f, -1.29410952e-01f, -1.24235013e-02f, -1.03501037e-01f, -2.15481240e-02f, 4.54274602e-02f, -1.52755037e-01f,
  1.91050246e-01f, 6.78464398e-02f, -1.15114823e-02f, -6.60162643e-02f, 1.00178868e-02f, 1.01836316e-01f, 3.24879065e-02f, 1.46683119e-02f, 6.16698526e-02f, 1.33361503e-01f,
  8.11070278e-02f, 4.91959937e-02f, -2.06102468e-02f, 5.75236902e-02f, 1.18060969e-01f, 9.29866508e-02f, 1.18202344e-01f, 1.13859087e-01f, -5.58083039e-03f, -3.18003185e-02f,
  3.82551625e-02f, -1.25496328e-01f, -1.07629061e-01f, -1.25094987e-02f, -1.27105922e-01f, -1.48377642e-01f, -1.18486136e-01f, -4.61593494e-02f, 1.58962548e-01f, -1.77494571e-01f,
  -1.52333394e-01f, 5.31948656e-02f, 7.74323419e-02f, -2.97231257e-01f, 2.36547127e-01f, 2.08334148e-01f, -2.60404106e-02f, -2.41042785e-02f, 1.00100219e-01f, -1.57126546e-01f,
  -2.04475835e-01f, -3.62683505e-01f, -1.15996130e-01f, -2.16563195e-01f, -2.56320834e-01f, -1.61472216e-01f, -7.73596689e-02f, -1.23570852e-01f, -2.18476534e-01f, 4.37065586e-03f,
  -1.58954374e-02f, -1.46362707e-02f, -2.13861056e-02f, 6.22555427e-02f, 5.46882525e-02f, -2.43252479e-02f, -6.86297864e-02f, -2.42483485e-02f, 1.23593144e-01f, 7.29553029e-02f,
  -1.00051584e-02f, 2.81981695e-02f, -2.75115669e-02f, -5.95524833e-02f, -4.95486818e-02f, -5.19738011e-02f, 1.07989468e-01f, 1.35456741e-01f, -7.79764028e-04f, -6.21840246e-02f,
  -2.77811103e-02f, 2.74488865e-03f, 6.60571605e-02f, 1.37387142e-01f, 8.37403536e-02f, 3.47218402e-02f, 6.67490140e-02f, 1.09287940e-01f, 4.91900146e-02f, 4.65819202e-02f,
  -2.45341398e-02f, 2.13171658e-03f, 9.51153412e-03f, -9.58418250e-02f, -3.01467697e-03f, 2.91066971e-02f, -3.92478891e-02f, 6.06919220e-03f, 7.30842203e-02f, -5.98365925e-02f,
  5.35159893e-02f, -4.58847452e-03f, 2.29253080e-02f, 1.04309851e-02f, -1.03859812e-01f, -7.63305277e-02f, -1.15122311e-02f, 2.69932114e-03f, -3.56784426e-02f, 1.56747065e-02f,
  -5.22380956e-02f, 4.53062728e-02f, 7.87492543e-02f, -5.21271899e-02f, -5.22300564e-02f, 1.26753785e-02f, -5.64521784e-03f, 1.35334879e-02f, 6.43290067e-03f, 9.83973444e-02f,
  2.81223655e-02f, 1.05996216e-02f, -4.77492623e-03f, 8.69345441e-02f, 1.21453203e-01f, 4.27435562e-02f, -1.24888033e-01f, -4.63967919e-02f, 5.58122694e-02f, -4.18312885e-02f,
  -1.01742178e-01f, 5.38132787e-02f, 6.14514090e-02f, -7.31814420e-03f, 5.64635098e-02f, -7.09175915e-02f, -1.52705843e-02f, 1.42615840e-01f, 7.89700970e-02f, 1.68800354e-02f,
  1.44749526e-02f, 6.67617247e-02f, 1.09605372e-01f, 1.93951335e-02f, 2.90984847e-02f, -2.23448183e-02f, 1.44192120e-02f, 2.05955077e-02f, 1.24303728e-01f, 8.88022184e-02f,
  2.78685600e-01f, -3.35578285e-02f, -2.36028969e-01f, -1.21199779e-01f, 2.00442910e-01f, 4.27618116e-01f, 1.03348196e-01f, -2.55158041e-02f, -3.00417338e-02f, 1.73976779e-01f,
  -1.04940340e-01f, 7.75323249e-03f, -2.48179123e-01f, 7.18082562e-02f, 3.08054596e-01f, -2.41348911e-02f, 1.91590190e-01f, 1.09945819e-01f, -7.69644380e-02f, -1.58736501e-02f,
  3.11210845e-02f, 3.28675479e-01f, -3.12784642e-01f, 1.90995499e-01f, 8.04858282e-02f, -1.07496679e-01f, -2.00911332e-02f, -1.00001000e-01f, -3.67115950e-03f, 1.22951336e-01f,
  -1.56846587e-02f, -3.19290068e-03f, -1.82682625e-03f, -1.30968792e-02f, -1.75948311e-02f, 7.22541139e-02f, 5.33151366e-02f, -1.10920407e-02f, -5.98874502e-03f, -1.44835815e-01f,
  8.65933951e-03f, -2.22063176e-02f, 5.34209646e-02f, -4.49677987e-04f, -4.26775552e-02f, -5.13924770e-02f, -1.39372677e-01f, -1.25901818e-01f, -1.13000862e-01f, -6.64999802e-03f,
  -1.38131469e-01f, -2.38228124e-02f, -7.74085447e-02f, -6.09987155e-02f, -2.82255225e-02f, -8.73647779e-02f, -1.55728543e-03f, -1.54601052e-01f, -2.82800030e-02f, 6.23495840e-02f,
  2.02118587e-02f, 1.33489490e-01f, 8.33592564e-02f, -1.03926376e-01f, 3.39978300e-02f, 3.27855013e-02f, 1.86424404e-02f, -8.67389422e-03f, 8.03844258e-02f, 3.73894162e-02f,
  -3.51607287e-03f, -3.67909707e-02f, -4.90545928e-02f, 1.18556671e-01f, 9.75916088e-02f, 2.04583686e-02f, 3.52803729e-02f, 1.43510839e-02f, -4.91263047e-02f, -7.06174299e-02f,
  4.47834432e-02f, 1.30600840e-01f, -2.69323625e-02f, -1.26395062e-01f, 9.98393283e-04f, -4.30420972e-02f, 1.43574491e-01f, -8.20687786e-03f, -1.64663717e-01f, -2.24671345e-02f,
  6.63386136e-02f, 2.45484084e-01f, -2.64692353e-03f, -7.08562657e-02f, -8.52073133e-02f, 1.56422853e-01f, 1.09735310e-01f, 6.50928095e-02f, 6.68685809e-02f, 7.52815530e-02f,
  1.76081271e-03f, -5.58633730e-02f, 1.34064376e-01f, -9.41556692e-02f, -8.19187984e-02f, 6.72538728e-02f, 5.28173894e-03f, -5.33549897e-02f, -3.10252123e-02f, 2.07420997e-02f,
  -5.22327051e-02f, 1.54365525e-02f, -3.31288949e-02f, 1.06549822e-01f, -2.25714291e-03f, -5.93046285e-02f, 4.97794300e-02f, -1.47859097e-01f, -5.08460030e-02f, -1.02518648e-01f,
  -2.56320924e-01f, 1.25353903e-01f, 1.50253087e-01f, -1.15273915e-01f, 3.13229889e-01f, 1.53840497e-01f, 1.32707357e-01f, 2.35952929e-01f, 2.80299246e-01f, -1.26082420e-01f,
  -2.21001446e-01f, -9.85144004e-02f, 2.53104307e-02f, -1.40796259e-01f, -1.03665262e-01f, -5.38100079e-02f, -3.34305204e-02f, -5.62156737e-02f, 3.21609408e-01f, -8.63784999e-02f,
  -1.10401949e-02f, -6.07858859e-02f, -7.68603608e-02f, 1.97485521e-01f, 2.06798136e-01f, 6.86361268e-02f, -2.01126590e-01f, 1.90667540e-01f, -1.95387527e-01f, 7.45178536e-02f,
  -2.78471913e-02f, 9.13357586e-02f, 1.24481499e-01f, 5.81993088e-02f, -1.02226235e-01f, -4.05459739e-02f, -2.47596875e-02f, 1.43362284e-01f, 9.04342979e-02f, -1.09725175e-02f,
  -1.13052212e-01f, 1.58308763e-02f, 1.19357025e-02f, 2.44703889e-02f, 1.37784556e-01f, 1.20271817e-01f, 1.23239338e-01f, -2.94403769e-02f, 1.21694915e-01f, 1.02194265e-01f,
  -2.95495335e-02f, -1.49712255e-02f, 1.65639408e-02f, 1.46269146e-02f, -2.49253549e-02f, 2.98849158e-02f, 3.24137807e-02f, -6.18794933e-02f, -1.42891556e-02f, -7.16074109e-02f,
  2.15003565e-01f, 8.07180479e-02f, 3.14795375e-02f, -1.05148487e-01f, 2.09120661e-02f, -1.75691675e-02f, -1.14748754e-01f, -1.38444677e-01f, -4.45359275e-02f, -7.93692935e-03f,
  -6.67485520e-02f, -6.00494146e-02f, 3.99806835e-02f, 2.96222605e-02f, -7.37818074e-04f, 2.97904154e-03f, -9.56188291e-02f, 3.20604555e-02f, -2.11584661e-02f, -4.42909030e-03f,
  8.08560327e-02f, -5.33456579e-02f, -3.14852386e-03f, -2.19429052e-03f, 4.41681407e-03f, 1.78114697e-02f, 6.05264194e-02f, 7.95447156e-02f, -9.99731123e-02f, -3.49802431e-03f,
  -2.47955948e-01f, -2.19638601e-01f, 5.96639775e-02f, 3.51548716e-02f, -2.31476631e-02f, -7.39374906e-02f, 8.93486440e-02f, 1.75814389e-03f, -9.61618870e-03f, 1.14296833e-02f,
  3.43839116e-02f, -1.06462598e-01f, -1.31573111e-01f, -4.61983271e-02f, -3.56838070e-02f, -8.23854133e-02f, -6.12124093e-02f, -1.34491906e-01f, -1.14894256e-01f, 4.71198261e-02f,
  -6.81009516e-02f, -6.68132901e-02f, -2.46384796e-02f, 5.10987751e-02f, -5.28651252e-02f, -7.27392957e-02f, -1.67247981e-01f, 2.41630208e-02f, -1.07282586e-02f, -1.10935561e-01f,
  2.17863634e-01f, -2.77722012e-02f, -9.58210081e-02f, 1.48195475e-01f, 5.38158640e-02f, 3.21977288e-01f, 4.47484344e-01f, -6.45423532e-02f, 5.25222570e-02f, 8.70974436e-02f,
  -9.10554081e-02f, 1.78856537e-01f, 1.76001955e-02f, 1.76932499e-01f, 3.82203072e-01f, 2.01776281e-01f, 1.47194043e-01f, 2.77303129e-01f, -6.95372447e-02f, 2.76259836e-02f,
  -2.43529826e-02f, 2.15229586e-01f, -9.81106833e-02f, -1.16977476e-01f, 7.97267556e-02f, -1.66840985e-01f, -1.08120225e-01f, -3.67849395e-02f, -5.30266352e-02f, 3.76286581e-02f,
  -9.70492885e-02f, -9.15541649e-02f, -9.33231041e-02f, -5.14196567e-02f, 8.23921189e-02f, 1.41952010e-02f, 3.22694294e-02f, 2.45392814e-01f, -7.17787296e-02f, -2.98421010e-02f,
  4.81376909e-02f, 2.48651318e-02f, 2.54280493e-02f, -1.50612760e-02f, 3.26020122e-02f, -6.10309094e-02f, -4.08477001e-02f, -1.09171219e-01f, -5.42740338e-02f, -3.33074975e-04f,
  -1.05162170e-02f, -6.71285763e-02f, -6.17853180e-02f, 6.13491610e-02f, -1.03587829e-01f, 3.93698700e-02f, 8.75962898e-02f, 8.40897337e-02f, -6.52265036e-03f, 8.95805806e-02f,
  3.59703936e-02f, 4.31350358e-02f, 4.60556289e-03f, -2.97631789e-02f, 1.04790166e-01f, 2.24876478e-02f, 4.81058136e-02f, 4.64094244e-02f, -9.46917832e-02f, 9.02496502e-02f,
  -4.56706211e-02f, 2.38006245e-02f, -1.55122634e-02f, 5.11616329e-03f, 5.99933453e-02f, 3.56505811e-02f, 1.14204943e-01f, -5.13914078e-02f, -1.88613757e-02f, 1.76987946e-02f,
  6.76450506e-02f, 8.48017856e-02f, -4.44993414e-02f, -1.12229064e-02f, 1.13455370e-01f, -4.49106134e-02f, -1.91756599e-02f, -1.20956972e-01f, -5.12062460e-02f, -4.86513637e-02f,
  1.82493031e-02f, 5.26750535e-02f, -1.20182209e-01f, -1.34709656e-01f, 6.70443177e-02f, -9.55675845e-04f, 5.04377745e-02f, 6.65445775e-02f, -2.03556996e-02f, 8.36769193e-02f,
  -4.31140289e-02f, 2.73650549e-02f, 1.49553996e-02f, 1.63262815e-03f, -1.04390746e-02f, 5.34238964e-02f, 1.05286397e-01f, -7.66648650e-02f, 6.93136975e-02f, -5.16362861e-02f,
  -5.11094881e-03f, 8.14071149e-02f, -2.45341118e-02f, 5.58335930e-02f, 3.42371278e-02f, 1.28836418e-02f, 9.98480394e-02f, -6.08939491e-02f, 1.20040402e-02f, -1.41192051e-02f,
  2.14134961e-01f, -2.25764945e-01f, -8.53522643e-02f, -1.01507585e-02f, 2.64497280e-01f, 1.69128582e-01f, 1.31295756e-01f, 1.41903326e-01f, 3.94109264e-02f, -1.48998171e-01f,
  1.41298948e-02f, -4.68899548e-01f, -1.81925550e-01f, -2.76271820e-01f, -8.77043977e-03f, -2.46816874e-01f, 3.12256925e-02f, -1.60973266e-01f, 8.62153843e-02f, 4.16311622e-02f,
  8.89740065e-02f, 1.79159179e-01f, -3.98933925e-02f, 1.69661373e-01f, 2.53517419e-01f, 2.78260469e-01f, 1.79998681e-01f, 5.29904962e-02f, -6.18441962e-03f, -1.38389170e-01f,
  -4.10560407e-02f, -1.33031467e-02f, 1.31921262e-01f, 8.73310640e-02f, 1.74260482e-01f, -3.13581154e-02f, -9.96209905e-02f, 2.51202844e-02f, 7.50807747e-02f, -3.13676484e-02f,
  -1.10400997e-01f, -1.63168997e-01f, -4.46226113e-02f, 1.67482883e-01f, 1.57672986e-01f, 1.10453725e-01f, -6.57545328e-02f, 8.34247172e-02f, -1.98615730e-01f, -5.07076159e-02f,
  -1.13896348e-01f, -5.25667854e-02f, -1.24281675e-01f, -8.70432481e-02f, -9.03840959e-02f, -2.70207599e-02f, 1.19502414e-02f, -8.33825693e-02f, -3.68902162e-02f, -1.14143625e-01f,
  -6.14016056e-02f, 1.13781571e-01f, 1.31965354e-01f, 6.40367866e-02f, 8.34982321e-02f, 5.91858327e-02f, 3.14107873e-02f, -3.65961678e-02f, 5.12772650e-02f, -6.94795772e-02f,
  6.69143274e-02f, 1.02291957e-01f, -6.06935695e-02f, 1.16809301e-01f, 6.75300583e-02f, 1.63992420e-02f, -9.48079024e-03f, -1.08710818e-01f, 3.18598673e-02f, 2.01976672e-02f,
  -4.06463146e-02f, 7.33115338e-03f, 3.65123991e-03f, -7.40085840e-02f, -2.20978521e-02f, 1.44143701e-01f, 1.74993072e-02f, 2.04002224e-02f, 1.53843507e-01f, -7.59953409e-02f,
  2.95391958e-02f, -7.73028284e-03f, 5.83891012e-02f, -1.14424117e-02f, -1.63638331e-02f, 1.53624788e-02f, 4.21860553e-02f, -6.35350198e-02f, 3.94337904e-03f, 4.19367515e-02f,
  9.59959999e-02f, 2.47871168e-02f, 2.96206921e-02f, 1.61397159e-01f, 1.46129159e-02f, 1.58175483e-01f, -1.51499376e-01f, 2.79501081e-02f, -1.69703230e-01f, 3.21908183e-02f,
  5.07491864e-02f, 1.83259845e-01f, -2.02421308e-01f, 6.75399154e-02f, -4.47683819e-02f, -1.45377994e-01f, 1.58293515e-01f, -3.76036838e-02f, -1.35116786e-01f, -1.37205884e-01f,
  3.80114079e-01f, -3.10327888e-01f, 8.78489837e-02f, 2.36507177e-01f, 1.65225804e-01f, 1.99761778e-01f, 3.73851269e-01f, -1.74996912e-01f, 1.36626989e-01f, -2.29441732e-01f,
  -5.40734529e-02f, 3.45326550e-02f, 3.71436663e-02f, 6.22860268e-02f, 4.01908129e-01f, 5.62283285e-02f, 2.30667710e-01f, 1.44530341e-01f, 8.20183530e-02f, 7.23499432e-02f,
  1.37736395e-01f, 6.02696203e-02f, 1.19010806e-02f, -3.18662047e-01f, 4.87580560e-02f, -1.52292147e-01f, -1.55358031e-01f, 8.38225633e-02f, -1.55961469e-01f, 6.63186535e-02f,
  4.90968414e-02f, -3.15691382e-02f, 1.96332932e-02f, 6.65948447e-03f, 4.59903991e-03f, 6.02503680e-02f, 1.08190356e-02f, 7.25193694e-02f, 1.42156035e-01f, -1.06175065e-01f,
  2.75866836e-02f, 2.68619545e-02f, -9.48858336e-02f, 8.61263350e-02f, 1.77904651e-01f, -2.43885424e-02f, -7.35743493e-02f, -1.05474107e-01f, -9.02627707e-02f, 7.58896545e-02f,
  1.71050970e-02f, 6.79422030e-03f, 7.52574950e-02f, -1.13143899e-01f, -4.37086932e-02f, -2.43510492e-02f, 1.25586810e-02f, -6.96448889e-03f, 1.99928209e-02f, 5.15410081e-02f,
  -9.99109671e-02f, 1.21425204e-01f, -3.57698975e-03f, 4.98177744e-02f, 1.13381281e-01f, 2.81507876e-02f, 1.23431534e-01f, -1.06238178e-03f, 4.03306745e-02f, 1.27721280e-01f,
  1.03445016e-01f, 6.83521628e-02f, 1.13535738e-02f, 1.11682072e-01f, 6.00344613e-02f, -5.34024164e-02f, -3.14913690e-02f, 3.77770443e-03f, 7.90610313e-02f, 2.53305379e-02f,
  -9.45207849e-02f, 4.64141667e-02f, -1.50903536e-03f, -1.23620383e-01f, -9.04892664e-03f, 9.06781666e-03f, -9.67571139e-03f, -2.15233099e-02f, -1.29996061e-01f, 1.76670849e-01f,
  7.02628270e-02f, -1.31313816e-01f, 2.47760918e-02f, -2.14192178e-02f, 1.71632171e-02f, -5.17965807e-03f, 1.20091379e-01f, -1.10352986e-01f, 6.79176375e-02f, -1.09202586e-01f,
  -5.75070977e-02f, 6.62316233e-02f, -3.02792341e-02f, -1.27068674e-02f, 8.24877918e-02f, -8.86429846e-02f, 2.25808285e-02f, -2.69652195e-02f, -6.29607588e-02f, -9.14242044e-02f,
  -2.61753295e-02f, 1.66953504e-02f, 1.41106486e-01f, 1.48714157e-02f, -9.12742317e-02f, -3.81488097e-03f, -6.75285831e-02f, -5.12617379e-02f, 1.69364884e-02f, 9.93131921e-02f,
  6.78211078e-02f, 3.70453626e-01f, 2.57624805e-01f, 9.32648480e-02f, 1.07252985e-01f, 2.30373383e-01f, 7.60386959e-02f, 7.68469200e-02f, 3.05352658e-01f, 1.65900126e-01f,
  -1.57713115e-01f, 2.70591408e-01f, -2.00306982e-01f, 9.85188261e-02f, -1.14270248e-01f, -2.51119696e-02f, 8.00036564e-02f, 5.80369048e-02f, -8.66100285e-03f, -6.24535652e-03f,
  -4.41051573e-02f, -2.10308403e-01f, -2.55459189e-01f, -1.62185147e-01f, 1.15544394e-01f, 2.02145297e-02f, -2.60560453e-01f, -5.04040159e-02f, 7.69049972e-02f, 6.89590946e-02f,
  6.83866255e-03f, -4.40837331e-02f, 1.45986408e-01f, 9.62075591e-02f, -4.12451401e-02f, -1.06858931e-01f, 2.29321737e-02f, -5.46802096e-02f, -4.18650061e-02f, 9.28534791e-02f,
  3.87558900e-02f, 1.21691667e-01f, -8.96858517e-03f, -6.39512688e-02f, 2.68738326e-02f, 7.16630444e-02f, 5.91735952e-02f, 1.14874892e-01f, 1.24540955e-01f, 2.01057456e-02f,
  1.31174326e-01f, 1.10240407e-01f, 1.24186790e-02f, -3.10175493e-02f, 1.35006886e-02f, 1.12956502e-01f, 1.46885678e-01f, 1.71988066e-02f, 5.25266640e-02f, 1.57454401e-01f,
  7.98046365e-02f, 8.99302810e-02f, 1.25014512e-02f, 4.92954552e-02f, -1.21283345e-02f, -6.51806220e-02f, -1.47124995e-02f, -9.71043184e-02f, 3.40847820e-02f, 4.92781401e-02f,
  2.19538100e-02f, 1.21909156e-01f, 1.09357879e-01f, 5.23218103e-02f, -3.20553929e-02f, 1.27358645e-01f, 3.07324566e-02f, 5.67805581e-02f, -3.48633379e-02f, 2.38114260e-02f,
  -4.21853922e-02f, -7.27560073e-02f, -5.91484010e-02f, -1.16432182e-01f, -2.52109095e-02f, 3.62966768e-02f, 8.54789540e-02f, -6.17051637e-03f, 3.07971109e-02f, -2.50653923e-01f,
  5.00303917e-02f, 7.98557401e-02f, 8.40544775e-02f, 3.86693031e-02f, -1.04183152e-01f, -2.00853813e-02f, -2.67635565e-02f, 2.36483496e-02f, -9.64197423e-03f, 5.02608754e-02f,
  -5.19132335e-03f, 7.60575607e-02f, 1.04687862e-01f, -9.49432626e-02f, -8.31169486e-02f, 3.78202274e-02f, 5.64126484e-02f, -8.11534896e-02f, -4.75409701e-02f, -1.13204466e-02f,
  8.22088402e-03f, -4.31755520e-02f, 1.78768337e-02f, 4.62338328e-03f, 4.11062874e-02f, 3.84797230e-02f, -6.40835566e-03f, 8.21978902e-04f, -5.62525503e-02f, -1.84066724e-02f,
  3.53309751e-01f, 1.60004482e-01f, 7.36855939e-02f, -6.16094768e-02f, -2.57510412e-02f, 8.97936374e-02f, -3.87884080e-02f, -1.13782488e-01f, -2.88451433e-01f, 1.15295060e-01f,
  -1.45064950e-01f, 3.15883189e-01f, -1.88115194e-01f, 5.95858395e-02f, -2.95566529e-01f, -2.67154127e-01f, -7.24740699e-02f, 3.26072685e-02f, -1.32407874e-01f, -1.30196521e-02f,
  -5.81010282e-02f, -4.38733660e-02f, -2.12668106e-01f, 7.29913637e-02f, 2.87720323e-01f, 2.14956090e-01f, -9.13608912e-03f, 1.47937238e-02f, 2.54965186e-01f, -2.16228887e-03f,
  4.21538502e-02f, -3.99206951e-02f, -9.06834099e-03f, 6.31260872e-02f, -5.58837801e-02f, 1.34315804e-01f, 1.31358147e-01f, -1.27025396e-02f, -4.56793047e-03f, -5.03013805e-02f,
  6.05572797e-02f, 5.33759408e-02f, -1.11853899e-02f, -9.45356116e-03f, 8.89966637e-02f, 4.59306873e-02f, -3.06173433e-02f, -1.84298661e-02f, 2.69868504e-02f, 9.18401182e-02f,
  -9.19101387e-03f, 9.25807953e-02f, 4.64289561e-02f, -1.92454495e-02f, -1.08911991e-01f, -2.24392358e-02f, -2.51883399e-02f, 2.61780526e-02f, 1.02430478e-01f, 4.55886163e-02f,
  2.15370283e-02f, 8.14219043e-02f, 8.94723237e-02f, 1.66084175e-03f, -4.88706455e-02f, -7.21659735e-02f, 1.70691926e-02f, -3.10014319e-02f, -1.11830644e-02f, 1.87245514e-02f,
  1.60282236e-02f, 8.44609290e-02f, 6.24499135e-02f, -3.09124868e-02f, 7.23048747e-02f, 1.33128073e-02f, -1.41394082e-02f, 5.60709424e-02f, -9.17192027e-02f, -6.69011497e-04f,
  1.43019930e-02f, 3.24288569e-02f, -5.73431626e-02f, 5.82343414e-02f, -2.67563201e-02f, -8.38045403e-02f, 4.27624695e-02f, 5.38611226e-02f, -1.41173974e-01f, -6.12904057e-02f,
  -1.43583626e-01f, -1.48927078e-01f, -1.09107532e-01f, 2.53451616e-02f, -3.42210196e-02f, 4.30082008e-02f, 7.54698552e-03f, 3.54005806e-02f, -7.26480037e-02f, 5.65790869e-02f,
  5.22149988e-02f, -9.87004861e-03f, 1.22670688e-01f, -3.68806385e-02f, -1.06291071e-01f, -1.38929278e-01f, 6.95323274e-02f, -5.82594126e-02f, -9.36141089e-02f, 5.31375781e-02f,
  2.30310597e-02f, 4.81347293e-02f, -2.01348327e-02f, -2.21145945e-03f, -6.57981634e-02f, 8.98818523e-02f, -3.41145247e-02f, -1.65057217e-03f, -1.39714442e-02f, -3.84914167e-02f,
  1.13181770e-01f, -1.01856127e-01f, -2.36493394e-01f, -5.89537732e-02f, 1.54958576e-01f, 6.32156432e-02f, -2.44962528e-01f, 7.34542161e-02f, -2.80734330e-01f, 6.97144940e-02f,
  5.22883050e-02f, -1.33651078e-01f, -2.36584559e-01f, 1.91928044e-01f, 2.73935258e-01f, -2.21843496e-01f, 3.37847382e-01f, 3.89747173e-02f, -1.06944799e-01f, 1.76312074e-01f,
  4.61567901e-02f, 4.07009959e-01f, -3.29231769e-02f, 2.80006886e-01f, 1.75722390e-01f, 6.95136264e-02f, 2.70133466e-01f, -8.98101702e-02f, 2.03175783e-01f, 7.30238259e-02f,
  -6.39461260e-03f, 2.30819862e-02f, -6.52516112e-02f, -1.37641445e-01f, 1.16573013e-01f, 1.53075056e-02f, -1.07342107e-02f, 5.64900739e-03f, -3.34339105e-02f, -7.52098626e-03f,
  -5.60559668e-02f, 7.72533789e-02f, 2.14418136e-02f, 1.27835140e-01f, 3.03359125e-02f, 9.67723504e-03f, -1.09325960e-01f, -6.02540793e-03f, -8.63042623e-02f, -8.33747312e-02f,
  -1.20179988e-01f, 2.03114729e-02f, 7.39260018e-02f, 1.60764717e-02f, -7.86967427e-02f, 1.46736437e-03f, -9.90324020e-02f, -9.60536599e-02f, 5.27260862e-02f, 7.27307051e-04f,
  7.89186731e-02f, -4.17852513e-02f, -2.38434635e-02f, -1.59521312e-01f, -1.90731511e-02f, -2.14750525e-02f, 8.79904851e-02f, 8.26841742e-02f, -1.87101066e-02f, 3.96862626e-02f,
  5.12784049e-02f, 3.79649689e-03f, -7.20888823e-02f, 9.01652724e-02f, 4.86726500e-02f, 4.61447649e-02f, -9.41467211e-02f, -6.22997731e-02f, -5.50836585e-02f, -2.56393719e-02f,
  9.78258532e-03f, 3.54843959e-02f, -1.29236147e-01f, -2.80114692e-02f, 5.06116785e-02f, -4.21797484e-02f, -8.13331455e-04f, -1.02154277e-01f, -7.14290887e-02f, 1.02220297e-01f,
  1.30339712e-01f, 1.79460600e-01f, -2.91213300e-02f, 2.32680347e-02f, -3.67556587e-02f, 9.46921632e-02f, 1.91505738e-02f, 4.25770916e-02f, 8.65049288e-02f, 5.37975580e-02f,
  7.29667544e-02f, -8.80905893e-03f, 1.23962864e-01f, 1.06193058e-01f, 7.50419311e-03f, -6.01446480e-02f, -7.35406950e-03f, 7.84114876e-04f, -1.99172478e-02f, 4.73190099e-02f,
  1.57711655e-02f, 7.25231320e-02f, 1.79677189e-03f, 3.79846171e-02f, 1.04141897e-02f, -4.29854542e-02f, 7.91323781e-02f, -4.45472077e-02f, 5.94816618e-02f, -9.96551290e-02f,
  -1.95116848e-01f, 5.05490266e-02f, 3.45255524e-01f, -8.04617181e-02f, -7.99104050e-02f, 3.36686462e-01f, 1.81365758e-01f, 1.07568301e-01f, 2.69787610e-01f, -1.69389918e-01f,
  -2.21385419e-01f, -1.27795041e-01f, 1.31527230e-01f, -2.03130051e-01f, 3.95574421e-01f, 3.29435974e-01f, 7.44960383e-02f, 4.91969101e-02f, 6.90106079e-02f, -1.78766653e-01f,
  -4.45170775e-02f, -2.59810328e-01f, -3.22434632e-03f, -2.60806054e-01f, -2.61401027e-01f, -9.34363902e-02f, -3.59825104e-01f, 1.26230851e-01f, -2.40848735e-01f, 4.71309610e-02f,
  -9.25395563e-02f, -1.44092545e-01f, -1.98195010e-01f, -3.66450078e-03f, -5.73834963e-02f, -1.39509374e-02f, 4.72552255e-02f, -1.08263735e-02f, -2.42443234e-02f, 1.78600159e-02f,
  -5.40530458e-02f, -3.53583284e-02f, -2.76003219e-02f, 3.45151760e-02f, 7.83224329e-02f, -4.87764413e-03f, 1.02970377e-02f, -3.52719165e-02f, -4.77411039e-02f, 4.87653688e-02f,
  3.24184299e-02f, 6.19649738e-02f, 1.05977684e-01f, -1.69005170e-02f, -2.04485487e-02f, -4.83170263e-02f, 1.44732535e-01f, -4.73590977e-02f, -3.20379958e-02f, 3.92948948e-02f,
  4.35834564e-02f, 2.09877361e-02f, -8.73131156e-02f, -1.59256365e-02f, -9.77223217e-02f, -1.73924230e-02f, 1.88518669e-02f, -7.55392388e-02f, 6.91819414e-02f, -4.67915758e-02f,
  -4.81227748e-02f, 1.65769048e-02f, 1.98003083e-01f, -1.47393171e-03f, -4.98968437e-02f, -2.26513203e-02f, 1.99973714e-02f, -4.59988937e-02f, 2.27101203e-02f, -4.31041569e-02f,
  -1.03271361e-02f, 1.41717596e-02f, -5.44082597e-02f, 4.85279597e-02f, 1.82854515e-02f, 7.67003894e-02f, 4.23758589e-02f, 1.44762605e-01f, -3.39333564e-02f, -2.46009901e-02f,
  7.25998655e-02f, 3.75799090e-02f, -1.39558136e-01f, -1.53772742e-01f, 3.99625115e-02f, -3.48083978e-03f, 5.39791137e-02f, -3.45993564e-02f, 6.85584173e-02f, -4.83026132e-02f,
  -8.42106435e-03f, -6.45674616e-02f, 2.16139462e-02f, 3.42039578e-02f, 4.85108122e-02f, 2.40113139e-02f, -4.94266227e-02f, -2.57177223e-02f, -9.30403396e-02f, -6.67616948e-02f,
  -1.29163876e-01f, 4.81508449e-02f, 7.71501884e-02f, -1.28166080e-01f, -8.12310800e-02f, -6.39780313e-02f, -1.13606513e-01f, -1.88166089e-02f, -2.19136886e-02f, -4.50280914e-03f,
  -1.22141577e-01f, 2.65784770e-01f, 2.14838251e-01f, -1.15541955e-02f, -2.59698570e-01f, -1.87818006e-01f, -2.50024468e-01f, 7.07767457e-02f, 1.64030686e-01f, -3.81024107e-02f,
  -3.84720676e-02f, 1.13237157e-01f, 9.25241783e-02f, -1.76281720e-01f, 9.14648175e-02f, 1.73832506e-01f, -9.86513197e-02f, -3.66604030e-02f, 2.77484246e-02f, -8.10599327e-02f,
  2.67307945e-02f, -3.96486908e-01f, 1.43942058e-01f, -7.86807686e-02f, -2.48519763e-01f, 2.03303639e-02f, -7.19505455e-03f, -8.68557766e-02f, -3.27553079e-02f, -1.09885849e-01f,
  1.47532169e-02f, 2.15429766e-03f, 1.24225661e-01f, 1.36078373e-01f, 6.35567382e-02f, -1.62461162e-01f, -1.48546711e-01f, -3.51627879e-02f, -1.25607131e-02f, 1.24517657e-01f,
  -2.43101735e-02f, -2.49600317e-02f, 1.41635062e-02f, -2.56056581e-02f, -2.06340805e-01f, 3.51298153e-02f, 7.05755129e-02f, 5.13624251e-02f, 1.42161712e-01f, -4.78024222e-02f,
  8.79101455e-02f, 5.61362505e-02f, -5.30772749e-03f, 3.78592350e-02f, 5.75585931e-04f, -7.58527443e-02f, -2.51091383e-02f, 9.83659402e-02f, 4.53544967e-02f, 1.84628852e-02f,
  -1.59254894e-01f, 9.59689263e-03f, 5.72954603e-02f, 1.18027277e-01f, -6.89197034e-02f, -6.99855527e-03f, -1.16751455e-01f, -3.98265161e-02f, -4.37438898e-02f, -8.34902003e-02f,
  1.14570506e-01f, -3.26711475e-03f, -1.11535966e-01f, -9.63580161e-02f, -1.87395737e-01f, 6.12489879e-02f, 5.45561360e-03f, 1.17062253e-03f, -1.04573108e-01f, 7.78887272e-02f,
  1.61064751e-02f, -8.92496333e-02f, 1.25767007e-01f, -5.33846617e-02f, 6.40021230e-04f, -4.19480465e-02f, -5.65814897e-02f, 4.65370193e-02f, 1.28124744e-01f, -1.65032763e-02f,
  2.68037114e-02f, 1.15115106e-01f, 7.99503699e-02f, 1.11324653e-01f, 1.38361499e-01f, 4.91859689e-02f, -1.09571405e-01f, 1.04595050e-02f, 5.68319447e-02f, 6.70513809e-02f,
  -7.62146637e-02f, 5.10174632e-02f, -3.89074683e-02f, -8.79700184e-02f, 5.41093200e-02f, 6.43257126e-02f, -1.01345414e-02f, 1.86342716e-01f, 1.48525596e-01f, 1.05840731e-02f,
  -5.49265323e-03f, -6.07477799e-02f, 7.73714557e-02f, -2.24084146e-02f, 2.80985516e-02f, 2.61320528e-02f, 1.82004534e-02f, 9.51080397e-02f, -1.66456103e-02f, 3.27807553e-02f,
  1.42744258e-01f, -3.86921793e-01f, -2.13225573e-01f, -2.45481774e-01f, 1.87328011e-01f, 3.02086323e-01f, 3.03177267e-01f, -1.25430390e-01f, -3.98042887e-01f, 3.82295847e-02f,
  1.75859317e-01f, 7.43110403e-02f, 1.49120659e-01f, 3.60048264e-02f, 2.94170499e-01f, -2.45080311e-02f, -1.91703311e-03f, 6.82798922e-02f, -2.13941634e-01f, 7.17242658e-02f,
  7.01693818e-02f, 2.59047478e-01f, -1.02279671e-02f, -5.99374324e-02f, 1.74305692e-01f, -1.23810485e-01f, 2.22564474e-01f, 2.21107334e-01f, 7.15617016e-02f, 1.02062620e-01f,
  4.28964086e-02f, -6.57868087e-02f, 1.57475714e-02f, -1.06424943e-01f, 8.23106244e-02f, 1.49996236e-01f, 8.07990357e-02f, 1.71802208e-01f, -1.08953081e-02f, 2.79783690e-03f,
  1.20197922e-01f, -3.78856920e-02f, -1.26618072e-01f, 1.00228339e-01f, -5.72099462e-02f, -7.65953213e-02f, -6.51110560e-02f, -5.57760186e-02f, -3.89474332e-02f, 6.68960288e-02f,
  1.42018276e-03f, -1.66433424e-01f, -1.19422205e-01f, -8.84869844e-02f, -8.32068250e-02f, -1.09448075e-01f, -8.62089768e-02f, 8.45107585e-02f, -7.70588368e-02f, -2.55605262e-02f,
  7.27858618e-02f, 8.67026672e-02f, 3.87344547e-02f, -1.19176865e-01f, -2.58791093e-02f, -2.79055759e-02f, 3.77713819e-04f, 1.35978889e-02f, -5.35257310e-02f, -1.65681709e-02f,
  -5.85824661e-02f, -3.65044596e-03f, -6.44249544e-02f, 6.58845380e-02f, 6.97124153e-02f, -6.79568723e-02f, 6.08673654e-02f, 1.40628293e-02f, 2.85832435e-02f, -1.03190597e-02f,
  -1.86920706e-02f, 1.40692829e-03f, 7.28069693e-02f, -7.93240815e-02f, -4.48784381e-02f, 8.33059996e-02f, -1.92281622e-02f, -1.27639547e-02f, -2.23318174e-01f, -1.98597368e-03f,
  -5.80827612e-03f, 3.52430418e-02f, -1.50968611e-01f, -9.31883305e-02f, 5.60035091e-03f, 6.88001588e-02f, 3.22369253e-03f, -4.73516732e-02f, -1.66098587e-02f, 9.21523571e-02f,
  3.25189531e-02f, -1.16742171e-01f, -7.71312043e-03f, 3.55086997e-02f, -1.02992333e-01f, -6.37528487e-03f, 8.54629651e-02f, -4.51479591e-02f, 1.80700030e-02f, -1.05114967e-01f,
  -1.27965268e-02f, -1.40906289e-01f, -7.01211542e-02f, -4.90926914e-02f, -6.02426566e-02f, 9.03910920e-02f, -5.40917590e-02f, 4.57839258e-02f, -6.08268101e-03f, -1.03742324e-01f,
  4.08940762e-01f, -1.59845144e-01f, 1.21550180e-01f, 2.20454603e-01f, 2.35690057e-01f, 8.74203071e-03f, -2.25734571e-03f, 9.25441608e-02f, 1.49426296e-01f, -5.56225814e-02f,
  -4.41568233e-02f, -2.79891654e-03f, -3.93413365e-01f, 1.10382929e-01f, -2.03419775e-01f, -3.81944388e-01f, 4.76743057e-02f, 3.40904370e-02f, 4.70542163e-02f, 2.83146109e-02f,
  6.96136057e-02f, -1.36389285e-01f, -1.59601614e-01f, -1.09071776e-01f, 3.24800074e-01f, 9.52758044e-02f, -4.96322811e-02f, -1.70460075e-01f, 1.28150716e-01f, -1.39763132e-01f,
  6.69165626e-02f, 3.97310518e-02f, 2.94240657e-02f, 4.45955992e-03f, -4.77985330e-02f, 1.04637444e-01f, 4.86527421e-02f, -1.40250981e-01f, 6.35266528e-02f, 5.70657291e-02f,
  4.66885604e-03f, 1.38768330e-01f, -9.78616718e-03f, -1.34434521e-01f, 1.24182306e-01f, 1.01761319e-01f, 1.86649904e-01f, 1.52106643e-01f, 1.50216937e-01f, 4.80850451e-02f,
  6.49451017e-02f, 1.22841731e-01f, 1.50645211e-01f, -5.49511872e-02f, 5.13444878e-02f, 8.18515718e-02f, 1.70135014e-02f, -4.94668121e-03f, 1.08049676e-01f, 1.27233580e-01f,
  4.15941104e-02f, -3.34061333e-03f, -2.08848119e-02f, 9.71418805e-03f, 1.49380453e-02f, 6.39428478e-03f, -5.82582615e-02f, 2.33952198e-02f, -5.01702391e-02f, -1.05718508e-01f,
  6.11632951e-02f, -1.15062715e-02f, -9.95507687e-02f, 6.60598511e-03f, -5.57241701e-02f, 1.19900703e-01f, -2.02653762e-02f, 4.99494001e-02f, -3.01742889e-02f, 9.56280157e-02f,
  -2.66449284e-02f, 9.00345594e-02f, -9.72713083e-02f, 5.17451093e-02f, -2.12677345e-02f, -9.52173397e-02f, 7.44339544e-03f, 5.22520617e-02f, 1.24594457e-01f, -1.00872338e-01f,
  -2.43429869e-01f, -3.87671798e-01f, -5.27201332e-02f, 4.58639376e-02f, -1.64382726e-01f, 8.52386802e-02f, 3.38601843e-02f, 2.64597237e-02f, -9.83472615e-02f, 2.70074960e-02f,
  8.69030282e-02f, 1.10685222e-01f, -3.90242338e-02f, 1.62104536e-02f, -8.43812078e-02f, -4.29414958e-02f, 9.83131900e-02f, 2.28995294e-03f, 1.01280950e-01f, 2.03667767e-02f,
  1.65086061e-01f, 1.54789388e-01f, 7.38627044e-03f, 1.07550308e-01f, 1.20597742e-01f, -1.49691790e-01f, 9.21812803e-02f, -1.22704223e-01f, -2.12694588e-03f, 1.50736133e-02f,
  2.98166513e-01f, -2.93601871e-01f, 4.67623845e-02f, 2.43404150e-01f, 1.74568877e-01f, -1.62599996e-01f, 1.44299731e-01f, -1.12687752e-01f, 3.58799189e-01f, -3.85574639e-01f,
  -7.46332780e-02f, 4.88959961e-02f, 8.33069086e-02f, -2.45865509e-01f, 3.55478227e-01f, 6.96022809e-02f, -5.47059402e-02f, -8.38821288e-03f, 1.67479023e-01f, -8.75604898e-03f,
  3.28562297e-02f, -3.23391616e-01f, -3.85764576e-02f, -3.71659696e-01f, -1.23547524e-01f, -1.22534439e-01f, -1.00899629e-01f, 1.79215334e-02f, -2.50775188e-01f, 5.56251640e-03f,
  1.17831156e-02f, 6.17766790e-02f, 1.02398987e-03f, -4.63420302e-02f, 6.32652417e-02f, -8.39196593e-02f, -1.36890113e-01f, -6.89173639e-02f, 1.62642688e-01f, -4.12663398e-03f,
  4.74232137e-02f, -5.27929775e-02f, -2.76123211e-02f, -1.69711523e-02f, 1.10890552e-01f, 2.71944012e-02f, 6.20308183e-02f, 1.10694006e-01f, -1.33229718e-02f, 8.09952170e-02f,
  6.31297752e-02f, 1.01460315e-01f, 5.39156944e-02f, -1.59376338e-02f, 5.20525761e-02f, -6.69869222e-03f, -3.51079181e-02f, 7.75395855e-02f, 9.18034911e-02f, 7.90446028e-02f,
  -1.29938796e-01f, -9.33783781e-03f, -4.99145724e-02f, -4.76921201e-02f, 7.07159862e-02f, 7.72955716e-02f, -2.19495762e-02f, -5.90648130e-02f, 8.92277882e-02f, 8.43669521e-04f,
  2.86797006e-02f, -9.25854221e-02f, 2.82375179e-02f, -1.09902900e-02f, -8.63409713e-02f, -4.76246774e-02f, 5.62767079e-03f, 9.51121468e-03f, 1.79764777e-02f, 3.35114673e-02f,
  -1.01211339e-01f, -1.12578990e-02f, 8.30340311e-02f, -4.82190512e-02f, -5.76828271e-02f, 3.26951928e-02f, -8.81734267e-02f, 3.77186425e-02f, -3.45227798e-03f, 4.05950993e-02f,
  -4.74707745e-02f, -3.37793231e-01f, -3.57024744e-02f, -2.33341902e-02f, -1.34389903e-02f, -4.25128080e-02f, -8.71351212e-02f, -7.15236440e-02f, 3.09190527e-02f, -1.36279806e-01f,
  -4.72478420e-02f, 2.57207919e-02f, 2.39714552e-02f, -1.32560143e-02f, 6.44354001e-02f, -8.37313011e-02f, -4.54181805e-02f, 3.13130245e-02f, -3.19661163e-02f, -6.75548688e-02f,
  4.06727418e-02f, 8.46000686e-02f, 1.45886699e-02f, 7.71435350e-02f, -5.29433191e-02f, 1.08838025e-02f, 4.99528013e-02f, 3.36190686e-02f, 5.96439503e-02f, 7.37918392e-02f,
  4.38932031e-01f, -1.41171679e-01f, -2.55361617e-01f, 1.67361964e-02f, 2.04551443e-01f, 1.82534203e-01f, -3.53185609e-02f, 1.24538578e-02f, 1.46183232e-02f, 3.27122957e-02f,
  1.38757408e-01f, -1.26171503e-02f, -2.68522918e-01f, 3.51662338e-01f, 2.34655887e-01f, -2.65566520e-02f, 1.80975795e-01f, 5.17647974e-02f, 1.04519211e-01f, 1.08724028e-01f,
  1.97989523e-01f, 4.53729898e-01f, -6.31740540e-02f, 1.30101010e-01f, 2.43162572e-01f, -1.03242502e-01f, -1.71536449e-02f, -2.00216725e-01f, 1.29733756e-01f, 2.40950892e-03f,
  5.62146455e-02f, 5.90343215e-02f, -3.26439850e-02f, 1.37387868e-02f, -8.83584172e-02f, 1.14663944e-01f, -2.78445035e-02f, -1.35396734e-01f, 2.23129820e-02f, -1.36707067e-01f,
  -3.78684066e-02f, 5.35243452e-02f, 1.37547031e-02f, 4.82395031e-02f, 1.18507385e-01f, 4.14022133e-02f, -3.80500816e-02f, -4.34549786e-02f, -1.10327572e-01f, 1.09922826e-01f,
  -5.82903177e-02f, -2.41385475e-02f, 7.75384977e-02f, -7.86009207e-02f, -1.78291947e-02f, 2.40743626e-03f, -2.23691501e-02f, -1.30154550e-01f, -3.35860439e-02f, 8.55473354e-02f,
  -2.36537345e-02f, 1.36612356e-01f, 1.60786077e-01f, 1.30425841e-02f, -5.09405024e-02f, -5.47305569e-02f, 7.03185499e-02f, -8.87644440e-02f, -3.25932764e-02f, 3.04875374e-02f,
  -5.32324687e-02f, 6.07389025e-02f, 5.17957434e-02f, 5.06474264e-02f, 1.82097778e-01f, 8.79405141e-02f, -4.53819223e-02f, -6.27339706e-02f, -2.58491356e-02f, -9.50541869e-02f,
  -4.08728644e-02f, 4.44463082e-02f, -4.13178764e-02f, -6.49411082e-02f, 3.11756320e-02f, -7.86818191e-02f, 1.05511330e-01f, 4.16738987e-02f, -1.85192730e-02f, 9.66528524e-03f,
  -4.65861633e-02f, -1.19871430e-01f, -7.14237988e-02f, -9.01118964e-02f, -1.85451642e-01f, 1.11168779e-01f, 1.31608143e-01f, -1.34044709e-02f, -1.74762048e-02f, 3.44946682e-02f,
  -5.40777519e-02f, -1.39559731e-01f, -1.31141646e-02f, 1.01032339e-01f, -1.38105139e-01f, 6.48642406e-02f, -2.23591849e-02f, -7.48778507e-02f, -1.76299453e-01f, -1.70270838e-02f,
  -8.46513584e-02f, -5.89975640e-02f, -1.11040190e-01f, 1.22288400e-02f, -9.15695801e-02f, -6.81338925e-03f, 3.42258178e-02f, 6.11323193e-02f, -7.11025447e-02f, -1.29837403e-02f,
  1.61386073e-01f, -3.19157392e-01f, -7.14027435e-02f, -2.73971528e-01f, 1.77509170e-02f, 1.99874327e-01f, 2.68434525e-01f, -2.65951067e-01f, -4.72134173e-01f, 2.69167759e-02f,
  -9.03429762e-02f, 8.19716230e-03f, 1.77512959e-01f, -1.59101710e-01f, 1.51646644e-01f, 3.47049199e-02f, -1.07367113e-01f, -4.65831831e-02f, -2.48780698e-01f, 8.24065730e-02f,
  -1.18298605e-02f, 2.63234600e-02f, 1.10394731e-01f, -1.03389295e-02f, -5.84447198e-02f, -3.37756798e-02f, 8.06004703e-02f, 1.16252176e-01f, -4.39335965e-02f, -1.52264118e-01f,
  4.24644612e-02f, -1.64464891e-01f, 3.60755548e-02f, -5.15891332e-03f, 1.36844916e-02f, 1.44062757e-01f, 8.63634497e-02f, 1.73498809e-01f, -4.19199504e-02f, -9.58576277e-02f,
  1.28657416e-01f, -3.01662907e-02f, -1.00569241e-01f, 9.68855806e-04f, -8.37109983e-02f, -9.69785005e-02f, 1.33859422e-02f, -1.44031951e-02f, 9.84590277e-02f, 5.71717285e-02f,
  9.28008277e-03f, -6.63885847e-02f, -1.80197135e-01f, -9.16842744e-02f, -1.67906493e-01f, -7.24027455e-02f, 1.34160966e-01f, 1.36919215e-01f, -1.35295689e-01f, -3.02581284e-02f,
  7.10640475e-02f, 9.06952992e-02f, 1.68506801e-01f, -2.64398158e-02f, 8.24090745e-03f, -7.27300495e-02f, 7.76609629e-02f, 4.22397032e-02f, -8.05080459e-02f, 4.27924618e-02f,
  -4.94930148e-02f, -1.24337310e-02f, -1.05232589e-01f, -2.03031506e-02f, 7.34262392e-02f, 2.58729490e-03f, 7.75569081e-02f, -1.01590510e-02f, -7.89682269e-02f, -4.44135219e-02f,
  7.53169656e-02f, 1.43383378e-02f, 7.09389076e-02f, -9.61616114e-02f, -5.31544946e-02f, -6.19181842e-02f, -3.47158164e-02f, -5.91744781e-02f, -1.16090640e-01f, -8.31641704e-02f,
  -3.85600477e-02f, 2.18317863e-02f, 1.26611087e-02f, -2.69408803e-02f, 6.39378056e-02f, 1.83383394e-02f, -7.93877319e-02f, -3.38220149e-02f, 2.82619353e-02f, 8.80417675e-02f,
  -1.84922945e-02f, 2.36972887e-02f, 5.93284890e-02f, 8.65157321e-02f, -1.43030703e-01f, 2.75249942e-04f, 1.98801756e-01f, 5.54014072e-02f, 1.13504231e-02f, 1.64456386e-02f,
  2.49647964e-02f, -4.12491523e-02f, -1.43590122e-01f, -7.19378814e-02f, -1.83533549e-01f, -2.65057590e-02f, 3.56216431e-02f, -2.68064272e-02f, -1.01707475e-02f, -8.68071020e-02f,
  -1.43261194e-01f, 2.67618924e-01f, 1.29428044e-01f, 3.33460897e-01f, -2.82083243e-01f, -3.79337758e-01f, -3.14816721e-02f, -6.76323771e-02f, 5.74616976e-02f, 3.10190827e-01f,
  6.01936243e-02f, 5.69370762e-02f, 8.77221450e-02f, 4.42642272e-01f, -5.67293465e-01f, 8.55943859e-02f, 1.14745274e-01f, 1.69253021e-01f, -1.04914762e-01f, -6.27084821e-02f,
  -1.22705540e-02f, -6.83560818e-02f, 1.43695444e-01f, -3.70717123e-02f, 9.49742272e-02f, 2.52532154e-01f, -5.44503005e-03f, 4.28660103e-04f, 1.55791923e-01f, -1.76059291e-01f,
  -6.30793497e-02f, 2.07812160e-01f, 1.92839444e-01f, 4.62665409e-02f, -2.13150717e-02f, 1.26923710e-01f, 1.06486432e-01f, 2.32479535e-02f, 2.20753867e-02f, -1.25911757e-02f,
  -4.06380408e-02f, -1.36520639e-01f, -3.46350105e-04f, 2.07280298e-03f, 2.06189696e-02f, 1.35795355e-01f, -7.27284402e-02f, 8.77080485e-02f, -2.22129058e-02f, 7.41722882e-02f,
  2.03948423e-01f, 7.77005330e-02f, -2.69632001e-04f, 1.59612909e-01f, -9.44216773e-02f, -9.85253230e-03f, -3.64048779e-02f, -1.88753810e-02f, 3.96639556e-02f, 2.48060040e-02f,
  4.04531658e-02f, -6.43275231e-02f, 1.62442580e-01f, -5.43866456e-02f, -6.56482875e-02f, 3.36235091e-02f, 3.75309363e-02f, 5.51353628e-03f, 3.88254202e-03f, -2.71005388e-02f,
  -1.85557187e-01f, 5.45426644e-02f, -1.02707498e-01f, 1.45516410e-01f, 1.47085235e-01f, 3.33428271e-02f, -3.71280052e-02f, -7.06138760e-02f, -7.48320520e-02f, 3.88823114e-02f,
  -4.09848243e-02f, -8.27099606e-02f, 5.23680914e-03f, -8.93027633e-02f, -3.62489261e-02f, -1.42458593e-03f, 5.63282296e-02f, 3.02249044e-02f, -7.24380687e-02f, -1.99000448e-01f,
  -3.40940744e-01f, -1.02056883e-01f, 2.31493916e-02f, -9.05775949e-02f, 9.03904662e-02f, 9.16736424e-02f, 1.66301370e-01f, 3.93381640e-02f, -1.00499071e-01f, -5.32797612e-02f,
  -5.42418752e-03f, -1.52876917e-02f, -1.15788110e-01f, -3.64525639e-03f, -1.38889417e-01f, 7.01321289e-02f, -9.27940533e-02f, 7.29577942e-03f, -6.47790432e-02f, -4.63456661e-02f,
  9.33923423e-02f, 3.96662690e-02f, 2.34955712e-03f, 9.78077296e-03f, -8.64067748e-02f, 3.98578122e-03f, 1.83917508e-02f, 3.41337249e-02f, -5.83019741e-02f, 7.02956542e-02f,
  -4.74161386e-01f, 3.33301902e-01f, 1.91833988e-01f, 1.50456771e-01f, -1.61012128e-01f, 2.55708992e-02f, 8.76907900e-04f, 8.92311186e-02f, -4.48390841e-02f, 6.60897270e-02f,
  -2.30391603e-02f, -2.22388152e-02f, 1.52875349e-01f, 2.19685614e-01f, 2.51301140e-01f, 3.37648422e-01f, 2.07921594e-01f, 9.76322517e-02f, 2.67874867e-01f, 1.77766338e-01f,
  2.41454288e-01f, 3.95472646e-02f, 3.33573431e-01f, 1.93609923e-01f, 5.10304645e-02f, 1.24304831e-01f, 1.59416050e-01f, 1.94036290e-01f, 2.74905950e-01f, -7.44984066e-03f,
  -1.45029470e-01f, -8.56533498e-02f, -6.03325665e-02f, -2.50038411e-02f, 3.64510599e-03f, -1.13843702e-01f, -1.79671664e-02f, -6.06104061e-02f, -4.50067148e-02f, 4.62810025e-02f,
  -3.98639701e-02f, 2.98656765e-02f, 1.19280711e-01f, -6.16116077e-02f, -1.23844072e-01f, 4.66326205e-03f, -5.55724390e-02f, -2.67171022e-03f, -1.52959004e-02f, 4.76531796e-02f,
  1.96701258e-01f, 1.26129150e-01f, 1.16221374e-02f, 1.19197965e-01f, 8.45393240e-02f, -2.54931278e-03f, 6.84768185e-02f, -6.23123422e-02f, 1.61787029e-02f, 4.39087637e-02f,
  -1.05972327e-02f, -1.58960819e-02f, -3.27250697e-02f, 1.04228985e-02f, 3.31462920e-02f, 1.44542381e-01f, 7.36767054e-02f, -8.62273797e-02f, 5.88216702e-04f, 4.23529968e-02f,
  -3.18473987e-02f, 5.07938638e-02f, 3.35127823e-02f, -5.25942654e-04f, 6.09396063e-02f, -5.52669987e-02f, -4.93700616e-02f, 5.45724994e-03f, 9.97788832e-02f, 8.37912560e-02f,
  -1.50912534e-02f, -4.75016329e-03f, 3.63177955e-02f, -1.49086922e-01f, -1.24315657e-01f, 7.60410801e-02f, 8.19552317e-02f, -5.15939444e-02f, 4.39257696e-02f, 5.64343631e-02f,
  1.72931641e-01f, 3.53108108e-01f, 9.67121720e-02f, -4.92727011e-02f, 6.70111389e-04f, 6.93764761e-02f, 5.91556095e-02f, 6.53137788e-02f, 1.26626998e-01f, 1.71735846e-02f,
  -5.29038757e-02f, -3.17637250e-02f, 1.54770119e-02f, -1.80089295e-01f, 4.66408357e-02f, 1.76831931e-01f, 3.50474417e-02f, -2.43026316e-02f, 2.76579931e-02f, 8.07527453e-02f,
  1.15830153e-01f, -5.34843691e-02f, 9.22182202e-02f, 5.49562834e-02f, -5.04173301e-02f, 5.80530800e-02f, -4.72283177e-02f, -1.25176743e-01f, 8.16956609e-02f, 4.71955054e-02f,
  -4.24600512e-01f, -2.54865795e-01f, -1.65904388e-01f, -4.58774306e-02f, 1.64885178e-01f, 2.19732523e-01f, -6.91790879e-02f, -5.85193262e-02f, -2.06847861e-01f, -4.73603010e-02f,
  1.30980343e-01f, -1.34379253e-01f, -1.80245742e-01f, 3.14860761e-01f, 1.54433623e-01f, 6.03605360e-02f, 2.13505462e-01f, 1.03921697e-01f, 6.04742132e-02f, -5.44336289e-02f,
  1.27410233e-01f, 2.17562512e-01f, 9.76306498e-02f, 2.12557793e-01f, 1.17819428e-01f, -1.16867810e-01f, 4.73700017e-02f, -2.36941911e-02f, 2.44173482e-01f, 1.25779569e-01f,
  -1.32898986e-01f, -2.21889764e-01f, -1.12535745e-01f, -1.46414191e-01f, -5.75562380e-03f, -5.17024882e-02f, -1.68286502e-01f, -3.65487561e-02f, -1.75538026e-02f, 2.16466542e-02f,
  -2.44992692e-02f, -2.19332930e-02f, 1.13888644e-01f, -3.30513790e-02f, 4.97402623e-02f, 2.22005472e-02f, 8.10997039e-02f, 1.14237126e-02f, -7.18564913e-02f, 9.48634744e-02f,
  -9.33307782e-02f, 4.53793108e-02f, 2.65395790e-02f, 1.24385878e-01f, 7.74249732e-02f, 3.43923569e-02f, -5.21799736e-02f, 1.37502998e-02f, 1.18661024e-01f, 9.06303599e-02f,
  6.61615431e-02f, -3.17056989e-03f, -7.62240440e-02f, 3.43301892e-02f, 4.78039756e-02f, 2.76992433e-02f, -3.68092172e-02f, 8.07274878e-02f, 2.69846674e-02f, 3.25891771e-03f,
  1.29806072e-01f, -2.45354045e-03f, -6.13463596e-02f, -4.12662998e-02f, 5.39284316e-04f, -7.09351227e-02f, 8.49654805e-03f, -8.07916280e-03f, 1.20328013e-02f, -6.75105304e-03f,
  -8.01085234e-02f, 4.83378209e-02f, 6.18307181e-02f, 6.00970238e-02f, -9.14322771e-03f, -1.14646219e-01f, 1.53080039e-02f, -5.11362264e-03f, 3.64404730e-02f, 1.78146753e-02f,
  -3.69798094e-01f, -3.73587489e-01f, -8.48676339e-02f, -3.05730347e-02f, -7.50459358e-03f, 4.69924184e-03f, -2.11425312e-02f, -2.76971422e-03f, -9.34392810e-02f, 5.05571626e-02f,
  -3.02465931e-02f, -2.86511667e-02f, -6.23949915e-02f, 6.94083422e-02f, 4.31468114e-02f, -2.24885307e-02f, -6.20777160e-02f, -4.06349637e-02f, -2.37601008e-02f, 5.41616045e-02f,
  -7.37258866e-02f, 2.37929020e-02f, 9.03621018e-02f, 3.50100137e-02f, 1.23691447e-01f, -5.73883951e-02f, -2.26931740e-02f, 5.42719774e-02f, 1.30076468e-01f, 8.08598325e-02f,
  -6.05306685e-01f, 2.26886377e-01f, -8.48436132e-02f, -4.88043278e-01f, 3.12480122e-01f, 2.64845699e-01f, -1.89279139e-01f, 1.50453568e-01f, -2.29846403e-01f, 1.47918984e-01f,
  -5.93027100e-02f, -3.29903007e-01f, -6.85925456e-03f, -3.53856325e-01f, -3.85429621e-01f, -2.56548762e-01f, -3.05395305e-01f, -3.01902920e-01f, -1.89541757e-01f, -1.52106702e-01f,
  -2.06250489e-01f, -2.10562609e-02f, -1.16166383e-01f, 3.07925612e-01f, 8.98310393e-02f, 1.21071286e-01f, 1.08276315e-01f, 9.78517160e-02f, 2.02361308e-02f, -1.72323976e-02f,
  -9.10975225e-03f, -1.13731697e-01f, 7.41277635e-02f, 1.21574365e-01f, -2.95092743e-02f, 5.70297986e-02f, -2.52418593e-02f, -3.92693393e-02f, 4.47650850e-02f, -2.35911477e-02f,
  6.78462386e-02f, 1.79404140e-01f, -9.65802893e-02f, -2.18437891e-02f, 9.65459943e-02f, 7.10934252e-02f, 9.87550765e-02f, 5.10471873e-02f, 1.57568753e-01f, -1.30566612e-01f,
  -5.90354577e-02f, 9.52082276e-02f, 3.64657268e-02f, -1.19463667e-01f, -8.69266223e-03f, -1.23330681e-02f, 3.55489999e-02f, 5.64600900e-02f, 5.41812740e-02f, -7.19836429e-02f,
  -9.27611627e-03f, -3.49658541e-04f, 4.62321145e-03f, -2.38855351e-02f, 5.21236360e-02f, 6.88862279e-02f, -1.17348274e-02f, 1.11451603e-01f, 8.93978775e-02f, 9.70446318e-02f,
  2.04031309e-03f, -2.71357130e-02f, -5.51911332e-02f, -1.39713902e-02f, -7.55701661e-02f, -4.69185077e-02f, 2.69047525e-02f, 4.78139892e-02f, -1.17545038e-01f, -4.90576215e-02f,
  2.89475247e-02f, -4.95465882e-02f, -9.51811224e-02f, 1.16644934e-01f, 3.57843637e-02f, -1.41435917e-02f, 1.76411048e-01f, 7.62091577e-02f, 3.64112630e-02f, -2.48177927e-02f,
  1.13437958e-01f, -7.56395422e-03f, 8.25311095e-02f, 1.35746479e-01f, -1.01614445e-02f, 6.28821924e-02f, -1.31247006e-03f, -3.85053977e-02f, -1.82218123e-02f, 6.63048355e-03f,
  9.92247835e-02f, 1.00263096e-01f, 7.24672303e-02f, 8.25061696e-04f, 4.18694399e-04f, 9.47072282e-02f, 8.75218511e-02f, 4.16984670e-02f, 1.36026502e-01f, 1.94511302e-02f,
  1.52788116e-02f, 5.57539389e-02f, 1.31825600e-02f, 1.63289197e-02f, 2.38876883e-02f, -1.34810887e-03f, 1.55449631e-02f, -5.29215522e-02f, -2.30935551e-02f, 6.76889867e-02f,
  3.42621624e-01f, -1.30282998e-01f, 4.28754315e-02f, 1.00927912e-01f, 3.86816449e-02f, -8.27735588e-02f, 1.87241465e-01f, -4.46788259e-02f, -1.01221584e-01f, -1.78493246e-01f,
  1.37443542e-01f, 5.87038510e-02f, 2.62543708e-01f, -1.40864719e-02f, 3.52715701e-01f, -8.61232802e-02f, 1.18959136e-01f, -1.25082806e-01f, -8.22918210e-03f, 1.82887986e-01f,
  2.30011508e-01f, 1.61808163e-01f, 2.52430946e-01f, -1.21815920e-01f, 1.54074296e-01f, -4.92933439e-03f, 1.46203682e-01f, -1.35284197e-02f, -1.15763605e-01f, 3.28924842e-02f,
  -1.01454340e-01f, 1.75076220e-02f, 2.08986644e-02f, -5.16153164e-02f, -2.81108432e-02f, 7.23771900e-02f, -1.18537918e-02f, 5.97339235e-02f, -1.60404686e-02f, -4.06407416e-02f,
  3.38740684e-02f, 4.64499891e-02f, -1.20505188e-02f, 1.91284701e-01f, 5.78617528e-02f, 6.69467542e-03f, -2.65678042e-03f, -1.40209822e-02f, -6.35728240e-02f, 2.19170704e-01f,
  6.99079782e-03f, -3.42380889e-02f, -1.35431963e-03f, -4.92562801e-02f, 8.28462392e-02f, 3.77227701e-02f, 2.09903102e-02f, 1.01373486e-01f, -1.08076811e-01f, 7.96065107e-02f,
  3.24671045e-02f, 7.32657462e-02f, -5.15254252e-02f, -6.37884587e-02f, -1.02381773e-01f, -3.28345634e-02f, -4.91222106e-02f, -9.32155773e-02f, -8.65208283e-02f, 3.78287807e-02f,
  6.27601370e-02f, 1.97651424e-02f, -1.79515164e-02f, -3.68465260e-02f, 9.17450637e-02f, 8.14207494e-02f, 2.80896463e-02f, 7.04584122e-02f, 1.35811791e-01f, -9.16578546e-02f,
  -6.11453690e-02f, -4.43727374e-02f, 2.90247332e-02f, 8.71442556e-02f, -8.52516443e-02f, 1.16604649e-01f, -4.10165153e-02f, 1.11099705e-01f, -1.67894304e-01f, 1.23258837e-01f,
  -2.42342148e-02f, 9.35587659e-02f, -1.65939275e-02f, -9.94695649e-02f, -9.76589844e-02f, -4.40045930e-02f, -6.01151437e-02f, -1.25919476e-01f, 8.84090643e-03f, 5.52710108e-02f,
  8.79441276e-02f, 2.77131349e-02f, -2.87859328e-02f, 4.74143289e-02f, 1.21873571e-02f, 6.39922172e-02f, 1.08872496e-01f, -3.83457839e-02f, 5.10068350e-02f, 3.42709012e-02f,
  5.94922714e-03f, 6.21000584e-03f, -2.76263524e-02f, -7.30399117e-02f, -3.10193915e-02f, 1.36257023e-01f, 6.91671148e-02f, -3.31347138e-02f, 3.57520729e-02f, -3.77565622e-02f,
  4.25797760e-01f, -2.40369186e-01f, -3.17248762e-01f, 6.37329221e-02f, 2.90274858e-01f, 1.84955329e-01f, -1.91892907e-02f, 2.48940978e-02f, -1.75199360e-01f, -1.02104368e-02f,
  7.71962553e-02f, 3.87084205e-03f, -2.65967280e-01f, 4.30853128e-01f, 4.53812808e-01f, -1.45359725e-01f, 3.54549348e-01f, 5.66121973e-02f, -7.68937692e-02f, 8.30886066e-02f,
  1.50017768e-01f, 4.95174944e-01f, -3.82329635e-02f, 1.58765942e-01f, 3.08027714e-01f, -1.68341860e-01f, 1.65765002e-01f, -1.83005944e-01f, 1.70946270e-01f, 9.52657759e-02f,
  -3.30270757e-03f, 9.33166370e-02f, -1.93812549e-02f, -4.16514231e-03f, -2.78388783e-02f, 8.57411921e-02f, 1.38187828e-02f, -4.84944880e-02f, -4.81048301e-02f, -1.06273055e-01f,
  -1.28600299e-02f, 6.77982122e-02f, 7.15590715e-02f, 1.62542872e-02f, 1.27170682e-01f, 1.04253687e-01f, -7.26321265e-02f, -1.11302957e-01f, -1.28764853e-01f, 1.09232053e-01f,
  -5.47125973e-02f, -2.08194144e-02f, 2.33675390e-02f, -2.20206007e-02f, -6.96764663e-02f, -3.56217064e-02f, 1.71230901e-02f, -6.03582747e-02f, -9.15527251e-03f, 1.14057429e-01f,
  1.17226318e-02f, 1.15116350e-01f, 3.39708850e-02f, -5.23530925e-03f, 2.01992877e-02f, -7.41415024e-02f, 6.50618076e-02f, 1.26526284e-03f, -7.92498961e-02f, 4.36334461e-02f,
  5.53036183e-02f, 9.40275937e-03f, -3.21098939e-02f, 6.84843734e-02f, 1.50018260e-01f, 6.86076060e-02f, 1.40146883e-02f, 3.61336507e-02f, -1.47813866e-02f, -7.02928752e-02f,
  -4.07727808e-02f, 9.51703452e-03f, -5.15620187e-02f, -3.93541940e-02f, -3.71341500e-03f, -6.92746043e-02f, 9.10799503e-02f, 7.38787800e-02f, -1.05896704e-01f, 4.31386940e-02f,
  -5.78667372e-02f, -1.46319028e-02f, -1.50656760e-01f, -3.85278687e-02f, -6.11870177e-02f, 1.93624571e-01f, 1.17891185e-01f, 2.42269803e-02f, -2.01167390e-02f, 9.81394872e-02f,
  6.01884760e-02f, -1.27311528e-01f, 5.45268431e-02f, 6.86504915e-02f, -1.16359517e-01f, 3.23718339e-02f, 1.29918838e-02f, -6.73261285e-02f, -3.58068012e-02f, 2.83318032e-02f,
  -2.81462446e-02f, -4.76029655e-03f, -2.71449275e-02f, -2.41163205e-02f, -5.90747073e-02f, 2.97822244e-02f, 7.88084324e-03f, -7.53526902e-03f, -7.32200071e-02f, -6.18016794e-02f,
  -1.67178199e-01f, 5.69958687e-02f, 2.40504757e-01f, 2.75241852e-01f, -3.30241889e-01f, -2.99743950e-01f, -2.44190976e-01f, -5.09240888e-02f, -3.98636796e-03f, -1.97272822e-01f,
  -1.78789049e-01f, 1.92888856e-01f, -2.93543041e-01f, 2.08929196e-01f, 1.30692113e-03f, -2.22387895e-01f, 2.50779510e-01f, 9.96027440e-02f, 4.87220362e-02f, 1.79452583e-01f,
  6.80005699e-02f, -8.39290470e-02f, 2.02440962e-01f, 1.41459955e-02f, 1.36947498e-01f, 3.74393344e-01f, 2.83223331e-01f, 1.30641997e-01f, 4.57753152e-01f, -6.25532120e-02f,
  4.58447561e-02f, -4.31974977e-02f, 1.19010992e-01f, 3.12899519e-03f, -3.83320227e-02f, -2.92594475e-03f, 1.87384844e-01f, 7.10555390e-02f, 1.47500327e-02f, 1.47327378e-01f,
  1.89599860e-02f, 7.42338225e-02f, 9.27952304e-02f, -4.27761637e-02f, -1.18133262e-01f, 4.43565957e-02f, 2.33287029e-02f, -1.23428032e-01f, 9.35893729e-02f, -1.45199984e-01f,
  1.21614076e-02f, -5.17501943e-02f, -7.12493137e-02f, -6.43790215e-02f, 1.18230749e-03f, -4.59841490e-02f, 1.94238089e-02f, 3.49716545e-04f, 1.47338122e-01f, -4.23004664e-02f,
  -1.77151188e-01f, 5.60832135e-02f, 9.64129344e-02f, 1.40159413e-01f, 4.66582226e-03f, 1.21345006e-01f, -6.89084232e-02f, -4.72616889e-02f, -2.65769828e-02f, 4.28039283e-02f,
  1.11068606e-01f, 8.77512470e-02f, 5.25233746e-02f, -1.95941366e-02f, -1.63434297e-02f, 3.07879951e-02f, 5.15182503e-02f, -6.24468625e-02f, 2.12726612e-02f, 8.07010010e-02f,
  4.46194522e-02f, 3.64074074e-02f, 9.86703411e-02f, -1.10474102e-01f, 1.87881812e-02f, 3.25827561e-02f, 2.41491534e-02f, -1.06890649e-01f, 7.89515898e-02f, -4.48278636e-02f,
  1.89728662e-02f, 2.04890490e-01f, 3.50368544e-02f, -8.34858343e-02f, 1.54388733e-02f, 6.50895461e-02f, 2.69565377e-02f, 9.76042822e-02f, 7.80043304e-02f, -4.82446328e-02f,
  -5.98867796e-02f, 8.80187526e-02f, -5.06818630e-02f, -1.06850676e-01f, -7.09447311e-03f, 2.19311975e-02f, 1.70714520e-02f, 3.88597064e-02f, 1.74706981e-01f, 1.20059095e-01f,
  8.68258253e-02f, -1.95196003e-01f, -7.18916208e-02f, -1.67401925e-01f, -8.08716286e-03f, -5.94910979e-02f, -6.59130514e-02f, -1.85768798e-01f, 3.02976649e-02f, 6.08256981e-02f,
  -2.97546566e-01f, -1.68700859e-01f, -1.63075060e-01f, 9.67775807e-02f, 1.45794913e-01f, 1.92748010e-01f, 1.48586079e-01f, 3.95219885e-02f, -1.53155461e-01f, 9.44381207e-02f,
  3.38021934e-01f, -1.92116469e-01f, 2.20518988e-02f, 3.01374197e-01f, 7.16685057e-02f, 7.11275786e-02f, 1.56619340e-01f, 1.01427533e-01f, -1.05739489e-01f, -1.12772793e-01f,
  -3.16202901e-02f, 2.02329576e-01f, 7.67982453e-02f, -6.84205815e-02f, 6.25875518e-02f, -2.36459091e-01f, 8.50062519e-02f, -1.85237259e-01f, 2.41506130e-01f, 7.35342056e-02f,
  -1.09270766e-01f, -1.03096753e-01f, -1.12281248e-01f, -1.34869531e-01f, -3.03658266e-02f, -5.63177578e-02f, -1.88174859e-01f, -6.49317652e-02f, -3.31833772e-02f, 5.76670580e-02f,
  -6.50740117e-02f, -8.82985145e-02f, 1.00129291e-01f, 6.55985763e-03f, 2.83676293e-03f, -2.31426917e-02f, 9.51123759e-02f, 9.73250419e-02f, 4.38334979e-03f, 6.38413951e-02f,
  -4.54920828e-02f, 1.07470185e-01f, 6.41059875e-02f, 6.76399469e-02f, 1.33774251e-01f, 1.66642875e-03f, -1.47817684e-02f, -7.32654938e-03f, 5.24693877e-02f, 5.93762398e-02f,
  6.48681894e-02f, -8.42757747e-02f, -8.14023018e-02f, 2.45690588e-02f, 9.23092887e-02f, 4.33700271e-02f, -1.54323666e-03f, 2.39563603e-02f, -4.63283770e-02f, 9.93469544e-03f,
  1.46079749e-01f, -3.36456746e-02f, -5.16228005e-03f, -5.89014515e-02f, -5.79956733e-02f, -9.36064720e-02f, -3.29279304e-02f, 3.67068453e-04f, 3.73986438e-02f, 2.36222111e-02f,
  -4.21683639e-02f, 1.69621333e-02f, 5.03551252e-02f, 5.54041155e-02f, -5.66766262e-02f, -5.50913904e-03f, 3.55858244e-02f, 1.12514079e-01f, 3.22058238e-02f, 2.01704316e-02f,
  -3.05617899e-01f, -3.29132676e-01f, -1.20946273e-01f, 4.49500792e-02f, -8.24149773e-02f, -4.29839343e-02f, -1.28606066e-01f, -3.40849049e-02f, -1.45389885e-01f, 4.53667901e-02f,
  -1.42979119e-02f, -3.22844717e-03f, -6.18620999e-02f, 7.99628720e-02f, 1.88735947e-02f, 4.91917767e-02f, -7.29096457e-02f, -2.74799149e-02f, 1.64251402e-02f, 4.96528894e-02f,
  -2.03298889e-02f, -1.31227635e-03f, -2.64022574e-02f, 2.83936113e-02f, 1.42346248e-01f, 2.06759218e-02f, -7.30269030e-02f, 3.71508300e-02f, 5.57536110e-02f, 8.09706300e-02f,
  1.27551317e-01f, 2.15149432e-01f, -8.83521363e-02f, 7.08917156e-02f, -1.90928832e-01f, -1.44451275e-01f, -1.74512595e-01f, -5.25770672e-02f, -6.55788928e-03f, 4.20612022e-02f,
  -1.35000069e-02f, 8.02342147e-02f, 2.52671652e-02f, 1.04848191e-01f, 8.95994902e-02f, 1.86741322e-01f, 5.39234392e-02f, -1.01056330e-01f, -3.11101577e-03f, -4.23798338e-03f,
  1.08360514e-01f, 3.41661215e-01f, 1.10594615e-01f, 1.24816947e-01f, -8.38732272e-02f, -2.42203306e-02f, 3.58199254e-02f, -1.55274555e-01f, -3.88514102e-02f, -1.11303004e-02f,
  -5.41467071e-02f, 1.83197528e-01f, -5.00109494e-02f, -4.11649011e-02f, 7.42322877e-02f, -1.09961674e-01f, -4.07576524e-02f, -3.46414186e-02f, -6.47850111e-02f, -4.54414375e-02f,
  6.16430528e-02f, 1.89192146e-01f, 6.00113831e-02f, -1.17977858e-02f, -6.67980909e-02f, 1.16510252e-02f, 9.73015279e-02f, -8.14637318e-02f, 1.65827200e-02f, 2.76549533e-02f,
  2.94703431e-02f, -5.04015684e-02f, 8.62355232e-02f, 1.12751126e-01f, 1.03659973e-01f, 8.18306506e-02f, 8.94587710e-02f, -6.99004307e-02f, 1.16497437e-02f, 1.43335864e-01f,
  3.92941572e-02f, -2.18628366e-02f, -1.31259365e-02f, -8.46683681e-02f, -7.16338749e-04f, -7.19037205e-02f, -1.25283201e-03f, 1.84910875e-02f, 3.68684120e-02f, -2.21214015e-02f,
  -8.74096751e-02f, -1.87305156e-02f, 5.96464463e-02f, -1.03652753e-01f, 1.04891837e-01f, 5.27088158e-02f, -9.68955234e-02f, 2.62731165e-02f, -5.59815988e-02f, -1.09732583e-01f,
  -2.82558482e-02f, 7.58029073e-02f, 9.63976886e-03f, -1.23653896e-02f, -1.83118194e-01f, 5.70681470e-04f, 1.58410430e-01f, 9.60864499e-02f, -2.17585444e-01f, 2.02359278e-02f,
  5.52644655e-02f, 3.70038271e-01f, 6.72087446e-02f, 3.25519480e-02f, -2.70775054e-02f, 1.55395723e-03f, 2.71498542e-02f, 7.43919015e-02f, 1.11962579e-01f, 8.49340633e-02f,
  1.43089399e-01f, -9.55138430e-02f, -3.23942974e-02f, -3.62963267e-02f, -5.72925545e-02f, 1.03034899e-01f, 7.70776421e-02f, -8.40141401e-02f, 1.00754134e-01f, -1.65712286e-03f,
  6.28196895e-02f, -7.27407262e-02f, 1.50568217e-01f, -3.61056514e-02f, 1.34117469e-01f, 1.13713615e-01f, -9.94711444e-02f, -1.64623689e-02f, 7.98344463e-02f, 9.53944493e-03f,
  -5.08442894e-02f, -4.94629681e-01f, 1.37769893e-01f, -6.56286031e-02f, 9.11201835e-02f, 2.76289433e-02f, 1.65980458e-01f, -1.99093759e-01f, -2.38379836e-01f, -3.83111954e-01f,
  -5.24687245e-02f, -6.46134233e-03f, 1.58252362e-02f, -6.13985471e-02f, 4.56634372e-01f, 2.04948355e-02f, 2.59230975e-02f, -2.20676046e-02f, 1.02441587e-01f, 3.96449156e-02f,
  1.13559037e-01f, 1.32977031e-02f, 1.66621864e-01f, -1.55282289e-01f, -1.20092994e-02f, -4.62300256e-02f, 7.01985061e-02f, 1.34929031e-01f, -9.97316837e-02f, 1.46297991e-01f,
  -7.65391886e-02f, -1.47705287e-01f, -5.57145104e-02f, -1.21514589e-01f, -6.18625432e-02f, 1.13616958e-01f, 7.58786201e-02f, 1.30799621e-01f, 9.26522613e-02f, -4.60533239e-02f,
  2.36782413e-02f, 8.00858717e-03f, -5.20772971e-02f, 5.94702400e-02f, -2.96057295e-03f, -3.10991239e-02f, -4.27411497e-02f, -1.26250833e-01f, -3.01385988e-02f, 1.44085750e-01f,
  6.70521781e-02f, -7.41248056e-02f, 4.41836892e-03f, -1.37254046e-02f, 3.14602964e-02f, 3.94384190e-02f, -8.04847106e-03f, 1.22258663e-01f, -3.46969860e-03f, -1.11383535e-02f,
  2.11319011e-02f, 4.70584780e-02f, 2.71359198e-02f, -5.26955202e-02f, -9.05974656e-02f, 5.19866981e-02f, -7.37765580e-02f, -6.63510570e-03f, -2.22891700e-02f, 2.98089795e-02f,
  1.99233089e-02f, -7.77007118e-02f, -8.93047675e-02f, 5.04712537e-02f, 5.41204680e-03f, -1.83686260e-02f, 8.67265910e-02f, 2.52423361e-02f, -2.52502728e-02f, -3.21978666e-02f,
  -2.99796276e-03f, 3.31299230e-02f, -2.13764305e-03f, 5.54105863e-02f, -5.72938956e-02f, -6.34692237e-02f, -4.02498432e-02f, 6.22806652e-03f, -7.60962814e-02f, 1.36003286e-01f,
  -2.62496084e-01f, -3.22648704e-01f, -6.94929734e-02f, -5.80611229e-02f, 1.00806607e-02f, -4.49505709e-02f, 1.59983486e-02f, -8.44016746e-02f, -3.20842005e-02f, -2.88356915e-02f,
  -2.98598185e-02f, 8.72955006e-03f, -2.60627382e-02f, 6.07816018e-02f, 1.92332976e-02f, -2.68163793e-02f, 3.02326363e-02f, -1.30305126e-01f, -1.52317798e-02f, -5.48910163e-02f,
  6.52638404e-03f, 1.61641072e-02f, 6.75766543e-02f, -6.08159136e-03f, -4.86423708e-02f, -5.47050848e-04f, -3.07143806e-03f, -1.17064379e-02f, 3.88302431e-02f, 1.03392474e-01f,
  1.15742177e-01f, 3.23378354e-01f, -5.53047191e-03f, 1.13746874e-01f, 5.71889896e-03f, -2.31976300e-01f, -1.47793770e-01f, 1.73248962e-01f, 6.05765879e-02f, 1.03978813e-01f,
  1.42570391e-01f, 1.51873648e-01f, 1.35789886e-01f, 7.92070031e-02f, -4.37554866e-01f, -1.70135126e-01f, 3.56669500e-02f, -2.59966664e-02f, -1.27526037e-02f, 2.67045666e-02f,
  -3.11864237e-03f, 1.64296106e-01f, -2.62237918e-02f, 9.73616689e-02f, 1.18559115e-01f, 1.73625007e-01f, -5.85369170e-02f, 4.40065786e-02f, -8.24648794e-03f, -4.62629497e-02f,
  -2.31169462e-02f, 1.46214217e-01f, -3.44195999e-02f, -2.48080082e-02f, -5.69924973e-02f, -4.56899069e-02f, -7.13101625e-02f, -5.57580926e-02f, -5.07806614e-02f, 7.74783120e-02f,
  1.28873125e-01f, 7.54888356e-02f, 9.33990851e-02f, 9.57110450e-02f, 5.63646071e-02f, 6.48471490e-02f, -6.41508177e-02f, -1.00203753e-01f, 4.16337103e-02f, 2.14001313e-02f,
  7.08400225e-03f, 7.58014200e-03f, 2.36987993e-02f, -4.11268510e-02f, 2.07547434e-02f, -2.97141690e-02f, -5.90386204e-02f, 3.28719150e-03f, 9.92783159e-02f, -4.69582491e-02f,
  1.85094342e-01f, -7.68680647e-02f, -9.55136567e-02f, 1.92498937e-02f, -5.60751744e-02f, -3.99580859e-02f, -3.40184718e-02f, -5.23113236e-02f, -3.75038162e-02f, -3.82590145e-02f,
  -5.51020503e-02f, 2.56598778e-02f, 2.21169684e-02f, 1.62884016e-02f, 6.77202195e-02f, -3.45197087e-03f, -1.77640002e-02f, 1.03822768e-01f, -3.61367431e-03f, -5.99221624e-02f,
  5.39298579e-02f, -1.05150372e-01f, -2.20676959e-02f, 1.39452666e-02f, -9.94364098e-02f, 8.06994811e-02f, 8.90106708e-02f, 3.46698202e-02f, -6.65078834e-02f, 7.49032125e-02f,
  -1.12379724e-02f, 1.48383662e-01f, 3.74642313e-02f, -5.78876212e-02f, -2.93330606e-02f, -2.35425066e-02f, -7.90140927e-02f, -9.53149330e-03f, 1.00712799e-01f, 5.12164906e-02f,
  6.79569840e-02f, -4.21346836e-02f, -3.08538079e-02f, -1.28176752e-02f, 7.83863198e-03f, -9.58707780e-02f, -4.20787698e-03f, -3.71047668e-02f, 7.97862038e-02f, 4.51002233e-02f,
  1.11413904e-01f, 7.58286119e-02f, -1.09662833e-02f, -1.24796197e-01f, 2.74130013e-02f, -4.01744135e-02f, 6.23039156e-02f, -2.34739613e-02f, 1.05963498e-01f, 3.07106879e-02f,
  -6.86300620e-02f, 2.77486891e-01f, 3.62490788e-02f, -2.17439443e-01f, -1.86728258e-02f, -1.39814362e-01f, -1.71572387e-01f, 1.96770117e-01f, 1.67046979e-01f, 7.57386610e-02f,
  -1.52058937e-02f, 3.89019996e-02f, 1.06038965e-01f, -2.32663438e-01f, -1.64821535e-01f, 1.09464847e-01f, -3.71836632e-01f, -1.59427881e-01f, 9.24284607e-02f, -1.86837614e-01f,
  -2.24778071e-01f, -4.26319271e-01f, -2.23126084e-01f, -5.96641526e-02f, -2.96776026e-01f, -4.64974120e-02f, -2.88855046e-01f, 7.77767971e-02f, -2.18006432e-01f, -1.50558017e-02f,
  9.48513001e-02f, 1.77031294e-01f, 4.42522354e-02f, 8.34675282e-02f, -6.35231286e-02f, -8.18781778e-02f, -1.19026780e-01f, -5.01130857e-02f, 1.00727297e-01f, 1.00177951e-01f,
  -1.81904584e-01f, -1.10708684e-01f, 1.44699216e-02f, 8.77033621e-02f, -2.98182480e-02f, 2.27326341e-02f, 4.82019745e-02f, 6.68332055e-02f, 5.22805154e-02f, -3.20556387e-02f,
  2.00814158e-02f, -1.24150263e-02f, 2.46319082e-03f, 1.13383383e-02f, -2.07260661e-02f, 8.21864139e-03f, -2.87926942e-02f, -4.39341326e-04f, -1.82132144e-02f, -6.29442185e-02f,
  -6.10861816e-02f, -9.43499133e-02f, -5.75021841e-03f, -1.47744436e-02f, 6.77051246e-02f, 1.10115416e-01f, 7.37089943e-03f, -3.29303998e-03f, 2.59314980e-02f, -1.78939268e-01f,
  -5.13657965e-02f, -2.07047667e-02f, -3.85232270e-02f, -7.12243915e-02f, -1.44345924e-01f, 1.02666384e-02f, -3.62744331e-02f, -7.66057381e-03f, -1.92516372e-01f, 3.21587920e-02f,
  7.39388168e-02f, -5.62619418e-02f, 5.75549863e-02f, -6.05460666e-02f, -5.72590008e-02f, 1.49130486e-02f, -6.84920400e-02f, 3.90176685e-03f, 5.95186763e-02f, -5.58181591e-02f,
  1.59310065e-02f, 2.32867114e-02f, 9.76954773e-02f, 1.29186079e-01f, 8.35433081e-02f, 2.87220199e-02f, -6.67632297e-02f, -1.04013970e-02f, -2.12620422e-02f, 8.18714406e-03f,
  -1.61952093e-01f, -5.17173782e-02f, -1.48139447e-01f, 8.92495289e-02f, -2.50242427e-02f, -3.75823714e-02f, -1.28732830e-01f, 1.29933655e-01f, -7.50567317e-02f, 5.29151149e-02f,
  -3.32862209e-03f, 2.73991786e-02f, 2.89103724e-02f, -1.04632005e-01f, 4.32351604e-02f, -4.37906533e-02f, 7.85307288e-02f, 6.93102330e-02f, -8.86666179e-02f, -3.51465680e-02f,
  2.09221989e-01f, -2.08930653e-02f, -2.08535224e-01f, 8.24685618e-02f, -8.34032893e-02f, 3.94087732e-01f, 3.98099035e-01f, -7.85059258e-02f, 2.19665587e-01f, 3.55357975e-01f,
  1.23570554e-01f, 1.70349002e-01f, 2.70071235e-02f, 4.01475728e-01f, 2.96857625e-01f, 2.78945267e-01f, 2.82382458e-01f, 2.64342487e-01f, 8.43214616e-02f, 1.28181204e-01f,
  1.66112766e-01f, 3.69283825e-01f, -1.89202383e-01f, -8.57399181e-02f, 9.98377800e-03f, -2.20648199e-01f, -1.50733396e-01f, -2.16205627e-01f, 2.27776058e-02f, 9.93077531e-02f,
  1.56752989e-02f, 1.20553179e-02f, 1.14509063e-02f, 3.19543071e-02f, -5.35408109e-02f, 1.92049351e-02f, 7.46104866e-02f, -1.27037093e-01f, -3.19313034e-02f, -8.63318965e-02f,
  1.08932659e-01f, 9.62138996e-02f, 8.11467841e-02f, -1.51157109e-02f, -6.46013469e-02f, -9.90792587e-02f, -1.31649682e-02f, -1.10355228e-01f, -5.88069484e-02f, 7.69807302e-05f,
  -7.13197142e-02f, -6.27198368e-02f, -1.03756262e-03f, 3.90150584e-02f, -3.09527833e-02f, 7.06760958e-02f, 1.30842656e-01f, -8.00859183e-02f, 6.88001886e-02f, 6.24601878e-02f,
  -3.69042940e-02f, 1.33230045e-01f, 4.16344404e-02f, 9.56543721e-03f, 3.65999937e-02f, -1.19077742e-01f, 1.50053442e-01f, 5.35453372e-02f, -3.41445543e-02f, 7.79244900e-02f,
  -3.27400700e-03f, -1.00764371e-02f, 4.19377759e-02f, 5.88369071e-02f, 1.95706680e-01f, 7.26317614e-02f, -7.71815553e-02f, 5.32265082e-02f, 8.18459243e-02f, -5.53447343e-02f,
  -5.02474792e-02f, 1.47367433e-01f, 3.03246803e-03f, -7.49554336e-02f, -2.44135298e-02f, -3.14985253e-02f, 8.39910880e-02f, 6.69911429e-02f, -3.74210365e-02f, -3.29195112e-02f,
  1.10896334e-01f, 8.74501467e-02f, -2.81892028e-02f, 4.92157191e-02f, -7.74544403e-02f, -1.96578745e-02f, 6.08700775e-02f, -5.59955612e-02f, -1.08472435e-02f, -3.52832191e-02f,
  1.95306470e-03f, 2.78341193e-02f, 4.48178723e-02f, -4.71802652e-02f, -8.73093754e-02f, 4.63402905e-02f, 1.84246629e-01f, -2.60146223e-02f, -7.43722618e-02f, -6.59708679e-02f,
  -1.14953876e-01f, 4.23096754e-02f, -1.44946957e-02f, 6.47207536e-03f, -9.87958442e-03f, -3.77937034e-02f, 6.75581247e-02f, -3.29761244e-02f, -1.56784281e-02f, 9.00628511e-03f,
  2.81710595e-01f, -3.00822333e-02f, 2.03288868e-01f, 4.32411343e-01f, 2.87615252e-03f, -4.96678278e-02f, 1.04360329e-02f, 4.86310497e-02f, 3.96538526e-01f, -1.10997684e-01f,
  -8.42895433e-02f, 6.37363717e-02f, -1.17744066e-01f, 6.83248192e-02f, -2.88998961e-01f, -1.55779079e-01f, 9.47624967e-02f, 9.15082842e-02f, 6.75869361e-02f, 1.76728874e-01f,
  1.17134620e-02f, -2.49279320e-01f, -1.69333532e-01f, -2.32611760e-01f, 1.57353610e-01f, 9.06545222e-02f, -2.09955320e-01f, -8.93321484e-02f, -1.73166767e-02f, -2.27249131e-01f,
  1.08484253e-01f, 8.85210782e-02f, -5.35326898e-02f, -3.66465226e-02f, 1.83841005e-01f, -1.02174155e-01f, 2.09760778e-02f, -1.92877263e-01f, 4.90606762e-02f, 1.33853704e-01f,
  5.44401146e-02f, 3.69577073e-02f, 2.74521788e-03f, -9.80671197e-02f, 9.70502570e-02f, 1.06398806e-01f, 1.21571943e-01f, 1.51348636e-01f, -4.20604795e-02f, 1.58603955e-02f,
  1.13278039e-01f, 1.41044721e-01f, 1.30347416e-01f, -4.30791192e-02f, 4.69623581e-02f, 8.83448273e-02f, -6.76331967e-02f, -7.04104360e-03f, 1.38437778e-01f, 2.74031721e-02f,
  -9.77939814e-02f, 2.12223958e-02f, -6.99576885e-02f, 9.85965058e-02f, 4.22124043e-02f, 2.97192559e-02f, 2.78859260e-03f, -4.84242812e-02f, 8.88735801e-02f, 5.28414100e-02f,
  1.57055575e-02f, 7.19742849e-02f, 9.01303366e-02f, 2.26494502e-02f, 1.15165249e-01f, 2.42236760e-02f, -4.35931385e-02f, 4.89256047e-02f, 1.52197808e-01f, -7.08456244e-03f,
  -1.33940950e-01f, -4.53776047e-02f, 1.08353486e-02f, 2.15763263e-02f, 4.30467650e-02f, 1.73774570e-01f, -1.20570483e-02f, 8.34403336e-02f, 4.25939076e-02f, -6.90960139e-02f,
  5.17790392e-03f, -1.35147959e-01f, 1.88671015e-02f, -4.08982374e-02f, 3.55902910e-02f, -5.68983741e-02f, 1.54712368e-02f, -2.90995128e-02f, 2.62597036e-02f, -8.80145729e-02f,
  6.84679393e-03f, 3.58416475e-02f, 2.00356804e-02f, -1.15675300e-01f, 3.79744209e-02f, -4.75648567e-02f, 1.13099078e-02f, -3.52627672e-02f, -4.24314775e-02f, 5.14298640e-02f,
  -5.21948840e-03f, 6.27592653e-02f, 5.25459833e-02f, 1.09350003e-01f, -2.03617755e-03f, -5.37501164e-02f, -1.56627651e-02f, -1.97086968e-02f, 2.37823781e-02f, 4.41101193e-02f,
  4.58154052e-01f, -2.28065461e-01f, 1.15324944e-01f, 3.13135535e-01f, 2.12066188e-01f, -1.00247383e-01f, 5.91719523e-02f, 3.80131379e-02f, 2.20276088e-01f, -2.49540687e-01f,
  -6.24203160e-02f, 9.98833627e-02f, -2.51769871e-01f, 5.90043291e-02f, 3.92509252e-02f, -3.39938700e-01f, 6.63321167e-02f, -8.69988203e-02f, 9.80860293e-02f, 1.26352489e-01f,
  2.08779633e-01f, -5.49901091e-02f, 5.78021109e-02f, -1.37626082e-01f, 2.39050850e-01f, 1.21285796e-01f, -1.24145366e-01f, -1.30845353e-01f, 3.30455229e-02f, 4.93100211e-02f,
  2.24312749e-02f, 1.09395139e-01f, 8.37792158e-02f, 2.17806082e-02f, 2.82232463e-02f, 7.34876702e-03f, 7.89199024e-02f, -2.32301261e-02f, 6.20568097e-02f, -6.59865662e-02f,
  -7.20023289e-02f, 6.64622486e-02f, 5.88373933e-03f, -4.29637395e-02f, 1.54727265e-01f, 3.28620709e-02f, 1.13879137e-01f, 1.07800610e-01f, 1.18623048e-01f, 1.10758834e-01f,
  3.33863162e-02f, 2.78826859e-02f, 7.13495389e-02f, -7.47184977e-02f, 1.25549575e-02f, 4.10623290e-02f, -4.05463576e-02f, 3.14260833e-02f, -2.16907375e-02f, 6.08411580e-02f,
  -5.83930463e-02f, 5.38465567e-02f, 2.56842412e-02f, -2.97629889e-02f, -1.39433760e-02f, 1.50410393e-02f, -6.11301996e-02f, -1.05789548e-03f, -6.85428604e-02f, -1.16671614e-01f,
  -3.18481997e-02f, 7.66570270e-02f, -6.78927600e-02f, -6.25806972e-02f, -2.60060690e-02f, 1.25069141e-01f, -5.74448407e-02f, -8.11467916e-02f, 1.41660869e-02f, 2.61073504e-02f,
  -8.40678345e-04f, 1.80404987e-02f, 8.45001312e-04f, 1.22640885e-01f, 2.74371658e-03f, -9.96820033e-02f, -2.90787201e-02f, 4.99204881e-02f, 5.17858006e-02f, -7.74980113e-02f,
  -2.02712432e-01f, -5.12067616e-01f, -6.72755539e-02f, -1.86675936e-02f, -1.76481947e-01f, -6.29427433e-02f, 3.72062922e-02f, -2.19766563e-03f, -1.57009199e-01f, 8.73485859e-03f,
  3.31156654e-03f, 3.27786691e-02f, -1.28541976e-01f, 6.88184649e-02f, 4.08399821e-04f, -4.23782952e-02f, 5.66509366e-03f, -1.23747073e-01f, 1.20035000e-02f, -8.52857716e-03f,
  2.23199464e-02f, -3.40077542e-02f, 1.83782503e-02f, 8.48231539e-02f, -1.62834227e-02f, -8.63207951e-02f, 1.00025639e-01f, 1.31207900e-02f, -5.74379265e-02f, -3.56673598e-02f,
  2.12896571e-01f, -2.84418494e-01f, -3.19245309e-01f, -2.37020571e-02f, 2.81629890e-01f, 1.71762049e-01f, -1.97010189e-02f, 1.75143555e-01f, -9.29665193e-02f, 1.59030914e-01f,
  4.60242219e-02f, -2.67723233e-01f, -1.58475339e-01f, 3.75543684e-02f, -4.21665981e-02f, -2.97043264e-01f, 1.41321719e-01f, -1.38892196e-02f, -1.17080912e-01f, 3.02563831e-02f,
  1.24108046e-01f, 3.60145539e-01f, -4.67163362e-02f, 3.22744638e-01f, 2.89884120e-01f, 9.12821665e-02f, 3.60758573e-01f, 3.09267528e-02f, 1.93208605e-01f, 7.93965980e-02f,
  -3.39718279e-03f, -4.81516868e-02f, -1.09049007e-02f, -8.24446753e-02f, 2.01826654e-02f, 1.23183466e-01f, 5.69208413e-02f, -8.24129432e-02f, -8.24372098e-02f, -1.12639017e-01f,
  -1.13831740e-02f, 6.65122792e-02f, 5.74178882e-02f, 9.32264924e-02f, 1.22219972e-01f, 2.87311040e-02f, -1.68602929e-01f, -1.15809999e-02f, -1.36672080e-01f, -1.03005156e-01f,
  -1.14128627e-01f, -4.76584509e-02f, 7.40758330e-02f, -7.80089349e-02f, -1.33318365e-01f, 2.62207203e-02f, 3.40549797e-02f, -9.50594097e-02f, 2.28527691e-02f, 5.15165254e-02f,
  9.64320526e-02f, 1.07347287e-01f, 7.41818249e-02f, -2.08998621e-02f, -8.37373585e-02f, -1.18524343e-01f, 9.02983323e-02f, -6.33995384e-02f, -8.04751664e-02f, 5.53668523e-03f,
  2.43679644e-03f, 5.12531102e-02f, 1.00433780e-03f, 8.14294294e-02f, 1.80210397e-01f, 6.72420487e-02f, 9.24482383e-03f, -4.42826077e-02f, -8.64123553e-03f, -6.70331120e-02f,
  1.41178230e-02f, 3.50524746e-02f, -8.25301334e-02f, 7.23081008e-02f, 1.05649326e-03f, -1.70257688e-02f, 1.10073946e-01f, 5.93337715e-02f, 9.92641225e-03f, 3.69541124e-02f,
  9.30838380e-03f, 5.71635365e-02f, -4.27994318e-02f, 2.77004465e-02f, -1.64468810e-01f, 1.18867502e-01f, 9.89845619e-02f, -6.16267174e-02f, -4.42579668e-03f, 5.53543605e-02f,
  1.10300519e-01f, 4.53761369e-02f, 1.35339290e-01f, 1.05983596e-02f, 3.87143195e-02f, 8.63101333e-02f, 2.17113700e-02f, 4.00867127e-02f, -2.13774038e-03f, -2.06114128e-02f,
  8.03257748e-02f, 7.71354735e-02f, 5.97905703e-02f, 4.27059680e-02f, -5.97557090e-02f, 5.14382217e-03f, 1.03949010e-01f, 8.62415042e-03f, -3.99661250e-02f, -1.15774676e-01f,
  1.78710610e-01f, -2.94142097e-01f, -2.43412200e-02f, -3.58632088e-01f, 7.97486976e-02f, 8.20485726e-02f, -9.26918983e-02f, -2.30912790e-01f, -2.33853206e-01f, -2.84282565e-01f,
  -2.48361066e-01f, -3.66824493e-02f, -1.29217461e-01f, -1.71459839e-01f, 3.91730696e-01f, 1.76959127e-01f, -1.51195258e-01f, -1.78274348e-01f, 8.01820680e-02f, -1.38900280e-01f,
  3.94744799e-02f, -1.40244216e-01f, 1.48366973e-01f, -1.31648853e-02f, -9.98344049e-02f, -1.22072868e-01f, 4.61808965e-02f, 2.12073345e-02f, -1.54667377e-01f, -1.24495877e-02f,
  2.85374168e-02f, -1.07085839e-01f, 5.55969104e-02f, 6.05401117e-03f, 2.85754874e-02f, 3.82571295e-02f, 7.73289707e-03f, 1.57623619e-01f, -2.54175700e-02f, -2.52182572e-03f,
  -8.42548013e-02f, -2.07630675e-02f, -5.78090847e-02f, 5.60800210e-02f, -1.31302446e-01f, -9.51515958e-02f, -1.61250532e-02f, 1.13929555e-01f, 2.36240979e-02f, 1.99649725e-02f,
  6.02848902e-02f, -3.10194902e-02f, -8.48889202e-02f, -5.10186628e-02f, -1.80435002e-01f, -8.37794915e-02f, 5.74872978e-02f, -8.36206675e-02f, -1.70298278e-01f, -1.48737831e-02f,
  -9.28625166e-02f, 1.50621468e-02f, 2.71273553e-02f, -1.32222429e-01f, -3.64904851e-02f, 1.70184765e-02f, 2.68607922e-02f, -4.05231193e-02f, -4.23373980e-03f, -8.29406455e-03f,
  -8.63447711e-02f, -2.84462646e-02f, 8.66744854e-03f, 2.08653975e-02f, 1.01480866e-02f, 1.19429216e-01f, 1.15580730e-01f, -1.35896197e-02f, -7.40340799e-02f, 5.75431250e-02f,
  1.59394816e-02f, 3.51753198e-02f, -5.61704533e-03f, -4.37223278e-02f, -6.38136044e-02f, -6.54075891e-02f, -8.01188573e-02f, -3.62097695e-02f, 4.41282690e-02f, -1.04349732e-01f,
  -3.02553177e-02f, -1.22850545e-01f, -2.16685701e-02f, -7.36590996e-02f, 1.03150368e-01f, 8.88525993e-02f, 9.21411291e-02f, -4.62643430e-02f, -8.69743749e-02f, 4.51267175e-02f,
  -9.15144831e-02f, -1.69181768e-02f, 2.14114152e-02f, -8.91233794e-03f, -1.34033471e-01f, -3.51283364e-02f, -2.89650578e-02f, 6.21176250e-02f, 1.96610279e-02f, -5.63043132e-02f,
  6.07998595e-02f, 4.57600020e-02f, -1.24957502e-01f, -8.07164237e-02f, -1.91264316e-01f, -5.73361292e-02f, 1.14864975e-01f, -7.96715766e-02f, -1.67334080e-01f, -1.81683436e-01f,
  2.08696708e-01f, -6.16726317e-02f, -2.31246278e-01f, -1.41209841e-01f, -2.82004565e-01f, -1.14939295e-01f, -1.11768514e-01f, -6.56508580e-02f, -5.06791249e-02f, 2.49849707e-01f,
  -3.25053990e-01f, 2.13951111e-01f, 1.34993598e-01f, -2.77948081e-01f, -3.23067904e-02f, 9.41661298e-02f, -7.30717927e-02f, 1.20621644e-01f, -7.43841529e-02f, 1.10888973e-01f,
  -1.32721454e-01f, -6.03328049e-02f, -2.03810245e-01f, -4.47863303e-02f, -2.25814953e-01f, -2.31106877e-01f, -1.80792511e-01f, -2.43347943e-01f, -2.01751947e-01f, -2.75396377e-01f,
  -1.83251292e-01f, -1.16870679e-01f, -2.67836824e-02f, 1.30416155e-01f, -2.30014976e-03f, 5.99749759e-02f, -3.62839326e-02f, -1.07897662e-01f, -5.54212928e-02f, -2.77813803e-03f,
  9.56359506e-02f, 8.64055082e-02f, 3.86115238e-02f, -1.06865838e-01f, -2.33750441e-03f, -5.72618172e-02f, 5.56345060e-02f, 3.19730975e-02f, 5.82366250e-02f, 1.00231981e-02f,
  5.80057167e-02f, 3.15671228e-02f, -4.55444083e-02f, 1.18353248e-01f, -3.76828127e-02f, -3.51501629e-02f, 2.91782841e-02f, -7.55086839e-02f, 1.42183779e-02f, 2.99743116e-02f,
  4.95726466e-02f, 4.99932244e-02f, 2.67792121e-03f, -9.60975140e-02f, -3.67343985e-02f, -4.96617742e-02f, -5.07275164e-02f, -9.83489379e-02f, -7.51212984e-02f, 5.07314689e-03f,
  -3.13320593e-03f, -3.53643633e-02f, 1.87592134e-02f, 8.57662484e-02f, 8.14564079e-02f, 4.98224869e-02f, -6.37903716e-03f, 5.12172356e-02f, 3.23657831e-03f, 1.73057906e-05f,
  -7.15993671e-03f, 8.32079425e-02f, 2.29895599e-02f, 1.18882218e-02f, -9.82822627e-02f, -9.38498825e-02f, 5.98003045e-02f, 3.41086723e-02f, -7.03714490e-02f, 3.23485769e-02f,
  2.72836573e-02f, 6.08557984e-02f, 2.13332707e-03f, 1.02704465e-01f, 3.01805940e-02f, 9.50791240e-02f, -8.16779137e-02f, 3.11814602e-02f, -6.46529496e-02f, 1.31388426e-01f,
  9.49916765e-02f, -1.85185391e-02f, 6.20553493e-02f, -1.60066217e-01f, 2.91962661e-02f, -2.93618790e-03f, 2.18397275e-01f, 6.62377998e-02f, 7.29680210e-02f, 3.49681266e-02f,
  1.09239712e-01f, 1.34809718e-01f, 2.75681227e-01f, 1.65532723e-01f, 2.26459697e-01f, 1.04210824e-01f, -6.71466663e-02f, -2.92382985e-02f, 2.29608268e-02f, -1.26732439e-02f,
  -1.27755508e-01f, -3.44739318e-01f, -2.58141994e-01f, 1.16105467e-01f, -2.64298543e-02f, 2.25424737e-01f, 3.72928023e-01f, -4.70342338e-02f, -2.35907435e-01f, 2.63289064e-01f,
  3.26166570e-01f, 7.38432407e-02f, 1.46542430e-01f, 4.51507866e-01f, 1.68030947e-01f, 9.10398811e-02f, 2.75602579e-01f, 3.08064878e-01f, -1.95294723e-01f, -8.54830518e-02f,
  1.86452139e-02f, 2.62924910e-01f, 1.83450624e-01f, -1.03399090e-01f, 1.37186453e-01f, -9.64452624e-02f, 1.78848699e-01f, 1.06254788e-02f, 2.84011245e-01f, 2.37228483e-01f,
  1.56606480e-01f, -1.52682006e-01f, 1.03702652e-03f, -8.55479762e-02f, -4.45546582e-02f, 1.12312995e-01f, 5.23689501e-02f, 1.77791819e-01f, 6.92365617e-02f, -6.73153177e-02f,
  1.04252450e-01f, 2.78814752e-02f, -6.08914644e-02f, -2.00841799e-02f, -1.27716601e-01f, -1.11111805e-01f, 1.30418902e-02f, 8.88630282e-03f, -4.56821956e-02f, 5.47942035e-02f,
  -4.87063751e-02f, -8.43963623e-02f, 2.47939657e-02f, 4.90997583e-02f, -2.68815421e-02f, -7.58670717e-02f, -2.06131134e-02f, -5.88589385e-02f, 2.42729615e-02f, -8.77543613e-02f,
  -1.69722997e-02f, -5.77988103e-02f, -1.02103397e-01f, -2.43593715e-02f, -6.85225427e-02f, 1.36750061e-02f, 6.78521022e-02f, 1.04263522e-01f, -5.58460616e-02f, -2.98708342e-02f,
  -5.56809548e-03f, -8.31854269e-02f, -2.16374453e-02f, 7.70795196e-02f, 8.62709712e-03f, 1.87892113e-02f, 3.62347215e-02f, 3.09377164e-02f, -5.51652908e-02f, 5.99146597e-02f,
  1.26579255e-01f, -2.92347185e-02f, -7.99011067e-03f, 4.06028591e-02f, 5.92681207e-02f, 7.78080076e-02f, 6.21070750e-02f, -4.19197418e-02f, 2.78116520e-02f, 3.75174917e-02f,
  -5.69051690e-02f, -2.89871216e-01f, -3.70926671e-02f, -3.11619304e-02f, 4.23946697e-03f, -9.22996402e-02f, -8.55600834e-02f, -4.74670790e-02f, 1.15517564e-02f, -1.06902942e-01f,
  -6.10323325e-02f, 1.02133714e-02f, -7.56258741e-02f, 1.55769503e-02f, -7.31426105e-02f, -6.31785989e-02f, 1.05856568e-01f, 2.36842129e-02f, 8.68775249e-02f, -4.91744280e-02f,
  4.41031605e-02f, -1.19172046e-02f, 3.56084891e-02f, 1.27514265e-02f, 8.57383907e-02f, 6.31959811e-02f, -1.07821822e-01f, -7.72091895e-02f, -1.44859636e-02f, -1.63138565e-02f,
  3.74331832e-01f, 2.90659338e-01f, 1.63544834e-01f, 3.78316820e-01f, 3.33454847e-01f, 3.46491516e-01f, 2.70127892e-01f, 2.18623266e-01f, 4.84381557e-01f, -3.52128558e-02f,
  -1.10589050e-01f, 1.78895667e-01f, -2.11829543e-01f, 2.64937937e-01f, -6.86546266e-02f, -8.09010416e-02f, 3.95932168e-01f, 2.18173087e-01f, 2.85986543e-01f, 7.29774088e-02f,
  2.17664585e-01f, 2.03950871e-02f, -2.64131725e-01f, -1.81773022e-01f, 1.44557685e-01f, -3.94512899e-02f, -3.25831741e-01f, -2.07503319e-01f, -1.02588966e-01f, 2.77202763e-02f,
  -2.18785480e-02f, 1.73571169e-01f, -4.03357483e-02f, -3.33347507e-02f, 2.21280940e-02f, 4.85520959e-02f, -3.45130600e-02f, -1.36291936e-01f, -5.28246760e-02f, -3.86336669e-02f,
  -1.97882578e-02f, -1.31505832e-01f, -4.31518517e-02f, 9.85695645e-02f, 1.57129839e-01f, -2.97906529e-03f, -6.02759840e-03f, -1.78294089e-02f, -8.39581713e-02f, 2.95713842e-02f,
  -4.08909731e-02f, -1.97162218e-02f, 4.10205461e-02f, 3.76740634e-03f, 3.65782455e-02f, 5.53312562e-02f, 6.82005286e-02f, -3.46895717e-02f, 1.20068789e-02f, 1.67260155e-01f,
  -5.74923260e-03f, 1.31463602e-01f, -5.69551904e-03f, -8.20449889e-02f, 1.08771496e-01f, -4.99580614e-02f, 2.21775230e-02f, 2.72297133e-02f, 8.55307132e-02f, 9.60062072e-02f,
  4.15819660e-02f, 1.34909183e-01f, 3.67598310e-02f, 1.21849757e-02f, 2.32519627e-01f, 7.38603473e-02f, -2.72680856e-02f, 5.07549681e-02f, 1.64820075e-01f, -5.84094115e-02f,
  -2.48105098e-02f, -3.06898654e-02f, -1.04959890e-01f, -8.68085399e-02f, -8.99275839e-02f, 8.53295252e-02f, 3.08966991e-02f, 2.08662748e-02f, -1.15611523e-01f, 3.77904996e-02f,
  2.21854076e-01f, 2.96226054e-01f, -7.71113113e-02f, -3.69809233e-02f, -3.83481495e-02f, 4.80937138e-02f, 1.63790271e-01f, 1.03897667e-02f, 7.76238590e-02f, -4.54506604e-03f,
  6.53131455e-02f, 3.95249613e-02f, -9.51420330e-03f, -4.46277224e-02f, -7.66800269e-02f, 5.13703600e-02f, -1.09013923e-01f, -1.48558458e-02f, -1.65157124e-01f, -6.03689328e-02f,
  -8.50001201e-02f, 4.73885760e-02f, -6.20962866e-02f, 1.22288816e-01f, 8.29632487e-03f, -1.07193001e-01f, 1.00287512e-01f, -3.25776190e-02f, -4.04336192e-02f, 4.83372323e-02f,
  2.34167818e-02f, -1.55257225e-01f, -9.57695618e-02f, 1.42072782e-01f, 5.66193499e-02f, 2.93420315e-01f, 4.22439218e-01f, -2.53693372e-01f, -2.72596478e-01f, 9.11419317e-02f,
  1.13245258e-02f, 8.63086730e-02f, -1.20254025e-01f, 3.94811451e-01f, 3.11122090e-01f, 4.31683399e-02f, 2.47399852e-01f, 1.84426740e-01f, -1.33162528e-01f, -2.49167070e-01f,
  -5.90805151e-02f, 3.28245133e-01f, 2.72865500e-02f, -8.40208605e-02f, 1.68989956e-01f, -8.19242522e-02f, 1.14708327e-01f, -4.87375185e-02f, 2.36127734e-01f, 2.95326531e-01f,
  1.01004012e-01f, -3.01350560e-02f, -8.14444497e-02f, 5.14504276e-02f, -1.45265600e-02f, 1.40066177e-01f, 2.27814674e-01f, 1.70994595e-01f, 9.50040743e-02f, -5.24930805e-02f,
  7.46158063e-02f, 1.88387156e-01f, 5.05499430e-02f, 3.84206511e-02f, -8.40045288e-02f, -6.51498437e-02f, -1.05183870e-04f, -1.48336872e-01f, -6.34847209e-02f, -7.98342228e-02f,
  -9.60753784e-02f, -9.01109204e-02f, -1.07826646e-02f, 1.06052153e-01f, -1.02771185e-02f, 4.26500626e-02f, 5.88090643e-02f, -5.53187467e-02f, -9.49234422e-03f, 3.58956158e-02f,
  -6.42821416e-02f, 7.87981600e-02f, -7.79723898e-02f, 4.43280637e-02f, -3.90049629e-03f, 3.91792692e-02f, 3.13609056e-02f, -2.19633803e-02f, 1.85676124e-02f, 2.49119643e-02f,
  -1.64729990e-02f, -5.86927980e-02f, 3.31046470e-02f, 6.15286939e-02f, 4.54837456e-02f, -1.89043023e-02f, -1.34516424e-02f, 9.62225497e-02f, -1.67034306e-02f, -2.70440336e-02f,
  4.83186767e-02f, 5.55735715e-02f, 1.85276661e-02f, -7.69214407e-02f, -2.40252484e-02f, -1.55791631e-02f, 1.50324360e-01f, -6.82668714e-03f, -1.29191294e-01f, 2.92189196e-02f,
  6.06250092e-02f, 1.38803467e-03f, -4.06583473e-02f, 1.15764737e-01f, -2.02684030e-02f, 5.33074103e-02f, 1.07556112e-01f, -5.20307459e-02f, -7.42958579e-03f, -1.29834656e-02f,
  5.18461317e-02f, 2.59082811e-03f, 7.73734376e-02f, -4.29231897e-02f, 2.08820328e-02f, -1.07000932e-01f, 1.56362653e-01f, -3.85327823e-02f, -9.22456309e-02f, -1.16295606e-01f,
  5.26679493e-02f, -3.59263271e-02f, 8.63615274e-02f, 3.33321244e-02f, 9.04839206e-03f, 1.13281440e-02f, -7.04576001e-02f, -2.02700160e-02f, -3.32025029e-02f, -2.19659205e-03f,
  -1.17646143e-01f, -1.85470611e-01f, -6.91745877e-02f, 1.14776902e-01f, 2.11125135e-01f, -2.74537019e-02f, 5.19690029e-02f, 6.59267008e-02f, 8.09669495e-02f, -8.52135345e-02f,
  -3.93637195e-02f, -2.82953888e-01f, -1.47026286e-01f, -2.48489186e-01f, -2.12360337e-01f, -3.77171695e-01f, 7.67824659e-03f, -1.11702070e-01f, -8.75948276e-03f, 8.75511691e-02f,
  -5.00110574e-02f, -1.10674255e-01f, -1.05256461e-01f, 9.94711742e-02f, 2.45914049e-02f, 1.59031600e-01f, 2.30462566e-01f, 1.68017134e-01f, 9.20901820e-02f, 1.11708887e-01f,
  3.35922204e-02f, -1.51782393e-01f, -5.05731404e-02f, 1.37975728e-02f, 1.56875297e-01f, -3.34374607e-02f, -4.15268466e-02f, -6.79830983e-02f, 1.00901432e-01f, 1.63083281e-02f,
  3.43001746e-02f, -4.36554849e-02f, 9.38502082e-04f, -9.65849012e-02f, 1.68608829e-01f, -4.90773953e-02f, -5.79123050e-02f, 4.52550799e-02f, 7.34807400e-04f, -1.01023622e-01f,
  -1.12558179e-01f, 3.11371572e-02f, 1.27383322e-01f, 8.40246230e-02f, 8.20461512e-02f, 5.40760681e-02f, 3.08498996e-03f, 4.55945358e-02f, 1.23905979e-01f, 6.67634830e-02f,
  -3.22164297e-02f, -2.08880305e-02f, -1.29155263e-01f, -3.66761908e-02f, -3.61557305e-02f, 8.97304416e-02f, 5.89110404e-02f, 1.59402564e-02f, 1.45762578e-01f, 2.31845211e-02f,
  9.98489708e-02f, 4.04677428e-02f, 6.97724447e-02f, -3.63761820e-02f, -4.10647839e-02f, -9.34760645e-02f, 6.08612634e-02f, 2.27316096e-03f, 8.12434182e-02f, -4.65359725e-02f,
  -7.57090077e-02f, 9.81983356e-03f, 5.54099642e-02f, 1.69730633e-02f, -4.49568890e-02f, 6.27445504e-02f, 1.64876727e-03f, -3.01062949e-02f, -4.38442826e-03f, 1.39939591e-01f,
  1.62272915e-01f, 9.29648727e-02f, 7.53160864e-02f, 1.74639057e-02f, 6.90755695e-02f, -7.29629770e-02f, -1.54677555e-01f, -1.00509925e-02f, 9.66921002e-02f, -1.70581400e-01f,
  1.46765083e-01f, 1.07085921e-01f, 5.84490821e-02f, -7.45468810e-02f, 2.01755106e-01f, -4.19734344e-02f, 5.63762784e-02f, 1.35500714e-01f, 2.45893374e-01f, 7.57022053e-02f,
  -2.94311829e-02f, 9.56855044e-02f, 7.05223829e-02f, 6.79526106e-02f, 6.07580058e-02f, -7.35974684e-03f, 3.38763557e-03f, 3.52376625e-02f, 1.61978260e-01f, 6.99409470e-02f,
  1.66567773e-01f, -1.28535450e-01f, -1.75973445e-01f, -1.58368424e-01f, -9.25179720e-02f, -1.46028355e-01f, -2.89719999e-01f, -5.24519980e-02f, -2.08054096e-01f, -5.44104502e-02f,
  -5.86155653e-02f, 2.12759860e-02f, -9.54561010e-02f, 1.62517710e-03f, 9.99156237e-02f, 1.64236546e-01f, -3.51303965e-02f, -1.82904936e-02f, 1.61781669e-01f, 1.41851595e-02f,
  2.04503790e-01f, 1.35437891e-01f, 2.54949838e-01f, 2.63738453e-01f, -4.99370284e-02f, 7.85063952e-02f, 2.53580838e-01f, 2.33932328e-03f, 1.01485841e-01f, 5.97095713e-02f,
  -1.06140738e-02f, 2.90437900e-02f, -8.21259394e-02f, -2.30931230e-02f, 3.80935334e-02f, -2.23375224e-02f, 2.47503966e-02f, -5.24970070e-02f, -9.02759507e-02f, 1.84709374e-02f,
  6.73833443e-03f, 4.16984223e-02f, -8.49644188e-03f, -4.50082123e-02f, -9.05871466e-02f, -9.71360356e-02f, 2.05495469e-02f, 4.06028666e-02f, -5.53540774e-02f, 8.15083161e-02f,
  2.74997298e-02f, -3.17340568e-02f, -6.70446977e-02f, 1.01219796e-01f, -8.67861584e-02f, 1.76285841e-02f, -6.97406882e-04f, -3.59092504e-02f, -6.60428852e-02f, -3.63599174e-02f,
  5.65561317e-02f, 4.04723175e-02f, -1.12762488e-02f, -1.24420397e-01f, -3.92862894e-02f, -7.86813870e-02f, -3.44292633e-02f, -8.21842328e-02f, -2.24102158e-02f, -5.82780205e-02f,
  -5.23693115e-02f, -1.02935687e-01f, -2.66817193e-02f, 1.28670326e-02f, 4.25631404e-02f, 1.35332033e-01f, -3.80854979e-02f, -6.77054375e-02f, -1.07641608e-01f, -5.16067110e-02f,
  -3.77050787e-02f, 4.72630486e-02f, 4.46445355e-03f, 9.34068114e-03f, -7.18650967e-02f, -5.26195988e-02f, 4.68294844e-02f, -5.53457811e-02f, -4.30246675e-03f, -5.92873432e-02f,
  4.47084829e-02f, 1.18915990e-01f, -6.18557911e-03f, -4.62478064e-02f, -5.01045138e-02f, -3.44597884e-02f, -3.89108621e-02f, -1.74553823e-02f, -2.72262674e-02f, 7.00801015e-02f,
  2.49545947e-02f, -6.53153807e-02f, 2.87289657e-02f, -1.38322720e-02f, -1.48170412e-01f, -3.18358131e-02f, 3.06170210e-02f, -1.77100848e-03f, -7.97332227e-02f, 1.03369072e-01f,
  1.13707878e-01f, -9.82727949e-03f, -6.15031160e-02f, -3.76211926e-02f, -3.99858914e-02f, 4.74789925e-02f, 2.82513839e-03f, 2.61821263e-02f, -9.12834108e-02f, -9.67125595e-02f,
  1.80281520e-01f, 6.82327077e-02f, 3.09293985e-01f, 1.30313367e-01f, 2.55071431e-01f, 3.13772380e-01f, 9.53344852e-02f, 2.89626926e-01f, 4.31946993e-01f, -6.84192851e-02f,
  -7.24849552e-02f, -6.16806000e-02f, -1.13635674e-01f, -1.03802584e-01f, 2.43201330e-01f, 7.87892193e-03f, 9.10698529e-03f, -1.40784562e-01f, 3.49222869e-02f, -4.32527550e-02f,
  -6.05903529e-02f, -2.92908251e-01f, -2.20403031e-01f, -2.47083038e-01f, -4.55794372e-02f, -7.18818605e-02f, -2.61295795e-01f, -9.00175050e-02f, -2.51998723e-01f, 2.34730821e-02f,
  6.35656342e-02f, -7.25529790e-02f, -7.39501640e-02f, -1.37172574e-02f, 1.34781180e-02f, -1.45822704e-01f, -1.75947130e-01f, -2.34108567e-02f, 1.96181145e-02f, 9.82544036e-04f,
  -1.94225848e-01f, -3.27313803e-02f, 1.77835226e-02f, 5.53928055e-02f, 1.24170773e-01f, 1.28577068e-01f, 5.78791201e-02f, 4.86959815e-02f, -4.81781410e-03f, 9.60599780e-02f,
  1.25189826e-01f, 1.30283520e-01f, 1.09077811e-01f, -6.22931160e-02f, 4.40017097e-02f, 1.17435805e-01f, 5.41771017e-03f, 6.90006018e-02f, 8.94162655e-02f, 1.98524445e-02f,
  -1.31393492e-01f, -1.83022469e-02f, 1.30797634e-02f, 6.55574873e-02f, 1.20925978e-01f, 9.56558902e-03f, 9.74735711e-04f, -2.48536319e-02f, 5.91209941e-02f, -6.74396902e-02f,
  1.61539800e-02f, -4.89659943e-02f, 4.96320166e-02f, 6.44259676e-02f, -2.09301814e-01f, -1.28745232e-02f, -2.27104053e-02f, -1.34946322e-02f, -8.35388228e-02f, 4.71412390e-02f,
  -1.51293904e-01f, -7.91447759e-02f, 1.89569797e-02f, 1.16499905e-02f, -1.84138119e-02f, 1.42116979e-01f, -7.42534697e-02f, 1.18176162e-01f, -5.53662814e-02f, -1.82546273e-01f,
  5.53162470e-02f, -2.40468279e-01f, -6.33907840e-02f, -5.50207794e-02f, -9.36246365e-02f, 5.08843269e-03f, -8.97956789e-02f, 1.18613698e-01f, -6.97850212e-02f, -6.14099391e-02f,
  -5.73927797e-02f, -1.05432592e-01f, 1.61450561e-02f, 9.86301824e-02f, -5.82811311e-02f, 1.24279782e-01f, -1.24864958e-01f, -1.23106480e-01f, -5.78189231e-02f, -9.28262547e-02f,
  -4.40167449e-02f, 2.68580783e-02f, -6.13335855e-02f, -6.14732020e-02f, -6.57041669e-02f, -3.04917376e-02f, 5.73604256e-02f, 7.20944405e-02f, -8.67100619e-03f, -1.00719362e-01f,
  1.56419918e-01f, 3.57744485e-01f, -6.00073859e-03f, -8.52693841e-02f, -2.83852834e-02f, -1.90859750e-01f, -2.28413492e-02f, 5.74964881e-02f, -3.49112935e-02f, 2.88107604e-01f,
  -3.38006206e-02f, 3.63552898e-01f, 4.44302894e-02f, 1.53204426e-01f, -4.33315575e-01f, -2.21025899e-01f, -1.79701179e-01f, -5.97085617e-02f, -3.58836167e-02f, -1.54286446e-02f,
  -1.08113803e-01f, -9.14268866e-02f, -1.46842837e-01f, 7.60188326e-02f, 2.26333961e-01f, 1.06714934e-01f, -1.44297346e-01f, 1.12695239e-01f, 1.28937125e-01f, 1.96121261e-03f,
  9.50610824e-03f, 1.73429221e-01f, 6.69555739e-02f, -2.35970803e-02f, -2.02222064e-01f, -7.70136761e-03f, 3.64299193e-02f, -1.14993222e-01f, 3.27311829e-02f, -9.08428729e-02f,
  2.49575134e-02f, 1.13808036e-01f, -7.13304207e-02f, 1.47426710e-03f, 9.00179297e-02f, 1.06785847e-02f, 9.13911611e-02f, 2.55406015e-02f, 1.72750279e-01f, 1.39576852e-01f,
  3.73014882e-02f, 2.53220536e-02f, -6.37106374e-02f, -3.56568210e-02f, -3.47064435e-02f, 3.26922722e-02f, 2.50852015e-02f, -2.15031244e-02f, 3.58904041e-02f, -1.63908694e-02f,
  -1.82882650e-03f, 3.33697014e-02f, 2.10616644e-02f, 8.05869047e-03f, -5.05028069e-02f, -1.48554537e-02f, 1.15705959e-01f, 1.68585833e-02f, 1.02452096e-02f, 2.30565500e-02f,
  6.28952263e-03f, 3.93917337e-02f, 1.31059866e-02f, -4.36182804e-02f, 4.68814597e-02f, 9.00914371e-02f, -6.84797317e-02f, 1.56937420e-01f, -7.35854581e-02f, -4.59928103e-02f,
  9.06801447e-02f, -2.10719928e-03f, 2.59668808e-02f, 3.80473323e-02f, -6.61833808e-02f, -5.08307889e-02f, 6.33269548e-02f, 1.02744304e-01f, -5.99768832e-02f, -1.25956148e-01f,
  -5.76156043e-02f, -1.22688897e-01f, -6.58995062e-02f, 3.50126438e-02f, -2.44607590e-02f, -3.44863757e-02f, -6.63853735e-02f, -1.09085590e-01f, -9.44911242e-02f, -5.27958460e-02f,
  -7.94132277e-02f, 2.20714863e-02f, -8.48161280e-02f, -3.09686642e-02f, -1.18819095e-01f, -1.39310747e-01f, 1.37925074e-01f, -3.80607955e-02f, -1.15421630e-01f, 2.00525243e-02f,
  1.45864189e-02f, 2.31084488e-02f, -4.74706441e-02f, -9.28879902e-03f, -3.38504016e-02f, -8.60043149e-03f, 8.58082324e-02f, 4.67034988e-02f, -1.49671631e-02f, -1.01299837e-01f,
  -2.43814632e-01f, 3.25798482e-01f, 2.96520919e-01f, 1.57872468e-01f, -1.17875338e-01f, 1.89619526e-01f, 1.21851161e-01f, 1.82034537e-01f, 2.07799897e-01f, 7.75804371e-02f,
  1.00317769e-01f, 2.88403481e-01f, 1.52177751e-01f, 7.45740309e-02f, 2.12667689e-01f, 1.29787520e-01f, -3.82816829e-02f, 9.99463908e-03f, 6.50620833e-02f, 9.06725749e-02f,
  9.06096771e-02f, 1.85101368e-02f, 9.56906080e-02f, -8.09694678e-02f, -7.58575723e-02f, 3.43790762e-02f, -1.21836141e-01f, 2.39537910e-01f, -3.10417954e-02f, 2.11147234e-01f,
  -1.07298672e-01f, -2.31436994e-02f, -2.67467089e-02f, 6.57404065e-02f, -5.12193367e-02f, -9.67669412e-02f, -1.28828641e-02f, 1.10680312e-01f, 4.54858392e-02f, 9.18785334e-02f,
  7.63612017e-02f, -1.39251143e-01f, 7.41563886e-02f, 4.74182442e-02f, -8.87105390e-02f, 4.46304493e-02f, 1.10148219e-02f, 8.25140625e-02f, 1.69455364e-01f, -4.37807180e-02f,
  1.54904708e-01f, 1.33816525e-01f, -5.41660972e-02f, -4.42503318e-02f, 1.77918166e-01f, -3.26958927e-03f, 3.06943264e-02f, -1.08967824e-02f, 7.00943023e-02f, 2.47780308e-02f,
  -7.80391619e-02f, -1.42649591e-01f, 8.91080941e-04f, 7.52463639e-02f, -1.87009070e-02f, -4.82331030e-03f, 7.08334669e-02f, -2.33014226e-02f, 3.42267714e-02f, 6.92216158e-02f,
  -1.40096068e-01f, 7.66988983e-03f, -2.76745874e-02f, 7.18436716e-03f, 5.31989411e-02f, 1.34071887e-01f, 6.01843335e-02f, -7.21485987e-02f, -7.57636130e-02f, 3.01729292e-02f,
  2.12470721e-02f, -5.57893515e-02f, -5.19424789e-02f, -1.24063969e-01f, -2.49112472e-02f, 1.41391963e-01f, 1.29796639e-01f, -8.94883350e-02f, 9.34511125e-02f, 2.37736076e-01f,
  1.08106278e-01f, 3.11924726e-01f, 1.16377339e-01f, -2.88770837e-03f, -1.35193923e-02f, 5.43006808e-02f, -2.69977786e-02f, -1.13384938e-02f, 2.21392289e-01f, 6.16017655e-02f,
  -1.93750747e-02f, -8.08966160e-02f, 2.71016452e-02f, -1.29126579e-01f, -1.88207384e-02f, 1.05835795e-01f, -1.38211027e-02f, 1.40521914e-01f, 8.34246650e-02f, 3.30694206e-02f,
  1.39867574e-01f, 9.64532234e-03f, 4.32011671e-02f, -6.13724068e-02f, 2.79751606e-02f, 1.12027436e-01f, -6.91783503e-02f, -8.14713985e-02f, 1.71097908e-02f, -3.54951732e-02f,
  -1.95270941e-01f, -2.16174629e-02f, -2.39693075e-01f, -5.37120961e-02f, 3.43489684e-02f, -3.40186417e-01f, -1.33884579e-01f, -1.42660048e-02f, 1.45354256e-01f, 1.90638050e-01f,
  9.38742459e-02f, -1.11216508e-01f, 1.73914105e-01f, -8.26712698e-02f, -3.12549680e-01f, 7.74652734e-02f, -3.15145403e-01f, -1.03219904e-01f, 9.41644683e-02f, -1.66114852e-01f,
  -1.24297552e-01f, 1.04933061e-01f, -1.60645306e-01f, 1.26367375e-01f, 1.45543544e-02f, 5.00845276e-02f, 6.26159087e-02f, -4.29373607e-02f, -7.81098381e-02f, -1.03046875e-02f,
  -1.66228205e-01f, 1.18582673e-01f, -8.66591409e-02f, -8.20224062e-02f, -2.45039716e-01f, -7.18619898e-02f, -7.92847350e-02f, -5.73876221e-03f, -6.38560355e-02f, 2.80131474e-02f,
  -3.06455027e-02f, 1.82816640e-01f, 1.05934098e-01f, 2.31768116e-01f, -5.41388728e-02f, -2.11881623e-02f, -1.48457428e-02f, -1.72454074e-01f, 1.91768389e-02f, -6.21102527e-02f,
  -1.04067244e-01f, -7.89175555e-02f, -1.41242683e-01f, 3.72669101e-03f, -1.20806560e-01f, 1.38218924e-02f, 4.92608324e-02f, -1.53129995e-01f, -7.68893585e-02f, -1.22121587e-01f,
  1.04781929e-02f, -1.05598737e-02f, -3.51505354e-02f, 1.31034315e-01f, 5.27840406e-02f, -3.45964544e-02f, -1.66266095e-02f, -2.80947089e-02f, -4.77279909e-02f, -1.25458285e-01f,
  -3.18678133e-02f, -8.11281949e-02f, 8.85372758e-02f, -1.31504862e-02f, -8.10150355e-02f, 4.24617045e-02f, -1.45916780e-02f, 1.60502300e-01f, 6.87976107e-02f, 3.49351652e-02f,
  9.51796770e-02f, -1.04384847e-01f, -3.13781500e-02f, -2.95097865e-02f, -9.89264175e-02f, 4.65733856e-02f, 1.12293743e-01f, 7.89341033e-02f, -9.11620185e-02f, -1.83214527e-02f,
  -3.24838251e-01f, -1.80342883e-01f, -1.97802067e-01f, -2.56788339e-02f, -1.70721367e-01f, -2.82986127e-02f, -3.45742516e-02f, 1.12036560e-02f, -1.43888161e-01f, 1.03245892e-01f,
  4.83370246e-03f, -1.19068734e-02f, 6.55191317e-02f, 1.81975648e-01f, -8.39374289e-02f, 6.20206669e-02f, 1.83958700e-03f, -1.35798290e-01f, -1.06388338e-01f, -1.03661187e-01f,
  -1.04476973e-01f, 7.35338358e-03f, -8.28307718e-02f, 4.82957587e-02f, -8.17466751e-02f, -4.39117178e-02f, 3.18202078e-02f, -6.43735006e-03f, 1.32841403e-02f, -1.07563958e-01f,
  -8.62004831e-02f, -2.63210386e-01f, -1.61482394e-01f, -3.43920738e-01f, 6.95274100e-02f, 1.27685338e-01f, -2.88793623e-01f, -6.31416077e-03f, -4.34406519e-01f, -3.43525223e-02f,
  4.28899154e-02f, -2.01250330e-01f, -2.08567053e-01f, 9.31226239e-02f, 1.21738225e-01f, -4.64492515e-02f, 3.12472265e-02f, 2.87442561e-02f, -2.46420708e-02f, 6.14204742e-02f,
  1.19542494e-01f, 2.40060791e-01f, 1.48705393e-01f, 3.19286376e-01f, -5.58555266e-03f, 1.07256733e-01f, 1.79972276e-01f, 6.48130327e-02f, 2.21965745e-01f, 1.69864804e-01f,
  8.11524838e-02f, -5.24874851e-02f, 9.35452655e-02f, 5.18743545e-02f, 2.32815281e-01f, 1.25368103e-01f, 7.72307962e-02f, -1.01248985e-02f, -1.44455135e-01f, -2.60128807e-02f,
  -8.35167319e-02f, -2.60394383e-02f, -9.01332349e-02f, 6.93416223e-02f, -6.63342476e-02f, -1.82920456e-01f, -1.11779207e-02f, -3.49869579e-02f, 1.19785350e-02f, -1.26452968e-01f,
  -9.62155685e-02f, -2.47013256e-01f, -2.40944505e-01f, -2.91535892e-02f, -1.55261382e-01f, -9.51857865e-02f, -7.71883354e-02f, -1.39603421e-01f, -9.01895091e-02f, -9.51281190e-02f,
  5.86079024e-02f, -2.90476717e-02f, -4.00714402e-04f, -3.46659012e-02f, 3.17729227e-02f, 4.58308756e-02f, -3.94436829e-02f, 1.23857781e-01f, -8.13648012e-03f, 4.71031815e-02f,
  -9.87616330e-02f, -2.88793053e-02f, -1.12554826e-01f, 1.00627337e-02f, 4.97429073e-02f, 2.78836787e-02f, 5.83831742e-02f, 4.97073047e-02f, -1.78200454e-01f, 4.54092696e-02f,
  -4.67426069e-02f, 1.55221103e-02f, -8.34255069e-02f, 3.25802155e-02f, -2.21231524e-02f, -1.14560917e-01f, 2.04434991e-02f, -7.99653903e-02f, 9.20714810e-02f, -9.76333767e-02f,
  8.96242410e-02f, 1.12570897e-01f, 3.03361453e-02f, 9.33323707e-03f, 8.57626349e-02f, 1.32038459e-01f, 1.73838630e-01f, 6.75461739e-02f, 1.84989721e-02f, 1.07303388e-01f,
  4.44301367e-02f, -4.12114374e-02f, 1.60987340e-02f, 7.41263628e-02f, -6.92557842e-02f, -1.27135798e-01f, -2.50285678e-02f, -1.13369431e-02f, 8.32126290e-02f, 6.90778159e-03f,
  5.08581661e-02f, -8.87548849e-02f, -2.13965088e-01f, -3.50616835e-02f, -1.18748903e-01f, 1.10583818e-02f, 2.74802484e-02f, -1.08558729e-01f, -1.09611332e-01f, -1.43467277e-01f,
  -4.18126099e-02f, -8.62630904e-02f, 1.94215644e-02f, 8.06577057e-02f, 2.08394185e-01f, -5.63588180e-03f, 2.94825286e-01f, 4.08555707e-03f, 3.18584353e-01f, -1.88850001e-01f,
  -7.71928057e-02f, -8.10952857e-03f, 1.00709185e-01f, -1.40732527e-01f, -1.09933112e-02f, 1.00587383e-02f, 3.27060721e-03f, 2.80851033e-02f, 3.23284566e-01f, 9.25527811e-02f,
  -9.51351449e-02f, 3.13627310e-02f, -1.52836025e-01f, -2.20486168e-02f, -3.58239152e-02f, 1.18975481e-02f, -1.32372990e-01f, 2.49508590e-01f, -1.73239052e-01f, 1.64768860e-01f,
  -2.28529554e-02f, 1.02539651e-01f, -6.08967617e-02f, -6.18383624e-02f, -1.64243847e-01f, -7.71037787e-02f, -5.87800890e-02f, 9.85414982e-02f, 1.33521959e-01f, -3.14199110e-03f,
  -8.42797756e-02f, -1.08617157e-01f, -2.29734927e-03f, 1.12382814e-01f, 9.12034586e-02f, 4.03477661e-02f, -4.98072170e-02f, -7.97819346e-02f, 4.38974723e-02f, -1.34740666e-01f,
  -4.50756475e-02f, -8.25177282e-02f, -5.80529720e-02f, -2.84149311e-02f, -9.17104483e-02f, 1.17691383e-01f, 6.90427842e-03f, -3.47921215e-02f, -7.87350908e-02f, -1.14677176e-02f,
  -1.95446680e-03f, 9.87692624e-02f, -4.85544242e-02f, 1.16103075e-01f, 8.37098807e-03f, -8.90501440e-02f, -1.09052751e-02f, -1.05129600e-01f, -8.59045312e-02f, -4.48389053e-02f,
  1.01682702e-02f, 5.26069058e-03f, 5.35007268e-02f, 8.65769610e-02f, 6.61913380e-02f, -4.20291349e-02f, 2.20878832e-02f, -1.52898561e-02f, -7.47782066e-02f, -3.05726063e-02f,
  1.76777281e-02f, 2.38213800e-02f, -5.39119840e-02f, -1.84651524e-01f, -4.58515203e-03f, 1.02274887e-01f, 3.19928825e-02f, -4.25929353e-02f, -5.45310155e-02f, 4.84743193e-02f,
  -2.88220849e-02f, 3.59980613e-02f, -5.31977825e-02f, -1.05934903e-01f, -4.75915782e-02f, -1.36447892e-01f, 1.70393899e-01f, -6.60023093e-02f, 6.75067976e-02f, -9.03931484e-02f,
  -5.55447191e-02f, -9.70289111e-02f, 6.23623542e-02f, 2.51615383e-02f, -3.12747918e-02f, -1.16490863e-01f, 1.91091206e-02f, -3.57556269e-02f, -5.46326600e-02f, -3.04890312e-02f,
  -6.53251484e-02f, 1.24357440e-01f, -5.58325946e-02f, 3.00472765e-03f, -2.10649669e-01f, 9.24590882e-03f, -1.53513448e-02f, 5.73098809e-02f, 8.63323659e-02f, -1.70953497e-02f,
  2.25284070e-01f, 2.40650633e-03f, 1.81723639e-01f, 4.11182761e-01f, 1.89319886e-02f, -2.00036228e-01f, -1.99096575e-01f, 1.73819572e-01f, 1.53268427e-01f, -2.59787858e-01f,
  7.18429238e-02f, -9.49566364e-02f, -8.85956809e-02f, 2.59322673e-01f, 1.16813406e-01f, -6.74802884e-02f, 2.62590617e-01f, -3.63022573e-02f, 1.64711345e-02f, 2.04781666e-01f,
  2.33163387e-01f, 1.85066104e-01f, 2.01103806e-01f, 5.14700562e-02f, 8.06079209e-02f, 1.77145004e-01f, 1.36613019e-03f, -1.21796988e-01f, 6.83937296e-02f, -8.93561095e-02f,
  -5.62942065e-02f, 1.67504176e-01f, 3.91988866e-02f, -5.82925975e-02f, 5.65274134e-02f, -8.26922953e-02f, -1.10523909e-01f, -1.85834140e-01f, -1.53665289e-01f, -9.82408822e-02f,
  -1.08409487e-02f, -5.18111549e-02f, 7.22617283e-02f, 4.08184156e-02f, 6.33486137e-02f, 6.35159463e-02f, 5.06604351e-02f, -1.38145918e-02f, -9.43180248e-02f, 1.02630384e-01f,
  -4.99241762e-02f, -2.98302341e-02f, 4.98536266e-02f, -1.67232789e-02f, 1.54801071e-01f, 5.24902754e-02f, 2.28326898e-02f, 1.05923065e-03f, -1.58282705e-02f, 2.57663801e-02f,
  8.93945992e-02f, 1.05221774e-02f, -1.86515525e-02f, 7.22448225e-04f, -2.45295931e-02f, -9.77390725e-03f, -7.83450231e-02f, -4.10558283e-02f, 1.56257171e-02f, 3.38527970e-02f,
  -2.64130663e-02f, 6.84559047e-02f, 6.41809553e-02f, -1.22649223e-01f, 5.59090078e-02f, 1.03478497e-02f, -5.88106960e-02f, 4.30383123e-02f, 1.41596600e-01f, 2.08128919e-03f,
  -7.29751438e-02f, -4.89549153e-02f, -2.64734682e-02f, -3.80641632e-02f, -9.28863585e-02f, 3.43558975e-02f, 6.90719113e-02f, 1.45453602e-01f, -2.46253721e-02f, 1.82296202e-01f,
  2.67119948e-02f, 1.55643076e-01f, 2.20406707e-02f, -7.42327794e-02f, -4.53853905e-02f, 1.14859222e-02f, 2.27710623e-02f, 3.58528364e-03f, -6.71708882e-02f, -3.79504785e-02f,
  1.04316846e-01f, -1.42089382e-01f, -7.99316838e-02f, 2.90196855e-02f, 1.00738585e-01f, 6.27201796e-02f, -7.07404092e-02f, -5.98988347e-02f, 3.11553990e-03f, 1.23081088e-01f,
  -3.92615013e-02f, -8.77905041e-02f, -1.25786671e-02f, -2.37782337e-02f, 1.40656112e-02f, 4.92938608e-02f, 1.05112270e-02f, 6.89881220e-02f, 7.75151551e-02f, 2.67467666e-02f,
  -3.83381918e-02f, 5.50892875e-02f, -2.37098128e-01f, -8.81734118e-02f, 1.28355041e-01f, 2.12030053e-01f, -2.30703573e-03f, 4.02833223e-02f, -1.45333707e-01f, 3.08998257e-01f,
  3.14843818e-03f, -1.00700647e-01f, -8.15428421e-02f, 1.05624981e-01f, 1.91885568e-02f, -1.62225351e-01f, 2.32738405e-01f, -5.28960600e-02f, -1.88993454e-01f, 1.23209901e-01f,
  -2.02654470e-02f, 3.65050763e-01f, -1.74729556e-01f, 1.68028340e-01f, 1.19356945e-01f, -6.03704788e-02f, 2.50762165e-01f, -1.72891989e-01f, 1.23027109e-01f, 4.47620973e-02f,
  -5.35699837e-02f, -7.70947263e-02f, -7.58284628e-02f, -1.00982659e-01f, 1.36978310e-02f, 8.18709657e-02f, 1.10258959e-01f, -1.12502120e-01f, -1.41509429e-01f, -9.58475992e-02f,
  -3.37251797e-02f, -7.62531459e-02f, 5.37915342e-03f, -2.48465268e-03f, 4.80415486e-02f, 1.07669262e-02f, -5.96354753e-02f, -4.13564779e-02f, -6.99043721e-02f, -1.74888130e-02f,
  -7.32530430e-02f, -7.40050897e-02f, 5.07131889e-02f, -2.28158236e-02f, 6.02746382e-03f, 4.12619337e-02f, 6.28101751e-02f, 3.58042382e-02f, 5.00225946e-02f, 1.00415237e-01f,
  6.88225031e-02f, 1.11601114e-01f, 5.87371923e-02f, -5.88481724e-02f, -2.29419898e-02f, -2.52635721e-02f, 2.65335813e-02f, -2.25289743e-02f, -4.92623672e-02f, 1.18280709e-01f,
  6.36571869e-02f, 1.67281609e-02f, -4.16070558e-02f, 6.00163825e-02f, 1.49924472e-01f, 1.64426249e-02f, -1.10681713e-01f, 7.17328563e-02f, 7.67925158e-02f, -5.88578694e-02f,
  -9.14919451e-02f, 5.43361828e-02f, -4.77163345e-02f, -1.44838262e-02f, -5.33397757e-02f, 2.99955588e-02f, 1.61134094e-01f, -2.01200545e-02f, -8.57960433e-02f, -1.67407608e-03f,
  2.03566566e-01f, 3.61009151e-01f, -9.78558213e-02f, -5.03818430e-02f, -6.21479377e-02f, 7.75035545e-02f, 8.28163847e-02f, -6.91362992e-02f, 2.96524819e-02f, 1.32490605e-01f,
  1.34144034e-02f, -2.52124686e-02f, 1.98398709e-01f, -6.46387925e-03f, -1.73786446e-03f, 1.86963469e-01f, 1.12243585e-01f, -1.04499817e-01f, 5.54736592e-02f, 4.75169085e-02f,
  9.91614014e-02f, -4.04040925e-02f, -4.41428492e-05f, 3.04389820e-02f, 1.16899066e-01f, 1.54085547e-01f, 8.98388922e-02f, -5.42059019e-02f, 1.66433938e-02f, -5.38881831e-02f,
  -4.99747274e-03f, 4.61181812e-02f, 4.05979514e-01f, -2.27448158e-02f, 2.20596656e-01f, 2.23037988e-01f, 2.41293520e-01f, 2.12704852e-01f, 2.80269027e-01f, -1.62158608e-01f,
  -2.11413085e-01f, 1.51021019e-01f, -4.94101718e-02f, -1.20783843e-01f, 2.49288306e-01f, 7.67852962e-02f, 2.32220646e-02f, -5.21191061e-02f, 1.07284211e-01f, -9.09095332e-02f,
  -4.29802462e-02f, -1.93356916e-01f, -6.14161156e-02f, -1.80960476e-01f, -4.63131405e-02f, -5.27745374e-02f, -3.03402245e-01f, 7.62540549e-02f, -1.51123136e-01f, 1.63461596e-01f,
  -1.36594057e-01f, -6.82021901e-02f, -1.27008185e-01f, -4.85220999e-02f, -7.71122128e-02f, 6.19021915e-02f, 1.00239828e-01f, 1.28169164e-01f, 2.10356321e-02f, -4.11949456e-02f,
  -1.25838965e-01f, 3.53724584e-02f, -1.28739059e-01f, 3.35529484e-02f, 2.47249492e-02f, -4.92615998e-02f, 4.55488488e-02f, -1.23444863e-01f, 2.86725536e-02f, 1.18719824e-01f,
  6.91269860e-02f, -4.86312583e-02f, 5.08924313e-02f, 7.60313496e-02f, 8.93617868e-02f, -2.95508783e-02f, 4.84421179e-02f, 1.74669892e-01f, -2.25180108e-02f, -1.47502683e-02f,
  1.52867422e-01f, 1.61343351e-01f, 4.47463952e-02f, -1.04793385e-01f, -5.01802228e-02f, -6.93675801e-02f, -1.07974038e-01f, -1.36756152e-01f, -5.32914810e-02f, -1.23644046e-01f,
  -1.13666743e-01f, -6.38122335e-02f, 4.59666084e-03f, 2.73808055e-02f, -7.23555386e-02f, 4.39860970e-02f, -9.04144719e-03f, 4.74261120e-02f, -3.52725643e-03f, -1.00980632e-01f,
  5.94206750e-02f, 2.96979845e-02f, -8.93092901e-03f, 8.99031200e-03f, -2.87763495e-02f, -9.38926078e-03f, -2.81430352e-02f, 1.49027407e-01f, -1.45278275e-01f, -1.15078412e-01f,
  -1.82567373e-01f, -8.03617314e-02f, -1.40019417e-01f, -1.47904932e-01f, -6.50444627e-02f, -1.03943586e-01f, 8.43889415e-02f, 1.03555501e-01f, -7.00608045e-02f, -4.51355726e-02f,
  2.79276799e-02f, -7.28898048e-02f, -3.70395742e-02f, 5.22207655e-02f, -3.14010791e-02f, -1.22362405e-01f, -8.63757823e-03f, -1.97042644e-01f, -9.55895036e-02f, 3.13671515e-03f,
  -6.40923232e-02f, -9.85847414e-02f, 1.97507534e-03f, -4.56968620e-02f, -2.08607204e-02f, -1.31258620e-02f, -5.82390502e-02f, 9.98499691e-02f, 2.93388125e-03f, -8.78926646e-03f,
  -3.50728631e-01f, 1.05708055e-01f, -1.68641239e-01f, 1.75676644e-02f, -9.10201389e-03f, 1.21523924e-01f, 1.45288870e-01f, -5.56006134e-02f, -1.13530166e-01f, 3.04554343e-01f,
  2.18782187e-01f, -2.24304751e-01f, 1.17275126e-01f, 1.48185119e-01f, -2.54778147e-01f, 1.45175681e-01f, 1.74148872e-01f, 1.68204203e-01f, -1.09274037e-01f, -1.74991205e-01f,
  -1.47246763e-01f, 9.88457203e-02f, -7.63790682e-02f, -1.44403325e-02f, 7.42911473e-02f, -1.22253790e-01f, 1.63711935e-01f, -2.10127518e-01f, 1.69576362e-01f, -8.64277035e-03f,
  4.34673652e-02f, -1.11543030e-01f, -1.39239445e-01f, -5.04753515e-02f, -1.25013981e-02f, 5.74502070e-03f, 6.64191619e-02f, -8.93667415e-02f, -1.39355719e-01f, 2.85163894e-02f,
  -8.03285651e-03f, -2.84436271e-02f, 2.12057456e-02f, -1.19438984e-01f, -2.25370638e-02f, -1.58197172e-02f, -4.14002948e-02f, 3.43224071e-02f, -3.18816900e-02f, -3.56091559e-02f,
  -6.10580780e-02f, 1.57591581e-01f, 4.92818430e-02f, 8.24752972e-02f, 4.37138863e-02f, 1.80925708e-02f, 7.08086938e-02f, 4.44648266e-02f, 1.52550578e-01f, 5.39726801e-02f,
  1.14915688e-02f, -6.53044507e-02f, -7.14322627e-02f, -3.79759558e-02f, -2.70407926e-02f, -3.37790921e-02f, -6.05968088e-02f, -2.78535411e-02f, -9.55355242e-02f, -2.05864049e-02f,
  -2.20328644e-02f, -1.15601249e-01f, -5.44114336e-02f, -5.94077893e-02f, -3.88946943e-02f, -4.48686555e-02f, -9.78638083e-02f, 5.47897294e-02f, -4.39062193e-02f, -2.72906367e-02f,
  -5.79984747e-02f, 1.05254874e-02f, -4.54674736e-02f, 1.87326461e-01f, 8.83507505e-02f, -1.10347055e-01f, 2.25541014e-02f, -2.31180131e-03f, 6.64921924e-02f, 7.51654059e-02f,
  1.25854194e-01f, -7.59041533e-02f, -1.12945929e-01f, 4.59297858e-02f, -9.80524346e-02f, 2.64142081e-02f, 7.39465430e-02f, -7.60498131e-03f, -4.03618552e-02f, -9.61121824e-03f,
  -1.51972249e-02f, 6.83939680e-02f, 4.19968031e-02f, -4.96112816e-02f, 6.07107095e-02f, 1.01777621e-01f, -1.82182528e-02f, 1.36748608e-02f, 7.52912164e-02f, -4.08970602e-02f,
  9.37752426e-03f, 3.20528559e-02f, 1.17033748e-02f, 1.10427864e-01f, 8.85519013e-02f, 3.53792384e-02f, -4.62469533e-02f, 5.62988669e-02f, 1.52069509e-01f, 1.04330480e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  3.64303410e-01f, 1.79457739e-01f, 3.03058833e-01f, 2.46153861e-01f, 2.66004026e-01f, 1.45183429e-01f, 6.42716810e-02f, 1.00692391e-01f, 8.67031440e-02f, 3.58106524e-01f,
  1.92036688e-01f, 1.95424661e-01f, 2.95376271e-01f, 3.31118882e-01f, 1.78583071e-01f, 1.51410416e-01f, 1.81864530e-01f, 9.02112499e-02f, 2.07089141e-01f, 3.04347038e-01f,
  1.89483523e-01f, 1.93748146e-01f, 2.43464395e-01f, 3.51968884e-01f, 1.42977417e-01f, 1.63676590e-01f, 1.73189923e-01f, 2.36976191e-01f, 3.17903399e-01f, 2.74928153e-01f,
  1.83329895e-01f, 5.77321351e-02f, 2.88006395e-01f, 1.57223865e-01f, 1.90799013e-01f, 6.98122308e-02f, 1.84024706e-01f, 2.57295877e-01f, 1.37013197e-01f, 3.47282439e-01f,
  1.37982532e-01f, 1.79192171e-01f, 3.91291291e-01f, 3.56118232e-01f, 1.63054466e-01f, 2.28281915e-01f, 2.02829227e-01f, 3.84168684e-01f, 1.33621812e-01f, 2.55374491e-01f,
  5.83741739e-02f, 2.30258122e-01f, 2.29542926e-01f, 2.76322454e-01f, 1.79856971e-01f, 1.64332166e-01f, 3.59360069e-01f, 3.02798599e-01f, 2.43990570e-01f, 1.93456590e-01f,
  2.49974966e-01f, 1.82048827e-01f, 2.99534827e-01f, 2.54969150e-01f, 3.97683680e-01f, 2.48471066e-01f, 2.49927178e-01f, 2.40930647e-01f, 2.70117849e-01f, 9.33637172e-02f,
  2.75059640e-01f, 3.80411834e-01f, 3.14088374e-01f, 1.22395620e-01f, 4.69459146e-01f, 3.09282809e-01f, 1.93073213e-01f, 2.71315932e-01f, 6.23691529e-02f, 1.45489886e-01f,
  2.09447220e-01f, 2.77073085e-01f, 1.83405966e-01f, 2.69057900e-01f, 1.54105470e-01f, 2.22977072e-01f, 2.88861275e-01f, 3.06235641e-01f, 1.92418098e-01f, 1.93920538e-01f,
  2.83874691e-01f, 2.31544092e-01f, 1.72027960e-01f, 6.62514493e-02f, 2.85739571e-01f, 1.81856990e-01f, 3.09369028e-01f, 1.60634756e-01f, 2.74326652e-01f, 2.29237080e-01f,
  1.44698426e-01f, 2.49135882e-01f, 3.25797290e-01f, 1.20660983e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -6.55663162e-02f, -9.05168615e-03f, -1.87370609e-02f, -1.34355783e-01f, -8.81718174e-02f, -1.51498407e-01f, -2.13728733e-02f, -2.12839127e-01f, 6.67334870e-02f, -1.06133699e-01f,
  -8.69743824e-02f, -2.06020281e-01f, 2.51584798e-01f, 7.99056664e-02f, -1.88291028e-01f, 1.98875517e-01f, 9.14007723e-02f, 7.58360475e-02f, 3.45518470e-01f, 2.83052742e-01f,
  -1.17027514e-01f, -2.45353952e-03f, -4.41076793e-02f, -4.95880097e-02f, -2.06571132e-01f, -2.92816579e-01f, 1.04989417e-01f, 2.07323566e-01f, -4.13582474e-01f, -1.75756231e-01f,
  -2.86641978e-02f, -1.01280421e-01f, 4.26678266e-03f, 2.79919118e-01f, 4.22306210e-01f, 4.14750844e-01f, -1.47199124e-01f, 2.38711640e-01f, -1.60811037e-01f, -2.90141016e-01f,
  -3.02833021e-01f, -7.90241174e-03f, -3.36159945e-01f, -1.93950027e-01f, -1.56097412e-01f, 2.42608443e-01f, -2.40844563e-01f, -1.12271465e-01f, -1.04055114e-01f, 3.01018864e-01f,
  -2.44597107e-01f, 4.92418021e-01f, -1.30995750e-01f, 2.52735436e-01f, -1.11814484e-01f, 1.91027224e-01f, -1.46792725e-01f, -1.39953986e-01f, 1.74216181e-01f, -1.59243539e-01f,
  1.17541283e-01f, -3.20093542e-01f, 2.76681721e-01f, 3.31555247e-01f, -2.22557306e-01f, 4.13424522e-03f, -2.92322040e-01f, 3.93743277e-01f, 5.97486377e-01f, -3.01224738e-01f,
  -1.49916083e-01f, -2.73534179e-01f, 5.01598775e-01f, 4.60187614e-01f, -9.68617573e-02f, 3.69583182e-02f, 2.74604172e-01f, -1.92428187e-01f, -2.56751060e-01f, -1.11729592e-01f,
  -4.05558884e-01f, -3.89285266e-01f, -1.07072525e-01f, -1.95209950e-01f, -1.62387937e-01f, -1.95856765e-01f, -2.31177315e-01f, -2.53906250e-01f, -7.87702799e-02f, -1.28066912e-02f,
  -1.30194634e-01f, -7.90327787e-02f, -2.53478169e-01f, -3.15703303e-01f, -4.05917643e-03f, 5.22479832e-01f, 1.00322552e-01f, 2.50614613e-01f, -1.66554242e-01f, -3.99362147e-01f,
  -4.35342848e-01f, -7.55940052e-03f, 4.02275920e-01f, -1.96236148e-02f, -7.20659792e-02f, -1.76521644e-01f, -3.17293584e-01f, 1.00206487e-01f, -5.26582357e-03f, -2.13049680e-01f,
  -3.21084112e-01f, -3.47341716e-01f, -1.20459713e-01f, 3.92456442e-01f, -3.87924105e-01f, 1.54425904e-01f, -7.28168637e-02f, -5.54369995e-04f, -3.38363498e-01f, -1.33121284e-02f,
  -2.42454261e-01f, 1.04714021e-01f, -2.99773216e-02f, -2.68342912e-01f, -3.00555795e-01f, 8.96199420e-03f, -4.33104455e-01f, 4.20102209e-01f, 1.09732086e-02f, 1.21708073e-01f,
  1.19796857e-01f, -1.16785854e-01f, 1.39353797e-01f, 2.00273290e-01f, 2.03624949e-01f, -8.52994248e-02f, 5.05038202e-02f, -1.92855671e-01f, -7.56061375e-02f, -4.75824594e-01f,
  -7.54490644e-02f, -1.87657177e-01f, -2.73588970e-02f, 3.60717773e-01f, 4.48963232e-02f, -3.15783918e-01f, -4.53923762e-01f, 2.81237960e-01f, -3.03580195e-01f, -1.34778440e-01f,
  -3.34129721e-01f, -1.09456405e-01f, 1.86627749e-02f, -1.20533131e-01f, -3.55006307e-01f, 7.15238377e-02f, 3.68383408e-01f, -1.04477532e-01f, 2.43513659e-01f, 1.18646666e-01f,
  -2.23033309e-01f, 2.65056670e-01f, 5.41766211e-02f, -2.97619373e-01f, -2.59491026e-01f, -4.81902778e-01f, -2.26582915e-01f, 1.09066673e-01f, -3.94758761e-01f, 1.58183694e-01f,
  -5.41828647e-02f, -2.45769009e-01f, -1.66194469e-01f, 1.29081190e-01f, -1.70066670e-01f, -1.14845596e-02f, -3.63074511e-01f, 3.02446067e-01f, 4.60465044e-01f, -4.37864572e-01f,
  -3.31053853e-01f, -2.78445721e-01f, -4.48264986e-01f, -1.89038888e-01f, -5.62265754e-01f, -1.39661282e-01f, -2.31096253e-01f, -3.46511267e-02f, -4.30535167e-01f, -3.25365365e-01f,
  -1.34946063e-01f, -5.05261838e-01f, -1.37842491e-01f, -3.83665971e-02f, -3.00514475e-02f, -1.52370378e-01f, -2.77526706e-01f, -1.87639698e-01f, -6.32704675e-01f, -2.42948890e-01f,
  2.07203507e-01f, 2.71068305e-01f, 5.45089357e-02f, -1.05344504e-01f, 2.85486847e-01f, -2.85110492e-02f, -1.81476101e-01f, -2.57723749e-01f, 3.59144032e-01f, -4.10580248e-01f,
  2.45807573e-01f, 2.70847697e-02f, 1.71821527e-02f, -3.56203839e-02f, 1.57548562e-01f, 3.25076252e-01f, -4.02993798e-01f, -4.05307114e-01f, 3.51523131e-01f, -7.15222850e-04f,
  -3.14845115e-01f, 4.29844677e-01f, 1.57784060e-01f, -4.49205965e-01f, 4.27386165e-03f, 4.09720242e-02f, -2.18934268e-01f, 1.64925531e-01f, 4.46391881e-01f, -4.31318820e-01f,
  1.89203158e-01f, 1.66728050e-01f, -3.59611899e-01f, 1.17935210e-01f, -3.35403860e-01f, 3.58135462e-01f, -2.89587438e-01f, -1.14113539e-01f, 2.48026341e-01f, 9.82662141e-02f,
  -6.51239008e-02f, 2.49940366e-01f, 2.46125475e-01f, 2.05107704e-01f, -3.36478382e-01f, 1.73504457e-01f, 1.68134142e-02f, 1.18706636e-01f, 7.78546259e-02f, -3.36832076e-01f,
  1.76679924e-01f, -2.59901047e-01f, 7.55264284e-03f, 3.01417708e-01f, -2.31387749e-01f, 8.57688934e-02f, -1.36967123e-01f, -6.12966195e-02f, -1.86219007e-01f, -3.03187162e-01f,
  -3.20801169e-01f, -1.78295374e-01f, -2.70247549e-01f, -1.89652648e-02f, 8.24898928e-02f, -6.08807169e-02f, 5.08772247e-02f, 1.09428450e-01f, -1.67357907e-01f, -1.09060863e-02f,
  2.23062977e-01f, 1.04298681e-01f, 1.70415446e-01f, 2.82217823e-02f, 2.15951696e-01f, 2.23402545e-01f, 1.73235521e-01f, -3.81081179e-02f, 2.62853533e-01f, -2.29008168e-01f,
  -1.58379734e-01f, 3.39516222e-01f, -1.08726501e-01f, -2.14951947e-01f, 8.72593299e-02f, -1.27485037e-01f, -1.43149197e-01f, -3.67947966e-01f, 2.71866411e-01f, -2.65361279e-01f,
  -1.67144895e-01f, -4.82978858e-02f, 1.02804296e-01f, -1.87889263e-01f, -2.03553200e-01f, 2.42781475e-01f, 3.55688214e-01f, -2.68466175e-01f, -1.35317609e-01f, -1.57824248e-01f,
  8.31671804e-03f, -2.98875332e-01f, -2.40749821e-01f, -5.72322793e-02f, 2.38476366e-01f, -1.69745117e-01f, 2.44145408e-01f, 1.53287034e-02f, -5.51643632e-02f, -6.67054206e-02f,
  -1.35524899e-01f, -3.34035931e-03f, -6.90295771e-02f, -1.21770024e-01f, -1.53716400e-01f, 4.46043313e-01f, -1.22873738e-01f, -1.14733294e-01f, -3.09367180e-01f, -9.24934968e-02f,
  -2.02723324e-01f, -2.03838706e-01f, -3.58206034e-01f, -3.52904588e-01f, 3.03962886e-01f, -3.09038460e-01f, 4.01607871e-01f, 1.96771488e-01f, -2.32515335e-01f, -2.55733907e-01f,
  4.49624300e-01f, -1.54082134e-01f, -3.05713028e-01f, -1.58170313e-01f, 8.96315202e-02f, -1.20409653e-01f, 1.42890513e-01f, -1.20322928e-01f, -1.08720891e-01f, 1.54432803e-01f,
  7.88324699e-02f, -2.84288079e-01f, 1.68475434e-01f, 3.71709228e-01f, -2.38973439e-01f, -2.41090178e-01f, -6.08964413e-02f, 2.04226822e-01f, -2.49557436e-01f, 3.26028973e-01f,
  -2.15888232e-01f, -9.89263430e-02f, -2.69109040e-01f, 4.48472053e-01f, 8.02619830e-02f, -1.70134634e-01f, 3.87144208e-01f, 2.37483442e-01f, 1.89861625e-01f, -2.74891049e-01f,
  1.94393575e-01f, -8.78139287e-02f, -4.40717377e-02f, 1.44655546e-02f, -1.30544126e-01f, 1.67107671e-01f, 3.32780451e-01f, 9.11216289e-02f, -1.42882437e-01f, 2.88635761e-01f,
  -4.18086469e-01f, 3.49051595e-01f, 1.74960926e-01f, 4.34507467e-02f, -3.79050225e-01f, -9.40827578e-02f, -3.64447564e-01f, -2.70807906e-03f, 3.89476687e-01f, -7.55289122e-02f,
  7.79826716e-02f, -4.34098318e-02f, -3.12581837e-01f, -1.91203073e-01f, -4.77708764e-02f, -3.39507997e-01f, -1.29688894e-02f, -1.00217767e-01f, -8.24353397e-02f, -1.07341483e-01f,
  -1.70073837e-01f, 9.32561830e-02f, 5.29689528e-02f, -1.84536308e-01f, 1.24677643e-01f, 5.49364239e-02f, 1.13184646e-01f, -5.17920852e-02f, -1.16658770e-01f, -8.46654177e-02f,
  -1.40020400e-01f, -3.06045217e-03f, -1.31315291e-01f, -1.01024233e-01f, 2.10598886e-01f, 3.36489648e-01f, -3.48572314e-01f, 1.09362565e-02f, -2.83006310e-01f, -2.13573620e-01f,
  1.53615206e-01f, -9.59235504e-02f, -2.66828656e-01f, 4.55287784e-01f, -1.84987947e-01f, 9.53620896e-02f, -8.17972869e-02f, -9.63862687e-02f, 4.07190710e-01f, -1.02732591e-01f,
  -3.56276453e-01f, 8.76024142e-02f, -2.49383345e-01f, -1.45939633e-01f, -2.37504229e-01f, -1.74554378e-01f, 3.90733302e-01f, 3.34065169e-01f, 4.37894672e-01f, -1.25457853e-01f,
  4.77195054e-01f, -2.09205315e-01f, 1.25265732e-01f, -1.27012968e-01f, -9.04810950e-02f, -4.63076293e-01f, -3.04695487e-01f, 3.60021323e-01f, 5.14002517e-02f, -3.82380374e-02f,
  -5.93780391e-02f, 5.37246406e-01f, 7.50999479e-03f, 9.01297387e-03f, 4.55131352e-01f, -3.49361897e-01f, -3.16277742e-01f, 3.25676411e-01f, -3.54024465e-03f, -1.21674025e-02f,
  4.53247968e-03f, 1.03111334e-01f, -4.22603264e-02f, -2.15534434e-01f, -1.28241226e-01f, 3.88788790e-01f, 2.44781926e-01f, 9.31533203e-02f, 7.21404925e-02f, -5.35018593e-02f,
  -1.77460000e-01f, -2.10349023e-01f, -1.88771456e-01f, -2.83550411e-01f, -2.29590490e-01f, 2.86410987e-01f, -1.38149768e-01f, -2.61688113e-01f, -1.55089974e-01f, -1.95273533e-01f,
  -5.79212643e-02f, -1.80544287e-01f, -4.75400448e-01f, -1.71867847e-01f, -1.60365596e-01f, -3.12213808e-01f, -2.68292189e-01f, 1.17300004e-02f, -2.22663522e-01f, 2.59934306e-01f,
  -2.28920072e-01f, -1.04072779e-01f, 3.08638215e-01f, -1.49121210e-01f, -1.05888970e-01f, -3.56342375e-01f, -1.54833257e-01f, 1.27340347e-01f, -1.56627193e-01f, 3.69985223e-01f,
  3.39296073e-01f, -1.69366479e-01f, -1.61757141e-01f, -1.21834524e-01f, -1.91002101e-01f, -2.18308121e-01f, -1.66330412e-01f, -1.14515617e-01f, -2.08237395e-01f, -1.28601670e-01f,
  -2.10953578e-01f, -2.95757145e-01f, -4.33455497e-01f, 3.83963346e-01f, 3.21813710e-02f, 5.28750002e-01f, -1.07704625e-01f, 3.17979157e-01f, 1.21620093e-02f, -1.96323633e-01f,
  -2.42113754e-01f, -1.26112446e-01f, 1.36517808e-01f, 1.89754903e-01f, 1.21749617e-01f, 1.70721337e-01f, 1.30106643e-01f, -4.41692546e-02f, 1.89565092e-01f, 1.39314428e-01f,
  -3.62344012e-02f, 2.66296536e-01f, -1.86706036e-01f, 2.40680680e-01f, -2.22443774e-01f, 4.59184647e-01f, -1.48065537e-01f, -2.67648280e-01f, -1.73458010e-02f, 2.15188682e-01f,
  -2.84758180e-01f, -5.35624586e-02f, 2.69034922e-01f, 5.59126846e-02f, -2.83775210e-01f, 2.61290669e-01f, 5.04010737e-01f, -1.76684946e-01f, 3.67126137e-01f, 2.04743981e-01f,
  -3.31273168e-01f, 5.73763400e-02f, 8.50504488e-02f, 2.28364408e-01f, -2.74688512e-01f, 1.75030619e-01f, -1.87119856e-01f, 1.24818869e-01f, -8.35656673e-02f, 4.70822245e-01f,
  -2.01395631e-01f, 4.50874537e-01f, -2.57437050e-01f, -1.65164098e-01f, -4.99928057e-01f, 2.53982637e-02f, 1.57902300e-01f, -1.61505908e-01f, -3.30577433e-01f, 1.52940169e-01f,
  -2.31054917e-01f, 7.46665969e-02f, -2.75865406e-01f, 7.24787312e-03f, 4.53300655e-01f, 2.85317153e-01f, -2.01451313e-03f, -2.27371648e-01f, -2.44300917e-01f, -3.36544156e-01f,
  -1.73113152e-01f, -1.23455860e-01f, -5.62524647e-02f, -1.70617998e-01f, 2.74922311e-01f, 4.50660408e-01f, 2.01955587e-01f, -5.57362773e-02f, 4.71434951e-01f, 2.92986959e-01f,
  1.52082831e-01f, -3.93689752e-01f, -3.00493330e-01f, 4.02886748e-01f, -2.35668179e-02f, -6.09458208e-01f, -2.02612266e-01f, -3.21360230e-01f, 4.57433537e-02f, -4.67873275e-01f,
  -1.42700896e-01f, -9.58046168e-02f, -3.13307866e-02f, 3.27067256e-01f, -4.28496629e-01f, 1.19602352e-01f, -3.66736829e-01f, 1.89286351e-01f, -1.48992464e-01f, 1.66464355e-02f,
  3.20437312e-01f, 2.09526032e-01f, -3.90363447e-02f, -1.70341775e-01f, -2.77754128e-01f, -5.82624413e-02f, 1.18648931e-01f, -2.72434890e-01f, 3.55707735e-01f, 3.49825859e-01f,
  3.15979481e-01f, -1.68142095e-01f, -2.76340246e-01f, -1.46739766e-01f, 4.49512377e-02f, -4.84817363e-02f, 9.25235599e-02f, -3.63365471e-01f, 2.03721672e-01f, -5.35219014e-01f,
  -2.88773865e-01f, -1.25508577e-01f, -1.64174765e-01f, 3.18609476e-01f, -3.17274481e-01f, -3.53653908e-01f, -2.85656750e-01f, -3.95665109e-01f, -3.48644733e-01f, 1.49145484e-01f,
  2.43193045e-01f, -1.16666324e-01f, 1.83935761e-01f, -1.88656881e-01f, 3.24552715e-01f, -1.00403182e-01f, -1.42115965e-01f, -1.35685667e-01f, 3.32127988e-01f, -5.29295281e-02f,
  1.17039047e-01f, 2.15667471e-01f, -1.51562795e-01f, 3.05596352e-01f, -3.22529078e-02f, -3.43671739e-02f, 3.52111012e-02f, 3.53114247e-01f, 1.64631754e-01f, 1.66292831e-01f,
  8.50451142e-02f, 4.09220397e-01f, -3.00235748e-01f, -2.44303018e-01f, 1.88979566e-01f, -1.83258072e-01f, -2.41167873e-01f, -3.74774218e-01f, 4.58226323e-01f, -3.14500779e-01f,
  -3.81637752e-01f, -2.64610499e-01f, -1.87707208e-02f, -5.67320228e-01f, -4.10965800e-01f, 2.28977904e-01f, -4.27733421e-01f, 3.78116012e-01f, -1.89525690e-02f, -1.29747301e-01f,
  4.42396775e-02f, -2.55723685e-01f, -3.44906598e-01f, 3.14627260e-01f, 2.65786439e-01f, 3.66730869e-01f, -1.37710031e-02f, -1.93562910e-01f, 1.65862054e-01f, -3.95704687e-01f,
  4.12084013e-01f, -1.21941499e-01f, -3.22229624e-01f, -4.97148842e-01f, -1.86257809e-01f, 2.96394620e-02f, -2.98254848e-01f, 3.96421045e-01f, 2.95924187e-01f, 1.51369587e-01f,
  -3.77568632e-01f, 3.43129694e-01f, -1.88731939e-01f, 2.21130643e-02f, 3.45783830e-01f, -3.04454476e-01f, 3.50068361e-01f, -4.71856594e-02f, -2.19536453e-01f, -7.76265562e-02f,
  -1.34295091e-01f, 3.20456684e-01f, 5.25281727e-02f, 8.01263452e-02f, -1.90954059e-01f, -2.88949430e-01f, -1.97925940e-01f, -3.98528457e-01f, -3.55842888e-01f, 3.22855860e-01f,
  -2.25681216e-01f, -4.17950034e-01f, -2.83313483e-01f, 1.83968335e-01f, -3.42833847e-01f, -8.33323076e-02f, -2.59132534e-01f, 7.03041069e-03f, -1.12581238e-01f, 2.00461194e-01f,
  2.50981301e-01f, 1.03457063e-01f, 2.71140844e-01f, -1.20238148e-01f, 1.01229280e-01f, 2.15624794e-01f, -6.71591684e-02f, -2.71638334e-01f, 4.01325613e-01f, 1.59766868e-01f,
  -3.14421475e-01f, -3.56772393e-01f, -1.02748573e-01f, -2.21684188e-01f, 1.04518764e-01f, -2.47855246e-01f, 9.97484699e-02f, -3.50899696e-01f, -5.35526991e-01f, -2.38323435e-01f,
  -3.38410199e-01f, 1.24318227e-01f, -4.09223109e-01f, 2.41840452e-01f, -2.92237103e-01f, -6.11018315e-02f, 1.89036392e-02f, 3.32755685e-01f, 5.45456186e-02f, -3.95570606e-01f,
  -3.81545454e-01f, -1.86511233e-01f, 5.11698246e-01f, -3.04810017e-01f, 4.01514173e-01f, 9.99685973e-02f, 5.80793656e-02f, -9.95789394e-02f, 1.31935045e-01f, -2.43013546e-01f,
  2.70480096e-01f, -7.79526755e-02f, -3.89178514e-01f, 3.11690748e-01f, -1.01080149e-01f, -2.83223786e-03f, 2.18729198e-01f, -1.72540247e-01f, -1.16768494e-01f, -2.26034626e-01f,
  -1.01914201e-02f, 8.55270624e-02f, 5.43638468e-02f, 1.16512120e-01f, -1.77474856e-01f, -1.45436347e-01f, 2.29692608e-01f, 1.44347087e-01f, 1.33420676e-01f, 1.52828231e-01f,
  -2.05703005e-01f, -2.47086167e-01f, -2.50666231e-01f, 2.09909499e-01f, 2.85050794e-02f, 2.81141954e-03f, -1.58480495e-01f, -2.81475246e-01f, 3.32747936e-01f, -2.34547719e-01f,
  4.87081148e-02f, 4.39874440e-01f, -2.59915471e-01f, -4.40900922e-01f, -1.22351676e-01f, -2.56351501e-01f, 3.84005845e-01f, -6.23955280e-02f, -1.23360075e-01f, -3.08965772e-01f,
  3.07769895e-01f, -5.67952335e-01f, -3.32922220e-01f, -2.42899969e-01f, -1.86197087e-01f, -4.75969315e-01f, 2.79599011e-01f, -1.78479001e-01f, 1.76089257e-02f, -7.95924142e-02f,
  -1.08188376e-01f, 1.18504524e-01f, -3.13844085e-01f, -1.05194122e-01f, -9.72032472e-02f, -5.60076892e-01f, -2.22418994e-01f, 1.74488954e-03f, 3.98349375e-01f, -1.69414848e-01f,
  -3.42061251e-01f, 3.10537536e-02f, -2.03545958e-01f, 6.24114513e-01f, 1.36853024e-01f, -1.61159694e-01f, -1.55545056e-01f, 8.78457129e-02f, -3.23933288e-02f, -5.01344651e-02f,
  3.16094100e-01f, -3.73598576e-01f, 4.33799624e-01f, -1.66473255e-01f, -2.50941187e-01f, -9.52927917e-02f, -1.11105174e-01f, 3.54377776e-01f, 2.65465945e-01f, 2.83557594e-01f,
  -2.70605743e-01f, 9.17570293e-02f, -2.19193101e-01f, -2.20677942e-01f, -1.26374871e-01f, 3.30986798e-01f, -9.46262255e-02f, 2.84239221e-02f, -9.05142725e-02f, 1.90571398e-01f,
  3.84725146e-02f, 4.22769576e-01f, 2.91169733e-01f, -2.61430684e-02f, -2.20146284e-01f, -1.93571523e-01f, -2.71244980e-02f, -1.91206142e-01f, -3.22867155e-01f, 4.35703576e-01f,
  3.75538468e-01f, 2.46351182e-01f, -3.58368158e-01f, -1.16154730e-01f, -5.38071156e-01f, -1.52874157e-01f, -2.54364200e-02f, 6.34309798e-02f, 4.07103263e-02f, -3.50019634e-01f,
  1.28803942e-02f, -1.62935585e-01f, 1.49196703e-02f, -1.68451622e-01f, -1.56716794e-01f, 9.33209434e-02f, 3.98263961e-01f, 4.52353776e-01f, 1.01444893e-01f, -1.28640039e-02f,
  -3.81140143e-01f, -2.26647630e-01f, 3.38108540e-01f, -3.02349895e-01f, 1.86531350e-01f, -1.81040049e-01f, 3.43721867e-01f, -2.84150958e-01f, -4.00567889e-01f, 2.27549911e-01f,
  -2.74078608e-01f, 1.91758379e-01f, 1.67076156e-01f, -2.59464204e-01f, 2.07270056e-01f, -1.87166736e-01f, -1.85337737e-01f, -9.21027586e-02f, -2.34534517e-01f, -2.52605299e-03f,
  -3.16658430e-02f, -7.99421445e-02f, -1.17831133e-01f, -3.12266685e-02f, -2.07508430e-01f, -3.35250974e-01f, -7.69282281e-02f, -2.87363768e-01f, 1.21772580e-01f, 1.24658711e-01f,
  1.60858452e-01f, -9.48011354e-02f, -1.14322357e-01f, 1.03512108e-01f, 1.38886034e-01f, -4.25142534e-02f, 1.50596738e-01f, 1.61154762e-01f, 7.21728876e-02f, 2.11561948e-01f,
  -1.08085312e-01f, 1.27024934e-01f, -1.25725254e-01f, -1.25359192e-01f, -1.96500927e-01f, 3.17574918e-01f, 3.75435664e-03f, 1.39617976e-02f, 3.94154370e-01f, -1.79158866e-01f,
  -3.76900285e-02f, -8.02265629e-02f, -1.58951759e-01f, 1.32303253e-01f, 3.13428104e-01f, 2.49390788e-02f, -1.22451475e-02f, 3.92507352e-02f, 1.26042873e-01f, 7.16251582e-02f,
  4.64066923e-01f, -1.88643962e-01f, 1.06779002e-01f, -1.44719079e-01f, 2.54499950e-02f, -2.30114132e-01f, -1.50153860e-01f, 1.88697726e-01f, 4.96678650e-01f, -2.61080146e-01f,
  4.51688349e-01f, -1.28171429e-01f, 1.22112982e-01f, 2.76768833e-01f, -2.01847956e-01f, 4.14708853e-02f, 5.13544716e-02f, 2.36655951e-01f, -1.16293058e-01f, -2.00834975e-01f,
  -9.76789743e-02f, 2.64817804e-01f, -2.11516067e-01f, -3.55251372e-01f, -9.46907252e-02f, -5.01158647e-02f, -8.53660703e-02f, -6.37370571e-02f, -6.22086599e-02f, -7.20226839e-02f,
  1.44612446e-01f, 3.62534150e-02f, -2.61467159e-01f, 2.36506015e-01f, -1.00055978e-01f, 3.72636437e-01f, -5.71305193e-02f, -1.77482173e-01f, -1.55523241e-01f, -9.36616063e-02f,
  -1.91039726e-01f, -1.70225352e-01f, -1.71308666e-01f, -1.01813950e-01f, 1.46653473e-01f, 2.53246814e-01f, -2.22459212e-01f, -1.63236812e-01f, 3.28530550e-01f, -1.17089394e-02f,
  -3.11457030e-02f, -8.64400044e-02f, -1.12847336e-01f, -6.91789016e-02f, -1.54669598e-01f, -3.08191106e-02f, -4.81801219e-02f, -2.06822390e-03f, -1.66410089e-01f, 1.20402776e-01f,
  9.78861749e-02f, -1.73187822e-01f, 2.71102905e-01f, -5.84330503e-03f, -5.64111955e-02f, -7.16747791e-02f, -1.80371806e-01f, 2.65385747e-01f, 2.63736188e-01f, -2.26777285e-01f,
  -1.44203082e-01f, -1.62787899e-01f, -6.94089830e-02f, 1.97614908e-01f, -1.29722254e-02f, -1.92416534e-01f, -2.55357891e-01f, 3.09108526e-01f, -2.57374458e-02f, -1.72377005e-01f,
  -9.41729173e-02f, -1.67923391e-01f, -7.34640285e-03f, 6.10666350e-03f, -1.34430394e-01f, -2.10849971e-01f, -2.66853482e-01f, 5.03149524e-04f, -1.60121828e-01f, -1.14370376e-01f,
  -1.63865592e-02f, -2.06016421e-01f, -1.14857845e-01f, 2.16885973e-02f, -1.45403832e-01f, -6.51524290e-02f, 3.94012034e-02f, -2.18705967e-01f, 8.65976140e-02f, -2.59144038e-01f,
  1.46318391e-01f, 2.47776687e-01f, 7.77579397e-02f, 1.33448198e-01f, -5.21313660e-02f, -7.16076940e-02f, 1.23888485e-01f, 1.35495514e-01f, -1.84895024e-01f, 2.86925793e-01f,
  -4.41193171e-02f, -1.51828066e-01f, -2.21378997e-01f, -2.28809565e-01f, 1.48930699e-01f, 3.24663728e-01f, 2.98418850e-02f, -4.91361320e-02f, -1.85060188e-01f, -1.95148066e-01f,
  6.76979646e-02f, -4.97356020e-02f, 1.71502560e-01f, 3.93247336e-01f, 4.29891236e-02f, 3.15411776e-01f, 2.18668692e-02f, -1.16027452e-01f, -1.77813336e-01f, -2.34208405e-01f,
  1.35041088e-01f, 2.39432603e-01f, 4.25938785e-01f, -1.91049442e-01f, 6.97362199e-02f, -6.80380911e-02f, -1.56019956e-01f, -2.07024828e-01f, 4.21891175e-02f, -1.27859965e-01f,
  -2.11329870e-02f, -5.89981154e-02f, 4.16497409e-01f, -9.81982704e-03f, -3.13912556e-02f, 1.30223244e-01f, -4.61641401e-02f, -2.54137754e-01f, 3.86264771e-01f, 2.93807890e-02f,
  -2.14172229e-01f, -9.98071805e-02f, 2.70699292e-01f, 9.02133211e-02f, 6.57749400e-02f, -1.05005674e-01f, -1.63840145e-01f, 6.85273996e-03f, -1.30249277e-01f, -1.72658250e-01f,
  4.82422346e-03f, -1.33337617e-01f, 5.76122776e-02f, -8.45258459e-02f, -2.49087140e-01f, -1.39856696e-01f, -1.38713270e-01f, -1.41005129e-01f, -2.55107671e-01f, -1.26801759e-01f,
  -2.59837717e-01f, 2.27895513e-01f, -1.06320400e-02f, 2.16819108e-01f, -1.62945241e-01f, -1.43425480e-01f, -1.18845887e-01f, -1.59398183e-01f, -2.76424050e-01f, 2.49080628e-01f,
  5.04910052e-01f, -2.61373490e-01f, -2.87142128e-01f, 2.66069919e-01f, 5.39524555e-02f, 4.97884154e-01f, -1.70122609e-01f, 3.04829478e-01f, -7.98692703e-02f, 2.66447067e-01f,
  -1.56106949e-01f, -3.07665348e-01f, 2.55506788e-03f, 4.95648477e-03f, -4.24468238e-03f, -2.60344148e-01f, -1.28610089e-01f, -2.23881438e-01f, -9.07275751e-02f, -1.84507087e-01f,
  -1.09389704e-02f, 1.11415967e-01f, -2.25485396e-02f, -2.24536687e-01f, 2.53639072e-01f, -8.29092786e-02f, 3.75726670e-02f, -6.22524209e-02f, 4.59697783e-01f, 1.75712675e-01f,
  -1.76689371e-01f, -1.82164773e-01f, 1.23964578e-01f, 1.78506300e-01f, 7.91050270e-02f, -5.81341423e-02f, 7.01724831e-03f, 5.10853576e-03f, 1.32428914e-01f, 7.70805404e-02f,
  -2.37827569e-01f, 2.05087408e-01f, 1.45365685e-01f, 9.27751586e-02f, 2.22540006e-01f, -1.19366586e-01f, -8.31432864e-02f, 2.74815291e-01f, 1.10486843e-01f, 3.48574758e-01f,
  2.94326484e-01f, -2.27448761e-01f, 2.12364674e-01f, 2.32400015e-01f, 2.76890993e-01f, 1.65198088e-01f, 3.09369534e-01f, 2.28725243e-02f, 3.93037826e-01f, -3.88619006e-01f,
  -1.86974674e-01f, -2.75575161e-01f, -2.83705682e-01f, 1.73346341e-01f, 2.44157910e-02f, -4.04762477e-01f, -1.44198760e-01f, -7.29702264e-02f, 2.53562272e-01f, 3.17065030e-01f,
  -1.94719255e-01f, -3.99724126e-01f, -3.43699157e-01f, -1.33895487e-01f, -1.51746690e-01f, -3.21022779e-01f, -7.97663033e-02f, 3.53508919e-01f, -1.51667371e-01f, -9.06466991e-02f,
  -4.81701310e-04f, -2.52188265e-01f, -3.16785604e-01f, 3.53493914e-02f, 4.42815155e-01f, -4.35031354e-01f, -2.58256316e-01f, -8.06663558e-02f, 4.20800775e-01f, -1.47779793e-01f,
  -1.01628684e-01f, -3.97426546e-01f, -3.64841759e-01f, -1.90900138e-03f, -1.57751396e-01f, -1.75660238e-01f, -3.79736871e-01f, -2.05581203e-01f, 2.07569420e-01f, -2.52704144e-01f,
  -1.10180996e-01f, -1.33143157e-01f, 3.17764997e-01f, -4.21360582e-01f, -3.06721658e-01f, -2.77988970e-01f, 5.20737795e-03f, -9.05831158e-02f, -2.36282647e-01f, 3.96555901e-01f,
  -7.76608288e-02f, 1.49862394e-01f, -9.81430411e-02f, -6.42081201e-02f, 2.23815456e-01f, -1.96087986e-01f, 4.36559439e-01f, -3.90379012e-01f, 4.74486575e-02f, -2.32493326e-01f,
  1.97469726e-01f, -1.83180422e-01f, 4.65554237e-01f, -2.19568253e-01f, 3.42282146e-01f, -2.21921727e-01f, 5.08277655e-01f, -2.10581437e-01f, -2.75509745e-01f, -3.80417854e-02f,
  -3.22727054e-01f, 4.39916164e-01f, -2.79857237e-02f, -2.99561679e-01f, 2.11912505e-02f, -3.10908228e-01f, 4.67862040e-01f, -1.78412750e-01f, -2.93751985e-01f, -5.70750870e-02f,
  -4.54881728e-01f, 1.15420029e-01f, -1.96026400e-01f, 3.61383080e-01f, -7.53125548e-02f, 3.43265355e-01f, -4.74732459e-01f, 3.15094948e-01f, -1.15599141e-01f, -2.52845287e-01f,
  4.47687954e-02f, -6.40247688e-02f, 1.59885764e-01f, -3.48451078e-01f, -2.67658889e-01f, 1.72401294e-01f, -3.22080940e-01f, -2.42673621e-01f, 2.24960893e-01f, -1.47317767e-01f,
  2.42465995e-02f, 6.02051243e-02f, 2.15388730e-01f, 1.83874533e-01f, 9.19260904e-02f, 1.48391813e-01f, 3.75966690e-02f, 6.81506544e-02f, 7.69462585e-02f, 3.09091955e-01f,
  1.69986963e-01f, 2.12573051e-01f, 3.21204275e-01f, 3.36353213e-01f, -7.65966298e-03f, 1.01731848e-02f, 1.19417615e-01f, -1.57498181e-01f, -2.69158095e-01f, 3.00623477e-01f,
  -2.47978553e-01f, -2.31965147e-02f, 2.48180389e-01f, -2.13858694e-01f, 1.18912593e-01f, -2.29946047e-01f, -2.36609980e-01f, -1.86383963e-01f, 1.13777377e-01f, -1.81229383e-01f,
  -3.08016807e-01f, -2.29893461e-01f, -1.85598046e-01f, -1.74080834e-01f, -3.42185497e-01f, -1.96251750e-01f, 3.37053090e-01f, -3.74683112e-01f, 2.56465584e-01f, -2.70679027e-01f,
  1.10281587e-01f, -1.12163477e-01f, 5.45509756e-01f, -1.85878724e-01f, -2.47991726e-01f, -2.99454033e-01f, 4.50948579e-03f, -1.72494739e-01f, -2.09305078e-01f, -3.11936021e-01f,
  -1.65658414e-01f, -1.62564777e-02f, 1.78619772e-01f, -3.09306741e-01f, -1.05680853e-01f, -2.90558726e-01f, -1.60379961e-01f, 2.48402998e-01f, 3.35319221e-01f, -1.09807111e-01f,
  1.06397912e-01f, -2.59248048e-01f, -2.70693302e-01f, -4.20211524e-01f, -1.86185271e-01f, -1.90468907e-01f, -3.15624297e-01f, 2.49111861e-01f, -1.45118922e-01f, -1.64733827e-01f,
  -2.73203343e-01f, 2.73780137e-01f, -1.78699702e-01f, -2.58461535e-01f, -8.02497640e-02f, 5.92283070e-01f, 2.82544523e-01f, -2.32427850e-01f, 5.85046113e-01f, -6.47168458e-02f,
  1.54225990e-01f, -2.76175290e-01f, -1.69265211e-01f, 2.79877633e-01f, -2.70137727e-01f, -6.85660616e-02f, 1.65843517e-01f, 2.04405159e-01f, -8.99255946e-02f, -2.67957568e-01f,
  2.84275591e-01f, 8.34736452e-02f, -1.27542362e-01f, -1.75983384e-01f, 2.74835169e-01f, -2.13585198e-01f, 2.14912649e-02f, -2.37333998e-01f, 5.27353704e-01f, 2.06655599e-02f,
  -2.08183125e-01f, 1.14876134e-02f, -1.83294371e-01f, -2.70604432e-01f, -1.29275039e-01f, 2.86440868e-02f, -2.28970841e-01f, -1.97050586e-01f, 2.49632243e-02f, -2.76683569e-01f,
  4.22660410e-01f, -1.85589582e-01f, 1.55304834e-01f, -4.59133368e-03f, -2.12789044e-01f, -2.05584839e-01f, 4.64214921e-01f, -8.65163282e-03f, -1.84323832e-01f, -5.80667071e-02f,
  -2.61178672e-01f, -3.72938253e-02f, 3.06391895e-01f, -7.33844936e-02f, -3.27212214e-01f, 4.47198033e-01f, -1.55891389e-01f, 2.80621856e-01f, 1.76344123e-02f, 1.19700767e-01f,
  7.32231066e-02f, -1.58158526e-01f, 8.59368891e-02f, -1.27238125e-01f, 9.76783112e-02f, -2.75334716e-02f, -1.65170044e-01f, -3.99350375e-02f, 4.89492789e-02f, 1.09772332e-01f,
  -2.10460886e-01f, 7.01637566e-02f, 2.57450968e-01f, -3.31463158e-01f, -1.14022315e-01f, -3.65482807e-01f, -4.13407832e-02f, -2.51992673e-01f, -2.31108636e-01f, -2.33209938e-01f,
  3.39367419e-01f, 9.07174200e-02f, 6.36849031e-02f, 1.86052322e-01f, -1.44095644e-01f, -3.48663598e-01f, -1.80548832e-01f, -2.10097313e-01f, -1.50715172e-01f, -1.36802606e-02f,
  -1.44581467e-01f, -3.03398043e-01f, -1.94461346e-01f, -1.66454911e-01f, 4.32702452e-01f, -2.58414239e-01f, -4.38061468e-02f, -1.25094904e-02f, 1.62517726e-01f, 2.26476595e-01f,
  -2.43574843e-01f, 4.41932648e-01f, -2.74575144e-01f, -2.44423468e-02f, 3.39207411e-01f, 2.42664255e-02f, -3.19243342e-01f, -1.23235971e-01f, -2.82261878e-01f, -2.03855112e-01f,
  -1.67782620e-01f, 2.92222619e-01f, -1.01576582e-01f, -7.11735487e-02f, -2.12630294e-02f, -3.97179067e-01f, -2.62599718e-02f, 1.08362675e-01f, 2.35740617e-01f, 3.86338562e-01f,
  1.19111866e-01f, 2.46368393e-01f, -4.34943438e-02f, 5.75668216e-01f, 2.10663065e-01f, 2.26916559e-03f, -1.01866975e-01f, 1.18831985e-01f, -1.43273771e-01f, -3.25207204e-01f,
  -1.82442084e-01f, -1.89823255e-01f, -5.01750931e-02f, -1.94374487e-01f, -2.22621877e-02f, -3.12494248e-01f, 1.18457489e-02f, -1.47684306e-01f, -2.53918171e-01f, -9.46204271e-03f,
  -2.15353295e-01f, -3.75055134e-01f, -2.39176527e-01f, 3.72115999e-01f, 5.19630671e-01f, -1.77424252e-01f, -2.52307147e-01f, 1.32147893e-01f, -1.04018763e-01f, 4.37357903e-01f,
  -5.66704907e-02f, -4.97930348e-02f, -8.49266499e-02f, 5.18335342e-01f, -1.94119230e-01f, -1.57681957e-01f, -2.21364498e-01f, -1.37962773e-01f, -1.30851746e-01f, 3.06516796e-01f,
  -1.74733669e-01f, -2.14746714e-01f, -2.06921563e-01f, 2.90969521e-01f, 8.46134946e-02f, -2.38704324e-01f, 3.76519382e-01f, 2.94419676e-01f, -2.34505087e-01f, -1.72848642e-01f,
  1.36590734e-01f, -3.74159999e-02f, 2.76104063e-01f, -1.72449157e-01f, -1.56776980e-01f, -2.16861710e-01f, 2.16449071e-02f, 4.86659229e-01f, 5.46534099e-02f, -2.17028901e-01f,
  -2.64979571e-01f, -2.24366203e-01f, -4.69155330e-03f, -2.51040936e-01f, 9.80794877e-02f, -1.33839592e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -8.64486843e-02f, 8.22448209e-02f, -1.37032181e-01f, 1.04929572e-02f, 3.67538631e-02f, 1.10942058e-01f, 1.56078022e-02f, -1.10333614e-01f, -3.72827910e-02f, 9.20799598e-02f,
  6.00975379e-02f, 2.37334967e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    