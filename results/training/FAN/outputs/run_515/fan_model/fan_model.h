/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.60504216e-01f, -2.26184979e-01f, -7.41696730e-03f, -1.69831276e-01f, 1.70789614e-01f, -3.05441082e-01f, -1.98793709e-01f, 9.50232372e-02f, -9.92774516e-02f, -1.19126782e-01f,
  -9.56162512e-02f, -6.64700866e-02f, -1.21198930e-01f, -2.15144739e-01f, 2.17253026e-02f, -1.33200482e-01f, -2.48945683e-01f, -1.35674253e-01f, 1.22732654e-01f, -7.29178414e-02f,
  8.35026056e-02f, 2.25806832e-02f, 1.80634093e-02f, -2.79624835e-02f, -6.60043359e-02f, 8.83472152e-03f, 1.28519952e-01f, 8.40863436e-02f, -5.91878854e-02f, -1.51630882e-02f,
  -1.35708109e-01f, -6.28013164e-02f, 4.74084169e-02f, -1.34802423e-02f, -3.90052572e-02f, -1.40273934e-02f, 7.50533165e-03f, -1.45816915e-02f, 2.89738867e-02f, -9.38188459e-04f,
  1.92039907e-02f, 5.06298319e-02f, 1.76733695e-02f, 3.08166575e-02f, -6.00169711e-02f, -2.04343442e-02f, 2.90516466e-02f, -6.96463883e-02f, 3.60023007e-02f, 5.03789559e-02f,
  2.90879011e-02f, 8.88143107e-03f, 2.97412146e-02f, -9.96400192e-02f, 5.15732616e-02f, -5.09214215e-02f, -5.33103868e-02f, 9.62509140e-02f, -1.68935731e-02f, -4.44228202e-02f,
  5.27101606e-02f, 1.09042395e-02f, 2.25157049e-02f, 3.19118059e-04f, 2.89127734e-02f, 7.25790160e-03f, -2.92318743e-02f, 4.20468412e-02f, 1.86444484e-02f, 3.12899575e-02f,
  -3.77895571e-02f, 6.56980053e-02f, -2.05857381e-02f, -1.01700854e-02f, 2.84804702e-02f, -4.83745858e-02f, -1.03972092e-01f, 3.04248203e-02f, -4.02475782e-02f, 2.92164925e-02f,
  -4.92721312e-02f, -4.67820577e-02f, -6.86189234e-02f, -7.39384862e-03f, 2.63823699e-02f, -1.12014264e-02f, -1.10891620e-02f, -2.12302413e-02f, -2.50719134e-02f, 5.33808433e-02f,
  -2.39214256e-01f, -7.15914695e-03f, -6.81843236e-03f, -1.14297876e-02f, -9.11379904e-02f, 2.76622120e-02f, 3.36010754e-02f, 3.58581878e-02f, -7.54555166e-02f, 1.52345141e-02f,
  -4.68641855e-02f, -4.11682427e-02f, 7.94728170e-04f, -2.90813334e-02f, -5.73107414e-02f, 2.91057043e-02f, -4.91343625e-03f, -7.57576823e-02f, 9.31745488e-03f, 2.21694726e-02f,
  -3.29517201e-02f, 1.51858227e-02f, 7.41479024e-02f, 6.97584227e-02f, 5.00488430e-02f, 6.72350302e-02f, 4.40706946e-02f, 3.21841761e-02f, 9.96372998e-02f, -1.48881488e-02f,
  2.86751211e-01f, 6.29105791e-02f, 1.25729218e-01f, 2.92656779e-01f, -5.77725917e-02f, -1.53519258e-01f, -8.43575373e-02f, 2.99814921e-02f, 1.88051119e-01f, 5.36221042e-02f,
  -1.36547476e-01f, 2.78919935e-01f, -1.42312244e-01f, 7.90749416e-02f, 3.72831933e-02f, -2.59397551e-02f, 1.25633970e-01f, 9.88800600e-02f, 4.48249094e-02f, 7.93952569e-02f,
  6.88519999e-02f, 6.78813308e-02f, -2.91808005e-02f, -4.60784994e-02f, 2.29501463e-02f, 1.91949364e-02f, 1.76718086e-01f, -1.00281976e-01f, -3.32618728e-02f, -8.21748190e-03f,
  1.01056017e-01f, 6.22903369e-02f, -4.87203375e-02f, 7.11975619e-02f, 4.94847680e-03f, -8.15904364e-02f, -4.24859766e-03f, -3.29047740e-02f, -5.66827841e-02f, -1.07330963e-01f,
  1.76550113e-02f, 1.04088776e-01f, -8.20630882e-03f, -3.55737954e-02f, 6.83697965e-03f, -9.88459866e-03f, -4.64617237e-02f, 1.98063087e-02f, -5.11401668e-02f, 2.53437106e-02f,
  -9.39335823e-02f, -3.02525479e-02f, 4.42566425e-02f, 4.89116944e-02f, -1.07205557e-02f, -5.29165417e-02f, -4.24569510e-02f, 2.33515166e-02f, -1.18545249e-04f, 4.99534719e-02f,
  1.10935429e-02f, -2.16467865e-03f, 9.46433563e-03f, 2.15399880e-02f, 5.47223985e-02f, 2.74970867e-02f, 3.97571921e-02f, -4.82902629e-03f, 9.87727046e-02f, 4.63126227e-03f,
  1.01951636e-01f, 6.70041963e-02f, -1.52080934e-02f, -4.53484245e-02f, 6.05670661e-02f, 5.48964702e-02f, -3.68957333e-02f, 6.93446621e-02f, 6.27458915e-02f, 2.94328369e-02f,
  3.65637243e-02f, 1.13691483e-03f, 8.12690705e-02f, -1.09195262e-02f, -5.81848472e-02f, -2.71595437e-02f, 6.07421026e-02f, -1.52535969e-02f, -8.95985365e-02f, -1.48116685e-02f,
  2.51658797e-01f, 3.63752127e-01f, -1.42516615e-02f, -5.52315190e-02f, -2.02872045e-03f, 1.27518624e-02f, 1.14732962e-02f, -1.63476169e-02f, 1.25181004e-02f, 2.96595786e-02f,
  -4.20967974e-02f, 5.41390618e-03f, 8.71345252e-02f, -2.91087013e-03f, -5.29847257e-02f, 3.84963751e-02f, -3.18145123e-03f, 6.21045269e-02f, 5.93965352e-02f, 6.36436194e-02f,
  5.35474233e-02f, -1.63634643e-02f, -6.79456368e-02f, -1.98054616e-03f, -3.33801210e-02f, -3.77520770e-02f, 7.03594312e-02f, 4.02776785e-02f, 9.48352832e-03f, 7.16894567e-02f,
  -2.81687617e-01f, -1.27100199e-01f, -3.40059727e-01f, -2.01289520e-01f, 1.62519589e-01f, -6.63870648e-02f, -1.85404867e-01f, 8.18952620e-02f, -2.51619279e-01f, 2.20240086e-01f,
  1.80896744e-01f, -2.73547620e-01f, -3.19653936e-02f, -2.75483401e-03f, -1.52826443e-01f, -1.16569363e-01f, -1.41653553e-01f, -4.82259281e-02f, -1.21306628e-01f, -7.12925643e-02f,
  -1.45259112e-01f, 2.23089233e-01f, -8.57600570e-02f, 1.80508986e-01f, 4.47760262e-02f, -4.43685576e-02f, 2.16235012e-01f, 1.07670270e-01f, 1.13600336e-01f, 4.60515805e-02f,
  5.78971878e-02f, -1.38425073e-02f, 4.36830297e-02f, -4.22523841e-02f, 2.37358436e-02f, 5.76380342e-02f, -3.97447981e-02f, -1.06541784e-02f, -4.44238521e-02f, -4.24528681e-02f,
  -5.73047251e-02f, -1.13183847e-02f, -2.26424262e-02f, 4.12780568e-02f, -5.94320074e-02f, -2.49159820e-02f, 7.38589168e-02f, -4.08592410e-02f, -6.12205118e-02f, -5.41126430e-02f,
  -9.04574096e-02f, -2.00817604e-02f, -3.35498005e-02f, 4.37999144e-02f, -1.31222233e-01f, -4.48061712e-02f, -2.09982786e-02f, 1.78082939e-03f, 3.40154357e-02f, 6.27992675e-03f,
  5.55110052e-02f, -3.46937403e-02f, 6.28532320e-02f, 4.71803509e-02f, -2.97902487e-02f, -8.57602619e-03f, 1.32614560e-02f, 3.58112678e-02f, 3.40337330e-03f, 1.31133432e-02f,
  8.79174173e-02f, 1.58252679e-02f, -9.69158951e-03f, -1.79343428e-02f, 1.57386810e-03f, -1.96272731e-02f, -1.22831380e-02f, 2.23290473e-02f, -1.56255979e-02f, 1.18576633e-02f,
  -2.68090423e-02f, -7.00973421e-02f, -5.50494194e-02f, 5.96770793e-02f, -5.85440919e-02f, 2.01948192e-02f, 4.21742238e-02f, -6.80237338e-02f, -3.02610677e-02f, 9.59461331e-02f,
  1.26600683e-01f, 3.27265672e-02f, 4.24354114e-02f, 9.84061807e-02f, 2.00995635e-02f, 9.00869966e-02f, -3.83096375e-02f, 5.86366223e-04f, 2.49563660e-02f, 3.66770998e-02f,
  3.23703438e-02f, 4.89992872e-02f, 2.51092929e-02f, -9.95193515e-03f, 4.34657037e-02f, 1.46574583e-02f, 2.06753612e-02f, 2.56377961e-02f, 4.51735184e-02f, 2.49578822e-02f,
  -1.24973841e-02f, -2.33540442e-02f, 9.66954380e-02f, 4.75285873e-02f, 3.53537663e-03f, 2.49479967e-03f, 4.27396670e-02f, -6.43207133e-02f, 6.03818893e-02f, 7.16508552e-02f,
  -3.11550289e-01f, -1.24589168e-01f, -1.92219540e-01f, -6.59463182e-02f, -6.51819929e-02f, -2.01401323e-01f, -5.30060334e-03f, -1.76932514e-01f, 1.81831960e-02f, 1.08002476e-01f,
  -1.29787266e-01f, 6.00262731e-02f, 5.57275228e-02f, 3.86137664e-02f, -2.29482241e-02f, 4.05594558e-02f, -9.67605934e-02f, 8.11100844e-03f, 3.33882682e-02f, -1.90514669e-01f,
  -5.14821596e-02f, -1.16369046e-01f, -8.09732378e-02f, -1.49276078e-01f, -1.05078608e-01f, 3.49230021e-02f, 8.76701847e-02f, -1.07677773e-01f, -4.48991023e-02f, 1.27950907e-02f,
  -5.96090890e-02f, -1.32356193e-02f, 2.85808574e-02f, 1.24248501e-03f, -1.06903933e-01f, 3.57855391e-03f, 4.65257056e-02f, 3.55678499e-02f, 5.38918152e-02f, -1.64607055e-02f,
  7.46527165e-02f, -3.86892847e-04f, 8.03295290e-04f, -2.33702119e-02f, -5.70439138e-02f, 2.25564390e-02f, 6.53976528e-03f, -9.43934098e-02f, 2.57814098e-02f, -1.27895521e-02f,
  -2.48785969e-03f, -3.61747518e-02f, 1.32635161e-02f, 1.10703390e-02f, -2.27660909e-02f, -5.58967628e-02f, 4.34376001e-02f, -3.99868898e-02f, -7.17878714e-03f, -3.86139825e-02f,
  -3.19275819e-02f, -5.14074170e-04f, -1.13020800e-02f, -3.80647019e-03f, -7.91269820e-03f, -5.43536991e-02f, -3.54280211e-02f, 4.36052494e-02f, -4.84522246e-02f, 1.72121059e-02f,
  -7.22007081e-02f, -3.85806747e-02f, -2.73608603e-02f, -3.25780287e-02f, -2.96920352e-02f, 1.08864130e-02f, -3.68906674e-03f, 5.72521538e-02f, -3.89280654e-02f, 6.75536916e-02f,
  1.24428747e-02f, -2.03064345e-02f, 1.58309061e-02f, -1.58291832e-02f, -9.28828027e-03f, 4.53108661e-02f, 7.00145811e-02f, -1.59339365e-02f, 7.16865249e-03f, -1.38122747e-02f,
  9.64991469e-03f, -4.96564694e-02f, -4.18228693e-02f, -3.05145010e-02f, 6.43462911e-02f, 6.10758327e-02f, -4.14790288e-02f, -3.47296633e-02f, -3.60206254e-02f, -9.13774967e-02f,
  -5.24819233e-02f, -8.23481474e-03f, 1.38208829e-02f, 4.83699553e-02f, 1.29929990e-01f, 3.36509012e-02f, -2.58612353e-02f, 5.04560359e-02f, -1.12600654e-01f, 4.36889380e-02f,
  2.17692945e-02f, -2.73932945e-02f, -3.66425440e-02f, -3.47675979e-02f, 2.94307657e-02f, 1.34281507e-02f, -7.56855905e-02f, 1.42290639e-02f, 7.79955238e-02f, 1.88356414e-02f,
  1.85113236e-01f, -8.76731053e-02f, 1.23619601e-01f, -3.50886732e-02f, 2.21851870e-01f, 7.20650777e-02f, -2.09337706e-03f, 1.76918969e-01f, -1.45038232e-01f, -1.90366209e-01f,
  7.85663608e-04f, -4.31825072e-02f, -4.20008749e-02f, -1.74926966e-02f, -4.86281216e-02f, -1.30337268e-01f, 7.01881945e-02f, -5.96202761e-02f, 7.96515867e-03f, 1.65494010e-01f,
  8.27832671e-04f, 3.41830067e-02f, -1.10185526e-01f, 1.18492559e-01f, 1.95014775e-01f, 6.45416183e-03f, -2.50090957e-02f, 4.73979712e-02f, 1.09621346e-01f, 1.73316244e-02f,
  8.04330036e-02f, 3.52758914e-02f, 1.86452776e-01f, 8.90535414e-02f, 1.31183818e-01f, 5.49475141e-02f, 6.35231063e-02f, -1.14264395e-02f, -3.92002538e-02f, -5.91534302e-02f,
  -5.78160547e-02f, 5.57535701e-02f, -1.04787663e-01f, -7.00770468e-02f, 4.72505502e-02f, -6.07436448e-02f, -7.94319808e-03f, 4.85011004e-02f, -6.70054853e-02f, 2.92155165e-02f,
  -3.97654846e-02f, 1.07836470e-01f, -2.22286209e-03f, 4.35476936e-02f, 2.29462720e-02f, -2.93997861e-02f, -1.22219525e-01f, 3.59514989e-02f, 8.42643306e-02f, 8.48760009e-02f,
  -5.30963251e-03f, -5.95228709e-02f, 1.18598808e-02f, 6.95650727e-02f, -2.87184771e-02f, 3.12235933e-02f, -4.48260941e-02f, -3.79790515e-02f, -5.73292375e-02f, 4.60022502e-02f,
  8.04068148e-02f, -5.20904921e-02f, 3.46028619e-02f, -5.24098463e-02f, -7.11328685e-02f, -3.14317569e-02f, 1.26599818e-02f, 4.90247570e-02f, -2.03718897e-02f, 2.46941615e-02f,
  -2.14916933e-02f, 2.31157336e-03f, -2.96312738e-02f, -2.43638363e-02f, -1.76736489e-02f, 4.82740216e-02f, -1.33440280e-02f, -1.03004761e-02f, -3.80387194e-02f, 1.92078557e-02f,
  6.76362291e-02f, 2.64360160e-02f, -2.32765842e-02f, 5.52227907e-02f, -3.68166640e-02f, 6.43206239e-02f, 1.07412843e-03f, 3.77176590e-02f, -3.50227170e-02f, 7.67010823e-02f,
  9.20771901e-03f, -4.53783870e-02f, 9.84205827e-02f, -7.40919216e-03f, -2.92561557e-02f, 6.52735233e-02f, -6.57341257e-02f, -6.25514686e-02f, 5.99783622e-02f, 3.60164307e-02f,
  6.66616559e-02f, 5.73421828e-03f, -1.55162252e-02f, 3.85695733e-02f, -4.77434043e-03f, -3.55858430e-02f, 2.94390172e-02f, -2.20550951e-02f, 1.41175957e-02f, 3.66132967e-02f,
  -1.43382221e-01f, 2.34781161e-01f, 3.49251591e-02f, -8.62076040e-03f, -1.31323889e-01f, -6.29946291e-02f, -7.18010515e-02f, 1.65632099e-01f, 9.16341245e-02f, 1.18863948e-01f,
  1.09081693e-01f, -4.72863466e-02f, 7.29352832e-02f, 2.03453582e-02f, -3.76754940e-01f, -1.43330976e-01f, -8.58290344e-02f, 6.75944537e-02f, -3.54386009e-02f, 1.93935961e-01f,
  -6.67710528e-02f, 3.99067774e-02f, -1.85548812e-01f, 1.15899714e-02f, 1.19450197e-01f, 6.88540339e-02f, -2.02754214e-01f, 5.07218391e-02f, 6.43431693e-02f, -6.66487515e-02f,
  1.78183373e-02f, 1.36301532e-01f, 5.80380782e-02f, -5.83011284e-02f, 3.19649167e-02f, -1.58037841e-02f, -1.25862047e-01f, -7.85554424e-02f, 9.06770397e-03f, -1.57522261e-02f,
  -3.84491421e-02f, -8.16966593e-02f, -9.62583199e-02f, -3.39140706e-02f, 3.68884131e-02f, 7.06145912e-02f, 2.57736333e-02f, -2.33533736e-02f, 1.12681568e-01f, -2.20564306e-02f,
  -6.41861232e-03f, 9.02526826e-03f, 5.04814573e-02f, 9.17772576e-03f, -2.23550107e-02f, 1.03294114e-02f, -4.26380709e-02f, 1.27743930e-04f, -9.95596647e-02f, 5.31504564e-02f,
  -1.66934039e-02f, -1.20043326e-02f, -2.11462379e-02f, 3.00832428e-02f, 6.18646741e-02f, 6.63693249e-02f, -9.84136667e-03f, -1.70746930e-02f, 4.88207117e-02f, -6.54508034e-03f,
  -9.35408846e-03f, -4.59416993e-02f, -3.53348739e-02f, -4.78147566e-02f, 2.82129180e-03f, 7.02646002e-02f, -6.92604035e-02f, 6.75466955e-02f, -1.65127311e-02f, 8.24896712e-03f,
  -9.62801650e-03f, 1.93627346e-02f, -5.16179425e-04f, 5.07022371e-04f, 5.08959591e-02f, 2.70217843e-02f, 6.78447932e-02f, -3.91104911e-03f, 3.01533309e-03f, -2.76014265e-02f,
  -4.20074351e-02f, 1.14484891e-01f, 3.73657532e-02f, 6.58865869e-02f, -3.96155752e-02f, -4.61710393e-02f, 5.00099408e-03f, 1.53903915e-02f, -1.02136014e-02f, 3.22777107e-02f,
  2.51565892e-02f, -2.14872397e-02f, 2.79940460e-02f, 6.35483414e-02f, -6.35801330e-02f, -2.06629485e-02f, -3.42055522e-02f, 3.26996036e-02f, -5.72681129e-02f, -8.20560846e-03f,
  -2.75901370e-02f, -1.53817497e-02f, -2.54005063e-02f, 2.29669977e-02f, 4.76006791e-03f, -9.53528881e-02f, 2.69662845e-03f, -1.05512217e-02f, 2.27535442e-02f, -7.30256364e-02f,
  -3.68530601e-01f, -9.51403826e-02f, -1.02624871e-01f, -1.99811772e-01f, 1.38347726e-02f, -7.86080062e-02f, -1.00411877e-01f, -5.21677993e-02f, -1.50357276e-01f, -4.82987799e-02f,
  4.70749810e-02f, -1.86869621e-01f, 1.73642233e-01f, 7.81164840e-02f, 1.57167956e-01f, 1.89969569e-01f, 1.30544975e-01f, 1.28747849e-02f, 5.08853234e-02f, -1.52270466e-01f,
  5.75343184e-02f, 1.07907131e-01f, 2.28028849e-01f, 1.07287243e-01f, 1.00958543e-02f, -1.78055778e-01f, 4.73424271e-02f, 8.71144235e-03f, -1.34439647e-01f, 1.12593532e-01f,
  1.94644649e-02f, 6.37471005e-02f, -3.01997387e-03f, -6.34910390e-02f, 1.22845098e-01f, -1.64991710e-02f, -1.10107672e-03f, 4.06873152e-02f, 1.27973752e-02f, -3.78038362e-02f,
  8.34377781e-02f, 3.52993309e-02f, -6.83973581e-02f, -3.85192931e-02f, -5.84624242e-04f, -1.00640461e-01f, -4.46764342e-02f, -3.94326262e-03f, -4.63694185e-02f, 2.44252700e-02f,
  -4.00740542e-02f, 5.59841357e-02f, 3.67068350e-02f, 7.60037377e-02f, -2.07839850e-02f, -5.90492152e-02f, 7.67521411e-02f, -5.60064800e-02f, -3.22498940e-02f, -7.24111870e-02f,
  7.78244808e-02f, -3.87131050e-02f, 4.65994664e-02f, -2.42760703e-02f, 3.14677954e-02f, 3.96568626e-02f, 7.29814768e-02f, 5.84520446e-03f, 5.61009198e-02f, 4.74376306e-02f,
  -7.92789385e-02f, -4.04326208e-02f, -4.45520021e-02f, -4.80861366e-02f, 6.67508394e-02f, 4.54511493e-02f, 6.34492561e-02f, -3.39600109e-02f, 2.08797771e-02f, -5.86019121e-02f,
  -3.64387855e-02f, -6.20516613e-02f, 5.78234494e-02f, -1.81350466e-02f, -2.99572479e-02f, 3.90767027e-03f, -3.28983390e-03f, 4.36348952e-02f, 7.52783716e-02f, 9.11552310e-02f,
  4.75134850e-02f, 1.04778018e-02f, -4.51674685e-02f, 8.98936838e-02f, -1.34512233e-02f, -4.77323635e-03f, -6.06295932e-03f, -7.38348365e-02f, -2.76674107e-02f, 8.21956694e-02f,
  -7.60083422e-02f, -7.11246058e-02f, 1.28922854e-02f, -9.40295979e-02f, 2.22636547e-04f, 5.37098683e-02f, 8.87375548e-02f, 9.82297063e-02f, 2.76723020e-02f, 4.03381884e-02f,
  8.72432142e-02f, 6.25306144e-02f, -6.44682720e-02f, 6.31430745e-02f, -1.84513684e-02f, 9.27061774e-03f, -1.16736911e-01f, -2.75047719e-02f, 7.41949454e-02f, 1.02593049e-01f,
  5.84445819e-02f, 5.80328032e-02f, -2.12459579e-01f, 1.18843816e-01f, -1.26877457e-01f, -1.16051100e-01f, 1.65641438e-02f, 3.30764614e-02f, -7.24948198e-02f, 1.41494647e-01f,
  1.21982306e-01f, -6.70959353e-02f, 2.58119572e-02f, 2.38601983e-01f, 9.75602567e-02f, 1.39280811e-01f, 2.68513739e-01f, 8.29865560e-02f, 5.00494912e-02f, 7.88279634e-04f,
  8.76001567e-02f, 3.46867889e-01f, 1.47788256e-01f, 9.57563743e-02f, 5.73353656e-02f, 6.68463111e-02f, 1.15386344e-01f, -1.13099307e-01f, 1.08245790e-01f, 4.43275494e-04f,
  8.54437500e-02f, -8.14228505e-02f, -9.54639167e-02f, 1.39639655e-03f, -6.20890446e-02f, -1.35994628e-01f, -2.41500884e-02f, 3.49314213e-02f, -9.89214797e-03f, 6.63623738e-04f,
  -5.90784959e-02f, -3.42217162e-02f, 6.56324178e-02f, 4.74732136e-03f, 3.39520536e-03f, -6.63479269e-02f, 2.58950014e-02f, 3.98818925e-02f, -3.89094800e-02f, 4.69292030e-02f,
  -1.22592493e-03f, 6.01415373e-02f, -4.08291183e-02f, 6.78357929e-02f, 1.28868567e-02f, -2.71547190e-03f, 3.68958944e-03f, -8.42398591e-03f, -3.36256139e-02f, 5.03153540e-02f,
  -2.44804155e-02f, -7.31034111e-03f, 6.62284270e-02f, -2.36068796e-02f, -4.47006039e-02f, 7.72954803e-03f, -9.25103202e-03f, 7.78696164e-02f, -3.20395604e-02f, 6.75521716e-02f,
  2.91086081e-02f, -1.53364474e-02f, -2.76569631e-02f, 4.72621582e-02f, 5.08387201e-02f, -2.64455099e-02f, 4.39805463e-02f, 8.30223337e-02f, -1.31597728e-01f, -1.39945243e-02f,
  -1.04609067e-02f, -8.58930312e-03f, -9.71023962e-02f, 7.47474208e-02f, 4.06185020e-04f, -3.35567482e-02f, 3.80204096e-02f, -2.11356413e-02f, 6.51161149e-02f, -7.14972196e-03f,
  2.80707609e-02f, 6.59129471e-02f, -1.85289178e-02f, 6.44276068e-02f, -8.01825002e-02f, -4.50353734e-02f, 6.09970046e-03f, 5.53071760e-02f, -4.59043495e-02f, -4.69180495e-02f,
  3.09188273e-02f, 3.12265754e-02f, 2.24801041e-02f, -4.54018153e-02f, -2.04148311e-02f, 4.11278158e-02f, -8.14156160e-02f, -1.01285251e-02f, 5.40925674e-02f, 1.85931218e-03f,
  1.30898366e-03f, 9.77838133e-03f, 2.08521746e-02f, -7.07837716e-02f, 3.15480138e-04f, 8.05628598e-02f, -5.16838580e-02f, -8.08609128e-02f, -3.04721296e-02f, 2.76698521e-03f,
  -2.68248320e-02f, 1.51194811e-01f, -1.15209408e-01f, 9.53086242e-02f, -3.20078105e-01f, -1.95702985e-02f, -1.82203740e-01f, -1.37466267e-02f, -3.24782342e-01f, 4.18277770e-01f,
  1.56524301e-01f, 3.38473991e-02f, 8.25301111e-02f, 3.43076259e-01f, -2.42238000e-01f, -8.91022086e-02f, 6.08339310e-02f, 5.08107878e-02f, -1.87895581e-01f, 5.29198907e-02f,
  -8.70567374e-03f, 2.28319675e-01f, 5.76356463e-02f, 2.18048215e-01f, 1.85579762e-01f, 6.10119440e-02f, 1.92020103e-01f, -1.64625987e-01f, 2.72865832e-01f, -7.89043680e-02f,
  2.79435646e-02f, 8.19521174e-02f, 2.73598433e-02f, 4.80184390e-04f, 5.33554144e-02f, -2.28502378e-02f, -1.30424071e-02f, -9.15577784e-02f, -8.68726522e-02f, 2.48784516e-02f,
  9.66273062e-03f, -2.18501454e-03f, 9.93511155e-02f, -1.11204989e-01f, -1.58337712e-01f, 4.53723967e-02f, -3.42823528e-02f, 2.60965675e-02f, 6.55957982e-02f, -6.56878948e-02f,
  -7.89907873e-02f, -5.21733873e-02f, -1.64051466e-02f, 2.59871352e-02f, -5.55162393e-02f, -1.52484579e-02f, 2.05594134e-02f, -8.81449953e-02f, 4.48550731e-02f, -8.46041143e-02f,
  -5.87416627e-02f, -1.21305875e-01f, 2.90566124e-02f, -1.55962212e-02f, 8.42815563e-02f, 5.46698868e-02f, 4.12444696e-02f, 4.27140016e-03f, -7.85203427e-02f, 5.54484650e-02f,
  4.15649563e-02f, 2.18938142e-02f, -8.90003219e-02f, 1.27959149e-02f, 6.19294569e-02f, 2.50538290e-02f, 3.97665845e-03f, -4.92599141e-03f, -5.00368588e-02f, -5.11278436e-02f,
  -1.29923727e-02f, -1.36508103e-02f, 1.03087395e-01f, -3.56220757e-03f, -2.25725267e-02f, -7.08919019e-02f, 8.68992135e-02f, 1.45780547e-02f, -2.13085152e-02f, 3.28252278e-03f,
  -1.54136196e-02f, 5.85758537e-02f, 4.61051948e-02f, 9.57821310e-02f, 2.17122715e-02f, 3.05670705e-02f, -7.32433200e-02f, 2.48626862e-02f, -9.20579955e-02f, 1.06668025e-01f,
  -1.06075611e-02f, 9.16510671e-02f, -8.27574916e-03f, -7.09001794e-02f, -1.69864669e-02f, -4.65721125e-03f, 4.45998134e-03f, 5.52602997e-03f, -1.09552415e-02f, 2.67862668e-03f,
  1.14110582e-01f, 6.40227925e-03f, 5.56561835e-02f, 3.31825502e-02f, 7.79855922e-02f, 9.07719806e-02f, -3.53143550e-02f, -1.49872452e-02f, 4.31732694e-03f, -1.32292146e-02f,
  -4.11842167e-01f, -1.85621269e-02f, 1.77697539e-01f, -1.06783979e-01f, -1.32539555e-01f, -9.90141854e-02f, 1.08480044e-01f, -2.01378107e-01f, -2.02163950e-01f, -3.23765352e-02f,
  6.87529668e-02f, 2.19324455e-02f, 1.83604836e-01f, 9.62640438e-03f, 2.21407816e-01f, 1.29182085e-01f, -1.22070666e-02f, -5.02735265e-02f, -1.63510460e-02f, -4.34895642e-02f,
  -1.11164823e-02f, -3.80038992e-02f, 1.03368938e-01f, -8.38884339e-02f, -2.99284812e-02f, -8.21736455e-02f, 1.00039095e-01f, 2.28727117e-01f, -8.41707587e-02f, 5.47697134e-02f,
  -5.29190339e-02f, -5.00141159e-02f, 6.61025569e-02f, 3.21578085e-02f, -2.84175947e-02f, -3.58638577e-02f, -3.63355428e-02f, 1.11892365e-01f, 2.61051077e-02f, -6.69149756e-02f,
  3.40213962e-02f, -2.40961760e-02f, -9.11588371e-02f, 5.66143394e-02f, -1.12226777e-01f, -4.44796868e-02f, -3.74403852e-03f, -5.93148544e-02f, 3.07506602e-02f, 4.41908725e-02f,
  2.00690627e-02f, 4.98489887e-02f, -3.47615071e-02f, 9.10672639e-03f, -2.93165240e-02f, -9.91763826e-03f, -6.09201714e-02f, 6.39755502e-02f, -6.78765848e-02f, -4.84805070e-02f,
  -6.62915483e-02f, 3.89236435e-02f, -1.42002907e-02f, 2.65460722e-02f, 2.34401654e-02f, -3.10964715e-02f, 3.77503708e-02f, -3.35638337e-02f, 1.81011725e-02f, 2.41739154e-02f,
  3.36435288e-02f, 9.19952244e-03f, -2.22645216e-02f, 9.30360798e-03f, -7.63611048e-02f, -4.60950881e-02f, 1.37032988e-02f, 1.34076839e-02f, 5.05071552e-03f, -8.07762425e-03f,
  1.66426264e-02f, -8.41687620e-03f, 7.72753805e-02f, -1.31529653e-02f, -6.71960227e-03f, 2.85182614e-02f, 3.47119942e-03f, 1.92817468e-02f, 2.06341464e-02f, 2.46086642e-02f,
  -7.57262781e-02f, 5.58340177e-02f, 7.56611209e-03f, 4.71414393e-03f, 1.40776234e-02f, -1.71172377e-02f, 7.88056627e-02f, -8.11166465e-02f, 7.39035904e-02f, -1.35164345e-02f,
  -3.08568031e-02f, -5.74069098e-03f, 2.80158818e-02f, 4.02020775e-02f, 2.34617013e-02f, 4.97604683e-02f, 6.23377413e-02f, -6.07878752e-02f, -1.17244152e-02f, -4.85066883e-02f,
  -4.88591045e-02f, -2.32421923e-02f, 2.18835138e-02f, -3.70309725e-02f, -7.75219826e-03f, -4.94084097e-02f, -5.42121343e-02f, -2.46061273e-02f, 8.73381048e-02f, 6.17976002e-02f,
  -1.97466329e-01f, -8.34634528e-02f, 1.85247689e-01f, -1.80058964e-02f, -1.17653720e-01f, 7.98081085e-02f, 1.08002856e-01f, -1.81611124e-02f, 1.39539510e-01f, -1.26131475e-01f,
  -7.12984204e-02f, -3.67736369e-02f, 1.77959323e-01f, -1.17926195e-01f, -1.10402569e-01f, 2.30715185e-01f, -1.36009321e-01f, -4.74208146e-02f, 9.55626965e-02f, -1.45354569e-01f,
  -3.93767133e-02f, -2.22785011e-01f, -3.76792587e-02f, -1.93485290e-01f, -1.42728135e-01f, -2.82798577e-02f, -3.23849738e-01f, 1.22033402e-01f, -3.08390081e-01f, -6.26653209e-02f,
  -2.02719960e-02f, -3.79035366e-03f, 4.14571166e-02f, 4.88971500e-03f, -9.89463627e-02f, -2.09898502e-02f, 5.05898930e-02f, 9.05472189e-02f, -5.70482984e-02f, 1.25447540e-02f,
  3.93347368e-02f, 5.55066951e-02f, 4.37330119e-02f, -3.46847490e-04f, 7.13292137e-02f, 5.15236594e-02f, 6.28072396e-02f, -3.82809006e-02f, -3.17780860e-02f, 9.28578228e-02f,
  3.22125480e-02f, 1.84811614e-02f, 1.64362341e-02f, 1.08932760e-02f, 3.70742418e-02f, 6.00656010e-02f, -3.61045934e-02f, 1.07674049e-02f, 7.52204657e-02f, -1.26711400e-02f,
  1.77792925e-02f, -1.76590886e-02f, 1.69216818e-03f, -5.72275929e-02f, -7.93763176e-02f, -3.94898653e-02f, -5.27139306e-02f, 1.28952377e-02f, -2.32378170e-02f, -9.16716829e-03f,
  -4.55547385e-02f, -1.51398964e-02f, 4.42299247e-02f, 8.37789848e-03f, 1.16752060e-02f, 9.24388133e-03f, 3.16587207e-03f, 7.56572559e-02f, 3.31168473e-02f, 2.24626120e-02f,
  -5.93429692e-02f, -7.63385072e-02f, -1.84595454e-02f, 1.76821332e-02f, -6.32412955e-02f, 5.14022186e-02f, 2.49402244e-02f, 2.87253354e-02f, 2.48480942e-02f, 4.15428774e-03f,
  -2.04660416e-01f, -2.62954056e-01f, 5.36489785e-02f, 4.27464284e-02f, -3.00023071e-02f, -6.78688884e-02f, -1.51879224e-03f, -6.44951984e-02f, -4.49686572e-02f, 1.18379965e-02f,
  2.31507439e-02f, -2.95425840e-02f, -9.28043351e-02f, 8.52884725e-03f, -8.10052976e-02f, -9.66906250e-02f, -4.26085070e-02f, -2.25454383e-02f, -1.25231653e-01f, -4.57693934e-02f,
  -3.76317278e-02f, 1.97267756e-02f, -1.48880733e-02f, 9.56218224e-03f, -3.71536203e-02f, -2.00530402e-02f, -2.54307855e-02f, 3.15317661e-02f, 4.60725799e-02f, -9.55255236e-03f,
  2.83034831e-01f, -6.78838342e-02f, 4.45713252e-02f, 2.64418244e-01f, -4.40354310e-02f, 1.87762864e-02f, 1.16699278e-01f, 1.54220974e-02f, 3.14785279e-02f, -1.85008734e-01f,
  4.38065119e-02f, 1.50672957e-01f, -8.06630850e-02f, 6.44337088e-02f, 2.48555019e-01f, -3.13378982e-02f, 1.55812815e-01f, 1.02896772e-01f, -2.34076716e-02f, 7.38970488e-02f,
  5.20236157e-02f, -1.44959390e-02f, 9.86298844e-02f, -1.60307847e-02f, 5.97461462e-02f, 8.83995593e-02f, 6.12973049e-02f, -7.58349895e-02f, 8.89023244e-02f, -1.10076666e-02f,
  5.87583557e-02f, -8.90154913e-02f, 4.09991741e-02f, -2.06377860e-02f, 1.95535570e-02f, -4.54483740e-03f, 2.57481243e-02f, 5.61273135e-02f, 6.62351167e-03f, -6.00670930e-04f,
  -5.38037270e-02f, 3.44522148e-02f, -5.64915054e-02f, -1.74802039e-02f, 1.92805249e-02f, -3.70700448e-03f, -3.65140177e-02f, -3.94927301e-02f, -7.24658370e-02f, 4.94667515e-02f,
  3.35329175e-02f, -2.95659602e-02f, -4.81959656e-02f, -4.80531305e-02f, -2.27992777e-02f, -1.49487276e-02f, 2.24726368e-02f, -3.85024883e-02f, 1.01040462e-02f, 1.95406582e-02f,
  -7.31611112e-03f, -1.69926621e-02f, -3.41715328e-02f, -2.46969536e-02f, 6.20103441e-03f, 1.71662420e-02f, 1.93156656e-02f, -1.02624912e-02f, 3.95947248e-02f, -7.56956264e-02f,
  2.00813357e-02f, -3.00362986e-02f, -6.78800344e-02f, -3.61912362e-02f, -7.98219349e-03f, 1.48931416e-02f, 3.36176790e-02f, -4.87788469e-02f, 4.04148623e-02f, -4.29587178e-02f,
  -7.60262385e-02f, 3.46103590e-03f, 9.71361157e-03f, 1.59932617e-02f, -9.59247574e-02f, 1.60411112e-02f, -2.71391682e-02f, -7.18388110e-02f, -5.04908152e-03f, -2.57877335e-02f,
  -1.75668690e-02f, -3.36196832e-02f, -6.02551699e-02f, 1.85600817e-02f, -7.19101205e-02f, -3.47021297e-02f, 5.06456569e-02f, 3.30832228e-02f, -1.29256826e-02f, 3.29425122e-04f,
  1.07558044e-02f, -6.22135438e-02f, -1.33471098e-02f, 7.86623135e-02f, 1.51420815e-03f, -5.76879568e-02f, 1.92436185e-02f, -2.63451628e-04f, 1.86460204e-02f, 2.15647202e-02f,
  2.82125548e-03f, 2.23093927e-02f, 3.80771644e-02f, -1.55187249e-02f, 7.78458044e-02f, 5.90412393e-02f, 2.34612077e-02f, 2.10004766e-02f, 6.21702820e-02f, -1.05250003e-02f,
  -7.29345456e-02f, -9.04551074e-02f, -8.33345577e-04f, -8.27237964e-02f, 1.07663805e-02f, 1.94053933e-01f, 2.75825560e-01f, -4.24048677e-02f, 2.25259483e-01f, 1.44526511e-01f,
  1.19457014e-01f, 6.81327283e-02f, 7.02895746e-02f, 1.55608088e-01f, 1.99075237e-01f, 1.86456159e-01f, 4.09449488e-02f, 9.37221646e-02f, -1.09562151e-01f, -1.44701660e-01f,
  -1.43417679e-02f, -1.24522388e-01f, 7.79306591e-02f, -1.99526146e-01f, -1.16557486e-01f, -2.24130690e-01f, -1.93991110e-01f, -9.82664824e-02f, -6.94530681e-02f, -2.63526309e-02f,
  -4.75286879e-02f, 1.25772521e-01f, -6.08511344e-02f, 5.15089445e-02f, 5.14802188e-02f, 4.55208085e-02f, -1.34156570e-01f, -2.35947743e-02f, 3.37594859e-02f, 2.47635059e-02f,
  -1.81886554e-03f, 1.07839284e-02f, -2.54757819e-03f, 7.79492706e-02f, 6.88180104e-02f, 4.10092846e-02f, 2.81677023e-02f, -7.59031549e-02f, -3.98632511e-02f, -3.79191991e-03f,
  6.09155484e-02f, -6.69063479e-02f, 6.43956754e-03f, 1.37229003e-02f, 3.52605246e-02f, 6.66694343e-02f, 6.55032811e-04f, -4.26658196e-03f, -3.31022381e-03f, 1.21302702e-01f,
  -2.95849945e-02f, -7.54920114e-03f, -3.45547944e-02f, -2.67402362e-02f, 4.89536114e-03f, 3.53157073e-02f, 2.98590902e-02f, -2.71441713e-02f, -7.14893937e-02f, -1.67984087e-02f,
  -1.53835146e-02f, 2.38569994e-02f, -6.20280718e-03f, 4.16113473e-02f, -1.21814953e-02f, -6.17878959e-02f, -8.66993070e-02f, -3.51861455e-02f, 1.00058191e-01f, -3.15746814e-02f,
  5.48026003e-02f, 4.75274399e-02f, 7.28793815e-02f, -1.73246767e-02f, 2.69527175e-02f, 8.63034874e-02f, -8.00411776e-02f, 3.63719687e-02f, -4.49062996e-02f, -1.74451675e-02f,
  -8.62983465e-02f, -1.11504555e-01f, 4.84713912e-02f, -5.69110699e-02f, -4.36306931e-02f, 7.13914111e-02f, -3.59654846e-03f, -6.55143410e-02f, 2.76631974e-02f, -1.34719359e-02f,
  -9.81047079e-02f, -5.62578961e-02f, -4.52034511e-02f, -7.33839050e-02f, -3.18841338e-02f, 1.44428566e-01f, -7.49398395e-02f, -6.18233345e-03f, -7.79650435e-02f, 7.03381328e-03f,
  -8.55747983e-02f, -1.89970322e-02f, -4.64553349e-02f, -7.14206696e-02f, 6.41586632e-02f, 7.03914613e-02f, -3.26710939e-02f, 5.23045510e-02f, -2.98099313e-02f, 9.22380537e-02f,
  8.54576677e-02f, -2.01146737e-01f, -1.06664814e-01f, 4.37441934e-03f, 1.45210117e-01f, -1.09755713e-02f, -1.32423654e-01f, 1.30679488e-01f, -2.58168519e-01f, -1.21749267e-01f,
  2.08485261e-01f, -1.16742030e-01f, -9.98689532e-02f, 8.04300979e-02f, 1.08101912e-01f, -1.84779197e-01f, 5.64006120e-02f, -5.09010293e-02f, -1.12799875e-01f, 6.32134527e-02f,
  -5.98226152e-02f, 1.10997401e-01f, 2.36062277e-02f, 7.86552504e-02f, -6.64701462e-02f, 4.27634381e-02f, 1.18169948e-01f, -3.31772282e-03f, 1.24423765e-01f, 4.05050479e-02f,
  2.83836517e-02f, -3.67337540e-02f, -2.10441966e-02f, -8.65265280e-02f, 8.57722163e-02f, 1.62617173e-02f, -6.99115172e-02f, -4.69574295e-02f, 4.49452410e-03f, -3.00045963e-02f,
  7.52950972e-03f, -4.09603156e-02f, 1.80059783e-02f, 7.99739850e-04f, -6.09348975e-02f, 1.12367729e-02f, -3.92819978e-02f, 2.22468432e-02f, -5.38144670e-02f, 1.69187877e-02f,
  -7.89534673e-02f, -2.11618226e-02f, -1.19901150e-01f, -5.74277118e-02f, 9.63478442e-03f, 1.46106742e-02f, -4.57702354e-02f, 5.73656969e-02f, -9.07265767e-02f, -9.14479271e-02f,
  5.86871710e-03f, 1.50143150e-02f, 5.83482236e-02f, 5.60688600e-02f, 6.89562857e-02f, -2.02298947e-02f, -3.02921664e-02f, 4.34388183e-02f, -6.12054653e-02f, 2.08934154e-02f,
  3.22906151e-02f, 5.15960716e-02f, -4.61576618e-02f, 5.15998602e-02f, 2.88494360e-02f, 1.21920630e-02f, -4.44385745e-02f, 9.03493538e-03f, 8.63317847e-02f, 2.71434821e-02f,
  -2.45774332e-02f, -2.18122713e-02f, 6.13119043e-02f, 6.98143523e-03f, -3.28137092e-02f, 8.92165601e-02f, -2.18160208e-02f, 1.00245420e-02f, -4.75294217e-02f, 4.31399420e-02f,
  3.72135453e-02f, 1.50007248e-01f, -1.41820619e-02f, 4.19227481e-02f, -5.22064790e-02f, -2.78688269e-03f, -1.09833211e-01f, 8.57442617e-02f, 6.31964579e-02f, 9.73668844e-02f,
  2.56641340e-02f, 3.17570055e-03f, -1.52897425e-02f, 7.65966475e-02f, 2.29031816e-02f, 4.01845053e-02f, -4.24096780e-03f, 1.90784801e-02f, -4.23258170e-02f, 6.01366311e-02f,
  2.05177777e-02f, 1.07888974e-01f, -4.03618366e-02f, 9.56469625e-02f, 2.66069062e-02f, 6.42325431e-02f, 4.19643410e-02f, 9.96177085e-04f, 2.84332130e-02f, -7.99537450e-02f,
  2.65496194e-01f, -3.08495760e-01f, -1.92410290e-01f, 2.15288699e-02f, 1.19483754e-01f, 1.86439127e-01f, 1.87795818e-01f, -1.22400202e-01f, -6.79411069e-02f, -8.97145271e-02f,
  1.94727272e-01f, -1.58739299e-01f, -5.43252863e-02f, 2.91962642e-02f, 2.06957683e-01f, -2.23946258e-01f, 1.94646455e-02f, 6.06294163e-02f, -1.26832098e-01f, 1.58168580e-02f,
  -5.79452217e-02f, 4.86047938e-02f, -5.21316566e-02f, -3.91329974e-02f, 1.00314893e-01f, -1.40583739e-01f, 9.48679671e-02f, -3.49152461e-02f, 5.88601567e-02f, 1.48430750e-01f,
  1.28468826e-01f, -2.68151816e-02f, 2.53910152e-03f, -1.24251477e-01f, 7.80792758e-02f, 5.25184460e-02f, 4.04568389e-02f, 6.02083169e-02f, 1.42645855e-02f, -7.17278793e-02f,
  9.49808210e-02f, -1.23017721e-01f, -1.77187063e-02f, 5.80997858e-03f, 1.43649625e-02f, -1.20387822e-01f, 1.19956108e-02f, -1.59716755e-02f, -5.22754900e-02f, -3.90019664e-03f,
  -4.69807163e-02f, -7.00002313e-02f, -1.64479539e-02f, -3.38889062e-02f, 2.96669523e-03f, -2.47821473e-02f, -1.68514252e-02f, -2.44270661e-03f, -2.22133193e-02f, -1.99827906e-02f,
  2.45989077e-02f, -7.38397017e-02f, -4.49575409e-02f, -5.20053580e-02f, -6.07402287e-02f, -1.97063363e-03f, 4.97064069e-02f, 5.15063889e-02f, -1.71334743e-02f, 5.17215319e-02f,
  -2.11320724e-02f, 5.92750311e-02f, 2.39137746e-02f, -1.71609651e-02f, 2.84895096e-02f, 5.16371764e-02f, 1.75707061e-02f, 2.71063149e-02f, -8.11723471e-02f, 1.18012140e-02f,
  5.02246097e-02f, 3.84923257e-02f, -5.48121594e-02f, 4.84324619e-02f, 2.17167102e-02f, -1.55762583e-02f, -5.94071001e-02f, -6.63938969e-02f, 9.03070439e-03f, -1.02597252e-02f,
  -2.19620857e-02f, -1.23925529e-01f, -1.63483657e-02f, 4.68998812e-02f, -1.14140464e-02f, 2.07191892e-02f, -2.38277894e-02f, -6.01604395e-02f, -1.20966882e-01f, 4.76375967e-02f,
  -6.79770559e-02f, 3.18254270e-02f, -3.82572375e-02f, 3.08660194e-02f, 5.94848692e-02f, 4.21174569e-03f, -4.41492610e-02f, -2.28227407e-04f, 9.24984217e-02f, 3.41284089e-02f,
  2.03644428e-02f, -6.35499507e-02f, 1.39589710e-02f, -4.67905737e-02f, -2.15699561e-02f, -6.94719004e-03f, -2.65911259e-02f, -5.60101904e-02f, 2.56873518e-02f, -8.41367543e-02f,
  2.67839462e-01f, 1.22073805e-02f, 1.27169162e-01f, 1.32720098e-01f, 1.62387714e-01f, 1.44061493e-02f, -6.48961887e-02f, 1.35816172e-01f, 5.78880124e-03f, 7.83915371e-02f,
  -4.31859158e-02f, -3.00436281e-02f, -1.87981650e-01f, 4.44742013e-03f, -3.21251035e-01f, -2.58436143e-01f, 2.71039847e-02f, 2.20979638e-02f, -2.30467021e-02f, 6.83495104e-02f,
  1.40384436e-01f, 2.85733901e-02f, -1.35903275e-02f, 1.28317103e-01f, 1.34794950e-01f, 1.72780827e-01f, 4.07028534e-02f, -4.54536118e-02f, 1.40623152e-01f, -6.98836073e-02f,
  -8.40325207e-02f, 1.11977558e-03f, 4.99407984e-02f, -1.89438537e-02f, 5.66937551e-02f, 3.65839303e-02f, -4.85276841e-02f, -1.48651138e-01f, -2.78824605e-02f, 7.35876188e-02f,
  2.82981321e-02f, 2.87984293e-02f, 1.27166985e-02f, -2.80062873e-02f, 3.23455557e-02f, 8.28938633e-02f, 3.74587029e-02f, 4.00461955e-03f, 3.61709595e-02f, 1.32331669e-01f,
  6.80022016e-02f, 3.82715948e-02f, 6.84589297e-02f, -5.66270947e-02f, 4.86279801e-02f, 4.99280430e-02f, 3.61554604e-03f, -3.84137705e-02f, 3.94781306e-03f, 8.34879950e-02f,
  -5.79122603e-02f, 1.52055211e-02f, 1.56095074e-02f, 7.36573040e-02f, -2.69987900e-02f, 6.08579479e-02f, 4.90721166e-02f, 2.44859029e-02f, 2.03018226e-02f, 1.83897726e-02f,
  3.74471173e-02f, 1.67472027e-02f, 3.03272232e-02f, 4.76879738e-02f, 3.58420536e-02f, -2.56055593e-02f, -8.96203443e-02f, 3.06014139e-02f, 2.40858644e-02f, 5.64986877e-02f,
  -2.16405001e-02f, -1.59992445e-02f, -3.49073322e-04f, 2.04098318e-02f, -4.65785824e-02f, -1.52464341e-02f, 5.35542704e-02f, -1.97784137e-03f, 8.47656094e-03f, -1.81315280e-02f,
  -8.62090215e-02f, -1.82240024e-01f, -1.51941448e-03f, 6.16456382e-03f, 1.58546187e-04f, -7.07581937e-02f, -3.66157144e-02f, 5.01068644e-02f, -1.23137608e-01f, -3.72986645e-02f,
  -1.97194591e-02f, -2.31324863e-02f, -1.95968375e-02f, 3.70370038e-02f, -4.70105410e-02f, -5.12330830e-02f, -4.07442711e-02f, -3.71571928e-02f, -1.32236984e-02f, -4.04142588e-02f,
  5.66867441e-02f, -4.59491201e-02f, -5.55565506e-02f, 1.53091289e-02f, -3.11533064e-02f, -2.78927740e-02f, 5.33860549e-02f, 1.20000467e-02f, 6.91216486e-03f, -6.71906769e-02f,
  2.38136984e-02f, -3.52712393e-01f, -1.35863468e-01f, -6.86403960e-02f, 2.18840480e-01f, -1.92403719e-01f, -3.76851894e-02f, -2.57897563e-02f, -2.11911388e-02f, -2.95358926e-01f,
  7.37963319e-02f, -2.51157194e-01f, 9.85419527e-02f, -7.49373212e-02f, 1.13305569e-01f, -1.34618804e-02f, -9.62995961e-02f, -7.08696619e-02f, 7.84572661e-02f, 5.08920066e-02f,
  1.76863447e-01f, 2.04177618e-01f, 7.30359601e-03f, 1.61377281e-01f, 1.84201464e-01f, -4.49415930e-02f, 1.16589881e-01f, 1.06075227e-01f, -1.09152757e-01f, 3.27732936e-02f,
  -5.35303578e-02f, -9.51359514e-03f, 4.41176519e-02f, -7.80782998e-02f, 7.99139291e-02f, 3.26517853e-03f, -4.86807786e-02f, 5.62759191e-02f, 3.35851386e-02f, -7.41110221e-02f,
  -2.91477069e-02f, 4.59778048e-02f, -6.82516098e-02f, 7.58993104e-02f, 5.89370765e-02f, -4.93110009e-02f, -2.94520464e-02f, 6.58326223e-02f, -5.05545288e-02f, -7.96579197e-03f,
  -4.26544957e-02f, -1.61851645e-02f, 4.60564457e-02f, -7.57191107e-02f, 4.43114415e-02f, -1.87988319e-02f, -7.10234568e-02f, -3.81294033e-03f, 3.61648388e-02f, -7.49969762e-03f,
  5.98590896e-02f, 8.27392004e-03f, -4.46175672e-02f, 1.35876881e-02f, 2.35809516e-02f, 1.04632892e-01f, 3.63587663e-02f, 1.08219432e-02f, 3.45742330e-02f, -2.18065958e-02f,
  4.14853469e-02f, -6.63712770e-02f, 7.37395212e-02f, 3.20399143e-02f, -1.69881377e-02f, -1.76373087e-02f, 7.00491816e-02f, -2.02502795e-02f, 2.24444885e-02f, 6.61889464e-03f,
  -5.32598458e-02f, -1.08885104e-02f, 1.48524633e-02f, 1.68117806e-02f, 4.62138169e-02f, -4.37445156e-02f, 4.43210676e-02f, -1.64600220e-02f, 2.08194833e-02f, 4.87050191e-02f,
  -8.69417116e-02f, -1.17854431e-01f, 1.14552779e-02f, -1.58144403e-02f, -2.29728855e-02f, 7.19356313e-02f, 5.71440719e-02f, -1.24854781e-02f, -2.33269278e-02f, 8.21266472e-02f,
  5.44074327e-02f, -4.93885465e-02f, 6.54149801e-02f, 5.40237352e-02f, 3.89027782e-02f, -9.90475435e-03f, -2.79042926e-02f, 5.18791713e-02f, -1.95212159e-02f, 3.97123657e-02f,
  2.11726855e-02f, 2.36141812e-02f, -8.30429047e-03f, 5.37459217e-02f, 3.40964720e-02f, -2.24454217e-02f, -1.86062772e-02f, -6.66566938e-02f, 2.21216157e-02f, 6.72186539e-03f,
  3.89862061e-01f, -1.63645044e-01f, -4.54177484e-02f, 1.67846924e-03f, 6.55177012e-02f, -3.75229530e-02f, 1.17881663e-01f, -1.34403249e-02f, 1.49732572e-03f, 9.45993364e-02f,
  -4.54686070e-03f, -5.11658564e-02f, -3.35959462e-03f, -1.91962928e-01f, 1.26313791e-02f, -1.14132732e-01f, 1.54225072e-02f, 6.66536763e-02f, -4.84044217e-02f, 4.22245152e-02f,
  6.56195953e-02f, -8.13875869e-02f, -1.14949226e-01f, -1.54364884e-01f, -4.79799062e-02f, 8.43620747e-02f, 3.15779522e-02f, -8.49923640e-02f, -1.75252572e-01f, -9.33442116e-02f,
  6.46457970e-02f, 2.12866105e-02f, -3.77997234e-02f, 1.30206756e-02f, 8.52736458e-02f, 8.84599239e-02f, 1.46777466e-01f, -8.86491537e-02f, 6.14906661e-02f, -5.68693168e-02f,
  1.07271619e-01f, -8.48580152e-03f, -2.19153445e-02f, -8.99616033e-02f, 1.04738772e-01f, -4.64678481e-02f, 3.10933255e-02f, -1.92346834e-02f, -4.45843525e-02f, 1.85184143e-02f,
  -2.43501980e-02f, -9.62469354e-02f, 7.51474723e-02f, -5.56718521e-02f, -4.17540856e-02f, -1.19417114e-02f, -1.04158863e-01f, -4.60532904e-02f, -2.13860646e-02f, 7.29103535e-02f,
  -2.71261018e-02f, -3.24174911e-02f, -7.19417334e-02f, 3.64869125e-02f, -6.23201393e-02f, 7.25697204e-02f, -8.20775777e-02f, 6.62114471e-03f, -1.13444068e-02f, 1.04671687e-01f,
  5.24361581e-02f, -1.54251745e-03f, 1.99227389e-02f, 2.83107371e-03f, -2.56857136e-03f, -8.04655254e-02f, 9.18082986e-03f, 5.12213558e-02f, 7.30777755e-02f, 2.69825757e-02f,
  6.41315058e-02f, -4.62759752e-03f, -1.76842790e-02f, 2.81351209e-02f, -3.89638729e-03f, -4.03620536e-03f, -5.63605130e-03f, -6.18925914e-02f, 3.70633565e-02f, -1.18745053e-02f,
  1.33383930e-01f, -5.72825968e-02f, -7.82747567e-02f, 4.96026352e-02f, 5.17484872e-03f, -4.79610898e-02f, -1.95348468e-02f, 1.99735612e-02f, 2.16025840e-02f, 5.32372296e-03f,
  3.68902343e-03f, 2.98531037e-02f, 6.63818121e-02f, 1.86318420e-02f, -6.03670515e-02f, 1.07515402e-01f, 4.18177880e-02f, -5.82506023e-02f, 3.59715298e-02f, 5.04065910e-03f,
  -2.75532622e-02f, -3.85932135e-03f, -1.53726730e-02f, -7.16831833e-02f, -6.99468050e-03f, 4.66913022e-02f, 9.10764337e-02f, -3.60209867e-02f, -6.65441039e-04f, -2.88973190e-02f,
  -2.14309946e-01f, 1.40955508e-01f, 3.26215886e-02f, -9.23885182e-02f, -9.11573395e-02f, -1.42332777e-01f, -1.44341394e-01f, 3.96538675e-02f, -9.24283192e-02f, 5.81662022e-02f,
  1.73340123e-02f, 1.58156287e-02f, 1.40847087e-01f, -9.73829105e-02f, -2.80599207e-01f, 1.07831135e-01f, -9.42193046e-02f, -4.96632159e-02f, 1.66022256e-01f, -5.15309386e-02f,
  -4.73640896e-02f, -1.63000941e-01f, 2.54373979e-02f, 1.18596621e-01f, -1.58345282e-01f, 1.42800240e-02f, 4.61297147e-02f, -5.52816242e-02f, 5.52636012e-02f, -1.15815081e-01f,
  -5.50134182e-02f, 5.08825965e-02f, 8.24242011e-02f, 2.18483410e-03f, -2.39449050e-02f, -1.23610981e-02f, -8.94514322e-02f, 2.81369183e-02f, 1.83548797e-02f, 1.17403846e-02f,
  -2.06366871e-02f, 1.39514236e-02f, -4.62455042e-02f, 1.63316652e-02f, -3.45388427e-02f, -7.02650324e-02f, -8.46135616e-02f, 4.69705611e-02f, 6.80518970e-02f, -3.16724405e-02f,
  2.29000896e-02f, 2.75150631e-02f, -1.11275651e-01f, 1.35283740e-02f, -2.36329213e-02f, -1.23213958e-02f, 8.44984278e-02f, -4.29034829e-02f, 3.90954278e-02f, -2.73369290e-02f,
  -1.26978308e-02f, 6.70724586e-02f, -2.41861418e-02f, 1.05074368e-01f, -3.86827365e-02f, -4.48266655e-04f, -4.60772403e-02f, -6.76226476e-03f, -2.31630560e-02f, 3.05733457e-02f,
  -3.17252055e-02f, -7.82460719e-03f, -7.15036988e-02f, 9.58932936e-02f, -4.73146923e-02f, -3.73152122e-02f, -1.40384063e-02f, 5.77889830e-02f, 2.75584925e-02f, -3.45452726e-02f,
  5.51354438e-02f, -1.22805126e-01f, 4.49793227e-02f, -1.89604219e-02f, -1.01370532e-02f, -8.24596882e-02f, 8.51314981e-03f, 9.00541246e-02f, 4.78457585e-02f, -3.88066028e-03f,
  -1.90141108e-02f, 8.84816051e-02f, -3.35133895e-02f, 3.76118231e-03f, 7.19409436e-02f, 3.93370688e-02f, 2.74527278e-02f, -5.69174951e-03f, 5.16115800e-02f, 1.66017341e-03f,
  1.94026809e-02f, 3.70300771e-03f, -3.85468267e-03f, 1.01710834e-01f, -2.08251085e-02f, -5.47225773e-03f, -8.92993063e-02f, 2.62343399e-02f, 2.75311265e-02f, 3.02437562e-02f,
  6.35229424e-02f, -1.21896609e-03f, 4.12338860e-02f, 7.07778409e-02f, -6.03661407e-03f, 6.04112595e-02f, -5.71635887e-02f, 9.87537429e-02f, -8.63710232e-03f, 6.50615767e-02f,
  1.58766434e-01f, -2.50839382e-01f, -1.18549198e-01f, 1.24158122e-01f, 7.13515356e-02f, 2.62916714e-01f, 2.76718736e-01f, -2.75380462e-02f, 2.03694299e-01f, -1.46816969e-01f,
  7.84910545e-02f, -1.29805222e-01f, 1.14967063e-01f, 1.65278420e-01f, 3.02643538e-01f, 2.33353749e-01f, 1.75196767e-01f, 4.18267846e-02f, 4.86292876e-02f, -6.04873598e-02f,
  1.01445444e-01f, 1.46085978e-01f, 1.36202604e-01f, -1.84860572e-01f, -1.13087468e-01f, -2.04062939e-01f, -6.81790560e-02f, -1.61724210e-01f, -1.01235531e-01f, 1.18454229e-02f,
  1.33610517e-01f, 5.67426272e-02f, -3.19973901e-02f, -3.03592198e-02f, -4.92055900e-02f, -7.84624070e-02f, -1.58698540e-02f, -4.51100320e-02f, 1.85975246e-02f, 1.54429395e-02f,
  -6.42834529e-02f, 8.44979286e-03f, 1.86907724e-02f, 4.55896836e-03f, -3.55587490e-02f, 5.99730909e-02f, -4.76859510e-02f, -1.33017553e-02f, 1.67852174e-02f, 1.09791039e-02f,
  -8.17739125e-03f, 4.63528670e-02f, -6.44859523e-02f, 5.06725274e-02f, -5.57977669e-02f, 7.30586722e-02f, 4.61445898e-02f, -7.30865747e-02f, -4.10913257e-03f, 2.60192920e-02f,
  -7.32192397e-03f, -5.20890914e-02f, 5.09342924e-02f, 2.38690116e-02f, 4.03653160e-02f, 4.92589129e-03f, 4.85482886e-02f, -3.08447494e-03f, -6.12482168e-02f, 5.18677793e-02f,
  2.99951863e-02f, -2.81288307e-02f, 5.86875044e-02f, 2.37648785e-02f, 6.94250241e-02f, 2.23736279e-02f, -9.70991254e-02f, 5.45864552e-02f, 1.72734633e-02f, 6.92238063e-02f,
  1.17620096e-01f, 3.10070030e-02f, -5.78507222e-02f, -2.32321899e-02f, 2.46869978e-02f, -4.03657667e-02f, 2.76810527e-02f, -5.30426726e-02f, -3.11599486e-03f, -4.41861376e-02f,
  -5.03190793e-02f, -2.17815191e-01f, -6.22528233e-02f, 7.81799108e-02f, 6.20007375e-03f, 4.39299643e-02f, -3.40770073e-02f, 5.48765585e-02f, -1.14127528e-02f, 5.29790968e-02f,
  1.07134995e-03f, -8.61114077e-03f, -5.08910343e-02f, -1.67375375e-02f, -1.43988132e-02f, -2.61459127e-02f, 2.94487160e-02f, -7.33276829e-02f, -1.16480261e-01f, 1.46533176e-02f,
  -7.76835456e-02f, -2.22325418e-02f, -2.35174131e-02f, 4.33340482e-03f, -4.70030829e-02f, -3.93641032e-02f, -7.72008523e-02f, -4.24323194e-02f, -7.65388533e-02f, 1.48902112e-03f,
  2.65170276e-01f, -1.28563777e-01f, 1.13692526e-02f, 1.48401827e-01f, -1.93451904e-02f, 3.73864621e-02f, -7.08399760e-03f, -3.81014235e-02f, 2.85504252e-01f, -1.78990871e-01f,
  -1.54825851e-01f, 1.64126992e-01f, -8.76992494e-02f, -3.88362221e-02f, 1.42473757e-01f, 2.41229877e-01f, -6.25888407e-02f, 9.53586400e-03f, 8.77771676e-02f, -1.59750655e-01f,
  -1.23358059e-05f, -1.74166396e-01f, 6.27175495e-02f, -1.62344620e-01f, 5.80055406e-03f, 9.92096774e-03f, -4.88640741e-02f, -2.15742160e-02f, -1.63274094e-01f, 4.23882119e-02f,
  -7.98014402e-02f, 6.16446622e-02f, 3.84658948e-02f, 4.72260080e-02f, -3.10743954e-02f, -1.04916066e-01f, -7.16141462e-02f, 7.01282918e-02f, 3.64197269e-02f, -8.78432300e-03f,
  8.36877525e-03f, 1.32262353e-02f, 5.12010343e-02f, 1.39969895e-02f, 1.70170665e-02f, -6.37942478e-02f, 2.04292312e-02f, 1.68342181e-02f, 8.89058504e-03f, 2.22092066e-02f,
  4.58059832e-02f, -4.20353189e-02f, 2.02595461e-02f, 8.28992501e-02f, 5.81220686e-02f, 4.39972430e-02f, 5.84176108e-02f, -6.61252961e-02f, 1.06336391e-02f, 9.98647232e-03f,
  -3.20019871e-02f, 2.70170104e-02f, 3.14852446e-02f, -1.10343108e-02f, -5.54561894e-03f, -1.82504281e-02f, -6.35541277e-03f, 1.20111806e-02f, 6.80402666e-02f, -2.84969378e-02f,
  -2.37080641e-02f, 1.82441659e-02f, -3.02449465e-02f, -4.28560823e-02f, 1.67183690e-02f, 5.30837998e-02f, -3.05297952e-02f, -4.46398519e-02f, 7.13684410e-02f, -4.87565659e-02f,
  1.43883694e-02f, -2.39768755e-02f, 5.78802675e-02f, -6.11812659e-02f, -1.48498826e-02f, 4.73984554e-02f, -9.64014605e-03f, 3.94840799e-02f, 5.76117896e-02f, -1.80216171e-02f,
  5.04865944e-02f, -1.20865621e-01f, -1.26587171e-02f, -4.05103564e-02f, 2.61412170e-02f, -3.13596167e-02f, -2.98593454e-02f, 1.91052239e-02f, -5.79032674e-03f, 2.38155518e-02f,
  -1.58542804e-02f, -3.67634408e-02f, 2.73807216e-02f, 2.41160672e-02f, -2.22121775e-02f, -2.88233086e-02f, 1.16064465e-02f, 6.62718341e-02f, -4.76647839e-02f, -1.66398928e-01f,
  -1.09927449e-02f, 8.10459629e-02f, 2.38177385e-02f, 4.87166569e-02f, -3.01385392e-02f, -1.29232286e-02f, 1.07246730e-02f, 6.55808672e-02f, -8.27035457e-02f, 5.26490770e-02f,
  -1.53069049e-01f, -4.64179516e-01f, 2.54560113e-01f, 1.42815173e-01f, 6.63494617e-02f, -1.00074142e-01f, 6.15592934e-02f, -2.40482762e-02f, -7.25106522e-02f, -2.79032975e-01f,
  5.37631884e-02f, -1.95329830e-01f, -9.63897929e-02f, 2.56770905e-02f, 3.32796127e-01f, -3.78565751e-02f, 4.63753156e-02f, -2.75866520e-02f, 5.33782085e-03f, -7.42261261e-02f,
  1.63574994e-01f, -1.04381246e-02f, 1.66204140e-01f, 5.94811626e-02f, 5.65572493e-02f, 1.41433002e-02f, -9.65493098e-02f, 4.40805368e-02f, -3.17787752e-02f, 7.45459273e-03f,
  -8.72267783e-02f, 4.74268682e-02f, -2.64049061e-02f, 2.09826306e-02f, -6.82747811e-02f, -4.72254353e-03f, -8.86006933e-03f, 1.04692690e-01f, 5.89150339e-02f, -3.01037692e-02f,
  -1.38164490e-01f, 9.63559188e-03f, 7.91830271e-02f, -2.60995012e-02f, -7.45844170e-02f, -3.92999910e-02f, -1.87317785e-02f, 2.98697110e-02f, -2.64946818e-02f, 4.89615612e-02f,
  4.18354087e-02f, -3.66599448e-02f, 4.81699780e-02f, 2.74520554e-02f, 7.71369338e-02f, -4.32876684e-03f, 4.56312578e-03f, 7.31670531e-04f, -9.42885950e-02f, -6.13754243e-03f,
  1.13570422e-01f, -6.71002045e-02f, 6.97677163e-03f, -2.98626348e-02f, 2.12368295e-02f, 2.09818557e-02f, -2.65843552e-02f, 1.75383817e-02f, -3.11216228e-02f, -1.03931474e-02f,
  -2.90366113e-02f, 5.45455329e-02f, -3.44383232e-02f, -3.38295326e-02f, -2.62812618e-02f, 2.44653132e-02f, -3.53730656e-02f, -4.77711670e-03f, -9.45071410e-03f, 4.79214303e-02f,
  2.83336211e-02f, -4.63865511e-02f, -5.35524525e-02f, -1.25095006e-02f, 1.82073675e-02f, 3.96400467e-02f, 3.28205563e-02f, 5.51908314e-02f, 5.75443543e-02f, 2.03519799e-02f,
  -3.09659928e-01f, -2.84902543e-01f, 2.78946925e-02f, -9.86177996e-02f, -4.53305095e-02f, -4.31317836e-02f, 2.68734153e-02f, -2.25959290e-02f, -3.30716483e-02f, -1.19540533e-02f,
  -1.81878544e-02f, 9.14783403e-03f, -3.09576802e-02f, -5.40753035e-03f, -7.73395412e-03f, 1.07067367e-02f, -1.72939673e-02f, -2.93191131e-02f, -3.92474011e-02f, -2.25237701e-02f,
  -1.37317658e-03f, -3.65134366e-02f, 1.95425600e-02f, 3.99065763e-02f, 1.75809506e-02f, -7.20958561e-02f, -5.27691320e-02f, 9.88543630e-02f, -1.01332786e-02f, -1.09269684e-02f,
  2.11833537e-01f, -4.30675089e-01f, -3.34832370e-01f, -1.41954884e-01f, 7.65580982e-02f, -2.29552612e-01f, -3.16708744e-01f, -1.55955002e-01f, 6.56022877e-02f, -2.12880164e-01f,
  -4.15194705e-02f, -1.58291698e-01f, -1.69364557e-01f, -1.99997008e-01f, -5.62727824e-03f, -1.13349959e-01f, -7.73187727e-02f, -1.13458067e-01f, 3.01168729e-02f, -1.10984489e-01f,
  4.06600423e-02f, -7.10493252e-02f, -1.83945984e-01f, -2.73033511e-02f, -3.20854224e-02f, 2.44845040e-02f, 6.95402995e-02f, -2.34592352e-02f, -1.07094988e-01f, 8.17281380e-03f,
  -2.96115689e-02f, 3.26596573e-02f, -3.09726801e-02f, -6.11394197e-02f, -5.91693595e-02f, 5.03512546e-02f, -3.44005749e-02f, -3.03164758e-02f, 8.27570036e-02f, 1.76008455e-02f,
  1.41195965e-03f, 2.75572240e-02f, -6.50242269e-02f, 2.14610249e-02f, 4.76651043e-02f, 4.98191779e-03f, 7.53806299e-03f, -3.99998873e-02f, 7.57352402e-03f, 3.61015508e-03f,
  -2.02340521e-02f, 3.39111984e-02f, 5.82365617e-02f, -1.96053181e-03f, -1.80165600e-02f, 1.40731810e-02f, 4.09074016e-02f, -2.96910871e-02f, 4.90981005e-02f, 5.10045514e-02f,
  -3.11254449e-02f, 4.69302796e-02f, -5.51746786e-02f, 3.85064669e-02f, -4.09327075e-02f, 7.83340260e-03f, -1.23463161e-02f, -8.85478407e-03f, 1.89127401e-02f, 3.81278666e-03f,
  4.94981743e-03f, -3.09757404e-02f, 8.07333831e-03f, -3.15845832e-02f, -9.24774352e-03f, 4.17974852e-02f, 1.10406494e-02f, -5.73449060e-02f, 1.29815741e-02f, 4.25975770e-03f,
  2.66821049e-02f, 5.10856397e-02f, -4.79110237e-03f, 9.61670280e-03f, -2.38899738e-04f, 1.08895246e-02f, -4.32152599e-02f, 1.51585741e-02f, 2.86705587e-02f, -2.47928742e-02f,
  -1.99198455e-01f, -2.17570916e-01f, 1.66796073e-02f, 6.40599281e-02f, -2.97176838e-02f, -4.75593209e-02f, 2.90566124e-02f, -7.74345687e-03f, -9.69517678e-02f, -3.40338871e-02f,
  -4.83716056e-02f, -3.33275944e-02f, 3.49998251e-02f, 5.46730608e-02f, 3.00724711e-03f, -1.45383244e-02f, -7.16272071e-02f, 9.17537231e-03f, -4.26723957e-02f, -5.79036213e-02f,
  1.18289059e-02f, -3.48846801e-02f, 7.85354152e-02f, -5.22612557e-02f, 7.06389919e-02f, 1.88820343e-02f, -3.71356010e-02f, 5.49319535e-02f, -9.03908685e-02f, 8.63824226e-03f,
  -2.39683956e-01f, 1.72147498e-01f, 1.28350779e-01f, -2.38261417e-01f, 1.58526510e-01f, 1.22433035e-02f, -5.57360426e-02f, 1.93889588e-01f, -1.72989547e-01f, 6.09294623e-02f,
  -2.38327011e-01f, -2.21896529e-01f, -6.62663132e-02f, -1.00278750e-01f, -4.11025017e-01f, -2.09501714e-01f, -2.06376567e-01f, -1.23066470e-01f, -6.18890077e-02f, -1.42019719e-01f,
  -6.20860793e-02f, -1.25166811e-02f, 2.65967846e-02f, 3.06899458e-01f, 2.27790982e-01f, 2.36092091e-01f, -2.60603223e-02f, 1.06269628e-01f, 6.56035021e-02f, 2.25374587e-02f,
  -3.17883423e-05f, -7.09101409e-02f, 2.58536171e-02f, 6.63345754e-02f, 5.80382869e-02f, -2.12478098e-02f, 1.03306465e-01f, 4.20606136e-02f, -4.16056067e-02f, 9.04751010e-03f,
  -7.93126523e-02f, -6.85553104e-02f, 1.62064247e-02f, 6.33829683e-02f, 7.48485774e-02f, -1.96165871e-02f, -4.15175520e-02f, -4.49527259e-04f, 6.74501359e-02f, -3.31420377e-02f,
  3.08947954e-02f, -6.28775656e-02f, -6.64243102e-02f, 5.55937141e-02f, -3.64824645e-02f, -6.74119517e-02f, 4.07855138e-02f, 6.24687737e-03f, 3.88618112e-02f, 4.63761315e-02f,
  3.13062686e-03f, 2.39495505e-02f, -1.63146351e-02f, -2.54989751e-02f, -2.37067211e-02f, -4.12239740e-03f, 1.56072201e-02f, 3.36878859e-02f, -4.44379672e-02f, 5.41387349e-02f,
  -9.22162533e-02f, 4.99909511e-03f, 9.57204215e-03f, 1.47536946e-02f, 8.21328163e-03f, 5.24818711e-02f, -6.18297560e-03f, 1.29282260e-02f, 2.47066300e-02f, 4.71587852e-02f,
  -3.51736657e-02f, -1.20190365e-04f, -4.14571762e-02f, 6.09417371e-02f, -1.12799726e-01f, -2.92431600e-02f, -7.54389167e-02f, -1.76818743e-02f, -2.34261956e-02f, 4.61169146e-02f,
  3.68466377e-02f, -2.99312156e-02f, -3.17697264e-02f, 3.69868912e-02f, -2.86940057e-02f, -5.43740541e-02f, -9.36938748e-02f, 2.21480858e-02f, 7.76337227e-03f, 3.91343050e-02f,
  1.01307720e-01f, -2.98845675e-02f, -3.05985827e-02f, -9.29781795e-02f, 6.05962574e-02f, -5.03572375e-02f, -7.69366920e-02f, 2.25895904e-02f, 2.84047201e-02f, 4.09644619e-02f,
  3.54684182e-02f, -5.03792763e-02f, 3.99796612e-04f, 1.39688596e-01f, 1.75273884e-02f, 4.58379537e-02f, 6.27585105e-04f, 1.71861686e-02f, -7.44134486e-02f, -6.52759150e-02f,
  3.43408793e-01f, -1.51277229e-01f, 7.80399218e-02f, -9.10647810e-02f, 3.48034203e-02f, -3.25604379e-01f, -2.13589370e-01f, -5.47843985e-02f, -5.54902665e-02f, -4.74560149e-02f,
  -2.53050271e-02f, 6.83414042e-02f, 7.35505000e-02f, -8.08064044e-02f, -6.09131902e-02f, -3.82307991e-02f, -1.54966816e-01f, 3.87675129e-02f, -8.16571191e-02f, 1.48529664e-01f,
  -5.02268746e-02f, -1.87684640e-01f, 6.85828403e-02f, -8.25617090e-02f, 1.87592745e-01f, 1.01572208e-01f, 1.59343198e-01f, 5.10268807e-02f, 2.20668539e-02f, 3.61794978e-02f,
  5.77469729e-03f, 2.65940011e-01f, 1.29806980e-01f, 1.31851807e-01f, 2.70017311e-02f, 7.09517598e-02f, 3.29552628e-02f, -1.58659257e-02f, 3.31452228e-02f, 1.09699396e-02f,
  -3.02081481e-02f, 4.09064218e-02f, -9.14385766e-02f, -1.89406630e-02f, -4.84010059e-04f, 3.68515216e-02f, -5.28333755e-03f, 7.01184210e-04f, 7.25889653e-02f, -7.02560768e-02f,
  -2.00382024e-02f, -2.24202033e-02f, -1.98112354e-02f, -1.74757186e-02f, -5.40964790e-02f, 2.27136258e-02f, -8.17666873e-02f, 1.61095359e-03f, 4.59824689e-02f, -3.33737954e-02f,
  7.28561357e-02f, -4.94064391e-02f, 1.80776957e-02f, 3.40618826e-02f, -3.39237787e-02f, 3.04354951e-02f, 4.54800762e-02f, -7.09754527e-02f, 1.91809256e-02f, -5.24485409e-02f,
  -5.72369508e-02f, 7.96212256e-02f, 3.08655333e-02f, 1.33975279e-02f, 3.67910489e-02f, 4.79161367e-02f, 2.54829247e-02f, -1.67288519e-02f, 3.29227261e-02f, -6.46793917e-02f,
  -2.56507751e-02f, -3.70614305e-02f, -1.74739826e-02f, 1.66704934e-02f, -6.48449082e-03f, -3.22952196e-02f, 4.18784888e-03f, 1.50903510e-02f, 8.07596669e-02f, 7.03477859e-02f,
  1.20515518e-01f, 1.22969002e-01f, -7.54324198e-02f, -2.76334677e-02f, -4.02398258e-02f, -4.34432586e-04f, -1.35334861e-02f, -8.93960427e-03f, -7.01348530e-04f, 7.04678670e-02f,
  4.96146455e-02f, -1.45796873e-02f, 3.81011181e-02f, -1.01336606e-01f, -3.14163566e-02f, -5.75742265e-03f, 1.69731770e-02f, -2.34749857e-02f, 8.84557702e-03f, 2.37198658e-02f,
  4.62745242e-02f, 5.48368655e-02f, -4.39396836e-02f, 1.98291033e-03f, -1.55199328e-02f, -6.22563474e-02f, 1.28533412e-02f, -5.74240908e-02f, -5.11799604e-02f, -1.22231785e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.88511112e-02f, -2.46501803e-01f, -1.58383831e-01f, -8.43558758e-02f, 6.69286922e-02f, -1.59352943e-01f, -2.38317519e-01f, -1.01522848e-01f, 4.42934781e-02f, 6.00074790e-02f,
  6.02709886e-04f, 1.01541623e-01f, -1.99325401e-02f, -3.90057713e-01f, -1.08722538e-01f, 1.49230403e-03f, -2.40222603e-01f, -5.42394519e-02f, -6.28758371e-02f, -7.87718147e-02f,
  -5.73730245e-02f, -2.29791164e-01f, -1.93355426e-01f, -9.73144323e-02f, -2.23315090e-01f, 4.94035706e-02f, 1.03329889e-01f, 4.68565300e-02f, -2.23672390e-02f, -6.80754110e-02f,
  1.73300523e-02f, -5.73841408e-02f, 5.70102520e-02f, -9.03726220e-02f, 4.60995771e-02f, 8.30006227e-03f, -1.10213041e-01f, 7.79740792e-03f, 1.70982850e-03f, 3.79009619e-02f,
  6.03422523e-02f, 9.12067518e-02f, -8.28808397e-02f, -4.83879168e-03f, 1.38355438e-02f, -6.24848045e-02f, -2.14639306e-02f, 3.64178009e-02f, 7.05517712e-04f, -3.32028680e-02f,
  -3.72140370e-02f, -1.64222263e-03f, 7.73519352e-02f, 2.84903217e-02f, -6.40779808e-02f, 1.63106620e-02f, -5.18079996e-02f, 1.37359858e-01f, 7.59015307e-02f, 1.34015203e-01f,
  -3.07999067e-02f, -8.51958932e-04f, 9.56721138e-03f, -6.47815317e-02f, 3.75068374e-02f, 7.02618808e-02f, -3.53097403e-03f, 2.60059889e-02f, 3.89243774e-02f, -3.98378670e-02f,
  -1.10412773e-03f, -9.99562442e-02f, -3.42362933e-02f, -3.85099761e-02f, 1.61432847e-02f, 7.01959878e-02f, -1.67175885e-02f, 9.06747431e-02f, -6.93326518e-02f, -2.78367964e-03f,
  -7.64766857e-02f, 1.43646318e-02f, 1.20520823e-01f, -7.79978558e-02f, -5.07203303e-02f, -2.29449254e-02f, -1.82420649e-02f, 1.99284423e-02f, 5.13486527e-02f, 3.10876463e-02f,
  8.71182904e-02f, 1.00311376e-01f, -5.08596972e-02f, -9.65358093e-02f, -4.49346192e-02f, -2.91892402e-02f, -4.64651436e-02f, -1.39899239e-01f, 4.53539640e-02f, -1.46708786e-01f,
  5.10709845e-02f, 1.01021543e-01f, 5.38585596e-02f, 5.78428842e-02f, -1.28614856e-02f, -5.94233237e-02f, -3.66199985e-02f, -8.10816046e-03f, -7.14535490e-02f, -1.59755312e-02f,
  6.65930752e-03f, 9.96858478e-02f, 5.06713390e-02f, -2.40793303e-02f, 2.56774854e-02f, 1.76859330e-02f, 5.96403405e-02f, 3.20173614e-03f, 2.80757751e-02f, 2.79621221e-02f,
  -7.68509433e-02f, 9.67697613e-03f, 2.53331840e-01f, 2.63081968e-01f, -6.60866797e-02f, -2.13727489e-01f, -3.31544161e-01f, 7.93874785e-02f, -9.07192230e-02f, -7.11752698e-02f,
  1.06943054e-02f, -5.58353476e-02f, -1.60462573e-01f, 2.37409517e-01f, 3.09294999e-01f, -3.28419693e-02f, 1.28552854e-01f, -1.05402015e-01f, 2.82701962e-02f, 1.72243237e-01f,
  2.16762930e-01f, 1.05950296e-01f, 2.57313430e-01f, 1.32217884e-01f, 8.79789591e-02f, 2.44111583e-01f, 2.03212515e-01f, -3.25021632e-02f, 1.62100449e-01f, -8.79517272e-02f,
  1.20032504e-02f, 1.27729848e-01f, -3.72769758e-02f, -6.64610043e-02f, 1.55283173e-03f, -2.98752449e-02f, -7.70566836e-02f, -4.93621267e-02f, 1.59679890e-01f, 1.06701642e-01f,
  3.86268757e-02f, -1.26714064e-02f, -1.20234722e-02f, 3.25587690e-02f, -4.66978177e-02f, 4.90143634e-02f, -3.63335535e-02f, -8.10739249e-02f, 6.80591017e-02f, 6.87095970e-02f,
  9.51151028e-02f, -1.77002754e-02f, 1.01130493e-01f, 2.43109260e-02f, 9.90429446e-02f, -2.95950789e-02f, 2.06378512e-02f, 6.70384318e-02f, 5.59167899e-02f, 8.91773850e-02f,
  1.03813604e-01f, -1.23935029e-01f, -1.19597465e-01f, -7.96280280e-02f, -4.67680581e-02f, -5.72324321e-02f, -6.89706877e-02f, -1.44940419e-02f, -8.75764266e-02f, -1.18350761e-03f,
  -7.29028434e-02f, 8.97587165e-02f, 1.04484521e-02f, -7.05445111e-02f, -1.02605950e-03f, -7.54451752e-02f, -1.48426592e-02f, 8.80009383e-02f, 1.25738218e-01f, 7.18891025e-02f,
  -5.21401316e-02f, 6.16062097e-02f, 3.92443128e-02f, -1.12249598e-01f, -6.47466928e-02f, -2.60911090e-03f, -2.63900720e-02f, -1.17990104e-02f, 1.97417624e-02f, -2.93471850e-02f,
  1.21626168e-01f, 1.07340820e-01f, -1.94128472e-02f, -1.26184836e-01f, 4.79429169e-03f, -5.77587560e-02f, -1.81614916e-04f, -1.90942902e-02f, 4.06940803e-02f, -6.87007010e-02f,
  1.04801171e-02f, -1.55527247e-02f, 1.28922006e-02f, 1.66873969e-02f, 6.41435683e-02f, -3.29262279e-02f, 9.61223170e-02f, -2.40128543e-02f, 1.02015890e-01f, 1.01236850e-01f,
  1.14868999e-01f, -4.50570509e-02f, 7.99627379e-02f, -8.47837329e-02f, 7.29510486e-02f, -2.08950900e-02f, 5.93678914e-02f, 1.08675743e-02f, 9.71256420e-02f, 1.34232506e-01f,
  9.60924942e-03f, -5.21054387e-01f, -2.64805742e-03f, 1.62832171e-01f, 8.37822035e-02f, -1.58142328e-01f, -1.91360682e-01f, -5.16578592e-02f, -1.25449434e-01f, -3.66518557e-01f,
  -3.21376584e-02f, -5.27143292e-02f, -3.32421422e-01f, 1.50710210e-01f, 3.04178506e-01f, -2.07029328e-01f, 9.74175632e-02f, -2.07566318e-05f, 5.08806407e-02f, 1.14052616e-01f,
  1.04496740e-01f, 2.00002119e-01f, 1.56175137e-01f, 1.38417169e-01f, 2.84031010e-03f, 1.35670364e-01f, 1.25377178e-01f, -3.95511575e-02f, 2.42565542e-01f, 1.61034122e-01f,
  -6.92011714e-02f, -8.80767778e-02f, 1.07251152e-01f, 1.04743205e-01f, -1.53673382e-03f, -5.65533191e-02f, -3.03157698e-02f, 8.64859447e-02f, 6.42442554e-02f, -1.31856296e-02f,
  -6.99365586e-02f, 1.32102549e-01f, 1.10380299e-01f, 5.26938513e-02f, 3.65356362e-04f, 7.11519942e-02f, -3.27145830e-02f, -1.15697989e-02f, -1.66369639e-02f, -1.04718849e-01f,
  -6.90539554e-02f, -6.23444244e-02f, -9.35818162e-03f, -3.18384096e-02f, -3.96798998e-02f, -2.71417224e-03f, -6.45426810e-02f, -7.67519698e-02f, -5.81482947e-02f, 3.02604064e-02f,
  -1.06589518e-01f, 2.73931045e-02f, -1.34337926e-02f, 4.81175669e-02f, -1.90539770e-02f, 9.70508829e-02f, -8.74172598e-02f, 3.00203934e-02f, 4.13714051e-02f, -6.53181449e-02f,
  5.42215444e-02f, -8.96822885e-02f, 3.73714603e-02f, -9.32726730e-03f, -3.93618830e-02f, -2.40286198e-02f, 1.92551184e-02f, 6.53783828e-02f, -3.35384160e-03f, -2.54580677e-02f,
  -1.22677442e-02f, 2.49289330e-02f, -1.67281798e-03f, -3.36605171e-03f, 7.68707693e-02f, 2.42198780e-02f, 3.97951826e-02f, 2.76689674e-03f, 3.50400768e-02f, 5.30257262e-02f,
  -1.97703987e-01f, -1.82718620e-01f, -1.79370493e-02f, 1.58971921e-02f, 2.26538107e-02f, -6.40453771e-02f, -1.05942283e-02f, -4.36740518e-02f, 1.78353228e-02f, -6.78543374e-02f,
  7.85342231e-02f, 5.28872944e-02f, -7.96987936e-02f, 9.53121856e-02f, 6.44857511e-02f, -1.17228448e-01f, -6.01881999e-04f, 3.76455970e-02f, 3.40076685e-02f, -5.89305535e-02f,
  -8.27519819e-02f, -3.65281105e-02f, 1.51103335e-02f, 4.24568802e-02f, -4.92180027e-02f, -4.26150933e-02f, -2.82619381e-03f, -2.89402343e-03f, 3.04026101e-02f, -1.01752235e-02f,
  3.82734090e-01f, -4.41685989e-02f, -8.99568759e-03f, 1.63064390e-01f, 2.01398715e-01f, 1.70799211e-01f, 1.78561419e-01f, 2.91599065e-01f, 3.76674712e-01f, -3.33269536e-02f,
  3.23889740e-02f, 5.25477335e-05f, -1.94988802e-01f, 2.65221477e-01f, 6.40844554e-02f, 4.96061146e-03f, 1.18285261e-01f, 1.00456461e-01f, 1.63924873e-01f, 1.09633863e-01f,
  1.17110237e-01f, 5.90547398e-02f, -8.18231404e-02f, -1.22278102e-01f, 6.16040118e-02f, -1.39322400e-01f, -2.09226251e-01f, -1.78175688e-01f, 2.92363707e-02f, 4.81907018e-02f,
  1.27778277e-01f, 9.15880725e-02f, -1.45992218e-02f, -1.72161777e-02f, -6.74475431e-02f, -1.12653278e-01f, -1.17413670e-01f, -6.87100366e-02f, -7.14984462e-02f, -4.07483149e-03f,
  4.70186286e-02f, -6.35592788e-02f, -8.26022401e-03f, 1.17813703e-02f, 1.73388217e-02f, 2.83660609e-02f, 5.24218827e-02f, -1.02459518e-02f, 9.54100024e-03f, -2.83327661e-02f,
  8.34957659e-02f, 5.71349636e-02f, 1.23714691e-03f, -4.08912078e-02f, -7.52490237e-02f, -2.68131914e-03f, 5.80444522e-02f, 4.21567000e-02f, 5.27797863e-02f, 4.74850982e-02f,
  5.21475375e-02f, 3.34683321e-02f, -3.63954529e-02f, 2.35058442e-02f, -1.49457555e-04f, 7.65492395e-03f, 6.90863235e-03f, -4.63881493e-02f, 4.02173121e-03f, -5.19671012e-03f,
  1.37224887e-02f, -2.57013720e-02f, 6.44729733e-02f, 3.35281640e-02f, -2.72446219e-02f, 8.22698176e-02f, 2.66875583e-03f, 6.34511933e-02f, -6.37405515e-02f, -6.20257622e-03f,
  -1.13649555e-02f, -7.28215873e-02f, -1.39906779e-01f, 6.85074879e-03f, 1.48830214e-03f, -4.56021950e-02f, -3.69948037e-02f, 4.65985574e-02f, 7.02886656e-02f, -2.81733721e-02f,
  6.50752410e-02f, -9.33794305e-02f, -9.17832479e-02f, -1.07866982e-02f, -3.74006331e-02f, -8.57085809e-02f, -1.00593768e-01f, 5.17892428e-02f, 6.64884150e-02f, -6.69964999e-02f,
  -6.86695473e-03f, 3.00083011e-02f, -8.62128735e-02f, 5.78833409e-02f, -8.31384584e-03f, -6.76380619e-02f, 4.84095924e-02f, -6.83987513e-02f, 2.91267439e-04f, -2.60034483e-02f,
  3.55958641e-02f, 2.76136249e-02f, -3.01137622e-02f, 9.04781148e-02f, 2.66038738e-02f, -9.33040380e-02f, -9.86783579e-03f, -7.93100223e-02f, -9.25347954e-03f, 4.75224741e-02f,
  9.38225240e-02f, 1.21383920e-01f, 2.69579608e-02f, -5.33375852e-02f, -1.52008727e-01f, -3.04704130e-01f, -3.71195316e-01f, -1.87781364e-01f, 1.16733193e-01f, 1.99655872e-02f,
  -1.80990100e-01f, 3.89612645e-01f, -1.24982797e-01f, 1.91998836e-02f, -2.64296412e-01f, -2.02527627e-01f, -2.25272298e-01f, -5.55485561e-02f, 6.86962083e-02f, -1.18071236e-01f,
  -7.50136748e-02f, -1.83898523e-01f, -7.02024400e-02f, -1.47420034e-01f, -7.40381330e-02f, 1.26936153e-01f, -1.21357977e-01f, -2.34449416e-01f, -2.25522928e-02f, -9.91745014e-03f,
  -3.83598879e-02f, 6.73979446e-02f, 6.06454387e-02f, -2.61306502e-02f, -8.96781161e-02f, 3.88557538e-02f, -4.96661812e-02f, -6.94016442e-02f, 1.08044766e-01f, -3.68171073e-02f,
  9.93921906e-02f, -9.06868428e-02f, 3.56517434e-02f, 2.50561628e-02f, 8.83675814e-02f, 2.08153538e-02f, 7.35112801e-02f, 6.27223775e-02f, 8.85178000e-02f, 4.47977670e-02f,
  -1.07505452e-02f, 2.36010775e-02f, 4.31304947e-02f, 1.33596435e-01f, -1.28434217e-02f, 1.09913014e-02f, -4.45697904e-02f, -4.91056533e-04f, -1.19796749e-02f, 4.97781262e-02f,
  -3.51596810e-03f, 2.64954902e-02f, 4.19520512e-02f, -5.28954975e-02f, 5.29143820e-03f, 8.42974037e-02f, 1.23196130e-03f, 5.59188724e-02f, 2.76557878e-02f, -5.91407623e-03f,
  6.16287589e-02f, 7.47595653e-02f, 3.88726108e-02f, 1.86443850e-02f, -1.33985784e-02f, 8.40054825e-02f, 1.94058213e-02f, -5.98691665e-02f, 5.71878813e-02f, -7.72946235e-03f,
  -3.66686098e-02f, 1.03323339e-02f, 7.21432641e-03f, 5.71778528e-02f, -1.11637369e-01f, 2.74480209e-02f, 3.14163566e-02f, 3.94300893e-02f, -2.98739336e-02f, -2.22501112e-03f,
  5.37495362e-03f, 1.74228791e-02f, 2.58699933e-04f, 9.09518972e-02f, -6.74708858e-02f, 8.44819471e-03f, -1.68153226e-01f, 1.70136858e-02f, 3.77320051e-02f, -1.92999002e-03f,
  -2.09381841e-02f, -3.92851979e-02f, -2.41986718e-02f, -4.31374880e-03f, -4.89958189e-03f, -8.94630153e-04f, 1.22336745e-01f, 1.44180804e-01f, -6.72301874e-02f, 3.71890441e-02f,
  6.85451999e-02f, 1.27582308e-02f, 1.63527533e-01f, 9.52554047e-02f, 6.24291338e-02f, 8.28798935e-02f, 3.84002626e-02f, 4.54700813e-02f, -3.07730287e-02f, 1.43446043e-01f,
  1.25596449e-01f, -1.23513982e-01f, -2.71349922e-02f, -1.51109979e-01f, -2.56209612e-01f, -1.71961322e-01f, -6.23253733e-03f, -2.31035247e-01f, -1.45366833e-01f, -1.18458495e-01f,
  -1.55152068e-01f, 1.49449527e-01f, 2.72753090e-01f, -2.38087416e-01f, 3.22274297e-01f, 1.31384999e-01f, -2.95499712e-01f, 8.40862002e-03f, -8.21286142e-02f, -1.39005348e-01f,
  9.94063541e-03f, -9.28599983e-02f, -2.76442105e-03f, -1.99956536e-01f, -1.93945378e-01f, -1.55756652e-01f, 5.49475849e-02f, -4.13409732e-02f, -2.22003251e-01f, -8.40557963e-02f,
  -2.27094050e-02f, -2.50072591e-02f, 6.57376414e-03f, 5.60329296e-02f, 5.34871109e-02f, -4.16985014e-03f, -3.13543193e-02f, 5.18235676e-02f, -7.55688325e-02f, 8.81590769e-02f,
  7.04163909e-02f, 4.96391878e-02f, -9.43943188e-02f, -6.04771310e-03f, -4.03796323e-02f, -2.28086933e-02f, -5.98811954e-02f, -7.58168325e-02f, 8.63782912e-02f, 6.32781684e-02f,
  7.35694617e-02f, 2.61404403e-02f, -5.84930889e-02f, 1.28542874e-02f, -1.54768825e-02f, -1.00969575e-01f, 7.33987764e-02f, 1.04132943e-01f, 4.01446633e-02f, -7.57296085e-02f,
  -8.52434337e-03f, 7.99178258e-02f, 3.40951644e-02f, -2.72621540e-03f, -5.93318827e-02f, -9.84701812e-02f, 2.00498812e-02f, 2.85207853e-02f, -2.18261350e-02f, 4.97279465e-02f,
  -3.27255875e-02f, -5.27836978e-02f, 6.31342381e-02f, 4.13518436e-02f, 5.43129519e-02f, 7.94712827e-02f, 4.47031669e-02f, 5.22930585e-02f, -1.25691965e-01f, 9.26176086e-02f,
  -2.49397177e-02f, -1.03062391e-01f, -1.23019628e-01f, 5.39500825e-02f, 2.93372455e-03f, 9.63597968e-02f, -8.83861557e-02f, 3.37229036e-02f, -3.30961705e-03f, 1.19308926e-01f,
  -5.88400923e-02f, -1.32315263e-01f, -6.77910596e-02f, 7.75973275e-02f, 5.94099425e-02f, -5.14904410e-02f, 2.95561552e-02f, 1.06640514e-02f, -9.33304876e-02f, 4.26183492e-02f,
  5.08328294e-03f, -2.10993681e-02f, -3.75604257e-02f, 7.14789778e-02f, -1.67525858e-02f, -5.60406931e-02f, -2.15908941e-02f, 6.53329566e-02f, -1.17019508e-02f, -6.50228709e-02f,
  3.09128799e-02f, 4.55943160e-02f, 1.19041108e-01f, -2.29060780e-02f, 1.56445499e-03f, 7.75891170e-02f, 2.02314649e-03f, 4.51418832e-02f, 2.06948221e-02f, -7.35438243e-02f,
  -3.47488195e-01f, 1.17685013e-01f, -1.96690232e-01f, -3.54566783e-01f, -1.44192353e-01f, -3.00074786e-01f, -2.38860935e-01f, 2.83479150e-02f, -6.74421294e-03f, 7.26654306e-02f,
  -1.22328095e-01f, 8.84736364e-04f, 1.24651507e-01f, -1.07822843e-01f, -2.01005936e-01f, 2.11093768e-01f, -2.36006275e-01f, -5.30798547e-02f, 1.26769558e-01f, -8.01941305e-02f,
  -2.16356702e-02f, 1.13628786e-02f, -2.03887448e-01f, 1.52669042e-01f, -2.20075250e-01f, -3.94103490e-02f, -6.78109704e-03f, 4.18005371e-03f, -1.81627452e-01f, 2.41780188e-02f,
  -1.14401512e-01f, -2.25311015e-02f, -2.68079728e-01f, -1.12818547e-01f, -1.90529913e-01f, -2.17063874e-02f, -8.80023688e-02f, 6.19068742e-03f, -1.20775938e-01f, -1.17056996e-01f,
  8.80262814e-03f, 4.65634502e-02f, -3.19503807e-02f, -1.55526567e-02f, -7.44252801e-02f, -5.11557981e-02f, 9.14723799e-02f, -7.96689913e-02f, -6.07343577e-02f, 8.24509710e-02f,
  -1.16409725e-02f, -6.35714978e-02f, -8.28417093e-02f, -5.05164154e-02f, -5.02809994e-02f, -4.81884032e-02f, -8.66158530e-02f, 1.57320593e-03f, -4.29847501e-02f, -2.74387631e-03f,
  1.28415197e-01f, -6.79368675e-02f, 2.44021625e-03f, 7.41140125e-03f, -4.46629114e-02f, 2.70982236e-02f, 3.64447497e-02f, 2.79646926e-02f, -4.62759845e-02f, -3.34123485e-02f,
  -6.09542802e-02f, 5.43852337e-02f, 2.70481966e-02f, -1.33330878e-02f, 1.37036229e-02f, 1.68365706e-02f, -4.74825650e-02f, -6.02834076e-02f, -1.44200362e-02f, -4.28975113e-02f,
  2.03187913e-02f, 7.62613444e-03f, 8.62463117e-02f, 2.84179170e-02f, -2.67437939e-02f, 6.21223636e-02f, 2.38629826e-03f, -2.08289381e-02f, -4.89399806e-02f, -3.64040285e-02f,
  -3.00942510e-01f, -2.76954830e-01f, -6.43018112e-02f, -7.74235576e-02f, -9.27448794e-02f, -8.86969343e-02f, 1.10618016e-02f, -5.68387657e-02f, -1.47751704e-01f, 4.43375707e-02f,
  -8.51612985e-02f, -7.15246946e-02f, -9.21313651e-03f, -4.13572118e-02f, 6.03418164e-02f, -1.60777774e-02f, -5.86956553e-02f, -8.49124715e-02f, -1.51999027e-01f, -2.46788468e-02f,
  -1.45247644e-02f, 5.52726835e-02f, 8.97003338e-02f, 7.61820152e-02f, -1.90895461e-02f, -1.33373991e-01f, 1.45503106e-02f, -2.94733420e-02f, -8.30181241e-02f, 5.14912680e-02f,
  5.17689437e-02f, -6.37211427e-02f, -3.02888546e-02f, 7.24705979e-02f, -1.74745515e-01f, -2.65087247e-01f, -3.18255723e-01f, 9.50653702e-02f, -1.77159816e-01f, -5.04578836e-02f,
  4.09412906e-02f, -9.55649018e-02f, 8.15328509e-02f, -2.36256290e-02f, 6.33013248e-02f, 2.97545362e-03f, 8.51055607e-02f, -2.80669937e-03f, 3.99623476e-02f, 2.34087259e-01f,
  1.54588580e-01f, 1.73136219e-01f, 1.17715046e-01f, 1.05295181e-01f, 6.55732080e-02f, 1.28349259e-01f, 2.74147451e-01f, 2.34161527e-03f, 1.48399577e-01f, -8.01940039e-02f,
  1.95418075e-02f, 7.26467371e-02f, 3.67686078e-02f, -5.13776019e-02f, 3.43736610e-03f, 4.82336991e-02f, 4.98855487e-02f, -4.87450585e-02f, -8.07167143e-02f, 8.28803405e-02f,
  -6.56543970e-02f, 3.85569641e-03f, -5.99416159e-02f, -3.66964601e-02f, -1.04611516e-01f, -5.38616180e-02f, -1.00481793e-01f, -8.39578584e-02f, 1.74250323e-02f, 6.70830160e-02f,
  -7.72303641e-02f, 1.95580851e-02f, 6.73173144e-02f, 4.96201143e-02f, -4.16169837e-02f, -3.53997760e-02f, -3.61711681e-02f, 8.76613259e-02f, 2.66781375e-02f, 8.06241557e-02f,
  -4.06325646e-02f, 6.32161647e-02f, -4.47857790e-02f, -5.85576855e-02f, 8.29304848e-03f, -8.80500488e-03f, -1.13464920e-02f, 2.65163165e-02f, -3.09643783e-02f, 6.16011582e-02f,
  -4.16485593e-02f, -9.66576636e-02f, -2.18062685e-03f, -2.11959495e-03f, 4.47986126e-02f, -1.61833465e-02f, -9.84028354e-03f, -1.60411205e-02f, -4.08900604e-02f, -2.09060833e-02f,
  2.89631356e-02f, -2.45407503e-02f, -2.96230465e-02f, 3.37440781e-02f, 2.66305171e-02f, 2.25411598e-02f, 1.86101533e-02f, -6.84683863e-03f, 1.56182591e-02f, 5.82366018e-04f,
  1.28935456e-01f, 2.46818766e-01f, -3.39096747e-02f, -1.03679910e-01f, -3.42521854e-02f, -5.29778562e-02f, -1.41561795e-02f, -1.21385390e-02f, 9.76969525e-02f, -1.06610367e-02f,
  3.23291458e-02f, 1.50574287e-02f, 1.17531262e-01f, 6.50269911e-02f, 9.43700876e-03f, 3.35122682e-02f, 9.86204073e-02f, -1.22494306e-02f, -6.14235038e-03f, 1.01826437e-01f,
  1.07688367e-01f, -9.17140320e-02f, -4.71037067e-02f, -1.04497530e-01f, 1.97702423e-02f, 7.68681020e-02f, -3.78929079e-02f, 2.77073681e-03f, 4.02003862e-02f, 4.73065339e-02f,
  -3.68273705e-01f, -1.28620356e-01f, 1.33507654e-01f, 1.74217477e-01f, -7.99306035e-02f, -3.88946295e-01f, -2.65961051e-01f, 1.52859166e-01f, 4.34526354e-02f, -1.02891098e-03f,
  6.96312413e-02f, -7.58969337e-02f, -2.22425312e-02f, 1.30111933e-01f, 1.33000538e-01f, 1.95896532e-02f, -6.51059020e-03f, -1.81213003e-02f, 4.54297215e-02f, 1.40906811e-01f,
  2.18469389e-02f, 1.09140918e-01f, 1.85796812e-01f, 1.12839274e-01f, 2.30853427e-02f, 1.60123631e-01f, 2.94659674e-01f, 9.55952033e-02f, 1.38845310e-01f, 1.96381640e-02f,
  -1.40926316e-01f, 1.68323874e-01f, 6.72147945e-02f, 4.12261821e-02f, 1.48845119e-02f, -1.25305369e-01f, -8.10703787e-04f, -7.84393996e-02f, 1.34406006e-02f, -3.94454692e-03f,
  -2.36260016e-02f, -2.39888541e-02f, -3.59408706e-02f, -4.29274887e-02f, 5.17572127e-02f, 1.71561047e-01f, 2.48376168e-02f, -9.77922082e-02f, -1.21166542e-01f, -7.71232545e-02f,
  4.41520326e-02f, 4.32331599e-02f, -5.10056689e-02f, 4.17877026e-02f, 1.11406595e-01f, -2.16695033e-02f, -8.04211944e-02f, -5.35957552e-02f, -7.24255573e-03f, 1.02488928e-01f,
  -1.45111457e-01f, 4.58905213e-02f, -8.85514636e-03f, 6.02352619e-02f, -7.59637356e-02f, 1.11901581e-01f, 6.90843491e-03f, 4.47197482e-02f, 4.99266293e-03f, -2.80208257e-03f,
  -2.61200890e-02f, -4.24300246e-02f, 8.42283666e-03f, 4.12030481e-02f, 1.44045819e-02f, 1.32708969e-02f, -1.43810362e-01f, 9.04759765e-02f, -1.03835404e-01f, 1.03790887e-01f,
  1.43082350e-01f, 4.48367931e-02f, -9.22589079e-02f, -2.90340856e-02f, -6.02365546e-02f, 8.42199698e-02f, 3.14366519e-02f, -2.36969697e-03f, -6.75387457e-02f, 5.14803939e-02f,
  -9.62845907e-02f, 2.45772108e-01f, 3.11495904e-02f, -9.54219326e-03f, 3.03734709e-02f, 3.11765801e-02f, 5.40316291e-02f, -1.30123803e-02f, 9.24567655e-02f, 5.29851913e-02f,
  1.25192225e-01f, -7.34965727e-02f, -1.21084646e-04f, -5.30541353e-02f, 1.01577297e-01f, -8.83977022e-03f, 5.16098514e-02f, 2.33779531e-02f, 1.01699214e-02f, 8.05832893e-02f,
  4.62537333e-02f, -2.29279045e-02f, 6.25493973e-02f, -3.69391926e-02f, 3.51960324e-02f, -3.89124379e-02f, -2.35320814e-02f, -8.55860263e-02f, -1.28651662e-02f, 1.61448289e-02f,
  -3.10695648e-01f, 1.13864265e-01f, -4.26712297e-02f, -1.96932539e-01f, 9.95104611e-02f, -1.28838181e-01f, -1.95667014e-01f, 4.94682342e-02f, 8.22106749e-02f, 1.11530952e-01f,
  1.27280146e-01f, -1.42686158e-01f, 1.10791959e-01f, -2.20634848e-01f, -2.55427569e-01f, 2.94188736e-03f, -3.38018477e-01f, -9.12562832e-02f, -9.77483019e-02f, -1.62785441e-01f,
  -1.92039773e-01f, -1.59023657e-01f, -1.45955116e-01f, 1.12959146e-01f, 5.50302211e-03f, -2.87729353e-02f, -1.25648662e-01f, 1.30755290e-01f, -1.54503539e-01f, 1.36348739e-01f,
  7.67691061e-02f, 1.43252924e-01f, -7.85495527e-03f, 6.79861605e-02f, 3.02132918e-03f, -8.64490196e-02f, -2.04391982e-02f, 6.81038499e-02f, -4.25671339e-02f, 4.34612259e-02f,
  -2.53991112e-02f, 5.75387590e-02f, -4.35095876e-02f, -3.28869894e-02f, 6.68416321e-02f, 8.18591490e-02f, 2.91679287e-03f, 6.96444884e-02f, -2.96795573e-02f, 9.39934235e-03f,
  3.08982236e-03f, -4.39016595e-02f, -1.76899642e-01f, -6.42592683e-02f, -7.66105726e-02f, 4.56559695e-02f, -1.42228484e-01f, 1.35036521e-02f, -8.76323730e-02f, -9.19257030e-02f,
  -3.43881361e-02f, -1.24800101e-01f, 6.57584891e-02f, 5.93114793e-02f, 6.85926080e-02f, 4.82325442e-02f, -1.08075282e-02f, 5.92628978e-02f, -5.18008694e-02f, 3.87117267e-02f,
  8.19097683e-02f, -4.48787436e-02f, -1.53165460e-02f, -1.55095875e-01f, -6.62641153e-02f, 9.29129273e-02f, -6.64126649e-02f, 1.90622881e-02f, -5.84221557e-02f, 1.29219629e-02f,
  2.64356076e-03f, -5.29798903e-02f, 3.63460891e-02f, -4.37990539e-02f, 4.04372253e-02f, -4.25586738e-02f, -6.65557906e-02f, 6.39341846e-02f, 5.47371320e-02f, -1.37532353e-01f,
  7.02046752e-02f, -9.49005485e-02f, 2.81222761e-02f, 1.76888213e-01f, 5.61204664e-02f, -6.17552362e-02f, -9.09408182e-03f, -1.20240161e-02f, 5.27288914e-02f, -1.63338296e-02f,
  -5.79426736e-02f, -1.86566338e-02f, -7.86678120e-02f, 7.43951509e-03f, 3.05498000e-02f, -4.07804959e-02f, -4.67511453e-02f, -3.08530983e-02f, 6.60852939e-02f, 2.10848916e-02f,
  -3.78284901e-02f, 7.40322173e-02f, -2.48970911e-02f, -8.22092146e-02f, -1.79008245e-01f, -3.99762541e-02f, 6.29714578e-02f, -7.34856054e-02f, -4.84260321e-02f, -7.33467564e-02f,
  3.28483105e-01f, 1.53162867e-01f, -1.00321710e-01f, -7.42376666e-04f, 4.78259735e-02f, 3.41891438e-01f, 1.98373795e-01f, 8.85325000e-02f, 2.29058474e-01f, 1.72173947e-01f,
  1.32002711e-01f, 6.29680082e-02f, -8.38591605e-02f, 2.19792545e-01f, 1.29487783e-01f, 5.85237071e-02f, 2.50724763e-01f, 1.27027616e-01f, 4.47863434e-03f, 1.26601934e-01f,
  2.82566976e-02f, 3.24393779e-01f, -2.29012057e-01f, -3.75464708e-02f, 5.93597330e-02f, -1.43819287e-01f, -2.51401722e-01f, -1.31229594e-01f, -3.64450132e-03f, 7.97232762e-02f,
  6.42242953e-02f, 4.84000184e-02f, 2.13821810e-02f, 1.61696896e-02f, -7.31568113e-02f, -5.18381260e-02f, -2.51954235e-02f, -1.07221082e-02f, -1.31492717e-02f, -4.72378023e-02f,
  -2.05742531e-02f, 3.17894965e-02f, 1.52423725e-01f, 5.15500978e-02f, 2.97951177e-02f, -9.02486295e-02f, 9.64443258e-04f, -3.30296084e-02f, -1.26833925e-02f, 1.45391217e-02f,
  -1.06874324e-01f, -5.59785478e-02f, 2.58455891e-02f, 2.03036889e-02f, -3.07228938e-02f, 2.50147320e-02f, -1.33767389e-02f, 1.02715846e-02f, -3.27450014e-03f, 1.34337116e-02f,
  2.71816999e-02f, 5.47278635e-02f, 1.20868497e-02f, 5.51751889e-02f, 4.54488397e-02f, -1.30850807e-01f, 3.92418839e-02f, -1.09431869e-03f, -4.98007461e-02f, 5.01095280e-02f,
  4.50071581e-02f, 5.89532442e-02f, -8.43563955e-03f, 3.74381430e-02f, 3.62052433e-02f, 3.43147386e-03f, -9.47044194e-02f, 8.03965256e-02f, 6.36936575e-02f, 5.36983795e-02f,
  -1.94376130e-02f, -1.94998384e-02f, 4.96167131e-02f, -7.77900219e-02f, -5.26714250e-02f, 3.19887176e-02f, 4.19973545e-02f, 8.04869160e-02f, -1.88305471e-02f, 1.17961772e-01f,
  1.13512576e-01f, 1.23151414e-01f, 4.79260236e-02f, 6.61513908e-03f, -1.99790169e-02f, 7.36699700e-02f, 7.59151801e-02f, 7.91174620e-02f, 7.67396390e-02f, 5.48423938e-02f,
  5.02538607e-02f, -4.07119505e-02f, 1.01246335e-01f, 1.40328621e-02f, 5.45509756e-02f, 1.20878994e-01f, -2.90736575e-02f, -2.90578208e-03f, 1.92691814e-02f, -3.86713669e-02f,
  -2.13907547e-02f, 1.02003261e-01f, 6.84951395e-02f, 1.57783944e-02f, 6.35522306e-02f, -1.00288637e-01f, -2.16640215e-02f, 4.78628688e-02f, 9.95009318e-02f, 3.56784388e-02f,
  -1.63130268e-01f, -2.44675696e-01f, 1.28303185e-01f, -1.46051094e-01f, 7.03646839e-02f, -1.36574551e-01f, 1.10456184e-01f, -2.87975520e-01f, -3.16975325e-01f, -2.18635604e-01f,
  5.92783540e-02f, 8.09078962e-02f, 2.81896710e-01f, -3.54695082e-01f, 4.12239313e-01f, 2.03700945e-01f, -2.03547418e-01f, 1.10026905e-02f, -1.58821598e-01f, -1.11354396e-01f,
  -9.78247374e-02f, -2.08549172e-01f, 1.44606084e-01f, -2.61105984e-01f, -7.46067762e-02f, -1.79819614e-01f, 1.39545426e-01f, 7.98216313e-02f, -8.25037062e-02f, 1.66160017e-01f,
  -1.10723771e-01f, -3.59424770e-01f, -1.32727087e-01f, 5.58018088e-02f, -5.33322580e-02f, 1.29495645e-02f, 1.21674851e-01f, 2.10222080e-01f, -1.54982535e-02f, -5.88129880e-03f,
  1.95831116e-02f, -4.74479795e-02f, -9.95317325e-02f, -2.10896824e-02f, -3.84511575e-02f, -5.89704886e-02f, 1.47507507e-02f, -1.07254181e-02f, -6.49643317e-02f, 1.17573431e-02f,
  -3.98592418e-03f, 4.03581224e-02f, -3.08467858e-02f, -3.28169949e-02f, 4.67677154e-02f, -1.03687175e-01f, 1.66840144e-02f, 1.17611513e-01f, -9.09306761e-03f, -3.43092233e-02f,
  -1.12499163e-01f, 6.69250563e-02f, -8.52508843e-02f, 4.14379351e-02f, -3.66456099e-02f, -1.92429479e-02f, -7.25446362e-03f, 5.89794293e-02f, -4.54556681e-02f, -8.89392570e-02f,
  2.31598224e-02f, -2.20177062e-02f, -5.67400977e-02f, -9.96339321e-02f, -5.63935973e-02f, -1.13829851e-01f, 1.03871167e-01f, -6.12661950e-02f, -2.14326195e-02f, 7.09552970e-03f,
  8.00988078e-02f, 3.21479738e-02f, 3.70055921e-02f, 3.97436321e-02f, -1.06429383e-01f, 1.94078796e-02f, -1.33034261e-03f, -1.11027630e-02f, -4.10564095e-02f, 7.93455839e-02f,
  -1.08395971e-01f, -2.97701061e-01f, -2.72936956e-03f, -4.90836427e-02f, -1.57457422e-02f, -5.44357076e-02f, -9.62169617e-02f, -2.91848406e-02f, 3.51757323e-03f, -3.83504219e-02f,
  -3.98160480e-02f, 5.23725748e-02f, -8.42047669e-03f, -1.75979268e-02f, -4.69844788e-02f, -1.17098078e-01f, -5.13570243e-03f, 5.49133644e-02f, 7.77977332e-02f, 2.36835759e-02f,
  3.26664820e-02f, 1.02149500e-02f, -5.11246175e-02f, -3.91699411e-02f, 9.87476576e-03f, -1.66534111e-02f, -2.90714260e-02f, -3.79718952e-02f, -2.35526985e-03f, -4.32568081e-02f,
  -3.40579599e-01f, -1.45802535e-02f, -2.00569078e-01f, -2.63581425e-01f, 9.99448746e-02f, -4.51790169e-02f, -1.08549744e-01f, 5.75399622e-02f, -2.37869248e-01f, 1.13199212e-01f,
  1.28444642e-01f, -1.67037547e-01f, -3.68367992e-02f, -2.33292580e-01f, -2.02103987e-01f, -3.28655601e-01f, -1.48427755e-01f, -7.57818818e-02f, -2.22936124e-01f, -1.21439934e-01f,
  -1.70440808e-01f, 8.96574780e-02f, -1.70225963e-01f, 1.88155070e-01f, 5.68142943e-02f, 1.48043707e-01f, 2.35935137e-01f, 2.55124807e-01f, 1.47408515e-01f, -2.42326278e-02f,
  -8.64404216e-02f, 3.84068601e-02f, 1.78359430e-02f, -5.46836369e-02f, -8.15238897e-03f, -1.74507014e-02f, 3.04098669e-02f, 4.62772809e-02f, 5.77329695e-02f, -1.08568028e-01f,
  2.12226510e-02f, 2.37668157e-02f, 9.68674105e-03f, 4.27694758e-03f, -1.49637861e-02f, -3.86742242e-02f, -3.74767892e-02f, -4.42104451e-02f, -1.99792646e-02f, -1.73214599e-01f,
  2.10826797e-03f, 2.28900947e-02f, -7.51817673e-02f, 1.80993171e-04f, 6.11905055e-03f, 1.26828356e-02f, 1.99434292e-02f, 1.17736487e-02f, -5.73514961e-02f, 8.64144489e-02f,
  1.42935067e-01f, 1.13160767e-01f, -5.40299937e-02f, -6.78787678e-02f, 3.44865490e-03f, 2.16198284e-02f, -5.39467260e-02f, 4.72317450e-04f, -1.36083225e-02f, 5.39013222e-02f,
  2.24066339e-02f, -8.84367619e-03f, -5.09900488e-02f, 3.26609537e-02f, 9.46370661e-02f, -6.54161498e-02f, 8.99476483e-02f, -2.68487334e-02f, 3.28020155e-02f, -2.75618229e-02f,
  6.56330138e-02f, -7.96730146e-02f, 1.11434102e-01f, -5.61046377e-02f, -9.43601206e-02f, 1.34051159e-01f, 1.49402097e-02f, -3.43537331e-03f, 1.39172394e-02f, 1.29365092e-02f,
  3.17048728e-02f, 1.25780746e-01f, -2.80538369e-02f, 4.87264991e-02f, 5.55969104e-02f, 2.32597347e-02f, -1.15445117e-02f, 4.14577425e-02f, 6.39042556e-02f, 4.42797178e-03f,
  9.13988575e-02f, 1.08168602e-01f, -1.63147915e-02f, -8.95164758e-02f, -1.43167889e-02f, 7.87179247e-02f, 4.45139073e-02f, 2.65313089e-02f, -2.46629659e-02f, 1.83816925e-02f,
  5.41121587e-02f, 1.43833563e-01f, -6.35944232e-02f, 3.76426838e-02f, 1.86000136e-03f, 1.08970307e-01f, 4.90323603e-02f, 4.26128916e-02f, -5.81101142e-03f, 2.15357430e-02f,
  -4.03018922e-01f, -7.61150708e-03f, -3.52285445e-01f, 1.95371136e-01f, -5.68990298e-02f, 1.01923220e-01f, 1.50051489e-01f, -7.06310058e-03f, -5.20022064e-02f, 3.77583891e-01f,
  2.96402305e-01f, -1.21734746e-01f, -2.04969570e-02f, 3.70631397e-01f, 9.71658155e-03f, 1.75885037e-01f, 2.74651378e-01f, 2.79418498e-01f, -1.64943114e-01f, -2.56783888e-02f,
  -7.14327842e-02f, 2.55371124e-01f, 6.70432672e-02f, 2.52353903e-02f, 7.05087036e-02f, -1.82578668e-01f, 2.15594038e-01f, -2.63068050e-01f, 2.94427544e-01f, 1.36973292e-01f,
  2.82082092e-02f, -1.26702443e-01f, 4.15881211e-03f, -9.63491350e-02f, -4.98137996e-02f, -1.91447455e-02f, 1.06002036e-02f, -1.04548067e-01f, -1.18626915e-01f, -7.17385411e-02f,
  -9.06114653e-02f, -3.86115462e-02f, 2.65856553e-02f, -7.15009822e-03f, -5.74923344e-02f, -8.22332967e-03f, 5.03142290e-02f, 5.51535897e-02f, 3.50364409e-02f, -5.51241376e-02f,
  4.04456332e-02f, -1.47849042e-02f, 8.31318870e-02f, 8.08638334e-02f, -2.60962127e-03f, 1.00500539e-01f, -3.15508209e-02f, 6.49144081e-03f, -3.79028381e-03f, -4.28920612e-02f,
  2.24718768e-02f, -8.28629658e-02f, 7.75021035e-04f, 4.82823551e-02f, -1.18922517e-01f, 7.04534799e-02f, 1.76402275e-02f, -2.36740727e-02f, -2.25490835e-02f, -3.00023425e-03f,
  3.44406441e-02f, -4.12329584e-02f, 7.25244135e-02f, -6.54399320e-02f, -9.20943730e-03f, 8.14166069e-02f, -7.73110166e-02f, -4.46554011e-04f, 4.47595678e-02f, 2.65894290e-02f,
  -2.81574694e-03f, -1.02667995e-01f, 8.50162134e-02f, 5.34785651e-02f, -5.65095283e-02f, -7.42218643e-02f, 6.08446486e-02f, -2.34819967e-02f, -3.62926349e-03f, -2.63512805e-02f,
  -2.00481519e-01f, -1.87665582e-01f, 2.97709275e-02f, -7.77737657e-03f, -2.55083945e-02f, 5.85135110e-02f, -1.00781827e-03f, -5.46934381e-02f, -6.87381551e-02f, -8.51579085e-02f,
  1.91497691e-02f, -8.68933462e-03f, -6.81828558e-02f, 2.12864522e-02f, -1.50231253e-02f, -1.65730249e-02f, 1.83065664e-02f, -1.65447537e-02f, 4.93456312e-02f, -6.33786097e-02f,
  2.66927332e-02f, 3.73358838e-02f, -3.36785689e-02f, 6.76694661e-02f, 7.67327026e-02f, 1.15564140e-02f, 2.17674393e-02f, -2.98640952e-02f, 2.95069572e-02f, 7.30481073e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.97254896e-01f, -2.36448161e-02f, 1.43145368e-01f, 2.37242907e-01f, 7.14028105e-02f, 1.96263585e-02f, 1.39312595e-01f, 3.51062790e-02f, -1.62862651e-02f, 1.22648522e-01f,
  1.00165717e-01f, 1.92290619e-01f, 1.27593577e-01f, 1.78048220e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -3.16216126e-02f, -7.25886747e-02f, 1.80976301e-01f, -5.62525019e-02f, 8.36034212e-03f, 9.68884081e-02f, -1.02922633e-01f, 4.63543497e-02f, -7.70649090e-02f, -9.48753394e-03f,
  -1.64097641e-03f, 4.31724489e-02f, -4.60246764e-02f, 1.22682363e-01f, 1.11561865e-01f, 8.19386542e-02f, -1.73713073e-01f, 2.00033169e-02f, -2.46877223e-02f, 1.98460504e-01f,
  7.14832395e-02f, 1.18908450e-01f, -8.41681808e-02f, 2.82210819e-02f, -8.82807001e-02f, -1.31690547e-01f, -1.81920417e-02f, -2.26811767e-01f, -5.23498617e-02f, -1.72770932e-01f,
  1.65894493e-01f, -2.69652642e-02f, -2.67491043e-02f, -7.89515749e-02f, 1.17544867e-01f, 4.04329896e-02f, -1.69445276e-01f, 1.43510684e-01f, -2.25194171e-01f, -3.30937117e-01f,
  -3.79521362e-02f, -9.20201838e-02f, -1.62418857e-01f, 1.91223368e-01f, -1.03075355e-01f, -3.09100375e-02f, -1.24908686e-01f, -2.99997687e-01f, 6.09451421e-02f, 2.97545493e-02f,
  -1.52117699e-01f, 2.10006893e-01f, -7.75763839e-02f, -1.89230129e-01f, 1.34847313e-01f, -6.30866503e-03f, 2.65464008e-01f, 5.36721386e-03f, 1.98262438e-01f, 6.29253834e-02f,
  -1.53446980e-02f, -1.43770918e-01f, -1.75612092e-01f, -1.59929290e-01f, -1.28949240e-01f, 4.22295481e-02f, 1.05676427e-01f, 8.55423138e-02f, -1.09315097e-01f, 1.40635163e-01f,
  1.52574629e-01f, 1.59252789e-02f, 7.54396841e-02f, -1.38322236e-02f, -1.38286456e-01f, 1.50687233e-01f, 7.57002681e-02f, 7.10982233e-02f, 3.71564887e-02f, -9.26776677e-02f,
  9.55184624e-02f, 1.16018921e-01f, 6.76956251e-02f, 1.97857302e-02f, 8.32959190e-02f, -7.96167776e-02f, 1.00384280e-01f, -8.66047665e-02f, -1.04821265e-01f, -8.57297853e-02f,
  3.77243455e-03f, -1.00498796e-01f, -2.11337104e-01f, -3.00972555e-02f, -1.30211443e-01f, -2.59898882e-02f, 1.46521851e-01f, -1.81189597e-01f, 2.01352369e-02f, -2.57295221e-02f,
  1.31300122e-01f, 2.36836046e-01f, 1.06224932e-01f, 6.60426319e-02f, -1.63594615e-02f, 3.16477492e-02f, -1.35778375e-02f, -2.32603058e-01f, 3.09533387e-01f, 1.78924769e-01f,
  1.72565535e-01f, -4.06712480e-03f, -1.03394926e-01f, -1.59168512e-01f, -1.57172993e-01f, -1.29900843e-01f, 1.60110354e-01f, 2.40019858e-01f, -1.90388590e-01f, 1.14883713e-01f,
  -1.76548794e-01f, -1.47230238e-01f, -2.51853079e-01f, -1.39030010e-01f, 1.97749943e-01f, -4.90899533e-02f, -9.88040343e-02f, 3.06321323e-01f, 2.08331227e-01f, 9.60785300e-02f,
  6.49127588e-02f, 4.07190621e-02f, -5.78357838e-02f, -6.81882873e-02f, 2.92016547e-02f, -6.10585250e-02f, 1.44429747e-02f, -4.17443784e-03f, -5.35300411e-02f, 8.03633332e-02f,
  -8.09194297e-02f, -9.12459195e-03f, -8.10366794e-02f, 3.88387218e-02f, 4.59908433e-02f, 1.52128125e-02f, 1.17232967e-02f, 6.58890791e-03f, -2.49283910e-02f, -1.97024062e-01f,
  1.27508685e-01f, 4.13777940e-02f, -5.68573661e-02f, 1.22826345e-01f, -1.34864375e-01f, 3.40745524e-02f, -1.76985577e-01f, 1.50685668e-01f, -1.36125937e-01f, 2.18010992e-01f,
  8.97869542e-02f, 6.52076229e-02f, 8.95761624e-02f, 9.30971950e-02f, 7.70192444e-02f, -1.27152756e-01f, 1.86180726e-01f, 2.88150370e-01f, 1.29436657e-01f, 1.67477340e-01f,
  -5.05191945e-02f, 1.01014413e-02f, 7.78623894e-02f, -1.23382434e-01f, 1.72358632e-01f, 1.51130721e-01f, 1.06273241e-01f, 9.87466872e-02f, -1.21531464e-01f, 2.23614708e-01f,
  2.25492552e-01f, -1.20328076e-01f, -2.39161864e-01f, -8.56948495e-02f, -1.62196994e-01f, -2.71807630e-02f, 4.84897494e-02f, -1.13969125e-01f, -6.45769835e-02f, 2.33672008e-01f,
  5.78225404e-02f, 2.11044267e-01f, 3.21972184e-02f, 2.00307205e-01f, 6.06865324e-02f, 1.40290529e-01f, -9.04595032e-02f, -5.16680144e-02f, 1.70046300e-01f, 1.24833867e-01f,
  1.23828478e-01f, -5.13478294e-02f, 1.46473080e-01f, -7.58633465e-02f, -1.77854318e-02f, 1.65858462e-01f, 7.82245547e-02f, 8.74411836e-02f, -4.18835145e-04f, -3.04040662e-03f,
  -3.62058096e-02f, -2.54019424e-02f, -2.72285249e-02f, -6.56101480e-02f, 8.52500368e-03f, -1.08483270e-01f, -1.00945160e-01f, 1.52105182e-01f, -1.38319403e-01f, 3.07036936e-01f,
  -2.90090442e-02f, 8.03039670e-02f, -9.09902155e-03f, 2.39160508e-01f, -6.95318133e-02f, -9.86227542e-02f, -1.40952185e-01f, 9.73386243e-02f, -1.87129498e-01f, 2.09365934e-01f,
  -2.15302818e-02f, 2.39359140e-01f, -6.28320277e-02f, 2.03129098e-01f, 4.13774550e-02f, -1.27323642e-01f, 9.04649198e-02f, -8.86083767e-03f, 8.77455026e-02f, 8.23331028e-02f,
  1.69405565e-01f, -2.61740446e-01f, 1.85347181e-02f, -1.54394433e-01f, 1.88402027e-01f, 1.71426281e-01f, -1.07013203e-01f, -3.44552062e-02f, 1.84057027e-01f, -1.35074273e-01f,
  -1.38613824e-02f, 2.25178227e-01f, 1.45080507e-01f, -4.96930629e-02f, 1.22721918e-01f, 1.58818394e-01f, -1.26499251e-01f, -7.57859275e-02f, 9.39898193e-02f, -7.18712807e-02f,
  -5.17515913e-02f, -1.35630310e-01f, -8.87896940e-02f, 6.62854165e-02f, 5.93712330e-02f, 7.37224370e-02f, 5.64972982e-02f, 3.95875685e-02f, 1.88096881e-01f, 6.89397380e-02f,
  1.58270281e-02f, -2.73788087e-02f, -4.57480736e-02f, -6.71797767e-02f, -6.83705434e-02f, 1.10052787e-01f, 1.22074880e-01f, 1.25827461e-01f, 1.11643866e-01f, 1.17769219e-01f,
  -8.06347877e-02f, -1.20397277e-01f, -2.28455976e-01f, -1.95354581e-01f, 1.82720423e-01f, -1.09843604e-01f, 9.05852541e-02f, -4.25472669e-02f, -4.43809219e-02f, -1.94420829e-01f,
  2.62510240e-01f, 1.37330458e-01f, -1.24019228e-01f, 2.26375565e-01f, -1.96126312e-01f, -1.92939445e-01f, -6.79638609e-02f, -5.54676317e-02f, -1.26090422e-01f, 1.63032949e-01f,
  1.74153656e-01f, 2.28332151e-02f, -2.07449822e-03f, -3.31795096e-01f, -2.00961575e-01f, -2.68753260e-01f, 5.59084909e-03f, -2.62268484e-01f, -1.83876917e-01f, -9.87351984e-02f,
  -6.59506544e-02f, 1.32103935e-01f, 2.96983540e-01f, -3.22031006e-02f, -1.79830864e-02f, 3.24765742e-01f, 1.54262288e-02f, 2.41282240e-01f, -7.00772926e-02f, -1.71067137e-02f,
  -1.04679793e-01f, 1.47728935e-01f, -1.65396675e-01f, 1.15749016e-01f, -2.46402826e-02f, 8.48611891e-02f, -4.09915708e-02f, 2.01906055e-01f, 7.08242357e-02f, -4.55253609e-02f,
  2.09371999e-01f, -8.56949016e-02f, 2.84921844e-02f, 1.51418269e-01f, 1.88612603e-02f, -5.53288460e-02f, 8.24162364e-03f, 2.53069680e-02f, -4.39335816e-02f, -1.40760422e-01f,
  -1.67278364e-01f, -5.07463235e-03f, 2.23864373e-02f, 9.96388420e-02f, 1.35467738e-01f, -3.29167359e-02f, -1.17400534e-01f, 6.84758350e-02f, 1.10184960e-03f, 1.62237957e-02f,
  1.74756914e-01f, -1.51304184e-02f, -1.23643838e-01f, 3.01662236e-02f, -2.12687388e-01f, 1.82470560e-01f, -1.45428136e-01f, -8.52678195e-02f, -1.67663813e-01f, -6.72894791e-02f,
  1.47832111e-02f, 1.74015462e-02f, 1.09231964e-01f, 2.12657169e-01f, -1.33288383e-01f, 1.17085636e-01f, -2.26378292e-01f, -2.60883290e-02f, 1.61849260e-01f, -6.33731857e-02f,
  1.74516529e-01f, -2.43439004e-01f, -2.35148549e-01f, 7.59738535e-02f, 1.97163746e-01f, -1.47803068e-01f, 2.33172718e-02f, -1.51924208e-01f, -2.28583887e-01f, -1.53334271e-02f,
  -7.59668648e-02f, -2.21939892e-01f, 1.23334907e-01f, -4.62832302e-02f, -6.14601783e-02f, -6.32750839e-02f, 1.88268200e-02f, 4.77356240e-02f, -1.53131366e-01f, -6.28816113e-02f,
  1.50729924e-01f, -5.03280461e-02f, -2.91261561e-02f, -1.29476056e-01f, -1.83484554e-01f, 6.74201101e-02f, -1.52070552e-01f, -1.36337355e-01f, -1.65748477e-01f, -1.80805251e-02f,
  -9.77016091e-02f, 1.06620863e-02f, 3.29450257e-02f, -7.91057199e-02f, -6.15187846e-02f, -1.90030620e-01f, 6.63609803e-02f, -1.33976892e-01f, -3.81607525e-02f, 1.68282706e-02f,
  -1.19780265e-01f, 2.15515159e-02f, 7.94106498e-02f, 1.44898957e-02f, -1.56274423e-01f, 1.53102249e-01f, 4.94748428e-02f, 1.71470255e-01f, -1.34494275e-01f, -1.75754815e-01f,
  9.08512529e-03f, 2.92643365e-02f, 1.65636286e-01f, 6.48282692e-02f, 6.79133609e-02f, -1.21250011e-01f, -1.43825158e-01f, -1.44807950e-01f, 5.47282659e-02f, -1.82242274e-01f,
  8.35543647e-02f, 3.62819694e-02f, -6.89384416e-02f, -2.28250340e-01f, -1.80501789e-01f, 7.13736489e-02f, 1.63373888e-01f, 7.84554034e-02f, -1.19724877e-01f, -8.67185816e-02f,
  -1.12808563e-01f, 7.43151680e-02f, -2.85824314e-02f, -1.55919254e-01f, 3.42851803e-02f, 1.96606945e-02f, 6.44395947e-02f, 3.64592582e-01f, 2.34161709e-02f, 1.59253001e-01f,
  6.26634210e-02f, 9.86034125e-02f, -1.05820388e-01f, 1.00194111e-01f, 1.51205495e-01f, -3.14950906e-02f, -2.83669923e-02f, -9.92833301e-02f, -1.10947199e-01f, -6.63052574e-02f,
  1.58777181e-02f, -5.82685843e-02f, 6.78278655e-02f, 1.64245591e-01f, -1.50747737e-02f, -2.13906597e-02f, -6.33671135e-02f, -4.32045897e-04f, 3.54124047e-02f, -8.65598116e-03f,
  5.07606417e-02f, 4.67370152e-02f, -1.72883552e-02f, -1.78396419e-01f, 9.39318240e-02f, -1.41736984e-01f, -1.65009379e-01f, 2.92991940e-02f, -1.53147608e-01f, 1.10307291e-01f,
  2.09863663e-01f, 6.13681376e-02f, 1.94786668e-01f, 4.64748591e-02f, 8.99993554e-02f, 2.68811546e-02f, 1.52774192e-02f, 1.45987093e-01f, -2.40501449e-01f, -6.00051396e-02f,
  -1.06487982e-01f, -7.48737855e-03f, 1.39920950e-01f, -1.29359424e-01f, -7.73889944e-02f, -2.60088533e-01f, -2.59954095e-01f, -2.95233011e-01f, -1.81465372e-01f, 1.86564490e-01f,
  5.09228557e-02f, -8.24207347e-03f, -2.48513073e-01f, 7.24259466e-02f, -2.44566590e-01f, 2.18185559e-02f, 7.95661658e-02f, -1.14304520e-01f, 3.81398462e-02f, -4.59143035e-02f,
  -2.49005910e-02f, 9.09081697e-02f, 3.51718329e-02f, 2.10229665e-01f, -1.89259890e-02f, 1.43700182e-01f, 1.23365261e-01f, -5.27012162e-02f, 9.29266736e-02f, -8.00242200e-02f,
  8.15640166e-02f, -1.18093081e-02f, -2.10324004e-01f, 1.25742376e-01f, 2.60471702e-02f, -1.16248429e-01f, -1.98301584e-01f, 1.22537976e-02f, 2.11521843e-03f, -2.66220383e-02f,
  6.62426502e-02f, -2.06464186e-01f, 4.72330004e-02f, -3.60018061e-03f, 4.29182313e-02f, 3.34903561e-02f, 2.93272566e-02f, -1.21855080e-01f, -5.01395538e-02f, 1.04567766e-01f,
  -5.55216111e-02f, 1.54387787e-01f, -1.97293088e-02f, -1.43955857e-01f, -9.66964886e-02f, 2.87282079e-01f, -1.10748090e-01f, -1.55923530e-01f, 1.31613895e-01f, -1.43021598e-01f,
  2.06017375e-01f, 1.92492440e-01f, 6.45617470e-02f, 1.01437904e-01f, 3.78012024e-02f, -1.19860500e-01f, -1.42044365e-01f, -1.08136646e-01f, -9.57867056e-02f, -1.02197967e-01f,
  1.09473109e-01f, 1.75747827e-01f, 3.60189602e-02f, -1.15251534e-01f, -1.72625557e-01f, 3.47064063e-02f, 2.03885604e-02f, -3.54059860e-02f, -2.21575573e-01f, -9.67486054e-02f,
  -1.54161945e-01f, -2.41474777e-01f, 7.39068165e-02f, 2.20170185e-01f, 7.66669363e-02f, -5.52248992e-02f, -1.59492195e-02f, 1.24327708e-02f, -3.67806256e-02f, -1.21602975e-01f,
  1.44935876e-01f, -1.00685775e-01f, -1.66537538e-01f, 2.18168721e-02f, -1.95892453e-02f, 4.61406028e-03f, 7.83632994e-02f, 1.28284052e-01f, 1.85182422e-01f, 1.29711002e-01f,
  -4.69548143e-02f, -1.53203070e-01f, 2.01128758e-02f, -1.78294666e-02f, -2.21523065e-02f, 2.79651955e-02f, -1.36977792e-01f, 6.54625222e-02f, 1.56128425e-02f, -1.95417963e-02f,
  -7.41291195e-02f, 2.33306840e-01f, -9.83678997e-02f, 1.43435458e-02f, 9.28717479e-02f, 1.64726749e-01f, -2.07136020e-01f, -1.37481347e-01f, -2.41621643e-01f, -9.98564288e-02f,
  -2.65268665e-02f, 9.39860344e-02f, -3.77895311e-03f, -1.41609207e-01f, -4.66429703e-02f, 7.09160045e-02f, 5.47547266e-02f, 1.49102658e-01f, 2.23414883e-01f, -6.04201630e-02f,
  -1.92716846e-03f, -6.64249412e-04f, 1.94892734e-01f, 1.45903379e-01f, -6.61733150e-02f, 1.95611015e-01f, 1.66277274e-01f, -2.06296623e-01f, -2.17854321e-01f, -1.36371760e-03f,
  1.39128059e-01f, 9.24528092e-02f, 2.72494624e-03f, -3.34216654e-02f, -8.16818979e-03f, 5.15775895e-03f, -1.42412066e-01f, 2.31942177e-01f, -4.21441672e-03f, -1.83385551e-01f,
  1.83674932e-01f, -1.12013919e-02f, -9.58987623e-02f, 1.20633699e-01f, 1.66919619e-01f, -1.34292990e-01f, 1.08173847e-01f, 7.36071914e-02f, 8.12661052e-02f, -8.69912207e-02f,
  -1.82759762e-02f, 6.38257992e-03f, 1.29419774e-01f, -8.94830152e-02f, -9.22202021e-02f, -1.07560158e-02f, 2.39196252e-02f, -1.18463434e-01f, -5.38600683e-02f, -2.22335964e-01f,
  -1.46600872e-01f, -5.43684773e-02f, 1.11146666e-01f, -1.61493659e-01f, 1.40276581e-01f, 7.40967095e-02f, -1.37809470e-01f, 7.87533000e-02f, -6.26749024e-02f, 1.56681940e-01f,
  3.31607722e-02f, -1.65530533e-01f, -8.69511664e-02f, -3.62201408e-02f, -5.80702648e-02f, 1.96695641e-01f, 2.05669831e-03f, -2.28925142e-02f, 4.43259329e-02f, 1.10292047e-01f,
  1.61896348e-01f, 2.54915923e-01f, 5.53300269e-02f, 1.38069429e-02f, -8.43714550e-02f, -3.73029010e-03f, 2.71480978e-01f, 3.69254678e-01f, 1.68557227e-01f, 1.20449245e-01f,
  -2.94081736e-02f, 2.27153078e-02f, 2.56682813e-01f, 3.42264324e-02f, 5.73305227e-02f, -3.27832758e-01f, -2.33418564e-03f, -1.48115233e-01f, -2.69395169e-02f, 2.26499408e-01f,
  -1.68608055e-01f, -9.52609554e-02f, 2.18514442e-01f, -9.81222838e-02f, 1.51990175e-01f, 1.36600047e-01f, -1.73990503e-02f, 1.37800770e-02f, 1.96483195e-01f, 1.76819459e-01f,
  8.68355408e-02f, 4.05943468e-02f, 1.24624960e-01f, -1.09948423e-02f, 4.30085175e-02f, 4.27844897e-02f, 1.46332711e-01f, 4.96159308e-02f, -7.90060014e-02f, -4.92654294e-02f,
  3.69793922e-03f, 6.86133131e-02f, -4.68760394e-02f, -1.50839418e-01f, 3.59235667e-02f, 3.30356546e-02f, -1.64356884e-02f, -1.52595742e-02f, 2.38492668e-01f, -2.61735613e-03f,
  1.11615874e-01f, -4.77070473e-02f, -1.53351873e-01f, 2.61036098e-01f, -4.95378822e-02f, -1.05394371e-01f, -1.58030272e-01f, -1.10188894e-01f, -1.79549351e-01f, -1.68416202e-01f,
  1.54335484e-01f, -1.67864695e-01f, 1.94820493e-01f, 3.12048405e-01f, 1.95068098e-03f, 3.89039256e-02f, 2.30897740e-01f, -2.83330619e-01f, 4.72078212e-02f, 2.71997415e-03f,
  -1.98690087e-01f, -2.85164341e-02f, -3.35676372e-02f, 1.16271660e-01f, 1.20748580e-01f, -1.23418786e-01f, 1.66792050e-01f, 2.13095993e-01f, 8.73717386e-03f, 9.87851098e-02f,
  -3.65039200e-01f, -3.87281440e-02f, -2.10884437e-01f, -2.72044271e-01f, 1.50285348e-01f, 1.01175867e-01f, 1.22786924e-01f, -1.60381928e-01f, -2.79087067e-01f, -1.37025267e-01f,
  9.74467918e-02f, -1.35945275e-01f, -2.56062657e-01f, -1.01192050e-01f, -1.40330389e-01f, -2.08159640e-01f, -4.31883223e-02f, -7.24675432e-02f, 7.44113177e-02f, 5.24829365e-02f,
  1.71549655e-02f, -9.09385905e-02f, 5.85304797e-02f, -1.08998045e-01f, -3.57839018e-02f, 9.64727029e-02f, -2.12743524e-02f, 8.75123814e-02f, -1.27074376e-01f, -1.04749344e-01f,
  -3.13855559e-01f, -9.15753306e-04f, -1.30529419e-01f, -2.45215937e-01f, 1.09254621e-01f, 7.12748095e-02f, 1.63359031e-01f, -2.01229155e-01f, -5.12045901e-03f, 1.53061673e-01f,
  2.79445142e-01f, 1.97169393e-01f, -1.20203301e-01f, -2.26400420e-01f, -8.95858780e-02f, 1.06328227e-01f, -1.89004093e-02f, 8.88085216e-02f, -1.33935854e-01f, -7.62810633e-02f,
  1.38493001e-01f, -2.91853398e-02f, 2.55192101e-01f, -7.06210583e-02f, -3.43663156e-01f, -4.24396172e-02f, -2.15766847e-01f, -1.56961292e-01f, -3.67113412e-03f, -2.91135311e-01f,
  -1.88909248e-01f, 3.81390448e-03f, 1.28647059e-01f, 1.59892008e-01f, 1.29831091e-01f, 4.73686494e-02f, -1.91871792e-01f, -1.83948539e-02f, 1.48162335e-01f, -1.59992218e-01f,
  -2.13221952e-01f, 3.53505164e-01f, 1.38141647e-01f, 1.56454705e-02f, 4.89349961e-02f, 5.65698147e-02f, 7.67016709e-02f, -8.28108713e-02f, -2.21287999e-02f, -1.76515616e-02f,
  -3.90374288e-02f, 5.54694682e-02f, 9.37855914e-02f, 7.70104080e-02f, -1.27640054e-01f, 8.90632719e-03f, 1.52810407e-03f, 1.63222462e-01f, 1.39549673e-01f, -1.24219194e-01f,
  -3.12980935e-02f, 1.41666353e-01f, 1.04573935e-01f, -1.01058958e-02f, 6.64793998e-02f, 1.07490584e-01f, -7.68961459e-02f, 2.77623147e-01f, -2.80627400e-01f, 1.91632628e-01f,
  7.47395456e-02f, 1.71885286e-02f, -8.47436562e-02f, 1.51829630e-01f, -9.75412503e-02f, -5.75636514e-02f, 2.95668632e-01f, 4.67998125e-02f, -1.97702169e-01f, 3.76444198e-02f,
  7.71741420e-02f, 2.29392797e-01f, -2.03585893e-01f, 2.40797132e-01f, -1.71857879e-01f, -3.59535627e-02f, 1.42951176e-01f, -9.48350355e-02f, 2.38088533e-01f, -1.52702816e-02f,
  1.44300833e-01f, -3.06572486e-02f, 1.56631097e-01f, -2.44763251e-02f, 1.83443487e-01f, -3.34140241e-01f, -7.95039088e-02f, 1.45188749e-01f, 1.69564366e-01f, 1.04635328e-01f,
  4.33578491e-02f, 2.85187483e-01f, -3.61754358e-01f, 4.37567204e-01f, 2.24948615e-01f, 6.90169558e-02f, 7.39227980e-02f, 2.25591334e-03f, -9.17445682e-03f, 1.65147454e-01f,
  9.34951901e-02f, 1.98846206e-01f, -1.24012819e-02f, 1.67354807e-01f, 5.19087771e-03f, -2.11007167e-02f, -1.02134690e-01f, -4.58698982e-04f, 8.78720880e-02f, 4.17518243e-02f,
  -6.67432919e-02f, 1.74338639e-01f, 5.57860918e-02f, 4.35478650e-02f, 7.62137845e-02f, -4.62554337e-04f, -9.92536023e-02f, -8.35220050e-03f, 2.40536302e-01f, -8.80355388e-02f,
  1.54684365e-01f, -5.57176210e-02f, 7.53223673e-02f, -1.22542366e-01f, -1.34551823e-01f, 9.78032202e-02f, 6.92161620e-02f, -7.02675059e-02f, -6.47954717e-02f, -6.29984215e-03f,
  -1.67676993e-02f, -2.94448473e-02f, 1.07304759e-01f, -1.17268644e-01f, 5.11979759e-02f, -1.15114748e-01f, 3.64246666e-02f, 1.25213251e-01f, 6.06710315e-02f, -4.07480672e-02f,
  -1.79282054e-01f, -1.01292916e-01f, -2.56749749e-01f, -1.13855302e-01f, 1.12812497e-01f, 1.58465669e-01f, -9.03965011e-02f, 2.11952582e-01f, -2.68037796e-01f, 9.38366950e-02f,
  -7.03096986e-02f, -1.77416876e-02f, -1.09673575e-01f, -6.62968494e-04f, -4.28391173e-02f, -4.90823016e-03f, 2.32550561e-01f, -1.30604729e-01f, 3.01209968e-02f, -2.94679493e-01f,
  -2.73959339e-02f, -9.25981700e-02f, -8.16886127e-02f, 1.61367245e-02f, -5.88265695e-02f, -4.42871004e-02f, -2.08280310e-01f, -8.13571513e-02f, -4.97592706e-03f, -5.21611981e-02f,
  5.53867035e-02f, -8.66148099e-02f, 8.14958960e-02f, -9.97626707e-02f, -7.30369193e-03f, -1.01220220e-01f, -8.20958167e-02f, -2.04788018e-02f, -6.16897233e-02f, -1.08155124e-01f,
  -1.11260675e-01f, 1.76641569e-01f, -2.02435657e-01f, 8.78280476e-02f, -1.04217790e-01f, 7.80077726e-02f, 1.17330953e-01f, -1.44717678e-01f, 2.93693960e-01f, -2.12575588e-02f,
  2.00591311e-01f, -5.43531403e-02f, 2.47197459e-03f, 3.21637988e-01f, 1.91768706e-01f, 3.66310738e-02f, -1.67357728e-01f, -1.17943451e-01f, 2.18341947e-02f, -2.48550892e-01f,
  6.86711818e-02f, -1.57289252e-01f, -2.05893919e-01f, 1.98115155e-01f, -2.71877527e-01f, -2.06976667e-01f, -2.08947480e-01f, -1.56179547e-01f, 7.51810893e-02f, 1.93760246e-01f,
  -3.07571478e-02f, 7.59536773e-02f, -2.24560037e-01f, -1.35146588e-01f, 2.07475990e-01f, 1.38710225e-02f, 2.43140161e-01f, 7.53260925e-02f, 1.98896065e-01f, 2.42250077e-02f,
  -1.92446530e-01f, 1.16124861e-01f, 1.29290596e-01f, -3.90952565e-02f, -7.83004239e-02f, -7.93743283e-02f, -4.30560336e-02f, 1.98185533e-01f, 1.37050524e-01f, 2.86815595e-02f,
  -2.44832903e-01f, 2.42815852e-01f, -9.67241358e-03f, 4.36111912e-02f, 4.91462126e-02f, -8.94168541e-02f, 8.24325830e-02f, 2.49351300e-02f, 1.31915361e-01f, -2.13380188e-01f,
  -2.11141184e-01f, -1.30971679e-02f, 3.59969325e-02f, 6.32294640e-02f, 8.17327574e-02f, 1.59579068e-02f, 1.11014977e-01f, -3.30314115e-02f, -3.39396596e-02f, -8.24666470e-02f,
  1.16410479e-01f, -2.61883318e-01f, -2.70367771e-01f, -8.00056383e-02f, 6.76315725e-02f, -2.43716896e-01f, -1.86799645e-01f, -1.63555697e-01f, -1.53536096e-01f, 1.83310151e-01f,
  -8.52232426e-03f, -2.16084402e-02f, -2.90758699e-01f, -2.08541602e-01f, 1.20738924e-01f, -1.87851951e-01f, -8.33842903e-02f, 5.25863431e-02f, -8.48038048e-02f, 2.51174062e-01f,
  1.51243791e-01f, 3.58285792e-02f, 2.05410987e-01f, -8.40692148e-02f, -1.96059018e-01f, 8.60715564e-03f, 9.57419723e-02f, 1.47121489e-01f, 1.84110273e-02f, -1.84034377e-01f,
  1.25497937e-01f, -2.12839141e-01f, 8.36958960e-02f, -4.73013856e-02f, 1.35226592e-01f, -4.08563882e-01f, -1.23643652e-01f, -4.01834428e-01f, -6.60856962e-02f, 2.33562775e-02f,
  -8.99907202e-02f, 5.32284006e-02f, 7.86934569e-02f, -2.94018872e-02f, -1.94727287e-01f, 1.96945801e-01f, -4.24088649e-02f, 1.08554043e-01f, 2.13657603e-01f, 4.16142270e-02f,
  1.41054943e-01f, 9.73425731e-02f, 1.72801971e-01f, -8.01954046e-02f, 1.96802127e-03f, -2.42897719e-02f, -4.18772474e-02f, -5.51359914e-02f, 2.22383346e-02f, 9.97491702e-02f,
  3.16357575e-02f, -4.54535969e-02f, 6.10306896e-02f, -6.70033544e-02f, -4.25853468e-02f, -9.88426581e-02f, 9.14515629e-02f, 1.74494833e-02f, 1.58609077e-01f, -1.46352619e-01f,
  -1.30143508e-01f, -1.83012381e-01f, -2.46974275e-01f, -3.34749781e-02f, -8.70991498e-02f, -2.66315453e-02f, -1.31789058e-01f, -2.50089198e-01f, 2.34268457e-02f, -1.14578679e-01f,
  5.89527981e-03f, 6.47040009e-02f, -1.02921531e-01f, 1.85963526e-01f, -1.33937299e-01f, 1.57894269e-01f, 1.26281276e-01f, -1.04220241e-01f, 1.70306772e-01f, -1.23975731e-01f,
  -2.11145103e-01f, 1.60293579e-01f, 2.14174762e-01f, -5.45200408e-02f, 1.62893757e-01f, -1.29941583e-01f, -1.79593980e-01f, 1.05674095e-01f, 2.07843892e-02f, -3.08788121e-01f,
  -2.83901822e-02f, -2.53374636e-01f, 7.92387500e-02f, 5.27239293e-02f, 8.20682794e-02f, 6.15191720e-02f, -2.65537538e-02f, 1.35767564e-01f, 8.05571005e-02f, -5.01453271e-03f,
  -1.63450122e-01f, -8.71581361e-02f, -2.78751761e-01f, 1.62697281e-03f, -1.11837484e-01f, -2.26474389e-01f, -3.17053162e-02f, 1.60396531e-01f, 1.97710931e-01f, -9.55826715e-02f,
  4.94929850e-02f, -6.87946305e-02f, 1.70525089e-02f, 4.63459454e-02f, -2.72701848e-02f, -8.40021446e-02f, 6.48076013e-02f, 5.33304848e-02f, -5.82346655e-02f, 1.52636662e-01f,
  -5.94136864e-02f, 9.33833122e-02f, 2.02882453e-03f, 7.51557052e-02f, -1.57698225e-02f, 1.21404849e-01f, 4.11102250e-02f, -8.53598192e-02f, -8.83149728e-02f, -7.11349249e-02f,
  -2.35380083e-02f, -6.97180908e-03f, -5.00021316e-02f, -5.58941159e-03f, -3.48402597e-02f, -1.01827927e-01f, 9.42627937e-02f, -1.30244568e-01f, 4.64722402e-02f, 1.38004133e-02f,
  1.00192823e-01f, -3.53940204e-02f, -6.84732199e-02f, 7.18664005e-02f, 1.44796774e-01f, -9.77007002e-02f, -1.83532536e-01f, -1.42417967e-01f, -1.65769994e-01f, 2.16574132e-01f,
  -5.81378415e-02f, -1.44325450e-01f, 1.16369560e-01f, -4.78981882e-02f, 2.03881294e-01f, 1.54427052e-01f, -7.79503956e-02f, 6.62106350e-02f, -1.74003899e-01f, 1.54825449e-01f,
  1.04801141e-01f, 3.03392917e-01f, 1.58886872e-02f, -7.96820596e-02f, 1.17616720e-01f, -2.01389920e-02f, -4.87095565e-02f, 1.64584607e-01f, 3.80360037e-02f, -1.00876682e-01f,
  9.89756212e-02f, 7.56164417e-02f, 1.45319223e-01f, -7.39303231e-02f, -1.56836323e-02f, -1.46869749e-01f, 6.18717931e-02f, 3.73521000e-02f, -4.31561237e-03f, -5.71814924e-02f,
  1.09232955e-01f, -1.61897451e-01f, 3.39664638e-01f, -5.83088025e-02f, -2.92662680e-01f, 2.84829140e-01f, 1.60125971e-01f, -1.17564686e-01f, 2.03019064e-02f, 1.28164902e-01f,
  -2.82077700e-01f, -2.96754032e-01f, 4.77915332e-02f, -1.31816313e-01f, 8.76162127e-02f, 1.34313792e-01f, 1.91910431e-01f, -1.63468987e-01f, 2.12578177e-01f, -5.37973121e-02f,
  -1.25842080e-01f, -4.04218249e-02f, -2.46842310e-01f, -8.01267177e-02f, 1.08223125e-01f, 2.43965149e-01f, 1.72142953e-01f, 1.11308485e-01f, -9.81950983e-02f, 2.14032382e-01f,
  5.68140559e-02f, -3.54272686e-02f, -3.00091267e-01f, 1.72588706e-01f, -1.65398121e-01f, -3.01935732e-01f, 1.65717885e-01f, -2.80053347e-01f, 3.34403999e-02f, -1.74570099e-01f,
  1.54050067e-02f, 1.59963414e-01f, 7.89430141e-02f, 1.25072792e-01f, -7.16430098e-02f, 7.30762631e-02f, 2.55576782e-02f, 6.54603317e-02f, -1.27776871e-02f, -1.77474096e-02f,
  -1.44656464e-01f, 4.03141268e-02f, -1.98057070e-02f, -3.89511101e-02f, -1.12470403e-01f, 3.05205453e-02f, 7.18412474e-02f, 1.71073124e-01f, 1.47942886e-01f, -7.12654041e-03f,
  1.87783897e-01f, -5.52749820e-02f, 1.27084246e-02f, 3.81778250e-03f, 1.02411389e-01f, -1.50356650e-01f, 5.55847818e-03f, 8.35473556e-03f, -1.83952704e-01f, 1.36273503e-01f,
  -2.04222292e-01f, -3.92751582e-02f, 7.96407983e-02f, -2.61257738e-01f, -1.78721040e-01f, 1.21650152e-01f, 7.95205534e-02f, 2.19154805e-01f, 7.60959536e-02f, 1.00017495e-01f,
  -3.64647061e-02f, 1.19095989e-01f, 1.59149304e-01f, -1.02103487e-01f, 2.69581735e-01f, 1.96620990e-02f, 2.12878183e-01f, 6.96999356e-02f, 6.15868047e-02f, -1.21887803e-01f,
  -9.61044654e-02f, 5.13503030e-02f, 1.51224405e-01f, 1.83895066e-01f, -1.85695887e-01f, 1.26428604e-01f, -1.46497741e-01f, -1.40914187e-01f, -1.90669984e-01f, -1.00870505e-01f,
  1.73656568e-01f, -1.19156711e-01f, -1.17476713e-02f, -1.25216153e-02f, -9.73634273e-02f, -5.02016693e-02f, 1.55870065e-01f, -1.09255269e-01f, 3.20861936e-02f, 4.30353917e-02f,
  3.36902845e-03f, 1.04151279e-01f, -7.38895833e-02f, 8.57554823e-02f, -1.09545104e-01f, 6.74350411e-02f, 4.27947976e-02f, -1.02162480e-01f, 1.58681005e-01f, -8.10151026e-02f,
  7.83332586e-02f, 4.28029671e-02f, 2.11103056e-02f, 2.33792350e-01f, -8.10526833e-02f, 6.71919808e-02f, -6.75489530e-02f, 8.24096277e-02f, -8.98047835e-02f, -1.06222086e-01f,
  7.31388628e-02f, -9.25512910e-02f, 7.49643520e-02f, -8.67644101e-02f, -1.68415844e-01f, 1.66240618e-01f, 1.20106928e-01f, -1.25923276e-01f, -1.57713834e-02f, -2.15881750e-01f,
  2.93432139e-02f, 1.09416835e-01f, -1.21658169e-01f, 3.12209204e-02f, -2.13584974e-01f, -7.39434659e-02f, 1.88601643e-01f, -7.05145672e-02f, 2.26268291e-01f, 1.85536385e-01f,
  -1.99728042e-01f, -9.33104306e-02f, -2.00417414e-01f, 1.68634430e-02f, 2.05835670e-01f, -1.39557347e-01f, -7.81426430e-02f, 1.12272855e-02f, 6.07536398e-02f, 2.42329389e-01f,
  8.95577390e-03f, 6.47015944e-02f, -2.09602952e-01f, -1.53918594e-01f, 1.83372036e-01f, 9.53260586e-02f, -1.97214171e-01f, 8.15080926e-02f, 5.16235977e-02f, 1.20724574e-01f,
  -1.46330267e-01f, 2.11953297e-02f, -4.28795144e-02f, 1.68640301e-01f, -9.75359455e-02f, -1.96481887e-02f, -1.16535746e-01f, -9.89786685e-02f, 1.00154467e-01f, 8.38972703e-02f,
  5.14125004e-02f, -8.88157412e-02f, -5.92757910e-02f, -1.36085197e-01f, -7.09090382e-03f, 9.84574184e-02f, 8.40842649e-02f, -1.52274862e-01f, 4.42269854e-02f, 6.39437810e-02f,
  6.88198954e-02f, 2.13194657e-02f, 2.87125558e-02f, -2.64741421e-01f, 6.25845864e-02f, -1.46965116e-01f, -3.06655824e-01f, 9.05373842e-02f, 4.06876730e-04f, -2.07588151e-01f,
  -2.00079352e-01f, -2.30356112e-01f, -1.75954133e-01f, -7.54029825e-02f, 2.24019766e-01f, 1.42034441e-01f, -9.05396938e-02f, 1.91147938e-01f, 2.99266696e-01f, -7.06340298e-02f,
  2.21024767e-01f, -9.64540616e-02f, -8.70906413e-02f, 2.07135260e-01f, -2.36583441e-01f, -1.70014814e-01f, -1.92564011e-01f, 2.29084000e-01f, 7.89174363e-02f, -8.17336887e-02f,
  -3.14216703e-01f, 1.39902800e-01f, -8.48834291e-02f, -2.57156547e-02f, -3.71159852e-01f, -4.38559940e-03f, -1.83018193e-01f, -2.03405783e-01f, 1.38541371e-01f, 5.58244530e-03f,
  -5.85414730e-02f, -2.22705156e-01f, -1.05226643e-01f, 2.51682475e-02f, 1.52976468e-01f, 5.62082455e-02f, -6.80674314e-02f, 1.09640598e-01f, -8.28761756e-02f, 1.07846767e-01f,
  -7.67994374e-02f, -1.78210232e-02f, 1.15977988e-01f, 1.99027255e-01f, 8.49602968e-02f, 8.13343283e-03f, 1.69334300e-02f, -3.40851285e-02f, -1.18471928e-01f, 2.61683203e-02f,
  1.51204243e-01f, -1.36741385e-01f, 1.26185402e-01f, 1.62637725e-01f, 9.36518684e-02f, 1.23424619e-01f, 4.54179198e-02f, -2.98854172e-01f, 4.10592332e-02f, -1.25331566e-01f,
  -1.27268344e-01f, -4.75293584e-03f, 1.67112768e-01f, -7.04118535e-02f, 8.55448470e-02f, 1.77558303e-01f, -5.81360310e-02f, -4.66454923e-02f, -1.20881675e-02f, 6.78652450e-02f,
  -2.16542274e-01f, 4.37481254e-02f, 5.34687527e-02f, -8.40994567e-02f, 6.83486685e-02f, 2.69314833e-02f, 1.85547963e-01f, -5.24370670e-02f, -3.54628175e-01f, -1.93494752e-01f,
  -5.07403649e-02f, -1.50093272e-01f, -9.69220325e-02f, -8.40779021e-02f, -3.78751010e-01f, 1.40228093e-01f, 2.60059424e-02f, 2.73775999e-02f, -2.64088511e-01f, -7.28719980e-02f,
  -1.61087498e-01f, -2.55674183e-01f, 2.50917792e-01f, -8.87271762e-02f, -1.37236878e-01f, 2.97070563e-01f, -6.48426786e-02f, -4.31505777e-02f, -9.99864936e-03f, -3.07259541e-02f,
  4.45814468e-02f, -1.60810903e-01f, -1.26081839e-01f, 1.35531023e-01f, 6.02891520e-02f, -1.33003011e-01f, 1.22738034e-01f, 1.23098344e-01f, 5.01867644e-02f, 2.05498606e-01f,
  -2.62259506e-02f, -2.34510139e-01f, 7.41356984e-02f, -1.49038043e-02f, 4.59361188e-02f, 7.23604113e-02f, 1.91880658e-01f, -3.72790657e-02f, -9.71224234e-02f, 1.19940147e-01f,
  -2.65322272e-02f, -6.61101043e-02f, -1.04471877e-01f, -2.70992815e-01f, -1.19727112e-01f, -1.25029147e-01f, -2.21299473e-02f, -1.01947494e-01f, -6.75238157e-03f, -2.81321168e-01f,
  1.69907227e-01f, 1.35660484e-01f, 1.75864920e-01f, 8.77923891e-02f, -1.41013831e-01f, -7.12490035e-03f, -7.85826668e-02f, -5.39737009e-02f, 1.78747475e-02f, -5.74472211e-02f,
  1.61356643e-01f, 1.62093654e-01f, 6.72067702e-02f, 4.00037039e-03f, -9.88625735e-02f, 1.27208531e-01f, 7.98043087e-02f, -1.07578054e-01f, -3.50535363e-02f, 2.40134522e-02f,
  1.55288801e-01f, 1.83889806e-01f, -3.68383974e-02f, -1.69297695e-01f, -1.69381738e-01f, 2.11334545e-02f, 2.41279826e-02f, 1.49716809e-01f, -6.12905622e-02f, -3.80543560e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.74355343e-01f, -3.51181775e-01f, 2.34452844e-01f, -1.87532250e-02f, 1.30327746e-01f, 6.86550587e-02f, 2.72015017e-02f, 1.56340986e-01f, -1.30499974e-01f, 1.44609317e-01f,
  -1.71035275e-01f, 1.14728533e-01f, -1.90288931e-01f, 5.97574972e-02f, 6.30678460e-02f, 1.02873206e-01f, 2.11883634e-02f, -6.53053299e-02f, 1.09774888e-01f, 1.54390231e-01f,
  1.66093171e-01f, 2.23980173e-01f, -3.93398404e-02f, -3.09099397e-03f, -9.41147953e-02f, 9.92754996e-02f, 2.80418634e-01f, -3.79112780e-01f, -4.07271348e-02f, -1.08321689e-01f,
  8.49740282e-02f, 1.20139256e-01f, 1.76595107e-01f, 1.92618519e-01f, 3.53159666e-01f, -1.16608612e-01f, 8.03739578e-02f, -1.74261406e-01f, 1.48931043e-02f, -4.27711666e-01f,
  2.60783117e-02f, 2.22658645e-02f, -2.55425423e-01f, 7.66714364e-02f, -1.61230221e-01f, -2.93074325e-02f, 8.28386545e-02f, -1.74039543e-01f, -2.66926568e-02f, 2.45830581e-01f,
  -2.09561273e-01f, 4.30111110e-01f, 1.06231354e-01f, -6.31806478e-02f, 8.49373639e-02f, -1.09872252e-01f, -5.88454790e-02f, 2.72423744e-01f, 4.55742508e-01f, 1.05257168e-01f,
  -1.29877403e-01f, -1.30913526e-01f, -1.87536031e-01f, 1.26055358e-02f, 1.14916526e-01f, 1.36246458e-01f, -1.77836586e-02f, 3.05756658e-01f, 2.49478132e-01f, 2.11504981e-01f,
  -6.48190975e-02f, 2.86554933e-01f, 3.25055458e-02f, 1.35277107e-01f, 7.57386684e-02f, 3.23200852e-01f, 1.31121606e-01f, 1.20505847e-01f, 2.14259192e-01f, 7.69186718e-03f,
  5.44693507e-02f, 1.15848213e-01f, 1.07291482e-01f, 7.12806955e-02f, 1.32793128e-01f, 1.23201184e-01f, 2.09706858e-01f, 5.64415008e-02f, 1.38050482e-01f, -4.39363942e-02f,
  1.87180489e-01f, -4.48588252e-01f, -2.63230413e-01f, 4.46548648e-02f, -6.12309612e-02f, -3.84122044e-01f, -2.14546606e-01f, -2.41130292e-01f, -3.25584114e-01f, -1.87383089e-02f,
  1.00893162e-01f, 8.64395797e-02f, -2.03317285e-01f, -4.56634127e-02f, 2.29148984e-01f, -1.37030616e-01f, 2.29790688e-01f, -6.44092113e-02f, -9.44382027e-02f, 2.09193766e-01f,
  -1.65853128e-01f, -1.48299128e-01f, -6.61473647e-02f, 1.59777313e-01f, -1.14331208e-02f, 5.22637106e-02f, -2.26770639e-01f, 2.81331271e-01f, 3.76061022e-01f, 4.31732945e-02f,
  -2.26291060e-01f, -1.49874285e-01f, -1.58677876e-01f, -5.08188233e-02f, 3.59499365e-01f, -6.37976453e-02f, -1.87310383e-01f, -2.49240950e-01f, -1.11589506e-01f, -8.94257799e-02f,
  3.34630609e-01f, -4.01328541e-02f, -9.61992070e-02f, 3.53078634e-01f, 1.30012631e-01f, -2.07823992e-01f, -1.37110025e-01f, 1.86989278e-01f, 3.64654101e-02f, 2.03389600e-01f,
  2.88471878e-02f, 1.09204978e-01f, 1.01887234e-01f, 1.39456078e-01f, -2.34104767e-02f, 1.01920538e-01f, 2.40704834e-01f, 2.83513665e-01f, 1.19533293e-01f, 2.82886207e-01f,
  -4.59190011e-02f, 1.93896785e-01f, -5.25541566e-02f, -3.62536728e-01f, -1.17885262e-01f, 5.80563024e-02f, -7.93619268e-03f, -1.49947982e-02f, 9.58698988e-03f, 3.24948311e-01f,
  2.99819022e-01f, 8.77844170e-02f, 7.44347498e-02f, -2.27917954e-02f, -2.60031670e-01f, 1.98642120e-01f, -9.13322195e-02f, -8.47537816e-02f, -1.07978031e-01f, -2.51661271e-01f,
  9.77343181e-04f, 1.98619962e-01f, 1.85766265e-01f, -2.55602181e-01f, -2.85360962e-01f, -3.78264993e-01f, 2.43291892e-02f, -3.49641263e-01f, -8.95914659e-02f, -6.75361007e-02f,
  -2.79436171e-01f, 2.54849866e-02f, -3.88111562e-01f, -1.94295466e-01f, 4.86031594e-03f, 2.19158292e-01f, -1.37655452e-01f, 1.66093912e-02f, 3.01906943e-01f, -4.43434604e-02f,
  -3.24492604e-01f, 4.04220462e-01f, -1.12600796e-01f, 5.37184551e-02f, 2.45988250e-01f, 2.49266140e-02f, -7.72066880e-04f, 7.18971491e-02f, 1.26947016e-02f, 1.53142020e-01f,
  9.18752775e-02f, 3.76427807e-02f, 1.89140931e-01f, 1.26748189e-01f, 8.39421898e-02f, 1.19916439e-01f, 5.13450010e-03f, -9.27651227e-02f, -4.18389812e-02f, 1.29512891e-01f,
  4.35392484e-02f, 1.71324074e-01f, -7.11051887e-03f, 2.24887982e-01f, -1.65717840e-01f, 2.55282700e-01f, 1.69666827e-01f, -1.72059536e-01f, 1.59354478e-01f, -2.68447578e-01f,
  2.44682223e-01f, -2.92150229e-01f, -1.63550094e-01f, 4.56315279e-02f, 3.06455437e-02f, -1.16932690e-01f, -6.00657575e-02f, -5.47876880e-02f, -1.13453316e-02f, 1.74416527e-01f,
  -9.68380049e-02f, 2.44570300e-02f, -3.57480347e-01f, -2.51604497e-01f, 1.97997063e-01f, 1.35461628e-01f, 1.17959604e-01f, 2.45687887e-01f, -3.07329625e-01f, -2.70904273e-01f,
  -4.51717675e-01f, -3.47308889e-02f, 1.81009829e-01f, -7.05773979e-02f, -8.49823803e-02f, -6.62667081e-02f, 7.84970745e-02f, 4.57661450e-01f, 1.22584179e-01f, 1.95683613e-01f,
  2.41723657e-02f, 4.41759446e-04f, 1.35993868e-01f, 2.55224884e-01f, -3.17315102e-01f, -5.63002974e-02f, 1.58537954e-01f, 1.01346210e-01f, -1.41775444e-01f, 2.92470664e-01f,
  2.75065035e-01f, -1.42366648e-01f, 3.16376358e-01f, 9.48149189e-02f, 1.26640841e-01f, 1.23248249e-01f, 8.46406594e-02f, -1.03646368e-01f, 9.76636857e-02f, 9.43104848e-02f,
  9.49865878e-02f, 1.85844421e-01f, 1.17041856e-01f, 7.13051064e-04f, 8.33709538e-03f, -4.68097739e-02f, 1.24420896e-02f, -1.75097555e-01f, 1.72014654e-01f, -1.65967143e-03f,
  1.85021296e-01f, 4.05615449e-01f, 5.82646094e-02f, 3.33376050e-01f, 3.97714693e-03f, 2.41940208e-02f, 1.56179890e-02f, -5.90808094e-02f, 8.15635473e-02f, 1.65559649e-01f,
  -1.31808475e-01f, -8.49646628e-02f, -4.83429357e-02f, -3.16001594e-01f, 1.31178558e-01f, 2.36272775e-02f, 6.40029088e-02f, 2.77051508e-01f, -2.74443291e-02f, -7.51519427e-02f,
  -1.38785630e-01f, -1.81071177e-01f, 8.36910605e-02f, 5.13702273e-01f, 2.00357705e-01f, 2.24813987e-02f, -5.20076454e-02f, 2.29196995e-01f, 4.38670188e-01f, -4.53361943e-02f,
  -1.48048744e-01f, -3.97414535e-01f, 3.24436128e-01f, -9.01037734e-03f, 2.39349559e-01f, 3.11047018e-01f, 1.72728412e-02f, -9.26886424e-02f, 4.62812573e-01f, -5.11729196e-02f,
  2.04271629e-01f, 4.30892222e-02f, 1.20451607e-01f, 1.24092266e-01f, 3.08833182e-01f, 5.49859107e-02f, 2.01023951e-01f, 2.39305764e-01f, -2.17443542e-03f, 2.32780054e-01f,
  2.70262092e-01f, 5.04931808e-02f, 2.54385740e-01f, 2.65987813e-01f, 1.73646510e-01f, 7.26815611e-02f, 2.64241189e-01f, 2.10615829e-01f, 1.75716028e-01f, 2.58685678e-01f,
  2.43701041e-02f, 1.97915614e-01f, 1.35858774e-01f, 8.55906978e-02f, 3.10707420e-01f, 1.54221728e-01f, -1.93267509e-01f, -1.71841368e-01f, -5.09146228e-02f, 4.86606658e-02f,
  -3.23406875e-01f, 5.94149902e-03f, -2.79202908e-01f, -5.35974562e-01f, -6.43002316e-02f, 2.44856402e-01f, 1.74747869e-01f, 2.25591674e-01f, 3.57080698e-02f, -3.99605632e-02f,
  -1.05814025e-01f, 3.17981839e-01f, 1.46751493e-01f, -1.48143098e-01f, 2.24882379e-01f, 2.36035183e-01f, 2.09688306e-01f, 1.91958621e-01f, -2.22594991e-01f, 9.71944481e-02f,
  2.67192751e-01f, -1.21909954e-01f, 9.70290452e-02f, 2.29982987e-01f, 1.74719408e-01f, 1.99291572e-01f, 2.27852598e-01f, -2.02871487e-01f, 4.90474887e-02f, 1.03987373e-01f,
  1.39752859e-02f, 4.38550711e-01f, -6.02122955e-02f, -2.71098971e-01f, 7.73920864e-02f, 2.07015142e-01f, -2.11705878e-01f, 4.06940728e-02f, 2.11563855e-01f, 1.80084124e-01f,
  1.30589768e-01f, 1.50619239e-01f, 1.22663572e-01f, 1.78271830e-01f, 7.94663876e-02f, 1.00359112e-01f, 2.93453056e-02f, 1.82260007e-01f, 2.13986591e-01f, 7.39185512e-02f,
  3.56422573e-01f, 1.83764741e-01f, 1.83950830e-02f, -1.79904550e-01f, -1.08436421e-01f, -1.46245593e-02f, 9.31182206e-02f, -1.33646369e-01f, 2.17506677e-01f, 1.29269913e-01f,
  -1.59551144e-01f, 2.61079460e-01f, 2.28431195e-01f, 1.21742368e-01f, 8.14431831e-02f, 2.32719444e-02f, -3.05126876e-01f, -5.88403177e-03f, -1.72619790e-01f, -5.14840074e-02f,
  -1.96736604e-01f, -2.52952427e-01f, 1.00227907e-01f, 2.91044891e-01f, 9.78349373e-02f, 2.83856809e-01f, 3.64011526e-01f, 4.56265844e-02f, -7.80089051e-02f, 1.48396105e-01f,
  -6.73802271e-02f, 4.88449246e-01f, -3.92743573e-02f, 3.51678073e-01f, 2.96780527e-01f, -2.10967854e-01f, 9.42137986e-02f, 6.38134107e-02f, 2.37646058e-01f, 8.21070373e-02f,
  2.15797737e-01f, 4.34729531e-02f, -1.16046757e-01f, 1.57230571e-01f, -5.31371236e-02f, 1.33106664e-01f, 4.17390019e-01f, 6.35101348e-02f, 2.16202646e-01f, 1.88029349e-01f,
  2.00768709e-01f, 2.17857882e-01f, -2.71730591e-02f, 3.76735687e-01f, 1.56901404e-01f, 1.35485366e-01f, -6.57028183e-02f, 1.66205093e-01f, -1.06283039e-01f, 3.52638751e-01f,
  6.50740713e-02f, 8.71973634e-02f, 1.54759780e-01f, 1.50568947e-01f, -1.20768650e-02f, 7.66941383e-02f, 9.46837962e-02f, 7.13223293e-02f, 2.22035348e-01f, 1.47361472e-01f,
  2.07686946e-01f, 8.89122784e-02f, 1.67326510e-01f, -3.52243364e-01f, 2.79666454e-01f, -4.41279858e-02f, -3.78729641e-01f, 2.86696963e-02f, -2.11064350e-02f, 5.49488552e-02f,
  9.58463103e-02f, 1.12015739e-01f, -3.33523631e-01f, -2.83191744e-02f, 1.76431105e-01f, -7.81128928e-02f, 2.51627434e-02f, 6.06014915e-02f, 1.30768329e-01f, 3.04361954e-02f,
  -3.32891643e-02f, -1.57510057e-01f, 1.55131951e-01f, 1.07799023e-01f, -2.72651523e-01f, -7.57806152e-02f, -9.21254009e-02f, -1.64489165e-01f, -9.80602726e-02f, 6.89630657e-02f,
  1.57332391e-01f, 2.61317134e-01f, 7.86548555e-02f, 4.50778082e-02f, -7.54289376e-03f, -1.87020395e-02f, -9.92903635e-02f, -8.24595392e-02f, 3.84617239e-01f, -2.73651868e-01f,
  -7.97919706e-02f, 1.36206448e-01f, 2.41088167e-01f, -4.22543772e-02f, 2.15202078e-01f, 7.79035538e-02f, 2.38456100e-01f, 2.16437727e-01f, 1.02505200e-01f, 1.57694072e-01f,
  -3.09631042e-02f, 1.34812683e-01f, 4.84178327e-02f, 3.58675644e-02f, -6.32846430e-02f, 1.29520759e-01f, 2.48821244e-01f, 2.37932652e-01f, -8.72139819e-03f, 1.45838425e-01f,
  2.33567730e-01f, 2.51591980e-01f, 3.10660303e-01f, 2.41710871e-01f, 1.50579304e-01f, 1.28521144e-01f, 3.16519216e-02f, 2.26742074e-01f, -2.58647978e-01f, -1.15252696e-01f,
  -9.86973494e-02f, -3.68427932e-02f, -1.03006333e-01f, 1.46994904e-01f, 2.61335112e-02f, -2.26297066e-01f, 2.20394731e-01f, 2.55399793e-01f, -1.46469578e-01f, 1.90448657e-01f,
  -4.23739478e-02f, -2.14587614e-01f, 5.64844683e-02f, -9.97053757e-02f, -3.45515579e-01f, 2.62609184e-01f, 6.90411485e-04f, -1.76481992e-01f, 5.00728011e-01f, -2.36354396e-01f,
  2.31201842e-01f, -3.03398848e-01f, -1.49114564e-01f, 2.93626994e-01f, 3.02903563e-01f, 1.08063687e-02f, -2.09262267e-01f, -5.19084334e-02f, 1.27564400e-01f, 1.47070915e-01f,
  3.93101931e-01f, 3.43283117e-01f, -8.35476965e-02f, 9.09043252e-02f, 8.59759226e-02f, 5.04617617e-02f, 2.45608464e-01f, 2.00820968e-01f, -1.01229303e-01f, 6.61592484e-02f,
  6.34357780e-02f, 2.04072356e-01f, 9.21629369e-02f, 1.28853381e-01f, 1.78240791e-01f, 2.20451698e-01f, -1.38155282e-01f, 7.07722604e-02f, -4.51828130e-02f, -4.90494519e-02f,
  -1.04404099e-01f, 2.12100953e-01f, 1.60573080e-01f, 1.75470203e-01f, 1.48814291e-01f, 5.28092645e-02f, 1.53637484e-01f, -1.74824402e-01f, 2.02953583e-03f, -1.61213920e-01f,
  1.45937145e-01f, 1.41893953e-01f, 1.04949206e-01f, 2.18957201e-01f, -3.17972720e-01f, 2.77442127e-01f, -2.52640396e-01f, 5.37032138e-05f, 2.19156340e-01f, 1.98696315e-01f,
  -4.08406794e-01f, -2.04694226e-01f, 1.62545115e-01f, -1.36372790e-01f, 3.15516472e-01f, 3.03984284e-01f, 1.25910684e-01f, 3.16891581e-01f, 5.17160594e-02f, -2.72375554e-01f,
  2.82618534e-02f, -1.20972559e-01f, 2.61141419e-01f, 4.19509292e-01f, 1.63204044e-01f, -8.32843408e-02f, -2.83253696e-02f, 2.17931718e-01f, 3.32191467e-01f, 3.33990753e-01f,
  -1.05029322e-01f, -1.48272350e-01f, -1.39521778e-01f, 2.42872119e-01f, 5.36319464e-02f, -1.27683505e-01f, 1.10974617e-01f, -2.23049507e-01f, 9.86241996e-02f, 2.76878238e-01f,
  8.78909510e-03f, 1.22748718e-01f, 2.92605013e-01f, 1.94540203e-01f, 4.77295630e-02f, -3.97128388e-02f, 1.37456760e-01f, -4.24933098e-02f, -8.75203833e-02f, 1.51879564e-01f,
  4.45057712e-02f, 1.22377731e-01f, 1.02327220e-01f, -5.17026521e-02f, -3.76509316e-02f, 9.21556503e-02f, 2.06597015e-01f, 1.20653450e-01f, 1.66005641e-01f, 1.76035259e-02f,
  1.95889205e-01f, -1.18238933e-01f, 9.26023200e-02f, 1.18778773e-01f, 1.38896048e-01f, -2.14564994e-01f, 2.43657697e-02f, 2.12773576e-01f, -8.47199708e-02f, -8.94252118e-03f,
  -1.41176239e-01f, 2.73738682e-01f, 5.39146811e-02f, 3.00868243e-01f, 2.03979701e-01f, -4.88836989e-02f, 1.86806247e-01f, -7.08720461e-02f, 1.77064955e-01f, 1.78444952e-01f,
  -2.99538255e-01f, 3.54458131e-02f, -2.19715402e-01f, -3.19056571e-01f, 2.55332381e-01f, -2.27427378e-01f, 1.39016181e-01f, -2.63346761e-01f, -2.59457350e-01f, -1.16089426e-01f,
  -2.18158752e-01f, 1.39632851e-01f, 3.55878472e-01f, 1.91719010e-02f, -1.99078679e-01f, 1.67063862e-01f, -2.29194120e-01f, 2.57889122e-01f, -1.58945080e-02f, -1.02618359e-01f,
  2.06871986e-01f, 2.65150100e-01f, 1.12375326e-01f, 3.87225837e-01f, 2.84563065e-01f, -5.19440621e-02f, 1.38145208e-01f, 3.43507141e-01f, 2.45050788e-01f, 1.90797344e-01f,
  -7.70045370e-02f, 1.52336866e-01f, 3.09496731e-01f, 2.75674254e-01f, 1.04383580e-01f, 1.44065276e-01f, 2.64074266e-01f, 2.51987755e-01f, 1.11415036e-01f, 2.31832862e-01f,
  9.15028825e-02f, 1.25250190e-01f, 1.39308318e-01f, 1.38166487e-01f, 1.21352211e-01f, 1.87298164e-01f, 3.35522979e-01f, 1.80506423e-01f, -2.81480271e-02f, 1.17397502e-01f,
  -1.12718932e-01f, -1.61859378e-01f, 6.91111609e-02f, 9.11334604e-02f, 2.23361462e-01f, -1.46274418e-01f, -1.63770497e-01f, 2.95241475e-01f, -4.63125817e-02f, 1.43848896e-01f,
  -6.57837316e-02f, -2.92917877e-01f, -1.88336015e-01f, -3.97843957e-01f, 2.21076086e-01f, -2.64492184e-01f, -2.67928272e-01f, 3.11168283e-01f, -3.55244726e-01f, -3.28687280e-01f,
  -2.49166623e-01f, -1.37366623e-01f, 4.94977474e-01f, 1.58926755e-01f, 4.49543670e-02f, 8.67082551e-03f, -1.43500537e-01f, -2.20222726e-01f, 2.68839657e-01f, -2.90816054e-02f,
  3.02979797e-01f, 1.10893220e-01f, 1.51249275e-01f, 3.57433170e-01f, -1.41698256e-01f, 5.12460843e-02f, 2.75849372e-01f, -2.98763603e-01f, 1.49592627e-02f, -1.10640235e-01f,
  1.50069848e-01f, 4.22953069e-02f, -5.66561818e-02f, 2.04196274e-02f, 2.87561882e-02f, -8.30748230e-02f, 1.36667460e-01f, 1.17448755e-02f, 1.07002936e-01f, -3.94078493e-02f,
  2.59586889e-02f, 2.18006194e-01f, 1.50745094e-01f, 1.52316377e-01f, -1.43636316e-01f, 1.90483350e-02f, 1.32591188e-01f, 1.42581627e-01f, 5.90243861e-02f, 1.04458489e-01f,
  2.16478705e-01f, 1.87800497e-01f, -2.42385536e-01f, 6.08952455e-02f, -3.94707978e-01f, 1.42714053e-01f, 8.61605182e-02f, -3.14450711e-01f, 3.46893042e-01f, 2.31231675e-01f,
  3.23843285e-02f, 1.34427279e-01f, 3.07524681e-01f, 4.78432029e-01f, -2.64087111e-01f, 2.12231874e-01f, -1.53848365e-01f, -4.16214913e-01f, -9.63653810e-03f, -9.26851481e-02f,
  -3.02945524e-01f, 3.48125100e-01f, 1.50430545e-01f, -2.66127557e-01f, 2.25569084e-01f, -1.18883379e-01f, 2.41741046e-01f, -3.59924555e-01f, -1.90002099e-01f, -1.24092557e-01f,
  -6.25265092e-02f, -1.49560288e-01f, -1.35600165e-01f, -1.97548062e-01f, 1.95269167e-01f, -8.21284056e-02f, 5.04215732e-02f, 4.51243103e-01f, -2.89710522e-01f, 1.66095868e-02f,
  -1.00499801e-01f, 3.03884625e-01f, -2.48159468e-02f, 1.00006908e-01f, 2.01586828e-01f, -4.78155203e-02f, 2.87693422e-02f, -1.97276026e-02f, 1.51307315e-01f, 1.30274490e-01f,
  3.25289033e-02f, 1.50415525e-01f, 1.06531642e-01f, 2.26836637e-01f, 1.20618872e-01f, 2.78560460e-01f, 2.66723275e-01f, 6.17487580e-02f, 2.66618639e-01f, 3.77127081e-02f,
  2.24274695e-01f, 2.30530649e-01f, 9.61243063e-02f, 3.62253338e-02f, 1.68343812e-01f, 3.04866284e-01f, 1.94924742e-01f, 1.43004999e-01f, -2.01644704e-01f, -2.24303663e-01f,
  2.20273226e-01f, -1.53508171e-01f, -3.13161224e-01f, 1.01013027e-01f, -1.65624797e-01f, -2.03036696e-01f, 3.48877639e-01f, 2.93126732e-01f, 1.02826208e-01f, 2.52084792e-01f,
  -2.17109621e-01f, 9.43029299e-02f, -2.77751058e-01f, 8.13223887e-03f, -5.72168361e-03f, 2.24240590e-02f, 2.75336146e-01f, 1.27186537e-01f, 4.09148574e-01f, -6.40495494e-02f,
  -1.85692549e-01f, 4.47668694e-02f, 2.35465363e-01f, -3.00224960e-01f, 1.07289150e-01f, -1.21127360e-01f, 9.55056623e-02f, 3.59767765e-01f, 2.60463715e-01f, -9.87711996e-02f,
  -3.25382352e-02f, 2.38267809e-01f, -1.19177558e-01f, 4.55473512e-01f, -4.58922498e-02f, -1.16903037e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -1.60216796e-03f, 3.16418082e-01f, 1.07025757e-01f, 1.38503425e-02f, 2.09917277e-01f, 2.12380171e-01f, 2.58463174e-01f, 1.96899340e-01f, 1.49378195e-01f, 4.83451709e-02f,
  2.38005713e-01f, 1.46374136e-01f, 8.59381258e-02f, 2.59671867e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -7.46133924e-03f, 4.48583718e-03f, -3.47559452e-02f, -6.83713108e-02f, -1.79601178e-01f, -2.07267791e-01f, -1.54367596e-01f, -3.55362222e-02f, -1.36376739e-01f, -1.47412673e-01f,
  4.89082634e-02f, -2.51398608e-02f, -1.15882933e-01f, -1.26601830e-01f, 4.23220620e-02f, 8.40962827e-02f, -3.06738308e-03f, -1.03944302e-01f, 8.67608562e-02f, 3.12005822e-02f,
  1.03429995e-01f, 9.01352912e-02f, -1.61882848e-01f, 9.12952498e-02f, 4.24812734e-02f, -1.38686644e-02f, -4.97818701e-02f, -4.35808562e-02f, 2.90777683e-02f, 7.19572529e-02f,
  -1.38661534e-01f, 1.34232178e-01f, 1.68625917e-02f, -9.70977321e-02f, -4.63663377e-02f, 7.06895292e-02f, -2.15424329e-01f, -2.54872032e-02f, 1.53025374e-01f, -1.88490883e-01f,
  1.82243496e-01f, -9.60004777e-02f, -1.63685277e-01f, 6.52162656e-02f, -1.14337943e-01f, -1.33205265e-01f, -1.40391037e-01f, -2.23069519e-01f, -1.96984202e-01f, -1.86185136e-01f,
  1.55750498e-01f, -7.05492571e-02f, 9.36662778e-02f, -1.16462328e-01f, 4.28347811e-02f, -1.50555715e-01f, -7.12922364e-02f, -1.71044931e-01f, 1.39149085e-01f, 2.98784766e-02f,
  1.92466363e-01f, 6.81157559e-02f, 2.45246738e-01f, -1.77382082e-02f, -7.41574168e-02f, 1.49968132e-01f, 1.49467411e-02f, -4.88683246e-02f, 1.18659854e-01f, 8.51112679e-02f,
  1.79678604e-01f, 3.05599887e-02f, 3.43634039e-02f, -6.47977963e-02f, 1.45718664e-01f, -5.97245013e-03f, -1.35899961e-01f, -1.21451430e-01f, 3.84074613e-03f, 1.27881216e-02f,
  -9.40069482e-02f, 2.04024106e-01f, 1.15262702e-01f, 7.00928420e-02f, -6.92755058e-02f, 1.63542211e-01f, 5.70996627e-02f, 9.97495577e-02f, -1.24569677e-01f, -2.67923176e-02f,
  3.42981219e-02f, 1.88674092e-01f, 1.59438059e-01f, -1.81604046e-02f, -1.05232090e-01f, -5.69163635e-02f, 2.81573571e-02f, -1.29477903e-01f, 1.68855265e-01f, 1.16541736e-01f,
  -9.11715776e-02f, 7.75979161e-02f, 2.12104619e-01f, -9.91534535e-03f, -2.20950827e-01f, -3.94889861e-02f, -1.78660676e-01f, 2.91951862e-03f, -6.39754981e-02f, 6.30185381e-02f,
  1.53972208e-01f, 1.32110313e-01f, -5.24104275e-02f, 5.44666164e-02f, 6.02897070e-02f, 3.17247435e-02f, 3.88620012e-02f, 1.96671803e-02f, -2.49628678e-01f, 3.21417674e-02f,
  -8.51017535e-02f, -1.58284172e-01f, 1.30215466e-01f, -1.63896963e-01f, -1.78320184e-02f, -8.57794136e-02f, 1.26719475e-02f, 1.67281255e-01f, -1.11973402e-03f, 1.72533974e-01f,
  7.14071542e-02f, -1.06787287e-01f, -3.26752551e-02f, -1.50890321e-01f, 9.52209085e-02f, 8.80327076e-02f, -1.24038570e-01f, -3.72798070e-02f, 1.88912451e-01f, -6.92926496e-02f,
  -1.47280589e-01f, -7.26598278e-02f, -1.30562872e-01f, 1.38495520e-01f, 4.38663438e-02f, -6.56899363e-02f, 2.93589048e-02f, -1.33161783e-01f, 2.35657737e-01f, 1.05576605e-01f,
  9.86922681e-02f, 1.28593639e-01f, -6.17934316e-02f, 8.36139619e-02f, -1.96332917e-01f, 1.41314343e-01f, -2.27385148e-01f, -2.43872970e-01f, -9.08608958e-02f, 1.43255115e-01f,
  3.28762047e-02f, 6.95897341e-02f, 1.05061993e-01f, 1.95768569e-02f, 2.21730381e-01f, -3.06968033e-01f, 9.09468681e-02f, 1.82573259e-01f, -1.09026819e-01f, -2.24038437e-01f,
  -2.00189635e-01f, 4.01208401e-02f, 1.19080357e-01f, 1.53896764e-01f, -9.03534368e-02f, 9.33611020e-02f, 3.53070609e-02f, -1.61003858e-01f, 5.64126857e-02f, -7.68401623e-02f,
  -1.89183112e-02f, -7.91938379e-02f, -8.73993114e-02f, -2.91523933e-02f, 4.18077083e-03f, -4.86422889e-02f, 9.59503874e-02f, 5.96429370e-02f, 1.26443788e-01f, 1.49026170e-01f,
  -2.01762199e-01f, -1.00488700e-01f, -4.77019046e-03f, 8.40399822e-04f, -2.53553260e-02f, 6.46951795e-02f, -1.25270471e-01f, -1.30887911e-01f, 3.61336805e-02f, -1.07980341e-01f,
  -9.42599624e-02f, 4.54232283e-02f, 9.61050764e-02f, 8.20720419e-02f, 7.86559191e-03f, 2.28527971e-02f, 7.11701950e-03f, -4.05079387e-02f, -2.57246196e-02f, 3.74003849e-03f,
  3.87611538e-02f, -1.25794128e-01f, 7.83555582e-02f, -1.13176659e-01f, -4.77235438e-03f, 1.39449807e-02f, 2.79804338e-02f, -1.04182683e-01f, -7.28321895e-02f, -1.81139946e-01f,
  -1.47893697e-01f, -1.35236397e-01f, 1.67151570e-01f, -4.40592952e-02f, 1.92955300e-01f, 1.80516794e-01f, -9.27835628e-02f, -6.74934015e-02f, 2.70456821e-01f, 4.94629480e-02f,
  -4.84005101e-02f, 1.12647362e-01f, 3.11392229e-02f, -1.85197666e-01f, 7.73242787e-02f, 2.39024341e-01f, 2.45426610e-01f, -6.48898557e-02f, 5.07635586e-02f, 4.21370007e-02f,
  -5.50354496e-02f, -1.82259217e-01f, -2.95769032e-02f, 5.80527186e-02f, 3.56786586e-02f, 7.18826130e-02f, 3.24640498e-02f, -1.72052398e-01f, 1.11257978e-01f, 1.10956095e-02f,
  -1.54051289e-01f, 1.01452313e-01f, 1.65408984e-01f, 5.82279451e-03f, -2.13338733e-01f, -1.92646027e-01f, 1.32699504e-01f, -7.88850486e-02f, -7.27400631e-02f, 8.62461701e-02f,
  5.58532923e-02f, -1.09493867e-01f, 1.72888897e-02f, 8.71052872e-03f, -7.60747865e-02f, 1.26361057e-01f, 8.83731991e-02f, 9.84465182e-02f, 3.90319303e-02f, 9.93861910e-03f,
  4.18103971e-02f, 1.30870461e-01f, -3.93217243e-02f, -5.77538041e-03f, 1.29377740e-02f, -4.24926803e-02f, 4.99232560e-02f, 6.33925945e-02f, -1.50370121e-01f, -1.67858433e-02f,
  -6.86250776e-02f, 8.06643218e-02f, -7.22781643e-02f, 4.03033234e-02f, 5.44832908e-02f, 9.36130658e-02f, 6.86463639e-02f, -1.95711832e-02f, -1.08793572e-01f, -8.38780329e-02f,
  8.04172456e-02f, -4.76985015e-02f, -2.52653569e-01f, -2.45464504e-01f, -9.99065489e-02f, 8.44349787e-02f, 1.86832607e-01f, 6.86715618e-02f, 1.98155880e-01f, 4.16923016e-02f,
  -1.65983766e-01f, -2.33980134e-01f, -7.01524541e-02f, -1.38424814e-01f, -2.21877128e-01f, 6.09623790e-02f, 2.22571883e-02f, -5.95479868e-02f, -1.14645191e-01f, -1.53376073e-01f,
  1.10183537e-01f, 4.16711643e-02f, -1.37175480e-03f, -2.31159613e-01f, 3.29173394e-02f, 5.75489178e-03f, -8.49797130e-02f, 2.32274309e-01f, 1.13334544e-02f, 4.51852381e-02f,
  -2.90577821e-02f, -1.52821481e-01f, -1.13295190e-01f, -4.30045389e-02f, -5.70997670e-02f, -1.87734701e-02f, 7.51487166e-02f, -7.74763972e-02f, 1.32801104e-03f, -5.22890389e-02f,
  -1.88168120e-02f, 4.01035994e-02f, 5.01363054e-02f, 3.40555348e-02f, 1.92918219e-02f, -6.55589253e-02f, 2.06781417e-01f, -9.20984298e-02f, -1.87783539e-02f, 9.81464386e-02f,
  -6.53797090e-02f, -1.55514479e-01f, -2.04970688e-02f, 1.70170635e-01f, -1.22546867e-01f, 2.11812794e-01f, -4.03379090e-02f, -9.12975520e-02f, -8.32422078e-02f, 2.45488390e-01f,
  1.03230756e-02f, -2.17634603e-01f, -1.69988107e-02f, -1.50545120e-01f, -3.02978046e-02f, -3.86181287e-02f, 7.75431888e-03f, -3.09547484e-01f, 6.40653074e-02f, 1.70189247e-01f,
  1.01609878e-01f, -1.98138550e-01f, -1.54809028e-01f, -1.10561818e-01f, -4.19914387e-02f, -1.41705975e-01f, -1.39730394e-01f, 9.12836567e-03f, -2.49702767e-01f, 7.90085196e-02f,
  2.52616912e-01f, 5.15640713e-02f, -6.53614253e-02f, -2.47503594e-02f, 1.30760655e-01f, 1.24378793e-01f, 2.30092146e-02f, -2.64517695e-01f, 4.98085953e-02f, -2.42273256e-01f,
  6.05962873e-02f, -3.92165594e-03f, -1.06072553e-01f, 1.22864701e-01f, 1.53501794e-01f, -1.51805848e-01f, 1.23133119e-02f, 1.26539141e-01f, 8.02616179e-02f, 8.97325650e-02f,
  -2.42426153e-02f, 6.54204702e-03f, -8.77615958e-02f, 1.66923434e-01f, 5.37771434e-02f, 9.52631980e-02f, 6.66119382e-02f, -1.13084175e-01f, -9.34600532e-02f, 1.82089016e-01f,
  7.52800107e-02f, -1.59851924e-01f, -1.21456705e-01f, 9.09775030e-03f, -6.07719757e-02f, 1.01095371e-01f, -9.40962285e-02f, 5.64922094e-02f, 9.68823880e-02f, 1.80858329e-01f,
  -2.19765767e-01f, -1.21514387e-01f, 5.98099530e-02f, 2.42207631e-01f, 1.87305585e-01f, -1.01140752e-01f, -1.97396502e-01f, -9.02996361e-02f, 7.56183863e-02f, 1.11754760e-01f,
  9.05347895e-03f, -7.53437579e-02f, -1.68623060e-01f, -5.65427989e-02f, 1.74689204e-01f, 6.94329515e-02f, 1.45867318e-01f, -2.31208801e-01f, -6.87711313e-02f, -8.70480761e-02f,
  -1.61311239e-01f, -2.42779721e-02f, -2.03978680e-02f, -1.04421272e-03f, -2.19817292e-02f, 1.02413893e-01f, -2.03327015e-01f, 7.25451559e-02f, 1.12712085e-01f, 3.17038447e-02f,
  6.50591105e-02f, 5.39314933e-03f, -7.66987801e-02f, -2.11416818e-02f, -4.74304110e-02f, 1.97248086e-01f, 1.20734207e-01f, 1.25460014e-01f, -4.84996326e-02f, 3.92873511e-02f,
  -4.02882211e-02f, 2.34293975e-02f, -1.76336080e-01f, -1.41939772e-02f, -4.76132929e-02f, -1.24861421e-02f, 5.11744283e-02f, 2.37113964e-02f, -3.04388329e-02f, -1.41745865e-01f,
  -6.57688677e-02f, -6.09906800e-02f, 2.75270846e-02f, -6.31809235e-02f, 9.72390026e-02f, -3.51662226e-02f, 1.03497714e-01f, 1.19325042e-01f, 4.17039776e-03f, 1.97235774e-02f,
  -5.32090515e-02f, 7.97515735e-02f, 7.50201270e-02f, -1.73974186e-01f, 8.84464830e-02f, 1.62319407e-01f, -2.86096614e-02f, 9.86348242e-02f, -1.66430339e-01f, 1.27943039e-01f,
  9.59096178e-02f, 1.00765444e-01f, -1.24991633e-01f, -2.86217816e-02f, -1.35249242e-01f, -5.93834855e-02f, 1.25994086e-01f, -1.56996250e-01f, 1.40734613e-02f, -4.82460335e-02f,
  -2.21423328e-01f, 5.22484966e-02f, -1.62931383e-01f, 2.22322211e-01f, 2.96283662e-02f, -2.35858813e-01f, -8.91628787e-02f, -1.41146094e-01f, 2.90342811e-02f, -1.72968313e-01f,
  5.09805530e-02f, -2.39835642e-02f, -1.13872580e-01f, 4.62518074e-02f, -2.26285130e-01f, 1.78614780e-02f, 1.03784189e-01f, 8.81850272e-02f, 1.83102116e-01f, -8.80891904e-02f,
  1.74608126e-01f, -9.97421890e-02f, 6.74318224e-02f, -7.22779408e-02f, -1.01295384e-02f, 7.85718486e-02f, 2.38201674e-02f, -8.97812769e-02f, 5.63140325e-02f, -5.62718660e-02f,
  -1.58556372e-01f, 4.50252369e-02f, -1.79524310e-02f, 1.02529518e-01f, 1.29075572e-01f, 4.13675181e-04f, -1.26583368e-01f, 1.32231340e-01f, -1.54934013e-02f, -1.76191796e-02f,
  -1.16974279e-01f, -1.44666269e-01f, 7.24174008e-02f, -8.64597037e-02f, 1.06104143e-01f, -3.15881111e-02f, -9.83328968e-02f, 1.00293517e-01f, -2.54193574e-01f, -1.63675874e-01f,
  -2.18445987e-01f, -2.16338143e-01f, 1.08361952e-01f, 9.29862782e-02f, -2.27619838e-02f, 1.47960082e-01f, -5.66260144e-02f, -1.82446644e-01f, 1.44428581e-01f, 1.31745607e-01f,
  -1.32791087e-01f, 9.03848410e-02f, -5.03405407e-02f, -1.98765799e-01f, 9.86020416e-02f, 1.12944636e-02f, 3.18501413e-01f, -2.35644609e-01f, 1.42991468e-01f, 6.27914146e-02f,
  -1.17096215e-01f, -1.94792509e-01f, 2.20004484e-01f, 1.81741696e-02f, 1.89848632e-01f, 1.92139044e-01f, -6.80202395e-02f, -2.52463743e-02f, 1.47192657e-01f, 1.45027310e-01f,
  -1.85058236e-01f, -1.93911809e-02f, -7.93903098e-02f, 3.83305699e-02f, -3.27558041e-01f, -3.41259949e-02f, -1.55894116e-01f, 2.31908318e-02f, -2.41910107e-02f, -6.28236309e-02f,
  1.76729988e-02f, -1.08418152e-01f, 1.01022273e-02f, -5.61461002e-02f, -2.17407569e-03f, -5.01115397e-02f, -3.44489366e-02f, -6.05642982e-02f, -4.83705662e-02f, 1.64299458e-01f,
  -6.69290945e-02f, 1.34726852e-01f, -1.14022866e-02f, -7.85120949e-03f, 6.56987578e-02f, -3.96296196e-02f, 3.21096443e-02f, 5.67621319e-03f, 4.57576476e-02f, 6.78779855e-02f,
  4.06029411e-02f, -2.37674713e-01f, -1.60985708e-01f, 1.10233597e-01f, -6.74222335e-02f, -2.83865303e-01f, 7.46686757e-02f, 1.34610042e-01f, -1.39917314e-01f, 2.35017121e-01f,
  1.52030857e-02f, 1.48959965e-01f, 1.39415309e-01f, -5.92579581e-02f, -1.92623109e-01f, 8.05341974e-02f, -9.10293218e-03f, 3.81323025e-02f, 1.22957665e-03f, 1.36615500e-01f,
  3.11495304e-01f, -3.63890193e-02f, 6.87401146e-02f, 1.79406274e-02f, -4.47097979e-02f, 3.68611515e-02f, -2.69699156e-01f, 1.37920439e-01f, -6.89857751e-02f, -1.93445951e-01f,
  6.51282072e-02f, -1.50301456e-01f, 6.24557994e-02f, 1.25637755e-01f, -9.09838080e-02f, 1.87415510e-01f, 9.52301919e-02f, 6.57518134e-02f, -9.70607176e-02f, -2.32995465e-01f,
  5.78976572e-02f, -1.42312169e-01f, -1.74673013e-02f, -2.18833275e-02f, 1.00330628e-01f, -2.92081743e-01f, 2.21170689e-04f, 9.85106081e-03f, 5.43354303e-02f, 1.25971705e-01f,
  1.19505182e-01f, -3.77996862e-02f, 6.15564659e-02f, -1.83240280e-01f, 1.47144005e-01f, 1.38871282e-01f, 1.04818352e-01f, -1.21048942e-01f, -7.21105933e-02f, -1.44389108e-01f,
  1.53020501e-01f, 7.22196028e-02f, -5.55036403e-02f, 7.50401691e-02f, -1.40728891e-01f, -1.19883642e-01f, -1.16594039e-01f, 1.21544585e-01f, -1.55373186e-01f, 1.25464629e-02f,
  1.67645831e-02f, -3.63799557e-02f, 1.25846863e-01f, 1.28772005e-01f, -7.17844591e-02f, -1.83676127e-02f, 1.61415607e-01f, -3.39222223e-01f, -8.83669965e-03f, 2.64898419e-01f,
  1.94446117e-01f, -1.70546249e-01f, -2.73820877e-01f, 1.19525000e-01f, -1.26544401e-01f, -1.03654899e-01f, -2.08876789e-01f, -9.41287577e-02f, -1.68356955e-01f, -3.21034119e-02f,
  7.98112229e-02f, -6.74638152e-02f, -2.02662379e-01f, -1.27358615e-01f, 8.29062462e-02f, -7.37738460e-02f, -1.07191525e-01f, -5.64231835e-02f, -6.50526863e-03f, -1.01845220e-01f,
  1.19608589e-01f, 1.84933156e-01f, -2.66969353e-02f, 9.46363881e-02f, -1.49388751e-02f, -1.10611841e-01f, 1.32227853e-01f, 1.28089249e-01f, -2.28964984e-02f, 1.48908868e-01f,
  -4.40665521e-02f, 2.56054960e-02f, 2.05749795e-02f, -5.46324812e-02f, -2.01222122e-01f, 2.14217212e-02f, -2.57353578e-02f, 2.49797061e-01f, -6.84073120e-02f, -6.39420152e-02f,
  3.97549197e-02f, 1.35398239e-01f, 2.78701186e-02f, 8.68208706e-02f, -4.98791896e-02f, 6.74425140e-02f, -5.53741194e-02f, -7.08413869e-02f, 1.51246578e-01f, -2.25099608e-01f,
  6.48621097e-02f, -5.95778190e-02f, 2.48377666e-01f, -2.69933224e-01f, 1.82371080e-01f, 2.01888636e-01f, 1.67744458e-02f, -3.89781669e-02f, -5.18715344e-02f, 4.66298610e-02f,
  7.27738515e-02f, 2.97315955e-01f, -8.67963135e-02f, -1.21055707e-01f, 1.91926036e-03f, -8.62355232e-02f, 1.10217207e-03f, 1.88780278e-01f, 2.31240004e-01f, 1.26977041e-01f,
  -3.14361490e-02f, 5.06001636e-02f, -1.13896597e-02f, -1.03959225e-01f, -1.38776869e-01f, -1.30174324e-01f, 1.68454260e-01f, 4.87140752e-02f, 6.59625381e-02f, -5.28920181e-02f,
  2.88405150e-01f, 7.65748769e-02f, -1.89556971e-01f, 2.46937677e-01f, -5.79366609e-02f, -1.84130222e-02f, -2.60955393e-02f, -1.16871782e-01f, -8.13417584e-02f, 2.01820552e-01f,
  -1.51351407e-01f, 6.65647686e-02f, -1.68280244e-01f, 7.73206353e-02f, 7.82159269e-02f, -6.66851252e-02f, -5.15440144e-02f, -1.01838380e-01f, -2.46742684e-02f, -3.84482481e-02f,
  4.61882874e-02f, 3.12873647e-02f, -1.21746436e-02f, -4.90231477e-02f, -1.41620725e-01f, 2.25549173e-02f, -1.46569954e-02f, 4.16677594e-02f, 7.00752735e-02f, -6.17485493e-02f,
  2.32723150e-02f, -1.57003105e-01f, 3.61064188e-02f, -1.40521154e-01f, -4.23258729e-02f, -4.06294279e-02f, -3.90750468e-02f, 3.16506252e-02f, -1.82163507e-01f, 1.75716460e-01f,
  1.61570325e-01f, 9.17648226e-02f, 2.04187389e-02f, -2.27526575e-01f, 7.81129673e-02f, 3.70223224e-01f, 1.79623589e-01f, -1.10476337e-01f, -1.41917720e-01f, -2.11090773e-01f,
  -2.28240117e-01f, -1.38373272e-02f, -1.32455423e-01f, 4.39235307e-02f, 2.64162242e-01f, -3.37441191e-02f, -8.60250834e-03f, 2.12711934e-02f, -5.50466627e-02f, -9.53520238e-02f,
  8.50979537e-02f, 1.70155436e-01f, -1.17889605e-01f, 1.12415597e-01f, -3.10343094e-02f, 5.82810529e-02f, -6.79555610e-02f, 8.98867100e-02f, 1.65390685e-01f, -9.35031101e-02f,
  -1.26607865e-01f, 7.05076084e-02f, -1.17529541e-01f, 1.12814307e-01f, -7.77064413e-02f, 6.39434457e-02f, -2.82732472e-02f, 4.31063119e-03f, 1.08776420e-01f, 2.58037616e-02f,
  7.63654411e-02f, -9.24054459e-02f, -3.43919620e-02f, 4.46830690e-02f, -5.53145353e-03f, 5.47573604e-02f, -6.67913705e-02f, -1.32910699e-01f, 2.68898415e-03f, -8.83143246e-02f,
  -3.40656098e-03f, 6.55629262e-02f, 1.17347874e-01f, 6.23832131e-03f, -2.95135416e-02f, 1.24117371e-03f, -6.71547428e-02f, 4.79241200e-02f, 1.36145934e-01f, 1.16568469e-01f,
  -7.17063323e-02f, -1.12924889e-01f, -1.30053148e-01f, 1.41931683e-01f, 4.44354489e-02f, 1.52286053e-01f, -9.53801647e-02f, 1.41127352e-02f, 2.01022774e-01f, -1.04096599e-01f,
  -1.35765567e-01f, 6.87541440e-02f, -1.74488083e-01f, 1.83224782e-01f, -1.76254809e-02f, -1.96150113e-02f, 2.99157858e-01f, 2.81541079e-01f, 1.60690069e-01f, 2.28305876e-01f,
  1.63505822e-01f, 6.15215413e-02f, 1.27932638e-01f, 1.18611008e-01f, 8.18430856e-02f, 5.01135997e-02f, -6.73657209e-02f, -1.11247607e-01f, -1.91317156e-01f, 2.58935243e-01f,
  -4.87748198e-02f, 1.98865682e-02f, 7.55342841e-02f, -6.53185621e-02f, -2.25676987e-02f, 6.44781487e-03f, -8.85257348e-02f, 7.77229085e-04f, -1.68426409e-01f, 6.40214309e-02f,
  -3.32601927e-02f, -8.64820257e-02f, 4.79658768e-02f, 1.10659994e-01f, -5.32650054e-02f, -1.00265145e-01f, -1.12933233e-01f, -1.07068546e-01f, -2.26460248e-02f, 7.64977485e-02f,
  -1.42891392e-01f, 9.11564827e-02f, -9.32446420e-02f, 6.06791787e-02f, -4.03097048e-02f, 1.17910244e-01f, 1.87767260e-02f, -8.27314183e-02f, 8.41177925e-02f, -1.25128999e-01f,
  -8.16728473e-02f, 7.48035982e-02f, 1.62210912e-01f, -1.01878799e-01f, -7.80003294e-02f, -9.77358432e-04f, 1.09463814e-03f, 1.63055677e-02f, 1.11851595e-01f, -2.09039673e-02f,
  -1.93537459e-01f, -2.79974222e-01f, -7.47412965e-02f, 2.46774077e-01f, 3.71728241e-02f, -6.73238784e-02f, -7.06124455e-02f, -4.68368419e-02f, -1.29427165e-01f, 1.13826379e-01f,
  1.24829322e-01f, 6.82170466e-02f, 1.58525392e-01f, -1.06175669e-01f, 5.46024181e-02f, -1.34055823e-01f, 3.58543321e-02f, -1.81408629e-01f, 6.32488579e-02f, 1.03087865e-01f,
  5.68060465e-02f, -6.38445392e-02f, -1.55897379e-01f, 7.54931569e-02f, -6.78148940e-02f, 3.29618417e-02f, 1.48584902e-01f, -7.07845539e-02f, 1.71713587e-02f, -2.03279089e-02f,
  7.29276007e-03f, 5.85308820e-02f, -1.31379187e-01f, 1.33067355e-01f, -2.40503848e-02f, -1.38494283e-01f, -5.28795943e-02f, 6.40983507e-02f, -1.72064062e-02f, -1.27468873e-02f,
  -4.94521596e-02f, 7.97468796e-02f, -1.51754960e-01f, -6.29546773e-03f, 2.52947398e-02f, -8.39959085e-02f, 1.79657638e-02f, -1.61766469e-01f, 3.46295792e-03f, 4.38508466e-02f,
  1.18613737e-02f, 5.93092740e-02f, -1.07193999e-01f, 6.13290854e-02f, -1.44901313e-02f, -1.56681225e-01f, 1.36236623e-01f, 1.34731844e-01f, -5.63283786e-02f, 1.46859419e-02f,
  -8.08805972e-03f, 1.03275768e-01f, -2.17651606e-01f, 1.09242667e-02f, 1.62637815e-01f, 2.02153087e-01f, 1.44697651e-01f, -7.30263516e-02f, -3.60855013e-02f, -1.82732016e-01f,
  9.44954157e-02f, 8.57409090e-02f, -4.19270694e-02f, -1.44749761e-01f, -8.50697886e-03f, 1.50359780e-01f, 6.23372290e-03f, 6.67103976e-02f, 5.48803024e-02f, 2.32726499e-01f,
  3.89763229e-02f, 1.14425600e-01f, -3.10569972e-01f, -6.05289675e-02f, 2.65134200e-02f, 1.78683430e-01f, 1.46358743e-01f, -7.45836869e-02f, -1.14850879e-01f, 8.98006484e-02f,
  -4.01279368e-02f, -1.59694731e-01f, -2.06740379e-01f, 1.43524900e-01f, -2.78251357e-02f, 1.49951845e-01f, 7.49234930e-02f, 1.09178405e-02f, 8.88154954e-02f, 4.99514528e-02f,
  4.45047207e-02f, 1.58518590e-02f, 9.10245329e-02f, -1.76146682e-02f, -7.84319267e-02f, 2.92379260e-02f, 1.10759698e-01f, 3.06735579e-02f, -8.61398950e-02f, 4.62043891e-03f,
  -1.34962246e-01f, 1.34482592e-01f, -7.92635530e-02f, -1.42090648e-01f, 1.06174253e-01f, -3.02281119e-02f, 1.20880395e-01f, -4.82770652e-02f, -1.54813088e-03f, 3.80381010e-02f,
  1.16989210e-01f, -9.98301134e-02f, -2.31965668e-02f, 6.44702464e-02f, -1.12560928e-01f, 5.26084704e-03f, -4.68552019e-03f, 1.12815358e-01f, 5.43917269e-02f, -1.98673591e-01f,
  2.25223631e-01f, 3.06512833e-01f, -1.96012408e-01f, -1.30602583e-01f, 9.46904570e-02f, -9.38648805e-02f, 2.76677907e-02f, -8.57864693e-02f, 1.63423672e-01f, 1.00180857e-01f,
  1.63702980e-01f, 2.05210268e-01f, 1.94814041e-01f, 1.20499738e-01f, -8.14563185e-02f, 1.00144528e-01f, 7.74741918e-02f, 2.57563859e-01f, -1.42823741e-01f, -6.05368428e-02f,
  -7.07357749e-02f, 2.75769401e-02f, -9.35281292e-02f, -2.71267369e-02f, 1.25333279e-01f, 4.53990959e-02f, -1.70362607e-01f, 7.13020489e-02f, -1.46507040e-01f, -8.92865136e-02f,
  -2.20508352e-02f, 2.38721818e-02f, -1.76680088e-02f, -1.18936412e-01f, -1.05453566e-01f, -1.07895538e-01f, -3.24913934e-02f, 7.35961050e-02f, 6.17852360e-02f, 1.02802087e-02f,
  -3.67098749e-02f, -2.77011961e-01f, 2.29681116e-02f, -6.94059068e-04f, 1.46759525e-01f, -1.62866861e-01f, 3.54738161e-02f, -2.25309450e-02f, -3.02414894e-02f, -1.75185688e-02f,
  -6.14767335e-02f, 1.37493595e-01f, -1.72081739e-01f, 1.63449541e-01f, 3.82312387e-02f, -5.83127327e-03f, 1.98944658e-01f, 2.78306574e-01f, -1.10438578e-02f, -3.03395391e-02f,
  -3.58229578e-02f, 1.16109654e-01f, 6.56978635e-04f, -3.80985774e-02f, 4.84181195e-02f, -2.79149860e-01f, 1.41231045e-01f, 1.21528376e-02f, 4.03054059e-02f, 9.62769240e-02f,
  2.63722334e-02f, -6.75503686e-02f, -3.24205190e-01f, 1.47695497e-01f, -1.40740752e-01f, -4.93318141e-02f, -1.35504037e-01f, 1.38838127e-01f, -1.44423112e-01f, -1.33216277e-01f,
  -1.30627349e-01f, -1.13849625e-01f, 5.66654131e-02f, 1.19330026e-01f, -1.97264284e-01f, -1.20041408e-01f, 5.67124374e-02f, -2.17719421e-01f, -9.09624845e-02f, 1.29871413e-01f,
  2.42793802e-02f, 1.09042302e-02f, 5.90682700e-02f, -6.70579746e-02f, -1.07713342e-01f, 9.90983471e-02f, 3.66437808e-02f, 2.69194413e-03f, -1.30604133e-01f, -1.51741192e-01f,
  3.65964137e-02f, -1.08381927e-01f, 3.58353592e-02f, 1.12842508e-02f, 6.19922169e-02f, -7.22204819e-02f, 3.54069471e-02f, 3.05851698e-02f, 1.98837034e-02f, -8.76756981e-02f,
  -8.41967463e-02f, -5.06173708e-02f, 3.08208559e-02f, -1.16678894e-01f, -1.04097158e-01f, 8.20411928e-03f, 9.74097252e-02f, 8.03943574e-02f, 3.62948589e-02f, -8.25690925e-02f,
  3.70043367e-02f, 1.56378672e-02f, -6.01744018e-02f, 9.78471413e-02f, 2.43257526e-02f, -1.59148172e-01f, -6.92961551e-03f, -2.51886398e-01f, -8.26574042e-02f, 2.77910322e-01f,
  1.48117721e-01f, -2.33754478e-02f, 1.48665318e-02f, -2.95784116e-01f, -9.44287777e-02f, -9.74746943e-02f, -1.55803174e-01f, -1.78948775e-01f, 1.56076595e-01f, -1.61335245e-01f,
  -7.50520676e-02f, -6.36460185e-02f, 1.94065139e-01f, -1.95215344e-01f, 2.04129189e-01f, 9.25597772e-02f, 5.40725514e-02f, 7.17956200e-02f, -2.92284023e-02f, -1.19553201e-01f,
  -5.77080511e-02f, -3.23419794e-02f, 1.39976233e-01f, -1.00811176e-01f, -4.17044573e-03f, 6.31332919e-02f, 8.17816257e-02f, 2.67496780e-02f, 1.93411306e-01f, 7.55661726e-03f,
  1.33456647e-01f, -3.00377328e-02f, -7.68142641e-02f, -8.72846809e-04f, -1.00676762e-03f, 1.65548071e-01f, -2.98594479e-02f, -7.97812939e-02f, 8.05789828e-02f, -7.12300986e-02f,
  -9.30685401e-02f, -7.79856592e-02f, 2.43365243e-02f, 8.45507905e-02f, 7.52190053e-02f, 1.54210344e-01f, 1.21039562e-02f, -3.54483202e-02f, -4.22245748e-02f, -8.29899982e-02f,
  5.52420430e-02f, 1.25870243e-01f, -1.03528447e-01f, -9.71091986e-02f, -7.63999149e-02f, -6.51630089e-02f, 5.85341677e-02f, -1.68205753e-01f, -1.92987949e-01f, 3.19189904e-03f,
  1.30263358e-01f, 1.56270593e-01f, 1.50739342e-01f, -1.29994735e-01f, -1.49444461e-01f, 2.06361398e-01f, 1.61910914e-02f, -1.08807832e-02f, 9.39395651e-02f, -1.63929358e-01f,
  1.64800704e-01f, 7.48138279e-02f, 6.19819984e-02f, 2.40048647e-01f, 8.07302892e-02f, 1.61718279e-01f, -5.80723174e-02f, 1.09372519e-01f, -1.42074719e-01f, -1.19870380e-02f,
  2.88068652e-02f, 6.11342639e-02f, 1.96222782e-01f, -2.16832384e-02f, 3.49470112e-03f, -1.98224992e-01f, -5.75755388e-02f, 2.98587028e-02f, -6.05893284e-02f, -9.53698680e-02f,
  1.28366217e-01f, -1.73192956e-02f, 5.55409938e-02f, -1.56693775e-02f, 9.50834602e-02f, 8.08341354e-02f, 4.49805371e-02f, -1.36396393e-01f, -7.09459651e-03f, -5.24505712e-02f,
  1.82970762e-01f, -3.19610573e-02f, -1.34725720e-01f, -2.27939487e-01f, 5.34125902e-02f, 1.32586434e-01f, -1.48370853e-02f, -1.54188529e-01f, -1.23787016e-01f, -1.73669770e-01f,
  1.19046429e-02f, -5.64132184e-02f, 5.06485067e-02f, 7.83541277e-02f, -6.80975318e-02f, 7.34919384e-02f, -1.52981773e-01f, 1.56715631e-01f, 7.62681141e-02f, 1.50289461e-01f,
  -1.02481969e-01f, -4.51086834e-02f, -3.27162771e-03f, 2.32346337e-02f, 1.89545542e-01f, -1.63728014e-01f, -1.51998371e-01f, -4.69309725e-02f, 1.51665643e-01f, -2.58232537e-03f,
  1.37785286e-01f, -2.25600228e-01f, -2.74333209e-01f, -1.42142355e-01f, -2.77523935e-01f, -1.31824747e-01f, -8.58916566e-02f, 1.05566829e-01f, -7.05832243e-02f, -5.66559732e-02f,
  1.33582056e-01f, -1.07725233e-01f, 1.21011809e-01f, -1.35158539e-01f, -1.02605380e-01f, 3.10717262e-02f, -1.10581703e-01f, -2.34354854e-01f, -5.38349105e-03f, -7.64342844e-02f,
  1.33794561e-01f, 1.62627280e-01f, 2.54391640e-01f, 1.56667069e-01f, 5.21462336e-02f, -2.57981420e-01f, 1.16790287e-01f, 8.70977566e-02f, -1.73377581e-02f, 1.11295618e-01f,
  2.59229951e-02f, -2.84862425e-02f, -8.50792974e-02f, 1.00286469e-01f, -5.91311865e-02f, 5.43337725e-02f, -1.36347562e-02f, -1.79956853e-02f, -1.38665633e-02f, -2.74764076e-02f,
  -7.51281083e-02f, 1.35750743e-02f, 1.12191867e-02f, -1.87138654e-02f, 2.70142872e-02f, -4.93119918e-02f, -1.83915317e-01f, 1.38472497e-01f, 4.20359857e-02f, 2.74742730e-02f,
  -1.79536626e-01f, -4.67979573e-02f, 2.57330030e-01f, 2.13121641e-02f, 3.43735795e-03f, -9.56537127e-02f, -1.11324124e-01f, -6.17477112e-02f, 1.30922735e-01f, 1.32408962e-01f,
  -1.49466157e-01f, -3.01189005e-01f, 7.06256926e-02f, 2.79038083e-02f, 1.27240673e-01f, -1.23589365e-02f, 2.49882236e-01f, -1.23337932e-01f, -1.89112902e-01f, -2.08901957e-01f,
  -1.46900803e-01f, -9.89585295e-02f, -1.74624130e-01f, -6.70101270e-02f, -9.29129794e-02f, -5.67820370e-02f, -1.42301485e-01f, -2.12736782e-02f, 1.36204973e-01f, 1.84596166e-01f,
  7.22223222e-02f, -1.81462482e-01f, -1.14424927e-02f, 5.72075509e-02f, -1.77292347e-01f, -4.23691384e-02f, 6.25969395e-02f, 4.90571633e-02f, -9.65142809e-03f, 4.59990315e-02f,
  -2.27767378e-02f, 6.78838715e-02f, 7.19283894e-03f, 3.10824607e-02f, 3.56193930e-02f, 5.34740128e-02f, -3.67786773e-02f, -1.65975630e-01f, -1.45280644e-01f, -1.39621153e-01f,
  4.31174301e-02f, 8.55537280e-02f, -1.01761945e-01f, 6.09081471e-03f, -2.24429324e-01f, -5.42855002e-02f, -4.38798405e-02f, 2.13304926e-02f, -3.94122154e-02f, -2.95603462e-02f,
  6.47211596e-02f, -8.59882757e-02f, 1.89663574e-01f, 1.20675017e-03f, 4.08236869e-02f, -6.18564822e-02f, -3.20620447e-01f, -2.24495813e-01f, 1.38818339e-01f, 2.76771300e-02f,
  -1.21070027e-01f, -1.09535500e-01f, 1.06891543e-01f, -2.33406618e-01f, -1.13302365e-01f, 3.08555901e-01f, -1.99450344e-01f, -1.47878408e-01f, 1.91124454e-01f, 1.98486567e-01f,
  1.65731981e-01f, 1.04704779e-02f, 9.32133719e-02f, 3.69487815e-02f, -3.51139568e-02f, 1.42959014e-01f, 1.07558116e-01f, 6.12908863e-02f, 4.78248820e-02f, 8.32930952e-02f,
  1.98340356e-01f, 3.17897797e-02f, -2.33593881e-01f, 8.31914973e-03f, -1.40673919e-02f, 1.94406122e-01f, -1.22745723e-01f, -2.91852914e-02f, -1.64003193e-01f, 1.03961341e-01f,
  -5.46950437e-02f, -7.45004416e-02f, 2.06920300e-02f, -4.73411866e-02f, 8.56219754e-02f, -1.08949296e-01f, 1.07951388e-01f, 1.16267711e-01f, -2.91408673e-02f, -5.75569756e-02f,
  -8.35526660e-02f, 3.69732380e-02f, 6.98124757e-03f, -9.94812772e-02f, 3.51397954e-02f, 2.19715945e-02f, -8.37038234e-02f, 7.23871067e-02f, -1.81979850e-01f, 3.82158123e-02f,
  -7.77727440e-02f, -1.51011348e-01f, 6.00655600e-02f, -7.11444393e-02f, 3.86422942e-03f, -6.93271682e-02f, -6.32333383e-02f, -2.26766001e-02f, -1.96011245e-01f, -1.26850188e-01f,
  8.52907524e-02f, -1.59305736e-01f, 6.27116710e-02f, 1.93672534e-02f, -1.53735384e-01f, -2.35351305e-02f, 2.10902691e-01f, 7.42168501e-02f, 6.69074580e-02f, 1.65202305e-01f,
  -2.32299671e-01f, 3.22035514e-02f, 2.82405287e-01f, -3.19613479e-02f, 2.03543887e-01f, -6.48230240e-02f, 7.38984197e-02f, -2.65741855e-01f, -1.60790235e-01f, -4.65560555e-02f,
  1.12339079e-01f, 4.95810620e-02f, 9.58074704e-02f, -7.93325529e-02f, 2.43418664e-02f, -1.09506398e-01f, -8.96093696e-02f, -1.88098717e-02f, 1.94671944e-01f, 7.62492418e-02f,
  -2.18562067e-01f, -4.03746590e-02f, -7.18560889e-02f, 1.60973489e-01f, -5.07661551e-02f, -6.26018411e-03f, -1.00822732e-01f, 1.93377212e-01f, -1.85231790e-02f, 1.57909971e-02f,
  1.10668167e-01f, 2.19371200e-01f, -6.21083155e-02f, 1.64159879e-01f, -1.00709319e-01f, -6.57716841e-02f, -5.69590814e-02f, -7.18491897e-02f, -5.17575964e-02f, 9.91993025e-02f,
  1.46287337e-01f, -1.04596972e-01f, 4.73808683e-02f, 1.78464383e-01f, 4.87992465e-02f, 1.12265475e-01f, -6.63147494e-02f, -4.51974832e-02f, 7.14469608e-03f, -4.44380753e-02f,
  1.27703637e-01f, 1.19656995e-01f, 1.81142941e-01f, 4.82529700e-02f, 2.16983706e-01f, 7.33937323e-02f, 7.22299218e-02f, 5.79127111e-02f, 1.03552222e-01f, -2.20000908e-01f,
  -8.94404482e-03f, -1.29882872e-01f, -1.17761999e-01f, 2.52995938e-01f, -6.21463358e-02f, 5.37826400e-03f, -2.41812825e-01f, 2.44523242e-01f, 6.64621070e-02f, 1.31155759e-01f,
  -5.22322655e-02f, 2.31220677e-01f, 9.59258303e-02f, -1.19988963e-01f, 3.07859816e-02f, -2.64045428e-02f, -1.23902798e-01f, -3.31300944e-02f, 3.21682811e-01f, -1.12194121e-01f,
  -1.16950274e-01f, -3.11087593e-02f, -1.14824153e-01f, 1.51057929e-01f, 4.33118381e-02f, -3.31194997e-02f, 2.03856807e-02f, -1.38246119e-01f, 2.29128405e-01f, -7.16260402e-03f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  2.01511398e-01f, 3.70473154e-02f, 2.71551497e-03f, 1.88666895e-01f, 1.52113497e-01f, 7.05726892e-02f, 2.14857489e-01f, 1.95687473e-01f, 2.20308751e-01f, 2.87852198e-01f,
  3.61077279e-01f, 1.06791863e-02f, 1.25819251e-01f, 1.62646025e-01f, 1.40707819e-02f, -1.19010732e-01f, 2.60581169e-02f, -1.95226185e-02f, 1.62622601e-01f, -1.27774894e-01f,
  -9.45580006e-02f, 3.17441039e-02f, 2.85853863e-01f, -8.59128907e-02f, 2.09521055e-01f, 2.81905234e-01f, 2.12222710e-01f, -3.12128931e-01f, -2.85375714e-01f, 7.51513988e-02f,
  -4.81261499e-02f, -1.33518443e-01f, 2.93668032e-01f, 1.34966135e-01f, -1.36255741e-01f, -1.73199505e-01f, 2.75545537e-01f, -2.31029198e-01f, -4.59276259e-01f, 4.61512536e-01f,
  -2.82422006e-01f, 4.62373614e-01f, 2.50009596e-01f, -1.59242705e-01f, 4.54340547e-01f, 2.98514605e-01f, 2.38445655e-01f, 3.84329975e-01f, 4.17301506e-01f, 3.91382426e-01f,
  4.66639966e-01f, 7.08715975e-01f, 1.14937082e-01f, 2.61140168e-01f, -1.73695609e-01f, 2.22404912e-01f, -3.24779600e-01f, 4.24486965e-01f, 1.88592210e-01f, 1.69868633e-01f,
  1.28226578e-01f, 2.12293163e-01f, -3.08380753e-01f, -1.45621132e-02f, -6.34651026e-03f, -1.47519216e-01f, 2.05890369e-02f, 1.50184408e-01f, 1.43916756e-01f, -9.52182710e-02f,
  -1.14876993e-01f, 6.18117899e-02f, 4.12658453e-02f, 1.66898876e-01f, 3.39107700e-02f, 4.04625051e-02f, 5.48930094e-02f, -7.92330503e-02f, 1.80846006e-01f, -3.70934814e-01f,
  5.64977005e-02f, 3.10880281e-02f, 7.76677579e-02f, 1.23420894e-01f, -2.48809740e-01f, 1.56816076e-02f, -2.07510814e-02f, 1.96069136e-01f, -9.13034019e-04f, -4.28907573e-01f,
  1.08079918e-01f, 3.35884765e-02f, 3.90117764e-01f, -1.79377988e-01f, -2.68757880e-01f, 2.61416622e-02f, -5.84613346e-02f, 3.92407551e-02f, 3.61995608e-01f, 3.67082119e-01f,
  1.57492280e-01f, -2.24824637e-01f, 3.10018212e-01f, -7.22991303e-02f, -1.00918517e-01f, -3.20047289e-01f, -2.97976226e-01f, -9.47552994e-02f, -1.11359112e-01f, 1.67607486e-01f,
  3.77613958e-03f, -8.62866044e-02f, -2.95296490e-01f, 2.54657239e-01f, -3.53092492e-01f, 1.07383588e-02f, -4.88910288e-01f, 3.67126092e-02f, 4.21407372e-01f, 4.05180752e-01f,
  5.17601609e-01f, -8.74277726e-02f, 2.10546367e-02f, 3.80445480e-01f, 9.50316712e-02f, -2.06652269e-01f, -2.69102544e-01f, 3.46351534e-01f, 1.06593911e-02f, -1.39626145e-01f,
  1.28550634e-01f, 4.45708521e-02f, 2.77221471e-01f, 6.70262054e-02f, 3.44288610e-02f, 2.00290233e-01f, 1.39499620e-01f, 6.74885362e-02f, 4.70505804e-02f, -1.29600003e-01f,
  -9.56510603e-02f, 4.59662452e-02f, 1.41385704e-01f, -4.55685377e-01f, 1.11910157e-01f, 1.05619170e-01f, 3.11803102e-01f, 1.33673549e-01f, -3.16678315e-01f, 1.24192037e-01f,
  3.85074645e-01f, 2.52714604e-01f, 5.60963415e-02f, -5.33898056e-01f, 2.14230910e-01f, 4.06358480e-01f, 4.18558687e-01f, -1.28857523e-01f, -2.96615690e-01f, 1.18409038e-01f,
  1.84440270e-01f, 2.83483565e-01f, 6.05342463e-02f, 4.19797003e-01f, 5.17775357e-01f, -1.50222033e-01f, 3.60401452e-01f, -6.00379445e-02f, -1.95636526e-01f, -3.53062660e-01f,
  -2.71127254e-01f, 8.32379237e-02f, 3.10633361e-01f, 4.61018533e-01f, 2.19795644e-01f, -1.74812339e-02f, 6.47295117e-02f, 8.02593008e-02f, -4.48035210e-01f, 4.65954542e-02f,
  -1.95717499e-01f, -1.29674062e-01f, 2.69610971e-01f, 3.51196945e-01f, 4.63051558e-01f, 1.85146168e-01f, -3.10141854e-02f, 3.85847509e-01f, 3.67134660e-01f, -3.26093286e-01f,
  -4.19644177e-01f, 1.58191666e-01f, 1.10453650e-01f, 2.41310850e-01f, 1.94838017e-01f, 2.34519988e-01f, 2.13967785e-01f, 3.16156805e-01f, 1.53916076e-01f, 2.63633698e-01f,
  1.37892976e-01f, 2.54008114e-01f, 1.71439927e-02f, 2.11875007e-01f, 7.82057345e-02f, 9.26647186e-02f, 2.13164553e-01f, 1.89788938e-01f, 6.47797883e-02f, -1.92353618e-03f,
  3.21339160e-01f, 9.64462757e-02f, 1.85933366e-01f, 3.03943425e-01f, 2.69177824e-01f, -1.07323982e-01f, 1.20247230e-01f, 2.74251282e-01f, 3.65460962e-01f, 1.50566874e-02f,
  1.09201834e-01f, 3.21553379e-01f, -5.14984541e-02f, -3.72232161e-02f, 2.54432499e-01f, 1.50540769e-01f, -1.67667389e-01f, -2.83175439e-01f, 2.36739889e-01f, 2.52134502e-02f,
  -5.07736094e-02f, 1.75855935e-01f, -3.89178723e-01f, 3.25570256e-01f, -1.29550532e-01f, -1.93090677e-01f, 6.23742025e-03f, 4.58578914e-01f, 2.38558426e-01f, 3.08297187e-01f,
  3.88118804e-01f, 1.69106662e-01f, -2.25637898e-01f, 2.99971551e-01f, 4.37252492e-01f, 8.66649225e-02f, -4.67705458e-01f, 1.69241242e-02f, -2.67886162e-01f, 5.14871716e-01f,
  2.65204698e-01f, -7.80822858e-02f, 3.28366876e-01f, 1.92043036e-01f, 2.93508559e-01f, 1.82590306e-01f, 2.04620004e-01f, 2.08797410e-01f, 1.83423489e-01f, 1.71072707e-01f,
  -1.38222647e-03f, 8.23804438e-02f, 4.36791778e-01f, 1.54985666e-01f, 1.14637978e-01f, 1.35361895e-01f, 1.38341472e-01f, 1.04414344e-01f, -1.41830876e-01f, -1.77339166e-01f,
  5.25322445e-02f, 1.80943638e-01f, 1.25650242e-01f, 2.01323792e-01f, 2.32855320e-01f, 1.07048213e-01f, 3.50495130e-01f, 1.93951979e-01f, 4.45962042e-01f, 2.86435038e-01f,
  -8.75745714e-02f, 1.11259401e-01f, 2.19951831e-02f, 3.66697073e-01f, -6.90509379e-02f, 1.08667485e-01f, -3.22636813e-01f, -8.05336609e-02f, 4.16031629e-01f, -1.66163772e-01f,
  -1.22580104e-01f, -2.89560199e-01f, -7.84780979e-02f, -1.14407361e-01f, 3.58331680e-01f, -5.06785735e-02f, -2.72614390e-01f, -4.05379087e-01f, -3.36828142e-01f, 2.43674025e-01f,
  -1.84177071e-01f, 3.26145977e-01f, 3.64443868e-01f, -1.12606749e-01f, 1.90536544e-01f, 8.69752243e-02f, 4.00449187e-01f, 9.08054225e-03f, 4.56786275e-01f, 2.40971640e-01f,
  -1.28986701e-01f, 2.17357486e-01f, -9.57318842e-02f, 8.65005478e-02f, 4.36762393e-01f, 1.01035379e-01f, 2.14551091e-01f, -1.08251452e-01f, 1.98649578e-02f, 3.60046625e-01f,
  1.29287213e-01f, 1.77450508e-01f, 8.79255384e-02f, 2.05209419e-01f, -1.73420757e-02f, 1.35341257e-01f, 1.72581896e-01f, -9.76036936e-02f, 2.18682006e-01f, 1.47613864e-02f,
  -1.20784357e-01f, 2.38951907e-01f, 1.83933884e-01f, 1.08843379e-01f, 1.14510931e-01f, 1.03580520e-01f, 1.26139196e-02f, 1.78023204e-01f, 6.44404069e-02f, -5.73726967e-02f,
  1.51147738e-01f, -6.29092902e-02f, -8.13439861e-02f, -1.11282431e-01f, 2.83149064e-01f, 1.01469323e-01f, 8.25950354e-02f, 1.41618983e-03f, 3.37351084e-01f, 3.31872165e-01f,
  -1.96213514e-01f, -6.61974400e-02f, 1.37080532e-02f, -2.81740367e-01f, -3.61174420e-02f, -3.13061774e-01f, -1.83859259e-01f, 4.33752328e-01f, 2.80733764e-01f, -3.92260730e-01f,
  -1.23606160e-01f, -2.77093142e-01f, -9.90135223e-02f, -1.28779083e-01f, -3.29055339e-01f, 9.43346098e-02f, 2.91367859e-01f, -3.98618996e-01f, -2.02039406e-01f, 8.20344761e-02f,
  -1.23286970e-01f, -2.65789658e-01f, 5.41664481e-01f, 1.72516719e-01f, -8.88491198e-02f, 1.40998885e-01f, 1.45918960e-02f, 2.01400876e-01f, 3.37786973e-01f, 1.90912411e-01f,
  3.10727626e-01f, 7.76620582e-02f, 4.12955880e-01f, 3.15424830e-01f, -2.10247952e-02f, 1.21735841e-01f, -2.46851444e-01f, 4.90576662e-02f, -3.29579674e-02f, -2.31469244e-01f,
  -9.08785462e-02f, -7.79936649e-03f, 7.83123672e-02f, -6.93485066e-02f, -2.05435380e-02f, 2.11655144e-02f, -4.10614498e-02f, 4.31561694e-02f, -3.19997035e-02f, 1.67336345e-01f,
  1.78647220e-01f, -3.47794257e-02f, 1.57388318e-02f, -9.56137925e-02f, 2.66868640e-02f, 1.82086930e-01f, 1.25918061e-01f, -2.20508389e-02f, 3.74181271e-02f, -1.21498987e-01f,
  -1.97968647e-01f, 8.18072110e-02f, -6.09185686e-03f, -3.42651367e-01f, -3.09512824e-01f, 3.92056495e-01f, 1.30922392e-01f, 2.20702529e-01f, -3.49889785e-01f, 2.32132941e-01f,
  3.22273105e-01f, -1.31828249e-01f, 1.35003477e-01f, 1.56859398e-01f, -8.68825912e-02f, -3.31788033e-01f, -2.15924188e-01f, 4.42701727e-01f, 3.44927549e-01f, 1.90705076e-01f,
  3.44675183e-02f, -3.86039257e-01f, -2.18294188e-01f, -3.67642581e-01f, 4.62773293e-01f, -1.78021520e-01f, -5.02779260e-02f, -1.19242601e-01f, 5.24195015e-01f, -2.06242606e-01f,
  -2.54107118e-02f, 4.04224515e-01f, 2.72637159e-01f, 5.05323529e-01f, 3.30304742e-01f, 1.03248902e-01f, -5.17751575e-01f, -3.02398384e-01f, 6.48811609e-02f, -6.13481514e-02f,
  -8.69951695e-02f, 3.65639827e-03f, -2.97848899e-02f, 9.52433795e-02f, 1.29543856e-01f, 2.94322729e-01f, 1.15735047e-01f, 2.87660092e-01f, 3.40011045e-02f, -2.73842812e-02f,
  1.93721771e-01f, 1.57040343e-01f, 2.82806695e-01f, -3.76627177e-01f, 2.30367184e-01f, 1.00058749e-01f, 2.66200364e-01f, 3.12272102e-01f, -2.87109196e-01f, 8.37884918e-02f,
  -1.77308038e-01f, 2.23175034e-01f, 2.21103996e-01f, 1.61895782e-01f, 4.20974672e-01f, 7.02787936e-02f, 5.19947827e-01f, 2.85116702e-01f, -3.49532664e-02f, -2.85261631e-01f,
  -5.13186492e-02f, -5.39160907e-01f, -1.92634296e-02f, 4.93179291e-01f, -6.71423376e-02f, -4.84815717e-01f, -8.35989136e-03f, 2.05491260e-01f, -1.96873561e-01f, 7.12099612e-01f,
  1.40943363e-01f, -8.89931545e-02f, -1.86216459e-01f, 3.90776008e-01f, -1.24560855e-01f, 1.27384439e-01f, -1.77224264e-01f, 3.65445942e-01f, -1.95959434e-01f, 1.32203177e-01f,
  -2.87322998e-01f, -3.00727159e-01f, 3.01375806e-01f, 3.63563657e-01f, -1.83109701e-01f, 2.32264534e-01f, 2.65361667e-01f, 2.84883410e-01f, -1.33441329e-01f, 1.72311105e-02f,
  3.33639592e-01f, 2.00863004e-01f, 1.29816085e-01f, 1.45117536e-01f, 2.22648650e-01f, 3.31813060e-02f, 1.18400715e-01f, 6.29541501e-02f, 1.28870625e-02f, 6.94943964e-02f,
  1.69184059e-01f, 2.63783842e-01f, 1.60157919e-01f, 1.10312752e-01f, -2.05373555e-01f, 1.15639299e-01f, 9.68078002e-02f, 1.51398942e-01f, 9.53809097e-02f, -4.85194363e-02f,
  1.81511536e-01f, 4.14617360e-02f, 1.34417221e-01f, 3.56080830e-01f, 7.81396287e-04f, 3.62599492e-01f, 2.90600449e-01f, 9.65996608e-02f, -3.27554762e-01f, 2.09643677e-01f,
  -8.12886097e-03f, -4.55277383e-01f, 2.41501525e-01f, -1.26126170e-01f, -3.77758741e-01f, 1.32526979e-01f, -7.87408724e-02f, 4.59089756e-01f, 1.40806898e-01f, -2.47420445e-01f,
  1.77439395e-02f, 3.94429624e-01f, 4.02295113e-01f, 1.69627398e-01f, 2.68811554e-01f, 8.03203732e-02f, 3.51843119e-01f, -2.42408156e-01f, -3.56156498e-01f, -2.18740672e-01f,
  -1.41944498e-01f, -3.05949003e-01f, 4.47862208e-01f, 2.38380358e-01f, -2.67158300e-01f, -4.09875751e-01f, 3.98236156e-01f, 7.74040744e-02f, 4.32875603e-01f, 3.44436578e-02f,
  4.02352959e-01f, 2.08680376e-01f, -1.24740638e-01f, 5.63735366e-01f, 2.87883788e-01f, -1.60759091e-01f, -1.18156575e-01f, 5.90033829e-03f, -1.11297637e-01f, -1.21714585e-01f,
  -2.60503560e-01f, -1.43887877e-01f, 8.24004784e-03f, 1.51824862e-01f, 4.94469590e-02f, 1.90291867e-01f, -6.23121718e-03f, 1.44107521e-01f, -1.00731440e-02f, 1.23276934e-02f,
  1.23854078e-01f, 2.66880363e-01f, 1.51291057e-01f, -7.35217482e-02f, 9.73012820e-02f, 2.08592460e-01f, 1.52415767e-01f, 1.51559770e-01f, -1.72830835e-01f, 1.13042094e-01f,
  2.89237887e-01f, 2.35513955e-01f, -6.39791042e-02f, 2.90552396e-02f, 4.46320415e-01f, 2.71017998e-01f, 8.70822221e-02f, 1.10536940e-01f, -2.83882469e-02f, -3.04754287e-01f,
  -4.14034456e-01f, 7.26558734e-03f, -6.74360573e-01f, -2.58347273e-01f, 2.55668759e-01f, -2.69216001e-01f, 3.13625559e-02f, -2.28441111e-03f, 4.41559069e-02f, 1.96255088e-01f,
  -3.98867607e-01f, -1.45472258e-01f, -3.03525150e-01f, -6.31006479e-01f, -3.07035625e-01f, -3.73192728e-01f, 4.97393429e-01f, -2.87872285e-01f, 1.35632530e-01f, -2.68351614e-01f,
  3.39590669e-01f, -1.30290791e-01f, -1.07569012e-05f, -9.58140492e-02f, 5.95674574e-01f, 2.41929695e-01f, 1.92841753e-01f, 3.14361721e-01f, 7.06005752e-01f, 4.20328863e-02f,
  1.70079336e-01f, -3.54803242e-02f, 3.38471830e-01f, 5.83695918e-02f, 1.70795321e-01f, 2.10422263e-01f, 1.91170901e-01f, 7.72756562e-02f, 3.40953097e-02f, 1.04483120e-01f,
  1.15458392e-01f, 4.13946919e-02f, -1.22932076e-01f, 8.64050072e-03f, 1.04663141e-01f, -1.55112371e-01f, 8.95060971e-02f, 1.03637092e-01f, 1.40483081e-01f, -5.32002151e-02f,
  6.10705987e-02f, 1.78293556e-01f, 3.62660229e-01f, 1.66001081e-01f, -9.55847651e-03f, -5.41969299e-01f, -1.16174899e-01f, 4.02255267e-01f, 3.33709151e-01f, -4.17691857e-01f,
  -6.74584135e-02f, 1.34968013e-01f, 3.27603668e-02f, 4.88627732e-01f, 2.01080918e-01f, 2.20568359e-01f, 4.28351849e-01f, -1.36700809e-01f, 1.38870135e-01f, 3.06835204e-01f,
  -1.20207116e-01f, -4.62085843e-01f, -1.21811777e-01f, 3.39291245e-01f, 3.29480380e-01f, 2.02048406e-01f, -2.88055167e-02f, 1.45045802e-01f, 9.14590135e-02f, -2.77863711e-01f,
  -5.02022564e-01f, 1.53560176e-01f, -7.87010696e-03f, -2.34866917e-01f, 1.51289657e-01f, 2.23987952e-01f, 3.14049929e-01f, 2.05502480e-01f, -2.67173111e-01f, 3.18248242e-01f,
  1.64964482e-01f, 1.00531206e-01f, -3.48229885e-01f, 7.32711032e-02f, 8.13911706e-02f, 1.90463334e-01f, 2.47456029e-01f, 2.16451824e-01f, 1.75792351e-01f, 3.59548219e-02f,
  2.28285920e-02f, 2.91709788e-02f, 6.45591319e-02f, 3.65053236e-01f, 2.52280772e-01f, 2.79474825e-01f, 2.22467080e-01f, -3.36732343e-03f, 1.15315177e-01f, 3.01572502e-01f,
  4.44193231e-03f, 1.10029258e-01f, 2.49780208e-01f, -2.47386228e-02f, 3.21736544e-01f, 1.16892710e-01f, 1.13093359e-02f, 3.51057172e-01f, 6.87816069e-02f, 1.54891327e-01f,
  -3.67312819e-01f, -1.00698791e-01f, 3.20506692e-01f, 4.16241065e-02f, 2.91485995e-01f, -3.79610419e-01f, -5.14481664e-01f, 1.52742296e-01f, 3.82098913e-01f, 2.47537717e-01f,
  2.31817644e-02f, -3.89044791e-01f, 9.28643271e-02f, 2.66252398e-01f, 1.70486763e-01f, 4.12991096e-04f, 3.83637607e-01f, -2.95462042e-01f, 1.06128462e-01f, -3.91650259e-01f,
  -3.19752663e-01f, -1.13127362e-02f, -6.01922646e-02f, 9.88334119e-02f, -2.69341677e-01f, 2.78588533e-01f, -1.10191330e-01f, -1.73905715e-01f, 3.38456541e-01f, 3.42836857e-01f,
  5.66530526e-01f, -2.27995887e-01f, 2.56615818e-01f, -4.93396334e-02f, -4.19699311e-01f, 4.34793502e-01f, 2.35771701e-01f, 3.00366879e-01f, 2.15470046e-01f, 1.15246929e-01f,
  -3.75129506e-02f, 2.05640972e-01f, 8.45876783e-02f, 1.42077759e-01f, -6.68623298e-02f, -2.66059283e-02f, 1.24754488e-01f, 4.62151244e-02f, 4.23681773e-02f, 2.82493919e-01f,
  2.63325602e-01f, 6.01872541e-02f, 1.99796334e-01f, -2.13619117e-02f, 4.12033536e-02f, -6.92890882e-02f, 1.56918019e-01f, 1.89865634e-01f, 4.24729362e-02f, -2.10758194e-01f,
  9.06664804e-02f, -4.14607264e-02f, 6.39661625e-02f, 4.24475789e-01f, 9.72264633e-02f, -3.70592237e-01f, -1.27013132e-01f, 4.03190434e-01f, 1.46905452e-01f, -3.59349191e-01f,
  -6.22600131e-03f, -4.10138458e-01f, 4.35695685e-02f, -2.39777818e-01f, 4.17738631e-02f, -1.33089527e-01f, -1.87161639e-01f, 1.12088874e-01f, 4.86665592e-02f, 1.04684874e-01f,
  4.01153028e-01f, -4.86504257e-01f, -1.18727222e-01f, 7.91754946e-02f, 1.47911757e-01f, 1.96166456e-01f, 1.58252195e-01f, 5.22303581e-01f, 4.42828350e-02f, 3.29761028e-01f,
  -1.27970070e-01f, 3.64675492e-01f, -1.36354372e-01f, 5.36639214e-01f, 2.12417111e-01f, 8.66554305e-02f, 8.05088282e-02f, -3.02539706e-01f, -1.48778036e-01f, 1.41157091e-01f,
  -1.66942239e-01f, 4.63099390e-01f, 1.30864233e-01f, 2.83524275e-01f, -1.42480701e-01f, 1.38880774e-01f, 6.21711724e-02f, 2.18894944e-01f, -4.03192975e-02f, -3.54183209e-03f,
  1.30213588e-01f, -3.01232245e-02f, 1.89665452e-01f, 4.62714061e-02f, 1.23617671e-01f, -5.10136902e-01f, 8.12710375e-02f, 1.68981984e-01f, -1.09805189e-01f, 2.53099561e-01f,
  -4.77502756e-02f, -8.37778822e-02f, 3.50473732e-01f, 6.81874976e-02f, 1.13450550e-01f, 1.79174095e-01f, 3.63520384e-02f, 1.65270835e-01f, -2.59071290e-02f, 1.44457191e-01f,
  9.15703699e-02f, 3.49676549e-01f, -1.42892510e-01f, -1.96486875e-01f, -6.89041167e-02f, -2.26308316e-01f, 3.51619154e-01f, -3.29762727e-01f, -6.19142167e-02f, 9.40590575e-02f,
  2.77300864e-01f, -6.12366319e-01f, -2.15697885e-01f, -3.95477444e-01f, -2.34725967e-01f, -2.12430850e-01f, -3.65580589e-01f, 6.03913628e-02f, 2.37782732e-01f, -3.11405778e-01f,
  -2.42719799e-01f, 3.30821097e-01f, 3.33134905e-02f, -6.18621781e-02f, 2.24460021e-01f, 4.02165473e-01f, -3.80582631e-01f, 2.44894534e-01f, 1.16446957e-01f, -2.39359468e-01f,
  2.36303240e-01f, -2.21389532e-01f, 3.36253285e-01f, -8.07946250e-02f, 9.44356471e-02f, 5.05025148e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.84424128e-02f, 1.70940816e-01f, 9.03511569e-02f, 2.22315773e-01f, 4.45621684e-02f, 1.44192755e-01f, 2.45079413e-01f, 5.68169430e-02f, 1.32923827e-01f, 2.19086096e-01f,
  2.54568905e-02f, 1.66953504e-01f, 6.23672754e-02f, 2.48569041e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -7.73618743e-02f, 3.47018838e-02f, 6.73337877e-02f, 6.73072189e-02f, 5.62650077e-02f, -6.88312948e-02f, 9.91207808e-02f, -9.21274647e-02f, 1.48444653e-01f, -1.08070619e-01f,
  -5.92209399e-02f, 1.37848899e-01f, -1.80430904e-01f, 1.78697333e-01f, -1.30204767e-01f, 1.17268711e-02f, 1.69022337e-01f, -1.15999624e-01f, -2.51016200e-01f, -2.33915418e-01f,
  -5.84025830e-02f, -1.11790234e-02f, 7.17360899e-02f, 7.00765625e-02f, -7.89806098e-02f, 2.84780622e-01f, 1.77945554e-01f, -2.04771653e-01f, -2.22427294e-01f, -2.84250289e-01f,
  -2.20229894e-01f, -1.50945067e-01f, 2.89058417e-01f, -3.58568996e-01f, -1.70922175e-01f, -2.25501120e-01f, 2.72549123e-01f, 1.62195727e-01f, 1.06393108e-02f, 4.06751335e-01f,
  -9.30324420e-02f, 2.28390753e-01f, -2.93538153e-01f, 2.41916314e-01f, -2.43980423e-01f, 3.36450756e-01f, -3.15739781e-01f, 5.29591627e-02f, -1.93759918e-01f, -4.53226529e-02f,
  -3.10833871e-01f, -2.19103411e-01f, -7.81458914e-02f, 2.61234403e-01f, 1.56927943e-01f, 3.45709920e-01f, -2.63448358e-01f, -3.99482608e-01f, -2.75753021e-01f, 2.75021374e-01f,
  -4.12919194e-01f, -4.22625422e-01f, -1.46046355e-01f, 1.96224451e-01f, 2.42528826e-01f, 1.60611257e-01f, 1.09098647e-02f, -1.08218595e-01f, -7.52224177e-02f, -2.62497455e-01f,
  -1.29216880e-01f, 2.83748154e-02f, -6.63634390e-02f, 3.54982428e-02f, 1.52845055e-01f, -2.49276817e-01f, -2.35967413e-01f, -1.63207322e-01f, 7.51955584e-02f, -6.91137388e-02f,
  -1.38075188e-01f, -1.79806188e-01f, 1.41888499e-01f, 8.14201012e-02f, 1.52460784e-01f, -2.68531322e-01f, 1.77918419e-01f, 6.92531615e-02f, 6.98350668e-02f, -2.51513869e-01f,
  -1.41252577e-01f, 2.26123542e-01f, 3.22883278e-01f, -8.46727490e-02f, -2.77408987e-01f, -2.98170596e-01f, 1.87236726e-01f, 1.84392899e-01f, 3.82355869e-01f, -9.78861284e-03f,
  1.40191644e-01f, 1.48738012e-01f, 1.59074515e-01f, 3.37315142e-01f, -4.19673920e-01f, 2.42630124e-01f, 9.64785889e-02f, 1.43371433e-01f, -1.99029252e-01f, -1.66403592e-01f,
  -8.55480656e-02f, 2.39662398e-02f, -2.36800343e-01f, 1.73104867e-01f, 2.16493934e-01f, -7.14231888e-03f, 2.49972895e-01f, 1.63967729e-01f, 1.06306180e-01f, 1.19709149e-01f,
  1.57046288e-01f, -5.91759920e-01f, -2.75187433e-01f, -4.42952633e-01f, 3.46948892e-01f, -2.31842473e-01f, -4.51585859e-01f, -1.02019779e-01f, 7.85691757e-03f, -1.68700621e-01f,
  1.52917076e-02f, 5.54056428e-02f, 1.23387855e-02f, 6.20078743e-02f, 1.21044859e-01f, -2.17965901e-01f, 4.83965091e-02f, -1.36312321e-01f, 2.39524823e-02f, -1.14411242e-01f,
  2.78400350e-03f, -4.02647723e-03f, -1.77632421e-02f, -6.83515817e-02f, -5.53479306e-02f, 2.88090482e-02f, -1.63421948e-02f, -1.95815772e-01f, -1.61876127e-01f, 5.70938140e-02f,
  -3.43445450e-01f, -2.22409070e-01f, 1.33181915e-01f, 4.15253460e-01f, -1.88251480e-01f, 2.20816121e-01f, 1.86840251e-01f, -9.25957784e-02f, -1.85308114e-01f, -1.81545883e-01f,
  1.25569105e-01f, -3.43132228e-01f, 2.14018181e-01f, 1.67891309e-01f, 2.26670690e-03f, 2.44895011e-01f, 1.40851140e-01f, 1.10927530e-01f, 3.66162628e-01f, -2.49944434e-01f,
  -1.65554062e-01f, 3.29877995e-02f, -2.49049351e-01f, -1.78694129e-01f, -1.28348991e-01f, 5.49343228e-02f, -7.37876147e-02f, -7.62061551e-02f, -2.86023438e-01f, 3.38201642e-01f,
  2.99400717e-01f, -3.90455514e-01f, -2.06106007e-01f, -6.98088855e-02f, 3.28556746e-01f, 2.04607785e-01f, -4.69134338e-02f, 2.04630435e-01f, 3.74566950e-03f, -5.18391907e-01f,
  -3.87287170e-01f, -1.00984700e-01f, -2.89883018e-02f, -1.04384400e-01f, 3.48511785e-02f, -1.66132510e-01f, -1.72021151e-01f, -1.92476600e-01f, -3.89031023e-02f, 1.40280142e-01f,
  -8.79977047e-02f, 6.51767179e-02f, -1.23118177e-01f, 1.31880894e-01f, -1.51542544e-01f, -2.15217859e-01f, -3.11539639e-02f, 7.51796961e-02f, -2.33871460e-01f, -1.00559585e-01f,
  1.92443252e-01f, 1.13628224e-01f, -1.37331605e-01f, -5.93632460e-02f, -1.50822431e-01f, 1.00190938e-01f, -6.20189086e-02f, 2.26195440e-01f, -3.75383943e-01f, -3.63053054e-01f,
  -2.40627363e-01f, -9.68543068e-02f, 1.13371022e-01f, -1.49541020e-01f, -1.96085051e-01f, -3.06319594e-01f, -2.57170886e-01f, 3.02173376e-01f, -9.63189974e-02f, -1.79598629e-01f,
  1.97691813e-01f, -1.78608775e-01f, -3.37433279e-01f, -1.23188369e-01f, 2.74903953e-01f, 3.51749994e-02f, 1.51471481e-01f, 1.96168497e-01f, 4.36871611e-02f, -1.77362636e-01f,
  3.10477614e-01f, -3.44242245e-01f, -2.99846143e-01f, 2.93435585e-02f, -4.75510061e-01f, -6.38573050e-01f, -5.13931692e-01f, 3.23684253e-02f, -4.28858519e-01f, 3.09150159e-01f,
  2.00267941e-01f, 3.20775449e-01f, -2.35768735e-01f, 2.17796892e-01f, -5.93728735e-04f, -2.39025563e-01f, 1.81062713e-01f, -7.27508664e-02f, 1.98125333e-01f, -1.21336311e-01f,
  -1.88206751e-02f, 3.42391320e-02f, -1.95071250e-01f, 2.36670002e-01f, -1.24594860e-01f, 3.15150851e-03f, 1.30846739e-01f, -1.74546584e-01f, 3.13646525e-01f, 1.13255255e-01f,
  1.50913209e-01f, 3.04270703e-02f, 1.81532264e-01f, 1.32137313e-01f, 2.09012643e-01f, 1.64394557e-01f, -7.13014454e-02f, 3.08982283e-01f, -7.27933645e-02f, 5.35594672e-02f,
  1.49006257e-02f, 2.88516641e-01f, 2.48185813e-01f, 1.09464668e-01f, 5.74311288e-03f, 3.87844682e-01f, 2.17838541e-01f, 3.35723788e-01f, 1.81465417e-01f, -1.17739931e-01f,
  -1.50139108e-01f, 3.15633267e-02f, -1.60023466e-01f, -4.24957454e-01f, -3.80559117e-01f, -2.69906849e-01f, -2.26095915e-01f, -3.66980880e-01f, 3.29813331e-01f, 1.00442789e-01f,
  -2.01807544e-01f, 2.05071792e-01f, 4.18571651e-01f, -1.09879971e-01f, -1.65066183e-01f, 5.43771148e-01f, -6.86879307e-02f, -2.83858210e-01f, -3.31580311e-01f, 4.37067635e-02f,
  1.42279789e-01f, 1.48604885e-01f, -1.18666291e-01f, 2.82825083e-01f, -8.16241186e-03f, 1.97377831e-01f, -2.96270609e-01f, 1.45719424e-01f, -7.78951794e-02f, 1.58279747e-01f,
  -2.71320701e-01f, 1.77546233e-01f, -1.03057072e-01f, 1.90559402e-01f, -5.12953624e-02f, 1.44384682e-01f, 1.24437690e-01f, 1.99189916e-01f, 1.06763273e-01f, 1.69775691e-02f,
  -2.79526561e-01f, 2.03742772e-01f, 1.68990687e-01f, 3.29635553e-02f, 9.20974761e-02f, 2.32535988e-01f, -1.58514455e-01f, 4.15586308e-02f, 1.56037048e-01f, 1.81157127e-01f,
  -1.06567368e-01f, -1.16948495e-02f, 1.13387600e-01f, 3.65813542e-03f, -1.08236656e-01f, -1.05280630e-01f, 4.65250239e-02f, -5.71619123e-02f, 2.90988269e-03f, -2.50337332e-01f,
  4.87659052e-02f, 1.61671475e-01f, -3.69895607e-01f, 1.77506924e-01f, -3.13064098e-01f, -2.38344818e-01f, 6.00621221e-04f, 3.91069576e-02f, 3.55448723e-02f, 1.08589001e-01f,
  -4.09183681e-01f, 1.90410003e-01f, -2.13555560e-01f, -3.65369804e-02f, 2.78403610e-01f, -2.59580284e-01f, -3.81649792e-01f, 2.22852319e-01f, -2.10682765e-01f, 2.80094802e-01f,
  3.81759107e-01f, -3.71685565e-01f, -1.45598173e-01f, 2.16867447e-01f, 7.10473806e-02f, -3.29794399e-02f, -3.29997629e-01f, 1.65799797e-01f, -6.63845301e-01f, -3.16899985e-01f,
  -3.11173171e-01f, -2.13466376e-01f, 3.75286967e-01f, -7.08400607e-02f, -1.53364182e-01f, 1.40152082e-01f, 8.65783244e-02f, 1.52251005e-01f, -2.54493542e-02f, 1.16607696e-01f,
  2.38727763e-01f, 2.08065093e-01f, 1.18682876e-01f, 1.43519402e-01f, -1.23770602e-01f, -5.25196455e-02f, 2.43584767e-01f, 1.15822144e-01f, -2.25335211e-01f, -1.29148602e-01f,
  8.30336437e-02f, -1.46219984e-01f, -2.40218729e-01f, 3.33835408e-02f, -2.87103087e-01f, 3.69845368e-02f, 2.53479183e-01f, 1.47860527e-01f, 1.81183204e-01f, -1.23631790e-01f,
  1.59117281e-01f, -2.19860673e-02f, -2.73695767e-01f, -5.09401709e-02f, -2.04783648e-01f, 1.14997417e-01f, -2.99270600e-01f, -3.20539683e-01f, 2.62318611e-01f, -4.03808296e-01f,
  3.32375586e-01f, -2.48636454e-01f, 2.31011614e-01f, -2.90886521e-01f, 3.49896014e-01f, -7.11473152e-02f, -1.96531221e-01f, -1.08800419e-01f, 3.42898995e-01f, -2.53315061e-01f,
  6.70775250e-02f, -9.03315917e-02f, -1.34125262e-01f, 1.89474523e-01f, 9.84373391e-02f, 2.21163109e-01f, 2.91093588e-01f, -5.37282042e-02f, -1.07837468e-01f, -2.69406199e-01f,
  -2.88128585e-01f, 3.20804328e-01f, 1.41055539e-01f, -3.62834275e-01f, 1.95758924e-01f, -1.16854586e-01f, -1.14415824e-01f, -5.94040513e-01f, 1.58545062e-01f, -3.93287502e-02f,
  -1.33317843e-01f, -6.07725717e-02f, -1.42269616e-03f, 1.04001863e-02f, -1.64276719e-01f, -2.22407088e-01f, -3.29558849e-02f, -5.35352826e-02f, -3.82076502e-02f, 1.65390879e-01f,
  -3.99651052e-03f, -2.09307462e-01f, 4.17122766e-02f, 4.44538221e-02f, -1.23342667e-02f, 1.04325838e-01f, -1.62815496e-01f, 1.28868386e-01f, -3.92653234e-02f, -8.44581723e-02f,
  1.38602853e-02f, 6.33960068e-02f, 3.60013545e-02f, -1.08345047e-01f, 2.44974330e-01f, -1.83635071e-01f, -2.85163447e-02f, 1.65787831e-01f, 1.95270970e-01f, -3.35497893e-02f,
  -2.33105585e-01f, 4.10004705e-01f, -4.08807024e-02f, -1.97261319e-01f, -2.19624490e-01f, 2.64382660e-01f, -1.42268911e-01f, -1.96509063e-01f, 3.67287844e-01f, 1.39957875e-01f,
  -7.47206584e-02f, 2.68772542e-01f, 8.91116783e-02f, 1.21279769e-01f, 1.53624877e-01f, 1.42805398e-01f, 2.61655509e-01f, -1.90225303e-01f, -2.93267101e-01f, 2.28777960e-01f,
  -2.78606206e-01f, -4.94463623e-01f, -1.98872145e-02f, 2.66652882e-01f, -2.24661440e-01f, -3.97416085e-01f, -3.21216524e-01f, -2.03562915e-01f, -3.56691927e-01f, 1.58062533e-01f,
  3.67329448e-01f, 4.05133456e-01f, -1.02588423e-01f, 1.33613929e-01f, -2.38552943e-01f, 7.37222806e-02f, 1.33032739e-01f, -2.54717097e-02f, 1.19319215e-01f, 6.15451625e-03f,
  -7.70201534e-02f, 9.56872851e-02f, -2.65606701e-01f, 1.06259950e-01f, 1.43608078e-01f, 3.17939818e-02f, 1.25270873e-01f, 5.43608628e-02f, -5.95039390e-02f, -1.72483280e-01f,
  1.26592934e-01f, -8.44132528e-02f, 1.16269954e-01f, -5.71069866e-02f, -1.79338276e-01f, -6.72497367e-03f, -7.56254122e-02f, 2.34906837e-01f, -1.94070727e-01f, 7.42760971e-02f,
  2.03998953e-01f, 1.50909781e-01f, 2.32783958e-01f, -1.74297750e-01f, 2.33720168e-01f, 1.23284191e-01f, 6.71512187e-02f, 2.10469574e-01f, -2.72233367e-01f, 3.40737824e-05f,
  1.50195777e-01f, 2.47627333e-01f, -3.03952664e-01f, -2.38307387e-01f, -1.65696025e-01f, 2.76396900e-01f, -2.18435958e-01f, 2.77058005e-01f, -6.72633350e-02f, -8.41004178e-02f,
  -1.25574350e-01f, -2.70415366e-01f, 1.84548199e-01f, -3.50261837e-01f, -4.33959097e-01f, -3.00542831e-01f, 2.63652444e-01f, -1.95296615e-01f, 3.27668160e-01f, -3.41341645e-01f,
  3.59485626e-01f, 2.80142725e-01f, -1.82309523e-01f, -4.18412715e-01f, -1.37562618e-01f, -2.34308198e-01f, 9.27882865e-02f, -3.00751120e-01f, 1.54345721e-01f, 1.59929029e-03f,
  1.19472153e-01f, -9.24202651e-02f, 1.89939663e-01f, 6.92844018e-02f, -5.14150821e-02f, -1.83619708e-01f, 1.63998887e-01f, -3.12678330e-02f, -6.06206879e-02f, 2.14263633e-01f,
  5.67934625e-02f, -1.97316542e-01f, 2.72831600e-02f, 2.30660126e-01f, 1.12729363e-01f, -3.37867178e-02f, 5.43521270e-02f, 1.42279908e-01f, -3.03541243e-01f, -2.15949625e-01f,
  1.62247017e-01f, -2.25081369e-01f, 1.85886949e-01f, 1.02957763e-01f, -1.96706101e-01f, -1.69406444e-01f, 3.80452782e-01f, 8.84828866e-02f, 1.01164788e-01f, -2.56643355e-01f,
  -2.34511271e-01f, 1.74632937e-01f, -3.86998415e-01f, 9.27326009e-02f, 2.23822575e-02f, -2.02183336e-01f, 1.50022849e-01f, 6.99406639e-02f, 2.41456509e-01f, 9.94813591e-02f,
  1.80945992e-02f, 3.74268830e-01f, -2.60737855e-02f, -9.16726068e-02f, -2.05622032e-01f, -3.27027962e-02f, -8.21048245e-02f, 2.49729678e-01f, 3.24378848e-01f, 3.56141068e-02f,
  2.16203377e-01f, -5.90078458e-02f, -4.06567693e-01f, -4.41672206e-02f, -5.86611390e-01f, -4.57121968e-01f, 9.17879716e-02f, -1.90434650e-01f, 6.26112670e-02f, 2.29879901e-01f,
  2.58277684e-01f, 1.30570782e-02f, -1.57130346e-01f, -6.50267825e-02f, -1.83016717e-01f, 1.84541151e-01f, -2.07530320e-01f, -1.07231446e-01f, 1.40658975e-01f, -1.16974689e-01f,
  -5.50637506e-02f, -1.39189333e-01f, -8.08377415e-02f, -1.27704173e-01f, -2.32138690e-02f, -2.51436178e-02f, 1.65273435e-02f, 1.72589272e-01f, -1.09219067e-01f, -3.11685968e-02f,
  7.79132843e-02f, -1.40942976e-01f, -9.60387811e-02f, 5.28765656e-02f, -2.13330731e-01f, -6.94453940e-02f, -1.63933128e-01f, 3.14860642e-01f, 1.18000343e-01f, 2.37618253e-01f,
  7.89657831e-02f, 2.03992769e-01f, -1.64237574e-01f, 3.73707175e-01f, 2.80520439e-01f, 1.14847921e-01f, 2.48359680e-01f, -1.98765039e-01f, -2.66156048e-01f, -1.55712530e-01f,
  9.82051250e-03f, -3.52373362e-01f, -1.79328039e-01f, -2.68848717e-01f, 1.27113670e-01f, -1.84923455e-01f, 2.65397787e-01f, -1.72988072e-01f, 2.98970044e-01f, -1.13069586e-01f,
  -4.01392341e-01f, 2.33255774e-02f, 1.07483290e-01f, -3.97531271e-01f, -7.48575106e-02f, -2.96910882e-01f, 3.95459197e-02f, -2.14618891e-01f, 3.21604669e-01f, -2.59810351e-02f,
  3.93746525e-01f, 2.77457952e-01f, -3.18040818e-01f, -2.24564791e-01f, -4.34151329e-02f, 1.03249572e-01f, 1.28165230e-01f, 4.21980396e-02f, 1.10041425e-01f, -7.50405639e-02f,
  -2.95046031e-01f, -6.49278462e-02f, 8.90832618e-02f, 7.83813372e-02f, 5.53387143e-02f, 1.00329690e-01f, -2.06888374e-02f, 2.01186731e-01f, -1.90011948e-01f, -6.91531971e-02f,
  -6.43115724e-03f, 9.95788798e-02f, -2.63321638e-01f, -2.20270559e-01f, 1.50051802e-01f, 1.27207845e-01f, -5.74516021e-02f, 8.16784501e-02f, 1.35754384e-02f, -2.80499309e-01f,
  -3.27423334e-01f, 2.94882536e-01f, 3.51675563e-02f, 2.43910447e-01f, -1.20916069e-01f, -1.64538950e-01f, -7.22171366e-02f, 2.91528404e-01f, 2.77801126e-01f, 1.36164248e-01f,
  -2.55431086e-01f, -3.66042137e-01f, 2.29145795e-01f, -1.44423470e-01f, 1.53805941e-01f, 3.62841874e-01f, -7.82567188e-02f, -1.96763486e-01f, 1.89355597e-01f, -1.61027431e-01f,
  -2.12383926e-01f, 3.07319909e-01f, 3.90969157e-01f, -2.93817341e-01f, 3.19705606e-01f, -3.29992086e-01f, -5.60694098e-01f, 2.57330894e-01f, -4.84225065e-01f, -5.08532822e-01f,
  -2.86520183e-01f, -1.77280411e-01f, 2.57265687e-01f, -2.85304129e-01f, -5.13059013e-02f, 2.57124931e-01f, 1.92722857e-01f, -2.19600335e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  5.48037402e-02f, 9.76387858e-02f, 7.71236122e-02f, 1.00285955e-01f, -1.05285808e-01f, 1.46144882e-01f, 1.20036735e-03f, 2.87595559e-02f, 1.12973921e-01f, 2.44514309e-02f,
  -1.05036154e-01f, -4.26190952e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    