/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.38977417e-01f, -3.24218236e-02f, -1.17300190e-01f, -1.54822484e-01f, -2.56328546e-02f, 5.38465790e-02f, -1.24368839e-01f, -5.72230853e-02f, 1.30841538e-01f, 1.85379148e-01f,
  -1.09682716e-01f, -1.10568486e-01f, 6.55856878e-02f, -2.71350503e-01f, -2.67902523e-01f, -7.98243135e-02f, -8.06940049e-02f, -2.43620463e-02f, -2.31693871e-02f, -1.07073702e-01f,
  -6.21872246e-02f, -1.41965777e-01f, -9.05939862e-02f, -3.00933365e-02f, -1.73015267e-01f, 7.06878453e-02f, 1.80990342e-02f, 7.29729608e-02f, -4.97307070e-02f, -7.81710520e-02f,
  -3.85501906e-02f, -1.72512420e-02f, -7.06127658e-02f, -3.06309387e-02f, -1.84432548e-02f, 2.38319933e-02f, 7.50809088e-02f, -3.97992097e-02f, 3.87728177e-02f, -5.05841225e-02f,
  -6.32869080e-03f, -2.95462143e-02f, 6.37440756e-02f, 1.05289770e-02f, -9.21069528e-04f, 1.07841017e-02f, -7.68052563e-02f, 6.37219474e-02f, -4.30262415e-03f, -1.95820699e-03f,
  2.13864371e-02f, -1.12562021e-03f, -1.57560501e-02f, -2.57478338e-02f, 3.10716834e-02f, 8.23835004e-03f, 7.30907246e-02f, -5.90752438e-02f, 3.51271257e-02f, -2.16888729e-02f,
  -4.62261923e-02f, -1.29619585e-02f, 8.05319380e-03f, -6.11038283e-02f, 1.77725609e-02f, -6.33365940e-04f, 4.25995402e-02f, -3.13412882e-02f, 2.31966395e-02f, -7.25896880e-02f,
  5.41235805e-02f, 1.78208295e-02f, -4.80354354e-02f, 5.62346317e-02f, -4.09131274e-02f, 2.51756385e-02f, -4.84901294e-02f, -4.71516475e-02f, 1.99555587e-02f, 4.92826290e-02f,
  -1.46576008e-02f, -3.94963585e-02f, -3.73148806e-02f, -4.15750928e-02f, 6.44801781e-02f, -5.40990159e-02f, 3.39570008e-02f, 5.17520495e-02f, -8.20037164e-03f, -1.55885164e-02f,
  5.94289554e-03f, -1.27241872e-02f, 6.94971830e-02f, 1.04876697e-01f, 2.36611534e-02f, -5.87256327e-02f, 9.65504069e-03f, 3.09797134e-02f, 3.64912041e-02f, -1.75098199e-02f,
  -1.27542680e-02f, -1.96508169e-02f, -2.65314821e-02f, -1.10327117e-02f, 3.03048864e-02f, 2.33394224e-02f, 6.18432201e-02f, 6.34671673e-02f, 2.41991002e-02f, -3.91618088e-02f,
  1.69615652e-02f, 3.07806600e-02f, 1.34689582e-03f, 7.73446560e-02f, -2.47831270e-02f, -1.36947464e-02f, -1.06296176e-02f, -3.68092097e-02f, -6.60834163e-02f, -1.87452454e-02f,
  3.11435070e-02f, -2.62381822e-01f, -1.16252117e-01f, 2.18110308e-01f, 1.13749407e-01f, -1.23241298e-01f, -1.97561413e-01f, 5.18957060e-03f, -1.77002952e-01f, -5.22913337e-02f,
  4.04432453e-02f, 9.98045430e-02f, -1.81286827e-01f, 1.44384533e-01f, 1.22306749e-01f, -1.57656968e-01f, -2.63209343e-02f, 7.22784922e-02f, -4.78974096e-02f, 9.61160809e-02f,
  2.33852848e-01f, 2.00080752e-01f, 2.18557701e-01f, 1.89591274e-01f, 1.33154288e-01f, 3.56323346e-02f, 3.48919153e-01f, -8.85226950e-02f, 2.07469180e-01f, -6.81831390e-02f,
  -3.07189282e-02f, -2.40391996e-02f, 5.60292341e-02f, -9.99293104e-02f, 1.88581571e-02f, -2.48947330e-02f, 2.14846432e-02f, -3.39973494e-02f, -8.22338089e-03f, -8.41539428e-02f,
  -1.59194618e-02f, 5.65607063e-02f, 4.61465243e-04f, -2.79418752e-02f, 6.58736005e-03f, 1.86204202e-02f, 1.77642889e-02f, -5.94444945e-02f, -3.63154337e-02f, -1.78202055e-02f,
  -3.30004059e-02f, 2.83594169e-02f, 3.38894241e-02f, 1.28360884e-02f, 1.28241871e-02f, -7.96617847e-03f, -5.80558591e-02f, 1.62740722e-02f, 1.02082156e-02f, -8.17930512e-03f,
  -1.76435392e-02f, 2.69277021e-02f, 2.43140459e-02f, -1.54277524e-02f, -2.20123790e-02f, -1.14537645e-02f, 4.65335473e-02f, 4.26414385e-02f, 1.48049183e-03f, 6.52695373e-02f,
  5.49686290e-02f, 6.00083657e-02f, -8.76443926e-03f, 1.45775639e-02f, 5.95224574e-02f, 1.33632105e-02f, 2.40616016e-02f, 1.41587071e-02f, -2.39611417e-02f, 9.53010991e-02f,
  2.30423138e-02f, -1.67168770e-03f, -2.22494509e-02f, 2.84437779e-02f, -8.16762671e-02f, 4.02496867e-02f, 8.55671894e-03f, -3.92886586e-02f, 4.84435695e-05f, 4.45454232e-02f,
  -1.42430335e-01f, -5.80058210e-02f, 1.97008774e-02f, -3.63778882e-02f, -4.32094373e-02f, 6.47730157e-02f, 5.41459285e-02f, -3.26337069e-02f, -9.69206244e-02f, 4.84156907e-02f,
  5.25642969e-02f, -6.46664621e-03f, 5.44801876e-02f, -2.03343090e-02f, -6.03114739e-02f, -1.86718609e-02f, 5.54611124e-02f, 3.19525152e-02f, 3.40284966e-02f, 8.31838176e-02f,
  3.37072983e-02f, -1.22010643e-02f, 2.50838622e-02f, 3.70262377e-02f, -1.39733637e-02f, 5.48612066e-02f, 7.21310303e-02f, 4.79584048e-03f, -2.43036058e-02f, -4.29209694e-02f,
  1.04152739e-01f, -2.24559575e-01f, -2.29629129e-01f, -1.12446867e-01f, -8.71746149e-03f, -1.25487939e-01f, 5.76976724e-02f, -1.60293713e-01f, -1.36281148e-01f, -1.85443442e-02f,
  -3.82919312e-02f, 9.67829898e-02f, 1.13143861e-01f, -2.47850776e-01f, 1.99270397e-01f, 3.56767327e-02f, -2.21996933e-01f, -1.09581336e-01f, -6.84910640e-02f, 1.60711985e-02f,
  -6.22396916e-02f, 3.16705443e-02f, -2.73800368e-04f, -8.55654627e-02f, -1.22799322e-01f, -9.30463895e-02f, 6.87207580e-02f, 4.86356728e-02f, -1.19511597e-01f, 5.92848249e-02f,
  -5.89184575e-02f, 6.93111168e-03f, 1.46076139e-02f, -1.07898578e-01f, 4.62242626e-02f, 4.01300341e-02f, 6.47058710e-03f, -3.01367547e-02f, -6.16465546e-02f, 2.23415066e-02f,
  6.72030672e-02f, 3.31913345e-02f, -1.23646989e-01f, 8.33311826e-02f, -4.60831672e-02f, -1.03078365e-01f, -3.67273912e-02f, -1.01451695e-01f, -1.15963906e-01f, -8.30847945e-04f,
  -5.21929078e-02f, -1.16546512e-01f, -6.26489241e-03f, -8.80784243e-02f, -7.62659162e-02f, -4.28202637e-02f, 1.04138833e-02f, 8.58624056e-02f, -1.95550192e-02f, -2.69225761e-02f,
  7.90938959e-02f, 1.90916099e-02f, 1.02442784e-04f, -3.09223845e-03f, 1.06846895e-02f, -6.49997918e-03f, -1.58079136e-02f, -5.05958609e-02f, -5.67931347e-02f, 4.35190350e-02f,
  -3.81865241e-02f, -1.06481388e-02f, -4.05760109e-02f, -4.78193052e-02f, 3.50709446e-02f, -1.87742263e-02f, 6.33222014e-02f, 4.20716219e-02f, -2.37718131e-02f, -6.55064061e-02f,
  2.05563530e-02f, -4.26645391e-02f, 4.60973270e-02f, -5.70939779e-02f, 1.35730682e-02f, -2.78964154e-02f, -2.17776988e-02f, -6.87295347e-02f, -4.36393060e-02f, 2.87756529e-02f,
  -2.99927425e-02f, 4.24168333e-02f, -1.04614999e-02f, 2.23695450e-02f, -6.04639910e-02f, 5.20636961e-02f, 1.39594749e-02f, -2.55358871e-03f, 3.99409235e-02f, -1.72519125e-02f,
  1.31801413e-02f, -5.09012528e-02f, -9.97894071e-03f, 6.12520315e-02f, -4.63618571e-03f, -1.26756718e-02f, 7.37375915e-02f, 6.42638728e-02f, 4.85715717e-02f, -4.37580096e-03f,
  1.06741805e-02f, 3.89680988e-03f, 3.34632024e-02f, 2.70311930e-03f, -2.33594179e-02f, 5.53879775e-02f, 4.19328585e-02f, -6.35942370e-02f, -1.64823402e-02f, -2.29152683e-02f,
  1.31830141e-01f, 6.07590713e-02f, 5.86497374e-02f, 1.39164180e-01f, -1.04593135e-01f, -8.55718404e-02f, 1.44687578e-01f, -1.33950159e-01f, 2.00420141e-01f, 1.29977867e-01f,
  -9.54276472e-02f, 1.49549738e-01f, 1.49508685e-01f, -4.17769663e-02f, -4.05840985e-02f, 9.66812372e-02f, 6.84929714e-02f, 3.60111184e-02f, 2.13252604e-02f, -6.30983151e-03f,
  -3.46249342e-02f, -1.91625655e-01f, -1.07988063e-02f, -2.37309054e-01f, -1.27776712e-01f, 7.55789354e-02f, -1.32820576e-01f, -2.13220194e-02f, -1.41244441e-01f, -1.23736337e-01f,
  -3.17880176e-02f, -5.23227118e-02f, 3.97400483e-02f, -1.44857001e-02f, 3.25898565e-02f, 5.88938855e-02f, 8.03511664e-02f, -4.90053669e-02f, -7.14511052e-02f, -5.53402537e-03f,
  3.23709249e-02f, -7.86294639e-02f, -6.16852902e-02f, 3.55772860e-02f, -5.15373424e-02f, -7.01483786e-02f, 2.84527186e-02f, 7.96503760e-03f, 1.19775236e-02f, -7.04525933e-02f,
  8.96290690e-02f, 3.15296911e-02f, -2.31469516e-02f, -3.64823407e-03f, 1.03098728e-01f, 8.13483745e-02f, 5.40789589e-02f, -5.16608171e-02f, 1.75257064e-02f, 3.73491570e-02f,
  8.84887669e-03f, 4.88107018e-02f, -3.39234173e-02f, -6.16101897e-04f, -9.72537044e-03f, 2.93832049e-02f, 1.81133617e-02f, -5.92805408e-02f, 6.71242550e-02f, -3.12138703e-02f,
  -6.03208132e-02f, -1.73516627e-02f, -4.94684745e-03f, 2.61491979e-03f, 6.92088455e-02f, -1.05872909e-02f, 6.63193986e-02f, 1.53062621e-03f, -1.81339926e-03f, 4.02460136e-02f,
  1.08469864e-02f, 5.42589612e-02f, -5.38879856e-02f, -9.01807398e-02f, 1.11414762e-02f, 3.79594751e-02f, -2.84497682e-02f, 1.24368360e-02f, 3.21578570e-02f, -5.52411638e-02f,
  -2.65139341e-02f, 9.75385774e-03f, 5.18683568e-02f, -1.02968164e-01f, 6.99119568e-02f, -7.41524100e-02f, -4.32596579e-02f, 4.06495780e-02f, 8.33338648e-02f, 6.69969246e-03f,
  2.13276111e-02f, -2.99681071e-02f, 6.20844308e-03f, 5.02944645e-03f, -4.87243794e-02f, -5.36715100e-03f, -3.59029844e-02f, 2.91506220e-02f, 1.16656078e-02f, -9.19329654e-03f,
  -8.06216821e-02f, 6.28401637e-02f, 5.44532016e-02f, 2.54127271e-02f, -7.93834925e-02f, 3.04628294e-02f, -2.17735805e-02f, 7.30952397e-02f, -8.02476425e-03f, -3.36964242e-02f,
  5.00597171e-02f, -2.03365982e-01f, -2.22332641e-01f, -4.19544987e-02f, -1.68053787e-02f, 1.80317402e-01f, 6.83215931e-02f, 2.27945261e-02f, 1.56283304e-01f, 7.25781247e-02f,
  7.46896192e-02f, -1.38241993e-02f, -4.06318577e-03f, 1.77753478e-01f, 1.33366138e-01f, 2.29930297e-01f, 1.37778625e-01f, 1.56753570e-01f, 6.25548437e-02f, -7.65565634e-02f,
  -1.22414157e-02f, -4.22944129e-03f, -4.45045251e-03f, -8.15438554e-02f, -4.80413847e-02f, -8.79728645e-02f, 7.23974837e-04f, -1.24740809e-01f, -1.18885143e-03f, -1.33155519e-02f,
  -3.70208956e-02f, 1.68823823e-02f, -1.05588920e-01f, -3.80202569e-02f, -8.15362036e-02f, -9.32163820e-02f, -1.05000757e-01f, -2.39064861e-02f, -4.45091166e-03f, -2.43409332e-02f,
  -2.33908445e-02f, -5.56533374e-02f, 4.22417894e-02f, 3.48178558e-02f, -3.10786925e-02f, -9.01035741e-02f, -2.63090711e-02f, 4.51714247e-02f, -2.82764342e-03f, -2.75707133e-02f,
  -4.63887863e-03f, -4.96043079e-02f, -4.63680783e-03f, 7.73352161e-02f, 1.72271617e-02f, -5.32128476e-02f, 2.99357884e-02f, -1.63000505e-02f, -2.18198784e-02f, -1.25618791e-02f,
  5.36172539e-02f, -4.97593395e-02f, -5.34972250e-02f, -5.26490249e-02f, 4.61289510e-02f, -8.74413997e-02f, 1.20903524e-02f, -1.97268613e-02f, 4.60757874e-02f, 4.07542698e-02f,
  7.83193484e-03f, -1.00988252e-02f, 4.11512218e-02f, 2.73428056e-02f, 4.20489237e-02f, 1.04657039e-02f, 1.42348902e-02f, 1.33231692e-02f, -1.51283825e-02f, 7.60000870e-02f,
  -5.17255068e-02f, 5.62623143e-02f, 4.50290553e-02f, -5.19532748e-02f, 5.35818115e-02f, 7.37759918e-02f, 1.16539355e-02f, 3.53984348e-02f, 5.50795626e-03f, 1.79610320e-03f,
  1.00058382e-02f, -1.65557116e-01f, -1.68948807e-02f, -3.42946462e-02f, -8.47433209e-02f, -2.47284733e-02f, -1.80101842e-02f, -1.66204832e-02f, -6.65495917e-02f, 3.31564918e-02f,
  -7.12600201e-02f, 1.12827178e-02f, -6.75390242e-03f, 3.00187599e-02f, 3.75938639e-02f, -2.26463303e-02f, 1.50857493e-02f, 3.78813334e-02f, 5.95234409e-02f, 1.61756333e-02f,
  -1.28090799e-01f, 4.27295528e-02f, 3.28627415e-02f, 1.50306392e-02f, 6.41837493e-02f, 2.63990574e-02f, -1.07367337e-03f, 4.90540192e-02f, -2.48704907e-02f, -7.80229643e-02f,
  2.28781790e-01f, 3.33518654e-01f, -3.63659412e-02f, 3.85816433e-02f, -1.86986662e-02f, -4.60259542e-02f, 4.60126018e-03f, 3.76214236e-02f, 3.82943541e-01f, 1.65948853e-01f,
  -4.32165191e-02f, 1.91039324e-01f, -3.77388019e-03f, 8.52497742e-02f, -3.14330459e-01f, -3.87926176e-02f, 1.44091034e-02f, -6.91419616e-02f, 2.64263842e-02f, -1.80648014e-01f,
  -1.63625896e-01f, -4.15094942e-02f, -2.30895251e-01f, -1.21216074e-01f, -5.75797558e-02f, -7.54021257e-02f, -2.96934724e-01f, -1.00007996e-01f, -1.10048540e-01f, 5.88282570e-02f,
  -2.00735833e-02f, 1.40472665e-01f, 6.94795623e-02f, 4.65636328e-02f, -4.62711938e-02f, -5.06686158e-02f, -5.49329482e-02f, 4.48426232e-03f, -5.61577007e-02f, 3.53033319e-02f,
  -6.66527171e-03f, -1.66070070e-02f, 6.61899373e-02f, 7.70571083e-02f, 1.40971616e-01f, 2.11237259e-02f, -5.06750084e-02f, 4.91015688e-02f, 9.94211901e-03f, -9.08005051e-03f,
  -1.68315601e-03f, 7.31097721e-03f, -5.26111461e-02f, -3.86158600e-02f, -4.41339090e-02f, 2.13926770e-02f, -8.30928460e-02f, -1.22778341e-01f, 1.29748791e-01f, 3.37508973e-03f,
  -2.21995590e-03f, -2.69506369e-02f, 2.79955938e-02f, 5.73119484e-02f, 6.09062202e-02f, -2.76985187e-02f, 1.23721184e-02f, -5.11142351e-02f, 2.84186611e-03f, -2.83065271e-02f,
  2.12743245e-02f, 5.47438264e-02f, 9.02599171e-02f, -2.24255566e-02f, 3.73594509e-03f, 7.59904459e-02f, -5.67180431e-03f, 1.59676112e-02f, 4.66619432e-02f, 2.97085065e-02f,
  5.05467206e-02f, 3.85365672e-02f, -3.52159366e-02f, -1.54722109e-02f, 6.41004890e-02f, -8.94077495e-02f, 4.67729717e-02f, 5.32146618e-02f, -1.09165972e-02f, -8.28203838e-03f,
  -3.86435241e-02f, -1.09391302e-01f, -6.57093991e-03f, 6.44972697e-02f, -4.84972075e-02f, -2.88898125e-02f, 3.20281573e-02f, 3.92345004e-02f, -3.07177920e-02f, -3.34566571e-02f,
  -4.78863977e-02f, -4.07243380e-03f, -4.60447706e-02f, -1.79200713e-02f, -1.22762442e-01f, -2.64702905e-02f, 1.75029095e-02f, -3.85373994e-03f, -4.60650586e-02f, -7.07385540e-02f,
  -3.81233506e-02f, -7.86141083e-02f, 3.09938863e-02f, -2.50621922e-02f, 6.28252747e-03f, -6.23160675e-02f, 2.84706913e-02f, -3.19773406e-02f, -5.91906011e-02f, 2.81729940e-02f,
  -2.29267582e-01f, 6.59920275e-02f, -3.03192317e-01f, -1.17599122e-01f, 2.68699341e-02f, 2.20549002e-01f, -4.74565811e-02f, 1.30255803e-01f, -1.76181998e-02f, 3.56545836e-01f,
  1.36275906e-02f, -1.62720278e-01f, -1.01570114e-01f, 1.58388615e-02f, -3.07144791e-01f, -1.56389058e-01f, 1.59901455e-01f, 5.13782762e-02f, 3.76691520e-02f, 6.62047714e-02f,
  -8.29832703e-02f, 1.18213654e-01f, -2.39400595e-01f, 1.90239757e-01f, -5.89420013e-02f, -6.35662302e-03f, -7.67821353e-03f, -7.68665895e-02f, 1.26102597e-01f, -1.49732241e-02f,
  -3.02380547e-02f, 9.64854807e-02f, -5.31982072e-02f, 9.52376053e-03f, 1.29296765e-01f, 2.67937649e-02f, -2.41463166e-02f, -9.64671746e-02f, -4.78716642e-02f, 8.83674696e-02f,
  -7.85144232e-03f, -2.56106891e-02f, 6.55321255e-02f, -3.77312824e-02f, 5.64260408e-02f, 7.11984634e-02f, 1.93530023e-02f, -8.76139197e-03f, -5.92559278e-02f, -2.17869468e-02f,
  -6.82401210e-02f, -2.52259653e-02f, 1.37362322e-02f, 7.22434744e-02f, -6.67444915e-02f, 6.46549836e-02f, -1.20944148e-02f, -8.07295218e-02f, 5.43516874e-02f, 4.56656590e-02f,
  8.77912790e-02f, 5.03913760e-02f, -6.22364879e-02f, -5.49948625e-02f, -1.21837771e-02f, 9.63335551e-05f, 1.33835031e-02f, 2.91843936e-02f, -5.95249049e-02f, 4.27758209e-02f,
  -6.79216534e-02f, -7.19377100e-02f, 4.35551591e-02f, -9.03230719e-03f, 4.63816598e-02f, 1.68453213e-02f, -1.37049695e-02f, 1.01970602e-02f, 5.71541525e-02f, -6.43932447e-02f,
  2.55538058e-02f, -3.61064486e-02f, -2.76499055e-03f, -3.56247276e-02f, 1.43184783e-02f, -4.47068252e-02f, 7.47785345e-02f, -4.77707349e-02f, -1.08561688e-03f, -5.42755015e-02f,
  1.81144208e-01f, 1.41490847e-01f, 5.68296351e-02f, 4.17242758e-02f, -2.21290775e-02f, 1.31696239e-02f, 4.69898805e-03f, -1.44984368e-02f, -3.02244117e-03f, 2.65056156e-02f,
  4.70678098e-02f, 4.53446731e-02f, 9.52707231e-03f, -5.06326696e-03f, -4.57377695e-02f, -4.44160551e-02f, 2.87536457e-02f, 7.69720878e-03f, 6.80069253e-02f, 3.40229794e-02f,
  3.82517837e-02f, 7.62385726e-02f, 3.77847999e-02f, 7.59420842e-02f, 6.15768880e-02f, 2.00538281e-02f, 4.51555327e-02f, 5.35689527e-04f, -1.61246397e-02f, -1.50073720e-02f,
  -1.22901991e-01f, 7.01019838e-02f, 1.55732065e-01f, 1.07523888e-01f, -1.39067307e-01f, -1.62983552e-01f, -7.29621574e-02f, -4.00960520e-02f, 2.15394139e-01f, -6.57568574e-02f,
  -2.91348368e-01f, 2.44972616e-01f, -1.17366634e-01f, -1.29566759e-01f, -2.73152590e-01f, -1.93882406e-01f, -1.90229550e-01f, -4.59022708e-02f, 1.68773830e-01f, 7.04050809e-02f,
  -8.58765170e-02f, -2.56726444e-01f, -1.61903530e-01f, -1.49350399e-02f, -9.07912180e-02f, 2.19844863e-01f, -1.89495638e-01f, 3.17449942e-02f, 2.70062499e-02f, -5.43324165e-02f,
  -4.98732664e-02f, 3.80182713e-02f, 3.60410661e-02f, 1.92274544e-02f, -4.96405736e-03f, -1.74636897e-02f, 2.30886526e-02f, -7.23385885e-02f, 1.35974092e-02f, 4.82154600e-02f,
  -2.71349084e-02f, 2.86925435e-02f, 3.04414351e-02f, -4.92824279e-02f, 5.53411469e-02f, 6.19530790e-02f, 3.91965806e-02f, -5.54619431e-02f, 8.97750407e-02f, -5.92613220e-02f,
  -3.38683613e-02f, 1.35138808e-02f, -6.55092448e-02f, 4.34746593e-02f, -3.92881632e-02f, 5.28403632e-02f, 7.99846090e-03f, 5.91957942e-02f, -1.64458901e-02f, 4.52378008e-04f,
  -8.05355757e-02f, 2.97957333e-03f, 3.41454428e-03f, 5.81870824e-02f, -2.82796044e-02f, -7.84285218e-02f, 3.98335755e-02f, -1.69643536e-02f, 3.76699902e-02f, -6.35452121e-02f,
  6.37476072e-02f, 4.05296363e-04f, 1.05710200e-03f, 7.74892792e-03f, -4.68599200e-02f, 3.09700612e-02f, -4.53669904e-03f, -1.91881508e-02f, 5.33066317e-02f, -5.20343557e-02f,
  9.36760977e-02f, 3.59577611e-02f, -1.58430282e-02f, 3.64055969e-02f, -6.22442514e-02f, 1.13534015e-02f, -1.31581603e-02f, -1.33314393e-02f, 1.73140354e-02f, -7.58477822e-02f,
  -6.48947060e-02f, -4.98507842e-02f, -1.16304653e-02f, 3.98109332e-02f, 4.39355411e-02f, -9.49636027e-02f, 4.91316803e-03f, 7.88773447e-02f, -4.44516428e-02f, 4.51657102e-02f,
  2.36226544e-02f, 2.97065768e-02f, 1.88117810e-02f, 4.68763486e-02f, -2.58059110e-02f, -5.68520911e-02f, -4.87792790e-02f, 5.60945868e-02f, -6.70620725e-02f, -6.04631752e-02f,
  1.99859329e-02f, 1.81649067e-02f, 7.09385201e-02f, 2.59010438e-02f, 5.69974445e-02f, -3.65183055e-02f, 4.72436622e-02f, -9.38641187e-03f, -2.53901575e-02f, 3.57477111e-03f,
  1.03057444e-01f, 5.47831245e-02f, -1.32306084e-01f, 2.00090900e-01f, -8.07775557e-02f, -2.22167477e-01f, -1.98734581e-01f, 2.23599821e-02f, 1.47043630e-01f, 1.06976978e-01f,
  -9.62297544e-02f, 1.85383469e-01f, -2.51117080e-01f, 2.41047189e-01f, -2.39930451e-01f, -3.22072655e-02f, 6.95464090e-02f, 1.57363608e-01f, 5.27796187e-02f, -5.37298992e-02f,
  9.34217870e-02f, 1.61225319e-01f, 1.94656886e-02f, 5.08157490e-03f, 1.18304342e-01f, 1.63298354e-01f, -2.87652761e-03f, -1.73024356e-01f, 9.19217691e-02f, 5.45235425e-02f,
  -5.47380932e-02f, 1.32642448e-01f, 3.23038287e-02f, 4.29411866e-02f, -1.08552445e-02f, -2.83178855e-02f, -4.42683958e-02f, -5.77094555e-02f, -5.03098965e-03f, 3.13590840e-02f,
  -2.19214167e-02f, -4.20391820e-02f, 4.26677689e-02f, -1.73869915e-02f, -5.57470508e-03f, 4.75575961e-02f, 5.01619838e-02f, 3.55508790e-04f, -3.83594111e-02f, -4.07823548e-02f,
  4.21301760e-02f, 1.28876362e-02f, 5.50810322e-02f, 9.83808842e-03f, -8.07263404e-02f, -2.66396552e-02f, 5.15460931e-02f, -2.30309144e-02f, 4.75616492e-02f, 2.54977727e-04f,
  3.76482867e-02f, -2.91350633e-02f, -9.74518526e-03f, 3.47134992e-02f, -1.06532192e-02f, 7.13519156e-02f, -7.65632242e-02f, -3.19025554e-02f, -2.70691793e-02f, -3.91068682e-02f,
  -5.69905713e-02f, 6.00406639e-02f, -2.39195917e-02f, -3.70694958e-02f, 6.99587836e-05f, 3.82158384e-02f, -5.15540317e-02f, 6.79377690e-02f, 6.46901084e-04f, 6.50023296e-02f,
  -1.22108217e-02f, -7.62545168e-02f, -1.70798060e-02f, 3.49442288e-02f, -6.93220347e-02f, -1.89964790e-02f, -2.11818907e-02f, -5.00631668e-02f, -1.36743234e-02f, -1.20267682e-02f,
  -2.49822170e-01f, -1.50872871e-01f, -7.46458676e-03f, -3.74975540e-02f, 3.83274630e-02f, -1.59299141e-03f, 1.70905050e-02f, 2.86338702e-02f, -1.06413558e-01f, 1.69579815e-02f,
  4.07703295e-02f, 3.14599425e-02f, -6.58757165e-02f, -2.82731056e-02f, -7.86584690e-02f, 2.27124617e-03f, -9.23301093e-03f, -5.98887168e-02f, 8.36263690e-03f, 4.90661226e-02f,
  -5.81738949e-02f, -2.49177013e-02f, -1.40229203e-02f, 6.59962147e-02f, 2.79941149e-02f, 3.94826382e-02f, -2.34449711e-02f, 3.98202566e-03f, -3.23843472e-02f, 3.61135486e-03f,
  -1.55529127e-01f, -2.27480933e-01f, 1.46528959e-01f, -5.77677414e-02f, 1.34592159e-02f, 2.53720462e-01f, 8.65573809e-02f, -1.39925610e-02f, -2.89116681e-01f, -1.39639199e-01f,
  -3.88388224e-02f, -5.69470748e-02f, -7.63031840e-02f, 1.00873165e-01f, 6.55950233e-02f, -6.65283576e-02f, 7.45187104e-02f, 1.37562770e-02f, -1.45676121e-01f, -1.42561719e-01f,
  -8.25782716e-02f, 7.81587660e-02f, 1.00373223e-01f, 5.08731864e-02f, -7.38291442e-02f, 7.78436288e-02f, -2.49708053e-02f, 1.14648663e-01f, 2.00006098e-01f, 7.78662935e-02f,
  -1.02520980e-01f, -1.70018524e-01f, 1.92830302e-02f, 9.53538269e-02f, 7.14657903e-02f, 6.86843395e-02f, 4.01087478e-02f, 9.97449607e-02f, -1.23904906e-02f, -2.93419454e-02f,
  4.49362956e-02f, 5.58670014e-02f, -8.33611097e-03f, 5.02091311e-02f, 3.79342660e-02f, 5.35792788e-04f, -2.99183745e-02f, 4.41486984e-02f, 1.20724952e-02f, 1.09753115e-02f,
  -6.65307865e-02f, 3.41170933e-03f, 1.24489507e-02f, 5.75952157e-02f, 1.54182175e-02f, 1.43849533e-02f, 8.55452567e-02f, -2.51743086e-02f, 3.96542102e-02f, -3.10194995e-02f,
  4.25737314e-02f, 2.38301023e-03f, 4.92154388e-03f, -7.07122171e-03f, 2.59369016e-02f, 7.10348636e-02f, -4.64265645e-02f, 2.25577876e-02f, 2.31102463e-02f, -4.89701815e-02f,
  -2.24369261e-02f, 3.71264219e-02f, 4.17743027e-02f, -4.29286761e-03f, -1.24284467e-02f, -5.39838858e-02f, 9.33726877e-02f, 3.65663245e-02f, 5.90139590e-02f, -3.60798091e-02f,
  -3.12170163e-02f, 1.37800295e-02f, -4.65253405e-02f, 4.04118560e-02f, 3.37830707e-02f, -2.64025619e-03f, -2.92861648e-03f, 1.68615971e-02f, 1.75793208e-02f, -4.98830415e-02f,
  -1.24392971e-01f, -1.11009479e-01f, -4.49591987e-02f, 1.64446924e-02f, -9.17128548e-02f, 2.99353562e-02f, 1.18545652e-03f, -2.54098512e-02f, -3.73199657e-02f, -4.23597023e-02f,
  2.67493688e-02f, -4.36730450e-03f, -4.55533899e-02f, 7.21557140e-02f, 6.58061802e-02f, -1.85005944e-02f, -1.55649744e-02f, 5.37719317e-02f, 3.86181548e-02f, -2.65633240e-02f,
  -4.54994589e-02f, -1.49404369e-02f, 3.67834121e-02f, 5.38657680e-02f, 5.63727207e-02f, -3.47965397e-02f, -2.84784585e-02f, 2.95702927e-02f, 4.26107123e-02f, 1.19912801e-02f,
  2.78180033e-01f, -1.78992465e-01f, 9.76639017e-02f, 9.53236744e-02f, -4.68957284e-03f, 2.19281763e-01f, -5.39652929e-02f, -1.13838017e-02f, -6.09589592e-02f, -2.81520069e-01f,
  -1.25240743e-01f, 1.43095106e-01f, -2.74334133e-01f, 7.39170536e-02f, 3.27767700e-01f, -1.09708644e-01f, 7.61009231e-02f, 7.40121976e-02f, 5.50599471e-02f, -3.47676091e-02f,
  6.98327944e-02f, -1.31545171e-01f, 6.76503554e-02f, -1.33972704e-01f, 9.81646404e-02f, 1.83703322e-02f, -1.81526586e-01f, -1.36276901e-01f, 9.05850679e-02f, 3.46461274e-02f,
  1.00949354e-01f, -9.13980231e-02f, -5.15241968e-03f, 7.92432278e-02f, -3.03565171e-02f, 3.68552729e-02f, 5.33594564e-02f, -3.68278921e-02f, 1.25737656e-02f, -4.24804688e-02f,
  -3.35403122e-02f, 8.84365737e-02f, 7.40654618e-02f, 3.62142250e-02f, 7.57128820e-02f, 3.89830619e-02f, -1.02884853e-02f, 5.42293414e-02f, -3.05796973e-02f, 1.15342103e-01f,
  -2.05077901e-02f, 5.41705601e-02f, 4.51665297e-02f, 3.43784429e-02f, 8.56148079e-02f, -1.21103367e-02f, 3.96656543e-02f, 8.04297477e-02f, 1.59825035e-03f, 1.08882589e-02f,
  4.97830808e-02f, -6.05744272e-02f, -1.51460925e-02f, 4.25556302e-03f, 7.38702575e-03f, -1.15134440e-01f, -8.76630843e-03f, 1.03900703e-02f, -3.59567404e-02f, -1.46591133e-02f,
  -4.25089598e-02f, -1.03146851e-03f, 2.70343740e-02f, -5.94180403e-03f, 1.05088938e-03f, 5.40207652e-03f, -3.18469740e-02f, 3.66937858e-03f, 2.93495171e-02f, 1.54157747e-02f,
  -1.09882370e-01f, -4.00088318e-02f, -3.99350096e-03f, -7.71373569e-04f, -1.26221487e-02f, -3.70967910e-02f, -1.79082900e-02f, 2.26370934e-02f, -1.13939084e-02f, 6.56787530e-02f,
  2.09307335e-02f, -2.29254901e-01f, -6.44551888e-02f, -3.60676572e-02f, 5.50993136e-04f, 2.47135423e-02f, -4.33027148e-02f, 6.40479922e-02f, -7.90501088e-02f, -6.20816424e-02f,
  2.21021622e-02f, -7.08721578e-02f, -2.53767297e-02f, 6.65925210e-03f, 7.56538659e-02f, -2.36614551e-02f, -4.07875329e-02f, -1.93754975e-02f, 1.05951298e-02f, -3.24373716e-03f,
  3.13887163e-03f, -6.29512295e-02f, 1.79659985e-02f, -2.66735163e-02f, -9.01600998e-03f, -2.69543398e-02f, 3.49594615e-02f, 1.41608538e-02f, 3.98782501e-03f, -7.45996684e-02f,
  3.60424779e-02f, -2.01484710e-02f, -2.39375636e-01f, -2.30980534e-02f, 1.72789738e-01f, -6.87402813e-03f, -2.42082298e-01f, 2.49056175e-01f, 1.61457255e-01f, -7.60017410e-02f,
  6.88164607e-02f, -1.08849570e-01f, -1.71897620e-01f, 1.06797088e-02f, 4.53045554e-02f, -7.43549615e-02f, 1.12933040e-01f, -1.13948211e-01f, 3.70843224e-02f, 1.28442362e-01f,
  2.05913894e-02f, 1.27816826e-01f, -6.42093420e-02f, 2.35064745e-01f, -1.62638277e-02f, -3.69244367e-02f, 1.39746100e-01f, -8.53461400e-03f, 4.32225764e-02f, -2.65549850e-02f,
  5.70043921e-02f, 1.13726616e-01f, -4.32029478e-02f, -2.56366767e-02f, 7.68203884e-02f, -2.80469167e-03f, -2.66842097e-02f, -1.21495835e-02f, 7.59060010e-02f, -1.06287533e-02f,
  1.69808771e-02f, 9.30177569e-02f, 9.47989076e-02f, 4.49725874e-02f, -1.30426997e-05f, 7.24439770e-02f, 3.32984142e-02f, -1.10469222e-01f, -7.10998550e-02f, 1.91092957e-02f,
  -4.24113572e-02f, -4.36391607e-02f, -1.12563737e-01f, 2.41669137e-02f, -7.88700357e-02f, -5.93084507e-02f, -1.84903294e-02f, -5.78597263e-02f, -4.70545851e-02f, 7.65957013e-02f,
  2.84580085e-02f, 2.72609144e-02f, -1.72263663e-02f, 7.47573748e-02f, 5.47091663e-02f, 5.81734404e-02f, -4.78491671e-02f, 1.09198345e-02f, -4.81502824e-02f, 5.59694394e-02f,
  -5.71840890e-02f, -2.66529582e-02f, 4.57556359e-02f, -2.98615042e-02f, 5.03423112e-03f, -3.26985046e-02f, -7.99568146e-02f, -1.97214652e-02f, -4.88412241e-03f, -4.41771820e-02f,
  -5.25478646e-02f, 1.89671516e-02f, -4.36868556e-02f, -3.52418385e-02f, 2.28452906e-02f, -5.52650653e-02f, -4.95862328e-02f, -6.94413856e-03f, -9.38738976e-03f, 4.42456221e-04f,
  1.39447436e-01f, 1.93710491e-01f, 2.00971663e-02f, 2.98166834e-02f, -4.08502901e-03f, -3.57183330e-02f, 1.13891726e-02f, 2.33018417e-02f, 7.96506703e-02f, 3.10469735e-02f,
  -1.96111649e-02f, -6.99945912e-02f, 8.80592465e-02f, -1.26299048e-02f, 5.04281409e-02f, -4.30706685e-04f, 3.57933864e-02f, 2.15169461e-03f, 7.14335889e-02f, 7.74418237e-03f,
  -2.46867910e-02f, -5.80938719e-03f, 3.80901666e-03f, -4.71823923e-02f, 4.28138338e-02f, 3.16309035e-02f, 9.16451588e-03f, 2.81011295e-02f, 5.07859886e-02f, -7.00100884e-02f,
  8.92408341e-02f, -2.11773440e-01f, -2.39918485e-01f, 1.31074771e-01f, 7.99556524e-02f, 1.08041756e-01f, 2.03136001e-02f, 8.00368637e-02f, 1.29884213e-01f, 5.62580191e-02f,
  1.76349983e-01f, -1.96097255e-01f, -1.35256782e-01f, 1.52697906e-01f, 4.03119251e-02f, 4.27209288e-02f, 1.88733488e-01f, 9.15395617e-02f, -4.68524918e-02f, 7.34505579e-02f,
  6.64961413e-02f, 2.46965945e-01f, 5.81818856e-02f, -1.24886250e-02f, 1.50633633e-01f, -4.38442491e-02f, 9.90721770e-03f, -8.99351165e-02f, 5.66164590e-02f, -6.64746910e-02f,
  8.63097012e-02f, 8.71190652e-02f, -2.00926047e-02f, -4.38193195e-02f, -4.72574309e-02f, -1.89064499e-02f, -3.68119553e-02f, -1.84195507e-02f, 3.17591690e-02f, -1.15922734e-03f,
  -1.09068707e-01f, 5.17866574e-02f, 4.33750041e-02f, 1.46803875e-02f, 8.00662413e-02f, 7.62210460e-03f, -6.16177246e-02f, 5.49731590e-02f, 4.42342870e-02f, -7.82538652e-02f,
  -2.30744202e-02f, 6.21006787e-02f, 8.74091834e-02f, -3.23214419e-02f, 6.05417080e-02f, -2.87076142e-02f, -5.00280671e-02f, -1.05131648e-01f, 1.58750210e-02f, -3.75557207e-02f,
  -3.38588208e-02f, -5.38956448e-02f, 2.55953539e-02f, 4.81882505e-02f, 7.48445326e-03f, 5.35425320e-02f, -5.48741408e-02f, 5.82111999e-02f, 3.45488712e-02f, 5.44830002e-02f,
  -2.43085884e-02f, -4.85218242e-02f, -7.13069318e-03f, 3.58439125e-02f, 1.35441236e-02f, -3.91340666e-02f, -7.81156868e-02f, -5.25759198e-02f, 2.42770799e-02f, 6.36047944e-02f,
  1.21393539e-02f, 5.35918325e-02f, -5.21110836e-03f, 1.84940770e-02f, 6.83447644e-02f, -3.66975032e-02f, -1.88576318e-02f, 4.17272560e-03f, 2.92323008e-02f, -7.44634345e-02f,
  -2.88444683e-02f, -1.01560034e-01f, -2.16471720e-02f, -1.42393969e-02f, 3.83347236e-02f, -5.07137701e-02f, -4.85446714e-02f, -4.95756418e-02f, 4.38375771e-02f, 1.52247353e-02f,
  4.35305387e-02f, -3.04007456e-02f, -7.60827065e-02f, -5.14458604e-02f, -6.18693642e-02f, 4.16184776e-02f, -2.71167755e-02f, -4.26429249e-02f, 6.65721446e-02f, -2.86393147e-02f,
  5.94763644e-02f, -4.47842889e-02f, 4.25939523e-02f, 7.06490576e-02f, 1.42234089e-02f, 4.73607183e-02f, -6.75815344e-02f, 2.42011584e-02f, -3.02111078e-02f, -5.54403402e-02f,
  5.47410883e-02f, -1.51702970e-01f, -1.37064427e-01f, 1.73248842e-01f, 5.64683266e-02f, 3.19182128e-01f, 1.68026149e-01f, -6.51759282e-02f, 1.47630259e-01f, -9.92503539e-02f,
  -2.77553741e-02f, -7.12606534e-02f, -1.72588482e-01f, 1.64262772e-01f, 2.47884989e-01f, -3.83786447e-02f, 1.79821253e-01f, 7.23979995e-02f, -1.54043753e-02f, -9.91697535e-02f,
  1.37931064e-01f, 5.39495014e-02f, -3.67897637e-02f, -3.44501249e-02f, -4.53593917e-02f, -1.53824195e-01f, -5.44197969e-02f, -2.14498490e-01f, 1.12077072e-01f, 9.60009322e-02f,
  2.87535670e-03f, -7.33920932e-02f, -2.57206615e-02f, 2.26825718e-02f, 6.82928599e-03f, -5.87777123e-02f, -3.74918282e-02f, 5.77134416e-02f, -3.09235286e-02f, -3.91432531e-02f,
  -3.53379138e-02f, -1.76844448e-02f, 8.99772570e-02f, -3.07048205e-02f, 6.23759702e-02f, 1.32733118e-02f, -2.52263974e-02f, 6.39588311e-02f, -5.73799424e-02f, -5.81356175e-02f,
  1.42742340e-02f, -4.97102104e-02f, -1.41626745e-02f, 6.24697246e-02f, 4.92221625e-05f, -8.69277027e-03f, -5.58662824e-02f, -4.25552018e-02f, -4.32526432e-02f, -3.63140227e-03f,
  1.93063468e-02f, 5.14768139e-02f, 6.50981367e-02f, -1.59857348e-02f, 5.09731695e-02f, 1.13654854e-02f, 3.25430147e-02f, -6.34615421e-02f, -4.72877510e-02f, 3.27236354e-02f,
  5.50837591e-02f, 5.92774414e-02f, 5.47702704e-03f, 2.36098412e-02f, -1.99492015e-02f, 1.26398485e-02f, -2.59873923e-02f, 1.18940165e-02f, 6.40629157e-02f, -2.49908809e-02f,
  -3.27610672e-02f, -9.57213750e-04f, 2.77782753e-02f, -6.66073486e-02f, 4.94511379e-03f, -1.46583673e-02f, -9.10783485e-02f, -2.46875547e-02f, -4.36874628e-02f, -6.55513117e-03f,
  9.53339338e-02f, -1.19778246e-01f, 5.91246262e-02f, -2.99917385e-02f, 3.43576968e-02f, 7.31984377e-02f, 2.39424710e-03f, 4.03921120e-02f, 4.58774716e-02f, 8.91382843e-02f,
  3.01222354e-02f, -2.49626283e-02f, 3.69049534e-02f, 6.18550703e-02f, 3.74703296e-02f, 7.65192732e-02f, 1.73569340e-02f, -1.87830478e-02f, -1.75132565e-02f, -5.32009825e-02f,
  -5.54965101e-02f, -8.66922364e-03f, 2.51757521e-02f, 1.43501461e-02f, -6.09566784e-03f, -5.72892986e-02f, -7.15397578e-03f, -5.64374700e-02f, 9.98141151e-03f, 6.49780184e-02f,
  4.98541117e-01f, -4.98290002e-01f, -1.72679842e-01f, 2.25587323e-01f, 1.11186497e-01f, 9.81909484e-02f, 1.20400965e-01f, -1.18935844e-02f, 1.49768710e-01f, -1.38032973e-01f,
  -8.69340077e-02f, -1.87209509e-02f, -2.62139529e-01f, -1.62254840e-01f, 2.60524124e-01f, -1.52046710e-01f, 4.52970788e-02f, -6.31462643e-03f, 2.73238402e-02f, 7.17825219e-02f,
  1.52202949e-01f, 3.58196199e-02f, -1.95246175e-01f, -1.75615475e-01f, -4.76646610e-02f, -1.65644139e-02f, -4.93626259e-02f, -1.03270248e-01f, -1.23239651e-01f, 4.18028347e-02f,
  -8.68462771e-02f, -6.90780729e-02f, -1.10527880e-01f, -1.59742180e-02f, 5.92450649e-02f, 3.52396704e-02f, 2.97158714e-02f, 3.86808999e-02f, 2.05702391e-02f, 7.12275505e-03f,
  6.99113607e-02f, 4.50571626e-02f, -3.92238470e-03f, -1.73635650e-02f, 5.34234755e-02f, 7.43049197e-04f, 2.27072332e-02f, 6.65688887e-03f, -4.73701432e-02f, -4.56117056e-02f,
  -5.01648150e-02f, -6.17631301e-02f, 3.06050293e-02f, 1.36970431e-02f, 9.11517185e-04f, 2.46634204e-02f, -3.73508669e-02f, -5.88225946e-02f, 1.19251031e-02f, 3.24868672e-02f,
  6.31592721e-02f, -4.31486070e-02f, -3.89005132e-02f, -5.40211983e-02f, -7.80448783e-03f, -3.22506428e-02f, -6.81873038e-03f, -3.66077386e-02f, 2.04963721e-02f, -2.98112314e-02f,
  8.25055540e-02f, -3.76628898e-02f, -6.30468549e-03f, 3.39378826e-02f, 1.19888736e-02f, 4.79110843e-03f, -5.19899535e-04f, 3.05171907e-02f, 4.55045998e-02f, -5.57773700e-03f,
  -1.00260926e-02f, 2.28453632e-02f, -6.13187328e-02f, 3.02399285e-02f, -5.58973514e-02f, -2.28141043e-02f, -3.01159290e-03f, 6.79766340e-03f, 2.49684229e-02f, 5.16958237e-02f,
  6.67609321e-03f, 4.39415723e-02f, 2.30361111e-02f, -4.50064838e-02f, -4.46823053e-03f, 3.17532802e-03f, -2.15282030e-02f, -2.45217569e-02f, -1.08754681e-02f, 2.94450596e-02f,
  -2.58351443e-03f, 5.21951839e-02f, 3.01766396e-02f, 2.03369604e-03f, 1.36670237e-02f, -6.13507144e-02f, -4.19391803e-02f, 1.80530529e-02f, 4.84961569e-02f, 3.28703187e-02f,
  -2.06863005e-02f, 4.45640571e-02f, 6.40711235e-03f, 6.75311312e-02f, 5.77134378e-02f, -3.26195955e-02f, 8.59127492e-02f, 2.83817053e-02f, -3.67929488e-02f, 6.48077764e-03f,
  7.27879182e-02f, -1.16002355e-02f, 2.63630897e-01f, 6.01524971e-02f, 1.98159534e-02f, 1.92247987e-01f, 1.11039765e-01f, 1.34066656e-01f, 3.09474617e-01f, -2.00162932e-01f,
  -1.85658187e-01f, 9.62196290e-02f, -2.80275941e-02f, -7.14279562e-02f, 3.17034811e-01f, 8.05027634e-02f, 1.17608514e-02f, -7.19442870e-03f, 2.62499064e-01f, 5.84306456e-02f,
  1.31615758e-01f, -9.68665481e-02f, -2.58295238e-02f, -5.61548397e-02f, -1.35308653e-01f, -8.45108107e-02f, -3.03884596e-01f, -1.10535510e-02f, -8.75094458e-02f, 1.03899844e-01f,
  6.09450452e-02f, 4.53888774e-02f, -8.32764879e-02f, 2.53390055e-02f, -5.91960363e-02f, -6.64483905e-02f, 4.53772023e-03f, 4.92991805e-02f, 5.93681447e-02f, 7.63301700e-02f,
  -7.12539926e-02f, -6.44377572e-03f, -9.72763076e-03f, 2.48496588e-02f, 2.18422059e-02f, 2.39619501e-02f, 3.74683775e-02f, -6.60946444e-02f, 2.77290400e-02f, 2.36742031e-02f,
  2.85482239e-02f, 3.78564978e-03f, -1.05746835e-03f, -8.69414285e-02f, 2.50228378e-03f, -3.28031816e-02f, -1.53542198e-02f, -2.43357811e-02f, -2.37660520e-02f, 6.34045228e-02f,
  3.16833407e-02f, -1.26177790e-02f, -5.05794846e-02f, 3.54400347e-03f, -6.47803396e-02f, -7.63379112e-02f, -5.02319038e-02f, -8.56517698e-04f, -6.22458346e-02f, -1.12672202e-01f,
  7.61202537e-03f, -6.60890490e-02f, -4.42661764e-03f, -5.27573191e-02f, 3.25840227e-02f, -1.04324948e-02f, 4.43063751e-02f, -3.31362970e-02f, 4.30627912e-02f, -5.35164699e-02f,
  6.43318594e-02f, 8.28091614e-03f, -8.78888294e-02f, -4.39408831e-02f, -1.42019195e-03f, 4.49403897e-02f, -5.40998206e-02f, 6.49362355e-02f, 6.38968172e-03f, -5.62854037e-02f,
  -3.80774327e-02f, 1.04353100e-01f, -7.54670352e-02f, -8.65489468e-02f, -4.94050086e-02f, 3.24607976e-02f, 6.04424067e-02f, -6.52448982e-02f, 6.60254657e-02f, 3.22488472e-02f,
  -4.88525964e-02f, -7.20615685e-02f, -2.38882266e-02f, 3.66285518e-02f, -2.41169240e-02f, -4.09718007e-02f, -5.99488709e-03f, 4.10321541e-02f, -9.78554506e-03f, -1.34763764e-02f,
  -6.13006838e-02f, -5.28857820e-02f, -8.15007910e-02f, 3.10687311e-02f, -8.61664191e-02f, -8.17774460e-02f, 8.02458748e-02f, 1.71996243e-02f, -5.02358377e-02f, -2.44791191e-02f,
  -2.49946430e-01f, 2.96188127e-02f, 7.55583867e-02f, -3.70343886e-02f, 7.87781999e-02f, 3.29725593e-01f, 1.93425506e-01f, -3.71513180e-02f, -4.68798578e-02f, -4.06074598e-02f,
  -4.58674282e-02f, 9.97520424e-03f, -9.27647129e-02f, 1.23286605e-01f, 9.55238715e-02f, 1.29476935e-01f, 9.45633501e-02f, -3.23671997e-02f, 9.77085531e-02f, -6.94240555e-02f,
  3.32903042e-02f, -7.27839768e-02f, 9.72085819e-02f, 1.73406284e-02f, 2.63401214e-03f, -1.29732743e-01f, -1.53624788e-01f, 7.92921185e-02f, 9.21643898e-02f, 1.35769978e-01f,
  8.82941019e-03f, -2.34136477e-01f, 2.67734006e-02f, -4.44581211e-02f, -6.95157349e-02f, -6.97042421e-02f, 4.66050394e-02f, 6.70157671e-02f, -1.95018835e-02f, -5.63012548e-02f,
  -3.62916812e-02f, 8.47064108e-02f, -3.59058045e-02f, -1.84392203e-02f, -1.75199043e-02f, -4.85938638e-02f, 1.63234789e-02f, -1.31130079e-02f, 4.35141772e-02f, 2.87959427e-02f,
  1.43798990e-02f, 6.38007224e-02f, 2.92789917e-02f, -4.85103054e-04f, -3.52449641e-02f, 7.29423063e-03f, 1.04649022e-01f, 3.91925164e-02f, 1.39657799e-02f, -5.37576601e-02f,
  2.58838665e-02f, -1.29246488e-02f, -3.34490873e-02f, -4.40088101e-02f, -1.47562437e-02f, 2.50626393e-02f, -5.82300732e-03f, -7.35673159e-02f, 3.14238630e-02f, 2.87490264e-02f,
  -2.28977762e-02f, -5.46886679e-03f, 2.25387234e-02f, 6.98862895e-02f, 6.72200462e-03f, 5.78785129e-02f, 2.76625641e-02f, 5.56079857e-02f, -5.65740801e-02f, 3.78666706e-02f,
  2.23321058e-02f, 4.90995534e-02f, -4.01866809e-03f, 5.42661138e-02f, -9.00550466e-03f, -4.82719243e-02f, 6.14386331e-03f, -4.11140099e-02f, -2.92562880e-02f, 4.28906232e-02f,
  -3.50218378e-02f, -2.73176312e-01f, -1.32334009e-02f, 7.80011192e-02f, -1.23191543e-03f, 6.66812574e-03f, 9.47672501e-03f, -5.42936362e-02f, -3.64004076e-02f, 6.82536289e-02f,
  -1.81275383e-02f, -1.86569039e-02f, 3.02096363e-02f, 7.03707412e-02f, 5.33073023e-03f, -2.95486934e-02f, 1.72068793e-02f, -6.56042947e-03f, -6.55370429e-02f, 2.49175280e-02f,
  1.14278058e-02f, -1.82263069e-02f, -1.57057180e-03f, -9.84564796e-02f, 5.94587401e-02f, -6.70443177e-02f, -9.72500592e-02f, -3.42637226e-02f, -1.04811164e-02f, 5.45993336e-02f,
  -2.52239287e-01f, -3.33140697e-03f, -1.17149740e-01f, -3.27197075e-01f, 8.79790038e-02f, 1.82282984e-01f, -1.81880176e-01f, -2.43888162e-02f, -2.27664605e-01f, -8.60661417e-02f,
  -2.09036507e-02f, -2.08414808e-01f, 1.64034605e-01f, -2.00614110e-01f, 9.45166275e-02f, 5.42614085e-04f, -7.93901011e-02f, -1.59315214e-01f, 3.27513106e-02f, -1.02391839e-01f,
  -8.15289244e-02f, 6.28448045e-03f, 1.54776201e-02f, 1.66165337e-01f, -1.18310407e-01f, -1.26962885e-01f, 4.83588735e-03f, 1.45957112e-01f, -9.26316679e-02f, 1.56141594e-01f,
  1.05999395e-01f, -1.03539810e-01f, -9.30172950e-03f, -3.18204658e-03f, -6.24311576e-03f, -1.94621589e-02f, 4.22478542e-02f, 4.09220122e-02f, -6.30966127e-02f, -5.59219643e-02f,
  -7.71221817e-02f, -2.03123223e-02f, 4.47954703e-03f, 3.91584262e-02f, -1.34288948e-02f, 1.58732720e-02f, 2.83534080e-02f, 6.43877387e-02f, -5.18584577e-03f, 4.19934792e-03f,
  1.02362102e-02f, -4.33859155e-02f, -1.42271603e-02f, -4.27487344e-02f, -1.97452176e-02f, -2.57774200e-02f, -2.86142044e-02f, 3.12355570e-02f, 5.35502797e-03f, -5.74283339e-02f,
  -8.47181585e-03f, 4.15152907e-02f, -1.66976601e-02f, 2.69664302e-02f, 5.84711172e-02f, 4.94152829e-02f, 2.42972709e-02f, 8.63648877e-02f, -6.69339746e-02f, 7.14640766e-02f,
  1.82507187e-02f, -5.45581914e-02f, -4.36445810e-02f, 1.76052880e-02f, -1.04849942e-01f, -6.93165883e-02f, -1.23603931e-02f, -2.28251051e-02f, 4.38900813e-02f, 2.69197058e-02f,
  -4.55116443e-02f, -7.08928630e-02f, -3.35069001e-02f, 2.59739272e-02f, 1.26230251e-02f, 9.46686231e-03f, 1.07377507e-02f, 4.99240197e-02f, 8.67221057e-02f, -5.61407348e-03f,
  -8.79905149e-02f, -1.68749601e-01f, 1.99950188e-02f, -2.80572269e-02f, -7.56675238e-03f, 5.77351898e-02f, -5.14606759e-03f, -2.73496774e-03f, -6.32579178e-02f, 5.70872203e-02f,
  2.76338384e-02f, -1.78328692e-03f, -2.03928091e-02f, -1.36904558e-02f, 2.18107644e-03f, -5.24116941e-02f, -6.36131167e-02f, -4.30086628e-02f, -1.32124254e-03f, -1.26484465e-02f,
  1.00394236e-02f, 1.79468635e-02f, -1.39038237e-02f, -1.66043900e-02f, -1.86819490e-02f, -5.55540100e-02f, 4.14548703e-02f, 2.08443739e-02f, -3.05400584e-02f, 5.66019863e-02f,
  -1.75559536e-01f, 2.23599579e-02f, -1.43376246e-01f, 1.58770084e-02f, 1.84856325e-01f, -1.30777761e-01f, -1.32323071e-01f, -3.81935984e-02f, -2.52408952e-01f, 1.19983390e-01f,
  5.11802062e-02f, 5.84117360e-02f, -1.47660658e-01f, 4.12648357e-03f, -3.79337698e-01f, -3.25498164e-01f, -1.10987179e-01f, -4.48199026e-02f, -9.29556862e-02f, -3.88218798e-02f,
  -1.03404634e-01f, 1.66960564e-02f, -1.59792513e-01f, 1.81356922e-01f, 1.30340531e-01f, 7.37920552e-02f, 1.80149600e-01f, 8.66556689e-02f, 2.46601090e-01f, 7.99698755e-02f,
  3.22542228e-02f, 3.89264221e-03f, -3.50521808e-03f, 2.31393334e-02f, -2.42032129e-02f, 8.12724158e-02f, 6.09808043e-02f, 1.03347167e-01f, -1.62867550e-02f, 3.87976272e-03f,
  3.80109809e-02f, 2.37770695e-02f, 3.73013467e-02f, -2.47317366e-03f, 3.87809239e-02f, 4.97006513e-02f, 6.96410015e-02f, 2.31251083e-02f, 4.44279239e-02f, -4.15357528e-03f,
  -5.51808365e-02f, 1.68777164e-02f, 4.52008471e-02f, -3.09219072e-03f, -5.90455011e-02f, -4.41471227e-02f, -7.08515421e-02f, -4.68231291e-02f, -2.56095212e-02f, -5.57737015e-02f,
  1.52787846e-02f, -4.51401919e-02f, -6.27046824e-02f, -3.46084647e-02f, -7.93596671e-04f, 7.76108652e-02f, -1.29057104e-02f, 2.05919668e-02f, -5.02094813e-03f, 1.18339583e-02f,
  6.38069678e-03f, 4.13479172e-02f, 2.20090896e-02f, 5.27212350e-03f, 3.03463098e-02f, 2.43831961e-03f, 2.97169741e-02f, 2.93846000e-02f, -4.70194966e-02f, 2.91572493e-02f,
  1.06041078e-02f, -2.69598141e-02f, 5.35739250e-02f, 2.13218909e-02f, -1.87508315e-02f, 2.09163371e-02f, 6.59130886e-02f, -4.29761186e-02f, 3.16996761e-02f, -5.92951104e-02f,
  2.46078963e-03f, -1.50915056e-01f, -2.59599257e-02f, 4.23228070e-02f, 2.54523959e-02f, 5.35036810e-03f, -2.08886731e-02f, -4.66648936e-02f, -5.55534400e-02f, -1.06077567e-01f,
  3.13001350e-02f, -2.04015784e-02f, -2.36639921e-02f, 5.62921427e-02f, 3.69164604e-03f, -8.80064294e-02f, -2.47823447e-03f, 1.30152041e-02f, 2.74659637e-02f, 1.02036066e-01f,
  5.02789840e-02f, 5.61970882e-02f, -4.57083099e-02f, 1.67929232e-02f, 3.72167677e-02f, 8.00795704e-02f, 5.10822870e-02f, 5.85382245e-02f, 2.90749110e-02f, 2.85532326e-02f,
  -1.18489906e-01f, -2.10314140e-01f, -2.85721093e-01f, -1.52127698e-01f, -9.17442888e-03f, -2.62637213e-02f, 1.61885485e-01f, -7.57990628e-02f, -1.26063228e-01f, 1.25495106e-01f,
  2.60336697e-01f, -9.77630168e-02f, 1.68505490e-01f, 1.80467784e-01f, 2.49866515e-01f, 2.22881928e-01f, 1.20866783e-01f, 3.91577296e-02f, -1.00787461e-01f, -3.40842195e-02f,
  -4.23055701e-02f, 2.77931213e-01f, 4.56890985e-02f, -1.40124634e-01f, -7.77566209e-02f, -2.11914390e-01f, 8.33212510e-02f, -9.22871083e-02f, 2.15123929e-02f, 1.52754933e-01f,
  -8.34432468e-02f, 6.46806806e-02f, -8.93137902e-02f, -3.66715305e-02f, -2.89463438e-02f, -3.07104625e-02f, 4.59792931e-03f, 1.52453873e-03f, -7.17703328e-02f, -5.44635355e-02f,
  -6.95974901e-02f, 1.21830059e-02f, 7.61885429e-03f, 3.37729305e-02f, -9.14443210e-02f, -1.00365244e-01f, -7.72251487e-02f, 1.01362215e-02f, -7.82904923e-02f, -3.97684537e-02f,
  -4.55665924e-02f, -2.99494136e-02f, 1.89209487e-02f, 4.46456624e-03f, -4.43294197e-02f, 4.37666383e-03f, -3.79174240e-02f, -2.38205325e-02f, 4.66415361e-02f, 1.88453924e-02f,
  1.27586490e-02f, 2.94727590e-02f, 6.10839650e-02f, -8.68865196e-03f, -4.05309945e-02f, -2.99314279e-02f, 1.82350557e-02f, -2.50501502e-02f, -6.31864220e-02f, 2.52026739e-03f,
  2.66419966e-02f, -1.62671134e-02f, 5.06540909e-02f, -1.92490090e-02f, 2.74310783e-02f, -6.73470199e-02f, 9.72285774e-03f, 4.81633432e-02f, -1.45765068e-02f, -7.14125559e-02f,
  6.03325292e-02f, 2.96780560e-02f, 5.64560294e-02f, -2.22364664e-02f, -6.58081658e-03f, -1.15161892e-02f, -1.65569764e-02f, -3.46885547e-02f, 3.82541791e-02f, 5.71066067e-02f,
  6.43605664e-02f, 7.14498311e-02f, 1.87910888e-02f, 4.34754863e-02f, -5.12286946e-02f, 3.31415143e-03f, 2.23947726e-02f, -6.08259579e-03f, 9.16057229e-02f, 6.16107322e-02f,
  4.15326376e-03f, -9.55134183e-02f, -4.01953459e-02f, -2.12228242e-02f, 3.80852520e-02f, 1.88375674e-02f, 1.05193242e-01f, -3.24551240e-02f, 1.21830709e-01f, -4.29453291e-02f,
  -6.12138025e-03f, 9.60779004e-03f, -2.93478253e-03f, -5.27621284e-02f, 6.57800213e-02f, -2.30069198e-02f, 3.97025235e-02f, -4.98153009e-02f, -7.77661148e-03f, -3.47269773e-02f,
  6.73620254e-02f, -1.34066910e-01f, -1.75299823e-01f, 5.95647953e-02f, -9.06588882e-02f, -2.34518051e-02f, -3.54783013e-02f, 8.16103369e-02f, -1.88197494e-02f, 1.19424626e-01f,
  3.32471877e-02f, 7.91270193e-03f, -1.23240307e-01f, 3.09584379e-01f, 2.66462266e-01f, -3.77483331e-02f, 2.78599799e-01f, 1.23793349e-01f, 2.15389896e-02f, -1.02259200e-02f,
  9.31312591e-02f, 2.89808840e-01f, 2.32711602e-02f, 9.44834128e-02f, 1.63827479e-01f, 1.58173144e-02f, 2.10980117e-01f, -1.34107023e-01f, 1.39048219e-01f, 6.54383898e-02f,
  -2.77116112e-02f, 5.63896224e-02f, -1.11217931e-01f, 3.42067727e-03f, 4.19240482e-02f, -1.12529039e-01f, -5.23487292e-02f, -5.53550124e-02f, 4.11216868e-03f, 6.74636662e-02f,
  -3.97827514e-02f, -6.87908158e-02f, -2.63128579e-02f, -3.98799330e-02f, -7.92428628e-02f, -1.77934803e-02f, -9.07073729e-03f, 2.10483056e-02f, 5.03252335e-02f, 3.90892588e-02f,
  -3.17762718e-02f, 3.29891294e-02f, 4.51248586e-02f, -2.05327068e-02f, 4.70680073e-02f, -2.56980173e-02f, 5.55951195e-03f, 1.14075746e-02f, -2.22367793e-02f, 1.64322238e-02f,
  5.32891564e-02f, 7.44872019e-02f, 3.19177434e-02f, 4.18604165e-03f, 6.22160509e-02f, -1.18094850e-02f, -2.77922954e-02f, 7.38425627e-02f, -5.35509810e-02f, -7.17838574e-03f,
  6.19352087e-02f, -1.31962784e-02f, -4.70553190e-02f, 1.50897820e-02f, 5.62298521e-02f, 4.69244905e-02f, 2.70932186e-02f, 5.25078028e-02f, 4.63136584e-02f, 4.36001122e-02f,
  -2.38092970e-02f, 7.21021965e-02f, 1.03281057e-02f, 5.44267856e-02f, 6.55058995e-02f, -2.97734421e-02f, 4.12964411e-02f, 5.92005476e-02f, 6.74522892e-02f, 1.69609524e-02f,
  5.18825240e-02f, 6.71993420e-02f, -5.33880554e-02f, 2.53508482e-02f, -2.58707791e-03f, 4.81721908e-02f, -1.48416124e-02f, 3.91758941e-02f, 1.31408963e-02f, 5.33026308e-02f,
  -5.07746711e-02f, 5.84154129e-02f, 5.06257638e-02f, -2.50470471e-02f, 5.88170364e-02f, 5.28289797e-03f, 9.83629897e-02f, 2.90459059e-02f, 5.00824563e-02f, -1.75485183e-02f,
  -4.05345373e-02f, -3.19836326e-02f, -4.88796458e-02f, 3.55972797e-02f, -3.58344093e-02f, 6.10847771e-02f, -5.88985495e-02f, -9.45640504e-02f, 2.72159725e-02f, 6.42242702e-03f,
  2.61858821e-01f, -3.94218937e-02f, 2.21383095e-01f, 2.70119995e-01f, -5.28409295e-02f, -1.88315943e-01f, -1.05846122e-01f, 8.01950172e-02f, 3.03534180e-01f, -2.26415470e-01f,
  -1.35618657e-01f, 1.21536449e-01f, -1.49330080e-01f, -2.97652874e-02f, 1.29761994e-01f, 1.58616640e-02f, 9.34551135e-02f, -1.27023578e-01f, 9.06254202e-02f, 1.39576465e-01f,
  1.85802802e-01f, -1.06142603e-01f, 8.56131166e-02f, -7.31617808e-02f, -5.48853166e-03f, 5.12359105e-02f, 7.47597776e-03f, -2.78127473e-02f, -9.29769129e-02f, 1.03143845e-02f,
  -4.91678640e-02f, 1.63509175e-01f, 1.20772757e-02f, 9.39231738e-03f, -3.86403687e-02f, -9.35924873e-02f, -1.86804328e-02f, -3.05120125e-02f, -2.34210771e-02f, 5.31472825e-02f,
  -4.84727658e-02f, -1.21661006e-02f, 6.44619763e-02f, 4.55186144e-02f, 1.99441202e-02f, 3.55940759e-02f, 3.26036215e-02f, 3.08004953e-02f, 3.96131463e-02f, 6.56633452e-02f,
  6.14782162e-02f, 5.08211851e-02f, 7.94665292e-02f, 2.33940743e-02f, -2.07803701e-03f, 4.47151251e-02f, -6.13689832e-02f, -6.95002675e-02f, 5.11780716e-02f, 1.11760199e-02f,
  -1.49182072e-02f, -7.97711760e-02f, -6.60754591e-02f, 5.70475310e-02f, 4.06943262e-02f, -1.10708969e-02f, -1.56413056e-02f, 4.13835654e-03f, 6.02766909e-02f, 2.93772463e-02f,
  -2.04088017e-02f, 6.27498627e-02f, 3.81584577e-02f, -2.46113203e-02f, 1.63964331e-02f, 2.52073118e-03f, -4.52901535e-02f, 3.72462571e-02f, 2.19003558e-02f, 3.15765515e-02f,
  -1.03924777e-02f, 3.70620079e-02f, 2.48930920e-02f, -1.36438115e-02f, -5.08564524e-02f, 5.79052344e-02f, -1.43069476e-02f, -1.95053332e-02f, -1.93239393e-04f, 5.83458133e-02f,
  -1.35710640e-02f, 1.77076057e-01f, -4.96594980e-02f, 1.36689153e-02f, -4.30355407e-02f, 2.31592245e-02f, -1.00329276e-02f, 7.64449313e-02f, 4.83673029e-02f, 6.29809201e-02f,
  -1.67383756e-02f, 4.19114791e-02f, -6.28937259e-02f, -4.87965941e-02f, -4.71290872e-02f, 2.26091295e-02f, -1.33560761e-03f, -5.38851954e-02f, 3.37270014e-02f, -1.56639088e-02f,
  -5.95391989e-02f, 3.46577279e-02f, 2.89141256e-02f, 1.66817009e-02f, -5.62819242e-02f, 7.53108878e-04f, 1.08473517e-01f, -2.50367746e-02f, -3.53165455e-02f, 6.86009899e-02f,
  3.09556033e-02f, -1.44483387e-01f, 1.86820269e-01f, 1.03495769e-01f, 7.54011720e-02f, -4.17279080e-02f, -1.32060885e-01f, 5.05085327e-02f, -5.50564073e-05f, -2.95140535e-01f,
  5.52348346e-02f, -6.11574017e-02f, 2.89738621e-03f, 6.30349666e-02f, -3.22114639e-02f, 4.79613021e-02f, -1.44680232e-01f, -7.26217106e-02f, 5.77538311e-02f, -9.73071754e-02f,
  -1.94828864e-02f, -2.47917753e-02f, 1.49831772e-02f, 7.87491724e-02f, 7.94009641e-02f, 1.13281697e-01f, -9.02152434e-02f, 8.63671601e-02f, 9.71081629e-02f, 6.15233816e-02f,
  -9.36318859e-02f, -1.17966443e-01f, -4.32278104e-02f, -5.00942953e-02f, -1.84161812e-02f, 3.96399125e-02f, 1.62114799e-02f, 1.73830185e-02f, 5.79672977e-02f, -1.48389759e-02f,
  -5.59977889e-02f, 6.51033372e-02f, 9.62960869e-02f, 3.25978808e-02f, 4.09153849e-02f, 3.18670273e-02f, 9.34253708e-02f, 4.38055769e-02f, -1.89742204e-02f, 1.05039831e-02f,
  7.25592747e-02f, -7.91195221e-03f, 4.76242937e-02f, -1.12913392e-01f, 3.03112157e-02f, 3.14445025e-03f, -3.23868804e-02f, 4.81886491e-02f, 4.44725435e-03f, 3.52544449e-02f,
  -1.40181091e-02f, -4.51474711e-02f, -7.00961575e-02f, -1.84092261e-02f, -6.16724230e-02f, -3.04356720e-02f, -5.33883609e-02f, 3.19291204e-02f, 3.64506766e-02f, 1.51078645e-02f,
  -3.24543118e-02f, -1.18225776e-02f, -2.46462375e-02f, -2.53774934e-02f, 4.11364995e-02f, -2.44150795e-02f, 5.73902875e-02f, -9.13187489e-02f, 1.46758053e-02f, 3.81347351e-02f,
  -4.29791883e-02f, 1.81493070e-02f, -7.66186975e-03f, -4.35816795e-02f, -5.07229678e-02f, 6.54715300e-02f, 1.32538229e-02f, -2.62807682e-02f, -6.66314662e-02f, 1.99013716e-03f,
  -2.24390745e-01f, -1.50315210e-01f, -7.51949474e-02f, 1.83757581e-02f, 1.50929149e-02f, -9.30264890e-02f, 2.51770038e-02f, -6.30963445e-02f, 3.04563586e-02f, -1.05665937e-01f,
  -9.14142802e-02f, 5.97148947e-02f, 3.70587446e-02f, -5.12344725e-02f, -8.64553154e-02f, 3.56479250e-02f, -6.30575866e-02f, -6.02323152e-02f, -5.60625456e-03f, 4.67205197e-02f,
  -6.29478246e-02f, -1.11445058e-02f, -5.00171678e-03f, -2.90798582e-02f, 3.72338593e-02f, 9.89525765e-03f, -4.53399271e-02f, -1.75406821e-02f, -3.84192988e-02f, 4.31193821e-02f,
  5.51964017e-03f, -1.20845355e-01f, 1.78289175e-01f, 4.01250012e-02f, 8.38994980e-02f, -1.93247825e-01f, -3.25178392e-02f, 8.70595723e-02f, 1.27829090e-01f, -6.46540672e-02f,
  -5.59471622e-02f, -3.67493480e-02f, 8.32606182e-02f, -2.52646744e-01f, -4.18925397e-02f, -1.10387146e-01f, -2.67693311e-01f, -7.83873647e-02f, -5.10519147e-02f, -1.29435524e-01f,
  2.10031942e-02f, -1.29325151e-01f, -6.02122284e-02f, -3.91774215e-02f, 3.06526758e-02f, 8.55720267e-02f, -3.68608423e-02f, 2.03853920e-01f, -1.16380133e-01f, 2.63382103e-02f,
  -5.00274561e-02f, 8.05653334e-02f, -2.80587398e-03f, 2.79027410e-02f, -7.58508146e-02f, -5.70942871e-02f, -3.52177545e-02f, 2.92049814e-02f, 9.22539756e-02f, -1.58057362e-02f,
  -1.36341527e-02f, -9.72552411e-03f, -1.41152982e-02f, 7.65139684e-02f, 6.86809793e-02f, 5.74233867e-02f, -3.41418497e-02f, -9.12683643e-03f, 7.57620856e-02f, -2.79152915e-02f,
  -2.84098983e-02f, -6.04325794e-02f, -2.91464739e-02f, 3.01337205e-02f, -2.09726077e-02f, 1.84235591e-02f, 3.28059949e-04f, 5.65309301e-02f, -6.52092099e-02f, -5.54301739e-02f,
  -4.81116623e-02f, -2.15796269e-02f, 1.57435145e-02f, -1.06439749e-02f, 2.02863105e-02f, 3.04772854e-02f, -4.55049127e-02f, 5.60041666e-02f, -1.02302572e-02f, -3.86253893e-02f,
  -3.73323448e-02f, -2.01597717e-02f, 9.85088013e-03f, -9.03050881e-03f, -8.71219113e-02f, -7.08163306e-02f, -1.49764186e-02f, -4.62880619e-02f, -4.12354358e-02f, -3.22754718e-02f,
  1.79293603e-02f, -8.58468097e-03f, 1.25327623e-02f, -7.25417351e-03f, -2.94759236e-02f, 5.07822782e-02f, 2.43751127e-02f, 1.04799494e-02f, 5.10493526e-03f, 4.09632847e-02f,
  -6.21938854e-02f, -1.39737517e-01f, 1.29583920e-03f, 7.87112340e-02f, -1.72487367e-03f, -9.05366912e-02f, -8.61589164e-02f, -6.14000969e-02f, -2.68458687e-02f, 3.64009179e-02f,
  3.73405230e-04f, 8.13651681e-02f, 4.47554663e-02f, -1.74345188e-02f, 5.37420511e-02f, -7.70151541e-02f, -4.66895029e-02f, -3.73314917e-02f, -6.38644844e-02f, -4.09390219e-02f,
  3.08209024e-02f, -4.24862020e-02f, 1.01159988e-02f, -4.45385370e-03f, 4.41164570e-03f, -1.23126637e-02f, -2.09477004e-02f, 1.56720467e-02f, 4.49001230e-02f, -7.49032646e-02f,
  -1.60183549e-01f, 9.32154059e-02f, -2.13213831e-01f, 1.49253458e-01f, 2.11806729e-01f, 1.84489056e-01f, 1.46327214e-03f, 2.45498449e-01f, 1.25686198e-01f, -1.10975280e-02f,
  5.94171509e-02f, -8.00024495e-02f, -2.39982128e-01f, 1.39935225e-01f, -9.81370062e-02f, -8.03257525e-02f, 1.43253759e-01f, 6.39535114e-02f, 4.97373417e-02f, 1.38927639e-01f,
  5.58775142e-02f, 2.13040054e-01f, -1.46290317e-01f, 2.12227419e-01f, 8.99276212e-02f, 8.49545151e-02f, -8.13355744e-02f, -5.31885661e-02f, 1.13999404e-01f, -6.14331337e-03f,
  -6.47515133e-02f, 1.29454643e-01f, -9.75918546e-02f, -1.43145457e-01f, -1.21000983e-01f, -1.14586167e-01f, -1.12199001e-01f, -1.26201779e-01f, 3.56621780e-02f, 3.12072970e-02f,
  -1.27147123e-01f, 6.27765581e-02f, 4.44963835e-02f, 2.35080831e-02f, 2.09626742e-02f, -3.98569815e-02f, 9.23336893e-02f, 6.98025012e-03f, 5.99408485e-02f, -8.42055213e-03f,
  3.47082056e-02f, 7.15492014e-03f, 2.92229708e-02f, 3.75481434e-02f, 3.69857587e-02f, 4.51794341e-02f, -1.35337114e-02f, -8.59008655e-02f, 7.18902647e-02f, 1.12082951e-01f,
  -3.34362276e-02f, -1.97101180e-02f, -4.72899294e-03f, -5.38388826e-03f, -1.08511727e-02f, 1.75286047e-02f, -1.87768713e-02f, -5.80076240e-02f, 3.23679596e-02f, -4.56657782e-02f,
  8.09443295e-02f, 3.00342236e-02f, 4.45870310e-02f, -3.35050449e-02f, -1.69639233e-02f, -3.78743410e-02f, -4.00080830e-02f, 6.80386741e-03f, 4.51364852e-02f, -1.87913105e-02f,
  -3.40574495e-02f, 7.84272105e-02f, 3.10925953e-02f, -2.20964141e-02f, 8.71022418e-03f, -6.38032379e-03f, 5.34534119e-02f, -3.19800824e-02f, -4.82891202e-02f, 3.41031444e-03f,
  9.07935798e-02f, 2.51616053e-02f, 1.42788021e-02f, 4.29811282e-03f, 3.28527056e-02f, 3.25387716e-02f, -6.68399259e-02f, 8.24674591e-02f, 1.59229152e-02f, 1.13344174e-02f,
  -6.09720312e-02f, -9.18561816e-02f, 1.72496010e-02f, 7.67559186e-02f, 1.42351370e-02f, -1.29066799e-02f, -8.02019611e-02f, -3.39586623e-02f, 2.92472709e-02f, -2.49171909e-02f,
  -2.34283786e-02f, 6.29383549e-02f, -2.52848770e-02f, 4.55981083e-02f, -8.58873129e-03f, 3.53136770e-02f, 3.65104824e-02f, -5.19221090e-02f, -6.06811699e-03f, -5.19123711e-02f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.59462371e-03f, -6.01842329e-02f, 2.89542675e-02f, 2.86452085e-01f, 3.33499908e-02f, -2.15027109e-01f, -8.51640701e-02f, 3.43983844e-02f, -2.75529996e-02f, -2.49879897e-01f,
  -8.77637044e-02f, 2.00100336e-03f, -9.93135273e-02f, 2.23012213e-02f, 2.93975621e-01f, -3.07355653e-02f, 7.65643716e-02f, -8.08700025e-02f, 1.54451290e-02f, -5.77762083e-04f,
  2.38365874e-01f, 3.76969203e-02f, 1.88343465e-01f, 1.04898579e-01f, -3.29923001e-03f, 1.46055728e-01f, 1.24082915e-01f, -2.64465567e-02f, 1.34573922e-01f, 2.98457835e-02f,
  -4.66050357e-02f, 4.48724255e-02f, 3.19584571e-02f, -4.73827347e-02f, 2.32485831e-02f, 5.44154039e-03f, 3.99882123e-02f, -3.56615819e-02f, -1.97002292e-02f, 2.92865909e-03f,
  -1.02545984e-01f, 9.03123021e-02f, 4.79222573e-02f, -1.59267243e-03f, 5.75805530e-02f, 1.08157985e-01f, -8.82843807e-02f, -4.67617027e-02f, -2.81610973e-02f, -1.36236977e-02f,
  -2.90978923e-02f, -5.39738201e-02f, 4.78698388e-02f, -6.12411126e-02f, 2.02117600e-02f, 7.83040375e-02f, -3.07781976e-02f, 7.36385817e-03f, -2.19630133e-02f, 1.46887675e-02f,
  1.00021951e-01f, -7.20356684e-03f, -5.84882610e-02f, -7.31306151e-02f, 2.78396457e-02f, 7.08398819e-02f, -2.62592379e-02f, 3.32930088e-02f, 1.12154158e-02f, -7.06517324e-02f,
  -1.30487559e-02f, -4.66310494e-02f, -6.70453999e-03f, -9.98701751e-02f, -7.64053920e-03f, 4.01017405e-02f, 9.14040953e-03f, -5.66649847e-02f, 6.45304546e-02f, 2.15889774e-02f,
  6.75496534e-02f, -5.57893366e-02f, -9.11064297e-02f, -2.61043776e-02f, -5.50072677e-02f, 4.80113141e-02f, -6.22520670e-02f, -8.08684304e-02f, 1.58788729e-02f, -1.43438810e-02f,
  5.43055981e-02f, 8.31412524e-02f, 9.08189192e-02f, -3.01119126e-02f, 8.87893257e-04f, 2.88513489e-02f, 3.92093919e-02f, 2.09208205e-02f, 9.60341915e-02f, -9.44638774e-02f,
  -2.06580814e-02f, 5.78312157e-03f, -5.05873859e-02f, -5.49879372e-02f, -5.25876544e-02f, -2.57643163e-02f, 6.42912462e-02f, 4.83655185e-02f, 5.30510908e-03f, 3.94262299e-02f,
  -1.28335031e-02f, -5.27538657e-02f, 8.70783441e-03f, 3.06601599e-02f, -6.18657023e-02f, -1.96809825e-02f, -5.54526895e-02f, 1.13673694e-02f, -5.54334559e-03f, 6.15173988e-02f,
  -1.30831435e-01f, 9.88401398e-02f, 5.83199225e-02f, 8.56673159e-03f, -8.94639175e-03f, 1.91438035e-03f, 9.48194265e-02f, 3.74309346e-02f, -7.75009692e-02f, 4.25847135e-02f,
  4.03775498e-02f, -8.36877897e-02f, 1.14566386e-01f, 8.53168666e-02f, -7.59588182e-02f, 1.43212050e-01f, 9.39903930e-02f, 2.98324134e-02f, -6.60098493e-02f, 3.05454824e-02f,
  8.02472904e-02f, 7.10821375e-02f, 1.71663299e-01f, -8.46965462e-02f, 6.88014999e-02f, -5.89356609e-02f, 3.26337442e-02f, -1.00912554e-02f, 9.29178763e-03f, -7.30014294e-02f,
  8.91841277e-02f, 6.60202429e-02f, 9.25434306e-02f, 3.20086372e-03f, -3.18946689e-02f, 4.62280363e-02f, -1.40364897e-02f, -1.03679476e-02f, -3.43624997e-04f, -2.93115284e-02f,
  8.47002084e-04f, -5.58478665e-03f, -1.03118770e-01f, 2.87096910e-02f, 3.99387218e-02f, -1.98215190e-02f, 7.17518404e-02f, -1.60746779e-02f, -8.00416693e-02f, 6.28622398e-02f,
  8.07747394e-02f, 6.26735762e-02f, 5.66325560e-02f, 9.58433971e-02f, -4.91633266e-02f, -5.47958538e-02f, -7.01477751e-03f, 2.51874607e-02f, 3.88544649e-02f, 3.23978774e-02f,
  -2.97468877e-03f, -4.88949977e-02f, 7.20857233e-02f, 6.80888444e-02f, -8.36818479e-03f, 1.05861492e-01f, 4.25243638e-02f, -7.31948623e-03f, 5.97549602e-02f, 8.28512385e-02f,
  2.84588034e-03f, -2.90563293e-02f, 4.52858247e-02f, 4.78325114e-02f, -7.31703416e-02f, 6.63749352e-02f, -5.64358989e-03f, 6.13402426e-02f, 9.05526578e-02f, 5.90798222e-02f,
  9.25539508e-02f, -2.67553311e-02f, 2.61941571e-02f, 8.29571411e-02f, 6.91066459e-02f, -2.40697917e-02f, -4.42110840e-03f, 2.09836438e-02f, -3.39221098e-02f, -3.61824259e-02f,
  9.75285769e-02f, -4.51513790e-02f, 7.64783993e-02f, 7.42591359e-03f, 3.37566286e-02f, 1.72754470e-02f, -2.67251022e-02f, -1.54228276e-02f, -9.63964909e-02f, -7.12919831e-02f,
  1.65638421e-02f, -2.65977290e-02f, -9.03312117e-02f, 1.63043514e-02f, 3.26339751e-02f, 8.14576671e-02f, -5.05577512e-02f, -6.39889687e-02f, -5.87517545e-02f, -8.23650276e-04f,
  5.97834885e-02f, -1.19023416e-02f, 3.31520215e-02f, -8.05268884e-02f, -2.63921488e-02f, -2.08896752e-02f, 1.22804511e-02f, -4.31040563e-02f, -7.87098780e-02f, 6.71189353e-02f,
  -2.15717759e-02f, 3.44290473e-02f, 1.74430043e-01f, 1.68431446e-01f, -6.58273920e-02f, 1.09175416e-02f, 4.75141332e-02f, -9.30220559e-02f, -5.05946344e-03f, -6.85550570e-02f,
  -1.00248754e-01f, 9.22533497e-02f, -5.18598221e-02f, 1.19711667e-01f, 1.15641013e-01f, 5.48765101e-02f, -2.82363314e-02f, -8.07180703e-02f, 8.39887485e-02f, 1.94596369e-02f,
  1.29976785e-02f, -3.52334715e-02f, 2.37685256e-02f, -3.16048004e-02f, 6.61281422e-02f, 3.18696047e-03f, 6.82738945e-02f, 1.27294287e-01f, 1.70266107e-01f, 1.16542548e-01f,
  4.93680164e-02f, 7.15250000e-02f, -5.28434031e-02f, 1.20027317e-03f, -8.10167566e-02f, -3.31437252e-02f, -2.47786138e-02f, 6.38176203e-02f, 1.04769483e-01f, 3.44238244e-02f,
  4.15582769e-02f, 3.04318368e-02f, 3.60310487e-02f, -7.98511356e-02f, 6.28064647e-02f, 2.08989289e-02f, -1.47241987e-02f, -1.09388180e-01f, 5.44450805e-02f, -1.02429315e-01f,
  -7.90327862e-02f, -1.03583768e-01f, 5.64962849e-02f, 7.02698007e-02f, -5.15816510e-02f, 8.14770609e-02f, 1.47155905e-02f, 6.83250725e-02f, 2.73465514e-02f, 1.84727944e-02f,
  -7.34409839e-02f, 8.45711455e-02f, 4.35364284e-02f, -6.02777377e-02f, -5.78175746e-02f, 6.94120675e-03f, -6.76486194e-02f, -4.48795781e-02f, 1.67776607e-02f, 4.70961109e-02f,
  7.24226311e-02f, 6.95515238e-03f, -7.74155781e-02f, 5.69261052e-02f, -2.37682816e-02f, -5.03598899e-02f, -4.37025800e-02f, 3.89221944e-02f, 3.75372656e-02f, 3.61516103e-02f,
  -5.77329211e-02f, -5.37494160e-02f, -2.38094870e-02f, 3.92153822e-02f, 4.81533706e-02f, 3.62577359e-03f, 1.95385665e-02f, -7.05790669e-02f, 3.03877573e-02f, -7.66533837e-02f,
  -3.96515727e-02f, 1.97431982e-01f, -2.02710778e-02f, -6.02010265e-03f, -2.41358746e-02f, 3.98982838e-02f, -3.35121527e-02f, 2.77889390e-02f, 1.23901412e-01f, 5.71025833e-02f,
  -9.63117331e-02f, 2.19263919e-02f, -6.72567114e-02f, -6.70735314e-02f, -1.57109480e-02f, 7.17179626e-02f, 2.43372675e-02f, -1.82341679e-03f, 7.60037750e-02f, 2.13312842e-02f,
  -7.52118900e-02f, 2.70814355e-02f, 8.28813761e-02f, 6.23884648e-02f, -5.30113243e-02f, 4.82575260e-02f, -2.07765643e-02f, -1.14230430e-02f, -3.69149223e-02f, 3.27012688e-02f,
  1.14873320e-01f, -6.99030235e-02f, -2.26592436e-01f, -1.75687715e-01f, 7.57121742e-02f, -6.08328870e-03f, -3.26746441e-02f, -5.31132519e-02f, -1.37923822e-01f, 1.32060334e-01f,
  1.80070177e-01f, -1.47170439e-01f, -6.54167756e-02f, -8.20881594e-03f, -1.36860348e-02f, -8.32406357e-02f, 9.64057148e-02f, 3.03954538e-03f, -1.42879039e-01f, 2.41964627e-02f,
  4.84659672e-02f, 1.13971040e-01f, -6.07914627e-02f, 6.83451816e-02f, 1.43679142e-01f, -5.64378202e-02f, 3.22056077e-02f, -6.33196607e-02f, 8.68596658e-02f, -3.75243239e-02f,
  7.41634816e-02f, 4.82277349e-02f, -1.21616289e-01f, -4.41694669e-02f, 1.11709215e-01f, 7.90785998e-02f, -7.99353942e-02f, 6.70463070e-02f, 3.93123515e-02f, 8.86922609e-03f,
  8.77661705e-02f, 1.48010044e-03f, 5.06516658e-02f, -7.68663958e-02f, 3.82719748e-02f, 2.78171562e-02f, -6.76537156e-02f, -1.16591759e-01f, -1.30067617e-01f, -4.00876924e-02f,
  -7.43738562e-02f, 3.56086157e-02f, -4.11760323e-02f, -2.73065381e-02f, 4.39996086e-03f, 5.35251610e-02f, -6.54005036e-02f, 3.12199593e-02f, 5.56064881e-02f, -6.75894693e-02f,
  5.98616451e-02f, 6.28223047e-02f, -3.23248282e-02f, 6.26634359e-02f, -7.35244527e-03f, 2.91622132e-02f, -3.83257051e-03f, 7.52788261e-02f, 5.18577397e-02f, 4.25158665e-02f,
  -5.03860191e-02f, 7.12419599e-02f, -1.68912783e-02f, 1.00861803e-01f, -1.12773792e-03f, 1.69618893e-02f, 4.24214117e-02f, -9.20783505e-02f, 1.82355754e-02f, -6.73681647e-02f,
  1.14820004e-02f, 2.57075056e-02f, 6.87109455e-02f, 1.64343752e-02f, -2.71923617e-02f, -6.32596090e-02f, 7.54174963e-02f, 2.74513010e-02f, -5.65457679e-02f, 6.80257976e-02f,
  -1.24718426e-02f, 8.70398283e-02f, 1.50617557e-02f, -7.49712288e-02f, -6.95301592e-02f, 1.16430715e-01f, -5.25045916e-02f, -9.15447436e-03f, 9.51618236e-03f, -2.55547073e-02f,
  1.31822735e-01f, -8.08034465e-02f, 1.13783777e-01f, -8.63898695e-02f, -5.33260230e-04f, 1.06891483e-01f, -4.50785719e-02f, 3.93984243e-02f, -6.10606261e-02f, 4.90637012e-02f,
  -4.79111373e-02f, 1.08527333e-01f, -1.64611582e-02f, 1.13783525e-02f, -3.29739042e-02f, -5.18345833e-02f, 4.75139916e-02f, -4.62691747e-02f, 2.35262848e-02f, -3.05569731e-02f,
  -4.72175553e-02f, 1.42675757e-01f, -1.88798651e-01f, -1.25823915e-01f, -7.01986328e-02f, -3.08117956e-01f, -2.89947003e-01f, -1.24566182e-01f, -1.83817148e-02f, 3.73234041e-02f,
  -8.55809450e-02f, 6.95813969e-02f, 3.12893093e-03f, -1.25911981e-01f, -1.04355261e-01f, 1.89814165e-01f, -1.31884441e-01f, 2.63785738e-02f, 4.04877355e-03f, -1.72400430e-01f,
  4.25019823e-02f, -1.09229080e-01f, -4.41613644e-02f, -6.58663213e-02f, -2.23812252e-01f, 3.31848264e-02f, 2.24023592e-02f, 1.23390118e-02f, -7.47955069e-02f, 3.61665115e-02f,
  -1.98417440e-01f, -6.20066002e-02f, -3.54108885e-02f, -6.82928041e-02f, -9.01768282e-02f, -7.19886422e-02f, -1.78959370e-02f, -4.19193693e-02f, -5.94343171e-02f, -8.85859504e-02f,
  -1.94348060e-02f, -6.51184618e-02f, 6.09725118e-02f, 5.07759750e-02f, 1.69846453e-02f, -6.99143186e-02f, -5.22781089e-02f, -3.12805101e-02f, -1.41386408e-02f, 6.95645735e-02f,
  -1.01564616e-01f, -5.82367890e-02f, -2.10139900e-02f, 5.82569987e-02f, -6.76749125e-02f, 3.00989896e-02f, 3.09027731e-02f, 1.04657549e-03f, -8.55239555e-02f, 3.83952670e-02f,
  -4.03449163e-02f, 6.14955872e-02f, -2.23035198e-02f, 3.70708760e-03f, -1.08529143e-01f, 1.07794097e-02f, -5.61909527e-02f, 1.61820576e-02f, 6.66234717e-02f, 5.11427689e-03f,
  -4.35268357e-02f, -5.75121455e-02f, 5.96446320e-02f, -5.93178310e-02f, -8.39122534e-02f, -3.16547267e-02f, 6.63716113e-03f, 6.04452416e-02f, 4.22797799e-02f, 7.52337053e-02f,
  -1.51403267e-02f, 4.08202112e-02f, 1.83031410e-02f, -4.88219038e-02f, -3.18188816e-02f, 2.66976021e-02f, -5.29007008e-03f, 6.39766315e-03f, 1.05480319e-02f, 1.22063980e-02f,
  -1.04319490e-01f, -1.43882185e-01f, -2.82959510e-02f, -1.35395518e-02f, 2.41898578e-02f, 2.73715779e-02f, 6.36307448e-02f, -3.10556199e-02f, -1.07851066e-01f, -4.61202711e-02f,
  2.91543324e-02f, -4.82031927e-02f, -7.56938010e-02f, 4.29941192e-02f, 1.34635679e-02f, 3.25079449e-02f, 5.23806699e-02f, 1.65047012e-02f, -7.75938183e-02f, 1.57962311e-02f,
  -2.16618762e-03f, -5.13458587e-02f, -2.13723406e-02f, -5.01791462e-02f, 5.67809790e-02f, -2.80886013e-02f, 3.93527281e-03f, 6.56264946e-02f, -4.45360318e-02f, -4.75064339e-03f,
  -1.00386189e-02f, 9.20217484e-02f, 1.76360518e-01f, 1.01764716e-01f, 8.94781575e-02f, -2.20231991e-02f, 5.50990887e-02f, 1.15108572e-01f, 1.48031771e-01f, -1.00363277e-01f,
  -1.16439126e-01f, -6.91650109e-03f, 3.53804510e-03f, 9.67304781e-02f, -4.40114625e-02f, -9.52573195e-02f, -2.20069196e-02f, -1.03762768e-01f, 1.00198403e-01f, -6.87542185e-02f,
  1.43143758e-01f, -7.87691250e-02f, 1.02218300e-01f, -1.54026151e-01f, 5.32416478e-02f, 6.13850616e-02f, -1.63239136e-01f, 3.27457860e-02f, -5.16748875e-02f, -1.87948253e-02f,
  2.24339147e-03f, -3.91509756e-02f, 7.41294026e-03f, -5.29426001e-02f, -5.76913096e-02f, 7.35027120e-02f, -8.03259090e-02f, 4.51474972e-02f, 1.34378569e-02f, 5.02147786e-02f,
  4.95641492e-02f, -9.55687240e-02f, -2.16535684e-02f, 5.42499349e-02f, -1.58954691e-02f, -6.06227294e-02f, -3.47042494e-02f, 5.28695360e-02f, -3.18033434e-02f, 1.14449747e-01f,
  -1.66751780e-02f, -4.80046794e-02f, 4.20222804e-02f, -5.94601631e-02f, 5.48369717e-03f, -1.88207496e-02f, -5.04005514e-02f, -5.88962063e-02f, -1.55108795e-02f, -3.76109630e-02f,
  2.24049040e-03f, 4.16880809e-02f, -7.64274746e-02f, 2.49839127e-02f, -6.14396185e-02f, 7.49944448e-02f, 2.79759783e-02f, -3.07397675e-02f, 3.97388078e-02f, -3.06071695e-02f,
  4.73414827e-03f, 1.00155719e-01f, -4.45858464e-02f, 2.99608223e-02f, 8.29839855e-02f, 1.94458496e-02f, -9.26743001e-02f, -1.07214190e-01f, 3.57041173e-02f, -1.87532362e-02f,
  -5.19202910e-02f, -3.41490544e-02f, 1.71265583e-02f, -6.08569272e-02f, -8.74339417e-02f, -5.52058667e-02f, 5.37862256e-02f, 4.95301411e-02f, -8.70124176e-02f, -7.54814669e-02f,
  -2.54253000e-02f, -1.87827237e-02f, 1.26123298e-02f, -2.68115457e-02f, -1.01292118e-01f, -2.78959032e-02f, -2.76030470e-02f, 1.70686264e-02f, 6.85788170e-02f, -9.96488482e-02f,
  -5.31209633e-02f, 1.04930568e-02f, -8.31407905e-02f, -3.73307010e-03f, -7.90399462e-02f, 4.63533867e-03f, -4.35612425e-02f, -2.84272023e-02f, 6.70271516e-02f, 3.13596688e-02f,
  -6.53680041e-02f, -5.84611744e-02f, 6.35532290e-02f, 7.02302828e-02f, -4.21137437e-02f, 7.33807385e-02f, -1.64456256e-02f, -1.07772255e-04f, -8.69356841e-03f, -5.84093221e-02f,
  1.10103697e-01f, -4.93639074e-02f, 1.07886121e-01f, 2.79779714e-02f, 2.88288351e-02f, 9.67681855e-02f, 8.44990686e-02f, 4.50491868e-02f, 1.15079165e-01f, -2.44660787e-02f,
  1.40161980e-02f, -1.06257945e-01f, -2.63957828e-02f, 3.42488661e-02f, -1.61163118e-02f, 9.48472470e-02f, 6.98399097e-02f, 7.82592595e-03f, 1.12373471e-01f, -7.05709979e-02f,
  -3.36147882e-02f, 6.27384707e-02f, 5.01321070e-02f, -4.53655869e-02f, 3.26679344e-03f, 4.51318845e-02f, -1.05760030e-01f, -3.29394476e-03f, -7.12111294e-02f, -7.93830603e-02f,
  -1.12979701e-02f, 7.42295012e-02f, -6.19011074e-02f, 8.14745501e-02f, 2.26439200e-02f, 2.48789210e-02f, -6.23058826e-02f, 3.30385342e-02f, -6.03531525e-02f, -6.82772100e-02f,
  7.75631219e-02f, 8.35454538e-02f, -5.08261397e-02f, 1.99532770e-02f, -8.13331008e-02f, -4.69025299e-02f, -3.29871401e-02f, -3.64863947e-02f, 8.33187774e-02f, 8.33955780e-02f,
  5.34631796e-02f, -1.18189501e-02f, -2.85402164e-02f, 2.94071380e-02f, 8.30361024e-02f, -8.72969348e-03f, -1.87184233e-02f, 6.48155361e-02f, -1.94725217e-05f, -5.75800017e-02f,
  -4.04185392e-02f, 1.52799662e-03f, 5.19466177e-02f, -5.72957098e-02f, 6.46247491e-02f, 1.55895511e-02f, -9.03747510e-03f, -1.66441593e-02f, 5.95719628e-02f, 4.11437489e-02f,
  -3.41339037e-02f, -2.53580883e-02f, 7.47366846e-02f, 8.57644081e-02f, 1.19720511e-02f, -4.90083173e-03f, 6.76371604e-02f, 2.76876204e-02f, 5.33477068e-02f, -8.67792144e-02f,
  -8.23006965e-03f, 1.13176778e-02f, 2.89275367e-02f, -5.72735928e-02f, 2.73990780e-02f, 7.23145008e-02f, 4.74496819e-02f, 3.73802446e-02f, -7.77130574e-02f, 3.22987437e-02f,
  3.59050231e-03f, -3.69870029e-02f, 9.32704136e-02f, 5.90516590e-02f, -9.40136537e-02f, 4.30492349e-02f, 3.43158245e-02f, -7.17820078e-02f, -5.87034672e-02f, 3.23605398e-03f,
  4.94004833e-03f, 7.86847547e-02f, -5.54912426e-02f, -8.95263776e-02f, 4.90852632e-02f, 2.85281483e-02f, -8.75354707e-02f, -6.96277916e-02f, 4.18556221e-02f, -1.46471122e-02f,
  -8.47591013e-02f, 1.35089429e-02f, -6.35546669e-02f, -7.49493912e-02f, 5.34596480e-02f, 5.88921644e-02f, -6.45873770e-02f, -3.54599953e-02f, -4.91374210e-02f, -9.02274400e-02f,
  -1.76918041e-02f, 6.68822527e-02f, -4.33155149e-02f, -1.59188390e-01f, 1.31357089e-01f, -8.25098976e-02f, -1.48001477e-01f, 5.74218556e-02f, 1.60766523e-02f, -3.19372900e-02f,
  6.98026037e-03f, -1.32490396e-01f, 1.50295287e-01f, -1.88165486e-01f, -8.38184133e-02f, 8.54026079e-02f, -2.27447301e-01f, -4.87062968e-02f, -9.07709673e-02f, -1.60860885e-02f,
  -1.15785755e-01f, -3.77769955e-02f, -8.37159529e-02f, 9.64849442e-02f, -8.74243379e-02f, -9.20098275e-02f, 1.68082472e-02f, -4.52613384e-02f, 9.42453928e-03f, -4.35554683e-02f,
  4.34107445e-02f, -3.61558236e-02f, 6.71362206e-02f, 8.07740018e-02f, -2.62342952e-02f, 6.94594979e-02f, -1.68645792e-02f, 1.10171847e-02f, -4.10564058e-02f, 5.17341644e-02f,
  -1.00343905e-01f, -2.67363414e-02f, -7.12562650e-02f, 6.17954433e-02f, -3.58601809e-02f, -1.16971519e-03f, 6.49721622e-02f, -3.36904381e-03f, -8.14543143e-02f, 8.44153166e-02f,
  3.04395463e-02f, -4.45116423e-02f, 6.54978678e-02f, 4.19956706e-02f, 6.60155788e-02f, 6.50938898e-02f, -4.78335507e-02f, -7.75805265e-02f, -9.81001630e-02f, -1.22223496e-02f,
  6.86574504e-02f, -8.81363526e-02f, -4.24524210e-02f, -7.62573853e-02f, 8.05108845e-02f, -4.86571379e-02f, -1.72892287e-02f, -3.10827140e-02f, -4.39529866e-02f, -8.99882615e-03f,
  -4.33221199e-02f, 7.43227750e-02f, -7.47564360e-02f, -8.30012038e-02f, -2.38462985e-02f, 6.26728982e-02f, -3.66742350e-02f, 7.89306611e-02f, -8.84403139e-02f, -6.21336922e-02f,
  4.28071842e-02f, -4.06039134e-02f, -2.05759220e-02f, -8.92770812e-02f, 6.54358566e-02f, 4.59830426e-02f, -4.08411399e-02f, -8.48402008e-02f, -7.41530806e-02f, 7.52165169e-02f,
  1.24699753e-02f, 5.37666976e-02f, 3.12658362e-02f, 5.11566363e-02f, 1.10270314e-01f, 4.03656699e-02f, 5.09061217e-02f, -4.31881323e-02f, -2.79296990e-02f, 1.05861604e-01f,
  9.02662706e-03f, -4.17047851e-02f, 3.40041816e-02f, -6.25952855e-02f, 4.95280921e-02f, 4.23992798e-02f, 5.70179783e-02f, -2.30893344e-02f, -7.73313716e-02f, 5.97337410e-02f,
  -4.20685075e-02f, -7.51576871e-02f, 1.63662136e-02f, 1.03620356e-02f, -3.96183841e-02f, -6.53710812e-02f, 7.53761455e-02f, -6.21834956e-02f, -5.22664823e-02f, -6.15218505e-02f,
  1.50619909e-01f, -1.69069260e-01f, 1.92024559e-01f, 7.41415396e-02f, 1.61128864e-01f, 1.61106773e-02f, -3.81207862e-03f, 1.05397627e-01f, 1.90019861e-01f, -7.49817640e-02f,
  -1.04698233e-01f, 7.90261924e-02f, -1.37117326e-01f, -1.23799250e-01f, -9.50364470e-02f, -1.93417430e-01f, -3.82676721e-02f, 1.42327426e-02f, 6.51118010e-02f, 3.29176821e-02f,
  -3.77980955e-02f, -8.13037902e-02f, -1.15745373e-01f, -1.28845111e-01f, 9.25140828e-02f, 7.46317804e-02f, -1.82407517e-02f, -7.16178343e-02f, -6.95547312e-02f, -1.40720591e-01f,
  -8.05209056e-02f, 7.52809346e-02f, -8.22856128e-02f, 1.20815486e-02f, 4.23343778e-02f, 3.73981930e-02f, 5.47635555e-02f, -8.03011805e-02f, 5.79387844e-02f, 2.72279233e-02f,
  3.80232651e-03f, 3.29052508e-02f, -1.22969244e-02f, -6.81504905e-02f, 1.24515146e-02f, 8.01570565e-02f, 3.86944599e-02f, 3.71241421e-02f, 6.15706369e-02f, 4.20558639e-02f,
  -3.55501175e-02f, 7.66324764e-03f, 5.30176386e-02f, -5.85282817e-02f, -9.69068985e-03f, -4.87827882e-02f, -8.23202953e-02f, 7.24570546e-03f, -1.19887134e-02f, -1.08553944e-02f,
  1.50665815e-03f, -4.13915096e-03f, -4.73957695e-02f, -6.22524396e-02f, 6.45006150e-02f, 9.90820900e-02f, -2.94648483e-02f, -5.08109294e-02f, 3.88927273e-02f, 7.77569562e-02f,
  1.01915859e-01f, 7.36181512e-02f, 1.09075429e-02f, 3.94516475e-02f, -4.54439484e-02f, 2.34976243e-02f, 7.37376884e-02f, 2.63055265e-02f, -4.54723183e-03f, 1.15764504e-02f,
  7.23822368e-03f, -9.42627490e-02f, -2.80018561e-02f, -2.41003465e-02f, -7.68163875e-02f, -5.62720224e-02f, 1.82234161e-02f, 7.67482072e-02f, 6.82632718e-03f, -8.77427906e-02f,
  -9.16539580e-02f, -9.37644914e-02f, 5.28507680e-02f, 5.78901432e-02f, -7.22173601e-02f, 4.76276055e-02f, -3.24130990e-02f, -6.22321069e-02f, -4.37202491e-02f, -1.89883746e-02f,
  -6.23495393e-02f, 3.90528142e-02f, -4.26710099e-02f, 3.44535671e-02f, -7.99863860e-02f, -7.05823898e-02f, 3.38731594e-02f, 4.51873243e-02f, -9.20447409e-02f, -7.49034360e-02f,
  -5.28017320e-02f, -1.07995290e-02f, 4.24348824e-02f, -1.65943429e-02f, -5.11388667e-02f, 9.09059718e-02f, 6.01673611e-02f, -4.40302454e-02f, -2.93784458e-02f, -2.74042357e-02f,
  -3.13466340e-01f, 1.97136551e-01f, -1.21650115e-01f, -7.63077987e-03f, -5.19553497e-02f, 1.55623570e-01f, 1.18196219e-01f, -3.74562927e-02f, -1.74889743e-01f, 1.01236321e-01f,
  6.63910583e-02f, -1.38851240e-01f, 1.31331384e-02f, -3.00324913e-02f, -1.34428859e-01f, 1.43032372e-01f, 1.07426077e-01f, 9.88021940e-02f, 1.81176495e-02f, -8.59318823e-02f,
  -8.58415514e-02f, 8.76929909e-02f, 2.45674066e-02f, 3.07207257e-02f, -3.71918678e-02f, -1.09785385e-01f, 5.18588163e-02f, -8.17320421e-02f, 7.74691254e-02f, 2.77841818e-02f,
  -6.31581992e-02f, -6.47972375e-02f, -1.17607608e-01f, 1.21110398e-03f, -9.82392579e-02f, 5.66041991e-02f, 4.13035648e-03f, -9.50085670e-02f, 9.94788297e-03f, -9.77346972e-02f,
  -2.21178103e-02f, 6.86632395e-02f, -2.69428045e-02f, -8.99916589e-02f, -4.11121175e-02f, 6.86451467e-03f, 3.69298756e-02f, -6.94313496e-02f, 4.95562470e-03f, -1.40015138e-02f,
  2.23628562e-02f, 6.75668567e-02f, -3.76876332e-02f, 8.31885710e-02f, 2.60152780e-02f, 2.84215640e-02f, 3.34223965e-03f, 2.67864894e-02f, -7.84040913e-02f, -3.97719853e-02f,
  1.41174598e-02f, -3.36300097e-02f, 7.68042682e-03f, -7.99566731e-02f, -1.68681517e-02f, -1.68837029e-02f, 3.09327468e-02f, 5.30994609e-02f, 8.40975344e-03f, 9.33131576e-02f,
  3.44275832e-02f, 9.47117060e-03f, 3.94747742e-02f, -7.81898722e-02f, 7.00139720e-03f, 4.46034707e-02f, 4.70549092e-02f, 3.21922041e-02f, 6.05133586e-02f, -2.39116587e-02f,
  5.12124933e-02f, -3.33167962e-03f, 3.66862454e-02f, -3.88869718e-02f, 1.43156834e-02f, -6.21339567e-02f, 4.25669877e-03f, -1.30625237e-02f, -2.44594030e-02f, 4.70096059e-02f,
  -5.94025068e-02f, -7.01316968e-02f, -1.35505944e-02f, -8.25742334e-02f, 5.20052798e-02f, 4.02668715e-02f, -8.33270024e-04f, -7.61080235e-02f, 5.10837846e-02f, -4.23083976e-02f,
  -4.26836349e-02f, -1.34970923e-03f, -4.42672484e-02f, -6.76742494e-02f, -3.65037955e-02f, -3.43654715e-02f, 8.55465010e-02f, -5.33990024e-05f, 3.92555371e-02f, -2.00780593e-02f,
  -2.16571819e-02f, 8.20271000e-02f, 4.14394401e-03f, -7.13954493e-02f, 5.28398380e-02f, 8.91815051e-02f, -4.73420024e-02f, 3.59378457e-02f, -6.47500483e-03f, -2.85874475e-02f,
  -9.77455731e-03f, 1.63896680e-01f, -1.88887697e-02f, -2.10462767e-03f, -1.14473835e-01f, 4.12011854e-02f, 1.60819620e-01f, 1.05329312e-01f, 1.53240874e-01f, 1.76770359e-01f,
  -2.74675954e-02f, 1.50333226e-01f, 1.19690478e-01f, -7.88138658e-02f, 1.19451977e-01f, 9.67214778e-02f, 9.42228213e-02f, 1.31700948e-01f, 1.92135237e-02f, 6.26969850e-03f,
  -8.71056598e-03f, 8.23460445e-02f, -2.00617462e-01f, 2.43203100e-02f, -1.45670086e-01f, -1.64892331e-01f, -8.99417475e-02f, -1.17222242e-01f, 2.14087181e-02f, -1.21290255e-02f,
  -6.08978607e-02f, -7.12312907e-02f, -3.89617216e-03f, -8.36402774e-02f, -1.32115245e-01f, 3.80327553e-03f, -2.89246868e-02f, -5.80553487e-02f, -4.77671139e-02f, -6.11664057e-02f,
  4.36392762e-02f, -3.95319089e-02f, -3.43814716e-02f, 7.24465633e-03f, 4.71803583e-02f, 2.94625815e-02f, -2.76681297e-02f, -1.27890240e-02f, 1.51674356e-02f, -7.45625645e-02f,
  -1.02650315e-01f, -6.11189604e-02f, -5.74929416e-02f, 5.40749058e-02f, -9.86863226e-02f, -8.26835558e-02f, 9.47660729e-02f, -7.02527240e-02f, -2.24210843e-02f, 1.65282432e-02f,
  -1.54454112e-02f, 9.23985317e-02f, -1.47076622e-02f, -6.92584664e-02f, -3.00751776e-02f, 6.43237010e-02f, 4.57048090e-03f, 6.55194819e-02f, -4.87768352e-02f, 5.83832851e-03f,
  3.74996848e-02f, 1.18530411e-02f, 1.78830996e-02f, -1.27268964e-02f, 3.59141417e-02f, 4.96950261e-02f, -3.09935994e-02f, 4.24246937e-02f, 2.09796522e-02f, 6.50719106e-02f,
  2.05649920e-02f, -4.35989648e-02f, 7.06794783e-02f, -1.10143892e-01f, 7.12216496e-02f, 2.89418222e-03f, 7.17517547e-03f, -6.26081005e-02f, -4.15333696e-02f, -4.52402681e-02f,
  1.41983077e-01f, 3.58224064e-02f, 8.21725875e-02f, -4.00963649e-02f, -4.78026755e-02f, 4.62944657e-02f, 2.26441324e-02f, 9.06424373e-02f, 6.24061450e-02f, -3.89342965e-03f,
  -2.66372990e-02f, 3.77185456e-02f, 3.03134844e-02f, -3.46597098e-02f, 3.40008177e-02f, 4.81586121e-02f, 2.04859581e-02f, -1.51799358e-02f, -3.80340703e-02f, 7.36175552e-02f,
  2.17161458e-02f, 8.45844597e-02f, 3.03120166e-02f, 4.22317460e-02f, -4.68461439e-02f, 5.16451895e-02f, 4.68738526e-02f, -2.27758996e-02f, -5.61603792e-02f, 5.52028231e-02f,
  -7.77920485e-02f, 6.78294078e-02f, -9.46654752e-03f, -1.09109238e-01f, 4.06959932e-03f, 2.09325785e-03f, 4.23374400e-03f, -7.25593269e-02f, -1.27455741e-01f, -3.21266204e-02f,
  9.15565044e-02f, -7.82903209e-02f, 1.20024793e-01f, -1.70229346e-01f, -1.44074902e-01f, -6.92654029e-02f, -1.69358030e-01f, -1.04265280e-01f, -4.92648743e-02f, -1.26285134e-02f,
  -4.04031500e-02f, -5.63517213e-02f, -6.36851713e-02f, 7.58218206e-03f, -4.82281148e-02f, 8.03031623e-02f, 6.26231134e-02f, 1.23961873e-01f, -5.59917912e-02f, 5.87304030e-03f,
  -7.00289086e-02f, -7.37310573e-02f, 6.28336966e-02f, -6.88109025e-02f, 3.01754549e-02f, -6.95961490e-02f, -9.84079554e-04f, 1.15310643e-02f, -2.93529835e-02f, -9.16035548e-02f,
  -5.41790649e-02f, 5.95379621e-02f, -1.13932379e-01f, 2.17282269e-02f, 4.21372568e-03f, -5.08497469e-02f, 9.48292837e-02f, 2.62269527e-02f, 7.55543709e-02f, 6.05913997e-02f,
  1.00369360e-02f, 9.17955581e-03f, -6.13845475e-02f, -7.43562207e-02f, -1.87299438e-02f, 5.50345378e-03f, 3.44157801e-04f, 7.16593675e-03f, -6.20026374e-03f, -9.17298198e-02f,
  4.67412770e-02f, -3.02484408e-02f, -4.67203632e-02f, -3.14128026e-02f, 9.40050185e-03f, -1.10430261e-02f, -4.61343639e-02f, 2.54007224e-02f, 5.16502112e-02f, -8.53833556e-02f,
  -8.46292451e-02f, -8.52126181e-02f, -8.28394517e-02f, 2.45230403e-02f, -6.66608587e-02f, -6.96642920e-02f, 5.77456411e-03f, 1.07418999e-01f, 5.34251556e-02f, -2.74477005e-02f,
  3.76114473e-02f, -1.00538507e-03f, 7.60936290e-02f, 2.61115469e-02f, 3.51311155e-02f, 6.80934116e-02f, -7.10879043e-02f, -5.86070493e-02f, 1.28065767e-02f, 3.45928706e-02f,
  -6.43944414e-03f, -1.37743978e-02f, 2.16653179e-02f, -7.44417086e-02f, 5.53533882e-02f, 9.98231471e-02f, 2.75392570e-02f, -1.62393358e-02f, -1.00534357e-01f, -1.01321876e-01f,
  -2.34622005e-02f, -7.54316896e-03f, -9.78464540e-03f, 6.77376846e-03f, -6.55231029e-02f, 6.05714507e-02f, 3.12563665e-02f, -7.35037774e-02f, 5.22185825e-02f, 5.79617508e-02f,
  2.69554667e-02f, 6.04609447e-03f, 5.72156422e-02f, 9.49690342e-02f, 7.33171627e-02f, -8.88610631e-03f, -8.61865655e-02f, 6.02352358e-02f, 4.71295007e-02f, 4.04408909e-02f,
  2.44509466e-02f, 2.28451863e-01f, 2.30923086e-01f, 1.60951197e-01f, -1.85768738e-01f, -1.60123557e-02f, -1.38712555e-01f, -7.35399517e-05f, 9.28763207e-03f, 1.14777535e-01f,
  -4.45278808e-02f, 2.85766453e-01f, -4.58408296e-02f, -9.27644670e-02f, -7.17030987e-02f, -2.01550320e-01f, 2.39786562e-02f, 5.39450124e-02f, -4.36964212e-03f, 3.95838879e-02f,
  -9.03505012e-02f, -1.78792089e-01f, 4.26425226e-03f, 5.35557754e-02f, 7.20307082e-02f, 2.21916094e-01f, 1.82465035e-02f, 1.83395240e-02f, 1.69771135e-01f, -3.11493184e-02f,
  1.56699307e-02f, 1.01700969e-01f, 6.68506473e-02f, -1.08444896e-02f, -2.51532197e-02f, 2.66916826e-02f, 5.41915409e-02f, -5.76643534e-02f, -6.27349541e-02f, 6.48883581e-02f,
  1.06395416e-01f, -7.96047598e-03f, -2.45735031e-02f, -1.01282537e-01f, 1.41504426e-02f, 9.55661535e-02f, -8.93065240e-04f, 8.02837461e-02f, -2.18129121e-02f, 1.13741599e-01f,
  1.25769973e-01f, -4.67784703e-02f, 1.00648440e-01f, 8.81775562e-03f, -2.81228535e-02f, -5.78018501e-02f, -1.44902943e-02f, 1.77287101e-03f, 6.33269474e-02f, 7.12314323e-02f,
  1.02153644e-01f, -6.35597855e-02f, -6.26975968e-02f, -3.11936438e-02f, -2.62379237e-02f, -1.05170995e-01f, 3.40521075e-02f, -2.67504845e-02f, 1.90665349e-02f, 2.64766514e-02f,
  7.28430152e-02f, 3.00045013e-02f, 3.53765152e-02f, -5.92518821e-02f, -7.79183581e-02f, 1.45805534e-02f, -4.73649055e-02f, 8.01057070e-02f, 3.08306105e-02f, -4.38357219e-02f,
  -1.98961142e-02f, -4.72445711e-02f, 2.91093364e-02f, 3.30454372e-02f, -4.92853336e-02f, -6.51955903e-02f, -4.44152206e-03f, 5.79544939e-02f, -4.34950851e-02f, 6.93699792e-02f,
  2.30109668e-03f, 2.10376516e-01f, 1.52885010e-02f, -2.41263527e-02f, -1.89127531e-02f, -2.28245053e-02f, -5.56167550e-02f, -3.19777541e-02f, 6.59419522e-02f, 1.68276932e-02f,
  -1.10706594e-02f, -3.27520184e-02f, 2.22594291e-02f, 6.56711534e-02f, -3.08384895e-02f, -9.79213603e-03f, 8.92532244e-02f, 5.86792715e-02f, 4.63955142e-02f, -4.03386988e-02f,
  3.49780843e-02f, 7.19524771e-02f, -4.59527634e-02f, 1.65322293e-02f, -3.75387296e-02f, 4.80716489e-02f, 3.82924005e-02f, 9.01000574e-02f, 3.06234276e-03f, 2.75662523e-02f,
  -9.39500257e-02f, 2.58053653e-02f, -1.73332736e-01f, -1.90551475e-01f, -5.96436337e-02f, -6.70141727e-02f, -8.23898315e-02f, -2.69139931e-02f, -1.37074009e-01f, 7.79845715e-02f,
  5.58775030e-02f, -8.74748155e-02f, 9.03856978e-02f, -1.23220973e-01f, -2.18058079e-01f, -1.52280539e-01f, -8.78241733e-02f, -8.64012316e-02f, -1.01446388e-02f, -1.91296060e-02f,
  -4.13149372e-02f, 3.35138142e-02f, -1.03672847e-01f, 3.62236127e-02f, 2.32657082e-02f, 1.17326386e-01f, 6.11161767e-03f, 1.03555687e-01f, 6.57322332e-02f, 1.33475405e-03f,
  -5.68198739e-04f, -1.38361193e-03f, -8.25764611e-03f, -3.51599157e-02f, 1.17086852e-02f, 4.02268692e-04f, 1.00085720e-01f, -4.30722088e-02f, 2.54477579e-02f, 7.02324733e-02f,
  5.38047664e-02f, 6.78353310e-02f, 5.93979917e-02f, -2.84941178e-02f, 6.90601841e-02f, -4.81775813e-02f, 9.77877155e-03f, 1.69197668e-03f, -5.45366295e-03f, -4.47077565e-02f,
  -9.64175537e-02f, 7.80752748e-02f, 3.82733308e-02f, -1.93176661e-02f, -9.50640514e-02f, 7.12165162e-02f, -6.67216033e-02f, -3.33782360e-02f, 8.59506875e-02f, -6.38349876e-02f,
  -3.73215415e-02f, 7.68883526e-02f, 9.40363389e-03f, -6.36867657e-02f, -6.96855932e-02f, -4.28779945e-02f, -2.29063518e-02f, -5.88518642e-02f, -4.94808853e-02f, -1.29869841e-02f,
  2.08877660e-02f, 4.32747006e-02f, -5.76428771e-02f, -2.16457285e-02f, 1.08213266e-02f, -4.80435975e-02f, 8.50104317e-02f, 5.98836914e-02f, 3.21625546e-02f, 5.35927825e-02f,
  7.56492242e-02f, 6.04597963e-02f, 1.99430175e-02f, -5.75779416e-02f, 3.03621572e-02f, -2.07752604e-02f, -5.31842411e-02f, 1.50999157e-02f, 5.87431341e-02f, 2.62840725e-02f,
  2.75570974e-02f, -1.99305955e-02f, 2.76680570e-02f, 5.04010879e-02f, -6.49224371e-02f, 8.86390209e-02f, -2.25314815e-02f, 9.62992292e-03f, 5.13767190e-02f, 5.59317842e-02f,
  -1.81964021e-02f, 7.51983374e-02f, -1.37466034e-02f, 2.85905562e-02f, -7.26185441e-02f, 5.58295250e-02f, -8.70301330e-04f, 7.32745379e-02f, 5.97780757e-02f, 5.25320508e-02f,
  -1.52426204e-02f, 4.52844687e-02f, 6.32514209e-02f, -4.43053991e-02f, 3.39653995e-03f, -3.21904533e-02f, -3.65293548e-02f, 6.19185604e-02f, -8.33061337e-02f, 3.76608483e-02f,
  -2.65275300e-01f, 6.38190210e-02f, -2.76811570e-01f, 4.36946414e-02f, -2.77942240e-01f, 2.00057365e-02f, 1.33796602e-01f, -5.64364605e-02f, 4.60327938e-02f, 3.47385913e-01f,
  1.59267694e-01f, -7.05415830e-02f, 2.52106279e-01f, 2.85544425e-01f, -1.10039383e-01f, 2.88501620e-01f, 2.16862097e-01f, 2.37721071e-01f, -6.99696392e-02f, -2.68157106e-02f,
  -5.75154759e-02f, 2.01848254e-01f, -1.64104551e-02f, -6.80226311e-02f, -7.03979284e-02f, -2.35191882e-01f, -1.10066459e-01f, -2.17723444e-01f, -5.82377203e-02f, -1.35683864e-01f,
  7.69716576e-02f, -4.76172455e-02f, -1.19835436e-01f, -1.27118258e-02f, -4.12707441e-02f, -6.87234700e-02f, 4.95350622e-02f, -9.51700583e-02f, 2.13473607e-02f, -3.13781872e-02f,
  -4.98346947e-02f, -4.54232916e-02f, 2.90723909e-02f, 4.97958856e-03f, -1.18674769e-03f, -8.40192437e-02f, -7.13663921e-02f, -5.91649003e-02f, -4.27553728e-02f, -7.01579526e-02f,
  -7.30465800e-02f, -5.32514192e-02f, -7.83776632e-04f, 7.97977895e-02f, -9.45661068e-02f, 1.90710388e-02f, 5.27431108e-02f, -5.67826480e-02f, 6.38162196e-02f, -8.81378874e-02f,
  -9.26672369e-02f, -3.96503545e-02f, -3.02004963e-02f, -4.57242616e-02f, -6.09702729e-02f, -5.50566800e-02f, 3.43079790e-02f, 2.38816515e-02f, -8.26587304e-02f, -5.99459037e-02f,
  -2.75686756e-02f, -5.76030128e-02f, -2.55792663e-02f, 3.07775866e-02f, 2.36229133e-02f, 6.50320277e-02f, -4.10026349e-02f, -7.39940330e-02f, -5.09197405e-03f, -6.08680733e-02f,
  1.57794338e-02f, -7.26095438e-02f, -1.44893052e-02f, 3.90879661e-02f, -4.79546040e-02f, 5.56158833e-02f, 7.27019683e-02f, -6.86529875e-02f, 5.01773320e-02f, 2.57567652e-02f,
  7.27392212e-02f, 5.95534369e-02f, -1.87188911e-03f, 3.18298489e-02f, 8.21812451e-02f, 4.31848653e-02f, 9.91053805e-02f, -3.54000763e-03f, -1.02537520e-01f, -3.28749008e-02f,
  2.28886172e-04f, 8.86857435e-02f, -4.99641113e-02f, 5.82439918e-03f, 1.26051316e-02f, 6.12960868e-02f, 3.31475884e-02f, 7.03629404e-02f, -4.03995141e-02f, 2.96558049e-02f,
  -4.62714434e-02f, -3.49686891e-02f, -7.12889656e-02f, 6.92134574e-02f, -1.40154054e-02f, 3.77859585e-02f, -5.98253720e-02f, 5.23370616e-02f, -1.75892804e-02f, 3.47636417e-02f,
  -1.75465867e-01f, -1.96651998e-03f, -4.52540442e-02f, -1.37282833e-01f, 8.73748139e-02f, 3.23143117e-02f, -4.46171407e-03f, 3.53911668e-02f, 1.02452919e-01f, -1.15640787e-02f,
  -6.57582581e-02f, -9.72589925e-02f, 4.50905301e-02f, -6.29326999e-02f, -2.08258674e-01f, -1.22333117e-01f, -2.05847725e-01f, -7.07734972e-02f, 1.36432752e-01f, 2.48229713e-03f,
  -1.23165719e-01f, -2.02035606e-02f, -1.70213297e-01f, 4.88036759e-02f, 2.38498617e-02f, -1.48418806e-02f, -9.45080593e-02f, 1.12373710e-01f, -1.18719108e-01f, 2.01403648e-02f,
  1.55249899e-02f, 1.42797962e-01f, -2.97455881e-02f, 8.08235407e-02f, -8.67382511e-02f, -8.35710317e-02f, -9.61469021e-03f, -1.48170860e-02f, 5.89757524e-02f, 4.53483351e-02f,
  5.09438515e-02f, -5.94233274e-02f, -5.38399555e-02f, 1.87619552e-02f, 1.04243793e-01f, 2.66673807e-02f, -4.25278172e-02f, 9.65519622e-03f, -4.60144831e-03f, 3.99904996e-02f,
  -2.13920586e-02f, -8.23082700e-02f, -8.01024660e-02f, 2.56878100e-02f, 1.67047419e-02f, 9.37505737e-02f, -9.71381217e-02f, -7.05178678e-02f, -2.82402541e-02f, -9.21761245e-02f,
  8.92468244e-02f, 6.86175525e-02f, 5.17901704e-02f, -4.27614199e-03f, 7.94885159e-02f, 5.16451299e-02f, 7.18559697e-02f, -7.82849416e-02f, 3.73108685e-02f, 7.50914216e-03f,
  6.33627921e-02f, 8.60716850e-02f, -3.63457799e-02f, 3.75800431e-02f, -2.15977598e-02f, -5.18929809e-02f, -6.88912198e-02f, -6.40502200e-02f, -6.59423545e-02f, 3.55527103e-02f,
  1.06459178e-01f, 5.76263443e-02f, -5.84864505e-02f, 6.42053485e-02f, -6.68389797e-02f, 2.03907653e-03f, 5.03783338e-02f, -7.01510310e-02f, 2.37667970e-02f, 4.21294458e-02f,
  6.20676428e-02f, 4.58986983e-02f, 7.25519434e-02f, 1.08901590e-01f, -3.25012282e-02f, -7.87825957e-02f, -3.27859633e-02f, 2.42026281e-02f, 5.48057370e-02f, 2.37235874e-02f,
  -5.53037077e-02f, 6.21105218e-03f, -3.64103392e-02f, -1.58645548e-02f, 5.18451119e-03f, 6.73852116e-02f, -6.55370802e-02f, 3.66068142e-03f, 1.96611285e-02f, -4.24749106e-02f,
  3.70761119e-02f, -5.06750345e-02f, 1.12242140e-02f, 1.26772206e-02f, 3.08539290e-02f, -7.48853162e-02f, 2.56942995e-02f, -6.54681996e-02f, -8.83868337e-02f, 5.10344207e-02f,
  -2.46953845e-01f, -1.53364148e-03f, 1.87161490e-01f, -2.15536416e-01f, 9.16606188e-03f, -1.48429470e-02f, 5.14056236e-02f, -4.17480245e-02f, 1.83672309e-02f, -9.67673659e-02f,
  -5.44698499e-02f, -8.89561549e-02f, 9.17377546e-02f, -4.72265966e-02f, -8.06640387e-02f, 1.68806851e-01f, -1.22371644e-01f, -3.15369405e-02f, 4.37134951e-02f, -1.11910567e-01f,
  -1.02040701e-01f, -6.11298718e-02f, 1.28728300e-02f, 1.33891642e-01f, -1.33492649e-01f, -8.60503241e-02f, -1.31818354e-01f, 1.47652298e-01f, -1.10580988e-01f, -2.25172956e-02f,
  -1.16835661e-01f, -1.08818263e-02f, -1.01928912e-01f, 1.16102332e-02f, 1.24998437e-02f, -9.87735242e-02f, -9.99760777e-02f, -2.27584131e-02f, 4.89372434e-03f, 6.95034713e-02f,
  -3.97055671e-02f, -7.41594359e-02f, 4.05343622e-02f, -5.24097979e-02f, 1.60666592e-02f, 8.84365141e-02f, 6.06503151e-02f, 6.69502094e-02f, -6.08119816e-02f, 2.97132619e-02f,
  5.99841550e-02f, -2.23802943e-02f, 2.70198546e-02f, 1.20644849e-02f, -3.15343626e-02f, 1.08574137e-01f, -7.38197565e-02f, 2.37091240e-02f, -7.92513788e-02f, -6.07430786e-02f,
  9.58849117e-02f, 3.43750301e-03f, 3.68511751e-02f, 5.25243320e-02f, 4.90761288e-02f, -7.00592920e-02f, -2.57614069e-02f, 1.29748601e-02f, -7.08938539e-02f, 6.04845770e-02f,
  -8.47593397e-02f, -3.71344462e-02f, -2.37384252e-02f, 1.65883433e-02f, 2.27900641e-03f, 5.89356720e-02f, -2.86490354e-03f, -3.16050611e-02f, -2.55533699e-02f, 7.43137766e-03f,
  4.83339876e-02f, -8.81572887e-02f, 1.04523338e-01f, -7.82051384e-02f, 5.36407493e-02f, -4.46673520e-02f, 6.12384034e-03f, 4.36274111e-02f, 6.04133233e-02f, 2.07293872e-02f,
  -1.84176117e-01f, -1.94520742e-01f, 3.01925950e-02f, -1.06673010e-01f, -6.57860264e-02f, 5.08237667e-02f, 7.33341649e-02f, -9.16586071e-02f, -4.76437919e-02f, 2.48334650e-03f,
  2.28535347e-02f, 2.16048174e-02f, -1.76859982e-02f, 6.43780753e-02f, -2.64150575e-02f, -5.95666356e-02f, -5.96604832e-02f, 4.06330824e-02f, -5.28538413e-02f, 3.76073346e-02f,
  -1.21188000e-01f, 4.31283042e-02f, -4.62823659e-02f, 3.88629884e-02f, 1.63933113e-02f, -1.07081637e-01f, -8.55492279e-02f, -4.96399589e-02f, -3.37764695e-02f, -6.17542788e-02f,
  3.79797481e-02f, -2.74620026e-01f, -4.18951921e-02f, 6.78289235e-02f, 7.55897015e-02f, 4.99780104e-02f, 1.15903452e-01f, -9.33712721e-02f, -4.03542332e-02f, -2.56933600e-01f,
  1.07809030e-01f, 4.48643081e-02f, 1.49639025e-01f, -6.24310635e-02f, 8.54135603e-02f, 9.45122093e-02f, -7.99234658e-02f, -1.14202805e-01f, -2.37658508e-02f, -2.90669431e-03f,
  -2.22377349e-02f, 9.81438756e-02f, 7.21653178e-02f, -1.56025887e-01f, -1.00511257e-02f, -1.55760780e-01f, -1.36398198e-02f, 1.62081867e-01f, -8.01969245e-02f, 2.57067140e-02f,
  4.01393510e-02f, 7.03930706e-02f, 3.34153846e-02f, 6.80610985e-02f, -8.85500386e-02f, -2.19849832e-02f, -6.28807396e-02f, 7.02456981e-02f, 3.24280187e-03f, 5.99387325e-02f,
  -7.75385424e-02f, 5.03852032e-03f, -3.44316475e-02f, 6.14808686e-02f, -4.58359569e-02f, -5.26248626e-02f, -1.73854548e-02f, -7.96953961e-02f, 1.02877304e-01f, 5.71686402e-02f,
  3.55824307e-02f, -8.66801366e-02f, -4.57879007e-02f, 1.20253414e-02f, 6.50134683e-02f, 6.05902597e-02f, -5.07852435e-02f, 2.02637799e-02f, 2.85644038e-03f, 1.06960237e-02f,
  1.54483430e-02f, -2.12758146e-02f, 4.45497595e-03f, 7.01030046e-02f, 2.94622667e-02f, 8.50717723e-02f, 3.14764343e-02f, 6.92724362e-02f, 7.07031833e-03f, 4.56266738e-02f,
  8.13571215e-02f, 9.23699960e-02f, -4.70160916e-02f, -6.15118667e-02f, 5.18905595e-02f, 4.09882553e-02f, -2.84178797e-02f, 7.41331801e-02f, -9.61882435e-03f, -7.52780512e-02f,
  4.02810052e-02f, 6.38913959e-02f, -8.93127397e-02f, 6.89169690e-02f, -1.21081444e-02f, 9.71321017e-02f, -3.91654260e-02f, 4.26176786e-02f, 2.55950112e-02f, 6.83528259e-02f,
  -1.25871629e-01f, -1.96926638e-01f, -9.24599320e-02f, -2.55920384e-02f, 4.08463068e-02f, -1.25503108e-01f, -8.66730735e-02f, 8.02538474e-04f, 1.14602474e-02f, -2.20082910e-03f,
  -1.45166546e-01f, 1.79332625e-02f, -9.60752144e-02f, 1.60446335e-02f, -8.54396224e-02f, 2.56737717e-03f, -1.44689735e-02f, -4.91458140e-02f, -1.73435602e-02f, -9.78589728e-02f,
  6.43751621e-02f, 3.70073617e-02f, 6.95987255e-04f, -2.81958524e-02f, -4.13940437e-02f, -1.55170029e-02f, -8.56663510e-02f, -1.00501537e-01f, -5.99319153e-02f, -5.92494123e-02f,
  1.09241724e-01f, 9.36649889e-02f, 4.61119786e-02f, -6.37538591e-03f, -5.10610342e-02f, -7.45452642e-02f, -2.54068524e-02f, 1.32195681e-01f, -1.37505364e-02f, 1.24658547e-01f,
  -5.94554543e-02f, 2.02098861e-01f, -3.42964083e-02f, 4.63980995e-02f, -4.71429713e-02f, -1.10698871e-01f, 1.05169509e-02f, -7.72502497e-02f, -2.54436880e-02f, 1.76021621e-01f,
  -4.61275466e-02f, 8.38162377e-02f, 7.46303052e-02f, 7.87320808e-02f, 1.02020174e-01f, 2.62927543e-02f, 1.05384380e-01f, -4.55340557e-02f, 1.12222984e-01f, 2.06681713e-02f,
  3.73344384e-02f, 1.20593935e-01f, 5.39582334e-02f, 5.97618893e-02f, -8.04606453e-02f, -6.66017756e-02f, -1.29292095e-02f, 2.70668045e-02f, -7.94822723e-02f, -3.70162129e-02f,
  -4.74745929e-02f, -4.99487109e-02f, 7.87805300e-03f, 1.35092670e-02f, 5.34552485e-02f, 7.59691894e-02f, 5.25793508e-02f, 5.49868867e-02f, 9.95422527e-02f, -3.68990935e-02f,
  1.22295991e-02f, -1.25909438e-02f, 8.86600316e-02f, 3.86035107e-02f, -6.93518519e-02f, -4.09731679e-02f, -8.31833109e-02f, 5.00430912e-02f, 9.72005799e-02f, 2.30363011e-03f,
  1.20866612e-01f, -7.95535892e-02f, -2.39203516e-02f, -6.29728585e-02f, -3.36826555e-02f, -5.71181253e-03f, -2.28972603e-02f, -8.95910040e-02f, -6.83099031e-02f, -1.77321099e-02f,
  2.68510655e-02f, 6.79168776e-02f, 6.35413975e-02f, 6.86296374e-02f, -2.47248430e-02f, 3.79549637e-02f, -5.88876233e-02f, 3.14798951e-02f, -3.17712724e-02f, -3.27544995e-02f,
  -8.18611681e-02f, -1.90952122e-02f, 8.90054703e-02f, 1.02128796e-02f, -6.28977045e-02f, -4.17998433e-02f, 4.46847007e-02f, 4.12873700e-02f, -9.90982205e-02f, -7.92380124e-02f,
  -3.14989835e-02f, 1.74885362e-01f, 6.97483718e-02f, -7.41227046e-02f, -3.35622765e-02f, 3.17008384e-02f, -1.56247607e-02f, -4.66779387e-03f, 1.05799332e-01f, 2.84899753e-02f,
  -4.27004732e-02f, 8.56566709e-03f, 7.34450668e-02f, 7.09522096e-03f, 2.74372362e-02f, 2.04748604e-02f, -3.12380362e-02f, 3.01667377e-02f, 4.36522812e-02f, -4.01368663e-02f,
  5.90574853e-02f, 9.86562595e-02f, 6.78575486e-02f, 1.92766935e-02f, 6.50643110e-02f, -1.86398334e-03f, 1.55676324e-02f, 5.56758381e-02f, 9.64150112e-03f, -4.05761749e-02f,
  7.02733025e-02f, -1.38430104e-01f, -5.75281382e-02f, 1.11790575e-01f, 7.12553784e-02f, -8.30876902e-02f, 4.45882902e-02f, 1.18944347e-01f, 1.49364561e-01f, -9.53007415e-02f,
  -3.63254696e-02f, -1.16652958e-01f, 6.07458912e-02f, -1.03858441e-01f, -4.89929225e-03f, -4.20118123e-02f, 9.98063385e-03f, -2.21412610e-02f, 1.47343650e-01f, -8.03228691e-02f,
  4.44203615e-02f, 2.50145756e-02f, -1.30652580e-02f, -1.07980475e-01f, -7.31506795e-02f, -2.74054427e-02f, 2.56516766e-02f, -4.20508310e-02f, -1.52090505e-01f, -8.39749798e-02f,
  -8.19461867e-02f, 9.69312433e-03f, -7.62297884e-02f, 5.14063686e-02f, -4.49549034e-02f, -5.39802127e-02f, -3.35777737e-02f, -2.17475910e-02f, -6.21520504e-02f, 6.87575862e-02f,
  4.40143421e-02f, 1.35693280e-02f, -3.10100652e-02f, -6.12107106e-02f, -4.76387180e-02f, 5.12608839e-03f, 6.49863482e-02f, -3.50963995e-02f, -6.07433077e-03f, -1.39128491e-02f,
  4.70646545e-02f, -8.69099423e-02f, -6.95730522e-02f, 4.53170612e-02f, 4.11497429e-02f, -5.39788157e-02f, 5.27179427e-02f, -6.66087717e-02f, -3.18595730e-02f, -5.88274449e-02f,
  1.91653669e-02f, -7.14939982e-02f, 1.86763313e-02f, 2.25048102e-02f, 3.13432841e-03f, -5.65753803e-02f, 1.54249789e-02f, 2.99590752e-02f, -2.95034866e-03f, 4.44341637e-02f,
  -6.20318716e-03f, 2.41601956e-03f, -5.30795380e-02f, -6.42380863e-02f, -1.51009336e-02f, 6.23585954e-02f, -4.06915834e-03f, 5.44654615e-02f, 9.43848118e-02f, 4.00632736e-04f,
  -6.85783401e-02f, 8.35311338e-02f, -1.89543385e-02f, 3.73962112e-02f, -6.95414320e-02f, -1.34688278e-03f, 2.79453192e-02f, 1.80063378e-02f, 8.37446377e-02f, 1.23197706e-02f,
  -1.11803085e-01f, -2.43237726e-02f, -7.99177885e-02f, -6.91585690e-02f, -1.30154118e-02f, -2.27672923e-02f, 1.20312376e-02f, 3.47366147e-02f, -9.35408473e-02f, 6.64352924e-02f,
  -2.50828695e-02f, 6.82052299e-02f, -2.75726151e-02f, 7.42987096e-02f, -6.91473708e-02f, -3.01282033e-02f, -3.73772644e-02f, -3.24701518e-02f, -8.46839771e-02f, -2.53861938e-02f,
  -9.84964659e-04f, 2.58808327e-03f, -9.90688335e-03f, -6.81432486e-02f, 4.40749936e-02f, 4.84917015e-02f, 6.41804934e-02f, -3.73202451e-02f, 7.29129612e-02f, 4.00850549e-02f,
  -1.06807627e-01f, 1.66886449e-01f, 1.38593510e-01f, 4.11581434e-02f, -9.24023613e-02f, 2.20679626e-01f, 2.19332322e-01f, -2.50910576e-02f, 6.80902302e-02f, -6.84344918e-02f,
  1.28141921e-02f, 1.63624391e-01f, 8.14279616e-02f, 3.83179560e-02f, 1.71134189e-01f, 9.78384465e-02f, 1.25348359e-01f, 1.77084908e-01f, -4.09198403e-02f, 2.10167672e-02f,
  -1.17126994e-01f, -8.37276205e-02f, 4.60244492e-02f, -4.89358641e-02f, -4.86866683e-02f, -8.75344649e-02f, 7.76776485e-03f, 2.10956987e-02f, -2.09328439e-02f, 9.90807451e-03f,
  -4.48672548e-02f, -9.54756290e-02f, -4.07109590e-04f, 4.43975404e-02f, 1.79972704e-02f, 7.30861500e-02f, 4.66733389e-02f, 9.08797756e-02f, 9.89616383e-03f, -2.04001330e-02f,
  7.09891468e-02f, 5.06372862e-02f, -1.00063523e-02f, 7.50551298e-02f, -5.35212271e-02f, 1.25051057e-02f, 5.13113104e-02f, -1.04017975e-02f, -3.24811861e-02f, -7.98879191e-02f,
  8.67780447e-02f, -1.03873722e-02f, 3.64773422e-02f, 6.20793514e-02f, 2.15646550e-02f, 2.68942453e-02f, -2.51852553e-02f, 5.18247448e-02f, 5.24692126e-02f, 9.47957933e-02f,
  8.98663253e-02f, 8.92178118e-02f, 4.68503945e-02f, 2.22140290e-02f, 9.69923846e-03f, -8.86635482e-02f, -2.32395958e-02f, 7.46325403e-02f, 3.09773977e-03f, -4.59402278e-02f,
  3.85414138e-02f, 3.56654637e-02f, 2.45707296e-02f, -2.52898466e-02f, -1.11688152e-01f, -4.62575257e-02f, 6.64794296e-02f, -6.82256818e-02f, 3.23285125e-02f, -8.85261744e-02f,
  -6.37181327e-02f, 8.70643705e-02f, 3.19398455e-02f, 1.57934763e-02f, 6.99713156e-02f, -5.74834049e-02f, -8.33084807e-03f, 6.41705245e-02f, 3.52168903e-02f, -6.93632737e-02f,
  5.44159114e-02f, 1.54422810e-02f, 8.07255283e-02f, 5.60920015e-02f, 8.08635727e-02f, 1.52394827e-02f, 2.74017155e-02f, -1.21097714e-02f, 7.73339868e-02f, 8.72043148e-02f,
  -5.99596985e-02f, 9.95131508e-02f, 7.50795454e-02f, -5.39968424e-02f, 2.72804499e-02f, -6.48547709e-03f, 6.61268681e-02f, -9.16533452e-03f, 5.37740206e-03f, -7.29881302e-02f,
  3.69477421e-02f, 3.44116352e-02f, -8.45848247e-02f, -1.10134587e-01f, 2.89753769e-02f, 1.07261660e-02f, -3.26224752e-02f, -6.82050362e-02f, 5.60415164e-02f, 6.90915138e-02f,
  1.45762209e-02f, -1.52990207e-01f, -4.62044403e-02f, 1.14298657e-01f, 1.77770689e-01f, 9.06232819e-02f, 5.51861338e-02f, 7.62849525e-02f, 1.81433320e-01f, -1.29910126e-01f,
  -4.30801772e-02f, -1.38542824e-03f, -1.36160618e-02f, 1.04448996e-01f, 1.44268377e-02f, -1.09866671e-01f, -7.32226763e-03f, -3.93116362e-02f, -1.25191305e-02f, -5.90952523e-02f,
  1.04779348e-01f, 9.82081443e-02f, -5.23938239e-02f, 5.37494533e-02f, -4.26248163e-02f, -7.25960061e-02f, -2.12405045e-02f, -7.36343786e-02f, -6.20174862e-04f, 4.77801263e-02f,
  2.83657443e-02f, 6.00151941e-02f, -6.60050102e-03f, -9.70319808e-02f, 5.66413812e-02f, 8.32958799e-03f, -8.54180530e-02f, 5.49082346e-02f, 1.08146168e-01f, -7.34406412e-02f,
  -6.15047552e-02f, 1.73411313e-02f, -1.65872052e-02f, -2.32156273e-02f, 4.35942747e-02f, 7.66272321e-02f, 1.75563097e-02f, -2.57986188e-02f, -8.90278220e-02f, -4.17135060e-02f,
  -3.09115779e-02f, -1.12598307e-01f, 9.15099159e-02f, -1.02200635e-01f, 1.63455550e-02f, 7.84368590e-02f, 5.76337706e-03f, -5.80477938e-02f, 3.05115674e-02f, 6.07322045e-02f,
  -8.47475827e-02f, -8.92642438e-02f, 6.75691962e-02f, -1.00879744e-03f, 7.87375569e-02f, -5.58648929e-02f, 5.75384796e-02f, -2.09531579e-02f, 1.07438937e-02f, -1.05471015e-02f,
  -1.07195536e-02f, 1.64389389e-03f, 3.70856114e-02f, -1.28546655e-02f, -8.04735646e-02f, -3.07388231e-02f, -3.17542925e-02f, 4.81291600e-02f, -5.92322014e-02f, -8.92814994e-02f,
  2.62498334e-02f, 3.00696362e-02f, -1.74327251e-02f, -9.30447876e-02f, 2.99446229e-02f, 6.80800900e-02f, -9.75250900e-02f, -8.53591785e-02f, -6.77271932e-02f, -6.33656979e-02f,
  -5.04246317e-02f, -6.80778548e-02f, 7.90903196e-02f, -3.76106426e-02f, 2.29929499e-02f, -2.70244032e-02f, 2.20290795e-02f, 8.20831358e-02f, 2.18648054e-02f, -6.66070357e-02f,
  -1.24051073e-03f, 1.42477425e-02f, 7.55793229e-02f, -5.55344298e-02f, 2.70424271e-03f, 2.09714398e-02f, -9.98164341e-02f, 5.56347258e-02f, 4.20663096e-02f, -8.43632966e-02f,
  -7.19231553e-03f, -6.59519481e-03f, 5.81925586e-02f, -1.51116669e-03f, 6.52949065e-02f, -4.94550690e-02f, 7.95056373e-02f, -5.34323566e-02f, -4.78912331e-02f, 5.21057546e-02f,
  -1.14109620e-01f, 1.58152297e-01f, 2.27705408e-02f, 7.22251758e-02f, -1.34292692e-01f, 5.37288450e-02f, 7.66587406e-02f, 4.45189178e-02f, 8.59530643e-02f, 2.88048363e-03f,
  -9.31772143e-02f, -2.40700077e-02f, 9.61647332e-02f, -1.35806724e-02f, 5.72749861e-02f, 1.41462103e-01f, 9.39378515e-02f, -5.25242183e-03f, 1.08783565e-01f, -2.90910974e-02f,
  7.20835328e-02f, 3.28716859e-02f, 7.35492632e-02f, -1.20242260e-01f, -4.75104265e-02f, 8.36952627e-02f, -7.41370171e-02f, 1.00622699e-01f, 2.57784706e-02f, 2.53270529e-02f,
  -3.45835276e-02f, 3.88420746e-02f, 6.69228509e-02f, 2.18875129e-02f, -6.60472587e-02f, -1.41950874e-02f, 9.66438558e-03f, 3.99500839e-02f, 1.04699589e-01f, -4.80172411e-02f,
  -6.08821027e-02f, -2.64553726e-02f, -9.58038419e-02f, 4.39774990e-02f, -5.53605109e-02f, -6.13134413e-04f, 2.90303864e-03f, -1.05029710e-01f, 8.69193953e-03f, -7.49454796e-02f,
  1.69669893e-02f, -2.39538425e-03f, -4.02915925e-02f, -3.99967171e-02f, 4.15354632e-02f, -1.06502855e-02f, -7.58156553e-02f, 1.55278742e-02f, 1.48783904e-02f, -8.34376458e-03f,
  9.16255489e-02f, -7.82863945e-02f, -1.00039154e-01f, -4.10852842e-02f, -1.27948076e-02f, 7.38658383e-02f, -4.40657698e-02f, -1.58475582e-02f, 6.52074218e-02f, 2.35794242e-02f,
  2.88800281e-02f, -4.52459082e-02f, -7.09557384e-02f, -4.58092093e-02f, -1.21296309e-02f, -2.28932984e-02f, 6.24390692e-02f, 6.11458719e-02f, -3.68940197e-02f, -6.47345707e-02f,
  8.44552666e-02f, 4.93913405e-02f, 9.47186071e-03f, -6.88149873e-03f, -3.45752239e-02f, -3.99747044e-02f, -2.32593715e-02f, -6.41910061e-02f, -3.27756777e-02f, 9.21900049e-02f,
  6.92594945e-02f, 1.72814816e-01f, 3.14252414e-02f, 4.98832203e-02f, 3.12213413e-02f, -1.58617441e-02f, -3.01687568e-02f, 4.09718566e-02f, 4.68826704e-02f, 5.94168678e-02f,
  -1.18924566e-02f, -4.80229557e-02f, 2.40762532e-02f, 2.29281615e-02f, 1.04930826e-01f, -8.07707757e-03f, 9.87133682e-02f, -5.71411736e-02f, 2.85649430e-02f, 3.75593565e-02f,
  6.59945905e-02f, 2.43347958e-02f, -8.70039780e-03f, -6.72297627e-02f, -1.32720331e-02f, -3.41394916e-02f, -2.78485361e-02f, 3.42481248e-02f, -2.34326646e-02f, 9.39549059e-02f,
  -1.40998870e-01f, 2.92086750e-01f, 2.86021014e-03f, -3.28163151e-03f, 2.56103463e-03f, 1.34652480e-01f, 5.59491254e-02f, 7.26573169e-02f, 6.32044896e-02f, -1.57332793e-03f,
  -3.25362347e-02f, 1.34839520e-01f, 2.71803346e-02f, 1.48514658e-01f, 1.19170956e-01f, 8.46406966e-02f, 2.10561324e-02f, -3.44898738e-02f, -4.22355831e-02f, -3.58710326e-02f,
  -5.82343526e-02f, 9.00415182e-02f, 4.92304303e-02f, 9.74931940e-02f, 5.23001589e-02f, -7.99031630e-02f, -5.92387766e-02f, -9.14516971e-02f, 5.42930663e-02f, 1.31669402e-01f,
  9.65074264e-03f, 1.93085074e-02f, -1.24492459e-01f, -2.95638070e-02f, -9.17215422e-02f, 2.05615275e-02f, -5.53856827e-02f, 6.09665774e-02f, -5.00163063e-02f, -8.97395983e-02f,
  -6.46391558e-03f, 4.76202331e-02f, 4.55588698e-02f, 3.44981179e-02f, -2.50452049e-02f, 1.30394129e-02f, -6.55656606e-02f, -9.02851224e-02f, -2.12827418e-02f, -2.08405405e-03f,
  3.87739087e-03f, -2.79913191e-02f, -1.05299868e-01f, 5.77257089e-02f, 3.63759100e-02f, -4.17277031e-03f, -6.89498037e-02f, -1.34978518e-02f, -1.78708285e-02f, -2.16609742e-02f,
  -5.08376993e-02f, -8.84166583e-02f, -4.40477207e-02f, 2.76706629e-02f, 1.19513106e-02f, 7.07645621e-03f, 7.56210759e-02f, -6.32987320e-02f, 3.81877758e-02f, -1.00421831e-02f,
  -1.54727427e-02f, 7.95004815e-02f, -9.83028337e-02f, 3.77523527e-02f, 5.99509068e-02f, -5.73060066e-02f, -7.20377732e-03f, 4.88904715e-02f, 6.92974553e-02f, -1.96938850e-02f,
  -8.16498883e-03f, 2.92997733e-02f, -5.33091463e-02f, -5.09787612e-02f, -5.89143857e-02f, -2.07036491e-02f, -1.06941350e-02f, 2.06623375e-02f, -5.99329732e-02f, 7.93637410e-02f,
  8.07775334e-02f, -1.86174363e-02f, 6.51645809e-02f, -9.69863981e-02f, 6.88378215e-02f, -1.97627153e-02f, -2.25575715e-02f, -7.65062794e-02f, -6.59719259e-02f, -8.11421946e-02f,
  4.55191806e-02f, 2.80865841e-02f, 6.08764179e-02f, -2.87674218e-02f, 5.47026694e-02f, 9.89922658e-02f, 2.79538389e-02f, 2.04323921e-02f, -6.87847883e-02f, 9.31828469e-02f,
  -7.39396438e-02f, -6.62779883e-02f, -8.84870738e-02f, 4.22498817e-03f, 1.69971154e-05f, -6.62244558e-02f, -4.80151772e-02f, -5.50410803e-03f, -5.19832112e-02f, 8.40149180e-04f,
  -1.13527872e-01f, 1.09403692e-02f, -3.51371989e-02f, 2.72710752e-02f, 3.91384661e-02f, -4.30976087e-03f, -2.63352077e-02f, 5.27492277e-02f, 9.56540648e-03f, -2.15723012e-02f,
  4.04010713e-02f, 7.62419850e-02f, 6.13029562e-02f, -1.37832850e-01f, -3.01689073e-03f, -7.13640824e-02f, -1.60124823e-02f, 1.01400912e-02f, 7.24584386e-02f, -4.27703410e-02f,
  -4.48413147e-03f, 1.48798330e-02f, -1.48862004e-01f, -2.51367651e-02f, -1.89675880e-03f, 9.51361880e-02f, 7.89692327e-02f, 4.31328379e-02f, -5.68131395e-02f, -7.43466318e-02f,
  -7.48728216e-02f, 8.24028030e-02f, -1.05096847e-01f, 6.35192618e-02f, -8.09348654e-03f, -2.07362957e-02f, -8.88718516e-02f, -7.69249722e-02f, -4.34545763e-02f, 1.93146076e-02f,
  7.04274550e-02f, 6.45916462e-02f, 7.02356771e-02f, 1.93907078e-02f, 7.10535347e-02f, 6.19841330e-02f, -1.00921735e-01f, 2.39008628e-02f, 4.81970273e-02f, -5.45682870e-02f,
  -3.35317254e-02f, 7.72847310e-02f, 1.64935235e-02f, -3.14569138e-02f, -6.40722662e-02f, 3.63166258e-02f, -2.16315351e-02f, 6.33894131e-02f, 2.98869591e-02f, 8.09136927e-02f,
  3.41797657e-02f, 3.92319895e-02f, -3.65695776e-03f, -4.88184430e-02f, -6.01365045e-02f, -1.58024151e-02f, -3.89681272e-02f, 4.49399278e-02f, -7.61500150e-02f, -4.35134731e-02f,
  -2.54195053e-02f, 2.18279529e-02f, 4.05126512e-02f, 8.67638364e-03f, -3.03038210e-02f, -2.81835049e-02f, 7.80537054e-02f, -6.18693307e-02f, -7.18335481e-03f, 7.75546357e-02f,
  -4.63064425e-02f, -3.53103280e-02f, 3.46413851e-02f, -1.08929753e-01f, 3.63510661e-02f, 3.18897031e-02f, 9.08991918e-02f, -7.54551031e-03f, 1.87335163e-02f, 8.66422728e-02f,
  8.99723098e-02f, 1.69645101e-01f, 7.37715587e-02f, -2.79395320e-02f, 7.88349193e-03f, -4.74485978e-02f, 5.85616156e-02f, -8.16627815e-02f, -4.39101597e-03f, 1.02730341e-01f,
  6.48749098e-02f, -7.44357333e-02f, -2.34188698e-02f, -3.35515141e-02f, 2.64804857e-03f, 8.35611522e-02f, -6.98106037e-03f, 1.10292800e-01f, 7.26449490e-02f, -2.36685816e-02f,
  -2.48975158e-02f, -1.84342153e-02f, -5.08069899e-03f, -4.24761698e-02f, -7.80044869e-02f, 2.39607450e-02f, 5.58721609e-02f, 6.53342307e-02f, 9.21645164e-02f, 6.86917081e-02f,
  6.37867078e-02f, -4.98736501e-02f, 4.17654216e-03f, 8.14107433e-02f, 1.24011755e-01f, 4.40842658e-02f, 4.61094873e-03f, -7.10594729e-02f, 2.25247163e-02f, -6.24590032e-02f,
  9.74784195e-02f, 9.26736556e-03f, -7.21731260e-02f, 6.31902553e-03f, 7.88978413e-02f, -6.08377233e-02f, 6.69133365e-02f, 2.48215348e-02f, -1.03823781e-01f, 1.15890004e-01f,
  6.99017197e-02f, 1.12698227e-01f, 9.79861710e-03f, -4.84884121e-02f, -6.47012237e-03f, 1.42254047e-02f, -8.63809139e-03f, -2.30796393e-02f, 9.36927125e-02f, -3.96747924e-02f,
  1.18684545e-02f, -4.75785062e-02f, -6.71099275e-02f, -1.13224993e-02f, 7.19353110e-02f, 6.93138540e-02f, 5.65916300e-02f, 5.41197546e-02f, -3.75130363e-02f, 7.41893724e-02f,
  9.78291035e-02f, -3.10013779e-02f, 7.85410926e-02f, 1.97536536e-02f, -3.77009303e-04f, 5.68790771e-02f, -7.55886361e-02f, 6.10329583e-02f, 1.60824135e-02f, 7.16456845e-02f,
  5.83746433e-02f, -5.93181029e-02f, -7.59180412e-02f, -3.34727764e-02f, 6.54625818e-02f, -2.87666228e-02f, 4.20661718e-02f, 6.15501544e-03f, -4.76005375e-02f, 3.48869376e-02f,
  -5.44156767e-02f, 7.45438710e-02f, 6.98009431e-02f, -2.55961027e-02f, -4.99050990e-02f, -2.02120896e-02f, -5.21434508e-02f, -8.03375170e-02f, -5.67247383e-02f, 8.74217320e-03f,
  -5.87530993e-02f, 6.29370287e-02f, 8.93505737e-02f, 7.73401409e-02f, 8.22747648e-02f, 7.18494058e-02f, -1.83051024e-02f, -4.10920642e-02f, 5.86655997e-02f, -2.52788719e-02f,
  2.17834059e-02f, 7.57187381e-02f, 3.72300036e-02f, -6.29617795e-02f, 2.54055727e-02f, 1.02808356e-01f, 8.42748210e-02f, -2.49008983e-02f, -1.97803974e-02f, 2.69816592e-02f,
  1.04458379e-02f, 8.39796886e-02f, -7.60418409e-03f, -4.48968541e-03f, 2.20707469e-02f, 1.07151657e-01f, 2.24409290e-02f, -4.15220931e-02f, 4.46826257e-02f, -1.25114294e-02f,
  7.99346492e-02f, -6.70673475e-02f, -3.01821157e-02f, -5.20489477e-02f, -1.01705238e-01f, 8.27036351e-02f, 9.62092206e-02f, -3.98739204e-02f, -2.21059155e-02f, -6.86015859e-02f,
  -3.73955332e-02f, -8.32921043e-02f, 1.42505150e-02f, -8.19297880e-03f, 9.15507879e-03f, -6.82074279e-02f, -5.58749819e-03f, 1.17595373e-02f, -5.83917610e-02f, -8.53777900e-02f,
  -9.86988023e-02f, -1.92340136e-01f, 4.19531465e-02f, 1.16447017e-01f, -9.04797018e-02f, -1.95602790e-01f, -2.58810997e-01f, -8.47284347e-02f, -9.04379264e-02f, -9.37957168e-02f,
  -6.74992278e-02f, 1.20921411e-01f, -1.94742024e-01f, 1.48015052e-01f, 2.67998785e-01f, 1.05672933e-01f, 1.12688698e-01f, 6.36926889e-02f, 6.57868460e-02f, 5.80293797e-02f,
  2.24397466e-01f, 1.21453889e-01f, 2.81288952e-01f, 1.92202538e-01f, 2.70905010e-02f, 4.71810624e-02f, 2.10207894e-01f, 4.70414348e-02f, 2.35559911e-01f, 1.22534066e-01f,
  -8.11989978e-02f, 4.26489301e-02f, -2.83391513e-02f, 7.26096183e-02f, -9.80137438e-02f, 2.99200565e-02f, -4.08820733e-02f, 1.20839663e-01f, 1.09362781e-01f, 2.79189199e-02f,
  4.09125350e-02f, -3.73118818e-02f, 5.14579192e-02f, 8.17487016e-02f, 2.36230232e-02f, 8.49538520e-02f, 3.37828556e-03f, -2.80563906e-03f, -7.36546740e-02f, -1.23210259e-01f,
  -8.57358873e-02f, 3.13469842e-02f, 2.19877977e-02f, 8.51291642e-02f, 2.20870785e-02f, -5.61885945e-02f, 1.11117102e-02f, 4.20093425e-02f, -1.47365332e-02f, -3.57501432e-02f,
  -2.77107004e-02f, -1.09722128e-03f, -6.96789026e-02f, -4.13115434e-02f, -1.58774182e-02f, 1.27438316e-03f, -4.61668213e-04f, 1.95604321e-02f, 4.47742566e-02f, -3.64391017e-03f,
  8.41593221e-02f, 6.90800548e-02f, 6.90092072e-02f, 1.87657569e-02f, -3.84368375e-02f, -1.92209892e-02f, 7.45483264e-02f, -1.65400617e-02f, 6.45922646e-02f, 8.46865922e-02f,
  8.51183459e-02f, -7.15261400e-02f, -6.66895360e-02f, -5.65346293e-02f, 3.31013352e-02f, -3.36529464e-02f, 9.95777026e-02f, -1.49432186e-03f, -5.48111927e-03f, -2.72281431e-02f,
  2.58796010e-02f, -4.38658446e-02f, -5.54225333e-02f, -6.69260845e-02f, -3.49533260e-02f, -5.99528179e-02f, 1.18622392e-01f, -4.52426188e-02f, -3.83974873e-02f, -7.83333927e-02f,
  6.02246597e-02f, -1.40060801e-02f, 1.84835773e-02f, 3.44689302e-02f, 9.67149958e-02f, -3.92137058e-02f, -8.25942773e-03f, 7.82198384e-02f, 7.40650576e-03f, 2.73264498e-02f,
  -1.51602188e-02f, -1.60224400e-02f, -3.91422845e-02f, -7.29025826e-02f, 1.02078013e-01f, 3.96364667e-02f, -4.21943516e-03f, -7.60269761e-02f, -4.14849594e-02f, -1.57399867e-02f,
  1.28008770e-02f, -2.23021641e-01f, 5.49785309e-02f, 1.02189057e-01f, -3.95878404e-02f, -5.53637147e-02f, 1.39371634e-01f, -1.00924551e-01f, -7.57293552e-02f, -2.23430574e-01f,
  -9.56663117e-02f, 3.77979018e-02f, 2.84505979e-04f, -6.62550703e-02f, 2.26019323e-01f, -3.34466957e-02f, -2.33719172e-03f, 4.11794186e-02f, -8.02233666e-02f, -1.35437073e-02f,
  -4.68946695e-02f, -6.07311055e-02f, -2.62522921e-02f, -1.02795258e-01f, 4.45603542e-02f, -1.23500675e-02f, 1.27941102e-01f, 3.31571512e-02f, 7.22087994e-02f, 1.09192193e-01f,
  -5.57347685e-02f, -9.89722982e-02f, 1.06072277e-02f, -1.01252176e-01f, 3.48441117e-02f, -9.25967768e-02f, 7.01184571e-02f, -1.46621550e-02f, 5.59218042e-02f, 2.84841433e-02f,
  2.96901576e-02f, -4.76106293e-02f, -3.06362398e-02f, -1.32806608e-02f, -7.89939389e-02f, -1.04080811e-01f, -8.96433517e-02f, -7.72889052e-03f, -6.62551820e-02f, -8.52684677e-02f,
  2.10819836e-03f, 5.13964333e-02f, -3.59781981e-02f, -2.70371623e-02f, -3.01475544e-02f, 2.71361340e-02f, 7.09980950e-02f, -5.95142087e-03f, -3.58778015e-02f, -1.77207473e-03f,
  7.01744556e-02f, 6.05939934e-03f, 5.31483777e-02f, -5.35756126e-02f, -2.47409916e-03f, 7.54748564e-03f, -3.82732227e-02f, 3.81546952e-02f, 4.72864136e-02f, -6.53045028e-02f,
  -4.66408432e-02f, 6.57323450e-02f, -1.25251049e-02f, 1.87702328e-02f, 6.45416528e-02f, 7.75814205e-02f, 5.90112284e-02f, 5.71147427e-02f, -1.71676334e-02f, 5.97946495e-02f,
  2.23435517e-02f, -6.53064847e-02f, 4.02670056e-02f, -8.86428133e-02f, 1.80425998e-02f, -4.13245149e-02f, -4.04165909e-02f, -6.13449663e-02f, 1.34604042e-02f, -8.91498942e-03f,
  -1.49502024e-01f, -1.10910669e-01f, -9.55163240e-02f, -6.80799596e-03f, -3.26906480e-02f, -4.81469333e-02f, 5.21524549e-02f, 7.77566209e-02f, 7.92888552e-02f, 5.68608940e-02f,
  2.87758783e-02f, -5.91956824e-02f, 9.66772158e-03f, 2.05789749e-02f, 4.98432741e-02f, 2.75346544e-03f, -3.50185037e-02f, 1.51941199e-02f, -6.98156282e-02f, -1.05658494e-01f,
  -4.42992058e-03f, -5.73186949e-02f, -5.51475994e-02f, -4.10996042e-02f, 3.32460590e-02f, 3.23613063e-02f, 3.10103614e-02f, -6.20347932e-02f, 3.33815031e-02f, 4.98547703e-02f,
  2.05239028e-01f, -1.71118572e-01f, 4.09574918e-02f, 6.39221892e-02f, 3.62320095e-02f, -5.38905300e-02f, -4.20562737e-03f, -6.30866513e-02f, 8.21709707e-02f, -1.76755339e-01f,
  -1.14104234e-01f, -5.74245267e-02f, -6.22500665e-02f, -1.14691466e-01f, 1.81418821e-01f, -4.28419746e-02f, -1.20304488e-01f, 3.06664929e-02f, -3.40984799e-02f, -1.30661115e-01f,
  -4.66913767e-02f, -5.62741980e-02f, 3.70355323e-02f, -1.71926528e-01f, -7.55014122e-02f, -8.83821249e-02f, -1.90088470e-02f, -1.26814656e-02f, -1.00342236e-01f, -6.77164504e-03f,
  6.63045049e-02f, -7.19620734e-02f, 6.12976998e-02f, -1.00169338e-01f, -5.00534754e-03f, 2.49188822e-02f, -6.01454265e-02f, 8.45974162e-02f, -1.28705101e-02f, 6.29303008e-02f,
  8.51497576e-02f, -8.94511715e-02f, -5.89412041e-02f, 9.34506580e-02f, -7.19804168e-02f, 4.57300171e-02f, 2.03654710e-02f, 8.97922963e-02f, -6.40776083e-02f, -3.26658525e-02f,
  5.37957139e-02f, -1.38085810e-02f, 1.02769107e-01f, -9.60330963e-02f, -1.56752449e-02f, 1.70949660e-02f, -1.93504915e-02f, 8.05562660e-02f, 2.90824939e-02f, -5.32005057e-02f,
  -7.49895275e-02f, -2.77931280e-02f, -3.59037556e-02f, 1.59436613e-02f, 1.10968277e-02f, 1.07154083e-02f, -6.71664104e-02f, 4.78800908e-02f, -1.06849289e-02f, -6.82067424e-02f,
  -8.24663322e-03f, 6.39695972e-02f, 9.11066867e-03f, -4.04518433e-02f, 5.81306182e-02f, 6.03218339e-02f, -7.70324022e-02f, -8.79908726e-02f, 1.42504089e-02f, -8.80106762e-02f,
  3.02347708e-02f, -1.98434312e-02f, -1.34865493e-02f, -2.51576398e-02f, 3.33616398e-02f, -5.48376068e-02f, -9.74621326e-02f, -2.88025159e-02f, -1.74368806e-02f, -8.20862502e-02f,
  -1.11110687e-01f, -5.13545237e-02f, 3.65516208e-02f, 5.55627495e-02f, -5.39150424e-02f, -1.02204911e-01f, -1.15570292e-01f, 4.26271409e-02f, -3.76696102e-02f, -3.14168818e-02f,
  -9.70224813e-02f, 3.85485888e-02f, 7.01063201e-02f, 1.50436107e-02f, 3.70489731e-02f, 4.30201776e-02f, -7.80386031e-02f, 7.80862272e-02f, 4.06722818e-03f, -2.32496485e-02f,
  1.63667686e-02f, 6.30602660e-03f, 6.13640733e-02f, 7.13814273e-02f, -1.31231099e-01f, 1.58830807e-02f, -8.58034641e-02f, -9.07751918e-02f, 3.98272164e-02f, -1.04812905e-02f,
  2.79337075e-02f, 7.82914609e-02f, 1.09669439e-01f, 1.40187303e-02f, -8.01782683e-02f, -5.39494939e-02f, 8.67071971e-02f, -8.24365541e-02f, 3.90121117e-02f, 9.11137387e-02f,
  -7.54745230e-02f, 1.01049796e-01f, -1.09666392e-01f, 4.23241742e-02f, -1.37431249e-01f, -1.38304994e-01f, -7.81150758e-02f, 2.48248708e-02f, -4.47084662e-03f, 1.69209316e-02f,
  -9.64053050e-02f, -2.36425661e-02f, 5.11217266e-02f, -2.07615886e-02f, 7.94063210e-02f, 1.46793678e-01f, -1.81271266e-02f, -5.89337237e-02f, 6.97555766e-02f, -1.00619406e-01f,
  -4.46511693e-02f, -1.28021110e-02f, -1.30433990e-02f, 3.00310161e-02f, 1.90656297e-02f, -2.28966195e-02f, 4.14686790e-03f, 4.21194099e-02f, 6.50987476e-02f, 2.68438961e-02f,
  -6.62711039e-02f, 6.04003668e-02f, 2.72063613e-02f, -6.39253035e-02f, 3.38560790e-02f, -4.68066633e-02f, 2.97192372e-02f, 2.38310844e-02f, 9.07600597e-02f, -4.61946055e-02f,
  -3.60249393e-02f, 6.23493979e-04f, -4.25453205e-03f, 2.89089847e-02f, 8.52461457e-02f, 3.96999829e-02f, 8.02221522e-02f, 8.72879177e-02f, -2.38790456e-02f, -1.02165993e-02f,
  6.74423575e-02f, -5.07530570e-02f, 4.26077098e-02f, 4.24642116e-02f, 1.60770081e-02f, -4.79640774e-02f, 7.70930783e-04f, -1.56447459e-02f, -3.51765081e-02f, -1.39292451e-02f,
  -2.77310889e-02f, -3.23744826e-02f, -7.81563520e-02f, 3.29966918e-02f, 9.15866792e-02f, 2.40122303e-02f, 3.84635897e-03f, -2.19653044e-02f, -2.32086163e-02f, 1.70315802e-03f,
  -6.02851622e-02f, -4.96063828e-02f, 7.55883902e-02f, -8.01667050e-02f, -5.80648109e-02f, -6.86322600e-02f, 6.18282631e-02f, 4.30620313e-02f, 2.37968303e-02f, 4.02707420e-02f,
  -5.34877814e-02f, -8.95252172e-03f, 6.14725500e-02f, -9.56265405e-02f, 3.94461825e-02f, 1.57750864e-02f, -1.36474520e-02f, 8.38749018e-03f, 4.87009765e-06f, -1.52962646e-02f,
  -1.76664020e-04f, -9.32494644e-03f, -5.43940291e-02f, -5.62146530e-02f, 4.40948755e-02f, -3.04256706e-03f, -6.19678125e-02f, 4.60129641e-02f, 3.80984647e-03f, 7.71423653e-02f,
  8.92077312e-02f, -5.09979320e-04f, -7.22768307e-02f, 8.14352743e-03f, 7.61470050e-02f, 4.47965451e-02f, -3.97403389e-02f, 6.57653585e-02f, 7.27386326e-02f, 8.41403604e-02f,
  1.96185082e-01f, 8.67856666e-02f, -1.97261795e-01f, -7.09753260e-02f, -2.05130056e-02f, 4.32350896e-02f, -9.29218233e-02f, -3.27703170e-02f, -1.71277970e-01f, -2.35719308e-02f,
  -3.74040864e-02f, -1.01625748e-01f, -1.56551581e-02f, 4.50605415e-02f, 7.74823781e-03f, -9.87628549e-02f, 1.33444324e-01f, -2.51538567e-02f, -1.05286151e-01f, 7.83784762e-02f,
  -1.96322054e-02f, 1.92127392e-01f, -8.72700736e-02f, 1.31003901e-01f, 1.67587191e-01f, 1.02202356e-01f, 1.43580288e-01f, 2.71944925e-02f, 2.74651106e-02f, 6.88622892e-02f,
  -1.90518107e-02f, 8.65849331e-02f, -7.92638063e-02f, -3.98401320e-02f, 5.36399409e-02f, 5.01295850e-02f, 2.74925046e-02f, -6.37811720e-02f, -1.22011006e-01f, 3.51768062e-02f,
  4.55337986e-02f, -8.88826847e-02f, -1.48965418e-03f, -6.17982186e-02f, 8.41961056e-03f, -2.24753600e-02f, -8.86841044e-02f, 5.02521470e-02f, -1.31438775e-02f, 8.13208334e-03f,
  2.83433106e-02f, 1.85817201e-02f, 1.57979839e-02f, -7.12951720e-02f, -7.81701282e-02f, 6.17080741e-03f, -6.93600550e-02f, 3.68069448e-02f, 8.44373330e-02f, -4.64344546e-02f,
  3.25030796e-02f, -7.35055953e-02f, 6.24708757e-02f, -6.63383491e-03f, 1.93718914e-02f, 5.48090003e-02f, -8.96273777e-02f, -4.82906178e-02f, -1.87324658e-02f, 3.10287159e-02f,
  -2.76203151e-03f, -9.77598801e-02f, -4.60839011e-02f, 2.18803119e-02f, -4.00580131e-02f, -4.67095189e-02f, 2.18208339e-02f, -2.89428718e-02f, -4.69946228e-02f, 3.46238464e-02f,
  3.04143708e-02f, 5.16227074e-02f, -2.82946602e-02f, -8.22862014e-02f, -2.21830774e-02f, -3.43473144e-02f, 6.90529402e-03f, 7.08301365e-02f, -9.23526213e-02f, -7.97094870e-03f,
  1.14099206e-02f, 2.18835741e-01f, 1.05337156e-02f, 2.54336260e-02f, -8.94808546e-02f, 9.46534574e-02f, 3.94736528e-02f, 4.42204066e-02f, -2.80790050e-02f, -2.32964363e-02f,
  2.22959295e-02f, -6.80833030e-03f, -2.72789970e-03f, 6.80894852e-02f, -3.37814055e-02f, -9.51663405e-03f, -6.31007180e-02f, -4.79408354e-02f, -6.06511459e-02f, -1.69295613e-02f,
  1.53350132e-02f, 9.65718478e-02f, -4.86697890e-02f, -2.42923312e-02f, -7.50943273e-02f, -6.00922629e-02f, 8.20507854e-02f, -8.91293958e-02f, 9.80887488e-02f, 4.00536619e-02f,
  -8.09992701e-02f, 3.81148383e-02f, -1.94903821e-01f, -1.62169769e-01f, 4.13711853e-02f, -1.69540405e-01f, -4.48546074e-02f, -3.52875255e-02f, 1.08408872e-02f, 1.00908421e-01f,
  1.33984715e-01f, 2.70536467e-02f, 4.42391261e-03f, -1.84254602e-01f, -2.79949874e-01f, -9.34909377e-03f, -2.05427900e-01f, -1.40560225e-01f, -1.11579329e-01f, 1.01528868e-01f,
  -4.65460047e-02f, -4.74229641e-03f, -1.30833089e-01f, 1.45827740e-01f, 1.25790965e-02f, 3.42059657e-02f, 1.53659672e-01f, 1.10275835e-01f, 5.05116163e-03f, -3.10219489e-02f,
  -1.10274673e-01f, -3.92500535e-02f, -7.93625042e-02f, -3.70940678e-02f, -5.94186932e-02f, -6.23085909e-02f, -1.02591133e-02f, -2.40495447e-02f, -7.94128701e-02f, 3.77034955e-02f,
  -6.87063299e-03f, 6.01515621e-02f, -6.54213428e-02f, 4.28159982e-02f, -6.32704347e-02f, -6.48127049e-02f, -3.41133308e-03f, -5.94194829e-02f, -3.24617065e-02f, -1.05289787e-01f,
  -2.62980144e-02f, -6.23818859e-02f, 3.75252478e-02f, -7.20270425e-02f, -5.65321259e-02f, 5.50537668e-02f, 2.96254568e-02f, -6.60027266e-02f, -2.60492116e-02f, -5.41992523e-02f,
  1.21042896e-02f, 4.64995690e-02f, 5.80892563e-02f, -7.59252608e-02f, 7.87793547e-02f, -8.06067362e-02f, -5.66741601e-02f, 3.28649879e-02f, -1.96847832e-03f, 5.12592159e-02f,
  -3.51781547e-02f, 7.13188723e-02f, -1.48348175e-02f, -6.24978058e-02f, 5.56534417e-02f, 7.63238892e-02f, 3.66524719e-02f, 6.23062663e-02f, -1.06492974e-01f, -1.10990390e-01f,
  -5.06088510e-02f, 4.39001173e-02f, -5.21833189e-02f, -4.83691879e-02f, -6.03726581e-02f, -6.43079504e-02f, -1.08835315e-02f, -3.82932834e-02f, 6.46423772e-02f, 8.81357566e-02f,
  3.31264250e-02f, 1.07440270e-01f, -2.53678747e-02f, 2.47248877e-02f, 4.42164280e-02f, -1.58504788e-02f, -6.94639906e-02f, -6.02986524e-03f, -2.60730516e-02f, -2.87139993e-02f,
  1.55629369e-03f, 7.42235184e-02f, 7.34320935e-03f, 5.11899441e-02f, 8.35128427e-02f, 7.74745718e-02f, -1.98511332e-02f, 6.50621504e-02f, -2.28581112e-02f, 7.15196580e-02f,
  2.52003632e-02f, 1.29692957e-01f, -2.06268504e-02f, 5.94896935e-02f, 5.98480366e-02f, 2.22953577e-02f, -5.28119057e-02f, 3.78693305e-02f, 3.23370323e-02f, -1.22393314e-02f,
  -3.96036178e-01f, 2.98439413e-01f, -5.72367087e-02f, 7.34618399e-03f, -2.12526128e-01f, -1.92698419e-01f, 1.67235415e-02f, -3.46213020e-02f, 1.15688801e-01f, 3.48257571e-01f,
  1.10431440e-01f, 9.76034924e-02f, 2.54642576e-01f, 1.88784778e-01f, -3.54065239e-01f, 1.38860419e-01f, -5.07775657e-02f, 1.44851297e-01f, 3.55523080e-02f, -1.30697042e-01f,
  -1.41971990e-01f, 4.44258526e-02f, -4.65380810e-02f, 7.84386694e-02f, -1.76308900e-01f, -1.25311345e-01f, -1.48841813e-01f, -3.92461941e-02f, 2.25146376e-02f, -4.50402685e-02f,
  -1.86124370e-01f, -1.71474069e-02f, -7.91990012e-02f, -6.14444949e-02f, -8.26056525e-02f, -3.75604406e-02f, -4.54757661e-02f, -8.13104883e-02f, -1.98562387e-02f, 8.37937579e-04f,
  5.23457043e-02f, 4.65409346e-02f, 3.08426153e-02f, 3.57709527e-02f, -7.07382411e-02f, 3.65184015e-03f, -5.33311628e-03f, 5.97101264e-02f, -4.47838493e-02f, -2.82851867e-02f,
  2.32940186e-02f, -3.15226801e-02f, 6.12008646e-02f, -2.21309960e-02f, -1.18610390e-01f, -3.36529836e-02f, -3.32714468e-02f, -1.08190008e-01f, -3.84704471e-02f, -2.64564026e-02f,
  -2.11166050e-02f, -6.64251149e-02f, 3.85735556e-02f, 1.67255774e-02f, 2.39880253e-02f, -3.31715979e-02f, 3.06137744e-02f, -1.35803106e-03f, 2.73886696e-03f, -1.17033925e-02f,
  -7.19300099e-03f, 1.40203945e-02f, 2.32206192e-02f, -5.16993068e-02f, 5.21154702e-02f, 7.71434279e-03f, -1.42182196e-02f, -2.19897591e-02f, -2.49869768e-02f, -1.06039710e-01f,
  7.41137599e-04f, -5.32615222e-02f, 4.69467416e-02f, 1.13514327e-02f, 3.26857902e-02f, -3.15739587e-02f, 4.72397432e-02f, 5.91929145e-02f, -5.09299673e-02f, -4.14351150e-02f,
  -2.80117303e-01f, -1.46580890e-01f, -1.83134489e-02f, 1.77619178e-02f, -7.67978951e-02f, -4.78754677e-02f, -2.68235933e-02f, -3.16845924e-02f, -9.11400095e-02f, 2.08214368e-03f,
  -8.11896324e-02f, -7.58041963e-02f, -1.43285030e-02f, 8.13154206e-02f, -5.10320663e-02f, -7.27525949e-02f, 1.02608567e-02f, -4.26493362e-02f, -5.68950847e-02f, -4.92383353e-02f,
  2.41301619e-02f, 2.52491962e-02f, -2.23136693e-02f, -4.36867028e-03f, 6.73674326e-03f, 4.06608805e-02f, -1.68717559e-02f, 2.42559984e-02f, -8.99593383e-02f, 5.47440872e-02f,
  -1.22357734e-01f, -3.46602388e-02f, 1.81573376e-01f, 3.84608097e-02f, 7.80135691e-02f, -6.88423961e-02f, -1.85662121e-01f, 9.70179439e-02f, -4.83904257e-02f, -1.24768481e-01f,
  -3.03694066e-02f, -9.26735476e-02f, 5.13968840e-02f, -2.92533133e-02f, -1.79553665e-02f, 1.85482274e-03f, 1.94917303e-02f, -1.26643941e-01f, -1.66178029e-02f, -6.79644942e-02f,
  1.60636008e-02f, 3.09449118e-02f, 8.52646306e-02f, 1.50391474e-01f, 5.08995168e-02f, -5.43094352e-02f, -7.00058937e-02f, -3.62105528e-03f, -3.64187658e-02f, 1.29234299e-01f,
  -1.03390209e-01f, -5.29565513e-02f, -2.17476394e-02f, 1.10692494e-01f, 1.75292231e-02f, -8.74523520e-02f, -9.31506380e-02f, -7.21691027e-02f, -3.10741290e-02f, 7.74260387e-02f,
  4.84446697e-02f, 9.71535817e-02f, 8.86545703e-03f, -6.11470006e-02f, -6.70467764e-02f, 4.80405055e-02f, 3.89960408e-02f, -1.06718829e-02f, 2.04131268e-02f, -2.58120745e-02f,
  2.75224471e-03f, -6.86335266e-02f, -6.47002365e-04f, 6.96612801e-03f, -4.69872206e-02f, 1.90771197e-03f, 2.98436973e-02f, 6.83524758e-02f, 3.49067301e-02f, 9.31064561e-02f,
  -3.27405110e-02f, -1.02223583e-01f, 1.61489118e-02f, 7.66028389e-02f, -7.17528462e-02f, -2.88262889e-02f, 7.39743784e-02f, 9.80215520e-03f, -6.95832372e-02f, 4.70990427e-02f,
  6.15564175e-02f, -4.94028581e-03f, 8.25184584e-03f, -1.41722420e-02f, -4.62955870e-02f, 4.63262983e-02f, 7.59626403e-02f, 4.00206521e-02f, -8.11338648e-02f, -9.38777998e-03f,
  -8.35842416e-02f, -5.70815131e-02f, -4.70807254e-02f, -1.58037189e-02f, 5.25225587e-02f, -1.10365041e-02f, -6.36050180e-02f, -2.14365982e-02f, 1.33182229e-02f, -1.09131835e-01f,
  -4.61574756e-02f, -9.15227234e-02f, 8.99829939e-02f, 6.69130683e-02f, 5.81368990e-02f, -1.74606778e-02f, 6.56580031e-02f, -3.80976014e-02f, -7.59335309e-02f, -2.10318901e-02f,
  -1.27352588e-02f, -2.62118271e-03f, -2.22682692e-02f, 1.28646689e-02f, 1.70016419e-02f, -6.21291511e-02f, -1.92996785e-02f, -4.49651107e-02f, -2.67005395e-02f, -4.25733775e-02f,
  -4.55369987e-02f, 2.19074786e-02f, 1.32568022e-02f, 6.41030297e-02f, -9.63523984e-02f, -3.13724130e-02f, 1.60021205e-02f, -7.81049728e-02f, -3.31146196e-02f, 6.91892877e-02f,
  -2.34451815e-01f, 6.28637746e-02f, 1.95170920e-02f, -2.11888447e-01f, 5.25852814e-02f, 2.70938763e-04f, -1.27192393e-01f, 9.82835591e-02f, -1.45034537e-01f, 7.50970840e-02f,
  -2.43518576e-02f, -1.96318865e-01f, -3.08875460e-02f, -1.56152159e-01f, -1.77121729e-01f, -6.09244741e-02f, -2.01832041e-01f, -9.31575671e-02f, -4.17045355e-02f, -2.40756758e-02f,
  8.93387757e-03f, -7.69341588e-02f, -9.39755421e-03f, 1.94865927e-01f, -4.79524396e-02f, 1.34363379e-02f, 1.27879143e-01f, 1.48205400e-01f, -3.35689187e-02f, -3.44415498e-03f,
  -1.12145603e-01f, -1.38644740e-01f, -3.15589644e-02f, -5.09535037e-02f, -2.90888008e-02f, 5.03076576e-02f, 2.17265617e-02f, 7.25961570e-03f, -5.28816208e-02f, 5.80876246e-02f,
  2.83862725e-02f, -4.80309268e-03f, 8.96347500e-03f, 3.55323520e-03f, -1.50468592e-02f, -6.78297132e-02f, -6.40546009e-02f, -2.28518173e-02f, 5.12443483e-02f, -8.13776255e-02f,
  2.40222551e-03f, 6.49535609e-03f, -1.97592303e-02f, 6.04980141e-02f, 5.29273115e-02f, -1.50944265e-02f, -7.03100339e-02f, 5.79748079e-02f, 3.01123057e-02f, -9.89385918e-02f,
  4.42598760e-02f, 7.38842934e-02f, -2.43238993e-02f, 7.77432397e-02f, 4.00418527e-02f, 2.59454898e-03f, 8.47921371e-02f, 6.21497221e-02f, 2.97267847e-02f, 7.64221847e-02f,
  -7.13610724e-02f, 6.50114194e-02f, 5.77978380e-02f, 5.89612289e-04f, -1.00059606e-01f, 4.01959941e-02f, -6.89017996e-02f, -3.73237021e-02f, 3.21622863e-02f, -5.90625070e-02f,
  6.80901781e-02f, -4.14235219e-02f, -5.80817312e-02f, 5.43651171e-02f, 4.81281132e-02f, -6.51234463e-02f, -8.32858961e-03f, 2.19479669e-02f, 2.21714228e-02f, 3.64367403e-02f,
  8.19967315e-03f, -9.84598845e-02f, -4.20884080e-02f, -2.53049731e-02f, -7.55644590e-02f, 5.39073944e-02f, -3.75745520e-02f, 5.92168905e-02f, 2.16357894e-02f, -2.99282931e-02f,
  1.14367142e-01f, 1.03303850e-01f, 5.22315800e-02f, -5.40304221e-02f, -7.18497187e-02f, -1.79699995e-02f, -5.83242066e-02f, 5.11320680e-02f, 4.04721797e-02f, -4.87916172e-02f,
  3.47596593e-02f, -3.12798545e-02f, -5.92503734e-02f, 5.85504882e-02f, 3.61852273e-02f, -7.04914704e-03f, 5.70998155e-02f, -4.71372642e-02f, 1.14029273e-02f, -7.83786103e-02f,
  6.46078736e-02f, -5.24369478e-02f, -1.59139819e-02f, 3.58862206e-02f, 1.69291377e-01f, 6.85211048e-02f, 3.61024514e-02f, 7.20595289e-03f, 1.51491404e-01f, -2.02049434e-01f,
  -1.02798983e-01f, -2.10902900e-01f, -1.78759784e-01f, -4.80138734e-02f, -9.34475735e-02f, -1.88305736e-01f, 3.89761962e-02f, -1.14754967e-01f, 3.50804031e-02f, -6.03260584e-02f,
  8.16155374e-02f, 4.87336740e-02f, 7.51111656e-02f, 3.43210995e-02f, -7.45815784e-02f, 1.38972506e-01f, 1.80565864e-02f, -4.40241992e-02f, -8.85991100e-03f, 6.03551231e-02f,
  5.73803810e-03f, -4.39684987e-02f, 7.38639850e-03f, 5.18439710e-02f, 1.14250612e-02f, 8.29245448e-02f, -2.12326609e-02f, -6.04702905e-02f, -1.20152952e-02f, 5.98707572e-02f,
  6.24870323e-02f, -4.85979095e-02f, -4.85630110e-02f, -7.04215989e-02f, 3.49637941e-02f, -1.00580100e-02f, 4.61638756e-02f, 1.10315315e-01f, -1.97010897e-02f, -7.18659088e-02f,
  -4.66500632e-02f, 3.85869294e-02f, 9.57081318e-02f, -8.98537934e-02f, 4.87998985e-02f, -2.97036152e-02f, -6.96365908e-02f, -8.25860500e-02f, 2.74273548e-02f, 6.33466691e-02f,
  6.26710132e-02f, 5.94086573e-02f, 3.30572203e-02f, -2.44590119e-02f, -1.00919038e-01f, 6.74128458e-02f, 3.46166193e-02f, 1.22723114e-02f, -3.05135921e-02f, 6.90446980e-03f,
  -1.51992287e-03f, -1.92662384e-02f, -5.38444407e-02f, -2.38222890e-02f, -3.93622592e-02f, -4.40547336e-03f, 3.02597824e-02f, -1.16156757e-01f, -3.04008722e-02f, 7.93247148e-02f,
  -1.44972540e-02f, 2.80890800e-02f, -5.30674718e-02f, -4.08073850e-02f, -2.78154761e-02f, 8.87195915e-02f, -7.84547329e-02f, 4.80975807e-02f, 7.23049566e-02f, -5.32031395e-02f,
  8.95981416e-02f, -7.39695430e-02f, 2.96711810e-02f, 7.83473849e-02f, -4.44670431e-02f, -1.00339204e-01f, -1.08685188e-01f, -1.43482732e-02f, -3.29665318e-02f, -2.05477141e-02f,
  1.07962534e-01f, 7.33567551e-02f, -1.04485109e-01f, 7.46098235e-02f, 1.00575956e-02f, 4.52489667e-02f, 2.56155524e-02f, 7.55261481e-02f, 1.78029239e-02f, -1.19852042e-02f,
  4.35010828e-02f, 3.97624113e-02f, 3.24830636e-02f, 1.83343180e-02f, 4.41781282e-02f, 6.00574948e-02f, -8.20854008e-02f, 4.85219061e-02f, -4.90618013e-02f, 2.72251703e-02f,
  -1.75577700e-02f, 1.68927297e-01f, -6.03680685e-02f, -2.21897196e-02f, -2.85090320e-02f, -1.98350325e-01f, -4.07222733e-02f, 5.31515367e-02f, -1.29502164e-02f, 1.55166909e-01f,
  2.62810942e-03f, 1.70164138e-01f, 2.49769501e-02f, 8.15676823e-02f, -9.14818719e-02f, -9.44520999e-03f, -1.33132190e-01f, -8.53310805e-03f, 7.31639713e-02f, 3.96484286e-02f,
  -5.20650344e-03f, 2.48771105e-02f, 1.12107918e-02f, -1.84166376e-02f, -1.19236730e-01f, 1.90185234e-02f, 1.61054190e-02f, 1.03239641e-02f, -6.34541288e-02f, 1.15407361e-02f,
  -1.13566779e-03f, -1.24103285e-01f, 9.86667001e-05f, 8.20152238e-02f, 1.88669097e-03f, 4.35405225e-02f, 2.39233971e-02f, -1.53517975e-02f, 2.46910588e-03f, 2.96241287e-02f,
  -1.09219062e-03f, 5.73015288e-02f, 4.55931481e-03f, 2.62017921e-02f, -6.87921122e-02f, 3.05348355e-02f, -8.68364275e-02f, 4.99584600e-02f, 2.00311076e-02f, 8.61529931e-02f,
  8.66216272e-02f, 7.65829310e-02f, -9.27214175e-02f, -3.11632119e-02f, -1.29435202e-02f, -5.16224056e-02f, 1.01968721e-02f, 3.29905376e-02f, 6.34970218e-02f, -2.89437380e-02f,
  -5.20759262e-02f, 7.26382583e-02f, -5.14725223e-03f, -5.79785518e-02f, 1.19916454e-03f, 1.54800732e-02f, 8.41830112e-03f, 4.04607877e-02f, -3.16743106e-02f, -8.10773447e-02f,
  -6.29660860e-02f, -8.53880681e-03f, 5.70343770e-02f, 1.23144966e-02f, -3.27475369e-02f, 7.22171068e-02f, 6.79322258e-02f, 8.73730239e-03f, -6.18528649e-02f, -7.20294118e-02f,
  2.06418410e-02f, -8.30584913e-02f, -1.00549180e-02f, -8.19459558e-02f, 7.65373781e-02f, -1.43260714e-02f, 5.46889566e-02f, -7.14838952e-02f, 1.01109482e-01f, -3.93735394e-02f,
  -5.47605939e-02f, -1.46754369e-01f, 1.55089861e-02f, 4.41557243e-02f, 5.23167327e-02f, -9.78919342e-02f, -5.18519320e-02f, -2.92768958e-03f, -9.50800478e-02f, -8.69932473e-02f,
  -4.72209416e-02f, -3.44629213e-02f, 4.86559942e-02f, 8.71023089e-02f, 3.51396240e-02f, 5.72869480e-02f, -7.61499479e-02f, -7.30804540e-03f, -7.50580505e-02f, -5.40399477e-02f,
  1.54889496e-02f, -1.57320611e-02f, 2.90345717e-02f, -5.67054190e-02f, 1.84894148e-02f, 1.30220046e-02f, -1.54387923e-02f, 2.28294022e-02f, 9.90523305e-03f, 4.45782728e-02f,
  -7.65382126e-02f, 1.43530086e-01f, -1.57837421e-01f, 4.78037000e-02f, -7.37785921e-02f, 5.40444665e-02f, 1.02638908e-01f, 1.24032445e-01f, 1.07418723e-01f, 7.89905638e-02f,
  1.04793631e-01f, 5.48070669e-02f, 2.52043083e-02f, 9.93871987e-02f, 8.98002312e-02f, -2.70191435e-04f, 2.16677010e-01f, -2.58820821e-02f, -7.16782436e-02f, 1.78450450e-01f,
  -3.57460827e-02f, 1.27111763e-01f, 4.15742137e-02f, -7.62048829e-03f, 4.40998981e-03f, 2.21852232e-02f, 1.02327965e-01f, -1.38613686e-01f, 9.57596973e-02f, -5.15596978e-02f,
  -1.21836022e-01f, 9.02602822e-02f, -1.06367327e-01f, -2.14514863e-02f, 3.03712562e-02f, 4.41654995e-02f, -8.43020976e-02f, 3.59351025e-03f, 3.13168168e-02f, 4.88922410e-02f,
  2.34982632e-02f, 7.57687241e-02f, 1.00629032e-01f, -8.41863826e-02f, -8.45868140e-03f, -1.07489964e-02f, -5.08060381e-02f, 1.52534125e-02f, -6.99815303e-02f, 2.14362238e-02f,
  -2.88183223e-02f, 8.57452303e-02f, 6.66389763e-02f, -5.34795523e-02f, -1.96154267e-02f, 5.52009828e-02f, -4.56825830e-02f, -6.70116171e-02f, -4.23772968e-02f, 3.19930203e-02f,
  6.27385303e-02f, 4.92224982e-03f, -4.20716070e-02f, -1.15600251e-01f, 1.07086850e-02f, -2.88352519e-02f, 7.40488321e-02f, -3.22375372e-02f, 7.98625872e-02f, 8.29546079e-02f,
  -3.76681201e-02f, -4.96848077e-02f, -5.06611131e-02f, 4.23453413e-02f, 6.72145858e-02f, 4.04823273e-02f, 4.20121998e-02f, 1.69229705e-03f, -9.38474759e-02f, -2.00817883e-02f,
  4.57109790e-03f, 1.28025459e-02f, -5.94790420e-03f, 2.98755169e-02f, -9.31434780e-02f, -3.70257311e-02f, -3.53726037e-02f, 5.29682823e-02f, -8.15119967e-02f, 1.02080286e-01f,
  1.73894748e-01f, 2.54363716e-01f, 6.90672845e-02f, 3.94992121e-02f, 7.06274882e-02f, -8.31581093e-03f, -1.10019473e-02f, -3.01028453e-02f, 6.09943084e-02f, -1.51499519e-02f,
  1.06823467e-01f, 2.28671767e-02f, 2.07864232e-02f, 1.76810361e-02f, 2.16821749e-02f, 1.41193286e-01f, 6.86577037e-02f, 3.34700271e-02f, 1.06070131e-01f, 4.74249311e-02f,
  3.56716141e-02f, -4.23389971e-02f, -5.13649061e-02f, -4.73349877e-02f, 1.15814187e-01f, 1.98125113e-02f, 1.01607911e-01f, -3.49038765e-02f, 6.96949437e-02f, 6.08999059e-02f,
  -4.45719883e-02f, -5.00750281e-02f, -1.11779645e-02f, -3.51325981e-02f, -9.90778133e-02f, 6.81584701e-02f, -1.38877044e-02f, -3.89324725e-02f, 1.76445059e-02f, 7.26915374e-02f,
  -5.09141237e-02f, 4.12390716e-02f, 4.67255199e-03f, 1.37557322e-02f, 2.43674517e-02f, 5.57560362e-02f, 2.84456322e-03f, 6.25941157e-02f, 7.70207867e-02f, -3.00257616e-02f,
  -8.27166215e-02f, 8.34359005e-02f, -6.16169088e-02f, -5.22580706e-02f, 1.74039211e-02f, -1.18487231e-01f, -4.33752835e-02f, 5.33087440e-02f, 5.89005128e-02f, 2.11035889e-02f,
  -3.37134451e-02f, 6.07038066e-02f, 4.74731326e-02f, -2.97361612e-02f, -3.74125503e-02f, -2.49902159e-02f, 8.41075331e-02f, -7.22324625e-02f, 1.52613753e-02f, -4.07913961e-02f,
  -3.61118577e-02f, -1.76711399e-02f, 1.94317065e-02f, -7.25163594e-02f, -3.30859646e-02f, -4.01925668e-02f, -6.37761950e-02f, -4.20629941e-02f, -3.91637832e-02f, -8.37777928e-02f,
  9.40139778e-03f, -5.68421260e-02f, 2.71647628e-02f, -3.19031673e-03f, -7.05022886e-02f, 3.49045917e-02f, -6.29057512e-02f, -6.91185668e-02f, 4.70886454e-02f, 2.56856028e-02f,
  4.65353206e-02f, -7.18547106e-02f, 7.25772381e-02f, -2.14163940e-02f, -5.23598604e-02f, 5.05024977e-02f, 4.75522354e-02f, 4.90681231e-02f, -3.63301598e-02f, 6.72410522e-03f,
  -1.43680803e-03f, -6.09361306e-02f, -4.22644205e-02f, 7.43059963e-02f, -8.02400634e-02f, 7.16725513e-02f, -8.26869309e-02f, 6.77520633e-02f, -4.33190688e-02f, -6.99623600e-02f,
  -5.22779711e-02f, -6.85392022e-02f, 9.78227332e-02f, -7.97334779e-03f, -6.29279763e-02f, -5.59968092e-02f, 6.41460344e-03f, -5.39209023e-02f, -4.06694785e-02f, 3.61060500e-02f,
  -4.08198163e-02f, -8.70624930e-02f, -3.32448669e-02f, -6.94303587e-02f, 6.80140331e-02f, 3.05983014e-02f, -7.24009424e-02f, 1.93189066e-02f, 9.10426676e-02f, -1.01177786e-02f,
  -7.52874315e-02f, 3.39690112e-02f, -9.13680643e-02f, -3.92045565e-02f, -8.19446295e-02f, -1.89009514e-02f, 6.60825595e-02f, -5.07463105e-02f, -3.57744657e-02f, -9.78158787e-03f,
  -8.72751996e-02f, -3.53164189e-02f, 2.58053150e-02f, 1.41462106e-02f, -6.54527768e-02f, 8.92032031e-03f, -8.96373615e-02f, 4.92151156e-02f, 1.56568587e-02f, -1.43512301e-02f,
  7.13824630e-02f, -3.06036532e-01f, 2.47310296e-01f, 1.22312367e-01f, 3.07617545e-01f, 2.35652819e-01f, 2.14969531e-01f, 6.94821924e-02f, 1.91218883e-01f, -3.29901487e-01f,
  -8.50384608e-02f, -1.55831352e-01f, 5.79690784e-02f, -1.22726031e-01f, 1.31920457e-01f, 7.65807852e-02f, 6.37012497e-02f, 1.03306361e-02f, 1.55744344e-01f, -9.33930685e-04f,
  4.89336587e-02f, -6.36593252e-02f, 8.78272858e-03f, -6.78425655e-02f, -4.09343168e-02f, -7.88665041e-02f, -2.08025694e-01f, 4.21700589e-02f, -2.19305933e-01f, 4.67931330e-02f,
  -4.51718532e-02f, -3.04926373e-02f, 7.45742349e-03f, 4.00793850e-02f, 4.76333266e-03f, -2.51903236e-02f, 1.05977226e-02f, -1.87197328e-02f, 7.03417286e-02f, 8.61003250e-02f,
  -1.35964304e-01f, -6.65360987e-02f, -3.87286618e-02f, 1.09071089e-02f, 3.35543901e-02f, -4.09491137e-02f, 3.59443240e-02f, -1.99582474e-03f, -2.96035619e-03f, 7.34345689e-02f,
  4.56695929e-02f, -4.24603038e-02f, -1.46557139e-02f, -7.29747340e-02f, -1.34280026e-02f, -6.48763031e-02f, -2.97507532e-02f, -4.40082923e-02f, -7.08529651e-02f, -1.59544535e-02f,
  1.06782280e-02f, 2.91931871e-02f, -1.46217477e-02f, -4.62571532e-02f, -3.12494561e-02f, -9.23068321e-04f, -3.86439189e-02f, 2.68825423e-03f, -6.18766807e-02f, 4.36568196e-04f,
  4.20023054e-02f, -3.89704406e-02f, 1.22981504e-01f, 2.70864982e-02f, -7.99755286e-03f, 4.41553630e-02f, 3.24722938e-02f, -5.54075651e-02f, -2.68666446e-02f, 5.38119562e-02f,
  5.40979616e-02f, -3.19705084e-02f, 3.29212919e-02f, -4.19844501e-02f, 2.23471969e-02f, -4.65011597e-02f, -2.19829194e-02f, -6.78027272e-02f, 6.00914061e-02f, 2.00189259e-02f,
  -1.11048281e-01f, -2.00296015e-01f, 2.01225001e-02f, -4.14024182e-02f, -7.17096180e-02f, -7.45444745e-02f, 3.17184627e-02f, -2.61298269e-02f, -1.12775810e-01f, -4.22980543e-03f,
  5.08397073e-02f, -4.96223047e-02f, -5.46923354e-02f, -5.05661704e-02f, 2.80290693e-02f, 2.86410917e-02f, -1.17877731e-02f, -5.00256941e-02f, -3.74337025e-02f, -6.55248761e-02f,
  2.99049672e-02f, -1.77240707e-02f, 1.08538093e-02f, 1.96806923e-03f, -6.31204993e-02f, 2.83355955e-02f, -4.46956083e-02f, 4.34597731e-02f, -6.31821901e-02f, -9.28214937e-02f,
  8.19248408e-02f, -5.25286384e-02f, -1.88772991e-01f, -4.76107188e-02f, 1.10180892e-01f, 1.21216089e-01f, 2.00871695e-02f, 4.44565341e-02f, -7.78751373e-02f, -3.16774361e-02f,
  -3.19354683e-02f, 4.76244763e-02f, -1.82338938e-01f, -3.83221433e-02f, 4.59893644e-02f, -1.98164061e-01f, 1.40053509e-02f, -4.07215655e-02f, -1.53333517e-02f, -2.66928710e-02f,
  -4.72856872e-02f, 1.31271467e-01f, 1.99044608e-02f, 1.33023849e-02f, 1.54658616e-01f, 9.73416865e-02f, 4.93345521e-02f, 9.63823404e-03f, 7.33306780e-02f, 9.38114822e-02f,
  -3.87366712e-02f, -5.94432652e-02f, 4.29849960e-02f, 2.54092421e-02f, 1.33278929e-02f, -6.62836358e-02f, 8.97468105e-02f, -5.68926893e-02f, 8.72770175e-02f, -2.64562517e-02f,
  -2.88759032e-03f, 7.31728747e-02f, 1.77930128e-02f, -8.34496915e-02f, 9.76728462e-03f, 3.71494778e-02f, -6.69379383e-02f, -4.98451702e-02f, -3.97421680e-02f, 4.95011993e-02f,
  -5.53955734e-02f, 7.39936382e-02f, -6.87516481e-02f, 4.57282849e-02f, -6.27740324e-02f, 7.02205673e-02f, -3.76427849e-03f, 8.28658789e-02f, -4.42345105e-02f, 9.35752168e-02f,
  -1.26431491e-02f, 5.89530952e-02f, -1.32270027e-02f, 2.05254983e-02f, -6.10851124e-02f, -2.32715551e-02f, -7.69928470e-02f, 5.63968644e-02f, -2.19649021e-02f, 4.30726856e-02f,
  1.40025523e-02f, -4.57428321e-02f, 6.31312877e-02f, 2.17319857e-02f, -5.97285852e-02f, 9.22013521e-02f, 6.58791214e-02f, -4.30901051e-02f, -7.22241029e-02f, 3.70409712e-02f,
  -2.74367407e-02f, 4.67008911e-02f, 8.78775492e-02f, 7.19185397e-02f, -3.42404060e-02f, -1.06250290e-02f, -9.68155637e-02f, -4.93293107e-02f, -5.61397299e-02f, 8.43281522e-02f,
  -6.97658882e-02f, -2.09709071e-02f, -6.08139820e-02f, -3.08500398e-02f, 8.46812502e-02f, 7.48785511e-02f, 3.87165956e-02f, -1.23775499e-02f, 4.17869724e-02f, 6.74539432e-02f,
  -1.54445581e-02f, -3.55212726e-02f, 8.97495374e-02f, -4.66449857e-02f, 4.72050905e-03f, 5.77213280e-02f, -4.91502210e-02f, 3.23659144e-02f, -2.12756731e-02f, 5.23640700e-02f,
  -1.85229108e-02f, -4.00770567e-02f, -2.78241169e-02f, -8.46263319e-02f, -5.43354340e-02f, 7.58006200e-02f, 3.31982151e-02f, 3.67709883e-02f, 2.23461539e-02f, -4.33617868e-02f,
  2.53025234e-01f, -1.90640073e-02f, -1.49525136e-01f, -8.58836547e-02f, 1.85117573e-02f, -1.60346050e-02f, -1.82408676e-01f, -8.70698988e-02f, -1.04825348e-01f, -7.01701492e-02f,
  1.31397182e-02f, 1.31243736e-01f, -1.64484009e-01f, 1.18290946e-01f, 1.30445912e-01f, -1.00943364e-01f, -2.47512059e-03f, 4.84059528e-02f, 4.63455617e-02f, 8.74213353e-02f,
  7.27375504e-03f, 1.42623231e-01f, -1.29649937e-01f, 1.34428650e-01f, 1.64799035e-01f, -6.19663745e-02f, 1.60286427e-01f, -4.66709286e-02f, 2.07754478e-01f, 6.44981265e-02f,
  2.75876392e-02f, 2.49931794e-02f, 2.25609820e-02f, 1.13542816e-02f, -1.19913347e-01f, 6.85912892e-02f, 9.64354426e-02f, -2.95674801e-02f, -4.71854992e-02f, -7.31846243e-02f,
  4.10817116e-02f, -4.38495632e-03f, 8.08810964e-02f, 6.59061149e-02f, 4.56385314e-03f, 4.42494228e-02f, -2.93900538e-02f, -1.26866288e-02f, 4.44111712e-02f, -2.03089453e-02f,
  -1.83879435e-02f, 2.68546361e-02f, 2.30736323e-02f, 5.02413996e-02f, -5.51242977e-02f, 4.89233546e-02f, -4.96696085e-02f, -3.13968509e-02f, 7.81781152e-02f, 1.05026430e-02f,
  7.85663798e-02f, 1.11240886e-01f, 4.29768376e-02f, -4.95820381e-02f, -3.07471119e-03f, 3.22808325e-02f, 8.78147036e-02f, -7.28859454e-02f, 7.00752810e-02f, -6.37140200e-02f,
  2.03205217e-02f, -7.02861398e-02f, 1.15187408e-03f, -5.35703562e-02f, 6.20742925e-02f, 6.45153364e-03f, 1.29644237e-02f, 6.20717555e-02f, -1.29991099e-01f, 6.65993197e-03f,
  6.06474690e-02f, 2.61949818e-03f, -2.74681393e-02f, 7.65877590e-02f, -8.02421793e-02f, -7.80663565e-02f, -2.40541119e-02f, 2.07552779e-03f, -1.94270555e-02f, -3.04116532e-02f,
  -3.69011890e-04f, -9.37377661e-02f, -3.31272632e-02f, 2.78453552e-03f, 3.52686807e-03f, 9.38464422e-03f, -5.08904867e-02f, 7.04640523e-02f, -6.11924417e-02f, -1.18032731e-02f,
  -2.39015259e-02f, -3.79539393e-02f, 6.36636838e-02f, 1.03804441e-02f, -6.79398254e-02f, -4.29235362e-02f, 7.69254565e-02f, 2.29688380e-02f, -6.67026592e-03f, -4.00141208e-03f,
  3.01411953e-02f, -7.69004971e-02f, -2.53232121e-02f, 1.17627885e-02f, 3.67731489e-02f, 1.02409624e-01f, -4.77831140e-02f, 9.34615880e-02f, 4.70737442e-02f, -4.99667600e-02f,
  -1.98211968e-01f, 2.04523951e-01f, 4.29909490e-02f, -2.37491950e-01f, -6.00315854e-02f, 1.64944246e-01f, 3.91960852e-02f, 1.79309640e-02f, -5.22377715e-02f, -1.21358130e-02f,
  -1.07704513e-01f, 1.12577630e-02f, 1.29331410e-01f, -1.99459251e-02f, 7.38373846e-02f, 1.86908633e-01f, -3.21694538e-02f, -7.18018860e-02f, 6.01621084e-02f, -7.77271241e-02f,
  -9.85412598e-02f, -8.88869911e-02f, -1.33918673e-02f, -1.65154152e-02f, -5.12235872e-02f, -4.11280952e-02f, -1.57896906e-01f, 7.29770958e-02f, -1.42607167e-01f, -6.48715720e-02f,
  -9.03102532e-02f, -1.92827567e-01f, -1.35173991e-01f, -8.20392072e-02f, 1.32005988e-02f, -8.44499543e-02f, -6.77636862e-02f, -3.28064971e-02f, -1.67064220e-02f, 4.92031015e-02f,
  -9.27090272e-02f, 4.44251709e-02f, 1.96833275e-02f, 3.19280103e-02f, -4.71500307e-02f, 7.29688257e-02f, 6.53463528e-02f, -4.72967289e-02f, -7.86557868e-02f, 9.69954282e-02f,
  1.03505617e-02f, 7.38211572e-02f, -9.88145173e-02f, 3.02601233e-03f, -8.51015076e-02f, 5.48390932e-02f, -1.34656224e-02f, -2.17674542e-02f, -1.00924321e-01f, -3.83081324e-02f,
  8.21134448e-02f, -8.44680816e-02f, 8.09624866e-02f, 3.42130028e-02f, 6.09032176e-02f, 2.33585555e-02f, 6.81444034e-02f, 1.10524287e-02f, 7.74781182e-02f, -1.51050184e-02f,
  -7.72503689e-02f, -1.20490253e-01f, -4.78145257e-02f, -9.37725790e-03f, 3.16439867e-02f, 6.61718622e-02f, -3.49871628e-02f, -7.14788288e-02f, 6.97906315e-02f, -3.30869388e-03f,
  2.32792012e-02f, 3.77332233e-02f, 6.11760691e-02f, -2.77396329e-02f, -5.75008355e-02f, 1.83887295e-02f, -8.39664489e-02f, -2.27456279e-02f, 6.55741245e-02f, -4.82613742e-02f,
  -1.04343601e-01f, -1.16302617e-01f, -6.82415888e-02f, 2.37379000e-02f, 4.41041999e-02f, -7.07125440e-02f, 2.37613712e-02f, 1.63696464e-02f, -4.94006835e-02f, -7.65316337e-02f,
  1.27765965e-02f, -7.39343762e-02f, -6.53933436e-02f, -6.17646575e-02f, 6.19781576e-02f, -1.57764517e-02f, -2.11754479e-02f, -1.89283155e-02f, 1.13820489e-02f, 5.66034168e-02f,
  -1.36667769e-02f, -9.02721137e-02f, 3.74470763e-02f, -5.72026111e-02f, -9.78769287e-02f, 4.21528779e-02f, 1.02857798e-02f, -1.22556770e-02f, 6.55807406e-02f, -4.57127839e-02f,
  -3.45398560e-02f, 8.17565154e-03f, 2.83738952e-02f, 9.60701481e-02f, 2.45586708e-02f, 2.30222344e-02f, -6.37911260e-02f, -2.23590881e-02f, -7.66805708e-02f, -1.99987553e-02f,
  -3.10477316e-02f, -9.32418704e-02f, 2.61661913e-02f, -4.74599637e-02f, -1.46838814e-01f, -7.76023790e-02f, -1.58116102e-01f, -1.39126256e-02f, -1.03937062e-02f, 2.36587264e-02f,
  -9.89088640e-02f, 3.54207680e-02f, 9.75964684e-03f, 9.14795324e-02f, -6.61480874e-02f, 7.39928409e-02f, 1.11384653e-01f, 4.07779105e-02f, 9.38600823e-02f, 4.40394618e-02f,
  5.42914234e-02f, 4.09089699e-02f, 2.93125957e-03f, -7.26669505e-02f, -7.26969838e-02f, -2.33533364e-02f, 8.17543939e-02f, 9.53188017e-02f, 2.81762611e-02f, 6.31869063e-02f,
  -3.29650678e-02f, -4.02440913e-02f, 3.36933732e-02f, 8.11625347e-02f, 3.23481597e-02f, 1.71502940e-02f, 5.01621701e-02f, -5.34048118e-03f, 6.55263737e-02f, -3.28021012e-02f,
  -1.00082748e-01f, 1.84184369e-02f, 2.82777287e-02f, -1.57862518e-03f, 9.01279077e-02f, -1.93998974e-03f, -1.09488461e-02f, -5.22178002e-02f, -7.90840313e-02f, 6.35137931e-02f,
  -1.68856028e-02f, -7.41648152e-02f, -6.82743788e-02f, -8.07456523e-02f, -9.79879498e-02f, 3.83269936e-02f, -1.26272012e-02f, -2.12560333e-02f, -2.59432252e-02f, -1.21923927e-02f,
  1.52638750e-02f, -2.31231656e-02f, -6.80459365e-02f, 3.97275463e-02f, 2.40162164e-02f, -7.12344497e-02f, -4.23911400e-02f, -4.17456366e-02f, 2.53623631e-02f, -9.70521383e-03f,
  -9.14144516e-03f, 1.73849110e-02f, 6.07682727e-02f, -5.63120330e-03f, 2.26030331e-02f, -4.69746701e-02f, 2.85096914e-02f, 4.55349777e-03f, 1.35284504e-02f, 5.86096570e-02f,
  -4.05531973e-02f, 4.41862233e-02f, 1.32021885e-02f, 3.79718877e-02f, 4.70128581e-02f, 4.42875549e-02f, -9.46065690e-03f, -1.06381379e-01f, 6.54367208e-02f, -5.43404818e-02f,
  -5.80934286e-02f, 5.82145751e-02f, -8.91492143e-02f, -3.77385616e-02f, 8.91185477e-02f, -1.88573748e-02f, 3.70550230e-02f, -5.00394814e-02f, 1.13297999e-02f, -5.42730018e-02f,
  9.68409330e-02f, -2.14372370e-02f, -1.82335079e-02f, 3.42337824e-02f, -5.17878868e-02f, -2.93095950e-02f, 4.34449203e-02f, -1.43905180e-02f, -7.64963450e-03f, -3.99743505e-02f,
  2.14297459e-01f, 9.22057331e-02f, 7.47643560e-02f, 2.51222819e-01f, -2.10572463e-02f, -1.21228971e-01f, -1.29668564e-01f, 6.15181448e-03f, 8.17832258e-03f, 3.65279219e-03f,
  9.48060602e-02f, -8.06899834e-03f, -2.04378247e-01f, 5.38058393e-02f, 1.01722889e-01f, -7.75724426e-02f, 2.47799531e-02f, 8.81515294e-02f, -7.37288818e-02f, 8.64960700e-02f,
  1.62194043e-01f, 1.08055867e-01f, 1.09788179e-01f, 3.50639969e-02f, 1.96810573e-01f, 1.19132474e-01f, -4.65314873e-02f, -1.36489451e-01f, 1.25079677e-01f, -3.04851029e-03f,
  1.70866530e-02f, 4.84794304e-02f, -1.89057663e-02f, 5.65951988e-02f, -3.74927931e-02f, 3.62676866e-02f, 6.33022264e-02f, -4.64704446e-02f, 6.94010854e-02f, -4.45372351e-02f,
  -7.99420848e-02f, 4.29479480e-02f, -8.37707147e-03f, -7.51674026e-02f, 6.45598397e-02f, 7.15265200e-02f, -1.82040371e-02f, -8.14971030e-02f, -5.06362617e-02f, 9.13012996e-02f,
  8.81891474e-02f, -7.61279315e-02f, 1.70685109e-02f, -5.16905710e-02f, 1.56907812e-02f, 4.10661437e-02f, 3.43808308e-02f, -3.44868861e-02f, 8.19182023e-03f, 8.97543281e-02f,
  5.50247282e-02f, -5.91922998e-02f, 5.74444234e-02f, 6.75590485e-02f, 7.53729045e-02f, 2.38663722e-02f, -6.17100894e-02f, 1.63226835e-02f, -6.84434325e-02f, -6.56713219e-03f,
  -2.26275083e-02f, 2.87565030e-02f, -1.47045627e-02f, -7.24904332e-03f, 7.49539025e-03f, 6.54336661e-02f, 5.23761176e-02f, 5.25911786e-02f, -2.91193612e-02f, 7.54890665e-02f,
  -7.99098518e-03f, 2.01245327e-03f, -8.25713649e-02f, 1.98736228e-02f, -6.09102135e-04f, -2.96571609e-02f, 8.53596181e-02f, 2.39863843e-02f, 7.97201097e-02f, 4.73577715e-02f,
  -5.10549732e-02f, 4.54801917e-02f, 2.14706194e-02f, -2.52240095e-02f, -6.16184808e-02f, -4.41996660e-03f, 7.73476362e-02f, 1.66679621e-02f, 3.94174680e-02f, 6.66607767e-02f,
  3.10462024e-02f, -1.18259573e-02f, 9.42859333e-03f, 8.05502012e-02f, -4.06413898e-03f, 7.16130808e-02f, 2.13864651e-02f, 6.03411533e-02f, 4.13427455e-03f, -2.63776910e-02f,
  -5.38033573e-03f, -8.57730508e-02f, -3.06505989e-02f, -4.47144220e-03f, 8.58712271e-02f, -5.55758215e-02f, 1.63847804e-02f, 9.37389024e-03f, -3.95175740e-02f, 7.95282517e-03f,
  1.00113809e-01f, -2.94425547e-01f, -1.06422707e-01f, 2.34788209e-02f, 9.13885161e-02f, 1.68376058e-01f, 4.69828472e-02f, -1.29697964e-01f, -1.20833576e-01f, -1.22598112e-01f,
  1.05921105e-01f, -5.32213338e-02f, -3.02032027e-02f, -6.81516062e-03f, -3.96673195e-03f, -1.78106099e-01f, -8.33933987e-03f, 1.49382064e-02f, -8.18029791e-02f, 7.15698004e-02f,
  -8.12210236e-03f, -9.76201147e-03f, -1.13405392e-01f, 5.52974977e-02f, 7.88320005e-02f, -3.53585109e-02f, 7.23812804e-02f, 3.88149247e-02f, 2.95195337e-02f, 1.31201833e-01f,
  -6.79607829e-03f, -1.13589384e-01f, 8.40879232e-03f, 1.02389716e-02f, 3.92385311e-02f, 6.46150634e-02f, 3.88948852e-03f, 2.51140725e-02f, 8.15281123e-02f, -1.47249848e-02f,
  3.41778882e-02f, 2.04239953e-02f, -1.12791628e-01f, -5.52451275e-02f, -4.53686044e-02f, -5.77950627e-02f, 5.28511219e-02f, -5.63630089e-02f, -1.29433367e-02f, -4.68028933e-02f,
  -1.01115048e-01f, -6.72759069e-03f, -2.56695529e-03f, -3.08451541e-02f, -6.42458051e-02f, 6.28079623e-02f, -3.18716560e-03f, 8.69310945e-02f, -4.22437638e-02f, 1.42318122e-02f,
  1.83550753e-02f, 5.54417558e-02f, -8.18639472e-02f, -1.11161672e-01f, 8.73333961e-02f, 1.25349285e-02f, -4.35968861e-02f, -7.31082037e-02f, 3.06971725e-02f, 6.04776926e-02f,
  4.40639593e-02f, 7.46221766e-02f, 3.73797454e-02f, 4.47386317e-02f, 4.28004861e-02f, -5.42400591e-02f, -1.36635378e-02f, -4.92254905e-02f, 3.10780457e-03f, -9.32213962e-02f,
  -6.95269555e-02f, -2.21277308e-02f, 7.44371191e-02f, 5.66891544e-02f, 1.14590926e-02f, 5.42777255e-02f, 7.32986480e-02f, -7.83610791e-02f, -2.64887102e-02f, 3.36584821e-02f,
  -4.51665036e-02f, -1.16228402e-01f, -8.68973434e-02f, 6.34381026e-02f, 3.13648395e-02f, 7.45505318e-02f, -2.09710412e-02f, 4.92380001e-03f, -5.53031005e-02f, -6.04856424e-02f,
  1.10149674e-01f, -2.65129805e-02f, 6.84828311e-02f, -7.08961487e-02f, -1.80581268e-02f, -6.51419684e-02f, 2.75831707e-02f, 2.36647706e-02f, 3.82524580e-02f, -2.22534258e-02f,
  2.64178216e-02f, -2.19021887e-02f, -7.14503741e-03f, -4.80834357e-02f, -2.20465045e-02f, 1.73066556e-02f, 2.67990883e-02f, 2.76826993e-02f, 6.87714517e-02f, -6.24345392e-02f,
  -7.47632459e-02f, -4.32117097e-02f, -1.53086772e-02f, -1.55820195e-02f, 1.18866168e-01f, 1.34612322e-01f, 1.83239758e-01f, 5.57075478e-02f, 1.42938733e-01f, 4.12229598e-02f,
  1.62058212e-02f, 7.72651955e-02f, 5.92021756e-02f, -1.84518415e-02f, 7.71080256e-02f, 3.63607816e-02f, 7.09639713e-02f, 1.17822334e-01f, 4.57333028e-02f, 1.50098186e-02f,
  -1.48104383e-02f, 2.48552412e-02f, -1.30981609e-01f, -9.04570743e-02f, 7.20749050e-02f, -1.04198642e-01f, 7.84509778e-02f, 7.21315295e-02f, 9.93522778e-02f, 1.13749996e-01f,
  -5.56930676e-02f, -7.07452074e-02f, -5.41570410e-02f, -4.92087342e-02f, -4.71700095e-02f, -4.21442688e-02f, 6.85094371e-02f, -4.80797067e-02f, 4.69108447e-02f, 6.43284395e-02f,
  -8.61769356e-03f, -7.99417496e-02f, 5.35783917e-02f, -7.64631778e-02f, -5.06327190e-02f, -8.20133239e-02f, 4.69987560e-03f, 3.11337132e-02f, 3.04975081e-03f, -7.63903037e-02f,
  -1.18000805e-01f, -4.74469848e-02f, -7.22983256e-02f, 1.06242253e-02f, -6.30107075e-02f, 2.82932967e-02f, 7.28298817e-03f, -4.10855077e-02f, 4.27036732e-02f, 3.28801870e-02f,
  8.80697817e-02f, 3.67402434e-02f, 1.03726666e-02f, -6.37413785e-02f, 4.03773189e-02f, -9.76199005e-03f, 7.33248517e-02f, -8.20672791e-03f, 5.84464371e-02f, -3.34706567e-02f,
  2.09773425e-02f, -6.45424798e-02f, 3.85034233e-02f, 8.96000639e-02f, 4.33252193e-02f, -6.20337911e-02f, -2.10676081e-02f, -6.84456527e-02f, 4.61338833e-02f, 2.18693186e-02f,
  1.75701659e-02f, -3.10271466e-03f, -7.65826181e-02f, 7.63042346e-02f, 7.86560997e-02f, 7.60009587e-02f, -6.83371052e-02f, 6.56204075e-02f, -9.17345360e-02f, -2.73389928e-02f,
  1.15301386e-01f, 2.09492683e-01f, 2.66060811e-02f, -3.42605263e-02f, 3.91670465e-02f, 3.10183801e-02f, 8.47110078e-02f, 1.43883303e-02f, 1.09313972e-01f, -3.35023105e-02f,
  5.86305261e-02f, 1.56829716e-03f, 4.37220521e-02f, 6.20787032e-02f, -9.44647472e-03f, -1.86312497e-02f, 7.25275502e-02f, 5.16887531e-02f, 3.21701430e-02f, -2.46836171e-02f,
  -3.35443243e-02f, 3.68413106e-02f, 1.17711741e-02f, -9.06177461e-02f, -8.74038637e-02f, -5.59942648e-02f, 1.75153017e-02f, -1.58787668e-02f, -3.92086245e-02f, 6.45566806e-02f,
  1.02956027e-01f, 9.56565365e-02f, -8.92965961e-03f, -8.19078162e-02f, -8.70161504e-02f, -7.71885961e-02f, -1.67711437e-01f, 2.14913730e-02f, 2.77302396e-02f, -1.04849935e-01f,
  -1.33798212e-01f, -4.27402207e-04f, 8.41245726e-02f, -1.24390267e-01f, 2.73626707e-02f, 4.49122712e-02f, -9.57221761e-02f, -1.12541370e-01f, 9.32920501e-02f, -1.92126617e-01f,
  -5.37531562e-02f, -2.36538798e-01f, -7.73739442e-02f, -1.19359903e-01f, -1.57027081e-01f, -9.87930596e-02f, -1.09196894e-01f, -6.05340786e-02f, -7.35508129e-02f, -1.00552123e-02f,
  1.69757716e-02f, 3.70853096e-02f, 9.90660191e-02f, 1.23489976e-01f, 5.77109195e-02f, -2.23850179e-02f, 4.17950675e-02f, 4.78984751e-02f, 4.84947935e-02f, -4.73500825e-02f,
  -8.27643946e-02f, 1.29075721e-02f, -3.02686170e-02f, 1.33598605e-02f, 4.84967530e-02f, -3.36156450e-02f, 6.84113652e-02f, 3.71918045e-02f, -1.35754040e-02f, 1.16484143e-01f,
  2.73325574e-02f, 5.35396263e-02f, -9.36286226e-02f, 1.18692163e-02f, -3.88324596e-02f, 1.03273448e-02f, 7.78973252e-02f, 9.36833769e-03f, 7.71920308e-02f, -1.60007942e-02f,
  3.35673057e-02f, 6.19734898e-02f, 2.46769357e-02f, -3.40676419e-02f, -1.98801942e-02f, 2.60637701e-02f, -4.85287271e-02f, -5.52169047e-03f, 3.85090662e-03f, -2.69896770e-03f,
  7.16702789e-02f, 5.03093936e-02f, 4.39039059e-02f, 2.96104439e-02f, 1.06808888e-02f, 3.67273651e-02f, 7.00366944e-02f, 9.77828982e-04f, -5.02244234e-02f, 2.72516906e-02f,
  4.49188203e-02f, -8.77919123e-02f, 1.17389718e-02f, -8.96085724e-02f, 1.24096116e-02f, 2.80532595e-02f, -7.52500296e-02f, 6.10084012e-02f, -1.45810563e-02f, -1.39515279e-02f,
  -5.96803837e-02f, -6.06943890e-02f, -1.50330579e-02f, -2.65185181e-02f, 1.06629366e-02f, 5.78985363e-02f, -1.90200061e-02f, -3.65821496e-02f, 4.50698771e-02f, 5.89578338e-02f,
  5.76742645e-03f, -4.39287424e-02f, -7.83772022e-02f, 2.08851270e-04f, -3.41919847e-02f, 1.29879266e-02f, -6.20804876e-02f, -8.84468257e-02f, -2.21276656e-02f, -7.37071037e-02f,
  -4.96390946e-02f, -6.83635324e-02f, 5.77036329e-02f, -6.31934851e-02f, -1.85360610e-02f, 4.65877615e-02f, -6.49364814e-02f, 1.00046746e-01f, -7.86705408e-03f, 9.73212272e-02f,
  -4.70095836e-02f, -2.69573092e-01f, 1.59764826e-01f, -5.62332422e-02f, -4.37541828e-02f, 1.60537884e-01f, 2.31597960e-01f, -2.28962347e-01f, -2.37357691e-01f, -3.53960767e-02f,
  3.33534405e-02f, -1.33049972e-02f, 4.47842889e-02f, 5.28474040e-02f, 2.36568853e-01f, 1.73388850e-02f, -6.02108706e-03f, 1.62279189e-01f, -8.86232182e-02f, -1.38008669e-01f,
  2.42084600e-02f, 5.65151423e-02f, 3.15853022e-02f, -1.27658337e-01f, 1.77795645e-02f, -1.48883229e-02f, -1.18317241e-02f, 1.44105881e-01f, 1.07425407e-01f, 1.29361272e-01f,
  -1.19910076e-01f, -1.27900437e-01f, 2.33539082e-02f, 2.46170145e-02f, -3.56584303e-02f, -5.48651777e-02f, 2.82106139e-02f, 1.04994595e-01f, 7.70360306e-02f, -1.04546532e-01f,
  4.52536121e-02f, 1.25870733e-02f, 4.19600531e-02f, 7.38807544e-02f, 1.36579862e-02f, -4.47265580e-02f, 8.86081660e-04f, 3.90096009e-02f, -7.09352717e-02f, 6.53302222e-02f,
  4.99089360e-02f, -6.07246533e-02f, 5.04777655e-02f, -5.02030775e-02f, 6.78668842e-02f, 3.82593088e-02f, 3.22612375e-02f, -1.19838445e-03f, -7.06858113e-02f, -7.42214769e-02f,
  2.60710083e-02f, 3.29429060e-02f, 5.84542602e-02f, 6.69334382e-02f, -4.96594422e-02f, -7.64134303e-02f, -1.19435824e-02f, 2.31091138e-02f, 6.65723681e-02f, -4.64438684e-02f,
  -4.41007949e-02f, -4.34835628e-03f, -2.87287030e-03f, -9.12361220e-02f, -8.90743285e-02f, -1.32245133e-02f, 8.15345794e-02f, -1.18629662e-02f, -7.42591023e-02f, 5.64393662e-02f,
  6.28104657e-02f, 3.42452228e-02f, 6.50462275e-03f, 9.26336646e-02f, -3.51343602e-02f, 5.26599362e-02f, -1.07894406e-01f, -6.20086165e-03f, -5.42391762e-02f, 1.06124178e-01f,
  -4.40461300e-02f, -1.20385408e-01f, 2.93448046e-02f, -7.68419132e-02f, 7.99539238e-02f, -7.83560798e-02f, -7.88741633e-02f, -5.93569949e-02f, -9.07591581e-02f, -1.84404589e-02f,
  5.31305186e-03f, 2.46542115e-02f, -9.53723043e-02f, 3.90485898e-02f, -2.46369317e-02f, -1.14420727e-02f, -5.65228332e-03f, 5.65671129e-03f, 4.55118977e-02f, -1.12168593e-02f,
  2.84747556e-02f, 3.24143432e-02f, 4.23615538e-02f, -7.38023967e-03f, 6.72357753e-02f, 4.16171812e-02f, 6.44834340e-02f, -7.48335943e-02f, 9.06156600e-02f, -7.13079348e-02f,
  -3.69904906e-01f, 1.83374658e-01f, 1.97818190e-01f, -2.93297112e-01f, 7.66243041e-02f, 2.21400082e-01f, -4.47589979e-02f, 1.26057044e-01f, -7.68048763e-02f, -2.15067100e-02f,
  -3.07514258e-02f, -1.91599727e-01f, 1.46450013e-01f, 2.73097288e-02f, 1.08403623e-01f, 1.73795015e-01f, -6.05332144e-02f, -2.59028338e-02f, -4.38023359e-02f, -1.08089603e-01f,
  -5.19280694e-02f, -1.13546357e-01f, 1.98062345e-01f, 9.22652707e-02f, 7.10277958e-03f, -9.41651613e-02f, -4.35812250e-02f, 1.10895157e-01f, 5.23919016e-02f, 2.75870226e-02f,
  -7.34309629e-02f, -2.40149662e-01f, -1.29691467e-01f, -1.00799702e-01f, -6.19909801e-02f, -1.04273409e-01f, -7.12985471e-02f, 2.78997887e-02f, -5.34279868e-02f, 8.40607956e-02f,
  -4.29036431e-02f, 4.73579653e-02f, -8.01832601e-02f, -6.24308474e-02f, -5.88425025e-02f, -1.02496641e-02f, -5.07808942e-03f, 7.79095590e-02f, 3.90681960e-02f, 8.73778388e-02f,
  1.30324244e-01f, 6.88438639e-02f, 3.69822048e-02f, 2.25312933e-02f, -4.04025763e-02f, 4.38977778e-02f, 3.06572597e-02f, -1.53016299e-03f, 7.71294534e-02f, 4.63917293e-02f,
  -1.53252324e-02f, -3.64464521e-02f, 8.00694246e-03f, -9.35050175e-02f, 1.47607978e-02f, -6.59681559e-02f, -7.39546865e-02f, -2.75814142e-02f, -7.35855773e-02f, -3.13079245e-02f,
  -1.89557094e-02f, 1.86514761e-02f, -4.01904546e-02f, -1.96881443e-02f, 2.18298528e-02f, -7.09958002e-02f, 4.41403463e-02f, 3.30119878e-02f, 3.53119671e-02f, -3.22175808e-02f,
  2.34145261e-02f, 6.31978139e-02f, 3.78136290e-03f, 6.08585440e-02f, -4.57146801e-02f, 6.80113584e-02f, -1.03718936e-02f, 6.07821159e-02f, 6.48387372e-02f, -1.93747059e-02f,
  -1.26118332e-01f, -2.24388018e-01f, -1.02501675e-01f, -1.17984720e-01f, -7.16949254e-03f, -3.53332534e-02f, -9.19760019e-02f, 5.23513556e-02f, -1.83384959e-02f, 3.13291997e-02f,
  -9.81894210e-02f, -6.52076397e-03f, -4.53022011e-02f, 3.05289663e-02f, 1.72536504e-02f, -5.23868501e-02f, -3.11294328e-02f, -7.90864229e-02f, -1.26604125e-01f, -2.87287999e-02f,
  -7.46330842e-02f, -9.49891284e-02f, 5.55270612e-02f, 3.84276621e-02f, 6.43507391e-03f, 4.71017361e-02f, -8.91066194e-02f, -1.19961398e-02f, 7.10170269e-02f, -5.94814541e-03f,
  7.67094120e-02f, -1.67264253e-01f, 1.24925099e-01f, 1.29422069e-01f, 4.87784157e-03f, -2.35254113e-02f, 9.81345586e-03f, 8.78873914e-02f, -7.12616891e-02f, -2.41956562e-01f,
  -8.94446373e-02f, -3.49404439e-02f, 1.19767943e-02f, 3.70679237e-02f, 2.38415599e-02f, 6.39806539e-02f, 1.00302301e-01f, -8.60382989e-02f, 6.71043545e-02f, 2.23521478e-02f,
  1.77594036e-01f, 1.49806157e-01f, 3.09706647e-02f, 6.81789592e-02f, -1.87990870e-02f, 1.12744212e-01f, -2.42936220e-02f, 1.89816356e-02f, 9.26283821e-02f, 4.72426228e-03f,
  2.29298100e-02f, 6.79133236e-02f, 1.01218857e-01f, -5.87820485e-02f, 6.78015724e-02f, -1.68547519e-02f, -8.82967934e-02f, 7.22298399e-02f, 3.75141390e-02f, -4.57557365e-02f,
  5.40058762e-02f, 2.83259600e-02f, 8.42622891e-02f, 4.14951779e-02f, -2.10084822e-02f, 9.89225954e-02f, 7.62401894e-02f, 2.15979349e-02f, -1.01836652e-01f, -8.36709961e-02f,
  4.57373448e-03f, 3.85701619e-02f, 1.15253903e-01f, 4.70744409e-02f, 5.56568801e-02f, 3.33025418e-02f, 7.15892687e-02f, -5.01940772e-02f, 1.36155616e-02f, 8.59891623e-02f,
  7.71980174e-03f, -4.57333475e-02f, -8.40854943e-02f, -3.49092819e-02f, -8.27887356e-02f, -5.45100719e-02f, -5.82221150e-02f, -4.31155972e-02f, -5.86953610e-02f, -9.96092916e-04f,
  -8.79201069e-02f, -3.53842886e-04f, -3.93330753e-02f, 2.25724224e-02f, 9.73851010e-02f, -3.28831114e-02f, -5.16820922e-02f, 1.22074652e-02f, 7.78300837e-02f, -6.55164123e-02f,
  1.47751151e-02f, -2.68987939e-02f, -2.63362676e-02f, -5.09539843e-02f, 5.50562441e-02f, -9.94807109e-02f, -5.59004545e-02f, -2.97903679e-02f, 7.71119520e-02f, 8.00114423e-02f,
  -3.31151523e-02f, -9.62124616e-02f, -4.26536798e-02f, -1.12982281e-02f, 2.79190838e-02f, -1.07524320e-01f, -7.68317580e-02f, -6.92000985e-02f, -6.17801584e-03f, 3.74152027e-02f,
  -8.02152455e-02f, -7.04640746e-02f, -7.57298023e-02f, 8.09124112e-02f, 8.99690017e-02f, 5.09988964e-02f, 4.28000055e-02f, 3.66028920e-02f, 8.04415531e-03f, 6.96230605e-02f,
  -2.75039244e-02f, -5.32407612e-02f, 7.02176243e-02f, 1.03668436e-01f, -8.10254514e-02f, -8.10145214e-02f, 8.55397880e-02f, -5.04311249e-02f, 4.06512991e-02f, -5.59902601e-02f,
  1.54847756e-01f, -1.59760281e-01f, 1.81818858e-01f, 1.76763181e-02f, 8.04243144e-03f, -4.00975496e-02f, 1.23619273e-01f, 3.81497554e-02f, -1.99398287e-02f, -1.78071842e-01f,
  -2.27676872e-02f, -8.42452347e-02f, -7.81677216e-02f, -8.58234316e-02f, -7.38792270e-02f, -2.38893386e-02f, -1.23044357e-01f, 2.71010473e-02f, 3.87451276e-02f, 6.15811162e-02f,
  1.20105512e-01f, -1.28677890e-01f, 1.29148206e-02f, -1.56726584e-01f, 3.00606806e-02f, -4.17871214e-02f, -2.64999121e-02f, 3.04652043e-02f, -5.50181009e-02f, -5.39182164e-02f,
  4.78944415e-03f, 9.94774476e-02f, 4.54695225e-02f, -1.35161425e-03f, 1.33658156e-01f, 1.16459012e-01f, -8.19844082e-02f, -6.38252869e-02f, 1.00788832e-01f, 7.64523307e-03f,
  5.67525290e-02f, -8.01003724e-02f, 9.64228902e-03f, -9.02551189e-02f, -6.66533038e-02f, 8.70281458e-02f, 8.23261291e-02f, 7.88928047e-02f, 2.80116145e-02f, 1.18098646e-01f,
  3.25640067e-02f, 4.18039635e-02f, 1.27690837e-01f, -4.06379104e-02f, -1.71211117e-03f, 5.44643328e-02f, 1.11724697e-02f, 3.05244401e-02f, -6.71339482e-02f, 9.96200740e-03f,
  3.56368311e-02f, 6.85704276e-02f, 8.05658475e-02f, 7.47048631e-02f, -7.27455243e-02f, 4.91052456e-02f, 4.08672728e-02f, -3.74102890e-02f, -5.91051653e-02f, -5.94530925e-02f,
  7.66730681e-02f, 2.47329883e-02f, -6.73808381e-02f, -4.13508229e-02f, -6.29895031e-02f, 7.83306658e-02f, -5.92126697e-02f, 4.56298031e-02f, 8.08350146e-02f, 1.10011376e-01f,
  -3.80163379e-02f, -4.29675207e-02f, -7.31859803e-02f, 5.34063652e-02f, 4.18433957e-02f, 2.00057682e-02f, 7.54310191e-03f, -2.68622562e-02f, 9.35111195e-02f, -3.08296476e-02f,
  3.04757450e-02f, -1.56766847e-01f, 1.04960047e-01f, 2.00564088e-03f, -6.36283979e-02f, 5.80340810e-02f, 6.42245188e-02f, -5.07976441e-03f, 3.11520323e-02f, 8.99805967e-03f,
  6.92594349e-02f, 7.58904556e-04f, -5.92641607e-02f, -9.25722122e-02f, 2.48882286e-02f, -4.21976894e-02f, 2.27794778e-02f, 3.07155903e-02f, 4.11730185e-02f, 5.03754765e-02f,
  -4.12297510e-02f, 1.21785495e-02f, -1.01385154e-01f, -7.36792088e-02f, -3.17562185e-02f, -3.22805345e-02f, -1.26606952e-02f, -4.77708466e-02f, -1.13221079e-01f, 3.26114148e-02f,
  -1.09931320e-01f, -6.29438832e-02f, 6.05300143e-02f, -6.98157996e-02f, 1.55866906e-01f, 1.14143997e-01f, 4.98785116e-02f, 1.42126083e-01f, -1.01696350e-01f, -5.51046468e-02f,
  -8.64541531e-02f, -1.55444250e-01f, -3.65158804e-02f, -5.05881272e-02f, 2.72019636e-02f, 7.09191384e-03f, -4.27348427e-02f, -2.90331878e-02f, 2.65816711e-02f, -2.79544629e-02f,
  6.45873770e-02f, -3.35222222e-02f, 1.62928011e-02f, 2.01190654e-02f, 8.51971731e-02f, 9.65961069e-02f, -8.92408043e-02f, 8.99592414e-02f, 4.34103012e-02f, -4.37995717e-02f,
  8.77554268e-02f, -7.13454857e-02f, 7.54376277e-02f, 1.08633779e-01f, 1.44756347e-01f, 6.92703202e-02f, -8.01799670e-02f, 2.87329331e-02f, 2.56579602e-03f, -2.58406177e-02f,
  -1.04686916e-01f, -5.87811060e-02f, 3.21369693e-02f, 1.51969735e-02f, 2.32063811e-02f, 1.52539266e-02f, 8.68547559e-02f, 7.79855773e-02f, 3.16611417e-02f, 9.26477555e-03f,
  8.42346251e-02f, -3.27704549e-02f, -3.67496423e-02f, -1.14659674e-01f, -1.62778925e-02f, -9.68850479e-02f, -4.98301275e-02f, 5.83455414e-02f, 3.85869271e-03f, 2.22480707e-02f,
  3.89328748e-02f, 5.00676855e-02f, -8.72882158e-02f, 4.24467884e-02f, -6.68826848e-02f, -3.03401388e-02f, 3.31337117e-02f, 2.80280551e-03f, 8.92361701e-02f, -7.24111795e-02f,
  3.26079950e-02f, -1.33393882e-02f, -1.11961889e-03f, -3.23061682e-02f, -6.61959797e-02f, -6.15918040e-02f, 4.85090986e-02f, 7.03608692e-02f, 2.70566307e-02f, 6.73437864e-02f,
  2.44493857e-02f, -2.90947198e-03f, -2.59887911e-02f, -1.57738309e-02f, -1.29902931e-02f, 4.64219153e-02f, 4.21361141e-02f, 5.76294661e-02f, -1.99708659e-02f, 7.54940361e-02f,
  -4.55559492e-02f, 1.20434836e-02f, 1.14596918e-01f, 8.17458704e-02f, 6.23339452e-02f, 7.99753368e-02f, -5.97070903e-02f, -2.77900808e-02f, -7.58454110e-03f, -8.59806761e-02f,
  8.76658782e-02f, 1.13715855e-02f, -8.27825591e-02f, 3.58183719e-02f, -3.77156995e-02f, 3.60074304e-02f, -9.80326235e-02f, -7.63593391e-02f, -2.71425899e-02f, -3.37819643e-02f,
  -7.53600821e-02f, 1.16908355e-02f, -8.35056528e-02f, 5.87948523e-02f, 2.00798940e-02f, 4.53947857e-02f, 4.37137522e-02f, 6.02475218e-02f, -1.08319812e-01f, -3.57310511e-02f,
  -2.18278170e-02f, 4.09972966e-02f, 1.58489123e-01f, 1.86399341e-01f, -3.42683680e-02f, 1.63228139e-01f, 2.33303964e-01f, -8.84390622e-02f, 2.43979767e-01f, -1.14353731e-01f,
  -1.95018336e-01f, 1.61234051e-01f, 7.28237778e-02f, 4.65552472e-02f, 1.25933558e-01f, 3.17224674e-02f, 7.64993280e-02f, 9.86264348e-02f, 1.00610517e-01f, 9.30924118e-02f,
  9.24925506e-02f, -4.54430804e-02f, -6.91526383e-02f, -2.31240779e-01f, -1.37978971e-01f, -4.09741327e-02f, -1.41532794e-01f, -2.83740256e-02f, -1.59783006e-01f, -7.71523193e-02f,
  3.22558954e-02f, 6.61721826e-02f, 3.05056181e-02f, 4.22820933e-02f, 1.36664752e-02f, -3.37984003e-02f, 4.37949561e-02f, 5.00076413e-02f, 1.32099944e-04f, -5.82260936e-02f,
  -4.55179531e-03f, -2.23995503e-02f, 8.61202553e-02f, 5.32410741e-02f, -5.62027469e-02f, -8.29011723e-02f, -1.49504421e-02f, 2.03660335e-02f, 6.76520616e-02f, 1.92532949e-02f,
  -4.52466123e-02f, 5.16747066e-04f, 2.15192065e-02f, -5.68163767e-02f, 2.80882549e-02f, -4.21056934e-02f, 6.70695454e-02f, -1.56345647e-02f, 2.89230514e-03f, -4.77459095e-02f,
  -4.47211824e-02f, 1.00192308e-01f, -7.05768168e-02f, -2.93852128e-02f, -3.00339796e-02f, -2.25985274e-02f, -6.12300411e-02f, -6.20247647e-02f, 4.62992601e-02f, 5.31232432e-02f,
  -3.53746526e-02f, 3.48132923e-02f, -3.10184248e-02f, 1.22421741e-01f, -2.46355180e-02f, 4.47109379e-02f, -9.26624537e-02f, -5.63228056e-02f, 3.70668769e-02f, -4.27462012e-02f,
  3.35192196e-02f, -1.24229314e-02f, -6.90958351e-02f, 6.40807347e-03f, -2.29745358e-03f, -8.60452279e-02f, 4.43459377e-02f, -3.43605988e-02f, 4.71510924e-02f, -1.98891014e-02f,
  1.18178926e-01f, 1.32338718e-01f, 4.90013249e-02f, 7.46808201e-02f, 9.61144492e-02f, -4.25571986e-02f, 9.45431814e-02f, -7.10679144e-02f, -3.04579828e-02f, -4.99852821e-02f,
  -6.09930009e-02f, 2.05245018e-02f, -6.12237006e-02f, -8.31661746e-02f, 8.19769725e-02f, -2.23227516e-02f, 1.08801410e-01f, 5.88372387e-02f, 2.58145691e-03f, -8.45415592e-02f,
  5.03368191e-02f, 7.00070336e-02f, 4.07094732e-02f, 2.33810898e-02f, 6.71709850e-02f, 8.26774985e-02f, 3.90230468e-03f, 7.40516931e-02f, 3.92349698e-02f, 4.45713736e-02f,
  3.05663973e-01f, 1.19849153e-01f, 1.63621128e-01f, 2.62350708e-01f, -4.81825136e-02f, -3.93407270e-02f, 1.02469428e-02f, 1.27097173e-02f, 2.39051253e-01f, 1.49662886e-02f,
  -1.81012779e-01f, 3.43825102e-01f, -1.97803840e-01f, 7.85947219e-02f, -9.66984257e-02f, -2.03251481e-01f, -5.31232953e-02f, 1.08078299e-02f, -2.57282313e-02f, 3.14015970e-02f,
  -2.65475176e-02f, -9.15177912e-02f, -7.22403899e-02f, -2.00379297e-01f, 1.46180347e-01f, 9.41745192e-02f, -1.82378545e-01f, -1.42434791e-01f, -7.69482506e-03f, -1.62141681e-01f,
  -9.45895561e-04f, 5.32330349e-02f, 1.06629476e-01f, 1.08723946e-01f, -1.97820719e-02f, -2.23683082e-02f, -6.72342861e-03f, -1.09037854e-01f, -6.69387206e-02f, 1.70550868e-02f,
  1.18218087e-01f, 8.28854181e-03f, 1.23349942e-01f, -8.65916908e-02f, 6.47523180e-02f, -3.71163711e-02f, 1.30610988e-01f, 1.36874855e-01f, -2.25281138e-02f, 1.56812090e-02f,
  1.61136732e-01f, 5.32248579e-02f, -2.38279048e-02f, 3.30277253e-03f, -2.95197610e-02f, 7.68648311e-02f, 7.19774067e-02f, 4.66303155e-02f, 1.05511129e-01f, -1.99630056e-02f,
  -6.33154213e-02f, -5.02913222e-02f, -2.37046722e-02f, 2.71520903e-03f, 2.97072772e-02f, 4.26808186e-02f, 5.71116135e-02f, -6.22476488e-02f, -2.13135732e-03f, -4.04145494e-02f,
  -6.40946999e-02f, 4.13598493e-02f, -8.55914429e-02f, -1.80514753e-02f, -1.44186579e-02f, -4.76349108e-02f, 3.37242335e-02f, 5.44508174e-02f, 5.89114847e-03f, -4.89367656e-02f,
  5.00906184e-02f, -7.62245134e-02f, 4.58216779e-02f, -9.78050381e-03f, -1.69985425e-02f, 2.54984796e-02f, 3.12006893e-03f, -8.15040432e-04f, 5.55160902e-02f, -8.98950547e-02f,
  -1.26831383e-01f, -4.62158769e-02f, -1.48922056e-02f, 9.57427248e-02f, 6.52941540e-02f, -2.57029291e-03f, -3.61077278e-03f, 1.00747772e-01f, -2.78094653e-02f, 1.12686008e-02f,
  2.33723167e-02f, 5.87978922e-02f, 8.32336023e-02f, 4.47524041e-02f, 4.51135747e-02f, -8.94854739e-02f, -7.28902072e-02f, -6.49987236e-02f, 4.95803244e-02f, 8.81725922e-02f,
  -1.18982280e-02f, 5.87076694e-02f, 2.73685083e-02f, -3.39737386e-02f, 6.65107071e-02f, -7.06607923e-02f, -4.23949696e-02f, -3.84692065e-02f, 5.52309677e-03f, -4.18903269e-02f,
  9.35850814e-02f, -1.37493551e-01f, 1.00694261e-01f, -1.73717160e-02f, -9.09549892e-02f, 8.08435306e-02f, 1.46819040e-01f, -1.77099928e-01f, -2.14474544e-01f, -1.29930303e-01f,
  5.45383058e-02f, 5.30541949e-02f, 1.75241306e-01f, -3.04904059e-02f, 9.01059508e-02f, 1.22322418e-01f, 4.57426580e-03f, 1.00044832e-01f, -2.78924536e-02f, 1.11370208e-02f,
  -2.67722644e-02f, -6.86880797e-02f, 2.24914327e-02f, -1.49568051e-01f, -8.47525895e-02f, -7.19836429e-02f, -8.88921227e-03f, -5.61227798e-02f, -1.03859074e-01f, -3.03700492e-02f,
  1.06386773e-01f, -4.96120974e-02f, -3.27532738e-02f, 2.46368255e-02f, -6.92072436e-02f, 1.42383995e-02f, 8.66721198e-02f, 1.33500382e-01f, -1.77397337e-02f, 7.61745274e-02f,
  5.47619984e-02f, -1.31306555e-02f, -5.73235378e-02f, 6.78818077e-02f, -2.46407427e-02f, 2.01418344e-02f, -3.19694877e-02f, 4.83629033e-02f, -4.54497822e-02f, 2.12907158e-02f,
  -5.60492128e-02f, 6.62832409e-02f, -2.15827040e-02f, 7.09941164e-02f, 3.91801409e-02f, -7.45145157e-02f, 3.18802446e-02f, 8.26144218e-02f, -3.56704369e-02f, -1.10807072e-03f,
  -8.30805451e-02f, -4.88847531e-02f, 7.44725764e-02f, -2.56355368e-02f, 4.72391844e-02f, 5.93229458e-02f, -2.95815822e-02f, 3.10577173e-02f, 4.42072153e-02f, -3.02759167e-02f,
  -5.93250394e-02f, 3.56597491e-02f, -7.33560324e-02f, -1.58662759e-02f, -3.94069888e-02f, 2.60315705e-02f, -3.76890004e-02f, -2.61668898e-02f, 2.40920652e-02f, 1.96069758e-02f,
  7.16280192e-02f, -7.39341825e-02f, -8.48036408e-02f, 3.44253406e-02f, 3.59617323e-02f, -6.92741200e-02f, 9.56046674e-03f, 2.48825308e-02f, -7.35123530e-02f, 5.55107743e-02f,
  -2.07501221e-02f, -8.58805031e-02f, 6.15353733e-02f, 1.06123509e-02f, 5.95153794e-02f, -3.11767850e-02f, -2.43006032e-02f, -9.90167335e-02f, 5.12056835e-02f, -2.90993173e-02f,
  -4.08822671e-02f, -6.24752901e-02f, -1.43390456e-02f, 5.75434864e-02f, -5.87748103e-02f, 1.80149004e-02f, -2.56188978e-02f, -2.68397145e-02f, -8.50376301e-03f, -7.42239431e-02f,
  5.77434078e-02f, 6.88062012e-02f, 1.00301012e-01f, 2.60907901e-03f, -6.28733337e-02f, -8.06333274e-02f, -1.01796694e-01f, -4.50486019e-02f, 7.39366561e-02f, -8.34012106e-02f,
  1.59681335e-01f, -4.97391187e-02f, -1.50752693e-01f, -1.14166670e-01f, -1.90054804e-01f, -2.90071607e-01f, -2.80051410e-01f, -1.00276716e-01f, 4.21146443e-03f, -1.17404546e-04f,
  -2.18097106e-01f, 6.33994266e-02f, 1.67121634e-01f, -1.81306615e-01f, 1.22721761e-01f, 1.84144467e-01f, -1.67434379e-01f, -7.21364049e-03f, -2.87901126e-02f, -1.92775398e-01f,
  -4.34554927e-02f, -1.64098918e-01f, -8.41937363e-02f, -1.38401896e-01f, -3.26299101e-01f, -1.15348488e-01f, -5.07248230e-02f, -1.59935266e-01f, -1.60442874e-01f, -9.70753655e-02f,
  4.02941518e-02f, -6.62114695e-02f, -7.75399357e-02f, 4.72112782e-02f, 9.36330669e-03f, -6.73906654e-02f, -8.87087658e-02f, -9.53042414e-03f, -1.37950601e-02f, 1.58199575e-04f,
  3.84074263e-02f, 4.94501442e-02f, -3.70397978e-02f, 4.68180962e-02f, -6.06706515e-02f, -2.34478600e-02f, 5.92286922e-02f, -1.33847352e-02f, -1.64791327e-02f, -6.47851378e-02f,
  -1.06564641e-01f, -4.29049022e-02f, -3.56303342e-02f, 9.11076665e-02f, 7.56284446e-02f, -5.47511317e-03f, 8.32540840e-02f, 3.66013050e-02f, -1.13546671e-02f, -5.29504232e-02f,
  3.44364755e-02f, 1.66595150e-02f, -6.40608668e-02f, 1.89454053e-02f, 5.12595512e-02f, -1.10123381e-01f, -3.34330909e-02f, 8.22315887e-02f, -2.64898012e-03f, -6.20350279e-02f,
  3.62375118e-02f, 5.17168008e-02f, 2.93711200e-02f, -3.42115164e-02f, -7.61819109e-02f, 4.89741713e-02f, -7.90112391e-02f, -1.73997860e-02f, -1.19958632e-02f, -1.10370340e-02f,
  -2.66609304e-02f, 7.27521628e-02f, -1.34583050e-02f, -5.31605296e-02f, -4.25097980e-02f, 7.88102224e-02f, 2.16795020e-02f, 2.53954455e-02f, -5.10344021e-02f, -1.60682015e-02f,
  -5.75025193e-02f, 5.15746437e-02f, -1.81007627e-02f, 5.15231006e-02f, 1.96906608e-02f, 4.47675511e-02f, -5.49306199e-02f, 2.87022820e-04f, -1.10266646e-02f, -7.19739497e-03f,
  -8.33169296e-02f, 6.37469739e-02f, -8.42249542e-02f, 4.01845053e-02f, 5.39521351e-02f, 1.35533949e-02f, -5.63085973e-02f, 3.86799015e-02f, -2.36256681e-02f, 6.20566979e-02f,
  1.79131906e-02f, 4.18556035e-02f, 5.58844507e-02f, 3.17664631e-02f, -3.87320407e-02f, -6.29370054e-03f, -3.49457078e-02f, 2.43155379e-02f, 6.33401871e-02f, -3.93874235e-02f,
  -2.18426570e-01f, 1.65418535e-01f, -1.12811647e-01f, -6.48966059e-02f, -1.04731523e-01f, -1.36178270e-01f, -1.40974402e-01f, 6.85920268e-02f, 7.40428418e-02f, 1.54783145e-01f,
  1.11224502e-01f, -1.05745062e-01f, 2.06126913e-01f, -1.10477366e-01f, -1.62457779e-01f, 1.10363521e-01f, -8.40080157e-02f, -6.97848424e-02f, 2.15109494e-02f, -4.27706055e-02f,
  -9.84401852e-02f, -5.21713942e-02f, -1.53631289e-02f, -1.75389238e-02f, -1.35386229e-01f, 3.73571515e-02f, 7.88926426e-03f, 2.32506245e-02f, -1.35643139e-01f, -4.82711270e-02f,
  -9.58231762e-02f, -1.54498801e-01f, -1.79995410e-02f, -2.01879553e-02f, -9.17823985e-02f, -1.18971780e-01f, -1.15197986e-01f, 1.97404381e-02f, -7.12990537e-02f, -6.75764233e-02f,
  1.66900028e-02f, 5.16919382e-02f, 6.93096593e-02f, 6.78748935e-02f, -5.52367698e-03f, -1.22304205e-02f, -3.08195818e-02f, -8.86940733e-02f, 4.14463459e-03f, -1.08583331e-01f,
  2.41606999e-02f, -2.13658307e-02f, -1.44422818e-02f, 3.75211909e-02f, -1.04897963e-02f, -3.22073102e-02f, -1.00213744e-01f, 3.29158008e-02f, -9.82928798e-02f, 3.64338905e-02f,
  5.87383062e-02f, -7.52644381e-03f, -1.70608405e-02f, 6.01327494e-02f, 3.32492329e-02f, 8.61207619e-02f, -4.28239368e-02f, -1.14422792e-03f, 5.11983447e-02f, 1.11862887e-02f,
  2.59576757e-02f, 1.44634172e-02f, 3.05272490e-02f, 4.71169651e-02f, 1.01258326e-02f, 3.29064652e-02f, 1.43572139e-02f, 8.97665974e-03f, 3.13791111e-02f, -4.40769494e-02f,
  8.94065723e-02f, 1.38081722e-02f, 8.44752863e-02f, 1.17922965e-02f, -9.08172131e-02f, 7.29548335e-02f, -5.04135862e-02f, 1.98606793e-02f, -6.97032828e-03f, -7.46012628e-02f,
  -2.18395218e-01f, -1.92348197e-01f, -1.92701276e-02f, -5.27374968e-02f, -4.28636186e-02f, 3.27399112e-02f, -4.74597625e-02f, 2.93287300e-02f, -3.34605426e-02f, -6.52321577e-02f,
  1.85442921e-02f, -7.97145590e-02f, -6.10963181e-02f, -3.28790210e-02f, 6.36138767e-02f, -2.34412532e-02f, -3.93979903e-03f, -1.38104276e-03f, 1.99476536e-03f, -6.42619655e-02f,
  -9.85774249e-02f, -4.14648019e-02f, 3.78078558e-02f, -1.90585423e-02f, -6.30981177e-02f, 3.70386429e-02f, -2.85476912e-02f, -8.82182494e-02f, -8.76365826e-02f, -4.87717390e-02f,
  -4.28979881e-02f, -7.84409270e-02f, -3.06369159e-02f, -1.09807380e-01f, -1.45767421e-01f, -6.80252016e-02f, -2.14397371e-01f, -1.04433000e-01f, 7.04162940e-02f, -4.44319472e-02f,
  -1.26036465e-01f, -1.19102467e-02f, 6.85006976e-02f, -1.22506998e-01f, 3.64481262e-03f, 6.88118627e-03f, -1.04552105e-01f, -8.43118802e-02f, 1.94601920e-02f, -1.40176773e-01f,
  -1.56491715e-02f, -1.75762951e-01f, -1.00846164e-01f, -4.64898068e-03f, -1.97617054e-01f, 5.49548455e-02f, 1.10749178e-01f, -9.93613899e-02f, -1.19599916e-01f, -1.06071763e-01f,
  -5.40440530e-02f, 2.34054457e-02f, -8.59336555e-02f, 3.45722325e-02f, 2.98537463e-02f, 2.85073444e-02f, 7.08592534e-02f, -5.19342758e-02f, 5.48179410e-02f, -8.12742114e-02f,
  1.62082016e-02f, -3.31098810e-02f, -9.30692442e-03f, 4.59646992e-03f, -2.28750501e-02f, -9.26856324e-02f, -7.90594369e-02f, 1.59308333e-02f, 3.75609496e-03f, -8.89067873e-02f,
  4.01203111e-02f, -6.39250129e-02f, 1.68257151e-02f, -5.80948545e-03f, -2.32529733e-02f, 1.90083534e-02f, -4.42839824e-02f, -3.34549546e-02f, 8.69733766e-02f, -1.67619903e-02f,
  -4.26546670e-02f, -6.69325590e-02f, -1.75335947e-02f, 7.92900007e-03f, -1.77543033e-02f, 4.57348786e-02f, -2.53155828e-02f, 8.99711177e-02f, -1.08064394e-02f, 5.09676374e-02f,
  -6.64975941e-02f, -7.33281747e-02f, -3.57579738e-02f, 3.47195193e-03f, -8.13095942e-02f, 8.75281394e-02f, 3.86727788e-02f, -4.21823002e-02f, 7.84729943e-02f, -4.53878157e-02f,
  -5.23832031e-02f, 4.78591323e-02f, 8.01620185e-02f, 1.07536577e-02f, -2.81350687e-03f, 4.85258289e-02f, -3.99766713e-02f, 1.53262112e-02f, 4.66175228e-02f, 1.28562013e-02f,
  -2.56344080e-02f, -1.73507798e-02f, 8.04546624e-02f, 6.78612366e-02f, -4.55197021e-02f, -3.51100750e-02f, -1.31833702e-02f, 1.20783746e-02f, -1.62250130e-03f, 3.14781033e-02f,
  -1.23035181e-02f, -5.47758266e-02f, 6.14239983e-02f, 6.78950399e-02f, 5.84001131e-02f, -1.02429181e-01f, 4.72676270e-02f, 1.04944736e-01f, 7.49905482e-02f, -2.47991867e-02f,
  7.12411478e-02f, 4.88361623e-03f, 2.34404244e-02f, 5.51681556e-02f, 6.41385764e-02f, 6.36704415e-02f, 7.73728713e-02f, -2.96048243e-02f, 3.55526246e-02f, 7.36512318e-02f,
  -3.78638208e-02f, 8.16495344e-02f, 1.00721240e-01f, -3.43033276e-03f, -5.79133965e-02f, 1.31445691e-01f, -9.96644348e-02f, 1.40029505e-01f, -2.67282454e-03f, -4.17713150e-02f,
  -2.02653315e-02f, -8.64927657e-03f, 5.31869419e-02f, -4.92122211e-02f, 8.01814720e-03f, 8.88404064e-03f, 4.31055725e-02f, 1.28815928e-02f, 7.09858090e-02f, 7.58919194e-02f,
  -6.06341325e-02f, -9.65299457e-02f, 1.00235566e-02f, 5.63877495e-03f, 3.83154452e-02f, 6.56456640e-03f, -1.58198878e-01f, -1.10288493e-01f, 9.52187255e-02f, 7.79218599e-03f,
  3.91485281e-02f, 6.95410743e-02f, 1.29847854e-01f, 1.01162538e-01f, 8.67057815e-02f, 6.88780919e-02f, 5.63035458e-02f, -1.32343341e-02f, 3.45194004e-02f, 4.70352918e-02f,
  -4.48407717e-02f, 1.36967218e-02f, 9.66668203e-02f, 7.20184818e-02f, 9.75521654e-03f, -2.01123245e-02f, -2.54552974e-03f, 1.55763496e-02f, -1.62659138e-02f, -2.73718871e-02f,
  -7.35846981e-02f, 1.01966136e-04f, -1.86037309e-02f, -3.62180211e-02f, 3.07513978e-02f, 4.56421301e-02f, 6.89087957e-02f, 3.36700976e-02f, 6.96710730e-03f, -6.91858158e-02f,
  -8.78118649e-02f, 9.01908949e-02f, -7.70545304e-02f, -3.71472761e-02f, 4.80476804e-02f, -6.80944249e-02f, -6.94704950e-02f, -4.92198467e-02f, 5.91727234e-02f, -2.07909271e-02f,
  4.32834728e-03f, -1.57718118e-02f, -1.89392678e-02f, -8.30151364e-02f, -4.77362610e-02f, 6.44741505e-02f, 6.78344816e-02f, 5.53898849e-02f, -8.01160038e-02f, 4.55712155e-02f,
  -1.54135544e-02f, 3.70188504e-02f, -2.35663690e-02f, 2.63711791e-02f, -4.06270847e-02f, 1.92562602e-02f, 9.20247957e-02f, 2.76226699e-02f, -3.47087458e-02f, -8.96257460e-02f,
  3.32067087e-02f, 1.07384706e-02f, 5.40945046e-02f, 4.03863564e-02f, 9.04432461e-02f, -2.54685935e-02f, -5.21602742e-02f, 2.65904218e-02f, -1.12451927e-03f, -1.97906028e-02f,
  1.14914449e-02f, 3.22367251e-02f, -6.55514281e-03f, -4.85133305e-02f, -9.46712643e-02f, 1.66943669e-02f, -6.11402243e-02f, -6.40484169e-02f, 7.07958220e-03f, 8.02829769e-03f,
  1.09518378e-03f, 5.43324277e-02f, 6.02007210e-02f, 1.72100775e-02f, 1.86165683e-02f, -5.25286607e-02f, -3.19818826e-03f, -7.48380423e-02f, 3.10562458e-02f, 6.11625202e-02f,
  -2.07428515e-01f, 7.71677867e-02f, 1.10235862e-01f, -1.74180314e-01f, -1.93892159e-02f, -2.96521299e-02f, 7.00457171e-02f, 5.53126149e-02f, -7.95205534e-02f, -2.63864156e-02f,
  -3.77355665e-02f, 5.81566021e-02f, 9.76875350e-02f, -5.17909639e-02f, -1.51476696e-01f, 6.13580942e-02f, -1.32057741e-01f, -1.16852298e-01f, 7.06215063e-03f, -3.06686647e-02f,
  -1.30334869e-01f, 1.12138921e-03f, -6.96279854e-02f, 3.11018880e-02f, 2.92157363e-02f, 4.11520600e-02f, 1.62408557e-02f, 7.63382157e-03f, -6.33707317e-03f, 7.78747573e-02f,
  -3.47981192e-02f, -1.22763388e-01f, 2.01971326e-02f, -1.26536749e-02f, -1.01042174e-01f, 2.28861347e-02f, -7.16882125e-02f, 3.14065851e-02f, 1.28335617e-02f, 1.88504439e-02f,
  -3.88228223e-02f, -3.97896580e-02f, -1.02172066e-02f, -1.66138355e-02f, 1.35846911e-02f, 2.29415600e-03f, -8.17214698e-03f, 6.07014038e-02f, 8.36445540e-02f, 4.89992835e-02f,
  2.01023351e-02f, 9.03946385e-02f, -2.83658355e-02f, 3.33864130e-02f, 7.86905214e-02f, -3.58592458e-02f, -4.88182902e-02f, -9.03104618e-02f, -6.36096299e-03f, 2.36534607e-02f,
  -8.39994550e-02f, -2.39681304e-02f, -8.03441703e-02f, -8.72223824e-02f, -3.28307748e-02f, -4.42061685e-02f, 2.66245641e-02f, -7.11983889e-02f, 2.89497944e-03f, -3.92248631e-02f,
  -4.48104739e-02f, -7.16960579e-02f, -6.20124675e-02f, -9.29056704e-02f, -6.33781999e-02f, -6.33350760e-02f, 1.84124969e-02f, -7.12528825e-02f, -6.32198015e-03f, 2.01247334e-02f,
  -7.79883638e-02f, -3.20524462e-02f, -8.07320923e-02f, -3.39419693e-02f, -5.36578298e-02f, -7.55424127e-02f, 8.45073462e-02f, -5.73053695e-02f, -5.91438785e-02f, 5.30529115e-03f,
  -1.39091760e-01f, -1.81765214e-01f, 5.70971407e-02f, 9.56897158e-03f, -3.01186275e-02f, 6.28843904e-02f, 1.17843961e-02f, -3.70138623e-02f, -5.47401421e-02f, -4.85792011e-02f,
  -1.16734756e-02f, 2.95199696e-02f, 5.61462939e-02f, -1.06212115e-02f, -5.21942787e-02f, 5.18669784e-02f, -4.39866818e-03f, 3.98075245e-02f, 4.50319201e-02f, -5.65513112e-02f,
  -8.80616903e-02f, -9.87499021e-03f, 5.61357699e-02f, -2.41332650e-02f, 3.41267772e-02f, 2.49791872e-02f, -1.18050445e-02f, -1.31069012e-02f, 6.84901401e-02f, 2.07091514e-02f,
  3.12549055e-01f, -2.44696110e-01f, -1.47312149e-01f, 1.89268112e-01f, 2.11493567e-01f, 2.09018067e-01f, 2.22825974e-01f, 7.68054575e-02f, 2.15892196e-01f, -4.57527973e-02f,
  1.51606634e-01f, -9.35613066e-02f, -1.42520666e-01f, 1.70576021e-01f, 1.17002919e-01f, 2.70258579e-02f, 2.36024544e-01f, 1.35508806e-01f, 1.01529472e-01f, -3.32039334e-02f,
  3.32971215e-02f, 1.27646312e-01f, -6.53890222e-02f, -9.12927315e-02f, 2.65678093e-02f, -8.89981166e-02f, 1.51672373e-02f, -1.28518313e-01f, 6.66480884e-02f, 2.51481421e-02f,
  1.28813297e-01f, 1.45707524e-03f, -5.82510941e-02f, 3.64683494e-02f, -3.64834890e-02f, 2.79205162e-02f, -3.06077227e-02f, -4.40981612e-02f, -6.13955148e-02f, -2.80205216e-02f,
  -2.97488496e-02f, -4.26659472e-02f, -1.73753481e-02f, 5.35813160e-02f, 9.20280814e-02f, -1.40830223e-02f, -5.13833873e-02f, -1.15681589e-02f, -1.07061602e-02f, -5.80706857e-02f,
  1.09049203e-02f, -3.16639915e-02f, 1.82989184e-02f, -1.24007501e-01f, 3.55281346e-02f, 5.64847980e-03f, 2.71971636e-02f, -9.31363553e-02f, 6.94417162e-03f, -6.27488196e-02f,
  3.97598147e-02f, 8.71413425e-02f, -3.07360273e-02f, 5.84354289e-02f, -6.19344488e-02f, -7.58036077e-02f, 5.99013455e-02f, 3.61455455e-02f, -2.70663928e-02f, -8.74605030e-02f,
  2.62787193e-02f, -2.45234575e-02f, 1.02241136e-01f, -5.24501465e-02f, -6.25835173e-03f, 5.03159277e-02f, 8.36271048e-02f, 6.35164231e-02f, 1.02022626e-01f, 4.05877866e-02f,
  -1.18025299e-02f, -3.37272584e-02f, -1.57423001e-02f, -6.15859143e-02f, 3.06398217e-02f, -6.89395443e-02f, 8.12131912e-02f, 6.03647828e-02f, 5.74373528e-02f, 7.87818953e-02f,
  4.94456850e-02f, -1.07528567e-01f, 3.05226035e-02f, -4.99206558e-02f, -1.19299553e-01f, 6.45796582e-02f, 1.95931494e-02f, 5.40543161e-02f, 3.22718546e-02f, 2.22903141e-03f,
  -4.96569015e-02f, 6.94146454e-02f, 5.57417311e-02f, -2.18625106e-02f, 4.79653403e-02f, 8.87299776e-02f, -5.83942384e-02f, -2.97017675e-02f, -1.59922615e-02f, -4.81350087e-02f,
  4.66594510e-02f, -3.84198688e-02f, 4.72183637e-02f, 4.66442890e-02f, -1.05830103e-01f, 6.30821288e-02f, -4.93327081e-02f, -1.16488077e-02f, 3.82777415e-02f, 5.00994734e-02f,
  -2.43793260e-02f, 1.65463984e-01f, 1.99308529e-01f, 6.40363470e-02f, -1.42605767e-01f, -1.34366408e-01f, -1.34325668e-01f, 8.90403837e-02f, -8.19635112e-03f, -5.97916134e-02f,
  4.85775508e-02f, 5.53244725e-02f, 6.89942688e-02f, 8.70421082e-02f, -1.55565236e-02f, -9.10055563e-02f, 5.73384836e-02f, 3.26696411e-02f, 6.27252758e-02f, 5.94969243e-02f,
  9.44432914e-02f, 6.49237707e-02f, 2.05116004e-01f, 1.63146004e-01f, 3.82032432e-02f, 1.56330079e-01f, 9.63549092e-02f, 4.70824763e-02f, -2.51025744e-02f, -1.08166143e-01f,
  -1.57363545e-02f, 1.31292105e-01f, 1.83270928e-02f, -3.06190494e-02f, 6.47326931e-02f, 1.19914925e-02f, -3.48582789e-02f, -9.30898190e-02f, -2.76235864e-02f, 2.43190192e-02f,
  -2.37277132e-02f, -4.34524976e-02f, 7.46770427e-02f, -8.79339725e-02f, -8.89708400e-02f, 7.82965347e-02f, 9.75969732e-02f, 9.78924111e-02f, 4.20479402e-02f, 6.33012457e-03f,
  1.92750823e-02f, 7.08698779e-02f, -3.57572176e-02f, -4.95485812e-02f, 7.31565282e-02f, -4.62701134e-02f, -3.09855677e-02f, -6.76251650e-02f, -2.47626007e-02f, 6.22062236e-02f,
  9.96799394e-02f, 3.63825373e-02f, -1.04504772e-01f, -7.59021938e-02f, 5.12970984e-03f, 4.18470763e-02f, -1.21381748e-02f, -2.45311409e-02f, -8.99209753e-02f, -8.45500603e-02f,
  6.41454756e-02f, 7.53906295e-02f, -7.68570378e-02f, 8.42041150e-03f, 2.97475792e-02f, -5.20016700e-02f, 3.31380814e-02f, -2.57199053e-02f, 8.44647065e-02f, 6.48211390e-02f,
  -4.16443907e-02f, -1.37178479e-02f, 6.02255315e-02f, -3.76707353e-02f, -1.26375388e-02f, -9.34620760e-03f, -5.36077581e-02f, -7.33873695e-02f, 7.35236704e-02f, -3.31892222e-02f,
  1.19357847e-01f, 4.52578478e-02f, 2.31360234e-02f, 5.63145727e-02f, 7.19859153e-02f, -6.35387227e-02f, -1.59836002e-02f, 7.13129118e-02f, 5.27122281e-02f, 5.78776114e-02f,
  6.12032749e-02f, -3.86157096e-03f, -3.87497316e-03f, -5.31724952e-02f, 7.06664473e-02f, -8.81484151e-02f, 7.37640485e-02f, 5.21105751e-02f, -9.98230055e-02f, 9.56413820e-02f,
  4.53695506e-02f, -4.14094143e-02f, 7.68334717e-02f, -2.45480910e-02f, -6.72616363e-02f, -8.69111568e-02f, -5.22895157e-02f, 1.10041901e-01f, 9.61866602e-02f, 1.22017674e-02f,
  -2.69669861e-01f, 1.58963621e-01f, 4.82239714e-03f, -2.39670604e-01f, 6.54849783e-02f, -1.55763865e-01f, -1.55050144e-01f, 1.72280967e-01f, 2.97976080e-02f, 1.45628259e-01f,
  1.94747895e-02f, 1.15490379e-02f, 1.72301471e-01f, 1.32660568e-02f, -1.86191723e-01f, 3.44609506e-02f, -1.99495450e-01f, -1.52114183e-01f, 2.99034063e-02f, -3.78152123e-04f,
  -1.36228263e-01f, 3.41486894e-02f, -3.52225974e-02f, 1.92483440e-01f, -2.93935486e-03f, 3.73933651e-02f, -1.08701721e-01f, 1.57073185e-01f, -1.63932234e-01f, 4.48348187e-02f,
  -7.34495372e-02f, 1.74141094e-01f, 1.00981519e-01f, 4.72362749e-02f, 8.50200187e-03f, -5.09705171e-02f, -9.91193131e-02f, 1.24511719e-02f, 6.98700175e-02f, -6.22947030e-02f,
  -1.15236209e-03f, -3.62706818e-02f, -4.88818390e-03f, -1.75733771e-02f, -3.76051888e-02f, -1.52317155e-02f, 8.91564265e-02f, -4.39814925e-02f, -2.69225333e-02f, 4.48029488e-02f,
  -3.68759111e-02f, 3.15921940e-02f, -6.35321364e-02f, -1.15973070e-01f, -2.87262462e-02f, -5.64803742e-02f, -1.91166867e-02f, -1.15763262e-01f, -2.03133654e-03f, -2.00620349e-02f,
  -4.59180884e-02f, -9.17275250e-02f, 5.20818196e-02f, 3.97163704e-02f, -8.49858485e-03f, -4.28364277e-02f, 4.86198515e-02f, -4.94686775e-02f, 5.94272986e-02f, -7.55043551e-02f,
  4.28847224e-02f, 4.01952229e-02f, -1.21558337e-02f, 1.12156691e-02f, -6.60716221e-02f, 5.35143316e-02f, -5.14802663e-03f, 4.16447483e-02f, -2.77148373e-02f, 3.40145975e-02f,
  9.88885313e-02f, 9.39816609e-03f, 6.64183423e-02f, -4.76854388e-03f, 1.42262294e-03f, -8.99489503e-03f, -5.96816465e-02f, 1.67742707e-02f, 3.58250849e-02f, -9.91928652e-02f,
  -1.02225989e-01f, 4.82783057e-02f, 1.04677781e-01f, 6.61355630e-02f, 5.18832058e-02f, 8.82142596e-03f, -1.35228951e-02f, 5.48064895e-02f, -5.58897071e-02f, 5.63929752e-02f,
  -1.05029874e-01f, -1.76453199e-02f, -7.01841116e-02f, -1.77788753e-02f, 6.87524155e-02f, -4.68497500e-02f, -5.50282337e-02f, -6.50125518e-02f, -6.63431734e-02f, -6.68987185e-02f,
  5.79363592e-02f, 4.56925519e-02f, 9.57208686e-03f, -2.23585349e-02f, -7.72101060e-02f, -2.99736066e-03f, -9.22328094e-04f, 7.40076005e-02f, 5.65359816e-02f, -7.61689022e-02f,
  1.57463655e-01f, -8.04928020e-02f, -1.08026460e-01f, -3.32289375e-02f, 5.59031107e-02f, 1.58425435e-01f, 1.60368737e-02f, -2.20248196e-02f, -1.72355041e-01f, -9.12535489e-02f,
  4.66429107e-02f, -8.30732007e-03f, 2.05070935e-02f, 9.66837853e-02f, 2.12963670e-01f, -2.21976149e-03f, 1.33738413e-01f, 1.61718905e-01f, -3.97486351e-02f, 4.56209816e-02f,
  -9.00102407e-03f, 1.64256737e-01f, -8.57822746e-02f, 8.05939063e-02f, -2.41237059e-02f, -1.08956620e-01f, 7.20729902e-02f, -7.35059828e-02f, 6.39007613e-02f, 1.61527395e-01f,
  2.73340363e-02f, -8.07774663e-02f, 5.50223812e-02f, 6.03673942e-02f, 8.76642764e-02f, 1.38442619e-02f, -5.58263138e-02f, -1.89283048e-03f, -5.90323645e-04f, 2.26352178e-02f,
  -7.92418942e-02f, -8.01232755e-02f, 3.69262137e-02f, -7.09548220e-02f, 4.72783856e-02f, -2.60965098e-02f, -8.58361796e-02f, -7.89936259e-02f, 2.98731346e-02f, -1.08235190e-02f,
  -7.53930360e-02f, 3.57049108e-02f, -8.32285509e-02f, -3.62687348e-03f, -6.89286888e-02f, -2.85031497e-02f, 5.26590236e-02f, 3.77716050e-02f, -4.31841202e-02f, 4.83479761e-02f,
  1.15027584e-01f, -9.00714546e-02f, 9.53022465e-02f, 7.34504163e-02f, -1.66317634e-02f, 9.84083414e-02f, 7.82780573e-02f, 2.89279539e-02f, -7.15860054e-02f, 2.12311186e-02f,
  2.32329476e-03f, -2.56852973e-02f, -2.06861533e-02f, 5.88550419e-02f, -4.62021865e-02f, 3.82276997e-02f, 5.81213273e-03f, 6.11552484e-02f, -2.70908009e-02f, -4.41994630e-02f,
  -2.86323912e-02f, -5.59960157e-02f, 5.32967634e-02f, -8.39871541e-02f, 3.75377536e-02f, 7.79773965e-02f, -5.71138365e-03f, -6.78085163e-02f, -4.92794365e-02f, -1.47103230e-02f,
  3.30210589e-02f, -1.97769534e-02f, 3.81304286e-02f, -4.83137444e-02f, -3.18547376e-02f, 5.99584430e-02f, 6.94087967e-02f, -4.15645093e-02f, -1.32346982e-02f, 6.00465983e-02f,
  4.65694815e-02f, 2.22046264e-02f, 4.24299613e-02f, 6.15491383e-02f, 5.93003072e-03f, -3.93524058e-02f, -2.81411819e-02f, -2.83474922e-02f, -7.72940069e-02f, 8.14562589e-02f,
  4.09924611e-02f, -5.02679497e-04f, 6.72385246e-02f, -1.81402247e-02f, -1.01933545e-02f, -2.06532404e-02f, -5.24124093e-02f, -1.02435820e-01f, 4.54671532e-02f, -9.84425992e-02f,
  1.37590379e-01f, -1.14412434e-01f, -1.70142800e-01f, -3.72839607e-02f, 3.42649929e-02f, 1.65070742e-01f, 1.21842034e-01f, -1.05419047e-01f, -1.71640664e-01f, -2.23249495e-02f,
  1.33787449e-02f, -1.26180276e-01f, 1.32288970e-02f, 1.38858870e-01f, 1.86633527e-01f, 3.72645147e-02f, 1.66784137e-01f, 1.56056434e-01f, 9.50981397e-03f, 7.42117092e-02f,
  2.97607630e-02f, 1.54753834e-01f, -4.38334458e-02f, 4.52267118e-02f, 1.11063309e-01f, 5.54285361e-04f, -6.97606131e-02f, -6.64130133e-03f, 2.19035447e-02f, 1.10069238e-01f,
  1.14778847e-01f, -9.66730788e-02f, 4.56337854e-02f, -1.02777798e-02f, 3.06468364e-02f, 7.82526359e-02f, 7.56846219e-02f, 8.86219442e-02f, -5.07172905e-02f, -2.89695640e-03f,
  -7.89668411e-02f, -5.23297340e-02f, -8.18457082e-03f, 4.73179594e-02f, -6.18172511e-02f, -9.28597301e-02f, 3.74950133e-02f, -5.42322509e-02f, -1.92868263e-02f, -3.41363288e-02f,
  -5.31650819e-02f, 3.49215753e-02f, -7.76387304e-02f, -2.32365094e-02f, -6.97896490e-03f, 6.69093952e-02f, 4.91925180e-02f, -7.37272725e-02f, -9.96358544e-02f, 3.87620218e-02f,
  -6.13866895e-02f, -5.45351878e-02f, -6.69053569e-02f, 9.12091285e-02f, 6.75242990e-02f, 5.27005717e-02f, -5.86119713e-03f, -5.32353879e-04f, -4.46551181e-02f, -7.56418258e-02f,
  -9.09656137e-02f, 2.79221367e-02f, -3.26078311e-02f, -8.52434486e-02f, -1.25931650e-02f, 1.28290299e-02f, -6.79976717e-02f, 6.80052787e-02f, 3.37105654e-02f, 8.19623694e-02f,
  4.00678702e-02f, 1.17671527e-02f, -2.67594773e-03f, -9.27797332e-03f, -1.49775837e-02f, -5.02229072e-02f, 1.29508683e-02f, 6.12452365e-02f, 3.65605578e-02f, -7.54513666e-02f,
  5.29945344e-02f, -5.01722433e-02f, -2.91059036e-02f, -7.08820717e-03f, 1.50080333e-02f, -5.70425540e-02f, 2.77813580e-02f, 7.76606426e-02f, 1.47217987e-02f, 1.29889231e-02f,
  9.67798661e-03f, 3.48270051e-02f, -6.26251251e-02f, -4.52821627e-02f, 4.72106636e-02f, 4.28072400e-02f, 5.50064184e-02f, 1.48662003e-02f, 2.96328831e-02f, -7.74449706e-02f,
  3.22107673e-02f, -3.50965001e-02f, -5.24856858e-02f, 6.61538318e-02f, 5.92758134e-02f, -2.86904559e-03f, 1.30376248e-02f, -1.13711081e-01f, -4.32360172e-02f, 4.05915938e-02f,
  -8.03883094e-03f, -9.42790508e-02f, 1.91154461e-02f, -1.75824072e-02f, 6.80434890e-03f, -4.28191423e-02f, 4.74526733e-02f, 2.65136827e-03f, -1.41124502e-01f, -7.24352449e-02f,
  4.38704714e-02f, 8.28645825e-02f, -6.39803056e-03f, 9.63954702e-02f, 9.49799940e-02f, -3.76493335e-02f, -1.40583059e-02f, 1.05792716e-01f, 2.05772165e-02f, 4.58096415e-02f,
  -1.19899062e-03f, -1.29575795e-02f, -4.01941873e-02f, 5.92694096e-02f, 4.19863909e-02f, 8.62416849e-02f, -4.63048443e-02f, 2.43224129e-02f, 1.67482734e-01f, 6.70598149e-02f,
  4.23169546e-02f, -1.17233358e-02f, -4.02229130e-02f, 8.43031481e-02f, -2.01706924e-02f, 9.91408806e-03f, 1.27098948e-01f, -5.00596277e-02f, 4.17349450e-02f, 2.06326898e-02f,
  1.00211576e-01f, -6.73596412e-02f, -3.22484411e-02f, -5.78914694e-02f, 6.70264214e-02f, -5.66053065e-03f, 8.21060389e-02f, 2.27980185e-02f, 4.73829061e-02f, -2.78372001e-02f,
  -6.59965798e-02f, -7.43772984e-02f, -3.69674060e-03f, -7.21763000e-02f, 7.16549084e-02f, 1.68050255e-03f, 6.42430112e-02f, 9.65363160e-02f, -1.52734276e-02f, -5.47108762e-02f,
  3.71550359e-02f, -3.53705324e-02f, 6.66215867e-02f, 8.07957202e-02f, 2.13199854e-02f, 6.97312132e-02f, 6.66108355e-02f, 2.99340207e-02f, 7.98192471e-02f, 7.41232038e-02f,
  -2.80086435e-02f, 5.14886938e-02f, -6.13712370e-02f, -6.27911044e-03f, -8.75464827e-02f, 3.03411186e-02f, 8.86045694e-02f, -3.96374054e-02f, -6.03228621e-02f, -6.13805838e-03f,
  1.44326277e-02f, 3.27926576e-02f, -8.77393708e-02f, 5.23385890e-02f, 4.96989191e-02f, 7.16980621e-02f, 6.25340790e-02f, -8.28725249e-02f, -9.03700218e-02f, 4.66790050e-02f,
  -7.96499401e-02f, -1.18217625e-01f, -7.36657716e-03f, 7.86181763e-02f, 5.88952214e-04f, -4.48244251e-02f, 7.77137205e-02f, 5.69844432e-02f, -3.57442871e-02f, 6.64032698e-02f,
  4.66718189e-02f, 9.29121822e-02f, 3.06346593e-03f, 9.20026898e-02f, -3.16087715e-03f, -2.28175893e-02f, -1.98755991e-02f, 5.53180017e-02f, -6.82254834e-03f, 9.56244320e-02f,
  2.41802726e-03f, 1.53454132e-02f, 6.13387264e-02f, 3.75486873e-02f, 2.47814264e-02f, -1.86485890e-02f, 6.51660562e-02f, 8.98981839e-02f, 8.26060995e-02f, 5.21468669e-02f,
  -6.42704591e-02f, -1.59384817e-01f, 4.95322496e-02f, -1.83563326e-02f, 7.01058144e-03f, 1.84639663e-01f, 5.60375676e-02f, -8.56165215e-02f, -1.44270852e-01f, -8.09025764e-02f,
  7.65778795e-02f, 6.41099736e-02f, 1.13894589e-01f, 8.05587918e-02f, 1.84328586e-01f, 8.73029381e-02f, -4.05573845e-02f, 6.30575186e-03f, -1.12078004e-01f, -1.17745958e-01f,
  5.43766171e-02f, -2.69578677e-02f, 1.23271853e-01f, -9.10487249e-02f, -2.94895545e-02f, -3.24181579e-02f, 9.62952673e-02f, 9.79637355e-02f, 3.70538607e-02f, 1.13085829e-01f,
  -7.86514133e-02f, -6.68832660e-02f, 3.11404150e-02f, -1.34767136e-02f, -7.17046633e-02f, 5.07938713e-02f, 6.10751845e-02f, 1.09328344e-01f, 8.04182664e-02f, -4.17665802e-02f,
  3.22849792e-03f, -2.13331059e-02f, -2.35304665e-02f, -7.61947706e-02f, -6.56417832e-02f, 1.46059571e-02f, 7.45923147e-02f, -6.99235201e-02f, 1.25210825e-02f, -4.83837053e-02f,
  -5.10968827e-02f, -3.81108969e-02f, -7.98335671e-03f, 3.98517177e-02f, -1.20485956e-02f, 1.34208065e-03f, -7.44935647e-02f, -2.95830723e-02f, 1.72785893e-02f, -7.42178783e-02f,
  3.48696858e-03f, 7.77177736e-02f, -2.82520223e-02f, 1.23998290e-02f, 6.50659278e-02f, 2.86309626e-02f, 3.93258035e-02f, -2.19165217e-02f, 8.17841515e-02f, 2.98477188e-02f,
  -4.91526090e-02f, -5.93303703e-02f, -4.27426249e-02f, -4.62522358e-03f, -2.68019736e-02f, -1.51670789e-02f, 1.23583853e-01f, 3.51656340e-02f, -3.43743674e-02f, 6.30629733e-02f,
  2.85588857e-02f, -3.01476885e-02f, 3.16455401e-02f, 2.97101587e-02f, -5.02770469e-02f, -3.66044939e-02f, -7.74134696e-03f, 3.15322056e-02f, -3.92594412e-02f, 8.15551579e-02f,
  -6.15130514e-02f, -1.06981523e-01f, 2.36852877e-02f, 7.72122061e-03f, 4.66495119e-02f, 6.60434291e-02f, 1.51445707e-02f, 2.12384332e-02f, -3.63977216e-02f, -2.42631864e-02f,
  -3.09943818e-02f, 3.57798524e-02f, 6.50529638e-02f, -4.18073796e-02f, -5.14392443e-02f, -3.64822559e-02f, -5.27732112e-02f, -1.00445546e-01f, 4.24987003e-02f, -7.34155551e-02f,
  2.81137880e-02f, -2.52460279e-02f, 2.60427734e-03f, 5.89330122e-02f, -9.40057933e-02f, -4.04608026e-02f, -2.59114262e-02f, 3.35487016e-02f, -1.25103490e-02f, -3.38680856e-02f,
  3.97994220e-02f, -2.75623381e-01f, -2.23901674e-01f, 6.55513396e-03f, 1.72827199e-01f, -1.13997590e-02f, -9.34300479e-04f, -2.94727609e-02f, -1.36668891e-01f, -1.10370331e-01f,
  -8.27636104e-03f, -5.19404858e-02f, -2.56990284e-01f, 1.76692277e-01f, 1.11985564e-01f, -1.57253310e-01f, 1.10249847e-01f, 6.33051470e-02f, 5.07002547e-02f, 3.36184651e-02f,
  4.42165323e-02f, 2.53425688e-01f, -2.32004095e-02f, 1.26939788e-01f, 7.38082975e-02f, 1.58812199e-02f, 5.35755651e-03f, -2.35994775e-02f, 1.58139616e-01f, 8.55306536e-02f,
  1.30144745e-01f, -8.41369405e-02f, -8.54502246e-02f, -1.76922209e-03f, -5.07517010e-02f, 3.70008908e-02f, 1.99608542e-02f, 6.46648109e-02f, -5.26423641e-02f, -3.41378003e-02f,
  -9.07077342e-02f, 1.74035039e-02f, -5.80590591e-03f, 7.63548613e-02f, -5.50999716e-02f, 3.22563723e-02f, 1.70240533e-02f, -5.85734285e-02f, 8.62202328e-03f, -1.66355241e-02f,
  1.75115932e-02f, 4.50274497e-02f, -7.54748806e-02f, -5.78396879e-02f, -2.05224082e-02f, 8.58312622e-02f, 2.53202002e-02f, -6.26553074e-02f, 4.78766821e-02f, 3.67263295e-02f,
  7.44318590e-02f, 7.94277340e-03f, -8.24321881e-02f, 2.61428468e-02f, -9.59762093e-03f, -1.52497059e-02f, 6.11695237e-02f, 7.70062655e-02f, -5.56859300e-02f, 5.96080953e-03f,
  4.56650220e-02f, 5.11390856e-03f, 7.64170720e-04f, 8.82919133e-02f, 8.73566698e-03f, -4.32248525e-02f, 7.30561167e-02f, 2.17398908e-03f, 3.95475216e-02f, -5.17827831e-02f,
  -4.96164411e-02f, 9.29624215e-02f, -9.27077085e-02f, 3.97260450e-02f, -1.04946271e-02f, -1.02491844e-02f, 8.72890204e-02f, 6.84497692e-03f, -8.09601694e-03f, -4.62056175e-02f,
  6.36575148e-02f, -5.64447343e-02f, 2.87268721e-02f, -3.22668254e-02f, -7.70382062e-02f, -1.57246843e-03f, -3.32405083e-02f, -2.77997786e-03f, -5.91038279e-02f, -1.28568504e-02f,
  5.45471087e-02f, 8.71632174e-02f, -5.68595305e-02f, 2.50695460e-02f, 1.03332505e-01f, 5.67930155e-02f, 1.02406060e-02f, 1.28200399e-02f, -5.11701889e-02f, -3.31416838e-02f,
  -1.02982661e-02f, 4.51571457e-02f, -2.36324612e-02f, -7.70423263e-02f, 6.11054935e-02f, -7.05194175e-02f, -1.86190754e-02f, -5.02282428e-03f, -3.38776782e-02f, -3.85086909e-02f,
  2.26429999e-01f, -2.32131362e-01f, 2.21315026e-02f, 1.58908501e-01f, 1.30592182e-01f, 1.23942956e-01f, 1.63644746e-01f, -1.10971764e-01f, 6.06472418e-02f, -1.12287231e-01f,
  -5.96216992e-02f, -7.88964629e-02f, 7.11899623e-02f, 1.52573124e-01f, 1.68073729e-01f, 1.78278740e-02f, 1.98736750e-02f, 4.94869500e-02f, -6.27055615e-02f, 1.04789194e-02f,
  -7.23808771e-03f, -3.26583758e-02f, 3.61938141e-02f, -2.05360025e-01f, 8.83767754e-02f, -5.38929217e-02f, -1.03701368e-01f, 5.39947711e-02f, -1.00720949e-01f, 3.06055956e-02f,
  5.26683554e-02f, -4.52773981e-02f, -1.05607295e-02f, -4.21673283e-02f, -4.16802354e-02f, 9.77868810e-02f, -5.04680574e-02f, 6.28576577e-02f, 1.89763792e-02f, 3.78803536e-02f,
  5.29643409e-02f, 3.21939141e-02f, -3.54075842e-02f, -2.41860989e-02f, 6.32213429e-02f, -7.63026550e-02f, 6.54576123e-02f, -9.06935409e-02f, -5.60058840e-02f, -3.86966243e-02f,
  4.61574793e-02f, 6.78715110e-02f, 5.47264777e-02f, -6.59595579e-02f, -7.44922832e-02f, -8.25980529e-02f, 3.65759023e-02f, -6.96698725e-02f, -5.10991849e-02f, -7.77529329e-02f,
  5.32944687e-02f, 1.78484190e-02f, 1.84159391e-02f, 6.76397681e-02f, 5.53123020e-02f, 6.35113288e-03f, 3.40127461e-02f, 4.43419553e-02f, -4.22022343e-02f, 5.89893572e-02f,
  -1.04488740e-02f, 1.02820396e-02f, -1.77052617e-02f, -4.78146039e-03f, 3.73592637e-02f, 6.53058961e-02f, 5.92207275e-02f, -8.11263546e-02f, 7.91787654e-02f, 5.52214719e-02f,
  1.74450390e-02f, 5.54050766e-02f, 7.87797347e-02f, -4.47418988e-02f, 4.04451452e-02f, -5.51011181e-03f, -3.66311818e-02f, 4.76169772e-02f, 1.57742687e-02f, 4.77697328e-02f,
  5.58051327e-03f, -1.10761806e-01f, -2.15235371e-02f, -2.76689678e-02f, -1.84548423e-02f, 3.10112033e-02f, 7.57792369e-02f, 1.17012160e-02f, 6.54036552e-02f, -1.15343370e-03f,
  -8.63494501e-02f, 3.55955474e-02f, -5.67930229e-02f, 2.58245901e-03f, -6.39701262e-02f, -2.09511071e-02f, 4.12723832e-02f, -1.11375310e-01f, -3.17450650e-02f, -1.15241088e-01f,
  1.81484781e-02f, -1.33147137e-02f, -6.61055148e-02f, -1.96592808e-02f, -1.09830201e-02f, 7.49098584e-02f, -9.39925238e-02f, 4.65222970e-02f, 1.82042997e-02f, -1.15782786e-02f,
  -1.73089758e-01f, 1.82016000e-01f, -1.74119040e-01f, 6.00242913e-02f, 1.82517573e-01f, 2.87704140e-01f, 1.63459256e-01f, 7.61393830e-02f, 1.30395040e-01f, 1.96991757e-01f,
  3.86729948e-02f, -2.94244681e-02f, 2.57203472e-03f, 4.46665734e-02f, -5.67800365e-02f, 8.05415735e-02f, 1.57328904e-01f, 1.87648818e-01f, -8.72745439e-02f, 6.24922849e-02f,
  -8.71944726e-02f, 1.03501581e-01f, -2.22621202e-01f, 5.61524648e-03f, -5.87856211e-02f, -5.20072244e-02f, -4.87900078e-02f, -1.75465420e-01f, 6.18929490e-02f, 7.34904557e-02f,
  -9.38671827e-03f, -1.38428003e-01f, -5.91159649e-02f, 3.53059284e-02f, -1.12875905e-02f, 3.16016637e-02f, -5.28506637e-02f, -1.01540402e-01f, -1.27264589e-01f, -7.01607484e-03f,
  1.59328245e-02f, -8.03889632e-02f, 1.22401975e-02f, -5.42362779e-02f, 6.86145201e-02f, 5.70515804e-02f, -3.83455493e-03f, 2.10499782e-02f, -3.67194600e-02f, 1.00071905e-02f,
  -3.81177742e-05f, -3.27395089e-02f, 4.91178818e-02f, 8.59801248e-02f, 2.86142230e-02f, -1.63492828e-03f, -1.29040452e-02f, 6.54898584e-02f, 1.56084877e-02f, 4.71905619e-02f,
  5.48364893e-02f, 6.01254962e-03f, 9.20688808e-02f, -1.77851506e-02f, 1.43518737e-02f, -8.44350830e-02f, -4.57380414e-02f, 1.05524603e-02f, -6.45644814e-02f, 7.63683692e-02f,
  -6.62322342e-02f, 2.35812180e-02f, -6.26978949e-02f, -6.90424964e-02f, -3.51125151e-02f, 7.80357048e-02f, -3.83129045e-02f, 5.73769491e-03f, 5.14365211e-02f, -2.29382981e-02f,
  -9.17587487e-04f, 2.74925237e-03f, -4.65501249e-02f, -3.98394205e-02f, 2.65788636e-03f, 2.11820938e-02f, -1.61256567e-02f, -7.81685486e-02f, 3.73344272e-02f, -5.76958992e-02f,
  2.60620207e-01f, 2.70458072e-01f, -8.98397341e-02f, -5.50048985e-03f, 1.87695269e-02f, 9.84261334e-02f, 8.87249634e-02f, 2.26561464e-02f, 8.86194110e-02f, 4.12177593e-02f,
  1.08698174e-01f, 4.07853797e-02f, 9.44726393e-02f, 4.56698909e-02f, -4.19131927e-02f, 8.32427144e-02f, -1.74718387e-02f, 8.27181935e-02f, 1.28907366e-02f, -1.93605591e-02f,
  2.75724642e-02f, 5.43616451e-02f, 4.54886556e-02f, 4.74464893e-02f, 5.29133826e-02f, 1.48188518e-02f, 1.34267593e-02f, 3.28738503e-02f, 4.47436683e-02f, 2.31909417e-02f,
  -1.42167509e-01f, 1.06893532e-01f, 4.49376889e-02f, -1.99584737e-02f, -1.72119103e-02f, 1.91820487e-02f, 8.83596838e-02f, -6.26706630e-02f, 8.14475194e-02f, 2.14750506e-02f,
  5.53842373e-02f, -8.05099308e-02f, 1.52976200e-01f, 5.22703826e-02f, 1.35942101e-01f, 7.83342198e-02f, 1.05680026e-01f, 1.73320621e-01f, -5.11406101e-02f, -2.83811055e-03f,
  -3.01773250e-02f, 6.20528124e-02f, 1.16672181e-02f, -3.03319618e-02f, 9.86258239e-02f, -1.33985192e-01f, -7.94309825e-02f, -5.51927425e-02f, 3.37688774e-02f, -9.40698981e-02f,
  -6.45788163e-02f, -4.67899218e-02f, -4.07335758e-02f, -1.05344310e-01f, -1.04955165e-03f, -2.29877755e-02f, -2.98015922e-02f, -8.21851492e-02f, -8.95324722e-02f, -2.97301821e-02f,
  2.90848571e-03f, 1.71343088e-02f, -3.39046679e-02f, 7.37906992e-02f, 7.03677610e-02f, 7.02910423e-02f, 6.30294830e-02f, -3.24666537e-02f, -6.60419911e-02f, -1.12978883e-01f,
  5.29260039e-02f, -4.10973541e-02f, 6.13072254e-02f, 6.88013881e-02f, 8.02109987e-02f, -7.68716261e-02f, 3.31535712e-02f, -4.40826640e-02f, -1.83235798e-02f, -4.52069566e-02f,
  -1.69788245e-02f, 8.87360191e-04f, -2.44986196e-03f, -2.47083139e-02f, 1.94364097e-02f, 9.51103270e-02f, -4.11764979e-02f, 6.00707904e-02f, 2.18052994e-02f, 1.35625880e-02f,
  8.60345885e-02f, 6.68228185e-03f, 4.90056463e-02f, 6.76064938e-02f, -4.71787155e-02f, 3.00000142e-02f, 7.66870193e-03f, -8.89882743e-02f, -2.42189877e-02f, -5.31038232e-02f,
  1.89015139e-02f, -5.58731966e-02f, 6.20089099e-02f, -4.78104921e-03f, -1.65204927e-02f, 4.44151349e-02f, 3.78571600e-02f, 1.69146396e-02f, 6.22471943e-02f, -5.66363521e-02f,
  2.31718756e-02f, 2.27454621e-02f, -4.83984984e-02f, 9.63959657e-03f, -7.15114847e-02f, -8.11883733e-02f, -6.66145608e-02f, -2.53057219e-02f, 1.12474989e-02f, 1.03026822e-01f,
  2.62365211e-02f, -4.40927148e-02f, 7.85549879e-02f, -9.57802404e-03f, 5.26607484e-02f, 1.75549295e-02f, 1.00657530e-02f, -2.46076826e-02f, -4.74911742e-03f, 5.10650352e-02f,
  -6.78493381e-02f, -8.31097178e-03f, -4.06188928e-02f, 1.97287053e-02f, 5.97379617e-02f, 5.02523296e-02f, 3.34613165e-03f, -5.06857149e-02f, -6.79536983e-02f, -2.25354843e-02f,
  1.45446077e-01f, 1.08864270e-01f, 1.91610530e-02f, 2.24013939e-01f, -2.52348147e-02f, -2.41097882e-01f, -1.57408774e-01f, -2.05847025e-02f, 4.92170081e-02f, -6.06597401e-02f,
  4.01588380e-02f, 1.25712547e-02f, 3.45175341e-02f, 1.08137608e-01f, 1.49204642e-01f, 1.63252167e-02f, 4.23945040e-02f, -8.71175528e-02f, -5.72049208e-02f, 1.95642114e-01f,
  2.00347975e-01f, 1.26572758e-01f, 1.79371238e-01f, 1.73263513e-02f, 8.33161101e-02f, 1.80979669e-01f, 1.80116743e-01f, 3.55978347e-02f, 5.00097573e-02f, -4.14017364e-02f,
  -8.85992944e-02f, 8.54951814e-02f, -3.01816594e-02f, 4.62841168e-02f, 1.76168010e-02f, -3.64164002e-02f, 3.35981846e-02f, -7.94880092e-03f, -3.25510465e-02f, -8.32921453e-03f,
  -1.12943845e-02f, -5.85005395e-02f, -4.97095212e-02f, 5.95892929e-02f, -7.73860365e-02f, -7.60662183e-02f, 2.34411974e-02f, -4.18295152e-02f, 6.52838200e-02f, 4.39951122e-02f,
  8.42825249e-02f, 1.66487563e-02f, -5.96602857e-02f, 6.43822998e-02f, 3.49041075e-02f, 4.36533876e-02f, 5.53750731e-02f, 3.76941785e-02f, -6.36899620e-02f, -5.99224959e-03f,
  6.90690577e-02f, -6.95426166e-02f, -2.47233361e-02f, 3.88423987e-02f, -3.82784307e-02f, -5.05966395e-02f, 1.64734833e-02f, -1.49018811e-02f, 6.65429309e-02f, -4.40137200e-02f,
  1.99564602e-02f, -2.25439556e-02f, 6.70979023e-02f, -1.99852251e-02f, 5.68792820e-02f, -1.49094616e-04f, -9.17700455e-02f, 3.24659459e-02f, -6.49982467e-02f, 3.11607067e-02f,
  -5.53318001e-02f, 3.47642861e-02f, 2.35444698e-02f, -2.97052190e-02f, -2.91853063e-02f, -6.40329570e-02f, -3.26586398e-03f, 4.19796221e-02f, 6.44242810e-03f, 8.46135989e-02f,
  8.41896253e-05f, 1.56140685e-01f, 3.26483734e-02f, -7.70843402e-02f, 3.07987984e-02f, 6.30083531e-02f, -8.40578303e-02f, -5.81317488e-03f, 8.99758115e-02f, 7.89714679e-02f,
  -4.78521474e-02f, 5.59244715e-02f, -8.09462294e-02f, 7.16895014e-02f, 2.70265993e-02f, -2.78794914e-02f, 5.55425286e-02f, 7.12110698e-02f, 5.03399670e-02f, 2.61433944e-02f,
  1.06259972e-01f, 3.28628942e-02f, 5.94588593e-02f, -8.62210393e-02f, 7.85959139e-02f, -1.14311610e-04f, -4.54171337e-02f, 3.66322026e-02f, -6.06777659e-03f, -4.89109866e-02f,
  1.41727356e-02f, 1.84687242e-01f, 8.99705067e-02f, -8.42200220e-02f, 1.68349165e-02f, 6.79676756e-02f, -4.16200273e-02f, 8.47570300e-02f, -2.45489273e-02f, 2.05280408e-02f,
  3.39539312e-02f, 1.20668471e-01f, 2.52331644e-02f, -5.10311276e-02f, -1.68553784e-01f, -5.94369918e-02f, 5.79193281e-03f, 2.82803029e-02f, 1.00146264e-01f, -6.80290759e-02f,
  -5.84309176e-02f, -4.54792846e-03f, 4.67611440e-02f, 3.82881723e-02f, 1.40435342e-02f, 2.22616293e-03f, -1.10384248e-01f, 5.39413244e-02f, 4.80220541e-02f, -9.21376422e-02f,
  -9.13747549e-02f, -1.05814226e-01f, -3.24237458e-02f, 6.41295984e-02f, -1.02523796e-01f, -1.36028985e-02f, -1.03342853e-01f, 4.96248435e-03f, -5.00720665e-02f, -5.11492342e-02f,
  9.68352333e-02f, -1.41151799e-02f, -5.16823269e-02f, 4.92130034e-02f, -6.34720176e-02f, 2.16129832e-02f, -6.68242201e-02f, 8.78392905e-02f, 1.13415420e-01f, 1.02197841e-01f,
  3.47664580e-03f, 3.00078616e-02f, -1.69217624e-02f, 9.39689949e-02f, 1.66456848e-02f, -8.09575170e-02f, -4.80122603e-02f, 2.51692981e-02f, 3.30805108e-02f, 4.21267860e-02f,
  6.58058897e-02f, -7.16709569e-02f, -2.34832335e-02f, -3.69440950e-02f, -8.91863033e-02f, 6.27589077e-02f, 2.32036188e-02f, -7.89792836e-02f, -1.84447300e-02f, 5.07038124e-02f,
  2.76191495e-02f, 4.62114401e-02f, 7.10864514e-02f, 3.84969562e-02f, -2.41258033e-02f, 2.83523891e-02f, 2.90620364e-02f, -1.87993906e-02f, 8.58520046e-02f, -7.55797327e-02f,
  3.62974480e-02f, 5.70595078e-02f, -5.35218045e-02f, 2.37505231e-02f, 8.32479522e-02f, -5.42332157e-02f, -3.66824754e-02f, 7.04135820e-02f, -5.14686778e-02f, -4.75810235e-03f,
  -1.63391251e-02f, -5.12537286e-02f, -4.55951728e-02f, -7.68786520e-02f, -1.56122940e-02f, -6.44102693e-02f, 6.50207745e-03f, -8.57606530e-02f, 5.96688874e-02f, -4.27753516e-02f,
  3.76021937e-02f, 4.37318273e-02f, -7.05460757e-02f, 2.59443056e-02f, 2.80347820e-02f, 8.88670504e-04f, 3.75562795e-02f, -1.81547850e-02f, -1.65931135e-02f, -6.27044439e-02f,
  5.36425551e-03f, 5.02677932e-02f, -3.91923487e-02f, 4.75472324e-02f, 6.50356477e-03f, -3.27223986e-02f, 7.22299004e-03f, 7.67126083e-02f, 1.40555585e-02f, -3.25317606e-02f,
  -2.47756811e-03f, -6.95789093e-03f, -1.45141631e-01f, 1.37811759e-02f, 2.56051123e-01f, -1.11768097e-01f, -7.54830167e-02f, 5.67184091e-02f, 1.13514580e-01f, 8.81804898e-02f,
  4.07727771e-02f, -1.51362613e-01f, 2.89280731e-02f, -6.93040043e-02f, -1.79416209e-01f, -2.33550206e-01f, -1.85150772e-01f, -2.16764763e-01f, -1.06156386e-01f, -7.66355693e-02f,
  -8.56300369e-02f, 1.16721950e-01f, -8.27884600e-02f, 2.61773407e-01f, 1.59804896e-01f, 9.87340137e-02f, 6.86755255e-02f, 1.80172190e-01f, -8.20487514e-02f, -3.59421782e-02f,
  -6.70596957e-02f, 6.08944632e-02f, 6.21138513e-02f, 6.41441941e-02f, -5.06507196e-02f, 6.67429268e-02f, -9.57198143e-02f, -3.28538939e-02f, -3.53244320e-02f, -5.02061881e-02f,
  -9.54554901e-02f, -4.84204106e-02f, -2.61404309e-02f, 5.80317862e-02f, 1.35010779e-01f, -2.21916120e-02f, -6.04660138e-02f, 5.93896508e-02f, 2.76846681e-02f, -1.28880560e-01f,
  -1.35512948e-02f, -8.37087780e-02f, -7.12670311e-02f, -1.13617390e-01f, 3.10455281e-02f, 4.39479388e-02f, -8.45280141e-02f, -4.56106402e-02f, 1.94642264e-02f, -8.62719491e-02f,
  -4.39086258e-02f, -2.33290028e-02f, 5.78171909e-02f, 4.14823070e-02f, 1.81860439e-02f, 1.02258839e-01f, -2.80608982e-03f, 7.28665069e-02f, 1.54100088e-02f, 1.24326255e-02f,
  1.90673280e-03f, -2.28818115e-02f, 4.94617037e-02f, 4.98225028e-03f, -5.51797263e-02f, -4.37811017e-02f, -4.99032661e-02f, 7.59560913e-02f, 1.43850008e-02f, 2.82918327e-02f,
  3.98623496e-02f, -5.26013672e-02f, 1.94281898e-02f, 9.59191769e-02f, 4.04069573e-02f, 5.66876829e-02f, -7.01516271e-02f, 5.09507162e-03f, -2.40381621e-02f, 1.92474574e-02f,
  -3.03737745e-02f, -8.93942043e-02f, -1.62859913e-02f, 2.82954396e-04f, -1.92165263e-02f, 6.62141964e-02f, -7.19229504e-02f, -1.98340975e-02f, 6.18811846e-02f, -3.90008581e-03f,
  -4.81973253e-02f, 9.61024221e-03f, 2.05270890e-02f, 5.55525273e-02f, -2.14172713e-02f, -7.67234247e-03f, -4.27006185e-03f, 2.82644164e-02f, -5.54635935e-02f, -3.70507687e-02f,
  4.50351387e-02f, 2.36712247e-02f, -3.14544770e-03f, -1.40654892e-02f, 2.60570049e-02f, -6.58239052e-02f, 9.97859240e-03f, 1.46434791e-02f, 2.10074671e-02f, -9.03258771e-02f,
  1.12126797e-01f, 1.66001275e-01f, -4.49307524e-02f, -6.81300685e-02f, 8.48638415e-02f, 2.06289720e-02f, -6.85511082e-02f, 6.79798499e-02f, -5.54035567e-02f, 1.70833096e-01f,
  1.61350638e-01f, 8.01184624e-02f, 2.33135279e-02f, -5.92397973e-02f, -3.94312590e-02f, -1.32871255e-01f, 9.54251438e-02f, 8.08513537e-02f, 9.98241268e-03f, 1.44355476e-01f,
  4.29302529e-02f, 1.92647964e-01f, -1.57113239e-01f, -1.08853849e-02f, 6.55100793e-02f, 8.83266404e-02f, 5.38083985e-02f, 8.65725204e-02f, 1.28578663e-01f, 8.43031108e-02f,
  -6.84131868e-03f, 7.18972906e-02f, -1.33722164e-02f, -1.64409671e-02f, 2.35490054e-02f, -6.38248324e-02f, -4.47148830e-02f, -8.82377774e-02f, 1.84802469e-02f, -7.84871206e-02f,
  6.85782954e-02f, 6.84290007e-02f, -4.64645661e-02f, -6.42964989e-02f, -4.27649505e-02f, 1.64263137e-02f, 3.10482271e-03f, -3.41949537e-02f, 6.60109371e-02f, -9.52355284e-03f,
  -3.49535979e-02f, 1.18941562e-02f, -2.86959335e-02f, -8.56004714e-04f, -8.71214923e-03f, -4.01444733e-02f, -3.71834673e-02f, 6.84785545e-02f, 1.08764745e-01f, -5.59368618e-02f,
  8.15203935e-02f, -3.83945368e-02f, 3.34013184e-03f, -7.57334679e-02f, -2.48212442e-02f, -5.55217490e-02f, -1.02537535e-02f, 9.69928876e-02f, -3.98077331e-02f, 8.09690282e-02f,
  -2.44863294e-02f, 6.45658821e-02f, 5.07181929e-03f, -7.83167481e-02f, -5.63996937e-03f, 3.71894315e-02f, -2.15262063e-02f, 7.60027096e-02f, 3.92055623e-02f, -5.42252399e-02f,
  -1.31513905e-02f, 3.72425467e-02f, -6.39816299e-02f, 3.42262536e-02f, -8.96762777e-03f, 1.33127358e-03f, 9.31949392e-02f, -1.22159394e-02f, -2.22991463e-02f, -8.03440362e-02f,
  8.97922367e-03f, 2.42528602e-01f, 4.93069272e-03f, -9.13020149e-02f, 7.00065270e-02f, 3.41014063e-04f, -2.23287884e-02f, -8.17993209e-02f, -2.16748714e-02f, -5.97269321e-03f,
  2.21903659e-02f, -7.69478157e-02f, 2.04167776e-02f, 7.42136613e-02f, 4.09348197e-02f, 1.52877823e-01f, 2.98012253e-02f, 1.47640938e-02f, 6.59880787e-02f, 1.10704869e-01f,
  1.15176052e-01f, -9.03479941e-03f, -5.88878654e-02f, 1.95798352e-02f, 6.74577802e-03f, 9.02199820e-02f, 9.34597552e-02f, -1.90210305e-02f, 5.88993132e-02f, -5.45458049e-02f,
  1.60270765e-01f, 5.30892424e-03f, 8.61604363e-02f, 1.63099289e-01f, -2.05930113e-03f, 4.09597643e-02f, 1.03008412e-01f, 8.30303282e-02f, 6.04763292e-02f, -1.43984213e-01f,
  -6.38331547e-02f, -2.98949145e-02f, -1.70300424e-01f, 1.13766871e-01f, 1.77465320e-01f, -1.11690238e-02f, 8.56659785e-02f, 7.17733353e-02f, -7.83223212e-02f, 1.09692551e-01f,
  1.33292198e-01f, 1.85462222e-01f, -4.18715216e-02f, 9.27066524e-03f, -1.14307562e-02f, 1.53356656e-01f, 1.37125582e-01f, 1.32276490e-02f, 6.97363913e-02f, 8.49566907e-02f,
  5.44548361e-03f, -2.82309391e-02f, -9.04572196e-03f, -1.08471408e-01f, 8.57466310e-02f, 2.80456170e-02f, -4.86863665e-02f, 6.31496832e-02f, -4.39772606e-02f, 7.24749193e-02f,
  -4.37990911e-02f, -4.05861922e-02f, 3.33107151e-02f, 3.05716731e-02f, 2.13204157e-02f, 8.70482326e-02f, -5.05302027e-02f, -1.50161060e-02f, -3.61079499e-02f, -1.34487068e-02f,
  -8.86338130e-02f, 4.48928252e-02f, -6.27807528e-02f, 7.22139627e-02f, 1.49078574e-03f, -3.29915471e-02f, -6.42764717e-02f, 1.00714050e-01f, -5.85185923e-02f, -3.63091044e-02f,
  -2.02617701e-02f, -5.41559458e-02f, 6.51322827e-02f, -7.66054019e-02f, 1.82443717e-03f, 2.91949924e-04f, 6.61852434e-02f, 4.04451974e-02f, 7.33681023e-02f, 6.91670328e-02f,
  -3.77981067e-02f, 3.84956896e-02f, -3.71999592e-02f, -1.12427445e-02f, -2.98978258e-02f, 1.54962614e-02f, 9.13711190e-02f, 1.21883694e-02f, 2.59911604e-02f, 4.72152717e-02f,
  4.18688450e-03f, 7.85634741e-02f, 7.83379599e-02f, -8.04942753e-03f, 7.58771300e-02f, 8.48241299e-02f, 1.32907825e-02f, -9.16390866e-02f, -8.37847739e-02f, -9.81429475e-04f,
  3.18072177e-02f, 1.13072000e-01f, 1.89598687e-02f, 3.50275934e-02f, -8.03071782e-02f, 3.55399325e-02f, 2.10996233e-02f, -7.66193122e-02f, -1.83627252e-02f, -1.31044537e-02f,
  -3.48273516e-02f, 6.73684478e-02f, 5.81467822e-02f, -2.03976985e-02f, 7.45340809e-03f, 9.68755484e-02f, 5.45210280e-02f, 5.26838303e-02f, 5.72517514e-02f, 4.83199693e-02f,
  2.57387646e-02f, -2.98591405e-02f, 9.90763903e-02f, 6.20754585e-02f, -1.33089721e-02f, -2.36416403e-02f, 7.49227703e-02f, -6.19087070e-02f, 9.81395841e-02f, -3.45994830e-02f,
  4.39312682e-03f, 7.69780874e-02f, -2.50161737e-02f, 1.10537671e-01f, 6.96641300e-03f, 1.00324020e-01f, -6.44435659e-02f, -2.25003809e-02f, 4.58181389e-02f, -1.14402883e-01f,
  -1.15411885e-01f, 1.10503823e-01f, -1.18842587e-01f, 1.03633046e-01f, -1.94175448e-02f, -6.61932901e-02f, 6.52417019e-02f, 6.38971999e-02f, -7.25880042e-02f, 5.04961200e-02f,
  -5.07742725e-02f, 1.71865001e-02f, -8.76249373e-02f, 1.01710605e-02f, 2.24924963e-02f, 1.13570474e-01f, 1.65305957e-02f, 7.17160776e-02f, 7.97405839e-02f, 7.21993297e-03f,
  7.82376677e-02f, 4.06725518e-03f, 1.52078047e-02f, 2.20799632e-02f, -2.23183446e-02f, -4.36392147e-03f, -2.19152751e-03f, 2.23500617e-02f, 7.20123993e-03f, 6.08360395e-02f,
  1.08189158e-01f, 1.00678541e-01f, 6.83382452e-02f, 1.48599194e-02f, 9.43508446e-02f, 2.03883997e-03f, -3.77297923e-02f, -1.15300100e-02f, -5.67332096e-02f, 4.88740616e-02f,
  -4.03540023e-02f, -2.62981877e-02f, 7.74314478e-02f, -3.22569930e-03f, -2.71759424e-02f, 3.05330157e-02f, -7.90757686e-03f, -3.24076898e-02f, 3.46935950e-02f, 2.56289020e-02f,
  -1.98522932e-03f, -2.07867119e-02f, -9.70025081e-04f, 3.61298397e-02f, -1.08371861e-02f, 4.10685167e-02f, -4.03574333e-02f, 6.55799732e-02f, -5.12325726e-02f, -5.04947938e-02f,
  -7.49440789e-02f, 7.90894125e-03f, 7.59008080e-02f, -4.60099243e-02f, 4.77628969e-02f, 1.53327864e-02f, -5.18253185e-02f, 3.26652937e-02f, 7.59615749e-02f, 9.08783898e-02f,
  9.61382873e-03f, -1.86859947e-02f, 5.06735332e-02f, -6.90165982e-02f, 4.81825545e-02f, 5.97797669e-02f, -6.47931397e-02f, -5.74048832e-02f, 5.95971309e-02f, -6.42962828e-02f,
  -2.31228676e-02f, -7.72135779e-02f, -2.06081625e-02f, 8.46805573e-02f, -8.15554336e-02f, -5.43608936e-03f, 8.52795169e-02f, 6.47495091e-02f, 9.28099155e-02f, 2.93069407e-02f,
  5.18849045e-02f, 2.74033565e-02f, -2.17032321e-02f, -7.57029280e-02f, 8.34690034e-03f, -1.51059888e-02f, -6.52615204e-02f, 1.20159602e-02f, 5.25654033e-02f, -2.09289026e-02f,
  6.86776415e-02f, 7.64578059e-02f, -4.56765899e-03f, 6.82164431e-02f, 1.79367159e-02f, 6.34829849e-02f, 3.10656261e-02f, -3.78881730e-02f, -3.66587751e-02f, 4.41365205e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  4.96341921e-02f, 1.00081995e-01f, -2.08494700e-02f, 4.20598425e-02f, 4.95393388e-02f, 4.15753759e-02f, 1.02341712e-01f, -4.10773745e-03f, 2.14158773e-01f, 7.11640865e-02f,
  1.21304572e-01f, 1.69740066e-01f, 1.11860000e-01f, 1.00286938e-01f, 1.22827627e-01f, 3.06746699e-02f, 1.98476061e-01f, 2.22903058e-01f, 1.01731740e-01f, -2.53988225e-02f,
  6.39180914e-02f, -2.05354728e-02f, -1.30321318e-02f, 1.10381193e-01f, 5.69405332e-02f, -2.34692618e-02f, 1.31406039e-01f, 1.31307274e-01f, 2.39751134e-02f, 9.35427565e-03f,
  3.83390822e-02f, 6.12496547e-02f, 1.50142938e-01f, 1.08266383e-01f, 2.08096221e-01f, 4.95092347e-02f, 6.03754669e-02f, 1.46718577e-01f, 7.06992447e-02f, 2.50822902e-01f,
  -2.80806404e-02f, 1.55828208e-01f, 1.98468089e-01f, 1.17679626e-01f, 4.20190021e-02f, 1.26604021e-01f, 3.45977545e-02f, 1.28662482e-01f, 1.03796072e-01f, 1.10694312e-01f,
  -1.61700547e-02f, 1.29971772e-01f, 1.50999613e-02f, 1.59440681e-01f, 2.19993934e-01f, 9.10922065e-02f, 4.53085154e-02f, 9.94220003e-03f, -1.89475473e-02f, 6.08471371e-02f,
  6.00257106e-02f, 1.65785596e-01f, 9.62373391e-02f, 7.44955242e-02f, 5.45736812e-02f, 5.35334572e-02f, -4.59638312e-02f, 1.00886181e-01f, 3.59233730e-02f, 7.21116960e-02f,
  2.17760071e-01f, 9.75338817e-02f, 8.19329023e-02f, -3.32839899e-02f, 2.17890993e-01f, 1.53622329e-01f, 1.07642822e-01f, -3.61686461e-02f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  5.10967821e-02f, 1.07880816e-01f, 4.60810922e-02f, -2.20907815e-02f, -2.07927421e-01f, 1.32757053e-01f, -4.59632650e-02f, -8.84857867e-03f, -1.61156729e-02f, -1.07801639e-01f,
  -8.70361775e-02f, -8.68582875e-02f, -5.58119118e-02f, 3.02335411e-05f, -1.81010261e-01f, -1.43097648e-02f, -7.32492581e-02f, 6.09597340e-02f, 7.80170262e-02f, -2.42975086e-01f,
  8.87735412e-02f, -1.29997179e-01f, -3.54319885e-02f, -8.47867057e-02f, 6.34066761e-02f, 5.57100363e-02f, -1.07927367e-01f, -1.91694677e-01f, 1.23708136e-01f, 2.20652819e-01f,
  -1.82146095e-02f, 2.39192262e-01f, -3.75038892e-01f, 1.55593246e-01f, 6.94431737e-02f, -2.42747873e-01f, -2.90406257e-01f, 2.23791748e-01f, 8.54606032e-02f, -4.46214259e-01f,
  -3.44613224e-01f, 1.28509358e-01f, 2.08158474e-02f, -1.38138101e-01f, 3.90182078e-01f, 1.95288405e-01f, -3.70763272e-01f, -1.60751179e-01f, -2.79256672e-01f, -1.10913061e-01f,
  -1.38908952e-01f, 2.97618747e-01f, -7.83879906e-02f, 2.83667222e-02f, 7.64194205e-02f, -5.97694926e-02f, 4.02906723e-02f, -1.32349327e-01f, -2.47940034e-01f, 3.93818051e-01f,
  6.68279529e-02f, -4.36977521e-02f, -1.59885675e-01f, 2.90543195e-02f, 7.73531795e-01f, -1.98833123e-01f, 4.05974500e-02f, -1.84943043e-02f, -1.57385513e-01f, -6.77710697e-02f,
  1.20082743e-01f, -9.63337570e-02f, 4.81117107e-02f, 6.16656393e-02f, -1.96296468e-01f, -1.07135169e-01f, 1.87132638e-02f, -1.39327226e-02f, -1.91505611e-01f, 5.16912639e-02f,
  -1.86319172e-01f, -4.99667600e-02f, 5.81069529e-01f, -1.39189541e-01f, -5.28606959e-02f, -1.58046335e-01f, 7.17103854e-02f, 1.89490262e-02f, 1.26453012e-01f, -2.46912569e-01f,
  -1.11740828e-01f, -2.64764845e-01f, 3.79307382e-02f, 1.07821764e-03f, -1.29736885e-01f, -1.48089811e-01f, -6.91329911e-02f, -1.74219310e-01f, 1.28346696e-01f, 1.24758132e-01f,
  -4.78598066e-02f, -6.19347878e-02f, -1.50441602e-01f, -6.22802302e-02f, -2.72690833e-01f, 1.70612469e-01f, -8.93164054e-02f, 1.72845557e-01f, -5.21119609e-02f, -1.09005775e-02f,
  6.17417544e-02f, 4.24639694e-02f, 3.09413075e-02f, -5.29774278e-02f, 1.79530308e-02f, 1.40924960e-01f, -7.61142978e-03f, 7.80375376e-02f, -5.14297187e-02f, 5.15073687e-02f,
  1.67969048e-01f, 2.28565648e-01f, -1.47887915e-01f, 3.22259851e-02f, -1.59967631e-01f, -1.22826330e-01f, -1.85519695e-01f, -1.33656606e-01f, -2.05184966e-02f, 3.17476183e-01f,
  -1.11446820e-01f, 4.50421497e-02f, -3.62059809e-02f, 9.61195529e-02f, 2.61801342e-03f, -3.30496341e-01f, 1.88177407e-01f, 1.82831228e-01f, 2.55671054e-01f, 1.94626674e-03f,
  -7.37272650e-02f, -1.44003287e-01f, 1.86659962e-01f, 1.41594680e-02f, 2.89719440e-02f, 1.28142331e-02f, 1.84245229e-01f, -2.26494581e-01f, -1.87372953e-01f, 2.22463787e-01f,
  -1.60748679e-02f, -1.72197133e-01f, -2.23366305e-01f, -3.26722413e-01f, 1.82623491e-01f, 8.87662545e-02f, -2.23281860e-01f, 2.01981038e-01f, 1.24699607e-01f, 3.30258787e-01f,
  -4.96580273e-01f, -4.31842217e-03f, -2.39251330e-01f, 1.56880572e-01f, 2.82820344e-01f, 2.02752724e-01f, 3.54741402e-02f, 1.52754784e-02f, -1.21684998e-01f, -1.42398085e-02f,
  -2.18053591e-02f, -5.58102354e-02f, 4.24010843e-01f, 2.50403106e-01f, -2.04287574e-01f, -3.01477641e-01f, -3.03812504e-01f, 3.39326948e-01f, -2.56359518e-01f, -3.86412516e-02f,
  -1.37201279e-01f, 4.20558453e-01f, -9.18214843e-02f, -1.81429327e-01f, -2.89597195e-02f, 4.56229523e-02f, -1.44336760e-01f, 6.24601357e-02f, 1.95810854e-01f, -7.85245374e-02f,
  -1.51731014e-01f, 2.73876395e-02f, 1.60413027e-01f, -1.81452706e-01f, -2.33857781e-01f, 1.66077074e-02f, 1.39935225e-01f, -1.53702959e-01f, 7.33945519e-02f, 8.66711661e-02f,
  -1.57855272e-01f, 1.92358747e-01f, -1.24460487e-02f, 1.58772409e-01f, -2.16488555e-01f, -1.66835934e-01f, 7.53564667e-03f, -1.63556173e-01f, 3.78383934e-01f, -4.52518761e-02f,
  -2.29662657e-01f, -1.30025968e-01f, -2.02823460e-01f, -1.72414154e-01f, -6.58001974e-02f, 2.78704435e-01f, 4.51971032e-02f, -1.24942906e-01f, 1.23391129e-01f, 3.10727268e-01f,
  -1.29690409e-01f, -1.75488070e-01f, 1.25617534e-01f, 1.25787929e-01f, 2.21606344e-01f, -8.68003964e-02f, -1.10483207e-01f, -1.00876309e-01f, -8.82712230e-02f, -1.02820374e-01f,
  -8.69418755e-02f, -2.14829385e-01f, -1.18287586e-01f, 2.30257399e-02f, -4.86358292e-02f, -2.81695724e-01f, -1.80875421e-01f, -2.13425141e-02f, -1.63645521e-01f, 3.59979868e-01f,
  -1.24629572e-01f, -1.59618735e-01f, 3.71830702e-01f, 3.19520503e-01f, 6.91943476e-03f, -4.07274067e-03f, 1.73399165e-01f, 9.95999053e-02f, 4.50392753e-01f, 9.65696052e-02f,
  3.83873172e-02f, -1.85488164e-02f, -4.58129421e-02f, 3.12080175e-01f, 1.01490945e-01f, -8.51635181e-04f, 6.27969205e-03f, -3.45780700e-01f, -4.78138663e-02f, -2.73135781e-01f,
  4.20895182e-02f, -1.08365595e-01f, 3.93658392e-02f, 1.83502398e-02f, -6.25539944e-02f, -2.25198463e-01f, -2.32503876e-01f, -1.78536829e-02f, -1.17244937e-01f, -2.29716420e-01f,
  -5.09246029e-02f, 1.94031969e-02f, 5.81956580e-02f, -5.02083711e-02f, -1.85368702e-01f, 4.32643704e-02f, -1.58436134e-01f, 1.68078303e-01f, -2.17717402e-02f, -1.56485997e-02f,
  -1.27285674e-01f, -1.30042717e-01f, 3.82178336e-01f, -1.23519726e-01f, -2.62022883e-01f, 9.47873890e-02f, -1.87861606e-01f, 4.35481258e-02f, -7.67189339e-02f, 3.01532239e-01f,
  3.85369599e-01f, 2.81873047e-01f, 2.95559466e-01f, 1.69623509e-01f, 3.82317722e-01f, 2.99537152e-01f, -9.83059853e-02f, 2.34640002e-01f, 7.93230236e-02f, 3.68042648e-01f,
  5.87282293e-02f, 2.85285205e-01f, -2.97052432e-02f, 2.11594880e-01f, -4.54276390e-02f, 2.79027581e-01f, 2.53780901e-01f, -1.17889836e-01f, 1.02645174e-01f, -2.22361973e-03f,
  -2.27766521e-02f, -8.26433953e-03f, -1.13672115e-01f, -1.08128466e-01f, -5.36644012e-02f, -6.15367629e-02f, -1.76635459e-01f, -1.41328573e-01f, -1.26283303e-01f, -7.98955560e-02f,
  -1.28033474e-01f, -3.59276719e-02f, -1.36890903e-01f, 5.23557365e-02f, -7.18083531e-02f, -5.34212589e-02f, -1.76296514e-02f, 1.57178894e-01f, -1.24318175e-01f, 2.18586382e-02f,
  -1.39356837e-01f, 4.30235118e-02f, 4.44143623e-01f, 1.76497087e-01f, -7.91795831e-03f, 5.14835864e-02f, 6.15207339e-03f, -8.94452184e-02f, -1.66086674e-01f, 1.22249261e-01f,
  -3.86305936e-02f, 1.64959177e-01f, -5.72335310e-02f, -8.20524469e-02f, -8.53407942e-03f, -1.05143487e-01f, 2.90989310e-01f, 3.08214813e-01f, -1.77247003e-01f, 8.93362984e-02f,
  1.96073011e-01f, 2.07482755e-01f, -3.24902236e-02f, -1.62802279e-01f, 1.90352708e-01f, -8.79332274e-02f, 1.78882495e-01f, -1.80802658e-01f, 1.17029538e-02f, -4.44816090e-02f,
  -1.95530578e-02f, -3.30136120e-02f, -1.03535511e-01f, -5.44289201e-02f, -6.52306750e-02f, -2.41671726e-02f, -1.22265816e-02f, 2.03225553e-01f, -6.86755404e-02f, -1.61055788e-01f,
  2.07028776e-01f, 2.34214336e-01f, 1.97680846e-01f, 8.42407644e-02f, 5.63608468e-01f, 2.09739394e-02f, -1.75976753e-01f, -1.77178413e-01f, -3.05455644e-02f, -8.35992843e-02f,
  1.33123875e-01f, -1.68547392e-01f, 2.10273385e-01f, 1.76930636e-01f, -1.17954746e-01f, 6.58878088e-02f, 6.92651495e-02f, -6.86517283e-02f, -9.25481319e-02f, -5.67060374e-02f,
  -9.00009051e-02f, -1.61552727e-01f, 7.83016756e-02f, -1.12721091e-02f, -3.76277119e-01f, 2.80979760e-02f, -9.60933119e-02f, -2.43245646e-01f, -2.67953217e-01f, -3.27401832e-02f,
  -7.64998794e-02f, -1.48911580e-01f, -8.35162178e-02f, -6.82885274e-02f, -1.08650394e-01f, -1.17590047e-01f, -1.56276599e-01f, -1.69475794e-01f, 9.02156085e-02f, 1.02222167e-01f,
  -2.35368803e-01f, 5.41295670e-02f, -1.48601085e-01f, -1.20122366e-01f, 4.28540260e-01f, 7.88854957e-02f, 1.68682337e-01f, 9.59177911e-02f, -1.74520105e-01f, -3.17110479e-01f,
  1.16476782e-01f, -1.06843248e-01f, -2.75417954e-01f, -3.00702006e-01f, -2.08949819e-01f, -3.71850841e-02f, 1.51908308e-01f, 3.62500787e-01f, 1.12289074e-03f, -3.20799887e-01f,
  -1.02787614e-01f, 9.62309912e-02f, 2.89647460e-01f, 9.10057500e-02f, -6.00664765e-02f, 2.00927211e-03f, -2.81576589e-02f, -9.20029432e-02f, 2.21895099e-01f, -1.89383440e-02f,
  -4.11186256e-02f, 2.38339096e-01f, 9.64136049e-03f, 5.48079610e-02f, 4.60598990e-02f, 1.99065015e-01f, 1.83909442e-02f, 1.80120423e-01f, -1.79528398e-03f, 3.84537935e-01f,
  2.58171529e-01f, 1.68238163e-01f, 1.13220371e-01f, 4.78655137e-02f, -1.45810515e-01f, 6.42382056e-02f, 3.74244712e-02f, 4.12597619e-02f, 9.87095833e-02f, -1.47882953e-01f,
  -1.55556291e-01f, -6.73417151e-02f, -1.06516145e-01f, 1.49338339e-02f, -4.75521237e-02f, 3.22026283e-01f, 5.06073952e-01f, 1.35043651e-01f, 1.96968749e-01f, -1.35534164e-02f,
  1.70273364e-01f, -1.05883449e-01f, 2.04004273e-02f, -1.50318772e-01f, 1.08583248e-03f, -3.76836434e-02f, 7.50426054e-02f, 1.25703022e-01f, -8.03832337e-03f, -5.83801121e-02f,
  -6.83059096e-02f, -7.96685666e-02f, -9.31767970e-02f, 3.51131558e-02f, -1.13871612e-01f, -1.93265334e-01f, -9.48463157e-02f, -1.77162588e-01f, -1.87065735e-01f, -1.90766573e-01f,
  -7.01145232e-02f, 3.75938892e-01f, -3.31886113e-02f, -9.93688032e-02f, 2.54097283e-01f, -1.76874772e-01f, 3.12718712e-02f, 6.09366953e-01f, -8.84161517e-02f, -9.11508426e-02f,
  -1.01645194e-01f, -8.63281265e-02f, -5.75840473e-02f, -2.42681596e-02f, -1.11146674e-01f, -9.19710100e-02f, -2.01133007e-04f, 1.54500216e-01f, 4.19636846e-01f, 5.95607199e-02f,
  -1.71805918e-01f, -1.31012453e-02f, 1.07465230e-01f, -1.97869614e-01f, 1.18307836e-01f, 7.14899376e-02f, 8.98751020e-02f, -7.99534842e-02f, 2.95012653e-01f, 1.99076295e-01f,
  -8.39592293e-02f, 7.08504096e-02f, 2.85261691e-01f, 1.49273574e-01f, 4.27686609e-02f, 9.72980782e-02f, 2.53371373e-02f, 1.47156522e-01f, -1.37683302e-01f, -1.63917914e-01f,
  2.24590123e-01f, 2.27469489e-01f, -3.26962173e-02f, 1.64040938e-01f, 8.44541788e-02f, 1.37484251e-02f, -5.04825711e-02f, 8.33167061e-02f, -1.72049791e-01f, -1.54244408e-01f,
  -1.19786240e-01f, -2.77227964e-02f, -1.72544196e-01f, -9.47921053e-02f, -1.09474018e-01f, -3.12165231e-01f, 2.89236605e-01f, 8.23310539e-02f, -1.23932622e-01f, -2.16761604e-01f,
  -8.41261223e-02f, -5.12167096e-01f, 3.34807456e-01f, 4.13148612e-01f, 5.27983665e-01f, -2.75215477e-01f, -1.69138074e-01f, -2.73136675e-01f, -1.48554236e-01f, 2.13868633e-01f,
  -2.49572331e-03f, 1.67213120e-02f, -6.85262354e-03f, 1.24470860e-01f, -2.56675947e-02f, -8.78394991e-02f, -1.10986196e-01f, 1.20248891e-01f, 6.61479384e-02f, 1.60342485e-01f,
  -4.62909788e-02f, 1.73789904e-01f, -4.33378853e-02f, 8.74282420e-02f, -7.55037591e-02f, 1.72887035e-02f, -2.26920933e-01f, 5.07443361e-02f, 3.64130914e-01f, -3.86038646e-02f,
  -1.23434849e-01f, -8.41252580e-02f, 4.47046459e-02f, -6.71880767e-02f, 3.42869684e-02f, 1.62329689e-01f, -5.20281903e-02f, -1.58356085e-01f, 9.71936341e-03f, -1.44570485e-01f,
  -6.55637160e-02f, -3.09455935e-02f, 1.12253278e-02f, -2.57922858e-01f, 2.28353515e-02f, 2.53096253e-01f, 1.57170966e-01f, 7.97002837e-02f, -6.15381338e-02f, -2.15947375e-01f,
  1.43800871e-02f, 2.22885102e-01f, -9.03978273e-02f, -1.47704884e-01f, 4.29936558e-01f, -7.08588585e-02f, -2.25670204e-01f, -1.59686163e-01f, -1.33583590e-01f, 1.66920304e-01f,
  -4.13339883e-02f, 7.27759600e-01f, 8.49742368e-02f, 1.25841320e-01f, 2.79109597e-01f, -1.39707729e-01f, -1.51689321e-01f, 8.12542718e-03f, -5.86568117e-02f, 3.00774053e-02f,
  -7.21585080e-02f, 2.37025827e-01f, 2.18158916e-01f, -3.18466544e-01f, 1.35680482e-01f, 1.51597068e-01f, 1.89159848e-02f, 9.32158679e-02f, -2.64866538e-02f, 8.59907940e-02f,
  5.65139530e-03f, -1.35922343e-01f, -1.62714776e-02f, 3.08817364e-02f, -1.33548170e-01f, 1.75202876e-01f, -1.33315727e-01f, -1.67825758e-01f, -1.80253386e-01f, -1.23252317e-01f,
  1.69460714e-01f, -2.05174610e-01f, -2.15738025e-02f, 2.85640620e-02f, 1.59435079e-01f, 6.45137252e-03f, 1.59329578e-01f, 2.76398718e-01f, 9.52620655e-02f, 8.22601542e-02f,
  2.45895520e-01f, 1.39921829e-01f, 1.91879109e-01f, 6.84175789e-02f, 2.28113681e-01f, -3.28075051e-01f, 6.69063032e-02f, -4.95011583e-02f, -1.56196848e-01f, 3.00116479e-01f,
  1.91766977e-01f, 1.57753378e-01f, -6.20828718e-02f, 1.08915545e-01f, 7.17164576e-02f, 9.13824290e-02f, -4.23500776e-01f, 1.18895518e-02f, 3.48579228e-01f, 1.86442673e-01f,
  2.88375109e-01f, 1.80910811e-01f, 2.28991136e-01f, -1.14523716e-01f, -2.62747616e-01f, 3.31196226e-02f, 8.46566632e-02f, -1.19315267e-01f, 2.85469890e-01f, 3.20719033e-01f,
  5.50582290e-01f, 6.61489144e-02f, -2.28982076e-01f, -4.79795873e-01f, 1.06061697e-01f, 3.44151109e-02f, 2.37417981e-01f, -2.67444789e-01f, -1.83727697e-01f, 1.03920065e-01f,
  8.10373668e-03f, -7.71755055e-02f, 2.89069921e-01f, -1.57498568e-01f, -1.41966373e-01f, 1.09916441e-01f, 5.72625771e-02f, -1.21594351e-02f, -1.12718925e-01f, -9.29190293e-02f,
  3.82668793e-01f, -2.05420390e-01f, 1.01918824e-01f, -8.15548152e-02f, 2.26575002e-01f, 5.31223938e-02f, -1.11251250e-01f, -2.72488952e-01f, 2.18686890e-02f, 1.51866209e-02f,
  3.21106374e-01f, 2.73249764e-03f, 2.44071171e-01f, 1.19850710e-01f, 1.35310337e-01f, -4.92630191e-02f, -1.23771615e-01f, -2.03218088e-02f, -1.14230931e-01f, 2.98854653e-02f,
  -6.39108941e-02f, -1.61841493e-02f, 8.37020576e-02f, -1.38060063e-01f, -2.64111847e-01f, -2.19053812e-02f, 3.24675930e-04f, 2.10093081e-01f, 5.12999482e-02f, 3.15712094e-02f,
  -1.04247905e-01f, -1.10744074e-01f, 1.04654655e-01f, -1.27656505e-01f, -9.38610584e-02f, -1.39763504e-01f, 2.56980777e-01f, -3.96648459e-02f, -1.58932418e-01f, -2.59644598e-01f,
  -1.23618647e-01f, -2.41045922e-01f, -1.46823153e-01f, 4.61808562e-01f, 1.01572871e-01f, -6.38956204e-02f, 1.60099477e-01f, -6.54190555e-02f, -8.71356297e-03f, 9.98389572e-02f,
  -1.81572959e-01f, 2.25445218e-02f, -9.40627381e-02f, -6.32559359e-02f, -6.33041635e-02f, -4.05858532e-02f, -2.67978683e-02f, -1.45089909e-01f, -1.92547366e-01f, 2.41577085e-02f,
  3.66344064e-01f, 7.45765716e-02f, -3.18809710e-02f, 3.27600949e-02f, -2.82832325e-01f, -5.56320371e-03f, 1.33764014e-01f, 6.78318515e-02f, 6.21149428e-02f, 2.06855297e-01f,
  1.57982782e-01f, 2.78394222e-02f, 1.47585515e-02f, 2.42219776e-01f, 8.53269324e-02f, 1.16898932e-01f, 1.16467245e-01f, 1.41356066e-01f, -4.64349166e-02f, 4.87669595e-02f,
  -1.16726443e-01f, -3.78653482e-02f, -3.40062886e-01f, -1.07183345e-01f, 7.72908796e-03f, 9.88312438e-03f, -1.01826265e-02f, -6.61284402e-02f, 1.90037549e-01f, -1.71341881e-01f,
  -6.19266108e-02f, -6.12079203e-02f, 8.69274735e-02f, -6.71747699e-02f, 1.34486675e-01f, -1.00140549e-01f, 1.18589327e-01f, 1.17904492e-01f, 2.49484792e-01f, -1.59631073e-01f,
  1.25083536e-01f, 1.81635693e-01f, -1.24534041e-01f, 2.11046278e-01f, 1.20579459e-01f, 3.35888505e-01f, 2.89994925e-01f, 3.60609561e-01f, 1.85388073e-01f, -3.06986272e-02f,
  -1.94760293e-01f, -2.97870785e-01f, -2.35229820e-01f, -3.69343273e-02f, 3.58918279e-01f, 1.57966852e-01f, 1.85140193e-01f, 2.36896127e-01f, 1.71416119e-01f, 3.54549177e-02f,
  -7.14322254e-02f, -8.82525817e-02f, -1.36453748e-01f, 2.56947458e-01f, 1.70777306e-01f, -1.50221586e-01f, 3.70366484e-01f, -2.35118628e-01f, -1.63245499e-01f, -1.61377668e-01f,
  -2.62158364e-01f, -1.05745129e-01f, -1.71491265e-01f, 7.97216147e-02f, -2.88079698e-02f, 1.57008037e-01f, -6.15283810e-02f, 2.72717118e-01f, -1.95820346e-01f, 2.75737435e-01f,
  -1.52878031e-01f, -2.15501234e-01f, -1.03719883e-01f, 7.22041875e-02f, -2.27504358e-01f, 2.98261307e-02f, 2.66471505e-01f, 2.00404413e-03f, -1.53285965e-01f, -1.11359067e-01f,
  -2.59863257e-01f, 2.93966550e-02f, -7.74109215e-02f, 3.36441487e-01f, -1.68675900e-01f, -1.58474758e-01f, -1.95598472e-02f, 5.69817603e-01f, 1.46294502e-03f, -1.71066985e-01f,
  -2.23356262e-01f, -3.94952409e-02f, 9.50402096e-02f, 7.97359571e-02f, -1.20597631e-01f, -6.41648695e-02f, -2.24728644e-01f, -1.34396359e-01f, 2.36174330e-01f, 2.88324684e-01f,
  1.19399481e-01f, 1.51685804e-01f, 2.23584488e-01f, -6.36494532e-02f, -1.94185361e-01f, -7.38237351e-02f, -7.73053244e-02f, 2.54400037e-02f, -8.45886767e-02f, 4.02862400e-01f,
  3.70622292e-04f, -1.40878648e-01f, -9.74808782e-02f, -2.55567883e-03f, -1.00925371e-01f, -1.69927642e-01f, 4.89488281e-02f, 3.13988000e-01f, -1.84375390e-01f, 9.83108766e-03f,
  -8.51551816e-03f, -6.31457269e-02f, 2.65938759e-01f, -2.15323165e-01f, 1.17227145e-01f, -2.46619359e-02f, -1.32714257e-01f, -2.25780547e-01f, -2.63996303e-01f, -1.29024804e-01f,
  1.24365008e-02f, 2.26291772e-02f, -1.06395163e-01f, 7.26875067e-02f, -2.73177415e-01f, -1.25431135e-01f, -7.17030466e-02f, -2.97050141e-02f, -5.22383600e-02f, -6.86220825e-02f,
  8.27118978e-02f, 2.32130755e-02f, -3.17088924e-02f, -6.82263300e-02f, -1.54842377e-01f, 6.37833327e-02f, -9.03950855e-02f, -9.20153037e-02f, 7.73886626e-04f, -6.92363977e-02f,
  -2.87782252e-01f, 1.03555188e-01f, 8.16968381e-02f, 2.90563732e-01f, 1.11817412e-01f, 1.57794788e-01f, 6.62679002e-02f, -1.40822068e-01f, 4.44953404e-02f, 1.29565597e-01f,
  -2.68898487e-01f, 6.27619624e-02f, -6.77371304e-03f, -2.12255776e-01f, -1.21785246e-01f, 1.03096992e-01f, -9.74005274e-03f, -2.88496345e-01f, 8.76629055e-02f, -2.08033934e-01f,
  1.48104757e-01f, 3.52418870e-02f, 7.35652670e-02f, 4.76807076e-03f, 9.18724611e-02f, -3.87546510e-01f, 5.75013719e-02f, -8.03966671e-02f, -6.33589551e-02f, 9.45467222e-03f,
  5.44586837e-01f, -8.29064101e-03f, -6.79486543e-02f, 2.10063234e-01f, 4.35328633e-02f, -8.76559839e-02f, 7.92414695e-02f, 1.26766980e-01f, -6.02666661e-02f, 8.63823444e-02f,
  5.74915707e-02f, 6.68709492e-03f, 1.35327011e-01f, 3.30572687e-02f, -3.70460711e-02f, 1.66905403e-01f, -1.28465533e-01f, -7.15887453e-03f, -9.14363340e-02f, -1.12555169e-01f,
  2.00145524e-02f, -1.13046475e-01f, 2.27088302e-01f, 6.06064796e-02f, 2.10772932e-01f, -9.72296670e-02f, -7.59106874e-02f, 4.69881743e-02f, 1.96503960e-02f, 3.50495502e-02f,
  9.15903524e-02f, 2.43197214e-02f, 1.23349406e-01f, -1.29364422e-02f, -1.46383168e-02f, -6.43357858e-02f, -9.67636555e-02f, 1.54934943e-01f, 1.30750299e-01f, -3.27256434e-02f,
  -1.09759308e-01f, -1.26648396e-01f, -2.11226121e-02f, 3.47349912e-01f, -1.37260228e-01f, 8.30534101e-03f, -7.85814151e-02f, -2.03790814e-02f, -1.66903242e-01f, -5.76916710e-02f,
  -3.53161246e-02f, 6.35258555e-02f, 7.21319079e-01f, 2.66242564e-01f, 4.24107969e-01f, -4.44732420e-02f, 3.76868546e-02f, -1.12766713e-01f, -6.66064098e-02f, -1.02399299e-02f,
  -5.47148213e-02f, -1.81535825e-01f, -8.46297853e-03f, -2.28530895e-02f, 2.83962023e-02f, -1.00533970e-01f, -1.24503583e-01f, -1.03512704e-01f, 3.96841057e-02f, 1.72537155e-02f,
  -1.08404130e-01f, -1.26633480e-01f, -1.52300015e-01f, -1.28086612e-01f, -8.28258321e-02f, -2.89065480e-01f, 6.08165525e-02f, -1.02825537e-01f, -7.49241114e-02f, -2.70413607e-01f,
  -1.80519614e-02f, 3.53218578e-02f, 3.33016925e-02f, 1.37539888e-02f, -7.04870075e-02f, -1.12826318e-01f, 8.15858245e-02f, -3.65375467e-02f, 3.99799086e-02f, 2.42054146e-02f,
  -2.93448549e-02f, -4.55686823e-02f, 3.69334221e-02f, 1.35680083e-02f, -1.23893119e-01f, -1.61473393e-01f, -5.33155277e-02f, 2.26344839e-02f, 6.98118731e-02f, -2.64210314e-01f,
  3.26916695e-01f, -7.35922530e-02f, -8.64008367e-02f, -2.57294565e-01f, -3.12425554e-01f, -1.89615011e-01f, -1.72239617e-01f, 3.97354364e-02f, -7.74629638e-02f, -9.48923081e-02f,
  1.56175867e-01f, -6.63614646e-02f, -2.26398692e-01f, -2.02148587e-01f, -4.53078263e-02f, -3.00993532e-01f, -2.64311075e-01f, -4.77827452e-02f, 1.33062107e-02f, 1.45285934e-01f,
  4.19221371e-01f, 2.24649385e-02f, -2.70713642e-02f, 1.93262808e-02f, 4.24376190e-01f, 8.99159163e-02f, 2.12846890e-01f, -2.00377908e-02f, -8.97864103e-02f, 6.38206750e-02f,
  -5.27335890e-03f, -7.33879134e-02f, -1.20571047e-01f, -1.17954157e-01f, -6.04483113e-02f, -3.26521061e-02f, 2.37667978e-01f, -6.83083311e-02f, -1.06331199e-01f, -1.72464490e-01f,
  -1.67338878e-01f, -5.12276478e-02f, 2.52993256e-01f, 1.63244344e-02f, -6.98443353e-02f, -1.44441038e-01f, 1.88409939e-01f, 7.97955394e-02f, 5.31597994e-02f, 4.63310406e-02f,
  3.70324254e-01f, 1.02085108e-03f, -1.20428711e-01f, 8.08446631e-02f, 1.44306809e-01f, 1.52128655e-02f, -1.51827365e-01f, 6.85983524e-02f, -6.18561581e-02f, -1.14802107e-01f,
  -3.63698527e-02f, 2.52364486e-01f, -2.12620944e-02f, -1.28590643e-01f, -1.16144836e-01f, 4.76082787e-02f, -1.44251168e-01f, 3.32520716e-02f, 2.83027768e-01f, -1.58033773e-01f,
  -7.72335231e-02f, -1.09038778e-01f, -1.29120335e-01f, -7.61409476e-02f, 1.97876915e-01f, -4.12469693e-02f, -5.01449890e-02f, 1.16954008e-02f, -9.31373760e-02f, -1.24648154e-01f,
  -1.43051296e-01f, -9.13772136e-02f, -3.96338627e-02f, 1.43844064e-03f, -1.34535417e-01f, -1.85997561e-01f, 4.65064108e-01f, -3.97050008e-03f, -1.01344228e-01f, -1.31945357e-01f,
  -1.95271447e-02f, -2.43999977e-02f, -3.78114171e-02f, -1.83617979e-01f, -1.24063663e-01f, 1.86918620e-02f, 5.48296273e-01f, 4.40926990e-03f, -7.28665143e-02f, 1.99178874e-01f,
  2.50671476e-01f, -4.54305634e-02f, -2.99170949e-02f, 1.94742844e-01f, -1.99511740e-02f, 2.46795956e-02f, 1.41970903e-01f, 7.92844966e-02f, -3.35074693e-01f, -6.06262423e-02f,
  -1.66437879e-01f, -6.76450366e-03f, 1.32681271e-02f, -1.89008862e-01f, -5.56260534e-02f, 2.84740441e-02f, 7.16816634e-02f, 8.42976719e-02f, -3.11162267e-02f, 1.71423733e-01f,
  1.96037050e-02f, 2.29209941e-02f, 6.64559845e-03f, 1.16448455e-01f, -1.07294349e-02f, 1.22903459e-01f, -3.70917171e-02f, -1.58750445e-01f, -4.59150784e-02f, 4.84981716e-01f,
  9.15789902e-02f, 7.80726224e-02f, -3.65857631e-01f, -5.73134005e-01f, -1.87979966e-01f, -4.11489099e-01f, 2.61361241e-01f, 1.92800730e-01f, -3.28623325e-01f, -2.00773776e-01f,
  7.28510171e-02f, 2.49691084e-01f, 1.37201041e-01f, 1.73025027e-01f, 1.71707287e-01f, -7.54374862e-02f, 2.21627861e-01f, -1.82057470e-01f, -8.25560242e-02f, 1.02447428e-01f,
  2.50272274e-01f, -5.57463706e-01f, 3.82694975e-03f, -1.47745404e-02f, 9.83731449e-02f, -1.24290258e-01f, -1.53959498e-01f, 1.31395655e-02f, 3.85276861e-02f, -1.40155539e-01f,
  1.28036048e-02f, -4.92144339e-02f, -5.08384444e-02f, 7.55951256e-02f, -6.43027797e-02f, -1.50475383e-01f, -1.92600101e-01f, -6.01225644e-02f, 9.03867334e-02f, 4.85830277e-01f,
  -1.80869713e-01f, 3.93983955e-03f, 2.00982317e-01f, 1.46064144e-02f, -1.51762860e-02f, -1.38764000e-02f, -1.19124390e-02f, 2.32147984e-02f, -2.20255330e-02f, 3.45183998e-01f,
  2.55430490e-01f, -6.20831503e-03f, -1.94535226e-01f, -9.19022486e-02f, -2.39712045e-01f, -5.81278950e-02f, -1.94331557e-01f, -1.28036514e-01f, -7.34844729e-02f, -2.01621488e-01f,
  4.90723103e-02f, 3.60876501e-01f, -3.64700481e-02f, -3.99759449e-02f, 4.93242331e-02f, 1.99449956e-02f, -1.68690100e-01f, 2.33478233e-01f, 3.98692191e-02f, -1.24986209e-02f,
  4.98339027e-01f, 2.97566056e-02f, 2.85526421e-02f, 7.11476728e-02f, -7.66504705e-02f, 1.24534257e-01f, -1.92024425e-01f, 3.75302196e-01f, -1.75847765e-02f, -1.81249276e-01f,
  -4.30239439e-02f, -1.56524345e-01f, 2.68742293e-02f, -1.75055694e-02f, -9.38701853e-02f, -1.96609482e-01f, 1.14058502e-01f, 1.09094687e-01f, 9.18515399e-02f, 3.74642581e-01f,
  -5.04105166e-02f, 3.54963511e-01f, -2.44754016e-01f, 3.19093727e-02f, -2.52357516e-02f, -5.34308963e-02f, -1.76878870e-01f, -3.89292017e-02f, 2.63977814e-02f, -4.49207649e-02f,
  9.34110582e-03f, 9.29807201e-02f, 4.94405068e-02f, 3.86145636e-02f, 3.74866128e-02f, 1.36262193e-01f, -2.61663347e-01f, 8.45302343e-02f, 1.51164338e-01f, 4.67762165e-02f,
  7.84391463e-02f, 9.50344577e-02f, 2.74377335e-02f, -1.96564663e-02f, 2.17139423e-01f, -2.47225687e-01f, 8.04622322e-02f, 1.40623555e-01f, -2.58075178e-01f, 7.14304969e-02f,
  1.13688923e-01f, -2.72720936e-04f, 1.63952380e-01f, 1.25362560e-01f, 2.59255797e-01f, 3.58411282e-01f, 1.46268457e-01f, 1.46212175e-01f, -1.49119854e-01f, -2.60910064e-01f,
  -4.14528251e-01f, 5.49193621e-01f, 5.46908565e-02f, -2.18623936e-01f, 1.29614949e-01f, -4.14442420e-01f, 1.55251488e-01f, -1.12028934e-01f, -2.74851531e-01f, 1.05105817e-01f,
  -3.86195689e-01f, -2.83873290e-01f, 1.93860546e-01f, 4.99210060e-01f, -6.45725727e-02f, -1.56685650e-01f, -2.67469615e-01f, -1.62324652e-01f, 7.32071325e-02f, 1.04278691e-01f,
  -1.35005146e-01f, -8.44507292e-02f, -1.38049930e-01f, 2.23895669e-01f, -1.38024852e-01f, -1.54513776e-01f, -1.40426144e-01f, 1.11182339e-01f, 8.67967978e-02f, 1.03209406e-01f,
  -1.40763998e-01f, 2.36384585e-01f, 1.22469008e-01f, 3.16157520e-01f, -1.49470523e-01f, 5.81629388e-02f, -1.70684442e-01f, -2.05678165e-01f, 7.88405817e-03f, -9.73436162e-02f,
  -2.06477746e-01f, -1.39143869e-01f, -5.88190854e-02f, -2.29536295e-01f, 1.54596850e-01f, 1.41049614e-02f, -2.25821733e-01f, -4.49077375e-02f, -1.50513276e-02f, 9.58455876e-02f,
  1.43984064e-01f, 3.38257462e-01f, -2.81700999e-01f, -8.51602033e-02f, 3.60145986e-01f, 1.45838603e-01f, -1.63767815e-01f, 9.85751152e-02f, -6.32157251e-02f, -1.70652613e-01f,
  1.12336084e-01f, 3.44459303e-02f, -1.38479799e-01f, 1.20129399e-01f, -1.80314854e-01f, 2.66500056e-01f, 2.48363223e-02f, -2.28079781e-01f, -5.89506179e-02f, -8.67172629e-02f,
  -1.27238989e-01f, -2.23796698e-03f, 7.65181929e-02f, -2.20390692e-01f, -1.48807839e-01f, -1.51035354e-01f, -2.04954475e-01f, -1.54898524e-01f, 1.16033264e-01f, -3.04638464e-02f,
  3.39866690e-02f, -8.14186931e-02f, -2.55782139e-02f, -5.95766604e-02f, -7.90555179e-02f, -1.29271910e-01f, 2.23199110e-02f, -7.11439596e-03f, 6.69878572e-02f, -1.53322399e-01f,
  2.47370347e-01f, -7.96837509e-02f, -9.11918208e-02f, -1.56446937e-02f, 2.27298722e-01f, 2.18089148e-01f, -3.85959409e-02f, -6.35499433e-02f, 1.61346853e-01f, 1.03897221e-01f,
  2.98047364e-02f, 1.05926476e-03f, 5.66871278e-02f, -1.64190251e-02f, 2.30845615e-01f, -2.71026313e-01f, 7.38424584e-02f, 5.35900798e-03f, 1.38682872e-01f, -4.05937508e-02f,
  4.03501689e-02f, 6.84572458e-02f, 8.05051550e-02f, 1.35893166e-01f, 8.39570239e-02f, -5.14093041e-02f, 8.98534060e-02f, -4.03469622e-01f, 2.53086872e-02f, 1.30341742e-02f,
  2.32626917e-03f, 7.92182386e-02f, 3.94678637e-02f, 1.39446435e-02f, -1.39348492e-01f, -3.27092409e-01f, 2.29410037e-01f, -2.67899036e-01f, 4.11739826e-01f, -9.15532634e-02f,
  4.23017919e-01f, 4.03889686e-01f, -3.63154449e-02f, 2.76862651e-01f, -3.04121375e-01f, -2.84068197e-01f, -2.54351974e-01f, -2.13801473e-01f, 1.82002280e-02f, -7.76986927e-02f,
  -3.50241274e-01f, 3.70520145e-01f, -4.34147328e-01f, -2.72591889e-01f, 1.14159606e-01f, 3.57320234e-02f, 4.32448015e-02f, -8.61582235e-02f, -1.82285443e-01f, 1.73080936e-02f,
  4.41159867e-02f, -9.45236832e-02f, -4.76635620e-02f, 1.90203995e-01f, -5.64072058e-02f, -1.33334950e-01f, 2.70353645e-01f, -7.51911253e-02f, -6.96248114e-02f, 1.06681203e-02f,
  4.63825315e-01f, 3.39765707e-03f, -2.12912962e-01f, -1.14091270e-01f, -6.19171746e-02f, -1.89406589e-01f, 2.14470729e-01f, -1.11508742e-01f, 7.46536851e-02f, -6.71854019e-02f,
  -4.13188748e-02f, 2.18006913e-02f, -2.90051363e-02f, -3.31859360e-03f, -1.63522452e-01f, -7.60995522e-02f, 2.22894251e-02f, 2.85315752e-01f, -1.04161106e-01f, -1.57155469e-01f,
  1.15031518e-01f, 6.77696383e-03f, -1.12937972e-01f, -5.43825924e-02f, 1.41740516e-01f, -9.82793942e-02f, -4.94038127e-02f, -2.18286544e-01f, 2.34187804e-02f, 1.23739488e-01f,
  -2.06509158e-02f, -1.69908982e-02f, 1.56520605e-01f, -1.11964300e-01f, -1.99889734e-01f, 8.18925947e-02f, -6.70113713e-02f, -1.38763472e-01f, -4.76978831e-02f, 1.23493202e-01f,
  -5.80013432e-02f, 7.01311529e-02f, 6.35955513e-01f, 4.46591862e-02f, -1.98343061e-02f, -1.28605694e-01f, -1.90658607e-02f, 1.02893494e-01f, 5.49868979e-02f, -1.74168602e-01f,
  1.71182439e-01f, -7.10232779e-02f, -1.67628467e-01f, -1.59095570e-01f, 1.27385601e-01f, -1.18250437e-01f, -8.03200752e-02f, -3.94381061e-02f, -6.43296912e-02f, -1.42710313e-01f,
  -3.10077518e-02f, 2.45986611e-01f, -8.84174109e-02f, 7.00011253e-02f, -1.05576612e-01f, 1.46621078e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.04265860e-02f, -7.45884553e-02f, -3.71515937e-02f, 8.45564436e-03f, 5.04138619e-02f, 8.12938884e-02f, 5.19658774e-02f, -1.19581856e-02f, -9.69234556e-02f, 3.18570584e-02f,
  8.06934983e-02f, 5.48079759e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    