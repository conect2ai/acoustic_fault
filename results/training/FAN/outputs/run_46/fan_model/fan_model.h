/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.90613890e-03f, -3.49708229e-01f, 4.67798710e-02f, 7.89544061e-02f, -7.18540028e-02f, -1.81528464e-01f, -1.76824510e-01f, 1.61494896e-01f, -1.76124558e-01f, -1.25199869e-01f,
  -1.24503396e-01f, -1.98874936e-01f, -1.43753886e-01f, -1.33378327e-01f, -6.68762028e-02f, -2.04923421e-01f, -2.75293682e-02f, -8.70496780e-02f, -3.04106474e-02f, 1.04911186e-01f,
  1.16336599e-01f, 3.84283601e-03f, 3.29275019e-02f, 1.77900285e-01f, 4.22524735e-02f, 2.29851723e-01f, 2.55170405e-01f, 1.10432290e-01f, 1.57104596e-01f, 4.26877581e-04f,
  8.23926926e-03f, -1.30350545e-01f, -1.73101891e-02f, 4.88227755e-02f, 8.62144306e-02f, 2.60349642e-02f, -5.90212224e-03f, 6.77615032e-02f, 3.00052599e-03f, -5.28102107e-02f,
  -6.48287237e-02f, -7.28862034e-03f, 2.43096948e-02f, -3.24053387e-03f, 9.97476093e-03f, 5.58745265e-02f, 4.73577064e-03f, -4.38424014e-02f, -3.86109315e-02f, -1.51113505e-02f,
  -7.32437521e-02f, 8.92041717e-03f, 2.30974685e-02f, -1.55448373e-02f, 4.33885679e-02f, -2.76080742e-02f, -6.62630796e-02f, 6.90548271e-02f, -1.15368459e-02f, -1.50127448e-02f,
  7.27158263e-02f, -5.04170964e-03f, 1.00963898e-02f, 1.35624222e-03f, -1.71889309e-02f, 2.58091576e-02f, -4.08572145e-02f, -3.58951725e-02f, -6.24594279e-03f, -2.08622199e-02f,
  4.85670306e-02f, -4.25624959e-02f, 6.34490997e-02f, -3.33975330e-02f, 1.32273519e-04f, 1.13227917e-02f, -2.99192090e-02f, 5.80768324e-02f, -2.23804470e-02f, -7.01169595e-02f,
  -4.94423620e-02f, 3.82553115e-02f, -2.79126782e-02f, -1.00081367e-02f, -3.09017505e-02f, 4.50357050e-02f, 6.12511002e-02f, -4.35370095e-02f, 9.92283225e-02f, -8.97353236e-03f,
  -2.28480566e-02f, 8.89915824e-02f, -3.79665382e-02f, -6.68844059e-02f, -4.78951894e-02f, 1.85649544e-02f, -4.22210507e-02f, -4.06088307e-02f, 6.46166503e-02f, 1.96512546e-02f,
  1.11251317e-01f, 3.29154246e-02f, -5.52622117e-02f, 5.75094707e-02f, 4.03637439e-02f, -8.25402234e-03f, -5.65358065e-03f, 4.57853749e-02f, 1.21245474e-01f, 4.58769361e-03f,
  8.59527662e-02f, 2.43811104e-02f, -1.27099669e-02f, 3.04133166e-02f, 1.19004892e-02f, -3.65217254e-02f, 5.44033721e-02f, -9.27643292e-03f, -7.15346960e-03f, -3.67543958e-02f,
  4.63854730e-01f, -2.32205153e-01f, -1.59847930e-01f, 1.55896842e-01f, -2.42418461e-02f, 2.29160930e-03f, 9.80323274e-03f, -1.55511657e-02f, 1.82099953e-01f, -1.70484602e-01f,
  1.41433939e-01f, -2.88012084e-02f, 6.62311465e-02f, -8.05872977e-02f, 4.66230482e-01f, 7.14131296e-02f, 2.17249766e-01f, 8.31517279e-02f, 3.67308110e-02f, 3.22741531e-02f,
  8.31797644e-02f, 4.50730398e-02f, -1.79585949e-01f, 2.31993329e-02f, -8.56906101e-02f, -1.04581572e-01f, 9.49555039e-02f, -6.78404272e-02f, 1.22472532e-02f, 6.63215294e-02f,
  -2.92351283e-02f, -7.83217400e-02f, -2.47920424e-01f, 1.32784303e-02f, 3.33987623e-02f, 2.21475679e-02f, -7.89870974e-03f, 4.25831601e-02f, -3.11798579e-03f, -2.01663189e-03f,
  2.09275866e-04f, 4.08204906e-02f, -1.60918832e-02f, 3.91654633e-02f, -3.82782966e-02f, -3.04665081e-02f, -1.22268088e-01f, -1.03052087e-01f, -5.60179316e-02f, -8.91605690e-02f,
  -1.34446681e-01f, -6.00906834e-02f, -2.94909999e-02f, -3.07959281e-02f, -2.39176098e-02f, 2.12484482e-03f, -2.76105898e-03f, 2.80549359e-02f, -2.68538613e-02f, 5.14511988e-02f,
  8.74388963e-02f, 1.03365816e-01f, -4.08223048e-02f, 1.56706793e-03f, 6.64708763e-02f, 1.06946770e-02f, 1.92769486e-02f, -1.44689577e-03f, 1.01247663e-02f, 5.43641150e-02f,
  5.01491763e-02f, 5.81852021e-03f, 8.75204522e-03f, 1.25093991e-02f, 4.27731089e-02f, -6.87733246e-03f, -3.08847171e-03f, 3.93418707e-02f, -1.63860060e-02f, -1.91046726e-02f,
  5.76994903e-02f, 9.37820226e-02f, -1.80157702e-02f, 4.42311801e-02f, 1.14908582e-02f, -2.58447584e-02f, 1.00725023e-02f, -1.84467845e-02f, -6.60720165e-04f, 8.18376020e-02f,
  3.24092776e-01f, 4.43006545e-01f, -1.11168614e-02f, 3.32511291e-02f, -1.68313552e-02f, -6.89734966e-02f, 7.02832043e-02f, -5.36391549e-02f, 4.10264730e-02f, 4.73043546e-02f,
  -2.89189667e-02f, -3.24883573e-02f, 1.04767323e-01f, -3.64715117e-03f, 5.92413843e-02f, 6.55706972e-02f, 1.08018935e-01f, 9.56439972e-02f, 8.55145380e-02f, 2.09663361e-02f,
  3.35679017e-02f, 5.09106778e-02f, 3.78181227e-02f, 4.21281494e-02f, 4.11634445e-02f, -1.31334765e-02f, 3.03199869e-02f, -6.56176656e-02f, 7.57024363e-02f, -4.88977134e-02f,
  -6.08974472e-02f, 3.79297882e-01f, 9.18681175e-02f, 4.12152916e-01f, -1.20054327e-01f, 4.64771612e-04f, -8.34038295e-03f, 1.93971902e-01f, 8.24306235e-02f, -7.39340708e-02f,
  1.10381223e-01f, 3.93880252e-03f, -1.78541690e-01f, 3.97539616e-01f, 3.13142300e-01f, 2.95447290e-01f, 2.19924569e-01f, -5.56613272e-03f, 1.78286154e-02f, 3.09135765e-02f,
  1.31352082e-01f, 1.26254305e-01f, 1.56432301e-01f, 5.30268112e-03f, -5.26282564e-02f, 2.30826586e-02f, 7.84501340e-03f, -9.13039148e-02f, 1.77531585e-01f, 2.19790965e-01f,
  5.52197695e-02f, 5.71848117e-02f, -1.42589267e-02f, 1.79331657e-02f, 2.61317715e-02f, -5.16850054e-02f, -8.99035484e-02f, 8.73899609e-02f, 9.81130823e-02f, 3.10664866e-02f,
  2.29013748e-02f, -1.41152171e-02f, 1.51881784e-01f, -4.13424373e-02f, -3.78770456e-02f, 7.14433193e-02f, -2.76286947e-03f, -2.55610812e-02f, 9.46179684e-03f, 1.99177228e-02f,
  -8.81573483e-02f, 9.70333163e-03f, -3.85897309e-02f, -1.70103309e-03f, 3.57576087e-02f, 8.82644951e-03f, -4.91622165e-02f, -8.38760007e-03f, 9.95383784e-02f, -5.77223208e-03f,
  -5.76855391e-02f, -2.94185877e-02f, -3.15704904e-02f, 4.57627103e-02f, 5.21614105e-02f, -4.16042050e-03f, -2.70322021e-02f, 2.63145808e-02f, -1.04947910e-01f, 2.50590146e-02f,
  -9.83212367e-02f, 7.39819929e-02f, -2.07982510e-02f, -4.13459055e-02f, 2.83387415e-02f, -1.67002052e-03f, -1.19853392e-02f, -1.98187847e-02f, -6.38356730e-02f, -3.78849059e-02f,
  -2.75697298e-02f, 5.40274046e-02f, -5.44035360e-02f, -7.32592642e-02f, -3.90937924e-02f, -4.34974842e-02f, 5.15152253e-02f, 6.80143619e-03f, 3.56731638e-02f, -3.61014381e-02f,
  2.54239161e-02f, 1.62134811e-01f, -2.32291631e-02f, -5.75911254e-02f, -2.00645160e-02f, -6.91809226e-03f, 1.30697533e-01f, -5.99016510e-02f, -5.77460863e-02f, 1.49064111e-02f,
  -7.21484423e-02f, -1.74988192e-02f, -1.00844860e-01f, 9.99396145e-02f, -4.12834175e-02f, -2.68302392e-02f, -5.64536974e-02f, -1.25424676e-02f, 6.89939409e-02f, -1.30172186e-02f,
  1.65948961e-02f, -9.93155241e-02f, 2.03448441e-02f, -6.38672337e-02f, -1.67015344e-02f, -7.16692731e-02f, 1.86245684e-02f, 1.55791827e-02f, -7.68434629e-02f, -9.68714803e-03f,
  3.87460411e-01f, 2.30569348e-01f, -1.74332559e-01f, 3.46449137e-01f, -1.43522009e-01f, 4.75215256e-01f, 1.73426986e-01f, 9.51344967e-02f, 1.43386386e-02f, 2.02538133e-01f,
  -1.01679638e-01f, 2.02577174e-01f, -1.19161330e-01f, 2.81515628e-01f, -3.16527188e-02f, 1.41145736e-01f, 2.08205074e-01f, 1.87358603e-01f, -7.48619586e-02f, 1.25727609e-01f,
  3.51214176e-03f, 1.98725984e-01f, -7.84281455e-03f, -3.15750986e-02f, 6.75266534e-02f, -3.51508297e-02f, -1.38806492e-01f, -2.34193474e-01f, -1.22395769e-01f, -4.48635295e-02f,
  7.10388422e-02f, -3.50125432e-02f, -3.51039357e-02f, 3.80965471e-02f, -2.01734845e-02f, 2.76416596e-02f, -4.68090730e-04f, -6.25458173e-03f, -2.03949623e-02f, 6.58926228e-03f,
  -1.99967735e-02f, -1.09492401e-02f, 5.57308905e-02f, -5.16365729e-02f, -1.83578338e-02f, -8.31935406e-02f, -5.26796058e-02f, -1.11398520e-02f, 3.87585573e-02f, 2.34531034e-02f,
  -1.00413766e-02f, -5.17238164e-03f, -5.74478228e-03f, 4.11917921e-03f, -2.89694797e-02f, -1.03694666e-02f, 1.82342306e-02f, -7.04630762e-02f, -4.65434156e-02f, 3.89304124e-02f,
  7.15005398e-02f, 5.38023300e-02f, 3.50826117e-03f, -3.40768993e-02f, -6.06728345e-03f, -2.25839764e-02f, -2.31204517e-02f, 1.64616182e-02f, -2.63694543e-02f, 2.41624005e-02f,
  4.79134396e-02f, -3.43706943e-02f, 1.72208168e-03f, 5.99050224e-02f, 4.09614481e-02f, 1.11625381e-02f, 5.39046538e-04f, 2.69285403e-02f, 4.48721349e-02f, 3.31715792e-02f,
  -3.75365745e-03f, 2.27743518e-02f, 3.94392274e-02f, 3.56610976e-02f, 8.66649486e-03f, -5.42634279e-02f, -8.26450437e-03f, -1.31137914e-03f, -8.83964822e-03f, 1.78972688e-02f,
  -2.56523117e-02f, 2.59544011e-02f, 8.67135637e-03f, -8.79562180e-03f, 1.26250610e-02f, 2.82093845e-02f, 3.16222832e-02f, 3.43216881e-02f, -2.38371361e-02f, 1.22368531e-02f,
  4.02930155e-02f, 1.80464964e-02f, -3.69855464e-02f, -2.88902549e-03f, -2.25846842e-02f, 8.83647874e-02f, 6.65318035e-03f, 1.74969406e-04f, 2.41381600e-02f, -4.26814929e-02f,
  -1.69914868e-02f, 6.79606851e-03f, -5.63916459e-04f, 2.02684365e-02f, 2.72960290e-02f, 9.65388771e-03f, -9.48131923e-03f, 7.27479085e-02f, 1.41479576e-03f, -1.82676241e-02f,
  -8.53015184e-02f, 3.07940930e-01f, 3.08380544e-01f, 1.02929704e-01f, 1.71557292e-01f, 8.88720006e-02f, 1.40286490e-01f, 1.53161913e-01f, 3.58413696e-01f, -6.50661066e-02f,
  3.64366770e-02f, -8.45060945e-02f, 1.91199910e-02f, 2.18119979e-01f, -2.34414533e-01f, 1.62286341e-01f, -2.31035817e-02f, 3.08162645e-02f, 1.62728667e-01f, 1.59267231e-03f,
  8.06204975e-02f, -1.33540124e-01f, -1.13875642e-02f, 9.37331915e-02f, -5.34595996e-02f, 7.34594017e-02f, -3.65308106e-01f, 1.50990158e-01f, -2.51807831e-02f, 2.79053561e-02f,
  7.70098716e-02f, 1.77006856e-01f, 2.10504290e-02f, 6.66327253e-02f, -5.66111952e-02f, -5.63463680e-02f, -2.88583082e-03f, 1.09950416e-02f, 8.99597164e-03f, 5.83789572e-02f,
  2.81016100e-02f, -2.17462201e-02f, 4.44466695e-02f, 4.55148295e-02f, 1.03852265e-01f, 3.12486198e-02f, -6.12830371e-03f, 7.34248683e-02f, 5.78694642e-02f, -6.83485437e-03f,
  9.46377590e-02f, -4.66279462e-02f, -1.21182343e-02f, 2.37912498e-02f, -2.79494990e-02f, 2.85446458e-02f, 4.63076942e-02f, 3.05992812e-02f, -4.96666916e-02f, 2.26258561e-02f,
  -1.44768143e-02f, 8.97389371e-03f, 4.30621840e-02f, 2.86718141e-02f, -1.06861806e-02f, -1.60294492e-02f, 1.69489942e-02f, -3.05761453e-02f, 3.04002827e-03f, 2.70549227e-02f,
  -5.04100397e-02f, 2.25083088e-03f, 2.53737345e-02f, 3.21971551e-02f, -1.22420732e-02f, -1.76688358e-02f, -4.57116142e-02f, 8.28161649e-03f, -1.20572401e-02f, -2.71761827e-02f,
  9.32650641e-02f, 7.29973018e-02f, -3.94064412e-02f, -7.25001236e-03f, 6.16986640e-02f, -1.51336566e-02f, -3.27372961e-02f, 1.75808631e-02f, 9.75054651e-02f, -4.80785547e-03f,
  6.71933591e-03f, -7.37327859e-02f, -6.62472844e-02f, -8.86910334e-02f, -7.02925166e-03f, -7.24741369e-02f, -3.00727377e-04f, -6.53149262e-02f, 1.71924494e-02f, -5.05360626e-02f,
  -1.61634237e-02f, 3.53004830e-03f, -2.54892819e-02f, -3.64215709e-02f, -7.85553083e-02f, 3.58833447e-02f, 1.96621548e-02f, 8.47889762e-03f, -6.12964667e-02f, -7.65613317e-02f,
  -1.75270662e-02f, 4.97180633e-02f, -3.38621400e-02f, -1.80427190e-02f, -5.32007702e-02f, -7.19634742e-02f, -6.91167116e-02f, -5.95140122e-02f, 2.78677102e-02f, -2.48635169e-02f,
  1.33049071e-01f, -2.53200203e-01f, 4.98633794e-02f, -1.68550424e-02f, 3.46492946e-01f, -1.64495304e-01f, 3.20961893e-01f, -2.28217661e-01f, 4.37832624e-02f, -1.45093322e-01f,
  1.77227572e-01f, -1.50947541e-01f, -9.76870675e-03f, 1.83980092e-02f, 3.26810241e-01f, -2.21852183e-01f, 1.42054319e-01f, 5.25069311e-02f, -7.66472891e-02f, 1.53125167e-01f,
  -2.23632231e-02f, 1.76104188e-01f, 2.32111197e-02f, -1.02952607e-01f, 2.96255052e-01f, -9.52086598e-03f, 2.19439313e-01f, -6.47857264e-02f, 1.80786639e-01f, -6.74870163e-02f,
  3.36590931e-02f, -8.15546289e-02f, 7.47138187e-02f, -7.31813759e-02f, 8.38511735e-02f, -4.03822549e-02f, 4.13903184e-02f, -9.40745696e-03f, -4.58013872e-03f, -6.34823814e-02f,
  2.57661957e-02f, -4.56530787e-03f, -2.63717361e-02f, 2.16098614e-02f, 3.61496508e-02f, -2.77991630e-02f, 5.13943322e-02f, 1.37348950e-01f, 6.74919970e-03f, -1.86179038e-02f,
  3.71464938e-02f, -6.65932745e-02f, -5.69830276e-03f, -2.86557153e-02f, 1.37498612e-02f, 2.68324371e-02f, 3.63361426e-02f, 1.79559719e-02f, -2.14630440e-02f, -1.17119681e-02f,
  2.05206517e-02f, -5.93782887e-02f, -4.94972410e-05f, -8.63901451e-02f, 7.43561238e-02f, -2.18864325e-02f, 8.59293621e-03f, -1.39796473e-02f, 2.60956641e-02f, 1.76632814e-02f,
  -2.27076709e-02f, -8.23566765e-02f, -6.89549297e-02f, 9.17453505e-03f, 2.54915077e-02f, 3.92960198e-03f, -2.82515977e-02f, -4.65715788e-02f, -1.98332462e-02f, 2.88218725e-02f,
  1.27869109e-02f, 3.18238027e-02f, 4.27198298e-02f, 6.89329877e-02f, 4.26585153e-02f, 3.65456082e-02f, -5.66524230e-02f, 4.11823988e-02f, 3.91379558e-02f, 6.81997910e-02f,
  1.22783840e-01f, 8.03502575e-02f, -2.67557427e-02f, -2.19596680e-02f, -3.57530899e-02f, 1.01506729e-02f, -5.81330806e-02f, -2.29209084e-02f, 3.60641000e-03f, 4.37927209e-02f,
  -3.36887911e-02f, 3.95822152e-02f, 6.20358391e-03f, -6.86803907e-02f, -2.71309242e-02f, 1.06268525e-02f, 5.20066246e-02f, -6.76367283e-02f, -4.05895077e-02f, -4.72386088e-03f,
  2.66881119e-02f, 2.57553719e-02f, -1.78041011e-02f, 8.44846144e-02f, -1.00670988e-02f, 3.91694047e-02f, -1.13874888e-02f, -6.84116706e-02f, 8.05398226e-02f, -6.43457938e-03f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.72686857e-01f, -3.11563045e-01f, 1.75269827e-01f, 3.93392980e-01f, 2.03579187e-01f, -3.23474199e-01f, 3.58034760e-01f, -1.49594769e-01f, 5.02710521e-01f, -3.48087668e-01f,
  -2.05580935e-01f, 1.14503898e-01f, -2.49676287e-01f, -1.19232483e-01f, 2.80922294e-01f, 1.36572272e-01f, -7.50174448e-02f, 4.13418040e-02f, 1.30681947e-01f, -1.67243689e-01f,
  1.57095373e-01f, -1.63756728e-01f, 1.22969769e-01f, -4.64077026e-01f, 3.69093642e-02f, 4.41972986e-02f, 2.37332862e-02f, -1.91158935e-01f, -1.92967609e-01f, -1.57893952e-02f,
  -1.90552860e-01f, 1.40135467e-01f, 2.70230398e-02f, 1.65780038e-02f, -3.70310210e-02f, -7.08425231e-03f, -4.35106270e-02f, -4.45383834e-03f, -7.24001881e-03f, 2.74685957e-02f,
  5.15778409e-03f, -1.02510527e-01f, 6.19403198e-02f, -7.60163441e-02f, 8.25888887e-02f, 2.93480735e-02f, 5.50104901e-02f, -1.62137300e-02f, 7.36573935e-02f, -6.78774389e-03f,
  6.76836148e-02f, -6.36863336e-02f, 1.26568712e-02f, -2.61365585e-02f, 7.17457905e-02f, -4.92878258e-02f, 1.92579757e-02f, -2.11360417e-02f, -1.76364277e-03f, 4.19308245e-02f,
  5.78312613e-02f, -4.14159596e-02f, -5.14293313e-02f, -3.79509516e-02f, -3.48580070e-02f, 5.75309396e-02f, -3.26995999e-02f, -6.64134324e-02f, -3.88340130e-02f, -4.27547470e-02f,
  -5.04454561e-02f, 2.63225362e-02f, 3.40700112e-02f, 8.80192667e-02f, 2.99848840e-02f, 4.12654057e-02f, -7.56834298e-02f, -8.55572224e-02f, 8.30710381e-02f, 9.67046246e-02f,
  -3.21597718e-02f, 3.30275521e-02f, -4.58965376e-02f, 3.64526547e-02f, -5.22006862e-02f, 1.44654000e-02f, -1.59819629e-02f, -8.77840444e-02f, 5.72819300e-02f, 1.90181322e-02f,
  -4.76208955e-01f, -4.96857256e-01f, 4.32905853e-02f, -5.24546690e-02f, -8.97488669e-02f, -1.19127229e-01f, 6.06377795e-02f, -1.89223443e-03f, -9.46950540e-02f, -1.31450444e-02f,
  2.33633518e-02f, -3.34642194e-02f, -8.13288540e-02f, 8.34355354e-02f, -1.46580413e-01f, -4.46146689e-02f, -8.32229704e-02f, -1.45296613e-02f, 5.45318127e-02f, -1.11565024e-01f,
  -8.37440491e-02f, 1.72175150e-02f, 6.56302497e-02f, 7.09946007e-02f, -5.65079674e-02f, 7.02846944e-02f, -1.74505170e-02f, 3.54761593e-02f, -1.12640619e-01f, 4.15039957e-02f,
  1.04156630e-02f, -1.39361620e-01f, 6.80210352e-01f, -2.61761785e-01f, 2.01329708e-01f, 1.66768849e-01f, 3.86746496e-01f, -5.19225560e-02f, -8.56522173e-02f, -3.31957370e-01f,
  -7.88082555e-02f, 3.50368791e-03f, 1.03340514e-01f, -2.59581685e-01f, 4.13559020e-01f, -1.82925500e-02f, -9.01277736e-03f, -1.32916570e-01f, 2.03943308e-02f, -1.34833679e-01f,
  -5.71182072e-02f, -2.31772169e-01f, 2.88502038e-01f, -1.87635466e-01f, 6.82829097e-02f, -6.15529995e-03f, -1.67737037e-01f, 2.66636103e-01f, -2.23656565e-01f, 1.41650170e-01f,
  3.55108947e-01f, 1.05128668e-01f, 2.83458456e-02f, -6.80103824e-02f, -2.57936283e-03f, 2.96814702e-02f, 7.67584667e-02f, 1.88839018e-01f, 1.24326952e-01f, -6.40760139e-02f,
  -2.36657970e-02f, 9.65656191e-02f, -8.56262296e-02f, 7.76809379e-02f, -3.74549329e-02f, 3.07467300e-02f, 1.35112897e-01f, 6.82167634e-02f, -1.53101496e-02f, 8.91947299e-02f,
  9.80728790e-02f, 7.08338991e-02f, 3.90339606e-02f, -2.04509608e-02f, 1.06567129e-01f, 1.06324732e-01f, 5.90872578e-02f, 1.78022027e-01f, 4.16016206e-03f, -8.17110538e-02f,
  -2.89917514e-02f, -6.99882656e-02f, 3.45099233e-02f, -3.52655165e-02f, -2.87208632e-02f, 6.06109649e-02f, 3.65581643e-03f, -4.08951938e-02f, 4.47570011e-02f, -1.97989494e-02f,
  -3.66097577e-02f, -1.11105926e-02f, 9.45321657e-03f, -6.25872612e-02f, -8.18123370e-02f, -1.76375601e-02f, -8.38709772e-02f, -3.69496550e-03f, 2.72441339e-02f, -6.22664206e-02f,
  3.48034650e-02f, 8.84746201e-03f, -5.02338670e-02f, -3.47570553e-02f, 1.05618089e-02f, 3.27823460e-02f, -2.04156376e-02f, -7.34696910e-02f, 2.61164978e-02f, 3.95734571e-02f,
  -3.11664045e-01f, -4.44618702e-01f, 4.24978649e-03f, 4.77166213e-02f, -1.81026943e-02f, -3.22624370e-02f, -1.01177938e-01f, -1.90006673e-01f, -1.17010903e-02f, -5.12870476e-02f,
  4.71572503e-02f, -1.01405457e-01f, -1.57822892e-02f, -1.33840842e-02f, 3.58432792e-02f, 1.71193876e-03f, -3.91518399e-02f, -1.24353968e-01f, -2.94489730e-02f, -4.17076796e-02f,
  -8.27630013e-02f, -3.18222120e-02f, 2.62595732e-02f, -1.29069477e-01f, -5.11629768e-02f, -7.60570765e-02f, 2.43848246e-02f, -9.89389867e-02f, -1.93159785e-02f, 3.11021395e-02f,
  -8.44529510e-01f, -3.74925911e-01f, -7.10383952e-02f, 1.27926677e-01f, -4.17825878e-01f, 8.12138394e-02f, 3.46418172e-01f, -2.05107599e-01f, -2.12924555e-01f, 6.02804832e-02f,
  4.64692786e-02f, -1.70328319e-02f, 4.25575636e-02f, 3.74583989e-01f, 2.68256843e-01f, 2.34028727e-01f, 1.54115558e-01f, 1.32024780e-01f, -1.14713222e-01f, -1.25013620e-01f,
  2.76077483e-02f, 1.55163884e-01f, 2.90340066e-01f, -4.21373732e-02f, -5.87356128e-02f, -1.05334863e-01f, 1.15634747e-01f, -1.09430119e-01f, 2.85677522e-01f, 1.58082053e-01f,
  3.35140258e-01f, -2.77171910e-01f, 3.83819528e-02f, 2.18960196e-02f, -1.53724581e-01f, -5.87918051e-02f, 7.17897043e-02f, 4.63793278e-02f, -5.94705828e-02f, -1.64504386e-02f,
  -7.58711919e-02f, -1.26902342e-01f, 1.03821456e-01f, -7.58287385e-02f, -1.10832885e-01f, -3.98929752e-02f, -4.75042611e-02f, 1.18809687e-02f, 1.36401728e-02f, 1.40724937e-03f,
  -6.77662641e-02f, 8.52593184e-02f, 3.45454998e-02f, 3.22688557e-02f, -1.88168846e-02f, -5.20664528e-02f, 1.32505223e-01f, 3.36074121e-02f, 1.25461246e-03f, 1.77603550e-02f,
  -4.42209356e-02f, -6.38254127e-03f, -4.36275937e-02f, 3.74226794e-02f, -2.71506775e-02f, 3.94382626e-02f, 4.10290733e-02f, 3.30473371e-02f, -1.98151413e-02f, 4.54802401e-02f,
  -1.09522883e-02f, 3.14520970e-02f, 1.09641277e-03f, 8.16812143e-02f, -4.34921077e-03f, 2.80253459e-02f, -5.13943434e-02f, -2.14082701e-03f, -6.17984508e-04f, 8.05456787e-02f,
  5.15766963e-02f, 1.05817333e-01f, 3.75539102e-02f, 8.41992944e-02f, -2.92843748e-02f, 6.57837540e-02f, -5.51346340e-04f, -2.29788143e-02f, 5.63879497e-02f, 5.19646816e-02f,
  -8.35617065e-01f, -4.33267742e-01f, -9.59853530e-02f, -5.45248250e-03f, 2.62002461e-02f, -8.03096816e-02f, -8.22273083e-03f, -2.73532216e-02f, -5.27627729e-02f, 7.51942955e-03f,
  -3.45306657e-02f, 8.76496136e-02f, -6.47505447e-02f, 7.48463646e-02f, 1.27974022e-02f, -3.74549651e-03f, -5.20733781e-02f, 2.47870199e-03f, -5.92401996e-03f, -3.08075398e-02f,
  3.41302343e-03f, -3.91269885e-02f, -1.36502972e-02f, -4.44550328e-02f, 1.24730719e-02f, 5.99309206e-02f, -2.56908029e-01f, 1.33937038e-02f, 7.10921967e-03f, 2.08655708e-02f,
  5.48062563e-01f, 6.87394381e-01f, 3.27530921e-01f, 5.46151936e-01f, -2.92807668e-01f, -7.79654533e-02f, -8.77289381e-03f, 1.07454276e-03f, -3.28692384e-02f, 1.86324328e-01f,
  -2.22248122e-01f, 3.87916237e-01f, -6.63776249e-02f, 2.65614510e-01f, -2.27941424e-01f, 8.37874319e-03f, 1.70564905e-01f, 2.32332855e-01f, -4.61581610e-02f, 1.97342172e-01f,
  2.73830555e-02f, -1.47955611e-01f, 1.92682371e-01f, -2.62879848e-01f, 2.08966389e-01f, 1.78639770e-01f, 2.91204434e-02f, -4.72877324e-02f, 3.23560178e-01f, -6.33836165e-02f,
  -8.20364207e-02f, 1.82108246e-02f, 1.32283494e-01f, 1.70138907e-02f, 4.29563113e-02f, -4.14725393e-02f, 7.16522485e-02f, -4.25545126e-02f, -1.26374722e-01f, 4.66345288e-02f,
  5.13782576e-02f, -1.17605515e-02f, -2.72633526e-02f, -3.57132852e-02f, 8.24333653e-02f, 1.05146557e-01f, 4.71538678e-02f, 1.12247244e-01f, 6.52789995e-02f, -7.99117424e-03f,
  1.54821351e-01f, 9.21964198e-02f, 2.70996764e-02f, 3.59165408e-02f, 4.87588756e-02f, 1.29611185e-02f, 1.22895814e-01f, 5.64993955e-02f, 1.25444531e-01f, 3.81203159e-03f,
  1.23367935e-01f, -5.82880825e-02f, 5.42047136e-02f, 1.21040959e-02f, 6.12133071e-02f, 4.26486209e-02f, 5.29039912e-02f, -1.07501030e-01f, 7.05713183e-02f, 1.24045815e-02f,
  -3.30500975e-02f, 9.03348997e-02f, -1.14393122e-01f, 4.01953459e-02f, 2.35537048e-02f, 5.96175492e-02f, -1.10219032e-01f, -9.39261615e-02f, -2.87080985e-02f, -1.18032629e-02f,
  -1.61087159e-02f, 2.22613551e-02f, 3.27030336e-03f, 2.21602172e-02f, -5.88722862e-02f, 6.85846386e-03f, 5.41085452e-02f, 1.03545308e-01f, -3.87604870e-02f, -2.59043295e-02f,
  8.61411467e-02f, 3.33914578e-01f, 1.21847941e-02f, -6.25675991e-02f, -7.99159110e-02f, -3.40050012e-02f, -3.39893813e-05f, -1.34017868e-02f, 1.37137815e-01f, -6.26280829e-02f,
  -6.89087808e-02f, -2.04123985e-02f, -3.24213617e-02f, 1.08046331e-01f, -1.07929826e-01f, 3.08219511e-02f, -3.71858589e-02f, 1.62932854e-02f, 2.20155399e-02f, 7.09538087e-02f,
  -1.94839612e-02f, -7.07699880e-02f, -6.02065362e-02f, -5.70039116e-02f, -1.86530538e-02f, 3.52543406e-02f, -7.10956231e-02f, -1.39199682e-02f, -8.10256600e-02f, 3.85171138e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.68749020e-01f, 1.27212584e-01f, 9.62589867e-03f, -2.07999423e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -3.67630899e-01f, -4.54556160e-02f, -3.07884753e-01f, 2.50396013e-01f, 4.99101192e-01f, 2.93413699e-01f, 9.77152407e-01f, -2.71635264e-01f, 1.84088051e-01f, 2.35330045e-01f,
  -4.47097629e-01f, 2.65387416e-01f, -3.70387197e-01f, -2.79207140e-01f, 1.89668372e-01f, 3.33767682e-01f, -7.11605772e-02f, -3.41336578e-01f, -2.55043358e-02f, -3.96326154e-01f,
  -6.73692450e-02f, 4.10465598e-02f, -2.83607095e-01f, 3.12946551e-02f, 1.69622689e-01f, 5.68326414e-01f, 3.98379177e-01f, -7.07888380e-02f, -3.76214564e-01f, 1.15033269e-01f,
  2.76644882e-02f, 5.91332674e-01f, 4.34598863e-01f, -4.62605022e-02f, 2.71565169e-01f, 1.88124701e-01f, -6.79868236e-02f, -2.25522548e-01f, 8.50196555e-02f, -2.30988950e-01f,
  -2.40975216e-01f, -3.51091653e-01f, 5.56104243e-01f, -3.38355958e-01f, 5.22574067e-01f, -9.61815342e-02f, -4.23992425e-01f, 4.51040059e-01f, 6.38064146e-02f, -3.04018527e-01f,
  3.88872296e-01f, 3.09019148e-01f, 1.50489509e-02f, -1.64622236e-02f, 3.04182589e-01f, -7.39988506e-01f, 1.32432550e-01f, 5.83668411e-01f, 1.83103964e-01f, 4.76958871e-01f,
  1.64124653e-01f, 5.21796405e-01f, 4.20987397e-01f, -1.03506811e-01f, -1.85997978e-01f, 2.51537830e-01f, 3.26916158e-01f, 4.08680588e-01f, 2.78414246e-02f, 1.24764189e-01f,
  -1.62453115e-01f, 2.27264643e-01f, 2.41898179e-01f, 4.46250021e-01f, -1.28317267e-01f, 4.89581615e-01f, 3.49377602e-01f, 1.53048756e-02f, 1.50201112e-01f, -4.47513372e-01f,
  -3.54435325e-01f, 3.88620168e-01f, -4.77349788e-01f, 9.18645412e-03f, -1.83110535e-01f, -7.84290880e-02f, 3.10123414e-01f, 6.97006822e-01f, -7.95508623e-02f, -2.27722615e-01f,
  -5.16484976e-01f, 6.25613689e-01f, 3.31519097e-01f, 2.07362726e-01f, -1.41753340e-02f, -5.46668470e-02f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -3.47248286e-01f, -5.69790564e-02f, 4.35012951e-02f, 6.87154010e-02f, 1.78332418e-01f, 1.43637910e-01f, -4.43535596e-02f, 3.39330763e-01f, 5.40971220e-01f, 8.71630728e-01f,
  1.71082392e-01f, 4.64215636e-01f, -5.06483614e-01f, -4.38060641e-01f, 5.90633690e-01f, 4.33279514e-01f, 8.07670206e-02f, 1.93775639e-01f, 4.87175405e-01f, 4.95042205e-01f,
  4.54035312e-01f, 2.08090529e-01f, -8.67182612e-02f, -4.93243575e-01f, 1.86573327e-01f, -2.38094106e-02f, -2.80457914e-01f, 2.54858702e-01f, -2.73502737e-01f, 6.64095044e-01f,
  8.64688098e-01f, -6.56930864e-01f, 4.34025973e-01f, 2.05647588e-01f, 6.85818017e-01f, -8.46342277e-03f, -1.42904669e-01f, 3.75481993e-01f, -6.91122174e-01f, -7.77728185e-02f,
  -1.35581404e-01f, 4.15072799e-01f, 6.12495363e-01f, -5.45466244e-01f, 1.91044152e-01f, 4.23261106e-01f, 1.80982918e-01f, 4.37492758e-01f, 4.34813142e-01f, 2.16280408e-02f,
  2.03313738e-01f, 2.76353896e-01f, 8.40962231e-02f, 1.52859196e-01f, -5.84451437e-01f, 1.88200742e-01f, -3.33279014e-01f, -3.72101367e-01f, -1.89135030e-01f, -1.05927393e-01f,
  1.05570517e-02f, 3.28967571e-01f, 2.87559241e-01f, -2.00733647e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  6.64038479e-01f, 2.34777510e-01f, -2.62846518e-02f, 5.02741277e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.89182754e-02f, 8.62576291e-02f, -1.99433699e-01f, 2.03638598e-02f, 6.78899527e-01f, 2.12156758e-01f, 5.14068246e-01f, 9.59320784e-01f, -2.56709218e-01f, -5.46784326e-02f,
  -2.42941082e-01f, -7.16402948e-01f, 2.35147431e-01f, -1.76668867e-01f, 2.32775435e-01f, -2.74351239e-01f, -1.61663130e-01f, -2.88627744e-01f, 2.62622148e-01f, 2.95302898e-01f,
  -4.22562659e-01f, 2.19658777e-01f, 5.83067775e-01f, -3.77146095e-01f, -4.55211818e-01f, 9.97238383e-02f, 1.11398801e-01f, 5.51210880e-01f, 3.21488976e-01f, -1.14992587e-02f,
  -6.00214541e-01f, -2.29827225e-01f, 5.80504954e-01f, 2.42949545e-01f, -1.23715416e-01f, -7.08872974e-02f, -3.34478140e-01f, -2.05091998e-01f, -3.78794163e-01f, 3.80746782e-01f,
  2.64724165e-01f, 9.60979760e-02f, 7.59456903e-02f, -1.24401055e-01f, -1.03512860e-03f, -1.22118786e-01f, 4.48182255e-01f, 7.69060031e-02f, 4.60145622e-02f, 1.22488059e-01f,
  3.44488978e-01f, -1.25037044e-01f, -3.96640599e-01f, -5.63832343e-01f, -2.32097641e-01f, -6.20104298e-02f, -1.98217362e-01f, 5.15223622e-01f, 3.01411301e-01f, 2.14055866e-01f,
  8.40612575e-02f, 3.11313033e-01f, -4.56603728e-02f, 6.08013980e-02f, -1.73417568e-01f, -1.30453020e-01f, 5.10395408e-01f, 6.47907183e-02f, -3.42260813e-03f, 9.41578299e-02f,
  -5.89843810e-01f, -5.76779127e-01f, 3.01131397e-01f, -5.77515773e-02f, -8.23930874e-02f, 3.52434307e-01f, -2.46423930e-01f, 1.66134074e-01f, -1.97830215e-01f, 4.31470364e-01f,
  -3.67937833e-01f, 1.58678144e-01f, -2.57114828e-01f, -5.24466574e-01f, -2.39614412e-01f, -2.15322793e-01f, 5.38745165e-01f, 5.37590623e-01f, -3.62452894e-01f, -1.27037555e-01f,
  -3.48098874e-01f, 9.88485366e-02f, 5.72934210e-01f, 2.97726423e-01f, -5.56812584e-01f, -3.21063876e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  5.01624167e-01f, 3.38502109e-01f, 5.78441560e-01f, 5.23538172e-01f, 6.34266078e-01f, 6.12069964e-01f, 6.37834549e-01f, 1.28665805e+00f, -1.05653822e+00f, 3.77237648e-01f,
  8.22746754e-01f, -1.68766260e-01f, 1.22699094e+00f, 1.26454964e-01f, 3.04431230e-01f, -7.73674622e-02f, 8.14387321e-01f, 1.64503723e-01f, -4.60398287e-01f, 8.25184658e-02f,
  1.57851577e-01f, 2.40700960e-01f, 4.52154689e-02f, 8.70298803e-01f, 5.87881580e-02f, 7.17688501e-01f, -4.62242007e-01f, -1.12508893e+00f, 1.94566101e-01f, 1.29485056e-01f,
  5.71972489e-01f, 1.71134174e-01f, -9.41321999e-02f, 4.56636697e-01f, 4.90265042e-01f, -7.98831403e-01f, -2.31136665e-01f, 2.61385173e-01f, 3.17741662e-01f, 2.45984498e-04f,
  -6.38132095e-01f, 6.66360557e-01f, 8.36748183e-01f, -1.05024256e-01f, 4.52167511e-01f, 1.02634847e+00f, 8.88525099e-02f, 5.20083904e-01f, -3.49721879e-01f, 4.42960918e-01f,
  5.36477029e-01f, 9.16048288e-01f, 5.43511033e-01f, 4.81733412e-01f, -4.63860989e-01f, 1.30116403e-01f, 4.54311669e-02f, -6.99997246e-01f, 3.73679817e-01f, 7.85968125e-01f,
  6.05877459e-01f, -4.13192034e-01f, 1.09094335e-02f, -6.27262890e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  5.08924365e-01f, 4.61757302e-01f, 3.91232163e-01f, 1.18953064e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  1.66802034e-01f, 2.52030581e-01f, -1.37650147e-02f, 3.62810850e-01f, 3.82472247e-01f, 2.16351375e-02f, -5.10498941e-01f, -7.79713333e-01f, 6.81726635e-01f, 4.18760002e-01f,
  5.33845365e-01f, -7.75238037e-01f, -2.36314282e-01f, 3.13202292e-01f, -1.02091707e-01f, 2.82884836e-01f, -1.20671235e-01f, 1.51526347e-01f, -3.26137662e-01f, -7.27297425e-01f,
  -9.22466367e-02f, -1.24988221e-01f, -2.09241975e-02f, 2.57168442e-01f, -3.42315704e-01f, -3.95741165e-01f, -1.21157922e-01f, 5.41304111e-01f, 1.49884805e-01f, -8.10919106e-01f,
  5.00825350e-04f, 2.86338598e-01f, 4.04332802e-02f, 2.18738601e-01f, -4.70961146e-02f, 4.43512440e-01f, 1.96611937e-02f, -9.64786410e-02f, -5.35353601e-01f, -2.77233601e-01f,
  4.26869512e-01f, 1.66951016e-01f, 7.88559139e-01f, -7.27152288e-01f, -1.64085090e-01f, -1.77747622e-01f, 1.01824798e-01f, 1.53459489e-01f, 4.48540002e-01f, -2.34255362e-02f,
  3.21811944e-01f, 4.19150412e-01f, -2.37181340e-03f, 2.07597360e-01f, -4.27687347e-01f, -2.95844913e-01f, 1.35017773e-02f, -6.87812492e-02f, 5.95214009e-01f, -6.82395756e-01f,
  -1.24965310e-01f, 5.48779130e-01f, -2.04449475e-01f, -3.79046172e-01f, -1.42566472e-01f, -8.49359185e-02f, -4.63596702e-01f, 7.88379088e-02f, 3.89663696e-01f, -5.21308780e-01f,
  -5.10644078e-01f, -5.35456300e-01f, 6.38301298e-02f, 1.35474101e-01f, 5.08060992e-01f, -4.70273167e-01f, -2.68579703e-02f, -3.40584397e-01f, -1.18976623e-01f, 5.33988535e-01f,
  -2.92530488e-02f, -2.41919067e-02f, -9.56341848e-02f, 2.48754904e-01f, 4.22633320e-01f, -3.74718368e-01f, 2.90162802e-01f, -5.59557617e-01f, 7.27403769e-03f, 2.66833216e-01f,
  -4.16047692e-01f, 2.15752169e-01f, 1.36417761e-01f, 7.87349492e-02f, -3.78048956e-01f, 5.16334474e-01f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  8.31263363e-01f, -4.51506749e-02f, -7.03756571e-01f, 5.37553489e-01f, 9.29083586e-01f, 2.98126668e-01f, 5.58836162e-01f, -1.02652490e+00f, 1.10608900e+00f, 3.73771101e-01f,
  -2.25639790e-01f, -7.78057456e-01f, 3.38232577e-01f, 1.27875090e+00f, 5.12377173e-02f, -6.23782992e-01f, 2.48818278e-01f, 6.04187846e-01f, 4.00201440e-01f, 9.58645463e-01f,
  5.09702861e-01f, 1.26400083e-01f, 9.35123205e-01f, 5.08811548e-02f, 1.78968295e-01f, -6.23359263e-01f, -8.24927211e-01f, -2.62902737e-01f, 9.23654795e-01f, 6.23354495e-01f,
  -6.43542767e-01f, 1.56028831e+00f, 1.14504147e+00f, -4.45449680e-01f, 6.47848368e-01f, 1.04372568e-01f, 7.73376882e-01f, 4.94640201e-01f, 7.34428823e-01f, 1.53742814e+00f,
  -9.68880653e-01f, 7.16390193e-01f, 5.58916330e-01f, 8.15877199e-01f, 1.09134650e+00f, -3.06008458e-01f, 7.00822532e-01f, 6.70792341e-01f, -1.16368771e+00f, 3.83798420e-01f,
  -7.14232698e-02f, -7.51161397e-01f, -3.18454444e-01f, 3.41085911e-01f, 2.01132312e-01f, -3.78159702e-01f, 9.71910536e-01f, 7.92187393e-01f, -7.82621145e-01f, -8.12086985e-02f,
  5.82324922e-01f, 5.03205657e-01f, 1.26186645e+00f, -8.02973688e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  1.72874898e-01f, 6.31602645e-01f, 5.65254912e-02f, 2.26986885e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  6.30204499e-01f, -2.48168230e-01f, -4.43376034e-01f, 1.52551010e-01f, -7.29352713e-01f, 4.33123708e-01f, -6.35700047e-01f, -7.41093829e-02f, -1.14790881e+00f, -8.21621537e-01f,
  5.84564686e-01f, -5.11634111e-01f, 8.12342763e-02f, -3.41201961e-01f, -9.48875323e-02f, 2.82304466e-01f, 3.98106009e-01f, 6.42224252e-01f, -6.85350373e-02f, -1.16989359e-01f,
  -1.01156330e+00f, 1.69880673e-01f, -3.66466910e-01f, -6.46542728e-01f, -6.06989622e-01f, -7.02577293e-01f, -1.28855920e+00f, 8.32645953e-01f, -5.92378438e-01f, 4.09130484e-01f,
  3.88024211e-01f, -1.63280636e-01f, -4.00262833e-01f, 2.84408424e-02f, 5.30178189e-01f, -7.82716632e-01f, 3.52047294e-01f, 2.22399518e-01f, -6.55880988e-01f, 1.06416392e+00f,
  -6.52800202e-01f, -5.43104172e-01f, -7.72526741e-01f, -3.69716048e-01f, -1.43897915e+00f, -7.32502341e-01f, 6.02284312e-01f, 1.79041296e-01f, -9.26097870e-01f, -7.01362550e-01f,
  2.07576975e-01f, -1.06387734e+00f, 1.14362383e+00f, 6.42833412e-01f, -7.73750842e-01f, 4.98301178e-01f, 7.89609790e-01f, -1.64743841e-01f, 4.95977581e-01f, 7.54494786e-01f,
  5.89457870e-01f, 3.75025809e-01f, -1.17715406e+00f, -8.16577315e-01f, -2.29228482e-01f, -2.90896922e-01f, 9.60260689e-01f, -4.88081187e-01f, 1.02194823e-01f, -3.40724975e-01f,
  7.44585872e-01f, 6.30885422e-01f, 7.23668218e-01f, 9.55232084e-01f, -1.46898198e+00f, -5.55741012e-01f, 3.90503883e-01f, -8.89914632e-01f, 1.91497207e-02f, 7.56758824e-02f,
  -3.34016174e-01f, -5.95885038e-01f, 5.82816303e-01f, 7.79794931e-01f, 3.63855302e-01f, -1.35692286e+00f, 2.60675013e-01f, -5.36719501e-01f, -4.14298415e-01f, 2.94046938e-01f,
  7.62670875e-01f, 5.50561436e-02f, 1.40229821e-01f, 4.90828335e-01f, -7.25037009e-02f, -3.37700665e-01f, -1.07381618e+00f, -1.02004433e+00f, -1.14958417e+00f, 8.21303129e-01f,
  2.37376988e-01f, 4.41491872e-01f, 2.17766508e-01f, -6.70836508e-01f, 3.49579483e-01f, 1.18241918e+00f, 1.67517507e+00f, -1.06096172e+00f, 1.18017405e-01f, -7.15533912e-01f,
  -1.02084315e+00f, 5.05978703e-01f, -1.31205797e+00f, 1.23699927e+00f, -1.07329881e+00f, 7.41147220e-01f, -1.08794498e+00f, 6.99790835e-01f, 3.22186857e-01f, -8.96217406e-01f,
  7.80599296e-01f, 8.53703380e-01f, 8.89298856e-01f, 1.18676603e+00f, -9.00860310e-01f, 8.19924951e-01f, -8.71529102e-01f, -1.07551360e+00f, 2.84036845e-01f, -4.23764318e-01f,
  2.62128651e-01f, -8.20380569e-01f, 4.87887472e-01f, -1.03708696e+00f, -8.73197079e-01f, 8.33744109e-01f, -9.62616205e-01f, -8.26256871e-01f, 1.08050387e-02f, 4.42984074e-01f,
  -1.31727791e+00f, 6.37420118e-01f, 5.07822692e-01f, -1.47688329e+00f, 1.17076325e+00f, 5.23040831e-01f, 1.52416855e-01f, -1.03493616e-01f, 3.59869540e-01f, -4.91431564e-01f,
  1.33629248e-01f, -4.47317958e-01f, 6.22582972e-01f, -1.18874502e+00f, -6.72037721e-01f, -1.38079688e-01f, -7.34311402e-01f, -6.01851642e-01f, -5.90084553e-01f, 8.24864566e-01f,
  8.94583404e-01f, 3.14437360e-01f, -1.44286796e-01f, 5.98932981e-01f, 1.10519755e+00f, 8.06321919e-01f, 7.67860830e-01f, -1.11341625e-01f, 1.51204944e+00f, 5.93648672e-01f,
  5.64542174e-01f, -1.28401625e+00f, -4.84568506e-01f, 1.49415001e-01f, 6.27575576e-01f, -9.82508421e-01f, 1.26205099e+00f, -2.83678863e-02f, -4.29207832e-01f, -5.50339818e-01f,
  -8.29367936e-01f, -3.72254759e-01f, 2.85149161e-02f, 4.61795926e-01f, -1.26918948e+00f, 5.13549984e-01f, -9.49804008e-01f, 7.62559593e-01f, 2.49769688e-01f, 4.81103271e-01f,
  -1.22071540e+00f, 1.59226626e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -5.44918001e-01f, -3.49693388e-01f, -1.32841110e-01f, 2.03598768e-01f, 1.59957886e-01f, -3.48943651e-01f, 4.32170719e-01f, 8.60018551e-01f, -5.73694520e-02f, 2.29190156e-01f,
  2.31071994e-01f, -4.84321527e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    