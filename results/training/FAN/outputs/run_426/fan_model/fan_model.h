/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.46317685e-01f, 8.28264430e-02f, -4.97214377e-01f, -1.81625381e-01f, 1.04955859e-01f, 5.09615168e-02f, -9.75194648e-02f, 5.27878292e-02f, -4.37899649e-01f, 3.03177476e-01f,
  1.57265365e-01f, -8.31117481e-02f, -4.82500121e-02f, 1.62533104e-01f, -1.54020712e-01f, -6.16681390e-02f, -1.12250917e-01f, 6.50290921e-02f, -1.73541337e-01f, 4.89690043e-02f,
  -2.45327756e-01f, 3.88527066e-01f, -1.00729294e-01f, 2.53219008e-01f, -2.69569946e-03f, -6.69902563e-02f, 3.00123453e-01f, 2.01872177e-03f, 3.26832712e-01f, 4.29217927e-02f,
  6.25119656e-02f, -7.66863376e-02f, -2.42449753e-02f, -1.27013633e-02f, -1.77069735e-02f, 6.96072762e-04f, 4.29730378e-02f, -2.02062875e-02f, -3.83507013e-02f, 3.86520140e-02f,
  -2.86827404e-02f, 7.71997869e-02f, 1.76563440e-03f, -6.60658851e-02f, -3.48048136e-02f, -2.92657502e-02f, -2.15189382e-02f, -1.27930433e-01f, 8.66782106e-03f, -5.99057041e-02f,
  -7.31697753e-02f, -2.72652004e-02f, -7.96471313e-02f, 6.74699433e-03f, -7.41951242e-02f, -1.75305158e-02f, -4.08620834e-02f, 5.72266802e-03f, -6.25364110e-02f, -4.89969775e-02f,
  3.94942472e-03f, -5.64883687e-02f, 3.67118828e-02f, 3.37110572e-02f, -3.73026915e-02f, 6.59333095e-02f, -4.16540988e-02f, 1.02256410e-01f, -5.40918820e-02f, 7.73046762e-02f,
  5.22323810e-02f, -3.91817540e-02f, -1.50150489e-02f, -8.11890587e-02f, -6.78577041e-03f, -6.24433421e-02f, -6.90268800e-02f, 4.13371101e-02f, -6.72668517e-02f, -1.01054497e-02f,
  1.80510862e-03f, 1.84435770e-02f, -2.11242028e-02f, 2.11277269e-02f, 6.58023879e-02f, -5.80118448e-02f, -5.98842204e-02f, -1.47338398e-02f, -4.04987261e-02f, -1.55103474e-03f,
  1.94638208e-01f, 1.04921862e-01f, 1.09825926e-02f, 7.03033060e-02f, 2.57216915e-02f, 6.46470711e-02f, -6.09955676e-02f, 4.69691120e-02f, 6.86812103e-02f, 1.30356112e-02f,
  6.65599704e-02f, -1.12253139e-02f, -1.98530331e-02f, 3.46787423e-02f, -3.37278135e-02f, 2.70483363e-02f, -1.22438883e-02f, 7.81954974e-02f, 4.03187610e-03f, -4.34361286e-02f,
  5.62760867e-02f, -3.15235704e-02f, 3.61243412e-02f, 4.41107973e-02f, 2.37852093e-02f, 7.98652321e-02f, -6.93455040e-02f, -8.01583007e-02f, 7.72604644e-02f, 2.47402433e-02f,
  1.07197970e-01f, -3.04213196e-01f, -3.02386701e-01f, 1.83685333e-01f, 1.55567035e-01f, -1.44545525e-01f, -1.60522297e-01f, 1.19728811e-01f, -1.62275881e-01f, 6.90822825e-02f,
  2.90053248e-01f, -3.59711736e-01f, -7.46775791e-02f, 8.81136581e-03f, 8.34422633e-02f, -1.00954026e-01f, 1.35284707e-01f, -8.86118785e-02f, -1.04098983e-01f, -1.82370562e-02f,
  4.13388945e-02f, 1.02419272e-01f, 9.23012868e-02f, 1.11389965e-01f, -1.34737706e-02f, 4.81943833e-03f, 2.50017971e-01f, -9.16736498e-02f, 1.49404824e-01f, 1.09441340e-01f,
  -2.82551087e-02f, 1.42568573e-01f, -3.70869301e-02f, -2.84347907e-02f, 4.43947762e-02f, 4.89081368e-02f, 1.58788580e-02f, -2.40568798e-02f, -6.08575903e-02f, -4.41586524e-02f,
  -6.93495795e-02f, -6.82612276e-03f, -4.09158319e-02f, 2.67852843e-02f, -3.11576407e-02f, -1.85275581e-02f, 6.92769932e-03f, -1.69915017e-02f, -7.19268247e-03f, -3.54611427e-02f,
  -5.18414862e-02f, -1.56280249e-02f, -1.21193510e-02f, 5.60601009e-03f, -4.12083194e-02f, -8.79687350e-03f, 2.31933016e-02f, -7.89514463e-03f, -2.97410302e-02f, 2.24641357e-02f,
  2.42057000e-03f, 5.52029982e-02f, -2.31152158e-02f, -2.43820213e-02f, 6.86492771e-02f, 8.66479799e-02f, -2.89357137e-02f, 3.31344046e-02f, 5.12995608e-02f, 2.22394019e-02f,
  8.41163248e-02f, 4.31745015e-02f, 2.24696789e-02f, 1.69290043e-02f, 6.46818653e-02f, 1.97640713e-02f, 2.84876730e-02f, 3.93192358e-02f, -3.24347839e-02f, 5.70966527e-02f,
  3.79165565e-03f, -2.24878336e-03f, 2.41974499e-02f, -4.62036915e-02f, -6.37567714e-02f, -3.49830873e-02f, 7.96511769e-02f, 5.14653064e-02f, -8.21830332e-02f, 7.17802420e-02f,
  5.71302921e-02f, 2.07774386e-01f, 2.77789067e-02f, -3.53467613e-02f, 1.00497771e-02f, 5.26891202e-02f, -1.55770451e-01f, -2.98267137e-03f, 1.69427209e-02f, 3.86709580e-03f,
  2.14207396e-02f, 1.93316862e-02f, 7.75473379e-03f, -5.51836891e-03f, 1.00934887e-02f, 9.63996351e-02f, 3.41577077e-04f, 4.92407084e-02f, 3.95422541e-02f, 2.83891000e-02f,
  7.84902573e-02f, -1.55750038e-02f, 8.45381692e-02f, 1.08000711e-02f, 9.72405374e-02f, 9.20136925e-03f, 3.07371654e-02f, -7.80551275e-03f, 8.43635798e-02f, -1.23933457e-01f,
  -2.17615321e-01f, 3.64282280e-02f, 1.21974699e-01f, 1.73969910e-01f, -1.47378854e-02f, 1.79812729e-01f, 1.61014482e-01f, 3.34513903e-01f, 2.17442304e-01f, 2.62087584e-01f,
  1.13837965e-01f, 4.80985083e-02f, 6.61609545e-02f, 8.33645388e-02f, -1.62556738e-01f, -2.06183195e-01f, 1.95389334e-02f, 5.50021641e-02f, -8.42367765e-03f, 8.95229802e-02f,
  -3.58227491e-02f, 2.93952823e-02f, -1.96514577e-01f, 1.91763639e-01f, -3.76681462e-02f, 1.28646001e-01f, -7.03822747e-02f, 1.26977712e-01f, 1.30897105e-01f, 1.26125902e-01f,
  -4.85706441e-02f, 1.50654659e-01f, -5.26145175e-02f, -1.97809413e-02f, -5.16519882e-02f, -1.81305483e-02f, 2.40499768e-02f, -9.72798318e-02f, 3.16729471e-02f, -5.02105393e-02f,
  -9.63658243e-02f, 1.10884041e-01f, -4.72538508e-02f, 5.12395240e-03f, -2.40183249e-03f, 1.15456052e-01f, -5.84897026e-02f, -6.72306225e-04f, 1.81389019e-01f, -1.82430223e-02f,
  -3.55048059e-03f, 4.55075921e-03f, -8.36965442e-03f, 3.83370481e-02f, 3.89319099e-03f, 9.75100845e-02f, 4.66649458e-02f, -4.14539613e-02f, 6.17600232e-02f, 1.00327641e-01f,
  -1.16421081e-01f, 7.17884600e-02f, -7.99724013e-02f, 7.75152966e-02f, 1.78001989e-02f, 8.45139399e-02f, 4.33306731e-02f, -3.64160389e-02f, 3.45023423e-02f, 4.39006388e-02f,
  -3.73510607e-02f, 7.98188243e-03f, 2.70716846e-02f, 2.56429929e-02f, 2.86759604e-02f, -2.45684385e-02f, 1.63503662e-02f, 4.62261476e-02f, -3.59582230e-02f, 2.09425893e-02f,
  -5.21940067e-02f, -9.25163776e-02f, -1.28784375e-02f, -4.53081019e-02f, 1.37995556e-01f, 8.39251932e-03f, 1.35579798e-02f, 1.04037739e-01f, -7.52729774e-02f, -1.02562964e-01f,
  7.53432810e-02f, 1.58446148e-01f, 3.64771634e-02f, 3.31362449e-02f, -4.68358062e-02f, 5.80585077e-02f, -1.32124117e-02f, 7.72789866e-02f, 5.17298351e-04f, 7.47284740e-02f,
  5.73740415e-02f, -5.31315692e-02f, 2.20889486e-02f, 7.38989795e-03f, 4.93919440e-02f, 3.17558050e-02f, 2.83213463e-02f, -1.37297846e-02f, -5.92715070e-02f, 8.73630121e-02f,
  9.60211083e-02f, -1.86787602e-02f, 3.18773203e-02f, -1.10056503e-02f, -2.76893023e-02f, -3.67976651e-02f, -9.25937593e-02f, -1.92439053e-02f, -5.52543737e-02f, -1.19968913e-01f,
  5.48764281e-02f, -3.98456961e-01f, 1.39576672e-02f, 4.90559727e-01f, 2.54602116e-02f, -2.63900459e-01f, -1.87874302e-01f, 1.95366114e-01f, 8.36334005e-02f, -3.27033877e-01f,
  1.38675580e-02f, -4.65161242e-02f, -1.84868619e-01f, 1.07329600e-01f, 2.27840766e-01f, -1.78212076e-01f, 1.13354653e-01f, -4.64868397e-02f, 7.81623423e-02f, 1.22489132e-01f,
  1.82280242e-01f, 1.04574598e-01f, 1.81016043e-01f, 1.12418450e-01f, 3.96868959e-02f, 2.28301376e-01f, 1.15900472e-01f, -1.22362293e-01f, 2.32283682e-01f, 2.80826986e-02f,
  9.83621404e-02f, 4.15864848e-02f, 6.85940906e-02f, -3.05057243e-02f, -3.74678113e-02f, -3.51966880e-02f, -2.64190212e-02f, -2.26957966e-02f, 1.11448625e-03f, 1.63503028e-02f,
  -9.07773823e-02f, 5.52354120e-02f, 1.47072738e-02f, -4.08884026e-02f, -4.73887019e-04f, -1.51997320e-02f, 1.91583615e-02f, 1.22179892e-02f, 7.56302662e-03f, -4.08308543e-02f,
  -8.54216740e-02f, 7.05011189e-02f, 1.16829947e-02f, 6.23483397e-03f, 2.29673088e-02f, 1.84461121e-02f, -5.62380329e-02f, -5.01061305e-02f, -2.15666480e-02f, -3.09247412e-02f,
  -1.31766507e-02f, 3.37002537e-04f, -3.12146377e-02f, 6.78861365e-02f, 2.23742723e-02f, 1.34979889e-01f, -2.57367995e-02f, 5.15457317e-02f, 6.08456545e-02f, 6.01866767e-02f,
  9.60413739e-02f, 1.36597147e-02f, -9.16122738e-03f, -5.51773831e-02f, 2.41163895e-02f, -7.80100981e-03f, -3.63815483e-03f, -4.53091301e-02f, 9.87387169e-03f, 1.07935918e-02f,
  2.42539197e-02f, -2.48661712e-02f, -2.82173343e-02f, -9.06356499e-02f, -1.40291092e-03f, 6.11910447e-02f, -2.95768045e-02f, 5.55937318e-03f, -2.76541733e-03f, -3.68537381e-02f,
  -8.32372233e-02f, -2.26998255e-01f, -3.16034406e-02f, 5.00913262e-02f, -7.02603310e-02f, -6.22135997e-02f, 1.26974108e-02f, 3.39874849e-02f, -2.94276625e-02f, 1.07978508e-02f,
  2.72766333e-02f, -5.34522696e-04f, -2.09107473e-02f, 2.76189158e-03f, 8.84739459e-02f, -9.50529352e-02f, 4.45905849e-02f, 1.83234923e-02f, 1.91394370e-02f, 4.25360985e-02f,
  8.76851194e-03f, -1.09053791e-01f, 1.31792575e-02f, 2.61982512e-02f, -8.11589416e-03f, 2.53966153e-02f, -1.18511310e-02f, 2.96615735e-02f, 3.36910458e-03f, -4.85621206e-03f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.53882638e-01f, -3.15467417e-01f, -1.35722250e-01f, 1.56781524e-01f, 2.14413106e-02f, -3.06007564e-01f, -4.82626259e-01f, 1.42608419e-01f, -2.54162341e-01f, -1.89826772e-01f,
  -4.45662029e-02f, -8.22638273e-02f, -3.16879869e-01f, 1.88070640e-01f, 3.85002643e-01f, -4.88185346e-01f, 1.70043260e-01f, -9.50434506e-02f, 1.36097400e-02f, 2.76908308e-01f,
  1.38890266e-01f, 4.11733747e-01f, 1.94078356e-01f, 3.82077754e-01f, 7.46296644e-02f, -6.10474981e-02f, 4.19241399e-01f, 1.49261579e-02f, 5.06544948e-01f, 1.65741101e-01f,
  1.50755182e-01f, 6.09209463e-02f, -7.45884553e-02f, 2.61531267e-02f, 2.98600569e-02f, 1.82899937e-01f, -3.67740840e-02f, -1.68643799e-02f, 1.59557667e-02f, 5.43686561e-02f,
  -8.58574454e-03f, 1.13544047e-01f, 1.73134618e-02f, -6.54407144e-02f, -9.72604081e-02f, 1.00850901e-02f, -1.43758124e-02f, -9.41878557e-02f, -1.50427163e-01f, 9.92487073e-02f,
  5.27694263e-03f, 3.92735424e-03f, -1.16643719e-01f, 6.67149797e-02f, -7.98300207e-02f, -1.17121033e-01f, -5.32849208e-02f, -6.86400682e-02f, -2.33316515e-03f, 9.71126091e-03f,
  -9.25461296e-03f, 1.19325239e-02f, -9.68666449e-02f, 4.14107963e-02f, 1.72655229e-02f, -4.35678624e-02f, 1.71291339e-03f, -3.85271423e-02f, -8.45915675e-02f, 9.67255700e-03f,
  -2.60538459e-02f, -7.30750710e-02f, 1.11874059e-01f, -1.91619359e-02f, -1.00428194e-01f, -5.25463112e-02f, -5.23300916e-02f, 6.43227249e-02f, 1.01384617e-01f, -1.42003059e-01f,
  -6.23181239e-02f, -1.12601276e-02f, 3.29052843e-02f, -1.89717207e-02f, 1.69425815e-01f, 6.12143055e-02f, 1.89689565e-02f, -8.18946585e-03f, -1.87498480e-02f, -1.06237099e-01f,
  1.08571701e-01f, 1.95413962e-01f, -2.84396503e-02f, 7.69858882e-02f, -1.00942746e-01f, -9.34626721e-03f, 1.04681198e-02f, -2.43505500e-02f, 1.24416113e-01f, 5.85519224e-02f,
  1.26078740e-01f, -1.02522083e-01f, 8.06264877e-02f, 7.93070719e-02f, 9.66565534e-02f, -3.41102257e-02f, 1.96127236e-01f, 5.68041429e-02f, 1.41206294e-01f, 1.54016450e-01f,
  9.90087911e-02f, -8.35471302e-02f, 6.86944649e-02f, 4.36787754e-02f, 1.42694055e-03f, 6.49208948e-02f, -1.30118266e-01f, -2.13478990e-02f, 7.03561530e-02f, -4.66867387e-02f,
  2.58220524e-01f, -3.65241885e-01f, 2.87436545e-01f, -1.78191736e-01f, 7.08111841e-03f, -3.03699106e-01f, 9.57113802e-02f, -3.56751323e-01f, 1.12743825e-02f, -1.25827581e-01f,
  4.16882671e-02f, 2.39374027e-01f, 3.43173981e-01f, -1.66143030e-01f, 5.29726744e-01f, 8.60761479e-02f, -4.30008203e-01f, -1.76978335e-01f, -1.98845908e-01f, -2.64924109e-01f,
  -3.72140855e-02f, -4.35048014e-01f, -3.14394720e-02f, -4.43230927e-01f, -8.23848546e-02f, -3.32017764e-02f, 3.31564426e-01f, 1.96075201e-01f, -2.38291249e-01f, -3.13321501e-02f,
  -4.50950265e-01f, -1.44901440e-01f, -2.60545556e-02f, 7.22654350e-03f, -6.55151252e-03f, 1.72354542e-02f, 8.79375562e-02f, 2.57737488e-01f, 8.06464925e-02f, 7.05544427e-02f,
  8.81415159e-02f, -1.50153130e-01f, 4.48368825e-02f, 5.93817681e-02f, -1.14731491e-01f, 4.33618091e-02f, -9.58738178e-02f, -1.38017684e-01f, 3.24699879e-02f, -8.31882190e-03f,
  1.31452773e-02f, -1.83067750e-02f, -9.71470624e-02f, -1.77222714e-02f, -4.75917198e-03f, -1.01856895e-01f, 2.40235198e-02f, 8.77649039e-02f, -2.40009855e-02f, 1.14575714e-01f,
  5.27416542e-02f, 2.41935179e-02f, -1.96193457e-02f, -6.12815097e-02f, -1.18147515e-01f, 1.49342278e-03f, -1.22864343e-01f, -4.29509431e-02f, -2.89321691e-02f, -1.20741859e-01f,
  -5.43349683e-02f, 1.30541027e-02f, -5.72382733e-02f, 2.94036046e-02f, -1.38330728e-01f, 1.35410605e-02f, -7.57189281e-03f, 3.66233326e-02f, 6.05763011e-02f, 7.48965144e-02f,
  2.52352767e-02f, -5.85847497e-02f, -1.15972348e-02f, 9.50258225e-02f, 6.03390625e-03f, 1.00416355e-01f, 2.80480627e-02f, 7.23228082e-02f, 5.88197708e-02f, 4.96782809e-02f,
  -5.50888181e-01f, -2.63495892e-01f, -2.47391108e-02f, -1.32746011e-01f, -1.00114346e-01f, -6.33269846e-02f, 2.19952781e-02f, -5.84277436e-02f, -1.79647270e-03f, 5.54722548e-02f,
  5.91323990e-03f, 4.58376408e-02f, -1.67331169e-03f, -6.55906275e-02f, -4.25126180e-02f, -3.05704419e-02f, 1.70460332e-03f, 4.80493158e-02f, 3.64305414e-02f, -1.17969014e-01f,
  -3.39804590e-02f, -4.69608754e-02f, 7.19111413e-02f, -4.36207913e-02f, -6.39760792e-02f, 6.53864518e-02f, -4.60186116e-02f, -4.20487672e-02f, -8.53617489e-02f, -3.91054153e-03f,
  2.78980851e-01f, -2.76592612e-01f, 2.23160803e-01f, 1.68808743e-01f, 2.90243059e-01f, -1.86255455e-01f, 5.66209376e-01f, -4.82936390e-02f, 2.79086590e-01f, -3.22357327e-01f,
  -4.58548479e-02f, -7.19478503e-02f, 3.50114964e-02f, -3.11541319e-01f, 2.71981686e-01f, -9.57311466e-02f, 2.86036246e-02f, -1.62972674e-01f, 3.08442079e-02f, 2.49274895e-02f,
  1.03609279e-01f, -1.25521570e-01f, -2.18706974e-03f, -2.94843048e-01f, 1.76555231e-01f, 9.62415989e-03f, -1.30191714e-01f, 1.29902914e-01f, -3.93849999e-01f, -8.82987902e-02f,
  8.46020952e-02f, 2.73346394e-01f, 4.56496142e-02f, -3.55455861e-03f, 1.10735014e-01f, 5.50675392e-02f, -4.37531285e-02f, 1.08905122e-01f, 1.73486635e-01f, 1.22168586e-02f,
  -8.29343572e-02f, -2.91283075e-02f, -2.71286275e-02f, 3.73201482e-02f, 4.73209098e-02f, 9.07749459e-02f, -2.85622310e-02f, 6.33553863e-02f, -5.66494875e-02f, 1.11418284e-01f,
  7.70544633e-02f, -5.15201688e-02f, 3.17283757e-02f, -7.47572109e-02f, -1.14279836e-02f, 2.61862092e-02f, 1.14904307e-01f, -3.45219932e-02f, -5.16572148e-02f, 1.45833688e-02f,
  -1.14055604e-01f, -5.63855879e-02f, 1.38885647e-01f, -3.42450142e-02f, 8.35833664e-04f, -9.84775648e-02f, 3.24387513e-02f, 6.72811419e-02f, -8.05936847e-03f, -5.79721853e-02f,
  -2.33000983e-02f, 3.39378379e-02f, 3.41502763e-02f, -5.64689487e-02f, 1.85050573e-02f, 9.10296850e-03f, 1.03243662e-03f, -5.18917590e-02f, 4.16245759e-02f, 4.95546833e-02f,
  2.97620259e-02f, -2.70173177e-02f, 2.35497430e-02f, 5.74883111e-02f, 1.71490107e-02f, 1.00139111e-01f, -9.77558196e-02f, -9.96445939e-02f, -2.24622488e-02f, 3.90647762e-02f,
  -3.06035727e-02f, -2.02903837e-01f, 1.97031908e-02f, 5.13866656e-02f, -8.28398168e-02f, -8.41931179e-02f, 5.77986054e-02f, -1.64714858e-01f, -1.52540788e-01f, 5.40012829e-02f,
  1.58316419e-02f, 5.41666932e-02f, 3.55686769e-02f, 6.41387552e-02f, -9.78427902e-02f, -4.77969497e-02f, -4.96952757e-02f, -6.65607154e-02f, -1.95141579e-03f, -5.06720208e-02f,
  -4.56220619e-02f, 9.93720964e-02f, 3.79875228e-02f, 8.07742923e-02f, -4.76928018e-02f, -7.27856606e-02f, 3.41662727e-02f, 4.51083258e-02f, -8.97919163e-02f, -7.52624571e-02f,
  -3.91126037e-01f, 1.98517397e-01f, -1.75494716e-01f, -3.36155057e-01f, 1.11054815e-01f, -5.48277676e-01f, -5.75385094e-01f, -1.17762111e-01f, -7.06322864e-02f, 1.78555042e-01f,
  -6.42744303e-02f, -3.90436351e-02f, 2.13688007e-03f, -3.25225174e-01f, -6.69847786e-01f, -7.96161145e-02f, -5.12762606e-01f, -2.52516180e-01f, 1.50452822e-01f, -1.24711975e-01f,
  -1.22702703e-01f, -2.00398088e-01f, -2.15964496e-01f, 1.47263527e-01f, -2.67655879e-01f, 5.60581535e-02f, -7.56935850e-02f, 1.91617250e-01f, -2.30409920e-01f, -1.28498763e-01f,
  -4.29709395e-03f, 1.17763631e-01f, -2.10697833e-03f, -6.56729862e-02f, -1.02593571e-01f, -2.38692369e-02f, -1.00076616e-01f, -4.12984230e-02f, -2.72418763e-02f, -2.57817153e-02f,
  6.28084466e-02f, 4.44792435e-02f, -3.40125598e-02f, 8.32605213e-02f, -6.44403920e-02f, -2.24955883e-02f, -2.20690388e-03f, -5.39047010e-02f, -4.05381843e-02f, -2.26422362e-02f,
  4.64918502e-02f, 5.68035245e-03f, -4.64686938e-02f, -9.39000398e-03f, 2.65294798e-02f, 4.06957045e-02f, 3.28432061e-02f, -6.98957369e-02f, 5.39926663e-02f, -4.21271548e-02f,
  9.46669094e-03f, 6.46412522e-02f, -1.05059566e-02f, 5.73183186e-02f, 1.50150117e-02f, -9.41134170e-02f, -5.00375056e-04f, -4.56984490e-02f, 1.58092324e-02f, 2.57569086e-02f,
  2.44806502e-02f, 3.05994973e-02f, 7.67699182e-02f, 4.79660518e-02f, 8.53361189e-02f, 4.13554497e-02f, 8.13361779e-02f, 2.87361420e-03f, -2.94703767e-02f, -4.68230695e-02f,
  1.00899935e-01f, -8.87989402e-02f, 2.14634836e-02f, 2.80461013e-02f, -7.70882368e-02f, 4.98023070e-02f, 4.84887362e-02f, -2.25426676e-03f, 8.19757506e-02f, -2.70977058e-03f,
  -1.35660440e-01f, -2.56254196e-01f, -3.62590961e-02f, 2.41707638e-02f, 7.73354471e-02f, -3.59506998e-03f, 2.04120204e-02f, -5.12942597e-02f, -8.66207182e-02f, -1.12044215e-01f,
  -7.99138173e-02f, 6.88635260e-02f, -4.16643843e-02f, 4.02943008e-02f, 6.00017309e-02f, -6.77209496e-02f, -4.78005894e-02f, -7.45971650e-02f, -5.43491282e-02f, 1.18123647e-02f,
  6.81879595e-02f, 6.01844639e-02f, -2.02031117e-02f, -3.86355110e-02f, 2.69564278e-02f, -2.55801100e-02f, -9.25282240e-02f, 8.54811147e-02f, -2.79551651e-02f, 7.42024109e-02f,
  -7.50525966e-02f, 1.85275614e-01f, 3.05757016e-01f, -4.06903476e-01f, 7.94803575e-02f, 5.05691990e-02f, -2.21941695e-01f, 1.03100270e-01f, 9.50477496e-02f, 3.76155563e-02f,
  -6.82094693e-02f, 3.83978151e-02f, 1.54328734e-01f, -1.27400085e-01f, 4.31011282e-02f, 1.35057837e-01f, -3.40948194e-01f, -1.75725490e-01f, 9.48088467e-02f, -3.77482235e-01f,
  -1.54017046e-01f, -4.05570269e-01f, -4.33249921e-02f, 7.61817247e-02f, -2.21634701e-01f, -1.10257760e-01f, -3.15608144e-01f, -2.82035675e-02f, 6.30925968e-03f, 1.30590588e-01f,
  6.24619611e-02f, 2.27793530e-01f, 5.31063080e-02f, 1.30911529e-01f, -9.54403207e-02f, -9.12891049e-03f, -1.08157785e-03f, 4.67832237e-02f, 7.62579739e-02f, 3.36941257e-02f,
  -1.59013137e-01f, 9.10529271e-02f, -5.64660318e-02f, 1.01694331e-01f, -8.88180956e-02f, 4.98599745e-02f, 7.16707204e-03f, 8.91268328e-02f, 7.49858171e-02f, 5.17147072e-02f,
  1.19093722e-02f, -7.40914792e-02f, -8.93030465e-02f, 5.92047088e-02f, -4.39427979e-02f, -2.54670810e-02f, 7.21881539e-02f, 1.35339126e-01f, -3.79814282e-02f, -9.65933055e-02f,
  2.82810703e-02f, 5.40437400e-02f, 6.37705550e-02f, -3.72966602e-02f, 3.36285718e-02f, 1.70263335e-01f, 6.98291138e-02f, 1.02988351e-02f, 1.05633721e-01f, -1.25848845e-01f,
  -3.26809958e-02f, -1.41277298e-01f, -1.02363691e-01f, -2.55423784e-02f, -1.76226139e-01f, -9.34297070e-02f, 5.53206075e-03f, 5.32132536e-02f, -8.58590230e-02f, -1.41558886e-01f,
  -2.82890499e-02f, 1.99561026e-02f, 3.02195400e-02f, -2.46373072e-01f, -5.36983162e-02f, -1.20088093e-01f, -9.00864154e-02f, -4.65911552e-02f, -6.67239875e-02f, -8.44169557e-02f,
  2.27786577e-03f, 3.59530710e-02f, 8.93615037e-02f, 7.72328451e-02f, 1.04197608e-02f, -2.71502919e-02f, -1.31257484e-02f, 8.53440166e-02f, -1.38713256e-01f, 1.25595793e-01f,
  1.38939247e-02f, -2.42105335e-01f, -6.36819750e-02f, -1.03144161e-01f, -3.69847864e-02f, 6.20015711e-02f, -3.84431966e-02f, 7.45928138e-02f, -1.26815766e-01f, 2.04080483e-03f,
  7.90776238e-02f, 3.20614241e-02f, 1.20246507e-01f, -1.32534504e-01f, 2.47275848e-02f, -1.51870698e-01f, 7.76913837e-02f, -5.29610254e-02f, -1.23054281e-01f, -8.92330855e-02f,
  -1.13772184e-01f, 2.70600226e-02f, 4.00336087e-01f, -5.59649289e-01f, 1.75218433e-02f, 1.05119921e-01f, -8.02088901e-02f, -7.42652267e-02f, -2.79186964e-01f, -3.05922687e-01f,
  -3.09167475e-01f, 1.57106116e-01f, 2.45734468e-01f, -4.74417031e-01f, 4.06335294e-01f, 1.72638491e-01f, -1.59130186e-01f, -8.19320455e-02f, 1.68659851e-01f, -1.26727685e-01f,
  -1.24093546e-02f, -2.68874079e-01f, 3.83136839e-01f, 6.99947253e-02f, 6.54112995e-02f, -1.89702973e-01f, -7.18279332e-02f, 1.78756610e-01f, -1.19059429e-01f, 1.91270113e-01f,
  6.88693449e-02f, -2.66446233e-01f, -1.11798175e-01f, 5.87261794e-03f, -1.60851285e-01f, 6.08953051e-02f, 2.94057094e-02f, 4.28307839e-02f, -1.98078394e-01f, -3.26797739e-02f,
  -1.40744331e-03f, 8.23408067e-02f, -1.11570112e-01f, 3.74018140e-02f, -6.82303309e-02f, -1.16834849e-01f, 1.75696939e-01f, 9.25547183e-02f, -1.93341225e-02f, 1.20524064e-01f,
  1.39612705e-01f, 4.49781567e-02f, 2.42273416e-02f, -7.02442750e-02f, 1.63589701e-01f, -1.17675737e-01f, -9.02144462e-02f, 8.44292045e-02f, 1.98368188e-02f, -1.21256292e-01f,
  -1.32867724e-01f, 6.34736270e-02f, 4.57578152e-02f, -1.11855846e-02f, 1.22241162e-01f, -1.72434375e-02f, 8.31702128e-02f, -2.27949880e-02f, 9.37927291e-02f, -2.19148528e-02f,
  -5.06171398e-02f, 3.47550884e-02f, -4.76606488e-02f, -3.49163567e-03f, 4.21733130e-03f, -6.94432333e-02f, 4.22068052e-02f, 1.10925458e-01f, 8.37047994e-02f, 3.54355201e-02f,
  2.59194262e-02f, -2.23560389e-02f, 8.67924094e-02f, -7.16803316e-03f, 4.60589014e-04f, 1.19547449e-01f, -1.79506518e-04f, 6.31995872e-02f, -2.26526614e-02f, 7.82900974e-02f,
  -8.39714035e-02f, -2.89545119e-01f, -1.66326374e-01f, -3.67852636e-02f, 6.93468973e-02f, 3.41790356e-02f, -1.22801401e-02f, -4.24952172e-02f, -5.02248481e-02f, -6.95376843e-02f,
  -6.97905570e-02f, -8.54505748e-02f, -5.61340041e-02f, -4.19227518e-02f, 1.95609972e-01f, -3.62816826e-02f, 6.14367649e-02f, -6.63245618e-02f, -8.22357237e-02f, 1.97598860e-01f,
  1.13298938e-01f, -3.53153166e-03f, 3.34242433e-02f, -9.40452665e-02f, -1.19574234e-01f, 4.58811708e-02f, -4.87521999e-02f, -4.63579670e-02f, 1.51077822e-01f, -7.07120076e-02f,
  -4.94684912e-02f, 5.76336086e-01f, 3.96188945e-01f, 3.43015969e-01f, -2.69692004e-01f, -5.77410996e-01f, -3.20205301e-01f, 2.29274869e-01f, -2.70625710e-01f, 2.12038636e-01f,
  -4.02308889e-02f, 3.33355159e-01f, -3.37662473e-02f, -1.22208491e-01f, -4.97268438e-01f, -3.26002926e-01f, -1.65108994e-01f, -1.02510583e-02f, -2.27932915e-01f, 1.97047055e-01f,
  5.28726215e-03f, -3.19504619e-01f, 6.80154040e-02f, -7.89189339e-02f, 1.99145555e-01f, 3.23152184e-01f, 2.01235607e-01f, 1.08902223e-01f, 2.34757751e-01f, -1.45932212e-01f,
  -3.65965843e-01f, 3.16033699e-02f, 2.57105380e-01f, 1.84362661e-03f, 3.39342318e-02f, 1.06521197e-01f, 9.88281891e-02f, -1.31979166e-02f, 2.10641995e-02f, 6.00548685e-02f,
  2.66549457e-02f, -1.74109153e-02f, -5.74304536e-02f, -7.32034743e-02f, -2.79499032e-02f, 1.48114264e-01f, 1.90309733e-02f, -1.33809438e-02f, 1.65633932e-01f, 1.80874430e-02f,
  1.06702797e-01f, 4.30875793e-02f, 9.35451314e-02f, -3.31330560e-02f, 2.57670563e-02f, -2.52643228e-02f, -5.48241585e-02f, 5.11381635e-03f, 3.06747053e-02f, -7.56069124e-02f,
  -8.56224000e-02f, 1.12493839e-02f, 4.35811542e-02f, -5.54785617e-02f, 4.97090369e-02f, 6.90046931e-03f, -1.22553557e-02f, -3.79274637e-02f, 2.35739164e-03f, -2.06504297e-03f,
  -2.17772070e-02f, 5.43968529e-02f, -8.16380903e-02f, 9.76067688e-03f, -3.50895524e-03f, 5.81240430e-02f, 5.70159545e-03f, 4.67748791e-02f, 1.75955500e-02f, 3.68306926e-03f,
  -7.08704814e-02f, -4.32648696e-02f, 4.22536172e-02f, -3.96362916e-02f, -1.16993887e-02f, 6.62808865e-02f, 1.59032959e-02f, 4.29745540e-02f, 3.65443826e-02f, 1.54227763e-02f,
  5.09472117e-02f, 4.03664351e-01f, -6.43259585e-02f, -8.37938339e-02f, -1.43620363e-02f, 2.72573978e-02f, -6.05084524e-02f, 5.50315939e-02f, 6.09748391e-03f, -5.07983416e-02f,
  1.03160888e-01f, 6.68419376e-02f, -2.02868283e-02f, 7.60995597e-03f, -1.32754454e-02f, -5.79802431e-02f, 1.30570278e-01f, 1.69584956e-02f, 3.15928832e-02f, 8.87659490e-02f,
  1.21744387e-01f, -3.70580591e-02f, -6.42759399e-03f, 5.79322577e-02f, -1.33927586e-02f, -4.79375385e-03f, 4.09826040e-02f, -3.86063531e-02f, 1.59287415e-02f, -3.88056748e-02f,
  -4.22088534e-01f, 1.07966289e-01f, 3.52382511e-01f, 1.32069811e-01f, -5.99716842e-01f, -5.89072295e-02f, 5.74365497e-01f, -4.82476920e-01f, 4.66666780e-02f, 3.34317476e-01f,
  1.53201312e-01f, 8.93601626e-02f, 3.44684392e-01f, 3.80383760e-01f, -1.68287680e-02f, 4.73103523e-01f, 1.28895670e-01f, 2.09659070e-01f, -3.95421870e-02f, -2.42925674e-01f,
  1.15015786e-02f, -2.03551292e-01f, 3.81170034e-01f, -3.05132210e-01f, -2.18852922e-01f, -2.34727889e-01f, -5.77173159e-02f, -3.18727344e-02f, -2.77268048e-02f, -4.92869243e-02f,
  -7.56606683e-02f, -1.24339320e-01f, -4.28338014e-02f, 6.82688430e-02f, -1.21856235e-01f, -7.76772648e-02f, 6.39477670e-02f, 1.56485692e-01f, 6.10811338e-02f, 7.14475289e-03f,
  8.23257864e-03f, -8.00574869e-02f, -6.74958006e-02f, -4.35340479e-02f, -1.78240195e-01f, -5.89021854e-02f, -1.22837216e-01f, -1.19203329e-02f, 1.05780289e-02f, 1.39582418e-02f,
  6.82685375e-02f, -5.32026105e-02f, -1.57631058e-02f, 9.75993723e-02f, -1.11510707e-02f, -1.76514927e-02f, 1.83377996e-01f, -1.22294119e-02f, -1.69918872e-02f, -8.21707696e-02f,
  2.67796125e-03f, -5.81890717e-03f, 8.16550385e-03f, 1.16825970e-02f, 2.51000728e-02f, 9.59773362e-03f, 7.55528212e-02f, 1.61875077e-02f, -1.03436818e-03f, 1.29552037e-01f,
  -6.21840768e-02f, -2.50147916e-02f, -9.59492847e-02f, 7.91345388e-02f, -5.88831417e-02f, 3.69898183e-03f, 2.40476951e-02f, -2.56373677e-02f, -3.38487439e-02f, -6.11893199e-02f,
  1.00589860e-02f, -3.82444425e-03f, -2.43180580e-02f, -1.58074964e-02f, 3.92318517e-02f, 6.43237436e-04f, -3.01604550e-02f, -7.83527363e-03f, 1.26771376e-01f, -1.57190040e-02f,
  -2.81954497e-01f, -1.44365504e-01f, -1.75402854e-02f, 4.35803123e-02f, 1.93340401e-03f, -2.23975293e-02f, 9.77979600e-02f, -1.46209002e-02f, -1.80559903e-01f, -2.30314005e-02f,
  -6.58109412e-02f, 2.86507979e-02f, -4.72509079e-02f, 3.03543881e-02f, 7.45921582e-02f, -9.53234546e-03f, 7.12292194e-02f, -7.85446092e-02f, -1.09481938e-01f, -2.39946581e-02f,
  7.38037750e-02f, -1.83406584e-02f, 2.62316298e-02f, -1.37028098e-01f, 6.45869598e-02f, 6.69451896e-03f, -2.34957427e-01f, -9.87366363e-02f, -9.20486301e-02f, 3.78090329e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  -1.48407981e-01f, -1.00993253e-01f, 9.94497761e-02f, 3.33817989e-01f, 9.33628306e-02f, -9.03520659e-02f, 2.30046198e-01f, 9.01392773e-02f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.21796140e-01f, -7.69833028e-02f, -4.34505373e-01f, -5.81031144e-02f, 5.30213892e-01f, 1.90350264e-01f, 1.60124749e-01f, -1.07715026e-01f, -8.89893398e-02f, -5.07210791e-02f,
  -7.53334984e-02f, 3.99230421e-01f, 1.82917193e-01f, -3.11551485e-02f, -4.81700122e-01f, -2.53274351e-01f, 1.21906444e-01f, -5.47408983e-02f, 1.65989012e-01f, -2.31544033e-01f,
  4.10220951e-01f, 3.71374637e-01f, 1.09523581e-02f, 3.18754107e-01f, 1.26386017e-01f, -1.17332712e-01f, 6.38047084e-02f, -2.45947108e-01f, -2.27807194e-01f, -3.77896696e-01f,
  1.66605674e-02f, 1.29581898e-01f, 2.06681490e-01f, 2.37913921e-01f, -3.29971582e-01f, 2.02356160e-01f, -7.12559521e-02f, -7.37417787e-02f, 1.82624966e-01f, -2.08779067e-01f,
  2.13923752e-01f, 1.84396639e-01f, 2.41095871e-01f, -2.34120056e-01f, 1.00677885e-01f, 2.37482339e-01f, -6.45727336e-01f, 4.95078981e-01f, -2.48210087e-01f, -2.59511113e-01f,
  -1.62221603e-02f, 9.41055119e-02f, 4.45528567e-01f, 2.93023102e-02f, 2.41537571e-01f, -2.58844078e-01f, 6.68447390e-02f, -4.21216190e-02f, -1.28156513e-01f, 2.65801758e-01f,
  8.28144550e-02f, -1.50026426e-01f, -2.06613932e-02f, -7.57006928e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -9.48990285e-02f, 6.14887834e-01f, -4.35592741e-01f, 4.45163488e-01f, -3.14240575e-01f, 4.32220876e-01f, 8.99934769e-03f, 7.97858894e-01f, 1.03854820e-01f, 8.00003052e-01f,
  6.94384038e-01f, -1.27275512e-01f, -1.36585906e-01f, 4.63901550e-01f, -5.43822765e-01f, 7.13015273e-02f, -2.35050797e-01f, -1.54015079e-01f, 4.68655787e-02f, 8.47720563e-01f,
  8.76962423e-01f, 3.52525294e-01f, 1.09637588e-01f, 8.44374374e-02f, 1.01007670e-01f, 7.27802292e-02f, 1.49905365e-02f, 3.28620374e-01f, 4.44192067e-02f, -2.13927180e-01f,
  -2.93732118e-02f, -3.29393774e-01f, 6.29415214e-01f, 1.19088339e-02f, -6.60800338e-01f, 3.00884575e-01f, 7.81657547e-02f, -3.93838853e-01f, -4.05503750e-01f, 8.17343965e-02f,
  2.35793386e-02f, 5.68375528e-01f, -1.75196633e-01f, 6.09024107e-01f, 3.27496022e-01f, 5.44987023e-01f, -1.73885182e-01f, -1.28471211e-01f, 5.62394559e-01f, 1.41303271e-01f,
  1.21370889e-01f, 9.69290197e-01f, -2.79486477e-01f, -2.12574005e-01f, 6.93311036e-01f, -5.05240679e-01f, 1.58765629e-01f, 2.58708954e-01f, -1.11928917e-01f, 1.01732719e+00f,
  7.64994144e-01f, 1.70469299e-01f, 6.99832618e-01f, 5.13526917e-01f, 4.15349931e-01f, -5.38532622e-02f, 5.84118009e-01f, -3.93896192e-01f, 7.26535141e-01f, 5.56092203e-01f,
  9.29268003e-02f, 1.57507941e-01f, 7.21275985e-01f, -3.93723875e-01f, -5.24000823e-01f, 1.91889167e-01f, -3.79336357e-01f, -2.83918023e-01f, 4.00318056e-01f, 4.33208972e-01f,
  -4.34143603e-01f, -3.55628073e-01f, -6.43163621e-02f, -6.07632875e-01f, -3.13430429e-01f, -1.56460047e-01f, 3.03159729e-02f, -4.26950663e-01f, -4.52613160e-02f, -2.24556610e-01f,
  8.20131525e-02f, -2.16954574e-02f, 2.11467177e-01f, -2.12352499e-01f, -3.44523460e-01f, -1.03555601e-02f, 2.98512518e-01f, -4.95249406e-02f, 3.18718344e-01f, 4.61504519e-01f,
  -1.96804151e-01f, -4.50348198e-01f, 2.10531488e-01f, 1.56878531e-01f, 4.21855748e-02f, -4.70326573e-01f, -2.74587929e-01f, -9.07595735e-03f, 1.08626679e-01f, 2.60226250e-01f,
  6.15203261e-01f, -1.79821387e-01f, 3.55904341e-01f, 5.73207378e-01f, 1.51950151e-01f, 2.80009776e-01f, -4.78033900e-01f, 6.38062432e-02f, -8.84814560e-02f, -3.75695646e-01f,
  -5.34789205e-01f, 3.70833874e-01f, 4.39777493e-01f, -4.74929601e-01f, 4.56245430e-02f, 4.22282249e-01f, -2.92646792e-02f, 9.98215973e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  3.55359852e-01f, 8.59401599e-02f, 1.74647540e-01f, 6.88551962e-01f, 1.10648647e-01f, -2.26381674e-01f, 2.56749745e-02f, 1.83120191e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.26591522e-01f, 1.17224060e-01f, 1.33992573e-02f, -3.93313646e-01f, 2.99441487e-01f, -2.43980959e-01f, 3.30939382e-01f, -2.55622119e-01f, 1.57567441e-01f, 2.11021751e-01f,
  4.00161386e-01f, -1.11602060e-01f, -2.64027476e-01f, 2.02038050e-01f, -7.10490867e-02f, 8.45169947e-02f, -1.39140114e-01f, 6.48934320e-02f, 4.68842983e-01f, 3.60134803e-02f,
  -7.21749440e-02f, -8.05601776e-02f, 2.13308096e-01f, -2.06998348e-01f, -2.60629859e-02f, 6.55858994e-01f, 2.75935709e-01f, 2.26478614e-02f, -5.79640627e-01f, 1.38301641e-01f,
  3.34817678e-01f, 5.49435914e-02f, 5.08820176e-01f, 5.34095243e-02f, 1.36696115e-01f, 2.27470413e-01f, -5.12230992e-02f, -2.41148189e-01f, 4.57643196e-02f, -7.74321780e-02f,
  -1.94362611e-01f, 5.08663297e-01f, 2.62556583e-01f, 2.26561688e-02f, -6.49846256e-01f, 3.40444952e-01f, 4.15064573e-01f, -1.38586372e-01f, 1.36967555e-01f, -4.35812235e-01f,
  -1.21027544e-01f, -1.04190186e-01f, 3.75393964e-02f, 2.52403557e-01f, 4.20524806e-01f, -2.71792591e-01f, -6.97159097e-02f, -5.09810209e-01f, -3.14460099e-01f, -9.93040204e-02f,
  2.97731400e-01f, 9.87556390e-03f, -1.83290660e-01f, 2.09812094e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  9.54425216e-01f, 3.47848952e-01f, 6.52087271e-01f, 6.55464828e-01f, -1.15378261e-01f, 1.72567949e-01f, 3.00830245e-01f, 2.49714836e-01f, 8.09434503e-02f, 3.46946061e-01f,
  -9.53702092e-01f, 5.72851747e-02f, 5.11176050e-01f, -5.98494351e-01f, -3.44122082e-01f, 1.60366073e-02f, -9.70810652e-03f, 5.06624937e-01f, -1.29877999e-01f, 2.94672012e-01f,
  -3.08325917e-01f, -1.16350770e-01f, 6.65559530e-01f, -4.42991823e-01f, 1.09013546e+00f, -6.97054937e-02f, 4.90554005e-01f, 3.94529283e-01f, -6.14029348e-01f, 9.05444659e-03f,
  -2.99900204e-01f, 5.68618715e-01f, 2.47795001e-01f, 2.83915609e-01f, 4.72049266e-01f, 7.66459167e-01f, -2.53090203e-01f, 1.62218243e-01f, -4.81098145e-01f, 6.97428226e-01f,
  -2.12433621e-01f, 4.07171041e-01f, -2.74399407e-02f, 7.51550972e-01f, 9.46452498e-01f, -3.98900747e-01f, 4.24075544e-01f, -1.87129155e-01f, 6.90512419e-01f, 4.56551105e-01f,
  9.34569836e-02f, -2.15190500e-02f, 3.85456592e-01f, 1.73718199e-01f, 8.83087635e-01f, -1.71659905e-02f, 8.47949028e-01f, 6.26848459e-01f, 7.05769539e-01f, 4.66201633e-01f,
  -1.15613788e-01f, -3.66353065e-01f, -3.54174495e-01f, 3.29292953e-01f, -5.16235471e-01f, 5.21889478e-02f, 3.35072100e-01f, -6.74206018e-02f, -6.10064745e-01f, -8.42030704e-01f,
  -1.28145921e+00f, 1.71996936e-01f, -4.19340491e-01f, 4.27761465e-01f, 9.31136776e-03f, 5.88413656e-01f, -2.94973310e-02f, -3.86650443e-01f, 8.43208969e-01f, -3.95520687e-01f,
  -4.41463590e-01f, 2.28286207e-01f, -2.08351672e-01f, 6.01395190e-01f, -9.67615783e-01f, -1.82565242e-01f, 4.17416811e-01f, -7.25881875e-01f, 3.39369215e-02f, -1.07746983e+00f,
  -4.40895557e-01f, 3.47059280e-01f, 5.58476448e-01f, 9.35822353e-02f, 3.21853280e-01f, 9.54044759e-01f, 2.61869192e-01f, 4.50123370e-01f, 3.45290601e-01f, -4.34620976e-02f,
  -3.73945326e-01f, 3.41974825e-01f, 3.37112904e-01f, -3.40114713e-01f, 6.91485882e-01f, -1.36315584e-01f, -4.52119410e-01f, -3.95622611e-01f, 3.64238262e-01f, -1.05978405e+00f,
  -1.07947707e+00f, 3.86277199e-01f, -8.30195099e-02f, -3.37287188e-01f, 7.70268787e-04f, 2.37384513e-01f, -1.77154973e-01f, -6.54524505e-01f, 3.67981434e-01f, -4.93264049e-01f,
  -4.08353023e-02f, -4.46117282e-01f, 7.16417551e-01f, 3.94201517e-01f, -6.43169088e-03f, 3.69861096e-01f, 7.11930633e-01f, 8.58022943e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  4.77108091e-01f, 4.39442731e-02f, 7.41957605e-01f, 2.73097843e-01f, 3.65177870e-01f, 6.05983019e-01f, 5.35327077e-01f, -7.66629204e-02f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  1.22395858e-01f, -3.55783999e-01f, -5.08002281e-01f, 1.64182052e-01f, -2.38737598e-01f, -3.94951254e-01f, -1.39456317e-01f, 4.32554120e-03f, -3.69975455e-02f, -2.82904990e-02f,
  2.25052342e-01f, -3.01975995e-01f, -1.61611512e-01f, 3.32721770e-01f, -2.47321784e-01f, -9.17081237e-02f, -1.10215038e-01f, -1.21063255e-01f, 1.67215407e-01f, -3.12059432e-01f,
  9.03607979e-02f, 3.76130939e-01f, 2.11654380e-01f, 1.51794314e-01f, -4.22774732e-01f, 9.72418562e-02f, -6.02295287e-02f, 1.07471934e-02f, 1.69590101e-01f, -1.65361509e-01f,
  -3.09997350e-01f, 2.37854615e-01f, 1.67900827e-02f, -1.42290816e-01f, -4.97169703e-01f, 4.86783504e-01f, -6.46265149e-02f, -1.53710008e-01f, -4.37275805e-02f, -2.97785718e-02f,
  5.24989426e-01f, -2.38325968e-01f, 3.03811997e-01f, -2.57173568e-01f, -5.44400275e-01f, 1.15715899e-01f, -4.92287241e-02f, 2.30717912e-01f, -8.09027255e-02f, 2.21246071e-02f,
  -3.61157835e-01f, -2.75453746e-01f, 6.67994469e-02f, 1.04470596e-01f, 3.58975798e-01f, -2.97147352e-02f, 3.13895851e-01f, 1.81948423e-01f, -8.58798176e-02f, -3.60005766e-01f,
  2.16705874e-01f, 4.26128834e-01f, 3.16477120e-01f, -1.88578784e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  5.30654527e-02f, 4.58970100e-01f, 6.16472244e-01f, 7.92000175e-01f, 8.05295587e-01f, 1.27639413e+00f, 7.61392355e-01f, -9.38951194e-01f, 1.91314578e-01f, 6.04564428e-01f,
  -2.46333972e-01f, 6.12705767e-01f, -5.32861769e-01f, 8.74766231e-01f, 4.09590602e-02f, 4.85058397e-01f, 2.87831068e-01f, 1.94417939e-01f, -6.14644699e-02f, 8.23607683e-01f,
  -5.40123820e-01f, -6.58204973e-01f, -6.25436127e-01f, 7.27220118e-01f, 1.16846836e+00f, -4.81695272e-02f, 7.51509964e-01f, 1.24691501e-01f, -6.98362112e-01f, 6.38277113e-01f,
  7.97414899e-01f, -7.00591147e-01f, 7.75049746e-01f, 6.36753917e-01f, 7.82592595e-01f, 3.53013456e-01f, -4.38946456e-01f, -2.17422787e-02f, -2.31567398e-01f, -7.83976316e-02f,
  1.05770099e+00f, -4.40586172e-02f, 8.01560104e-01f, 5.33072650e-01f, -1.86875284e-01f, -4.97098178e-01f, 1.14929602e-01f, -4.63129461e-01f, 9.94041324e-01f, 6.79969192e-01f,
  7.74785399e-01f, -2.23953500e-01f, -2.80174255e-01f, 1.07341444e+00f, 9.68516469e-01f, -1.05380845e+00f, -1.72431707e-01f, -2.38096669e-01f, 8.24319363e-01f, 4.01182145e-01f,
  9.76277351e-01f, -4.43198800e-01f, -3.88059795e-01f, 6.68026984e-01f, -5.18299043e-01f, -4.12994355e-01f, -2.93573499e-01f, 5.31703457e-02f, -6.68283165e-01f, -4.15768147e-01f,
  -2.67513663e-01f, -2.64355123e-01f, 2.26534903e-01f, -5.96702516e-01f, 5.18522382e-01f, -8.35814953e-01f, 4.08392668e-01f, 2.79176772e-01f, -8.20500776e-02f, -6.17721863e-02f,
  -1.48455054e-01f, 2.39411350e-02f, -3.20740700e-01f, 2.00120270e-01f, -4.59513068e-01f, -2.69969106e-01f, -1.12183355e-01f, -5.13630748e-01f, -7.91545063e-02f, -3.52954306e-02f,
  4.11417633e-01f, -6.06672108e-01f, 4.64445859e-01f, 1.26165986e+00f, -4.35825348e-01f, 3.83146912e-01f, -5.39094567e-01f, 3.07086378e-01f, 3.69976491e-01f, 2.96029598e-01f,
  9.13012505e-01f, 7.62056470e-01f, 9.77441669e-02f, -3.54407817e-01f, -1.90206200e-01f, 1.23613405e+00f, -1.75176516e-01f, 1.09183991e+00f, -3.48154277e-01f, 2.53213584e-01f,
  6.79806948e-01f, 5.82675815e-01f, 5.97707629e-01f, 7.52795637e-02f, 1.45380512e-01f, 3.56047750e-01f, -2.69533932e-01f, -4.38023239e-01f, -6.89996064e-01f, 1.95577011e-01f,
  7.11787641e-01f, 7.16312453e-02f, 1.14348009e-01f, 1.65662169e-01f, -6.62002191e-02f, 5.16936958e-01f, 1.29563212e+00f, -6.20921254e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  3.31625581e-01f, 1.04647890e-01f, 2.89202929e-01f, 3.69363666e-01f, 2.61542737e-01f, 2.23670989e-01f, 2.66955793e-01f, 6.27692580e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -4.13399220e-01f, -2.45435357e-01f, -3.25947970e-01f, -1.47178648e-02f, 7.41711199e-01f, -2.07298808e-03f, 6.15205824e-01f, -6.64950311e-02f, -1.23420976e-01f, 4.34763193e-01f,
  -1.52551040e-01f, -1.13871789e+00f, -8.92672420e-01f, 4.68201935e-01f, -2.76132464e-01f, 3.59092951e-01f, 2.44943872e-01f, -4.00341988e-01f, -4.33821946e-01f, 3.49603146e-01f,
  -1.42489851e-01f, -1.58020765e-01f, 6.32651031e-01f, -5.63080549e-01f, -2.33486786e-01f, 3.38026524e-01f, 6.66052043e-01f, -1.17414743e-01f, -5.97377181e-01f, -1.12747753e+00f,
  -2.78498471e-01f, 5.91722503e-02f, -3.92441481e-01f, -1.88424185e-01f, 1.45383915e-02f, -4.41567361e-01f, 6.44641459e-01f, 1.28863260e-01f, 1.37910270e-03f, 2.58050948e-01f,
  -1.13824403e+00f, 5.07178247e-01f, 1.95940971e-01f, -1.14114821e+00f, 6.20253533e-02f, -3.47929567e-01f, -9.98877585e-01f, 6.58058643e-01f, -2.59979427e-01f, -4.57554966e-01f,
  -1.59365803e-01f, -6.09786399e-02f, -4.20983434e-01f, 5.70379853e-01f, -4.62465972e-01f, -5.62265813e-01f, -7.77596116e-01f, -7.64939547e-01f, 7.30197728e-02f, 7.46885955e-01f,
  -6.00648820e-01f, -3.45892638e-01f, -3.82606924e-01f, -1.24310029e+00f, 3.86679769e-01f, 3.54541212e-01f, 5.97236037e-01f, 1.20894325e+00f, -9.53852355e-01f, 1.50465024e+00f,
  -1.51969671e+00f, -6.11467183e-01f, 4.71293747e-01f, -9.77755010e-01f, -5.40596724e-01f, -5.88602349e-02f, -4.30214256e-01f, -1.38191342e-01f, 1.55155897e-01f, -4.43447679e-01f,
  9.00411606e-01f, 9.86441016e-01f, 1.11416197e+00f, -3.42424840e-01f, -9.02687013e-02f, -9.02642488e-01f, 5.04757702e-01f, 6.42168343e-01f, 3.38909358e-01f, 3.35534215e-02f,
  -1.15892097e-01f, -2.86043584e-01f, -1.96531445e-01f, 1.94401309e-01f, -1.28254995e-01f, -1.02277189e-01f, 1.36355773e-01f, -6.48385406e-01f, 4.12363619e-01f, -7.12386847e-01f,
  -7.49112785e-01f, -4.74773586e-01f, -1.19611108e+00f, 3.26310039e-01f, 6.76137209e-03f, 1.04923256e-01f, -9.85526070e-02f, -1.35029483e+00f, -3.14338088e-01f, -1.27675390e+00f,
  1.30070403e-01f, 4.84816104e-01f, -5.06979346e-01f, -3.37598294e-01f, -7.65671968e-01f, -1.10456693e+00f, 5.69848537e-01f, -2.26788804e-01f, 8.68080795e-01f, -1.84324801e-01f,
  2.07577065e-01f, -1.32563674e+00f, -2.46203188e-02f, -2.51379222e-01f, 5.59340343e-02f, -1.00175416e+00f, 4.39042419e-01f, -1.42382765e+00f, -6.81600273e-01f, -2.58504033e-01f,
  -4.78234708e-01f, 7.86593184e-02f, -3.02689467e-02f, -4.69474167e-01f, -3.61650854e-01f, -2.47022323e-02f, -5.97844601e-01f, 2.85205573e-01f, -1.83546051e-01f, -3.90981346e-01f,
  6.02100432e-01f, 8.37153316e-01f, -7.03252912e-01f, -2.49959543e-01f, -3.13997418e-02f, 8.04125011e-01f, -7.46797442e-01f, 3.13653164e-02f, -4.91261125e-01f, -1.05487399e-01f,
  5.26405036e-01f, 4.47462767e-01f, 3.00423801e-01f, -3.05356205e-01f, -1.36554956e+00f, -1.04069018e+00f, -1.84918806e-01f, -4.48339045e-01f, 3.51785183e-01f, 4.51493412e-02f,
  3.52184236e-01f, 9.49170291e-01f, 7.06089973e-01f, 4.93011951e-01f, 1.32530853e-01f, -6.37449026e-01f, 3.83945554e-01f, 1.61066458e-01f, -9.11912501e-01f, -2.11319387e-01f,
  6.06922030e-01f, 4.18046743e-01f, 1.56871647e-01f, -8.80162641e-02f, -1.02683759e+00f, -1.61515892e-01f, 1.76906645e-01f, -9.80359092e-02f, 4.66104522e-02f, -3.71057063e-01f,
  8.89430225e-01f, 5.28175950e-01f, -1.82021096e-01f, 8.49584416e-02f, -9.99670625e-02f, -6.41168475e-01f, -5.06113291e-01f, 2.06225827e-01f, 4.10032690e-01f, 7.28345275e-01f,
  -5.14589548e-01f, -5.79949796e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.67285228e-01f, -1.36940777e-01f, 2.73647010e-02f, 1.29149675e-01f, 1.93950921e-01f, 3.68949026e-01f, 2.41463944e-01f, -1.16024399e-02f, 5.63900508e-02f, -1.80317685e-01f,
  -1.29679590e-01f, 4.12233993e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    