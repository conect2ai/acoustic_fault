/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.12521139e-02f, -5.63166514e-02f, 4.01124120e-01f, -1.15738988e-01f, 4.95084748e-02f, 1.33870214e-01f, 3.88467126e-02f, -1.17148235e-02f, -2.48742178e-01f, -1.20923594e-01f,
  -4.98587117e-02f, 8.31741989e-02f, -4.49633338e-02f, 4.10579657e-03f, 7.81313982e-03f, -3.93184237e-02f, -1.05214203e-02f, 2.60651410e-01f, 1.44190207e-01f, -3.56014669e-02f,
  -1.05640694e-01f, -1.64238781e-01f, -4.78300676e-02f, -4.48912643e-02f, 1.47008086e-02f, -1.38127908e-01f, 2.37874389e-02f, 1.39475793e-01f, -1.31083326e-02f, 1.08286142e-01f,
  2.44294763e-01f, 2.95762181e-01f, 3.98504734e-03f, 1.32786795e-01f, 8.81203711e-02f, 1.12643071e-01f, -4.28335479e-04f, 2.38772258e-01f, 1.36282071e-01f, 1.31680025e-02f,
  1.89749926e-01f, 1.89593181e-01f, 1.12779163e-01f, 5.63495792e-02f, 5.07554151e-02f, 9.18778926e-02f, 7.67545681e-03f, 1.01865001e-01f, 1.47453412e-01f, 1.95350852e-02f,
  1.44270718e-01f, 1.47431836e-01f, 1.94049612e-01f, 1.35477632e-01f, 5.67249171e-02f, 2.18908772e-01f, 1.26479223e-01f, 1.19901657e-01f, 1.72841325e-02f, -1.34338036e-01f,
  -1.02361098e-01f, 5.75556494e-02f, 4.09674570e-02f, -4.65536714e-02f, 4.32304144e-02f, 2.37962864e-02f, 1.63123477e-02f, -2.21359339e-02f, -4.62518707e-02f, -2.40886770e-02f,
  7.85850361e-02f, -6.34305738e-03f, -5.22403093e-03f, 1.11945183e-03f, -4.98691835e-02f, 1.07619725e-01f, -5.37784211e-02f, -7.85872191e-02f, -3.81016284e-02f, 3.55065800e-02f,
  2.61432026e-02f, 8.70628655e-02f, 7.58349672e-02f, -7.71978498e-02f, -6.26336643e-03f, 6.82418272e-02f, -2.95979809e-02f, 5.73149957e-02f, 3.77397276e-02f, 1.04884773e-01f,
  -3.94001752e-01f, 2.85057008e-01f, -1.00986592e-01f, 1.94459222e-02f, 5.21437563e-02f, 1.64318718e-02f, 2.38429084e-02f, -5.54466732e-02f, 4.40129377e-02f, 2.74887960e-02f,
  4.15748879e-02f, 1.15138471e-01f, -2.11636815e-02f, -8.28361437e-02f, 5.59168607e-02f, 4.18133065e-02f, -7.11307079e-02f, 1.86088271e-02f, -2.31910013e-02f, -2.70930491e-02f,
  -1.04593255e-01f, -1.26944080e-01f, -1.77570224e-01f, -8.54321644e-02f, -8.29789266e-02f, -1.15102500e-01f, -1.08232550e-01f, -5.31442426e-02f, 9.64648649e-03f, -3.87613326e-01f,
  1.83604375e-01f, -1.38697205e-02f, 2.06870601e-01f, 1.40059248e-01f, 1.34932011e-01f, 1.60830840e-01f, 2.71137238e-01f, 4.37730625e-02f, -1.77917592e-02f, 1.88701395e-02f,
  -1.33489326e-01f, -2.25829661e-01f, -1.93102717e-01f, -2.35279292e-01f, -7.58298710e-02f, 1.52808249e-01f, 1.74630359e-01f, 1.14420228e-01f, 3.44469026e-02f, 7.89192766e-02f,
  -4.55658101e-02f, 4.38771807e-02f, 1.61911830e-01f, -1.14258789e-02f, 5.23735434e-02f, -5.45883551e-02f, 6.47550225e-02f, 1.55265421e-01f, 1.86888073e-02f, 2.04446516e-03f,
  -6.68904036e-02f, 8.32215846e-02f, -1.36679068e-01f, 2.29078382e-02f, -8.83941632e-03f, -1.03662975e-01f, -1.28550082e-02f, 5.53985238e-02f, 1.46607049e-02f, 3.04576801e-03f,
  -1.59084480e-02f, -3.87914553e-02f, 1.01519786e-01f, 3.40373442e-02f, 2.48275115e-03f, -2.61442102e-02f, 1.09061666e-01f, 9.42663550e-02f, 3.09906062e-03f, -2.19717566e-02f,
  3.27479020e-02f, 1.81500778e-01f, 1.08593374e-01f, 1.23236321e-01f, 9.29299816e-02f, 3.02389972e-02f, 2.51204297e-02f, 1.18975855e-01f, -5.16001284e-02f, -3.39144431e-02f,
  2.55666897e-02f, -1.00660741e-01f, 1.02782682e-01f, -4.41247225e-02f, -2.73500551e-02f, -3.50528918e-02f, -3.65390517e-02f, -9.40153301e-02f, -4.89548370e-02f, -5.66538284e-03f,
  -1.32168680e-01f, -2.92261783e-02f, -9.64029133e-02f, -5.23485094e-02f, 1.08884377e-02f, 5.76446392e-02f, 1.01595886e-01f, 7.02869669e-02f, -6.82223439e-02f, 2.68635117e-02f,
  -1.18842579e-01f, 1.15872949e-01f, 7.11007491e-02f, 1.82734542e-02f, -9.62413661e-03f, -5.17720208e-02f, -3.53543237e-02f, -5.76532036e-02f, -7.67032430e-02f, 2.21117064e-02f,
  -1.36167631e-01f, 1.95402317e-02f, -1.42499015e-01f, -1.00017739e-02f, 5.33851609e-02f, -4.40409556e-02f, -8.87652189e-02f, -2.34115738e-02f, 2.86088269e-02f, -5.07199131e-02f,
  4.10867184e-02f, 1.02181487e-01f, 7.25134313e-02f, 8.05797148e-03f, -7.70714357e-02f, 8.51138011e-02f, -6.89206123e-02f, 3.43782566e-02f, 9.33525525e-03f, 2.37940568e-02f,
  1.06626876e-01f, -1.67766586e-02f, -2.24106889e-02f, -9.58228484e-03f, 5.06377853e-02f, 6.20266274e-02f, 3.29483189e-02f, -7.24737272e-02f, 7.07723349e-02f, -3.96668464e-02f,
  1.56084448e-01f, -1.25013947e-01f, 1.87871888e-01f, -1.19447149e-02f, 1.04306594e-01f, 1.26086190e-01f, 1.64836913e-01f, -1.39088184e-01f, -2.29299814e-01f, -3.48855890e-02f,
  -2.15252206e-01f, -4.00881469e-01f, -1.65288970e-01f, -2.40156054e-01f, 7.35956281e-02f, 8.57191309e-02f, 3.17427993e-01f, 1.98734611e-01f, 1.08583972e-01f, -3.09535842e-02f,
  -9.34651941e-02f, 8.39625224e-02f, 5.60438596e-02f, -1.04670018e-01f, -1.08072549e-01f, -2.20613301e-01f, 1.38586581e-01f, 7.85909146e-02f, -1.25182554e-01f, -9.26310662e-03f,
  4.78239283e-02f, 1.23705208e-01f, 1.49903111e-02f, -1.20874280e-02f, 7.78920436e-03f, -8.61618742e-02f, -5.33508398e-02f, 4.62386571e-02f, -9.91744697e-02f, -1.14509016e-01f,
  4.01329249e-02f, -9.73369852e-02f, -1.40628507e-02f, 4.11348082e-02f, 7.17180893e-02f, 4.57249843e-02f, 1.01637840e-02f, 4.75983918e-02f, 1.00362003e-01f, -4.33001779e-02f,
  6.33056276e-03f, 1.21610574e-02f, 7.49152079e-02f, 4.19223160e-02f, 6.76128864e-02f, -1.97395552e-02f, -8.20190161e-02f, 6.12569936e-02f, -6.74595758e-02f, -2.41468959e-02f,
  -1.35356382e-01f, -1.39103755e-02f, 1.06581524e-01f, 3.09169851e-02f, -1.51128871e-02f, 2.74711326e-02f, -1.49442658e-01f, -5.85531704e-02f, 2.02912278e-02f, -2.97150947e-02f,
  -1.95769910e-02f, -6.86717685e-03f, 2.38886606e-02f, -3.88198420e-02f, -7.03657717e-02f, 5.63306585e-02f, 9.46822751e-04f, -1.08263217e-01f, -2.12729629e-02f, 8.15584213e-02f,
  3.54837701e-02f, -4.34972532e-02f, 6.88356627e-03f, -6.90449625e-02f, 1.38883954e-02f, -3.41223106e-02f, -1.32226080e-01f, -7.56974444e-02f, 4.01252694e-03f, 1.64273959e-02f,
  -5.65908588e-02f, 1.37769297e-01f, 4.65824865e-02f, -1.96070708e-02f, 6.81450441e-02f, -1.92377698e-02f, 3.53915133e-02f, 8.02494958e-02f, -3.47816646e-02f, -8.88424069e-02f,
  -1.30291060e-01f, -4.01336774e-02f, 4.29030024e-02f, 8.30816757e-03f, -9.48390737e-02f, -9.49250981e-02f, -2.02512462e-02f, 4.11242759e-03f, 3.69108953e-02f, 4.50391136e-02f,
  -1.21124275e-02f, -9.20372382e-02f, -2.92509533e-02f, -8.48222524e-02f, -2.74193324e-02f, -3.38899121e-02f, 3.21135744e-02f, -1.04019009e-01f, 3.07405125e-02f, -1.02607831e-01f,
  4.54999119e-01f, 8.33052322e-02f, -2.58216739e-01f, 2.13471614e-03f, 9.29140747e-02f, 4.23008762e-02f, 1.20861135e-01f, 1.21798795e-02f, 9.31249335e-02f, 1.34797990e-01f,
  -7.98575282e-02f, -1.61261350e-01f, -2.16043726e-01f, -2.22241268e-01f, -2.15034872e-01f, 5.23367301e-02f, 1.66988626e-01f, -1.64830729e-01f, -2.09187463e-01f, -1.46986812e-01f,
  9.70934853e-02f, 2.11497411e-01f, 5.42933308e-02f, -1.13404706e-01f, 1.83154553e-01f, -8.60584378e-02f, 8.01441148e-02f, 5.99493496e-02f, -1.13418758e-01f, 2.06006065e-01f,
  -3.34402800e-01f, -3.51488106e-02f, -1.21040627e-01f, -5.11940122e-02f, -1.04611598e-01f, -1.02043115e-01f, -1.94014803e-01f, -7.41968825e-02f, -1.36585921e-01f, -6.28357977e-02f,
  -1.44322917e-01f, -1.30214915e-01f, -1.28999546e-01f, -1.63811997e-01f, -3.33367847e-02f, -1.39178544e-01f, 8.97267610e-02f, -7.68251717e-02f, -1.27668828e-01f, -1.36802152e-01f,
  -4.50621024e-02f, -3.33204754e-02f, -1.04028977e-01f, -1.02205306e-01f, -1.19597375e-01f, 4.28728648e-02f, -8.76953825e-02f, -1.68848291e-01f, -1.20733783e-01f, 2.47138999e-02f,
  -3.63263935e-02f, -2.26397403e-02f, 2.54797912e-03f, 1.33375853e-01f, 1.31420856e-02f, 1.54106589e-02f, 1.18363336e-01f, 8.92087445e-02f, 2.53670160e-02f, 1.52405202e-01f,
  6.54800981e-02f, 6.22634739e-02f, 8.94075334e-02f, 5.21032698e-02f, 5.70073985e-02f, 1.46329910e-01f, -2.00389698e-02f, 5.38891554e-02f, 1.39041945e-01f, 1.14654347e-01f,
  1.18210733e-01f, -1.18346013e-01f, 8.89870226e-02f, -1.02924528e-02f, 9.63921100e-03f, 1.05888397e-01f, 5.47099076e-02f, 3.16711180e-02f, 1.51417896e-01f, 5.07096499e-02f,
  -5.55467186e-03f, -1.01574376e-01f, -1.03968300e-01f, -1.87517643e-01f, -6.56055938e-03f, -1.43536866e-01f, -3.73505987e-02f, -1.56214759e-02f, -9.03443620e-02f, -4.94534150e-02f,
  -1.16559088e-01f, -7.92118087e-02f, 1.61807761e-02f, -9.51974541e-02f, -8.69598389e-02f, -1.87306315e-01f, 1.33367544e-02f, -3.78012881e-02f, -1.09529644e-01f, -7.88165554e-02f,
  -1.27858929e-02f, -3.20268869e-02f, -2.19961293e-02f, -2.89760511e-02f, -1.46078616e-01f, -6.19073659e-02f, -1.39657572e-01f, -4.57293689e-02f, -7.43303522e-02f, 7.50944763e-02f,
  -2.30576470e-01f, 3.24475497e-01f, -1.17514260e-01f, 4.63763019e-03f, 1.69344649e-01f, -4.39725779e-02f, 2.00340614e-01f, 9.38255936e-02f, 3.28944437e-02f, 2.67923206e-01f,
  2.74561405e-01f, 1.78060855e-03f, -3.06701828e-02f, -7.74655938e-02f, -2.31029376e-01f, 9.28461701e-02f, 9.56185721e-03f, -2.34854668e-01f, -5.12947440e-01f, -2.20395684e-01f,
  -5.43846600e-02f, -1.40443280e-01f, -3.04419249e-01f, -2.45754659e-01f, 1.43699974e-01f, -7.74430856e-02f, 1.19535372e-01f, 1.60350546e-01f, 8.26283768e-02f, 3.19197118e-01f,
  1.38839036e-02f, 1.07300192e-01f, -2.33291984e-02f, 7.03284591e-02f, 7.00000376e-02f, 9.36117489e-03f, 1.50413558e-01f, 5.79806715e-02f, 5.37473150e-02f, 5.33662103e-02f,
  1.36042133e-01f, 1.41473800e-01f, 4.84369434e-02f, 4.49352749e-02f, 6.83282912e-02f, -5.14081456e-02f, 6.01486042e-02f, 8.15852210e-02f, 2.32357271e-02f, 1.63473800e-01f,
  1.19499438e-01f, 4.73037176e-02f, 5.76201230e-02f, 1.36839956e-01f, 1.31702736e-01f, -1.82795543e-02f, 1.00762226e-01f, -2.89669307e-03f, 1.11810965e-02f, 2.13685572e-01f,
  -9.37065110e-02f, 6.03059456e-02f, 8.44547153e-02f, 3.98985259e-02f, 1.42025754e-01f, 1.25333965e-01f, 4.91000945e-03f, 8.09388682e-02f, -7.42731467e-02f, -6.79935561e-04f,
  -5.28612323e-02f, 6.26292378e-02f, 3.66969593e-02f, 3.96404229e-02f, -2.04888359e-03f, -4.31294218e-02f, 8.60633794e-03f, -3.23925242e-02f, 9.79152471e-02f, 8.10944065e-02f,
  -6.91088140e-02f, 1.92891359e-02f, 7.46341646e-02f, -5.32318465e-02f, 8.41374174e-02f, 1.52270449e-02f, -7.48051330e-02f, 3.01107299e-02f, 5.01998514e-02f, -1.23213246e-01f,
  -6.42538592e-02f, -3.99727337e-02f, 1.68847889e-01f, 4.16513681e-02f, 6.57014996e-02f, 1.17700703e-01f, 1.01438239e-01f, 8.26828331e-02f, 4.17948216e-02f, -2.12392341e-02f,
  5.23970723e-02f, -8.14726278e-02f, 6.74846694e-02f, 3.46282090e-04f, -4.94144112e-02f, 4.42975387e-02f, 1.38420731e-01f, 5.77821620e-02f, 1.97870401e-03f, 1.38711482e-01f,
  1.42099738e-01f, -4.41631190e-02f, -1.26482412e-01f, 1.06353976e-01f, 4.54880297e-02f, -3.72828245e-02f, 4.88162935e-02f, -1.66097749e-02f, -9.15754959e-02f, -1.85048655e-02f,
  2.00614840e-01f, 9.15129483e-02f, 4.97826897e-02f, -1.24048114e-01f, -3.47216725e-02f, 2.72985935e-01f, 3.47299486e-01f, 1.69866621e-01f, -3.33112217e-02f, -5.25837243e-02f,
  9.46186334e-02f, -9.86598283e-02f, -1.49734020e-01f, -1.13464817e-01f, 7.71369189e-02f, 8.22525248e-02f, -1.28830716e-01f, 1.28439307e-01f, 3.01639915e-01f, 1.88984051e-01f,
  -4.59055640e-02f, -1.01920620e-01f, 9.15855393e-02f, 7.59529024e-02f, -2.57239401e-01f, -1.88702028e-02f, -1.44776523e-01f, -2.80378591e-02f, -5.83594432e-04f, -3.37010145e-01f,
  -6.43462269e-03f, 2.69499328e-02f, 1.48540974e-01f, 2.99693458e-02f, 3.03027947e-02f, 1.00327700e-01f, 3.63065451e-02f, -1.45082667e-01f, -9.67133716e-02f, -1.19899862e-01f,
  -2.73213871e-02f, 5.54382354e-02f, 3.64572071e-02f, 5.89584112e-02f, 2.82949265e-02f, 1.00465246e-01f, -4.68636528e-02f, 8.70464444e-02f, -1.50888953e-02f, 1.06527090e-01f,
  1.62322037e-02f, 9.49240252e-02f, 4.84558567e-02f, 1.63418084e-01f, 1.55453235e-01f, -4.82281484e-03f, 7.43213445e-02f, 8.52901340e-02f, 5.31135276e-02f, 6.90612122e-02f,
  6.50906330e-03f, -9.18239057e-02f, -1.80109683e-02f, -4.05414868e-03f, 6.09845780e-02f, -6.35806024e-02f, -6.17660098e-02f, 5.53819686e-02f, -2.17094850e-02f, 9.80333686e-02f,
  7.57389516e-02f, -3.36792618e-02f, -9.69044939e-02f, -8.95349905e-02f, 4.55490537e-02f, -3.99350189e-02f, 1.17340470e-02f, -1.15568368e-02f, -8.56018998e-03f, -7.47832209e-02f,
  2.80696116e-02f, -9.65859592e-02f, -7.39217401e-02f, -6.43678084e-02f, 3.40256840e-02f, 4.10261564e-02f, -8.64822194e-02f, -4.16994095e-02f, 2.98550893e-02f, -2.79314518e-02f,
  -1.00364164e-01f, -4.18257490e-02f, -1.53365331e-02f, 1.67230412e-01f, 1.05981857e-01f, 3.21768858e-02f, -5.66879846e-02f, 8.13523531e-02f, 3.57883461e-02f, -4.68881428e-03f,
  -1.88343655e-02f, 6.43265173e-02f, -1.04073510e-02f, 2.90632974e-02f, 9.10793766e-02f, 1.08523080e-02f, 8.17843229e-02f, 2.22011015e-01f, 5.09028174e-02f, 1.17516086e-01f,
  -1.78469997e-02f, 2.56861508e-01f, 1.78950787e-01f, 1.46299213e-01f, 9.09700170e-02f, 1.69459403e-01f, 1.02387004e-01f, 1.61355570e-01f, 2.40004390e-01f, 1.45347059e-01f,
  4.84482735e-01f, 4.24842030e-01f, 2.53059585e-02f, 1.24508232e-01f, -5.66857532e-02f, -1.09006263e-01f, 3.60684782e-01f, 1.00268163e-01f, -1.16140302e-02f, 3.51153880e-01f,
  1.93646297e-01f, -2.28841648e-01f, -3.72374728e-02f, -8.76894072e-02f, -2.88932510e-02f, 1.83465704e-01f, -7.89913386e-02f, -1.95826262e-01f, -3.19889814e-01f, -7.64519200e-02f,
  -2.10918225e-02f, 1.81751013e-01f, 1.00093782e-01f, -4.48695756e-02f, 2.20648035e-01f, 1.17100067e-02f, 1.86290637e-01f, 1.13643803e-01f, -2.57017687e-02f, 8.24458674e-02f,
  6.75686449e-02f, 2.85862803e-01f, -1.43557221e-01f, 7.65907317e-02f, -3.41662229e-03f, 1.92602724e-01f, 1.93113297e-01f, 1.79293528e-01f, 1.12889804e-01f, 1.68197617e-01f,
  8.97773430e-02f, 1.20679647e-01f, 1.12379543e-01f, -4.77710925e-02f, 7.26355985e-02f, 6.77365717e-03f, 6.23368211e-02f, 3.75207178e-02f, -2.23779771e-02f, 1.20888352e-01f,
  4.39661741e-03f, 9.49370563e-02f, 1.30162537e-01f, 4.60259505e-02f, 7.07403347e-02f, 4.63698953e-02f, 1.49682298e-01f, 3.15335356e-02f, 5.79513870e-02f, 3.92424166e-01f,
  1.82953253e-02f, 2.93549839e-02f, 5.91218239e-04f, 5.33580296e-02f, 5.35115749e-02f, -6.13102354e-02f, -1.08568385e-01f, -3.58513425e-05f, -1.05147339e-01f, 3.96572128e-02f,
  -9.16182250e-03f, -6.62676990e-02f, -4.71444763e-02f, 4.29657996e-02f, 7.74547085e-03f, 2.60422062e-02f, -4.69822064e-02f, 5.27346395e-02f, 4.59593199e-02f, 9.19437334e-02f,
  -5.03116334e-03f, -2.22516768e-02f, 8.57562274e-02f, -2.42377203e-02f, 9.91165359e-03f, 5.67131564e-02f, -6.12988544e-04f, -2.66007297e-02f, 1.76455826e-01f, 4.31684144e-02f,
  -3.45748067e-02f, -2.20588803e-01f, 1.33333743e-01f, 1.24701679e-01f, 8.53270441e-02f, 7.09846988e-02f, 1.11013912e-01f, 2.79450859e-03f, 1.49480412e-02f, 1.07006975e-01f,
  2.72740214e-03f, 9.24318656e-02f, 1.89279273e-01f, 1.26401290e-01f, 5.08786365e-03f, 9.88553017e-02f, 3.50845344e-02f, 5.93711585e-02f, -3.59718390e-02f, 1.03985332e-01f,
  7.93214738e-02f, 6.26523271e-02f, 7.92990476e-02f, 2.74512526e-02f, 1.96876819e-03f, 7.38515928e-02f, 7.84284621e-02f, 7.52753392e-02f, 8.94570202e-02f, 4.44473654e-01f,
  6.71335280e-01f, 3.47621560e-01f, -1.35050744e-01f, 4.69747223e-02f, -1.86570734e-01f, 7.12005347e-02f, 1.92666098e-01f, 1.42379537e-01f, -2.79713050e-02f, 4.55384925e-02f,
  -1.27191514e-01f, -3.58203314e-02f, 7.60153309e-02f, -2.41011307e-02f, 2.24466637e-01f, 1.34699479e-01f, 1.44452900e-02f, 1.40870064e-01f, 1.57244122e-05f, 6.59991875e-02f,
  -1.11698501e-01f, 9.89450514e-02f, 1.29564062e-01f, 2.46411841e-02f, 6.03122674e-02f, -4.52147499e-02f, -9.14109200e-02f, -2.39888169e-02f, -2.79373284e-02f, 3.45611349e-02f,
  -3.92840207e-02f, 1.32102787e-01f, -1.16972793e-02f, -3.99154089e-02f, -1.32139936e-01f, -1.67421848e-02f, 9.17451903e-02f, -5.43502197e-02f, -7.01397145e-03f, 3.40463780e-02f,
  -1.59235731e-01f, 9.45914984e-02f, -7.55445436e-02f, 4.93754596e-02f, 6.48985133e-02f, 1.25706464e-01f, 1.46105334e-01f, 6.08022884e-02f, -7.23097995e-02f, -2.26796065e-02f,
  -1.67159773e-02f, 4.51749824e-02f, 1.14481308e-01f, -2.38922238e-02f, 3.55417542e-02f, -7.03625157e-02f, -2.98867058e-02f, -4.90903892e-02f, -7.66218901e-02f, 1.38288617e-01f,
  4.66313511e-02f, -9.57161039e-02f, 5.28588379e-03f, 1.21960625e-01f, 5.91882803e-02f, 2.93957908e-03f, 3.31374705e-02f, 7.77814686e-02f, 7.76859596e-02f, 1.61830738e-01f,
  7.20902681e-02f, 2.81320028e-02f, 1.46948704e-02f, 6.27797991e-02f, 1.71691645e-02f, 1.00382917e-01f, 9.42605957e-02f, 2.73362380e-02f, 3.60885821e-02f, -1.59380883e-02f,
  -8.42505544e-02f, 6.98367059e-02f, -6.67103231e-02f, -1.01590522e-01f, -7.13133961e-02f, 1.23969177e-02f, -7.94299692e-02f, -1.00714145e-02f, 4.25943285e-02f, -7.88176730e-02f,
  1.40668586e-01f, -1.92690119e-01f, -7.63348583e-03f, 1.97273776e-01f, 5.14403805e-02f, -1.07762376e-02f, 1.12595104e-01f, 2.77309380e-02f, -1.74357798e-02f, 1.01335317e-01f,
  -1.53732551e-02f, 1.68336838e-01f, 1.02621801e-01f, -1.42464535e-02f, 5.03862612e-02f, 4.81038243e-02f, 1.62388161e-01f, -7.93731865e-03f, -6.84969202e-02f, 9.41911563e-02f,
  2.57304357e-03f, 1.68587759e-01f, 7.49390721e-02f, 8.27109590e-02f, 5.52374162e-02f, 1.53645113e-01f, 1.10039346e-01f, -2.38845423e-02f, 2.20511686e-02f, 2.52219081e-01f,
  5.98003063e-03f, 2.89943218e-01f, 3.71490240e-01f, 1.13012083e-01f, 1.18488390e-02f, -2.92741627e-01f, -2.41936922e-01f, -2.12676048e-01f, -1.60498649e-01f, -1.38240695e-01f,
  -2.23919809e-01f, -1.46424159e-01f, -7.39346538e-03f, -2.15672683e-02f, -4.01927195e-02f, 1.95022784e-02f, 2.98780978e-01f, 2.25575149e-01f, -1.04499377e-01f, -2.04015985e-01f,
  -1.75139643e-02f, 6.09912276e-02f, 7.03648722e-04f, 3.06811947e-02f, 2.66416758e-01f, -7.43809491e-02f, 2.15026781e-01f, 1.93098575e-01f, -1.67759098e-02f, 4.15035486e-01f,
  8.78797024e-02f, 2.80340523e-01f, -3.86891998e-02f, 6.87478157e-03f, 2.16198161e-01f, -4.46245782e-02f, 7.48964548e-02f, 9.55296755e-02f, -1.88012291e-02f, 7.18025938e-02f,
  1.56408712e-01f, 5.52890301e-02f, 1.90601960e-01f, 1.47997350e-01f, -1.64670870e-02f, -3.61783686e-03f, 2.21319094e-01f, 1.04883216e-01f, 1.74638793e-01f, 1.24071732e-01f,
  8.52926522e-02f, 7.93820471e-02f, -2.66065914e-02f, -4.49408224e-04f, 4.61951047e-02f, 3.80370729e-02f, 1.05599642e-01f, 8.28186572e-02f, -6.09470978e-02f, 6.24108687e-02f,
  -5.65850101e-02f, 2.05717757e-01f, 5.95777631e-02f, -3.49948034e-02f, 1.40840309e-02f, -6.03326187e-02f, 7.63505697e-02f, 1.01839416e-02f, -7.07083344e-02f, -1.23492308e-01f,
  -6.91105723e-02f, -3.93005237e-02f, -5.70363738e-02f, 8.44058860e-03f, -7.71885142e-02f, 1.84688866e-02f, -4.49953787e-03f, -3.42863314e-02f, -3.67324390e-02f, -9.04306676e-03f,
  8.84441135e-04f, -5.82413450e-02f, 1.75643694e-02f, -3.75542999e-03f, 1.17987245e-01f, 8.06030333e-02f, 1.31017463e-02f, 4.73473920e-03f, -9.40053910e-02f, -1.37477517e-01f,
  -6.14423268e-02f, 2.60607135e-02f, -6.20981269e-02f, -8.87474790e-02f, 5.71991466e-02f, 6.82734698e-02f, 7.18477517e-02f, -4.33256775e-02f, 9.24091712e-02f, 1.02092223e-02f,
  -6.58227801e-02f, -7.90703949e-03f, 4.38760929e-02f, 9.55084711e-02f, -7.88295865e-02f, -2.10935008e-02f, -1.22907296e-01f, -9.48527828e-03f, -5.13071939e-02f, 5.04987724e-02f,
  -4.51709703e-02f, -1.94116414e-01f, -3.16742182e-01f, -2.62159090e-02f, 6.40650094e-02f, -6.24883212e-02f, -4.19400781e-02f, -1.09493718e-01f, -1.71760738e-01f, -2.35364124e-01f,
  1.18314952e-01f, -5.41134663e-02f, 1.78241357e-01f, 3.78641486e-02f, 4.06724252e-02f, 2.05534875e-01f, 1.16037048e-01f, 7.12894648e-02f, -8.61752927e-02f, 5.78207821e-02f,
  -2.01644823e-01f, -2.36128315e-01f, -1.81605563e-01f, -1.16523199e-01f, 2.06837147e-01f, 1.14931718e-01f, 1.53344572e-01f, 1.07818015e-01f, 1.21620223e-01f, 9.19893086e-02f,
  -8.48692060e-02f, 3.90791148e-02f, 5.20689588e-04f, 4.67112213e-02f, -1.68541484e-02f, -1.31842688e-01f, -8.09196383e-02f, 8.75235945e-02f, -7.75320968e-03f, -2.09923148e-01f,
  4.07700650e-02f, 1.41463712e-01f, -1.47196561e-01f, -8.32378417e-02f, -7.54176974e-02f, 3.29556428e-02f, 4.11363170e-02f, 6.75993785e-02f, 2.80023403e-02f, -4.64964705e-03f,
  -1.45151660e-01f, -4.69862744e-02f, -2.32069492e-01f, -1.96631104e-01f, -2.75900885e-02f, -4.49399240e-02f, 9.41320658e-02f, 6.78305477e-02f, 6.43452555e-02f, 6.91085458e-02f,
  -1.42517731e-01f, 1.84859056e-02f, -1.52964890e-02f, 8.67417082e-02f, -1.04578240e-02f, 9.58398450e-03f, -1.33849055e-01f, 6.57339245e-02f, 8.99038464e-02f, -2.73309443e-02f,
  -3.72035094e-02f, 4.30110283e-02f, 5.89565784e-02f, -5.70397533e-04f, -7.57988989e-02f, -7.60505721e-02f, -2.02087928e-02f, -2.91850269e-02f, 1.53390253e-02f, 1.50249945e-02f,
  -3.09317783e-02f, 1.33521724e-02f, -3.49882734e-03f, -4.41742539e-02f, -1.45273939e-01f, 1.45157099e-01f, 2.19106991e-02f, -2.42858678e-02f, -3.55443321e-02f, 4.92672399e-02f,
  -4.02021334e-02f, 4.55376059e-02f, 3.91008006e-03f, 9.44990385e-03f, 7.01643303e-02f, 2.36555114e-02f, 2.12877244e-02f, 6.69834986e-02f, -5.27175926e-02f, 1.09401532e-01f,
  -2.37152785e-01f, 5.06894551e-02f, -5.96207082e-02f, -9.77478102e-02f, -9.04115289e-03f, 5.31202704e-02f, -5.79321720e-02f, 6.59741983e-02f, 3.02164014e-02f, -4.51649949e-02f,
  4.07529101e-02f, -8.55094716e-02f, -9.43892971e-02f, -5.59222102e-02f, -4.82576899e-03f, -1.11924838e-02f, -7.11638629e-02f, -6.52100220e-02f, -3.44248861e-02f, 4.00185250e-02f,
  -1.30288482e-01f, -2.81662773e-02f, -9.47413817e-02f, -1.08657911e-01f, -2.47554854e-03f, 6.96020201e-02f, -1.17225423e-01f, -7.76412189e-02f, -4.63983230e-03f, -1.41314670e-01f,
  -2.55868554e-01f, -3.55989426e-01f, 2.47916486e-02f, -1.15075549e-02f, -2.25611374e-01f, -2.72010446e-01f, -3.39403033e-01f, -2.60371804e-01f, -1.27130091e-01f, -1.47508293e-01f,
  -2.41903588e-01f, 6.47412986e-02f, -1.14668636e-02f, 1.90256611e-01f, 9.20785591e-02f, 1.12839699e-01f, 3.08629423e-01f, 3.62931311e-01f, 2.42985874e-01f, 3.97266261e-02f,
  1.73536614e-01f, 4.41350564e-02f, 5.17854318e-02f, 2.23648876e-01f, 7.03141540e-02f, 1.57481164e-01f, -8.80637690e-02f, -1.40193487e-02f, 1.68790996e-01f, 2.96335876e-01f,
  -7.96333775e-02f, -2.39434138e-01f, 9.51871276e-02f, 5.07814586e-02f, 4.36907634e-02f, -2.47206278e-02f, -3.20104808e-02f, 9.64833517e-03f, -2.84427274e-02f, -3.46721262e-02f,
  8.32637325e-02f, 5.54094315e-02f, 8.83861557e-02f, 2.22432259e-02f, 4.03615236e-02f, 2.99398750e-02f, -6.90726191e-03f, 7.47340173e-02f, -5.93154430e-02f, -5.56408018e-02f,
  1.40813231e-01f, 1.13198115e-02f, -1.00369342e-01f, -4.55870107e-02f, -4.95328605e-02f, 1.00761622e-01f, -1.02477752e-01f, -6.11068308e-03f, -3.39581794e-03f, -1.12874284e-02f,
  4.77992184e-02f, -6.32099062e-03f, 4.08383012e-02f, -9.03515331e-03f, 5.32663753e-03f, -2.40643695e-02f, 7.97635242e-02f, 3.95961665e-02f, 5.13751917e-02f, 3.25948857e-02f,
  7.92973023e-03f, 7.63582364e-02f, -5.17138876e-02f, -1.39582693e-03f, 9.72647965e-03f, 3.26078609e-02f, -7.07459636e-03f, -8.01721588e-04f, 1.09076910e-01f, 6.01082221e-02f,
  2.37614531e-02f, 7.02843964e-02f, -2.83264425e-02f, 1.14046939e-01f, -6.94936216e-02f, 4.64873686e-02f, 4.87286337e-02f, -6.74877018e-02f, -1.07999332e-01f, 8.21567979e-03f,
  -3.34644884e-01f, -1.27474234e-01f, -1.01765774e-01f, 1.94894392e-02f, 5.41260606e-03f, -1.87347922e-02f, 2.99680606e-02f, -1.77104305e-02f, -1.20343387e-01f, 1.44765424e-02f,
  -2.01058418e-01f, -1.46391049e-01f, -2.74273921e-02f, 4.04596254e-02f, -1.15668438e-02f, -1.08734958e-01f, -2.38392781e-02f, 4.65268679e-02f, -2.61343326e-02f, -7.44542032e-02f,
  -1.15578964e-01f, -3.12068798e-02f, -7.77563676e-02f, -2.18684375e-01f, -1.80970296e-01f, -1.71479955e-01f, -1.22402813e-02f, -7.19640264e-03f, -9.68013927e-02f, -7.24455938e-02f,
  -3.17091852e-01f, 2.53349096e-01f, 1.63790628e-01f, 3.88988457e-03f, -1.24985546e-01f, -9.29247811e-02f, -2.71882564e-02f, -2.46263161e-01f, -4.47663739e-02f, 5.99548556e-02f,
  3.73011567e-02f, 2.06531920e-02f, 7.86276534e-02f, 5.85940108e-02f, -2.85399295e-02f, 2.46864960e-01f, 3.14615458e-01f, 1.16439864e-01f, -1.22681290e-01f, -1.58578262e-01f,
  3.72456573e-02f, -7.35381059e-03f, -9.64425951e-02f, 5.73744923e-02f, 2.10708484e-01f, 6.86179623e-02f, 1.34765416e-01f, 1.05942383e-01f, 3.80648188e-02f, 4.74696964e-01f,
  1.59590900e-01f, -1.01418018e-01f, -1.85229465e-01f, -9.44060534e-02f, 1.03184760e-01f, -1.18124401e-02f, -7.04388469e-02f, -4.05475311e-02f, -8.07890594e-02f, 3.62042934e-02f,
  1.20656136e-02f, -1.00716390e-01f, -5.86958155e-02f, 5.76620959e-02f, -5.94181828e-02f, 4.64231856e-02f, 7.26036653e-02f, 1.31178349e-01f, -7.19587654e-02f, 3.32785137e-02f,
  2.41246056e-02f, 1.39016449e-01f, 9.84014049e-02f, 2.00905129e-02f, 3.41379568e-02f, 3.50429043e-02f, 1.05688952e-01f, 9.26096514e-02f, 7.52592310e-02f, 1.74785435e-01f,
  3.04112341e-02f, -1.65534504e-02f, -5.83687648e-02f, -2.97920592e-02f, 6.57949373e-02f, 1.28777683e-01f, 6.65204972e-02f, -4.44602631e-02f, 4.47359420e-02f, 5.07736169e-02f,
  -1.26780957e-01f, 4.98920493e-02f, 8.17700289e-03f, -3.32982652e-02f, 1.80914439e-02f, -4.86724675e-02f, -2.32203156e-01f, 4.74109128e-02f, 7.45984986e-02f, -1.83507968e-02f,
  3.74319591e-02f, -2.92990468e-02f, 4.82950434e-02f, 1.54669341e-02f, -5.72316349e-03f, 5.65020554e-03f, -2.80126277e-02f, -9.22585279e-02f, -5.17222844e-03f, -9.96676609e-02f,
  -2.44304940e-01f, -1.12243658e-02f, 7.73127526e-02f, -4.92884740e-02f, 2.64261197e-02f, -3.80651318e-02f, 7.41139054e-02f, -4.60907482e-02f, -9.24739912e-02f, 1.64701752e-02f,
  1.56824272e-02f, -2.85389312e-02f, 5.51420376e-02f, -1.41542768e-02f, 3.52915190e-02f, -9.40401480e-03f, 5.46047799e-02f, -3.95585224e-03f, -1.75587442e-02f, -3.58866975e-02f,
  -3.71058583e-02f, 8.94049257e-02f, -3.86610255e-03f, 6.58173636e-02f, 8.55694339e-02f, -8.44551846e-02f, 3.36408801e-02f, 2.78242193e-02f, 4.95071430e-03f, 1.13029733e-01f,
  3.41053367e-01f, -2.25529261e-02f, 2.27581114e-01f, 4.73562162e-03f, 8.23125690e-02f, 1.69133157e-01f, 4.99794185e-02f, 2.41617888e-01f, 1.05091929e-01f, 2.45234706e-02f,
  5.74298389e-02f, -3.66558991e-02f, 8.60592350e-02f, 4.95685339e-02f, 3.37059706e-01f, 5.69018424e-02f, 1.98245402e-02f, 2.51150727e-01f, 2.85563886e-01f, 2.00335339e-01f,
  -4.41809744e-02f, 4.56754379e-02f, 1.30220473e-01f, 2.60769337e-01f, 5.20221591e-02f, 1.76629841e-01f, 8.26499015e-02f, 4.78713997e-02f, 1.84715107e-01f, -8.06338191e-02f,
  2.04649225e-01f, 1.62757888e-01f, 5.87263927e-02f, -8.04571509e-02f, 5.18231168e-02f, -4.92232712e-03f, 4.64019319e-03f, 6.77990392e-02f, -4.52459586e-04f, 3.78741208e-03f,
  1.18684374e-01f, 2.80628856e-02f, -3.44633646e-02f, 5.00509590e-02f, 1.08201683e-01f, 7.29742646e-02f, 4.62685432e-03f, 1.16121903e-01f, 1.62125438e-01f, 7.15329945e-02f,
  -1.26681089e-01f, 1.17558017e-01f, 7.96915404e-03f, 1.10911630e-01f, 7.03703910e-02f, 6.72386810e-02f, 1.18584320e-01f, 5.30990064e-02f, 1.95125729e-01f, 1.43033013e-01f,
  8.14591050e-02f, -4.16850895e-02f, 6.52170694e-03f, -2.67067757e-02f, -6.28781840e-02f, 2.34955661e-02f, -3.63728181e-02f, 8.59829946e-04f, 1.43975355e-02f, 1.41887382e-01f,
  2.89310776e-02f, -7.31087029e-02f, -3.57059725e-02f, 1.53714806e-01f, 1.52240336e-01f, 1.14501014e-01f, 9.39079821e-02f, -9.91378725e-02f, -6.42526969e-02f, 5.84475091e-03f,
  -2.02525854e-02f, -2.62432359e-02f, 5.60828634e-02f, -9.71596614e-02f, 3.36434273e-03f, 1.28585353e-01f, 1.68150395e-01f, 6.86207190e-02f, 1.00907922e-01f, 1.04023278e-01f,
  1.03971764e-01f, 1.85311541e-01f, 6.63925484e-02f, -6.93691075e-02f, 7.76439533e-02f, 3.20204571e-02f, 3.92555743e-02f, 8.28781053e-02f, 1.25899762e-01f, 4.48184870e-02f,
  1.97439324e-02f, 1.69700667e-01f, 1.14289023e-01f, 1.82973668e-01f, 1.36720538e-01f, 5.76807968e-02f, -1.15516298e-02f, 6.66653216e-02f, 1.45599514e-03f, 9.76911485e-02f,
  4.96872701e-02f, 7.26978853e-02f, 8.68758857e-02f, 2.65326444e-02f, 9.18426663e-02f, 5.61561771e-02f, 2.59589255e-01f, 1.73556149e-01f, 1.39757916e-01f, 1.90767348e-01f,
  -1.86823476e-02f, -2.69370377e-01f, 1.51097834e-01f, 2.57092286e-02f, 2.85358168e-02f, 3.61054242e-02f, -1.88120678e-01f, 2.67739855e-02f, -1.67347863e-02f, -1.40608296e-01f,
  4.47887275e-03f, 2.48698488e-01f, 2.42980018e-01f, 2.63712645e-01f, 1.83078170e-01f, 3.30267586e-02f, -6.05018884e-02f, 2.13538215e-01f, 4.40609753e-01f, 3.14287961e-01f,
  -6.65512607e-02f, -2.71849167e-02f, -2.15119645e-02f, 1.11400276e-01f, -1.54789239e-01f, 6.60523400e-02f, -7.66373798e-02f, -5.38705401e-02f, 2.34382749e-02f, -2.14013979e-01f,
  1.26320899e-01f, -1.59659684e-02f, 2.77543038e-01f, 1.61758229e-01f, 2.06653208e-01f, 2.29763910e-01f, 1.99149534e-01f, 1.69294849e-01f, 1.41440347e-01f, 9.91887897e-02f,
  1.62159815e-01f, 9.25782621e-02f, 2.43297175e-01f, 3.50729004e-02f, 1.08638056e-01f, 1.72309905e-01f, 1.07608043e-01f, 1.00128375e-01f, 1.07232824e-01f, 7.29135349e-02f,
  9.82631594e-02f, 1.34895280e-01f, 1.77585274e-01f, 1.23001754e-01f, 1.66997015e-01f, 2.19861060e-01f, 8.89326409e-02f, 3.64242005e-03f, 2.16653943e-01f, -8.13699439e-02f,
  3.49756181e-02f, -5.59600852e-02f, -2.01250538e-02f, -1.22111350e-01f, -1.11745350e-01f, -1.88741330e-02f, 4.19721752e-02f, -9.91802961e-02f, 2.10196134e-02f, 5.23580937e-03f,
  -2.77331867e-03f, -5.28598242e-02f, 3.42161991e-02f, 4.43073884e-02f, -3.78889181e-02f, 5.23847230e-02f, 1.40295876e-02f, -1.28554050e-02f, 2.61851475e-02f, -2.45883334e-02f,
  3.72307152e-02f, -3.80566902e-02f, -1.43652065e-02f, 7.12532476e-02f, 2.56197043e-02f, -3.38059850e-02f, 2.91708019e-02f, 1.56528119e-03f, -5.10971844e-02f, 4.05109972e-02f,
  -6.49733990e-02f, 2.20911920e-01f, 2.80897599e-02f, 1.76248863e-01f, 1.44961923e-01f, 1.22241721e-01f, 1.87353522e-01f, 1.22979291e-01f, 1.43349335e-01f, 2.68643778e-02f,
  1.48836300e-01f, 2.09967986e-01f, 6.51857406e-02f, 7.21498057e-02f, 6.50530905e-02f, 1.56509448e-02f, -6.95873145e-03f, 1.20945185e-01f, 1.24626569e-01f, 8.66865814e-02f,
  7.71114081e-02f, 1.71713829e-01f, 1.32763788e-01f, 9.20133591e-02f, 9.54418033e-02f, 1.44977778e-01f, 1.33204669e-01f, 1.67565942e-01f, 3.04573387e-01f, 1.79739241e-02f,
  -9.61392000e-02f, -6.98737800e-02f, -1.29355252e-01f, -6.58513531e-02f, -2.33033627e-01f, -1.96624920e-01f, -1.83374345e-01f, -8.47081169e-02f, -3.62432115e-02f, 2.87489612e-02f,
  4.78722602e-02f, 8.22296292e-02f, 3.72407623e-02f, 9.12425146e-02f, -1.13848343e-01f, -9.08575878e-02f, -7.95807764e-02f, -1.35377392e-01f, -1.89927444e-01f, -2.58895636e-01f,
  -2.04475492e-01f, -4.65850569e-02f, -1.16138317e-01f, -7.86633939e-02f, -2.36218214e-01f, -3.53674665e-02f, 4.62922081e-02f, -7.29689896e-02f, -4.99196835e-02f, -1.90402567e-01f,
  -2.01950237e-01f, -8.72033238e-02f, 6.26957789e-02f, 1.04207862e-02f, -1.18221613e-02f, 6.29639067e-03f, -3.42211314e-02f, 2.81338897e-02f, 5.90086766e-02f, -3.79390130e-03f,
  4.41168733e-02f, 8.51294026e-02f, -3.35410470e-03f, 2.82181539e-02f, -1.53958291e-01f, -1.03874519e-01f, 1.06806599e-01f, -3.87281403e-02f, 7.59397298e-02f, -4.16306034e-02f,
  2.23653112e-02f, -6.15482293e-02f, 7.38019031e-03f, 1.05648145e-01f, -2.64766365e-02f, -3.74554358e-02f, 1.19141206e-01f, -1.38148451e-02f, -1.39065851e-02f, -6.67823032e-02f,
  8.60301033e-02f, 2.20831688e-02f, -5.12900390e-02f, 4.76448387e-02f, -2.85219327e-02f, 1.70435771e-01f, 9.64246392e-02f, 4.47992571e-02f, -6.42567873e-02f, 7.35129090e-03f,
  -6.08131848e-02f, 6.37124926e-02f, 7.65192956e-02f, 3.24809104e-02f, -6.71196878e-02f, 1.22373318e-02f, 2.69314125e-02f, 3.75739448e-02f, 7.09343627e-02f, 7.55277723e-02f,
  -9.60028023e-02f, 2.64502354e-02f, -2.20746617e-03f, 1.00029567e-02f, -7.68922828e-03f, 2.34843381e-02f, -9.31439847e-02f, -2.13578194e-02f, -1.68291293e-02f, -6.22777678e-02f,
  -1.45318478e-01f, 1.46712959e-01f, -9.05144552e-04f, -2.36148946e-02f, -4.44102138e-02f, 3.19745094e-02f, 6.95189461e-02f, 5.21424152e-02f, -1.80085916e-02f, 2.77548991e-02f,
  -8.58904794e-03f, 5.49259298e-02f, -1.35234315e-02f, -7.33415931e-02f, -1.23684101e-01f, 1.41469203e-02f, -7.33093591e-03f, 1.05539009e-01f, 1.72253400e-01f, 1.76219195e-02f,
  4.02900986e-02f, 5.74433769e-04f, -4.53312322e-02f, 3.94352525e-02f, 3.67658846e-02f, 1.04881199e-02f, 1.14007495e-01f, 7.44938925e-02f, 1.12674870e-01f, 8.54656622e-02f,
  -2.42077008e-01f, -3.23925197e-01f, -3.99566591e-02f, -8.17260146e-02f, 2.53463704e-02f, 4.17826660e-02f, 4.09354419e-02f, -2.18452979e-02f, 4.97155003e-02f, -1.49361953e-01f,
  -4.31087576e-02f, 1.50829390e-01f, 1.05316669e-01f, 4.73076813e-02f, 7.23484084e-02f, 2.94550620e-02f, 2.43191477e-02f, 7.90641904e-02f, 3.10458958e-01f, 1.44614011e-01f,
  2.12007016e-02f, -5.78278005e-02f, -1.40591606e-01f, 6.33183587e-03f, -1.17078453e-01f, 1.98276788e-01f, -1.33352205e-01f, -1.29748419e-01f, 2.27192733e-02f, -5.21114655e-02f,
  3.06457102e-01f, -2.00536638e-01f, 2.64760077e-01f, 1.22987434e-01f, 6.68351427e-02f, 1.13142319e-01f, 7.77969733e-02f, 1.02836527e-01f, 4.45531532e-02f, 1.01621009e-01f,
  9.62590650e-02f, 1.23923801e-01f, 4.61182743e-02f, 1.02048419e-01f, -4.45674546e-03f, 1.84538126e-01f, -6.05968311e-02f, 7.74864927e-02f, 3.15581262e-02f, 1.60601616e-01f,
  1.43876761e-01f, 2.79465737e-03f, 8.95691365e-02f, 3.78699563e-02f, 2.25028563e-02f, 1.85894474e-01f, 5.02276979e-02f, 3.92659456e-02f, 1.82363898e-01f, -2.25070547e-02f,
  -1.71530165e-03f, 8.57468043e-03f, 5.48448861e-02f, 4.13324758e-02f, -1.47701532e-01f, -7.09007755e-02f, -6.53492361e-02f, 9.41464528e-02f, -9.20521021e-02f, -4.46260758e-02f,
  -8.45365375e-02f, -2.70815063e-02f, -1.53310165e-01f, -8.26396495e-02f, 2.29382585e-03f, -1.27675487e-02f, -1.24129960e-02f, 1.79167092e-02f, 2.88060699e-02f, 4.46703322e-02f,
  8.70685652e-02f, -4.57016006e-02f, 3.75830680e-02f, -2.10921485e-02f, -1.67719722e-01f, -3.10201738e-02f, -3.51054296e-02f, -1.19941510e-01f, -4.97795129e-03f, 5.01499628e-04f,
  3.15856248e-01f, 2.11557224e-01f, 4.87043597e-02f, 9.12333876e-02f, 1.42000496e-01f, 1.32337073e-02f, 7.03034699e-02f, 1.74364746e-02f, 1.00620762e-01f, 4.92192954e-02f,
  1.10668980e-01f, 1.06045097e-01f, 7.21412301e-02f, 1.43132225e-01f, 1.29538685e-01f, 2.11992458e-01f, 1.51125446e-01f, 1.55597404e-01f, 1.51332676e-01f, 1.74238145e-01f,
  1.42696453e-02f, 1.81315020e-01f, 3.93102989e-02f, 1.82922930e-01f, 2.06874907e-01f, 1.96897700e-01f, 2.51856774e-01f, 1.99735209e-01f, 2.10357264e-01f, 2.10336730e-01f,
  5.43153465e-01f, 6.89105913e-02f, -1.81860402e-01f, 1.57385096e-01f, 2.51761246e-02f, 3.33917737e-02f, 1.65283725e-01f, 2.07364231e-01f, 1.17393143e-01f, 2.20914572e-01f,
  9.04526561e-03f, -1.69473276e-01f, -8.65251273e-02f, -1.56915456e-01f, 3.50983627e-02f, 3.13551584e-03f, -5.22784367e-02f, -1.37893602e-01f, -2.14716811e-02f, 3.66814360e-02f,
  9.28397756e-03f, 7.93565810e-02f, 1.37988597e-01f, -3.64939384e-02f, 4.69241105e-02f, -1.38451353e-01f, -3.72441635e-02f, 3.72865386e-02f, -2.09534708e-02f, -1.13342188e-01f,
  -1.61148429e-01f, 1.85506582e-01f, 3.27711888e-02f, 6.25380576e-02f, -8.07710923e-03f, 6.00399598e-02f, 6.07841164e-02f, 7.42416903e-02f, 7.80377239e-02f, -5.11042215e-02f,
  3.94101739e-02f, 3.40339728e-02f, -5.07482849e-02f, -2.57191285e-02f, -5.95064051e-02f, 9.62250754e-02f, 1.13734722e-01f, 1.27473563e-01f, 1.46807134e-01f, 7.86775723e-02f,
  2.55156402e-02f, -8.16789716e-02f, -8.53374694e-03f, 1.04395881e-01f, 6.91308454e-02f, -7.89940916e-03f, -5.89417480e-02f, -3.46714072e-02f, -4.36060922e-03f, -3.04690935e-02f,
  -7.88242817e-02f, -8.79409462e-02f, -1.53393850e-01f, -4.08681370e-02f, -4.81743738e-02f, -2.10899845e-01f, -9.84508693e-02f, -8.00679252e-02f, -1.17257833e-01f, 2.94324234e-02f,
  -1.62148595e-01f, -1.53380096e-01f, -9.19828042e-02f, -2.21401881e-02f, -1.23195790e-01f, -8.57697949e-02f, -2.14834902e-02f, -5.72427958e-02f, -2.21020177e-01f, -2.74142455e-02f,
  -1.22194201e-01f, -8.22025687e-02f, -4.50487584e-02f, -1.80755317e-01f, -1.21247075e-01f, -9.68447551e-02f, -4.90250513e-02f, -1.05188325e-01f, -1.35182887e-01f, -6.22683316e-02f,
  1.45372301e-01f, -2.07029898e-02f, 8.74149129e-02f, 3.36384540e-03f, -2.27482095e-02f, 3.55509738e-03f, -4.31885198e-02f, -2.93553118e-02f, -1.14192709e-01f, 1.49662038e-02f,
  6.50289953e-02f, -3.55611630e-02f, 3.02439053e-02f, 3.22320387e-02f, -3.42699606e-03f, 2.60036048e-02f, 5.47974817e-02f, -7.09239440e-03f, -2.08865106e-02f, 3.09891775e-02f,
  6.79026544e-02f, 1.28235385e-01f, -3.90897840e-02f, 2.97960127e-03f, 4.16115262e-02f, 4.07606475e-02f, -1.17113963e-02f, 6.70031831e-02f, 1.10083088e-01f, 1.80194482e-01f,
  2.97277402e-02f, -6.99426839e-03f, -4.32830334e-01f, -1.36228293e-01f, 4.17964943e-02f, 7.90066924e-03f, -3.90918665e-02f, 1.02994151e-01f, 9.83226746e-02f, 3.06402631e-02f,
  -7.91653693e-02f, 1.25443235e-01f, -3.78587209e-02f, -3.84434424e-02f, 8.48439261e-02f, 5.50811887e-02f, -5.87582253e-02f, -5.11994921e-02f, 1.70653135e-01f, 3.71797606e-02f,
  1.98549837e-01f, -9.71814319e-02f, -1.49343178e-01f, -3.16036716e-02f, -1.11061009e-02f, 6.42700540e-03f, -1.57029450e-01f, -2.22236633e-01f, 6.87043294e-02f, -1.08589649e-01f,
  4.94303228e-03f, -2.80684203e-01f, 8.81975815e-02f, 1.58315793e-01f, -1.46972379e-02f, 1.06645569e-01f, -6.57248171e-03f, -1.40916184e-02f, 8.94145370e-02f, 8.62828270e-02f,
  -1.14073895e-01f, 3.29091847e-02f, 2.47688908e-02f, 9.43300053e-02f, 7.06984252e-02f, 3.18030454e-02f, -5.60636558e-02f, -1.12446442e-01f, 1.34888841e-02f, 1.46800160e-01f,
  2.38159224e-02f, 1.07535325e-01f, 3.11239138e-02f, -1.85897748e-03f, -3.75778116e-02f, 4.31142896e-02f, 9.29194465e-02f, 3.08592375e-02f, 8.68027657e-02f, 1.32120714e-01f,
  3.63915935e-02f, -5.77701107e-02f, 1.50163928e-02f, -4.59657749e-03f, 4.84579280e-02f, -9.78422686e-02f, -7.84062222e-02f, 4.73990329e-02f, -3.55429091e-02f, -6.58145621e-02f,
  -1.73694137e-02f, -7.51588345e-02f, -2.27574073e-03f, 2.81149428e-03f, -8.64548311e-02f, 1.68244250e-03f, 5.30144945e-02f, -1.87724605e-02f, -1.13441333e-01f, -1.88186076e-02f,
  -5.17245643e-02f, -5.23586869e-02f, -1.22347169e-01f, -7.98288584e-02f, -1.80502594e-01f, -1.44068941e-01f, 3.30875516e-02f, 4.35723774e-02f, -8.98306742e-02f, -8.18853080e-02f,
  3.72229397e-01f, -1.80888288e-02f, 6.81279674e-02f, 7.85874501e-02f, -2.24992987e-02f, 6.02121688e-02f, -3.32594700e-02f, 3.08169816e-02f, -5.81445731e-02f, 1.42485753e-01f,
  -1.91770680e-02f, 7.61358673e-03f, 1.09121762e-01f, 8.39563832e-02f, 2.05398455e-01f, 2.49057859e-02f, 2.13457897e-01f, 1.16353609e-01f, 1.45981997e-01f, 1.13208920e-01f,
  2.95388311e-01f, 3.75786483e-01f, 3.69731009e-01f, 2.46924818e-01f, 1.71425551e-01f, 2.18786597e-01f, 2.98753351e-01f, 1.75595388e-01f, 1.39683172e-01f, 4.63760227e-01f,
  2.42319360e-01f, 1.09170906e-01f, 1.72078252e-01f, -5.07502630e-03f, -1.67370409e-01f, 2.21017897e-02f, 1.39892489e-01f, 4.49749157e-02f, -1.55113980e-01f, -1.00672707e-01f,
  -1.34561121e-01f, -8.26306269e-02f, -2.84135658e-02f, 2.62501296e-02f, 4.23302323e-01f, 2.45397851e-01f, 1.78255245e-01f, 3.43656361e-01f, 2.86166817e-01f, 6.23379797e-02f,
  5.13119400e-02f, -8.52847025e-02f, 1.10508151e-01f, 1.77302078e-04f, -1.17711134e-01f, 7.17029348e-02f, 1.20232012e-02f, -1.09563461e-02f, 9.36320424e-03f, 1.45560682e-01f,
  9.47347507e-02f, -4.40181717e-02f, 3.70988473e-02f, 5.42968959e-02f, -1.36127234e-01f, -1.56234264e-01f, 4.31290753e-02f, 3.28499940e-03f, -1.10355869e-01f, -1.03332654e-01f,
  -7.32482448e-02f, 1.78456921e-02f, -4.18297686e-02f, -2.76021753e-02f, 2.38367394e-02f, -2.89666262e-02f, -8.17555711e-02f, 9.13730264e-02f, 5.94368437e-03f, -9.72638652e-02f,
  -5.21126464e-02f, -8.79302323e-02f, 8.27145800e-02f, -1.00557581e-01f, -7.17443824e-02f, -9.72658992e-02f, -1.56601623e-01f, -6.33256882e-02f, -6.69904351e-02f, -9.71664935e-02f,
  -3.49416770e-02f, 3.53219993e-02f, -2.16420796e-02f, -2.77037621e-02f, 1.02728240e-01f, -3.14554013e-02f, 4.47029583e-02f, -5.25287353e-02f, 1.16576932e-01f, 4.89187986e-02f,
  -2.06216630e-02f, 1.73398596e-03f, 4.30734530e-02f, 8.56624823e-03f, -2.45207231e-02f, 1.00688506e-02f, 1.03909500e-01f, -2.24959590e-02f, -3.81185748e-02f, -6.36375695e-02f,
  1.10301517e-01f, 4.05938663e-02f, -9.20702983e-03f, 1.63064063e-01f, 8.68337005e-02f, -8.45362246e-02f, 4.43587489e-02f, 8.92987177e-02f, 2.27189846e-02f, 1.23561308e-01f,
  -3.52939144e-02f, 3.77247073e-02f, -1.02324532e-02f, 9.22051370e-02f, -1.03008069e-01f, -6.79369969e-03f, -1.45472497e-01f, 1.03073135e-01f, -3.83804515e-02f, 8.11522529e-02f,
  9.10211056e-02f, 5.19106537e-02f, -1.14922421e-02f, 5.96246645e-02f, 3.25860307e-02f, 3.15283611e-02f, -2.10385062e-02f, -1.37597136e-02f, 1.16586052e-01f, -5.02387099e-02f,
  -3.73896882e-02f, -5.72666787e-02f, 7.38940835e-02f, -2.79817097e-02f, 3.29614766e-02f, -2.46119127e-03f, 5.20332679e-02f, 5.13484329e-02f, 1.15945324e-01f, -8.90226886e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.13480130e-01f, -2.89385736e-01f, 7.04026967e-02f, 1.65029302e-01f, 2.79117405e-01f, -5.75487353e-02f, -3.49639267e-01f, 1.25568464e-01f, 1.05910845e-01f, -1.76909436e-02f,
  2.23730266e-01f, 3.23627740e-01f, 1.03004187e-01f, 5.04649244e-02f, -2.61314690e-01f, -2.17191473e-01f, -1.18126862e-01f, -1.00077234e-01f, 1.36377186e-01f, 2.03699932e-01f,
  1.83940485e-01f, 9.68458503e-02f, 8.64328966e-02f, -3.90806720e-02f, -4.45427522e-02f, 3.56008695e-03f, -5.61049283e-02f, -1.02192000e-01f, -2.61234969e-01f, -1.10574879e-01f,
  6.58776090e-02f, -1.40275225e-01f, 4.63206246e-02f, 1.25177622e-01f, 7.17940256e-02f, -1.29826916e-02f, -7.40547031e-02f, 3.77541110e-02f, -2.49611624e-02f, 1.01604825e-02f,
  8.24909285e-02f, 8.56691077e-02f, 1.01089887e-01f, 6.61474094e-02f, 8.73120651e-02f, -3.69687676e-02f, 1.03702493e-01f, -4.22372855e-03f, -1.72301859e-01f, -8.02940950e-02f,
  7.95738995e-02f, 1.79004714e-01f, 1.01196483e-01f, -1.07754909e-01f, -1.25316307e-01f, 3.85976955e-02f, -1.26802139e-02f, -1.46233141e-01f, -5.98490834e-02f, -3.39575976e-01f,
  1.28723577e-01f, -5.17359972e-02f, -1.03840835e-01f, -1.43026069e-01f, -9.61155146e-02f, 5.31895347e-02f, 8.37100744e-02f, -7.95707852e-03f, -1.50884306e-02f, -5.49880378e-02f,
  2.95981369e-03f, -8.57495121e-04f, -7.29886070e-02f, -3.47700715e-02f, 6.93400353e-02f, -1.60321817e-02f, -1.20520309e-01f, -1.38094455e-01f, -7.09019415e-03f, -2.52551772e-03f,
  9.22429934e-02f, -9.35415104e-02f, 1.20629303e-01f, -1.64410695e-02f, -4.57181148e-02f, -3.27361189e-02f, 2.22048704e-02f, 8.12055636e-03f, 1.51170567e-01f, 1.57807365e-01f,
  2.16743782e-01f, 4.23840731e-02f, -1.25757128e-01f, -3.29546034e-02f, -1.01912007e-01f, -9.84546766e-02f, -4.58762273e-02f, 2.64446214e-02f, -3.55911143e-02f, 1.59435570e-02f,
  4.94760238e-02f, -1.19835600e-01f, -6.26330897e-02f, 8.35102145e-03f, 9.62847695e-02f, 1.72220599e-02f, -3.46389711e-02f, 1.89574920e-02f, -1.59787089e-01f, 3.05201695e-03f,
  -1.12242103e-01f, 7.90020544e-03f, -1.12770990e-01f, -1.92447394e-01f, -3.66947316e-02f, -5.12032062e-02f, -1.60184130e-01f, -8.50483328e-02f, -2.10645765e-01f, -3.29567760e-01f,
  -2.96872586e-01f, -2.04623803e-01f, -3.12942743e-01f, -3.68143111e-01f, -2.59465188e-01f, 5.13426438e-02f, -5.79304397e-02f, 1.11715645e-02f, -8.24897811e-02f, -3.03683668e-01f,
  -1.17640458e-01f, 8.46322253e-02f, -1.62474751e-01f, -5.17167822e-02f, 1.31783560e-01f, -2.96263158e-01f, -3.26453388e-01f, -1.97472453e-01f, 1.95243329e-01f, 1.78872302e-01f,
  -1.70565426e-01f, -2.38811791e-01f, -1.34291286e-02f, 2.73803039e-03f, -1.30930468e-01f, -6.25633693e-04f, -1.75197750e-01f, -2.05565058e-02f, 6.26192614e-02f, -1.85667589e-01f,
  -1.68657765e-01f, 1.21676110e-01f, -1.77384600e-01f, 8.86556879e-02f, -2.03045085e-01f, -1.15356870e-01f, 5.37144803e-02f, -1.72252566e-01f, -2.12452607e-03f, -1.09823860e-01f,
  -1.31140724e-01f, 8.84011090e-02f, -3.59586477e-02f, 8.18205848e-02f, -2.12647468e-02f, 4.86186482e-02f, -1.62722647e-01f, -2.99134683e-02f, -1.19878709e-01f, -1.02240600e-01f,
  -1.61437467e-01f, -6.45285621e-02f, 6.40065148e-02f, 1.94394290e-01f, 3.44389454e-02f, -5.42691313e-02f, 1.31928414e-01f, 1.48892358e-01f, 2.59045690e-01f, 4.47773933e-02f,
  -6.78620338e-02f, 5.50367981e-02f, 4.75603826e-02f, 3.49519514e-02f, -2.88772881e-02f, 5.26702628e-02f, 3.13735455e-02f, 2.71085445e-02f, -4.01583593e-03f, 4.17343080e-02f,
  5.64412922e-02f, 1.11197345e-02f, -6.52472582e-03f, -1.08984552e-01f, -7.19677359e-02f, 4.59284484e-02f, 3.32730785e-02f, -9.52581093e-02f, 4.50873189e-02f, -8.37935600e-03f,
  1.24908559e-01f, 1.14474930e-01f, -7.37502128e-02f, 1.41773432e-01f, 5.88506572e-02f, 5.43206558e-03f, -6.94507509e-02f, 3.91905457e-02f, -5.26667461e-02f, -7.39470944e-02f,
  -2.71232333e-03f, -5.26265539e-02f, -2.04672232e-01f, 2.21144378e-01f, 3.23786326e-02f, 6.99240044e-02f, -8.19074735e-02f, 9.36647952e-02f, -1.89862994e-03f, -9.41607058e-02f,
  1.11766376e-01f, -5.05266190e-02f, 8.69145151e-03f, 9.55306366e-02f, 2.34665927e-02f, 1.62401721e-02f, -7.15531334e-02f, -2.30600331e-02f, 1.94464564e-01f, -1.17311981e-02f,
  -6.28879219e-02f, 1.48233306e-02f, -2.70357523e-02f, 1.68636441e-01f, 8.14571604e-02f, 1.83677040e-02f, 9.35305655e-02f, 1.49137929e-01f, 1.35431498e-01f, -5.76824844e-02f,
  9.47084744e-03f, -4.88361232e-02f, 2.39894316e-01f, 7.29308638e-04f, 2.56159991e-01f, 3.50417018e-01f, 4.20873761e-01f, -1.06602214e-01f, -1.73607439e-01f, -2.74761580e-03f,
  2.24285177e-05f, -3.42607945e-01f, -2.86568344e-01f, -2.51162887e-01f, -6.67000636e-02f, 3.52641374e-01f, 3.08691263e-01f, 9.86322016e-02f, 4.13575210e-02f, -7.76670575e-02f,
  -1.44569442e-01f, -2.86654402e-02f, -1.92029208e-01f, -2.16490537e-01f, -1.34412557e-01f, -5.44854626e-02f, 1.38440013e-01f, 6.21563494e-02f, 7.14787841e-02f, -9.96967107e-02f,
  2.70047691e-02f, -3.09585240e-02f, -9.71077830e-02f, -2.03543857e-01f, -1.10583104e-01f, -1.97416469e-01f, -1.62314951e-01f, -2.77553294e-02f, 3.89026850e-02f, 7.84793496e-02f,
  3.54200192e-02f, 6.66198954e-02f, -1.39182713e-02f, 3.12773213e-02f, 1.26465887e-01f, 6.42254874e-02f, 6.38684956e-03f, -5.80497012e-02f, -1.43172607e-01f, -3.95550728e-02f,
  -4.85395230e-02f, 1.22834988e-01f, 2.72057299e-02f, 3.13440152e-02f, 1.07399933e-01f, -6.98085725e-02f, 9.34390649e-02f, 3.94313000e-02f, 6.23513758e-03f, -2.31904462e-02f,
  -1.04734875e-01f, 1.35887610e-02f, 7.38075972e-02f, -1.02200635e-01f, -1.85301546e-02f, 4.30024676e-02f, 6.60881177e-02f, -2.95542385e-02f, -9.61806700e-02f, -1.04816228e-01f,
  4.57330234e-03f, 1.92086220e-01f, -1.25722468e-01f, -3.87463868e-02f, -8.48383009e-02f, -3.38260345e-02f, 1.04150914e-01f, 7.75440708e-02f, -3.32179517e-02f, -3.42861786e-02f,
  -1.58006340e-01f, -1.31327480e-01f, -9.64488015e-02f, -9.44276601e-02f, -5.98975345e-02f, -1.37753740e-01f, -1.28260374e-01f, -2.85314787e-02f, -1.27619863e-01f, -1.23548239e-01f,
  -4.78323728e-01f, 3.91438603e-02f, -1.86939389e-01f, -2.80853361e-01f, -5.09915948e-02f, -7.24843219e-02f, -1.89017043e-01f, 4.81262431e-02f, 8.22449774e-02f, -3.27945128e-02f,
  6.52345642e-02f, 3.79733816e-02f, -7.31583731e-03f, -1.68920513e-02f, -7.60634691e-02f, -7.25908577e-02f, -1.36104524e-01f, -7.50742331e-02f, 1.65994890e-04f, -8.17642435e-02f,
  -2.17562336e-02f, 7.01505393e-02f, -5.57681024e-02f, -9.43214446e-02f, -1.12349056e-01f, 2.51670573e-02f, -1.84931010e-02f, 1.11878350e-01f, 1.63544834e-01f, 8.13650936e-02f,
  -2.93722153e-01f, -2.70897657e-01f, -1.96044937e-01f, -1.28873447e-02f, 5.27926795e-02f, -5.20664379e-02f, -2.85727590e-01f, 6.85821176e-02f, 5.35668507e-02f, -2.95625091e-01f,
  -1.12762779e-01f, 2.13267058e-01f, -3.45960855e-02f, 3.82623300e-02f, -1.77324727e-01f, -3.50529909e-01f, -2.92330980e-01f, -6.39827177e-02f, 2.54057735e-01f, 2.30634943e-01f,
  3.07241678e-02f, 5.11381663e-02f, 9.32344347e-02f, 8.49299282e-02f, 4.00501257e-03f, 1.93439778e-02f, -2.14690998e-01f, 1.16125932e-02f, -6.50571436e-02f, -3.04718196e-01f,
  -1.91716030e-01f, -7.00744614e-02f, 5.24334051e-02f, -1.59996748e-02f, -1.49148908e-02f, -7.28828982e-02f, -5.72091043e-02f, 1.52771957e-02f, -8.64374489e-02f, -1.17626758e-02f,
  4.37345877e-02f, -2.38739569e-02f, -9.31654274e-02f, 2.76616625e-02f, 4.64036427e-02f, 6.93296492e-02f, 1.30538508e-01f, 1.78978331e-02f, 8.48515239e-03f, 2.07848381e-02f,
  1.72695760e-02f, -9.72139370e-03f, 8.39576274e-02f, 1.11932494e-01f, 1.10980496e-01f, -2.04636995e-02f, 8.91361609e-02f, 1.11179516e-01f, 9.07403007e-02f, -7.19881505e-02f,
  2.34369673e-02f, 2.31760740e-02f, 7.05701634e-02f, 7.03716576e-02f, 7.90915787e-02f, -4.91392761e-02f, -7.78192952e-02f, 1.84012130e-02f, 9.70070735e-02f, -6.87178001e-02f,
  -3.77549715e-02f, -3.78924906e-02f, 3.35751884e-02f, -1.21592812e-01f, -7.27716908e-02f, -4.13206108e-02f, -3.67272608e-02f, 8.96006525e-02f, 4.34544161e-02f, 4.18525003e-02f,
  -1.63019281e-02f, 3.74496505e-02f, -2.49191765e-02f, -6.57545850e-02f, -2.48981509e-02f, 8.09266865e-02f, 3.16869281e-02f, 4.37380560e-02f, 2.64337584e-02f, -1.06218837e-01f,
  -5.95034054e-03f, -1.17667265e-01f, -1.84396490e-01f, 1.35212895e-02f, 2.75462344e-02f, 4.85896729e-02f, 7.62400106e-02f, 1.06339738e-01f, 1.05058206e-02f, 8.78613070e-02f,
  1.47483721e-01f, -5.16075306e-02f, -7.41858482e-02f, 6.69447556e-02f, -7.07430067e-03f, -1.03074558e-01f, -1.41505599e-01f, -6.58754632e-02f, 7.18422905e-02f, 3.43770087e-02f,
  3.52198072e-02f, -8.32517594e-02f, -1.00272633e-01f, -3.88668887e-02f, 7.13498965e-02f, -1.41658872e-01f, 1.58236511e-02f, 1.07197575e-01f, -3.93686704e-02f, -1.84524521e-01f,
  -5.51118433e-01f, 1.35355711e-01f, -5.89827336e-02f, -1.93730503e-01f, 3.02089483e-01f, 2.70487607e-01f, 3.36003274e-01f, -8.62777680e-02f, -1.95107579e-01f, 1.52524561e-01f,
  2.11731568e-01f, 1.39337957e-01f, 3.61815989e-02f, 9.00509134e-02f, -6.91395625e-02f, 9.96715203e-02f, 1.57715589e-01f, -6.09548800e-02f, -2.59530097e-01f, -3.47735696e-02f,
  1.46670163e-01f, -1.02656141e-01f, -3.30453336e-01f, -1.78013578e-01f, 1.67640582e-01f, -6.93657026e-02f, 3.59944850e-02f, -5.27508222e-02f, 1.30249232e-01f, 2.40564376e-01f,
  -9.69597772e-02f, -1.34188756e-01f, 4.37534899e-02f, -2.83031184e-02f, 8.24499279e-02f, -1.09226488e-01f, 5.20207733e-02f, -1.38386071e-01f, 2.04395386e-03f, -2.01280937e-01f,
  -1.14999086e-01f, 1.88554749e-02f, 1.15579806e-01f, -5.69093898e-02f, -2.16616750e-01f, -7.19816908e-02f, -2.42801324e-01f, -1.34524062e-01f, -2.06016675e-01f, -1.06951810e-01f,
  3.27690870e-01f, 9.85590592e-02f, -1.88100174e-01f, 1.19490944e-01f, -8.55849013e-02f, -2.25465879e-01f, -3.19940858e-02f, -1.68933898e-01f, -1.49813175e-01f, -2.35476211e-01f,
  9.50308517e-02f, 1.32257352e-02f, 1.51358500e-01f, -6.42897710e-02f, -1.07171059e-01f, -1.73444618e-02f, 6.66353703e-02f, 1.12196609e-01f, 5.08898869e-02f, 1.06270220e-02f,
  4.63697454e-03f, 9.62301157e-03f, -3.82353067e-02f, 1.81795508e-02f, 7.84515403e-03f, 3.87314074e-02f, 2.27007829e-02f, -3.97399580e-03f, -2.58461051e-02f, -1.17817298e-01f,
  -3.72976921e-02f, 2.75970381e-02f, -3.47040780e-02f, -3.71780470e-02f, 9.92989913e-02f, -1.11123193e-02f, 1.01616693e-04f, -6.05391711e-02f, -2.10136682e-01f, 3.54671776e-02f,
  -2.22554356e-01f, 1.15115345e-01f, -1.87942192e-01f, -6.03387058e-02f, -2.42232680e-02f, -1.15032688e-01f, 5.93114980e-02f, -1.06445760e-01f, -1.04190648e-01f, 6.13643415e-02f,
  -7.34015256e-02f, -5.50737092e-03f, 5.78251593e-02f, -8.57375413e-02f, 1.20021189e-02f, -1.63289178e-02f, 1.13492668e-01f, 1.66230291e-01f, 5.32355858e-04f, 1.18767127e-01f,
  -2.24154370e-04f, -1.04109608e-01f, -1.17062196e-01f, 1.18362702e-01f, 4.97354418e-02f, -1.11486711e-01f, -1.75737649e-01f, -3.24057974e-02f, -4.98551689e-02f, -2.89955407e-01f,
  7.99606740e-01f, -5.21410882e-01f, 7.77578587e-03f, 3.00238669e-01f, 1.45507425e-01f, 9.51988176e-02f, -2.02876002e-01f, 9.30487085e-03f, 1.82243586e-01f, 2.73597799e-02f,
  -3.64567898e-02f, 2.82630324e-01f, 2.36772269e-01f, 1.12969279e-01f, -4.34377324e-03f, -1.68280751e-01f, -5.75896390e-02f, 1.54221281e-01f, 3.07263762e-01f, 2.05490708e-01f,
  -6.33657277e-02f, -1.23420686e-01f, 5.30893877e-02f, 2.75644623e-02f, -2.93452889e-01f, 2.02563182e-01f, -2.12211549e-01f, -2.12090775e-01f, -2.13339105e-01f, -3.29627484e-01f,
  4.87650372e-02f, -6.70561865e-02f, 2.29664266e-01f, 4.72859107e-02f, -1.34822324e-01f, 6.39030859e-02f, 8.25404459e-06f, 4.00097743e-02f, 4.76839989e-02f, -6.65913597e-02f,
  -8.90822709e-02f, -4.85912152e-02f, 3.96072157e-02f, -1.00645714e-01f, -1.87848225e-01f, -1.02038354e-01f, -1.85521632e-01f, -1.01917520e-01f, 2.73140520e-02f, -2.32183170e-02f,
  -1.06675059e-01f, -5.56316338e-02f, -2.07098145e-02f, 6.98319897e-02f, 2.35263817e-02f, 1.51790857e-01f, -1.19702607e-01f, -1.15196630e-02f, -5.42646125e-02f, -1.18100971e-01f,
  8.14468041e-02f, 3.61019559e-02f, -5.58591157e-04f, -4.37397026e-02f, 1.27850510e-02f, 1.06672764e-01f, 8.73770341e-02f, -7.69111421e-03f, 7.65200406e-02f, 1.55762006e-02f,
  -6.66006133e-02f, 9.31334402e-03f, 5.88752888e-03f, 4.53375839e-02f, -4.00639996e-02f, -8.65611359e-02f, 1.34078180e-02f, -6.00145385e-02f, 1.44737319e-03f, -1.48843341e-02f,
  7.32712373e-02f, -3.94911245e-02f, 1.55999092e-02f, -1.49452478e-01f, -8.78028572e-02f, 2.19742693e-02f, 4.07100022e-02f, 2.22532470e-02f, 2.44905753e-03f, 7.71799264e-03f,
  -5.59335481e-03f, 1.53712183e-01f, 1.44749731e-01f, -5.51574305e-02f, -3.32779698e-02f, -6.73465878e-02f, 4.22401354e-02f, -1.11761436e-01f, 2.88363807e-02f, -4.29039188e-02f,
  6.86717331e-02f, 1.28736138e-01f, -1.39084145e-01f, -8.02098885e-02f, 1.37134567e-01f, 1.24327824e-01f, -4.56879698e-02f, 4.36522588e-02f, 5.87710738e-02f, -1.52350456e-01f,
  -1.36832938e-01f, 1.93945110e-01f, 3.01749766e-01f, 1.96227491e-01f, 1.72246918e-01f, 2.89012998e-01f, 2.21118834e-02f, 4.03885543e-02f, 1.81299299e-01f, 4.46063355e-02f,
  -7.54950523e-01f, 1.68973327e-01f, 2.49484330e-01f, -1.87061563e-01f, -1.55102655e-01f, -1.98066130e-01f, -6.17268384e-02f, -1.52068779e-01f, -2.50185817e-01f, 4.83112931e-02f,
  5.52237183e-02f, 6.73650056e-02f, 2.09885269e-01f, 1.63671911e-01f, 2.28501022e-01f, 9.44009870e-02f, 3.72179523e-02f, 5.59623688e-02f, -1.16991755e-02f, -7.01390430e-02f,
  -1.88856684e-02f, -4.07251827e-02f, -1.40823722e-01f, -5.34153134e-02f, 1.53155729e-01f, 1.03858849e-02f, -2.35491153e-02f, 4.80504967e-02f, 1.24424569e-01f, 2.57334292e-01f,
  6.42618954e-01f, -1.70929149e-01f, 1.62616035e-03f, -1.42821848e-01f, -6.05416708e-02f, -5.48442304e-02f, 5.83164133e-02f, -5.26844263e-02f, -1.95878655e-01f, -6.26699254e-02f,
  -6.54687136e-02f, -1.37576655e-01f, -1.19445547e-01f, 1.11216111e-02f, -6.62039313e-03f, -6.00113720e-02f, -1.52181998e-01f, 5.34315705e-02f, -4.16911952e-02f, 7.99259171e-02f,
  5.51782316e-03f, -4.04967777e-02f, 9.10419002e-02f, -1.00065082e-01f, -5.70183955e-02f, -5.41309826e-02f, -1.62886009e-02f, -9.01657566e-02f, -1.01901554e-01f, 3.22473161e-02f,
  9.81081650e-02f, -2.07379423e-02f, 8.05434287e-02f, 1.22066073e-01f, -2.30334904e-02f, -2.11447738e-02f, -6.51420951e-02f, 8.61531496e-02f, 3.34140509e-02f, -9.64452177e-02f,
  -6.65357783e-02f, 2.44313497e-02f, 4.71759290e-02f, -6.55322475e-03f, 8.51870477e-02f, 4.22526933e-02f, -1.14164539e-01f, 8.88449978e-03f, -7.37743974e-02f, -1.21355198e-01f,
  -5.16392179e-02f, -1.78785473e-02f, -9.44208950e-02f, 1.02028653e-01f, 3.01368721e-02f, -2.02534143e-02f, -1.05199635e-01f, 5.74759059e-02f, -9.48039144e-02f, -1.39716705e-02f,
  4.34829623e-01f, -1.21891506e-01f, 2.57315516e-01f, 9.62272957e-02f, -6.03420893e-03f, -6.25483692e-02f, 9.10959169e-02f, 6.80465847e-02f, 4.12858240e-02f, 4.04977724e-02f,
  2.65927464e-02f, -8.98671597e-02f, 1.12912047e-03f, 5.51197901e-02f, -6.72292570e-03f, -1.07815042e-02f, -2.77877450e-02f, 1.08578205e-01f, 7.30618089e-02f, 4.82092462e-02f,
  -1.64942890e-02f, -5.45528568e-02f, 1.89912811e-01f, 2.70183813e-02f, 1.58255585e-02f, 1.03397101e-01f, 2.49563873e-01f, 7.15509504e-02f, 1.22820318e-01f, -2.53999159e-02f,
  -1.57695785e-01f, 3.97515856e-02f, 3.45019693e-03f, 5.06737866e-02f, 2.85407037e-01f, 1.42529933e-02f, -3.52187157e-02f, -1.70998842e-01f, 3.47061345e-04f, 4.49810363e-02f,
  1.69643879e-01f, 1.27990425e-01f, 2.34978676e-01f, 1.49980504e-02f, -1.88411728e-01f, 3.46341692e-02f, 2.15857401e-01f, -9.23766270e-02f, -4.11108762e-01f, -2.09376156e-01f,
  1.80890888e-01f, -8.44297409e-02f, -3.62648249e-01f, -1.45948008e-01f, 2.15851128e-01f, 1.76780149e-02f, 1.03432253e-01f, 6.95155188e-02f, 5.03597641e-03f, 4.36078995e-01f,
  1.31000072e-01f, -7.82320499e-02f, -5.10147540e-03f, -2.37545893e-02f, 9.19365324e-03f, -2.85394248e-02f, -1.84998319e-01f, -2.69883443e-02f, -1.12726539e-01f, 7.98460171e-02f,
  2.70826548e-01f, -3.68923321e-02f, 2.91178972e-01f, -3.52972536e-03f, -1.27761468e-01f, -2.31655970e-01f, -1.61464736e-01f, -2.69001931e-01f, -1.38736293e-01f, -1.74865961e-01f,
  2.59285271e-01f, -7.13984147e-02f, -5.36239594e-02f, -6.66775852e-02f, -9.08871964e-02f, -2.78681032e-02f, -8.52194950e-02f, -5.98308630e-02f, -2.66498685e-01f, -9.30957496e-02f,
  -8.08946192e-02f, -7.06275553e-02f, -1.89507399e-02f, -2.80701891e-02f, 1.65563151e-01f, 1.74277157e-01f, 3.35474759e-02f, -1.52957058e-02f, 2.78149247e-02f, -4.64454368e-02f,
  -4.96242661e-03f, -1.02440737e-01f, -6.81089684e-02f, -1.48613304e-01f, 1.49666546e-02f, -1.65352345e-01f, -3.82110029e-02f, -6.93614855e-02f, -1.63826749e-01f, -6.17224164e-02f,
  8.30020681e-02f, 4.27159406e-02f, 1.22101396e-01f, -5.44154784e-04f, 3.98846455e-02f, -1.32306650e-01f, -5.71601512e-03f, -1.90480411e-01f, -1.19605131e-01f, -3.06859557e-02f,
  -1.17653385e-01f, 4.97457869e-02f, 8.92222449e-02f, -3.80224027e-02f, -2.49096099e-02f, -6.79200292e-02f, 8.54672492e-02f, -1.06693491e-01f, 2.53455178e-03f, -1.53258681e-01f,
  2.25883052e-02f, -2.66269222e-02f, 1.34943742e-02f, -8.62892345e-03f, -3.61937732e-02f, 1.22142971e-01f, 4.49410034e-03f, -6.03001155e-02f, -1.00092374e-01f, -6.62086308e-02f,
  -3.38685364e-02f, -2.09936708e-01f, -3.35117318e-02f, 5.46448119e-02f, 5.74672483e-02f, -1.26974583e-01f, -5.64711681e-03f, -2.50142794e-02f, -1.16120756e-01f, -1.89018771e-01f,
  1.54680759e-01f, -2.42923945e-01f, -2.09391117e-01f, 2.15413243e-01f, 1.12809241e-01f, -6.99277148e-02f, -3.66411030e-01f, 5.29342219e-02f, 1.06882200e-01f, -2.59651691e-01f,
  4.51963767e-02f, 2.01853082e-01f, -2.01430526e-02f, -1.01072930e-01f, -1.43216550e-01f, -3.89085710e-01f, -2.25236282e-01f, -1.43488795e-01f, 9.73685011e-02f, 2.37397686e-01f,
  9.49059203e-02f, 1.45116806e-01f, 1.54495761e-02f, 7.87721574e-02f, -1.01247855e-01f, 1.91868674e-02f, -2.21923709e-01f, -9.05183852e-02f, -2.42607370e-01f, -2.99958318e-01f,
  -3.18893313e-01f, -6.63787797e-02f, 5.54798432e-02f, 1.45989209e-02f, 9.35993623e-03f, 8.12861696e-02f, 7.72134066e-02f, -8.89439508e-02f, 1.10465296e-01f, 1.17485980e-02f,
  1.31759226e-01f, 2.32602715e-01f, 1.67650789e-01f, 7.28015006e-02f, 5.03040664e-02f, 9.94107723e-02f, -3.48443612e-02f, -8.37273970e-02f, -2.97784694e-02f, -1.50006905e-01f,
  1.18598538e-02f, -4.70628887e-02f, -5.03803464e-03f, -1.40633732e-01f, -3.14188097e-03f, -1.62282120e-02f, -4.70142178e-02f, -1.08122369e-02f, -1.60071492e-01f, -1.24355637e-01f,
  -1.49037736e-02f, -7.09294602e-02f, -6.76444024e-02f, 8.42095613e-02f, 1.67990886e-02f, 4.00098972e-02f, 9.78762135e-02f, -3.81295010e-02f, -5.25231697e-02f, 7.42975771e-02f,
  9.20485612e-03f, -7.27083758e-02f, 7.41203129e-02f, -2.48347428e-02f, -3.57076712e-02f, 6.58626780e-02f, -7.55681172e-02f, -1.63014397e-01f, -8.12570825e-02f, 9.80572402e-02f,
  1.01769887e-01f, 8.70192144e-03f, 2.63573043e-02f, 2.87816264e-02f, -1.43037856e-01f, -8.53563920e-02f, 8.08893889e-02f, 1.38967752e-01f, 1.18181571e-01f, 5.68267554e-02f,
  1.03359029e-01f, -1.49356335e-01f, -7.20005715e-04f, 1.31227776e-01f, -7.98661634e-02f, -3.59704234e-02f, -9.99823585e-02f, -1.16870310e-02f, 1.33279920e-01f, 4.00123969e-02f,
  2.91639976e-02f, 4.36964706e-02f, -1.18417025e-01f, 2.07076762e-02f, 3.94518562e-02f, 1.33085757e-01f, -6.84972405e-02f, 6.39921576e-02f, -1.03456587e-01f, 1.31001994e-01f,
  -3.54673266e-02f, -6.88866302e-02f, 3.90421785e-02f, -1.99653476e-01f, -1.16307037e-02f, 9.27355587e-02f, -1.23445146e-01f, -7.73053095e-02f, -1.55869141e-01f, -2.97954917e-01f,
  -3.73930544e-01f, -2.64533848e-01f, -8.75846371e-02f, -4.64510262e-01f, -9.17803124e-02f, 2.94493884e-01f, 6.59455359e-02f, 2.97896471e-02f, -1.88440427e-01f, -2.70037830e-01f,
  -8.30388367e-02f, -3.94469462e-02f, -1.90055415e-01f, -4.63856868e-02f, -2.31123101e-02f, -1.61586508e-01f, -1.34383380e-01f, -9.76669490e-02f, 1.75193578e-01f, 2.91841835e-01f,
  4.60013896e-02f, -3.59661400e-01f, -2.55982995e-01f, 9.32556763e-03f, -3.05171221e-01f, -2.39292383e-01f, -3.93763363e-01f, -2.36134171e-01f, -2.55939048e-02f, -3.78120124e-01f,
  -1.38261467e-01f, 7.22318562e-03f, 1.94707643e-02f, -1.89827997e-02f, -4.50637117e-02f, 2.99612880e-02f, -1.69912037e-02f, -1.10870637e-01f, 8.11217874e-02f, 7.59885386e-02f,
  -4.72958721e-02f, 1.00547686e-01f, -7.54307359e-02f, 6.98615015e-02f, -2.01650988e-02f, 4.71775644e-02f, 1.54013395e-01f, -7.04228552e-03f, -2.12438358e-03f, 7.94246495e-02f,
  1.67627320e-01f, 2.27613971e-01f, -3.21171284e-02f, 2.87171990e-01f, 2.72778124e-01f, 8.48379061e-02f, 1.84317783e-01f, 2.20634073e-01f, 2.18645096e-01f, 2.96103191e-02f,
  -1.32408202e-01f, -1.45603493e-02f, -5.98729961e-02f, -2.25166753e-02f, 1.25083789e-01f, 1.06563613e-01f, 2.88222097e-02f, -6.07027933e-02f, -2.58075334e-02f, 4.41980250e-02f,
  2.11176574e-02f, -2.05534492e-02f, 8.87280516e-03f, -6.94939792e-02f, -5.54036237e-02f, -6.06172010e-02f, 1.31066027e-03f, -2.96373870e-02f, 1.25870585e-01f, 1.86291276e-04f,
  9.28708389e-02f, 7.62535408e-02f, -8.10984746e-02f, 6.72637206e-03f, -5.12070619e-02f, -1.27630889e-01f, -4.45517823e-02f, 9.81073827e-05f, 5.43440208e-02f, 2.98158973e-02f,
  -4.00336325e-01f, 1.76870197e-01f, -1.42619997e-01f, -1.11118704e-01f, 4.50758496e-03f, 8.90682936e-02f, -9.32283252e-02f, -1.59271955e-02f, -4.59021069e-02f, 6.04655482e-02f,
  1.98788017e-01f, 1.55549888e-02f, 5.30817546e-02f, 3.84267494e-02f, 1.84081316e-01f, 1.73441857e-01f, 9.82646551e-03f, -1.30892590e-01f, 4.50531095e-02f, 4.94518057e-02f,
  1.02355247e-02f, 5.32751121e-02f, -3.29193883e-02f, 5.52405566e-02f, 1.56989664e-01f, 4.49242517e-02f, 7.22790807e-02f, 1.42321244e-01f, 1.82539783e-02f, -6.08437508e-02f,
  -3.04010600e-01f, -1.18029587e-01f, 1.33076146e-01f, 1.93223223e-01f, 9.51713547e-02f, 8.87548402e-02f, 2.89900303e-01f, 2.56430298e-01f, 1.71142846e-01f, 5.95317632e-02f,
  -1.22987308e-01f, -8.74934196e-02f, 2.65075965e-03f, 1.41784683e-01f, 2.37351432e-01f, 3.45946610e-01f, 3.76377165e-01f, 3.47704925e-02f, 4.78011789e-03f, -2.82183615e-03f,
  1.66752592e-01f, -3.64869796e-02f, -1.92347005e-01f, 2.26800907e-02f, 1.14726238e-01f, -1.39759155e-02f, 3.00710090e-04f, 2.83040013e-02f, 4.63890471e-02f, 2.60854423e-01f,
  -1.20572016e-01f, -3.46447304e-02f, 5.95980436e-02f, -1.95219815e-01f, -2.54619539e-01f, -1.45914271e-01f, 2.75118221e-02f, 2.32788585e-02f, -2.63525844e-01f, -2.60548536e-02f,
  -6.60553500e-02f, -1.30957782e-01f, 5.05129807e-02f, -7.29271630e-03f, -1.18315844e-02f, -9.14122835e-02f, 5.75147420e-02f, 1.93839207e-01f, 1.70079738e-01f, 9.88378674e-02f,
  1.59417763e-01f, -1.68737452e-02f, 1.42226130e-01f, 9.48966295e-02f, 1.91049099e-01f, 1.51014095e-03f, 3.62714306e-02f, -3.05546094e-02f, 8.07525218e-02f, 2.84008589e-02f,
  4.95817177e-02f, 1.20948087e-02f, 1.22623079e-01f, 7.02016354e-02f, 9.15796161e-02f, -5.02584465e-02f, 1.21911623e-01f, 9.20379236e-02f, 1.66231528e-01f, 6.29348382e-02f,
  5.17666228e-02f, 2.43478179e-01f, 1.90722883e-01f, 1.13775156e-01f, -9.40841250e-03f, 1.43622220e-01f, 1.21732570e-01f, -4.97969389e-02f, -9.65529233e-02f, -5.87726384e-02f,
  1.66968316e-01f, -5.83452135e-02f, -7.64166117e-02f, 8.32922757e-02f, -4.07209769e-02f, 5.85965924e-02f, 1.05691977e-01f, 3.36093791e-02f, -3.32613811e-02f, -1.36845792e-02f,
  1.31434456e-01f, 5.78048825e-02f, 1.64851651e-01f, 9.23970938e-02f, -1.32560208e-01f, -2.57252365e-01f, -1.66584533e-02f, -8.41694847e-02f, -1.37710139e-01f, -1.27347158e-02f,
  -1.29295275e-01f, -1.26017526e-01f, -1.19786831e-02f, 1.53646506e-02f, -8.90889317e-02f, -5.03403172e-02f, -6.46019951e-02f, 2.08543763e-01f, 1.16511397e-01f, -8.43298212e-02f,
  1.07442796e-01f, 7.20662996e-03f, -4.58087809e-02f, 1.03438966e-01f, 2.92634442e-02f, -7.64566585e-02f, -9.41557586e-02f, -7.72881135e-03f, -1.48011848e-01f, -1.25503704e-01f,
  -5.64046741e-01f, 1.09266043e-01f, -1.32168029e-02f, -1.55339763e-01f, -3.38321365e-02f, -6.21446520e-02f, -1.27178535e-01f, 1.53220175e-02f, -1.84325546e-01f, -1.56858265e-01f,
  1.07393369e-01f, 1.33761242e-01f, 3.10382508e-02f, 1.25246763e-01f, 1.78875718e-02f, -2.19370052e-01f, -3.18378508e-01f, -2.05475375e-01f, 1.53436270e-02f, 3.51587646e-02f,
  -1.03448704e-01f, -1.29767463e-01f, -2.34865203e-01f, -1.40839934e-01f, 1.23287827e-01f, -4.65364903e-02f, -6.72189146e-02f, -1.35387763e-01f, 2.66612377e-02f, -9.93381366e-02f,
  5.29739678e-01f, 2.40000710e-02f, 6.71058223e-02f, -6.00353777e-02f, 1.26423687e-01f, -6.96258694e-02f, 5.58282733e-02f, -5.02779707e-02f, -9.71107557e-02f, 3.65068875e-02f,
  -2.99342908e-02f, -4.82321680e-02f, -2.75541246e-02f, 1.02041110e-01f, 4.49454896e-02f, -2.00465843e-02f, 2.61164252e-02f, 8.60288925e-03f, 5.17591052e-02f, 1.17143795e-01f,
  -5.59933707e-02f, 1.32351406e-02f, 1.48467064e-01f, -1.95578691e-02f, 2.32207356e-03f, -3.00877336e-02f, 1.91706493e-01f, -4.67175320e-02f, 8.95655155e-02f, 1.87304930e-03f,
  -1.82904638e-02f, 6.47099912e-02f, 5.39211482e-02f, 4.57716398e-02f, -1.24295019e-02f, -1.92934237e-02f, 6.85189143e-02f, 1.00047365e-02f, 3.87170985e-02f, 2.63476302e-03f,
  -2.51519904e-02f, 2.57747844e-02f, 3.27124819e-02f, -2.07818858e-02f, 4.45695519e-02f, 1.26133934e-01f, -8.27291906e-02f, 9.27460417e-02f, 1.14453945e-03f, -5.96555732e-02f,
  -6.10566810e-02f, 1.44084860e-02f, 2.90053133e-02f, 9.10909548e-02f, -5.42515330e-02f, -6.99061677e-02f, -4.71633263e-02f, 3.87366675e-02f, -1.75368994e-01f, -8.19318965e-02f,
  4.21135902e-01f, -3.82130481e-02f, 1.03003211e-01f, 7.75263458e-03f, -2.20646914e-02f, -1.37734428e-01f, -2.01593954e-02f, 7.04850927e-02f, 1.41417325e-01f, 8.50261599e-02f,
  2.57327501e-02f, 9.08825547e-03f, 2.94325240e-02f, 9.48067084e-02f, -1.62716322e-02f, 1.00020885e-01f, 8.64537880e-02f, 8.81044194e-02f, 6.25340343e-02f, 4.77750339e-02f,
  -7.38812611e-02f, 7.38715380e-02f, 2.25071937e-01f, 1.35745496e-01f, -2.93227676e-02f, -5.25360554e-02f, 2.07214981e-01f, 9.48563442e-02f, 2.75318567e-02f, 5.41193187e-02f,
  -5.71489453e-01f, -1.76844269e-01f, -9.51436982e-02f, -2.66279489e-01f, 1.24670200e-01f, 3.86743903e-01f, 3.26392561e-01f, 1.21463127e-01f, -1.58660207e-02f, -8.84354785e-02f,
  1.51943266e-01f, 6.68544248e-02f, -1.18953750e-01f, 1.22613229e-01f, 1.54643118e-01f, 1.93478584e-01f, 1.29114851e-01f, -3.92540656e-02f, 1.55997649e-01f, 4.15685713e-01f,
  1.94002926e-01f, -1.22990839e-01f, -1.13098308e-01f, 9.70407575e-02f, -1.14301339e-01f, -8.53861943e-02f, -1.65242165e-01f, -9.73836631e-02f, 1.02738753e-01f, -3.02754551e-01f,
  -3.06271493e-01f, -2.62539208e-01f, 1.77669033e-01f, 1.86994255e-01f, -4.65122871e-02f, -3.85791846e-02f, 1.88838150e-02f, -2.67851204e-01f, 1.86317172e-02f, -7.33393952e-02f,
  -8.03875327e-02f, 4.03832383e-02f, -1.04863375e-01f, 1.82826951e-01f, 1.51872244e-02f, 9.79370028e-02f, 4.09233235e-02f, 5.66278445e-03f, -1.20487353e-02f, -7.82011263e-03f,
  1.36270359e-01f, 7.11406395e-02f, -2.60837972e-01f, 3.66217159e-02f, -1.43434554e-01f, -1.44549936e-01f, -5.85790090e-02f, -1.46424487e-01f, -5.00181206e-02f, -3.54495794e-01f,
  2.11116746e-02f, -3.78592052e-02f, -2.57381089e-02f, -4.87447120e-02f, -7.01994151e-02f, -8.59075785e-02f, 5.19897230e-03f, 8.62168819e-02f, 3.97843085e-02f, -1.34243652e-01f,
  -1.24871517e-02f, 7.64949024e-02f, 4.91133183e-02f, -3.26068997e-02f, 3.55512500e-02f, -9.96805634e-03f, 7.83638880e-02f, -5.20044602e-02f, 3.47521827e-02f, -1.35996407e-02f,
  -6.73689470e-02f, -1.51149988e-01f, -4.89014201e-02f, 9.50155035e-03f, 1.01999275e-01f, 1.11107618e-01f, 3.71671468e-02f, 1.26221493e-01f, 3.23700570e-02f, -1.16873542e-02f,
  -4.14152704e-02f, 2.60452747e-01f, -2.49233946e-01f, -3.71443257e-02f, -7.17094913e-02f, -1.69099525e-01f, -1.37857869e-01f, -2.39291997e-03f, -7.90530071e-03f, -1.04615381e-02f,
  6.64794967e-02f, -1.08028494e-01f, -1.39491737e-01f, -4.27614897e-02f, -1.06768675e-01f, -3.72529365e-02f, -1.26843899e-01f, -4.99759568e-03f, 3.54841724e-03f, 6.68560937e-02f,
  -1.52249306e-01f, 1.25659049e-01f, -2.06830889e-01f, -2.76239365e-01f, -1.77115694e-01f, -1.63998172e-01f, -3.00478101e-01f, -8.11428875e-02f, -1.34066209e-01f, -1.83977649e-01f,
  -4.50421453e-01f, -5.10668874e-01f, 8.17828476e-02f, -1.50965974e-01f, 1.41535550e-01f, 2.28112921e-01f, 5.47609739e-02f, -5.39338402e-02f, -6.13740310e-02f, -1.39781639e-01f,
  -1.87468037e-01f, -4.00763303e-02f, -6.38087019e-02f, 3.30373296e-03f, -1.37252011e-03f, -4.22097445e-02f, -2.04621628e-02f, 2.84324288e-01f, 3.77424896e-01f, 3.07694644e-01f,
  5.70698082e-02f, -2.71814000e-02f, -8.26986060e-02f, -1.11692593e-01f, -1.89637378e-01f, 1.02694608e-01f, -1.87268734e-01f, -1.20073864e-02f, -8.73820856e-02f, -2.68512636e-01f,
  3.13393593e-01f, -3.57054114e-01f, -6.05655797e-02f, -2.08779961e-01f, -8.22269022e-02f, -4.94387299e-02f, 1.06405653e-02f, -1.90824777e-01f, -9.06037688e-02f, -2.20899582e-02f,
  -3.55930105e-02f, 6.30428419e-02f, 1.68796420e-01f, -9.48444456e-02f, -1.82643197e-02f, -1.00393064e-01f, -2.25214124e-01f, -1.78738311e-01f, -1.10983048e-02f, 5.44801429e-02f,
  -6.79575577e-02f, 1.97288785e-02f, 9.33336392e-02f, -2.55816504e-02f, 2.95864101e-02f, 2.14768518e-02f, -1.09522752e-01f, -3.10673509e-02f, 7.06858337e-02f, -4.91649806e-02f,
  7.02562109e-02f, 8.19001049e-02f, -1.25497192e-01f, 8.29465538e-02f, 4.53656800e-02f, 1.20594865e-02f, 9.95136127e-02f, 4.74476777e-02f, 1.32170588e-01f, 3.12344581e-02f,
  -1.65003948e-02f, -5.20487577e-02f, 3.87073942e-02f, -7.66007453e-02f, 2.76516494e-03f, 1.30824735e-02f, 5.05508706e-02f, -1.49314851e-01f, -9.65058152e-03f, -1.30128801e-01f,
  -1.70818833e-03f, 1.11599572e-01f, -1.58573896e-01f, 3.64020690e-02f, -1.84757844e-01f, -6.06347397e-02f, 2.94489190e-02f, -9.76012796e-02f, -1.33850854e-02f, 4.88677248e-03f,
  2.79424727e-01f, -5.69964871e-02f, 1.08369693e-01f, -1.47204129e-02f, 7.10179433e-02f, -6.21148571e-02f, -3.07220742e-02f, 4.62540686e-02f, 2.35412251e-02f, 2.11325318e-01f,
  1.01262398e-01f, 7.96493329e-03f, 5.05723581e-02f, -1.50991902e-01f, 4.32622768e-02f, 9.03300792e-02f, -1.01614073e-01f, 4.14539762e-02f, 6.51007891e-02f, -2.05575824e-02f,
  -2.05776662e-01f, 1.97378740e-01f, 1.28389597e-01f, 1.80669188e-01f, 1.05234876e-01f, 2.95495093e-01f, 1.37630314e-01f, 1.08047344e-01f, 2.60825574e-01f, 1.24612503e-01f,
  1.27311856e-01f, -1.89661533e-01f, 5.20730987e-02f, 1.82434425e-01f, 3.72129604e-02f, -4.12252337e-01f, -5.91283798e-01f, -2.81802744e-01f, 1.09964050e-01f, -1.42634526e-01f,
  -1.23739704e-01f, 6.14785030e-02f, 9.17872936e-02f, -6.62066638e-02f, -2.91312218e-01f, -2.99259871e-01f, -1.72335848e-01f, 7.05971122e-02f, -1.01160288e-01f, -7.99500197e-02f,
  7.18320459e-02f, 1.59129098e-01f, 1.78023458e-01f, 2.29884731e-03f, 2.43435606e-01f, 5.05551212e-02f, 2.10076943e-01f, 8.34026337e-02f, -9.23334509e-02f, 2.53573388e-01f,
  3.86268608e-02f, -7.87271187e-03f, 1.02111146e-01f, -1.34451622e-02f, -1.80476625e-02f, -6.95113093e-02f, -1.96805134e-01f, 1.07851423e-01f, 9.53454711e-03f, 1.87498368e-02f,
  9.10929963e-03f, 1.46625665e-04f, 2.86003768e-01f, 9.60409120e-02f, -7.23838061e-02f, -7.73490742e-02f, 8.41431599e-03f, -2.67325435e-02f, -7.69778341e-03f, -3.42274159e-02f,
  -1.54858440e-01f, 4.43518087e-02f, 6.05657138e-03f, -9.31625515e-02f, -1.17637470e-01f, -5.31417504e-02f, 9.19499435e-03f, -3.85745801e-02f, -1.24057457e-01f, -4.92942892e-02f,
  -2.72801216e-03f, -5.82420500e-03f, -2.44740620e-02f, -7.34870583e-02f, -6.21684417e-02f, 6.66703209e-02f, 9.44307894e-02f, -2.22712643e-02f, 5.78243062e-02f, 4.90645971e-03f,
  -1.97388768e-01f, 3.84940393e-02f, 7.56526291e-02f, 5.58989234e-02f, 3.88939492e-02f, 3.18644606e-02f, -7.83002749e-03f, -6.62201047e-02f, -1.23079615e-02f, 5.59235290e-02f,
  4.74305563e-02f, 4.48689833e-02f, 6.00892454e-02f, 7.81868100e-02f, -8.35772082e-02f, -1.30912550e-02f, 6.56158058e-03f, -1.20556347e-01f, 4.42819297e-02f, 9.91805177e-03f,
  1.06845751e-01f, -2.36605406e-02f, 1.59572717e-02f, 4.21345718e-02f, -1.45588564e-02f, 7.17855692e-02f, 5.72169572e-02f, -4.60367091e-02f, 7.37805059e-03f, 1.54440310e-02f,
  -6.09701164e-02f, 1.35706412e-03f, -7.40450621e-02f, -6.11599870e-02f, -2.46752072e-02f, 8.73215869e-02f, -1.16285309e-01f, -1.29172187e-02f, -2.71237064e-02f, 4.43543233e-02f,
  -3.80809940e-02f, -1.17379472e-01f, -2.14859515e-01f, -3.40867817e-01f, -7.83090815e-02f, -1.18819028e-01f, -1.23490982e-01f, -9.97144803e-02f, -2.19260588e-01f, -3.00200015e-01f,
  2.00441673e-01f, -2.79346019e-01f, -6.61021471e-02f, 1.70250490e-01f, 7.68037215e-02f, 6.64462000e-02f, 1.02367342e-01f, -7.47441053e-02f, -6.90590367e-02f, 9.17877257e-02f,
  -2.35926285e-01f, -4.62753385e-01f, -2.77496159e-01f, -2.60532588e-01f, -1.48591548e-01f, 2.11414590e-01f, 2.45471746e-01f, 8.83478820e-02f, -1.84756666e-01f, -1.91429511e-01f,
  -2.10667923e-01f, 1.11172646e-02f, -3.78698781e-02f, -8.22483674e-02f, 4.00971696e-02f, -6.59113452e-02f, -2.30925493e-02f, -3.87180820e-02f, -2.14408755e-01f, 3.33869569e-02f,
  -4.62156571e-02f, -1.39325827e-01f, -6.65215477e-02f, -7.84749910e-02f, 2.04870664e-02f, -5.39312735e-02f, -3.72647010e-02f, -1.54311294e-02f, -1.84467122e-01f, -1.86662227e-02f,
  -1.13385744e-01f, -1.50558665e-01f, -2.58566201e-01f, -1.13615848e-01f, -1.32958904e-01f, 1.27174463e-02f, -2.14402042e-02f, -2.27037996e-01f, -1.55662015e-01f, -1.61461085e-01f,
  -1.26575619e-01f, 1.87144671e-02f, -1.14364944e-01f, -5.59564494e-02f, -2.28104573e-02f, -9.82196480e-02f, -4.47118469e-02f, -1.14458159e-01f, 4.18171249e-02f, 1.41173378e-01f,
  9.81185958e-02f, 6.25009388e-02f, -5.00394516e-02f, 2.84532849e-02f, 1.47233009e-01f, 1.21687613e-01f, -7.02651963e-02f, -8.97150580e-03f, -1.17974002e-02f, -7.99008086e-02f,
  -9.18743983e-02f, 1.03348888e-01f, 1.59167834e-02f, 6.59290478e-02f, -4.42139581e-02f, -1.17185980e-01f, 7.41664171e-02f, -1.70704816e-03f, 2.60470938e-02f, -1.27524650e-02f,
  -7.78624490e-02f, 7.96357542e-02f, -2.78588962e-02f, -6.48549050e-02f, 8.94701779e-02f, -2.08893474e-02f, 8.04577991e-02f, -3.88244651e-02f, 6.66770560e-04f, -1.16465643e-01f,
  -1.34249821e-01f, -1.43702254e-01f, 1.32826954e-01f, -1.27439812e-01f, 8.54800940e-02f, 4.30626646e-02f, -3.70712765e-02f, -3.57896537e-02f, 5.38193097e-04f, 9.64623094e-02f,
  -1.83977187e-01f, -1.01148328e-02f, -3.28896120e-02f, -6.38402402e-02f, 5.41182086e-02f, 1.38379917e-01f, 7.07651675e-02f, 9.63810366e-03f, -5.96114211e-02f, 1.86279174e-02f,
  7.51844794e-02f, 1.65051386e-01f, 1.74678758e-01f, 1.68481067e-01f, 1.24000289e-01f, 2.19882622e-01f, 9.85222161e-02f, -8.03279281e-02f, 3.79214399e-02f, 2.51082838e-01f,
  -4.56481352e-02f, 4.34659630e-01f, 2.30745926e-01f, 1.42704591e-01f, 2.31000975e-01f, 4.05193210e-01f, 6.15533233e-01f, 1.88042134e-01f, -2.16492526e-02f, 9.75719541e-02f,
  1.73581451e-01f, -6.86155036e-02f, -8.31249505e-02f, -1.93801507e-01f, -5.35679050e-02f, -1.76070221e-02f, 7.84599110e-02f, -5.51343672e-02f, -1.02815196e-01f, -4.16311882e-02f,
  -1.01342477e-01f, 6.50696233e-02f, -3.46012525e-02f, -1.70260817e-01f, -5.72836362e-02f, -2.78688163e-01f, 1.32173195e-01f, 1.93291128e-01f, 7.86676705e-02f, -1.92776993e-01f,
  2.64491916e-01f, 3.33541065e-01f, -1.73416063e-01f, -6.04990050e-02f, 9.77280065e-02f, 2.46496759e-02f, 1.02465086e-01f, 1.68134332e-01f, 8.53949785e-02f, 3.75179015e-02f,
  1.59590751e-01f, 6.06200099e-02f, 4.42124866e-02f, 6.69217482e-02f, 1.32379889e-01f, -6.89121289e-03f, 3.85142975e-02f, -1.53610632e-02f, 7.50148222e-02f, 8.76497030e-02f,
  -2.81155854e-02f, 1.48605794e-01f, 2.63667852e-01f, 3.73370163e-02f, -1.87392626e-02f, 6.73912419e-03f, 1.76960118e-02f, -8.46289024e-02f, 8.33426882e-03f, -1.27367586e-01f,
  2.75930595e-02f, -1.36240691e-01f, -3.77853587e-02f, -6.86519966e-02f, -6.14127368e-02f, -5.47465980e-02f, -6.06316403e-02f, 7.90090933e-02f, -1.80189386e-01f, -1.43898964e-01f,
  6.97026923e-02f, -1.45754619e-02f, 2.13980317e-01f, -5.64980358e-02f, -7.49627426e-02f, 1.03859991e-01f, 8.60096514e-02f, 4.14621457e-02f, 1.45634890e-01f, 4.82962579e-02f,
  5.70028275e-03f, 9.56350639e-02f, 4.33145463e-02f, 1.14404466e-02f, -9.74376425e-02f, -1.37085915e-01f, -3.07545941e-02f, 3.58066484e-02f, -1.02226818e-02f, 5.63791357e-02f,
  2.82317430e-01f, 1.61713570e-01f, -2.58947372e-01f, -4.49552312e-02f, 1.14936329e-01f, -6.80474937e-02f, 5.22681745e-03f, 3.01965885e-03f, 2.82080680e-01f, 1.75181895e-01f,
  2.17959538e-01f, -8.87310132e-03f, -4.49859947e-02f, -8.99268836e-02f, -1.10089645e-01f, -1.79712623e-02f, -1.91300184e-01f, 5.11744358e-02f, 1.48294196e-01f, 2.04790145e-01f,
  3.07517592e-02f, 3.16184647e-02f, 1.01053745e-01f, -5.04042059e-02f, -1.20399587e-01f, -5.61791621e-02f, 4.10106964e-02f, 1.65530201e-02f, 1.60831530e-02f, -2.89852709e-01f,
  -2.50307731e-02f, -2.18299329e-01f, -1.97740853e-01f, 1.33993238e-01f, 3.19059163e-01f, -9.81096178e-02f, -3.44515890e-01f, 4.29202989e-02f, 2.47683525e-01f, -7.64341354e-02f,
  3.71903181e-02f, 9.96577591e-02f, 7.09173456e-03f, -1.28593281e-01f, -5.30290008e-01f, -5.58985770e-01f, -3.48952264e-01f, -2.59178102e-01f, -1.15695782e-01f, 5.93093075e-02f,
  -1.25718703e-02f, 8.32111016e-02f, -2.50445213e-02f, -9.08635743e-03f, 1.51800767e-01f, 1.60692275e-01f, 1.03169065e-02f, 1.28182629e-02f, -5.98149709e-02f, 5.97317778e-02f,
  -1.66453540e-01f, 6.39161617e-02f, -3.71986367e-02f, -5.13057830e-03f, 3.54786813e-02f, -8.05748999e-03f, -1.58409595e-01f, -1.35275409e-01f, -6.05237968e-02f, -1.23815589e-01f,
  -7.21261231e-03f, 6.38702288e-02f, 1.97938278e-01f, 6.56287139e-03f, -6.63885772e-02f, -4.46004700e-03f, -3.91741432e-02f, -7.50603527e-02f, -1.67304859e-01f, 6.16299827e-03f,
  -3.31954844e-02f, -5.83338086e-03f, 2.21900307e-02f, -2.12673694e-02f, -2.19890028e-01f, 2.94519067e-02f, 1.13048881e-01f, 9.96225029e-02f, 4.41614585e-03f, 1.25813708e-01f,
  6.54343739e-02f, -3.17508839e-02f, -1.32178487e-02f, 4.49703895e-02f, 1.98957697e-02f, 5.18636294e-02f, 1.10748611e-01f, -7.53595382e-02f, -2.82615796e-02f, 3.84874158e-02f,
  -9.20221582e-02f, 2.18354408e-02f, 2.03940012e-02f, -8.51199478e-02f, 5.25836684e-02f, -5.69641218e-02f, -4.05592360e-02f, -8.90892670e-02f, -1.07849061e-01f, 6.73189759e-03f,
  1.08499909e-02f, 1.86800640e-02f, 9.80475470e-02f, 3.37661207e-02f, 4.70925942e-02f, -3.30936424e-02f, -1.03181139e-01f, 1.95364952e-02f, 1.91032309e-02f, -9.85473469e-02f,
  -3.73071358e-02f, -7.58993477e-02f, -8.98943022e-02f, -6.64132461e-02f, -3.09740230e-02f, 1.41365975e-02f, -3.27151790e-02f, -4.78468649e-02f, -3.29387784e-02f, -4.67629209e-02f,
  -3.24266180e-02f, 3.87015231e-02f, -9.90001932e-02f, -1.27583435e-02f, -5.38618825e-02f, -4.79613990e-03f, -7.61125758e-02f, 5.39866686e-02f, -1.29110664e-01f, 7.76945576e-02f,
  -2.85150371e-02f, -1.49291351e-01f, -8.71594995e-02f, -1.38555750e-01f, 6.09529801e-02f, 9.82059631e-03f, 6.27430379e-02f, 6.94252253e-02f, -1.02675013e-01f, -8.29154849e-02f,
  1.26940429e-01f, -3.64007622e-01f, 3.24002653e-01f, 2.59203285e-01f, 3.87370348e-01f, 3.95783633e-01f, 2.22189009e-01f, 1.78572014e-01f, 1.59431234e-01f, -7.14997873e-02f,
  -1.77060381e-01f, -2.96799719e-01f, -3.39915544e-01f, -2.71652162e-01f, -2.58392572e-01f, 1.51073085e-02f, 1.64463207e-01f, 1.29595071e-01f, 1.63693681e-01f, 1.29116595e-01f,
  -3.56062427e-02f, 1.27365932e-01f, 1.28146922e-02f, -8.32759961e-02f, -1.23511799e-01f, -3.19785438e-02f, 5.79216182e-02f, 6.00683577e-02f, -3.87661085e-02f, -1.89134434e-01f,
  -3.12658459e-01f, -1.39384404e-01f, 3.26844752e-02f, -1.62756935e-01f, 3.96081284e-02f, -1.55179963e-01f, -3.32531668e-02f, -2.42032371e-02f, -4.30661105e-02f, -1.37255728e-01f,
  -9.09151062e-02f, -1.97760746e-01f, -3.31886895e-02f, -1.09120667e-01f, 1.00239813e-01f, 4.08783443e-02f, -9.95108932e-02f, -7.38379732e-02f, -1.88979805e-01f, -4.13303822e-02f,
  -2.83819754e-02f, 8.65847990e-02f, -5.22231646e-02f, -7.46217743e-03f, 2.78014801e-02f, 1.08192571e-01f, -4.63204309e-02f, 1.65704377e-02f, 4.66440879e-02f, -1.03056572e-01f,
  -7.52459988e-02f, 9.34924856e-02f, 2.64093820e-02f, -1.40645299e-02f, 7.95014203e-02f, 3.07078362e-02f, -8.28961805e-02f, -2.56787483e-02f, -1.32115856e-01f, -1.68374553e-02f,
  9.31854770e-02f, -2.50209607e-02f, 2.40842644e-02f, 5.96751599e-03f, -4.57048044e-03f, 7.59942532e-02f, 1.34013183e-02f, -8.44351295e-03f, 3.63024101e-02f, 4.78449315e-02f,
  -2.99518630e-02f, 1.51338996e-02f, 1.01149656e-01f, -3.57511677e-02f, 6.24163076e-03f, -8.41744319e-02f, 5.24169616e-02f, 3.16381231e-02f, -2.38912292e-02f, 7.02342018e-02f,
  -2.64340907e-01f, -7.93866664e-02f, -1.61137834e-01f, 4.52318089e-03f, -1.45578552e-02f, 7.86327422e-02f, 5.86217418e-02f, -3.25188488e-02f, -3.26333232e-02f, -1.22813366e-01f,
  3.07988040e-02f, -1.72947779e-01f, -1.08831838e-01f, 8.60525742e-02f, 1.49794683e-01f, 8.95129070e-02f, -1.58490285e-01f, 6.58233166e-02f, -6.50183260e-02f, 7.89856017e-02f,
  4.32926267e-02f, 2.20231965e-01f, 5.08756330e-03f, 1.09115407e-01f, -3.91733162e-02f, 1.17300510e-01f, 1.79417785e-02f, 4.37194109e-02f, 6.39289469e-02f, 8.74062404e-02f,
  -3.72853816e-01f, -3.22216809e-01f, -3.48031610e-01f, 4.71717492e-02f, 1.98517829e-01f, -6.38953000e-02f, -2.45708734e-01f, -3.13601315e-01f, 1.25984056e-02f, 6.46083429e-02f,
  1.75160795e-01f, 3.52002949e-01f, 1.48602813e-01f, 4.85510118e-02f, -1.64469957e-01f, -3.20664863e-03f, 1.67562217e-01f, 3.46902646e-02f, -3.53703797e-02f, 1.36276260e-01f,
  2.53578037e-01f, 1.38202891e-01f, -1.43911958e-01f, 8.89823809e-02f, 2.46827856e-01f, 4.43355776e-02f, -2.85155103e-02f, 8.78135934e-02f, -1.08180687e-01f, 2.02065498e-01f,
  -2.89947111e-02f, -3.16616744e-01f, 9.03853104e-02f, 1.64285347e-01f, 1.05556861e-01f, -1.65607065e-01f, -1.83963522e-01f, -8.01096931e-02f, 7.49089345e-02f, -8.85321870e-02f,
  1.58021674e-01f, -8.24084356e-02f, 7.40390047e-02f, 3.35032977e-02f, 7.39340559e-02f, -6.44570142e-02f, 4.07491922e-02f, -9.02252495e-02f, -5.66915162e-02f, -9.15952548e-02f,
  2.39693448e-01f, 6.31626025e-02f, -1.92250907e-02f, -9.16776583e-02f, -2.12194353e-01f, 1.49457112e-01f, -2.37534773e-02f, -9.70414951e-02f, -2.09338218e-01f, -2.82483935e-01f,
  1.03516310e-01f, 1.63687110e-01f, 1.30195403e-02f, -5.85507378e-02f, 1.47963226e-01f, 4.29328792e-02f, 2.45440621e-02f, 1.72619909e-01f, 4.91707176e-02f, -5.15978150e-02f,
  4.25691530e-02f, 1.15259679e-03f, -5.19602448e-02f, 2.84250136e-02f, 5.27591445e-02f, 4.40509096e-02f, 8.03483427e-02f, 2.65084337e-02f, 5.97124547e-02f, 2.89147645e-02f,
  1.35154615e-03f, -6.10005073e-02f, 5.79927191e-02f, 3.03608757e-02f, -8.55119079e-02f, 5.46908826e-02f, -1.35947000e-02f, 9.55397412e-02f, -1.38339140e-02f, 4.34322692e-02f,
  -5.38507476e-02f, -5.33191022e-03f, 4.61549424e-02f, 7.31299296e-02f, 4.30672206e-02f, 4.64095585e-02f, -3.44228819e-02f, 1.23500466e-01f, 1.56265244e-01f, 1.19631272e-02f,
  -7.62982592e-02f, -9.52101126e-02f, -1.16609529e-01f, -2.37209927e-02f, -1.32473126e-01f, -1.94181390e-02f, 4.03711237e-02f, 6.61455616e-02f, 2.02392608e-01f, 4.52770144e-02f,
  -3.00937388e-02f, 5.41578420e-02f, 5.56296855e-02f, -7.71105364e-02f, 1.08704409e-02f, -8.62845592e-03f, -3.34349498e-02f, -1.75907135e-01f, -1.43095538e-01f, -4.37551528e-01f,
  -1.98600203e-01f, -4.06854488e-02f, 1.37429729e-01f, 1.10657990e-01f, 1.81777567e-01f, 2.24540755e-02f, -2.17726350e-01f, -2.47348584e-02f, 1.52540937e-01f, -4.11094017e-02f,
  9.45089906e-02f, 1.99412048e-01f, -2.49794945e-02f, -1.60602644e-01f, -3.86773705e-01f, -3.36756259e-01f, -2.46596739e-01f, -2.75588244e-01f, -2.03529343e-01f, -1.23476468e-01f,
  -3.57361287e-02f, 3.33145671e-02f, -1.84994802e-01f, -1.12589404e-01f, 2.16433946e-02f, -1.06112413e-01f, 3.83990258e-02f, -7.32975975e-02f, -1.80948541e-01f, -1.57463983e-01f,
  -2.00682983e-01f, 2.18007877e-01f, 6.25653043e-02f, 4.23874855e-02f, 2.23938987e-01f, 1.96131282e-02f, 1.99476425e-02f, 2.74001118e-02f, 7.87135288e-02f, -6.09661788e-02f,
  -1.04551665e-01f, -5.74894696e-02f, 1.49412170e-01f, -3.03956997e-02f, -1.48603156e-01f, -1.81312516e-01f, 1.41812950e-01f, -9.74709988e-02f, 2.55348906e-02f, 9.68707129e-02f,
  2.23106379e-03f, -9.05871484e-03f, -1.09927550e-01f, 5.68278916e-02f, -1.51639268e-01f, -1.21901952e-01f, -3.56667228e-02f, -1.51373520e-01f, -2.23417863e-01f, -1.62004963e-01f,
  4.60801721e-02f, 4.69471775e-02f, 1.23207718e-01f, -8.03502575e-02f, -3.92194912e-02f, -9.45903175e-03f, -4.58551869e-02f, -1.01262860e-01f, -3.40490863e-02f, -8.06383491e-02f,
  -7.56011009e-02f, 1.10692546e-01f, 6.41649663e-02f, 1.27682555e-03f, 1.11931027e-03f, -1.41052483e-03f, -4.62430976e-02f, -9.62585211e-02f, -7.26412907e-02f, -6.29719496e-02f,
  -4.33529280e-02f, 7.86930546e-02f, 1.29430518e-01f, -3.73959616e-02f, -1.17787551e-02f, -6.65614605e-02f, -5.31269461e-02f, -1.42610684e-01f, -5.62846996e-02f, 5.85615821e-02f,
  -6.66603372e-02f, 4.35639732e-02f, -2.21883152e-02f, -3.11224516e-02f, 1.43383294e-01f, -2.75827991e-03f, 1.51544958e-01f, 3.63180339e-02f, -3.43641639e-02f, -1.34501591e-01f,
  -7.58969635e-02f, -1.17865510e-01f, -9.43614505e-05f, 1.45840039e-02f, -3.40567492e-02f, -2.12753862e-01f, -6.23005591e-02f, 1.36874348e-01f, -1.02888614e-01f, 9.70531106e-02f,
  2.69079152e-02f, -1.93412349e-01f, -1.50260732e-01f, -1.49417087e-01f, -1.68788396e-02f, -1.27039149e-01f, -6.61658645e-02f, -1.90825835e-01f, -1.16316676e-01f, -4.20403600e-01f,
  3.66605848e-01f, -3.22829932e-01f, 3.76147836e-01f, 4.85259861e-01f, 4.58898306e-01f, 3.19040447e-01f, 3.41702282e-01f, 2.93937951e-01f, 2.55852073e-01f, 7.78128579e-02f,
  -1.12549670e-01f, -1.56030625e-01f, -2.46084601e-01f, -1.01390682e-01f, -1.01231806e-01f, 1.60662666e-01f, 1.67355806e-01f, 1.30501643e-01f, 2.65174627e-01f, 1.97295249e-01f,
  -8.82570893e-02f, 1.43367276e-01f, 7.90091828e-02f, 9.00117010e-02f, 4.10539396e-02f, -2.72336341e-02f, 1.07079767e-01f, 1.23866208e-01f, -6.57985955e-02f, -2.75774747e-02f,
  -1.08337574e-01f, -5.66551164e-02f, -1.24532841e-02f, -2.42542759e-01f, -1.00676246e-01f, -1.57016501e-01f, -1.45983351e-02f, -9.09271091e-02f, -1.38581321e-01f, -4.00104523e-02f,
  -1.05202638e-01f, -1.76292285e-01f, -8.15734491e-02f, 2.32125577e-02f, 4.48011309e-02f, -3.39220688e-02f, 2.93648671e-02f, 1.01338383e-02f, -3.37205711e-03f, -7.38969222e-02f,
  -1.58116341e-01f, 4.61365767e-02f, 1.59379214e-01f, 9.19253901e-02f, 1.74763575e-01f, 2.28684936e-02f, 2.08565462e-02f, -2.04829089e-02f, -5.86514361e-02f, 2.31182743e-02f,
  2.45881137e-02f, 9.81964543e-02f, 6.62415177e-02f, 4.91928197e-02f, -4.50994708e-02f, -2.30230205e-03f, 3.57620977e-02f, 8.61273929e-02f, 9.38152447e-02f, 7.78733268e-02f,
  -4.36408147e-02f, 1.07778832e-01f, 3.95944826e-02f, 1.08179756e-01f, 4.42911610e-02f, 4.62270761e-03f, 2.07752194e-02f, -7.26647526e-02f, -1.22720107e-01f, -7.33860657e-02f,
  2.14260444e-02f, 7.30389729e-02f, 5.10210991e-02f, 1.78034771e-02f, -5.14391921e-02f, 4.03709076e-02f, 1.18120447e-01f, -8.29686075e-02f, 4.05363292e-02f, 2.75179632e-02f,
  -1.44104198e-01f, 6.69553727e-02f, 4.81115468e-02f, -1.73806939e-02f, -1.65274739e-02f, -9.77976397e-02f, 1.42479032e-01f, -6.45034835e-02f, -1.57761469e-01f, -5.64407371e-03f,
  -6.02865107e-02f, -4.91634086e-02f, -1.88349746e-02f, 2.32550912e-02f, 1.69376910e-01f, -4.40480741e-04f, -1.53100103e-01f, 6.57276884e-02f, -9.26871449e-02f, -3.07001807e-02f,
  -1.30886314e-02f, 1.34468615e-01f, 1.28824979e-01f, 5.35816625e-02f, -9.38548967e-02f, 7.24582821e-02f, 9.28704999e-03f, 8.92513618e-02f, 6.83080107e-02f, -3.67085077e-02f,
  7.11304069e-01f, 2.31545985e-01f, 3.24804008e-01f, 2.47819960e-01f, -2.04681471e-01f, -2.57562935e-01f, -3.70331824e-01f, -8.05717334e-02f, 9.16360393e-02f, 1.40191779e-01f,
  1.13928847e-01f, 1.95435166e-01f, 1.90552384e-01f, 1.96194783e-01f, 1.73114598e-01f, 4.48687039e-02f, -4.81892601e-02f, 3.31160963e-01f, 2.16982126e-01f, 2.04470485e-01f,
  -1.83764342e-02f, 1.21908240e-01f, 1.50821611e-01f, 2.17446178e-01f, 2.01818738e-02f, 1.94061741e-01f, -5.00255376e-02f, -1.13205276e-02f, 4.65485938e-02f, 3.10956359e-01f,
  1.78464398e-01f, 1.71476632e-01f, 1.02783173e-01f, -4.29827301e-03f, -3.66938971e-02f, 8.67585018e-02f, 1.86793506e-02f, 2.27633361e-02f, 5.09478375e-02f, 3.98761742e-02f,
  7.94604719e-02f, -7.55471596e-03f, -1.88783005e-01f, -1.62227750e-01f, -1.80888623e-01f, -7.20008463e-03f, -3.81690171e-03f, 1.18023790e-01f, -3.94719616e-02f, 4.54527885e-03f,
  -7.30553493e-02f, -2.41381470e-02f, -3.97900306e-02f, -9.55998451e-02f, -6.21988140e-02f, 6.13768511e-02f, -4.71066423e-02f, 8.46712813e-02f, 9.06663015e-02f, 2.24514470e-01f,
  1.73123881e-01f, -5.08223698e-02f, 4.16380614e-02f, -6.66674599e-02f, -4.54411190e-03f, -6.36912836e-03f, 1.07093481e-02f, -7.59188086e-02f, -2.64737029e-02f, -1.00865357e-01f,
  1.99018698e-03f, 5.54403961e-02f, 4.41603623e-02f, -2.83660283e-05f, -2.55317171e-03f, -1.92671723e-03f, 1.05229571e-01f, 9.15302634e-02f, -1.82645693e-01f, -4.70046401e-02f,
  -4.71225716e-02f, -8.68199486e-03f, -1.18131503e-01f, -5.93032874e-02f, -7.69586191e-02f, 3.11343018e-02f, 2.57053338e-02f, -4.91915643e-03f, -1.30572289e-01f, -2.02346332e-02f,
  -3.17674279e-01f, -2.68549860e-01f, 1.63928047e-01f, 6.93845470e-03f, -3.80148850e-02f, -4.07852903e-02f, 7.13232756e-02f, 1.61584094e-02f, -3.10996249e-02f, -2.64180619e-02f,
  -6.39632493e-02f, -4.24773199e-03f, -1.10131666e-01f, -2.71932650e-02f, -5.53188771e-02f, -1.37210369e-01f, -1.64059121e-02f, 1.45300567e-01f, -2.49737836e-02f, 2.19738819e-02f,
  -9.10545364e-02f, 1.74543504e-02f, 4.32820022e-02f, -7.02059921e-03f, 8.89386982e-02f, 8.27808455e-02f, -1.12482332e-01f, 1.24705657e-02f, -2.99629271e-02f, -1.59592122e-01f,
  -2.12460071e-01f, 1.37999803e-01f, -2.44279057e-01f, 7.80010447e-02f, 2.24401653e-01f, -1.59326062e-01f, -1.12689964e-01f, -2.83654511e-01f, -4.93570454e-02f, 7.29052499e-02f,
  2.29772866e-01f, 8.82058963e-02f, -5.97683229e-02f, -2.84343008e-02f, -3.41329664e-01f, -1.27416864e-01f, -5.26751801e-02f, -2.20136911e-01f, -4.14177388e-01f, -1.85563117e-01f,
  1.23348884e-01f, 2.43274886e-02f, -2.68738955e-01f, -2.00853676e-01f, 2.60128289e-01f, 1.63798392e-01f, 1.11020692e-01f, 9.48295593e-02f, 1.95284888e-01f, 5.22564888e-01f,
  2.20692065e-02f, -1.72722310e-01f, 2.86720581e-02f, 6.22999249e-03f, 1.54037297e-01f, -1.29736550e-02f, -2.51928382e-02f, -1.80626422e-01f, 2.26789946e-03f, -5.54090850e-02f,
  1.21340312e-01f, -5.94528764e-02f, -6.82344213e-02f, 4.69226502e-02f, -8.77059847e-02f, -9.85850841e-02f, -6.95079416e-02f, -2.58508891e-01f, -2.95395941e-01f, -9.33216438e-02f,
  1.70446455e-01f, 1.29431337e-01f, -1.49400011e-01f, -1.48972139e-01f, -3.08012180e-02f, 8.06030631e-02f, 4.81000468e-02f, -4.47329916e-02f, -2.66136285e-02f, 9.24004614e-02f,
  -8.23804438e-02f, -4.88510961e-03f, 4.85154614e-02f, 8.27669799e-02f, 1.20540716e-01f, -1.09510161e-01f, 1.14144899e-01f, 2.80761048e-02f, -4.26644236e-02f, -5.41517958e-02f,
  1.66886318e-02f, 9.34060216e-02f, -1.02332652e-01f, -1.12123815e-02f, 1.43155709e-01f, 1.02963507e-01f, 1.77072868e-01f, -8.64854455e-03f, -6.25262409e-02f, 3.31134275e-02f,
  -4.86906944e-03f, 4.78959158e-02f, 9.04621184e-02f, 2.30756365e-02f, 1.50866091e-01f, 8.79837275e-02f, 1.68165147e-01f, 3.11228987e-02f, 2.66736615e-02f, 2.77490355e-02f,
  -9.36846361e-02f, 5.18979244e-02f, 1.33560181e-01f, 3.72770242e-02f, 8.48506987e-02f, 2.81223785e-02f, 2.12229580e-01f, 8.88359919e-02f, 1.83885932e-01f, 4.45301272e-02f,
  1.47359774e-01f, 2.86733992e-02f, -9.54629201e-03f, -6.00349754e-02f, 6.02398403e-02f, 1.39797807e-01f, -4.16105671e-04f, -4.61109579e-02f, 2.93971170e-02f, 8.64908546e-02f,
  6.23313561e-02f, -8.72993320e-02f, -1.63731977e-01f, -1.63406014e-01f, 8.70466679e-02f, 1.14906400e-01f, 4.50726561e-02f, -9.34781157e-04f, 5.13361767e-02f, -1.81783378e-01f,
  7.74046361e-01f, -2.10358128e-01f, -3.26481342e-01f, 2.20424179e-02f, -9.67480913e-02f, -1.80430457e-01f, -9.05191600e-02f, -6.93407431e-02f, 1.02712192e-01f, 3.38606624e-04f,
  1.18131237e-02f, 1.87491223e-01f, 2.60989457e-01f, 4.01550345e-02f, 7.23685250e-02f, -1.32703543e-01f, -2.01592982e-01f, 1.14749067e-01f, 2.27021798e-01f, 1.04436696e-01f,
  -4.33579367e-03f, -8.79968032e-02f, 3.84688750e-02f, -2.54587494e-02f, -2.68284321e-01f, 3.11981700e-02f, -2.03092799e-01f, -1.90538019e-01f, -1.72402918e-01f, -3.81627142e-01f,
  -1.82542607e-01f, -1.74033225e-01f, 1.27892345e-01f, 1.12048835e-01f, -8.93201903e-02f, 1.87311590e-01f, 4.46951576e-02f, 6.59728870e-02f, 1.12424009e-01f, -5.73941842e-02f,
  -6.11298047e-02f, 4.68705036e-02f, 9.91803706e-02f, -1.28442019e-01f, -1.25523567e-01f, -1.41575187e-01f, -1.03756681e-01f, -4.57281135e-02f, -1.57762936e-03f, -1.01661034e-01f,
  -1.53476179e-01f, 2.89641898e-02f, -5.52972816e-02f, 1.40949218e-02f, 6.05556704e-02f, 6.88209832e-02f, -7.10771307e-02f, -1.10480160e-01f, -5.84511869e-02f, -3.40634361e-02f,
  -1.20691784e-01f, -1.06688645e-02f, 2.88502835e-02f, 1.83263868e-01f, 1.75022945e-01f, 1.52530611e-01f, 7.24003091e-02f, 1.93471998e-01f, 6.15061447e-02f, -1.95098788e-01f,
  -1.63098320e-01f, -1.03704497e-01f, 7.54503757e-02f, 9.95264482e-03f, 7.68503221e-03f, -1.27594005e-02f, -3.11097875e-02f, -7.77292298e-03f, -5.87400049e-03f, 3.20101790e-02f,
  -7.27039129e-02f, 1.41665805e-02f, -7.34674335e-02f, -6.55644983e-02f, -4.32612114e-02f, -6.06234036e-02f, -1.54975832e-01f, 3.83799486e-02f, -1.64981127e-01f, -8.73374660e-03f,
  1.27341568e-01f, 3.64734344e-02f, 1.67088598e-01f, -5.11207767e-02f, 1.15547841e-03f, -7.28988647e-03f, 4.94858176e-02f, 7.89739415e-02f, -2.33597327e-02f, 3.34828533e-02f,
  -1.28073528e-01f, 1.36420086e-01f, -3.65402102e-02f, -1.52732119e-01f, 2.74898019e-02f, 8.50777626e-02f, 1.62525311e-01f, 2.37416357e-01f, -1.28944265e-02f, -2.54826903e-01f,
  -1.92048065e-02f, 2.60798812e-01f, 2.53900051e-01f, 2.01438114e-01f, 1.21504195e-01f, 1.77293941e-01f, -5.32099977e-03f, 1.60189439e-02f, 4.77189161e-02f, 1.08121648e-01f,
  6.53043330e-01f, -5.85527718e-01f, -8.99428688e-03f, 1.61927119e-01f, -1.87977199e-02f, -2.12826729e-01f, -4.43428427e-01f, -1.44481316e-01f, 9.95115638e-02f, -7.01339170e-02f,
  1.02197669e-01f, 3.39198619e-01f, 3.15802336e-01f, 1.79930046e-01f, 2.76902556e-01f, -6.78940788e-02f, -1.01598032e-01f, 3.96928549e-01f, 3.40649456e-01f, 1.64012849e-01f,
  -1.10188603e-01f, -1.87539160e-01f, 1.78175420e-01f, 8.59930813e-02f, -3.44058126e-01f, 1.17449924e-01f, -9.68229845e-02f, -1.82613432e-01f, -2.34738871e-01f, -1.97456747e-01f,
  -2.21504360e-01f, -4.15420458e-02f, 2.18194634e-01f, -2.52849348e-02f, -9.92389992e-02f, -2.04615109e-02f, -4.60061021e-02f, -5.53025082e-02f, -3.31346109e-03f, 4.70661223e-02f,
  -3.85283157e-02f, -2.11701971e-02f, 5.41970618e-02f, -1.69573888e-01f, -1.61427766e-01f, 1.90407550e-03f, -1.15102544e-01f, 7.86575824e-02f, 1.50709614e-01f, -3.82063421e-03f,
  2.83166803e-02f, 6.86086342e-03f, -1.09210998e-01f, -8.62747431e-02f, 1.70714334e-02f, 2.52444804e-01f, -1.11416213e-01f, -1.53703997e-02f, 1.07445933e-01f, -1.22293755e-01f,
  -7.62673020e-02f, 6.35464340e-02f, -3.87850218e-02f, -5.89624643e-02f, 1.12004345e-03f, 2.74065826e-02f, 1.44431395e-02f, -1.37160788e-03f, -6.01085387e-02f, -3.38705480e-02f,
  3.67253274e-02f, 4.88877259e-02f, 1.36403918e-01f, 1.44610992e-02f, 6.39453232e-02f, -2.33185533e-02f, -4.02913652e-02f, 2.72076298e-02f, 8.78943503e-02f, -3.37764435e-02f,
  -4.65980656e-02f, -5.16547374e-02f, 8.73328298e-02f, 3.46017927e-02f, -2.54477505e-02f, 1.77751020e-01f, 4.19030264e-02f, -6.63965940e-02f, -3.90582830e-02f, -5.77250086e-02f,
  -2.28318051e-01f, 2.80157417e-01f, 6.90569133e-02f, -7.06080347e-02f, 3.85054052e-02f, 2.63527203e-02f, 8.03470463e-02f, -8.61498564e-02f, -1.42630175e-01f, -9.25937667e-02f,
  -1.11734316e-01f, 5.66331903e-03f, -9.73305106e-02f, -1.02874860e-01f, -7.75925890e-02f, -4.05892543e-02f, -4.57914993e-02f, 1.36766270e-01f, 1.82142481e-02f, -1.09855227e-01f,
  -1.33573785e-01f, 2.00870279e-02f, 9.48823020e-02f, 1.35469679e-02f, -1.04157673e-02f, 2.48974696e-01f, -2.44500376e-02f, -5.49612045e-02f, 2.00255170e-01f, -1.37044951e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.61336155e-02f, 7.29099885e-02f, 1.74826026e-01f, -3.77672613e-02f, 2.51807608e-02f, -7.62607809e-03f, 7.29400152e-03f, 6.14464954e-02f, 2.46539339e-02f, -9.68294740e-02f,
  -1.90395638e-01f, -8.07327405e-02f, -3.45382490e-03f, 1.32821217e-01f, 3.60771008e-02f, 6.34260774e-02f, -1.64570615e-01f, -1.09071610e-02f, -3.67065705e-02f, -4.48247120e-02f,
  -9.96229649e-02f, 6.39899448e-02f, -9.29050706e-03f, 4.98089679e-02f, 9.81070176e-02f, 2.64487445e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.09778851e-01f, 1.92398075e-02f, 8.95602107e-02f, 1.97107732e-01f, 5.01022972e-02f, 3.30636017e-02f, -4.19646353e-02f, 2.67164499e-01f, 4.89349701e-02f, 8.60514343e-02f,
  -8.37275088e-02f, -4.60704640e-02f, -5.48462057e-03f, 1.24236085e-01f, 8.25454742e-02f, 9.66916233e-03f, -1.29377609e-02f, -1.28623262e-01f, 7.76682748e-03f, -1.65314093e-01f,
  -7.15669431e-03f, -4.24143597e-02f, 4.93737459e-02f, -1.57710314e-01f, -1.99946672e-01f, 2.45018136e-02f, 6.80182204e-02f, -4.46549095e-02f, 8.91888440e-02f, -4.65328358e-02f,
  -1.08010933e-01f, 6.90953583e-02f, -1.22902228e-03f, 1.80104539e-01f, 4.48309146e-02f, 1.91558838e-01f, -8.62381384e-02f, -3.80439423e-02f, 6.04654662e-02f, 1.07151054e-01f,
  -2.53816873e-01f, 2.20159084e-01f, -1.90017238e-01f, -3.55811007e-02f, 5.20543903e-02f, -1.79447159e-01f, 3.10055375e-01f, -1.66558340e-01f, -1.78775206e-01f, -8.18629265e-02f,
  -1.40683085e-01f, -1.08866140e-01f, 4.74055767e-01f, 3.56134251e-02f, -8.17176402e-02f, 3.42092454e-01f, -6.59938678e-02f, -3.27908583e-02f, 9.51700211e-02f, 1.26969472e-01f,
  1.96947396e-01f, -7.99615011e-02f, -4.37893681e-02f, 1.46791175e-01f, -2.37319365e-01f, 9.84634906e-02f, 2.56109070e-02f, -3.89672979e-03f, -1.25248984e-01f, 6.63031777e-03f,
  -1.13718845e-02f, -1.31839901e-01f, -1.08652055e-01f, 3.74564715e-02f, -1.88895121e-01f, -9.81386900e-02f, -2.54285391e-02f, 1.85503528e-01f, -8.89009908e-02f, 5.98821566e-02f,
  1.26600070e-02f, 1.05044998e-01f, -1.12760119e-01f, -1.97568759e-01f, -1.30776420e-01f, -3.42091024e-02f, 1.45779833e-01f, -6.38905987e-02f, -4.03187610e-02f, 6.54487014e-02f,
  -9.58171412e-02f, 1.32431276e-02f, -1.69169232e-01f, 1.16889626e-01f, -1.04942665e-01f, 1.61620937e-02f, -6.78072944e-02f, -5.18827699e-02f, -1.23170815e-01f, 4.50036041e-02f,
  -7.43070468e-02f, -1.23771518e-01f, 9.97837335e-02f, 1.65639326e-01f, 3.17216245e-03f, 4.90155518e-02f, 5.36273757e-04f, -1.11442074e-01f, -1.48047641e-01f, -1.80072680e-01f,
  1.73973784e-01f, 1.48683727e-01f, -1.01463653e-01f, -1.08786836e-01f, -2.73774099e-02f, -1.90954417e-01f, 2.76130766e-01f, -1.08889818e-01f, -1.32497817e-01f, 2.31360123e-01f,
  -9.51246638e-03f, 1.42238393e-01f, 5.88795654e-02f, -1.07558090e-02f, -6.41036630e-02f, 7.27057382e-02f, -4.46837135e-02f, -7.80483931e-02f, -4.60586026e-02f, 6.47336394e-02f,
  -1.43136859e-01f, 3.78721952e-02f, -1.11644745e-01f, 2.30417401e-02f, -4.47453856e-02f, -1.03456296e-01f, 4.02155593e-02f, 3.17970663e-02f, -6.87236711e-02f, -2.63326734e-01f,
  -6.50425553e-02f, -3.83886741e-03f, -1.91933438e-01f, -2.74681523e-02f, 8.40096548e-02f, 3.49169970e-02f, -5.49039952e-02f, -1.22038260e-01f, -9.84087493e-03f, -1.24488309e-01f,
  6.73826113e-02f, 1.04849420e-01f, -1.78573448e-02f, 7.46435523e-02f, 1.90370120e-02f, 1.65368970e-02f, -3.35015133e-02f, -3.08229346e-02f, -1.54810613e-02f, 1.03073288e-02f,
  -1.08117379e-01f, 1.56976935e-02f, -1.07151978e-01f, 1.81089103e-01f, -1.01440333e-01f, 2.48945947e-03f, 1.03754386e-01f, 2.15319619e-01f, -1.03153713e-01f, 1.45258576e-01f,
  3.38247359e-01f, -5.73791265e-02f, -1.64436206e-01f, 1.21462889e-01f, 1.81516334e-01f, 6.17689975e-02f, 9.73762125e-02f, -2.12164149e-02f, 2.30213732e-01f, -4.25091445e-01f,
  -6.70966953e-02f, -2.69670580e-02f, 1.26489982e-01f, 5.17284460e-02f, 5.77622950e-02f, 3.01910996e-01f, 1.89301759e-01f, -7.08247256e-03f, -6.38842359e-02f, 1.81854248e-01f,
  4.35386971e-02f, -1.46646991e-01f, -1.48898467e-01f, -5.72702810e-02f, -1.59460530e-01f, -1.67533681e-02f, -4.04014513e-02f, -2.61648763e-02f, -8.64608288e-02f, -1.85103655e-01f,
  -1.04771564e-02f, -2.87902579e-02f, 3.33642103e-02f, -1.63238756e-02f, -2.23914057e-01f, -3.14719826e-02f, 7.02343062e-02f, -1.19218469e-01f, -4.15548272e-02f, 4.22936752e-02f,
  3.77534926e-02f, -1.58716649e-01f, 3.39654349e-02f, 1.17299579e-01f, -5.16407937e-02f, 1.55236095e-01f, 1.86758135e-02f, -1.76347569e-01f, -7.08373711e-02f, 2.56226771e-02f,
  1.39412746e-01f, -1.28867328e-01f, 6.80662841e-02f, -1.82161301e-01f, -1.27128288e-01f, -5.97879738e-02f, 5.37450984e-02f, -1.07900292e-01f, -1.06820174e-01f, -1.80702079e-02f,
  -3.89907062e-02f, -6.58828439e-03f, 1.14236288e-01f, -1.93735182e-01f, 3.37042868e-01f, -2.62724608e-01f, 1.82158891e-02f, 2.70232111e-01f, -4.00094777e-01f, 1.14552975e-01f,
  1.85899138e-02f, 1.26540232e-02f, 1.09032668e-01f, -1.10885343e-02f, -1.86268613e-01f, 4.71104831e-02f, -1.57111868e-01f, -1.87923029e-01f, 5.30961938e-02f, 1.15293324e-01f,
  -7.96477031e-03f, 1.51807636e-01f, -2.05529600e-01f, 1.38882056e-01f, -1.91519782e-01f, -1.97968870e-01f, -1.07940227e-01f, -1.72194570e-01f, 7.98827857e-02f, -5.57720140e-02f,
  -3.39025399e-03f, 2.55179070e-02f, -1.21344402e-01f, -9.31260437e-02f, 3.19786393e-03f, -8.95812139e-02f, 5.69907352e-02f, -9.57283527e-02f, 1.16565786e-02f, -1.82558402e-01f,
  -1.51273116e-01f, -7.05261305e-02f, 3.56435515e-02f, -1.20867483e-01f, -2.07083137e-03f, 1.40655711e-01f, 3.77199538e-02f, 5.42147495e-02f, 6.01085275e-02f, -1.62953753e-02f,
  -2.88327839e-02f, 3.48552763e-02f, 6.02612682e-02f, -1.17486104e-01f, 1.08030677e-01f, -1.04684435e-01f, -7.71429995e-03f, 1.20578893e-01f, -5.41027728e-03f, -1.19960196e-01f,
  2.78173331e-02f, -2.50564213e-03f, 1.85845345e-02f, 1.30784631e-01f, -2.76672542e-01f, -9.45839286e-02f, -2.05487415e-01f, -1.59409568e-01f, -1.00504883e-01f, 8.47490355e-02f,
  7.13764876e-02f, -1.83703583e-02f, -9.85053182e-02f, -1.16618060e-01f, -8.22413638e-02f, 3.56207229e-02f, -3.42246860e-01f, -1.08005151e-01f, 2.95398640e-03f, 3.09180263e-02f,
  1.21321738e-01f, -2.09876642e-01f, 6.38614073e-02f, -2.40630925e-01f, -1.70788482e-01f, -4.55870107e-02f, 1.65404439e-01f, -8.93317908e-02f, 1.07733287e-01f, -5.97732324e-05f,
  1.83400720e-01f, -1.88090857e-02f, 1.76972643e-01f, 7.57219717e-02f, -6.73957821e-03f, -4.51304093e-02f, 9.88270789e-02f, 1.63665577e-03f, 1.06743641e-01f, -8.28491431e-03f,
  -3.57422642e-02f, 1.75532684e-01f, 8.73341709e-02f, -1.31444007e-01f, 1.21420674e-01f, -8.81295577e-02f, -2.95348801e-02f, 9.19967592e-02f, 1.62060037e-02f, 2.24296957e-01f,
  -8.86406377e-02f, 1.00050315e-01f, -1.91775665e-01f, -1.05742313e-01f, 6.12712577e-02f, 2.43707355e-02f, -3.99658196e-02f, 1.89237103e-01f, -1.28614958e-02f, 1.38593256e-01f,
  1.68361198e-02f, 1.75070837e-01f, 2.57228702e-01f, 3.97963151e-02f, -5.45102432e-02f, -1.63475543e-01f, 1.07432149e-01f, 1.81833848e-01f, -4.65607084e-02f, -1.15364883e-02f,
  1.68996170e-01f, -1.04825772e-01f, -2.37882465e-01f, 1.83924481e-01f, 2.10296288e-01f, -1.75925940e-01f, -1.25514776e-01f, -2.47708857e-01f, -1.57123193e-01f, 2.26076305e-01f,
  -2.83331692e-01f, 2.49807507e-01f, -1.54641587e-02f, -2.22138390e-01f, -6.57954300e-03f, -1.76965147e-01f, 4.55693007e-02f, -1.31834194e-01f, -1.94973812e-01f, 5.57421260e-02f,
  1.49963871e-01f, -1.11429825e-01f, 1.43709779e-02f, 3.29767503e-02f, 6.77338839e-02f, -5.21091744e-02f, -2.91472469e-02f, 1.88864674e-02f, -1.03960216e-01f, -3.82291526e-02f,
  -2.10451540e-02f, -8.73056874e-02f, -1.55798882e-01f, 3.49394567e-02f, 3.12167057e-03f, 5.04708737e-02f, -1.21416964e-01f, 1.15463838e-01f, 1.93950564e-01f, 1.98204234e-01f,
  7.70146549e-02f, -2.04462446e-02f, 1.42777622e-01f, 1.38481960e-01f, -3.79028991e-02f, 1.00922339e-01f, -1.44221902e-01f, 3.53323594e-02f, -3.88225578e-02f, -2.76417315e-01f,
  -2.77364910e-01f, 1.63309157e-01f, -5.40169775e-02f, 9.32144150e-02f, 2.04019458e-03f, 8.24015290e-02f, -6.44547269e-02f, 1.40727520e-01f, 8.52197632e-02f, -4.56992611e-02f,
  -2.58464605e-01f, -1.49772942e-01f, 1.87071919e-01f, -9.28625390e-02f, 8.07139948e-02f, 1.40043885e-01f, 2.89965928e-01f, -1.88962191e-01f, 3.53427157e-02f, 3.93698290e-02f,
  -1.80360246e-02f, 2.12292373e-02f, -8.26463848e-03f, 4.39683199e-02f, 3.48912179e-01f, 5.18900715e-02f, 6.67224750e-02f, -1.84602574e-01f, -1.41067460e-01f, 1.70400932e-01f,
  -1.42890811e-01f, 2.98446834e-01f, 2.72308677e-01f, -9.25354809e-02f, 4.95061167e-02f, 2.05855966e-01f, -1.62433490e-01f, -1.67617753e-01f, 7.35999867e-02f, 1.83777697e-02f,
  8.52703676e-02f, 5.05679846e-02f, 2.17570543e-01f, -8.54464918e-02f, 9.87161249e-02f, -1.57458074e-02f, 5.57720251e-02f, 6.81010410e-02f, 1.12121500e-01f, 1.12109669e-01f,
  1.61026698e-02f, 8.51975232e-02f, -1.65691152e-01f, 1.29201980e-02f, -1.40984803e-02f, 1.68251857e-01f, -2.46040802e-02f, -1.33076116e-01f, -1.22282185e-01f, 1.17017729e-02f,
  9.40522179e-02f, 8.97248369e-03f, 3.70093398e-02f, 5.92144951e-02f, 1.35977745e-01f, 7.75941834e-02f, -3.78958997e-03f, 7.52289593e-02f, 5.67047074e-02f, -5.51545136e-02f,
  3.91344614e-02f, -1.08877756e-01f, -3.56928222e-02f, 1.09925903e-01f, 1.58946700e-02f, -2.13116594e-02f, -1.26177236e-01f, -2.07001239e-01f, -1.57135084e-01f, -5.66748455e-02f,
  -1.15628958e-01f, 1.56142980e-01f, 1.00424454e-01f, 9.69900414e-02f, 3.85079086e-02f, -2.63017893e-01f, 1.48891762e-01f, 3.45270261e-02f, -2.59819955e-01f, 1.55716822e-01f,
  6.09100275e-02f, 2.47942880e-02f, -2.66058408e-02f, 3.88254523e-02f, -9.20748990e-03f, 1.50424123e-01f, -1.45309389e-01f, 2.58814156e-01f, 6.82646642e-03f, -1.96382832e-02f,
  1.36118546e-01f, 2.10662022e-01f, -1.94587529e-01f, -3.92988278e-03f, 1.95678860e-01f, -5.54449186e-02f, -8.28012917e-03f, 1.06108733e-01f, 2.46959720e-02f, -4.53740470e-02f,
  -1.47922069e-01f, -4.38691750e-02f, -6.98267147e-02f, 1.19855441e-01f, 7.98374489e-02f, 5.86594315e-03f, -4.95631574e-03f, 1.11158170e-01f, -3.22948880e-02f, -2.04577476e-01f,
  -1.95577908e-02f, -9.79080200e-02f, -1.90720260e-01f, -2.03825727e-01f, -1.84488855e-02f, 2.13803694e-01f, 1.11996308e-01f, 2.08101273e-01f, 8.75658691e-02f, -1.56609192e-01f,
  -1.76764131e-01f, 5.71752563e-02f, 2.24022761e-01f, 1.21149987e-01f, -1.01491682e-01f, 1.40839489e-02f, -1.06249731e-02f, 4.12487984e-02f, 4.53303978e-02f, 3.35842483e-02f,
  -3.59218448e-01f, 4.44911271e-02f, -2.24213526e-01f, -5.41936532e-02f, -2.52906621e-01f, -1.16318554e-01f, 1.71088412e-01f, 6.65199524e-03f, -1.24797538e-01f, -1.64147228e-01f,
  1.37931198e-01f, 1.18673347e-01f, -2.42891699e-01f, -1.28014147e-01f, -2.08058842e-02f, 3.42841819e-02f, -1.12759449e-01f, 8.91517699e-02f, -2.32420370e-01f, -1.70418411e-01f,
  -4.36492622e-01f, -5.86405434e-02f, 8.19601417e-02f, 2.91889638e-01f, 7.54894465e-02f, 1.02558710e-01f, -1.39120281e-01f, -5.92705756e-02f, -8.82237742e-04f, -3.67356613e-02f,
  6.04732148e-02f, 1.01522923e-01f, -1.09590158e-01f, -1.42585337e-01f, -1.72781572e-02f, -3.68935764e-02f, 2.98234466e-02f, 5.44218794e-02f, 1.15861684e-01f, 9.70305875e-02f,
  -5.85793965e-02f, -1.28037706e-01f, 2.98999026e-02f, -2.32310355e-01f, -1.28207043e-01f, 2.88760625e-02f, 1.11088872e-01f, 1.83866099e-01f, 5.01296222e-02f, -1.07072987e-01f,
  -1.20489717e-01f, 2.60104746e-01f, 1.82866201e-01f, -1.07098319e-01f, 1.37398452e-01f, -1.24074943e-01f, -1.26211308e-02f, 2.54056361e-02f, -7.33545423e-02f, -5.41971028e-02f,
  2.62324605e-02f, 6.39801249e-02f, 6.24842644e-02f, 1.02357768e-01f, -2.67582595e-01f, -2.34738901e-01f, 3.38329732e-01f, -1.04018554e-01f, -9.97212678e-02f, -2.11350005e-02f,
  -3.00373614e-01f, -3.26471835e-01f, -1.87704340e-01f, 1.13446200e-02f, -7.89064467e-02f, -1.41811147e-01f, -9.24430639e-02f, -1.16499841e-01f, -6.36872277e-02f, 1.34812906e-01f,
  -9.84408706e-02f, -2.54158199e-01f, 2.20630810e-01f, -2.60398895e-01f, -1.38285115e-01f, 2.66771376e-01f, 4.83566076e-02f, -2.13004753e-01f, -2.27000844e-02f, -1.37164548e-01f,
  -4.17250767e-02f, -5.95927946e-02f, -1.56949669e-01f, 5.79604171e-02f, 3.71819213e-02f, 8.14345852e-02f, 4.84819487e-02f, 1.23262607e-01f, -3.94596383e-02f, -4.42919172e-02f,
  6.85971826e-02f, -3.14743668e-02f, -1.49376998e-02f, -5.20543158e-02f, -6.56532049e-02f, 1.83412228e-02f, -5.80878071e-02f, 1.14092685e-01f, 1.79323956e-01f, -2.46081486e-01f,
  -2.00873882e-01f, -1.65969506e-01f, -3.86145487e-02f, 3.91449966e-02f, -1.20531939e-01f, -7.46962205e-02f, 9.44510754e-03f, -1.83278263e-01f, -1.35783941e-01f, -1.79787621e-01f,
  -9.63034332e-02f, 8.35630968e-02f, -4.40161163e-03f, 7.84520060e-02f, -3.35954279e-02f, 9.28648114e-02f, 1.36755243e-01f, 1.70189999e-02f, -1.23651475e-01f, 2.18256608e-01f,
  -9.42603946e-02f, 1.67939067e-01f, 2.33689304e-02f, -7.50830770e-02f, 1.78029716e-01f, -1.30950034e-01f, 1.06485836e-01f, 8.34461302e-02f, -1.30072013e-01f, 1.73901483e-01f,
  2.83851534e-01f, 1.64776981e-01f, -1.78011701e-01f, 1.27786890e-01f, -7.05216452e-02f, -1.63662173e-02f, -1.76078081e-01f, -1.36254495e-02f, -1.01978637e-01f, -1.84636533e-01f,
  -2.61243433e-01f, -9.11694095e-02f, 3.48997802e-01f, 5.03852852e-02f, -1.97940126e-01f, -1.04608066e-01f, -7.75126666e-02f, 7.39890635e-02f, -1.33851290e-01f, -5.37385195e-02f,
  1.01390250e-01f, 9.44027007e-02f, -9.85664427e-02f, 1.85714126e-01f, -6.02451302e-02f, 8.04767683e-02f, 1.03504382e-01f, 1.06105730e-01f, 1.21225983e-01f, -7.49681965e-02f,
  7.90810660e-02f, -1.74359277e-01f, -3.49023826e-02f, -2.57250387e-03f, 9.37581435e-02f, 2.25766357e-02f, 1.96916789e-01f, 3.97361554e-02f, -2.25901321e-01f, 3.05831999e-01f,
  8.17569122e-02f, 5.27545661e-02f, 7.68845726e-04f, -1.94781959e-01f, 4.70912308e-02f, -9.46366042e-02f, 2.96993530e-03f, 1.40329167e-01f, 1.21709324e-01f, 1.25837892e-01f,
  -7.81062543e-02f, -1.70816347e-01f, 4.07810397e-02f, -4.96089570e-02f, 1.35980532e-01f, -1.41156241e-02f, -1.91600844e-01f, 4.04108018e-02f, -1.24053895e-01f, -1.13333263e-01f,
  5.31113483e-02f, -6.16813600e-02f, -1.21158890e-01f, 2.42997287e-03f, -3.29829484e-01f, 1.45650038e-03f, 7.44668990e-02f, 2.69895285e-01f, 2.73212940e-01f, 3.21074165e-02f,
  -1.30398953e-02f, -2.57924825e-01f, 1.38947010e-01f, 1.52033925e-01f, 1.81194291e-01f, -8.60524997e-02f, -9.18733254e-02f, -8.89823064e-02f, 2.49755174e-01f, 5.77688590e-02f,
  5.95395602e-02f, 9.17137116e-02f, -7.58154467e-02f, 5.20657003e-02f, -3.87358703e-02f, 1.49223089e-01f, -1.00082502e-01f, 1.57794535e-01f, -1.80520061e-02f, -1.96630701e-01f,
  7.13335872e-02f, -1.19108707e-01f, 1.51157647e-01f, -1.97765436e-02f, 5.19129960e-03f, 7.32524097e-02f, 4.04647142e-02f, -1.80755645e-01f, -6.65461272e-02f, 2.09351450e-01f,
  3.93364169e-02f, -3.70981634e-01f, 1.66092277e-01f, -1.30438462e-01f, 2.28961534e-03f, -8.43065232e-02f, 1.36624530e-01f, 2.86341608e-01f, 5.61537407e-02f, 6.09686524e-02f,
  1.82218373e-01f, -1.37633488e-01f, 2.57699471e-02f, 1.56536847e-01f, 5.44181652e-02f, 1.73363745e-01f, -4.63407785e-02f, 1.59716725e-01f, 5.44108748e-02f, 2.32846722e-01f,
  -4.14425462e-01f, 1.34470627e-01f, 1.40716642e-01f, -3.05316120e-01f, -1.13751523e-01f, -5.05880527e-02f, -1.05481960e-01f, 7.26375505e-02f, -1.82500228e-01f, 3.39128405e-01f,
  -9.93104354e-02f, 3.82651463e-02f, -2.96468846e-02f, -4.31181155e-02f, 2.29086012e-01f, -1.47658944e-01f, -1.30380571e-01f, 2.42253169e-01f, 8.22607651e-02f, -1.99709669e-01f,
  2.40765765e-01f, 2.14517936e-01f, -1.31062657e-01f, -3.22941914e-02f, -5.05367480e-02f, 3.74109820e-02f, -4.57066298e-02f, 8.75767246e-02f, 5.32740494e-04f, -1.19815372e-01f,
  -2.40497682e-02f, -3.44796013e-03f, 4.01927270e-02f, 2.22775340e-01f, 4.52286825e-02f, 1.10761732e-01f, -5.92625588e-02f, -9.48165208e-02f, 3.48922424e-02f, -4.97178435e-02f,
  1.06135450e-01f, -5.77115864e-02f, -5.73279820e-02f, -1.02216015e-02f, 1.21964544e-01f, 1.76694691e-01f, 2.60427386e-01f, 2.09290802e-01f, 2.31151044e-01f, -6.36139363e-02f,
  1.01211242e-01f, -5.92835015e-03f, 7.56502077e-02f, 4.84852493e-02f, -1.51579887e-01f, -2.69383229e-02f, 8.25784430e-02f, -4.97738458e-02f, 1.59319818e-01f, 1.32154360e-01f,
  -2.14214653e-01f, 5.52018210e-02f, 2.22218633e-01f, -1.37040764e-01f, 2.30444998e-01f, -2.35740491e-03f, 1.40648112e-01f, -1.43578976e-01f, -1.76553890e-01f, 4.21719737e-02f,
  1.67362150e-02f, 1.00109629e-01f, 3.30345154e-01f, -1.56307835e-02f, -1.87964022e-01f, -3.58527899e-02f, 1.71342760e-01f, -2.70310163e-01f, 1.51116297e-01f, -3.10856283e-01f,
  -1.93768024e-01f, 5.85224032e-02f, -7.16927573e-02f, -2.11281255e-01f, 2.48982781e-03f, -5.05764112e-02f, 6.94679543e-02f, 5.88219045e-05f, 1.02322280e-01f, 5.79521172e-02f,
  1.42974406e-01f, 6.86970055e-02f, 2.29902595e-01f, 8.45223889e-02f, 1.60445590e-02f, 1.09127879e-01f, -1.55697605e-02f, 1.19132601e-01f, -1.72637075e-01f, 4.22075465e-02f,
  -1.10069156e-01f, 1.97266981e-01f, 1.44873932e-01f, 8.47842619e-02f, 1.02502681e-01f, -4.70914058e-02f, 6.51978478e-02f, -1.35688633e-01f, 2.12171540e-01f, -7.17225969e-02f,
  -1.26787543e-01f, 1.47247732e-01f, 1.56743571e-01f, 1.03272140e-01f, -1.04215957e-01f, 2.98085988e-01f, 9.52540711e-02f, -1.00804709e-01f, -8.24651346e-02f, -9.31592137e-02f,
  -1.40334263e-01f, 2.18913749e-01f, -1.71254590e-01f, 8.19864571e-02f, 3.08177061e-02f, -2.75635153e-01f, -8.64361823e-02f, -1.31932974e-01f, 1.27324790e-01f, -6.87207431e-02f,
  2.93642990e-02f, 2.31880516e-01f, 1.51246950e-01f, -4.83711716e-03f, 9.10753310e-02f, 9.72710028e-02f, -1.82307914e-01f, -2.45645896e-01f, -3.71957081e-03f, -6.50216788e-02f,
  8.85784253e-02f, 9.76911485e-02f, 1.58504564e-02f, 2.47333854e-01f, -6.30312487e-02f, -1.58375036e-02f, 2.08472654e-01f, 2.16468096e-01f, -4.87019941e-02f, 1.02104075e-01f,
  2.81871296e-02f, -5.23021370e-02f, -2.18453050e-01f, 2.04606000e-02f, -2.20463142e-01f, -2.36435439e-02f, -1.67372257e-01f, -3.95484678e-02f, -1.50508001e-01f, -8.65268707e-02f,
  -1.58770666e-01f, -2.64686137e-01f, -1.73163079e-02f, -1.35923937e-01f, 1.96436286e-01f, -1.77115917e-01f, 3.97017039e-02f, -5.17113283e-02f, 9.82489660e-02f, 1.00833043e-01f,
  -2.57957838e-02f, -2.67447922e-02f, -1.41777188e-01f, -5.91069162e-02f, 7.00996518e-02f, -8.65680054e-02f, 5.62649071e-02f, -1.68555919e-02f, -3.93367410e-02f, 7.31791481e-02f,
  2.15764299e-01f, 7.85203725e-02f, 6.82007298e-02f, 1.77785635e-01f, -3.28555070e-02f, -9.59017053e-02f, 8.76276940e-02f, -1.08870521e-01f, -6.16698079e-02f, 4.72782291e-02f,
  -1.12870626e-01f, 3.26741904e-01f, -1.72237739e-01f, -6.29907325e-02f, -7.99978152e-03f, -4.03095573e-01f, 1.34746060e-01f, 3.35172147e-01f, 1.14469409e-01f, 2.21972823e-01f,
  1.57424778e-01f, 1.50749654e-01f, -1.73311662e-02f, -1.65324867e-01f, -5.04383072e-02f, -2.89060045e-02f, 1.65598337e-02f, -8.10355470e-02f, -1.11462288e-01f, -1.48392394e-01f,
  -2.02095583e-01f, -2.17481285e-01f, 3.77223827e-02f, 4.54308055e-02f, 2.32310761e-02f, -4.68330942e-02f, 1.14898726e-01f, 1.23914294e-01f, 1.55174676e-02f, 2.01259777e-02f,
  -1.01850443e-01f, 1.49103269e-01f, -9.91321877e-02f, 8.63273367e-02f, 4.05485183e-02f, -5.26558459e-02f, 5.73652573e-02f, 1.50603456e-02f, 1.65316276e-02f, 5.97441709e-03f,
  1.54780690e-02f, 3.81377153e-02f, -9.20277014e-02f, 1.27894515e-02f, 5.11302575e-02f, -6.79976046e-02f, -1.64064988e-01f, -1.21454544e-01f, 1.27650559e-01f, -1.02948956e-01f,
  5.67563809e-02f, -2.10556611e-01f, 2.71028802e-02f, -1.74588338e-01f, -3.82879972e-02f, 9.16571319e-02f, 9.65129808e-02f, 1.31889982e-02f, 8.39267820e-02f, 1.22912616e-01f,
  7.80162290e-02f, -4.77251858e-02f, 1.13483943e-01f, 1.82524011e-01f, -5.26408590e-02f, -2.94347350e-02f, -2.45337248e-01f, -3.94562036e-02f, -2.24804744e-01f, -3.20692450e-01f,
  1.52532443e-01f, 4.67179380e-02f, -5.45951165e-02f, -3.97310518e-02f, 1.75429195e-01f, -1.04647912e-02f, -1.27583414e-01f, 2.88645197e-02f, 1.26723498e-01f, 1.64725617e-01f,
  3.42385732e-02f, -9.42931995e-02f, 1.29231155e-01f, -5.45592271e-02f, -1.07414864e-01f, -2.69272417e-01f, 5.50208203e-02f, 6.49018027e-03f, -8.66806135e-02f, -7.82511979e-02f,
  -1.33839119e-02f, 6.32479489e-02f, 6.51700571e-02f, -6.75111040e-02f, 1.08077787e-02f, -1.17312625e-01f, 6.48858026e-02f, 2.78361887e-02f, 9.21980292e-02f, 9.72685441e-02f,
  2.24217176e-01f, -4.62734737e-02f, 2.65866704e-02f, 1.32098168e-01f, -5.39256297e-02f, -6.71483204e-02f, -4.20235805e-02f, 1.59454092e-01f, 6.35956377e-02f, 9.91577804e-02f,
  2.63291206e-02f, -3.15806903e-02f, 1.32431820e-01f, 4.76633944e-02f, 1.53320609e-04f, -1.47631198e-01f, 8.14533457e-02f, -1.54502094e-01f, -9.49293971e-02f, 7.99733922e-02f,
  8.67618900e-03f, 3.63149709e-04f, 2.20263842e-02f, -1.64626971e-01f, 5.90497907e-03f, 6.66709803e-03f, -1.63078025e-01f, 5.88291734e-02f, 1.14711098e-01f, 2.78069377e-02f,
  -7.61918724e-02f, 1.56252412e-03f, 8.74187276e-02f, -1.05682380e-01f, -2.59752244e-01f, 5.47176693e-03f, -1.27584606e-01f, 1.09709054e-01f, -2.69480199e-02f, 6.40224963e-02f,
  -3.37437391e-02f, -1.92950887e-03f, 1.74789280e-01f, -1.54325098e-01f, 8.61005336e-02f, -3.34135145e-01f, -5.35796173e-02f, 1.34025678e-01f, 3.10064442e-02f, -2.51422882e-01f,
  -4.04398292e-02f, -3.51706371e-02f, -2.08838344e-01f, 1.00042984e-01f, -1.15014941e-01f, -6.25243559e-02f, 1.42604873e-01f, -8.10073167e-02f, -2.36968901e-02f, -5.12630418e-02f,
  1.02590203e-01f, 7.22354874e-02f, 3.70789655e-02f, 1.05059862e-01f, -5.37210843e-03f, -3.57004628e-02f, 4.38071899e-02f, 7.98628330e-02f, -9.00107846e-02f, -8.72577280e-02f,
  2.49602310e-02f, -1.43249512e-01f, -6.53847679e-02f, -1.18333839e-01f, 1.47385001e-01f, 2.22503290e-01f, -2.69622773e-01f, 1.60878971e-01f, -1.09208830e-01f, -4.95705847e-03f,
  2.23823804e-02f, -1.91103891e-01f, 1.47910625e-01f, -6.35423213e-02f, -3.25624257e-01f, 1.56234233e-02f, -4.28663902e-02f, -1.34838685e-01f, -6.64871335e-02f, -7.44937137e-02f,
  1.42273024e-01f, -1.36648625e-01f, 1.11811481e-01f, -1.17147878e-01f, 8.56107399e-02f, -7.52392085e-03f, -3.36386189e-02f, 1.66617751e-01f, -4.51329313e-02f, 2.07140326e-01f,
  -5.38051836e-02f, 1.59170348e-02f, 1.31698310e-01f, -1.23708636e-01f, 1.10426247e-01f, -1.04130290e-01f, 1.04009330e-01f, 1.50026053e-01f, -1.12175107e-01f, 1.95894018e-01f,
  1.03485025e-01f, -1.63282290e-01f, 1.03293903e-01f, 1.66244864e-01f, -1.51580311e-02f, -1.32224530e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.84873119e-01f, -4.63278443e-02f, -4.81824093e-02f, 4.48051607e-03f, 1.86291197e-03f, -3.38844582e-02f, 1.84199199e-01f, 9.58832353e-02f, 1.71246931e-01f, -1.78589240e-01f,
  1.16204754e-01f, 4.05968307e-03f, 5.58977164e-02f, -1.66414887e-01f, -2.45955680e-02f, 2.71063689e-02f, 8.27787966e-02f, 5.70404716e-02f, 7.33216926e-02f, -1.96821392e-02f,
  -1.64992847e-02f, -2.26026684e-01f, 7.54559338e-02f, -7.80829936e-02f, -3.93509269e-02f, 8.98534134e-02f, -1.26944155e-01f, -1.21782050e-01f, -1.97528824e-01f, 4.23432812e-02f,
  1.08909644e-01f, -4.76621352e-02f, -1.68268140e-02f, 1.47970887e-02f, 4.06918203e-04f, 2.29139859e-03f, 1.10253118e-01f, -3.48790996e-02f, 1.43593624e-01f, -1.02846488e-01f,
  -3.65737677e-01f, 6.42049536e-02f, -8.89252499e-03f, 3.81082594e-02f, 4.96797822e-02f, 1.90378800e-01f, 1.27561718e-01f, 1.71099395e-01f, -2.68761575e-01f, 1.47443205e-01f,
  -1.27488106e-01f, -1.93922147e-02f, 3.12185045e-02f, 5.54836690e-02f, 1.62232473e-01f, 2.71975428e-01f, -1.89515501e-02f, 1.50604844e-01f, 1.16623849e-01f, -1.49198681e-01f,
  5.59502766e-02f, 2.91212171e-01f, -4.58860695e-02f, 2.14863978e-02f, 6.28324971e-02f, 1.73028588e-01f, 2.47279793e-01f, 7.26841316e-02f, 2.79828995e-01f, 4.97482829e-02f,
  1.42515991e-02f, 1.27625942e-01f, -6.10616384e-03f, 1.33219346e-01f, -2.95134559e-02f, 1.53282166e-01f, 1.38560385e-02f, 2.84149740e-02f, 1.11696646e-01f, 1.00674845e-01f,
  1.35789484e-01f, 6.33544102e-02f, 1.47760674e-01f, 3.53009373e-01f, 1.25380248e-01f, 2.80378133e-01f, 1.36570111e-01f, -1.76635504e-01f, -9.47244018e-02f, -2.26998895e-01f,
  3.27289775e-02f, 3.84638578e-01f, 2.00904340e-01f, 5.72100937e-01f, 2.49421552e-01f, -1.89606756e-01f, 8.00464302e-02f, -1.67960286e-01f, 1.13679007e-01f, -2.57801294e-01f,
  -9.40146968e-02f, 3.13582897e-01f, 1.71031952e-02f, -5.07686436e-01f, 1.85959667e-01f, 2.10982978e-01f, 9.63622481e-02f, -3.19802493e-01f, -6.03372827e-02f, 1.61615863e-01f,
  2.07863674e-02f, -2.56952047e-01f, 2.58091301e-01f, -3.46502095e-01f, 5.54788150e-02f, -9.28624645e-02f, 2.30588272e-01f, -1.78690568e-01f, -2.81877279e-01f, -4.66929674e-02f,
  -3.00369084e-01f, 2.15541855e-01f, -3.05790067e-01f, -9.15167630e-02f, -4.16713618e-02f, -7.10301474e-02f, -1.27277404e-01f, 2.11808339e-01f, -2.26348136e-02f, -4.37259525e-02f,
  1.26918644e-01f, 1.70363888e-01f, 3.97311114e-02f, -9.94608179e-02f, 1.49450064e-01f, 9.65930596e-02f, -4.29447405e-02f, 1.20829733e-03f, 7.40974024e-02f, 1.34771928e-01f,
  1.61876664e-01f, 1.02948342e-02f, 6.20223247e-02f, 1.79262087e-03f, 1.78057760e-01f, 4.01061252e-02f, 1.25964910e-01f, 3.29280309e-02f, 5.78400120e-02f, 1.34948954e-01f,
  1.10811725e-01f, 1.77597553e-01f, 1.34008288e-01f, 1.20800160e-01f, -6.93375170e-02f, -1.14630349e-01f, 2.57703178e-02f, -1.45645112e-01f, 3.59972864e-02f, -2.90156119e-02f,
  -1.26095757e-01f, -8.95173848e-02f, 1.29730999e-01f, 2.00179741e-02f, 1.12849288e-01f, -5.80253452e-02f, -1.37179017e-01f, 4.74988483e-02f, 5.13412952e-01f, -7.75903761e-02f,
  5.36416732e-02f, 6.40101656e-02f, -8.77904743e-02f, -1.47133008e-01f, -8.26481879e-02f, 3.64836514e-01f, 7.78321475e-02f, -8.60800818e-02f, 1.19045384e-01f, 2.27155983e-01f,
  -4.05221224e-01f, 2.34535769e-01f, -8.00485909e-02f, -3.11876740e-02f, 2.15616390e-01f, -1.78102061e-01f, 9.64815468e-02f, 2.93419152e-01f, -4.43941057e-02f, 1.86607763e-01f,
  -8.14205483e-02f, -1.42341763e-01f, 1.08113170e-01f, 1.45673538e-02f, 2.75192335e-02f, 1.53762892e-01f, 6.04305416e-02f, 2.28045046e-01f, 3.76159288e-02f, 2.11248785e-01f,
  -5.32247014e-02f, 3.83838266e-02f, 1.14487708e-01f, -4.97679263e-02f, -4.16590720e-02f, -8.29369798e-02f, -6.81194216e-02f, 2.57665049e-02f, 6.93888292e-02f, 4.03050035e-02f,
  -3.60034145e-02f, 1.00845717e-01f, -9.18186530e-02f, -1.98288769e-01f, -5.56811243e-02f, -2.39402041e-01f, 6.81101084e-02f, -7.36860335e-02f, -3.47692333e-02f, -3.95419523e-02f,
  -2.03158632e-01f, -8.34827274e-02f, 1.76008679e-02f, 8.65574926e-02f, -7.46978074e-02f, 1.73923358e-01f, 5.66272140e-02f, -3.14321928e-02f, 5.83017282e-02f, -8.10539052e-02f,
  1.50855735e-01f, 2.28704065e-01f, -2.85412729e-01f, 1.16331004e-01f, -2.02400267e-01f, -3.80946174e-02f, 3.57118845e-02f, -1.20519780e-01f, 2.63179719e-01f, -1.90553553e-02f,
  -9.67679843e-02f, 1.14934817e-01f, 1.02051921e-01f, 3.24387266e-03f, 9.90714040e-03f, -1.63202763e-01f, -1.22213989e-01f, 1.28380939e-01f, -1.66336671e-01f, -2.32328642e-02f,
  -1.60091091e-02f, -1.15764342e-01f, 2.01432072e-02f, -2.26444796e-01f, 3.17706093e-02f, 3.16572011e-01f, -8.40839967e-02f, 5.13309501e-02f, 1.15643598e-01f, 6.19318262e-02f,
  1.71204165e-01f, 1.28806248e-01f, 9.08456966e-02f, 1.63554788e-01f, 1.83743164e-01f, 6.01253286e-02f, 2.33035535e-01f, 1.70133248e-01f, 1.56582490e-01f, -4.52342350e-03f,
  1.44204825e-01f, -7.75616318e-02f, 1.12192735e-01f, 3.43489368e-03f, 2.07412615e-01f, 1.14341542e-01f, 6.29933327e-02f, 2.91052759e-01f, 7.96270147e-02f, -8.54084790e-02f,
  1.75931916e-01f, 1.29975215e-01f, 1.40827358e-01f, -2.91594695e-02f, 9.59282145e-02f, -1.43776476e-01f, -1.20933264e-01f, 8.29145089e-02f, -3.22137326e-02f, 1.31984288e-02f,
  1.56051023e-02f, 4.89165559e-02f, 6.72823712e-02f, 9.78508368e-02f, -1.32786542e-01f, 2.77247392e-02f, 2.54948556e-01f, -2.14995757e-01f, 1.62323117e-01f, -1.58207327e-01f,
  -7.16703460e-02f, 6.79600984e-03f, -2.22455218e-01f, -1.17819212e-01f, 5.87187782e-02f, -4.08245344e-03f, 1.96311221e-01f, 2.71671802e-01f, -1.61968708e-01f, 1.94693744e-01f,
  1.33115232e-01f, -1.39161006e-01f, 1.56284556e-01f, -1.43901736e-01f, -1.16099887e-01f, 1.26229197e-01f, -3.39840353e-01f, -2.56111007e-02f, -1.02177508e-01f, -1.76795334e-01f,
  1.83352143e-01f, -1.64016839e-02f, 1.38625100e-01f, 1.29578397e-01f, -5.24196066e-02f, 6.66951910e-02f, 1.15752116e-01f, 9.23960581e-02f, -2.24387392e-01f, -4.79126275e-02f,
  -1.48724262e-02f, -1.60417914e-01f, 1.08503126e-01f, 6.93816245e-02f, 8.95495266e-02f, -4.13388722e-02f, 1.00319780e-01f, 4.58039418e-02f, 4.66471165e-03f, -9.64005888e-02f,
  1.01864845e-01f, -1.15505092e-01f, -1.42659768e-01f, -4.13036607e-02f, 4.85973135e-02f, -2.18621586e-02f, 1.05994262e-01f, -9.30498019e-02f, 6.64569344e-03f, 1.11025192e-01f,
  2.28717536e-01f, 9.51881781e-02f, -2.83130705e-02f, -5.85682467e-02f, -6.64442107e-02f, -1.32132247e-01f, 9.87876877e-02f, 9.03679132e-02f, -8.36077780e-02f, 1.94691122e-01f,
  -2.41669193e-01f, 1.36113927e-01f, -1.49641901e-01f, -1.80839732e-01f, 2.86428303e-01f, -1.90071076e-01f, 1.29529238e-01f, -1.11954316e-01f, -5.91738783e-02f, 1.20913230e-01f,
  -1.05322458e-01f, 1.17013671e-01f, 6.15862757e-02f, -1.56378925e-01f, -3.21640253e-01f, 1.73711404e-02f, -2.93477923e-01f, 3.48095521e-02f, -6.83347955e-02f, -1.15411676e-01f,
  2.30467215e-01f, 7.73453340e-02f, -1.06866084e-01f, 5.22420853e-02f, 1.07477374e-01f, 1.45692080e-01f, 9.68085229e-02f, 1.05316378e-01f, 8.54259655e-02f, 1.27855986e-01f,
  5.58095351e-02f, 2.31129769e-02f, -4.42328304e-03f, 2.99704205e-02f, 9.41531882e-02f, -1.53321669e-01f, -1.90679096e-02f, -3.14285271e-02f, 4.39276993e-02f, 1.78975284e-01f,
  -2.88495072e-03f, 6.36662170e-02f, -9.93255898e-02f, -1.90755680e-01f, 1.09080048e-02f, -1.64827392e-01f, 2.60355324e-02f, -1.89933963e-02f, -4.63086180e-02f, -5.93758635e-02f,
  -9.45908204e-02f, -2.72661060e-01f, -3.68349180e-02f, 2.46055946e-02f, -1.97469398e-01f, 1.06268190e-01f, -5.40312454e-02f, 4.07122336e-02f, -1.53440516e-02f, 7.42321908e-02f,
  7.24389106e-02f, -1.11367516e-01f, 1.59769803e-01f, 1.97111040e-01f, -7.88307488e-02f, 8.31872001e-02f, -1.78620622e-01f, 2.39520133e-01f, -1.45912230e-01f, -1.79021493e-01f,
  2.63098210e-01f, 1.88480675e-01f, 1.31684870e-01f, -8.29258412e-02f, 2.99601182e-02f, -1.57885812e-02f, -7.04968348e-02f, -8.36907327e-02f, -1.65793002e-01f, 1.36320159e-01f,
  1.81605980e-01f, 1.33919464e-02f, 1.81936979e-01f, 1.29785404e-01f, -2.02511121e-02f, -2.15343237e-01f, 2.87370831e-01f, 2.61647671e-01f, 1.03516094e-01f, -4.49001528e-02f,
  1.33537591e-01f, 2.58329157e-02f, 1.01704113e-01f, 6.55513629e-02f, 7.76114583e-04f, 8.44147429e-02f, 1.79157183e-01f, -1.38316695e-02f, 2.35994458e-01f, 1.19933799e-01f,
  1.70965847e-02f, 1.11334987e-01f, -7.35504404e-02f, 1.31178955e-02f, 1.06283747e-01f, -7.87633751e-03f, 4.13628817e-02f, -1.19596329e-02f, 1.68708518e-01f, -6.33263811e-02f,
  1.19659796e-01f, 1.07060693e-01f, 6.26474693e-02f, -9.81555879e-02f, 1.62600368e-01f, -2.68890411e-01f, -6.89335838e-02f, -4.61346842e-02f, -1.93586856e-01f, -6.56973869e-02f,
  3.03876251e-02f, -1.24228016e-01f, -1.21487923e-01f, -5.79971671e-02f, -4.65099812e-02f, 4.22976129e-02f, -5.26674539e-02f, 1.04218453e-01f, 2.37331793e-01f, -6.76472187e-02f,
  2.30056480e-01f, 2.53966093e-01f, -2.88471311e-01f, 4.56868932e-02f, -6.26723021e-02f, 1.52605787e-01f, 6.71742186e-02f, -7.85882324e-02f, 2.46106490e-01f, 3.19416411e-02f,
  -3.50651383e-01f, 1.09833805e-02f, -2.25925237e-01f, -2.60493696e-01f, 1.62318498e-01f, -1.24630029e-03f, -9.45848450e-02f, 8.62791315e-02f, -2.46254578e-01f, 3.30915973e-02f,
  2.19562843e-01f, 1.14467693e-02f, 4.26912913e-03f, 1.41688632e-02f, 1.90954246e-02f, 1.33593604e-02f, 1.17923710e-02f, 4.68754880e-02f, 1.58818632e-01f, 2.10724212e-02f,
  3.62081677e-02f, 4.35381867e-02f, 1.86642185e-02f, 1.10376969e-01f, 3.17619406e-02f, 2.46768370e-02f, -5.58934323e-02f, -6.44690916e-02f, 4.37307730e-02f, 4.87861559e-02f,
  1.53286066e-02f, 1.66873232e-01f, 3.48047949e-02f, 6.21477664e-02f, 8.32569450e-02f, 6.60682917e-02f, 2.30527282e-01f, 4.99840938e-02f, 4.25464734e-02f, 1.22193754e-01f,
  9.42019559e-03f, 3.10010165e-02f, 1.48961231e-01f, -1.18415006e-01f, -2.23548505e-02f, -1.04916431e-01f, -1.25642598e-01f, 1.28099098e-04f, -1.22164659e-01f, 9.29750204e-02f,
  -2.47963250e-01f, -4.50937420e-01f, 1.29370049e-01f, -8.01530480e-02f, 2.35388324e-01f, -2.00366110e-01f, 1.10952854e-01f, 2.45062947e-01f, -7.10741756e-03f, -3.49041492e-01f,
  2.58132607e-01f, 1.24726430e-01f, 6.00257479e-02f, -3.79722267e-02f, -6.14609569e-02f, -1.82915628e-01f, 2.82822669e-01f, 6.41039833e-02f, -1.94019149e-03f, -9.08143539e-03f,
  -1.36587620e-01f, 1.13000803e-01f, -1.88203037e-01f, 5.46138883e-02f, -3.17628562e-01f, -4.23311234e-01f, 1.38433769e-01f, 3.13393027e-02f, -3.92328613e-02f, 1.11497611e-01f,
  4.01396118e-03f, -7.70936310e-02f, -1.00642294e-01f, -1.06603481e-01f, 8.78127515e-02f, 4.41229679e-02f, 3.49399559e-02f, -1.11130394e-01f, 1.58816442e-01f, 1.43858030e-01f,
  -5.70307337e-02f, 3.12368087e-02f, 2.66586095e-02f, 2.89342314e-01f, 8.06915760e-02f, -1.15462989e-02f, 1.97466034e-02f, -5.02974205e-02f, -1.51055902e-01f, 1.67101193e-02f,
  -1.14900451e-02f, -2.53992647e-01f, -7.49362856e-02f, 7.12975264e-02f, -7.84566030e-02f, 1.64461993e-02f, -5.25467172e-02f, 4.74480763e-02f, 1.16167329e-01f, 4.39679101e-02f,
  2.71566678e-02f, -2.07594652e-02f, -8.18531066e-02f, 1.64851740e-01f, -2.48666808e-01f, -6.09750785e-02f, 7.38968700e-02f, 4.15018238e-02f, 3.04644763e-01f, 2.32445806e-01f,
  -1.73609667e-02f, 7.81506002e-02f, -1.08216807e-01f, 2.24898860e-01f, 9.62219834e-02f, 2.44106710e-01f, 2.28130683e-01f, 6.86601028e-02f, -4.68224287e-01f, -6.91425204e-02f,
  9.50564668e-02f, -2.31852427e-01f, 6.58731833e-02f, 1.90532729e-01f, 1.25416517e-02f, 1.44181341e-01f, 1.23551011e-01f, 2.12101266e-01f, 1.73873842e-01f, -4.68875468e-03f,
  6.17645122e-02f, 8.18768218e-02f, 1.28902942e-01f, 2.25378558e-01f, -2.88686738e-03f, 8.49041268e-02f, 7.64450012e-03f, -1.51399930e-03f, 5.26957167e-03f, 1.15712829e-01f,
  7.99042657e-02f, 2.14622468e-02f, 5.51240109e-02f, 1.59632966e-01f, 1.05128020e-01f, 1.22521013e-01f, -1.15251273e-01f, 2.20253095e-01f, -4.38592583e-02f, 7.89380372e-02f,
  8.99258107e-02f, 9.38833654e-02f, -1.60066485e-02f, -7.79243484e-02f, -2.51731426e-01f, -3.29230607e-01f, -2.21487924e-01f, 2.68428117e-01f, -1.58913791e-01f, 2.54988164e-01f,
  1.27037033e-01f, -2.24876434e-01f, 1.09081745e-01f, -5.31716682e-02f, 3.40253115e-02f, -7.28723630e-02f, -2.31957495e-01f, -1.06685936e-01f, 7.08301142e-02f, -4.03186604e-02f,
  -2.13976935e-01f, 3.21850888e-02f, 7.59757012e-02f, -1.91030785e-01f, 6.59659356e-02f, 2.58168459e-01f, 7.05674812e-02f, -1.43387944e-01f, 2.93177143e-02f, -2.41871074e-01f,
  1.17688082e-01f, -1.78508133e-01f, 2.54603773e-01f, -2.21790910e-01f, -2.35885322e-01f, 2.49300040e-02f, -1.44613594e-01f, 1.73115253e-01f, 1.09615408e-01f, -2.16760099e-01f,
  4.14826497e-02f, 2.77521223e-01f, -2.85716057e-01f, 2.60382295e-01f, 9.63386744e-02f, 2.61783183e-01f, 1.58208489e-01f, 5.18332534e-02f, 6.92902654e-02f, 2.44364977e-01f,
  -9.73551050e-02f, 5.12406603e-02f, 1.58368096e-01f, 1.16041638e-01f, -7.62609988e-02f, -1.03581045e-02f, -4.93056923e-02f, 1.89613272e-02f, 2.62952466e-02f, -1.85159892e-02f,
  1.14346087e-01f, 7.95368552e-02f, 4.47574072e-02f, 5.89541942e-02f, -5.01592364e-03f, -1.69191062e-01f, -1.51855215e-01f, -3.93462747e-01f, 1.94517195e-01f, -2.13122860e-01f,
  7.14147240e-02f, -1.76703662e-01f, -6.00783005e-02f, -9.28037614e-02f, -1.80293009e-01f, -3.95079255e-02f, 1.80569693e-01f, 1.36942104e-01f, -1.23420671e-01f, -2.38159448e-02f,
  -3.26834805e-02f, 7.17829838e-02f, 1.10902689e-01f, 1.77312344e-01f, -9.13745910e-02f, 1.22829631e-01f, -6.18374869e-02f, 4.23645452e-02f, 7.18771592e-02f, -1.39845669e-01f,
  2.06307203e-01f, 1.21412843e-01f, 5.06742522e-02f, -3.70712695e-03f, 3.11984897e-01f, 1.76813751e-01f, 1.93365302e-03f, -2.25983068e-01f, -3.52462500e-01f, 3.39178625e-03f,
  -3.49487811e-01f, 1.63669258e-01f, 5.73456399e-02f, -1.72714815e-01f, -1.84929624e-01f, -2.97574490e-01f, -4.57354747e-02f, 3.93589169e-01f, 4.57363017e-02f, -1.41100828e-02f,
  1.40241995e-01f, -2.38804799e-02f, -1.16017889e-02f, 2.34006926e-01f, -4.64022085e-02f, 1.35971233e-01f, -2.22086292e-02f, 2.59465594e-02f, 1.29840234e-02f, -2.07142696e-01f,
  3.94791663e-02f, 1.44951772e-02f, 2.49784440e-01f, 8.31553191e-02f, -8.38658735e-02f, 5.90054058e-02f, 3.87153849e-02f, -2.21363038e-01f, 7.17921555e-02f, -2.33456790e-01f,
  -1.21998809e-01f, -3.26177739e-02f, 2.99728066e-01f, -1.97190996e-02f, -4.84127812e-02f, -5.55959903e-02f, -8.16665068e-02f, 2.98378672e-02f, 2.05379277e-01f, 7.03142807e-02f,
  -3.41580883e-02f, 1.64838973e-02f, 1.03115693e-01f, 2.20754836e-02f, 1.10338055e-01f, 1.64095182e-02f, 1.10808037e-01f, 1.52496755e-01f, -3.14671606e-01f, 2.43421212e-01f,
  -3.01684365e-02f, -2.92390049e-01f, 2.61184633e-01f, 4.16041352e-02f, 2.86754649e-02f, 1.48852170e-01f, 9.65291709e-02f, 1.44325122e-01f, 2.32220247e-01f, 3.26515943e-01f,
  -8.72118250e-02f, -1.70715287e-01f, 5.11390194e-02f, 2.64425278e-01f, -1.16440609e-01f, 1.48825899e-01f, -8.17208141e-02f, -2.24720061e-01f, -2.07907856e-02f, -7.71308988e-02f,
  -2.87316322e-01f, -2.38024712e-01f, 3.60286236e-02f, 2.10330293e-01f, 3.04314196e-02f, -4.67876643e-02f, -5.96990995e-02f, -1.18618039e-02f, 4.81465757e-02f, -9.23787057e-02f,
  -4.21093665e-02f, 1.16126433e-01f, -5.50411530e-02f, 2.21138131e-02f, -2.82502118e-02f, -5.12117893e-02f, -3.77722308e-02f, 1.87572226e-01f, -4.22462896e-02f, 1.64902613e-01f,
  -8.39725956e-02f, 1.62025429e-02f, -1.34590954e-01f, -9.09345970e-02f, -1.75489917e-01f, 3.26375186e-01f, 2.55767107e-02f, -1.62578106e-01f, -2.23596826e-01f, -7.45768622e-02f,
  -9.58070755e-02f, -1.17764883e-01f, -1.45789817e-01f, 6.08966639e-03f, 1.00773107e-02f, 9.60978195e-02f, -2.28083402e-01f, -6.64085671e-02f, -1.59165993e-01f, 4.57386002e-02f,
  1.28368493e-02f, 1.35307714e-01f, -6.04505241e-02f, -2.59961039e-01f, 1.23983353e-01f, 1.83951095e-01f, -1.29524544e-02f, 2.53625989e-01f, -1.85105294e-01f, 1.40775770e-01f,
  -3.57939750e-02f, -1.13063656e-01f, 2.97874480e-01f, -2.44225159e-01f, -2.76916504e-01f, -1.72414333e-01f, -9.98684838e-02f, -5.95273525e-02f, 4.35219072e-02f, 1.46302357e-02f,
  -9.17035192e-02f, 4.39572036e-02f, -1.77720692e-02f, -6.40385449e-02f, 1.00995377e-02f, 4.05988961e-01f, 1.92336738e-01f, 8.21650550e-02f, 1.08086556e-01f, 2.06846222e-01f,
  -1.25776855e-02f, 9.65195075e-02f, 2.71605905e-02f, 9.72187519e-02f, 8.20870027e-02f, 8.35177004e-02f, 1.61942601e-01f, 4.91124652e-02f, 1.07088111e-01f, 7.98237976e-03f,
  6.19745925e-02f, -2.86826883e-02f, 2.79122740e-02f, 7.80391768e-02f, 5.26303016e-02f, -3.78388576e-02f, 1.43893473e-02f, -1.73684344e-01f, 4.19157138e-03f, -1.82468817e-02f,
  2.07705237e-02f, -9.98271555e-02f, 9.22817388e-04f, 1.73211485e-01f, 4.58186604e-02f, -5.24129830e-02f, 1.31843776e-01f, 1.71824843e-01f, 1.73972808e-02f, 2.28204448e-02f,
  1.58536024e-02f, -8.27895850e-02f, -9.00507569e-02f, -1.83372319e-01f, 1.74993068e-01f, 1.64132148e-01f, -2.22635791e-01f, 1.35530934e-01f, -1.63936317e-02f, -6.14300184e-03f,
  -4.73939069e-02f, -5.20224236e-02f, 1.25152260e-01f, 3.47276092e-01f, -4.28198844e-01f, 2.33582050e-01f, 2.05903888e-01f, -9.65221748e-02f, 6.80446401e-02f, -4.73581590e-02f,
  6.90934137e-02f, 2.25669339e-01f, 7.16099329e-03f, 1.33238763e-01f, 1.98016405e-01f, -2.90600687e-01f, -5.75698204e-02f, 1.22729607e-01f, -3.31295654e-02f, -5.16133569e-02f,
  1.71106026e-01f, 1.72442108e-01f, 5.79435602e-02f, -1.21751554e-01f, 8.22170544e-03f, 1.28157154e-01f, 1.42528504e-01f, -1.36477083e-01f, 1.88811913e-01f, 2.79523097e-02f,
  5.33976406e-02f, 1.49589360e-01f, 3.97700220e-02f, -6.07088469e-02f, -7.23445192e-02f, -4.73432690e-02f, -1.43396571e-01f, 7.77042704e-03f, 1.09982215e-01f, 1.19341128e-01f,
  -1.47560641e-01f, -1.34711042e-01f, -2.62052655e-01f, 1.24721631e-01f, 1.01925373e-01f, -6.40088990e-02f, -6.47634044e-02f, 9.67787765e-03f, -7.69087896e-02f, -2.08973408e-01f,
  -9.38944146e-02f, -4.78684641e-02f, -9.07148942e-02f, -3.68961729e-02f, 2.65718643e-02f, -3.25244330e-02f, 1.02419011e-01f, -1.70963109e-02f, -6.13400899e-02f, 8.51868242e-02f,
  9.66447219e-03f, -2.05897719e-01f, 3.14044803e-01f, 1.19460989e-02f, 3.35727841e-01f, 5.14278114e-02f, -1.42418787e-01f, 1.65144607e-01f, 6.09407388e-03f, 4.86691371e-02f,
  2.95346379e-01f, 4.01967503e-02f, -3.52003217e-01f, -4.43838090e-02f, -2.80699432e-01f, -2.59511679e-01f, -9.89079773e-02f, -1.75527513e-01f, -1.62076578e-01f, -2.44045302e-01f,
  -3.83296549e-01f, 8.13980326e-02f, 5.83564537e-03f, 3.42123955e-02f, -1.40842438e-01f, 3.96129750e-02f, 6.46811873e-02f, -4.42875884e-02f, -7.13604242e-02f, -1.33910505e-02f,
  9.83008146e-02f, -5.74000739e-02f, -1.55410752e-01f, 1.08368695e-01f, 2.19144031e-01f, 1.36123747e-01f, 1.66183725e-01f, 2.69689206e-02f, -3.68263796e-02f, 7.32732713e-02f,
  1.15658723e-01f, 4.16367278e-02f, 2.09929615e-01f, 2.91280877e-02f, -4.04544882e-02f, 6.20646551e-02f, 7.13705346e-02f, 2.70948932e-02f, -1.26278596e-02f, 7.87864029e-02f,
  2.66758129e-02f, -2.02459708e-01f, -1.28066808e-01f, -1.05111636e-01f, -2.69910008e-01f, 1.27866725e-03f, 6.61809966e-02f, 2.31169805e-01f, 1.02085315e-01f, -2.96214186e-02f,
  8.38857368e-02f, -5.50852492e-02f, -7.46098980e-02f, 2.43758649e-01f, -1.79695035e-03f, -1.49679005e-01f, -2.28099510e-01f, 1.54217333e-01f, -1.42991945e-01f, -2.15151936e-01f,
  -1.94832623e-01f, -8.94664824e-02f, 1.36463031e-01f, -3.09889495e-01f, -9.77066811e-03f, -1.88532978e-01f, -3.64463292e-02f, 1.63745910e-01f, -1.35730848e-01f, -1.18701637e-01f,
  2.02227645e-02f, -1.18676275e-02f, -9.45352167e-02f, 1.94087490e-01f, 8.70253891e-03f, 1.58317329e-03f, 1.20697834e-01f, 3.59879911e-01f, -9.67074409e-02f, -1.03282118e-02f,
  1.78828269e-01f, 1.60127252e-01f, 5.88205978e-02f, 1.37580991e-01f, 2.59504795e-01f, 2.17036754e-01f, -8.56959913e-03f, 8.66070297e-03f, 2.85815746e-01f, 6.69597834e-02f,
  1.25281457e-02f, 7.48158917e-02f, 1.48985028e-01f, 1.16249278e-01f, 1.05195470e-01f, 3.78023162e-02f, -1.08847367e-02f, -2.36445278e-01f, -1.50631117e-02f, 2.11719517e-02f,
  8.91179219e-02f, -1.71021685e-01f, 1.03100926e-01f, -8.22704062e-02f, 2.65339464e-01f, -2.96029210e-01f, -1.10151783e-01f, 3.15714069e-02f, -3.57285857e-01f, -3.82882692e-02f,
  3.79732922e-02f, -5.50064594e-02f, 3.01456880e-02f, 7.58131780e-03f, 9.52577889e-02f, 3.40041630e-02f, -6.02358170e-02f, 1.16211861e-01f, -6.26722351e-03f, -8.48529637e-02f,
  -4.73876670e-02f, 2.18978345e-01f, 8.00269097e-02f, -3.03401917e-01f, 9.49195921e-02f, -2.32506413e-02f, -1.72157690e-01f, -1.08149670e-01f, 6.59555197e-02f, 2.88320154e-01f,
  -2.16420650e-01f, 2.13040218e-01f, -2.65367031e-01f, -1.92760184e-01f, 8.30910355e-02f, 1.19700767e-02f, -1.81264177e-01f, 1.94521695e-01f, -2.84210593e-01f, 4.83847782e-02f,
  3.28263968e-01f, 2.45847315e-01f, 8.78607482e-02f, 2.60154661e-02f, 1.48428679e-01f, -1.09162323e-01f, 2.56033301e-01f, -5.50794564e-02f, 1.22994646e-01f, 4.45450209e-02f,
  1.34771718e-02f, 1.81722324e-02f, -1.04355067e-01f, 4.92894351e-02f, -1.87755868e-01f, -6.60056621e-02f, -6.05379976e-02f, 7.77299181e-02f, 6.57338277e-02f, 1.50733560e-01f,
  -4.54301573e-02f, 1.26358271e-01f, -7.64176575e-03f, -6.65736794e-02f, -7.78465047e-02f, 1.05507836e-01f, 1.80690914e-01f, 1.21695913e-01f, 9.75699071e-03f, -5.67626990e-02f,
  1.19300053e-01f, 2.58105785e-01f, -5.64362593e-02f, -8.25068951e-02f, -1.91566385e-02f, -2.23377362e-01f, -1.30219748e-02f, 1.14255048e-01f, -8.64095092e-02f, 9.93749220e-03f,
  -2.70301133e-01f, -2.40700871e-01f, 1.54835418e-01f, -4.87883911e-02f, 1.76323682e-01f, 1.09980971e-01f, 2.98054546e-01f, 3.13324898e-01f, -4.76161540e-02f, -2.81181186e-01f,
  2.60900974e-01f, 4.44717854e-02f, -1.91786930e-01f, 3.01922739e-01f, -1.27502456e-01f, -2.15807185e-01f, -7.22764805e-02f, 4.41200398e-02f, 6.62895888e-02f, -6.18582740e-02f,
  -9.32320356e-02f, 2.88701147e-01f, 2.03739986e-01f, -2.51709037e-02f, 2.74357889e-02f, -1.74276270e-02f, -3.30636233e-01f, 7.60190710e-02f, -1.01298667e-01f, -3.18521969e-02f,
  2.59613246e-02f, 2.31059060e-01f, 1.22279478e-02f, 1.34459898e-01f, 6.72850981e-02f, 1.26949186e-02f, 1.30814046e-01f, 3.41022238e-02f, -2.77677141e-02f, 4.37940806e-02f,
  -1.25517204e-01f, 1.94055438e-01f, 5.20261899e-02f, 1.71425100e-02f, 3.86485122e-02f, -3.34308892e-01f, -2.40279436e-01f, -1.74616650e-01f, 8.84292051e-02f, -1.28001481e-01f,
  -2.72877514e-01f, 2.25660384e-01f, 3.31382811e-01f, -2.75841475e-01f, -3.94108258e-02f, -8.98349360e-02f, -1.54233396e-01f, -2.90496081e-01f, -2.43854135e-01f, 1.62982300e-01f,
  -4.09396440e-02f, 2.61451989e-01f, 2.39032000e-01f, -5.34892008e-02f, 1.90425813e-01f, 1.89858973e-01f, -3.77991885e-01f, -9.31254774e-02f, -3.17366958e-01f, 2.08833069e-02f,
  -4.13789265e-02f, -2.42284104e-01f, 3.11245859e-01f, -1.89465091e-01f, 3.63144167e-02f, -9.75984633e-02f, 1.07549131e-01f, -2.22779125e-01f, -1.05493665e-01f, 4.93258685e-02f,
  6.17442578e-02f, -1.45735681e-01f, 4.06968500e-03f, -8.97889733e-02f, -2.19911888e-01f, 4.55874093e-02f, 2.97661364e-01f, -1.10773981e-01f, 3.76143575e-01f, 1.03862703e-01f,
  5.25036529e-02f, 7.53624961e-02f, 1.04485914e-01f, 5.08346297e-02f, -8.80567357e-02f, 1.38548166e-01f, -5.42754754e-02f, 9.27617848e-02f, -8.33369568e-02f, 1.43670822e-02f,
  4.12288308e-02f, -1.40304044e-01f, 1.04201533e-01f, -4.93508689e-02f, 6.64905310e-02f, 4.78038080e-02f, 5.75591438e-02f, 1.78190798e-01f, -1.31865233e-01f, 1.82043642e-01f,
  5.41214943e-02f, 3.00841834e-02f, -1.41968161e-01f, -2.83495218e-01f, 4.93448274e-03f, -2.30454296e-01f, 1.72478817e-02f, -1.00815453e-01f, 1.30039692e-01f, 1.25829637e-01f,
  -1.31808758e-01f, 1.54380977e-01f, 3.22117180e-01f, 3.70550193e-02f, 3.08425259e-03f, 6.54634833e-02f, -1.02599770e-01f, 1.43998325e-01f, 9.06483158e-02f, 2.18176782e-01f,
  -1.23848021e-01f, 3.38088674e-03f, -2.31809810e-01f, 1.83375433e-01f, -1.54261455e-01f, -2.07393199e-01f, 1.76748022e-01f, 6.12298809e-02f, 1.56158999e-01f, -1.31355328e-02f,
  4.03509922e-02f, -7.37356916e-02f, 1.05556317e-01f, -1.58285081e-01f, -2.17556417e-01f, 4.14727665e-02f, -8.25638771e-02f, 1.99131250e-01f, 3.75071466e-02f, 1.40813915e-02f,
  1.01012893e-01f, -2.48718604e-01f, 1.15448236e-01f, 3.84809256e-01f, -2.14543656e-01f, 2.12924808e-01f, 9.01181921e-02f, 1.96273968e-01f, -3.96064632e-02f, -1.26838580e-01f,
  1.83933645e-01f, 4.52242978e-02f, -1.01587987e-02f, -1.12386249e-01f, 4.09292169e-02f, 1.45281106e-01f, 1.14970878e-01f, 1.02104641e-01f, 1.04889246e-02f, 5.63019216e-02f,
  1.13580398e-01f, -8.20580721e-02f, 1.17560185e-01f, 1.37372479e-01f, 1.31230593e-01f, 8.26848000e-02f, 2.12337285e-01f, 9.22887474e-02f, 3.40345591e-01f, 1.78136393e-01f,
  1.15224496e-01f, -9.83234644e-02f, 2.26937145e-01f, -1.46192744e-01f, 1.01020467e-02f, 1.44103780e-01f, -1.58049241e-01f, 4.76037003e-02f, -1.41994525e-02f, 2.17957377e-01f,
  1.00952730e-01f, 1.68979719e-01f, -2.19042614e-01f, -8.55495706e-02f, 3.24018359e-01f, -1.88137800e-01f, -1.15528535e-02f, -2.63148010e-01f, -5.68629839e-02f, -2.15889752e-01f,
  -2.17447445e-01f, -6.18826784e-02f, -7.81945437e-02f, -1.05160639e-01f, -1.10383093e-01f, -1.07200809e-01f, 1.99298803e-02f, 6.86783120e-02f, 1.25118122e-01f, -8.71565118e-02f,
  1.50201589e-01f, -2.23008007e-01f, 8.74344707e-02f, 3.64339203e-02f, 1.54116482e-03f, 7.81883150e-02f, 1.53323086e-02f, -1.61373094e-01f, -6.33243844e-02f, 3.60345654e-02f,
  3.70665453e-02f, 2.47550178e-02f, -2.79442649e-02f, 1.08273059e-01f, 3.84347700e-02f, 5.16531579e-02f, 1.00472644e-01f, 1.85773801e-02f, 9.06932727e-02f, 1.74729690e-01f,
  1.67223677e-01f, 8.68334323e-02f, -1.27660288e-02f, 3.71970572e-02f, 8.96579325e-02f, 5.00758216e-02f, 4.90784794e-02f, 4.05515730e-02f, -1.32115990e-01f, 1.91676304e-01f,
  5.82237393e-02f, -2.35312581e-01f, -2.82831676e-02f, 8.60023405e-03f, 3.45394202e-02f, 1.35626392e-02f, 1.18745655e-01f, 1.24807283e-01f, -2.37237997e-02f, 1.73794553e-01f,
  4.00162935e-02f, -3.36072743e-02f, -3.35177667e-02f, 9.55327973e-02f, 2.71964837e-02f, 1.88474894e-01f, -1.65131420e-01f, -1.89370900e-01f, 2.82098919e-01f, 5.27730845e-02f,
  -1.73785612e-01f, -1.12257093e-01f, -1.99418738e-01f, -8.24125335e-02f, -2.72095632e-02f, -3.62693779e-02f, 2.20697537e-01f, -1.32576888e-03f, -8.65855440e-02f, 2.68290881e-02f,
  2.44164109e-01f, 6.26394700e-04f, 3.73101197e-02f, -4.00418974e-02f, -1.25078193e-03f, -1.84143096e-01f, -9.36133713e-02f, 2.78679192e-01f, 6.82566836e-02f, -4.59074490e-02f,
  -1.24649070e-01f, 1.85532719e-01f, -3.58064063e-02f, -1.98605619e-02f, 2.22057812e-02f, 1.75915170e-03f, 2.06093848e-01f, -6.78014606e-02f, 2.66635716e-01f, -2.75556836e-02f,
  2.71843791e-01f, 2.15117857e-02f, 1.52784377e-01f, 3.85548145e-01f, 3.84673453e-03f, 6.50440082e-02f, 9.14463848e-02f, 6.25408217e-02f, 1.06666639e-01f, 4.74760830e-02f,
  2.33587891e-01f, -7.87537023e-02f, 8.24554171e-03f, 2.16605008e-01f, 2.59166747e-01f, 2.65927106e-01f, -5.47485277e-02f, 2.86717802e-01f, 2.64667645e-02f, 1.28814965e-01f,
  -8.38913769e-02f, -1.88908055e-01f, -1.02886774e-01f, -6.07235953e-02f, -4.68953513e-02f, 8.74776989e-02f, -2.82017402e-02f, 1.71495378e-01f, 2.71368567e-02f, -1.13343716e-01f,
  -9.28292498e-02f, -1.11529984e-01f, 2.42610201e-01f, -1.43940821e-01f, 1.38491288e-01f, -2.41353869e-01f, -3.55970673e-02f, 2.44990870e-01f, -5.29037695e-03f, -6.51704594e-02f,
  -6.02826755e-03f, -2.12169424e-01f, -5.63417263e-02f, 3.79311033e-02f, -3.65679450e-02f, 2.28321701e-01f, 9.73554552e-02f, 1.23105749e-01f, 1.47686496e-01f, -2.36995891e-01f,
  1.94400191e-01f, 1.08439729e-01f, -1.19111359e-01f, 2.54289061e-01f, -4.30296734e-02f, -2.89504111e-01f, -1.36236340e-01f, 1.04127645e-01f, 2.09121704e-01f, 1.53055578e-01f,
  1.57508269e-01f, 2.86982744e-03f, 1.67647332e-01f, -3.94584015e-02f, 2.30807379e-01f, 7.35279471e-02f, 7.39943534e-02f, 2.47472867e-01f, 3.02209128e-02f, 5.24436422e-02f,
  1.47998054e-02f, 9.07365754e-02f, 1.87993407e-01f, 3.38794254e-02f, 2.32876781e-02f, -2.33232781e-01f, -6.74895421e-02f, -2.43583292e-01f, 3.23421240e-01f, 3.46916586e-01f,
  -5.90660982e-02f, 4.94484514e-01f, 4.59712185e-02f, -2.37907451e-02f, -2.01383814e-01f, -3.04990351e-01f, -4.16944697e-02f, -6.92078471e-02f, -1.90782353e-01f, 1.11946560e-01f,
  -1.09552912e-01f, 2.09215060e-01f, 1.00847827e-02f, -1.80573910e-01f, 2.77486369e-02f, 1.71283651e-02f, 5.57256900e-02f, -2.00396135e-01f, -1.29381269e-01f, -3.46811235e-01f,
  2.19972908e-01f, 1.86683714e-01f, 8.23994167e-03f, -3.93648684e-01f, -5.31805865e-02f, 1.68695986e-01f, -4.51910704e-01f, -1.87298968e-01f, 1.56121537e-01f, 2.80029863e-01f,
  -4.08304222e-02f, 2.13427037e-01f, -1.32669359e-01f, -1.06161296e-01f, 1.32150501e-01f, -1.53299049e-01f, -2.35380065e-02f, 1.80667102e-01f, -1.58966556e-02f, -2.20880419e-01f,
  3.48452091e-01f, -3.48132811e-02f, 8.96459296e-02f, 5.51907495e-02f, 1.19913921e-01f, -2.08900347e-02f, -1.91555973e-02f, 1.83610260e-01f, 2.45600373e-01f, 2.25630179e-01f,
  2.42144853e-01f, 1.65870950e-01f, 5.45548089e-02f, 1.62343666e-01f, 1.51800931e-01f, 1.02305681e-01f, 7.61409570e-03f, -2.34325714e-02f, -2.78305262e-02f, 2.72213101e-01f,
  -9.06734094e-02f, 1.13355123e-01f, -7.91447759e-02f, 9.52174962e-02f, -1.90215930e-01f, -3.85671645e-01f, -3.11174273e-01f, 3.35637271e-01f, -6.97785690e-02f, 5.46403192e-02f,
  -3.25080543e-03f, -1.73140734e-01f, 6.13639131e-02f, 8.10223520e-02f, -4.02690992e-02f, -1.90081373e-01f, -8.85048136e-02f, -2.90594250e-01f, 1.83766648e-01f, 1.86150104e-01f,
  1.71532422e-01f, -5.02411462e-02f, 2.43178800e-01f, -1.55610163e-02f, 3.63031193e-03f, 2.47567445e-01f, -1.84011012e-01f, 2.54051715e-01f, -1.95765391e-01f, -3.04486528e-02f,
  2.30720267e-01f, -8.19250867e-02f, -5.20693213e-02f, 2.74247047e-03f, -1.75357267e-01f, -2.50141285e-02f, 2.72066563e-01f, 1.62795186e-01f, 2.32662261e-01f, 1.03737041e-01f,
  -1.85652331e-01f, 2.28362560e-01f, -3.54763597e-01f, 5.07656448e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -5.24432361e-02f, 1.08782180e-01f, 1.85434833e-01f, 2.73444038e-02f, 4.39800546e-02f, 2.31459141e-02f, 1.47948518e-01f, 1.32494316e-01f, 4.24602032e-02f, -1.61823079e-01f,
  4.45685275e-02f, 6.70363232e-02f, -1.73793912e-01f, -5.48246801e-02f, -7.24699050e-02f, 1.03248462e-01f, 1.63028419e-01f, 1.06583551e-01f, -1.30312657e-02f, 2.66637094e-03f,
  -8.73784628e-03f, 2.04405840e-02f, -2.17032544e-02f, 1.25601262e-01f, 2.83561498e-01f, 1.34607628e-01f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.56721309e-01f, 2.89042711e-01f, 2.54301399e-01f, 7.35582933e-02f, 1.77173793e-01f, 2.01718092e-01f, -9.62959230e-02f, -4.79010865e-02f, 3.72976139e-02f, 9.33487341e-02f,
  1.23459727e-01f, -4.85702567e-02f, -8.71077254e-02f, -4.09903824e-02f, -3.77608184e-03f, 1.28271175e-03f, -3.48459966e-02f, 2.11129803e-02f, -2.30382523e-03f, -1.52394891e-01f,
  9.67007875e-02f, 1.56457245e-01f, 1.85406599e-02f, -2.00043410e-01f, -2.10373789e-01f, 1.11533023e-01f, -1.11452296e-01f, 1.21681660e-01f, -1.60785988e-01f, 1.56534016e-01f,
  4.70692217e-02f, -1.80267125e-01f, 3.93685214e-02f, -1.61919355e-01f, -1.37303814e-01f, 6.01882674e-02f, -1.29124641e-01f, 1.44614309e-01f, 9.15511921e-02f, -2.56544113e-01f,
  4.93968744e-03f, 3.28520536e-02f, -1.06875934e-01f, -1.32480636e-01f, 4.36856262e-02f, -1.71655063e-02f, -1.49450198e-01f, 5.19411964e-03f, -5.17000556e-02f, -1.20166443e-01f,
  -1.89104974e-01f, 1.45980999e-01f, 9.52412263e-02f, 7.84439370e-02f, 1.41553536e-01f, -2.09781379e-01f, 2.49400064e-02f, 1.78318724e-01f, -9.86918435e-02f, -1.44139811e-01f,
  8.53122696e-02f, 4.24142089e-03f, 1.19720064e-01f, 1.58503845e-01f, 1.15985729e-01f, 4.13561642e-01f, 1.35891005e-01f, 2.48366907e-01f, 2.79202044e-01f, 4.93955575e-02f,
  3.84034514e-02f, 2.17547938e-02f, 1.19545087e-01f, 6.58206362e-03f, 1.19522206e-01f, 1.81197990e-02f, -7.78068453e-02f, -6.89075142e-02f, -5.26006408e-02f, 6.18787706e-02f,
  -3.93555034e-03f, -5.52771799e-02f, -3.25923450e-02f, -1.15732267e-01f, -7.68238679e-02f, 1.89849898e-01f, 2.44714245e-01f, -1.65543124e-01f, -3.12184244e-01f, 9.47860405e-02f,
  1.26466975e-01f, 1.73419211e-02f, 3.29157822e-02f, -1.15708299e-01f, 1.09950535e-01f, -9.57628340e-02f, 1.73404723e-01f, -2.01096088e-02f, -2.33076811e-01f, -4.84592095e-02f,
  -4.04051170e-02f, 2.67642170e-01f, -8.28630105e-02f, 5.38584515e-02f, -8.05239566e-03f, -1.16762079e-01f, 3.86582464e-02f, 6.18580952e-02f, -2.16548920e-01f, 1.62017137e-01f,
  1.47127494e-01f, -5.52393086e-02f, -2.35581044e-02f, -1.83804810e-01f, -1.69579946e-02f, 9.75975692e-02f, 4.88535948e-02f, 1.31370813e-01f, -1.75956070e-01f, -2.27374837e-01f,
  -1.46648837e-02f, -1.25106245e-01f, -1.30995736e-01f, 2.20169835e-02f, -2.17557903e-02f, 1.52029604e-01f, 1.95313811e-01f, 1.50370435e-03f, -5.74808614e-03f, 1.15027666e-01f,
  2.05544829e-01f, 1.42507419e-01f, -4.75284569e-02f, 1.09703548e-01f, 8.62944871e-02f, 1.47608399e-01f, -1.35933816e-01f, -8.96289758e-03f, -1.62685916e-01f, 1.09327428e-01f,
  2.61016954e-02f, 1.16555959e-01f, -1.48673207e-01f, -9.50243473e-02f, 2.98172086e-02f, -1.23600464e-03f, 1.99346803e-02f, 1.40560687e-01f, 4.03997209e-03f, -1.06989637e-01f,
  -2.12403417e-01f, -1.52122319e-01f, 8.23640302e-02f, -3.87574211e-02f, 1.23920850e-01f, 2.47073397e-01f, -1.34258732e-01f, 1.90956131e-01f, 2.29006410e-01f, 2.48504385e-01f,
  -1.97130367e-01f, 6.25838637e-02f, -4.63990569e-02f, -1.62827373e-01f, -2.14909106e-01f, 4.12742198e-02f, 3.43433879e-02f, 3.61387506e-02f, -1.40343800e-01f, 2.80665904e-01f,
  -2.56209582e-01f, 3.23386937e-01f, 1.55807227e-01f, -3.92325744e-02f, -2.74538666e-01f, -2.30354503e-01f, 1.35181397e-01f, 1.91054285e-01f, -1.43558860e-01f, -1.06365867e-01f,
  5.56845777e-02f, 9.87050980e-02f, -5.04267886e-02f, 1.07627049e-01f, -7.55242631e-02f, 1.94295958e-01f, 8.92005935e-02f, -1.90877810e-01f, -1.57799274e-01f, -1.71944618e-01f,
  3.22494566e-01f, -2.61146482e-02f, 1.11358799e-02f, 3.47830318e-02f, -1.54317796e-01f, 2.34989107e-01f, 3.11297446e-01f, 1.11663781e-01f, 5.11839911e-02f, -1.11567594e-01f,
  -1.20390058e-01f, -9.63992104e-02f, -1.20335236e-01f, -4.79903817e-02f, -9.66079242e-04f, 1.26522481e-01f, 2.81210899e-01f, 8.79130065e-02f, -5.45039885e-02f, 1.97062001e-01f,
  -1.95476726e-01f, -8.19541290e-02f, -3.63505065e-01f, -9.57085192e-02f, 8.58946964e-02f, -2.46819273e-01f, -1.79541245e-01f, 1.32374108e-01f, -1.96354955e-01f, -4.24817726e-02f,
  -7.71888867e-02f, 1.42099351e-01f, -1.06464624e-01f, -5.15959831e-03f, -8.04299489e-02f, 1.25588536e-01f, -6.67458847e-02f, 6.85735345e-02f, -1.73525393e-01f, -1.35602310e-01f,
  8.60361606e-02f, -3.75607133e-01f, -5.22822253e-02f, 1.24560460e-01f, 1.25194564e-01f, 4.42825072e-02f, 2.87408624e-02f, 1.09245805e-02f, 1.80981830e-02f, -4.77774777e-02f,
  -9.91329476e-02f, 1.41327634e-01f, -4.54723686e-02f, 1.26331896e-02f, 2.04996347e-01f, 2.08537057e-01f, 1.28098086e-01f, 2.59854406e-01f, -8.52659419e-02f, 1.57918558e-01f,
  4.18489464e-02f, -1.71856999e-01f, -1.81815743e-01f, -8.05174634e-02f, -3.04334406e-02f, 9.00581107e-03f, -1.92727018e-02f, 7.11488798e-02f, 4.93142381e-03f, -2.81640571e-02f,
  1.65193170e-01f, 7.72285229e-03f, -4.59409207e-02f, 1.22230716e-01f, -1.61677841e-02f, -1.88616477e-02f, -5.31845465e-02f, 2.35481322e-01f, -7.02792481e-02f, 1.36872917e-01f,
  3.04279834e-01f, 1.83809519e-01f, 2.05675364e-01f, 1.86357513e-01f, 2.38436665e-02f, -1.33922696e-01f, -2.05702245e-01f, -2.02216610e-01f, 7.63632357e-02f, -7.69693032e-02f,
  5.65294661e-02f, 3.52365188e-02f, -3.68647762e-02f, 1.26503155e-01f, -1.86759084e-01f, 1.79976031e-01f, -8.25012252e-02f, 1.47212386e-01f, 9.78646148e-03f, 8.97375867e-02f,
  -6.66414723e-02f, -1.22717582e-01f, 1.67623997e-01f, 1.91928014e-01f, -2.81948838e-02f, -1.85540438e-01f, -1.64683670e-01f, 1.53521940e-01f, 5.29821180e-02f, 1.46825865e-01f,
  2.21791752e-02f, -4.31281552e-02f, 5.69717810e-02f, -1.42791525e-01f, 2.49012541e-02f, 1.28616154e-01f, 1.30440518e-01f, 3.57786287e-03f, -6.73408508e-02f, 2.24921331e-01f,
  -2.40243529e-03f, 2.46129096e-01f, -8.60320553e-02f, 1.00941442e-01f, 4.46428284e-02f, -2.13810980e-01f, -8.44808444e-02f, -6.07662462e-02f, -6.83921995e-03f, 2.11833399e-02f,
  8.85606557e-02f, -3.79988998e-02f, 8.68806168e-02f, 9.46606100e-02f, 1.54201165e-01f, 2.09757295e-02f, -1.33798078e-01f, -6.17471933e-02f, 3.75284776e-02f, 3.93541344e-02f,
  8.74124467e-03f, -1.81843657e-02f, -7.67811090e-02f, -3.63453515e-02f, -8.05751830e-02f, -6.15373440e-02f, -1.01398617e-01f, 1.39196873e-01f, -2.63786077e-01f, 1.10663325e-01f,
  6.17928989e-03f, -1.56468287e-01f, 1.79403260e-01f, -1.40836043e-02f, 2.24280834e-01f, 1.15647785e-01f, 1.95215717e-01f, -1.30101651e-01f, -4.03911617e-05f, -2.26998508e-01f,
  -2.12936029e-02f, -7.66919479e-02f, -5.37126400e-02f, -1.64263368e-01f, 8.89581349e-03f, -4.75981422e-02f, -1.00927725e-01f, -2.09139571e-01f, -7.46442452e-02f, 3.14990163e-01f,
  -7.95332808e-03f, 4.98058982e-02f, -2.44488791e-02f, -5.10635078e-02f, -1.85631335e-01f, -7.65286088e-02f, 1.40988231e-01f, 2.86623687e-01f, -5.48283234e-02f, -6.85143545e-02f,
  1.71723682e-02f, -6.88895257e-03f, 3.26932818e-02f, -9.70961675e-02f, 5.50965182e-02f, 8.56827646e-02f, 2.68091440e-01f, -4.91822101e-02f, 1.09171227e-01f, 1.38311073e-01f,
  2.17573583e-01f, 5.63049456e-03f, -3.66156071e-01f, 3.81060294e-03f, 7.71039352e-02f, -1.18008532e-01f, -2.42970437e-01f, -1.92142621e-01f, -1.32342771e-01f, -2.53058225e-01f,
  -7.97271505e-02f, -1.81888834e-01f, 1.42834205e-02f, 4.98939417e-02f, 6.81869462e-02f, -1.19480990e-01f, -2.41966620e-01f, 1.92844778e-01f, 1.63926497e-01f, -2.04551816e-02f,
  -9.22210291e-02f, -2.30396725e-02f, -8.45548362e-02f, -9.07059014e-02f, -1.40511438e-01f, -3.04495841e-01f, 1.70040339e-01f, -3.77860218e-02f, 2.95709461e-01f, -9.23620071e-03f,
  6.58116117e-02f, -2.11586505e-01f, -6.29574060e-02f, 1.68189406e-01f, -3.99113655e-01f, 2.05411747e-01f, 1.16462618e-01f, -1.79104909e-01f, 1.21108793e-01f, 4.84250515e-04f,
  -4.76683490e-02f, -1.67300433e-01f, -1.39037445e-01f, 1.22698709e-01f, 1.04561627e-01f, -1.79230142e-02f, -2.09820196e-02f, 6.01919219e-02f, 2.42849395e-01f, 2.37314105e-01f,
  -3.87899764e-03f, 1.21982828e-01f, -1.35976434e-01f, 1.74247950e-01f, 4.42049280e-03f, 1.77445248e-01f, 4.35134098e-02f, 2.18065977e-01f, -1.47253564e-02f, 2.39043429e-01f,
  1.29575029e-01f, -2.63954461e-01f, 1.84135228e-01f, -3.30786332e-02f, 5.82160912e-02f, -1.59297511e-01f, -5.76372683e-01f, 1.57805141e-02f, 3.68364081e-02f, 5.31474426e-02f,
  -7.53518939e-02f, -2.06544429e-01f, -2.30331346e-01f, -6.88327253e-02f, -3.91130596e-02f, -1.56746209e-01f, -2.03710839e-01f, 1.59364697e-02f, 1.30881056e-01f, -4.16340912e-03f,
  -7.42038861e-02f, 1.65209904e-01f, -1.88998207e-02f, 4.74870205e-02f, -3.29110511e-02f, 7.86059946e-02f, -3.31983366e-03f, 1.65281035e-02f, 6.70754164e-02f, -2.24182740e-01f,
  7.87148476e-02f, -7.11406618e-02f, 1.90301016e-01f, 7.77405500e-02f, 1.66149646e-01f, 1.23601355e-01f, 1.05101772e-01f, -4.65416387e-02f, -3.12196817e-02f, -6.60945848e-02f,
  -1.38018325e-01f, -6.94477707e-02f, -5.75645603e-02f, -2.53519893e-01f, -2.88230419e-01f, -1.58998549e-01f, 7.32933059e-02f, 2.91265726e-01f, -3.17499377e-02f, -1.24387175e-01f,
  -1.13881722e-01f, -1.58204183e-01f, -1.07052907e-01f, -1.22086518e-01f, -2.35121138e-03f, 2.44684473e-01f, -4.29344364e-02f, -2.50762612e-01f, 1.32073522e-01f, -3.69018577e-02f,
  -1.58478171e-01f, -1.08675592e-01f, -1.22383140e-01f, -1.37653515e-01f, 2.09691480e-01f, 1.17644286e-02f, -1.02266409e-01f, -3.95686273e-03f, 1.16096653e-01f, 1.04816824e-01f,
  3.77020687e-02f, -1.15096688e-01f, 1.53537646e-01f, 1.00552514e-02f, 3.20445448e-02f, 6.11480176e-02f, 4.37383838e-02f, -9.47562978e-02f, 4.58776876e-02f, 7.21717104e-02f,
  5.46339303e-02f, -7.75719434e-02f, -9.33240727e-02f, 1.38338208e-01f, 1.33194357e-01f, 1.00642309e-01f, -1.63539484e-01f, 1.26597643e-01f, 1.08132944e-01f, -1.87950701e-01f,
  2.52183467e-01f, -1.34532958e-01f, 5.47619648e-02f, 7.79312402e-02f, 3.24468948e-02f, 1.58890560e-01f, -1.78357512e-01f, 2.17214689e-01f, 7.71405697e-02f, 3.18925828e-01f,
  3.08913793e-02f, -2.21461654e-01f, 8.50279257e-02f, -1.13099962e-01f, 1.05900094e-01f, 6.68819323e-02f, -1.90487921e-01f, -1.72570288e-01f, 4.16261144e-02f, 2.08804697e-01f,
  1.10413536e-01f, 8.18591639e-02f, 5.29689491e-02f, -8.16569924e-02f, -4.89299558e-02f, 1.77665010e-01f, -1.37505084e-01f, -6.87047392e-02f, 1.99468300e-01f, -5.02661280e-02f,
  9.44190919e-02f, -1.29503548e-01f, 1.54108822e-01f, 1.75313894e-02f, -9.86298695e-02f, 4.76470590e-02f, -8.96180570e-02f, -3.28328162e-01f, 1.86026976e-01f, 2.25369595e-02f,
  -8.19861293e-02f, 2.16577545e-01f, -9.07040760e-02f, 1.98713690e-01f, 3.82141411e-01f, -5.34271002e-02f, -1.40317127e-01f, -2.66226351e-01f, -2.71750063e-01f, 1.40671089e-01f,
  6.69883490e-02f, -1.97604857e-02f, -7.08838329e-02f, -1.53075799e-01f, -1.12425014e-01f, -1.02659516e-01f, 1.59670383e-01f, 7.35119283e-02f, 7.32063949e-02f, 1.28603026e-01f,
  3.00467074e-01f, 2.28313193e-01f, 9.65887159e-02f, 2.99316138e-01f, 8.70760381e-02f, 9.90120880e-03f, 1.40470443e-02f, -1.59557462e-01f, 1.23083547e-01f, -1.02763310e-01f,
  -2.07489394e-02f, -6.04263432e-02f, -1.56109914e-01f, -1.06057122e-01f, 2.95132816e-01f, 1.66966006e-01f, -5.73809147e-02f, -9.20354053e-02f, 7.97570646e-02f, 2.77160872e-02f,
  1.44145861e-01f, -4.00083028e-02f, 1.68641299e-01f, 5.91028817e-02f, -6.67739660e-02f, -1.47408456e-01f, 3.06201756e-01f, 8.78166109e-02f, 1.76113233e-01f, 7.15572760e-02f,
  -4.64008152e-02f, 7.40617290e-02f, -2.13299617e-01f, -1.06924362e-01f, -1.54054388e-01f, -3.99901122e-02f, 2.30391100e-01f, -1.11606896e-01f, 1.01773798e-01f, 8.44628438e-02f,
  -1.12570994e-01f, 3.55233960e-02f, -1.54337868e-01f, -8.72603431e-02f, -1.63762882e-01f, -7.62905851e-02f, -1.56964570e-01f, 7.59977028e-02f, -8.17591846e-02f, 7.21976459e-02f,
  8.48430917e-02f, -3.14712822e-02f, -2.60051824e-02f, -1.11328155e-01f, 1.10034972e-01f, 1.56238899e-01f, -7.13428929e-02f, -1.71869159e-01f, 1.45882681e-01f, 2.51862377e-01f,
  1.40407324e-01f, 2.02127863e-02f, -4.84760404e-02f, 2.56165624e-01f, 4.93875705e-02f, 5.57702407e-02f, 1.55254647e-01f, 1.81274265e-01f, -1.94940075e-01f, -3.57751660e-02f,
  -1.93110913e-01f, -4.58206646e-02f, 1.79342225e-01f, -1.53540457e-02f, -1.10239990e-01f, -1.13341346e-01f, -1.65171653e-01f, -1.16302751e-01f, -2.13186219e-01f, 8.15977007e-02f,
  -2.61897236e-01f, -7.55008906e-02f, 1.21358670e-01f, 6.20973483e-02f, -1.33811133e-02f, 5.77048697e-02f, 6.54544309e-02f, -1.35605678e-01f, -6.05154261e-02f, -4.70247120e-02f,
  1.30590051e-01f, -6.91262558e-02f, 1.68009564e-01f, -2.53238887e-01f, -5.81598468e-02f, 2.82088965e-01f, 1.18429493e-02f, 3.41769718e-02f, -6.63122758e-02f, 7.03237727e-02f,
  -1.86295748e-01f, 1.53105423e-01f, 2.39149071e-02f, 2.45875850e-01f, 1.92691460e-01f, 3.29784863e-02f, -6.31181970e-02f, -2.00621337e-01f, 7.41761327e-02f, -1.41277283e-01f,
  1.27887189e-01f, 4.40346869e-03f, -4.77423638e-01f, 2.75836110e-01f, -1.67224288e-01f, 1.05849293e-03f, -1.27852410e-01f, 2.30898894e-02f, 2.85578430e-01f, -1.07990779e-01f,
  1.63461342e-01f, -1.65374950e-01f, 9.29915681e-02f, -1.69957936e-01f, 1.79951116e-01f, -1.90377861e-01f, -2.80330572e-02f, -5.25323078e-02f, -2.81208605e-02f, 6.51594251e-02f,
  -1.42558236e-02f, -5.92006296e-02f, -1.06755078e-01f, -2.52702832e-01f, 5.01854531e-02f, -3.63376774e-02f, 1.03571638e-01f, 5.49277775e-02f, -2.35310663e-02f, 3.78192402e-02f,
  1.95929483e-01f, -1.31242201e-01f, 4.37670313e-02f, -1.52425542e-01f, 4.27637994e-03f, -1.97412908e-01f, 1.95727363e-01f, 1.52853325e-01f, -2.34773576e-01f, 2.60765478e-02f,
  2.28188425e-01f, -4.70421277e-02f, -1.66054532e-01f, -1.80862336e-09f, 4.97200787e-02f, -1.47478431e-01f, 3.25766802e-01f, -1.08069152e-01f, -1.77119002e-01f, 8.71375203e-02f,
  5.87751046e-02f, 3.01834624e-02f, -2.53328308e-02f, -1.87711075e-01f, -1.41565323e-01f, -1.32810742e-01f, -1.96120828e-01f, -6.56716228e-02f, -7.26120993e-02f, 1.02164142e-01f,
  -7.17495680e-02f, -1.43030331e-01f, -2.10551605e-01f, -5.01606055e-02f, -2.20225304e-01f, 9.45993438e-02f, 2.20359936e-01f, 2.59038731e-02f, -1.25133261e-01f, -6.97941110e-02f,
  -1.84960499e-01f, 4.48133945e-02f, -1.47002339e-01f, 4.36516590e-02f, -6.01883382e-02f, 3.76036763e-02f, -7.33981431e-02f, -2.76248902e-02f, 7.26794153e-02f, -6.51816800e-02f,
  4.99361642e-02f, -5.75300232e-02f, 2.29223087e-01f, 3.39073986e-01f, -2.58213766e-02f, -2.08275989e-02f, 2.26476446e-01f, 1.49865910e-01f, 2.44476661e-01f, 1.43674806e-01f,
  -2.33223453e-01f, 7.59321377e-02f, 7.21113570e-03f, -1.84062004e-01f, -2.67003864e-01f, -8.12896639e-02f, 1.60402074e-01f, 9.77078155e-02f, -4.01404090e-02f, 1.28124297e-01f,
  -2.81550102e-02f, -1.83093622e-02f, -5.28478287e-02f, -1.13381349e-01f, 7.62112215e-02f, -1.04907379e-01f, -5.96676581e-03f, -2.20254034e-01f, 9.25323740e-02f, -3.01911449e-03f,
  -5.85097298e-02f, -9.54628736e-02f, -9.19887144e-03f, -9.40828547e-02f, -2.99431741e-01f, 1.03269760e-02f, 5.98914213e-02f, -5.16740791e-03f, -3.41599225e-03f, -1.43780768e-01f,
  9.92371291e-02f, -1.58473462e-01f, 7.05615282e-02f, 8.42068270e-02f, -2.63250142e-01f, -9.55877528e-02f, -1.17074601e-01f, -1.85056031e-02f, -6.76229075e-02f, -6.05105869e-02f,
  1.91608354e-01f, -3.64978681e-03f, 1.01218805e-01f, 1.86498970e-01f, -1.11613721e-01f, 2.47980237e-01f, -8.54505971e-02f, 1.46564901e-01f, 2.90556401e-02f, 4.99738753e-02f,
  -1.84314281e-01f, 4.79621328e-02f, 1.93027303e-01f, 3.17691080e-02f, 3.89062986e-02f, -1.27548814e-01f, 1.54842138e-02f, 7.90299773e-02f, 3.73024680e-02f, 1.22242346e-01f,
  -1.63273141e-01f, 1.13204174e-01f, 8.47971160e-03f, -1.29930124e-01f, -3.45664434e-02f, -7.46045411e-02f, -5.22285216e-02f, 1.79348379e-01f, -3.40002291e-02f, 4.03030515e-02f,
  3.33632603e-02f, 1.35084391e-01f, 1.61449820e-01f, 6.99080899e-02f, -3.06376219e-01f, -2.83823144e-02f, 6.43633008e-02f, -5.83391748e-02f, -2.73564816e-01f, 1.26354527e-02f,
  3.20556872e-02f, 1.15945917e-02f, -1.70428067e-01f, 8.56257305e-02f, -1.56830445e-01f, 1.37126269e-02f, 5.23246871e-03f, -1.05203927e-01f, -1.82740510e-01f, 1.89064238e-02f,
  2.05573678e-01f, 1.54081895e-03f, -2.34750137e-02f, -5.13153635e-02f, 1.06064186e-01f, 8.84538442e-02f, 7.34731788e-03f, -2.15632483e-01f, 1.05382666e-01f, 1.30244747e-01f,
  4.20254581e-02f, -1.40898734e-01f, 2.41910871e-02f, -1.34742126e-01f, 3.90580073e-02f, 5.12103178e-02f, 2.65278816e-01f, 1.73498571e-01f, 1.42615438e-01f, 7.57284388e-02f,
  1.13024436e-01f, -1.38869718e-01f, -1.74810573e-01f, 1.42985791e-01f, 5.25296070e-02f, 1.57778248e-01f, 2.26299688e-01f, 1.75414828e-03f, -6.13513924e-02f, 8.46529007e-03f,
  1.53358787e-01f, 2.02883974e-01f, 1.78975552e-01f, 1.48182034e-01f, 8.53518173e-02f, -4.91307899e-02f, 1.08291246e-01f, -1.57331273e-01f, -3.75886969e-02f, -5.33946790e-03f,
  1.03944957e-01f, -1.02448374e-01f, 2.57111132e-01f, 2.15191647e-01f, 1.58342853e-01f, 4.62306738e-02f, -3.53794508e-02f, 1.34227499e-01f, 1.21712439e-01f, 1.51466444e-01f,
  -1.65365934e-02f, 6.94107339e-02f, 2.60337293e-01f, -1.01601342e-02f, -2.12902352e-01f, 3.87087725e-02f, -1.20969405e-02f, 5.14905564e-02f, 8.97485092e-02f, -2.43771188e-02f,
  -1.21139906e-01f, 1.96858302e-01f, 3.60616334e-02f, -1.61000177e-01f, 1.55184008e-02f, 7.01354891e-02f, -3.27641629e-02f, 6.68277889e-02f, -7.24067241e-02f, 2.07659960e-01f,
  4.75707911e-02f, 3.43830496e-01f, 3.38053703e-02f, 1.27196968e-01f, 8.51431489e-02f, 9.75049585e-02f, 1.91378132e-01f, -4.65758778e-02f, -8.86552036e-02f, -2.66298428e-02f,
  -1.58573583e-01f, 2.79399455e-01f, 2.65966862e-01f, 2.82304049e-01f, 2.00877249e-01f, 3.41548890e-01f, 2.80719399e-01f, 2.33109087e-01f, 1.18712606e-02f, 8.35309401e-02f,
  5.33901453e-02f, 6.41736090e-02f, 2.06006899e-01f, -1.31836236e-01f, -7.43438117e-03f, 1.15250848e-01f, 7.40745887e-02f, 1.47126243e-01f, -6.36843890e-02f, 9.68267098e-02f,
  -6.50481358e-02f, 1.42365456e-01f, -5.32752424e-02f, -1.56722218e-01f, -2.40105391e-01f, 1.21642858e-01f, -8.62603933e-02f, -5.46845719e-02f, -1.48482993e-01f, -2.09723175e-01f,
  4.16595846e-01f, -5.68156987e-02f, 5.52183075e-04f, 2.05726817e-01f, -2.52249449e-01f, -4.57689073e-03f, -3.74107920e-02f, 2.29431376e-01f, 1.80675045e-01f, -7.57224411e-02f,
  -1.55602932e-01f, 2.76823789e-02f, -9.46087539e-02f, -8.86493325e-02f, -5.22495173e-02f, -2.17470765e-01f, -2.26570982e-02f, 1.10863701e-01f, 9.63251069e-02f, -1.04917310e-01f,
  -3.59055288e-02f, 7.18567008e-03f, -5.69419528e-04f, -1.35966390e-01f, 3.09937168e-02f, -1.66607380e-01f, -6.38261288e-02f, 1.84275046e-01f, -4.43826951e-02f, 1.53822094e-01f,
  4.66123968e-02f, 2.11222649e-01f, 3.91281873e-01f, -6.22759312e-02f, -9.87796462e-04f, 2.10874215e-01f, 8.78219530e-02f, -5.83098605e-02f, 1.30248606e-01f, -1.98498651e-01f,
  1.25443358e-02f, 1.41950414e-01f, -6.65945350e-04f, 3.91242951e-02f, 8.86690915e-02f, -8.28117207e-02f, -1.59285247e-01f, -4.40331455e-03f, -2.60566827e-02f, -5.36521263e-02f,
  1.12767592e-01f, 2.80225668e-02f, 9.53291282e-02f, -4.59766909e-02f, -4.80235554e-02f, -1.55043960e-01f, 1.13986745e-01f, 1.23042159e-01f, -7.20329210e-02f, -7.61864111e-02f,
  7.86722228e-02f, -6.15937412e-02f, -6.20339215e-02f, -1.23225853e-01f, 1.19593255e-01f, -1.66694522e-01f, 1.22480474e-01f, 3.27844173e-02f, -2.65501410e-01f, -6.33763075e-02f,
  1.91750169e-01f, -4.38467301e-02f, -8.44653696e-02f, 3.48555654e-01f, 1.99537411e-01f, -1.00147009e-01f, 1.64495006e-01f, -8.55572056e-03f, -1.16542429e-01f, 1.99301131e-02f,
  -1.23979012e-02f, -5.21256253e-02f, 1.37603935e-02f, -1.82923079e-01f, -1.46238118e-01f, -1.19260676e-01f, 1.42054046e-02f, 8.53018686e-02f, 1.58669315e-02f, 1.27116114e-01f,
  -6.40977472e-02f, -2.41035298e-01f, -9.16024297e-02f, 1.31995389e-02f, 1.96406245e-02f, 5.73324859e-02f, 9.13310237e-03f, 1.56561837e-01f, 1.76468179e-01f, 8.79853517e-02f,
  1.37769639e-01f, 1.07706144e-01f, -4.24952395e-02f, -6.75296485e-02f, -2.40419228e-02f, 1.27558291e-01f, 5.71203372e-03f, 2.69557219e-02f, 1.22689001e-01f, 9.14581958e-03f,
  -8.15912709e-02f, 9.00941715e-02f, 2.32806474e-01f, 5.44709861e-02f, 2.82911092e-01f, 1.21853620e-01f, -4.99921255e-02f, 1.23793945e-01f, -8.03318396e-02f, -2.28633657e-01f,
  -4.97085266e-02f, -4.32384871e-02f, 2.61348337e-01f, -8.74851197e-02f, 1.52058452e-01f, 7.34067261e-02f, 6.60440847e-02f, -5.14743403e-02f, 2.09454820e-01f, 7.88057595e-02f,
  2.65357912e-01f, 1.11671880e-01f, -1.96013600e-01f, 1.85113940e-02f, 2.71357417e-01f, -5.41535690e-02f, -2.74109870e-01f, 1.98031560e-01f, 7.26102144e-02f, -8.20788220e-02f,
  1.64920762e-01f, -4.97085042e-02f, -7.95338377e-02f, 1.10646136e-01f, -9.28844698e-03f, -1.64321974e-01f, -2.17145104e-02f, 4.83962111e-02f, -7.40544274e-02f, -7.06502870e-02f,
  -1.80972651e-01f, 8.17325935e-02f, 1.93213910e-01f, 2.09912837e-01f, 8.06611478e-02f, 9.79441451e-04f, 3.43455151e-02f, 7.52365738e-02f, 7.26286694e-02f, 3.88076976e-02f,
  -1.20336320e-02f, -3.00447457e-02f, -1.36498675e-01f, -9.30541009e-02f, -6.49106652e-02f, -3.85185257e-02f, 1.06530450e-01f, 2.26167440e-02f, 1.76126450e-01f, -1.73791423e-01f,
  -1.03498800e-02f, -6.01443090e-02f, -4.99779344e-01f, -1.02700688e-01f, -3.96772400e-02f, -4.24436554e-02f, -5.28148189e-02f, -2.80573398e-01f, -3.47099811e-01f, -1.31233469e-01f,
  -1.04662202e-01f, -8.74537602e-02f, -3.17238122e-01f, -7.95827582e-02f, -1.61803633e-01f, 7.09600225e-02f, 1.12887025e-01f, -3.10086496e-02f, -9.98727307e-02f, -1.04073428e-01f,
  -1.93997920e-01f, -2.02370025e-02f, 5.04984893e-02f, 1.70151621e-01f, -1.36569738e-01f, 1.31740078e-01f, 1.14979766e-01f, -9.69168544e-03f, -5.48769124e-02f, -4.29286100e-02f,
  2.36706421e-01f, -7.36924168e-03f, -1.22612029e-01f, 5.08629531e-03f, -1.89914107e-01f, 4.76783253e-02f, 8.07600543e-02f, 2.34538596e-02f, -5.04136756e-02f, 2.16571480e-01f,
  5.26981354e-02f, 1.02680698e-01f, 4.63275164e-02f, 3.04026771e-02f, 2.06816494e-01f, -1.54176235e-01f, -1.73590392e-01f, 1.03031956e-02f, 2.71700211e-02f, 1.62329450e-01f,
  2.78807507e-04f, 7.27376342e-03f, -8.83868933e-02f, -2.45168090e-01f, -3.34023058e-01f, -1.23224735e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.91307768e-01f, 1.77138731e-01f, 1.17385238e-01f, 5.54556474e-02f, -1.24483548e-01f, 1.97018489e-01f, -2.06824645e-01f, 1.50088659e-02f, -8.35560933e-02f, 1.24757484e-01f,
  3.74676287e-01f, 1.33618042e-01f, 7.37769008e-02f, 2.42248420e-02f, 1.57967970e-01f, 2.48086192e-02f, 1.33222774e-01f, 1.45258188e-01f, 6.86920597e-04f, 2.37679124e-01f,
  1.01971470e-01f, 1.69087499e-01f, 1.70427695e-01f, -2.60320276e-01f, -2.59126216e-01f, 1.38469905e-01f, -1.72374323e-01f, -2.30244800e-01f, -1.12174086e-01f, 1.44865960e-01f,
  -1.03948027e-01f, 4.13038060e-02f, 3.55817080e-02f, 3.04539260e-02f, -8.54492560e-03f, 1.93692580e-01f, -2.28995550e-02f, 5.42170443e-02f, -1.83114737e-01f, -2.61727739e-02f,
  2.77719855e-01f, 5.30875362e-02f, 7.58413672e-02f, -3.46031003e-02f, 7.68254697e-02f, -5.24039455e-02f, -3.30917120e-01f, -6.52040988e-02f, 2.51994491e-01f, 8.94767791e-02f,
  -1.92162722e-01f, 5.90164997e-02f, -2.53170729e-02f, -4.48985882e-02f, 2.03943983e-01f, 2.72346996e-02f, -2.42884740e-01f, -1.80488210e-02f, -1.93290606e-01f, -1.78259298e-01f,
  -1.34181067e-01f, 8.90966207e-02f, -7.38963857e-02f, 2.36732706e-01f, 1.50049433e-01f, -4.52659987e-02f, -2.93047819e-02f, 1.80441856e-01f, 1.35797188e-01f, -3.29125207e-03f,
  -2.53563486e-02f, 1.65187106e-01f, -7.60491267e-02f, 1.35684237e-01f, -5.90435080e-02f, 1.52893186e-01f, 5.31214029e-02f, 1.72626480e-01f, 8.14363882e-02f, 1.42675593e-01f,
  1.89221829e-01f, 1.77854955e-01f, 1.86497241e-01f, 1.79343596e-01f, -1.28453866e-01f, -4.64868009e-01f, -2.02701256e-01f, 1.90943182e-01f, 5.07667840e-01f, 3.14560205e-01f,
  -2.00074524e-01f, 1.52464435e-01f, -1.15776867e-01f, 6.97323605e-02f, -3.69460322e-02f, 3.12590718e-01f, -2.23925442e-01f, 3.79343741e-02f, 1.48817450e-01f, -2.00452119e-01f,
  -1.29284590e-01f, -2.92675942e-01f, -1.46339253e-01f, 3.42555344e-01f, -2.51836568e-01f, 2.07374915e-01f, 4.32029180e-02f, 3.19701076e-01f, 2.30650660e-02f, -1.45019948e-01f,
  -1.60341352e-01f, -2.39998698e-01f, 2.12617189e-01f, 3.09560657e-01f, 1.72137409e-01f, -7.18565732e-02f, 3.92201915e-02f, 4.10989858e-02f, -1.84255298e-02f, 1.16674677e-02f,
  1.54424421e-02f, -1.17963515e-01f, 1.49419725e-01f, -8.50857422e-02f, 6.08310513e-02f, -2.82516271e-01f, -1.33441210e-01f, 8.21814165e-02f, -1.01786576e-01f, 5.24526983e-02f,
  -3.29619162e-02f, -1.29161477e-01f, 5.76676242e-02f, -1.50426686e-01f, 4.43178415e-02f, -9.18038413e-02f, 1.15009367e-01f, -1.79049224e-01f, -1.10591516e-01f, 1.17533721e-01f,
  -1.48200572e-01f, 1.34767164e-02f, -6.80369511e-02f, -4.79541421e-02f, -5.26796803e-02f, -1.51135758e-01f, 6.42208382e-02f, -4.42063272e-01f, -1.10773399e-01f, 1.45618707e-01f,
  2.61588097e-01f, -2.89880186e-01f, -2.16595992e-01f, 7.49605522e-02f, 1.62614539e-01f, -1.89373240e-01f, -2.94988394e-01f, -7.02117980e-02f, 3.20086963e-02f, -8.85464475e-02f,
  2.35409345e-02f, -9.76747498e-02f, -4.64536808e-02f, -3.42534818e-02f, -9.04539973e-02f, -6.04275940e-03f, -8.42672139e-02f, 2.04488665e-01f, -2.57344782e-01f, 5.81462868e-02f,
  3.55529875e-01f, -7.75282010e-02f, -1.22084863e-01f, 4.82421070e-01f, 3.46297890e-01f, -1.78729985e-02f, 1.08322717e-01f, 2.70419084e-02f, 1.37553364e-01f, -7.94522092e-02f,
  -3.61378193e-01f, 5.43353073e-02f, -2.99330235e-01f, 1.72679201e-01f, 2.14010671e-01f, 5.65559492e-02f, -1.25375926e-01f, -1.04063861e-01f, 3.35735418e-02f, 1.24292403e-01f,
  1.52784005e-01f, 2.67138660e-01f, 1.40382782e-01f, 6.98917657e-02f, 9.10136476e-02f, 1.93490073e-01f, 1.75697193e-01f, 1.95104584e-01f, 1.29639685e-01f, 2.40652896e-02f,
  1.22661553e-01f, -3.46616171e-02f, 1.06246233e-01f, 1.23703238e-02f, -1.59154035e-04f, -1.53058514e-01f, -4.17623907e-01f, -2.10527614e-01f, 2.35961393e-01f, -4.06762259e-03f,
  2.17285305e-01f, -7.71843567e-02f, -7.86849335e-02f, 1.85193717e-01f, -1.37231395e-01f, 7.25167841e-02f, -1.74810454e-01f, -6.20041788e-02f, 1.38342366e-01f, 6.64118007e-02f,
  4.52031232e-02f, -3.25528324e-01f, 4.16849077e-01f, -2.54406780e-02f, -1.47612467e-01f, 2.14312717e-01f, -7.81364664e-02f, -1.91314578e-01f, -8.64610523e-02f, 1.40207827e-01f,
  1.66610822e-01f, 3.81012082e-01f, -2.91677088e-01f, 6.31036237e-02f, -1.20346352e-01f, 2.51046736e-02f, -1.53319374e-01f, -1.35978550e-01f, 1.86301008e-01f, -1.00398712e-01f,
  1.49266392e-01f, -2.11501434e-01f, -2.22763807e-01f, 7.89564028e-02f, 2.43232604e-02f, -2.39342928e-01f, -2.06068948e-01f, -4.70285028e-01f, 9.24495533e-02f, -2.79229730e-01f,
  2.82743271e-03f, 1.37350574e-01f, 7.27719627e-03f, 2.81043828e-01f, 3.09968531e-01f, 1.07728444e-01f, 5.52289151e-02f, 1.07626878e-01f, 1.17181383e-01f, 2.43998960e-01f,
  1.69405252e-01f, 1.22235067e-01f, 9.30283815e-02f, 5.48476130e-02f, 1.74844965e-01f, 7.27168769e-02f, 3.97889651e-02f, 1.01355337e-01f, 3.49053204e-01f, 6.96579814e-02f,
  9.88253281e-02f, 1.05830640e-01f, 8.84816423e-02f, -3.26835290e-02f, 1.32095978e-01f, 2.22584471e-01f, 4.04670136e-03f, 7.86652789e-02f, -1.61370367e-01f, 9.17988643e-02f,
  -9.83058512e-02f, -1.17891259e-01f, 6.98550493e-02f, 8.61641765e-03f, 2.72075623e-01f, -2.19583690e-01f, 3.26497436e-01f, -1.11060090e-01f, 1.63178787e-01f, 2.61021644e-01f,
  -1.68011382e-01f, 1.70404720e-03f, 2.15057135e-02f, -1.90955266e-01f, -2.33945817e-01f, 1.74333274e-01f, 2.11810619e-01f, -1.56089962e-01f, 2.97419369e-01f, -1.36474982e-01f,
  1.12277027e-02f, 9.67567265e-02f, 8.80460367e-02f, -3.28245103e-01f, 9.10644829e-02f, 9.55237541e-03f, -1.81667313e-01f, -3.12154949e-01f, -1.13904767e-01f, -1.03286639e-01f,
  1.50715649e-01f, 8.19429532e-02f, -6.70367703e-02f, 1.68360192e-02f, -1.38804451e-01f, 2.12271720e-01f, 1.53816476e-01f, 1.10136606e-01f, 8.04634988e-02f, -1.49016127e-01f,
  2.01890469e-01f, 1.40319943e-01f, 1.57448396e-01f, -1.56530738e-01f, -1.75673380e-01f, 1.78661630e-01f, 4.48549725e-02f, -1.76542491e-01f, 4.18600626e-02f, 1.64165109e-01f,
  -5.08182943e-02f, -4.89934459e-02f, -2.15688609e-02f, 3.92261624e-01f, -1.57125339e-01f, 3.82418595e-02f, 2.26602659e-01f, 2.17601418e-01f, 2.00656876e-01f, -3.76722291e-02f,
  -1.31698906e-01f, -4.54128534e-02f, -7.53148422e-02f, 2.24928528e-01f, 1.05406433e-01f, -6.94224015e-02f, -5.42626530e-02f, 3.32309812e-01f, -1.60448238e-01f, 2.68015146e-01f,
  -3.01948369e-01f, 1.07746877e-01f, 1.60795346e-01f, -1.98292751e-02f, -1.29003704e-01f, -8.27605724e-02f, 2.78774738e-01f, 6.72507733e-02f, -2.97354069e-02f, 1.89302415e-01f,
  5.61753288e-02f, -5.66475429e-02f, 3.98194939e-02f, 3.96243855e-02f, -1.08260043e-01f, 1.31177112e-01f, -1.71841010e-01f, 4.11462970e-03f, 1.52109161e-01f, 1.61646590e-01f,
  1.30330399e-02f, 2.35682607e-01f, 1.19882815e-01f, 3.64830345e-01f, 3.00083011e-01f, -7.77351111e-02f, 4.02393900e-02f, 7.38997459e-02f, 1.04969539e-01f, -1.20123597e-02f,
  1.85917597e-02f, -1.26617044e-01f, -3.16480160e-01f, -1.10325022e-02f, 9.21175480e-02f, -3.05364411e-02f, 1.39658630e-01f, 2.66339272e-01f, 3.71924303e-02f, 2.22215638e-01f,
  7.30782598e-02f, -6.72027469e-02f, 3.72879393e-03f, -1.06726073e-01f, 3.93373519e-01f, 3.16724889e-02f, -1.28063008e-01f, -3.60843875e-02f, -3.65584530e-02f, 2.39958894e-02f,
  1.36954099e-01f, -7.26352483e-02f, -1.39862821e-02f, -6.91679642e-02f, 6.97937682e-02f, 2.12720975e-01f, 1.79401591e-01f, -3.06808233e-01f, -2.01381475e-01f, 2.22662449e-01f,
  -1.92261443e-01f, -2.32474148e-01f, -1.96860135e-01f, -8.21577087e-02f, 2.15344802e-01f, -1.69869423e-01f, -1.40598223e-01f, 2.29194723e-02f, 7.32504937e-04f, 6.06816122e-03f,
  9.30470899e-02f, 3.88182938e-01f, 1.80460483e-01f, -2.47927472e-01f, 1.91758245e-01f, -1.31187648e-01f, -9.05130953e-02f, -3.79425660e-02f, -1.60326064e-01f, -3.29588830e-01f,
  2.99209822e-02f, -2.67701477e-01f, 5.86616918e-02f, -1.90309808e-01f, 4.45342176e-02f, -1.29125372e-01f, 1.75031587e-01f, 7.55586252e-02f, -1.99902788e-01f, -3.72518063e-01f,
  -7.14940354e-02f, -4.57599610e-01f, -3.41389537e-01f, -1.26383439e-01f, -1.66320771e-01f, 2.24174693e-01f, 1.56972349e-01f, 2.82634676e-01f, -2.98541095e-02f, 8.45023170e-02f,
  3.55279505e-01f, -2.64146894e-01f, 3.48855704e-02f, 2.50417739e-01f, 1.50360823e-01f, 3.32600445e-01f, 6.22407645e-02f, 3.50636601e-01f, -2.33633161e-01f, -3.55160311e-02f,
  7.90795460e-02f, 2.45721117e-01f, 9.77850258e-02f, 3.54375062e-03f, 1.02568604e-01f, 1.76596180e-01f, 2.58237749e-01f, 1.99117586e-01f, -4.01887931e-02f, -2.23780796e-02f,
  -2.29881331e-01f, 5.55525064e-01f, 2.89594203e-01f, -2.75425524e-01f, -1.16859086e-01f, 2.77790070e-01f, 1.01353779e-01f, 9.96696725e-02f, 1.93315983e-01f, 1.19167320e-01f,
  8.63960534e-02f, 7.99127892e-02f, 5.08411741e-03f, -8.56975019e-02f, 2.29001030e-01f, -1.25897497e-01f, -8.92373249e-02f, -3.84094915e-03f, -2.35691935e-01f, 2.11053789e-01f,
  -1.27539217e-01f, 1.97880462e-01f, 3.83738009e-03f, 6.50625452e-02f, 3.28309461e-02f, -1.24748670e-01f, -1.64049119e-02f, 8.64959881e-02f, -3.09853554e-01f, -1.52055454e-02f,
  -7.58702904e-02f, -4.97510731e-02f, 1.85889453e-01f, 2.54072975e-02f, 1.50454998e-01f, 1.47826120e-01f, 9.52272788e-02f, -8.32567289e-02f, 1.24370322e-01f, -2.11494025e-02f,
  6.41106293e-02f, -3.57941836e-01f, -1.41316324e-01f, 1.00692675e-01f, 1.03731588e-01f, 2.13259593e-01f, 2.17778236e-01f, 3.00385039e-02f, 5.24913147e-03f, 6.13835789e-02f,
  1.79338798e-01f, 3.51129808e-02f, 5.86121045e-02f, -1.26078129e-01f, -5.95939681e-02f, -1.29525617e-01f, 4.07520205e-01f, -8.58775303e-02f, -1.23641521e-01f, -8.64009410e-02f,
  -1.89129010e-01f, -1.87731050e-02f, -1.09088510e-01f, -3.93603258e-02f, -3.32713425e-02f, -8.95962268e-02f, -1.39377668e-01f, 1.00987284e-02f, 2.09568981e-02f, -1.63445279e-01f,
  1.47029161e-01f, -8.91467109e-02f, 1.81333765e-01f, -4.42006718e-03f, 2.41692904e-02f, 4.74015400e-02f, -6.72729090e-02f, 1.36887327e-01f, 4.92096581e-02f, -4.44789529e-02f,
  -2.25752592e-03f, -8.05185586e-02f, 1.49949193e-01f, -1.27306089e-01f, 2.15641126e-01f, -3.68040085e-01f, 1.25636727e-01f, 9.66030732e-02f, 2.24108130e-01f, 1.48496255e-01f,
  -2.58451253e-01f, -1.94018140e-01f, -1.13748550e-01f, -2.00852677e-01f, -9.60592553e-02f, -2.12355047e-01f, -1.30430415e-01f, 2.93286890e-01f, 1.13555640e-01f, -1.85811538e-02f,
  -1.47238150e-01f, 1.65124252e-01f, 1.30683973e-01f, 7.37077445e-02f, -1.64515346e-01f, 1.60190836e-01f, -1.11130036e-01f, -3.13229024e-01f, -8.68171975e-02f, 1.89860705e-02f,
  8.25836584e-02f, -1.14080533e-01f, -1.71754643e-01f, 6.97510666e-04f, -3.30957435e-02f, 8.67068768e-02f, 1.60852477e-01f, -1.59989104e-01f, -3.71846050e-01f, -1.52665200e-02f,
  3.56505928e-03f, -2.17145398e-01f, 1.88431945e-02f, -9.15987119e-02f, -2.37234354e-01f, -6.15939312e-02f, 9.86390561e-02f, -2.62348503e-01f, -1.62020355e-01f, 2.33440384e-01f,
  2.59189636e-01f, -2.06761688e-01f, 8.32769871e-02f, -3.08835983e-01f, 1.79369807e-01f, -4.62892652e-02f, 2.24914569e-02f, 9.09841210e-02f, 2.08363812e-02f, 1.80824362e-02f,
  -8.00326988e-02f, -1.30434975e-01f, 1.63027346e-01f, -2.48378620e-01f, 7.66703486e-02f, -1.58821613e-01f, 2.98237681e-01f, -1.49629395e-02f, 1.11281574e-01f, -2.14409947e-01f,
  1.10668935e-01f, 1.57649592e-01f, -2.97394954e-02f, 1.38696888e-02f, -1.12865880e-01f, -2.20192075e-01f, -5.45084709e-03f, -4.26818207e-02f, -1.63843527e-01f, -2.38285527e-01f,
  2.41872966e-02f, 1.66384354e-01f, 2.63279140e-01f, -3.57072294e-01f, 9.09191594e-02f, -9.31198001e-02f, -1.21273868e-01f, 1.32488385e-01f, -4.70407724e-01f, 1.02500573e-01f,
  -1.14727624e-01f, 2.72630543e-01f, 5.02649248e-02f, 1.05882317e-01f, 4.29494791e-02f, 2.97174063e-02f, 1.43505663e-01f, 1.78965613e-01f, 1.32404357e-01f, 1.20321542e-01f,
  -3.72566551e-01f, -3.64821069e-02f, 5.35968959e-01f, 1.06408693e-01f, -2.14644466e-02f, -1.16215266e-01f, 3.80583853e-02f, 2.09024832e-01f, 1.73869938e-01f, -2.08942480e-02f,
  -1.65389940e-01f, 2.48429090e-01f, -1.28511786e-01f, 3.13533336e-01f, -3.94729555e-01f, -1.74395025e-01f, -8.10299590e-02f, 1.47363216e-01f, 1.93166912e-01f, 7.82640651e-02f,
  1.85920537e-01f, -4.90701869e-02f, 1.78738043e-01f, 6.93974718e-02f, -1.67107075e-01f, 1.53625846e-01f, 8.35248455e-02f, 1.30382359e-01f, -6.97705373e-02f, -1.02874286e-01f,
  -4.90713641e-02f, -1.25077680e-01f, 3.09510306e-02f, 8.86208713e-02f, 2.02136617e-02f, 8.19124207e-02f, 1.34111986e-01f, -2.03302130e-01f, -2.02422902e-01f, -1.66394830e-01f,
  -1.74850732e-01f, -2.29893788e-03f, -9.27307531e-02f, -1.22265061e-02f, 8.20463151e-02f, 1.74353011e-02f, -1.85809761e-01f, 2.53529221e-01f, -8.96218047e-02f, -4.04809527e-02f,
  -8.12402815e-02f, 1.60225973e-01f, 3.22316170e-01f, -2.60714620e-01f, 1.14582796e-02f, -7.74330050e-02f, 6.05814345e-02f, -1.19132854e-01f, -1.65301397e-01f, 4.39064540e-02f,
  -1.81579739e-01f, -2.58491009e-01f, -1.86689745e-03f, -3.88609171e-02f, 4.85260263e-02f, 3.22287589e-01f, 1.47321567e-01f, 1.53380126e-01f, -3.05028744e-02f, -1.38123125e-01f,
  3.00355591e-02f, 2.15049013e-01f, 1.28147140e-01f, 7.26114288e-02f, 3.46532494e-01f, 3.35613266e-02f, 1.43692926e-01f, -8.51930678e-02f, -1.35122463e-01f, 2.50237346e-01f,
  -1.57154873e-01f, -2.62791604e-01f, -1.51915178e-01f, 5.77667467e-02f, -1.83896005e-01f, -9.42803994e-02f, -1.20597556e-01f, -9.22145694e-02f, 2.21090525e-01f, -5.68758622e-02f,
  -1.60329983e-01f, 6.96554780e-03f, -4.63981070e-02f, 1.42826706e-01f, 2.60383338e-01f, 4.40321602e-02f, 2.47396040e-03f, -1.07120693e-01f, 2.05340654e-01f, 5.00970483e-02f,
  1.03352934e-01f, 3.48807275e-02f, 3.49243671e-01f, 3.72164816e-01f, -2.96703428e-02f, 9.92923081e-02f, 2.38792479e-01f, 1.56017663e-02f, 1.58566117e-01f, 7.89926425e-02f,
  -2.11773470e-01f, -3.19645345e-01f, 5.29608130e-02f, -4.23825681e-02f, 2.36854963e-02f, -9.25375670e-02f, -3.48690361e-01f, 3.90539497e-01f, 1.52583018e-01f, 2.04012513e-01f,
  9.77773517e-02f, 1.61512792e-01f, 1.15486376e-01f, 6.16367683e-02f, 2.36309506e-02f, 2.40954772e-01f, 2.40535382e-02f, 1.34181589e-01f, -1.82048734e-02f, 4.31937166e-02f,
  1.84816197e-01f, 1.24482229e-01f, 2.92285591e-01f, 2.34335572e-01f, 2.33298205e-02f, 2.70564020e-01f, 1.27615720e-01f, 2.34798595e-01f, 3.77988890e-02f, -1.35367038e-02f,
  -2.83519149e-01f, 1.08290143e-01f, -6.65382966e-02f, -1.69360161e-01f, 3.08844037e-02f, -1.52903423e-01f, 2.44320408e-01f, 1.11043677e-02f, 2.76534587e-01f, 2.44998798e-01f,
  9.41682905e-02f, 2.98850775e-01f, -2.58748710e-01f, 1.39103651e-01f, 5.84475510e-03f, -5.13160825e-02f, -1.83120236e-01f, 1.13382630e-01f, 1.14843491e-02f, 6.57850131e-02f,
  1.05466098e-01f, -1.69853806e-01f, 9.18087289e-02f, 1.49685889e-01f, -8.17871988e-02f, -2.53965884e-01f, -1.27440900e-01f, -8.48040506e-02f, -3.31232727e-01f, -8.29255730e-02f,
  1.72953382e-02f, -1.20835029e-01f, 1.06295772e-01f, 1.44539773e-01f, -5.04999422e-02f, 2.19957665e-01f, -3.61971706e-02f, 1.13929160e-01f, 1.38896108e-01f, 1.43318519e-01f,
  -5.72017580e-02f, -5.75562306e-02f, -6.90182149e-02f, 9.92524102e-02f, -9.17828158e-02f, 1.42430097e-01f, 3.07793736e-01f, -9.02096089e-03f, 3.01465124e-01f, -8.63783620e-03f,
  6.96858333e-04f, 8.75724331e-02f, -1.31260371e-02f, 1.24253884e-01f, 1.19219705e-01f, 8.18965659e-02f, 3.34945461e-03f, 4.22709957e-02f, 1.11063287e-01f, 3.96842062e-02f,
  -4.15392406e-02f, 1.25033811e-01f, -1.56192482e-01f, 1.02460071e-01f, 4.78040352e-02f, 2.20103059e-02f, 2.43725292e-02f, -6.26344085e-02f, 5.22823147e-02f, -1.65449470e-01f,
  2.78921813e-01f, -1.97971761e-01f, 3.14586431e-01f, 2.28470936e-02f, 1.58219591e-01f, 4.48199958e-02f, -1.07994184e-01f, 1.30445302e-01f, 3.37646864e-02f, -5.58193140e-02f,
  2.13072188e-02f, -2.90216636e-02f, 3.04952592e-01f, -1.98300108e-02f, 3.53178918e-01f, -1.50154844e-01f, -1.72619149e-01f, 1.17265642e-01f, 2.91271448e-01f, 1.04314517e-02f,
  -7.33805075e-02f, -2.61606902e-01f, -9.28125605e-02f, -2.03754097e-01f, -2.52400398e-01f, -3.11707910e-02f, -7.92652518e-02f, 9.11858007e-02f, -1.87269021e-02f, -1.51006162e-01f,
  -1.93956956e-01f, 1.72097981e-01f, 1.82458222e-01f, 9.78116244e-02f, -7.24007562e-02f, -2.43450806e-01f, 1.91903234e-01f, 4.64539528e-02f, -8.64285678e-02f, 2.00012043e-01f,
  1.28763348e-01f, 3.50807160e-01f, 2.37912741e-02f, -2.46584564e-02f, -1.78182527e-01f, 2.31909771e-02f, 1.94723949e-01f, 1.24663822e-01f, 3.59501205e-02f, 9.28382203e-02f,
  2.83041835e-01f, 1.24056645e-01f, -9.42430496e-02f, 2.89656609e-01f, 6.27644584e-02f, 8.14107582e-02f, -1.17705120e-02f, 7.77979568e-02f, 2.54204143e-02f, -1.79970726e-01f,
  -5.73090883e-03f, 8.68176520e-02f, -3.83862294e-02f, 2.58646667e-01f, 8.08783174e-02f, 3.28640491e-01f, 8.44763294e-02f, 1.38617918e-01f, -1.07105717e-01f, -1.41771615e-01f,
  3.02766617e-02f, -1.27916276e-01f, -2.32640728e-01f, 5.31919450e-02f, 1.61355168e-01f, -1.08637914e-01f, -7.00567216e-02f, -4.26085107e-02f, -1.07461944e-01f, 7.40749612e-02f,
  -8.94375965e-02f, -1.67383745e-01f, -8.06597471e-02f, 1.06906611e-02f, 9.57456231e-02f, -8.66937116e-02f, 1.05872005e-01f, 3.64477709e-02f, 2.02142805e-01f, 7.97199234e-02f,
  2.18638077e-01f, -3.21419910e-02f, 2.39265268e-03f, 2.57863700e-01f, 1.49098309e-02f, 8.67908150e-02f, -5.76396957e-02f, 6.15110248e-02f, 1.77033633e-01f, 5.98881505e-02f,
  -1.15941249e-01f, 2.99094748e-02f, 2.76289545e-02f, 1.91825144e-02f, 1.48463488e-01f, 4.89437878e-02f, -4.14470322e-02f, 8.42293277e-02f, 1.57992527e-01f, 1.69081660e-03f,
  1.89662740e-01f, 6.33666366e-02f, -6.69731945e-02f, 1.97976142e-01f, 2.28428349e-01f, -7.82607570e-02f, 1.52892545e-01f, -8.90288129e-02f, 3.77128348e-02f, 9.49651003e-02f,
  -4.72935364e-02f, 2.12071970e-01f, -1.82245336e-02f, 7.30348378e-02f, -1.49363771e-01f, -1.85193852e-01f, 1.47192311e-02f, -2.38201410e-01f, -8.71541277e-02f, 1.22839250e-01f,
  -8.02026410e-03f, -1.84126347e-01f, 7.86871761e-02f, -1.51310088e-02f, -8.27823803e-02f, 1.59344003e-01f, 2.65825301e-01f, -5.17976731e-02f, -1.62295327e-02f, -2.21649751e-01f,
  2.99630672e-01f, -1.37204483e-01f, 1.11775085e-01f, -2.71041483e-01f, 6.96125180e-02f, 1.58860505e-01f, 1.83346361e-01f, -3.18509825e-02f, -6.37851283e-02f, -9.21211392e-02f,
  -1.65227771e-01f, -1.43045679e-01f, -1.27523124e-01f, 3.36545222e-02f, 9.83616337e-02f, 1.05763197e-01f, -8.15348402e-02f, -2.47711241e-01f, -1.16947308e-01f, 1.33137599e-01f,
  8.02295431e-02f, 2.89295703e-01f, -1.92498088e-01f, 3.48304451e-01f, -4.59666997e-02f, -3.62187773e-02f, -1.02455616e-01f, -1.83617711e-01f, -2.24604294e-01f, 2.98766568e-02f,
  -4.70124930e-02f, -4.10223335e-01f, 9.83665045e-03f, 6.18633889e-02f, 7.86934048e-02f, -3.05038430e-02f, -1.17707439e-01f, 6.00150712e-02f, -6.46620542e-02f, -3.64124887e-02f,
  -9.61580127e-02f, -2.53190190e-01f, 5.31039014e-02f, -2.47771487e-01f, -7.23939836e-02f, 6.79291710e-02f, 1.40023187e-01f, 3.44856791e-02f, -7.46246353e-02f, -7.34689385e-02f,
  9.10187289e-02f, -1.46778643e-01f, -1.72170445e-01f, -4.61149476e-02f, -2.35857889e-01f, -1.04990592e-02f, -7.05238432e-02f, -2.13259123e-02f, -5.95443789e-03f, -2.35197712e-02f,
  -4.78043258e-02f, -2.53202796e-01f, -5.56348823e-02f, 2.52342466e-02f, -1.01087682e-01f, -1.81304328e-02f, 2.02006157e-02f, -2.44930342e-01f, 2.70505130e-01f, 2.91899115e-01f,
  1.42750330e-02f, 2.51960844e-01f, 1.32442176e-01f, 1.85058340e-01f, 1.50591075e-01f, 2.25520164e-01f, -1.43002152e-01f, 1.08457785e-02f, 2.19472423e-01f, 2.20580295e-01f,
  2.59589493e-01f, 8.28018859e-02f, 1.55001640e-01f, -5.49636595e-02f, 1.03281617e-01f, -8.43753442e-02f, -3.53573740e-01f, 7.53154084e-02f, 1.20992791e-02f, 1.80545419e-01f,
  4.84124720e-02f, 6.52079582e-02f, 2.11612340e-02f, 1.38437003e-01f, -2.65832767e-02f, 2.56635416e-02f, 2.08727077e-01f, 6.61630705e-02f, 2.06170782e-01f, 2.99715191e-01f,
  2.09477261e-01f, 1.50817810e-02f, -1.39253795e-01f, 2.22293004e-01f, 1.50151402e-01f, 9.07037258e-02f, 2.56352425e-01f, -1.37997279e-02f, 1.10921510e-01f, 1.81159824e-01f,
  1.61617786e-01f, 1.76943317e-02f, -9.99862626e-02f, 2.18312114e-01f, -3.73307499e-03f, -1.37894720e-01f, -1.90622643e-01f, -2.40551546e-01f, -1.90156326e-01f, -2.66128778e-01f,
  -5.03431745e-02f, -1.22552790e-01f, -2.94890761e-01f, -1.69704249e-03f, -1.81030467e-01f, -9.21488777e-02f, -8.11355412e-02f, 5.55420935e-01f, -1.54893860e-01f, -1.11479022e-01f,
  2.00216174e-01f, 7.38658085e-02f, -2.46403188e-01f, 1.37987807e-01f, 2.59602904e-01f, -5.43484092e-03f, 3.82567912e-01f, 9.84537825e-02f, -8.25420693e-02f, 7.46579692e-02f,
  7.74163473e-03f, 6.88155070e-02f, -1.73307583e-01f, -2.90849894e-01f, 1.33153334e-01f, -3.54719728e-01f, -1.26337498e-01f, -1.71275977e-02f, -4.28755283e-02f, 2.02920958e-01f,
  1.89578105e-02f, 3.12149554e-01f, 5.05823642e-02f, 3.31485271e-02f, 1.00185819e-01f, -6.77647395e-03f, 7.41741732e-02f, -4.46446426e-02f, 2.12639585e-01f, 3.35009336e-01f,
  2.78248824e-02f, 1.63018033e-01f, -2.45024592e-01f, -5.06979711e-02f, 4.14188057e-02f, 3.34873438e-01f, 1.73572987e-01f, 3.20284106e-02f, 1.38503194e-01f, 3.01006407e-01f,
  3.22509557e-02f, 1.49031505e-01f, -8.72545466e-02f, -7.54790939e-03f, -1.25155061e-01f, 1.90858990e-01f, 2.19591692e-01f, -1.07330941e-01f, 2.10816205e-01f, 2.49389499e-01f,
  8.68707523e-02f, 1.87383592e-01f, 2.60496467e-01f, 1.50890961e-01f, 5.43209538e-02f, 3.97301652e-03f, -1.97145447e-01f, -5.00086788e-03f, 1.42860815e-01f, 1.01658385e-02f,
  -8.83699730e-02f, -4.64440100e-02f, 1.77167699e-01f, -6.66270629e-02f, 2.40416303e-02f, 2.08986163e-01f, 1.12339728e-01f, 8.89078230e-02f, 3.88244428e-02f, -2.37384006e-01f,
  -2.41904140e-01f, -8.10624510e-02f, -3.67914028e-02f, -1.36192068e-01f, -2.18914524e-02f, 1.98284835e-01f, 1.88988715e-01f, 2.93885857e-01f, 8.97908062e-02f, 1.73235252e-01f,
  -1.17898948e-01f, 8.97079781e-02f, 1.53230026e-01f, 1.43549889e-01f, 8.86070281e-02f, -2.68628687e-01f, 2.84308791e-01f, 2.79534161e-01f, 1.81563795e-01f, -2.08365694e-01f,
  -1.66966289e-01f, 2.28993803e-01f, -2.45947227e-01f, -3.50230485e-01f, -5.04475534e-02f, 7.62888789e-02f, 1.68220356e-01f, 9.21503976e-02f, 5.47140054e-02f, 1.97109118e-01f,
  -1.65899381e-01f, 1.11972149e-02f, 2.51588911e-01f, 4.22281623e-02f, 3.38757783e-02f, -5.43886684e-02f, 1.43333629e-01f, 6.92817792e-02f, 1.01927340e-01f, 1.40150294e-01f,
  -4.85666431e-02f, -2.45828867e-01f, 2.51861997e-02f, 1.41794488e-01f, -1.23275891e-01f, 3.31199765e-01f, -3.10554236e-01f, -1.80456974e-02f, 2.23368943e-01f, -9.15687159e-02f,
  1.89258289e-02f, 3.78560722e-02f, 2.19104514e-01f, 8.17380697e-02f, -1.42465636e-01f, -2.26349249e-01f, 1.13078974e-01f, -1.11270092e-01f, -2.17032172e-02f, -9.57333744e-02f,
  1.31658226e-01f, 1.96250081e-01f, -5.35507984e-02f, -8.30093585e-03f, 1.54981669e-03f, -2.92502269e-02f, -1.87320426e-01f, 1.81648031e-01f, -3.22031714e-02f, 1.93762824e-01f,
  2.55812496e-01f, 1.40855283e-01f, 1.68605987e-02f, 2.33117700e-01f, -7.34629408e-02f, -8.79287794e-02f, 6.26053708e-03f, -7.15489909e-02f, -1.56217068e-01f, 1.91904083e-01f,
  4.50602286e-02f, 9.41883922e-02f, -1.96504910e-02f, 2.80619591e-01f, 1.02073759e-01f, 2.47308180e-01f, 7.31411353e-02f, -3.38350609e-02f, -1.25752389e-01f, 6.86504692e-02f,
  3.14868122e-01f, -2.76756734e-02f, 2.16264740e-01f, 3.23397368e-02f, 2.20455125e-01f, 8.64901692e-02f, 1.53637335e-01f, 1.93826035e-01f, 2.47138709e-01f, 5.38967401e-02f,
  2.17510872e-02f, 1.91080779e-01f, 1.50101319e-01f, -1.09814629e-01f, -4.52746242e-01f, -5.80565669e-02f, -3.01221520e-01f, 1.36597957e-02f, 1.08050495e-01f, 2.12084591e-01f,
  1.05643570e-01f, -2.07860261e-01f, 2.30856061e-01f, 2.10743338e-01f, -2.64214814e-01f, 2.24705681e-01f, 1.23304896e-01f, 1.62348449e-01f, -9.19958949e-02f, -4.16418523e-01f,
  6.86188936e-02f, -1.69459715e-01f, 1.01558402e-01f, -6.66345954e-02f, 9.18805320e-03f, 1.28185779e-01f, -1.40662387e-01f, -9.36524794e-02f, -6.03309087e-03f, -8.48704427e-02f,
  7.16401637e-02f, 3.14644575e-02f, -1.05365068e-02f, 1.04549052e-02f, 9.46257487e-02f, 1.19967826e-01f, -2.73040384e-01f, 8.74183998e-02f, -2.94335306e-01f, 2.84642607e-01f,
  -8.97865072e-02f, 2.16680244e-01f, 2.80249000e-01f, 2.29368180e-01f, -2.28556052e-01f, -1.32732213e-01f, -2.73872092e-02f, 2.43623734e-01f, -1.15738191e-01f, 3.88130136e-02f,
  -1.32938296e-01f, -1.46473350e-03f, 2.55113356e-02f, -1.02105513e-01f, 3.28217417e-01f, 9.52701643e-02f, 1.00646846e-01f, -1.63663656e-01f, 2.03021988e-01f, 2.59627283e-01f,
  4.27524298e-02f, 9.96400043e-02f, -4.17450182e-02f, 2.09655136e-01f, 1.75463036e-01f, -5.28642237e-02f, -1.63230821e-01f, -2.91037619e-01f, 9.15082023e-02f, 3.51409793e-01f,
  -2.57161230e-01f, -4.66493487e-01f, -1.90822452e-01f, -7.79608041e-02f, -2.66410783e-02f, 1.15882732e-01f, -3.50844920e-01f, 8.66218433e-02f, 1.98353976e-01f, -2.11193878e-02f,
  -1.59944341e-01f, -1.91064194e-01f, -2.01615274e-01f, 1.57389581e-01f, -2.01222003e-01f, 6.28832728e-02f, -4.87540923e-02f, -4.56819236e-02f, 1.72667861e-01f, -2.85978019e-01f,
  -7.64621943e-02f, -2.95960665e-01f, 2.41940707e-01f, 1.77272886e-01f, -3.49056572e-02f, -2.12986663e-01f, 1.07243091e-01f, -2.48510927e-01f, -2.04635989e-02f, -1.95965216e-01f,
  -2.38372907e-01f, -4.31596339e-01f, 2.05003023e-01f, -2.58295268e-01f, -7.73779582e-03f, -3.34798694e-02f, -1.12533748e-01f, 1.81967601e-01f, -1.37013555e-01f, -2.62906730e-01f,
  -7.83198625e-02f, -1.56293646e-01f, -2.67848551e-01f, 6.46266863e-02f, -5.69798239e-02f, 1.30952103e-02f, -2.56087240e-02f, 3.25758122e-02f, 1.13041267e-01f, 8.62331316e-02f,
  1.68388247e-01f, -1.32011771e-01f, 1.27928585e-01f, 8.77412260e-02f, -1.54903397e-01f, -1.96443461e-02f, 1.50587261e-01f, 1.75038755e-01f, 3.17369193e-01f, 2.16915801e-01f,
  -1.03820041e-01f, -1.10019371e-01f, 9.48587656e-02f, 2.64436245e-01f, -3.66219342e-01f, -2.25666597e-01f, -3.44935767e-02f, 1.57867745e-02f, -7.76994601e-02f, 1.55167788e-01f,
  -2.41022944e-01f, -7.23744510e-03f, 1.52079433e-01f, 5.17201684e-02f, -2.57193953e-01f, 5.22078089e-02f, 1.23731695e-01f, 1.06515415e-01f, 1.76716581e-01f, 1.28229111e-01f,
  -3.20694856e-02f, -5.86389080e-02f, 7.12534636e-02f, 2.69692671e-03f, -1.86760277e-02f, -4.61453646e-02f, 2.31862009e-01f, 2.91887354e-02f, 2.86325842e-01f, 1.15152905e-02f,
  2.89164662e-01f, -1.46124870e-01f, -9.37355086e-02f, -1.61425665e-01f, -3.12026948e-01f, -3.78996849e-01f, 1.88586786e-02f, 1.17587879e-01f, -1.03101693e-01f, -8.02452490e-02f,
  -1.65931091e-01f, 7.67491385e-02f, 9.96115953e-02f, 1.20203719e-02f, 5.41396327e-02f, 2.52983958e-01f, 1.49696231e-01f, 1.11006968e-01f, -5.72487824e-02f, 6.49398565e-02f,
  6.99418932e-02f, 1.64158016e-01f, 1.58873215e-01f, -1.28584448e-02f, 1.46321520e-01f, 1.75919887e-02f, 3.14562052e-01f, 2.08381012e-01f, 9.75079760e-02f, 2.39534095e-01f,
  -5.25110886e-02f, 3.38084251e-01f, 1.62075862e-01f, 1.19691696e-02f, -2.05165163e-01f, -2.05172867e-01f, -2.05931887e-01f, -5.83783463e-02f, -6.43722787e-02f, -1.42345220e-01f,
  1.63919732e-01f, 2.85886461e-03f, -2.31842585e-02f, 5.61683923e-02f, 7.46520907e-02f, 7.09830225e-02f, -1.52161449e-01f, 4.88962941e-02f, 7.76206478e-02f, -2.19264477e-01f,
  -1.03647500e-01f, -2.28218436e-02f, 1.74438536e-01f, -4.14123349e-02f, 1.04916647e-01f, -1.88861564e-01f, 1.51146650e-01f, 2.82599218e-02f, -1.52859226e-01f, -2.31472999e-01f,
  8.64046626e-03f, -8.48802626e-02f, -2.59655416e-01f, -2.85386533e-01f, -1.16280317e-01f, 3.42942514e-02f, 1.27122954e-01f, 1.45391852e-01f, -1.51877090e-01f, 8.30943584e-02f,
  -2.73567885e-02f, -1.10001154e-02f, 5.06342649e-02f, 1.01321027e-01f, -3.33085610e-03f, 1.31808072e-01f, 9.48902816e-02f, -1.45075455e-01f, -1.33312523e-01f, 2.30910584e-01f,
  5.33496365e-02f, 3.91883999e-02f, 3.65192108e-02f, -5.07599153e-02f, -8.34804922e-02f, -5.13546877e-02f, 9.87590030e-02f, 2.53651977e-01f, 4.24659178e-02f, 2.33822778e-01f,
  2.31453478e-01f, 3.63279805e-02f, -7.69638419e-02f, 1.15489446e-01f, 1.52693927e-01f, -2.83227295e-01f, -1.82431549e-01f, -1.79363951e-01f, 1.94848478e-01f, -2.36573011e-01f,
  -2.72694300e-03f, 3.14904004e-01f, -2.10596055e-01f, 4.16868001e-01f, -2.21647527e-02f, 2.49654904e-01f, -1.66994587e-01f, 1.71966463e-01f, 1.81282967e-01f, 5.36331572e-02f,
  1.67896032e-01f, -4.83628586e-02f, 3.68067473e-02f, -4.46059406e-02f, 6.65518939e-02f, -3.46160978e-01f, 2.38880530e-01f, 6.85787797e-02f, 2.33614475e-01f, 2.78854072e-01f,
  1.47582710e-01f, 1.41019091e-01f, -2.71616071e-01f, -2.70640880e-01f, 2.93496568e-02f, 3.10264885e-01f, 4.53550577e-01f, 5.17384671e-02f, 1.32299215e-02f, 4.45108175e-01f,
  -1.73907399e-01f, 7.86946341e-02f, -1.09079853e-01f, -3.27688009e-02f, -1.17360882e-01f, -2.36051664e-01f, -2.93876112e-01f, 6.32654727e-02f, 2.03722998e-01f, 2.16599420e-01f,
  1.20703608e-01f, -5.24490885e-02f, 1.70637950e-01f, -2.29177922e-01f, 1.31723911e-01f, 2.91383296e-01f, -9.67284068e-02f, -3.71444583e-01f, 6.89166933e-02f, 1.12068266e-01f,
  5.40432520e-03f, -1.85834929e-01f, -1.28345072e-01f, 1.61466807e-01f, 3.14685851e-02f, -1.94857463e-01f, 3.03358808e-02f, 6.71666563e-02f, -4.59141359e-02f, -2.19382849e-02f,
  -6.66847527e-02f, 1.87229246e-01f, -7.71298930e-02f, 1.58762068e-01f, 7.95243010e-02f, -2.93501616e-01f, 9.98137295e-02f, -1.72311291e-01f, 7.91947842e-02f, 6.55463040e-02f,
  -1.65424123e-01f, -2.87080631e-02f, 6.07527979e-02f, -9.48626101e-02f, -1.03647836e-01f, 6.14725724e-02f, 2.08376721e-01f, 2.20170170e-02f, -7.34556466e-02f, -2.70504653e-01f,
  1.37953430e-01f, 1.45899728e-01f, -3.97065133e-02f, -1.19625501e-01f, 2.78477758e-01f, 2.51676083e-01f, -3.26881051e-01f, 1.20418489e-01f, -1.28328890e-01f, 5.98587245e-02f,
  -1.72347963e-01f, 1.81954443e-01f, -2.91584767e-02f, -3.33687551e-02f, 2.15209365e-01f, 1.24520048e-01f, 1.15621537e-01f, 9.54372957e-02f, 2.17056900e-01f, -1.22485757e-01f,
  1.78010599e-03f, -1.08399643e-02f, -4.97600287e-01f, 6.86487854e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  9.11491662e-02f, 1.94571674e-01f, -6.99151456e-02f, 2.29918599e-01f, 1.82678476e-01f, 1.08004406e-01f, 4.19617333e-02f, 1.08704537e-01f, -3.84335779e-02f, -9.52850878e-02f,
  -6.39672130e-02f, -5.73273823e-02f, 1.07368708e-01f, 1.37337521e-01f, -8.94816667e-02f, -9.04991403e-02f, 7.48385787e-02f, 9.36063603e-02f, 2.20928323e-02f, -1.07837273e-02f,
  6.67996928e-02f, -4.83255484e-04f, 4.33423370e-02f, 7.40349591e-02f, -9.75498259e-02f, 3.85464244e-02f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  7.52347633e-02f, 3.03471796e-02f, -1.43985301e-01f, -8.55753571e-02f, -3.99458893e-02f, -6.93678558e-02f, -9.42589939e-02f, -2.32756068e-03f, 1.37321800e-01f, 1.17708743e-01f,
  -2.15808988e-01f, -2.77572796e-02f, -9.58470404e-02f, -8.89886469e-02f, -1.47445295e-02f, -2.24169105e-01f, -1.92118242e-01f, 1.25221491e-01f, 9.55975503e-02f, -4.80604321e-02f,
  2.85058562e-02f, -2.41091073e-01f, 8.38653892e-02f, 6.89135864e-02f, -2.25089788e-01f, 2.35735238e-01f, -4.38113809e-01f, -2.37341132e-02f, 1.77262634e-01f, 7.99248070e-02f,
  2.05614999e-01f, 7.60580078e-02f, -4.71826531e-02f, 6.01490662e-02f, -8.21036473e-02f, 1.18809611e-01f, -9.80752036e-02f, -6.51163459e-02f, -1.32265657e-01f, 6.02317834e-03f,
  7.65780434e-02f, -1.11672238e-01f, -4.46728170e-02f, 1.23603374e-01f, -2.31319532e-01f, -2.59093512e-02f, 9.85570922e-02f, 7.66107142e-02f, -1.79112647e-02f, -5.06833754e-02f,
  1.40981406e-01f, 6.28163293e-02f, -3.80178280e-02f, 8.04398209e-02f, 9.57531705e-02f, -2.45658368e-01f, 1.73273787e-01f, 6.94011822e-02f, -1.34628192e-01f, -2.52323240e-01f,
  -2.36599639e-01f, 1.86363921e-01f, -2.10553389e-02f, 2.16556564e-01f, 1.56727254e-01f, -1.31428003e-01f, -9.47743654e-02f, -3.69810499e-02f, 6.27236962e-02f, -1.21035524e-01f,
  2.97776461e-01f, -1.37431949e-01f, -1.74255820e-03f, 4.03333642e-02f, 8.99564847e-02f, 1.55158207e-01f, 6.82098791e-02f, -3.14926207e-02f, 2.56950080e-01f, -1.21857934e-01f,
  8.86504129e-02f, 2.40974203e-02f, 1.46022007e-01f, -2.27269948e-01f, -5.87737001e-02f, 4.49137436e-03f, -1.29639059e-01f, -6.14678301e-02f, 7.39645138e-02f, -2.10256785e-01f,
  8.47193673e-02f, 1.97546873e-02f, 4.41542938e-02f, 1.62037522e-01f, 2.83218503e-01f, 6.93089068e-02f, -8.52365643e-02f, -1.35014892e-01f, 1.09709255e-01f, 1.85904726e-01f,
  1.46060642e-02f, 8.56542364e-02f, -1.23657413e-01f, 1.86961442e-02f, -9.46290733e-04f, 1.07825391e-01f, 1.97847053e-01f, 2.32420322e-02f, -2.67469376e-01f, 6.43839315e-02f,
  -9.53869224e-02f, -1.63718194e-01f, 1.90476969e-01f, -3.09165288e-02f, 2.07530260e-01f, 2.40120497e-02f, -9.52630863e-02f, 2.47094687e-02f, -1.22441016e-01f, 3.73231247e-02f,
  -2.00984329e-02f, -1.17065229e-01f, 1.10751698e-02f, 1.63356081e-01f, 9.78933498e-02f, 2.12927371e-01f, -3.55222262e-02f, -2.63232082e-01f, 8.31840094e-03f, 2.32997417e-01f,
  3.25693160e-01f, 6.54937103e-02f, 4.20601219e-02f, 2.52969682e-01f, 3.76963705e-01f, 3.71768810e-02f, 1.21676482e-01f, -8.90498087e-02f, 7.93972462e-02f, -1.14753895e-01f,
  8.82686377e-02f, 4.52805571e-02f, 1.95602581e-01f, -3.37001262e-03f, 1.13632150e-01f, 1.17386259e-01f, -6.33226261e-02f, -7.70150051e-02f, -8.74555260e-02f, 3.77211958e-01f,
  -1.80016950e-01f, 4.25922684e-02f, 2.43514746e-01f, -1.72357693e-01f, -1.40874963e-02f, 1.32718176e-01f, -1.01952761e-01f, -1.63251817e-01f, -9.58992839e-02f, -4.12485860e-02f,
  5.72780818e-02f, 1.03370816e-01f, 2.06660524e-01f, 1.39395371e-01f, 2.93918662e-02f, -1.38418049e-01f, -4.34588082e-02f, 1.79317489e-01f, 9.73374695e-02f, 3.94700989e-02f,
  -1.88734569e-02f, 5.73516786e-02f, -1.31172035e-02f, 6.24347217e-02f, -8.79098997e-02f, -1.37815773e-01f, 7.76491761e-02f, -7.61846676e-02f, -1.56135291e-01f, -8.45029354e-02f,
  5.32547571e-02f, -8.66940469e-02f, 1.22258045e-01f, 2.60120153e-01f, -2.54195463e-03f, 1.15822423e-02f, -7.00248852e-02f, 5.74220866e-02f, -1.28884703e-01f, -1.92517564e-02f,
  9.06971768e-02f, -1.95042714e-01f, -5.02715185e-02f, 5.27854450e-02f, 3.99590880e-02f, 1.74065247e-01f, 1.41646862e-02f, 1.04007795e-01f, -2.06277326e-01f, 2.44722620e-01f,
  -5.51228300e-02f, -4.01819329e-04f, -1.45164788e-01f, -8.23323652e-02f, 1.93836391e-01f, -4.19351086e-02f, 8.51175487e-02f, 1.72344252e-01f, 1.36217410e-02f, 5.42038046e-02f,
  1.02637589e-01f, -1.26344487e-01f, -8.96020383e-02f, -1.79741725e-01f, -1.15694225e-01f, -1.40420524e-02f, 1.73221320e-01f, -1.70435663e-02f, 1.00038067e-01f, -3.48525941e-02f,
  -3.38077813e-01f, -1.15898438e-01f, -8.61403644e-02f, -2.21386805e-01f, 2.48464085e-02f, 8.79068896e-02f, -6.86403438e-02f, -4.89861667e-02f, 2.38407388e-01f, -7.09505379e-02f,
  -4.11750004e-02f, 4.13031550e-03f, -3.59925419e-01f, -8.80243331e-02f, 2.59650648e-01f, 1.02039374e-01f, -1.02174252e-01f, -4.61474136e-02f, -5.61602637e-02f, 2.48719797e-01f,
  2.49671310e-01f, 6.04035705e-02f, 8.17801952e-02f, 1.40053518e-02f, -1.00901730e-01f, 1.09370559e-01f, -8.79731774e-02f, 1.09621972e-01f, 2.31237914e-02f, 8.21950957e-02f,
  -1.95736155e-01f, -4.71319184e-02f, -3.42327394e-02f, 1.04263030e-01f, -1.28561392e-01f, 6.21717796e-02f, 2.69867890e-02f, -1.91096708e-01f, -7.68944854e-03f, -1.09387010e-01f,
  1.30716801e-01f, 7.20251352e-02f, 1.76636219e-01f, 4.36775722e-02f, -9.35822576e-02f, -2.05209572e-02f, 9.52723697e-02f, 1.26417100e-01f, 1.72536477e-01f, -1.14441425e-01f,
  3.25313173e-02f, 1.44930020e-01f, -9.85731035e-02f, -8.90046358e-02f, -1.49564520e-01f, -1.50500149e-01f, 1.09367214e-01f, 6.53544739e-02f, -1.11745536e-01f, -4.75177765e-02f,
  8.55155736e-02f, -2.68553555e-01f, 3.24835628e-01f, 7.76375225e-03f, -1.09386384e-01f, 8.02895129e-02f, 2.45202988e-01f, 9.21772048e-02f, -3.23483050e-02f, 6.12589531e-02f,
  2.45350953e-02f, 1.24575697e-01f, -2.17452981e-02f, 1.28685862e-01f, -1.31555483e-01f, 5.86070716e-02f, 1.11455284e-01f, 1.93443701e-01f, 1.82603598e-01f, 2.92710774e-02f,
  -1.37045294e-01f, -4.50719036e-02f, -4.77243960e-02f, 1.98725045e-01f, -8.92944038e-02f, 3.40138227e-02f, 5.84840328e-02f, 8.42314661e-02f, -2.85789017e-02f, -1.35653034e-01f,
  1.58634223e-02f, 8.90978277e-02f, -1.47060025e-04f, -2.79409319e-01f, -2.50628233e-01f, 6.55560195e-02f, 7.31495470e-02f, -4.86697741e-02f, -2.17757169e-02f, -7.79950693e-02f,
  -1.56503484e-01f, 2.51134515e-01f, 1.25029713e-01f, -7.31089264e-02f, -1.64521456e-01f, -2.05629934e-02f, 1.74843013e-01f, 1.68942600e-01f, 2.60768741e-01f, 5.77440150e-02f,
  2.37059258e-02f, -6.41666353e-02f, -5.47245657e-03f, 8.52107853e-02f, 2.09743589e-01f, -1.72902197e-01f, 9.24386755e-02f, 2.13671103e-01f, 3.44703287e-01f, -4.42825817e-02f,
  6.25145957e-02f, 1.05195679e-01f, 1.60252959e-01f, 3.61819863e-02f, -4.45160270e-03f, -9.39636678e-02f, -1.05049461e-02f, 4.31301743e-02f, -7.76319876e-02f, 2.64065355e-01f,
  -1.40210554e-01f, -5.00410311e-02f, 2.90027224e-02f, 2.35488966e-01f, 4.42054356e-04f, -1.66560262e-01f, 2.59582609e-01f, 4.20818031e-02f, -2.35351045e-02f, -3.17684039e-02f,
  -1.18250974e-01f, -7.72106722e-02f, 1.60734892e-01f, -4.80021201e-02f, -7.49077573e-02f, 2.00069100e-01f, 5.03924973e-02f, -1.75019071e-01f, 2.22812697e-01f, -1.37881458e-01f,
  1.41943961e-01f, 1.93112224e-01f, 3.45493928e-02f, -1.52319998e-01f, -1.24922097e-01f, -2.40143314e-02f, 2.06603363e-01f, 6.26301169e-02f, 1.94269806e-01f, -5.02752960e-02f,
  -1.52337044e-01f, -3.24101071e-03f, 1.01229645e-01f, -8.86158422e-02f, -2.53140181e-01f, 2.85867035e-01f, 2.05778822e-01f, 7.55673647e-02f, -8.17660466e-02f, -2.30009615e-01f,
  4.30675633e-02f, -1.13087162e-01f, 2.99390763e-01f, 1.80589288e-01f, -1.46527309e-02f, 5.98985665e-02f, 3.07748700e-03f, -6.66111410e-02f, -2.33942434e-01f, -1.25695124e-01f,
  3.43663581e-02f, -1.66287795e-01f, 7.04600513e-02f, 1.12179130e-01f, -2.21565768e-01f, -4.71938513e-02f, 3.23876321e-01f, 5.76197878e-02f, 2.96973772e-02f, 8.24987218e-02f,
  -1.29528522e-01f, -1.37629271e-01f, 4.52610515e-02f, 5.49998917e-02f, -1.67315915e-01f, -6.96636289e-02f, 4.29673456e-02f, -9.33892503e-02f, 7.37036439e-03f, -1.38449773e-01f,
  -5.42721748e-02f, -1.70392826e-01f, 1.62365898e-01f, 4.89851125e-02f, -1.71797156e-01f, -1.91399634e-01f, -8.59814510e-02f, -1.95331257e-02f, 1.25551105e-01f, -2.76476800e-01f,
  -1.68238599e-02f, -4.65283496e-03f, 3.42300870e-02f, 7.96448290e-02f, 1.25832796e-01f, -1.36348724e-01f, 1.68936163e-01f, 9.81178284e-02f, -1.02566637e-01f, -7.23004714e-02f,
  2.27801558e-02f, 1.55216590e-01f, 2.47788668e-01f, 1.09607309e-01f, 1.15588464e-01f, -5.58328293e-02f, 1.73135087e-01f, 9.42025613e-03f, -2.62174904e-02f, -3.96116860e-02f,
  7.98653960e-02f, 1.18575431e-01f, 1.88781664e-01f, 8.17028061e-02f, 1.72949433e-02f, -4.65164743e-02f, -5.53214401e-02f, -6.69195428e-02f, -1.19448684e-01f, 2.01758459e-01f,
  -3.61060612e-02f, -4.80021462e-02f, 1.87352579e-02f, 4.17871587e-02f, -1.58448145e-01f, -1.42091274e-01f, -2.14061156e-01f, -2.97079831e-01f, 1.49222210e-01f, -2.88591266e-01f,
  2.69123968e-02f, 2.87566576e-02f, -8.74696821e-02f, -1.89292282e-02f, -5.26977368e-02f, -3.27237993e-02f, 4.69446629e-01f, -1.15857627e-02f, 1.02519475e-01f, -6.62239641e-02f,
  -1.65653363e-01f, -3.10926381e-02f, -1.50468454e-01f, 8.75066891e-02f, -2.98694074e-01f, -3.58920284e-02f, -2.57263752e-03f, 8.18098336e-02f, 3.16672891e-01f, -1.69153035e-01f,
  -4.36611753e-03f, -6.03043698e-02f, -5.08525930e-02f, -8.23582709e-02f, 6.22788109e-02f, 6.72417581e-02f, -8.19899812e-02f, 1.41776815e-01f, -1.11361362e-01f, 1.91247523e-01f,
  -3.06261573e-02f, 8.80246386e-02f, -9.33494791e-02f, 4.28877696e-02f, -1.21333927e-01f, -3.56885754e-02f, 1.38976231e-01f, -6.39422312e-02f, 5.13219871e-02f, -9.63660423e-03f,
  1.86542928e-01f, -1.42477944e-01f, 1.05836190e-01f, 1.24296807e-01f, -1.69947714e-01f, 1.86880887e-01f, -9.23718885e-02f, -9.59555730e-02f, 1.62457034e-01f, 6.99769408e-02f,
  1.63017422e-01f, 6.12864383e-02f, 1.09982297e-01f, -2.49503925e-02f, -8.83196015e-03f, -2.43789405e-02f, 1.84123609e-02f, -1.16055608e-01f, 1.07955992e-01f, -3.21151130e-02f,
  2.37334266e-01f, 1.66267321e-01f, -7.30574653e-02f, -1.47222146e-01f, 1.73193157e-01f, -2.94265635e-02f, -1.21098660e-01f, -9.33240578e-02f, -3.23064625e-01f, 1.98890027e-02f,
  1.46502284e-02f, 3.48393112e-01f, 1.69637740e-01f, 4.26054150e-02f, -1.31875753e-01f, 2.18095541e-01f, -3.02200262e-02f, -2.39416566e-02f, 6.54077902e-02f, -4.69068959e-02f,
  -1.16053261e-02f, -3.25423782e-03f, -4.15698765e-03f, -8.59505162e-02f, 1.07199445e-01f, 2.94327661e-02f, 3.85810398e-02f, -1.11046596e-03f, -2.78831404e-02f, 6.67516962e-02f,
  -3.58534828e-02f, -1.99700251e-01f, 9.70952436e-02f, 3.84901688e-02f, -9.05069858e-02f, 1.08361930e-01f, 2.65769172e-03f, -1.41117513e-01f, 1.00171767e-01f, -6.67225278e-04f,
  2.39723027e-01f, -2.09185585e-01f, -8.59045796e-03f, 2.11148381e-01f, -1.42892256e-01f, 6.09125895e-03f, 1.49135590e-01f, -3.16553295e-01f, -2.56380171e-01f, 5.74628152e-02f,
  1.62144169e-01f, 2.22773179e-02f, -6.85697868e-02f, 1.92503035e-01f, -3.48070562e-01f, 6.25832006e-02f, 1.77173898e-01f, 1.70321345e-01f, -5.48444353e-02f, 1.47004658e-02f,
  -2.02894323e-02f, 6.04048893e-02f, 9.25968401e-03f, 9.71396826e-03f, -7.14542195e-02f, -1.88033298e-01f, 8.15641955e-02f, -2.35795677e-01f, -2.96271890e-01f, -1.28671288e-01f,
  2.74624974e-01f, -2.16789991e-01f, 2.35359654e-01f, 1.27785161e-01f, -7.76972696e-02f, -1.27343848e-01f, 3.66805047e-01f, 3.71197984e-02f, 2.30906560e-04f, 5.93309440e-02f,
  1.09343752e-02f, 1.70484155e-01f, 1.89332068e-01f, 1.74078211e-01f, -1.29107714e-01f, 1.02641724e-01f, 2.90051778e-03f, 1.33620230e-02f, 1.56303063e-01f, -1.49127409e-01f,
  -1.35783106e-01f, -2.69682501e-02f, -4.01962213e-02f, 1.05349168e-01f, 1.15396790e-01f, 5.62739410e-02f, 1.42371178e-01f, 1.09037347e-01f, -2.20633343e-01f, 1.11271933e-01f,
  -1.57085866e-01f, 7.41305947e-02f, 1.79657310e-01f, -1.71194822e-02f, -2.56015956e-01f, -6.38744757e-02f, 5.91285340e-02f, 1.08707942e-01f, -3.06092482e-02f, -9.19140503e-02f,
  1.40425697e-01f, -1.20466337e-01f, -8.05772692e-02f, -1.36311650e-01f, -1.50075397e-02f, 6.97934628e-02f, -1.54218748e-01f, 1.57065913e-01f, -1.22025907e-01f, -1.12662487e-01f,
  -1.70581769e-02f, 8.40894599e-03f, 1.15040895e-02f, 1.33012682e-01f, 7.29712620e-02f, 8.18623155e-02f, -7.05659315e-02f, -7.65263513e-02f, 6.06209598e-02f, -1.36350968e-03f,
  1.07692622e-01f, -2.06220344e-01f, -1.50797173e-01f, -9.73577332e-03f, 2.63664871e-01f, 3.84203531e-02f, 1.71686113e-01f, 1.40863851e-01f, -2.05448046e-02f, 4.11261544e-02f,
  -3.41057889e-02f, -1.54260367e-01f, 3.73004586e-03f, 1.11987792e-01f, -7.04247877e-02f, 3.15062851e-02f, 1.86984614e-01f, 1.18414506e-01f, -1.65764451e-01f, -7.69610330e-02f,
  7.26702958e-02f, -4.33058813e-02f, -2.02178247e-02f, 3.27608436e-02f, -1.28918499e-01f, 8.05806816e-02f, 1.41148552e-01f, -6.77072778e-02f, -7.48917609e-02f, -1.00636952e-01f,
  1.12353399e-01f, 1.86662570e-01f, -9.15268585e-02f, 6.15455769e-02f, 1.82181194e-01f, -1.45987570e-01f, 3.78641039e-02f, -7.12676123e-02f, -2.39504263e-01f, -1.83220088e-01f,
  3.13766375e-02f, -7.61070773e-02f, 9.12538096e-02f, 7.47106224e-02f, 5.50874509e-02f, -7.38771260e-02f, 4.04800698e-02f, -1.79853469e-01f, -9.59158987e-02f, 1.92383438e-01f,
  9.86953080e-03f, -9.98047590e-02f, -1.65486619e-01f, -5.11029474e-02f, -2.78499816e-02f, 2.81087700e-02f, -7.25189969e-02f, 1.48309916e-01f, -3.75432856e-02f, 2.90578194e-02f,
  4.92902957e-02f, 1.10345416e-01f, 6.03691563e-02f, 1.18627764e-01f, 1.55425921e-01f, 7.05214366e-02f, 1.24614149e-01f, 4.40981239e-03f, -1.18854716e-01f, 3.33600104e-01f,
  -2.70218194e-01f, 4.74181399e-02f, 2.02500612e-01f, -2.06585541e-01f, 1.88720420e-01f, 9.74679515e-02f, 9.38821957e-02f, -8.93125236e-02f, -2.08946988e-01f, 1.21850446e-01f,
  1.03168078e-01f, 7.63112828e-02f, 7.39732981e-02f, 1.32476836e-01f, 1.75848052e-01f, -1.34114567e-02f, -7.53874406e-02f, 1.79022029e-01f, 4.46078330e-02f, -3.94492932e-02f,
  -1.09210365e-01f, -1.94603741e-01f, -8.35672542e-02f, 9.87402443e-03f, -1.77114502e-01f, -1.30841687e-01f, 7.67083764e-02f, -4.69842404e-02f, 4.36480306e-02f, -1.13392092e-01f,
  -4.24443558e-02f, 1.58929095e-01f, -8.30506384e-02f, -5.59557118e-02f, 1.67291006e-03f, -2.65963655e-02f, 2.51362592e-01f, 1.73804313e-01f, 7.06530586e-02f, 6.84523582e-02f,
  -1.40459940e-01f, -2.20282108e-01f, -6.44110516e-02f, -4.38669212e-02f, 2.64280066e-02f, -1.07678235e-01f, -1.68050095e-01f, 3.51380482e-02f, 2.05281019e-01f, 4.79990281e-02f,
  -1.61609247e-01f, -2.16732204e-01f, 1.12920694e-01f, -4.00691122e-01f, -1.60226151e-01f, 4.03481210e-03f, -6.09624619e-03f, 4.49181944e-02f, 2.35675976e-01f, 1.93553492e-01f,
  1.28162861e-01f, 1.24460861e-01f, -1.17489114e-01f, 4.35795598e-02f, -1.78879485e-01f, 1.03269942e-01f, 2.19749436e-01f, -1.85563471e-02f, 8.44762772e-02f, 1.54080421e-01f,
  8.56051594e-02f, 5.30700199e-02f, -1.03938498e-01f, -2.04247162e-02f, 4.44884561e-02f, 1.26030058e-01f, -4.87292893e-02f, 2.09602471e-02f, 1.53750824e-02f, 4.42806557e-02f,
  2.46549696e-02f, -4.42143530e-03f, 6.65446520e-02f, 4.76405174e-02f, 1.52458837e-02f, -2.79904157e-01f, -5.28536811e-02f, -1.58600047e-01f, 1.19203359e-01f, 1.71784475e-01f,
  1.01183906e-01f, -3.24718244e-02f, -2.41643786e-01f, -1.57100573e-01f, 2.26953119e-01f, 9.63527244e-03f, -1.22176848e-01f, -1.09722093e-01f, 3.38174738e-02f, -3.28166131e-03f,
  1.43116042e-01f, 1.17754238e-02f, -1.91677734e-01f, 2.85475284e-01f, 2.28199914e-01f, -1.34639582e-02f, 5.06408736e-02f, -1.30948216e-01f, 2.68909317e-02f, -5.26821241e-02f,
  -5.50500564e-02f, -1.83965132e-01f, -2.01924890e-01f, -6.89806491e-02f, -6.05798364e-02f, -1.60959139e-01f, -7.84461759e-03f, -9.02270973e-02f, -4.28243652e-02f, -1.14942111e-01f,
  6.91933557e-02f, 2.49732524e-01f, -1.68338865e-02f, -1.50475025e-01f, 3.16156924e-01f, 2.22313982e-02f, -1.09010026e-01f, 6.28189817e-02f, 1.10981256e-01f, 7.93177634e-02f,
  9.08361897e-02f, -2.12307051e-01f, -4.13741991e-02f, -6.15491346e-02f, 6.51696175e-02f, -2.67404169e-01f, 1.93583425e-02f, -7.13286921e-02f, -1.69077829e-01f, -1.17685489e-01f,
  5.64133450e-02f, -1.85114354e-01f, 1.23601548e-01f, 7.24924132e-02f, -6.05522394e-02f, 6.68738410e-02f, 1.58537656e-01f, -1.83832794e-01f, 1.39384881e-01f, 4.18896135e-03f,
  -1.68500230e-01f, 5.51349707e-02f, -1.54810980e-01f, -2.32538864e-01f, 1.68904871e-01f, -2.16132719e-02f, 1.98247731e-01f, 1.14347979e-01f, -2.54900068e-01f, -5.59892058e-02f,
  2.20181912e-01f, -1.09317459e-01f, -4.68344912e-02f, -9.86083820e-02f, 5.31164594e-02f, 1.87238500e-01f, 3.33115943e-02f, 2.45083887e-02f, 3.49682085e-02f, -1.06346004e-01f,
  -1.16132066e-01f, -1.52510107e-02f, -1.26208186e-01f, -5.98970316e-02f, -4.32833321e-02f, 1.30889833e-01f, -1.84191346e-01f, 9.66482684e-02f, 4.74937027e-03f, 3.65700088e-02f,
  3.90410945e-02f, 4.38022129e-02f, -1.23415507e-01f, -5.90895973e-02f, 1.33639947e-01f, 2.08065420e-01f, 1.56461969e-01f, -2.47913092e-01f, 1.12106420e-01f, 1.97847128e-01f,
  -8.49118605e-02f, 2.87052989e-01f, 9.02790800e-02f, -2.09679618e-01f, -3.68583389e-02f, 7.16976672e-02f, 2.20387548e-01f, 1.98114365e-01f, -7.05577582e-02f, 1.61282107e-01f,
  -2.36161068e-01f, 5.40776402e-02f, -1.46328118e-02f, -4.61499654e-02f, 1.01649165e-01f, -1.98660970e-01f, 1.57927603e-01f, -9.83256847e-02f, -6.87992619e-03f, 1.16895884e-01f,
  4.94354684e-03f, -2.05624141e-02f, 3.12656187e-03f, 2.97400743e-01f, -6.32226169e-02f, 1.62901208e-01f, -6.12473041e-02f, -3.94664630e-02f, 1.36126950e-01f, 1.59303084e-01f,
  1.15403071e-01f, -6.28346503e-02f, -4.94293384e-02f, 1.50406763e-01f, 6.27641305e-02f, -2.00389042e-01f, 2.00491562e-01f, 1.40701771e-01f, 9.96015128e-03f, 2.54609197e-01f,
  1.87955186e-01f, -1.80499494e-01f, -4.00345139e-02f, -4.13555615e-02f, 4.45933007e-02f, 1.22966260e-01f, 1.89776588e-02f, 7.11163729e-02f, 8.03279728e-02f, 2.00277388e-01f,
  -7.18691200e-02f, 1.97412834e-01f, 1.90955028e-01f, 8.95861536e-02f, 4.05012369e-02f, 1.05844170e-01f, 2.76470780e-01f, -4.04116027e-02f, -1.76511317e-01f, -1.95738790e-03f,
  9.00642201e-02f, 2.32728031e-02f, 6.27139956e-02f, 1.03619032e-01f, -1.69797167e-01f, 2.16332600e-02f, -1.75112545e-01f, -1.82603255e-01f, 2.56139159e-01f, 2.51505196e-01f,
  -1.06174655e-01f, -8.62556323e-02f, -1.62280947e-01f, -1.85997710e-01f, -4.58859317e-02f, 1.34843281e-02f, -2.11068958e-01f, 1.85806170e-01f, -5.68578131e-02f, -2.87509710e-02f,
  -1.87974334e-01f, -1.19749680e-01f, -2.07060963e-01f, 3.02555412e-02f, 1.09484404e-01f, -1.29911542e-01f, -1.91533357e-01f, -5.98540492e-02f, -6.83601424e-02f, 1.47393540e-01f,
  -4.19676378e-02f, 1.40211843e-02f, -8.21950883e-02f, 5.87641485e-02f, -3.23447317e-01f, -2.59666294e-01f, 3.96356806e-02f, 4.44290228e-02f, 1.60953119e-01f, 1.13817595e-01f,
  9.86207947e-02f, -7.49424547e-02f, 3.57810587e-01f, -4.88504358e-02f, -5.81593104e-02f, -3.33033800e-02f, 4.28278698e-03f, -1.55343950e-01f, 1.07708618e-01f, -5.21798767e-02f,
  5.84415160e-02f, 4.53050807e-03f, 1.35485321e-01f, -4.43715118e-02f, 1.82431817e-01f, -1.36049390e-02f, -9.60067101e-03f, -5.43413386e-02f, -7.75423944e-02f, -1.71116561e-01f,
  -5.90191744e-02f, 5.14663896e-03f, 8.20881501e-02f, -4.51093167e-02f, -3.32680605e-02f, 5.13564289e-01f, 9.79674682e-02f, 9.10601988e-02f, -1.46722883e-01f, -1.56435743e-01f,
  -2.18952950e-02f, 8.20336044e-02f, -1.14308475e-02f, 8.40084851e-02f, -1.59366503e-01f, -1.34864701e-02f, 2.02971235e-01f, -1.41726434e-01f, 8.37963298e-02f, -8.50473419e-02f,
  4.14974131e-02f, -1.77604809e-01f, -9.27372649e-03f, 2.39404872e-01f, -3.06811947e-02f, 1.98781997e-01f, 1.52099570e-02f, 6.75144233e-03f, 1.13581963e-01f, -7.78305857e-03f,
  -8.19883645e-02f, -1.16232567e-01f, 1.55498534e-02f, -2.12850291e-02f, 4.38668691e-02f, -1.44662842e-01f, 8.86947066e-02f, -4.54017334e-03f, -1.28637061e-01f, -5.68465590e-02f,
  -7.42811561e-02f, -1.03395276e-01f, 8.94515961e-02f, 1.03357613e-01f, 5.54681048e-02f, -2.81133149e-02f, 1.17751785e-01f, -1.13763921e-01f, -6.03565946e-02f, -1.65066030e-02f,
  8.06924850e-02f, -1.28437966e-01f, -1.65980950e-01f, 8.40881765e-02f, 1.30941242e-01f, -1.96884736e-01f, -1.40760183e-01f, -3.68310437e-02f, -1.28031835e-01f, -3.61107066e-02f,
  -1.07495867e-01f, -3.72657701e-02f, -2.11058650e-02f, 1.21047281e-01f, 7.29231462e-02f, 3.57321016e-02f, 2.61178583e-01f, 1.21174939e-01f, 8.00368190e-02f, 1.28760234e-01f,
  -1.76107749e-01f, -2.04415724e-01f, -1.33124888e-01f, 6.29270002e-02f, -3.11064541e-01f, 1.64021432e-01f, 1.76555775e-02f, 1.79527849e-02f, 9.43988487e-02f, -3.27277362e-01f,
  -2.00285807e-01f, 3.21553685e-02f, -8.09615850e-02f, -1.43665327e-02f, -5.46653755e-02f, 1.95318952e-01f, -6.84717968e-02f, -8.06174129e-02f, 7.30551258e-02f, -9.69219767e-03f,
  -9.81447026e-02f, 1.56062152e-02f, 1.30821958e-01f, 5.91969602e-02f, -1.46602839e-01f, -1.76514640e-01f, 2.96710253e-01f, 6.04651123e-02f, -1.95970491e-01f, -8.55247900e-02f,
  -1.63642913e-01f, 4.72716577e-02f, 3.79240103e-02f, 1.15763053e-01f, 3.88459861e-02f, 2.38629729e-01f, 2.24700212e-01f, -1.99619785e-01f, -2.65786350e-01f, -2.26888299e-01f,
  9.75525305e-02f, -5.33890426e-02f, 1.49556369e-01f, -6.26338571e-02f, 1.27211779e-01f, -1.42903388e-01f, 3.24890167e-02f, 1.44305304e-01f, -2.49017328e-01f, 8.20643157e-02f,
  -2.76875377e-01f, -9.44167674e-02f, -2.74711490e-01f, 6.32907748e-02f, -7.12706000e-02f, 2.08485946e-01f, 1.10682752e-02f, 1.26917183e-01f, 1.02087334e-01f, 2.76053905e-01f,
  1.33943364e-01f, 1.50446296e-01f, 2.00623050e-02f, 3.20190042e-01f, -3.84284317e-01f, -2.75786854e-02f, -8.88959784e-03f, 3.18824798e-02f, 3.97207886e-02f, 2.27433190e-01f,
  -1.00936458e-01f, -3.34116101e-01f, -1.67963415e-01f, -2.10641786e-01f, -2.56145839e-02f, -4.20362921e-03f, -1.31946385e-01f, -8.11981037e-02f, 1.23311304e-01f, 1.87463239e-01f,
  3.92144509e-02f, 1.06054567e-01f, -8.93652886e-02f, -2.66152676e-02f, -1.14075623e-01f, 2.79747825e-02f, -1.05824366e-01f, 2.09258392e-01f, -7.22968206e-02f, -1.32550830e-02f,
  1.57646667e-02f, -4.39114608e-02f, -8.74164999e-02f, -8.60045180e-02f, -2.07430691e-01f, -1.30467236e-01f, -1.45821571e-02f, 8.53135660e-02f, 6.41774386e-02f, 7.88784549e-02f,
  -1.45053998e-01f, -1.36089876e-01f, -2.15845376e-01f, -2.22537950e-01f, -2.48285383e-03f, 4.11774442e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -9.48449746e-02f, 1.99257173e-02f, 6.59771413e-02f, -6.44150972e-02f, 2.23264709e-01f, 3.11693937e-01f, -3.28043640e-01f, 3.89936507e-01f, 3.33509961e-04f, -3.72078642e-02f,
  -3.93192530e-01f, 9.08792093e-02f, 1.32997900e-01f, -3.59866470e-02f, 6.54467195e-02f, 4.07490075e-01f, 1.31691366e-01f, 8.72128978e-02f, 1.74233630e-01f, -2.29255017e-02f,
  6.57013953e-02f, -4.00637746e-01f, -2.02642635e-01f, -1.56857207e-01f, 2.03118175e-01f, 2.92530388e-01f, 1.55914947e-01f, 9.24610868e-02f, 6.16171621e-02f, -3.85818809e-01f,
  1.47541806e-01f, -3.60134602e-01f, -3.12887311e-01f, -1.12024628e-01f, -4.91377383e-01f, 2.10356191e-01f, -1.74226061e-01f, 2.35908121e-01f, 2.16248453e-01f, -1.91544041e-01f,
  2.12602481e-01f, 1.11899957e-01f, 1.17666587e-01f, 3.92352380e-02f, 3.33332360e-01f, -8.32489505e-02f, 1.54218018e-01f, 2.46529520e-01f, -2.53103912e-01f, 1.63616523e-01f,
  2.41100863e-02f, 4.03649211e-02f, -2.82512724e-01f, 3.43993604e-01f, -2.76149716e-02f, 2.00352415e-01f, 6.68009222e-02f, 9.23352912e-02f, 3.94194052e-02f, -1.67593077e-01f,
  -6.00308552e-02f, 3.67396162e-03f, 1.52160719e-01f, 1.71380505e-01f, -1.59557581e-01f, 2.80047655e-01f, 2.19267309e-02f, 3.20615098e-02f, 1.84007570e-01f, 4.06153500e-02f,
  3.08660299e-01f, -3.94116528e-02f, 2.18598858e-01f, 2.83129543e-01f, 1.51295841e-01f, 3.51513654e-01f, 8.34541302e-03f, 6.08975887e-02f, 2.93194026e-01f, -3.77456248e-01f,
  1.12790689e-01f, -1.77010447e-02f, -4.45304252e-02f, -1.46408528e-01f, 2.03262847e-02f, -2.76765972e-01f, 3.15625042e-01f, 1.62809268e-01f, 2.01589733e-01f, -7.32982308e-02f,
  -8.16151351e-02f, 7.84757137e-02f, 6.53302819e-02f, 2.79737949e-01f, -9.77273807e-02f, -1.32540166e-01f, 4.76751998e-02f, 3.51905338e-02f, 1.27930954e-01f, 1.07443869e-01f,
  -1.41581953e-01f, -2.75636673e-01f, -1.69345737e-02f, -1.39076829e-01f, -2.53632311e-02f, 1.46699592e-01f, 2.73435205e-01f, -3.90297137e-02f, -2.96555966e-01f, 1.84361473e-01f,
  2.81185091e-01f, -1.12707270e-02f, 1.12795666e-01f, -2.14081511e-01f, 1.83823809e-01f, 3.38238180e-01f, 4.43091355e-02f, 1.49358556e-01f, -1.11075833e-01f, 1.06529072e-01f,
  1.91901922e-01f, -3.09178848e-02f, 3.40301573e-01f, -4.13408220e-01f, -2.07703277e-01f, 5.48545122e-02f, 9.48714092e-02f, -5.27566448e-02f, 2.25710645e-01f, 5.73157184e-02f,
  2.16134652e-01f, 2.41619557e-01f, 9.05305669e-02f, -2.05570124e-02f, -8.82527679e-02f, 3.55870038e-01f, 1.00186653e-01f, 2.24268422e-01f, -4.69404347e-02f, -1.38121545e-01f,
  2.42784083e-01f, 7.03192642e-03f, -9.63762105e-02f, 3.19810182e-01f, 1.38743073e-01f, -1.92682117e-01f, -3.37954089e-02f, 3.16865481e-02f, -1.48832172e-01f, -5.34330048e-02f,
  -1.00976549e-01f, 1.70109961e-02f, 3.20011854e-01f, 9.89618804e-03f, 1.45139799e-01f, -1.67300984e-01f, -6.10291421e-01f, -1.05825983e-01f, -1.78467244e-01f, -2.60240763e-01f,
  -5.06146345e-03f, -6.57251328e-02f, 1.59511000e-01f, 6.57404289e-02f, 2.47840911e-01f, 4.96911518e-02f, 1.94819674e-01f, 8.52104556e-03f, -3.40271026e-01f, 7.68060312e-02f,
  2.40552500e-01f, -3.57369962e-03f, -1.40449300e-01f, 1.72602668e-01f, 1.13373898e-01f, 2.80050159e-01f, 2.38502681e-01f, 2.05291331e-01f, 2.75775313e-01f, -3.42672132e-02f,
  -1.20502710e-02f, 5.81700318e-02f, 6.24918826e-02f, 9.77084860e-02f, 4.77022678e-02f, 2.00693637e-01f, -7.70208016e-02f, -2.78449450e-02f, -4.81984802e-02f, 2.39885524e-01f,
  -3.19443434e-01f, 3.31856310e-01f, -1.01670526e-01f, 3.68131936e-01f, 2.96852738e-01f, 1.06823914e-01f, 3.70974317e-02f, -1.38039021e-02f, 8.37939456e-02f, 1.73080444e-01f,
  -4.45958786e-02f, -1.30755693e-01f, -1.55149505e-01f, 4.44837473e-02f, -2.49670558e-02f, 1.41015440e-01f, 1.81632504e-01f, -2.20622286e-01f, 1.22371167e-01f, -1.57418698e-02f,
  2.04573795e-01f, -1.12609133e-01f, 7.53951892e-02f, 1.75459310e-01f, 1.17052142e-02f, -8.29015151e-02f, -2.57104337e-02f, -1.80785343e-01f, 1.72197949e-02f, 2.12520987e-01f,
  -1.29533395e-01f, -3.23044568e-01f, -4.45483118e-01f, -1.30314335e-01f, 1.01970173e-01f, -3.95708345e-02f, -2.56734230e-02f, 1.38759792e-01f, -9.51409489e-02f, -3.62170070e-01f,
  1.51201248e-01f, 1.25590786e-01f, 1.34361178e-01f, 1.07586794e-01f, 6.13598116e-02f, 2.69513249e-01f, 2.31795609e-01f, -1.63536274e-03f, -2.04175621e-01f, -9.61222872e-02f,
  -1.19799875e-01f, 4.52906713e-02f, -1.26275346e-01f, -5.45536019e-02f, 1.47976294e-01f, 2.47790720e-02f, -1.17282972e-01f, 3.83498847e-01f, -1.27013877e-01f, 2.80583687e-02f,
  -4.58435751e-02f, 1.07924931e-01f, -7.80243054e-02f, -1.16873264e-01f, 1.27748296e-01f, -1.12040207e-01f, 8.95895287e-02f, 3.30249339e-01f, 2.91667908e-01f, -5.95255755e-02f,
  1.03755608e-01f, 1.04092434e-01f, 2.22231716e-01f, 1.64231569e-01f, 3.10984343e-01f, 1.99558824e-01f, -1.15563378e-01f, 3.60387079e-02f, 1.01092406e-01f, 1.30974755e-01f,
  -2.99763456e-02f, 1.77818626e-01f, 1.87320933e-01f, 1.06027409e-01f, 3.15754861e-01f, -5.16790487e-02f, -1.49891585e-01f, -1.16031013e-01f, 1.42296925e-01f, 1.45843700e-01f,
  1.55118275e-02f, 7.18496069e-02f, -2.24052727e-01f, -2.54579335e-01f, 4.72194850e-02f, 1.62500471e-01f, -1.66220516e-01f, -1.39179379e-02f, -1.17529280e-01f, 2.28615716e-01f,
  1.59508869e-01f, 1.48563618e-02f, 5.64517193e-02f, -1.82235211e-01f, 2.51711905e-01f, 7.11530149e-02f, -1.18893564e-01f, -8.89392346e-02f, 1.47275567e-01f, 6.36916906e-02f,
  -7.44320452e-02f, 6.90112337e-02f, 5.73031269e-02f, -2.76037082e-02f, 5.92462979e-02f, 9.50337648e-02f, 2.17424154e-01f, 1.32099554e-01f, -1.59857586e-01f, 2.37607613e-01f,
  -2.04281509e-01f, -2.82238070e-02f, 2.02084407e-01f, 2.93238550e-01f, 2.03803316e-01f, -5.14294067e-03f, 5.09346314e-02f, 6.88286498e-02f, 6.42977878e-02f, 3.87840979e-02f,
  2.23375380e-01f, -1.53843120e-01f, -1.23284236e-01f, -1.75945833e-01f, -2.25388989e-01f, 2.59288162e-01f, -2.31071651e-01f, -1.40591459e-02f, 3.77490185e-02f, -1.07389897e-01f,
  -1.54496834e-01f, -1.50284067e-01f, 2.99579892e-02f, 2.80135367e-02f, -1.99192733e-01f, 2.86866397e-01f, 2.76108980e-02f, 4.18255366e-02f, 2.64593571e-01f, 7.27118701e-02f,
  -1.12723872e-01f, 1.44535094e-01f, -8.95704925e-02f, -7.96931162e-02f, -2.25505725e-01f, 2.01852500e-01f, -2.30582580e-01f, 8.80734622e-02f, 9.90070053e-04f, -5.87129183e-02f,
  2.78717186e-02f, -2.60161251e-01f, -7.36127980e-03f, 3.76092017e-01f, -1.20940939e-01f, -1.76581919e-01f, 3.61338466e-01f, 4.10531610e-01f, 6.76990002e-02f, 2.84242362e-01f,
  -1.24730885e-01f, -7.95748755e-02f, -3.10580522e-01f, 2.83722103e-01f, -5.93166016e-02f, 7.88804218e-02f, -1.66040566e-02f, -5.10170199e-02f, -3.24437350e-01f, 4.24933657e-02f,
  2.02841721e-02f, -1.52350441e-01f, 1.00542836e-01f, -4.07625474e-02f, 1.00500882e-01f, -1.14089645e-01f, 3.35218087e-02f, 2.22693056e-01f, -1.49444073e-01f, 1.12881206e-01f,
  3.35037149e-02f, -1.92708060e-01f, 2.06670359e-01f, 5.53384423e-02f, 9.00720730e-02f, 2.88555115e-01f, 2.79181629e-01f, -1.11955658e-01f, -1.87746003e-01f, 1.33975834e-01f,
  -2.24660024e-01f, 1.87933952e-01f, 7.37348720e-02f, -1.47851348e-01f, -7.00457990e-02f, -5.13518751e-02f, 3.95117439e-02f, 2.33089358e-01f, -7.27854297e-02f, 6.55732155e-02f,
  2.97248781e-01f, 4.74086255e-02f, 3.07582408e-01f, 1.78731810e-02f, -2.64368504e-01f, 5.02486169e-01f, 7.02714771e-02f, -6.28802031e-02f, 4.02591983e-03f, 1.44417986e-01f,
  1.30040552e-02f, 7.52997473e-02f, -3.17988038e-01f, -8.81735086e-02f, -5.18198609e-01f, -3.07222188e-01f, 1.71030879e-01f, 1.43148452e-02f, -8.87776688e-02f, -2.78363284e-02f,
  2.41316929e-01f, 1.15739349e-02f, 1.09523898e-02f, 3.24662238e-01f, -1.92632556e-01f, 2.15141401e-01f, -6.88317865e-02f, 2.39627972e-01f, 2.13952363e-02f, 2.19558120e-01f,
  -2.02435732e-01f, 8.23612977e-03f, 8.64754245e-03f, 1.14683826e-02f, 1.71122178e-01f, -1.08409584e-01f, 1.46267623e-01f, -1.66998431e-01f, -1.35097122e-02f, 5.75095676e-02f,
  1.93595126e-01f, 1.99062705e-01f, -1.64156452e-01f, -5.85505813e-02f, -1.71111926e-01f, 7.40953907e-03f, 4.79239831e-03f, 1.70951486e-01f, 2.36310035e-01f, -4.00293134e-02f,
  -8.55090022e-02f, 2.62333155e-01f, 2.78987974e-01f, 1.63331568e-01f, -7.17970952e-02f, 2.82647222e-01f, -7.17224628e-02f, 6.99676350e-02f, 4.29215908e-01f, -5.69440424e-02f,
  -1.50007784e-01f, 1.16881438e-01f, 1.19127579e-01f, -3.44452441e-01f, 1.49787053e-01f, -8.78113136e-02f, 8.45644996e-03f, 8.70870724e-02f, 2.58498222e-01f, 1.49356559e-01f,
  -4.39417437e-02f, -1.74149901e-01f, -1.21501215e-01f, -2.31694922e-01f, -1.98143721e-01f, 2.19874471e-01f, -3.65569368e-02f, 2.61929054e-02f, -2.18993142e-01f, 1.82510838e-02f,
  7.39957914e-02f, -3.66165251e-01f, 3.27802151e-01f, -1.63625985e-01f, -1.43670395e-01f, -1.37027189e-01f, 2.11984608e-02f, -6.98319916e-03f, 1.32736387e-02f, 4.25706983e-01f,
  6.07904643e-02f, -1.24076009e-01f, 4.34845418e-01f, 5.67069240e-02f, 1.72762901e-01f, -1.68493599e-01f, -1.21823484e-02f, -4.90383059e-03f, 1.16606243e-01f, 7.82886967e-02f,
  1.16025522e-01f, 1.53396115e-01f, -2.66143858e-01f, 1.35975212e-01f, -1.98270218e-03f, -4.53404218e-01f, 1.72764167e-01f, 1.47912294e-01f, 1.88805945e-02f, 1.11250132e-01f,
  -1.52523607e-01f, -3.45078349e-01f, 3.94588634e-02f, 2.97225211e-02f, -6.54569408e-03f, 2.68089950e-01f, 3.34731340e-01f, -1.29541501e-01f, 3.02156806e-02f, 1.47372127e-01f,
  7.54049420e-02f, -5.77963144e-02f, 4.16104496e-02f, 3.74619186e-01f, 4.59847488e-02f, -7.74426982e-02f, 1.47682339e-01f, -6.71334863e-02f, 3.99757922e-02f, -7.33832121e-02f,
  -1.57856777e-01f, -1.76985487e-02f, 2.64398009e-02f, -2.13182285e-01f, 1.70711920e-01f, 1.39680535e-01f, -2.61617117e-02f, -2.79683638e-02f, -1.19885400e-01f, -1.79024339e-01f,
  3.28562677e-01f, -5.16337750e-04f, 4.03384455e-02f, 1.59029052e-01f, -6.19863905e-02f, -2.75200337e-01f, -1.03922844e-01f, 2.22582355e-01f, -3.87584746e-01f, -2.17195123e-01f,
  2.39088729e-01f, 3.16571966e-02f, -5.38699999e-02f, 5.32659516e-02f, 5.86610585e-02f, -5.04358523e-02f, 3.56417626e-01f, -1.03985265e-01f, 2.18389317e-01f, 2.01960161e-01f,
  -2.22843587e-01f, 1.58613905e-01f, 8.64725932e-02f, 2.15768039e-01f, -6.96594566e-02f, 1.66749403e-01f, -1.23811498e-01f, 5.78617081e-02f, 1.50840776e-02f, -5.78280278e-02f,
  1.35267749e-01f, 3.57575357e-01f, 1.25424653e-01f, 1.61853656e-01f, 1.17925636e-01f, 4.12145853e-02f, 1.27302378e-01f, -1.37831062e-01f, -1.12190291e-01f, -5.48184700e-02f,
  2.31671870e-01f, 4.92202863e-02f, 9.49418545e-02f, -7.09639266e-02f, 6.20583445e-02f, 5.89073226e-02f, 1.05655298e-01f, -9.51939970e-02f, 9.67442468e-02f, 1.20525237e-03f,
  -4.82027465e-03f, 4.46366053e-03f, -2.37596408e-02f, 4.85252105e-02f, 1.50899872e-01f, -1.32473465e-02f, 6.95124492e-02f, -4.64472063e-02f, 1.30302399e-01f, -2.00323183e-02f,
  -1.42542168e-01f, -4.35919575e-02f, -1.51924297e-01f, -5.56378588e-02f, 3.04088235e-01f, 8.69344249e-02f, 1.15761934e-02f, 1.80669591e-01f, 1.59509014e-02f, -6.45387694e-02f,
  -3.63900512e-02f, -1.65451933e-02f, -1.49612039e-01f, 1.28469868e-02f, 2.21813262e-01f, 1.64441466e-01f, 2.50958502e-01f, 1.38151839e-01f, -5.77898547e-02f, -7.48434057e-03f,
  3.55783641e-01f, -2.76610881e-01f, -5.93786463e-02f, -1.11551449e-01f, -2.94652343e-01f, 4.00051534e-01f, -1.02457680e-01f, 2.85120569e-02f, 5.82481595e-03f, 1.99358940e-01f,
  -5.37074506e-02f, 1.69430703e-01f, -3.92692983e-01f, -7.21432120e-02f, 3.97343673e-02f, 3.64677876e-01f, 3.42508167e-01f, 2.93386746e-02f, 1.48692310e-01f, 2.12525241e-02f,
  1.38373688e-01f, 3.05566847e-01f, 2.97181547e-01f, -8.61052275e-02f, 3.14027108e-02f, 6.16764016e-02f, 1.04446970e-02f, 3.10403585e-01f, 9.78392214e-02f, 1.20687801e-02f,
  1.40693694e-01f, -5.60114123e-02f, -2.08735876e-02f, 1.47023559e-01f, 9.02558938e-02f, -4.80489805e-02f, 3.22787464e-01f, -3.76448408e-02f, 1.11472502e-01f, -6.17652722e-02f,
  8.35592523e-02f, 4.19272482e-01f, 6.32169247e-02f, 6.25589788e-02f, 2.21555494e-02f, -2.47771025e-01f, -2.70629525e-01f, -5.86916953e-02f, 9.70855728e-02f, -2.81377174e-02f,
  -5.16330063e-01f, -2.68147558e-01f, 1.46943629e-01f, -8.78530219e-02f, -3.98050696e-02f, 1.64817378e-01f, 5.59881367e-02f, -8.87877420e-02f, 1.51106060e-01f, 3.88003528e-01f,
  -1.76557541e-01f, 2.10738301e-01f, 4.83606532e-02f, 1.11398816e-01f, 3.78169239e-01f, 3.13235112e-02f, -2.39763662e-01f, 1.17716203e-02f, -1.58037454e-01f, 6.61094533e-03f,
  5.60100786e-02f, -8.03132057e-02f, 6.80928379e-02f, -1.60297066e-01f, -2.91949272e-01f, 2.08358511e-01f, 4.99950424e-02f, -1.74707085e-01f, -1.63876429e-01f, 1.60157755e-01f,
  7.20547289e-02f, -6.69672042e-02f, 4.89252694e-02f, -2.93282926e-01f, 2.54524589e-01f, -3.65786612e-01f, 1.46993473e-02f, 1.86269239e-01f, 2.51314580e-01f, 2.82661706e-01f,
  1.54603451e-01f, 2.15023398e-01f, -3.55886370e-01f, 1.06854253e-01f, 2.30172366e-01f, -5.14187776e-02f, 1.08479194e-01f, 2.76429746e-02f, 2.49090418e-01f, -1.46432910e-02f,
  2.19627768e-01f, 3.35213363e-01f, 2.00303704e-01f, -3.11642528e-01f, 1.11251079e-01f, -4.65302169e-03f, -3.98705661e-01f, -1.60960287e-01f, 4.04316664e-01f, -3.43472064e-01f,
  -9.77725834e-02f, 3.26907367e-01f, -2.37440944e-01f, -1.13304503e-01f, 1.42682061e-01f, -3.80955756e-01f, -2.39101499e-01f, 1.01793565e-01f, 1.71743289e-01f, 2.94647932e-01f,
  2.71878839e-01f, 1.72595605e-02f, -1.74648985e-01f, 3.18893194e-01f, 5.31763211e-03f, 3.76065135e-01f, 2.83610255e-01f, 1.92143902e-01f, -9.00889710e-02f, 2.09472358e-01f,
  -7.62058944e-02f, -1.17052734e-01f, 4.50355299e-02f, 1.72647044e-01f, -4.03487906e-02f, 1.68879107e-01f, -1.86990246e-01f, 4.17643040e-02f, -2.78198421e-01f, 2.33018145e-01f,
  6.53313920e-02f, -1.13104448e-01f, -7.11369962e-02f, 4.91751842e-02f, 7.89360050e-03f, -1.57303661e-01f, -4.62171644e-01f, -1.98667198e-01f, -5.21558486e-02f, -7.92168975e-02f,
  8.75450820e-02f, -3.33068073e-01f, 8.13019127e-02f, 1.17002949e-01f, -4.97310087e-02f, 1.05484858e-01f, -2.34130695e-01f, -1.48539349e-01f, -2.32364699e-01f, 1.26246527e-01f,
  -7.01997653e-02f, 1.59502551e-01f, 2.55590796e-01f, 2.32287440e-02f, 2.30228737e-01f, 2.24028856e-01f, 1.21094458e-01f, -5.84094413e-02f, 1.93499252e-01f, 1.70101836e-01f,
  -2.81708926e-01f, -2.80479819e-01f, 2.59594500e-01f, -8.17486867e-02f, 5.00087678e-01f, 3.54590654e-01f, -2.86661446e-01f, -5.18101096e-01f, 9.39968824e-02f, -2.43154377e-01f,
  7.41691664e-02f, -2.89172353e-03f, -1.19855940e-01f, 1.56647101e-01f, -1.14332542e-01f, 2.67707966e-02f, -7.15823546e-02f, 4.08879705e-02f, 2.01428652e-01f, 2.57673323e-01f,
  9.10806581e-02f, 1.49949953e-01f, -3.58781870e-03f, 9.17450264e-02f, -4.36385632e-01f, -7.09181130e-02f, -1.57843828e-01f, -9.82507691e-02f, -1.70169964e-01f, -1.85215279e-01f,
  -9.09707919e-02f, -3.58191192e-01f, -1.45116821e-01f, 2.41329283e-01f, 4.24958356e-02f, -1.80327639e-01f, -2.81898022e-01f, -1.58456624e-01f, -3.13691527e-01f, -3.21618557e-01f,
  -1.83310688e-01f, -2.32249498e-01f, 1.49406269e-01f, -4.01748359e-01f, -3.05434912e-01f, -5.35415374e-02f, -2.15266556e-01f, -6.86963722e-02f, -1.35355353e-01f, -1.43059164e-01f,
  1.43962085e-01f, 2.25499317e-01f, 1.26465559e-01f, 4.37863506e-02f, 3.11151803e-01f, 1.74507111e-01f, -3.31387818e-02f, 3.07089359e-01f, -1.54251114e-01f, -6.00670613e-02f,
  -1.03539832e-01f, -3.85088861e-01f, -1.62418447e-02f, 4.38305214e-02f, -1.35208115e-01f, -1.74075529e-01f, 2.26811156e-01f, 1.56985790e-01f, 2.20411807e-01f, -1.20320342e-01f,
  5.57635352e-02f, 3.42140555e-01f, 2.45083004e-01f, -7.86699951e-02f, 7.21567348e-02f, 3.00277323e-01f, -1.75042331e-01f, 6.21275045e-02f, 3.13323557e-01f, 1.60506651e-01f,
  1.50359096e-02f, 3.08413148e-01f, 2.13289246e-01f, -1.72167066e-02f, 5.01471125e-02f, 1.04471795e-01f, -2.11133912e-01f, 9.42187756e-02f, -9.87432748e-02f, -6.19167089e-02f,
  -1.06331557e-01f, 2.36909166e-01f, -2.71465294e-02f, -3.61502804e-02f, 2.13665012e-02f, -2.26862893e-01f, 1.32378817e-01f, 4.15598899e-02f, 1.38370693e-01f, -1.82964370e-01f,
  -4.02656257e-01f, 2.42241949e-01f, 2.59957165e-01f, -1.28573313e-01f, 1.32070959e-01f, -3.05021584e-01f, 3.51373926e-02f, -2.58392364e-01f, 5.41576259e-02f, -1.70764253e-01f,
  1.57138571e-01f, -5.22406176e-02f, -1.06204912e-01f, -2.72510834e-02f, -3.05225939e-01f, -6.73716366e-02f, 1.22372203e-01f, 6.34836545e-03f, -1.32101655e-01f, 1.09843254e-01f,
  1.46024570e-01f, 8.65972117e-02f, -4.77195196e-02f, -3.25405896e-02f, 2.03996971e-01f, -3.19474488e-02f, 5.45035191e-02f, 6.82090316e-03f, -2.90157646e-01f, -1.60433501e-01f,
  1.03166327e-01f, -1.84267670e-01f, 3.34084243e-01f, 2.28492305e-01f, -3.38420868e-01f, -2.06006750e-01f, -1.25947064e-02f, -1.47635952e-01f, -7.90356398e-02f, 2.84562647e-01f,
  1.08187377e-01f, -1.54641986e-01f, 2.50237882e-01f, 1.71489909e-01f, -2.09428027e-01f, -1.17635891e-01f, -2.17330381e-02f, 1.49988115e-01f, 1.97680369e-02f, 1.49546012e-01f,
  -2.28240654e-01f, 3.15788865e-01f, -1.88806988e-02f, 1.52784228e-01f, -1.26327246e-01f, 6.73139319e-02f, 5.04730046e-02f, 9.29879397e-02f, 6.75486727e-03f, 7.00440332e-02f,
  1.69550091e-01f, 3.07109170e-02f, 3.69598716e-02f, 1.05127491e-01f, -3.60385656e-01f, -3.27701658e-01f, -1.48478776e-01f, -1.39848858e-01f, -1.16676494e-01f, 2.55096883e-01f,
  9.73560512e-02f, -5.19956686e-02f, 2.97507830e-02f, 4.26623255e-01f, 1.34032711e-01f, 1.13107517e-01f, 2.25027889e-01f, 1.17704071e-01f, 1.50223061e-01f, 4.45665538e-01f,
  3.78601365e-02f, 3.06802213e-01f, 5.74582256e-02f, -1.88825920e-01f, 2.36210544e-02f, -1.37378797e-01f, 9.65513140e-02f, -1.25125363e-01f, -2.55060136e-01f, 1.37511443e-03f,
  1.09301969e-01f, -5.00846148e-01f, 2.25091398e-01f, 1.32309655e-02f, 9.86328423e-02f, -8.50006659e-03f, -4.45381314e-01f, -9.60527062e-02f, 1.69346586e-01f, 3.07435125e-01f,
  1.65693477e-01f, -3.36587392e-02f, -2.59555906e-01f, -2.38595411e-01f, 1.52617395e-01f, 8.42399374e-02f, -3.47686231e-01f, -1.21385947e-01f, -2.32710596e-03f, -2.81969100e-01f,
  5.68171628e-02f, 9.12655592e-02f, 1.95706278e-01f, -9.46111381e-02f, 4.52746481e-01f, -6.13130294e-02f, 3.39304388e-01f, 2.29362905e-01f, 3.51695456e-02f, -6.07836209e-02f,
  1.20726906e-01f, 3.51976246e-01f, -1.96536705e-01f, 2.42968589e-01f, -1.14633277e-01f, 5.33139240e-03f, 1.71358764e-01f, 1.03089139e-01f, 4.78931427e-01f, 5.63112944e-02f,
  -8.56170878e-02f, 5.48777692e-02f, 3.03505640e-02f, -2.98683112e-03f, 2.42974609e-02f, 1.74854517e-01f, 1.73622295e-01f, 1.44376466e-02f, 1.32191151e-01f, -6.60831295e-03f,
  1.74789459e-01f, -2.94205219e-01f, 2.77221322e-01f, 2.12775856e-01f, -1.26249328e-01f, -2.96553709e-02f, 1.66602269e-01f, 1.10145703e-01f, 3.39926668e-02f, 5.15376888e-02f,
  3.41789201e-02f, -7.28565753e-02f, 1.07914656e-02f, 1.14651002e-01f, 3.01376521e-03f, 1.58841923e-01f, 2.46068850e-01f, 2.25415185e-01f, -1.47019282e-01f, -2.08976399e-02f,
  -1.37121126e-01f, -3.56413215e-01f, -3.04691307e-02f, 2.11187676e-01f, -1.81010649e-01f, 8.18669870e-02f, 1.45000488e-01f, 4.56441604e-02f, 1.92779332e-01f, 1.04341820e-01f,
  2.34360546e-02f, -7.64738843e-02f, 2.27063313e-01f, 1.01938300e-01f, -2.51449674e-01f, -1.68443993e-01f, 6.84328973e-02f, 2.24806413e-01f, -1.37373701e-01f, -4.53275442e-02f,
  -2.53305256e-01f, -2.98702031e-01f, 4.14569795e-01f, 2.21531093e-01f, 9.77388695e-02f, -1.21027023e-01f, 1.42586619e-01f, -1.49143301e-02f, -8.21039379e-02f, 3.40850353e-02f,
  1.50894625e-02f, 1.79699972e-01f, 3.19160283e-01f, 1.45696878e-01f, 1.79300800e-01f, 8.25952366e-02f, 4.99577709e-02f, -1.35732546e-01f, 1.83903694e-01f, 8.96479040e-02f,
  9.36819762e-02f, -2.32190222e-01f, -1.10604353e-01f, 1.92267954e-01f, 8.30848515e-02f, -8.50214958e-02f, 2.41192826e-03f, 8.92841741e-02f, 1.49043813e-01f, -5.06971069e-02f,
  2.77673407e-03f, 2.31952071e-01f, 2.54304290e-01f, 4.00849730e-02f, 1.50158197e-01f, 2.04603747e-01f, 9.21752825e-02f, -2.40659758e-01f, 2.18628734e-01f, 3.63631546e-01f,
  -2.57289499e-01f, 1.04186960e-01f, 6.46094792e-03f, -1.44793063e-01f, -7.87648782e-02f, 1.06912345e-01f, -4.86421585e-02f, 8.56244266e-02f, -1.07022665e-01f, -8.65217894e-02f,
  -2.50098556e-01f, 3.77888083e-01f, 7.93036353e-03f, 1.52715463e-02f, 3.96049112e-01f, 9.27619189e-02f, -1.02759555e-01f, 1.77980676e-01f, -2.31840506e-01f, -2.09174529e-02f,
  9.60784554e-02f, 2.30468825e-01f, -1.55185223e-01f, 3.47883254e-01f, -1.45040363e-01f, -2.36142427e-01f, 3.58857095e-01f, -2.04091474e-01f, 1.76488921e-01f, 1.31807029e-01f,
  1.58811077e-01f, -1.11237295e-01f, -2.92381018e-01f, -1.10458717e-01f, 3.05001199e-01f, 6.86929226e-02f, 1.08391523e-01f, -2.84737557e-01f, -3.13049376e-01f, -8.73559788e-02f,
  3.34828317e-01f, 4.78731357e-02f, 2.42393203e-02f, 4.48059812e-02f, -2.92326421e-01f, 1.39663085e-01f, -6.53468221e-02f, -2.98608571e-01f, 8.67168382e-02f, 1.09425783e-01f,
  1.47707000e-01f, 3.58701199e-01f, 1.63536817e-01f, -3.06898672e-02f, 2.32696950e-01f, 8.62699226e-02f, -2.47867763e-01f, 1.58107251e-01f, -1.91168915e-02f, -2.38040835e-01f,
  2.03228765e-03f, -2.39302609e-02f, -1.84106201e-01f, -1.31077051e-01f, 1.27750456e-01f, -3.94702516e-02f, 2.42199108e-01f, -1.10897452e-01f, 1.03925213e-01f, -6.54131100e-02f,
  -3.15801322e-01f, 3.65798175e-01f, 1.18251346e-01f, -3.43624316e-02f, -1.77569427e-02f, 1.22160120e-02f, 2.08679214e-01f, -6.79646134e-02f, 3.84091854e-01f, -2.60646753e-02f,
  1.16507985e-01f, 1.64277643e-01f, -1.61401212e-01f, -1.13677457e-01f, 1.14517763e-01f, -8.22917372e-02f, -6.75750896e-02f, 1.31769165e-01f, 2.00225085e-01f, 2.46809602e-01f,
  2.80794293e-01f, 1.02713555e-01f, 4.75229383e-01f, 2.54453421e-01f, -1.15187662e-02f, 1.79175213e-01f, 8.77228528e-02f, -7.50202537e-02f, 2.85481125e-01f, -1.47782549e-01f,
  -6.18642978e-02f, 3.29861015e-01f, 1.58988297e-01f, 5.38066506e-01f, -5.18026389e-02f, 5.54815196e-02f, 3.25666666e-02f, 3.94360386e-02f, -8.18024054e-02f, -9.30230841e-02f,
  3.29564475e-02f, -4.57387008e-02f, 5.80106452e-02f, -2.16200650e-01f, -1.13588162e-01f, -2.19097048e-01f, -3.69234979e-02f, 4.43158410e-02f, -2.54086733e-01f, -1.74007602e-02f,
  1.40955597e-01f, 9.13827270e-02f, 3.34325843e-02f, 8.98682624e-02f, -3.78984096e-03f, -3.73053811e-02f, -7.83177763e-02f, 1.35645433e-03f, -3.57086390e-01f, -2.83176035e-01f,
  -8.04601237e-02f, 2.01728880e-01f, 3.65020111e-02f, 2.12850913e-01f, -2.13368997e-01f, -1.52525350e-01f, 1.46039635e-01f, 1.94163378e-02f, 1.61879808e-01f, -2.66458951e-02f,
  -6.65552840e-02f, -4.35397550e-02f, -1.87267393e-01f, -6.26369640e-02f, -4.26980741e-02f, -1.47760078e-01f, 5.18154621e-01f, 1.97522908e-01f, 6.01815805e-02f, -6.44961819e-02f,
  9.32407230e-02f, -5.48616499e-02f, 3.21331955e-02f, 1.87507495e-01f, -2.87416965e-01f, -9.70832855e-02f, -2.76430845e-01f, -1.29329428e-01f, 4.15295884e-02f, -1.70149043e-01f,
  3.37297618e-01f, 2.41058543e-01f, -2.13074461e-01f, 6.56665536e-03f, -3.57891768e-01f, -2.01881491e-02f, -4.10297632e-01f, -2.22110242e-01f, -2.30910316e-01f, 1.24040201e-01f,
  9.96034499e-03f, 7.10721463e-02f, -7.00226277e-02f, -1.47077382e-01f, 1.48427084e-01f, -9.78187025e-02f, 4.98963259e-02f, -2.76322305e-01f, 2.18189865e-01f, 9.48439762e-02f,
  1.08242936e-01f, 2.61285026e-02f, -7.89759979e-02f, -7.40811825e-02f, 1.99828316e-02f, -1.97180405e-01f, -1.20134115e-01f, -1.07795820e-01f, -2.28377149e-01f, 1.08109728e-01f,
  3.14016156e-02f, -7.29729980e-02f, 2.48843372e-01f, 1.44480392e-01f, -2.95361817e-01f, 4.26676013e-02f, -5.80383241e-02f, -1.47438362e-01f, 2.37821192e-01f, 9.93129909e-02f,
  1.68838333e-02f, 5.14466465e-01f, 1.67982519e-01f, -2.27948114e-01f, -5.09623438e-02f, -1.98307037e-01f, -1.56336457e-01f, -4.78425212e-02f, 2.47754216e-01f, 5.76337613e-02f,
  -5.13591915e-02f, 7.59315863e-02f, -7.90787954e-03f, -1.06100149e-01f, -8.92518670e-04f, 1.09234631e-01f, 2.64343172e-01f, 1.59077309e-02f, -1.94975406e-01f, 1.28587916e-01f,
  1.23551479e-02f, -5.71351796e-02f, 2.75590092e-01f, 1.06624432e-01f, 1.17306925e-01f, -2.93959588e-01f, 1.68741792e-01f, 9.04665962e-02f, 3.08487262e-03f, 3.09673488e-01f,
  2.95824796e-01f, 3.00810724e-01f, 7.93275088e-02f, 2.37417355e-01f, 1.21598825e-01f, 2.29165420e-01f, 2.11622238e-01f, 5.76612167e-02f, -2.54610151e-01f, 1.95980281e-01f,
  9.68503058e-02f, 3.38515967e-01f, 1.11377575e-01f, 7.74655398e-03f, -3.05572618e-02f, 1.72729865e-01f, 1.08155690e-01f, 1.31122351e-01f, -3.85449524e-03f, 4.76934724e-02f,
  1.78728014e-01f, 4.03271466e-02f, -1.30032837e-01f, -2.67798334e-01f, 1.20298557e-01f, 1.67370364e-01f, 1.77304342e-01f, -2.84458436e-02f, 5.20147718e-02f, 7.76823536e-02f,
  -3.81505400e-01f, 2.02762321e-01f, 2.94836253e-01f, 4.99829426e-02f, -1.91004604e-01f, -3.46197225e-02f, -6.72748089e-02f, -2.15956345e-02f, 8.22867826e-02f, 8.79918225e-03f,
  -9.43173915e-02f, 1.12889916e-01f, -3.79826099e-01f, 1.80235684e-01f, 1.35977075e-01f, -3.12050898e-02f, -2.28472292e-01f, 7.91594386e-02f, 9.36176479e-02f, -7.81672522e-02f,
  -1.55704707e-01f, -5.02713816e-03f, -3.92862827e-01f, -3.76372904e-01f, -2.30176851e-01f, 5.05525917e-02f, 1.58069625e-01f, -2.41605073e-01f, -1.44433573e-01f, -2.00822502e-02f,
  1.88549131e-01f, -2.58992851e-01f, -5.22851385e-02f, -2.23718490e-02f, -4.60905433e-02f, -3.57765496e-01f, 4.91672456e-01f, -3.68638396e-01f, 2.27881253e-01f, -3.08358908e-01f,
  -2.23628342e-01f, -7.13565275e-02f, -6.70007542e-02f, 6.89747464e-03f, -1.92179874e-01f, -2.09405988e-01f, -1.92729272e-02f, -5.01090065e-02f, -1.94503561e-01f, -2.51333207e-01f,
  -9.64343920e-02f, 1.51575282e-01f, -2.43250072e-01f, 3.34118813e-01f, -6.88613625e-04f, -8.35903361e-02f, 8.47078040e-02f, 4.48976718e-02f, -9.71630067e-02f, 1.06297374e-01f,
  -1.77459463e-01f, 6.84238300e-02f, 2.67197769e-02f, -2.16517895e-02f, -1.12368405e-01f, -1.84253529e-01f, -1.13002479e-01f, 1.10812813e-01f, -5.10003380e-02f, -1.81834817e-01f,
  -3.51367630e-02f, 2.00792417e-01f, -1.94507495e-01f, -1.84776381e-01f, 3.59335542e-01f, 3.44025701e-01f, 1.53752893e-01f, 3.18924278e-01f, -2.31453255e-01f, -2.02926751e-02f,
  -1.44831523e-01f, 1.38694406e-01f, -1.68195650e-01f, 5.42237312e-02f, -1.82760015e-01f, -7.00493157e-02f, -2.51118004e-01f, 3.55719268e-01f, -7.17989653e-02f, -6.05715513e-02f,
  9.86145288e-02f, -1.03657037e-01f, 9.31192189e-02f, 5.23226522e-02f, 1.53090426e-07f, 4.63333121e-03f, -3.55102062e-01f, 3.26088786e-01f, 3.61344188e-01f, 5.99538945e-02f,
  7.38315731e-02f, 1.13500297e-01f, 2.71297544e-01f, -2.00860545e-01f, -2.58510113e-01f, 8.83722529e-02f, 4.09390777e-02f, -9.91738588e-02f, -1.91356868e-01f, -2.04324633e-01f,
  -2.13940173e-01f, -4.02208641e-02f, 5.01840152e-02f, -6.97972402e-02f, -1.61256611e-01f, 1.19705096e-01f, -3.58389467e-02f, 3.83040696e-01f, -2.99407393e-02f, 3.65209766e-02f,
  -1.07634448e-01f, -7.59248957e-02f, 1.01001605e-01f, -5.05229175e-01f, -3.05405885e-01f, -2.88313419e-01f, 2.95823246e-01f, 4.93919589e-02f, 1.05559818e-01f, 7.42699951e-02f,
  1.08933430e-02f, 4.89416206e-03f, 3.37081403e-01f, 1.61023274e-01f, -1.97087348e-01f, -4.94837621e-03f, -8.63448605e-02f, -6.43557161e-02f, 1.69883788e-01f, 1.72307283e-01f,
  1.36225805e-01f, -2.87618756e-01f, 6.14937305e-01f, -5.81270680e-02f, -1.97834279e-02f, 1.00285240e-01f, -1.08744264e-01f, 1.38971522e-01f, 2.61233181e-01f, 2.29340822e-01f,
  -1.39832646e-01f, -3.80270183e-02f, 7.82096460e-02f, 1.49452120e-01f, -1.49259835e-01f, 3.40959281e-01f, 3.60019654e-01f, 8.13073292e-02f, -2.53720097e-02f, 2.86550641e-01f,
  -2.34015454e-02f, -1.78336367e-01f, -2.66965717e-01f, 1.03093460e-01f, 1.23826982e-02f, 1.67842507e-01f, 3.22621204e-02f, -1.07113466e-01f, 1.16262041e-01f, -3.51974428e-01f,
  6.70649111e-03f, 1.58990741e-01f, -8.07961598e-02f, -3.23429376e-01f, 1.38728410e-01f, 1.86525583e-02f, -2.07166493e-01f, -4.97556739e-02f, 4.64074500e-03f, -7.62817562e-02f,
  -2.86301970e-02f, 1.67645961e-01f, -2.79714204e-02f, -9.57836397e-03f, 2.59359125e-02f, 1.80093527e-01f, -1.07836261e-01f, -3.10318861e-02f, 1.91481650e-01f, 1.39403120e-01f,
  -3.28542173e-01f, 4.26785886e-01f, -5.93059473e-02f, -1.97006837e-01f, 4.56783175e-02f, -1.63103998e-01f, 3.80731821e-02f, 7.85882398e-02f, -1.02400199e-01f, 1.05552748e-01f,
  -2.50882417e-01f, -1.32639080e-01f, -8.63575041e-02f, 2.22314790e-01f, 1.81976587e-01f, 4.42815237e-02f, -2.15189019e-03f, -4.63905334e-02f, -1.50390714e-01f, 2.11254090e-01f,
  8.95364955e-02f, 1.36742741e-01f, -3.28886956e-02f, 1.50103182e-01f, -2.83765167e-01f, 2.23750740e-01f, 1.08071893e-01f, -1.14087142e-01f, 1.98199630e-01f, 2.54825294e-01f,
  1.80118755e-01f, -3.44785124e-01f, 3.10170323e-01f, 3.04268003e-01f, 1.07353050e-02f, -5.12354374e-02f, 8.15819204e-02f, 2.85344459e-02f, 3.11542630e-01f, 3.57450753e-01f,
  -7.17159957e-02f, 3.83649111e-01f, 3.18356633e-01f, 1.19584657e-01f, 1.93413302e-01f, -7.72988051e-02f, 2.12697685e-01f, -5.57073504e-02f, 2.77586401e-01f, 2.02124253e-01f,
  -6.84488565e-02f, -5.54102622e-02f, 4.81605977e-02f, -8.77014026e-02f, -1.52202472e-01f, -1.52992323e-01f, 2.54580230e-01f, -2.13224962e-01f, 2.13819951e-01f, 1.88406125e-01f,
  -3.06897134e-01f, -5.71075594e-03f, 4.97972816e-01f, 2.52412111e-01f, -1.04521364e-01f, -9.55419466e-02f, -3.72830868e-01f, -3.57717313e-02f, -4.40067127e-02f, 1.46239966e-01f,
  -2.00976118e-01f, 7.53049329e-02f, 2.82167941e-02f, -5.24322689e-02f, 2.10156694e-01f, 9.67371929e-03f, 1.58315912e-01f, -3.94755185e-01f, 2.17646867e-01f, -1.66046426e-01f,
  -2.03862026e-01f, -9.93283466e-03f, 1.84321225e-01f, 8.57976452e-02f, 1.71976220e-02f, -5.54333553e-02f, 2.66591638e-01f, 1.20384358e-01f, 1.72986001e-01f, -2.14655716e-02f,
  3.03320676e-01f, -5.52942380e-02f, 3.45681980e-02f, 2.19085500e-01f, -2.38671452e-02f, 4.16327864e-02f, -6.71585724e-02f, 1.18820004e-01f, 5.14142275e-01f, -2.61440761e-02f,
  1.08582951e-01f, 3.20170760e-01f, -2.31217220e-02f, 2.17682064e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  1.84332803e-02f, 1.71541274e-01f, 2.10861325e-01f, 6.66695982e-02f, -1.23831280e-01f, 1.60497665e-01f, 7.99661726e-02f, 2.59199619e-01f, 2.14069039e-02f, 1.33029483e-02f,
  3.47757451e-02f, 1.02353610e-01f, 4.43141311e-02f, -4.94844187e-03f, 2.30644241e-01f, 1.03173479e-04f, -8.32086280e-02f, 4.55066264e-02f, 9.08144712e-02f, 9.74347815e-02f,
  9.24057662e-02f, 1.18221559e-01f, 1.21069863e-01f, 6.55582771e-02f, 1.58838615e-01f, -3.10339257e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  8.56958404e-02f, 2.18101710e-01f, 4.06249501e-02f, -1.78187624e-01f, 7.81273469e-02f, -4.90765646e-02f, -1.09983690e-01f, -2.07042187e-01f, -2.23512098e-01f, 1.06151015e-01f,
  -6.66326061e-02f, -2.56284207e-01f, 1.05367839e-01f, 2.15406060e-01f, -3.00013185e-01f, -1.16774119e-01f, -1.23456299e-01f, -1.13202959e-01f, -2.02789545e-01f, -1.57931931e-02f,
  5.89419752e-02f, -1.49337888e-01f, -1.91488802e-01f, 1.14435323e-01f, 1.77733198e-01f, 2.32687250e-01f, 1.50030166e-01f, 4.04471382e-02f, -1.72829241e-01f, -3.02033186e-01f,
  1.04867823e-01f, 8.47645402e-02f, 1.66532978e-01f, -1.21873438e-01f, -5.36169931e-02f, 2.02736035e-01f, -1.79949358e-01f, -1.55805022e-01f, -2.52883732e-01f, -2.50086397e-01f,
  -3.98322254e-01f, -1.68986738e-01f, -1.85214922e-01f, 1.05165213e-01f, -3.61763537e-01f, -3.10751051e-01f, 9.08546075e-02f, 1.95823073e-01f, 1.67652424e-02f, -4.67519253e-01f,
  -1.07400134e-01f, 3.59693319e-01f, -1.64809395e-02f, -2.79080868e-01f, 1.94770068e-01f, -2.91542143e-01f, -4.84810770e-02f, -3.06629628e-01f, 2.24012211e-01f, -3.36153626e-01f,
  2.22380713e-01f, -1.45355254e-01f, 1.71611652e-01f, -3.60106677e-01f, -5.47286794e-02f, -1.05923049e-01f, 2.30945081e-01f, 1.64171178e-02f, 4.50719558e-02f, 1.77106738e-01f,
  2.07734048e-01f, -4.87335026e-02f, 1.26275927e-01f, 2.53881514e-01f, -7.54102468e-02f, -6.33446500e-02f, -1.14296280e-01f, 2.52660453e-01f, -1.78631559e-01f, 1.27769068e-01f,
  9.31462348e-02f, 5.08821085e-02f, -1.31015673e-01f, 1.49811253e-01f, -1.13910325e-01f, -1.60744563e-01f, 8.37550759e-02f, -9.95484218e-02f, 7.90747181e-02f, -6.65527657e-02f,
  -2.97135651e-01f, 2.33699426e-01f, -1.30589176e-02f, 2.03031138e-01f, 7.24666864e-02f, -8.84637758e-02f, 3.28394249e-02f, 1.92719504e-01f, -3.06536425e-02f, -1.29132956e-01f,
  1.68507829e-01f, 1.41149014e-01f, -5.11146076e-02f, -3.32381457e-01f, 1.39275804e-01f, -4.48543489e-01f, 1.24866329e-01f, 2.71700859e-01f, 1.75077975e-01f, -3.20251286e-01f,
  -3.53246957e-01f, -6.82719350e-02f, -2.85251260e-01f, -1.95979744e-01f, -1.72023967e-01f, -2.95225549e-02f, 1.93080962e-01f, -4.07601714e-01f, -1.15574077e-01f, 1.63204759e-01f,
  3.86369191e-02f, -5.42844040e-03f, 3.73933241e-02f, -3.81571174e-01f, 1.30372882e-01f, 8.74079466e-02f, 1.98052242e-01f, 4.60313857e-02f, -7.89207034e-03f, -6.67515560e-05f,
  -1.24678105e-01f, 2.69470047e-02f, 6.20018542e-02f, 7.10821748e-02f, 2.18880206e-01f, 8.99824724e-02f, 1.33970141e-01f, 3.50250959e-01f, -8.54776427e-02f, 1.62925914e-01f,
  -4.19909656e-01f, 1.73357487e-01f, 6.20902292e-02f, 2.52573431e-01f, 1.11023372e-03f, -2.60689914e-01f, -3.47384326e-02f, -9.57611054e-02f, 8.97956360e-03f, -2.10120648e-01f,
  3.36032867e-01f, 9.20531601e-02f, -2.73492306e-01f, 2.64413357e-01f, -2.41725817e-01f, -1.05886482e-01f, -8.54276940e-02f, 8.54205154e-03f, -2.84421533e-01f, -2.09651589e-01f,
  -1.11155465e-01f, -1.30336717e-01f, -2.86462784e-01f, -6.17807917e-02f, -9.19753090e-02f, -2.67888576e-01f, -2.46354952e-01f, -6.31154597e-01f, 2.06301734e-01f, 9.81713608e-02f,
  3.65332444e-03f, -2.36151628e-02f, 3.62708233e-02f, -4.37510498e-02f, -1.23335226e-02f, 2.95684133e-02f, 1.72362611e-01f, 7.24587068e-02f, -5.06673813e-01f, 3.15622419e-01f,
  -1.76109269e-01f, -3.94052923e-01f, 1.17456332e-01f, -3.80975246e-01f, 2.92271256e-01f, -4.31008339e-01f, -1.12611882e-01f, -8.59854519e-02f, 1.82231367e-01f, 3.53128165e-02f,
  -2.92700857e-01f, 6.21270761e-02f, 7.57764950e-02f, -4.30291355e-01f, 1.16231237e-02f, 1.03796847e-01f, -4.11117703e-01f, -1.13618143e-01f, -1.73166022e-01f, -4.22570050e-01f,
  -1.43862054e-01f, -7.60425851e-02f, -1.27949074e-01f, -4.36572701e-01f, -1.49316788e-01f, -2.93063670e-01f, -2.91536659e-01f, -6.69386191e-03f, 2.04359233e-01f, -6.81175068e-02f,
  1.43774480e-01f, -9.87941697e-02f, 4.22225669e-02f, 1.51807517e-01f, -1.24555290e-01f, -2.15004012e-01f, -1.99415743e-01f, -8.81696269e-02f, 1.49590224e-01f, -1.43856794e-01f,
  1.24898449e-01f, -3.06777298e-01f, -1.05841964e-01f, -2.13595107e-01f, -1.28754348e-01f, -3.19891185e-01f, 1.19259119e-01f, -8.42280686e-02f, 5.83432496e-01f, -3.56091466e-03f,
  3.78489316e-01f, -6.16354309e-02f, -2.38445118e-01f, 2.00691804e-01f, 1.65026903e-01f, 9.77533981e-02f, -6.25197813e-02f, -4.47943032e-01f, 8.69629011e-02f, 9.26992446e-02f,
  7.85087720e-02f, -1.85069963e-01f, -1.93429455e-01f, -1.78980604e-01f, -4.87979680e-01f, -1.66046955e-02f, 1.44695774e-01f, -1.38569564e-01f, -6.12885416e-01f, -5.73582053e-01f,
  -3.87040041e-02f, -2.78401792e-01f, 1.11318287e-02f, 1.23150140e-01f, 1.70013681e-01f, 1.20856754e-01f, -1.18506677e-01f, -8.21610093e-02f, 4.83194999e-02f, -3.04682344e-01f,
  8.69595185e-02f, 9.89824086e-02f, -6.64746687e-02f, 1.74156040e-01f, 4.39013578e-02f, -1.36058807e-01f, -7.53541216e-02f, 2.17681408e-01f, 1.36340022e-01f, -1.75344780e-01f,
  2.34651148e-01f, -2.44490981e-01f, -1.46237239e-01f, 1.22451782e-01f, -1.54368043e-01f, 1.34831905e-01f, -1.13717116e-01f, 1.92809477e-01f, -1.70829162e-01f, -1.84385702e-01f,
  -2.14631349e-01f, -1.68691114e-01f, 2.52970189e-01f, -4.18632664e-02f, -1.22894824e-01f, 2.62661755e-01f, 2.78212368e-01f, 7.51076918e-03f, 2.01947823e-01f, 2.21867532e-01f,
  3.94784927e-01f, -1.64368048e-01f, -2.04543650e-01f, -5.39729185e-02f, -2.77029544e-01f, -5.19515909e-02f, -4.26004261e-01f, 1.29609510e-01f, -3.75723280e-02f, -1.45364016e-01f,
  -2.98482835e-01f, 2.90438652e-01f, 1.72841221e-01f, 1.95562109e-01f, 2.05943555e-01f, -3.74237150e-01f, -4.08497036e-01f, -1.84114218e-01f, -3.18867490e-02f, 3.74423154e-02f,
  -7.73207285e-03f, -2.42840827e-01f, -1.62865147e-01f, 5.90208545e-02f, 1.65368095e-01f, 1.70983240e-01f, -6.80030435e-02f, 1.36424735e-01f, -6.14673905e-02f, 1.11255392e-01f,
  3.15802358e-02f, 7.56971315e-02f, 2.02620387e-01f, 2.58623272e-01f, -7.81704858e-02f, -2.18650132e-01f, -2.25467727e-01f, 1.43505588e-01f, -1.38971001e-01f, 7.15180710e-02f,
  1.47728220e-01f, 3.58807802e-01f, -2.12985519e-02f, 9.31009874e-02f, -1.41027765e-02f, 1.06506847e-01f, 1.06968567e-01f, 7.50463903e-02f, 9.15718079e-02f, 2.60615200e-01f,
  1.03632472e-01f, 2.45462507e-02f, 8.60904530e-02f, -9.75013152e-02f, -2.49916408e-02f, 1.50197446e-01f, -2.88507849e-01f, 1.10041358e-01f, -1.75153017e-01f, -3.19565088e-01f,
  6.67294767e-03f, 1.36620298e-01f, -1.84158944e-02f, 2.57745117e-01f, 2.17990384e-01f, 1.40464708e-01f, -9.29966290e-03f, -4.23495650e-01f, -3.87880385e-01f, 2.22289592e-01f,
  6.94795549e-02f, -4.15554903e-02f, 1.87921032e-01f, -1.02658674e-01f, 6.60865977e-02f, -1.20358750e-01f, 1.79742090e-02f, -2.78862536e-01f, 1.67436106e-03f, -3.49821687e-01f,
  -7.45166615e-02f, -2.20350027e-01f, -3.06981236e-01f, 3.00882123e-02f, 2.17637777e-01f, 1.93081751e-01f, 5.64432666e-02f, 1.27699837e-01f, 1.16620257e-01f, -2.05218256e-01f,
  -1.99473411e-01f, -2.08517954e-01f, 4.55238856e-02f, 2.98267931e-01f, 1.56532809e-01f, -9.59913656e-02f, -1.02770016e-01f, -6.17200509e-02f, 3.01081985e-02f, -2.40501780e-02f,
  -7.06355125e-02f, -1.13515314e-02f, 3.03645343e-01f, -1.61362439e-01f, 1.64323360e-01f, 5.13989897e-03f, 2.80561507e-01f, -2.15350732e-01f, 1.75204314e-02f, -2.11714879e-01f,
  1.43420622e-01f, 1.54782385e-01f, -9.96472761e-02f, -1.45109534e-01f, 1.98362321e-02f, 7.80814048e-03f, 1.09126717e-01f, 1.61030114e-01f, 2.20605269e-01f, -6.38321489e-02f,
  -2.31801808e-01f, -2.02448949e-01f, -1.43976072e-02f, 1.05502233e-02f, -1.67071506e-01f, 2.06456427e-02f, -2.57744789e-01f, -1.34489402e-01f, -1.58207253e-01f, 3.69714499e-01f,
  -3.08730483e-01f, 1.09462045e-01f, -3.01587850e-01f, 1.34424895e-01f, 2.65882127e-02f, 1.49194062e-01f, -6.82560727e-02f, -2.45655313e-01f, 1.73115522e-01f, 1.90778468e-02f,
  -4.48177367e-01f, -5.61168015e-01f, 5.55702820e-02f, 2.16530547e-01f, 1.94180757e-01f, -1.22066893e-01f, 2.26921424e-01f, -4.26361114e-01f, -1.96034178e-01f, 2.60966718e-01f,
  -8.10958296e-02f, -1.23815902e-01f, 1.33129777e-02f, -5.46944849e-02f, -9.85402465e-02f, -5.57062685e-01f, -5.33455722e-02f, -8.12231749e-02f, -5.28942384e-02f, -6.83087856e-02f,
  -1.35020718e-01f, -2.62925830e-02f, -1.93253636e-01f, 8.35881829e-02f, -2.31812708e-02f, -9.28014424e-03f, 9.99022946e-02f, -6.45771697e-02f, 6.66276459e-03f, 6.77951574e-02f,
  -2.47486055e-01f, 5.42714559e-02f, 1.10535221e-02f, -9.31592099e-03f, -2.43649166e-02f, -1.15781114e-01f, 7.67353699e-02f, -9.00034308e-02f, 1.60429448e-01f, 9.97689590e-02f,
  -1.03417411e-01f, 8.89371037e-02f, -9.58543494e-02f, -1.02103598e-01f, 1.76603720e-01f, -1.02844961e-01f, 9.89595205e-02f, 1.84905738e-01f, -6.96438318e-03f, -6.61948323e-02f,
  1.59792870e-01f, 2.51919422e-02f, 3.40470709e-02f, -2.88047135e-01f, 2.24538758e-01f, -8.52699112e-03f, 9.50509980e-02f, -6.22586310e-02f, -2.59026978e-02f, 4.56074588e-02f,
  -1.99380875e-01f, -2.04209417e-01f, -3.67670566e-01f, -2.18441695e-01f, -1.68994546e-01f, 1.64492521e-02f, -5.31003177e-01f, 7.85244852e-02f, 2.61996746e-01f, 1.62878647e-01f,
  1.58379987e-01f, -1.32586420e-01f, -1.76396459e-01f, -2.48168811e-01f, -4.00308967e-02f, 3.23301166e-01f, -9.26721171e-02f, 9.23386440e-02f, -3.08159828e-01f, 2.22216204e-01f,
  -1.15544640e-01f, -2.25536779e-01f, -2.14402020e-01f, 9.87495929e-02f, -1.85066178e-01f, -3.32250655e-01f, 5.19926008e-03f, 1.68391854e-01f, 1.27593622e-01f, 4.89674062e-02f,
  -1.44237816e-01f, -1.57209337e-01f, -2.48289675e-01f, -1.80653989e-01f, 1.22947350e-01f, 3.25733244e-01f, -2.85604060e-01f, 1.80919558e-01f, -4.36427504e-01f, -2.51379311e-01f,
  -5.88826165e-02f, -2.40389541e-01f, -1.69615254e-01f, -2.10394964e-01f, 1.10073991e-01f, -2.80545373e-02f, 6.21036477e-02f, 4.98214103e-02f, 2.27052510e-01f, -3.95376459e-02f,
  4.69483346e-01f, 1.87824145e-01f, -1.12420462e-01f, -2.07343400e-02f, -4.53717262e-02f, -2.21408866e-02f, 1.53313592e-01f, -3.01614925e-02f, -2.42767483e-01f, -1.33496374e-01f,
  3.41853112e-01f, 1.27853185e-01f, 9.41919610e-02f, -2.83936083e-01f, 1.04061514e-01f, -2.44064555e-01f, -2.69300342e-01f, -5.03457129e-01f, 2.61813372e-01f, -3.01315188e-01f,
  -2.06279770e-01f, -4.09736425e-01f, -1.38418436e-01f, -1.83116987e-01f, -7.14667588e-02f, 1.50551245e-01f, -6.27999902e-01f, -1.95388451e-01f, 1.01753891e-01f, -1.48731455e-01f,
  7.39278793e-02f, -1.58478727e-03f, -4.82933402e-01f, 1.39673874e-01f, 4.34452891e-02f, 4.96893898e-02f, -2.22777620e-01f, 2.29615137e-01f, -2.44239897e-01f, 2.22595528e-01f,
  -5.56017505e-03f, 1.00391105e-01f, 1.68902755e-01f, 8.47905353e-02f, -1.59436613e-01f, 7.94231370e-02f, -2.58640591e-02f, 1.47458583e-01f, -8.43723267e-02f, 1.39180347e-01f,
  8.73505771e-02f, 2.53054738e-01f, 3.89408730e-02f, 1.36089742e-01f, 1.08348519e-01f, 9.48931575e-02f, 1.11366488e-01f, 9.98985395e-02f, 4.99781631e-02f, 2.77418345e-01f,
  -2.99739808e-01f, -3.04775476e-01f, -2.11694419e-01f, 6.07612543e-02f, -7.58627579e-02f, -4.70601708e-01f, 3.32499072e-02f, -1.63330585e-01f, 3.78757983e-01f, -3.12006503e-01f,
  -1.86227128e-01f, 2.83987343e-01f, -3.18627711e-03f, 3.61587614e-01f, 2.47794047e-01f, -2.86544681e-01f, 3.48566100e-02f, 2.21744671e-01f, -3.59024167e-01f, -2.55480558e-01f,
  1.44815147e-01f, 2.79146254e-01f, -1.13441311e-01f, -1.68403499e-02f, 1.99520022e-01f, 1.42385349e-01f, 2.88266540e-01f, -1.28504187e-01f, -1.12921834e-01f, 1.54059730e-03f,
  -1.74023792e-01f, -3.24090719e-01f, -4.84296232e-01f, 5.98577857e-02f, -5.48826814e-01f, 1.00498304e-01f, -1.02573559e-02f, -4.57463473e-01f, -3.66625667e-01f, -3.42480421e-01f,
  4.97390218e-02f, 7.80261904e-02f, -2.15910316e-01f, 6.27824962e-02f, 1.28518805e-01f, -7.50459656e-02f, 6.45518079e-02f, -2.57389769e-02f, 9.07242894e-02f, -1.60190016e-02f,
  3.03842500e-02f, -3.68110955e-01f, -1.73467427e-01f, -1.79468334e-01f, 2.75741547e-01f, -2.24677905e-01f, -1.80043951e-01f, -1.37811273e-01f, 3.76129150e-02f, 1.73108846e-01f,
  -1.48728326e-01f, 1.21856704e-01f, -1.39112085e-01f, -1.36174545e-01f, 3.46617877e-01f, 1.59454778e-01f, 2.71708488e-01f, 9.68139917e-02f, -1.12900883e-01f, 2.14209065e-01f,
  1.44873753e-01f, 2.76631057e-01f, -2.04425186e-01f, -1.21435784e-01f, 2.31844455e-01f, 1.28320441e-01f, 2.47531861e-01f, 1.63875028e-01f, -1.49105117e-01f, -2.81968638e-02f,
  -5.33018172e-01f, 3.15126032e-02f, 4.50567231e-02f, 2.63573378e-01f, 1.88515738e-01f, -1.87819421e-01f, -1.55191198e-01f, -1.50904700e-01f, 1.93216220e-01f, -3.06027204e-01f,
  -2.95623332e-01f, 2.84931123e-01f, -5.07416785e-01f, -1.91587746e-01f, -1.73835352e-01f, 3.23514938e-01f, -2.01086685e-01f, -4.47952807e-01f, -1.95231184e-01f, 7.15047479e-01f,
  -1.21409642e-02f, -2.91031510e-01f, 3.37941721e-02f, -2.64087647e-01f, 2.24346727e-01f, -9.55119822e-03f, 2.54277825e-01f, -1.28300294e-01f, 2.22546130e-01f, 6.95825741e-02f,
  2.30329186e-01f, 2.34444235e-02f, -1.91584036e-01f, -1.32421046e-01f, 1.40523305e-02f, -1.73268571e-01f, 1.80040866e-01f, -8.06647539e-02f, 3.38551402e-01f, 7.73393288e-02f,
  2.55529374e-01f, 1.21894822e-01f, 3.97643857e-02f, 1.57711819e-01f, 3.58939797e-01f, -4.88848612e-02f, -3.00709587e-02f, 2.48094276e-01f, 2.81028867e-01f, -3.42206508e-01f,
  1.89449564e-01f, 2.56388098e-01f, 2.02998847e-01f, 1.36358023e-01f, 1.58457377e-03f, 6.37230203e-02f, -1.58492908e-01f, -5.15430942e-02f, -1.39424384e-01f, -3.59825522e-01f,
  2.63909131e-01f, -1.96553141e-01f, 7.91827440e-02f, 2.66998082e-01f, 7.50955567e-02f, -2.80568123e-01f, 4.21054959e-02f, -1.66324779e-01f, -4.31100816e-01f, 2.81864017e-01f,
  -3.82581819e-03f, 5.64108081e-02f, -3.75344932e-01f, 2.40679532e-01f, -3.05056900e-01f, -3.90308380e-01f, -5.63297234e-02f, 2.98348069e-01f, -2.38770410e-01f, 9.91751254e-02f,
  7.04436973e-02f, -2.98222154e-01f, -4.45057213e-01f, 6.51605427e-02f, -1.16138756e-01f, 2.80201547e-02f, -6.41882718e-01f, 7.73974136e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  5.08585721e-02f, 3.86509299e-02f, -9.54792127e-02f, -3.56584266e-02f, -1.90066043e-02f, 1.47062853e-01f, 1.65348828e-01f, 6.05029687e-02f, -1.35145336e-01f, -6.31847903e-02f,
  3.23722176e-02f, -6.75859079e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    