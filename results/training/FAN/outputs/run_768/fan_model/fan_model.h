/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.31972510e-02f, -3.17524195e-01f, -3.21345925e-01f, -3.46190065e-01f, -8.94854292e-02f, -1.17184175e-02f, -1.84430897e-01f, 5.47676161e-02f, -2.21681073e-02f, -1.80297956e-01f,
  1.07134216e-01f, 2.80676752e-01f, 1.41213730e-01f, 1.66891351e-01f, 4.15836722e-02f, -3.25633675e-01f, -3.97117496e-01f, -1.08218253e-01f, 9.12428498e-02f, 1.07928373e-01f,
  -4.10382785e-02f, -1.46439314e-01f, 5.56455515e-02f, -9.16208550e-02f, -2.04384670e-01f, 4.55872295e-03f, -2.09552795e-01f, -1.44518642e-02f, -7.01456964e-02f, -4.17363286e-01f,
  -2.07016557e-01f, -1.68115854e-01f, 2.01736107e-01f, 1.00942403e-01f, -2.01761406e-02f, 6.06701188e-02f, 3.45858373e-02f, 1.28773749e-02f, 1.50361955e-01f, -3.00559271e-02f,
  8.71022046e-02f, 8.34288597e-02f, 4.69875475e-03f, 3.70084979e-02f, 4.24576661e-04f, 5.07898331e-02f, -1.62093993e-02f, -1.18847989e-01f, -6.25219345e-02f, -3.29447202e-02f,
  -7.99653381e-02f, -3.67338285e-02f, -2.91075800e-02f, 7.56925941e-02f, 7.21802786e-02f, 9.35598984e-02f, 4.25473005e-02f, -1.86379347e-02f, 6.89800009e-02f, -2.35246718e-01f,
  -3.33420858e-02f, 1.50621673e-02f, 2.52994467e-02f, 2.40276605e-02f, -1.48794493e-02f, 4.25587371e-02f, -4.15502489e-02f, 1.18155107e-02f, 1.62461903e-02f, 2.89134309e-02f,
  2.77382620e-02f, -4.81126420e-02f, -6.17139228e-02f, -4.51461114e-02f, -1.18137598e-01f, -1.57359969e-02f, -1.42345792e-02f, -1.21375658e-01f, 2.87419967e-02f, -2.07630061e-02f,
  2.20468584e-02f, 2.26296019e-02f, -8.47202167e-03f, -3.86285707e-02f, -3.09332162e-02f, -1.03217550e-01f, 5.87704182e-02f, 1.47246003e-01f, 6.66399226e-02f, 8.93480405e-02f,
  2.62259811e-01f, 2.65217155e-01f, -1.24910668e-01f, -2.62026787e-02f, -3.49868797e-02f, 3.66376415e-02f, 3.05899326e-03f, 2.33839750e-02f, 3.62180248e-02f, -2.13287268e-02f,
  3.33835967e-02f, -9.03851911e-03f, 1.33660026e-02f, 9.88442730e-03f, -1.47382086e-02f, 1.97421610e-02f, -1.42895486e-02f, -1.06105879e-01f, -1.76600013e-02f, -1.12107158e-01f,
  -1.35731637e-01f, -6.33351654e-02f, 9.81586203e-02f, 2.87899538e-03f, -1.28001701e-02f, 9.63287875e-02f, 6.23743199e-02f, -1.66442748e-02f, 1.17606618e-01f, -4.48947921e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.72963138e-02f, -8.66097063e-02f, 1.54090926e-01f, 2.52822548e-01f, 5.58286726e-01f, 5.39595544e-01f, 6.38835788e-01f, 3.62156421e-01f, 2.72625715e-01f, 1.48287207e-01f,
  -2.77797401e-01f, -1.57247454e-01f, -5.72368689e-02f, -2.24807840e-02f, -5.38746342e-02f, 3.10742557e-01f, 3.82822901e-01f, 1.88388035e-01f, 1.39323339e-01f, 1.44703776e-01f,
  1.84342071e-01f, 1.17372222e-01f, -1.01936050e-01f, 1.05546594e-01f, 1.45393252e-01f, 1.19829595e-01f, 1.20587148e-01f, 5.24237528e-02f, -7.75792673e-02f, -1.72544196e-02f,
  -5.03892422e-01f, -1.52289391e-01f, 1.75239578e-01f, -1.61250100e-01f, -1.49077848e-01f, -1.52852982e-01f, -4.23145145e-02f, -1.23565629e-01f, 4.41175811e-02f, 4.57720235e-02f,
  -1.20581597e-01f, -1.27387092e-01f, 3.69852446e-02f, -6.64682761e-02f, 8.03665742e-02f, -2.50363927e-02f, -2.08226237e-02f, -3.61039527e-02f, 3.58044193e-03f, -1.94284499e-01f,
  -1.54285386e-01f, -4.40537184e-02f, 8.14544130e-03f, 6.67172521e-02f, -1.40216559e-01f, -1.29943222e-01f, -1.02659144e-01f, -1.35706082e-01f, -1.26010447e-03f, 1.71543229e-02f,
  4.55713319e-03f, 5.38922893e-03f, -3.58913913e-02f, -3.15667838e-02f, -5.81150614e-02f, 5.99606968e-02f, 3.06461994e-02f, -2.69712135e-02f, 3.25289518e-02f, 9.98270884e-02f,
  6.60467222e-02f, 4.01709042e-03f, 6.33688197e-02f, -1.08257923e-02f, 1.93421636e-02f, 6.25420138e-02f, 1.18189733e-02f, -7.50138098e-03f, -1.80316065e-02f, -2.19264533e-03f,
  -4.50294539e-02f, 1.77025131e-03f, -5.10544069e-02f, -6.13254979e-02f, 7.42761865e-02f, -4.28176224e-02f, -2.55821366e-02f, -2.38220971e-02f, 6.59908801e-02f, 4.64114361e-02f,
  7.37580955e-02f, -6.56818226e-02f, -7.71586150e-02f, -9.45830122e-02f, -5.56646660e-02f, -1.29504964e-01f, -1.47135884e-01f, -8.25570673e-02f, -1.15333565e-01f, 5.98755404e-02f,
  -1.08284384e-01f, -1.56957194e-01f, -1.37610584e-01f, -2.40639355e-02f, 4.58729118e-02f, 4.53489907e-02f, -3.61749046e-02f, -1.29105626e-02f, 3.01761962e-02f, -1.16836771e-01f,
  -3.47438008e-02f, 1.92756608e-01f, 2.18953460e-01f, 7.80160204e-02f, -1.99204106e-02f, 1.62074119e-01f, 2.48670299e-02f, -7.15954974e-02f, 7.58685991e-02f, 2.46919557e-01f,
  -2.31183946e-01f, 7.26346970e-01f, 2.33900324e-01f, -4.40743178e-01f, 2.84734908e-02f, 2.52235293e-01f, 6.39529288e-01f, 1.75269432e-02f, -2.40782425e-01f, 2.36339986e-01f,
  2.23445401e-01f, -1.71699747e-01f, -1.23958945e-01f, -1.79559737e-01f, -2.09501367e-02f, 2.79694438e-01f, 6.73365220e-02f, -2.53419161e-01f, -3.97964090e-01f, -2.06579074e-01f,
  -2.02871010e-01f, -2.57306874e-01f, -3.39990050e-01f, -2.23365873e-01f, -1.80277988e-01f, -3.30782264e-01f, 8.62082615e-02f, 8.51201545e-03f, 2.44902387e-01f, -1.77077144e-01f,
  2.49008775e-01f, 2.00058460e-01f, -3.56783301e-01f, -1.16066270e-01f, 3.00682150e-02f, -6.77203238e-02f, -1.07333390e-02f, -5.23868427e-02f, 1.86952222e-02f, -5.59854284e-02f,
  1.76316947e-02f, -1.38231767e-02f, -7.66901821e-02f, -6.39214850e-05f, -1.85697451e-02f, 6.28844053e-02f, -2.92673316e-02f, -6.12682961e-02f, -8.85456577e-02f, 8.21149945e-02f,
  5.06140180e-02f, 1.29934609e-01f, 2.24909604e-01f, 1.16056599e-01f, 3.34651321e-02f, -1.51034594e-01f, 2.64372319e-01f, -9.88950208e-03f, -6.31082281e-02f, -4.04712372e-03f,
  -4.50111926e-03f, 2.79024504e-02f, -3.82474959e-02f, -1.36647187e-02f, -1.29173119e-02f, 9.19271260e-03f, -5.48755713e-02f, 8.06979742e-03f, -1.22171957e-02f, 1.98721737e-02f,
  5.13709076e-02f, 1.31688580e-01f, 3.99472453e-02f, 6.61005825e-02f, -5.14730737e-02f, -7.64551247e-03f, 7.89047256e-02f, 2.05215812e-02f, 1.35299444e-01f, -1.08869793e-03f,
  -5.15880734e-02f, 6.83321133e-02f, 3.66566777e-02f, -6.68292120e-02f, 5.91426082e-02f, 1.60226959e-03f, -6.12249486e-02f, 1.44668603e-02f, -4.61192802e-02f, 5.69547825e-02f,
  -1.58348903e-01f, 1.14929028e-01f, -4.11977321e-02f, -1.94173932e-01f, 6.23534396e-02f, 4.09286320e-02f, 5.83375134e-02f, -2.57923882e-02f, 1.47847144e-03f, 1.16453273e-02f,
  3.38487849e-02f, -1.35710565e-02f, 1.50718912e-01f, -6.59845471e-02f, -7.36495107e-02f, 1.44333187e-02f, 1.95982769e-01f, -1.35218963e-01f, -7.30053633e-02f, 6.07005917e-02f,
  5.08632511e-02f, -3.47891413e-02f, 4.92843986e-02f, -5.24913222e-02f, -1.20460812e-04f, -1.31872177e-01f, 1.11298516e-01f, -8.93552881e-03f, 5.69159873e-02f, 4.01986353e-02f,
  -4.78909731e-01f, -4.78336662e-01f, -3.01749617e-01f, -2.75210351e-01f, -7.67785534e-02f, 5.66939153e-02f, 8.32086802e-02f, 1.18123338e-01f, -6.53306991e-02f, -1.68381214e-01f,
  -1.66909799e-01f, -6.43265173e-02f, -4.77883294e-02f, 7.17313811e-02f, 1.36161938e-01f, -1.28188536e-01f, -9.60703865e-02f, -1.23166554e-01f, 8.19916278e-02f, 2.74442941e-01f,
  2.90568117e-02f, -1.36281416e-01f, -3.60339954e-02f, 3.13225724e-02f, -1.95699707e-01f, -1.29730925e-01f, -1.86884254e-01f, -1.72239348e-01f, -8.18743259e-02f, -3.99593771e-01f,
  -3.59174848e-01f, -1.78131357e-01f, 1.91425726e-01f, -6.76490441e-02f, -1.25026386e-02f, 5.63358516e-02f, -7.99889117e-02f, -4.01798030e-03f, 2.79804785e-02f, -9.55900252e-02f,
  -6.35360703e-02f, 1.00012988e-01f, -1.20343253e-01f, 7.30099082e-02f, -3.60725671e-02f, -6.63245097e-02f, 5.57585880e-02f, 3.70198265e-02f, -5.78671917e-02f, -1.32465875e-02f,
  -1.21321090e-01f, -2.24155694e-01f, -2.72208661e-01f, 3.24077308e-02f, -1.13087818e-02f, -1.04386963e-01f, -6.44182786e-02f, -8.30692574e-02f, -8.45530778e-02f, -2.14828685e-01f,
  8.28004107e-02f, -3.80268544e-02f, 9.28146113e-03f, 4.08807062e-02f, 8.74828547e-03f, -5.50488308e-02f, -1.41133340e-02f, 2.59999186e-02f, 4.15124930e-02f, -7.81617463e-02f,
  9.40698609e-02f, 5.45030534e-02f, 7.34457597e-02f, -7.72926211e-02f, -1.46842645e-02f, -8.73386767e-03f, 1.66910272e-02f, -5.34423888e-02f, 2.50908807e-02f, 7.70095512e-02f,
  -1.63597986e-02f, -1.77302547e-02f, -6.87726215e-02f, 4.55381609e-02f, -6.32553780e-03f, 5.69441915e-03f, -4.61557396e-02f, -3.27665661e-03f, 6.97825402e-02f, -3.61193866e-02f,
  -1.69849157e-01f, 2.46156871e-01f, -2.34850705e-01f, -3.31884287e-02f, -1.54047921e-01f, -4.86391485e-02f, -7.43478537e-02f, -4.31918502e-02f, -8.79995301e-02f, -9.37678516e-02f,
  1.36075327e-02f, -5.87673895e-02f, -1.36438787e-01f, 9.43865329e-02f, 5.41065820e-02f, 3.49964888e-04f, -2.49799173e-02f, -1.74971566e-01f, 3.09528317e-02f, 6.44772649e-02f,
  -2.49944888e-02f, -1.53977856e-01f, -2.96016872e-01f, -1.95478216e-01f, -1.92493424e-02f, -2.18375131e-01f, -1.70694813e-01f, -1.27080768e-01f, -2.54248381e-01f, -3.48263949e-01f,
  7.36401081e-02f, 9.65605825e-02f, 3.68334711e-01f, -8.10546726e-02f, -3.74552935e-01f, -3.25377911e-01f, -3.89260858e-01f, -1.58105373e-01f, -2.16800328e-02f, -1.96979672e-01f,
  -2.60153800e-01f, -2.71720797e-01f, 5.73330484e-02f, -4.68576327e-02f, 1.25766367e-01f, 1.22176312e-01f, 1.86133221e-01f, 2.88167119e-01f, 3.83305848e-02f, -2.14374423e-01f,
  -2.52101094e-01f, 1.60182938e-02f, 1.57309309e-01f, 1.14535868e-01f, -1.44039050e-01f, -1.09098524e-01f, 2.44724527e-01f, -3.52509916e-02f, 5.68486825e-02f, -7.45871365e-02f,
  -3.14826928e-02f, 2.59704202e-01f, -5.99045306e-03f, -6.27512112e-02f, 4.76940647e-02f, 6.26961812e-02f, -1.03231512e-01f, 1.08177088e-01f, 4.88160066e-02f, -2.90200487e-02f,
  -1.33441895e-01f, -2.45374199e-02f, -4.16468196e-02f, -2.77028363e-02f, -1.47289455e-01f, -1.54168168e-02f, 1.03694104e-01f, 2.56621718e-01f, 9.61216465e-02f, 1.50418254e-02f,
  -2.15839431e-01f, -1.95936367e-01f, -6.64325207e-02f, 9.17667076e-02f, 1.42758295e-01f, -5.39246900e-03f, 8.02164301e-02f, 1.79521344e-03f, 2.48862490e-01f, 7.13994280e-02f,
  3.64325498e-03f, -1.42024327e-02f, -3.85823362e-02f, 1.00693062e-04f, -9.20994058e-02f, 7.62239248e-02f, 7.98395276e-02f, -1.08239867e-01f, -3.80034745e-02f, -2.61345338e-02f,
  6.60168231e-02f, 1.94495954e-02f, -4.82549928e-02f, 5.94258159e-02f, 9.07432213e-02f, 1.64144617e-02f, -4.30377200e-02f, 1.11864939e-01f, -2.96941376e-03f, 3.91002633e-02f,
  -4.32110531e-03f, -3.35538648e-02f, 6.73808604e-02f, -4.42921221e-02f, 5.44087850e-02f, 1.23451151e-01f, -7.96512887e-02f, -5.11625372e-02f, 4.25090045e-02f, -3.14766988e-02f,
  -1.53787032e-01f, 2.26094812e-01f, -2.09166646e-01f, -6.94569275e-02f, 7.78514100e-03f, 8.50864872e-02f, -8.65804628e-02f, 6.35003000e-02f, -3.48040238e-02f, -7.67788943e-03f,
  -5.64155430e-02f, -2.67452486e-02f, -5.49454987e-02f, -9.06118006e-02f, -8.81075636e-02f, -1.58249244e-01f, -4.70870398e-02f, -1.05364807e-01f, -2.25521456e-02f, -9.46643725e-02f,
  -4.97442037e-02f, -1.78593278e-01f, -2.67482340e-01f, -2.60541756e-02f, -9.53326002e-02f, -1.74594864e-01f, -1.10793717e-01f, -3.41044143e-02f, -1.11016162e-01f, -1.94645211e-01f,
  -8.92099068e-02f, -3.13123874e-02f, 2.70113237e-02f, 2.62144417e-01f, 1.00494444e-01f, -2.82077909e-01f, -5.43875694e-01f, -3.55267406e-01f, 1.15611650e-01f, 6.48575351e-02f,
  1.58879772e-01f, 1.03503741e-01f, -1.18993774e-01f, -3.52707028e-01f, -6.78642750e-01f, -3.83855432e-01f, -3.61216456e-01f, -5.90614080e-01f, -6.79438472e-01f, -3.80039662e-01f,
  -1.50980175e-01f, -1.17834657e-01f, -2.82722950e-01f, -1.22309320e-01f, 3.43986243e-01f, 1.53040364e-01f, 2.01600939e-01f, 8.33783522e-02f, -1.04329651e-02f, 3.30315530e-01f,
  1.38643563e-01f, 1.71702400e-01f, -1.83846250e-01f, 4.73715216e-02f, 1.68267176e-01f, -5.51111586e-02f, -6.12337701e-02f, 1.02279410e-01f, 3.86748184e-03f, -5.32629751e-02f,
  6.00431375e-02f, 6.13229014e-02f, 5.31227104e-02f, -1.87019203e-02f, -9.00752246e-02f, -1.60354733e-01f, -9.92240831e-02f, -1.76953271e-01f, -1.65499166e-01f, -9.40852799e-03f,
  -1.78965740e-02f, 4.74530794e-02f, -1.47593543e-01f, -9.13476348e-02f, 1.75017659e-02f, 1.99380256e-02f, -1.26472383e-03f, 4.74143252e-02f, -4.19168659e-02f, 4.08580899e-02f,
  -4.14153300e-02f, 5.13151996e-02f, 9.73779988e-03f, 2.72308709e-03f, -4.39387225e-02f, 9.90394354e-02f, -2.34098732e-02f, -4.53290865e-02f, -3.72328348e-02f, 1.95053890e-02f,
  1.15129752e-02f, 1.94344372e-02f, 3.75563651e-02f, -1.40059609e-02f, -1.86413092e-06f, 3.76832783e-02f, -4.07875404e-02f, -1.00538276e-01f, -8.54062811e-02f, 8.88962857e-03f,
  -3.67066413e-02f, 7.95461796e-03f, 1.29703209e-01f, -1.10296691e-02f, -1.76012516e-02f, -1.78677142e-02f, 1.50791164e-02f, -5.30473376e-03f, -1.80226862e-02f, 1.18512720e-01f,
  2.99742725e-03f, -3.15095305e-01f, -2.68055853e-02f, -1.56397775e-01f, 8.64953734e-03f, 4.68249917e-02f, 1.13381319e-01f, -2.48879883e-02f, 5.93493320e-02f, -1.28818586e-01f,
  -3.02928872e-02f, -7.93375522e-02f, -1.37096923e-02f, -6.33350462e-02f, -1.59147650e-01f, -6.08906522e-02f, -1.57463297e-01f, -4.44312133e-02f, -1.89791292e-01f, 6.13150112e-02f,
  -8.10836032e-02f, -4.01631027e-01f, -4.33653623e-01f, -2.00512499e-01f, -1.14138372e-01f, -3.30228269e-01f, -1.83915257e-01f, -1.18701741e-01f, -3.56689811e-01f, -4.41377401e-01f,
  -6.15295907e-03f, -1.88422427e-01f, 2.51318812e-01f, -9.36527699e-02f, -3.82943511e-01f, -5.10347545e-01f, -4.77508843e-01f, -3.89070749e-01f, -1.59579486e-01f, -2.03777239e-01f,
  -2.91750550e-01f, -5.28318211e-02f, 1.32216532e-02f, 1.67436436e-01f, 1.68822065e-01f, 7.32932240e-02f, 2.86387742e-01f, 6.08093202e-01f, 3.52700889e-01f, 4.19492833e-02f,
  1.03951715e-01f, 3.43448371e-01f, 3.65571618e-01f, 2.39595830e-01f, 1.72850594e-01f, 7.42372125e-02f, 3.66760902e-02f, 1.00196205e-01f, 2.19595462e-01f, 3.45004082e-01f,
  -3.61060314e-02f, -2.63869405e-01f, 1.23625491e-02f, 2.53500026e-02f, -5.63547015e-02f, 7.92639554e-02f, -3.41864824e-02f, 8.19939971e-02f, -1.18402578e-01f, 5.35358787e-02f,
  -8.33420604e-02f, 4.68501188e-02f, -2.72769225e-03f, 1.41527904e-02f, -2.65335049e-02f, -4.16265465e-02f, 1.38922617e-01f, 2.02929899e-01f, 6.01511709e-02f, -4.43939492e-02f,
  2.74831057e-02f, -1.07114002e-01f, -1.02387257e-01f, -1.79804027e-01f, -3.71018350e-02f, 4.40882705e-02f, -1.27533898e-01f, 1.31365852e-02f, -1.44407374e-03f, -8.22155401e-02f,
  -1.55368438e-02f, 5.56469932e-02f, -2.33123600e-02f, 6.17033802e-03f, 3.80810536e-02f, -4.07764502e-02f, 8.43140930e-02f, -6.57879636e-02f, 6.60939515e-02f, 1.23899430e-02f,
  2.59586461e-02f, -2.37419382e-02f, 1.13997534e-02f, -1.63530596e-02f, -2.73212157e-02f, 3.95928044e-03f, -2.29790370e-04f, 3.96262072e-02f, 4.62496057e-02f, -5.54743446e-02f,
  3.09917796e-02f, 4.41399822e-03f, -2.00716723e-02f, 5.93773015e-02f, -2.52325609e-02f, 3.66082825e-02f, 5.35371080e-02f, -1.20763760e-02f, -4.41907868e-02f, -1.19397677e-02f,
  -2.85680830e-01f, -1.20300483e-02f, -9.34928879e-02f, 4.38673981e-02f, 8.89019389e-03f, 7.26644546e-02f, -1.03293426e-01f, 4.60583009e-02f, -4.61352430e-02f, -3.03854123e-02f,
  -1.06659323e-01f, 1.88474078e-02f, -8.79249945e-02f, 3.09660397e-02f, -1.34735499e-02f, -1.23404056e-01f, -4.39290553e-02f, 9.77353156e-02f, -5.03605828e-02f, -7.12481067e-02f,
  -5.43958358e-02f, -2.64190704e-01f, -2.92871237e-01f, -3.24784547e-01f, -2.30741665e-01f, -2.37170592e-01f, -1.45263568e-01f, -2.66359419e-01f, -2.77989030e-01f, -2.65681744e-01f,
  7.28094637e-01f, 8.88068154e-02f, -1.10403633e+00f, 1.70307100e-01f, -3.41656893e-01f, -3.33534956e-01f, -1.06539570e-01f, 1.06587924e-01f, 2.73228347e-01f, -7.37892315e-02f,
  -5.95002621e-02f, 1.20292686e-01f, -9.14307311e-02f, -2.03243326e-02f, 4.15763967e-02f, -3.34296525e-01f, -4.60511088e-01f, -2.80347049e-01f, -2.26676166e-01f, 3.50835994e-02f,
  6.33045509e-02f, 2.22519577e-01f, 2.76794016e-01f, 7.52066150e-02f, -1.38852105e-01f, -1.73324168e-01f, -4.07102376e-01f, -2.19461933e-01f, -2.86078930e-01f, -3.86067569e-01f,
  -7.17847407e-01f, -5.11963740e-02f, -9.89238322e-02f, 1.61580309e-01f, -2.21539363e-01f, 4.94284034e-02f, -5.82923144e-02f, -1.07006162e-01f, -3.52774896e-02f, -4.52094562e-02f,
  -1.79221988e-01f, -7.75440857e-02f, -9.78595167e-02f, -5.25390506e-02f, 9.69054177e-03f, -4.10799645e-02f, 4.01305296e-02f, -1.19966239e-01f, -7.14095235e-02f, -5.12788817e-02f,
  -8.24204162e-02f, -1.59470633e-01f, -2.39475399e-01f, -1.72402561e-02f, -1.76056683e-01f, -1.27944723e-01f, -2.02651873e-01f, -1.98184252e-01f, -2.42045894e-01f, 1.30898505e-01f,
  3.00247297e-02f, -7.48665035e-02f, 6.65910251e-04f, 1.06632143e-01f, 9.41301137e-02f, -2.75719333e-02f, -2.94772610e-02f, -2.23311167e-02f, 8.16387758e-02f, 4.70537990e-02f,
  2.04220936e-02f, -8.80677104e-02f, 3.86503562e-02f, 6.00757748e-02f, -8.81159231e-02f, -4.62675281e-02f, 1.32098719e-02f, 9.85716134e-02f, -4.55391593e-03f, 6.19965754e-02f,
  -1.37618398e-02f, -1.06848009e-01f, -1.29595678e-03f, -2.43015997e-02f, -1.05048306e-01f, -1.61162000e-02f, -4.77187671e-02f, 4.81872708e-02f, 1.91120226e-02f, 1.13700200e-02f,
  3.95689666e-01f, -1.58444375e-01f, 1.62675031e-04f, 8.92990306e-02f, -1.55203149e-01f, -4.33549806e-02f, -2.52054930e-02f, 3.22032087e-02f, -6.97665736e-02f, -9.15606767e-02f,
  -2.80773081e-02f, 9.06792134e-02f, -4.44368348e-02f, -1.30747184e-02f, -5.57231195e-02f, 3.82332690e-02f, 1.77033886e-01f, -5.69824204e-02f, -1.10192955e-01f, -4.25653644e-02f,
  1.49019033e-01f, 1.21113963e-01f, 2.22739518e-01f, 4.20946218e-02f, -2.55109761e-02f, -6.39570430e-02f, -1.15247183e-01f, -8.00439250e-03f, 7.96772260e-03f, 5.21801591e-01f,
  -4.27151471e-01f, -2.75317192e-01f, -2.79343754e-01f, -4.22227323e-01f, -2.04811648e-01f, -9.76826251e-03f, -6.48375601e-02f, -1.25129614e-02f, -2.20861092e-01f, -1.76015839e-01f,
  -1.98079925e-02f, 4.57764789e-03f, -4.89266850e-02f, 6.76185712e-02f, -6.17114641e-03f, -1.60717472e-01f, -3.04730982e-01f, -1.58175174e-02f, 9.35466886e-02f, 1.24228798e-01f,
  -1.87601782e-02f, -1.37034386e-01f, -1.33104891e-01f, -1.77188352e-01f, -2.29774371e-01f, -2.02682614e-02f, -1.17122956e-01f, -1.30716294e-01f, -5.10043688e-02f, -2.01721668e-01f,
  1.05383366e-01f, 9.79726762e-02f, 1.32335335e-01f, -2.51167696e-02f, -1.71133265e-01f, -8.54687300e-03f, -8.08872208e-02f, -2.82830037e-02f, -5.27888089e-02f, -3.78427133e-02f,
  8.07371363e-03f, 9.44261998e-03f, -4.07226296e-04f, -3.85212488e-02f, -7.21603110e-02f, 3.90415192e-02f, -4.32712138e-02f, 1.02862623e-02f, -6.02991544e-02f, 8.02043229e-02f,
  4.62564714e-02f, -6.18769135e-03f, 1.23374067e-01f, 1.23934358e-01f, 6.22248389e-02f, 8.33603591e-02f, 1.36917224e-04f, 5.91732822e-02f, 1.27360210e-01f, -9.25839022e-02f,
  -3.47279944e-02f, -7.31663108e-02f, 4.47223932e-02f, -1.97085440e-02f, -1.91348530e-02f, -3.12194489e-02f, 5.26968390e-04f, -2.42650546e-02f, -3.90325487e-02f, 2.81056054e-02f,
  6.52419869e-03f, -1.21490732e-02f, -2.40824651e-03f, -8.14544503e-03f, -7.57643906e-03f, -2.85179801e-02f, -8.50636885e-03f, -4.50273976e-02f, 1.91367771e-02f, -7.54701123e-02f,
  2.01628078e-02f, 2.90402342e-02f, -1.88875087e-02f, 2.44035106e-02f, 3.04725189e-02f, -8.97371471e-02f, -6.43481500e-03f, 5.33298813e-02f, -2.15276945e-02f, 9.30976495e-02f,
  -1.01802424e-01f, 1.30112648e-01f, -1.14098966e-01f, 1.16346285e-01f, -5.37588671e-02f, 5.62422490e-03f, -5.95320165e-02f, 4.97711003e-02f, -3.77526246e-02f, 4.33676923e-03f,
  1.63445920e-01f, 1.66468062e-02f, -3.15508805e-02f, 3.33918072e-02f, -8.34856328e-05f, 5.78283332e-02f, -1.35569558e-01f, -8.17479566e-02f, 1.39855117e-01f, -8.09466615e-02f,
  -6.64171502e-02f, -9.83884037e-02f, -5.75211160e-02f, -4.41635214e-02f, 4.13359851e-02f, 8.30135867e-02f, 9.44755524e-02f, 6.85662106e-02f, 6.04913086e-02f, -3.30864161e-01f,
  -3.29352170e-01f, -1.20405994e-01f, 7.63709918e-02f, -2.89124489e-01f, -8.64707902e-02f, 3.77930738e-02f, 9.81966928e-02f, -5.75836655e-03f, -1.88891366e-01f, -7.40760118e-02f,
  3.71127836e-02f, -4.65187505e-02f, -8.90327021e-02f, 1.29939750e-01f, 5.99070080e-02f, 1.33307189e-01f, 1.57416940e-01f, 4.93814275e-02f, 1.28881380e-01f, -1.50479257e-01f,
  -1.91363972e-02f, -1.24762155e-01f, 4.42268588e-02f, 1.48332128e-02f, -2.98648983e-01f, -1.64705828e-01f, 4.84875813e-02f, -1.17189944e-01f, -2.29907762e-02f, -1.79919317e-01f,
  -2.09038019e-01f, -2.10253343e-01f, 1.02232732e-01f, -1.41981095e-02f, -8.02723914e-02f, 2.67857444e-02f, -5.55971637e-02f, -3.18939164e-02f, -8.37196037e-02f, -2.30367463e-02f,
  -3.30673084e-02f, -1.22813039e-01f, -5.03327735e-02f, -1.21690616e-01f, -3.14928479e-02f, -3.64320539e-02f, -3.22654136e-02f, 1.31690875e-01f, 1.39101192e-01f, 1.11061580e-01f,
  5.02315722e-02f, -3.49444486e-02f, 6.14371300e-02f, 1.55526578e-01f, 9.55159590e-02f, 1.94637433e-01f, -1.86820198e-02f, -7.16101602e-02f, 2.06421122e-01f, -1.77048653e-01f,
  5.03327288e-02f, 5.41715845e-02f, -3.57683934e-02f, -1.16201630e-02f, -2.87389290e-02f, -4.31255065e-02f, 2.55983528e-02f, -3.06431334e-02f, -7.37803802e-02f, -6.13982230e-02f,
  -4.20692898e-02f, 3.90256755e-02f, -1.17515223e-02f, -1.19812325e-01f, -1.84947960e-02f, 3.94478589e-02f, 7.60372132e-02f, -3.62176932e-02f, 9.71578585e-04f, 1.19097661e-02f,
  -7.06504844e-03f, 4.14065011e-02f, 2.74629705e-02f, -2.54833605e-04f, 1.27335295e-01f, 1.23635098e-01f, 8.82028043e-03f, 1.09376218e-02f, -4.54251356e-02f, 5.45127355e-02f,
  -3.51026058e-01f, 3.82740617e-01f, -1.22754686e-01f, 5.43521903e-02f, -1.19233914e-01f, -4.08456884e-02f, -4.92551923e-02f, 3.72775435e-03f, -2.71071438e-02f, -1.28803864e-01f,
  5.54629974e-02f, -1.76985171e-02f, -7.73577020e-02f, 2.03691460e-02f, -1.30995095e-01f, -8.09636265e-02f, -2.11385004e-02f, 4.78372946e-02f, 1.67306125e-01f, -3.57562341e-02f,
  1.25680327e-01f, 5.56570850e-02f, -1.33649647e-01f, 1.94534361e-02f, -4.67712879e-02f, 6.40011718e-03f, -8.11344981e-02f, -4.80731167e-02f, 1.23249494e-01f, -1.89498141e-01f,
  -2.86720455e-01f, -1.30657554e-01f, 8.45747665e-02f, -3.02691311e-01f, -1.79736614e-01f, 1.00500360e-01f, 1.13184825e-01f, -1.74088687e-01f, -1.86903819e-01f, -4.16422039e-02f,
  -1.43994868e-01f, 5.57411462e-02f, 2.23509520e-02f, -9.08394456e-02f, 1.01069296e-02f, 1.16320260e-01f, -5.24784178e-02f, 8.38309005e-02f, 1.29924566e-01f, -6.48141780e-04f,
  1.23685235e-02f, -1.72463357e-01f, -1.74341306e-01f, -2.02077478e-01f, -1.74474761e-01f, -3.53816412e-02f, -3.02127060e-02f, -2.53982306e-01f, -1.23497613e-01f, -6.95018172e-02f,
  5.81318438e-01f, -4.14097577e-01f, -4.57450636e-02f, -2.14618549e-01f, -1.31789729e-01f, -3.31267193e-02f, -7.45635703e-02f, -1.61332503e-01f, -1.11007877e-01f, -1.06702045e-01f,
  -1.12118922e-01f, -8.63883272e-02f, -6.99328110e-02f, -5.46586141e-02f, -5.07090688e-02f, -3.12608667e-02f, -6.16234206e-02f, -1.83583111e-01f, -1.75260350e-01f, -1.59511849e-01f,
  -1.74559802e-01f, -6.79006502e-02f, 5.67637347e-02f, -4.02402738e-03f, -1.70162797e-01f, -5.65772243e-02f, -3.10366098e-02f, -9.39442143e-02f, -8.38938579e-02f, -1.16296433e-01f,
  1.79507677e-02f, 3.09302136e-02f, 3.65249142e-02f, 2.11513340e-02f, 2.78325379e-02f, 4.57232930e-02f, 9.10098553e-02f, 9.64454263e-02f, 1.88188162e-02f, 5.17260171e-02f,
  -1.37013022e-03f, 6.84769675e-02f, -2.08244212e-02f, 2.10292451e-02f, 3.52987833e-02f, -8.43256526e-03f, -1.02042062e-02f, 3.97193395e-02f, 1.45609649e-02f, -4.25657108e-02f,
  -7.16850832e-02f, -5.76577149e-02f, 2.51041958e-03f, -5.72041459e-02f, -1.01596326e-01f, -1.23746745e-01f, -1.77679360e-02f, -9.33709070e-02f, 2.85209082e-02f, -4.23325673e-02f,
  5.48490107e-01f, -2.23389342e-01f, 2.34894946e-01f, -1.19380355e-01f, -9.79072601e-02f, -6.71171024e-02f, 1.26181617e-02f, -3.18786167e-02f, -2.22974077e-01f, 9.11507159e-02f,
  -1.91382453e-01f, -1.72170158e-02f, -3.57037187e-02f, 5.21405227e-02f, 1.44553035e-01f, 4.36684676e-02f, -1.07515275e-01f, 8.11166838e-02f, -4.82080951e-02f, -6.02252111e-02f,
  2.13205535e-02f, 2.22916931e-01f, 4.01569217e-01f, 2.07684383e-01f, -1.15469955e-02f, 2.05422208e-01f, 4.08315271e-01f, 1.57461643e-01f, 2.99127400e-01f, 3.77302468e-01f,
  6.54404759e-01f, 5.61096549e-01f, 5.46106339e-01f, 4.65626456e-02f, 2.22427701e-03f, 2.41516814e-01f, 4.50596899e-01f, 2.25052044e-01f, -8.22215155e-02f, 8.06466565e-02f,
  -8.57425407e-02f, -4.60491031e-01f, -3.05524141e-01f, -2.92275012e-01f, 1.76230371e-02f, 1.54856458e-01f, 1.28639325e-01f, 1.46271154e-01f, 4.71183732e-02f, -3.39601785e-02f,
  -2.34753698e-01f, 8.57554078e-02f, 2.35945627e-01f, 4.85975295e-02f, 4.82164249e-02f, -2.51015753e-01f, 4.15009707e-02f, 2.33917102e-01f, 5.60111776e-02f, 8.81488770e-02f,
  7.75825754e-02f, 6.18266881e-01f, -2.98579067e-01f, -2.55064905e-01f, -1.00967035e-01f, 6.98775128e-02f, -4.72983457e-02f, 2.08508298e-02f, -8.00929889e-02f, 1.56157017e-02f,
  -1.71680655e-02f, -5.51751757e-04f, -2.74044499e-02f, -9.66520980e-02f, 1.09541163e-01f, 2.00122464e-02f, 2.86850743e-02f, 1.83910325e-01f, -1.64532848e-02f, -3.88313644e-02f,
  -1.54980317e-01f, 4.28612456e-02f, 1.17898807e-01f, -4.74216323e-03f, 5.97702377e-02f, -2.08310887e-01f, 1.13504939e-01f, 3.90749127e-02f, 2.97518242e-02f, 1.12836912e-01f,
  -1.11445338e-01f, 1.30763361e-02f, 5.24593666e-02f, 9.07496959e-02f, -4.71653566e-02f, 6.13429304e-03f, 1.24569125e-02f, -4.35570069e-03f, 8.26593582e-03f, 1.10061176e-01f,
  -4.31229696e-02f, 1.69391632e-02f, 3.04084383e-02f, -2.71032043e-02f, -1.38153717e-01f, 1.89956836e-02f, 9.19429883e-02f, -7.42301419e-02f, -1.97828170e-02f, 3.12363505e-02f,
  1.35038840e-02f, 2.85765398e-02f, -2.06901077e-02f, -2.98058726e-02f, -5.38937002e-02f, 1.77039076e-02f, -8.93574283e-02f, 2.20671110e-02f, -1.03043482e-01f, 4.66659032e-02f,
  -4.36029226e-01f, -1.82223737e-01f, -7.11769685e-02f, 5.08236066e-02f, 9.32371616e-02f, -8.28256160e-02f, -4.56866957e-02f, -6.75994381e-02f, -4.85329377e-03f, -4.36897436e-03f,
  3.51615474e-02f, 1.16220415e-01f, 2.77818367e-02f, 6.18805811e-02f, 5.74835856e-03f, -1.25353724e-01f, -1.09185517e-01f, -9.01566297e-02f, -9.55062956e-02f, 6.04008995e-02f,
  -1.54048592e-01f, -9.48461592e-02f, -1.08237021e-01f, -1.26523197e-01f, -1.82988554e-01f, -2.98002839e-01f, -6.89218640e-02f, -1.20940611e-01f, -1.07354363e-02f, -1.00970492e-01f,
  9.56946790e-01f, -7.64869332e-01f, 1.71420813e-01f, 1.53802097e-01f, 1.50154397e-01f, 2.77806878e-01f, -1.03502743e-01f, 2.94600129e-02f, 4.15316671e-02f, -1.33624181e-01f,
  -1.03261523e-01f, 1.63821459e-01f, 1.00853987e-01f, -4.13825437e-02f, 2.00399339e-01f, -1.51952997e-01f, -1.21470690e-01f, 4.06132400e-01f, 4.50868815e-01f, 1.82444856e-01f,
  -1.40216380e-01f, -3.30430605e-02f, 8.87003019e-02f, -6.45215139e-02f, -2.83922732e-01f, -5.20794429e-02f, -2.11975247e-01f, -1.72275856e-01f, -1.42438233e-01f, -4.25047636e-01f,
  -1.76907837e-01f, 2.98265107e-02f, 1.13434963e-01f, -4.14071716e-02f, -6.88061491e-02f, -7.85400439e-03f, 6.18555024e-02f, -9.41701531e-02f, -3.91474850e-02f, -1.38740063e-01f,
  -9.53630172e-03f, 2.86906119e-02f, 6.87640067e-03f, -1.66430593e-01f, -9.03800353e-02f, 3.68257798e-02f, -4.58589941e-02f, -1.40715335e-02f, -5.00455126e-02f, -1.33848652e-01f,
  -2.11970210e-01f, 2.76523735e-02f, 2.15148762e-01f, -1.00211529e-02f, 9.44314301e-02f, 3.08236718e-01f, -1.17289223e-01f, -4.97030243e-02f, 1.10472359e-01f, -2.47064650e-01f,
  -6.15309514e-02f, 6.90399855e-02f, 5.58635518e-02f, 1.11337276e-02f, 4.54350039e-02f, 1.70071255e-02f, 2.40928270e-02f, -3.50704379e-02f, 8.23583379e-02f, 7.52785150e-03f,
  -2.61860481e-03f, 6.23329021e-02f, 1.01952009e-01f, 2.19438050e-04f, 3.68801318e-02f, -1.56738032e-02f, 2.32483242e-02f, -8.43354389e-02f, 3.93242016e-02f, 4.03626859e-02f,
  2.47185230e-02f, 9.24917385e-02f, -4.25075591e-02f, -7.65613168e-02f, -8.11398327e-02f, -3.39183956e-02f, 2.80241780e-02f, -6.78140596e-02f, -1.48503855e-02f, -1.85297020e-02f,
  -3.45043123e-01f, 5.00203907e-01f, -1.90646909e-02f, 5.96244149e-02f, 1.05694197e-02f, -1.26089081e-01f, -2.30439603e-02f, -7.64074922e-02f, -8.41390640e-02f, -1.59751639e-01f,
  -1.01359198e-02f, 2.66840849e-02f, -2.06908118e-02f, -1.09641552e-01f, 8.93010125e-02f, 8.93343315e-02f, -7.69446269e-02f, 1.78948417e-01f, -3.67381200e-02f, -1.97154343e-01f,
  -2.69068986e-01f, 2.12947935e-01f, 2.96577930e-01f, 4.85413186e-02f, 6.29180744e-02f, 3.96789938e-01f, 2.10936815e-02f, -3.92858833e-02f, 3.02494973e-01f, -2.35658288e-01f,
  -7.33880162e-01f, 2.57255971e-01f, -9.72374454e-02f, -1.18181519e-01f, 4.27503049e-01f, 2.95733988e-01f, 4.82315123e-01f, -1.15351602e-01f, -1.89726874e-01f, 3.01032644e-02f,
  2.61540916e-02f, -3.74271907e-02f, -1.73639506e-01f, -1.54467311e-03f, 8.22409987e-03f, 1.62023053e-01f, 2.12427124e-01f, -3.36584039e-02f, -1.14570677e-01f, 5.32596745e-02f,
  1.17649280e-01f, -7.14110881e-02f, -3.28586370e-01f, -1.32471874e-01f, 3.99665274e-02f, -1.70120038e-02f, -3.20971459e-02f, 8.13795105e-02f, 2.75249869e-01f, 2.13473395e-01f,
  -2.77996689e-01f, -1.18007764e-01f, -1.33042959e-02f, 3.67815867e-02f, 1.05812669e-01f, -1.68048292e-01f, 6.07515266e-03f, -1.69227317e-01f, 2.10055179e-04f, 8.55908031e-04f,
  6.26691356e-02f, 5.58234192e-02f, 1.17756464e-02f, -2.50022542e-02f, -1.64665282e-01f, -1.22494370e-01f, -1.51090622e-01f, -2.71193951e-01f, -1.76214412e-01f, -5.37242070e-02f,
  3.00048441e-01f, 1.39862612e-01f, -9.33788940e-02f, -1.20182093e-02f, -8.47932771e-02f, -1.60467282e-01f, -1.33972973e-01f, -9.91184786e-02f, -1.42748356e-01f, -3.61109287e-01f,
  7.50098005e-02f, 2.10593641e-02f, 3.99682857e-02f, -8.56631063e-03f, 1.04153594e-02f, 3.01876105e-02f, 8.78519714e-02f, 9.22603086e-02f, -1.16913738e-02f, 2.73477705e-03f,
  -2.66598780e-02f, -1.80462226e-02f, -7.77146220e-02f, -8.32888037e-02f, -5.81355719e-03f, 8.53625778e-03f, 5.57320192e-02f, 7.93337151e-02f, -6.86630979e-03f, -3.14357802e-02f,
  -5.01376279e-02f, -6.66749431e-03f, -1.07074283e-01f, 4.00175247e-03f, 5.63780665e-02f, -4.74947020e-02f, -3.44228968e-02f, 2.39646062e-02f, -1.50860012e-01f, -1.02267442e-02f,
  -5.71667016e-01f, 2.17517525e-01f, -2.29022622e-01f, -1.09699421e-01f, 7.91641846e-02f, -7.56262988e-02f, -3.19934497e-03f, -3.75216976e-02f, -7.95407686e-03f, -1.11457936e-01f,
  -4.31012549e-03f, -1.06536970e-01f, -3.30025069e-02f, 2.26000715e-02f, -6.11376315e-02f, -6.73357025e-02f, 3.41573805e-02f, 2.65067327e-03f, -9.50845331e-02f, -1.22043416e-01f,
  -1.22887157e-02f, -1.17847763e-01f, -2.64841586e-01f, -1.41213894e-01f, -3.73631790e-02f, -2.22528443e-01f, -1.65611133e-01f, -2.21891880e-01f, -2.14026213e-01f, -3.73282433e-01f,
  5.11505246e-01f, 1.87890187e-01f, -4.40029725e-02f, 3.87239754e-01f, 2.07254216e-01f, -2.05035470e-02f, -2.49783412e-01f, -1.54176936e-01f, 5.96027337e-02f, 3.14739883e-01f,
  4.99664783e-01f, 4.37679529e-01f, 3.09787929e-01f, 2.14484498e-01f, -5.14204800e-02f, -1.93735644e-01f, -1.21187076e-01f, 7.72145689e-02f, 7.50649199e-02f, 2.65647411e-01f,
  2.35002637e-01f, 3.06993127e-01f, 9.04746652e-02f, 7.25897849e-02f, 2.35188290e-01f, 2.49789327e-01f, 8.16641375e-02f, 1.22529179e-01f, 2.21529678e-01f, 3.94948512e-01f,
  2.82875299e-01f, 6.53627589e-02f, -5.41022308e-02f, 1.66399464e-01f, 9.86163244e-02f, -4.89446223e-02f, -5.01645803e-02f, -1.64319798e-01f, 1.39108039e-02f, -1.89683829e-02f,
  7.38423765e-02f, 7.59148896e-02f, 2.63849064e-03f, -1.20366417e-01f, -9.01626572e-02f, -6.24525063e-02f, -1.66327104e-01f, -9.89979506e-02f, -3.68104316e-02f, 5.45959026e-02f,
  1.78456023e-01f, 6.90112188e-02f, -9.30868834e-02f, -1.59279391e-01f, -1.22269541e-01f, 1.74575467e-02f, -5.12352660e-02f, -8.62822458e-02f, -1.44949153e-01f, -8.15360621e-03f,
  6.11343421e-02f, 9.45962444e-02f, -1.74116492e-02f, 3.42608280e-02f, 9.11804736e-02f, 1.48207303e-02f, -6.43000156e-02f, 6.70206323e-02f, -5.99908121e-02f, -6.00518994e-02f,
  -2.73204613e-02f, 4.81796302e-02f, -8.14895332e-02f, 7.07623661e-02f, 1.37965366e-01f, 1.93228759e-02f, 9.23786592e-03f, 7.63475709e-03f, 4.88325302e-03f, 1.64214596e-02f,
  1.36110131e-02f, -6.92712888e-02f, -1.89404991e-02f, -1.10680617e-01f, -8.94636959e-02f, 2.64891628e-02f, -1.54529391e-02f, 1.03845984e-01f, 6.25495389e-02f, 1.05366558e-01f,
  -1.91893920e-01f, -3.97221260e-02f, 6.29402697e-02f, -8.26259106e-02f, 2.90932097e-02f, 7.15292152e-03f, 1.46007359e-01f, -2.04376667e-03f, 2.57083513e-02f, -5.15357368e-02f,
  -3.38067263e-02f, 1.26981847e-02f, 3.39818466e-03f, -1.39387891e-01f, -9.03184488e-02f, -7.07474202e-02f, 8.65105167e-02f, -7.13462904e-02f, -6.81264997e-02f, -1.41116843e-01f,
  -5.77175952e-02f, -1.53634176e-01f, -1.45541608e-01f, -2.03646258e-01f, -6.52714670e-02f, 7.23303184e-02f, -2.06204504e-01f, -2.10017249e-01f, -2.66120017e-01f, -1.89271837e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.28355372e-01f, 7.47398794e-01f, 2.97887653e-01f, 3.96328419e-01f, 2.22686335e-01f, 4.24286008e-01f, 4.54959452e-01f, 1.83411911e-01f, 3.77867579e-01f, 4.69000816e-01f,
  2.46259987e-01f, 8.17579687e-01f, 3.32097888e-01f, 3.24074209e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -3.53702456e-01f, -5.50353587e-01f, -1.61435515e-01f, -7.07570791e-01f, 9.59768653e-01f, -1.79376870e-01f, 1.90979540e-01f, -9.57646072e-02f, 7.08372831e-01f, 6.50957644e-01f,
  -1.36493862e-01f, -3.56121361e-01f, -2.77749032e-01f, 4.56118844e-02f, -2.60094911e-01f, -1.26665801e-01f, -8.45686078e-01f, 2.84413755e-01f, 3.20135453e-03f, -5.79396486e-01f,
  -8.24075490e-02f, 3.89695726e-02f, -5.78740299e-01f, -5.00863135e-01f, 6.25043631e-01f, 3.12379062e-01f, 2.14236960e-01f, 1.16933934e-01f, -2.07816541e-01f, 1.32465148e+00f,
  -5.50413251e-01f, 8.70499611e-01f, 7.24292099e-01f, 7.31248707e-02f, -3.75567168e-01f, -4.70569819e-01f, 3.41484249e-01f, 9.07310545e-01f, -2.10373327e-01f, 1.09025300e+00f,
  -4.52928483e-01f, 4.07997072e-02f, 5.15301824e-01f, -2.52041310e-01f, -5.52479506e-01f, 2.76431501e-01f, 1.06640148e-03f, -3.26729745e-01f, -8.22812989e-02f, 2.40720972e-01f,
  -4.05965388e-01f, 9.70383346e-01f, 6.25151694e-01f, 1.84601005e-02f, -1.29957899e-01f, -1.54870793e-01f, -6.68132544e-01f, 5.33140600e-01f, 6.93780363e-01f, 4.26867157e-02f,
  -1.49614781e-01f, -2.71131158e-01f, 8.35829973e-01f, -4.67522413e-01f, -1.60585996e-02f, 5.22823691e-01f, 2.47631237e-01f, 2.66346246e-01f, 1.72164645e-02f, 4.77592915e-01f,
  1.59594774e+00f, -5.47303200e-01f, -2.70127952e-01f, 1.91934537e-02f, -3.06922406e-01f, -2.04747722e-01f, -1.51986212e-01f, -4.93572026e-01f, -3.89789253e-01f, -2.58027107e-01f,
  4.96791929e-01f, 5.39510489e-01f, 5.51596701e-01f, 1.63309202e-01f, -9.66342017e-02f, -1.06662780e-01f, -3.23305607e-01f, -2.57172197e-01f, 1.59237099e+00f, -7.09915340e-01f,
  -2.06174836e-01f, 2.26345271e-01f, -3.07010472e-01f, -3.57672393e-01f, -4.38191384e-01f, 2.94672817e-01f, -5.82011223e-01f, -6.53923273e-01f, -3.45555484e-01f, -4.42670852e-01f,
  -6.28116131e-01f, 6.28269792e-01f, -2.80983418e-01f, 8.64493430e-01f, -2.69133121e-01f, 6.01590611e-02f, -2.63214231e-01f, -4.15925324e-01f, 9.78998721e-01f, -3.61890286e-01f,
  -4.67971355e-01f, 1.47384852e-01f, -5.00507891e-01f, -2.54110008e-01f, 8.53853822e-01f, -3.40272099e-01f, 2.63426676e-02f, -4.07016844e-01f, -1.86536774e-01f, 2.37613101e-03f,
  -4.09536541e-01f, 3.05385254e-02f, 1.45122424e-01f, -8.26254860e-02f, -3.51110488e-01f, -6.13881648e-01f, 1.14592528e+00f, 9.33905505e-03f, 6.12351418e-01f, -4.49641943e-01f,
  9.23976183e-01f, -4.00908798e-01f, -4.01315719e-01f, -3.34668458e-01f, -3.43525469e-01f, -2.58583367e-01f, -4.72013623e-01f, -3.90085131e-01f, -1.12553068e-01f, 5.79444170e-01f,
  2.93378830e-01f, 1.12095797e+00f, -1.04653776e-01f, -7.06710398e-01f, 3.52265179e-01f, -6.10329390e-01f, -6.42527759e-01f, -2.28917480e-01f, -4.57786411e-01f, -4.16102797e-01f,
  1.07213581e+00f, 5.58107376e-01f, -1.40673235e-01f, -1.05952330e-01f, -3.90831441e-01f, -2.12609112e-01f, -5.34413040e-01f, -3.57439041e-01f, 4.31087196e-01f, 9.86984849e-01f,
  1.22573227e-01f, 3.27772677e-01f, -1.36451572e-01f, 4.05994952e-01f, -2.85176456e-01f, -2.42432863e-01f, -2.50011623e-01f, -3.38103436e-02f, -5.94578505e-01f, 2.78518766e-01f,
  -4.21054155e-01f, 1.38772178e+00f, -1.44003898e-01f, -6.12011075e-01f, -4.58547205e-01f, -1.54776603e-01f, 1.33400023e-01f, -4.11071837e-01f, -3.04857711e-03f, 9.37268555e-01f,
  -3.67966950e-01f, 8.71215463e-02f, -6.13489896e-02f, -6.83118224e-01f, -4.87634182e-01f, 7.55777434e-02f, 2.90146023e-02f, -3.08083564e-01f, 1.20300472e+00f, 3.26999038e-01f,
  4.73765075e-01f, 8.51020217e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.54269475e-01f, 4.41867411e-02f, 8.70066285e-02f, -1.90040991e-01f, 1.94234818e-01f, 4.67724681e-01f, 3.04872513e-01f, -2.20219746e-01f, -7.14958087e-03f, -2.38215681e-02f,
  2.92412937e-01f, -8.94766003e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    