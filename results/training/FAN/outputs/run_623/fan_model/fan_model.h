/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.31219894e-01f, 3.27548385e-01f, -2.33174995e-01f, 7.52774030e-02f, 1.73597902e-01f, -8.60372260e-02f, 1.82065621e-01f, -5.22680022e-02f, -6.60013407e-02f, 2.31567383e-01f,
  -5.49648777e-02f, -4.42064963e-02f, -7.64243230e-02f, 1.44591555e-01f, -7.48796165e-02f, 6.34402856e-02f, 1.74623862e-01f, 9.46018659e-03f, -1.17684677e-01f, 1.88184157e-02f,
  3.10246408e-01f, 7.46909678e-02f, -9.55899898e-03f, -1.31332353e-01f, 2.97995955e-01f, -1.72572602e-02f, -7.75926858e-02f, 6.29828051e-02f, 2.68330309e-03f, 7.04124153e-01f,
  -4.84269316e-04f, 2.35231847e-01f, 1.38093848e-02f, 2.17322242e-02f, 3.89557183e-02f, -4.11663614e-02f, -1.16498142e-01f, 7.49748424e-02f, -5.08411303e-02f, 5.13805225e-02f,
  2.31117364e-02f, -4.26943563e-02f, -1.91172957e-02f, 1.01626612e-01f, 1.84157994e-02f, 5.13772257e-02f, 6.00725375e-02f, -5.06936982e-02f, -2.32343725e-03f, 4.32055220e-02f,
  6.99336529e-02f, 1.13717742e-01f, 1.55001683e-02f, 4.26054709e-02f, -3.72326821e-02f, -2.00338233e-02f, 1.07521564e-01f, 5.70411794e-02f, -6.92077121e-03f, 2.37915948e-01f,
  -6.26044348e-02f, -3.87307294e-02f, -1.34620667e-02f, 3.06018088e-02f, -7.29952380e-02f, -1.10747486e-01f, -6.93667354e-03f, 7.50761526e-03f, 2.10436564e-02f, -4.92496714e-02f,
  -1.71618816e-02f, -7.47154877e-02f, -1.40963225e-02f, -4.26502898e-02f, 7.45012164e-02f, 4.59574647e-02f, 5.37109748e-02f, -3.69986892e-03f, 7.55675063e-02f, 8.07133690e-02f,
  -1.23682246e-03f, -2.69762371e-02f, -2.93551181e-02f, 2.21435707e-02f, -1.38299651e-02f, 2.44463608e-02f, 7.40393475e-02f, 5.72426151e-03f, -3.79010029e-02f, 3.82095091e-02f,
  -2.34693199e-01f, -1.02943122e-01f, 5.86367175e-02f, 1.43315066e-02f, 7.97943175e-02f, -3.70144099e-02f, 1.18315466e-01f, 1.47947771e-02f, -7.02129006e-02f, 1.28061548e-01f,
  9.56853107e-03f, -4.87044454e-02f, -5.08102067e-02f, 1.33023146e-04f, 2.30833935e-03f, 4.93202694e-02f, -8.50729346e-02f, 5.08676842e-02f, 3.59696299e-02f, 7.71338791e-02f,
  1.25805545e-03f, 4.06117365e-02f, 2.45589297e-02f, -3.60393599e-02f, 4.88301031e-02f, 1.90003216e-02f, -1.15265148e-02f, -2.82241441e-02f, -1.05355337e-01f, -6.86910376e-02f,
  -6.14335656e-01f, 2.34558389e-01f, 1.43940136e-01f, -2.13747069e-01f, -2.14537665e-01f, -1.54854611e-01f, -3.37174147e-01f, -2.48631895e-01f, -1.65241444e-03f, -1.25391409e-01f,
  3.59564871e-02f, 3.08520138e-01f, 3.17950577e-01f, 2.11805731e-01f, -9.48261544e-02f, -8.04015100e-02f, -2.47853808e-02f, 9.44080055e-02f, 1.34542167e-01f, 2.74202554e-03f,
  3.18661571e-01f, -7.95146152e-02f, -1.57660112e-01f, 7.05472678e-02f, 2.88621453e-03f, 1.37475878e-01f, -1.01209126e-01f, -1.05378859e-01f, 1.12146981e-01f, 4.41724658e-01f,
  2.66226619e-01f, 2.85841059e-02f, 1.04126960e-01f, -1.04447834e-01f, -1.19097859e-01f, 1.36565755e-03f, 6.06842302e-02f, 6.63086027e-02f, 7.13484809e-02f, -2.72363219e-02f,
  3.88718285e-02f, 1.79493390e-02f, 7.48684704e-02f, 1.21063493e-01f, -5.08293658e-02f, 3.68862860e-02f, -7.04524294e-02f, 1.31218180e-01f, 1.76669717e-01f, 4.50399779e-02f,
  1.09005056e-01f, -3.25943641e-02f, 2.33943947e-03f, 7.17342889e-04f, -6.62943348e-02f, 4.32238951e-02f, 9.79841426e-02f, -1.65359303e-03f, 2.67239865e-02f, 1.83334127e-01f,
  1.54455509e-02f, 1.39641315e-02f, -7.12798759e-02f, 5.60832918e-02f, -8.55707526e-02f, 9.92346928e-02f, 9.08065471e-04f, 4.97978665e-02f, -3.99174243e-02f, -9.10894647e-02f,
  5.69501631e-02f, 4.18974692e-03f, 5.58283664e-02f, -1.51511673e-02f, 6.39599785e-02f, -1.19680185e-02f, -2.35419832e-02f, -9.30843595e-03f, 4.07558978e-02f, -3.11573353e-02f,
  6.21748380e-02f, 7.75528885e-03f, -1.09800816e-01f, 1.06535211e-01f, -7.59468749e-02f, 7.37771317e-02f, -4.17784192e-02f, -8.45998526e-04f, 1.58038028e-02f, -1.52014539e-01f,
  2.01375932e-02f, -7.22731724e-02f, 1.06907800e-01f, 1.55082829e-02f, 4.97021824e-02f, -1.20734163e-02f, -1.05609829e-02f, 8.48395228e-02f, 4.65402985e-03f, 5.31758964e-02f,
  -7.32401311e-02f, -8.36993754e-03f, 4.88964878e-02f, 5.57299368e-02f, -1.13518368e-02f, -1.06906734e-01f, -5.10086492e-02f, 1.53046278e-02f, 5.79523807e-03f, -1.99965984e-02f,
  -4.19004001e-02f, -6.55320138e-02f, -6.79427711e-03f, 3.80689278e-02f, 4.21691053e-02f, -1.25184208e-01f, 7.92254210e-02f, -2.82397065e-02f, -6.49558529e-02f, -1.14057720e-01f,
  3.03170621e-01f, -5.15194893e-01f, 1.42856449e-01f, 9.07065943e-02f, -1.40845060e-01f, 1.18570015e-01f, -3.09073985e-01f, 3.23027819e-02f, 9.92868096e-02f, -1.68292254e-01f,
  1.60752498e-02f, 1.98953062e-01f, 9.48648453e-02f, 1.61841676e-01f, 3.33258778e-01f, -1.52182966e-01f, -6.66996464e-02f, 2.34026209e-01f, 4.04047966e-01f, 2.02126101e-01f,
  -5.32092080e-02f, -1.30706459e-01f, 1.97612047e-01f, 1.55791476e-01f, -3.79335552e-01f, 2.27364734e-01f, -7.87316561e-02f, -1.18024826e-01f, -5.75906113e-02f, -6.08605146e-01f,
  -8.26248303e-02f, -2.30845034e-01f, 2.63407111e-01f, 1.06564783e-01f, -1.31518945e-01f, -3.31089273e-02f, -3.50995138e-02f, -3.86584364e-02f, 1.56117720e-03f, 1.89265385e-02f,
  -1.34976003e-02f, 2.30968688e-02f, -2.11249627e-02f, -4.07787822e-02f, -7.33732730e-02f, 9.66626685e-03f, -5.98461274e-03f, -1.93818957e-02f, 3.74400541e-02f, -1.18783370e-01f,
  -7.96031654e-02f, -2.98416521e-02f, -6.68344870e-02f, 7.08360001e-02f, 2.28951108e-02f, 9.58960429e-02f, -4.83850949e-02f, -3.96261327e-02f, 1.34471804e-01f, -1.98910043e-01f,
  -3.48231802e-03f, -2.79935431e-02f, 2.24202443e-02f, -3.82459275e-02f, 9.22749843e-03f, -4.20430899e-02f, -2.42375191e-02f, 9.88875167e-04f, 2.28537694e-02f, -2.38154270e-02f,
  1.04302010e-02f, -2.27756258e-02f, -1.73834320e-02f, -1.82330853e-03f, 3.12622637e-02f, -4.24730368e-02f, 1.91359483e-02f, -3.40794586e-02f, 1.04792342e-01f, 1.22235576e-03f,
  7.67412856e-02f, 1.80047583e-02f, 9.82554164e-04f, -7.00974613e-02f, 6.92530051e-02f, 1.40754888e-02f, 1.19457915e-02f, 1.80861969e-02f, 4.33481522e-02f, -1.58600714e-02f,
  -1.74037457e-01f, 2.37778798e-01f, -1.84115078e-02f, -6.91573694e-02f, 6.18573427e-02f, -3.55145857e-02f, 9.48763825e-03f, -1.30667267e-02f, -1.44929826e-01f, 1.01453178e-02f,
  2.65853107e-02f, -6.50534267e-03f, -8.33780617e-02f, -1.54412398e-02f, 4.13959101e-02f, 2.93422695e-02f, -7.01893046e-02f, -4.71714092e-03f, -1.60327945e-02f, -3.43358293e-02f,
  -2.85843238e-02f, 6.89967126e-02f, 1.59495592e-01f, 3.08595900e-03f, -5.54133765e-02f, 1.55433893e-01f, -1.69531982e-02f, -2.64545009e-02f, 6.76370934e-02f, 9.49759874e-03f,
  6.20068789e-01f, 4.12513852e-01f, -5.22390045e-02f, -4.23860997e-02f, -3.54922354e-01f, -1.06201082e-01f, 4.27900642e-01f, 1.52253196e-01f, -1.74647421e-01f, 2.44783133e-01f,
  -2.10926048e-02f, -1.86359435e-01f, -1.43190557e-02f, 2.16012206e-02f, 2.79079616e-01f, 4.16968882e-01f, 1.57982528e-01f, 3.07960156e-02f, -4.93333228e-02f, -3.04761585e-02f,
  -2.44051758e-02f, 7.83290789e-02f, 3.53931598e-02f, 1.17256511e-02f, 1.83337834e-02f, -1.22607030e-01f, 7.57159814e-02f, -1.39252082e-01f, -4.84727360e-02f, 8.79900716e-03f,
  2.16218963e-01f, 6.98770434e-02f, -5.35196029e-02f, -1.00069763e-02f, -3.71274725e-02f, 2.69302279e-02f, 4.23117951e-02f, -8.00097138e-02f, 1.04755303e-02f, 3.67613090e-03f,
  -8.70632678e-02f, -1.17752649e-01f, 2.91480999e-02f, -6.15011901e-02f, 8.89987797e-02f, 2.46521067e-02f, -1.83275640e-02f, 1.43341169e-01f, 1.31424025e-01f, 3.13514993e-02f,
  1.55978873e-02f, -1.95912525e-01f, 1.60035696e-02f, 3.23524512e-02f, 9.80896875e-02f, -1.22455068e-01f, -4.97003123e-02f, -1.68374598e-01f, 2.18028203e-02f, 3.06364540e-02f,
  -1.83219966e-02f, -3.19342092e-02f, -1.59296822e-02f, 5.26111834e-02f, 3.96953709e-02f, -2.12498155e-04f, -1.76405106e-02f, 6.22310229e-02f, 5.31876124e-02f, 8.09989125e-02f,
  -1.47979334e-03f, 4.83179279e-02f, 2.26196665e-02f, 1.25718236e-01f, -1.37401978e-02f, -5.61241731e-02f, -8.41531344e-03f, 5.20590991e-02f, -6.91978708e-02f, 5.58224842e-02f,
  7.28765875e-02f, -7.35333785e-02f, -1.79469157e-02f, 6.55814493e-03f, 7.67199323e-02f, 4.68537360e-02f, 1.02301631e-02f, 1.18757002e-02f, 2.45909505e-02f, -1.06673710e-01f,
  9.36085135e-02f, -1.42817408e-01f, 9.74961668e-02f, 7.31290653e-02f, -7.45081529e-02f, -6.95228055e-02f, -2.85541043e-02f, -2.82828920e-02f, -1.35013387e-01f, 7.19769746e-02f,
  1.29862754e-02f, 1.14568479e-01f, 3.49247344e-02f, -1.19139822e-02f, 6.51999116e-02f, 8.50128010e-03f, 6.59035593e-02f, -6.16087876e-02f, -1.32912099e-02f, -7.49172717e-02f,
  5.63843036e-03f, 7.71038830e-02f, 3.08991283e-01f, 1.83791876e-01f, 7.31858164e-02f, 1.18418947e-01f, 1.46142572e-01f, 3.09073403e-02f, 8.63806382e-02f, 4.61088151e-01f,
  1.18420444e-01f, -2.76092589e-01f, -1.76238388e-01f, -1.23224007e-02f, 5.44943549e-02f, 2.24165574e-01f, 3.06515489e-02f, 4.55966480e-02f, 1.02837317e-01f, 1.06051736e-01f,
  -1.30625620e-01f, 7.17147961e-02f, -3.49245779e-02f, -7.92993233e-03f, 7.53245354e-02f, 2.18853839e-02f, -1.21186398e-01f, 4.72634584e-02f, 2.50917524e-01f, 1.45999771e-02f,
  -9.91721824e-02f, 9.82820895e-03f, -4.10356782e-02f, -1.68384507e-01f, -7.49380961e-02f, 8.72468129e-02f, -1.43459504e-02f, -9.70015302e-02f, -1.04134440e-01f, -3.71863693e-01f,
  -6.21267930e-02f, -3.61755997e-01f, 1.22869961e-01f, -4.20829207e-02f, -9.25356150e-02f, 4.79091369e-02f, 3.37412469e-02f, -6.46326467e-02f, 1.24550648e-02f, -1.98469441e-02f,
  -8.84564817e-02f, -4.51486930e-02f, -3.89840975e-02f, 4.30696979e-02f, -1.37555506e-02f, 5.51929474e-02f, -9.61269960e-02f, -1.12854965e-01f, -1.94771066e-02f, 4.51728627e-02f,
  -1.22486085e-01f, -1.63452849e-01f, -8.45335275e-02f, -1.08209401e-01f, -1.32930391e-02f, 5.22987656e-02f, -5.70515022e-02f, -1.53852358e-01f, -8.98794681e-02f, -5.89724481e-02f,
  1.88936815e-02f, 1.34408185e-02f, -1.07088182e-02f, 6.32898556e-03f, -7.22737238e-03f, 8.23828653e-02f, -3.36482897e-02f, 1.01769745e-01f, -1.48142846e-02f, -2.66261697e-02f,
  2.57556085e-02f, 9.28819776e-02f, 5.64582236e-02f, -3.30416933e-02f, -3.04557513e-02f, -1.77444331e-02f, 2.20899358e-02f, -9.28225182e-03f, -6.12144805e-02f, -9.73105896e-03f,
  2.93331277e-02f, 2.29441142e-03f, -1.26495203e-02f, -2.19489243e-02f, -6.29801825e-02f, -9.90524516e-03f, 2.54850294e-02f, 3.56520489e-02f, -1.50848646e-02f, -3.32280733e-02f,
  2.86643296e-01f, 8.66216701e-03f, 1.84125677e-01f, 4.10765633e-02f, 8.90985876e-02f, -1.22120613e-02f, -2.30916142e-02f, -7.37028793e-02f, 1.47601664e-02f, -4.80983965e-03f,
  1.00987464e-01f, 8.16888586e-02f, 6.06635697e-02f, 1.34983510e-02f, 1.58947870e-01f, 1.93842556e-02f, 7.09555000e-02f, 1.04088753e-01f, 1.17021669e-02f, 4.48347330e-02f,
  7.65550584e-02f, 1.10532649e-01f, 3.78480911e-01f, 6.90068007e-02f, 2.05978140e-01f, 3.06930929e-01f, 2.35988781e-01f, 2.14168847e-01f, 2.90702224e-01f, 4.26930785e-01f,
  2.22755536e-01f, -2.72283673e-01f, 4.80382353e-01f, 2.15958767e-02f, 2.79568553e-01f, 1.27378553e-01f, 3.31583381e-01f, 7.23884851e-02f, -9.05759260e-02f, 5.26914038e-02f,
  -8.85128677e-02f, -2.10503995e-01f, -2.56827712e-01f, -1.94204554e-01f, 8.20360035e-02f, 1.20255977e-01f, 1.73321664e-01f, 1.35413185e-01f, 1.44491389e-01f, 2.20005691e-01f,
  -1.29882589e-01f, -2.20504906e-02f, -9.33311731e-02f, -6.07958883e-02f, 1.38160987e-02f, -2.04699084e-01f, -1.84057765e-02f, 8.56564566e-02f, -2.01602519e-01f, 2.41913497e-01f,
  1.81610752e-02f, 2.34344095e-01f, -6.76376298e-02f, -1.85990855e-01f, -2.24680025e-02f, 1.19993500e-02f, 8.18888471e-03f, 2.57683359e-02f, -2.91475896e-02f, 3.12344972e-02f,
  -1.24249943e-02f, -6.66174963e-02f, -1.33087877e-02f, -2.70779878e-02f, -1.16002960e-02f, 3.39995101e-02f, -6.24235496e-02f, 4.40414101e-02f, -4.31030728e-02f, 5.32151945e-02f,
  -8.98655951e-02f, 7.25353733e-02f, 2.05651373e-01f, 3.66341546e-02f, 1.01734810e-02f, -3.76774892e-02f, 3.38740210e-05f, 1.05490237e-01f, 1.17643308e-02f, 3.70081118e-03f,
  -7.41358101e-02f, 3.56059708e-02f, -6.04559444e-02f, 4.58980203e-02f, -4.17899601e-02f, -6.26402572e-02f, 1.03507610e-02f, -6.63113371e-02f, -5.64115494e-02f, 1.20064449e-02f,
  -5.61886318e-02f, 3.90468538e-02f, -4.21833694e-02f, 5.68594635e-02f, -5.02481945e-02f, 8.64388198e-02f, 7.95004889e-02f, -7.65128359e-02f, -1.80620346e-02f, -9.94249210e-02f,
  -3.78613658e-02f, 4.71695960e-02f, -5.55666909e-02f, 4.51291390e-02f, -1.75741054e-02f, 2.91106235e-02f, 3.70273888e-02f, -1.23992655e-02f, -1.50770089e-02f, 7.50620589e-02f,
  -2.28222534e-01f, -5.45751303e-02f, 2.60336958e-02f, 3.44874114e-02f, 3.50033306e-02f, -7.00538978e-02f, 9.79429577e-03f, -8.24777503e-03f, -9.19806957e-02f, 1.69548355e-02f,
  4.26401682e-02f, 8.74570454e-04f, 5.32797119e-03f, -2.58021355e-02f, 4.25668135e-02f, 7.57145435e-02f, -9.85079482e-02f, 1.58725474e-02f, 4.44159880e-02f, 6.43226504e-02f,
  -3.91216464e-02f, 3.22870947e-02f, -3.46575342e-02f, 6.70780381e-03f, 1.07890427e-01f, -2.53574140e-02f, 2.44936999e-02f, 8.34581256e-02f, 2.38111671e-02f, -7.19171464e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.94318497e-01f, 1.02308296e-01f, -6.51922464e-01f, 6.11348264e-02f, -2.89404511e-01f, -1.21845111e-01f, -4.70287740e-01f, 2.96211898e-01f, 3.18794787e-01f, -3.16782802e-01f,
  -4.28502820e-02f, 3.36557105e-02f, -2.81796128e-01f, -1.21482104e-01f, -5.52901328e-02f, -4.19504523e-01f, -3.76553863e-01f, -4.65053767e-01f, -1.89180687e-01f, 1.19323298e-01f,
  1.60599232e-01f, 4.61611077e-02f, 1.75295979e-01f, 2.58395433e-01f, 1.70052610e-02f, 6.24649227e-04f, -2.99072325e-01f, -7.84531981e-02f, 3.07238512e-02f, -5.14355302e-01f,
  -6.10019386e-01f, 2.11264297e-01f, -2.20149860e-01f, -5.92654422e-02f, -1.60375744e-01f, 1.06913641e-01f, -1.44152522e-01f, 3.18996385e-02f, 1.64920725e-02f, -5.00410190e-03f,
  -4.51334529e-02f, 8.16470757e-02f, 8.50508884e-02f, -1.36352619e-02f, 3.95688489e-02f, 3.70826502e-03f, 3.68145518e-02f, -9.83270854e-02f, -7.96999112e-02f, 7.06377700e-02f,
  2.72549165e-04f, -6.50153533e-02f, -1.17197983e-01f, 2.83470973e-02f, 3.98711599e-02f, -1.50225669e-01f, 6.09037541e-02f, 1.38013263e-03f, 1.68143138e-02f, 1.07355855e-01f,
  -3.40164900e-02f, -1.10524788e-01f, 1.80470310e-02f, 8.31809342e-02f, 1.95856653e-02f, -6.10525645e-02f, -3.72883826e-02f, -3.21124941e-02f, 5.13737909e-02f, 1.50899338e-02f,
  2.24960092e-02f, -1.02716625e-01f, 9.32056308e-02f, -8.11826438e-02f, -6.62499145e-02f, 1.85743198e-02f, 1.00107267e-01f, -1.78815592e-02f, -1.67446118e-02f, 7.24602863e-02f,
  6.01176955e-02f, -2.54845824e-02f, 6.58844551e-03f, 1.32135913e-01f, -1.13087811e-01f, 1.13204625e-02f, -2.71461289e-02f, -1.09627927e-02f, 1.18423946e-01f, 3.31724137e-02f,
  2.65552461e-01f, -2.34860986e-01f, -6.80608675e-02f, 1.11500613e-01f, -3.88120301e-03f, 8.29048175e-03f, -2.33984850e-02f, 7.79994577e-02f, 1.57041382e-02f, -1.66373607e-02f,
  1.02528349e-01f, 8.17034952e-03f, -3.97138409e-02f, -7.79875740e-02f, 9.20001045e-02f, 4.27712575e-02f, 3.03379614e-02f, -4.28051176e-03f, 8.13335255e-02f, 1.75468996e-01f,
  3.15512717e-02f, 7.50941485e-02f, 1.91449728e-02f, -5.49819437e-04f, 1.44718215e-01f, -9.36726332e-02f, -2.20961105e-02f, 3.42296995e-02f, -4.97271493e-02f, 5.79186864e-02f,
  -9.23515439e-01f, 6.49712384e-02f, 1.81390837e-01f, -4.48571235e-01f, 1.79215655e-01f, 2.61739373e-01f, 1.54485051e-02f, 2.76295632e-01f, 1.89588562e-01f, 1.55804932e-01f,
  7.86933824e-02f, -1.87085435e-01f, -1.34521529e-01f, 1.34478956e-01f, -1.20205656e-01f, -1.03029415e-01f, -1.85971633e-01f, -3.83432508e-01f, -2.41364077e-01f, 1.66142091e-01f,
  -6.72844946e-02f, -6.47561252e-01f, -6.34195626e-01f, -3.45879756e-02f, 2.71037668e-02f, -2.37775579e-01f, -3.00442725e-01f, -3.91457647e-01f, 9.07638203e-03f, -3.74735087e-01f,
  -1.41633317e-01f, 9.08867046e-02f, 2.57061720e-01f, -5.95001467e-02f, -1.04559213e-01f, 6.01263642e-02f, -1.16311356e-01f, -1.44739360e-01f, 5.03139310e-02f, 9.48894024e-02f,
  -8.50197375e-02f, 8.76410082e-02f, -6.07916191e-02f, -8.10799152e-02f, -6.95127398e-02f, -2.99661439e-02f, 1.30303457e-01f, -5.51750809e-02f, 9.13705751e-02f, 2.58324981e-01f,
  1.53498456e-01f, 9.99312922e-02f, 7.84653649e-02f, 3.04008096e-01f, 1.20376229e-01f, 1.17400557e-01f, 1.76228553e-01f, 2.46259063e-01f, 2.75345892e-01f, -9.40210000e-02f,
  1.07397242e-02f, 1.47440424e-02f, 1.67622000e-01f, -2.73667928e-02f, -8.09615478e-02f, 3.82339321e-02f, -1.67737201e-01f, -1.35763586e-01f, -1.04581811e-01f, -7.32871518e-02f,
  1.13850601e-01f, 6.97699562e-02f, -8.60776231e-02f, -1.12334574e-02f, -5.91280349e-02f, 1.52723029e-01f, -6.52670935e-02f, -2.33661029e-02f, 1.22616470e-01f, 6.72934158e-03f,
  2.99627800e-02f, -6.40226603e-02f, 4.30479506e-03f, -1.04381613e-01f, -3.92112918e-02f, -3.70520204e-02f, 1.09542899e-01f, 1.43959492e-01f, -1.03086268e-03f, 1.47569180e-01f,
  -3.72700930e-01f, 1.74327165e-01f, -9.90734324e-02f, 4.54187617e-02f, 1.05609149e-02f, 1.52710229e-01f, -1.05075967e-02f, -2.30619591e-02f, 9.80435312e-03f, -2.46378146e-02f,
  8.76614153e-02f, -5.52494787e-02f, -9.07716081e-02f, 1.00708976e-01f, -1.06990032e-01f, 1.34402946e-01f, -6.71655522e-04f, -1.40458703e-01f, 1.13764375e-01f, 1.08588226e-01f,
  5.87364510e-02f, 5.15005291e-02f, -8.46571624e-02f, -3.36926356e-02f, 3.52106579e-02f, -1.36943042e-01f, -4.27677594e-02f, -4.77248542e-02f, -4.81437780e-02f, -2.01337799e-01f,
  6.08245432e-01f, -1.56119540e-01f, 8.78977925e-02f, 3.95166397e-01f, 3.14443707e-01f, 4.55988944e-01f, 3.88426304e-01f, 2.43419170e-01f, 1.96277291e-01f, 2.18297556e-01f,
  6.92117810e-02f, -1.05074197e-01f, -9.18240696e-02f, -2.34723836e-01f, -1.32232651e-01f, 4.35420349e-02f, -2.12474279e-02f, -2.21316531e-01f, 3.56701128e-02f, 1.60643324e-01f,
  -3.57487053e-02f, -4.51202057e-02f, -7.53690256e-03f, -1.87118292e-01f, -2.13147447e-01f, -1.40216216e-01f, 3.10840039e-03f, -1.37335673e-01f, -1.33893296e-01f, -4.63930964e-01f,
  1.16070919e-01f, 1.01823770e-01f, 1.48080453e-01f, 7.75220767e-02f, 4.37055044e-02f, 3.31777707e-02f, 4.95073311e-02f, -1.19572952e-01f, 1.38588905e-01f, 5.18540964e-02f,
  -7.44059831e-02f, 1.89829841e-02f, 8.31281766e-02f, -1.17856659e-01f, 5.09908609e-02f, -1.04975319e-02f, -1.08234202e-02f, 6.25942424e-02f, 5.65537177e-02f, 6.73719421e-02f,
  1.57142952e-02f, 1.10997275e-01f, 3.05435546e-02f, 8.46198723e-02f, 3.76812629e-02f, 1.11892134e-01f, -4.43251990e-02f, -6.39116466e-02f, -3.33090909e-02f, -4.72874790e-02f,
  1.71614349e-01f, 3.08957929e-03f, -4.55661528e-02f, 1.27566596e-02f, -1.16601810e-01f, 1.33340865e-01f, 5.16434340e-03f, -2.57015154e-02f, -8.44141021e-02f, -1.69640079e-01f,
  -6.66601509e-02f, 6.40088543e-02f, 1.73977378e-03f, 7.17844963e-02f, -5.64904697e-02f, 3.91746536e-02f, -6.46186322e-02f, 4.10013199e-02f, -9.35690254e-02f, -3.39366011e-02f,
  -9.39554125e-02f, 6.89343885e-02f, -8.12037615e-04f, -1.10205263e-01f, -4.21421416e-02f, -4.83677015e-02f, -1.18087754e-02f, -9.44850296e-02f, -1.17566414e-01f, 5.72208203e-02f,
  1.92443371e-01f, 1.86334521e-01f, 8.88322964e-02f, -4.82007675e-02f, -1.73723064e-02f, -4.99698371e-02f, -3.55929956e-02f, 2.18706578e-02f, 3.83065268e-02f, 3.43932249e-02f,
  6.72538057e-02f, -2.74150912e-02f, 3.48590314e-03f, 4.42825407e-02f, 2.09233128e-02f, 1.21361852e-01f, -7.95764774e-02f, 2.52022315e-02f, 8.66961405e-02f, 1.04543954e-01f,
  -9.56806913e-02f, 9.10520330e-02f, 2.36242011e-01f, 7.23825470e-02f, -7.66014308e-02f, 2.17860285e-03f, -3.18897367e-02f, 6.87620267e-02f, 1.07662253e-01f, 3.39083783e-02f,
  -6.33358896e-01f, 1.31166860e-01f, -6.23980463e-01f, -2.83510327e-01f, 3.18874747e-01f, 1.42449543e-01f, 3.16592604e-01f, 3.47020887e-02f, -5.41552268e-02f, 1.59454029e-02f,
  1.26410350e-02f, 1.23214655e-01f, -2.69459616e-02f, 2.11818635e-01f, 3.89041938e-02f, 3.12719673e-01f, 1.87685773e-01f, -1.43330783e-01f, -3.48758250e-01f, -8.06920454e-02f,
  4.19594884e-01f, -1.01996772e-01f, -5.46221316e-01f, -1.13040954e-02f, 8.58544111e-02f, -8.69075283e-02f, -1.11139759e-01f, -4.00438759e-04f, 1.73222065e-01f, 3.62488389e-01f,
  -2.09164649e-01f, -2.00754806e-01f, -1.83789860e-02f, 8.23974684e-02f, -2.73606293e-02f, -2.52619218e-02f, 6.00717328e-02f, -7.26862103e-02f, 6.15542680e-02f, -5.34334183e-02f,
  6.04514964e-02f, -4.10579890e-03f, 1.45663600e-02f, -5.31964004e-02f, 1.19267218e-02f, 7.66302506e-03f, -3.66167277e-02f, -1.51912466e-01f, -3.91671993e-02f, -1.18001714e-01f,
  3.38246077e-01f, -2.69109886e-02f, -1.44768611e-01f, 1.25216857e-01f, -3.09855621e-02f, -2.56111890e-01f, -2.59948790e-01f, 3.92301902e-02f, -2.14126915e-01f, 4.06142958e-02f,
  4.58324701e-02f, -2.24676952e-02f, 3.28699984e-02f, -4.75629382e-02f, 1.28623089e-02f, -1.27650155e-02f, 1.34678394e-01f, 2.39428692e-02f, 8.31975266e-02f, -8.04474577e-02f,
  5.25296181e-02f, -5.70424497e-02f, 7.97603279e-02f, -8.75895657e-03f, -1.19820721e-02f, -6.50675818e-02f, 3.74485925e-02f, 9.57504753e-03f, -1.63717084e-02f, -1.70930810e-02f,
  6.23692088e-02f, 2.98154131e-02f, 2.76759397e-02f, 5.04151471e-02f, 1.62287846e-01f, 4.34315056e-02f, -1.11427091e-01f, -4.16775867e-02f, -1.32195234e-01f, -9.13661905e-04f,
  -4.45536599e-02f, 1.87522218e-01f, -5.80840707e-02f, -5.71767911e-02f, -9.51385219e-03f, -4.50722128e-02f, -7.91921988e-02f, -1.76116265e-02f, -2.51217112e-02f, -1.01407990e-02f,
  -2.99095339e-03f, 5.56238890e-02f, -3.74480113e-02f, 6.82032853e-03f, -3.29304449e-02f, -7.10799396e-02f, 9.26850289e-02f, -6.01484142e-02f, 2.50988491e-02f, 5.00289872e-02f,
  -7.36892447e-02f, 3.72048020e-02f, 7.19560310e-02f, -1.24187730e-01f, 8.36141706e-02f, 7.60849193e-02f, -2.39527792e-01f, -2.09977478e-01f, -2.45497823e-02f, -2.67490596e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.77805088e-02f, -5.28857648e-01f, 2.39967003e-01f, -6.98987618e-02f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -3.15317243e-01f, 1.11080490e-01f, -5.10316968e-01f, -1.08561255e-01f, 6.23701327e-02f, 2.92422116e-01f, -3.41862917e-01f, 2.61056405e-02f, 3.11517417e-01f, -1.92295566e-01f,
  -8.14584568e-02f, -3.28333467e-01f, 1.19674623e-01f, -2.29059622e-01f, -1.54976442e-01f, -2.45764077e-01f, -3.11118245e-01f, -1.94169596e-01f, -4.86862868e-01f, -2.91703582e-01f,
  6.84078187e-02f, 3.98268938e-01f, 1.19021386e-02f, 4.02626514e-01f, -2.20138699e-01f, -2.96017885e-01f, 3.12788516e-01f, -3.02093744e-01f, 3.51612240e-01f, 1.30587518e-01f,
  1.12652749e-01f, 1.11791783e-03f, 1.20354883e-01f, 3.88920791e-02f, -4.29212242e-01f, 2.49056727e-01f, 1.54650629e-01f, -1.93391323e-01f, -1.39363885e-01f, -5.66438317e-01f,
  2.64733166e-01f, 6.70492724e-02f, 1.90037042e-01f, 2.58137554e-01f, -4.99506928e-02f, -9.79892537e-02f, 1.95987597e-01f, -1.58135995e-01f, -3.22609454e-01f, 7.12491870e-02f,
  -1.37746245e-01f, 1.06427722e-01f, 4.94528525e-02f, 3.90140682e-01f, 3.45098190e-02f, 2.75303394e-01f, 2.86898077e-01f, 4.39887904e-02f, 3.64779472e-01f, -3.92561369e-02f,
  -1.73527464e-01f, 2.08106801e-01f, -1.18769020e-01f, 5.61195314e-01f, 3.36069703e-01f, -1.36598051e-01f, 3.70300621e-01f, 1.70820020e-02f, -2.63160825e-01f, 1.02657443e-02f,
  1.04562789e-01f, -1.79295108e-01f, -7.75312185e-01f, 2.25883663e-01f, 1.23957500e-01f, -5.24006605e-01f, -1.69144526e-01f, -3.16551656e-01f, -2.88798749e-01f, 1.37476727e-01f,
  3.07278335e-01f, 7.10331872e-02f, 4.50159609e-02f, 2.62272693e-02f, -1.15071349e-01f, 1.06690899e-01f, -1.73093811e-01f, 5.20557798e-02f, 5.78664303e-01f, 1.09769627e-01f,
  1.71435907e-01f, -3.49495620e-01f, 2.10471302e-01f, -2.90324926e-01f, 1.53622776e-01f, -3.81233931e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -2.34257489e-01f, 1.08828142e-01f, 2.81718075e-01f, -5.43822870e-02f, 2.45635808e-02f, 5.09426668e-02f, 4.89624590e-01f, -9.37994421e-02f, -8.05358410e-01f, 3.85858417e-01f,
  -4.92358476e-01f, 8.93281400e-01f, -8.81529331e-01f, -6.86650813e-01f, 1.16748378e-01f, 7.12782204e-01f, -3.58505845e-02f, 2.64639944e-01f, 6.53880835e-02f, -2.12933064e-01f,
  3.44446957e-01f, 2.53031123e-03f, -5.26321083e-02f, -1.67998075e-01f, 4.64895993e-01f, 2.33200744e-01f, 2.49533162e-01f, -4.20879185e-01f, 6.40394092e-01f, -8.87073576e-02f,
  3.35564971e-01f, 1.02955759e-01f, 1.41733438e-01f, 5.66414714e-01f, 4.65871751e-01f, 4.42033112e-02f, 4.31998968e-01f, -2.96506286e-02f, 5.32321870e-01f, 3.45814943e-01f,
  -6.53210759e-01f, -4.59315658e-01f, -7.14512348e-01f, -9.33626667e-02f, 2.44734466e-01f, 4.71037626e-01f, -3.78937781e-01f, 6.68210268e-01f, 2.66687334e-01f, 2.45906413e-01f,
  -1.94930173e-02f, 6.72938079e-02f, 5.40918112e-01f, 4.72451836e-01f, 7.47373924e-02f, 8.72975662e-02f, 2.78753906e-01f, -5.53074181e-01f, -3.79901201e-01f, -4.36685950e-01f,
  3.34742039e-01f, 5.32583058e-01f, -5.79594672e-02f, 8.40835512e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  2.46436670e-01f, 1.13487415e-01f, -5.99289127e-02f, 3.03384438e-02f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  2.75072694e-01f, 3.10883187e-02f, -7.74752796e-02f, 3.09242815e-01f, -1.56851962e-01f, 2.50903040e-01f, -9.35831070e-02f, 4.72823381e-02f, 2.27915779e-01f, -4.41831261e-01f,
  5.18528879e-01f, 5.05516291e-01f, -1.51748985e-01f, 5.36952674e-01f, -9.36326385e-02f, -7.35507607e-02f, -6.13075830e-02f, 2.06845812e-03f, -8.25775042e-02f, -4.49349165e-01f,
  -9.17845219e-02f, -2.24081233e-01f, 2.71831155e-01f, -3.23418179e-03f, -2.95962840e-01f, 4.10643756e-01f, -4.91667747e-01f, -5.58508992e-01f, 8.79605711e-02f, -1.00885779e-01f,
  2.79824793e-01f, 3.10427606e-01f, 2.16925606e-01f, 7.03253508e-01f, 3.77665460e-01f, 3.28018442e-02f, -3.42642292e-02f, 7.31639564e-02f, 2.11773217e-02f, 5.21076381e-01f,
  -4.72033411e-01f, 6.21660113e-01f, 3.53716403e-01f, 1.51198536e-01f, -3.40907246e-01f, 4.51413542e-01f, -1.23227954e-01f, 2.17354268e-01f, 1.48696646e-01f, -4.84923460e-02f,
  4.80774254e-01f, -9.11162496e-02f, -1.32119849e-01f, -1.52166069e-01f, 2.28631094e-01f, -1.74131751e-01f, -7.30392516e-01f, 3.81308585e-01f, 1.28928050e-01f, -6.40607297e-01f,
  -1.51908612e-02f, -1.39449239e-01f, 3.38305026e-01f, 1.09802023e-01f, 1.32313045e-02f, -1.58365965e-01f, -1.70921817e-01f, -2.08246991e-01f, -1.87066466e-01f, 2.93929040e-01f,
  -8.88318241e-01f, 3.20197970e-01f, 5.90107262e-01f, -9.62636471e-02f, 5.06232306e-02f, 2.65553415e-01f, 2.09822923e-01f, 5.89132369e-01f, -2.24196643e-01f, -8.74599516e-02f,
  -3.48028600e-01f, -2.20467478e-01f, -1.52531162e-01f, -3.68662387e-01f, -3.68209422e-01f, 8.67970139e-02f, 8.13241839e-01f, 4.02489305e-01f, -6.20100737e-01f, 4.82819438e-01f,
  -4.50059235e-01f, -5.90692222e-01f, 3.37939024e-01f, 1.19073242e-01f, 3.48106027e-01f, -8.17193277e-03f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  9.48443353e-01f, 9.44840431e-01f, 6.47298217e-01f, 8.86961818e-02f, 6.75574243e-01f, 5.62904418e-01f, -7.75764227e-01f, -7.83906758e-01f, -8.54770780e-01f, 1.07546687e-01f,
  9.63489532e-01f, -1.69265449e-01f, 8.59044790e-01f, -8.22654188e-01f, 6.56680942e-01f, -1.08316272e-01f, -2.34232366e-01f, 2.70792723e-01f, 1.42657012e-01f, -2.17937827e-01f,
  1.46817937e-01f, 4.54056054e-01f, -4.47920144e-01f, 2.24644363e-01f, 4.91728872e-01f, -3.11319977e-01f, -2.51698434e-01f, -4.24320161e-01f, 1.28366917e-01f, -1.07336067e-01f,
  -1.97074153e-02f, -2.61410385e-01f, 6.51091754e-01f, 3.97211015e-02f, 6.96113467e-01f, 1.62466958e-01f, 6.42621577e-01f, 4.51257497e-01f, 4.83053654e-01f, 1.76634290e-03f,
  -2.43982702e-01f, 2.39821675e-04f, 3.13095190e-02f, -9.69564915e-02f, -7.69844353e-01f, 2.52123356e-01f, 1.08055329e+00f, 8.25283229e-01f, 8.11498106e-01f, 6.15952611e-01f,
  1.51524350e-01f, 9.73749459e-01f, 1.52729213e-01f, 3.19763161e-02f, 3.18292856e-01f, 4.84823763e-01f, 4.29597378e-01f, 7.06308335e-02f, -3.76207292e-01f, 1.05060303e+00f,
  -4.61060554e-01f, 5.02452910e-01f, -1.86399296e-01f, 3.14123154e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  6.31836593e-01f, 3.08802336e-01f, 4.04801130e-01f, 4.24592733e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -7.94189095e-01f, -3.38371605e-01f, -5.26742041e-01f, -5.35266660e-02f, -9.93414298e-02f, -3.88290584e-01f, 3.24473809e-03f, -1.21464439e-01f, -5.49326777e-01f, -6.07496321e-01f,
  1.12680614e+00f, 2.91161180e-01f, -1.07643818e-02f, 2.66891748e-01f, 7.92926773e-02f, -1.17022000e-01f, 1.33494809e-01f, 2.11410969e-01f, -3.10421586e-01f, 2.84455687e-01f,
  -1.23352163e-01f, 2.56626546e-01f, -3.64495784e-01f, -4.65762913e-01f, -6.58788204e-01f, -4.29277807e-01f, 8.08219135e-01f, -5.51724315e-01f, -1.24520473e-01f, 2.91640490e-01f,
  1.57745227e-01f, 2.15279777e-02f, 7.87202418e-01f, 2.69897103e-01f, -7.82304108e-02f, -3.73213626e-02f, 1.95246518e-01f, 5.92293203e-01f, 2.67610937e-01f, -5.84513485e-01f,
  -3.80445302e-01f, -1.33090004e-01f, -3.58687580e-01f, -4.86515224e-01f, 3.29546928e-01f, 1.53203070e-01f, -3.35904092e-01f, 5.80372214e-02f, -9.25656408e-02f, 2.38460049e-01f,
  -5.88648140e-01f, 4.01591390e-01f, 2.45324522e-01f, -4.69363660e-01f, -2.30772451e-01f, -8.52460384e-01f, -4.84645396e-01f, -5.90714335e-01f, -1.24905147e-01f, -3.58871728e-01f,
  3.55098665e-01f, 1.55231124e-02f, -2.46115640e-01f, -9.62114930e-02f, 1.90538511e-01f, 2.63512284e-01f, 1.19241871e-01f, -9.85703915e-02f, -2.24867567e-01f, 7.88486779e-01f,
  1.60281137e-01f, 1.56388208e-01f, 1.05024469e+00f, -9.92374718e-02f, -1.05872059e+00f, -1.37196049e-01f, -1.65646777e-01f, -4.00067508e-01f, -1.70026615e-01f, 4.76519614e-01f,
  -6.55923665e-01f, -4.31800157e-01f, -5.54479182e-01f, 1.51211828e-01f, -1.63631052e-01f, -6.64366841e-01f, -4.51088190e-01f, 3.47598851e-01f, -2.17372596e-01f, 7.10190058e-01f,
  7.56502673e-02f, 5.56145847e-01f, 1.90693960e-01f, -2.69874722e-01f, 3.33440840e-01f, -4.73982543e-01f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  5.00086606e-01f, 6.03400707e-01f, 1.16402498e-02f, 9.12785947e-01f, 1.08445537e+00f, -2.29324222e-01f, 1.10184610e+00f, -1.21426463e+00f, 5.58233559e-01f, 1.08297877e-02f,
  8.22561145e-01f, -1.13693833e+00f, 9.70916629e-01f, -1.07646408e-02f, -3.96879375e-01f, 5.03397822e-01f, -4.02463704e-01f, -6.33529007e-01f, 8.36378574e-01f, -1.29330730e+00f,
  3.93010885e-01f, 1.44533485e-01f, -1.36140859e+00f, 5.36854267e-01f, 2.14305758e-01f, 7.92062640e-01f, -3.57491046e-01f, 1.33336616e+00f, 8.53772521e-01f, -1.03414345e+00f,
  4.84692574e-01f, -8.53738606e-01f, 1.24654412e+00f, 7.48492181e-01f, 6.67367458e-01f, 6.60190046e-01f, 3.90995443e-02f, 9.25133109e-01f, -5.46744049e-01f, -3.25119108e-01f,
  7.47034490e-01f, 6.84222519e-01f, -4.12095457e-01f, -3.12763080e-03f, 1.02049088e+00f, 4.64049250e-01f, 3.86294037e-01f, -3.96144480e-01f, 6.72279596e-01f, -3.01331967e-01f,
  -3.78344446e-01f, 3.93378407e-01f, 4.35001224e-01f, -2.72704586e-02f, 5.16008973e-01f, 8.91812921e-01f, 7.81254709e-01f, 7.68541455e-01f, -5.01833260e-01f, 1.55446187e-01f,
  -3.40094984e-01f, -8.43221605e-01f, 1.35492110e+00f, 9.85994399e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  7.74231970e-01f, 1.49911763e-02f, 3.18648994e-01f, 1.01263374e-02f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  2.90468901e-01f, -1.66222349e-01f, -6.30886555e-01f, -5.06577611e-01f, -5.74887730e-02f, 1.47173330e-01f, 3.71655285e-01f, 6.48512542e-01f, 1.05456542e-03f, -2.79645175e-01f,
  1.21969573e-01f, -2.60680597e-02f, -9.96142745e-01f, -1.09628725e+00f, -1.16672146e+00f, 6.28346682e-01f, 1.18953192e+00f, -1.09829038e-01f, 2.62571096e-01f, 3.52264017e-01f,
  -1.25452697e+00f, -7.77434111e-01f, -2.58815974e-01f, 3.24680030e-01f, 2.26871386e-01f, -8.83128494e-02f, 1.62833571e-01f, 1.11141658e+00f, 2.19838083e-01f, -4.81343031e-01f,
  -1.85911512e+00f, 2.40410924e-01f, -1.13328290e+00f, 6.56131208e-01f, 5.41285336e-01f, 3.84592026e-01f, -1.10951805e+00f, -3.00804585e-01f, 7.69313872e-01f, -2.84276873e-01f,
  6.54307842e-01f, -7.05192029e-01f, -6.33593261e-01f, -1.01521766e+00f, -3.97868067e-01f, -9.94204700e-01f, 8.84645954e-02f, 1.98038444e-01f, 3.65908176e-01f, 3.11726741e-02f,
  1.62597120e-01f, 4.88706559e-01f, 2.66657751e-02f, -2.60608286e-01f, 5.80236971e-01f, 4.92815822e-01f, -6.07221365e-01f, -1.15167034e+00f, -1.27826583e+00f, -5.33197150e-02f,
  -1.66419137e+00f, 4.73666310e-01f, 4.11866397e-01f, -1.45595998e-01f, -4.61066395e-01f, 4.28046793e-01f, 2.80489832e-01f, -1.10862327e+00f, 1.78625613e-01f, -1.22666530e-01f,
  -1.52878749e+00f, -1.15122342e+00f, -6.64021194e-01f, 2.10752711e-01f, 1.44521296e+00f, 7.03666508e-01f, -8.40977669e-01f, -1.88512996e-01f, 7.86877275e-02f, 3.27247053e-01f,
  -4.74767268e-01f, -1.34334430e-01f, 5.89034975e-01f, 2.88928121e-01f, 1.58766723e+00f, 1.06834486e-01f, 9.83255565e-01f, 4.34758842e-01f, -6.34231687e-01f, 5.71019471e-01f,
  8.68261635e-01f, -1.36953557e+00f, 3.24942738e-01f, -5.69303572e-01f, -8.25220764e-01f, 1.25981942e-01f, -5.34956217e-01f, 7.49442101e-01f, -6.25842735e-02f, -1.26252338e-01f,
  8.72200429e-01f, 3.60011578e-01f, -6.08112574e-01f, -3.44393626e-02f, -1.04689455e+00f, 7.64173627e-01f, -4.87871677e-01f, 7.57298172e-01f, 2.54692167e-01f, 3.27126205e-01f,
  3.49906355e-01f, -1.43934453e+00f, 1.48867726e+00f, -6.42970279e-02f, 9.53769311e-02f, -9.85742286e-02f, -8.07115972e-01f, -8.58823776e-01f, 1.34697378e-01f, -4.91510779e-01f,
  5.55665731e-01f, 5.27489662e-01f, -1.12827890e-01f, -1.86005518e-01f, -2.27472454e-01f, 7.90751338e-01f, 1.57474771e-01f, -9.03304219e-01f, -2.58379430e-01f, -2.80883789e-01f,
  -6.06169514e-02f, -7.29894757e-01f, 8.48864764e-02f, -2.83488959e-01f, 7.43202686e-01f, 7.06015468e-01f, 1.26342821e+00f, 8.68525326e-01f, -1.91657352e+00f, -9.16302323e-01f,
  7.24782288e-01f, -5.79319894e-01f, -1.20385420e+00f, -1.27592635e+00f, -9.80242491e-01f, -6.90604448e-01f, -1.55145779e-01f, 8.74700785e-01f, 3.79761338e-01f, -4.22870070e-01f,
  2.10949540e-01f, -8.40147436e-01f, 1.16276777e+00f, -2.78909832e-01f, 6.70370460e-01f, 1.35669363e+00f, -2.71812588e-01f, 2.40989134e-01f, 4.63674545e-01f, -3.87307435e-01f,
  -1.12790716e+00f, 8.26195478e-01f, -1.30057502e+00f, -9.71077025e-01f, 4.10940707e-01f, 6.69257164e-01f, -1.74890053e+00f, -2.80296385e-01f, 3.20699662e-01f, 5.94545484e-01f,
  9.42523003e-01f, -8.06178093e-01f, 3.46202672e-01f, -1.03220832e+00f, 7.88521543e-02f, -3.14451665e-01f, 8.60541403e-01f, -1.40531051e+00f, -4.95722979e-01f, -4.51608181e-01f,
  -6.20757580e-01f, 7.58495033e-01f, 1.27187952e-01f, 6.82286263e-01f, -4.94216084e-01f, -1.05950606e+00f, -2.89009303e-01f, 4.95211154e-01f, 4.03338343e-01f, -7.33520389e-01f,
  3.06128711e-01f, -9.56671417e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.94326922e-01f, 3.21664751e-01f, -3.24019343e-01f, -6.11984670e-01f, -8.47036112e-03f, -3.45658988e-01f, -1.17278859e-01f, 2.82375634e-01f, 6.31366611e-01f, -1.64268628e-01f,
  -7.42194951e-01f, 1.84333269e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    