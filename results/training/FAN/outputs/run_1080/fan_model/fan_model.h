/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.29507497e-01f, -2.39743486e-01f, 7.62093207e-03f, -3.48946936e-02f, -3.78669947e-02f, -9.33818705e-03f, -1.41872659e-01f, -6.01155348e-02f, 4.54252474e-02f, -1.60578057e-01f,
  -3.53623647e-03f, 6.20934553e-03f, 5.11653237e-02f, 1.76590815e-01f, 6.74917772e-02f, -1.85816303e-01f, -1.47504434e-01f, 2.04770435e-02f, 1.10439025e-01f, 1.01284772e-01f,
  -4.11346816e-02f, -4.33368003e-03f, -4.94704908e-03f, 1.14939027e-01f, -3.75307538e-02f, -6.35324717e-02f, -2.46036202e-02f, 1.16855390e-02f, 2.89582275e-02f, -1.28605768e-01f,
  2.58593028e-03f, 2.21462138e-02f, 1.16994627e-01f, 8.92203227e-02f, 9.01219249e-02f, 2.92010810e-02f, 1.39990926e-01f, 6.51597381e-02f, 9.22629088e-02f, 1.03064157e-01f,
  1.32631317e-01f, 1.54610172e-01f, 5.31792529e-02f, 6.58784136e-02f, 1.96361430e-02f, -2.61940004e-04f, 1.02076650e-01f, -1.33063681e-02f, 1.56896815e-01f, 1.23916261e-01f,
  -1.18586868e-02f, 1.20154418e-01f, 1.11124374e-01f, 1.48628801e-01f, 2.03589499e-01f, 9.22640115e-02f, 8.16421211e-02f, 1.52189210e-01f, 2.18746051e-01f, -3.27779539e-02f,
  9.65386480e-02f, -2.79650949e-02f, -1.36239249e-02f, -1.06065664e-02f, -1.26186550e-01f, -5.57226501e-02f, -9.80610773e-02f, -8.58646333e-02f, -4.24300916e-02f, 1.14404373e-02f,
  -6.67289644e-02f, -1.80739742e-02f, 3.90205607e-02f, -1.40067294e-01f, -3.15543078e-02f, -8.34664181e-02f, 2.16807816e-02f, -7.81680644e-02f, 5.19670770e-02f, -7.30992556e-02f,
  -4.96654995e-02f, -8.27918872e-02f, -9.35048833e-02f, -8.33283365e-02f, 3.60368565e-03f, 5.72544597e-02f, -1.12240911e-01f, 9.08078998e-02f, -6.72493950e-02f, -9.24076587e-02f,
  -2.11852025e-02f, 2.82302618e-01f, -7.73687940e-03f, 4.60870117e-02f, 1.39613107e-01f, 2.12703958e-01f, 7.06413835e-02f, 7.37011805e-02f, 9.82851461e-02f, 8.09963197e-02f,
  -6.76201144e-03f, 2.69698091e-02f, 1.37641862e-01f, 1.45871982e-01f, -4.47686901e-03f, 1.29901126e-01f, 9.12926197e-02f, 4.12798859e-02f, 1.20558836e-01f, 3.93300280e-02f,
  -1.01505464e-03f, -1.56637914e-02f, -3.60791683e-02f, -5.98270074e-02f, 6.21624775e-02f, 3.15781347e-02f, -1.10377215e-01f, 4.64769155e-02f, 5.16011901e-02f, -1.07714556e-01f,
  -3.03022146e-01f, 3.20213974e-01f, 7.67945349e-02f, 1.22804366e-01f, 2.63869405e-01f, 6.92337155e-02f, 9.07774568e-02f, -1.23550273e-01f, 3.05290390e-02f, 9.30476561e-02f,
  4.97206561e-02f, -2.10780442e-01f, -7.51935914e-02f, -1.41913235e-01f, -2.26707056e-01f, 1.52409419e-01f, 1.64530456e-01f, -1.51033610e-01f, -2.54203975e-01f, -3.66992280e-02f,
  1.73120771e-03f, -1.42243579e-02f, -1.20679773e-01f, -7.78084248e-02f, 2.25502118e-01f, 3.64772812e-03f, 1.40860751e-01f, 1.47281945e-01f, 1.50296032e-01f, 2.95990556e-01f,
  -8.24380964e-02f, 1.40915766e-01f, -1.04562655e-01f, 6.75637722e-02f, 2.74229739e-02f, -5.15313298e-02f, 7.03385025e-02f, -1.34660434e-02f, 2.36499775e-03f, 3.53180356e-02f,
  9.13658142e-02f, 5.53343855e-02f, 6.11839257e-02f, 6.00416400e-03f, -2.32331473e-02f, -3.74071486e-02f, 3.42563204e-02f, -8.86786878e-02f, 7.14889839e-02f, 4.33033518e-02f,
  1.61776051e-01f, 1.32525831e-01f, 1.08250521e-01f, 2.50491090e-02f, -3.28454711e-02f, -2.86397953e-02f, -1.77471619e-02f, 1.19889397e-02f, 3.63339148e-02f, 1.46566287e-01f,
  -2.86769904e-02f, -3.95142511e-02f, -7.39940442e-05f, -1.27870724e-01f, -2.27543209e-02f, -4.48226593e-02f, 2.15962846e-02f, -5.33598587e-02f, -1.12129763e-01f, 1.99900083e-02f,
  -5.21690659e-02f, -2.84636728e-02f, -4.52436432e-02f, 5.01293652e-02f, 2.72596115e-03f, -3.34008262e-02f, 2.93473643e-03f, -1.58549268e-02f, -4.52338047e-02f, -4.22560424e-02f,
  -8.84531438e-02f, 1.16044446e-03f, 1.50281452e-02f, -5.35067990e-02f, 5.89912049e-02f, -1.42277390e-01f, -9.50895995e-03f, -1.31909326e-01f, -2.07469705e-02f, -1.60083603e-02f,
  -3.07845082e-02f, -1.43669024e-02f, 6.22700853e-03f, -5.00395633e-02f, 5.50632663e-02f, -2.06538662e-02f, -1.23356674e-02f, 3.98357809e-02f, -2.35209148e-02f, -5.38579002e-02f,
  1.09616825e-02f, -5.74307516e-02f, 5.84372021e-02f, 5.64565472e-02f, -4.27762941e-02f, 6.93258345e-02f, -4.55873944e-02f, 2.36173980e-02f, -2.53826729e-03f, 1.34288251e-01f,
  9.87073313e-03f, 8.28513652e-02f, -1.05282627e-01f, 8.37450195e-03f, 4.16110195e-02f, -4.03944664e-02f, -3.88825632e-04f, -8.61144960e-02f, -8.88357908e-02f, -1.01929218e-01f,
  4.41674978e-01f, 1.11607268e-01f, 3.46513502e-02f, 8.72588977e-02f, -2.29896456e-01f, -1.03050925e-01f, -5.23299053e-02f, 1.22353949e-01f, 1.60415828e-01f, -3.89922597e-02f,
  8.35848749e-02f, -3.76038365e-02f, 1.40670121e-01f, 2.93612424e-02f, 1.99608281e-01f, 1.48508642e-02f, -1.19172685e-01f, 1.29476950e-01f, 9.46587548e-02f, 3.14902067e-02f,
  -1.36647180e-01f, 1.01387188e-01f, 1.88162506e-01f, -3.94103192e-02f, -4.38954532e-02f, -8.30892995e-02f, -5.55750951e-02f, 4.81620096e-02f, -3.62257473e-02f, -6.05750047e-02f,
  1.10838503e-01f, 2.83474267e-01f, 3.38049345e-02f, 8.24031308e-02f, -1.91458408e-02f, 4.60428745e-02f, 1.20335512e-01f, 1.48580089e-01f, 1.75604165e-01f, 1.39065668e-01f,
  6.45968616e-02f, 1.79543599e-01f, 1.28866762e-01f, 1.10148983e-02f, 2.86759250e-02f, 1.30915880e-01f, 9.20122564e-02f, 1.11029781e-01f, 9.58283469e-02f, 1.45780891e-01f,
  4.94486019e-02f, -3.94284427e-02f, 1.31754845e-01f, 1.04355000e-01f, 1.06151432e-01f, 1.43653657e-02f, 1.22711509e-01f, 1.17761575e-01f, 5.70346564e-02f, 2.06121653e-01f,
  5.10644726e-02f, -8.48188400e-02f, -5.30810803e-02f, -7.46119320e-02f, 2.61743013e-02f, -4.18807827e-02f, -8.30230191e-02f, -1.13349207e-01f, -2.31495630e-02f, -2.81427838e-02f,
  1.43142622e-02f, -8.68764073e-02f, -1.87111143e-02f, -7.07873479e-02f, -9.98473391e-02f, -6.02836162e-02f, -6.75003603e-02f, -4.35276739e-02f, -2.05470305e-02f, 1.17671499e-02f,
  3.81707810e-02f, 3.82416546e-02f, 3.38749290e-02f, -4.22392320e-03f, -4.25423160e-02f, -8.64576027e-02f, -7.07307458e-02f, -1.09755643e-01f, -3.42520364e-02f, -2.48580743e-02f,
  1.57518774e-01f, 1.43133253e-01f, 5.66622168e-02f, 1.82519302e-01f, 4.73910570e-02f, 1.18494496e-01f, 1.48604512e-01f, 6.26557171e-02f, -4.42964397e-03f, 9.72890928e-02f,
  1.26611918e-01f, 8.83295685e-02f, 1.47800848e-01f, 6.57942519e-02f, 8.64330456e-02f, 1.42544791e-01f, 9.34123769e-02f, 7.07121566e-02f, 1.29828140e-01f, 9.56690982e-02f,
  1.57031730e-01f, 1.61624566e-01f, 1.63487747e-01f, 1.34229049e-01f, 8.35588574e-02f, 1.72757268e-01f, 4.95372107e-03f, 6.05302453e-02f, 2.15003058e-01f, 1.93522364e-01f,
  1.94551721e-01f, -2.59216577e-01f, 3.57681923e-02f, 5.44759110e-02f, 6.90304786e-02f, -6.45848215e-02f, -1.74431592e-01f, -1.34283870e-01f, 2.26759035e-02f, -4.52108942e-02f,
  -1.62029192e-01f, 8.21218342e-02f, 4.41509150e-02f, 2.42154766e-02f, -6.89413622e-02f, -6.08731695e-02f, 1.01325154e-01f, 1.03940584e-01f, 1.38619110e-01f, 4.73892801e-02f,
  -2.94467490e-02f, 4.47541364e-02f, 3.02032530e-02f, -1.04652725e-01f, -1.11300357e-01f, -5.75173460e-02f, -1.81607589e-01f, -1.26987353e-01f, -1.41433686e-01f, 4.36785594e-02f,
  1.39442999e-02f, -1.73016995e-01f, -5.40263299e-03f, -8.32118466e-02f, -1.48572037e-02f, -6.26849383e-02f, 2.02124622e-02f, -5.81398383e-02f, -8.03804696e-02f, -1.08220093e-01f,
  -7.51882493e-02f, -5.75813986e-02f, -3.59123424e-02f, -1.33757725e-01f, -9.54918489e-02f, -1.38970867e-01f, -7.44674504e-02f, -1.48375645e-01f, -9.97777730e-02f, -1.63938448e-01f,
  -2.84017529e-02f, -7.63686225e-02f, 1.37600666e-02f, -1.57942280e-01f, -7.93512240e-02f, -7.88669586e-02f, -1.58522934e-01f, -1.28738418e-01f, -1.79834634e-01f, -3.53289023e-02f,
  -1.07211936e-02f, -1.01770945e-01f, -1.66623853e-02f, 4.97740554e-03f, -4.84379567e-02f, -8.67488887e-03f, 2.22904682e-02f, -2.44316049e-02f, -1.01610804e-02f, -3.05450261e-02f,
  9.14690644e-03f, -7.13487342e-02f, -1.38110034e-02f, -4.11369093e-03f, -3.46703678e-02f, -1.08522847e-01f, 4.87597920e-02f, -1.51101500e-02f, 9.81781818e-03f, 9.58126131e-03f,
  3.48886847e-02f, -4.96885329e-02f, 2.19007046e-03f, 8.44953060e-02f, -6.70432374e-02f, -1.00197196e-02f, 4.31808177e-03f, -3.42799611e-02f, 7.30090123e-03f, -1.93705596e-02f,
  6.03883192e-02f, -9.03393403e-02f, 2.62204614e-02f, 3.99121605e-02f, 2.64634341e-02f, -2.33113002e-02f, -2.44548563e-02f, -8.57882947e-02f, -2.89981198e-02f, -8.31208937e-03f,
  -4.33835164e-02f, -7.04899803e-02f, -3.64169702e-02f, 9.78527963e-03f, 5.92890847e-03f, -8.32266267e-03f, -9.89956334e-02f, 5.64290434e-02f, -2.74229888e-02f, -2.07505599e-02f,
  -1.16682343e-01f, -1.03259552e-02f, 4.98433672e-02f, -9.95279923e-02f, -1.10247791e-01f, 3.50375883e-02f, 5.83762303e-03f, -1.36230052e-01f, -7.83897936e-02f, -1.06503172e-02f,
  -1.33535624e-01f, 9.15315300e-02f, -2.26811424e-01f, 6.91781044e-02f, 1.34188756e-01f, 8.89521316e-02f, 1.83968008e-01f, 1.04837835e-01f, 1.13145076e-01f, 6.58633709e-02f,
  6.06510788e-02f, 5.69941774e-02f, -4.67004022e-03f, -3.97319645e-02f, 4.83542308e-02f, 6.98123425e-02f, -2.31231023e-02f, -8.79263058e-02f, 1.05182128e-02f, 9.82671306e-02f,
  1.42494544e-01f, 1.40828729e-01f, 1.23719826e-01f, 6.54809996e-02f, 1.86651886e-01f, 7.91123137e-02f, 9.79924649e-02f, -1.59477293e-02f, 9.14645493e-02f, 1.05016701e-01f,
  -2.73555279e-01f, -1.77176476e-01f, 2.57080304e-03f, 1.23392731e-01f, -1.33500442e-01f, 2.17900220e-02f, 2.97697373e-02f, -9.22013167e-03f, -8.65512341e-03f, 4.68696952e-02f,
  9.21999756e-03f, 1.89709645e-02f, -6.23385236e-03f, 1.13925271e-01f, -2.60746982e-02f, 4.45881374e-02f, -1.23583172e-02f, -1.58324823e-01f, 4.52728855e-04f, -4.38308157e-02f,
  5.23955524e-02f, -2.92297769e-02f, -1.54838100e-01f, 1.85644105e-02f, -2.89065507e-03f, -3.21684182e-02f, -7.89399967e-02f, -2.18237247e-02f, -6.21131174e-02f, -6.34901598e-02f,
  1.20092988e-01f, -6.12414926e-02f, -9.90132615e-02f, -6.08360060e-02f, -6.89924322e-03f, -7.87293464e-02f, -8.92337784e-02f, -3.24819684e-02f, -8.49436224e-02f, 6.15799874e-02f,
  -3.45810950e-02f, -5.30424938e-02f, -4.52983044e-02f, -1.52936215e-02f, 3.47351469e-02f, -8.55289400e-02f, 5.34126088e-02f, -4.08197939e-02f, -8.59048739e-02f, 2.28132382e-02f,
  -1.02360398e-01f, -9.39143896e-02f, -3.88242975e-02f, -6.03900179e-02f, -9.88313407e-02f, -1.11193530e-01f, -8.30625594e-02f, 6.02517799e-02f, -7.46308789e-02f, -1.94332711e-02f,
  8.29125643e-02f, -6.89721107e-02f, 8.44814479e-02f, 4.77237552e-02f, -1.05237350e-01f, 3.33092026e-02f, -5.36222989e-03f, -7.73673952e-02f, 1.93077251e-02f, -7.65541866e-02f,
  -8.39606076e-02f, -8.48829821e-02f, 2.25736387e-02f, 6.98136240e-02f, -1.47345634e-02f, 2.69165207e-02f, 6.35801777e-02f, 1.35853076e-02f, 6.86654076e-02f, -2.45009083e-03f,
  1.20781906e-01f, 7.85267055e-02f, 4.06679809e-02f, 6.26252592e-02f, 1.48465931e-02f, 5.15264049e-02f, 7.90837556e-02f, -2.99166236e-03f, 6.75888732e-02f, 2.31700808e-01f,
  9.21350047e-02f, 3.31744164e-01f, 7.90890753e-02f, 2.69904286e-01f, 1.79903895e-01f, -2.32757833e-02f, 6.75149262e-02f, -6.34737313e-02f, 1.23021565e-01f, 1.14150725e-01f,
  1.79788291e-01f, -4.93459851e-02f, 1.76622868e-02f, -2.47282325e-04f, -3.48636135e-02f, 3.14954594e-02f, 3.61771993e-02f, -1.28574520e-01f, -1.30878747e-01f, -1.16880506e-01f,
  -5.58203943e-02f, 2.19984725e-02f, 3.47335227e-02f, -3.11798044e-02f, 1.84943914e-01f, 3.91055793e-02f, 1.07840471e-01f, 2.37227321e-01f, 1.93240196e-01f, 3.28693718e-01f,
  1.26184240e-01f, 2.78904438e-01f, -6.80486262e-02f, 8.25792849e-02f, 1.73160374e-01f, -1.02579407e-02f, 1.31427482e-01f, 1.00344680e-01f, 1.29494369e-01f, 2.23942958e-02f,
  1.78781331e-01f, 8.34828988e-02f, 1.92382708e-01f, 1.04571357e-01f, 7.86724314e-02f, 2.67658918e-03f, 3.58295180e-02f, -2.39531347e-03f, 3.13575305e-02f, 9.80146378e-02f,
  7.14431703e-02f, 1.67405978e-01f, 4.74751629e-02f, 8.81494358e-02f, 9.68280807e-03f, 1.14199303e-01f, 1.60481676e-01f, 2.54083108e-02f, 2.47381739e-02f, 2.12056160e-01f,
  -6.88520297e-02f, -6.31952137e-02f, -1.36654764e-01f, -1.40199244e-01f, -1.65951744e-01f, -9.15506184e-02f, -1.24468245e-01f, -1.08976722e-01f, -1.49505153e-01f, -1.22176446e-01f,
  -8.14292729e-02f, -1.23909347e-01f, -1.32047847e-01f, -1.42859623e-01f, -1.12050466e-01f, -1.22014850e-01f, -1.61236987e-01f, -1.47435367e-01f, -9.55978855e-02f, -5.52253276e-02f,
  -1.38475597e-01f, -1.05781347e-01f, -9.45608318e-02f, -1.74492210e-01f, -5.19954860e-02f, -1.38344109e-01f, -8.24193060e-02f, -2.13058710e-01f, -1.13018095e-01f, -5.89018948e-02f,
  4.53719236e-02f, 1.21725630e-02f, 4.46189642e-02f, 1.32606193e-01f, 8.29779431e-02f, 7.67277628e-02f, 3.32734957e-02f, 2.02693604e-02f, 1.51360512e-01f, 8.03043097e-02f,
  1.04406558e-01f, -7.28075877e-02f, 1.16082475e-01f, -2.59997025e-02f, 9.05786753e-02f, 3.52069847e-02f, 1.37941256e-01f, 1.11571938e-01f, 5.42618781e-02f, 1.75114304e-01f,
  6.93413243e-02f, -5.27304709e-02f, -3.81736755e-02f, 1.22599781e-01f, 1.02073736e-01f, -1.03712857e-01f, -3.97399999e-02f, -3.74490558e-03f, -6.21893145e-02f, 1.38948811e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.47071178e-02f, -1.94903895e-01f, -1.89033657e-01f, 1.67403817e-01f, -2.56185710e-01f, -2.18623519e-01f, -3.33552301e-01f, -1.00010425e-01f, 1.84920728e-01f, -5.09292968e-02f,
  -1.04856230e-02f, -7.33286282e-03f, -7.32228765e-03f, -1.50032908e-01f, -2.50438750e-01f, -3.18745635e-02f, -5.40901795e-02f, -1.58831373e-01f, -2.49195054e-01f, -2.37679109e-01f,
  -1.38169125e-01f, -2.52870172e-02f, 6.35036379e-02f, 5.30246980e-02f, 2.00278074e-01f, 4.13367637e-02f, 8.67242441e-02f, -1.08588018e-01f, -2.36356989e-01f, -4.00088765e-02f,
  4.30856906e-02f, -8.50648731e-02f, -1.08377330e-01f, -1.06957018e-01f, 3.39656621e-02f, -3.16000357e-02f, -1.12337470e-01f, -1.16284974e-02f, 1.08502999e-01f, 3.37537415e-02f,
  -1.57633990e-01f, -1.54392585e-01f, -4.58071828e-02f, -1.19892433e-01f, 1.24603733e-02f, -1.39147446e-01f, -6.58147559e-02f, -7.44090378e-02f, -1.05255008e-01f, 4.62997071e-02f,
  -1.44124264e-02f, -1.50696084e-01f, -1.12957992e-02f, 6.36279583e-02f, -3.41399498e-02f, 3.83901261e-02f, 3.55363302e-02f, 3.52925174e-02f, 1.27055775e-02f, 9.14357528e-02f,
  7.34514818e-02f, 1.17515050e-01f, 1.25294417e-01f, 1.66190386e-01f, 1.41389415e-01f, 1.28572956e-01f, 1.78130955e-01f, 1.98306456e-01f, 1.44073116e-02f, 1.23132862e-01f,
  -4.76021990e-02f, 1.18913101e-02f, -9.06495377e-04f, 7.10212253e-03f, -1.64264273e-02f, -1.45627903e-02f, -4.13043313e-02f, -7.98716694e-02f, -9.04166251e-02f, 4.03787792e-02f,
  -2.30162013e-02f, 9.15767848e-02f, 1.47470161e-02f, 3.28956880e-02f, -8.65625665e-02f, -1.89070795e-02f, -6.47309348e-02f, -4.39599827e-02f, -1.61413208e-01f, -2.19955817e-01f,
  3.16978723e-01f, -4.11250025e-01f, 1.78915024e-01f, 6.44237697e-02f, -6.34899288e-02f, -3.33454236e-02f, 1.42320499e-01f, 3.24281901e-02f, 3.52289043e-02f, -4.53068540e-02f,
  -2.32071534e-01f, 7.33350292e-02f, 9.97273996e-02f, -6.71809316e-02f, 9.60619003e-02f, 7.38944858e-03f, -1.54079691e-01f, 9.72167328e-02f, 2.23598927e-02f, 2.26250826e-03f,
  5.01922332e-02f, 1.84241787e-01f, 1.50157481e-01f, 9.99636054e-02f, 1.96368936e-02f, 9.48174372e-02f, 3.87609005e-02f, 1.09625943e-01f, 1.00049183e-01f, 2.16180548e-01f,
  -3.79816419e-03f, -1.04298748e-01f, 5.72872683e-02f, 1.93498760e-01f, 1.25880763e-01f, -1.63208112e-01f, -3.35881382e-01f, -2.76920289e-01f, 1.56231210e-01f, 1.68227907e-02f,
  3.42241414e-02f, 2.38118321e-01f, 1.63026884e-01f, 1.62447646e-01f, 6.27140142e-03f, -3.27569619e-02f, 1.02528475e-01f, 1.28682777e-01f, 1.23895012e-01f, 8.29664022e-02f,
  1.73132062e-01f, 1.17774025e-01f, 1.09163985e-01f, -1.20181758e-02f, 1.72281921e-01f, 2.48473912e-01f, -2.19982229e-02f, 1.82035953e-01f, 1.43793315e-01f, 3.03696394e-01f,
  1.60272971e-01f, -1.40183493e-02f, 1.17276065e-01f, 3.38583849e-02f, 6.35077879e-02f, -1.74154621e-02f, 1.58395454e-01f, -1.38017043e-01f, -1.25834465e-01f, -1.33998334e-01f,
  9.10527185e-02f, 3.78421284e-02f, 3.13264951e-02f, -8.97470303e-03f, 2.68658157e-02f, 3.22279595e-02f, -5.72612844e-02f, -2.26632267e-01f, -1.07278854e-01f, -8.96463022e-02f,
  1.13511823e-01f, 3.87081616e-02f, -3.26509252e-02f, -2.33270720e-01f, -1.45227209e-01f, 7.57037401e-02f, -9.27147567e-02f, -3.09042092e-02f, -2.89173448e-03f, 1.02370642e-01f,
  -4.18934077e-02f, 1.24640457e-01f, 1.38667658e-01f, 1.14720412e-01f, 1.55745342e-01f, 7.11427405e-02f, 8.43675286e-02f, 1.48854733e-01f, 1.36222079e-01f, -6.53291047e-02f,
  1.09530903e-01f, 1.74513265e-01f, 1.36530073e-02f, -9.32087600e-02f, 3.31000760e-02f, 1.51948303e-01f, 5.01537435e-02f, 1.19993523e-01f, -6.44753873e-02f, 1.27031237e-01f,
  4.63913754e-03f, 3.63229290e-02f, 1.47676811e-01f, 6.83447421e-02f, -9.20397509e-03f, 1.99759658e-02f, 9.63119417e-02f, 1.60286978e-01f, 8.36292431e-02f, 8.81868601e-02f,
  1.98503435e-01f, -2.09335685e-01f, 7.37020299e-02f, -6.93783015e-02f, 5.67127997e-03f, 8.51708055e-02f, 1.24676876e-01f, -3.79712209e-02f, 7.60329068e-02f, -1.19514756e-01f,
  6.75392896e-03f, -5.30951321e-02f, -1.31361214e-02f, -1.04673751e-01f, -1.06388284e-02f, 4.81144190e-02f, 3.77379246e-02f, 9.25795920e-03f, -4.84920898e-03f, -4.40953709e-02f,
  1.17113143e-02f, -3.55741717e-02f, -9.18290839e-02f, -1.66298181e-01f, 3.36727314e-02f, -2.47801226e-02f, -6.06294908e-02f, 5.01469560e-02f, -1.32354870e-01f, -1.11827038e-01f,
  -1.62040144e-01f, -4.30491537e-01f, 2.99309909e-01f, 1.12614758e-01f, 1.64390355e-02f, -4.85613011e-02f, -2.63598114e-01f, -8.13184530e-02f, -3.63967428e-03f, -1.79425050e-02f,
  -3.42070162e-02f, 1.65084116e-02f, 9.09106210e-02f, 2.64715642e-01f, 1.78561553e-01f, 1.83041245e-02f, 2.16741636e-01f, 3.32624465e-01f, 2.95911402e-01f, 7.93705881e-02f,
  4.19792309e-02f, 1.43339977e-01f, 1.90762445e-01f, 2.54137188e-01f, -3.57476249e-02f, 2.06394613e-01f, 1.12933718e-01f, 7.88997561e-02f, -2.61737994e-04f, 6.69170544e-02f,
  -9.31304842e-02f, -2.47209266e-01f, 1.92816928e-01f, 2.48767547e-02f, 9.16827172e-02f, -5.23199961e-02f, -8.17603767e-02f, -3.18261757e-02f, -3.13320160e-02f, -6.27639890e-02f,
  9.27594025e-03f, -1.53603911e-01f, -5.88793121e-02f, -9.74118561e-02f, -1.04429528e-01f, -1.40114784e-01f, -1.02894872e-01f, 1.32223457e-01f, 6.06938303e-02f, -1.18179165e-01f,
  -1.17103614e-01f, -4.24000211e-02f, -1.05178021e-01f, -3.41389254e-02f, -1.13048665e-01f, 1.28867149e-01f, -6.43410757e-02f, -9.22783390e-02f, -1.20957932e-02f, -1.42418221e-01f,
  -9.09331068e-03f, -2.12288741e-03f, -6.50390759e-02f, -8.13016295e-02f, -2.80043744e-02f, -2.29062233e-02f, 9.82504711e-02f, 3.47125903e-02f, 1.32123634e-01f, 2.90562101e-02f,
  -1.03336582e-02f, 3.11184544e-02f, 4.12258320e-02f, -2.11670231e-02f, 7.93918520e-02f, -6.57597706e-02f, -3.75873991e-03f, -1.06054761e-01f, 7.41697848e-02f, 5.62647954e-02f,
  -3.06902397e-02f, 9.83264204e-03f, 1.15174279e-02f, 7.53114969e-02f, -1.40164990e-03f, 1.09984659e-01f, 1.02704339e-01f, -1.43891796e-01f, -3.88327204e-02f, -1.39104217e-01f,
  -2.34821558e-01f, 3.56670976e-01f, -5.65836877e-02f, -1.24875255e-01f, 2.53437962e-02f, -2.63458956e-02f, -3.65620367e-02f, -5.00735864e-02f, -4.24801596e-02f, -1.01818673e-01f,
  -1.81885153e-01f, -7.85745531e-02f, -4.77223173e-02f, 2.66957972e-02f, 9.87506583e-02f, -5.18941805e-02f, -5.22977524e-02f, 7.34805167e-02f, -8.35890248e-02f, -1.12286270e-01f,
  -1.64631363e-02f, -9.52620283e-02f, -1.01003453e-01f, -1.06721722e-01f, -6.62453100e-02f, -4.63180616e-02f, 9.58361924e-02f, -9.08097997e-02f, -6.96990639e-02f, -1.57545552e-01f,
  2.82022059e-01f, -6.01605661e-02f, 1.80889070e-01f, 3.57931829e-03f, -2.79648453e-01f, -2.51760989e-01f, -2.94343352e-01f, -1.91109002e-01f, -1.81505308e-02f, -7.72621408e-02f,
  -6.81877956e-02f, 1.10390656e-01f, -9.02947113e-02f, 1.16189055e-01f, 9.87476632e-02f, 4.45833914e-02f, 1.22503929e-01f, 3.16490620e-01f, 2.11418837e-01f, 1.71381459e-02f,
  2.80818734e-02f, 1.31921932e-01f, 1.84713811e-01f, 1.66011214e-01f, 1.22446090e-01f, 2.52872892e-02f, 8.18950757e-02f, 1.39667004e-01f, 2.90506147e-02f, 4.12830800e-01f,
  2.53480017e-01f, 3.24480012e-02f, -1.83753133e-01f, 2.83790380e-02f, -3.02132238e-02f, 6.34923652e-02f, -7.73963556e-02f, 1.79469019e-01f, -1.45455487e-02f, 1.26794934e-01f,
  -6.92201853e-02f, 3.11241671e-02f, -2.63877735e-02f, -3.02109364e-02f, -3.79708596e-02f, -5.90459965e-02f, 9.96818691e-02f, 1.32737353e-01f, 7.31281238e-03f, 7.80149130e-03f,
  -1.66339648e-03f, -1.53425848e-03f, -8.14787671e-02f, -3.16701710e-01f, -1.23766229e-01f, -1.28923744e-01f, -2.81131081e-02f, 3.28694992e-02f, -9.41992700e-02f, 2.04390049e-01f,
  1.84317362e-02f, 4.13424820e-02f, 4.09633331e-02f, 4.55223024e-02f, 2.90753762e-03f, 6.26893789e-02f, -5.96090816e-02f, 4.41559255e-02f, -3.63352410e-02f, 8.39379430e-02f,
  -1.12079121e-02f, 2.39879102e-03f, -2.06532907e-02f, 4.46821041e-02f, -1.21903822e-01f, 9.96399224e-02f, -4.76303250e-02f, 1.00147037e-03f, -5.46166208e-03f, 2.94652060e-02f,
  3.04059032e-02f, 2.82195210e-02f, -2.26927418e-02f, 4.12080325e-02f, -2.30715639e-04f, 1.77294074e-03f, 1.19078241e-01f, 5.27283736e-02f, -3.06243612e-03f, 4.69809286e-02f,
  -9.15855095e-02f, -2.73249388e-01f, -2.32675802e-02f, 3.66728641e-02f, -5.67956939e-02f, -1.31094202e-01f, -2.91440971e-02f, 1.19386360e-01f, -2.87743323e-02f, 6.13006130e-02f,
  -7.85997435e-02f, -6.84624363e-04f, -3.76906134e-02f, -1.35052036e-02f, -7.11564347e-02f, -8.17231368e-03f, -3.07795443e-02f, -2.04771925e-02f, -1.01549305e-01f, 5.78364432e-02f,
  6.39233680e-04f, -2.02691332e-01f, -2.08364114e-01f, -1.78106204e-01f, -2.49338716e-01f, -3.10183674e-01f, -1.20537102e-01f, -1.71003968e-01f, -1.42181039e-01f, -9.20149758e-02f,
  2.48291660e-02f, -2.74596930e-01f, 5.38339131e-02f, -1.51972929e-02f, -1.68235242e-01f, -8.77932310e-02f, -1.90819576e-01f, 5.32276221e-02f, 7.29800239e-02f, -1.99762702e-01f,
  -8.82748663e-02f, 1.07947797e-01f, 2.20806189e-02f, 1.66932359e-01f, 1.50814548e-01f, -1.54033020e-01f, -1.20254606e-01f, 1.89264879e-01f, 2.51842856e-01f, 9.63448063e-02f,
  -4.76949774e-02f, 9.64956656e-02f, 1.60223499e-01f, 1.47488415e-01f, -2.09373325e-01f, -5.45993932e-02f, -1.04505815e-01f, 3.57271880e-02f, -1.94148496e-01f, -4.01273251e-01f,
  -8.78645554e-02f, -3.58005576e-02f, 1.20387860e-01f, 1.76108014e-02f, -8.25749114e-02f, -1.48585439e-01f, -1.50285438e-01f, 3.23053077e-02f, 8.53357762e-02f, 3.93408835e-02f,
  -1.59406155e-01f, 2.19940059e-02f, 2.08020322e-02f, 4.78831232e-02f, 8.10134709e-02f, 4.07864116e-02f, 1.89771995e-01f, 8.66235718e-02f, 2.41223335e-01f, -4.39869128e-02f,
  -1.39249533e-01f, -1.46859303e-01f, 7.53817568e-03f, 7.83395469e-02f, 1.04805551e-01f, 3.47501948e-03f, 2.56094690e-02f, 8.99411961e-02f, 3.59814391e-02f, -3.47456425e-01f,
  -1.19957514e-01f, 8.34145248e-02f, 1.38451904e-02f, -1.48795724e-01f, 1.05936289e-01f, -7.88903311e-02f, 1.91905908e-02f, -3.94579209e-02f, -2.05821060e-02f, -1.22573197e-01f,
  8.42972919e-02f, 4.51439731e-02f, 4.79032211e-02f, 1.51136177e-04f, 3.64562199e-02f, 1.19344136e-02f, 6.11777790e-02f, 3.63721885e-02f, 2.77352892e-02f, -7.68241510e-02f,
  -5.21644540e-02f, -9.66018488e-05f, -1.26348063e-01f, 8.77810046e-02f, -6.97458312e-02f, 7.52011761e-02f, -1.09642919e-03f, 1.01895109e-01f, -1.46044806e-01f, -3.20230089e-02f,
  3.71353030e-02f, 2.01121733e-01f, -2.49616653e-01f, -7.22080544e-02f, -4.05996107e-02f, 9.71107930e-03f, -3.68254185e-02f, 9.23194289e-02f, 2.00610459e-02f, -3.91260795e-02f,
  4.34572324e-02f, -2.12242045e-02f, -9.78332609e-02f, -3.06592565e-02f, -7.36530945e-02f, -1.85662553e-01f, -1.17208630e-01f, -5.84175140e-02f, -1.36475954e-02f, -7.94264898e-02f,
  -2.44621537e-03f, -4.18408215e-02f, -7.80426338e-02f, 4.77518402e-02f, -6.82123899e-02f, -6.16200045e-02f, -1.37681052e-01f, -2.02484190e-01f, -1.06968313e-01f, -3.25598806e-01f,
  4.23710108e-01f, -1.75047636e-01f, -2.72414416e-01f, 5.22856377e-02f, -7.35862702e-02f, -2.99810991e-02f, -1.63784996e-02f, 1.05641514e-01f, 1.12049505e-01f, -2.39440188e-01f,
  -2.55966097e-01f, -4.31636684e-02f, -2.27915317e-01f, -5.27206343e-03f, 3.75212878e-02f, -1.49405450e-01f, -1.41499698e-01f, 1.42864004e-01f, 1.56644911e-01f, 1.42999813e-01f,
  -3.91304977e-02f, 2.12869510e-01f, 2.64482915e-01f, 1.84717774e-02f, -2.15219483e-01f, 1.12525104e-02f, -1.59577161e-01f, -3.87944877e-02f, -1.29257843e-01f, -3.29200417e-01f,
  -3.40481073e-01f, -2.56673872e-01f, 3.37866321e-02f, -3.60174067e-02f, -1.90452382e-01f, 1.34644955e-01f, -1.49683133e-02f, -7.96067119e-02f, -7.84382895e-02f, -8.71521682e-02f,
  -1.58205956e-01f, -1.34295106e-01f, -1.09562926e-01f, -1.56839520e-01f, -6.85839653e-02f, -4.10951376e-02f, 7.77147338e-02f, -3.27779097e-03f, -5.74941076e-02f, -1.83898494e-01f,
  -1.08374007e-01f, -7.97704086e-02f, -1.26677230e-01f, 4.88671660e-02f, -8.19019601e-02f, -3.35414670e-02f, -1.95517853e-01f, -2.53307074e-01f, -9.76651311e-02f, -1.11016080e-01f,
  7.94296991e-03f, -9.29898247e-02f, -2.97266152e-02f, 3.75149772e-02f, 1.73787754e-02f, -1.37092092e-03f, 5.82275428e-02f, -1.47140847e-04f, 6.07345700e-02f, 4.71088253e-02f,
  6.42892253e-03f, -8.99260342e-02f, -3.94062325e-02f, -3.95318083e-02f, -3.94950286e-02f, 2.72242557e-02f, -5.55891283e-02f, 6.30750954e-02f, -2.65729371e-02f, 8.83528069e-02f,
  6.70139268e-02f, 6.20487705e-02f, 1.48659460e-02f, -5.96784381e-03f, 5.71735725e-02f, 5.70927630e-04f, -1.61716282e-01f, -5.77026755e-02f, -2.84754839e-02f, -7.27254944e-03f,
  2.27155671e-01f, -9.87791419e-02f, 7.86105618e-02f, 1.33469790e-01f, -1.34352461e-01f, -3.62920612e-02f, 2.65141521e-02f, 7.26755857e-02f, -9.80032012e-02f, 5.32180890e-02f,
  -1.21415243e-01f, -1.62367579e-02f, -8.52492601e-02f, 4.41156514e-02f, 4.52513760e-03f, 6.01577349e-02f, 1.14144199e-01f, 4.77516204e-02f, 4.29385714e-02f, 1.60107091e-01f,
  2.00026289e-01f, 2.26435483e-01f, 1.39177829e-01f, 7.31125697e-02f, 4.35501784e-02f, 2.03424901e-01f, 1.18963998e-02f, -3.51740718e-02f, 1.34543717e-01f, 2.60421336e-01f,
  -1.20502435e-01f, 1.56532228e-01f, 9.23211798e-02f, -2.66552102e-02f, 2.88475335e-01f, -9.96787287e-03f, -2.02836424e-01f, -2.18413606e-01f, -4.04643938e-02f, 7.60680884e-02f,
  8.93079787e-02f, 6.00706376e-02f, -3.43897790e-02f, -9.85368267e-02f, -3.16011697e-01f, 9.00238529e-02f, 1.59230843e-01f, -1.06538296e-01f, -2.75503010e-01f, -1.21180937e-01f,
  9.73532051e-02f, -7.72919431e-02f, -2.06965834e-01f, -1.70306832e-01f, 2.22628117e-01f, 5.02260635e-03f, 1.30675241e-01f, 1.20046504e-01f, 1.14941299e-01f, 3.85880142e-01f,
  1.25909999e-01f, 4.47973469e-03f, 2.63459012e-02f, 1.42197266e-01f, 8.81558433e-02f, -3.27004939e-02f, -3.85250449e-02f, -7.16915354e-02f, -4.66115177e-02f, -2.23247055e-02f,
  2.53790319e-01f, 9.04912278e-02f, 9.85134244e-02f, 3.77736278e-02f, -1.64127454e-01f, -1.75191060e-01f, -1.69539839e-01f, -1.78627610e-01f, -2.70110905e-01f, -1.03578217e-01f,
  1.66158408e-01f, 3.73996720e-02f, -1.16629086e-01f, -3.76582220e-02f, -6.75071254e-02f, 9.54470932e-02f, -1.56710371e-01f, -4.16449904e-02f, -2.52445519e-01f, -2.37997144e-01f,
  4.24689017e-02f, 2.43323371e-02f, 4.14153142e-03f, 5.58232628e-02f, -4.97871749e-02f, 1.67460255e-02f, 9.70467702e-02f, 1.55670596e-02f, -7.77098760e-02f, 2.47638728e-02f,
  -9.61043760e-02f, 1.37855555e-03f, -1.94625147e-02f, 2.33210139e-02f, -8.84728730e-02f, 2.01446321e-02f, -2.76998207e-02f, -4.33900878e-02f, -6.36192560e-02f, 1.10595018e-01f,
  1.51864570e-02f, 3.58338691e-02f, 1.55346438e-01f, -3.53625007e-02f, 2.34691296e-02f, -4.35861908e-02f, 1.28387108e-01f, -6.06788415e-03f, -4.24797721e-02f, 5.74675538e-02f,
  -1.65105075e-01f, 2.16088053e-02f, 4.66029113e-03f, -2.84594987e-02f, -3.04601528e-02f, -4.69249347e-03f, 6.52972981e-02f, 4.55155149e-02f, -2.88852509e-02f, -1.63814113e-01f,
  -1.94068737e-02f, -4.43121195e-02f, 5.00393696e-02f, -5.13204560e-03f, -1.34010762e-01f, 2.88364422e-02f, 8.22066814e-02f, -7.72520294e-03f, -1.14773102e-01f, -8.56087059e-02f,
  -1.00989573e-01f, -2.48919666e-01f, -9.93442461e-02f, -1.39905035e-01f, -7.76020661e-02f, -1.29294485e-01f, -1.09291308e-01f, -3.28946039e-02f, -2.15259314e-01f, -3.42823863e-01f,
  -3.01031470e-02f, 2.87087470e-01f, 1.10889591e-01f, 5.73357427e-03f, 1.23303987e-01f, 7.63934255e-02f, 2.06643835e-01f, -1.59039110e-01f, -9.62417126e-02f, 1.11444682e-01f,
  -5.35078766e-03f, -3.74888666e-02f, 5.03857806e-02f, 2.04250645e-02f, 9.21696075e-04f, 9.49342996e-02f, 1.91194311e-01f, -5.03369309e-02f, -1.76489845e-01f, 1.40848840e-02f,
  -4.17528264e-02f, -1.39621794e-01f, -1.11461371e-01f, -9.52431187e-02f, 5.81860803e-02f, -1.10771872e-01f, 4.91395518e-02f, 1.21029861e-01f, 9.20400694e-02f, 3.29550117e-01f,
  2.18734086e-01f, 1.90131962e-01f, -3.88070568e-02f, -8.97849798e-02f, 7.60105178e-02f, 2.08856743e-02f, -1.15202591e-01f, -1.39267491e-02f, -7.91410655e-02f, 1.11308591e-02f,
  1.62850067e-01f, 1.14472449e-01f, -1.77734420e-02f, 7.82301947e-02f, -1.61283925e-01f, -8.18429217e-02f, 3.94409522e-02f, 1.38088949e-02f, -2.24147171e-01f, 8.05756375e-02f,
  -4.17346833e-03f, 1.64609268e-01f, 4.81353402e-02f, 4.92236391e-02f, -2.81137787e-02f, -1.98278785e-01f, -2.41173171e-02f, 3.48808914e-02f, -6.11902215e-02f, -4.70365733e-02f,
  2.61392538e-03f, -5.47970692e-03f, 1.65773928e-02f, 1.34611771e-01f, 9.06217769e-02f, -3.49362195e-02f, 4.81569655e-02f, 6.95766211e-02f, 3.10983639e-02f, 1.18206829e-01f,
  1.16128720e-01f, -6.83337674e-02f, -2.13510916e-02f, 1.05952024e-01f, 1.51400557e-02f, -1.05757199e-01f, -2.15269998e-02f, -2.52914764e-02f, -3.07933986e-02f, 8.60369280e-02f,
  -2.13314537e-02f, 2.12343931e-02f, -9.60009769e-02f, 2.79682782e-02f, 1.70070622e-02f, 1.00675123e-02f, -1.93085559e-02f, -6.62699118e-02f, -4.90944609e-02f, -1.66067481e-02f,
  -1.81044772e-01f, 1.50558390e-02f, -3.14087868e-02f, -3.64643633e-02f, -9.08283740e-02f, -1.01589337e-01f, -1.19210176e-01f, -1.32268161e-01f, 3.57547104e-02f, -8.90897810e-02f,
  -1.39614001e-01f, -1.35585591e-01f, -6.21769205e-02f, -6.59837499e-02f, -1.94453731e-01f, -4.55254503e-02f, -1.78894252e-02f, -3.04164807e-03f, -1.03415340e-01f, -1.82368964e-01f,
  -1.70698136e-01f, -2.66868293e-01f, -3.07833940e-01f, -6.32160679e-02f, -6.44926801e-02f, -2.39076182e-01f, -6.81637675e-02f, -8.13239068e-02f, -1.33460671e-01f, -1.07951820e-01f,
  -4.73578751e-01f, 1.92635342e-01f, -1.91761613e-01f, -4.45034266e-01f, -1.91383481e-01f, -1.62094645e-02f, 3.42396319e-01f, 9.92705747e-02f, -5.35122156e-02f, 1.60959825e-01f,
  1.78356357e-02f, -7.28499517e-02f, 3.88686322e-02f, 4.66481037e-02f, 4.49152514e-02f, 6.26151562e-02f, -1.43038750e-01f, -2.64516801e-01f, -2.99251437e-01f, -8.34902078e-02f,
  1.03960417e-01f, -2.40020216e-01f, -3.39591712e-01f, -1.66698873e-01f, 5.65321743e-02f, -1.23072267e-01f, 5.11884950e-02f, -1.82309389e-01f, 1.11587785e-01f, 3.55017371e-02f,
  3.29182968e-02f, -1.05442174e-01f, 8.39322526e-03f, -1.54696062e-01f, 5.33804223e-02f, -1.23355491e-02f, -1.34162813e-01f, -2.88027469e-02f, -6.36000931e-03f, -5.10665998e-02f,
  -1.05734617e-01f, 9.12959203e-02f, -2.02513948e-01f, 4.99344543e-02f, -7.28253648e-02f, -5.16031720e-02f, -7.70232007e-02f, -1.00859672e-01f, 9.31905508e-02f, 1.24282546e-01f,
  1.44442767e-01f, -9.91877541e-02f, -8.84986669e-02f, 4.87548113e-02f, -3.22139449e-02f, -9.78516415e-02f, 1.30215392e-01f, -2.47739181e-02f, 3.45590562e-02f, 2.16356650e-01f,
  4.72500399e-02f, 1.50113972e-02f, -8.76125693e-02f, -9.16777737e-03f, -3.18418839e-03f, -8.13706070e-02f, -1.37596205e-01f, -7.47035667e-02f, -1.82263665e-02f, 3.70701700e-02f,
  4.40120064e-02f, -7.56730884e-02f, -7.01104179e-02f, -6.20380193e-02f, -1.00059785e-01f, -8.12339410e-02f, -6.70280606e-02f, 4.43230420e-02f, -3.16305831e-02f, -9.39236954e-02f,
  -1.05064571e-01f, 1.24042407e-01f, 5.60083240e-03f, -1.11771990e-02f, -1.60689130e-02f, -1.23074263e-01f, 6.85337856e-02f, 1.25779388e-02f, 3.93240638e-02f, -7.52358809e-02f,
  1.10864139e-03f, -2.60278910e-01f, -1.66837405e-02f, 1.94203574e-02f, -1.32007867e-01f, 1.01322815e-01f, -1.25615597e-01f, -1.34536937e-01f, -1.76636562e-01f, -4.47693318e-02f,
  -1.16055131e-01f, -2.79701333e-02f, -1.61387213e-02f, 5.30793183e-02f, 8.34627599e-02f, -1.25495875e-02f, 7.94919580e-02f, -5.69676645e-02f, 1.12257123e-01f, 1.09645113e-01f,
  1.19780377e-01f, -7.01244920e-02f, 1.35190394e-02f, 5.13302460e-02f, 1.78357530e-02f, -1.03965931e-01f, 1.44281000e-01f, -1.43310865e-02f, -4.37762849e-02f, 1.69223636e-01f,
  6.33013785e-01f, 2.72147179e-01f, 3.67751926e-01f, 1.48353949e-01f, -1.53082177e-01f, -7.32903481e-02f, 2.66160965e-02f, 8.95573869e-02f, -3.28648388e-02f, 8.34575370e-02f,
  3.07919295e-03f, -2.22885842e-03f, 1.65956244e-01f, 1.19630791e-01f, 1.49861902e-01f, 6.57202080e-02f, 8.74050856e-02f, 2.49117851e-01f, 1.54004544e-01f, 1.15429901e-01f,
  -1.06829852e-01f, -1.38548175e-02f, 2.59430379e-01f, 1.34741003e-02f, 2.09243689e-02f, -3.81944366e-02f, 9.49053839e-02f, -1.16809737e-02f, 3.92035581e-02f, 1.42595377e-02f,
  7.06309900e-02f, 2.93670893e-01f, 2.72816326e-02f, -1.39011726e-01f, 1.30229341e-02f, 5.85548580e-02f, -7.27715641e-02f, -3.64898257e-02f, -1.28659636e-01f, -1.33418255e-02f,
  -8.24019685e-03f, 5.53399045e-03f, -2.52019223e-02f, -3.84928770e-02f, -5.15797026e-02f, 2.76593175e-02f, 2.17623636e-02f, 1.41838253e-01f, 1.44506574e-01f, -1.06122578e-02f,
  -9.18890312e-02f, 5.37956133e-03f, -8.50564707e-03f, 6.28040060e-02f, 1.72109008e-01f, 5.66139705e-02f, 7.39954263e-02f, 2.72703283e-02f, 1.43556476e-01f, 1.52824491e-01f,
  1.67258918e-01f, 1.97840706e-01f, 1.92239266e-02f, 1.06481597e-01f, 3.08666583e-02f, 2.00171396e-02f, 7.45571405e-02f, -5.06303944e-02f, 3.75970118e-02f, -4.74625304e-02f,
  1.24162078e-01f, 1.06621748e-02f, 7.98117146e-02f, -5.28055094e-02f, 3.55335101e-02f, 2.13932339e-03f, -7.58642852e-02f, -3.77054736e-02f, 6.21706136e-02f, -1.01000294e-01f,
  -9.49663762e-03f, -6.57190681e-02f, 7.82893151e-02f, 6.17545843e-02f, 1.04681132e-02f, 9.57213938e-02f, 3.34066972e-02f, 1.97024341e-03f, -4.56233695e-02f, -4.78862710e-02f,
  -4.66229975e-01f, 4.03742567e-02f, -3.39580886e-02f, -8.34728032e-02f, -4.76470664e-02f, -1.00695893e-01f, -7.13936016e-02f, -5.29972613e-02f, -2.42301285e-01f, -1.31253570e-01f,
  -1.25497162e-01f, 1.88523941e-02f, 7.05454350e-02f, -6.76217005e-02f, -3.55300866e-02f, -6.74610883e-02f, -1.13771744e-01f, -3.31899635e-02f, -3.12637836e-02f, -6.93959892e-02f,
  5.81412576e-02f, -2.72796676e-03f, 4.02417295e-02f, -7.44770020e-02f, -1.21359646e-01f, -2.44976729e-02f, -9.08511207e-02f, -2.88478676e-02f, -3.07850391e-02f, -3.18183526e-02f,
  -5.46580851e-01f, 7.67108425e-02f, 3.94032188e-02f, -1.61929891e-01f, -1.72063589e-01f, -3.26908082e-01f, -3.86798233e-02f, -1.57981917e-01f, -2.61238039e-01f, 7.77956471e-02f,
  1.51318505e-01f, -7.87284151e-02f, 2.20714927e-01f, 2.43374836e-02f, -1.72518909e-01f, 1.82943046e-01f, 7.03534633e-02f, -1.65490761e-01f, -4.69324499e-01f, -2.78479844e-01f,
  -1.16555125e-01f, -3.00122947e-01f, -2.61859715e-01f, -8.96651149e-02f, -5.77393845e-02f, -1.98667929e-01f, 6.63737953e-02f, -1.67779535e-01f, -1.58405632e-01f, 1.19645946e-01f,
  1.95008978e-01f, -1.84235409e-01f, -1.19519226e-01f, -1.60350040e-01f, 1.51540842e-02f, -2.24607754e-02f, -2.30761301e-02f, -2.29811482e-02f, 1.61143560e-02f, -2.56365854e-02f,
  -2.88165966e-03f, -5.24883717e-02f, -4.86549176e-03f, -7.81135559e-02f, -1.78995028e-01f, -2.80111451e-02f, 1.14331111e-01f, -2.04367191e-02f, 4.77077514e-02f, 2.76801318e-01f,
  2.96316855e-02f, 6.93543032e-02f, 8.15118253e-02f, 9.68061611e-02f, 6.02427609e-02f, -3.25201340e-02f, 4.09782305e-03f, -4.21506688e-02f, -4.88562509e-02f, 1.07183352e-01f,
  -4.98097874e-02f, 1.71129480e-01f, -5.09684943e-02f, -1.54387653e-01f, 7.64074130e-03f, -2.52920929e-02f, -1.28590902e-02f, 5.83341927e-04f, -3.35971452e-02f, 2.98743062e-02f,
  7.46098310e-02f, -1.71398241e-02f, -6.29093964e-03f, -3.29971337e-03f, 1.07958028e-02f, 6.89375848e-02f, 4.14014608e-02f, 4.51024137e-02f, 5.73394671e-02f, -6.15737401e-02f,
  -1.41511023e-01f, 8.42435285e-04f, 1.64154842e-02f, 2.99741533e-02f, -1.51964708e-03f, 9.67741460e-02f, 1.06672823e-01f, -6.22671582e-02f, -4.00887430e-02f, 9.36133265e-02f,
  6.66046739e-02f, -2.32106373e-01f, 6.62437603e-02f, 1.02592288e-02f, 6.29231632e-02f, 7.56694004e-02f, 1.16658688e-01f, 5.90288676e-02f, -2.48412862e-02f, 1.61648411e-02f,
  2.94302460e-02f, -3.02072521e-02f, 7.04832301e-02f, 7.82918260e-02f, -4.31843102e-02f, -8.02325904e-02f, 1.41513169e-01f, -8.00360441e-02f, -3.07849608e-02f, 1.15368620e-01f,
  1.41708821e-01f, 5.02005555e-02f, 2.63919053e-03f, 8.63653272e-02f, -2.11976022e-02f, -1.25527129e-01f, 7.79597983e-02f, 1.20505154e-01f, -4.91076969e-02f, 2.10494831e-01f,
  -2.47609466e-01f, 4.34609428e-02f, 3.86529751e-02f, -6.81114197e-02f, 2.91241497e-01f, 1.71899930e-01f, 3.22870731e-01f, 9.96568277e-02f, -4.24956270e-02f, 9.45578441e-02f,
  -4.54476736e-02f, -4.04914357e-02f, 1.13055464e-02f, 9.24495310e-02f, 5.59139289e-02f, 1.67290971e-01f, 9.58331376e-02f, -5.47955632e-02f, -9.10705552e-02f, 1.82517376e-02f,
  1.76798537e-01f, -1.64506152e-01f, -2.93054402e-01f, -1.38220668e-01f, -1.34309828e-01f, -8.11916813e-02f, 6.09443448e-02f, -7.69752115e-02f, 1.37837291e-01f, 8.09115395e-02f,
  -1.73978359e-01f, -7.78697431e-02f, 9.20292139e-02f, 2.98183062e-03f, -2.23066639e-02f, -1.45494491e-01f, -1.00065559e-01f, -1.47324398e-01f, -1.81927867e-02f, 6.34454414e-02f,
  6.65282011e-02f, -1.04201443e-01f, -4.65683416e-02f, -5.58929630e-02f, -6.41076341e-02f, -6.88972026e-02f, -1.12318955e-01f, 5.76139949e-02f, 2.21188739e-03f, -6.84814155e-02f,
  1.56143770e-01f, 6.74630627e-02f, -5.24343178e-03f, -4.33666259e-02f, -6.00988455e-02f, -1.43156990e-01f, 3.32748964e-02f, -4.28238921e-02f, -5.71548343e-02f, -1.17252827e-01f,
  -3.12601514e-02f, 4.99955602e-02f, -4.25129160e-02f, -1.85969342e-02f, 4.33405936e-02f, 4.37154919e-02f, -3.23476866e-02f, 7.28598312e-02f, 1.04818836e-01f, -7.80078694e-02f,
  -8.69983882e-02f, -9.99760479e-02f, -3.49718779e-02f, -9.88560691e-02f, -1.23838395e-01f, -3.70657928e-02f, 5.73128648e-02f, -1.98217388e-02f, -9.61327031e-02f, 2.20699189e-03f,
  1.60020404e-02f, 5.10113724e-02f, -1.07064232e-01f, -2.07898091e-03f, -7.07418919e-02f, -1.58903629e-01f, -1.42308995e-01f, 3.91305611e-02f, -6.00177608e-02f, -1.08689740e-01f,
  -3.26683074e-01f, 1.44448772e-01f, -4.56582978e-02f, -2.82829665e-02f, -3.20072956e-02f, -1.65804643e-02f, -6.29737526e-02f, 9.05908830e-03f, 5.35626449e-02f, 3.22811306e-03f,
  3.41165178e-02f, -4.33623344e-02f, -6.64505139e-02f, 1.22510709e-01f, 1.24459285e-02f, 8.02720338e-02f, 1.36755724e-02f, 1.25060648e-01f, 1.59292266e-01f, -3.35872360e-02f,
  2.71308441e-02f, -6.81492314e-02f, -1.47896305e-01f, -2.51108259e-02f, -6.93587363e-02f, -2.31811851e-01f, -4.21836786e-02f, -2.36312285e-01f, -7.83706158e-02f, -1.92056239e-01f,
  3.25286239e-01f, 1.96939170e-01f, 1.05231456e-01f, 5.86281642e-02f, -3.44839007e-01f, -1.37461111e-01f, -4.40487750e-02f, 1.40512669e-02f, -2.36594267e-02f, -4.37362716e-02f,
  -1.80308819e-01f, -1.66127875e-01f, -9.47599337e-02f, 1.11037292e-01f, 2.58662999e-01f, 1.04687281e-01f, 1.26241460e-01f, 2.80325711e-01f, 1.94823802e-01f, -1.43134845e-02f,
  -2.22613905e-02f, -7.89442658e-02f, 1.28876701e-01f, -2.14638822e-02f, -2.48358063e-02f, -1.71647947e-02f, 6.00644527e-03f, -1.53499898e-02f, 7.47508183e-02f, 2.61600107e-01f,
  7.59341791e-02f, 1.36643946e-01f, -7.88295344e-02f, 7.84463808e-02f, -2.97452994e-02f, 2.87411027e-02f, -3.65678966e-02f, -2.84474139e-04f, -3.53837162e-02f, -5.99496216e-02f,
  -9.90149975e-02f, -3.57010774e-02f, -1.33653551e-01f, 1.08703084e-01f, -1.08483963e-01f, -1.01339623e-01f, 6.79977098e-03f, 8.62896666e-02f, 7.41530284e-02f, -3.57257463e-02f,
  6.06377833e-02f, -2.49182329e-01f, -1.67597637e-01f, -7.80525729e-02f, 5.05564176e-02f, -1.19982883e-01f, -1.12928547e-01f, 8.05974081e-02f, -4.85114083e-02f, 1.69579744e-01f,
  -1.26373798e-01f, 7.40396306e-02f, 6.59019202e-02f, -1.08865134e-01f, -7.67684877e-02f, -1.18601710e-01f, 7.13029457e-03f, -2.76953224e-02f, 3.22359018e-02f, -1.26754016e-01f,
  -7.52154365e-02f, 3.90684158e-02f, 2.91844644e-03f, -7.75042102e-02f, -2.94049773e-02f, -6.51788488e-02f, 2.18107924e-02f, -4.47442047e-02f, -1.30068615e-01f, -9.04522836e-02f,
  -8.63812938e-02f, 8.33072066e-02f, -6.24208823e-02f, 7.67466277e-02f, -4.67555895e-02f, 1.05020985e-01f, -9.08783730e-03f, -6.42395392e-02f, -4.91024703e-02f, -1.48937345e-01f,
  -3.46893758e-01f, -4.32582617e-01f, 2.09963903e-01f, 2.14839548e-01f, 1.05137512e-01f, 1.22323200e-01f, 4.48677056e-02f, 5.85020594e-02f, -3.16704884e-02f, -2.19411519e-03f,
  2.38552559e-02f, 1.32031679e-01f, -2.61577144e-02f, 1.08660340e-01f, -1.72307789e-01f, -9.85984877e-02f, 1.08969705e-02f, 8.77556056e-02f, 1.72104351e-02f, -5.43303825e-02f,
  -1.04555590e-02f, -8.72302726e-02f, -1.77210152e-01f, -8.12689811e-02f, -6.15099892e-02f, -1.34873852e-01f, -2.43743658e-01f, -6.78892508e-02f, -2.79998720e-01f, -9.86698270e-02f,
  5.26932061e-01f, 2.15765491e-01f, 1.51473612e-01f, 1.89461157e-01f, -1.17752522e-01f, -2.66864598e-01f, -2.99339712e-01f, -1.61388367e-01f, 3.96557823e-02f, -1.72565575e-03f,
  3.42409797e-02f, 8.01882148e-02f, 1.72367349e-01f, 1.97823778e-01f, 1.52508497e-01f, -3.77646014e-02f, -3.82693149e-02f, 2.54034370e-01f, 1.81137472e-01f, 2.97281947e-02f,
  -5.31139337e-02f, 8.85856226e-02f, 2.50436932e-01f, 1.13426507e-01f, 1.78230241e-01f, 9.95081365e-02f, 3.39403586e-03f, 6.52202144e-02f, 1.31546944e-01f, 3.58868629e-01f,
  1.59916490e-01f, 7.91839361e-02f, -3.87576148e-02f, 2.34385896e-02f, -4.79614735e-02f, -9.17764194e-03f, 5.11648320e-02f, 1.34332525e-02f, -1.53489131e-03f, -1.77073091e-01f,
  -1.36381343e-01f, 3.15236300e-02f, -6.88396618e-02f, -1.12885222e-01f, -1.44193530e-01f, -7.59276748e-02f, -1.20825604e-01f, 5.97220240e-03f, 6.32734448e-02f, -2.63504740e-02f,
  -4.14208658e-02f, -2.18803644e-01f, -1.92447796e-01f, -1.96158662e-01f, 2.91243698e-02f, -1.22396216e-01f, 5.39456669e-04f, 3.91042344e-02f, -1.05761975e-01f, 3.03904042e-02f,
  -8.77136588e-02f, 4.34953533e-02f, -3.53617854e-02f, -3.93528938e-02f, -9.92184877e-02f, -7.63325319e-02f, -4.57955897e-02f, -1.73478395e-01f, -3.83999571e-02f, -9.41157900e-03f,
  -2.52229925e-02f, -1.05725162e-01f, -5.23770303e-02f, -4.03937101e-02f, 1.23841815e-01f, -7.26949945e-02f, -4.58508208e-02f, -8.34614560e-02f, -2.32693274e-02f, -1.13581521e-02f,
  7.81690609e-03f, -3.39404903e-02f, 5.38688991e-03f, 2.72836797e-02f, -7.95926973e-02f, -9.67158675e-02f, 1.43920677e-02f, -1.85947269e-02f, -7.72791728e-02f, -1.05189689e-01f,
  -1.94944263e-01f, -5.15785255e-02f, 2.60280252e-01f, 1.53942525e-01f, 5.91794141e-02f, 2.15364113e-01f, 2.16526821e-01f, 1.92023620e-01f, 9.88272429e-02f, -8.66258666e-02f,
  3.66800465e-02f, 8.66820589e-02f, 1.66640040e-02f, 6.10104413e-04f, -9.83089730e-02f, -1.07298620e-01f, 4.64949794e-02f, 1.21714607e-01f, 4.87385057e-02f, 1.05122715e-01f,
  -2.27308311e-02f, -1.25688702e-01f, -8.66289958e-02f, -1.07144304e-01f, -7.08826184e-02f, 2.41326094e-02f, 2.78096888e-02f, 2.11648140e-02f, -1.10298134e-01f, -1.50260553e-01f,
  3.98496687e-01f, -4.81280871e-02f, -4.40236896e-01f, 1.37940258e-01f, -1.68401316e-01f, 1.20481486e-02f, 8.21460038e-02f, 1.72478691e-01f, 1.17420740e-01f, 1.20031528e-01f,
  -5.41786104e-02f, -1.03124036e-02f, 1.18540086e-01f, 5.67418411e-02f, 2.45503291e-01f, 6.44697472e-02f, -1.25701040e-01f, -3.49780433e-02f, -4.64155339e-02f, 5.65532176e-03f,
  -8.09590798e-03f, 1.29922375e-01f, 1.82787135e-01f, 9.69433039e-02f, -1.29011378e-01f, -2.67407149e-02f, -1.46688715e-01f, -4.42292839e-02f, -1.68574825e-01f, -1.40304580e-01f,
  -3.09502542e-01f, -1.65268511e-01f, -4.82176505e-02f, 6.04978167e-02f, -1.31071344e-01f, 4.76643778e-02f, 1.66341644e-02f, -1.01811647e-01f, 7.41494894e-02f, -4.38345037e-02f,
  -1.39548376e-01f, 1.09457925e-01f, -1.58823162e-01f, -5.05330674e-02f, -7.36097917e-02f, -2.37100050e-02f, -4.84325029e-02f, -8.26137662e-02f, -6.10080212e-02f, -8.96218717e-02f,
  6.13992810e-02f, -1.95443425e-02f, -1.78102702e-01f, -1.32523496e-02f, -1.68124542e-01f, -1.26602381e-01f, -8.95356685e-02f, -2.31118515e-01f, -6.53970763e-02f, -2.96762101e-02f,
  2.56627705e-02f, -7.78354183e-02f, -1.69259101e-01f, 4.30973321e-02f, 1.86983451e-01f, 5.59936538e-02f, -4.48099226e-02f, 1.17830537e-01f, 1.50253549e-01f, 7.82301128e-02f,
  -3.26040648e-02f, -2.24776827e-02f, 6.00549839e-02f, 8.03941488e-03f, -5.97402826e-02f, 1.35210454e-01f, 4.01785523e-02f, -5.20699797e-03f, -6.59734895e-03f, -5.45709468e-02f,
  -6.59021810e-02f, -1.14895385e-02f, -1.10418096e-01f, -1.32673293e-01f, -3.53792980e-02f, 5.24812229e-02f, -3.25968787e-02f, 2.60110814e-02f, 3.59298708e-03f, 6.80151507e-02f,
  9.58093330e-02f, -5.70325293e-02f, 1.84861138e-01f, 3.10301781e-03f, -2.32146129e-01f, 1.85311455e-02f, -6.54871985e-02f, -1.58341035e-01f, -1.17024384e-01f, 2.43032679e-01f,
  1.07160889e-01f, 1.89863667e-01f, 1.88989323e-02f, -4.77837510e-02f, -4.90280725e-02f, 6.97100116e-03f, -3.53024863e-02f, 4.35790839e-03f, 1.19033761e-01f, -4.51159403e-02f,
  2.18039393e-01f, 9.83597413e-02f, 1.94513261e-01f, 5.19652292e-02f, -1.16966359e-01f, 1.47088900e-01f, -1.00008845e-01f, -2.92986501e-02f, 9.30150449e-02f, 3.33054483e-01f,
  -4.68670130e-01f, 1.17660407e-02f, -8.58220756e-02f, -3.27561677e-01f, -2.01754589e-02f, 5.82605340e-02f, -1.65251225e-01f, -1.75755233e-01f, -1.58857495e-01f, -1.24866322e-01f,
  9.97316372e-03f, 2.69286305e-01f, 9.58652571e-02f, -2.83571314e-02f, -2.33270109e-01f, -3.39630187e-01f, -3.02476764e-01f, -3.36114347e-01f, -1.75441325e-01f, 1.26712993e-01f,
  2.23991826e-01f, 6.47137985e-02f, -1.25319138e-01f, 5.52182458e-02f, 2.25069806e-01f, 2.11009666e-01f, 3.65560763e-02f, 2.97635049e-02f, 2.02616856e-01f, 8.06851760e-02f,
  1.48390919e-01f, -1.58360749e-01f, 5.58676459e-02f, -1.95988685e-01f, 7.40969032e-02f, -5.36796637e-02f, 2.20517907e-02f, 8.51049460e-03f, -4.18019183e-02f, -3.22669186e-02f,
  2.23092381e-02f, 3.64393108e-02f, 3.41950059e-02f, -2.78144106e-02f, -1.87428266e-01f, -1.43106526e-03f, -7.75539279e-02f, -1.55595660e-01f, -1.22991845e-01f, 3.34451422e-02f,
  -6.96424767e-03f, 4.05537002e-02f, 8.21358040e-02f, -8.59545395e-02f, 2.60113198e-02f, 3.32446583e-02f, 2.07694083e-01f, 2.18358085e-01f, 1.49236843e-01f, 4.91638482e-02f,
  -8.98746029e-02f, -4.02865447e-02f, -3.46792154e-02f, 1.40622994e-02f, -4.58323117e-03f, 2.07882635e-02f, 1.38358101e-02f, -4.74764779e-02f, 1.71479583e-02f, -1.46228783e-02f,
  -5.49885863e-03f, 4.07064445e-02f, 7.25235417e-02f, 1.61189083e-02f, 4.93106060e-02f, 7.33993351e-02f, -6.29711375e-02f, -5.93496673e-02f, 9.34681818e-02f, -6.37813658e-02f,
  -7.23455250e-02f, 7.82392994e-02f, 2.80190422e-03f, -4.60464880e-02f, -9.62487832e-02f, -8.71056169e-02f, -3.40835005e-02f, -4.42031063e-02f, 8.90199170e-02f, -5.55082075e-02f,
  -2.73031481e-02f, -5.10355942e-02f, -1.64511606e-01f, -4.96687926e-02f, -9.61177796e-02f, 2.71950494e-02f, 5.13507575e-02f, 5.87457372e-03f, -5.08412495e-02f, -4.14675325e-02f,
  -6.82516545e-02f, 1.28516760e-02f, -9.97887030e-02f, 1.05705947e-01f, -7.38935918e-02f, -2.56636273e-02f, -2.25880504e-01f, -5.81251122e-02f, -1.23541705e-01f, -2.75087245e-02f,
  -2.67986834e-01f, -1.47874773e-01f, -1.84178174e-01f, -1.48954421e-01f, -8.03112425e-03f, -1.09857926e-02f, 8.71010721e-02f, -7.87580106e-03f, -5.72947972e-02f, 1.28984172e-02f,
  -3.92479189e-02f, -8.66723806e-03f, 1.22193322e-01f, 1.92026719e-01f, 9.30543244e-02f, 2.14184865e-01f, 8.39343891e-02f, 1.76149189e-01f, 1.06115550e-01f, 9.16358605e-02f,
  1.11016467e-01f, 2.43875653e-01f, 1.53089970e-01f, 1.06204614e-01f, 1.92648202e-01f, 6.46085292e-02f, 4.50384542e-02f, 7.67999701e-03f, 2.70075314e-02f, 1.72731116e-01f,
  9.01142284e-02f, 1.60424057e-02f, -4.06284668e-02f, -5.89877879e-03f, -8.02380741e-02f, 1.85660064e-01f, -5.12171425e-02f, -5.50958402e-02f, 8.86309817e-02f, -1.17620021e-01f,
  6.32505640e-02f, -1.62205160e-01f, 6.45019412e-02f, -6.84481263e-02f, -1.09972000e-01f, -1.05856128e-01f, 3.92907932e-02f, -1.16472647e-01f, 2.89503224e-02f, 1.12401396e-01f,
  -6.93031549e-02f, -2.18532339e-01f, -1.37880236e-01f, -7.29035586e-02f, -4.29688767e-02f, -6.58234134e-02f, -1.23136424e-01f, 8.25555101e-02f, 1.14528500e-01f, -4.44573462e-02f,
  1.26403049e-01f, -5.23723615e-03f, 3.37425396e-02f, 1.09091118e-01f, 1.47921085e-01f, 8.63499120e-02f, -2.51729023e-02f, -7.68811954e-03f, 3.37423272e-02f, 8.69297236e-02f,
  9.02567431e-02f, 3.55643928e-02f, -8.67424607e-02f, 1.26916200e-01f, 9.64840055e-02f, -1.42746950e-02f, 4.99103814e-02f, 6.32124394e-02f, 9.22179744e-02f, -2.80941296e-02f,
  -8.34969208e-02f, 1.35113806e-01f, 1.08810075e-01f, 6.03366061e-04f, -3.19606476e-02f, -1.28515214e-01f, -1.19759537e-01f, 4.53455048e-03f, -1.51499242e-01f, 6.01494312e-03f,
  -5.07447086e-02f, -1.04145482e-01f, -2.03824863e-01f, -3.40957418e-02f, 3.45948618e-04f, 1.82441920e-02f, -9.21583027e-02f, -2.33341064e-02f, -2.70929420e-03f, -6.09382130e-02f,
  1.73003376e-01f, 2.12153327e-02f, -3.23099867e-02f, 2.81052422e-02f, -1.51759118e-01f, -1.13185234e-01f, 1.65997222e-01f, -1.05336070e-01f, -3.19567993e-02f, -3.20009999e-02f,
  -8.51799920e-02f, -1.44705445e-01f, 7.83780497e-03f, -1.10642612e-01f, -1.86130386e-02f, -6.88400418e-02f, -2.94484310e-02f, 6.44142628e-02f, -3.29529122e-02f, -5.49731664e-02f,
  -1.02171250e-01f, -9.88079142e-03f, 2.22598836e-01f, 2.28769451e-01f, 4.35823090e-02f, 1.70784637e-01f, 3.73819582e-02f, 1.61894113e-02f, 5.91224544e-02f, -1.85357351e-02f,
  4.63058203e-01f, -2.91742504e-01f, -1.32973149e-01f, 4.82371888e-06f, 2.72519495e-02f, 3.45882252e-02f, 1.03912711e-01f, 6.65751398e-02f, 2.53305794e-03f, -9.25657824e-02f,
  3.58805582e-02f, 1.01556584e-01f, 1.26961574e-01f, 1.38729036e-01f, 1.98150411e-01f, -4.94153760e-02f, 7.18592433e-03f, 1.56522170e-01f, 1.79235294e-01f, 4.80260216e-02f,
  -1.26029611e-01f, -9.10286233e-02f, 6.36059865e-02f, 1.45603018e-02f, -1.21932328e-01f, 3.76709481e-03f, -6.32738695e-02f, -1.49187297e-01f, -1.14869125e-01f, -1.75323963e-01f,
  8.21677148e-02f, -1.34037640e-02f, 8.72971416e-02f, -1.00161605e-01f, -1.58186778e-01f, -2.50547137e-02f, -6.96242973e-02f, -7.83130452e-02f, -8.06126185e-03f, -4.61039357e-02f,
  -1.46818655e-02f, -1.17882200e-01f, 5.01738377e-02f, -2.34034583e-02f, -1.42273247e-01f, -1.94578189e-02f, -1.13284789e-01f, -1.18519627e-01f, -3.28527540e-02f, -7.60826990e-02f,
  -1.43817246e-01f, -1.21448390e-01f, 5.63222766e-02f, -7.92697445e-02f, -9.83786732e-02f, 4.03973497e-02f, -4.62239198e-02f, -1.01056144e-01f, -6.21345825e-02f, -2.24888604e-02f,
  -2.02281494e-02f, 3.79698873e-02f, -1.62936583e-01f, -2.50036195e-02f, -1.62439179e-02f, 1.60477012e-01f, -1.65106710e-02f, -1.43827334e-01f, -9.11675394e-02f, -5.94966188e-02f,
  5.21905087e-02f, -3.84676941e-02f, 3.30452286e-02f, -1.06544718e-01f, -9.82365385e-02f, 2.73042619e-02f, -6.24801628e-02f, -1.05679855e-02f, 2.45060027e-02f, 2.43196823e-02f,
  7.30238035e-02f, 8.00496638e-02f, 3.71348336e-02f, 6.59999847e-02f, 2.34646760e-02f, 1.25785202e-01f, 3.74762751e-02f, 2.06994191e-02f, -5.14504500e-02f, -3.49714868e-02f,
  3.40722986e-02f, 2.57320888e-02f, 1.17293835e-01f, -1.10716850e-01f, -1.13509342e-01f, 2.35641189e-02f, 9.29228142e-02f, 2.35299971e-02f, 8.87794793e-02f, 1.02448530e-01f,
  -7.95140192e-02f, 8.94856006e-02f, -4.56006005e-02f, -2.28743628e-03f, 1.06907181e-01f, 8.24160203e-02f, -2.86290087e-02f, 8.80219489e-02f, 7.00209290e-02f, -1.20404363e-01f,
  -1.12771548e-01f, 7.20627746e-03f, 1.05229251e-01f, 1.12069376e-01f, 4.66502868e-02f, 1.71321452e-01f, -5.74162172e-04f, 4.76097167e-02f, 1.69196561e-01f, 1.22632906e-02f,
  6.66259006e-02f, -1.27304614e-01f, -2.29888439e-01f, 2.22811177e-01f, -5.55452183e-02f, -2.41112471e-01f, -3.94852996e-01f, -6.51091151e-03f, 2.01669753e-01f, -5.13986647e-02f,
  1.13502763e-01f, 6.52679354e-02f, 2.70766336e-02f, -1.25529453e-01f, -2.99466789e-01f, -3.47177386e-01f, -2.09674433e-01f, -8.68669003e-02f, -2.02823058e-02f, -1.87421460e-02f,
  5.64693734e-02f, 1.18683912e-01f, 1.56342145e-02f, 1.50117846e-02f, 9.10605863e-02f, -5.32018654e-02f, -5.30632660e-02f, -3.71837243e-02f, -1.78122878e-01f, 1.51990121e-02f,
  -8.05080235e-02f, 1.65199578e-01f, -1.35743916e-01f, -1.20008690e-02f, 6.91401064e-02f, 5.11993244e-02f, -2.12449534e-03f, -5.60665876e-02f, 3.07878833e-02f, -3.72852944e-02f,
  6.38775975e-02f, 4.19322355e-03f, 1.26848236e-01f, -9.61983278e-02f, 6.52374923e-02f, -5.55801801e-02f, -3.77218835e-02f, -4.56027761e-02f, -9.99025702e-02f, 1.00234412e-02f,
  -3.07199545e-02f, 2.20549423e-02f, -6.71683773e-02f, -3.61326337e-02f, 1.06440067e-01f, -6.55793026e-02f, -3.50072086e-02f, 1.25863343e-01f, -1.58652976e-01f, 3.05970479e-02f,
  1.24774642e-01f, 1.24844812e-01f, -7.00147375e-02f, 2.37704515e-02f, -2.37084646e-02f, 1.50917228e-02f, 2.51790993e-02f, 1.31301768e-02f, -2.91395579e-02f, 5.66868950e-03f,
  4.15954329e-02f, 3.08687817e-02f, 8.20649788e-02f, 1.14414580e-01f, -9.34839323e-02f, -4.35168594e-02f, -4.11591269e-02f, -5.60836866e-02f, -5.57061285e-02f, -1.72545407e-02f,
  -6.95741400e-02f, 9.33296382e-02f, 1.06709331e-01f, -3.01542133e-02f, 1.50928088e-03f, -1.30015850e-01f, 8.77950341e-02f, 5.16065657e-02f, -1.40569359e-01f, -1.42967450e-02f,
  1.22903943e-01f, -2.01706052e-01f, 2.51099914e-02f, -2.01815329e-02f, -8.30421671e-02f, 9.61786732e-02f, -7.34218732e-02f, -9.83766243e-02f, 4.84615900e-02f, 1.26001649e-02f,
  -3.08796465e-02f, -2.18165573e-02f, 4.36328910e-02f, -1.73650738e-02f, -1.06097423e-01f, 7.51829594e-02f, -1.08422495e-01f, -2.46447623e-02f, -2.16710865e-01f, 5.25304489e-02f,
  -6.88901991e-02f, -2.00753048e-01f, -1.97474852e-01f, -9.15858895e-02f, -5.13125435e-02f, -1.70326427e-01f, -1.33518234e-01f, 6.58642221e-03f, -1.11291714e-01f, -2.55134702e-01f,
  -2.28464261e-01f, 3.43373656e-01f, 6.31474108e-02f, -1.08879231e-01f, -3.32404934e-02f, -1.65080860e-01f, 5.39458506e-02f, -1.87160596e-01f, -1.34613425e-01f, 2.87443817e-01f,
  6.46018833e-02f, -3.61156538e-02f, 2.13496294e-02f, -8.70835185e-02f, -2.38935411e-01f, 1.79666013e-01f, 1.12710796e-01f, -2.23418400e-01f, -4.64577585e-01f, -4.09370303e-01f,
  -1.48277968e-01f, -1.40514955e-01f, -2.82005906e-01f, -1.53907552e-01f, 7.00647160e-02f, 4.77007031e-02f, 1.99588150e-01f, -1.90561414e-02f, 3.69504988e-02f, 2.15813041e-01f,
  1.59387454e-01f, -1.22451521e-02f, -5.81025109e-02f, -2.02836320e-01f, 4.64076772e-02f, -3.42745520e-02f, -1.11683644e-01f, 7.12253526e-03f, -1.84511364e-01f, -3.84419411e-02f,
  8.26763660e-02f, 1.78681184e-02f, -6.71919361e-02f, -1.62138361e-02f, -1.76980823e-01f, -2.14741409e-01f, -1.40358329e-01f, -4.40587774e-02f, -1.81632027e-01f, -7.34473988e-02f,
  -1.23218819e-01f, -1.24796085e-01f, -9.42578763e-02f, 6.91082189e-03f, -1.74959362e-01f, -8.01751092e-02f, 3.70642655e-02f, -8.25257376e-02f, -1.69319928e-01f, 1.83933124e-01f,
  -1.49813537e-02f, 3.51578668e-02f, 7.78388530e-02f, -2.82203383e-03f, -3.46195623e-02f, -4.35458049e-02f, -7.32700080e-02f, -5.44390008e-02f, -1.01914003e-01f, 2.30327551e-03f,
  -8.60999823e-02f, 1.35546580e-01f, 2.33762600e-02f, -3.37256119e-02f, -3.50020602e-02f, 3.24243843e-03f, 4.20212969e-02f, -5.46748154e-02f, 3.80720161e-02f, 7.51939863e-02f,
  4.05238532e-02f, 1.24362543e-01f, 1.41615838e-01f, -8.21908657e-03f, -4.02299650e-02f, 5.89708984e-03f, 6.84698694e-04f, 2.83660702e-02f, -1.00135207e-01f, -5.69155032e-04f,
  3.58126760e-02f, -2.92069484e-02f, 1.59956560e-01f, -1.90575689e-01f, 2.60403063e-02f, 1.32020593e-01f, 1.28038555e-01f, 5.14082704e-03f, 1.71630383e-02f, -4.53446284e-02f,
  -5.74205816e-02f, 4.92676832e-02f, 1.65997092e-02f, 7.11872382e-03f, -3.08763981e-02f, 4.79804762e-02f, -5.41983843e-02f, -1.11075744e-01f, 4.86032329e-02f, -2.35157330e-02f,
  2.91586537e-02f, -8.22185427e-02f, 2.00166218e-02f, 1.21845245e-01f, -3.95598486e-02f, -3.88036296e-02f, 2.83724293e-02f, -2.79870437e-04f, -1.15201272e-01f, 1.89129174e-01f,
  7.49958232e-02f, -3.38497400e-01f, -1.23123161e-01f, -2.28875745e-02f, -2.19987139e-01f, -7.64316395e-02f, -1.65218338e-01f, 4.96407188e-02f, -7.67916441e-02f, -1.80940926e-01f,
  -3.95958405e-03f, 9.51518044e-02f, 8.81451443e-02f, 1.48748711e-01f, 1.75658330e-01f, -1.51520655e-01f, -2.13895172e-01f, 1.47230588e-02f, 2.57892460e-01f, 2.10122004e-01f,
  -6.17664307e-02f, 5.86070418e-02f, 9.53880548e-02f, 7.98719451e-02f, -9.86381173e-02f, -5.71720209e-03f, -1.26034185e-01f, -1.70742095e-01f, -1.89884648e-01f, -3.40961665e-01f,
  2.93666661e-01f, -5.90662993e-02f, -9.47616547e-02f, -1.62194632e-02f, 6.06473209e-03f, 9.49696731e-03f, 5.44699356e-02f, -6.88456893e-02f, -3.64775136e-02f, -1.75116509e-01f,
  -2.15462279e-02f, -2.53150575e-02f, 6.57152608e-02f, 4.06115875e-02f, -1.10538334e-01f, 1.07338548e-01f, -1.06557161e-01f, -4.25867364e-02f, -9.57169682e-02f, 1.87630095e-02f,
  -5.44528812e-02f, -7.83322975e-02f, -7.37751424e-02f, -9.13977474e-02f, -2.01492459e-02f, 6.30692691e-02f, -1.60757393e-01f, 5.09835370e-02f, 2.73881257e-02f, -5.77867702e-02f,
  -5.41233271e-02f, 5.54418191e-02f, -3.10763922e-02f, -5.13579845e-02f, -3.35237347e-02f, -6.61462033e-03f, 6.24203980e-02f, -4.43717353e-02f, 1.61809940e-02f, -1.02496333e-01f,
  2.89822761e-02f, 6.89804852e-02f, -6.56718835e-02f, -7.25810453e-02f, -3.71089056e-02f, -3.94304805e-02f, 7.77793676e-03f, 1.75118614e-02f, -5.30371740e-02f, -7.93160498e-02f,
  -5.39513789e-02f, 9.83351395e-02f, -5.64597920e-02f, -5.75894192e-02f, 5.65404557e-02f, 4.93229590e-02f, 7.54345674e-03f, 7.54220039e-02f, 4.01350781e-02f, -1.54617459e-01f,
  2.32206121e-01f, -1.05879366e-01f, 5.12165986e-02f, 9.23063532e-02f, -4.12607789e-02f, -5.73600121e-02f, -1.65688079e-02f, -7.52240270e-02f, 7.29747117e-02f, 7.97118023e-02f,
  -1.05320334e-01f, 1.64165974e-01f, -5.61634749e-02f, 2.72146929e-02f, 5.54142222e-02f, 7.01787788e-03f, -4.54211868e-02f, -3.16346288e-02f, -1.63434491e-01f, -8.77471417e-02f,
  -7.64232054e-02f, 7.24164071e-04f, 1.93867296e-01f, 7.91069120e-02f, -1.08991247e-02f, 2.49729693e-01f, -5.17879575e-02f, -4.30952385e-02f, -1.22663187e-04f, 4.12195772e-02f,
  2.26073489e-01f, -1.82334378e-01f, 3.75622034e-01f, 1.92910671e-01f, 2.63234049e-01f, 1.89551786e-01f, 2.38700345e-01f, 2.11320385e-01f, -2.28089485e-02f, 8.72393232e-03f,
  -2.08025515e-01f, -2.69592077e-01f, -1.13524027e-01f, -1.98815987e-01f, -7.32345209e-02f, 4.17507514e-02f, 5.15664071e-02f, 2.10887060e-01f, 1.31441832e-01f, 9.97579321e-02f,
  -1.54227972e-01f, 6.85878322e-02f, 4.28113006e-02f, 9.81280804e-02f, -6.28897101e-02f, -4.54525165e-02f, -1.43278926e-03f, 5.52881975e-03f, -7.36264810e-02f, -1.43277124e-01f,
  -2.48986725e-02f, 1.12553410e-01f, 5.25614284e-02f, -2.38486394e-01f, -6.02370426e-02f, -7.54951388e-02f, -5.11348061e-02f, 1.27826016e-02f, -9.41604972e-02f, -7.46369436e-02f,
  8.79622344e-03f, 4.45894115e-02f, 4.98612896e-02f, -8.17454886e-03f, 2.46980097e-02f, -4.04047295e-02f, -7.01185614e-02f, 7.02865124e-02f, -8.13466609e-02f, -2.76627969e-02f,
  -1.81023210e-01f, 3.41489799e-02f, 1.21877417e-01f, 1.27773032e-01f, -4.88934703e-02f, -1.97031512e-03f, -1.11820800e-02f, 3.30301262e-02f, 6.58186376e-02f, -4.06830572e-02f,
  -1.17370524e-01f, 4.39184867e-02f, -4.59013740e-03f, 1.66932158e-02f, -8.23476631e-03f, 1.33807972e-01f, 8.38851109e-02f, 1.00293703e-01f, 4.66699116e-02f, 1.01180933e-01f,
  5.30875027e-02f, 6.01085797e-02f, 1.28399745e-01f, 8.57860446e-02f, 6.67855591e-02f, 3.95381963e-03f, 1.05432123e-01f, -1.02403298e-01f, 1.20683298e-01f, 1.17514096e-01f,
  8.58452991e-02f, 8.73767212e-02f, 5.20747295e-03f, 8.00302252e-02f, 8.00712854e-02f, 5.98840415e-02f, 2.74993852e-03f, 2.38660742e-02f, -1.68619975e-02f, 1.02410369e-01f,
  -1.18398584e-01f, 5.98195493e-02f, -2.13739257e-02f, -1.21876277e-01f, -3.17121968e-02f, -9.89783332e-02f, -5.21101523e-03f, -4.34730314e-02f, -3.31623964e-02f, 5.31858020e-02f,
  1.12770014e-01f, -6.36246651e-02f, 7.45061710e-02f, 1.07332662e-01f, 1.06303044e-01f, 1.13641389e-01f, -2.01242268e-01f, 1.04011968e-03f, -1.21622153e-01f, -6.89867586e-02f,
  -1.01661541e-01f, 1.00830272e-01f, 1.45147860e-01f, 1.07936770e-01f, -3.61267142e-02f, -2.21332051e-02f, 8.88480172e-02f, 7.95598626e-02f, -3.09920986e-03f, 3.19290981e-02f,
  -7.01773703e-01f, -1.36841163e-01f, 2.27317080e-01f, -2.48846263e-01f, -1.18819764e-02f, -1.61901731e-02f, 1.24513753e-01f, -1.14566296e-01f, -2.84022838e-01f, 3.44022661e-02f,
  3.44437286e-02f, 2.45867800e-02f, 5.30088767e-02f, 1.15030073e-01f, -3.32156606e-02f, 2.18479335e-01f, 1.99889988e-01f, -1.74166299e-02f, 2.53233854e-02f, -3.57936881e-02f,
  -7.12577924e-02f, -1.08487822e-01f, -2.77099818e-01f, -1.56504542e-01f, -1.59313288e-02f, 4.86232452e-02f, 1.05731294e-01f, -8.27713087e-02f, -1.80581994e-02f, 9.47810560e-02f,
  2.96393812e-01f, 2.49476191e-02f, 7.01213032e-02f, -2.18780518e-01f, -1.51136652e-01f, -1.93103299e-01f, 2.00121999e-02f, -1.28019109e-01f, -1.74833134e-01f, -4.27483208e-02f,
  -2.71752216e-02f, 3.84620987e-02f, -4.38621789e-02f, -3.24879549e-02f, -1.14143208e-01f, -6.58282489e-02f, -1.03168093e-01f, -3.30329537e-02f, -1.42284343e-02f, -1.23518808e-02f,
  7.08329603e-02f, -1.14271268e-01f, -2.55394187e-02f, 1.14145808e-01f, 5.38143441e-02f, -1.20872758e-01f, 1.45941181e-02f, -1.63358003e-01f, -5.71752451e-02f, 2.92369220e-02f,
  1.56673323e-02f, -9.11166966e-02f, -4.04334590e-02f, -3.51027846e-02f, 4.00685221e-02f, -2.29957346e-02f, 1.44782349e-01f, -6.14442304e-02f, 1.37795061e-01f, -1.09498464e-02f,
  4.23077084e-02f, 1.49069220e-01f, 1.24349250e-02f, -4.53659035e-02f, -2.05149241e-02f, -2.12828461e-02f, -5.85878864e-02f, -1.28235240e-02f, 1.65081676e-02f, -3.76187861e-02f,
  -6.12148643e-02f, -9.52888131e-02f, -9.84538272e-02f, 5.47763966e-02f, -1.17868468e-01f, -2.26337332e-02f, -1.19789504e-01f, -4.48124819e-02f, 5.34003936e-02f, 1.36995390e-02f,
  2.62755662e-01f, 1.70147806e-01f, 6.31829798e-02f, 5.13326749e-02f, 5.98017983e-02f, -2.76996978e-02f, -2.35657115e-02f, -1.64607521e-02f, -7.75433332e-02f, 1.50950387e-01f,
  4.42613140e-02f, -6.89650774e-02f, 4.66177277e-02f, -3.11709717e-02f, 6.38061538e-02f, 7.18619078e-02f, 5.19641005e-02f, 1.22516908e-01f, 2.64417790e-02f, -3.64733636e-02f,
  -1.23321377e-01f, -4.10966435e-03f, 1.13792382e-01f, 1.87968135e-01f, 8.61338377e-02f, 1.35590509e-01f, 9.39530879e-02f, 6.62166327e-02f, 1.66596174e-01f, 4.41675223e-02f,
  -1.71173036e-01f, -3.69384021e-01f, -2.76217633e-03f, 1.06778279e-01f, 1.67966962e-01f, 2.25289136e-01f, -1.85283586e-01f, -2.88348012e-02f, 6.15395270e-02f, -4.06324379e-02f,
  -2.97581285e-01f, -2.30406150e-01f, -1.76075026e-01f, -1.61683187e-01f, -2.47445434e-01f, -1.67818338e-01f, -7.77523220e-02f, 3.25149558e-02f, 7.28796124e-02f, 8.88266191e-02f,
  -2.66690161e-02f, -6.33044094e-02f, -7.42785111e-02f, -1.42791169e-02f, 4.24169600e-02f, -1.27532378e-01f, -4.48719077e-02f, 5.71107790e-02f, 2.59330850e-02f, -8.51463303e-02f,
  -3.45241204e-02f, -5.79583906e-02f, 1.96161512e-02f, -1.65784329e-01f, -6.84118345e-02f, 4.37459610e-02f, -3.92129011e-02f, -1.56958371e-01f, -2.04991117e-01f, 3.99900898e-02f,
  3.48300040e-02f, 3.73518430e-02f, -2.92810444e-02f, 1.34812770e-02f, 1.16525963e-01f, 1.62216723e-01f, 7.65530616e-02f, 3.27744186e-02f, 4.44296189e-02f, -2.98069175e-02f,
  -6.18409850e-02f, 1.30830437e-01f, 1.13549121e-01f, 1.57955602e-01f, 1.19445175e-01f, 1.76970467e-01f, 1.58331767e-01f, 9.07615200e-02f, 9.32611674e-02f, 1.04602002e-01f,
  -4.03904319e-02f, -1.25673607e-01f, -2.85889059e-02f, -7.98289329e-02f, -1.91567093e-02f, -4.11128029e-02f, 5.02581336e-02f, 3.27270962e-02f, -1.75334662e-02f, 9.83953550e-02f,
  1.59009889e-01f, 9.10416245e-02f, 7.49024004e-02f, -7.85359927e-03f, 1.69487804e-01f, 1.44713342e-01f, 3.54838371e-02f, -4.08173203e-02f, 8.22610036e-02f, 2.75510978e-02f,
  -2.35304497e-02f, 6.65875748e-02f, 7.13433251e-02f, 9.92571637e-02f, 3.34383249e-02f, 6.58706203e-02f, 1.30006209e-01f, -4.00625207e-02f, 6.59736469e-02f, 1.40446588e-01f,
  -1.80915862e-01f, -7.94118643e-02f, 4.67642322e-02f, -5.55272140e-02f, 2.25760825e-02f, 3.54470611e-02f, 1.40978009e-01f, -5.78121096e-02f, 2.06441842e-02f, 4.83286195e-02f,
  2.59114094e-02f, 1.04667880e-01f, -2.32180841e-02f, 1.35917574e-01f, 7.23352432e-02f, 8.85585546e-02f, -6.29727691e-02f, 4.01749322e-03f, 1.82072092e-02f, 3.48419175e-02f,
  1.37028126e-02f, -5.21762930e-02f, -1.07752807e-01f, -1.28432428e-02f, 3.32426205e-02f, 1.86124071e-03f, 5.09448983e-02f, 1.02389045e-01f, 1.09777585e-01f, -8.82312283e-02f,
  5.36015570e-01f, -2.77710766e-01f, -3.17392498e-01f, -1.49316676e-02f, -1.59139007e-01f, -7.32926652e-02f, -2.88234949e-01f, 6.06536753e-02f, 4.29501384e-02f, -2.37369195e-01f,
  9.29353014e-02f, 2.12827161e-01f, 1.34598330e-01f, 4.44374382e-02f, -2.13763751e-02f, -3.84654224e-01f, -3.08541387e-01f, 4.35916102e-03f, 2.28033766e-01f, -4.44462011e-03f,
  -7.31409267e-02f, -9.88054797e-02f, 1.95360109e-01f, 2.91094705e-02f, -1.67327359e-01f, 8.60476121e-02f, -2.51146823e-01f, -1.93990946e-01f, -1.36739567e-01f, -2.49491826e-01f,
  -1.64935812e-01f, 1.60293594e-01f, 1.57340437e-01f, 1.12553887e-01f, 1.34735201e-02f, 9.48211476e-02f, 6.68983310e-02f, -1.04203902e-01f, -4.15340327e-02f, -6.93560913e-02f,
  -2.49063279e-02f, 8.73342007e-02f, 1.13437042e-01f, 6.31392822e-02f, -4.90050390e-02f, 3.71678099e-02f, 5.07744327e-02f, -4.18790057e-03f, -9.45252553e-02f, -3.96046191e-02f,
  -1.73428096e-02f, 3.19182836e-02f, -1.37233377e-01f, -5.21854125e-02f, 8.50273073e-02f, 1.75177395e-01f, -1.23041058e-02f, 1.28131099e-02f, 1.01499602e-01f, -5.02327345e-02f,
  -1.71289556e-02f, 6.49086088e-02f, 9.46521983e-02f, 1.75356284e-01f, 1.29933864e-01f, -9.32408124e-02f, -4.32222709e-02f, -1.15287758e-01f, 1.88112929e-01f, 9.35120359e-02f,
  -1.03707649e-01f, 5.69036640e-02f, -5.86061599e-03f, -6.85380101e-02f, -2.97466051e-02f, -5.44494987e-02f, -1.04084812e-01f, -4.04805541e-02f, 5.08204401e-02f, -4.22361083e-02f,
  2.50749253e-02f, -1.34164676e-01f, -6.37504309e-02f, -6.48203418e-02f, -1.17959403e-01f, 5.04321344e-02f, -1.09967522e-01f, 4.49752249e-02f, -1.00278025e-02f, -8.98455232e-02f,
  -4.38589714e-02f, 1.34406835e-01f, 9.25186574e-02f, 8.06673914e-02f, -5.80123290e-02f, 5.55601418e-02f, 1.20306604e-01f, -2.58505773e-02f, -4.65524979e-02f, -1.93383358e-02f,
  6.50121048e-02f, 1.62415653e-01f, 7.44992122e-02f, 3.18380841e-03f, 1.37580782e-01f, 5.92349917e-02f, 4.41225320e-02f, 2.97998432e-02f, -1.16580568e-01f, -8.59151930e-02f,
  -8.35195184e-02f, -4.07818407e-02f, 5.34197316e-02f, 1.21084571e-01f, 4.71916236e-02f, 2.83691920e-02f, 6.61553964e-02f, -2.66770311e-02f, 1.48290284e-02f, -1.55325979e-01f,
  6.29905879e-01f, 9.51577947e-02f, 3.28261852e-01f, 1.40856192e-01f, 2.41859406e-01f, 3.20557505e-01f, 2.19503805e-01f, 1.97276950e-01f, 1.17867559e-01f, 1.09048299e-01f,
  1.46412104e-01f, 3.19080651e-02f, 9.62423161e-02f, 1.26967981e-01f, 5.89550734e-02f, -9.12322178e-02f, -8.58139992e-02f, 1.26600862e-01f, 1.74909085e-01f, 1.56233996e-01f,
  -9.76981148e-02f, -3.70960012e-02f, 1.34772107e-01f, 1.34136481e-02f, -8.97295028e-02f, 1.01917014e-02f, 6.48949146e-02f, -2.48856824e-02f, -1.10274620e-01f, -1.90655798e-01f,
  -1.38027146e-01f, 1.87197521e-01f, -1.69468205e-02f, -3.85197662e-02f, -8.65793005e-02f, -6.80669909e-03f, -5.09983711e-02f, -2.18229089e-02f, -4.42395918e-02f, -1.68696702e-01f,
  -9.69822779e-02f, -1.06765136e-01f, 3.33211944e-02f, -8.59859865e-03f, 2.31335070e-02f, 4.95272281e-04f, -1.82471946e-02f, 1.46154535e-03f, 9.46703702e-02f, -7.99493268e-02f,
  -9.13294107e-02f, 3.92839462e-02f, 1.14279181e-01f, 7.54209086e-02f, 5.64886481e-02f, 9.62277651e-02f, 1.63407978e-02f, 3.60800959e-02f, 3.71521562e-02f, -2.70490553e-02f,
  5.35466075e-02f, 1.03196211e-01f, 5.78756295e-02f, 1.27659336e-01f, 6.92090194e-04f, 3.83556597e-02f, -4.83126529e-02f, -1.32133797e-01f, 1.33925807e-02f, -1.27040558e-02f,
  1.49996495e-02f, -5.39910346e-02f, -6.06441088e-02f, 4.93161045e-02f, 3.31908949e-02f, 5.47436476e-02f, -3.63089219e-02f, 9.14773345e-03f, -9.72453803e-02f, 6.51731063e-03f,
  -5.83537370e-02f, 4.70617274e-03f, 8.28406140e-02f, -1.44989893e-01f, -1.35684520e-01f, 1.08571842e-01f, -4.14746478e-02f, 2.44210777e-03f, -2.75317696e-04f, -5.83942514e-03f,
  -4.18032527e-01f, 3.11793059e-01f, -6.50857091e-02f, -1.42311811e-01f, -4.62216325e-02f, -7.93212429e-02f, -4.20586653e-02f, -1.74967319e-01f, -9.01562274e-02f, -8.65062252e-02f,
  7.96529651e-02f, 1.72098931e-02f, -4.04882729e-02f, 1.97417233e-02f, -4.07815613e-02f, -3.14132981e-02f, -4.34849598e-02f, 1.15788970e-02f, -1.32128611e-01f, -1.06707923e-01f,
  -1.84045315e-01f, 1.13219775e-01f, 7.62969628e-02f, 1.40778035e-01f, -1.05703838e-01f, 1.19200479e-02f, -5.33441082e-02f, 2.45338976e-02f, 9.86211747e-02f, -3.90623473e-02f,
  3.65476668e-01f, -1.32565543e-01f, -9.33216289e-02f, 1.86384067e-01f, -2.36817971e-01f, -3.34227890e-01f, -3.91232967e-01f, 2.80795600e-02f, -2.14039553e-02f, -2.62011588e-01f,
  -1.75561756e-01f, 1.01361886e-01f, -1.86144058e-02f, -3.14098708e-02f, 5.00825467e-03f, -8.52871612e-02f, -8.37046877e-02f, 6.16082810e-02f, 1.29644185e-01f, 7.71002844e-02f,
  -1.12292804e-02f, 1.08143933e-01f, 2.98813820e-01f, 6.33717254e-02f, 2.38195574e-03f, -1.41048934e-02f, -9.18549746e-02f, 9.25173163e-02f, -3.74206267e-02f, -1.97678551e-01f,
  -1.76106080e-01f, -7.06406683e-02f, -1.02781057e-01f, 3.66307609e-02f, -1.75121531e-01f, -6.97752833e-02f, -2.33658984e-01f, 9.84390974e-02f, 1.14986680e-01f, -1.09392978e-01f,
  -7.49646202e-02f, -9.72001851e-02f, -1.42115012e-01f, -5.90281673e-02f, -2.15605814e-02f, -9.89482775e-02f, 6.31676689e-02f, 1.55189320e-01f, 1.48493811e-01f, -4.36634868e-02f,
  -1.14050031e-01f, 6.56015100e-03f, -2.16986910e-02f, -3.34559754e-02f, 4.26022448e-02f, 7.70059824e-02f, -1.25081986e-01f, -8.75054002e-02f, 1.59849957e-01f, -4.60771956e-02f,
  2.31891554e-02f, -4.98032942e-02f, -1.33852109e-01f, -1.14915438e-01f, -5.15755005e-02f, 3.10951583e-02f, -3.44807506e-02f, 1.33273050e-01f, 2.27677561e-02f, -2.23700460e-02f,
  -3.27373035e-02f, 2.15398539e-02f, 6.35139924e-03f, 7.92066753e-02f, 1.32197648e-01f, 1.74865097e-01f, 3.87871452e-02f, 1.15221463e-01f, 4.90293615e-02f, -5.36773633e-03f,
  2.07560137e-02f, 7.58123621e-02f, -6.59270957e-02f, 6.44487934e-03f, 5.59208505e-02f, 1.27055496e-01f, 2.70120408e-02f, -2.32776124e-02f, 5.20916618e-02f, 6.28527403e-02f,
  1.24006748e-01f, -2.34802142e-02f, -1.77372545e-01f, 8.48683417e-02f, -3.44162732e-02f, -9.05738696e-02f, -1.52234271e-01f, 1.99634489e-02f, -3.39613929e-02f, -1.09278910e-01f,
  -1.61840379e-01f, -1.03585877e-01f, -6.43948168e-02f, 5.53239556e-03f, -2.54392829e-02f, -1.32744402e-01f, -1.86218590e-01f, -3.77626419e-02f, 7.39476383e-02f, -1.68789789e-01f,
  1.32967636e-01f, -9.29835588e-02f, 3.13528115e-03f, -8.27298090e-02f, -1.15616642e-01f, -1.69422012e-02f, -8.20972100e-02f, -4.20598760e-02f, 2.86542997e-02f, -4.02098522e-02f,
  3.66384923e-01f, 1.66967675e-01f, 2.13512838e-01f, 1.15244165e-01f, -1.42574191e-01f, 1.88236609e-02f, 1.49926990e-01f, -8.67829397e-02f, -8.24847072e-02f, -3.26987281e-02f,
  -1.27391428e-01f, -1.90880224e-01f, -8.97397995e-02f, -2.01950625e-01f, -7.93198496e-02f, 1.34278581e-01f, 1.12008125e-01f, 1.31750599e-01f, -4.95850407e-02f, 2.93507054e-02f,
  -9.33209583e-02f, -7.43227173e-03f, 1.60592437e-01f, -2.09635720e-02f, 1.26322538e-01f, 3.33213038e-03f, -1.44217229e-02f, 5.73817119e-02f, -3.89375612e-02f, 2.01733053e-01f,
  2.36221254e-01f, 2.09566727e-01f, -2.14986473e-01f, -1.08560152e-01f, -8.76585320e-02f, 7.01942369e-02f, -2.13381946e-02f, 4.57624309e-02f, -9.81376320e-02f, 2.04743468e-03f,
  -8.95341579e-03f, 4.01972681e-02f, -9.66221001e-03f, -1.01386309e-01f, -5.50315715e-02f, -7.68093765e-02f, -2.49898825e-02f, 1.61434069e-01f, 7.72516876e-02f, 5.97882792e-02f,
  -1.19181074e-01f, -5.72845601e-02f, 2.86315549e-02f, -3.54725569e-02f, 7.65590519e-02f, -2.84205750e-02f, 1.07639693e-01f, 1.75622646e-02f, 1.27271906e-01f, 3.90562937e-02f,
  -2.91066174e-03f, -1.11957695e-02f, 6.52719215e-02f, 7.93082863e-02f, -1.05320275e-01f, -9.73564163e-02f, 1.91273424e-03f, -8.24613273e-02f, -6.63914382e-02f, 7.94706866e-02f,
  -6.24215938e-02f, -1.47018805e-01f, -1.15578115e-01f, 6.79915771e-02f, -1.21124700e-01f, -4.33929302e-02f, -1.51058538e-02f, -5.70658967e-02f, -1.93555616e-02f, 6.24458827e-02f,
  3.97963338e-02f, 3.66777927e-02f, 9.27175358e-02f, 2.03152113e-02f, -8.65703598e-02f, 3.19521762e-02f, -6.81901276e-02f, -5.60647622e-02f, -4.12703463e-04f, 9.40659195e-02f,
  -2.52016276e-01f, -2.91759878e-01f, 6.33399487e-02f, -9.77803841e-02f, -4.86774705e-02f, -8.51675570e-02f, 8.07900280e-02f, -3.58171947e-02f, -1.39353238e-02f, 1.25467062e-01f,
  7.47022405e-02f, 1.05528207e-02f, -7.16580972e-02f, -2.30296552e-02f, -4.84041646e-02f, 6.88441321e-02f, -4.45928164e-02f, -6.84441179e-02f, -1.37440532e-01f, 6.25386089e-02f,
  -2.92488150e-02f, -5.09051122e-02f, -6.79513291e-02f, -4.58413400e-02f, -1.10108644e-01f, -4.41058539e-02f, 2.92293485e-02f, -8.37806314e-02f, -8.91659688e-03f, -1.13435008e-01f,
  -4.74760532e-01f, 3.34577970e-02f, -8.84920433e-02f, -3.23642284e-01f, -1.44107705e-02f, 1.57734513e-01f, 3.74068081e-01f, 1.58846043e-02f, -1.22587100e-01f, 8.82233679e-02f,
  1.03940412e-01f, -7.07702786e-02f, -5.24300970e-02f, 1.53681234e-01f, 1.59512207e-01f, 2.65576065e-01f, 2.07016304e-01f, 3.75615316e-03f, 6.26386330e-03f, 6.57461286e-02f,
  1.52764171e-01f, -1.88848719e-01f, -2.81315565e-01f, -3.44671793e-02f, -1.27744794e-01f, -8.57400596e-02f, -5.16269580e-02f, -1.02377906e-01f, 1.49112970e-01f, 1.53604895e-02f,
  -2.22945660e-01f, -3.38203579e-01f, 1.73665106e-01f, -1.36033311e-01f, -1.28451288e-01f, 6.83631152e-02f, 4.56725806e-02f, -8.14271420e-02f, -1.77796017e-02f, -9.73989293e-02f,
  -1.23469919e-01f, -6.89132437e-02f, 8.37012231e-02f, -7.81687573e-02f, -1.07467517e-01f, 9.70358029e-03f, -1.59491956e-01f, -5.69036268e-02f, -4.08202969e-02f, 2.78841350e-02f,
  9.80194360e-02f, -1.42954424e-01f, -1.14078656e-01f, 1.48783373e-02f, 1.09022774e-01f, -2.14597419e-01f, -3.59909087e-02f, -8.93554315e-02f, -3.86598893e-02f, -1.64448887e-01f,
  4.35654037e-02f, 8.77282321e-02f, 9.28636491e-02f, 1.24496914e-01f, 9.64695811e-02f, 5.46483183e-03f, 3.15236375e-02f, 1.00785576e-01f, 3.24139483e-02f, -8.51232186e-02f,
  9.21340100e-03f, 4.61674370e-02f, 4.72338982e-02f, -7.08264038e-02f, -7.69528225e-02f, -1.65493339e-02f, 4.63911220e-02f, 4.45251726e-02f, 6.02684021e-02f, -1.89351551e-02f,
  -9.73859150e-03f, 6.25151098e-02f, -4.70957644e-02f, 1.40198007e-01f, 1.65933400e-01f, 7.84310624e-02f, -2.05792058e-02f, 6.74035819e-03f, -6.64554685e-02f, -1.52433544e-01f,
  -5.87673001e-02f, 1.51901543e-01f, -8.00345317e-02f, 1.35415331e-01f, -4.39345464e-02f, -6.25344086e-03f, -1.52145356e-01f, 6.64717779e-02f, -6.84897602e-02f, -1.37544367e-02f,
  7.90124014e-03f, -2.72423439e-02f, -5.64209558e-02f, 2.42765788e-02f, 8.12814236e-02f, -7.08754808e-02f, 8.77611265e-02f, -8.87968466e-02f, 1.37322828e-01f, -2.72833388e-02f,
  -2.23516524e-02f, 4.19750139e-02f, -5.29174134e-02f, 6.68677688e-02f, 1.48142502e-02f, 2.03891844e-03f, -2.06938502e-03f, 9.62503105e-02f, 1.39991641e-01f, 5.69430590e-02f,
  5.63410930e-02f, -1.91898480e-01f, -3.60108286e-01f, 1.20301850e-01f, -3.60352546e-02f, -1.85191765e-01f, -2.28272513e-01f, -3.82757522e-02f, 2.89896309e-01f, -9.10058692e-02f,
  8.29351097e-02f, 1.99285761e-01f, 6.25978503e-03f, -5.07082092e-03f, -1.55684277e-01f, -2.72764742e-01f, -2.53709197e-01f, -1.45746246e-01f, 7.23923892e-02f, 2.10580528e-01f,
  2.47309223e-01f, 1.76955402e-01f, 1.37107819e-01f, 8.26214924e-02f, 1.62125722e-01f, 1.25154793e-01f, -7.75946528e-02f, -1.26183201e-02f, -5.58478013e-02f, -2.21601382e-01f,
  -3.18210304e-01f, 3.42651922e-03f, 9.49147046e-02f, 1.73655465e-01f, 7.24294260e-02f, 5.19271046e-02f, 2.06713259e-01f, 1.63169712e-01f, -3.16067263e-02f, 1.39361890e-02f,
  -5.52333817e-02f, 1.03950292e-01f, 7.67934993e-02f, -7.50292689e-02f, 1.59680188e-01f, 2.24394388e-02f, -8.13083276e-02f, -2.44913429e-01f, -3.43621850e-01f, -2.10334565e-02f,
  1.22124419e-01f, -3.24319489e-02f, -1.99397758e-01f, -1.24584742e-01f, -2.61837244e-01f, 5.55359907e-02f, -7.51604214e-02f, -1.24049082e-01f, -2.10393593e-01f, -1.23190343e-01f,
  7.14512691e-02f, -3.29722203e-02f, -9.05112103e-02f, -2.63871551e-02f, 2.60513928e-02f, -6.25253376e-03f, 1.81985609e-02f, 1.73808038e-02f, -8.92802626e-02f, -7.63740540e-02f,
  1.53120337e-02f, -5.90250902e-02f, -1.07258111e-01f, -4.92586978e-02f, -5.30960783e-03f, 4.68539484e-02f, -1.31909654e-01f, 1.63845718e-02f, -1.83925465e-01f, -6.70094639e-02f,
  -2.43701860e-02f, 4.38769162e-02f, -6.76823705e-02f, 2.66249459e-02f, -4.55847085e-02f, -1.07061543e-01f, 5.69926724e-02f, 6.12078840e-03f, -6.19557966e-03f, 1.21773176e-01f,
  6.44569993e-02f, -4.03530821e-02f, -1.26541138e-01f, 3.68629163e-03f, -6.05309233e-02f, 4.19057235e-02f, -6.52709603e-02f, 6.77894149e-03f, -7.67373070e-02f, -4.46146652e-02f,
  -8.22301134e-02f, -9.03191417e-02f, -1.01625443e-01f, 7.84318242e-03f, 1.13866828e-01f, 8.32512751e-02f, -3.11123580e-02f, -1.79369837e-01f, -2.05432639e-01f, 1.93402216e-01f,
  -6.01239577e-02f, -1.52122214e-01f, -1.66637570e-01f, -2.36855730e-01f, 2.03792062e-02f, -6.41561970e-02f, -4.48496863e-02f, -1.60049275e-01f, -1.94583371e-01f, -1.12791896e-01f,
  8.03290829e-02f, -4.89843279e-01f, 4.01715934e-01f, 1.54584453e-01f, 8.03950354e-02f, 1.25513479e-01f, -2.72170931e-01f, -4.78476472e-03f, -2.93827932e-02f, -1.31728590e-01f,
  -2.88712442e-01f, -4.05606776e-01f, -2.20491260e-01f, -2.07581252e-01f, -8.43006372e-02f, 2.39133555e-02f, 1.82793796e-01f, 3.50101590e-01f, 4.07808065e-01f, 1.11962549e-01f,
  -4.63543646e-02f, 1.63719296e-01f, 3.20063561e-01f, 1.46933138e-01f, -9.05098021e-02f, -1.39179388e-02f, 1.54294327e-01f, 9.23842117e-02f, -9.63350311e-02f, -1.23561516e-01f,
  -8.89814869e-02f, -2.61204362e-01f, 2.33964190e-01f, -7.89108500e-02f, -1.01854675e-01f, -1.10568844e-01f, -1.05151264e-02f, 1.16974980e-01f, -8.08122680e-02f, -2.85315346e-02f,
  -6.93964809e-02f, -5.40760905e-02f, -1.42386049e-01f, -7.79717192e-02f, -2.88295522e-02f, -4.14879508e-02f, -5.45341475e-03f, -4.10411656e-02f, -1.19092070e-01f, -2.33361855e-01f,
  -2.58174777e-01f, -7.21664056e-02f, -2.88749598e-02f, -5.63876927e-02f, -1.71979025e-01f, 1.16500460e-01f, -2.10678354e-01f, -1.21485196e-01f, -2.71651540e-02f, -5.87076284e-02f,
  4.92476895e-02f, -1.82944201e-02f, -8.20767283e-02f, 3.30319107e-02f, -2.49343440e-02f, -9.14449058e-03f, -4.59117256e-02f, -8.07420388e-02f, -4.30828966e-02f, -1.09018639e-01f,
  -9.57726222e-03f, 1.62481759e-02f, -8.74136314e-02f, 1.57244690e-02f, -5.06457314e-02f, -1.12076871e-01f, -7.71928877e-02f, -7.38747045e-02f, 1.66710243e-02f, -1.18697017e-01f,
  -1.12711281e-01f, 4.68116105e-02f, -1.88178588e-02f, -9.08911824e-02f, 1.86264534e-02f, -1.77265164e-02f, -9.16572884e-02f, -8.50721076e-02f, -9.05642584e-02f, -3.50705944e-02f,
  -1.51511699e-01f, 2.74093956e-01f, 6.45955876e-02f, -1.62143007e-01f, 4.48264256e-02f, -1.20713264e-01f, -1.03677295e-01f, 3.35198976e-02f, -2.79027992e-03f, 2.01880373e-02f,
  6.80628195e-02f, 2.37604901e-02f, 3.75532769e-02f, -6.76217973e-02f, 9.78319645e-02f, 1.09838448e-01f, -1.15828164e-01f, -2.70724185e-02f, 4.70030047e-02f, -7.91931152e-02f,
  -1.65811945e-02f, 4.72215936e-03f, 6.59882203e-02f, 1.26339853e-01f, -1.05376225e-02f, 1.14424363e-01f, 1.73915565e-01f, 1.30868763e-01f, 2.26193488e-01f, 2.29910448e-01f,
  3.41059208e-01f, 2.92951614e-01f, 1.79363981e-01f, 1.55236796e-02f, 4.53382498e-03f, 1.95827723e-01f, 3.66402686e-01f, 1.99657544e-01f, -8.88735577e-02f, 6.40603006e-02f,
  1.83895066e-01f, -9.50247198e-02f, -5.38942330e-02f, 2.55113225e-02f, 9.66841057e-02f, -4.14754078e-02f, -2.13788241e-01f, -2.94696987e-02f, -1.48446625e-02f, 1.74636394e-02f,
  3.78337987e-02f, 1.41196296e-01f, 1.05604924e-01f, -5.61039969e-02f, -9.14451927e-02f, -3.22614349e-02f, 1.84343830e-02f, 1.35709807e-01f, -4.76798750e-02f, -9.41565558e-02f,
  1.43813282e-01f, 4.01210696e-01f, -2.46736541e-01f, -1.20820187e-01f, 1.38231620e-01f, -8.64750519e-02f, -8.22967887e-02f, 1.60359035e-04f, 2.20891070e-02f, -2.15042233e-02f,
  -1.30105074e-02f, 1.87329892e-02f, 1.35705382e-01f, 1.04259811e-01f, 1.01570792e-01f, 1.32700041e-01f, -5.05708065e-03f, -2.00114399e-03f, 4.35716584e-02f, 1.27105013e-01f,
  -2.67020110e-02f, 1.03507377e-01f, 1.02963306e-01f, -8.82317033e-03f, -6.59059454e-03f, -1.20022811e-01f, -1.60774197e-02f, 6.91852048e-02f, -2.61477139e-02f, 6.86569735e-02f,
  -6.21319860e-02f, 6.46659210e-02f, 8.59437510e-03f, -7.84738082e-03f, 8.23679790e-02f, -2.97697298e-02f, 2.34852778e-04f, 1.46637363e-02f, -1.71501655e-02f, 8.68414640e-02f,
  -1.19708359e-01f, 3.53096658e-03f, 5.21835014e-02f, 1.07485704e-01f, -1.15138993e-01f, -1.08828554e-02f, 7.95473531e-02f, -7.15345703e-03f, 3.16881798e-02f, 1.08012423e-01f,
  -8.44914280e-03f, -9.65965316e-02f, 8.36255495e-03f, 7.28980005e-02f, -3.77806425e-02f, 3.31867449e-02f, 2.21630204e-02f, 8.51731747e-03f, 9.78324637e-02f, 3.46033368e-03f,
  3.72005925e-02f, 1.64776057e-01f, -2.35252723e-01f, -1.47330388e-01f, 2.50193453e-03f, 4.46165688e-02f, -1.08263738e-01f, -1.13324389e-01f, -6.78007752e-02f, -1.02346458e-01f,
  4.29937914e-02f, -5.50430119e-02f, 9.30975080e-02f, -5.85366972e-03f, -1.79005876e-01f, -1.28415048e-01f, 2.44415067e-02f, -1.06670253e-01f, -5.05803488e-02f, -1.22973077e-01f,
  -6.47421703e-02f, -1.18917331e-01f, -9.95951146e-02f, -1.55926868e-01f, -1.03421137e-01f, -2.78525770e-01f, -4.01572920e-02f, -1.17696285e-01f, 4.91322763e-02f, -9.25505087e-02f,
  -3.95002156e-01f, -2.58644164e-01f, 8.95000175e-02f, -1.54487208e-01f, 8.44943225e-02f, 2.01617360e-01f, 2.80216694e-01f, 5.17542064e-02f, 3.99479307e-02f, -8.84007942e-03f,
  -1.95680484e-01f, -1.83806047e-01f, -9.66936424e-02f, -7.81406313e-02f, -2.62097474e-02f, 1.13736987e-01f, 6.83542266e-02f, 1.61958218e-01f, 2.67178178e-01f, 2.50792593e-01f,
  1.50822520e-01f, 1.39093609e-03f, -4.66755703e-02f, -2.83115990e-02f, 5.95769137e-02f, -5.65013029e-02f, -8.64465237e-02f, -3.89900766e-02f, -1.94846123e-01f, -1.60213962e-01f,
  3.78864072e-02f, -3.43033433e-01f, -8.03023577e-02f, -2.17128858e-01f, -5.79514657e-04f, -1.66100696e-01f, -8.42722952e-02f, -5.40299639e-02f, -2.09963415e-02f, 4.06124815e-02f,
  -1.64516076e-01f, -1.46395070e-02f, -2.69030277e-02f, -7.05706105e-02f, 3.72294756e-03f, -7.78766945e-02f, -1.13988414e-01f, 1.73969846e-02f, -7.85352290e-02f, 4.77616675e-02f,
  -7.26020113e-02f, 9.47643258e-03f, 2.16421112e-02f, 1.15707025e-01f, -8.40850472e-02f, 2.11922154e-02f, 5.23885228e-02f, -1.59296338e-02f, -5.44943996e-02f, 1.35928512e-01f,
  9.77133866e-03f, -8.08477327e-02f, -1.89709496e-02f, -3.94714512e-02f, 6.29424825e-02f, -2.64362637e-02f, -3.31578515e-02f, 9.31216106e-02f, 1.80276304e-01f, 4.41989116e-03f,
  3.75765860e-02f, 3.28106573e-03f, 2.46584490e-02f, -2.49453820e-02f, 4.53643277e-02f, -9.67702419e-02f, -1.06026836e-01f, 9.05857523e-05f, -1.30317912e-01f, -7.30224922e-02f,
  -5.39137051e-02f, -1.45424185e-02f, 7.99975023e-02f, 3.79914306e-02f, -1.09420612e-01f, -4.32845280e-02f, 3.28447893e-02f, -7.27766678e-02f, 2.66397595e-02f, 1.97110418e-03f,
  1.33717492e-01f, -3.10489267e-01f, -6.09433576e-02f, -5.45768533e-03f, 7.67681887e-03f, -3.14216176e-03f, -1.33008391e-01f, -4.67726812e-02f, 2.73905266e-02f, 5.54143451e-02f,
  -1.13044888e-01f, 4.83637303e-02f, -2.52888328e-03f, -5.54678962e-02f, 1.57482266e-01f, -3.36912237e-02f, -2.02545464e-01f, -1.62419938e-02f, -6.43086582e-02f, -2.51246225e-02f,
  -8.82890448e-03f, 6.23227283e-02f, 2.21388623e-01f, 9.95032340e-02f, 2.30477396e-02f, -1.16690714e-02f, 2.35398099e-01f, 1.25853881e-01f, 5.39142266e-02f, 2.18424737e-01f,
  -1.82201549e-01f, -2.65949517e-01f, -2.36688793e-01f, -3.38635832e-01f, -2.16875181e-01f, 3.69648077e-02f, -3.89970280e-02f, 1.14193097e-01f, -2.27253400e-02f, -2.82072902e-01f,
  -1.88901708e-01f, 3.46686170e-02f, -1.33146727e-02f, 1.31382227e-01f, 1.39715642e-01f, -3.76434863e-01f, -2.38915280e-01f, -1.88520327e-02f, 1.57991424e-01f, 1.43440664e-01f,
  5.57955243e-02f, -8.69924650e-02f, 1.27039075e-01f, 9.95277800e-03f, -2.44808137e-01f, 1.73327867e-02f, -1.93517506e-01f, -1.13360286e-01f, 3.97051834e-02f, -3.79437625e-01f,
  -3.62973899e-01f, -9.28465053e-02f, 3.12482230e-02f, 7.62494057e-02f, -2.03641981e-01f, 3.39146890e-02f, -2.06179861e-02f, -1.34299457e-01f, 4.89592133e-03f, -6.15238324e-02f,
  -1.32275015e-01f, 1.03331871e-01f, -8.43677521e-02f, -8.06188062e-02f, -1.44948050e-01f, 3.39723453e-02f, 5.84864728e-02f, -1.29641108e-02f, 8.88260156e-02f, 2.05909424e-02f,
  6.97950721e-02f, -7.90375024e-02f, 2.19210070e-02f, 1.15668222e-01f, 2.95527354e-02f, 2.24391054e-02f, 5.32350652e-02f, 1.63906768e-01f, 1.33626401e-01f, -9.85131934e-02f,
  3.57676744e-02f, -2.54865158e-02f, 6.39135344e-03f, 4.30719033e-02f, 1.69310514e-02f, 1.04357205e-01f, -1.41240329e-01f, 1.26942564e-02f, 5.91165200e-02f, -7.44306222e-02f,
  4.90913950e-02f, 2.83853654e-02f, 4.71748635e-02f, -7.54979998e-02f, 5.81594408e-02f, -4.14988250e-02f, -8.02305043e-02f, -6.84570447e-02f, -5.93774952e-04f, 4.98257950e-02f,
  8.58599395e-02f, 7.77901337e-02f, -4.21957225e-02f, 1.82622448e-02f, -2.85267853e-03f, -6.07452448e-03f, -7.20833391e-02f, 8.52686632e-03f, -3.99734117e-02f, -3.23326215e-02f,
  -2.33594000e-01f, 1.24686740e-01f, -2.95936912e-01f, 1.06741227e-02f, -1.93060935e-01f, 1.89380869e-02f, -8.50626081e-02f, -1.09502234e-01f, -8.33775103e-02f, -2.09042672e-02f,
  1.32904559e-01f, 7.86754712e-02f, -9.42941532e-02f, 9.50767100e-02f, 2.41908934e-02f, 8.06740746e-02f, -2.07688585e-02f, -7.06546232e-02f, 1.69571832e-01f, 6.54467866e-02f,
  9.92323309e-02f, 1.00248151e-01f, 1.63324941e-02f, -1.85773168e-02f, 1.06954731e-01f, 5.41287363e-02f, -2.71542440e-03f, 1.94453150e-02f, 6.49176314e-02f, -1.82382748e-01f,
  -3.68909985e-01f, 4.38864768e-01f, 1.02484986e-01f, -1.87926084e-01f, 3.74038577e-01f, 4.16612148e-01f, 5.81791222e-01f, 1.76363692e-01f, -1.11320108e-01f, 4.07486819e-02f,
  -1.24855274e-02f, -1.43941626e-01f, -1.44963190e-01f, -4.28961182e-04f, 2.85504758e-02f, 1.59424633e-01f, 7.40225166e-02f, -5.64149767e-03f, -2.31164694e-01f, -1.02862358e-01f,
  3.01111850e-05f, -1.07248634e-01f, -2.21908584e-01f, -5.64555638e-02f, -8.80513489e-02f, -8.26782361e-02f, -2.56209429e-02f, 3.44625190e-02f, 1.28560841e-01f, -7.68368086e-03f,
  -1.36290923e-01f, 7.52350241e-02f, -1.60818398e-01f, -1.41186923e-01f, 1.83889605e-02f, -1.00101441e-01f, -3.48590240e-02f, -1.28664657e-01f, 1.23861129e-04f, -7.87889883e-02f,
  6.68948283e-03f, -1.06546752e-01f, 3.98706552e-03f, -1.82892121e-02f, -6.93455618e-03f, -7.77133331e-02f, 1.51819140e-02f, -1.25006601e-01f, -2.21352309e-01f, -1.29185751e-01f,
  1.17048435e-01f, 5.18136024e-02f, 7.32055902e-02f, 1.09307468e-01f, 2.29889136e-02f, -9.22137126e-02f, 8.32914263e-02f, -1.67065680e-01f, -6.30629016e-04f, -2.49039680e-01f,
  -1.52279940e-02f, 6.93610534e-02f, 6.59388527e-02f, -3.47098261e-02f, -1.06154948e-01f, 1.16745699e-02f, 1.22086098e-02f, -4.14498150e-02f, 4.22229767e-02f, 2.92862710e-02f,
  4.71455716e-02f, -4.45566028e-02f, -1.03152193e-01f, 5.58920857e-03f, 5.14006689e-02f, -3.34184654e-02f, -4.93168645e-03f, 4.36903834e-02f, -3.27594280e-02f, 5.76118603e-02f,
  -4.80812937e-02f, 3.09517048e-02f, -1.32747022e-02f, -3.83234099e-02f, -5.83481602e-02f, 6.09725191e-07f, -6.05749115e-02f, 5.40544605e-03f, 6.44182563e-02f, -1.88152604e-02f,
  -2.84043074e-01f, 3.42522323e-01f, -1.65666148e-01f, 2.34570056e-02f, 1.06103845e-01f, -9.27090272e-03f, 1.05354674e-01f, 1.19207077e-01f, 1.43296883e-01f, -8.43766257e-02f,
  -6.45172000e-02f, 2.68321838e-02f, 2.71272585e-02f, -1.52163645e-02f, -1.14444392e-02f, -2.01430004e-02f, 1.70208290e-01f, 7.68679678e-02f, -8.49067122e-02f, -6.64212108e-02f,
  3.85861211e-02f, -7.25362673e-02f, -2.40630105e-01f, -2.93522179e-02f, -8.86987448e-02f, -1.40920535e-01f, 2.29307767e-02f, -5.44949025e-02f, -5.86764142e-02f, -1.01902597e-01f,
  -1.05919972e-01f, 1.18293978e-01f, -1.49626389e-01f, 5.28124794e-02f, 2.36644998e-01f, 1.18386500e-01f, 3.68078647e-04f, 3.90871018e-02f, 6.00134954e-02f, -1.50714647e-02f,
  5.59384264e-02f, 1.15849800e-01f, 3.97660360e-02f, -3.36586051e-02f, -2.67812200e-02f, -1.74204595e-02f, 8.46303329e-02f, -1.45344809e-01f, -1.27182230e-01f, -4.94817793e-02f,
  1.52861685e-01f, 1.93290766e-02f, -1.89619750e-01f, -1.70424804e-02f, 8.19704980e-02f, 1.01036981e-01f, 6.79085329e-02f, 1.12605430e-01f, 1.98965326e-01f, 1.66303203e-01f,
  -2.57096738e-01f, -2.65169859e-01f, 1.77056715e-02f, 8.69943425e-02f, -2.39242762e-02f, -5.97983487e-02f, -4.30724248e-02f, -2.26097226e-01f, -2.38946397e-02f, -4.42958735e-02f,
  -4.85816300e-02f, -9.33940038e-02f, 1.45881951e-01f, -9.07646045e-02f, -6.97558466e-03f, 3.08200121e-02f, -9.33799818e-02f, -1.18335217e-01f, -1.26915663e-01f, -9.31845084e-02f,
  1.78558111e-01f, 8.47175196e-02f, -9.83096585e-02f, -1.23636596e-01f, 1.56855453e-02f, 1.01438155e-02f, 3.71289030e-02f, -1.27893850e-01f, -1.52473450e-01f, -8.30950439e-02f,
  -1.45707587e-02f, 3.28980237e-02f, 1.14233240e-01f, 1.03203654e-01f, -1.93841476e-02f, 2.82638222e-02f, -5.87238893e-02f, 4.41225544e-02f, 2.24748254e-02f, 1.26340277e-02f,
  -4.81536612e-02f, 1.75161415e-03f, -8.34838301e-02f, -1.57725401e-02f, 7.34465644e-02f, -9.52905193e-02f, 5.26258312e-02f, 4.55319062e-02f, -3.52890454e-02f, -5.28230667e-02f,
  -4.97521758e-02f, -8.05078670e-02f, -4.31426056e-02f, 2.34533604e-02f, -7.28500215e-03f, 4.05057706e-03f, -8.28312263e-02f, -1.07547641e-02f, -1.11918613e-01f, -4.87082042e-02f,
  -2.65766345e-02f, -1.38936713e-01f, -1.50929131e-02f, 8.36375207e-02f, 4.47333977e-02f, 4.42929380e-02f, 1.15753785e-01f, -8.47970545e-02f, 3.79496962e-02f, -1.20183796e-01f,
  -9.49882641e-02f, -6.61079818e-03f, 3.23913023e-02f, -7.97717646e-02f, -5.77815995e-02f, -3.60245854e-02f, 1.95756122e-01f, 8.93838145e-03f, 4.77666147e-02f, -1.13167457e-01f,
  -1.03515677e-01f, 7.64678493e-02f, 4.44274694e-02f, 4.62376792e-03f, 1.20547645e-01f, 3.33556486e-03f, -6.41749147e-03f, -4.92337905e-02f, -1.16773978e-01f, -1.12146683e-01f,
  -3.34389091e-01f, -8.22014660e-02f, -2.89389733e-02f, 7.96576664e-02f, 2.21636832e-01f, 1.86523125e-01f, -3.28219086e-02f, -3.74334008e-02f, -4.57987413e-02f, 1.12139601e-02f,
  1.55241087e-01f, 1.30453169e-01f, 1.06305830e-01f, 7.57615119e-02f, -1.51132699e-02f, 4.37245890e-02f, 1.54827923e-01f, -1.88720338e-02f, -4.31094132e-02f, 1.35445714e-01f,
  1.64374292e-01f, -6.45308476e-03f, -2.21188575e-01f, -8.95372182e-02f, 1.00014754e-01f, -1.17267845e-02f, -4.35120687e-02f, -3.76209691e-02f, 1.28711000e-01f, 1.45296946e-01f,
  -6.56011701e-02f, -2.25270405e-01f, 1.92598596e-01f, 9.17829648e-02f, 9.30906609e-02f, -6.56727776e-02f, 5.45659550e-02f, -1.22344747e-01f, 2.29853094e-02f, -3.88720213e-03f,
  -3.47224511e-02f, -1.24887258e-01f, 1.07466318e-01f, 6.04264857e-03f, -5.29096052e-02f, -2.23589223e-02f, -9.03937444e-02f, -1.31862089e-01f, -1.85082674e-01f, -1.62648812e-01f,
  2.74421573e-01f, 8.77514184e-02f, -1.05298162e-01f, -4.44190726e-02f, -2.08067466e-02f, 2.11706068e-02f, -9.08860192e-02f, -1.86843455e-01f, -1.33811086e-01f, -1.37577757e-01f,
  -4.16958220e-02f, -8.37803166e-03f, -2.56651808e-02f, -3.23307216e-02f, -6.68226928e-02f, 4.65931296e-02f, 1.06375283e-02f, 1.53699264e-01f, 1.77145168e-01f, -2.62277876e-03f,
  2.27316450e-02f, 2.95884460e-02f, -2.92154104e-02f, -6.74836487e-02f, 1.32179573e-01f, 4.21256721e-02f, 8.00807476e-02f, -1.18247010e-01f, -5.00639267e-02f, 5.37031889e-02f,
  3.88573371e-02f, 1.09442577e-01f, -3.86887304e-02f, 1.03303909e-01f, 2.28515845e-02f, -1.20615568e-02f, 5.79671822e-02f, -1.98650709e-03f, -9.44945589e-03f, -1.17250517e-01f,
  -1.97590441e-01f, 4.24273163e-02f, -3.99675295e-02f, -2.23704055e-02f, 3.96910077e-03f, -2.87583806e-02f, -8.74207690e-02f, 2.67924815e-02f, -4.06906493e-02f, -8.17115605e-02f,
  -6.75644428e-02f, -1.02045275e-01f, 2.46014763e-02f, 8.24989527e-02f, 8.38421136e-02f, -8.94033164e-02f, 1.63005721e-02f, 3.30974348e-02f, 6.76852390e-02f, -9.43941325e-02f,
  1.22263275e-01f, -3.35443541e-02f, -4.02333625e-02f, -4.25399691e-02f, -1.00504048e-02f, 4.50872853e-02f, -9.75023657e-02f, -1.78517103e-01f, -2.27230147e-01f, -2.23567575e-01f,
  -4.63037975e-02f, -3.73354740e-02f, -8.98566172e-02f, 8.26467946e-02f, 2.26750270e-01f, 1.79861203e-01f, 2.31819466e-01f, 2.51347516e-02f, 5.96171170e-02f, 1.18120618e-01f,
  1.09226540e-01f, 6.81609362e-02f, 1.35391086e-01f, 1.15761258e-01f, 7.90167451e-02f, 1.36099949e-01f, 1.02536395e-01f, -1.21758087e-03f, 6.10441007e-02f, 3.81352752e-02f,
  1.36961177e-01f, 1.37642333e-02f, -1.25474840e-01f, 9.66945440e-02f, 5.34040146e-02f, 5.45286387e-02f, -4.23149765e-02f, 8.31039399e-02f, -6.44363509e-03f, 5.53091317e-02f,
  -1.89537406e-01f, -2.67752679e-03f, -3.84217896e-03f, -8.40461254e-03f, -9.56793204e-02f, -1.35081649e-01f, -1.06006317e-01f, -7.75930583e-02f, 1.84263978e-02f, -7.06998110e-02f,
  -9.14815664e-02f, -3.34354378e-02f, -9.23012476e-03f, -1.24749094e-02f, -4.09203731e-02f, -1.53854623e-01f, -1.06498837e-01f, 5.81994429e-02f, 4.51701395e-02f, 6.04046024e-02f,
  2.72614695e-02f, 4.96036187e-02f, -5.90735562e-02f, -1.80037841e-02f, 1.84983164e-02f, 3.57341096e-02f, -8.29583481e-02f, 6.78206049e-03f, 5.15269935e-02f, 3.09696910e-03f,
  5.62437028e-02f, 2.38072984e-02f, -1.33082196e-02f, 1.08620644e-01f, -5.02538588e-03f, 5.71293049e-02f, -6.58032373e-02f, 9.89571512e-02f, 1.16297327e-01f, -2.17968738e-03f,
  7.06960708e-02f, 1.15907706e-01f, 7.69296736e-02f, -8.22089612e-03f, 7.64090270e-02f, 3.32492553e-02f, 6.98637515e-02f, -3.09424587e-02f, 2.27853823e-02f, 2.90901978e-02f,
  -3.73955406e-02f, 5.22553623e-02f, -1.39285594e-01f, 9.05719325e-02f, 1.37552008e-01f, 1.09225497e-01f, 9.53937545e-02f, -5.35458289e-02f, -2.90361512e-02f, -7.94041753e-02f,
  1.06655069e-01f, -1.27658676e-02f, 3.68564613e-02f, 6.77809492e-02f, -7.25121051e-03f, -2.02886403e-01f, 8.46581310e-02f, -7.99047947e-02f, -1.73813552e-01f, -1.22809313e-01f,
  -5.37568890e-02f, -1.49418399e-01f, -3.75988781e-02f, -1.45699471e-01f, -5.33072054e-02f, -1.67741492e-01f, -1.39241993e-01f, 8.80084261e-02f, 4.28523757e-02f, -1.38809338e-01f,
  -1.05870757e-02f, 5.75313792e-02f, 1.15468629e-01f, -2.40622591e-02f, 3.11818551e-02f, -4.87449095e-02f, -1.69109955e-01f, -4.05008271e-02f, -3.94203588e-02f, -1.09649420e-01f,
  1.93573862e-01f, 1.87307209e-01f, 2.88698882e-01f, 1.03084609e-01f, 2.59941399e-01f, 3.72586697e-01f, 3.87357265e-01f, 2.15153679e-01f, -7.59004354e-02f, 4.85301986e-02f,
  -1.35979787e-01f, -3.84682029e-01f, -3.25619608e-01f, -1.87120706e-01f, -1.27476826e-01f, 7.25607276e-02f, 1.44933194e-01f, 4.87308688e-02f, 1.55276000e-01f, 1.70954719e-01f,
  -5.97416535e-02f, 1.15852855e-01f, 6.04301915e-02f, -4.97164093e-02f, -7.61391670e-02f, -2.14796439e-01f, 1.20233759e-01f, 1.08695745e-01f, -2.55240854e-02f, -8.85926560e-02f,
  -4.74174283e-02f, 1.42830685e-01f, -1.92539275e-01f, -1.18706703e-01f, 1.50025226e-02f, 1.68327186e-02f, -1.07302219e-01f, 8.26458260e-02f, 7.28684440e-02f, 8.25788602e-02f,
  -4.14900761e-03f, 4.76144552e-02f, -9.89972353e-02f, 9.56052020e-02f, 1.24115445e-01f, 8.85760114e-02f, 2.74746921e-02f, 1.49393290e-01f, 4.01201360e-02f, -8.20115674e-03f,
  -2.17830893e-02f, 1.03962012e-01f, 2.69324392e-01f, -5.25093712e-02f, -6.95835277e-02f, -1.09483942e-01f, 1.71947237e-02f, -1.07544633e-02f, -8.08264315e-02f, 6.16568364e-02f,
  -2.53015999e-02f, 9.70661864e-02f, -1.34693667e-01f, -1.45401224e-01f, -1.02173254e-01f, 6.12905584e-02f, -2.11612228e-02f, -3.92688118e-04f, -1.48468256e-01f, 5.49267940e-02f,
  5.34976237e-02f, -5.81111386e-02f, 4.16247025e-02f, -1.87790021e-02f, -2.52100110e-01f, 5.01117148e-02f, 1.19201019e-01f, 2.47752611e-02f, -1.13171220e-01f, -6.18475117e-02f,
  -6.66134953e-02f, 1.28067762e-01f, -6.18379824e-02f, 3.83464396e-02f, -4.04194258e-02f, 2.53835646e-03f, -8.80976692e-02f, 2.78627146e-02f, -7.36348405e-02f, 6.34906068e-02f,
  -8.68446231e-02f, -3.59123915e-01f, -2.60275483e-01f, -2.11388860e-02f, 9.03713331e-02f, -3.70433293e-02f, -2.45603412e-01f, -9.36038420e-02f, 8.30504522e-02f, 5.62527925e-02f,
  9.67606204e-04f, -6.58707842e-02f, 8.88055842e-03f, -7.19541833e-02f, -3.84588800e-02f, 5.44306077e-02f, 1.48779564e-02f, 3.95878740e-02f, 6.02237545e-02f, 7.96193033e-02f,
  -7.02552497e-03f, 6.81541488e-02f, 8.75673816e-02f, -7.19309300e-02f, 1.76959801e-02f, -3.87054421e-02f, -2.06140690e-02f, 1.27580106e-01f, 4.33350615e-02f, -2.01140773e-02f,
  -6.90018475e-01f, -9.47095081e-02f, -4.62615825e-02f, -8.46868828e-02f, 1.80665255e-01f, 2.19759107e-01f, 1.45546868e-01f, 9.45575163e-02f, 2.98236543e-03f, -3.45032662e-02f,
  -2.56694183e-02f, -9.91968717e-03f, 1.18590429e-01f, 2.03209385e-01f, 1.49259046e-01f, 2.32636318e-01f, 2.13283002e-01f, 6.04445301e-03f, 1.18720770e-01f, 1.74530372e-01f,
  1.04377076e-01f, 7.39258751e-02f, -2.02655345e-01f, 2.05459818e-02f, 2.96593383e-02f, 8.41088071e-02f, 1.27264857e-01f, 3.38277631e-02f, 3.54278609e-02f, 8.88899118e-02f,
  3.09020489e-01f, -1.52788013e-01f, 2.46348605e-02f, -9.01347771e-02f, -8.65231231e-02f, -1.95104972e-01f, -8.92195851e-02f, -8.40039253e-02f, -1.33720368e-01f, 1.00826740e-01f,
  -1.17769696e-01f, -2.53558550e-02f, -5.49749099e-02f, 1.31325210e-02f, -6.15949705e-02f, -9.97053087e-02f, -3.04445084e-02f, -1.27604213e-02f, 2.00523138e-02f, 1.10454947e-01f,
  5.06520830e-02f, -4.50463034e-02f, 6.17216788e-02f, 9.15375054e-02f, -6.25109226e-02f, -6.21827208e-02f, -1.17987603e-01f, -3.52664441e-02f, -2.70926654e-02f, -5.10551222e-02f,
  -5.79759814e-02f, -4.72625196e-02f, 1.95726864e-02f, -4.25084867e-02f, 3.33226174e-02f, 1.21237207e-02f, 8.85865539e-02f, 4.50717770e-02f, 9.92065221e-02f, -1.27714910e-02f,
  3.85321416e-02f, 2.18609478e-02f, -2.24831179e-02f, -3.47319245e-02f, -2.65080873e-02f, -3.81567888e-03f, -1.45009486e-02f, -4.21252027e-02f, -1.51911855e-01f, -1.70334540e-02f,
  5.39509915e-02f, 1.58519186e-02f, -7.84424245e-02f, -7.08288550e-02f, 3.58898528e-02f, -6.20911308e-02f, 3.65345888e-02f, 2.71583907e-02f, 1.35551682e-02f, 5.61868809e-02f,
  4.04347032e-01f, -1.50698069e-02f, 8.27960894e-02f, 1.35639042e-01f, -1.01939939e-01f, -2.10545495e-01f, 3.18442136e-02f, -6.31306767e-02f, -2.61909477e-02f, 6.60613701e-02f,
  -6.77001029e-02f, 1.77643960e-03f, 1.01441495e-01f, -4.80805747e-02f, 3.71878371e-02f, -3.39840129e-02f, -1.25644475e-01f, 1.15500547e-01f, 1.41798869e-01f, 3.13548669e-02f,
  -3.18556316e-02f, 1.76635291e-02f, 1.43752530e-01f, 9.82244313e-02f, 9.29825678e-02f, 1.07349886e-04f, 1.21597148e-01f, 7.24104419e-02f, 8.25457741e-03f, 8.05171654e-02f,
  -2.24265844e-01f, -1.36583522e-02f, -2.37957343e-01f, 1.44032031e-01f, 2.11074889e-01f, 5.45637906e-02f, 1.19956806e-01f, -1.51668536e-02f, 1.45484343e-01f, 1.18632503e-01f,
  2.58257054e-02f, 2.18922749e-01f, 1.28327623e-01f, 1.80250421e-01f, 8.08987021e-02f, 3.72578949e-02f, 1.85450632e-02f, -7.98774436e-02f, 3.07648815e-03f, 1.27370581e-01f,
  2.88090616e-01f, 1.51134863e-01f, -2.25227941e-02f, -8.46394431e-03f, 1.71096876e-01f, 1.13881737e-01f, -2.66096788e-03f, 7.70156309e-02f, 1.33329183e-01f, 1.40911400e-01f,
  3.92966084e-02f, -1.81415901e-01f, 1.66972980e-01f, -1.37448485e-03f, -1.30955102e-02f, -6.35204762e-02f, -9.53226909e-02f, 3.06335301e-03f, -7.34794233e-03f, 9.73290130e-02f,
  1.49639547e-02f, -1.79727688e-01f, -6.28504157e-02f, -1.07030720e-01f, -1.14994213e-01f, -2.55374168e-03f, -1.37055919e-01f, 3.17432284e-02f, -1.80197451e-02f, -5.87024540e-02f,
  3.79463397e-02f, -5.04818521e-02f, -6.77837001e-04f, -5.41463159e-02f, -5.40082203e-03f, -5.97095490e-02f, -1.26758695e-01f, -3.93092409e-02f, -1.44679233e-01f, -4.18768125e-03f,
  5.93031794e-02f, -7.59250745e-02f, -2.11073622e-01f, -1.28413334e-01f, 1.68362223e-02f, -3.26686651e-02f, -1.02059864e-01f, -9.59259793e-02f, -5.88095188e-02f, -5.96590824e-02f,
  7.06820982e-03f, 2.26995982e-02f, 1.15213804e-02f, 1.07800052e-01f, 5.08834645e-02f, -6.04205877e-02f, -9.95936766e-02f, -2.30068844e-02f, -1.17302991e-01f, -1.45638689e-01f,
  5.18111736e-02f, -1.45883828e-01f, -1.33442104e-01f, -2.55624168e-02f, -4.14181501e-02f, -5.87016270e-02f, -9.39527340e-03f, -5.29996082e-02f, -6.21468835e-02f, 7.24272430e-02f,
  8.11589211e-02f, -2.07205936e-01f, 1.49947656e-02f, -2.78970748e-02f, -6.76507428e-02f, -7.69690499e-02f, -5.26157266e-04f, -5.23372442e-02f, -1.09126963e-01f, 2.32390990e-03f,
  -6.53504729e-02f, -1.77279696e-01f, 6.69604912e-02f, -1.26178145e-01f, 1.90159343e-02f, -1.38377935e-01f, -3.75396237e-02f, 9.34567600e-02f, -6.36969209e-02f, -8.42789710e-02f,
  -7.13644400e-02f, 5.59036322e-02f, -6.09668121e-02f, -1.69688109e-02f, 1.71865914e-02f, 7.02514574e-02f, 2.59729940e-02f, 2.16719639e-02f, -3.92637774e-02f, -1.12473235e-01f,
  -3.91878426e-01f, 1.27494782e-01f, 9.72039104e-02f, -3.82320513e-03f, -1.45886093e-01f, -1.66587710e-01f, 9.63941142e-02f, -1.86908349e-01f, -1.53820947e-01f, 1.04274340e-01f,
  1.09295532e-01f, -2.21368328e-01f, -8.75314400e-02f, -2.04986498e-01f, -1.39900029e-01f, 8.79477113e-02f, -5.60642406e-02f, -3.01965714e-01f, -3.54014039e-01f, -2.68519282e-01f,
  -9.35227051e-02f, -1.89017043e-01f, -3.48592311e-01f, -2.18047306e-01f, 9.25495327e-02f, -1.00006737e-01f, 1.51337897e-02f, -1.69284359e-01f, -1.00730829e-01f, -3.18326429e-02f,
  1.80041879e-01f, -1.18307747e-01f, -1.57799595e-03f, -1.10411085e-01f, 5.18359691e-02f, 6.45157769e-02f, 3.25190648e-02f, 1.34204790e-01f, 1.13878109e-01f, 7.62163773e-02f,
  1.54137807e-02f, 8.41484070e-02f, 7.53376931e-02f, 1.20880313e-01f, -5.64596727e-02f, -1.57807115e-02f, 2.24498749e-01f, 8.31793845e-02f, 9.81841795e-03f, 1.11363009e-01f,
  1.28455311e-01f, -9.70339850e-02f, 2.08259048e-03f, 7.45777711e-02f, -4.38809544e-02f, -4.26714048e-02f, 1.03878237e-01f, -7.16153458e-02f, -1.69582680e-01f, 2.49742895e-01f,
  -6.22367533e-03f, 6.51220754e-02f, -4.63563427e-02f, -9.41554829e-02f, 6.62705228e-02f, 6.42577410e-02f, 1.22701921e-01f, 1.57951251e-01f, 3.84647138e-02f, 9.94914621e-02f,
  2.00052798e-01f, 7.71871805e-02f, -2.97540668e-02f, 9.67851654e-02f, 6.84428141e-02f, 2.83079334e-02f, -1.79734714e-02f, 1.07406013e-01f, -1.21651161e-02f, 1.11309797e-01f,
  2.31824759e-02f, -2.74394825e-02f, -2.79286895e-02f, -2.14391910e-02f, 1.35554392e-02f, 8.15934837e-02f, -7.88234621e-02f, -7.30142891e-02f, -2.15397384e-02f, -1.20012373e-01f,
  1.78674206e-01f, -1.66744128e-01f, 1.00890294e-01f, 3.24781202e-02f, 1.14244083e-02f, 9.25213099e-03f, -8.53892416e-02f, 3.31555190e-03f, 2.03265417e-02f, 4.37570475e-02f,
  -8.94202068e-02f, 1.08689472e-01f, 1.19059563e-01f, 2.23584965e-01f, -5.44122942e-02f, -2.55928151e-02f, 2.68096209e-01f, 4.25762273e-02f, -1.14161782e-01f, 1.62257627e-01f,
  5.08420207e-02f, -2.00592335e-02f, 6.05362877e-02f, 1.93536133e-01f, -3.33770774e-02f, -6.43048137e-02f, 7.85427168e-02f, 1.45514205e-03f, 1.17198250e-03f, 2.46417150e-01f,
  -4.17854451e-03f, 1.27958700e-01f, 5.91811948e-02f, -8.16807300e-02f, -3.24033827e-01f, -1.83048680e-01f, -2.89512694e-01f, -1.52552143e-01f, -1.89491495e-01f, -9.15299058e-02f,
  6.10906929e-02f, 1.96367145e-01f, 1.79071873e-01f, 2.54521459e-01f, 2.30121508e-01f, -1.83483317e-01f, -2.32460663e-01f, 5.02962656e-02f, -6.35160226e-03f, -2.32242212e-01f,
  -2.59260207e-01f, -1.68380693e-01f, -1.04712069e-01f, -1.45998031e-01f, -1.72597885e-01f, -1.60995841e-01f, -2.24101350e-01f, -3.44228446e-02f, -8.88163298e-02f, -1.48747116e-01f,
  -5.21291308e-02f, -2.46181458e-01f, -1.05186798e-01f, -1.16622094e-02f, -5.69163822e-02f, 8.10127407e-02f, 5.70898019e-02f, -3.08094881e-02f, 6.77818879e-02f, 1.10994197e-01f,
  -3.42657231e-02f, -2.11772993e-02f, 2.66484693e-02f, -5.91787994e-02f, -2.27968574e-01f, -1.80866390e-01f, -1.63323849e-01f, -1.82937518e-01f, -1.69152990e-01f, -1.02946043e-01f,
  -2.37478688e-01f, -5.51867113e-02f, 5.85956722e-02f, 4.12633978e-02f, 5.93492836e-02f, 8.55191946e-02f, -1.37298200e-02f, -1.29848152e-01f, 6.64516985e-02f, -1.66324899e-01f,
  -8.80707428e-02f, 5.96933998e-02f, -6.32677041e-03f, -5.91018423e-03f, -6.77785054e-02f, 9.63552892e-02f, 3.36576079e-04f, 7.48666655e-03f, -4.27650735e-02f, 1.15822963e-02f,
  -4.58702296e-02f, -7.51724094e-02f, -9.14620981e-03f, 9.23385397e-02f, -9.82335024e-03f, 5.13679944e-02f, 4.34195399e-02f, 4.77899835e-02f, -1.50085967e-02f, 5.37592880e-02f,
  -1.53826028e-02f, -1.60008259e-02f, 1.03313569e-03f, 2.74045598e-02f, -1.30013947e-03f, 4.04096432e-02f, -4.60304134e-02f, 4.73412947e-04f, 2.78542377e-02f, -2.49534193e-02f,
  1.73625126e-01f, -1.75514575e-02f, -2.03212313e-02f, -5.35941124e-02f, 1.37507431e-02f, 1.51032982e-02f, 1.45084772e-03f, 3.27970684e-02f, 4.76117022e-02f, 2.38184500e-02f,
  -5.92210144e-02f, 3.76423486e-02f, 1.50454417e-01f, -2.65342090e-02f, -7.80818015e-02f, -1.02488905e-01f, -4.48930031e-03f, -3.67466137e-02f, -1.54216196e-02f, -1.52096748e-01f,
  -1.66470811e-01f, 4.16441336e-02f, 2.25089550e-01f, 1.35221750e-01f, 7.29133785e-02f, 1.17102280e-01f, 3.90994512e-02f, 9.03389007e-02f, 2.70023972e-01f, 9.93392020e-02f,
  -4.57127616e-02f, -2.60327548e-01f, -3.61230999e-01f, -2.97267556e-01f, -1.68964759e-01f, -2.31783558e-02f, 3.47984359e-02f, 1.76729366e-01f, 4.56983708e-02f, -1.71672687e-01f,
  4.82840724e-02f, 1.99734733e-01f, -5.54104410e-02f, 1.34751618e-01f, 2.01477364e-01f, -1.57167375e-01f, -2.84190923e-01f, -4.29592840e-02f, 1.78641468e-01f, 2.49685794e-01f,
  3.98029126e-02f, 3.02010737e-02f, -8.80057272e-03f, 5.80759495e-02f, -2.18642399e-01f, -1.37853056e-01f, -3.89007509e-01f, -1.53461680e-01f, -1.22729912e-01f, -3.88209760e-01f,
  -1.44279540e-01f, 8.10587704e-02f, 4.26335260e-02f, 1.80589080e-01f, -2.31330082e-01f, 3.95817086e-02f, 1.23304531e-01f, -9.73769724e-02f, 5.56944609e-02f, -9.23020300e-03f,
  -1.49893388e-01f, 7.92287737e-02f, -1.52980099e-02f, 1.02878645e-01f, 2.83536371e-02f, 5.12545072e-02f, -5.26705682e-02f, -2.41266228e-02f, -1.03903348e-02f, -4.65088002e-02f,
  -1.15310974e-01f, 1.71666890e-02f, 6.48022294e-02f, 1.01929352e-01f, 1.40646696e-01f, -1.04785785e-02f, -2.27084458e-02f, 1.10029466e-01f, 1.57539859e-01f, -3.12751323e-01f,
  -1.04690492e-01f, -1.08953670e-01f, -6.97990879e-02f, -5.12159988e-02f, -2.08475199e-02f, -8.65281895e-02f, 1.70577355e-02f, 1.03855684e-01f, 6.97537065e-02f, -5.64252958e-02f,
  -1.04566440e-02f, 4.06836979e-02f, 7.73959756e-02f, 2.88727023e-02f, -1.21134609e-01f, -1.16029873e-01f, -6.32684305e-02f, 2.70056035e-02f, -2.73983255e-02f, -9.17770714e-02f,
  -1.98025685e-02f, 4.09647599e-02f, -5.17582372e-02f, 4.87614498e-02f, 1.01006977e-01f, -5.56482226e-02f, 6.62416592e-02f, 7.44495019e-02f, -1.72275137e-02f, 2.41968427e-02f,
  -1.33464843e-01f, 2.13970408e-01f, -1.27726227e-01f, 6.35562688e-02f, -4.33372594e-02f, -9.40305144e-02f, -1.35127500e-01f, 9.61312726e-02f, 1.26350120e-01f, 1.19578615e-01f,
  6.38063401e-02f, 9.12784711e-02f, -4.93048178e-03f, 2.11453270e-02f, 2.96458453e-02f, -5.18327355e-02f, 1.88737035e-01f, -2.55745035e-02f, 1.21514454e-01f, -6.62435815e-02f,
  -2.07624018e-01f, 3.05473506e-02f, 1.88292041e-01f, 7.66394213e-02f, 1.04854153e-02f, 7.37212971e-02f, -3.88490334e-02f, -1.56225055e-01f, 4.03910168e-02f, -1.64614469e-01f,
  1.22420631e-01f, -1.46532431e-01f, 2.00190797e-01f, 9.90277678e-02f, -9.19276550e-02f, -3.58662233e-02f, -1.90290928e-01f, -1.34365596e-02f, 7.42749870e-03f, -6.95954040e-02f,
  -4.80163693e-02f, 2.18161903e-02f, 1.10793896e-01f, -1.17778312e-02f, -3.68009252e-03f, -1.18538491e-01f, -2.92420923e-03f, 9.48122516e-02f, 1.47172093e-01f, 2.95600551e-03f,
  1.36923017e-02f, -4.98428605e-02f, -1.04788043e-01f, -6.85101226e-02f, -1.57517657e-01f, -5.80199249e-03f, 5.32717295e-02f, -1.22636460e-01f, 2.11784951e-02f, -9.88949463e-02f,
  1.77644014e-01f, 1.87655345e-01f, 7.34671131e-02f, 2.68991478e-02f, 1.79914068e-02f, 2.58199479e-02f, 5.41244075e-02f, 1.22814141e-02f, 4.80276197e-02f, -1.89149682e-03f,
  -9.90824495e-03f, -8.15877283e-04f, -1.25602677e-01f, -2.15957146e-02f, -2.05831192e-02f, -5.79406992e-02f, 2.37666741e-02f, 1.10620767e-01f, 9.73916054e-02f, 2.64556240e-02f,
  -6.91272244e-02f, 4.86634709e-02f, 2.84011122e-02f, 1.00225687e-01f, 1.20169567e-02f, 1.71968490e-01f, 1.65268123e-01f, 1.43414646e-01f, 3.26563679e-02f, 1.38465270e-01f,
  4.61784266e-02f, -1.50873279e-03f, 1.20389976e-01f, -2.52284668e-02f, -2.96456423e-02f, 6.46047965e-02f, 3.83730046e-02f, 2.27056760e-02f, -5.58214150e-02f, -2.15721682e-01f,
  -3.59785855e-02f, 1.18501022e-01f, 2.47541722e-02f, 4.11144458e-02f, 1.04433611e-01f, -9.14803892e-02f, 2.44655963e-02f, 1.10088497e-01f, -5.57509512e-02f, -7.47882724e-02f,
  2.70692091e-02f, -5.01446240e-02f, 7.86400051e-04f, -3.45001407e-02f, 5.22310671e-04f, 7.38929212e-02f, 1.49758244e-02f, -1.25079751e-02f, -2.07749918e-01f, -5.36298752e-02f,
  8.75353292e-02f, 1.60770670e-01f, 2.40795147e-02f, -5.34027182e-02f, 7.87404478e-02f, -7.92727843e-02f, 1.68853894e-01f, -3.38027664e-02f, 9.34679806e-02f, 3.86318602e-02f,
  3.62852216e-02f, -4.86514233e-02f, -5.16286455e-02f, -1.10346638e-01f, -7.27873445e-02f, 2.76172087e-02f, 1.32351115e-01f, 7.21539482e-02f, 1.28008857e-01f, 5.52076176e-02f,
  3.44776213e-02f, 1.98251992e-01f, 1.96389005e-01f, 2.39366516e-01f, 1.24579631e-01f, 8.30752403e-02f, 4.29851040e-02f, 6.48943186e-02f, 4.64130156e-02f, 8.57151521e-04f,
  -3.92937571e-01f, -6.23576939e-02f, -1.56787753e-01f, -5.90690672e-01f, -2.43310466e-01f, -4.05211933e-02f, -7.32566556e-03f, -1.76088035e-01f, -3.05956393e-01f, -2.58630753e-01f,
  2.91801505e-02f, 3.60382395e-03f, -6.86115101e-02f, 2.33325437e-01f, 2.15813056e-01f, 4.47407588e-02f, -1.36855498e-01f, 1.34569317e-01f, 2.37849906e-01f, 5.19832782e-02f,
  -4.49073538e-02f, -9.16896090e-02f, -7.91872889e-02f, -1.11539550e-01f, -3.46776307e-01f, -1.14585675e-01f, -2.42457032e-01f, -1.60476714e-01f, 1.06190689e-01f, -1.41272604e-01f,
  2.87788250e-02f, -2.12300092e-01f, -7.36746565e-02f, 1.18122056e-01f, -7.44182467e-02f, -7.76982903e-02f, -1.49284214e-01f, -1.56950757e-01f, 4.79181968e-02f, -1.40128389e-01f,
  -2.06879959e-01f, -5.48519753e-03f, -9.74245295e-02f, -1.29834563e-01f, -1.79199159e-01f, 7.75407115e-03f, -3.75217535e-02f, -6.64016232e-02f, 1.33383900e-01f, 4.22219783e-02f,
  5.59297986e-02f, 1.00437373e-01f, 1.74747333e-02f, -3.68465632e-02f, -2.73054242e-02f, -5.84938228e-02f, 1.34089142e-01f, 1.19703241e-01f, 2.80299410e-02f, -7.64913857e-02f,
  -1.72546087e-03f, 9.01985355e-03f, 3.54437158e-02f, 6.25990480e-02f, 7.63671249e-02f, 1.53869122e-01f, -4.80852425e-02f, -1.96180493e-02f, 2.33188272e-02f, 1.16957821e-01f,
  -8.74419659e-02f, -3.23037766e-02f, 1.12107052e-02f, -2.35040821e-02f, -4.46090139e-02f, 1.79739557e-02f, 1.25756040e-01f, 8.08135867e-02f, -2.86425781e-02f, -5.48711419e-02f,
  8.55529681e-02f, -2.40328759e-02f, -2.81534605e-02f, -7.90908635e-02f, 6.73074946e-02f, -1.29929006e-01f, -2.38935538e-02f, 8.63125846e-02f, -1.02408886e-01f, 1.01928107e-01f,
  -9.62839574e-02f, 1.49018750e-01f, -1.33779109e-01f, 3.04586370e-03f, -3.53101939e-02f, -1.22300617e-01f, -4.45018448e-02f, 3.55234705e-02f, -7.16865808e-02f, -8.28407519e-03f,
  9.55021754e-02f, 9.47021022e-02f, -6.78684860e-02f, 6.47603720e-02f, -2.65332609e-02f, 1.26399890e-01f, 5.17654717e-02f, 1.20068945e-01f, 1.38442859e-01f, 6.56144023e-02f,
  6.76365420e-02f, 1.85802490e-01f, 8.40201527e-02f, 1.06093176e-01f, 2.91124475e-03f, 9.60061923e-02f, 1.49628058e-01f, 8.96832049e-02f, 1.88307434e-01f, 7.78410360e-02f,
  -1.31644398e-01f, 2.40809247e-01f, -2.04820335e-01f, 6.65068254e-02f, 3.42303306e-01f, 4.38427590e-02f, 8.02683830e-02f, -1.96349427e-01f, -4.40208502e-02f, 8.77805427e-02f,
  7.59998932e-02f, 8.51763561e-02f, -4.43002349e-03f, -9.45478156e-02f, -1.60978839e-01f, -1.50109846e-02f, 1.08958177e-01f, -9.52607244e-02f, -2.28090510e-01f, 5.64167537e-02f,
  2.09730148e-01f, 4.03839797e-02f, -1.22643851e-01f, -1.72599584e-01f, 1.60508126e-01f, 7.37701729e-02f, -1.10752940e-01f, 7.85366911e-03f, 2.58918732e-01f, 3.37931991e-01f,
  -7.18164071e-02f, -2.52231181e-01f, -2.62129605e-02f, 1.30735353e-01f, 9.53199342e-03f, -8.39023963e-02f, 7.22272545e-02f, -7.89908171e-02f, 1.52740683e-02f, -8.56312215e-02f,
  9.11510289e-02f, -1.12632558e-01f, 1.99873403e-01f, -9.37828794e-02f, 4.51073647e-02f, -7.16187656e-02f, -1.17809894e-02f, -1.24723218e-01f, -2.80373812e-01f, -7.17812926e-02f,
  2.85983205e-01f, 1.93968430e-01f, -8.98665115e-02f, 8.10461044e-02f, -5.37302643e-02f, -1.91013012e-02f, -1.23213708e-01f, -1.05540447e-01f, -2.03664675e-01f, -4.99990173e-02f,
  1.22042242e-02f, 3.73564325e-02f, 6.62729740e-02f, -4.02746573e-02f, 1.82736162e-02f, -8.57912451e-02f, 8.44174530e-03f, -5.17064855e-02f, 1.24667406e-01f, -5.37648872e-02f,
  9.22320969e-03f, -6.67360332e-03f, 2.76110508e-02f, -5.82254771e-03f, 1.11589851e-02f, 4.98863757e-02f, 3.43304612e-02f, 1.04223803e-01f, -6.74235635e-03f, -5.90658225e-02f,
  3.11365463e-02f, 3.24756354e-02f, -1.28690436e-01f, 3.53688337e-02f, 6.90546632e-02f, -2.78188232e-02f, 8.67042094e-02f, -2.65490431e-02f, -9.13464129e-02f, 2.02071969e-03f,
  -3.34886968e-01f, -1.18944623e-01f, -9.32466090e-02f, -1.34811774e-02f, -8.56898725e-02f, -3.76959853e-02f, 1.80351492e-02f, 2.92205121e-02f, -7.81038254e-02f, 1.53183555e-02f,
  -1.22594774e-01f, -1.64528489e-01f, 6.01326860e-02f, -1.26595810e-01f, 1.00563737e-02f, -2.54995562e-02f, 2.05664169e-02f, 5.75089045e-02f, 6.41406029e-02f, -1.65007021e-02f,
  5.14282882e-02f, -1.19140856e-02f, -8.73312280e-02f, 1.68501381e-02f, 1.34158641e-01f, -9.21786502e-02f, -6.18785433e-02f, -2.28872031e-01f, -2.00332671e-01f, -1.95651561e-01f,
  2.35738792e-02f, -3.44683640e-02f, 1.93316922e-01f, 9.90017802e-02f, -1.34926409e-01f, -1.77321598e-01f, -4.96810913e-01f, -1.03702493e-01f, 3.39255668e-02f, -4.90486734e-02f,
  -1.01498459e-02f, 1.23567857e-01f, -7.01226247e-03f, -4.25860621e-02f, 1.39039820e-02f, -7.46355802e-02f, 8.35910439e-02f, 3.80126573e-02f, -5.78795560e-02f, -2.29804758e-02f,
  -1.32490173e-01f, 8.72759074e-02f, 2.46626854e-01f, 3.42115127e-02f, 1.11342020e-01f, 9.02572423e-02f, 1.39524043e-01f, 8.26154426e-02f, 3.74319404e-02f, 1.66753918e-01f,
  8.05737376e-02f, 9.45051461e-02f, -1.82204902e-01f, -1.48663521e-01f, 7.28314519e-02f, -1.26682520e-01f, -1.81839317e-01f, -4.71689664e-02f, -8.62737745e-02f, -6.56529982e-03f,
  -6.10926114e-02f, -1.38596430e-01f, 2.48342175e-02f, -5.19692674e-02f, -7.49759823e-02f, -9.84394923e-02f, -9.72873904e-03f, -4.56010215e-02f, 3.91349904e-02f, 1.19789414e-01f,
  -1.35520682e-01f, -2.35025063e-02f, 3.45024467e-02f, -1.28866449e-01f, -8.91199037e-02f, 7.49719515e-02f, -7.66758770e-02f, -2.38540731e-02f, -4.07781899e-02f, -3.48032266e-02f,
  -3.44137824e-03f, 6.45563379e-02f, -5.00920266e-02f, 3.13002430e-02f, 7.62462467e-02f, 3.96402646e-03f, 1.17298432e-01f, -4.33315225e-02f, -2.01886464e-02f, 1.16498649e-01f,
  -7.38351122e-02f, 9.81078148e-02f, -1.49572147e-02f, -1.10723255e-02f, -1.00772716e-02f, -3.73606477e-03f, -1.37172341e-01f, 2.32112352e-02f, 1.28637448e-01f, -2.69631464e-02f,
  -4.38747369e-02f, -5.89765161e-02f, 7.77852312e-02f, -3.55243199e-02f, -2.18206085e-02f, 3.25743444e-02f, 5.74192703e-02f, -1.00583777e-01f, -7.03860167e-03f, -2.89669596e-02f,
  1.01396158e-01f, 1.06078107e-02f, -1.23802356e-01f, -1.41934693e-01f, -3.81610580e-02f, 1.10747991e-02f, 1.31911889e-01f, -4.66395393e-02f, -7.28524849e-03f, -1.78722709e-01f,
  -2.12062776e-01f, -8.48722830e-02f, -9.47498437e-03f, -5.87801151e-02f, -1.04025237e-01f, -2.97881127e-03f, -1.64648980e-01f, -1.37365133e-01f, -1.97831299e-02f, 8.21713507e-02f,
  -1.85613818e-02f, -1.44572169e-01f, -9.19257402e-02f, -1.65629208e-01f, -6.32472113e-02f, -1.55986726e-01f, -1.29225582e-01f, -1.87549502e-01f, -1.13918871e-01f, -1.04236893e-01f,
  -1.22472726e-01f, -1.00928724e-01f, -2.43643411e-02f, 2.01070569e-02f, 1.33704811e-01f, 7.56646618e-02f, -2.24274531e-01f, 3.98611799e-02f, 5.62767498e-02f, -1.38710007e-01f,
  1.96498111e-02f, 1.52596757e-01f, -9.12528709e-02f, -9.55960378e-02f, -2.71808684e-01f, -3.41440946e-01f, -2.85385817e-01f, -1.88848659e-01f, -1.67107642e-01f, 3.23938951e-02f,
  2.82837078e-03f, -8.15369263e-02f, 4.18476835e-02f, -7.40104243e-02f, -4.23146747e-02f, -1.89325035e-01f, -2.05819339e-01f, -4.22872491e-02f, -1.06757469e-01f, -2.79844820e-01f,
  -1.37099281e-01f, -3.25420201e-02f, 7.74145797e-02f, -1.04150973e-01f, 9.43627432e-02f, 7.15177925e-03f, 2.18018591e-02f, 4.56680078e-03f, -3.71203385e-02f, -8.76186639e-02f,
  -7.87818655e-02f, -1.21153919e-02f, -5.31684645e-02f, 1.26047349e-02f, -6.25702962e-02f, 5.25480583e-02f, 7.57364929e-02f, -8.78959429e-03f, -8.88723433e-02f, -1.83072989e-03f,
  -1.29736727e-02f, -7.18116462e-02f, -2.31158376e-01f, -5.76356519e-03f, 1.56294182e-01f, -3.70213389e-02f, -5.58072925e-02f, -4.90943491e-02f, -2.29599327e-01f, -2.78676897e-01f,
  -8.76354892e-03f, 9.70183611e-02f, 9.51492116e-02f, -5.15261777e-02f, -6.27359468e-03f, 1.02541680e-02f, -1.00183614e-01f, -6.06321804e-02f, 9.89990905e-02f, -5.44053242e-02f,
  1.06671594e-01f, -2.43850285e-03f, 2.35071704e-02f, -4.68686447e-02f, -1.42502218e-01f, 7.45564401e-02f, 4.16709669e-02f, -6.26793951e-02f, -7.69278258e-02f, -1.05056591e-01f,
  -1.44739533e-04f, 1.73440948e-02f, 1.08254559e-01f, -2.75352653e-02f, 1.28151670e-01f, -1.07494429e-01f, 1.29042398e-02f, 1.20724261e-01f, 3.98266390e-02f, -1.38179570e-01f,
  -6.32071123e-02f, -1.64289400e-01f, -1.70043752e-01f, -9.04214680e-02f, -6.24391064e-03f, 1.02009796e-01f, -2.37736646e-02f, 7.16241598e-02f, 5.02386317e-02f, 8.19697529e-02f,
  -6.67933375e-03f, -1.42341748e-01f, -1.59750693e-02f, 4.98991087e-02f, 5.71856983e-02f, -1.14186265e-01f, -1.12432405e-01f, 7.66184600e-03f, -6.79904502e-03f, 8.12951326e-02f,
  5.12452647e-02f, -1.21401526e-01f, -2.48353675e-01f, -1.78412125e-01f, -2.27162261e-02f, -2.38651216e-01f, -2.43166462e-01f, -2.03967616e-01f, -2.77835011e-01f, -4.15957451e-01f,
  3.49001676e-01f, 5.47782362e-01f, -1.13867842e-01f, 9.90942419e-02f, -7.24826232e-02f, -1.23151667e-01f, 1.51872009e-01f, 2.33499199e-01f, 1.89899772e-01f, 1.79076642e-01f,
  2.48140451e-02f, -2.41242826e-01f, -1.04820341e-01f, -6.59432933e-02f, -1.04084983e-01f, 5.62215969e-02f, -2.49915086e-02f, -2.45747492e-01f, -4.23028737e-01f, -1.63350075e-01f,
  -9.74623039e-02f, 9.28636193e-02f, 2.10514575e-01f, 9.62941870e-02f, 1.96965933e-02f, 5.47655206e-03f, 3.15406233e-01f, 1.11259259e-01f, -1.29492551e-01f, 3.56972567e-03f,
  -3.18836302e-01f, 2.44750947e-01f, -3.63593698e-01f, 2.70149298e-02f, 3.57544087e-02f, -6.55627251e-02f, -4.53782454e-02f, -1.32091507e-01f, -1.19278990e-02f, 1.38541823e-02f,
  -2.81805485e-01f, -5.78023791e-02f, -1.79620817e-01f, -9.02390778e-02f, 2.94183530e-02f, -1.48523539e-01f, 9.69834030e-02f, -1.27512468e-02f, -2.56700963e-02f, -1.03798188e-01f,
  -1.33296236e-01f, -1.42664135e-01f, -1.24259166e-01f, 1.75472423e-02f, -8.56928229e-02f, -2.30255142e-01f, 4.54476103e-02f, 7.21916603e-03f, 6.35071620e-02f, 2.30154037e-01f,
  -3.25963013e-02f, -4.51765507e-02f, -9.23860539e-03f, 9.21043456e-02f, 1.45683154e-01f, -4.86266315e-02f, -6.46632165e-02f, 5.95285259e-02f, 4.14892845e-02f, 4.09411639e-02f,
  -5.65859526e-02f, 8.20208937e-02f, -1.04563564e-01f, -2.48466767e-02f, 2.91204751e-02f, -3.53818722e-02f, -1.94520563e-01f, 5.02436347e-02f, -3.05406656e-02f, -9.52323154e-03f,
  -5.17438427e-02f, -6.23837300e-02f, -3.73883508e-02f, 1.34184342e-02f, 8.00028816e-02f, -3.79902567e-03f, 5.13168201e-02f, 3.48203145e-02f, -1.18597988e-02f, -4.81310308e-05f,
  7.29853958e-02f, -1.25535190e-01f, -6.29339442e-02f, 7.21934512e-02f, -3.49967666e-02f, -8.32529645e-03f, 1.22974530e-01f, 2.61217281e-02f, 3.76074314e-02f, 9.03542433e-03f,
  -6.29158020e-02f, -1.13537170e-01f, 7.48707429e-02f, 2.95143407e-02f, -1.06157653e-01f, 5.43972626e-02f, 1.06292523e-01f, 3.14671732e-02f, -1.37829566e-02f, 1.71058979e-02f,
  9.96166468e-02f, 2.01979235e-01f, 5.15337288e-03f, 8.37456137e-02f, -4.43766676e-02f, -1.22756585e-01f, 1.09109573e-01f, -4.13108282e-02f, -7.70520046e-02f, 3.30091447e-01f,
  2.15667427e-01f, -2.92877853e-01f, 7.74172246e-02f, 9.38252583e-02f, 1.52236730e-01f, 2.47967333e-01f, 1.91830814e-01f, 1.51019245e-01f, 1.14543229e-01f, 2.24865042e-02f,
  -2.06394225e-01f, -2.65520543e-01f, -1.27214357e-01f, -1.06659330e-01f, 6.38912315e-04f, 2.19012380e-01f, 2.04907283e-01f, 1.04579911e-01f, 2.34849125e-01f, 6.33985475e-02f,
  -4.92693149e-02f, 1.12923831e-01f, -2.99935509e-02f, 6.52884468e-02f, -1.12699606e-01f, 8.87620673e-02f, 1.59071404e-02f, -1.90427378e-01f, -1.95783243e-01f, -1.04270086e-01f,
  -9.92149264e-02f, -2.23271385e-01f, -4.60059941e-02f, -1.97090000e-01f, -1.24985958e-02f, 2.39626206e-02f, 3.76125239e-02f, -1.30725101e-01f, -3.41975987e-02f, 6.44944087e-02f,
  -1.46763092e-02f, -4.98957373e-03f, -8.61568078e-02f, 1.70092601e-02f, 9.55199227e-02f, 3.93174402e-02f, -4.64536026e-02f, -2.94147283e-02f, -3.30222398e-02f, -1.55354723e-01f,
  -7.17383549e-02f, -1.29048169e-01f, 1.10917846e-02f, -5.84896952e-02f, 2.41218880e-02f, -1.06023043e-01f, 1.84656191e-03f, -1.05827495e-01f, -1.40252605e-01f, -9.00845975e-02f,
  -5.94959036e-03f, 9.51832607e-02f, -3.21976431e-02f, 1.29103452e-01f, 1.31901592e-01f, -7.81278536e-02f, -8.05235803e-02f, -7.31477365e-02f, -5.73993884e-02f, 7.60885403e-02f,
  -9.54668745e-02f, -2.70804800e-02f, -1.07217925e-02f, 9.38481763e-02f, -2.97825225e-02f, -4.21741121e-02f, 1.67797908e-01f, 4.38280217e-02f, -2.19386015e-02f, 8.26149620e-03f,
  -8.38255212e-02f, 6.07938580e-02f, -3.38923484e-02f, 8.55189562e-02f, -3.04972734e-02f, -2.26361658e-02f, 5.68472221e-02f, -6.50159502e-03f, 1.12092376e-01f, 1.08487777e-01f,
  -7.02660754e-02f, -1.73203334e-01f, 4.44774292e-02f, -2.14558557e-01f, -8.51306915e-02f, -4.03852249e-03f, -1.07290007e-01f, -3.41035128e-02f, -1.46192104e-01f, -1.07023679e-02f,
  -1.40399411e-01f, -1.19961739e-01f, -4.73238043e-02f, -8.37505050e-03f, 7.24036917e-02f, 5.43265976e-02f, -7.28137046e-02f, 1.70688629e-02f, -4.99075018e-02f, 1.36287715e-02f,
  -5.06667122e-02f, 2.30725855e-02f, 1.25387207e-01f, 1.10410184e-01f, -4.83014248e-02f, 3.73946391e-02f, 7.58261457e-02f, 1.00630842e-01f, 1.09988719e-01f, 2.14975119e-01f,
  -4.09246415e-01f, -1.22079618e-01f, 1.66730985e-01f, -2.75480300e-01f, 9.56141502e-02f, 1.29011786e-02f, -2.35803753e-01f, -2.01090038e-01f, -9.40837711e-02f, -1.27749801e-01f,
  1.87115222e-01f, 1.93881214e-01f, 4.11519781e-02f, 3.09031028e-02f, -3.35899681e-01f, -3.07437390e-01f, -1.66062027e-01f, -9.56489425e-03f, 1.45694930e-02f, 3.13825794e-02f,
  9.43002403e-02f, 5.60151553e-03f, -1.31577253e-01f, 9.07579735e-02f, -1.41971605e-02f, 7.24521056e-02f, 3.88815179e-02f, -6.82851523e-02f, 2.03329295e-01f, 4.79389727e-02f,
  1.58269644e-01f, -1.66646540e-01f, 3.32282074e-02f, -1.04349308e-01f, 1.10209279e-01f, -1.28589094e-01f, -9.72915813e-02f, 7.81746581e-02f, 1.24189988e-01f, -7.22409338e-02f,
  -3.75090428e-02f, 6.27467781e-02f, -1.60548091e-02f, -2.76258104e-02f, -1.86972976e-01f, -9.55526307e-02f, -4.62099835e-02f, -7.87362680e-02f, -1.59071550e-01f, -1.77271411e-01f,
  -1.53844833e-01f, 2.01707077e-03f, -1.71918701e-02f, -1.99969579e-02f, -1.92766592e-01f, 7.25496039e-02f, 1.29152477e-01f, 5.11329956e-02f, 2.90785637e-03f, -1.83716536e-01f,
  5.43622263e-02f, 1.71339791e-02f, 1.43273294e-01f, 3.06904521e-02f, 5.23585007e-02f, 1.45792868e-02f, -3.57962288e-02f, 5.35599664e-02f, 1.26617335e-04f, 6.00803457e-02f,
  -1.28231943e-01f, 9.38780978e-02f, 1.38815865e-02f, -2.72326637e-02f, 9.94901806e-02f, -4.57162149e-02f, -6.87389821e-03f, -1.27692506e-01f, -2.74012070e-02f, -2.22165231e-02f,
  -1.19825877e-01f, -1.59758534e-02f, 4.82597090e-02f, 1.22153230e-01f, 3.61610837e-02f, 1.74479745e-02f, -7.43086450e-03f, -1.84516720e-02f, -9.28854123e-02f, -3.53198163e-02f,
  -1.96464490e-02f, 2.61527449e-01f, -1.34689525e-01f, 6.86713532e-02f, 1.34748310e-01f, 6.34613261e-02f, 9.99720674e-03f, 8.01892728e-02f, 4.63585481e-02f, -4.66138162e-02f,
  -1.57333821e-01f, -8.74239802e-02f, -1.33086741e-01f, -3.75315920e-02f, -5.74189285e-03f, 7.35239033e-03f, -2.35644504e-02f, 1.48767442e-01f, -2.37215795e-02f, -7.58341886e-03f,
  -2.42156267e-01f, -2.11020991e-01f, -1.77508578e-01f, -1.56806931e-01f, -2.20082074e-01f, -1.76225007e-02f, 3.16219218e-02f, 4.95982692e-02f, -3.51670459e-02f, -1.11608341e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  7.73319826e-02f, 2.00836197e-01f, 2.33042270e-01f, 1.42938988e-02f, 1.28927469e-01f, 1.78152502e-01f, 1.71979412e-01f, 9.54715759e-02f, 3.00573379e-01f, 2.26784810e-01f,
  2.26970509e-01f, 1.15739316e-01f, 8.11118037e-02f, 1.52447730e-01f, 1.30835220e-01f, 4.85003889e-02f, 4.06204201e-02f, 5.43437488e-02f, -4.04636487e-02f, 2.53314763e-01f,
  2.37386644e-01f, 1.00624241e-01f, 9.67618674e-02f, 1.32487908e-01f, 6.85702190e-02f, 1.78100124e-01f, 8.53635520e-02f, 1.96526960e-01f, 2.32061997e-01f, 9.93630290e-02f,
  3.85978192e-01f, 2.17635497e-01f, 2.28095889e-01f, 8.85823518e-02f, 1.02034263e-01f, -1.19404979e-01f, 1.22377627e-01f, 1.18407026e-01f, 6.74049631e-02f, 2.35833034e-01f,
  1.61968961e-01f, 1.39575243e-01f, 1.79371387e-01f, 1.93533748e-01f, -2.91922539e-01f, 2.39858776e-02f, 1.90408416e-02f, 2.17538089e-01f, 8.20230693e-02f, 1.48921832e-01f,
  3.81510079e-01f, 2.27318347e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -5.46640344e-03f, 8.15709010e-02f, -3.53088044e-02f, -1.09332718e-01f, -2.75912639e-02f, -9.70734581e-02f, -2.09579412e-02f, 3.44420113e-02f, -1.12118967e-01f, 2.88751181e-02f,
  8.87023434e-02f, 6.07415363e-02f, 8.72380212e-02f, 1.81584746e-01f, 1.08672269e-01f, 2.33934090e-01f, 1.21179000e-01f, 1.85527056e-01f, 4.91171405e-02f, -1.04568135e-02f,
  1.39242738e-01f, -3.38664651e-02f, 2.62988601e-02f, -1.52578264e-01f, 8.12883452e-02f, 1.46691352e-01f, -1.13818146e-01f, 2.36733072e-02f, -1.54500276e-01f, -1.91293746e-01f,
  2.04370156e-01f, -1.28450975e-01f, 1.87833477e-02f, -1.57557838e-02f, 1.69731546e-02f, -4.98578623e-02f, 7.93513879e-02f, -2.67026156e-01f, 2.02163413e-01f, -4.04781774e-02f,
  -2.52958775e-01f, 1.89445063e-01f, 7.44452775e-02f, 4.06698026e-02f, 1.24339923e-01f, 2.46426463e-01f, -3.14098686e-01f, 1.30492384e-02f, -4.95498478e-02f, -9.68020409e-02f,
  -1.24924131e-01f, -9.91997123e-02f, -2.30006967e-02f, -8.36359262e-02f, -1.71467587e-01f, 1.40970526e-02f, -1.48746390e-02f, -1.42401204e-01f, -1.72607556e-01f, 1.83357447e-01f,
  3.56428623e-02f, 6.58332333e-02f, -3.73859890e-02f, 5.29946876e-04f, 6.24212548e-02f, 5.24493381e-02f, -8.43548402e-02f, 1.59444764e-01f, 1.22671187e-01f, 1.84922457e-01f,
  5.73909208e-02f, -6.71216249e-02f, -4.82784286e-02f, 3.97123732e-02f, -8.19148868e-02f, -1.03805020e-01f, -9.53028500e-02f, -1.62937343e-01f, 1.63054392e-01f, -5.26994951e-02f,
  1.96481854e-01f, -8.95992070e-02f, -1.31485969e-01f, 5.43736294e-02f, -8.75967219e-02f, 4.16671969e-02f, -8.48957226e-02f, 1.19900584e-01f, 6.07676692e-02f, 9.72523838e-02f,
  -2.48331800e-02f, 3.23300175e-02f, 1.64982796e-01f, 1.80041850e-01f, -1.63334846e-01f, -1.48224056e-01f, 1.31983191e-01f, 4.73029353e-02f, 6.09714910e-02f, -2.84107141e-02f,
  -3.92280556e-02f, -1.28474552e-02f, -1.34951383e-01f, 1.09304875e-01f, 2.19714195e-01f, -2.30383933e-01f, 6.76017702e-02f, -1.95654884e-01f, 4.25700620e-02f, 2.99445894e-02f,
  1.62802383e-01f, -8.56596008e-02f, 1.66587427e-01f, 7.77113950e-04f, 1.04210652e-01f, 3.58179398e-02f, 3.48748127e-03f, -1.59796730e-01f, 1.34478897e-01f, 1.87024102e-01f,
  1.20584093e-01f, 2.57589996e-01f, 2.41329800e-02f, 4.22160886e-02f, 8.09689760e-02f, -3.80309224e-01f, 1.67378560e-01f, -4.06282395e-02f, -2.66217235e-02f, 1.04179963e-01f,
  -3.25144827e-02f, 6.58497289e-02f, 9.02824402e-02f, 2.25104362e-01f, 2.41051409e-02f, -2.32197955e-01f, 5.75605221e-03f, 5.41002527e-02f, -1.39218435e-01f, -1.26065016e-02f,
  1.70175865e-01f, 1.39617231e-02f, 9.17847976e-02f, -1.15920536e-01f, 5.20948358e-02f, 1.68830171e-01f, -3.20544600e-01f, -1.45240232e-01f, -2.93421060e-01f, 3.86980660e-02f,
  8.03182870e-02f, -5.96088506e-02f, -1.40955999e-01f, 1.15569651e-01f, 1.08665973e-01f, -1.30679170e-02f, 6.33328333e-02f, 1.10459656e-01f, -1.02818511e-01f, -2.24785104e-01f,
  2.56167501e-01f, -4.11404632e-02f, 2.22243220e-01f, -2.54371136e-01f, 7.02439174e-02f, 1.74911302e-02f, 1.12864561e-01f, 2.95753106e-02f, -7.60606602e-02f, -1.84672117e-01f,
  2.91251898e-01f, -8.04679766e-02f, 1.52058184e-01f, -1.33280709e-01f, -1.04159832e-01f, -6.75928071e-02f, -7.08320271e-03f, -3.72179300e-02f, 4.02421653e-02f, 4.25111614e-02f,
  -7.81022012e-02f, 1.08151808e-02f, 5.81451058e-02f, -4.32149917e-02f, 1.47010431e-01f, 4.42681909e-02f, -2.16435283e-01f, -7.13228583e-02f, -2.20294952e-01f, -1.39826581e-01f,
  2.40104273e-01f, 5.14155068e-02f, -3.02851275e-02f, -2.99549252e-02f, -6.35015368e-02f, 1.84426278e-01f, 8.13952088e-02f, 2.66412627e-02f, -1.61183085e-02f, -1.57246783e-01f,
  1.23983338e-01f, -1.86044388e-02f, 1.01892725e-02f, 1.18173070e-01f, 8.75972211e-03f, -2.61687469e-02f, -4.97277454e-02f, -1.26282066e-01f, -5.59872249e-04f, 1.33138686e-01f,
  -1.51031762e-01f, 1.19422805e-02f, -3.83038856e-02f, 1.91057131e-01f, -1.21575266e-01f, -9.52716991e-02f, -5.92630878e-02f, 1.50301516e-01f, 1.81662977e-01f, 1.46058970e-04f,
  -1.74641423e-02f, 8.03532004e-02f, 2.32837256e-02f, -1.06323302e-01f, 1.54382855e-01f, 1.36096478e-02f, -1.99980453e-01f, 6.98026866e-02f, 1.02845550e-01f, 2.15698972e-01f,
  1.77119911e-01f, -9.48056579e-03f, -1.72163218e-01f, 5.33871278e-02f, -9.64595005e-02f, 1.61165014e-01f, -2.19521567e-01f, 1.80026084e-01f, -2.39537865e-01f, 1.19053572e-02f,
  2.11103214e-03f, 7.01546445e-02f, -4.02053744e-02f, -1.35043964e-01f, -8.08205903e-02f, -7.62659162e-02f, 1.32162794e-01f, 1.47318572e-01f, -1.36673674e-01f, -7.77041689e-02f,
  -2.05312997e-01f, 1.79676749e-02f, 8.87532830e-02f, -1.31634191e-01f, -2.19933316e-01f, -1.39028937e-01f, -7.70361796e-02f, 1.42531171e-01f, 9.45032015e-02f, -7.80402031e-03f,
  -1.09191440e-01f, -1.96929183e-02f, -3.33332457e-02f, 2.25507114e-02f, -7.26933256e-02f, 4.25994955e-02f, -7.56148696e-02f, 3.27637866e-02f, 1.19829148e-01f, -2.26543322e-01f,
  -3.18226367e-02f, 1.04105607e-01f, 1.78708270e-01f, 2.89098322e-01f, -1.90673441e-01f, 8.37237611e-02f, -1.83001488e-01f, 1.44488752e-01f, -2.49078020e-01f, -2.93187238e-02f,
  1.16076253e-01f, -1.20897874e-01f, 8.19476470e-02f, -7.61778280e-02f, 7.05606341e-02f, 1.12548377e-02f, 1.76625684e-01f, -1.81716099e-01f, -4.10164753e-03f, 1.45156607e-01f,
  -2.66959816e-01f, 1.31011277e-01f, 3.30233797e-02f, 8.96928608e-02f, 1.65198609e-01f, 7.69249052e-02f, -1.84414059e-01f, 9.97680202e-02f, -1.48861669e-02f, -7.28699490e-02f,
  4.04966297e-04f, 5.10405488e-02f, -2.15048581e-01f, -2.03980610e-01f, -1.14907073e-02f, 7.30827898e-02f, 1.53545395e-01f, -1.10430777e-01f, -8.30590054e-02f, -1.63425565e-01f,
  1.12935543e-01f, 2.42802292e-01f, 1.22810505e-01f, -3.05633084e-03f, -2.54771449e-02f, -3.19704376e-02f, 1.31345287e-01f, -1.98098406e-01f, 8.45440850e-02f, -1.14125736e-01f,
  -5.46442829e-02f, 2.04851963e-02f, 9.15843621e-02f, -1.23008648e-02f, 2.65398249e-02f, -2.35977590e-01f, -1.70700289e-02f, 1.04496144e-01f, -1.17663383e-01f, -1.21540539e-01f,
  4.37479559e-03f, -7.52643347e-02f, 2.21403427e-02f, -3.77596691e-02f, 4.62984182e-02f, -7.46751055e-02f, -1.95355296e-01f, -1.80032793e-02f, 2.98370391e-01f, -1.31732404e-01f,
  1.94430426e-01f, -2.78817058e-01f, 4.94388081e-02f, 6.51023909e-02f, -2.29671717e-01f, -1.05607830e-01f, -1.29867103e-02f, 1.62486225e-01f, 3.84488888e-02f, -1.96825460e-01f,
  9.00055319e-02f, 1.04079589e-01f, -1.84183732e-01f, 6.05616011e-02f, 5.88419735e-02f, -1.29772827e-01f, 4.68122102e-02f, -1.15867257e-01f, -7.29801133e-02f, -6.57680631e-02f,
  6.87416792e-02f, 1.13327265e-01f, 6.29091561e-02f, 6.25005215e-02f, 3.90973181e-01f, -4.07182984e-02f, 2.78890550e-01f, 9.05795395e-02f, 1.93044752e-01f, -5.07520624e-02f,
  8.27087238e-02f, 1.51072159e-01f, 1.15317911e-01f, 1.80901214e-01f, -1.75169110e-01f, -8.82102624e-02f, 5.45184687e-02f, -1.65652469e-01f, 1.97905302e-01f, 5.35532460e-02f,
  2.55097985e-01f, 1.90541893e-02f, 1.72863230e-01f, 6.29743040e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.01653971e-01f, -6.94022179e-02f, -1.35885254e-01f, 7.56661147e-02f, 1.12500541e-01f, -1.06779866e-01f, 8.22687075e-02f, -1.55454110e-02f, -9.64891538e-02f, -1.42275035e-01f,
  1.94671173e-02f, -8.11181515e-02f, -1.36067361e-01f, -3.99756245e-02f, 1.87088698e-01f, -6.12961240e-02f, 1.08718425e-01f, -2.26829693e-01f, 2.21093059e-01f, 1.18702047e-01f,
  1.15157381e-01f, -7.78196231e-02f, -2.54276278e-03f, 1.85538247e-01f, -8.60763714e-02f, -2.84965411e-02f, -2.14130238e-01f, 1.40434667e-01f, 9.41650793e-02f, -1.75645780e-02f,
  3.88043113e-02f, -7.03306729e-03f, -1.04038268e-02f, -1.71699226e-01f, 1.53957769e-01f, 9.13301557e-02f, -1.34565324e-01f, -4.07161713e-02f, -9.64816809e-02f, 6.16653711e-02f,
  4.06350791e-01f, -7.88341239e-02f, -2.81529147e-02f, -2.01804340e-01f, 1.26138538e-01f, 3.02649140e-01f, 2.79017508e-01f, 4.91680689e-02f, 2.19883814e-01f, 1.34957880e-01f,
  -2.17900425e-01f, 2.57590711e-01f, 7.98852667e-02f, -1.45237902e-02f, 5.86472601e-02f, 2.60573655e-01f, 5.60106635e-02f, 3.01537335e-01f, 1.27260759e-02f, 9.30826962e-02f,
  1.51913449e-01f, -3.35429490e-01f, 1.21146224e-01f, 2.34892100e-01f, 8.35737586e-02f, -8.63023251e-02f, -4.93931621e-02f, 7.69434497e-02f, -7.49726780e-03f, 1.94394007e-01f,
  8.02023709e-02f, -1.39945343e-01f, 1.10993333e-01f, 6.95115179e-02f, -2.78377440e-02f, -1.50570318e-01f, 1.99432880e-01f, 1.12275705e-01f, 5.08191176e-02f, 2.66668014e-02f,
  -1.28071889e-01f, -6.42153472e-02f, -1.53645128e-01f, 8.59462190e-03f, 1.41561761e-01f, 2.48029903e-01f, 4.55382746e-03f, 5.03645875e-02f, 1.35275170e-01f, 1.97332397e-01f,
  2.40206607e-02f, 7.69631937e-02f, 2.99633056e-01f, -1.10387899e-01f, -1.43378302e-01f, -9.56876948e-02f, 1.14453733e-01f, -2.68989671e-02f, 3.81012298e-02f, -1.40576407e-01f,
  9.15638879e-02f, 2.24689677e-01f, -6.47586808e-02f, 1.39336409e-02f, -2.12526508e-02f, 4.54724804e-02f, -2.27557003e-01f, 4.08366285e-02f, -4.56573330e-02f, -2.81352010e-02f,
  -2.76951073e-03f, 1.33785948e-01f, 8.59354064e-02f, 1.65393740e-01f, 1.59571301e-02f, 2.74523854e-01f, 9.80809256e-02f, -7.79678673e-02f, 2.56437063e-01f, 1.73097089e-01f,
  -2.17092447e-02f, 2.77243286e-01f, -3.58298384e-02f, -2.02314481e-01f, -2.40891203e-01f, -3.44099365e-02f, -1.69383556e-01f, 3.74275744e-02f, 4.83556911e-02f, 2.22520120e-02f,
  -2.04500668e-02f, 7.68958926e-02f, 9.64163691e-02f, 2.13618562e-01f, -3.53229884e-03f, 1.62654445e-01f, -5.09361550e-02f, -4.48952466e-02f, -4.16516662e-02f, 1.22392595e-01f,
  -9.07436833e-02f, 1.33144990e-01f, -3.27024966e-01f, 1.73522532e-01f, -4.15864855e-01f, -1.12080544e-01f, 2.53600955e-01f, 2.71757424e-01f, 2.60167010e-02f, -1.43875852e-01f,
  -2.64725983e-01f, 4.39495146e-02f, 2.72491336e-01f, 1.97192878e-01f, -1.32272139e-01f, -5.61966328e-03f, 4.25742008e-02f, 4.19700425e-03f, 1.38811201e-01f, -1.36698946e-01f,
  -1.73606262e-01f, -1.86030775e-01f, 5.04728891e-02f, 2.25001052e-02f, -1.40196398e-01f, -2.66055703e-01f, 7.18045458e-02f, 2.42892608e-01f, -1.24276295e-01f, 7.36814290e-02f,
  -4.30075303e-02f, 2.56220311e-01f, -4.95662913e-02f, -3.89978290e-01f, 2.20108658e-01f, 1.58003613e-01f, 1.06146634e-01f, -1.45735309e-01f, 1.57754287e-01f, 1.09242335e-01f,
  1.08022660e-01f, -2.23860189e-01f, -1.47614583e-01f, -1.53730169e-01f, 1.79047755e-03f, -4.89641666e-01f, 2.58041710e-01f, 1.71776935e-01f, -9.47382525e-02f, 7.16313273e-02f,
  -6.71814978e-02f, -2.46877685e-01f, 6.32907152e-02f, -1.34337574e-01f, -7.02646226e-02f, 8.70400742e-02f, 7.81352296e-02f, -4.48363237e-02f, 2.48909026e-01f, -1.95703328e-01f,
  1.23360656e-01f, 1.26666471e-01f, -1.30453631e-01f, -6.65236712e-02f, 1.83063358e-01f, -1.31595768e-02f, 7.94718415e-02f, -2.64744963e-02f, 1.38189092e-01f, -1.49252042e-02f,
  -2.53584653e-01f, -1.61790222e-01f, -2.70886302e-01f, 3.28787148e-01f, -3.84463556e-02f, -6.85296655e-02f, -2.94369161e-02f, -1.03805378e-01f, -8.84390995e-02f, 6.14300780e-02f,
  6.29941151e-02f, 2.21640095e-01f, 7.84625560e-02f, -3.31420988e-01f, 2.14578211e-01f, 1.98132098e-01f, 2.35049680e-01f, 1.68056682e-01f, 3.32449347e-01f, 2.51472741e-01f,
  1.06106594e-01f, 1.48987537e-03f, -1.37331888e-01f, 1.45606976e-02f, 1.43084005e-01f, -8.09158981e-02f, 2.13174317e-02f, 2.53694654e-01f, -2.94817179e-01f, -1.70151293e-01f,
  3.94526031e-03f, 1.07880674e-01f, -1.76296160e-01f, -8.23648572e-02f, 1.66651402e-02f, -2.09120557e-01f, 9.12583992e-02f, 1.00306325e-01f, 8.41714069e-02f, 2.90771514e-01f,
  -1.48977071e-01f, -4.79550920e-02f, -2.01700348e-02f, -4.37198222e-01f, 1.54952258e-01f, 1.84356838e-01f, -2.44398527e-02f, 7.33781978e-02f, 5.75228408e-02f, 1.19135110e-02f,
  1.42097980e-01f, -2.03674771e-02f, -2.72856001e-02f, 2.12901652e-01f, -8.67331102e-02f, -1.96028054e-01f, 2.54213307e-02f, 3.94633077e-02f, -2.25186404e-02f, -1.24801874e-01f,
  -1.31032929e-01f, -1.10241756e-01f, 1.05588339e-01f, -4.27408010e-01f, 2.99182922e-01f, 1.19038023e-01f, 1.55681014e-01f, -1.74064502e-01f, 1.26824051e-01f, 1.43465221e-01f,
  5.63861169e-02f, 6.85843453e-03f, -3.42053294e-01f, 2.20682725e-01f, 1.37679249e-01f, -1.37726277e-01f, -1.10463172e-01f, 2.10679904e-01f, -1.57779351e-01f, -2.95524835e-03f,
  1.98091358e-01f, -2.53299493e-02f, -2.60995895e-01f, -1.46486580e-01f, -2.73615360e-01f, 3.24019566e-02f, 3.46490353e-01f, -5.27553931e-02f, -3.67954850e-01f, -1.39028266e-01f,
  6.60079718e-02f, 5.47550097e-02f, 2.71595567e-01f, -8.10639001e-03f, 1.63227260e-01f, 1.76997408e-01f, -7.19755068e-02f, 1.13130525e-01f, 8.52753296e-02f, -4.65469882e-02f,
  1.03569508e-01f, -3.30986530e-02f, 1.75341461e-02f, 2.55531579e-01f, 2.79135913e-01f, -1.25481918e-01f, -2.90783495e-02f, 4.83077653e-02f, -7.36023709e-02f, 1.69749781e-01f,
  1.09984897e-01f, 7.43434504e-02f, 2.57003069e-01f, 5.74533865e-02f, 9.35256928e-02f, -5.43892384e-02f, -2.31770605e-01f, -7.43540898e-02f, -8.96394476e-02f, -8.16850066e-02f,
  1.45038188e-01f, -1.16107345e-01f, 2.22040370e-01f, 1.76202163e-01f, -1.81795120e-01f, 1.34252876e-01f, -1.05109721e-01f, 4.46531884e-02f, -1.02160543e-01f, -1.37137726e-01f,
  2.50438035e-01f, -1.83286950e-01f, 2.48693675e-01f, -5.41880801e-02f, -4.28079553e-02f, -1.92364473e-02f, 1.38636604e-01f, 9.46465433e-02f, 8.04842114e-02f, -1.19828954e-01f,
  1.94898814e-01f, 9.85486507e-02f, 2.42251277e-01f, -1.33437067e-01f, 9.39078629e-02f, -2.38621622e-01f, -6.21494912e-02f, -8.86417180e-02f, 1.26232058e-02f, -1.74068794e-01f,
  -6.38932288e-02f, 1.39661029e-01f, -2.76250802e-02f, -4.75495607e-02f, 1.67043507e-01f, -3.07857513e-01f, -2.97791809e-01f, 6.34179786e-02f, 3.30909379e-02f, -1.69105947e-01f,
  -2.46498622e-02f, -2.41217650e-02f, 9.07018259e-02f, 1.32021695e-01f, 9.20645427e-03f, -2.25024596e-01f, -4.79443893e-02f, -1.22791052e-01f, -1.79756999e-01f, 1.15140662e-01f,
  7.62900189e-02f, 3.05553287e-01f, -1.02492452e-01f, 6.32748157e-02f, 2.01660261e-01f, 6.28530756e-02f, 2.89688054e-02f, -7.01910704e-02f, -1.73203852e-02f, 5.12469597e-02f,
  -2.97174100e-02f, -8.01293936e-04f, -1.95984766e-01f, -2.10474748e-02f, 1.45070702e-01f, -1.23404086e-01f, 1.14509210e-01f, -6.23274921e-03f, -1.59822494e-01f, -1.13006637e-01f,
  -6.63358951e-03f, -2.23362982e-01f, 3.38439256e-01f, -1.13126136e-01f, 2.25679904e-01f, -2.06336364e-01f, 2.68933564e-01f, 1.01901963e-02f, 4.66201967e-03f, -1.26779035e-01f,
  -1.08693823e-01f, 5.08038551e-02f, -1.68678641e-01f, -9.52007994e-02f, 2.62294620e-01f, 1.93740502e-01f, -1.05605656e-02f, -8.83194730e-02f, -1.93873838e-01f, 2.77166784e-01f,
  -7.91186653e-03f, -2.39977334e-02f, 5.04182838e-02f, -1.22598052e-01f, -2.83053547e-01f, 2.36386016e-01f, -2.88156182e-01f, 1.48220733e-01f, -1.58327565e-01f, 1.02715947e-01f,
  7.11905286e-02f, 1.55171752e-01f, 9.40413848e-02f, -3.18110138e-02f, 1.09173648e-01f, -3.21804196e-01f, -2.75738239e-01f, 1.48215741e-01f, -4.52735834e-02f, 3.97047177e-02f,
  -1.79061200e-02f, -1.43436506e-01f, 1.90370470e-01f, 1.18614756e-01f, 2.64234453e-01f, 2.01009586e-01f, 1.90164428e-02f, 1.54219151e-01f, 1.20022841e-01f, 1.27755940e-01f,
  1.69881478e-01f, -3.95301990e-02f, -1.81049202e-03f, -6.86940178e-02f, -4.24363278e-02f, -1.32708013e-01f, 3.88284698e-02f, -1.65716261e-01f, 1.36052459e-01f, -1.20598741e-01f,
  2.28710234e-01f, 7.78255314e-02f, 1.61800459e-01f, -9.43150967e-02f, 8.93209651e-02f, 2.32348859e-01f, -4.20389734e-02f, -3.57043184e-02f, 5.80761060e-02f, -2.46884331e-01f,
  -6.89645335e-02f, 8.88374634e-03f, -1.94926947e-01f, -2.27725893e-01f, 2.09670499e-01f, 8.64864290e-02f, -7.96053279e-03f, 1.58458147e-02f, 1.61116302e-01f, -3.50072607e-02f,
  -2.31184661e-02f, -6.74047843e-02f, -1.54969975e-01f, -1.91577431e-02f, 1.26311705e-01f, -5.46065532e-02f, 1.51220620e-01f, -6.58126026e-02f, 4.54118066e-02f, 1.89519525e-01f,
  -4.21496592e-02f, 8.59729275e-02f, 4.11282741e-02f, 7.50030437e-03f, -1.05207048e-01f, 4.10409495e-02f, -2.97479387e-02f, -1.68582380e-01f, -1.51077285e-03f, -2.73943931e-01f,
  1.91277653e-01f, 1.91793084e-01f, 4.38593067e-02f, 1.82367817e-01f, 4.87726927e-02f, -1.56912610e-01f, -1.23073548e-01f, 1.19119555e-01f, 1.36980414e-01f, 2.56140560e-01f,
  8.37696567e-02f, -9.21417698e-02f, 1.27866313e-01f, 3.25425684e-01f, 1.07933722e-01f, 1.85778201e-01f, 2.53787518e-01f, 1.19388752e-01f, -1.89584196e-02f, 1.09576285e-01f,
  1.45179376e-01f, -1.56178372e-03f, 3.13460857e-01f, -4.12477367e-02f, 1.65559590e-01f, 4.76028025e-02f, -1.01940982e-01f, -1.05981246e-01f, -9.45159271e-02f, 2.73611873e-01f,
  -1.42987166e-02f, -1.92844108e-01f, 4.49551754e-02f, -2.68680632e-01f, 7.31016621e-02f, 4.14600072e-04f, -2.06556872e-01f, -9.76313800e-02f, 1.80763438e-01f, 5.53851090e-02f,
  9.06150863e-02f, 4.22806554e-02f, 1.83298856e-01f, 1.59133703e-01f, -8.43664706e-02f, 1.48337066e-01f, -1.86980456e-01f, -5.19958660e-02f, 9.61756036e-02f, -8.78551602e-03f,
  9.42605883e-02f, -1.62429605e-02f, -9.05136839e-02f, 2.71981895e-01f, 4.42382842e-01f, 8.89166538e-03f, 1.76549971e-01f, 1.97814163e-02f, -2.07037792e-01f, 6.92287683e-02f,
  4.18703770e-03f, -8.21085125e-02f, 1.23372816e-01f, 2.98975799e-02f, 5.13515212e-02f, 1.69110179e-01f, 1.43008143e-01f, -9.83066335e-02f, -8.76182914e-02f, -1.91620737e-02f,
  -1.82660341e-01f, 1.63829461e-01f, 1.47161214e-03f, 4.04129982e-01f, 2.39519924e-01f, -1.12705156e-01f, 7.01333210e-02f, -7.53965080e-02f, -4.00247239e-02f, 2.07545340e-01f,
  2.81901479e-01f, 1.22360602e-01f, 2.66636878e-01f, -2.69364089e-01f, 9.31093097e-02f, 1.21868122e-02f, -1.58886481e-02f, -1.95335642e-01f, -1.11802779e-01f, 1.11166462e-01f,
  3.00849020e-01f, -1.67280268e-02f, 3.30020905e-01f, -1.54734170e-02f, -3.10608625e-01f, 3.22148204e-02f, 9.54034831e-03f, -2.86815409e-02f, 7.22636748e-03f, 1.79704800e-01f,
  3.52626517e-02f, -6.17899038e-02f, 1.20720558e-01f, 1.26880392e-01f, -2.70336624e-02f, 9.33599547e-02f, 6.10797554e-02f, -8.81621391e-02f, 1.21965028e-01f, -2.05954030e-01f,
  -1.50370836e-01f, -1.00919038e-01f, 2.39436910e-01f, 1.33745641e-01f, 1.92679659e-01f, -1.61603689e-01f, 1.32479101e-01f, 8.07541311e-02f, 7.11792633e-02f, 2.25177612e-02f,
  -2.07083061e-01f, 3.03850263e-01f, -4.71155606e-02f, -1.39117226e-01f, 1.75870672e-01f, -4.87060174e-02f, -5.00708699e-01f, -1.45233139e-01f, 1.63298529e-02f, -9.48422104e-02f,
  2.06260383e-01f, 3.14006180e-01f, -1.54754668e-01f, 2.93181986e-01f, -2.29027405e-01f, 1.83269903e-02f, 4.86801602e-02f, -3.16525221e-01f, 3.09006087e-02f, 2.14477733e-01f,
  2.00528115e-01f, 2.17026547e-02f, 9.93048698e-02f, 2.22004384e-01f, 1.50761425e-01f, 1.21777959e-01f, -5.32859415e-02f, 1.39586046e-01f, 7.43200034e-02f, 2.06311688e-01f,
  -3.41735967e-02f, -9.54483896e-02f, 8.32040310e-02f, -5.15990853e-02f, -5.54577522e-02f, -1.95804760e-01f, 5.25568798e-02f, 2.34390408e-01f, 2.70959407e-01f, 4.58813868e-02f,
  -2.48952970e-01f, 8.11254829e-02f, -2.81561941e-01f, 2.00194493e-01f, 7.90848434e-02f, -1.89845994e-01f, 2.11983174e-03f, -1.73165336e-01f, -7.57896826e-02f, 5.58182932e-02f,
  -6.12023240e-03f, -3.61094683e-01f, 9.99210626e-02f, 2.56349266e-01f, 3.32757533e-02f, 2.44568437e-01f, 7.73396518e-04f, 9.69765112e-02f, -3.16799760e-01f, 2.27200650e-02f,
  -1.09338902e-01f, -4.17650759e-01f, 3.30118388e-01f, 8.17034096e-02f, 1.32737309e-01f, -1.14653721e-01f, 1.71896204e-01f, -3.41361575e-02f, 5.38945459e-02f, -8.10411051e-02f,
  2.70241261e-01f, 1.44934021e-02f, -1.50787279e-01f, 4.11234610e-02f, -3.66613179e-01f, -1.24243714e-01f, 4.13860418e-02f, -6.72960421e-03f, -3.36923748e-02f, -1.02536455e-01f,
  1.33307770e-01f, -1.30615100e-01f, 2.40092635e-01f, -1.00704327e-01f, 8.35137218e-02f, 1.61114171e-01f, 2.07163244e-01f, 9.78274420e-02f, 5.64805791e-02f, 1.43562645e-01f,
  -1.24820128e-01f, 1.07933342e-01f, 1.20940052e-01f, -4.91170473e-02f, 4.63204645e-02f, 6.26098663e-02f, 6.47710264e-02f, -4.89057340e-02f, 6.52647242e-02f, -2.64010072e-01f,
  -1.07209748e-02f, 2.45165706e-01f, 7.98659995e-02f, 7.11632222e-02f, -4.66188528e-02f, -2.22042412e-01f, -4.13508974e-02f, -3.00741345e-02f, -1.42235518e-01f, -1.70751303e-01f,
  2.20650807e-01f, -1.26087040e-01f, -4.71861009e-03f, -6.32417351e-02f, 1.76640972e-01f, -3.32824551e-02f, -1.16169937e-01f, 3.04273749e-03f, -1.70698583e-01f, 4.34510075e-02f,
  -1.20048605e-01f, 9.05729756e-02f, 7.33021572e-02f, 2.60721501e-02f, -6.34087026e-02f, 2.11468041e-01f, 4.32220727e-01f, 1.29661825e-03f, 6.00840226e-02f, -1.49886042e-01f,
  1.71519071e-01f, -1.03758471e-02f, -2.96005718e-02f, 7.20236152e-02f, 3.13732862e-01f, -3.88325080e-02f, 7.29877204e-02f, 1.11384079e-01f, -1.40409768e-02f, -1.14894643e-01f,
  5.83267361e-02f, -1.47228256e-01f, -2.01884925e-01f, 9.92395207e-02f, 1.18018158e-01f, 3.49441379e-01f, 1.99964568e-01f, -3.99314752e-03f, -4.37000357e-02f, -7.46954978e-02f,
  -1.14845544e-01f, -1.26598845e-03f, 8.19583461e-02f, -8.45836103e-02f, -1.88243285e-01f, 1.13462796e-02f, 9.07625444e-03f, 1.09408006e-01f, -1.04095086e-01f, 1.11634575e-01f,
  -3.97136807e-02f, 4.98758592e-02f, -3.03428061e-02f, -1.29073292e-01f, -5.71176223e-02f, -2.34216705e-01f, 5.48973456e-02f, 6.51126504e-02f, 4.03729081e-02f, 6.22767322e-02f,
  -1.85938030e-01f, 1.72677130e-01f, 1.26199434e-02f, 1.39961001e-02f, 1.40725166e-01f, 1.23963125e-01f, 1.96516961e-01f, 2.39809081e-02f, 1.99884683e-01f, -2.00606942e-01f,
  8.19286183e-02f, 6.44506365e-02f, -2.83232797e-02f, 7.35260919e-02f, -5.60640730e-02f, 2.68116951e-01f, 4.42592502e-02f, 1.68226764e-01f, 1.66798577e-01f, 1.29259169e-01f,
  -1.03646971e-01f, 3.87630820e-01f, -2.10464224e-01f, 2.23888084e-02f, 6.32222667e-02f, 2.06766278e-01f, 1.39187992e-01f, 2.01753169e-01f, 5.83792944e-03f, 1.75515711e-01f,
  2.16274291e-01f, -9.59423631e-02f, -1.83657125e-01f, 2.61553079e-01f, -1.04173869e-01f, -6.89743832e-02f, 1.05449170e-01f, -1.19480696e-02f, 1.04339436e-01f, -8.74037296e-02f,
  -2.29884461e-01f, -1.46336863e-02f, 1.13545962e-01f, 1.96044549e-01f, 9.36090350e-02f, 1.68926254e-01f, 2.37469316e-01f, 1.37363285e-01f, 8.06048363e-02f, -2.69480199e-01f,
  -5.74624958e-03f, 2.20319480e-02f, -9.66573425e-04f, -1.76132277e-01f, 1.76600412e-01f, -2.22845953e-02f, 2.93931991e-01f, 1.46467075e-01f, 1.61134765e-01f, 3.36329818e-01f,
  -1.49835929e-01f, -9.89911705e-02f, 6.51080832e-02f, 1.72506854e-01f, -1.69089139e-01f, -6.11656941e-02f, 1.59248620e-01f, -6.46949708e-02f, -4.39675637e-02f, 3.38352323e-02f,
  5.07546552e-02f, -1.41640268e-02f, 1.44175336e-01f, -1.92325339e-01f, 2.29693055e-01f, 6.11983612e-02f, -1.69637084e-01f, 1.75956602e-03f, 1.44970402e-01f, 1.20242372e-01f,
  5.66170886e-02f, -7.46286986e-03f, -7.16455430e-02f, 1.09134488e-01f, 3.88346791e-01f, -1.09763734e-01f, 2.20363438e-01f, 6.96379840e-02f, -3.14137638e-01f, -1.36158109e-01f,
  1.36045679e-01f, 7.52374977e-02f, -1.46268532e-01f, -4.59699519e-03f, 7.98836797e-02f, -2.08209813e-01f, -7.28892311e-02f, 1.61382720e-01f, -1.30760759e-01f, -6.52302653e-02f,
  -2.88048506e-01f, 1.70185063e-02f, 1.26295999e-01f, -1.30251750e-01f, 2.85453349e-01f, -3.37565877e-02f, 2.29542679e-03f, 3.09914984e-02f, -1.17277307e-03f, 1.89819530e-01f,
  -1.89272240e-02f, -7.40858987e-02f, -4.46003266e-02f, -2.90284812e-01f, 1.88395023e-01f, -1.42997637e-01f, 1.31806985e-01f, -4.13872302e-02f, 1.62160531e-01f, -3.00458204e-02f,
  6.86380267e-02f, -4.97122854e-02f, 3.74557786e-02f, 2.32545555e-01f, -1.95598498e-01f, -3.77105847e-02f, 8.47762972e-02f, -1.56903803e-01f, 1.57420740e-01f, -2.15466321e-01f,
  -2.19478970e-04f, 4.26336825e-02f, 4.09744114e-01f, 1.16434231e-01f, 1.56460881e-01f, 1.73609465e-01f, 7.38296211e-02f, 1.42374963e-01f, 2.72484958e-01f, -3.00366193e-01f,
  -4.41113953e-03f, -2.72504747e-01f, 1.95638612e-01f, -1.24207906e-01f, 2.31145084e-01f, -2.27614433e-01f, 8.15216750e-02f, 1.00779839e-01f, -1.06379665e-01f, 7.97748119e-02f,
  -1.04059288e-02f, 2.12149456e-01f, -1.36096895e-01f, -6.19395748e-02f, 6.03756867e-02f, 1.16332933e-01f, -4.22308296e-01f, 9.06070769e-02f, 8.35467800e-02f, 1.69498146e-01f,
  2.04644799e-01f, 2.58395553e-01f, -6.79606795e-02f, 9.81577486e-02f, -2.64817238e-01f, 5.31366207e-02f, -1.12385355e-01f, 1.94175050e-01f, -9.52592865e-02f, 5.73624857e-02f,
  7.56879225e-02f, 8.32800418e-02f, 1.86625302e-01f, 1.07267603e-01f, 8.32825229e-02f, 9.87946838e-02f, -2.38834798e-01f, 1.59813538e-02f, -7.45627061e-02f, 1.57827407e-01f,
  2.26683561e-02f, -1.90258831e-01f, 2.41772652e-01f, 1.15138263e-01f, -2.81759910e-02f, 9.76994857e-02f, -3.26737165e-01f, -1.10351667e-01f, 1.82251051e-01f, -4.18182556e-03f,
  6.61501139e-02f, -1.08250841e-01f, 2.28405938e-01f, 1.59140721e-01f, 4.68429327e-02f, -1.56995669e-01f, -1.53975427e-01f, 2.05756098e-01f, 1.40884355e-01f, 8.33783597e-02f,
  2.81103398e-03f, 1.66626945e-01f, 2.02852428e-01f, 3.44450176e-02f, 1.12750672e-01f, 2.62676142e-02f, 1.38438726e-02f, 2.19984096e-04f, -1.93808690e-01f, -6.73016682e-02f,
  7.76608884e-02f, 9.89935473e-02f, -1.29581153e-01f, -2.45440573e-01f, 2.14528143e-01f, -1.97079465e-01f, -1.52876405e-02f, 1.30523488e-01f, 2.21199304e-01f, 1.14497952e-01f,
  -4.60707657e-02f, 3.29161465e-01f, 1.66742519e-01f, 1.41238734e-01f, 3.82214002e-02f, -2.93619901e-01f, -4.81191017e-02f, -7.87055045e-02f, 2.66806185e-01f, -1.47613466e-01f,
  -1.49251372e-01f, -1.55381888e-01f, 4.95065376e-02f, -6.56098202e-02f, 5.97755006e-03f, 1.55022368e-01f, 1.72945917e-01f, -6.17280882e-03f, 4.20187153e-02f, 1.95111170e-01f,
  -3.96592123e-03f, -7.92408660e-02f, 1.58289060e-01f, 4.07141559e-02f, -3.96279171e-02f, 2.60739792e-02f, 7.67437592e-02f, 1.67188659e-01f, -7.79251456e-02f, 3.16878200e-01f,
  7.52623081e-02f, -6.19871318e-02f, 4.09728363e-02f, 8.50841030e-02f, 9.89255030e-03f, 2.07160160e-01f, 2.58991510e-01f, -5.20951450e-02f, 2.61696726e-01f, 3.87916237e-01f,
  -8.90182629e-02f, -2.53163893e-02f, -4.25996035e-02f, 1.17720015e-01f, 1.53097630e-01f, 9.43554565e-02f, 5.09485565e-02f, -3.38052846e-02f, -2.58543760e-01f, 4.50477637e-02f,
  6.42476231e-02f, 1.91091076e-01f, 3.56080800e-01f, 1.40446365e-01f, -3.23529631e-01f, -1.46084800e-02f, -1.05772398e-01f, 1.81654260e-01f, -1.79678410e-01f, -1.20502539e-01f,
  -3.06151181e-01f, -4.64455895e-02f, -1.41868860e-01f, 1.01167597e-01f, 1.39457425e-02f, -1.14100002e-01f, 1.38441265e-01f, -1.32881939e-01f, 1.15748845e-01f, -7.08066151e-02f,
  1.20376639e-01f, -1.01375625e-01f, -1.41916454e-01f, 2.25270346e-01f, 4.76322733e-02f, 2.33693942e-01f, -3.64916921e-02f, -1.11509748e-01f, -1.94364283e-02f, -2.43767872e-02f,
  -1.02175914e-01f, 4.23434973e-02f, 4.03723270e-02f, -3.29913273e-02f, 5.45457937e-02f, 2.03747436e-01f, 3.74588817e-02f, 9.76329390e-03f, 2.33429819e-02f, 8.71335939e-02f,
  1.82982489e-01f, -8.41650516e-02f, 7.47586414e-02f, 8.12628865e-02f, -1.85921639e-01f, 1.24234324e-02f, 2.68282562e-01f, 7.36490712e-02f, -1.87873811e-01f, 2.15828754e-02f,
  -2.12486297e-01f, 2.00229228e-01f, 3.59142758e-02f, -4.40753922e-02f, 2.82042716e-02f, -1.18399061e-01f, 1.37706637e-01f, 1.94478389e-02f, 1.89271688e-01f, -2.01388359e-01f,
  -4.51140814e-02f, 1.42369187e-02f, 9.33501720e-02f, -4.96061407e-02f, -2.40395833e-02f, -1.43396720e-01f, 7.78480470e-02f, 1.35858268e-01f, 7.06893355e-02f, 1.09538704e-01f,
  2.22606286e-02f, -2.28101149e-01f, 1.10780925e-01f, -4.08913314e-01f, 9.13170427e-02f, 1.72105700e-01f, 2.50792474e-01f, 5.70064485e-02f, 8.40368196e-02f, 2.40926787e-01f,
  5.28530926e-02f, -3.11247796e-01f, -1.26776785e-01f, -2.06157252e-01f, 1.71159789e-01f, -2.05267698e-01f, 2.03582183e-01f, -8.75427052e-02f, -7.41113722e-03f, -5.60792238e-02f,
  1.42878786e-01f, -2.00978503e-01f, 9.80638936e-02f, -6.91859201e-02f, 1.91777930e-01f, 4.76622358e-02f, -4.99407686e-02f, 6.21106569e-03f, 2.40647063e-01f, -1.60414562e-01f,
  6.00991957e-02f, 1.03416331e-02f, -6.69437349e-02f, -1.50325850e-01f, -9.91008654e-02f, -1.20878257e-02f, 2.51885504e-01f, -5.95260561e-02f, 2.40730017e-01f, 1.03374310e-01f,
  -1.83480307e-01f, -4.64914814e-02f, -5.75940832e-02f, -3.19984034e-02f, -5.01864888e-02f, -9.39300358e-02f, 4.16033454e-02f, -3.19784060e-02f, -6.36683218e-03f, 8.02273229e-02f,
  1.50612500e-02f, -2.48926878e-02f, 2.08494011e-02f, -1.47892460e-01f, -7.24894851e-02f, -1.54059961e-01f, -1.88473299e-01f, 6.79047331e-02f, 2.60063022e-01f, 2.42144316e-02f,
  1.87444508e-01f, -4.30595018e-02f, -3.79128084e-02f, 1.34381011e-01f, -1.16351396e-01f, 2.01479897e-01f, -5.28647453e-02f, 2.89826721e-01f, -4.32756543e-02f, -5.46039722e-04f,
  1.76491309e-02f, -1.52193189e-01f, -2.94514205e-02f, -2.15132952e-01f, -4.57783788e-02f, 6.58208579e-02f, 1.23617709e-01f, 2.99294919e-01f, 7.60382786e-02f, 9.75499824e-02f,
  -2.01346174e-01f, 1.28125399e-01f, 1.94776908e-01f, 7.51933083e-02f, 6.77583963e-02f, 2.02588402e-02f, 2.29776695e-01f, 7.93633536e-02f, 8.83346573e-02f, 8.68800804e-02f,
  1.83051363e-01f, -7.28190318e-02f, 7.02186627e-03f, 1.52980924e-01f, -2.06636488e-01f, 8.89655277e-02f, -6.08458109e-02f, 1.94832414e-01f, 2.70678978e-02f, 2.93325216e-01f,
  1.97279453e-01f, 9.72253308e-02f, -2.99217571e-02f, -3.46109986e-01f, 3.07326823e-01f, 8.68155211e-02f, 8.87040049e-03f, -1.34737045e-01f, 1.87483415e-01f, -1.10287353e-01f,
  -1.67684942e-01f, 9.07219574e-02f, -3.89561772e-01f, 7.04491585e-02f, -2.69090861e-01f, -1.19085498e-01f, 1.34597689e-01f, 2.69151062e-01f, -1.96980312e-01f, -1.53670274e-03f,
  8.46242979e-02f, 1.60210535e-01f, 6.15063682e-02f, -1.60221219e-01f, 2.15276834e-02f, -8.70130062e-02f, -2.35970780e-01f, 9.11839530e-02f, 1.94671765e-01f, -1.57385264e-02f,
  -9.96040478e-02f, -1.43974990e-01f, -2.78876182e-02f, -7.75848776e-02f, 1.21517815e-01f, -1.15521148e-01f, -2.35632583e-01f, -1.27887666e-01f, -5.77562042e-02f, -4.91051488e-02f,
  1.15853578e-01f, 6.53038966e-04f, 1.26156762e-01f, -1.61252663e-01f, 1.49601862e-01f, 2.10738003e-01f, 2.11891741e-01f, -1.61333874e-01f, -2.78003871e-01f, 2.33722404e-01f,
  6.60952032e-02f, -3.98666635e-02f, 1.54134303e-01f, 4.83298376e-02f, 2.36742094e-01f, 8.77810791e-02f, -2.16989532e-01f, -1.81350529e-01f, 3.70610468e-02f, 1.34970158e-01f,
  1.96117312e-01f, -1.30580992e-01f, 6.25464246e-02f, 5.22810817e-02f, -4.42376547e-02f, -1.29092112e-01f, -2.22345829e-01f, 2.20560089e-01f, -1.76467881e-01f, -1.98947415e-01f,
  3.59578431e-02f, -1.28442720e-02f, 1.08837932e-01f, -5.17056063e-02f, -1.60787076e-01f, -9.99160111e-02f, 1.45830497e-01f, 5.96386604e-02f, 2.24687889e-01f, 7.16430619e-02f,
  -5.86044863e-02f, -4.51465622e-02f, 1.86409369e-01f, 5.94947860e-02f, 5.45127243e-02f, -1.47110090e-01f, -1.90116256e-01f, 2.12474599e-01f, -1.08456098e-01f, -4.44264524e-02f,
  1.51348174e-01f, 1.59083679e-01f, 2.12912150e-02f, 2.58059632e-02f, -4.48214263e-02f, 8.35059062e-02f, 1.68142077e-02f, 1.28454342e-01f, -1.24430060e-01f, 1.45643964e-01f,
  -8.26080218e-02f, 9.59447175e-02f, 1.97998911e-01f, 5.42999953e-02f, 2.71089673e-01f, 1.78495809e-01f, 3.10051609e-02f, 1.63400456e-01f, -7.16398284e-02f, -1.06051706e-01f,
  -6.82162866e-02f, -1.51586905e-01f, -1.64972909e-03f, -2.86508147e-02f, 1.38804153e-01f, 6.29257038e-02f, 1.62123993e-01f, -4.01523337e-02f, 3.13213617e-02f, 4.72460948e-02f,
  -4.57963757e-02f, 3.38710472e-02f, -2.32313983e-02f, -1.21149257e-01f, 7.29121128e-03f, -7.84490481e-02f, 1.99365020e-01f, -1.71116263e-01f, -2.40380794e-01f, -3.38088781e-01f,
  -2.86366995e-02f, -1.34964705e-01f, -2.23392788e-02f, -6.46906644e-02f, 2.29912430e-01f, 1.30725816e-01f, 2.74087697e-01f, 1.43562183e-01f, 4.38396074e-02f, -8.95943344e-02f,
  1.01408839e-01f, 1.49183258e-01f, 4.89420481e-02f, -3.62582989e-02f, 2.17733815e-01f, -3.98265896e-03f, -2.74162311e-02f, -1.00187898e-01f, -2.19403744e-01f, 1.26629218e-01f,
  8.59753340e-02f, 2.75426567e-01f, -1.10338405e-01f, 1.23998962e-01f, -2.25999728e-02f, 3.10770184e-01f, -2.80386627e-01f, 4.56824571e-01f, 5.67837916e-02f, 8.19107667e-02f,
  4.08591658e-01f, -1.17149660e-02f, -1.22615039e-01f, 9.96781141e-02f, 1.90779284e-01f, -5.63983582e-02f, 1.11629263e-01f, 1.36588648e-01f, 5.15695587e-02f, 2.79628605e-01f,
  -7.14623481e-02f, 4.39121807e-03f, -1.08452976e-01f, -1.22829333e-01f, 1.82260722e-01f, 1.44241974e-01f, -2.51830488e-01f, 1.74424827e-01f, 8.00264850e-02f, 3.02918367e-02f,
  8.86105448e-02f, 9.71273109e-02f, 6.98663592e-02f, 2.00195491e-01f, -8.34540557e-03f, -1.66168854e-01f, 3.31627309e-01f, -1.13879532e-01f, -8.84855613e-02f, -1.04878187e-01f,
  7.11498037e-02f, 1.40444845e-01f, 4.93590496e-02f, 2.49630764e-01f, 1.17824674e-01f, 1.47437394e-01f, -3.10967773e-01f, 9.74729583e-02f, -2.56313413e-01f, 1.78843275e-01f,
  -1.46234572e-01f, -1.04922503e-01f, 2.81840116e-01f, 2.77419657e-01f, 1.32509038e-01f, -7.68175870e-02f, -2.42588879e-03f, 4.15735431e-02f, -2.42941082e-01f, -2.21562833e-01f,
  8.91533792e-02f, -1.99652150e-01f, -2.38790050e-01f, -2.69255608e-01f, 2.55162328e-01f, -1.78403094e-01f, 7.70472288e-02f, 2.07099423e-01f, -4.99574877e-02f, -4.62297611e-02f,
  -1.49676964e-01f, 1.74843930e-02f, -3.52379471e-01f, -5.25758527e-02f, -1.70519873e-01f, -1.29174188e-01f, -3.07058520e-03f, 1.67773049e-02f, -1.05385870e-01f, -1.28841579e-01f,
  9.68621951e-03f, 4.82628085e-02f, 2.51033157e-01f, 1.44447371e-01f, -6.27868623e-02f, 1.95843711e-01f, -3.14137451e-02f, 1.04648672e-01f, -2.86501169e-01f, -1.77947670e-01f,
  7.69075332e-03f, 4.35153313e-04f, 4.66666669e-02f, -1.84207484e-02f, -2.44129933e-02f, 8.71177018e-02f, 1.25622079e-01f, 9.75775998e-03f, -1.81161854e-02f, 2.51495421e-01f,
  -1.72587216e-01f, 1.65431544e-01f, -7.21932426e-02f, 7.70951286e-02f, 5.81123680e-02f, 2.73739517e-01f, -4.10605446e-02f, 8.99516121e-02f, -4.62695658e-02f, -3.77648801e-01f,
  3.36870611e-01f, 1.24828279e-01f, 1.00978054e-01f, -1.98411316e-01f, 2.80159771e-01f, -7.80765861e-02f, -1.27951890e-01f, 1.12989023e-01f, -1.51523992e-01f, 1.07991390e-01f,
  -5.55310119e-03f, -1.49971411e-01f, 2.15397552e-01f, 1.31004393e-01f, -4.39418219e-02f, -2.13208348e-01f, 1.83820575e-01f, 4.74821851e-02f, -7.15097263e-02f, -1.77278250e-01f,
  -4.16254327e-02f, -9.36442688e-02f, -1.98780578e-02f, 1.41931862e-01f, 1.56081393e-02f, -1.95124596e-01f, -4.98921946e-02f, -3.08417052e-01f, -6.39296472e-02f, 1.92243397e-01f,
  2.05326170e-01f, -6.46846667e-02f, -1.32983699e-01f, 1.64591536e-01f, 4.96797599e-02f, 1.35832503e-01f, 1.20175898e-01f, -2.84709662e-01f, -5.96020184e-02f, -9.01654661e-02f,
  2.53529340e-01f, 4.90452237e-02f, -1.15877204e-01f, -1.12275042e-01f, -3.87553185e-01f, 9.14937183e-02f, 1.13610789e-01f, -3.30118127e-02f, 6.27697958e-03f, 2.00966269e-01f,
  2.33272523e-01f, -1.92470104e-03f, 2.48228908e-01f, -9.81796607e-02f, -4.08845767e-02f, -1.19951323e-01f, -1.76996768e-01f, -2.63019830e-01f, -1.09171890e-01f, 7.31330961e-02f,
  1.70293361e-01f, 2.20858827e-02f, 7.11467713e-02f, 2.23517045e-02f, 1.20463803e-01f, 9.25537422e-02f, 2.33684778e-01f, -1.58683270e-01f, 1.18290238e-01f, 1.18053317e-01f,
  -6.69197142e-02f, 9.94443223e-02f, -6.17617704e-02f, 2.91495007e-02f, 1.38117611e-01f, 1.48421332e-01f, 6.39719367e-02f, -6.19787499e-02f, 1.16844438e-02f, -2.48846218e-01f,
  9.14680399e-03f, 1.28289923e-01f, 1.39773533e-01f, 1.00569325e-02f, -8.08795094e-02f, -1.87520489e-01f, 3.34353417e-01f, 1.23117760e-01f, -2.54971464e-03f, -2.02649664e-02f,
  1.21168017e-01f, 2.83970386e-01f, 1.32650182e-01f, -4.66951802e-02f, 2.78878093e-01f, 2.88311136e-03f, -4.32593286e-01f, 1.11593872e-01f, 3.67579013e-02f, -5.10732979e-02f,
  9.68371779e-02f, 2.86115885e-01f, -1.47175089e-01f, 1.99000493e-01f, 1.89159900e-01f, -3.31691653e-02f, 4.33843806e-02f, -4.23593253e-01f, 6.84307665e-02f, 1.29013494e-01f,
  1.17395133e-01f, 4.05813664e-01f, 1.95494071e-01f, 1.41381174e-01f, 1.77272156e-01f, 1.41821757e-01f, -1.83188543e-01f, 2.09706221e-02f, -2.86527444e-02f, 6.73729554e-02f,
  3.07688683e-01f, -2.41915554e-01f, 1.34888530e-01f, 8.01687241e-02f, -1.86823487e-01f, -3.01733036e-02f, -1.94444150e-01f, 7.25328997e-02f, -5.30271046e-02f, -7.23327175e-02f,
  -3.07136215e-02f, -3.44256163e-01f, 2.58747935e-01f, -1.93052858e-01f, -3.03681523e-01f, -2.81571209e-01f, 2.05584884e-01f, -8.27997625e-02f, -2.84430571e-02f, -9.48110893e-02f,
  3.29878591e-02f, 2.77417094e-01f, 2.59880722e-02f, 5.25531285e-02f, 2.22864449e-02f, -1.31324321e-01f, -1.96948424e-01f, 1.14345871e-01f, -1.14803433e-01f, -8.37420579e-03f,
  1.39212757e-01f, 2.12147787e-01f, 5.41363284e-02f, -5.34700677e-02f, 9.09452289e-02f, -2.58685201e-01f, -2.14045510e-01f, 1.69802513e-02f, -1.70308262e-01f, -1.17027231e-01f,
  7.53565431e-02f, 6.96235821e-02f, 2.45439276e-01f, 1.50238648e-01f, 8.25633183e-02f, -2.66221166e-01f, -6.34736568e-02f, 3.97648551e-02f, -1.03198186e-01f, 1.50490344e-01f,
  2.87437048e-02f, 4.12770569e-01f, 2.33416945e-01f, 4.63168919e-02f, 2.78016776e-01f, 2.02619985e-01f, 6.99150935e-02f, 2.02104375e-01f, 1.64473936e-01f, 1.71813872e-02f,
  -1.72585562e-01f, 2.56400183e-02f, 8.92136693e-02f, -9.61358771e-02f, 3.44056822e-02f, 3.12188081e-02f, 1.63807958e-01f, -1.77145943e-01f, -1.89437464e-01f, 1.83472171e-01f,
  -3.42336223e-02f, 1.29375935e-01f, 4.63216566e-02f, 8.58472735e-02f, 5.33608869e-02f, 1.86945945e-01f, -7.54334731e-03f, 1.06118836e-01f, 7.50793293e-02f, -9.45537686e-02f,
  1.64477989e-01f, -1.64162502e-01f, -1.67413384e-01f, -1.43205732e-01f, 1.17278472e-01f, 2.71854639e-01f, -2.59458989e-01f, 1.94727257e-01f, -1.50985867e-01f, 9.70177874e-02f,
  -1.19011946e-01f, 2.41789874e-02f, 9.35719088e-02f, 1.92233220e-01f, -2.66780645e-01f, 8.55198409e-03f, 8.26125145e-02f, 2.46691048e-01f, 1.93042122e-02f, -1.60045832e-01f,
  4.37243422e-03f, -2.50697434e-02f, -1.93369061e-01f, -8.95604864e-02f, 3.10306847e-01f, -8.05328507e-03f, -1.01088122e-01f, 2.74326742e-01f, 2.61386875e-02f, -4.65819165e-02f,
  -1.75107598e-01f, -2.05467626e-01f, -2.92675979e-02f, 6.66967407e-02f, 2.43188795e-02f, 5.34985960e-01f, 1.43321514e-01f, -2.62375355e-01f, 1.76934510e-01f, 3.74477327e-01f,
  1.08691350e-01f, 3.20561647e-01f, 6.27757609e-02f, 1.42905042e-01f, 1.48309525e-02f, 9.94278044e-02f, 1.59647781e-02f, 5.35030998e-02f, 1.04043111e-01f, -2.23536357e-01f,
  -1.79163188e-01f, 1.39580846e-01f, 3.31897825e-01f, 1.21782906e-01f, -6.36951402e-02f, 2.09829733e-01f, 1.48292512e-01f, 2.80961040e-02f, 1.45105630e-01f, -1.49434358e-01f,
  -5.22557348e-02f, 1.74814776e-01f, -2.13271584e-02f, -1.51416138e-02f, 1.48576602e-01f, -7.02470243e-02f, 1.42859071e-01f, 5.70711941e-02f, -1.51896596e-01f, 1.61741823e-01f,
  -1.30249798e-01f, -8.88143703e-02f, 1.60801664e-01f, 8.65711048e-02f, -3.47417057e-01f, -1.11958891e-01f, 7.36468434e-02f, -1.14525378e-01f, 3.76054108e-01f, 1.53728381e-01f,
  4.48691010e-01f, -2.52831101e-01f, 1.75316066e-01f, -4.31359112e-02f, 2.13034917e-02f, -3.03391684e-02f, 2.26691384e-02f, 1.02758661e-01f, -2.12203071e-01f, 1.40391469e-01f,
  4.44853418e-02f, 1.94969490e-01f, -2.03823354e-02f, -9.67117101e-02f, -1.18327230e-01f, 2.10998908e-01f, 3.93330976e-02f, 1.54991820e-01f, -7.80135673e-03f, 1.19909756e-01f,
  2.65052229e-01f, -5.45551591e-02f, 2.12419093e-01f, 1.86845884e-01f, 1.85552642e-01f, 1.65001214e-01f, 5.06130233e-02f, 2.44175732e-01f, 8.55651200e-02f, 2.71968126e-01f,
  -4.39186096e-02f, 3.87435295e-02f, -1.66237846e-01f, 2.68231835e-02f, 5.96908852e-03f, 6.29567578e-02f, 8.89634416e-02f, -8.07748586e-02f, 1.50702894e-01f, -1.64580382e-02f,
  1.67986274e-01f, 1.11964196e-01f, -1.95525751e-01f, 1.85042471e-02f, 4.32598293e-02f, 3.43918316e-02f, -1.07296005e-01f, -1.76323891e-01f, -9.90139097e-02f, 1.03435880e-02f,
  -2.03447133e-01f, 7.66182244e-02f, -3.17872651e-02f, 2.50316262e-01f, -1.40948370e-01f, 2.17370450e-01f, 1.17581272e-02f, 1.47701308e-01f, -1.10050395e-01f, 3.37655060e-02f,
  2.04726309e-01f, 9.25124884e-02f, -3.49042654e-01f, -1.22425802e-01f, 2.86893487e-01f, 1.56732142e-01f, -9.50033218e-02f, -1.71952158e-01f, 2.50005871e-01f, -5.82172945e-02f,
  2.74656974e-02f, -6.07501855e-03f, 6.44371882e-02f, 5.54113351e-02f, -2.34899804e-01f, 1.01569153e-01f, 6.18413799e-02f, -2.00948089e-01f, -1.25706136e-01f, -1.50657684e-01f,
  -2.34236233e-02f, 1.26638308e-01f, 1.46984935e-01f, 2.88591415e-01f, -1.42064933e-02f, 1.13226734e-01f, 2.02391997e-01f, 1.76615715e-01f, 2.02193975e-01f, 1.79253370e-01f,
  3.71374632e-03f, 1.95848510e-01f, 8.29506069e-02f, -3.60014699e-02f, 2.01846644e-01f, -4.17264402e-02f, -1.45416677e-01f, 1.46845043e-01f, 1.38942283e-02f, 6.00772649e-02f,
  2.21318901e-01f, -8.61908682e-03f, 3.14546138e-01f, -5.75841079e-03f, -2.88802862e-01f, 5.88347502e-02f, -2.98541307e-01f, 3.23326051e-01f, -3.32610235e-02f, 5.96898124e-02f,
  -1.28361862e-02f, -1.58227980e-02f, 5.57222627e-02f, -9.59156603e-02f, -2.93829348e-02f, 1.62531391e-01f, -8.18618238e-02f, -2.20537663e-01f, 8.46886169e-03f, 1.07008226e-01f,
  -9.90164354e-02f, 8.54046643e-02f, 7.87663907e-02f, 1.50031194e-01f, 1.42210558e-01f, 2.09803462e-01f, -3.06941777e-01f, -4.04532366e-02f, 7.13182017e-02f, 1.86736211e-01f,
  -1.36685938e-01f, 1.90352812e-01f, -5.32337166e-02f, -6.43275678e-02f, -1.58776820e-01f, -6.36542588e-03f, -6.56254068e-02f, -2.24349901e-01f, -1.70431450e-01f, 1.76199677e-03f,
  1.67552575e-01f, 2.95235962e-01f, -2.22631302e-02f, -2.84246393e-02f, 1.06070861e-02f, 1.59387052e-01f, 1.84452776e-02f, -1.93890005e-01f, -1.70177862e-01f, 6.36274293e-02f,
  -1.83680186e-06f, 3.79949212e-01f, 2.39205569e-01f, 2.07712203e-01f, 7.11357817e-02f, 1.72214240e-01f, -1.32732540e-01f, 9.45421532e-02f, 3.66533138e-02f, 5.35289757e-02f,
  2.91560650e-01f, 2.27934718e-02f, -1.80504918e-02f, 3.32608372e-01f, -1.21800385e-01f, 1.15436941e-01f, -3.32847208e-01f, -7.91198984e-02f, 2.49423862e-01f, -2.69989278e-02f,
  1.64920315e-01f, -3.31599489e-02f, -2.59063039e-02f, 6.17509782e-02f, 4.40626293e-02f, 1.33096188e-01f, 1.65951923e-01f, 2.10604250e-01f, 3.61504126e-03f, -6.94065690e-02f,
  6.75121471e-02f, 2.40858749e-01f, 3.85515504e-02f, -3.34474295e-01f, 1.60331503e-01f, -5.96167855e-02f, 1.59613028e-01f, -2.74002075e-01f, -5.69802076e-02f, 1.74734265e-01f,
  1.26121745e-01f, 6.81483671e-02f, -7.54267275e-02f, -9.82295200e-02f, -2.28149295e-02f, -2.79215813e-01f, -9.28206891e-02f, 1.45068452e-01f, 1.90760881e-01f, -1.35201678e-01f,
  -1.95798919e-01f, 1.79371610e-03f, 1.76125348e-01f, 1.40564620e-01f, 1.36008218e-01f, -1.11873224e-01f, -1.11265287e-01f, 1.25304267e-01f, 2.17804849e-01f, -1.24384664e-01f,
  -8.89221877e-02f, 8.18548165e-03f, 4.28982116e-02f, -4.61033508e-02f, 1.68216586e-01f, 1.41197428e-01f, 1.10847667e-01f, 9.88770127e-02f, 2.16528296e-01f, 4.15238477e-02f,
  -1.82716221e-01f, -4.36943304e-03f, -3.82909924e-02f, 1.58662617e-01f, 1.65916860e-01f, 5.86557493e-04f, 5.74431159e-02f, 1.33077979e-01f, 5.70094846e-02f, 6.24223761e-02f,
  -3.11506152e-01f, 1.57973230e-01f, 3.59691322e-01f, 1.06460683e-01f, 1.34149328e-01f, -2.62878090e-01f, -2.41602939e-02f, 1.04861051e-01f, -6.15164591e-03f, -7.45206252e-02f,
  3.24442633e-03f, -1.94684416e-02f, 2.02033073e-02f, -2.69297119e-02f, 8.37762058e-02f, 1.03630222e-01f, 1.46373706e-02f, 2.44249865e-01f, 2.62159467e-01f, 2.46913970e-01f,
  4.53056535e-03f, -2.00476587e-01f, -2.54860044e-01f, 6.26845956e-02f, 2.69746363e-01f, -6.70923665e-02f, 3.53886485e-01f, -2.53045857e-01f, 3.36913109e-01f, -2.43652329e-01f,
  5.02440473e-03f, 1.42622575e-01f, 2.40460932e-01f, 9.60404947e-02f, -6.80808723e-02f, 2.96933819e-02f, -8.10960233e-02f, 1.85815692e-01f, -1.01509310e-01f, -1.46580160e-01f,
  -7.36593828e-02f, -9.22627002e-02f, 8.38669688e-02f, -7.08742812e-02f, -7.48529062e-02f, -2.08314389e-01f, 4.22547221e-01f, 1.24290586e-02f, 9.83576551e-02f, 4.38156314e-02f,
  1.05251722e-01f, 2.50371303e-02f, 1.07503168e-01f, 4.50189523e-02f, 1.01590291e-01f, 8.10895935e-02f, -3.80016379e-02f, -8.41921046e-02f, 5.33841364e-02f, 1.04885586e-01f,
  8.39449465e-02f, -3.62491369e-01f, -4.17477265e-02f, -2.22344249e-01f, 1.72915459e-01f, 1.78673863e-01f, -1.28564820e-01f, 1.92092001e-01f, 1.24138057e-01f, -2.94303685e-01f,
  2.24129960e-01f, 9.33968797e-02f, -7.36350492e-02f, -3.25567007e-01f, 2.36658052e-01f, 7.65415207e-02f, -4.24767956e-02f, -1.04668200e-01f, -2.72381268e-02f, -6.29000366e-02f,
  -4.38715192e-03f, -1.71546295e-01f, -1.47583872e-01f, 9.63876992e-02f, 2.19020560e-01f, -2.64255345e-01f, 1.16373889e-01f, -4.09201905e-02f, -1.43504795e-02f, 1.89562172e-01f,
  -2.18078941e-01f, -1.90738618e-01f, 5.46666719e-02f, 2.45018676e-01f, 2.05377832e-01f, 5.86419366e-02f, 3.32902819e-02f, -4.80077825e-02f, -1.00827068e-01f, -2.48128995e-01f,
  -2.48709679e-01f, 3.59306961e-01f, 1.98020115e-01f, 3.79905581e-01f, 1.87815845e-01f, 7.63673782e-02f, 2.38694161e-01f, 3.53177264e-02f, 2.34460130e-01f, 3.24135453e-01f,
  1.74948871e-02f, 2.94537377e-02f, -7.79620335e-02f, -4.05719317e-02f, 1.05832569e-01f, 1.10436864e-01f, 1.63061455e-01f, -4.89443634e-03f, 1.41518280e-01f, 7.73023888e-02f,
  -3.00472796e-01f, 7.95155019e-02f, -1.73807666e-01f, -2.23656860e-03f, -2.33138561e-01f, 8.49359035e-02f, 1.16165675e-01f, 4.85060140e-02f, 2.36774817e-01f, -1.47265896e-01f,
  1.34106368e-01f, 1.02303006e-01f, 1.48337752e-01f, -1.96150631e-01f, 9.00040939e-02f, 9.50788781e-02f, -6.54429346e-02f, -1.36096343e-01f, -2.98779637e-01f, 2.25442111e-01f,
  -6.88328519e-02f, -2.06945792e-01f, 1.79005221e-01f, 2.42265016e-02f, -9.83278453e-02f, -8.90813991e-02f, -1.95664167e-01f, 2.66234130e-01f, -3.76461744e-02f, 2.56015602e-02f,
  -4.03003842e-02f, -1.69842079e-01f, 3.10667127e-01f, 3.11548293e-01f, 1.77512944e-01f, 1.13084301e-01f, 4.98591326e-02f, 3.34459037e-01f, 1.29430711e-01f, 1.13297552e-02f,
  1.90447971e-01f, 3.69494897e-03f, -2.01217875e-01f, 7.61601627e-02f, 1.08486384e-01f, -1.09103225e-01f, -1.24972254e-01f, 1.82027280e-01f, -1.63395718e-01f, 6.23481125e-02f,
  5.85145317e-02f, -3.98556292e-02f, 2.18778744e-01f, -2.19273448e-01f, -2.24413365e-01f, 3.25549453e-01f, -4.21979912e-02f, -1.04341663e-01f, -1.77479105e-03f, -9.18209145e-04f,
  -1.20578576e-02f, -1.71468288e-01f, 1.65938884e-01f, 5.92796281e-02f, -5.75159863e-02f, -2.15569198e-01f, -4.72364612e-02f, 4.05403739e-03f, 5.98330460e-02f, -2.09125727e-01f,
  1.19668886e-01f, 1.16493993e-01f, 7.45752454e-02f, -5.79774939e-02f, -4.48819064e-02f, -2.34645028e-02f, 3.72908004e-02f, -1.26290992e-01f, 5.94501644e-02f, -6.17468506e-02f,
  -1.07527122e-01f, 3.08064129e-02f, -2.57709414e-01f, 2.19910011e-01f, 1.31150335e-01f, -2.88532376e-01f, 1.08057678e-01f, -1.76098451e-01f, 1.12244748e-01f, -7.84888044e-02f,
  -1.80907384e-01f, 8.19211751e-02f, 2.66006738e-02f, -1.62470624e-01f, 3.39807458e-02f, -9.49927568e-02f, -5.95993102e-02f, 1.59272328e-01f, -3.13004181e-02f, -1.83351383e-01f,
  2.42851883e-01f, 1.58771887e-01f, -2.33917043e-01f, -4.05121334e-02f, 6.80567324e-02f, -1.82560936e-01f, -6.09584525e-02f, 3.20289284e-02f, 9.52038318e-02f, -2.00684126e-02f,
  -3.03105768e-02f, 1.86104089e-01f, -1.17419735e-01f, -1.33560104e-02f, -4.53353785e-02f, 5.35217896e-02f, 1.26352027e-01f, -8.86380672e-03f, -1.27550468e-01f, 1.41768694e-01f,
  2.39115193e-01f, 2.22160444e-01f, 2.39361376e-01f, 3.27494115e-01f, 1.07722677e-01f, 8.41976553e-02f, 2.35663522e-02f, 3.23702805e-02f, 1.13554280e-02f, 4.83544022e-02f,
  1.73826933e-01f, 8.66263658e-02f, 2.45356590e-01f, 2.75740206e-01f, 9.84485075e-02f, -1.13305032e-01f, -1.73652515e-01f, 2.50240773e-01f, -4.20964248e-02f, -1.51754066e-01f,
  7.44115561e-02f, -2.53515184e-01f, -7.91100413e-02f, -5.85784949e-02f, -2.04323620e-01f, -5.81128001e-02f, 7.43946731e-02f, 1.32109120e-01f, 1.00940317e-01f, 7.87396953e-02f,
  1.26606226e-01f, 1.46997571e-01f, 2.73253787e-02f, 1.07321329e-01f, 3.47491801e-02f, -1.44900337e-01f, 1.23050496e-01f, -7.60178780e-03f, 3.94477025e-02f, 4.82083205e-03f,
  -4.70310524e-02f, 3.62756312e-01f, 2.76329756e-01f, -6.87824935e-02f, 1.90454274e-02f, -2.11539894e-01f, -2.86750644e-01f, 2.52201427e-02f, -1.94428172e-02f, 8.69491622e-02f,
  -1.34869680e-01f, 2.32029818e-02f, 3.68478075e-02f, 2.11381689e-01f, 4.38007638e-02f, -1.21375725e-01f, 1.79525313e-03f, -2.92482469e-02f, 3.77755761e-02f, 1.14347704e-01f,
  7.04181790e-02f, 3.46119821e-01f, 1.64794818e-01f, 6.60134479e-03f, -1.00824367e-02f, 2.25199819e-01f, 8.75071064e-02f, 2.69041002e-01f, 3.47063281e-02f, 1.51168168e-01f,
  -1.68516815e-01f, -2.63660908e-01f, 1.40765533e-01f, 1.34952843e-01f, -3.36808711e-02f, -2.20179424e-01f, 2.72971600e-01f, 8.80129635e-02f, -1.00635096e-01f, -2.05646902e-01f,
  -3.28129083e-01f, 1.80762604e-01f, -4.29142356e-01f, -1.76095128e-01f, 3.71988229e-02f, 1.18755318e-01f, 4.75185961e-02f, -2.34855935e-01f, -4.74538878e-02f, 6.02370687e-02f,
  2.19000354e-01f, -5.61656803e-02f, 9.96875241e-02f, 1.18128516e-01f, -1.13505028e-01f, 6.81129918e-02f, 2.35233441e-01f, 1.24381214e-01f, 8.78265947e-02f, -2.63223261e-01f,
  4.78690341e-02f, 1.85991809e-01f, 5.31102158e-03f, -5.47156557e-02f, 9.76168662e-02f, 1.07380532e-01f, 2.47942265e-02f, 3.27422917e-02f, 1.30383089e-01f, -5.04425131e-02f,
  -2.64449805e-01f, 1.58830639e-02f, -1.37094572e-01f, -5.41444719e-02f, -2.20107034e-01f, 1.28675669e-01f, 1.65354267e-01f, 1.37534782e-01f, 2.44759902e-01f, 1.14312060e-01f,
  -1.91918939e-01f, 1.79473236e-01f, 8.85001197e-02f, -1.77154228e-01f, -2.61250913e-01f, -3.06321494e-02f, 7.50074536e-02f, -1.56802595e-01f, 2.67074928e-02f, -6.05717413e-02f,
  -4.14380170e-02f, 4.50421348e-02f, 3.63869295e-02f, 1.92907915e-01f, 4.18638326e-02f, 1.80884749e-01f, 1.00745313e-01f, 1.53570816e-01f, -8.96535069e-02f, 1.02885559e-01f,
  -2.12967098e-01f, 2.34103635e-01f, -1.37156442e-01f, 4.30326313e-02f, -2.04046637e-01f, 1.78241020e-03f, 1.90468237e-01f, 1.64449319e-01f, 6.43580630e-02f, 2.77586514e-03f,
  -9.27294791e-02f, 2.04106644e-01f, -9.49125066e-02f, 5.27636036e-02f, 1.04216807e-01f, 1.62759051e-02f, -5.41056320e-02f, 4.27482314e-02f, -1.26138613e-01f, 1.20514277e-02f,
  -1.41620874e-01f, 8.62906948e-02f, 6.18671514e-02f, 1.70413837e-01f, 9.58594531e-02f, 4.74202521e-02f, -1.40285045e-02f, 3.51139680e-02f, 2.82922179e-01f, 1.36746049e-01f,
  -1.29644632e-01f, 2.67827690e-01f, -2.28807405e-01f, 1.24710508e-01f, 3.48183542e-01f, 8.18099603e-02f, 4.76488993e-02f, 5.11142239e-03f, -8.79162699e-02f, -2.60997694e-02f,
  1.50898159e-01f, -4.07915078e-02f, -2.80184746e-02f, 1.83371287e-02f, -3.30190826e-03f, 2.20002741e-01f, 3.46885026e-01f, 6.85501993e-02f, -4.47947383e-02f, -1.80350929e-01f,
  -1.22616127e-01f, -2.55158879e-02f, 2.10404456e-01f, 2.09145650e-01f, 1.87328205e-01f, 4.99480926e-02f, 2.05367118e-01f, 1.91651016e-01f, 8.16246569e-02f, -8.26977100e-03f,
  -1.50295243e-01f, -1.64358750e-01f, 1.06268056e-01f, -1.01064563e-01f, 1.87530264e-01f, -3.36608499e-01f, -8.23712200e-02f, -1.28440738e-01f, 3.40271257e-02f, -1.58614904e-01f,
  1.60621300e-01f, 1.09467216e-01f, 2.92866379e-01f, -7.61246011e-02f, 4.16923016e-01f, 4.43607755e-03f, 9.04701427e-02f, -2.79544860e-01f, 1.97144113e-02f, 1.96276501e-01f,
  -9.36939642e-02f, -1.02782883e-01f, 8.57144371e-02f, 2.75589675e-01f, -7.62731954e-02f, -2.44949907e-01f, 2.78858021e-02f, 2.12334424e-01f, -1.76629975e-01f, -2.60313779e-01f,
  -1.00426212e-01f, 2.39694235e-03f, 1.79658994e-01f, 9.74706784e-02f, -3.52333814e-01f, -1.22701697e-01f, 9.71437246e-02f, -4.27752957e-02f, 6.56784326e-02f, -4.48242165e-02f,
  1.86963622e-02f, -2.06386834e-01f, -3.82756218e-02f, -2.82998174e-01f, -1.61838695e-01f, 2.90317595e-01f, 4.95452285e-02f, -9.92998597e-04f, 1.22747712e-01f, 8.11414234e-03f,
  -7.69472867e-03f, 1.32104397e-01f, 1.44081727e-01f, 3.52013260e-01f, 1.66916370e-01f, 1.99347600e-01f, 5.57273701e-02f, 1.53474197e-01f, 1.14931557e-02f, 1.14742674e-01f,
  1.63848802e-01f, 1.29612545e-02f, 1.14058301e-01f, -1.29619718e-01f, -1.55250549e-01f, -7.89279640e-02f, 1.29516467e-01f, -1.47404015e-01f, 1.86413944e-01f, -7.76070803e-02f,
  1.92954436e-01f, -2.16226093e-02f, 1.76755115e-01f, 1.31498963e-01f, -8.13086107e-02f, -1.03403464e-01f, -3.84577699e-02f, 1.50105760e-01f, -1.11024082e-01f, -6.66474402e-02f,
  -1.50649726e-01f, -1.75981894e-01f, 9.69333127e-02f, 1.68368250e-01f, -3.31206806e-02f, -1.41676785e-02f, 7.73881078e-02f, -5.56479096e-02f, 1.52233154e-01f, -1.07352026e-01f,
  -3.72249424e-01f, 1.73320949e-01f, 1.66325465e-01f, 1.27017081e-01f, 1.12621665e-01f, -1.30378827e-01f, 5.16886115e-02f, 1.60703570e-01f, 9.14024562e-02f, -7.77209774e-02f,
  -1.81316910e-03f, 1.55331001e-01f, -1.78078517e-01f, -5.69545142e-02f, 2.28907153e-01f, 3.60607058e-02f, -7.15212896e-03f, 3.95749174e-02f, 1.20998500e-02f, 7.81340897e-02f,
  1.57876000e-01f, 8.76319502e-03f, 2.37222062e-03f, 1.56396218e-02f, -1.37484625e-01f, 1.56069264e-01f, 1.51714161e-01f, -9.98860318e-03f, -3.04697771e-02f, 2.07390562e-01f,
  5.20539321e-02f, 1.84027761e-01f, 1.40449211e-01f, 1.69282064e-01f, 7.79440403e-02f, 3.44001144e-01f, 9.34733450e-03f, 1.52073011e-01f, 1.45762309e-01f, -1.26455836e-02f,
  7.63816237e-02f, 6.22611567e-02f, 1.47129595e-01f, 8.77908021e-02f, 8.20989087e-02f, 1.30509511e-01f, -1.18439309e-02f, 2.02493757e-01f, -1.33326441e-01f, 1.30397737e-01f,
  -1.38185740e-01f, 1.22282930e-01f, -9.98812467e-02f, 1.91527177e-02f, 2.41962969e-01f, 1.63513049e-01f, -7.47225154e-03f, -3.53159696e-01f, -6.02459051e-02f, 6.45610970e-03f,
  -5.67047782e-02f, -9.39867571e-02f, 1.01405218e-01f, 1.64994940e-01f, -5.43849915e-02f, 1.64313957e-01f, -6.40704930e-02f, 2.03156203e-01f, 1.43164799e-01f, 2.37794831e-01f,
  2.50003468e-02f, -3.35153908e-01f, 2.00395033e-01f, 5.75474091e-02f, 1.95359573e-01f, -1.49442449e-01f, 1.97184756e-01f, 8.43174662e-03f, -1.38818072e-02f, 5.17546721e-02f,
  4.59625386e-02f, -1.46816485e-02f, 6.74075633e-02f, -1.03989221e-01f, 2.99145877e-02f, -7.89204687e-02f, -1.40716165e-01f, -1.22509524e-01f, -7.99535215e-02f, 1.30402222e-01f,
  -3.73765938e-02f, -9.32448730e-02f, 2.09554091e-01f, -2.04367206e-01f, 5.84487356e-02f, 8.15305486e-02f, 2.24132255e-01f, 2.23488703e-01f, 1.92042023e-01f, 1.28274918e-01f,
  1.03789657e-01f, 2.81785894e-02f, -1.49592921e-01f, 1.27616137e-01f, -1.32081792e-01f, -1.60570014e-02f, 1.60236448e-01f, 1.80989802e-01f, 1.28740892e-01f, 2.35049143e-01f,
  3.20726670e-02f, 2.64368176e-01f, 5.77412732e-02f, -3.75292376e-02f, -7.94344395e-02f, -7.04359561e-02f, -7.48555064e-02f, -1.41149282e-01f, 1.52905226e-01f, 3.35133970e-01f,
  -6.41503930e-02f, -1.46603659e-01f, -2.15591848e-01f, 7.41392151e-02f, 1.95736736e-01f, -1.02202676e-01f, 2.86467019e-02f, 5.48884124e-02f, 1.76997706e-02f, 5.82900867e-02f,
  8.99831504e-02f, -2.76169956e-01f, 3.11952621e-01f, 8.27837884e-02f, -1.80517942e-01f, 1.14736095e-01f, 4.79832798e-01f, 2.60921307e-02f, 1.34871840e-01f, 7.43134394e-02f,
  -3.10690373e-01f, -5.17662503e-02f, 4.91647758e-02f, -2.61393815e-01f, 1.94452807e-01f, -1.86952755e-01f, 4.66114320e-02f, -3.75949107e-02f, -5.30027114e-02f, -1.40304103e-01f,
  9.18733627e-02f, -1.66837856e-01f, -1.11491717e-01f, 2.67974913e-01f, 9.74614769e-02f, -5.43776862e-02f, 1.03067644e-01f, -1.91172045e-02f, 2.37344921e-01f, 7.97419697e-02f,
  -1.06806017e-01f, 3.11632067e-01f, 1.90480232e-01f, 3.22955489e-01f, 1.05596937e-01f, 1.28581859e-02f, 1.17093369e-01f, 1.92844152e-01f, -1.95209801e-01f, -1.92243736e-02f,
  -8.25298391e-03f, 4.22063619e-02f, 2.36061156e-01f, 1.40263801e-02f, 4.51272786e-01f, 1.17264546e-01f, 2.81253885e-02f, 1.13114022e-01f, -2.84650207e-01f, 6.65082112e-02f,
  -3.97854000e-01f, 2.09489122e-01f, 1.74003765e-01f, -6.71293307e-03f, -2.11054683e-01f, -2.65074670e-01f, -4.31947410e-02f, 8.36679712e-02f, -1.21985160e-01f, -4.48556781e-01f,
  1.35832593e-01f, 1.63243487e-01f, 1.37785167e-01f, 2.29379594e-01f, -1.39980868e-01f, -1.81155689e-02f, -6.46941513e-02f, 2.39195615e-01f, 4.28703474e-03f, -2.16789633e-01f,
  2.86808163e-01f, 1.85134709e-01f, 1.64525211e-01f, -1.00262649e-01f, 2.73934096e-01f, -4.83054947e-03f, -1.00878462e-01f, 1.56645030e-01f, 5.74024767e-02f, 8.74596760e-02f,
  -5.90998270e-02f, -6.61553303e-03f, -1.40398279e-01f, -1.67447194e-01f, -1.43756405e-01f, -1.92078546e-01f, -1.12545632e-01f, -6.65253848e-02f, -7.60404766e-02f, -5.76414317e-02f,
  2.88547307e-01f, 6.50665313e-02f, 1.17237270e-01f, 2.21554175e-01f, -4.93210070e-02f, 2.11670071e-01f, 1.80772662e-01f, 5.91905378e-02f, 4.79119606e-02f, -2.59227604e-01f,
  2.10228279e-01f, 2.90278904e-02f, -8.83915722e-02f, -1.78780124e-01f, 5.63682839e-02f, 1.90750882e-01f, 3.10799748e-01f, 3.02886903e-01f, 1.67883020e-02f, 1.78650990e-01f,
  -3.51332247e-01f, -1.15957847e-02f, -1.21887393e-01f, 1.87565640e-01f, -6.84362948e-02f, 8.83231536e-02f, 1.41144916e-01f, 1.96315274e-01f, 9.18880776e-02f, -5.36571220e-02f,
  4.75853048e-02f, 1.91157699e-01f, -2.08446249e-01f, -1.37010992e-01f, 3.97214815e-02f, -1.61303475e-01f, -2.64879167e-01f, -1.49089754e-01f, -7.67623633e-02f, 6.11272492e-02f,
  2.71756619e-01f, 1.32582292e-01f, 2.13105649e-01f, -1.06121898e-01f, 1.23500504e-01f, -1.32415760e-02f, -2.85900265e-01f, 1.21527195e-01f, -1.75487339e-01f, 5.17403241e-03f,
  1.66823700e-01f, -1.99051481e-03f, -2.88398445e-01f, -5.51166795e-02f, 2.85499562e-02f, -1.13516815e-01f, 2.28540808e-01f, 1.14214107e-01f, -7.50545710e-02f, 9.00802165e-02f,
  -8.25018659e-02f, 1.15778111e-01f, -6.52541891e-02f, -2.44591445e-01f, 1.61392111e-02f, 6.78787082e-02f, 1.51932597e-01f, 3.25220346e-01f, 4.17759605e-02f, -7.77713442e-03f,
  9.88535658e-02f, 5.51372878e-02f, -9.10342038e-02f, 9.12544057e-02f, 1.50523871e-01f, -1.84782416e-01f, 1.86970755e-01f, 9.68197957e-02f, -1.35690197e-02f, 1.12594709e-01f,
  -9.79228541e-02f, 6.59414902e-02f, 3.46409082e-02f, -2.23280102e-01f, 5.72318546e-02f, 2.12400094e-01f, -4.53356430e-02f, 1.20826162e-01f, 1.01765923e-01f, 1.28968164e-01f,
  2.08700925e-01f, 2.47983724e-01f, -1.04470827e-01f, 7.03510791e-02f, -6.43954054e-02f, 5.46862371e-02f, -1.07394636e-01f, 1.62215143e-01f, -2.53197253e-01f, -1.25304982e-01f,
  1.59154013e-01f, 9.19038057e-02f, -1.89160302e-01f, -3.09075445e-01f, 7.68434629e-03f, 9.84167904e-02f, 1.81843773e-01f, -1.05699986e-01f, -2.37486959e-01f, 1.06172115e-01f,
  -2.27976665e-01f, -2.79685613e-02f, 5.13563566e-02f, 1.71329230e-01f, -3.36277112e-02f, -1.62547510e-02f, 1.94414146e-02f, 2.84249932e-01f, 1.58351451e-01f, 1.06120691e-01f,
  -3.52250636e-02f, 7.67353922e-02f, 7.53379799e-03f, -2.63413526e-02f, 1.90440834e-01f, 5.03357612e-02f, -6.10749386e-02f, 1.92276269e-01f, -1.47077411e-01f, 5.84240854e-02f,
  5.37734181e-02f, 8.56506452e-02f, 6.22184724e-02f, 1.36351109e-01f, 7.24100694e-02f, -9.73134264e-02f, -9.24004689e-02f, 2.09822565e-01f, -1.20115899e-01f, 2.26974905e-01f,
  -1.31997233e-02f, 2.35430956e-01f, -2.72043973e-01f, 1.23386011e-01f, 2.13094130e-01f, 2.09880456e-01f, -1.12118475e-01f, 2.96379291e-02f, 3.94032560e-02f, 1.06608041e-01f,
  5.86857535e-02f, -1.68907106e-01f, -1.61228955e-01f, 9.85248387e-02f, -3.56150195e-02f, 2.57606298e-01f, -1.33920414e-02f, 2.72002190e-01f, -7.91406482e-02f, -1.07587352e-01f,
  5.02280444e-02f, -7.51184672e-02f, -1.30473197e-01f, -2.48727486e-01f, 6.06264211e-02f, 2.30068043e-01f, 4.64788899e-02f, -2.87311733e-01f, -1.51666394e-02f, 8.78643394e-02f,
  2.97893912e-01f, 2.49532029e-01f, 3.35982144e-02f, -7.08992630e-02f, 6.29836544e-02f, 2.66933441e-01f, -3.59502584e-02f, 5.80558106e-02f, 1.08040467e-01f, -2.69666445e-02f,
  -2.92208046e-01f, 9.63036120e-02f, 4.73415814e-02f, -1.76730722e-01f, -7.54661039e-02f, 1.42350644e-01f, 5.75223193e-03f, -9.20238160e-03f, 2.03892946e-01f, 9.26943198e-02f,
  2.24738389e-01f, -3.37119967e-01f, -8.60778168e-02f, 9.39799026e-02f, 1.43503055e-01f, -1.27918497e-02f, 1.40314132e-01f, 1.55783936e-01f, 1.63485602e-01f, 4.14038189e-02f,
  -1.71006218e-01f, 1.48507193e-01f, -6.35680109e-02f, -7.82462433e-02f, -4.01586629e-02f, 6.02854751e-02f, -1.01776242e-01f, -9.61417109e-02f, -6.02983497e-02f, -1.94118842e-01f,
  -2.51928046e-02f, -2.69022942e-01f, 1.72804907e-01f, 2.69937009e-01f, 2.28506401e-01f, -1.17084354e-01f, 2.12140784e-01f, 1.32660970e-01f, 1.65176019e-02f, -1.26749754e-01f,
  -6.19278997e-02f, 1.21888205e-01f, 4.43725735e-02f, -1.83150768e-01f, -1.53605998e-01f, 2.81788796e-01f, -1.66611061e-01f, -1.91184375e-02f, 3.67108285e-01f, -4.14931662e-02f,
  -4.41326439e-01f, -3.86674516e-02f, -2.26314530e-01f, -2.09735539e-02f, 3.67394716e-01f, -2.28966281e-01f, -3.17045361e-01f, 2.37462595e-01f, 4.00387719e-02f, 5.16496226e-02f,
  5.33190787e-01f, 1.48951218e-01f, 8.77781883e-02f, 1.06796443e-01f, 1.37955472e-01f, 2.05022007e-01f, 4.28430103e-02f, 2.09941208e-01f, 1.33166045e-01f, 8.04172307e-02f,
  -6.32145442e-03f, 6.42139614e-02f, 8.18650275e-02f, 6.05874807e-02f, 7.37259164e-02f, 1.96316585e-01f, 2.46905480e-02f, 1.41792953e-01f, 7.48439059e-02f, 2.31346354e-01f,
  2.14753494e-01f, 8.63394365e-02f, 1.32527389e-02f, 1.09882452e-01f, -2.32323706e-02f, 1.67108849e-01f, 1.59664229e-01f, -2.87113059e-02f, -1.46221787e-01f, 2.57427245e-01f,
  1.67668357e-01f, -3.96173373e-02f, -2.97010303e-01f, 2.49266088e-01f, -6.19444102e-02f, -3.08464497e-01f, 2.26428539e-01f, 2.05607280e-01f, -1.48785174e-01f, 1.99823424e-01f,
  7.45912418e-02f, -8.00304636e-02f, 1.68882087e-01f, 6.49541020e-02f, -2.39288777e-01f, 1.24530979e-01f, -2.56464154e-01f, -7.05089569e-02f, 3.15090418e-01f, 2.32291788e-01f,
  -3.95688564e-02f, 1.66592389e-01f, 4.65762727e-02f, 2.15858445e-01f, -3.88742760e-02f, -8.07868596e-03f, 1.76677853e-01f, 1.88231960e-01f, -3.43142867e-01f, 3.80682722e-02f,
  -2.47269362e-01f, 2.51031041e-01f, -2.36458689e-01f, -2.65591800e-01f, -1.23996083e-02f, -5.43660559e-02f, -1.22681536e-01f, -1.60487309e-01f, 1.71646968e-01f, -5.07231541e-02f,
  -2.27864441e-02f, 1.13446660e-01f, 1.89394839e-02f, -1.78755701e-01f, -1.76594406e-01f, -2.00272083e-01f, 2.67420951e-02f, 1.75439581e-01f, -1.73662242e-03f, 2.32911617e-01f,
  -1.33488864e-01f, -1.14952112e-02f, 8.07946995e-02f, 2.00840399e-01f, 1.78287432e-01f, -6.51907176e-02f, 1.12472787e-01f, 1.28836092e-02f, 1.73347384e-01f, 6.39942288e-03f,
  -1.25444710e-01f, -4.33222577e-03f, -2.58844346e-01f, 1.43469155e-01f, -7.83659145e-02f, 8.98297355e-02f, 1.79825455e-01f, 2.67003804e-01f, 2.03451529e-01f, -4.75750491e-02f,
  1.28119469e-01f, -1.11564107e-01f, -5.26447920e-03f, -1.57173648e-02f, 3.30809802e-02f, -4.71704490e-02f, 4.53225113e-02f, 9.90089960e-03f, -2.75447965e-01f, 2.65701562e-01f,
  -5.67959212e-02f, -1.65403843e-01f, 2.21928477e-01f, -6.76979125e-02f, -1.65258870e-01f, -2.95336813e-01f, -2.41565466e-01f, 1.52316481e-01f, 1.96404874e-01f, -2.17677101e-01f,
  2.19222412e-01f, -2.71983296e-02f, -2.13030204e-02f, 2.67415434e-01f, 8.75203535e-02f, -4.69260802e-03f, -1.85161442e-01f, 2.39105478e-01f, -2.89768338e-01f, -1.11711547e-01f,
  1.24078810e-01f, -4.67940308e-02f, -2.19364956e-01f, -8.41608942e-02f, 2.18289383e-02f, -2.69907285e-02f, -4.20645140e-02f, 7.77047276e-02f, -1.98390052e-01f, 5.82559705e-02f,
  2.47837584e-02f, 1.39099270e-01f, 2.33845666e-01f, -1.90560952e-01f, -2.03781612e-02f, 1.41523108e-01f, 1.34605408e-01f, 2.14676276e-01f, 7.79553736e-03f, -5.83378710e-02f,
  1.72230363e-01f, 9.46342349e-02f, -5.12856506e-02f, 3.93469393e-01f, -2.44565785e-01f, 1.80716395e-01f, 1.12879522e-01f, 2.74352670e-01f, 6.25264794e-02f, 2.25840017e-01f,
  -1.04743518e-01f, 9.17191431e-03f, -1.01222843e-02f, -3.30381453e-01f, 1.47227287e-01f, 1.61946103e-01f, -7.33258352e-02f, -4.62354720e-02f, 1.63168475e-01f, 7.04757646e-02f,
  -4.36166651e-04f, 2.89834496e-02f, -3.35501343e-01f, 6.90060481e-02f, -1.24817982e-01f, -3.40001695e-02f, 5.83420210e-02f, 2.56344795e-01f, -1.46051690e-01f, -2.95913994e-01f,
  3.57471891e-02f, 1.28661981e-02f, -2.20231473e-01f, -1.34931520e-01f, -1.18137762e-01f, -5.35179749e-02f, -9.85576510e-02f, -7.51696080e-02f, -2.38501325e-01f, 1.01480424e-01f,
  -2.50177771e-01f, -1.31928280e-01f, 4.03169207e-02f, 1.33579031e-01f, 1.14372477e-01f, -4.98560476e-05f, -2.84781963e-01f, -2.36958964e-03f, 4.13614698e-02f, 1.81649774e-01f,
  1.54766276e-01f, -1.10056959e-01f, -1.77891463e-01f, 5.04864529e-02f, 2.19496071e-01f, 1.85531136e-02f, 1.44304335e-01f, -2.82654203e-02f, -2.04592437e-01f, 8.72718841e-02f,
  7.41284043e-02f, 2.22433984e-01f, 1.88927978e-01f, -4.76999730e-02f, 3.17138195e-01f, 7.95418024e-02f, 3.43658268e-01f, 8.73712301e-02f, -1.99431658e-01f, -6.10333569e-02f,
  -2.38311261e-01f, -5.67470416e-02f, 2.05461532e-02f, 2.27393046e-01f, 3.26973528e-01f, 1.72333986e-01f, 2.22397879e-01f, -1.18763350e-01f, 1.03833400e-01f, -1.78294815e-02f,
  2.44386885e-02f, 1.34182677e-01f, -1.23274833e-01f, -1.44663960e-01f, 9.66781825e-02f, 1.48186877e-01f, -2.80204207e-01f, 8.79455954e-02f, -1.61817521e-01f, -1.40535563e-01f,
  -1.60523932e-02f, 1.05353206e-01f, -3.05193420e-02f, -1.53023258e-01f, -1.28783509e-01f, 5.26056364e-02f, -1.26932070e-01f, -1.92660317e-01f, 1.54491141e-01f, -6.56515593e-03f,
  1.11696385e-02f, 4.14038338e-02f, 2.26492241e-01f, -7.10016638e-02f, -6.50287196e-02f, -3.61996107e-02f, -2.07922533e-01f, -1.07376285e-01f, 1.38199031e-01f, -2.51341257e-02f,
  -2.88461566e-01f, -1.32707968e-01f, -6.24108426e-02f, -4.54832390e-02f, 3.50153446e-02f, -1.07977442e-01f, -1.76987052e-01f, -6.19490817e-02f, -5.69450408e-02f, 1.59627855e-01f,
  2.52917171e-01f, -1.49488389e-01f, -2.21282423e-01f, 1.83520854e-01f, 2.35395700e-01f, 4.31444235e-02f, 3.60451862e-02f, 5.19462824e-02f, 8.47695395e-02f, 3.70204933e-02f,
  -1.26875892e-01f, 2.53271133e-01f, -1.55672818e-01f, 1.53542114e-02f, 2.55228758e-01f, -4.08330597e-02f, 2.71101780e-02f, 1.39716238e-01f, -1.30572677e-01f, -3.88448276e-02f,
  -1.63862213e-01f, -2.58600563e-01f, 1.90007567e-01f, 2.25901678e-01f, 1.12442680e-01f, -3.55362296e-01f, 1.98858425e-01f, 2.12063745e-01f, 2.73283795e-02f, -1.36980847e-01f,
  -5.41030709e-03f, -7.28382245e-02f, 7.43273005e-04f, -2.08590224e-01f, -1.56816512e-01f, 2.65525997e-01f, -1.90914631e-01f, -5.33196777e-02f, 3.48416448e-01f, -1.88343018e-01f,
  -2.39311233e-01f, -2.37826183e-01f, -1.26296252e-01f, -8.41944963e-02f, 3.21253002e-01f, 5.73511682e-02f, -1.49833962e-01f, -8.21459591e-02f, 2.88919993e-02f, -2.42546946e-02f,
  3.39552969e-01f, 1.21547289e-01f, 1.07203983e-01f, 1.20465137e-01f, -4.75435853e-02f, 1.34188816e-01f, 1.64914206e-01f, 1.48405403e-01f, 1.46299556e-01f, 5.80417886e-02f,
  -1.58239245e-01f, 1.08830236e-01f, 2.30075479e-01f, 7.78175890e-02f, -2.64646113e-02f, -3.44227329e-02f, 1.14763990e-01f, 1.15045823e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  6.18272461e-02f, -3.95703614e-02f, 7.03311898e-03f, 5.42140333e-03f, 1.60651028e-01f, 1.88775823e-01f, -7.62106776e-02f, 1.20636769e-01f, 3.25358599e-01f, 2.19595030e-01f,
  5.99350333e-02f, 1.24845058e-01f, 1.65762126e-01f, 1.20404005e-01f, 1.85865462e-01f, 2.23427713e-01f, 8.97842646e-02f, -1.93003118e-01f, 6.72256202e-02f, 1.46763712e-01f,
  6.63733750e-04f, 1.51163414e-01f, 1.15352236e-01f, -1.85147636e-02f, 1.48445189e-01f, 1.38252720e-01f, 1.25378132e-01f, 5.93441725e-02f, 2.26518393e-01f, 2.30522621e-02f,
  6.53689653e-02f, 1.81281894e-01f, 9.93525460e-02f, 2.05853224e-01f, -4.06116107e-03f, 3.54797572e-01f, 1.56937987e-01f, 1.75900847e-01f, 6.16831295e-02f, 7.79535025e-02f,
  2.60446727e-01f, 2.20417708e-01f, 1.43546551e-01f, 1.37446985e-01f, 1.72433734e-01f, 1.36585280e-01f, 1.38814598e-01f, 2.09671646e-01f, 8.21573362e-02f, -2.02127919e-02f,
  9.14956704e-02f, 3.18508595e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.28933534e-01f, -1.16416411e-02f, -6.84142560e-02f, 8.93115699e-02f, 1.03428930e-01f, -2.48070695e-02f, 2.90451050e-02f, 3.47142257e-02f, 1.16436929e-01f, -4.06599402e-01f,
  1.04435340e-01f, 2.52348691e-01f, 1.50184575e-02f, 4.67230380e-02f, 1.06039375e-01f, -1.69818208e-01f, 2.24228472e-01f, 1.19614646e-01f, -3.68846208e-02f, -5.14588840e-02f,
  1.97597197e-03f, -1.92246258e-01f, -9.21598747e-02f, -1.36628672e-01f, -1.51949793e-01f, -1.08347654e-01f, -2.21962179e-03f, 8.97053909e-03f, -8.01774487e-03f, 7.25383731e-03f,
  -2.34339237e-01f, 9.15495970e-04f, 1.11376852e-01f, 2.95440741e-02f, 3.51909921e-03f, 1.43897548e-01f, -3.72594371e-02f, 3.74434978e-01f, 2.16031805e-01f, 1.80724263e-01f,
  7.85223320e-02f, 2.82925162e-02f, 4.31863740e-02f, 1.44411117e-01f, -1.06161647e-01f, 3.74121629e-02f, 5.95696047e-02f, -7.48947486e-02f, -2.59894114e-02f, 2.59719193e-02f,
  -7.84972310e-02f, 1.90751012e-02f, 9.35345665e-02f, 1.36772051e-01f, -6.46101951e-04f, -6.84815869e-02f, 9.11941826e-02f, 5.95335755e-03f, 4.73380163e-02f, 8.76876619e-03f,
  -6.53906390e-02f, 1.57295793e-01f, 5.06483577e-02f, 1.70601606e-01f, 6.86888471e-02f, -4.30411510e-02f, -9.18477681e-03f, 1.45213634e-01f, -2.41545647e-01f, -4.06983048e-02f,
  1.05651781e-01f, 2.72585839e-01f, 2.94403493e-01f, 1.87002346e-02f, 5.28480150e-02f, -2.77888477e-01f, 7.21614733e-02f, 1.58363089e-01f, 6.61820732e-03f, 4.20590527e-02f,
  2.02842113e-02f, -1.05382421e-03f, -8.48111361e-02f, -3.95117588e-02f, 2.60898974e-02f, 3.48578542e-02f, -1.79640785e-01f, -2.92901248e-01f, 6.43705800e-02f, -7.25619942e-02f,
  1.06391229e-01f, 4.55535874e-02f, 1.45357206e-01f, 1.98435560e-02f, -3.86646613e-02f, 3.84682766e-03f, -7.64957222e-04f, -3.43142934e-02f, 3.05175662e-01f, -1.47743791e-01f,
  -1.69567987e-01f, 1.01768989e-02f, 2.85704583e-02f, -9.91348624e-02f, 2.73093246e-02f, 9.40655693e-02f, 1.11296505e-01f, -1.40968323e-01f, -8.24782699e-02f, -2.66203791e-01f,
  -1.36226162e-01f, -1.28364116e-02f, 7.78913945e-02f, -7.24829212e-02f, -1.88102052e-01f, -1.30476639e-01f, 1.54060915e-01f, -1.49787173e-01f, 1.19049340e-01f, -2.66876491e-03f,
  1.28548488e-01f, -9.67054442e-03f, -1.38361931e-01f, 1.78474292e-01f, -8.78935233e-02f, -3.69215086e-02f, -7.32920766e-02f, -6.55368716e-02f, -1.40307546e-01f, -6.38982505e-02f,
  -8.89108479e-02f, 7.68311545e-02f, 8.67748186e-02f, 1.68206751e-01f, -9.18693990e-02f, 8.13888758e-02f, 3.13841671e-01f, -9.48047116e-02f, -7.89197069e-03f, 2.79432565e-01f,
  5.11276275e-02f, -2.48341680e-01f, -1.01552814e-01f, 9.34206620e-02f, -8.71685818e-02f, -1.68688800e-02f, 9.43545476e-02f, 8.56076702e-02f, -5.38496189e-02f, 5.71944267e-02f,
  -2.89376359e-02f, 5.89246787e-02f, -1.37804329e-01f, 8.45832005e-03f, 6.63112998e-02f, -1.65493056e-01f, -6.02002554e-02f, -1.67423859e-01f, -5.53893261e-02f, 9.85398144e-03f,
  -2.31195614e-01f, -4.34653461e-02f, -1.25459000e-01f, -3.16039398e-02f, 1.31512180e-01f, 7.65388180e-03f, -8.61632824e-02f, 5.25984839e-02f, -3.35628092e-02f, -3.98572311e-02f,
  1.02207236e-01f, -1.15828877e-02f, 1.81484535e-01f, 9.87870097e-02f, 8.91723484e-02f, -1.99552774e-02f, -1.34966239e-01f, 6.94228262e-02f, 1.64860412e-01f, -5.22370189e-02f,
  6.25090078e-02f, -9.37752947e-02f, -1.36759160e-02f, 1.33363381e-01f, -1.42650887e-01f, 2.26577833e-01f, -1.38059139e-01f, -2.28658691e-01f, 1.31923988e-01f, 2.04014815e-02f,
  1.81808889e-01f, 3.83474268e-02f, 4.22527194e-02f, -1.17650375e-01f, 7.42329359e-02f, 5.23652993e-02f, 9.93032381e-02f, 3.17577235e-02f, -5.03707752e-02f, 1.20446272e-01f,
  3.18940997e-01f, -3.36367339e-02f, 3.19508910e-01f, 5.29897138e-02f, -1.90494701e-01f, -1.45226032e-01f, -1.59810260e-02f, -1.09612219e-01f, -2.33500868e-01f, 1.82077773e-02f,
  -2.72260159e-02f, -1.45059988e-01f, 5.75930811e-02f, -1.17503978e-01f, 8.41516405e-02f, 2.89068557e-02f, -1.62902862e-01f, 8.35262090e-02f, -1.90579429e-01f, -5.12330905e-02f,
  6.23705098e-03f, -1.05311096e-01f, 9.71583091e-03f, 1.06667653e-01f, -1.28657043e-01f, -1.50271699e-01f, -1.58777267e-01f, 5.63724674e-02f, -1.39818713e-01f, 2.98416987e-02f,
  1.49060890e-01f, -2.95371618e-02f, -8.94731134e-02f, -4.80269305e-02f, -1.42288253e-01f, 1.02515690e-01f, -4.97530997e-02f, -4.48389091e-02f, 2.71978751e-02f, -1.27486298e-02f,
  -6.39566556e-02f, -4.06935364e-02f, 7.02137724e-02f, -1.64010137e-01f, 1.17690220e-01f, 1.93130732e-01f, -7.31761158e-02f, -1.71354413e-02f, -9.68651250e-02f, 8.69466588e-02f,
  -2.53432959e-01f, 1.05619982e-01f, -7.41049647e-02f, -8.68736207e-02f, 1.93172842e-01f, -1.30105793e-01f, -2.29064241e-01f, -2.43744567e-01f, 1.04762122e-01f, -1.62512571e-01f,
  -2.56623149e-01f, -2.33078852e-01f, -4.90643494e-02f, 7.58555382e-02f, 1.77023634e-01f, 1.96884379e-01f, -2.57666223e-02f, -8.29801559e-02f, 1.49449363e-01f, 5.77250123e-03f,
  -1.90785795e-01f, -7.02071413e-02f, -6.71782866e-02f, -7.83119909e-03f, -7.71170184e-02f, 6.79313913e-02f, -1.73614845e-01f, 1.78939566e-01f, -4.20180224e-02f, -1.17155939e-01f,
  6.46336675e-02f, 1.37994438e-03f, -4.33897600e-03f, -1.10573724e-01f, -2.97392998e-02f, 1.05739646e-01f, 1.11727208e-01f, -3.15592811e-02f, 2.24066060e-02f, -6.30832314e-02f,
  8.54567252e-03f, -8.42734724e-02f, 1.21212579e-01f, -1.19227655e-01f, -3.53238195e-01f, -5.41768642e-03f, -4.97660078e-02f, 4.90266085e-03f, -6.52492568e-02f, -8.99168178e-02f,
  1.32820576e-01f, 1.02807216e-01f, 1.21964097e-01f, -6.71187863e-02f, 7.27524385e-02f, -9.08953622e-02f, 8.56898949e-02f, 1.04290687e-01f, 3.96970958e-02f, 5.66760413e-02f,
  4.27327789e-02f, 3.29614314e-03f, -1.13702409e-01f, 3.39548215e-02f, -1.46773383e-01f, -2.83298343e-01f, 2.48654727e-02f, -1.12791464e-01f, 2.01813817e-01f, -1.30048111e-01f,
  -4.02144529e-02f, 1.56784669e-01f, 3.27490807e-01f, -4.25423793e-02f, -1.12900920e-01f, 1.14249205e-02f, -6.12736903e-02f, -2.73816735e-01f, -2.96627343e-01f, 1.58322543e-01f,
  -1.38119906e-01f, -1.41014084e-01f, -5.77514209e-02f, 4.21774983e-02f, -7.73262829e-02f, -1.72902077e-01f, -4.51788828e-02f, -1.51987299e-01f, 1.15533978e-01f, -9.70672294e-02f,
  -9.82726738e-02f, -2.94895265e-02f, 6.54493179e-03f, -4.55622450e-02f, 2.17980564e-01f, -4.09283675e-02f, 4.48433906e-02f, -1.50806792e-02f, 2.27370322e-01f, -6.60470047e-04f,
  9.09668356e-02f, -1.81907818e-01f, -5.11247404e-02f, 1.55590832e-01f, 6.99036047e-02f, -3.52465421e-01f, 6.02652058e-02f, 7.33367950e-02f, 3.52170914e-01f, -7.60536566e-02f,
  1.41648361e-02f, 1.29211068e-01f, -1.79993182e-01f, -2.71506850e-02f, 9.35087278e-02f, -5.26849739e-02f, -7.75515884e-02f, -1.43176273e-01f, -9.05170739e-02f, 1.80644859e-02f,
  2.06073970e-01f, 5.05507737e-02f, -2.97256988e-02f, -1.62073642e-01f, 4.44614366e-02f, -1.13286577e-01f, 2.00928241e-01f, -1.80358082e-01f, 1.00652277e-01f, 1.68139830e-01f,
  -3.56566459e-02f, -1.77435398e-01f, -7.74853602e-02f, -3.00084967e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  2.19403412e-02f, -5.66863688e-03f, 5.28793558e-02f, 1.50352880e-01f, -5.40366061e-02f, 5.02005741e-02f, -2.52201986e-02f, 1.16356790e-01f, -6.11491501e-02f, -1.89074770e-01f,
  -7.46572390e-02f, 1.87760085e-01f, 3.05597246e-01f, -1.18768662e-01f, -4.21416819e-01f, -5.96401282e-02f, 1.88490108e-01f, -1.99320018e-02f, 1.08993351e-01f, 3.28295864e-02f,
  1.16947807e-01f, 1.92554012e-01f, -1.38488248e-01f, -1.69854879e-01f, -2.17067704e-01f, 1.57240238e-02f, 2.47876599e-01f, 1.73986480e-02f, -2.13434100e-01f, -3.56834829e-01f,
  -6.60346914e-03f, 9.14797634e-02f, 2.40970641e-01f, 3.43969673e-01f, -2.64426172e-01f, -1.62427798e-01f, 2.68086970e-01f, 1.66158557e-01f, -1.53666764e-01f, -1.03767186e-01f,
  -1.08149305e-01f, -1.47778139e-01f, -3.18855159e-02f, -7.46462718e-02f, 7.72512108e-02f, 2.19368920e-01f, 2.77757317e-01f, 7.36410841e-02f, 1.10704206e-01f, -6.97745942e-03f,
  3.76176327e-01f, -3.95763811e-04f, -2.45062247e-01f, -2.49599934e-01f, -4.63062674e-01f, -3.44195627e-02f, 2.82736663e-02f, -1.06296822e-01f, 3.72969002e-01f, -8.42948537e-03f,
  2.00097412e-01f, 4.60157823e-03f, 3.53609473e-02f, 2.57214189e-01f, 7.08191693e-02f, 6.95519671e-02f, 2.20751062e-01f, -1.55694876e-02f, -1.34639516e-01f, -2.54708081e-02f,
  -2.90995669e-02f, -5.62619790e-03f, 9.31081027e-02f, 3.69409859e-01f, 3.67518723e-01f, -4.02588576e-01f, -1.40794039e-01f, 4.40726988e-02f, 1.76629528e-01f, -3.39786708e-02f,
  -2.20253572e-01f, -1.08394444e-01f, -1.51829258e-01f, 8.30323994e-02f, 8.86142999e-02f, 1.11892492e-01f, -1.06823452e-01f, -7.94948339e-02f, 9.26784053e-02f, 1.58943564e-01f,
  2.20081627e-01f, -1.07519493e-01f, 1.53585657e-01f, -1.43160671e-02f, 9.57494378e-02f, -2.02058598e-01f, 8.55467021e-02f, -5.99963963e-02f, 2.51457870e-01f, -2.35367656e-01f,
  -1.51633486e-01f, -2.38381904e-02f, 3.65571141e-01f, -1.34697324e-02f, -8.74335617e-02f, 1.86265081e-01f, 1.05210789e-01f, -1.83082879e-01f, 2.45040521e-01f, -2.40170285e-01f,
  2.56528743e-02f, 1.26829818e-01f, 2.77198702e-01f, 5.51319905e-02f, -1.04906512e-02f, 9.89460796e-02f, 1.78105727e-01f, 2.80087769e-01f, 2.15382073e-02f, 8.14658180e-02f,
  1.39516164e-02f, -3.73297222e-02f, -1.20436065e-01f, 2.25765318e-01f, -7.80006945e-02f, -6.16821200e-02f, -3.34033035e-02f, -1.37058869e-01f, 5.41860908e-02f, 7.28071555e-02f,
  1.21608406e-01f, -8.96224938e-03f, 1.12870615e-02f, -5.55981300e-04f, -9.49777383e-03f, 5.49930558e-02f, 1.35789856e-01f, 3.65238428e-01f, 2.12397724e-01f, -9.20558944e-02f,
  -1.54948026e-01f, -5.90904728e-02f, 2.17562407e-01f, 3.14080045e-02f, -2.96313703e-01f, 3.84924412e-02f, 4.84537799e-03f, 1.80945605e-01f, 2.48218969e-01f, -4.96869907e-02f,
  1.97991371e-01f, 1.08930804e-01f, -1.54634081e-02f, 7.36957714e-02f, 1.32395327e-01f, 3.46179935e-03f, 6.63323852e-04f, 6.56613484e-02f, 1.96109816e-01f, 1.03802733e-01f,
  7.86476769e-03f, 1.15852475e-01f, -2.53888052e-02f, -8.68498832e-02f, -7.71717206e-02f, 2.84496695e-03f, 2.29385704e-01f, -4.87999916e-02f, 1.60357580e-02f, 6.23090044e-02f,
  -4.22749631e-02f, -5.65357227e-03f, 4.91069891e-02f, 1.30659416e-02f, -2.15787236e-02f, 2.15752676e-01f, 2.48709559e-01f, 1.14768282e-01f, 1.83673911e-02f, 7.95621574e-02f,
  1.91895604e-01f, 5.68100512e-02f, 1.30521581e-01f, -4.72095013e-02f, 8.24736878e-02f, 4.63248566e-02f, -9.06717405e-02f, 2.40400899e-02f, -3.85768246e-03f, -1.28498048e-01f,
  -1.80758148e-01f, -4.78696264e-02f, 2.26367656e-02f, 2.89327323e-01f, 4.20702338e-01f, 2.71591485e-01f, 2.90343612e-01f, 2.49002710e-01f, 6.96872547e-02f, -3.12056184e-01f,
  -4.13047165e-01f, 2.14028761e-01f, 5.78370504e-02f, 4.37493399e-02f, -7.73377046e-02f, -4.87631522e-02f, 2.05730975e-01f, -3.57211769e-01f, 1.99320838e-02f, 5.38306236e-02f,
  4.40798759e-01f, 1.82067201e-01f, 1.20732881e-01f, -2.12496277e-02f, 1.45618603e-01f, 1.56803787e-01f, 2.37155885e-01f, -1.05640963e-01f, -3.75934504e-02f, -2.86863465e-02f,
  1.69913426e-01f, -3.45961414e-02f, 2.80543417e-02f, 6.16423786e-02f, 9.99146234e-03f, 3.12062383e-01f, -1.30511329e-01f, -5.98127171e-02f, -2.56505124e-02f, 3.99429686e-02f,
  1.95476741e-01f, -1.28318682e-01f, -4.22493555e-03f, 1.59356333e-02f, 1.48457140e-01f, -7.06659928e-02f, 1.46276116e-01f, 1.49688616e-01f, 1.84674993e-01f, 3.19649912e-02f,
  -2.30658263e-01f, 1.82286426e-01f, 2.56137788e-01f, 1.08489849e-01f, -4.23031207e-03f, 1.86608687e-01f, -1.32650929e-02f, -1.20887943e-01f, 1.04454696e-01f, 1.96614921e-01f,
  4.30230647e-02f, 3.19786698e-01f, 2.47476518e-01f, 1.29671052e-01f, 7.78212324e-02f, -6.03520952e-04f, 8.88098702e-02f, 2.56189704e-01f, 4.37565356e-01f, 2.31656283e-01f,
  2.41631523e-01f, 3.49009246e-01f, -1.20675512e-01f, -2.73924261e-01f, -1.76486760e-01f, -1.03627533e-01f, -2.07148463e-01f, 3.93621594e-01f, 1.03199877e-01f, -6.06893785e-02f,
  -7.49493763e-02f, -5.15748918e-01f, 2.85540044e-01f, 2.08727807e-01f, 3.84627610e-01f, 3.73840444e-02f, 2.47070491e-01f, -1.83048937e-03f, -2.70273715e-01f, 6.12857975e-02f,
  1.62739187e-01f, 7.02414513e-02f, -3.82408872e-02f, 5.72831258e-02f, -1.31317943e-01f, -3.21376145e-01f, -2.20834017e-02f, 1.28304124e-01f, -5.71538471e-02f, 3.83191615e-01f,
  -1.21014535e-01f, 1.27623856e-01f, 2.11946115e-01f, 2.08370075e-01f, 1.84117388e-02f, 2.24332303e-01f, -2.19244361e-02f, -1.47776514e-01f, 2.39948153e-01f, 7.24446252e-02f,
  7.67400712e-02f, 3.44391197e-01f, 1.70089781e-01f, 1.88140452e-01f, 1.21471874e-01f, 3.12225148e-02f, 3.41278344e-01f, 2.07334653e-01f, -1.39889151e-01f, -2.29459465e-01f,
  -2.26092532e-01f, -2.35270429e-02f, -4.33755741e-02f, 2.57426888e-01f, 2.06983969e-01f, -9.07544270e-02f, 1.14985511e-01f, 1.18668415e-01f, 8.10980424e-02f, 3.06011260e-01f,
  2.49418378e-01f, 1.86060861e-01f, 2.25498363e-01f, 5.52777350e-02f, 5.94546981e-02f, -6.30171597e-02f, -3.33846241e-01f, 2.08890393e-01f, 2.19472498e-01f, -7.45459124e-02f,
  2.47745559e-01f, 9.80000868e-02f, 1.01151623e-01f, 8.88213795e-03f, 1.83419332e-01f, -2.13229850e-01f, 8.93302560e-02f, 1.07568257e-01f, -1.78893030e-01f, -5.82402460e-02f,
  1.52295262e-01f, -5.52547760e-02f, 2.16920003e-01f, 2.11625353e-01f, 9.55867860e-03f, -5.26680313e-02f, 7.02303723e-02f, 5.53730540e-02f, -2.27473065e-01f, 3.79049890e-02f,
  1.95279941e-02f, -1.96995974e-01f, 1.78521007e-01f, 2.86840238e-02f, 7.92911425e-02f, -1.08329594e-01f, 9.54056755e-02f, 1.07276350e-01f, 8.19062740e-02f, 1.13781087e-01f,
  7.35464916e-02f, -5.80105744e-02f, 1.74448022e-03f, 3.12565267e-01f, 6.31267428e-02f, -1.25958219e-01f, -2.60715466e-02f, 1.08865388e-01f, 2.24757686e-01f, 2.18982339e-01f,
  -4.93133813e-02f, 1.20427743e-01f, 1.49875328e-01f, -2.10883185e-01f, 8.57102200e-02f, 1.04453355e-01f, 1.83660630e-02f, -1.39074877e-01f, 3.26817006e-01f, -2.51268268e-01f,
  -1.29313245e-01f, -1.75874487e-01f, -2.76759207e-01f, 3.19804370e-01f, 2.90637881e-01f, -6.75792631e-04f, -9.00923833e-02f, 1.48395211e-01f, 3.57864171e-01f, 4.08173725e-02f,
  7.13672638e-02f, 1.77661106e-01f, -2.00847521e-01f, -2.80289680e-01f, 7.68639445e-02f, 3.81675571e-01f, 8.86694267e-02f, 1.46297486e-02f, -8.98857936e-02f, 5.22748940e-02f,
  2.24457577e-01f, 3.68405804e-02f, 2.52988264e-02f, 5.92295676e-02f, 1.58077925e-01f, -2.25466639e-02f, 1.51092470e-01f, -9.07017011e-03f, -1.64989680e-02f, -5.44084385e-02f,
  -1.93620414e-01f, 1.15863994e-01f, -5.53541817e-03f, -5.57731232e-03f, -1.94108754e-01f, 2.15056449e-01f, -8.39279443e-02f, -1.10348627e-01f, -8.37678835e-02f, 2.56467015e-01f,
  -7.18424022e-02f, 1.08441569e-01f, -6.84115216e-02f, -2.80087050e-02f, 1.39980555e-01f, -1.21510826e-01f, 1.65466160e-01f, 3.71214658e-01f, -1.21315897e-01f, -5.30969910e-02f,
  -1.26690626e-01f, 8.72199759e-02f, -1.92731693e-01f, 4.84940372e-02f, 4.68144938e-02f, -1.08844720e-01f, 1.42287642e-01f, 1.09848268e-01f, 1.56812355e-01f, 5.05127683e-02f,
  2.85412762e-02f, 5.45731597e-02f, 1.87139273e-01f, 3.03736091e-01f, -2.36571208e-02f, 2.98579574e-01f, 2.03265518e-01f, 2.77588457e-01f, 2.37658232e-01f, 3.29860508e-01f,
  9.99456719e-02f, 3.59622300e-01f, 2.86208034e-01f, 2.45628119e-01f, 4.49970990e-01f, -1.36969686e-01f, 2.16816977e-01f, 4.36384156e-02f, 7.95684382e-02f, -4.12274413e-02f,
  -1.25785619e-01f, -3.28486823e-02f, 7.39216283e-02f, 1.43259102e-02f, -2.09077492e-01f, -2.11820682e-03f, -2.97618210e-02f, -5.13911620e-02f, 5.38567305e-02f, 2.77692522e-03f,
  -1.09697141e-01f, 1.69120375e-02f, 2.05104183e-02f, 2.01517865e-02f, 6.02004342e-02f, 1.18566804e-01f, 2.63133854e-01f, 6.66649416e-02f, 6.67278618e-02f, 2.23428130e-01f,
  -1.20772505e-02f, -4.79388535e-02f, 2.18885973e-01f, 4.45340760e-02f, -2.42456906e-02f, 9.31315124e-02f, 2.30951667e-01f, 1.98413774e-01f, 2.18725860e-01f, 1.17202893e-01f,
  1.99935287e-02f, 8.19917768e-02f, -4.66559455e-03f, -4.10292596e-02f, -8.20204467e-02f, 1.81231186e-01f, 1.01842806e-01f, 5.09193391e-02f, -4.15588282e-02f, -7.91404843e-02f,
  1.00932427e-01f, 2.20967337e-01f, -5.53976707e-02f, 1.67593956e-01f, 1.99281629e-02f, -3.40871103e-02f, -1.57235295e-01f, 2.43586957e-01f, 1.23757444e-01f, 1.58725515e-01f,
  3.34675670e-01f, -6.20459765e-02f, 1.40689462e-01f, 3.06007206e-01f, 2.53579378e-01f, 2.44221553e-01f, 2.95046955e-01f, 1.26771793e-01f, -7.69936368e-02f, -1.49933845e-01f,
  2.89248466e-01f, 1.63495936e-03f, -6.30962700e-02f, 2.13541448e-01f, -1.12216406e-01f, -1.13668531e-01f, -2.42623255e-01f, -3.45758796e-01f, -1.14278294e-01f, 2.76696384e-01f,
  7.59730637e-02f, -2.72750929e-02f, 6.79063350e-02f, -6.91721216e-02f, -1.24182194e-01f, 1.65150091e-01f, 7.13961795e-02f, -3.88498344e-02f, 8.88404101e-02f, 2.07581371e-01f,
  9.26218331e-02f, -3.07138890e-01f, -3.37207504e-02f, -3.20723653e-03f, 1.01704411e-01f, 9.16747600e-02f, -1.14777490e-01f, 1.24650478e-01f, -4.51474078e-02f, 1.32554263e-01f,
  2.51524389e-01f, 4.42287661e-02f, 2.29314208e-01f, -1.31637201e-01f, -3.28864381e-02f, 1.22677222e-01f, 1.45462111e-01f, -5.82847819e-02f, -1.08551413e-01f, 1.46545127e-01f,
  2.01901704e-01f, -6.31754026e-02f, 1.20993249e-01f, 7.47570070e-03f, -7.08969757e-02f, -1.10403992e-01f, 2.61970125e-02f, -1.01725139e-01f, -8.57302733e-03f, -2.76286393e-01f,
  7.80159906e-02f, 1.57619983e-01f, -1.05341114e-01f, 1.01453036e-01f, -1.01251423e-01f, -2.09901314e-02f, -7.67331347e-02f, 1.95463188e-03f, 4.49937433e-02f, -5.66956438e-02f,
  -1.54535785e-01f, -1.07393965e-01f, -2.53178161e-02f, 2.02880457e-01f, 2.46794775e-01f, 2.80408382e-01f, 1.69227108e-01f, 3.01049761e-02f, -6.57216609e-02f, -6.56354427e-02f,
  -1.58835977e-01f, 2.43738413e-01f, -2.19158396e-01f, -2.25400887e-02f, -1.39933527e-01f, 1.58249885e-01f, 2.12200820e-01f, 1.38020709e-01f, 1.26241520e-01f, 3.12629580e-01f,
  -1.55297413e-01f, 2.56200552e-01f, 2.31223442e-02f, -9.37673599e-02f, -7.51114637e-02f, 1.49664328e-01f, 2.78402150e-01f, 4.03504334e-02f, -2.05881838e-02f, 3.22173983e-02f,
  -2.69628782e-02f, -4.22491282e-01f, -3.41368690e-02f, 2.01634914e-02f, -1.10189594e-01f, 3.10963094e-01f, -3.46956588e-02f, 1.75126627e-01f, -4.84711006e-02f, 1.58407182e-01f,
  2.09250376e-01f, 7.62151601e-03f, -6.98832422e-02f, 5.97346649e-02f, 1.67525858e-01f, 1.53820179e-02f, 6.36172295e-03f, 9.57625508e-02f, 2.12889295e-02f, 2.47557193e-01f,
  1.97955549e-01f, 1.29342958e-01f, -8.20899606e-02f, -1.07426792e-01f, -2.90360034e-01f, -3.91923577e-01f, 8.26358199e-02f, -2.24630862e-01f, 1.20589718e-01f, -3.11365336e-01f,
  -3.50000970e-02f, 1.58156510e-02f, -2.88551990e-02f, -1.12618394e-01f, -2.42538109e-01f, 2.45990500e-01f, -8.30397159e-02f, 2.32203841e-01f, 2.23519519e-01f, 4.82743755e-02f,
  6.12772256e-02f, 3.58895093e-01f, 1.75723702e-01f, -4.37361188e-03f, -2.07387492e-01f, 6.94814250e-02f, -2.04328559e-02f, 1.37242824e-01f, -2.90340818e-02f, -1.96755379e-02f,
  8.66613463e-02f, 1.32610634e-01f, -3.91266197e-02f, -5.34367524e-02f, 1.69796079e-01f, 2.54495561e-01f, 1.61945283e-01f, 1.54551238e-01f, -2.22421259e-01f, -2.58051455e-01f,
  -9.84081626e-02f, -2.83067971e-02f, 1.33495241e-01f, 1.80207297e-01f, 4.67322059e-02f, -7.81399235e-02f, 1.42743737e-01f, -3.46511938e-02f, -2.96879798e-01f, 9.98366065e-03f,
  -2.36350283e-01f, -7.40007088e-02f, 1.65739600e-02f, 1.15736254e-01f, 9.87187028e-03f, 2.20266342e-01f, 1.77028880e-01f, 1.75779283e-01f, 1.03845939e-01f, -9.25371125e-02f,
  -4.76783141e-02f, 1.45242646e-01f, -9.43012536e-02f, -1.85559392e-01f, -1.68388784e-01f, -4.70715240e-02f, -1.62998229e-01f, 2.84584612e-02f, 5.05357189e-03f, -1.58450529e-01f,
  1.43215358e-01f, -1.97033495e-01f, 4.41735685e-02f, -3.48951854e-02f, 1.62482008e-01f, 1.76692083e-01f, 1.10197820e-01f, 2.53159612e-01f, 1.98417246e-01f, 1.93856135e-01f,
  1.27728745e-01f, 9.48606208e-02f, 2.46841848e-01f, -3.29982899e-02f, 1.19386494e-01f, 3.84537816e-01f, 1.33464197e-02f, -1.87198132e-01f, -7.42092729e-02f, -2.23986208e-01f,
  1.27343507e-03f, -3.10191810e-02f, 2.67166138e-01f, 1.49594069e-01f, 1.69814125e-01f, 4.67958078e-02f, 2.80208975e-01f, 3.31371516e-01f, -1.65728685e-02f, 1.23512655e-01f,
  -1.10423669e-01f, -5.31550832e-02f, -1.48076341e-01f, -1.96064904e-01f, 6.11329339e-02f, 2.46551171e-01f, -1.42423660e-01f, -5.58247939e-02f, -2.20711708e-01f, -5.56656383e-02f,
  -4.73493598e-02f, 2.40216240e-01f, 2.77725488e-01f, 5.52217215e-02f, 2.47548491e-01f, -1.93362292e-02f, -2.08456352e-01f, 4.27745171e-02f, 5.32981791e-02f, 2.54649878e-01f,
  5.07189967e-02f, 1.89205602e-01f, -4.38879095e-02f, -6.75124079e-02f, 1.20664105e-01f, 1.36211991e-01f, 1.40774384e-01f, 1.28815159e-01f, 2.29023814e-01f, 4.02441993e-03f,
  6.14591129e-02f, 2.41956301e-02f, 1.64807826e-01f, 6.23057485e-02f, 1.01394132e-01f, 3.67602520e-02f, 8.02086145e-02f, -5.17846271e-02f, 1.57789201e-01f, -2.10479368e-02f,
  -6.95865974e-02f, 8.63822773e-02f, -5.59227029e-03f, -1.20607562e-01f, -4.26141858e-01f, 2.51669735e-01f, 2.13268116e-01f, -1.69017717e-01f, 8.06240439e-02f, -1.12497941e-01f,
  4.97098155e-02f, 1.77903593e-01f, 1.65743493e-02f, -1.60616979e-01f, 1.73524186e-01f, -1.02159427e-02f, -1.92933649e-01f, 8.44028443e-02f, -1.57899950e-02f, 2.76752021e-02f,
  -2.10143223e-01f, -2.79508922e-02f, 1.59664631e-01f, 9.75325704e-03f, 2.05503732e-01f, 2.13984832e-01f, -1.69896886e-01f, -1.16684707e-02f, -1.46370813e-01f, -2.24446848e-01f,
  1.88967362e-01f, -7.29753599e-02f, 7.98318684e-02f, -5.05179837e-02f, 1.30327344e-01f, 1.55911058e-01f, -1.46265551e-01f, 3.30946892e-01f, -2.06378713e-01f, -1.14202507e-01f,
  2.74968535e-01f, 1.89704865e-01f, 9.37174112e-02f, 6.29331619e-02f, -1.60049081e-01f, 1.07126087e-01f, 3.27821612e-01f, 1.21982597e-01f, 2.17991993e-02f, 5.69295883e-02f,
  -1.84080992e-02f, -2.10519791e-01f, -1.28090367e-01f, 6.64123446e-02f, 1.23398125e-01f, 2.17386484e-01f, 1.86408222e-01f, -4.02975291e-01f, -1.73459470e-01f, -8.99041966e-02f,
  -1.30602315e-01f, 2.13917822e-01f, 1.44554511e-01f, 2.08586037e-01f, 1.09130777e-01f, 1.76819384e-01f, 3.76892447e-01f, 3.45998943e-01f, 1.03658877e-01f, -1.06379002e-01f,
  3.52341048e-02f, 2.01356158e-01f, -3.10376715e-02f, 1.65347651e-01f, 5.28456420e-02f, -2.98872560e-01f, -1.04034141e-01f, -4.13478389e-02f, 3.13334987e-02f, -1.18751042e-01f,
  2.42271870e-01f, 1.39793292e-01f, 2.83448756e-01f, 1.34074494e-01f, 6.12204783e-02f, 1.51025444e-01f, 2.73781754e-02f, -5.43026514e-02f, -1.72940054e-04f, -1.96748972e-01f,
  -5.30066527e-02f, -6.25369251e-02f, 1.39994785e-01f, 3.08075458e-01f, -1.73206791e-01f, 1.93023250e-01f, -2.31590569e-01f, 6.37773648e-02f, 2.01596618e-01f, 1.01096533e-01f,
  -1.10087670e-01f, -2.01548188e-04f, 1.83671057e-01f, 6.30306005e-02f, 1.52718695e-02f, -1.13735400e-01f, 1.40694067e-01f, 6.06679879e-02f, 1.25785079e-02f, 2.64732510e-01f,
  -2.83415735e-01f, 1.32615715e-01f, 1.12521701e-01f, 1.26525283e-01f, -1.76531985e-01f, 2.85725389e-03f, -2.38969132e-01f, -1.02069467e-01f, -8.87346454e-03f, 4.02076691e-02f,
  2.50180867e-02f, -2.17667148e-02f, 2.38367826e-01f, 1.63753447e-03f, 6.95609003e-02f, 6.06965721e-02f, -9.12539139e-02f, 1.71899080e-01f, 3.54545355e-01f, -1.57359704e-01f,
  -7.78263584e-02f, 1.04530165e-02f, -1.51525646e-01f, 6.15606271e-02f, 1.40810236e-01f, 4.14965779e-01f, -9.83035378e-03f, -2.72397906e-01f, 2.63425950e-02f, 9.85642374e-02f,
  1.67616040e-01f, 4.69895080e-02f, -1.01336747e-01f, 1.55427545e-01f, 5.70613369e-02f, 1.23280384e-01f, 1.64671037e-02f, 2.12750882e-01f, 4.56099398e-02f, 1.70173243e-01f,
  1.39135271e-01f, 7.45282248e-02f, 1.84465960e-01f, -2.09925592e-01f, 2.81090103e-02f, 7.79538825e-02f, 2.37445340e-01f, -8.63346457e-02f, 4.95397225e-02f, 2.07337692e-01f,
  9.44106653e-02f, -4.11549866e-01f, 1.03316106e-01f, -1.54364988e-01f, 1.71489082e-02f, -1.13381311e-01f, 1.08788520e-01f, 1.32435411e-01f, -1.18909411e-01f, -3.16506654e-01f,
  1.17601134e-01f, 1.20480835e-01f, -3.83056365e-02f, -8.32375735e-02f, 1.17118791e-01f, 1.28920481e-01f, 3.76279727e-02f, -3.17521319e-02f, 1.05545603e-01f, 4.67106774e-02f,
  -1.48248831e-02f, 1.41702816e-01f, -5.52942082e-02f, -1.52933493e-01f, -2.16021482e-02f, 4.83170860e-02f, 3.64475437e-02f, -2.65688896e-01f, -1.43868178e-01f, -6.59758747e-02f,
  2.49894500e-01f, 4.83062826e-02f, 2.18617082e-01f, 1.60654306e-01f, 2.47489169e-01f, 4.39045094e-02f, 2.22647667e-01f, 3.25363308e-01f, -1.47516727e-01f, 5.72287142e-02f,
  1.88374594e-01f, -2.84408897e-01f, 1.49613783e-01f, -7.95204565e-02f, 1.52188838e-01f, -3.23339313e-01f, 8.39977562e-02f, -1.32433429e-01f, -7.07410723e-02f, -1.20200783e-01f,
  -1.27674147e-01f, 6.59699962e-02f, -6.50083050e-02f, -2.07121968e-01f, 3.91541123e-02f, -5.69845885e-02f, -9.34987441e-02f, -1.24777488e-01f, 5.64033687e-02f, 1.98974125e-02f,
  -1.70834959e-02f, 2.21541017e-01f, -2.50019878e-01f, -1.54939130e-01f, 7.93826357e-02f, 1.43012526e-02f, 6.87175617e-02f, -3.09513882e-02f, 2.11766466e-01f, 1.89697534e-01f,
  2.13748485e-01f, -1.86285693e-02f, 1.15213379e-01f, 9.86231267e-02f, -2.19607670e-02f, 1.73433065e-01f, 7.27206022e-02f, -2.21398056e-01f, -1.69362366e-01f, 1.29224241e-01f,
  1.06544420e-01f, 1.51550937e-02f, 5.57844788e-02f, 5.20796813e-02f, 1.70078084e-01f, 2.40009099e-01f, 1.68388993e-01f, 2.31759772e-01f, 2.59442836e-01f, 2.77375162e-01f,
  1.88452974e-01f, 1.87229410e-01f, 2.87798703e-01f, 2.87844446e-02f, 1.29267603e-01f, 2.73085564e-01f, 1.13947354e-01f, 7.93035179e-02f, 2.53545821e-01f, 1.95032865e-01f,
  -1.48090556e-01f, 5.24745435e-02f, 4.69267786e-01f, -8.88345465e-02f, 5.84457954e-03f, 4.55929875e-01f, -6.42293990e-02f, -2.22125709e-01f, -3.32804352e-01f, -2.02505454e-01f,
  -2.56740689e-01f, 1.06552742e-01f, 2.54765972e-02f, 2.24169940e-01f, 2.06792220e-01f, -1.43270612e-01f, 8.76380801e-02f, 3.44406992e-01f, -1.79123029e-01f, 1.47017732e-01f,
  7.43833706e-02f, 3.73510830e-02f, -2.36975968e-01f, -9.04361606e-02f, -9.32667628e-02f, 9.17099640e-02f, 4.41988520e-02f, -5.79020754e-02f, -3.72277349e-02f, 9.82402265e-02f,
  -1.05209261e-01f, 2.73226112e-01f, 1.68055862e-01f, 1.41022086e-01f, 1.53174937e-01f, -7.25149587e-02f, -5.29433787e-02f, 1.50046676e-01f, 7.69104734e-02f, 7.09845051e-02f,
  -4.21500280e-02f, 2.02432930e-01f, 2.64972508e-01f, -1.68207332e-01f, -2.11521350e-02f, 1.72867149e-01f, 1.40729830e-01f, 1.60169110e-01f, 7.29755685e-03f, 1.48544997e-01f,
  -9.55198556e-02f, -1.29298996e-02f, 3.57226878e-02f, -1.16493441e-01f, 6.63233036e-03f, -1.32207692e-01f, 1.00641452e-01f, -2.90674437e-02f, 1.45825028e-01f, 9.62423608e-02f,
  1.72144711e-01f, 6.91891462e-02f, -5.34959584e-02f, 1.82506964e-01f, 1.43772721e-01f, -1.67660732e-02f, -8.71379226e-02f, -1.88379943e-01f, -8.34164023e-02f, 2.77310908e-01f,
  -2.25429103e-01f, 1.60024762e-01f, -7.69195855e-02f, 3.01306173e-02f, -6.06793426e-02f, 2.85985082e-01f, 3.04711871e-02f, -1.03086337e-01f, 9.81205180e-02f, -1.73669711e-01f,
  7.28043541e-02f, 4.42386977e-02f, 4.25779447e-02f, 1.32854134e-01f, -8.97936672e-02f, 1.45496681e-01f, 1.90848649e-01f, -2.83034309e-03f, -9.43053290e-02f, -1.03979953e-01f,
  8.67594182e-02f, 1.21455289e-01f, 4.85426933e-02f, 7.64830932e-02f, -1.66975766e-01f, 2.10402921e-01f, 3.27068329e-01f, 5.71180042e-03f, 8.91573820e-03f, -2.67159902e-02f,
  7.53282309e-02f, 1.41731380e-02f, -1.80584401e-01f, -1.77405283e-01f, -3.17795724e-02f, 5.07210195e-02f, 1.84825778e-01f, -1.72814161e-01f, 1.34310290e-01f, 9.92570631e-03f,
  8.18637833e-02f, 1.92614328e-02f, 1.40361398e-01f, -1.53467074e-01f, 3.89893316e-02f, -3.95821393e-01f, 9.80330333e-02f, 2.92978913e-01f, -1.69929892e-01f, -1.07349291e-01f,
  -1.34048149e-01f, -1.95124988e-02f, -1.00954557e-02f, 6.51575699e-02f, 1.21754773e-01f, -2.51468662e-02f, -1.63930461e-01f, 1.59915984e-01f, -1.37326300e-01f, 4.39722657e-01f,
  4.63653445e-01f, 1.14028163e-01f, 2.70482898e-01f, -1.11483328e-01f, -1.16691506e-03f, -9.99889523e-02f, -1.02067515e-01f, 7.26890564e-02f, -3.22052926e-01f, -9.77819636e-02f,
  -1.39410868e-01f, 9.58723016e-03f, 1.39089108e-01f, 2.25715712e-01f, 2.40067482e-01f, 4.65352423e-02f, -1.48492735e-02f, 2.76655495e-01f, 4.28088456e-02f, -1.20593973e-01f,
  2.91387402e-02f, -2.18055487e-01f, 2.03112692e-01f, -1.69727728e-01f, -2.19680183e-02f, -3.13253067e-02f, 1.80860013e-01f, -4.16626185e-01f, 1.20806985e-01f, 2.15834454e-02f,
  2.69329306e-02f, 1.72757506e-01f, 1.93056449e-01f, 1.45966306e-01f, -2.16360942e-01f, -1.70492053e-01f, 3.63922305e-03f, 9.94122624e-02f, 6.53355718e-02f, 4.82073948e-02f,
  1.93553492e-01f, 7.40396529e-02f, -1.19452126e-01f, 6.57244623e-02f, 2.45652497e-01f, 1.41470358e-01f, 3.01396608e-01f, 1.98518336e-01f, 4.62901331e-02f, -1.01295277e-01f,
  -1.94862038e-01f, -2.11098030e-01f, 7.98913240e-02f, -2.03850955e-01f, 1.26915634e-01f, -2.91912973e-01f, -6.66202754e-02f, -1.22501226e-02f, 1.77205071e-01f, 6.19847290e-02f,
  1.25849605e-01f, -1.31573319e-01f, -1.41666323e-01f, -3.14462744e-02f, 1.12785265e-01f, -3.45922261e-01f, -1.17725097e-01f, 1.20971873e-01f, 1.15735181e-01f, 2.54065663e-01f,
  1.58578962e-01f, -1.23285957e-01f, 3.21212292e-01f, 1.50611043e-01f, -9.80115831e-02f, -8.64571333e-02f, 4.44836989e-02f, -5.33663593e-02f, 1.49917439e-01f, 1.50854886e-01f,
  -4.97751161e-02f, -6.10188097e-02f, 1.07608251e-01f, 9.53205749e-02f, 4.44890857e-02f, 1.41457379e-01f, -5.92497513e-02f, -6.30935803e-02f, 2.25191861e-01f, 2.93544047e-02f,
  -2.73654908e-02f, -5.86382858e-02f, 1.50723666e-01f, 2.18804389e-01f, -3.18984687e-02f, 2.91698515e-01f, -6.48145750e-02f, -7.30724782e-02f, 2.43705623e-02f, 1.50806248e-01f,
  -8.26844499e-02f, -9.98822823e-02f, -1.08524866e-01f, 1.33292839e-01f, 1.87028289e-01f, -5.08085303e-02f, 1.38199434e-01f, -7.06607029e-02f, 5.18458225e-02f, -2.63426304e-01f,
  3.75713184e-02f, 1.54176697e-01f, -3.14063914e-02f, -8.09923112e-02f, 2.13242143e-01f, -2.63345838e-01f, -1.49733767e-01f, 4.01603319e-02f, -2.11363867e-01f, 2.95705527e-01f,
  -3.71999070e-02f, 1.55748412e-01f, 2.20495924e-01f, -1.13513991e-01f, 1.17582910e-01f, 6.51161447e-02f, 4.05087098e-02f, -4.33226302e-02f, 1.24076411e-01f, 3.32498223e-01f,
  1.66997671e-01f, -4.83669192e-02f, 9.00426414e-03f, -2.01909244e-01f, 4.42664251e-02f, -2.24278599e-01f, -1.20415755e-01f, 3.29816826e-02f, 1.00592837e-01f, -2.36391556e-03f,
  -8.94965306e-02f, 2.16392931e-02f, 1.87158212e-01f, 4.09232900e-02f, 1.11476712e-01f, 6.30958378e-02f, 7.60783926e-02f, -1.00526579e-01f, 7.10191801e-02f, -1.39654577e-01f,
  8.03994164e-02f, 2.61214644e-01f, -3.33182573e-01f, 1.25375345e-01f, -8.71735439e-02f, 2.54676580e-01f, 1.17233202e-01f, -1.08769327e-01f, 8.24090000e-03f, -1.13963284e-01f,
  2.33353570e-01f, 7.22648725e-02f, -1.49564952e-01f, 1.93889979e-02f, 9.90734175e-02f, 2.03324452e-01f, 1.10184230e-01f, -3.13444771e-02f, -3.57454300e-01f, -2.79066768e-02f,
  2.21122921e-01f, 4.13543880e-02f, 3.11759207e-02f, 1.31486356e-01f, 8.49744454e-02f, 4.37857658e-02f, 5.57853021e-02f, 2.23210350e-01f, -6.15378246e-02f, 8.49270076e-02f,
  1.27929956e-01f, 1.22981399e-01f, 2.31977239e-01f, -1.95058838e-01f, 1.03798524e-01f, -1.87733397e-01f, 1.79952420e-02f, 9.41013098e-02f, 3.15565675e-01f, -6.34865416e-03f,
  2.70681828e-01f, 1.55232966e-01f, 3.85462455e-02f, -7.21990243e-02f, 2.17938408e-01f, 1.20554797e-01f, 9.04427562e-03f, -1.46807075e-01f, 8.97916779e-02f, 1.28553003e-01f,
  -1.17404565e-01f, 8.99085402e-02f, -2.88714886e-01f, -1.71297006e-02f, 2.07144201e-01f, -4.73247111e-01f, 2.65981369e-02f, 4.68432643e-02f, -1.79363057e-01f, 3.60774279e-01f,
  -3.28948259e-01f, 3.84020135e-02f, 1.63981393e-01f, 1.00681238e-01f, -2.00417534e-01f, 1.72522917e-01f, -1.99371688e-02f, -4.88086164e-01f, 1.15433298e-01f, 1.41645849e-01f,
  -3.56174307e-03f, 1.11181609e-01f, 1.21704504e-01f, 2.33365297e-01f, -5.79737909e-02f, -8.11553299e-02f, 9.53299254e-02f, 3.58929932e-01f, -3.71245265e-01f, -4.49941009e-02f,
  -6.18141703e-02f, 7.05226660e-02f, -8.83170515e-02f, 1.56003088e-02f, -3.09730142e-01f, -2.39280593e-02f, 1.26867309e-01f, 2.44736046e-01f, 6.30112663e-02f, 1.75642222e-01f,
  2.26020351e-01f, 2.70961165e-01f, -7.79490173e-02f, 8.16047713e-02f, 1.96776167e-01f, -6.12322614e-03f, 1.78814799e-01f, -4.59176302e-02f, -5.45933396e-02f, 1.83707681e-02f,
  -1.85765494e-02f, -6.17467687e-02f, 4.75389771e-02f, 1.75960943e-01f, 2.78806657e-01f, -4.32568192e-01f, -2.88077772e-01f, 1.09730877e-01f, -1.55252337e-01f, 1.27150357e-01f,
  7.84230903e-02f, 1.82533488e-01f, 3.50566357e-02f, 4.11387831e-02f, 6.32788688e-02f, 1.68499008e-01f, 2.92350590e-01f, 1.60095781e-01f, 8.54167342e-02f, 1.66701637e-02f,
  4.79153432e-02f, 4.08771858e-02f, 2.07763135e-01f, 6.04038462e-02f, -3.28401886e-02f, 1.58748701e-01f, 7.38161206e-02f, 2.65193552e-01f, 1.42216563e-01f, 2.15406522e-01f,
  2.30209962e-01f, 1.40791968e-01f, -3.70383747e-02f, 3.76763612e-01f, -1.24473944e-02f, -7.04502165e-02f, -2.51580328e-01f, 3.02329590e-03f, -2.77586803e-02f, 8.21510404e-02f,
  2.51147360e-01f, -1.16884217e-01f, 2.43083358e-01f, 1.36713564e-01f, 1.64629921e-01f, 2.36073770e-02f, -2.00991198e-01f, 9.05124620e-02f, 1.18578196e-01f, 6.33907169e-02f,
  -7.18785301e-02f, -1.55028790e-01f, -1.34108186e-01f, -8.51337314e-02f, 8.17402899e-02f, 2.81094640e-01f, -2.17667282e-01f, 1.06784120e-01f, 2.64553398e-01f, 2.28087753e-01f,
  2.03614742e-01f, 1.49878091e-03f, 2.58841604e-01f, 1.50246575e-01f, 1.51248053e-01f, 5.70712462e-02f, 2.88016889e-02f, 2.37217471e-01f, -1.91339761e-01f, 8.32626894e-02f,
  3.56700957e-01f, 8.65264907e-02f, -2.45832652e-02f, -1.06737427e-01f, -1.58558160e-01f, 1.36627614e-01f, -1.23931646e-01f, -7.88164064e-02f, -1.28060460e-01f, 9.85939503e-02f,
  -2.34960616e-01f, 1.98911458e-01f, 1.75766781e-01f, 3.38204019e-02f, -2.37979278e-01f, 1.68117017e-01f, -9.77430195e-02f, 2.26746440e-01f, 3.13055396e-01f, 1.40652224e-01f,
  -1.07283577e-01f, -4.69224229e-02f, -1.01681978e-01f, -2.73167998e-01f, 1.97142020e-01f, -1.33193154e-02f, 1.84383571e-01f, -1.70771673e-01f, 7.79156014e-02f, 2.38577932e-01f,
  -1.06477134e-01f, 1.81559190e-01f, -2.56294996e-01f, 5.77835850e-02f, 1.08515695e-01f, 1.18614817e-02f, 7.21532702e-02f, -1.96707264e-01f, -3.84559035e-02f, 2.54717976e-01f,
  4.06620651e-01f, -4.52584662e-02f, 1.44546106e-01f, 1.19492337e-02f, -2.36540399e-02f, -2.17875615e-01f, -4.60374579e-02f, 5.92704630e-03f, -2.16859177e-01f, -1.14372753e-01f,
  5.42426072e-02f, -2.60791659e-01f, -1.94009110e-01f, -3.18499655e-01f, -3.12037438e-01f, -2.89295297e-02f, -1.60409048e-01f, -1.55728057e-01f, -1.54145271e-01f, -1.01618089e-01f,
  -9.68078673e-02f, 3.66309583e-02f, -2.80720830e-01f, -2.73055378e-02f, -1.60302803e-01f, -4.57545221e-02f, 1.24656335e-01f, -6.58877343e-02f, 2.89533734e-01f, 9.52215493e-02f,
  1.83204517e-01f, -2.15900570e-01f, 2.65163124e-01f, -3.62191677e-01f, 9.99868512e-02f, -1.76836029e-01f, -1.63957492e-01f, -7.05734044e-02f, 7.37089524e-03f, -1.48258079e-03f,
  2.74235487e-01f, -1.93317365e-02f, -2.57470787e-01f, 1.16573766e-01f, 4.84009236e-02f, 2.46760845e-01f, -7.70432577e-02f, 9.80242528e-03f, 1.21451765e-01f, -8.17048624e-02f,
  6.68169633e-02f, 5.72637767e-02f, 1.06652975e-02f, -1.72502652e-01f, -3.66833568e-01f, 2.00168416e-01f, -1.93326339e-01f, -2.18594939e-01f, 4.02915291e-02f, 7.60870278e-02f,
  -1.01140644e-02f, 2.60759979e-01f, -1.32081464e-01f, 2.04561297e-02f, -2.58234322e-01f, 2.81477332e-01f, -2.09853545e-01f, -1.57602564e-01f, 4.66165096e-02f, 8.20392594e-02f,
  2.90593766e-02f, 1.49212480e-01f, 2.95178890e-01f, 1.91767126e-01f, 2.66347110e-01f, -2.12154090e-01f, -3.40775959e-02f, 1.59791857e-01f, -9.16076452e-02f, 3.05820882e-01f,
  -1.98276758e-01f, -1.74566917e-02f, 2.84058880e-02f, 4.67917621e-02f, -2.47427989e-02f, 7.63693079e-02f, -1.00222796e-01f, -2.92729605e-02f, 3.69616270e-01f, 3.18672001e-01f,
  2.04449490e-01f, -9.29148048e-02f, -9.91178975e-02f, 1.80270761e-01f, -9.47508812e-02f, 8.03238750e-02f, -9.28182900e-02f, 1.41833574e-01f, -7.33931884e-02f, 4.94292788e-02f,
  1.41964117e-02f, 1.36687294e-01f, -2.71876156e-03f, 5.91637604e-02f, 1.52954355e-01f, 1.34362668e-01f, 1.52822137e-01f, 8.63112137e-02f, 9.34114866e-03f, -2.11996973e-01f,
  -1.17314570e-02f, -2.12383762e-01f, 3.59714404e-02f, 2.19427720e-01f, 2.48067841e-01f, -1.10219203e-01f, 1.76945344e-01f, 7.62588754e-02f, -2.05829829e-01f, -1.04212165e-01f,
  -9.64255333e-02f, -9.64792743e-02f, 5.37353754e-02f, -2.82839268e-01f, 1.71096146e-01f, 6.84754224e-03f, 1.66348919e-01f, 1.40414506e-01f, 2.20402405e-01f, -6.56653270e-02f,
  6.51884377e-02f, 1.26437649e-01f, -1.27548322e-01f, -2.41160184e-01f, -1.52312398e-01f, 1.04216248e-01f, -2.03540981e-01f, 5.68999462e-02f, -2.54283965e-01f, -2.92035565e-02f,
  -3.06224041e-02f, -2.29131237e-01f, -2.00061068e-01f, -1.82273328e-01f, 1.25581011e-01f, 2.01201096e-01f, 2.73524853e-03f, 1.96231514e-01f, 2.43692681e-01f, 1.07774906e-01f,
  3.56494963e-01f, -2.83649653e-01f, -2.62916423e-02f, -1.16308063e-01f, -1.68825626e-01f, 1.18400557e-02f, -6.84659332e-02f, 7.58399591e-02f, -1.66313440e-01f, -8.37619528e-02f,
  -6.58553988e-02f, -2.05729343e-02f, 1.93260953e-01f, 1.37049571e-01f, 1.72701910e-01f, 1.15964644e-01f, -8.26959908e-02f, 1.50455818e-01f, -8.60135183e-02f, 1.00863636e-01f,
  -3.82765569e-02f, -1.86862543e-01f, 2.54854560e-01f, 3.47820744e-02f, 1.56774387e-01f, 1.55683935e-01f, -6.57799393e-02f, -1.17841430e-01f, -9.37159732e-02f, 1.56824753e-01f,
  -1.14453606e-01f, 1.64674073e-01f, 1.48032261e-02f, 1.32774994e-01f, -2.19288133e-02f, -4.12128791e-02f, 5.75568900e-02f, -6.09380826e-02f, 1.88267574e-01f, 1.43290609e-01f,
  -7.66794756e-02f, 1.01580553e-01f, -2.03333974e-01f, 8.56338441e-03f, 1.67110711e-01f, 4.16689459e-03f, 4.77301590e-02f, 1.58572435e-01f, -1.27513528e-01f, 1.63952321e-01f,
  1.32940263e-01f, 1.98713899e-01f, -7.25926366e-03f, 6.59205765e-02f, 2.55196631e-01f, 1.62461996e-01f, 1.84315532e-01f, -7.39932060e-02f, 6.98353956e-03f, -1.12377427e-04f,
  -4.26828451e-02f, -1.78295836e-01f, -1.85359299e-01f, -7.32201412e-02f, -3.35807428e-02f, 3.24664786e-02f, 2.24088063e-03f, -1.29177660e-01f, -2.39092439e-01f, 1.31307775e-02f,
  2.24078238e-01f, -1.24058746e-01f, -8.20309967e-02f, 4.13892604e-02f, 1.96390241e-01f, 1.87663913e-01f, 5.27025796e-02f, -5.91974407e-02f, -8.30976292e-02f, 4.65547778e-02f,
  -2.93297827e-01f, -1.21750541e-01f, 9.48542356e-02f, 7.34505802e-02f, 1.55382842e-01f, 1.44211218e-01f, -7.15549290e-02f, -2.98202317e-02f, 4.09051739e-02f, 2.18362108e-01f,
  -8.82477984e-02f, 6.99605793e-02f, 1.16375163e-01f, 2.35021219e-01f, 1.29862785e-01f, -1.05152033e-01f, -4.23009023e-02f, -3.45537402e-02f, 7.93347061e-02f, -5.31569235e-02f,
  1.11589292e-02f, -1.60459727e-02f, -6.02954514e-02f, 3.45168933e-02f, 1.50974825e-01f, -3.93114276e-02f, -1.61787167e-01f, -1.40417414e-02f, 7.81794190e-02f, -4.08153720e-02f,
  -4.86498214e-02f, -1.45659251e-02f, -1.24708354e-01f, -9.70940739e-02f, 1.29348099e-01f, 1.45392194e-01f, 6.82043880e-02f, -9.59263742e-03f, 1.93067148e-01f, 1.76115304e-01f,
  2.21465081e-01f, 1.65276185e-01f, 2.15616718e-01f, 3.32753867e-01f, 2.41660953e-01f, 7.96653628e-02f, 7.77867809e-02f, 1.59062237e-01f, -1.93871483e-01f, 5.15323915e-02f,
  3.05669636e-01f, 3.08016479e-01f, 4.04751211e-01f, -2.10970581e-01f, -1.84284151e-01f, 6.11303486e-02f, 2.01157838e-01f, -2.90261537e-01f, -2.18812957e-01f, -7.00166076e-02f,
  -1.77696228e-01f, 1.27341539e-01f, 2.20964506e-01f, -2.01890897e-02f, 5.55598922e-02f, 2.41374046e-01f, 1.16908714e-01f, 1.57344252e-01f, -4.84560803e-02f, -5.03358617e-02f,
  7.37305731e-02f, -1.35092884e-01f, 1.26367331e-01f, -2.53395498e-01f, 8.81516859e-02f, 8.87862593e-02f, 1.45628467e-01f, -4.51870173e-01f, -3.57663631e-02f, 1.84395209e-01f,
  2.95866340e-01f, 7.39698559e-02f, -2.18592416e-02f, 4.33701314e-02f, 1.96725987e-02f, -8.33334029e-02f, 4.97030979e-03f, -1.89773589e-01f, 2.68740579e-02f, 7.90650845e-02f,
  2.26414308e-01f, -8.81008506e-02f, -7.53661469e-02f, 1.02068029e-01f, 2.47415408e-01f, 2.32983366e-01f, 1.63064629e-01f, 2.57401109e-01f, 6.07771054e-02f, -1.62375703e-01f,
  -7.95069858e-02f, -8.41316432e-02f, -1.92840189e-01f, -2.80109704e-01f, -2.20461681e-01f, -4.41525914e-02f, 3.98435369e-02f, 9.92252007e-02f, 1.54977277e-01f, 9.20169801e-02f,
  -3.06891650e-02f, 5.85002601e-02f, 1.07950069e-01f, 2.17036456e-01f, -1.88193083e-01f, -2.64590830e-01f, -2.84914166e-01f, 1.80515885e-01f, 2.23188847e-01f, 9.97295454e-02f,
  4.91547696e-02f, -1.52832836e-01f, 2.18599662e-01f, 1.24709815e-01f, 1.54999830e-02f, 5.46566956e-02f, 1.32220954e-01f, 1.39171526e-01f, -2.73146302e-01f, -2.07991660e-01f,
  -5.95076196e-02f, 1.86243579e-01f, -6.81532919e-03f, 1.72547787e-01f, -2.12943017e-01f, -1.94759443e-01f, 1.42145559e-01f, 7.38056898e-02f, 4.18511033e-02f, 1.07805155e-01f,
  -7.65420347e-02f, 7.33383223e-02f, 2.86257029e-01f, 1.97955314e-03f, -3.72412205e-01f, 3.31838250e-01f, -2.07495447e-02f, -1.50081024e-01f, 1.64975256e-01f, 2.12731495e-01f,
  -4.12591659e-02f, 2.59617895e-01f, 8.24443996e-02f, 2.40878854e-02f, -9.45240930e-02f, -3.95896323e-02f, 1.65742055e-01f, -4.20133621e-02f, -1.31040990e-01f, -2.72887945e-02f,
  -1.49412006e-01f, 1.62233680e-01f, 1.13060936e-01f, 2.83826828e-01f, 1.56027272e-01f, -2.01718703e-01f, 1.87086359e-01f, 1.03736505e-01f, 1.88366577e-01f, 2.96496511e-01f,
  -1.77978501e-01f, -1.69059709e-02f, -2.09716707e-01f, -1.72879491e-02f, -1.06324688e-01f, -1.90975904e-01f, 3.73398513e-01f, -7.44468644e-02f, 2.34631434e-01f, 5.71838431e-02f,
  -3.06593984e-01f, -9.90003943e-02f, 1.40005052e-02f, 1.75205544e-01f, -1.42331868e-01f, 2.82113254e-01f, 1.32216185e-01f, 1.74259633e-01f, -6.14054650e-02f, 4.26293835e-02f,
  3.45447212e-02f, 1.04420446e-01f, -9.17181447e-02f, -9.21529010e-02f, 7.77728483e-02f, -5.83854802e-02f, 1.32635191e-01f, 5.38147762e-02f, 2.41898537e-01f, -7.78969424e-03f,
  3.10201980e-02f, 1.63104057e-01f, 1.69096336e-01f, 1.09375753e-01f, 1.93367705e-01f, 7.30152503e-02f, -5.12140132e-02f, 6.22652024e-02f, -2.07121983e-01f, -7.56615028e-02f,
  -2.36048475e-02f, 1.88673586e-01f, 6.00729994e-02f, -2.72096634e-01f, 1.40994191e-01f, -3.58091071e-02f, 2.74691265e-02f, -1.67703107e-02f, 8.25134441e-02f, -1.15956061e-01f,
  9.51728821e-02f, 1.38576388e-01f, 7.40176588e-02f, -1.83074385e-01f, 3.29639316e-02f, 1.42988965e-01f, 6.24599308e-02f, -1.41494170e-01f, -1.10215701e-01f, 1.39149547e-01f,
  -2.48297602e-02f, 1.45090267e-01f, -1.11479843e-02f, 5.50469048e-02f, -8.25455710e-02f, -2.83661168e-02f, 3.45422328e-01f, 4.69041914e-02f, -1.02980934e-01f, 9.42404717e-02f,
  9.03532952e-02f, -8.65926221e-02f, 2.21075401e-01f, -1.51609257e-01f, -3.09506506e-01f, -1.01914316e-01f, 1.51174113e-01f, 9.54512581e-02f, -1.98417068e-01f, 7.78603256e-02f,
  1.72697678e-01f, 1.05791055e-01f, 3.96697447e-02f, 8.54795799e-02f, 1.95697814e-01f, 2.56303936e-01f, -1.42694086e-01f, -1.23512156e-01f, -9.15722549e-02f, 8.94565359e-02f,
  3.26021135e-01f, 1.18979543e-01f, -4.73261178e-02f, -2.08886620e-02f, -7.02745318e-02f, -1.22871816e-01f, 6.31169081e-02f, 2.71239817e-01f, -4.99197468e-02f, 4.77639288e-02f,
  2.38541067e-01f, 2.85051137e-01f, -5.84376715e-02f, 5.54310577e-03f, -1.14002414e-02f, -1.72883242e-01f, 2.13750526e-01f, -1.41658476e-02f, 3.08613122e-01f, 1.04272142e-01f,
  1.22974545e-01f, 1.77953288e-01f, 2.30385274e-01f, -2.45107375e-02f, 3.16345751e-01f, 1.37493521e-01f, -1.53499050e-02f, -3.40515763e-01f, -1.04196355e-01f, 1.03417095e-02f,
  -6.95015397e-03f, -2.49901742e-01f, 1.79330736e-01f, -1.67778492e-01f, -8.14988688e-02f, 1.60520133e-02f, -2.53180265e-01f, 1.72119275e-01f, 1.84045568e-01f, 2.67215371e-01f,
  6.77167103e-02f, 1.01975128e-01f, 1.76735923e-01f, 1.31906390e-01f, 1.97501361e-01f, -1.50901943e-01f, 3.64632130e-01f, -8.64487141e-02f, 1.39398530e-01f, 2.59164542e-01f,
  -9.21657607e-02f, -3.13133262e-02f, -7.00750500e-02f, -1.01449206e-01f, -2.80547053e-01f, 3.03793430e-01f, -1.74609020e-01f, 1.36556491e-01f, 2.28270069e-01f, -1.10398591e-01f,
  9.42183211e-02f, 1.89919084e-01f, -1.01094134e-01f, 3.22697014e-01f, 6.38284255e-03f, 3.30315918e-01f, -8.38356689e-02f, -3.82265672e-02f, 2.96992976e-02f, -2.18720753e-02f,
  8.78239423e-02f, 1.81450718e-03f, -1.36842400e-01f, 1.70989141e-01f, -1.50938883e-01f, 2.09248126e-01f, -4.97506037e-02f, 3.14219564e-01f, -2.14861445e-02f, -7.36672878e-02f,
  2.18185976e-01f, 2.83306777e-01f, -6.11097477e-02f, 7.82185700e-03f, 9.49652120e-02f, 2.78660089e-01f, 3.01097840e-01f, -1.92365482e-01f, 7.70063251e-02f, 8.93597603e-02f,
  5.93080632e-02f, 3.09727192e-01f, -5.59421889e-02f, 1.06043525e-01f, 5.84995374e-02f, -2.81935055e-02f, -2.20310628e-01f, -1.47360846e-01f, 5.09021729e-02f, -1.28099369e-02f,
  1.93344444e-01f, -3.87698188e-02f, 2.09524527e-01f, 1.54781371e-01f, -3.16109043e-03f, 1.85259148e-01f, 1.95716634e-01f, 3.19424182e-01f, -1.31009892e-01f, -1.50751412e-01f,
  7.81220868e-02f, 8.32234323e-02f, -1.99559793e-01f, 2.59041190e-01f, -3.71807814e-02f, 3.88498083e-02f, -3.54095735e-02f, -2.01400563e-01f, -8.14864710e-02f, 5.85681349e-02f,
  -9.21549797e-02f, 8.46887827e-02f, 1.11228496e-01f, -9.27366316e-02f, -1.21096060e-01f, 9.33786407e-02f, 1.81177616e-01f, -5.39467745e-02f, 4.20209505e-02f, 1.75835729e-01f,
  -1.05538525e-01f, -1.13084242e-01f, -1.68510124e-01f, -9.50643346e-02f, 1.73696473e-01f, -9.40392986e-02f, -3.93295437e-02f, 1.23291917e-01f, 1.58453166e-01f, 8.67775083e-02f,
  -3.45420353e-02f, 1.02679454e-01f, 1.21135672e-03f, -7.65034854e-02f, 2.42735952e-01f, 3.24623853e-01f, -1.62501186e-01f, 1.39850244e-01f, -1.68883100e-01f, 2.16716290e-01f,
  2.69725591e-01f, 2.23816946e-01f, -6.07050322e-02f, -9.16027203e-02f, -5.99496290e-02f, 1.10537134e-01f, 3.40381376e-02f, -1.30119219e-01f, -7.91069046e-02f, 2.16099173e-01f,
  5.61909452e-02f, -1.50630996e-01f, -2.95423307e-02f, 7.26961438e-03f, -2.00014368e-01f, 1.85146496e-01f, 8.32110122e-02f, 1.70414299e-02f, 1.92995593e-01f, 2.28297308e-01f,
  -3.65812369e-02f, -2.81603485e-02f, -8.80387798e-02f, 1.36325061e-01f, 8.54111388e-02f, 6.31911606e-02f, 3.59040767e-01f, -1.27461120e-01f, -2.21794769e-01f, -1.51520502e-02f,
  3.39679718e-02f, -4.16029580e-02f, -1.64805993e-01f, -2.78030634e-01f, -4.23725694e-01f, 5.33670858e-02f, 9.51751396e-02f, -5.08292854e-01f, 1.95676908e-02f, -1.80839784e-02f,
  1.63646162e-01f, 1.12187877e-01f, -4.36554223e-01f, -2.00030599e-02f, 2.02986196e-01f, -1.64380834e-01f, -1.12179801e-01f, -1.52017415e-01f, 2.03154702e-02f, -4.06422392e-02f,
  1.49410293e-01f, -1.90052241e-01f, -3.24705541e-01f, 8.83481465e-03f, 2.81229973e-01f, 1.04016021e-01f, 1.34239167e-01f, 1.96547508e-01f, -1.20367594e-01f, 1.73003569e-01f,
  -2.49702021e-01f, -3.36533844e-01f, -2.64213443e-01f, -5.10895327e-02f, 2.49281004e-01f, -2.55356357e-02f, -2.70184100e-01f, -1.05609074e-01f, 1.31580964e-01f, 2.36946732e-01f,
  3.23054075e-01f, 6.32118806e-02f, 2.63644028e-02f, -1.44239634e-01f, -1.25389667e-02f, 3.02099824e-01f, -2.97200143e-01f, -6.42576814e-02f, -1.29809737e-01f, -1.93474799e-01f,
  4.12551872e-03f, 9.61965844e-02f, 1.41025810e-02f, 2.91091949e-02f, 9.31132361e-02f, 8.39394256e-02f, -3.99317175e-01f, 3.30957681e-01f, -5.33739477e-02f, -4.85084914e-02f,
  2.16344193e-01f, 2.04196036e-01f, 6.96783960e-02f, -1.00452274e-01f, 2.56152079e-02f, -1.32044956e-01f, 1.35960244e-03f, -9.40390080e-02f, 1.90444008e-01f, -1.41385093e-01f,
  -1.45066716e-02f, -4.33164179e-01f, 2.37125337e-01f, 1.41011700e-01f, -5.52064180e-02f, 5.37107326e-02f, -2.62705505e-01f, 1.58280097e-02f, -1.46911040e-01f, 3.78927588e-02f,
  -2.54042178e-01f, -7.98426345e-02f, -1.34651572e-01f, 2.15086624e-01f, -6.04318790e-02f, 2.75678840e-02f, -9.61862281e-02f, -1.42172650e-01f, 3.27714235e-01f, 1.04531750e-01f,
  2.96326876e-01f, -7.05372915e-02f, -1.53689429e-01f, 1.17762968e-01f, -2.83557683e-01f, 9.51890573e-02f, -1.35423303e-01f, 2.90110707e-02f, -4.50444147e-02f, 9.14220065e-02f,
  -1.38682306e-01f, -1.50026247e-01f, 2.01677874e-01f, -6.35766983e-02f, 1.59311980e-01f, -2.85513699e-03f, 1.72536463e-01f, -1.42749950e-01f, 2.46857986e-01f, 2.03113630e-01f,
  -2.60139167e-01f, 2.38798391e-02f, -4.58627604e-02f, 2.74247527e-02f, -6.72866479e-02f, -3.55865538e-01f, -1.97490111e-01f, 5.48375286e-02f, -9.35063809e-02f, -1.78982049e-01f,
  -1.66674972e-01f, 4.43178564e-01f, -8.74660462e-02f, 1.88878939e-01f, 1.76968977e-01f, -1.29263639e-01f, 2.72487253e-01f, 9.29593388e-03f, -1.74167231e-01f, 1.48275003e-01f,
  8.74077249e-03f, -3.12119573e-01f, -6.32133484e-02f, 2.60140654e-02f, -1.36376068e-01f, 2.85880089e-01f, 1.48420021e-01f, -3.42037752e-02f, 1.39651969e-01f, 1.73631012e-01f,
  9.73488986e-02f, 3.32345292e-02f, -7.02685788e-02f, 1.50891736e-01f, 9.79367122e-02f, 9.59423631e-02f, 5.07267099e-03f, -1.57711245e-02f, 5.67748435e-02f, -9.25208107e-02f,
  1.94663748e-01f, -3.06970119e-01f, -3.09760213e-01f, 1.35712117e-01f, -5.03943190e-02f, 2.55202413e-01f, -1.69122815e-01f, 8.75387564e-02f, 2.45531946e-01f, 9.25990753e-03f,
  6.97672218e-02f, -1.02384225e-01f, -1.37163326e-01f, 8.52381960e-02f, 1.05810434e-01f, 1.03438757e-01f, 1.53920338e-01f, -1.35685652e-01f, 2.27177531e-01f, 5.29817566e-02f,
  6.59393221e-02f, 9.71412659e-02f, 4.29008007e-02f, -2.47155875e-01f, 1.28554106e-01f, -6.89565465e-02f, 9.53407660e-02f, 6.08997829e-02f, 1.08740754e-01f, 1.95972085e-01f,
  1.52183033e-03f, 1.07422873e-01f, 1.10987864e-01f, 1.14965059e-01f, -1.53546423e-01f, 3.31963599e-03f, -1.31756470e-01f, -2.99146920e-01f, -4.11202818e-01f, 3.38329226e-01f,
  -5.47343120e-02f, 2.52445370e-01f, -3.35122421e-02f, -1.62005760e-02f, 2.29610339e-01f, 7.98865594e-03f, 1.46562364e-02f, 1.64987966e-02f, 1.38794601e-01f, -7.92622715e-02f,
  1.74225450e-01f, 2.68048942e-01f, 3.89606357e-02f, -7.61631057e-02f, 3.39391939e-02f, 2.16812938e-01f, -7.98740797e-03f, 1.29853701e-02f, -4.72279564e-02f, 1.01308718e-01f,
  2.03518599e-01f, 2.32597634e-01f, -2.42262155e-01f, 1.77303091e-01f, 2.22239387e-03f, 2.47742370e-01f, 1.39080927e-01f, 6.65134862e-02f, 8.74797106e-02f, -8.13604370e-02f,
  4.30151704e-04f, 1.80130273e-01f, -6.71330914e-02f, -1.54826818e-02f, 1.15300804e-01f, 1.90088693e-02f, 4.09671068e-02f, -1.05539426e-01f, 1.65260777e-01f, 2.02398514e-03f,
  2.96714716e-02f, -1.64556488e-01f, 1.68361247e-01f, -1.50154665e-01f, 6.99492097e-02f, -3.19010526e-01f, 3.28242272e-01f, 1.94716096e-01f, -6.84581548e-02f, 1.97644517e-01f,
  -5.52838482e-02f, 3.10836107e-01f, 7.39151165e-02f, 2.03627631e-01f, 1.17213123e-01f, 1.52989984e-01f, 1.97306294e-02f, -7.42947087e-02f, 1.88712329e-01f, -1.11530060e-02f,
  2.67334521e-01f, 2.50225574e-01f, 2.88307071e-01f, -3.34400833e-01f, -1.14625692e-01f, 6.19526468e-02f, -2.16408335e-02f, -5.62946349e-02f, -2.69410223e-01f, -8.32939968e-02f,
  -2.06476241e-01f, -4.12106477e-02f, 1.17563948e-01f, 8.34237784e-02f, -2.83193707e-01f, -2.41484791e-02f, -1.19709462e-01f, 9.46791470e-02f, 1.30072713e-01f, -1.00324921e-01f,
  2.91678369e-01f, -7.75574287e-03f, 1.30033540e-02f, 3.09497397e-02f, -3.50439847e-02f, -1.29761845e-01f, 2.52837777e-01f, -1.86535463e-01f, 9.55512002e-03f, 2.10551724e-01f,
  1.44990414e-01f, 2.57157505e-01f, 1.82775199e-01f, 2.31935173e-01f, 9.83232036e-02f, -2.71656156e-01f, -1.15013672e-02f, -4.42292318e-02f, -1.80339977e-01f, -6.65251166e-02f,
  6.44060969e-02f, -8.60199034e-02f, 7.05268010e-02f, 4.54081260e-02f, 1.06723972e-01f, 1.42420024e-01f, 9.66744423e-02f, 2.74809748e-01f, 7.88235068e-02f, 3.82364988e-02f,
  -1.06925517e-02f, 2.32249960e-01f, 7.83928633e-02f, -8.59182999e-02f, 2.33851865e-01f, -4.48543355e-02f, 1.44460273e-03f, -1.47531390e-01f, 8.60310495e-02f, 8.15941617e-02f,
  6.12146966e-02f, 1.54747680e-01f, -3.28793645e-01f, 2.37181529e-01f, 1.55936927e-01f, 1.05911829e-01f, -6.89657331e-02f, -3.48755389e-01f, -6.46986812e-02f, 1.37524143e-01f,
  7.48113263e-03f, 7.68987834e-02f, 1.64471105e-01f, -8.37360099e-02f, -1.91785648e-01f, -6.97277039e-02f, 3.35695930e-02f, 1.50247172e-01f, 6.01169700e-03f, -1.98309436e-01f,
  4.89565171e-02f, -1.75806448e-01f, 1.44688979e-01f, -8.02110881e-02f, -2.73782872e-02f, -2.43905768e-01f, -4.74995039e-02f, -1.60776705e-01f, 1.07653849e-01f, 1.27789512e-01f,
  2.43146941e-01f, -5.60966991e-02f, 1.58312961e-01f, -1.30962655e-01f, -1.56951725e-01f, 1.53408438e-01f, 6.78897742e-03f, 9.34559107e-02f, 1.65710133e-02f, 9.16585140e-03f,
  1.08745679e-01f, 8.52133557e-02f, -1.28206626e-01f, -3.68963112e-03f, 1.41077757e-01f, 2.94883579e-01f, -3.41838039e-02f, -1.72698453e-01f, 9.29895788e-02f, -1.11735865e-01f,
  -5.37535511e-02f, 5.82653396e-02f, 1.24551751e-01f, -1.90034136e-02f, 2.86240876e-01f, -4.50946297e-03f, -1.64737299e-01f, 3.82903591e-02f, -1.71258837e-01f, 2.32012331e-01f,
  1.63122043e-02f, 6.42749369e-02f, -1.61940306e-01f, 4.75103781e-03f, -2.28447877e-02f, -9.87261161e-03f, -3.92334014e-01f, 1.08415008e-01f, 1.23149283e-01f, -3.31061661e-01f,
  -1.76547766e-01f, 8.95826593e-02f, 1.71819732e-01f, 5.74684106e-02f, 5.94945587e-02f, -1.44208536e-01f, 2.75654703e-01f, 1.61312297e-01f, -2.22046360e-01f, -8.71863775e-03f,
  -5.75058199e-02f, 1.01798050e-01f, -1.59843698e-01f, 9.49838534e-02f, 1.26181528e-01f, -1.15929350e-01f, 6.92476705e-02f, 2.25745559e-01f, -8.70680213e-02f, 1.03278466e-01f,
  -1.13026686e-01f, -1.30288556e-01f, 1.53861940e-01f, -5.77138700e-02f, 5.05899377e-02f, 2.47640505e-01f, 4.84390557e-02f, 6.90396577e-02f, -3.22366834e-01f, 2.34593794e-01f,
  -1.18291564e-01f, -1.98193297e-01f, 2.02557713e-01f, 3.95852178e-02f, -1.02531515e-01f, 3.18632834e-02f, -1.15638569e-01f, 3.51327099e-02f, 1.22095816e-01f, 5.81602864e-02f,
  -5.48107363e-03f, 3.66775086e-03f, -6.97406009e-02f, -2.31131122e-01f, 8.99382234e-02f, 1.21487819e-01f, 2.64873981e-01f, 1.92204341e-01f, 2.87401408e-01f, -3.33541900e-01f,
  -1.15131035e-01f, 7.59147629e-02f, -9.22213793e-02f, 3.25680852e-01f, 2.28450999e-01f, 3.12135398e-01f, 2.06773043e-01f, 2.03576341e-01f, 3.16704005e-01f, 4.34807502e-02f,
  2.67370999e-01f, -1.04229137e-01f, 2.64555454e-01f, 3.62090677e-01f, 2.72324741e-01f, -2.58132577e-01f, -1.71989799e-01f, 1.55141830e-01f, 1.66083783e-01f, -8.52213204e-02f,
  -1.26222655e-01f, 1.15291998e-01f, -2.65713409e-02f, 1.38870269e-01f, 2.46752426e-02f, 1.51136890e-01f, -2.06152037e-01f, -2.78651784e-03f, 7.35624656e-02f, -1.38312712e-01f,
  1.23176917e-01f, -5.54368310e-02f, 3.35955918e-01f, -8.64721835e-02f, 9.73530039e-02f, 2.15942964e-01f, -5.33061335e-04f, 2.36719586e-02f, 2.48690903e-01f, -1.39038801e-01f,
  -1.07185468e-01f, 8.01643208e-02f, 3.09711456e-01f, 1.76710505e-02f, 1.47117853e-01f, 1.96491659e-01f, 6.77728951e-02f, -7.24733397e-02f, 8.82189721e-02f, -1.69455007e-01f,
  -1.90226987e-01f, 6.34345636e-02f, 1.08896948e-01f, 2.03438982e-01f, -9.62020755e-02f, 5.67204040e-03f, 7.00228959e-02f, 2.36702263e-01f, -5.61537705e-02f, 2.90963233e-01f,
  -3.06304377e-02f, -1.00555629e-01f, -3.40233967e-02f, 3.51639748e-01f, 2.19701901e-01f, 1.62844777e-01f, 7.94485137e-02f, -1.28698736e-01f, 3.32921386e-01f, 1.21703915e-01f,
  2.05339581e-01f, 1.02649048e-01f, 4.01013523e-01f, 1.18093193e-01f, 2.03457758e-01f, -6.12342209e-02f, 1.14611320e-01f, -9.66852903e-02f, 1.07253343e-01f, 5.36799543e-02f,
  4.11998816e-02f, -1.14199243e-01f, 1.16486177e-01f, -3.03703964e-01f, 9.88199636e-02f, 1.09659411e-01f, -4.57855724e-02f, -7.05056563e-02f, -7.31816068e-02f, -5.49024679e-02f,
  -1.53097078e-01f, 4.16282192e-02f, -1.60766587e-01f, -2.53298637e-02f, 5.13443463e-02f, -1.78811401e-02f, 1.46481752e-01f, -1.75167590e-01f, -8.22176933e-02f, 1.25700638e-01f,
  -1.24566093e-01f, 6.03677183e-02f, 5.91072552e-02f, 2.33097877e-02f, -6.19741231e-02f, 3.31167206e-02f, 1.55844286e-01f, 1.09271578e-01f, 2.21579745e-01f, 7.20527619e-02f,
  4.12187027e-03f, -1.30941972e-01f, 6.35642633e-02f, -1.99274346e-02f, -1.39337569e-01f, 5.28834807e-03f, -8.90791491e-02f, 2.71216128e-02f, 1.80051938e-01f, 2.62774285e-02f,
  1.70491591e-01f, 1.38648078e-01f, -4.95315902e-02f, 5.62032945e-02f, 3.09990972e-01f, 4.74963374e-02f, 2.64619648e-01f, 2.47198537e-01f, 1.13699473e-01f, 1.90069124e-01f,
  7.46084750e-02f, 8.67720973e-03f, 1.21237077e-01f, 1.15222022e-01f, 4.47015204e-02f, 1.70858636e-01f, 1.96622282e-01f, 2.87482619e-01f, -1.88512459e-01f, 2.51917124e-01f,
  2.39943340e-01f, -3.81361730e-02f, -5.90453409e-02f, 5.27480096e-02f, 2.78643370e-01f, -1.79401115e-02f, -2.12383211e-01f, -4.28893194e-02f, 1.70864388e-01f, -5.22689149e-02f,
  1.66650683e-01f, 3.50166857e-02f, 7.91670755e-02f, 2.63534665e-01f, 2.00600311e-01f, 3.33791785e-02f, 7.99689069e-03f, 2.00354308e-02f, 1.64913014e-01f, 8.94669350e-03f,
  -9.98803899e-02f, -3.02937895e-01f, -1.00670934e-01f, 1.38668567e-01f, 1.05987541e-01f, 2.10058987e-01f, -4.20576409e-02f, -1.31199330e-01f, 1.61149219e-01f, -1.81950163e-04f,
  2.05752775e-01f, 2.38579884e-02f, 2.61556357e-01f, 1.37561768e-01f, -1.47614300e-01f, -3.81620787e-02f, 3.50245237e-02f, 1.44677341e-01f, 6.13191798e-02f, -3.35486010e-02f,
  -2.35457905e-02f, -3.29422206e-02f, 1.25721589e-01f, 4.11360748e-02f, 1.33120820e-01f, -2.00457931e-01f, 6.68148249e-02f, 1.90913957e-02f, -9.96428877e-02f, -1.87296674e-01f,
  4.12344873e-01f, -1.30807208e-02f, -1.34674311e-01f, 2.03531906e-01f, 3.91411223e-02f, 1.34546086e-01f, -1.70873255e-01f, -4.23890799e-01f, -1.59593076e-01f, 4.65586372e-02f,
  -2.48717949e-01f, 2.05214377e-02f, -3.82650532e-02f, 3.93466502e-01f, 1.52562767e-01f, 6.67994395e-02f, 2.79381961e-01f, -2.92259045e-02f, 3.57069075e-02f, -6.43179342e-02f,
  -2.98203707e-01f, 1.60632044e-01f, -1.56255648e-01f, 5.85624191e-04f, 1.56958878e-01f, -1.72806364e-02f, -7.94792846e-02f, 2.26279169e-01f, 1.37414560e-01f, 4.09987830e-02f,
  1.68444768e-01f, 1.23538584e-01f, -1.41211795e-02f, 1.43970653e-01f, -2.97271628e-02f, -6.18087202e-02f, 1.08208004e-02f, 3.02987218e-01f, -3.50907259e-02f, 5.19232415e-02f,
  4.15700190e-02f, 7.42468238e-02f, 2.20896006e-01f, -9.94951651e-02f, -2.83307880e-01f, -6.85320348e-02f, 4.56965389e-03f, 3.64739597e-01f, -5.35776056e-02f, 9.83114243e-02f,
  1.48783252e-01f, 8.33635852e-02f, 1.31445989e-01f, 7.23107606e-02f, -8.27419236e-02f, -1.63380764e-02f, 3.49205397e-02f, 1.58783048e-01f, 2.58743670e-02f, 1.93202987e-01f,
  2.12910920e-01f, 1.70948818e-01f, -1.99889451e-01f, 1.03948817e-01f, -2.71898955e-01f, -1.38184920e-01f, 1.62884980e-01f, -2.09358364e-01f, 1.74802110e-01f, -1.45890936e-01f,
  2.76250720e-01f, 9.76223424e-02f, 1.72632977e-01f, 1.83532342e-01f, 1.99122101e-01f, 1.30983502e-01f, -6.36945814e-02f, 3.58965486e-01f, -1.92036614e-01f, 7.68277124e-02f,
  3.11988220e-02f, -1.07356682e-01f, 8.36532637e-02f, -6.50593936e-02f, 9.12592486e-02f, -2.24110737e-01f, 1.85888872e-01f, -1.89217001e-01f, -2.66252621e-03f, -1.84557930e-01f,
  -1.09474108e-01f, -1.65712401e-01f, -8.55960250e-02f, -3.39771956e-01f, 7.43327662e-02f, -1.57249361e-01f, -1.11347556e-01f, 6.22024387e-02f, 8.92385766e-02f, -7.12630972e-02f,
  9.04765427e-02f, 1.93749115e-01f, -2.14862466e-01f, 1.55310139e-01f, 1.83005616e-01f, 1.44330949e-01f, 1.08902708e-01f, -1.04862727e-01f, 2.47483745e-01f, -2.24179290e-02f,
  2.63790160e-01f, 1.19177081e-01f, 2.57975996e-01f, 6.78894520e-02f, -1.44674107e-01f, 1.16178282e-01f, 4.06100117e-02f, -1.45601332e-01f, -2.36908972e-01f, 2.70915926e-01f,
  -7.53318444e-02f, -2.16820627e-01f, 1.62254140e-01f, 9.15599167e-02f, 4.35379557e-02f, 3.94391175e-03f, 1.80838987e-01f, 1.23641104e-01f, 1.94241211e-01f, 4.66378331e-01f,
  -6.35725958e-03f, 2.43578985e-01f, 1.83509171e-01f, 6.39586076e-02f, 2.68008381e-01f, 8.49200506e-03f, -1.69466317e-01f, 1.46303205e-02f, 5.19072339e-02f, -1.24242283e-01f,
  9.03392360e-02f, 2.67312795e-01f, 3.55392277e-01f, 3.21675912e-02f, 2.45231479e-01f, -1.08961076e-01f, 1.35825202e-02f, 1.96027979e-01f, 6.50444552e-02f, 2.49254964e-02f,
  -1.75193787e-01f, 9.22323316e-02f, -2.66341418e-01f, -3.81097533e-02f, -1.04994282e-01f, 9.35923606e-02f, -8.21367651e-02f, -2.61170238e-01f, -4.16288860e-02f, -2.05577295e-02f,
  1.73012123e-01f, 3.01025957e-01f, 1.02298692e-01f, 7.24815056e-02f, 5.05957939e-02f, 4.77875397e-02f, -3.98079567e-02f, -1.74844995e-01f, 4.11290348e-01f, 2.94777513e-01f,
  -2.32207086e-02f, 1.33598968e-01f, 6.18973710e-02f, 8.98703262e-02f, 9.54804569e-02f, -1.19548850e-02f, 3.67928892e-01f, 1.70343563e-01f, 8.93820152e-02f, -1.72038212e-01f,
  -3.18981886e-01f, 5.21915853e-02f, 3.02250952e-01f, 1.22380637e-01f, -2.63889849e-01f, -2.51322854e-02f, 2.60322064e-01f, 1.58562228e-01f, -7.15081543e-02f, 2.81720370e-01f,
  1.57315224e-01f, 1.22638629e-03f, -1.31200597e-01f, 1.87560216e-01f, 1.71659980e-02f, 3.89220826e-02f, -1.25155941e-01f, 9.98394489e-02f, -1.20437190e-01f, 5.80856800e-02f,
  -1.11967009e-02f, 1.17420822e-01f, -1.04182020e-01f, 1.78555295e-01f, -2.04882413e-01f, -5.95238879e-02f, 6.05990887e-02f, 2.23239318e-01f, 3.05963792e-02f, -9.01905745e-02f,
  3.72379273e-02f, 3.55648637e-01f, 1.09513834e-01f, 4.13102433e-02f, 4.61091064e-02f, -2.85881668e-01f, -7.74901062e-02f, -3.25653434e-01f, -8.31916109e-02f, -2.41077214e-01f,
  1.01855889e-01f, 2.30555922e-01f, 4.04254168e-01f, -5.90410344e-02f, -1.13186441e-01f, 2.86072880e-01f, 1.66559741e-01f, 2.77809918e-01f, -5.72134890e-02f, -2.80131549e-01f,
  2.26545274e-01f, 1.64559826e-01f, -2.66136322e-02f, -1.02181531e-01f, -1.10743321e-01f, -9.23165381e-02f, 7.12167323e-02f, 6.19594343e-02f, 1.09861374e-01f, 2.48322114e-01f,
  -3.71894091e-02f, 1.53979659e-01f, -4.05705482e-01f, -8.97559375e-02f, -3.36376339e-01f, -5.22705875e-02f, -2.88425572e-02f, 1.77286230e-02f, -3.12552571e-01f, 5.49575910e-02f,
  2.96846181e-01f, -2.21849710e-01f, 3.07475805e-01f, -5.39567359e-02f, 1.56542301e-01f, -1.06184818e-01f, 4.88251261e-02f, 5.59520237e-02f, -2.64810413e-01f, 5.95990345e-02f,
  -8.72233883e-02f, 1.17471904e-01f, -2.07121506e-01f, 1.64940745e-01f, 2.38514915e-01f, -7.17563853e-02f, 1.41245574e-01f, -2.81313229e-02f, 3.57411951e-01f, -6.60908282e-01f,
  -2.83344030e-01f, 1.63617134e-01f, -1.31674021e-01f, -4.37885672e-02f, -8.56532753e-02f, 8.04466978e-02f, 1.02195986e-01f, -4.60452624e-02f, -3.67111005e-02f, 4.99769486e-02f,
  2.41006434e-01f, 1.24817304e-01f, 2.22906068e-01f, -8.37353095e-02f, 4.58103344e-02f, 1.39126182e-01f, -2.52807010e-02f, 1.82106331e-01f, 1.55489475e-01f, -2.61468273e-02f,
  2.73435026e-01f, 5.25023825e-02f, 1.60189066e-02f, -1.48136895e-02f, -6.64459988e-02f, -8.33914056e-02f, 1.08595058e-01f, 1.38847068e-01f, -1.07651800e-01f, 9.68683958e-02f,
  1.97364450e-01f, 9.39392718e-04f, -6.73836097e-02f, -7.40673989e-02f, 1.93531960e-01f, 5.17733432e-02f, -1.26524922e-03f, 5.44956662e-02f, 9.17852223e-02f, 1.72250137e-01f,
  -1.29010588e-01f, -1.62639692e-01f, 7.87378103e-02f, 1.04212210e-01f, -8.35229233e-02f, 2.43817866e-01f, 2.31621005e-02f, 3.10948789e-02f, 6.24257363e-02f, 2.47783616e-01f,
  -1.99239299e-01f, 1.28974035e-01f, 1.56069994e-01f, 7.09340675e-03f, 9.64154899e-02f, -1.42856613e-01f, -4.59312052e-02f, -3.01061690e-01f, -3.33293408e-01f, 2.52682231e-02f,
  6.91687912e-02f, 2.34387368e-02f, -3.43083471e-01f, 3.30855548e-01f, 1.98185414e-01f, -1.88878939e-01f, 1.60935879e-01f, 1.50295049e-01f, 2.07459107e-02f, 2.17829570e-01f,
  1.51701897e-01f, 1.66022658e-01f, 7.37144575e-02f, 2.73780320e-02f, -5.17455712e-02f, -2.10071906e-01f, -5.43843657e-02f, -2.98721433e-01f, 1.05295315e-01f, -1.57353893e-01f,
  1.52544096e-01f, 1.27861530e-01f, -5.67703322e-02f, 3.28929216e-01f, 6.28817752e-02f, -1.94671601e-02f, -2.89806485e-01f, -2.59862393e-02f, 5.17816953e-02f, 1.92886237e-02f,
  -5.40966429e-02f, 1.58701599e-01f, -1.74488634e-01f, 3.63030806e-02f, 2.25626767e-01f, 1.12933733e-01f, -2.33288892e-02f, 1.87136754e-01f, 1.34863287e-01f, 2.83123106e-01f,
  -3.51875782e-01f, -2.08821148e-01f, -2.48807967e-02f, 1.57920927e-01f, 1.41718298e-01f, -5.52908629e-02f, -5.64859547e-02f, 4.94241947e-03f, 2.55279720e-01f, -8.21498260e-02f,
  1.31644428e-01f, 7.38035962e-02f, 2.11199209e-01f, -5.38199069e-03f, 1.63156644e-01f, 1.41766876e-01f, -1.48917541e-01f, 1.05749778e-01f, -2.53230810e-01f, -1.48695139e-02f,
  1.90017775e-01f, -4.17541891e-01f, -4.37980950e-01f, 4.88717854e-02f, -9.94376168e-02f, -2.58177263e-03f, 1.46501571e-01f, 4.79655564e-01f, 4.06668186e-01f, -1.43094763e-01f,
  3.30225259e-01f, 1.07026055e-01f, 2.60314703e-01f, 3.04768216e-02f, -1.43068343e-01f, 4.14456993e-01f, 2.74979006e-02f, -2.67437488e-01f, -3.34838212e-01f, -2.09934097e-02f,
  4.35263403e-02f, 2.09349275e-01f, 1.24667160e-01f, -2.80990489e-02f, 2.79524047e-02f, 2.13650331e-01f, -1.12115435e-01f, 6.66611865e-02f, 7.51939341e-02f, -1.74780525e-02f,
  1.20034758e-02f, 2.14375407e-01f, 8.17327425e-02f, -2.08717719e-01f, 1.18150339e-01f, 1.88392863e-01f, 2.10521668e-01f, -2.64626235e-01f, -3.37187916e-01f, 2.16088608e-01f,
  1.83734432e-01f, 1.35598347e-01f, 6.15605675e-02f, 2.35140756e-01f, -8.95497128e-02f, 2.36243829e-01f, -5.15512330e-03f, 2.06246138e-01f, 4.40577790e-02f, 7.04622688e-03f,
  -1.80035874e-01f, 2.25991130e-01f, -7.63581553e-03f, 1.71405330e-01f, 2.07853928e-01f, 1.41309336e-01f, 6.89908070e-03f, 3.02011430e-01f, -1.77200586e-02f, -1.90022185e-01f,
  1.31431758e-01f, 8.11050739e-03f, 2.40086317e-01f, -1.73711509e-01f, -1.43430069e-01f, -2.23261729e-01f, 4.00500670e-02f, -1.71414092e-01f, -2.23566279e-01f, -3.09077084e-01f,
  1.43190369e-01f, 1.57769039e-01f, 1.80519551e-01f, 1.94553256e-01f, 8.29633400e-02f, -4.01122659e-01f, -3.98317166e-02f, 1.56547785e-01f, -9.96792316e-02f, 1.15247279e-01f,
  -9.68245566e-02f, -3.82068455e-02f, -1.70445427e-01f, 6.21080585e-02f, -7.88670704e-02f, 2.70705879e-01f, -2.95953453e-03f, -1.95149496e-01f, 1.06757887e-01f, 2.83191472e-01f,
  1.02883004e-01f, -2.02552080e-02f, 1.36844903e-01f, -1.52113616e-01f, 2.17069924e-01f, -6.24970160e-02f, 5.48131503e-02f, 2.33618682e-03f, 2.28303224e-01f, -2.66471893e-01f,
  4.85434234e-02f, -2.29783967e-01f, -9.41080973e-02f, -1.13688633e-01f, -6.65950328e-02f, 2.46890366e-01f, 1.56005304e-02f, -1.51284292e-01f, 3.00674379e-01f, -1.74354970e-01f,
  1.59364939e-02f, -5.92430830e-02f, 1.57992035e-01f, -6.06639720e-02f, 4.94476520e-02f, 2.11433351e-01f, 1.81288585e-01f, 1.13226123e-01f, -3.23214047e-02f, 1.70924112e-01f,
  1.38739543e-02f, -3.20376381e-02f, -1.34959400e-01f, -1.33967757e-01f, 1.01142652e-01f, -1.87218145e-01f, -7.53334984e-02f, -2.53022909e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  -4.88996878e-03f, 9.77539122e-02f, 1.11886561e-01f, 1.82438232e-02f, 1.00765832e-01f, 2.63119012e-01f, 1.86785445e-01f, 2.47130617e-01f, 1.83610599e-02f, 9.44911912e-02f,
  1.85045470e-02f, 3.20137925e-02f, 1.90909907e-01f, 2.62722135e-01f, 1.10802338e-01f, 1.87257275e-01f, 1.51013747e-01f, 6.72240704e-02f, 4.41151634e-02f, 2.21643567e-01f,
  9.00712833e-02f, 1.82183564e-01f, 6.39931187e-02f, 6.66892380e-02f, 1.49790064e-01f, -9.83402580e-02f, 1.21690877e-01f, -2.17711609e-02f, 1.51217848e-01f, -3.70795988e-02f,
  -2.35152747e-02f, -9.60958097e-03f, 2.52656192e-01f, 8.22739303e-02f, 9.73433256e-02f, 4.19179574e-02f, 7.88336247e-02f, 6.97899684e-02f, 2.30256751e-01f, 2.16543838e-01f,
  1.12899020e-01f, 1.37236685e-01f, 7.91216418e-02f, -4.34790365e-03f, 7.63651952e-02f, 1.93695605e-01f, 7.88096115e-02f, 2.08138123e-01f, -8.24309047e-03f, 1.51707292e-01f,
  2.08085746e-01f, 5.67967147e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -3.74733597e-01f, -2.98782289e-01f, -6.20882884e-02f, 6.72337487e-02f, -4.67231244e-01f, -2.34122485e-01f, 1.41913602e-02f, -5.00475578e-02f, 2.24991105e-02f, 8.54012519e-02f,
  5.40036522e-02f, 2.03199416e-01f, 1.46143153e-01f, 2.17990205e-02f, 9.88854021e-02f, 1.26057044e-01f, 1.18083730e-01f, -3.69694412e-01f, -4.21675771e-01f, -1.49344280e-01f,
  -2.63559967e-01f, 1.48186892e-01f, 2.09779382e-01f, -1.17278621e-02f, -1.33207113e-01f, 4.89282012e-02f, 1.82718262e-01f, -1.84821814e-01f, -2.44014338e-02f, -2.88017273e-01f,
  1.36003166e-01f, -3.73551637e-01f, 1.83877081e-01f, -2.26021409e-01f, 9.68808010e-02f, -6.31796494e-02f, -1.40103251e-01f, 1.62478432e-01f, 4.83186878e-02f, 1.26010880e-01f,
  -2.67102811e-02f, 9.06448886e-02f, 4.16518152e-02f, 4.31806445e-02f, -3.18259932e-02f, -2.29405269e-01f, -1.11573778e-01f, 1.90444559e-01f, 1.54917538e-01f, -1.40346959e-01f,
  -9.68333557e-02f, -1.29615232e-01f, -2.19381228e-01f, -4.57099155e-02f, -1.04248926e-01f, 2.52784733e-02f, 2.54252434e-01f, -3.37617815e-01f, -4.37786460e-01f, -4.29879725e-01f,
  1.88126281e-01f, -1.13752611e-01f, -1.09232388e-01f, 1.63450032e-01f, -4.79939207e-02f, -2.29321178e-02f, 1.39587343e-01f, -4.94920686e-02f, 1.07700497e-01f, 2.17883721e-01f,
  -2.92878568e-01f, 1.61480114e-01f, -7.83715844e-02f, -2.67891586e-01f, 3.22059721e-01f, -7.89800584e-02f, -4.00474705e-02f, 2.34332547e-01f, 1.39431462e-01f, -3.77885669e-01f,
  -3.27071279e-01f, -1.20193530e-02f, -1.77359030e-01f, 5.22086807e-02f, -2.33606383e-01f, 1.51814625e-01f, 2.81215701e-02f, -4.22600687e-01f, 1.00929469e-01f, -6.39454275e-02f,
  1.32101744e-01f, -2.62201041e-01f, -8.89316648e-02f, -5.39895594e-02f, 2.25884363e-01f, -2.24723089e-02f, -3.57941687e-01f, -1.86910540e-01f, -9.22508314e-02f, 1.38431996e-01f,
  1.30320741e-02f, 2.04575330e-01f, -1.09720498e-01f, 8.45495705e-03f, 1.17382705e-01f, -1.64046913e-01f, 2.10080072e-01f, 4.31038924e-02f, -1.00160927e-01f, -1.98746361e-02f,
  2.05175672e-02f, -1.09421842e-01f, 1.70121342e-01f, -1.63960829e-01f, 8.42104554e-02f, 2.22798109e-01f, -3.50285992e-02f, 1.62930444e-01f, -3.06949049e-01f, 4.64689955e-02f,
  2.26844758e-01f, -3.62943746e-02f, 1.93577871e-01f, 1.05666101e-01f, -1.60945103e-01f, 1.32754937e-01f, 1.37067497e-01f, 3.06362629e-01f, 6.16527312e-02f, 9.45009962e-02f,
  -1.14683948e-01f, 8.15661717e-03f, 1.61026180e-01f, 8.87897536e-02f, -1.46308318e-01f, -3.09555233e-01f, 3.81766021e-01f, 1.88437313e-01f, 4.00065720e-01f, -2.42055982e-01f,
  -5.53411305e-01f, -1.86530381e-01f, -6.34264871e-02f, -1.87278569e-01f, -9.95043591e-02f, -2.13710815e-01f, -1.38784915e-01f, 1.18235931e-01f, -1.70951590e-01f, 2.14971706e-01f,
  -2.50346243e-01f, 2.19504058e-01f, -4.37690973e-01f, 1.23389646e-01f, -8.26319493e-03f, 1.36150479e-01f, 2.63195455e-01f, -2.19675690e-01f, 3.57032627e-01f, -3.57883841e-01f,
  1.52362123e-01f, 3.57461609e-02f, -1.40660182e-01f, -2.82490164e-01f, -1.72076449e-01f, -4.21808928e-01f, 1.93414256e-01f, 8.68683457e-02f, 3.06357890e-02f, 1.21669821e-01f,
  4.82546026e-03f, -3.25619906e-01f, 2.35121161e-01f, -2.42927030e-01f, -2.68131196e-01f, -1.57306626e-01f, 1.90578684e-01f, -2.01119706e-01f, 2.01514527e-01f, -1.25259787e-01f,
  -2.91355371e-01f, 6.65145889e-02f, 1.44878224e-01f, 2.89775245e-02f, 3.16373289e-01f, -3.15589905e-02f, -1.31111100e-01f, -4.16289002e-01f, -1.32243410e-01f, -4.80091184e-01f,
  3.09381902e-01f, 6.11685663e-02f, -2.60872450e-02f, -1.25458017e-01f, -4.81857061e-02f, -1.63391363e-02f, 8.40450004e-02f, 1.35080352e-01f, 9.64301303e-02f, -1.07784815e-01f,
  1.78395629e-01f, -2.65661865e-01f, 5.86820804e-02f, 1.15523331e-01f, 1.70090944e-01f, -4.04567540e-01f, -3.27496111e-01f, -2.87570469e-02f, 2.01057658e-01f, 4.14392315e-02f,
  -1.06089050e-02f, -4.44820076e-01f, -2.22009540e-01f, -9.30633321e-02f, 5.91448806e-02f, -2.73868833e-02f, 1.83839142e-01f, 8.66275504e-02f, -7.20719099e-02f, 6.56611025e-02f,
  -3.66315752e-01f, -3.06090295e-01f, -1.13722198e-01f, 1.80345118e-01f, -1.15041450e-01f, -4.20600295e-01f, -8.77574012e-02f, -1.41365647e-01f, 1.66939005e-01f, -1.48454070e-01f,
  6.21101968e-02f, 5.55030443e-02f, -3.50024216e-02f, 1.92015082e-01f, -5.44944555e-02f, 1.16252869e-01f, -3.99644226e-01f, -7.98051506e-02f, -8.64165425e-02f, -1.48617670e-01f,
  1.90733358e-01f, -4.36608121e-03f, -2.31423259e-01f, 2.30986953e-01f, 1.99447155e-01f, -2.41455108e-01f, 1.44348726e-01f, 1.43768847e-01f, -1.26930803e-01f, 7.95392990e-02f,
  -4.45345879e-01f, -6.32696629e-01f, -3.58062297e-01f, -3.37998271e-01f, -4.80343774e-02f, -5.50968759e-02f, 7.59362429e-02f, -1.43439351e-02f, -2.23003641e-01f, -2.71884650e-01f,
  1.85860783e-01f, -1.50315225e-01f, -1.04971170e-01f, 5.28126247e-02f, 2.59104967e-01f, 2.94342488e-01f, -8.30482915e-02f, 2.14905098e-01f, 1.17635682e-01f, -2.76633322e-01f,
  -9.61512849e-02f, 1.04083508e-01f, 1.41664490e-01f, -4.30879831e-01f, 5.81972487e-02f, 5.93882352e-02f, 2.02472642e-01f, -2.00019673e-01f, -2.29989439e-02f, 1.22626960e-01f,
  -2.15773121e-01f, 8.72544944e-02f, -7.75715932e-02f, -4.92188036e-02f, 3.01524885e-02f, 2.03752264e-01f, -3.00852776e-01f, 4.35973220e-02f, 9.69837233e-02f, -4.55406904e-01f,
  8.12416822e-02f, -3.23964238e-01f, -1.58538193e-01f, -7.18794465e-02f, 2.01979697e-01f, 1.12521902e-01f, -4.13749993e-01f, -1.01826778e-02f, 2.26738080e-01f, 6.85615912e-02f,
  -4.78034392e-02f, -2.60915339e-01f, -2.53418177e-01f, -2.18831256e-01f, -1.14519142e-01f, 1.56465352e-01f, -7.62417242e-02f, -1.98882431e-01f, -9.67290699e-02f, 4.83600572e-02f,
  1.85020462e-01f, 1.09772384e-01f, -1.61865093e-02f, -8.22338611e-02f, -2.45210707e-01f, 2.04412520e-01f, 2.01283678e-01f, -5.50215803e-02f, -1.51119202e-01f, -9.77044180e-02f,
  2.71634519e-01f, 5.61179742e-02f, -8.89912769e-02f, 6.68152049e-02f, -4.66708839e-03f, 9.12656412e-02f, 1.98852830e-02f, -2.72982866e-01f, 7.96087757e-02f, -6.76251128e-02f,
  -2.33743489e-01f, 1.50297195e-01f, -3.06677967e-02f, 1.68812886e-01f, 1.99100673e-01f, 5.63307852e-02f, 1.49986789e-01f, 1.86605796e-01f, -3.01636845e-01f, 8.69223922e-02f,
  3.16738218e-01f, 1.32247865e-01f, -8.92656762e-03f, 1.60724465e-02f, 1.07656047e-01f, 3.93514521e-02f, 1.08354077e-01f, -3.14705551e-01f, 2.82340229e-01f, 3.60403769e-02f,
  4.56645116e-02f, 8.76341388e-02f, -2.78443635e-01f, -7.96235073e-03f, -1.23391569e-01f, 1.87973693e-01f, 1.38434917e-01f, 8.01684856e-02f, 1.05350092e-01f, -2.56080419e-01f,
  3.10139567e-01f, -1.10180110e-01f, -1.36387065e-01f, 6.37996122e-02f, 1.83553472e-01f, 1.59666255e-01f, -1.07201906e-02f, -3.82658541e-01f, -3.00774753e-01f, -9.37284157e-02f,
  5.92169203e-02f, 4.28678580e-02f, -9.86519502e-04f, 1.26699984e-01f, 3.41862626e-02f, -1.75185804e-03f, -3.65112305e-01f, -3.25466841e-01f, -4.82394286e-02f, 1.68013293e-02f,
  1.90541431e-01f, -2.69054085e-01f, -3.84508520e-01f, -6.79493994e-02f, 1.69529859e-02f, -1.33454099e-01f, -9.07885134e-02f, 1.00266397e-01f, -1.27493471e-01f, 1.37645919e-02f,
  1.55997217e-01f, 2.58102208e-01f, -2.30877817e-01f, 2.41782799e-01f, -4.86013256e-02f, 1.55626804e-01f, -6.36323765e-02f, 2.52112746e-01f, -4.36456166e-02f, 1.21713402e-02f,
  -5.85927129e-01f, -2.25281656e-01f, -2.70246360e-02f, 2.18976244e-01f, -2.61910915e-01f, -2.09091306e-01f, -3.09074530e-03f, -1.20210722e-01f, -1.92165330e-01f, -4.91823196e-01f,
  -1.51268378e-01f, 1.88799292e-01f, -2.84319937e-01f, -4.38530976e-03f, 1.10317342e-01f, -2.93519527e-01f, -1.33691337e-02f, 2.92445958e-01f, -1.76279157e-01f, -2.13200688e-01f,
  -8.04424286e-02f, -9.71862972e-02f, 8.43308717e-02f, -4.99886870e-02f, 1.45749778e-01f, -3.90486211e-01f, -1.86073445e-02f, -1.59395095e-02f, -7.76572600e-02f, -2.86350936e-01f,
  2.16051653e-01f, 1.10772308e-02f, -1.09812282e-01f, -5.96791506e-01f, 2.66727239e-01f, -2.69930195e-02f, -4.34161782e-01f, 2.30042785e-01f, 2.10507840e-01f, -5.67593753e-01f,
  -3.00701618e-01f, 1.88711971e-01f, 1.18677989e-01f, -8.35818723e-02f, 1.92111343e-01f, 4.47783060e-02f, -1.29884496e-01f, 6.79661930e-02f, 5.33590838e-03f, 9.37355310e-02f,
  -5.41227944e-02f, -9.22344998e-02f, 2.74485033e-02f, -6.37073889e-02f, 1.29345760e-01f, 3.66812460e-02f, -2.01208532e-01f, -2.69376099e-01f, 1.61491763e-02f, -1.11372791e-01f,
  -4.35811132e-01f, -2.92992324e-01f, -1.02554061e-01f, -1.16088517e-01f, -4.66121994e-02f, 1.00832410e-01f, 1.78773087e-02f, -2.14708656e-01f, -3.56887728e-01f, -1.43997908e-01f,
  -1.95251629e-01f, -2.16566861e-01f, 2.13044688e-01f, -4.03949171e-01f, -4.84531298e-02f, 8.88353661e-02f, -1.90496519e-01f, -6.58828616e-02f, -2.91453660e-01f, 1.30589038e-01f,
  -1.14142619e-01f, 1.15094869e-03f, 1.13643007e-02f, -1.32811025e-01f, 2.27227792e-01f, -9.99062806e-02f, -2.73700446e-01f, 1.49406493e-01f, -2.90954173e-01f, 3.83992046e-02f,
  -5.17991255e-04f, -1.52136117e-01f, -2.45407075e-01f, 7.01675937e-02f, -2.60845661e-01f, 2.00980619e-01f, 1.52299210e-01f, 1.82797201e-02f, -3.29009414e-01f, 7.35862628e-02f,
  3.24213207e-01f, -1.50160551e-01f, -5.91561794e-02f, -1.12854198e-01f, -9.59547609e-02f, 1.23972319e-01f, 7.17704510e-03f, 1.36206150e-01f, -1.94772944e-01f, 2.33870775e-01f,
  5.57453372e-02f, -1.76388919e-01f, 6.69641942e-02f, -1.27436787e-01f, -1.61718875e-02f, -6.91379756e-02f, 2.33789422e-02f, -2.47543201e-01f, 2.56158859e-01f, -3.30637693e-01f,
  -6.29689172e-02f, 3.72791499e-01f, -2.19616264e-01f, -2.65247881e-01f, -9.79428291e-02f, -7.92770833e-02f, 1.53597921e-01f, -2.37934336e-01f, -2.52884269e-01f, 2.48414278e-01f,
  2.29025587e-01f, -5.04980199e-02f, -2.01165117e-02f, 2.06490874e-01f, -1.63593199e-02f, 1.70411512e-01f, -4.56551425e-02f, -1.67801887e-01f, -4.16080266e-01f, -3.12029302e-01f,
  2.83302695e-01f, 1.31557226e-01f, 1.85844198e-01f, 1.05003510e-02f, -3.76238167e-01f, 4.13099200e-01f, -3.05428684e-01f, 5.39240101e-03f, -2.40904450e-01f, -2.72332489e-01f,
  -2.30655193e-01f, -1.51150346e-01f, 7.58988559e-02f, -2.99054325e-01f, -3.25510502e-01f, -1.53707489e-01f, 2.24583969e-01f, 1.33971334e-01f, 1.63644210e-01f, 2.58698940e-01f,
  -6.14755973e-03f, 5.90606071e-02f, -1.98096126e-01f, -1.92335367e-01f, -1.80213243e-01f, -2.53130913e-01f, -4.28600371e-01f, 6.49105087e-02f, 1.43816143e-01f, -2.27441385e-01f,
  -4.05727215e-02f, 6.62553683e-02f, -7.10960403e-02f, 2.17454806e-01f, 2.32626691e-01f, -2.35667989e-01f, 9.39869136e-02f, 2.14106157e-01f, 4.23576683e-01f, 6.17817380e-02f,
  -4.27111238e-02f, 1.40270621e-01f, 2.82143027e-01f, -1.51653960e-01f, -1.62452266e-01f, 6.78418800e-02f, -2.87690312e-01f, -2.97623783e-01f, -5.02027035e-01f, -1.82868168e-01f,
  2.49733739e-02f, 1.40183374e-01f, 1.17471769e-01f, -2.13011906e-01f, 2.10253865e-01f, 2.10121304e-01f, -1.31768927e-01f, -3.53935897e-01f, -4.32395041e-01f, -1.27287200e-02f,
  5.48979687e-03f, 2.24932119e-01f, -4.50919330e-01f, 7.32619762e-02f, -1.56315759e-01f, -1.28258973e-01f, -3.44119161e-01f, -1.71476811e-01f, 9.56768468e-02f, 2.22111642e-01f,
  9.54621211e-02f, -1.36427090e-01f, 1.11463644e-01f, -1.94316074e-01f, 1.66918263e-01f, 3.78969498e-02f, -1.28913447e-01f, 3.29996757e-02f, -7.88892955e-02f, -5.55732131e-01f,
  1.13994233e-01f, 2.20433727e-01f, -1.98725969e-01f, -2.10441828e-01f, -9.77490991e-02f, -2.23110154e-01f, -5.49738519e-02f, 1.06132522e-01f, -8.82561207e-02f, 1.36592194e-01f,
  1.42097443e-01f, -3.63242328e-01f, -3.02836834e-03f, 1.88195720e-01f, 9.31487009e-02f, -1.30261794e-01f, 8.12195837e-02f, 1.29208220e-02f, 1.05428316e-01f, -3.23835045e-01f,
  -1.61141366e-01f, 1.22485101e-01f, -6.57560453e-02f, -1.89860255e-01f, 3.48825119e-02f, -8.68582502e-02f, 9.11923945e-02f, -1.29558206e-01f, -1.35631055e-01f, -1.85486153e-01f,
  -1.15626305e-01f, -1.75823852e-01f, 1.22548781e-01f, -3.06437820e-01f, -1.69930845e-01f, -3.82433802e-01f, 1.61253899e-01f, 6.52902350e-02f, -1.02042168e-01f, -2.70423740e-01f,
  1.63952932e-01f, -2.56936461e-01f, 1.44841284e-01f, -1.93831787e-01f, 2.49050185e-01f, -2.79375345e-01f, -2.74256855e-01f, -3.15621287e-01f, 1.83877751e-01f, 1.58924386e-01f,
  -3.38148206e-01f, 1.77184403e-01f, -8.23004171e-02f, -1.09740667e-01f, -1.74820468e-01f, 2.61901736e-01f, -5.20322382e-01f, 4.34857607e-02f, -3.08480620e-01f, 9.94354859e-02f,
  -1.42600045e-01f, 1.13651447e-01f, 1.03111453e-01f, 2.06076756e-01f, 1.44447386e-01f, 1.73748925e-01f, -2.03187764e-01f, -2.66087383e-01f, -4.43989396e-01f, 1.65158942e-01f,
  -3.69711667e-01f, 9.08555016e-02f, 2.99669772e-01f, -4.40444440e-01f, -4.20615710e-02f, 6.38237819e-02f, -1.87254980e-01f, -1.36345267e-01f, 6.18941672e-02f, -4.26690936e-01f,
  -1.77642450e-01f, 1.53391942e-01f, -9.25285220e-02f, 7.56280497e-02f, -4.24494110e-02f, 1.59406409e-01f, -1.83891475e-01f, 7.18439966e-02f, -2.41004720e-01f, -1.14217356e-01f,
  -5.57441339e-02f, 2.24366561e-01f, -2.33468309e-01f, -6.06073774e-02f, -1.21136576e-01f, 1.28252551e-01f, -2.63334304e-01f, 2.94425879e-02f, 1.47501081e-01f, 1.85938910e-01f,
  5.00980243e-02f, 1.09246105e-01f, -5.58837950e-02f, 3.43427882e-02f, 8.59798267e-02f, -4.32887584e-01f, -2.36751795e-01f, 1.55085951e-01f, -1.52856767e-01f, 9.07271206e-02f,
  2.06223443e-01f, 6.37416020e-02f, -4.30240035e-02f, 1.17699750e-01f, 9.28830877e-02f, -1.53503612e-01f, 1.66676208e-01f, -2.85363644e-01f, -3.52669418e-01f, -2.33781174e-01f,
  -1.22241832e-01f, -1.72364011e-01f, -3.00833285e-01f, -2.54588246e-01f, 1.86073616e-01f, -2.91331202e-01f, -2.42818519e-01f, -3.47207665e-01f, -3.68361503e-01f, -2.63868389e-03f,
  1.56919897e-01f, 3.82816344e-01f, -2.19616797e-02f, 1.05855584e-01f, -3.05380989e-02f, 1.87191129e-01f, -1.67655796e-01f, 1.24176435e-01f, 1.36558712e-01f, 2.31768891e-01f,
  -2.14944154e-01f, 2.57321060e-01f, -1.39167368e-01f, 2.03882799e-01f, -3.72175366e-01f, 1.02096483e-01f, -4.01267707e-01f, -2.66909927e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.57414596e-02f, -5.87724485e-02f, 1.88176613e-02f, -1.31621554e-01f, 9.52073932e-03f, 6.75406829e-02f, -1.88477159e-01f, 1.96039397e-02f, -2.66079791e-02f, -2.34539770e-02f,
  -9.62754339e-03f, 9.55852270e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    