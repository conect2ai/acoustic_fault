/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.95265090e-01f, -2.82357961e-01f, -1.62506044e-01f, -2.96941757e-01f, -1.63692772e-01f, 3.46235842e-01f, 1.56880632e-01f, -2.15611994e-01f, -2.00222522e-01f, 6.79887757e-02f,
  1.35417029e-01f, -3.27879786e-01f, 3.52029681e-01f, -2.18252718e-01f, 5.70008124e-04f, 3.09638321e-01f, -2.85917014e-01f, -5.06274514e-02f, -4.87072803e-02f, -2.97669113e-01f,
  -1.27771437e-01f, -8.16249996e-02f, -1.34069785e-01f, -9.61684622e-03f, -2.17848554e-01f, -1.13018252e-01f, -8.75832587e-02f, 1.78127199e-01f, -1.26362413e-01f, 2.82661077e-02f,
  3.68016027e-02f, -1.12106137e-01f, -4.55540530e-02f, 6.15130998e-02f, -5.43732122e-02f, 2.74000759e-03f, 5.64461052e-02f, 7.83191845e-02f, 5.07012531e-02f, 1.12142498e-02f,
  -5.91969816e-03f, 1.84629466e-02f, -7.67549872e-02f, 5.09401783e-02f, -7.97957852e-02f, -3.65894809e-02f, 4.00330871e-02f, -1.29135847e-02f, -3.04716956e-02f, -5.11119962e-02f,
  -2.55105272e-02f, 3.66115198e-02f, -9.99157503e-02f, 3.16671059e-02f, -6.75060451e-02f, -3.14177759e-02f, 3.89607660e-02f, 3.08147147e-02f, 5.67336492e-02f, -1.19857728e-01f,
  -4.52083200e-02f, 5.26141115e-02f, 2.72590443e-02f, 3.30987275e-02f, 2.86409091e-02f, -4.15222496e-02f, 4.11583222e-02f, -1.02775134e-02f, 4.52155769e-02f, -8.41669459e-03f,
  1.84725281e-02f, -9.89495590e-02f, 3.36887948e-02f, -1.52308540e-03f, -3.17861103e-02f, -2.18905397e-02f, 8.48754309e-03f, 5.53809516e-02f, -3.92468460e-02f, 5.63489608e-02f,
  -7.17489235e-03f, -1.42181094e-03f, 5.94153218e-02f, -1.25586772e-02f, 8.86292309e-02f, 3.62075982e-03f, -3.86713333e-02f, -5.10136858e-02f, 7.66785592e-02f, -3.41449529e-02f,
  9.18708816e-02f, -1.28493831e-01f, 2.08530968e-04f, 3.63800153e-02f, 4.36979160e-02f, -8.61458201e-03f, -3.07305735e-02f, -5.00916243e-02f, 1.30547341e-02f, 1.11571010e-02f,
  -6.83988929e-02f, 1.00138895e-02f, -8.48051254e-03f, 1.30674914e-02f, 5.09061385e-03f, -3.18010561e-02f, 1.41465683e-02f, -8.09083600e-03f, -1.09600082e-01f, 2.29446739e-02f,
  -6.22976338e-03f, 4.73571680e-02f, -2.66495254e-03f, -1.01614766e-01f, -3.82554135e-03f, -2.90850531e-02f, -8.91108587e-02f, -5.35330400e-02f, 4.15064469e-02f, 4.10383707e-03f,
  -1.88716471e-01f, 1.73342720e-01f, -1.15981579e-01f, -4.98891741e-01f, -1.77310541e-01f, 4.61076766e-01f, 3.40207629e-02f, 2.53361523e-01f, -2.72028536e-01f, 3.33393902e-01f,
  -4.66976538e-02f, 1.10359758e-01f, 1.86657995e-01f, -8.55369195e-02f, -3.45079720e-01f, -5.48576713e-02f, 1.62617043e-01f, 4.81358804e-02f, -1.60211548e-01f, 1.98831737e-01f,
  1.16935465e-02f, -1.22290969e-01f, -8.98488909e-02f, 1.23104453e-01f, 7.98079073e-02f, -5.51957302e-02f, -2.67953455e-01f, -2.03343242e-01f, -7.31848478e-02f, -2.08914474e-01f,
  1.47284105e-01f, -1.65749699e-01f, 5.96848503e-02f, 9.13384743e-03f, 4.61020097e-02f, 1.15085401e-01f, -2.64528617e-02f, -1.88770458e-01f, -1.56176507e-01f, 1.37840444e-02f,
  4.38777208e-02f, -2.05403287e-02f, 9.35854018e-03f, -1.48789003e-01f, -3.48435156e-02f, 1.83479884e-03f, -5.18843047e-02f, 7.29426742e-02f, -3.80151346e-02f, -1.08349044e-02f,
  5.38364165e-02f, 7.99968243e-02f, 7.84809887e-03f, -7.02096801e-03f, -6.91232532e-02f, -7.46003464e-02f, -5.81289968e-03f, -1.24999635e-01f, -1.96410157e-02f, -1.33575797e-01f,
  2.87480596e-02f, -4.35806662e-02f, 1.48444483e-02f, -7.98940212e-02f, -8.48751441e-02f, -4.56947833e-02f, -2.55613886e-02f, 8.98038894e-02f, -7.81269670e-02f, 4.80748564e-02f,
  -9.25823748e-02f, -7.61831030e-02f, 3.19120847e-02f, -4.35789227e-02f, -2.64440998e-02f, 1.41208787e-02f, -2.20642723e-02f, -5.80835603e-02f, 1.23953573e-01f, 5.47952056e-02f,
  2.29444839e-02f, -9.10498500e-02f, 6.21334352e-02f, 7.31955990e-02f, 1.91539880e-02f, -1.10991217e-01f, -2.51538828e-02f, 3.18760239e-02f, 8.39300603e-02f, -6.77735638e-03f,
  -2.59232987e-03f, -8.63905400e-02f, 7.46940449e-02f, 9.73566930e-05f, -2.61780899e-03f, 1.50290564e-01f, -3.57894450e-02f, 8.62627998e-02f, -1.81603521e-01f, 5.49880676e-02f,
  5.85580133e-02f, -4.18732427e-02f, 4.76891398e-02f, 2.81279851e-02f, 1.72830354e-02f, 1.07555073e-02f, -1.10697456e-01f, -5.13014756e-02f, -9.34820548e-02f, 1.24508247e-01f,
  6.48215637e-02f, 3.48602654e-03f, 5.30463643e-02f, 6.28959909e-02f, 1.28843099e-01f, 6.59563616e-02f, 1.10438410e-02f, 4.96509671e-02f, 4.04351810e-03f, -1.01418737e-02f,
  3.39004993e-01f, -1.10127158e-01f, 3.48854363e-01f, 1.93259299e-01f, -8.26294161e-03f, -2.51357108e-01f, -9.16228220e-02f, -1.25719113e-02f, 3.04568589e-01f, -3.18389952e-01f,
  -2.43429556e-01f, 2.88775682e-01f, -1.38351455e-01f, -1.61366433e-01f, 2.81446695e-01f, -1.17486827e-01f, -5.40959425e-02f, -6.17482029e-02f, 4.22697216e-02f, -1.04899846e-01f,
  1.20280519e-01f, -3.58547807e-01f, 1.46831749e-02f, -2.89299071e-01f, -5.23876622e-02f, 1.64287761e-01f, -8.11404064e-02f, -4.02301066e-02f, -1.93410471e-01f, -4.05091196e-02f,
  -3.66227403e-02f, -5.97766740e-03f, 2.16680542e-02f, 1.40171379e-01f, -2.47659814e-02f, -5.19121476e-02f, -2.19640434e-02f, -2.38143392e-02f, 8.50147307e-02f, 2.55442895e-02f,
  5.62038720e-02f, 2.27177069e-02f, 4.78300489e-02f, -2.29351525e-03f, -3.08018760e-04f, 1.12369396e-01f, 5.76091371e-02f, 2.68890671e-02f, -7.58539420e-03f, 4.07833420e-02f,
  2.58980095e-02f, 3.44135538e-02f, 5.11025749e-02f, -8.70715454e-03f, 1.35874763e-01f, 3.12763490e-02f, 6.14112504e-02f, 9.12353173e-02f, -1.01203276e-02f, 5.76050133e-02f,
  -5.76566644e-02f, -3.81840989e-02f, -4.10665832e-02f, 1.96435619e-02f, -4.40973938e-02f, 6.80769503e-04f, -5.33019751e-03f, -5.55658899e-02f, 6.01836964e-02f, -3.90446782e-02f,
  3.81007269e-02f, 5.99995330e-02f, 1.84189118e-02f, 2.91838516e-02f, -5.62914647e-02f, 3.96282114e-02f, 4.07690220e-02f, -1.26932878e-02f, 2.07268391e-02f, 1.65627934e-02f,
  -1.03498213e-02f, -2.22099852e-02f, -5.89865595e-02f, -6.67201867e-03f, -1.96101796e-02f, 3.57925557e-02f, -1.90535802e-02f, 4.98877428e-02f, 3.16709615e-02f, -5.66275045e-03f,
  -5.20453043e-02f, -3.21837097e-01f, 5.13142422e-02f, -2.23979540e-03f, -2.84126331e-03f, -4.84370179e-02f, -1.84662000e-03f, 2.27943175e-02f, -3.52509394e-02f, -1.19040072e-01f,
  -2.19143741e-03f, 2.86198426e-02f, -4.25873883e-02f, 3.78152616e-02f, 5.37129231e-02f, -4.71561104e-02f, -8.87880325e-02f, 1.65437106e-02f, -4.59142141e-02f, -7.26459473e-02f,
  -4.78951409e-02f, -1.95519626e-03f, 1.10923068e-03f, -8.06592591e-03f, -5.00697233e-02f, -3.03270016e-03f, -1.46745266e-02f, 1.36525035e-02f, -3.69072780e-02f, -4.14696187e-02f,
  -2.26060882e-01f, 2.11662516e-01f, 4.21257496e-01f, 5.23872487e-02f, -1.93204701e-01f, -3.63702208e-01f, -1.48909658e-01f, 3.76843810e-02f, 1.19423144e-01f, -1.60514377e-02f,
  -1.28380090e-01f, 3.23443532e-01f, 4.78311852e-02f, -7.37610459e-02f, -3.05798233e-01f, -7.71942586e-02f, -1.82556719e-01f, -7.98579380e-02f, 1.09246142e-01f, 6.51251003e-02f,
  1.02910604e-02f, -8.79816040e-02f, 9.45453718e-02f, 1.27800688e-01f, 3.02159600e-02f, 2.00723216e-01f, -1.96279407e-01f, 1.27625108e-01f, -1.09108813e-01f, -9.07814875e-02f,
  -1.85679555e-01f, 1.54147744e-01f, 1.22753575e-01f, 1.41282729e-03f, -1.89259514e-01f, -3.25442199e-03f, 3.41897160e-02f, -1.55939953e-02f, -1.74515992e-02f, -3.80215123e-02f,
  -6.90362453e-02f, -2.04342161e-03f, 8.31682011e-02f, 4.91462648e-02f, 1.86546221e-02f, 4.69663404e-02f, 3.15204635e-02f, -1.43355522e-02f, 2.82458179e-02f, -5.25259562e-02f,
  5.93262538e-02f, 5.08262515e-02f, -2.20665708e-03f, -8.63085836e-02f, 1.21626183e-01f, 4.36852463e-02f, -1.20704146e-02f, -2.23968104e-02f, -1.18811391e-01f, -7.71600530e-02f,
  9.07076672e-02f, 1.40299052e-02f, 1.17270350e-02f, -2.51852907e-02f, 4.96118218e-02f, -3.14902142e-02f, -3.46240662e-02f, -1.23528399e-01f, -1.08146928e-02f, -9.20408890e-02f,
  -7.95531645e-02f, -3.50673236e-02f, 1.60373580e-02f, -3.16449031e-02f, -3.44254524e-02f, -5.53129055e-02f, 5.02953567e-02f, -2.70058997e-02f, -6.50401264e-02f, -5.37015796e-02f,
  8.56021419e-02f, -2.90016513e-02f, -1.30704166e-02f, -1.60713986e-01f, -3.93390981e-03f, -4.08915766e-02f, 5.44090830e-02f, 1.33420024e-02f, 4.34334762e-02f, -9.24867466e-02f,
  -3.02018136e-01f, 2.10383549e-01f, -5.10317786e-03f, -4.53128032e-02f, 3.54679897e-02f, -8.57419893e-02f, 8.65694880e-02f, 1.53749203e-02f, 8.35443556e-04f, 8.50993395e-03f,
  7.59496214e-03f, -5.05908579e-02f, -3.92033197e-02f, -8.52889270e-02f, 5.96566498e-02f, -1.92188695e-02f, -3.79499011e-02f, -5.68083897e-02f, -9.13627967e-02f, 5.54120727e-02f,
  5.21681309e-02f, -5.58241419e-02f, 1.27441376e-01f, 4.15154286e-02f, -8.87453482e-02f, -1.55043602e-02f, -1.77495424e-02f, 6.68970793e-02f, -3.51490937e-02f, 3.07383779e-02f,
  -1.93212524e-01f, 5.48935831e-02f, 1.59354299e-01f, 3.72379929e-01f, -2.25847170e-01f, 1.51590094e-01f, 2.09955662e-01f, -1.49078751e-02f, -1.20366298e-01f, 8.24261829e-02f,
  1.71092991e-03f, -8.88644978e-02f, -1.17974833e-01f, 2.77668029e-01f, 1.10652439e-01f, 9.80125964e-02f, 2.19322816e-01f, 4.98229079e-02f, -2.01911703e-01f, 9.66166183e-02f,
  2.15618238e-02f, 7.79616535e-02f, 2.70452648e-01f, -1.56090453e-01f, 5.46228215e-02f, 6.95401877e-02f, 1.57667935e-01f, -1.16077222e-01f, 3.43790680e-01f, -1.64743021e-01f,
  -6.48676753e-02f, -1.29136354e-01f, 5.91224283e-02f, 1.51819708e-02f, 8.29999596e-02f, 1.32621095e-01f, 2.82634925e-02f, 5.09491377e-02f, -1.86773594e-02f, -5.66291139e-02f,
  -5.69527447e-02f, -5.40753976e-02f, -1.40450239e-01f, -8.45578685e-02f, -7.10014775e-02f, 1.45368353e-02f, -1.19274594e-02f, 1.90280735e-01f, -5.34116700e-02f, 6.85275998e-03f,
  1.08187936e-01f, 4.41590175e-02f, 5.80151118e-02f, -1.14445481e-02f, 2.82418132e-02f, 3.53215188e-02f, 7.86895305e-02f, 4.01102938e-02f, 2.04759371e-03f, -6.82983994e-02f,
  -1.03718713e-01f, -2.87530944e-02f, 9.54647362e-03f, -3.73952799e-02f, 1.44748604e-02f, 1.33257568e-01f, -6.10474572e-02f, 5.02031557e-02f, -7.92263355e-03f, 4.01610062e-02f,
  6.41473085e-02f, -3.49436812e-02f, 8.56211856e-02f, 3.82674672e-02f, 1.89714711e-02f, 8.64341483e-02f, -1.30309174e-02f, -1.74688250e-02f, -2.65268553e-02f, 5.83984740e-02f,
  1.56607181e-02f, 1.70063321e-02f, 2.18694136e-02f, -7.50903860e-02f, 1.20850854e-01f, -1.18362404e-01f, -7.46839792e-02f, -4.91947755e-02f, 8.47444609e-02f, -5.34535497e-02f,
  1.02883555e-01f, 7.55188018e-02f, -9.59516466e-02f, -1.10674098e-01f, 8.70505348e-02f, -3.00576799e-02f, 6.25243932e-02f, -6.87196255e-02f, -2.81751482e-03f, -7.28592873e-02f,
  6.44614920e-02f, 2.36481279e-02f, 5.80895804e-02f, -5.31955846e-02f, 8.46260116e-02f, -4.65455726e-02f, 9.81748328e-02f, 1.83718465e-02f, 1.43255189e-01f, -7.31817959e-03f,
  5.93810976e-02f, -1.08499050e-01f, 8.58067498e-02f, -1.06487356e-01f, 3.47340554e-02f, -5.09274192e-02f, -7.43969679e-02f, -5.61007066e-03f, 9.27946810e-03f, 3.65744419e-02f,
  -2.24106863e-01f, 2.83155173e-01f, 1.20153382e-01f, 7.27277175e-02f, 1.80166066e-01f, -1.45109922e-01f, -1.83763340e-01f, 2.66479403e-01f, -1.78767174e-01f, 2.99385220e-01f,
  1.49932494e-02f, -3.25591058e-01f, -1.08453691e-01f, -1.12303779e-01f, -5.17475426e-01f, -3.67131650e-01f, -1.96257636e-01f, -2.01477155e-01f, -1.94501176e-01f, 1.08500138e-01f,
  -5.13096675e-02f, -4.49487474e-03f, 1.67384461e-01f, 2.42782533e-01f, 2.65417516e-01f, 1.29245803e-01f, 1.72519892e-01f, 1.00098543e-01f, 1.95873871e-01f, -1.31105721e-01f,
  3.78451906e-02f, 9.63646639e-03f, 9.77947563e-02f, 5.35652265e-02f, 7.77713880e-02f, 4.86466587e-02f, 6.50708154e-02f, -9.69895199e-02f, -5.25255278e-02f, 1.22713652e-02f,
  -3.69671620e-02f, -7.13369176e-02f, -1.03519917e-01f, -2.38270331e-02f, 3.77120078e-02f, -2.06514318e-02f, 8.95342082e-02f, 1.53258368e-01f, 3.13676125e-03f, -3.36627476e-02f,
  -1.80539414e-02f, -8.02357495e-03f, -4.38911095e-02f, -6.44581467e-02f, 1.67666972e-02f, -1.10074237e-01f, -1.94052365e-02f, 2.98886523e-02f, -7.63328280e-04f, -1.44800276e-01f,
  2.87178457e-02f, -8.88049975e-02f, 4.11774591e-02f, -1.25516551e-02f, -7.04039931e-02f, 6.30755350e-02f, -4.50524092e-02f, -4.51477803e-02f, -5.51993698e-02f, -2.19716355e-02f,
  6.09942824e-02f, -1.67737156e-02f, -5.15786838e-03f, 8.68600681e-02f, 2.92695872e-03f, 1.88440885e-02f, 3.90552394e-02f, -4.07068096e-02f, 2.50756908e-02f, 1.12005115e-01f,
  -2.52450220e-02f, 1.02020958e-02f, 3.88974845e-02f, 7.08725629e-03f, -9.87663940e-02f, -4.01170775e-02f, 4.78637405e-02f, 9.86466482e-02f, 1.90095771e-02f, -3.55299190e-02f,
  9.58946347e-03f, 1.07964745e-03f, -2.41516922e-02f, -5.42977042e-02f, -7.08147809e-02f, 5.71968257e-02f, -5.87696731e-02f, 4.78954390e-02f, -1.25638880e-02f, -7.47561678e-02f,
  1.00907527e-01f, 1.40114948e-01f, -1.32355548e-03f, -5.12594432e-02f, 1.95171591e-02f, -5.17572239e-02f, -1.98168792e-02f, -2.91952398e-02f, 2.85492036e-02f, 4.76349369e-02f,
  1.27292618e-01f, -6.75951224e-03f, -5.33485077e-02f, 6.24684840e-02f, 8.69063009e-03f, -2.17961203e-02f, -3.08143999e-02f, 2.70739533e-02f, -4.50343825e-02f, -4.62130923e-03f,
  -5.27954936e-01f, 7.90924653e-02f, -1.79172680e-01f, -3.05837601e-01f, -2.37506013e-02f, -1.53926015e-01f, -1.86003953e-01f, 1.22123919e-01f, -1.93449520e-02f, 1.83898732e-01f,
  2.33033285e-01f, -2.70546287e-01f, 3.92037481e-01f, -1.79642603e-01f, -3.56972396e-01f, 2.46158093e-01f, -2.19647288e-01f, -1.06575482e-01f, 9.22553539e-02f, -9.96563770e-03f,
  -6.19272962e-02f, 1.79091357e-02f, 8.41105502e-05f, 1.14826255e-01f, -2.87970513e-01f, -1.02230951e-01f, 6.41614571e-02f, 1.18426383e-01f, -3.29537213e-01f, -1.51819557e-01f,
  -8.61508772e-02f, 5.42001128e-02f, -7.06344321e-02f, 6.07244037e-02f, -1.05927795e-01f, 4.21670005e-02f, -7.50088170e-02f, -6.54214621e-02f, -3.99730168e-02f, -1.46549856e-02f,
  -4.97205593e-02f, 1.04593700e-02f, -8.79728347e-02f, 7.83839151e-02f, -5.38614951e-02f, -1.06533468e-02f, -2.51395702e-02f, -7.92780668e-02f, 2.04946175e-02f, -4.63455692e-02f,
  -5.95970042e-02f, 4.15888760e-04f, -6.54341057e-02f, -6.44036382e-02f, -1.49314970e-01f, 3.53992917e-02f, -3.88220698e-02f, -9.74014997e-02f, -8.52892399e-02f, -1.70631513e-01f,
  -1.59370583e-02f, 2.73125954e-02f, 2.03445507e-03f, -2.34089103e-02f, 3.00991461e-02f, -2.25495063e-02f, 3.40023711e-02f, 2.89742146e-02f, -6.12518787e-02f, -7.52495276e-03f,
  -8.56309570e-03f, 5.00127953e-03f, 2.88092829e-02f, -1.18153067e-02f, 2.55904738e-02f, -8.33520107e-03f, -2.93655973e-02f, -2.60611065e-02f, -3.92298698e-02f, -3.73602919e-02f,
  6.23943433e-02f, -2.73002572e-02f, 4.32268381e-02f, -6.07556896e-03f, 2.80906400e-03f, 2.87733506e-02f, 4.41163480e-02f, -3.98430191e-02f, 3.97074930e-02f, -5.27078360e-02f,
  1.09149471e-01f, 1.01742633e-02f, 7.13748485e-02f, 2.21974384e-02f, 2.54210215e-02f, 4.77440935e-03f, 4.63364497e-02f, -7.41099417e-02f, 2.17538979e-02f, 7.23414822e-03f,
  1.91444047e-02f, 4.99933679e-03f, -1.04954224e-02f, -8.55328515e-02f, -1.32719930e-02f, -1.98253058e-02f, 6.47805855e-02f, 1.11905588e-02f, -2.89458148e-02f, 3.51452455e-02f,
  4.99715991e-02f, -2.85721403e-02f, -5.70034236e-03f, -1.37420408e-02f, 2.80530751e-02f, -7.76735470e-02f, -7.67902359e-02f, 1.47701446e-02f, -3.78745161e-02f, 4.56890091e-02f,
  -2.98478246e-01f, -1.85887307e-01f, 3.10631543e-01f, 2.82217115e-02f, -2.17180729e-01f, -4.16172296e-01f, -1.26531050e-01f, -1.27720967e-01f, -1.62867829e-01f, -8.42332989e-02f,
  5.03998622e-02f, 8.15812200e-02f, 9.61196348e-02f, -4.89782654e-02f, -1.15982600e-01f, 2.21648231e-01f, -1.67677015e-01f, -5.30614108e-02f, 4.69540665e-03f, -1.68026954e-01f,
  5.82446158e-03f, -3.19790393e-01f, 2.78227478e-01f, -1.86590850e-01f, -1.15528949e-01f, 6.53720945e-02f, -1.52771734e-03f, 6.44714162e-02f, -9.32514295e-02f, 4.97279428e-02f,
  -1.45062596e-01f, -1.91466603e-02f, 4.47951145e-02f, 2.51075663e-02f, -4.20141891e-02f, 4.90681455e-02f, 8.52644145e-02f, 9.28556100e-02f, 1.21513620e-01f, -2.98598385e-03f,
  -8.35333299e-03f, -3.66882868e-02f, 2.83736028e-02f, 3.50231826e-02f, -8.47847164e-02f, 4.37843502e-02f, 4.27688472e-02f, 6.65543452e-02f, -1.51286777e-02f, 9.08786952e-02f,
  8.10660124e-02f, 7.18388557e-02f, -4.98935990e-02f, 2.59103738e-02f, 1.16726244e-02f, -1.35406423e-02f, 9.49907750e-02f, 1.52058369e-02f, -3.51835378e-02f, -1.05251044e-01f,
  -2.23041093e-03f, -3.10574956e-02f, 4.17739414e-02f, -1.82598568e-02f, -4.93470803e-02f, -8.40162393e-03f, 3.45376357e-02f, 1.97724700e-02f, -3.63862254e-02f, -4.96994779e-02f,
  -4.52687405e-02f, -1.15389898e-02f, -1.22521734e-02f, -2.42386460e-02f, 2.38317694e-03f, -3.59144583e-02f, 2.64596101e-02f, -6.55390620e-02f, -3.25706191e-02f, 3.04751638e-02f,
  6.86501339e-02f, -5.98605536e-02f, 4.67800163e-03f, 1.33551965e-02f, -2.51968354e-02f, 3.42461169e-02f, -4.51509748e-03f, 4.71094660e-02f, 3.37714776e-02f, -4.67631184e-02f,
  -2.77245432e-01f, -2.76973128e-01f, 1.17661105e-02f, -8.67542997e-02f, -4.16806825e-02f, -5.35294786e-02f, -2.96119191e-02f, 3.20415162e-02f, -8.93648490e-02f, -8.22814852e-02f,
  -3.68157141e-02f, 1.14084175e-03f, -4.26838584e-02f, 2.19633952e-02f, -5.20152114e-02f, -3.87253724e-02f, -1.45146763e-02f, -3.86006720e-02f, -9.87574607e-02f, -8.55733529e-02f,
  -4.02016304e-02f, -1.87135749e-02f, 7.57040009e-02f, -3.63747403e-02f, 3.93688418e-02f, -8.89936276e-03f, -1.25670478e-01f, 8.14925507e-02f, 6.23202287e-02f, -4.88119246e-03f,
  -2.48573739e-02f, -2.59450376e-01f, -3.37871141e-03f, 1.47601888e-01f, -1.68827564e-01f, -3.18772979e-02f, 1.10257015e-01f, -1.52596414e-01f, -4.60749924e-01f, 9.49690416e-02f,
  -6.22044355e-02f, 3.19343626e-01f, -7.12768957e-02f, 1.75573990e-01f, 3.30381125e-01f, -3.75965267e-01f, 4.95653190e-02f, 1.43118516e-01f, -3.43164712e-01f, 2.11053222e-01f,
  -3.97531427e-02f, 2.60953724e-01f, 1.71693698e-01f, 9.97535512e-02f, 4.08513509e-02f, -2.47417577e-02f, 2.54231989e-01f, -5.04755825e-02f, 3.18551987e-01f, -5.40128574e-02f,
  -4.67471294e-02f, -8.81443322e-02f, 1.27194822e-02f, -9.41077769e-02f, 2.75808759e-02f, 1.81399528e-02f, 8.04154947e-02f, 6.30859807e-02f, 6.74401131e-03f, -2.55347472e-02f,
  4.24229577e-02f, 1.11168467e-01f, 6.98217331e-03f, 2.92995423e-02f, -9.24950466e-02f, -3.88860479e-02f, -2.23450400e-02f, -3.63822728e-02f, -2.77505117e-03f, -1.52107440e-02f,
  -5.98948598e-02f, -7.34763499e-03f, -4.64312732e-02f, 3.67392488e-02f, -1.74689554e-02f, -9.54637975e-02f, -3.23499292e-02f, 7.03641623e-02f, -1.06081225e-01f, 3.17980768e-03f,
  -1.62410154e-03f, -6.13637529e-02f, 1.24150084e-03f, 2.67619509e-02f, -5.33847604e-04f, -1.01005428e-01f, 1.10807838e-02f, 5.20420121e-03f, -7.16056526e-02f, 1.69198178e-02f,
  3.91446520e-03f, 1.32405059e-02f, -1.58224106e-01f, 1.60679743e-02f, 7.51953423e-02f, 3.34608592e-02f, 5.77466004e-02f, 4.21171710e-02f, -5.42377168e-03f, 4.11636941e-02f,
  -8.12478587e-02f, -6.52580336e-02f, -1.35062514e-02f, 7.40852132e-02f, -9.78642628e-02f, 3.89346294e-02f, 4.30080779e-02f, -5.91416424e-03f, -3.92202698e-02f, 4.04495336e-02f,
  -2.64652576e-02f, -4.94360328e-02f, -3.39802802e-02f, 7.08605871e-02f, -7.27162734e-02f, 5.42486608e-02f, -8.79450366e-02f, -2.66643167e-02f, 1.56786107e-02f, 7.60954292e-03f,
  1.19996339e-01f, 5.60894422e-02f, -7.74344243e-03f, -1.39021156e-02f, 5.15715517e-02f, 5.91332577e-02f, 2.08913852e-02f, -4.27748896e-02f, 5.06000780e-02f, 5.55166900e-02f,
  1.24887060e-02f, 8.43488351e-02f, 3.17914300e-02f, -1.51669448e-02f, 6.92356005e-02f, 5.65274060e-02f, 2.24152524e-02f, 9.40322503e-03f, 2.50163283e-02f, -6.48588547e-03f,
  -1.15297586e-01f, 7.92601630e-02f, 3.26720595e-01f, 6.99370876e-02f, -3.69818717e-01f, -9.71185789e-03f, -6.35441244e-02f, -7.07677156e-02f, 3.28936934e-01f, 3.59302424e-02f,
  -1.19605914e-01f, 5.69339693e-02f, 3.14886943e-02f, 1.02675699e-01f, 3.23450267e-01f, 3.73201758e-01f, 3.00783843e-01f, 1.81363672e-01f, 1.79027513e-01f, -3.35472785e-02f,
  1.57368496e-01f, -2.50373095e-01f, 1.76536739e-01f, -2.30815396e-01f, -4.56422925e-01f, -6.24453537e-02f, -2.96457022e-01f, -9.62999463e-02f, -1.95318699e-01f, -1.12825803e-01f,
  1.15470760e-01f, -1.74831916e-02f, 3.21976549e-04f, 1.55497774e-01f, -7.79654309e-02f, -1.22876309e-01f, 1.04994774e-02f, -1.10802934e-01f, 5.35528362e-02f, 7.44941011e-02f,
  -1.25437856e-01f, -1.22987414e-02f, 9.29980800e-02f, -7.29076117e-02f, -9.75902751e-02f, 7.07576126e-02f, 8.07981566e-03f, -3.84525545e-02f, 2.75520403e-02f, 3.07504311e-02f,
  1.02812029e-01f, 7.67194256e-02f, 2.40094587e-02f, 7.17547070e-03f, 5.65684447e-03f, 5.71295433e-02f, 6.65200949e-02f, -9.57938433e-02f, -2.87842527e-02f, 4.99478318e-02f,
  -1.87744617e-01f, 5.57585899e-03f, -5.20067699e-02f, 5.87245151e-02f, -5.75353317e-02f, -8.50388501e-03f, 5.62654510e-02f, -1.02864236e-01f, -2.25427840e-02f, -3.33549008e-02f,
  4.94622020e-03f, 3.86571921e-02f, -6.69975504e-02f, 6.26558885e-02f, -7.76065961e-02f, 5.18282540e-02f, 6.79477677e-02f, -7.29399398e-02f, 9.17166620e-02f, -1.37358289e-02f,
  3.31648774e-02f, 7.00300559e-02f, 2.61591356e-02f, -7.88488016e-02f, 3.24969366e-02f, 2.42099389e-02f, -8.90541747e-02f, 8.67713243e-02f, 3.49353044e-03f, -1.26749426e-01f,
  2.47800052e-02f, -4.26796600e-02f, -3.08963645e-04f, 3.69797796e-02f, 1.63900509e-01f, -6.87344745e-03f, 7.58228153e-02f, -3.63461748e-02f, 4.48944904e-02f, 4.87628840e-02f,
  9.17754788e-03f, -4.23970632e-02f, -3.89036275e-02f, -8.84229131e-03f, 1.35345347e-02f, -1.26072941e-02f, 3.81402187e-02f, 4.09457982e-02f, -1.47035956e-01f, 1.12857262e-03f,
  -1.43890247e-01f, -9.37176123e-02f, 1.49140665e-02f, -6.82842955e-02f, -6.68639541e-02f, 1.94422938e-02f, -5.95338270e-02f, 5.47385514e-02f, -2.06830483e-02f, 8.42027962e-02f,
  -1.42279230e-02f, -1.28951699e-01f, 1.26168430e-01f, 2.30776489e-01f, 2.24901468e-01f, 8.37079585e-02f, 1.09215826e-01f, 1.36572629e-01f, -2.56461322e-01f, -9.38559398e-02f,
  3.05682868e-01f, -3.49078715e-01f, -8.45023897e-03f, 2.43806645e-01f, 3.13794017e-01f, 6.10539317e-02f, 2.48627767e-01f, 2.22711042e-02f, -1.66053891e-01f, 1.14495061e-01f,
  1.33769855e-01f, 1.45534217e-01f, 2.47105151e-01f, 7.99490288e-02f, 1.13855071e-01f, -1.25992149e-01f, 1.71798676e-01f, -4.45214240e-03f, 1.86526775e-01f, 7.50506520e-02f,
  6.13979772e-02f, 1.45749040e-02f, 5.29168844e-02f, -4.77000549e-02f, 1.45202756e-01f, -6.60818368e-02f, 4.42137234e-02f, 7.06686871e-03f, -3.21272090e-02f, -3.61597277e-02f,
  -7.86916241e-02f, -7.40658119e-03f, 6.14958163e-03f, -1.00376899e-03f, -3.70768569e-02f, 2.32103709e-02f, -4.65984084e-02f, 7.50816166e-02f, -9.39276516e-02f, 4.54651155e-02f,
  -4.14194278e-02f, 5.18117547e-02f, 7.21672028e-02f, -2.95564644e-02f, 8.84636268e-02f, 1.68880001e-02f, -3.20964046e-02f, 2.82354653e-02f, -5.09500243e-02f, -1.82056688e-02f,
  3.66985723e-02f, -7.26936609e-02f, 2.11854419e-03f, -9.40455869e-03f, -2.30773650e-02f, 8.44185054e-02f, -1.12945745e-02f, 9.21673402e-02f, -7.23209232e-02f, 1.06146984e-01f,
  5.04048914e-02f, -1.74080227e-02f, 7.98740238e-02f, 7.91526679e-03f, 4.98851873e-02f, 2.15467978e-02f, 1.17670866e-02f, -1.21300370e-02f, 4.89228144e-02f, 7.66026378e-02f,
  3.56280766e-02f, 3.46260257e-02f, 1.88825093e-02f, 2.45894236e-03f, 2.75267083e-02f, -2.13108789e-02f, -6.64204285e-02f, 6.50323033e-02f, 4.16950136e-03f, 1.46383569e-02f,
  4.91738245e-02f, -1.13091126e-01f, 1.22872964e-02f, -1.40640829e-02f, -2.79999580e-02f, 6.77800626e-02f, -2.83815246e-03f, 6.41877130e-02f, -1.20067708e-02f, 2.05475446e-02f,
  7.34565258e-02f, -2.60681678e-02f, 2.33611967e-02f, -4.13508043e-02f, 1.74344108e-02f, 4.57011834e-02f, 7.18930438e-02f, -7.33840242e-02f, 4.39620614e-02f, 6.28411621e-02f,
  5.10816984e-02f, -3.32947597e-02f, 7.76806520e-03f, 1.70311462e-02f, -3.06171854e-03f, 3.01678292e-03f, 1.35466261e-02f, -9.91963819e-02f, 1.01128429e-01f, -2.00491045e-02f,
  -1.42311146e-02f, -1.76653355e-01f, -9.86247808e-02f, 2.46107176e-01f, -1.37619421e-01f, -3.92224966e-03f, 3.36049162e-02f, -5.74218109e-02f, -2.03397602e-01f, 6.39856905e-02f,
  1.52291149e-01f, -5.82236163e-02f, -1.49100661e-01f, 2.81570852e-01f, 2.75817901e-01f, -2.86613125e-02f, 1.85760543e-01f, 5.39881960e-02f, -2.23522052e-01f, 1.75483711e-02f,
  1.20797895e-01f, 2.47035742e-01f, 8.51278976e-02f, 5.76252602e-02f, 6.02205768e-02f, -3.71943787e-02f, 2.56249189e-01f, 1.40549485e-02f, 3.11816126e-01f, 6.34476468e-02f,
  4.11581621e-02f, 4.33935523e-02f, -4.68640327e-02f, -4.16582301e-02f, 1.04736947e-01f, -3.50006483e-02f, 4.94541712e-02f, 8.54020864e-02f, -3.36292237e-02f, -6.74400851e-02f,
  -5.23261093e-02f, -7.80944386e-03f, 9.77494121e-02f, -8.64564255e-02f, -1.66697770e-01f, -6.47806153e-02f, -5.40887602e-02f, -8.10507908e-02f, -9.39784106e-03f, -1.15652882e-01f,
  -7.52026215e-02f, 7.63380760e-03f, 6.99320342e-03f, 4.66370285e-02f, -3.07245757e-02f, 5.54678664e-02f, -5.18047996e-02f, -2.06369087e-02f, 5.15123866e-02f, -6.46387860e-02f,
  -1.01154968e-02f, -4.61072624e-02f, 9.20102093e-03f, 3.00402325e-02f, 1.25344291e-01f, 1.01484537e-01f, 6.39437651e-03f, 4.40173484e-02f, 7.44332969e-02f, 1.36915362e-03f,
  2.12588850e-02f, -5.66564016e-02f, 5.83789451e-03f, -9.58153009e-02f, 7.84228090e-03f, 4.49343435e-02f, 4.77632582e-02f, 4.98721423e-03f, -5.29958494e-02f, 4.13362235e-02f,
  7.50114992e-02f, -6.33229781e-03f, 2.46901973e-03f, -4.94078100e-02f, 1.60487171e-03f, 5.31308651e-02f, -6.98323473e-02f, -4.63052280e-02f, -8.51665437e-03f, 7.69184977e-02f,
  1.44040436e-01f, 2.45258912e-01f, -3.37738581e-02f, -1.10409316e-02f, 7.94346109e-02f, -4.06587422e-02f, 4.43791226e-03f, -2.89684851e-02f, 1.57736242e-01f, 8.12003296e-03f,
  -8.56146123e-03f, 6.03747834e-03f, -5.75188473e-02f, 3.31973098e-02f, -1.62510388e-02f, 2.01272164e-02f, 7.02527240e-02f, 2.26746444e-02f, 6.95961639e-02f, 7.50331879e-02f,
  4.67767529e-02f, 3.53659177e-03f, 2.54967790e-02f, 4.07556146e-02f, -2.75677294e-02f, 6.12982772e-02f, 2.56818309e-02f, -9.73847657e-02f, 3.36393006e-02f, 2.40201261e-02f,
  4.30585504e-01f, -1.85826302e-01f, 2.04861999e-01f, -3.87762487e-02f, 6.88393936e-02f, 2.85306107e-02f, -8.06251839e-02f, -1.08152233e-01f, -8.86618569e-02f, -2.61229903e-01f,
  -3.33525777e-01f, -6.87490925e-02f, -1.94391608e-01f, -2.68889993e-01f, 3.15990508e-01f, 4.64218222e-02f, -3.42984870e-02f, -6.79262727e-02f, 6.19565174e-02f, -1.85174644e-01f,
  1.62509084e-01f, -2.52943665e-01f, 1.34097353e-01f, -8.07425827e-02f, -1.24948233e-01f, 1.98841207e-02f, 5.91490306e-02f, -3.37048247e-02f, -1.77922055e-01f, -4.47169468e-02f,
  2.31550168e-02f, -6.21126331e-02f, 3.90734114e-02f, 3.52011658e-02f, 6.69715405e-02f, 3.65014710e-02f, 6.00973070e-02f, 9.32850242e-02f, 5.55517040e-02f, 4.90794592e-02f,
  4.47544642e-02f, 4.19514701e-02f, -5.85896745e-02f, -2.45185848e-02f, -9.28277001e-02f, 4.72139940e-02f, 8.34435448e-02f, -7.16823637e-02f, -9.42996815e-02f, -3.55952010e-02f,
  1.85300261e-02f, 6.16206005e-02f, -3.21190096e-02f, -3.89650464e-02f, 1.45113170e-02f, -2.03887355e-02f, -5.52352630e-02f, 5.46154082e-02f, -2.23103706e-02f, 3.22962413e-03f,
  -7.90740028e-02f, 2.24436779e-04f, 2.52546351e-02f, -4.42666672e-02f, -9.81168915e-03f, -6.26149029e-02f, -5.66669442e-02f, -3.95792499e-02f, 2.27672365e-02f, -2.44908910e-02f,
  -3.96780483e-02f, -2.49063000e-02f, -3.59315015e-02f, -4.36881185e-02f, 1.46520874e-02f, 1.82286035e-02f, 5.09652263e-03f, -2.74386462e-02f, 1.92956359e-03f, 5.95217850e-03f,
  -6.53273836e-02f, 4.11408246e-02f, -4.62308004e-02f, -1.39222713e-02f, 3.76359001e-02f, -1.07996091e-02f, -4.65626307e-02f, -3.30631025e-02f, -5.36781177e-02f, 1.14905294e-02f,
  -1.60314158e-01f, -1.73302352e-01f, -1.43469840e-01f, -1.00391701e-01f, -5.81246465e-02f, 1.12049013e-01f, 1.74088683e-02f, 1.31059519e-03f, -3.54388021e-02f, -2.03013923e-02f,
  4.64715846e-02f, -1.84177905e-02f, 3.54784764e-02f, 3.53869982e-02f, 6.15201816e-02f, -8.60541034e-03f, -2.81007849e-02f, 2.46960204e-02f, 4.99490686e-02f, -2.94151739e-03f,
  -3.00893821e-02f, -1.93411633e-02f, 8.76376852e-02f, 1.91298854e-02f, -3.42628695e-02f, 4.00046632e-02f, -6.96564605e-03f, -1.29156234e-02f, 9.41282138e-02f, -1.96576454e-02f,
  -4.75618243e-02f, 2.70370036e-01f, -1.63213387e-01f, -2.82058954e-01f, -1.89171657e-01f, 2.36357346e-01f, 3.81615549e-01f, -1.24535888e-01f, -1.82079777e-01f, 4.05816138e-01f,
  4.74240296e-02f, 1.83759909e-02f, 2.58229554e-01f, -1.52875125e-01f, -2.78554201e-01f, -4.89349850e-02f, -4.65519167e-02f, 2.14580685e-01f, -1.48935795e-01f, -2.73861457e-02f,
  -1.76237494e-01f, -2.01757818e-01f, -1.77752838e-01f, -2.37333570e-02f, -5.46226911e-02f, -1.20996341e-01f, -9.88613144e-02f, 3.01503576e-02f, 3.43007147e-02f, -2.35825181e-02f,
  3.18433009e-02f, -2.73906090e-03f, -9.62531846e-03f, -5.39937196e-03f, -1.40749877e-02f, 1.23034060e-01f, 7.17322389e-03f, 3.20803821e-02f, -1.11794248e-01f, -3.32743786e-02f,
  9.41199511e-02f, -7.89959133e-02f, 2.60631982e-02f, -3.94314937e-02f, 3.17850290e-03f, 4.23298945e-04f, -5.99852167e-02f, 4.26106267e-02f, -2.90006176e-02f, 5.71598709e-02f,
  4.07452919e-02f, -2.95764375e-02f, -3.43791768e-02f, -3.51046631e-03f, -2.84512751e-02f, -2.14631110e-02f, 6.91546798e-02f, 4.59977146e-03f, 6.90170079e-02f, -4.48633581e-02f,
  7.53950551e-02f, -8.49640579e-04f, -4.36873026e-02f, 7.82064628e-03f, -2.79270690e-02f, 4.32018749e-02f, 1.23397317e-02f, -1.88419945e-03f, -7.49685094e-02f, 5.38508147e-02f,
  5.25245024e-03f, -3.43829617e-02f, -4.07381393e-02f, -1.18486071e-03f, -3.92169412e-03f, -1.70023516e-02f, 4.40564491e-02f, 2.58931797e-02f, -3.01146880e-03f, -7.23619014e-02f,
  -6.60876632e-02f, -7.02375621e-02f, 6.43766439e-03f, 4.33793850e-02f, 3.35780904e-02f, -4.13029902e-02f, -3.55283543e-02f, 5.02526984e-02f, -5.56508861e-02f, 1.63286831e-02f,
  8.28452110e-02f, 8.57547447e-02f, 5.66237047e-03f, 9.90408566e-03f, 2.91960570e-03f, -9.32604447e-03f, 9.95163247e-03f, -2.28862353e-02f, 1.39346374e-02f, 1.68858971e-02f,
  -2.56566796e-02f, 1.44793019e-02f, 3.66626941e-02f, -6.28994629e-02f, -5.73041737e-02f, 2.09812354e-02f, 1.05558895e-01f, -4.62761782e-02f, -4.27299924e-02f, -1.34344690e-03f,
  -3.13449316e-02f, 4.67717871e-02f, -3.00778244e-02f, 4.11104523e-02f, 3.53879780e-02f, 6.38825893e-02f, -9.31241550e-03f, 3.76715958e-02f, 1.66441035e-02f, 1.76255684e-02f,
  -5.95921159e-01f, 2.68169791e-01f, -2.79241264e-01f, -4.07357037e-01f, 1.48001209e-01f, -3.44183356e-01f, -7.89958984e-02f, 2.99331900e-02f, -1.94795907e-01f, 4.32568848e-01f,
  1.20976791e-01f, -2.59131312e-01f, 1.63617164e-01f, -1.63864017e-01f, -2.31285021e-01f, -4.27480750e-02f, -2.55682111e-01f, -5.45447953e-02f, -5.38173839e-02f, -2.89898738e-02f,
  -1.55107185e-01f, 1.69281766e-01f, -2.66857315e-02f, 2.56369203e-01f, 3.10457107e-02f, -2.71058716e-02f, 3.03193182e-01f, 1.60486102e-02f, -3.02519929e-02f, 2.44727731e-03f,
  1.34917013e-02f, 1.08241439e-01f, 9.34130251e-02f, 7.10916799e-03f, 7.89231528e-03f, 6.61890134e-02f, -3.31514440e-02f, -4.18643616e-02f, -5.01347892e-02f, -1.21619133e-02f,
  -1.65892057e-02f, 7.02439714e-03f, -4.51637171e-02f, -2.32477281e-02f, 3.48701328e-02f, -6.51229993e-02f, -5.74054569e-02f, 7.97312427e-03f, -3.45176607e-02f, -7.20025748e-02f,
  -7.08468780e-02f, -7.28016868e-02f, -7.69738331e-02f, -7.19947321e-03f, -1.00510284e-01f, -6.88318834e-02f, -9.90231857e-02f, -5.61739355e-02f, -1.37245124e-02f, 9.63570271e-03f,
  6.16072640e-02f, 3.17014903e-02f, 1.94804333e-02f, 7.25223636e-03f, -6.22733980e-02f, 1.15246121e-02f, 1.18283937e-02f, 4.88740392e-02f, -1.25127301e-01f, -2.72254758e-02f,
  -6.27418384e-02f, -3.57491635e-02f, 9.52563994e-03f, -2.21207850e-02f, -2.50074882e-02f, 1.02168433e-02f, -4.93466854e-02f, -2.87650339e-02f, -6.31400347e-02f, -3.05869319e-02f,
  5.83011396e-02f, 9.88863781e-03f, -1.01765748e-02f, 2.49031745e-02f, 3.73286530e-02f, -2.59304345e-02f, 3.20175057e-03f, -6.06733896e-02f, -5.00255302e-02f, -6.98548406e-02f,
  5.48229478e-02f, 5.83267733e-02f, -1.94163993e-02f, -4.03982587e-02f, -2.36317273e-02f, -1.94935370e-02f, -9.43614617e-02f, 2.49362271e-03f, -9.50483046e-03f, 3.42506394e-02f,
  1.34562198e-02f, 1.77567080e-02f, 3.94973159e-02f, -1.07926518e-01f, -6.28459379e-02f, 1.23931818e-01f, 6.65798783e-03f, 1.31470226e-02f, 2.41607092e-02f, 2.34240666e-02f,
  6.05752282e-02f, -2.80196648e-02f, -1.72637701e-02f, 5.89661263e-02f, 2.46167905e-03f, 3.33417915e-02f, -3.16401124e-02f, 3.86377843e-03f, -4.79883961e-02f, 1.68345310e-02f,
  -4.12766665e-01f, 4.34389174e-01f, -1.90507293e-01f, -9.97119769e-02f, -1.19404644e-01f, -3.19242507e-01f, -3.79596680e-01f, -4.83266637e-02f, -3.27645615e-02f, 2.83107400e-01f,
  1.20892935e-01f, 1.98752403e-01f, 1.38892412e-01f, -6.02753311e-02f, -3.61230910e-01f, 1.82087589e-02f, -1.86081544e-01f, -4.59959917e-02f, 2.83900881e-04f, 1.12698503e-01f,
  5.04405936e-03f, 6.24235310e-02f, -1.74124971e-01f, 1.80957034e-01f, -9.57036093e-02f, 1.26157925e-01f, 1.17986776e-01f, -3.35661992e-02f, 5.20565324e-02f, -4.98350449e-02f,
  -1.73427016e-01f, 1.49297118e-01f, -7.51976436e-03f, 1.62670370e-02f, -4.30645496e-02f, -5.68935089e-02f, -2.93082502e-02f, -8.52409601e-02f, -9.21197832e-02f, 5.18941097e-02f,
  1.36461006e-02f, -4.97666262e-02f, 6.16631806e-02f, -3.81412543e-02f, 8.02549627e-03f, 5.58428373e-03f, -1.10317077e-02f, -8.56567100e-02f, 5.28425947e-02f, 1.73492059e-02f,
  -1.41930077e-02f, -6.50544390e-02f, -5.90545833e-02f, 1.05145559e-01f, -7.62872249e-02f, 4.60470729e-02f, -1.09447524e-01f, -5.06274663e-02f, 5.63160516e-02f, 3.64900418e-02f,
  4.44624089e-02f, 7.47586265e-02f, -4.28561904e-02f, -5.05285524e-02f, 3.86148840e-02f, -3.80223878e-02f, 5.79844043e-02f, 4.01530564e-02f, 2.36503892e-02f, 8.54074433e-02f,
  -1.33729493e-02f, 4.11233418e-02f, 4.61175926e-02f, -7.03156665e-02f, -2.58412156e-02f, 3.85136418e-02f, -3.43725197e-02f, 8.48887488e-02f, -1.68636665e-02f, -1.14210591e-01f,
  3.25624682e-02f, 5.48921786e-02f, -3.02007142e-03f, -2.88812723e-02f, 3.57433967e-02f, -6.48660632e-03f, 1.07757077e-01f, 5.10325320e-02f, -1.82379894e-02f, -8.26853216e-02f,
  7.16971010e-02f, 3.46510917e-01f, 7.97173288e-03f, 8.93533826e-02f, 8.35472867e-02f, 7.28472620e-02f, -6.53228834e-02f, 4.89321016e-02f, 7.25539178e-02f, 1.64529514e-02f,
  5.39337471e-02f, -5.15575195e-03f, -2.15216409e-02f, 4.82443757e-02f, -5.55600971e-02f, -1.13458782e-02f, 1.13427464e-03f, 9.38105509e-02f, -1.08995382e-02f, 7.62358308e-02f,
  6.80385903e-03f, 1.01769365e-01f, 1.13986125e-02f, -5.76970614e-02f, 9.32257622e-02f, 2.72123311e-02f, 3.23072225e-02f, -3.58042642e-02f, 5.52299246e-02f, 5.23213036e-02f,
  -6.35097921e-01f, 1.60511121e-01f, -1.76263496e-01f, -3.35339874e-01f, 1.17373288e-01f, 2.89512306e-01f, 5.32505400e-02f, -2.74391007e-02f, -3.35425645e-01f, 3.26088279e-01f,
  1.53064355e-01f, -1.97818428e-01f, 4.20195200e-02f, 1.66889891e-01f, -3.54652315e-01f, 9.81094465e-02f, -1.80970252e-01f, 6.44581392e-02f, -7.19357878e-02f, -1.08847119e-01f,
  -2.21280128e-01f, 2.19861045e-01f, -9.04758424e-02f, 2.19794229e-01f, -2.84888558e-02f, -1.09399952e-01f, -7.80687854e-02f, 9.81406420e-02f, 1.83425784e-01f, 9.28344131e-02f,
  1.33575186e-01f, 4.32295650e-02f, 5.07718287e-02f, 4.24283855e-02f, -2.56701820e-02f, -1.17715672e-02f, 8.17117020e-02f, 7.00773075e-02f, -5.02222218e-02f, -2.10922826e-02f,
  -7.73692410e-03f, 2.21512839e-02f, 1.82215106e-02f, -2.35489663e-02f, -1.01624485e-02f, 2.39736997e-02f, -9.71739739e-03f, -1.61039773e-02f, 2.69384924e-02f, -2.83744261e-02f,
  -7.10124522e-02f, -6.15468482e-03f, -7.06705917e-03f, 3.08297388e-02f, -5.82682230e-02f, -4.93531600e-02f, 4.04572152e-02f, 1.14047970e-03f, -7.94044510e-03f, -1.08164668e-01f,
  -5.62396310e-02f, -2.40168944e-02f, -1.55043984e-02f, 4.82633524e-02f, -1.60569474e-02f, -1.42044323e-02f, -4.16168943e-02f, 7.62697086e-02f, -8.51942226e-02f, 2.31830049e-02f,
  -6.87810332e-02f, -3.41634755e-03f, 5.55156358e-02f, -2.80904546e-02f, -2.10776739e-02f, -2.33652219e-02f, 2.19025854e-02f, 2.54405495e-02f, -8.80284980e-02f, -4.57358323e-02f,
  1.14079844e-02f, -1.80538930e-02f, -9.65720695e-03f, 1.80401169e-02f, 5.70001788e-02f, -9.19329282e-03f, -1.05426051e-02f, -5.79059161e-02f, -4.01417306e-03f, -5.29047288e-02f,
  -6.60724984e-03f, -8.32092017e-02f, -2.86286175e-02f, 5.55912405e-02f, 1.60324909e-02f, 5.15147261e-02f, -3.31334695e-02f, -6.82300553e-02f, -2.15499680e-02f, -1.95510816e-02f,
  -2.11792793e-02f, -5.12526482e-02f, 2.37546880e-02f, 1.06071029e-02f, 3.53182550e-03f, -1.15191974e-02f, -7.29975328e-02f, -6.48471415e-02f, -5.23539856e-02f, 6.23374525e-03f,
  7.78723275e-03f, -1.53289391e-02f, 8.60268064e-03f, 4.44499329e-02f, 2.93964855e-02f, -2.28357431e-03f, -4.41554524e-02f, 1.25816157e-02f, -1.36133647e-02f, -5.56780025e-02f,
  3.22630972e-01f, -2.65900671e-01f, -1.84730783e-01f, 9.91167501e-02f, 2.47522265e-01f, 6.16699494e-02f, -1.54784217e-01f, 1.61664248e-01f, 2.13155779e-03f, -2.47912556e-01f,
  1.50116652e-01f, -2.23123699e-01f, -1.90555543e-01f, 1.04037814e-01f, 3.71054739e-01f, 1.20482616e-01f, 9.63413119e-02f, -3.43947858e-02f, 2.58572996e-01f, 2.18772471e-01f,
  1.42654240e-01f, 4.09883380e-01f, 2.07372457e-01f, 2.05228537e-01f, 1.49664238e-01f, -2.17393022e-02f, 9.82730985e-02f, -6.32605627e-02f, 8.01426247e-02f, 1.49535447e-01f,
  -6.06040135e-02f, 1.37695381e-02f, 8.41099173e-02f, -1.66629687e-01f, -2.71858536e-02f, -1.52267978e-01f, -8.92551169e-02f, 1.67537592e-02f, -6.04334695e-04f, 1.60756297e-02f,
  -7.60914981e-02f, 6.03872575e-02f, 7.01522306e-02f, -8.92649125e-03f, 4.89898846e-02f, 9.18688029e-02f, 4.25049663e-02f, -3.77057232e-02f, -7.41569474e-02f, -3.27579379e-02f,
  4.46879528e-02f, -6.08469993e-02f, 4.74331416e-02f, 4.12878208e-02f, 6.81409687e-02f, 4.91959527e-02f, -9.18558389e-02f, -1.44790053e-01f, 3.46706063e-02f, 7.80290887e-02f,
  -8.42653215e-03f, -1.33975789e-01f, 2.52015516e-02f, -5.33296019e-02f, -1.64536219e-02f, 8.32161084e-02f, 2.97183320e-02f, 3.45539041e-02f, -6.51375875e-02f, -2.66054105e-02f,
  -1.97666902e-02f, -4.32306267e-02f, 4.85326797e-02f, -1.18009560e-02f, 1.00734467e-02f, -6.90063611e-02f, -5.02915084e-02f, 7.18246354e-03f, -2.03694627e-02f, -4.41383920e-04f,
  3.94106768e-02f, 1.02908924e-01f, -5.00723757e-02f, -5.99201284e-02f, -2.09291279e-02f, 2.41474062e-02f, -3.04380786e-02f, -8.05952102e-02f, 6.22540787e-02f, -4.23365459e-03f,
  -7.49616846e-02f, -2.86410619e-02f, 1.48214549e-02f, -3.20127197e-02f, -2.73836330e-02f, 7.11919442e-02f, 6.61738450e-03f, 7.06262961e-02f, 7.76751200e-03f, 5.89344166e-02f,
  7.06932619e-02f, -1.39793754e-01f, -3.86055894e-02f, 6.59555122e-02f, 1.81736685e-02f, -5.01573011e-02f, -7.71273449e-02f, -2.10013222e-02f, 6.18271157e-03f, 7.66572282e-02f,
  -2.22329665e-02f, 7.27879480e-02f, 8.77245441e-02f, 1.69899732e-01f, 1.80915818e-02f, -6.07880317e-02f, 7.10953260e-03f, -1.37140891e-02f, 9.66991410e-02f, 2.60012294e-03f,
  9.54408646e-02f, -7.34699517e-02f, -4.87170778e-02f, -2.26045892e-01f, 7.05099776e-02f, 3.41732979e-01f, 2.20116794e-01f, 7.38248676e-02f, -2.33675316e-01f, -9.51212049e-02f,
  9.67470407e-02f, -9.31607485e-02f, 9.42806154e-02f, 2.28659749e-01f, 3.68055403e-01f, 1.77367106e-01f, 2.09003419e-01f, 7.31744170e-02f, -5.42831756e-02f, -2.70444602e-02f,
  -2.04011705e-02f, 2.46031255e-01f, 1.49357989e-01f, 3.63139261e-04f, 2.24122748e-01f, -1.56796589e-01f, -2.55391121e-01f, -6.99241757e-02f, 6.58367723e-02f, 1.81291565e-01f,
  1.24841198e-01f, -1.31105185e-01f, 1.05418302e-02f, 3.44870170e-03f, -6.33349176e-03f, -2.77666785e-02f, 3.67693487e-03f, 6.00566082e-02f, -2.73082275e-02f, 1.76211968e-02f,
  -3.52179855e-02f, 1.27807716e-02f, -2.41807513e-02f, -3.54386307e-02f, -5.22578321e-02f, -2.95569468e-02f, 7.71576585e-03f, 1.59969144e-02f, -4.48512547e-02f, 1.35849535e-01f,
  6.98032081e-02f, -6.35776520e-02f, -9.55981901e-04f, -8.51876065e-02f, -1.98630057e-02f, -3.20313461e-02f, -5.63954785e-02f, 5.17364144e-02f, -1.69335976e-02f, -6.58060610e-02f,
  1.06241889e-02f, -7.12286448e-03f, 6.38288632e-02f, 1.49399862e-02f, 3.59466039e-02f, -5.97298630e-02f, 1.64334197e-02f, 1.66057062e-03f, -6.93516135e-02f, 4.76643816e-02f,
  -7.00202771e-03f, 1.16655156e-02f, 4.61102054e-02f, 3.91589291e-02f, 2.96511650e-02f, -3.15860435e-02f, 3.85531150e-02f, -3.91029455e-02f, -5.95175810e-02f, 3.16677205e-02f,
  -5.63560240e-02f, -1.43418303e-02f, 1.96649171e-02f, -3.78031544e-02f, 2.46899407e-02f, -1.89553052e-02f, -5.13609536e-02f, 1.10145718e-01f, -7.62273595e-02f, 4.93475050e-02f,
  2.89801043e-02f, -1.19991221e-01f, -2.79794615e-02f, -3.69899049e-02f, -8.61734226e-02f, 8.12318921e-02f, 4.54270989e-02f, -3.82352737e-03f, 2.78607998e-02f, 1.35079529e-02f,
  -1.75426900e-02f, -2.51092073e-02f, 3.26174498e-02f, 3.06423958e-02f, -7.57274553e-02f, 2.98827644e-02f, -6.79445416e-02f, -5.93666062e-02f, -2.62209587e-02f, -5.69067635e-02f,
  -5.85617758e-02f, -8.67655035e-03f, -4.77009751e-02f, 7.84128383e-02f, -5.38746268e-02f, -8.28606561e-02f, 7.51744211e-02f, -4.00404967e-02f, 3.22528817e-02f, -6.12791739e-02f,
  9.61227864e-02f, 2.61922687e-01f, 3.59536529e-01f, 2.98879087e-01f, -1.61535189e-01f, -2.64427036e-01f, 4.99253683e-02f, 7.41049647e-02f, 3.47399920e-01f, 6.97041452e-02f,
  -2.55608290e-01f, 2.28171334e-01f, 3.15478854e-02f, -1.29398242e-01f, -2.36283228e-01f, -1.12059236e-01f, -2.46681436e-03f, 8.46514180e-02f, 6.76549003e-02f, 2.51782238e-01f,
  4.39185761e-02f, -2.12938115e-01f, -9.74513292e-02f, -1.24187432e-01f, 3.20671536e-02f, 2.39867255e-01f, -1.61249921e-01f, 5.37200011e-02f, -9.42718983e-02f, -1.18797936e-01f,
  -1.09237723e-01f, 1.53929234e-01f, 6.30951747e-02f, -9.21263453e-03f, -1.08140565e-01f, -2.69126222e-02f, 2.74742837e-03f, -8.15672521e-03f, -6.93660676e-02f, 1.90571044e-02f,
  4.54735085e-02f, -2.07239166e-02f, 8.80674198e-02f, -1.13450974e-01f, 5.72428741e-02f, -4.45248596e-02f, -3.61370519e-02f, -3.76966856e-02f, 8.00420493e-02f, 3.82997259e-03f,
  2.01635193e-02f, 5.60130551e-03f, 3.94117050e-02f, 9.53472629e-02f, 1.04272431e-02f, 2.40772422e-02f, -1.65940374e-02f, 6.21459559e-02f, 2.49317605e-02f, 4.58392613e-02f,
  -1.53497830e-02f, 6.99365586e-02f, 6.43644631e-02f, -6.48177266e-02f, 4.22722101e-02f, -1.55693680e-01f, -5.27944192e-02f, -1.16585247e-01f, 1.17349671e-02f, -1.33523539e-01f,
  -1.86443364e-03f, 1.54525200e-02f, 2.28542485e-03f, -7.41588175e-02f, -3.52647193e-02f, -2.41533611e-02f, 8.42430536e-03f, 5.43246530e-02f, 1.20172337e-01f, -5.28242290e-02f,
  4.00788849e-03f, -2.98849810e-02f, -1.96955181e-04f, -1.13207800e-02f, -6.84133219e-03f, -3.90230259e-03f, -5.13343886e-02f, -5.27745187e-02f, -5.62286936e-02f, 1.80609804e-02f,
  4.20943201e-02f, 2.49851748e-01f, 9.91772488e-02f, -9.50085465e-03f, 7.21194670e-02f, 2.98285596e-02f, -1.13249689e-01f, 3.24921720e-02f, 1.15990425e-02f, 3.78334224e-02f,
  3.09777279e-05f, -8.73249955e-03f, -1.58646388e-03f, -7.34472368e-03f, 1.33064017e-02f, 6.66675791e-02f, 6.56329468e-02f, -6.04102667e-03f, 7.33212903e-02f, -5.95476292e-02f,
  8.56435895e-02f, 1.27545120e-02f, 1.39508676e-02f, -3.19031291e-02f, 8.97603706e-02f, -8.01661164e-02f, 7.74173439e-02f, 1.23581439e-02f, -1.16062380e-01f, 7.00179711e-02f,
  -1.60319328e-01f, -2.91961599e-02f, 2.84055203e-01f, -4.21935111e-01f, 1.38408035e-01f, 4.89154272e-02f, 1.19559586e-01f, -1.70672059e-01f, -9.32975188e-02f, -2.20536649e-01f,
  -9.25885737e-02f, -4.30064788e-03f, 3.63639235e-01f, -3.82759660e-01f, -3.39586437e-02f, 1.47761181e-01f, -3.11187387e-01f, -2.93872625e-01f, 6.97577149e-02f, -4.62666005e-02f,
  -1.55104533e-01f, -3.51862311e-01f, -1.72324888e-02f, -1.29725933e-02f, -7.46862069e-02f, 1.45253772e-02f, -1.76013127e-01f, 2.36776158e-01f, -1.88442901e-01f, 1.29742706e-02f,
  1.06999464e-03f, -1.36548683e-01f, 1.75344050e-02f, -8.36475343e-02f, 3.67092714e-02f, 6.97191292e-03f, -2.03622710e-02f, 8.85778666e-02f, 3.79155912e-02f, -1.00637635e-03f,
  5.25387116e-02f, -6.71039745e-02f, -9.46128070e-02f, -3.00783422e-02f, -7.91011974e-02f, 8.43435992e-04f, 3.10330000e-02f, 5.77439703e-02f, 3.19294184e-02f, -4.49221320e-02f,
  6.83049187e-02f, -1.08648594e-02f, -1.89151540e-02f, -8.12244862e-02f, 7.62653947e-02f, 1.28243174e-02f, -4.66877148e-02f, 1.01967841e-01f, -3.15486267e-02f, -8.06144178e-02f,
  -5.85749894e-02f, 7.23756431e-03f, 1.57869346e-02f, 2.15969179e-02f, 2.41123661e-02f, 2.79842429e-02f, 2.71997806e-02f, 2.95126885e-02f, 6.81243977e-03f, -2.15483550e-02f,
  -4.38903831e-02f, -5.41629903e-02f, -1.86383575e-02f, -4.61652428e-02f, -1.17818736e-01f, -5.49274534e-02f, 4.09735553e-02f, -9.42713767e-03f, 3.68310064e-02f, 2.02632323e-02f,
  -2.30601989e-02f, 9.79036908e-04f, -6.65588863e-03f, -1.38979265e-02f, -1.87944397e-02f, 6.29491881e-02f, -6.03395775e-02f, -1.20730023e-03f, 6.82834759e-02f, 4.53623533e-02f,
  -3.59194912e-02f, -1.97685733e-01f, 6.07717149e-02f, -2.40171738e-02f, 3.83859016e-02f, 7.44015211e-03f, -1.34905502e-02f, 1.03252055e-02f, -1.45483455e-02f, -8.61165300e-02f,
  -9.03185308e-02f, -3.26210782e-02f, 5.88027108e-03f, 7.12032290e-03f, 1.60801560e-02f, 2.09024381e-02f, -4.06645332e-03f, -1.31308185e-02f, -9.11680385e-02f, -5.38218245e-02f,
  -2.78452225e-02f, 4.62560244e-02f, 1.47860509e-03f, -2.09621042e-02f, -3.46616134e-02f, -3.09389438e-02f, 3.82399447e-02f, 3.01330769e-03f, 1.22740967e-02f, -3.18460427e-02f,
  3.18800628e-01f, -1.09749481e-01f, 3.24622899e-01f, 1.64663404e-01f, 2.01143578e-01f, -3.33904147e-01f, -2.14589015e-01f, 1.47403747e-01f, -6.89404830e-02f, -3.06995928e-01f,
  -1.04680106e-01f, 3.17365766e-01f, -1.71502948e-01f, -1.05797425e-02f, 7.32369348e-02f, -1.78465903e-01f, -2.38502696e-01f, -6.17579445e-02f, 1.00785717e-01f, -1.36902211e-02f,
  1.03688508e-01f, -2.26390779e-01f, 2.28190422e-01f, -1.27844468e-01f, 1.62599862e-01f, 1.57260224e-01f, -1.66267619e-01f, 8.92443657e-02f, -7.48763233e-02f, 8.95663574e-02f,
  7.16990680e-02f, -1.81250591e-02f, 1.61433920e-01f, -8.37242976e-03f, -9.97046158e-02f, 1.59432162e-02f, -9.85779613e-03f, -3.12447604e-02f, 1.04436770e-01f, 1.23021156e-02f,
  3.96883348e-03f, 1.30565464e-01f, 8.05458333e-03f, -9.71734002e-02f, 4.85282727e-02f, 1.85649265e-02f, 1.27380654e-01f, -4.85953726e-02f, 5.22440895e-02f, 1.69246152e-01f,
  9.64348316e-02f, 4.39070463e-02f, -3.09003741e-02f, -4.25262451e-02f, 1.53004885e-01f, 6.25710413e-02f, -1.50572613e-03f, 6.32292777e-02f, 3.25394571e-02f, -4.48052511e-02f,
  -4.33011465e-02f, -7.47252330e-02f, 4.15292270e-02f, 9.06078219e-02f, -1.46082342e-02f, 7.89694861e-02f, -3.50372158e-02f, 7.73200765e-02f, 2.65961196e-02f, -4.45149206e-02f,
  4.80656438e-02f, 1.25251442e-01f, -1.15696220e-02f, 2.64119823e-02f, -1.91789865e-02f, -1.24513926e-02f, 1.80611224e-03f, 2.34248843e-02f, -1.73171924e-04f, 9.80190113e-02f,
  3.39205959e-03f, -4.78882529e-02f, -7.14299902e-02f, -4.64126356e-02f, -5.33602200e-02f, -6.53507654e-03f, 2.13545300e-02f, 6.21707365e-02f, 1.65480748e-02f, 1.14509910e-02f,
  -3.86705756e-01f, -2.87756830e-01f, -1.18895317e-03f, 4.66617644e-02f, -4.71974760e-02f, 1.62772667e-02f, -1.62539613e-02f, 3.16854529e-02f, -6.10711761e-02f, -5.24664707e-02f,
  3.16208564e-02f, -5.03244950e-03f, -2.75981929e-02f, -3.17160487e-02f, -1.01203248e-01f, -4.79783639e-02f, -5.30920699e-02f, -6.19939752e-02f, -6.47484437e-02f, -6.87385947e-02f,
  -7.54631162e-02f, -4.02666368e-02f, 6.59883171e-02f, 1.96119677e-02f, 1.19408295e-02f, -3.59889343e-02f, -3.65083031e-02f, -5.84249943e-02f, -2.04380024e-02f, -4.76494581e-02f,
  -5.17311275e-01f, -1.20832309e-01f, 6.74938783e-02f, -1.09070159e-01f, -9.08171386e-02f, -3.61149728e-01f, -5.31582460e-02f, -1.62015125e-01f, -6.95123896e-02f, 1.08439423e-01f,
  3.94619629e-02f, -1.59270227e-01f, 3.30312401e-01f, -1.57145754e-01f, -4.16450808e-03f, 1.52602807e-01f, -1.88957587e-01f, -1.26021802e-01f, 5.84911890e-02f, -1.07388608e-01f,
  -8.43791068e-02f, -1.43957049e-01f, 1.82232842e-01f, -5.29854260e-02f, -1.81627795e-01f, -1.02163121e-01f, 2.79579222e-01f, 8.99013504e-02f, -1.52847067e-01f, 6.53591240e-03f,
  -8.58486816e-03f, 2.62686238e-03f, -1.03677018e-02f, -4.85756174e-02f, -2.47955117e-02f, -2.40375251e-02f, -3.36061120e-02f, 1.86777651e-01f, 4.05167155e-02f, 1.89639404e-02f,
  2.26207860e-02f, -1.19876547e-03f, -3.43877040e-02f, 7.33279735e-02f, -1.50277361e-01f, -4.79149520e-02f, -3.41461264e-02f, -3.01973633e-02f, 1.84599087e-02f, -6.34365454e-02f,
  -1.10405080e-01f, -2.84773391e-03f, -5.62309586e-02f, 3.20109800e-02f, 4.81751673e-02f, 3.17332819e-02f, 4.55257222e-02f, 5.92470691e-02f, 3.17247733e-02f, -3.02969757e-02f,
  2.28010193e-02f, 7.36343116e-02f, 4.22847345e-02f, 7.54660368e-02f, -9.49307755e-02f, 4.60740142e-02f, -2.81072799e-02f, 2.18517426e-02f, -8.06441009e-02f, -3.13475914e-02f,
  -1.63810868e-02f, -1.33540090e-02f, -8.35710987e-02f, -6.25605285e-02f, -5.96263483e-02f, -5.35563454e-02f, -9.95712169e-03f, 1.61936451e-02f, -4.44189832e-02f, -2.87765972e-02f,
  6.54671714e-02f, -4.73177172e-02f, 9.37777981e-02f, 4.57714647e-02f, -2.27453914e-02f, 1.75248422e-02f, -3.83752063e-02f, -1.00302078e-01f, 7.61510953e-02f, 5.52035160e-02f,
  4.88077551e-02f, 1.80194318e-01f, 8.24132562e-02f, 1.77675975e-03f, 5.99165037e-02f, -8.51456895e-02f, 6.01810822e-03f, -1.28069490e-01f, -1.67120453e-02f, -2.12137494e-02f,
  -6.32629320e-02f, 1.14711411e-02f, -6.88946694e-02f, 1.81172434e-02f, 7.05943108e-02f, -6.93860045e-03f, 7.32709914e-02f, -2.94501185e-02f, 5.40842377e-02f, 1.88390315e-02f,
  6.69740215e-02f, -5.21490350e-02f, -3.95166076e-04f, -1.41549818e-02f, -4.07214575e-02f, 4.34864946e-02f, -1.05561011e-01f, -5.39408810e-02f, 1.62875950e-02f, 4.77811955e-02f,
  -1.15717396e-01f, 8.47421587e-03f, -4.04978901e-01f, -1.30253568e-01f, 3.08298972e-02f, -2.59535462e-01f, -1.64962471e-01f, -6.92240000e-02f, 5.24086654e-02f, 2.98866808e-01f,
  1.93792596e-01f, 2.43970309e-03f, 3.31614166e-02f, 7.66400546e-02f, -9.13235471e-02f, -7.42881522e-02f, -1.59156278e-01f, 8.37463588e-02f, -9.80138779e-03f, -7.71476654e-04f,
  -1.71217248e-01f, 2.49549285e-01f, -2.16803178e-01f, 4.47128117e-02f, -2.00857610e-01f, -1.69260696e-01f, 1.75375640e-01f, -8.76398236e-02f, 4.73026969e-02f, 1.36320353e-01f,
  1.94497705e-02f, 7.98293054e-02f, -1.08817918e-02f, -1.05619468e-01f, -2.25347448e-02f, -8.00807402e-02f, -4.55754511e-02f, 4.52297879e-03f, -2.43565757e-02f, -9.26434621e-02f,
  -6.32679742e-03f, -7.14718774e-02f, 1.18413009e-02f, 2.24007089e-02f, -2.90876627e-02f, -5.10496385e-02f, -9.96970758e-02f, -6.44306615e-02f, -1.49459064e-01f, -1.54310271e-01f,
  -1.21497974e-01f, -1.77484810e-01f, -8.27398822e-02f, -3.38234417e-02f, -7.20510855e-02f, -5.54453880e-02f, -8.26249644e-02f, -3.92201059e-02f, -3.01291663e-02f, -1.02237500e-01f,
  1.76970158e-02f, 8.84928778e-02f, -1.03518158e-01f, 6.27783909e-02f, -1.29883569e-02f, -2.00595055e-02f, 4.48979251e-02f, 3.11791655e-02f, 1.15307588e-02f, 3.90111958e-03f,
  -1.54647371e-02f, 3.81217152e-02f, 2.27170382e-02f, 3.04751452e-02f, 3.28189954e-02f, 4.94420379e-02f, 3.41306254e-02f, -3.31150480e-02f, 1.46579300e-03f, 6.12913594e-02f,
  4.18963060e-02f, -1.10525265e-01f, 5.85585907e-02f, -2.94366572e-02f, 2.82140784e-02f, 6.59751594e-02f, -5.66951446e-02f, -1.08841322e-01f, -3.99522893e-02f, -3.42006460e-02f,
  1.70684099e-01f, 1.77926943e-01f, 1.14284530e-01f, 6.65189102e-02f, 8.07971433e-02f, 1.39255561e-02f, -7.37553388e-02f, 3.20003070e-02f, 3.34307663e-02f, 1.71858468e-03f,
  7.34137222e-02f, -8.41881242e-03f, 1.18249515e-02f, 3.85712236e-02f, 1.02503516e-01f, -1.96467489e-02f, -1.91600844e-02f, 1.63026154e-01f, 1.03782862e-01f, 1.94642171e-02f,
  5.51601723e-02f, 1.22491568e-02f, -1.55453142e-02f, 3.27046700e-02f, 7.40444064e-02f, 5.76139726e-02f, -4.55515236e-02f, 1.02966698e-03f, -3.63702364e-02f, -3.38798314e-02f,
  -4.63100910e-01f, 9.07151178e-02f, 1.81017965e-01f, 3.63531336e-02f, -7.01908246e-02f, 2.95917898e-01f, 1.07407399e-01f, 1.07144490e-01f, -7.04198107e-02f, 8.20499845e-03f,
  1.39141798e-01f, -4.70217243e-02f, 1.40755668e-01f, 2.89207816e-01f, 3.66429299e-01f, 2.83672392e-01f, 2.79361844e-01f, 7.45281652e-02f, -6.68918639e-02f, -5.86096421e-02f,
  4.84923925e-03f, 1.30149946e-01f, 2.20983371e-01f, -9.36966836e-02f, 4.29806374e-02f, -2.42422864e-01f, -8.01756699e-03f, -9.62942615e-02f, 1.17231652e-01f, 7.96940178e-02f,
  -2.21663658e-02f, -5.50972261e-02f, 4.70344611e-02f, 3.39143015e-02f, -4.19629849e-02f, -6.91142380e-02f, -1.53751135e-01f, 1.03107050e-01f, -2.80390438e-02f, 5.11432812e-02f,
  -3.35662328e-02f, -5.32790385e-02f, 4.21312414e-02f, 5.71786950e-04f, -9.25039276e-02f, 4.37688874e-03f, 1.43566236e-01f, 7.60246813e-02f, -1.87066495e-02f, 8.81576911e-02f,
  1.36679351e-01f, -3.84882987e-02f, 8.14944208e-02f, -9.63856815e-04f, -9.14792065e-03f, 1.67146511e-02f, 1.82555001e-02f, 3.29273753e-02f, -5.70232905e-02f, -3.59857758e-03f,
  -1.88943315e-02f, -9.80536938e-02f, 5.54419607e-02f, -2.49411073e-02f, 2.36941017e-02f, 1.81857403e-02f, -5.59501722e-03f, 4.29783762e-02f, -1.75005943e-01f, 2.19537336e-02f,
  1.89526137e-02f, 3.01746223e-02f, 2.13839784e-02f, -1.38567304e-02f, -1.07222797e-04f, -8.61681774e-02f, 8.05829931e-03f, -2.23694947e-02f, 2.51026750e-02f, 1.29456809e-02f,
  -1.82816368e-02f, 5.28200381e-02f, 1.03758806e-02f, -3.16029824e-02f, 5.95504269e-02f, 4.03822698e-02f, 3.69438753e-02f, 5.36342263e-02f, 1.95173007e-02f, 3.07976510e-02f,
  -4.97003533e-02f, -9.29056108e-02f, 4.80423197e-02f, -4.23676744e-02f, -1.35003552e-02f, 3.72143276e-02f, 9.99593213e-02f, 2.05728877e-03f, -2.56835669e-02f, -5.78276031e-02f,
  -4.87067327e-02f, 1.06355769e-03f, -1.06041253e-01f, -2.17598006e-02f, -4.56361426e-03f, 8.72908458e-02f, -9.12554488e-02f, -6.58258125e-02f, 4.10928391e-02f, -4.54666242e-02f,
  -9.47312638e-02f, -6.40951991e-02f, 4.97087836e-02f, -6.21386655e-02f, -2.09836997e-02f, -7.22961174e-03f, -1.98218618e-02f, -5.73973656e-02f, 5.26896939e-02f, 4.35550883e-02f,
  -4.36855704e-01f, 1.40411723e-02f, 1.98200688e-01f, -9.87415239e-02f, -4.21523243e-01f, 1.03260420e-01f, -2.87142336e-01f, -1.69955343e-01f, -1.76692173e-01f, -5.29561825e-02f,
  -2.04945281e-01f, 1.64093614e-01f, -1.53373778e-01f, 1.28403515e-01f, 3.04390609e-01f, 2.74077535e-01f, 1.42156675e-01f, -1.23701766e-02f, -2.38002632e-02f, -1.90544918e-01f,
  -6.24122769e-02f, -2.60043532e-01f, 2.02233195e-01f, -1.64536104e-01f, -1.87015161e-01f, 5.75310364e-02f, 6.05581142e-03f, -5.61215654e-02f, 1.70412004e-01f, -1.29918288e-02f,
  3.22946087e-02f, -5.02125919e-02f, 1.22214034e-01f, 1.51392356e-01f, 1.34593965e-02f, -2.71917786e-02f, -5.94711788e-02f, 2.49030385e-02f, 9.21787135e-03f, -6.52276352e-03f,
  -5.00347354e-02f, -1.26219476e-02f, 7.14728385e-02f, 2.40551145e-03f, -6.26890883e-02f, 3.26437466e-02f, 2.42108852e-01f, 1.21548168e-01f, -1.16959009e-02f, 1.63481608e-01f,
  2.17271641e-01f, 9.62577164e-02f, 8.70331470e-03f, 5.43979779e-02f, 1.34131297e-01f, 1.48976356e-01f, 1.36404335e-01f, 7.53458142e-02f, 6.49028271e-02f, 5.54899126e-02f,
  4.02584299e-02f, -1.17923036e-01f, -2.26818640e-02f, 1.38291633e-02f, -9.40362290e-02f, -9.40939710e-02f, 6.03113621e-02f, 8.56629852e-03f, -7.87353218e-02f, -3.05041987e-02f,
  -4.28750739e-02f, -2.12901086e-02f, 1.12120202e-02f, 5.99271655e-02f, -7.53953401e-03f, -3.82588096e-02f, 6.03016131e-02f, -5.25009707e-02f, -1.01558998e-01f, 4.79365811e-02f,
  -1.14096142e-01f, -5.77885844e-02f, -2.18745768e-02f, 5.02798483e-02f, 1.03910699e-01f, 3.87198967e-03f, -5.71535528e-02f, 1.02192806e-02f, 1.50184408e-02f, -8.92199874e-02f,
  -2.33860597e-01f, -1.53613478e-01f, -3.92959006e-02f, -1.17186680e-02f, 9.17025097e-03f, 3.33509035e-02f, 1.34798540e-02f, 8.68476257e-02f, -6.00146241e-02f, -4.75507341e-02f,
  6.17611967e-02f, -9.75450152e-04f, -1.14588991e-01f, -3.30557898e-02f, 1.38308108e-02f, 1.48625765e-02f, -3.86123285e-02f, -5.95635958e-02f, -9.25687626e-02f, -2.98515633e-02f,
  -4.42579538e-02f, -1.58578426e-01f, 4.04844955e-02f, -3.71778645e-02f, -7.65601844e-02f, -4.46820967e-02f, -1.37713879e-01f, 6.76613450e-02f, 3.06441709e-02f, 4.60877270e-02f,
  6.12763107e-01f, 7.42557123e-02f, 1.12129718e-01f, 3.97147477e-01f, 1.61681905e-01f, 4.45756838e-02f, 1.36788756e-01f, 1.64055288e-01f, 3.28628957e-01f, -5.29638268e-02f,
  -1.10493749e-01f, 2.29756147e-01f, -2.72491843e-01f, 2.81749666e-01f, 3.52186203e-01f, -3.14460546e-01f, 3.36744606e-01f, 1.57757774e-01f, 5.41105680e-02f, 3.02907318e-01f,
  1.78434387e-01f, 1.14179708e-01f, -6.40006363e-02f, 6.27649948e-02f, 1.24056734e-01f, 1.00140266e-01f, -2.42539555e-01f, -2.09412754e-01f, 3.01407967e-02f, 7.19417632e-03f,
  -2.17373706e-02f, 1.01457499e-01f, 3.05953063e-02f, 1.01710856e-02f, 4.27753404e-02f, 3.90550978e-02f, -7.47928545e-02f, -4.67260033e-02f, 3.71482000e-02f, 1.47191519e-02f,
  6.63751038e-04f, 8.11322108e-02f, 1.36323631e-01f, -3.28311287e-02f, 3.99325714e-02f, 1.27931416e-01f, 3.16383354e-02f, -4.05775160e-02f, 2.65846923e-02f, 1.03154266e-02f,
  1.31668337e-02f, -3.10991015e-02f, 4.22741510e-02f, -5.37448376e-02f, -2.71931961e-02f, 1.10062584e-01f, 4.19439897e-02f, -5.09315282e-02f, -6.59985794e-03f, 1.02808878e-01f,
  7.54843727e-02f, 5.32494672e-03f, -6.95494786e-02f, 3.86041659e-03f, 5.12757525e-02f, 1.72077201e-03f, -5.13121076e-02f, 3.50561216e-02f, 2.03577299e-02f, 2.39152387e-02f,
  4.01737131e-02f, 2.54220963e-02f, 1.44415759e-02f, 4.80927564e-02f, -3.64318700e-03f, 6.65229335e-02f, -3.76939550e-02f, -3.65025215e-02f, 3.18708755e-02f, -3.65754105e-02f,
  7.95575604e-03f, 9.96811539e-02f, -4.55583446e-02f, -1.93389542e-02f, 5.70310652e-02f, -1.00586414e-02f, -4.24660519e-02f, 9.17167403e-03f, 4.24087141e-03f, -4.60661352e-02f,
  6.80737244e-03f, 7.30180666e-02f, -3.27337496e-02f, 3.74458507e-02f, -7.08801150e-02f, 6.93449797e-03f, 7.35669360e-02f, 8.76268297e-02f, 7.44769117e-03f, 4.86950837e-02f,
  8.57473388e-02f, 1.02576502e-02f, -7.91490823e-02f, 1.91642661e-02f, 2.36969199e-02f, -3.78999487e-02f, -4.29507717e-03f, -5.05614690e-02f, 5.66560104e-02f, 7.21713481e-03f,
  1.29954536e-02f, 2.44813859e-02f, -1.01075310e-03f, 3.07591707e-02f, -2.70602014e-02f, -6.09596297e-02f, 4.81948331e-02f, 7.12804124e-02f, -4.08973657e-02f, 3.30974460e-02f,
  -2.79354423e-01f, 3.43000263e-01f, -3.46469879e-01f, -1.59572542e-01f, 6.02813736e-02f, 3.55436414e-01f, -1.37986049e-01f, 4.83955443e-02f, -1.88055530e-01f, 2.07968175e-01f,
  2.14086950e-01f, -1.22396894e-01f, -1.35539211e-02f, 3.27873707e-01f, 1.40829787e-01f, 1.17046975e-01f, 1.13262214e-01f, -7.68021494e-02f, 3.96399088e-02f, -1.35994598e-01f,
  8.85269791e-03f, 2.82110751e-01f, -9.12557170e-02f, 2.49010459e-01f, 1.84413157e-02f, -6.00041077e-02f, 7.84333423e-02f, -1.04651585e-01f, 2.13929966e-01f, 6.67587146e-02f,
  -7.47834072e-02f, -2.06478938e-01f, -1.94802761e-01f, -7.01334551e-02f, -2.48315614e-02f, -2.77148094e-02f, -2.15636939e-01f, -1.34084925e-01f, -8.67648050e-02f, 5.23122251e-02f,
  -5.26153743e-02f, 1.73198245e-02f, 5.44326454e-02f, -1.06214978e-01f, -7.83707500e-02f, -1.44713029e-01f, 8.45069215e-02f, 5.79159111e-02f, 6.08674483e-03f, 1.14070456e-02f,
  7.77904987e-02f, 1.49893805e-01f, -7.77925253e-02f, 2.81940270e-02f, -2.00529285e-02f, 3.86657827e-02f, 7.49520957e-03f, -5.83202094e-02f, 9.88964513e-02f, 6.30639195e-02f,
  4.28986875e-03f, 7.63248093e-03f, -4.65208180e-02f, -8.17285329e-02f, -5.35753630e-02f, 2.02938411e-02f, -1.69137307e-02f, -5.23670129e-02f, -6.97178245e-02f, 1.70751452e-03f,
  1.78432286e-01f, -3.87839936e-02f, -6.04864620e-02f, 1.21940440e-02f, -4.74058092e-02f, -4.26081829e-02f, 1.85439866e-02f, 3.39730829e-02f, 7.72771463e-02f, -3.80476168e-03f,
  -4.61881496e-02f, 4.49062213e-02f, 1.21967867e-02f, -6.58332780e-02f, -7.26371165e-03f, 2.57777586e-03f, -3.42586115e-02f, 4.63612489e-02f, -6.25149757e-02f, -1.71598967e-03f,
  3.90893668e-02f, -9.01958346e-02f, -9.94567201e-02f, -4.86265346e-02f, -5.49349859e-02f, 8.02437514e-02f, 6.89360721e-04f, 8.56133401e-02f, -6.80066496e-02f, -3.06006856e-02f,
  -9.65647623e-02f, -1.03007160e-01f, 1.29739970e-01f, 9.91207138e-02f, 3.53881977e-02f, 1.10586986e-01f, 2.03185398e-02f, -7.16059431e-02f, -6.27002567e-02f, -3.73133793e-02f,
  -4.46793884e-02f, 4.76131868e-03f, -4.98192534e-02f, -9.31732282e-02f, -5.01923151e-02f, 1.30571797e-02f, -1.43233702e-01f, 3.32466103e-02f, 5.18738590e-02f, 4.44785692e-04f,
  -4.37154442e-01f, 1.92699611e-01f, -3.12020808e-01f, -2.87347138e-02f, 1.03233783e-02f, -3.37579131e-01f, -4.39845100e-02f, 1.11230902e-01f, -6.88690022e-02f, 2.46007964e-01f,
  3.09554726e-01f, 1.42901197e-01f, 2.77370483e-01f, 3.48407060e-01f, 4.46516322e-03f, 1.26275808e-01f, 1.18004896e-01f, 2.02298798e-02f, -3.13188434e-02f, -7.29215369e-02f,
  -2.25329980e-01f, 3.01701725e-01f, 7.03781098e-02f, 2.12811679e-01f, 1.51628077e-01f, -9.76594165e-02f, 2.92538375e-01f, 1.23215273e-01f, 1.72791436e-01f, 1.63485855e-01f,
  -3.45231257e-02f, 5.25793172e-02f, -6.81806877e-02f, -6.13272153e-02f, -2.91768927e-02f, -1.32021353e-01f, -6.92498460e-02f, 8.97389427e-02f, 2.20690072e-02f, -3.03808879e-02f,
  6.72604740e-02f, 2.44871620e-02f, -3.90291065e-02f, -2.90552732e-02f, -7.16739893e-02f, -6.13909855e-04f, 2.54428871e-02f, -1.00576721e-01f, 7.60925859e-02f, -6.07837848e-02f,
  -3.01727839e-02f, -4.56254706e-02f, -7.76552483e-02f, -1.37596000e-02f, -2.04250589e-02f, 8.65448713e-02f, -4.82936315e-02f, 3.50508727e-02f, -1.23588905e-01f, -6.97415844e-02f,
  -2.39066482e-02f, -1.13492861e-01f, -4.77820775e-03f, -1.51210763e-02f, -2.53803246e-02f, 1.26922615e-02f, -5.39820828e-03f, 6.04992248e-02f, -1.55149102e-02f, 6.80829445e-03f,
  -2.36646291e-02f, -3.27536613e-02f, -1.26920762e-02f, -6.28429931e-03f, -6.52628317e-02f, 8.36102664e-03f, -9.19920728e-02f, 1.00463055e-01f, -1.13515332e-01f, 1.63834635e-02f,
  1.03708044e-01f, -3.24519128e-02f, -2.35700118e-03f, -6.16121851e-02f, -6.44303486e-02f, 1.65501088e-02f, 6.43834323e-02f, -4.48450074e-02f, 6.09765835e-02f, -2.67767124e-02f,
  1.40983030e-01f, 1.09325148e-01f, -1.22298189e-02f, -2.35116445e-02f, 2.58963369e-02f, -1.07697742e-02f, 4.93849814e-03f, -3.46514545e-02f, 5.77448420e-02f, -5.48950303e-03f,
  -5.74740283e-02f, -4.87019587e-03f, -6.16371185e-02f, 2.85926480e-02f, 1.75105557e-02f, 2.22202297e-02f, 2.34404020e-02f, 4.48438711e-02f, -2.89428737e-02f, 6.62655383e-02f,
  -1.65288057e-02f, 3.79538797e-02f, -4.27503092e-03f, 4.67021316e-02f, -3.45562175e-02f, -5.49360514e-02f, -8.35527852e-03f, -4.63612042e-02f, 6.01408519e-02f, -2.47882251e-02f,
  5.30957639e-01f, 2.35341445e-01f, 1.47568375e-01f, 1.11473173e-01f, 2.68715501e-01f, -2.14939147e-01f, -4.64531690e-01f, 1.74141586e-01f, 4.91151400e-02f, -1.18392542e-01f,
  8.48622527e-03f, -1.01476558e-01f, -1.55235857e-01f, 3.22363712e-02f, -2.57022709e-01f, -1.35255441e-01f, -8.78747925e-02f, -2.06617162e-01f, 5.27710393e-02f, 1.17010623e-01f,
  1.41232684e-01f, -1.13951921e-01f, 1.03723012e-01f, 1.27877727e-01f, 2.40551144e-01f, 8.89257565e-02f, -1.45390436e-01f, -1.64924189e-01f, -3.61813530e-02f, -2.21436232e-01f,
  9.66665819e-02f, 1.95266470e-01f, -1.41516663e-02f, -5.64263761e-02f, 7.63281882e-02f, -7.60423914e-02f, -7.74618760e-02f, -1.39014497e-01f, -1.23021435e-02f, -4.95294333e-02f,
  -5.10797650e-02f, 9.49510932e-02f, 6.79921657e-02f, -9.51673761e-02f, 5.42581938e-02f, 1.18777936e-03f, 5.81125990e-02f, 7.23833069e-02f, 1.24816298e-01f, 7.94605091e-02f,
  -1.07823899e-02f, 6.01225048e-02f, 6.32119775e-02f, 6.75362395e-03f, 6.32767379e-02f, 5.38849644e-02f, -4.61983420e-02f, -5.47014698e-02f, 6.21875003e-03f, 1.63294300e-02f,
  3.38869751e-03f, -2.44401190e-02f, -7.74225965e-02f, 9.55843627e-02f, -1.03746563e-01f, -2.24742647e-02f, -7.36008063e-02f, -3.97833884e-02f, -4.20338959e-02f, -6.15516631e-03f,
  9.71869379e-02f, 4.90754507e-02f, 5.98682016e-02f, 1.97550915e-02f, -8.51884205e-03f, -2.81752013e-02f, 4.84113656e-02f, 4.28734645e-02f, 8.03008899e-02f, 4.66884635e-02f,
  -7.58179650e-02f, 4.82977554e-02f, -8.20380077e-02f, -2.26992238e-02f, -3.26127633e-02f, -4.22569327e-02f, 7.16912970e-02f, 9.04757753e-02f, -3.29578929e-02f, -4.79541905e-02f,
  1.42073885e-01f, -1.05408831e-02f, -6.82090670e-02f, 6.54375628e-02f, -7.93836340e-02f, -7.81779960e-02f, -4.03559022e-02f, 1.44705221e-01f, -7.97544718e-02f, -5.08885421e-02f,
  8.96562561e-02f, -2.87952293e-02f, -1.29105318e-02f, 3.41108348e-03f, -6.25284836e-02f, 3.50037180e-02f, -6.71385452e-02f, -1.03656538e-01f, -4.42339927e-02f, 1.02278413e-02f,
  3.56929228e-02f, -4.15723287e-02f, -5.09049036e-02f, -3.81383933e-02f, -5.09328954e-02f, -1.16456725e-01f, -4.16557770e-03f, 3.14952247e-02f, -2.84940209e-02f, 4.51925434e-02f,
  2.41402924e-01f, -2.70927906e-01f, -2.14682072e-01f, -1.11347586e-01f, 2.81716794e-01f, 4.68592346e-01f, 2.28718683e-01f, 3.72151466e-04f, 1.58320442e-01f, -4.20216545e-02f,
  2.72419453e-01f, -1.34824574e-01f, 7.83455521e-02f, -1.04398921e-01f, 3.38020504e-01f, -7.67157823e-02f, 3.78924944e-02f, -6.85012853e-03f, -1.53432503e-01f, -9.96882841e-03f,
  -1.28235277e-02f, 1.81097731e-01f, -1.85401484e-01f, 1.72062255e-02f, 8.60634744e-02f, -1.59843445e-01f, -5.54133067e-03f, -4.55666110e-02f, -4.28297296e-02f, 1.00045599e-01f,
  1.44701093e-01f, -9.23887491e-02f, -3.12361475e-02f, 5.41706532e-02f, 1.55030042e-01f, 4.46757600e-02f, 1.22479079e-02f, 1.12587411e-03f, 5.11121489e-02f, 8.87416154e-02f,
  5.05015813e-02f, -1.31236045e-02f, -1.20550720e-02f, 6.16957918e-02f, 7.81925768e-02f, -7.44998315e-03f, -1.16897799e-01f, 3.48951221e-02f, -5.94065860e-02f, -7.18966052e-02f,
  -6.02891184e-02f, -7.44103938e-02f, -5.31301834e-02f, -7.65501782e-02f, -5.03020473e-02f, -1.39014255e-02f, -5.58384806e-02f, -6.90855365e-03f, 1.19101321e-02f, -1.44460956e-02f,
  2.89384704e-02f, -5.89653328e-02f, -3.18802297e-02f, -4.19400632e-02f, 5.26471399e-02f, -2.92173550e-02f, -4.60481085e-02f, -1.97492577e-02f, -1.03754006e-01f, 1.03148855e-01f,
  1.33042708e-02f, -3.60493176e-02f, 2.90902331e-02f, -3.90405941e-04f, -1.56944450e-02f, 3.56199667e-02f, -1.60927381e-02f, -1.83564809e-03f, -3.85481901e-02f, -5.08542592e-03f,
  -2.11054664e-02f, 7.07332939e-02f, 3.73610854e-02f, -1.39519125e-02f, 1.38741732e-01f, -2.41977256e-02f, -8.20542946e-02f, -6.84583858e-02f, -3.44551168e-02f, 4.01327759e-02f,
  2.04920396e-01f, 6.06142469e-02f, -3.21970619e-02f, 3.27468961e-02f, -1.05212508e-02f, 2.35247314e-02f, -2.42848080e-02f, -1.08964527e-02f, 3.34126540e-02f, 7.22435936e-02f,
  2.01174878e-02f, -1.50417106e-03f, 2.77446341e-02f, -2.44124178e-02f, 2.65120938e-02f, 2.73963828e-02f, 7.21443165e-03f, 1.66002549e-02f, 2.62383111e-02f, -1.63485650e-02f,
  2.29227021e-02f, 4.03236458e-03f, -6.29065856e-02f, 7.98320845e-02f, 7.02387746e-03f, 5.10886423e-02f, 6.43035397e-02f, -3.10451519e-02f, 2.17918418e-02f, -2.03240197e-02f,
  -5.11090219e-01f, 4.39073175e-01f, -1.30532756e-01f, 5.88416308e-02f, -3.32883477e-01f, 1.71766013e-01f, 2.09974855e-01f, -3.67813930e-02f, 9.14218575e-02f, 2.87004560e-01f,
  3.35314572e-02f, 8.14560950e-02f, 1.09331787e-01f, 3.11204910e-01f, 1.80753712e-02f, 3.73493969e-01f, 2.35356703e-01f, 8.45296457e-02f, 3.02039329e-02f, -6.48794398e-02f,
  -9.76713225e-02f, 2.03059733e-01f, -3.46700437e-02f, 9.84630659e-02f, -4.84406427e-02f, -1.86551601e-01f, -2.03652486e-01f, 5.65885566e-02f, 2.17717094e-03f, 1.19915143e-01f,
  -1.25493020e-01f, -3.51616405e-02f, -1.37223095e-01f, -6.60501346e-02f, -1.79219797e-01f, -1.02550246e-01f, -2.72672903e-02f, -2.75214016e-02f, -3.70008834e-02f, 3.48693766e-02f,
  2.22013448e-03f, -8.03830922e-02f, 3.91169377e-02f, 5.48713580e-02f, 9.45350807e-03f, -4.41067815e-02f, 9.58035216e-02f, 3.41498964e-02f, 6.00664690e-02f, -3.36227790e-02f,
  3.83767225e-02f, -5.37045076e-02f, 1.94414146e-02f, 5.78207523e-02f, -4.40877862e-02f, 9.28295702e-02f, -1.55097777e-02f, -1.52952939e-01f, 1.25591367e-01f, -4.84220125e-02f,
  -2.80113574e-02f, -4.99678627e-02f, 2.25281082e-02f, 9.30595845e-02f, 1.51015790e-02f, -1.84161291e-02f, 1.01774909e-01f, -2.40025613e-02f, 1.53682511e-02f, 5.41548384e-03f,
  -3.05801369e-02f, 1.22501971e-02f, 8.05216134e-02f, -4.32531051e-02f, -7.72617161e-02f, -1.18488539e-02f, -5.47301732e-02f, -1.60113089e-02f, -2.50637922e-02f, -4.05086949e-02f,
  7.80430138e-02f, 1.60059687e-02f, 3.70178744e-02f, -2.22704969e-02f, 7.54160509e-02f, -4.51163054e-02f, 2.14585420e-02f, 8.44713151e-02f, -4.95277345e-02f, -9.96573176e-03f,
  -4.33228835e-02f, 1.55520335e-01f, 1.08280025e-01f, 4.59675565e-02f, 7.63931051e-02f, 2.77177207e-02f, -3.80396075e-03f, -3.20560182e-03f, 3.71121913e-02f, -5.85388243e-02f,
  -1.66534096e-01f, -9.16046149e-04f, -1.83297899e-02f, -3.28886732e-02f, 2.36031488e-02f, -3.64644304e-02f, -4.70156409e-02f, -2.60924157e-02f, 5.77736534e-02f, -7.93790519e-02f,
  -8.52902420e-03f, -8.77904668e-02f, 7.32317120e-02f, -4.51171696e-02f, -9.53646749e-02f, -6.27842396e-02f, -7.83680603e-02f, -3.44684608e-02f, 4.49414402e-02f, 4.84288037e-02f,
  -5.13058662e-01f, 2.43692458e-01f, -5.92127182e-02f, -4.25393909e-01f, 6.53454587e-02f, -1.16777644e-02f, -1.00281239e-01f, 1.35773897e-01f, -2.36840378e-02f, 1.60004303e-01f,
  -1.40399307e-01f, 1.66641194e-02f, -1.89012140e-02f, -1.91993773e-01f, -4.39158708e-01f, -1.28496006e-01f, -2.10764006e-01f, -4.52177878e-03f, 2.96275079e-01f, -6.28612936e-02f,
  -6.67505711e-02f, -2.60394394e-01f, -3.30084056e-01f, 2.08777562e-01f, -1.86489634e-02f, 1.43775433e-01f, -9.37571004e-02f, 1.63890049e-01f, -1.58300884e-02f, -1.05467038e-02f,
  -6.91297650e-02f, 1.75368339e-02f, 8.39274493e-04f, 1.01965271e-01f, -3.64970677e-02f, 8.51042010e-03f, 1.69212800e-02f, -8.02496150e-02f, 1.14951180e-02f, 8.91181603e-02f,
  -2.58847531e-02f, -4.13398147e-02f, 6.13403097e-02f, -4.50981446e-02f, -1.73472334e-02f, -3.01827844e-02f, -4.04677633e-03f, 2.97817518e-03f, 6.97904592e-03f, -8.70168433e-02f,
  -1.05503183e-02f, 7.61016319e-03f, -5.33543527e-02f, -1.98710524e-03f, -2.27940977e-02f, 1.22209149e-03f, -3.89964618e-02f, -3.17086233e-03f, 9.87614505e-03f, 8.07479303e-03f,
  -4.43973765e-02f, 1.03581818e-02f, -5.08401878e-02f, -5.20079695e-02f, 3.02159730e-02f, 8.69156141e-03f, -4.89117913e-02f, -2.13784929e-02f, 7.41994828e-02f, -4.29855706e-03f,
  8.05150426e-04f, -4.23913309e-03f, -2.13816538e-02f, -5.74659072e-02f, -1.35562681e-02f, -5.13471256e-04f, -3.80020551e-02f, 7.48108849e-02f, -1.87853891e-02f, -6.75651282e-02f,
  5.33451810e-02f, -6.43725544e-02f, 1.86061822e-02f, -1.50586595e-03f, 3.12449019e-02f, -4.99141142e-02f, 1.04033083e-01f, -4.01877798e-02f, 4.51605767e-02f, -9.09355283e-02f,
  6.74843639e-02f, 1.40005127e-01f, 5.87048233e-02f, 5.20052090e-02f, 5.95294945e-02f, 2.27083042e-02f, -7.23080710e-02f, 2.95586940e-02f, 4.38843220e-02f, 7.59993680e-03f,
  -8.95743724e-03f, 5.06712943e-02f, 5.02372347e-02f, -2.06956714e-02f, 4.31032926e-02f, -7.98218942e-04f, 5.53638861e-03f, 7.18437433e-02f, -5.45715839e-02f, 1.00257263e-01f,
  -8.98704678e-02f, -2.02021729e-02f, -9.18431506e-02f, 1.28531680e-01f, 3.37681323e-02f, 2.36241352e-02f, 6.30389005e-02f, -2.22243667e-02f, -9.42725390e-02f, 2.57079601e-02f,
  -2.75565326e-01f, 1.54579863e-01f, 1.00663275e-01f, -3.17658633e-01f, -2.08127245e-01f, 6.98926970e-02f, -1.60330441e-02f, 2.54183691e-02f, -1.03891067e-01f, 1.29699737e-01f,
  -5.40064313e-02f, 1.19250253e-01f, 2.59468198e-01f, -1.04964226e-01f, -2.79407144e-01f, 2.80332953e-01f, -2.82416403e-01f, 3.93861756e-02f, 2.61014048e-03f, -2.17302814e-01f,
  -6.12592697e-02f, -2.29779482e-01f, -1.21460930e-02f, -1.19382754e-01f, -2.17189312e-01f, -5.45316674e-02f, -3.50911617e-01f, 3.57976370e-02f, -2.05435708e-01f, -1.11649238e-01f,
  -7.67265484e-02f, -2.99771242e-02f, 3.76431756e-02f, -3.40832360e-02f, -4.40416448e-02f, 3.56694795e-02f, -7.35815912e-02f, 5.45982718e-02f, 4.92543168e-02f, -6.15530123e-04f,
  5.04603162e-02f, -5.12016080e-02f, -3.57120447e-02f, 6.20861165e-02f, -6.17109844e-03f, -6.95384517e-02f, -4.72900681e-02f, 4.96659428e-02f, 3.79428491e-02f, 2.01938413e-02f,
  8.24931934e-02f, -1.70343723e-02f, -6.73319027e-02f, -1.39594376e-02f, -9.55222324e-02f, -7.31371269e-02f, -5.67500107e-03f, 1.83380712e-02f, -5.02113700e-02f, -7.30412304e-02f,
  -8.19232408e-03f, 5.04904659e-03f, 3.90017629e-02f, -1.27849169e-02f, -2.56655812e-02f, -6.35061860e-02f, 1.57295633e-02f, -3.98119204e-02f, 4.80422340e-02f, -6.48473725e-02f,
  -7.91378990e-02f, 1.36454189e-02f, -7.68737495e-02f, 8.47649388e-03f, -1.22852542e-03f, 1.21860746e-02f, 2.89569627e-02f, 1.03335502e-02f, -7.51518384e-02f, -5.27982228e-03f,
  -1.83392409e-02f, -1.78257488e-02f, 1.46833509e-02f, -1.50160240e-02f, -1.89491548e-02f, -5.19690663e-03f, 8.21086857e-03f, 6.42248020e-02f, 2.77948696e-02f, -4.22927464e-04f,
  -2.61169821e-02f, -3.52281064e-01f, 4.86073010e-02f, -1.85375311e-03f, 1.32431760e-02f, -6.79166149e-03f, 4.28971723e-02f, -1.69062819e-02f, -1.46572068e-01f, 1.54529689e-02f,
  -9.61505026e-02f, -5.52053712e-02f, -1.23484738e-01f, -1.03171738e-02f, -3.53380777e-02f, -4.45908494e-02f, -6.30567372e-02f, -9.38586146e-02f, -1.86606929e-01f, -1.05940020e-02f,
  -7.31004179e-02f, 5.73571073e-03f, 2.03730073e-02f, -1.17568627e-01f, -3.85108143e-02f, -1.04960077e-01f, 1.50956074e-03f, 1.07920868e-02f, -6.53043985e-02f, -5.62161859e-03f,
  -2.44728312e-01f, 2.47652650e-01f, 1.66432351e-01f, 1.85657758e-02f, -2.44989410e-01f, -5.03105447e-02f, 1.19144507e-01f, -6.64149597e-03f, 2.28263602e-01f, 2.28245839e-01f,
  -6.72627166e-02f, -5.55851609e-02f, 1.71130046e-01f, 1.42622828e-01f, -4.80343550e-01f, 2.42281482e-01f, -1.16240144e-01f, -1.52130648e-02f, 1.75970316e-01f, -1.25218853e-01f,
  -8.50479379e-02f, -2.23051235e-01f, -1.74745053e-01f, -4.33920249e-02f, -9.67449993e-02f, 1.70529895e-02f, -1.98810473e-01f, 2.05854196e-02f, -1.39480770e-01f, -1.52573332e-01f,
  -5.18187210e-02f, 1.96785890e-02f, 1.52864277e-01f, 5.74529320e-02f, -4.07758392e-02f, -5.76807326e-03f, 3.39374952e-02f, 1.25305308e-02f, 1.38101885e-02f, 6.89325780e-02f,
  1.07118547e-01f, -8.90383273e-02f, 1.00425765e-01f, 2.02713162e-02f, -4.27848920e-02f, 9.20766294e-02f, -4.90432093e-03f, 8.13110396e-02f, 8.20494741e-02f, -6.25519678e-02f,
  6.21518232e-02f, -1.09922821e-02f, 5.09695336e-02f, -3.61301526e-02f, -4.97696782e-03f, 4.04552035e-02f, 5.16795777e-02f, -1.13042176e-01f, -4.76418249e-02f, -8.24718773e-02f,
  -2.29329057e-03f, 4.48798276e-02f, -1.14456248e-02f, 7.86794275e-02f, -1.32422084e-02f, 3.50004919e-02f, -1.14670058e-06f, -1.29775684e-02f, -3.18662487e-02f, -3.42818983e-02f,
  -9.83317345e-02f, 1.25032384e-02f, 4.50365990e-02f, -3.81775224e-03f, -1.02700097e-02f, 4.64775562e-02f, 5.14301211e-02f, -1.33121118e-01f, -5.86277479e-03f, -3.69156562e-02f,
  8.88141319e-02f, -5.28306067e-02f, -5.81676587e-02f, -3.14992033e-02f, 2.03867350e-02f, -7.75804520e-02f, 5.60939722e-02f, 3.73399742e-02f, 7.50805587e-02f, -1.90767962e-02f,
  -3.14729780e-01f, -3.38443995e-01f, 1.43875051e-02f, -1.04200177e-01f, 6.13450212e-03f, -1.68497534e-03f, 1.38743743e-01f, 2.49557905e-02f, -1.05125599e-01f, -3.77924889e-02f,
  -7.63260871e-02f, -3.28914747e-02f, -7.50080198e-02f, -3.67326615e-03f, 4.82592033e-03f, -2.97796689e-02f, 4.11807336e-02f, -2.65429430e-02f, -8.82047117e-02f, -8.77417922e-02f,
  -7.89580941e-02f, -9.15530026e-02f, 6.62306207e-04f, 1.63373854e-02f, -6.32261932e-02f, -4.95718569e-02f, -1.03196643e-01f, -2.43655834e-02f, -6.12793583e-03f, 5.83194420e-02f,
  3.02968383e-01f, -4.94870581e-02f, -7.83374459e-02f, 2.17141241e-01f, 2.99918562e-01f, -1.06867336e-01f, -2.20226526e-01f, 7.61221945e-02f, 1.99496433e-01f, -1.52222097e-01f,
  -2.29048416e-01f, 1.89866185e-01f, -2.32249752e-01f, 9.61964056e-02f, -2.51300246e-01f, -2.10405186e-01f, -9.23740491e-02f, -9.16880816e-02f, 2.48081893e-01f, 3.78684439e-02f,
  -6.33189380e-02f, -1.99989937e-02f, -2.69923836e-01f, 2.13897362e-01f, 1.38592189e-02f, 1.43144742e-01f, -3.03277671e-01f, 7.56303519e-02f, 1.30534962e-01f, 6.55616969e-02f,
  -3.50397155e-02f, 8.54471400e-02f, -2.93721911e-02f, -8.72760713e-02f, -1.02449499e-01f, 6.55023335e-03f, -1.49031267e-01f, -7.59511888e-02f, 9.37326923e-02f, 5.86758815e-02f,
  5.42163327e-02f, 2.74411831e-02f, 1.66753963e-01f, 5.93395792e-02f, 4.00616229e-02f, 3.08917854e-02f, 4.04149219e-02f, -8.28548819e-02f, 6.89253211e-02f, 6.14839010e-02f,
  6.70596287e-02f, -1.85042977e-01f, -1.10908620e-01f, -1.24028996e-01f, -1.32264525e-01f, 6.69623464e-02f, -7.50094354e-02f, -2.75849029e-02f, -6.89038113e-02f, 6.80914372e-02f,
  1.26574919e-01f, 1.56733736e-01f, 4.35043350e-02f, 1.12007231e-01f, 5.22347763e-02f, -2.28075869e-02f, -7.16019720e-02f, -2.32987478e-02f, -1.67544097e-01f, -2.19959281e-02f,
  2.37935726e-02f, 7.14625418e-02f, 8.04589540e-02f, -1.31346127e-02f, 5.34932837e-02f, -2.59697437e-02f, -1.14844576e-01f, 4.26217914e-02f, -7.70843960e-03f, 1.86832845e-02f,
  -3.43712494e-02f, -5.21944463e-02f, -2.98089869e-02f, -5.12969233e-02f, -1.23995822e-02f, -7.39935935e-02f, -9.74906608e-02f, -8.40827525e-02f, -1.30767539e-01f, -9.82313007e-02f,
  -1.29784510e-01f, -2.12536484e-01f, -2.68804301e-02f, -1.42237276e-01f, 3.53100970e-02f, -1.61900520e-01f, 7.55873844e-02f, 1.00157876e-02f, -9.09977183e-02f, -1.08895764e-01f,
  -2.11945977e-02f, -6.91929236e-02f, -7.04370365e-02f, -2.50695832e-02f, -1.25688110e-02f, -3.09602767e-02f, 1.66865550e-02f, -7.83889815e-02f, -1.46967113e-01f, -3.73395979e-02f,
  -2.20770597e-01f, -5.29864021e-02f, -4.50402088e-02f, -1.18798457e-01f, -4.28284220e-02f, -4.41839397e-02f, 1.43174142e-01f, 2.27861982e-02f, -1.75612867e-02f, -9.11200643e-02f,
  4.20540333e-01f, -7.61587843e-02f, -8.75651985e-02f, 1.10577442e-01f, -1.33735508e-01f, -5.49251437e-01f, -2.02665657e-01f, -6.65513277e-02f, 7.83333927e-02f, -1.57286063e-01f,
  2.45344844e-02f, -5.38024642e-02f, 8.88602212e-02f, 6.42965063e-02f, 6.54412992e-03f, 9.29828808e-02f, -1.39613956e-01f, -9.18250903e-02f, 1.44607887e-01f, 3.75000834e-02f,
  1.07206523e-01f, 3.45848911e-02f, 7.07403272e-02f, -9.55296457e-02f, -8.58568493e-03f, 1.59850657e-01f, 1.85573138e-02f, 5.03453799e-02f, -9.07693729e-02f, 4.12674211e-02f,
  6.55712262e-02f, 1.55337915e-01f, -2.09664572e-02f, -5.89763261e-02f, -1.05545424e-01f, -4.64188494e-02f, -5.95220700e-02f, 8.28275234e-02f, 4.03208211e-02f, -3.40742953e-02f,
  -2.93042045e-02f, 5.47170304e-02f, -1.79216210e-02f, 1.02270469e-01f, 8.10511559e-02f, -4.98901941e-02f, 7.26503134e-02f, -7.40518495e-02f, 3.42959054e-02f, 5.91394641e-02f,
  1.77172050e-02f, -5.44925919e-03f, 7.94458576e-03f, 4.91547734e-02f, 3.89851592e-02f, 1.16561092e-01f, 1.52220605e-02f, -8.91441926e-02f, -1.55477002e-01f, -1.64007187e-01f,
  -6.33818358e-02f, 5.46101341e-03f, -2.51019225e-02f, 8.73430632e-03f, -8.09345618e-02f, 1.28030293e-02f, -1.54446531e-02f, 1.19611695e-02f, 5.39070815e-02f, -2.41386835e-02f,
  -4.79060300e-02f, -4.06676307e-02f, 8.83536600e-03f, -8.14747214e-02f, -2.06088331e-02f, 4.36732918e-02f, -3.82281188e-03f, 2.52960082e-02f, -6.97835982e-02f, 1.92231610e-02f,
  7.47201070e-02f, 2.88669448e-02f, -3.17843333e-02f, 1.28308997e-01f, 7.57686421e-02f, -7.02320188e-02f, -1.34043276e-01f, 4.62480597e-02f, 4.33740355e-02f, -7.02657849e-02f,
  -2.70458400e-01f, -2.70869642e-01f, -9.26618464e-03f, -7.71636516e-03f, 8.21314305e-02f, -7.14033619e-02f, 1.38292685e-02f, -5.90791740e-02f, -2.89254673e-02f, -2.32455265e-02f,
  -1.10986821e-01f, 1.15232833e-01f, -1.10120595e-01f, 2.42731217e-02f, -3.60800810e-02f, -1.52131110e-01f, -2.41385563e-03f, -5.82791865e-02f, -1.17510356e-01f, -6.25885278e-02f,
  -5.62098883e-02f, 4.56582233e-02f, -2.01325230e-02f, -5.31304143e-02f, -1.45604415e-02f, 9.50948428e-03f, -2.07349863e-02f, 7.08233491e-02f, -4.11575772e-02f, -8.01095665e-02f,
  2.99066633e-01f, -5.01054406e-01f, -2.03731686e-01f, 1.04606241e-01f, 2.15950608e-01f, 1.24861524e-01f, 8.00230131e-02f, -7.39180520e-02f, -5.48928566e-02f, -2.38925233e-01f,
  -1.07742943e-01f, -3.18995602e-02f, -1.73201635e-01f, -2.65777498e-01f, 1.55714452e-01f, -3.43242824e-01f, -1.01840258e-01f, -1.56958736e-02f, -1.35537371e-01f, -7.33758360e-02f,
  6.98790997e-02f, -2.07140204e-02f, -1.73666909e-01f, -6.51267841e-02f, 5.73072303e-03f, 6.02223389e-02f, 1.11963004e-01f, 9.59762651e-03f, 1.07288390e-01f, 1.08811304e-01f,
  -1.29565895e-01f, -2.66953617e-01f, -1.16967391e-02f, 1.37109431e-02f, -3.08286417e-02f, 1.46940246e-01f, 1.08141065e-01f, 2.97069382e-02f, 2.71902420e-02f, -5.40103614e-02f,
  5.54327331e-02f, 6.28270283e-02f, 8.21012945e-04f, -4.93977871e-03f, -4.16696724e-03f, -4.68456522e-02f, -1.12611502e-01f, 3.01874001e-02f, 3.55278817e-03f, -4.94893715e-02f,
  -8.66537318e-02f, -5.02960831e-02f, 5.07427640e-02f, -7.72989094e-02f, 2.93955877e-02f, -2.33262163e-02f, -4.01092740e-03f, 9.67845321e-02f, 2.81022321e-02f, 7.84050003e-02f,
  4.00711026e-04f, 2.17794208e-03f, -1.74900331e-02f, -1.05600692e-01f, -8.42183679e-02f, 1.57190524e-02f, -1.06551610e-02f, -5.69522148e-03f, -3.37212980e-02f, -7.52308667e-02f,
  7.97800273e-02f, 3.64441797e-02f, -2.21495666e-02f, 1.05591089e-01f, 4.25743647e-02f, -1.96045991e-02f, 7.64154717e-02f, -5.08610159e-03f, 5.87775558e-02f, 4.53329645e-02f,
  1.59273930e-02f, 7.46231005e-02f, -8.36998150e-02f, 6.24640286e-02f, -7.28435861e-03f, -5.52788563e-02f, -4.24925797e-03f, -9.57663804e-02f, 4.01536711e-02f, 7.18358532e-02f,
  -4.20793742e-02f, -9.13470089e-02f, -5.33655621e-02f, -3.14065348e-03f, -6.02539741e-02f, 9.60194785e-03f, -3.29699256e-02f, 1.18963770e-03f, -2.50327517e-04f, 4.83727939e-02f,
  7.62711614e-02f, 2.57042870e-02f, 8.31203163e-02f, 3.02190398e-04f, 4.91451956e-02f, -6.20125085e-02f, 1.33704141e-01f, 9.86859873e-02f, 3.09624393e-02f, -2.66846269e-03f,
  5.96106388e-02f, 2.30472498e-02f, -2.18397211e-02f, 4.63185273e-02f, 1.14721172e-01f, 2.72385334e-03f, 5.39607294e-02f, -6.46931231e-02f, 9.56494734e-03f, -6.48302119e-03f,
  -2.40043029e-01f, 4.00196277e-02f, 1.95829466e-01f, -1.97905079e-01f, -1.58322394e-01f, 1.55061111e-01f, 2.53770113e-01f, -6.06752373e-02f, -2.08464161e-01f, 2.36596286e-01f,
  1.49188116e-01f, -1.95245728e-01f, 3.02590251e-01f, -9.37871635e-02f, 1.90739125e-01f, 6.34629801e-02f, 1.31690666e-01f, -2.06548045e-03f, -1.98915288e-01f, 1.64591059e-01f,
  -1.86744228e-03f, 1.58800319e-01f, 2.12443501e-01f, -3.30943689e-02f, 5.27196005e-02f, -7.66689181e-02f, 3.13537836e-01f, 1.27257984e-02f, 4.24347036e-02f, -4.39388454e-02f,
  -6.64266720e-02f, -9.54166278e-02f, 2.79451776e-02f, 2.48328224e-03f, 1.56552657e-01f, 6.21488923e-03f, 4.02490981e-02f, 8.58677737e-03f, -3.85154523e-02f, 6.58265576e-02f,
  2.18758974e-02f, -6.03919812e-02f, -8.20505470e-02f, -5.00186011e-02f, -9.40942392e-02f, -9.43088755e-02f, 9.60492063e-03f, -3.90750691e-02f, -4.21998873e-02f, -1.14828423e-02f,
  8.31690431e-02f, -4.66221310e-02f, 4.09228727e-02f, -1.59099810e-02f, 6.05678707e-02f, -9.86251608e-02f, 4.71584648e-02f, 8.00361335e-02f, -1.07331060e-01f, -4.40091118e-02f,
  4.66984278e-03f, 4.75761034e-02f, 3.11457627e-02f, -3.41713168e-02f, -3.00553963e-02f, -5.95986843e-02f, -2.86516957e-02f, -3.56918164e-02f, 2.69530416e-02f, -5.42187598e-03f,
  -5.33661097e-02f, -9.69701558e-02f, -4.07372937e-02f, -5.04901633e-02f, -1.39144175e-02f, -8.23227987e-02f, 5.19170484e-04f, 7.01316670e-02f, -4.77055162e-02f, -3.98703665e-02f,
  -1.28583182e-02f, -3.26063111e-02f, 1.11040799e-02f, -3.00419014e-02f, -1.94316655e-02f, -1.28981294e-02f, 3.26655991e-02f, -4.78936359e-02f, 9.39575490e-03f, 5.51363528e-02f,
  2.29823053e-01f, 2.27154985e-01f, -6.13313578e-02f, -8.68279487e-02f, -6.05188869e-02f, 5.86107038e-02f, -3.63362767e-02f, -3.70384343e-02f, 6.31634817e-02f, 3.99300903e-02f,
  2.78080944e-02f, 1.72570664e-02f, 7.20731914e-02f, -6.27473891e-02f, -3.79471853e-02f, 1.50565416e-01f, 8.93913582e-02f, -4.66077309e-03f, 1.06333621e-01f, 8.37342888e-02f,
  7.20665976e-02f, 9.34312791e-02f, -1.51743693e-02f, -3.15287486e-02f, -6.47451729e-02f, 8.20645913e-02f, -7.72702247e-02f, -3.76649573e-02f, 6.92265928e-02f, 4.37437594e-02f,
  -2.92400181e-01f, 4.83049363e-01f, -2.66073763e-01f, 2.56575234e-02f, 4.05121669e-02f, 3.90897959e-01f, 5.45390286e-02f, 1.06802344e-01f, -1.62911415e-01f, 3.09069097e-01f,
  3.51244211e-02f, 3.20551847e-03f, -4.95312959e-02f, 2.34559312e-01f, 9.22886729e-02f, -3.20693254e-02f, 3.61792028e-01f, 2.07270324e-01f, -1.59020096e-01f, 2.18025208e-01f,
  -4.70801331e-02f, 3.15887213e-01f, -1.56934801e-02f, 1.96512714e-01f, 4.49532010e-02f, -1.23328738e-01f, 5.66591360e-02f, -1.72717407e-01f, 1.51825681e-01f, 1.00935884e-01f,
  2.74161808e-02f, -9.24174115e-02f, -7.47550428e-02f, -6.86809197e-02f, -5.00284694e-03f, -4.97154407e-02f, -3.06719728e-02f, -5.93090653e-02f, -1.10528655e-01f, -4.66742814e-02f,
  -6.73311949e-02f, -3.20773646e-02f, 3.13279368e-02f, 4.31608558e-02f, -6.08396828e-02f, -5.40580526e-02f, -7.38572553e-02f, -3.46585289e-02f, 3.96623835e-02f, -9.03744921e-02f,
  -7.34416991e-02f, -1.35201616e-02f, -1.68486703e-02f, 5.40441610e-02f, -5.26146479e-02f, 6.64855586e-03f, 5.06849289e-02f, -2.88278214e-03f, 5.57508990e-02f, 2.73369681e-02f,
  -2.12498177e-02f, 1.10523859e-02f, -3.29342633e-02f, -1.43794650e-02f, 4.51850295e-02f, -8.12388435e-02f, 4.08413745e-02f, -5.06389216e-02f, -9.53103974e-02f, 6.73983768e-02f,
  -5.44474833e-02f, -4.88009863e-03f, 1.34552550e-03f, -3.08430847e-02f, 2.98325624e-02f, -1.59355141e-02f, -8.03725421e-02f, -2.03729551e-02f, -4.78820130e-02f, -7.34864324e-02f,
  -5.20024300e-02f, 1.68847889e-02f, -5.89441843e-02f, -9.39546451e-02f, 5.22793978e-02f, -1.93831827e-02f, 3.80962193e-02f, -4.15209234e-02f, 5.12954663e-04f, 4.41509939e-04f,
  2.37003013e-01f, 3.22965175e-01f, -5.27814031e-02f, 5.92127480e-02f, 6.48843944e-02f, -3.14800069e-02f, -3.61389555e-02f, 2.95897014e-02f, 1.12180911e-01f, 5.25418296e-02f,
  1.75409093e-02f, -1.26757771e-02f, 1.07507203e-02f, -7.14009181e-02f, 1.01520136e-01f, 4.74846028e-02f, 2.34127250e-02f, -5.28650507e-02f, 3.47609520e-02f, 3.99993397e-02f,
  4.26158533e-02f, -5.09716980e-02f, 4.37357426e-02f, -1.08903705e-03f, 7.97939152e-02f, -2.32399236e-02f, 3.79519686e-02f, -4.33227271e-02f, -1.94901340e-02f, 6.92032874e-02f,
  -2.67948091e-01f, 2.22067446e-01f, 7.23535120e-02f, 1.98692545e-01f, -2.43204892e-01f, -4.31824416e-01f, -2.55141288e-01f, -4.30437252e-02f, -1.26879737e-01f, 2.61725597e-02f,
  2.83740498e-02f, 2.65797526e-01f, -2.74600871e-02f, 3.70825648e-01f, -2.04880729e-01f, 7.48518035e-02f, -5.37418127e-02f, 4.55732867e-02f, 4.43839654e-02f, -3.94484326e-02f,
  -3.83727849e-02f, 1.61674619e-01f, 2.50990778e-01f, 5.62579334e-02f, 3.33472267e-02f, 5.87662645e-02f, 1.19011998e-01f, 4.35975306e-02f, 2.64678091e-01f, 1.03870012e-01f,
  4.02618796e-02f, 1.61135256e-01f, 2.47558765e-02f, 2.89927833e-02f, -9.83509868e-02f, -1.03360802e-01f, -8.98350775e-03f, -8.02428946e-02f, -1.98399536e-02f, 2.43288334e-02f,
  -2.52597686e-02f, 1.12327375e-02f, 5.31182662e-02f, 1.17799975e-02f, -4.46150936e-02f, 1.04970112e-01f, 5.56245493e-03f, 1.27057033e-02f, 1.94735490e-02f, 2.21199151e-02f,
  -9.56766307e-04f, 6.09909110e-02f, -2.98292786e-02f, 6.90545887e-02f, 6.83824625e-03f, -2.72854082e-02f, -3.15188654e-02f, -3.71585675e-02f, 1.62567776e-02f, -1.12337582e-01f,
  -1.23110704e-01f, -5.31203710e-02f, 5.13080135e-03f, 4.29479666e-02f, 4.43894900e-02f, 8.45196005e-03f, -2.69015133e-03f, 6.01557568e-02f, -7.21961632e-02f, -3.90072237e-03f,
  -3.71280201e-02f, 6.17594644e-02f, 7.14476258e-02f, -7.73893148e-02f, -1.59034859e-02f, -8.31809361e-03f, 2.36047842e-02f, 5.33460975e-02f, -5.53312562e-02f, 4.37125377e-02f,
  7.31456280e-02f, -4.05746363e-02f, 9.40103307e-02f, -4.19242568e-02f, -3.73021401e-02f, -1.45489806e-02f, -2.06484459e-02f, -4.24837926e-03f, 8.11179802e-02f, -3.04926280e-02f,
  -1.09809019e-01f, -2.20891297e-01f, 2.83221062e-02f, 6.11285195e-02f, 4.70119379e-02f, -1.72470007e-02f, 2.09676921e-02f, -2.18190420e-02f, 1.16676260e-02f, -8.62422958e-02f,
  6.66586608e-02f, -2.77504660e-02f, -1.57692775e-01f, 3.33732478e-02f, -3.16342525e-02f, -7.48825446e-02f, 1.87366046e-02f, 4.23360011e-03f, -1.13816760e-01f, -5.76197542e-02f,
  4.26394343e-02f, -1.13202013e-01f, 3.03161610e-02f, -5.82018830e-02f, -3.78004089e-02f, -3.63067426e-02f, -5.48987947e-02f, 3.37542072e-02f, -6.92423806e-02f, -3.42973694e-02f,
  -2.35347319e-02f, 3.98278944e-02f, -1.26968458e-01f, 7.04059824e-02f, 8.49378705e-02f, -1.93983614e-02f, 9.20444261e-03f, 6.66867942e-02f, -6.68178275e-02f, 7.19209015e-02f,
  3.51493567e-01f, -1.57370448e-01f, 3.38961750e-01f, 3.04124504e-01f, 4.11653109e-02f, 3.40694875e-01f, 1.78964242e-01f, 5.81239676e-03f, 1.49111181e-01f, 1.47081167e-01f,
  -3.74325225e-03f, 2.92244226e-01f, 1.47595510e-01f, 2.00897038e-01f, 8.33988860e-02f, -1.80312440e-01f, 3.71799320e-02f, 8.78741145e-02f, -1.47260159e-01f, -2.06335187e-02f,
  3.69933322e-02f, 2.63326317e-01f, 4.66186646e-03f, -1.06328214e-02f, 1.41374662e-03f, -3.93340178e-02f, -1.32673845e-01f, 9.59093198e-02f, 8.98019224e-02f, -1.88650377e-02f,
  -1.43006975e-02f, 4.33755256e-02f, 5.13532311e-02f, 3.99984531e-02f, -1.07473820e-01f, 3.04528400e-02f, -1.99191477e-02f, -1.32544592e-01f, -4.87284549e-03f, 9.66485962e-03f,
  3.78239118e-02f, -3.42893676e-04f, -6.53412417e-02f, -4.37605940e-02f, -1.64345168e-02f, -4.47598323e-02f, -6.82225227e-02f, -9.86395031e-02f, -1.61877796e-02f, 1.19047589e-03f,
  -4.32172604e-02f, 2.66183838e-02f, -9.70226992e-03f, 2.38313768e-02f, 1.40505865e-01f, 2.07466930e-02f, -1.51260395e-03f, -9.33337864e-03f, -2.95907594e-02f, 1.72286220e-02f,
  1.24756421e-03f, -6.41455948e-02f, 1.64976921e-02f, -9.97915193e-02f, 9.07473639e-03f, -5.20225130e-02f, -4.88008745e-02f, -5.29049374e-02f, -5.30050416e-03f, -2.68145632e-02f,
  1.70070112e-01f, -5.52529655e-02f, 3.22486199e-02f, 5.55217732e-04f, 8.61434117e-02f, 1.54277380e-03f, -2.85787825e-02f, -9.51127261e-02f, -2.87462529e-02f, -3.98871861e-02f,
  -3.12447194e-02f, 1.04836181e-01f, 5.42837903e-02f, 2.56353780e-03f, -1.96608417e-02f, 9.29709524e-03f, 9.92731377e-02f, -4.90999892e-02f, -6.64530275e-03f, 1.24768414e-01f,
  -4.11247723e-02f, -1.18520655e-01f, -1.59072161e-01f, 1.90285817e-02f, 3.18585895e-02f, -5.26659265e-02f, -7.97581449e-02f, -5.25261834e-02f, -4.33386415e-02f, -4.88133356e-02f,
  -9.33565274e-02f, 8.94043967e-03f, 1.06358081e-02f, 1.16396174e-01f, -7.15123564e-02f, 5.70624955e-02f, -1.15842655e-01f, 5.13197714e-03f, 1.90078262e-02f, -1.88253466e-02f,
  -3.95351082e-01f, -3.24124664e-01f, -1.83714539e-01f, -2.38695130e-01f, -2.05684127e-03f, 1.65267527e-01f, 1.78712681e-02f, -2.77357280e-01f, -3.62250119e-01f, -5.23190685e-02f,
  6.21907264e-02f, -7.67470598e-02f, 7.05230385e-02f, -8.95388201e-02f, 3.26662272e-01f, 2.10255593e-01f, -1.76858485e-01f, -1.53728547e-02f, -9.03282613e-02f, -2.48589560e-01f,
  -8.23029876e-02f, 1.31874949e-01f, -3.49760964e-03f, 9.92673412e-02f, -2.55863011e-01f, -1.74840480e-01f, 2.10869789e-01f, 1.25693336e-01f, 7.54398704e-02f, 1.84676856e-01f,
  4.85632718e-02f, -1.45749480e-01f, -7.81081915e-02f, 1.00562900e-01f, -1.28295168e-01f, 3.90712135e-02f, 8.96279216e-02f, 1.34052411e-01f, 5.03827929e-02f, 3.62109538e-04f,
  3.62185575e-02f, 8.91928524e-02f, -5.99363483e-02f, 7.95228928e-02f, -1.16589718e-01f, -7.47778490e-02f, -8.18680972e-02f, -1.52463272e-01f, -1.22140169e-01f, 1.10139437e-02f,
  -1.71884313e-01f, -1.15841456e-01f, -6.66906536e-02f, -5.56374714e-03f, -2.77455021e-02f, -7.06965178e-02f, 2.19454989e-02f, -4.70729694e-02f, -6.18408918e-02f, -4.99911830e-02f,
  -1.22277942e-02f, 7.00504929e-02f, -3.38440090e-02f, -3.59780975e-02f, 4.64281626e-03f, -3.74755152e-02f, 1.98371317e-02f, 7.42792934e-02f, -2.17969995e-02f, -1.28816273e-02f,
  -9.73150891e-04f, -1.37002662e-01f, -7.93844536e-02f, 7.69990683e-03f, 4.44591511e-03f, -7.01441765e-02f, 1.11636311e-01f, -4.32776511e-02f, -1.18583441e-01f, -5.29217012e-02f,
  3.89251374e-02f, 7.45792612e-02f, -6.14648275e-02f, 3.47226416e-03f, -2.62726308e-03f, 6.13272488e-02f, -9.40677449e-02f, -3.87504473e-02f, 1.46635063e-03f, 7.54056945e-02f,
  -2.88325138e-02f, -2.16160202e-03f, 4.24420163e-02f, 3.07093970e-02f, 5.05444109e-02f, -5.69312088e-02f, 4.07305211e-02f, -6.89586923e-02f, -4.44880240e-02f, -2.37837294e-03f,
  6.14665588e-03f, 6.10270631e-03f, 3.01462710e-02f, 5.41304331e-03f, 6.87660724e-02f, -9.58900675e-02f, 1.00621283e-01f, 3.48479562e-02f, 5.68073392e-02f, -4.24683727e-02f,
  1.37198670e-02f, 1.25284836e-01f, 1.05736703e-02f, -3.36690918e-02f, -1.40989646e-02f, 3.00928205e-02f, -5.86394258e-02f, -1.25018926e-02f, 6.24195337e-02f, -1.52836591e-02f,
  -2.52543747e-01f, 3.05037558e-01f, -3.63462478e-01f, -2.56318718e-01f, -6.51358292e-02f, -2.80833930e-01f, -3.20590496e-01f, -8.81431326e-02f, -5.19295223e-02f, 2.80327678e-01f,
  1.65169626e-01f, -3.76831666e-02f, 2.27324396e-01f, -1.03810176e-01f, -2.53843993e-01f, -1.87993161e-02f, -2.02934280e-01f, -1.02425776e-01f, 9.71384905e-03f, 2.22648550e-02f,
  1.13919494e-04f, 1.16330035e-01f, -7.50982314e-02f, 7.70148039e-02f, -1.39566034e-01f, -3.34303528e-02f, 1.98498413e-01f, 9.29065719e-02f, -9.84662622e-02f, -3.12982276e-02f,
  5.37149310e-02f, 6.80074245e-02f, -2.55429056e-02f, 7.68943951e-02f, -8.85865241e-02f, 1.31860962e-02f, 2.48417817e-02f, -3.02365106e-02f, 3.32735333e-04f, -3.76073979e-02f,
  -2.01941282e-02f, 1.92090316e-04f, -5.62090203e-02f, 3.55609655e-02f, -7.09411781e-03f, 9.57187489e-02f, -8.14283863e-02f, -4.13750485e-02f, -4.27868478e-02f, 1.73469447e-02f,
  -6.24020435e-02f, -6.40984103e-02f, -1.15770005e-01f, -4.82690521e-02f, -6.01170398e-02f, -2.60791518e-02f, -5.30112088e-02f, -2.03636866e-02f, -1.13329878e-02f, 3.52117196e-02f,
  -5.02049774e-02f, -1.91936046e-02f, -6.29699603e-02f, -2.55197622e-02f, 1.16397990e-02f, -3.70881110e-02f, -8.74017738e-03f, 9.64502096e-02f, -1.24200201e-03f, 5.69308773e-02f,
  -9.16098505e-02f, 1.11455228e-02f, -9.45469190e-04f, 4.02041785e-02f, 1.80023219e-02f, -3.10973148e-04f, 1.34284701e-02f, 3.52917276e-02f, -7.65854344e-02f, -3.44106257e-02f,
  9.67236981e-03f, 4.07800339e-02f, -5.13885096e-02f, 8.30165595e-02f, 4.74946722e-02f, 3.60968746e-02f, 3.32350540e-03f, -4.15088236e-02f, -1.67011786e-02f, -1.00616857e-01f,
  2.15339124e-01f, 2.21583694e-01f, 1.40400557e-02f, 6.76390380e-02f, 2.89038252e-02f, -5.05820569e-03f, -1.64434686e-02f, -2.68015973e-02f, 5.59308901e-02f, 8.88523534e-02f,
  4.20197733e-02f, -3.77697987e-03f, -6.89379126e-03f, -3.83493602e-02f, -4.18740585e-02f, 5.50123975e-02f, 6.20442554e-02f, 4.84225675e-02f, 7.85261244e-02f, 4.75096740e-02f,
  2.74996855e-03f, 8.23953822e-02f, -5.42854443e-02f, -2.56970879e-02f, 7.85452779e-03f, -1.48387747e-02f, 4.49759215e-02f, -9.64231342e-02f, 3.11753359e-02f, -3.16182859e-02f,
  -2.74812013e-01f, 3.67541820e-01f, 8.76267254e-02f, -5.10382205e-02f, 1.65199846e-01f, -2.73101449e-01f, -2.85686582e-01f, 3.33965093e-01f, 3.57502550e-02f, 9.22496468e-02f,
  -2.20733896e-01f, -2.36387104e-02f, 1.01466775e-01f, -4.48544651e-01f, -2.45151713e-01f, -2.85713613e-01f, -3.04534853e-01f, -1.90157861e-01f, 5.90048395e-02f, 7.19622755e-03f,
  1.02919638e-01f, 1.81806472e-03f, 3.51918600e-02f, 4.51171756e-01f, 3.93120423e-02f, 2.22424135e-01f, 1.03677660e-01f, 1.95586279e-01f, -2.14112010e-02f, -7.31508359e-02f,
  -1.87515318e-02f, 6.95682317e-02f, 4.16972302e-02f, -1.25797158e-02f, 2.77760737e-02f, -8.36211890e-02f, -3.53012495e-02f, 4.14330401e-02f, 8.51835497e-03f, 1.06582008e-02f,
  -3.14680822e-02f, 3.99703458e-02f, -1.15237515e-02f, 7.20122876e-03f, 4.76522744e-02f, 9.94760841e-02f, -8.32874328e-02f, -5.79016916e-02f, 9.86863747e-02f, -6.99078292e-02f,
  2.54053175e-02f, -1.31215319e-01f, -9.06712934e-02f, -4.81162407e-02f, 7.84372631e-03f, -3.16036642e-02f, -5.02535738e-02f, -3.24639939e-02f, -7.32593657e-03f, -3.51517797e-02f,
  -6.36057928e-02f, 3.36973406e-02f, -4.46405113e-02f, 7.02001229e-02f, -2.79257577e-02f, -4.63721156e-02f, 5.38846441e-02f, -6.22062013e-02f, 1.60024296e-02f, -5.69077134e-02f,
  4.99608181e-03f, -3.93411070e-02f, -2.30351724e-02f, -4.50282246e-02f, -1.23009868e-01f, 3.38337086e-02f, -1.60152130e-02f, -1.27616316e-01f, -3.21254246e-02f, -6.53921887e-02f,
  6.98383898e-02f, -6.96567595e-02f, 4.39158715e-02f, 3.44898067e-02f, 6.40514269e-02f, 9.98826027e-02f, -2.22589038e-02f, -3.81505489e-02f, -8.06640089e-02f, -9.67953540e-03f,
  1.57010540e-01f, 2.12997481e-01f, 9.85210314e-02f, 2.66285986e-02f, -6.77671954e-02f, 1.52376005e-02f, 5.96506987e-03f, -3.99360694e-02f, 1.62534922e-01f, -5.57373650e-02f,
  3.64270210e-02f, -2.60367375e-02f, 6.94375634e-02f, -8.72624665e-02f, -4.54547582e-03f, -2.65491847e-02f, -7.47625828e-02f, -5.29288128e-02f, 2.54585221e-02f, 9.07344371e-02f,
  1.87533274e-02f, 2.90354956e-02f, 2.49588080e-02f, 9.21916738e-02f, 1.86721254e-02f, 2.59442832e-02f, 3.70555446e-02f, 7.33269304e-02f, -2.56671123e-02f, 3.22924368e-02f,
  -3.83647323e-01f, 4.74741846e-01f, 3.16941855e-03f, 3.03225428e-01f, -2.54101008e-01f, 1.37516469e-01f, 5.95209375e-02f, 1.46791011e-01f, 8.66502598e-02f, 3.08642209e-01f,
  2.24127136e-02f, -1.44249618e-01f, 2.12606266e-01f, 2.24017277e-01f, -8.62845127e-03f, 3.69593561e-01f, 2.70076692e-01f, 1.07423641e-01f, 5.26361726e-02f, 9.15247761e-03f,
  8.66697654e-02f, 2.60364264e-01f, 1.99813157e-01f, 8.38802829e-02f, -7.22273514e-02f, -9.27309915e-02f, 3.62120904e-02f, -1.10771030e-01f, -2.97751259e-02f, -7.47350305e-02f,
  -1.23200472e-02f, 1.20767482e-01f, -1.10001758e-01f, 4.69754227e-02f, -2.97447648e-02f, -7.52719864e-02f, -1.14100315e-01f, -7.61539042e-02f, -1.46779031e-01f, -2.09305007e-02f,
  -6.01485968e-02f, 1.38396388e-02f, 1.03276201e-01f, 6.62135854e-02f, -7.71884155e-03f, -3.76924537e-02f, -6.29179999e-02f, -6.41082525e-02f, -1.98106691e-02f, 3.52491103e-02f,
  3.12723517e-02f, -5.45611829e-02f, -3.82710323e-02f, 9.23947692e-02f, -3.04681389e-03f, -2.26986762e-02f, 4.06456776e-02f, -5.06540649e-02f, 6.87082186e-02f, 2.26941835e-02f,
  -4.46959138e-02f, 4.97932453e-03f, 4.02129814e-03f, -8.03760663e-02f, 8.75087976e-02f, -8.26677829e-02f, 3.77407372e-02f, -7.94892088e-02f, -3.10027916e-02f, -4.53724945e-03f,
  -3.71693037e-02f, -1.22768115e-02f, 1.39980204e-02f, -5.35019673e-03f, 1.94298960e-02f, -3.16625535e-02f, -1.00838602e-01f, -3.39509733e-02f, -5.53934425e-02f, -1.94981489e-02f,
  3.73618044e-02f, -2.58857831e-02f, 2.47728974e-02f, -4.68744114e-02f, 9.08699632e-02f, -4.46098372e-02f, 2.67164782e-02f, -4.97775599e-02f, 2.35290881e-02f, -6.27240017e-02f,
  2.07613245e-01f, 3.52052540e-01f, 1.35491833e-01f, -2.07809247e-02f, 4.34543416e-02f, 1.97735106e-04f, 7.24478960e-02f, 3.63203371e-03f, 1.20025903e-01f, 1.08548865e-01f,
  -2.42638197e-02f, -3.63694467e-02f, 6.51436066e-03f, -5.59198335e-02f, 1.73374265e-02f, 4.49064523e-02f, 2.04679314e-02f, -5.25900535e-02f, -2.08967887e-02f, 2.61528511e-02f,
  -7.91928917e-02f, 3.37239262e-03f, -4.27773558e-02f, 4.37893672e-03f, -1.08653596e-02f, -2.01688912e-02f, -9.50991735e-02f, 5.20694954e-03f, -7.84192607e-02f, 6.35377988e-02f,
  -1.80141032e-01f, -2.03377202e-01f, 7.55097121e-02f, -1.63457338e-02f, -2.44067498e-02f, 2.91643500e-01f, -8.52373838e-02f, -1.14081837e-01f, 4.36086170e-02f, -2.68863797e-01f,
  -1.48191392e-01f, 2.68712901e-02f, -2.50794947e-01f, -2.31437713e-01f, 4.57220405e-01f, 2.28772640e-01f, -9.86747071e-02f, -9.25378725e-02f, 1.43491879e-01f, -2.60813922e-01f,
  4.85303029e-02f, -2.58493751e-01f, 2.01863736e-01f, -1.59532011e-01f, -2.71336019e-01f, -4.20551077e-02f, -1.80107411e-02f, 1.84076369e-01f, 3.62433568e-02f, 8.12468752e-02f,
  1.72310937e-02f, -2.16940790e-01f, -1.48639023e-01f, -4.15036678e-02f, -6.58224449e-02f, 5.46105802e-02f, 1.28337890e-01f, 1.09769605e-01f, 6.29157275e-02f, -5.35281450e-02f,
  -2.82747690e-02f, 2.03173514e-02f, -3.95270512e-02f, 6.10890463e-02f, -2.69633736e-02f, 4.26760279e-02f, 7.46824965e-02f, 3.75782140e-03f, -1.34740427e-01f, 2.10866961e-03f,
  -1.36643602e-02f, 4.11974004e-04f, -8.11657682e-02f, -2.24814825e-02f, 1.48805033e-03f, 1.59377151e-03f, 2.81403195e-02f, 6.49258122e-02f, 3.00529506e-02f, 8.65697116e-02f,
  -1.43140822e-03f, -1.10439425e-02f, -9.29620266e-02f, -1.20769683e-02f, -1.05805740e-01f, -1.22207865e-01f, 3.69684026e-02f, -2.38669794e-02f, 9.80353262e-03f, -2.93746293e-02f,
  3.85736413e-02f, -4.17570993e-02f, -2.47387905e-02f, 1.97134428e-02f, -3.77391540e-02f, -8.06986168e-02f, 3.49179395e-02f, 4.10990715e-02f, -7.99454376e-02f, -2.81769573e-03f,
  2.32610526e-03f, 3.30980159e-02f, -9.75093693e-02f, 8.04545730e-02f, -6.88136462e-03f, 5.48926881e-03f, -3.95261049e-02f, -3.32257748e-02f, -1.24455579e-02f, 6.61650300e-02f,
  6.81344718e-02f, -1.65244155e-02f, -8.45560282e-02f, 2.01028567e-02f, -2.19405815e-02f, -2.91442350e-02f, 5.82785793e-02f, -9.83607024e-02f, 9.14339796e-02f, -5.15673086e-02f,
  -1.00011945e-01f, -5.53201698e-02f, -5.32958796e-03f, 6.32337257e-02f, 1.34518743e-01f, -5.71331978e-02f, -4.16676663e-02f, -4.22664918e-02f, 5.75301684e-02f, -3.51837799e-02f,
  -2.06032842e-01f, -1.78180411e-02f, -4.64204848e-02f, -8.43217447e-02f, -5.72417453e-02f, 1.02256397e-02f, 1.73455831e-02f, -1.03489636e-02f, 1.23655591e-02f, 1.64232925e-02f,
  -3.00665438e-01f, -3.13179493e-01f, 3.70918140e-02f, -1.90654412e-01f, -2.71228198e-02f, -2.62987852e-01f, -5.47329187e-02f, -2.22844988e-01f, -3.03633958e-01f, -1.09838396e-01f,
  -3.70579772e-02f, 8.80757123e-02f, 1.36891812e-01f, -3.42763007e-01f, 3.60147446e-01f, 3.07595003e-02f, -2.81675994e-01f, -5.33949137e-02f, -1.15222298e-01f, -1.99228805e-02f,
  -1.16316415e-01f, -1.31408051e-02f, 1.48921058e-01f, -7.98741262e-03f, -2.02371225e-01f, -4.57089692e-02f, 2.33866900e-01f, 1.98767826e-01f, -6.99106455e-02f, 3.85592058e-02f,
  -1.94225207e-01f, -3.85840088e-02f, -9.39740390e-02f, -4.93274704e-02f, -8.43395367e-02f, 1.44355101e-04f, 3.94009613e-02f, 1.32445753e-01f, 1.19990438e-01f, -2.54484825e-02f,
  9.82839838e-02f, 8.62979740e-02f, -9.84854400e-02f, 2.62062382e-02f, -1.02506727e-01f, -5.59183098e-02f, -9.91890803e-02f, -1.25481293e-01f, -2.42316425e-02f, -3.97510417e-02f,
  -3.61405835e-02f, -6.13192767e-02f, -4.63611223e-02f, -1.69199985e-02f, -5.67126013e-02f, -7.78558105e-02f, 1.85408890e-02f, 3.44629250e-02f, -6.37766942e-02f, -6.56053126e-02f,
  -1.33278016e-02f, 1.94697585e-02f, -5.01106493e-02f, -7.53794312e-02f, -3.28722335e-02f, -6.45308048e-02f, 3.46864387e-02f, 8.78794305e-03f, -3.70593481e-02f, -2.08814051e-02f,
  6.15257304e-03f, -4.13692221e-02f, -5.06551601e-02f, -7.63582587e-02f, 5.68825612e-03f, -1.48009434e-01f, 5.14188260e-02f, 4.19302769e-02f, -5.54558039e-02f, -1.05061550e-02f,
  4.11412725e-03f, -1.43839596e-02f, 4.12965901e-02f, 2.79954951e-02f, -3.78111415e-02f, 4.83453535e-02f, -1.08530838e-03f, -2.43999306e-02f, -4.19137217e-02f, 1.50969252e-01f,
  1.00339651e-02f, 2.10327938e-01f, -2.16117948e-02f, -5.70546687e-02f, -1.24888197e-02f, -2.38630418e-02f, -1.71104558e-02f, -8.20135176e-02f, 3.67503762e-02f, -7.45415166e-02f,
  1.59607753e-02f, -5.44158854e-02f, 3.09041552e-02f, 5.28590567e-02f, 6.05787523e-02f, 4.24159877e-02f, 1.22439921e-01f, 1.96894184e-02f, 4.10110354e-02f, 2.79233754e-02f,
  5.36183044e-02f, 3.95583846e-02f, 6.50355816e-02f, -5.98331280e-02f, 4.02205698e-02f, 5.82603589e-02f, -6.34897873e-02f, -5.01577444e-02f, 8.73039812e-02f, 1.17205605e-02f,
  2.99473610e-02f, 1.37531251e-01f, 1.79193184e-01f, 1.51364475e-01f, 1.74568802e-01f, -3.28401029e-01f, -2.24191055e-01f, 3.20225179e-01f, 4.88626301e-01f, -1.65367410e-01f,
  5.67978546e-02f, -2.11325198e-01f, 1.12446837e-01f, -2.18248740e-01f, -2.28725180e-01f, -1.07812311e-03f, -1.71459839e-01f, -1.91127241e-01f, 1.83536202e-01f, -1.87526252e-02f,
  1.44840315e-01f, -2.08554879e-01f, -2.09317058e-01f, 5.45555493e-04f, -8.16540122e-02f, 1.52547389e-01f, -1.24449544e-02f, 1.03867464e-01f, -2.99017936e-01f, -9.71742943e-02f,
  -1.82621852e-01f, 2.77226686e-01f, -3.59924277e-03f, 8.55577295e-04f, 7.43921176e-02f, -5.71828075e-02f, -1.05593838e-01f, -2.31830198e-02f, 9.17151868e-02f, -1.93196852e-02f,
  -3.48263532e-02f, -3.57346758e-02f, -1.08664207e-01f, -2.47657280e-02f, 3.05920802e-02f, 4.52007763e-02f, 1.44720236e-02f, 5.35098203e-02f, -8.23350530e-03f, -1.66487843e-02f,
  5.76627180e-02f, -4.39573117e-02f, 5.46477959e-02f, 4.24443604e-03f, 4.01258990e-02f, 7.80470073e-02f, -5.20498157e-02f, -3.91331827e-03f, -3.38563509e-02f, 5.31702042e-02f,
  5.37747443e-02f, 3.06397639e-02f, 3.10661476e-02f, -8.71364120e-03f, 4.87057399e-03f, 4.34427150e-02f, -5.21894060e-02f, -2.44026240e-02f, 5.46986386e-02f, -6.85672536e-02f,
  4.69594486e-02f, -6.81980327e-02f, 1.18018962e-01f, 1.97783615e-02f, -6.75743520e-02f, -2.13693772e-02f, -3.86895128e-02f, 6.61736280e-02f, 3.96091603e-02f, -7.26513416e-02f,
  3.72805521e-02f, -2.59235408e-03f, -1.69622358e-02f, -2.65407842e-02f, -3.33880819e-02f, 3.44677046e-02f, 1.10726738e-02f, -2.01809872e-02f, 4.46014218e-02f, -1.28637001e-01f,
  6.05101399e-02f, 2.32894167e-01f, -1.80963781e-02f, -1.26692906e-01f, -8.86282604e-03f, -4.08188775e-02f, 4.04775981e-03f, 1.41361319e-02f, 9.01513640e-03f, -2.81476323e-02f,
  -4.53138910e-03f, -1.80887226e-02f, -9.75487009e-03f, -1.65705327e-02f, 2.76877917e-02f, 2.50989683e-02f, -5.61411232e-02f, 5.39541915e-02f, -1.63651048e-03f, 1.53986141e-02f,
  -4.82818894e-02f, 4.12803665e-02f, 1.77113283e-02f, 3.97045305e-03f, -7.99354166e-02f, 1.61225349e-02f, 4.35457714e-02f, -4.65298290e-05f, -3.05875447e-02f, -2.45354371e-03f,
  -6.61951527e-02f, -2.13614374e-01f, 2.58939359e-02f, -3.08853120e-01f, -1.06203064e-01f, -3.26736480e-01f, -1.79556921e-01f, -1.13463596e-01f, -1.67402461e-01f, -2.45446593e-01f,
  1.35713667e-02f, -3.57558951e-02f, 4.12149638e-01f, -2.61012733e-01f, 2.35818490e-01f, 1.75632447e-01f, -4.59830523e-01f, -3.15467417e-01f, 1.23123065e-01f, -3.01329233e-02f,
  2.38086339e-02f, -8.49549845e-02f, 1.15318350e-01f, -9.07203928e-03f, -1.05748922e-01f, 1.88797414e-02f, 2.16705456e-01f, 2.92230487e-01f, -1.41880155e-01f, 5.76589182e-02f,
  -1.27036899e-01f, 6.90111071e-02f, -7.29916766e-02f, 7.42002428e-02f, -5.01966029e-02f, -1.02959901e-01f, -7.02692047e-02f, 1.89718530e-01f, 1.54326549e-02f, -8.68831761e-03f,
  1.19426809e-02f, 1.05016001e-01f, -2.27546636e-02f, 7.71792531e-02f, -6.52166232e-02f, 6.34714263e-03f, 2.38616839e-02f, -6.70666248e-02f, -1.22454334e-02f, 1.25378191e-01f,
  -3.01299077e-02f, -6.60528988e-02f, -1.00472055e-01f, -3.77931483e-02f, 5.07143699e-02f, 4.02613878e-02f, -1.15062930e-01f, -1.95117686e-02f, -1.00313179e-01f, -6.34175912e-02f,
  3.39204818e-02f, 6.70298235e-03f, 1.87768601e-02f, 6.71857595e-02f, 1.21929377e-04f, -9.71598271e-03f, -1.16472098e-03f, 3.90558280e-02f, 3.17769088e-02f, -8.41176417e-03f,
  -2.45711785e-02f, 2.57522184e-02f, 9.85396951e-02f, 1.69293117e-02f, -1.18055955e-01f, -6.66051283e-02f, 1.79121327e-02f, -4.30036373e-02f, -1.34853106e-02f, -3.46210152e-02f,
  9.85137373e-02f, -2.64924411e-02f, 1.91808529e-02f, 1.57127660e-02f, 5.84641136e-02f, 5.67709468e-02f, 5.03247008e-02f, 2.14650091e-02f, -7.46961311e-02f, -3.70711368e-03f,
  -1.21005587e-01f, -2.02979930e-02f, 1.07313041e-02f, 2.17549503e-02f, -2.82524363e-03f, -3.68888453e-02f, -9.82418582e-02f, -2.02735439e-02f, -2.32425909e-02f, 1.40711099e-01f,
  -1.20396152e-01f, -1.11174665e-01f, -1.53112337e-01f, 6.45743608e-02f, 5.87109961e-02f, -3.20093404e-03f, 9.08215716e-02f, -3.45986933e-02f, -9.56807956e-02f, 3.19468975e-02f,
  2.90935161e-03f, 9.63218790e-03f, -2.59537790e-02f, -1.57578588e-01f, -1.31227329e-01f, -1.76809765e-02f, 1.29138101e-02f, 7.44348159e-03f, 1.08940542e-01f, -7.04100309e-03f,
  5.54952443e-01f, 7.43042305e-02f, 8.95329490e-02f, 2.71174252e-01f, -1.32512702e-02f, -1.32823870e-01f, -5.44054136e-02f, 4.22096327e-02f, 1.09365925e-01f, -4.21712883e-02f,
  -7.46441409e-02f, 1.58522710e-01f, -4.29409683e-01f, 1.56385377e-01f, 1.72919631e-01f, -3.00572008e-01f, 2.26769909e-01f, 5.48934639e-02f, -3.49640287e-03f, 1.71325430e-01f,
  9.17383730e-02f, 2.65154362e-01f, 2.39142831e-02f, -2.37954650e-02f, 3.07359010e-01f, 1.24151468e-01f, 1.85115308e-01f, -1.76902756e-01f, 2.26045534e-01f, 6.34317026e-02f,
  1.99169695e-01f, 1.66147456e-01f, 2.74279946e-03f, -2.57639978e-02f, 6.00792207e-02f, -8.50915909e-02f, -6.00778544e-03f, -1.95379615e-01f, -5.02037890e-02f, -4.22277637e-02f,
  -1.05071202e-01f, -5.09435944e-02f, 7.83719793e-02f, -5.11052422e-02f, 5.07745221e-02f, 3.10616754e-02f, 4.46795300e-02f, 1.17555037e-01f, 3.74123380e-02f, 4.55992110e-02f,
  3.83904912e-02f, 4.25481461e-02f, 1.26022603e-02f, 6.68264627e-02f, 5.44991456e-02f, -1.90995857e-02f, 5.02525903e-02f, 1.50453616e-02f, 3.03625222e-02f, 5.71164489e-02f,
  5.03918305e-02f, -1.03772618e-01f, -5.42060249e-02f, -8.25575646e-03f, 5.13284728e-02f, 9.26881433e-02f, -3.17456499e-02f, -1.13479642e-03f, -5.26439920e-02f, 7.34112710e-02f,
  -1.30101200e-02f, 1.07109487e-01f, 3.78827825e-02f, -1.90963596e-02f, 4.71765809e-02f, 3.03116050e-02f, -7.47373998e-02f, 1.43681308e-02f, 8.66003409e-02f, -2.42925994e-02f,
  -1.84753370e-02f, 5.13799712e-02f, -4.02321070e-02f, -3.59678380e-02f, 3.44754867e-02f, -5.13871349e-02f, -3.14616747e-02f, 8.00551698e-02f, -4.87137176e-02f, -1.86421964e-02f,
  1.26210511e-01f, 1.88980192e-01f, 1.17608737e-02f, -2.71227583e-03f, -1.62412040e-02f, -8.83196145e-02f, -1.26201389e-02f, 2.99727954e-02f, 6.74034134e-02f, 1.67202763e-02f,
  1.77902225e-02f, 4.24106754e-02f, 1.05651058e-01f, -7.16665834e-02f, -1.47963762e-02f, 6.55234605e-02f, 8.22629221e-03f, 4.73974124e-02f, 3.11718564e-02f, -2.77708024e-02f,
  -1.90221425e-02f, -1.12985753e-01f, -1.96160655e-03f, 5.57255931e-02f, -1.65983029e-02f, 8.29950273e-02f, 7.34574348e-02f, -7.77263800e-03f, -7.56728351e-02f, 2.69201212e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.92901790e-01f, 1.55500034e-02f, -6.10149562e-01f, 2.36665636e-01f, -1.55854613e-01f, -1.23425417e-01f, -2.98048794e-01f, -6.47804290e-02f, -1.48134425e-01f, 2.76075244e-01f,
  3.52513105e-01f, -1.68048203e-01f, -2.28033796e-01f, 5.56951761e-01f, -5.27739823e-02f, 2.51200318e-01f, 3.97332907e-01f, 3.37708324e-01f, 1.09753542e-01f, -4.92369607e-02f,
  8.51143599e-02f, 6.26861989e-01f, 6.01839460e-03f, 2.74389148e-01f, 1.02690831e-01f, -1.38132097e-02f, 2.16899380e-01f, -2.98191875e-01f, 5.03170609e-01f, 2.32987419e-01f,
  -3.48915398e-01f, -3.01165849e-01f, -2.05670848e-01f, -1.98043734e-01f, -2.39161804e-01f, -2.14332774e-01f, -1.73270896e-01f, -8.25013034e-03f, -6.46834821e-02f, -6.13950752e-03f,
  -2.18511652e-02f, -1.53962094e-02f, 1.48212284e-01f, 9.71529633e-02f, -2.77764667e-02f, -3.85243073e-02f, -2.76503842e-02f, 3.27674448e-02f, -3.25620435e-02f, -4.60545011e-02f,
  -2.81966273e-02f, 2.04157576e-01f, -7.96917453e-02f, 1.59585118e-01f, -2.64636744e-02f, 9.67746601e-02f, -3.81845497e-02f, -6.08369745e-02f, -2.45653857e-02f, 2.64238697e-02f,
  1.33151689e-03f, 2.89975088e-02f, 1.86676178e-02f, 1.11886971e-01f, -3.19607966e-02f, 5.65888993e-02f, 8.23487416e-02f, 3.23222429e-02f, -1.06368445e-01f, -1.75346315e-01f,
  1.04442403e-01f, -4.67491969e-02f, -3.04869227e-02f, -2.88134324e-03f, 1.04430318e-02f, 7.58016929e-02f, -3.60318236e-02f, 1.35519296e-01f, -5.44113331e-02f, 6.39581382e-02f,
  8.12501553e-03f, -1.56958506e-01f, -6.49782345e-02f, 3.73332761e-03f, 2.15471126e-02f, -1.48864269e-01f, -1.90237295e-02f, -1.44710705e-01f, -8.80525410e-02f, 2.86047906e-03f,
  -4.94163603e-01f, -5.31825662e-01f, -3.26702669e-02f, 5.31684197e-02f, 1.56942625e-02f, 2.82816198e-02f, -1.01683490e-01f, 1.00144990e-01f, -1.71611026e-01f, -1.53850287e-01f,
  -8.76128227e-02f, 6.31733462e-02f, -4.37112562e-02f, 3.62244323e-02f, 4.59673740e-02f, -3.93887088e-02f, 5.29764295e-02f, -3.60693857e-02f, -2.09527323e-03f, 9.09505710e-02f,
  -7.62516446e-03f, -5.51841035e-02f, -6.57040402e-02f, 1.93683188e-02f, 1.88112915e-01f, -1.48857031e-02f, -5.41515462e-02f, 6.21379428e-02f, 4.18195836e-02f, 1.22217990e-01f,
  6.70422912e-01f, -3.60346466e-01f, -5.05870998e-01f, -1.90296888e-01f, 4.34091270e-01f, 2.74476379e-01f, -3.31886858e-01f, 2.07645848e-01f, 2.25998774e-01f, -5.55936992e-02f,
  2.62976587e-01f, -6.46935776e-02f, -3.63553673e-01f, 8.11916888e-02f, 2.57469445e-01f, -1.39865398e-01f, 1.54040949e-02f, 6.57790303e-02f, 1.06535465e-01f, 1.17931746e-01f,
  1.67276382e-01f, 3.95098329e-01f, -4.57942545e-01f, -4.15582322e-02f, -3.69127505e-02f, -1.53835431e-01f, 2.30732616e-02f, -3.99759978e-01f, -1.03254326e-01f, 4.55438830e-02f,
  3.21448818e-02f, 5.15090302e-02f, -1.66895077e-01f, -6.30557071e-03f, -5.24511002e-02f, -6.00959584e-02f, -9.69641656e-02f, -3.65277752e-02f, -5.72010018e-02f, -1.19540200e-01f,
  -1.07154973e-01f, 8.05908442e-02f, 1.31428465e-01f, -1.12157516e-01f, 1.16385497e-01f, -1.56550389e-02f, 1.43921405e-01f, 1.25221303e-02f, -5.71226403e-02f, 3.12046381e-03f,
  -1.75825488e-02f, 9.34074670e-02f, 1.30087122e-01f, -1.08876228e-01f, 5.34754507e-02f, 2.45880470e-01f, -1.03409514e-01f, -1.04878880e-01f, 1.14910239e-02f, 1.06301352e-01f,
  -5.95453791e-02f, -7.20306188e-02f, 5.88712581e-02f, -5.32384999e-02f, -9.70557183e-02f, 5.68404533e-02f, -9.86563042e-03f, -2.28066016e-02f, -8.13444555e-02f, 3.74556966e-02f,
  4.39680135e-03f, -7.83165917e-02f, 9.24302861e-02f, -9.04432163e-02f, -4.75969575e-02f, 4.73189354e-02f, 6.32247031e-02f, 1.97800994e-01f, -1.01459748e-03f, -2.04831604e-02f,
  -2.25524560e-01f, 5.43551631e-02f, 4.53850441e-02f, -3.54067273e-02f, -2.50700694e-02f, -7.78404847e-02f, 9.19590592e-02f, 1.00955933e-01f, -1.95603771e-03f, -9.01765972e-02f,
  -3.17170806e-02f, -1.22592732e-01f, -1.70777977e-01f, -3.26025337e-02f, -1.21369198e-01f, 2.45357692e-01f, -1.42188817e-01f, 2.30410710e-01f, -1.77167282e-01f, 1.79781884e-01f,
  1.61510348e-01f, -9.59970653e-02f, 1.98218688e-01f, 1.88941006e-02f, -1.58727899e-01f, 2.11390167e-01f, 4.15338092e-02f, 2.52396315e-02f, 9.39367041e-02f, 1.42682359e-01f,
  6.56849742e-02f, 9.70450863e-02f, -5.77415042e-02f, 1.54814363e-01f, 7.33827651e-02f, 1.80618372e-02f, 2.13213667e-01f, -7.49060512e-02f, -6.15992583e-03f, -1.90393510e-03f,
  -7.99574256e-01f, -7.73258209e-02f, 3.04802567e-01f, -3.09496403e-01f, 2.65034407e-01f, 4.31663811e-01f, -3.69062752e-01f, 2.53221542e-01f, -1.94945186e-01f, -3.09039861e-01f,
  -3.90329331e-01f, -2.72168458e-01f, -3.86131197e-01f, 1.66797876e-01f, 3.88340473e-01f, -8.22690651e-02f, 1.90244138e-01f, -9.32226777e-02f, 1.07768215e-01f, -9.12349597e-02f,
  5.78339808e-02f, -9.43623111e-02f, 1.96829557e-01f, 4.42646205e-01f, -4.56092618e-02f, 2.35558767e-02f, -1.26137763e-01f, 1.63058206e-01f, 2.56096154e-01f, 1.45053819e-01f,
  -9.95521341e-03f, -4.10156757e-01f, 6.29601907e-03f, 3.59613113e-02f, 3.50648686e-02f, -2.17671022e-01f, -1.03616410e-04f, 3.76755707e-02f, 5.03689982e-02f, 2.48125251e-02f,
  -1.88818127e-01f, 1.51891157e-01f, 6.40152544e-02f, -6.16249908e-03f, 4.85983416e-02f, 1.40432671e-01f, 1.15077682e-01f, -1.73218939e-02f, 4.58457805e-02f, 1.39904220e-03f,
  -1.03792153e-01f, 1.33818552e-01f, -2.74366490e-03f, -9.69475508e-03f, -4.12706174e-02f, 7.73405209e-02f, 1.26279816e-01f, 2.02348307e-02f, -6.46379497e-03f, 7.43638501e-02f,
  1.89122498e-01f, -3.96983884e-02f, -7.85541013e-02f, -7.75154904e-02f, 1.71878806e-03f, -1.10696014e-02f, -2.37036757e-02f, -3.68026569e-02f, 1.04753964e-01f, -1.20404903e-02f,
  6.57987669e-02f, -3.27522829e-02f, 5.47618568e-02f, -1.96145121e-02f, -8.21988583e-02f, -1.40453011e-01f, -4.59789224e-02f, -7.06883892e-02f, 3.68680321e-02f, 4.65060622e-02f,
  -1.38588727e-01f, 5.23604490e-02f, -1.78866342e-01f, 4.46125027e-03f, 1.30121917e-01f, -4.71146889e-02f, 1.59300212e-02f, -1.43802790e-02f, 2.24833027e-03f, -4.79881689e-02f,
  -2.39380077e-01f, -2.81594008e-01f, 1.07431989e-02f, -5.84316179e-02f, 6.66727424e-02f, 6.42646402e-02f, 7.30776936e-02f, -6.09185509e-02f, -1.19565530e-02f, -1.15258526e-02f,
  3.66672650e-02f, -3.87201011e-02f, -3.16308737e-02f, -5.09859473e-02f, 5.53075075e-02f, -3.09388898e-02f, -1.78296432e-01f, -6.85219169e-02f, 4.06892188e-02f, 8.77281204e-02f,
  -1.05581194e-01f, -4.44402210e-02f, 8.94128978e-02f, 4.11642604e-02f, -2.64904313e-02f, -4.32317816e-02f, -9.01947394e-02f, 9.89744440e-02f, 6.98172080e-04f, 8.63275528e-02f,
  2.82975405e-01f, 3.70795637e-01f, -3.10172886e-01f, -1.45356208e-01f, -4.24515218e-01f, -2.64394172e-02f, -2.32778803e-01f, -5.02071902e-02f, 4.17381704e-01f, 5.05282208e-02f,
  -4.10936326e-01f, 1.65646732e-01f, 5.02137281e-02f, -2.98629165e-01f, 3.91337365e-01f, 4.64131087e-01f, 1.05370462e-01f, 4.91417870e-02f, 2.82516003e-01f, -1.13750525e-01f,
  1.20077506e-01f, -2.65398920e-01f, -3.15418482e-01f, -1.88606158e-01f, -3.97224337e-01f, -2.18283191e-01f, -1.75471470e-01f, -1.95429206e-01f, -2.52386183e-01f, 2.58339383e-02f,
  2.09738240e-02f, 2.17774227e-01f, -7.62696266e-02f, 1.87514633e-01f, -1.72571372e-02f, -1.25297219e-01f, -1.17370412e-01f, -6.36284798e-02f, 9.19754268e-04f, -7.71606015e-03f,
  1.25491828e-01f, 4.57576066e-02f, 4.66189682e-02f, -4.02545035e-02f, -7.46658295e-02f, -1.02671668e-01f, 2.17288174e-02f, -1.09517507e-01f, -1.61537915e-01f, -3.36754583e-02f,
  -1.72619283e-01f, 3.44881639e-02f, -1.49032071e-01f, 1.05442539e-01f, -1.12005947e-02f, -1.99770126e-02f, -1.27369061e-03f, -7.78988600e-02f, 2.60954127e-02f, 1.00145914e-01f,
  -1.30074983e-02f, 8.00864324e-02f, 2.38452777e-02f, -1.08128339e-01f, 1.11320518e-01f, -3.11625656e-02f, -1.87600311e-02f, -1.23394690e-01f, 1.01955488e-01f, -9.02157798e-02f,
  -1.83633640e-02f, -3.77737582e-02f, 6.30333945e-02f, -3.97608895e-03f, 6.23974726e-02f, -1.09580560e-02f, -7.40524456e-02f, 1.19215306e-02f, 1.09001296e-02f, -2.56507620e-02f,
  -1.88483261e-02f, 8.43957886e-02f, 4.24869321e-02f, -1.79252595e-01f, 2.36015283e-02f, -3.23393941e-02f, 3.31858397e-02f, 4.20752987e-02f, -1.56354159e-03f, -1.71234552e-02f,
  1.64516911e-01f, 4.05118316e-01f, 4.02405038e-02f, 1.11405246e-01f, 9.42848027e-02f, 1.17985032e-01f, 8.13038647e-02f, 1.88042764e-02f, 1.29523352e-01f, 1.51644945e-01f,
  1.82097759e-02f, -1.74098127e-02f, 5.12792654e-02f, -4.00183648e-02f, 2.65158676e-02f, 2.66543813e-02f, -1.34058413e-04f, 1.50813669e-01f, -5.40658571e-02f, -1.75011903e-02f,
  -1.03825830e-01f, 1.28462866e-01f, 9.89240929e-02f, -7.37946294e-03f, -6.30446300e-02f, 3.91922109e-02f, 3.86368968e-02f, 1.97170116e-03f, -9.53486003e-03f, -5.00095412e-02f,
  -2.70890474e-01f, 2.52233475e-01f, -8.56389031e-02f, 7.57099241e-02f, 3.48473378e-02f, -6.33083701e-01f, -4.61768478e-01f, -7.79110566e-02f, -1.71609074e-01f, 1.46360755e-01f,
  -8.44109207e-02f, 3.54150206e-01f, -4.66403574e-01f, -2.40947232e-01f, -6.11045122e-01f, -5.56094229e-01f, -2.73173988e-01f, -6.49458691e-02f, -1.08504035e-01f, -2.60140281e-02f,
  -2.57016778e-01f, -4.47437614e-02f, -2.94605136e-01f, 3.27179521e-01f, 2.17125341e-01f, 3.57219040e-01f, 4.52469498e-01f, 3.00674230e-01f, 3.74327689e-01f, 9.31878835e-02f,
  -2.07834154e-01f, -1.46247391e-02f, 1.14747867e-01f, 6.34060875e-02f, -6.11056713e-03f, 3.19874883e-02f, -3.79279591e-02f, -1.52245816e-02f, 3.51636373e-02f, 9.49252471e-02f,
  3.78542244e-02f, 1.04872681e-01f, 1.11218177e-01f, 2.06101477e-01f, 1.94168556e-02f, 2.05173478e-01f, -1.25822229e-02f, -4.74796593e-02f, 1.10881932e-01f, 4.00351398e-02f,
  -7.65734315e-02f, -7.40712956e-02f, 1.05935737e-01f, -8.32029358e-02f, -2.70778444e-02f, -5.17314412e-02f, 9.78279300e-03f, 1.33328497e-01f, 6.69279099e-02f, 2.32754230e-01f,
  -1.14362575e-01f, 9.08995718e-02f, 1.21303927e-03f, 5.55571690e-02f, -1.53085841e-02f, 3.23142074e-02f, 7.08897831e-03f, -4.29555215e-03f, 8.56427327e-02f, -1.90522894e-03f,
  1.22684270e-01f, -6.43251091e-02f, 4.60727103e-02f, 7.50257075e-02f, 5.16234245e-03f, -6.30789697e-02f, -1.08215749e-01f, 1.81513298e-02f, -1.23808615e-01f, 1.30146602e-02f,
  1.41495973e-01f, -8.84308517e-02f, 1.23760656e-01f, 1.79406330e-02f, -1.39752135e-01f, 2.51511149e-02f, 1.51296780e-01f, -1.00780979e-01f, -2.92240083e-02f, 4.95844893e-02f,
  -6.44318014e-02f, 2.52893895e-01f, 3.94856073e-02f, -5.63235320e-02f, 1.35074893e-03f, 5.59460521e-02f, -9.07365903e-02f, 8.70591588e-03f, -3.97136919e-02f, -8.69935285e-03f,
  -1.64546698e-01f, -4.20845151e-02f, 1.00114495e-01f, 4.47254553e-02f, -5.38508706e-02f, -8.68153945e-02f, -2.14552041e-02f, 1.05913252e-01f, 1.27704069e-01f, 2.02260494e-01f,
  2.20450759e-01f, 9.11539793e-02f, -1.21338323e-01f, -1.85215045e-02f, 6.83815852e-02f, -3.07687856e-02f, 1.16604567e-01f, 1.65624672e-03f, 1.68943629e-01f, 9.11181495e-02f,
  4.09152657e-01f, -2.78865416e-02f, -7.20001236e-02f, 2.92379260e-01f, 4.30907160e-01f, 5.46329260e-01f, 5.02033114e-01f, 4.24255133e-01f, 7.06959963e-01f, -8.03691968e-02f,
  2.14542150e-02f, -2.19221607e-01f, -2.43020907e-01f, 1.97691292e-01f, 7.49573037e-02f, 1.75877869e-01f, 4.08687025e-01f, 2.31708497e-01f, 4.07441348e-01f, 1.30264610e-01f,
  1.33917943e-01f, 2.43907779e-01f, -3.70374084e-01f, -4.84880209e-02f, 1.03428543e-01f, -8.10142756e-02f, -4.68331784e-01f, -6.16567209e-02f, -3.20642740e-01f, 8.74230936e-02f,
  7.46728405e-02f, 1.56525180e-01f, -1.57667622e-02f, -1.12308204e-01f, 3.98159437e-02f, 5.56586217e-03f, -1.45913363e-01f, -1.60071433e-01f, 1.61966942e-02f, -1.00839119e-02f,
  2.40350254e-02f, -3.00593488e-03f, 3.20722312e-02f, 3.51590179e-02f, 1.71798274e-01f, -6.39065281e-02f, -3.24516818e-02f, -3.24472273e-03f, -7.37709552e-02f, 5.03097810e-02f,
  3.44756432e-03f, -1.64766759e-02f, 1.57716274e-02f, 8.01816061e-02f, -8.73134062e-02f, 1.10737376e-01f, 5.38006909e-02f, 3.83580327e-02f, -4.71385680e-02f, 1.59346715e-01f,
  -3.81986313e-02f, 1.68132484e-01f, 3.43924202e-02f, -3.26807350e-02f, -3.46808732e-02f, 1.99678000e-02f, -8.06342959e-02f, -2.37095971e-02f, 3.14782956e-03f, 4.22743941e-03f,
  4.05605845e-02f, 2.36295853e-02f, 1.16693676e-01f, 5.31734750e-02f, 6.48966879e-02f, 6.51445836e-02f, -7.75225610e-02f, -5.80374058e-03f, 6.64198026e-02f, 2.83808969e-02f,
  6.81891516e-02f, -4.45698947e-03f, -1.03814602e-01f, -1.61314517e-01f, 3.95460539e-02f, -1.40539408e-02f, 7.74670690e-02f, 7.25694327e-03f, 2.26837974e-02f, -4.17261235e-02f,
  1.46435887e-01f, 3.90946567e-01f, -1.23745305e-02f, -1.83330867e-02f, -8.44046250e-02f, -2.39444561e-02f, 8.49942714e-02f, 1.47396520e-01f, 1.28186986e-01f, 1.07619956e-01f,
  -3.86077054e-02f, 3.40072513e-02f, -5.35926446e-02f, 2.03937013e-02f, -8.16752315e-02f, 1.79039296e-02f, -2.69005783e-02f, 3.77524123e-02f, 2.29437910e-02f, -6.21634051e-02f,
  -1.55630365e-01f, 9.02683102e-03f, 2.96262074e-02f, 7.17749149e-02f, 4.08563428e-02f, -1.05396926e-01f, 5.23400418e-02f, -2.45108791e-02f, -9.63019803e-02f, -3.62967700e-03f,
  6.94556773e-01f, -5.27007163e-01f, 2.09094763e-01f, 1.23801365e-01f, 3.17715883e-01f, 5.49915284e-02f, 3.69088948e-01f, -2.84709394e-01f, -7.13043585e-02f, -5.14347255e-01f,
  -1.46874994e-01f, -2.03495026e-01f, 2.26079077e-01f, -4.74966884e-01f, 4.94157374e-01f, 6.97642341e-02f, -3.40043485e-01f, -2.74219930e-01f, 9.55355018e-02f, -2.41194829e-01f,
  4.17228527e-02f, -4.63757813e-01f, 3.75107192e-02f, -4.65890408e-01f, -2.54316861e-03f, -2.50797212e-01f, -1.84168801e-01f, 6.83760867e-02f, -5.08566558e-01f, -1.57278329e-02f,
  1.14714049e-01f, 1.03595428e-01f, 1.65030867e-01f, -1.04525335e-01f, -2.04973537e-02f, 1.00837053e-04f, -3.25288810e-02f, 3.15839387e-02f, 1.03571206e-01f, 5.29197678e-02f,
  -4.57341708e-02f, 2.34685000e-02f, -1.08250767e-01f, 1.05707064e-01f, 3.72253507e-02f, -5.48117310e-02f, 8.85311048e-03f, 1.40559942e-01f, 1.35316262e-02f, 1.52048960e-01f,
  1.68075740e-01f, 5.93714677e-02f, 1.85804978e-01f, -1.51984259e-01f, 6.31549433e-02f, 6.70595234e-03f, 5.06487824e-02f, 2.96964291e-02f, -5.56434244e-02f, -5.74745573e-02f,
  -2.17475742e-02f, 5.76589517e-02f, 1.08468428e-01f, -4.71692979e-02f, 1.32488564e-01f, 8.34010169e-02f, -1.24347165e-01f, -7.58543983e-02f, 1.80955585e-02f, 1.19582653e-01f,
  -3.72906663e-02f, 2.53642630e-03f, -4.64173481e-02f, 3.73639464e-02f, 2.15630140e-02f, 1.02619484e-01f, -3.17991915e-04f, -1.35646343e-01f, 4.46599424e-02f, 7.69440904e-02f,
  6.61415383e-02f, -1.27181873e-01f, 3.11994813e-02f, -5.07088825e-02f, 1.13607990e-02f, 1.06502905e-01f, -7.06572831e-02f, 1.00368671e-01f, 3.44138294e-02f, -3.87421735e-02f,
  -5.90202548e-02f, -5.98602116e-01f, -4.62536439e-02f, -1.13568038e-01f, -1.04312144e-01f, -8.21049362e-02f, -7.04816952e-02f, -2.72286236e-01f, -1.60830453e-01f, 3.63355540e-02f,
  -1.76607147e-01f, -5.52478842e-02f, -4.09580357e-02f, 2.43105721e-02f, -1.83424190e-01f, -4.95438650e-03f, -1.20584242e-01f, -4.84563969e-02f, -5.50148599e-02f, -2.15680644e-01f,
  -1.10882550e-01f, -9.21532512e-02f, 3.43269259e-02f, 4.36725654e-03f, -2.43651778e-01f, 7.87712913e-03f, -5.10922894e-02f, 3.71771231e-02f, -8.33429280e-04f, -1.99369639e-01f,
  -1.27418235e-01f, 3.69496077e-01f, -4.48860794e-01f, 4.05687779e-01f, -4.10635918e-01f, 5.37117362e-01f, 5.86453557e-01f, -1.52713824e-02f, 2.59279519e-01f, 4.11351740e-01f,
  2.51933217e-01f, 1.41905874e-01f, 1.81186005e-01f, 5.94593227e-01f, 1.14028692e-01f, 5.07721364e-01f, 4.53090280e-01f, 3.71225297e-01f, -5.51311038e-02f, 3.05073231e-01f,
  -3.11496649e-02f, 4.46953565e-01f, -1.00146390e-01f, -5.77484965e-02f, -9.97094810e-03f, -3.06376159e-01f, -9.79808122e-02f, -3.55762899e-01f, 2.15228684e-02f, -1.36200622e-01f,
  1.25378609e-01f, 1.90917123e-02f, -7.53636360e-02f, -1.07083127e-01f, -2.84552630e-02f, -5.86458407e-02f, -9.41035226e-02f, -1.55772224e-01f, -1.60780132e-01f, 2.67777983e-02f,
  1.10103963e-02f, -4.59241606e-02f, 1.05239622e-01f, -6.60536885e-02f, -1.55313816e-02f, -4.98635843e-02f, -4.76641469e-02f, -1.20493189e-01f, 1.23675801e-02f, -3.33382301e-02f,
  -2.52449922e-02f, 3.17980126e-02f, 1.21088393e-01f, 1.79667920e-02f, -6.47292882e-02f, 5.23543172e-02f, 4.47823964e-02f, -7.72975162e-02f, 6.85705990e-02f, 4.90526780e-02f,
  -1.91274378e-02f, 8.98505226e-02f, 3.41868028e-02f, -6.76667020e-02f, -8.50581285e-03f, -7.11580291e-02f, 8.70993882e-02f, -4.24008034e-02f, -1.46538347e-01f, 1.08425789e-01f,
  -3.17899287e-02f, -9.89642814e-02f, 5.40470071e-02f, 5.93749061e-03f, 3.79918404e-02f, 5.59185557e-02f, -1.52869195e-01f, -5.41993976e-02f, 4.30464074e-02f, -8.71555135e-02f,
  4.34121815e-03f, 8.34063888e-02f, -1.43468790e-02f, -6.37912750e-02f, 6.78806454e-02f, -6.68325648e-02f, 9.10335109e-02f, -9.44187050e-04f, -3.91745428e-03f, -5.90024665e-02f,
  2.58449376e-01f, 3.98024619e-01f, 1.34930506e-01f, -1.91554185e-02f, 6.87917545e-02f, -8.69252253e-03f, 1.03667147e-01f, -2.75659114e-02f, 6.04443140e-02f, 3.14644910e-02f,
  8.41346662e-03f, 1.05852962e-01f, 2.14202106e-02f, -1.49214389e-02f, 2.87458617e-02f, 5.26208803e-02f, 1.53538913e-01f, -6.45370930e-02f, 6.58640191e-02f, -5.53671941e-02f,
  -2.22430937e-02f, 6.41738474e-02f, -2.91560832e-02f, -2.59502754e-02f, 7.60767534e-02f, 2.16173790e-02f, -5.21507999e-03f, -4.76569645e-02f, -5.78047372e-02f, 1.02738328e-01f,
  -6.15473092e-01f, 5.69657207e-01f, 2.92393953e-01f, -2.95122355e-01f, 3.12371522e-01f, 5.37600368e-03f, -7.12617934e-02f, 2.37939984e-01f, -1.78491753e-02f, 1.89606979e-01f,
  7.46847913e-02f, 3.48934084e-01f, 1.25396714e-01f, -1.64814502e-01f, -5.00751495e-01f, -2.62140840e-01f, -4.41381872e-01f, -2.42383540e-01f, -5.34454063e-02f, -1.59730747e-01f,
  -1.40376315e-01f, -1.44581899e-01f, -2.31253371e-01f, 2.81042308e-01f, 5.67205884e-02f, 6.03675768e-02f, -3.49889219e-01f, 2.96402782e-01f, -1.31901145e-01f, 2.04868615e-01f,
  8.50914698e-03f, 2.41160199e-01f, 1.09994985e-01f, 1.56475127e-01f, -1.21245794e-01f, 3.01051121e-02f, -1.15946405e-01f, 2.87489612e-02f, -5.21191396e-02f, -5.76999299e-02f,
  7.31918588e-02f, 1.77663475e-01f, -3.47833894e-02f, 4.97090034e-02f, 7.65513256e-02f, 5.58717996e-02f, 9.88234505e-02f, -9.85388365e-03f, 1.58873096e-01f, 1.31424638e-02f,
  1.87258646e-01f, 5.00851497e-02f, -2.90653519e-02f, -7.31859058e-02f, 4.73374426e-02f, 8.47494677e-02f, -4.67407331e-03f, 3.34122367e-02f, 5.62380394e-03f, -2.35389564e-02f,
  -1.81291674e-04f, -2.35549524e-01f, 3.69055197e-02f, -2.45250296e-02f, 3.78585234e-02f, 8.36784020e-02f, -7.16982335e-02f, -9.20416862e-02f, -1.43019091e-02f, 1.16308257e-02f,
  -3.88902575e-02f, 3.28796171e-02f, -2.09673345e-02f, -2.37990618e-01f, -5.23560084e-02f, -7.29110539e-02f, 2.01242454e-02f, 6.58582002e-02f, -1.63156942e-01f, -1.06794290e-01f,
  -6.82922453e-02f, -2.91806087e-02f, 6.17894121e-02f, -8.33258331e-02f, -4.00427766e-02f, -3.01873051e-02f, -9.21236798e-02f, 6.92624524e-02f, -1.20996550e-01f, -1.41761258e-01f,
  -2.72773296e-01f, -8.09305385e-02f, 5.11960760e-02f, 8.19161981e-02f, 4.20666561e-02f, -1.54563291e-02f, -1.13035642e-01f, -5.54425418e-02f, -1.39021292e-01f, 7.90948421e-02f,
  1.04754210e-01f, -1.66982487e-02f, -2.01835930e-02f, -2.60488316e-02f, -3.40039395e-02f, -1.69775710e-01f, 1.40458811e-02f, 4.22066636e-02f, -1.30376175e-01f, -1.00574501e-01f,
  -8.97501688e-03f, -1.73999909e-02f, 4.75747101e-02f, -3.22349928e-02f, -1.39259815e-01f, -2.56618280e-02f, -3.26474570e-02f, 1.36881813e-01f, 2.74420623e-02f, 2.00898363e-03f,
  1.42858401e-01f, 1.91400707e-01f, -2.10389286e-01f, -6.96843639e-02f, -1.35920718e-01f, 6.25606328e-02f, -2.39901021e-01f, 9.60064158e-02f, -4.06981558e-01f, 2.01817229e-01f,
  2.03803718e-01f, -1.40317738e-01f, 9.82725993e-02f, 1.78906396e-01f, -1.32740378e-01f, -4.84238937e-03f, 2.68537551e-01f, 1.05533443e-01f, 3.73766082e-03f, 3.55707347e-01f,
  2.55460948e-01f, 2.79864222e-01f, 1.24454625e-01f, 3.45207781e-01f, 2.92182475e-01f, 2.73322701e-01f, 3.42972428e-01f, -9.85768437e-02f, 3.26191872e-01f, -1.76435784e-01f,
  -3.06126382e-02f, 3.06364335e-02f, -2.51043160e-02f, -1.53231829e-01f, 1.45474285e-01f, 1.66005075e-01f, 9.50640142e-02f, -1.78624559e-02f, -1.54468045e-01f, 6.19230047e-02f,
  -3.48842591e-02f, -3.58803645e-02f, 6.69036806e-02f, -8.62572789e-02f, -7.77316764e-02f, -7.70349279e-02f, -1.10047519e-01f, -8.49923268e-02f, -1.27584025e-01f, 1.72675952e-01f,
  -6.39547333e-02f, -4.92074676e-02f, 1.08592920e-02f, -1.33072570e-01f, -1.10104688e-01f, -8.83965269e-02f, -1.62077080e-02f, 4.91146296e-02f, 2.49809958e-02f, -4.35104929e-02f,
  1.59432217e-01f, 4.53339294e-02f, 1.38450593e-01f, -7.56249055e-02f, 2.62085441e-02f, -2.17855554e-02f, -1.17473401e-01f, -3.96383330e-02f, 2.34947912e-02f, 1.05686612e-01f,
  8.22907966e-03f, 7.19079226e-02f, -1.08814791e-01f, 1.68248624e-01f, 5.68845384e-02f, -5.13315201e-04f, -2.35296451e-02f, -4.50514350e-03f, 9.37998816e-02f, 3.91257228e-03f,
  -1.71686426e-01f, -7.06218882e-03f, 1.01881884e-01f, -7.20074996e-02f, -1.89348795e-02f, 9.62474421e-02f, 8.46836492e-02f, 4.81242724e-02f, -4.77049984e-02f, -1.79747827e-02f,
  1.31193399e-01f, 3.52579117e-01f, 1.84068661e-02f, -5.66981025e-02f, -2.78307591e-02f, 4.95880507e-02f, 1.18133230e-02f, 6.53654709e-02f, 1.21868029e-01f, 6.69743940e-02f,
  1.75711945e-01f, -9.26390477e-03f, 1.41783535e-01f, 5.64581603e-02f, -1.71817258e-01f, 1.39990836e-01f, 3.99985798e-02f, -8.74325261e-02f, -2.58964673e-03f, 1.83711976e-01f,
  1.68175681e-03f, 1.33093238e-01f, -5.73378913e-02f, -1.72513217e-01f, -2.67061647e-02f, -1.39364053e-03f, 4.26162519e-02f, -1.60050690e-02f, 3.30168828e-02f, -1.53235793e-01f,
  -9.11388576e-01f, 4.17277992e-01f, -1.52215689e-01f, -2.87746191e-01f, -1.40560895e-01f, -1.94540806e-02f, -1.19811073e-01f, -8.37668777e-03f, -9.65308845e-02f, 2.50117391e-01f,
  2.84196585e-02f, -2.36580357e-01f, 3.88595641e-01f, 1.72693864e-01f, -3.03902358e-01f, 4.21976179e-01f, 7.90770072e-03f, -1.29508346e-01f, 1.75876781e-01f, -2.77276903e-01f,
  -8.89206976e-02f, -7.76986703e-02f, 3.14679299e-03f, 1.36367142e-01f, -3.50814223e-01f, -2.32887089e-01f, -1.56393394e-01f, 7.67334178e-02f, -7.00645745e-02f, -3.48846912e-02f,
  -6.10633314e-01f, -3.90296340e-01f, -4.16888207e-01f, -2.26360127e-01f, -2.51612037e-01f, -1.28738359e-01f, -1.62155792e-01f, -3.88172083e-02f, -1.02126814e-01f, 1.35305384e-02f,
  -2.35544164e-02f, 3.72293498e-03f, -6.65100217e-02f, 6.51265532e-02f, -1.31699026e-01f, -9.72181410e-02f, 1.47596091e-01f, 4.76502925e-02f, -1.90965403e-02f, 1.04831234e-01f,
  1.05090424e-01f, 7.75933415e-02f, -3.11484169e-02f, 3.60786803e-02f, -3.89791839e-02f, -1.70937348e-02f, 2.16975287e-02f, -7.28181154e-02f, -2.19760150e-01f, -8.75925273e-02f,
  1.38174957e-02f, 4.83677089e-02f, -5.73087558e-02f, 3.76633368e-02f, 2.07146890e-02f, 9.17604715e-02f, 4.16589938e-02f, -2.06361897e-02f, 5.85426614e-02f, 6.31320402e-02f,
  4.86629084e-02f, -1.00922160e-01f, -7.87768066e-02f, 4.69038710e-02f, -2.79236920e-02f, -1.49355996e-02f, -9.01010931e-02f, -6.57309219e-02f, 6.72677755e-02f, -8.70130807e-02f,
  -1.04010798e-01f, 9.75937769e-02f, 5.84489331e-02f, 3.18814116e-03f, -1.96766038e-03f, 1.23632303e-03f, 7.72628840e-03f, 9.57593322e-02f, -6.35237396e-02f, -3.38510722e-02f,
  -8.25167775e-01f, -5.56584597e-01f, -1.49007127e-01f, -1.49191618e-01f, -1.25339389e-01f, -8.24145824e-02f, 1.42580103e-02f, -6.71490235e-03f, -1.01322390e-01f, -1.42493919e-01f,
  -7.36755803e-02f, 7.38602690e-03f, -8.99297819e-02f, 4.71947826e-02f, 3.29931974e-02f, 2.40091234e-02f, -1.30870879e-01f, -9.99009460e-02f, -1.38441876e-01f, -1.13540195e-01f,
  -7.85528943e-02f, -3.62270586e-02f, 9.04415846e-02f, 2.64257547e-02f, 2.25387700e-03f, -9.91846994e-02f, -8.06843936e-02f, 1.17342591e-01f, -7.15559274e-02f, 1.20073535e-01f,
  -5.80493450e-01f, 2.99204826e-01f, 4.94471006e-02f, -5.32402337e-01f, 2.52063185e-01f, -1.02362230e-01f, -5.27546763e-01f, 3.38006824e-01f, 1.40339077e-01f, -1.11319371e-01f,
  -1.50118083e-01f, -2.40589395e-01f, 3.38661283e-01f, -4.29170996e-01f, 6.77806213e-02f, 1.25957325e-01f, -4.64213282e-01f, -3.45282018e-01f, 1.98470563e-01f, -2.75620043e-01f,
  -3.26449536e-02f, -2.16497838e-01f, -7.08010197e-02f, 3.73527527e-01f, -1.87900141e-01f, 8.43508542e-03f, -2.44590104e-01f, 2.94401318e-01f, -2.93230116e-01f, 2.29044437e-01f,
  -3.80342752e-01f, -1.64884850e-01f, -7.71847367e-02f, 3.72613706e-02f, -1.04039229e-01f, -1.00852542e-01f, -6.34829402e-02f, 1.02510907e-01f, -6.93569109e-02f, 1.32148504e-01f,
  -2.82513741e-02f, 9.84776914e-02f, 2.47318484e-02f, 1.85384542e-01f, 3.55103426e-02f, 1.43018961e-01f, 8.89715366e-03f, -8.36538300e-02f, 6.87894598e-02f, 8.90989900e-02f,
  2.21444611e-02f, 4.67720479e-02f, -1.32612810e-01f, -3.36648598e-02f, 6.07143492e-02f, -1.37259111e-01f, -4.07316424e-02f, -7.78688677e-03f, -1.37891760e-02f, 1.53706409e-02f,
  7.69274458e-02f, 7.60327354e-02f, -2.80722361e-02f, 9.37278643e-02f, -5.95128816e-03f, 6.30230829e-02f, -2.87630185e-02f, 3.51820886e-02f, 1.87052730e-02f, -2.80523337e-02f,
  -1.86262634e-02f, -6.76575378e-02f, 8.64693299e-02f, -6.35222197e-02f, -1.76504850e-01f, -5.16205579e-02f, -2.36341327e-01f, 6.75615817e-02f, 6.23036958e-02f, -9.77196172e-03f,
  5.52841052e-02f, 4.64948192e-02f, 8.67119655e-02f, 7.31853694e-02f, -5.41397333e-02f, 4.22695130e-02f, 6.76232725e-02f, 4.24615517e-02f, 9.62954387e-02f, 4.99409772e-02f,
  -4.98242885e-01f, -2.81098902e-01f, -4.88035753e-02f, -1.35777267e-02f, -1.85284652e-02f, 7.01895391e-04f, -5.14689228e-03f, 1.02473699e-01f, -3.50486785e-02f, 5.37749473e-03f,
  -2.28596628e-02f, -7.98573121e-02f, -2.03851312e-02f, -5.24855666e-02f, -1.29353568e-01f, -1.04046203e-02f, -2.74232388e-01f, -1.70279056e-01f, -1.84902921e-01f, 9.31980088e-02f,
  -4.49251458e-02f, -1.13009298e-02f, -8.03273823e-03f, -1.08701922e-02f, -1.15217641e-01f, -2.15586841e-01f, -3.68496180e-02f, 7.76454136e-02f, -2.03641597e-02f, -1.66569855e-02f,
  -6.04597367e-02f, 3.37516777e-02f, 4.44109887e-02f, 1.10917702e-01f, -1.17335044e-01f, -2.57607937e-01f, -2.25038275e-01f, 3.00257862e-01f, -2.78739333e-01f, -6.17974326e-02f,
  7.28898495e-02f, -4.00063276e-01f, 2.62817740e-02f, -2.12943017e-01f, 1.93900868e-01f, -2.30291262e-01f, 8.37353095e-02f, -1.19756386e-01f, 1.87163398e-01f, 3.39682609e-01f,
  3.61116409e-01f, 1.35073587e-01f, 4.72032130e-01f, 4.60684270e-01f, 2.58224368e-01f, 3.70092630e-01f, 3.61879617e-01f, 3.25740993e-01f, 3.70060414e-01f, -1.22942239e-01f,
  -1.97454005e-01f, 8.12604744e-03f, -3.41427736e-02f, -2.81556904e-01f, 4.15790379e-01f, -2.39931606e-02f, 1.31191798e-02f, -1.32771969e-01f, 4.15899372e-03f, 4.64751646e-02f,
  -2.62364512e-03f, -1.50607675e-02f, -1.17000483e-01f, -9.06124115e-02f, -1.19791059e-02f, -4.36563231e-02f, 1.14984639e-01f, 2.19737310e-02f, -1.60853378e-02f, 2.84568989e-03f,
  5.87813184e-02f, -9.86312255e-02f, -1.13732755e-01f, 1.28325289e-02f, -7.89019465e-03f, 4.09463607e-02f, -5.75952977e-02f, 1.08121894e-01f, -1.24210864e-01f, 1.16254151e-01f,
  1.66273370e-01f, -2.81056594e-02f, -6.08111545e-02f, -1.25999779e-01f, -9.73970741e-02f, -1.77063625e-02f, -8.21706876e-02f, 6.60364255e-02f, -4.20382507e-02f, 8.38325247e-02f,
  6.63205534e-02f, 8.45221654e-02f, -1.18044898e-01f, -7.22014010e-02f, -1.97588522e-02f, -1.08185135e-01f, 6.94204168e-03f, -9.77191105e-02f, 2.94545852e-02f, -9.22629833e-02f,
  -1.23830818e-01f, 9.10614710e-03f, 3.35336961e-02f, 1.55310230e-02f, -1.69630989e-01f, 1.18138092e-02f, 3.62625755e-02f, -3.65645029e-02f, 5.24799526e-02f, 1.51206017e-01f,
  1.38094351e-01f, 3.00978214e-01f, 5.45571223e-02f, -8.63287523e-02f, -9.70769301e-03f, 4.48914655e-02f, -1.89484611e-01f, -3.97225618e-02f, 6.61549643e-02f, 3.78800407e-02f,
  2.95307338e-01f, 1.18369311e-01f, -1.71527248e-02f, -9.22678597e-03f, 6.87045306e-02f, 1.40125453e-01f, 4.11875434e-02f, -2.45092213e-02f, 1.22715700e-02f, 1.72777876e-01f,
  -5.85224107e-03f, 8.03613365e-02f, 3.60611342e-02f, 6.74178004e-02f, 5.23317121e-02f, 3.16607766e-02f, 7.94829726e-02f, 8.31615925e-02f, 8.91226530e-02f, -2.29235236e-02f,
  -2.65233934e-01f, 2.83840054e-04f, 5.17895043e-01f, -5.64141154e-01f, 1.34841338e-01f, 6.25318408e-01f, 2.18774527e-01f, -1.51811661e-02f, -3.33281517e-01f, -2.77322561e-01f,
  -1.44917652e-01f, -1.28267193e-02f, 2.07946077e-01f, -2.98482180e-01f, 7.05185056e-01f, 1.96950048e-01f, -2.65478939e-01f, -2.30711579e-01f, 9.17599052e-02f, -1.27596617e-01f,
  -3.99109498e-02f, -3.34582001e-01f, 2.42517576e-01f, -1.08427674e-01f, 9.24708694e-03f, -2.26331189e-01f, -4.20371175e-01f, 3.43460143e-01f, -3.24611574e-01f, 2.14566708e-01f,
  7.44275004e-02f, -2.38699540e-01f, 6.72035366e-02f, 8.97720233e-02f, 1.70819595e-01f, 2.58706138e-02f, -4.08153310e-02f, 1.57834113e-01f, -1.48647696e-01f, 2.00625486e-03f,
  -1.11909481e-02f, -2.80108619e-02f, -8.62844959e-02f, 1.15641579e-01f, -7.91996345e-02f, -4.59800810e-02f, 5.27691431e-02f, 8.67545828e-02f, -4.81866375e-02f, 1.84791565e-01f,
  1.17697157e-01f, 4.34737355e-02f, -9.17382017e-02f, -1.86191633e-01f, 4.83138338e-02f, 1.14083672e-02f, -3.68295759e-02f, 1.44683525e-01f, 6.77974941e-03f, -8.32000002e-02f,
  -1.08539186e-01f, 5.43862134e-02f, 9.14797410e-02f, 2.30353493e-02f, 1.69854656e-01f, -3.76922525e-02f, -3.27972672e-03f, 1.32652754e-02f, -2.11498886e-02f, 3.06412671e-03f,
  -1.18078202e-01f, -6.38105720e-02f, -8.29828456e-02f, -1.12226106e-01f, -7.83191770e-02f, -1.16212532e-01f, 3.86143774e-02f, -7.13027269e-02f, 5.12747234e-03f, 1.08116135e-01f,
  -8.14337209e-02f, -2.60288455e-02f, -9.81318858e-03f, -1.41741082e-01f, -1.49807408e-02f, 3.83375213e-02f, -1.37614027e-01f, 5.67144528e-02f, -7.67834485e-02f, 2.12473795e-01f,
  1.04844384e-01f, -1.85464039e-01f, -4.83741947e-02f, -8.36577937e-02f, 2.99044941e-02f, 1.50919288e-01f, -3.28454338e-02f, 8.84156674e-02f, -4.98786308e-02f, -5.52057587e-02f,
  -1.06259875e-01f, -1.21027239e-01f, -1.16470316e-02f, 6.47156909e-02f, 1.42918387e-02f, 1.03352211e-01f, -1.37928680e-01f, -5.26030734e-02f, 3.36813331e-02f, -1.16043137e-02f,
  3.79576832e-02f, -2.47446567e-01f, -3.63407545e-02f, -1.35462061e-01f, -1.35774210e-01f, -2.97945905e-02f, -4.96239215e-02f, -4.90822159e-02f, 3.52738090e-02f, -2.50275452e-02f,
  -1.31484240e-01f, 4.93707806e-01f, 6.08483255e-01f, 2.91266859e-01f, -3.42495024e-01f, -6.04248166e-01f, -5.09855092e-01f, 8.24348554e-02f, 4.48410287e-02f, -1.67586982e-01f,
  -3.80961955e-01f, 4.65750098e-01f, 5.01704682e-03f, 3.29417139e-01f, 1.09250225e-01f, 9.82063934e-02f, 9.85961482e-02f, 1.22158393e-01f, 2.07428589e-01f, 2.89132476e-01f,
  1.91970766e-01f, -2.05531821e-01f, 4.03464526e-01f, -5.03788143e-02f, 1.09709367e-01f, 3.35378885e-01f, 2.40994602e-01f, 3.09924372e-02f, 2.63226032e-01f, -7.18688965e-02f,
  -5.08732758e-02f, 1.75197408e-01f, 2.19735891e-01f, 8.63312259e-02f, 2.68242899e-02f, -7.37522170e-02f, -3.77969854e-02f, -1.28416903e-02f, -9.43602249e-02f, 1.32002577e-01f,
  8.53678510e-02f, 8.93204380e-03f, 6.02943152e-02f, -4.24980707e-02f, -9.88016650e-02f, 1.52736649e-01f, 1.60217613e-01f, 1.72347456e-01f, 2.35623583e-01f, -2.86093075e-02f,
  1.97908774e-01f, 1.87912405e-01f, -1.43701369e-02f, 1.23984717e-01f, 1.23202704e-01f, -9.15425122e-02f, -6.89734742e-02f, 6.39429614e-02f, 5.97002879e-02f, 2.15129573e-02f,
  -5.82707785e-02f, -1.32985294e-01f, -5.93015784e-03f, -3.95976789e-02f, -5.52835241e-02f, -2.40196846e-02f, -1.22272588e-01f, -7.95915499e-02f, -1.59358908e-03f, 6.86460882e-02f,
  -6.75358176e-02f, 1.71048250e-02f, -1.52330190e-01f, -8.81529450e-02f, -5.84813440e-03f, -1.86298966e-01f, -3.22251730e-02f, 9.83635560e-02f, 8.22796449e-02f, 7.93088451e-02f,
  3.59163061e-02f, -1.60051987e-01f, -1.11963172e-02f, -7.62125328e-02f, -3.14866304e-01f, -5.14566451e-02f, 1.06779501e-01f, 5.56081682e-02f, 3.38834636e-02f, 1.28252193e-01f,
  1.97171569e-01f, 4.03860867e-01f, 6.97653592e-02f, 4.17702235e-02f, 5.16322665e-02f, 3.57659049e-02f, 6.55533224e-02f, 2.97650434e-02f, 2.38665581e-01f, 5.32250898e-03f,
  -7.32522309e-02f, -9.88522545e-02f, 1.72886565e-01f, -1.10880926e-01f, 6.44099414e-02f, 1.33926749e-01f, 8.88608471e-02f, 2.80228674e-01f, 1.44760907e-01f, 1.97483376e-01f,
  1.55638561e-01f, -1.89524516e-01f, 6.01684377e-02f, -3.70749384e-02f, -1.17135555e-01f, 8.12371969e-02f, -4.52153720e-02f, -2.54415236e-02f, 2.13246182e-01f, 8.42343345e-02f,
  -1.48707464e-01f, 6.93350017e-01f, 5.26070952e-01f, 2.77070016e-01f, -5.39839804e-01f, 1.33090630e-01f, 2.42936730e-01f, -1.07074670e-01f, 2.73598671e-01f, 5.08154988e-01f,
  -1.95564672e-01f, 4.04150248e-01f, -7.58346096e-02f, 2.38384873e-01f, -6.00501776e-01f, 8.19205493e-02f, 2.76954353e-01f, 3.36650848e-01f, -1.01001620e-01f, -6.70202263e-03f,
  -2.88258255e-01f, -4.44290966e-01f, -2.95433775e-03f, -3.70578498e-01f, 1.44181952e-01f, 1.54085293e-01f, -4.73834276e-01f, -2.02788338e-01f, 2.53222466e-01f, -6.40695393e-02f,
  2.42609069e-01f, -9.89626646e-02f, 1.28450483e-01f, 1.60152718e-01f, 1.33552313e-01f, -1.01299947e-02f, 1.75348446e-01f, -5.25881276e-02f, -7.22602308e-02f, 1.14670686e-01f,
  7.55878463e-02f, -6.07022271e-02f, 6.44662380e-02f, -1.11271024e-01f, 3.24543156e-02f, 1.04662068e-01f, 9.74374115e-02f, 7.71511197e-02f, 1.86966300e-01f, 1.34610936e-01f,
  2.23056123e-01f, 1.93738654e-01f, -7.47074857e-02f, 9.91985351e-02f, -7.00105280e-02f, 6.71944842e-02f, 1.79066136e-01f, -6.52015535e-03f, 2.10982308e-01f, 3.88114937e-02f,
  -8.04495886e-02f, 5.12258336e-02f, 9.56131816e-02f, 6.01610616e-02f, -2.55968999e-02f, -1.84075534e-02f, 4.69809175e-02f, -1.23856470e-01f, 3.98755372e-02f, -7.10504949e-02f,
  -4.21286747e-02f, 5.66412285e-02f, -8.11404642e-03f, 1.02063447e-01f, -6.81439340e-02f, 1.11248575e-01f, -1.04362398e-01f, 6.36101440e-02f, 1.10815570e-01f, 1.02170068e-03f,
  -8.93985182e-02f, 3.32222655e-02f, 5.64164743e-02f, -1.27246426e-02f, 4.62249294e-02f, -8.43059644e-02f, -7.15373382e-02f, 1.03944220e-01f, -4.97130714e-02f, -1.75914735e-01f,
  1.22115135e-01f, -1.55395627e-01f, 1.03018202e-01f, 8.42996761e-02f, 4.76722308e-02f, 4.32878966e-03f, -5.92304431e-02f, 8.66711736e-02f, -5.15513960e-03f, -9.85359997e-02f,
  6.98712915e-02f, 9.05081555e-02f, -2.16258839e-02f, 5.22558438e-03f, 7.09950086e-03f, 6.90214038e-02f, -2.40107141e-02f, -1.41524943e-02f, -8.86014402e-02f, -9.14095715e-02f,
  -5.21383174e-02f, 1.31265144e-03f, -1.93766281e-02f, -4.04235385e-02f, 5.62785976e-02f, -3.23863253e-02f, -6.51763603e-02f, 1.02109566e-01f, -1.08778447e-01f, 6.02209494e-02f,
  -5.73473573e-01f, 3.78690749e-01f, 3.84189665e-01f, 5.10797696e-03f, 6.82186626e-04f, 5.51635027e-01f, 4.74373281e-01f, 3.29684168e-01f, 4.45077598e-01f, 1.97514802e-01f,
  -1.24658160e-01f, 2.28597205e-02f, 1.98868141e-01f, -4.18551415e-02f, 3.04880530e-01f, 3.22945833e-01f, 2.63172418e-01f, 1.22895263e-01f, 1.17208220e-01f, -1.22876279e-01f,
  2.24178787e-02f, -1.13098575e-02f, -2.13987976e-01f, -1.67193025e-01f, -3.39389026e-01f, -2.06938505e-01f, -3.93898726e-01f, -2.28596311e-02f, -1.64499119e-01f, 1.56566396e-01f,
  -2.07375795e-01f, -2.50604868e-01f, -2.91099668e-01f, 2.19960660e-02f, -8.78813937e-02f, 6.22769259e-03f, -8.40411931e-02f, 2.55579147e-02f, 5.12456894e-02f, 2.83827186e-02f,
  -1.05919048e-01f, 2.25152671e-02f, 1.36903264e-02f, 1.08730026e-01f, 1.23432897e-01f, 1.31250275e-02f, 2.69146953e-02f, -4.94527481e-02f, 6.08009212e-02f, -2.70395651e-02f,
  -7.18026161e-02f, -4.61621396e-02f, -1.17982134e-01f, 6.70485049e-02f, -5.63691836e-04f, 2.80439598e-03f, 1.77806437e-01f, -1.07778152e-02f, 7.30495434e-03f, 3.35245654e-02f,
  -1.24708777e-02f, 1.54099658e-01f, 4.92851883e-02f, -1.97209734e-02f, 1.36541557e-02f, -1.22127131e-01f, -6.43173605e-03f, -4.74107750e-02f, -5.40194549e-02f, -1.49515197e-01f,
  -3.59482318e-02f, -1.27610683e-01f, -4.27389294e-02f, 6.18270151e-02f, 5.61437160e-02f, -3.50927189e-02f, 2.78326608e-02f, -3.69251817e-02f, 5.46012782e-02f, -1.13057464e-01f,
  8.77920724e-03f, 1.05766430e-01f, -4.11092974e-02f, 1.92748755e-02f, 3.29616554e-02f, 6.26023933e-02f, -1.58786296e-03f, 3.00882421e-02f, 6.20374940e-02f, 5.58867585e-03f,
  4.60166454e-01f, 3.88401717e-01f, -1.22117877e-01f, -3.24486308e-02f, -1.22901760e-02f, -6.03025779e-02f, 5.71886599e-02f, -3.40325050e-02f, 2.72999197e-01f, 4.13037390e-02f,
  -3.68389226e-02f, -6.60684481e-02f, -5.88811329e-03f, -4.61418591e-02f, 1.59728446e-03f, 9.43321437e-02f, 8.94227326e-02f, 1.31718755e-01f, 1.00092530e-01f, -3.05474047e-02f,
  -1.69776857e-01f, -2.59461645e-02f, -6.14087433e-02f, -1.02120861e-01f, -1.18506528e-01f, -1.84908792e-01f, -2.25843769e-02f, -8.34313408e-02f, -2.27864850e-02f, 5.38120698e-03f,
  4.25681889e-01f, -3.16970438e-01f, -3.22532803e-01f, 1.02185989e-02f, 3.46274287e-01f, 5.46823703e-02f, -2.18556821e-01f, 2.29013607e-01f, -1.97335094e-01f, -2.48654723e-01f,
  1.75989941e-01f, -2.61310160e-01f, -2.41852537e-01f, 4.96229112e-01f, 2.95379788e-01f, -2.36837909e-01f, 3.58926356e-01f, 1.44295558e-01f, 1.24676026e-01f, 3.37107509e-01f,
  2.99501687e-01f, 4.94411170e-01f, 2.09569618e-01f, 2.75651217e-01f, 4.95895952e-01f, -4.95498665e-02f, 1.02807097e-01f, -3.09515625e-01f, 2.44087964e-01f, 4.56509646e-03f,
  1.92706361e-01f, 1.70870811e-01f, 7.72945136e-02f, 1.02520650e-02f, 1.91526905e-01f, 1.11979492e-01f, -6.33043349e-02f, -6.83307573e-02f, 3.48533988e-02f, -7.40297958e-02f,
  -9.46050435e-02f, 7.08157243e-03f, -2.70968080e-02f, 5.20977676e-02f, 1.89099297e-01f, 1.48035232e-02f, 1.14669934e-01f, 4.19358462e-02f, -2.50398479e-02f, 6.74486309e-02f,
  -7.05450252e-02f, -3.89590263e-02f, -5.81709780e-02f, -1.35229379e-01f, -1.37623578e-01f, -1.24137506e-01f, -1.92073002e-01f, -1.39844760e-01f, -7.46097416e-03f, 3.73557210e-02f,
  1.15731120e-01f, -7.17211142e-02f, 1.34881064e-02f, 5.32430708e-02f, 3.93778160e-02f, -7.98784941e-02f, 2.89791729e-02f, 2.35476922e-02f, -6.14173785e-02f, 4.20552157e-02f,
  2.66058855e-02f, -2.51372382e-02f, 6.02161400e-02f, -5.43052293e-02f, 5.80443069e-02f, -3.49472240e-02f, -1.59370322e-02f, -3.29468101e-02f, -3.19929272e-02f, 1.58762001e-02f,
  -6.31334782e-02f, 7.24199787e-02f, -1.10941909e-01f, 4.98690158e-02f, -3.19806626e-03f, -5.37707172e-02f, 1.00472391e-01f, -1.28968209e-01f, 7.11664408e-02f, 1.40925879e-02f,
  4.17017415e-02f, -6.46080077e-02f, -8.78635421e-03f, -1.06235340e-01f, -6.43839985e-02f, 1.86339512e-01f, 1.29819050e-01f, -6.34363294e-02f, -4.54396047e-02f, -5.17365872e-04f,
  -4.43434045e-02f, -6.24093749e-02f, -8.76335278e-02f, 7.43929073e-02f, -2.01105289e-02f, 8.81050080e-02f, -1.70727402e-01f, -1.73575804e-01f, -5.14313281e-02f, 4.22897041e-02f,
  -8.57703686e-02f, -5.81053384e-02f, -2.45758109e-02f, -2.44037975e-02f, -2.02871431e-02f, -4.28369753e-02f, -1.12080136e-02f, -1.17238566e-01f, 8.34893808e-02f, 5.68745367e-04f,
  -3.96298975e-01f, 5.17588481e-02f, -4.12505269e-01f, -1.82693571e-01f, -5.36640763e-01f, -2.91217327e-01f, -2.10301027e-01f, -6.00960739e-02f, 1.95174679e-01f, 4.18608636e-01f,
  4.58173826e-02f, -2.11619586e-02f, 4.70470130e-01f, -4.96555294e-04f, -1.98781475e-01f, 5.42850733e-01f, -9.74088833e-02f, 1.19119376e-01f, 4.49218936e-02f, -8.65834057e-02f,
  -1.21409841e-01f, -1.19011946e-01f, -1.40796602e-01f, -9.28268805e-02f, -4.76954192e-01f, -2.88706541e-01f, -1.01056546e-01f, -4.14447725e-01f, -4.14166838e-01f, -2.81480491e-01f,
  -4.45020139e-01f, -2.46151686e-01f, -1.64521590e-01f, -3.85047942e-02f, -1.23713650e-01f, 6.04687743e-02f, -1.02771729e-01f, -9.70112905e-02f, -1.08217716e-01f, -2.79586893e-02f,
  1.10104904e-01f, -7.18446868e-03f, 6.19798303e-02f, 1.18609227e-01f, -8.85297805e-02f, -1.52306795e-01f, -9.30718407e-02f, -1.40034005e-01f, -9.15589035e-02f, -1.73984632e-01f,
  -8.43131691e-02f, -1.29392445e-01f, -8.68236572e-02f, 6.40650615e-02f, -2.52113014e-01f, -7.66674653e-02f, 2.84619592e-02f, -1.06614821e-01f, -2.02966794e-01f, -1.54859543e-01f,
  -2.74621155e-02f, -3.12205814e-02f, -2.98709888e-02f, -4.85797077e-02f, 5.64158522e-02f, -3.70688066e-02f, -3.57880890e-02f, 1.55214697e-01f, 2.63691358e-02f, -8.13610330e-02f,
  1.20200990e-02f, -6.79704770e-02f, 1.68413986e-02f, -2.34360617e-04f, 2.98065245e-02f, 1.42028034e-01f, 7.91042969e-02f, -5.73644824e-02f, 1.52046487e-01f, 1.46906720e-02f,
  -9.10627916e-02f, 1.99253615e-02f, -4.47723232e-02f, 5.09343185e-02f, -2.53947079e-02f, 2.46111974e-02f, 5.46758845e-02f, 9.43926815e-03f, -5.08109964e-02f, -1.46607965e-01f,
  -4.91814166e-01f, -3.88659984e-01f, -4.85705361e-02f, -1.21501051e-01f, 3.19966227e-02f, -4.14715149e-02f, 1.13041744e-01f, -4.63676974e-02f, -1.59607932e-01f, 6.54674098e-02f,
  5.03518432e-02f, 1.60449058e-01f, 2.25004200e-02f, 7.40054846e-02f, 1.64828584e-01f, -4.61122580e-02f, 1.65433884e-02f, 1.92965508e-01f, -1.36585772e-01f, -8.16565529e-02f,
  -4.03488986e-02f, 1.41054079e-01f, 5.59526570e-02f, 6.57342374e-02f, 6.34590834e-02f, -9.00168642e-02f, -4.79147919e-02f, -3.50684486e-02f, -1.54107258e-01f, 1.20745204e-01f,
  2.55616218e-01f, 3.72952700e-01f, 2.41567761e-01f, 4.87434208e-01f, 4.39027091e-03f, -3.99455130e-01f, 7.66143873e-02f, 2.86554545e-01f, 5.36373675e-01f, 1.55541793e-01f,
  -1.10354275e-01f, 3.55315804e-01f, 5.06606419e-03f, 2.38149419e-01f, -5.06837010e-01f, -2.22384080e-01f, -2.88790822e-01f, 5.49893230e-02f, 1.29702181e-01f, 1.63566455e-01f,
  -6.84083253e-02f, -2.66282737e-01f, -2.54327089e-01f, -4.98866662e-02f, 1.57662496e-01f, 2.73089230e-01f, -5.25173843e-01f, 7.62327835e-02f, -9.57217216e-02f, -1.86445743e-01f,
  -1.16320089e-01f, 4.08679247e-01f, 1.81497410e-01f, -3.85833755e-02f, -1.09636232e-01f, -1.26862139e-01f, -3.58345881e-02f, 9.02476460e-02f, 4.35011312e-02f, 9.85198840e-02f,
  9.39010605e-02f, 5.12399292e-03f, 6.87596053e-02f, 1.49198562e-01f, 6.99251369e-02f, 7.14513361e-02f, 1.48658156e-01f, -8.92001856e-03f, 1.49265632e-01f, 6.39649853e-02f,
  1.00633457e-01f, 1.09712102e-01f, -1.25413135e-01f, -8.66372064e-02f, -8.21521208e-02f, 4.06554826e-02f, -1.58197314e-01f, -9.84224677e-02f, -1.76085103e-02f, 1.15086265e-01f,
  2.84032356e-02f, -1.76489949e-01f, -2.75326357e-03f, 3.80759872e-02f, 2.49631777e-02f, 9.60932523e-02f, 4.41636890e-02f, -6.41848743e-02f, -1.04865246e-01f, -1.15184903e-01f,
  -1.37687266e-01f, 4.35219035e-02f, 2.46125758e-02f, 9.64688510e-02f, 1.24211326e-01f, 1.32424250e-01f, -9.55801606e-02f, 3.21275182e-02f, -1.92099903e-02f, -7.02603161e-02f,
  4.80048694e-02f, -7.54533932e-02f, 3.05492599e-02f, -1.29574314e-01f, -2.61779651e-02f, 2.06442341e-01f, 1.20924748e-01f, 1.40975848e-01f, -3.99096869e-02f, -6.79480806e-02f,
  -3.21993798e-01f, 7.85126314e-02f, -1.20863274e-01f, 1.70315895e-02f, -1.13330716e-02f, -5.47999963e-02f, 4.13856702e-03f, 3.36064845e-02f, -7.06255808e-02f, -1.04002982e-01f,
  -1.19113378e-01f, 5.08017130e-02f, -1.50623128e-01f, -3.08463667e-02f, -9.81333330e-02f, -1.25674084e-01f, 1.46781690e-02f, -9.72083062e-02f, -1.48864135e-01f, 2.21703239e-02f,
  2.89173592e-02f, -1.42697403e-02f, -3.54523659e-02f, -2.09976006e-02f, -9.44658890e-02f, 4.50369790e-02f, 1.41807515e-02f, 6.26609698e-02f, -2.49045640e-02f, -1.16652958e-01f,
  -6.59476280e-01f, 4.82254446e-01f, -6.84542537e-01f, -2.98536301e-01f, 3.31041634e-01f, 1.86585754e-01f, 8.98978040e-02f, 1.34743884e-01f, -2.33389974e-01f, 4.89224046e-01f,
  5.95968723e-01f, -3.71982068e-01f, 2.15823054e-01f, 2.27825016e-01f, -4.58181351e-01f, 5.74167632e-02f, -1.58298630e-02f, 3.07743698e-02f, -2.89866894e-01f, -4.40900140e-02f,
  -4.04607087e-01f, 3.83472681e-01f, -3.68842989e-01f, 2.53958315e-01f, 8.72398391e-02f, -2.77633816e-01f, 3.62777323e-01f, -9.44349468e-02f, 2.09092155e-01f, 7.76827261e-02f,
  -5.09138480e-02f, -2.48424888e-01f, 4.93239798e-02f, -2.75726974e-01f, -1.06315114e-01f, 4.91825826e-02f, -4.65091281e-02f, -9.74966660e-02f, -1.93878338e-01f, -7.66606778e-02f,
  4.54454049e-02f, 3.27643789e-02f, -1.05089910e-01f, -1.39986083e-01f, -2.98205502e-02f, 4.53934409e-02f, 5.46794534e-02f, 5.14534935e-02f, 7.95371532e-02f, -6.76529631e-02f,
  -8.72289017e-03f, -3.26896571e-02f, 1.15233146e-01f, -1.74423419e-02f, 3.07064950e-02f, 1.20480157e-01f, -6.27434701e-02f, -1.90108903e-02f, 5.16633056e-02f, -1.11067388e-03f,
  -2.74371561e-02f, -1.56837761e-01f, 5.32922223e-02f, 2.59034173e-03f, 8.12599063e-03f, 8.19080397e-02f, 4.52678576e-02f, 5.22923132e-04f, -1.07851751e-01f, 6.57192245e-02f,
  4.35638661e-03f, -6.77934587e-02f, 6.16215281e-02f, -3.26629356e-02f, 7.14514777e-02f, -1.05283670e-01f, -7.57081285e-02f, 2.87075923e-03f, -9.50106755e-02f, -6.30372064e-03f,
  5.78229092e-02f, -3.98121811e-02f, 6.27834648e-02f, 4.69351597e-02f, 8.69595557e-02f, -1.39878569e-02f, 2.11488791e-02f, 4.40671779e-02f, 6.11430518e-02f, 2.18683444e-02f,
  2.41773978e-01f, -9.87400934e-02f, 5.58084697e-02f, 1.02192268e-01f, -9.40513890e-03f, 7.06780031e-02f, -6.47276416e-02f, -8.49239901e-02f, 7.94405639e-02f, -3.17180716e-02f,
  -7.88414851e-02f, -2.03871424e-03f, -1.60662755e-02f, 2.57482193e-02f, -6.86361566e-02f, 2.38118306e-01f, 4.84180897e-02f, -7.37412274e-02f, 8.50274488e-02f, -1.22021334e-02f,
  2.25551818e-02f, 9.34312418e-02f, -8.85737017e-02f, 4.21708748e-02f, -3.34664807e-02f, 2.17948496e-01f, 2.60810852e-02f, -9.90583822e-02f, -9.26552527e-03f, -1.41188080e-04f,
  -9.85341147e-02f, -1.83148637e-01f, -2.40719900e-01f, 2.90233493e-01f, 3.47966105e-01f, 3.51256505e-03f, 1.32660076e-01f, 3.06505740e-01f, 2.88289189e-01f, -6.50096089e-02f,
  -9.78423730e-02f, -5.82258940e-01f, -2.51460850e-01f, -1.44472092e-01f, -5.35097539e-01f, -2.97510803e-01f, -3.62000048e-01f, -4.23996508e-01f, -5.90792596e-02f, -2.52876997e-01f,
  -3.40407230e-02f, 4.77682203e-01f, 4.61225249e-02f, 3.39104146e-01f, 2.72057056e-01f, 2.93479323e-01f, 1.12038299e-01f, 2.04419777e-01f, 5.22864796e-02f, -3.64150479e-02f,
  8.02073255e-02f, 5.96759282e-02f, 1.40440136e-01f, 2.10156009e-01f, -4.10310328e-02f, -2.01148307e-03f, -1.20267816e-01f, -7.05424994e-02f, 1.06891111e-01f, -1.02000008e-03f,
  -1.09830864e-01f, 2.11785156e-02f, 4.46889624e-02f, 1.02079138e-01f, 2.09437445e-01f, 1.42518193e-01f, -4.65444736e-02f, 1.10959031e-01f, 3.55579890e-02f, -2.71995723e-01f,
  7.74744013e-03f, -2.36003682e-01f, -1.81787148e-01f, -9.55946371e-02f, -1.60108924e-01f, 5.52804507e-02f, -1.49957418e-01f, -2.13789463e-01f, -1.80285066e-01f, -5.65785691e-02f,
  -1.28957063e-01f, -5.58316819e-02f, -1.96873564e-02f, 2.89669901e-01f, 7.14806914e-02f, 1.55755579e-01f, 9.19046029e-02f, -8.88907388e-02f, 9.87124518e-02f, -2.00093482e-02f,
  8.41655657e-02f, 1.88214451e-01f, 1.22707754e-01f, 1.13802319e-02f, 3.88051644e-02f, 6.72985092e-02f, -1.23277977e-01f, -6.39240742e-02f, -3.39151733e-02f, -1.58868842e-02f,
  1.77459210e-01f, -3.57436091e-02f, 2.90152952e-02f, 2.29211664e-03f, 4.40795496e-02f, -8.93417597e-02f, 1.54430363e-02f, 9.94415134e-02f, -5.37043158e-03f, -9.81123298e-02f,
  -1.10225528e-01f, -3.41859102e-01f, 1.21354185e-01f, 2.24042520e-01f, 5.01072966e-02f, 1.13754841e-02f, -7.00529590e-02f, 1.37471501e-02f, -5.83658963e-02f, 1.07556283e-01f,
  -6.32232353e-02f, 5.07410504e-02f, -1.18768543e-01f, -5.46164960e-02f, 6.29531518e-02f, -2.78513134e-02f, -8.69630799e-02f, 9.85721424e-02f, -8.79618805e-04f, -1.17069066e-01f,
  2.90236995e-02f, -1.62868679e-01f, 3.74922529e-02f, 8.98676440e-02f, -1.53637296e-02f, -7.25272372e-02f, -1.03722714e-01f, -6.90244585e-02f, 2.82646529e-02f, -1.78404212e-01f,
  -2.52391934e-01f, -6.43956959e-01f, -4.11677897e-01f, -5.30501232e-02f, 1.95098832e-01f, 3.52754325e-01f, -2.92642802e-01f, -1.15408070e-01f, -4.65610236e-01f, 1.52812853e-01f,
  1.20188639e-01f, -4.02639776e-01f, -2.93270081e-01f, 2.25965288e-02f, -1.57220080e-01f, -3.56894284e-01f, 3.23405355e-01f, 1.11801378e-01f, -2.97958255e-01f, -1.06272578e-01f,
  -3.20345238e-02f, 3.85935664e-01f, -1.92983061e-01f, 2.91083753e-01f, 1.73781022e-01f, 1.77966371e-01f, 3.85097235e-01f, -8.30428973e-02f, 4.88783479e-01f, 2.62689710e-01f,
  8.30846056e-02f, -2.16220900e-01f, -1.84571996e-01f, -2.40560304e-02f, 3.92203704e-02f, 2.04152912e-01f, 1.61376551e-01f, -3.91037278e-02f, -9.86721367e-02f, -7.17123002e-02f,
  1.11594237e-01f, -4.03925404e-02f, 1.12655908e-01f, -1.68791949e-03f, 2.43329201e-02f, 8.28529708e-03f, -2.49696359e-01f, -2.36764997e-02f, -1.66982815e-01f, -2.96874344e-01f,
  -2.73709238e-01f, -2.58243512e-02f, 1.19186088e-01f, 9.13384631e-02f, -6.95600957e-02f, -6.42553493e-02f, 5.13329618e-02f, -7.13558942e-02f, 1.12469807e-01f, -6.78168014e-02f,
  5.71629256e-02f, 2.35702515e-01f, -8.37091431e-02f, -9.27217770e-03f, -1.28350586e-01f, 9.71937329e-02f, 3.68667506e-02f, 5.24722524e-02f, -1.46858603e-01f, -1.22671910e-01f,
  1.26221672e-01f, -6.17749766e-02f, -4.36475547e-03f, 8.94472301e-02f, -2.75054239e-02f, -6.38418570e-02f, 1.38936773e-01f, -1.38669470e-02f, 8.49907324e-02f, 1.82457529e-02f,
  -1.18113803e-02f, -9.54469945e-03f, -2.16479041e-02f, 1.55597925e-01f, -6.73181713e-02f, 6.92852587e-02f, 2.19453797e-01f, -2.57682726e-02f, 7.62507021e-02f, 1.76902890e-01f,
  1.62604883e-01f, 8.50322023e-02f, -4.07299958e-02f, 1.25015154e-01f, -2.93525495e-02f, 1.23760194e-01f, 7.01988041e-02f, 5.17526120e-02f, 7.49853849e-02f, -6.27287552e-02f,
  1.60848126e-01f, 6.97846189e-02f, 1.23881049e-01f, 1.66664994e-03f, 1.64656490e-01f, 4.58254069e-02f, 5.51096797e-02f, 1.12558417e-01f, 1.80499971e-01f, 9.46922600e-03f,
  2.10741639e-01f, -2.83373706e-03f, 1.25737339e-02f, 7.14080334e-02f, 1.40199348e-01f, 1.25272736e-01f, 1.22651242e-01f, -1.84619222e-02f, 1.55518595e-02f, -9.66680050e-02f,
  3.68925840e-01f, -4.65244919e-01f, 1.98860452e-01f, 6.13426864e-01f, 2.22414508e-01f, 2.85789400e-01f, 5.93257368e-01f, 7.42359608e-02f, 5.92441738e-01f, -3.32257181e-01f,
  2.36130938e-01f, -1.87711358e-01f, 1.04340322e-01f, 1.94546849e-01f, 2.22901478e-01f, 3.26028466e-01f, 2.84684181e-01f, 2.97209769e-01f, 2.37157807e-01f, 1.76021278e-01f,
  2.86369830e-01f, 1.04200169e-01f, 1.63962934e-02f, -4.26896840e-01f, -1.21163338e-01f, -2.75161952e-01f, -2.54601449e-01f, 1.75780691e-02f, -3.33803684e-01f, -5.56294061e-03f,
  1.19454093e-01f, 1.75772429e-01f, -6.10060915e-02f, -1.09094359e-01f, -6.74902424e-02f, -5.75237758e-02f, 8.35651010e-02f, 2.68982928e-02f, 5.93022443e-02f, -6.26951531e-02f,
  4.74322625e-02f, -1.86757505e-01f, -3.56356539e-02f, -1.75840117e-03f, 3.87873352e-02f, -1.90280691e-01f, -1.17536567e-01f, -4.79846559e-02f, -3.42227407e-02f, -1.57524660e-01f,
  4.27958146e-02f, 8.10281411e-02f, 8.76054354e-03f, -1.52398273e-01f, 2.24381108e-02f, 9.47408676e-02f, -4.95054424e-02f, -1.27693685e-02f, -2.28203996e-03f, 2.70159114e-02f,
  5.57498559e-02f, 8.34859237e-02f, 6.19309070e-03f, 1.33392900e-01f, 6.05051480e-02f, 1.74164511e-02f, 5.54098450e-02f, 8.21380690e-02f, -9.04248934e-03f, 3.25803608e-02f,
  1.31550625e-01f, -2.63845213e-02f, 6.29927740e-02f, 1.44115016e-01f, 1.42817736e-01f, -8.31588823e-03f, 2.29749531e-02f, -3.10093779e-02f, 5.08120619e-02f, 1.19513748e-02f,
  3.69388014e-02f, -6.75404444e-02f, -2.40274146e-02f, 3.00560566e-03f, -1.64662544e-02f, 2.21515689e-02f, -6.79922849e-02f, -3.27726603e-02f, 9.53300446e-02f, 1.23539805e-01f,
  9.76863224e-03f, -7.32485726e-02f, 5.01161367e-02f, -3.36280093e-02f, -8.31208006e-02f, -8.35285783e-02f, 4.77862656e-02f, -8.72676522e-02f, 1.12457186e-01f, -1.19937323e-02f,
  2.60355845e-02f, -7.96949212e-03f, -8.56181420e-03f, -1.07616857e-01f, -1.05626509e-01f, -5.12002334e-02f, 1.42743111e-01f, 1.02635585e-02f, -2.77484283e-02f, -1.95691615e-01f,
  -1.20472006e-01f, 2.86851879e-02f, 2.23005973e-02f, 2.34655105e-02f, -1.13851473e-01f, -2.83403452e-02f, -3.38321738e-02f, 3.47436666e-02f, -1.04596764e-01f, -7.25606456e-02f,
  3.86228472e-01f, -2.40542725e-01f, -1.28209973e-02f, -1.15865037e-01f, -2.17925280e-01f, 1.44330621e-01f, 4.66382951e-01f, -5.17930567e-01f, -4.18645471e-01f, -1.19993679e-01f,
  -1.77216351e-01f, 4.59915966e-01f, 5.40810704e-01f, -1.93064556e-01f, 6.30169272e-01f, 3.07820678e-01f, -1.98341608e-01f, 2.71647841e-01f, -2.22408548e-01f, -1.02458507e-01f,
  -1.96492955e-01f, -1.17247343e-01f, 2.18373328e-01f, -3.35395247e-01f, -9.06667188e-02f, -3.09056073e-01f, 9.04791523e-03f, 2.31522858e-01f, -1.91241562e-01f, 1.79096401e-01f,
  -4.92602326e-02f, -3.15223396e-01f, -6.38666004e-02f, -3.53824608e-02f, -1.18365526e-01f, -2.02372633e-02f, 2.66798556e-01f, 3.65720809e-01f, 9.90697742e-02f, -5.18151410e-02f,
  1.99942365e-01f, 6.83544949e-02f, -1.47305027e-01f, 1.06768951e-01f, -8.15395042e-02f, -2.29235962e-01f, -1.31991342e-01f, -9.66692567e-02f, -3.61551903e-02f, -1.58845726e-02f,
  -2.23795250e-02f, -1.87845558e-01f, -1.09345831e-01f, -5.31365983e-02f, 1.39199458e-02f, -1.03522524e-01f, 8.40074569e-02f, 1.50867403e-01f, -4.79825102e-02f, -1.18791029e-01f,
  9.12303254e-02f, 1.06480168e-02f, 8.09712932e-02f, -3.25978696e-02f, -2.63645835e-02f, -1.24569356e-01f, 2.70678885e-02f, 9.49466974e-02f, 1.38666453e-02f, 3.43131945e-02f,
  -3.13634947e-02f, -4.58390042e-02f, -7.27881566e-02f, -6.53549656e-02f, -8.04618597e-02f, -1.11458130e-01f, 2.33577326e-01f, -2.59292801e-03f, -1.18342869e-01f, -1.15504816e-01f,
  4.14224081e-02f, 7.66610131e-02f, 1.60933286e-02f, 9.61010531e-03f, 9.32909697e-02f, 1.62684947e-01f, -4.56724539e-02f, -2.96477377e-02f, -1.45010546e-01f, 1.29241139e-01f,
  -8.60890597e-02f, -2.39393309e-01f, -2.37758458e-02f, -1.48664759e-02f, 9.22908112e-02f, -3.00231129e-02f, -4.94569633e-03f, -9.34248939e-02f, -1.16468444e-02f, -1.19395338e-01f,
  -1.18456721e-01f, -3.47061567e-02f, -1.12226374e-01f, 5.89637086e-02f, 1.04472026e-01f, -5.20113260e-02f, 1.42757446e-01f, -1.12769261e-01f, 3.64198871e-02f, -5.59986643e-02f,
  -2.74967812e-02f, 1.03163034e-01f, 1.03469826e-01f, -1.05937228e-01f, -1.38557449e-01f, 1.01365030e-01f, -4.80994247e-02f, 4.74121869e-02f, 4.49278988e-02f, 1.56852941e-03f,
  4.59840178e-01f, -3.04104071e-02f, -4.96784151e-01f, -4.32230145e-01f, -1.55139923e-01f, -8.39134455e-02f, -3.09762001e-01f, -1.96465954e-01f, -5.97616285e-02f, 2.69552261e-01f,
  -2.99901456e-01f, 6.17157519e-02f, 1.62758365e-01f, -2.61767209e-01f, 1.06800914e-01f, 1.36600897e-01f, -9.04538333e-02f, -1.72471017e-01f, -1.15465157e-01f, 1.46981955e-01f,
  -8.86904597e-02f, 6.28306270e-02f, -4.35654253e-01f, 1.41984532e-02f, -2.32217729e-01f, -1.03875823e-01f, -1.46802422e-03f, -9.88368765e-02f, -1.86429769e-01f, -1.75254241e-01f,
  -1.36697441e-01f, 1.24797355e-02f, -6.58838227e-02f, -3.22263986e-02f, 1.58101432e-02f, -2.66956463e-02f, -1.14981577e-01f, -5.42521141e-02f, -1.73037797e-01f, -1.38239134e-02f,
  2.13278517e-01f, 1.49930105e-01f, 6.68643042e-02f, 9.40096006e-03f, 1.78460598e-01f, -3.02276462e-02f, 4.98018488e-02f, -9.35328603e-02f, 9.23925564e-02f, 2.29130816e-02f,
  -9.17183980e-02f, -6.80522174e-02f, -9.62154344e-02f, 5.98636866e-02f, -6.58553327e-03f, -7.87888393e-02f, 1.27433807e-01f, 1.53061245e-02f, 1.58352017e-01f, 3.00218398e-05f,
  8.91348869e-02f, -3.78312804e-02f, 5.69201913e-03f, -1.13217808e-01f, -9.77479517e-02f, -7.82474950e-02f, 6.91138953e-02f, -1.72455329e-02f, 3.47338133e-02f, 1.02930591e-02f,
  -8.97159129e-02f, 2.82449182e-03f, -3.64669040e-02f, -9.88860503e-02f, 1.56921297e-01f, 4.68978658e-02f, 1.31793953e-02f, 3.65602486e-02f, -6.98759705e-02f, -1.12436824e-01f,
  -1.46610774e-02f, 1.42268732e-01f, -5.65768629e-02f, -7.59788379e-02f, -1.55273825e-01f, -7.76797673e-03f, 2.96154376e-02f, 5.59077375e-02f, -1.51652277e-01f, 5.31696975e-02f,
  1.75804570e-02f, 2.74523884e-01f, 4.09167856e-02f, 1.21144885e-02f, -3.56193036e-02f, 3.15617323e-02f, 7.56314471e-02f, -6.66454136e-02f, -2.06594374e-02f, 7.52773210e-02f,
  1.62880227e-01f, 7.91624337e-02f, 5.72052151e-02f, 2.31020451e-02f, 2.50394046e-02f, 5.52481264e-02f, 7.45874792e-02f, 7.36079216e-02f, 7.35338256e-02f, 3.86254303e-02f,
  2.38508247e-02f, 1.32449627e-01f, 2.00604811e-01f, -7.01540038e-02f, 6.22711927e-02f, 4.75612991e-02f, 2.06052989e-01f, -8.10160041e-02f, 1.67228326e-01f, -8.96076784e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.11452627e-01f, 4.85875070e-01f, 3.37365478e-01f, 3.20080370e-01f, 6.97924495e-01f, 1.91734940e-01f, 4.57703292e-01f, 2.00134292e-01f, 4.18820381e-01f, 4.04424638e-01f,
  2.88617790e-01f, 2.10734025e-01f, 3.34584802e-01f, 3.95313442e-01f, 4.43319380e-01f, 4.71886337e-01f, 3.04878712e-01f, 4.85802025e-01f, 2.65828162e-01f, 4.78024095e-01f,
  3.96463096e-01f, 4.21538413e-01f, 4.01410103e-01f, 3.09446752e-01f, 2.74551123e-01f, 4.30948675e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.21090457e-01f, -4.01165113e-02f, -2.11317778e-01f, 6.77505508e-03f, -1.61381215e-01f, 1.04002438e-01f, -1.36449054e-01f, 1.43090412e-01f, 2.05486313e-01f, -1.87697768e-01f,
  -2.69480553e-02f, -2.59024650e-02f, -1.71009392e-01f, -8.06709155e-02f, -1.00661211e-01f, -6.54330552e-02f, -1.17577247e-01f, 2.25394275e-02f, 7.81697407e-02f, -1.05429560e-01f,
  1.22258037e-01f, -3.19332719e-01f, 4.89205793e-02f, -1.34412898e-02f, -2.78634161e-01f, -7.59485886e-02f, 9.61790234e-02f, -1.33255497e-01f, -1.38904840e-01f, -3.52446854e-01f,
  7.23686889e-02f, -3.72322887e-01f, 1.23520792e-01f, 3.54368314e-02f, -1.54440820e-01f, -2.09436059e-01f, 8.06758627e-02f, -2.10361376e-01f, -1.84452370e-01f, -4.44697626e-02f,
  4.20297012e-02f, -2.12506413e-01f, 2.59650350e-02f, -4.90898825e-02f, -2.97980517e-01f, -3.14793080e-01f, -5.89374341e-02f, 2.03374941e-02f, -1.22283198e-01f, -7.28319883e-02f,
  -5.94645180e-02f, 3.68977278e-01f, 2.58336067e-01f, -2.62307912e-01f, -1.77444905e-01f, 3.96369338e-01f, 1.52598128e-01f, 3.35957468e-01f, 3.13124031e-01f, 1.10652305e-01f,
  2.95600563e-01f, 1.55992433e-01f, 7.92559609e-02f, -3.06221396e-01f, 1.95691571e-01f, 2.85160601e-01f, 1.18798353e-01f, 3.36531758e-01f, -2.93605119e-01f, 1.09201305e-01f,
  -1.42726064e-01f, -2.37322882e-01f, -9.65941623e-02f, 3.64020139e-01f, 1.39585719e-01f, 2.29679942e-01f, 3.08025330e-01f, -4.78217781e-01f, 5.25763854e-02f, 2.39889592e-01f,
  -3.17225426e-01f, -1.86036080e-01f, 9.19431299e-02f, -5.44056036e-02f, 3.28677744e-01f, 3.74091387e-01f, -2.29685575e-01f, -9.49836429e-03f, -2.01091260e-01f, 2.17614964e-01f,
  1.05407588e-01f, 3.14882725e-01f, 1.57522149e-02f, 2.03127235e-01f, -2.33594347e-02f, -2.09193617e-01f, 2.09209502e-01f, -2.20708847e-01f, -1.85476974e-01f, -3.58406037e-01f,
  -2.83599705e-01f, -3.54331166e-01f, 4.63513762e-01f, -7.43506014e-01f, -3.06550473e-01f, -1.76728159e-01f, -4.25755620e-01f, -2.93043315e-01f, -3.71861428e-01f, 4.09720004e-01f,
  -3.43025863e-01f, 4.41008918e-02f, 4.41257179e-01f, -6.74874663e-01f, -3.51273149e-01f, -5.75727701e-01f, -7.29433671e-02f, 4.32068259e-01f, 3.20287533e-02f, -2.39917710e-01f,
  4.11242247e-01f, -2.74999231e-01f, 3.52946043e-01f, -5.81674203e-02f, 8.82309899e-02f, 7.53414258e-02f, -6.88249245e-02f, -3.98451865e-01f, 1.91645622e-01f, 3.24818105e-01f,
  -1.78309992e-01f, -3.73257160e-01f, -8.70547909e-03f, 2.09510013e-01f, 1.11058101e-01f, -4.97058600e-01f, 1.58280194e-01f, 2.10482329e-01f, -2.69201249e-02f, -5.28032109e-02f,
  -2.03250363e-01f, 1.76811188e-01f, 3.00878584e-01f, 1.07885979e-01f, 2.99058724e-02f, -6.10773042e-02f, -2.54413992e-01f, 7.31093984e-04f, -1.04968578e-01f, -8.09300765e-02f,
  5.62221324e-03f, -2.20374405e-01f, -1.43825233e-01f, -2.25437395e-02f, 5.45911416e-02f, -3.99431586e-01f, -1.12169348e-01f, -1.32693001e-03f, -3.32312971e-01f, -1.23648576e-01f,
  -3.62053402e-02f, 5.83447516e-02f, -9.06913131e-02f, 1.73938408e-01f, -2.59618044e-01f, 1.56115204e-01f, 8.57529566e-02f, -3.48742634e-01f, 2.10984964e-02f, -6.29901439e-02f,
  8.72140899e-02f, -8.84628147e-02f, 8.20139870e-02f, -4.27732710e-03f, 1.29442224e-02f, -2.38719136e-02f, -1.34031251e-01f, -2.02513695e-01f, -9.90872644e-03f, -2.07123905e-01f,
  3.10500443e-01f, -4.14657623e-01f, -3.56122464e-01f, -1.07874036e-01f, -1.71319440e-01f, -2.85766840e-01f, -3.71999383e-01f, 3.19976956e-01f, -3.42297375e-01f, 1.61868870e-01f,
  3.78218263e-01f, -1.97718427e-01f, 2.77484477e-01f, 1.28138766e-01f, 4.81696278e-02f, 2.48329476e-01f, 2.97073096e-01f, 2.92705745e-01f, -3.24418724e-01f, -2.26557925e-01f,
  -2.02108786e-01f, -4.41915363e-01f, 3.72056991e-01f, 7.19294548e-02f, -3.49095136e-01f, 3.03199798e-01f, 3.79193604e-01f, 2.86826193e-01f, 2.03442872e-01f, 2.71651357e-01f,
  2.74359465e-01f, -2.46123418e-01f, -3.49581659e-01f, -3.84610981e-01f, -2.70864278e-01f, -4.85842070e-03f, -1.35872677e-01f, 2.04408854e-01f, 1.30430028e-01f, -1.59792170e-01f,
  3.18668008e-01f, 6.49827570e-02f, 2.49731928e-01f, -3.26669574e-01f, 3.29768032e-01f, -3.82277519e-01f, -2.39014402e-01f, -2.83163726e-01f, 3.90022211e-02f, 2.20903262e-01f,
  1.40650943e-01f, 4.54895735e-01f, -4.66256559e-01f, 1.43459870e-03f, -5.72994471e-01f, 2.35980198e-01f, 4.76665348e-02f, 3.39366049e-01f, -3.34993273e-01f, 3.51703495e-01f,
  -4.74194616e-01f, -2.61856705e-01f, -5.33675291e-02f, -2.03147922e-02f, -4.25635487e-01f, -2.40880296e-01f, -3.82299870e-02f, 3.06551576e-01f, -6.55862391e-01f, -5.11253238e-01f,
  4.47125971e-01f, -3.14994395e-01f, 7.02904537e-02f, -5.75331412e-02f, 9.52439010e-02f, 1.80980742e-01f, 6.64046407e-02f, -8.78346637e-02f, 1.05230220e-01f, -4.16802336e-03f,
  5.42592965e-02f, -1.59604549e-01f, -2.73533374e-01f, 4.65619974e-02f, -3.02595228e-01f, -1.94556192e-01f, -1.80520296e-01f, -2.75203794e-01f, 5.69330566e-02f, -2.38108367e-01f,
  -5.72404303e-02f, 2.07774919e-02f, 1.11014925e-01f, -2.55968571e-01f, 2.83983033e-02f, -9.87344906e-02f, -2.06168279e-01f, 9.42181144e-03f, -8.89095068e-02f, 1.43461049e-01f,
  -1.47474110e-02f, -2.91933585e-02f, -1.32657692e-01f, 4.84303199e-02f, 1.99054927e-01f, -4.85626943e-02f, 5.67572415e-02f, 7.56759644e-02f, -1.18285911e-02f, -3.62629473e-01f,
  -1.87673375e-01f, -8.45116004e-02f, 5.26862517e-02f, -2.13261425e-01f, 8.98062512e-02f, 1.96443707e-01f, 1.51976962e-02f, 6.16630130e-02f, 2.51566265e-02f, -2.01905772e-01f,
  4.24714014e-02f, 1.42134905e-01f, 8.16800725e-03f, 2.34836899e-02f, -2.55602717e-01f, 1.44582406e-01f, -1.75888747e-01f, -1.52430430e-01f, -3.34107608e-01f, 1.27763957e-01f,
  -1.98001191e-01f, 1.51655719e-01f, 2.25454606e-02f, -5.35175763e-02f, 3.99781205e-03f, 2.59983510e-01f, 8.28069896e-02f, 2.59566545e-01f, 2.32996106e-01f, 1.94189861e-01f,
  -3.29424798e-01f, -2.36121207e-01f, -3.23436111e-01f, -3.09056211e-02f, 1.13699161e-01f, 1.49030045e-01f, -3.58086377e-01f, -1.96545228e-01f, 2.61217296e-01f, -2.86007941e-01f,
  8.57322738e-02f, 1.28889769e-01f, 2.48076886e-01f, 1.89375222e-01f, 2.27269053e-01f, 6.80215433e-02f, -1.07510917e-01f, 1.25307605e-01f, -2.09017321e-02f, -1.17275245e-01f,
  -1.78125560e-01f, -2.29992792e-01f, 3.18861306e-01f, 1.75300539e-01f, 3.85844290e-01f, -3.46480072e-01f, 2.82916725e-01f, 2.79054075e-01f, -6.67752400e-02f, 3.86293650e-01f,
  -3.53065729e-01f, -1.19765677e-01f, -2.96292067e-01f, 3.52665991e-01f, -4.15336415e-02f, -3.05398434e-01f, -1.19869530e-01f, 1.17110975e-01f, 4.25421953e-01f, 3.02361876e-01f,
  5.12392700e-01f, -2.35009581e-01f, 2.36616433e-01f, -2.09822565e-01f, -6.30838633e-01f, -2.78730005e-01f, -2.35122994e-01f, -1.47790551e-01f, -2.74189651e-01f, -2.02714011e-01f,
  -2.62723099e-02f, -3.35992575e-01f, -3.72260183e-01f, -3.02748203e-01f, -4.95055944e-01f, 3.28629643e-01f, -2.50934660e-01f, -2.77714938e-01f, -5.25664032e-01f, 3.13590765e-01f,
  4.65103388e-01f, -1.59994751e-01f, -1.55179590e-01f, -2.72115350e-01f, 5.55981286e-02f, 2.93476917e-02f, 1.99739039e-02f, -2.14686736e-01f, -2.34405935e-01f, 2.83704717e-02f,
  -3.80241960e-01f, 2.60901023e-02f, -1.24780297e-01f, 3.50604840e-02f, -9.07647163e-02f, -1.63586378e-01f, -5.33276610e-02f, -3.24000567e-02f, -3.30121458e-01f, -3.24129075e-01f,
  -1.53919071e-01f, 1.87874902e-02f, -4.61887866e-02f, 3.90053801e-02f, -1.48975089e-01f, 1.78491563e-01f, -2.01459855e-01f, -1.01023696e-01f, 1.20332666e-01f, 8.50892738e-02f,
  -1.42224342e-01f, -1.16641983e-01f, -1.28540635e-01f, -1.18678607e-01f, 1.54592108e-03f, 2.17385650e-01f, -2.78172076e-01f, -1.02226481e-01f, -2.84180999e-01f, -1.88227043e-01f,
  -2.00548638e-02f, -8.38789716e-02f, 1.03177212e-01f, 1.16072223e-01f, 5.06717227e-02f, -7.94164017e-02f, 1.08211458e-01f, -3.16721529e-01f, -3.38429570e-01f, -2.40305103e-02f,
  -2.81619709e-02f, -4.64926437e-02f, -1.67539388e-01f, 3.94628607e-02f, -2.03255296e-01f, 1.74551606e-01f, -2.84598529e-01f, -3.41100872e-01f, 3.49224359e-01f, -2.72810787e-01f,
  2.79338241e-01f, 2.08937854e-01f, 1.77863955e-01f, -3.76229823e-01f, -4.80262488e-01f, -2.06650689e-01f, -8.28816667e-02f, -3.28964591e-01f, 6.39398098e-02f, 2.02130526e-01f,
  1.73589021e-01f, 1.96557358e-01f, -1.89926729e-01f, -1.83026075e-01f, 1.69700325e-01f, 1.93286493e-01f, 2.16384102e-02f, 2.56631285e-01f, 3.32180232e-01f, -2.27291316e-01f,
  -3.76702696e-01f, -2.03236490e-01f, -7.14572743e-02f, 4.13104028e-01f, -3.83992530e-02f, -2.18620196e-01f, 3.56669098e-01f, -8.05535242e-02f, 2.58110702e-01f, 2.56000161e-01f,
  2.40557164e-01f, 3.62057775e-01f, -2.89924890e-01f, -2.80003399e-01f, -2.37510592e-01f, 3.74070346e-01f, 2.61035025e-01f, 1.70054275e-03f, 1.95594788e-01f, 8.69553164e-02f,
  2.63318587e-02f, -3.65013987e-01f, 1.60893947e-01f, 1.88798815e-01f, 4.78630573e-01f, -2.39870444e-01f, 1.74457937e-01f, -2.41442531e-01f, -1.91877559e-01f, -1.31136373e-01f,
  2.55925864e-01f, -2.13412732e-01f, -5.33298433e-01f, -3.27901095e-01f, 4.19687301e-01f, -4.14177239e-01f, 2.78884023e-01f, 4.43849057e-01f, -4.72909927e-01f, -2.31057733e-01f,
  -1.88957199e-01f, -2.34041765e-01f, -3.95436257e-01f, -3.73120964e-01f, 2.05761999e-01f, 4.14885342e-01f, 3.27542603e-01f, 3.33500057e-01f, -4.99591321e-01f, -1.22525394e-01f,
  -3.07456762e-01f, -2.12979950e-02f, -6.21757060e-02f, 1.53546152e-03f, 5.57607599e-02f, 5.98685518e-02f, 2.92512208e-01f, 2.81413764e-01f, 1.17156513e-01f, 4.61778380e-02f,
  -1.19744942e-01f, 1.20385617e-01f, 2.24793732e-01f, -3.84123772e-02f, 1.19215362e-02f, 1.41686738e-01f, 3.53461534e-01f, 3.23281407e-01f, 1.11848086e-01f, -8.77810717e-02f,
  7.34652430e-02f, -8.77619255e-03f, -1.50222123e-01f, 1.12089887e-01f, 6.64619058e-02f, 1.13759618e-02f, 8.68629068e-02f, 6.81288959e-03f, 9.41829458e-02f, -1.11601405e-01f,
  5.55119999e-02f, 1.76880211e-02f, 2.62036771e-02f, -3.75493169e-02f, 1.66103512e-01f, -6.87665492e-03f, 7.16209859e-02f, 2.90527344e-02f, -6.35770336e-02f, -4.46442328e-02f,
  -9.85316839e-03f, 2.07822591e-01f, 8.19758251e-02f, -4.02926095e-03f, 6.23871423e-02f, 2.42949829e-01f, 3.25707525e-01f, 2.07917079e-01f, 3.15494230e-03f, 2.62533911e-02f,
  3.26747634e-02f, 2.52732366e-01f, -1.54561475e-01f, 3.25454503e-01f, 4.72969681e-01f, 3.63818333e-02f, 1.66563630e-01f, -1.09616049e-01f, 1.33526489e-01f, 4.50093001e-01f,
  2.84915507e-01f, -2.26645648e-01f, 3.75315636e-01f, 3.57212648e-02f, -2.80568033e-01f, 1.33615404e-01f, 1.88669432e-02f, 1.86469615e-01f, -1.87473774e-01f, 3.76208991e-01f,
  1.23139881e-01f, 3.23765606e-01f, -2.23867327e-01f, 3.40743154e-01f, 1.41342148e-01f, 1.19707204e-01f, -4.28758115e-01f, 5.37747800e-01f, 4.53513891e-01f, -4.06453371e-01f,
  3.81034285e-01f, -1.70003146e-01f, 6.69469824e-03f, -1.60724610e-01f, 2.81784683e-01f, 4.98458773e-01f, 2.78247565e-01f, 1.39313489e-01f, -6.45120591e-02f, -2.13363260e-01f,
  -2.96814471e-01f, 9.56759825e-02f, -4.26952494e-03f, -9.18026492e-02f, 1.42321776e-04f, 1.16494589e-01f, -2.19352484e-01f, 2.66330540e-01f, 2.43265405e-01f, 2.97476143e-01f,
  -2.97518764e-02f, 1.49226412e-02f, 2.74642795e-01f, -3.39570940e-01f, -1.07004270e-01f, -2.00955123e-01f, 6.63116932e-01f, -9.36130658e-02f, -8.08629394e-01f, -3.31700504e-01f,
  -4.80624294e-04f, -6.47296906e-01f, 2.09137961e-01f, 5.31020269e-05f, 3.97069067e-01f, 4.17099178e-01f, 1.91479534e-01f, 5.87580979e-01f, 1.08980171e-01f, 8.92045274e-02f,
  2.61827350e-01f, 2.04743356e-01f, -1.93524137e-01f, -9.97680202e-02f, -1.40872253e-02f, -8.26484486e-02f, -3.18999410e-01f, -6.30946398e-01f, -3.44091117e-01f, -3.18524748e-01f,
  1.13357283e-01f, -2.03623891e-01f, 3.12829494e-01f, 2.31035128e-01f, 4.94348891e-02f, -4.32133898e-02f, -9.70150307e-02f, -4.55132946e-02f, -6.64336681e-02f, -1.68427318e-01f,
  2.05317631e-01f, 7.82302469e-02f, 8.65391046e-02f, 1.07548743e-01f, 1.23837590e-01f, 1.52707845e-01f, 1.60083920e-01f, 8.74353647e-02f, 2.29717240e-01f, 6.11749664e-02f,
  2.32337177e-01f, 1.18505761e-01f, -3.45760174e-02f, 1.35380238e-01f, 1.65128917e-01f, -1.19600356e-01f, 6.52664453e-02f, 3.26060712e-01f, 1.48818403e-01f, 1.19717687e-01f,
  1.65059969e-01f, -6.53393343e-02f, 1.58726364e-01f, -3.56937386e-02f, 1.27474472e-01f, 5.76450936e-02f, 8.99241194e-02f, 8.31627622e-02f, 1.10980034e-01f, 9.10423473e-02f,
  -1.45327464e-01f, 1.25876352e-01f, -3.24481055e-02f, 1.92982450e-01f, 2.49100581e-01f, -7.10527524e-02f, -1.08506948e-01f, -6.34451136e-02f, 1.53175861e-01f, -2.62347283e-03f,
  -9.79204625e-02f, -6.96555451e-02f, -1.48187831e-01f, 1.07471623e-01f, -1.12620458e-01f, -1.95461754e-02f, -5.16145349e-01f, -6.53234944e-02f, -4.40913886e-01f, -3.65388870e-01f,
  3.32977504e-01f, -3.46696854e-01f, -7.65736848e-02f, 1.53225129e-02f, 2.36707583e-01f, -4.33963925e-01f, -2.88862623e-02f, -3.08105439e-01f, -1.64663717e-01f, 2.82580387e-02f,
  4.52874005e-01f, -1.99074984e-01f, -4.99832720e-01f, -6.46555647e-02f, 3.06659453e-02f, 5.39094843e-02f, -1.04992501e-01f, 4.23511207e-01f, -3.29605453e-02f, -2.22412288e-01f,
  -3.05186957e-01f, 3.23469758e-01f, 4.44408447e-01f, 1.52952597e-01f, -1.94418139e-03f, 1.34354252e-02f, 1.31568342e-01f, -3.37932110e-01f, -1.42626584e-01f, 5.05983606e-02f,
  4.91666645e-01f, -2.68002629e-01f, -3.02015548e-03f, -1.78778097e-02f, -2.47726500e-01f, -2.79303372e-01f, 4.91315961e-01f, 2.10283667e-01f, -4.55267057e-02f, 1.91570207e-01f,
  -2.44050562e-01f, -9.18830112e-02f, -4.87518907e-01f, -2.03095451e-01f, -2.14415547e-02f, 4.12135154e-01f, -1.79569557e-01f, 4.53414768e-01f, -6.36063278e-01f, 3.39641213e-01f,
  -3.41889381e-01f, -2.45666713e-01f, -2.23137796e-01f, -3.19219440e-01f, -3.80134225e-01f, -1.90347642e-01f, 1.07820489e-01f, 2.81414330e-01f, 5.20523071e-01f, -7.02378809e-01f,
  2.41264746e-01f, -3.08264606e-02f, -6.01419687e-01f, -2.71149814e-01f, -4.53611672e-01f, 1.92220733e-01f, 1.13956548e-01f, 2.23392367e-01f, -4.32276018e-02f, 9.14905816e-02f,
  -1.41590610e-01f, 1.30154788e-01f, -4.10076790e-02f, 1.25675321e-01f, -2.95214094e-02f, 1.35914639e-01f, -2.83507910e-02f, 7.14815259e-02f, 8.52540284e-02f, 1.88067585e-01f,
  2.15415537e-04f, -1.18771598e-01f, -1.98193833e-01f, -2.30124488e-01f, -1.93241790e-01f, 3.49298343e-02f, 1.51863366e-01f, 4.36981954e-02f, 1.63896561e-01f, 1.25300745e-02f,
  -9.94780660e-02f, -1.53036132e-01f, -2.41491310e-02f, -1.07451275e-01f, -3.08157325e-01f, -1.32336039e-02f, -1.72819287e-01f, 1.30957767e-01f, 6.90278634e-02f, 2.94226930e-02f,
  1.17726531e-03f, 1.01773441e-01f, 1.51598692e-01f, 1.51763961e-03f, 1.50035352e-01f, -4.52395864e-02f, -2.25106776e-02f, 5.11052907e-02f, 2.12591253e-02f, 3.08223050e-02f,
  -4.79595270e-03f, -2.40704253e-01f, -2.21494839e-01f, 1.30396098e-01f, 1.05981074e-01f, -2.73194909e-02f, 2.39070561e-02f, 7.77582675e-02f, 7.78785422e-02f, -3.93077910e-01f,
  -3.29762578e-01f, 3.09659898e-01f, -1.61339030e-01f, -1.78516239e-01f, 1.15398742e-01f, -2.10790560e-01f, -1.19092889e-01f, -2.77932584e-01f, -5.78961112e-02f, 1.39042750e-01f,
  -2.67733812e-01f, 3.02847922e-01f, -2.60698140e-01f, 1.06853083e-01f, -2.74159074e-01f, -2.91001678e-01f, 4.47321266e-01f, 2.84613017e-02f, 9.23974738e-02f, -8.75773560e-03f,
  3.56666505e-01f, -2.63078451e-01f, -2.31154650e-01f, -1.44074798e-01f, -3.23816270e-01f, 2.00803727e-01f, -3.18812966e-01f, -3.45277399e-01f, 4.95660752e-01f, 2.71034092e-01f,
  -4.25766975e-01f, -2.90136158e-01f, -3.50448400e-01f, 9.28154513e-02f, 3.65911007e-01f, 2.47434184e-01f, 1.51428863e-01f, -3.33925575e-01f, -3.70312244e-01f, -3.48721832e-01f,
  1.40832914e-02f, -5.55749059e-01f, -8.48137438e-02f, 1.39277995e-01f, -2.42503747e-01f, -8.54243562e-02f, -4.53287840e-01f, 4.50650364e-01f, -1.79893166e-01f, 2.51835793e-01f,
  -2.90098429e-01f, 4.45607871e-01f, -1.30729988e-01f, -7.79876634e-02f, -4.76937145e-01f, 4.49921310e-01f, 3.86224985e-01f, -5.54919131e-02f, -3.35447311e-01f, -3.52841258e-01f,
  -3.82182598e-01f, 1.40656069e-01f, 5.52702658e-02f, -2.36809433e-01f, -5.68347752e-01f, -3.81376684e-01f, -2.87168592e-01f, 2.21763209e-01f, -2.46614873e-01f, 1.77400649e-01f,
  -3.06269377e-01f, 4.74121064e-01f, -4.80530888e-01f, 4.36142296e-01f, -5.88842452e-01f, -3.51595342e-01f, -6.10606857e-02f, -3.08961608e-02f, -1.96843818e-01f, 1.27260372e-01f,
  -2.07433835e-01f, 6.85720239e-03f, 4.48704436e-02f, -1.59310520e-01f, -2.75319628e-02f, 1.75996982e-02f, -3.24814051e-01f, -1.44821942e-01f, -2.56793350e-01f, -5.20386733e-02f,
  1.31906614e-01f, 6.06188253e-02f, -3.53777446e-02f, 8.21813419e-02f, -2.26380546e-02f, 1.15397185e-01f, -5.80354929e-02f, -8.27193409e-02f, -9.10335407e-02f, -1.03224367e-01f,
  -1.78473458e-01f, 1.86274331e-02f, -2.00810313e-01f, 8.47362950e-02f, 2.41395384e-02f, 7.12578967e-02f, -7.82540888e-02f, -1.03234969e-01f, 1.90246627e-01f, -1.73642844e-01f,
  8.67025331e-02f, 7.43867904e-02f, -1.97968036e-01f, -8.77321232e-03f, -8.36591199e-02f, -3.31828773e-01f, -2.22894385e-01f, -6.78710118e-02f, -1.64992046e-02f, -1.23778678e-01f,
  1.66585669e-01f, 3.76057401e-02f, -1.02668218e-01f, -1.09080255e-01f, 7.00043561e-03f, -2.59415120e-01f, -2.75789555e-02f, 1.82204898e-02f, -2.12865338e-01f, 2.57198840e-01f,
  -1.10537425e-01f, -2.59792298e-01f, -2.20179632e-01f, 1.13498531e-01f, 1.61934301e-01f, -1.29951566e-01f, 2.35333651e-01f, -2.20212713e-01f, -1.60953641e-01f, 3.01220924e-01f,
  -1.14505872e-01f, 2.31317818e-01f, 3.11354578e-01f, -2.25049794e-01f, -1.19370170e-01f, -3.44577104e-01f, -9.21989903e-02f, -9.00281668e-02f, 1.36437088e-01f, 3.01524967e-01f,
  2.63796926e-01f, -3.37709099e-01f, 1.88635007e-01f, -2.04400346e-01f, -2.99644679e-01f, -1.98090030e-03f, 3.64387780e-02f, -1.48653910e-01f, -3.11129451e-01f, 3.10922209e-02f,
  1.08472714e-02f, -4.58152182e-02f, -7.56262627e-04f, 2.25306109e-01f, -2.51481440e-02f, -2.57400274e-01f, -2.03536868e-01f, 4.51793037e-02f, -2.21854880e-01f, 2.46973932e-01f,
  1.68839142e-01f, -7.52984732e-02f, -1.87535629e-01f, 2.66919136e-01f, 2.76144773e-01f, 1.36983842e-01f, 1.58553541e-01f, 4.61745560e-02f, 9.07018334e-02f, 2.48663619e-01f,
  -3.82274717e-01f, 4.15489852e-01f, 8.95933583e-02f, -2.21647084e-01f, 2.28617221e-01f, -3.66097629e-01f, -3.71623844e-01f, -2.68913567e-01f, 1.67884395e-01f, 3.62526715e-01f,
  -2.54718065e-01f, 1.56157184e-02f, 2.43254393e-01f, -4.10007119e-01f, -8.17216039e-02f, -1.20319895e-01f, 3.97139519e-01f, -3.16694975e-01f, -2.49916300e-01f, -3.62558275e-01f,
  -2.51710802e-01f, -3.55034947e-01f, 1.57813922e-01f, 2.96062589e-01f, -4.11310375e-01f, -1.83694541e-01f, 2.00029705e-02f, 4.11185212e-02f, -8.84583667e-02f, -4.95333634e-02f,
  1.21832147e-01f, 1.44703671e-01f, -2.03577071e-01f, 1.41532654e-02f, -6.08946718e-02f, -2.73012578e-01f, 3.04930639e-02f, -1.33713886e-01f, 9.50894058e-02f, -4.94887121e-02f,
  -1.88774437e-01f, 9.22764465e-03f, 4.38384637e-02f, 1.10400125e-01f, -1.50231898e-01f, 7.61595741e-02f, 9.01923776e-02f, 8.78095627e-03f, 2.28597119e-01f, 1.36242270e-01f,
  -4.97230813e-02f, 1.00350007e-01f, -1.50570452e-01f, 3.70978341e-02f, -5.65544628e-02f, 1.47925526e-01f, 6.03112169e-02f, -3.13006073e-01f, -9.75430831e-02f, -2.61273445e-03f,
  -2.05272324e-02f, 8.13047215e-02f, -1.85867682e-01f, -1.72887426e-02f, -3.32802355e-01f, 2.43075192e-03f, 3.12370136e-02f, 1.85019165e-01f, -9.33780000e-02f, -1.68348283e-01f,
  -3.84263583e-02f, 8.29124898e-02f, 3.60677540e-02f, -4.27430049e-02f, -3.54056776e-01f, -1.28757834e-01f, -3.25256974e-01f, -1.64402127e-02f, 3.48458499e-01f, 3.28443944e-01f,
  1.94239616e-01f, -1.45603403e-01f, 2.14075277e-04f, 2.19057992e-01f, 6.44084141e-02f, 2.10807875e-01f, 2.01296091e-01f, -7.34795025e-03f, -3.70699555e-01f, -5.64232953e-02f,
  2.64991671e-01f, -3.51220727e-01f, 3.44094127e-01f, -2.04781994e-01f, 3.52647960e-01f, -1.82180464e-01f, 1.61999017e-01f, 2.24764004e-01f, -3.69092301e-02f, 2.03248143e-01f,
  -3.94170843e-02f, 1.22286081e-01f, -1.49215236e-01f, 2.93277889e-01f, 2.66702056e-01f, -3.75639766e-01f, 1.15827464e-01f, -1.57995358e-01f, -9.96304899e-02f, -1.75530791e-01f,
  -1.66763037e-01f, 1.69684231e-01f, -3.13765675e-01f, 2.63775527e-01f, 1.31500974e-01f, 2.87650168e-01f, 2.70555466e-01f, -2.91230261e-01f, 2.14015543e-01f, 3.18053186e-01f,
  3.41067344e-01f, -1.96610570e-01f, 2.97650874e-01f, 2.99650937e-01f, 2.59474248e-01f, 2.31547490e-01f, -4.66861650e-02f, -3.43947172e-01f, -2.98936188e-01f, -1.25861660e-01f,
  2.40080878e-01f, -3.80487174e-01f, -2.23189309e-01f, 3.75839621e-02f, -3.99103314e-01f, 3.17048341e-01f, -2.70285308e-01f, -8.34172890e-02f, 4.27159101e-01f, -1.48018330e-01f,
  5.23292303e-01f, -2.30762839e-01f, -2.69998789e-01f, 1.11309446e-01f, -2.24480405e-01f, 1.10125907e-01f, -3.67336899e-01f, -1.98842689e-01f, -2.68791709e-02f, -5.20184375e-02f,
  -3.67122084e-01f, -6.78313226e-02f, 3.71468551e-02f, 7.38753425e-03f, 9.67241973e-02f, -7.03317896e-02f, 1.98471114e-01f, -1.19374193e-01f, 2.78289001e-02f, 6.17015213e-02f,
  1.04200214e-01f, 1.33241424e-02f, 1.55074537e-01f, 1.60390899e-01f, -6.51645735e-02f, 1.75203010e-01f, -8.37408528e-02f, -2.21860975e-01f, 1.84452638e-01f, 1.34543821e-01f,
  6.68667781e-04f, 3.23523059e-02f, -3.55628319e-02f, 7.19487965e-02f, 1.63056582e-01f, -8.12829938e-03f, 8.37312117e-02f, 1.03818618e-01f, 2.73794800e-01f, 3.63392048e-02f,
  -5.68525121e-03f, -6.31961524e-02f, 4.49445972e-04f, 1.89412445e-01f, -1.10569261e-01f, 1.92562953e-01f, 1.43359199e-01f, -5.77254631e-02f, 2.32584197e-02f, -9.20364857e-02f,
  1.31293371e-01f, 1.05537064e-01f, -2.88031041e-03f, 1.00768276e-01f, 8.88060406e-03f, -7.73050785e-02f, -1.43927827e-01f, -3.24208736e-02f, -1.95070601e-03f, 1.07698413e-02f,
  1.35670677e-01f, 1.92855015e-01f, 1.69570535e-01f, 3.15547973e-01f, -2.33351603e-01f, 3.07059139e-01f, -1.75785840e-01f, 2.91006546e-02f, -3.56141150e-01f, -1.89879969e-01f,
  3.63701999e-01f, 3.91369820e-01f, -1.11993574e-01f, 2.05836251e-01f, 1.20079115e-01f, 2.63145715e-01f, 2.50334628e-02f, -4.00501341e-01f, -1.46169782e-01f, -2.43679971e-01f,
  1.72996633e-02f, 2.33353779e-01f, -1.88980877e-01f, 4.30472344e-01f, 2.22079515e-01f, 1.50654078e-01f, -1.59120396e-01f, 1.28931955e-01f, 3.56965028e-02f, -1.38885960e-01f,
  -3.22414368e-01f, 3.05538159e-02f, -4.50135946e-01f, 2.43099704e-01f, -2.07126096e-01f, -3.44849110e-01f, 9.75094214e-02f, -2.66394734e-01f, -2.28017360e-01f, 1.05173953e-01f,
  2.79234201e-01f, 3.06120306e-01f, -4.49273527e-01f, -1.42553240e-01f, -3.29231657e-02f, 4.49936420e-01f, -1.89938426e-01f, -3.88813347e-01f, -3.43611032e-01f, 4.15032804e-01f,
  4.96303350e-01f, -3.98366868e-01f, 5.00980616e-01f, -3.77944171e-01f, -5.30256867e-01f, -3.53958875e-01f, -3.52542907e-01f, -3.83018225e-01f, -1.68239757e-01f, -3.10301006e-01f,
  4.63264346e-01f, -4.11091268e-01f, -1.78073838e-01f, -3.81102920e-01f, -2.42217347e-01f, -3.87954205e-01f, -2.28827283e-01f, 4.77147996e-01f, -6.25231266e-02f, -2.57004440e-01f,
  -5.32634482e-02f, -2.92037725e-01f, -2.26727098e-01f, -5.54208517e-01f, -2.45622382e-01f, -5.62654316e-01f, -1.64068282e-01f, 2.80469567e-01f, 7.26023674e-01f, -1.23261318e-01f,
  1.98307246e-01f, 1.24794245e-02f, -3.35257240e-02f, 2.29953066e-01f, 3.34034860e-02f, -2.17818305e-01f, 1.05097085e-01f, 1.28206566e-01f, 7.30287358e-02f, -2.13350087e-01f,
  2.32805014e-01f, 1.78942144e-01f, 1.69824332e-01f, 6.33246973e-02f, -1.94650590e-01f, 8.40920433e-02f, 6.75232336e-02f, 8.82207826e-02f, 4.45020758e-02f, -5.35930693e-02f,
  2.28976041e-01f, -7.75981620e-02f, 3.86368409e-02f, 1.16076738e-01f, -1.50194362e-01f, 4.41123396e-02f, -4.69127558e-02f, 2.29685232e-01f, 8.93879309e-02f, 1.32838175e-01f,
  1.42776251e-01f, -9.08088684e-02f, -1.33145630e-01f, 2.45328039e-01f, 1.90309256e-01f, 1.43524200e-01f, 1.29677663e-02f, 1.36857897e-01f, -4.41294722e-02f, 8.24775100e-02f,
  1.00224772e-02f, 1.33359972e-02f, 1.03691384e-01f, -2.61383858e-02f, -4.75546159e-02f, 9.24752280e-03f, 8.31538364e-02f, -3.07300524e-03f, 1.98839933e-01f, -3.88809666e-03f,
  2.00099513e-01f, 3.04916382e-01f, 3.98622781e-01f, -3.12542409e-01f, -1.21611916e-01f, 1.77216735e-02f, 2.91994721e-01f, 4.26471472e-01f, -2.29505315e-01f, 2.14293540e-01f,
  -3.05571109e-01f, -1.23689301e-01f, 4.30285931e-02f, -2.10078701e-01f, 4.14820611e-01f, 3.65633398e-01f, 3.97276551e-01f, 2.17893630e-01f, -3.05388421e-01f, -3.46664011e-01f,
  -3.40855904e-02f, 1.47746339e-01f, -2.88298517e-01f, 7.41401613e-02f, 3.09592187e-01f, -3.37307215e-01f, -2.62953490e-01f, -3.52262616e-01f, -1.81880370e-01f, -3.62452343e-02f,
  9.95977502e-03f, 1.70211762e-01f, -3.80835742e-01f, 4.53828394e-01f, -2.48604000e-01f, -3.45013708e-01f, -1.64440900e-01f, -3.43417495e-01f, 4.62580979e-01f, 2.78497487e-01f,
  7.36148283e-02f, -4.41375405e-01f, -3.63935769e-01f, 8.94262344e-02f, 3.46655101e-01f, 2.33745947e-01f, -3.36929828e-01f, -1.93050265e-01f, 2.73597866e-01f, 2.35360861e-01f,
  -1.54086962e-01f, -1.66121036e-01f, -6.16367519e-01f, 1.99874088e-01f, -1.16451867e-01f, -3.38699847e-01f, 3.33224475e-01f, -2.90889412e-01f, -2.99689084e-01f, -2.82575011e-01f,
  -4.62661982e-02f, 2.41554618e-01f, -4.97208625e-01f, -2.30426922e-01f, 3.10051948e-01f, -2.13246360e-01f, -2.75147587e-01f, -2.42868006e-01f, -4.06798184e-01f, -3.16669494e-01f,
  -3.17022294e-01f, -3.99658680e-01f, 3.53094757e-01f, 7.86429197e-02f, 5.38281858e-01f, -3.25336725e-01f, -2.98279434e-01f, 1.91510648e-01f, -1.53996855e-01f, 1.25931412e-01f,
  -1.10594451e-01f, -8.88220519e-02f, 1.13357514e-01f, 4.69700024e-02f, -2.76320390e-02f, 3.90395559e-02f, 3.49640362e-02f, 3.50691192e-02f, 4.61219884e-02f, -7.40666734e-03f,
  1.29377320e-01f, 1.16002433e-01f, 9.85481143e-02f, 1.80208549e-01f, 8.68491083e-02f, -1.33256570e-01f, 4.12885547e-02f, -2.52463996e-01f, 9.91188586e-02f, -1.23152807e-01f,
  -5.02294637e-02f, 1.27523188e-02f, 1.23252809e-01f, 9.89233777e-02f, 1.32326670e-02f, -2.28738673e-02f, -1.28121078e-02f, 3.43515761e-02f, -6.99482709e-02f, 9.43870693e-02f,
  1.16638340e-01f, 1.99788198e-01f, 5.02261594e-02f, 3.84465344e-02f, 1.04872212e-01f, 1.53102323e-01f, 4.48746048e-02f, 1.34071454e-01f, 1.02978259e-01f, -1.45096138e-01f,
  -3.09021562e-01f, 1.96112528e-01f, 9.60289091e-02f, -9.98194236e-03f, 3.49765345e-02f, -4.57301475e-02f, 1.50177002e-01f, -4.56109736e-03f, 2.11549044e-01f, -3.67730677e-01f,
  3.62632453e-01f, 3.17658991e-01f, 1.96977362e-01f, 2.03018803e-02f, 3.15204948e-01f, -3.23500991e-01f, 2.45905980e-01f, 1.31240517e-01f, 4.66798991e-02f, -3.86100143e-01f,
  -2.93908596e-01f, -6.99746162e-02f, 2.91820943e-01f, -2.63439894e-01f, 1.68115243e-01f, -1.62099138e-01f, -4.00503069e-01f, -1.48611918e-01f, 2.73046255e-01f, 7.90013224e-02f,
  3.64306003e-01f, -3.74048412e-01f, -3.02068830e-01f, -3.13253909e-01f, 1.51925132e-01f, 2.43119419e-01f, -2.53306329e-01f, -2.31020615e-01f, 2.86139488e-01f, -3.82023364e-01f,
  -1.14979357e-01f, 2.26918250e-01f, 3.49624872e-01f, 4.00768220e-01f, 2.99747229e-01f, 6.28707334e-02f, -9.39853787e-02f, -3.74902517e-01f, -9.21319500e-02f, 3.05113167e-01f,
  -4.19207245e-01f, -2.61337101e-01f, -2.73162335e-01f, 1.08313955e-01f, -2.09120840e-01f, -3.06583762e-01f, -3.43018711e-01f, -1.65842369e-01f, -3.47433537e-01f, 2.68801302e-01f,
  -1.28636464e-01f, -2.09826842e-01f, -1.75337851e-01f, -1.27242088e-01f, 3.02444100e-01f, -4.66926932e-01f, -1.20081164e-01f, -3.14608574e-01f, 2.48909056e-01f, -8.62453952e-02f,
  -3.16655219e-01f, -3.70689154e-01f, -4.49025720e-01f, -1.10637464e-01f, 3.39549214e-01f, 7.08259344e-01f, -3.84880722e-01f, -2.33106390e-01f, -2.08378121e-01f, 5.22547841e-01f,
  -4.65942085e-01f, -2.32796580e-01f, -3.99251789e-01f, -4.68995184e-01f, -1.77891791e-01f, -1.28885686e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  3.16503048e-02f, -1.80454701e-02f, -7.56791607e-02f, 4.00753543e-02f, -3.71088795e-02f, 3.40877511e-02f, -8.12025294e-02f, 8.42873529e-02f, -4.82244380e-02f, -4.26745526e-02f,
  -3.35258767e-02f, 1.45415692e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    