/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.05949652e-01f, 1.77077949e-01f, -3.09012204e-01f, 3.48682255e-01f, -5.98885072e-03f, -1.57331020e-01f, -1.79167792e-01f, 1.91869549e-02f, 7.08557852e-03f, 7.88878947e-02f,
  4.65943545e-01f, 2.77735114e-01f, 2.27180228e-01f, 8.54770765e-02f, -8.67462903e-02f, -2.28593960e-01f, -2.21375540e-01f, -4.15983796e-01f, -2.05486327e-01f, -1.53697222e-01f,
  4.38103564e-02f, -1.39748856e-01f, -5.96475676e-02f, -9.99012366e-02f, -1.57759488e-01f, -8.91850591e-02f, -1.98420495e-01f, -2.09464133e-01f, -2.22794369e-01f, -4.51237828e-01f,
  -1.11555949e-01f, 1.93321943e-01f, -4.80960310e-02f, 1.34003043e-01f, -6.58962056e-02f, -9.59436819e-02f, 6.82771653e-02f, -2.18801051e-02f, 9.10481960e-02f, -5.78498393e-02f,
  7.29994252e-02f, 9.55885276e-02f, -2.63618641e-02f, -2.97646094e-02f, -5.72605096e-02f, 2.27259081e-02f, 8.26521888e-02f, 1.54067893e-02f, 1.28505202e-02f, 7.94443563e-02f,
  1.05652526e-01f, -2.47788280e-02f, 1.11842609e-03f, 5.22964634e-02f, 5.74718118e-02f, -5.43324351e-02f, -5.74100651e-02f, -1.35705480e-02f, -8.23241994e-02f, -1.40628770e-01f,
  -9.65370834e-02f, -1.15066774e-01f, -3.62578593e-02f, 1.25317544e-01f, 9.09714624e-02f, 4.48089130e-02f, 7.66052864e-03f, 4.49475646e-02f, -1.06904872e-01f, -4.34485404e-03f,
  5.45946583e-02f, -3.87500040e-02f, -1.29252309e-02f, -2.18157424e-03f, -4.63921130e-02f, -5.25217392e-02f, -6.41177148e-02f, 1.38458321e-02f, 7.17234835e-02f, 3.42099667e-02f,
  6.96535334e-02f, 3.15733440e-02f, 3.28940749e-02f, 1.23692052e-02f, -1.24923326e-03f, -1.36623951e-02f, 3.69883589e-02f, 1.39390081e-02f, 1.69145852e-01f, -8.02635495e-03f,
  1.47204280e-01f, 9.99869406e-02f, 6.52821222e-03f, 2.35468820e-02f, -1.40318768e-02f, 1.06745511e-02f, 2.58847065e-02f, 6.33582426e-03f, -3.46784964e-02f, 3.81960645e-02f,
  5.01399934e-02f, -2.60886345e-02f, 1.41876740e-02f, 6.73595676e-03f, -2.56905593e-02f, 9.87345800e-02f, 1.59571394e-01f, 1.07474625e-02f, -2.75111143e-02f, 9.54056438e-03f,
  7.26239532e-02f, -3.10814809e-02f, -1.73518397e-02f, 3.01450621e-02f, 1.96120087e-02f, -4.73773181e-02f, 8.76632985e-03f, -1.20825626e-01f, -1.55737519e-01f, -7.62040401e-03f,
  7.10550606e-01f, 2.76922695e-02f, 2.47664839e-01f, 1.39104635e-01f, 2.29130819e-01f, 1.41064048e-01f, 1.82212770e-01f, 4.64946544e-03f, -1.39569407e-02f, 1.67792633e-01f,
  -6.68115541e-02f, -1.56146020e-01f, -8.91200975e-02f, -3.25777322e-01f, -2.18369991e-01f, 2.02760965e-01f, 2.20809609e-01f, 4.53765392e-02f, 1.58935320e-03f, -8.49573240e-02f,
  -3.47925164e-02f, 4.21968587e-02f, 5.35517670e-02f, -1.40233323e-01f, 2.69451171e-01f, 2.70135254e-01f, 8.03715661e-02f, 2.37787619e-01f, -5.65794355e-04f, 3.17956924e-01f,
  2.98137128e-01f, 8.21962431e-02f, -9.97723341e-02f, -1.54215932e-01f, -8.48718435e-02f, -5.57165667e-02f, -3.52541618e-02f, -2.72062141e-02f, 4.62678000e-02f, -2.08427198e-02f,
  -4.88401726e-02f, -5.61479516e-02f, 1.87098291e-02f, -6.80315793e-02f, 6.75722286e-02f, -5.61120249e-02f, -1.04037791e-01f, -1.17117487e-01f, -1.37555912e-01f, -8.95109028e-02f,
  -1.34981319e-01f, -1.21306442e-02f, 1.06174186e-01f, -1.63174197e-01f, -9.31142345e-02f, -1.28591999e-01f, 2.79994849e-02f, -1.77014600e-02f, 7.41481408e-02f, 3.22512358e-01f,
  -2.35991683e-02f, 1.08414315e-01f, -6.31021988e-03f, 1.87769288e-03f, 1.22102074e-01f, 5.29530421e-02f, 2.43542492e-02f, 9.01594982e-02f, 4.11476642e-02f, 1.19234391e-01f,
  -5.07670566e-02f, -9.15948185e-04f, -9.16114822e-02f, 1.03330202e-02f, -1.10309767e-02f, -1.15248589e-02f, -6.53871074e-02f, -5.00321668e-03f, -1.84207354e-02f, 6.62076250e-02f,
  6.67105317e-02f, 5.63690290e-02f, 7.88508076e-03f, -2.25404892e-02f, -9.29685757e-02f, -5.45981750e-02f, -5.45173027e-02f, -6.57190979e-02f, 1.34439263e-02f, 2.39772163e-02f,
  -7.21170604e-02f, -3.13102275e-01f, 1.73489183e-01f, -2.50918008e-02f, 1.24943666e-02f, -1.27845913e-01f, -3.10621900e-03f, -5.67520000e-02f, -1.46908648e-02f, 4.10554968e-02f,
  -2.37460341e-02f, -4.16209223e-03f, 3.30511928e-02f, -1.83262676e-02f, 7.08528683e-02f, 7.91200995e-02f, 5.98864118e-03f, 1.17815621e-01f, -8.28519277e-03f, 4.06375937e-02f,
  3.74472216e-02f, 1.43134788e-01f, 1.04958020e-01f, 1.56083956e-01f, 4.50133719e-02f, 8.38317350e-02f, 1.11726195e-01f, 1.70065254e-01f, 9.93689429e-03f, 2.97516912e-01f,
  4.49713133e-02f, -6.15002811e-01f, 1.51280090e-01f, 1.17005780e-02f, 3.40743512e-02f, -1.01490751e-01f, -4.80650634e-01f, -3.78254563e-01f, 3.30996960e-02f, -1.98610008e-01f,
  7.50034973e-02f, 5.22024632e-01f, 4.23356146e-01f, 2.97791511e-01f, 3.88663262e-03f, -3.16065103e-01f, -2.37659827e-01f, 3.46905053e-01f, 4.38622624e-01f, 1.61906347e-01f,
  -9.16023403e-02f, -1.59590483e-01f, -8.14068094e-02f, -2.63035055e-02f, -6.45800903e-02f, 1.15674719e-01f, -2.03952804e-01f, -1.59101207e-02f, -6.17286563e-03f, 3.75295915e-02f,
  4.76999700e-01f, -2.75747955e-01f, 3.46069694e-01f, 1.13284238e-01f, 7.14008883e-02f, -3.12578566e-02f, 3.09838001e-02f, -1.95023175e-02f, 2.68862303e-02f, -7.16810152e-02f,
  7.31663257e-02f, 1.64315730e-01f, 1.39679596e-01f, -5.49642853e-02f, -1.22378856e-01f, -8.03729370e-02f, 1.32592060e-02f, -3.28982323e-02f, 2.27908399e-02f, -4.63778786e-02f,
  1.08959325e-01f, 8.80461037e-02f, 9.39123705e-02f, -1.69596542e-02f, 4.11981996e-03f, 2.55812228e-01f, -5.77150434e-02f, 5.72028104e-03f, -9.32902694e-02f, -1.23529226e-01f,
  1.46968648e-01f, -9.71503183e-02f, -7.43552148e-02f, -1.07929088e-01f, -8.73770118e-02f, -9.18733105e-02f, 1.52396010e-02f, -7.10230693e-02f, -8.85627121e-02f, -1.08934097e-01f,
  -6.69438466e-02f, -1.14681534e-01f, -8.13347995e-02f, -1.36158392e-01f, -5.12503460e-02f, -1.29635349e-01f, -6.50756359e-02f, -1.24587156e-01f, -6.06669001e-02f, -1.87768191e-01f,
  -3.91730107e-02f, 1.74210723e-02f, -1.55206755e-01f, -1.44634649e-01f, -1.37071148e-01f, -4.70277108e-02f, -1.11687824e-01f, -1.34087056e-01f, -1.76902980e-01f, -1.13713033e-01f,
  -7.51501396e-02f, 3.32328230e-01f, 1.56794652e-01f, 1.50568843e-01f, 6.73302114e-02f, 4.41517867e-02f, 9.46553722e-02f, 7.72327334e-02f, 6.99301213e-02f, 1.83697250e-02f,
  9.53005627e-02f, 1.21334970e-01f, 6.26403242e-02f, 1.31973512e-02f, 1.11581445e-01f, 7.50647932e-02f, -4.08755690e-02f, 2.04130784e-01f, 3.02679595e-02f, 4.05657031e-02f,
  -1.06875591e-01f, 4.20390069e-02f, 1.46836445e-01f, 9.15536731e-02f, 9.44887027e-02f, 1.82710975e-01f, 8.85349438e-02f, 9.52242389e-02f, 2.46591538e-01f, -1.49257198e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.70632875e+00f, 8.46258998e-02f, -1.97642040e+00f, 1.41597912e-01f, -1.08723199e+00f, -8.27194571e-01f, -4.51742224e-02f, 6.26933575e-01f, 2.81921655e-01f, -2.39949808e-01f,
  -3.46698552e-01f, -2.03811184e-01f, -5.72189987e-01f, -2.11453289e-01f, 3.91145378e-01f, -6.05425239e-01f, -8.25556815e-01f, -6.56165302e-01f, -2.59791195e-01f, 1.23284673e-02f,
  1.69650599e-01f, 7.61718526e-02f, 4.06451911e-01f, 6.30417913e-02f, -6.93566561e-01f, -5.76254487e-01f, -1.03492761e+00f, -7.91000605e-01f, -4.88625348e-01f, -9.23693776e-01f,
  -1.14298034e+00f, -2.87156641e-01f, -2.50035375e-01f, 2.10202038e-01f, -6.87610032e-03f, 2.33591616e-01f, 2.21231915e-02f, 1.77155182e-01f, 3.58082145e-01f, -1.15525196e-04f,
  -2.30690062e-01f, 1.73942801e-02f, -1.13402769e-01f, -1.10067174e-01f, -2.74445303e-02f, 1.49353147e-01f, 1.26578540e-01f, -1.29211292e-01f, -9.66567323e-02f, -4.16600883e-01f,
  -4.73768823e-02f, -3.73772651e-01f, -2.86942482e-01f, 3.14783715e-02f, -2.67488539e-01f, -4.34516191e-01f, -4.30985451e-01f, -1.99130312e-01f, -2.20542684e-01f, 1.97400570e-01f,
  1.00086749e-01f, -6.21450767e-02f, 4.69466895e-02f, 8.54265764e-02f, 4.24916923e-01f, -1.32228564e-02f, -7.01431260e-02f, 5.68816960e-02f, 5.85014932e-03f, 1.84326544e-01f,
  -3.39425318e-02f, 1.68927498e-02f, 1.17292553e-01f, 1.18570901e-01f, -2.35575184e-01f, -2.41260231e-01f, 1.54433101e-01f, 1.60107046e-01f, 8.62229392e-02f, 9.99173224e-02f,
  -1.06905915e-01f, -2.19156772e-01f, -1.02115735e-01f, 3.25569004e-01f, -1.54109105e-01f, -2.13823617e-01f, -3.90164484e-03f, 2.49514297e-01f, 1.16435252e-01f, -9.41640958e-02f,
  7.66416788e-02f, -4.72499393e-02f, -1.05246305e-01f, -8.16641822e-02f, 2.02118754e-02f, 1.48173282e-02f, -2.00352930e-02f, 2.69063503e-01f, -1.03609204e-01f, -2.48224035e-01f,
  -2.97773510e-01f, -2.05446959e-01f, -1.19835380e-02f, 3.05610858e-02f, 8.27080905e-02f, -1.08688148e-02f, 3.44739586e-01f, -2.68569499e-01f, 1.41242951e-01f, -5.71982712e-02f,
  3.79298419e-01f, 4.82566148e-01f, 5.41989446e-01f, 4.40070517e-02f, -1.03076734e-01f, 3.44623402e-02f, -9.88138020e-02f, -1.44784629e-01f, 7.82649219e-02f, 9.06561971e-01f,
  9.79789793e-01f, -8.23560238e-01f, 1.41495079e-01f, 4.68670987e-02f, -1.04754949e+00f, -8.20660830e-01f, -9.63134170e-01f, -3.04215193e-01f, -1.02195889e-01f, -2.49986961e-01f,
  -3.44455630e-01f, 3.81298423e-01f, 3.10290992e-01f, 5.97695589e-01f, 5.61649382e-01f, -3.10239434e-01f, 1.08532898e-01f, 8.27199996e-01f, 7.56188035e-01f, 1.99371815e-01f,
  2.94699948e-02f, 3.99196088e-01f, 9.44604576e-01f, 5.72456598e-01f, -2.84161810e-02f, 1.95821345e-01f, 5.82195260e-03f, 1.17177576e-01f, -7.88960159e-02f, 6.52535379e-01f,
  1.86359867e-01f, -6.31920844e-02f, 3.08657195e-02f, 2.07931891e-01f, -9.07007605e-02f, 2.35381469e-01f, -7.39798024e-02f, 3.62320393e-01f, 1.10165430e-02f, 2.07442433e-01f,
  -2.14282185e-01f, 2.49396130e-01f, -4.65719253e-02f, 1.25844598e-01f, -2.03903273e-01f, -1.74041152e-01f, 4.07373846e-01f, 5.80304325e-01f, 3.09146583e-01f, 5.86768351e-02f,
  -5.64675108e-02f, -3.12920541e-01f, -5.27720749e-01f, -4.38030839e-01f, -6.25485405e-02f, 2.70962268e-01f, -2.06695169e-01f, 1.77931488e-01f, 3.35360020e-02f, 3.28699887e-01f,
  -3.94775486e-03f, 1.42522171e-01f, -7.70096183e-02f, 5.48387459e-03f, 4.98137176e-02f, -9.56858322e-02f, 4.47379723e-02f, -3.63196842e-02f, 1.04180664e-01f, -1.11437947e-01f,
  5.17322011e-02f, 9.09726992e-02f, 1.18022405e-01f, -1.49388924e-01f, 6.34786040e-02f, -7.76916966e-02f, -5.06595857e-02f, 2.36799836e-01f, -5.55129908e-02f, -3.41664106e-02f,
  6.92221522e-02f, -8.57346058e-02f, 4.80953865e-02f, 4.75139797e-01f, -8.55889618e-02f, 9.29192752e-02f, 1.13997348e-01f, 1.38100788e-01f, -1.07143126e-01f, -1.69106536e-02f,
  -3.44169110e-01f, 2.78914213e-01f, -3.09759136e-02f, 1.67234957e-01f, -3.39279711e-01f, -1.33931205e-01f, -1.85229301e-01f, 2.22497620e-02f, -1.69607863e-01f, 8.10282528e-02f,
  -4.38129604e-01f, 5.15138637e-03f, -1.43379807e-01f, 7.56683424e-02f, -4.54621564e-04f, -3.56835634e-01f, -2.98080653e-01f, -7.78953508e-02f, 1.43765703e-01f, -6.77932426e-02f,
  -4.18414548e-02f, -5.24016261e-01f, -3.29774350e-01f, -3.92814279e-01f, -4.56873506e-01f, -3.59198004e-01f, -3.97020757e-01f, -4.08576369e-01f, -4.74840730e-01f, -5.12920916e-01f,
  1.33708274e+00f, -1.16458678e+00f, 6.85949206e-01f, 3.68572682e-01f, 2.36272082e-01f, 5.00039577e-01f, -2.39794399e-03f, 1.72842309e-01f, 2.75773257e-01f, -4.79287244e-02f,
  -2.76227772e-01f, -9.72141549e-02f, -2.25442544e-01f, -8.31917152e-02f, -3.73847000e-02f, -4.21049185e-02f, 2.05531940e-01f, 5.91281831e-01f, 6.11038387e-01f, 2.57206649e-01f,
  -2.79739916e-01f, -1.01775192e-01f, 5.92902005e-02f, 2.73716208e-02f, -2.36844853e-01f, -3.39805335e-02f, -2.11174920e-01f, -2.10748225e-01f, -2.97818244e-01f, -1.42671838e-01f,
  1.73348933e-01f, -3.56855094e-02f, 1.61036119e-01f, -3.30216289e-01f, -1.56415373e-01f, 3.89314108e-02f, 1.22153580e-01f, -9.53306779e-02f, -1.28417715e-01f, -9.20290649e-02f,
  -7.12662637e-02f, -8.29525813e-02f, 3.90656367e-02f, -5.15379198e-03f, -2.42160112e-02f, 1.18485592e-01f, 5.57364002e-02f, 3.21280099e-02f, -8.13539922e-02f, -7.70403147e-02f,
  -1.75486639e-01f, 1.10076338e-01f, 6.92461878e-02f, 7.54751191e-02f, 3.08589526e-02f, 1.20688863e-01f, -1.70164704e-01f, 1.41223287e-02f, 1.04938269e-01f, 3.48307341e-02f,
  -4.07712944e-02f, 1.88864350e-01f, 1.30491778e-01f, 2.86191422e-02f, 9.50687081e-02f, 1.91564426e-01f, 1.84589684e-01f, 1.65151834e-01f, 1.81824952e-01f, 6.36281073e-02f,
  3.37446257e-02f, 4.93566804e-02f, 6.54091686e-02f, -2.47084093e-03f, -6.31914474e-03f, 1.27129806e-02f, 8.44234824e-02f, -2.40714148e-01f, 1.55453205e-01f, -4.63431403e-02f,
  2.00075746e-01f, 4.29159515e-02f, -7.22257718e-02f, 3.28767560e-02f, 1.38496822e-02f, 1.08857393e-01f, 9.87829268e-02f, -1.67816639e-01f, -1.72584146e-01f, -1.40292257e-01f,
  -5.66237569e-01f, 2.17970088e-01f, 1.55244842e-01f, -1.35550454e-01f, -1.13327704e-01f, -1.03628255e-01f, 6.05747197e-03f, -1.27216488e-01f, -2.79111296e-01f, -1.94049656e-01f,
  -2.35524982e-01f, 5.69702722e-02f, -1.22221947e-01f, -1.25614434e-01f, 2.46453211e-01f, -7.91823398e-03f, -1.69635773e-01f, 1.19709387e-01f, -1.24114856e-01f, -1.27398089e-01f,
  -2.06930086e-01f, 3.24313611e-01f, 3.30641598e-01f, 2.79590398e-01f, -5.85566275e-02f, 3.19569021e-01f, 3.50226350e-02f, -3.14565860e-02f, 1.02260634e-01f, 7.57319555e-02f,
  1.02512658e+00f, 5.77040493e-01f, 7.46951044e-01f, 1.63049057e-01f, 6.55705333e-02f, -2.32342318e-01f, -1.96479172e-01f, -2.66761869e-01f, -2.01941982e-01f, 2.22836390e-01f,
  1.42711282e-01f, -3.87222975e-01f, -1.55019641e-01f, -3.95097792e-01f, -3.54933381e-01f, -8.87850598e-02f, 3.72778736e-02f, -1.35026976e-01f, -7.11989880e-01f, -7.44866908e-01f,
  -8.67770195e-01f, -1.81262102e-02f, 1.84726790e-01f, -8.88582915e-02f, 3.87069434e-01f, -3.21997583e-01f, 6.83028460e-01f, 7.30650783e-01f, 3.06458771e-01f, 6.08692944e-01f,
  4.36507821e-01f, 8.87564659e-01f, -8.22159767e-01f, -6.79128841e-02f, 4.40183699e-01f, 4.63433042e-02f, 2.18894258e-02f, 2.61118829e-01f, 1.45386606e-01f, 8.41250196e-02f,
  2.97172636e-01f, 1.52679071e-01f, 2.77679473e-01f, 9.65501368e-03f, 2.91207172e-02f, -2.85494000e-01f, 1.71649963e-01f, -1.05928980e-01f, -1.08209357e-01f, 1.48899660e-01f,
  -3.62257153e-01f, 2.11886019e-01f, 4.42668736e-01f, -2.43321985e-01f, 1.94848701e-01f, -3.05801541e-01f, 3.71174932e-01f, 1.00024231e-01f, 3.84581462e-02f, 3.92471641e-01f,
  -5.22253029e-02f, 1.03845008e-01f, 1.03845373e-01f, 3.05723548e-02f, -4.49668951e-02f, 1.48180470e-01f, 4.13763300e-02f, 5.04730316e-03f, -1.59606248e-01f, 1.87306270e-01f,
  -1.13833304e-02f, -1.81232356e-02f, 7.55914003e-02f, 8.36634785e-02f, -2.95913666e-01f, 2.12127253e-01f, -6.67280704e-02f, -6.63507134e-02f, -2.51090042e-02f, -7.00143650e-02f,
  -5.50473034e-02f, -5.91404587e-02f, 1.94961175e-01f, -1.28377499e-02f, -7.88093433e-02f, -3.07144281e-02f, 3.52591719e-03f, -4.91452888e-02f, -2.92788465e-02f, 7.51085505e-02f,
  -5.44840276e-01f, -3.42171848e-01f, -3.12686749e-02f, -1.76293343e-01f, 2.27470815e-01f, 5.91987260e-02f, -5.20391911e-02f, -9.92732495e-02f, 3.37382972e-01f, -1.57356232e-01f,
  -1.30727023e-01f, -1.81587219e-01f, 2.34620169e-01f, -5.62947355e-02f, -3.49725336e-01f, -2.35315219e-01f, -3.78511176e-02f, -1.65548757e-01f, -2.21011281e-01f, 1.36981964e-01f,
  7.42849186e-02f, -7.42028832e-01f, -8.20804119e-01f, -7.20598936e-01f, -4.30627614e-01f, -1.01450145e+00f, -2.65886188e-01f, -4.28517520e-01f, -4.34488207e-01f, -5.79961538e-01f,
  3.68532598e-01f, 4.30646896e-01f, -2.98554599e-01f, 5.60295463e-01f, 5.97700894e-01f, 4.18282717e-01f, 4.54917550e-01f, 2.28315204e-01f, 3.34367514e-01f, 4.88437176e-01f,
  7.63993919e-01f, 7.26018071e-01f, 5.03261387e-01f, 2.72040099e-01f, 3.66287045e-02f, 8.67673010e-02f, 1.24223948e-01f, -1.71870112e-01f, -1.19111672e-01f, 2.71455944e-01f,
  4.57834572e-01f, 3.19481522e-01f, -3.46793570e-02f, 4.22267467e-02f, 1.87685519e-01f, 2.55054712e-01f, 2.71081477e-01f, 2.20696852e-01f, 1.22706488e-01f, -1.75382614e-01f,
  1.09933689e-01f, 1.61589473e-01f, 1.54010514e-02f, 2.89462745e-01f, 4.92508002e-02f, -2.63877720e-01f, -3.97700816e-02f, -4.02321607e-01f, -1.07117899e-01f, -1.74485117e-01f,
  -1.21232361e-01f, -6.70520067e-02f, 3.74729335e-02f, -1.05663456e-01f, -1.21424235e-01f, -1.58937350e-01f, -1.64863870e-01f, -5.71867935e-02f, 2.49788556e-02f, 1.07218169e-01f,
  1.89492688e-01f, 1.53265014e-01f, -5.86179234e-02f, 4.18991745e-02f, 2.00601425e-02f, 1.20957568e-01f, 3.59417759e-02f, 4.75123338e-02f, 1.02119436e-02f, -5.55055812e-02f,
  3.78732234e-01f, 1.74076229e-01f, 1.54002801e-01f, 1.59201682e-01f, 7.68590719e-02f, 2.88499501e-02f, -1.01111807e-01f, 1.24489889e-03f, 2.10644424e-01f, -1.20431550e-01f,
  -7.53170550e-02f, 1.10670730e-01f, -3.26925404e-02f, -7.59021798e-03f, 8.87736753e-02f, 4.18116972e-02f, -1.98546454e-01f, -1.74036384e-01f, -2.29623932e-02f, -6.70828819e-02f,
  -1.24771133e-01f, -1.25296310e-01f, -8.77005160e-02f, -1.57514095e-01f, -4.98763360e-02f, 5.58275804e-02f, -1.14981616e-02f, -8.29247292e-03f, -8.32391344e-03f, 5.81318047e-03f,
  2.17631027e-01f, 2.62149960e-01f, -1.42269641e-01f, -2.20019430e-01f, -1.28931150e-01f, -4.45115864e-01f, 4.73759510e-02f, -2.86983162e-01f, -2.41558522e-01f, -3.14320385e-01f,
  -1.78101450e-01f, -2.86381662e-01f, -9.83309522e-02f, -1.87629297e-01f, -2.60177851e-01f, -1.59797162e-01f, 1.03280380e-01f, 1.66672066e-01f, 7.55825043e-02f, -8.54802430e-02f,
  6.53005838e-02f, 5.22773080e-02f, -1.26926079e-01f, -8.76701847e-02f, 2.32910309e-02f, 1.01492748e-01f, -5.08845113e-02f, -1.18064024e-01f, -1.33134991e-01f, -1.49281994e-01f,
  -1.16610503e+00f, 5.43554425e-01f, 4.71889883e-01f, -7.10996926e-01f, 2.88726807e-01f, 9.02208447e-01f, 1.28519690e+00f, 2.94584155e-01f, -5.98190367e-01f, 1.06644914e-01f,
  1.79618388e-01f, -5.21019161e-01f, -3.75651896e-01f, 2.87776105e-02f, 3.57583553e-01f, 6.67653143e-01f, 3.46602648e-01f, -1.03828810e-01f, -2.90416449e-01f, 6.64556921e-02f,
  1.10107720e-01f, -3.03699851e-01f, -4.90188271e-01f, -2.49741033e-01f, -4.58877325e-01f, -3.59011292e-01f, -3.52706723e-02f, 4.04917747e-02f, 6.03094399e-01f, -8.29645321e-02f,
  -4.34645975e-04f, 9.81570929e-02f, -1.09880790e-01f, -2.19910353e-01f, -6.92893490e-02f, -1.04354769e-01f, -7.86406025e-02f, -3.46928686e-01f, -6.56078234e-02f, -1.00676259e-02f,
  -3.12753208e-02f, 7.97581226e-02f, -1.34997189e-01f, 4.19627689e-02f, -6.03696741e-02f, -4.97769453e-02f, -6.93623424e-02f, 4.36580405e-02f, 1.53944045e-01f, 2.08539039e-01f,
  2.65681863e-01f, 1.78161100e-01f, 6.92623332e-02f, 3.34582627e-01f, 3.69049728e-01f, 7.66348168e-02f, 2.99987525e-01f, 8.23459625e-02f, 1.88691065e-01f, -3.21018934e-01f,
  1.16194800e-01f, 7.25796893e-02f, 2.40162164e-01f, -1.27390340e-01f, 4.38238122e-02f, -3.52991186e-02f, -4.67160121e-02f, -5.06638782e-03f, 9.14653540e-02f, -6.95083737e-02f,
  -5.16810734e-03f, 2.24610254e-01f, 1.08639441e-01f, -9.82569009e-02f, -1.99677214e-01f, 8.95385966e-02f, 1.58287406e-01f, -4.36052382e-02f, 6.06215596e-02f, -4.64846604e-02f,
  1.83942299e-02f, 1.79589361e-01f, -7.91891813e-02f, 1.37522504e-01f, 1.26828313e-01f, 1.67117361e-02f, -1.25904962e-01f, 7.21754413e-03f, -2.22820207e-01f, 2.30169017e-02f,
  -7.49054313e-01f, 7.43241489e-01f, -2.89268374e-01f, -7.94270337e-02f, 6.58038035e-02f, -3.41638178e-02f, -3.66810733e-03f, -1.64640769e-02f, 1.73604526e-02f, -1.02078103e-01f,
  1.79577202e-01f, -1.71378925e-01f, 1.24610163e-01f, 9.22288895e-02f, -1.45763665e-01f, -5.42832986e-02f, -4.93502431e-02f, -3.85289527e-02f, 1.34222284e-01f, -1.00520194e-01f,
  1.71301980e-02f, -1.47929549e-01f, -4.26198781e-01f, -1.67296678e-01f, -3.87721024e-02f, -2.54186213e-01f, -8.39978456e-02f, -1.14994138e-01f, 1.95987016e-01f, -3.42267215e-01f,
  -1.22672963e+00f, 3.09514642e-01f, -5.84955990e-01f, 3.74711096e-01f, 6.36594713e-01f, -7.03665540e-02f, 5.32971043e-03f, -3.98800045e-01f, -2.83759952e-01f, -6.78050518e-02f,
  -2.87486464e-01f, -6.40602931e-02f, -7.30838766e-03f, -5.01888432e-03f, 7.02385930e-03f, 5.37689447e-01f, 7.79556990e-01f, 9.86801907e-02f, -1.99258178e-01f, 1.10916935e-01f,
  4.26850975e-01f, -1.01270556e-01f, -5.53060591e-01f, -7.64231309e-02f, 6.04210675e-01f, 3.39864701e-01f, -2.44842261e-01f, 2.33063668e-01f, 4.54936147e-01f, 1.07410467e+00f,
  -4.04518507e-02f, -4.91013497e-01f, -1.42610177e-01f, 6.56022504e-02f, -1.36753708e-01f, -3.69673371e-01f, -1.65899575e-01f, -1.50110414e-02f, 7.50777349e-02f, -1.63306624e-01f,
  1.04427680e-01f, -2.35939443e-01f, 3.85009229e-01f, -9.65519901e-03f, -6.49284422e-02f, -3.04419219e-01f, -2.71292388e-01f, -5.49600840e-01f, -8.55096102e-01f, -3.94250304e-02f,
  1.11858654e+00f, 8.75460804e-01f, -5.39424181e-01f, -3.53027701e-01f, -4.51169133e-01f, -3.59370828e-01f, -5.54856062e-01f, -3.14528197e-01f, -1.18653870e+00f, -4.13642358e-03f,
  -1.77373990e-01f, -1.00724168e-01f, 2.78613210e-01f, -1.70898046e-02f, 9.03055295e-02f, 2.61557996e-01f, 4.71243113e-01f, 4.37134951e-01f, 2.52033174e-01f, -6.60922974e-02f,
  5.12947477e-02f, 3.01077869e-02f, -1.43426046e-01f, -4.93666679e-02f, 4.19011265e-01f, 1.35715514e-01f, 4.32546288e-02f, -8.07258934e-02f, 2.26916984e-01f, -4.15837020e-01f,
  5.15990369e-02f, -6.23759143e-02f, -2.41094559e-01f, 6.57213910e-04f, 1.07793488e-01f, 4.45477925e-02f, 1.36775494e-01f, -1.36032194e-01f, -3.50854576e-01f, -3.18668932e-01f,
  -4.68246311e-01f, -5.32951474e-01f, 1.54323086e-01f, 1.22812495e-01f, 2.87392944e-01f, -1.20298952e-01f, 9.14718211e-02f, 1.48113951e-01f, 1.28966063e-01f, -1.10867232e-01f,
  -2.48397604e-01f, -2.24605352e-01f, -1.16391011e-01f, -1.46893427e-01f, 1.94637105e-02f, -3.44732627e-02f, 1.13027170e-01f, 1.58790022e-01f, -9.51278061e-02f, -1.06440946e-01f,
  1.85178980e-01f, 2.36617938e-01f, -2.99696416e-01f, -2.07140908e-01f, 1.98770426e-02f, 4.05019894e-03f, -3.33874464e-01f, -2.75337666e-01f, -8.49951506e-01f, -3.55863839e-01f,
  -1.42108643e+00f, 4.78460073e-01f, 6.95872426e-01f, -7.37857342e-01f, -6.84868276e-01f, -3.61700147e-01f, 7.12773919e-01f, -2.93001056e-01f, -4.38587189e-01f, 7.87357330e-01f,
  2.88353801e-01f, -3.72398198e-01f, 1.39673889e-01f, -1.31880045e-01f, -2.89875567e-01f, 6.36099935e-01f, 2.88080275e-01f, -3.19348663e-01f, -9.06984866e-01f, -6.65947139e-01f,
  -3.27026963e-01f, -3.53236109e-01f, -7.58873165e-01f, -4.09879059e-01f, 9.75261331e-02f, -1.16267353e-01f, 5.70307970e-01f, -4.27120000e-01f, -2.58312881e-01f, 2.88106948e-01f,
  5.66132665e-01f, -6.53182805e-01f, -3.01812887e-01f, -5.44170737e-01f, 1.02930553e-01f, -2.09100112e-01f, 2.20513493e-02f, 1.75723657e-02f, 7.12175965e-02f, 1.01068974e-01f,
  -3.16062927e-01f, -2.39250720e-01f, -3.24764282e-01f, -7.13952705e-02f, -2.62123138e-01f, -1.22138470e-01f, -1.05413005e-01f, -1.28332004e-01f, -3.27846855e-02f, 3.35946858e-01f,
  2.01506615e-01f, -2.87579834e-01f, -3.06152195e-01f, 1.37569949e-01f, -2.15472266e-01f, -4.56412137e-01f, 1.25483081e-01f, -3.91650915e-01f, -3.57939541e-01f, 7.18563020e-01f,
  2.01563090e-01f, 1.03507221e-01f, -2.14952931e-01f, 6.96036294e-02f, 2.35859439e-01f, 1.58099473e-01f, 1.36962712e-01f, 9.93892327e-02f, 4.25315835e-02f, 1.05290420e-01f,
  -7.42604434e-02f, 1.31417230e-01f, 1.23124402e-02f, -1.56983230e-02f, 7.79463723e-02f, -2.01511353e-01f, 4.27688798e-03f, 2.64706761e-01f, -3.44570465e-02f, -1.20747343e-01f,
  -1.58076212e-01f, -1.71932921e-01f, 2.97157932e-02f, 1.56204104e-01f, -9.87365544e-02f, -8.52434523e-03f, -2.95534413e-02f, -4.78870980e-02f, -1.40637919e-01f, -1.34508163e-01f,
  4.99392450e-01f, -3.25466067e-01f, 4.16448921e-01f, -1.27428278e-01f, 9.10602733e-02f, 7.06809014e-02f, 1.48481280e-01f, -4.25946787e-02f, -1.40355989e-01f, -8.47657397e-02f,
  -4.25316751e-01f, -8.95883664e-02f, 1.88749313e-01f, 1.82069182e-01f, -9.90592614e-02f, 1.48085992e-05f, 1.76336914e-02f, 1.56023189e-01f, -5.19107282e-02f, -4.11026254e-02f,
  2.07231656e-01f, 2.00461239e-01f, 2.29334101e-01f, 3.36598784e-01f, 4.44353484e-02f, -2.35253483e-01f, 4.85327572e-01f, 2.37084150e-01f, 9.80036426e-03f, 1.05707204e+00f,
  -1.18146622e+00f, -1.37281835e+00f, 1.42712340e-01f, -1.20676124e+00f, -6.23052001e-01f, -1.76494986e-01f, -1.26986170e+00f, -5.57146907e-01f, 1.65716067e-01f, -1.21802926e+00f,
  -3.00228477e-01f, 4.70070779e-01f, 4.70065176e-01f, 4.29918975e-01f, -1.56095594e-01f, -1.24879026e+00f, -6.88473761e-01f, 2.90389024e-02f, 4.87140447e-01f, -6.05057895e-01f,
  -9.67642009e-01f, -8.86746883e-01f, -1.66018367e-01f, -3.64904702e-02f, -5.98468602e-01f, -1.09175183e-01f, -2.03091741e-01f, -3.01105320e-01f, -1.88162714e-01f, -6.93207562e-01f,
  -3.49923164e-01f, -1.15160689e-01f, 6.89801216e-01f, 4.67066169e-01f, -4.28603813e-02f, 2.90774517e-02f, -3.49712372e-01f, 5.93572520e-02f, 2.12308876e-02f, -8.56454745e-02f,
  -1.92618117e-01f, 1.98394642e-03f, 2.38541543e-01f, 7.65773049e-03f, -1.79439664e-01f, -2.40613580e-01f, 8.51225629e-02f, -3.93194798e-03f, 2.64256656e-01f, -3.19142342e-01f,
  -3.53740066e-01f, -4.02954146e-02f, 4.97408718e-01f, 3.38816941e-01f, 2.20000267e-01f, 3.81130219e-01f, 4.72879820e-02f, 2.01611996e-01f, 4.93798524e-01f, -6.97743118e-01f,
  1.40079595e-02f, -7.65700564e-02f, 2.63926014e-02f, 1.13643594e-01f, 9.10063908e-02f, 1.60409436e-01f, -5.58890440e-02f, -8.10550451e-02f, 4.52691391e-02f, 1.33593723e-01f,
  -6.75296187e-02f, 9.89633948e-02f, 2.09359545e-03f, -1.75035477e-01f, -9.12556574e-02f, -9.73352194e-02f, 1.30515415e-02f, -3.67587619e-02f, 1.99808571e-02f, 3.08329817e-02f,
  -1.39500275e-01f, -1.24577098e-01f, -5.47774248e-02f, 3.86851467e-02f, 8.91848654e-03f, 4.45918925e-02f, -1.35995016e-01f, 3.54521394e-01f, -4.00535613e-02f, -6.96667731e-02f,
  -3.33794117e-01f, 7.38384128e-01f, -4.28286821e-01f, -6.60281107e-02f, -3.16994935e-01f, 6.14648908e-02f, 2.29389429e-01f, 1.31152436e-01f, 2.02936023e-01f, -4.77278769e-01f,
  -1.95508152e-02f, -4.08943892e-01f, -8.30143392e-02f, 3.83671261e-02f, 6.49628639e-02f, 1.93352625e-01f, -4.56543803e-01f, -3.34371775e-01f, 3.13601375e-01f, -1.65954456e-01f,
  -7.17280209e-02f, -1.99782282e-01f, -3.54731232e-01f, -2.09849566e-01f, -1.26187250e-01f, -1.49702862e-01f, -2.15565354e-01f, -4.69997168e-01f, -7.68186450e-02f, -1.07178688e+00f,
  -4.49279070e-01f, -4.63712633e-01f, -1.08061087e+00f, 2.63477098e-02f, 6.62525594e-01f, -1.55298188e-01f, -8.31791043e-01f, -5.63506424e-01f, 3.66614372e-01f, 6.14498593e-02f,
  9.11596477e-01f, 7.27203548e-01f, -3.63354146e-01f, -4.66924608e-01f, -8.90723228e-01f, -8.47195089e-01f, -1.15977383e+00f, -1.30781972e+00f, -6.72409534e-01f, 6.61488593e-01f,
  6.30137384e-01f, 8.14149976e-02f, -3.08579952e-01f, -3.06359708e-01f, 2.68281460e-01f, 2.32310504e-01f, -2.86636949e-01f, 3.34231317e-01f, 2.07172841e-01f, 6.00059628e-02f,
  5.93094267e-02f, -3.54033738e-01f, -3.02697178e-02f, 3.30328971e-01f, 3.87562096e-01f, -8.98374990e-03f, -2.23182943e-02f, -2.92484194e-01f, -1.14443861e-01f, 6.29188195e-02f,
  3.61510754e-01f, 2.14359507e-01f, -1.27108216e-01f, 1.95039466e-01f, 9.05500278e-02f, -8.04929882e-02f, -3.86840135e-01f, -7.11438954e-01f, -4.87230092e-01f, -1.32088199e-01f,
  5.43563008e-01f, 2.70745993e-01f, -6.95254564e-01f, -4.04266536e-01f, -2.24409267e-01f, 9.65980813e-02f, 1.03467137e-01f, 3.22543323e-01f, -3.58571619e-01f, -6.16322011e-02f,
  1.45983025e-01f, 9.98252556e-02f, 1.11457765e-01f, -7.82064497e-02f, 1.84724540e-01f, 1.24124333e-01f, -8.47565010e-02f, 6.46624640e-02f, 1.78773046e-01f, -6.01585470e-02f,
  -4.65492904e-02f, 6.79324046e-02f, -1.19588692e-02f, -1.99420556e-01f, -2.15166241e-01f, -4.36258465e-02f, 2.28949562e-02f, -1.91301256e-01f, -3.11795324e-01f, -2.03916244e-02f,
  -1.67832971e-01f, 3.17034990e-01f, 2.51951814e-01f, 8.90909731e-02f, 5.54647371e-02f, -2.88789779e-01f, 9.01898295e-02f, 1.88554361e-01f, -1.32937387e-01f, 9.51521173e-02f,
  1.26768485e-01f, 1.80693805e-01f, -2.15630040e-01f, -2.12669566e-01f, 1.49956187e-02f, 4.25070934e-02f, 2.30482370e-02f, -1.86816692e-01f, 2.64872890e-02f, -2.70109884e-02f,
  1.23872161e-01f, -2.58349776e-01f, 1.71764493e-01f, 1.51991248e-01f, 1.25592887e-01f, 2.23220065e-02f, -4.59132642e-02f, -1.82040274e-01f, -1.22813083e-01f, 4.55962867e-01f,
  -2.24566132e-01f, -4.30986375e-01f, -4.43779975e-01f, -3.74042630e-01f, 1.31828681e-01f, -6.31723285e-01f, -5.58001280e-01f, -9.19556692e-02f, -7.86600411e-01f, -8.79455090e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  8.10352385e-01f, 6.98005080e-01f, 1.29990864e+00f, 1.35431778e+00f, 2.72438705e-01f, 9.02089357e-01f, -1.51121125e-01f, 1.62751865e+00f, 8.82417560e-01f, 6.51455462e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -6.82509169e-02f, -6.99841082e-01f, 2.05985025e-01f, 8.06978121e-02f, 9.16795135e-02f, 7.75772706e-02f, 3.76812369e-01f, -1.07501470e-01f, -7.88483500e-01f, -1.91388285e+00f,
  -1.01418877e+00f, -1.09769881e+00f, -6.20588064e-01f, -1.35143542e+00f, 3.91820788e-01f, 7.72298872e-01f, 3.79547685e-01f, 2.50717968e-01f, -3.60665590e-01f, 1.12742245e+00f,
  -4.10644025e-01f, 7.12081730e-01f, 5.52422047e-01f, 1.13918819e-01f, 5.84067881e-01f, -1.22275388e+00f, 3.18707824e-01f, -1.37460679e-01f, -3.76181513e-01f, -1.46642292e+00f,
  1.06980217e+00f, -2.64590669e+00f, 6.75024033e-01f, -9.96015966e-02f, -1.75315142e-01f, -8.36341262e-01f, -7.82171667e-01f, 6.09398663e-01f, -1.14812076e+00f, 1.06113172e+00f,
  1.82750076e-02f, -6.31066382e-01f, -1.18024695e+00f, -6.23968244e-01f, -5.09864211e-01f, -1.26419437e+00f, 1.40134001e+00f, -1.23137522e+00f, 1.93111766e-02f, -8.37669790e-01f,
  -1.48214935e-03f, -4.47143584e-01f, -3.82464230e-01f, -3.70233148e-01f, -4.83651012e-01f, -3.81924033e-01f, -7.87656128e-01f, -9.38880622e-01f, -1.14854157e+00f, 1.34002101e+00f,
  -3.13956439e-02f, 3.18643063e-01f, 2.89448828e-01f, 1.08834654e-01f, -1.01353216e+00f, 9.43074096e-03f, -3.06849241e-01f, 7.46396244e-01f, -8.45932603e-01f, -3.85996014e-01f,
  -7.72527397e-01f, -1.37505341e+00f, -2.17986226e-01f, 7.42306232e-01f, 3.63520175e-01f, -1.96292830e+00f, -6.64180636e-01f, 5.27934909e-01f, 4.50591385e-01f, 2.44702399e-01f,
  8.72088522e-02f, 5.15979111e-01f, 4.90216017e-01f, 1.00891376e+00f, 3.28032047e-01f, -8.55326772e-01f, 1.21895063e+00f, -1.83863156e-02f, -7.72212088e-01f, -1.64222085e+00f,
  3.21507335e-01f, -9.56110716e-01f, -5.97340882e-01f, 1.43025517e-01f, -1.34995115e+00f, 4.90596414e-01f, -1.62848726e-01f, 1.56786278e-01f, 1.77017510e-01f, -8.84212494e-01f,
  1.53506041e-01f, -7.51571238e-01f, -9.97513235e-01f, 8.60045612e-01f, -3.38910460e-01f, 1.01873457e+00f, -6.91772461e-01f, -8.38047922e-01f, -3.14256638e-01f, -9.27399814e-01f,
  -1.45025492e+00f, -2.18417835e+00f, -6.28522933e-02f, 5.56168370e-02f, -1.89759731e-01f, -3.16658318e-01f, -3.13858479e-01f, -3.95777732e-01f, -8.23194325e-01f, -9.53828633e-01f,
  -1.02427042e+00f, -9.54673827e-01f, 4.05555487e-01f, 8.02745700e-01f, 1.24832821e+00f, -5.01437485e-01f, -1.08955824e+00f, -2.47389704e-01f, -3.38300765e-01f, -7.60806501e-01f,
  5.38223565e-01f, -1.53842258e+00f, 8.13944519e-01f, 1.89388663e-01f, 1.25097781e-01f, -7.18105197e-01f, 1.19092798e+00f, -8.64232957e-01f, -4.78668839e-01f, -9.31450352e-03f,
  3.65130723e-01f, -2.60021329e-01f, -1.33581626e+00f, -6.63372993e-01f, -5.07198721e-02f, 6.37939423e-02f, -3.27921420e-01f, 6.06381781e-02f, 1.73121020e-01f, 1.12590420e+00f,
  -7.86121905e-01f, 1.31862955e-02f, -5.60955584e-01f, 5.31366825e-01f, -1.01871081e-02f, -1.57086051e+00f, 6.02849603e-01f, -1.32801092e+00f, -7.82795131e-01f, 1.09668136e+00f,
  7.74157822e-01f, 4.53869790e-01f, -1.74710080e-02f, -2.65044659e-01f, 4.57954288e-01f, 5.63421011e-01f, -1.21796238e+00f, -4.64968741e-01f, -1.00619841e+00f, -1.72819757e+00f,
  -2.79959619e-01f, -5.63277900e-01f, -6.27107799e-01f, 1.53113592e+00f, 7.50935376e-02f, -4.03936356e-01f, 1.74950331e-01f, -2.73963958e-02f, -2.54143387e-01f, 5.46594918e-01f,
  1.11011609e-01f, -5.98925889e-01f, -4.26652342e-01f, -1.07952511e+00f, -1.14965200e-01f, 1.34913707e+00f, -1.53753310e-01f, 1.50144112e+00f, -6.28882945e-01f, -1.20240879e+00f,
  -1.00959671e+00f, -9.43339050e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.17572927e-01f, 1.41082644e-01f, 4.76554304e-01f, -1.14262426e+00f, -1.61015123e-01f, 1.94471747e-01f, 4.68148202e-01f, -4.97152865e-01f, -4.52105962e-02f, -1.73826143e-01f,
  -8.70114207e-01f, -5.95704734e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    