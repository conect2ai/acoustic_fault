/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.20510483e-01f, -2.07556397e-01f, 1.85811922e-01f, -9.81577039e-02f, 1.01139016e-01f, -1.21555710e-02f, -2.82811783e-02f, -6.38107816e-03f, -1.79662079e-01f, -1.91528738e-01f,
  -2.43960053e-01f, -3.14517282e-02f, 3.79161127e-02f, -2.02763632e-01f, 4.35992211e-01f, 6.01222515e-02f, -3.38450670e-02f, -1.19222268e-01f, 7.85571113e-02f, -1.84250586e-02f,
  1.22767016e-01f, -2.14058474e-01f, 2.61530578e-01f, 3.17037164e-04f, -5.62310070e-02f, 4.62290347e-02f, 6.20540865e-02f, 1.72208130e-01f, -2.76372917e-02f, 7.79850036e-02f,
  1.30617237e-02f, -1.74337298e-01f, -4.74720262e-02f, -3.48568708e-02f, 7.93987066e-02f, 5.47436923e-02f, 8.46027210e-02f, -1.73462983e-02f, -7.19753653e-03f, 5.50564341e-02f,
  -2.49714497e-02f, 4.20921482e-02f, 5.68971671e-02f, 2.63751745e-02f, 4.39917520e-02f, 3.16709094e-02f, 6.30611777e-02f, -7.62178898e-02f, 2.09344123e-02f, 1.21621184e-01f,
  1.06346749e-01f, 6.39060959e-02f, 1.93682010e-03f, 5.45539223e-02f, 7.65180960e-02f, 8.78063682e-03f, 5.63409328e-02f, 8.62755626e-02f, -6.07557334e-02f, -3.97031419e-02f,
  9.18868370e-03f, 1.37736589e-01f, -9.54912230e-02f, -3.61321718e-02f, -1.51853576e-01f, -3.59042101e-02f, -3.51105630e-02f, -6.19029962e-02f, -4.40525310e-03f, -7.39456639e-02f,
  2.30989065e-02f, -1.23184152e-01f, 6.89811260e-02f, -8.00950155e-02f, -7.44718537e-02f, -1.29911497e-01f, -7.18658864e-02f, -1.52826868e-02f, -4.68400382e-02f, -5.90821244e-02f,
  -1.01024769e-01f, 6.91091642e-03f, -7.31717050e-02f, -1.11322422e-02f, -7.28402510e-02f, 2.86104763e-03f, 3.98129737e-03f, -9.92529467e-02f, -1.54549377e-02f, 2.22029202e-02f,
  -2.14673355e-02f, -1.55169860e-01f, -2.85344701e-02f, -5.04761003e-02f, 4.45485562e-02f, 6.60839351e-03f, 3.61231267e-02f, -2.32543070e-02f, -1.33769363e-02f, 3.42946686e-02f,
  8.79674926e-02f, -1.35729015e-02f, 3.29009704e-02f, -3.04200221e-02f, 3.89998704e-02f, -4.36855387e-03f, -3.85050140e-02f, -3.47821787e-02f, -3.37096453e-02f, 1.06514515e-02f,
  -1.12620555e-01f, -3.82924378e-02f, 7.62699768e-02f, -4.98047508e-02f, 1.04544125e-02f, -1.27919428e-02f, -3.26404069e-03f, 3.33111100e-02f, -3.30063165e-03f, 4.77202944e-02f,
  3.21181238e-01f, -2.36863896e-01f, 1.77622229e-01f, 3.16519976e-01f, -1.89533338e-01f, 9.57652032e-02f, 2.60014802e-01f, -1.80523351e-01f, 3.35022181e-01f, -1.42911881e-01f,
  3.78012769e-02f, 6.93778470e-02f, -1.91254556e-01f, 1.61067471e-01f, 7.68705606e-02f, 1.86269581e-01f, 1.66371956e-01f, 1.02976568e-01f, 3.03506702e-02f, 3.80858853e-02f,
  7.89912641e-02f, -1.63513407e-01f, -1.07852884e-01f, -3.46618831e-01f, -8.79648030e-02f, 8.17804486e-02f, -1.60175964e-01f, -1.41237184e-01f, -7.15734363e-02f, -1.89780027e-01f,
  -1.49158865e-01f, 4.44899164e-02f, 4.13631126e-02f, -1.15839235e-01f, 3.70629244e-02f, -1.41751422e-02f, 3.35177220e-03f, 4.04349230e-02f, 9.43289883e-03f, -6.41331449e-02f,
  1.76143628e-02f, -8.23211111e-03f, -1.47690242e-02f, 3.63507420e-02f, 2.38122791e-02f, 3.97899467e-03f, -8.71118158e-03f, -2.14162786e-02f, -3.40492129e-02f, -1.62330084e-03f,
  -6.29532263e-02f, 1.85080953e-02f, 1.12447761e-01f, 1.54575030e-03f, 4.93223481e-02f, 6.75610155e-02f, 8.82128924e-02f, -4.48667370e-02f, -1.05149979e-02f, 6.75319359e-02f,
  6.70549273e-02f, 2.64797620e-02f, -3.83797660e-02f, -9.19093788e-02f, 2.07845028e-02f, -6.42576441e-02f, -1.46348923e-02f, -4.67828326e-02f, 1.18207857e-02f, -2.84549291e-03f,
  -8.68032128e-03f, -8.35192110e-03f, 2.28407737e-02f, 7.88777322e-02f, 1.98805146e-02f, 5.79843707e-02f, 2.67205294e-02f, -1.32303182e-02f, 6.29232749e-02f, -9.79581326e-02f,
  3.22584086e-03f, 2.41142139e-02f, -2.84284931e-02f, -2.62124818e-02f, -6.35803789e-02f, 1.68911996e-03f, 8.82579461e-02f, 4.54019681e-02f, 5.64889945e-02f, -9.15770512e-03f,
  -8.24523419e-02f, -8.07446614e-02f, -9.21708345e-02f, -2.81059388e-02f, -3.82016078e-02f, -5.35740331e-02f, 3.45133543e-02f, -2.57419925e-02f, -1.05405480e-01f, 9.13779140e-02f,
  5.94004281e-02f, 2.81851962e-02f, 2.01164931e-02f, -8.89716484e-03f, -2.66424716e-02f, 2.17794091e-03f, 6.98296130e-02f, 3.30363028e-02f, -5.59767224e-02f, 3.80532700e-03f,
  8.39478374e-02f, 4.03226987e-02f, -5.30730486e-02f, -7.01374784e-02f, 3.35696191e-02f, 1.47650875e-02f, 3.66745740e-02f, 6.41039759e-02f, -2.58542206e-02f, -2.62582637e-02f,
  -6.10850871e-01f, -3.49107385e-02f, 4.05737460e-02f, -1.51085213e-01f, -1.45869166e-01f, 1.39139369e-01f, 1.44484103e-01f, -1.21111698e-01f, -1.71430185e-01f, 1.04766592e-01f,
  -5.32470793e-02f, 3.87942530e-02f, -1.75806601e-02f, 1.00435384e-01f, -2.11280718e-01f, 8.33068341e-02f, -1.37906924e-01f, -2.76881587e-02f, -5.89967705e-02f, -1.38438612e-01f,
  -8.47238377e-02f, 3.69000360e-02f, 4.92634997e-02f, 3.05001233e-02f, -5.24947233e-02f, -7.70523995e-02f, -8.50529224e-02f, 7.20702112e-02f, 7.17838332e-02f, 6.43461645e-02f,
  -2.18183510e-02f, -7.85944089e-02f, 1.06084935e-01f, 6.31873161e-02f, -5.05649932e-02f, -4.23165876e-03f, 5.48831858e-02f, 1.38992921e-01f, 9.92252529e-02f, -9.93917231e-04f,
  -2.58760210e-02f, -2.71243043e-02f, 9.31424368e-03f, -2.40100101e-02f, -8.30570906e-02f, 2.09662579e-02f, -2.48018298e-02f, 2.29516551e-02f, 8.38026851e-02f, -5.80503158e-02f,
  -2.46532820e-03f, -4.67637330e-02f, -5.86912408e-02f, 5.00775548e-03f, 4.72060181e-02f, 1.52513217e-02f, 8.65971670e-02f, 9.45114419e-02f, -4.73207980e-02f, 6.20325888e-03f,
  4.08815704e-02f, -2.14162786e-02f, 3.53884324e-02f, 3.74650918e-02f, -2.84938179e-02f, 2.47230679e-02f, -2.34436374e-02f, 6.36609644e-02f, 2.80116778e-02f, -8.79628509e-02f,
  -7.30622485e-02f, -5.81601448e-02f, 3.49218696e-02f, 5.78891253e-03f, -2.93942261e-02f, -5.35006672e-02f, 5.21914810e-02f, -3.34656946e-02f, 1.30145708e-02f, -3.57246660e-02f,
  1.80170648e-02f, -9.49616432e-02f, 1.13404468e-02f, -6.98181316e-02f, -1.75125897e-02f, -1.66933555e-02f, -3.94165749e-03f, -3.24826464e-02f, 5.54105975e-02f, -4.56434116e-02f,
  -2.73057491e-01f, -1.98883340e-01f, 1.17227107e-01f, -4.85393479e-02f, 5.62209003e-02f, -2.66313590e-02f, 6.67335168e-02f, -3.83309759e-02f, -4.43723723e-02f, -1.26186460e-02f,
  4.72147241e-02f, -1.15036322e-02f, -6.52135164e-02f, -3.65946181e-02f, -2.12735236e-02f, -8.24465882e-03f, 5.77509813e-02f, -1.26413014e-02f, -2.66280100e-02f, -4.91954871e-02f,
  -3.91051210e-02f, -7.02458608e-04f, 5.74580766e-02f, -3.28261629e-02f, -1.80300903e-02f, -4.54492494e-02f, -9.14434344e-02f, -2.53754575e-02f, -4.86728176e-02f, -3.42319086e-02f,
  4.30732727e-01f, -3.35674345e-01f, -1.95674986e-01f, 4.69056033e-02f, -1.42699882e-01f, -1.70478225e-01f, -3.54544669e-02f, -1.91029310e-01f, -8.88800398e-02f, -5.88374361e-02f,
  -1.07622609e-01f, 4.91936728e-02f, 1.22546998e-03f, -1.36629581e-01f, 3.09092164e-01f, -4.61782068e-02f, -1.84640866e-02f, 1.37305614e-02f, -9.70733911e-03f, -9.84584615e-02f,
  1.98822422e-03f, 2.14774683e-02f, -4.80530150e-02f, -8.31721574e-02f, -1.34425282e-01f, 1.19878922e-03f, 1.81795567e-01f, -4.74126227e-02f, -4.32775170e-02f, 6.31646141e-02f,
  9.45724547e-03f, -1.38100281e-01f, -2.96936301e-03f, -5.40712103e-03f, 2.97446586e-02f, -6.95703551e-02f, 1.77843273e-02f, 2.62074340e-02f, -2.52222754e-02f, -5.73106371e-02f,
  -3.09999697e-02f, -5.08018956e-02f, 5.88645935e-02f, 6.83329403e-02f, -7.61688799e-02f, -5.12177162e-02f, -5.47954291e-02f, -9.96045917e-02f, -4.99497354e-02f, -1.11701190e-01f,
  -5.93557172e-02f, 4.08264771e-02f, -7.40525201e-02f, -1.44703100e-02f, -1.45588657e-02f, -1.34272911e-02f, -3.41505371e-02f, 1.46636646e-02f, 7.68297985e-02f, -9.15318057e-02f,
  -2.53352430e-02f, 1.69132166e-02f, 3.28679383e-02f, -2.68255739e-04f, -1.80149488e-02f, -5.75146675e-02f, -1.67781655e-02f, 1.79401934e-02f, 3.34480070e-02f, 2.03884346e-03f,
  3.51888649e-02f, 4.64704521e-02f, -1.07099123e-01f, 1.40531613e-02f, -2.25900449e-02f, -6.75417017e-04f, 8.49721488e-03f, -4.69292849e-02f, 4.48924191e-02f, 8.03074916e-04f,
  2.14020517e-02f, -2.64614895e-02f, 3.06602218e-03f, 3.28135607e-03f, 8.83721653e-03f, 6.27178550e-02f, 4.30145785e-02f, -6.61586449e-02f, -4.15576696e-02f, 5.76415770e-02f,
  -3.59068364e-02f, 4.89726961e-02f, 3.43706869e-02f, -6.21968545e-02f, 4.79054963e-03f, 6.31456077e-02f, -5.44095300e-02f, 6.09165318e-02f, -3.90923023e-03f, 3.44723016e-02f,
  -8.93689692e-03f, -4.68709208e-02f, 8.17711577e-02f, 6.45327941e-02f, -1.09040942e-02f, -4.31267992e-02f, 4.49100696e-02f, 4.44050953e-02f, 3.39349881e-02f, 3.58470045e-02f,
  2.21033916e-02f, -4.76144999e-03f, 5.91103472e-02f, 8.83233398e-02f, -1.32912239e-02f, 2.05596387e-02f, 5.36447205e-02f, 1.01549122e-02f, -1.38002504e-02f, 1.49945114e-02f,
  1.86941415e-01f, -2.19760358e-01f, 7.56570464e-03f, -1.56923041e-01f, 2.46442825e-01f, 3.37914407e-01f, 9.29040983e-02f, 8.01605806e-02f, -1.21275075e-01f, -3.07818413e-01f,
  5.37520573e-02f, -1.75955057e-01f, -1.73774958e-01f, 4.23004963e-02f, 2.83331186e-01f, -1.77245408e-01f, -4.66024391e-02f, -1.64573133e-01f, -4.88510318e-02f, -4.98124883e-02f,
  -1.10093351e-04f, -1.00852540e-02f, 6.39673546e-02f, 2.30599009e-03f, 1.57335177e-01f, -4.19839956e-02f, -8.64052773e-02f, 2.20002537e-03f, 1.49818296e-02f, -1.13952821e-02f,
  4.00648005e-02f, -9.57575813e-02f, 1.07804090e-01f, -3.49729247e-02f, 8.43769237e-02f, 5.20906784e-02f, 1.27077037e-02f, 2.35660281e-02f, 4.81546707e-02f, -8.03047966e-04f,
  -1.85399391e-02f, 3.91629376e-02f, -3.71902622e-02f, 5.83694205e-02f, 6.15466759e-02f, -5.51042845e-03f, 7.76293948e-02f, 8.56443048e-02f, -2.28513218e-02f, 7.07042143e-02f,
  4.73021418e-02f, 8.32701921e-02f, 2.93525457e-02f, -8.95452872e-02f, 8.24102461e-02f, 5.35983443e-02f, -6.21683784e-02f, 1.59201468e-03f, 2.30597686e-02f, 7.22710267e-02f,
  4.43211477e-03f, -2.14319304e-02f, -2.62270439e-02f, -1.29766564e-03f, -3.49722803e-02f, 1.19730579e-02f, 3.47146229e-03f, 1.86162107e-02f, -5.53660654e-02f, 5.26942350e-02f,
  1.22295767e-02f, -1.56654250e-02f, 6.05230220e-03f, 9.50233638e-03f, -1.19089615e-02f, 1.93927381e-02f, -3.70590724e-02f, -3.85450087e-02f, -4.41150181e-03f, 7.27771968e-02f,
  -7.33927190e-02f, 2.06833426e-02f, 7.86364451e-03f, -2.38094442e-02f, 1.59453880e-02f, -1.91288590e-02f, -4.82045636e-02f, 1.29023921e-02f, -6.27239347e-02f, 1.53971231e-02f,
  -4.95248660e-02f, -3.56357336e-01f, -9.96517614e-02f, -3.41046341e-02f, -7.60667101e-02f, 8.87159184e-02f, -2.07573338e-03f, 6.14674948e-02f, -1.16945848e-01f, 3.27080339e-02f,
  4.95164990e-02f, -2.21760403e-02f, -3.68025564e-02f, -2.37988569e-02f, -3.86120193e-02f, -9.28039774e-02f, -1.77441746e-01f, -5.76305352e-02f, 4.35425267e-02f, -5.20245954e-02f,
  -2.17321906e-02f, -6.91527054e-02f, -2.79113892e-02f, 1.69857778e-02f, -9.17788222e-03f, -7.42961168e-02f, 4.30211872e-02f, 1.51357008e-02f, 5.84579781e-02f, -8.13289657e-02f,
  1.28362924e-01f, -2.18344741e-02f, -6.89245621e-03f, -1.50577694e-01f, 2.15831026e-01f, -1.20682806e-01f, -1.94108620e-01f, 1.62844107e-01f, 2.05949321e-01f, -1.26790583e-01f,
  -5.21679234e-04f, -1.01064533e-01f, -1.65686235e-01f, -1.17842458e-01f, -2.00820923e-01f, -1.63936272e-01f, -2.44313121e-01f, -1.26280054e-01f, 6.56869188e-02f, -3.81759778e-02f,
  -4.20526862e-02f, -6.97946474e-02f, -2.21383259e-01f, 1.38468310e-01f, 1.74086124e-01f, 7.93870613e-02f, -1.50760323e-01f, 9.51924920e-03f, -4.01525758e-02f, -5.04470207e-02f,
  6.85054436e-02f, 8.77579823e-02f, 1.16795294e-01f, 1.59918051e-02f, -3.33844572e-02f, -3.46880853e-02f, -1.13992944e-01f, -3.54688130e-02f, 1.00115292e-01f, -1.24202333e-02f,
  -9.74377766e-02f, 1.36080403e-02f, -5.72469495e-02f, 3.32368053e-02f, 8.65417495e-02f, 1.86354648e-02f, 3.61780152e-02f, 6.62492290e-02f, 2.26250328e-02f, 6.99158804e-03f,
  7.53350034e-02f, -3.45978923e-02f, 3.86317186e-02f, -1.01463348e-01f, 1.77360345e-02f, 9.38626230e-02f, -8.60753818e-04f, -2.08296943e-02f, 1.37279052e-02f, 9.57335578e-04f,
  -5.21518290e-02f, -2.91286539e-02f, -4.20220010e-02f, -2.77765505e-02f, 3.21400873e-02f, 3.27835083e-02f, -2.50653718e-02f, -5.28923683e-02f, 1.01444349e-01f, -3.60725187e-02f,
  -4.82146582e-03f, -2.00864077e-02f, 1.54285766e-02f, 4.40313108e-02f, -1.91004835e-02f, 1.49335694e-02f, -1.17661230e-01f, 3.86659987e-03f, -3.95202413e-02f, 2.02352535e-02f,
  -2.23135129e-02f, -3.54359299e-03f, 6.73233941e-02f, -3.21874879e-02f, 2.91915722e-02f, 3.86842191e-02f, -1.97621118e-02f, 1.32038360e-02f, -1.45260533e-02f, -4.41372730e-02f,
  -1.11112170e-01f, -2.58079529e-01f, -5.28898314e-02f, -9.44238901e-02f, 3.83351371e-02f, 2.52684280e-02f, -5.03258891e-02f, 8.19887444e-02f, -3.46389078e-02f, -3.49961743e-02f,
  4.37190272e-02f, -3.78880091e-02f, 1.64010096e-03f, 3.15734334e-02f, -6.63870946e-02f, -2.17200182e-02f, -9.46206674e-02f, 4.34223143e-03f, -8.86855200e-02f, 2.14640005e-03f,
  -4.99855876e-02f, -4.81952503e-02f, -2.81779617e-02f, 4.35755402e-02f, 1.19421184e-02f, -8.73439014e-02f, 3.70543227e-02f, -8.15734360e-03f, -6.87276646e-02f, 7.11350760e-04f,
  1.62244320e-01f, 1.46052077e-01f, 1.88647002e-01f, -3.21719833e-02f, -1.27008051e-01f, -4.11762834e-01f, -2.94839114e-01f, 4.95703481e-02f, -1.55689254e-01f, -1.09089509e-01f,
  -1.95834354e-01f, 4.53953706e-02f, -1.26779675e-01f, -3.29954892e-01f, -3.09344918e-01f, -2.11228222e-01f, -2.35691592e-01f, -8.81946608e-02f, -9.21845902e-03f, 2.51790229e-02f,
  1.52629353e-02f, -1.63474798e-01f, 9.37488116e-03f, 6.94593862e-02f, 8.14933479e-02f, 2.92918444e-01f, 1.37686759e-01f, 2.02375352e-02f, 4.34389338e-02f, -5.57431653e-02f,
  4.51723486e-02f, 2.07909241e-01f, 3.33009996e-02f, -3.48471925e-02f, 1.41717628e-01f, 8.34865794e-02f, 1.25940405e-02f, 2.48015877e-02f, -8.23081657e-03f, -5.11031710e-02f,
  1.42544666e-02f, -2.10730489e-02f, 3.39391716e-02f, -7.78483003e-02f, -9.18585658e-02f, 1.56920031e-02f, -5.34256697e-02f, -2.27043070e-02f, -4.38119061e-02f, -8.77517741e-03f,
  -3.47760059e-02f, 1.02664288e-02f, -3.80893727e-03f, -4.53625917e-02f, 2.63467850e-03f, -1.53503016e-01f, -8.42478722e-02f, 2.00958271e-02f, -4.08265516e-02f, -1.38884119e-03f,
  -7.61370314e-03f, 1.66104231e-02f, 1.02960272e-02f, 2.30441410e-02f, -4.71499562e-02f, 7.61102885e-02f, -4.26260903e-02f, 2.35870201e-02f, 1.05449371e-01f, -5.50253205e-02f,
  -1.17667027e-01f, -4.15619090e-02f, -1.43443805e-03f, -2.16055661e-02f, 6.45088330e-02f, -4.49082144e-02f, 3.23540159e-02f, -2.10920386e-02f, 3.39124948e-02f, -3.81425694e-02f,
  3.12861465e-02f, -4.86233793e-02f, 1.21348649e-02f, 6.08211458e-02f, -1.36315778e-01f, 4.49002348e-02f, -4.31266837e-02f, -1.79858562e-02f, 1.19570810e-02f, 4.40381244e-02f,
  4.74987701e-02f, 2.40443513e-01f, -3.80302668e-02f, -2.22952869e-02f, -3.07665002e-02f, -4.93854247e-02f, -3.23453895e-03f, 9.50209855e-04f, 6.83006868e-02f, 1.95569396e-02f,
  9.12919175e-03f, -6.39584381e-04f, 3.20524126e-02f, 9.58980154e-03f, -4.19504084e-02f, -3.35609796e-03f, 2.83851824e-03f, -1.19370408e-02f, -1.56483296e-02f, 5.65821230e-02f,
  8.40486810e-02f, 1.83596611e-02f, -5.84412254e-02f, 7.91544691e-02f, 7.52917007e-02f, 2.77355369e-02f, 6.84909821e-02f, 2.04736535e-02f, -1.29448539e-02f, -2.60751080e-02f,
  1.39514625e-01f, 1.07474644e-02f, -2.88941264e-01f, 2.60697007e-01f, 1.42923206e-01f, -2.11811736e-01f, -1.70705467e-01f, 8.50958154e-02f, 1.45160303e-01f, 2.55454153e-01f,
  -8.08626227e-03f, 7.59469867e-02f, -1.40062004e-01f, 9.31665897e-02f, -4.73003447e-01f, -3.50971341e-01f, 3.37020643e-02f, 1.79262739e-02f, -4.14957143e-02f, 1.80269465e-01f,
  -2.45177709e-02f, 2.94445038e-01f, -1.79676369e-01f, 1.46580577e-01f, 1.28326818e-01f, 6.85146451e-02f, 9.81034040e-02f, -4.00749184e-02f, 1.63035646e-01f, -1.34619605e-02f,
  -1.55579314e-01f, 1.96820214e-01f, -6.49108179e-03f, -2.42939685e-02f, -5.11944108e-03f, -3.18340771e-03f, -2.18009809e-03f, -5.47381304e-02f, -4.24401350e-02f, 8.50213841e-02f,
  1.81024838e-02f, 3.82235348e-02f, 9.36775878e-02f, 1.08289964e-01f, 1.36786804e-01f, 7.08242506e-02f, 6.62086904e-03f, -1.98143814e-02f, 6.50556460e-02f, -1.29573178e-02f,
  -8.28589424e-02f, -4.16789018e-02f, -1.87854394e-02f, 7.76255503e-02f, -3.67956646e-02f, 2.30925176e-02f, -5.24459593e-02f, -1.10961571e-01f, -2.34180540e-02f, 1.05530009e-01f,
  3.87772284e-02f, 4.58355285e-02f, -2.53234114e-02f, 9.26986337e-03f, -7.70629058e-03f, -7.50289997e-03f, 5.11645377e-02f, -5.35965972e-02f, -2.13718531e-03f, -4.35361192e-02f,
  1.72974635e-02f, 9.00929421e-03f, 7.13138953e-02f, -3.14785875e-02f, 2.41713412e-02f, 5.94728962e-02f, -7.22187459e-02f, -6.15338562e-03f, -1.90541018e-02f, -2.83958167e-02f,
  4.66835797e-02f, -3.77831310e-02f, 3.25842053e-02f, 2.69331820e-02f, -5.19166403e-02f, -3.25193703e-02f, 8.59460756e-02f, 2.49519534e-02f, 2.26906873e-02f, -1.16630062e-01f,
  -9.44377761e-03f, 1.84778869e-01f, -1.13586001e-02f, 1.03313707e-01f, 2.33758427e-02f, 6.28119558e-02f, 4.26738113e-02f, 3.69309150e-02f, -5.62130809e-02f, 5.62622771e-02f,
  3.87020893e-02f, 3.72372232e-02f, -3.49181169e-03f, -3.22283469e-02f, -4.29037474e-02f, -5.08774668e-02f, -1.95508599e-02f, 1.48396045e-02f, 5.19642979e-02f, -1.36722066e-02f,
  1.06934369e-01f, 5.92707135e-02f, 9.45067964e-03f, 3.11160721e-02f, 7.07665384e-02f, -4.06098925e-02f, 8.97780210e-02f, -5.98259419e-02f, 8.77190288e-03f, -9.06168669e-03f,
  -6.96954787e-01f, 7.60950074e-02f, 8.12341124e-02f, -2.02322781e-01f, 8.00700858e-02f, -2.22083569e-01f, -2.01752484e-01f, 3.17428745e-02f, -3.51524353e-01f, 2.02058285e-01f,
  3.27258289e-01f, -1.71169683e-01f, 1.16978869e-01f, 1.64223045e-01f, -1.77426577e-01f, -7.35579953e-02f, -1.23443961e-01f, -1.86336488e-01f, -1.36595424e-02f, 8.42350498e-02f,
  -6.22449555e-02f, 2.01313153e-01f, 1.57914728e-01f, 1.11683100e-01f, 5.91514353e-03f, -4.93696742e-02f, 1.59413904e-01f, 2.03764901e-01f, 7.88591504e-02f, 3.59995291e-02f,
  1.08742572e-01f, -7.77983293e-02f, 3.26384641e-02f, -1.25981510e-01f, 3.45023163e-02f, -1.54957464e-02f, -2.55964883e-02f, -7.87060591e-04f, -4.77270745e-02f, -1.74417775e-02f,
  8.06783698e-03f, 3.78255844e-02f, -8.26592296e-02f, 3.63681540e-02f, -4.56981994e-02f, 1.23078481e-03f, -4.75065131e-03f, -8.00467730e-02f, -9.86869633e-03f, -7.12230355e-02f,
  -1.32502811e-02f, -2.64080297e-02f, -1.30615560e-02f, -4.98582423e-02f, 1.30827511e-02f, -4.52749878e-02f, 1.36095902e-03f, -4.36480641e-02f, -1.00737661e-01f, -9.06249285e-02f,
  -2.69897021e-02f, -5.39363064e-02f, -6.38330588e-03f, 4.14284170e-02f, -2.28855498e-02f, 6.01752847e-02f, 9.79006365e-02f, 3.18850763e-02f, -2.45776363e-02f, 5.08242920e-02f,
  -6.93265861e-03f, 6.35196920e-03f, 3.69715504e-02f, -4.23432849e-02f, 4.49272878e-02f, -5.34093678e-02f, -2.36253850e-02f, 5.68460412e-02f, -8.09302330e-02f, 2.43351702e-02f,
  1.74820162e-02f, 3.79585586e-02f, 1.97096169e-02f, 5.88750765e-02f, -3.29226106e-02f, -9.95231699e-03f, 5.71672209e-02f, 1.79705080e-02f, 6.37526438e-02f, 1.91592611e-02f,
  -2.75790505e-02f, 2.88341884e-02f, 1.46156531e-02f, 7.82810450e-02f, -1.55370301e-02f, 5.12302108e-02f, -1.34542538e-02f, 1.13379327e-03f, -4.32280786e-02f, 6.09387048e-02f,
  -2.91600563e-02f, 1.41021900e-03f, 4.72975969e-02f, -8.42658132e-02f, 3.87584674e-03f, -2.19906028e-02f, 5.22095636e-02f, -1.75744295e-02f, -7.26688504e-02f, 8.70780498e-02f,
  7.35064819e-02f, 9.70077328e-03f, 2.80037103e-03f, -2.20652781e-02f, -3.41000818e-02f, 3.97094823e-02f, -9.14486647e-02f, -4.97670360e-02f, 4.15654704e-02f, -3.88711393e-02f,
  -7.49530643e-02f, 1.58003300e-01f, -1.08812951e-01f, -2.73447990e-01f, 1.72362626e-01f, 2.45515868e-01f, 2.01828673e-01f, -1.04102336e-01f, -7.13614225e-02f, 3.65866199e-02f,
  -4.55328748e-02f, 1.57018434e-02f, 2.49562338e-02f, -1.60267577e-01f, -2.61571795e-01f, -1.59358367e-01f, -2.71691203e-01f, -5.67619037e-03f, -5.83616309e-02f, 3.76086794e-02f,
  -7.16275573e-02f, -8.99203494e-02f, -1.43987805e-01f, 7.46840686e-02f, 1.85250551e-01f, 6.71401098e-02f, -3.60386781e-02f, 1.06211253e-01f, -1.12134665e-01f, 3.91462585e-03f,
  1.87676057e-01f, -1.72119662e-02f, -7.66813233e-02f, -3.57822422e-03f, 1.60460249e-02f, 7.22474083e-02f, 8.04966763e-02f, -1.81880333e-02f, -9.33296382e-02f, -2.05530170e-02f,
  5.44863045e-02f, 2.27504391e-02f, -1.14531741e-01f, -2.20689159e-02f, 1.17040724e-01f, -3.53399441e-02f, -6.22564442e-02f, -1.59133058e-02f, 4.93215770e-02f, -6.74490109e-02f,
  -4.56442647e-02f, -3.15370187e-02f, 7.37712607e-02f, -1.91478804e-02f, 3.85254510e-02f, -7.91483596e-02f, -7.85680264e-02f, -3.77370007e-02f, -7.94768706e-03f, -1.44371875e-02f,
  -6.66222302e-04f, 5.40957525e-02f, 3.02942079e-02f, 6.53401716e-03f, 1.88143682e-02f, -4.60532755e-02f, -3.70487235e-02f, -8.74071009e-03f, 8.00702907e-03f, -1.52270717e-03f,
  -3.82623523e-02f, 1.02706244e-02f, -4.71305065e-02f, 1.84225962e-02f, -7.51179177e-03f, 9.71072260e-03f, 4.96547222e-02f, -2.01521702e-02f, 1.84709001e-02f, -6.94537610e-02f,
  8.38341564e-02f, 2.94235218e-02f, 5.26652411e-02f, 3.16016674e-02f, -5.99814169e-02f, -3.62570584e-02f, 2.24934071e-02f, 2.11747130e-03f, -3.43738799e-03f, -2.84719374e-02f,
  2.26542264e-01f, 2.68193074e-02f, 5.03256032e-03f, 8.97648484e-02f, -2.69374978e-02f, -1.01132818e-01f, -6.25612438e-02f, -3.48536745e-02f, 7.02471361e-02f, 5.80669083e-02f,
  -9.57169570e-04f, 1.94996670e-02f, 5.96151538e-02f, 4.54699807e-03f, -7.83909857e-02f, 2.60040611e-02f, -2.17281841e-02f, 7.67902797e-03f, -1.16723226e-02f, -3.00945938e-02f,
  7.83014372e-02f, 5.34174219e-03f, -7.36600459e-02f, 2.45316736e-02f, -3.80655751e-02f, 1.09388061e-01f, 1.07411131e-01f, -1.67872559e-03f, -3.30904089e-02f, 3.10956333e-02f,
  3.57017249e-01f, -2.64043868e-01f, 2.53579408e-01f, -1.44838795e-01f, 1.36527762e-01f, -2.15686277e-01f, -1.55077174e-01f, -1.22649960e-01f, -6.04116879e-02f, -3.60670000e-01f,
  -1.15026787e-01f, 7.07040308e-03f, -1.74802616e-01f, -3.42112094e-01f, 8.70406069e-03f, -2.74416864e-01f, -2.33966962e-01f, -7.15945959e-02f, 7.68145360e-03f, -8.15704241e-02f,
  -1.89390741e-02f, -2.53120571e-01f, -2.08201073e-02f, -3.80816497e-02f, 2.09148936e-02f, 1.23412445e-01f, -5.43608181e-02f, 1.28455907e-01f, -3.33390236e-02f, 7.20404014e-02f,
  7.85811618e-02f, -3.40633392e-02f, 7.10510463e-02f, 6.75439239e-02f, 2.12177727e-02f, 6.48356527e-02f, -9.60083120e-03f, 1.09108217e-01f, 3.52204591e-02f, -3.48928757e-02f,
  1.90349221e-02f, 3.06892209e-02f, -2.32967976e-02f, -9.97796096e-03f, 2.12056041e-02f, 1.33094355e-01f, -1.89636163e-02f, 5.97481988e-02f, 1.96032431e-02f, -9.61073907e-04f,
  7.11168870e-02f, 4.81172949e-02f, 6.15988439e-03f, -1.74275119e-04f, 7.21638426e-02f, -3.40469778e-02f, -5.23900688e-02f, 2.49458142e-02f, 1.63111538e-02f, -4.37156372e-02f,
  4.83973511e-02f, -4.58880588e-02f, -2.46575326e-02f, 2.92537566e-02f, 7.16825724e-02f, 4.94746380e-02f, -2.68674530e-02f, 1.68694351e-02f, 8.11612979e-02f, -2.63716448e-02f,
  2.66489964e-02f, 4.50956523e-02f, -6.58378704e-03f, -7.01266974e-02f, -3.00043710e-02f, -2.23276224e-02f, 7.19754398e-02f, -4.30571288e-02f, 1.12810805e-02f, -6.98570744e-04f,
  -2.11830977e-02f, -8.73925444e-03f, -3.08319516e-02f, 1.50318630e-02f, -1.97502803e-02f, -2.13643704e-02f, -4.19787876e-02f, 1.31110288e-02f, 1.50957089e-02f, 4.51178402e-02f,
  -2.62700766e-01f, -3.82235646e-01f, -7.81853795e-02f, -4.37699771e-03f, 8.17548390e-03f, 3.34054567e-02f, -5.86905889e-02f, -2.95660738e-02f, 3.16534936e-03f, -2.94791535e-02f,
  7.07199983e-03f, -5.12660444e-02f, -6.47090515e-03f, 5.59986979e-02f, -2.65212450e-02f, -7.18605593e-02f, -3.45799290e-02f, 3.59996781e-02f, -7.18508363e-02f, -5.14442995e-02f,
  -5.37171736e-02f, -6.88634217e-02f, 4.78518866e-02f, 1.32004311e-02f, 7.05217104e-03f, 2.02746186e-02f, -2.10664589e-02f, 4.60428111e-02f, -1.50522776e-02f, -5.23992516e-02f,
  1.93590462e-01f, -3.49560529e-01f, 4.75767180e-02f, -2.85243064e-01f, 1.36100367e-01f, -3.25339913e-01f, 2.06489190e-01f, -2.04451293e-01f, -5.67239374e-02f, -7.17305467e-02f,
  1.33743599e-01f, -3.16891558e-02f, 1.62021875e-01f, -2.78092682e-01f, -1.75313473e-01f, -1.94718301e-01f, -2.51057297e-01f, -5.76967597e-02f, -9.69230533e-02f, 2.65363306e-02f,
  -6.29120767e-02f, -1.88080400e-01f, -7.44477212e-02f, -1.39955193e-01f, 1.44467607e-01f, -8.80869944e-03f, 9.86095518e-02f, 8.18059668e-02f, -2.07735822e-01f, -9.92809534e-02f,
  5.06532378e-02f, 7.98462629e-02f, 3.81807908e-02f, -4.44414048e-03f, 2.78846659e-02f, 6.40816689e-02f, 3.62303518e-02f, 3.70763466e-02f, 1.46317258e-02f, -5.54783195e-02f,
  4.02413271e-02f, -1.73378866e-02f, -3.75841074e-02f, -6.23736121e-02f, -2.32203957e-03f, 2.11182311e-02f, -6.46281317e-02f, -3.73169743e-02f, -6.79449737e-02f, -8.81393999e-02f,
  -1.16847111e-02f, -6.72094449e-02f, -2.85876039e-02f, -2.80154943e-02f, 4.05255444e-02f, -5.10033742e-02f, 1.50912767e-02f, 6.29324913e-02f, -9.36860219e-02f, 6.90336339e-04f,
  -5.72240818e-03f, 9.40003991e-02f, 5.59256487e-02f, 2.18499340e-02f, -7.65006840e-02f, 5.18774092e-02f, -2.82318871e-02f, 5.93404286e-03f, 5.21848835e-02f, -6.94724917e-02f,
  2.91894190e-02f, -5.08001931e-02f, -6.06712624e-02f, 4.02669460e-02f, 9.13588032e-02f, -4.60606068e-02f, 3.78776006e-02f, -1.74449869e-02f, -3.57117392e-02f, 8.48911761e-04f,
  9.82648134e-03f, -1.00398352e-02f, 1.50612341e-02f, 5.41179962e-02f, -9.24024954e-02f, 7.88849071e-02f, 4.68560122e-02f, -8.12004060e-02f, 5.78635745e-02f, 2.25177268e-03f,
  -7.57790590e-03f, 9.25992057e-02f, 5.32925427e-02f, 2.22523790e-03f, -9.76661500e-03f, -6.57510431e-03f, -5.40810004e-02f, -7.21382275e-02f, 1.99446343e-02f, 3.85997780e-02f,
  7.38450587e-02f, 5.60404323e-02f, 4.80718575e-02f, -1.81055870e-02f, -5.51452376e-02f, 7.00903907e-02f, 3.48903313e-02f, 2.10227966e-02f, 5.65052554e-02f, -5.25983870e-02f,
  3.37686054e-02f, 6.59603477e-02f, 4.10876935e-04f, -6.06345432e-03f, 6.54038191e-02f, 5.68505116e-02f, 8.03125277e-03f, -5.48565947e-02f, -7.06256274e-03f, -5.32612726e-02f,
  -9.77185518e-02f, 2.00396404e-01f, -7.38830641e-02f, -1.04905427e-01f, 1.23360686e-01f, -3.09484929e-01f, -2.54123837e-01f, 5.53579442e-02f, -3.22662815e-02f, 1.72462285e-01f,
  -6.86917827e-02f, 6.42850175e-02f, -1.33917257e-02f, -3.29971373e-01f, -4.07166213e-01f, -9.72133279e-02f, -3.41568261e-01f, -5.18185534e-02f, -3.02630430e-03f, -1.33028524e-02f,
  -3.27993147e-02f, -2.97802780e-02f, -2.04764560e-01f, 1.93329528e-01f, 3.21239829e-02f, 1.58881053e-01f, 9.13766623e-02f, 1.24368273e-01f, 5.11779785e-02f, -6.57098964e-02f,
  -7.83161446e-02f, 3.54178026e-02f, 4.94556166e-02f, 3.09468415e-02f, -2.35627894e-03f, 3.72769497e-02f, -8.84354711e-02f, 6.82965899e-03f, -3.91614139e-02f, 1.43733677e-02f,
  -3.11663141e-03f, -2.00406220e-02f, -8.33472237e-02f, 1.17716081e-02f, 6.23873025e-02f, -6.62354752e-03f, -7.12838396e-02f, 3.78285651e-03f, 3.53222825e-02f, -9.09659266e-03f,
  -5.25676236e-02f, 3.59420888e-02f, -4.06108201e-02f, 3.03665791e-02f, -3.12465578e-02f, -2.10306048e-02f, -3.06302030e-02f, 5.02620917e-03f, 6.04878701e-02f, 3.06345336e-02f,
  2.42663547e-02f, 5.74229918e-02f, 3.72220972e-03f, -7.69657455e-03f, 1.26488395e-02f, -1.04781205e-03f, -2.64636558e-02f, 1.82735026e-02f, 4.88802120e-02f, 2.46012975e-02f,
  -5.33072650e-02f, -4.74268943e-03f, -2.84577925e-02f, 1.61733292e-02f, -3.32295038e-02f, 6.71254052e-03f, 9.37102549e-03f, 1.75333302e-02f, -2.81295404e-02f, -3.30548882e-02f,
  -5.54373749e-02f, -1.12126414e-02f, -1.84184406e-04f, -1.69230420e-02f, -2.88151503e-02f, 6.99316291e-03f, 2.70277560e-02f, 1.18449628e-02f, 2.36251671e-02f, -3.82953845e-02f,
  -1.07095748e-01f, 1.00537613e-01f, 7.30780289e-02f, 3.63231860e-02f, -3.50251198e-02f, -3.28660458e-02f, -8.00613239e-02f, -1.24436514e-02f, -1.97711755e-02f, -1.78146288e-02f,
  7.02157021e-02f, 1.08457571e-02f, 1.67860314e-02f, 3.99435349e-02f, -5.47536835e-02f, -3.81320491e-02f, 1.17334835e-02f, 1.98976230e-02f, -5.69016598e-02f, 2.72866432e-02f,
  3.24619450e-02f, 2.81330384e-02f, 6.13814034e-02f, 3.77894305e-02f, -3.91604826e-02f, -4.80033904e-02f, 3.87247987e-02f, 6.58128634e-02f, -6.27027676e-02f, 2.72842199e-02f,
  3.67416069e-02f, -2.69243389e-01f, 1.72547713e-01f, 3.44806522e-01f, 5.56007028e-02f, -4.47762549e-01f, -1.36002243e-01f, -1.77534223e-02f, 1.78867519e-01f, -2.87270427e-01f,
  -3.56637836e-02f, 2.32221335e-02f, -1.71383843e-01f, -1.47386538e-02f, 2.24987105e-01f, -2.06810459e-01f, -1.87439267e-02f, -1.41715854e-01f, 1.02416635e-01f, -4.21672985e-02f,
  1.64661512e-01f, -1.86580252e-02f, 1.30843475e-01f, -1.82133690e-02f, 9.91679206e-02f, 2.35279366e-01f, 1.93908826e-01f, 7.02325031e-02f, 3.84945571e-02f, -1.09071350e-02f,
  -1.47312790e-01f, 1.69833437e-01f, 3.64689492e-02f, -6.08225353e-02f, 2.48131771e-02f, -3.30415629e-02f, -1.83306336e-02f, -1.59355216e-02f, 1.10254571e-01f, -1.79934744e-02f,
  -1.14373088e-01f, -3.31178270e-02f, 3.89408767e-02f, 8.95605385e-02f, 3.39471363e-02f, 4.54052910e-02f, -1.76838611e-03f, -1.58595126e-02f, 2.64182910e-02f, 6.94139972e-02f,
  4.15258370e-02f, 3.14537948e-03f, 4.09914106e-02f, -2.38523707e-02f, 5.04670627e-02f, 1.27565125e-02f, 4.44363952e-02f, 2.23557148e-02f, 2.83269864e-02f, 1.17861383e-01f,
  -1.03890710e-01f, 6.21499009e-02f, 6.24864316e-03f, 1.71180554e-02f, 9.03609302e-03f, 5.08187190e-02f, 6.92336308e-03f, 1.83979012e-02f, 1.63954273e-02f, -7.53059015e-02f,
  -2.94620525e-02f, -3.72051029e-04f, 5.90518257e-03f, 8.02931190e-02f, 5.43007478e-02f, 3.57510033e-03f, -3.56758796e-02f, -4.70027253e-02f, -2.50436226e-03f, 1.56409554e-02f,
  7.46156499e-02f, -1.46661438e-02f, -1.01044074e-01f, 2.17729062e-03f, -1.01640970e-01f, 9.67029706e-02f, 1.43044582e-02f, -3.28652784e-02f, 5.04880436e-02f, -6.52926136e-03f,
  -2.05213308e-01f, 7.02762380e-02f, 1.59567073e-02f, 8.35613161e-03f, -8.75515565e-02f, -6.16794340e-02f, 6.50952831e-02f, -4.56173308e-02f, -5.66318445e-02f, -5.60147427e-02f,
  -1.25324829e-02f, -7.70549336e-03f, -4.88794707e-02f, -7.20156878e-02f, 1.50759583e-02f, -6.68495372e-02f, -6.72328752e-03f, -2.17214227e-02f, 3.77855673e-02f, -2.95809135e-02f,
  -1.81646850e-02f, -4.95974422e-02f, 8.47058594e-02f, 1.03483871e-01f, -1.02737285e-02f, 1.88410133e-02f, 5.97462233e-04f, -3.36704194e-04f, 5.10112867e-02f, 7.65723083e-03f,
  -2.45848775e-01f, 2.63776958e-01f, 7.06473216e-02f, -1.80609554e-01f, -2.31777161e-01f, -6.46417588e-02f, -1.70167133e-01f, 6.95857257e-02f, 2.36726627e-01f, 3.71266492e-02f,
  -9.37863067e-02f, -1.62779242e-01f, 5.17529547e-02f, 1.14193012e-04f, -1.79322734e-01f, 2.69604027e-01f, -2.15971116e-02f, -7.15882704e-03f, 2.40489453e-01f, -1.84035480e-01f,
  5.12247197e-02f, -1.53330907e-01f, 8.91684517e-02f, 3.78404520e-02f, -6.46646544e-02f, -5.57522057e-03f, -1.31313294e-01f, -9.55535471e-03f, -1.83516771e-01f, 3.68676223e-02f,
  2.83019990e-02f, 1.16074599e-01f, -2.91676112e-02f, 1.09229218e-02f, -1.00554600e-02f, -1.04414113e-01f, -8.99241716e-02f, -3.15975063e-02f, -6.10048398e-02f, 6.60489351e-02f,
  -5.84695973e-02f, -3.56241576e-02f, -2.06877794e-02f, 8.35230015e-03f, -1.37304300e-02f, 5.89847937e-02f, -1.83034241e-02f, 2.55466886e-02f, 3.26485111e-04f, -2.66309902e-02f,
  6.13806918e-02f, -4.42103297e-02f, -4.53024358e-02f, 8.21886733e-02f, -3.26413885e-02f, 4.83682640e-02f, -6.22640401e-02f, -1.13638133e-01f, 4.02767882e-02f, 2.92490423e-02f,
  -2.47855205e-02f, 2.33374685e-02f, -7.78499898e-03f, 3.42388153e-02f, -6.08264208e-02f, 5.98565908e-03f, 5.76154748e-03f, -3.58040296e-02f, 3.63319516e-02f, 7.94529449e-03f,
  -6.17334340e-03f, -4.37836051e-02f, 5.44737233e-03f, -9.98321250e-02f, -6.21631145e-02f, 3.62751400e-03f, 3.03135253e-02f, -8.78898725e-02f, -6.10954724e-02f, -6.66546542e-03f,
  1.10655017e-01f, -1.65632851e-02f, -3.00300843e-03f, 4.40557982e-04f, 1.98306404e-02f, -4.79619130e-02f, -1.34923672e-02f, 2.61776317e-02f, -3.89643088e-02f, -1.72030758e-02f,
  -5.84712736e-02f, 1.33520663e-01f, 4.72260304e-02f, -2.03750525e-02f, 8.10331255e-02f, -8.65890458e-03f, 1.05820343e-01f, 3.52817103e-02f, -1.00362254e-02f, 8.65155011e-02f,
  -1.17372386e-01f, -3.15205269e-02f, 3.39712203e-02f, -9.18131247e-02f, -5.84484562e-02f, -3.50018255e-02f, 6.05313852e-02f, 3.86888050e-02f, -4.18191999e-02f, 5.34560392e-03f,
  -9.52571183e-02f, -4.59325910e-02f, 8.18108767e-02f, -3.41079310e-02f, -2.53555197e-02f, -3.63914073e-02f, -9.05445591e-02f, -1.06995665e-02f, 4.07051668e-02f, 2.25097151e-03f,
  4.44105119e-02f, -2.99689453e-02f, -9.84707754e-03f, 1.07212020e-02f, -9.36742723e-02f, -1.35023668e-01f, 3.37715179e-01f, -1.52303845e-01f, 2.57261634e-01f, 3.77019756e-02f,
  -3.41274589e-02f, 7.18439743e-02f, 2.76818871e-01f, -1.87161967e-01f, 6.30902350e-02f, 2.69586921e-01f, -1.90373704e-01f, 4.48831804e-02f, 9.33526531e-02f, -1.51173711e-01f,
  -9.38154459e-02f, -1.09756194e-01f, -4.91393581e-02f, -1.49813592e-01f, -8.00508335e-02f, -6.05720729e-02f, -2.07087845e-01f, 1.19740583e-01f, -3.36731315e-01f, -1.61135923e-02f,
  2.47430950e-02f, 7.94061422e-02f, 3.57959233e-02f, 6.07741885e-02f, -7.21432865e-02f, 3.55992466e-02f, -4.32422012e-02f, 1.54490680e-01f, 3.28238755e-02f, -5.30107133e-02f,
  2.62643080e-02f, -4.05240618e-02f, -6.83453381e-02f, 1.26125908e-03f, 1.25654852e-02f, -4.37080674e-02f, 6.83333678e-03f, -2.68592406e-02f, 2.32481249e-02f, 2.35219952e-02f,
  1.18347600e-01f, -7.02049732e-02f, -1.37607679e-02f, -6.25196192e-03f, -7.93623924e-02f, 2.18529850e-02f, 6.06361441e-02f, 3.01080327e-02f, -3.74450488e-03f, 1.24676730e-02f,
  -2.16721296e-02f, 3.97428907e-02f, 1.20493863e-02f, -4.60818857e-02f, 1.81336161e-02f, -1.75730861e-03f, -1.17263589e-02f, 2.33174488e-02f, 7.66905099e-02f, -4.80401516e-02f,
  -2.47676689e-02f, -2.22987588e-02f, -1.09202210e-02f, -2.09103408e-03f, -2.09302641e-02f, 1.30917430e-02f, 2.29238328e-02f, -2.20909212e-02f, -3.68334875e-02f, 4.82540485e-03f,
  5.24069590e-04f, -2.10807985e-03f, -1.60010289e-02f, -4.32120729e-03f, 2.07417328e-02f, 1.11651672e-02f, -7.29658604e-02f, -1.08988080e-02f, 5.86908087e-02f, -3.18774208e-02f,
  -1.14965275e-01f, -1.54797435e-01f, 3.79438768e-03f, 5.53703606e-02f, -3.01329009e-02f, -7.60127157e-02f, 8.06596801e-02f, -1.30678520e-01f, -1.43221281e-02f, 7.01507274e-03f,
  -5.05903289e-02f, 7.12401494e-02f, -1.25546277e-01f, -4.17537615e-02f, -2.22798064e-02f, 1.36434166e-02f, -2.62919553e-02f, -3.98210809e-02f, -9.86341164e-02f, -1.03770465e-01f,
  -6.44817501e-02f, -3.65083255e-02f, -2.93406565e-03f, -3.66076007e-02f, -5.51681109e-02f, 1.05243158e-02f, -2.84086866e-03f, 9.81733296e-03f, -1.19205996e-01f, 5.54753803e-02f,
  2.76945800e-01f, 3.07570755e-01f, 1.63637325e-01f, 4.53152508e-01f, -2.27471609e-02f, -1.60402209e-02f, 3.36963236e-02f, 2.06773028e-01f, 2.53723711e-01f, 3.90333496e-02f,
  1.47629827e-02f, 8.65884945e-02f, -7.45917112e-02f, 3.49498987e-01f, -2.13812143e-01f, 4.07644324e-02f, 3.52249146e-01f, 3.54251601e-02f, 1.17038794e-01f, 2.19845816e-01f,
  1.33084178e-01f, -2.79163774e-02f, 7.84154534e-02f, 1.38346097e-02f, 1.33998334e-01f, 1.66573688e-01f, -6.50301725e-02f, -1.72695130e-01f, -2.61646919e-02f, -1.08684830e-01f,
  -3.60898003e-02f, 5.23405597e-02f, 6.65771365e-02f, -3.09079215e-02f, 9.31463242e-02f, -3.47840339e-02f, -8.35779086e-02f, -1.17474928e-01f, -5.27067184e-02f, 7.46763661e-04f,
  -5.13117053e-02f, -3.29502411e-02f, 5.39936833e-02f, -3.89026031e-02f, 5.37163988e-02f, 1.39501747e-02f, 2.82475203e-02f, 3.02152913e-02f, 2.71562599e-02f, 2.26483331e-03f,
  5.96357733e-02f, 4.41983603e-02f, 7.27314278e-02f, 6.38685189e-03f, 5.06755039e-02f, 9.76441726e-02f, 1.12451818e-02f, -3.75686213e-02f, -3.51084322e-02f, 1.36642486e-01f,
  2.95592528e-02f, -1.68156475e-02f, 2.08999254e-02f, 1.91331003e-02f, 1.60938725e-02f, -1.57684255e-02f, 1.35512697e-02f, -5.47764786e-02f, 1.77290328e-02f, 2.79544550e-03f,
  4.24703658e-02f, 5.02747074e-02f, 4.39921767e-02f, 8.10463428e-02f, 2.29326468e-02f, 7.49438778e-02f, -6.83652535e-02f, 2.43432578e-02f, 6.67327866e-02f, -2.14310773e-02f,
  -5.86353280e-02f, 3.00990716e-02f, -6.82053193e-02f, -3.01946774e-02f, -3.07423715e-02f, 2.89818048e-02f, 3.95138562e-02f, 3.72509472e-02f, -6.54748678e-02f, -9.49629024e-02f,
  1.21175788e-01f, 1.89037055e-01f, -3.31843621e-03f, -7.47173727e-02f, -9.79461819e-02f, 8.69538449e-03f, -9.46930517e-03f, 7.32051507e-02f, 5.03923558e-02f, -6.98247924e-03f,
  1.29393507e-02f, 3.21553089e-03f, 1.25436240e-03f, 1.02142300e-02f, -2.43613124e-02f, 1.83843747e-02f, -2.11650766e-02f, -3.69979143e-02f, -7.79823512e-02f, -4.56453068e-03f,
  -9.43655148e-03f, -2.75890753e-02f, -6.10272819e-03f, -9.64180473e-03f, -1.31685976e-02f, -5.94389588e-02f, 1.80480648e-02f, 5.44277206e-02f, 4.38543921e-03f, -1.74557772e-02f,
  3.90148640e-01f, -1.35782093e-01f, 5.18158637e-02f, 1.72489643e-01f, 1.15663625e-01f, -1.63154379e-01f, 1.24313414e-01f, 9.45098400e-02f, -4.64621037e-02f, -1.52044922e-01f,
  7.56367296e-02f, 9.60663483e-02f, 1.43796513e-02f, 2.22139731e-01f, 1.73127547e-01f, -1.02631442e-01f, 2.25279704e-02f, -1.01387789e-02f, -4.11088131e-02f, 1.04644664e-01f,
  1.39858663e-01f, 1.21990919e-01f, 2.03271344e-01f, -8.68370663e-03f, 1.86664581e-01f, 2.45860219e-02f, 7.17647001e-03f, -2.39086896e-01f, 9.79769528e-02f, -1.67507976e-02f,
  -4.03073803e-03f, 1.13548711e-01f, 1.32899493e-01f, -6.67775720e-02f, -3.38070579e-02f, -5.29797897e-02f, 1.28828771e-02f, 2.64505241e-02f, 3.64925042e-02f, 2.83272546e-02f,
  -1.02426931e-02f, 4.76233698e-02f, 8.03381130e-02f, -6.27165139e-02f, -6.37189150e-02f, 1.47592667e-02f, 1.01402156e-01f, 1.88459698e-02f, 6.28667846e-02f, 1.05335429e-01f,
  3.40930112e-02f, 3.04314289e-02f, 2.21593622e-02f, -2.03275345e-02f, 9.16932300e-02f, 4.15797420e-02f, -2.21753158e-02f, 9.48716104e-02f, -6.25593290e-02f, 9.76650938e-02f,
  1.11381732e-01f, -5.67882322e-02f, 6.21029101e-02f, 3.83742899e-02f, 3.73219289e-02f, 6.72578299e-03f, -1.03670716e-01f, 6.57366812e-02f, 1.88554246e-02f, -2.13563032e-02f,
  3.21071632e-02f, -1.46380858e-03f, -3.17415111e-02f, -5.82559295e-02f, -1.83257833e-02f, 7.31122820e-03f, -1.14005087e-02f, -1.26573490e-02f, 1.04953675e-02f, 1.39464894e-02f,
  -7.57940859e-02f, -1.05717458e-01f, 7.58217201e-02f, -1.30737666e-02f, -6.78515732e-02f, 8.36630464e-02f, -4.38235402e-02f, 3.12468066e-04f, -4.27031070e-02f, -1.30893802e-02f,
  -2.50560462e-01f, -1.87980935e-01f, 5.68081848e-02f, 3.96723673e-02f, -2.15686783e-02f, -1.93595067e-02f, -9.87155288e-02f, 3.81045528e-02f, -7.93464705e-02f, -1.32039404e-02f,
  -2.49001216e-02f, 2.95081567e-02f, -8.28641057e-02f, 3.65622565e-02f, -3.24957184e-02f, 1.52247110e-02f, -1.12807909e-02f, -7.71983340e-02f, -2.70838905e-02f, 1.59243289e-02f,
  6.91918330e-03f, 6.12838147e-03f, 2.41753981e-02f, 7.28816614e-02f, -2.70624049e-02f, -7.70337461e-03f, -2.36405861e-02f, -8.02005455e-02f, -2.54052579e-02f, -9.37185436e-02f,
  -2.41885006e-01f, 1.01795718e-02f, 1.42033443e-01f, 9.86412689e-02f, 2.12496936e-01f, -2.65326709e-01f, -3.62426490e-01f, 2.98808336e-01f, -1.90965205e-01f, 3.23492661e-02f,
  -1.55410647e-01f, -3.11562955e-01f, -2.16545731e-01f, -1.09392159e-01f, -1.70687139e-01f, -5.60595505e-02f, 2.77083274e-02f, -8.12287182e-02f, 8.57271254e-03f, -2.72944383e-02f,
  1.08167067e-01f, 1.20923817e-01f, 2.62770783e-02f, 2.70975322e-01f, 1.46755055e-01f, 1.86881050e-01f, 2.03389466e-01f, 3.06418315e-02f, 1.45731822e-01f, -6.59120977e-02f,
  -7.58566856e-02f, -1.25558078e-01f, 5.82470559e-02f, -7.21628740e-02f, 3.80528457e-02f, -3.00451387e-02f, -7.40821362e-02f, -5.14206178e-02f, -6.17652386e-03f, 2.09794212e-02f,
  -7.77547136e-02f, 4.31662127e-02f, 6.46973327e-02f, 7.49419350e-03f, -3.79267484e-02f, 5.21739200e-02f, 1.52850151e-02f, 6.78045908e-03f, -1.35267070e-02f, -1.74323488e-02f,
  -7.09289163e-02f, -4.81872121e-03f, -5.32373600e-03f, 2.42712870e-02f, 1.16195418e-02f, -7.02035576e-02f, 5.70305325e-02f, -2.41525490e-02f, 4.95975018e-02f, 1.36650000e-02f,
  -3.13207041e-03f, 2.55759377e-02f, 4.21960764e-02f, 6.85787126e-02f, -6.35702312e-02f, 7.59646222e-02f, -1.30300242e-02f, 2.02949159e-02f, -1.64041948e-03f, -4.77002412e-02f,
  4.54332829e-02f, 1.49752554e-02f, 1.85955898e-04f, 4.45910431e-02f, 3.71432342e-02f, 3.97652620e-03f, -1.70897022e-02f, -2.51978114e-02f, 4.12992425e-02f, 3.78801022e-03f,
  1.30506027e-02f, -1.86860394e-02f, -9.58285574e-03f, -3.43559124e-02f, -1.21423341e-02f, -4.39250879e-02f, 1.00881241e-01f, 7.22062960e-02f, 1.85000692e-02f, -1.17294514e-03f,
  -1.04380451e-01f, -1.59791876e-02f, 3.22759412e-02f, -5.72350994e-03f, -7.02142641e-02f, 9.60982591e-02f, 2.04640310e-02f, 1.01362571e-01f, -5.59348650e-02f, -2.86590005e-03f,
  4.78368141e-02f, 9.92865041e-02f, 3.99747565e-02f, -6.32330403e-02f, 8.16799477e-02f, 1.09776761e-02f, -3.92380990e-02f, -2.27534454e-02f, -5.64074051e-03f, 9.19306055e-02f,
  1.19827561e-01f, 2.98409052e-02f, 9.26143602e-02f, 6.69960901e-02f, 7.69335032e-02f, 2.15638373e-02f, -2.20695660e-02f, 1.74021330e-02f, 6.00837730e-02f, 1.74297206e-02f,
  4.42059152e-02f, -3.79677042e-02f, 2.08540544e-01f, -1.10651799e-01f, 4.77833673e-02f, -1.13484405e-01f, 2.31590346e-01f, -1.34459227e-01f, 2.29466051e-01f, -1.53170183e-01f,
  -5.45805097e-02f, 1.44241676e-01f, 1.95266843e-01f, -1.95874766e-01f, 1.84862062e-01f, 1.35414481e-01f, -1.15960598e-01f, -4.93862405e-02f, 1.40747741e-01f, 6.57460513e-03f,
  -5.25338873e-02f, -1.36423782e-01f, -1.27541991e-02f, -1.74362242e-01f, -1.38965383e-01f, -1.31542727e-01f, -1.81714699e-01f, 1.82222351e-01f, -2.74065733e-01f, 6.83452114e-02f,
  -1.54213622e-01f, -4.68487032e-02f, -5.77147231e-02f, -9.33597088e-02f, -7.24266618e-02f, 6.37662560e-02f, 7.22218528e-02f, 1.30986229e-01f, 5.61560579e-02f, -3.20189372e-02f,
  4.81075197e-02f, 3.23844068e-02f, -5.36551066e-02f, -1.32923769e-02f, 1.06754014e-02f, 1.91875249e-02f, -6.49575964e-02f, -6.31819963e-02f, -7.04336390e-02f, 1.36498213e-02f,
  4.73688990e-02f, -1.53865421e-03f, -4.57659401e-02f, -5.28909862e-02f, -5.25867427e-03f, -4.28402750e-03f, 2.28406228e-02f, 6.83720857e-02f, -5.52349202e-02f, 1.63343493e-02f,
  3.01206466e-02f, 8.82568359e-02f, 3.82054001e-02f, 1.50258234e-02f, 2.18154844e-02f, -6.24172688e-02f, -2.38532443e-02f, -2.35367101e-02f, 5.10295294e-03f, -9.54550356e-02f,
  -5.73091656e-02f, -7.45039210e-02f, 6.54148264e-03f, 6.25709957e-03f, 5.14699817e-02f, 3.57750729e-02f, 2.60334020e-03f, -8.61598477e-02f, 4.74897921e-02f, -8.94186869e-02f,
  5.93547598e-02f, -4.37492877e-02f, 5.54243140e-02f, -2.35904381e-03f, 7.22323284e-02f, 4.34655808e-02f, 3.28697935e-02f, 4.69391830e-02f, 6.03491217e-02f, -1.03154569e-03f,
  -1.08825386e-01f, -8.61232132e-02f, -2.34790146e-02f, -4.63450998e-02f, -4.05086540e-02f, -5.49235754e-02f, -1.69260912e-02f, 1.04592470e-02f, -4.81066061e-03f, 1.37860724e-03f,
  -3.90319005e-02f, -9.51347202e-02f, -1.17116002e-02f, 4.31758799e-02f, 2.92216148e-02f, 2.06160061e-02f, 2.73071639e-02f, -2.33203135e-02f, -1.13073466e-02f, -8.34140629e-02f,
  -6.97804540e-02f, 3.84222455e-02f, 1.83965676e-02f, 2.61433441e-02f, -8.65429118e-02f, 2.05216892e-02f, 2.62288284e-02f, -1.93740372e-02f, 2.30536819e-03f, -2.54700594e-02f,
  -6.06444553e-02f, -1.23821497e-01f, -1.92752048e-01f, -2.26535380e-01f, -2.00846002e-01f, 3.05997163e-01f, 2.31540948e-01f, -1.12198800e-01f, -3.28996539e-01f, 3.74405414e-01f,
  1.96673661e-01f, -4.76138480e-03f, 2.03085229e-01f, 2.95225549e-02f, -1.53975248e-01f, -3.79683040e-02f, 1.34724662e-01f, 1.49787173e-01f, -2.16244698e-01f, -1.41649717e-03f,
  -1.48820132e-01f, 2.66080350e-01f, -2.22666278e-01f, -1.01397671e-01f, 3.78888771e-02f, -6.48607686e-02f, 1.99842200e-01f, -1.51852757e-01f, 3.11643747e-03f, -8.55421126e-02f,
  1.21669210e-02f, -1.15928441e-01f, 3.37218530e-02f, -3.85209695e-02f, 9.07839388e-02f, 1.15898229e-01f, 5.94593696e-02f, 3.72063033e-02f, -5.65443002e-02f, 3.81859988e-02f,
  1.29676402e-01f, 8.07765275e-02f, -1.46561246e-02f, 3.12489159e-02f, -2.36603972e-02f, -5.95577881e-02f, -1.41934723e-01f, -8.70033801e-02f, -4.40240279e-02f, 5.05439974e-02f,
  -4.33411859e-02f, -7.29277506e-02f, 4.77247648e-02f, 3.72106247e-02f, -1.04885973e-01f, -6.98800907e-02f, 2.97358148e-02f, 6.28959835e-02f, 5.19132949e-02f, -6.51658699e-02f,
  7.01020844e-03f, -6.06839433e-02f, -3.89377512e-02f, 2.49515660e-02f, -9.87406969e-02f, 5.46652675e-02f, 1.19383251e-02f, 1.58236884e-02f, -8.82303268e-02f, 8.18572182e-04f,
  3.13979574e-02f, -7.37645626e-02f, -7.52272010e-02f, 2.05869880e-03f, 6.03102241e-03f, -1.69238951e-02f, -1.17776627e-02f, 1.27529642e-02f, -6.48037866e-02f, -6.35807514e-02f,
  -2.98303459e-03f, -3.79587188e-02f, -2.76055280e-02f, 3.46561298e-02f, 6.80659488e-02f, -4.95469430e-03f, 9.07021924e-04f, 3.87434773e-02f, -7.81055167e-02f, -6.98275585e-03f,
  -1.02357799e-02f, -8.78214836e-03f, 5.13028773e-03f, -3.84069346e-02f, -7.16212913e-02f, 4.47712168e-02f, -6.35744557e-02f, 5.70944250e-02f, -5.46034090e-02f, 4.33488749e-02f,
  1.12961516e-01f, 5.13345189e-03f, 3.16115692e-02f, 3.53916474e-02f, -6.97747841e-02f, 5.79752848e-02f, 5.11517562e-02f, -7.14602247e-02f, 3.21606547e-02f, 7.96202221e-04f,
  7.18840435e-02f, 5.66751659e-02f, 5.97237125e-02f, 1.15122711e-02f, 1.80204734e-01f, 6.25959262e-02f, -4.43836972e-02f, -6.25433624e-02f, -1.26722818e-02f, 6.65360466e-02f,
  -2.72925496e-01f, 3.71339530e-01f, 2.47927636e-01f, 1.64362818e-01f, -3.53245705e-01f, 7.00308383e-02f, 8.94597769e-02f, -3.72359753e-02f, -9.12216827e-02f, 1.32916033e-01f,
  -1.80266649e-01f, 1.73432812e-01f, -6.29676953e-02f, 2.27011442e-01f, -9.78583246e-02f, 8.08365718e-02f, 1.76493600e-01f, 9.61088911e-02f, -2.91346591e-02f, -4.83149961e-02f,
  -1.78241041e-02f, -1.34811684e-01f, 8.17794576e-02f, -1.77492574e-02f, -4.38743234e-02f, -2.90316641e-02f, -4.87615988e-02f, 6.22863434e-02f, 1.02385879e-01f, -7.59376585e-02f,
  -1.64092973e-01f, -1.60303578e-01f, 4.89853090e-03f, 6.66950122e-02f, -3.12031005e-02f, 2.34661289e-02f, 5.51953074e-03f, -6.71651140e-02f, 3.37579548e-02f, -7.89234531e-04f,
  6.08248226e-02f, 2.85550207e-02f, -2.70133726e-02f, 3.17355879e-02f, -2.83783041e-02f, -6.49984693e-03f, -1.90276336e-02f, -1.50331538e-02f, 6.49799872e-03f, 4.47744951e-02f,
  -1.47024347e-02f, 5.11368690e-03f, 1.15810183e-03f, 1.15489297e-01f, -7.80917285e-03f, -5.69999442e-02f, 7.11343661e-02f, 2.91576739e-02f, 8.07618722e-03f, 1.02970777e-02f,
  -8.50206614e-02f, 6.44563660e-02f, -1.84001252e-02f, -6.39398396e-02f, -9.55160335e-03f, -9.47110504e-02f, 5.89144677e-02f, -1.74554549e-02f, 4.23331745e-02f, -4.17790711e-02f,
  -4.15900052e-02f, -5.49250841e-03f, -7.61356130e-02f, -1.44798048e-02f, 2.92209685e-02f, -2.68740989e-02f, 3.41639183e-02f, 2.45136339e-02f, -1.60835497e-02f, -6.48358166e-02f,
  -3.58166173e-02f, -1.54541880e-02f, -1.54207870e-02f, -2.55915672e-02f, 2.28147451e-02f, 1.88133772e-02f, 3.02425753e-02f, -1.70577876e-02f, -6.22972809e-02f, -7.04601291e-04f,
  8.94402266e-02f, 2.06161037e-01f, -2.16839109e-02f, -1.02655664e-01f, 8.09692815e-02f, 7.18242750e-02f, 1.06852017e-02f, 6.65008053e-02f, 5.77343069e-02f, -3.39795016e-02f,
  4.06379923e-02f, 8.77020508e-02f, -4.07368643e-04f, 4.22823522e-03f, 1.81750655e-02f, -2.74485052e-02f, 4.80815470e-02f, 5.60857728e-02f, -1.03966026e-02f, -4.65804711e-02f,
  -2.80991737e-02f, -1.59736872e-02f, 2.04485282e-02f, -1.83611382e-02f, 2.46084724e-02f, -2.44917348e-02f, 4.11636867e-02f, -5.78058623e-02f, -4.63586338e-02f, 3.89585532e-02f,
  -4.29900363e-02f, -5.97461611e-02f, -3.10105294e-01f, 8.41348097e-02f, 8.42456967e-02f, -2.78568983e-01f, 4.11814973e-02f, 6.87432438e-02f, 7.92478397e-03f, 6.17826693e-02f,
  1.21562324e-01f, -1.18277237e-01f, 8.11631083e-02f, 7.16759562e-02f, 2.09246784e-01f, -2.40821019e-02f, 9.50354561e-02f, -4.20336165e-02f, 4.94991662e-03f, 8.32444057e-02f,
  -6.03239052e-02f, 2.95529664e-01f, -7.21461177e-02f, 5.63837402e-02f, -1.05229557e-01f, -9.63459089e-02f, 3.62358540e-01f, -6.14297204e-02f, 2.52619870e-02f, 5.39452210e-02f,
  -3.48967314e-02f, 9.41988081e-02f, -7.94369653e-02f, -2.70381719e-02f, 4.73515540e-02f, 2.66532656e-02f, 1.45644620e-02f, -6.10879138e-02f, 4.19123136e-02f, -4.27548513e-02f,
  -9.04641747e-02f, 3.93386409e-02f, -6.28494378e-03f, -4.40157689e-02f, -1.64187215e-02f, -3.09625641e-02f, -1.22849748e-01f, -6.99764341e-02f, -3.96970101e-02f, -6.42112494e-02f,
  -3.75332013e-02f, -1.06155924e-01f, 1.85922626e-02f, -3.35847028e-02f, -3.33524086e-02f, -2.64902581e-02f, -8.77212584e-02f, -7.68581852e-02f, -3.77697647e-02f, -4.78029735e-02f,
  -8.60836655e-02f, 9.31336358e-02f, 3.39198881e-03f, 3.81429680e-02f, 1.93644278e-02f, -1.18176024e-02f, 1.63005721e-02f, 2.40987260e-02f, 5.16373329e-02f, -1.43236546e-02f,
  4.30395864e-02f, -4.21310402e-03f, 4.00400301e-03f, -1.54893901e-02f, 4.05287892e-02f, 3.96282636e-02f, -2.42240429e-02f, -5.66993020e-02f, -1.86578613e-02f, -3.63269448e-02f,
  -2.41482770e-03f, 1.13915876e-02f, 1.08193867e-02f, -2.12138873e-02f, 2.25857552e-02f, 8.22988153e-03f, 1.00918487e-02f, -7.73534477e-02f, -2.07630713e-02f, 4.91274633e-02f,
  2.54441530e-01f, 2.35816047e-01f, 1.08956352e-01f, -1.19341603e-02f, 2.24878863e-02f, 3.12293712e-02f, 1.00139193e-02f, -3.36516537e-02f, 4.55792099e-02f, -1.65011603e-02f,
  -5.71914054e-02f, -1.39347911e-02f, 1.09799225e-02f, 1.88601613e-02f, 5.22326529e-02f, 2.63141412e-02f, 1.03285670e-01f, 5.08727171e-02f, 1.38918057e-01f, 6.44942839e-03f,
  3.42535181e-03f, -1.08059868e-02f, 1.37988187e-03f, 3.18117887e-02f, 3.71564813e-02f, -2.48346683e-02f, 4.06338647e-02f, -2.08406039e-02f, 1.14867361e-02f, 9.10772663e-03f,
  -4.20570344e-01f, 1.10809170e-01f, 1.61624610e-01f, -1.41439229e-01f, -2.38126844e-01f, -1.86821371e-01f, -2.88113803e-01f, -7.97990710e-03f, -2.86291808e-01f, 1.90357462e-01f,
  6.07888168e-03f, 8.33318979e-02f, 2.29013234e-01f, 3.12065613e-02f, -2.88818240e-01f, 1.72479689e-01f, -5.84782287e-02f, 1.08914468e-02f, -5.11020888e-03f, -1.20723277e-01f,
  -1.27366781e-01f, -2.20050335e-01f, 8.90184268e-02f, 1.33178592e-01f, -1.69261307e-01f, 5.11577018e-02f, 1.03063732e-01f, 5.93040660e-02f, 5.30891828e-02f, -9.30566788e-02f,
  -1.07038826e-01f, 4.74679880e-02f, 3.71097811e-02f, -1.21851247e-02f, -8.88704732e-02f, 2.03731619e-02f, 2.45758314e-02f, -2.04404145e-02f, -4.48831655e-02f, -1.31236883e-02f,
  -6.08591586e-02f, -5.18699512e-02f, -1.05576329e-01f, 7.97454864e-02f, -9.24390703e-02f, 2.20558923e-02f, 3.89280170e-02f, 3.08041144e-02f, 2.39522830e-02f, 7.69872367e-02f,
  1.00247264e-01f, 4.11338694e-02f, 1.57550238e-02f, 4.13339734e-02f, -7.40864202e-02f, 2.83410344e-02f, 2.79788952e-02f, 1.98165979e-02f, -8.67367685e-02f, -4.48101088e-02f,
  -1.51733002e-02f, 1.83133390e-02f, 3.65203470e-02f, 2.95045786e-03f, 3.88426632e-02f, -2.98872720e-02f, 5.12816943e-02f, -2.08741496e-03f, 5.04228063e-02f, -2.27152184e-02f,
  -8.61214846e-02f, 5.81166614e-03f, 3.73127405e-03f, 1.00391038e-01f, -3.28749903e-02f, 2.80711204e-02f, 3.11750900e-02f, -1.69801316e-03f, 2.55675316e-02f, -2.08793487e-02f,
  4.93121780e-02f, -4.53965440e-02f, 4.22489829e-02f, 1.55409630e-02f, 2.92610880e-02f, 4.73440066e-02f, 6.87177703e-02f, 7.98140615e-02f, 1.59787107e-02f, -4.62543741e-02f,
  -1.47065878e-01f, -1.35370970e-01f, 1.30196428e-03f, 4.01702821e-02f, 6.54848814e-02f, 4.18130457e-02f, 2.52970383e-02f, 4.28700168e-03f, -1.04563311e-01f, -9.72167477e-02f,
  5.23424987e-03f, 6.60431609e-02f, -5.24907336e-02f, 5.41415811e-02f, 2.81126276e-02f, -3.95031087e-02f, -1.11843921e-01f, -6.74800668e-03f, -9.79754999e-02f, -4.90291007e-02f,
  4.46490422e-02f, -8.03671107e-02f, -3.29174995e-02f, -7.33135343e-02f, 9.14988294e-03f, -5.80848530e-02f, -2.46513989e-02f, 4.36633220e-03f, -4.94815521e-02f, 2.46090423e-02f,
  3.51837397e-01f, 2.65379399e-01f, -1.15433931e-01f, 2.24101603e-01f, -1.60138849e-02f, -1.29397869e-01f, 1.21471420e-01f, -4.29247431e-02f, 6.27700984e-02f, 2.10378379e-01f,
  -1.76199209e-02f, 2.11680293e-01f, -1.59684017e-01f, 1.11469619e-01f, -1.18753590e-01f, -1.81985110e-01f, 1.96854636e-01f, 1.66563779e-01f, -1.38275623e-01f, 3.09167325e-01f,
  -3.53366137e-02f, -8.08827113e-03f, -3.18122320e-02f, -8.15524310e-02f, 1.14906155e-01f, -3.05341519e-02f, -3.20692593e-03f, -2.08773673e-01f, 1.17508538e-01f, -1.03043942e-02f,
  -9.67689510e-03f, 7.22568333e-02f, 8.42873454e-02f, -1.17164411e-01f, 8.60757083e-02f, 4.25646380e-02f, 4.38351445e-02f, -7.51305223e-02f, 3.55865061e-02f, -3.14128548e-02f,
  -3.43318619e-02f, -1.11807384e-01f, -6.38031885e-02f, -1.05323240e-01f, -1.37275569e-02f, -1.97909195e-02f, -7.81216994e-02f, 4.22453554e-03f, 8.99295285e-02f, 5.37269143e-03f,
  5.21886274e-02f, -3.20643596e-02f, 8.29055682e-02f, 2.56307889e-02f, -8.86576772e-02f, 1.04766637e-02f, -1.54874464e-02f, -1.19369701e-02f, -5.20422915e-03f, 7.80893071e-03f,
  1.37505457e-01f, 9.64909606e-03f, -6.02596393e-03f, -2.45334227e-02f, -4.22383621e-02f, 3.14990282e-02f, -2.23061647e-02f, 7.93129485e-03f, 2.16782503e-02f, -4.37801778e-02f,
  -2.73802411e-02f, 3.29819229e-03f, -6.56613614e-03f, -1.66999586e-02f, 2.12565791e-02f, 2.20992435e-02f, -1.02791386e-02f, -1.37693852e-01f, 6.67010024e-02f, -2.35089492e-02f,
  6.04698397e-02f, 6.06622882e-02f, -8.57970119e-03f, 2.66003683e-02f, 5.46561629e-02f, -4.10770066e-02f, -5.88040277e-02f, -2.72108838e-02f, 7.81650888e-04f, -4.25133221e-02f,
  1.64029822e-01f, 1.77860364e-01f, 5.09530213e-03f, 3.48370010e-03f, 3.56572866e-02f, -3.92049290e-02f, 3.17113362e-02f, 8.48266035e-02f, -7.59103708e-03f, -2.98175979e-02f,
  6.25134930e-02f, 7.00791180e-02f, 1.27278557e-02f, -1.28970388e-02f, 4.88679521e-02f, 3.52057703e-02f, 5.20919487e-02f, 2.43901554e-02f, 4.76766899e-02f, -4.91058789e-02f,
  -3.39493267e-02f, 5.90651818e-02f, 3.27926278e-02f, 6.90483898e-02f, 9.01440829e-02f, 3.39386277e-02f, 3.89917567e-02f, -4.99257371e-02f, -1.45291358e-01f, -3.12762670e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.47882652e-01f, -1.22085750e-01f, -4.41341192e-01f, -3.65207434e-01f, 1.28330022e-01f, -3.78523827e-01f, -1.91923603e-01f, -9.68993157e-02f, -1.15357883e-01f, 2.55007327e-01f,
  2.20367946e-02f, -2.37756863e-01f, 2.42641568e-01f, -4.39418286e-01f, -5.80241263e-01f, -2.74514109e-01f, -4.76138800e-01f, -1.91305846e-01f, -4.49775830e-02f, -1.11590751e-04f,
  -1.65504947e-01f, -6.43011630e-02f, -3.94406199e-01f, 2.79283553e-01f, -6.16099760e-02f, 9.32735205e-02f, 2.73246765e-01f, 1.73956320e-01f, -8.49813223e-02f, -1.32541209e-01f,
  -1.37511507e-01f, 3.29454639e-03f, 4.00485191e-03f, -1.09279975e-01f, -8.60641599e-02f, 7.63889924e-02f, 5.40219201e-03f, -1.40812034e-02f, -1.06257014e-02f, -1.58301979e-01f,
  4.24321257e-02f, 3.39982584e-02f, -7.27009401e-02f, -3.39123211e-03f, -1.50869172e-02f, -6.48355335e-02f, -1.73396230e-01f, -3.15105096e-02f, -2.30219238e-03f, -1.19851045e-01f,
  -2.15324193e-01f, -1.10039122e-01f, 5.42040281e-02f, -4.94999662e-02f, -1.83762591e-02f, 8.45194459e-02f, -9.45960283e-02f, 1.78446025e-02f, -1.77222248e-02f, -1.98503882e-02f,
  8.78941789e-02f, 7.99793750e-02f, 5.58732497e-03f, -5.44421002e-02f, 5.67625649e-02f, 1.24093927e-02f, 1.79328937e-02f, 3.17035019e-02f, 7.98529312e-02f, -2.00520214e-02f,
  5.08159101e-02f, -8.92102942e-02f, 2.51466352e-02f, -2.66484376e-02f, -7.31303170e-02f, 3.74683179e-02f, 1.70582149e-03f, 4.43009101e-02f, -9.11496058e-02f, -5.33408113e-02f,
  7.92782158e-02f, -7.01618707e-03f, 7.67253935e-02f, 9.29881930e-02f, 4.89884950e-02f, -6.65956968e-03f, 2.65006386e-02f, -2.52482928e-02f, -8.63126665e-02f, -2.00314429e-02f,
  9.19328853e-02f, 2.57926852e-01f, -6.40164083e-03f, 1.82762910e-02f, 2.71184854e-02f, -4.79691252e-02f, -7.22950101e-02f, -7.11233243e-02f, -1.20641394e-02f, 9.27804559e-02f,
  9.26906615e-02f, -1.38914557e-02f, 1.10551693e-01f, -2.27682851e-02f, -1.22018689e-02f, 9.67842340e-03f, 1.39144927e-01f, 5.70508316e-02f, 9.12119821e-02f, 4.42613065e-02f,
  1.47467300e-01f, 1.06964611e-01f, -2.52402127e-02f, 5.88862970e-02f, 9.60886665e-03f, 4.18286137e-02f, 1.23030186e-01f, 1.09855989e-02f, 5.34705147e-02f, 2.73635145e-02f,
  1.93798527e-01f, 2.33323529e-01f, 1.61376908e-01f, 1.42506287e-01f, -3.61433566e-01f, -3.78744572e-01f, -2.93504983e-01f, 1.22659259e-01f, -1.20230198e-01f, -3.79155539e-02f,
  -6.28529340e-02f, -6.94325101e-03f, 2.83390552e-01f, 9.49722081e-02f, 2.15832084e-01f, 1.92791283e-01f, 1.13849685e-01f, -9.14816111e-02f, 2.38706544e-01f, 2.17635602e-01f,
  2.91260302e-01f, 1.86489955e-01f, 3.40302736e-01f, 1.92201197e-01f, 1.19045049e-01f, 1.51993513e-01f, 2.68721431e-01f, 6.10802062e-02f, 9.67900828e-02f, -4.95348312e-02f,
  1.27259940e-01f, 1.30926594e-01f, 5.27238026e-02f, -7.18695223e-02f, 1.04195319e-01f, -2.33420152e-02f, -7.98319653e-02f, 3.56360115e-02f, -9.61122848e-03f, 1.46718919e-02f,
  -1.39807416e-02f, -4.28516306e-02f, 1.95202362e-02f, 2.39339843e-02f, -1.63519770e-01f, -4.35753949e-02f, 1.82910617e-02f, -1.11215793e-01f, 1.93569753e-02f, 2.01567262e-02f,
  -4.78893198e-04f, -4.62591536e-02f, -5.31284995e-02f, 6.13630675e-02f, 6.78849667e-02f, -3.47651504e-02f, -1.43816024e-02f, 7.56416172e-02f, 1.40571641e-02f, -8.07566047e-02f,
  6.38848096e-02f, -5.34964204e-02f, 4.99067344e-02f, -2.31422856e-02f, -2.18012556e-02f, 7.35983551e-02f, -7.50091597e-02f, -1.10880109e-02f, -6.74628764e-02f, 7.51738399e-02f,
  3.84719893e-02f, -3.46345045e-02f, 2.92981323e-02f, -4.44110446e-02f, -1.17624237e-03f, 1.52194183e-02f, 5.46695292e-02f, 1.71410199e-02f, -5.75698055e-02f, 7.14646187e-03f,
  -4.06948570e-03f, -4.70544435e-02f, 2.15789527e-02f, -2.65274644e-02f, -4.38594818e-02f, -6.45883977e-02f, 1.24267392e-01f, 5.56848245e-03f, 1.31290406e-01f, -3.21393646e-02f,
  9.22373682e-02f, 2.89885908e-01f, 9.61449444e-02f, -1.68546643e-02f, 1.10791713e-01f, 4.91000945e-03f, 4.01161164e-02f, 2.61466689e-02f, 7.76428804e-02f, 5.79940118e-02f,
  1.35955419e-02f, -9.44237411e-02f, 1.09179087e-01f, -7.61265531e-02f, -8.57385471e-02f, 1.82958931e-01f, 1.08301833e-01f, 1.40058734e-02f, 7.02142045e-02f, 1.20066017e-01f,
  6.89744502e-02f, -8.79938379e-02f, -3.15401778e-02f, -7.47465938e-02f, 5.97240357e-03f, -5.35152555e-02f, -1.03438057e-01f, -6.34060949e-02f, -7.85937384e-02f, 1.77880675e-02f,
  2.35723048e-01f, -5.58979034e-01f, -3.44317742e-02f, 3.09154809e-01f, 3.06889057e-01f, -5.68827800e-02f, -3.32137235e-02f, 7.30276406e-02f, 4.98693325e-02f, -3.91565859e-01f,
  1.50751593e-02f, -1.98746815e-01f, -2.29902998e-01f, 1.84405521e-01f, 2.46246770e-01f, -1.88592747e-01f, 1.93211868e-01f, -2.92920396e-02f, 1.60403118e-01f, 6.95132911e-02f,
  2.15365961e-01f, 2.33892009e-01f, 1.18555844e-01f, -2.30647735e-02f, 8.45346823e-02f, 4.40629162e-02f, 2.89713629e-02f, -1.32002681e-01f, 1.25756308e-01f, -4.43900973e-02f,
  5.86742675e-03f, -3.55564021e-02f, 4.35761223e-03f, -9.65514183e-02f, 1.90807842e-02f, -8.42460468e-02f, -5.53189889e-02f, -4.67816517e-02f, 1.98774323e-01f, 2.16299854e-02f,
  -7.38660470e-02f, 5.29881679e-02f, 3.43732424e-02f, 2.21702997e-02f, -2.89598189e-04f, 3.77096124e-02f, 1.08747549e-01f, -7.03465519e-03f, 8.16389471e-02f, 6.54318044e-03f,
  1.93961877e-02f, -1.85310710e-02f, 5.86847626e-02f, 2.14919690e-02f, 9.44354236e-02f, -2.82131918e-02f, -3.80518921e-02f, -6.08260743e-02f, -1.90547779e-02f, 1.69614349e-02f,
  -7.81780630e-02f, -2.12145392e-02f, -2.69029825e-03f, 7.20680803e-02f, 1.02758911e-02f, 1.04410551e-01f, 2.44281627e-02f, 5.21356240e-02f, -7.27367029e-02f, -1.69614144e-02f,
  1.40047492e-02f, -1.48478313e-03f, 5.07718287e-02f, -2.17738040e-02f, -3.29669118e-02f, 2.61027017e-03f, 6.84434175e-02f, 2.75841057e-02f, -4.92765233e-02f, 1.26041248e-01f,
  4.12385166e-02f, 7.06966743e-02f, -9.15482491e-02f, 8.25905427e-02f, 4.66267802e-02f, -6.75973371e-02f, 6.44157454e-03f, -9.95426551e-02f, 4.19819839e-02f, -3.39251198e-02f,
  -2.64616340e-01f, -3.76155466e-01f, -6.19655065e-02f, 7.90446252e-02f, -5.23336157e-02f, -7.67059848e-02f, 4.49654320e-03f, 2.22529639e-02f, -1.77398682e-01f, -5.23738423e-03f,
  -1.47259212e-03f, 1.37400195e-01f, -1.36883423e-01f, 7.06788823e-02f, 6.28163200e-03f, -3.09815723e-02f, -3.93645279e-02f, -1.13944836e-01f, -5.79748340e-02f, -8.07793289e-02f,
  -5.51095754e-02f, -3.54997814e-02f, 7.34130293e-02f, 7.09041357e-02f, 3.02857514e-02f, -2.72450950e-02f, -8.94693192e-03f, -8.68632644e-02f, 2.14395877e-02f, -5.37940823e-02f,
  1.00149512e-01f, 3.73139352e-01f, 2.78659284e-01f, 2.39676595e-01f, -6.32766038e-02f, -4.61770713e-01f, -3.28798741e-01f, 4.73641381e-02f, -6.55678734e-02f, 1.20169744e-01f,
  -1.71840727e-01f, 4.07502204e-01f, -6.99679777e-02f, -1.38150543e-01f, -3.30969840e-01f, -3.59225154e-01f, -1.49907932e-01f, -5.91686927e-02f, -8.29176512e-03f, 2.31757328e-01f,
  3.13434843e-03f, -1.81060523e-01f, 1.04001671e-01f, 3.67437713e-02f, 1.82381034e-01f, 3.67097735e-01f, 3.17018002e-01f, 1.05659656e-01f, 1.45738348e-01f, -1.45244911e-01f,
  -1.51584491e-01f, 1.87635310e-02f, 1.69764161e-01f, -8.53244588e-02f, 2.88895834e-02f, 1.29255252e-02f, 8.31144378e-02f, -6.70277551e-02f, 2.03737952e-02f, -1.11633763e-01f,
  3.32260281e-02f, 3.97017449e-02f, -6.10291921e-02f, -6.04393035e-02f, 4.02385518e-02f, -1.58346742e-02f, 1.04726464e-01f, 6.97195157e-02f, 7.40370713e-04f, 9.63474363e-02f,
  1.57896429e-01f, 5.68286218e-02f, 1.29653290e-01f, -2.26014964e-02f, 8.45890716e-02f, 3.12418230e-02f, -1.18001560e-02f, 3.22067924e-02f, 9.56627354e-02f, -4.11023200e-03f,
  -2.90871449e-02f, 2.73677446e-02f, -4.12740447e-02f, 1.14659980e-01f, -6.77733943e-02f, -6.39626756e-03f, -6.42957240e-02f, -1.22521371e-01f, 1.26103535e-02f, 6.91570714e-03f,
  -2.53252853e-02f, 1.56592354e-02f, -4.11725268e-02f, 3.94423008e-02f, 1.03292270e-02f, 1.08276069e-01f, 2.44743656e-02f, 2.47961264e-02f, -2.05138903e-02f, 7.40495399e-02f,
  3.58476751e-02f, -4.87639867e-02f, 3.66748013e-02f, -4.31412682e-02f, -1.31094918e-01f, 5.09176217e-02f, -2.82336753e-02f, -1.00197367e-01f, 5.23095615e-02f, -1.96350664e-02f,
  -4.11583371e-02f, 1.92442998e-01f, 7.71780089e-02f, -1.24932870e-01f, 2.60283612e-02f, 8.88138358e-03f, -2.84134857e-02f, -7.59936348e-02f, 1.87596120e-03f, -5.05977310e-02f,
  1.38117373e-01f, 4.44946140e-02f, 2.00495706e-03f, -7.06445500e-02f, -7.85524175e-02f, -1.12818303e-02f, 1.82919332e-03f, 1.06633596e-01f, 1.49703607e-01f, 6.61754310e-02f,
  1.31794170e-01f, 7.13981390e-02f, -1.50628597e-01f, -5.05457222e-02f, 1.22486772e-02f, 4.48273458e-02f, 5.22489510e-02f, 8.34776387e-02f, 5.56969345e-02f, 1.04538277e-02f,
  4.20754790e-01f, -1.64256454e-01f, -3.68207484e-01f, -1.43942922e-01f, -1.14603803e-01f, -1.68638512e-01f, -2.16629267e-01f, -1.15378611e-01f, -2.51195222e-01f, -1.72595218e-01f,
  7.84814879e-02f, 7.33073279e-02f, -2.56767571e-01f, 2.55774856e-01f, 4.61135656e-01f, -1.54250026e-01f, 1.12200268e-01f, 1.09217994e-01f, 2.97530256e-02f, 2.88892463e-02f,
  1.04475103e-01f, 3.01815867e-01f, 2.42093042e-01f, 3.14802736e-01f, 7.61594623e-02f, 3.96492593e-02f, 2.34652862e-01f, -2.40589585e-02f, 2.72631526e-01f, 2.03990862e-01f,
  -1.03347981e-02f, 5.15863448e-02f, -7.01717213e-02f, -9.03551280e-02f, -3.40368901e-03f, 9.89656616e-03f, -3.88967879e-02f, 2.17393011e-01f, 6.12838333e-03f, -6.24860190e-02f,
  -2.73665302e-02f, 1.76618546e-02f, -1.13352844e-02f, 1.06805779e-01f, -1.68494564e-02f, -3.41048390e-02f, -6.33332059e-02f, -1.16379276e-01f, -1.75692469e-01f, 1.04220770e-01f,
  -1.86208636e-01f, -7.60072842e-02f, -8.53693634e-02f, -5.23448028e-02f, -1.33966923e-01f, -5.01469150e-02f, -2.23287158e-02f, -9.96606648e-02f, -1.88953930e-03f, -5.61715430e-03f,
  6.05994910e-02f, 2.57646143e-02f, -8.80984291e-02f, 1.53401187e-02f, -2.71035712e-02f, -2.21272688e-02f, 2.31850129e-02f, -8.00448284e-02f, -1.16745085e-02f, 1.07190246e-02f,
  -2.03534946e-01f, -7.19811860e-03f, 6.31832033e-02f, -4.61702198e-02f, 7.79255778e-02f, 1.39992997e-01f, 1.02371322e-02f, -4.52995859e-02f, -1.94176719e-01f, -9.24576670e-02f,
  7.03694001e-02f, 2.17687599e-02f, -1.22108936e-01f, -7.47657940e-02f, 6.29659370e-02f, -3.96918580e-02f, 2.73997001e-02f, -5.34068383e-02f, 1.20848056e-03f, -6.22908175e-02f,
  7.70535991e-02f, -1.38002979e-02f, -6.38525933e-02f, 6.86689392e-02f, -1.36374384e-01f, 3.40943336e-02f, -1.69705749e-02f, -5.46465516e-02f, 2.17172727e-02f, -1.37120616e-02f,
  1.83749311e-02f, -4.81211767e-02f, -1.61979515e-02f, -8.52577835e-02f, -5.62242083e-02f, -1.86010962e-04f, 3.04039232e-02f, 8.03977996e-03f, -1.07789494e-01f, 1.16583295e-01f,
  -5.88007011e-02f, -7.81728849e-02f, -3.48115116e-02f, -2.14895621e-01f, -4.59872298e-02f, -9.61700529e-02f, 2.35940944e-02f, 4.04226594e-02f, 1.82417538e-02f, -6.29693344e-02f,
  5.69240868e-01f, -2.20196486e-01f, -1.62908897e-01f, 2.44993582e-01f, 3.74793679e-01f, 3.54114860e-01f, 3.84789824e-01f, 2.30046034e-01f, 4.52805132e-01f, -7.65076652e-02f,
  6.78702518e-02f, -1.54928073e-01f, -1.59003705e-01f, 2.04002380e-01f, 2.30397910e-01f, -5.48078790e-02f, 3.24988812e-01f, 4.02834713e-02f, 1.96796775e-01f, 9.87711251e-02f,
  2.88914680e-01f, 2.01810420e-01f, -2.90841043e-01f, -3.71469110e-02f, 1.30243436e-01f, -1.94149226e-01f, -3.56051862e-01f, -1.23114988e-01f, -1.76658213e-01f, 6.15353547e-02f,
  1.25389427e-01f, 1.87754229e-01f, -3.56262028e-02f, -1.10368744e-01f, -1.15595956e-03f, 8.69416818e-03f, -7.02454597e-02f, -5.44001572e-02f, 8.66037905e-02f, 8.87542590e-03f,
  1.71570629e-02f, 3.83024476e-02f, 6.76265508e-02f, -5.01977615e-02f, 3.34557146e-02f, 2.23397706e-02f, 1.42294634e-02f, 2.05437606e-03f, -1.16908118e-01f, -3.13906036e-02f,
  -1.50546115e-02f, -1.22559607e-01f, -2.84266518e-03f, -1.41590178e-01f, -1.05160691e-01f, -3.66100366e-03f, -4.68587726e-02f, -5.13262264e-02f, -6.36342764e-02f, 7.54761547e-02f,
  -2.73792800e-02f, 1.81599874e-02f, -1.54637462e-02f, 1.06726671e-02f, -6.21508807e-03f, -1.72630828e-02f, 6.86489046e-02f, -1.86907593e-02f, 5.91257736e-02f, -4.55720015e-02f,
  5.19333147e-02f, 7.16258436e-02f, 8.59674215e-02f, 3.02707832e-02f, 5.29301018e-02f, 5.88738844e-02f, -8.41928553e-03f, 1.24600073e-02f, 6.40699193e-02f, 1.35218296e-02f,
  3.43107469e-02f, -1.26716692e-03f, -8.05648267e-02f, -7.01590031e-02f, 4.32920679e-02f, -6.20403364e-02f, 5.04741929e-02f, -3.54006849e-02f, 1.06459953e-01f, 2.51046917e-03f,
  7.53776580e-02f, 7.70900538e-03f, 4.75982167e-02f, 1.23521201e-02f, -6.61553442e-02f, 2.53755618e-02f, 5.16131818e-02f, 9.38453227e-02f, -2.69732866e-02f, 3.58617455e-02f,
  -5.56878000e-03f, -4.16460223e-02f, 5.65841645e-02f, -7.69115314e-02f, -4.23994847e-02f, -1.77976377e-02f, -4.46368344e-02f, 5.29702827e-02f, 4.32530455e-02f, -1.05505325e-01f,
  -8.51654708e-02f, 9.29043964e-02f, -2.64123436e-02f, 2.08273884e-02f, 9.73569378e-02f, -6.11635000e-02f, 5.61634935e-02f, -2.89197788e-02f, -1.28940210e-01f, 2.76968274e-02f,
  1.28038703e-02f, 3.72010693e-02f, -1.65479198e-01f, -2.68615186e-01f, -2.37010762e-01f, 3.22348088e-01f, -7.71223307e-02f, 2.16574401e-01f, 5.22886515e-02f, 9.83366594e-02f,
  -1.94164231e-01f, 1.81333497e-01f, 3.26796733e-02f, -2.92717189e-01f, 4.12527360e-02f, 2.26631060e-01f, -1.59615457e-01f, -5.28132915e-02f, -6.29326552e-02f, 1.08023677e-02f,
  -2.10522130e-01f, -1.99313045e-01f, -2.90783048e-01f, -1.86865956e-01f, -4.01964515e-01f, -6.99358210e-02f, -2.43538454e-01f, -2.49156460e-01f, -1.22600786e-01f, -1.00856058e-01f,
  7.05284327e-02f, 4.72699143e-02f, 5.37254624e-02f, 1.32937536e-01f, 6.09454848e-02f, -2.77216267e-02f, 7.85942301e-02f, 1.29063940e-02f, 3.11023239e-02f, 4.60060835e-02f,
  4.45365869e-02f, 3.87114882e-02f, 6.05921261e-02f, -2.15344783e-03f, 4.06584032e-02f, -1.93920527e-02f, -6.74362630e-02f, -1.56463578e-01f, 2.11466607e-02f, -7.11510330e-02f,
  -1.97823614e-01f, 2.44731121e-02f, -6.82019368e-02f, 9.09328386e-02f, -1.91105083e-02f, -3.06573487e-03f, 1.09879389e-01f, -6.20729215e-02f, 3.61458734e-02f, 7.70409182e-02f,
  6.22157240e-03f, 1.43251285e-01f, -3.79286660e-03f, -1.04407839e-01f, -2.07967535e-02f, -1.14317626e-01f, -1.38715163e-01f, -6.74575195e-03f, -8.10915381e-02f, -6.92367554e-02f,
  -6.58984855e-02f, -7.29429349e-02f, 6.03107177e-02f, -4.36287150e-02f, -1.43501252e-01f, 6.93541169e-02f, -7.42252320e-02f, -5.13227796e-03f, -1.19323276e-01f, 2.19441317e-02f,
  3.55035216e-02f, 1.50646463e-01f, 2.33164970e-02f, -1.12924211e-01f, -5.49225956e-02f, 6.75243363e-02f, 4.96396348e-02f, -1.54440859e-02f, 1.45301251e-02f, -2.23787516e-01f,
  7.61735812e-02f, 2.72118926e-01f, 1.04942165e-01f, 9.81215760e-02f, 1.49907306e-01f, 1.38065055e-01f, 9.65566412e-02f, 1.27744034e-01f, 1.48788959e-01f, -3.64296585e-02f,
  -1.13818526e-01f, 1.45059481e-01f, 1.56664938e-01f, -3.91086228e-02f, -3.52713726e-02f, 1.19656004e-01f, 1.23737819e-01f, 5.50056621e-02f, -1.78502519e-02f, 2.41289213e-02f,
  -1.02834135e-01f, 1.30509764e-01f, 5.56409247e-02f, 8.15091431e-02f, -2.73988452e-02f, -2.02504154e-02f, 1.05331033e-01f, 1.83742568e-02f, -6.73290994e-03f, -4.13934104e-02f,
  -6.17024302e-01f, 1.43367395e-01f, -3.62429440e-01f, 3.58647928e-02f, -2.03639716e-01f, 3.12530071e-01f, 1.75069973e-01f, -9.18163657e-02f, -2.04809859e-01f, 3.92114997e-01f,
  3.31144303e-01f, -2.90738523e-01f, 1.49558514e-01f, 4.26510811e-01f, -1.74539506e-01f, 4.21902865e-01f, 2.92970240e-01f, 1.31194755e-01f, -1.15850128e-01f, -1.40703842e-01f,
  -2.79758889e-02f, 2.72830158e-01f, 2.70337999e-01f, -9.14169028e-02f, 6.08623214e-02f, -2.62863398e-01f, 1.65233865e-01f, -2.92560637e-01f, 1.76617265e-01f, -4.46435856e-03f,
  2.62826383e-02f, -3.08388561e-01f, -8.07101000e-03f, -1.45723537e-01f, -7.04387575e-02f, -6.20414168e-02f, -6.09459169e-02f, -1.00749964e-02f, -1.29573166e-01f, -7.72047043e-02f,
  -1.61053061e-01f, -1.48686379e-01f, 2.62462981e-02f, -4.13003266e-02f, -1.17890798e-01f, -2.49996781e-02f, 3.71010043e-02f, 1.34657800e-01f, -4.13586460e-02f, -2.40401179e-02f,
  2.19620038e-02f, 4.30143140e-02f, 4.40006666e-02f, 6.17376603e-02f, -1.50434431e-02f, 4.96986397e-02f, -1.53609915e-02f, -2.86081955e-02f, 5.32670058e-02f, 4.78433957e-03f,
  -5.08155636e-02f, -2.99207792e-02f, 5.32765388e-02f, 3.96172404e-02f, -3.39845158e-02f, 1.01287290e-01f, 1.67049151e-02f, 3.52597572e-02f, -1.20945489e-02f, -3.04787699e-02f,
  1.94626953e-02f, -4.82276268e-02f, 9.87846497e-03f, 8.91684368e-02f, 5.70434406e-02f, 1.47372195e-02f, -7.32346028e-02f, -1.01757543e-02f, 1.63161140e-02f, 2.34509744e-02f,
  6.42735809e-02f, -3.18532214e-02f, 7.82528520e-02f, 8.27792734e-02f, -3.44670750e-02f, 6.54970035e-02f, 5.38195036e-02f, 1.17803235e-02f, 6.14163429e-02f, -6.45858422e-02f,
  -6.41191155e-02f, -3.32185656e-01f, -3.94943496e-03f, -2.94603463e-02f, -4.06919904e-02f, 6.34866953e-02f, -6.85449839e-02f, -6.57081380e-02f, -1.39589747e-02f, -9.72715244e-02f,
  -5.99205308e-02f, -1.11688944e-02f, -3.74048837e-02f, -2.75562517e-02f, -3.20100710e-02f, 9.13227275e-02f, -7.38960057e-02f, -1.21996276e-01f, -7.19508082e-02f, -1.49763167e-01f,
  -4.62922230e-02f, -1.03024468e-01f, -2.97925770e-02f, 2.37955451e-02f, 4.73340899e-02f, 4.99544479e-02f, -1.16939187e-01f, -1.40057310e-01f, -1.66056547e-02f, -3.26662995e-02f,
  1.48460373e-01f, -3.44308048e-01f, 9.89764482e-02f, 2.77164072e-01f, -1.37143889e-02f, -5.00687137e-02f, 2.06600115e-01f, -9.50377733e-02f, -2.82398760e-01f, -1.80460811e-01f,
  2.59747058e-01f, 2.37216115e-01f, -3.59829259e-03f, 1.48943514e-01f, 3.98945928e-01f, -3.49060409e-02f, 7.13373274e-02f, 7.67896175e-02f, -9.98865515e-02f, -1.37416581e-02f,
  8.04204494e-02f, 1.15473874e-01f, 3.20563227e-01f, 4.17002738e-02f, 2.37400502e-01f, 7.27047771e-02f, 2.75878847e-01f, 1.57737941e-01f, 1.72296762e-01f, 3.16568494e-01f,
  9.32618454e-02f, -1.04943112e-01f, 1.48998089e-02f, 3.87430638e-02f, -8.75398368e-02f, -6.77128509e-03f, 5.93331717e-02f, 1.88151330e-01f, 5.79981878e-02f, 2.53233146e-02f,
  -4.96216565e-02f, 8.36756006e-02f, -1.18384346e-01f, 1.02905013e-01f, -7.37279877e-02f, -8.93913433e-02f, -3.79889980e-02f, -5.36215305e-02f, -6.60307780e-02f, -6.86861202e-03f,
  -4.31521162e-02f, -1.03335902e-01f, 3.63342166e-02f, 1.39209703e-02f, -3.33654024e-02f, 5.23651484e-03f, -1.37301147e-01f, -6.92765266e-02f, -3.37400325e-02f, -6.39310479e-02f,
  3.03958356e-02f, -1.43704012e-01f, -4.53606173e-02f, 6.57282695e-02f, 9.40821599e-03f, 3.09039466e-02f, 9.40625730e-04f, 3.61053087e-02f, 8.65518674e-02f, 2.36958265e-02f,
  3.34610566e-02f, 6.66679591e-02f, 2.17922106e-02f, -5.17615341e-02f, -4.74963635e-02f, -1.48969352e-01f, 6.44497648e-02f, 6.68744072e-02f, -1.01223297e-01f, -3.84378731e-02f,
  3.20303515e-02f, 8.82721320e-02f, 1.55998347e-02f, 1.46295913e-02f, -1.65603254e-02f, -1.74596850e-02f, 1.11650524e-03f, 7.81672373e-02f, -1.05654605e-01f, 1.11732572e-01f,
  6.54849177e-03f, -4.82595749e-02f, -2.89775562e-02f, -5.58160953e-02f, -1.84766613e-02f, -7.99438879e-02f, -1.98305398e-02f, 1.98947750e-02f, 1.21993296e-01f, -1.32620465e-02f,
  -7.93096498e-02f, 2.43267976e-02f, -4.16131131e-02f, 1.19975600e-02f, 1.07875019e-01f, -9.00644809e-02f, 8.09494313e-03f, 4.87763323e-02f, 3.30285057e-02f, -7.47909173e-02f,
  3.80824246e-02f, -1.69170350e-02f, 2.30304766e-02f, -2.75330711e-02f, -1.80416387e-02f, 6.36620894e-02f, 1.99806574e-03f, -4.17436510e-02f, 4.69086692e-02f, 7.78260827e-02f,
  -2.23411605e-01f, 8.80363658e-02f, -2.53024787e-01f, -3.53726983e-01f, -1.72785334e-02f, -2.85285473e-01f, -3.48409355e-01f, -4.97977287e-02f, 8.67005065e-02f, 6.45039380e-02f,
  -8.68207496e-03f, -8.07826407e-03f, 2.86770314e-01f, -1.13710567e-01f, -1.61390752e-02f, 2.49346465e-01f, -1.94975674e-01f, -9.77622643e-02f, 3.53119671e-02f, -2.08012328e-01f,
  -7.86026567e-02f, -1.85855327e-03f, -1.41435429e-01f, 5.71068190e-02f, -1.69137865e-01f, -1.26940072e-01f, -4.30208333e-02f, 4.85265814e-02f, -1.87500998e-01f, 1.57836065e-01f,
  -3.90393198e-01f, -3.23864549e-01f, -2.84822285e-01f, -2.37329870e-01f, -1.82253957e-01f, 1.18090659e-02f, -1.57828674e-01f, 3.28108594e-02f, -3.53663266e-02f, -9.82026607e-02f,
  -2.35000346e-02f, -2.86739301e-02f, -7.90681168e-02f, 8.70331600e-02f, -2.46130973e-02f, -1.09696342e-02f, 1.70978568e-02f, -1.09461665e-01f, -2.99457810e-03f, 6.16189502e-02f,
  -2.19581574e-02f, -3.44850421e-02f, -2.68194228e-01f, 4.53354837e-03f, 2.61350740e-02f, -8.61218795e-02f, -5.13901524e-02f, -2.61184275e-02f, -1.65966138e-01f, -8.10405836e-02f,
  1.65082544e-01f, 5.45127578e-02f, -4.25120778e-02f, 4.39602584e-02f, 5.62077761e-02f, 1.40798846e-02f, -1.79689005e-02f, 1.70913246e-02f, -6.57491386e-02f, -1.43301627e-02f,
  -8.18596873e-03f, 3.00324932e-02f, -7.18572959e-02f, -1.51341960e-01f, 6.06233031e-02f, 1.94010641e-02f, 7.55837467e-03f, -7.17145056e-02f, 1.63712967e-02f, -9.07373149e-04f,
  -1.01687431e-01f, -5.66674955e-02f, -6.06438853e-02f, -7.49347657e-02f, -1.05625920e-01f, 5.24783097e-02f, -5.37908450e-02f, 1.10740010e-02f, -3.86511795e-02f, -5.14361374e-02f,
  -4.20152634e-01f, -4.49162066e-01f, -2.79555051e-03f, -1.45041734e-01f, -2.74902297e-04f, -6.51287064e-02f, 2.69457996e-02f, 5.68715334e-02f, -1.07636444e-01f, -9.20067653e-02f,
  -4.80755381e-02f, -1.43149290e-02f, 2.19876077e-02f, 1.91115122e-02f, 4.30976711e-02f, -5.62901795e-02f, -6.13427013e-02f, 2.80994512e-02f, -1.55979261e-01f, 1.32154091e-03f,
  1.78069174e-02f, 1.20022252e-01f, 9.93669182e-02f, -7.00314119e-02f, -9.48688164e-02f, -8.05073157e-02f, 6.36315718e-02f, 6.42725686e-03f, -4.52889092e-02f, 4.02036831e-02f,
  2.31558129e-01f, 4.34764683e-01f, 8.79990309e-02f, 1.88895136e-01f, -2.05243871e-01f, -3.07847351e-01f, -2.25597471e-01f, -7.31616393e-02f, 1.48541003e-01f, 2.02275813e-01f,
  -1.94640279e-01f, 5.76162934e-01f, -2.76933108e-02f, -2.91467179e-02f, -4.31694210e-01f, -2.63794690e-01f, -2.06989735e-01f, 2.60080602e-02f, -3.79901081e-02f, -6.38457434e-03f,
  -2.30738029e-01f, -3.03449214e-01f, -2.21393123e-01f, -9.38543603e-02f, -4.16824780e-02f, 1.99891955e-01f, -3.32779825e-01f, -9.82103944e-02f, 8.82971659e-02f, -6.54150099e-02f,
  -2.93375440e-02f, 2.56455153e-01f, 2.03995615e-01f, 5.33384643e-02f, -2.46883616e-01f, 1.65899366e-03f, -5.32192830e-03f, 3.79100554e-02f, -5.74673042e-02f, 9.09151658e-02f,
  1.75169528e-01f, 8.02605972e-03f, 1.06818616e-01f, 8.79396051e-02f, 8.10856745e-02f, 1.53026983e-01f, 6.92791119e-02f, -2.17955671e-02f, 9.78421047e-02f, 1.13692179e-01f,
  1.01561233e-01f, 7.42573738e-02f, 3.90984043e-02f, -9.82621219e-03f, -4.02970314e-02f, 3.60892713e-02f, -4.84360717e-02f, 2.25825701e-03f, 9.45208687e-03f, 3.96709777e-02f,
  -4.35775742e-02f, -1.64038748e-01f, -5.63167557e-02f, 4.83844914e-02f, -7.86250830e-03f, -6.24100901e-02f, 6.30386397e-02f, -6.67593405e-02f, -3.06015313e-02f, -8.89501274e-02f,
  -2.57336292e-02f, 9.48667675e-02f, -1.28638986e-02f, -5.64977378e-02f, -8.41234326e-02f, 1.01642303e-01f, -6.72973841e-02f, 5.53705133e-02f, -2.51751356e-02f, -1.08635485e-01f,
  5.62344044e-02f, -8.64325985e-02f, 1.17874309e-01f, -3.83800231e-02f, 6.16163015e-02f, 1.07646259e-02f, 1.16339736e-01f, 1.30473107e-01f, -1.58416964e-02f, -1.39371485e-01f,
  -2.08490759e-01f, -1.74014598e-01f, -9.66706686e-03f, 2.01918721e-01f, -8.25836230e-03f, 3.65325846e-02f, -7.96974152e-02f, 7.45132864e-02f, -2.01506466e-01f, -3.29838730e-02f,
  -7.96185583e-02f, -3.34526077e-02f, -3.48234065e-02f, -1.44987768e-02f, -2.38644369e-02f, -2.58592013e-02f, -5.86225241e-02f, -2.56773103e-02f, -2.55038403e-02f, -3.87458391e-02f,
  6.73552603e-03f, -8.38009566e-02f, 4.43065390e-02f, -5.19930720e-02f, 1.85957029e-02f, 2.70534977e-02f, 6.89530671e-02f, 5.78805357e-02f, -9.39241722e-02f, -7.57970586e-02f,
  -2.10102886e-01f, -2.52504721e-02f, -3.10300719e-02f, 5.99929430e-02f, 2.98551708e-01f, -1.66675195e-01f, 4.62225638e-02f, 3.42207074e-01f, 3.66754651e-01f, 5.51753398e-03f,
  1.57621682e-01f, -2.07277074e-01f, 1.84468135e-01f, -8.63004550e-02f, -2.60951906e-01f, -7.23423138e-02f, -2.86786556e-01f, -1.85489193e-01f, 1.10298574e-01f, -9.29320976e-02f,
  4.87595275e-02f, -4.07416709e-02f, -1.25322253e-01f, 1.78437427e-01f, 1.71005782e-02f, 5.03231259e-03f, -2.82027960e-01f, 6.71670437e-02f, -2.78943807e-01f, -9.72480178e-02f,
  -1.14868231e-01f, 2.24807605e-01f, -2.17630658e-02f, 4.35466804e-02f, -6.26884922e-02f, -2.27273870e-02f, -1.99926034e-01f, 1.60531644e-02f, 4.91773933e-02f, 5.58752306e-02f,
  -1.73520539e-02f, 2.56939959e-02f, 6.50981292e-02f, 2.19972610e-01f, 1.40692323e-01f, 3.23247872e-02f, -7.41612539e-02f, -9.63449776e-02f, 1.78287514e-02f, -2.27626059e-02f,
  -4.61002365e-02f, 5.56933656e-02f, -5.30638583e-02f, -1.35113597e-01f, -9.48608443e-02f, 7.48162344e-02f, -1.41967937e-01f, -1.65412545e-01f, -1.86279174e-02f, -5.48895486e-02f,
  5.84965944e-02f, 7.69400550e-03f, 1.08499741e-02f, 1.78193763e-01f, 1.71352420e-02f, 1.17350236e-01f, -3.21010016e-02f, -1.87876690e-02f, 2.23120442e-03f, 5.38462121e-03f,
  -1.31352199e-02f, -3.01327780e-02f, 1.59724623e-01f, -4.13574353e-02f, 1.64027009e-02f, 3.95645313e-02f, -1.78217515e-01f, 7.98681825e-02f, 2.55052634e-02f, -1.07983612e-01f,
  9.78832319e-02f, -6.92151040e-02f, 3.92517596e-02f, -5.44737047e-03f, 2.99170315e-02f, 2.16464419e-02f, 3.98370400e-02f, -2.44344887e-03f, -3.96928526e-02f, -6.63518831e-02f,
  -2.29742050e-01f, -9.14452225e-02f, 3.28364633e-02f, 4.33967188e-02f, -1.05771191e-01f, -2.41968166e-02f, -1.32123694e-01f, -3.27961077e-03f, -5.00640832e-02f, 3.59868258e-02f,
  -8.60924497e-02f, 5.48739694e-02f, -1.81309924e-01f, 6.81160018e-02f, -3.43517028e-02f, -2.61286768e-04f, -6.36879578e-02f, -8.05470198e-02f, -1.51272237e-01f, -4.54271287e-02f,
  -8.42229575e-02f, 8.02627858e-03f, 3.99674438e-02f, -2.73148119e-02f, -1.59007739e-02f, 1.88177936e-02f, -3.00645828e-02f, -3.77227589e-02f, -1.07135147e-01f, -2.79082134e-02f,
  2.35627025e-01f, -3.24037254e-01f, -2.67259985e-01f, -1.19618364e-01f, -1.45574078e-01f, -3.13305229e-01f, -2.61534750e-01f, -3.40152889e-01f, -4.04154621e-02f, -1.75220028e-01f,
  -1.17160432e-01f, 9.45963115e-02f, 2.45601639e-01f, -3.54090422e-01f, 4.47940320e-01f, 2.45857850e-01f, -2.89577574e-01f, -1.32762969e-01f, -3.64567749e-02f, -2.14025214e-01f,
  2.88465843e-02f, -2.25383773e-01f, 2.07798015e-02f, -3.31073195e-01f, -2.35238791e-01f, -2.06186563e-01f, 1.31643817e-01f, -2.38872021e-01f, -3.29286188e-01f, -1.60061672e-01f,
  -1.62845075e-01f, -4.80103232e-02f, -1.12795336e-02f, 1.55485524e-02f, -7.41849989e-02f, -2.46943459e-02f, -2.77260616e-02f, 8.38832781e-02f, 3.60009968e-02f, 1.29848659e-01f,
  4.70602401e-02f, 3.77545953e-02f, -4.92424369e-02f, 1.53819069e-01f, -1.08914517e-01f, -1.17681645e-01f, 1.83072835e-02f, -5.09895645e-02f, -6.54166713e-02f, -7.32203051e-02f,
  -3.74595486e-02f, -6.76611513e-02f, -1.59699433e-02f, 6.70764670e-02f, 3.11342478e-02f, -7.88479522e-02f, 2.38070972e-02f, 6.94211945e-02f, 5.27518392e-02f, 3.62604856e-02f,
  -7.14652240e-02f, 7.83534627e-03f, -2.95349639e-02f, -5.52673936e-02f, -8.28336403e-02f, -4.32954729e-02f, -2.83024460e-02f, 1.58267450e-02f, -5.41431177e-03f, -2.27905456e-02f,
  -2.51775645e-02f, -2.31230799e-02f, -3.91891338e-02f, 6.47198185e-02f, -8.16419125e-02f, -3.78482938e-02f, 6.18772209e-02f, 4.42026258e-02f, -4.64850143e-02f, -7.02559203e-03f,
  5.75863458e-02f, -3.31920981e-02f, 9.16987583e-02f, 5.90595156e-02f, -9.18992162e-02f, 4.42312993e-02f, -2.59274766e-02f, 4.04629149e-02f, -1.67522691e-02f, 7.60619715e-02f,
  -1.34725720e-01f, 3.99869382e-02f, -8.31383746e-03f, 5.19571528e-02f, 3.19747371e-03f, 8.59927759e-03f, -1.20435685e-01f, -9.28754881e-02f, -1.04496498e-02f, -5.72986379e-02f,
  -6.39628917e-02f, 8.33608583e-02f, -5.43265678e-02f, -1.03581339e-01f, 6.01541959e-02f, -6.55149594e-02f, -5.04000336e-02f, 1.87543295e-02f, 1.93259604e-02f, 3.92530300e-03f,
  6.16401434e-02f, 7.13632479e-02f, 1.33216143e-01f, -5.86040802e-02f, 7.42168054e-02f, 5.76619208e-02f, -3.92306559e-02f, -3.08295246e-02f, 8.26836675e-02f, -3.85188311e-02f,
  -2.53976565e-02f, -3.16644073e-01f, -5.13658524e-01f, -2.12267995e-01f, 2.04178095e-01f, 2.07473278e-01f, -1.99123502e-01f, 1.11338809e-01f, -2.98448920e-01f, -3.11948229e-02f,
  1.40705451e-01f, -2.17206955e-01f, -4.19139057e-01f, -5.64833209e-02f, 5.41043431e-02f, -3.32792372e-01f, 1.59291700e-01f, 7.86655620e-02f, -2.14051679e-01f, 1.34112328e-01f,
  -1.53389554e-02f, 2.01585874e-01f, -5.35384715e-02f, 3.64369869e-01f, 1.00997217e-01f, 1.10503100e-01f, 2.71356434e-01f, 2.48409007e-02f, 3.91344279e-01f, 1.13105014e-01f,
  -7.27961585e-02f, -1.18533097e-01f, -6.97879195e-02f, -9.00288485e-03f, 1.00134060e-01f, 1.56978235e-01f, 1.02557689e-01f, 2.45952774e-02f, -6.53371066e-02f, -1.43631786e-01f,
  2.09918572e-03f, -4.77901399e-02f, 2.79076640e-02f, 3.17374021e-02f, -1.13332421e-02f, 2.41659977e-03f, -1.22827299e-01f, -4.72339019e-02f, -1.50731802e-01f, -9.43869352e-02f,
  -1.16989970e-01f, -2.84108017e-02f, -6.03029914e-02f, 7.18769953e-02f, -1.20200507e-01f, 2.02381518e-02f, 3.86822745e-02f, 8.83108601e-02f, -3.19424309e-02f, 1.04936525e-01f,
  3.27265225e-02f, 6.86980933e-02f, -1.72386505e-02f, -5.96984923e-02f, -2.87481919e-02f, -1.02181666e-01f, -5.26366755e-02f, -4.89753000e-02f, -5.57792932e-02f, -5.54788709e-02f,
  3.30476314e-02f, -1.68969054e-02f, -3.84515934e-02f, 4.01850268e-02f, 1.14668243e-01f, -5.08432984e-02f, 2.60899160e-02f, 5.47994934e-02f, 2.69180033e-02f, -6.94810376e-02f,
  -9.40119028e-02f, 7.95333609e-02f, 4.40028049e-02f, 2.36238055e-02f, -2.10888032e-02f, 8.22464377e-02f, 8.15242007e-02f, -4.62339371e-02f, 1.14723310e-01f, 5.86899482e-02f,
  1.36018783e-01f, 1.33669823e-01f, -4.58369777e-02f, 4.03349735e-02f, -4.62583415e-02f, 5.39898910e-02f, -6.19141124e-02f, -3.10890842e-02f, 7.12333098e-02f, 2.32026465e-02f,
  1.65858909e-01f, 4.90519628e-02f, 7.72730783e-02f, 3.73421796e-02f, 6.52685985e-02f, 1.94612190e-01f, 4.48649488e-02f, 1.07011579e-01f, 7.85477459e-02f, 7.60881454e-02f,
  1.23298116e-01f, 3.57731134e-02f, 4.79598269e-02f, 1.97372437e-02f, 1.06312215e-01f, 6.61474690e-02f, 1.66286692e-01f, 2.33317986e-02f, -4.65364754e-02f, -9.08935890e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  9.49159637e-02f, 7.37037882e-02f, 1.95302755e-01f, 2.89503515e-01f, 2.79603362e-01f, 2.42420763e-01f, 2.39467055e-01f, 1.12892479e-01f, 1.28246337e-01f, 2.25889027e-01f,
  3.20609838e-01f, 1.69289142e-01f, 5.16530462e-02f, 2.28777245e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.29430366e-02f, 1.20074712e-01f, -1.72876716e-01f, 6.99602859e-03f, -1.82604808e-02f, -1.40728250e-01f, -4.65900823e-02f, 1.70302063e-01f, -1.02399439e-02f, 1.97204918e-01f,
  -2.41894603e-01f, 1.24490328e-01f, 2.43219167e-01f, -1.74367383e-01f, 9.66406092e-02f, -4.66336906e-02f, 9.80229378e-02f, 1.18735321e-01f, -6.10240623e-02f, 1.30524874e-01f,
  -3.01114798e-01f, -4.92294095e-02f, -1.01106741e-01f, 3.84625904e-02f, -6.24178760e-02f, -1.20732188e-01f, 3.53047475e-02f, -2.46325165e-01f, -1.76343799e-01f, -1.37032634e-02f,
  -8.21757540e-02f, -2.37432867e-01f, -7.77619556e-02f, -1.33704156e-01f, 7.30586424e-02f, -1.86720937e-01f, -3.29999864e-01f, -1.87693179e-01f, -3.05149108e-01f, 7.58633688e-02f,
  -1.06932685e-01f, 3.39714676e-01f, -5.78931123e-02f, -1.18221238e-01f, -1.18986957e-01f, 1.36907637e-01f, 2.37635538e-01f, 1.32909715e-01f, -2.99079623e-02f, 1.64999232e-01f,
  -2.42888570e-01f, 2.17215389e-01f, -1.43188179e-01f, -7.45703280e-02f, -1.11943223e-01f, 2.12663308e-01f, 1.97281409e-03f, 1.57740533e-01f, -6.58706874e-02f, -1.86895132e-01f,
  -9.84123498e-02f, 2.15697698e-02f, -1.01654932e-01f, 2.05935445e-02f, -1.25663579e-01f, 5.89511730e-02f, -2.07323916e-02f, 8.09321478e-02f, -1.34352073e-02f, -7.05145895e-02f,
  1.44962698e-01f, -1.74412951e-02f, -1.69897750e-01f, -7.39851519e-02f, 3.24375816e-02f, -1.79292560e-02f, -1.70918882e-01f, 8.81564617e-02f, 6.04638010e-02f, 1.18288755e-01f,
  -6.79679215e-02f, 1.88242927e-01f, 2.66396552e-02f, 1.72696084e-01f, -2.99634468e-02f, 2.19599735e-02f, -5.89253055e-03f, -6.36683172e-03f, -7.60789812e-02f, -7.35853612e-02f,
  -2.73948848e-01f, 3.10952157e-01f, -3.36087555e-01f, 3.03910617e-02f, -3.78011167e-02f, -3.34426686e-02f, 5.54792695e-02f, 2.94701397e-01f, 1.63977414e-01f, -1.06573202e-01f,
  -1.16885155e-01f, 5.89493848e-03f, -6.76139891e-02f, 1.54888108e-01f, 6.38652071e-02f, -1.38019904e-01f, -1.09121963e-01f, 9.16188508e-02f, 1.34936450e-02f, 4.42997701e-02f,
  1.47800505e-01f, 7.98106417e-02f, 3.40802878e-01f, -2.17254579e-01f, 1.07857212e-01f, -1.84587538e-01f, -1.95335329e-01f, 1.09876193e-01f, -2.58757442e-01f, -3.33582699e-01f,
  -5.33129126e-02f, 2.83061057e-01f, -6.09386861e-02f, -6.58731014e-02f, 1.82875454e-01f, 6.57052696e-02f, -1.61658227e-01f, -1.44184366e-01f, -2.18227529e-03f, 7.98922926e-02f,
  -2.16113217e-02f, 8.79120734e-03f, 3.70082147e-02f, 6.13412354e-03f, -5.31426035e-02f, -1.73571631e-01f, 4.87987837e-03f, -9.69135016e-02f, 1.25195980e-01f, -7.73659945e-02f,
  -4.89109494e-02f, -9.63277146e-02f, -3.58237848e-02f, -4.75620776e-02f, -1.14779554e-01f, -7.42297247e-02f, -1.30295336e-01f, 8.52328539e-02f, 5.65565825e-02f, 5.13497973e-03f,
  -7.81779736e-02f, 1.16304882e-01f, -7.27690384e-02f, 1.06096625e-01f, 2.46536329e-01f, 3.16096067e-01f, 1.79872110e-01f, -3.74157019e-02f, -2.28380889e-01f, 1.41141832e-01f,
  8.55466409e-04f, 1.91005751e-01f, -2.39209607e-01f, 5.61558716e-02f, -1.26304507e-01f, -1.94011927e-01f, 3.96831095e-01f, -9.29235220e-02f, -1.22182675e-01f, -3.34885329e-01f,
  -1.41457826e-01f, 1.65814787e-01f, -1.15198670e-02f, -1.44116998e-01f, 1.76961958e-01f, -4.51318808e-02f, 1.82843804e-01f, -1.23605095e-01f, 1.00350022e-01f, 1.11982003e-01f,
  1.56905875e-01f, 1.19576760e-01f, -3.23165767e-02f, -1.80010647e-01f, -1.30649909e-01f, -8.39340687e-03f, 2.41765827e-01f, -2.19038486e-01f, -1.82684854e-01f, -2.96028852e-01f,
  -1.54919595e-01f, 9.90960747e-02f, 1.79300911e-03f, -5.75193018e-03f, 4.68362309e-02f, -3.00588440e-02f, -2.95974594e-03f, -9.12019163e-02f, -2.07939669e-01f, 2.20609248e-01f,
  1.07672952e-01f, -1.02790713e-01f, -2.08424404e-01f, -8.58404636e-02f, 4.23321966e-03f, -1.45264894e-01f, -1.02861077e-01f, -1.45346597e-01f, -5.56740277e-02f, 2.74382364e-02f,
  -3.85443517e-03f, 7.07407147e-02f, 9.15878415e-02f, 2.55208760e-02f, 4.09719385e-02f, -8.12050537e-04f, 4.16010655e-02f, -2.71380246e-01f, 2.16822296e-01f, 1.53588802e-01f,
  -1.19365834e-01f, -7.68517554e-02f, -1.06802888e-01f, -3.33626978e-02f, 2.94421941e-01f, -5.99870980e-02f, -1.41724989e-01f, -1.20194286e-01f, -3.37183774e-01f, -4.03241403e-02f,
  -5.03381379e-02f, -4.47796583e-02f, -3.21385294e-01f, 2.77222931e-01f, -7.34067112e-02f, -1.52511835e-01f, -1.30299002e-01f, 3.22323591e-02f, 3.41620356e-01f, -1.62800513e-02f,
  -7.78948292e-02f, 3.27159524e-01f, -4.16345745e-01f, -1.60238370e-01f, -2.52999216e-02f, 7.63577297e-02f, 1.13636414e-02f, -5.42375585e-03f, 9.72530842e-02f, 1.83537304e-01f,
  3.19470391e-02f, -1.15254857e-01f, 1.44287229e-01f, -2.55901337e-01f, -2.79938102e-01f, 1.97481483e-01f, 1.82605401e-01f, 8.20390955e-02f, 5.93903698e-02f, -1.41457273e-02f,
  6.62568212e-02f, 3.76739204e-02f, 1.03663810e-01f, 2.05186326e-02f, 1.32312998e-02f, -5.99600673e-02f, 1.50955752e-01f, 6.25365078e-02f, 1.55311286e-01f, 3.56318094e-02f,
  1.04724400e-01f, -9.05998573e-02f, 4.86164391e-02f, 2.73451814e-03f, -5.35204411e-02f, 1.07194796e-01f, 1.72758147e-01f, -4.22891416e-02f, -1.04779445e-01f, 1.96551248e-01f,
  6.59040287e-02f, 7.94184580e-02f, 3.16737704e-02f, -1.14212021e-01f, 3.02949138e-02f, 5.72008528e-02f, 4.64098528e-02f, 1.59255341e-01f, -2.83973753e-01f, -3.01797003e-01f,
  -1.80902570e-01f, 1.17898382e-01f, -2.78598368e-01f, 5.78345694e-02f, 3.09380710e-01f, 6.66552633e-02f, -9.11294967e-02f, 5.09826355e-02f, 8.88450444e-02f, 9.33703110e-02f,
  4.44435477e-02f, -2.72322536e-01f, 2.28064865e-01f, -1.92764997e-01f, 1.48620740e-01f, 1.83995850e-02f, -3.88790786e-01f, 1.14131130e-01f, 1.12243704e-01f, 9.43448022e-02f,
  -7.28772357e-02f, 9.90919955e-03f, -1.11772679e-02f, -3.14780474e-01f, 4.81356420e-02f, 5.07031418e-02f, 1.45777494e-01f, 7.05609098e-02f, -3.61007564e-02f, 2.65777521e-02f,
  -4.75209579e-03f, 7.96036646e-02f, -5.41298613e-02f, 1.97205380e-01f, 1.13041051e-01f, 4.00608070e-02f, -1.06874801e-01f, 2.26053268e-01f, 1.20060910e-02f, -3.05140652e-02f,
  -1.14072733e-01f, -6.48363382e-02f, -9.73032042e-02f, 1.15856610e-01f, 8.67316276e-02f, 6.38489053e-02f, -1.33079886e-02f, 1.24474712e-01f, -1.04341216e-01f, 1.19359165e-01f,
  -1.80595055e-01f, 2.75029484e-02f, 3.24873738e-02f, 9.81615484e-03f, 9.09202322e-02f, -1.46763623e-01f, 7.47436509e-02f, -2.28808179e-01f, -2.06974819e-01f, -7.08312094e-02f,
  -2.40318596e-01f, 2.00676192e-02f, 2.04282805e-01f, -1.45014748e-01f, 2.39853546e-01f, -2.51455992e-01f, -8.31061900e-02f, 3.96601744e-02f, -4.04308438e-01f, -5.66142648e-02f,
  -1.54453889e-01f, 2.82533675e-01f, -2.94532944e-02f, -9.82313976e-02f, -2.14878783e-01f, 3.19817394e-01f, 1.96698233e-01f, 2.57963032e-01f, -1.19056404e-01f, 2.10315973e-01f,
  2.37688318e-01f, -4.46702391e-02f, -3.43231469e-01f, 1.12100772e-03f, 2.61931717e-02f, 3.43293957e-02f, 1.00151412e-01f, 1.05278343e-02f, -1.09006844e-01f, -2.86182046e-01f,
  -8.47959965e-02f, -1.36585847e-01f, -1.54273719e-01f, 1.31704628e-01f, 1.30284071e-01f, -1.09485827e-01f, -9.98632386e-02f, 3.19187641e-02f, 2.22593948e-01f, -1.60575453e-02f,
  2.46677827e-02f, 8.59210175e-03f, -9.46313217e-02f, -2.17251405e-01f, 3.31161767e-02f, 3.99353392e-02f, -2.42224991e-01f, -5.23624895e-03f, -8.17764103e-02f, -2.22475920e-02f,
  -8.60559195e-02f, -7.82487467e-02f, 7.98573121e-02f, 6.03569038e-02f, 6.32511592e-03f, 1.63821071e-01f, -1.40007138e-01f, 7.56109599e-04f, -1.08514139e-02f, -2.10119709e-01f,
  -1.60732135e-01f, -1.78239852e-01f, -3.02448440e-02f, 1.77269075e-02f, 1.26018077e-01f, 2.86221892e-01f, 2.64136851e-01f, 1.59249008e-01f, 1.14537716e-01f, -1.40844882e-01f,
  -1.74760714e-01f, 2.78511763e-01f, -5.33276945e-02f, -1.70354992e-01f, -1.47892103e-01f, 6.34733811e-02f, 6.99660406e-02f, 3.18503976e-01f, -1.79159343e-01f, -1.56381857e-02f,
  1.20729670e-01f, 2.61778474e-01f, -5.23724183e-02f, 2.52367347e-01f, 2.42431298e-01f, 8.60024095e-02f, -8.17091390e-02f, 1.78077132e-01f, -3.03712860e-02f, -1.30294532e-01f,
  -7.30798990e-02f, -2.21730649e-01f, 1.43209435e-02f, -7.92172700e-02f, 1.32595778e-01f, 4.59611043e-02f, -2.03206301e-01f, 1.87026799e-01f, 7.68216923e-02f, -2.06301004e-01f,
  -9.04971734e-02f, 4.76625934e-02f, -1.00773327e-01f, -1.70087457e-01f, -1.88320220e-01f, -4.09360640e-02f, -3.90025415e-02f, -3.06955606e-01f, 7.37918261e-03f, -1.61329553e-01f,
  -1.08162053e-01f, -1.89227089e-01f, -8.81974325e-02f, -1.18484031e-02f, -1.06565729e-01f, -1.82048708e-01f, -1.93243816e-01f, 1.15191378e-03f, 4.29086611e-02f, 2.34129746e-02f,
  -1.90957174e-01f, 5.88252619e-02f, -5.50010130e-02f, -1.88333303e-01f, -1.31412953e-01f, -1.59087390e-01f, 3.12517107e-01f, 2.40111113e-01f, -2.29939502e-02f, 5.68548739e-02f,
  3.90995666e-02f, 4.99896519e-02f, -1.61255896e-01f, -3.75139713e-02f, -8.31489414e-02f, 8.04193392e-02f, 8.29778016e-02f, -1.92488745e-01f, -1.55834213e-01f, 7.80246332e-02f,
  2.45171010e-01f, 3.22377652e-01f, -2.67859459e-01f, 2.99948081e-03f, -2.27828324e-01f, 2.10811362e-01f, -1.10683389e-01f, 6.16186904e-03f, -5.30513376e-02f, 5.32995053e-02f,
  2.17080161e-01f, 3.51285562e-04f, 1.93225648e-02f, 1.10866502e-01f, -2.08168358e-01f, -1.55208185e-01f, -2.80153397e-02f, -3.73214215e-01f, -2.70085543e-01f, 5.39473929e-02f,
  -2.20547631e-01f, 2.75650233e-01f, 7.29809627e-02f, -3.73696089e-02f, 2.70589348e-02f, 5.77525757e-02f, -1.28249507e-02f, -7.28178918e-02f, 1.51519135e-01f, -1.18459441e-01f,
  -1.54877141e-01f, 1.27680913e-01f, -6.10239096e-02f, 1.36269465e-01f, -1.36844859e-01f, -2.37525292e-02f, -3.18103395e-02f, -2.64324713e-02f, -2.04816416e-01f, 1.09658845e-01f,
  -4.65651229e-02f, -3.88583131e-02f, 2.04572529e-02f, 9.08711851e-02f, 1.47185341e-01f, 4.30036411e-02f, 4.47529778e-02f, 1.54021576e-01f, 3.26565951e-01f, -5.74836414e-03f,
  4.32833284e-02f, -3.87256265e-01f, -3.25694859e-01f, 3.39945145e-02f, 1.27510041e-01f, -1.09579772e-01f, -6.46086186e-02f, -2.20036432e-01f, 1.19003028e-01f, -1.59875572e-01f,
  1.60232931e-01f, 5.98615482e-02f, 2.71355599e-01f, -9.32326391e-02f, -2.45221063e-01f, -2.41897240e-01f, 8.76763090e-02f, -1.56748742e-01f, 2.56902844e-01f, 1.74292207e-01f,
  6.29291087e-02f, -7.29984716e-02f, -8.64995122e-02f, 2.06593141e-01f, -2.21701577e-01f, 1.96885746e-02f, -7.39063099e-02f, -1.68940037e-01f, 5.07095195e-02f, -8.60963613e-02f,
  3.27777475e-01f, 3.02062124e-01f, 1.27015993e-01f, -1.42798182e-02f, 2.72287428e-01f, -3.06323260e-01f, -1.07474104e-01f, 1.34860232e-01f, 8.50622281e-02f, 4.38454188e-02f,
  1.52540803e-01f, 1.87257111e-01f, -6.51466951e-04f, -2.08586246e-01f, 7.17754737e-02f, -6.53686700e-03f, 2.55949736e-01f, -3.56913731e-02f, 1.89576251e-03f, 1.04535930e-01f,
  6.59899495e-04f, -4.28525545e-02f, 9.87767950e-02f, 8.30328166e-02f, 7.87020624e-02f, -8.20782036e-02f, 2.43069068e-01f, 3.28480564e-02f, 1.52805569e-02f, 1.14775114e-01f,
  2.56227795e-03f, 1.73936412e-01f, -1.89205915e-01f, 4.48262617e-02f, 1.68337762e-01f, 2.20515639e-01f, 9.09937546e-02f, -1.26414150e-01f, -7.56350011e-02f, 6.00629346e-03f,
  -3.27288881e-02f, 1.35015845e-01f, 1.41463414e-01f, 1.57286208e-02f, -1.85966641e-01f, -1.99302465e-01f, -2.42834575e-02f, -2.94431508e-01f, 1.36285394e-01f, 7.65285939e-02f,
  -1.20127890e-02f, 1.51674554e-01f, -1.37830868e-01f, -1.09549552e-01f, -1.19053870e-01f, -2.27394968e-01f, 2.35441282e-01f, -2.12451756e-01f, 2.34174699e-01f, -1.47766262e-01f,
  2.06571728e-01f, 2.61952113e-02f, -1.22524453e-02f, -1.31591275e-01f, 1.56645104e-01f, -1.68223053e-01f, -1.78963810e-01f, -5.85224666e-02f, -2.22544000e-01f, 2.68070608e-01f,
  -9.93616879e-02f, 1.19695691e-02f, 9.32229534e-02f, 6.94251657e-02f, -2.58903578e-02f, 2.02642053e-01f, 3.18891585e-01f, -1.25972003e-01f, -4.61807773e-02f, 1.42107397e-01f,
  3.31817806e-01f, 1.97766013e-02f, 1.12154774e-01f, 5.03154937e-03f, 1.26535259e-02f, 2.22878680e-01f, 9.64358449e-02f, 1.09735996e-01f, 6.46946654e-02f, -4.95875292e-02f,
  2.17610478e-01f, -5.18111028e-02f, 6.47804290e-02f, 1.90489486e-01f, -5.82285449e-02f, 3.04804832e-01f, 1.79872468e-01f, 3.06158811e-01f, -1.05708674e-01f, 1.68115869e-01f,
  1.49437055e-01f, 5.32127321e-02f, -3.03949535e-01f, 3.24594527e-02f, 5.86427711e-02f, 7.75369406e-02f, -6.13170862e-02f, -1.12149045e-01f, 2.02904746e-01f, -5.82123995e-02f,
  1.99340045e-01f, -1.55046374e-01f, 3.67648825e-02f, -1.47237942e-01f, 1.72646955e-01f, -2.23446235e-01f, 5.81375435e-02f, -3.36983949e-01f, 1.60216123e-01f, -1.84239417e-01f,
  -2.75621861e-01f, -2.16212552e-02f, 1.99606821e-01f, 1.19105242e-01f, -1.03234895e-01f, -1.41644999e-01f, 1.83379918e-01f, -1.78694427e-01f, 1.80178434e-01f, -6.77228495e-02f,
  2.53940195e-01f, -8.95015299e-02f, -2.38823637e-01f, 4.19818982e-02f, 2.59784549e-01f, -2.25425854e-01f, 6.39196783e-02f, 4.18310612e-02f, -5.82251735e-02f, -3.88458334e-02f,
  1.28542662e-01f, 1.02939710e-01f, -2.28223667e-01f, -2.70977262e-02f, 1.52491674e-01f, 1.61251619e-01f, -9.60791111e-02f, 1.66230704e-04f, 7.14097917e-02f, 3.51494364e-02f,
  -1.66468546e-01f, -2.88255922e-02f, -7.55034992e-03f, 8.53947997e-02f, -8.34301934e-02f, -4.89971600e-02f, -1.12814501e-01f, 8.34579691e-02f, 2.60028057e-02f, -1.25319809e-01f,
  -1.55646980e-01f, -2.95822859e-01f, -1.57872632e-01f, -1.45595193e-01f, 2.48432323e-01f, 2.92784899e-01f, -1.51504790e-02f, -1.08611599e-01f, -1.71424851e-01f, 5.51061593e-02f,
  4.88475524e-03f, 1.97037056e-01f, 2.87836313e-01f, 1.01355314e-01f, 1.10207431e-01f, 3.50700855e-01f, 9.40022692e-02f, 2.70052552e-01f, 1.02348737e-01f, -2.40980133e-01f,
  -4.32274155e-02f, 8.41857046e-02f, 1.72233790e-01f, 1.57065138e-01f, 6.69245422e-02f, 1.56379595e-01f, 6.13642633e-02f, 1.53262854e-01f, -1.17737785e-01f, 1.00321747e-01f,
  7.07029784e-03f, -3.17440838e-01f, -8.56651813e-02f, 2.21050113e-01f, 2.80099660e-01f, 1.58640712e-01f, 5.99737167e-02f, -1.89308599e-01f, -1.46230981e-01f, 8.85918289e-02f,
  -2.47373004e-02f, 1.91431120e-02f, -1.10148147e-01f, 2.51769032e-02f, -3.51282917e-02f, -8.21681991e-02f, 1.22965738e-01f, -6.98749423e-02f, 9.17655975e-02f, -1.51101977e-01f,
  2.61311568e-02f, 1.19151168e-01f, 2.88350247e-02f, 1.34733841e-01f, 1.95783734e-01f, -1.12924889e-01f, -1.47957364e-02f, -1.16824776e-01f, 4.28218842e-02f, -8.93942490e-02f,
  9.60758254e-02f, 9.51913074e-02f, -1.00750461e-01f, 2.46913463e-01f, 1.14213482e-01f, 3.64410102e-01f, 2.91408133e-02f, 8.85275602e-02f, -1.29468933e-01f, -2.12945551e-01f,
  -2.68637240e-01f, 2.74929166e-01f, 2.05231830e-01f, -1.12731308e-01f, -1.03375778e-01f, 3.36793140e-02f, 6.32357923e-03f, 1.01493634e-01f, 4.54021320e-02f, -3.26438636e-01f,
  -2.49715760e-01f, 3.56406607e-02f, -3.41970585e-02f, 1.72583103e-01f, -1.24187153e-02f, -2.93031871e-01f, 1.88231036e-01f, -2.17426360e-01f, 8.82350281e-02f, -1.40321970e-01f,
  -6.99837208e-02f, -1.15700461e-01f, -1.00604177e-03f, -1.29780456e-01f, 7.05941394e-02f, 1.17382027e-01f, 9.12886020e-03f, -1.08307473e-01f, -3.06621611e-01f, -1.25172809e-01f,
  -2.68046349e-01f, 2.23291248e-01f, -8.91924575e-02f, -2.47572124e-01f, -3.99246551e-02f, -1.62312165e-02f, -2.04386096e-02f, -1.36345327e-01f, 1.91765100e-01f, 1.68276951e-01f,
  -1.18862003e-01f, -1.04972690e-01f, 2.10996956e-01f, -6.58100843e-02f, 2.52555180e-02f, 1.97425261e-02f, 3.63493860e-02f, 2.23136678e-01f, 6.99274540e-02f, -6.45823851e-02f,
  -8.75619520e-03f, 1.09595843e-01f, -1.17828242e-01f, -3.82897221e-02f, 1.42182976e-01f, -2.69916616e-02f, 1.68762989e-02f, 5.89619502e-02f, -8.90920833e-02f, 1.70006119e-02f,
  -2.59584159e-01f, -3.44211794e-02f, 2.34407783e-01f, -5.51070757e-02f, -2.54041702e-01f, 8.60842615e-02f, 8.16802159e-02f, -2.21254215e-01f, -8.41658860e-02f, 9.79675278e-02f,
  2.08087847e-01f, 2.16465309e-01f, 4.59376723e-02f, 7.26313889e-02f, -2.49833316e-01f, 1.47969604e-01f, 6.83966577e-02f, -2.01411813e-01f, -1.43626437e-01f, -2.38708869e-01f,
  2.17868850e-01f, -1.62767291e-01f, 2.18066722e-01f, -4.96322624e-02f, 3.90782170e-02f, -6.22116365e-02f, -1.61062539e-01f, -3.07323579e-02f, 9.69310179e-02f, -4.84528169e-02f,
  -2.65838116e-01f, 7.40934536e-03f, -2.72853315e-01f, 3.63785535e-01f, -3.40977341e-01f, 2.29479559e-02f, -1.53448790e-01f, 1.32015377e-01f, 1.16210552e-02f, -7.34467208e-02f,
  2.69773081e-02f, 1.06012978e-01f, -1.79974772e-02f, -4.72790152e-02f, 1.85159996e-01f, 2.21020386e-01f, -1.99858770e-01f, 9.39372629e-02f, 2.13600829e-01f, 4.03915457e-02f,
  -7.18530938e-02f, -3.78135368e-02f, 1.82371587e-01f, 6.79726005e-02f, -6.73500597e-02f, -1.49763688e-01f, -1.08078592e-01f, 9.04752612e-02f, 2.26545110e-01f, 5.53767197e-02f,
  3.26151438e-02f, -9.06437170e-03f, 1.52582796e-02f, -3.31479050e-02f, 1.81518063e-01f, 1.91199899e-01f, -9.96045545e-02f, -3.00947994e-01f, -6.43410087e-02f, -1.73827231e-01f,
  1.61680058e-02f, -1.77970380e-02f, -1.31879309e-02f, -1.86583072e-01f, -2.56562203e-01f, -9.18681026e-02f, 3.48815396e-02f, -2.12536827e-01f, 5.71390577e-02f, -2.78426468e-01f,
  9.55781564e-02f, 2.18075052e-01f, -8.50107074e-02f, 1.69823244e-02f, -2.17942297e-01f, -3.57625224e-02f, -1.50588423e-01f, -1.18057922e-01f, 7.45702442e-03f, -1.92790672e-01f,
  -4.44495864e-03f, 3.87269288e-01f, 2.03029402e-02f, 2.45375156e-01f, 5.44429608e-02f, -1.32838100e-01f, -2.10539773e-01f, -9.69091952e-02f, 1.11596659e-01f, 1.08934648e-01f,
  -2.28922844e-01f, 1.34654269e-01f, 1.10855680e-02f, 7.98645392e-02f, 1.34416334e-02f, 3.65124792e-02f, 1.11759141e-01f, -1.43290892e-01f, 2.36359060e-01f, 1.03087261e-01f,
  2.16499969e-01f, -8.81626830e-02f, 1.77190363e-01f, 7.78956413e-02f, 3.75304557e-02f, 9.56333131e-02f, 8.78031105e-02f, -3.70535180e-02f, -6.71803951e-02f, -1.24648862e-01f,
  -2.96569038e-02f, 1.57361880e-01f, -1.89634472e-01f, 5.77721819e-02f, 1.04055546e-01f, 2.35797971e-01f, -2.29070321e-01f, 6.13530576e-02f, 1.45864096e-02f, 4.06276286e-01f,
  1.87906856e-03f, -1.50637880e-01f, -3.69620651e-01f, 1.14764825e-01f, 5.21039478e-02f, 1.61882073e-01f, 5.99704161e-02f, -1.52571082e-01f, -1.89669311e-01f, -2.14778811e-01f,
  -1.35030597e-01f, -3.04124206e-01f, 2.56225795e-01f, 5.05608730e-02f, -1.42275412e-02f, 1.46275789e-01f, -3.20998043e-01f, -8.31000060e-02f, -1.09500095e-01f, -1.42489031e-01f,
  8.65703896e-02f, -5.70376255e-02f, 2.97265351e-01f, -1.55041993e-01f, 1.06904030e-01f, 3.16893458e-02f, -1.54994940e-02f, 9.51199699e-03f, 1.34389684e-01f, -8.72270167e-02f,
  -1.30782053e-01f, 3.72397043e-02f, -1.84266552e-01f, 2.91831970e-01f, 3.07330526e-02f, 2.84879446e-01f, -9.01713148e-02f, -1.36792332e-01f, -2.77278200e-02f, -6.12358265e-02f,
  -2.20370010e-01f, 2.28801128e-02f, 2.92131662e-01f, 1.32486656e-01f, -1.97391346e-01f, 1.36029482e-01f, 2.15794612e-03f, -1.71889793e-02f, -6.86320439e-02f, -1.37887701e-01f,
  -5.21362051e-02f, -2.87887193e-02f, -4.92572635e-02f, -6.39030989e-03f, -1.39617026e-01f, -3.94037701e-02f, -1.45330697e-01f, 2.63217892e-02f, -8.10594112e-02f, -1.10121615e-01f,
  2.11064294e-01f, 4.82851788e-02f, 1.41073525e-01f, -7.34561011e-02f, -2.25728348e-01f, -1.52284317e-02f, -1.17986463e-02f, 3.17404307e-02f, -1.08400755e-01f, 2.42522568e-01f,
  8.63695294e-02f, -1.38181239e-01f, -1.23838119e-01f, -3.55894655e-01f, -7.97299296e-02f, -1.45774931e-01f, 3.24098140e-01f, -2.64201283e-01f, -1.57022685e-01f, 1.33262739e-01f,
  -8.10944140e-02f, -1.96715847e-01f, 3.35145462e-03f, 1.58436731e-01f, -2.70672411e-01f, 1.63372830e-01f, -8.35354030e-02f, 1.77754968e-01f, 1.54750362e-01f, -1.80546761e-01f,
  -1.42530113e-01f, 2.66334206e-01f, 2.19394878e-01f, -3.46769169e-02f, 2.17868343e-01f, -2.66191900e-01f, 2.51561970e-01f, -5.91588430e-02f, 9.95875522e-02f, 2.70951148e-02f,
  2.17048287e-01f, -6.30605742e-02f, 1.65595457e-01f, 1.97636530e-01f, 1.99045390e-01f, 2.47537978e-02f, -5.29260375e-02f, 7.60729983e-02f, 2.24542961e-01f, 8.36832225e-02f,
  -6.12016674e-03f, 2.87573099e-01f, -1.07230246e-01f, 1.59292608e-01f, -1.17444001e-01f, 4.49402891e-02f, 1.58650763e-02f, 3.06103155e-02f, 7.13446438e-02f, -4.59776595e-02f,
  -5.89216244e-04f, 7.99593255e-02f, 1.87909305e-02f, 1.09805865e-02f, 4.39729393e-02f, 6.48017228e-02f, -1.61211327e-01f, -1.56600982e-01f, 1.02794848e-01f, 2.21454591e-01f,
  5.48340939e-02f, -2.50472665e-01f, 9.52544212e-02f, -1.31337643e-01f, -3.07441577e-02f, 1.88013539e-01f, -1.15727670e-01f, 1.88140139e-01f, -1.20911486e-01f, -4.12039347e-02f,
  -2.82417744e-01f, 3.92013229e-02f, 1.09369002e-01f, -2.26642117e-01f, 1.88400045e-01f, -1.16413213e-01f, 1.13653526e-01f, -1.28590092e-01f, 8.88360739e-02f, -5.98833784e-02f,
  -4.03370947e-01f, 1.17846146e-01f, -1.24106221e-01f, -8.53135586e-02f, 2.33929396e-01f, -2.95465618e-01f, -1.98848128e-01f, 1.38418108e-01f, 1.50589764e-01f, -2.70893183e-02f,
  7.44055808e-02f, -1.50950149e-01f, -1.53952942e-03f, -5.80977313e-02f, -1.31652698e-01f, 1.06254645e-01f, -1.01997323e-01f, -2.31067073e-02f, -1.09725609e-01f, 2.33835429e-01f,
  -1.12583570e-01f, 1.36153484e-02f, -9.42797773e-03f, -1.52263969e-01f, 3.08225825e-02f, -1.36688784e-01f, 6.97412342e-02f, -8.91882107e-02f, -5.95466122e-02f, -2.13945270e-01f,
  -8.08641091e-02f, -6.40624687e-02f, 3.52069885e-02f, -9.30982232e-02f, -4.49531376e-02f, -9.30860788e-02f, -3.42970826e-02f, -1.16448618e-01f, 1.17153771e-01f, -3.16663206e-01f,
  2.60358423e-01f, -3.56029928e-01f, -8.65811557e-02f, -1.44590354e-02f, 1.31900698e-01f, -2.06023127e-01f, -1.03644699e-01f, -2.06714168e-01f, -3.38632613e-02f, -1.08416744e-01f,
  1.52975023e-01f, 4.27799188e-02f, 3.25839780e-02f, 2.33139679e-01f, -1.16412938e-01f, 2.74008065e-02f, 3.86804119e-02f, -1.51150793e-01f, -6.33246675e-02f, 7.33019337e-02f,
  -3.10218215e-01f, 2.13182151e-01f, 3.56375277e-02f, 2.44434029e-01f, -2.25168258e-01f, -6.05281182e-02f, -4.78349403e-02f, 2.83166468e-01f, 4.70465869e-02f, -2.70755500e-01f,
  -6.22874126e-02f, 7.61182010e-02f, -1.69822708e-01f, 1.75922945e-01f, 1.79177180e-01f, -8.65221098e-02f, -4.47379723e-02f, -2.96793766e-02f, -1.64311349e-01f, 3.91278155e-02f,
  -2.35269256e-02f, -8.44453424e-02f, -2.47169584e-01f, 1.77748099e-01f, -1.03063114e-01f, -9.97886658e-02f, -2.46489942e-01f, -8.45322162e-02f, -5.01933135e-02f, -6.79808855e-02f,
  5.29763289e-02f, -9.88583192e-02f, 8.89027789e-02f, -1.74213257e-02f, -4.67610024e-02f, 5.85915986e-03f, -1.31354764e-01f, -1.40827164e-01f, 2.60238107e-02f, -1.52372479e-01f,
  4.54264809e-04f, -2.52716810e-01f, -1.39152020e-01f, 7.54288137e-02f, -6.14209995e-02f, -1.48266286e-01f, -7.55072758e-02f, -2.08663821e-01f, 2.39859506e-01f, 3.33250195e-01f,
  2.31249481e-02f, -2.88285673e-01f, -2.82936633e-01f, -6.48902357e-02f, -2.39486843e-01f, 2.10904777e-01f, -1.40654594e-01f, 1.35245979e-01f, -1.99050054e-01f, 1.20849364e-01f,
  -1.81359202e-01f, 1.21485926e-01f, 1.38978824e-01f, 1.95862100e-01f, -5.44529520e-02f, 1.12872243e-01f, 2.58302510e-01f, 2.12879643e-01f, -9.14565921e-02f, -1.20997488e-01f,
  -5.73073514e-02f, -1.47757784e-01f, -4.73971218e-02f, 1.92170054e-01f, -1.71315759e-01f, -1.48163185e-01f, -2.19941825e-01f, 1.21479429e-01f, -1.96151510e-01f, 8.37763995e-02f,
  -1.69050992e-02f, 1.12596497e-01f, 7.22602680e-02f, -7.48302788e-02f, -1.49601683e-01f, 8.47707912e-02f, 1.78965092e-01f, -1.18789941e-01f, -6.17397949e-02f, -1.67539448e-01f,
  1.66880414e-01f, -9.80028585e-02f, -1.37482315e-01f, -5.65438457e-02f, -1.52227461e-01f, -1.49663672e-01f, 6.11654595e-02f, 3.97044793e-03f, -1.28763348e-01f, -4.85312268e-02f,
  1.62158981e-01f, -5.92540205e-02f, 5.08798063e-02f, -9.35902447e-02f, 2.84806043e-02f, 2.58541167e-01f, 2.66683310e-01f, 4.39240009e-01f, 2.51031250e-01f, 5.91275143e-03f,
  -1.61841139e-01f, -2.13636905e-02f, -7.04504699e-02f, 3.37895334e-01f, -1.66995555e-01f, 5.12552001e-02f, 1.98935568e-01f, -1.32370340e-02f, 2.18673572e-01f, -4.27187309e-02f,
  2.82232575e-02f, -4.26467836e-01f, -1.41686171e-01f, 3.72182690e-02f, 1.68014273e-01f, 5.70254512e-02f, -5.90365976e-02f, -2.52495650e-02f, 8.78680497e-02f, -2.49159649e-01f,
  2.80791909e-01f, -9.81888101e-02f, 1.94368139e-02f, -1.53166786e-01f, -2.53089499e-02f, -1.79715440e-01f, -7.29833730e-03f, 1.62233606e-01f, 1.92797735e-01f, 2.35244438e-01f,
  -7.59620667e-02f, -9.10456702e-02f, 9.22302231e-02f, 1.66542128e-01f, 4.62980680e-02f, -6.81478232e-02f, 1.24426231e-01f, -8.09189379e-02f, -3.07941549e-02f, -6.10686839e-02f,
  3.34235393e-02f, 4.77724001e-02f, -1.42163048e-02f, -3.65782194e-02f, 4.29253355e-02f, 1.58861116e-01f, -1.10656336e-01f, -3.60355526e-02f, -3.36157111e-03f, 6.49428293e-02f,
  -5.86368926e-02f, -7.30285347e-02f, -3.53155062e-02f, -1.85778737e-02f, 1.07894532e-01f, -3.38331871e-02f, 9.08632670e-03f, -6.42065704e-02f, 1.35039806e-01f, 1.02707580e-01f,
  3.03122520e-01f, 9.22502950e-02f, -2.89857350e-02f, -8.59297365e-02f, 2.55674243e-01f, 1.29879370e-01f, -8.15792531e-02f, -2.97396451e-01f, 1.58315316e-01f, 1.77429691e-01f,
  1.75939143e-01f, 3.02826352e-02f, 3.11821699e-01f, -6.77363351e-02f, 2.55773187e-01f, 1.25172958e-01f, -1.09267779e-01f, -1.85311869e-01f, 2.48742595e-01f, -1.61328595e-02f,
  4.05079639e-03f, -8.29792321e-02f, 1.85466811e-01f, 3.82223986e-02f, 3.23620671e-03f, -2.67422378e-01f, -2.89642680e-02f, 1.58173479e-02f, -2.96848476e-01f, 1.08384885e-01f,
  8.76757652e-02f, -2.75154203e-01f, -1.21933497e-01f, 1.28688365e-01f, 3.71051818e-01f, 2.76192844e-01f, 2.32730106e-01f, -1.67165831e-01f, 2.74720807e-02f, -5.31779341e-02f,
  1.74698420e-02f, 7.81642944e-02f, -2.42377985e-02f, -1.96041651e-02f, -5.60786724e-02f, -2.07914755e-01f, -1.09095154e-02f, -1.18825302e-01f, 1.06545724e-01f, -6.84149638e-02f,
  -1.85598567e-01f, 3.02055404e-02f, -2.01639876e-01f, -2.24367142e-01f, -1.65661052e-02f, -8.02628398e-02f, -7.46138841e-02f, -1.84496209e-01f, 4.33051102e-02f, 8.50915164e-02f,
  7.45448545e-02f, 1.17702298e-01f, 7.73663074e-02f, 2.40707919e-01f, 2.90688239e-02f, -1.89579204e-01f, 3.37299794e-01f, -6.93909675e-02f, -1.95385173e-01f, 2.35823214e-01f,
  1.33423403e-01f, 1.61749765e-01f, -1.18357979e-01f, 6.81191459e-02f, 1.61229655e-01f, 7.82881901e-02f, 1.75428450e-01f, -1.77925512e-01f, -2.58599252e-01f, -2.42205948e-01f,
  6.97679222e-02f, 1.47576958e-01f, -4.46734652e-02f, -3.40072811e-03f, 6.74314573e-02f, 2.85412997e-01f, 1.27447918e-02f, -1.94810227e-01f, 1.66764528e-01f, -9.19658840e-02f,
  1.11623585e-01f, -3.83762158e-02f, 1.31214380e-01f, -3.16780418e-01f, 3.06534376e-02f, -2.56927937e-01f, 1.63773909e-01f, 6.77295625e-02f, -1.56476170e-01f, -2.08094552e-01f,
  2.81765372e-01f, 1.33667484e-01f, 1.60342723e-01f, -5.52477017e-02f, 1.89774781e-01f, -1.23459334e-03f, 3.54074501e-02f, -3.32138911e-02f, 1.66994929e-02f, 1.68900877e-01f,
  -4.89811562e-02f, 5.58664687e-02f, -5.59759028e-02f, 6.04658686e-02f, -1.66465417e-01f, 1.43496543e-01f, -3.59351300e-02f, 1.05520241e-01f, -2.88876612e-03f, 1.13895275e-01f,
  -5.49726561e-02f, 8.04707706e-02f, 6.91976622e-02f, 5.74372448e-02f, 1.54940516e-01f, -1.32758424e-01f, 1.22355148e-02f, -2.07799569e-01f, 1.26253068e-01f, -1.39633328e-01f,
  8.54924992e-02f, 8.22295025e-02f, 9.85107347e-02f, -1.31298780e-01f, 2.80865431e-01f, -3.54809821e-01f, 2.50830650e-01f, -1.58653297e-02f, 3.85874659e-02f, -2.72147730e-03f,
  -1.07690103e-01f, -1.22042045e-01f, 1.23840325e-01f, -2.51581036e-02f, 1.78573113e-02f, -1.84970826e-01f, 8.32973123e-02f, 8.15254450e-02f, -4.52471003e-02f, -8.00688169e-04f,
  -2.55016118e-01f, 1.98473334e-01f, 1.96583197e-01f, -2.67605573e-01f, -2.13192329e-02f, -6.42572343e-02f, -6.80544749e-02f, 2.45640412e-01f, 2.51448434e-02f, -2.70119399e-01f,
  4.18046191e-02f, -1.65811732e-01f, 1.58125926e-02f, -3.01244352e-02f, -1.10515483e-01f, 4.54669334e-02f, -2.30051383e-01f, 4.03835699e-02f, 1.10512171e-02f, -1.62163123e-01f,
  3.92431468e-02f, 1.39233232e-01f, 1.31811962e-01f, -2.49575198e-01f, 9.29432511e-02f, -3.13671120e-02f, 1.05093107e-01f, -1.14046663e-01f, -1.23873129e-01f, 1.44053504e-01f,
  -2.16948107e-01f, 5.80512881e-02f, 2.74335742e-02f, -1.30206853e-01f, -9.69470218e-02f, -2.36239716e-01f, 1.02473907e-01f, -1.27166952e-03f, 2.74870056e-03f, 2.82106362e-03f,
  1.40568884e-02f, 2.20552564e-01f, -5.26226535e-02f, 7.02458471e-02f, 1.58026770e-01f, 1.60408318e-01f, -3.68427448e-02f, -8.42943788e-02f, 3.90102006e-02f, 8.52646977e-02f,
  7.37769529e-02f, 1.75181746e-01f, 3.02993059e-01f, 8.20419341e-02f, -1.32724255e-01f, -6.10415936e-02f, -1.25426844e-01f, -3.73281032e-01f, 4.63002659e-02f, -2.76863761e-02f,
  5.38365580e-02f, 1.80784538e-01f, -1.81500316e-01f, 1.41978383e-01f, -1.17404863e-01f, -2.83367068e-01f, 2.08170474e-01f, -3.28252017e-01f, -5.85117862e-02f, -5.89963011e-02f,
  1.98154747e-01f, -4.70631011e-02f, -8.40281323e-02f, -1.76458091e-01f, 1.88855112e-01f, 2.06891205e-02f, -2.23512873e-01f, -2.04673171e-01f, 2.09987655e-01f, 1.04375377e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  9.47011113e-02f, 3.72839779e-01f, 2.72054642e-01f, -5.61171360e-02f, 2.24732995e-01f, 3.31221849e-01f, 2.57910579e-01f, -4.53811735e-02f, 2.92464077e-01f, 5.20323873e-01f,
  2.52067894e-01f, 5.81210516e-02f, 5.39211869e-01f, 2.67414331e-01f, 1.03844814e-01f, 7.54621401e-02f, -2.67403945e-02f, 2.58999616e-01f, 3.26542586e-01f, 1.96179509e-01f,
  2.49206185e-01f, 2.10821554e-01f, 7.49158412e-02f, 3.05985481e-01f, -1.43902421e-01f, 5.30329347e-01f, 2.76374817e-01f, 2.45366599e-02f, -1.71361133e-01f, -1.20980948e-01f,
  -5.14486730e-02f, -1.91844627e-01f, -5.93680501e-01f, -4.97516185e-01f, 1.10500947e-01f, -2.33206868e-01f, -4.45518494e-01f, -1.84278771e-01f, -3.14777553e-01f, 3.14045668e-01f,
  4.65575196e-02f, 8.10272899e-03f, -4.23779398e-01f, -2.86231041e-01f, 2.71785676e-01f, -2.75342137e-01f, 3.67395997e-01f, -3.48201692e-01f, 8.24139565e-02f, -2.42174417e-01f,
  -5.65428078e-01f, 3.28283489e-01f, -5.17305791e-01f, -1.25954136e-01f, 2.60346860e-01f, -1.74247891e-01f, 5.29873312e-01f, -2.40863234e-01f, -6.84162751e-02f, 2.51818448e-01f,
  2.67035395e-01f, 1.27304103e-02f, 4.93366003e-01f, -2.28527054e-01f, -1.39433995e-01f, 3.85148823e-01f, -4.97872792e-02f, 3.06901067e-01f, 3.01588595e-01f, 1.46324441e-01f,
  -1.65144980e-01f, 5.25581278e-02f, 2.53181964e-01f, 5.16936481e-01f, -3.54677558e-01f, 2.67593116e-01f, 1.76129803e-01f, 1.97139427e-01f, 2.79050142e-01f, 8.55676159e-02f,
  2.53057003e-01f, 2.55559772e-01f, 7.71155357e-02f, 1.17322557e-01f, 7.71770477e-02f, 3.06317657e-02f, 1.86971128e-01f, 2.06854697e-02f, -3.55748571e-02f, -3.27795744e-01f,
  1.16332121e-01f, 1.84439108e-01f, -1.52206466e-01f, 4.13813107e-02f, -3.09101433e-01f, -4.58007783e-01f, -8.03583115e-02f, -2.52903160e-02f, 3.39275062e-01f, -3.97871166e-01f,
  -2.41175875e-01f, -2.82064915e-01f, -6.77677929e-01f, -3.88899259e-02f, 6.96746930e-02f, 3.46577652e-02f, -3.05998251e-02f, -6.16307616e-01f, 6.82629049e-02f, 5.46419621e-01f,
  1.07519589e-01f, -6.66888023e-04f, -1.05315715e-01f, 1.55299395e-01f, -2.78482109e-01f, 1.51785597e-01f, -5.14735818e-01f, -3.97797316e-01f, 1.96396083e-01f, 2.84962565e-01f,
  1.06707066e-01f, 4.08289105e-01f, 1.45835549e-01f, -3.52932960e-02f, 3.56814899e-02f, -1.28659233e-01f, 1.34361356e-01f, -1.24462791e-01f, 1.21571846e-01f, -3.63468640e-02f,
  1.74328670e-01f, 8.13877061e-02f, -2.61658579e-02f, 1.29713835e-02f, 2.10425816e-02f, 1.81388974e-01f, 1.16232997e-02f, 2.66500235e-01f, 5.18672653e-02f, 5.74998297e-02f,
  6.50291219e-02f, 2.89015155e-02f, 2.01674670e-01f, 6.03940599e-02f, 2.10479558e-01f, 9.44474488e-02f, 1.21740289e-01f, 5.69982193e-02f, 7.31482282e-02f, 1.11005316e-02f,
  3.04359347e-01f, 1.65000185e-02f, 2.02090323e-01f, 1.02455974e-01f, 5.55971384e-01f, 1.96173444e-01f, 8.44530687e-02f, -3.68503094e-01f, -1.40417457e-01f, 1.96158122e-02f,
  -1.94552094e-01f, -1.53019190e-01f, -2.44425595e-01f, 1.99999437e-01f, 4.20952410e-01f, -6.99694753e-02f, 2.12198004e-01f, 2.13705525e-01f, 3.21426660e-01f, 9.90586355e-02f,
  -7.54804984e-02f, -3.31306219e-01f, 3.09820831e-01f, 4.89489357e-05f, 1.57035254e-02f, -1.46311209e-01f, 1.52264386e-01f, -7.71555603e-02f, 1.04856389e-02f, 2.07358152e-01f,
  1.00032128e-01f, 2.05381867e-03f, -2.18957409e-01f, 2.23817021e-01f, 1.66691199e-01f, 2.80385703e-01f, 5.63634261e-02f, 3.34348977e-01f, 3.63213032e-01f, 2.42097065e-01f,
  4.99898404e-01f, -4.88830298e-01f, 2.63914108e-01f, 5.37895113e-02f, 3.39002132e-01f, 1.75976411e-01f, 8.27268660e-02f, 2.86858022e-01f, 4.22125161e-01f, 1.20478816e-01f,
  -1.04226470e-01f, 2.77344525e-01f, 4.31706727e-01f, 3.87829036e-01f, 1.77910894e-01f, 2.31217310e-01f, 2.33663559e-01f, 4.62854475e-01f, 1.92013368e-01f, 2.95120507e-01f,
  2.34962165e-01f, 1.99109226e-01f, 3.63526404e-01f, 3.96105528e-01f, 4.02992845e-01f, 1.82801083e-01f, 1.50336072e-01f, 3.85497034e-01f, 3.82692188e-01f, -1.20638460e-02f,
  -3.65683660e-02f, -1.82316273e-01f, 1.16943367e-01f, -1.06771909e-01f, -2.10291967e-01f, -3.78144145e-01f, 1.13632396e-01f, 2.24757805e-01f, 4.20829087e-01f, -8.32684636e-02f,
  2.88813829e-01f, 1.04086950e-01f, 4.58904564e-01f, -1.63966596e-01f, 3.99778895e-02f, -3.76628369e-01f, 4.30058151e-01f, -2.84189641e-01f, -2.78267235e-01f, -2.93761104e-01f,
  1.09999552e-01f, -2.98482955e-01f, 1.95935577e-01f, -1.08496204e-01f, 8.05966631e-02f, 1.75427362e-01f, -2.01860860e-01f, 3.62368256e-01f, 2.56560445e-01f, -5.03063679e-01f,
  8.23748261e-02f, 3.29231262e-01f, 4.57479388e-01f, 5.19031227e-01f, 4.01401430e-01f, -5.37639558e-01f, 3.51396017e-02f, 1.37438700e-01f, 3.02861243e-01f, 1.07608989e-01f,
  1.65521607e-01f, 2.62522638e-01f, -3.08796316e-02f, -3.17447782e-01f, 4.33343917e-01f, 1.55791655e-01f, 2.08956599e-01f, 1.47904515e-01f, -4.32174429e-02f, 8.21473747e-02f,
  3.96733284e-02f, -1.33996278e-01f, 1.37770593e-01f, 6.18400052e-02f, -2.07690466e-02f, -1.46451056e-01f, 3.61251444e-01f, 2.91758835e-01f, 2.02319566e-02f, 2.58460969e-01f,
  2.09992275e-01f, 3.38398010e-01f, -1.09999925e-01f, -2.26300344e-01f, 4.67851758e-01f, 4.79580194e-01f, -8.38312805e-02f, -5.22113964e-02f, 3.44180092e-02f, 5.19914255e-02f,
  -2.32409492e-01f, 4.90419149e-01f, 2.31066287e-01f, -1.57437593e-01f, 1.55157045e-01f, -3.42534214e-01f, -1.10905975e-01f, -4.77213830e-01f, 4.43090975e-01f, -9.09903925e-03f,
  -7.71182477e-02f, 2.01031417e-01f, -5.00655413e-01f, 1.89482868e-01f, -2.58166552e-01f, -3.02641302e-01f, 1.65400803e-01f, 2.04665229e-01f, 5.48508644e-01f, 9.62667242e-02f,
  4.87335563e-01f, 1.04429796e-01f, -4.25788155e-03f, 1.65636614e-01f, 6.95397317e-01f, 1.30790591e-01f, -3.46061379e-01f, -3.40546101e-01f, 4.45520729e-01f, 5.03931582e-01f,
  2.60452956e-01f, 1.75667226e-01f, 1.07102841e-01f, 3.13255012e-01f, 2.71107793e-01f, 1.63317338e-01f, 3.94164361e-02f, 4.03375119e-01f, 5.59341498e-02f, 4.48293053e-02f,
  -1.59816563e-01f, 2.38072291e-01f, -2.50870079e-01f, 1.50595203e-01f, 2.42834225e-01f, 2.84676433e-01f, 6.81246892e-02f, 1.05880849e-01f, 1.83275148e-01f, 1.71037987e-01f,
  -7.72126615e-02f, 1.64023116e-01f, 1.74556404e-01f, 1.36337876e-01f, 1.34973601e-01f, -4.80171263e-01f, -1.01056837e-01f, -1.77123174e-01f, -2.31261685e-01f, -2.46656790e-01f,
  -2.58215261e-03f, 2.58572906e-01f, 4.91746634e-01f, 1.15281217e-01f, 3.04634780e-01f, -2.69725561e-01f, 1.85529396e-01f, 2.62346387e-01f, -4.30175334e-01f, -2.32756570e-01f,
  -2.89482236e-01f, 2.92047620e-01f, -4.04077992e-02f, -4.20178398e-02f, -3.21393996e-01f, 4.27880108e-01f, 2.29716465e-01f, 2.02236772e-01f, 3.81920598e-02f, 4.94060814e-01f,
  5.64632654e-01f, -8.39428604e-03f, -4.27459538e-01f, 3.81073296e-01f, -9.89054292e-02f, 5.83060794e-02f, 7.75139257e-02f, 2.88924873e-01f, -6.19339272e-02f, -1.17129892e-01f,
  2.75068343e-01f, 5.28198332e-02f, -2.63346255e-01f, 1.23773880e-01f, 1.07950754e-01f, 1.41719788e-01f, 1.43681332e-01f, 2.53218830e-01f, 2.14095153e-02f, 2.94158280e-01f,
  9.56210867e-02f, 1.06215835e-01f, 8.26388672e-02f, 2.36876592e-01f, -2.76349515e-01f, 4.25227508e-02f, 1.07781783e-01f, 6.95653632e-02f, 5.64654134e-02f, 1.80215120e-01f,
  1.60016432e-01f, 1.88692957e-01f, 8.50340351e-02f, -2.05280483e-02f, -1.72555423e-03f, 1.74518153e-01f, 3.07169467e-01f, 3.38549167e-02f, 1.07933708e-01f, -2.86706030e-01f,
  5.37063956e-01f, -1.33146763e-01f, 2.59182483e-01f, -1.38643384e-01f, -5.69390953e-01f, -5.15010178e-01f, 1.02337927e-01f, -4.15368974e-01f, -7.84479752e-02f, -3.98709506e-01f,
  -1.79187357e-01f, -4.58001941e-01f, -5.27337372e-01f, -1.88026384e-01f, 2.03851581e-01f, -1.23454109e-01f, -8.82512182e-02f, -6.99847043e-01f, -1.30425319e-02f, 4.69800591e-01f,
  2.98078448e-01f, 3.07476848e-01f, -2.93774307e-01f, 2.83700198e-01f, -2.61594266e-01f, -1.40608206e-01f, -2.54577160e-01f, -5.24815023e-01f, 1.51435927e-01f, 2.99144894e-01f,
  1.81985840e-01f, 4.70088005e-01f, 2.89714962e-01f, -1.70476675e-01f, -3.20665926e-01f, -5.77709340e-02f, 2.51229167e-01f, 1.04599334e-01f, 1.44579098e-01f, 1.20165728e-01f,
  5.40703051e-02f, 1.80070683e-01f, -3.71512678e-03f, -2.99354340e-03f, -5.03872216e-01f, 2.11804360e-01f, 1.64850786e-01f, -6.24373518e-02f, -2.63316035e-01f, -6.74942695e-03f,
  1.44569427e-01f, -1.39609188e-01f, 2.00229257e-01f, 5.86771034e-02f, -6.89406991e-02f, 2.09669143e-01f, 7.21995384e-02f, 2.53457248e-01f, -1.12029590e-01f, -2.35531852e-03f,
  -2.14785621e-01f, 2.90783316e-01f, -6.47510737e-02f, 1.18878912e-02f, 2.99317926e-01f, 2.51435228e-02f, -1.36646107e-01f, -4.94168401e-01f, -2.43233502e-01f, 4.99287546e-01f,
  1.26401275e-01f, 3.23674917e-01f, -4.42826480e-01f, 6.10314310e-03f, -2.56197322e-02f, 4.10925113e-02f, 4.28299904e-01f, 4.55420762e-02f, -1.97005153e-01f, 2.28874594e-01f,
  1.27518430e-01f, 4.34405267e-01f, -1.61939859e-01f, -7.69374967e-02f, 4.05857146e-01f, -1.97814003e-01f, 5.09222567e-01f, 3.59815300e-01f, -2.25114703e-01f, 6.59417152e-01f,
  -1.61838561e-01f, 6.39196754e-01f, -3.18099856e-02f, -4.52115268e-01f, 3.45675126e-02f, 4.20630008e-01f, 1.95184618e-01f, -1.09391026e-01f, 3.28950137e-01f, -2.30623856e-01f,
  6.43988252e-02f, -5.44294268e-02f, -8.68405774e-02f, 1.21032536e-01f, 2.41335079e-01f, 2.11135849e-01f, 1.41563192e-01f, 1.98323667e-01f, 1.47091135e-01f, -2.35137101e-02f,
  1.54762179e-01f, 1.60298616e-01f, 2.80390531e-01f, 2.49699667e-01f, 1.19855754e-01f, 3.49995017e-01f, 1.20582357e-01f, 3.73563647e-01f, 2.04321325e-01f, 3.82956356e-01f,
  2.72304863e-01f, 3.51486176e-01f, 5.41230105e-02f, 2.87172467e-01f, -1.37576103e-01f, 2.50884354e-01f, -3.76027226e-02f, 1.08543746e-01f, -5.30449808e-01f, 5.88151276e-01f,
  -6.24210596e-01f, 1.62217677e-01f, 2.40063220e-01f, 2.02118859e-01f, -2.60593563e-01f, 4.46758926e-01f, 4.64398205e-01f, 2.85963655e-01f, -1.31634057e-01f, 3.04942220e-01f,
  -3.02996278e-01f, 1.80021375e-01f, -8.04129764e-02f, -1.77858666e-01f, -1.88508913e-01f, 3.78194928e-01f, 4.73975278e-02f, -1.65098220e-01f, 2.33658299e-01f, -5.04001975e-01f,
  6.75552547e-01f, -1.96005598e-01f, -2.04396229e-02f, -1.86785206e-01f, -3.12227681e-02f, 2.24260807e-01f, -1.58165678e-01f, -5.31605124e-01f, 6.33349419e-02f, 4.11199689e-01f,
  -4.00616556e-01f, 2.53370374e-01f, 4.13343072e-01f, 1.26551777e-01f, -6.03982270e-01f, -7.08823605e-03f, -1.17777484e-02f, 2.74807721e-01f, 3.88334654e-02f, -1.09201834e-01f,
  1.79157518e-02f, -3.93009000e-02f, 1.42343864e-01f, 2.38999166e-02f, 1.86533302e-01f, 1.75996423e-01f, 2.04689026e-01f, 7.89029151e-03f, 8.88697803e-02f, -3.67320981e-03f,
  5.56331798e-02f, 9.88667235e-02f, 1.23892352e-01f, 1.15586281e-01f, 3.29857826e-01f, 3.07793349e-01f, -1.05022274e-01f, 1.63393825e-01f, 1.66439205e-01f, 1.51172966e-01f,
  -1.12662679e-02f, 1.08102672e-01f, -4.41070199e-01f, 5.79642355e-01f, -3.21278036e-01f, 3.57620511e-03f, 3.26255471e-01f, -1.24722257e-01f, -3.36861312e-01f, 4.93132949e-01f,
  4.42023985e-02f, -1.01419471e-01f, -5.11168577e-02f, 3.61285985e-01f, -2.69475579e-01f, 4.72333431e-01f, 1.03471979e-01f, -2.65599310e-01f, -3.89295727e-01f, 3.11178237e-01f,
  -5.55798970e-02f, 1.26527762e-02f, 1.00853872e-02f, -1.21991277e-01f, 6.14297867e-01f, -4.49742585e-01f, 3.36020738e-01f, 5.79458103e-02f, -1.22924857e-01f, -1.17761493e-01f,
  -1.71576180e-02f, -5.71897686e-01f, 2.69409180e-01f, 6.49007797e-01f, -4.06037658e-01f, 6.40236735e-01f, 2.48428032e-01f, 4.14442331e-01f, 2.60872990e-01f, -2.72188872e-01f,
  8.34002867e-02f, 2.39427358e-01f, 1.14270613e-01f, 1.15964957e-01f, 3.23836416e-01f, 2.66672492e-01f, -2.17201293e-01f, 1.76922515e-01f, 2.95762479e-01f, 7.35026821e-02f,
  -1.20483562e-01f, 1.30001111e-02f, 4.80745882e-01f, 6.84483256e-03f, 3.22995067e-01f, 2.01193988e-01f, 5.20559819e-03f, 2.56018221e-01f, 1.96691245e-01f, 8.00755695e-02f,
  -1.04108334e-01f, 1.75334275e-01f, 6.80746511e-02f, 3.61785978e-01f, 1.47675827e-01f, -2.21183687e-01f, -4.44623798e-01f, -2.24353299e-01f, -1.54839322e-01f, -2.19669089e-01f,
  -4.36117887e-01f, -2.06963733e-01f, 2.02474296e-01f, 2.85828680e-01f, -1.41000137e-01f, -3.91418397e-01f, -3.58435333e-01f, -1.13514125e-01f, -4.18024123e-01f, -5.00140414e-02f,
  -6.17292643e-01f, 1.91047490e-01f, 1.24297980e-02f, 2.31463775e-01f, -4.00492042e-01f, 4.43252027e-01f, 2.74546415e-01f, 4.82768118e-01f, -1.29915208e-01f, 1.60154760e-01f,
  3.44148636e-01f, 7.13424504e-01f, -1.13413543e-01f, 1.79789692e-01f, 4.37021762e-01f, 4.75675948e-02f, 1.35031641e-01f, 4.05189097e-01f, 4.24281731e-02f, -1.31705076e-01f,
  -5.26036799e-01f, -4.71121877e-01f, 7.35555217e-02f, 4.83793139e-01f, 2.40499586e-01f, 5.21392887e-03f, 2.26565018e-01f, -2.96630058e-02f, 2.27003112e-01f, 1.87075615e-01f,
  1.06107503e-01f, 4.57773656e-01f, 7.41205290e-02f, 2.04755533e-02f, 1.85520262e-01f, 3.61467078e-02f, 1.49270475e-01f, 4.77280915e-02f, 1.61603004e-01f, 2.00188071e-01f,
  2.25294903e-01f, 6.86912215e-04f, 1.54953316e-01f, 1.92422315e-01f, -5.22922911e-02f, 3.17880251e-02f, -1.53338239e-01f, -1.46153957e-01f, 6.89663365e-02f, -3.39843363e-01f,
  -2.15815723e-01f, -4.38473463e-01f, 9.87870805e-03f, 4.50826854e-01f, 6.17105067e-01f, 2.22005412e-01f, 3.81249875e-01f, -5.10493577e-01f, -2.02339608e-03f, 3.79686236e-01f,
  -4.12506640e-01f, 1.37039915e-01f, -2.41131131e-02f, -2.51191795e-01f, -1.98149696e-01f, 5.54284990e-01f, 5.89795828e-01f, 1.82351187e-01f, -4.12170291e-01f, -2.01459855e-01f,
  -2.44674459e-01f, -2.25340724e-01f, -3.73787373e-01f, 3.90172154e-01f, -3.54630381e-01f, -9.50439796e-02f, 4.67743367e-01f, 2.64269888e-01f, 4.48619932e-01f, 5.58032513e-01f,
  -2.62786560e-02f, 1.10801905e-01f, -3.79816070e-02f, -5.78035414e-01f, 5.25973082e-01f, 1.56595349e-01f, -2.53016502e-01f, 4.00507689e-01f, 2.01278612e-01f, 4.20647934e-02f,
  1.88722640e-01f, 1.67679071e-01f, 1.79070942e-02f, 1.20176382e-01f, 6.10574968e-02f, 1.12735130e-01f, -2.65052188e-02f, -1.18452586e-01f, 1.13997206e-01f, 5.35047278e-02f,
  -3.75322938e-01f, 1.95615634e-01f, -9.10595357e-02f, 5.58503494e-02f, 2.74082460e-02f, -1.90992560e-02f, 1.54796824e-01f, -1.92538812e-03f, 2.05181226e-01f, 2.76345499e-02f,
  1.22491293e-01f, 1.27362847e-01f, 2.71801353e-01f, -1.90097690e-01f, -3.16222042e-01f, -7.17925057e-02f, 4.17043194e-02f, -3.61087292e-01f, 2.74307936e-01f, 5.21910012e-01f,
  3.86992425e-01f, 1.01134554e-01f, 1.50536865e-01f, 2.58113384e-01f, 3.23430508e-01f, 4.86045331e-01f, -4.17062873e-03f, 2.08531544e-02f, -1.25794500e-01f, -3.44979465e-01f,
  -3.95188928e-01f, 1.86746597e-01f, -1.39068142e-01f, 1.31661505e-01f, -2.25101948e-01f, 2.15978518e-01f, 2.90613264e-01f, -7.15904832e-02f, 7.37671554e-01f, -2.15014890e-01f,
  -3.87928575e-01f, 3.90623540e-01f, -1.88330617e-02f, -2.21347392e-01f, 2.09335342e-01f, -3.96943092e-01f, -3.16793740e-01f, 5.55534244e-01f, 4.29816902e-01f, 1.14904299e-01f,
  5.74235618e-01f, 2.09049657e-01f, 2.66730636e-01f, 3.09846759e-01f, 3.31670642e-01f, 2.94656545e-01f, 3.54489982e-01f, 2.65213460e-01f, -9.34653357e-03f, 2.19267398e-01f,
  3.14321935e-01f, 2.60397382e-02f, 6.28881380e-02f, 6.96166232e-02f, 3.47135104e-02f, 2.67433494e-01f, 7.14934170e-02f, 8.80237222e-02f, 3.45151462e-02f, 2.38745138e-01f,
  1.82752937e-01f, 1.42361909e-01f, 6.28151000e-02f, 1.72722861e-01f, -7.61316046e-02f, 3.19670260e-01f, 2.39309415e-01f, -5.36889285e-02f, 4.39671837e-02f, -2.97955334e-01f,
  2.65747756e-01f, 1.90271884e-01f, -1.03208683e-01f, 2.77810842e-01f, 3.98548335e-01f, -1.84290066e-01f, 5.83713278e-02f, 3.16403866e-01f, 1.04934931e-01f, 1.94259882e-01f,
  3.71175818e-02f, -5.26434958e-01f, -2.99018085e-01f, 2.68206950e-02f, 1.64485201e-01f, 1.70244455e-01f, -3.99349749e-01f, 3.58228862e-01f, 7.11834282e-02f, -2.90351827e-02f,
  -2.76898205e-01f, 3.61592710e-01f, 9.03361440e-02f, -1.03972480e-01f, 2.15257868e-01f, 4.65157956e-01f, 3.21148634e-01f, 1.70367032e-01f, -1.04769953e-01f, -1.34398520e-01f,
  2.82897949e-01f, -5.82462668e-01f, 1.50530025e-01f, -3.23076606e-01f, -1.82005152e-01f, 6.26720548e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.30605116e-01f, 1.27189592e-01f, 2.84218967e-01f, 2.28839576e-01f, 2.94095695e-01f, 1.97916850e-01f, 1.53063521e-01f, 2.59746492e-01f, 2.94089794e-01f, 2.16109514e-01f,
  2.25812763e-01f, 2.22239375e-01f, 2.35864386e-01f, 1.72641769e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.63205475e-01f, -2.31729999e-01f, 7.34966919e-02f, -2.54037604e-02f, -9.00218934e-02f, 1.13652132e-01f, -1.52916163e-01f, -3.15141119e-02f, 2.28563268e-02f, -2.42599650e-04f,
  1.66140050e-01f, -1.24678925e-01f, 1.00949094e-01f, 2.32643887e-01f, -2.23705489e-02f, 1.43062472e-01f, 1.61311089e-03f, 2.09295079e-02f, -8.06418359e-02f, -1.18023135e-01f,
  6.47350401e-02f, 6.63917363e-02f, -1.21233039e-01f, -8.25946704e-02f, -2.57292509e-01f, 2.80995935e-01f, 3.91987562e-01f, 1.57671854e-01f, 3.74797195e-01f, -3.48748237e-01f,
  3.34050268e-01f, -2.36364976e-01f, 5.32802902e-02f, 2.19472677e-01f, -4.53890622e-01f, -3.47482383e-01f, -2.71843851e-01f, 3.82613629e-01f, -3.34156514e-03f, 2.23275900e-01f,
  -2.75081426e-01f, 6.03845417e-01f, -5.25654793e-01f, -3.68066758e-01f, 3.54918659e-01f, 1.71404839e-01f, -3.69694322e-01f, -2.34862372e-01f, -3.87905806e-01f, -1.20606072e-01f,
  -1.75951347e-01f, 2.75248468e-01f, 2.48833299e-01f, -6.03499830e-01f, -3.34442109e-01f, 6.12705238e-02f, 1.95481226e-01f, 3.78219187e-01f, 6.00000396e-02f, 3.55369627e-01f,
  1.59235895e-01f, -5.60620189e-01f, -3.95212740e-01f, -2.92660534e-01f, -2.52448320e-01f, 6.86844140e-02f, -2.27752123e-02f, -3.43781449e-02f, 1.09471470e-01f, -3.08058321e-01f,
  1.16907686e-01f, 3.41732472e-01f, -7.24802632e-03f, 1.37463674e-01f, -2.18106598e-01f, -8.59829858e-02f, 4.76582386e-02f, -2.41566136e-01f, -2.11202785e-01f, -4.86459024e-02f,
  -9.11142603e-02f, 2.81251613e-02f, 1.74863145e-01f, 2.22344905e-01f, -1.34313077e-01f, -1.94284201e-01f, 6.90315068e-02f, -1.66443232e-02f, 9.08881873e-02f, 3.01435530e-01f,
  -1.50036409e-01f, -3.98960769e-01f, -6.50239438e-02f, -5.15358329e-01f, 2.51706600e-01f, 2.47057542e-01f, 8.73046294e-02f, -2.86620259e-01f, 3.21660966e-01f, -4.69504714e-01f,
  -3.16482067e-01f, -1.93318427e-01f, -1.76858962e-01f, 4.63261828e-02f, 3.84808242e-01f, 3.15876454e-01f, -3.96256179e-01f, 1.09407328e-01f, 3.71304184e-01f, -4.05935794e-01f,
  -3.86731029e-02f, -1.82053193e-01f, 1.32119358e-01f, -1.12268003e-02f, -1.61261901e-01f, 4.60531265e-01f, -4.44412380e-01f, -6.66411281e-01f, 5.89401536e-02f, 1.88929781e-01f,
  2.77574182e-01f, -3.37126225e-01f, -4.54718351e-01f, -4.76097226e-01f, 3.35711241e-01f, 1.70077801e-01f, -3.53185356e-01f, 1.57623321e-01f, 9.05675888e-02f, -9.05696675e-02f,
  -2.30438590e-01f, 1.10119343e-01f, 1.06353007e-01f, 1.97118372e-01f, 1.73213258e-01f, -1.14457168e-01f, 7.54135521e-03f, -3.18043202e-01f, -2.98638940e-02f, 3.91905829e-02f,
  1.75036460e-01f, -2.18749627e-01f, -1.17101772e-02f, -2.29520157e-01f, 1.22504808e-01f, -1.62517324e-01f, -5.02449945e-02f, -6.92878035e-04f, -1.03040235e-02f, -3.02426696e-01f,
  -8.69104266e-02f, 6.56293035e-02f, 6.80170655e-02f, -3.69296968e-01f, -3.66585590e-02f, 4.42298532e-01f, 4.18860704e-01f, 2.44713619e-01f, -4.36527878e-01f, 1.88806459e-01f,
  4.01687324e-01f, -3.42838556e-01f, -2.11755842e-01f, 2.23996103e-01f, -2.38032013e-01f, -1.05043530e-01f, -1.92453071e-01f, 3.52801204e-01f, -4.75020474e-03f, 2.27905422e-01f,
  -1.24719599e-02f, -2.41021395e-01f, -3.32388192e-01f, 5.80863833e-01f, -3.23020667e-01f, 4.28174794e-01f, 4.99142930e-02f, 2.65844256e-01f, -4.86116439e-01f, -4.41500217e-01f,
  -3.74933004e-01f, -5.33658504e-01f, 4.53603029e-01f, -5.21491349e-01f, 6.43036366e-02f, -3.10108513e-01f, -3.26210767e-01f, -2.26050198e-01f, -3.68352160e-02f, 4.04178619e-01f,
  -2.79901803e-01f, 3.39260042e-01f, -3.56349558e-01f, -3.82632732e-01f, -1.07078835e-01f, -1.81805357e-01f, 7.08661303e-02f, 2.58774191e-01f, 1.39472894e-02f, -3.21640134e-01f,
  1.68974802e-01f, 1.22147530e-01f, 2.27237538e-01f, -3.51749718e-01f, 7.17006326e-02f, -1.35277927e-01f, -3.07235122e-01f, 7.26044402e-02f, -3.47714067e-01f, -1.46117613e-01f,
  2.53469814e-02f, 3.13054621e-01f, -3.50667201e-02f, -1.43701732e-01f, 2.82811016e-01f, 5.50970100e-02f, 2.28788584e-01f, -1.84183359e-01f, 1.97228596e-01f, -2.14055106e-01f,
  -7.17212930e-02f, -3.99869114e-01f, -1.00894086e-01f, 4.64008987e-01f, -2.19988134e-02f, 3.14722717e-01f, -3.69468182e-02f, 4.75395620e-02f, 2.24494204e-01f, -1.60502702e-01f,
  7.10461810e-02f, -1.75608188e-01f, -3.96603793e-01f, -1.73183516e-01f, 1.75347447e-01f, -1.21366344e-01f, 1.75515383e-01f, 1.31685495e-01f, 2.08920971e-01f, -2.21553013e-01f,
  2.65923962e-02f, -8.76708105e-02f, -5.09893775e-01f, -4.40959811e-01f, 4.99784201e-02f, 2.61545479e-01f, -6.25127017e-01f, 1.81724682e-01f, -3.52104813e-01f, -1.50950655e-01f,
  2.44085833e-01f, 3.14377964e-01f, -5.07872164e-01f, -6.58449650e-01f, 3.74126166e-01f, -5.58734357e-01f, 3.58364880e-01f, 5.04783727e-02f, -3.68647091e-02f, 7.57712126e-02f,
  2.03615218e-01f, 9.73795056e-02f, 8.80538672e-02f, -8.44529048e-02f, 2.22363278e-01f, 1.01164505e-01f, -3.13432276e-01f, 2.83489674e-01f, -4.38660271e-02f, 2.99502704e-02f,
  3.40216100e-01f, -1.68045953e-01f, 2.13525727e-01f, 3.59200761e-02f, -1.91347569e-01f, 3.09751391e-01f, 1.20036684e-01f, -4.90244068e-02f, -1.07590798e-02f, -5.95676079e-02f,
  2.45083511e-01f, -1.10111333e-01f, 5.01304150e-01f, 3.09129246e-02f, -3.79005283e-01f, 2.52482384e-01f, -3.63680303e-01f, -4.24518615e-01f, -1.80028185e-01f, -1.81681722e-01f,
  2.46862069e-01f, 2.57079601e-01f, -4.81684618e-02f, 3.48848730e-01f, 5.03464758e-01f, 1.48057416e-01f, 4.20946747e-01f, -4.36463535e-01f, 3.20431888e-01f, -3.14170122e-01f,
  -1.96006134e-01f, 1.10820428e-01f, -1.63924024e-01f, -2.11380109e-01f, -3.39044362e-01f, -1.22928627e-01f, 5.50600946e-01f, -2.81232987e-02f, -9.64994952e-02f, 5.42262010e-02f,
  -1.01140454e-01f, -4.66339380e-01f, -3.93450201e-01f, -1.19749218e-01f, 5.49294651e-01f, 4.28863138e-01f, 2.37946808e-02f, -2.47668192e-01f, -3.36005330e-01f, -4.39451009e-01f,
  -1.73014164e-01f, 2.86831111e-01f, -9.23405811e-02f, 1.99736863e-01f, 7.51689374e-02f, -5.19064255e-02f, 8.33585784e-02f, -2.34482855e-01f, -2.03560784e-01f, 2.05750540e-01f,
  2.76232183e-01f, 3.10424089e-01f, -2.58189160e-02f, 1.87405199e-01f, -2.42840033e-02f, 1.80428877e-01f, -1.92060266e-02f, 1.82560027e-01f, 1.59054726e-01f, 3.89257163e-01f,
  3.33636217e-02f, 2.82381475e-01f, -6.04658574e-02f, -1.28218010e-01f, -2.09433615e-01f, 4.80408490e-01f, -4.50377643e-01f, -3.49125750e-02f, 4.89714593e-01f, 1.71991274e-01f,
  3.83318007e-01f, -2.22027496e-01f, -2.80737072e-01f, 4.03601617e-01f, -3.23801786e-01f, 2.48703927e-01f, 8.41921419e-02f, -4.86801974e-02f, 8.81468579e-02f, 3.34124029e-01f,
  -5.87405205e-01f, -3.99832308e-01f, 4.94509578e-01f, 5.24026871e-01f, -9.53916460e-02f, -2.87266940e-01f, 2.93159127e-01f, -9.52378362e-02f, 4.03810441e-01f, -3.05737108e-01f,
  5.20783484e-01f, 2.48984128e-01f, 1.44917861e-01f, 2.43885785e-01f, -5.60418427e-01f, 3.48809361e-02f, 3.89095932e-01f, -3.11917365e-01f, -5.87522745e-01f, -3.28837156e-01f,
  -5.88179193e-02f, -2.26979002e-01f, -2.68056422e-01f, -9.72892269e-02f, 1.83795169e-01f, -2.60437399e-01f, -1.15325423e-02f, 3.16446796e-02f, 3.01187448e-02f, 8.49892423e-02f,
  9.25607234e-02f, 3.55182290e-01f, 1.09028958e-01f, 1.33198693e-01f, 2.72073969e-02f, -1.35747775e-01f, -1.97199613e-01f, 1.24075249e-01f, 8.79518036e-03f, -5.59756830e-02f,
  9.61504951e-02f, 1.47561148e-01f, 1.81593940e-01f, -2.95188367e-01f, 1.35831431e-01f, 8.18903893e-02f, -5.65572195e-02f, -7.27645904e-02f, 7.32488260e-02f, 7.51385391e-02f,
  -2.86564410e-01f, -4.15713280e-01f, -2.88525552e-01f, 3.43770653e-01f, -3.75219345e-01f, -3.05288166e-01f, 1.53784916e-01f, -5.72032690e-01f, 2.93277621e-01f, 2.70585209e-01f,
  5.33428073e-01f, -2.96227962e-01f, 2.50312984e-01f, 2.94147521e-01f, 3.64086181e-01f, -5.03015101e-01f, -4.72681016e-01f, 2.75730014e-01f, -1.77878112e-01f, -6.50672972e-01f,
  4.44443315e-01f, -4.29127783e-01f, 3.28625768e-01f, -4.27341849e-01f, -4.17650759e-01f, -3.25153738e-01f, 1.33715391e-01f, 2.51927167e-01f, 1.67247299e-02f, -3.14369589e-01f,
  -1.56171322e-01f, -1.86696842e-01f, -4.00018632e-01f, -2.37485558e-01f, -5.98545134e-01f, 6.10518396e-01f, -4.09958392e-01f, 8.86779502e-02f, -1.44662976e-01f, -1.48492947e-01f,
  -2.14191452e-01f, -2.11445689e-01f, 9.87868942e-03f, -2.04975560e-01f, 6.03143387e-02f, -1.32516056e-01f, -2.11285129e-01f, -4.23821397e-02f, 1.21391699e-01f, -1.84921294e-01f,
  -1.99932516e-01f, 1.43725611e-02f, 2.17141047e-01f, 4.37624641e-02f, -4.19184007e-02f, -2.20032528e-01f, -5.97844310e-02f, -2.72722572e-01f, -1.55950217e-02f, -2.65945662e-02f,
  -2.10656092e-01f, -1.78303814e-03f, 2.78592762e-02f, -1.70100480e-01f, -3.54789883e-01f, -4.03346457e-02f, -4.53235488e-03f, -8.58804658e-02f, -6.48409650e-02f, -2.51090944e-01f,
  6.91429824e-02f, 7.93842822e-02f, -2.46303305e-01f, -2.58199006e-01f, 1.06958993e-01f, -1.94604605e-01f, -2.71931827e-01f, -1.21257506e-01f, -3.30301285e-01f, 2.31477544e-02f,
  1.43681705e-01f, 3.57432663e-01f, 2.92539336e-02f, 2.62949497e-01f, -2.46050954e-03f, 3.71827006e-01f, -2.86048889e-01f, 2.82237172e-01f, 3.91888827e-01f, -5.11583805e-01f,
  2.32555136e-01f, 1.04439527e-01f, 5.21584749e-02f, -5.55880249e-01f, -3.13897967e-01f, 1.08783662e-01f, -7.01573312e-01f, 2.79312819e-01f, 5.20088486e-02f, -2.39725873e-01f,
  4.62739497e-01f, -3.25874001e-01f, 1.64515316e-01f, 4.75084893e-02f, -1.69018820e-01f, 1.58687517e-01f, -1.14696026e-01f, 1.69797614e-01f, -2.99689680e-01f, 1.21432599e-02f,
  -2.60147057e-03f, 1.88436165e-01f, 8.81008506e-02f, -3.17925066e-01f, -4.14346933e-01f, -1.53888881e-01f, -7.12138638e-02f, 1.38918474e-01f, -1.26502961e-01f, 1.67713389e-01f,
  6.54985905e-02f, 1.30761936e-01f, -6.48732185e-02f, -2.10592479e-01f, -1.41983882e-01f, -3.05995554e-01f, -2.46320710e-01f, 2.73938149e-01f, -3.17951441e-01f, 3.63436341e-01f,
  8.39485973e-02f, 3.26720983e-01f, 2.17110530e-01f, 2.83460349e-01f, 2.57105172e-01f, 3.34990144e-01f, -2.76436545e-02f, -1.66256428e-01f, 3.84973288e-01f, -2.07164630e-01f,
  -1.45643070e-01f, -4.91688371e-01f, 1.78535674e-02f, 2.70331383e-01f, -2.14684457e-01f, 3.67026508e-01f, 2.02363625e-01f, -2.96943277e-01f, -1.06423169e-01f, 2.83087313e-01f,
  -3.34408224e-01f, -3.20391715e-01f, -1.96851313e-01f, -3.93756390e-01f, -1.47804365e-01f, -3.31082433e-01f, 1.36421323e-01f, 4.75478247e-02f, -5.71563780e-01f, 6.21672869e-01f,
  -5.33588529e-01f, -3.51033688e-01f, 3.85906458e-01f, -7.87130967e-02f, -2.18809977e-01f, 2.33430684e-01f, -3.23940404e-02f, 1.84609771e-01f, 1.16044141e-01f, -2.00971842e-01f,
  1.77510187e-01f, -4.19008136e-02f, -1.91088244e-01f, -7.17891604e-02f, -1.31225707e-02f, -2.57132024e-01f, -3.10427129e-01f, 1.54310405e-01f, 1.57783151e-01f, -1.13227859e-01f,
  -1.20844781e-01f, -2.10607946e-01f, -1.47910975e-02f, 1.78685233e-01f, 1.28091320e-01f, -3.72059703e-01f, -2.02819854e-02f, 2.49491885e-01f, 2.66310543e-01f, 5.71611933e-02f,
  3.82721573e-02f, -4.48279917e-01f, -3.03276032e-01f, 2.30341703e-01f, -3.40886235e-01f, -2.70736497e-02f, -2.31368318e-01f, -6.08493388e-02f, -3.76388401e-01f, 5.05316257e-01f,
  2.66814888e-01f, 1.03968740e-01f, -4.29072380e-01f, 6.74329549e-02f, -3.95853609e-01f, 1.61232993e-01f, 2.29794323e-01f, 3.95107657e-01f, -2.23945901e-01f, -3.47244620e-01f,
  1.64278954e-01f, 5.93549252e-01f, 2.32544437e-01f, 2.02874407e-01f, 2.10377738e-01f, 6.27690256e-01f, 5.63919283e-02f, 1.74297914e-01f, 2.17189312e-01f, 3.33563209e-01f,
  4.70859021e-01f, -4.02569771e-01f, 2.52720594e-01f, -1.49864435e-01f, -2.66829818e-01f, -4.02212590e-01f, -6.47901356e-01f, -5.86321533e-01f, -2.98622876e-01f, 5.62915159e-03f,
  -9.20717865e-02f, 2.07034498e-01f, 2.14642346e-01f, -7.67812179e-03f, 1.09649591e-01f, -2.97136903e-01f, -2.44747728e-01f, 2.01810837e-01f, -8.23546350e-02f, -3.78508300e-01f,
  1.30305395e-01f, 2.38180041e-01f, -2.41944492e-02f, 1.69257224e-01f, 6.02500625e-02f, -1.04015633e-01f, -8.08920115e-02f, -3.17953974e-02f, -2.31686197e-02f, 1.69433638e-01f,
  7.63462931e-02f, 2.44753182e-01f, 8.75554420e-03f, 2.89815720e-02f, 6.48989305e-02f, -2.61898339e-01f, 3.19623709e-01f, 4.79986481e-02f, -3.65397215e-01f, -4.19066757e-01f,
  3.08169425e-01f, 2.39213943e-01f, -3.62319872e-02f, -5.42870939e-01f, 1.81437552e-01f, -9.39473212e-02f, 1.12436920e-01f, 2.67092079e-01f, 2.93351471e-01f, -1.52645007e-01f,
  2.85212725e-01f, -3.10080588e-01f, 2.69785315e-01f, -6.51470125e-02f, 2.08982319e-01f, 1.04121007e-01f, -1.15191728e-01f, 3.50806117e-01f, 1.40862152e-01f, 2.47442722e-01f,
  -5.41215539e-01f, -3.63725424e-01f, -4.36126590e-01f, -1.98494866e-01f, -6.39576837e-02f, 3.58330011e-01f, -3.14582914e-01f, 1.00053987e-02f, 6.94772080e-02f, -5.74009605e-02f,
  2.44561687e-01f, -2.62243509e-01f, 3.30192924e-01f, 3.82704854e-01f, 1.41832396e-01f, 2.31660008e-01f, 4.77093346e-02f, 5.06702438e-02f, -1.34567901e-01f, 3.70300263e-02f,
  3.57965343e-02f, -1.77703440e-01f, 5.67609780e-02f, 1.72720682e-02f, -2.56385177e-01f, -1.02980152e-01f, -2.16052637e-01f, -8.56571794e-02f, -1.32124349e-01f, -1.07208602e-01f,
  9.34608430e-02f, -2.01230809e-01f, -7.66934380e-02f, -2.39351720e-01f, -1.62349910e-01f, -1.13989435e-01f, -1.39859304e-01f, 8.11440349e-02f, -2.47404069e-01f, -1.51765972e-01f,
  2.03047425e-01f, -1.23924397e-01f, 5.37587285e-01f, 2.70454258e-01f, 1.08792454e-01f, 2.77394325e-01f, -1.39472922e-02f, -8.95514637e-02f, -1.41101748e-01f, 1.00485727e-01f,
  1.42060593e-01f, -9.57923904e-02f, -2.44808391e-01f, -2.56788373e-01f, -3.57926667e-01f, 5.24125278e-01f, 2.31910840e-01f, -2.08539471e-01f, 2.02327725e-02f, -2.25385666e-01f,
  1.98345020e-01f, -2.24761769e-01f, 9.97645706e-02f, -1.14812374e-01f, 1.07215352e-01f, -1.38550490e-01f, -1.13643510e-02f, -3.87268923e-02f, -5.41041374e-01f, 2.29880676e-01f,
  -4.87119257e-01f, 3.80697966e-01f, 3.48165870e-01f, -1.46334812e-01f, -5.63588083e-01f, 4.15693015e-01f, -4.70206793e-03f, 2.41339117e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -8.85088816e-02f, -1.39367118e-01f, -1.04645073e-01f, 5.37822675e-03f, 7.34932497e-02f, 1.26226947e-01f, 1.70084402e-01f, -1.08914062e-01f, 9.76412147e-02f, -5.38284779e-02f,
  -8.72420147e-02f, -7.89102539e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    