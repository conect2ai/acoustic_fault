/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.39849734e-01f, -1.15280062e-01f, -4.13499810e-02f, 1.15098402e-01f, -3.03223163e-01f, -2.23971680e-01f, -2.97996044e-01f, 5.38223200e-02f, 1.08090967e-01f, -1.22302845e-01f,
  3.01521346e-02f, 1.82053134e-01f, 1.18243575e-01f, 8.24687108e-02f, 2.16253802e-01f, -6.85688108e-02f, -1.14689894e-01f, 9.95625183e-02f, 2.09178925e-01f, 6.86735287e-02f,
  1.46634262e-02f, -1.18914060e-02f, 2.34798178e-01f, 1.48741812e-01f, -8.40345025e-02f, 4.92449701e-02f, -2.05285162e-01f, -1.01899624e-01f, -1.07301109e-01f, -1.20540485e-02f,
  4.04535942e-02f, 3.77178937e-02f, 1.33914456e-01f, 6.96076155e-02f, -1.23580754e-01f, 2.90772617e-02f, -2.28506755e-02f, 2.02528983e-02f, -7.69298300e-02f, 3.19982991e-02f,
  -2.27654185e-02f, 4.49480563e-02f, 7.19805658e-02f, -1.91594958e-02f, 3.76101583e-02f, 7.65557811e-02f, -3.45478691e-02f, 5.87171242e-02f, -5.61719015e-02f, -4.63983379e-02f,
  -7.72469044e-02f, -7.20743686e-02f, -3.07253022e-02f, -6.79278895e-02f, 1.20851379e-02f, -6.61883578e-02f, -5.49613945e-02f, 5.73381074e-02f, -4.54699509e-02f, 3.78126986e-02f,
  6.35720268e-02f, 5.34336418e-02f, -2.32172385e-02f, -2.34288499e-02f, 3.67071703e-02f, -6.15518875e-02f, 6.36184514e-02f, 2.86988690e-02f, 4.79776450e-02f, 1.85987353e-02f,
  4.95838467e-03f, -8.21462125e-02f, 5.63931614e-02f, -3.53360623e-02f, 1.43029038e-02f, -1.45003675e-02f, 1.19473338e-02f, 2.77173761e-02f, -2.66993791e-02f, -2.81396415e-02f,
  2.52053756e-02f, 9.03037470e-03f, 3.45059261e-02f, 6.01196587e-02f, -4.22852971e-02f, 2.00482532e-02f, -4.01953459e-02f, -4.00436893e-02f, -7.22042397e-02f, -9.64426529e-03f,
  1.11060068e-02f, -5.26779005e-03f, 5.93484454e-02f, 8.07690173e-02f, -3.61158662e-02f, 2.18030103e-02f, 3.89471017e-02f, -2.16545090e-02f, -4.03922573e-02f, -3.51719838e-03f,
  6.42200047e-03f, 5.77516407e-02f, -3.48379947e-02f, 4.89520095e-02f, -2.72871349e-02f, -2.92323790e-02f, 2.35791486e-02f, 6.84338585e-02f, -3.58974598e-02f, -2.59374902e-02f,
  -7.23666400e-02f, 3.76406759e-02f, -9.18438807e-02f, -2.57860944e-02f, 3.37601490e-02f, 1.02204509e-01f, -1.11108862e-01f, 2.92429291e-02f, -6.76470692e-04f, -1.28193572e-01f,
  1.81579068e-01f, 9.89259034e-02f, -1.05595626e-01f, 3.62912845e-03f, -4.48183045e-02f, 7.58748055e-02f, 1.34594500e-01f, 7.04528857e-03f, 2.23940387e-02f, 7.52797490e-03f,
  -1.63485527e-01f, -4.04566638e-02f, -4.30852873e-03f, 6.08405843e-02f, 2.66028736e-02f, 8.79449993e-02f, -2.62350421e-02f, 8.34033415e-02f, 8.56719986e-02f, -3.59104015e-02f,
  1.14592900e-02f, 1.27384201e-01f, 6.29184246e-02f, 5.50529882e-02f, 6.11458793e-02f, 2.67323330e-02f, -9.09131113e-03f, 9.91459563e-02f, -9.60242376e-02f, -8.29435661e-02f,
  -5.48197776e-02f, -9.08781812e-02f, 1.03809461e-02f, 6.84101656e-02f, -1.28327208e-02f, -3.58374268e-02f, -1.31067522e-02f, -1.65263414e-02f, -3.80023047e-02f, -2.41343840e-03f,
  -2.38720197e-02f, -1.36553764e-01f, -6.24191854e-03f, -4.61635403e-02f, -6.38692528e-02f, 4.59591635e-02f, 8.66878033e-02f, 9.10270661e-02f, 2.18442213e-02f, 4.66153882e-02f,
  5.72562702e-02f, 5.46570756e-02f, 9.13245454e-02f, 8.49162340e-02f, -3.91552523e-02f, 2.02931408e-02f, -3.59613746e-02f, 9.05589492e-04f, 2.81739850e-02f, 1.27224321e-03f,
  -1.74346995e-02f, -6.44784123e-02f, 2.19760071e-02f, 4.49984930e-02f, -6.76617771e-02f, 2.50012288e-03f, -2.00950336e-02f, -7.80779347e-02f, 1.88428219e-02f, 4.95174825e-02f,
  -3.40312198e-02f, 2.22855695e-02f, 1.17593473e-02f, -5.04237376e-02f, 1.37783373e-02f, 7.89307407e-04f, 2.54377536e-02f, 4.47551347e-02f, 1.60985943e-02f, -9.92820263e-02f,
  -5.44239841e-02f, -3.19749489e-02f, -1.63886379e-02f, -2.43619978e-02f, 3.60771939e-02f, 4.95452955e-02f, -2.67676152e-02f, 9.11532789e-02f, 7.16937035e-02f, -5.09657227e-02f,
  5.43670021e-02f, -1.13439038e-01f, -1.76246017e-02f, 1.66576598e-02f, 5.55732148e-03f, 1.82985533e-02f, 2.84077413e-02f, 5.34493215e-02f, -5.09308204e-02f, -3.68527658e-02f,
  4.46063429e-02f, -4.06282619e-02f, -3.35426219e-02f, 2.38635112e-02f, 3.74144763e-02f, 7.65657378e-03f, 1.31823830e-02f, -5.61340526e-02f, 1.44082960e-02f, 1.16561428e-01f,
  1.11124456e-01f, 7.28916526e-02f, 1.28193185e-01f, 9.53863487e-02f, 1.01378851e-01f, 8.94075111e-02f, -4.55242023e-02f, 6.19395077e-02f, 1.44521922e-01f, 1.40067771e-01f,
  1.21279813e-01f, 1.37374118e-01f, -8.82394165e-02f, 1.28514707e-01f, -1.39266893e-01f, -2.60584921e-01f, -1.79449245e-01f, -6.41311780e-02f, 4.64754589e-02f, 8.88562053e-02f,
  -2.68990956e-02f, 2.77727768e-02f, 9.08533558e-02f, 5.62268719e-02f, -8.08273479e-02f, -8.30870122e-02f, 6.05438687e-02f, -7.81176388e-02f, -2.11046666e-01f, -1.82229802e-01f,
  -5.38852699e-02f, 4.79306914e-02f, 1.32190049e-01f, 2.75157765e-02f, 1.60860792e-02f, 5.67962043e-02f, -4.76355888e-02f, 3.24135646e-02f, -2.99236197e-02f, 1.69474393e-01f,
  -7.27207139e-02f, 7.57303759e-02f, -1.64498407e-02f, 9.89118889e-02f, -8.31022765e-03f, 3.98950739e-04f, 1.44389430e-02f, 1.03697414e-02f, 3.45786661e-03f, -7.37355207e-04f,
  -2.04962846e-02f, -4.27943356e-02f, -1.16672739e-02f, -6.07220381e-02f, -5.09392098e-02f, 1.57323014e-02f, 6.16952106e-02f, 6.61331862e-02f, -7.61232600e-02f, -4.72355187e-02f,
  2.69017518e-02f, 4.84060384e-02f, -1.24893486e-01f, -1.05947509e-01f, -7.84883872e-02f, 9.15427878e-02f, -1.29518686e-02f, -6.39449209e-02f, -2.82942615e-02f, 2.30262969e-02f,
  -2.20275484e-02f, -5.72542511e-02f, 8.03771801e-03f, -3.14055756e-02f, 3.36277224e-02f, -4.68468517e-02f, -5.12483902e-02f, -2.02528685e-02f, -1.21329054e-02f, 1.01343598e-02f,
  -1.53039936e-02f, 4.32258993e-02f, -1.36256795e-02f, -8.30772426e-03f, 4.94369529e-02f, -2.38765683e-02f, -5.63221611e-02f, 5.76771051e-02f, 4.00066115e-02f, 1.02754265e-01f,
  -7.85270780e-02f, -1.35019049e-02f, 7.63887390e-02f, -1.61158834e-02f, 4.90367338e-02f, 4.72351760e-02f, 2.41540521e-02f, -5.76218851e-02f, -5.05864397e-02f, -4.78838533e-02f,
  3.26258899e-03f, -6.88755438e-02f, 1.91757120e-02f, -4.31992672e-02f, 6.60014013e-03f, 6.23488091e-02f, 1.03837601e-03f, 3.39919403e-02f, -3.11339721e-02f, 6.66229567e-03f,
  -7.69693404e-02f, -5.34303375e-02f, -5.25210910e-02f, 5.44150062e-02f, -8.51823762e-02f, -6.87267780e-02f, -2.60031037e-02f, -5.13252318e-02f, -8.82278755e-02f, -6.37147948e-02f,
  6.48266450e-02f, 7.58185610e-03f, -1.67522416e-01f, -7.53585920e-02f, 2.16451730e-03f, -4.72863652e-02f, -1.70001924e-01f, -2.30005048e-02f, -1.44104972e-01f, -2.24822730e-01f,
  2.67752200e-01f, 6.46147355e-02f, 1.35355935e-01f, 2.88716465e-01f, 2.63967574e-01f, 1.23245686e-01f, 1.50248230e-01f, 4.96047214e-02f, 4.14272100e-02f, 2.95605399e-02f,
  4.83152457e-02f, 2.87870914e-02f, 7.85481334e-02f, -7.12528229e-02f, 8.54961649e-02f, 2.39278059e-02f, 1.89423710e-01f, 7.19304234e-02f, 1.14748098e-01f, 2.01233163e-01f,
  1.08418666e-01f, 1.00946024e-01f, 7.37654120e-02f, 9.39870551e-02f, -1.01738945e-02f, 5.54777309e-02f, 3.38127650e-02f, 8.02641287e-02f, 1.07613783e-02f, 2.83883861e-03f,
  3.24899442e-02f, 1.03685841e-01f, 3.61296982e-02f, -7.52523020e-02f, 5.06624058e-02f, 2.07540998e-03f, 2.27214564e-02f, 5.54932430e-02f, -1.32051688e-02f, 4.43335902e-03f,
  4.58485931e-02f, -5.85866161e-02f, 1.09468345e-02f, 1.08864754e-02f, -3.31689678e-02f, 8.01157132e-02f, -2.77444348e-02f, 1.07596340e-02f, -2.89101303e-02f, -8.87592435e-02f,
  -2.64401510e-02f, 7.98743069e-02f, -5.83861805e-02f, 3.96485440e-02f, 7.32479468e-02f, 4.53974726e-03f, -5.63444421e-02f, 4.25447673e-02f, -2.63047889e-02f, 1.15579460e-02f,
  -7.96024874e-02f, -8.50305893e-03f, 1.03648482e-02f, -1.53241754e-02f, -2.64031161e-02f, 1.84919443e-02f, -5.70224784e-02f, -4.67051342e-02f, -3.75596955e-02f, -4.14420404e-02f,
  -9.42195207e-03f, 3.80888395e-02f, -3.35322879e-02f, 6.45442382e-02f, -6.35082368e-03f, 1.20206643e-02f, -7.94833228e-02f, 2.18591057e-02f, -8.27760901e-03f, -1.04145207e-01f,
  5.11287749e-02f, -3.12094446e-02f, 6.26430335e-03f, -3.90716605e-02f, 4.30525132e-02f, 5.55657782e-02f, 7.21055195e-02f, -5.07396571e-02f, -3.35550588e-03f, 4.67456579e-02f,
  -9.34816673e-02f, -6.34310544e-02f, 7.86579326e-02f, 5.17458059e-02f, -8.82747620e-02f, -5.13513088e-02f, 4.27569225e-02f, 2.65649483e-02f, 4.43354100e-02f, -3.92759964e-02f,
  3.61165926e-02f, -1.00733735e-01f, -5.72001450e-02f, -8.00550506e-02f, 1.73130762e-02f, -2.31455266e-02f, -3.63199180e-03f, 1.75714400e-02f, -9.13675204e-02f, 2.42434330e-02f,
  -1.24671002e-04f, -9.35831945e-03f, -1.85071658e-02f, 1.18564293e-02f, -4.04559299e-02f, -6.19007908e-02f, -3.05748302e-02f, -7.64294788e-02f, -2.30493080e-02f, 5.69015881e-03f,
  -1.65531427e-01f, 2.66770478e-02f, -1.48171186e-01f, -1.36768430e-01f, -7.50104636e-02f, 2.68168282e-02f, 4.33117850e-03f, 1.80318877e-02f, 1.28006432e-02f, -4.13131975e-02f,
  2.28272546e-02f, -3.21829598e-03f, -7.81869814e-02f, -2.00214777e-02f, 3.65097374e-02f, -7.89243951e-02f, 2.80060433e-02f, -1.62577882e-01f, -1.74371526e-02f, -1.40243515e-01f,
  -1.04243279e-01f, -1.89140975e-01f, -1.36053944e-02f, 4.12820652e-03f, -8.14762861e-02f, 3.12262382e-02f, -8.52832869e-02f, -8.42181519e-02f, -1.47124678e-02f, -2.69692749e-01f,
  -1.67537913e-01f, -1.53805912e-01f, -9.16134194e-02f, 5.04353046e-02f, 2.61843242e-02f, 1.14588760e-01f, -1.87778305e-02f, -1.00509776e-02f, 7.70575255e-02f, -5.59109338e-02f,
  -5.38507923e-02f, 7.64436871e-02f, -1.35103175e-02f, 3.86191420e-02f, 3.83952516e-03f, -9.15241018e-02f, -6.79444801e-03f, -2.68731825e-02f, 3.46661098e-02f, -2.79487856e-02f,
  -7.12069348e-02f, 2.51904665e-03f, -2.39907801e-02f, 6.49090409e-02f, -2.00060774e-02f, -3.00285197e-03f, -6.66765571e-02f, 4.20106575e-02f, 1.09206080e-01f, 7.88559485e-03f,
  2.76018563e-03f, 6.51094988e-02f, -4.25913185e-02f, -3.84903550e-02f, 2.94387285e-02f, 7.14931265e-02f, -6.44865111e-02f, -1.21175107e-02f, 4.71857004e-02f, -1.39590260e-02f,
  -6.98975287e-03f, -6.58151694e-04f, -1.34016620e-02f, 1.63610037e-02f, -8.29004645e-02f, 2.09568776e-02f, 5.57394773e-02f, 1.49491020e-02f, -5.42966761e-02f, -3.28364708e-02f,
  -5.29266708e-02f, 5.08197863e-03f, 1.48685835e-02f, 3.18207890e-02f, 1.67963319e-02f, -1.18020410e-02f, 3.69978435e-02f, -1.26074478e-02f, -2.14029998e-02f, 2.38755867e-02f,
  7.14320987e-02f, 2.87115294e-02f, -3.84082124e-02f, 4.38339449e-03f, -3.67644802e-02f, 2.39546574e-03f, -8.19298401e-02f, 1.69434100e-02f, -3.53790224e-02f, -6.11666441e-02f,
  4.26016096e-03f, -3.49108479e-03f, -1.67662427e-02f, 1.52587481e-02f, 1.24840513e-02f, 1.55052310e-02f, 5.53123131e-02f, -3.83826345e-02f, -6.90273643e-02f, -9.66711342e-03f,
  3.58628854e-02f, 8.02550316e-02f, 2.67553031e-02f, 3.62974927e-02f, 2.35265289e-02f, -9.14691165e-02f, -3.60304154e-02f, 1.85164846e-02f, 1.15447477e-01f, 1.44861460e-01f,
  1.77186187e-02f, 2.48956397e-01f, 7.23587628e-03f, -4.74949032e-02f, 4.83884662e-02f, -2.88068783e-02f, 2.81613190e-02f, -7.74098113e-02f, -1.25829712e-01f, 5.74593730e-02f,
  8.39436427e-02f, -1.00566661e-02f, 2.34260820e-02f, 1.00886494e-01f, 7.39818588e-02f, 4.90821786e-02f, 1.18262731e-01f, -1.58964992e-02f, -2.15711474e-01f, -1.34322450e-01f,
  -5.64217009e-02f, -5.09540029e-02f, -4.86651585e-02f, 3.82807925e-02f, -1.42486067e-02f, -1.63117200e-01f, -1.21032462e-01f, 1.07018061e-01f, -1.46532068e-02f, 1.78396627e-02f,
  -1.36408195e-01f, 1.89254567e-01f, -9.63954162e-03f, 1.70021765e-02f, -1.59586221e-02f, -8.18114951e-02f, -6.32960647e-02f, 4.10633050e-02f, 3.12583819e-02f, -1.59660745e-02f,
  9.54598412e-02f, 4.48150709e-02f, 7.35572875e-02f, 5.73695116e-02f, -5.35666049e-02f, -5.38527593e-02f, 4.67026830e-02f, 7.52181336e-02f, 2.47214437e-02f, 3.48929092e-02f,
  1.71939850e-01f, 8.09658468e-02f, 4.16447036e-02f, 2.42653564e-02f, -6.84269797e-03f, 6.86242431e-02f, 1.06958501e-01f, -3.00209243e-02f, 1.17678843e-01f, -1.08309425e-01f,
  -2.09640823e-02f, -1.99201144e-02f, 6.20416738e-02f, -2.46198364e-02f, -5.70966266e-02f, -2.12401133e-02f, 2.18565986e-02f, -3.72606190e-03f, 3.71591374e-02f, -8.27179626e-02f,
  5.88086732e-02f, -8.15664753e-02f, -4.44975421e-02f, 3.78249097e-03f, -7.76188001e-02f, 5.63296378e-02f, -3.55678573e-02f, 8.07246007e-03f, 6.45614639e-02f, 4.49150950e-02f,
  -5.96832950e-03f, -9.80427116e-03f, -8.07335787e-03f, 4.20031250e-02f, 3.87993976e-02f, 6.38586730e-02f, -4.31659371e-02f, -4.59751934e-02f, -3.67785841e-02f, 2.85053048e-02f,
  -3.41608375e-01f, 3.20337236e-01f, -1.38877496e-01f, -4.70971391e-02f, 4.21611853e-02f, -2.64670737e-02f, 5.09536527e-02f, 1.04348511e-01f, 3.88546363e-02f, -7.73174390e-02f,
  1.17988519e-01f, -5.82039319e-02f, 5.06346226e-02f, 5.89364842e-02f, -6.96463212e-02f, -5.79378717e-02f, -3.57743129e-02f, -4.85019162e-02f, -3.60842496e-02f, -5.22517860e-02f,
  -2.68601812e-02f, -1.85392633e-01f, -1.39877841e-01f, -8.67252201e-02f, 1.65188238e-02f, -1.89903632e-01f, -1.86967522e-01f, -1.61451727e-01f, -1.50306314e-01f, -2.71086723e-01f,
  5.22613823e-01f, 1.98892709e-02f, -3.19118425e-02f, 1.43880948e-01f, -1.49127260e-01f, -8.74122083e-02f, -1.83143139e-01f, -6.76461086e-02f, 2.00018696e-02f, -1.36477535e-03f,
  -9.82556771e-03f, -8.03137869e-02f, -4.95021157e-02f, 5.28381281e-02f, -6.57982901e-02f, -1.14196114e-01f, -1.34439319e-01f, 1.63273349e-01f, 3.83006036e-02f, -6.50163963e-02f,
  -5.76866530e-02f, 1.66650876e-01f, 1.55653551e-01f, 9.10828710e-02f, 2.77305432e-02f, 3.16936038e-02f, 1.71775371e-03f, 1.02447264e-01f, -1.80879012e-02f, -3.75755294e-03f,
  1.54000521e-01f, 1.05066136e-01f, -4.39968742e-02f, 2.07131114e-02f, -7.45312602e-04f, 1.15266643e-01f, -1.07695209e-02f, 2.58304644e-02f, 8.72403011e-02f, 7.16591403e-02f,
  -2.45014974e-03f, -6.69152588e-02f, 9.18084849e-03f, 1.14324139e-02f, 5.15154041e-02f, 3.90897021e-02f, 3.13918702e-02f, 4.02291790e-02f, 6.76409230e-02f, 5.95378727e-02f,
  -9.39065740e-02f, 8.09759423e-02f, 3.80808488e-02f, -4.66270112e-02f, 2.18734685e-02f, 9.77444351e-02f, 5.87606337e-03f, 1.67047381e-02f, 2.18635388e-02f, 6.77373037e-02f,
  -1.04670562e-01f, 2.14303695e-02f, -2.81514358e-02f, 1.34799816e-02f, -5.83354980e-02f, 5.37403673e-02f, -1.60558764e-02f, 2.60017756e-02f, -1.62865187e-03f, -2.84515042e-02f,
  1.16538808e-01f, 1.26473345e-02f, 7.21239224e-02f, -5.87923713e-02f, 3.40149589e-02f, 6.25474751e-02f, 6.44049868e-02f, -4.11269516e-02f, -4.34779003e-02f, 2.44052950e-02f,
  -1.91831104e-02f, 5.63888159e-03f, -1.28243596e-03f, -8.69845133e-03f, 6.78236783e-03f, 5.63530773e-02f, 7.04976097e-02f, -4.71752882e-02f, -1.33393323e-02f, 7.22023547e-02f,
  2.72598825e-02f, -5.48734628e-02f, 8.03634804e-03f, -5.78806214e-02f, 6.76908111e-03f, -4.65764031e-02f, 9.64431390e-02f, 2.23794766e-02f, -8.43856891e-04f, 1.99629162e-02f,
  3.60039994e-02f, -6.16068626e-03f, 2.09138123e-03f, 1.63472984e-02f, 5.62816486e-02f, 3.34436595e-02f, -5.56618199e-02f, 1.57134626e-02f, -3.33319902e-02f, 5.73503934e-02f,
  -8.93663391e-02f, -7.71994814e-02f, 6.90278709e-02f, -5.61316907e-02f, -9.28232297e-02f, -4.76905741e-02f, 4.80429716e-02f, -9.83162969e-02f, -5.70501164e-02f, -6.00414239e-02f,
  2.43495300e-01f, 1.38041392e-01f, -5.59558272e-02f, 2.53493011e-01f, 1.07442677e-01f, -1.82301760e-01f, -2.42663771e-02f, -7.99702480e-02f, 1.00141153e-01f, 2.17841953e-01f,
  9.36132520e-02f, 1.01247713e-01f, 8.28541368e-02f, -1.53048739e-01f, -1.06459446e-01f, 2.32538264e-02f, 4.07440886e-02f, -9.70848277e-02f, -2.61995077e-01f, -2.26755999e-02f,
  8.60447809e-02f, 1.45557120e-01f, -9.80022922e-02f, 2.27286902e-04f, 1.18864089e-01f, -8.92791245e-03f, 8.00436828e-03f, 1.55711502e-01f, 3.89248282e-02f, 3.21480602e-01f,
  7.03824386e-02f, -1.62819792e-02f, -5.03349490e-02f, 5.66968648e-03f, 2.19432898e-02f, -9.62045696e-03f, 8.36346671e-02f, -6.72424212e-02f, -1.98234175e-03f, 4.56005335e-02f,
  2.14062408e-02f, -8.22922029e-03f, 1.84995215e-02f, -4.37190607e-02f, -5.33298552e-02f, 5.74550256e-02f, 4.93040308e-02f, -6.82950541e-02f, -5.16175441e-02f, -7.89965317e-02f,
  5.28856479e-02f, 9.06248391e-02f, 3.78322750e-02f, -1.28582731e-01f, -6.44733161e-02f, -1.28360495e-01f, 6.14883192e-02f, -2.88437512e-02f, -2.99658813e-02f, 2.24382102e-01f,
  2.11174302e-02f, 2.41354369e-02f, -1.01445736e-02f, -1.68349892e-02f, 9.89527330e-02f, 3.55721228e-02f, -3.92059945e-02f, 7.85614401e-02f, 1.37265064e-02f, 6.92553297e-02f,
  -9.56360325e-02f, 7.01944623e-03f, -1.75961927e-02f, 2.73894276e-02f, 2.23553255e-02f, 3.87341976e-02f, -2.05877088e-02f, 1.03530968e-02f, -2.59553231e-02f, 4.67863865e-02f,
  -1.23904301e-02f, -5.86018013e-03f, 4.37052771e-02f, 6.35975599e-03f, 1.23460619e-02f, -3.73727158e-02f, 3.69659401e-02f, -1.09847844e-01f, -9.03632194e-02f, -7.12749362e-02f,
  2.31310442e-01f, -2.59422779e-01f, 1.17831260e-01f, 9.16939601e-02f, 2.90272292e-02f, -1.03456482e-01f, 2.24333759e-02f, -3.18594873e-02f, 4.69109742e-03f, 2.68000010e-02f,
  -8.06032494e-02f, 3.12763527e-02f, 1.90244745e-02f, 5.69046363e-02f, -5.96195757e-02f, -4.95823659e-02f, 2.91150771e-02f, 7.58087542e-03f, -1.21084876e-01f, 3.75738330e-02f,
  3.11295707e-02f, 9.42442492e-02f, -5.61076142e-02f, 5.21562472e-02f, 6.11348194e-04f, 5.35202622e-02f, -5.34484349e-02f, 7.38124503e-03f, -3.03388238e-02f, 1.38895750e-01f,
  1.95253685e-01f, -2.85775691e-01f, -5.97889163e-02f, 5.65184616e-02f, 3.88973998e-03f, -1.29063413e-01f, -3.79147619e-01f, -7.77852163e-02f, 1.69215918e-01f, -2.35643685e-01f,
  6.98060170e-02f, 2.27641702e-01f, 7.65242130e-02f, 1.09770454e-01f, 8.15301314e-02f, -2.43387178e-01f, -1.26476720e-01f, 1.85037270e-01f, 1.80287182e-01f, 1.59371182e-01f,
  1.28676251e-01f, 5.68033494e-02f, 1.93170056e-01f, 2.26085875e-02f, -1.46556646e-01f, 2.83149667e-02f, -1.27477527e-01f, -1.53119460e-01f, -9.36281681e-02f, -1.72187865e-01f,
  -8.08843747e-02f, -2.96711014e-03f, 3.55666056e-02f, 9.34252590e-02f, -4.65026908e-02f, -4.81839478e-02f, -4.63757701e-02f, -9.63796452e-02f, 7.72488955e-03f, -4.49520983e-02f,
  1.04730420e-01f, 1.03174902e-01f, 3.90216410e-02f, 1.98507737e-02f, 4.55085933e-03f, 5.24095073e-02f, 5.34372032e-02f, 1.28337890e-01f, -6.84251264e-03f, -5.92990667e-02f,
  2.90379636e-02f, 7.50398561e-02f, 5.23778051e-02f, -5.56301698e-02f, -1.32310778e-01f, 3.56757902e-02f, -8.06131512e-02f, -1.16441287e-01f, -5.56945316e-02f, -2.28524357e-01f,
  -2.43702228e-03f, 5.61398193e-02f, 1.91118494e-02f, -5.98572269e-02f, -4.35012393e-02f, -2.13106233e-03f, -4.17178199e-02f, 7.51165971e-02f, -5.05480580e-02f, -4.03279699e-02f,
  9.08606350e-02f, 2.18379609e-02f, -1.57563798e-02f, 3.46653275e-02f, -2.66842302e-02f, -2.18256097e-02f, -7.28557026e-03f, 1.60727631e-02f, 5.79127893e-02f, 2.19767727e-02f,
  6.91591501e-02f, -7.48658106e-02f, -3.27830426e-02f, 8.67253840e-02f, -6.14852011e-02f, 1.64755154e-02f, 3.35060097e-02f, 6.96824910e-03f, 2.88262814e-02f, 5.91821671e-02f,
  8.18108395e-02f, 2.99674701e-02f, -4.77191247e-03f, -4.52417731e-02f, 5.67450300e-02f, -4.82470989e-02f, -2.18603723e-02f, 5.28850257e-02f, -3.99378221e-03f, -9.45910215e-02f,
  6.88813478e-02f, -4.73219231e-02f, -5.15853539e-02f, 2.70042382e-02f, 2.80970186e-02f, -3.60519998e-02f, -6.70682564e-02f, 4.76064123e-02f, -2.14173123e-02f, -2.03388389e-02f,
  -9.19266492e-02f, 2.95811868e-03f, 6.43854402e-03f, -1.05153576e-01f, -1.54892743e-01f, 1.13924788e-02f, -8.23902488e-02f, -1.84499115e-01f, -7.81915039e-02f, -2.61821061e-01f,
  1.63641870e-01f, 1.52928174e-01f, -1.90670844e-02f, 1.00988396e-01f, 7.12060183e-02f, -1.21124923e-01f, 7.32896030e-02f, -2.80287154e-02f, -5.10515645e-02f, 6.03159517e-02f,
  2.03991737e-02f, -1.45662352e-01f, 1.53718758e-02f, -1.22766688e-01f, -1.79125331e-02f, -1.38757890e-02f, -8.97326991e-02f, -8.73866454e-02f, -2.02951580e-01f, -1.70699775e-01f,
  -1.85844637e-02f, 1.66888870e-02f, -6.91408217e-02f, -1.07717395e-01f, -1.12889828e-02f, -9.22374241e-03f, 3.28187719e-02f, 8.45867321e-02f, -4.92065549e-02f, 1.45444795e-01f,
  8.73240307e-02f, 6.20948784e-02f, -7.58188590e-02f, -1.18352048e-01f, 4.02996019e-02f, -6.28374293e-02f, 4.07535210e-02f, 1.29578747e-02f, -4.83653694e-02f, -7.76484907e-02f,
  -4.73621450e-02f, -4.63309996e-02f, -5.45098074e-02f, -1.77412555e-02f, 7.70781115e-02f, -6.33097365e-02f, 6.45222142e-02f, -9.31231380e-02f, -9.82623920e-03f, 8.21123272e-02f,
  5.08415047e-03f, -5.90623505e-02f, 9.06722024e-02f, -8.37075859e-02f, -6.44672364e-02f, -1.12575166e-01f, 4.81187142e-02f, 6.99326545e-02f, -4.65427265e-02f, 7.16621354e-02f,
  9.33080614e-02f, -4.64721136e-02f, -2.09647417e-02f, 1.02144025e-01f, 9.42254215e-02f, 4.38353755e-02f, 4.42891419e-02f, 7.49403536e-02f, -5.87822460e-02f, 6.26809150e-02f,
  3.71588022e-02f, 2.00518221e-02f, 2.74659786e-02f, 4.22878377e-02f, -3.52773778e-02f, -8.68517011e-02f, 8.31233338e-03f, 2.38440242e-02f, 1.39375962e-02f, 4.07240428e-02f,
  7.36085176e-02f, -6.49732649e-02f, 9.37791094e-02f, 1.07732061e-02f, -1.06956057e-01f, 1.44097283e-02f, -3.85997095e-03f, 3.00985062e-03f, 7.75918271e-03f, -5.60331978e-02f,
  9.37251374e-02f, -1.25118226e-01f, 5.94682805e-02f, -1.67359225e-02f, -7.44551197e-02f, -4.87890467e-02f, 3.11505347e-02f, 7.54470192e-03f, -6.74324632e-02f, -7.06899762e-02f,
  4.42257375e-02f, -1.00113861e-01f, 2.58033648e-02f, 5.34710027e-02f, -5.02379164e-02f, -9.83860940e-02f, 8.08392540e-02f, 5.70887700e-02f, -1.07655659e-01f, -7.53946677e-02f,
  -1.07926102e-02f, 6.14881553e-02f, -1.41576901e-02f, 5.71180927e-03f, 2.87186503e-02f, -4.20627557e-02f, -7.43303448e-02f, -7.46937916e-02f, 3.70505154e-02f, 1.49151459e-01f,
  -1.99760571e-01f, -2.06840709e-02f, -1.58131808e-01f, -4.31840755e-02f, -4.68222797e-02f, 6.96661398e-02f, 1.26736552e-01f, 1.03511840e-01f, 9.49728489e-02f, 1.73315965e-02f,
  -7.41040939e-03f, 1.06778760e-02f, -5.29972240e-02f, -4.72285450e-02f, -3.82637940e-02f, 1.18273799e-03f, 4.63892287e-03f, -1.70000553e-01f, 4.13306430e-02f, 8.56306180e-02f,
  -2.10212078e-02f, -1.19076841e-01f, -1.02768466e-01f, 3.63308005e-02f, -4.44053225e-02f, 2.06732973e-02f, -4.20483463e-02f, -5.94877750e-02f, 1.06953830e-02f, -7.95133263e-02f,
  -1.71674132e-01f, 2.48611551e-02f, 7.38550797e-02f, -3.97236459e-02f, -5.85443638e-02f, -6.78298622e-02f, -1.83559605e-03f, -1.40681257e-02f, 1.38807772e-02f, -1.67860109e-02f,
  2.72159483e-02f, -7.77478889e-02f, -9.24458504e-02f, 6.13914058e-02f, -1.34721380e-02f, 8.35173577e-02f, 2.77261138e-02f, -1.91375446e-02f, -7.16923922e-02f, -3.71941850e-02f,
  -9.73157138e-02f, 5.08655654e-03f, -2.60824658e-04f, 8.67042542e-02f, -3.70686315e-02f, 3.78553905e-02f, -3.11800018e-02f, 9.72516984e-02f, 7.34215677e-02f, -9.46678873e-03f,
  -3.26883644e-02f, -7.37736225e-02f, 1.91485928e-03f, -4.27293926e-02f, 8.36291984e-02f, -1.11403158e-02f, -7.48948231e-02f, 1.68470703e-02f, -4.54727858e-02f, -4.26936224e-02f,
  7.32353777e-02f, -8.31612945e-02f, 6.71384037e-02f, -6.54792413e-02f, -1.12478239e-02f, -2.81500202e-02f, -9.37012956e-03f, -4.39303368e-02f, -3.94061916e-02f, -3.03619299e-02f,
  -4.74755913e-02f, -2.69874856e-02f, -2.77400482e-02f, 4.26144013e-03f, 2.07213234e-04f, -7.51490220e-02f, -2.72925925e-02f, 9.63141844e-02f, -8.83046538e-03f, -6.48329109e-02f,
  5.81056103e-02f, 3.20128389e-02f, -8.33483264e-02f, 6.92013800e-02f, -6.94743916e-02f, -2.04129349e-02f, 5.78521267e-02f, -5.33455983e-02f, 3.32055427e-02f, 1.06081069e-01f,
  2.54278220e-02f, -9.28704143e-02f, -7.13874623e-02f, 9.12618935e-02f, -6.18491247e-02f, 3.57473604e-02f, 5.12200035e-02f, -5.57530522e-02f, -7.90650696e-02f, -5.57639748e-02f,
  -8.64000395e-02f, 1.88392103e-02f, 1.30440727e-01f, 3.23579684e-02f, 7.13807046e-02f, 3.27428579e-02f, 1.29562374e-02f, 7.74822235e-02f, -4.61006761e-02f, -2.79060807e-02f,
  -4.37247068e-01f, -6.05387501e-02f, -3.88841378e-04f, -3.15252170e-02f, 8.85953605e-02f, 2.44497340e-02f, -1.67836383e-01f, -2.34372821e-02f, -3.39741521e-02f, -8.71557221e-02f,
  1.00848917e-02f, 1.34104237e-01f, 1.15383253e-01f, 1.98826134e-01f, 4.63258028e-02f, -5.38389459e-02f, -2.53426880e-02f, 3.25754583e-02f, 1.20758064e-01f, 1.00830644e-01f,
  6.19523525e-02f, 1.83993131e-02f, 6.96886480e-02f, 1.51275052e-02f, -7.35245943e-02f, 3.61903347e-02f, -1.19278748e-02f, 3.89376059e-02f, -1.67365223e-02f, -9.30705220e-02f,
  -9.32776257e-02f, -1.35789961e-01f, 1.14102438e-01f, 8.35557189e-03f, 2.70172879e-02f, -3.43505084e-03f, -3.69801968e-02f, 7.18539930e-04f, 1.34300208e-03f, 2.53819693e-02f,
  5.18000359e-03f, -3.73268351e-02f, -1.39457490e-02f, 9.74716060e-03f, -7.34629110e-02f, -4.08774242e-04f, 4.05989550e-02f, -2.14186385e-02f, 2.30535548e-02f, 1.24898916e-02f,
  -3.07441838e-02f, 6.58482984e-02f, -6.10420154e-03f, -1.22367797e-04f, 8.00257251e-02f, 1.39690951e-01f, -5.00889048e-02f, -4.59325314e-02f, 4.70300242e-02f, -1.22091725e-01f,
  1.16735481e-01f, -1.33290710e-02f, 1.02244737e-02f, -3.20800915e-02f, 3.75029966e-02f, -3.56598641e-03f, 1.22939073e-01f, -2.90624350e-02f, -1.12439329e-02f, -1.01785949e-02f,
  2.45063305e-02f, -3.48417945e-02f, 7.72126066e-03f, -9.23256800e-02f, 6.95883334e-02f, -1.03240181e-02f, 2.31001414e-02f, 6.90284297e-02f, -8.78332299e-04f, -2.39171330e-02f,
  1.11138290e-02f, 2.37246091e-03f, -4.49195206e-02f, 2.70842519e-02f, 1.52930170e-02f, 5.65380231e-02f, -3.10839224e-03f, 4.59413417e-02f, -3.34641859e-02f, -1.03189260e-01f,
  -2.35990778e-01f, 1.52207449e-01f, -2.03199480e-02f, -7.20271468e-03f, -1.92201650e-03f, 4.15849835e-02f, -7.83709660e-02f, -2.05349252e-02f, 1.07136359e-02f, -2.80345269e-02f,
  -5.46519011e-02f, 1.95045583e-02f, 4.49052732e-03f, 4.83499914e-02f, -1.30890878e-02f, -7.14772269e-02f, -1.97216757e-02f, -1.93775054e-02f, 7.35674202e-02f, 6.42446503e-02f,
  2.32046396e-02f, -9.51075107e-02f, -8.75266939e-02f, -9.60634649e-02f, 5.56490719e-02f, -5.32636642e-02f, -8.60255137e-02f, -1.03111684e-01f, -1.50107995e-01f, -2.64683992e-01f,
  1.05090491e-01f, 3.55271883e-02f, -9.01227966e-02f, 1.30415801e-02f, 2.53358018e-02f, -1.95521209e-02f, 1.67660847e-01f, 1.51063818e-02f, -2.72214208e-02f, -2.23620590e-02f,
  1.31879607e-02f, -7.72564262e-02f, -3.78419161e-02f, -4.58504520e-02f, 6.56571761e-02f, 2.86382008e-02f, 7.18244985e-02f, -9.25463066e-02f, 5.95275238e-02f, 1.40875224e-02f,
  -8.99417885e-03f, -3.23750265e-02f, -6.25939518e-02f, -1.33045524e-01f, -5.93899637e-02f, -9.75763872e-02f, -6.81463182e-02f, -4.63089719e-02f, -4.73680533e-02f, -1.31368130e-01f,
  -7.43062645e-02f, -1.16441071e-01f, 7.57885277e-02f, -3.60096954e-02f, 2.35520769e-02f, 3.15045342e-02f, -1.34506943e-02f, -7.80804679e-02f, -6.48366138e-02f, -6.73651248e-02f,
  -6.30446002e-02f, -9.91572067e-02f, 9.76523310e-02f, -8.58887583e-02f, 8.80141184e-02f, -3.91555242e-02f, 8.10594559e-02f, 2.60188710e-02f, 1.73163041e-02f, 8.23946223e-02f,
  -8.30371976e-02f, 7.18051717e-02f, -1.30157184e-03f, 1.83011107e-02f, 7.50409290e-02f, -4.38481085e-02f, 6.10386208e-03f, -7.92936757e-02f, 1.00941770e-02f, -1.72405653e-02f,
  4.96428832e-02f, 2.69692689e-02f, -6.00006320e-02f, -4.73587923e-02f, 6.48014769e-02f, 8.93336758e-02f, -6.53168932e-02f, 6.63485453e-02f, -6.67067394e-02f, 9.79681164e-02f,
  3.08992434e-02f, 7.00001270e-02f, -4.20263708e-02f, -4.42155823e-02f, -2.04777122e-02f, -4.13217880e-02f, 7.04149529e-02f, 4.43423018e-02f, 4.68572304e-02f, -7.13631213e-02f,
  -2.25881338e-02f, -3.66780348e-02f, -2.76978174e-03f, -1.36400089e-02f, -6.74455687e-02f, -3.04009928e-03f, 2.71591032e-03f, 4.50407853e-03f, 1.29352156e-02f, -1.27156191e-02f,
  -7.57241175e-02f, -1.62610156e-03f, -5.30619286e-02f, -1.78410485e-02f, -8.32141191e-03f, -4.47273217e-02f, -9.33732688e-02f, -1.61707513e-02f, -4.42234650e-02f, 5.06124161e-02f,
  6.87243342e-02f, 3.83203104e-02f, -1.98170822e-02f, 6.66537061e-02f, -1.89666525e-02f, 7.70054236e-02f, -6.86976360e-03f, 4.70570251e-02f, -3.86049487e-02f, -3.46120074e-02f,
  -6.24366105e-02f, 1.01675175e-01f, 1.28658473e-01f, 8.71929675e-02f, -5.78439049e-02f, 3.37675512e-02f, 1.37859378e-02f, 8.59970693e-03f, 1.38540164e-01f, 8.54127705e-02f,
  -2.04964876e-01f, 2.61266083e-01f, 2.68439442e-01f, -2.13080179e-02f, -5.35244346e-02f, -3.85597236e-02f, 1.24333754e-01f, -3.46252024e-02f, -1.34288192e-01f, 1.34993503e-02f,
  9.59868059e-02f, -9.75083485e-02f, -5.24482541e-02f, -1.26497313e-01f, -3.45004350e-02f, 2.55192578e-01f, 2.40713790e-01f, 9.58489180e-02f, -1.67835191e-01f, -1.14230812e-01f,
  -4.51765209e-02f, 5.80719225e-02f, -3.13243009e-02f, -2.26471089e-02f, -2.27084644e-02f, -1.01163164e-01f, 1.54369041e-01f, -5.47345504e-02f, 5.17477244e-02f, 3.22670281e-01f,
  1.40512556e-01f, 6.97996542e-02f, 4.03932668e-02f, -1.74758658e-02f, 4.01745141e-02f, -4.28450294e-03f, 9.23641084e-04f, 2.11432204e-02f, -9.14010629e-02f, 5.37165590e-02f,
  -6.41265288e-02f, 1.82656731e-04f, -7.42624998e-02f, -8.79869610e-03f, 3.64386998e-02f, -5.03090629e-03f, 2.45548785e-02f, 4.61411476e-02f, 3.94072570e-02f, 8.66356716e-02f,
  9.73815471e-02f, 7.05857053e-02f, 9.10586566e-02f, 1.14715956e-02f, -5.95118590e-02f, 5.66979311e-02f, 7.38827214e-02f, 4.58062403e-02f, -6.55484293e-03f, 2.89842766e-02f,
  1.72978155e-02f, 1.05847225e-01f, -4.32517938e-02f, -5.26842400e-02f, -6.49647564e-02f, -3.65014304e-04f, -8.32234249e-02f, 5.11196665e-02f, -3.86488587e-02f, 4.95175347e-02f,
  3.21604311e-02f, 1.16093874e-01f, -4.28341329e-03f, -5.25579080e-02f, -8.53710435e-03f, 5.53565770e-02f, 4.56479862e-02f, 2.36875694e-02f, -7.40397647e-02f, -1.92520265e-02f,
  1.85289606e-02f, -4.89268675e-02f, -2.28193644e-02f, 3.11867753e-03f, 1.28640998e-02f, 1.50425043e-02f, -5.09728715e-02f, -2.40187328e-02f, -2.16504484e-02f, -5.48824072e-02f,
  -2.00557947e-01f, 1.38620138e-01f, -4.57151048e-02f, -3.37922089e-02f, -2.13675965e-02f, 3.66608612e-02f, -1.58324055e-02f, 1.28243575e-02f, -3.28434929e-02f, 2.04670170e-04f,
  3.63506712e-02f, 3.41451517e-03f, 4.53603528e-02f, -1.49161601e-02f, -9.14734825e-02f, -9.93108470e-03f, 4.80408557e-02f, -2.89392397e-02f, -2.87064146e-02f, -2.82723699e-02f,
  4.26178761e-02f, -5.30853160e-02f, -1.86570629e-01f, 1.87257901e-02f, -3.74185108e-02f, -1.41041443e-01f, -1.17574431e-01f, -9.43872631e-02f, -9.47362632e-02f, -1.02340057e-01f,
  5.44900119e-01f, -1.20943971e-01f, -7.27858990e-02f, 1.91782728e-01f, -1.52541265e-01f, 2.85076555e-02f, -1.75664932e-01f, 7.73279369e-02f, 1.78053930e-01f, -1.02047682e-01f,
  -3.83160003e-02f, 1.79279789e-01f, 6.32642508e-02f, -5.09136682e-03f, 1.29043043e-01f, -2.51628190e-01f, -1.36239648e-01f, -2.41929684e-02f, 1.24528915e-01f, 1.84783787e-01f,
  -8.93342271e-02f, -8.09426829e-02f, 1.46829203e-01f, 3.57968807e-02f, -9.60245430e-02f, 3.52002345e-02f, -1.06704518e-01f, -2.08239406e-02f, -5.41812032e-02f, -2.29789525e-01f,
  -1.16585195e-01f, 4.47031744e-02f, -4.05967012e-02f, -2.83612330e-02f, -4.77323383e-02f, 2.34310515e-02f, 6.82620928e-02f, 1.52961991e-04f, 5.82371503e-02f, -3.92040573e-02f,
  -5.89055195e-02f, -4.54041287e-02f, -2.04684846e-02f, 1.55017870e-02f, -4.08975780e-02f, -6.41348213e-02f, 1.51671264e-02f, -1.01785576e-02f, 8.09385329e-02f, -1.55119821e-02f,
  -4.79718074e-02f, -1.24354213e-01f, -1.66673530e-02f, 2.97553279e-02f, 1.34371534e-01f, -9.14147273e-02f, 2.36260463e-02f, 9.62982178e-02f, 1.04969457e-01f, 7.16771558e-02f,
  2.00926960e-02f, 4.70861383e-02f, -5.70881239e-04f, -1.72496308e-02f, 7.41191730e-02f, -1.87870639e-03f, -1.82940569e-02f, -2.16772035e-02f, 6.16555698e-02f, -6.86130822e-02f,
  -1.09513802e-03f, 2.45312713e-02f, -5.45850396e-02f, 4.89708334e-02f, 2.78143454e-02f, -4.41438183e-02f, 2.69712787e-02f, 2.65127514e-02f, -2.82521620e-02f, 2.66208705e-02f,
  5.97995557e-02f, -3.37784030e-02f, -7.04591498e-02f, 3.48305702e-02f, -2.87036858e-02f, -4.03587520e-02f, 3.63120623e-02f, -3.36434022e-02f, -9.13504791e-03f, -5.87688088e-02f,
  -5.63200228e-02f, 5.68217374e-02f, -5.23109473e-02f, 6.60497881e-03f, 3.27780135e-02f, 2.11916212e-02f, -2.97713801e-02f, -3.44386734e-02f, -6.85990304e-02f, -3.45703848e-02f,
  7.45031238e-02f, -1.18774688e-02f, 6.34248462e-03f, -5.16392775e-02f, 3.60670779e-03f, 2.06906963e-02f, 2.77960598e-02f, -3.29879522e-02f, 3.81776728e-02f, -9.04161762e-03f,
  4.38646507e-03f, -3.17661129e-02f, 5.40690869e-02f, 5.33306748e-02f, -6.17153710e-03f, -8.50033108e-03f, -9.59017277e-02f, -5.46751879e-02f, 7.85812438e-02f, -3.73529121e-02f,
  -4.20366526e-01f, -4.57231551e-02f, 5.62047698e-02f, -1.62730336e-01f, 2.82263935e-01f, 3.06488186e-01f, 3.75205576e-01f, 7.23784193e-02f, -9.53502059e-02f, -2.50051767e-02f,
  5.92764206e-02f, -1.13115042e-01f, -5.10052480e-02f, -1.08867012e-01f, 2.04776973e-02f, 5.00849821e-02f, 5.07644378e-02f, -1.29577527e-02f, 1.07103802e-01f, 1.40540004e-01f,
  1.01407170e-02f, -9.74322110e-02f, -1.90851510e-01f, -1.77205615e-02f, -1.31417532e-02f, 7.10852519e-02f, 1.12949714e-01f, 5.84326088e-02f, 8.76323581e-02f, -9.17847529e-02f,
  3.05647757e-02f, -2.61647478e-02f, 8.87805670e-02f, -1.14878871e-01f, -7.16262590e-03f, 8.04080721e-03f, 6.94620162e-02f, -1.90553255e-02f, 1.10503152e-01f, 4.09532562e-02f,
  -1.17030464e-01f, 5.00529334e-02f, 3.02199405e-02f, -4.65667136e-02f, -4.22161445e-02f, 1.48965223e-02f, -5.83573915e-02f, -7.88350999e-02f, -5.86962178e-02f, 1.24785751e-01f,
  4.04951125e-02f, 2.35780329e-03f, 7.66466260e-02f, 3.21931131e-02f, 7.70613328e-02f, -7.55021274e-02f, -8.61916970e-03f, -6.70581684e-02f, 1.60901677e-02f, 1.98084619e-02f,
  1.10462777e-01f, 4.49848212e-02f, 2.17043199e-02f, 2.94703264e-02f, 3.27040367e-02f, -3.86964320e-03f, -4.82571647e-02f, 7.42877647e-02f, -5.56741725e-04f, -5.30857556e-02f,
  5.51484339e-02f, 7.68628642e-02f, -7.31029212e-02f, 7.68788233e-02f, -4.55996627e-03f, -2.81750821e-02f, 5.25607392e-02f, -2.53195222e-02f, -5.61296120e-02f, 3.03612947e-02f,
  2.40581632e-02f, -1.06019340e-02f, 2.40844227e-02f, 3.20001505e-02f, -1.50697147e-02f, -4.92520481e-02f, 2.58684233e-02f, -6.28811345e-02f, 8.24358836e-02f, -6.66340590e-02f,
  3.88700217e-02f, 8.50620717e-02f, 2.05354244e-02f, -7.95917287e-02f, -3.03592086e-02f, 1.34155080e-02f, 2.98725255e-02f, 6.40432462e-02f, -9.96855348e-02f, -2.45671459e-02f,
  -2.29187440e-02f, -4.53474261e-02f, 5.52707464e-02f, -3.65201607e-02f, 7.32977316e-02f, -7.73466378e-03f, 6.09646365e-02f, 6.14816658e-02f, 4.93106619e-02f, 1.06266208e-01f,
  -1.41138425e-02f, 8.63157660e-02f, 6.32483186e-03f, -1.49649223e-02f, 4.28399909e-03f, 4.80256742e-03f, 6.36140928e-02f, 5.32180667e-02f, 1.33778155e-01f, 1.69694558e-01f,
  -3.59162629e-01f, 4.82757166e-02f, -8.57896209e-02f, -6.14454821e-02f, 2.17979420e-02f, -9.51929986e-02f, -9.11493041e-03f, 3.72394584e-02f, 5.02365343e-02f, 8.75468627e-02f,
  -1.95188187e-02f, 1.29759058e-01f, 1.06774792e-01f, 4.93937023e-02f, -2.17254572e-02f, 2.77902894e-02f, 6.11868538e-02f, -1.08457401e-01f, -8.21112469e-02f, 6.28118739e-02f,
  4.06567752e-02f, -3.80338803e-02f, 1.49468323e-02f, 1.14577368e-01f, 3.55144143e-02f, 1.53426319e-01f, 6.98125362e-02f, 1.62817945e-03f, 7.50282556e-02f, 1.73733532e-01f,
  1.07558519e-01f, -1.04213573e-01f, 5.06361797e-02f, -1.78400800e-02f, -3.90452072e-02f, -2.80968100e-02f, -1.21724149e-02f, -2.55433731e-02f, 2.39828657e-02f, 1.39259631e-02f,
  -1.02555910e-02f, 4.86608222e-03f, 7.57476240e-02f, 1.18680581e-01f, 1.90160610e-02f, -5.53152114e-02f, 3.38918809e-03f, -3.87608930e-02f, -9.38864723e-02f, 8.42363909e-02f,
  1.36450425e-01f, -5.02409711e-02f, -6.44380003e-02f, 2.22976636e-02f, -6.33413196e-02f, -3.81418876e-02f, 7.56814256e-02f, -2.53002848e-02f, -5.30009456e-02f, 8.99767354e-02f,
  2.34793983e-02f, -3.19875143e-02f, -7.05176890e-02f, 5.87396435e-02f, 1.50143262e-02f, 7.45996162e-02f, -8.69990215e-02f, -7.94236083e-03f, 4.09769407e-03f, -2.43977439e-02f,
  3.59451678e-03f, 2.55565103e-02f, 9.76375304e-03f, -4.14511710e-02f, 1.33200157e-02f, -6.26149550e-02f, -8.83696526e-02f, 7.97083080e-02f, -2.10184939e-02f, -4.79022823e-02f,
  1.25980079e-02f, -1.07581709e-02f, 5.69522008e-02f, -3.12642776e-03f, -3.33062448e-02f, -5.15325256e-02f, -2.81463768e-02f, 4.69179004e-02f, 1.40926673e-03f, 5.38347848e-02f,
  1.18493043e-01f, -2.09938020e-01f, -6.80798143e-02f, 3.17218415e-02f, -6.77637830e-02f, 6.47735968e-03f, 4.11443226e-02f, -3.77061293e-02f, -3.91529649e-02f, -3.77929658e-02f,
  1.70233510e-02f, -7.83468336e-02f, -6.14267923e-02f, -1.15579609e-02f, 2.78259721e-02f, -5.44326603e-02f, -1.16466405e-03f, -6.14441112e-02f, -3.90617400e-02f, 8.76745731e-02f,
  1.54751129e-02f, -7.12627172e-02f, -1.68924723e-02f, 6.32826239e-02f, 7.95841496e-03f, -4.41868231e-02f, -7.83983842e-02f, 3.57742533e-02f, -9.62752029e-02f, -2.09068973e-02f,
  8.76818836e-01f, 9.82445031e-02f, -4.94847856e-02f, 1.75010383e-01f, -1.41353935e-01f, -4.76401821e-02f, -1.09627163e-02f, 6.04453683e-02f, 2.33808961e-02f, -2.52296440e-02f,
  -2.73976848e-02f, -1.57929108e-01f, -2.61326805e-02f, -1.50824755e-01f, 5.33899181e-02f, 4.04962450e-02f, -1.05679646e-01f, -2.16412488e-02f, 2.48193927e-03f, -4.00708728e-02f,
  -1.67925805e-01f, -2.94643305e-02f, 1.99660957e-01f, 4.65096608e-02f, -4.85657947e-03f, -1.42403066e-01f, -8.19801018e-02f, -5.22038527e-02f, -3.24729495e-02f, -3.60228345e-02f,
  -3.07944566e-02f, 2.33553484e-01f, -1.26868010e-01f, -1.72016751e-02f, -1.23780653e-01f, 6.97739273e-02f, -3.54142189e-02f, 1.87923256e-02f, 1.25531763e-01f, 3.51944230e-02f,
  -2.62521096e-02f, 1.78398732e-02f, 2.70970892e-02f, -1.08520366e-01f, 3.75187621e-02f, 1.24323621e-01f, 8.77680406e-02f, 9.37720388e-02f, 6.19076490e-02f, 7.36938342e-02f,
  -5.88455163e-02f, -5.10032922e-02f, 1.58361882e-01f, -9.53606889e-02f, 2.95221843e-02f, -5.38611375e-02f, 4.17504236e-02f, 6.54267520e-02f, -6.77733496e-02f, 8.37224796e-02f,
  4.82494105e-03f, -2.43184678e-02f, 4.06189039e-02f, 1.19924936e-02f, 2.55638603e-02f, -4.74307239e-02f, -7.84445740e-03f, -5.98046370e-02f, -4.93894368e-02f, 3.89130972e-02f,
  -3.92246842e-02f, 1.25444112e-02f, -2.39343159e-02f, 1.47922263e-02f, -3.03632542e-02f, -2.93750204e-02f, -2.72029322e-02f, 9.34935827e-03f, 4.02038395e-02f, 3.44654359e-02f,
  -6.65480690e-03f, 5.96270263e-02f, -3.14290682e-03f, -5.01324832e-02f, -1.10535696e-02f, -5.58304042e-03f, -7.26391077e-02f, 1.64453946e-02f, -2.02751737e-02f, 4.61102370e-03f,
  -1.28710372e-02f, -1.12734474e-01f, 7.07885921e-02f, -9.57636088e-02f, 6.69766441e-02f, 4.42035757e-02f, -4.39807475e-02f, 7.80445784e-02f, -5.73088182e-04f, 3.23519707e-02f,
  -2.39406247e-02f, 2.33172346e-02f, 3.95211019e-02f, 1.30643351e-02f, 2.95884851e-02f, -3.36309075e-02f, -4.54910584e-02f, -2.67040636e-02f, -2.12356336e-02f, 5.12358248e-02f,
  -5.67224696e-02f, 8.01461712e-02f, 1.48443386e-01f, 1.35834534e-02f, 1.62389781e-02f, -2.99772285e-02f, 4.14568279e-03f, 2.76004039e-02f, 1.79353058e-02f, 2.67937332e-02f,
  -1.33895263e-01f, 5.67512549e-02f, 1.99331701e-01f, -5.09399027e-02f, 2.88815081e-01f, 3.26599926e-01f, 4.83035564e-01f, 2.04727709e-01f, -1.87058598e-02f, 1.00771233e-01f,
  5.26396781e-02f, -1.66888639e-01f, -2.07800791e-01f, -7.81425312e-02f, 5.00964187e-02f, 8.50866288e-02f, 1.17882274e-01f, -3.31206731e-02f, 7.15154260e-02f, 5.61347194e-02f,
  2.12211479e-02f, -1.74493704e-03f, -9.31941494e-02f, 6.52071740e-03f, 4.42073718e-02f, -5.54442368e-02f, 7.71801593e-03f, -9.36999619e-02f, -1.68989412e-02f, -9.15366560e-02f,
  -7.90962949e-02f, 2.01949805e-01f, 3.48132923e-02f, 4.49088664e-04f, 1.57078467e-02f, -6.20106421e-02f, 7.76114641e-04f, -7.39914030e-02f, 9.76723060e-03f, 4.52867858e-02f,
  4.94211540e-02f, -5.26596308e-02f, -4.49373946e-02f, 6.34088889e-02f, 3.59610058e-02f, -4.88932766e-02f, -9.00685787e-02f, 1.01448223e-02f, 8.05588588e-02f, -7.97894448e-02f,
  4.97119948e-02f, 2.89696306e-02f, 1.40086979e-01f, 1.61421522e-01f, 3.86972241e-02f, -5.03981300e-02f, 9.30303261e-02f, -3.87376174e-02f, 1.43276807e-02f, -6.55695200e-02f,
  -5.37310801e-02f, 5.57159483e-02f, 7.77967051e-02f, -4.99832369e-02f, 1.44368382e-02f, -6.68956786e-02f, -1.29714161e-02f, 1.13082891e-02f, 6.10223338e-02f, -6.71902895e-02f,
  -1.35038011e-02f, -1.74910075e-03f, 7.16539426e-03f, 1.89500942e-03f, -7.97041226e-03f, 9.72119048e-02f, 7.42887566e-03f, 2.35150717e-02f, -8.19270909e-02f, -5.39841764e-02f,
  -7.81946853e-02f, 4.25454564e-02f, 6.73971102e-02f, -1.69420373e-02f, -4.76839952e-02f, 4.05139625e-02f, -4.63020653e-02f, 1.72931526e-04f, -8.22300911e-02f, 3.41650806e-02f,
  -2.29421645e-01f, 6.79652318e-02f, -1.80568814e-01f, -6.28946200e-02f, 6.26458302e-02f, -6.85855821e-02f, -2.10829638e-02f, -8.22840482e-02f, 1.88437831e-02f, -4.08950858e-02f,
  4.50065993e-02f, -5.83869331e-02f, 5.54281026e-02f, 8.61437544e-02f, 9.66744497e-02f, 5.55161014e-02f, -1.00207783e-01f, 1.33429989e-01f, -3.77975665e-02f, -1.05043687e-01f,
  -5.77117205e-02f, 7.24559724e-02f, -3.12531106e-02f, 2.84793098e-02f, -1.40223047e-02f, -3.96087319e-02f, 5.12436256e-02f, 7.17847198e-02f, 7.05105215e-02f, -5.26133515e-02f,
  4.47735697e-01f, -8.73823985e-02f, 5.47312014e-02f, -7.66546233e-03f, -1.00478865e-01f, -5.03985584e-02f, 7.20191896e-02f, -6.29008636e-02f, 3.29578929e-02f, -2.10464522e-02f,
  -8.30546319e-02f, -8.98667052e-02f, 1.08497001e-01f, -8.02726485e-03f, 8.16839784e-02f, 3.99233960e-02f, 9.92665067e-02f, 3.65229063e-02f, 2.12713387e-02f, 9.71211959e-03f,
  -5.45722544e-02f, -5.78953438e-02f, 2.35443618e-02f, 2.55628359e-02f, 2.94138603e-02f, 9.77958273e-03f, 4.26899046e-02f, -3.92198600e-02f, -1.02226086e-01f, -4.50242916e-03f,
  7.89583400e-02f, 9.58175957e-02f, 8.38424489e-02f, -3.49774286e-02f, -2.11936999e-02f, 3.10417283e-02f, 7.77723268e-02f, 8.35209806e-03f, 1.75269470e-02f, 1.01696514e-02f,
  -6.23104200e-02f, 6.36726320e-02f, 8.54291916e-02f, -5.76769281e-03f, -3.42916362e-02f, 5.91459237e-02f, -5.70264198e-02f, 1.45486668e-01f, 9.69709456e-02f, 3.27797271e-02f,
  -1.08260714e-01f, 2.99884137e-02f, 1.90420020e-02f, -5.88436015e-02f, 4.64984067e-02f, 6.07842654e-02f, 2.60391943e-02f, -6.03182130e-02f, 1.09642677e-01f, 1.36861488e-01f,
  2.02103704e-02f, -1.81535967e-02f, 2.86065843e-02f, 6.95613995e-02f, -2.42630057e-02f, 1.96546633e-02f, -7.17135668e-02f, -2.32522078e-02f, -4.11155932e-02f, 1.44503936e-02f,
  -5.27414866e-02f, -1.19756721e-02f, -5.16957380e-02f, 7.22204894e-02f, 6.11834973e-02f, 3.12831178e-02f, -5.04693054e-02f, 4.43510264e-02f, 5.68070337e-02f, 8.30832273e-02f,
  3.29703689e-02f, -8.80045875e-04f, -1.11622056e-02f, 4.05369997e-02f, 2.21037548e-02f, 4.02393378e-02f, 1.28353722e-02f, -2.40067746e-02f, -3.57922465e-02f, 5.16460240e-02f,
  1.49216920e-01f, -2.97641866e-02f, 3.57831158e-02f, -6.25287695e-03f, 1.95483305e-02f, -4.30089161e-02f, -7.39955530e-02f, -7.50575513e-02f, -5.57878688e-02f, 2.46232431e-02f,
  5.91988340e-02f, 1.85556505e-02f, -1.58792790e-02f, -7.54092857e-02f, -1.60681512e-02f, 4.85581309e-02f, 1.38277775e-02f, 4.06437963e-02f, -2.74751354e-02f, -2.27716449e-03f,
  5.95311448e-03f, 7.83313587e-02f, 1.03746124e-01f, -1.69559959e-02f, -4.08943892e-02f, 1.52048528e-01f, 6.19532205e-02f, -2.83772536e-02f, 1.72723338e-01f, 1.11967131e-01f,
  1.78895652e-01f, -1.13490134e-01f, 9.44580957e-02f, 4.51894812e-02f, 3.34863714e-03f, 2.58211568e-02f, 1.19148023e-01f, -7.67678022e-02f, -1.17275445e-03f, 1.75824687e-01f,
  2.88210064e-02f, -6.51738122e-02f, 6.39278665e-02f, 6.39322475e-02f, 3.63372862e-02f, 1.89077288e-01f, 1.54913217e-01f, 1.57228887e-01f, -1.48055302e-02f, 2.15495881e-02f,
  8.02275836e-02f, 1.13062136e-01f, -1.13995165e-01f, -1.13620594e-01f, 5.00591211e-02f, 3.10107041e-02f, -4.30315034e-03f, -1.27057387e-02f, -1.34192454e-03f, 5.98779768e-02f,
  2.02876627e-01f, -3.64442505e-02f, 7.72077963e-02f, -2.82877348e-02f, 2.23940611e-02f, 7.78564892e-04f, 1.48923509e-02f, -4.27979194e-02f, -3.49792540e-02f, -5.71858846e-02f,
  -5.53456992e-02f, -1.22303650e-01f, -3.53243053e-02f, 1.35896979e-02f, 8.31759796e-02f, -6.12644926e-02f, -1.08892523e-01f, -6.90953853e-03f, -3.91946994e-02f, -7.65497163e-02f,
  1.92900872e-04f, -1.01029277e-01f, 5.80581948e-02f, -1.31153226e-01f, -2.25776266e-02f, 6.32336549e-03f, -1.58776045e-01f, -1.02423556e-01f, -7.04594925e-02f, -4.30671461e-02f,
  -5.04514314e-02f, 6.57541528e-02f, -2.57068872e-02f, -8.58388394e-02f, -2.29075439e-02f, -3.67167853e-02f, 8.83613080e-02f, 8.95822719e-02f, 3.95964608e-02f, -6.36102930e-02f,
  -3.52723040e-02f, 2.17235349e-02f, -1.70792919e-02f, 3.43005657e-02f, 2.56421436e-02f, -9.98057425e-02f, 1.22925285e-02f, 3.06631476e-02f, -3.48451175e-03f, -5.80439046e-02f,
  -4.22718190e-02f, -7.66419899e-03f, -2.93624047e-02f, -4.37599458e-02f, -2.29716767e-02f, -7.35721067e-02f, 7.37617388e-02f, -2.03629639e-02f, -2.22791545e-02f, -1.32363336e-02f,
  1.00421228e-01f, -6.01571836e-02f, 9.74722356e-02f, 2.04542484e-02f, -4.36699716e-03f, -6.71499595e-02f, -6.31740093e-02f, -3.83426808e-02f, 1.53381713e-02f, -1.00289537e-02f,
  -4.16645855e-02f, 8.16828310e-02f, 3.21925897e-03f, -2.14810222e-02f, 3.11734714e-02f, -5.15440144e-02f, -6.01398339e-03f, 3.32417944e-03f, 4.46771383e-02f, -1.28108570e-02f,
  -3.67496386e-02f, 3.07185575e-02f, 5.61469495e-02f, 8.72166082e-02f, -7.25504011e-02f, 1.43288448e-01f, 6.15585372e-02f, 1.93086267e-02f, -2.50758766e-03f, 1.71975747e-01f,
  5.50872833e-02f, -8.57676044e-02f, -2.29555145e-02f, -1.56846140e-02f, 8.60636011e-02f, 4.72104922e-02f, 1.20880874e-02f, 1.33588929e-02f, 1.07270531e-01f, -1.61337703e-02f,
  9.40158665e-02f, 9.54112187e-02f, 2.86074281e-02f, 2.83517651e-02f, -1.13640934e-01f, -1.23046590e-02f, -6.42201081e-02f, -8.72286186e-02f, -5.79127036e-02f, 3.07583865e-02f,
  -4.80435081e-02f, -1.00727767e-01f, -1.33713514e-01f, 1.35055631e-02f, -4.31705900e-02f, 1.88366082e-02f, -8.70986432e-02f, 1.00208949e-02f, -2.20607873e-02f, -1.62169859e-01f,
  -1.27671687e-02f, -1.85552370e-02f, 3.84512804e-02f, 2.45785434e-02f, -1.33086341e-02f, 1.07487015e-01f, -4.97583412e-02f, -6.94062281e-03f, -1.28761623e-02f, -7.03827664e-02f,
  2.04479042e-02f, -8.62916932e-02f, -7.18708560e-02f, 1.96145345e-02f, -5.59918284e-02f, 7.25012496e-02f, -2.89389049e-03f, -4.89742048e-02f, -7.82696903e-02f, -8.14443529e-02f,
  -2.97874082e-02f, -4.10586409e-02f, 4.50056568e-02f, -3.39535847e-02f, -7.02604302e-04f, -8.88670534e-02f, 1.25869559e-02f, -1.18512332e-01f, -6.36892170e-02f, 1.72902290e-02f,
  -1.44393137e-03f, 2.64309067e-02f, 3.99198793e-02f, -8.13579857e-02f, -6.16878346e-02f, -6.70479089e-02f, -5.66027053e-02f, -7.98111632e-02f, 6.46410733e-02f, -3.46538536e-02f,
  7.82719906e-03f, 5.73107973e-02f, -4.20539081e-02f, 1.30044837e-02f, -3.27496044e-03f, 7.67855486e-03f, 6.13630414e-02f, 1.40632577e-02f, 7.73107260e-02f, 1.60909072e-02f,
  -3.26674874e-03f, 4.48368397e-03f, -6.68122396e-02f, 6.08483516e-02f, -3.47753987e-02f, -6.64388314e-02f, -1.07745558e-01f, 3.10119335e-03f, 1.55303217e-02f, 1.12958346e-02f,
  1.24198876e-01f, -4.86407727e-02f, -2.67915893e-02f, 6.04820177e-02f, 7.63964653e-02f, 2.42080763e-02f, 2.52105482e-02f, 4.14834172e-02f, -8.91927108e-02f, 3.81992348e-02f,
  8.05500224e-02f, -5.96015453e-02f, 3.93603295e-02f, 2.95511819e-02f, 7.11347014e-02f, 4.23097610e-02f, 6.67257160e-02f, 6.28232807e-02f, 3.17495726e-02f, -8.13894421e-02f,
  -2.05591563e-02f, 9.24806595e-02f, 1.98385380e-02f, 1.54596586e-02f, 6.99381158e-02f, 7.63461143e-02f, 6.63694665e-02f, 1.01183921e-01f, 1.21842705e-01f, 9.77535173e-02f,
  2.80360132e-01f, -4.04244987e-03f, 1.03707969e-01f, 9.62246135e-02f, 2.21331567e-02f, 8.93312171e-02f, 8.55266452e-02f, 1.20929383e-01f, 8.60324726e-02f, 1.92287967e-01f,
  1.53521687e-01f, 1.32508159e-01f, 1.76737890e-01f, 7.38159716e-02f, 1.47497758e-01f, 4.40406017e-02f, -1.09085836e-01f, -5.96771166e-02f, 4.44285832e-02f, -4.37193438e-02f,
  -1.45642981e-01f, -3.63604948e-02f, -7.00392276e-02f, -6.11649500e-03f, -6.41083568e-02f, -4.10411917e-02f, -5.64897507e-02f, -1.22504264e-01f, -1.69368461e-01f, -2.33523548e-01f,
  8.94570276e-02f, 9.05721560e-02f, 3.50548625e-02f, 4.25328426e-02f, -2.83673238e-02f, -1.15827695e-02f, -1.21059222e-02f, 6.38520112e-04f, -1.00811990e-02f, 8.04883987e-02f,
  5.91016486e-02f, 1.69156436e-02f, 4.83897775e-02f, -9.69202593e-02f, 9.78959948e-02f, 8.73111486e-02f, 3.94065641e-02f, -5.44302724e-02f, -2.86478493e-02f, -1.22859459e-02f,
  -7.37490952e-02f, 7.90410768e-03f, -1.60220582e-02f, -8.14272165e-02f, -6.40932694e-02f, 5.93024865e-02f, -3.33158597e-02f, 4.94667850e-02f, -4.02352661e-02f, -6.65519238e-02f,
  -6.82143494e-03f, -6.75151199e-02f, 6.15613684e-02f, 7.47478753e-02f, 4.01278511e-02f, -5.86913293e-03f, 2.86453143e-02f, 2.88974232e-04f, -5.99074177e-02f, 8.24730620e-02f,
  6.62889630e-02f, 1.98296569e-02f, 6.47018775e-02f, -3.61692123e-02f, -8.84787217e-02f, 5.04618473e-02f, -5.93629405e-02f, -3.83225339e-03f, -1.26827449e-01f, -2.49363109e-02f,
  1.07583199e-02f, 2.74875630e-02f, -7.54338354e-02f, -7.35193714e-02f, -6.32401109e-02f, 2.60728411e-02f, 6.63247555e-02f, 1.16630286e-01f, 3.55325155e-02f, 5.09695522e-02f,
  2.40323484e-01f, 1.00736983e-01f, 8.35348070e-02f, 4.72031496e-02f, 6.23422302e-02f, -1.33278444e-01f, 6.27092645e-02f, -2.84478124e-02f, -1.40224500e-02f, 1.13019995e-01f,
  -2.50859535e-03f, 4.17868346e-02f, 8.84096101e-02f, -5.93485869e-03f, -1.89204961e-02f, 5.10385558e-02f, 7.86184445e-02f, -1.56757627e-02f, -6.15831232e-03f, -6.38479218e-02f,
  6.37783408e-02f, 6.46160990e-02f, 1.50438055e-01f, 1.44069299e-01f, 6.87001869e-02f, 3.80775444e-02f, 2.83810105e-02f, 1.40829802e-01f, 1.64849520e-01f, 7.89452642e-02f,
  6.55006850e-03f, -2.76328772e-01f, 6.50159195e-02f, -1.27171010e-01f, -4.04664017e-02f, 1.17229536e-01f, -1.11212216e-01f, 7.04474971e-02f, 8.59323831e-04f, -9.67580974e-02f,
  -5.80164343e-02f, 3.99462432e-02f, 1.04841210e-01f, 9.65922046e-03f, 5.82210235e-02f, -6.96899220e-02f, -9.99495238e-02f, 1.35093778e-01f, 2.32512772e-01f, 2.19880342e-01f,
  -3.75934392e-02f, -2.45453641e-02f, 8.01307783e-02f, -2.88495291e-02f, -4.54391949e-02f, 4.18904535e-02f, -1.69668466e-01f, -1.48110598e-01f, -7.11157247e-02f, -3.18921626e-01f,
  1.35050276e-02f, 1.12779243e-02f, 1.60728171e-01f, 8.08426272e-03f, -2.61499528e-02f, -2.67672408e-02f, 1.57369543e-02f, -3.17349173e-02f, -2.77289152e-02f, -7.53044188e-02f,
  -1.00894444e-01f, -1.81499887e-02f, -2.94864327e-02f, -1.79787762e-02f, 7.01644793e-02f, 8.41530710e-02f, -2.41397619e-02f, 7.47380555e-02f, 3.22448388e-02f, 2.90655829e-02f,
  -6.18515611e-02f, -2.38779932e-02f, 9.78772491e-02f, 5.42095490e-02f, 6.58212453e-02f, 1.24804311e-01f, -1.43608954e-02f, -1.65304933e-02f, 8.04215968e-02f, -7.97942802e-02f,
  -4.44404781e-02f, -4.10266817e-02f, 4.34134007e-02f, -3.96603458e-02f, -3.90026066e-03f, 1.73303764e-02f, -8.70488733e-02f, 3.05614881e-02f, 5.38959280e-02f, -5.05709127e-02f,
  -4.39414522e-03f, 6.29924238e-02f, 3.51695269e-02f, 7.81251770e-03f, -5.28079681e-02f, -3.74848992e-02f, -3.17456499e-02f, -6.89262571e-03f, 1.03608795e-01f, 3.96026373e-02f,
  8.12109280e-03f, -1.09998947e-02f, -1.59593653e-02f, 3.13737281e-02f, -6.39694184e-02f, 6.26495779e-02f, -5.13346270e-02f, 1.75336860e-02f, -7.09307194e-02f, -7.71433562e-02f,
  9.30917263e-02f, 1.97928652e-01f, -8.96857008e-02f, 9.19215195e-03f, -8.33876804e-02f, -3.85563187e-02f, -7.64429569e-02f, 5.00819832e-02f, 4.50584572e-03f, 2.27429550e-02f,
  7.34501034e-02f, 4.10804190e-02f, -7.05519691e-02f, 1.58301108e-02f, -2.21317187e-02f, -9.86616015e-02f, -5.21075539e-02f, -8.36368476e-04f, 8.49506482e-02f, -2.35259626e-02f,
  -2.39968020e-03f, 5.41510396e-02f, 1.04208589e-01f, -3.72031913e-03f, 1.03467271e-01f, 1.07204631e-01f, 1.16337661e-03f, 7.77968839e-02f, 1.86432377e-01f, -3.25461067e-02f,
  -7.98508972e-02f, -8.45712051e-03f, -1.68461397e-01f, -7.67662674e-02f, -1.87229905e-02f, -1.31982863e-01f, -1.20535351e-01f, 9.38277319e-02f, -1.77866053e-02f, -6.35212287e-02f,
  3.27130407e-02f, -9.02615637e-02f, 3.12307663e-02f, -1.31570891e-01f, -1.17128789e-01f, -4.43840139e-02f, -2.52185110e-02f, -2.03468621e-01f, -2.12327570e-01f, -9.57155451e-02f,
  -9.88676921e-02f, -1.20949082e-01f, -1.60040572e-01f, -1.03903760e-03f, -5.91992177e-02f, 3.93201560e-02f, -8.86081085e-02f, -8.79985467e-02f, -8.27704370e-02f, -1.90319747e-01f,
  -2.59210207e-02f, 3.10486406e-02f, 2.76757814e-02f, -7.80368736e-03f, 5.32072224e-02f, -3.08128446e-02f, 5.53536341e-02f, 7.13256095e-03f, 3.71815898e-02f, 4.53716784e-04f,
  8.18549320e-02f, 4.56326865e-02f, 3.54243815e-02f, -1.96967870e-02f, -3.67270363e-03f, -5.24279363e-02f, 2.06272919e-02f, 5.61802983e-02f, -7.89131820e-02f, -5.20059690e-02f,
  1.72722973e-02f, -5.96574061e-02f, 7.72901773e-02f, 1.19280718e-01f, 3.32541838e-02f, -1.09339207e-01f, 9.32832062e-02f, 7.71660432e-02f, 5.13638258e-02f, 1.11276194e-01f,
  -7.59570226e-02f, -1.16128726e-02f, -6.60297349e-02f, 3.32851000e-02f, -1.82814952e-02f, 8.30217302e-02f, 5.25591001e-02f, -4.33637910e-02f, -2.27504987e-02f, 5.87955602e-02f,
  1.93562396e-02f, -4.44530435e-02f, -2.30010543e-02f, 5.13866916e-02f, 4.22110632e-02f, 5.02700964e-03f, 1.90325920e-02f, -7.00956583e-02f, 4.09944579e-02f, -5.99645711e-02f,
  -3.99215259e-02f, 8.06308463e-02f, -3.26135755e-02f, 7.91184790e-03f, 4.34045158e-02f, -3.15312333e-02f, 1.08746318e-02f, -6.41676709e-02f, -2.86488351e-03f, 1.36912894e-02f,
  -1.70266032e-02f, -9.48353186e-02f, -5.42555973e-02f, 5.72526529e-02f, -5.87004609e-02f, 2.46211365e-02f, -4.72813100e-02f, 1.47759035e-01f, 7.92571828e-02f, -4.12256084e-02f,
  -4.61370051e-02f, 4.89434414e-02f, 7.01291533e-03f, 5.74560910e-02f, -5.98771460e-02f, -2.27979813e-02f, 6.09708875e-02f, -2.32304335e-02f, -5.11892997e-02f, 3.90880518e-02f,
  7.79103264e-02f, -3.29802558e-02f, -3.58111747e-02f, 1.14574790e-01f, 1.32626053e-02f, -8.15673843e-02f, 7.96418712e-02f, -4.60650353e-03f, -8.37089587e-03f, 2.26734001e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.15352893e-02f, -1.48885190e-01f, -6.25967681e-02f, 1.37668177e-01f, 1.29521891e-01f, 1.43443599e-01f, 6.26624525e-02f, 7.48409703e-02f, 1.51598617e-01f, 3.41436500e-03f,
  1.38690621e-02f, 9.51653644e-02f, 9.67178643e-02f, 1.34308890e-01f, 3.98786478e-02f, 1.28526194e-02f, 2.92927064e-02f, 5.96005507e-02f, 8.51379037e-02f, 5.85424080e-02f,
  8.52546021e-02f, -2.93738805e-02f, 1.73789263e-02f, 3.55548598e-02f, -6.04918413e-02f, 3.81486043e-02f, -4.32551280e-03f, 1.56023877e-03f, -7.74660185e-02f, 2.37807017e-02f,
  -4.62973118e-03f, -1.17513202e-01f, 1.36805445e-01f, 5.65495044e-02f, -4.08495851e-02f, 3.47889736e-02f, 1.09106503e-01f, -1.14983007e-01f, -7.40225241e-02f, 4.43060137e-02f,
  -2.61320062e-02f, -1.15484986e-02f, 7.01375157e-02f, -2.39768568e-02f, -5.91693670e-02f, -7.07837865e-02f, -1.16048895e-01f, 3.57682817e-02f, -5.70669882e-02f, -8.73589814e-02f,
  1.91576574e-02f, 3.74328233e-02f, -5.39175943e-02f, -5.91368303e-02f, 5.09448051e-02f, 9.52568352e-02f, 5.24319224e-02f, -9.85668451e-02f, 8.26591179e-02f, -7.79423714e-02f,
  1.29130244e-01f, -7.61682838e-02f, -6.47846609e-02f, 5.00312336e-02f, 1.04858093e-01f, -8.00154917e-03f, -3.22651193e-02f, -3.06091327e-02f, 6.46167621e-02f, 2.24623084e-02f,
  7.00360462e-02f, 9.72868949e-02f, 3.26669626e-02f, 8.93386826e-03f, -5.12998775e-02f, -4.12295908e-02f, -7.98596740e-02f, 4.66824062e-02f, -1.38918804e-02f, -7.76854903e-03f,
  -6.24086857e-02f, -1.73017532e-02f, -2.81128194e-02f, -6.24993369e-02f, 1.21909762e-02f, 3.08048204e-02f, 1.94113478e-02f, -3.28192636e-02f, 4.94340509e-02f, -1.03710696e-01f,
  -1.43972486e-02f, 4.88642454e-02f, -4.87337727e-03f, 9.64005420e-04f, -8.83519799e-02f, -6.92391619e-02f, 3.66442651e-02f, 2.08500251e-02f, -9.56856087e-02f, -6.75209984e-02f,
  -9.03922915e-02f, 7.14331791e-02f, -5.17275631e-02f, -8.82467628e-02f, 8.36026967e-02f, -2.60325894e-02f, -8.90338272e-02f, 3.71298455e-02f, -1.88063420e-02f, -9.37193111e-02f,
  3.66593860e-02f, 6.48216233e-02f, 3.24044861e-02f, 5.96603788e-02f, -6.48490340e-02f, 1.16377994e-01f, -5.96718378e-02f, 3.11645921e-02f, 5.94655499e-02f, 1.00483753e-01f,
  -1.91521440e-02f, 2.00019460e-02f, -6.83668405e-02f, 7.84156322e-02f, 1.12885401e-01f, -3.39533053e-02f, 5.04484214e-03f, 4.27998304e-02f, 6.24365173e-03f, -2.21374147e-02f,
  -6.23314232e-02f, 8.23132321e-02f, -2.28577829e-03f, -8.10497627e-02f, 7.34352544e-02f, 1.46913767e-01f, -9.55695659e-03f, 5.54571748e-02f, -2.99484096e-02f, -7.89587125e-02f,
  8.21250156e-02f, -7.10809277e-03f, 2.32593045e-02f, -5.30202091e-02f, 1.17688388e-01f, -4.09857780e-02f, 4.06575687e-02f, 7.59160444e-02f, 1.49048511e-02f, 1.11759389e-02f,
  -9.02535468e-02f, 4.28796895e-02f, -5.18413968e-02f, 5.01742251e-02f, -6.82148039e-02f, -4.50145677e-02f, 5.22044823e-02f, 1.70043055e-02f, -4.55319844e-02f, -9.36334059e-02f,
  3.68204862e-02f, 7.31878157e-04f, 3.53271863e-03f, 2.14249343e-02f, 6.00336865e-02f, -8.36424381e-02f, 8.42552409e-02f, 2.59293690e-02f, -2.29562866e-03f, -9.19832438e-02f,
  1.19739911e-03f, -3.55778635e-02f, -5.13389893e-02f, -5.20497635e-02f, 4.22065668e-02f, -5.88638484e-02f, -4.69528651e-03f, 5.13162576e-02f, -9.31709260e-02f, -9.27877203e-02f,
  5.54879904e-02f, -6.52469415e-03f, -3.16113117e-03f, -3.51373246e-03f, 6.28912225e-02f, -5.66801764e-02f, 8.75488743e-02f, -3.69233079e-02f, -4.18485515e-02f, 2.29596402e-02f,
  -6.15375042e-02f, -3.15235630e-02f, -2.51458790e-02f, 4.43373658e-02f, -4.81808148e-02f, -1.48145789e-02f, 4.41916995e-02f, 3.32288556e-02f, 3.41622978e-02f, -5.76602966e-02f,
  5.05974367e-02f, 2.72321654e-03f, -7.22636878e-02f, -2.57763211e-02f, -5.54832593e-02f, -3.88321802e-02f, -3.20967264e-03f, -3.74889858e-02f, 7.43779242e-02f, -5.64543121e-02f,
  -4.08665836e-02f, -1.03742696e-01f, -3.48250307e-02f, -3.53461690e-02f, 1.72126405e-02f, 5.51023446e-02f, -3.35336030e-02f, 2.17426885e-02f, -7.17848837e-02f, 4.57131714e-02f,
  3.57890278e-02f, 9.48390341e-04f, -6.50160685e-02f, -3.23654637e-02f, 7.38412933e-03f, 1.77332275e-02f, 1.33540984e-02f, 4.00839699e-03f, 7.88753852e-02f, -5.18718921e-02f,
  2.16559563e-02f, 3.62738743e-02f, 1.50579726e-02f, 3.01432759e-02f, -4.49085571e-02f, 6.31571785e-02f, -5.63897826e-02f, -9.59542468e-02f, 4.55180258e-02f, -2.65002232e-02f,
  2.53978688e-02f, -6.42236089e-03f, -4.70952764e-02f, 1.07772112e-01f, -4.44032960e-02f, -2.25856677e-02f, -1.59965262e-01f, 3.31863537e-02f, -4.35541151e-03f, -5.47856390e-02f,
  3.13368216e-02f, 7.78317526e-02f, -4.13932353e-02f, -6.50392175e-02f, 4.37796414e-02f, -9.26537067e-02f, -1.08700000e-01f, 2.38476675e-02f, 6.86788484e-02f, 2.41700932e-02f,
  3.95972878e-02f, 8.60703513e-02f, 5.44454679e-02f, -7.75499130e-03f, -6.96353093e-02f, -4.59822007e-02f, -5.58670759e-02f, 5.36113046e-02f, -1.13411456e-01f, -3.39345895e-02f,
  -7.04323724e-02f, -1.53598841e-02f, -4.05317172e-02f, -8.17919597e-02f, -9.53997076e-02f, 5.73877208e-02f, 1.75360683e-02f, -3.55875380e-02f, -6.39279233e-03f, 1.32896993e-02f,
  -5.12348488e-03f, -6.66408858e-04f, 3.66705395e-02f, -5.81974536e-02f, 8.61736387e-03f, -8.54552835e-02f, -2.48763189e-02f, -3.02717276e-02f, 1.85733549e-02f, -5.38345464e-02f,
  -1.21483523e-02f, -9.88951325e-02f, -1.04135521e-01f, 3.66946869e-02f, -6.28199354e-02f, 4.81003150e-02f, 1.66985001e-02f, 7.03195110e-02f, -1.97486226e-02f, -6.05286583e-02f,
  -5.77248409e-02f, 5.69243208e-02f, -1.02231510e-01f, 8.97908807e-02f, -3.79553214e-02f, -9.69960704e-04f, -4.92225587e-03f, 5.45662232e-02f, -7.31498599e-02f, -2.05502212e-02f,
  -3.52059118e-02f, 5.52687831e-02f, 2.84466725e-02f, -7.15939002e-03f, -4.22744118e-02f, -4.87462841e-02f, -6.48706034e-02f, -1.90043654e-02f, 2.15065349e-02f, -1.14928149e-02f,
  -6.43773079e-02f, 4.00415994e-02f, -6.25827014e-02f, -9.81888101e-02f, 2.80673802e-02f, 8.02904461e-03f, -5.66001125e-02f, -5.08001298e-02f, -2.07131654e-02f, -2.36569569e-02f,
  1.26566753e-01f, -4.94065089e-03f, 2.43972149e-02f, -7.84009025e-02f, -4.57213372e-02f, -6.33309782e-03f, 3.40528712e-02f, -3.33839469e-02f, 3.05734128e-02f, -4.90410104e-02f,
  -3.26183951e-03f, -5.76305203e-02f, 7.55326524e-02f, 1.01346737e-02f, 1.36034517e-02f, 2.35983147e-03f, -7.25775808e-02f, -2.71886634e-03f, -1.11363875e-02f, -4.16126437e-02f,
  -3.16741168e-02f, -2.01861318e-02f, 1.48917567e-02f, -7.57505968e-02f, 2.40978282e-02f, -7.67124146e-02f, 2.01615673e-02f, -7.78515488e-02f, -5.62577695e-02f, -9.48284939e-02f,
  -5.54954000e-02f, 9.10152793e-02f, -1.30700693e-01f, 1.01761632e-01f, 4.97352369e-02f, 8.70066062e-02f, -3.06673162e-02f, -4.29087617e-02f, -3.55377793e-02f, 3.01429722e-02f,
  -1.19301900e-01f, 8.63288343e-02f, 4.24249843e-02f, 1.82559341e-02f, 1.25010416e-01f, 7.49466419e-02f, 3.90466191e-02f, 5.40796369e-02f, 1.15315998e-02f, -1.90363210e-02f,
  1.36699274e-01f, 9.28295590e-03f, 3.72424759e-02f, 9.95991305e-02f, 1.15920585e-02f, -3.52931209e-02f, 7.08725452e-02f, 5.09535782e-02f, 1.11153640e-01f, 1.69558123e-01f,
  -1.26591757e-01f, -1.32824808e-01f, -8.87580961e-02f, -5.84441200e-02f, -8.56266543e-02f, -7.05488101e-02f, 2.58413348e-02f, 1.34489033e-02f, -9.77847800e-02f, -3.41040716e-02f,
  8.98565128e-02f, -8.13953206e-02f, 1.24881327e-01f, -7.74633735e-02f, 2.81329099e-02f, -4.95569594e-02f, -1.74064301e-02f, -5.98058775e-02f, 3.11318017e-03f, 3.84082124e-02f,
  1.36064485e-01f, 1.16789825e-01f, -6.35720696e-03f, 2.88153682e-02f, -2.18703244e-02f, -8.23592618e-02f, -4.66362312e-02f, -6.11471906e-02f, -4.46638688e-02f, -4.49915379e-02f,
  2.24798103e-03f, 9.01598483e-03f, 4.87032980e-02f, -9.50334445e-02f, 4.50354926e-02f, -3.36627960e-02f, 5.49314953e-02f, 2.33031772e-02f, 1.78902876e-02f, 3.55437249e-02f,
  -1.32437330e-02f, 1.71375796e-02f, 1.89533904e-02f, 1.23656122e-02f, -9.50392801e-03f, -1.47249969e-02f, 7.97209740e-02f, 2.28552744e-02f, 2.68316846e-02f, -9.74535272e-02f,
  -4.28273417e-02f, -6.93730861e-02f, -4.61782962e-02f, 6.25195950e-02f, 2.85589043e-02f, -9.47085693e-02f, 1.85382403e-02f, -2.78211571e-03f, 2.42597796e-02f, -7.43023604e-02f,
  -1.55325353e-01f, -1.85261965e-01f, -3.62858698e-02f, -8.25128611e-03f, 4.04084213e-02f, -1.18552439e-01f, -9.93640497e-02f, 1.92654431e-02f, 2.18625702e-02f, -5.42272106e-02f,
  4.76960726e-02f, 5.29066101e-02f, -5.27568236e-02f, -1.02836695e-02f, -2.22859066e-02f, -4.82171439e-02f, -9.47564393e-02f, -1.76373683e-02f, -5.83323911e-02f, -5.31793460e-02f,
  6.90397024e-02f, -4.88467216e-02f, -7.12842867e-02f, 2.38505639e-02f, -6.55516386e-02f, -8.46072510e-02f, -6.03217520e-02f, -3.34852412e-02f, -2.16017198e-02f, -6.35626838e-02f,
  1.80484071e-01f, -9.46855173e-02f, -1.81758851e-01f, 2.38027181e-02f, -7.50507861e-02f, -1.45936701e-02f, 3.38771790e-02f, -6.49040099e-03f, -7.27819949e-02f, 1.36525650e-02f,
  -1.88116711e-02f, -3.29796784e-02f, -1.04109421e-02f, 9.43313241e-02f, 1.07872263e-01f, -9.28996503e-02f, 4.05578725e-02f, 3.78665328e-02f, 9.58679095e-02f, 6.28546625e-02f,
  -1.23552019e-02f, -1.51810432e-02f, -2.72988016e-03f, -3.17325890e-02f, -1.32228702e-01f, -6.87315091e-02f, -8.94152895e-02f, -1.19346619e-01f, -1.47507310e-01f, -3.61512303e-02f,
  -6.74943477e-02f, -2.46072542e-02f, 1.23837262e-01f, 7.03891143e-02f, 2.75426991e-02f, 9.46673602e-02f, 4.89407890e-02f, -2.02277731e-02f, 4.50575948e-02f, -1.15414625e-02f,
  4.43097856e-03f, -1.10166585e-02f, -1.63311288e-02f, -7.12357014e-02f, -5.70715293e-02f, -2.69864537e-02f, -5.71829975e-02f, -1.22598782e-02f, -3.52937654e-02f, -4.94494918e-04f,
  6.48927614e-02f, 6.16744347e-02f, 2.55400855e-02f, 8.39794055e-02f, 7.30055943e-02f, 2.43891403e-02f, 5.30294068e-02f, 2.21413225e-02f, 2.10877005e-02f, -5.31978048e-02f,
  -2.97598671e-02f, 1.41210575e-02f, -7.32329488e-02f, -4.44502085e-02f, 8.54375288e-02f, 6.87646940e-02f, 2.90066954e-02f, 2.47236863e-02f, -9.08673108e-02f, -2.59374939e-02f,
  -3.36321294e-02f, -1.13029443e-01f, -8.78078341e-02f, 6.59065172e-02f, -3.62095045e-04f, -2.06058403e-03f, 1.08438194e-01f, -3.83816399e-02f, -7.49586523e-02f, 5.74847348e-02f,
  -2.18895599e-02f, -6.68855384e-02f, 9.26600583e-03f, -4.91432548e-02f, -8.03954899e-02f, 4.00703773e-02f, 3.57628167e-02f, 2.55091395e-02f, 2.43608076e-02f, -9.07611549e-02f,
  -9.11448449e-02f, 2.30776612e-02f, 5.05731404e-02f, 6.08500056e-02f, -2.47102287e-02f, 3.35304961e-02f, -4.45242412e-02f, 2.26601046e-02f, -6.96428046e-02f, 4.60303091e-02f,
  -1.13105729e-01f, -7.77917057e-02f, 7.38021871e-03f, -3.51950270e-03f, 2.41506305e-02f, -2.43318230e-02f, 6.69602007e-02f, -6.21541105e-02f, -1.08675018e-01f, -6.75481409e-02f,
  -1.15025640e-01f, 1.37550384e-01f, 6.21747524e-02f, 1.02287561e-01f, -4.36958333e-04f, 3.78435440e-02f, 9.46084335e-02f, -9.04867426e-03f, 5.78048714e-02f, 5.42360470e-02f,
  1.11878090e-01f, -3.70009094e-02f, 4.29750495e-02f, 7.29747266e-02f, 6.01872355e-02f, -9.36259255e-02f, -1.60347328e-01f, 2.30887979e-02f, 5.83599396e-02f, 4.41624634e-02f,
  -5.56692407e-02f, -2.51258519e-02f, -2.51251571e-02f, 5.76931797e-02f, -1.03855610e-01f, 7.55204260e-02f, -5.02906404e-02f, 4.10309024e-02f, -5.52767478e-02f, -2.12878026e-02f,
  -1.69027671e-02f, -5.75121352e-03f, -2.58305706e-02f, 9.60766058e-03f, 1.32793531e-01f, 6.90043867e-02f, 2.34093424e-02f, -4.34465997e-04f, -3.17807086e-02f, 1.29144594e-01f,
  1.53451875e-01f, -5.93769737e-03f, -4.06776257e-02f, 2.68028192e-02f, 1.03249095e-01f, 3.40200067e-02f, -3.15705426e-02f, 1.51156057e-02f, -6.46436810e-02f, 1.22144140e-01f,
  3.34801152e-02f, 1.08117118e-01f, -5.77699803e-02f, 8.92672464e-02f, 9.17734578e-02f, 1.74191762e-02f, 1.75446123e-02f, 7.07614720e-02f, 2.27303300e-02f, -5.37561290e-02f,
  7.22006485e-02f, 6.85769394e-02f, -9.16159060e-03f, -6.31064773e-02f, -6.38983473e-02f, -3.19906957e-02f, -2.28680015e-04f, 9.72137526e-02f, 6.48397133e-02f, -4.32892591e-02f,
  2.41019297e-02f, 2.15658825e-02f, -4.66747843e-02f, -2.07575969e-02f, 5.03277741e-02f, 7.99662694e-02f, -6.96858100e-04f, 7.95166194e-02f, -6.74370304e-02f, -8.43186155e-02f,
  -2.05227006e-02f, -2.27626171e-02f, -5.37224263e-02f, -1.11759752e-02f, 6.87210485e-02f, 7.53397942e-02f, 3.28599405e-03f, -3.47611234e-02f, 6.90414459e-02f, 3.45310681e-02f,
  -6.26393631e-02f, 7.82327503e-02f, -7.75148720e-02f, 3.37062851e-02f, -8.09467956e-02f, -1.15727857e-02f, -4.03827839e-02f, 3.81325670e-02f, 7.99945146e-02f, 8.91844109e-02f,
  7.69660622e-02f, 4.00411151e-02f, 4.58710790e-02f, -2.11190879e-02f, 3.80890779e-02f, -3.43211703e-02f, -5.68587594e-02f, 3.14261466e-02f, -1.88547447e-02f, -3.18280719e-02f,
  -3.80177982e-02f, 1.06939105e-02f, -4.34588417e-02f, -5.94416447e-02f, 1.08656473e-02f, -7.34352767e-02f, 3.77208106e-02f, -1.13318615e-01f, 1.80127658e-02f, 4.62185368e-02f,
  -7.77114779e-02f, -9.87273455e-02f, -1.14173412e-01f, -2.55724625e-03f, -7.86636770e-02f, -4.51770574e-02f, -3.97759350e-03f, -6.19254075e-02f, -6.28954545e-02f, -1.69619322e-01f,
  1.84312258e-02f, -5.98016568e-02f, 8.68466496e-02f, 4.18546982e-02f, 5.05023189e-02f, -2.75728274e-02f, -1.29702007e-02f, 5.04774898e-02f, 4.89445329e-02f, 9.60625336e-02f,
  -8.08328763e-02f, 1.16209656e-01f, 1.17053054e-01f, 1.17830664e-01f, -1.79277814e-03f, 1.34366855e-01f, 3.59030142e-02f, 1.17915377e-01f, 6.87908158e-02f, 1.82899404e-02f,
  1.56091517e-02f, 3.52268517e-02f, -1.50665967e-02f, 5.19517809e-02f, 8.92283991e-02f, 8.44357237e-02f, 1.07246689e-01f, -7.02049881e-02f, -2.43198639e-03f, 8.43592659e-02f,
  1.00654392e-02f, 7.35875918e-03f, 1.20886080e-02f, -2.38488764e-02f, 1.46813318e-02f, -1.77182555e-02f, 1.76672209e-02f, 5.79917338e-03f, -8.33290517e-02f, 1.33217014e-02f,
  -8.37101638e-02f, 4.22598794e-02f, -4.08641584e-02f, 3.67872743e-03f, -6.46153465e-02f, -1.91330984e-02f, -9.72100347e-02f, 1.19785545e-02f, 6.15453869e-02f, 4.15425003e-03f,
  -5.38388230e-02f, -7.34076351e-02f, -6.97154701e-02f, -1.91080477e-02f, -2.16225684e-02f, 4.54331897e-02f, -8.61209929e-02f, -3.17948461e-02f, 6.61840364e-02f, -1.06277200e-03f,
  -5.51081710e-02f, 6.86232743e-05f, 1.41252251e-02f, 8.37089270e-02f, -1.74623355e-02f, -3.49482559e-02f, 6.89231083e-02f, 3.96086462e-03f, -4.13825875e-03f, 9.48934536e-03f,
  -8.12807977e-02f, 9.03072432e-02f, 9.34707448e-02f, 1.16510224e-02f, -3.50770541e-02f, -1.69005934e-02f, -2.84414142e-02f, 2.94974446e-02f, -4.85780947e-02f, -5.17509617e-02f,
  -2.45820358e-03f, 7.64454657e-04f, -3.34955119e-02f, 4.76468401e-03f, 1.83183104e-02f, 3.34544331e-02f, 2.93584447e-02f, 5.92643619e-02f, -7.84670003e-03f, 4.56981035e-03f,
  -4.79171686e-02f, -2.57499125e-02f, 1.00810245e-01f, -9.22650937e-03f, -3.92653681e-02f, 4.27128859e-02f, -3.02752350e-02f, -8.64873305e-02f, -7.58062452e-02f, -1.95301580e-03f,
  -1.23330764e-02f, 6.13698028e-02f, -9.02545005e-02f, -1.43650398e-02f, 7.40755573e-02f, -7.69995479e-03f, -8.22853446e-02f, 1.00250684e-01f, 6.32721633e-02f, -8.24467167e-02f,
  8.05751085e-02f, 5.17283380e-02f, 2.67141201e-02f, 6.05657808e-02f, 1.14945553e-01f, -4.89508957e-02f, -2.06379662e-03f, -6.00800961e-02f, 5.18195145e-02f, 4.92427647e-02f,
  -1.58551112e-01f, -1.10486925e-01f, -1.19054481e-01f, 2.09967922e-02f, -8.96214470e-02f, -4.61930037e-02f, -1.14013173e-01f, -1.40592679e-02f, 3.17073846e-03f, -1.07184365e-01f,
  8.78546573e-03f, 9.59031656e-02f, 8.92356224e-03f, 1.24538802e-02f, -8.63784775e-02f, -1.42428830e-01f, -2.13679627e-01f, -1.86524406e-01f, -3.98792289e-02f, 4.86839265e-02f,
  2.10359972e-02f, -1.13951312e-02f, -1.40537217e-01f, 3.36595695e-03f, -6.52138963e-02f, -5.29811829e-02f, -8.37524384e-02f, 2.26362366e-02f, -8.37708712e-02f, -4.87028211e-02f,
  -4.58701588e-02f, 9.95748937e-02f, 4.31530513e-02f, -1.44719347e-01f, -2.72446498e-02f, -8.42428505e-02f, 1.67774409e-02f, 4.75627594e-02f, 5.48657291e-02f, 8.87341797e-02f,
  -6.74964935e-02f, -4.21528742e-02f, -6.52016699e-03f, -2.71443427e-02f, -5.36339171e-03f, -4.70829345e-02f, -5.24952263e-02f, -1.51303811e-02f, 4.79298718e-02f, -1.16620529e-02f,
  -5.60830310e-02f, 7.06388615e-03f, -1.22032017e-02f, -7.37642217e-03f, 3.55549566e-02f, -9.18180402e-03f, 1.23296775e-01f, 9.94182006e-02f, -1.15043912e-02f, 1.09074377e-01f,
  -6.50463402e-02f, 8.53664428e-02f, -9.65166651e-03f, -5.91090620e-02f, -4.67431694e-02f, -1.24419527e-02f, 4.82282937e-02f, -2.83828471e-02f, -2.81132739e-02f, -9.68227442e-03f,
  -5.01344493e-03f, -1.02841012e-01f, -5.15917465e-02f, 5.63401096e-02f, 5.13824038e-02f, -2.49468088e-02f, -5.79170361e-02f, 4.80889305e-02f, -7.41709173e-02f, -6.12493567e-02f,
  2.05953699e-02f, -1.10786827e-02f, -3.82636338e-02f, -8.91525857e-03f, -7.82782882e-02f, -6.25970513e-02f, 9.10502970e-02f, 4.94948775e-03f, 7.74654150e-02f, 4.51626368e-02f,
  1.09192021e-01f, -1.24135621e-01f, -5.51985130e-02f, 1.02017894e-01f, 5.44237904e-02f, -1.10463366e-01f, 2.30402593e-02f, 3.09898071e-02f, -2.04888787e-02f, 3.65376547e-02f,
  7.63592124e-02f, 5.02572209e-02f, 2.27790810e-02f, 5.04236296e-02f, 5.15656099e-02f, 9.44263767e-03f, -6.95181787e-02f, -2.87196916e-02f, -2.10165046e-02f, 5.49290553e-02f,
  -8.26541036e-02f, -8.63857567e-02f, -2.88554095e-02f, 9.83508155e-02f, 1.00711830e-01f, 5.52716218e-02f, -1.33648198e-02f, 2.64012273e-02f, -1.06740901e-02f, -3.86846103e-02f,
  1.02198981e-01f, 1.07786313e-01f, 1.23091955e-02f, 4.16080579e-02f, -1.58992887e-01f, 1.46759872e-03f, -8.37142318e-02f, -1.53278997e-02f, -1.93744935e-02f, 7.33744651e-02f,
  -1.56882778e-03f, -8.23862851e-03f, -3.42625044e-02f, 4.69440259e-02f, -2.74891984e-02f, 8.33930820e-02f, 9.61555988e-02f, 9.95675549e-02f, 9.13504958e-02f, 4.52319682e-02f,
  8.68862122e-02f, 1.11794911e-01f, 2.38967035e-02f, 4.76379022e-02f, 1.34226382e-01f, -1.65780075e-02f, 5.86584620e-02f, -2.96504945e-02f, 7.89740533e-02f, 1.32919699e-01f,
  1.27733275e-01f, 9.06016454e-02f, -3.63726579e-02f, 2.79045366e-02f, 9.74492207e-02f, -2.06931457e-02f, 9.66848433e-02f, 5.92917837e-02f, -3.36664682e-03f, -4.64529768e-02f,
  8.05556178e-02f, -2.43389197e-02f, 4.43008244e-02f, 3.21460366e-02f, 5.38180657e-02f, 1.00745007e-01f, 1.31086539e-02f, 6.23697042e-02f, 7.94580951e-02f, -4.97313663e-02f,
  4.55571562e-02f, -3.48363109e-02f, -8.02306160e-02f, -6.90071285e-02f, 6.50577098e-02f, -5.30223958e-02f, -6.70428053e-02f, 5.63077480e-02f, -5.71875311e-02f, 4.65282392e-05f,
  8.25619251e-02f, 8.23642779e-03f, -7.45248841e-03f, -2.38346532e-02f, -4.63303216e-02f, -4.05536741e-02f, 5.33247599e-03f, -7.87318572e-02f, 7.12247193e-02f, -5.49440049e-02f,
  8.06533918e-03f, -4.34479229e-02f, -9.12922695e-02f, -3.08314767e-02f, -1.27376810e-01f, -7.23154023e-02f, 4.47705016e-02f, -9.71645676e-03f, -2.28758473e-02f, 3.23794317e-03f,
  1.02206662e-01f, 1.37017397e-02f, 2.79504862e-02f, 7.42259109e-03f, 3.49470298e-03f, 6.78965300e-02f, 1.48549769e-02f, -8.48048478e-02f, 5.80102243e-02f, 6.35049045e-02f,
  -1.03021018e-01f, -9.16154385e-02f, -3.87500934e-02f, 1.44747227e-01f, 1.32342428e-01f, 7.16531128e-02f, -4.59534936e-02f, -7.41792144e-03f, -5.57735115e-02f, 3.50990742e-02f,
  -1.03893481e-01f, 5.95100075e-02f, -4.52970751e-02f, 8.23188052e-02f, 3.30294147e-02f, -5.17288372e-02f, -5.62432669e-02f, 9.80193168e-02f, 5.64885028e-02f, 3.66241694e-03f,
  -9.06705856e-02f, -1.76599175e-02f, -1.03536658e-01f, -3.27048190e-02f, 8.85129627e-03f, -4.65369448e-02f, -3.53199393e-02f, -3.30791399e-02f, -8.06456581e-02f, -3.32140699e-02f,
  -2.74604827e-01f, 7.58289918e-02f, -4.77988087e-02f, -1.44717604e-01f, -5.00983335e-02f, 9.09178704e-02f, -1.02982074e-01f, -9.13502499e-02f, -5.70484772e-02f, -4.72154394e-02f,
  -3.00345048e-02f, -1.09930694e-01f, -1.53271854e-01f, -3.33181918e-02f, -6.95185885e-02f, -1.39017001e-01f, -6.74478784e-02f, -1.74903199e-01f, -8.36093128e-02f, -3.78208384e-02f,
  -1.19184203e-01f, -1.38290778e-01f, -9.65077654e-02f, -1.01682164e-01f, -4.59839366e-02f, 1.05821721e-01f, 5.88260740e-02f, 1.73637047e-02f, 4.64461222e-02f, -8.73548537e-02f,
  7.93702975e-02f, 5.67304157e-02f, -1.22612491e-02f, -3.81375849e-02f, -7.43358571e-04f, 5.79281375e-02f, -9.04997140e-02f, -3.32157761e-02f, -2.52204947e-02f, 2.31749713e-02f,
  -8.41466058e-03f, 5.07444097e-03f, -6.88510528e-03f, 5.29491454e-02f, 7.07379580e-02f, 1.05336970e-02f, 2.51021199e-02f, -3.63312289e-02f, 1.05353475e-01f, -1.50020039e-02f,
  -4.29351144e-02f, -5.95714934e-02f, 1.34455059e-02f, 8.35693926e-02f, 1.11225471e-01f, -8.74564126e-02f, 3.88345607e-02f, 2.88756937e-02f, 8.50029811e-02f, 8.93299282e-03f,
  -4.29857746e-02f, 6.29748392e-05f, 1.05017535e-02f, 3.88173386e-02f, 3.87654342e-02f, 2.79635228e-02f, 4.82218117e-02f, -3.57518531e-02f, -9.69477519e-02f, 1.91022810e-02f,
  -8.09607282e-02f, 4.71941382e-02f, -8.60614926e-02f, -6.65504485e-02f, 6.38217852e-02f, -1.33786593e-02f, -3.08580995e-02f, 5.64173497e-02f, 6.26789927e-02f, -7.81408325e-03f,
  1.06224045e-01f, 4.20218036e-02f, -5.45143411e-02f, 1.25080004e-01f, 6.51336387e-02f, -4.06109914e-03f, 4.63636518e-02f, -1.97258946e-02f, 6.02282509e-02f, -5.88879362e-02f,
  -4.84046265e-02f, -6.65315464e-02f, -8.41325447e-02f, -1.03581259e-02f, 1.56678781e-02f, 8.06107819e-02f, -1.37701845e-02f, 2.43507177e-02f, -3.08995061e-02f, 4.86783125e-02f,
  3.23178060e-02f, 4.16357145e-02f, -4.05256217e-03f, -5.78872152e-02f, -5.48655055e-02f, 1.34327030e-03f, -2.83094421e-02f, 7.24186236e-03f, 5.33356182e-02f, 1.17113017e-01f,
  2.76512038e-02f, -7.47003313e-03f, -7.35860467e-02f, 4.96570356e-02f, 2.98333745e-02f, -4.60494272e-02f, 4.70619053e-02f, 2.69607715e-02f, -6.86732978e-02f, -3.31536904e-02f,
  1.30925626e-02f, -3.65817882e-02f, 6.50642887e-02f, 8.93461984e-03f, -7.82171637e-02f, -5.12829574e-04f, 7.25611905e-03f, 8.41926336e-02f, 1.65075995e-02f, -6.20230101e-02f,
  -4.66044806e-02f, 1.12195782e-01f, -2.87600458e-02f, 1.19446933e-01f, 5.67293167e-02f, -9.84848887e-02f, -3.93840112e-02f, -5.55130013e-04f, 2.46991888e-02f, -7.30283409e-02f,
  -8.62575136e-03f, -7.11854547e-02f, 5.93597069e-02f, 4.86286096e-02f, -3.94733213e-02f, -9.03068930e-02f, -1.39168233e-01f, -7.12671801e-02f, 5.93487322e-02f, -1.36157140e-01f,
  -7.94981867e-02f, 1.25265479e-01f, 7.25127384e-02f, 1.09920971e-01f, -1.76110528e-02f, -7.90493041e-02f, 9.91078466e-02f, 8.59575495e-02f, 1.68692172e-02f, 1.99837945e-02f,
  -5.34162223e-02f, -5.16877659e-02f, -6.96234927e-02f, -8.59995112e-02f, -4.73954864e-02f, 1.71646159e-02f, 7.26274699e-02f, 1.24915019e-01f, 1.03085220e-01f, 6.34612069e-02f,
  6.53227977e-03f, 9.80564579e-02f, -7.86791556e-03f, -3.44479457e-02f, 2.10043583e-02f, -8.89222044e-03f, 7.34336069e-03f, 4.58963290e-02f, 1.06068507e-01f, 7.19981492e-02f,
  -4.72710729e-02f, 1.20316483e-02f, 8.24669674e-02f, -4.16193157e-02f, -9.19234678e-02f, 5.69864847e-02f, -2.63985060e-02f, 1.20063731e-02f, 5.52272387e-02f, -5.68130612e-02f,
  1.20544748e-03f, 1.36478078e-02f, 1.97209418e-03f, -7.67989680e-02f, 3.64684314e-02f, 9.97653306e-02f, -5.98075148e-03f, -8.07216577e-03f, -5.14748283e-02f, -7.31907366e-03f,
  -2.80566653e-03f, 2.65581869e-02f, 8.25792626e-02f, -7.88278580e-02f, 9.90731269e-02f, -3.45272794e-02f, -1.30705992e-02f, -2.24105846e-02f, -2.38100141e-02f, -5.32009564e-02f,
  -4.41740304e-02f, 1.68479115e-01f, 5.41105960e-03f, 3.27104032e-02f, 1.95113067e-02f, -4.64813504e-03f, -8.46661553e-02f, -4.51666713e-02f, -4.44406755e-02f, -2.51361486e-02f,
  -5.24372095e-03f, -4.28113788e-02f, 1.45945698e-02f, 2.75475383e-02f, 6.03626817e-02f, 1.00898473e-02f, 2.49264836e-02f, -5.75730465e-02f, 1.12180412e-01f, 1.91136487e-02f,
  4.20684628e-02f, -4.44630980e-02f, 5.82557311e-03f, 8.43904912e-02f, 9.68717486e-02f, 5.87942488e-02f, 5.67184351e-02f, 3.86648104e-02f, 8.88725147e-02f, -1.32049501e-01f,
  -8.58654082e-02f, -7.92797953e-02f, -2.76464876e-02f, 6.90822606e-04f, 2.85355113e-02f, 5.29666878e-02f, -3.23986150e-02f, -1.59527268e-02f, 2.83933152e-02f, -8.34373757e-02f,
  4.99973781e-02f, -2.23380197e-02f, 5.08148186e-02f, -8.02198872e-02f, -1.18964620e-01f, -2.15787813e-01f, -1.53508425e-01f, -5.89169711e-02f, 8.43242407e-02f, 4.99091558e-02f,
  -1.22774625e-02f, -3.83067988e-02f, 6.74582571e-02f, 8.53051692e-02f, -2.73950342e-02f, -7.55673870e-02f, -7.91078154e-03f, -7.18675926e-02f, -1.21649392e-01f, -9.17642564e-02f,
  -8.94751325e-02f, -9.79226315e-04f, -1.32910889e-02f, -5.97119890e-02f, 4.03374955e-02f, 8.31180513e-02f, 1.54779805e-02f, 1.05788767e-01f, 8.77158642e-02f, 5.88139286e-03f,
  -5.62965497e-02f, -3.86819132e-02f, -1.80857684e-02f, -1.45822205e-02f, 2.29719281e-02f, 8.48791152e-02f, -4.56924066e-02f, -2.19416208e-04f, 1.96774378e-02f, -3.83842178e-02f,
  -7.97363347e-04f, 2.78974045e-02f, -1.65857568e-01f, 8.13508313e-03f, -7.91195035e-02f, 6.13090098e-02f, 2.36330759e-02f, -2.99210418e-02f, -2.22330168e-02f, -1.90726921e-01f,
  -8.64300877e-04f, -2.97150947e-02f, -5.89079522e-02f, -2.99128015e-02f, -1.66273713e-02f, -3.11928913e-02f, 9.72000975e-03f, -2.02654190e-02f, 1.89878885e-02f, 9.79835168e-03f,
  6.67850301e-02f, 4.24918532e-02f, 6.30768836e-02f, 1.59930177e-02f, -3.25334407e-02f, 1.81001157e-03f, 6.36321753e-02f, -6.37741983e-02f, -9.14476141e-02f, 4.38093208e-02f,
  -1.65996682e-02f, -7.07475245e-02f, 4.68888506e-02f, -2.49031466e-02f, -4.08580638e-02f, 4.05618139e-02f, 2.89564803e-02f, -3.30463573e-02f, -1.69148203e-02f, 7.14390576e-02f,
  -1.03845023e-01f, -1.42609375e-02f, -2.70084068e-02f, 4.90183085e-02f, 4.68698218e-02f, 8.09604973e-02f, 1.00977567e-03f, 4.27743532e-02f, -3.71656492e-02f, 2.61857510e-02f,
  -6.51950836e-02f, 7.69199943e-03f, -1.06546450e-02f, -7.90685266e-02f, -4.01431434e-02f, -6.50806399e-03f, -6.54624850e-02f, -4.28984053e-02f, -5.49364798e-02f, 7.05779493e-02f,
  -8.91637653e-02f, -6.30173385e-02f, -1.44649833e-01f, -4.41009924e-02f, -4.07824591e-02f, -1.37525141e-01f, -1.31031439e-01f, -6.55667186e-02f, -1.43504903e-01f, -1.68351486e-01f,
  -2.23469585e-01f, 7.12005198e-02f, 7.43330941e-02f, -1.17646791e-01f, 7.71669671e-02f, 2.64197998e-02f, 1.04227357e-01f, -1.29742533e-01f, -1.12040393e-01f, 6.95847422e-02f,
  4.93405722e-02f, -6.29025996e-02f, -5.14687458e-03f, -5.38553447e-02f, 9.63326395e-02f, 2.95605194e-02f, 1.26951069e-01f, -2.83868518e-02f, 7.61687174e-04f, -2.42090989e-02f,
  2.19884701e-02f, 3.19446810e-02f, -1.26407877e-01f, -1.07048944e-01f, -5.01073748e-02f, -2.00495850e-02f, 4.94270492e-03f, 6.93616048e-02f, 1.99460369e-02f, 9.69416872e-02f,
  -8.90645292e-03f, 2.58496590e-02f, -3.20393406e-02f, 3.96164805e-02f, -8.95280167e-02f, 3.03665809e-02f, 4.05125991e-02f, -5.53136356e-02f, 6.18419684e-02f, -2.19561011e-02f,
  4.35238555e-02f, -5.98314852e-02f, -3.46473753e-02f, -7.23364800e-02f, -7.78817534e-02f, -7.13382568e-03f, 4.54737060e-02f, 3.16701569e-02f, 7.40966797e-02f, -8.57927799e-02f,
  3.00947740e-03f, 7.60322586e-02f, 8.60889908e-03f, 2.69717164e-02f, 3.99811491e-02f, -3.58943529e-02f, -1.04202725e-01f, -2.68528219e-02f, -8.43498949e-03f, -1.11472547e-01f,
  -3.69293317e-02f, 4.54228967e-02f, 6.40948638e-02f, 6.98344335e-02f, -3.22132073e-02f, 1.81586538e-02f, -4.24189717e-02f, 2.99265496e-02f, -4.37337272e-02f, -3.29438038e-02f,
  3.04476563e-02f, -1.33181242e-02f, -4.53845076e-02f, -5.97403385e-02f, 3.15074585e-02f, -5.30771688e-02f, -3.16472985e-02f, 2.08058003e-02f, -3.17087546e-02f, 2.36654654e-02f,
  3.63471396e-02f, 6.04405738e-02f, 4.89736982e-02f, -7.61417821e-02f, 4.70470861e-02f, -3.57763320e-02f, -2.01177737e-03f, 5.34795150e-02f, -5.43650649e-02f, 1.36116073e-02f,
  -1.08438186e-01f, 1.12898983e-01f, -6.98969364e-02f, 9.96740651e-04f, 4.43128236e-02f, -2.75671855e-02f, -3.57637368e-02f, -2.97655892e-02f, 3.38937491e-02f, -7.51331300e-02f,
  2.54196934e-02f, -8.00858662e-02f, -4.02105823e-02f, -3.53342965e-02f, -2.78471541e-02f, 2.89693903e-02f, 9.04515013e-02f, -8.06785654e-03f, -5.27843274e-03f, -9.46271941e-02f,
  -1.80359632e-02f, -7.46308193e-02f, -1.78029969e-01f, -8.19507800e-03f, -8.03373978e-02f, -2.86716875e-02f, -1.31727010e-01f, -1.49513438e-01f, -1.82194784e-02f, -2.20338866e-01f,
  2.86392123e-01f, 3.45180705e-02f, 8.59939754e-02f, 7.76930153e-02f, 1.20331667e-01f, 1.94255754e-01f, 2.69404739e-01f, 1.82419926e-01f, -5.94536308e-04f, -1.34083070e-02f,
  9.30703655e-02f, 2.44910456e-02f, 3.66759375e-02f, 6.04516231e-02f, 1.34583816e-01f, 9.96065885e-02f, 8.29514787e-02f, 9.16412398e-02f, 1.19858705e-01f, 4.06918637e-02f,
  -1.26613081e-01f, 5.65657318e-02f, 1.46387266e-02f, 7.94749260e-02f, 4.78756242e-02f, -4.59578857e-02f, 2.20541172e-02f, 6.40797094e-02f, -2.67847031e-02f, -1.12154230e-01f,
  -8.09559599e-02f, 1.13330565e-01f, -3.79468761e-02f, -1.42679557e-01f, -6.99932724e-02f, 7.20819682e-02f, -2.91740391e-02f, -2.92494502e-02f, 2.06681471e-02f, 3.37942317e-02f,
  -4.90566790e-02f, 4.93069068e-02f, -3.56895733e-03f, -3.69759724e-02f, -7.38284513e-02f, 7.21472725e-02f, 4.76297475e-02f, 1.35185886e-02f, -7.97045976e-03f, -4.97204959e-02f,
  -2.46285740e-02f, 1.69365183e-02f, 9.85547435e-03f, -2.30982918e-02f, 1.57018095e-01f, -7.81363696e-02f, 5.65163232e-02f, 3.95945497e-02f, 4.30709235e-02f, -5.41522168e-02f,
  -1.51284821e-02f, 1.79642998e-02f, 2.37365942e-02f, -6.36156201e-02f, -3.02183479e-02f, 2.65161227e-03f, -2.13388577e-02f, -6.31052479e-02f, 1.33025283e-02f, 3.66447940e-02f,
  -8.31459388e-02f, 9.76705551e-02f, -3.89622226e-02f, 6.16775788e-02f, 6.85769413e-03f, -3.59581411e-02f, -5.61786396e-03f, -1.68369729e-02f, 6.04438782e-03f, -5.40563054e-02f,
  9.10174400e-02f, -2.40848418e-02f, 5.14934547e-02f, 1.84913892e-02f, 9.79253650e-02f, 8.64003878e-03f, -1.12265069e-02f, -3.47502939e-02f, 6.15775138e-02f, 1.73934102e-02f,
  -1.11430325e-01f, 3.31648886e-02f, -2.06713807e-02f, 1.99113023e-02f, -3.86145078e-02f, -9.86065939e-02f, 1.36411805e-02f, 5.42032011e-02f, -5.40341139e-02f, -4.64975499e-02f,
  -5.62115535e-02f, 4.44005132e-02f, 7.06864381e-03f, 2.94259954e-02f, 4.42986260e-04f, 4.73343469e-02f, -5.54780252e-02f, 3.21441237e-03f, 9.38446354e-03f, 2.03176122e-02f,
  -6.33919984e-02f, -3.39184813e-02f, 6.74072877e-02f, 5.38741872e-02f, -2.63038967e-02f, -3.34526151e-02f, 4.07105274e-02f, -1.06171668e-01f, 6.93535134e-02f, -3.79721913e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  9.83767062e-02f, 3.15150395e-02f, -3.92999500e-02f, 5.78275695e-02f, 8.63561034e-02f, 8.32216963e-02f, 1.05869152e-01f, 7.91700259e-02f, 3.69080193e-02f, 3.91727090e-02f,
  4.01420705e-02f, 5.42672127e-02f, 2.01654673e-01f, 1.99429423e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.36008447e-02f, 2.97116674e-03f, -1.47190824e-01f, -7.36431852e-02f, -1.15366071e-01f, 7.54528632e-03f, 1.49245426e-01f, 9.90108103e-02f, 1.39758974e-01f, -1.24814063e-02f,
  -8.96995440e-02f, 1.04654498e-01f, 5.69564402e-02f, 7.76920319e-02f, 6.43789023e-02f, -2.15563495e-02f, 9.44561511e-02f, -4.87323143e-02f, 3.38423587e-02f, -4.56534047e-03f,
  1.28771644e-02f, 1.07079349e-03f, -3.42851356e-02f, 4.50528450e-02f, -1.57355100e-01f, -3.22121158e-02f, 3.60995643e-02f, 9.53886136e-02f, -6.01064116e-02f, -5.48820384e-02f,
  -2.63831526e-01f, -4.73031215e-02f, 1.81197047e-01f, -3.48409116e-02f, 1.79887742e-01f, 9.04303417e-02f, -2.09851563e-01f, -1.55059565e-02f, -1.98016107e-01f, -1.34334043e-01f,
  8.92182365e-02f, 1.87700912e-01f, -1.53025910e-02f, -5.14331423e-02f, -5.96309416e-02f, 1.23411722e-01f, -2.26697903e-02f, 1.54611185e-01f, -1.99873075e-01f, 1.82840265e-02f,
  5.09050954e-03f, -2.40542348e-02f, -3.43100168e-02f, 3.51767405e-03f, -1.25147313e-01f, 6.16997331e-02f, -9.47277695e-02f, 1.32699609e-01f, -1.16440713e-01f, 7.38190627e-03f,
  -1.88795432e-01f, 6.38670623e-02f, -1.23782277e-01f, -1.60401449e-01f, 7.06282780e-02f, -1.95220094e-02f, 4.81798034e-03f, -1.01843566e-01f, -2.77627259e-02f, -2.45318580e-02f,
  1.27934277e-01f, 3.94883342e-02f, -2.08202209e-02f, -1.69405807e-02f, 2.40703709e-02f, 3.71935926e-02f, 1.25680611e-01f, -1.56762004e-02f, 1.54609943e-03f, 6.33943230e-02f,
  5.98035641e-02f, -3.78920212e-02f, 8.56617466e-03f, -4.60756458e-02f, -1.56355798e-01f, 4.25437912e-02f, 1.28803909e-01f, 6.94152787e-02f, -8.36573243e-02f, -1.66414231e-01f,
  -6.40123710e-02f, -2.70180017e-01f, -1.70303464e-01f, 2.54568070e-01f, -3.04800928e-01f, -2.02446118e-01f, -5.57512380e-02f, -1.02390476e-01f, 1.36894301e-01f, 2.29698434e-01f,
  -2.03995004e-01f, 2.32351452e-01f, -1.97957024e-01f, 1.68855190e-01f, 2.35853732e-01f, 3.77778225e-02f, 2.35915426e-02f, 2.13978559e-01f, 5.37908589e-03f, -6.86082169e-02f,
  1.55076399e-01f, 1.68533355e-01f, 5.08970246e-02f, 1.67647645e-01f, 1.18650869e-01f, -1.16929911e-01f, -1.07780464e-01f, -1.00715384e-01f, 1.95722476e-01f, -1.16931878e-01f,
  4.20258492e-02f, 1.27357572e-01f, -2.29750812e-01f, 8.01892653e-02f, -6.26054630e-02f, -7.07403943e-03f, -8.93738419e-02f, 1.04707174e-01f, 1.22507997e-01f, 9.11299735e-02f,
  -1.08677320e-01f, 1.32353991e-01f, 4.65248264e-02f, -7.49995783e-02f, 1.39614329e-01f, 1.40555337e-01f, -1.58370435e-01f, 9.53728929e-02f, -7.19613060e-02f, 1.60002392e-02f,
  -5.27811088e-02f, -5.53581379e-02f, 7.42160529e-02f, 4.69579473e-02f, 2.60246620e-02f, -3.45964245e-02f, -3.01250140e-03f, 9.18499604e-02f, 8.99021253e-02f, 1.01358756e-01f,
  1.11322880e-01f, 5.49666546e-02f, 6.22869097e-03f, 2.87361126e-02f, 1.59177128e-02f, -5.55544831e-02f, -5.48219134e-04f, -6.00185851e-03f, 8.44043419e-02f, 1.68597594e-01f,
  1.55195268e-02f, 1.68367028e-02f, -1.00095626e-02f, -1.23349033e-01f, -7.26185739e-02f, 8.94262642e-02f, -1.02025360e-01f, 3.37507389e-02f, -4.71681356e-04f, -7.78222159e-02f,
  3.70142162e-02f, -9.41644907e-02f, 6.83554336e-02f, -4.24856357e-02f, -2.41304804e-02f, -8.42384622e-03f, 9.47922319e-02f, -1.33473143e-01f, -6.74367324e-02f, -3.65388691e-02f,
  9.46187824e-02f, 1.03519894e-01f, 8.48043188e-02f, 1.06902145e-01f, 1.17642611e-01f, 9.44751650e-02f, 1.18220888e-01f, -8.38597491e-02f, -3.77163233e-05f, -6.80066720e-02f,
  -8.10281634e-02f, -4.48359661e-02f, 1.34285390e-01f, 1.21208422e-01f, 6.28754795e-02f, -8.63289088e-02f, -4.99189943e-02f, 1.02258168e-01f, 1.33232385e-01f, 1.45456597e-01f,
  -7.33539984e-02f, 7.39714354e-02f, -1.09948792e-01f, 4.94336188e-02f, 8.09239596e-02f, 6.98160473e-03f, 3.74084935e-02f, -7.05776885e-02f, -6.40619397e-02f, 3.81268859e-02f,
  -5.31205870e-02f, -1.43172264e-01f, -1.72028616e-02f, -9.66151282e-02f, 5.00802100e-02f, -1.19684592e-01f, 4.98151518e-02f, 1.85361773e-01f, -2.92571075e-02f, -2.14371663e-02f,
  6.23786002e-02f, 1.25547364e-01f, -2.36628190e-01f, 6.92335293e-02f, -1.78089961e-01f, 1.75468385e-01f, -9.80428606e-02f, 6.08231407e-04f, 1.73637338e-04f, 1.08915813e-01f,
  -2.50456244e-01f, 3.05158973e-01f, 7.44507462e-02f, 8.70685279e-03f, 4.22053561e-02f, -6.71028793e-02f, -2.24590059e-02f, 6.14199936e-02f, 1.02373973e-01f, 2.11110726e-01f,
  1.50075570e-01f, 4.89078164e-02f, 6.78564683e-02f, 4.66898791e-02f, 7.15841260e-03f, -1.52001530e-01f, -1.95073001e-02f, -1.09769300e-01f, -1.09870933e-01f, 1.76335201e-01f,
  6.49376679e-03f, 5.24748527e-02f, 5.38318716e-02f, -8.16039462e-03f, -2.41806686e-01f, 1.35438710e-01f, 3.43165696e-02f, 1.35719981e-02f, 6.31322414e-02f, 1.59605995e-01f,
  1.38976157e-01f, 9.77405384e-02f, -7.19511211e-02f, -4.72433008e-02f, 9.76630226e-02f, 1.02581894e-02f, 1.80099115e-01f, 1.97873991e-02f, 1.05273023e-01f, 1.72631219e-01f,
  1.04723655e-01f, 3.25074941e-02f, 9.23652053e-02f, 6.05561770e-02f, 3.59744392e-02f, 1.11038737e-01f, 2.03078136e-01f, 1.28127858e-01f, 8.44445676e-02f, -5.46020642e-02f,
  1.76560834e-01f, -1.12052217e-01f, 1.01150960e-01f, 1.31378949e-01f, 1.14084654e-01f, -6.23619221e-02f, -6.82409331e-02f, 1.11496344e-01f, 1.99075624e-01f, -6.17806166e-02f,
  6.09591268e-02f, 4.25631553e-02f, -1.42173022e-01f, 2.27878988e-02f, 1.13261692e-01f, -1.87508017e-01f, -1.11847967e-02f, -8.54974687e-02f, -9.07554477e-03f, -9.40998495e-02f,
  -7.58343264e-02f, 1.88926548e-01f, -9.32443421e-03f, -7.24187344e-02f, -1.48058444e-01f, -5.02347462e-02f, 1.19613431e-01f, 6.96723536e-02f, -1.04054518e-01f, 2.06487909e-01f,
  6.58308864e-02f, 1.42052036e-03f, 1.33670777e-01f, -5.63785387e-03f, 5.73545545e-02f, 7.37062991e-02f, -6.73070848e-02f, -1.57858610e-01f, 1.23194620e-01f, 1.33224025e-01f,
  -6.79147840e-02f, 6.80744275e-02f, -1.00358993e-01f, -5.97192869e-02f, 7.22020641e-02f, -1.10014953e-01f, 1.76404156e-02f, 1.71684623e-01f, 2.61684000e-01f, -7.08092283e-03f,
  -6.57459274e-02f, 4.34794389e-02f, -2.62942966e-02f, -2.00828072e-02f, -1.32581428e-01f, -1.12394445e-01f, -5.07439068e-03f, -6.19911328e-02f, -4.92583737e-02f, 8.58315378e-02f,
  1.26636058e-01f, 1.70093924e-02f, 1.28436550e-01f, -1.52042368e-02f, -6.31401911e-02f, -3.12303808e-02f, 1.44626290e-01f, 3.02443560e-02f, -4.37570587e-02f, -1.55738100e-01f,
  -3.35384518e-01f, 1.46386296e-01f, 2.45756641e-01f, -1.04986519e-01f, 2.07602218e-01f, -5.94686531e-02f, -1.88529611e-01f, 1.05721772e-01f, -1.64356604e-01f, -9.16183665e-02f,
  -2.08363459e-02f, 8.49084184e-02f, 1.69061467e-01f, -5.94956763e-02f, 1.67863503e-01f, 2.82107830e-01f, 9.36093926e-02f, 8.29151832e-03f, 1.65718026e-03f, 4.99104559e-02f,
  -4.00939723e-03f, 5.58819883e-02f, -2.55478895e-04f, -9.73706320e-03f, 3.19468193e-02f, 1.01913340e-01f, 1.26249909e-01f, -8.05908293e-02f, 3.32495309e-02f, -1.36452481e-01f,
  -1.47750109e-01f, -2.11993784e-01f, -6.69481456e-02f, -2.68839933e-02f, 4.43078503e-02f, 9.93154198e-02f, -1.12904787e-01f, 2.93993391e-02f, 7.07585504e-03f, -9.42448974e-02f,
  -5.03839888e-02f, 1.53075486e-01f, 3.13533936e-03f, -6.26727939e-02f, 1.16910830e-01f, 6.85672164e-02f, 4.79726307e-02f, 1.17756069e-01f, -5.00268154e-02f, -9.69320089e-02f,
  -1.27954587e-01f, 7.51298666e-02f, -9.00298357e-02f, 4.04215120e-02f, 1.65860921e-01f, 5.97077608e-02f, 8.02173167e-02f, 8.80102348e-03f, 1.42047197e-01f, -1.36990026e-01f,
  1.68977439e-01f, 6.82218745e-03f, 4.42210548e-02f, -4.62658033e-02f, -1.94510177e-01f, -1.09201089e-01f, 7.76758194e-02f, -2.23903015e-01f, 5.49372868e-04f, -7.26726577e-02f,
  -4.99037607e-03f, -1.08206734e-01f, -5.67916594e-02f, -1.14816278e-01f, 2.04551339e-01f, 1.19083350e-04f, -2.27166363e-03f, -1.68096889e-02f, 3.37515445e-03f, 2.34939247e-01f,
  -7.63554638e-03f, -9.17262118e-03f, -7.10868090e-02f, -6.45250753e-02f, -1.25784248e-01f, -3.08613423e-02f, -9.33031738e-02f, 1.37532488e-01f, -7.74573758e-02f, 3.91541533e-02f,
  -4.10061590e-02f, -1.01662213e-02f, 9.38525572e-02f, -4.58949916e-02f, -7.52296224e-02f, -6.65075704e-02f, -8.03449303e-02f, -4.05735224e-02f, 1.31771667e-02f, -7.41202757e-02f,
  1.65296625e-02f, 8.06530267e-02f, -5.71164005e-02f, 1.10948145e-01f, -3.24182920e-02f, -1.80568755e-01f, -1.13988377e-01f, 3.60957487e-03f, 6.79590106e-02f, -1.25224903e-01f,
  2.64605638e-02f, 1.25322029e-01f, 1.47213355e-01f, 7.85259679e-02f, 2.46118940e-02f, -8.74737501e-02f, 2.25881319e-02f, -4.33298945e-02f, 1.36532292e-01f, 2.40976382e-02f,
  5.96667789e-02f, 1.45694256e-01f, 1.63601533e-01f, -1.69623747e-01f, 5.87940067e-02f, 3.20055112e-02f, -9.30829123e-02f, -8.51869807e-02f, 2.22982571e-01f, -1.30058974e-01f,
  -1.12197101e-01f, 4.42674570e-02f, 4.56606224e-02f, -2.85941567e-02f, 2.03556851e-01f, -1.11102499e-01f, 2.04004019e-01f, -2.58469015e-01f, -7.67407566e-02f, 1.63584515e-01f,
  -2.06765786e-01f, -2.63110418e-02f, -9.47122350e-02f, -2.09683672e-01f, -1.79509819e-01f, -1.88226730e-01f, -1.51378110e-01f, 5.61564649e-03f, -1.40507162e-01f, -2.11741030e-02f,
  -9.83044133e-02f, 1.39674589e-01f, -4.28149011e-03f, 1.76762059e-01f, 3.87412049e-02f, 3.83321149e-03f, 7.00069964e-02f, -7.56689310e-02f, 1.30438088e-02f, 4.18381132e-02f,
  1.64658621e-01f, 3.03149801e-02f, 1.50736436e-01f, 1.29406840e-01f, -1.34618863e-01f, 1.24980561e-01f, 1.43026188e-01f, -1.18986845e-01f, 8.51920918e-02f, 9.30363238e-02f,
  1.35394171e-01f, 3.67435552e-02f, 7.00980127e-02f, 2.38912497e-02f, -1.01198711e-01f, 1.03916109e-01f, 1.34554803e-01f, -1.00643925e-01f, 1.63976904e-02f, -1.01494685e-01f,
  -8.77760071e-03f, 1.54633924e-01f, 2.18540296e-01f, -1.57826375e-02f, 1.95073903e-01f, 6.69814399e-05f, -1.44483652e-02f, -5.06600030e-02f, -2.37541422e-02f, 1.01684988e-01f,
  1.02429770e-01f, -6.38830885e-02f, 4.01833802e-02f, -5.08611426e-02f, 2.02233985e-01f, -2.70963311e-01f, 3.44959535e-02f, -8.71261954e-03f, -8.53972510e-02f, 9.99398455e-02f,
  1.31400317e-01f, -2.20872238e-01f, 1.54973611e-01f, 1.04539074e-01f, 1.78505592e-02f, -9.27041657e-03f, -5.68469577e-02f, 1.51762187e-01f, -1.04131557e-01f, -1.89727068e-01f,
  -7.62357339e-02f, -9.63801444e-02f, -5.22881337e-02f, 1.75231189e-01f, -1.47923529e-01f, 1.44119784e-01f, -2.46789888e-03f, -5.07020578e-02f, -1.70003623e-01f, -1.41738787e-01f,
  5.07289357e-02f, -1.84592545e-01f, -1.02471232e-01f, 4.82467972e-02f, 1.72299132e-01f, -9.22113433e-02f, 3.33239936e-04f, 6.78842217e-02f, 9.00380313e-02f, -8.40119347e-02f,
  -2.12002061e-02f, 4.41593714e-02f, 3.28604840e-02f, 1.34713992e-01f, 2.67677605e-01f, -1.20202787e-01f, 6.48103058e-02f, 1.50495365e-01f, 8.97603408e-02f, 1.81288738e-02f,
  -1.06472410e-01f, -9.57196653e-02f, 2.48329006e-02f, 2.37646680e-02f, -1.75710171e-01f, -8.76219273e-02f, 1.14930198e-01f, 6.63180947e-02f, 5.86395385e-03f, 5.97720295e-02f,
  -3.89572196e-02f, 2.56791264e-01f, 2.93731783e-02f, -4.85378616e-02f, -2.55094450e-02f, -1.71326339e-01f, -3.94518934e-02f, 2.05116346e-01f, 7.68922642e-02f, 3.01168091e-03f,
  6.43387064e-02f, -7.74375647e-02f, -2.11334437e-01f, -2.71573514e-02f, 3.84448059e-02f, 2.16688678e-01f, -1.37239441e-01f, -1.79623544e-01f, 3.23927701e-01f, 1.04432702e-01f,
  2.53366739e-01f, 4.45971340e-02f, -1.60905775e-02f, 1.54674724e-01f, 1.92539729e-02f, 6.61923958e-04f, 1.46892205e-01f, 3.62380445e-02f, -6.56391159e-02f, 6.75232112e-02f,
  2.14456230e-01f, 1.31533472e-02f, 1.62913337e-01f, -2.01774970e-01f, 1.46159425e-01f, -2.69578546e-01f, 1.55698135e-01f, -2.02397928e-01f, -1.30412161e-01f, 1.65976897e-01f,
  9.17340815e-02f, 5.94525365e-03f, 8.33058134e-02f, -1.32549584e-01f, -1.02338791e-02f, -3.73291373e-02f, 9.59300324e-02f, 5.63723892e-02f, 8.29757527e-02f, 1.70236036e-01f,
  1.62945151e-01f, -1.14111565e-02f, 3.27264555e-02f, -1.23160563e-01f, -7.81649500e-02f, -2.20962483e-02f, -1.23655289e-01f, -9.93856192e-02f, -2.75586575e-01f, -5.78864478e-02f,
  2.55575981e-02f, -4.88252603e-02f, 1.15141617e-02f, -5.95726855e-02f, -8.08336362e-02f, -3.59916501e-02f, 1.04315400e-01f, -1.16130970e-01f, 1.35448158e-01f, 3.62718664e-02f,
  4.41293158e-02f, -1.43576294e-01f, -1.06035709e-01f, -4.70081940e-02f, 1.25745218e-02f, 7.83690512e-02f, -3.34975384e-02f, 1.79818928e-01f, 4.23883311e-02f, 1.02976732e-01f,
  -6.33759052e-02f, -1.75917268e-01f, 1.13732986e-01f, 2.48060912e-01f, -2.11585015e-02f, 2.64880452e-02f, -1.19204745e-02f, 8.75280797e-02f, 1.56671539e-01f, -1.79376394e-01f,
  2.10428536e-01f, 1.58436373e-01f, 2.85927709e-02f, 5.61093949e-02f, 1.76130280e-01f, -1.15392819e-01f, 7.10625872e-02f, -2.54943352e-02f, 4.34412844e-02f, -5.24323657e-02f,
  -8.97881482e-03f, -7.72296935e-02f, 1.22429788e-01f, 2.23327935e-01f, -6.82794526e-02f, -1.60783947e-01f, -3.56878825e-02f, 1.16826639e-01f, 1.50768105e-02f, 4.58308719e-02f,
  1.28797069e-01f, -1.21781223e-01f, -2.82033756e-02f, -1.46280140e-01f, 4.79746908e-02f, -1.56261642e-02f, -4.87662405e-02f, -7.85805658e-03f, -5.86155392e-02f, -4.86365799e-03f,
  -8.98607895e-02f, 1.26097322e-01f, 4.99930605e-02f, 4.35378514e-02f, 2.77219061e-02f, 1.08037561e-01f, -2.52576638e-02f, -1.22721292e-01f, 7.26354644e-02f, 3.86939868e-02f,
  -1.31737486e-01f, 8.58375877e-02f, -1.36719540e-01f, 5.21302707e-02f, -1.87853947e-02f, -1.02879137e-01f, 1.34216413e-01f, 1.69161588e-01f, -1.52212419e-02f, 6.84851184e-02f,
  1.09762274e-01f, -2.19946280e-01f, 7.68396705e-02f, -2.26229221e-01f, 8.28590710e-03f, 2.57183433e-01f, -1.44341454e-01f, -2.63877690e-01f, -2.05877200e-01f, -1.76082939e-01f,
  6.69761449e-02f, 8.97143632e-02f, -2.14021839e-02f, 1.75304085e-01f, -7.11175427e-02f, -1.32787144e-02f, 1.24830440e-01f, 5.16883805e-02f, -1.12550445e-02f, 1.35396436e-01f,
  6.95850700e-02f, 5.61833791e-02f, -8.47427472e-02f, 1.74546555e-01f, 6.84270859e-02f, 1.59069657e-01f, -9.81547013e-02f, -2.67447144e-01f, 2.83547174e-02f, 3.10943071e-02f,
  1.22561224e-01f, -7.06884414e-02f, 6.12079464e-02f, -3.41618098e-02f, 4.43275124e-02f, 7.40998015e-02f, 3.79864722e-02f, 8.96543041e-02f, -3.83196920e-02f, 2.79266071e-02f,
  -6.77511171e-02f, 1.57644022e-02f, -7.09781200e-02f, 1.04427733e-01f, 1.04747705e-01f, 1.76174760e-01f, 2.04748929e-01f, -6.97555467e-02f, -2.81900503e-02f, -2.34243702e-02f,
  2.19268147e-02f, 1.71858240e-02f, 9.92740318e-03f, -4.45394916e-03f, -1.63468663e-02f, -2.05812290e-01f, -2.00447261e-01f, 2.92914718e-01f, -2.27979273e-01f, 9.56016127e-03f,
  -3.30011964e-01f, 1.99456409e-01f, -1.81251720e-01f, 1.99122399e-01f, 9.52299833e-02f, 2.21859273e-02f, -3.17917019e-01f, 1.51257396e-01f, 1.07158385e-01f, -3.35294269e-02f,
  -1.92230031e-01f, -8.13356042e-03f, -7.11074993e-02f, 2.76694540e-02f, 1.58308074e-01f, 1.32143885e-01f, 1.22692496e-01f, 1.82974294e-01f, -1.62795428e-02f, -1.22585326e-01f,
  -2.83387061e-02f, -1.35858223e-01f, 2.09858090e-01f, -1.52805626e-01f, -1.01292364e-01f, -9.01936274e-03f, -1.70934334e-01f, 2.12240562e-01f, 1.59416758e-02f, 1.24817997e-01f,
  5.22146188e-02f, -9.85646918e-02f, -1.59757897e-01f, 1.04481488e-01f, 5.77582903e-02f, -5.43654710e-02f, -1.93877682e-01f, 3.03826630e-01f, 5.79174161e-02f, -1.70163795e-01f,
  -2.55689740e-01f, -1.60447694e-02f, -1.91326737e-01f, -1.95180718e-02f, 1.66553259e-02f, -1.89245939e-01f, 6.15325421e-02f, -2.55894009e-02f, -5.33308908e-02f, -2.41319165e-02f,
  1.15787396e-02f, 1.10525936e-02f, 1.62386056e-02f, -1.23318166e-01f, -2.17595860e-01f, -7.90055096e-02f, -1.45762727e-01f, 3.64218026e-01f, -3.94024961e-02f, 1.73640966e-01f,
  -9.83310640e-02f, 1.30753234e-01f, -1.11252248e-01f, 1.70582429e-01f, -2.59874831e-03f, 2.40196198e-01f, -8.63133594e-02f, -9.01605934e-03f, -2.62792185e-02f, -5.06000221e-02f,
  -6.44293055e-02f, 2.06816539e-01f, -3.14086884e-01f, 7.02787787e-02f, 1.35405108e-01f, -2.70786226e-01f, 9.93543770e-03f, -1.29925549e-01f, -1.34221800e-02f, 2.66147836e-04f,
  1.61235005e-01f, 9.49579626e-02f, 3.61719429e-02f, -1.59507804e-02f, -3.29816900e-02f, -6.49145097e-02f, 2.67461203e-02f, 1.23247176e-01f, 6.80478960e-02f, -9.94748995e-02f,
  -3.22043300e-02f, -6.81871548e-02f, 4.85580973e-02f, 2.27967631e-02f, -8.04789215e-02f, -7.63282105e-02f, -2.82211080e-02f, -9.19153318e-02f, 9.45597664e-02f, 7.41613805e-02f,
  -1.87014509e-02f, -4.39152978e-02f, 7.48115629e-02f, -7.09658489e-02f, -1.03714295e-01f, 8.74722563e-03f, -1.00137129e-01f, 4.51942869e-02f, 1.08100973e-01f, 5.04427515e-02f,
  -1.04603589e-01f, -6.49089590e-02f, -1.44606642e-02f, 3.34040336e-02f, 1.45354688e-01f, 5.10136373e-02f, -1.24203138e-01f, -7.90336058e-02f, 3.23296990e-03f, 3.11001223e-02f,
  -5.58978654e-02f, 1.60569325e-02f, -4.47046533e-02f, -1.01274565e-01f, -1.06279217e-01f, -7.83763528e-02f, -6.92975521e-02f, -8.95961281e-03f, 1.06515229e-01f, 1.28385440e-01f,
  -1.13510236e-01f, 2.15417659e-03f, 1.80596069e-01f, -3.30512039e-02f, -3.62560898e-02f, -1.34155914e-01f, 2.07737386e-02f, 1.62789002e-01f, -2.53618598e-01f, -2.00416803e-01f,
  1.25862914e-03f, -6.39841631e-02f, -1.37533322e-01f, -1.31168768e-01f, 1.49861574e-01f, -1.29525214e-01f, -3.59676816e-02f, -9.92440153e-03f, -8.41258839e-02f, 1.10277861e-01f,
  -8.54684785e-02f, -9.64331180e-02f, 1.54194996e-01f, -3.57545093e-02f, -1.34938955e-02f, 4.71289344e-02f, 8.07316136e-03f, -8.50594342e-02f, 5.11828139e-02f, -9.16662719e-03f,
  -1.12772644e-01f, -1.09570436e-01f, -6.74153566e-02f, -6.70236722e-02f, -2.14473512e-02f, -4.39672768e-02f, -1.21983305e-01f, 8.50124955e-02f, 1.70831040e-01f, -4.49667685e-02f,
  6.03364557e-02f, 3.47605124e-02f, -1.48466915e-01f, 5.97259961e-02f, 4.93877046e-02f, -1.02671549e-01f, 8.02032743e-03f, -8.29712525e-02f, -1.01162411e-01f, 1.14530958e-01f,
  1.87849119e-01f, -1.27875522e-01f, 5.53872772e-02f, 4.31705266e-02f, 6.89336360e-02f, -1.13544591e-01f, -4.61580791e-02f, 1.78379893e-01f, 1.17008448e-01f, -4.07277904e-02f,
  1.57472327e-01f, 2.19940990e-01f, 2.16832340e-01f, -8.23263824e-02f, 1.61336035e-01f, -6.23934604e-02f, -1.22343183e-01f, 9.71195474e-02f, 1.42123327e-01f, -7.09796622e-02f,
  -8.51237029e-02f, -1.43843457e-01f, 3.73383969e-01f, 1.51448786e-01f, 7.30606765e-02f, 7.30693992e-03f, -3.47989798e-02f, -9.67032537e-02f, -2.12831303e-01f, 4.99177016e-02f,
  -1.99760288e-01f, 4.21475507e-02f, -7.01245666e-02f, -7.44895041e-02f, -8.45949128e-02f, 9.44977030e-02f, -7.44634792e-02f, -1.39249742e-01f, 2.14708969e-01f, 3.13084498e-02f,
  -7.48767927e-02f, -6.32948428e-02f, 8.28808099e-02f, -3.10864728e-02f, -4.31706905e-02f, 6.75519556e-02f, 1.77801177e-01f, -4.31455076e-02f, 5.02472073e-02f, 2.60571450e-01f,
  -8.37484654e-03f, 4.89051105e-04f, -1.25418290e-01f, 1.08963795e-01f, 1.03052966e-01f, -6.38631359e-02f, 1.16765149e-01f, -7.94255361e-02f, -2.33525056e-02f, -6.55115321e-02f,
  1.03354827e-03f, 7.42298141e-02f, 1.21679924e-01f, -4.88191880e-02f, -1.09366857e-01f, -9.96075794e-02f, -6.36667013e-02f, 8.77718255e-02f, -1.61699466e-02f, 1.50697023e-01f,
  -9.85372737e-02f, -1.78019218e-02f, -2.18807869e-02f, -1.60830721e-01f, 1.59798518e-01f, 7.10214600e-02f, -1.63233891e-01f, 1.06766656e-01f, -7.26022795e-02f, -3.96852428e-03f,
  2.45705277e-01f, 9.50576439e-02f, -1.61838215e-02f, 1.60875067e-01f, -1.00503862e-01f, -8.64463672e-02f, -1.66406825e-01f, 5.35108969e-02f, -1.46989286e-01f, -1.15280248e-01f,
  -7.60456249e-02f, -1.69123009e-01f, -3.11953072e-02f, -9.91763175e-02f, 2.77499668e-02f, -1.04940340e-01f, -3.13706771e-02f, 1.45047575e-01f, -4.84552532e-02f, 2.93712653e-02f,
  1.00436985e-01f, -7.30648562e-02f, 1.62938103e-01f, -1.09569758e-01f, 1.99188322e-01f, 1.51258126e-01f, 4.68050875e-02f, 1.02479599e-01f, 9.38881934e-02f, -1.28777340e-01f,
  3.60929617e-03f, 2.21186336e-02f, -7.88339376e-02f, -1.78668708e-01f, -1.10033125e-01f, -1.65847108e-01f, 1.75339445e-01f, 6.53864890e-02f, -1.01359978e-01f, -9.81279984e-02f,
  3.09754517e-02f, -5.33590689e-02f, -7.80560300e-02f, -2.39755455e-02f, -1.19712748e-01f, -4.27293181e-02f, -1.24273166e-01f, 1.05763994e-01f, -5.52992783e-02f, 6.31787032e-02f,
  1.62232891e-01f, -3.92261147e-02f, 2.29750760e-02f, -2.57104814e-01f, -7.51146153e-02f, -8.18103775e-02f, -5.42845875e-02f, -8.88158530e-02f, 8.23103935e-02f, -2.27881655e-01f,
  4.37673554e-03f, -1.80568010e-01f, -4.76452745e-02f, -3.11141796e-02f, 3.31139117e-02f, 1.14989907e-01f, 1.53462783e-01f, -2.68673748e-01f, 2.75561363e-01f, -1.12032361e-01f,
  -2.38694087e-01f, 1.84713677e-01f, -1.00658245e-01f, 1.00071393e-01f, 5.55589385e-02f, -3.03023141e-02f, 2.94044465e-02f, -1.60728693e-01f, 8.97901580e-02f, 5.46565317e-02f,
  -1.43787861e-01f, 8.74598622e-02f, 9.52991843e-02f, -1.65545464e-01f, 1.13552399e-01f, -6.48707077e-02f, -1.30118251e-01f, 1.87873337e-02f, 1.54187232e-01f, -1.68279350e-01f,
  2.04305723e-01f, -1.19042099e-01f, 1.53319463e-01f, -6.80834129e-02f, -6.35718480e-02f, -6.53819740e-02f, 1.68580279e-01f, -3.08590323e-01f, 1.07544772e-01f, 1.20850131e-01f,
  2.19296739e-01f, 7.99269900e-02f, 1.56129286e-01f, 1.39246196e-01f, 6.15382288e-03f, 9.68553796e-02f, 3.70992683e-02f, -1.41456515e-01f, -1.28317624e-01f, -1.08366832e-01f,
  -1.52952492e-01f, 9.82923582e-02f, 7.14683533e-02f, -1.06755763e-01f, 2.12056771e-01f, 6.19217642e-02f, 2.59898510e-02f, -2.06833169e-01f, 9.70214158e-02f, -1.13503955e-01f,
  -1.31937861e-01f, 1.03078410e-01f, -6.67597260e-03f, -5.83949462e-02f, 8.75057653e-02f, -1.17530070e-01f, 1.39567181e-01f, -7.69311469e-03f, -2.22789049e-01f, 8.75774994e-02f,
  -3.59084085e-02f, -2.33771145e-01f, 1.73179224e-01f, -8.14304203e-02f, 3.03550400e-02f, 1.73693359e-01f, -5.43828458e-02f, 2.04569981e-01f, 1.14288777e-01f, 8.52849111e-02f,
  -2.00601771e-01f, 1.23088248e-01f, -1.79172620e-01f, -4.93378006e-02f, -2.37369519e-02f, -1.10230818e-01f, -6.32381067e-02f, -7.38341287e-02f, -2.46749204e-02f, -1.25858691e-02f,
  -4.08023931e-02f, -4.13227268e-02f, -7.23707899e-02f, -3.48392799e-02f, -1.26020610e-02f, 1.15293205e-01f, 1.30239487e-01f, -4.86180373e-02f, 2.99896933e-02f, -6.28890172e-02f,
  1.69079397e-02f, 1.45198032e-01f, 1.81212291e-01f, -4.72467542e-02f, -1.05260290e-01f, -7.24766254e-02f, 3.17006297e-02f, -1.75402090e-02f, -9.68162790e-02f, -6.00454956e-02f,
  8.77808221e-03f, 3.57343146e-04f, 7.89867640e-02f, 2.21473858e-01f, 1.31143466e-01f, 5.94428973e-03f, -3.86193604e-03f, -1.01929002e-01f, 6.96407333e-02f, -1.70450248e-02f,
  -6.47505224e-02f, -1.53571889e-02f, 1.84234828e-02f, 5.81089668e-02f, -8.69298503e-02f, 2.37937525e-01f, -1.82715923e-01f, 6.53427690e-02f, 2.14783791e-02f, 2.35214114e-01f,
  -1.59057945e-01f, 3.70933488e-02f, 2.93229334e-02f, 8.96212384e-02f, -2.99450636e-01f, 2.40634307e-01f, 4.57894877e-02f, 1.28926886e-02f, -7.63009042e-02f, -2.50899911e-01f,
  2.31819879e-02f, -1.19380608e-01f, 5.60776703e-02f, 9.35029760e-02f, 4.95994762e-02f, -1.20881656e-02f, 1.74959466e-01f, -4.41855229e-02f, 1.50847524e-01f, -1.43476561e-01f,
  4.70396318e-02f, -1.26556352e-01f, 3.63437459e-02f, 1.03642486e-01f, 6.30242899e-02f, 1.88157603e-01f, -1.03732524e-02f, 1.41742125e-01f, -1.41456991e-01f, -1.08207680e-01f,
  5.30914254e-02f, -1.28045365e-01f, -1.58431172e-01f, -1.53244197e-01f, 8.49297196e-02f, -2.23604217e-01f, -4.23581377e-02f, 3.27338139e-03f, -2.71373075e-02f, 9.39022098e-03f,
  9.39927325e-02f, 5.80135398e-02f, -1.61934271e-02f, 1.30958259e-01f, -1.05979338e-01f, 5.81234843e-02f, -1.64575994e-01f, -7.37634450e-02f, 6.24768063e-02f, -1.38443723e-01f,
  -7.49157071e-02f, -1.31923467e-01f, -9.86469351e-03f, 2.69051176e-02f, 2.16024481e-02f, -2.25280404e-01f, -7.05827624e-02f, -1.40719369e-01f, 1.00152478e-01f, -1.85539111e-01f,
  5.57960086e-02f, -5.11256121e-02f, 3.71949039e-02f, -2.46406958e-01f, -1.16396651e-01f, -2.04650164e-02f, -8.20405483e-02f, -1.12203196e-01f, 1.44510955e-01f, -2.90100396e-01f,
  1.20285347e-01f, 8.34040567e-02f, -1.97575122e-01f, 1.90139517e-01f, -9.40698162e-02f, 1.89948633e-01f, 6.61647096e-02f, 5.52884489e-02f, 3.70306186e-02f, 4.94083725e-02f,
  -4.14628126e-02f, -8.24891776e-02f, -1.65453076e-01f, 1.05124645e-01f, -9.96357203e-02f, 7.72195384e-02f, 7.44178817e-02f, -2.32236087e-03f, -1.08854666e-01f, 1.32128671e-01f,
  1.83235649e-02f, -6.93425983e-02f, 6.08125292e-02f, -9.88293737e-02f, 1.37659088e-01f, 1.89761639e-01f, -5.02081541e-03f, 1.25270680e-01f, 6.68537989e-03f, -5.50431684e-02f,
  2.34375522e-02f, 2.50544161e-01f, 4.71205525e-02f, 8.56062174e-02f, -5.21665402e-02f, 1.20473720e-01f, 1.29322559e-01f, -1.50839821e-01f, 9.56441015e-02f, -7.45000914e-02f,
  -1.22230640e-02f, -3.24652828e-02f, -7.09215254e-02f, -1.36628479e-03f, 1.82246625e-01f, -2.29458306e-02f, 9.31991711e-02f, -3.84872854e-02f, 1.07371174e-01f, 2.36320004e-01f,
  8.74609351e-02f, -1.15546674e-01f, 4.03398685e-02f, 7.51510612e-04f, -2.20415831e-01f, 2.13733882e-01f, 1.31698221e-01f, -1.09338909e-01f, 1.44782677e-01f, -8.29774588e-02f,
  -3.08320075e-01f, 5.65070920e-02f, -1.62133962e-01f, 1.46385760e-03f, -1.77457556e-02f, -4.46156636e-02f, 3.28822196e-01f, -8.22098404e-02f, 1.16852209e-01f, 1.08253121e-01f,
  -1.36968708e-02f, 7.71872653e-03f, 3.08638569e-02f, -1.20657712e-01f, -1.26636118e-01f, -8.24171454e-02f, 1.12055928e-01f, 6.66205678e-03f, 1.41252548e-01f, -9.61601809e-02f,
  6.20932169e-02f, 1.33081019e-01f, 1.27803311e-01f, -1.24096304e-01f, -1.02861822e-01f, -8.46558884e-02f, -1.55789718e-01f, 8.03938657e-02f, -1.07597411e-01f, 1.56774789e-01f,
  3.22831981e-02f, -6.59025013e-02f, -2.96510942e-02f, 7.26040155e-02f, 9.10387933e-02f, -5.72569780e-02f, 3.10036354e-02f, 1.14767000e-01f, -5.30351587e-02f, 2.89914031e-02f,
  -1.14525549e-01f, -2.08418474e-01f, -7.21054673e-02f, -6.47742003e-02f, -1.21490471e-01f, -9.07968804e-02f, -2.08118722e-01f, 5.50631694e-02f, 6.90584257e-02f, -9.56918821e-02f,
  2.36748047e-02f, -4.96916436e-02f, 6.51687235e-02f, 3.40242296e-01f, 1.13680765e-01f, -5.85435554e-02f, 7.92632326e-02f, -6.57807812e-02f, 1.98841952e-02f, 1.96320698e-01f,
  -1.07339211e-01f, 7.24043697e-02f, 2.27447413e-02f, -5.44521920e-02f, -2.14773118e-01f, 1.85097307e-02f, -3.40248011e-02f, 3.21081012e-01f, -7.30862096e-02f, -1.69339672e-01f,
  4.14803535e-01f, 1.37164488e-01f, 2.64257222e-01f, 1.64265051e-01f, 1.56837963e-02f, -3.61627853e-03f, 1.27236724e-01f, -3.21333930e-02f, -2.63706353e-02f, -2.69172830e-03f,
  -1.16844088e-01f, -2.83290204e-02f, 1.04922481e-01f, 1.50654400e-02f, -3.39879245e-02f, -1.06238663e-01f, 1.82374716e-02f, -1.20909914e-01f, -6.88578710e-02f, -2.93088835e-02f,
  -5.83666675e-02f, 1.26350403e-01f, 1.30946040e-02f, -8.28036070e-02f, -2.17681006e-02f, 1.32920593e-01f, 2.93640811e-02f, 1.07411124e-01f, -6.15752898e-02f, 3.13583352e-02f,
  -7.56296962e-02f, -7.94367585e-03f, 7.88479298e-02f, -1.75388288e-02f, 7.88216889e-02f, -5.26821911e-02f, -1.17834076e-01f, 2.75511425e-02f, 1.06622158e-02f, -1.46772668e-01f,
  -1.01182930e-01f, -7.53702521e-02f, 1.25523806e-01f, -9.21766311e-02f, 4.16700728e-02f, -1.40184462e-01f, 8.69657099e-02f, -4.16039601e-02f, 4.33821753e-02f, 3.72387432e-02f,
  2.61993319e-01f, -1.80775076e-01f, 1.71906874e-01f, 6.50500730e-02f, 2.37340227e-01f, -8.74668956e-02f, 6.50558099e-02f, -9.44257975e-02f, -1.48410052e-01f, -6.67675138e-02f,
  6.99686036e-02f, 1.34529442e-01f, -1.80440873e-01f, 3.60072702e-02f, 3.08002889e-01f, 2.42144346e-01f, -3.83273140e-02f, 5.25125712e-02f, 9.18715447e-03f, -1.33282607e-02f,
  -2.39460781e-01f, -4.02931832e-02f, -1.44574970e-01f, 1.25918359e-01f, -3.49693187e-02f, 1.02234490e-01f, -1.79413348e-01f, 1.45609841e-01f, -1.14652559e-01f, -1.74211621e-01f,
  1.28506690e-01f, -1.57119468e-01f, 1.26148434e-02f, -1.07084222e-01f, 5.25507890e-02f, 1.64440006e-01f, 1.35232797e-02f, -1.78015396e-01f, 3.13956812e-02f, -7.32450932e-02f,
  3.60628814e-02f, -1.67523742e-01f, -8.27553496e-02f, 5.19890226e-02f, 2.24770665e-01f, -8.01744312e-02f, -1.49901805e-03f, -1.06366999e-01f, -1.29345253e-01f, 1.67503446e-01f,
  2.55994424e-02f, 7.04860613e-02f, 5.53457923e-02f, -1.94068365e-02f, -1.21667758e-01f, -4.06195447e-02f, 2.05345042e-02f, -1.38384745e-01f, -1.08929100e-02f, 1.20985553e-01f,
  1.48262367e-01f, -2.51001716e-01f, -1.01894952e-01f, 1.02974713e-01f, -3.58751155e-02f, -1.51257157e-01f, 2.36615255e-01f, -3.23168077e-02f, 1.43506512e-01f, -4.53242138e-02f,
  1.40606537e-01f, 4.51794313e-03f, -2.48267390e-02f, 7.41250291e-02f, 2.86234140e-01f, -1.63559556e-01f, 7.43198544e-02f, -7.24574402e-02f, -1.52784353e-02f, 8.45462456e-02f,
  -1.08025894e-02f, 1.39922619e-01f, -1.86679885e-01f, -1.51295448e-02f, -9.67114270e-02f, -9.72911492e-02f, -1.03298143e-01f, -5.45418672e-02f, -2.96572410e-02f, -1.05178971e-02f,
  -1.28992885e-01f, 5.17810509e-02f, -3.43383811e-02f, -1.89793959e-01f, 5.97069524e-02f, -2.24488582e-02f, -1.55957222e-01f, -1.12209424e-01f, 2.14701831e-01f, -2.59266235e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.44243650e-02f, -5.43912351e-02f, 1.43405031e-02f, -9.19790789e-02f, 9.67592224e-02f, 3.71211022e-02f, -1.08703323e-01f, 3.15837078e-02f, 5.58178164e-02f, 1.22570463e-01f,
  -1.07471362e-01f, -1.62968654e-02f, -7.22666755e-02f, -9.51044559e-02f, -2.14528125e-02f, -2.42495481e-02f, -4.67184447e-02f, 8.61266553e-02f, -6.53866082e-02f, -1.03841946e-02f,
  -4.87782471e-02f, -1.17227778e-01f, 7.08486289e-02f, 2.78313663e-02f, 5.62273338e-02f, 9.12827849e-02f, -1.13210402e-01f, -1.06440350e-01f, -1.21693812e-01f, 3.46194655e-02f,
  -2.30287779e-02f, -8.77086222e-02f, -7.15932474e-02f, 4.51924354e-02f, -5.36154583e-03f, -8.62695053e-02f, -4.59728427e-02f, 1.19549975e-01f, 6.49997368e-02f, 1.11541286e-01f,
  9.73665193e-02f, -5.28439693e-02f, -2.75651179e-02f, -1.73096135e-02f, -5.87449074e-02f, 5.19417599e-02f, -1.05830021e-01f, 1.11472886e-02f, 3.91439274e-02f, -6.31682500e-02f,
  -3.01521216e-02f, -8.82405415e-02f, 8.29886496e-02f, 4.84520756e-03f, 6.02319576e-02f, -6.31084889e-02f, 1.17751099e-01f, -8.12109113e-02f, -6.09449111e-03f, -4.58297208e-02f,
  -4.57566455e-02f, 5.62162921e-02f, 2.98064146e-02f, -8.55089724e-02f, 8.63091052e-02f, -6.96432069e-02f, -2.12697517e-02f, 9.05672237e-02f, 5.24625666e-02f, 1.32309899e-01f,
  2.18815744e-01f, 2.31561754e-02f, -1.37996122e-01f, 4.02510092e-02f, 9.88119692e-02f, 2.47426853e-02f, 1.24837153e-01f, 1.35421276e-01f, 9.84401442e-03f, 2.06499435e-02f,
  1.10919677e-01f, 1.24006480e-01f, 4.26520556e-02f, 5.95898107e-02f, -2.59740427e-02f, 9.58602130e-02f, -5.26908692e-03f, 1.39063105e-01f, -1.21250920e-01f, -2.24419132e-01f,
  -1.12838872e-01f, 1.53326824e-01f, -1.65325284e-01f, 2.77220637e-01f, -1.49191678e-01f, 1.33152939e-02f, 1.37474462e-01f, 1.03861563e-01f, 1.48148611e-01f, -3.91769893e-02f,
  -5.50638959e-02f, -1.47067264e-01f, -1.37549460e-01f, -5.70057854e-02f, -8.97011608e-02f, 8.43979940e-02f, -1.50263220e-01f, -9.05910209e-02f, -1.79166347e-01f, -1.37757152e-01f,
  2.03907102e-01f, -6.47508865e-03f, -2.86614448e-01f, 3.20577621e-01f, 3.27214412e-02f, 4.19307314e-02f, 1.17026769e-01f, -1.83894917e-01f, -1.30003318e-01f, 1.67867988e-01f,
  9.90723353e-03f, 1.47446811e-01f, -1.95655357e-02f, 1.56573355e-01f, -8.57451707e-02f, 2.00600132e-01f, 6.35846406e-02f, -1.83869705e-01f, -9.01961252e-02f, 1.04108214e-01f,
  -2.71058585e-02f, -4.38216962e-02f, 6.92013130e-02f, -4.49564308e-02f, 7.62895793e-02f, 9.45133194e-02f, 7.68411607e-02f, -2.11747102e-02f, 5.01503609e-02f, 8.71880054e-02f,
  9.68337506e-02f, 7.42282942e-02f, -1.19030498e-01f, 1.27701253e-01f, -8.00587460e-02f, 6.60648197e-02f, -4.72711623e-02f, -6.27761334e-02f, 1.17232643e-01f, -6.58361241e-02f,
  -8.63794982e-02f, -2.12595630e-02f, 5.45843355e-02f, -1.33155407e-02f, 7.10522458e-02f, -4.86780368e-02f, 1.85827851e-01f, 6.19226135e-02f, 9.50539261e-02f, 6.26129359e-02f,
  7.70155042e-02f, -2.52157636e-02f, 7.40800351e-02f, 2.16709152e-02f, 3.48130465e-02f, -8.13956410e-02f, 1.41072810e-01f, -5.58590665e-02f, 1.09934062e-01f, -1.03393778e-01f,
  -7.23574981e-02f, 1.91239923e-01f, 1.00607120e-01f, 8.47426206e-02f, 7.81020075e-02f, 1.01107001e-01f, -8.75713453e-02f, -6.94007752e-03f, 8.68582428e-02f, 3.67080909e-03f,
  -8.30707774e-02f, 2.59411912e-02f, -2.89758760e-02f, 9.59850326e-02f, 1.94270521e-01f, -8.28234479e-02f, -8.62851590e-02f, -6.27777427e-02f, 6.26189187e-02f, -4.04385701e-02f,
  -2.94245724e-02f, 2.21521527e-01f, -9.53390375e-02f, -8.95361677e-02f, 9.76253897e-02f, 1.11858323e-02f, 1.73041783e-02f, -3.86973582e-02f, -9.19436440e-02f, 1.08038247e-01f,
  1.69826634e-02f, -5.47997616e-02f, 4.91934158e-02f, 2.96580940e-02f, -1.07637659e-01f, -6.47704303e-02f, -7.13156685e-02f, 5.99139556e-02f, -1.07495009e-03f, -2.81445216e-02f,
  1.08406968e-01f, 8.34645033e-02f, -1.01430528e-01f, 1.01555139e-01f, 3.09017394e-03f, -1.14198007e-01f, -7.68210292e-02f, 6.38829544e-02f, -7.09255338e-02f, 6.25049397e-02f,
  -2.57492624e-02f, 2.07647812e-02f, 5.86159818e-04f, 4.01092619e-02f, 2.34044576e-03f, 9.33223963e-02f, 5.38186356e-02f, -3.44883576e-02f, -1.14558347e-01f, 6.40031695e-03f,
  -1.71991140e-02f, -7.74424290e-03f, 9.83158275e-02f, -9.92170200e-02f, 3.81434113e-02f, -1.19786702e-01f, 1.14273615e-01f, 1.22204497e-01f, -7.73770139e-02f, 3.95141095e-02f,
  1.32255450e-01f, 5.54996915e-02f, -7.93952122e-02f, 1.44562935e-02f, 6.99394643e-02f, 9.84669700e-02f, -3.12103964e-02f, -5.32592786e-03f, -6.46915883e-02f, -4.91205491e-02f,
  1.34536540e-02f, 1.38469739e-02f, -4.22719494e-03f, 5.84096275e-02f, -8.84509832e-02f, -6.16002455e-02f, -6.90106675e-02f, -1.17497891e-01f, -4.55064252e-02f, 7.50207230e-02f,
  5.88440597e-02f, 4.21846397e-02f, 1.04271449e-01f, -1.00915015e-01f, 6.58855215e-03f, 8.25672746e-02f, 8.31314474e-02f, -5.32888137e-02f, -9.49092731e-02f, -2.89145112e-02f,
  -8.70302618e-02f, 1.14658952e-01f, 5.13526388e-02f, -5.01377769e-02f, -4.86119613e-02f, -1.04992837e-01f, -1.23320468e-01f, 2.25934070e-02f, -5.78766763e-02f, 4.23374847e-02f,
  -2.99373623e-02f, 3.09414882e-02f, -2.07334030e-02f, 7.92259201e-02f, -6.92364797e-02f, 5.66009842e-02f, -2.39110142e-02f, 1.10165022e-01f, -5.99103980e-02f, 4.60485369e-02f,
  7.93452282e-03f, -9.23229818e-05f, 5.06481677e-02f, -1.26992464e-01f, -6.58607930e-02f, -4.64145802e-02f, 7.41753355e-02f, -4.09422033e-02f, 5.22006005e-02f, -2.73459610e-02f,
  4.79812510e-02f, 1.90033868e-03f, -6.69266060e-02f, 6.05545565e-02f, -9.21533629e-02f, 6.33120462e-02f, -2.88299806e-02f, 9.37345251e-02f, 4.47452962e-02f, -1.08111352e-01f,
  1.26532149e-02f, -3.17212082e-02f, -1.09474212e-01f, 1.05326779e-01f, -7.98791572e-02f, -1.01432398e-01f, 4.76279631e-02f, 2.83548944e-02f, -1.24389054e-02f, 1.08678550e-01f,
  -7.45907053e-02f, -5.03283963e-02f, -7.40286857e-02f, 5.03172427e-02f, 5.60510270e-02f, -3.91061231e-02f, -8.71293247e-02f, -1.27207965e-01f, 4.03272994e-02f, 7.33468011e-02f,
  -2.72087869e-04f, 1.37304857e-01f, -4.24703360e-02f, -1.20073082e-02f, -5.89894541e-02f, -7.33454302e-02f, -7.92283788e-02f, -9.23757181e-02f, 1.53573900e-01f, -5.80273271e-02f,
  1.38610363e-01f, 2.19332669e-02f, 1.83601435e-02f, -6.44437224e-03f, 1.09413527e-01f, 1.27418935e-01f, 3.00986655e-02f, 2.95247398e-02f, 4.19712663e-02f, -1.40337855e-01f,
  1.17209092e-01f, -3.44272964e-02f, 1.42221749e-01f, -2.09030835e-03f, 1.49873253e-02f, -1.30342767e-01f, 1.48980394e-01f, -6.16032779e-02f, 7.63166323e-02f, -6.80682287e-02f,
  5.59582599e-02f, 1.11126341e-01f, -1.27927154e-01f, -3.58643718e-02f, -2.17468124e-02f, 4.54553030e-02f, 2.69953697e-03f, -1.71544850e-01f, -9.74800289e-02f, 2.54469551e-02f,
  1.07224450e-01f, -4.56021428e-02f, -9.71381068e-02f, 1.88184172e-01f, 6.11301102e-02f, 2.46268120e-02f, -6.47284389e-02f, 1.01615852e-02f, 1.31367445e-01f, 6.52556643e-02f,
  -7.61266649e-02f, 4.86508571e-02f, 3.72797251e-02f, -6.94336295e-02f, -4.06877771e-02f, 1.02629453e-01f, 7.03637749e-02f, 9.37087834e-02f, -8.49224441e-03f, -1.03186540e-01f,
  -1.77362859e-02f, 5.88493273e-02f, 4.00219969e-02f, -3.16886939e-02f, 3.44248414e-02f, 1.36444885e-02f, 9.22201350e-02f, 4.18940522e-02f, -4.79893163e-02f, 6.14367500e-02f,
  2.24731565e-02f, 1.13941915e-01f, 1.19519494e-01f, 1.15905434e-01f, 8.93965885e-02f, 3.01997401e-02f, -2.15918589e-02f, 1.30000636e-01f, 2.16668732e-02f, -1.40071929e-01f,
  9.41916183e-02f, -6.50730506e-02f, -1.80351697e-02f, -7.61507079e-02f, 5.76536618e-02f, 6.86765984e-02f, -1.23642735e-01f, -4.83839661e-02f, -2.61619948e-02f, -6.89377412e-02f,
  4.66720648e-02f, 1.08482786e-01f, -1.32097930e-01f, -1.44483345e-02f, 2.68990453e-02f, -3.26801352e-02f, -6.94286823e-02f, 4.81168516e-02f, 1.55348135e-02f, 4.48585190e-02f,
  1.01558179e-01f, 1.69345334e-01f, 1.66369721e-01f, 4.10481319e-02f, -6.73704967e-02f, 2.07618121e-02f, 1.15509726e-01f, -1.98780242e-02f, 1.35209144e-03f, -3.48592810e-02f,
  6.01757132e-02f, 3.08830477e-02f, -8.26032832e-02f, -4.95398045e-02f, 2.89351400e-02f, 4.60010581e-02f, 5.87493107e-02f, -8.28346610e-02f, -3.93375903e-02f, -3.75683643e-02f,
  3.90978828e-02f, -9.12796482e-02f, -1.22874878e-01f, 1.23372987e-01f, 1.04941621e-01f, 1.11945748e-01f, -9.74361449e-02f, 9.09336880e-02f, -1.42497681e-02f, 3.69291976e-02f,
  9.29908305e-02f, -4.39571217e-02f, -1.17284626e-01f, 8.58289078e-02f, 6.85310140e-02f, 8.08861926e-02f, -2.49628760e-02f, 9.42218453e-02f, 3.90001759e-02f, 1.19131953e-01f,
  -1.23960525e-01f, 2.63989344e-02f, -6.26771823e-02f, 1.91125244e-01f, 4.14012708e-02f, 8.33953917e-02f, 6.60131946e-02f, 2.69420557e-02f, -1.17262729e-01f, -1.55457137e-02f,
  3.26264985e-02f, 1.89882696e-01f, -6.42810836e-02f, -1.33435115e-01f, 8.30483958e-02f, -8.79714862e-02f, -1.38638169e-01f, 2.16753364e-01f, -1.67806342e-01f, 9.90536287e-02f,
  1.54514924e-01f, -1.78446531e-01f, 1.91890951e-02f, 8.49013403e-02f, -5.55982850e-02f, 1.23713836e-01f, 1.87244371e-01f, -9.69200432e-02f, 1.25443891e-01f, -6.63803890e-02f,
  1.09691270e-01f, -8.05883259e-02f, -5.47679216e-02f, -3.84743288e-02f, 5.73146564e-04f, 1.85751453e-01f, 1.36595014e-02f, 5.25207678e-03f, 8.84509012e-02f, 1.46043271e-01f,
  7.01051159e-03f, -1.87101811e-02f, -1.36198727e-02f, 1.69383243e-01f, 1.30489588e-01f, 1.72587514e-01f, 8.15063566e-02f, 3.08598578e-01f, 2.39456192e-01f, 1.84231177e-01f,
  2.06946190e-02f, -7.64257368e-03f, -4.06694673e-02f, 1.13680348e-01f, 1.40727624e-01f, 1.50076538e-01f, 1.11246310e-01f, 9.86255109e-02f, 1.12457179e-01f, 2.16945350e-01f,
  1.27431065e-01f, 1.85922801e-01f, 1.55588880e-01f, -2.08018031e-02f, -1.49097843e-02f, 1.76827282e-01f, 6.72599487e-03f, 1.71774492e-01f, 3.92330587e-02f, 1.65208340e-01f,
  -5.26490323e-02f, -1.45431394e-02f, -5.42121194e-02f, 2.54235685e-01f, 1.86150059e-01f, 4.24927883e-02f, 2.06942782e-01f, -1.56422526e-01f, -3.88983125e-03f, -1.58091053e-01f,
  -2.67448314e-02f, 2.78384089e-01f, -3.16933274e-01f, -8.08596984e-03f, 3.79320055e-01f, -2.18045071e-01f, 9.71930325e-02f, -2.14644462e-01f, -7.01157078e-02f, 7.26613253e-02f,
  -1.62617967e-01f, 1.35942191e-01f, 5.60210794e-02f, -1.19648322e-01f, 1.70568302e-01f, -1.53751716e-01f, 1.19432136e-01f, 1.30625352e-01f, -4.15747054e-03f, -1.09086908e-01f,
  2.10885912e-01f, -1.59173891e-01f, 1.14033327e-01f, 1.01529181e-01f, -1.08584911e-01f, -1.53684197e-02f, 3.40643385e-03f, 9.22257677e-02f, -1.64519101e-02f, 6.33993885e-03f,
  1.11264652e-02f, -1.25941560e-01f, 1.47156343e-01f, 1.11982360e-01f, 1.03407107e-01f, 6.00577183e-02f, 2.00015530e-01f, 5.77744953e-02f, 1.88530043e-01f, -1.93338338e-02f,
  6.71183020e-02f, 1.14293523e-01f, -2.37888796e-03f, 1.10693485e-01f, -6.31802389e-03f, 1.04920812e-01f, 5.26113436e-02f, -4.45045717e-02f, 1.53513864e-01f, -4.23491485e-02f,
  2.95132454e-02f, -2.24636436e-01f, -7.10390601e-03f, -1.46727994e-01f, -3.81598696e-02f, 5.58152571e-02f, -2.02128410e-01f, -6.81495890e-02f, 1.19140722e-01f, -2.29436532e-01f,
  9.17298812e-03f, 6.78872317e-02f, -1.94704637e-01f, 1.06257655e-01f, -1.89437270e-01f, 5.27749397e-02f, 2.28898600e-01f, 7.18822256e-02f, -1.39188543e-01f, 2.63486564e-01f,
  8.73506889e-02f, 1.29346907e-01f, 1.14673026e-01f, 3.23523432e-02f, 1.65089872e-02f, -6.51006252e-02f, 7.09054172e-02f, 9.51733906e-03f, -1.33628324e-01f, 3.61778066e-02f,
  8.74641240e-02f, -9.49325487e-02f, 5.84897473e-02f, 2.40233857e-02f, 1.26806423e-02f, 5.42045347e-02f, -6.94411919e-02f, -6.17294274e-02f, -7.06915259e-02f, 7.69813582e-02f,
  1.11577116e-01f, 2.22240195e-01f, 5.16467467e-02f, 3.86292972e-02f, 9.29507837e-02f, 1.82716683e-01f, 1.31511092e-01f, -7.41870701e-02f, -1.46555647e-01f, 2.11484328e-01f,
  1.29158786e-02f, 4.92360853e-02f, 8.00634399e-02f, -1.50080010e-01f, -1.17375009e-01f, 7.56789893e-02f, -5.23669533e-02f, 3.12023479e-02f, -2.13349294e-02f, 5.57685718e-02f,
  -4.75944355e-02f, -2.83264220e-02f, -1.04639173e-01f, -6.08633012e-02f, 1.35453105e-01f, 2.43899405e-01f, -2.20137145e-02f, -8.19640234e-02f, -2.52987314e-02f, -3.58057842e-02f,
  -1.47411048e-01f, 7.29926080e-02f, -1.23400033e-01f, 9.18447897e-02f, -1.29229099e-01f, 3.56125757e-02f, 1.49678439e-01f, 9.01597887e-02f, -1.30393803e-01f, 1.07175551e-01f,
  -4.84864004e-02f, -1.58830851e-01f, 7.74118081e-02f, -1.05137825e-01f, 5.31339794e-02f, 8.29586387e-02f, 1.05566218e-01f, 6.62597083e-03f, 2.59135067e-01f, 4.68719527e-02f,
  1.87192351e-01f, -9.64387357e-02f, 6.39424846e-02f, -5.82829025e-03f, 5.01201637e-02f, -1.29501566e-01f, 1.77349880e-01f, 7.41700977e-02f, 1.20775238e-01f, -6.94881454e-02f,
  -6.64406270e-02f, -5.01779243e-02f, -9.97141376e-02f, 1.78888246e-01f, 1.23499520e-01f, 1.92492098e-01f, -1.24794506e-02f, -3.31128053e-02f, 9.62232575e-02f, -7.70488903e-02f,
  2.15583354e-01f, 2.44821548e-01f, 1.14855319e-01f, -2.13281978e-02f, -3.67128365e-02f, 5.65426759e-02f, 1.40099198e-01f, -4.70862426e-02f, 4.64981124e-02f, 1.81710258e-01f,
  2.08652213e-01f, 2.48424351e-01f, 3.70718688e-02f, 3.44110020e-02f, -3.57079655e-02f, 1.63227379e-01f, 2.32029840e-01f, 1.66961908e-01f, -1.55267520e-02f, -6.79388866e-02f,
  -1.40297953e-02f, -1.83195800e-01f, 4.93646134e-03f, 1.33441418e-01f, -8.19181427e-02f, -1.46799520e-01f, -5.80643266e-02f, -1.01503484e-01f, 4.30648029e-02f, 1.55365244e-01f,
  3.35913338e-02f, 3.81195210e-02f, -1.30669266e-01f, 3.99329104e-02f, 1.62198588e-01f, -8.69802535e-02f, -4.61349674e-02f, -3.36688235e-02f, -5.09695113e-02f, -1.47232383e-01f,
  1.96668595e-01f, 1.60079703e-01f, 2.10322917e-01f, 2.05585733e-01f, 4.82719019e-02f, 3.50396261e-02f, -1.55583781e-03f, -7.01951012e-02f, 1.12547331e-01f, -1.07525224e-02f,
  -8.47754553e-02f, 1.95825726e-01f, -1.21960230e-01f, 1.64224103e-01f, 1.23935722e-01f, 1.20608009e-01f, 1.06682412e-01f, 2.08731920e-01f, -8.97637606e-02f, -1.21140406e-02f,
  7.54648820e-02f, -9.52866208e-03f, 6.30256087e-02f, 4.14298996e-02f, 1.09456450e-01f, -4.40048501e-02f, 1.40622169e-01f, 1.30092993e-01f, 1.18596643e-01f, -3.15870717e-02f,
  7.33339116e-02f, -8.01582485e-02f, -7.69449174e-02f, 1.20846003e-01f, -1.43102426e-02f, -3.82909738e-02f, 2.19209795e-03f, -1.17385229e-02f, 1.21454313e-01f, -2.02402398e-02f,
  -9.93704200e-02f, -1.06058396e-01f, -2.22556610e-02f, 3.29047279e-03f, 1.23524748e-01f, -4.38783802e-02f, 9.04038250e-02f, -1.46544710e-01f, 1.94176640e-02f, 7.09642395e-02f,
  1.50925413e-01f, -1.51919290e-01f, 2.29070242e-02f, 8.35089013e-02f, -3.78354974e-02f, -3.38866226e-02f, 1.40336946e-01f, -7.67007470e-02f, -7.95890912e-02f, -7.58749619e-02f,
  -1.24242291e-01f, 1.84178293e-01f, -1.23525091e-01f, 6.90303221e-02f, -9.51372907e-02f, 5.45977103e-03f, 8.20983760e-03f, -1.32897928e-01f, 1.29989535e-01f, 9.23429057e-02f,
  1.00374974e-01f, 1.59246832e-01f, 1.20896287e-03f, -1.25435546e-01f, -6.02103285e-02f, 1.72755439e-02f, -8.12144652e-02f, -2.74894070e-02f, -3.06411041e-03f, 7.50812441e-02f,
  9.01531652e-02f, 7.67339766e-03f, -3.60038429e-02f, 6.33595213e-02f, 1.19047962e-01f, 8.30110908e-02f, 1.07632942e-01f, -7.94423968e-02f, 6.52883500e-02f, -6.02779463e-02f,
  4.50031273e-02f, -5.21450862e-02f, -2.36787647e-02f, -5.80127984e-02f, 6.33629635e-02f, 8.87562782e-02f, -5.96664026e-02f, 1.53442457e-01f, 1.20901428e-01f, -4.05389778e-02f,
  1.26240477e-01f, -5.34797609e-02f, 4.02183924e-03f, 1.42868191e-01f, 5.69371693e-02f, -3.43901478e-02f, -3.93669792e-02f, -1.12635866e-01f, -1.19871899e-01f, 1.36557380e-02f,
  4.06101495e-02f, 1.45794898e-02f, -6.59573525e-02f, -9.13098902e-02f, -3.14848013e-02f, -6.59407601e-02f, 1.13177612e-01f, 1.57436907e-01f, 2.52004936e-02f, -1.23920783e-01f,
  -4.87828255e-02f, -6.50176257e-02f, 1.79610774e-01f, 1.38848409e-01f, -6.13881238e-02f, -7.49140158e-02f, -1.18309215e-01f, -3.81476991e-02f, 1.19642131e-01f, -1.33329317e-01f,
  -4.96874861e-02f, 9.30595677e-04f, 1.11474052e-01f, -1.13497518e-01f, -9.61454138e-02f, -3.29621509e-02f, -4.03391793e-02f, 4.90650684e-02f, 9.21074301e-03f, -5.23088090e-02f,
  1.15998395e-01f, 2.43478175e-03f, 1.36681989e-01f, 1.58677205e-01f, 1.23317074e-02f, -9.56803635e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -4.94967215e-02f, 1.00730620e-01f, -4.24206853e-02f, 3.59045491e-02f, 4.35461365e-02f, 1.23827606e-01f, 1.58620372e-01f, 1.41672613e-02f, 6.07189983e-02f, 8.95401910e-02f,
  1.24048010e-01f, 4.26979400e-02f, -7.73269683e-02f, 1.72267914e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -2.56861337e-02f, -1.32644847e-02f, -7.61985630e-02f, 4.62115631e-02f, 6.37913942e-02f, -1.17366105e-01f, -1.80048663e-02f, -1.57958984e-01f, 4.98516951e-03f, 1.43590748e-01f,
  5.13947271e-02f, 1.52027741e-01f, 1.09576687e-01f, -9.92852077e-02f, 5.26034571e-02f, 5.82333170e-02f, -4.90243472e-02f, 4.08404358e-02f, -1.37928188e-01f, -1.71456430e-02f,
  1.18954323e-01f, 1.51435867e-01f, -3.48321907e-02f, 1.01532698e-01f, -1.29213929e-01f, -3.85992453e-02f, -2.28955615e-02f, 7.90482610e-02f, 1.32161289e-01f, -7.46646076e-02f,
  -1.04695000e-01f, 8.93838033e-02f, 2.72743981e-02f, 7.05183819e-02f, -2.86340058e-01f, 1.45409508e-02f, 1.55539170e-01f, 2.29428425e-01f, 9.84053314e-02f, 1.22713737e-01f,
  -3.08006167e-01f, 1.04888335e-01f, 1.25797123e-01f, -1.82669044e-01f, 6.03655353e-03f, 9.13078114e-02f, -1.97479814e-01f, -3.13781708e-01f, -1.94217905e-01f, -6.44989759e-02f,
  6.16871342e-02f, -1.35945398e-02f, 9.99926403e-03f, -9.86904055e-02f, -1.00453176e-01f, 2.38341205e-02f, 4.58759703e-02f, 4.76406738e-02f, -1.49554759e-01f, 1.21929035e-01f,
  6.36276975e-02f, 2.39306331e-01f, -8.51419345e-02f, 1.78823858e-01f, -5.74989505e-02f, -7.64176100e-02f, -1.28289431e-01f, 1.07894927e-01f, -1.95535690e-01f, 9.07307267e-02f,
  1.26011863e-01f, 1.35917440e-01f, -9.65642743e-03f, 7.50887245e-02f, 9.82683524e-02f, 7.29178637e-02f, 9.50121228e-03f, -6.02054410e-03f, -1.69129327e-01f, 5.05889431e-02f,
  5.65312430e-02f, 6.92438707e-02f, -1.39173061e-01f, 1.27988517e-01f, 8.22731182e-02f, -1.45818129e-01f, -2.67824791e-02f, -1.42229646e-01f, 1.13530286e-01f, 1.65432602e-01f,
  -1.83046922e-01f, 3.02517135e-02f, -1.59336790e-01f, 1.63131922e-01f, 2.33099341e-01f, 2.42903411e-01f, 1.22237287e-01f, 3.12703758e-01f, 2.95340657e-01f, -1.74458444e-01f,
  -3.89706790e-02f, -1.93094909e-01f, -4.25197706e-02f, -7.60717690e-02f, 3.40437531e-01f, -1.76685244e-01f, -1.42545968e-01f, 2.07415327e-01f, -1.60171211e-01f, 1.54953059e-02f,
  2.43307993e-01f, -2.68191211e-02f, 4.82467711e-02f, -5.78627251e-02f, -4.02664915e-02f, 7.22145438e-02f, -1.17706247e-01f, -3.80596593e-02f, -1.28172785e-01f, -2.26807836e-02f,
  -5.08966185e-02f, -1.20082155e-01f, 2.26744294e-01f, 8.06613714e-02f, -1.99684307e-01f, -3.99880335e-02f, 4.75300057e-03f, -2.74376888e-02f, -1.00278556e-01f, 2.71577705e-02f,
  8.80246758e-02f, 2.37981811e-01f, -9.46255401e-02f, 4.44068499e-02f, 1.08073803e-03f, -1.21791460e-01f, 7.94053674e-02f, 1.56291947e-01f, 2.41206177e-02f, 1.06604397e-01f,
  2.08956644e-01f, 1.80499211e-01f, -1.41160265e-01f, 1.17144339e-01f, 9.06894803e-02f, 1.31407157e-01f, 4.97805104e-02f, 2.17125162e-01f, -4.28220443e-02f, -3.22862826e-02f,
  2.19363403e-02f, 1.84010923e-01f, 1.52643889e-01f, 1.99349552e-01f, -4.93650101e-02f, -7.00912625e-02f, -1.58364877e-01f, 1.17282003e-01f, -8.39635581e-02f, -1.12984469e-02f,
  1.67319715e-01f, 2.06414163e-01f, 7.08774179e-02f, -4.63297591e-02f, 1.20027348e-01f, -8.89067724e-02f, -1.06907949e-01f, -1.82313532e-01f, 2.35817865e-01f, -1.00382760e-01f,
  -1.24067739e-02f, 1.98031634e-01f, 1.72437653e-01f, -6.51459098e-02f, -3.64420004e-02f, -1.64930403e-01f, 2.19474379e-02f, 2.23060623e-02f, 2.78304666e-02f, 2.00646594e-01f,
  2.05140971e-02f, -5.74635714e-02f, -3.45190242e-02f, 7.14066327e-02f, -1.29814837e-02f, -1.83007970e-01f, 1.52726069e-01f, -6.77578449e-02f, -2.23929539e-01f, 1.42033836e-02f,
  -1.83800265e-01f, 6.04174025e-02f, 3.68221924e-02f, 7.29864230e-03f, 1.11815706e-01f, -1.65951237e-01f, 5.78013510e-02f, 7.38416761e-02f, 3.95647101e-02f, -1.83402926e-01f,
  -1.57281026e-01f, -1.11609235e-01f, 1.23296147e-02f, 1.18601650e-01f, -2.31859729e-01f, -7.97011331e-02f, 1.04800425e-01f, 4.61369678e-02f, 1.04205799e-03f, -8.11315030e-02f,
  -3.17976475e-02f, -1.36102840e-01f, -1.23368576e-01f, 1.44512728e-01f, -4.58209477e-02f, -8.76129344e-02f, -2.54439920e-01f, 2.78729433e-03f, -1.11037657e-01f, -4.68200557e-02f,
  -1.77949909e-02f, -2.72913165e-02f, -1.96977332e-01f, -1.41708225e-01f, -5.35414927e-02f, -1.53221279e-01f, -6.42650574e-02f, 2.34197378e-01f, 1.33510530e-01f, -7.52058625e-02f,
  2.12954178e-01f, 1.63438380e-01f, -2.88487196e-01f, 2.56328613e-01f, 2.67359704e-01f, -2.34716088e-01f, -1.74817845e-01f, -3.21578123e-02f, -2.06199095e-01f, -7.53580034e-02f,
  -1.25877097e-01f, -1.25688687e-01f, 9.75957960e-02f, -2.78109238e-02f, 1.14573814e-01f, 5.28810397e-02f, 4.28811833e-02f, 1.30090356e-01f, 9.43601280e-02f, 1.90206066e-01f,
  -2.85032898e-01f, -4.10272442e-02f, 2.40554437e-01f, -2.77453884e-02f, 2.12025240e-01f, -1.04545102e-01f, -1.76589713e-02f, -6.93195313e-02f, 1.25943616e-01f, 4.81239557e-02f,
  -1.90816328e-01f, 8.55532289e-02f, -5.81358885e-03f, -1.26748785e-01f, -6.76673427e-02f, 1.32574946e-01f, -9.57712159e-02f, 4.19847574e-03f, -1.64732337e-01f, 7.17107579e-02f,
  3.58183645e-02f, 1.90191388e-01f, -1.63461845e-02f, 1.22998446e-01f, 1.65112287e-01f, 4.14102748e-02f, 1.88110441e-01f, 3.51581015e-02f, 3.05271372e-02f, -1.03408709e-01f,
  2.24183157e-01f, 1.65922195e-02f, -2.11082771e-01f, -9.85672176e-02f, -2.40346193e-01f, 1.08144574e-01f, -2.26481199e-01f, 5.52439988e-02f, 3.22129101e-01f, 1.16717391e-01f,
  3.87574807e-02f, -1.01980865e-01f, 1.53908387e-01f, -2.39948675e-01f, -1.24278016e-01f, 5.69534451e-02f, 2.95653582e-01f, 2.09311750e-02f, 1.34774223e-01f, -1.00031294e-01f,
  -3.37313302e-02f, -1.92491338e-02f, -1.41855001e-01f, -7.62821585e-02f, 1.68472633e-01f, 1.09628879e-01f, 5.12453206e-02f, -6.21539587e-03f, -2.95648491e-03f, 8.94951448e-02f,
  -5.70479557e-02f, 1.98562682e-01f, -9.44620967e-02f, -9.38750431e-02f, -5.10999188e-02f, -1.23042203e-01f, -1.29503280e-01f, -2.74657935e-01f, 1.84656754e-02f, 6.20920397e-03f,
  1.24844074e-01f, -5.19194417e-02f, -1.29053131e-01f, 9.38958079e-02f, -1.12318143e-01f, 6.16756007e-02f, 8.75242949e-02f, -2.54241265e-02f, -5.93396276e-02f, 8.43500271e-02f,
  1.80787779e-02f, -1.38822690e-01f, 3.22060063e-02f, -8.78455210e-03f, -3.68979238e-02f, -2.00963896e-02f, -4.00376283e-02f, -9.47048515e-02f, 1.07488528e-01f, -8.42545927e-02f,
  -1.84793714e-02f, 7.28248805e-02f, 2.28140101e-01f, 1.01013012e-01f, 2.14538798e-02f, -1.29078284e-01f, -2.80505836e-01f, 9.85447764e-02f, -2.01806158e-01f, 1.48399383e-01f,
  1.73869506e-02f, 1.75022438e-01f, 6.53447434e-02f, 2.57024884e-01f, 3.62191558e-01f, 4.12331820e-02f, -3.88745181e-02f, -2.61918694e-01f, -1.85522169e-01f, -1.41896456e-01f,
  3.01426947e-01f, 1.24644190e-01f, 7.61511773e-02f, 1.26314104e-01f, -2.34913170e-01f, 9.16159898e-02f, 1.84486583e-01f, 2.19239309e-01f, 2.31436163e-01f, 1.73349395e-01f,
  -6.45056292e-02f, -9.56251249e-02f, 1.19879596e-01f, 4.54500578e-02f, 1.14945777e-01f, 2.90339421e-02f, -4.86269705e-02f, -1.85820729e-01f, 3.91858928e-02f, 6.52327091e-02f,
  -1.05047300e-01f, -2.16257662e-01f, 1.12768285e-01f, -2.21336838e-02f, -9.77884158e-02f, 2.52068460e-01f, 1.06592081e-01f, -3.14808637e-02f, 5.69048151e-02f, -7.01239109e-02f,
  8.23165700e-02f, -8.31529722e-02f, 2.28598546e-02f, 1.12471014e-01f, -1.64878041e-01f, -1.25330746e-01f, 2.54376624e-02f, 1.46295682e-01f, 4.93446365e-02f, 1.03866309e-01f,
  1.27868121e-02f, -7.02280626e-02f, 2.52916291e-02f, -1.88099623e-01f, 7.46352747e-02f, 1.09452151e-01f, -2.17235655e-01f, 2.72705834e-02f, -1.93022028e-01f, -5.59749864e-02f,
  4.32469696e-03f, -1.55895099e-01f, 3.11487950e-02f, -1.27867594e-01f, -2.79177547e-01f, -2.44307816e-01f, 8.83031338e-02f, -2.23799750e-01f, -3.35593611e-01f, -4.49143983e-02f,
  5.93500733e-02f, 1.57976523e-01f, 1.00385182e-01f, -9.23378915e-02f, -2.55864888e-01f, 5.58102131e-02f, -9.44996849e-02f, -1.44923910e-01f, 1.24943823e-01f, -8.98428112e-02f,
  -2.85425276e-01f, -2.16774389e-01f, -2.36013249e-01f, -2.06940733e-02f, -2.90750191e-02f, 1.69918045e-01f, 9.58503410e-02f, 9.43062007e-02f, -6.25492856e-02f, -1.22024141e-01f,
  2.68804077e-02f, -4.60583903e-02f, -1.81325197e-01f, -1.57541409e-01f, -4.25527468e-02f, 1.11091420e-01f, 5.95891625e-02f, -4.99536209e-02f, 4.83929589e-02f, 7.58606046e-02f,
  -1.15584910e-01f, -1.03280462e-01f, 1.84395127e-02f, -1.59370169e-01f, 4.08100821e-02f, -5.71637647e-04f, -2.42073342e-01f, -9.68244672e-02f, -2.67681964e-02f, 7.33945370e-02f,
  -1.86301693e-01f, -2.03455910e-01f, 3.54105420e-02f, -2.42208719e-01f, -7.34435394e-02f, -5.52505776e-02f, 9.12564099e-02f, -1.00046411e-01f, -4.27703112e-02f, -1.15812212e-01f,
  4.95793186e-02f, -2.24802539e-01f, -1.72437459e-01f, -2.58430332e-01f, -9.28298756e-02f, 4.69905175e-02f, -1.01346910e-01f, -1.24950767e-01f, -1.70360997e-01f, 8.68767221e-03f,
  1.15058146e-01f, -1.11953661e-01f, 2.77858507e-02f, 3.05559665e-01f, -2.78834164e-01f, -2.15495273e-01f, 1.48812653e-02f, -1.28927350e-01f, 1.30804881e-01f, 1.04902133e-01f,
  2.84564435e-01f, -9.93766785e-02f, -3.14172089e-01f, 6.98004141e-02f, -2.20081322e-02f, 2.92477459e-01f, 1.43290535e-01f, 4.35131229e-02f, -6.38400316e-02f, -2.71797746e-01f,
  1.86948046e-01f, 4.79257815e-02f, -7.27221593e-02f, -6.76358789e-02f, -5.69122992e-02f, -6.20064465e-03f, -2.14615032e-01f, 1.17688894e-01f, 2.13850498e-01f, 1.58763230e-01f,
  4.65036780e-02f, 8.01843032e-02f, -4.95276488e-02f, 9.52101126e-02f, 9.47539657e-02f, -3.67592610e-02f, -1.09141991e-01f, 2.39093140e-01f, 2.01161206e-01f, -3.33286561e-02f,
  -3.29303108e-02f, 7.98688270e-03f, 8.90072435e-02f, 1.67496964e-01f, -9.67216268e-02f, 3.66991945e-02f, 3.53186503e-02f, 8.05850923e-02f, 1.09450080e-01f, 9.20453593e-02f,
  6.69802502e-02f, -3.74241211e-02f, -5.89061119e-02f, -1.13071851e-01f, -1.34153692e-02f, -1.13507777e-01f, 1.60731509e-01f, -9.49151888e-02f, -2.38799810e-01f, 4.25498234e-03f,
  2.28328295e-02f, 5.09385765e-02f, -2.15601623e-02f, -3.27601650e-04f, -6.62524924e-02f, 1.55096456e-01f, 4.37612176e-01f, 2.24670172e-01f, -2.79414386e-01f, -3.59204747e-02f,
  -1.05575286e-01f, -1.72986507e-01f, 1.55695602e-01f, -5.80068752e-02f, -7.02362210e-02f, -8.51498172e-02f, -1.89754352e-01f, 5.74746877e-02f, 2.64532804e-01f, 3.50947022e-01f,
  1.41507298e-01f, 2.21166238e-01f, -6.88275024e-02f, -2.67973512e-01f, 5.75453639e-02f, 7.98696950e-02f, 1.01807252e-01f, -4.80015464e-02f, 8.51937234e-02f, -1.12231439e-02f,
  5.62778898e-02f, -2.92264428e-02f, 6.19580708e-02f, -1.31412685e-01f, -1.58856809e-02f, -1.12523168e-01f, 4.08742726e-02f, 1.14170313e-01f, 1.42366998e-02f, -1.22311160e-01f,
  1.39896065e-01f, -8.91885757e-02f, 1.76659916e-02f, 1.52680188e-01f, -2.40781028e-02f, -1.30894348e-01f, 6.89493045e-02f, -1.56471774e-01f, 2.32593894e-01f, -1.47296816e-01f,
  -7.98204467e-02f, -2.97273714e-02f, 6.41102344e-02f, -1.35598540e-01f, 3.22171748e-02f, -1.33984592e-02f, -1.90465853e-01f, 9.64055359e-02f, 1.25566050e-01f, -4.94689867e-02f,
  -2.32362390e-01f, -8.38134065e-02f, 1.42416447e-01f, 1.59574106e-01f, 1.16556235e-01f, 6.03354461e-02f, -3.25594796e-03f, -2.97556389e-02f, -3.27694774e-01f, -1.82948574e-01f,
  1.49181932e-01f, 1.11020088e-01f, -1.64033055e-01f, 1.30705982e-01f, 1.15857229e-01f, -2.00727224e-01f, -1.09034568e-01f, -1.35485873e-01f, -1.93653569e-01f, 1.78147256e-01f,
  1.91049606e-01f, -7.32224435e-02f, 1.00980267e-01f, 1.60242230e-01f, -1.50468498e-01f, -1.95898488e-01f, -4.61986288e-02f, -8.27013552e-02f, 8.76330510e-02f, 1.71063598e-02f,
  -1.00389950e-01f, -1.86491057e-01f, 6.68581277e-02f, 1.58060759e-01f, 2.14994729e-01f, 9.41532291e-03f, 8.09408054e-02f, 1.77658468e-01f, 3.48532088e-02f, -1.27106383e-01f,
  -1.80000067e-01f, 1.56338081e-01f, 4.78413366e-02f, -3.96361239e-02f, 5.20935804e-02f, 2.42398623e-02f, -1.78293120e-02f, -5.62885925e-02f, -5.73022626e-02f, 1.08722471e-01f,
  1.40596451e-02f, -1.66217864e-01f, 1.78405732e-01f, -2.57962734e-01f, -8.96904916e-02f, 2.35241745e-02f, 6.10371083e-02f, 1.50300190e-02f, -2.27821842e-01f, 1.30045444e-01f,
  -1.17921382e-01f, -9.07249302e-02f, -2.64176559e-02f, 2.98714042e-02f, -1.07326791e-01f, 1.98545799e-01f, 1.94185793e-01f, -1.13472253e-01f, -1.42725371e-03f, -8.77550319e-02f,
  1.34435117e-01f, 2.42657453e-01f, -1.04164317e-01f, 1.08524874e-01f, 5.18940203e-02f, 1.95639417e-01f, -1.68237895e-01f, 1.96684167e-01f, -1.29641920e-01f, -5.47987036e-03f,
  -1.10146411e-01f, -1.70759246e-01f, 1.73184469e-01f, 2.34148279e-01f, 1.03444383e-01f, 1.43359631e-01f, 1.21644363e-01f, -9.20264795e-02f, -9.52728838e-02f, -2.26764567e-02f,
  -8.14922061e-03f, -7.82008022e-02f, -2.81616151e-02f, -5.13294563e-02f, -2.22595632e-02f, -2.52281018e-02f, 4.99823727e-02f, -1.53674021e-01f, -2.06617683e-01f, 2.79399902e-01f,
  -1.93919614e-02f, 5.98125979e-02f, 2.02345792e-02f, -1.19000152e-01f, 1.03232067e-03f, 1.40587715e-02f, -4.74163406e-02f, -8.68552029e-02f, 1.92815941e-02f, -1.58773750e-01f,
  -1.39471963e-02f, -9.51828733e-02f, 1.30288079e-01f, 3.27080861e-02f, 3.05837672e-02f, 1.52887821e-01f, 2.95435861e-02f, 4.14541624e-02f, 1.33334994e-01f, 9.03201252e-02f,
  2.58353958e-03f, 2.52478896e-03f, 1.00120433e-01f, -1.25976279e-03f, -5.77015951e-02f, 2.80700028e-02f, -2.49565333e-01f, 8.46318379e-02f, -2.39044279e-02f, -5.36054671e-02f,
  7.58067530e-04f, -1.04669951e-01f, 3.62005346e-02f, -2.04114765e-01f, -4.35182899e-02f, -1.41515091e-01f, 1.05649605e-01f, -1.85095981e-01f, -3.85829329e-01f, -1.13566801e-01f,
  2.10827574e-01f, 3.16196799e-01f, -6.83136284e-02f, 1.49968460e-01f, -3.89377654e-01f, -5.52555248e-02f, 8.67035240e-02f, -5.11615872e-02f, 1.88223794e-01f, -1.76837333e-02f,
  -1.89301580e-01f, -2.15533778e-01f, -2.43761972e-01f, -1.46803781e-01f, -9.40089226e-02f, 1.29804492e-01f, 6.63748235e-02f, 3.87046412e-02f, 1.62375218e-03f, 6.80705234e-02f,
  5.98645583e-02f, 9.30462927e-02f, -1.03615791e-01f, 2.60437503e-02f, 1.27982143e-02f, 1.38668656e-01f, -1.00952372e-01f, 1.12672877e-02f, 2.83409618e-02f, 1.88042998e-01f,
  1.17899058e-03f, 1.24426939e-01f, 1.72027856e-01f, 9.67395455e-02f, 4.68945913e-02f, -4.66571562e-02f, 1.38125464e-01f, 9.02181119e-02f, 4.29890528e-02f, -7.67516121e-02f,
  1.11052349e-01f, -7.57243624e-03f, 5.86506464e-02f, 2.29395535e-02f, 1.35283574e-01f, 6.94850609e-02f, 1.06613994e-01f, -4.27158922e-02f, 1.01122335e-01f, 1.85590908e-01f,
  -1.22196734e-01f, 1.06743611e-01f, -2.10567079e-02f, 8.54569525e-02f, -5.74920364e-02f, 5.94112463e-02f, 6.49402365e-02f, -9.15460140e-02f, -2.07327366e-01f, -1.94943398e-01f,
  1.78883106e-01f, 3.37933414e-02f, -1.69393271e-01f, -5.77052720e-02f, -1.61039997e-02f, 9.70442072e-02f, 8.39396864e-02f, -3.80471237e-02f, -3.75118591e-02f, 1.16789408e-01f,
  -1.84157804e-01f, -5.88136613e-02f, -3.27662788e-02f, -2.32914746e-01f, -1.37405619e-01f, -2.28049636e-01f, 3.39802206e-02f, -4.73366939e-02f, 7.35883340e-02f, 3.56366009e-01f,
  -2.08448377e-02f, -9.13488492e-02f, 2.40892358e-02f, 7.42259761e-03f, -8.05362239e-02f, 7.20065460e-02f, 7.66592771e-02f, -8.75358060e-02f, -2.35659301e-01f, 1.90391645e-01f,
  3.58995087e-02f, -1.08391583e-01f, -5.13988286e-02f, 6.42556623e-02f, 1.80193651e-02f, -5.38660586e-02f, 1.30903319e-01f, -8.43239278e-02f, -1.40158683e-01f, 6.71176761e-02f,
  2.70504579e-02f, 6.07042052e-02f, -1.18828349e-01f, -1.12341203e-01f, 1.29284114e-01f, -8.59281495e-02f, 6.33812919e-02f, -1.43498257e-01f, 3.29280980e-02f, 9.85058174e-02f,
  -1.36509044e-02f, -1.65949613e-02f, 1.70497820e-02f, 5.71256019e-02f, -3.58305424e-02f, 1.21484548e-01f, -7.77590647e-02f, 2.04984903e-01f, 1.26916036e-01f, 1.58268377e-01f,
  2.47153640e-01f, -1.71140909e-01f, 6.90222904e-02f, 4.63231057e-02f, -1.50064453e-01f, 6.38737183e-05f, 5.87823428e-03f, -5.56813292e-02f, -2.07976792e-02f, 1.44293290e-02f,
  1.37271106e-01f, 2.67312061e-02f, -5.89633733e-02f, -1.54851615e-01f, -1.48889795e-01f, 7.01547489e-02f, 2.14487568e-01f, -6.98992461e-02f, 7.14948326e-02f, -5.86665832e-02f,
  -2.13404819e-02f, -1.53729349e-01f, 5.37941270e-02f, 1.35330424e-01f, -1.24698073e-01f, 1.68758612e-02f, -3.81855778e-02f, -1.47154003e-01f, -6.00380823e-02f, 1.99401006e-01f,
  2.05173448e-01f, 1.42961308e-01f, 3.97585370e-02f, 1.76905185e-01f, -1.28114820e-01f, -4.56125662e-02f, 5.83155379e-02f, 3.65202576e-02f, 7.29645938e-02f, 5.53734042e-02f,
  5.63737378e-02f, 1.15438327e-01f, -9.74973217e-02f, -2.42775166e-03f, 1.07115202e-01f, 1.06305316e-01f, -8.07994902e-02f, -6.32507056e-02f, 4.77874056e-02f, -2.34249294e-01f,
  -1.16895780e-01f, 3.01728733e-02f, 1.45150900e-01f, 1.15322620e-02f, -1.30520105e-01f, 7.81323686e-02f, 2.22042277e-01f, 1.06890246e-01f, 1.20994011e-02f, -4.67846319e-02f,
  1.93330437e-01f, 1.81042939e-01f, 1.23346761e-01f, 6.97961077e-03f, -2.86441837e-02f, 1.17466271e-01f, -4.84182909e-02f, 1.64829075e-01f, 5.70654944e-02f, 9.15813744e-02f,
  -1.59585401e-01f, 3.31639349e-02f, -6.47335798e-02f, 9.73198190e-02f, -3.02938491e-01f, -1.25293642e-01f, 1.56139150e-01f, -1.40942648e-01f, 2.58089036e-01f, 3.18213701e-01f,
  5.21323904e-02f, 2.64616221e-01f, -2.72408519e-02f, -1.85552925e-01f, -2.10909303e-02f, 8.00827146e-02f, -7.53552094e-02f, 5.03213927e-02f, -8.05720016e-02f, 6.56267675e-03f,
  5.63796312e-02f, 7.87495226e-02f, 7.00749159e-02f, -3.19618545e-02f, -3.14487994e-01f, 1.91743881e-01f, -1.17348626e-01f, 2.88848765e-02f, 1.33451134e-01f, 1.67616799e-01f,
  -1.64431363e-01f, 5.91571815e-03f, 2.02691965e-02f, -1.90121740e-01f, -6.08972237e-02f, -1.23659104e-01f, -7.19597116e-02f, -6.71726614e-02f, -2.24911161e-02f, -2.02531070e-01f,
  7.43983611e-02f, 1.37169054e-02f, -6.92285970e-02f, 6.33174330e-02f, -9.45006907e-02f, -1.11012131e-01f, -1.08433843e-01f, -4.44650464e-02f, 7.32903332e-02f, -1.46866545e-01f,
  2.55788434e-02f, -1.52443096e-01f, -1.45077044e-02f, 2.20649294e-03f, -2.07789525e-01f, 1.09395824e-01f, 1.71333954e-01f, 1.15258740e-02f, 1.95909157e-01f, -8.24918821e-02f,
  1.27575859e-01f, -1.87012441e-02f, -1.87989920e-01f, -2.28272527e-01f, -3.64742391e-02f, 1.52580906e-02f, 1.05186187e-01f, -5.39483316e-02f, 2.81279892e-01f, 1.58870861e-01f,
  -1.38701215e-01f, 1.34334415e-01f, -8.03109482e-02f, -3.04441303e-01f, 1.73359096e-01f, -6.93413988e-02f, 1.17974982e-01f, 1.71196163e-01f, -8.07288960e-02f, -7.69857019e-02f,
  8.15337151e-02f, -7.76723996e-02f, -2.51189694e-02f, -3.83063853e-02f, 8.35155025e-02f, -1.27214953e-04f, -6.42691404e-02f, 1.80233642e-01f, 1.34923011e-01f, -1.11954957e-01f,
  1.40093550e-01f, -1.08285725e-01f, 1.46881649e-02f, -1.48542831e-02f, 3.26988250e-02f, 9.71971229e-02f, 5.97028956e-02f, -4.79705743e-02f, -1.31002352e-01f, -1.34931237e-01f,
  -1.85294487e-02f, 1.06738567e-01f, -6.36369064e-02f, -2.13556111e-01f, -7.71404896e-03f, -5.87563403e-02f, -5.44751547e-02f, -4.18695211e-02f, -4.84567620e-02f, -1.71287924e-01f,
  -1.14762411e-01f, -5.23587167e-02f, -1.62949979e-01f, -1.52257793e-02f, -2.10289702e-01f, -2.28553280e-01f, 3.20771709e-02f, -1.08015560e-01f, -1.04532965e-01f, 4.44264524e-02f,
  2.58491278e-01f, 1.60862096e-02f, 8.72382373e-02f, 7.85482749e-02f, 2.13566661e-01f, -9.92575884e-02f, -2.94175804e-01f, 6.40252680e-02f, 1.34602368e-01f, 3.48395228e-01f,
  -2.78438836e-01f, -7.54027218e-02f, 7.88727924e-02f, -9.05086473e-02f, -1.21830165e-01f, -1.15615554e-01f, 8.01050812e-02f, 3.63598913e-02f, -1.13906771e-01f, -9.77489054e-02f,
  1.44483566e-01f, 3.52211952e-01f, 1.91935167e-01f, 1.71966642e-01f, -4.10310216e-02f, -3.44986767e-01f, 1.02150120e-01f, -2.11308580e-02f, -2.71125063e-02f, -7.25443736e-02f,
  -3.31374928e-02f, -2.88418513e-02f, 2.46366225e-02f, 1.52050421e-01f, 1.98377341e-01f, -6.60611270e-03f, 6.25226200e-02f, -9.71547961e-02f, -8.75048265e-02f, 1.31260633e-01f,
  1.11131266e-01f, 9.04192552e-02f, -1.32568717e-01f, -8.95792320e-02f, -4.94483262e-02f, -1.40049364e-02f, -4.56346795e-02f, -2.87920907e-02f, 8.04388300e-02f, -4.58898544e-02f,
  -4.08289991e-02f, -1.76495761e-01f, 1.00619771e-01f, 1.79170445e-02f, 1.51475936e-01f, 1.03044212e-01f, -1.50061119e-02f, 4.69338410e-02f, 1.46797761e-01f, -1.18907861e-01f,
  -5.76898679e-02f, -3.96069661e-02f, 3.88473198e-02f, 1.13886841e-01f, 1.32628307e-01f, -9.22063813e-02f, -1.08989745e-01f, 2.06380367e-01f, 9.21972767e-02f, 1.83625653e-01f,
  1.59670599e-02f, 1.99662685e-01f, -1.29821509e-01f, 8.41660798e-02f, -2.08540767e-01f, 2.02949256e-01f, -2.02464178e-01f, 6.02931390e-03f, 1.14395499e-01f, -2.46451035e-01f,
  2.61678457e-01f, 3.39431167e-01f, -1.46145985e-01f, 2.68089503e-01f, -1.13475770e-01f, 2.05333065e-02f, -9.97846872e-02f, 9.57355723e-02f, -2.46408172e-02f, -2.95931380e-02f,
  1.53209150e-01f, -4.33405191e-02f, -7.45141506e-02f, -6.77932873e-02f, 1.12982832e-01f, -1.87488794e-01f, -3.26881349e-01f, 2.56772131e-01f, -2.19428003e-01f, -3.68848955e-03f,
  5.73508106e-02f, 2.94202156e-02f, -1.12105906e-02f, -1.50055736e-01f, 4.46034372e-02f, -6.75938353e-02f, -5.90740815e-02f, 1.14877969e-01f, -6.89790770e-02f, 5.90978935e-02f,
  7.50740543e-02f, 9.15196911e-02f, -1.00982845e-01f, 1.06308304e-01f, 1.27382576e-01f, 1.77293807e-01f, -5.07149696e-02f, 2.75474191e-01f, -6.78694695e-02f, -4.50166650e-02f,
  8.45884308e-02f, 2.03749433e-01f, -1.14286728e-02f, 5.47988601e-02f, 2.81374864e-02f, 2.27372557e-01f, 2.07229823e-01f, 2.32898936e-01f, -1.70485348e-01f, 7.50354454e-02f,
  2.71029398e-02f, 1.63835958e-01f, -1.15285978e-01f, -5.88369090e-04f, -3.56715657e-02f, 3.06247417e-02f, -2.14749247e-01f, -1.68722272e-01f, 1.86112642e-01f, 8.45792610e-03f,
  6.06380543e-03f, 1.19366154e-01f, -1.43288717e-01f, -1.05342053e-01f, 4.23962697e-02f, -1.32072732e-01f, 2.77639270e-01f, -5.69085963e-02f, -1.92549884e-01f, -1.90463871e-01f,
  -1.53724909e-01f, -1.30808771e-01f, -7.29020387e-02f, 2.62983620e-01f, 2.32511647e-02f, -4.43889275e-02f, -1.01222791e-01f, 1.88408867e-02f, -1.18716814e-01f, -1.20188091e-02f,
  1.45774156e-01f, -1.06334388e-01f, -1.29441679e-01f, -1.52604103e-01f, -7.01290295e-02f, 9.24137160e-02f, 9.38677490e-02f, 1.52524695e-01f, 1.09374098e-01f, -7.25927278e-02f,
  -1.61333129e-01f, 1.44846737e-01f, 4.41325791e-02f, 1.94432288e-02f, -5.00568449e-02f, 7.03477785e-02f, -7.76631609e-02f, 3.96848135e-02f, -5.94105609e-02f, -1.82866603e-01f,
  -1.06801905e-01f, 1.45550132e-01f, 1.37505576e-01f, -6.19576685e-02f, 7.15452507e-02f, -1.02714092e-01f, -4.72746156e-02f, -9.09370035e-02f, -1.46420389e-01f, 4.08563241e-02f,
  1.38240159e-01f, 7.17092259e-03f, 2.10062861e-01f, -8.61567166e-03f, -1.57287598e-01f, 4.70313691e-02f, 4.39673923e-02f, 8.86308849e-02f, -1.54756695e-01f, -1.79378837e-02f,
  1.35892719e-01f, 2.64065027e-01f, -1.45759866e-01f, 1.96168888e-02f, -1.25725061e-01f, -1.67504653e-01f, 1.00505911e-01f, 2.62140594e-02f, 2.19479397e-01f, 2.10033774e-01f,
  1.18819885e-02f, -5.90646546e-03f, -7.66251460e-02f, -1.42754633e-02f, 1.13803752e-01f, -3.94455716e-03f, 1.26547944e-02f, -7.14887008e-02f, 5.24111502e-02f, 4.55385149e-02f,
  -9.76907387e-02f, -5.70625067e-03f, -1.53147712e-01f, -1.27225975e-02f, -1.14210904e-01f, 2.11279020e-01f, -8.18342119e-02f, -1.18928645e-02f, 3.96504849e-02f, -8.84441659e-02f,
  -5.86847290e-02f, 7.79516920e-02f, -1.15825064e-01f, -5.24970070e-02f, -1.34294242e-01f, -5.30071408e-02f, -1.74609736e-01f, 1.03139825e-01f, 2.88235173e-02f, 7.19252825e-02f,
  -1.13725983e-01f, -1.13233276e-01f, -9.85244289e-02f, -1.83564216e-01f, 3.08512133e-02f, -2.41112560e-02f, -7.78810009e-02f, 4.99213785e-02f, -1.65841773e-01f, -1.73008293e-02f,
  1.38075411e-01f, -9.06453058e-02f, 6.59550875e-02f, -1.09259263e-01f, 7.90705085e-02f, -8.49467814e-02f, 1.21052429e-01f, 1.30166858e-01f, 2.61493726e-03f, 1.37511134e-01f,
  2.66813576e-01f, 2.81711698e-01f, -2.38198638e-02f, 8.55615437e-02f, 4.32511903e-02f, 2.32878968e-01f, -1.44311845e-01f, -9.30860862e-02f, -1.70039088e-01f, 8.76412988e-02f,
  -2.60506794e-02f, -1.81655049e-01f, 2.70335078e-01f, 5.64419329e-02f, -3.37203518e-02f, 8.72717872e-02f, 1.59128666e-01f, 1.85763966e-02f, -5.44460714e-02f, 7.82562420e-02f,
  -3.48884687e-02f, -3.17555696e-01f, 1.32000297e-01f, -3.70825417e-02f, -3.33285481e-02f, 1.27340913e-01f, 5.13387658e-02f, -1.25613526e-01f, -2.74610817e-01f, 1.94558620e-01f,
  8.16156119e-02f, 1.11409016e-01f, 8.44576210e-02f, -6.75375387e-02f, -7.66170770e-02f, 2.09827825e-01f, 3.30880024e-02f, 3.55175324e-02f, 1.43883094e-01f, 4.35309410e-02f,
  -3.57605191e-03f, 1.38688385e-01f, -8.98267627e-02f, 3.23066190e-02f, -4.56604436e-02f, -1.69162497e-01f, 4.19104435e-02f, 2.52013770e-03f, 8.43590125e-02f, -1.04847275e-01f,
  5.26157990e-02f, -6.30585849e-02f, -6.23001307e-02f, 5.08439988e-02f, 5.26149990e-03f, -9.85360295e-02f, -8.42844844e-02f, -1.37434959e-01f, -8.58178809e-02f, -9.31575447e-02f,
  3.20306033e-01f, 7.18362555e-02f, 1.57586709e-01f, 6.02530874e-02f, 1.44096380e-02f, 3.86476815e-02f, -9.65012610e-02f, -2.15435758e-01f, -1.42230198e-01f, 1.02031238e-01f,
  -1.51186898e-01f, 2.62469590e-01f, -8.77804682e-02f, -7.07442611e-02f, -1.42830074e-01f, 4.15888652e-02f, -5.98467514e-02f, 1.33259863e-01f, 2.47008656e-03f, -1.76472496e-02f,
  -9.19377282e-02f, -4.28595543e-02f, -1.46953434e-01f, 3.83712873e-02f, -1.20603330e-01f, -7.63875023e-02f, 1.24523453e-01f, 9.60048810e-02f, 8.82667154e-02f, 5.52799553e-02f,
  -4.27663438e-02f, 9.64570865e-02f, -2.42955998e-01f, 1.62442282e-01f, 3.10585033e-02f, 2.83248067e-01f, 2.26039928e-03f, 1.10586934e-01f, 9.67740193e-02f, -1.28472328e-01f,
  -1.34700360e-02f, -1.81361005e-01f, 5.91374673e-02f, -3.47567573e-02f, -2.14264933e-02f, -4.04321477e-02f, -4.61766459e-02f, -1.91233963e-01f, 2.64768712e-02f, -1.26435757e-01f,
  -2.53371418e-01f, 1.73018485e-01f, -2.54443381e-02f, -4.94697876e-02f, 9.33025703e-02f, 9.40498197e-04f, -1.58017762e-02f, -1.90586790e-01f, -1.42213106e-01f, 2.12468673e-02f,
  1.33043259e-01f, -1.78517159e-02f, -2.15884373e-01f, 9.89510864e-02f, -4.98022176e-02f, 3.50755937e-02f, -3.31283621e-02f, -7.27533251e-02f, 1.44147366e-01f, -5.54946326e-02f,
  8.56731646e-03f, -2.18747541e-01f, 1.51990190e-01f, 6.24860004e-02f, 5.49128205e-02f, -2.26330623e-01f, 2.40901262e-01f, -4.71412279e-02f, 1.42383397e-01f, 8.91003571e-03f,
  -2.08324194e-01f, -1.55737698e-01f, -8.52151737e-02f, -1.13510251e-01f, 1.97084442e-01f, 2.95101523e-01f, 2.50013411e-01f, -6.77613467e-02f, 1.25742123e-01f, 7.59192631e-02f,
  1.24672309e-01f, 6.35902956e-02f, -1.59268230e-02f, 9.28830057e-02f, -1.26509577e-01f, 1.94864199e-01f, 9.17500257e-02f, -5.27045690e-02f, 9.18734539e-03f, -2.23512769e-01f,
  1.44765958e-01f, -1.07022054e-01f, 1.38592854e-01f, -9.05485898e-02f, 1.43423704e-02f, 4.89648841e-02f, 1.22319432e-02f, -1.22907097e-02f, 1.46299690e-01f, -8.44070502e-03f,
  -6.25565574e-02f, 1.27290815e-01f, -9.62952226e-02f, 4.01328318e-03f, 1.30493566e-01f, 4.94240969e-03f, -1.17125167e-02f, 1.97494030e-01f, 1.30133390e-01f, 2.53659226e-02f,
  6.39810562e-02f, 5.21947909e-03f, 1.18822686e-01f, 1.37064874e-01f, -7.35082477e-02f, -2.30103941e-03f, 2.04003423e-01f, -1.01717226e-01f, -2.63047248e-01f, -7.77505338e-02f,
  -1.51496664e-01f, 6.49523288e-02f, -2.57937163e-01f, -1.52351214e-02f, 1.47078156e-01f, -3.10165975e-02f, 1.87391397e-02f, 2.13371888e-02f, 7.16389790e-02f, -5.46286814e-02f,
  -1.34308532e-01f, 8.09796751e-02f, -2.80414466e-02f, 1.75585672e-01f, 6.23763055e-02f, -7.43539305e-04f, -5.94478287e-02f, -5.89061864e-02f, -1.99188307e-01f, -1.69635683e-01f,
  1.07107967e-01f, 1.82819709e-01f, 1.75602660e-02f, 1.43182784e-01f, -3.72211635e-03f, -8.02053437e-02f, -1.11307584e-01f, 4.49811369e-02f, -7.98862875e-02f, 3.96546762e-04f,
  -1.02436416e-01f, -2.11638048e-01f, -1.13346264e-01f, -1.85813606e-01f, -7.41184428e-02f, 1.26886785e-01f, -4.04488817e-02f, 7.54813179e-02f, -9.26246345e-02f, -9.60744265e-03f,
  1.47633895e-01f, -6.41319752e-02f, -9.05744061e-02f, -6.09511659e-02f, 2.31348015e-02f, -6.35964200e-02f, 1.32323474e-01f, 1.64105400e-01f, 3.72309685e-02f, 2.12446883e-01f,
  -1.67734958e-02f, 4.06352337e-03f, -8.00358504e-02f, -1.00849412e-01f, 1.25879779e-01f, 1.08698308e-01f, 6.33770153e-02f, 3.99028584e-02f, -2.25429963e-02f, 1.01664625e-01f,
  -1.15557678e-01f, -1.19604304e-01f, -1.94482177e-01f, -8.58470798e-02f, -1.52463298e-02f, -5.60625531e-02f, -1.34977922e-01f, -8.22740868e-02f, 2.07489774e-01f, -1.99051932e-01f,
  -1.92514807e-01f, -1.91780198e-02f, 1.63862079e-01f, 9.20691267e-02f, 2.15275437e-01f, 6.69400468e-02f, -1.56183094e-01f, 2.21926019e-01f, -1.81837708e-01f, -2.04275936e-01f,
  -8.05331618e-02f, -1.26393782e-02f, 2.19256543e-02f, 1.06344052e-01f, -1.27369687e-01f, 3.29022342e-03f, 5.21598421e-02f, -4.92365845e-02f, -1.05995134e-01f, 5.63943908e-02f,
  -1.14299446e-01f, 4.04240750e-02f, -4.47373129e-02f, 1.04874074e-01f, 1.02355368e-01f, -1.93487063e-01f, 1.60117805e-01f, -7.62796700e-02f, -3.45673636e-02f, -3.49745899e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  6.54114559e-02f, 1.67629108e-01f, -1.93233893e-03f, 8.90059844e-02f, 1.86857119e-01f, 3.43078673e-02f, -1.52776390e-02f, 2.52596587e-01f, 1.41967475e-01f, 1.72713771e-02f,
  4.24144119e-02f, -9.11917537e-02f, -4.78755347e-02f, 1.11086160e-01f, 6.13705292e-02f, -1.08524017e-01f, 3.38490605e-02f, -1.35564938e-01f, 6.97611719e-02f, -1.21371552e-01f,
  -9.02760848e-02f, 1.21278785e-01f, -8.24975688e-03f, -6.71386793e-02f, -1.66139364e-01f, 2.68964082e-01f, 2.58639693e-01f, 2.05623135e-02f, 1.10979520e-01f, -1.79462701e-01f,
  -2.83718831e-03f, -8.41231942e-02f, 5.33230826e-02f, -2.28985026e-01f, -3.08748901e-01f, 4.56818491e-02f, 2.79005095e-02f, 1.24558091e-01f, 8.67036283e-02f, -1.69313729e-01f,
  -2.00896233e-01f, -8.59028548e-02f, -1.97054863e-01f, -1.54276853e-02f, 1.32778719e-01f, -2.32646987e-02f, 8.91631693e-02f, -9.73256156e-02f, -1.30022645e-01f, -2.14334518e-01f,
  7.19405040e-02f, 3.26588720e-01f, 9.09509957e-02f, -3.25704888e-02f, 1.11926891e-01f, -5.26204966e-02f, -2.13483125e-02f, -3.28422934e-02f, 5.65593839e-02f, 1.19373433e-01f,
  -1.14740558e-01f, 2.30879739e-01f, 3.85389999e-02f, 9.08925906e-02f, -5.44309504e-02f, -1.28609598e-01f, -1.57951899e-02f, -7.01600537e-02f, 1.25204682e-01f, 3.58712114e-02f,
  -1.33052304e-01f, 1.03982575e-01f, 4.92084131e-04f, 1.16706409e-01f, 8.48924592e-02f, 7.30810091e-02f, 4.91740229e-03f, 4.53279056e-02f, -7.83803686e-02f, -3.48317400e-02f,
  -6.34215251e-02f, -1.28249183e-01f, -7.00195730e-02f, -1.31680325e-01f, -1.48221150e-01f, 3.42896059e-02f, -1.29096134e-05f, -3.97060961e-02f, -1.31399587e-01f, -1.12886965e-01f,
  1.33496448e-02f, 8.38487968e-02f, -5.86260334e-02f, 9.68254060e-02f, -4.47265012e-03f, 6.47705272e-02f, 3.45176598e-03f, 9.29410458e-02f, -9.77895036e-02f, -9.04904157e-02f,
  9.52372029e-02f, 1.11166663e-01f, -6.40154481e-02f, -7.59454817e-02f, -7.35776126e-02f, -3.14414427e-02f, 1.06116958e-01f, -1.03109553e-01f, -9.94248614e-02f, -3.63228507e-02f,
  5.22842035e-02f, 7.84413740e-02f, 8.00672397e-02f, -7.46787786e-02f, 4.28080037e-02f, 6.09574988e-02f, -4.92362007e-02f, 3.00388243e-02f, -2.65099034e-02f, 7.69168586e-02f,
  7.86836669e-02f, -7.05177858e-02f, 6.06738999e-02f, -3.44138108e-02f, 1.29932001e-01f, 1.31662846e-01f, 1.08065858e-01f, 9.97120366e-02f, 1.49686515e-01f, -5.26045226e-02f,
  1.21898673e-01f, 1.17802285e-01f, 3.46175842e-02f, -5.03516607e-02f, -5.60390987e-02f, 8.45952705e-02f, 1.30846307e-01f, -9.19149220e-02f, 1.52500242e-01f, 1.64503768e-01f,
  -8.94756541e-02f, 1.69416100e-01f, 5.22211045e-02f, 7.22941086e-02f, -8.32873583e-02f, 1.24498136e-01f, 9.68925580e-02f, -8.43083337e-02f, -9.95870084e-02f, 6.24465160e-02f,
  -4.91374396e-02f, -1.13714352e-01f, 5.98011054e-02f, -1.42538726e-01f, -1.10933214e-01f, 1.22832417e-01f, 2.22073011e-02f, 5.25827035e-02f, 3.09871491e-02f, -1.78101342e-02f,
  1.59798756e-01f, 1.91554204e-02f, 1.95809767e-01f, -1.11540817e-01f, -7.04355761e-02f, -1.83052316e-01f, 7.86903128e-02f, 2.59067453e-02f, 9.20274705e-02f, -1.73268486e-02f,
  -4.91894968e-02f, -2.74357088e-02f, -1.17378920e-01f, -1.59198269e-01f, 6.90126643e-02f, 1.85445338e-01f, 1.56266198e-01f, 1.92949269e-02f, 1.22268461e-02f, -1.05722272e-03f,
  -5.56744039e-02f, 1.02918074e-01f, -1.08812831e-01f, 1.05132103e-01f, 1.06701650e-01f, 1.53964192e-01f, 2.50204265e-01f, -2.18910083e-01f, -2.71668453e-02f, 7.77749717e-02f,
  -6.21426702e-02f, -1.52601838e-01f, -7.89248943e-02f, 5.57029480e-03f, -4.57696989e-02f, 5.21750636e-02f, -4.90466021e-02f, 1.07625782e-01f, 7.10211545e-02f, -9.91480425e-02f,
  -2.10573450e-02f, -1.20898023e-01f, -9.10299495e-02f, -2.04098653e-02f, -5.92430495e-03f, 9.32805538e-02f, 1.17224529e-01f, -5.03405705e-02f, -1.18003003e-01f, 5.02483994e-02f,
  3.03179212e-02f, -1.18909247e-01f, -5.90685233e-02f, -8.17665011e-02f, -1.25616610e-01f, 6.79473355e-02f, 9.49922651e-02f, 9.53507274e-02f, -3.08120809e-02f, -5.73808746e-03f,
  9.05639231e-02f, -1.11390658e-01f, -1.04398228e-01f, -7.49455541e-02f, -3.65759395e-02f, -6.24834411e-02f, -7.00179487e-02f, 2.19723955e-02f, -1.19020909e-01f, -5.28730303e-02f,
  1.23571344e-01f, 8.64533931e-02f, 1.05759203e-01f, -1.11080669e-01f, 3.06313727e-02f, 4.92670797e-02f, -5.60950954e-03f, 7.45040551e-02f, -5.72299547e-02f, 7.09734783e-02f,
  -3.67280245e-02f, 1.23755239e-01f, -1.18816588e-02f, -8.08677375e-02f, -4.33558859e-02f, 1.02254048e-01f, -1.68403331e-02f, -2.61667687e-02f, 4.13327329e-02f, 5.60743697e-02f,
  -8.52762386e-02f, -3.98945101e-02f, -7.47648403e-02f, -4.75253463e-02f, 3.89966331e-02f, 5.19382954e-02f, 5.75666539e-02f, -1.29020855e-01f, 1.23790689e-01f, 1.71882525e-01f,
  4.03738357e-02f, 1.13647655e-02f, 1.67198360e-01f, -1.33482605e-01f, 7.12032542e-02f, -4.43904623e-02f, 2.95716897e-02f, 1.17774524e-01f, -6.75935373e-02f, 1.02468856e-01f,
  1.51393458e-01f, 1.80319995e-01f, 1.09112233e-01f, -6.77133501e-02f, 1.42534018e-01f, 1.59938246e-01f, -1.50850136e-02f, 1.71314567e-01f, 1.90166160e-01f, 1.63841158e-01f,
  1.75119579e-01f, -2.02916376e-02f, -3.29885393e-01f, 1.60362974e-01f, -2.58637071e-01f, 7.26759955e-02f, -1.00491062e-01f, 1.21420912e-01f, 2.38428742e-01f, 1.87237039e-01f,
  9.77865234e-02f, 4.01771888e-02f, -4.22606431e-02f, -2.96865642e-01f, -1.41426310e-01f, 1.09156661e-01f, 6.90875426e-02f, 1.67456642e-01f, 8.10641870e-02f, -2.24514380e-01f,
  -9.79485363e-02f, -4.87255454e-02f, -7.09404200e-02f, -1.64701879e-01f, 8.79379213e-02f, 3.21960300e-02f, 3.84600684e-02f, -9.60578993e-02f, -7.99592957e-03f, -7.44951656e-03f,
  8.73127058e-02f, 2.01869532e-01f, -7.54392743e-02f, 9.39224064e-02f, 3.48604992e-02f, 4.57412899e-02f, -4.58575301e-02f, -2.10730717e-01f, 1.32925138e-01f, 1.10102870e-01f,
  1.15007497e-01f, 1.74713820e-01f, 8.90521035e-02f, 1.65436059e-01f, -3.36292908e-02f, 1.74665242e-01f, 3.11036594e-02f, 3.79833058e-02f, 6.04461282e-02f, 8.78581405e-02f,
  -6.37986809e-02f, -4.29671146e-02f, 4.35311198e-02f, -2.72345930e-01f, 1.22213610e-01f, -5.16125374e-02f, 3.43617536e-02f, 1.18940689e-01f, 6.16685674e-02f, 2.32517603e-03f,
  1.78082481e-01f, 1.52484119e-01f, 4.22935337e-02f, -4.85479422e-02f, 1.65650576e-01f, 8.48991200e-02f, 2.01938480e-01f, 2.32066531e-02f, 2.27949005e-02f, 1.40381316e-02f,
  -5.89726120e-03f, 1.74405456e-01f, 4.87691909e-02f, 3.87622863e-02f, 5.38550969e-03f, 2.57468019e-02f, -1.88658163e-01f, -6.48707673e-02f, -2.91931212e-01f, -6.50549680e-02f,
  -1.25411320e-02f, -7.31534436e-02f, 1.25297323e-01f, 3.31925511e-01f, -1.73486918e-01f, 1.33822169e-02f, 6.83668032e-02f, -5.96849732e-02f, 1.72137469e-02f, -5.24494685e-02f,
  -4.41174544e-02f, 8.45272690e-02f, 1.08193450e-01f, -4.55894060e-02f, -7.56402966e-03f, 8.24066550e-02f, 1.02489941e-01f, -1.66129842e-01f, -1.36315376e-01f, 1.96700245e-01f,
  1.45293074e-02f, 2.99159914e-01f, 6.92026094e-02f, 1.24292217e-01f, 1.16638588e-02f, -2.35325620e-02f, -7.94310942e-02f, -1.32804727e-02f, 1.01549560e-02f, -5.21166921e-02f,
  -5.82103804e-02f, -1.48028582e-02f, 6.89221919e-02f, -1.38672628e-02f, 9.96258035e-02f, -2.88447179e-02f, 1.06446944e-01f, 1.02021463e-01f, -2.65552606e-02f, 6.77345395e-02f,
  -9.48336557e-04f, -7.26388721e-03f, 1.10385008e-01f, -6.62604719e-02f, -4.19397615e-02f, 7.50997961e-02f, -1.45839453e-02f, -4.87615019e-02f, 9.96707529e-02f, -1.01057030e-01f,
  6.23957179e-02f, -2.76704188e-02f, -7.07033053e-02f, -7.18848407e-02f, 1.27539560e-01f, 2.06796965e-03f, 4.80650589e-02f, 9.30303335e-02f, -4.53255847e-02f, 1.16574019e-02f,
  -6.72123879e-02f, 1.14312761e-01f, 5.54248579e-02f, 3.03745866e-02f, 9.53942910e-02f, -3.52797061e-02f, -8.81847553e-03f, 7.95057416e-02f, 1.08558439e-01f, -9.58682671e-02f,
  3.19002755e-02f, 8.88794586e-02f, -2.05932166e-02f, 2.73192693e-02f, 1.29554639e-04f, -3.63169564e-03f, -5.35403192e-03f, -2.46530715e-02f, 1.93008482e-02f, 1.58592891e-02f,
  -4.84887175e-02f, -9.30730999e-02f, 1.50326416e-01f, -6.08121604e-02f, -2.87813116e-02f, 2.64923163e-02f, -1.03386141e-01f, -8.35402980e-02f, 2.11755503e-02f, 3.80249657e-02f,
  9.21180025e-02f, -1.83514934e-02f, 3.94456498e-02f, 3.10972501e-02f, 5.66608086e-02f, -6.67772740e-02f, -5.24856709e-02f, -9.16660726e-02f, -2.87819952e-02f, -2.65263021e-02f,
  -2.61923112e-02f, 1.04808882e-01f, -1.42067736e-02f, 4.73630317e-02f, 8.88306797e-02f, -1.82366688e-02f, -1.74632072e-02f, -9.51408744e-02f, -6.33669645e-02f, -1.20710678e-01f,
  -9.99355093e-02f, -6.98129386e-02f, -1.13937721e-01f, -1.09333239e-01f, 2.59603951e-02f, 4.80723009e-02f, 1.05672918e-01f, -1.14577368e-01f, -1.14267521e-01f, -6.02029487e-02f,
  -1.96706615e-02f, -4.01300602e-02f, -5.54332836e-03f, 1.23986945e-01f, 2.53486522e-02f, 2.46487116e-03f, -7.27521181e-02f, 7.31399357e-02f, -6.34059906e-02f, 5.68916043e-03f,
  -3.62625569e-02f, -2.69956458e-02f, -6.38512745e-02f, 9.12825614e-02f, 7.00784773e-02f, 7.22065791e-02f, -1.12998724e-01f, -5.13036400e-02f, -7.53773451e-02f, -7.24566802e-02f,
  2.74369102e-02f, -2.10528988e-02f, 2.34249253e-02f, -7.95235578e-03f, -6.10253699e-02f, 4.67261635e-02f, -1.10577166e-01f, 1.03254117e-01f, -5.80058321e-02f, -1.57898329e-02f,
  -4.72283587e-02f, 3.85876894e-02f, -8.05339143e-02f, -2.27651875e-02f, -8.72185230e-02f, 7.30183944e-02f, 1.18389875e-01f, -8.95342007e-02f, -1.01353846e-01f, 8.43866095e-02f,
  -3.19665819e-02f, -1.25062212e-01f, 1.18872933e-01f, -5.63676283e-02f, -1.49349779e-01f, 8.52899328e-02f, -4.17209715e-02f, 1.01623781e-01f, -7.31434077e-02f, 1.12591386e-01f,
  7.82783031e-02f, 1.23833485e-01f, 1.10540845e-01f, -2.31098011e-02f, 7.90601596e-02f, -2.24035624e-02f, 4.69395630e-02f, 8.78868327e-02f, 1.41771168e-01f, -1.46334082e-01f,
  -1.20682083e-01f, 7.23703057e-02f, 6.20645992e-02f, 1.12170309e-01f, 7.28688063e-03f, 3.91716808e-02f, -1.56639978e-01f, -7.70917386e-02f, 4.31329310e-02f, 4.84702550e-03f,
  -8.62771496e-02f, 7.95830563e-02f, -9.57420692e-02f, 5.83038814e-02f, -3.15088667e-02f, 9.94612426e-02f, -3.70216556e-02f, 1.30029500e-01f, 1.92435589e-02f, 2.48260982e-02f,
  -9.29722339e-02f, -1.42897712e-02f, -6.32615387e-02f, 5.52819632e-02f, -1.18924432e-01f, 8.55165124e-02f, -6.28471002e-02f, 3.01916730e-02f, 1.55839860e-01f, -6.33998215e-02f,
  -8.78954157e-02f, 1.64234579e-01f, -4.05992977e-02f, 1.96394920e-01f, 9.21921432e-02f, 1.23849414e-01f, 1.13392636e-01f, -1.12294164e-02f, -1.14924908e-01f, -3.45706753e-02f,
  -8.93032402e-02f, 7.28759766e-02f, -4.90693226e-02f, 1.28484517e-01f, 1.79765280e-02f, -4.56699952e-02f, -1.09671131e-02f, -1.37507319e-02f, 9.72465426e-02f, -6.40563592e-02f,
  8.81298482e-02f, 3.84018235e-02f, 6.78759813e-03f, 1.68503299e-01f, -1.23000937e-02f, 3.78348939e-02f, 1.24134779e-01f, -1.15062773e-01f, -9.37138200e-02f, 4.19469997e-02f,
  9.57762748e-02f, -1.87361002e-01f, -9.53413993e-02f, 9.20578092e-02f, -2.13234369e-02f, 9.33448412e-03f, -1.10868610e-01f, 2.31662001e-02f, 7.65251294e-02f, 1.25199199e-01f,
  -7.98721537e-02f, -7.14709610e-02f, -1.44935176e-01f, 5.16901426e-02f, 6.01027310e-02f, -7.31978193e-02f, -1.78034324e-02f, 5.60193919e-02f, 1.01859435e-01f, -1.34520782e-02f,
  6.47716746e-02f, 9.34150419e-04f, 3.20860334e-02f, 1.14746809e-01f, -7.18680248e-02f, -4.00098301e-02f, 5.23371883e-02f, 2.33569928e-02f, 1.17371313e-01f, -5.30087277e-02f,
  -1.00641057e-01f, -1.34047329e-01f, 3.12930234e-02f, -9.99079198e-02f, 1.47259068e-02f, -4.15218361e-02f, -5.93084283e-02f, 1.97754353e-02f, 2.60428619e-03f, -1.22497961e-01f,
  -3.80880348e-02f, 1.75945625e-01f, -5.11490069e-02f, -9.88270994e-03f, 1.25639588e-01f, 1.30168676e-01f, 5.03028976e-03f, 5.11653349e-02f, -6.83138371e-02f, -2.28587650e-02f,
  -6.32285401e-02f, 1.12846613e-01f, -4.38477993e-02f, -1.37155250e-01f, -1.23424036e-02f, 5.10778977e-03f, -7.40400031e-02f, 6.81948895e-03f, -2.49642180e-03f, -3.47585231e-02f,
  1.44712850e-01f, 1.65948957e-01f, 1.04311086e-01f, -2.48144343e-02f, 3.09834033e-02f, -1.62848786e-01f, -1.18902192e-01f, 1.37670850e-02f, 8.22000671e-03f, 1.32825986e-01f,
  -1.29976422e-01f, -1.41225532e-01f, 1.14024520e-01f, -9.38862935e-02f, -5.08439145e-04f, 1.76566169e-01f, -1.56223670e-01f, -1.79361239e-01f, -9.35787782e-02f, -1.55756205e-01f,
  -1.49810258e-02f, 5.00680804e-02f, -9.57186371e-02f, 1.41516596e-01f, -4.61219810e-02f, 9.13567469e-02f, -7.41663203e-02f, -5.98867908e-02f, -6.32565171e-02f, 1.77968636e-01f,
  -7.40718991e-02f, -1.12433821e-01f, -7.32660070e-02f, -3.65870222e-02f, -1.21797226e-01f, -1.46395728e-01f, 5.52288294e-02f, -5.96981905e-02f, 1.62444174e-01f, 7.16081113e-02f,
  -3.54541279e-02f, 1.50844250e-02f, 6.93968162e-02f, -4.19999398e-02f, 6.38870671e-02f, 9.12404433e-03f, 8.10353458e-02f, 9.53146219e-02f, -1.20377488e-01f, -7.56700113e-02f,
  8.85114297e-02f, -6.91205487e-02f, 5.00218943e-02f, -5.96864559e-02f, 7.89641738e-02f, -2.07081847e-02f, -6.48889616e-02f, -1.82167038e-01f, 6.63709119e-02f, 5.43025136e-02f,
  5.30560613e-02f, 5.28636537e-02f, -1.53860837e-01f, -7.04096407e-02f, 1.30749896e-01f, -4.45268266e-02f, -4.41849940e-02f, -5.74340522e-02f, 4.71129678e-02f, -5.18123806e-02f,
  5.84160946e-02f, 5.41551411e-02f, 1.01394564e-01f, 6.10449398e-03f, 2.05239039e-02f, 2.57321764e-02f, -2.20652409e-02f, -5.60691990e-02f, -8.45801607e-02f, 1.93904087e-01f,
  -6.57137018e-03f, -4.44788449e-02f, -6.51284819e-03f, -6.72512054e-02f, 5.12099601e-02f, -1.32795706e-01f, -7.10839257e-02f, 8.08455572e-02f, -9.92957875e-02f, -9.38520506e-02f,
  1.54204909e-02f, 1.34836137e-01f, 6.60496503e-02f, 1.28511339e-01f, 1.15370125e-01f, -6.46869689e-02f, -5.18882349e-02f, -1.19754165e-01f, 1.22067600e-01f, -3.70104201e-02f,
  1.40173182e-01f, -1.38287265e-02f, -1.02957092e-01f, 1.16787612e-01f, 9.12880003e-02f, 8.12789574e-02f, 1.95568390e-02f, -1.04851648e-01f, -1.32460808e-02f, 2.02022612e-01f,
  8.21505487e-02f, 5.94575405e-02f, 8.89823809e-02f, -1.34308025e-01f, 5.59364744e-02f, 1.51865959e-01f, 2.31617972e-01f, 1.73538566e-01f, 1.28769800e-01f, 1.84906140e-01f,
  1.51528969e-01f, 3.96075062e-02f, 1.50566310e-01f, 2.48577148e-02f, 2.39752326e-02f, -2.19994644e-03f, 1.30333588e-01f, 8.63722339e-03f, 1.30146831e-01f, 1.11574806e-01f,
  -2.64415052e-02f, 2.20796794e-01f, 5.05613498e-02f, -4.32879329e-02f, -1.35131672e-01f, -2.66093574e-03f, 1.31716594e-01f, 1.56526297e-01f, -3.39043140e-01f, 1.46417534e-02f,
  1.79475069e-01f, -4.78602126e-02f, -2.71044075e-01f, -2.68395156e-01f, 2.54224360e-01f, 4.82142940e-02f, -5.65354265e-02f, 1.22640550e-01f, -1.32066876e-01f, -2.39966530e-02f,
  -1.60672292e-01f, -1.45106971e-01f, 5.23408093e-02f, -2.14638829e-01f, -1.97357446e-01f, -1.79234907e-01f, -2.43660256e-01f, -1.06605627e-02f, 6.61256611e-02f, 2.59256035e-01f,
  -1.35760486e-01f, -3.82019505e-02f, -1.02888323e-01f, -1.56281754e-01f, 9.27323028e-02f, -3.70623954e-02f, 2.04531252e-01f, -7.41697550e-02f, -1.02756560e-01f, 2.41319045e-01f,
  -9.43320990e-02f, 1.10190623e-01f, 2.90807243e-02f, 2.56339312e-01f, 9.03316885e-02f, -1.00097947e-01f, 9.95691493e-02f, 2.07962096e-01f, 1.48805588e-01f, 2.37471610e-01f,
  1.15827359e-01f, -1.21066794e-01f, 1.41827583e-01f, -5.81634529e-02f, 1.00806430e-01f, 2.17640842e-03f, -6.29581884e-02f, 1.03886835e-01f, 2.33691484e-01f, -2.54859962e-02f,
  2.34526590e-01f, 1.00596868e-01f, -5.79422601e-02f, 3.42354104e-02f, -6.48912415e-02f, 1.84790269e-01f, 3.76105271e-02f, 5.08285947e-02f, -2.73310971e-02f, 1.92514256e-01f,
  2.57389605e-01f, 2.20649675e-01f, 4.93845977e-02f, -7.53210634e-02f, -1.72458246e-01f, -1.53562680e-01f, 3.54177773e-01f, 1.70472443e-01f, -2.25841552e-01f, -1.24968715e-01f,
  1.28163561e-01f, -1.44141197e-01f, 1.48522019e-01f, 6.90783039e-02f, -2.08439499e-01f, -3.02300621e-02f, 3.92730981e-02f, -2.71391511e-01f, 3.78816217e-01f, 4.03886825e-01f,
  1.18378468e-01f, 7.74972960e-02f, 2.72488799e-02f, 9.01767164e-02f, 1.46746725e-01f, -6.43574586e-03f, 2.60094497e-02f, -4.10672128e-02f, 2.21234057e-02f, 1.92497492e-01f,
  5.46498120e-01f, -1.72275342e-02f, 2.53907949e-01f, 1.32354572e-01f, -9.56492871e-02f, -6.61505535e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  4.52255756e-02f, 2.69492320e-03f, 1.60514675e-02f, -1.65000316e-02f, 1.10076800e-01f, 9.57994163e-02f, 3.71492766e-02f, 3.23957726e-02f, -8.86530280e-02f, 4.80666459e-02f,
  1.89693142e-02f, -1.01834998e-01f, 9.74548757e-02f, 1.03037208e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -2.92656839e-01f, -4.22574311e-01f, 3.63128811e-01f, -1.28194243e-01f, -3.00803363e-01f, -2.66205966e-01f, -1.07241437e-01f, 9.29029658e-02f, -2.15765521e-01f, -9.35338810e-02f,
  -1.70559257e-01f, -1.81659415e-01f, -2.99115330e-01f, -2.97280908e-01f, -4.65325564e-02f, 7.60407448e-02f, -1.59352198e-01f, -3.37422699e-01f, 1.78782612e-01f, -2.44889736e-01f,
  -1.93878338e-01f, -9.57497209e-03f, 1.88300326e-01f, 6.63769245e-02f, -9.28376466e-02f, 2.03045517e-01f, -3.48738313e-01f, -3.50785166e-01f, 4.30593371e-01f, -2.43016243e-01f,
  4.92722727e-02f, 3.27977300e-01f, -2.67196625e-01f, -2.17862129e-01f, 1.80187896e-01f, -6.44948408e-02f, 2.26784691e-01f, -6.97220042e-02f, 6.50309622e-02f, -2.57625490e-01f,
  4.85910028e-01f, -1.88773602e-01f, -3.02833855e-01f, 5.99706266e-03f, -2.41165876e-01f, -1.03619777e-01f, 1.72279701e-01f, 2.24281251e-01f, -1.85709268e-01f, 2.83041447e-01f,
  5.50208867e-01f, 1.68093055e-01f, -7.98957236e-03f, 4.54522576e-03f, -1.05577059e-01f, -1.30850613e-01f, -7.40830675e-02f, 1.88393262e-03f, -7.00717932e-03f, -4.33697142e-02f,
  3.55641805e-02f, 3.11046764e-02f, 1.53687999e-01f, -2.27443606e-01f, 1.37569364e-02f, 3.05322677e-01f, 3.32490474e-01f, 3.87625933e-01f, -9.97642130e-02f, -8.94441009e-02f,
  3.62544864e-01f, 1.15158044e-01f, 1.08773649e-01f, -2.77330905e-01f, 6.50588274e-02f, 4.98211272e-02f, 1.89348459e-01f, 3.40988226e-02f, -1.08543992e-01f, 8.04914683e-02f,
  2.01088831e-01f, -2.13397518e-01f, 2.66815007e-01f, 1.17843263e-01f, 1.89492300e-01f, -2.22179182e-02f, 1.30417883e-01f, -1.57777146e-02f, 3.52256894e-02f, -1.46448016e-01f,
  -5.58220804e-01f, -5.32628179e-01f, 2.07353935e-01f, -9.69872549e-02f, -3.18098813e-01f, 1.23663448e-01f, 2.02031992e-02f, 2.33269423e-01f, -3.81584503e-02f, -1.41705140e-01f,
  2.04040661e-01f, 8.34733769e-02f, 9.57919434e-02f, -3.51980925e-01f, 5.12463331e-01f, 4.18462723e-01f, -2.85425603e-01f, -1.55181661e-01f, 3.98203433e-02f, -7.26630613e-02f,
  2.76656479e-01f, 3.89449835e-01f, -3.20283264e-01f, 2.03549638e-01f, 1.53052369e-02f, 9.18168128e-02f, 7.47260079e-02f, -1.10831577e-02f, -1.52974874e-01f, -2.81713039e-01f,
  -1.37582630e-01f, 4.62460667e-02f, -1.68578520e-01f, -2.39504240e-02f, 9.80204269e-02f, 8.08062479e-02f, -3.46603900e-01f, 6.04834557e-01f, -2.37439014e-02f, 3.41535836e-01f,
  -1.07434139e-01f, 1.42937660e-01f, 2.62197971e-01f, 5.08458138e-01f, 5.47203481e-01f, -2.85764247e-01f, 4.84548301e-01f, 2.04177991e-01f, -1.71415031e-01f, 2.67593741e-01f,
  -2.72729665e-01f, 2.17741251e-01f, -1.02796117e-02f, -3.55604775e-02f, -4.33965951e-01f, -2.09308714e-01f, -2.32801184e-01f, -1.95425719e-01f, -1.63747802e-01f, 1.92581579e-01f,
  -6.51194528e-02f, -5.42138182e-02f, -2.45222852e-01f, 2.72612453e-01f, 9.81764868e-02f, 1.84422761e-01f, -5.20739183e-02f, 1.12494320e-01f, -8.45513940e-02f, 1.84581056e-01f,
  -2.60268688e-01f, -1.50041492e-03f, 7.76063055e-02f, -2.99501598e-01f, 3.86899203e-01f, 1.37834862e-01f, 1.16846383e-01f, -2.23840415e-01f, 2.54507978e-02f, -2.33732492e-01f,
  -3.75921398e-01f, 1.49338529e-01f, -3.24167401e-01f, -1.82838082e-01f, -3.04945081e-01f, -3.96612138e-01f, 1.77881390e-01f, 2.70808011e-01f, -3.76555890e-01f, 8.41276348e-02f,
  1.72699735e-01f, -9.83908474e-02f, 1.71327963e-01f, -3.52627069e-01f, 1.12151943e-01f, 1.92368887e-02f, -1.94536924e-01f, 1.54338688e-01f, 2.74332743e-02f, 3.12630944e-02f,
  4.45077538e-01f, -1.34004995e-01f, -2.04233855e-01f, 1.17559865e-01f, -8.97508636e-02f, 3.04993987e-01f, 2.83354282e-01f, -1.57177821e-01f, 2.28878129e-02f, 1.31422982e-01f,
  -3.45591642e-02f, 1.74622104e-01f, 3.07721823e-01f, -3.80065769e-01f, -2.71384507e-01f, 2.00711593e-01f, -6.03447482e-02f, -5.45585565e-02f, -3.09579641e-01f, 2.46203944e-01f,
  -2.80508446e-03f, 1.53280079e-01f, 2.01057360e-01f, -2.11293008e-02f, -3.89905155e-01f, 1.05940243e-02f, 1.79098725e-01f, 2.20103130e-01f, -3.30799043e-01f, 1.28606811e-01f,
  8.42775479e-02f, 1.63294196e-01f, -3.52101654e-01f, 4.99797672e-01f, -4.17194813e-01f, -4.64595199e-01f, -3.15247297e-01f, -9.80439335e-02f, 2.24880591e-01f, 2.00073168e-01f,
  -1.83338925e-01f, 3.60760301e-01f, -1.89872801e-01f, -1.16547778e-01f, 2.82677919e-01f, 6.63908720e-02f, 3.67830433e-02f, -3.75396341e-01f, 2.30197266e-01f, -2.10493535e-01f,
  3.40001702e-01f, 8.49816576e-02f, -1.11046163e-02f, -2.98292754e-04f, -1.44079223e-01f, -1.14110429e-02f, -8.65192041e-02f, 1.36835322e-01f, -1.21041261e-01f, 9.17875245e-02f,
  2.62495100e-01f, 7.59639964e-02f, -2.46392693e-02f, -4.39693108e-02f, 2.21965313e-01f, -7.73135185e-01f, 1.35676131e-01f, 2.33991772e-01f, -1.47050679e-01f, -1.89434290e-02f,
  1.30681798e-01f, -1.00276150e-01f, -1.94249481e-01f, -3.37924033e-01f, -2.03276306e-01f, 2.00965434e-01f, -9.53543372e-03f, -9.66985449e-02f, -1.90312028e-01f, -1.64263830e-01f,
  3.44186395e-01f, 9.52606425e-02f, -3.11829746e-01f, 3.66683900e-01f, -4.35274363e-01f, 6.00114167e-02f, -1.59951136e-01f, 4.53945585e-02f, -8.42115730e-02f, 1.77380159e-01f,
  1.39760286e-01f, 9.17356014e-02f, -7.05054849e-02f, 1.67697176e-01f, -1.72305331e-01f, -6.91863820e-02f, -3.21641713e-01f, 4.37856197e-01f, 4.81410593e-01f, -4.71826434e-01f,
  2.90117562e-01f, -1.69838816e-01f, 1.53256178e-01f, -3.16970855e-01f, 3.25350165e-01f, 2.90981859e-01f, -6.65275231e-02f, 2.92869240e-01f, -4.35894370e-01f, -4.94823568e-02f,
  -4.18791920e-02f, 5.04853465e-02f, 6.75959960e-02f, -1.48952767e-01f, 2.10967943e-01f, 1.46306738e-01f, 3.74152690e-01f, -1.54035628e-01f, -1.26947373e-01f, -7.34793469e-02f,
  -1.93779767e-01f, 4.80199531e-02f, -1.12096677e-02f, 7.32984245e-02f, -5.09260148e-02f, -5.95602207e-02f, 2.09854953e-02f, 7.09701562e-03f, 2.83197105e-01f, 2.69556604e-02f,
  1.43312395e-01f, 6.69683889e-02f, -1.90733954e-01f, -3.32275301e-01f, -2.08217993e-01f, 3.61608177e-01f, 1.50805280e-01f, -4.69665408e-01f, 1.62754759e-01f, -3.46377283e-01f,
  3.54935765e-01f, 3.46307546e-01f, -1.35606363e-01f, -1.01014271e-01f, 4.15398091e-01f, 3.14472914e-01f, 3.13774496e-01f, 3.47907782e-01f, -2.82054506e-02f, 2.35785127e-01f,
  8.12251568e-02f, 1.75238624e-01f, 2.89489776e-01f, -3.63219716e-02f, 5.71332276e-02f, -1.66556805e-01f, 4.01740551e-01f, 2.21932039e-01f, -3.34688127e-01f, -4.16025072e-01f,
  -2.76297092e-01f, -1.41513690e-01f, -3.98236774e-02f, 9.83832851e-02f, 3.00048798e-01f, 2.54602749e-02f, -7.86675066e-02f, 2.13209704e-01f, 1.63933769e-01f, -1.27382249e-01f,
  -5.93104623e-02f, 8.20221938e-03f, -2.78833270e-01f, 1.07167311e-01f, 1.10457130e-01f, -2.33942300e-01f, 2.57059503e-02f, -7.70707130e-02f, -2.78901875e-01f, -1.91769183e-01f,
  2.08916187e-01f, 1.05886541e-01f, 6.43965900e-02f, 9.61035863e-02f, -3.60550165e-01f, -3.94234136e-02f, 1.16096944e-01f, -1.68437827e-02f, -8.59192088e-02f, -7.97328353e-02f,
  -1.01159342e-01f, -1.43519774e-01f, -1.79913137e-02f, 2.94838130e-01f, -2.96223164e-01f, -3.34800094e-01f, 1.38500690e-01f, -5.40220924e-02f, 9.81843285e-03f, -1.63311914e-01f,
  -3.30704838e-01f, 4.86085474e-01f, -3.80869567e-01f, 1.72032446e-01f, -4.11708564e-01f, -1.96424618e-01f, 2.80158430e-01f, 2.71162065e-03f, -8.34460333e-02f, 1.07179031e-01f,
  2.63789207e-01f, -3.98510918e-02f, 3.66938919e-01f, 1.69194072e-01f, 1.08424172e-01f, -1.16836548e-01f, -1.64064750e-01f, 1.53091103e-01f, 1.04480118e-01f, -3.79583597e-01f,
  7.33332261e-02f, 4.44082431e-02f, -2.52764016e-01f, 3.49707842e-01f, 3.15271109e-01f, 3.70128490e-02f, -4.70449142e-02f, 1.46342769e-01f, -2.16575772e-01f, -2.17552662e-01f,
  -2.61071980e-01f, -1.29799604e-01f, -2.34982014e-01f, -4.67262477e-01f, 1.54232368e-01f, 8.93483087e-02f, -2.72353917e-01f, -5.32686859e-02f, -2.31125429e-01f, -1.52700931e-01f,
  -3.90468895e-01f, 3.86577249e-01f, -8.92697796e-02f, 1.59426481e-01f, -1.31257460e-01f, 4.76365052e-02f, 2.85692066e-01f, -6.54792637e-02f, 2.20282108e-01f, -2.34081402e-01f,
  8.95263478e-02f, -8.89661908e-02f, 4.44647782e-02f, 4.46991511e-02f, -3.37164290e-02f, -1.70316741e-01f, -4.44033861e-01f, 2.43672967e-01f, 1.10300280e-01f, 1.33028194e-01f,
  2.94427752e-01f, 2.15466797e-01f, -2.47009203e-01f, -3.05696189e-01f, 1.85947582e-01f, 1.29564181e-01f, -9.24108252e-02f, -1.75620243e-01f, 1.63430557e-01f, 1.34259880e-01f,
  4.39678458e-03f, -1.25249788e-01f, 1.03289997e-02f, -2.25025207e-01f, 2.32416257e-01f, -1.16960622e-01f, 1.32168680e-01f, -7.98922256e-02f, 1.80049501e-02f, 1.49212360e-01f,
  9.50012282e-02f, -8.09385255e-02f, 1.21794485e-01f, 9.63496268e-02f, -1.56768207e-02f, -2.48316210e-02f, 6.42378867e-01f, 3.21763635e-01f, 3.99976045e-01f, -8.55659619e-02f,
  5.11970460e-01f, 2.59327412e-01f, -3.91244292e-01f, -1.21258751e-01f, -1.34693608e-01f, -1.19102612e-01f, -5.90892732e-01f, 1.53977320e-01f, -1.52941599e-01f, -1.24766231e-01f,
  4.19413447e-01f, -1.16012625e-01f, 2.18135938e-01f, 2.71045566e-01f, -1.77994356e-01f, -1.25602484e-01f, 2.48742625e-01f, -1.73284754e-01f, -1.04408935e-01f, 4.07362245e-02f,
  -1.00027069e-01f, -3.56001966e-02f, 5.60583711e-01f, 2.68208653e-01f, 1.14059016e-01f, -2.94126924e-02f, -7.51366392e-02f, -6.36902079e-02f, 1.29281878e-01f, -4.47249971e-02f,
  -2.78757304e-01f, -3.65579396e-01f, 8.00809041e-02f, 5.22063952e-03f, 2.29490742e-01f, -1.59596354e-01f, -3.22964042e-02f, 3.70725930e-01f, -2.64235258e-01f, 3.24509680e-01f,
  8.61801282e-02f, -1.41289666e-01f, -1.40698314e-01f, 2.06132963e-01f, 2.01444104e-01f, -6.06864132e-02f, -1.05909631e-01f, 4.68914695e-02f, -3.72052155e-02f, -2.10720971e-01f,
  1.75609127e-01f, -4.58584204e-02f, -2.66041160e-01f, 2.23770482e-03f, -1.03603609e-01f, -5.56629635e-02f, -1.77626818e-01f, 1.00257874e-01f, 1.40204936e-01f, -8.15341473e-02f,
  -2.64315039e-01f, -3.22521240e-01f, 3.88057560e-01f, -2.17137262e-01f, -1.48525059e-01f, 3.84656817e-01f, 2.68143237e-01f, 4.75007564e-01f, -3.10958833e-01f, -2.28184640e-01f,
  2.43672386e-01f, 2.07687736e-01f, -1.89921513e-01f, 5.40693164e-01f, 3.21887672e-01f, -2.82333255e-01f, 3.57782543e-01f, 3.71025354e-01f, 2.67019898e-01f, -8.53698179e-02f,
  -1.32913083e-01f, -1.60780564e-01f, -1.89055726e-01f, 2.06414163e-02f, -3.32755655e-01f, 5.65594099e-02f, -1.82626262e-01f, 3.38523000e-01f, -8.58559236e-02f, 1.16877995e-01f,
  -1.38890445e-02f, 1.27732858e-01f, -1.81124300e-01f, 2.33513772e-01f, -5.03259301e-01f, 2.29959950e-01f, 3.59089822e-01f, -2.97740638e-01f, -4.55850482e-01f, -9.96675715e-03f,
  -3.03614795e-01f, 2.79351808e-02f, 2.62106974e-02f, -2.03039259e-01f, 4.31660891e-01f, 7.53085688e-02f, -2.64827907e-01f, 3.31530929e-01f, -4.09786925e-02f, 5.15337959e-02f,
  6.56549558e-02f, 6.14667609e-02f, -3.71238738e-01f, -1.34884462e-01f, -2.49978453e-01f, 2.54079960e-02f, -9.42901894e-02f, -2.37352312e-01f, 2.10130051e-01f, -1.89180851e-01f,
  9.67515111e-02f, -3.59571666e-01f, 3.69527072e-01f, 1.63906261e-01f, -3.69878039e-02f, 4.23759401e-01f, 5.43481529e-01f, -3.58562410e-01f, -3.37643445e-01f, 3.15474153e-01f,
  -4.42328542e-01f, -2.09076509e-01f, -4.24657285e-01f, 7.70919025e-02f, -2.96178274e-02f, -2.08128631e-01f, -1.24745384e-01f, -4.31193352e-01f, -1.72940925e-01f, 4.49502170e-01f,
  -2.05469713e-01f, -2.17635185e-01f, -3.70143026e-01f, 2.95979679e-01f, 3.35093468e-01f, 6.19601011e-02f, -3.26212734e-01f, 3.00896391e-02f, 1.88413933e-01f, 1.15070775e-01f,
  4.07985061e-01f, -2.43470460e-01f, -1.04720615e-01f, -6.26841411e-02f, 1.13061219e-02f, -2.33150460e-02f, -2.15782061e-01f, 5.18008806e-02f, -1.02202194e-02f, 6.00101473e-03f,
  -1.59863517e-01f, 2.32112892e-02f, 1.92388043e-01f, -9.03611351e-03f, -7.59169012e-02f, -9.45841745e-02f, 2.54567444e-01f, -2.79128224e-01f, 2.58515656e-01f, 1.53650850e-01f,
  2.83459444e-02f, -9.09030065e-02f, 2.16743246e-01f, -9.25266966e-02f, -3.79372656e-01f, 3.63017134e-02f, 5.16091399e-02f, -3.30586880e-02f, 8.50162283e-02f, 4.45708111e-02f,
  1.45164430e-01f, -1.11112975e-01f, -3.59156013e-01f, 4.33064140e-02f, -3.80565934e-02f, 3.06151658e-01f, 3.06788355e-01f, 1.26875505e-01f, -2.74026752e-01f, -2.77729481e-01f,
  -3.78844380e-01f, -2.62483954e-01f, -1.92261055e-01f, -3.32688391e-01f, 2.91576870e-02f, 5.52267015e-01f, 4.02785063e-01f, 1.70201391e-01f, 1.97597623e-01f, 3.30776274e-01f,
  -7.14133605e-02f, -3.49802822e-01f, 4.90453482e-01f, 6.75272644e-02f, -1.13106534e-01f, 4.51221943e-01f, 1.48232624e-01f, -1.78164527e-01f, -3.31006289e-01f, -2.48362780e-01f,
  1.97002664e-01f, 1.11624852e-01f, -2.72349834e-01f, -3.50651778e-02f, -2.34181613e-01f, 2.99944669e-01f, 2.11291965e-02f, 5.58952913e-02f, 1.89759016e-01f, -3.77513729e-02f,
  -1.71033919e-01f, 3.41186859e-02f, 2.09244844e-02f, -4.14828956e-01f, -1.70257464e-01f, -3.10308397e-01f, -1.18764326e-01f, -8.50376934e-02f, 3.64261031e-01f, -2.91180521e-01f,
  -1.80222869e-01f, 1.15960516e-01f, -3.82486165e-01f, 2.67786056e-01f, 3.82549554e-01f, -4.16883767e-01f, 2.54256055e-02f, 8.08726698e-02f, 1.09933026e-01f, -4.05908644e-01f,
  1.94044113e-01f, 6.79218844e-02f, -9.38825458e-02f, -6.88464046e-02f, 4.82969433e-02f, 4.75719124e-02f, 1.17137134e-01f, 4.25002016e-02f, -5.51715195e-02f, -3.85649532e-01f,
  1.12157874e-01f, -2.72201095e-02f, -3.06354463e-01f, 1.77496389e-01f, 1.50600091e-01f, -1.26930326e-01f, 3.77580583e-01f, 2.03795582e-01f, 2.73419857e-01f, -1.00998744e-01f,
  -1.36014655e-01f, 1.08713962e-01f, -1.42736509e-01f, 1.20457217e-01f, -4.03083563e-02f, 2.53048211e-01f, 2.83410132e-01f, -5.19273579e-01f, 1.06507696e-01f, 2.24896237e-01f,
  1.80549808e-02f, -5.40689304e-02f, 1.11321412e-01f, -3.04980785e-01f, -1.70420095e-01f, 8.97154287e-02f, 1.35155037e-01f, -1.05661742e-01f, -9.79901105e-02f, 3.32796156e-01f,
  -2.22116504e-02f, -6.58200532e-02f, -1.09878562e-01f, 2.08155453e-01f, 3.38480651e-01f, 1.90213680e-01f, -2.46411949e-01f, 2.60561079e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.02106601e-01f, 2.83142645e-02f, -8.82742777e-02f, -8.69346038e-03f, -1.40418755e-02f, 6.53332546e-02f, -7.88444802e-02f, 3.94329764e-02f, -1.57046467e-02f, 8.98217559e-02f,
  -8.76193941e-02f, -1.44136585e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    