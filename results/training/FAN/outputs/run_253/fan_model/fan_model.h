/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.21666685e-01f, -3.12863737e-02f, 3.23551327e-01f, -8.14799126e-03f, -8.18356648e-02f, -3.43612820e-01f, -4.95216809e-02f, -1.52567392e-02f, 1.05119549e-01f, -1.36951759e-01f,
  1.87435100e-04f, 1.38748929e-01f, 1.56961486e-01f, -1.28805265e-01f, 8.93645138e-02f, 8.41822103e-03f, -7.22731203e-02f, -2.64615212e-02f, 1.69366486e-02f, 4.70525809e-02f,
  1.15585163e-01f, -2.20828637e-01f, 1.34579092e-01f, -1.12162933e-01f, -1.36009464e-02f, 1.29072130e-01f, 1.03718780e-01f, 3.85318696e-02f, -1.36046171e-01f, -5.32905161e-02f,
  -1.09178796e-01f, 8.80533531e-02f, 2.13554744e-02f, 3.30394357e-02f, 3.38574499e-02f, -4.86838594e-02f, 5.10933176e-02f, -2.85794586e-02f, 5.96314706e-02f, -4.81179915e-02f,
  2.30618864e-02f, 2.69770157e-02f, -5.37754223e-02f, 1.22182285e-02f, -1.94349904e-02f, 6.31624982e-02f, -5.41122258e-02f, -1.77516416e-02f, 3.56934443e-02f, 1.70061700e-02f,
  4.74401563e-02f, 4.22908440e-02f, -2.77033858e-02f, 3.08336690e-02f, 6.31498396e-02f, 2.30951514e-02f, 4.16791588e-02f, 6.22903965e-02f, 6.95341686e-03f, -7.97543153e-02f,
  -3.88807431e-02f, -8.35812651e-03f, -9.84751210e-02f, -2.27922332e-02f, -7.39599690e-02f, -1.11714667e-02f, -4.36703041e-02f, -1.68480314e-02f, -6.47960696e-03f, -1.06190462e-02f,
  -4.37827706e-02f, 1.67530142e-02f, -6.16383292e-02f, -2.13570371e-02f, -2.88309902e-02f, -2.51966901e-02f, 2.88998764e-02f, -1.83233041e-02f, -5.57571137e-03f, -3.79952826e-02f,
  4.30854154e-04f, -9.50915739e-03f, -6.78558126e-02f, -2.28324886e-02f, 2.17796545e-02f, 6.79700300e-02f, -4.47385088e-02f, -1.34030739e-02f, 4.87922840e-02f, 2.83545386e-02f,
  4.16601822e-02f, 1.67899318e-02f, -1.25891650e-02f, -5.57748266e-02f, 1.25841796e-02f, -1.36328163e-04f, -3.13383602e-02f, -5.22410981e-02f, 4.12035547e-02f, 3.86988074e-02f,
  3.61104794e-02f, -1.06916111e-02f, 4.19789366e-02f, -1.18498774e-02f, -3.23637612e-02f, -2.56780311e-02f, 1.10749127e-02f, 2.27589272e-02f, -2.38855779e-02f, -1.07490374e-02f,
  -5.59297502e-02f, -7.10553601e-02f, 6.28620088e-02f, -7.25808814e-02f, -2.70578079e-02f, 2.06519626e-02f, -5.92701808e-02f, -6.17366731e-02f, -3.11523471e-02f, 7.36206397e-02f,
  -4.86134253e-02f, 2.50570029e-01f, 3.55036408e-01f, 3.25424492e-01f, -1.71452194e-01f, 1.43236950e-01f, 1.81727469e-01f, -5.07421745e-03f, 2.51805812e-01f, 6.81345016e-02f,
  -1.57862473e-02f, 1.52715877e-01f, 4.63219434e-02f, 2.81876147e-01f, -4.63381559e-02f, 1.87089935e-01f, 1.26770005e-01f, 1.07531779e-01f, 2.91984100e-02f, 6.30065352e-02f,
  3.34993452e-02f, 5.82714081e-02f, 8.61844271e-02f, -1.08411491e-01f, 4.44837883e-02f, 1.39309503e-02f, -1.99814782e-01f, -7.01673329e-02f, -8.24526176e-02f, -5.28480522e-02f,
  -7.04248026e-02f, 2.48927742e-01f, 6.75247461e-02f, 6.81099994e-03f, -1.49886990e-02f, -8.46383721e-02f, -2.38401983e-02f, 7.45336413e-02f, 2.52337828e-02f, 7.35943541e-02f,
  8.67015198e-02f, 2.64213923e-02f, 1.97203290e-02f, 2.68674809e-02f, 1.47574088e-02f, 6.57287845e-03f, 1.81474059e-03f, 1.67683437e-02f, 1.55273573e-02f, 3.57463323e-02f,
  3.11521944e-02f, 2.04325616e-02f, 1.11779168e-01f, 4.12993580e-02f, 5.41736707e-02f, 4.31901915e-03f, 2.71787681e-03f, -7.14949425e-03f, -2.94380579e-02f, 7.73623446e-03f,
  7.84188062e-02f, -8.41470957e-02f, 1.31882736e-02f, -6.42686337e-02f, 5.19983657e-02f, -6.56109303e-02f, 6.62211478e-02f, -7.17511848e-02f, -7.15927128e-03f, 2.00052541e-02f,
  -2.78520454e-02f, 2.94849668e-02f, 4.88869473e-02f, 1.14882262e-02f, 2.38802116e-02f, 3.11154053e-02f, 2.01588701e-02f, -6.88592270e-02f, -6.57738149e-02f, -3.35493423e-02f,
  2.95352694e-02f, -3.14772725e-02f, 3.35635990e-02f, -9.59814265e-02f, -9.66720562e-03f, -4.91043972e-03f, -2.28422880e-02f, 7.87845775e-02f, -3.02835703e-02f, -3.69938724e-02f,
  -1.59687996e-01f, -2.39769518e-02f, -3.77901345e-02f, -1.96828730e-02f, 4.43071331e-04f, 1.39015103e-02f, 5.03101647e-02f, -1.14109963e-02f, 5.59053849e-03f, -5.21469973e-02f,
  -8.56821463e-02f, -1.64699145e-02f, -6.46955371e-02f, -1.01103922e-02f, 6.23309053e-02f, -4.35294807e-02f, -1.00221578e-02f, 2.28277147e-02f, -3.91402021e-02f, -4.11041714e-02f,
  1.69026072e-03f, -1.62418876e-02f, 4.99756774e-03f, -7.00579733e-02f, -5.05172610e-02f, 5.40514337e-03f, 1.73202436e-02f, -1.09703187e-03f, -2.60986798e-02f, -6.40852423e-03f,
  5.03944039e-01f, -1.46675065e-01f, -2.38232873e-02f, -8.98038670e-02f, 5.32059856e-02f, 2.21364349e-01f, 1.10274844e-01f, -4.08318155e-02f, 3.19560796e-01f, -2.04078630e-01f,
  -1.75137311e-01f, 2.42753968e-01f, -1.73706874e-01f, -8.06009099e-02f, 2.94562817e-01f, -7.56668299e-02f, 4.63473890e-03f, 7.12840185e-02f, 1.32580921e-01f, -1.74891390e-02f,
  7.44882748e-02f, -5.47505133e-02f, -1.19914599e-01f, -5.09884804e-02f, 1.79261547e-02f, 1.86026667e-03f, -2.07919121e-01f, -1.27695292e-01f, -1.73358366e-01f, 1.07032061e-01f,
  5.33981398e-02f, 4.42159697e-02f, 2.53053922e-02f, 7.83191323e-02f, -9.61255729e-02f, -1.66414268e-02f, -7.30183627e-03f, 3.27969752e-02f, 5.14331795e-02f, 2.83953454e-02f,
  4.41866703e-02f, 5.63018695e-02f, 3.51115428e-02f, 6.34799898e-02f, 4.16002944e-02f, 5.43843731e-02f, 3.03247068e-02f, 4.26704064e-02f, -1.26435086e-02f, 2.65097786e-02f,
  -1.27381850e-02f, -1.12274764e-02f, -6.75878208e-03f, -2.38152836e-02f, -1.65669862e-02f, 1.81005131e-02f, 2.50750370e-02f, -1.07375672e-02f, 2.26958748e-03f, 4.50184159e-02f,
  9.61682647e-02f, 4.03292477e-03f, 1.28563046e-02f, -1.35494061e-02f, 4.24533710e-02f, -3.92426737e-02f, 1.22178737e-02f, -2.28840820e-02f, 2.70861667e-02f, -2.48003826e-02f,
  -3.74717265e-02f, -2.68340427e-02f, 6.13323040e-02f, 6.69251895e-03f, -2.49751029e-03f, 4.66145761e-02f, 1.22433985e-02f, -5.37998751e-02f, 2.63923518e-02f, -2.49511581e-02f,
  -3.65375099e-03f, 4.51629013e-02f, -2.93968827e-03f, -1.12788053e-03f, 2.81435233e-02f, 5.63746225e-03f, -4.33791466e-02f, -2.20665243e-02f, -1.59876700e-02f, -1.80199128e-02f,
  5.21812886e-02f, -1.27536312e-01f, -5.77589460e-02f, 3.79753932e-02f, -4.84200716e-02f, -2.68326085e-02f, -1.33640121e-03f, -2.34927908e-02f, -1.14082322e-02f, -1.22624459e-02f,
  -2.70449631e-02f, -5.91442250e-02f, -2.69166622e-02f, 1.46222869e-02f, 4.21491042e-02f, 1.18071854e-03f, -3.17109516e-03f, 2.16450747e-02f, -9.29203629e-03f, 8.84169340e-03f,
  -5.61166853e-02f, 2.37279013e-02f, 2.07235552e-02f, 1.83950812e-02f, -7.14115426e-02f, 2.06848644e-02f, 4.76901121e-02f, 2.84474809e-02f, 7.36691570e-03f, -4.46581915e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.96953207e-01f, -2.80484818e-02f, -1.34305134e-01f, -7.71772787e-02f, -4.71528172e-02f, 5.90517633e-02f, 7.61551857e-02f, 6.33157091e-03f, -2.51325965e-01f, 9.16974545e-02f,
  1.79438338e-01f, -3.38946283e-02f, 2.34435294e-02f, -3.38672921e-02f, 1.07254095e-01f, 6.88419715e-02f, 9.54414159e-02f, 5.76917641e-02f, -8.88846070e-02f, 1.64493635e-01f,
  5.09327613e-02f, 9.65204611e-02f, 2.08952781e-02f, 2.16858461e-02f, 7.82009438e-02f, 5.11067025e-02f, 2.10281506e-01f, 3.27961296e-02f, 7.04293177e-02f, 5.92945218e-02f,
  8.13586712e-02f, -1.53029449e-02f, 8.36552382e-02f, -8.56228620e-02f, 1.54871792e-01f, 1.70636594e-01f, 2.48190109e-02f, 5.93121760e-02f, -3.48622128e-02f, -9.40418150e-03f,
  3.80118601e-02f, -3.13357636e-02f, -4.95889634e-02f, -1.25872763e-02f, -1.11990735e-01f, -7.59035349e-02f, -7.08023319e-03f, -7.34648928e-02f, -4.40071989e-03f, 3.37395519e-02f,
  3.57630954e-04f, -9.19339061e-02f, -9.37802568e-02f, -4.02258243e-03f, -1.44202814e-01f, 1.51998142e-03f, -7.39486367e-02f, 5.11045866e-02f, -5.47423847e-02f, -4.42980342e-02f,
  9.45436507e-02f, -7.24337697e-02f, 5.31835407e-02f, -3.05133220e-02f, -2.46915072e-02f, -4.00574431e-02f, 3.88166606e-02f, 6.89060055e-03f, 2.52502132e-02f, 7.72411078e-02f,
  -2.76068691e-02f, -1.61628164e-02f, 1.54100573e-02f, -4.80378531e-02f, 1.04463622e-02f, 6.21114532e-03f, -4.54779007e-02f, 2.61574201e-02f, -2.57672686e-02f, -5.25663421e-02f,
  -8.07919502e-02f, 1.17505612e-02f, 3.74049973e-03f, -3.97491343e-02f, -8.24818015e-02f, -5.71375303e-02f, 2.36022659e-02f, -1.75319444e-02f, -8.84031355e-02f, 3.41010280e-02f,
  1.99041426e-01f, 1.40362307e-01f, -5.59011921e-02f, 2.42027342e-02f, -3.35773639e-02f, 6.61267713e-02f, -8.67127031e-02f, 5.46295419e-02f, 3.14551629e-02f, 1.00944735e-01f,
  7.18645900e-02f, -9.56532806e-02f, 7.46992696e-03f, -1.07472956e-01f, 1.62661020e-02f, 3.62156034e-02f, -1.67007465e-02f, -4.31707688e-03f, 2.40812618e-02f, 6.46411553e-02f,
  -1.48829427e-02f, 2.60895509e-02f, -8.28100890e-02f, -1.07596017e-01f, -7.48719350e-02f, 1.87551193e-02f, -2.00231280e-02f, 1.66800693e-02f, 1.03048675e-01f, -5.36867604e-02f,
  7.48970285e-02f, 8.06020945e-02f, 6.44563884e-02f, -2.39058062e-02f, 1.91773511e-02f, 1.75891444e-01f, 5.43098450e-02f, 1.83085203e-02f, 3.84335041e-01f, 2.22888235e-02f,
  -2.09760636e-01f, 1.37454927e-01f, -9.10702124e-02f, -5.13695143e-02f, 1.71230212e-01f, 1.76786438e-01f, 8.86975601e-03f, -5.05824666e-03f, 1.25630274e-01f, 2.07222323e-03f,
  5.03532216e-02f, -1.54119045e-01f, -1.41812697e-01f, -2.51475245e-01f, -2.55173177e-01f, -1.69756606e-01f, -2.02629775e-01f, -1.03900991e-01f, -2.60446072e-01f, -3.66168693e-02f,
  -5.13375513e-02f, -4.59823906e-02f, -9.81316119e-02f, -1.17665716e-02f, -4.76544015e-02f, -7.96641782e-02f, 3.91462296e-02f, 1.48308612e-02f, -2.54321303e-02f, -1.45300664e-02f,
  -3.02475411e-02f, 9.04226582e-03f, 1.02406880e-02f, 5.29633462e-02f, 2.02886630e-02f, -1.74756702e-02f, -3.87921184e-02f, -6.99653700e-02f, -5.72846532e-02f, -2.55762693e-02f,
  -5.45432717e-02f, 3.22125219e-02f, -2.05716081e-02f, 8.10625032e-02f, 5.23425220e-03f, 1.25363423e-02f, 8.09646845e-02f, -6.92351814e-03f, 4.87953005e-03f, 1.40247662e-02f,
  -6.22366816e-02f, 5.13038561e-02f, 7.30874017e-03f, -1.42708197e-02f, -4.71138507e-02f, -1.17530048e-01f, -2.74739712e-02f, 3.56638804e-02f, -8.91287904e-03f, -3.16414461e-02f,
  6.46911841e-03f, 2.87732184e-02f, -5.04208431e-02f, 2.97340155e-02f, -5.04329093e-02f, -2.20502969e-02f, -2.43458077e-02f, 1.38722798e-02f, 1.82491876e-02f, 3.10039427e-02f,
  -4.98261303e-02f, 6.20583519e-02f, -8.47133398e-02f, -5.90519644e-02f, -5.60005009e-02f, 4.59896177e-02f, 5.34443147e-02f, -2.76201125e-03f, 6.63450686e-03f, 2.49982011e-02f,
  9.23509076e-02f, 2.74170518e-01f, -6.90791756e-02f, -1.29605841e-03f, 6.21379465e-02f, 1.15220919e-02f, 1.32537171e-01f, 9.11806747e-02f, 1.63599074e-01f, 4.16711792e-02f,
  2.82445401e-02f, 5.93262538e-03f, 3.14575993e-02f, -9.77806672e-02f, 4.43493016e-02f, -6.95396513e-02f, -2.67321672e-02f, 7.69424364e-02f, 4.45971154e-02f, 6.25810772e-02f,
  4.89278287e-02f, -2.06467602e-03f, 4.34681624e-02f, -8.57326388e-03f, -8.96945894e-02f, -4.83520329e-02f, 2.96526384e-02f, 1.60718001e-02f, -2.24177018e-02f, 2.08391789e-02f,
  2.59810835e-01f, 2.43008602e-02f, -1.48293972e-01f, -1.71730325e-01f, -1.14043713e-01f, -2.95654535e-01f, -4.35382277e-01f, -2.54560441e-01f, 1.40340244e-02f, -2.58632060e-02f,
  -1.82576999e-01f, 9.55855921e-02f, -1.34875122e-02f, -2.84332961e-01f, -7.41401315e-02f, -3.65194492e-02f, -3.32732379e-01f, -1.79151278e-02f, 6.71537966e-02f, -1.08706191e-01f,
  -1.32257760e-01f, -2.78911829e-01f, -1.86551318e-01f, -6.29980192e-02f, -1.10238582e-01f, -3.40841785e-02f, 6.38787523e-02f, -1.25373989e-01f, -5.69804721e-02f, -1.69006541e-01f,
  -4.12321016e-02f, 1.26733901e-02f, -4.79259454e-02f, -5.12371995e-02f, -1.28159359e-01f, 5.62970117e-02f, -7.15231150e-03f, -6.77742288e-02f, -7.83970654e-02f, -1.48020769e-02f,
  1.22449875e-01f, 8.41921419e-02f, 3.74585986e-02f, -1.76193938e-02f, 7.95227382e-03f, -7.48009160e-02f, -7.26086721e-02f, 2.20422484e-02f, -9.89566371e-02f, 4.10906635e-02f,
  4.80421223e-02f, 8.24671332e-03f, 1.95402857e-02f, 2.62963288e-02f, -1.92474797e-02f, -3.35656926e-02f, -2.75009368e-02f, -7.93336928e-02f, 6.93000555e-02f, -1.31518757e-02f,
  -1.75632369e-02f, 8.88099521e-02f, 1.97567269e-02f, -2.83595100e-02f, -2.00864684e-04f, -9.62194651e-02f, -4.64825369e-02f, 3.01956758e-02f, 1.78928524e-02f, 4.41446193e-02f,
  5.11296988e-02f, 2.85986774e-02f, 4.04057950e-02f, -7.33597428e-02f, 5.63442521e-02f, 1.07610375e-01f, 5.30781373e-02f, -3.03128343e-02f, -6.45087734e-02f, -6.26888825e-03f,
  -7.56248757e-02f, -2.71153040e-02f, 1.16174044e-02f, 2.34450269e-02f, -9.40922619e-05f, -5.61938062e-02f, -2.31926162e-02f, -1.10483670e-03f, 1.66306105e-02f, 1.15009816e-02f,
  -7.70512223e-02f, -8.11889544e-02f, 1.45453373e-02f, 1.14575429e-02f, 1.24618495e-02f, -9.33218002e-02f, 3.25952508e-02f, 1.31559120e-02f, -1.25269732e-02f, -5.64985313e-02f,
  -4.66762036e-02f, -8.50990042e-02f, -4.20120321e-02f, -1.49955023e-02f, -9.49416086e-02f, -2.76066884e-02f, 5.92252798e-02f, 6.02565669e-02f, 6.86678709e-03f, -1.00385528e-02f,
  -1.37607530e-02f, -9.97797120e-03f, 4.18407954e-02f, 1.71673000e-02f, -5.00129652e-04f, 5.33954725e-02f, 5.71619011e-02f, 4.05127704e-02f, -5.24129570e-02f, -2.06231931e-03f,
  -1.27098277e-01f, -1.04521692e-01f, 6.37318194e-02f, -1.28374279e-01f, 4.86398786e-02f, 7.56395012e-02f, -2.64875721e-02f, 5.94990291e-02f, -2.35088497e-01f, -1.44083668e-02f,
  -2.49611139e-02f, -6.69540232e-03f, 1.18765481e-01f, -4.99776080e-02f, -5.12159839e-02f, -9.09239519e-03f, -5.70881888e-02f, -1.49838347e-03f, 5.76027669e-02f, 1.16569921e-01f,
  1.06045663e-01f, -3.74066494e-02f, 1.47753388e-01f, 3.30594392e-03f, -3.86469401e-02f, 8.37405100e-02f, 2.63126493e-02f, 1.79149404e-01f, 1.99457686e-02f, 7.70851225e-02f,
  -1.14811193e-02f, -6.96050702e-03f, 5.73469065e-02f, -6.62461743e-02f, 8.87611881e-02f, 3.11642978e-02f, 5.10027893e-02f, -5.02220355e-02f, 9.88082215e-02f, -2.20583044e-02f,
  -9.20740515e-02f, 5.80074005e-02f, 1.20678749e-02f, -3.15274373e-02f, 1.39882201e-02f, -1.95588712e-02f, 5.34168631e-02f, 1.60287023e-02f, 3.88881788e-02f, -3.11416313e-02f,
  -2.94405874e-02f, -4.94673178e-02f, 5.46595491e-02f, -9.31533575e-02f, 7.15246424e-02f, -9.48856920e-02f, 4.94691692e-02f, 9.16673839e-02f, -9.64590833e-02f, 2.68939584e-02f,
  7.29260445e-02f, -4.94184345e-02f, -2.31475644e-02f, -4.09797356e-02f, -6.27277568e-02f, 1.76496562e-02f, -3.91227119e-02f, -1.48069346e-02f, 8.16209689e-02f, -2.33884528e-03f,
  -7.23060146e-02f, -3.13945487e-02f, 5.69378063e-02f, -3.05287223e-02f, 2.53811926e-02f, 1.82196184e-03f, 9.11565199e-02f, 9.44725499e-02f, 1.32856490e-02f, -4.04720986e-03f,
  -6.80470141e-03f, 6.63911551e-03f, 8.79915953e-02f, -2.77986582e-02f, -6.20199516e-02f, -4.51314487e-02f, 3.67838633e-03f, -3.84444557e-02f, -3.61181935e-03f, 3.11653782e-02f,
  4.52392399e-02f, 1.63749233e-02f, 9.84190381e-04f, -3.87797207e-02f, 6.35918304e-02f, 4.59190682e-02f, -2.52427924e-02f, -2.37233285e-03f, -2.85659079e-03f, 7.56497830e-02f,
  6.48408988e-03f, -6.52751625e-02f, -9.73969251e-02f, 2.86856350e-02f, 9.35107470e-02f, -2.97567770e-02f, 1.07620850e-01f, -5.06854989e-02f, -6.31778985e-02f, 6.80163354e-02f,
  2.37448309e-02f, -3.49395424e-02f, -3.86953773e-03f, -5.35851950e-03f, 3.72203216e-02f, 4.82810326e-02f, 8.09298083e-02f, -1.13623329e-02f, 6.17804676e-02f, 4.53322232e-02f,
  -3.48599516e-02f, 1.44857973e-01f, -2.16605768e-01f, 2.12556832e-02f, -3.29735093e-02f, 9.28311870e-02f, 1.95134029e-01f, -2.26167459e-02f, 1.90608978e-01f, 2.93005854e-01f,
  2.64505327e-01f, -3.41119468e-02f, 1.25852734e-01f, 2.50630081e-01f, 7.72388130e-02f, 2.23044723e-01f, 1.95716470e-01f, 2.23488376e-01f, 9.10384674e-03f, 9.57490653e-02f,
  -2.79685874e-02f, 2.81138539e-01f, -7.56706819e-02f, -1.55302942e-01f, 4.34232391e-02f, -1.82755753e-01f, -1.34589016e-01f, -1.37530953e-01f, 1.82658387e-03f, 2.29489263e-02f,
  2.43239775e-02f, 8.70495141e-02f, -7.81255811e-02f, -1.05628632e-01f, -3.85483168e-02f, -8.28844756e-02f, 2.57320073e-03f, -8.91815126e-02f, -1.06548175e-01f, -3.04939784e-02f,
  -4.53215949e-02f, -6.30706400e-02f, 7.29328766e-02f, -9.22234803e-02f, 2.67632976e-02f, -6.25665858e-02f, 5.00314124e-03f, -5.59975114e-03f, 4.80532693e-03f, -5.68023697e-02f,
  -5.28236367e-02f, -2.57490072e-02f, -3.64829898e-02f, 7.16260523e-02f, -1.24110058e-02f, 2.87124701e-02f, 1.87395199e-03f, -6.88284039e-02f, -6.32588640e-02f, 5.61257489e-02f,
  -9.94991744e-04f, 5.03212214e-02f, 6.92728683e-02f, -3.65739390e-02f, -1.12594878e-02f, 1.55666582e-02f, -5.65314628e-02f, 2.08261199e-02f, -7.08563179e-02f, 1.19638313e-02f,
  -3.96504551e-02f, -2.21950263e-02f, -3.46001573e-02f, -4.56293263e-02f, 9.61966440e-03f, 6.96052462e-02f, 2.88013406e-02f, 6.05531372e-02f, -3.51610109e-02f, -4.58462425e-02f,
  7.03307837e-02f, 1.09857075e-01f, -5.87333851e-02f, -6.95722774e-02f, 3.72101692e-03f, -2.81195305e-02f, 1.00077704e-01f, -6.63407668e-02f, -9.26367491e-02f, -4.47611064e-02f,
  1.18441164e-01f, -2.40970086e-02f, 1.52539602e-02f, 5.92380017e-02f, 2.40927842e-02f, -3.21486667e-02f, 4.49492335e-02f, -1.20807933e-02f, 8.06103274e-02f, -1.85151293e-03f,
  -8.18091482e-02f, -2.42225826e-02f, -2.39930376e-02f, -8.08746293e-02f, -9.14729759e-02f, 9.27024186e-02f, 2.24749912e-02f, -1.92341153e-02f, 2.45878175e-02f, -5.04241139e-02f,
  -6.89685345e-02f, -7.82709755e-03f, 1.12113655e-02f, -6.23911619e-02f, 2.36701244e-03f, 4.37853113e-02f, 5.68998605e-02f, -9.58727375e-02f, -6.88455775e-02f, 4.39465716e-02f,
  -1.06136464e-01f, 5.89765050e-02f, -1.87950179e-01f, 1.07777253e-01f, 5.84875839e-03f, 4.34213970e-03f, -5.19659109e-02f, 1.25450477e-01f, -1.09572589e-01f, 2.46558413e-02f,
  1.39271408e-01f, -3.31896134e-02f, 2.40498614e-02f, 2.81456828e-01f, 2.00189784e-01f, -6.45904168e-02f, 2.42968038e-01f, 1.28887028e-01f, -6.23372532e-02f, 1.23358294e-01f,
  1.12640783e-01f, 2.01535299e-01f, 1.86731946e-02f, 1.30632117e-01f, 1.58369005e-01f, 1.03779864e-02f, 1.32251620e-01f, -1.17502980e-01f, 1.43930152e-01f, 4.50661704e-02f,
  -7.82344639e-02f, 6.36364222e-02f, -6.40171021e-02f, -2.63657887e-02f, -4.72964570e-02f, 3.49943079e-02f, -3.97288166e-02f, -4.92285974e-02f, -3.53172794e-02f, -2.65938044e-03f,
  -3.01260147e-02f, -4.54101451e-02f, 3.86348441e-02f, 1.61549393e-02f, -4.36783545e-02f, 8.45756158e-02f, -1.77340116e-02f, -4.11433727e-02f, -7.29560703e-02f, -3.65012772e-02f,
  -6.49664551e-02f, 1.68816596e-02f, 4.91040619e-03f, 2.28340495e-02f, -5.23571437e-03f, 3.41968983e-02f, 2.31413729e-02f, -2.86634844e-02f, -8.07175636e-02f, -6.49403490e-04f,
  -5.77586740e-02f, 3.05855777e-02f, 8.56352784e-03f, 7.93403201e-03f, 2.90822051e-02f, -7.05181584e-02f, 5.53386621e-02f, -5.28430752e-03f, -5.07706888e-02f, 2.42724083e-02f,
  -3.00393514e-02f, -4.34055030e-02f, 4.12299186e-02f, -4.52563018e-02f, 5.01014180e-02f, -4.99404781e-02f, -7.62205571e-02f, -1.49049552e-03f, -5.90161420e-02f, 8.08478296e-02f,
  -1.42554529e-02f, -1.30659435e-02f, 5.44185080e-02f, -4.05055620e-02f, -5.14007695e-02f, 7.76079157e-03f, 7.07257837e-02f, 2.08001453e-02f, -5.50039858e-02f, 4.97885942e-02f,
  2.77680811e-02f, 1.82657525e-01f, -1.49956774e-02f, -1.30806994e-02f, -5.26135564e-02f, 1.52473702e-04f, 1.43277282e-02f, -4.62337211e-03f, 4.08985503e-02f, 1.26932748e-02f,
  -4.07423079e-02f, -2.72492804e-02f, -4.85686166e-03f, 9.00343582e-02f, -1.30161345e-02f, 1.02493145e-01f, 7.98780471e-02f, 4.57669348e-02f, 2.70518716e-02f, 4.71649915e-02f,
  5.33314422e-02f, -4.74400148e-02f, -5.24217486e-02f, -2.76804697e-02f, 3.69149335e-02f, -3.23092169e-03f, -1.67999230e-02f, -3.01979780e-02f, -1.12726458e-03f, -8.89518298e-03f,
  7.43348449e-02f, 2.90399402e-01f, 4.61168706e-01f, -4.05853763e-02f, -1.19459845e-01f, -5.76059334e-02f, -1.60520852e-01f, 2.09061727e-02f, 8.50023329e-03f, 1.04293548e-01f,
  -1.46604091e-01f, 4.04621512e-01f, -7.36897215e-02f, -6.87285587e-02f, -2.18039200e-01f, -2.38335088e-01f, -1.29704535e-01f, 7.40633160e-02f, -6.29673898e-02f, -1.37091670e-02f,
  -1.49309516e-01f, -4.29412693e-01f, -1.83557048e-02f, -8.47594664e-02f, 6.14563227e-02f, 2.76475668e-01f, -2.57066429e-01f, -5.40382378e-02f, 1.93734020e-01f, -8.36229650e-04f,
  -4.93565388e-03f, -6.03551567e-02f, 4.81511205e-02f, 1.10421114e-01f, 6.18870705e-02f, 1.26340389e-01f, 1.22318976e-02f, -2.58407779e-02f, 2.56536100e-02f, 7.82637447e-02f,
  3.02652433e-03f, 2.30544601e-02f, 1.29136033e-02f, -8.19849148e-02f, 5.57289831e-02f, 5.87650612e-02f, 2.82673258e-02f, 8.78571942e-02f, 3.09453197e-02f, 8.85434598e-02f,
  1.24708511e-01f, 1.11806273e-01f, 8.14472511e-03f, 3.00957877e-02f, -3.45863849e-02f, -5.15738390e-02f, 1.92649495e-02f, 9.52542424e-02f, 1.28035158e-01f, 6.27722265e-03f,
  8.29517934e-03f, -9.92520899e-02f, -5.17011732e-02f, 1.37950527e-02f, -3.16500179e-02f, -2.56740879e-02f, 2.86803916e-02f, 2.65837628e-02f, -6.28023893e-02f, -5.53929210e-02f,
  3.01239975e-02f, 4.48343344e-02f, -1.95845049e-02f, 5.47133163e-02f, -6.31348416e-02f, -2.51901895e-02f, -6.64955601e-02f, 3.91068794e-02f, 2.29038652e-02f, -5.40154018e-02f,
  -3.98946414e-03f, -8.90230238e-02f, 6.45863041e-02f, 5.05361781e-02f, -7.46698603e-02f, 3.38673517e-02f, 8.45231265e-02f, 4.44751047e-03f, 3.05763446e-02f, -9.48079154e-02f,
  -1.63097948e-01f, -1.57673374e-01f, 1.86614115e-02f, 5.12003675e-02f, -8.68045837e-02f, -5.96808782e-03f, 2.49346364e-02f, 3.88757326e-02f, -1.28950581e-01f, -3.83584872e-02f,
  -3.68662514e-02f, 3.57471779e-02f, 4.72280495e-02f, 2.51075514e-02f, 1.91092417e-02f, -2.75206082e-02f, -1.02526054e-01f, 3.43157947e-02f, -5.84663935e-02f, 3.83077636e-02f,
  8.47525746e-02f, -1.64729618e-02f, 1.18462620e-02f, -6.09563664e-02f, -1.11157540e-02f, -2.05224548e-02f, -2.14780793e-02f, -1.69078391e-02f, 5.85100390e-02f, -2.96957623e-02f,
  -1.71179399e-02f, 5.65733388e-02f, -4.11088616e-02f, -3.48985046e-02f, 2.26323511e-02f, 5.66618890e-02f, 1.22671224e-01f, -7.32735768e-02f, 3.53807658e-02f, 1.79103076e-01f,
  1.32696182e-01f, 4.18296903e-02f, 2.10726559e-02f, 1.39040828e-01f, -7.01747537e-02f, 5.01092523e-02f, 1.09121557e-02f, 2.11899690e-02f, -5.84357753e-02f, 5.14027290e-02f,
  -1.95013173e-02f, 2.11051106e-01f, -5.39819002e-02f, 1.47014912e-02f, -5.59959114e-02f, -5.68384901e-02f, -8.82683322e-02f, 3.10407020e-02f, -4.15620208e-02f, 6.29141228e-03f,
  7.01256096e-02f, -5.02144545e-02f, 1.51079461e-01f, 1.11152261e-01f, -2.66117696e-02f, -4.51355614e-02f, -8.71992260e-02f, 4.70135435e-02f, 6.60967752e-02f, -5.27628511e-02f,
  1.67593863e-02f, 4.91552316e-02f, 1.19453385e-01f, 4.31862772e-02f, 3.57053913e-02f, 3.61444545e-03f, -6.85659349e-02f, -2.54635960e-02f, -2.18013544e-02f, -1.24310981e-02f,
  1.65251177e-02f, -1.02886148e-01f, 4.02514115e-02f, -1.13192886e-01f, -9.84496921e-02f, -9.36293229e-02f, -6.79055229e-02f, -1.11028083e-01f, -5.87397665e-02f, -7.54142180e-02f,
  -1.08459547e-01f, -2.09947284e-02f, -6.87670009e-03f, 1.09258175e-01f, -6.08322993e-02f, -3.83274183e-02f, -9.15074870e-02f, 4.05081473e-02f, 5.85582711e-06f, 5.92985470e-03f,
  8.61496702e-02f, 4.11975943e-02f, -4.00981400e-03f, 3.88153493e-02f, 6.78361431e-02f, 5.26803732e-02f, 7.16022849e-02f, 4.73430678e-02f, 4.78804372e-02f, -5.33670448e-02f,
  -7.15312958e-02f, -4.01114300e-02f, -3.23868543e-02f, 1.97439995e-02f, 6.86227009e-02f, -2.38437541e-02f, 3.10933869e-02f, -2.77057942e-02f, 1.14991307e-01f, 2.72371490e-02f,
  6.52438328e-02f, -6.46220520e-02f, 8.02431628e-02f, 7.05708861e-02f, 5.86237125e-02f, 3.16614620e-02f, 2.57648714e-02f, 7.55679458e-02f, 2.24023126e-02f, 3.32712978e-02f,
  -9.89883915e-02f, -8.52382854e-02f, 6.05591498e-02f, 6.20848499e-02f, -1.16737828e-01f, 8.64268318e-02f, -3.16001847e-02f, -5.03543131e-02f, 5.34575917e-02f, -4.92357984e-02f,
  6.94700629e-02f, -6.98516741e-02f, -4.76064570e-02f, 5.80136990e-03f, 4.29492220e-02f, -2.82844305e-02f, -9.44472402e-02f, -4.87367623e-02f, 2.30042748e-02f, -1.06254719e-01f,
  -5.25082313e-02f, 3.46195906e-01f, 2.21145064e-01f, 1.59382045e-01f, -8.20384547e-02f, -2.83135265e-01f, -1.31073534e-01f, 7.71290138e-02f, -1.13022514e-01f, 7.02697933e-02f,
  -2.50093430e-01f, 3.33930373e-01f, -1.33432522e-01f, 1.99832693e-02f, -3.32982451e-01f, -1.70107126e-01f, -1.06027350e-01f, -1.31108249e-02f, 1.12207361e-01f, 1.04584053e-01f,
  1.17043927e-01f, -4.15755361e-02f, 1.39321789e-01f, 8.06704238e-02f, 1.80676788e-01f, 2.14524314e-01f, 2.06207950e-02f, 5.96150570e-02f, 1.16647847e-01f, -6.90415725e-02f,
  9.40662995e-03f, 1.21234924e-01f, 1.57220453e-01f, -2.22208165e-02f, -7.81246349e-02f, -5.32896779e-02f, 2.96748802e-02f, -7.99392611e-02f, 2.03827787e-02f, 2.48293742e-03f,
  8.12438577e-02f, 1.27615966e-02f, 6.65946305e-02f, 2.96672676e-02f, -9.75312851e-03f, 8.08912218e-02f, 1.35051578e-01f, 9.71059129e-02f, 1.33687571e-01f, 1.09109491e-01f,
  6.34731650e-02f, 1.47935405e-01f, 5.24054654e-02f, 1.37520512e-03f, 8.42018798e-02f, -2.86253002e-02f, 1.29682375e-02f, -2.38667261e-02f, -1.58599727e-02f, 3.04566342e-02f,
  -3.14394273e-02f, 4.62689847e-02f, 7.18906596e-02f, -2.73341383e-03f, -3.25102508e-02f, -1.42642343e-02f, 3.71251814e-02f, -7.27574304e-02f, 6.64883554e-02f, -6.48127794e-02f,
  -5.26510030e-02f, 8.74276757e-02f, -5.84562011e-02f, -3.37106399e-02f, 4.69751190e-03f, -1.67725440e-02f, 8.41411054e-02f, 9.07499418e-02f, 5.93632273e-03f, 5.77503294e-02f,
  2.98443530e-02f, 1.10201538e-02f, -3.25555988e-02f, -1.22107901e-02f, -5.61963301e-03f, -2.58577708e-02f, 1.08490869e-01f, -1.95524568e-04f, 2.81098168e-02f, -1.22392699e-02f,
  -9.79283601e-02f, -1.61159988e-02f, -1.80871913e-03f, -3.71906795e-02f, 7.49484524e-02f, -1.01580203e-01f, -4.58008349e-02f, 9.92939621e-02f, 4.30471031e-03f, -1.12976313e-01f,
  3.82835045e-02f, -9.57841612e-03f, -4.00423706e-02f, -8.71609226e-02f, -1.32010043e-01f, 9.70173627e-03f, -2.40017846e-02f, -2.29745060e-02f, 5.00600040e-03f, 1.15206875e-01f,
  1.08821198e-01f, 1.14967423e-02f, -6.55919462e-02f, 3.91299240e-02f, -6.81270659e-02f, -1.73442382e-02f, -1.02948835e-02f, 6.00547865e-02f, -4.54878546e-02f, 1.62488744e-02f,
  -7.55284131e-01f, 3.36525291e-01f, -3.89074162e-02f, -1.56795103e-02f, -2.44244814e-01f, 2.50063717e-01f, 2.09591895e-01f, 3.55912745e-02f, -4.48422134e-02f, 2.77039170e-01f,
  8.03703070e-02f, -8.65289792e-02f, 1.25985935e-01f, 2.37841979e-01f, -2.19206795e-01f, 2.97307014e-01f, 1.44695058e-01f, 1.03642307e-01f, 4.38062884e-02f, -1.85351014e-01f,
  -8.34094733e-02f, 5.33872703e-03f, 2.14246750e-01f, 1.60724372e-02f, -1.29396766e-01f, -1.92303836e-01f, -3.89808677e-02f, -4.10976028e-03f, -1.99090987e-02f, -1.90883800e-02f,
  -9.65623632e-02f, -3.16321313e-01f, -2.15663627e-01f, -1.05283931e-01f, -8.96053240e-02f, 2.25908924e-02f, -7.61080310e-02f, -4.08030972e-02f, -9.10993069e-02f, 1.67936576e-03f,
  2.61593889e-03f, 1.23389373e-02f, -3.06175519e-02f, -3.84447444e-03f, -1.76211912e-02f, 4.80290130e-02f, 3.33619267e-02f, 8.10637176e-02f, 2.56290864e-02f, 1.89660229e-02f,
  4.96997237e-02f, -1.51315350e-02f, -4.16918807e-02f, 8.35959911e-02f, 4.43881117e-02f, 1.00928694e-01f, 6.63630366e-02f, -2.56198589e-02f, -1.50497141e-03f, -6.23604842e-02f,
  -8.34440887e-02f, 7.95521289e-02f, 4.57729399e-02f, -7.79022947e-02f, 2.55096685e-02f, -9.66039076e-02f, -1.78892277e-02f, -8.09746981e-02f, 2.11135875e-02f, 4.70752530e-02f,
  -4.93639968e-02f, -4.93358485e-02f, -8.25988203e-02f, 7.72342607e-02f, -2.46900693e-02f, -1.94520392e-02f, 4.27679494e-02f, -4.71577160e-02f, -3.16762482e-03f, -7.28742033e-02f,
  5.41019179e-02f, -5.00582419e-02f, 4.96211797e-02f, 3.03150080e-02f, 4.07497510e-02f, -2.64214762e-02f, -4.21920605e-02f, -3.01695783e-02f, 7.46596325e-03f, -9.92005691e-02f,
  -2.66190290e-01f, -3.18725139e-01f, -1.12660713e-01f, -9.09024626e-02f, -7.64970556e-02f, -7.68571049e-02f, 4.46933471e-02f, -1.12512156e-01f, -7.03964233e-02f, -5.61368912e-02f,
  -3.44878137e-02f, -7.84998313e-02f, -3.87850814e-02f, 1.25825657e-02f, 1.50821898e-02f, -3.03807706e-02f, -3.55173163e-02f, -1.28826415e-02f, -9.09248516e-02f, 3.58963162e-02f,
  -6.86011985e-02f, -3.47458795e-02f, -9.85781383e-03f, -2.11945083e-02f, -2.31179092e-02f, -5.30587658e-02f, -1.56455308e-01f, 4.11733873e-02f, -7.96244144e-02f, 2.36506872e-02f,
  -2.61351138e-01f, -1.75542124e-02f, 1.95036873e-01f, -3.85484934e-01f, 1.22593924e-01f, 7.09020197e-02f, -3.16586941e-01f, 3.66509147e-02f, -2.60441035e-01f, -2.17737496e-01f,
  -1.81865409e-01f, -7.33219460e-02f, 1.20595843e-01f, -2.60318577e-01f, 2.43748888e-01f, 2.08640382e-01f, -3.01065981e-01f, -1.93183959e-01f, 1.90071240e-02f, -2.57211149e-01f,
  -7.23994523e-02f, -1.57891706e-01f, 1.75248504e-01f, 9.86393169e-02f, -2.18736142e-01f, -1.15291812e-01f, -1.51199356e-01f, 2.19653532e-01f, -7.75014460e-02f, 1.80969194e-01f,
  8.59782547e-02f, -1.86423093e-01f, 6.45398870e-02f, 1.33665770e-01f, 9.67620465e-04f, -6.26284978e-04f, -3.21128890e-02f, 9.20951962e-02f, 3.13502625e-02f, -4.25984850e-03f,
  -5.41471653e-02f, -2.21095048e-02f, -8.15731362e-02f, 3.79159413e-02f, -1.34249283e-02f, 3.55770113e-03f, 6.03466444e-02f, 3.95739637e-02f, -3.51399742e-02f, 1.34752691e-01f,
  2.45131999e-02f, 2.25815941e-02f, -3.69297192e-02f, -3.56902741e-02f, 6.06764592e-02f, -1.03898114e-02f, -3.36200893e-02f, -1.77004393e-02f, -2.05965471e-02f, -2.42559370e-02f,
  -8.30577165e-02f, 3.89975635e-03f, 4.85704988e-02f, 2.70960238e-02f, -1.37902983e-03f, 2.94703022e-02f, -2.43534669e-02f, -3.27490866e-02f, 8.13321967e-04f, -4.31060754e-02f,
  3.66929024e-02f, -7.08294511e-02f, -4.93554287e-02f, -6.56893626e-02f, 2.08836831e-02f, -7.65897706e-02f, 6.21297881e-02f, -1.38348797e-02f, -6.32112920e-02f, 3.22390161e-02f,
  2.97307782e-02f, 2.53779329e-02f, -4.60839272e-02f, -6.44032732e-02f, -5.46438657e-02f, -2.33929437e-02f, -1.33325569e-02f, 9.49120801e-03f, -1.28174759e-02f, 5.91529906e-02f,
  -6.72621578e-02f, -2.65746951e-01f, -8.47256568e-04f, 2.82595661e-02f, -9.61369462e-03f, 1.74019411e-02f, 8.17812607e-03f, 5.25028370e-02f, -3.73587981e-02f, -4.86477911e-02f,
  -1.93451811e-02f, -9.54466760e-02f, 6.56823888e-02f, 2.12861039e-02f, -6.32906519e-03f, 5.78928962e-02f, -5.12926318e-02f, -3.25066783e-02f, -5.60993589e-02f, 3.13771367e-02f,
  2.19949870e-03f, -9.40235034e-02f, -6.75161928e-02f, -8.72660875e-02f, -9.33554173e-02f, -9.09116939e-02f, -5.43361083e-02f, -8.91668629e-03f, -1.18768224e-02f, -5.28399721e-02f,
  -4.26611751e-02f, -2.71331221e-01f, -2.81114370e-01f, 4.18285988e-02f, -8.24036077e-02f, 1.48550374e-02f, -2.03483731e-01f, -4.67681699e-02f, -3.23830098e-01f, -9.08000693e-02f,
  9.92335156e-02f, -3.37073468e-02f, -1.71854317e-01f, 4.61825937e-01f, 2.66977280e-01f, 7.88528919e-02f, 2.94152975e-01f, 1.73858628e-01f, 2.61191418e-03f, -1.02872707e-01f,
  1.89769730e-01f, 4.77623343e-01f, 2.23261893e-01f, 3.00306320e-01f, 1.83301196e-01f, 5.26474081e-02f, 1.56260431e-01f, -1.48127764e-01f, 3.82566303e-01f, 2.72510678e-01f,
  9.57311466e-02f, -9.81774703e-02f, -7.41466656e-02f, -2.48069763e-02f, -8.34524333e-02f, -2.49159560e-02f, 6.38565188e-03f, 1.13110013e-01f, 2.10445691e-02f, -7.84790441e-02f,
  -4.80885431e-02f, 5.40764742e-02f, 1.24313712e-01f, 1.65088903e-02f, 2.34345775e-02f, 8.07492621e-03f, -3.39930467e-02f, -7.40232691e-02f, -4.30113487e-02f, 8.87259468e-03f,
  -1.62075654e-01f, 4.99072522e-02f, -5.92364445e-02f, 7.37785473e-02f, -7.79235139e-02f, -6.21740893e-02f, -3.91339138e-02f, -4.64760736e-02f, 1.22442655e-02f, -9.90603957e-03f,
  -2.58874651e-02f, -6.27986118e-02f, -6.54641911e-02f, 6.85172901e-02f, -3.45855877e-02f, 3.89564596e-02f, 3.25021856e-02f, 3.00221443e-02f, -4.68017310e-02f, -1.53070716e-02f,
  -2.61877459e-02f, 2.06932221e-02f, -3.89661305e-02f, -4.53057252e-02f, -3.51024047e-02f, -2.56149527e-02f, 5.65504655e-02f, 3.26399654e-02f, -2.24588215e-02f, 1.17114850e-03f,
  -2.68341284e-02f, 4.77302223e-02f, -1.06589220e-01f, 3.82840782e-02f, 1.79789383e-02f, -6.50788620e-02f, 7.96194077e-02f, -7.50240311e-02f, -8.40873457e-03f, -3.14998738e-02f,
  2.82959286e-02f, -8.95660892e-02f, -4.46324162e-02f, 3.87766249e-02f, -1.97121054e-02f, -3.23269255e-02f, 7.65738860e-02f, 1.73002742e-02f, -4.69715223e-02f, -7.51864091e-02f,
  -1.16818976e-02f, 4.13026996e-02f, -9.40118581e-02f, 2.34988276e-02f, 4.89877500e-02f, -1.51542276e-01f, -4.74240445e-02f, -2.13156957e-02f, -2.70024431e-03f, 2.42824983e-02f,
  -1.31657561e-02f, -7.16779679e-02f, 2.16800105e-02f, -7.44044408e-02f, 7.37931058e-02f, -1.34558501e-02f, -3.12293041e-02f, -8.40598941e-02f, 4.16746140e-02f, 6.58410881e-03f,
  -1.92084461e-01f, 1.66632339e-01f, 1.47683531e-01f, 1.85817391e-01f, -1.82788476e-01f, -1.28041178e-01f, -1.62004128e-01f, -5.14781550e-02f, 3.51158949e-03f, 1.50492549e-01f,
  8.38901624e-02f, 4.15004119e-02f, 7.41186365e-02f, 2.23757491e-01f, -1.38879970e-01f, 1.94895491e-01f, 1.06837139e-01f, 6.41306937e-02f, -3.34909782e-02f, 6.29649758e-02f,
  -3.14699374e-02f, 1.61726132e-01f, 2.57255822e-01f, 1.46076083e-01f, -3.21553871e-02f, 1.84035584e-01f, 1.21127941e-01f, -1.79284364e-02f, 1.17729612e-01f, -1.02573454e-01f,
  7.37276599e-02f, 8.92987251e-02f, 5.28958440e-02f, -5.90936132e-02f, 1.57421976e-02f, -2.37570610e-03f, -1.89031996e-02f, 5.41931093e-02f, -9.30952579e-02f, -2.36164685e-02f,
  -7.00953379e-02f, -6.11313581e-02f, -3.35566588e-02f, 1.86373666e-02f, -5.03559336e-02f, -2.10677516e-02f, 4.03076559e-02f, 2.47048065e-02f, 3.12338397e-02f, -3.11805997e-02f,
  -7.96707720e-02f, -2.92438958e-02f, -2.68320623e-03f, 2.90209930e-02f, -6.47897720e-02f, 1.82225797e-02f, 4.48467843e-02f, -7.39139039e-04f, -2.27412488e-02f, -1.18676141e-01f,
  -1.54115558e-01f, 1.00977113e-02f, -1.71347782e-02f, 5.83138205e-02f, -6.54746667e-02f, 5.61952479e-02f, 2.35774461e-03f, 6.15129061e-02f, -6.46560341e-02f, -7.29139522e-03f,
  -4.23393622e-02f, -7.90577382e-02f, 8.83217994e-03f, -6.87369481e-02f, -1.56420302e-02f, -6.13507964e-02f, -7.72546381e-02f, -7.92057365e-02f, 7.02619553e-02f, -4.18571122e-02f,
  8.11539292e-02f, -4.45437059e-02f, 9.24112946e-02f, 1.50722116e-02f, -7.48936906e-02f, 8.17995295e-02f, 5.36568463e-04f, 2.92061698e-02f, 4.32311818e-02f, 7.41184428e-02f,
  8.26797485e-02f, 3.73603515e-02f, 4.96788323e-02f, -5.61822280e-02f, -2.24767607e-02f, -5.36752446e-03f, 5.92305772e-02f, -2.57149860e-02f, 3.68949883e-02f, 3.29990610e-02f,
  -4.88263406e-02f, -4.16701660e-02f, 6.27691206e-03f, -4.33621630e-02f, 6.94469288e-02f, -7.41241872e-02f, -4.21649367e-02f, -1.36116929e-02f, -3.46545652e-02f, 5.20966910e-02f,
  1.34105533e-02f, 4.09940965e-02f, -5.14000207e-02f, -3.31900306e-02f, -5.71285598e-02f, 2.61869822e-02f, -1.17351776e-02f, 9.12544727e-02f, 2.50953212e-02f, -4.18859087e-02f,
  1.14919208e-01f, 1.04084790e-01f, 1.81059226e-01f, 2.98041443e-04f, -9.55975428e-02f, -4.72596213e-02f, -2.37269282e-01f, -1.83023773e-02f, 5.82601689e-02f, 3.12726572e-03f,
  -9.19200853e-02f, 1.48102030e-01f, -2.69088410e-02f, -9.74097177e-02f, -7.47018680e-02f, -3.92052718e-02f, -7.52868950e-02f, -1.33781597e-01f, -3.88722233e-02f, -9.56558958e-02f,
  -2.53343806e-02f, -2.49621749e-01f, -1.17377065e-01f, -1.06863320e-01f, -1.89859152e-01f, -6.04175553e-02f, -2.63201017e-02f, -4.51225527e-02f, -8.77768621e-02f, -2.58190185e-02f,
  3.58485281e-02f, -7.88302794e-02f, 2.84034386e-02f, -7.58797899e-02f, 5.07009448e-03f, -1.94063839e-02f, -8.36707950e-02f, 1.38468258e-02f, -4.83170785e-02f, -3.97361480e-02f,
  4.55784164e-02f, -7.71271661e-02f, 5.97639643e-02f, -7.21873567e-02f, -7.82115981e-02f, -8.12884013e-04f, 3.16472203e-02f, 6.62124455e-02f, 9.30127781e-03f, 2.18366496e-02f,
  1.07727431e-01f, -6.26062900e-02f, -1.37947360e-03f, 5.24242260e-02f, 6.72105551e-02f, 5.69775142e-02f, 6.51813000e-02f, 3.20843421e-02f, 1.07606566e-02f, -8.05645809e-03f,
  3.24688293e-02f, 1.44136325e-02f, 3.61450352e-02f, 3.71147203e-03f, -4.83423956e-02f, 7.26881251e-02f, 5.82572743e-02f, -4.80736941e-02f, -1.39949089e-02f, -3.10516953e-02f,
  -3.10874656e-02f, -6.30013049e-02f, -4.88996506e-02f, -1.35919107e-02f, 2.17151288e-02f, 7.15118125e-02f, 1.19793834e-02f, 4.70872223e-02f, 7.09960610e-02f, 6.19331151e-02f,
  -2.82111224e-02f, 2.99417274e-03f, 1.91992037e-02f, 5.73162511e-02f, -1.94754917e-02f, -3.88759524e-02f, -3.24609689e-02f, -2.52885837e-03f, -1.94237307e-02f, 1.67932734e-02f,
  -1.08698145e-01f, -1.09433636e-01f, -1.27940267e-01f, -1.40508726e-01f, -1.04436941e-01f, -4.15774174e-02f, 1.23786451e-02f, 2.98657864e-02f, 2.62853764e-02f, -4.36694324e-02f,
  -2.87349839e-02f, -9.03774947e-02f, -7.31124952e-02f, 5.85850924e-02f, -3.68254259e-02f, 1.76215023e-02f, 4.32650708e-02f, -1.36703933e-02f, 5.68382703e-02f, -6.63105324e-02f,
  -5.95778739e-03f, 3.41802686e-02f, 6.54739961e-02f, -2.69015804e-02f, -4.18154635e-02f, -8.53354037e-02f, 5.15312441e-02f, 4.69377823e-02f, -8.98882281e-03f, 1.84309427e-02f,
  -2.60509014e-01f, 1.85402378e-01f, 4.86720400e-03f, -4.25562799e-01f, 7.13932067e-02f, -2.68913060e-01f, -3.38571995e-01f, -1.45936375e-02f, -6.08343072e-02f, -1.59402698e-01f,
  -8.42459127e-02f, -1.38935819e-01f, 1.62140056e-01f, -2.30553791e-01f, -8.20937231e-02f, 2.24291414e-01f, -3.08829308e-01f, -2.36696899e-01f, 1.10097431e-01f, -1.21348009e-01f,
  -4.47684387e-03f, -1.42768666e-01f, -3.05994786e-02f, 1.51037231e-01f, -1.31598905e-01f, -4.79670577e-02f, -1.40559867e-01f, 1.23988926e-01f, -1.82087064e-01f, 6.90964535e-02f,
  -1.75264165e-01f, -6.57930896e-02f, -2.10536927e-01f, -1.07501194e-01f, -1.30983889e-01f, -1.05059408e-01f, -1.29794538e-01f, 4.01047319e-02f, -1.76948085e-02f, 2.28198040e-02f,
  -4.61092517e-02f, 2.34534796e-02f, -7.86213428e-02f, 4.90297861e-02f, 4.12785895e-02f, -1.54275978e-02f, 1.38863642e-02f, -5.81482202e-02f, -5.01655713e-02f, 7.28181675e-02f,
  6.14217781e-02f, -5.61706945e-02f, -1.59208551e-01f, 4.44589145e-02f, -1.26757212e-02f, 1.91368982e-02f, -8.44437107e-02f, 5.22768833e-02f, -4.54772897e-02f, -3.02118193e-02f,
  6.12296909e-02f, -9.93271396e-02f, -1.70932095e-02f, -5.87082356e-02f, 7.41326511e-02f, -4.18296270e-03f, 1.66775249e-02f, 3.43330428e-02f, -6.21962063e-02f, -5.93302818e-03f,
  -7.64256269e-02f, 2.24826559e-02f, 3.64758186e-02f, 5.26468689e-03f, -1.28193825e-01f, -9.78714302e-02f, -2.52805706e-02f, 8.96074064e-03f, 4.52227844e-03f, 2.37570331e-02f,
  -2.78928652e-02f, 3.87018584e-02f, 5.14580198e-02f, -7.35655501e-02f, -8.20812676e-03f, 2.34457683e-02f, -9.33908974e-04f, 1.16253845e-01f, -3.32035236e-02f, -3.92925441e-02f,
  -2.63588250e-01f, -1.60457432e-01f, -8.13698471e-02f, 2.28481349e-02f, -7.35984668e-02f, -7.93064851e-03f, -4.94994223e-02f, -9.42989141e-02f, -5.29020429e-02f, -3.34405005e-02f,
  -9.29493904e-02f, -5.53140566e-02f, -2.59981174e-02f, 9.54936072e-03f, 4.07315493e-02f, -5.18291034e-02f, -8.69793445e-02f, -1.18307099e-01f, -4.45690267e-02f, -2.83807213e-03f,
  -7.56318495e-02f, 4.74317484e-02f, 6.38505071e-02f, -2.63674632e-02f, -2.23185718e-02f, -1.17201105e-01f, 3.15357260e-02f, 8.90785754e-02f, 3.69601771e-02f, 2.01943032e-02f,
  -4.88799326e-02f, -2.73195595e-01f, 2.40329877e-01f, -7.23405629e-02f, 1.41284660e-01f, 2.19259679e-01f, 3.26186746e-01f, -3.53235513e-01f, -4.49047416e-01f, -2.73617089e-01f,
  5.74351810e-02f, -2.20214855e-02f, 3.34094375e-01f, -1.28117159e-01f, 4.35107082e-01f, 2.22014666e-01f, -5.37845455e-02f, 3.72338630e-02f, -1.00713171e-01f, -9.64543745e-02f,
  -7.64572769e-02f, 5.59395459e-03f, 3.01385432e-01f, -1.90488949e-01f, 2.45508235e-02f, -1.62000343e-01f, 9.52765420e-02f, 2.59144604e-01f, -6.78198114e-02f, 1.55730024e-01f,
  -1.37181163e-01f, -1.21501960e-01f, -3.48862521e-02f, -6.75668418e-02f, -7.43910596e-02f, 1.92717295e-02f, 1.47962213e-01f, 2.08741471e-01f, 4.98398487e-03f, -7.74396807e-02f,
  4.26452234e-03f, 1.36646396e-02f, -8.34739506e-02f, -1.17791854e-02f, -7.00561926e-02f, 1.32678170e-03f, -3.99836972e-02f, -1.14630852e-02f, 4.64151846e-03f, 7.52922073e-02f,
  6.00626357e-02f, -4.22632582e-02f, -1.07718352e-03f, -2.12705974e-02f, 9.96648222e-02f, -5.77487350e-02f, 6.83349669e-02f, 1.65508136e-01f, -7.47952908e-02f, -5.80688007e-02f,
  1.05636017e-02f, 9.73526612e-02f, 3.62963304e-02f, -3.42400447e-02f, -5.91502190e-02f, -7.62801096e-02f, -2.12882534e-02f, 8.64534453e-02f, 1.66522819e-04f, -1.69635226e-04f,
  -5.14009744e-02f, 2.02521142e-02f, -3.08040846e-02f, -2.54075844e-02f, -4.75318208e-02f, -2.71868743e-02f, 2.91189626e-02f, -3.29826656e-03f, 9.67922714e-03f, -2.03922652e-02f,
  1.41681805e-02f, 1.30570810e-02f, 3.47831100e-02f, 6.60034716e-02f, -4.13517319e-02f, 1.28489491e-02f, -5.91708235e-02f, -6.34824932e-02f, -2.15872396e-02f, 1.08546741e-01f,
  -2.30642244e-01f, -2.64395118e-01f, -1.56587195e-02f, -5.13436683e-02f, -1.95186548e-02f, -6.54172897e-02f, -4.65500094e-02f, -1.16963252e-01f, 2.22517923e-02f, -7.16422647e-02f,
  -8.06583017e-02f, 2.52464004e-02f, -7.88639188e-02f, -6.26447098e-03f, 2.67954078e-02f, -9.30456966e-02f, 5.20879738e-02f, 1.04308855e-02f, 1.52791142e-02f, -4.71213199e-02f,
  2.64303181e-02f, 5.56360893e-02f, 1.29687950e-01f, 6.08256785e-03f, -2.92583071e-02f, 1.76342577e-02f, 4.50451374e-02f, -3.45098376e-02f, 4.08878773e-02f, 2.70287110e-03f,
  -3.15800190e-01f, -4.52432260e-02f, -1.60642564e-01f, -3.82395029e-01f, 1.81973413e-01f, -2.45861590e-01f, -2.02584729e-01f, 5.52178696e-02f, 3.19773778e-02f, 2.30130747e-01f,
  5.44371791e-02f, -8.02409053e-02f, 8.95025805e-02f, -4.64145809e-01f, -6.53034687e-01f, -2.39300594e-01f, -5.05176425e-01f, -2.98551679e-01f, -6.91923648e-02f, -1.06626991e-02f,
  -2.80063659e-01f, -6.32212088e-02f, -2.91627288e-01f, 3.56236696e-01f, -4.63772230e-02f, 1.31432205e-01f, 2.48564571e-01f, 2.68445075e-01f, -7.13576656e-03f, -7.46079609e-02f,
  -3.81309167e-02f, 9.43302140e-02f, -1.03545254e-02f, 6.22647032e-02f, -7.60599002e-02f, -4.97884192e-02f, 9.26130265e-03f, 5.69288842e-02f, -1.59930568e-02f, -6.74524531e-02f,
  2.96728816e-02f, 1.04593886e-02f, -9.07356739e-02f, 2.18017995e-02f, 8.94183442e-02f, 3.42085585e-02f, -6.08135797e-02f, -6.56832531e-02f, 7.09644184e-02f, -1.54345080e-01f,
  -1.13130912e-01f, -9.40921605e-02f, -1.15752723e-02f, -1.53477374e-03f, -3.25113945e-02f, -3.30721103e-02f, -9.31772031e-03f, -2.57925428e-02f, -1.04695052e-01f, -1.87039543e-02f,
  3.35777998e-02f, 4.12016585e-02f, -2.62295473e-02f, 2.80055013e-02f, 1.83758922e-02f, 6.55356422e-02f, -2.66832653e-02f, -1.32807801e-02f, 6.37499914e-02f, 1.45228682e-02f,
  -1.30346790e-02f, -1.06185637e-02f, 8.56083035e-02f, -3.70918885e-02f, 2.26146448e-02f, 3.85068096e-02f, -2.59783212e-02f, 1.14264429e-01f, -7.91995600e-02f, -4.59123366e-02f,
  3.99853960e-02f, -5.47188111e-02f, 1.84010938e-02f, 7.79917510e-03f, -7.28743076e-02f, 4.87797149e-02f, 5.52770011e-02f, 7.54868099e-03f, -2.15251488e-03f, -4.81936708e-02f,
  -6.58932477e-02f, 6.81629851e-02f, 7.28360116e-02f, 5.06485701e-02f, 6.38727173e-02f, 2.87270080e-02f, 2.13926826e-02f, -9.85774621e-02f, 3.23728547e-02f, -3.51940356e-02f,
  -3.70065793e-02f, 4.85853963e-02f, 4.02681865e-02f, 2.04748604e-02f, 1.67445187e-02f, -3.28978710e-02f, 8.23504999e-02f, 8.40204507e-02f, -6.83786571e-02f, 2.04384960e-02f,
  1.07772402e-01f, 8.30429196e-02f, -3.97089012e-02f, -2.22833929e-04f, -1.66927781e-02f, 1.06798135e-01f, 4.07663127e-03f, 2.33916081e-02f, -4.51858640e-02f, -4.15857397e-02f,
  6.07598685e-02f, -2.03589231e-01f, -7.77408406e-02f, 3.57392460e-01f, 1.37169510e-01f, -1.89762503e-01f, -2.21955612e-01f, 2.11620361e-01f, 5.03376313e-03f, -6.40872866e-02f,
  8.75500292e-02f, -8.15898553e-02f, -2.62876451e-01f, 1.79306597e-01f, 1.19691327e-01f, -3.78963679e-01f, 1.43724650e-01f, -8.00814629e-02f, -1.36640564e-01f, 2.34771684e-01f,
  2.78415114e-01f, 1.77178264e-01f, 2.86391348e-01f, 2.51455516e-01f, 8.16948190e-02f, 1.80936411e-01f, 3.62795442e-01f, 4.49736938e-02f, 2.61106551e-01f, -1.03750909e-02f,
  -8.01397562e-02f, -3.65959629e-02f, 9.10348259e-03f, -8.34901109e-02f, 6.27598092e-02f, -8.34588241e-03f, -7.25325895e-03f, -8.17279071e-02f, 3.05497982e-02f, -2.18322724e-02f,
  -7.20387325e-02f, 3.61744910e-02f, -1.14761274e-02f, -2.39185560e-02f, 6.62894687e-03f, -1.82072108e-03f, -3.57252620e-02f, 6.79497514e-03f, -3.65867130e-02f, -4.46360372e-02f,
  -1.84933860e-02f, -3.07706613e-02f, 1.54809989e-02f, -9.82034504e-02f, -8.13759565e-02f, -5.09633869e-02f, -8.14145878e-02f, -9.00087412e-03f, -2.59633958e-02f, 2.80144941e-02f,
  -3.79060209e-02f, -3.76098268e-02f, -9.96626448e-03f, 7.49449385e-03f, -3.96029241e-02f, -2.05188952e-02f, -1.79728083e-02f, -3.01286764e-02f, 2.89455485e-02f, 3.84151526e-02f,
  5.46418205e-02f, 6.33322820e-02f, -3.46999913e-02f, 5.30190989e-02f, -3.92006636e-02f, -6.17464222e-02f, 2.99363416e-02f, -1.48791717e-02f, 9.41813886e-02f, 9.22994781e-03f,
  -6.01295792e-02f, 5.29227369e-02f, 6.33012056e-02f, -5.42807998e-03f, -6.51521012e-02f, 6.54864013e-02f, 2.05638018e-02f, -8.37147385e-02f, 4.89261411e-02f, -1.26790758e-02f,
  -8.45782738e-03f, 1.34674862e-01f, -6.07497916e-02f, -2.57177781e-02f, 7.12431371e-02f, -6.49533942e-02f, -3.22776884e-02f, -7.23838136e-02f, 6.07494731e-03f, -8.68451875e-03f,
  1.09380327e-01f, 6.58927709e-02f, -1.93583947e-02f, 6.46256208e-02f, 9.31461155e-02f, 7.46907070e-02f, 1.01881899e-01f, 7.79436007e-02f, 1.03146240e-01f, 6.51386976e-02f,
  5.80297783e-03f, -4.17633131e-02f, 4.79536839e-02f, 4.06214967e-02f, 4.60063331e-02f, 3.93074416e-02f, 1.21700093e-02f, 9.76062417e-02f, -6.80828914e-02f, -2.23121978e-02f,
  1.07420385e-01f, -2.31592834e-01f, -5.24217725e-01f, -2.58636445e-01f, 3.47037226e-01f, 3.28054011e-01f, -7.00154528e-02f, -4.08416837e-02f, -3.15512449e-01f, 2.38154784e-01f,
  3.01194757e-01f, -2.19276905e-01f, -3.29392284e-01f, 1.36655062e-01f, -1.28960222e-01f, -2.69674093e-01f, 2.02378228e-01f, 1.03168637e-01f, -1.20241381e-01f, 2.38195509e-02f,
  -6.95720091e-02f, 3.55960786e-01f, -2.66102821e-01f, 2.05046684e-01f, 2.33331755e-01f, -1.02597468e-01f, 2.22844690e-01f, -1.59202203e-01f, 2.66478181e-01f, 6.49290010e-02f,
  4.32427134e-03f, -8.63481760e-02f, -8.99307579e-02f, -5.04484922e-02f, 9.19883922e-02f, 1.79737985e-01f, 5.66995069e-02f, -7.73402229e-02f, -3.93283404e-02f, -2.63143573e-02f,
  -5.31757511e-02f, 8.93660728e-03f, -2.50595398e-02f, -3.11094373e-02f, 7.56100789e-02f, 4.77866875e-03f, -7.29748234e-02f, -4.45338897e-02f, -6.06367402e-02f, -3.65917869e-02f,
  -1.16705060e-01f, 5.06618656e-02f, 3.97108905e-02f, 1.45290541e-02f, -2.68542413e-02f, -1.81406550e-02f, 5.05294763e-02f, -5.77217937e-02f, 1.14210658e-01f, -1.17867626e-02f,
  8.76894072e-02f, 3.67946699e-02f, -2.48402590e-03f, -5.50602116e-02f, 6.65597618e-03f, -3.53784077e-02f, 4.04101945e-02f, -3.48786600e-02f, -3.51956747e-02f, 4.52463068e-02f,
  3.04073691e-02f, -2.00467110e-02f, 5.02711646e-02f, 9.50907916e-02f, 9.98138934e-02f, -5.08597046e-02f, 6.54640049e-02f, -2.10035946e-02f, 3.12188989e-03f, -2.83158273e-02f,
  -5.90635315e-02f, 7.92502090e-02f, 1.79377813e-02f, 1.12625975e-02f, 1.17672952e-02f, -4.03358825e-02f, 2.47965679e-02f, 2.75592264e-02f, -7.25420043e-02f, 2.09307577e-02f,
  1.44434813e-02f, 3.55655551e-02f, -1.12194501e-01f, -8.03583562e-02f, -4.89219390e-02f, 1.12995632e-01f, -3.44525240e-02f, -2.16929130e-02f, -6.70812130e-02f, -6.57763053e-03f,
  1.56045020e-01f, 5.70077039e-02f, 8.88238177e-02f, -6.73068629e-04f, -2.92870216e-02f, 7.53448680e-02f, -3.92096670e-04f, 1.28548639e-02f, 5.14797121e-02f, 4.52545211e-02f,
  8.70316625e-02f, 8.19129124e-02f, 2.06325836e-02f, -8.38829018e-03f, 1.81004405e-03f, 7.35980719e-02f, 1.99058708e-02f, -4.82573435e-02f, 2.78327167e-02f, -5.44076338e-02f,
  1.29910395e-01f, -3.60830814e-01f, 2.63435543e-01f, 1.89320177e-01f, 3.69795442e-01f, 2.03972846e-01f, 3.54857534e-01f, 4.02662307e-02f, 1.40153989e-01f, -3.28251898e-01f,
  -1.42171606e-01f, -7.50533715e-02f, -1.43171698e-01f, -3.24991010e-02f, 2.45152473e-01f, -7.08407257e-03f, 7.31078908e-03f, -5.77516668e-02f, 1.72794983e-01f, -5.85669018e-02f,
  6.70488924e-02f, 7.01790536e-03f, 1.30367488e-01f, -6.10661507e-02f, -4.13953438e-02f, -4.61839028e-02f, -1.55399173e-01f, 9.68605876e-02f, -9.88991633e-02f, 2.70507913e-02f,
  4.02385816e-02f, -1.18225157e-01f, -4.19761203e-02f, -4.38532606e-02f, -5.96877225e-02f, 6.49046227e-02f, 2.14803424e-02f, 5.99815473e-02f, 3.22743803e-02f, -2.05695573e-02f,
  -6.16501756e-02f, -4.65817600e-02f, 6.81517124e-02f, -2.77475622e-02f, -2.99213436e-02f, -3.30079943e-02f, 4.49223965e-02f, 1.28313862e-02f, 1.10957175e-02f, 1.21664619e-02f,
  2.14754455e-02f, -4.72122477e-03f, 5.39198006e-03f, -3.22654657e-02f, -4.31209132e-02f, 5.03638908e-02f, 2.70562805e-02f, -6.93205558e-03f, -5.37688285e-03f, 1.13196839e-02f,
  4.01252769e-02f, -2.34957580e-02f, -4.53966595e-02f, -8.59292597e-02f, -9.07694455e-03f, -7.51958862e-02f, 4.34614765e-03f, -4.61835451e-02f, 4.97606024e-02f, 3.61196585e-02f,
  -3.69244032e-02f, -1.04544675e-02f, 1.71547290e-02f, 2.05875058e-02f, 1.84126105e-02f, -9.91126336e-03f, 6.71597794e-02f, -2.45685112e-02f, -8.57777148e-02f, 3.79969762e-03f,
  -9.27231461e-03f, 5.63708916e-02f, -8.81480649e-02f, 5.20325042e-02f, 4.85520810e-02f, -1.58203505e-02f, 1.39614232e-02f, -8.48633125e-02f, 3.72634120e-02f, 7.32049644e-02f,
  -1.96318969e-01f, -2.02044189e-01f, -8.05832669e-02f, -9.25911665e-02f, -9.57784504e-02f, -1.47958487e-01f, 7.25911334e-02f, -4.05286700e-02f, -1.14458673e-01f, 3.57922283e-03f,
  -5.37498444e-02f, 5.24565428e-02f, -6.71722144e-02f, 6.40264377e-02f, -1.92648999e-03f, 4.34239469e-02f, -4.98667918e-02f, -5.68407662e-02f, -5.00648469e-02f, -9.70153362e-02f,
  -1.01157315e-01f, 1.39350398e-02f, 5.65023068e-03f, -6.19197041e-02f, 4.13451605e-02f, -4.71694618e-02f, -3.12692896e-02f, 5.83050735e-02f, -6.22718371e-02f, 4.30085789e-03f,
  3.57280135e-01f, -4.88497883e-01f, 9.25622433e-02f, 1.96501121e-01f, 1.06634773e-01f, 5.04131131e-02f, 3.17185163e-01f, -1.78899780e-01f, -2.39243120e-01f, -4.54984099e-01f,
  1.88841578e-02f, -3.28844376e-02f, -6.03142232e-02f, 6.88774586e-02f, 3.98747206e-01f, -6.58250824e-02f, 7.08630905e-02f, 1.24222012e-02f, -1.20258659e-01f, 6.01930581e-02f,
  2.93160211e-02f, 9.01136547e-02f, 7.07472935e-02f, -1.89733252e-01f, 1.25654876e-01f, -2.06714839e-01f, 6.93650246e-02f, 6.28547817e-02f, 4.07455638e-02f, 7.12531283e-02f,
  9.69279110e-02f, -1.86730251e-01f, 3.60156074e-02f, -1.01710614e-02f, -5.85409999e-02f, 1.07761810e-03f, -2.15177685e-02f, 5.89680597e-02f, 1.08477876e-01f, -2.85066068e-02f,
  4.95729633e-02f, 3.61830927e-02f, 9.69339511e-04f, 1.40782315e-02f, -1.00268777e-02f, -5.73368371e-02f, -9.04219318e-03f, 6.03978429e-03f, -8.51841420e-02f, -7.74625540e-02f,
  -5.19561432e-02f, -3.06506455e-02f, 5.60692661e-02f, -9.32064578e-02f, -5.70670813e-02f, 4.01826724e-02f, -6.56603277e-02f, -2.01118528e-03f, -5.80176003e-02f, -1.02742679e-01f,
  -3.51154655e-02f, -3.88100892e-02f, 3.20467353e-02f, 1.28435278e-02f, 1.51460961e-01f, 8.30462947e-02f, -1.87548995e-02f, -4.83529083e-03f, -4.17439528e-02f, 1.11447465e-04f,
  5.52091487e-02f, -4.17597033e-03f, 5.70474006e-03f, 6.10383488e-02f, -1.61308795e-02f, -2.66744066e-02f, 5.24236225e-02f, 1.23766307e-02f, 4.69154259e-03f, 4.80642505e-02f,
  -3.92857343e-02f, 1.68544352e-02f, 2.61041969e-02f, 2.58566532e-03f, 4.16446803e-03f, 9.05071348e-02f, -7.42912218e-02f, 3.56605574e-02f, -2.19819844e-02f, 1.89813897e-02f,
  -7.09387437e-02f, -3.50482672e-01f, -8.36799666e-02f, -5.03315590e-02f, 1.62688978e-02f, 5.29761948e-02f, -4.93978821e-02f, -1.71757098e-02f, 2.87655517e-02f, -6.03627414e-02f,
  2.92553846e-02f, -2.80241668e-02f, -2.35429313e-02f, 3.24542285e-03f, 2.62618009e-02f, -8.99810567e-02f, -6.54239058e-02f, 1.60290506e-02f, 4.79241274e-02f, 5.61027369e-03f,
  3.70938629e-02f, 2.75268573e-02f, -2.04102378e-02f, -1.54443337e-02f, -1.08167529e-01f, -5.19657992e-02f, -2.57968958e-02f, -2.48716474e-02f, 5.35971522e-02f, -3.21513005e-02f,
  -1.25514073e-02f, -8.39370638e-02f, 7.90580586e-02f, -2.10607439e-01f, -2.38803715e-01f, 8.61975923e-02f, 7.03636482e-02f, -9.87937599e-02f, -6.22671880e-02f, -9.32386378e-04f,
  -2.27719434e-02f, -2.00526044e-02f, 1.73783094e-01f, -1.14502341e-01f, 2.34797701e-01f, 2.40250498e-01f, 8.14086571e-03f, 1.52908564e-02f, -1.53991058e-01f, -2.98928171e-02f,
  -6.19138554e-02f, -1.40597239e-01f, 3.27532813e-02f, -1.86483636e-01f, -4.80409674e-02f, -8.02305415e-02f, -1.42653674e-01f, -2.56268959e-02f, -2.26878691e-02f, 5.21355588e-03f,
  3.96994315e-03f, 5.05775213e-02f, 1.11970967e-02f, 1.00821294e-01f, 9.36187431e-02f, 1.51968701e-03f, 9.78039503e-02f, 9.43798944e-02f, -2.00521369e-02f, -2.90539004e-02f,
  3.02468073e-02f, 5.96735775e-02f, 2.05296557e-02f, -7.30714351e-02f, -1.08481169e-01f, -6.35225549e-02f, -1.17821591e-02f, -8.59621391e-02f, -7.89790321e-03f, -1.01530567e-01f,
  -4.74989973e-02f, 7.49556944e-02f, 3.18965763e-02f, 1.08242081e-03f, -5.57260998e-02f, 7.15428591e-02f, 4.38986486e-03f, -5.89498086e-03f, -3.13769951e-02f, -7.55804917e-03f,
  -4.14435752e-02f, 3.39195528e-03f, 5.51075600e-02f, -9.13484544e-02f, 2.65328102e-02f, -3.27274129e-02f, 3.92404236e-02f, -3.44937742e-02f, 2.22434308e-02f, 2.15905905e-02f,
  6.65920079e-02f, -2.76649036e-02f, 6.53291047e-02f, -5.69872409e-02f, 5.10986783e-02f, -2.58709099e-02f, 5.18801063e-02f, 8.46916996e-03f, -3.26379575e-02f, -3.01678870e-02f,
  -6.08218694e-03f, -5.39681455e-03f, -3.50202317e-03f, 5.83777428e-02f, -7.78403655e-02f, 7.54386857e-02f, 3.59113608e-03f, 4.45870869e-02f, -4.82360460e-02f, 4.22106870e-02f,
  -2.61625033e-02f, 7.76780536e-03f, 8.76560807e-02f, 5.91399185e-02f, 9.68995392e-02f, -7.57329166e-02f, 5.12955636e-02f, -6.08917363e-02f, -7.06618801e-02f, 4.49630022e-02f,
  -6.23294078e-02f, 1.00418188e-01f, -2.40165461e-02f, 2.23086197e-02f, -1.93998159e-03f, -2.27328539e-02f, 9.26296860e-02f, -6.11394122e-02f, -3.76524888e-02f, -7.97498301e-02f,
  6.26325533e-02f, -3.55580524e-02f, 5.76130226e-02f, 5.47435954e-02f, -1.31265316e-02f, 3.61668542e-02f, -2.49203630e-02f, 7.60036483e-02f, -7.31363073e-02f, 7.74088427e-02f,
  -1.01116084e-01f, 3.51600766e-01f, 1.30802497e-01f, 1.21768966e-01f, -1.39158025e-01f, 8.16499516e-02f, 2.26461291e-02f, -1.22860461e-01f, 3.00917454e-04f, 2.15346664e-01f,
  -1.78746700e-01f, 2.14941114e-01f, -2.92571131e-02f, 5.53283431e-02f, -5.41544482e-02f, 3.36043686e-02f, 2.57600099e-01f, 4.01788913e-02f, -6.21836744e-02f, 1.67368744e-02f,
  -5.71180210e-02f, -1.27088711e-01f, -2.44708601e-02f, -1.25889694e-02f, 1.13784984e-01f, 2.84670610e-02f, -9.48071331e-02f, -1.30418509e-01f, 2.15495527e-01f, -4.30940725e-02f,
  -8.47742036e-02f, -6.17525801e-02f, 7.32057691e-02f, 7.68266022e-02f, 2.71460041e-02f, -2.91304793e-02f, 3.58209461e-02f, -7.36543834e-02f, 4.57882620e-02f, -5.71278296e-02f,
  9.05325264e-02f, -1.09232999e-01f, 7.35972375e-02f, -1.08083412e-01f, 5.17094843e-02f, -9.70814750e-03f, 4.40870710e-02f, -3.50248218e-02f, 8.76946151e-02f, -4.60949279e-02f,
  7.23386034e-02f, 8.61752629e-02f, 6.39882833e-02f, 1.38734177e-01f, -1.89425834e-02f, 2.46020500e-02f, 1.11439176e-01f, 4.14498197e-03f, 1.25993878e-01f, 9.79329497e-02f,
  2.45439149e-02f, -1.84048656e-02f, -7.21918419e-02f, -3.06364847e-03f, 2.05859356e-03f, -2.66823714e-04f, -7.36078694e-02f, 6.98409928e-03f, 2.76992153e-02f, 2.04706192e-03f,
  -1.12651773e-02f, 3.11894882e-02f, -9.38584581e-02f, 5.34414165e-02f, 2.04383526e-02f, -7.93504938e-02f, -1.63080227e-02f, -2.47964822e-02f, 7.87162334e-02f, -5.45081086e-02f,
  -6.85692532e-03f, 6.03983067e-02f, -8.15063268e-02f, 1.06566427e-02f, -8.73849392e-02f, -6.05129413e-02f, -1.45455701e-02f, 4.76858951e-02f, -2.10219412e-03f, 6.05341643e-02f,
  1.44854486e-01f, 1.28970250e-01f, -1.04992269e-02f, 4.45587002e-02f, 9.27069318e-03f, -6.87570572e-02f, -3.32238674e-02f, 5.11730183e-03f, 1.20565087e-01f, -2.76350826e-02f,
  3.35648544e-02f, 5.03722616e-02f, -3.75856459e-02f, 1.90139543e-02f, 5.88123500e-02f, 2.65657846e-02f, 7.50144422e-02f, 7.76458010e-02f, -3.85369100e-02f, -7.11781383e-02f,
  -4.43180129e-02f, 5.21252304e-02f, -1.58768483e-02f, -2.72217076e-02f, -4.45404742e-03f, -4.15479345e-03f, 2.07787678e-02f, 2.01302581e-02f, -1.02593619e-02f, 1.87742687e-03f,
  -4.19807099e-02f, 1.13833338e-01f, 1.13874115e-01f, -1.58978067e-02f, -5.00291213e-02f, 1.31095247e-02f, -1.07638314e-01f, 2.71156318e-02f, -5.37540875e-02f, -4.26080748e-02f,
  -4.18016240e-02f, 1.28191216e-02f, 8.42828155e-02f, 8.10469016e-02f, 1.93359300e-01f, 1.14202693e-01f, 1.04798786e-01f, 1.53349787e-02f, 1.91830948e-01f, 9.05825868e-02f,
  3.58058512e-02f, 1.21305540e-01f, 1.88683420e-01f, 4.42367718e-02f, 1.02064759e-02f, 1.10926047e-01f, -3.44022997e-02f, -3.89701389e-02f, -3.25203612e-02f, 1.09240137e-01f,
  7.87834227e-02f, 1.31016284e-01f, 5.40396459e-02f, -1.93567015e-03f, 6.06855564e-02f, -6.51786849e-02f, -7.84462467e-02f, -1.06786549e-01f, 2.42219004e-03f, -1.11551872e-02f,
  -7.70615339e-02f, 9.96869206e-02f, -8.40815622e-03f, 2.49127075e-02f, -8.28243792e-02f, 8.89361501e-02f, -3.25828120e-02f, -2.57437900e-02f, -1.47620251e-03f, 3.86876836e-02f,
  5.18154278e-02f, -9.73833259e-03f, 3.37625155e-04f, 2.48185173e-02f, -3.64664346e-02f, -6.83958828e-02f, 5.41471802e-02f, 2.64272746e-02f, 6.90667555e-02f, 4.33021896e-02f,
  1.25862554e-01f, -7.96830207e-02f, -9.21362415e-02f, -6.35197610e-02f, -2.38243453e-02f, 9.37027708e-02f, -9.31334868e-02f, -1.80716533e-02f, -1.89519320e-02f, -5.26882969e-02f,
  -3.08773275e-02f, -3.79086025e-02f, 4.57937680e-02f, -2.78394558e-02f, 6.56986162e-02f, 1.81449056e-02f, -6.35464713e-02f, 3.36909294e-02f, -1.31491506e-02f, 4.09685150e-02f,
  1.03715509e-02f, 4.00654562e-02f, 6.42006695e-02f, -4.46383767e-02f, 2.87019815e-02f, 2.97486931e-02f, -1.42249698e-02f, 8.30515996e-02f, 5.46813533e-02f, -4.67882641e-02f,
  6.21371269e-02f, 4.07323569e-01f, 8.38538781e-02f, -2.20900774e-02f, 1.94799975e-02f, 4.16568890e-02f, 3.13679827e-03f, 1.06018476e-01f, 7.78284967e-02f, 2.77541112e-02f,
  7.65257282e-03f, -6.75135106e-02f, -1.17402785e-02f, 3.25327925e-02f, 7.33801629e-03f, 8.14203694e-02f, 6.82380944e-02f, -3.11956573e-02f, 8.16548895e-03f, 1.13228746e-01f,
  -5.66273071e-02f, -7.17750471e-03f, -3.37656513e-02f, -1.82670504e-02f, -2.77291518e-02f, -5.50238183e-04f, -1.30028659e-02f, -1.57030337e-02f, 1.06070489e-01f, -3.53906155e-02f,
  -4.74652320e-01f, 2.76132852e-01f, 1.40781417e-01f, -3.04758370e-01f, 1.31208569e-01f, -2.29343120e-02f, 7.71609545e-02f, 9.11337063e-02f, 1.10987313e-01f, 1.95610881e-01f,
  2.03799121e-02f, 6.47562742e-03f, 2.73462564e-01f, 1.90117374e-01f, -3.84000957e-01f, 5.92840509e-03f, -1.50100335e-01f, 1.55191729e-03f, 1.10723920e-01f, -1.12797558e-01f,
  -7.85561353e-02f, 1.04948711e-02f, -4.00902666e-02f, 2.61993527e-01f, 9.61558819e-02f, -6.55266866e-02f, -1.76931247e-01f, 1.30987227e-01f, -1.28960669e-01f, 8.45444947e-02f,
  -9.54530239e-02f, -2.29756404e-02f, 2.62252335e-03f, 7.39930272e-02f, -4.07086089e-02f, -4.89142723e-02f, -5.17600849e-02f, -4.15646099e-02f, -2.24505682e-02f, 6.59712702e-02f,
  -2.19920953e-03f, 6.66001067e-02f, -8.98667052e-03f, 4.20160666e-02f, -4.25837077e-02f, 7.66487345e-02f, -4.10505831e-02f, -4.68464419e-02f, 2.37857141e-02f, 4.91070785e-02f,
  4.60913070e-02f, 4.81426120e-02f, -8.69305688e-04f, -4.97585759e-02f, -1.07663631e-01f, 6.34031668e-02f, -3.40608656e-02f, -4.95255962e-02f, -5.70065938e-02f, -4.63523716e-02f,
  3.27858925e-02f, -5.51934764e-02f, 2.47046053e-02f, -9.35322978e-03f, -2.35944311e-03f, -1.36461137e-02f, 4.69563156e-02f, -6.37583435e-02f, 2.47656293e-02f, 2.29333378e-02f,
  -2.67796107e-02f, 2.79079750e-02f, 5.26398933e-03f, -5.76670021e-02f, -1.97594706e-02f, -3.19599137e-02f, -9.07871947e-02f, -6.01400584e-02f, -2.80723311e-02f, -3.42628583e-02f,
  2.45390311e-02f, 1.45886568e-02f, 7.64407516e-02f, -5.87543659e-02f, 5.19866608e-02f, 4.11585458e-02f, -3.14035360e-03f, -3.52180004e-03f, 1.34067414e-02f, -1.07670084e-01f,
  -2.34219357e-01f, -2.04522744e-01f, 1.64318811e-02f, -1.96782313e-02f, -4.08509001e-02f, -8.27129185e-02f, 2.67033894e-02f, 5.30271344e-02f, -8.73322263e-02f, 1.59888063e-02f,
  -4.84603643e-02f, 1.98143385e-02f, -9.72781330e-02f, -9.23394710e-02f, -7.15811998e-02f, -1.47496387e-02f, -4.97386605e-02f, -1.28258578e-02f, -8.01425241e-03f, -7.35144988e-02f,
  1.92236677e-02f, -1.15842074e-02f, -1.42213572e-02f, -3.04050837e-02f, -8.79123881e-02f, -4.13337648e-02f, -7.96487331e-02f, -6.25859797e-02f, -2.25271229e-02f, 3.15066352e-02f,
  1.77292556e-01f, -3.90640616e-01f, 4.90113832e-02f, 4.26536590e-01f, 2.78184235e-01f, -7.67190903e-02f, -7.49064162e-02f, 1.02425724e-01f, 2.87980497e-01f, -4.18134838e-01f,
  -4.95457426e-02f, -1.69665933e-01f, -3.68946731e-01f, 1.34296134e-01f, 7.37843364e-02f, -1.75411910e-01f, 7.74677992e-02f, -1.40740141e-01f, 9.87557545e-02f, 1.04192756e-02f,
  3.33158523e-01f, 1.39731571e-01f, 1.09925665e-01f, 3.64197418e-02f, 1.83996424e-01f, 1.46971449e-01f, -7.66847208e-02f, -1.49629563e-01f, -8.92777182e-03f, -2.08968781e-02f,
  1.05103493e-01f, 5.33619002e-02f, 6.01652041e-02f, 5.79069108e-02f, -2.59994790e-02f, 5.29395342e-02f, -1.22835645e-02f, -6.49875700e-02f, 4.09372374e-02f, -6.12520017e-02f,
  -9.40568075e-02f, 7.35742897e-02f, 1.03389263e-01f, 4.33060266e-02f, 1.80646151e-01f, 9.62357521e-02f, 6.39236048e-02f, 3.25966105e-02f, 4.66069318e-02f, 4.67921495e-02f,
  7.50449747e-02f, -4.22569178e-02f, 1.21116780e-01f, -4.53913733e-02f, 8.76445174e-02f, 4.77481820e-02f, 1.44354207e-02f, -1.13712400e-01f, -1.58227701e-02f, 5.78731485e-03f,
  -4.54606600e-02f, 2.14120578e-02f, -5.11084609e-02f, 5.18060029e-02f, 9.83488187e-03f, 2.42575072e-02f, 3.80670838e-03f, -1.86223425e-02f, 1.13330530e-02f, -5.24742305e-02f,
  4.00562063e-02f, 5.11642620e-02f, 4.88242507e-02f, -5.26188388e-02f, 5.76681085e-02f, 4.27474640e-02f, -3.01878080e-02f, -6.53429925e-02f, 4.29495685e-02f, 6.53898902e-03f,
  2.60810852e-02f, -1.95611417e-02f, -6.80793673e-02f, -5.22072148e-03f, -7.56315440e-02f, -2.65983641e-02f, -2.34374381e-03f, -3.92782427e-02f, 1.07053118e-02f, -2.40207813e-03f,
  -1.23038210e-01f, -2.67565399e-01f, 1.00655043e-02f, 2.08011437e-02f, -5.57187162e-02f, -9.76798534e-02f, -4.65898849e-02f, 5.25981262e-02f, -7.98669457e-02f, 4.22805585e-02f,
  -5.88841885e-02f, -1.79660786e-02f, -1.05588868e-01f, -5.16790934e-02f, -3.96858379e-02f, -7.83934370e-02f, -1.43868420e-02f, -1.07048061e-02f, -6.92563727e-02f, 2.38061473e-02f,
  4.05714884e-02f, 8.15900788e-03f, -4.78290282e-02f, 4.82226312e-02f, 1.34003423e-02f, -7.23008662e-02f, -2.20057294e-02f, 1.44362301e-02f, -6.84901997e-02f, 6.00696029e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.40741199e-01f, 2.19384015e-01f, 1.80694684e-01f, 2.99157184e-02f, 1.67811498e-01f, 3.66679244e-02f, 2.15226844e-01f, 1.79938868e-01f, 2.39201695e-01f, 3.28819275e-01f,
  4.29149687e-01f, 2.60313481e-01f, 1.08690284e-01f, 6.26057088e-02f, 2.87474573e-01f, 1.58571362e-01f, 2.80296654e-01f, 2.63924956e-01f, 4.65478778e-01f, 3.04900467e-01f,
  1.52852595e-01f, 1.64693475e-01f, 2.37325251e-01f, 1.41171113e-01f, 2.07490742e-01f, 1.34431750e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.03612654e-01f, -9.79443714e-02f, 1.50680646e-01f, 3.20610404e-01f, 4.41539288e-02f, 4.28241909e-01f, 5.45064993e-02f, 1.40242651e-01f, 1.77496359e-01f, -1.63768530e-02f,
  -1.22859418e-01f, -3.01299900e-01f, 1.22863397e-01f, -1.73377246e-01f, -1.48799524e-01f, -1.46622717e-01f, 3.22239995e-01f, -1.39101461e-01f, -1.17165416e-01f, 2.69694552e-02f,
  1.47349387e-01f, 1.90648496e-01f, -2.88130939e-01f, -2.05582619e-01f, -7.55906152e-03f, 2.27291957e-01f, 1.95507959e-01f, 2.00937763e-01f, 2.89299916e-02f, 1.01321511e-01f,
  -6.31874427e-03f, 1.47187725e-01f, 8.80669616e-03f, 6.74452111e-02f, 1.92016233e-02f, -2.62403097e-02f, -1.40153423e-01f, 3.30107331e-01f, -2.83639848e-01f, -1.92109519e-03f,
  2.09044531e-01f, -9.06528011e-02f, -1.48054942e-01f, 8.20466056e-02f, 2.06147015e-01f, -1.18729837e-01f, 2.53551066e-01f, -2.18712673e-01f, 8.43883604e-02f, 2.99057484e-01f,
  -1.35047510e-01f, 1.55016527e-01f, 3.38526845e-01f, -2.57166088e-01f, 1.27696529e-01f, 1.67974785e-01f, -2.67243475e-01f, -1.22729361e-01f, 5.01327077e-03f, -9.84507203e-02f,
  -7.01742470e-02f, -7.13576525e-02f, 7.30663314e-02f, 3.19357485e-01f, -2.08067924e-01f, 4.99636717e-02f, 1.15956031e-01f, 2.75352448e-01f, -3.22523326e-01f, 1.68903470e-01f,
  -2.96862245e-01f, 1.83624011e-02f, 9.82611626e-02f, 1.63754132e-02f, -1.79494366e-01f, 1.01308137e-01f, -3.99502106e-02f, 3.61452177e-02f, -2.70800013e-02f, -3.03104877e-01f,
  2.95975894e-01f, 1.74241066e-01f, 1.03518009e-01f, 1.55416325e-01f, 6.85110614e-02f, 1.11868434e-01f, -2.49098897e-01f, 1.72118902e-01f, -9.33629647e-02f, 2.76517689e-01f,
  3.32228005e-01f, -9.14625302e-02f, -3.15195210e-02f, -9.49380100e-02f, -2.68146843e-01f, 1.32019669e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -4.47230637e-02f, -5.50618432e-02f, -1.74858883e-01f, -9.68804210e-02f, -6.90542087e-02f, 1.42909989e-01f, -9.97081921e-02f, 1.84668247e-02f, 1.50815621e-01f, 3.28630023e-02f,
  2.22676229e-02f, 8.03680196e-02f, -1.49501935e-01f, 4.50424738e-02f, 5.13806865e-02f, -1.35486975e-01f, 7.27432445e-02f, -4.17957678e-02f, -8.37411433e-02f, 1.07531443e-01f,
  -1.40786797e-01f, -1.57994181e-01f, -2.81694457e-02f, -8.73526186e-02f, -1.38258070e-01f, 4.27235365e-02f, -1.33253798e-01f, -3.83310653e-02f, -5.38399182e-02f, -8.64971057e-03f,
  -4.03870568e-02f, -3.63343954e-02f, 4.48654927e-02f, -8.99560899e-02f, 2.81359889e-02f, -5.08155627e-03f, 6.16220236e-02f, -2.08317012e-01f, 3.58674489e-02f, -9.87098366e-02f,
  -1.25491142e-01f, -7.37012997e-02f, -4.62467596e-02f, -3.88431139e-02f, -1.67078972e-01f, -5.89869916e-02f, 2.09331244e-01f, -3.47561836e-02f, -1.93245798e-01f, 6.81081936e-02f,
  5.80644459e-02f, 4.27015796e-02f, 9.57722589e-02f, -1.30699381e-01f, -1.58228889e-01f, 2.31345966e-01f, -1.74959388e-03f, -1.18530542e-01f, 5.32962494e-02f, 1.68315440e-01f,
  1.45575762e-01f, 1.52658835e-01f, -1.58707760e-02f, 1.27242729e-01f, -2.04396009e-01f, 2.63760328e-01f, 4.39813212e-02f, -1.60464868e-01f, 4.20486003e-01f, -3.52584690e-01f,
  1.15166321e-01f, -2.01325014e-01f, -1.09426729e-01f, 1.05910555e-01f, 2.62772262e-01f, 3.09328467e-01f, 2.03559622e-01f, -7.12689385e-03f, 3.51004392e-01f, 2.02227145e-01f,
  2.24858418e-01f, 5.92297316e-01f, 4.14863050e-01f, 1.17073067e-01f, -6.45022765e-02f, -1.92234978e-01f, -3.44870120e-01f, 3.38878661e-01f, 1.21009789e-01f, -2.68955231e-01f,
  6.76037371e-02f, 2.57250927e-02f, 2.41496816e-01f, 3.27231169e-01f, -7.28620915e-03f, 7.52623156e-02f, -8.51160511e-02f, 1.39330417e-01f, -1.47781432e-01f, -1.32427722e-01f,
  4.03311178e-02f, -1.91072211e-01f, -1.63616631e-02f, -1.86977670e-01f, 1.67987734e-01f, 8.11896229e-04f, 2.19854280e-01f, -6.82804734e-02f, 5.88455349e-02f, 1.43375352e-01f,
  -2.78146137e-02f, 8.35319310e-02f, -9.81029421e-02f, -5.39784916e-02f, 1.75078139e-01f, -1.38916308e-02f, 1.81843132e-01f, 1.25761861e-02f, -5.35785817e-02f, -1.25197366e-01f,
  -1.02221802e-01f, -1.26399636e-01f, -1.08746342e-01f, -1.25136614e-01f, -1.32357642e-01f, 1.92336533e-02f, 2.03483015e-01f, -1.00676447e-01f, 3.49782586e-01f, 1.25530168e-01f,
  -8.30196366e-02f, 9.87011865e-02f, 2.28636518e-01f, 2.85337001e-01f, -1.33534223e-01f, 1.53326616e-01f, -1.56172961e-01f, 3.17128040e-02f, 6.99606463e-02f, -9.35869142e-02f,
  -2.20471144e-01f, 9.67973620e-02f, 3.38507481e-02f, 1.10697567e-01f, 4.25262302e-02f, -1.39389783e-01f, 2.00583473e-01f, 6.80597946e-02f, 1.63798138e-01f, 1.96581528e-01f,
  3.04103702e-01f, 2.40662113e-01f, -3.86120617e-01f, 4.55512732e-01f, 2.75583684e-01f, 4.06532325e-02f, -1.51329055e-01f, 2.24260136e-01f, 3.80143702e-01f, 3.36068213e-01f,
  3.06365013e-01f, 1.25767589e-01f, 5.69410389e-03f, -1.35627359e-01f, -1.87897786e-01f, -1.81243047e-01f, -1.77244022e-01f, 3.51421838e-03f, -1.09143980e-01f, 1.52478039e-01f,
  -2.87049234e-01f, -1.68460310e-01f, 3.28263462e-01f, -1.82645749e-02f, 1.06463864e-01f, -6.37668446e-02f, 2.36431971e-01f, 1.06180243e-01f, 3.76477391e-02f, 1.38351426e-01f,
  -4.34974171e-02f, -8.82992223e-02f, 5.17280996e-01f, 1.25917748e-01f, 2.08900928e-01f, 3.53230685e-02f, -8.12491849e-02f, -1.96986333e-01f, -5.32257855e-02f, -4.91319746e-02f,
  4.06542182e-01f, 3.27808768e-01f, 2.00266972e-01f, -3.48864123e-02f, 2.19632104e-01f, -3.26729506e-01f, 1.35503322e-01f, 2.13825062e-01f, 8.14465061e-02f, 1.67213574e-01f,
  8.01610574e-02f, -1.97949931e-01f, 5.34579754e-01f, 6.15751334e-02f, -2.85634965e-01f, 1.77637011e-01f, -1.75014094e-01f, 9.36330333e-02f, -3.54226977e-01f, 6.98097935e-03f,
  -4.20596600e-02f, -6.13610446e-02f, -2.65409231e-01f, -3.34274888e-01f, 6.77078590e-02f, 1.45382211e-01f, 5.45621514e-01f, 2.78799742e-01f, 7.77594969e-02f, 7.97652602e-02f,
  2.46266946e-01f, -1.31725296e-01f, 1.04871877e-01f, 2.25094616e-01f, 3.79142851e-01f, 2.81135559e-01f, 1.35745704e-01f, -1.65233269e-01f, 8.23961645e-02f, 4.88072783e-01f,
  -4.52476963e-02f, 2.74167448e-01f, -1.63809314e-01f, -8.18709135e-02f, 1.90169215e-01f, -9.70713887e-03f, -1.50753975e-01f, 2.67760843e-01f, -3.21971983e-01f, -4.19041872e-01f,
  -8.79920051e-02f, 2.40664750e-01f, -2.30747178e-01f, -8.96628201e-02f, -1.37902096e-01f, 1.97423667e-01f, 5.71659915e-02f, 3.23661685e-01f, 5.30181587e-01f, 5.15900493e-01f,
  6.83983326e-01f, 4.60158028e-02f, -2.42789984e-01f, -1.00037538e-01f, -2.00631723e-01f, 6.67929590e-01f, 2.06383556e-01f, 7.03684092e-02f, 1.51396215e-01f, 1.21169701e-01f,
  -4.36652541e-01f, -9.42386314e-02f, 1.81994364e-02f, -3.15244123e-02f, 5.94631016e-01f, 3.66346203e-02f, -2.61063538e-02f, 1.09640649e-02f, 1.10580392e-01f, -9.47475359e-02f,
  2.34163597e-01f, -2.04494536e-01f, 3.21868092e-01f, -1.09542735e-01f, 8.00166056e-02f, 1.57330513e-01f, 4.72448945e-01f, -4.81008142e-02f, 6.65010929e-01f, 2.46517956e-02f,
  4.07550007e-01f, -2.71822095e-01f, -2.15988412e-01f, 1.41424209e-01f, 3.88280004e-02f, -1.62354127e-01f, -3.86662707e-02f, -1.22663975e-01f, 2.87106782e-01f, 1.18767336e-01f,
  1.39516845e-01f, 2.66705394e-01f, 4.37078297e-01f, -1.07368909e-01f, 2.47072019e-02f, -1.07809395e-01f, 3.45608853e-02f, -1.02316894e-01f, -1.52908608e-01f, -5.25466055e-02f,
  5.58840632e-01f, 2.76817590e-01f, 5.27308822e-01f, 4.82567489e-01f, 2.52331764e-01f, -5.16888127e-02f, 2.25465894e-01f, 2.25989252e-01f, 1.44395322e-01f, -1.08776741e-01f,
  -8.78408626e-02f, 5.00212833e-02f, -2.71841288e-01f, 1.88527852e-01f, -2.53160655e-01f, 2.11972728e-01f, 2.25189328e-01f, 1.06581263e-01f, 3.58282179e-01f, 1.74113944e-01f,
  -8.17691460e-02f, 1.24899514e-01f, 3.95550281e-02f, -2.12749958e-01f, -3.98181453e-02f, -1.85908258e-01f, -2.13193342e-01f, -1.23273946e-01f, -8.31344202e-02f, -4.71903719e-02f,
  -2.78523386e-01f, -1.50112629e-01f, -4.24677469e-02f, -1.69910103e-01f, -2.59418041e-03f, 3.44959706e-01f, 4.56615925e-01f, 4.96446311e-01f, -4.91270423e-03f, 9.86865684e-02f,
  1.78625867e-01f, 5.13230622e-01f, -1.68458596e-01f, 5.08408323e-02f, -1.91715192e-02f, 2.59556592e-01f, 2.07789168e-01f, 1.37886330e-01f, 5.60955890e-02f, 1.97472163e-02f,
  4.88209538e-03f, -1.02125853e-02f, -1.09047256e-01f, -5.94848432e-02f, 3.62517387e-02f, -1.71750799e-01f, 8.81816894e-02f, 3.13080437e-02f, 2.06357777e-01f, -1.40643701e-01f,
  -3.86469103e-02f, -4.91700284e-02f, 2.45892763e-01f, -6.99186418e-03f, 7.07662702e-02f, 1.03464261e-01f, 2.60322262e-02f, 7.25367591e-02f, 1.58683777e-01f, -8.07792321e-02f,
  -2.36235578e-02f, -5.35556786e-02f, -1.27550820e-02f, -1.78314652e-02f, -6.54664412e-02f, 1.06753230e-01f, 4.61527556e-02f, -1.72362313e-01f, 7.47069344e-02f, 2.01324373e-01f,
  -3.95399472e-03f, -1.36593178e-01f, 1.24645606e-02f, 2.12340290e-03f, 1.85168296e-01f, 1.32367238e-01f, -9.88295972e-02f, 1.83271259e-01f, 1.41428798e-01f, -2.19329312e-01f,
  -1.24541953e-01f, 1.35970693e-02f, -1.21124107e-02f, -1.27142489e-01f, 6.81306943e-02f, 2.27880582e-01f, -9.65447277e-02f, 8.10677782e-02f, -6.66101575e-02f, -7.81260952e-02f,
  1.40097722e-01f, -1.51457498e-02f, 1.07138902e-01f, -6.91766962e-02f, 2.35361066e-02f, -1.21262550e-01f, 1.96132168e-01f, 1.00756034e-01f, -6.17712662e-02f, -1.75769672e-01f,
  -1.00805335e-01f, -1.23738818e-01f, 8.66163969e-02f, 2.29142338e-01f, -2.38576420e-02f, 5.71555793e-02f, 1.43736720e-01f, 2.71481723e-01f, 1.96139943e-02f, -2.46158361e-01f,
  -2.04521760e-01f, -4.75098878e-01f, -1.49953604e-01f, -8.86972845e-02f, -2.48458348e-02f, 1.32866636e-01f, 2.04181463e-01f, 1.71332480e-03f, -9.08286273e-02f, 2.43804201e-01f,
  -7.01980665e-03f, 4.80586082e-01f, 4.05639187e-02f, 9.16265771e-02f, 2.39750534e-01f, -1.30935088e-01f, 2.29976878e-01f, -3.20836678e-02f, 6.31654739e-01f, -2.04034120e-01f,
  3.40229958e-01f, -1.44725785e-01f, -7.47238696e-02f, -1.19634271e-01f, 3.77134569e-02f, -1.89669639e-01f, 4.72650051e-01f, -2.62690514e-01f, 1.25166878e-01f, -5.17067648e-02f,
  -1.48498207e-01f, -4.56679203e-02f, 1.68656617e-01f, -6.06991835e-02f, 1.22087270e-01f, -8.92018303e-02f, 1.56052813e-01f, 7.22203478e-02f, 6.53066635e-02f, 1.22754104e-01f,
  6.57880008e-02f, -2.11464558e-02f, -9.92834345e-02f, 9.30544212e-02f, -7.17096329e-02f, 2.65641898e-01f, 3.34983356e-02f, 4.42975052e-02f, -8.31281394e-02f, 6.12774305e-02f,
  -7.75368065e-02f, 1.66056812e-01f, -5.67232743e-02f, 1.19466461e-01f, -2.31164191e-02f, 1.96757242e-01f, -7.09787011e-02f, -1.10564679e-01f, -1.72840104e-01f, -1.31218955e-01f,
  -3.76797654e-02f, 6.67559803e-02f, 1.42335102e-01f, 8.72524083e-02f, 1.33281186e-01f, 7.37084523e-02f, -1.64620101e-01f, -2.78054267e-01f, 2.18843699e-01f, -8.05034414e-02f,
  3.92684853e-03f, -5.48750982e-02f, 4.82719213e-01f, -7.78272077e-02f, 4.34004098e-01f, -1.36099026e-01f, -1.76159903e-01f, 3.93437259e-02f, 1.49640098e-01f, 6.33278582e-03f,
  2.77972110e-02f, -1.86437607e-01f, 2.52141953e-01f, -5.08689396e-02f, 1.14553601e-01f, 1.05596095e-01f, 1.85956165e-01f, -2.21029878e-01f, 5.71659245e-02f, -2.82127887e-01f,
  1.52955800e-01f, 1.09213710e-01f, 3.52746993e-02f, 8.23196992e-02f, 1.33576095e-01f, 7.24904686e-02f, -1.40166253e-01f, -1.72235817e-01f, 3.53529662e-01f, -1.81641996e-01f,
  5.87827079e-02f, 2.40554020e-01f, -1.15050375e-01f, 3.24401438e-01f, 1.07405379e-01f, 6.49877861e-02f, 1.34447724e-01f, -2.00717002e-01f, 1.32082254e-01f, 3.12894315e-01f,
  5.05280867e-02f, -9.08892974e-02f, -1.92160681e-01f, 4.47196215e-01f, -5.11424877e-02f, 2.62505919e-01f, 3.68434668e-01f, 8.02732259e-02f, 4.91835624e-01f, -5.82456365e-02f,
  1.35526448e-01f, -1.00287050e-01f, -1.54828832e-01f, -2.61278063e-01f, 4.25281227e-01f, 3.37221205e-01f, 4.02277112e-01f, 1.08184658e-01f, 4.12224770e-01f, 2.76648879e-01f,
  2.91101318e-02f, 2.19571829e-01f, -3.11078764e-02f, 1.41358227e-01f, 1.78036824e-01f, -1.24839768e-01f, 2.73686409e-01f, 2.05128804e-01f, -7.39525035e-02f, 6.23647094e-01f,
  1.10007435e-01f, -1.50125593e-01f, 1.51901633e-01f, 9.43498313e-02f, 1.77984655e-01f, 5.98765194e-01f, -1.35057211e-01f, -2.74495333e-01f, -3.55254769e-01f, 3.43400568e-01f,
  2.04156339e-01f, 4.88184184e-01f, 1.05252892e-01f, 3.18649560e-02f, 3.71952146e-01f, -2.75676101e-01f, 5.06196581e-02f, -5.63048385e-02f, -1.95271745e-02f, -3.42339039e-01f,
  -4.54564869e-01f, -1.75494954e-01f, 2.51215011e-01f, 4.63591553e-02f, 2.04783395e-01f, 1.49182394e-01f, -5.13593620e-03f, 2.12266594e-01f, -3.02542187e-02f, -8.77637640e-02f,
  -2.78528612e-02f, 1.61233656e-02f, 9.95969325e-02f, 4.01444852e-01f, -3.65538374e-02f, -6.17675036e-02f, 4.05005276e-01f, -1.53080508e-01f, 4.37563986e-01f, 2.96533197e-01f,
  5.98412931e-01f, 8.56205001e-02f, 7.93662667e-03f, -1.00232013e-01f, -2.36097902e-01f, 1.09637091e-02f, 1.08383350e-01f, 1.46092564e-01f, 6.89556748e-02f, -1.86630681e-01f,
  2.68121153e-01f, 1.54102489e-01f, -1.39221996e-01f, 2.00533479e-01f, 4.11289819e-02f, 3.40242714e-01f, 1.86772078e-01f, -3.77031043e-02f, 8.61971825e-02f, 8.75434801e-02f,
  4.72185910e-02f, -7.18255267e-02f, -4.11307588e-02f, -7.33981952e-02f, 8.59969631e-02f, 3.26780975e-01f, -9.46044102e-02f, 2.17937842e-01f, 1.45702824e-01f, 7.08021596e-02f,
  -3.49548347e-02f, 5.70928268e-02f, 1.56224683e-01f, 9.12782028e-02f, -1.25869080e-01f, 2.87064403e-01f, 3.53250764e-02f, 6.77882880e-02f, -1.39618009e-01f, 6.36911318e-02f,
  -2.47378424e-01f, -3.25535908e-02f, -2.32922763e-01f, 1.67228281e-02f, 4.78888825e-02f, -4.15997386e-01f, 1.55199468e-01f, -1.55657336e-01f, -2.26949200e-01f, 3.61812226e-02f,
  1.52185053e-01f, 2.18354404e-01f, -7.12791979e-02f, 1.65278897e-01f, 3.96331623e-02f, 4.79496330e-01f, 1.02041095e-01f, 6.82189345e-01f, 3.81225228e-01f, -1.36521786e-01f,
  5.69000281e-02f, 3.76616508e-01f, -2.03598738e-01f, 3.50057125e-01f, 2.02839166e-01f, -2.37947434e-01f, 1.43751159e-01f, 1.49004966e-01f, 1.28190264e-01f, 1.32529780e-01f,
  1.21125013e-01f, 2.89543308e-02f, 9.73475277e-02f, -8.78383815e-02f, -2.87346169e-02f, 5.33851124e-02f, -3.30866963e-01f, -4.41162378e-01f, 1.85142204e-01f, 1.39806405e-01f,
  9.09490287e-02f, 2.93460041e-01f, -2.69185305e-01f, 1.25112221e-01f, 2.05114409e-01f, -1.10097103e-01f, 4.11256433e-01f, -8.14747661e-02f, 2.66951263e-01f, -1.95312142e-01f,
  1.66193351e-01f, 2.02152357e-01f, 2.56809950e-01f, -1.63752779e-01f, 4.57585692e-01f, 5.22983789e-01f, 2.40938932e-01f, 6.98225051e-02f, -8.47778991e-02f, 7.24862441e-02f,
  1.75150052e-01f, 1.33052483e-01f, -4.16882411e-02f, 2.17774376e-01f, 4.73950177e-01f, 1.99658886e-01f, 4.79855001e-01f, -3.21361095e-01f, 1.43818259e-01f, 3.85979116e-01f,
  -2.16852110e-02f, 5.65074027e-01f, 2.92485744e-01f, -3.36463936e-02f, 1.58426613e-01f, 5.83564490e-02f, 4.39658821e-01f, 7.69107863e-02f, 1.33608028e-01f, 2.40218744e-01f,
  -9.57026407e-02f, 7.41049647e-03f, -4.31845110e-04f, 1.63588464e-01f, -7.39614619e-03f, -3.89711618e-01f, -2.60299355e-01f, -2.36723021e-01f, 4.07045007e-01f, -9.02672783e-02f,
  -3.15199882e-01f, 1.22659586e-01f, 5.89304745e-01f, 2.93288589e-01f, -2.34805420e-02f, -4.29866791e-01f, -1.02678820e-01f, 3.76244009e-01f, 6.31003901e-02f, -1.89211622e-01f,
  -9.11638513e-02f, -1.49630159e-01f, 2.73516834e-01f, -1.28426567e-01f, -6.18437082e-02f, 1.83820203e-01f, -3.96863073e-02f, -2.10776255e-02f, -1.19463429e-02f, 1.21922940e-01f,
  -9.00830105e-02f, 2.04974979e-01f, 4.34254110e-01f, 8.20033997e-02f, -1.81679755e-01f, 1.12015828e-02f, 3.49584639e-01f, 4.78048742e-01f, 2.20905825e-01f, -2.12930501e-01f,
  3.43184769e-02f, 1.51886314e-01f, 1.28924251e-01f, 1.06202461e-01f, -2.29870006e-02f, 1.78094164e-01f, 1.48057982e-01f, -2.96549380e-01f, 5.82380891e-02f, -1.49270073e-01f,
  -2.05617864e-02f, 1.91744640e-02f, -1.21781185e-01f, 7.71957543e-03f, 1.35549486e-01f, -9.35930945e-03f, 4.23840612e-01f, -1.22575089e-01f, -7.48245344e-02f, -1.13544114e-01f,
  3.00384581e-01f, -2.22332209e-01f, 1.83510020e-01f, -4.73452881e-02f, 2.22763836e-01f, 8.50810781e-02f, -9.34956223e-03f, 3.44822854e-01f, 2.22483873e-02f, 1.04817860e-01f,
  9.50068012e-02f, 1.14012033e-01f, -3.35478894e-02f, -1.64778218e-01f, 7.05757004e-04f, -6.38885871e-02f, 5.15069254e-02f, 1.28780967e-02f, -6.78339973e-02f, -1.43184394e-01f,
  6.54673949e-02f, 2.23289937e-01f, 1.86616734e-01f, -5.79421595e-02f, -1.30716652e-01f, 2.24043414e-01f, 3.10959537e-02f, 1.06856786e-01f, 3.45832169e-01f, -9.48123261e-03f,
  8.54270309e-02f, 7.70829096e-02f, -8.35942924e-02f, 1.82002470e-01f, -1.21920042e-01f, 1.48979992e-01f, 6.00010395e-01f, 1.17401473e-01f, -5.31543046e-03f, 2.82870624e-02f,
  6.57898664e-01f, 2.46235579e-02f, 1.92406699e-01f, -2.52017051e-01f, 1.26098514e-01f, -1.44231230e-01f, -4.32653166e-02f, -5.96152283e-02f, -2.07018256e-01f, 1.51354253e-01f,
  3.46050888e-01f, -1.27240524e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -8.56186077e-02f, -1.18222654e-01f, 2.73389459e-01f, 2.08053887e-02f, 1.75838917e-01f, 1.49736971e-01f, 3.65375489e-01f, 2.01627821e-01f, 6.94726780e-02f, 8.96122903e-02f,
  -5.12164668e-04f, 2.05718502e-02f, -8.82196575e-02f, 6.14949055e-02f, -4.10342291e-02f, 1.20069645e-01f, 2.41391197e-01f, 4.50533032e-01f, 2.34175771e-01f, -7.06136972e-02f,
  1.04134068e-01f, 1.88220695e-01f, 3.83557111e-01f, -6.64251670e-02f, 1.94497615e-01f, -1.49650611e-02f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -2.73721069e-02f, -2.24726975e-01f, -3.98596376e-01f, -5.42678773e-01f, -3.61411899e-01f, -3.55246723e-01f, 4.52393331e-02f, 5.49899153e-02f, 2.88342863e-01f, 2.14532539e-01f,
  -1.37453362e-01f, -2.28053719e-01f, 1.85321704e-01f, -5.21483064e-01f, -3.89993012e-01f, 2.98158467e-01f, 1.99603975e-01f, 2.35650614e-01f, -8.18359479e-02f, 5.06817162e-01f,
  6.37626275e-02f, -1.98297091e-02f, -1.94406837e-01f, 3.83321226e-01f, -1.75524741e-01f, -2.07245708e-01f, 6.96492732e-01f, -4.17898893e-01f, -3.11089177e-02f, -7.53418207e-02f,
  -1.43393129e-01f, -2.69977093e-01f, -3.71425971e-03f, 2.71085948e-01f, 4.60291535e-01f, -2.53677666e-01f, -3.48661363e-01f, -2.67301589e-01f, -1.69581786e-01f, -4.93769683e-02f,
  3.43815207e-01f, -3.02857514e-02f, -5.49417078e-01f, -5.07241070e-01f, 5.24859667e-01f, 3.32866162e-01f, 1.43857095e-02f, -5.94421327e-01f, -2.20496312e-01f, 2.26100251e-01f,
  3.91978249e-02f, 9.95766521e-02f, 6.31812541e-03f, -7.63790458e-02f, 4.21548307e-01f, -4.03339177e-01f, 3.74768376e-01f, -1.06926784e-02f, 7.00261071e-02f, -4.07762349e-01f,
  4.12215352e-01f, 1.53472155e-01f, 8.27345997e-03f, 2.33283997e-01f, 1.60520911e-01f, -2.85452157e-01f, -3.06393713e-01f, -6.88764676e-02f, 1.78295285e-01f, 3.61142725e-01f,
  -9.62605104e-02f, 2.20526196e-02f, 1.53235435e-01f, 1.34416409e-02f, -1.91104189e-01f, 1.80487633e-01f, 2.24311635e-01f, 6.51934087e-01f, -2.59537637e-01f, -4.87404287e-01f,
  4.15290236e-01f, -2.01793715e-01f, -2.03227639e-01f, -2.03525454e-01f, 5.71464822e-02f, 2.02233404e-01f, 2.60488003e-01f, -7.35137820e-01f, 3.86281878e-01f, 1.14139214e-01f,
  3.64616930e-01f, -1.90193370e-01f, -4.81454372e-01f, -1.65825859e-01f, -1.54536411e-01f, -2.36852378e-01f, 1.39608383e-01f, -3.88308883e-01f, -1.71581030e-01f, -3.01012605e-01f,
  3.64628255e-01f, -1.89032301e-01f, -8.97364598e-03f, -1.93174910e-02f, -3.93229991e-01f, 1.25848547e-01f, 3.27764064e-01f, 3.77443582e-01f, -1.66363910e-01f, -3.13227862e-01f,
  4.36352640e-01f, 1.95487402e-02f, -2.22256795e-01f, -9.42657962e-02f, 1.51476219e-01f, 7.49860406e-01f, 8.62789452e-02f, 2.06359401e-01f, -5.43207288e-01f, -1.56178519e-01f,
  1.60308510e-01f, -4.44549531e-01f, -1.54337615e-01f, 7.64133781e-03f, -3.33397716e-01f, 2.68273175e-01f, -7.18968809e-02f, 4.54290032e-01f, 7.83573091e-02f, 3.09414595e-01f,
  2.06251830e-01f, 4.09073681e-01f, 2.45865479e-01f, -7.01540485e-02f, -9.27226096e-02f, -1.54590845e-01f, 4.45722230e-02f, -1.23742834e-01f, 5.80427498e-02f, 2.63302803e-01f,
  -4.90377367e-01f, -4.59028751e-01f, -2.62424439e-01f, 3.78390342e-01f, 5.06415546e-01f, 1.48674384e-01f, -1.36506081e-01f, 5.40958829e-02f, -1.74455881e-01f, -3.19862694e-01f,
  -8.60724971e-02f, 4.32176411e-01f, 7.04926625e-02f, -1.44945413e-01f, -7.63669312e-02f, -1.29207177e-02f, 4.10799161e-02f, 5.53826034e-01f, -9.62903127e-02f, 5.40715098e-01f,
  4.23021883e-01f, 4.99801755e-01f, 2.00902238e-01f, 3.13532025e-01f, -3.41067351e-02f, -2.31374323e-01f, -8.48131031e-02f, 1.35477468e-01f, -2.13399932e-01f, -1.19495597e-02f,
  2.11303413e-01f, -2.01828226e-01f, 4.99061406e-01f, -2.02802233e-02f, -3.76938850e-01f, 3.02707292e-02f, -2.78446823e-01f, 1.19310297e-01f, 3.04183848e-02f, -2.46231139e-01f,
  -1.16734400e-01f, -3.25151592e-01f, -2.83014089e-01f, 5.71261168e-01f, -4.54936057e-01f, 2.23264262e-01f, -4.04980391e-01f, -4.11053479e-01f, 1.05417347e+00f, -2.72834480e-01f,
  -2.47068852e-01f, -9.29663479e-02f, 9.79651362e-02f, 2.93333352e-01f, 1.81087509e-01f, 4.82827336e-01f, 2.02206314e-01f, 4.44615215e-01f, -1.31555587e-01f, -5.19070476e-02f,
  -4.25905704e-01f, -1.50922582e-01f, 6.58102095e-01f, 9.91967320e-02f, 4.15948778e-01f, 9.86601055e-01f, -2.89431334e-01f, 8.32535103e-02f, -2.48209193e-01f, 9.56600979e-02f,
  -1.71763614e-01f, -3.40751886e-01f, -1.25925899e-01f, 9.33711529e-02f, -1.48333460e-01f, -1.64296608e-02f, 1.84213780e-02f, -1.18182890e-01f, -4.90444839e-01f, -2.07169093e-02f,
  -4.89895433e-01f, -4.72733796e-01f, -5.57593331e-02f, -2.89800614e-01f, -3.75972748e-01f, -6.00464523e-01f, -2.82262087e-01f, 4.20875311e-01f, 1.94445029e-01f, 2.88132995e-01f,
  -8.48790184e-02f, 5.01300022e-03f, -3.79954278e-01f, -1.86009452e-01f, -2.12310553e-01f, -1.71821699e-01f, -3.46143633e-01f, -3.68653774e-01f, 7.26574481e-01f, -1.24933101e-01f,
  9.56490785e-02f, -1.08373404e-01f, -1.62790388e-01f, -2.14685068e-01f, -1.11910231e-01f, -1.92813396e-01f, -1.84203967e-01f, -1.60429880e-01f, 3.59843642e-01f, 4.53814596e-01f,
  -2.27379307e-01f, 1.79937929e-01f, 1.76068664e-01f, 2.43455917e-02f, 4.85002846e-01f, 5.72014332e-01f, -6.32338151e-02f, 1.01238891e-01f, -2.26096839e-01f, -2.92682469e-01f,
  -3.49211991e-02f, 7.34221935e-02f, 7.42225200e-02f, 3.61121148e-01f, 7.62451410e-01f, 7.01540709e-02f, 6.41428679e-02f, -1.43750757e-01f, -4.07939464e-01f, -4.12788212e-01f,
  -1.33019298e-01f, 1.40328020e-01f, -3.14735132e-03f, -1.26117572e-01f, 2.81403989e-01f, -3.82677734e-01f, 1.09710991e-01f, -1.63371667e-01f, 3.88502568e-01f, -3.55556428e-01f,
  4.01084032e-03f, -1.34668648e-01f, 6.07402444e-01f, 5.09610891e-01f, -4.70414639e-01f, -2.37253159e-01f, 7.74553940e-02f, -3.32006037e-01f, -2.97131449e-01f, -4.77794521e-02f,
  -1.04067847e-01f, 2.85104394e-01f, -1.81001917e-01f, 2.29733720e-01f, -5.66632161e-03f, 9.76448059e-02f, -4.83198822e-01f, 1.46928281e-02f, 1.99149102e-01f, -1.92128375e-01f,
  -3.93062621e-01f, 4.09041226e-01f, -1.38977140e-01f, -3.16760480e-01f, 4.47492361e-01f, -3.33586484e-02f, 1.41770728e-02f, -3.94499391e-01f, 7.73544461e-02f, -5.94588630e-02f,
  5.65741241e-01f, 7.26429760e-01f, -4.88492936e-01f, -4.82385494e-02f, -1.58852842e-02f, -4.58632171e-01f, -4.36766148e-01f, 4.52220231e-01f, 3.92207317e-02f, -1.26425445e-01f,
  1.71225235e-01f, 2.20549047e-01f, 1.32573813e-01f, -5.44513702e-01f, -1.76486790e-01f, -2.91628540e-01f, 1.20752260e-01f, -1.41184945e-02f, -4.73554164e-01f, -2.04830512e-01f,
  -4.70927656e-01f, 3.82891506e-01f, 1.28707051e-01f, -8.25367719e-02f, 6.26209497e-01f, -5.94484687e-01f, -2.49054641e-01f, 8.15110058e-02f, -1.49442554e-01f, 4.39117968e-01f,
  -2.47357279e-01f, 4.26678434e-02f, 2.08123028e-01f, -7.03763545e-01f, 5.80747545e-01f, -1.22298159e-01f, -2.08291471e-01f, 5.96497059e-01f, 4.79833707e-02f, -1.07112586e-01f,
  1.19964629e-01f, -2.07396835e-01f, 1.01915903e-01f, -1.48372471e-01f, 9.01324302e-02f, 9.72786769e-02f, 1.57449558e-01f, -7.01650456e-02f, -5.09867072e-02f, -8.62936825e-02f,
  1.73249587e-01f, 1.04946475e-02f, -3.40366185e-01f, 2.64167964e-01f, -2.74792701e-01f, -4.05106902e-01f, 1.19480647e-01f, 7.00328290e-01f, -2.75008112e-01f, -1.69436634e-02f,
  1.07615158e-01f, -1.66573182e-01f, 8.49075988e-03f, 7.07120717e-01f, 5.33354841e-02f, 9.58251655e-02f, -4.96777117e-01f, -1.45158112e-01f, -3.53042006e-01f, 3.91108170e-02f,
  5.63136101e-01f, -2.67790943e-01f, 3.48594815e-01f, -2.89967030e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  4.09208834e-02f, -4.79961820e-02f, -3.13019514e-01f, -2.41223827e-01f, -1.16212167e-01f, 4.08097804e-01f, 2.62491286e-01f, -1.94337457e-01f, 3.21528204e-02f, 4.86487225e-02f,
  -5.13692908e-02f, 1.91665441e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    