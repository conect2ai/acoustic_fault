/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.25166672e-01f, 4.71885167e-02f, -4.16348517e-01f, -2.21701950e-01f, -8.09722170e-02f, 6.80380911e-02f, -7.62245730e-02f, 5.07902838e-02f, -2.99394280e-01f, 2.68340677e-01f,
  2.62493551e-01f, -4.35818464e-01f, 5.04939966e-02f, 1.67390123e-01f, -3.10780942e-01f, 3.48166227e-02f, 2.39194274e-01f, -2.95272395e-02f, 6.31329119e-02f, 1.47177488e-01f,
  3.94198596e-02f, 3.69207889e-01f, 1.15714641e-02f, 2.88603604e-01f, 5.96329868e-02f, -5.06895743e-02f, 1.27974421e-01f, -4.29683328e-02f, 1.19764574e-01f, 1.10090745e-03f,
  4.64698747e-02f, 1.43680558e-01f, 6.85049966e-02f, -4.63173352e-02f, 7.62333721e-02f, -8.78700987e-02f, -6.66491985e-02f, -9.39117521e-02f, -8.72206837e-02f, -7.27966428e-02f,
  -1.80859547e-02f, 4.60943021e-02f, 7.75180459e-02f, -1.36573181e-01f, -2.50044148e-02f, -7.42816105e-02f, -1.59344971e-02f, 6.31853789e-02f, -3.88871431e-02f, -9.63284343e-04f,
  -3.67172770e-02f, -9.40735266e-03f, 8.37450698e-02f, 5.71401929e-03f, -3.64478789e-02f, 7.54804015e-02f, -1.75161064e-02f, 8.95507634e-03f, 3.27866827e-03f, -3.74764167e-02f,
  1.77117527e-01f, 3.78548820e-03f, -1.03458919e-01f, 6.25888333e-02f, -8.94887745e-02f, 7.84894973e-02f, 1.05714072e-02f, -2.67678518e-02f, 2.71998420e-02f, 6.76728934e-02f,
  -1.38519071e-02f, 6.33883104e-02f, 6.89192712e-02f, 2.06993446e-02f, 6.12485819e-02f, 7.63073117e-02f, -3.72203030e-02f, -1.16919331e-01f, 4.43081707e-02f, -7.48558622e-03f,
  -8.83359313e-02f, -4.10765335e-02f, 3.26218568e-02f, -3.40267047e-02f, 5.39112762e-02f, -8.01104121e-03f, 9.30798352e-02f, 9.07639880e-03f, -5.49014769e-02f, 3.22318412e-02f,
  1.06633760e-01f, -3.73397842e-02f, 9.59418416e-02f, 3.96459326e-02f, -2.54090577e-02f, 9.33440775e-02f, -8.88025686e-02f, 1.48412958e-02f, 7.29126707e-02f, 5.00945598e-02f,
  4.44339514e-02f, -4.42994721e-02f, -2.62742750e-02f, 6.68056086e-02f, 1.69798806e-02f, -1.21126547e-02f, 1.40974624e-02f, 1.06811844e-01f, 7.65195191e-02f, 8.45920891e-02f,
  5.78224249e-02f, 5.85638955e-02f, -1.25240445e-01f, 5.70230074e-02f, 9.43431407e-02f, -3.38656269e-02f, -1.04559623e-01f, -8.38061795e-03f, 2.19152551e-02f, 7.22759366e-02f,
  -7.11849570e-01f, -2.27717817e-01f, -1.22108534e-02f, -1.54302403e-01f, 2.42867589e-01f, 3.76448423e-01f, 7.43989870e-02f, 3.34689580e-02f, -1.26083707e-02f, -6.95855245e-02f,
  7.89705291e-02f, 5.62265515e-02f, 1.98079348e-02f, 1.74320206e-01f, 2.02040821e-01f, 1.60621971e-01f, 9.41120312e-02f, -1.02396071e-01f, 5.85248731e-02f, -1.82075296e-02f,
  1.55067146e-02f, 2.26056010e-01f, -3.55958496e-03f, 1.96464628e-01f, -4.50951327e-03f, -3.74910533e-02f, -5.19673228e-02f, -7.18437061e-02f, -6.77278787e-02f, 1.05308205e-01f,
  6.70650452e-02f, -1.44137710e-01f, 3.44662443e-02f, -2.32719313e-02f, 4.28143330e-02f, -6.92748055e-02f, -2.92326324e-02f, 5.42147160e-02f, -9.00847167e-02f, -6.10850751e-02f,
  -1.19814393e-03f, 2.11539157e-02f, 8.30122903e-02f, 8.45020860e-02f, -1.12595528e-01f, -6.44663721e-02f, 1.94129944e-02f, 4.09707241e-02f, 9.91638750e-03f, -2.12691315e-02f,
  1.27708808e-01f, 6.25749603e-02f, -7.21405074e-02f, 4.33056941e-03f, 9.37655009e-03f, -4.07082960e-02f, 5.86207025e-02f, -3.42692249e-03f, -3.14073749e-02f, -2.54778727e-03f,
  -2.76852548e-02f, 6.97301179e-02f, 3.56477462e-02f, 8.90500192e-03f, 5.73119940e-03f, 6.97682276e-02f, -7.30121089e-03f, 3.07140928e-02f, -9.98749882e-02f, -2.22638473e-02f,
  4.44526486e-02f, -1.18933216e-01f, 3.24485973e-02f, -6.14783242e-02f, -1.70378610e-02f, 9.71264578e-03f, 2.28476692e-02f, 2.87659857e-02f, -1.72320474e-02f, 9.27381497e-03f,
  -1.21349897e-02f, -1.02803754e-02f, 4.79052924e-02f, 1.37845799e-02f, -5.60824480e-03f, 4.69459593e-03f, -3.11969575e-02f, -6.65883999e-03f, 4.96019833e-02f, 9.14142188e-03f,
  -2.42949963e-01f, -2.66948551e-01f, 8.57075527e-02f, -1.89800058e-02f, -2.23887246e-02f, 4.58081327e-02f, 1.10395446e-01f, 5.54873832e-02f, -7.81516135e-02f, 4.21791933e-02f,
  3.28415520e-02f, -5.96267618e-02f, -2.63772570e-02f, -4.22235020e-02f, 5.33208214e-02f, 6.13578781e-02f, 4.23231572e-02f, -4.92818188e-03f, -3.10084429e-02f, -5.57253361e-02f,
  -3.91793102e-02f, -5.92913143e-02f, 4.32379879e-02f, -5.87908588e-02f, -1.08732898e-02f, 3.44504900e-02f, -7.59509578e-02f, -1.60933696e-02f, 5.33454604e-02f, -4.79132645e-02f,
  -2.26060644e-01f, 1.63965479e-01f, 1.62141517e-01f, -2.63543338e-01f, -9.01899412e-02f, -1.27993390e-01f, -8.68424177e-02f, -3.59436776e-03f, 1.35127619e-01f, 1.38459548e-01f,
  -1.55662507e-01f, 4.73984294e-02f, 1.87788680e-01f, -6.22419231e-02f, -3.65255266e-01f, 2.44885832e-01f, -3.19295317e-01f, -5.70380390e-02f, 1.64690673e-01f, -1.90502778e-01f,
  -6.09164052e-02f, -1.34775504e-01f, -4.35856469e-02f, -2.08334439e-02f, 4.77553234e-02f, -1.11881858e-02f, -1.47383541e-01f, 1.23595931e-01f, -1.92213461e-01f, -3.92253809e-02f,
  5.02914563e-02f, 1.00002781e-01f, 3.98061797e-02f, 7.07745999e-02f, -8.26804489e-02f, -3.01263053e-02f, -7.47144818e-02f, 2.20554173e-02f, -5.09687550e-02f, 3.81182879e-02f,
  7.45806247e-02f, 2.99130548e-02f, -2.06114016e-02f, 4.75961119e-02f, 5.90092763e-02f, -5.76990074e-04f, 9.59375873e-02f, -2.41645761e-02f, 6.24402948e-02f, 1.15417100e-01f,
  5.93491308e-02f, 2.52563525e-02f, -1.14340680e-02f, -2.54494231e-03f, 3.97274904e-02f, 2.06750054e-02f, 1.69226322e-02f, -5.29686511e-02f, -1.88585068e-03f, -8.03110190e-03f,
  6.46670386e-02f, -8.50962549e-02f, 3.53177674e-02f, -5.26027903e-02f, -5.98262213e-02f, 2.89341547e-02f, -1.66658945e-02f, -4.64313626e-02f, 1.76996067e-02f, -1.37965130e-02f,
  -9.08234343e-03f, -5.29175140e-02f, 2.06223242e-02f, 5.69178239e-02f, -2.70981016e-03f, -1.29551785e-02f, -4.08791266e-02f, 3.01446170e-02f, -1.69008281e-02f, -2.39464119e-02f,
  4.99742515e-02f, -4.19025309e-02f, -5.96630424e-02f, -2.38101278e-02f, 2.78919260e-03f, 3.46663222e-02f, 8.29863772e-02f, 9.70513821e-02f, 2.10611057e-02f, 4.43664193e-03f,
  -2.58404404e-01f, -1.83968261e-01f, -6.32752404e-02f, -2.76679397e-02f, 2.00257655e-02f, 5.12372032e-02f, -1.03802672e-02f, -9.93052684e-03f, 5.32738157e-02f, 8.82396661e-03f,
  -4.83521027e-03f, -2.51519084e-02f, -3.21983360e-02f, 7.32312119e-03f, -5.30344620e-02f, 1.40290288e-02f, -4.07255292e-02f, -1.62876192e-02f, -1.66408122e-01f, -1.66650489e-01f,
  -3.84278670e-02f, 6.88414648e-03f, 1.96452346e-02f, 2.90155653e-02f, -6.13856614e-02f, -5.65979518e-02f, -7.11093992e-02f, -1.53161297e-02f, -1.46014299e-02f, 6.74876496e-02f,
  -1.70085095e-02f, 1.84990570e-01f, 1.24158360e-01f, 7.64813274e-02f, 1.61978140e-01f, -2.53744656e-03f, -5.36880530e-02f, 1.88290775e-01f, -1.99570414e-02f, 4.09428775e-02f,
  -8.81119892e-02f, -7.21064731e-02f, -2.25427866e-01f, 1.05176561e-01f, -3.51621240e-01f, -2.63932586e-01f, -3.60088497e-02f, -6.46970645e-02f, -1.10253273e-03f, 1.23109862e-01f,
  -1.05828429e-02f, 1.53627815e-02f, -8.89701769e-02f, 1.74609065e-01f, 1.44703224e-01f, 1.16574354e-01f, -1.49654359e-01f, 5.36328256e-02f, 1.62685007e-01f, -6.14994280e-02f,
  -7.88783282e-02f, -6.18857183e-02f, 9.21377987e-02f, 5.78471199e-02f, -5.39173186e-02f, -2.62495577e-02f, 5.40330354e-03f, -2.30845269e-02f, 4.69882600e-03f, -1.84835568e-02f,
  -3.19484323e-02f, 3.77655439e-02f, 3.24985906e-02f, 5.11822775e-02f, 6.59118742e-02f, 8.19680765e-02f, 3.94409373e-02f, -1.59196630e-02f, 8.10582787e-02f, -6.46160692e-02f,
  1.05933808e-02f, 1.42711727e-03f, -1.63615867e-02f, -5.01194932e-02f, -1.97841115e-02f, 5.96384071e-02f, -7.20276758e-02f, -1.15675982e-02f, -1.90255772e-02f, 1.78606715e-02f,
  -1.77251995e-02f, 4.80630323e-02f, -2.99214162e-02f, 7.03171417e-02f, -6.44092774e-03f, 3.16436924e-02f, 1.45844156e-02f, -1.85031723e-02f, 1.29369143e-02f, -3.62002611e-04f,
  -7.10076012e-04f, -1.75221567e-03f, 1.72253828e-02f, 7.95303751e-03f, 2.40050722e-02f, 5.47238439e-03f, -4.35280800e-02f, -2.14845408e-02f, 1.34611037e-02f, 2.81890314e-02f,
  -2.63289344e-02f, 6.07029395e-03f, 5.09802289e-02f, 2.00743657e-02f, 3.57462605e-03f, -4.68207896e-02f, 7.16626421e-02f, -2.19606496e-02f, 3.58129367e-02f, -8.19888264e-02f,
  -5.12478538e-02f, -5.32527082e-03f, 4.96408029e-04f, 1.27226841e-02f, -2.29977467e-03f, 4.50449400e-02f, 6.74756197e-03f, 4.89284173e-02f, -4.78097908e-02f, 1.27329445e-02f,
  1.52317267e-02f, -3.08035668e-02f, -2.61152871e-02f, -1.75120998e-02f, -4.42461111e-02f, -1.60591900e-02f, -6.95869401e-02f, 1.82529949e-02f, -6.22658466e-04f, 4.39644568e-02f,
  -8.91577452e-03f, -3.08423676e-02f, -1.46194929e-02f, 2.26991624e-02f, 8.09483975e-02f, -1.00092039e-01f, 7.69719034e-02f, 1.81530416e-02f, 1.45673482e-02f, 6.88267453e-03f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.83524644e-01f, 2.38697380e-01f, 3.05677682e-01f, 5.63184261e-01f, 2.44187281e-01f, 4.12601799e-01f, 3.98848057e-01f, 2.97597677e-01f, 9.20222819e-01f, -1.84908971e-01f,
  4.02463153e-02f, 2.79773027e-01f, -1.28527164e-01f, 4.04113203e-01f, 2.64639109e-01f, 1.82907134e-01f, 3.92072618e-01f, 3.02262753e-01f, 3.80801022e-01f, 1.78827778e-01f,
  2.68615842e-01f, 2.38963112e-01f, -1.81075603e-01f, -3.39879066e-01f, 1.12048447e-01f, -8.86479989e-02f, -6.12955868e-01f, -1.64210543e-01f, -3.18335205e-01f, 8.60660076e-02f,
  -3.53038982e-02f, 1.96140394e-01f, -4.91456762e-02f, -1.77419856e-02f, 6.67265803e-02f, -1.04885861e-01f, -1.81062967e-01f, -4.74433564e-02f, 3.96578498e-02f, 1.78199243e-02f,
  2.88427640e-02f, -7.82376453e-02f, 8.48789737e-02f, -2.88148653e-02f, 1.95544083e-02f, -2.95860842e-02f, 3.23449969e-02f, 1.00441957e-02f, -3.40473093e-02f, 1.96210109e-02f,
  7.13765323e-02f, -1.34899756e-02f, 4.85922284e-02f, -5.33401966e-02f, 5.41549101e-02f, 1.36381134e-01f, -1.16633149e-02f, 1.67407058e-02f, -6.86823353e-02f, 1.22759789e-01f,
  1.03342049e-01f, 4.22798060e-02f, -5.34468517e-02f, -1.27663746e-01f, -9.44304932e-03f, 8.09726194e-02f, -3.86786424e-02f, -2.73950249e-02f, -2.28861719e-02f, 1.23990895e-02f,
  4.87162992e-02f, 5.36463633e-02f, 1.07991710e-01f, -1.62729248e-02f, 2.11747512e-01f, 1.26877781e-02f, -6.74167201e-02f, -2.05218624e-02f, 8.90772790e-02f, -1.24216741e-02f,
  9.18927193e-02f, -1.03919871e-01f, -7.50159696e-02f, -6.82361573e-02f, -1.84805263e-02f, -1.19180486e-01f, 8.71251076e-02f, 5.67754358e-02f, -2.49711853e-02f, 2.72330828e-02f,
  1.55262515e-01f, 3.28447402e-01f, 6.33733273e-02f, -6.28073364e-02f, 1.22598624e-02f, -8.91716853e-02f, 1.26167238e-01f, 3.80454143e-03f, 8.57120007e-02f, 3.36381719e-02f,
  -7.74196088e-02f, -1.61981750e-02f, -1.01016238e-01f, -5.46285473e-02f, -2.95207109e-02f, -1.74884368e-02f, 2.87980530e-02f, 1.07824787e-01f, 6.83287755e-02f, -6.06090128e-02f,
  -4.88113873e-02f, 7.73175573e-03f, -4.74033244e-02f, -8.63232762e-02f, -2.05379073e-02f, -1.91115931e-01f, -2.32595373e-02f, 5.36398543e-03f, -9.56979915e-02f, 2.07448415e-02f,
  -2.78225332e-01f, 5.00858009e-01f, -2.23965317e-01f, 5.83072841e-01f, -7.78136253e-02f, -6.53104633e-02f, -7.92535394e-02f, -4.21911180e-02f, -3.27523559e-01f, 3.39749068e-01f,
  3.52688283e-01f, -1.48199499e-01f, 7.75814056e-02f, 7.41170764e-01f, 2.17162982e-01f, 1.97696567e-01f, 5.30039191e-01f, 1.65498272e-01f, -6.22961745e-02f, 1.65549070e-01f,
  1.00803770e-01f, 6.44726217e-01f, 3.07761878e-01f, 2.24172801e-01f, 3.46224874e-01f, -1.63799584e-01f, 2.19976544e-01f, -2.08318755e-01f, 4.20062780e-01f, 2.33533397e-01f,
  1.61544457e-01f, 6.45484254e-02f, -1.43796384e-01f, -4.02843729e-02f, -5.80891259e-02f, -5.32660224e-02f, 6.92455377e-03f, -4.33110669e-02f, -1.47584394e-01f, -1.76333025e-01f,
  -1.62457541e-01f, 1.07356664e-02f, 1.06858797e-02f, -1.64440088e-02f, -9.09318104e-02f, -3.81764136e-02f, 2.76658107e-02f, -2.94570369e-03f, -4.64577079e-02f, 5.05208299e-02f,
  -8.82864743e-02f, 1.03889264e-01f, 1.32471129e-01f, 3.51683907e-02f, -1.49158239e-01f, -6.86438754e-02f, -3.46377566e-02f, -4.28132107e-03f, -8.31574127e-02f, -5.69618307e-02f,
  -1.97996888e-02f, -8.20661187e-02f, -7.79815391e-02f, 4.26522009e-02f, 3.36755477e-02f, 7.76408687e-02f, 6.16585650e-02f, 9.58447605e-02f, -1.18756138e-01f, 1.69964075e-01f,
  7.98400212e-03f, -5.85107133e-02f, -4.06097583e-02f, 1.27698230e-02f, 4.45925519e-02f, -5.53190000e-02f, -9.36249718e-02f, 1.23606741e-01f, -1.46723792e-01f, 4.57280129e-02f,
  1.84252158e-01f, -7.85995647e-03f, 3.53666730e-02f, 5.97940497e-02f, -4.17827591e-02f, -3.66767757e-02f, 1.60382763e-01f, -3.59728076e-02f, -9.24079791e-02f, -3.24655324e-02f,
  1.52802855e-01f, 2.22510666e-01f, 2.95862481e-02f, 1.13642411e-02f, 9.03947875e-02f, 3.19124460e-02f, 8.55064839e-02f, -8.19753550e-05f, 2.02540513e-02f, 8.83400887e-02f,
  -5.35881184e-02f, 1.67665891e-02f, 2.82753352e-03f, -1.60807222e-02f, -9.76102501e-02f, -1.57132968e-01f, 4.49459441e-02f, -1.24062793e-02f, 1.18950017e-01f, 7.15391561e-02f,
  1.17642209e-01f, -1.46432882e-02f, -6.36199415e-02f, 5.15016764e-02f, 2.96439826e-02f, -2.88031250e-02f, 7.85784870e-02f, 1.43514173e-02f, 1.37194619e-01f, 1.10966064e-01f,
  -8.02401423e-01f, -1.15477694e-02f, 3.01228642e-01f, 6.44678771e-02f, 1.93143442e-01f, 8.76791060e-01f, 7.95725644e-01f, 3.58736604e-01f, 3.49484563e-01f, 2.59998292e-01f,
  1.30587786e-01f, -6.44270182e-02f, 4.26219516e-02f, 3.01391691e-01f, 2.75526851e-01f, 4.55302410e-02f, 5.37964821e-01f, 2.36273199e-01f, -4.82620485e-02f, 4.30860855e-02f,
  1.60708085e-01f, 7.59631023e-02f, 5.12158684e-02f, -4.03014690e-01f, 5.30635118e-02f, -3.93321931e-01f, -2.64688283e-01f, -1.30429313e-01f, -1.34032816e-01f, -9.52444673e-02f,
  -2.06373096e-01f, -1.17904969e-01f, -8.91078934e-02f, -4.43827659e-02f, 1.14610776e-01f, -5.11154272e-02f, 5.32640666e-02f, -1.98330119e-01f, -1.96096320e-02f, 4.42977734e-02f,
  -5.51334694e-02f, -8.47558379e-02f, 7.78129138e-03f, -8.06900635e-02f, -8.64139944e-02f, 4.40451354e-02f, -8.78387317e-02f, 9.44186151e-02f, 1.00264110e-01f, 5.12241647e-02f,
  1.79034621e-01f, 2.60104053e-02f, 1.12646364e-01f, 9.22093615e-02f, 6.50734454e-02f, -3.25281285e-02f, 7.92888924e-02f, 4.79409993e-02f, -5.97848371e-02f, 2.02832848e-01f,
  5.32669798e-02f, -4.81307693e-02f, 9.26926509e-02f, 2.01385729e-02f, 1.43569335e-02f, -9.64711457e-02f, -8.17234442e-03f, -4.77415584e-02f, 5.94090484e-02f, 1.63189676e-02f,
  -4.68105078e-02f, 4.39195670e-02f, -2.62445165e-03f, 4.42615524e-02f, 1.25886694e-01f, 3.84449288e-02f, -1.49721280e-01f, -1.31143099e-02f, 1.60794631e-01f, 1.00833401e-01f,
  -1.38297677e-01f, -6.99058473e-02f, -4.68540676e-02f, 1.02969259e-01f, 3.15347128e-02f, -6.91698641e-02f, 5.49838990e-02f, -5.02137393e-02f, -8.52387175e-02f, -4.62546460e-02f,
  -4.69378948e-01f, -2.67322332e-01f, -4.86752577e-02f, 6.56774268e-02f, -3.42578478e-02f, 2.41171960e-02f, -7.38645270e-02f, 8.12099874e-02f, -2.63610389e-02f, -4.78907153e-02f,
  1.42323181e-01f, -7.41024017e-02f, -1.90524131e-01f, 3.59999528e-03f, 2.20340472e-02f, 1.39077157e-01f, 6.17314465e-02f, -4.09256332e-02f, 1.25049964e-01f, -1.79551646e-01f,
  -7.47856647e-02f, -1.12781264e-01f, -1.24639813e-02f, -1.80502851e-02f, 1.34246543e-01f, -2.02847999e-02f, -7.61198327e-02f, -8.97397175e-02f, -9.91738737e-02f, 1.47760734e-01f,
  3.62838924e-01f, 2.14290455e-01f, -4.47689682e-01f, -2.52200756e-02f, -3.38973850e-02f, 5.26860058e-01f, 4.26437378e-01f, -1.74553126e-01f, -1.45626292e-02f, 3.36699814e-01f,
  -2.05779463e-01f, -1.23967566e-01f, -2.15200841e-01f, 1.12685509e-01f, 1.40360221e-01f, 5.69247678e-02f, 4.06135142e-01f, 3.44108105e-01f, -1.97086304e-01f, 2.13683024e-01f,
  -1.72449172e-01f, 2.54191726e-01f, -3.57165217e-01f, 3.22102644e-02f, 2.62986690e-01f, -2.39022329e-01f, -2.85390411e-02f, -1.74922705e-01f, -1.86549351e-02f, -1.44210845e-01f,
  -1.75880343e-01f, -3.14288884e-01f, -5.17845266e-02f, 4.02535275e-02f, 1.28256977e-01f, 9.21862647e-02f, -4.70534014e-03f, -2.81116311e-02f, -2.55712628e-01f, -4.25050221e-02f,
  1.24942519e-01f, -1.12401858e-01f, 1.24871813e-01f, -6.51442483e-02f, 6.80457130e-02f, -1.02678932e-01f, -1.53497204e-01f, -1.35163426e-01f, -9.20019969e-02f, -1.13709986e-01f,
  -9.60343033e-02f, -1.69587046e-01f, -4.23356406e-02f, 8.78460482e-02f, -1.01707518e-01f, -4.13012058e-02f, -1.27031906e-02f, -4.87862863e-02f, 1.53237656e-01f, 9.32016447e-02f,
  -3.96886654e-02f, 9.43626314e-02f, 2.19120122e-02f, 2.93343272e-02f, 3.25791053e-02f, -1.18852876e-01f, 6.12964369e-02f, -1.30216733e-01f, 2.07263138e-02f, -7.81840365e-03f,
  5.94262704e-02f, -1.39267191e-01f, 4.37923260e-02f, 8.40373430e-03f, -5.13902232e-02f, -8.32370948e-03f, -3.76850292e-02f, -2.66774613e-02f, -3.22328731e-02f, 1.31489253e-02f,
  -1.11374229e-01f, 5.22599630e-02f, -3.78467813e-02f, 9.88360271e-02f, -1.15149356e-01f, -7.61280581e-02f, -4.68567312e-02f, -1.63254246e-01f, 2.10262109e-02f, 2.00763717e-02f,
  3.32820952e-01f, 4.04501647e-01f, 1.51984533e-03f, -3.29745449e-02f, -5.64098777e-03f, 5.33187687e-02f, 1.31483898e-01f, 1.46201700e-01f, 7.84429982e-02f, 7.21579567e-02f,
  1.33280501e-01f, 9.32099819e-02f, 9.35441777e-02f, -1.14198461e-01f, 5.48105547e-03f, 2.00649768e-01f, 1.33024603e-01f, -2.90765967e-02f, 4.58208472e-02f, -1.40962109e-01f,
  -9.52548236e-02f, 1.30328208e-01f, 1.86863601e-01f, 2.42250739e-03f, 1.86745688e-01f, 6.39138892e-02f, 1.48671061e-01f, -5.75067708e-03f, -1.77152753e-02f, 1.02878204e-02f,
  5.04231393e-01f, -2.12132139e-03f, -3.20154876e-02f, 3.87265593e-01f, -1.51488975e-01f, -9.57641006e-02f, -4.04439628e-01f, 3.60482067e-01f, -3.21079433e-01f, -1.34740546e-01f,
  2.35232949e-01f, -1.63140878e-01f, -3.51928659e-02f, 2.90564716e-01f, 5.87316453e-01f, -2.05109641e-01f, 1.59398615e-01f, -1.75852943e-02f, 3.13173085e-02f, 2.40374729e-01f,
  2.71110386e-01f, 4.51220959e-01f, 2.43926913e-01f, 3.65456998e-01f, 2.55677849e-01f, 3.34852308e-01f, 4.02638227e-01f, 9.52682644e-02f, 4.31732982e-01f, 1.17576979e-01f,
  -1.23148002e-01f, 1.07003659e-01f, -1.27596117e-03f, -6.44792244e-02f, 1.26174629e-01f, 1.22746505e-01f, -1.20068066e-01f, -7.53179044e-02f, -9.51456204e-02f, -6.81148842e-02f,
  1.46257924e-03f, -4.47329544e-02f, -2.67969370e-02f, -7.16750771e-02f, 1.18675672e-01f, -1.42420698e-02f, -7.31419995e-02f, -1.59362674e-01f, -1.77133247e-01f, 6.18138239e-02f,
  7.16233328e-02f, -2.46460531e-02f, 9.44901183e-02f, -8.62989277e-02f, 1.68026283e-01f, 1.60272978e-02f, -1.35991946e-01f, -1.12290941e-01f, -6.77295849e-02f, -6.71022981e-02f,
  1.27629384e-01f, -7.26377442e-02f, 5.76578490e-02f, -1.01741590e-01f, 9.52946767e-02f, -9.97979939e-03f, -7.36567378e-02f, -1.76537544e-01f, 1.56315099e-02f, -1.23305023e-02f,
  5.05110547e-02f, 9.44406353e-03f, 7.72949904e-02f, -1.63839549e-01f, 7.29339346e-02f, -9.62404758e-02f, -7.69773722e-02f, 4.09577116e-02f, 8.27303827e-02f, -5.49350381e-02f,
  -1.02022097e-01f, 3.84379141e-02f, -1.80889964e-02f, -5.74343503e-02f, 2.00591777e-02f, 9.38087627e-02f, 7.15139508e-02f, 1.00330681e-01f, -1.03531145e-01f, -1.00751230e-02f,
  1.51778534e-01f, 3.77876580e-01f, -6.54316396e-02f, -1.56912103e-01f, -1.48511995e-02f, 1.13459714e-01f, 1.11994566e-02f, 1.76820666e-01f, 1.21341638e-01f, -8.58117826e-03f,
  1.39551163e-01f, -1.61381036e-01f, 1.14104398e-01f, 7.32335299e-02f, -6.10782392e-02f, 1.05779275e-01f, 3.05385739e-02f, -1.30336564e-02f, 2.96442714e-02f, 1.38015449e-01f,
  2.47120839e-02f, -7.05961511e-02f, -6.42446578e-02f, -1.59529835e-01f, 7.77604207e-02f, -1.22603007e-01f, -3.08783967e-02f, 4.05212454e-02f, 3.82945165e-02f, -1.11902572e-01f,
  4.29882586e-01f, -1.31056309e-01f, 6.65048599e-01f, 3.25817540e-02f, 2.17248082e-01f, 2.73498654e-01f, 3.35852355e-01f, -1.55584589e-01f, -1.67911306e-01f, -4.33183521e-01f,
  -7.71552995e-02f, 1.33098379e-01f, -1.39397278e-01f, -2.40285471e-02f, 1.36603191e-01f, -1.01694517e-01f, -2.88348347e-02f, -3.34189530e-03f, 1.15020402e-01f, 1.77928180e-01f,
  2.25544423e-01f, -2.26111636e-01f, 3.79519939e-01f, -1.97685156e-02f, 5.46195686e-01f, 9.97241065e-02f, -3.19506973e-01f, 2.73125976e-01f, -5.10217175e-02f, 6.63128216e-03f,
  6.84750229e-02f, 3.19107324e-02f, 1.76735401e-01f, -8.27914700e-02f, 1.17843464e-01f, -7.57030351e-03f, 3.56116407e-02f, 5.07568344e-02f, 3.17747286e-03f, -6.79640770e-02f,
  1.19177110e-01f, 6.79373881e-03f, 4.07380871e-02f, 2.46304809e-03f, 5.28649688e-02f, 2.70651039e-02f, 1.71925694e-01f, 6.82572797e-02f, 3.91645357e-02f, 3.00429195e-01f,
  1.38924167e-01f, 1.83882594e-01f, 1.37304351e-01f, -2.30917465e-02f, 1.54018536e-01f, -6.65810257e-02f, -4.78147268e-02f, 1.75997108e-01f, 7.82047287e-02f, -1.45598292e-01f,
  1.96080387e-01f, 2.45289388e-03f, 3.63848470e-02f, -6.93474188e-02f, 1.38283586e-02f, -8.68574008e-02f, -2.41041705e-02f, -1.30301684e-01f, 1.09743528e-01f, -3.53693105e-02f,
  -8.12420249e-03f, -4.71832119e-02f, 3.01303826e-02f, -7.30456412e-03f, -3.88181582e-02f, -4.41568717e-02f, -9.97218043e-02f, -1.68216988e-01f, 5.29737910e-03f, -1.67606529e-02f,
  -1.24452636e-01f, -1.21058702e-01f, -2.80245319e-02f, 8.04670900e-03f, -4.14900444e-02f, 1.41816691e-01f, -5.39805219e-02f, 3.66394334e-02f, 7.67218471e-02f, 1.61464781e-01f,
  -7.33447134e-01f, -5.28760970e-01f, 2.49119028e-02f, -7.22994655e-02f, 4.67358343e-02f, 1.42194226e-01f, 3.87139129e-03f, 5.15695103e-02f, -1.59922525e-01f, 2.79179867e-02f,
  4.02716501e-03f, -3.62629956e-03f, -5.93694374e-02f, -8.40266943e-02f, -1.24316365e-01f, -7.53702521e-02f, -1.27649844e-01f, -1.59578264e-01f, -1.65943071e-01f, 4.28921217e-03f,
  -6.99686706e-02f, -1.36322781e-01f, -1.02435742e-02f, 7.78745534e-03f, 4.02700454e-02f, -4.14943583e-02f, -6.28106818e-02f, 6.69338042e-03f, -1.35510331e-02f, -3.30104567e-02f,
  7.55381525e-01f, -4.40535426e-01f, 1.02468275e-01f, 6.18293822e-01f, 4.81773913e-01f, -4.52057272e-02f, -8.59547555e-02f, 3.32108825e-01f, 2.94880331e-01f, -5.32013059e-01f,
  6.87767416e-02f, -4.63681877e-01f, -4.39032197e-01f, 2.21653849e-01f, 5.08576632e-01f, -1.44268766e-01f, 5.45435488e-01f, 1.46637456e-02f, 4.18723039e-02f, 3.09925139e-01f,
  3.09992790e-01f, 5.93897820e-01f, 1.20240055e-01f, 1.66183144e-01f, 3.79173964e-01f, 2.54577994e-01f, 2.14253306e-01f, -1.61976889e-01f, 1.81529209e-01f, 1.11709358e-02f,
  2.01857209e-01f, 4.02186662e-02f, -1.94292944e-02f, -6.65681809e-02f, 5.67607507e-02f, -8.27761590e-02f, -1.72506675e-01f, -3.71369766e-03f, 9.04320255e-02f, 1.33261811e-02f,
  -6.24965616e-02f, 1.47279352e-01f, 1.59998253e-01f, 6.86089993e-02f, 7.86551908e-02f, -7.27526322e-02f, 2.57609263e-02f, -4.33840305e-02f, -5.11607062e-03f, -1.95493959e-02f,
  -1.63716137e-01f, 8.74116644e-02f, 1.54459298e-01f, -4.22043130e-02f, -2.95559298e-02f, 8.50827768e-02f, -4.44199443e-02f, -1.99142054e-01f, -7.00215623e-02f, 9.16358605e-02f,
  1.48324361e-02f, -5.28445505e-02f, -6.62327334e-02f, 1.22896463e-01f, 1.50965517e-02f, -2.04982758e-02f, 1.94060022e-03f, -1.10532477e-01f, -8.33839998e-02f, 7.02859368e-04f,
  1.03941098e-01f, 3.04727927e-02f, 1.89980455e-02f, 1.72510725e-02f, -1.18041364e-02f, -8.22671056e-02f, 3.76009978e-02f, -3.30171250e-02f, -7.38901347e-02f, 7.19776750e-02f,
  -4.06998806e-02f, 1.14521414e-01f, -4.48723175e-02f, 5.23284748e-02f, -4.94536348e-02f, -1.13478772e-01f, 1.00546312e-02f, -1.48643628e-01f, 5.75250126e-02f, 5.41147888e-02f,
  -1.75822154e-01f, -2.70029217e-01f, -8.89890194e-02f, -4.66742506e-03f, -9.05634463e-02f, -7.66090257e-03f, 8.44464526e-02f, 4.19125333e-02f, 8.27649161e-02f, 1.60924375e-01f,
  -9.94080957e-03f, 5.43854982e-02f, -3.39594558e-02f, 1.34438366e-01f, -2.91143432e-02f, 2.38380637e-02f, -2.16646697e-02f, -1.01479486e-01f, -1.44897392e-02f, -9.38353315e-02f,
  -1.13423951e-01f, -1.22215249e-01f, 7.67475218e-02f, 1.67086974e-01f, 3.79806943e-02f, -1.80027112e-02f, 7.88883343e-02f, -2.04332098e-02f, 2.55210828e-02f, -3.29831317e-02f,
  -1.71772048e-01f, 1.27916425e-01f, 1.35475889e-01f, 2.25199446e-01f, 2.04531863e-01f, -3.61878812e-01f, -1.05956085e-01f, 2.75783300e-01f, -3.49719822e-01f, 1.90934539e-01f,
  -6.56141341e-03f, -4.37559411e-02f, 5.98579831e-02f, -4.56378669e-01f, -4.70339298e-01f, -4.91995841e-01f, -1.51114285e-01f, -1.45295843e-01f, -2.56081790e-01f, 2.43810147e-01f,
  8.77238512e-02f, 5.41077480e-02f, -5.40928170e-02f, 3.07155222e-01f, 2.88966686e-01f, 4.75961655e-01f, 5.41799784e-01f, 1.41273946e-01f, 3.54363948e-01f, -1.95368901e-01f,
  -1.92742795e-01f, -5.44768833e-02f, 1.06300466e-01f, -3.32167633e-02f, 1.46238491e-01f, 1.55182362e-01f, 5.45441657e-02f, -3.22445966e-02f, -1.64866168e-02f, -2.20208615e-02f,
  -5.69490083e-02f, -1.54731832e-02f, -1.23884439e-01f, -3.87500180e-03f, -7.66237006e-02f, 2.01584548e-02f, 1.06039964e-01f, 4.19271924e-02f, -3.79575812e-03f, 6.41045794e-02f,
  1.34581745e-01f, 6.45295754e-02f, 2.80345231e-01f, 2.84565426e-02f, 4.73774783e-02f, 3.44345858e-03f, -5.71231125e-03f, 9.46729165e-03f, -1.28299315e-02f, -1.51618114e-02f,
  1.45602720e-02f, 6.71693310e-02f, -1.38656929e-01f, -8.96605700e-02f, -3.42255160e-02f, 4.57917787e-02f, -5.45182265e-02f, -2.25518215e-02f, -4.15164093e-03f, 2.25559343e-02f,
  4.15522084e-02f, 6.11181855e-02f, -1.38230488e-01f, 3.15963589e-02f, 7.10861087e-02f, -5.43140583e-02f, -9.08920355e-03f, 3.44084315e-02f, 3.55016813e-02f, -2.52991337e-02f,
  -9.17634591e-02f, 2.60855928e-02f, 6.04640618e-02f, 8.03111568e-02f, -1.50811598e-01f, 1.57003507e-01f, 8.21627676e-02f, 4.11680043e-02f, -7.90200382e-03f, 6.56828284e-02f,
  9.18119624e-02f, 4.02019262e-01f, 6.81073666e-02f, -4.31190133e-02f, -3.26721929e-02f, -1.85932040e-01f, -1.20657675e-01f, 6.12194836e-02f, 8.03088024e-02f, -2.95272935e-02f,
  2.28322044e-01f, 6.44098744e-02f, 4.44657840e-02f, -6.85590282e-02f, -6.17213883e-02f, 4.32002470e-02f, 3.68566625e-02f, 9.46952999e-02f, 1.05833896e-01f, 9.71112400e-02f,
  1.48565575e-01f, 1.03694638e-02f, -8.96975994e-02f, 4.74925227e-02f, 8.28964412e-02f, 7.49829337e-02f, -2.02390775e-02f, 1.17763698e-01f, 7.66769843e-03f, 6.16867021e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  9.82432663e-02f, 2.54860431e-01f, 7.24088371e-01f, 2.43571103e-01f, -6.20739460e-02f, 7.11301088e-01f, 3.53823930e-01f, 4.30772066e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.66088426e-01f, 5.99145174e-01f, 3.99326414e-01f, -6.91722259e-02f, 2.03832388e-01f, 3.78997400e-02f, -6.99745238e-01f, -1.00106800e+00f, 3.11855912e-01f, 1.16598206e-02f,
  1.16251983e-01f, 2.72382945e-01f, -4.66095395e-02f, -4.15264294e-02f, -3.07041705e-01f, -9.51214433e-02f, 3.58967856e-02f, -2.19005078e-01f, -3.98332268e-01f, 6.10617399e-02f,
  6.76867589e-02f, 3.77947301e-01f, 5.19672751e-01f, 7.86038220e-01f, 7.25352094e-02f, -1.90337181e-01f, -6.39743581e-02f, -3.81922215e-01f, -2.58856893e-01f, 7.21097365e-02f,
  5.10499775e-01f, -1.02030471e-01f, 2.59328038e-01f, 2.43273363e-01f, -4.00673822e-02f, 3.54547977e-01f, -8.88282806e-02f, 2.24661920e-02f, -2.82979161e-01f, -1.63163245e-01f,
  4.27195393e-02f, 3.51319045e-01f, 6.04674928e-02f, -4.63875644e-02f, 2.97597677e-01f, -2.40364641e-01f, 4.56803888e-01f, -2.95662880e-01f, 1.15911998e-02f, -2.90408641e-01f,
  3.14711958e-01f, -2.30646178e-01f, -4.18366790e-01f, -5.99941790e-01f, 4.47639748e-02f, -5.00864327e-01f, 9.20579880e-02f, -3.26831013e-01f, -2.20729321e-01f, 1.93931431e-01f,
  7.55663903e-04f, 4.94476259e-01f, 9.21028703e-02f, -1.50113851e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  9.24021676e-02f, -1.38358371e-02f, 3.23903710e-01f, 5.81234992e-01f, 9.39468741e-01f, 7.96265841e-01f, 3.00174117e-01f, -2.36291647e-01f, -5.31579971e-01f, 1.00560236e+00f,
  1.11165524e+00f, 2.38969341e-01f, 6.48218155e-01f, 1.45171136e-01f, 3.13413918e-01f, -4.17592317e-01f, 9.87992585e-02f, 2.83176810e-01f, 7.12161243e-01f, 2.98475474e-01f,
  -5.82574248e-01f, -9.55302119e-01f, 4.65186909e-02f, 1.18963766e+00f, 7.90528119e-01f, -7.82786086e-02f, -7.58909881e-02f, 4.45691794e-01f, -2.74994671e-01f, 1.16905272e-01f,
  -4.33986872e-01f, 8.76626134e-01f, 5.03841877e-01f, 3.50736648e-01f, 5.83228469e-01f, 3.49057943e-01f, -7.72339821e-01f, 3.42290759e-01f, -3.41049507e-02f, -3.39128114e-02f,
  2.35027492e-01f, -3.60881656e-01f, 3.07724625e-01f, -6.46099865e-01f, -4.55359638e-01f, 8.37886751e-01f, 9.78830814e-01f, 4.24752720e-02f, 1.11508131e+00f, 4.76736248e-01f,
  -7.41106749e-01f, 6.45431459e-01f, 6.51165605e-01f, 5.27272522e-01f, 4.42533672e-01f, 1.02323806e+00f, -1.58345640e-01f, 4.35840160e-01f, 6.56813532e-02f, -6.92040682e-01f,
  5.05163848e-01f, 4.15670499e-02f, 9.28377450e-01f, 5.32214642e-01f, 2.70027012e-01f, 3.31486374e-01f, 1.09797275e+00f, 4.31032896e-01f, -4.11484748e-01f, 2.01468244e-01f,
  8.46519619e-02f, -9.87426400e-01f, -3.22752029e-01f, 1.85661405e-01f, 5.22122979e-01f, -6.70087561e-02f, -6.72805548e-01f, 8.83780658e-01f, -3.73402715e-01f, -3.78089666e-01f,
  6.31322563e-01f, 8.96056294e-01f, 1.23637132e-01f, 5.13737619e-01f, 6.94032788e-01f, -2.97405511e-01f, 4.93864380e-02f, 2.99277335e-01f, 8.42746124e-02f, 3.57550859e-01f,
  -3.86397213e-01f, -3.90784651e-01f, 3.21175843e-01f, -6.79593384e-01f, -2.15483442e-01f, 8.33148301e-01f, 1.56401172e-01f, 3.70945305e-01f, 6.62138343e-01f, 7.48909235e-01f,
  -3.18704963e-01f, -8.88780132e-02f, -1.11346769e+00f, -1.44803151e-01f, 9.18152690e-01f, -4.74660136e-02f, 2.41862863e-01f, 4.72800404e-01f, 3.90035689e-01f, 5.87876141e-02f,
  8.63119841e-01f, 3.21081936e-01f, 4.07218784e-01f, 6.77564502e-01f, 4.99828309e-01f, 4.48250920e-01f, 2.39762858e-01f, -4.88702357e-01f, -1.51223451e-01f, 7.15084225e-02f,
  5.67139983e-01f, -3.07741791e-01f, 1.06809147e-01f, 4.93376225e-01f, 6.17488146e-01f, -2.82861978e-01f, -2.41991013e-01f, 5.31621039e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  6.14960670e-01f, 3.03060949e-01f, 6.93942666e-01f, 7.34358430e-01f, 9.72140789e-01f, -4.02634442e-02f, -1.81978643e-01f, 2.10519180e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  5.09995520e-01f, 2.74530370e-02f, 2.11490486e-02f, -2.01814845e-01f, 4.47437495e-01f, -5.88169336e-01f, 4.62559581e-01f, -2.97876805e-01f, 3.72598730e-02f, -1.39122605e-01f,
  -3.86795849e-01f, -1.32125188e-02f, -2.55655888e-02f, 2.05573574e-01f, 3.15784775e-02f, 3.80066067e-01f, -2.14954522e-02f, -2.15297733e-02f, -7.62810931e-02f, 2.84799878e-02f,
  -7.84851491e-01f, 7.51394391e-01f, -4.14428979e-01f, 2.57898625e-02f, -4.39646468e-02f, 6.36606291e-02f, 4.39845651e-01f, 2.15508163e-01f, 3.55886877e-01f, -1.83437750e-01f,
  -2.31730834e-01f, -4.14950758e-01f, 6.61319971e-01f, 4.30236489e-01f, 4.43880320e-01f, 1.16405547e-01f, 2.71010280e-01f, -6.09669745e-01f, -2.70661831e-01f, 2.30368808e-01f,
  -2.55557299e-01f, -1.91150494e-02f, -1.17329165e-01f, 1.06118917e-01f, -1.84499264e-01f, 3.18409741e-01f, -1.60452664e-01f, 3.39622974e-01f, -7.15966895e-02f, 2.57642478e-01f,
  -3.58984828e-01f, -3.31128269e-01f, -3.04154098e-01f, -4.27264035e-01f, 2.72137910e-01f, 2.20315024e-01f, 1.40779674e-01f, -5.65804467e-02f, -2.86224425e-01f, 3.55442762e-01f,
  -4.28084046e-01f, -2.67779350e-01f, 5.73091321e-02f, -1.47369862e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -4.34264451e-01f, -3.90420109e-01f, -7.33961940e-01f, 5.21912158e-01f, -9.86083001e-02f, 4.89621639e-01f, 4.72488821e-01f, 4.96566683e-01f, 7.29605734e-01f, 3.33343923e-01f,
  8.42068195e-01f, 1.33072242e-01f, 1.94339901e-02f, -5.23125112e-01f, 1.24323928e+00f, 3.76714408e-01f, 1.35305190e+00f, 7.66466498e-01f, 1.44056904e+00f, 1.27946258e+00f,
  -2.91890472e-01f, -2.74204344e-01f, -4.38331038e-01f, 6.41645849e-01f, -4.33248095e-02f, 7.59416580e-01f, 1.14032306e-01f, 3.07586700e-01f, 1.48182482e-01f, 5.45625865e-01f,
  -8.11517537e-01f, 1.08830428e+00f, 6.78397357e-01f, 5.69373548e-01f, 8.36505234e-01f, 3.43179047e-01f, 6.75477564e-01f, -1.01982403e+00f, 1.03463149e+00f, 3.55898052e-01f,
  8.25035810e-01f, -1.11902630e+00f, 2.29769289e-01f, -5.06736100e-01f, 1.26202548e+00f, -2.96415031e-01f, -7.63368905e-01f, -4.54401553e-01f, -2.96031237e-01f, 7.78320478e-03f,
  2.60035336e-01f, 5.32490671e-01f, -1.19057131e+00f, 7.41692245e-01f, -4.72183198e-01f, -1.78505689e-01f, -6.41127348e-01f, 1.60202253e+00f, 4.51941013e-01f, 4.11412746e-01f,
  -2.16699585e-01f, 9.05726194e-01f, 3.72795016e-01f, 7.62532115e-01f, 1.66979462e-01f, -1.77233040e-01f, 4.16682392e-01f, 4.21071470e-01f, -1.30476880e+00f, 1.58003664e+00f,
  5.78935921e-01f, -1.02615929e+00f, 3.51285130e-01f, -5.25660515e-01f, 7.26704597e-01f, 1.28589344e+00f, -5.32416906e-03f, 3.07136625e-01f, -2.01917306e-01f, -3.57086986e-01f,
  5.72731555e-01f, 6.33756936e-01f, 4.41590756e-01f, 7.72925436e-01f, -1.13847363e+00f, 1.28401768e+00f, -1.13258052e+00f, 5.02233922e-01f, 8.09067488e-02f, 6.99249923e-01f,
  2.80810565e-01f, 5.67056775e-01f, 5.04248202e-01f, -5.16152740e-01f, -6.73882365e-01f, -4.29402530e-01f, -1.19705275e-01f, 2.87988245e-01f, -3.65286797e-01f, 2.92357922e-01f,
  -1.74008280e-01f, -3.39990050e-01f, -2.55752325e-01f, -1.55680919e+00f, 9.78438675e-01f, 3.14422220e-01f, -7.24554896e-01f, 7.77597368e-01f, 1.73121482e-01f, 8.87485206e-01f,
  4.40990090e-01f, 2.84824759e-01f, -1.31464586e-01f, 7.57335871e-02f, 6.43528521e-01f, 8.09784010e-02f, 6.94409132e-01f, -2.01108545e-01f, 4.19188887e-01f, 1.11560237e+00f,
  -4.45598215e-01f, 7.03298822e-02f, 9.50518250e-01f, -6.05823874e-01f, 1.11300409e+00f, -3.06273729e-01f, 6.32576108e-01f, 1.16431884e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  4.22413945e-01f, 6.95372283e-01f, 8.89991581e-01f, -2.42329508e-01f, -8.36146623e-02f, 7.91816294e-01f, 3.65474038e-02f, 3.43840599e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -3.85831982e-01f, 6.18933797e-01f, -1.98974431e-01f, 5.05737066e-01f, 2.86329895e-01f, -3.93671632e-01f, -7.10463285e-01f, 4.65953559e-01f, -2.22019151e-01f, -1.31214118e+00f,
  1.08177280e+00f, -3.82763892e-01f, -6.91382289e-02f, -1.02744174e+00f, 2.56174266e-01f, -4.23050731e-01f, -4.73542601e-01f, -1.40910506e-01f, 9.26600620e-02f, -1.36927977e-01f,
  5.89424849e-01f, -6.81681454e-01f, -3.54650378e-01f, 8.39182734e-01f, 4.55775619e-01f, -1.04716229e+00f, -8.18186283e-01f, -8.99708748e-01f, -3.12522173e-01f, -8.48601520e-01f,
  6.44911706e-01f, -9.20190454e-01f, 2.85499513e-01f, 1.65094305e-02f, -3.30561578e-01f, -4.47672397e-01f, -5.40101469e-01f, 7.57990181e-01f, -8.17154288e-01f, 5.53682268e-01f,
  1.30699113e-01f, -1.32614195e+00f, -6.11946106e-01f, 2.97291465e-02f, 8.24974895e-01f, 7.59782419e-02f, -5.44789359e-02f, -9.27111983e-01f, 7.24193931e-01f, 1.08225346e-01f,
  -2.93439507e-01f, 3.20481360e-01f, -1.10933654e-01f, 7.15467453e-01f, 5.69746256e-01f, 3.06096077e-01f, -1.38898480e+00f, 1.89710349e-01f, -8.21504116e-01f, 2.02780977e-01f,
  8.58622193e-01f, 2.81342894e-01f, 2.57905096e-01f, -9.32924330e-01f, -4.23440486e-02f, -5.89347363e-01f, 6.39586389e-01f, -1.47594651e-02f, 1.29691884e-01f, 4.82365459e-01f,
  -2.87692338e-01f, -4.05876905e-01f, 6.79816678e-02f, 1.49062678e-01f, 3.99102032e-01f, -7.58302271e-01f, 4.01864916e-01f, 5.16710460e-01f, -2.46661976e-01f, -2.06800222e-01f,
  9.71960902e-01f, 4.93864805e-01f, 4.99745570e-02f, -4.26448077e-01f, -8.68088752e-02f, -1.17017400e+00f, -1.10493541e+00f, -9.38224733e-01f, 2.04007208e-01f, -4.51999396e-01f,
  -4.71243262e-01f, 4.17149365e-01f, -1.10255969e+00f, -9.15063143e-01f, -8.32198840e-03f, 3.41921061e-01f, -8.28054905e-01f, -4.00452614e-01f, -4.29960102e-01f, 5.81051707e-01f,
  1.04545109e-01f, 7.05675006e-01f, 7.52733886e-01f, 4.77786660e-01f, 4.28245574e-01f, -5.37210405e-01f, -6.16846383e-01f, 2.24952012e-01f, 3.51119190e-01f, -5.74220717e-01f,
  -9.52016652e-01f, 3.11648637e-01f, 5.23553610e-01f, 7.85714686e-01f, 6.92313313e-02f, 5.55414975e-01f, 2.87161618e-02f, 3.60627025e-01f, 9.49654043e-01f, -4.59467798e-01f,
  -1.27128172e+00f, 7.14010894e-01f, 7.73781776e-01f, -8.82952631e-01f, -8.53833735e-01f, 5.77644467e-01f, -8.28948557e-01f, 1.12798981e-01f, -5.85935175e-01f, 3.71389568e-01f,
  -1.52137026e-01f, -2.84416974e-01f, 6.72270209e-02f, -6.16860449e-01f, 1.09493637e+00f, 5.94251275e-01f, -3.32322627e-01f, -3.05843800e-01f, -8.86756778e-01f, 4.00548339e-01f,
  3.88518304e-01f, -1.09011328e+00f, 4.32394177e-01f, -5.50127566e-01f, -3.91744077e-01f, -3.53814363e-01f, -6.17956407e-02f, -9.26989615e-02f, -6.89551592e-01f, 4.46424246e-01f,
  -3.32001418e-01f, 1.10093415e-01f, 1.50902718e-01f, -1.11390686e+00f, 5.26070178e-01f, -1.14165866e+00f, -3.16512048e-01f, -2.64071226e-01f, -1.02761590e+00f, 9.35555279e-01f,
  -4.34564441e-01f, -2.76339799e-01f, -2.57326961e-01f, -2.57109016e-01f, 5.85946381e-01f, -6.09467030e-01f, -4.09483552e-01f, -3.85736078e-01f, -9.54550982e-01f, 5.08599758e-01f,
  -5.59674501e-01f, 6.26917839e-01f, -9.05291855e-01f, -6.42857015e-01f, 3.68614286e-01f, -5.32607377e-01f, -2.82842726e-01f, -3.42599005e-02f, 4.52034056e-01f, -1.03703216e-01f,
  -1.12139237e+00f, 4.22921360e-01f, 4.24804240e-01f, -3.17848735e-02f, -1.38220713e-01f, 2.48615935e-01f, -1.06069851e+00f, 4.31753159e-01f, -7.32883215e-01f, 1.11344135e+00f,
  -7.45986104e-01f, -1.24600060e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.23699687e-01f, 2.05378473e-01f, -9.31528285e-02f, -2.02873312e-02f, -1.91984743e-01f, 1.28953099e-01f, -1.56819344e-01f, 4.38470483e-01f, -2.27233484e-01f, -3.78152952e-02f,
  -4.04822081e-01f, -2.02087429e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    