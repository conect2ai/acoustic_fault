/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  9.32350755e-02f, 1.61702298e-02f, 1.23155653e-01f, -2.56302836e-03f, 1.55900419e-02f, -4.34054658e-02f, 1.94975391e-01f, -2.63175201e-02f, -4.10550199e-02f, 1.79033130e-01f,
  4.84363083e-03f, -8.97588804e-02f, -1.90412137e-03f, 9.47798565e-02f, 1.45614907e-01f, 9.87848490e-02f, 1.73654363e-01f, 1.54390544e-01f, 1.02665782e-01f, 3.89324017e-02f,
  2.28715744e-02f, 1.04882821e-01f, -2.83830054e-03f, -2.98285075e-02f, -7.67251700e-02f, -1.63251638e-01f, -6.01634290e-03f, -7.37281889e-02f, -9.45771858e-02f, -6.48839399e-02f,
  -3.34897414e-02f, 1.00439794e-01f, -6.44214749e-02f, 5.16039729e-02f, 9.71679986e-02f, 6.36367723e-02f, 9.89123657e-02f, 9.42824110e-02f, -9.81251802e-03f, -1.76416673e-02f,
  4.53507565e-02f, -3.23179923e-02f, -9.42881033e-02f, 4.43172157e-02f, -5.76922707e-02f, 7.52458051e-02f, 1.46836653e-01f, 1.99263580e-02f, -2.76176631e-02f, 1.07793435e-01f,
  1.86979864e-02f, 2.64186282e-02f, 4.80043553e-02f, -8.14107805e-02f, 6.77522793e-02f, 3.67924236e-02f, -6.57696277e-02f, -8.13932270e-02f, 4.19096164e-02f, 6.41967775e-03f,
  -2.52606627e-02f, -3.91076729e-02f, 7.56161138e-02f, -1.70723889e-02f, -2.58048270e-02f, 1.26033956e-02f, -1.13781933e-02f, -5.50003089e-02f, 2.13851165e-02f, 4.93744873e-02f,
  1.80800054e-02f, -3.54533037e-03f, 7.29175983e-03f, 7.28790089e-02f, 2.20702440e-02f, -5.16085178e-02f, -7.37682870e-03f, 9.02206264e-03f, -3.51508297e-02f, -3.69833373e-02f,
  7.25853592e-02f, -3.70286405e-02f, 1.61256585e-02f, -1.08748898e-01f, 5.91068976e-02f, 1.02423243e-01f, 1.40727125e-02f, 7.74339586e-03f, -8.36126357e-02f, 6.12227954e-02f,
  -1.36161774e-01f, -4.76954579e-02f, 2.33574323e-02f, -2.68879663e-02f, -4.01431927e-03f, 7.82521963e-02f, -1.13702975e-02f, 6.82630390e-02f, -3.05455290e-02f, 6.73611313e-02f,
  -2.99271140e-02f, 1.83186568e-02f, -1.52659332e-02f, -5.53704388e-02f, -1.68366712e-02f, -5.61065180e-03f, 1.43120021e-01f, -7.75851309e-02f, 8.33737478e-02f, 8.36168081e-02f,
  4.14506383e-02f, -4.50942246e-03f, 3.84146161e-02f, -1.94899626e-02f, 9.56339017e-02f, -8.48340094e-02f, -1.20844208e-02f, -5.98475104e-03f, -8.03439133e-03f, -9.73233134e-02f,
  9.18724313e-02f, 2.36777335e-01f, 4.97829504e-02f, 1.47593692e-01f, 3.42452899e-02f, -1.01054363e-01f, -2.99853235e-01f, 7.15236692e-03f, 2.23247573e-01f, 6.55581057e-02f,
  6.20260499e-02f, 3.44282314e-02f, 3.44655535e-04f, -6.09996393e-02f, -1.25074312e-01f, -1.93560690e-01f, 1.09548103e-02f, -2.10359730e-02f, -1.50473893e-01f, -4.03554179e-02f,
  6.53401762e-02f, 3.81690226e-02f, 1.19573914e-01f, 2.81909462e-02f, 1.90289959e-01f, -7.54740313e-02f, -1.61093213e-02f, 6.79267421e-02f, -1.29162113e-03f, 1.19303055e-01f,
  6.95156232e-02f, 2.35610023e-01f, -1.45981193e-01f, -7.43234903e-03f, 7.51343742e-02f, 2.86266357e-02f, 2.57622730e-02f, 4.95506339e-02f, -6.71039373e-02f, 2.91802026e-02f,
  5.51139526e-02f, 6.60688058e-02f, -2.04178877e-02f, 1.09469555e-02f, 4.85637002e-02f, -5.07743806e-02f, 4.96873707e-02f, 8.40568468e-02f, 1.10119954e-01f, 9.02627781e-02f,
  2.24356689e-02f, 1.68626279e-01f, 1.36644259e-01f, 8.97755697e-02f, 7.93785322e-03f, 1.23423502e-01f, 1.56861484e-01f, 8.72397348e-02f, 9.65546593e-02f, 4.76144217e-02f,
  -6.19665571e-02f, 6.46481812e-02f, 3.73744145e-02f, 2.31562387e-02f, -1.24261221e-02f, 9.83775314e-03f, 9.08533111e-02f, -4.40145805e-02f, 8.16959981e-03f, 2.09233277e-02f,
  7.23103285e-02f, 1.14273941e-02f, 4.16950509e-02f, 1.62670277e-02f, 4.08367515e-02f, -1.53086539e-02f, -1.20007060e-02f, -8.77449960e-02f, 9.98618156e-02f, 4.80730720e-02f,
  -2.44748872e-02f, -2.09422018e-02f, -1.25664091e-02f, -1.08785503e-01f, 2.79420037e-02f, -3.43746692e-02f, -9.50481519e-02f, -1.74940340e-02f, -4.16630413e-03f, -1.40805207e-02f,
  2.13226974e-02f, -5.56492545e-02f, -4.85961288e-02f, -2.39963178e-02f, -6.10768376e-03f, -1.87099185e-02f, -3.40973698e-02f, -1.04395971e-01f, 1.18443347e-03f, 3.35660540e-02f,
  -5.57413995e-02f, 1.37429708e-03f, 4.66144830e-02f, -5.83093008e-03f, -3.80441849e-03f, -6.22099303e-02f, -7.27895573e-02f, -6.73361914e-03f, -7.71078989e-02f, -3.63491140e-02f,
  -3.03125158e-02f, -1.22294441e-01f, 1.19529630e-03f, -3.78742218e-02f, 1.47813290e-01f, -1.43345669e-01f, -4.17914763e-02f, -2.14025378e-02f, -1.70203716e-01f, -2.17229724e-01f,
  -1.72966663e-02f, 2.05163792e-01f, 1.42631575e-01f, -1.87962111e-02f, 8.69271755e-02f, -1.02556586e-01f, 1.66861579e-01f, -5.36870882e-02f, -1.49590790e-01f, -4.19149287e-02f,
  -9.66077205e-03f, -9.49955136e-02f, -1.92800120e-01f, -1.40510229e-02f, -1.47251278e-01f, -6.15704581e-02f, 2.10603941e-02f, -1.95376612e-02f, -2.54523426e-01f, -2.34647959e-01f,
  -9.85207930e-02f, -5.13647422e-02f, -6.76198825e-02f, -1.39163613e-01f, 2.02755466e-01f, 3.07115167e-02f, 1.78446606e-01f, 3.51419486e-02f, -1.43794790e-02f, 3.39779943e-01f,
  3.24912071e-02f, 1.63463578e-01f, -1.11870259e-01f, -1.83751099e-02f, 3.24671082e-02f, 2.19833981e-02f, 6.29445091e-02f, 1.96442418e-02f, 1.95784215e-02f, -8.49366039e-02f,
  -1.26193479e-01f, -1.41878668e-02f, -6.78144842e-02f, 1.17675876e-02f, -2.13169423e-03f, -1.32256560e-02f, -1.61568373e-02f, -2.07671076e-02f, -8.24859142e-02f, 7.28799850e-02f,
  1.04058944e-01f, 1.35578036e-01f, 2.64898203e-02f, -9.97077581e-03f, 7.98596963e-02f, -5.78910671e-02f, 1.27012255e-02f, 2.37476714e-02f, 1.12896375e-01f, 2.44565234e-01f,
  2.20318343e-02f, -8.25040415e-02f, 5.20475842e-02f, 6.10923441e-03f, 4.43337038e-02f, -1.06155984e-02f, 1.12631067e-03f, -3.99281345e-02f, 4.17008577e-03f, -2.20887614e-05f,
  -4.19028886e-02f, 2.17559077e-02f, -7.07627274e-03f, -4.99632061e-02f, 2.62414422e-02f, -1.20667908e-02f, 3.38261686e-02f, 6.30089790e-02f, -1.09034702e-02f, 3.86988968e-02f,
  -5.54853911e-03f, -4.30579018e-03f, -3.50895897e-02f, 3.79166678e-02f, 8.13724324e-02f, -7.51465559e-02f, -1.01303123e-02f, -2.57810764e-02f, -1.48571162e-02f, -2.90751960e-02f,
  -4.34217006e-02f, -1.53778708e-02f, -3.62390629e-03f, 4.49118949e-02f, -9.10807177e-02f, 3.22045684e-02f, 8.46953969e-03f, 4.65145744e-02f, 5.23423888e-02f, -3.51113491e-02f,
  -5.54598831e-02f, -4.61655529e-03f, -4.19314764e-02f, 1.95840592e-04f, -8.27991441e-02f, -3.84300016e-03f, 5.88158797e-03f, 7.36246407e-02f, 1.31474193e-02f, -3.25488001e-02f,
  -8.14029947e-02f, 2.60881372e-02f, -1.37655316e-02f, 3.90613265e-02f, 1.03086084e-02f, -7.38196680e-03f, 3.93690392e-02f, 6.75732866e-02f, 2.07901038e-02f, 1.46667480e-01f,
  -5.19236140e-02f, 6.15868233e-02f, -7.90057704e-03f, -1.93511751e-02f, 5.12137637e-02f, -2.40156855e-02f, -7.56846517e-02f, 6.81287274e-02f, -1.41455242e-02f, -1.16057262e-01f,
  4.31096740e-03f, 1.20368332e-01f, 9.75738317e-02f, 8.78582001e-02f, 9.05061811e-02f, -4.86383364e-02f, 4.90061380e-02f, -5.61615564e-02f, -2.82694586e-03f, 3.44127193e-02f,
  8.22426975e-02f, 1.68633610e-02f, -1.20752798e-02f, -1.91379283e-02f, 8.36935360e-03f, 6.79499879e-02f, -8.36643502e-02f, -4.72930297e-02f, 1.03569798e-01f, -4.35256911e-03f,
  2.78220363e-02f, -9.66673195e-02f, -3.77212395e-03f, 8.34476203e-02f, 2.89419889e-02f, -6.64448971e-03f, 2.02531647e-02f, 4.75760140e-02f, -1.13501608e-01f, 1.51284784e-02f,
  -3.67575996e-02f, -6.35611266e-02f, -4.00071219e-02f, 3.94741930e-02f, -8.27492625e-02f, 4.81065661e-02f, 7.11410642e-02f, -9.90958884e-02f, 5.94532071e-03f, -4.43521217e-02f,
  -5.03079854e-02f, -3.82564520e-03f, -2.66347509e-02f, -4.20196876e-02f, -7.55547881e-02f, -5.49896620e-02f, 7.36497268e-02f, 1.86560815e-03f, 8.77365023e-02f, 5.76478504e-02f,
  -3.23325023e-02f, -5.52214757e-02f, 1.43879084e-02f, -7.07914606e-02f, -2.92809531e-02f, -1.02840520e-01f, 3.16759348e-02f, 1.04607698e-02f, -7.68375322e-02f, 9.30519216e-03f,
  -3.63286631e-03f, -4.56505865e-02f, -6.55121058e-02f, -2.22597253e-02f, -8.86420086e-02f, 5.63044623e-02f, 3.55826728e-02f, -5.82662299e-02f, 2.24560611e-02f, 2.90518906e-02f,
  -4.84705088e-04f, 4.55254540e-02f, 2.83291843e-03f, 5.40849306e-02f, -6.90464303e-02f, -6.01943908e-03f, 4.44880873e-02f, 3.10348882e-03f, 5.87082729e-02f, 4.46709171e-02f,
  -2.34969170e-03f, -3.25192139e-02f, 6.50302619e-02f, -4.57966551e-02f, 5.66025972e-02f, 3.85464169e-02f, 2.10219659e-02f, 2.35330407e-02f, -1.19496614e-01f, 2.66922973e-02f,
  -6.19636737e-02f, -4.16621901e-02f, -4.98281606e-02f, -7.74556026e-02f, -2.44384501e-02f, 6.42703846e-02f, -5.81651330e-02f, -6.57380968e-02f, -2.46507023e-03f, 3.20907533e-02f,
  -5.56142405e-02f, 2.07618289e-02f, -2.17741113e-02f, -8.28561708e-02f, 3.89222167e-02f, -1.17141634e-01f, -8.46178383e-02f, 6.90522790e-02f, -6.61921203e-02f, -1.40486853e-02f,
  -1.29375458e-01f, -6.82092533e-02f, -9.16757062e-02f, 7.48047978e-02f, -5.29588386e-02f, 6.96501508e-03f, 2.63975258e-03f, 4.67101745e-02f, 7.32267052e-02f, 2.54977290e-02f,
  -1.02818608e-01f, 9.45066586e-02f, -6.47013485e-02f, -5.27748540e-02f, -4.83186916e-02f, 1.08862087e-01f, -5.85605428e-02f, -3.42560448e-02f, -5.17494371e-03f, 7.75259361e-02f,
  3.97022143e-02f, 3.23056616e-02f, -3.19490544e-02f, 1.07703872e-01f, -6.28869608e-02f, -5.39225712e-02f, -4.05287072e-02f, -8.70313048e-02f, -6.24451376e-02f, -1.13152467e-01f,
  -3.75952683e-02f, -1.34700164e-01f, 6.66057505e-03f, 3.70406769e-02f, 2.62607401e-03f, 3.40665691e-02f, -2.67568342e-02f, -4.67454419e-02f, -5.51316477e-02f, -2.42810436e-02f,
  -3.54720280e-02f, -4.73863585e-03f, -8.07331279e-02f, -3.71423848e-02f, -4.63941805e-02f, -1.00980410e-02f, 4.00058366e-02f, -1.53847868e-02f, -2.20708549e-02f, 2.98535619e-02f,
  -3.53385694e-02f, -2.75684353e-02f, -4.28828597e-02f, -7.19617680e-02f, -1.54318940e-02f, 4.55558933e-02f, -3.51063535e-02f, -6.95162266e-02f, 2.56058425e-02f, -3.57517377e-02f,
  -6.19446896e-02f, 5.53843901e-02f, 9.56476703e-02f, 7.08455816e-02f, 4.15245108e-02f, 6.61595911e-02f, 3.19087803e-02f, -1.89201161e-02f, -5.44874147e-02f, 5.84128127e-02f,
  -8.52746442e-02f, 9.70652178e-02f, 9.67395213e-03f, -2.75625568e-03f, 6.56455830e-02f, 7.92222172e-02f, -3.97809967e-02f, -4.34603505e-02f, -1.18628526e-02f, 1.80253722e-02f,
  -2.24323943e-02f, -8.78451988e-02f, 1.89756397e-02f, -6.89707696e-02f, 3.29940319e-02f, -4.16917875e-02f, 2.02353112e-03f, -1.38694217e-04f, -3.20941769e-02f, -5.52438609e-02f,
  5.00235483e-02f, -1.39205242e-02f, -5.46039715e-02f, -4.62040957e-03f, 5.74967787e-02f, -2.59405328e-03f, -3.49975675e-02f, 5.28073683e-02f, 4.03722040e-02f, -2.97603365e-02f,
  -8.55493397e-02f, -5.44520952e-02f, 5.48850894e-02f, -6.72436273e-03f, -6.18680827e-02f, 2.37754676e-02f, 1.02635818e-02f, 4.03865613e-02f, 5.67143410e-02f, 2.60001756e-02f,
  9.56345126e-02f, -3.90375443e-02f, 4.64996882e-03f, -6.33057952e-02f, 5.23534371e-03f, 2.41004955e-02f, 8.13840479e-02f, -1.27622606e-02f, 3.47929373e-02f, -8.60323850e-03f,
  -2.12992981e-01f, 2.74451096e-02f, -3.79952788e-01f, -5.78390993e-02f, -1.46246016e-01f, -9.76015255e-02f, -1.82812557e-01f, 2.08970364e-02f, 1.06218591e-01f, -4.46198620e-02f,
  3.07809998e-04f, 2.21078366e-01f, 8.08924511e-02f, 8.57820082e-03f, 5.97415566e-02f, -3.61575857e-02f, -1.50421947e-01f, -1.22719944e-01f, -1.72224835e-01f, -1.28441200e-01f,
  6.08170666e-02f, -7.76550872e-03f, -2.69621648e-02f, -6.50598183e-02f, 9.31402072e-02f, 5.37015423e-02f, 1.15842875e-02f, -1.36939928e-01f, -7.16385618e-02f, -1.13005728e-01f,
  -1.47231668e-02f, -3.52803618e-01f, 5.71295545e-02f, 5.93437664e-02f, -2.24252846e-02f, 1.28584038e-02f, -4.39373367e-02f, -5.34462743e-02f, 1.46102589e-02f, 8.68772641e-02f,
  -3.97853814e-02f, -1.71926140e-03f, -9.31304991e-02f, 8.19048733e-02f, 1.13347759e-02f, -7.78434053e-02f, -6.67300448e-02f, -8.04045871e-02f, -2.66872458e-02f, -1.21432140e-01f,
  -5.38651831e-02f, -3.56732085e-02f, -1.52844861e-01f, 1.58816557e-02f, -3.53130661e-02f, 1.86154861e-02f, -2.99013499e-02f, -5.85675426e-02f, -1.10570274e-01f, 3.33934948e-02f,
  -9.92441457e-03f, -1.86246261e-02f, -6.48108870e-03f, -3.78591791e-02f, 6.89215362e-02f, 1.04659185e-01f, -5.77325597e-02f, 2.14782124e-03f, 9.17569995e-02f, -7.00281262e-02f,
  3.42904590e-02f, -1.32746875e-01f, 5.57507714e-03f, -3.49515826e-02f, -3.35641182e-03f, -4.36360762e-02f, 1.83284562e-03f, 1.01339743e-02f, -1.12665175e-02f, 4.20470461e-02f,
  6.35531023e-02f, -5.51135018e-02f, 9.45465490e-02f, 1.54190166e-02f, 3.67054939e-02f, 2.50468105e-02f, -4.71609719e-02f, -5.01145795e-03f, 2.20089424e-02f, -3.01674362e-02f,
  2.58808076e-01f, -1.73792318e-01f, 1.56497911e-01f, -3.98883708e-02f, 1.17530162e-02f, 9.35270637e-02f, -9.85483080e-03f, 9.79666933e-02f, -6.20998964e-02f, 1.44208334e-02f,
  -4.93958034e-02f, 3.27961817e-02f, 5.24464576e-03f, -1.45889977e-02f, -3.81495096e-02f, 2.65174615e-03f, 1.70336634e-01f, -5.52175492e-02f, -7.45541081e-02f, 1.03670813e-01f,
  1.69186324e-01f, 7.18639717e-02f, 4.01727073e-02f, 6.27700686e-02f, -4.46886625e-05f, -2.21044440e-02f, 1.05831936e-01f, 8.87885392e-02f, 3.37995626e-02f, 1.70319572e-01f,
  -3.27615827e-01f, -8.91176462e-02f, 1.49989486e-01f, -2.37162605e-01f, -1.96465980e-02f, -1.46412794e-02f, 1.76398158e-01f, -6.94211423e-02f, -1.37634620e-01f, 3.18530314e-02f,
  -1.68535784e-01f, -1.40301988e-01f, -5.02041206e-02f, -8.69983807e-02f, -4.42790352e-02f, 2.39139482e-01f, 2.17603758e-01f, 1.21337563e-01f, -2.45556571e-02f, -9.40040201e-02f,
  -9.99689549e-02f, 5.06722182e-02f, -5.88074476e-02f, -2.83552576e-02f, 1.01452887e-01f, -4.23752181e-02f, 6.38581663e-02f, -1.43582728e-02f, -4.60425206e-03f, 1.72683433e-01f,
  -1.13134198e-02f, -5.68378828e-02f, 5.47088645e-02f, -9.53965709e-02f, -7.31771290e-02f, 6.09511277e-03f, -3.85491177e-02f, -1.38073219e-02f, -2.36328393e-02f, 6.06356412e-02f,
  -6.59454539e-02f, -4.75288257e-02f, 6.74262717e-02f, -8.79700389e-03f, 1.12670459e-01f, -1.14155496e-02f, -2.50577871e-02f, 6.08697757e-02f, 1.35586500e-01f, -6.16776533e-02f,
  7.84267262e-02f, 6.33211853e-03f, 4.48660180e-02f, 9.86347906e-03f, 5.66613264e-02f, 1.07809827e-01f, 5.50868437e-02f, 3.70292105e-02f, -2.96543390e-02f, 6.15143403e-02f,
  -3.63330543e-02f, 2.49424987e-02f, -1.29432939e-02f, 8.79685879e-02f, -7.17370287e-02f, -1.46355908e-02f, -6.88037276e-03f, 2.60982644e-02f, 1.70243327e-02f, -4.02653441e-02f,
  4.92796004e-02f, 3.90509143e-02f, -1.13811530e-03f, -2.94722989e-02f, -1.76293310e-02f, 1.05400495e-02f, -4.37187999e-02f, -2.30731275e-02f, 1.85633916e-02f, 3.35426740e-02f,
  -7.02682212e-02f, 1.55661218e-02f, -3.76169942e-03f, -5.49249314e-02f, 6.57776147e-02f, 4.34913253e-03f, 7.53076449e-02f, -6.91907629e-02f, 3.56720090e-02f, -1.23158912e-03f,
  -6.88416837e-03f, 5.28659858e-03f, 6.00085296e-02f, -4.44078781e-02f, 1.32999262e-02f, -4.58091088e-02f, -1.14644028e-01f, 1.27166025e-02f, -1.78636033e-02f, 5.38186356e-03f,
  -4.14872393e-02f, 3.90815549e-02f, 1.34414239e-02f, 4.64837030e-02f, 5.35760960e-03f, -3.51975188e-02f, -4.99662906e-02f, -1.15912206e-01f, -2.93304566e-02f, -6.78336173e-02f,
  -4.27727289e-02f, 2.06242055e-02f, -7.63087198e-02f, 9.32457745e-02f, 5.63135138e-03f, 1.35093359e-02f, -3.18065211e-02f, -3.17435712e-02f, -1.39238201e-02f, -6.12125322e-02f,
  -8.16192999e-02f, 3.52423042e-01f, -1.84608236e-01f, -1.62544265e-01f, -9.53677073e-02f, 1.34858564e-01f, 5.53537250e-01f, 1.79503947e-01f, -7.29335919e-02f, 8.30642730e-02f,
  4.45607454e-02f, -1.40321180e-01f, -6.21729828e-02f, -2.37683002e-02f, 2.11223587e-01f, 2.32674718e-01f, -3.17646898e-02f, -5.90086170e-02f, 5.51400706e-02f, 1.11534866e-02f,
  -2.52098609e-02f, -8.43355134e-02f, -1.07862704e-01f, 3.90113369e-02f, -8.58566761e-02f, -6.47648200e-02f, -1.90299358e-02f, -2.37542003e-01f, 7.39355981e-02f, -3.40104997e-01f,
  -1.54257357e-01f, 9.11818817e-02f, 4.57267240e-02f, -4.94356640e-02f, -3.54243964e-02f, 6.68682754e-02f, 4.62381244e-02f, -1.57496676e-01f, -1.21748727e-02f, -9.32078809e-02f,
  -1.70313224e-01f, -5.42754531e-02f, -5.60693666e-02f, -1.37146071e-01f, 5.25909383e-03f, -1.99569259e-02f, -2.89990753e-02f, -1.44679723e-02f, 8.16286877e-02f, 3.63217108e-02f,
  1.86420921e-02f, -5.32990731e-02f, 2.05419939e-02f, 6.44305870e-02f, 5.59424870e-02f, -5.29102758e-02f, -8.53122969e-04f, -7.74774179e-02f, -2.51255166e-02f, -1.11072749e-01f,
  -8.36195424e-03f, -4.54538800e-02f, 2.38414053e-02f, 9.06375516e-03f, 7.88870230e-02f, 5.73787130e-02f, 1.29811221e-03f, -5.80858849e-02f, -6.60345331e-02f, 1.57237396e-01f,
  1.47525128e-02f, 2.39280704e-02f, -7.55328164e-02f, -8.02667346e-03f, -3.71707492e-02f, -8.96415487e-02f, -6.43619969e-02f, 3.82304303e-02f, -1.13542974e-02f, 4.02182154e-02f,
  -2.85971407e-02f, -1.06593417e-02f, 1.06437858e-02f, -3.91173512e-02f, 3.10222860e-02f, 1.71573411e-04f, -5.93016930e-02f, 6.78802282e-02f, -6.17822586e-03f, 4.55426611e-02f,
  1.18711796e-02f, 5.74315526e-02f, -5.99330030e-02f, 2.34522019e-02f, -8.70131925e-02f, -2.51160674e-02f, -2.73183919e-02f, 2.72508450e-02f, -3.70346308e-02f, 8.46578926e-02f,
  6.43795133e-02f, -2.14745179e-02f, 1.43746575e-02f, -1.60384215e-02f, 5.16265184e-02f, -1.65470056e-02f, 5.29020876e-02f, -6.36525638e-03f, 1.73772834e-02f, 1.12711377e-02f,
  1.13563977e-01f, 1.35485813e-01f, 1.61410213e-01f, 1.62484974e-01f, 3.41697945e-03f, 1.26370445e-01f, 8.15413799e-03f, 1.96796507e-02f, 1.15142956e-01f, 3.14511031e-01f,
  -8.53429139e-02f, -1.23287976e-01f, 1.48592234e-01f, 2.16602124e-02f, 1.21935979e-01f, 3.05606704e-02f, 1.60229698e-01f, 1.17086001e-01f, 1.49593828e-02f, -7.53040910e-02f,
  -2.69871831e-01f, -1.53851330e-01f, -2.22526696e-02f, -1.06425762e-01f, -1.67330336e-02f, 1.56711593e-01f, 1.91377282e-01f, 1.54983610e-01f, 1.71328411e-01f, 9.59939510e-02f,
  -5.31796440e-02f, 1.05127595e-01f, 7.89267290e-03f, -1.27595924e-02f, 1.56740218e-01f, -2.79637109e-02f, -5.13393022e-02f, -1.05954437e-02f, -3.57245840e-02f, 1.57657042e-01f,
  -7.59982392e-02f, 1.60595864e-01f, 1.43665811e-02f, -9.36208367e-02f, -1.41831562e-01f, 5.11789508e-03f, -2.49996427e-02f, 1.40366673e-01f, -1.02837227e-01f, 5.34201413e-02f,
  -1.05384886e-01f, -1.67839578e-03f, 3.61143332e-03f, 1.21693604e-01f, 1.54955219e-02f, 8.61461908e-02f, 9.22759436e-03f, 6.48134053e-02f, 5.02630696e-02f, 3.54135334e-02f,
  -8.52523372e-02f, -1.93395582e-03f, 1.57651141e-01f, 9.75778103e-02f, 5.07840216e-02f, 1.88697521e-02f, 1.04214409e-02f, 4.38446365e-02f, -5.03416697e-04f, -2.37806663e-02f,
  -5.95701784e-02f, 7.27403089e-02f, -1.83463376e-02f, 2.92043923e-03f, -3.41681242e-02f, 2.49630157e-02f, 7.52013084e-03f, -8.01070258e-02f, 1.17075384e-01f, 9.21138227e-02f,
  -5.92478774e-02f, 5.26367053e-02f, -2.49528065e-02f, -2.11620312e-02f, -1.57712307e-02f, 6.30805492e-02f, 5.78882731e-02f, -3.17821205e-02f, -7.66754448e-02f, -7.21863359e-02f,
  -9.86501854e-03f, 2.46851984e-02f, -2.72136163e-02f, 6.75794706e-02f, -5.10346191e-03f, -2.59506423e-03f, -8.31982195e-02f, 2.05257628e-02f, -2.21448005e-04f, 2.53362134e-02f,
  1.43341839e-01f, -1.67865321e-01f, -1.66433498e-01f, 1.81279313e-02f, 1.00640699e-01f, -1.97128803e-02f, 2.42653247e-02f, -1.13282017e-02f, -7.58461282e-02f, 2.03591045e-02f,
  -2.01787315e-02f, -2.37862822e-02f, -1.87236797e-02f, -1.92529261e-02f, 8.70504156e-02f, 9.09834728e-02f, -8.12361091e-02f, 8.08424726e-02f, -1.82560869e-02f, -3.49845104e-02f,
  -2.77551226e-02f, -5.70572121e-03f, 6.66443678e-03f, 3.98362316e-02f, -4.93078642e-02f, -1.39831100e-02f, 4.18658219e-02f, 6.07385077e-02f, -4.99848276e-02f, -6.64138794e-02f,
  1.01427265e-01f, -4.92465831e-02f, 7.26391897e-02f, -7.65158981e-02f, -3.81000079e-02f, 4.57286276e-03f, 1.12599738e-01f, 4.95200083e-02f, -1.23345733e-01f, 4.92675900e-02f,
  3.51728946e-02f, -6.08409457e-02f, 2.40244046e-02f, -5.58076687e-02f, 3.07628978e-02f, 1.01499356e-01f, -1.01089172e-01f, 1.53709248e-01f, 8.13803449e-02f, 1.80510152e-02f,
  -9.86243039e-02f, -1.21140424e-02f, 1.33508043e-02f, 9.24508125e-02f, -1.29198685e-01f, -4.04522195e-02f, -2.21787784e-02f, -2.09821500e-02f, 1.31072253e-01f, -1.07176676e-01f,
  -1.21221170e-01f, 8.48378167e-02f, 8.25338811e-03f, 2.44095735e-02f, 3.11742742e-02f, 6.77099228e-02f, 1.34841278e-01f, 8.09332579e-02f, 8.87623280e-02f, 2.99916919e-02f,
  1.01000639e-02f, 4.86925133e-02f, -1.22017302e-02f, -8.96885321e-02f, -2.93235015e-02f, 1.92192253e-02f, -1.08074039e-01f, 6.70931116e-02f, -7.35737979e-02f, -2.64472179e-02f,
  3.87747288e-02f, -6.67562038e-02f, 1.02958139e-02f, 7.02227801e-02f, 1.08630955e-01f, -5.92291206e-02f, 2.18019877e-02f, 3.18891592e-02f, -4.56671789e-02f, -1.17406592e-01f,
  8.24474245e-02f, -3.59578035e-03f, -3.89203764e-02f, -2.42555942e-02f, -1.04636075e-02f, -1.94729269e-02f, 2.39436943e-02f, -3.06774676e-02f, -2.71169096e-03f, 1.03363078e-02f,
  -5.97693725e-03f, 4.27405126e-02f, -3.32126953e-02f, 4.80605029e-02f, -4.29856032e-02f, -2.00582184e-02f, 1.25538502e-02f, 6.89875558e-02f, 1.05421701e-02f, -4.21807766e-02f,
  -8.49613175e-02f, 5.65254129e-02f, 1.74890589e-02f, -8.92542601e-02f, 2.22887378e-02f, 3.47732306e-02f, -6.00942299e-02f, -8.19048658e-02f, 3.93866338e-02f, -3.84057164e-02f,
  -9.61046740e-02f, 2.07363218e-02f, -1.05457470e-01f, -5.19178808e-02f, 2.75887223e-03f, -5.70270419e-02f, 5.22558577e-02f, -3.14850137e-02f, 3.48148905e-02f, 8.17200821e-03f,
  -3.02861612e-02f, -1.41430702e-02f, -7.48061389e-02f, -2.13853791e-02f, 8.26761127e-02f, -6.20088167e-02f, 5.02662268e-03f, -8.11454877e-02f, -7.41610453e-02f, -1.34898862e-03f,
  -5.14484830e-02f, -5.93707431e-04f, 5.23801520e-02f, -6.38734624e-02f, 4.65951152e-02f, -7.75275528e-02f, 1.23217888e-02f, 4.87112068e-02f, -1.03426054e-02f, -2.90355626e-02f,
  -9.08768456e-03f, 1.93169743e-01f, -4.05722372e-02f, 1.04341716e-01f, 1.18379081e-02f, -1.09361976e-01f, -1.27511844e-02f, 8.44526291e-02f, 2.14224402e-02f, -1.61500573e-02f,
  6.54360726e-02f, 3.72238532e-02f, 4.07381579e-02f, 5.67972772e-02f, 3.83780450e-02f, 2.63130423e-02f, 5.35740815e-02f, -1.44912913e-01f, -1.44660294e-01f, -2.78691929e-02f,
  -1.85973290e-02f, -6.14679083e-02f, 3.57214399e-02f, -5.00296848e-03f, -2.79015675e-02f, -8.53226110e-02f, -4.57168333e-02f, -8.87991041e-02f, 5.12152277e-02f, 1.12927124e-01f,
  -2.20495358e-01f, 1.02325521e-01f, 6.00184463e-02f, 8.27775598e-02f, -2.89108250e-02f, -3.98502089e-02f, -7.44641349e-02f, 2.45220810e-02f, 1.03727616e-01f, 1.27934190e-02f,
  6.33847937e-02f, 3.71014923e-02f, 4.97395657e-02f, 7.73640275e-02f, -9.53183398e-02f, -6.85091363e-03f, 6.32241368e-02f, 3.31078209e-02f, 3.48502845e-02f, -2.26422958e-02f,
  3.24887894e-02f, 2.79241125e-03f, -6.76155612e-02f, 8.22705552e-02f, 9.68762338e-02f, -9.27417800e-02f, -4.96834069e-02f, 1.48237096e-02f, -2.73199491e-02f, 6.48515671e-02f,
  1.47919366e-02f, 2.54340991e-02f, 2.17921752e-02f, -7.67627731e-03f, -7.83795640e-02f, -1.60482675e-02f, -2.08674539e-02f, 1.56120742e-02f, 3.88403013e-02f, -1.41157746e-01f,
  5.36299124e-02f, -5.33196107e-02f, 6.16286248e-02f, 3.45353386e-03f, 1.33255590e-02f, 7.48307854e-02f, 2.21039131e-02f, 1.37590636e-02f, 3.78232747e-02f, -1.65101886e-02f,
  3.51893492e-02f, 9.64316279e-02f, -1.55527629e-02f, -1.15485668e-01f, 4.71072346e-02f, 4.20125574e-02f, -5.76108098e-02f, -5.62104862e-03f, -1.11446500e-01f, 5.54712452e-02f,
  -2.70185590e-01f, 1.39344662e-01f, -1.16185308e-01f, -6.82438761e-02f, -7.30040949e-04f, 2.08910797e-02f, 4.04841714e-02f, 7.50895217e-02f, -7.62323337e-03f, 8.46407749e-03f,
  6.29243851e-02f, 6.24518655e-03f, -7.53835514e-02f, -8.00268445e-03f, -7.97012448e-02f, 5.92745766e-02f, -6.44018874e-02f, -8.67760405e-02f, -1.02599412e-02f, -2.26862039e-02f,
  5.43043725e-02f, -8.63888338e-02f, -1.71386495e-01f, -1.93042103e-02f, -7.08667189e-02f, -1.59284621e-01f, -1.83448404e-01f, -7.91549459e-02f, -5.92653267e-02f, -2.14248180e-01f,
  3.31052184e-01f, 5.12508824e-02f, 7.46309832e-02f, 8.78151730e-02f, -8.53420198e-02f, -7.91600049e-02f, -3.27091627e-02f, 1.34721193e-02f, -7.75246695e-02f, 3.06201242e-02f,
  -4.98826616e-02f, -9.54247564e-02f, -6.38753101e-02f, -1.44353449e-01f, -4.06660587e-02f, 6.15338795e-02f, -3.75978253e-03f, -6.92679882e-02f, -6.28204048e-02f, 4.36926968e-02f,
  9.17567238e-02f, -9.84212104e-03f, 2.25133579e-02f, 3.22545208e-02f, 1.08123999e-02f, -4.70835939e-02f, 7.83469975e-02f, -7.83601105e-02f, -1.02019221e-01f, 1.09722324e-01f,
  -4.89507988e-02f, -1.97575577e-02f, 5.53388894e-02f, -4.91035208e-02f, -6.80869166e-03f, -1.83929540e-02f, 4.17939760e-02f, -6.00316189e-02f, -2.64952276e-02f, -9.11413133e-02f,
  4.37318832e-02f, 1.77391618e-02f, -7.49482363e-02f, 1.88328361e-03f, -2.81971842e-02f, 2.55434643e-02f, 1.63324885e-02f, 4.46167886e-02f, -6.12904690e-02f, 1.07668824e-02f,
  2.57705115e-02f, 7.16620907e-02f, 6.82125017e-02f, 5.26687838e-02f, -9.36869308e-02f, -4.71657366e-02f, 3.27857099e-02f, -5.43351984e-03f, 4.92348219e-04f, 1.39462247e-01f,
  8.14193487e-02f, -5.75265251e-02f, -5.88678904e-02f, 5.01683578e-02f, 4.96122539e-02f, -3.73207661e-03f, -2.99520865e-02f, -4.13720235e-02f, -3.92587259e-02f, 9.85994637e-02f,
  -7.46233612e-02f, -2.18970999e-02f, -7.37884045e-02f, -3.87675166e-02f, 6.91852495e-02f, -4.03758101e-02f, -4.24623229e-02f, -2.79651377e-02f, 1.15141002e-02f, -3.97929735e-02f,
  3.55480835e-02f, -4.73684072e-03f, 6.62775040e-02f, -5.48935831e-02f, 5.57140298e-02f, -1.36669846e-02f, -5.47484234e-02f, -6.85859621e-02f, -1.96467042e-02f, -3.58952791e-03f,
  -2.84433812e-02f, -1.41389593e-01f, 9.85402614e-02f, 1.76831335e-02f, -8.75837505e-02f, 5.77818565e-02f, -6.76580593e-02f, -4.30236757e-02f, 3.99978645e-02f, 6.42923862e-02f,
  -6.71545640e-02f, 1.71114551e-03f, -2.71294508e-02f, -8.07389393e-02f, -3.96809243e-02f, 1.39587442e-03f, 5.01123331e-02f, -2.53416244e-02f, -3.08076479e-02f, -3.88092138e-02f,
  -3.88071239e-02f, 3.25065963e-02f, 2.65800729e-02f, -4.72202757e-03f, 5.96038345e-03f, -5.54192141e-02f, 5.63770346e-02f, 7.35946149e-02f, -4.80992086e-02f, 1.97355896e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.89844713e-02f, -3.83100919e-02f, 1.33299842e-01f, -3.22690867e-02f, 4.92125154e-02f, -3.32806334e-02f, 1.20508991e-01f, -6.67534992e-02f, 1.87440664e-02f, -3.85473520e-02f,
  -3.91712831e-03f, -5.88272735e-02f, 3.03186867e-02f, 4.49234918e-02f, 2.59828893e-03f, 3.27308998e-02f, -8.15527216e-02f, -4.17777486e-02f, -7.61173526e-03f, -4.80785817e-02f,
  9.29006040e-02f, 5.97851025e-03f, -8.91740769e-02f, 4.45023645e-03f, 9.02807266e-02f, 3.85280587e-02f, 6.98584914e-02f, -3.69526469e-03f, 1.03774644e-01f, 4.44860896e-03f,
  1.23491049e-01f, 7.97788501e-02f, -4.40748557e-02f, -9.06136334e-02f, -5.03746467e-03f, 4.25608493e-02f, 4.82439399e-02f, -5.85172884e-02f, 9.09309983e-02f, 8.93548876e-02f,
  6.28620908e-02f, -3.32139842e-02f, 2.92485617e-02f, -8.56374428e-02f, -1.03454823e-02f, 2.66210362e-02f, -4.22056485e-03f, -3.45875334e-04f, 6.63465559e-02f, 1.04530931e-01f,
  5.40269576e-02f, 3.99801284e-02f, 2.30422579e-02f, 1.24375224e-01f, 5.66513613e-02f, -5.19404262e-02f, 4.27347645e-02f, 5.86466156e-02f, 7.20170960e-02f, -6.13123886e-02f,
  -4.21725474e-02f, 8.39164183e-02f, 1.22426048e-01f, -5.21566756e-02f, 4.08022292e-02f, 8.06822702e-02f, -1.92996682e-04f, -2.39323676e-02f, 9.40624177e-02f, 3.07204835e-02f,
  -1.36019578e-02f, -8.43819752e-02f, 4.30484861e-02f, -2.92583760e-02f, 2.31120903e-02f, 6.00127690e-02f, -4.84537743e-02f, -2.85100397e-02f, -1.15127889e-02f, -5.80205992e-02f,
  6.06727712e-02f, -2.65973788e-02f, -6.36283085e-02f, -2.96611115e-02f, 8.94491654e-03f, -8.53621736e-02f, -5.55579215e-02f, -2.84726545e-02f, -3.52948830e-02f, -4.27168980e-02f,
  1.09822445e-01f, -1.03595844e-02f, -3.71197723e-02f, 6.94078133e-02f, -4.57281359e-02f, -3.25930230e-02f, 8.13996792e-02f, 7.98616260e-02f, 5.17268702e-02f, -6.48597032e-02f,
  7.43783936e-02f, 3.52227204e-02f, 9.17344913e-03f, 9.17524993e-02f, 8.66489299e-03f, 5.49017005e-02f, -6.40063137e-02f, -4.36318740e-02f, 2.13452112e-02f, -8.01249295e-02f,
  -4.90088090e-02f, -5.86224422e-02f, 7.41271600e-02f, 5.42300791e-02f, 5.96118644e-02f, -1.77629441e-02f, 1.14196219e-01f, 3.99748236e-02f, -2.80518979e-02f, -5.26196286e-02f,
  3.11176796e-02f, -1.19391926e-01f, 1.37145922e-01f, 1.17830083e-01f, 2.89565995e-02f, 2.84851855e-03f, -6.48692548e-02f, 4.14849184e-02f, 6.73004389e-02f, 1.63576640e-02f,
  9.51960981e-02f, -1.07571026e-02f, 1.36134829e-02f, 1.00815997e-01f, 5.15676849e-02f, 4.71043587e-02f, -2.38838233e-02f, -9.73453559e-03f, 3.37757319e-02f, 3.19410302e-02f,
  -6.96427450e-02f, 1.93548948e-02f, -6.92739561e-02f, 1.28304707e-02f, 2.66134683e-02f, 1.08184412e-01f, 6.82970881e-02f, -4.07221355e-02f, 3.07638906e-02f, -6.01890637e-03f,
  -8.15045554e-03f, 4.54759710e-02f, 1.61803976e-01f, 5.57030849e-02f, 1.80332456e-02f, 3.36981528e-02f, 1.26058888e-02f, -5.45804389e-02f, -6.93354681e-02f, 9.30721238e-02f,
  1.75957230e-03f, -3.13254334e-02f, -3.90920676e-02f, 3.49007323e-02f, 1.32992733e-02f, -6.05375767e-02f, -4.37099226e-02f, -9.55809839e-04f, 2.73637660e-03f, 1.58550404e-02f,
  -4.84801494e-02f, -1.78330578e-02f, 9.86885205e-02f, 4.80822772e-02f, 4.72683869e-02f, -2.32038889e-02f, 4.33837846e-02f, 2.94856578e-02f, -1.58716217e-02f, -7.92452320e-02f,
  1.03399284e-01f, -6.10854998e-02f, 6.52695373e-02f, -1.08372241e-01f, -1.14554018e-01f, -1.12584494e-01f, -5.15690073e-02f, -3.28516737e-02f, 4.54298928e-02f, -4.69506569e-02f,
  -9.49647930e-03f, 7.48649612e-02f, -1.76164340e-02f, -5.54437786e-02f, -8.24464392e-03f, 8.49418622e-03f, -7.32903183e-02f, -4.33383845e-02f, 4.66797277e-02f, 1.92761663e-02f,
  1.98352020e-02f, -1.00635186e-01f, -3.45063880e-02f, 4.76657823e-02f, 6.14261962e-02f, -3.61374654e-02f, -1.98285896e-02f, 1.92413721e-02f, -1.06651254e-01f, -8.71398598e-02f,
  9.56820026e-02f, 1.52383953e-01f, -2.89813103e-03f, -3.55390422e-02f, 5.24138547e-02f, -7.37117529e-02f, 8.70224983e-02f, 7.38898516e-02f, 1.19812954e-02f, -3.80539745e-02f,
  4.71845903e-02f, 2.86260415e-02f, 2.72803418e-02f, 1.85777992e-02f, -8.06012303e-02f, 6.05889335e-02f, -1.27211273e-01f, 1.12846419e-01f, 8.01792741e-02f, 4.58978303e-02f,
  -8.78538340e-02f, -5.63560985e-02f, 4.48632538e-02f, 4.29728888e-02f, -3.72482389e-02f, 4.07341011e-02f, -6.62508160e-02f, 8.82842913e-02f, -3.06985825e-02f, 6.03244901e-02f,
  -2.95217279e-02f, -9.55149755e-02f, -7.22550452e-02f, -2.08734553e-02f, -8.95528272e-02f, -1.60352662e-02f, 3.08649527e-04f, -2.62107551e-02f, -2.17550411e-03f, -6.51696473e-02f,
  -5.74842207e-02f, 1.39622271e-01f, 1.60727240e-02f, 3.74767333e-02f, -4.15974893e-02f, -6.34332895e-02f, -7.55186984e-03f, 1.60233006e-02f, 5.09364530e-02f, 4.77417149e-02f,
  4.03657695e-03f, -9.71894637e-02f, -4.55263406e-02f, 9.64727327e-02f, -2.00468544e-02f, 8.17986801e-02f, -5.70234470e-02f, -1.11188188e-01f, 9.94946249e-03f, -1.08242825e-01f,
  7.26044476e-02f, -1.05116880e-02f, 7.03136101e-02f, -6.62990799e-03f, -6.72868267e-02f, 6.83249831e-02f, 9.85902622e-02f, -1.05862739e-02f, 7.71786422e-02f, 2.90954467e-02f,
  -1.84293911e-02f, 3.17274928e-02f, -1.43829547e-02f, 8.63610357e-02f, -8.50835145e-02f, 1.98064372e-02f, 5.29012643e-02f, -6.02025203e-02f, 1.90499326e-04f, 4.51787263e-02f,
  1.04910463e-01f, -3.70395929e-02f, -9.65311471e-03f, 1.52420014e-01f, -4.14021220e-03f, 8.26273039e-02f, 8.25673416e-02f, 1.50514573e-01f, 7.41224885e-02f, -1.47239761e-02f,
  -6.21733721e-03f, -2.63639223e-02f, 7.31546506e-02f, -4.98021618e-02f, -6.96512237e-02f, 2.30462383e-02f, -3.54315676e-02f, -3.24914418e-02f, 1.05850054e-02f, 5.31821959e-02f,
  -7.40646496e-02f, 6.68206364e-02f, -1.53535861e-04f, -8.98945108e-02f, 2.73637641e-02f, -1.81112438e-02f, 2.50982065e-02f, 7.94218630e-02f, -4.02399041e-02f, 8.72159936e-03f,
  -3.70322652e-02f, 8.01719353e-03f, 1.13432109e-02f, -4.80150506e-02f, 3.96281742e-02f, -1.01516031e-01f, 5.59836663e-02f, -1.43967522e-02f, -7.11881369e-02f, -2.23237611e-02f,
  -2.85336114e-02f, -6.05270937e-02f, -6.05683662e-02f, 1.05380900e-01f, -8.77116770e-02f, -7.59129226e-02f, -5.57581261e-02f, -3.07762604e-02f, -4.66398802e-03f, 2.53852503e-03f,
  3.81835029e-02f, 1.37061134e-01f, 3.95752899e-02f, 6.05647005e-02f, 2.62801666e-02f, -1.78107470e-02f, 3.89039479e-02f, -5.86363487e-02f, 7.79784620e-02f, 8.45683813e-02f,
  -8.34253579e-02f, 1.02129288e-01f, 9.47260037e-02f, 8.20496306e-03f, 5.04751178e-03f, -1.61786005e-02f, -1.75783485e-02f, 7.17663839e-02f, -3.06276809e-02f, -6.18505515e-02f,
  -1.49124503e-01f, -2.73460478e-01f, -9.83016640e-02f, -2.97630187e-02f, -1.56406716e-01f, -3.59985642e-02f, -2.32980475e-01f, -1.14976251e-02f, 3.43379788e-02f, -3.05254310e-01f,
  -6.23307936e-02f, -3.63897509e-03f, 6.62175789e-02f, 7.27773607e-02f, -1.31912343e-02f, -1.62060827e-01f, -1.34359850e-02f, -1.17342751e-02f, 1.87448770e-01f, -2.92205941e-02f,
  1.81159414e-02f, -1.11323416e-01f, 1.92165002e-01f, 1.45401895e-01f, -4.36916761e-02f, 9.92648862e-03f, 2.27208883e-02f, -1.00739852e-01f, 6.77917823e-02f, -2.61048436e-01f,
  -2.69185334e-01f, -1.26675636e-01f, -1.49354059e-02f, 1.47523712e-02f, -8.23047236e-02f, 4.63205278e-02f, 6.31059706e-02f, -2.39287727e-02f, -2.22094078e-03f, 1.27165029e-02f,
  -8.19116011e-02f, 8.10242374e-04f, -4.59244512e-02f, 3.26271541e-03f, -9.50541496e-02f, 3.21908370e-02f, 5.67911491e-02f, 7.88429528e-02f, 6.18892862e-03f, 1.32763432e-02f,
  2.03540362e-02f, 1.64256326e-03f, 6.78423718e-02f, 8.42585862e-02f, 1.31794274e-01f, -1.66265648e-02f, 2.27642450e-02f, -2.23970022e-02f, 9.19689909e-02f, -1.31301075e-01f,
  -9.64312628e-02f, 3.86377089e-02f, -3.54019590e-02f, 6.23355396e-02f, -1.46801192e-02f, -2.87787002e-02f, 2.97663305e-02f, -5.15608564e-02f, 4.26230533e-03f, 4.96577322e-02f,
  -1.76754836e-02f, -1.60480682e-02f, 2.49342946e-03f, -2.25996152e-02f, 9.28374976e-02f, -1.90089513e-02f, 3.14502418e-02f, -6.78405957e-03f, 8.92825648e-02f, -4.53577675e-02f,
  -1.33019798e-02f, 5.98025583e-02f, 3.49282138e-02f, 6.37624636e-02f, 3.20443651e-04f, -1.18768094e-02f, -6.10525049e-02f, -6.76010624e-02f, -7.07974657e-02f, -8.85193944e-02f,
  -5.54454327e-02f, 1.50098935e-01f, -1.42852277e-01f, 3.60095724e-02f, 8.68908037e-03f, 7.74131119e-02f, -9.34356600e-02f, -2.96610198e-03f, 3.40602994e-02f, -7.74065256e-02f,
  4.81502265e-02f, -8.72216653e-03f, -3.53345163e-02f, 5.25032170e-03f, 2.89313644e-02f, -6.80055246e-02f, -7.65469819e-02f, 7.10745677e-02f, 9.43957344e-02f, 1.28068915e-02f,
  -4.80435714e-02f, -4.39098068e-02f, -1.30238429e-01f, -4.19253577e-03f, -1.07532954e-02f, -5.07079214e-02f, -1.08673662e-01f, -9.26797539e-02f, 9.87965334e-03f, -1.57081902e-01f,
  -7.61520192e-02f, -1.05736934e-01f, -6.13309219e-02f, 7.29386359e-02f, 9.72560346e-02f, 7.29425550e-02f, -3.19042951e-02f, -7.34423026e-02f, 2.61251982e-02f, 6.75744265e-02f,
  -1.03826232e-01f, -9.54628398e-04f, -7.36013055e-02f, -2.47347169e-02f, 6.06509484e-02f, -3.09093460e-03f, 1.11611970e-01f, 1.49516135e-01f, -7.44046969e-03f, 6.39200537e-03f,
  2.03268696e-02f, 9.14701894e-02f, 7.02517405e-02f, -4.02441807e-02f, 4.24726456e-02f, -5.07479981e-02f, -7.22007966e-03f, -4.85681044e-03f, 2.59401686e-02f, 1.20144069e-01f,
  -9.27878544e-02f, -3.35366167e-02f, -1.15152143e-01f, -7.26419128e-03f, -1.24235243e-01f, 3.49210836e-02f, 3.16603854e-02f, -6.71883598e-02f, 2.45764218e-02f, -4.48214216e-03f,
  5.99696897e-02f, -4.84059155e-02f, -4.66014966e-02f, 7.29144439e-02f, 2.10282858e-02f, 3.93648855e-02f, 1.09923054e-02f, 4.87848148e-02f, -8.52741748e-02f, -5.92886098e-02f,
  -6.51959628e-02f, -6.53493851e-02f, 4.15853672e-02f, -3.59980240e-02f, -1.26254946e-01f, 7.02063963e-02f, 7.70271868e-02f, 8.92721117e-02f, -4.44937386e-02f, 3.65889296e-02f,
  -5.60000597e-04f, -2.12093117e-04f, -9.31977201e-03f, 8.46545547e-02f, 5.12158908e-02f, 3.27958688e-02f, 1.06123835e-01f, 1.49526156e-03f, 7.51618966e-02f, -3.87873985e-02f,
  -4.73970100e-02f, -7.03157932e-02f, -3.22938301e-02f, -1.03607029e-01f, 2.80342959e-02f, -5.26724011e-02f, -5.22874966e-02f, 6.16554655e-02f, -4.83003594e-02f, 4.81061637e-02f,
  8.27946290e-02f, 1.31186508e-02f, -1.02807812e-01f, 2.05177311e-02f, -5.41743562e-02f, 6.31544292e-02f, -4.42133583e-02f, 3.07577327e-02f, -6.10053167e-03f, -6.51077107e-02f,
  -2.29890458e-02f, 1.82562768e-02f, -3.57112437e-02f, 6.09464236e-02f, -7.15995207e-02f, -2.02140585e-02f, -4.11356241e-02f, -2.21664980e-02f, -5.95200583e-02f, -6.21506833e-02f,
  7.99671263e-02f, 3.22598107e-02f, -5.25194593e-03f, -8.02724212e-02f, 5.39627522e-02f, -8.79225954e-02f, 5.49968258e-02f, -5.72586916e-02f, -1.27892988e-02f, 6.41833292e-03f,
  7.40402639e-02f, 1.04925767e-01f, 8.56228471e-02f, -6.37291148e-02f, -6.82270387e-03f, -1.83268040e-02f, 5.53058833e-02f, 3.11807506e-02f, 5.15878834e-02f, -7.29707330e-02f,
  5.33973016e-02f, -2.69339085e-02f, -6.12735488e-02f, 5.27379215e-02f, -1.36071637e-01f, -1.86044127e-01f, -6.92449287e-02f, -7.80584440e-02f, -5.67492517e-03f, -4.67041545e-02f,
  -9.87165868e-02f, 4.27203141e-02f, 1.26283022e-03f, 1.47280609e-02f, 1.58601090e-01f, 1.09017111e-01f, 1.54718071e-01f, 2.13332567e-02f, 2.26590820e-02f, 8.54459330e-02f,
  8.50974768e-03f, -2.44424380e-02f, 8.05765837e-02f, 4.16659452e-02f, 4.45577018e-02f, 7.04791620e-02f, 2.93643232e-02f, -1.93566717e-02f, -4.94445525e-02f, 2.11579353e-01f,
  -7.22269490e-02f, -4.85944226e-02f, -2.30597425e-02f, 1.10827712e-02f, 2.27141324e-02f, 4.16802466e-02f, -7.09196031e-02f, 7.74684399e-02f, -4.72345687e-02f, 7.89301842e-02f,
  -1.13499619e-03f, 8.34706575e-02f, -1.60316955e-02f, -6.24498986e-02f, -2.56296061e-02f, 1.39716165e-02f, 7.85904452e-02f, 9.84632373e-02f, 6.08654208e-02f, 7.79253617e-02f,
  8.21189359e-02f, -7.48018101e-02f, -9.78157073e-02f, -2.68532056e-02f, 9.47185755e-02f, -6.88431505e-03f, -9.94280949e-02f, -5.35012372e-02f, -1.53892767e-02f, 7.13194311e-02f,
  1.14510432e-02f, 3.85341160e-02f, -5.13195060e-02f, 6.43661097e-02f, -4.32829820e-02f, -9.24466643e-03f, -3.47087272e-02f, -3.85505594e-02f, 1.19377021e-03f, 1.55822595e-03f,
  -4.66711000e-02f, 1.63254850e-02f, -3.18244938e-03f, -1.01674497e-02f, 4.09728810e-02f, 5.67343570e-02f, -7.19533162e-03f, 8.18026345e-03f, 5.87140433e-02f, 3.90065135e-03f,
  -1.60134397e-02f, -1.80685334e-02f, -1.17035871e-02f, 3.90970474e-03f, -3.91646139e-02f, -4.39923257e-02f, 3.10952705e-03f, 2.56278664e-02f, 5.54994754e-02f, -1.19112637e-02f,
  -8.07134658e-02f, 6.76753148e-02f, 5.25126792e-03f, 8.20077062e-02f, 6.58498034e-02f, -4.52540815e-02f, 4.13724706e-02f, -5.81008494e-02f, 1.40210614e-02f, -7.66840503e-02f,
  6.16652407e-02f, -5.88220805e-02f, 5.02821915e-02f, 7.20080733e-02f, 3.36322561e-02f, -6.44999519e-02f, -1.97150148e-02f, 5.66251241e-02f, -1.05898846e-02f, -3.61129157e-02f,
  -8.45118687e-02f, -7.99663961e-02f, -7.54500460e-03f, 5.79010183e-03f, -6.11208528e-02f, -7.06227217e-03f, -8.19454119e-02f, -3.42621468e-02f, -9.02841091e-02f, -7.76482597e-02f,
  -2.25475878e-01f, 5.80596291e-02f, -4.57855649e-02f, -1.47567749e-01f, 7.06416368e-02f, 1.83494031e-01f, 7.43680894e-02f, -3.03108543e-02f, -6.88649714e-02f, -8.09122808e-03f,
  8.63491967e-02f, -1.03603244e-01f, -8.47608671e-02f, -1.05011828e-01f, -2.11510301e-01f, -2.49031167e-02f, -1.70346841e-01f, -1.74326226e-01f, -9.14050862e-02f, 1.97593402e-02f,
  -1.20417409e-01f, -2.41691381e-01f, -1.17133282e-01f, -5.35867400e-02f, 5.25030904e-02f, 6.48413002e-02f, -6.94171945e-03f, 8.55835155e-03f, 1.33586243e-01f, -5.03800474e-02f,
  5.05605303e-02f, 7.76005462e-02f, -1.30568668e-01f, 2.15318855e-02f, 7.60571510e-02f, 2.45734546e-02f, 5.03805391e-02f, 1.77840106e-02f, 6.53285608e-02f, -7.18118399e-02f,
  -1.14174187e-02f, -4.97697778e-02f, 6.52080178e-02f, -2.24528816e-02f, -9.48777646e-02f, -1.00914352e-02f, -3.60519551e-02f, -6.65898025e-02f, 4.13768888e-02f, 1.13325477e-01f,
  6.56451434e-02f, -2.82037389e-02f, -4.56065638e-03f, 3.64881344e-02f, -2.88878158e-02f, -3.18253040e-02f, -7.60559365e-02f, 9.21484903e-02f, -7.98286274e-02f, -7.36196265e-02f,
  2.75675375e-02f, -5.51680177e-02f, 7.06184953e-02f, -5.33659458e-02f, 4.93636355e-03f, -2.93574366e-03f, 5.06439880e-02f, -5.78149445e-02f, -2.72323005e-02f, -3.02495994e-02f,
  3.98048051e-02f, -3.36730704e-02f, 2.33685086e-03f, -4.23190407e-02f, -1.42024467e-02f, 8.19700658e-02f, -3.76811549e-02f, -6.30187802e-03f, -2.90979277e-02f, -9.96474829e-03f,
  -2.89569683e-02f, -7.95849971e-03f, -5.34840897e-02f, 9.82527360e-02f, -1.07848234e-02f, 6.87950552e-02f, 1.89717319e-02f, -5.96947186e-02f, -9.44931805e-02f, -7.92966932e-02f,
  -6.47979006e-02f, -4.07054797e-02f, -1.04199894e-01f, 5.37367426e-02f, -6.44953027e-02f, 1.15690313e-01f, 1.04958333e-01f, -1.06275184e-02f, -4.33119573e-02f, -8.84383637e-03f,
  -7.55552128e-02f, 9.34018381e-03f, -2.51057073e-02f, 1.85540679e-03f, -8.42761844e-02f, -3.95367593e-02f, -3.74694392e-02f, 1.03308484e-02f, -7.89427012e-02f, 1.47644684e-01f,
  2.54618265e-02f, -8.35714638e-02f, -1.22893542e-01f, 4.99474481e-02f, -2.79483609e-02f, 3.15440521e-02f, -5.54279163e-02f, -7.59743452e-02f, -1.13838173e-01f, -7.29818717e-02f,
  4.37067188e-02f, -9.69482735e-02f, -5.17251082e-02f, 2.04371884e-02f, -1.18027104e-03f, -1.76051464e-02f, -1.23576760e-01f, -6.42173663e-02f, 6.05295738e-03f, 6.10299259e-02f,
  7.30144093e-03f, 7.08309561e-02f, 8.70459080e-02f, 1.18590519e-01f, 7.41239870e-03f, 5.26430085e-02f, 8.85028094e-02f, 9.29654539e-02f, 1.06125571e-01f, 4.65802401e-02f,
  2.58481968e-02f, -4.82341321e-03f, 9.03064385e-02f, 9.90578625e-03f, 4.95555699e-02f, -7.42007270e-02f, 3.96253094e-02f, 8.46203715e-02f, -4.37792251e-03f, 4.37290184e-02f,
  1.18104815e-01f, -3.27498354e-02f, 4.29711230e-02f, 1.33856479e-02f, -4.60870229e-02f, 4.24177013e-02f, -2.64295819e-03f, 2.58313306e-02f, 8.81547928e-02f, 5.31448983e-02f,
  -2.61448789e-02f, -5.02153710e-02f, -8.06784704e-02f, 3.49486731e-02f, 2.65401155e-02f, 2.97921915e-02f, -5.97326830e-02f, -6.96395263e-02f, 6.81615546e-02f, -1.81404874e-02f,
  -1.75671708e-02f, -6.64763153e-02f, 5.40264621e-02f, -2.34805737e-02f, -9.46793556e-02f, 3.45489457e-02f, 2.49109790e-02f, 2.45132707e-02f, -7.50258714e-02f, -1.55873026e-03f,
  4.76748832e-02f, 5.05248178e-03f, 3.99649888e-02f, -5.66088874e-03f, 8.31791759e-02f, -1.11274995e-01f, 1.39121460e-02f, 1.09337971e-01f, 2.11397093e-02f, -4.72989231e-02f,
  -7.91460450e-04f, -7.59323463e-02f, -8.95762965e-02f, -5.19090593e-02f, -4.25599217e-02f, -3.14027518e-02f, 6.84541836e-02f, -5.22123575e-02f, -5.51322773e-02f, 2.15356220e-02f,
  -4.21388038e-02f, -1.13400985e-02f, 5.87696768e-02f, -6.89469427e-02f, 8.27696323e-02f, 1.01655327e-01f, 9.41017792e-02f, -2.82053879e-05f, 7.32078180e-02f, 4.44754958e-02f,
  -3.75099406e-02f, 1.55856190e-02f, 3.03022452e-02f, 5.38589433e-02f, 8.66800323e-02f, -2.99591776e-02f, 7.06331208e-02f, 1.01852216e-01f, 1.76335312e-02f, -3.36304083e-02f,
  3.37203108e-02f, 3.44853885e-02f, -5.61662279e-02f, -1.64330509e-02f, -1.04832510e-02f, -6.09226003e-02f, 2.59294417e-02f, -5.40054701e-02f, -1.03074303e-02f, 6.80398569e-02f,
  6.46791011e-02f, -1.07319221e-01f, -7.56460577e-02f, -8.82045925e-03f, 6.46853866e-03f, 4.09129150e-02f, 5.89818321e-02f, 6.04126230e-02f, 2.72863116e-02f, -9.76939425e-02f,
  1.43024012e-01f, -6.45472948e-03f, -8.96455795e-02f, 6.54905736e-02f, -3.94678116e-02f, -7.08910227e-02f, -1.60144955e-01f, 4.24323753e-02f, -2.57938099e-03f, 2.48502214e-02f,
  9.83995125e-02f, 1.37091190e-01f, 1.69660464e-01f, 1.17022641e-01f, 3.48251723e-02f, -3.31362560e-02f, 3.79636907e-03f, -2.93304753e-02f, 9.94272064e-03f, 1.12592056e-01f,
  -2.10330598e-02f, -7.91297108e-02f, 6.75838068e-02f, 6.06995039e-02f, -1.29313126e-01f, 1.09678239e-01f, 3.59702744e-02f, 3.38745862e-02f, -1.98106356e-02f, -4.77593578e-02f,
  9.96083692e-02f, -6.56797141e-02f, 1.17317215e-01f, 1.24798290e-01f, -8.83822069e-02f, -1.32434303e-02f, 3.60796042e-02f, -3.02780401e-02f, -1.81438271e-02f, 1.55189261e-02f,
  5.83447814e-02f, -7.28540868e-02f, -5.22957258e-02f, 2.11362392e-02f, 7.72215426e-03f, 8.80573131e-03f, -1.31946176e-01f, -3.90767977e-02f, 2.69117616e-02f, -8.13938528e-02f,
  7.31275156e-02f, 4.36982475e-02f, 2.21842192e-02f, 9.13780034e-02f, 3.76856737e-02f, -6.29882934e-03f, -3.83059978e-02f, 3.13016288e-02f, 7.87944347e-02f, 2.80256867e-02f,
  2.55456716e-02f, 3.60836759e-02f, 1.42879803e-02f, -5.23418747e-02f, -4.12383154e-02f, -1.27770705e-02f, 3.48766334e-02f, -6.13258854e-02f, 2.10418236e-02f, -6.89140931e-02f,
  1.78132914e-02f, 9.29392641e-04f, -1.43593242e-02f, 6.18890561e-02f, 9.92799643e-03f, -6.25100285e-02f, 5.75387478e-02f, 7.01687858e-02f, -4.44683470e-02f, 5.14016785e-02f,
  -7.97791556e-02f, -2.53575598e-03f, 6.91853173e-04f, -5.28358370e-02f, -4.26833630e-02f, 2.59736702e-02f, -2.26387437e-02f, 5.85481152e-02f, -2.88105626e-02f, 1.23934476e-02f,
  8.12595189e-02f, 6.06814250e-02f, 7.78209344e-02f, -3.94500010e-02f, -2.09045466e-02f, -4.57577072e-02f, 2.99568847e-02f, 5.49993552e-02f, -1.00498842e-02f, -6.50736094e-02f,
  5.08922199e-03f, 3.86015363e-02f, -6.24823235e-02f, 3.67239267e-02f, -4.63459417e-02f, 1.77029613e-02f, -8.41034949e-02f, 6.49081543e-02f, 2.65510213e-02f, -8.51916596e-02f,
  -7.08094165e-02f, 8.43901485e-02f, 1.95058361e-02f, 1.38139978e-01f, -1.76003668e-02f, 1.16526932e-01f, 7.54178390e-02f, -2.34012888e-03f, 9.02397484e-02f, 3.61486524e-03f,
  4.03340384e-02f, -1.07857950e-01f, -1.77414790e-02f, -1.11264594e-01f, -1.30401820e-01f, -1.46920547e-01f, -6.33657798e-02f, -9.25295129e-02f, -9.36099291e-02f, -1.35538891e-01f,
  4.58040386e-02f, 5.18672774e-03f, 9.53692496e-02f, 1.17051832e-01f, -1.65524594e-02f, 1.20436577e-02f, -1.23277083e-01f, 3.44763808e-02f, 1.57645464e-01f, -1.97042176e-03f,
  -1.64139332e-04f, 2.41107196e-02f, 1.26481317e-02f, -4.88014147e-02f, -1.12581767e-01f, 1.70657190e-03f, -6.60211667e-02f, 3.88930589e-02f, 4.17193733e-02f, -7.04585686e-02f,
  8.19383711e-02f, -7.16663003e-02f, -3.22292633e-02f, -3.27238366e-02f, 1.35539062e-02f, -3.89776602e-02f, 4.57270183e-02f, 1.15466848e-01f, -5.92183657e-02f, -3.35327387e-02f,
  -2.13859108e-04f, -2.28623543e-02f, 5.58512136e-02f, 7.98873156e-02f, -6.86267316e-02f, -3.37774567e-02f, 2.57122219e-02f, 3.97606045e-02f, 6.89605102e-02f, 8.12880918e-02f,
  5.39060086e-02f, -3.18147317e-02f, 6.23331703e-02f, 8.51534009e-02f, -6.23028316e-02f, 1.36646014e-02f, 5.44684753e-02f, -2.17536632e-02f, -6.99452357e-03f, -2.04811301e-02f,
  6.69301152e-02f, -4.83566038e-02f, 4.62783277e-02f, 3.52400206e-02f, 8.73297229e-02f, 8.08114931e-02f, -2.66064834e-02f, -1.91916693e-02f, 8.58568251e-02f, 8.15048665e-02f,
  -9.21995938e-02f, -6.70679063e-02f, -5.55701694e-03f, -2.08533071e-02f, 2.34288722e-02f, -7.66364411e-02f, 1.97670851e-02f, 3.23815644e-02f, 2.31722016e-02f, -4.95906770e-02f,
  9.59207211e-03f, -5.14037088e-02f, -8.50692987e-02f, 2.30818260e-02f, -9.82179190e-04f, 5.79168759e-02f, -3.64763141e-02f, -8.01306292e-02f, 3.64621021e-02f, 5.35538932e-03f,
  9.96137485e-02f, -1.03904426e-01f, 1.80614479e-02f, 9.62962862e-03f, 4.97564338e-02f, 1.00591131e-01f, 1.00488111e-03f, -2.64510233e-02f, -7.57645592e-02f, -2.10876539e-02f,
  -6.28830642e-02f, 8.77664909e-02f, 4.74314243e-02f, -1.01330373e-02f, -5.74710406e-02f, -2.50929222e-02f, 2.10525151e-02f, -8.75466969e-03f, 3.78628541e-03f, -4.88992110e-02f,
  1.63042489e-02f, -4.63617854e-02f, 6.14415854e-02f, 4.96823154e-02f, -4.18448746e-02f, 7.88235068e-02f, 1.08037882e-01f, -6.49434999e-02f, 1.73299927e-02f, 2.85793142e-03f,
  -1.35291994e-01f, -1.77616686e-01f, -2.44838774e-01f, -1.05122374e-02f, -1.67253897e-01f, -9.72033143e-02f, -2.47269660e-01f, 2.37453748e-02f, 1.81542277e-01f, -3.04268122e-01f,
  -1.83987379e-01f, -3.65749076e-02f, -2.68676970e-03f, 1.22212274e-02f, 7.44986385e-02f, -2.36588284e-01f, -2.00362042e-01f, -7.45242760e-02f, 2.18435545e-02f, -2.21796520e-02f,
  4.87228893e-02f, 3.10336500e-02f, 4.84403521e-02f, 7.61449412e-02f, -3.60728018e-02f, 1.29564986e-01f, -8.34750310e-02f, -1.11868128e-01f, -4.83766347e-02f, -2.21556768e-01f,
  -3.26585412e-01f, 3.27582136e-02f, 7.48095289e-02f, -2.00322494e-02f, -6.55940920e-02f, -3.15112881e-02f, -1.22883089e-01f, 6.04315251e-02f, 1.77932475e-02f, -7.35160336e-02f,
  -5.45615070e-02f, 4.26337915e-03f, 1.25659211e-02f, -8.83644745e-02f, 5.38489223e-02f, -6.62949076e-03f, 6.61067814e-02f, 6.35850430e-02f, -1.09198289e-02f, -6.72520176e-02f,
  8.87829531e-03f, 1.15366476e-02f, 9.60503817e-02f, 1.69944558e-02f, 1.31596833e-01f, -2.41796635e-02f, 9.64033902e-02f, 1.58301651e-01f, 6.40684515e-02f, 3.34490389e-02f,
  2.69471426e-02f, -1.70081425e-02f, 4.00032066e-02f, 1.63059924e-02f, 1.38957892e-02f, 1.73643529e-02f, 3.79191618e-03f, -4.33533154e-02f, 6.14192300e-02f, -1.41185662e-02f,
  -5.91343418e-02f, -6.84551671e-02f, 2.94016255e-03f, -5.22280857e-02f, -5.34733944e-02f, 2.18565129e-02f, -3.08891870e-02f, -4.45725210e-02f, -3.07774525e-02f, 1.20606385e-02f,
  2.69852243e-02f, 4.05327678e-02f, -4.96726744e-02f, 7.02968091e-02f, 1.72757991e-02f, 1.18056173e-02f, 8.68578441e-03f, 9.41078141e-02f, 2.35630712e-03f, -2.81708641e-03f,
  -3.45512815e-02f, 9.24884304e-02f, -7.00870007e-02f, -3.10438368e-02f, -7.87276949e-04f, -9.61905345e-02f, -2.87228283e-02f, 5.01195490e-02f, 1.57825258e-02f, -1.55449156e-02f,
  2.29263026e-02f, -4.70139906e-02f, -9.76276547e-02f, 9.57913026e-02f, -1.05588615e-01f, 2.89829485e-02f, -1.00110106e-01f, 1.52200656e-02f, 7.58202001e-02f, -3.62688899e-02f,
  -4.96815145e-02f, -2.41247062e-02f, -9.69267413e-02f, -2.16043759e-02f, 4.38590385e-02f, -4.58381362e-02f, -9.35637951e-02f, 1.44411903e-02f, 3.29575837e-02f, -2.76093720e-03f,
  -1.16178535e-01f, -9.89219546e-02f, -1.55863911e-01f, 3.60820517e-02f, 1.23033449e-01f, 5.50055830e-03f, -9.65272784e-02f, 3.00025903e-02f, 5.47499582e-02f, -1.47108696e-02f,
  -2.58705001e-02f, -4.01913375e-02f, 5.85428104e-02f, 4.18041162e-02f, 4.41865027e-02f, -3.15073878e-02f, 3.60985845e-02f, -1.00555234e-01f, -9.32410546e-03f, -4.01649922e-02f,
  1.24189630e-01f, -3.69025907e-03f, -1.33628845e-02f, -9.97820348e-02f, 3.11098788e-02f, 9.78568383e-03f, 1.08790502e-01f, 3.50366607e-02f, 3.46181393e-02f, 5.51249012e-02f,
  3.27700153e-02f, 3.06974016e-02f, 2.21323641e-03f, 2.99663730e-02f, 9.22277048e-02f, 2.86391973e-02f, 1.16510186e-02f, 4.91562374e-02f, 6.82953671e-02f, -6.12868555e-02f,
  2.61730123e-02f, 3.97517979e-02f, 1.35619519e-02f, -8.52089524e-02f, -5.27912378e-02f, 8.10600221e-02f, -2.47314610e-02f, -2.45218445e-02f, -6.77561834e-02f, 6.62607746e-03f,
  7.49708340e-02f, -5.45314103e-02f, -7.19482824e-02f, 2.78411228e-02f, 3.94973680e-02f, -3.55247483e-02f, -5.27688451e-02f, 2.89355386e-02f, 5.04834726e-02f, 2.66852714e-02f,
  1.38838619e-01f, -9.03520063e-02f, 8.60195309e-02f, 1.16601689e-02f, 8.50175172e-02f, -3.78005169e-02f, -2.55821496e-02f, -2.05620136e-02f, 3.91739644e-02f, 1.27748551e-03f,
  -3.14369090e-02f, 2.89522801e-02f, 6.85604960e-02f, 3.64126414e-02f, -2.67057531e-02f, -8.03958997e-02f, 6.88570663e-02f, 1.88572574e-02f, -1.03985660e-01f, -3.15845124e-02f,
  4.96477634e-02f, 7.17884675e-02f, 7.69351125e-02f, 8.76283199e-02f, -1.16418935e-02f, 9.84081328e-02f, 7.14662969e-02f, 1.93798039e-02f, -3.45231742e-02f, 6.55313255e-04f,
  -2.78720055e-02f, -1.27553746e-01f, 3.07680387e-02f, -6.58968166e-02f, 3.60445008e-02f, 5.28327860e-02f, -4.76735607e-02f, 6.43191561e-02f, 7.01407343e-03f, -9.31110978e-02f,
  5.53684197e-02f, -5.27836531e-02f, -9.96426269e-02f, -2.42438801e-02f, -8.24283361e-02f, -5.88058941e-02f, -8.64869636e-03f, 7.81139955e-02f, -1.41403377e-01f, -9.86646563e-02f,
  -3.68223302e-02f, -5.21628745e-02f, 2.32458208e-02f, -1.09238386e-01f, 1.01021223e-01f, 5.58416285e-02f, 1.21954018e-02f, -9.04241111e-03f, 1.96595397e-02f, -8.77207890e-02f,
  1.35533154e-01f, 1.62254050e-01f, 8.87918100e-02f, -9.83748734e-02f, -1.90531194e-01f, -1.57154143e-01f, -2.41692007e-01f, -9.22776386e-02f, -8.99753273e-02f, 1.33924577e-02f,
  -1.11407437e-03f, -7.14619607e-02f, -2.11179573e-02f, 7.90088996e-02f, 6.49957657e-02f, -8.08858573e-02f, 1.18259154e-01f, 9.36535895e-02f, -5.05742840e-02f, -8.86832848e-02f,
  -6.39209822e-02f, 1.10780753e-01f, -4.17317823e-02f, 4.04258631e-02f, 4.02041227e-02f, 2.74343640e-02f, 3.92405614e-02f, 6.71655610e-02f, 5.21808630e-03f, 3.12075883e-01f,
  1.26751542e-01f, 4.58094254e-02f, -5.11515029e-02f, 8.58288780e-02f, -2.13634595e-02f, 8.55154246e-02f, 7.22776121e-03f, 3.79426964e-02f, -2.30651777e-02f, 5.90267032e-02f,
  -6.56794608e-02f, 3.30684870e-03f, 1.12659529e-01f, -5.92921823e-02f, -8.39118510e-02f, 1.62799116e-02f, -2.85990499e-02f, 1.14593655e-01f, 1.44593073e-02f, 2.80053113e-02f,
  -8.23651999e-02f, -7.29667246e-02f, -9.09273028e-02f, -2.80968715e-02f, -5.34135662e-02f, -3.24911401e-02f, -9.23321769e-02f, -3.65767404e-02f, 2.41852608e-02f, 9.67415944e-02f,
  -1.73975065e-01f, 2.75740400e-02f, -3.38383801e-02f, -6.23491779e-03f, -2.21594833e-02f, -7.50150308e-02f, -9.58446935e-02f, -7.22829700e-02f, -1.01936564e-01f, 9.01936665e-02f,
  -7.50355050e-02f, -4.52136062e-02f, -5.19738048e-02f, 4.31309640e-02f, -1.44272387e-01f, -5.57699390e-02f, 4.46239635e-02f, 9.01172683e-03f, 2.76654703e-03f, 3.16629224e-02f,
  -2.53067655e-03f, 8.02216828e-02f, -1.54320933e-02f, -1.62074082e-02f, 3.14586759e-02f, -6.14730865e-02f, 1.03151845e-03f, -2.56043989e-02f, 1.59753151e-02f, -4.42207232e-02f,
  -1.56202679e-03f, -6.64956570e-02f, -1.38498163e-02f, 8.95246193e-02f, -1.38906091e-02f, -1.46115422e-02f, 9.10603106e-02f, 7.13737011e-02f, -4.25157556e-03f, -2.13172659e-02f,
  7.35074840e-03f, 4.01305174e-03f, -5.06357290e-03f, 5.24890460e-02f, 7.18798563e-02f, 5.24469540e-02f, -2.19543604e-03f, 6.85895085e-02f, 3.77335623e-02f, 9.93634388e-02f,
  4.23472710e-02f, -1.40414089e-02f, -7.15146810e-02f, 8.95161107e-02f, -3.52707244e-02f, -8.51539150e-02f, -6.41560182e-02f, -3.32621834e-03f, -1.30393177e-01f, -1.67524949e-01f,
  -1.50195956e-01f, -3.86621314e-03f, 5.04793115e-02f, 2.56698299e-02f, 5.71924038e-02f, 2.11187918e-02f, 1.44942086e-02f, -2.01262720e-02f, -3.86892632e-03f, -3.90587114e-02f,
  -3.39797772e-02f, -2.92438082e-02f, 3.10915112e-02f, -3.83543260e-02f, -4.14255671e-02f, -1.42500019e-02f, 3.95128727e-02f, -7.17695057e-02f, 3.78454700e-02f, 7.07361102e-02f,
  2.50105634e-02f, -4.07106951e-02f, -4.71214987e-02f, -1.05528980e-01f, 4.90263961e-02f, -9.18115005e-02f, 8.29275604e-03f, -9.20413360e-02f, 5.63831301e-03f, -1.17102869e-01f,
  3.80611829e-02f, 3.26861776e-02f, -4.09383476e-02f, 1.02867782e-02f, -4.14230675e-02f, -7.76340663e-02f, -4.23551612e-02f, -7.73699358e-02f, 3.77521589e-02f, -6.54170439e-02f,
  3.79767269e-02f, -1.78142376e-02f, -7.30671212e-02f, -6.82396293e-02f, 3.40866335e-02f, -2.08600294e-02f, 1.67154763e-02f, -2.61856951e-02f, 8.88640583e-02f, 6.87505230e-02f,
  -2.31038202e-02f, 1.56640653e-02f, -3.09485346e-02f, 6.90676123e-02f, -4.32937741e-02f, 7.77229145e-02f, -3.11102569e-02f, 7.08548725e-02f, -1.57375969e-02f, 8.13062713e-02f,
  6.85322285e-02f, 7.41264001e-02f, -1.57507500e-04f, 5.69283888e-02f, -6.82682768e-02f, -2.50738934e-02f, -7.05652463e-04f, 2.60066390e-02f, 2.10694391e-02f, -1.25682736e-02f,
  -1.42468661e-02f, 2.57838666e-02f, -3.88614647e-02f, -3.38593423e-02f, 2.33839955e-02f, 7.22923651e-02f, -8.46739113e-02f, -1.10526355e-02f, 5.74140362e-02f, 5.13635203e-02f,
  2.50808951e-02f, 7.64391348e-02f, -4.55640890e-02f, -7.61239529e-02f, -5.20476922e-02f, -8.13329741e-02f, -3.80813070e-02f, -2.09673531e-02f, 7.04024658e-02f, 8.90956521e-02f,
  5.03547378e-02f, -1.04318410e-02f, -3.57018672e-02f, 9.02969018e-03f, 2.81128436e-02f, 6.21820567e-03f, 1.08546643e-02f, 6.83952076e-03f, 4.21797410e-02f, -5.03361039e-02f,
  1.23723298e-02f, -2.87082046e-03f, -1.98516566e-02f, -1.36419870e-02f, 4.62435372e-02f, 2.58222502e-02f, -7.46200085e-02f, 3.13331597e-02f, 2.68447194e-02f, 8.88348073e-02f,
  -1.07442364e-02f, -1.24837533e-02f, -3.96753289e-03f, -3.81732956e-02f, -6.81132125e-03f, 3.48456278e-02f, 2.90092621e-02f, 8.29202905e-02f, -1.42963175e-02f, 2.80351546e-02f,
  3.46697904e-02f, 1.44901210e-02f, 1.32113937e-02f, 6.25399500e-02f, 8.98896083e-02f, -4.01618928e-02f, -1.20880239e-01f, 6.69587255e-02f, 1.15799375e-01f, 3.95964496e-02f,
  9.02868807e-02f, -2.95476951e-02f, -6.13694377e-02f, -1.06867231e-01f, 1.18865054e-02f, 1.55611094e-02f, -6.59206808e-02f, 3.38523765e-03f, 7.87836909e-02f, -3.08985021e-02f,
  -4.67804894e-02f, 4.53586951e-02f, 2.58161034e-02f, -7.88806900e-02f, -4.10685129e-02f, -7.70601630e-02f, -9.25018266e-02f, -5.73782660e-02f, -3.92217562e-02f, -9.09474343e-02f,
  -2.76785735e-02f, 3.02717015e-02f, -7.30666704e-03f, -3.62894870e-02f, -7.67957941e-02f, 2.75199972e-02f, 2.96104588e-02f, -1.36738084e-02f, 1.48314117e-02f, 2.84650084e-02f,
  -3.85595337e-02f, 5.84630519e-02f, 4.57927436e-02f, -7.88312629e-02f, 7.16721937e-02f, -6.50743544e-02f, -6.90322071e-02f, -2.19294578e-02f, -8.79946649e-02f, -5.98468222e-02f,
  -3.78345437e-02f, -1.36302672e-02f, -8.46676603e-02f, -3.43281440e-02f, 5.90107627e-02f, 9.85191204e-03f, 3.62485126e-02f, 7.09998757e-02f, -7.72020891e-02f, 8.32145959e-02f,
  1.41137158e-02f, -4.53348197e-02f, -3.10804117e-02f, 7.42198154e-02f, 6.44652871e-03f, -5.17394394e-02f, -1.32990740e-02f, -1.79440472e-02f, 3.08052599e-02f, 7.91580230e-02f,
  -5.96380122e-02f, -4.71901782e-02f, -2.33790316e-02f, -9.45454370e-03f, -8.84877741e-02f, -1.12181650e-02f, 3.00326329e-02f, -3.81166935e-02f, -4.71095853e-02f, -2.70739547e-03f,
  6.17358088e-03f, -8.32411125e-02f, -2.97271702e-02f, -8.27862397e-02f, 4.95493822e-02f, -9.70647205e-03f, 6.27362281e-02f, -5.48330992e-02f, -8.68595392e-02f, 5.05768210e-02f,
  1.31703705e-01f, -3.26180756e-02f, 8.50395337e-02f, -4.09725532e-02f, -9.12875310e-03f, -8.37633014e-03f, 2.47595794e-02f, 4.30144072e-02f, -2.65172217e-02f, -2.24621892e-02f,
  -6.07564487e-02f, -1.10709734e-01f, 2.89249960e-02f, -1.84348517e-03f, 4.99267653e-02f, -9.36915278e-02f, -3.20018530e-02f, -6.66344017e-02f, 7.77230188e-02f, -2.62863953e-02f,
  8.51521865e-02f, -3.63564119e-02f, -3.05673033e-02f, -1.97969545e-02f, -1.47156464e-02f, -2.15067714e-03f, 4.55653556e-02f, -5.23661599e-02f, -1.39448289e-02f, -8.19891319e-02f,
  5.36132008e-02f, -5.52250333e-02f, 4.54466715e-02f, 1.07526541e-01f, 2.05168694e-01f, 7.50301629e-02f, 4.64783162e-02f, 1.50899276e-01f, 8.18950087e-02f, 6.06446080e-02f,
  6.22634031e-02f, -4.00559269e-02f, -1.63406450e-02f, 2.51228362e-02f, -2.05361377e-02f, 1.13705278e-03f, 5.81163168e-02f, 4.12276164e-02f, 1.01266213e-01f, 4.34878729e-02f,
  -2.35981424e-03f, -3.92257273e-02f, -1.17981080e-02f, 3.99568900e-02f, -1.51006151e-02f, 7.93116242e-02f, -8.16216394e-02f, -1.11167535e-01f, -5.70580736e-02f, -1.32932737e-02f,
  -1.50050789e-01f, -9.61798504e-02f, 1.46122882e-02f, -4.72355029e-03f, 1.08628965e-03f, 3.92130911e-02f, 1.31953470e-02f, -1.32952973e-01f, 2.27936450e-02f, 2.16999725e-02f,
  -3.30481455e-02f, 4.97878194e-02f, 3.99470888e-02f, -3.85193564e-02f, 1.26389805e-02f, -2.17246171e-02f, -9.66811255e-02f, 6.67935163e-02f, 5.32995984e-02f, 6.59225285e-02f,
  -2.68154254e-04f, -4.90257777e-02f, -5.69974445e-02f, 7.78580159e-02f, 6.89936206e-02f, 1.12125285e-01f, -7.21426681e-03f, 6.02486869e-03f, 3.96161266e-02f, 3.57205933e-03f,
  -1.19182318e-02f, 7.84087107e-02f, 7.02250153e-02f, -5.52091151e-02f, 2.67393123e-02f, 4.36006710e-02f, -7.51114544e-03f, -3.62610008e-04f, -1.77654922e-02f, 1.21109426e-01f,
  -2.49032825e-02f, -1.89791787e-02f, 9.90865659e-03f, 2.62822025e-02f, 3.88875380e-02f, 4.54111136e-02f, 4.22707200e-02f, -9.58467871e-02f, 2.34860484e-03f, -4.53333892e-02f,
  -3.38261873e-02f, -3.45562100e-02f, -7.34865218e-02f, -8.03758577e-02f, -5.27640544e-02f, 1.24151103e-01f, 8.96792114e-02f, -1.88546465e-03f, -5.46953119e-02f, -2.21306384e-02f,
  -3.98706868e-02f, 4.36286964e-02f, -1.06049990e-02f, -5.85333705e-02f, -3.18303751e-03f, -1.00422785e-01f, 3.87038291e-02f, -4.71925326e-02f, -3.95896845e-02f, -6.70531765e-02f,
  -6.35291710e-02f, -2.25255210e-02f, 3.57858418e-03f, 2.73904894e-02f, 6.63227811e-02f, -4.09351401e-02f, 2.06958540e-02f, 7.04525113e-02f, 5.98900877e-02f, -5.12215197e-02f,
  2.33738013e-02f, 1.04914010e-02f, -2.01370269e-02f, 1.07029356e-01f, 2.58631445e-02f, 1.47204427e-02f, 4.25637737e-02f, 6.96484745e-02f, -1.91997159e-02f, -3.29617262e-02f,
  1.30814701e-01f, -5.31130433e-02f, -9.90632772e-02f, -4.23480682e-02f, 2.05862743e-04f, -4.95088361e-02f, -1.32933363e-01f, -6.59516007e-02f, -3.76861505e-02f, 1.91302020e-02f,
  7.00430349e-02f, 8.54013935e-02f, 1.22979738e-01f, -4.38628644e-02f, -3.38751301e-02f, -5.25578186e-02f, -9.18983594e-02f, 9.13789198e-02f, -1.03478450e-02f, 3.12525104e-03f,
  -2.34997980e-02f, 6.85919868e-03f, 4.18616310e-02f, -1.16628138e-02f, 5.69369979e-02f, -4.05707955e-02f, -7.45942518e-02f, 2.61376221e-02f, -2.15670913e-02f, -1.41630322e-02f,
  -3.32117751e-02f, -8.68729502e-02f, -9.45795886e-03f, 7.54531249e-02f, -4.26760539e-02f, -4.29895781e-02f, -9.84063372e-02f, -6.50094748e-02f, -2.09966712e-02f, -4.57790941e-02f,
  7.20906630e-02f, 2.67475005e-02f, 4.81024943e-02f, -5.47708897e-03f, 2.43761390e-02f, 3.59263532e-02f, 6.83181211e-02f, 3.01659890e-02f, -9.56686661e-02f, -7.04319850e-02f,
  -6.18265122e-02f, -3.94305810e-02f, -9.13074147e-03f, -4.35185023e-02f, -9.61138401e-03f, 5.97377010e-02f, -9.99294594e-02f, 3.30120400e-02f, 1.39439749e-02f, -1.62620079e-02f,
  4.49529812e-02f, 8.08943212e-02f, 2.33407710e-02f, -7.03239487e-03f, 5.28628267e-02f, 1.41630098e-02f, 6.92665949e-02f, -3.16388197e-02f, 4.01984677e-02f, -4.77458611e-02f,
  -1.27111590e-02f, -3.23171392e-02f, 7.03151003e-02f, 2.12679096e-02f, -4.70958538e-02f, 9.94205847e-02f, 1.28792832e-02f, 3.14756185e-02f, 3.30706909e-02f, -8.19332153e-02f,
  6.30128607e-02f, -2.64212843e-02f, 7.08709508e-02f, 9.77508724e-02f, -4.77336198e-02f, 1.69202946e-02f, 5.72761074e-02f, 4.48141014e-03f, -2.19073873e-02f, -6.45944551e-02f,
  -6.76443651e-02f, 7.97228590e-02f, -2.45277900e-02f, 3.46500017e-02f, -3.43257152e-02f, 8.91772062e-02f, 5.44478036e-02f, -7.95689505e-03f, 6.09093383e-02f, -5.96906208e-02f,
  9.98287724e-05f, 4.96625900e-02f, 5.25051951e-02f, -3.48157138e-02f, 7.55358338e-02f, 2.09308993e-02f, 5.55274822e-03f, 2.16685026e-03f, -1.19797781e-03f, -4.04040441e-02f,
  2.68387366e-02f, 4.21800092e-02f, 4.33213301e-02f, -1.19600240e-02f, -5.98326176e-02f, 1.19371369e-01f, -3.27848122e-02f, -6.29297420e-02f, 7.37466151e-03f, 2.38137580e-02f,
  2.64620692e-01f, -2.67970324e-01f, -3.97371128e-02f, 1.77039161e-01f, 4.92727831e-02f, 6.11976609e-02f, -1.18132651e-01f, -3.55606601e-02f, 1.10770538e-02f, -7.63202533e-02f,
  -2.66599935e-02f, 6.94852741e-03f, 6.79781660e-03f, 2.09337231e-02f, 6.58862591e-02f, -1.00303501e-01f, -2.77039036e-02f, 5.01812883e-02f, 1.93398386e-01f, 8.66865069e-02f,
  -6.03274815e-02f, 3.78806219e-02f, -4.79711890e-02f, -6.98401034e-02f, -6.03646450e-02f, 7.93309882e-02f, 1.06281005e-02f, -6.10718690e-03f, 1.60963900e-04f, -1.78024799e-01f,
  3.84505838e-02f, 4.90307845e-02f, 1.09508835e-01f, -3.99911031e-02f, 8.09981525e-02f, 3.37624066e-02f, -5.63512780e-02f, 5.75253507e-03f, -1.21421693e-02f, 2.72008441e-02f,
  -7.62379095e-02f, -6.47906214e-02f, -8.13181251e-02f, 2.73114536e-02f, -3.50111201e-02f, 2.92895325e-02f, -3.65588181e-02f, 7.99815431e-02f, 7.86551312e-02f, 2.14148164e-02f,
  -9.41076651e-02f, 9.27293766e-03f, -3.88013832e-02f, -2.52596699e-02f, -2.72536520e-02f, -1.36441141e-02f, -1.48906827e-01f, -2.01130193e-02f, -1.45251967e-03f, -1.14692286e-01f,
  -2.07318831e-02f, -2.14194991e-02f, 3.07176877e-02f, -1.75763536e-02f, 8.14813375e-03f, 6.96472004e-02f, -2.43939385e-02f, -4.83375192e-02f, -5.83236441e-02f, -4.82589044e-02f,
  9.52734277e-02f, -2.88733784e-02f, -1.53586990e-03f, 2.66643185e-02f, -7.24969953e-02f, 1.18547864e-03f, -3.45054679e-02f, -5.23172393e-02f, -5.12110852e-02f, 2.19214875e-02f,
  3.33805680e-02f, -2.02730838e-02f, 5.02533093e-02f, 3.62779796e-02f, 5.61136194e-02f, 1.10525228e-02f, 2.25990973e-02f, 5.07018678e-02f, 4.50130925e-02f, -4.14197193e-03f,
  -6.46252334e-02f, 1.00426540e-01f, 1.13156885e-01f, -1.25526547e-01f, 4.43438627e-02f, 6.78352192e-02f, 1.06018089e-01f, -8.63701105e-03f, 4.79635298e-02f, -2.55638529e-02f,
  3.95170301e-02f, -1.65146380e-03f, 2.70256493e-03f, -1.09509818e-01f, 4.14183475e-02f, 1.94489416e-02f, -4.97947074e-02f, 7.40239546e-02f, -4.64054272e-02f, -5.46443760e-02f,
  -4.16624993e-02f, 1.15382023e-01f, 5.80742843e-02f, 2.86446996e-02f, 7.79978186e-02f, 1.71391383e-01f, 5.36701456e-02f, 2.08016708e-02f, 2.21287017e-03f, -4.46501747e-02f,
  -2.65379429e-01f, -7.82453865e-02f, 1.73423607e-02f, 1.05733545e-02f, 3.88062410e-02f, -1.02451369e-02f, -1.32153388e-02f, -7.45206028e-02f, -5.31437881e-02f, -1.25869080e-01f,
  4.27580737e-02f, 1.78175047e-02f, 1.59834214e-02f, 9.09517333e-03f, -1.58232078e-01f, -9.06181633e-02f, -1.09692745e-01f, -8.57126862e-02f, -3.29143889e-02f, 7.94369495e-04f,
  6.77270517e-02f, -7.70630389e-02f, -1.27655461e-01f, -9.02416483e-02f, 4.96982187e-02f, -1.19958021e-01f, 4.17162143e-02f, -4.80809100e-02f, 3.45955491e-02f, 6.34075403e-02f,
  1.38063626e-02f, -8.95191059e-02f, 7.11809993e-02f, 7.45030120e-03f, -3.54568660e-02f, -4.22464646e-02f, 2.39325240e-02f, -8.09069872e-02f, 4.99848649e-02f, -1.53238531e-02f,
  1.19410679e-02f, -2.36414243e-02f, -8.04373436e-03f, -6.47883192e-02f, -3.76328900e-02f, -4.17144671e-02f, 4.58265990e-02f, -8.69340524e-02f, -2.25754175e-02f, 1.01753630e-01f,
  6.69269562e-02f, 3.69731225e-02f, 7.29027465e-02f, -4.45101410e-02f, 7.58313313e-02f, -6.05480485e-02f, -9.68544036e-02f, 6.55346513e-02f, -1.09369628e-01f, -1.26119614e-01f,
  -5.63780144e-02f, -1.11163901e-02f, -4.29265611e-02f, -9.63429585e-02f, 4.83347103e-03f, 4.95845936e-02f, -3.20699774e-02f, -2.31155977e-02f, -9.01579037e-02f, -5.10585792e-02f,
  9.60161502e-04f, 8.84732977e-02f, -4.73618694e-02f, -4.74787503e-03f, 9.38825216e-03f, -7.62069523e-02f, -3.95727493e-02f, -4.03937250e-02f, 4.78054434e-02f, 4.92331162e-02f,
  -4.72133644e-02f, 9.13867801e-02f, 4.90486994e-02f, 3.65670621e-02f, 8.15076753e-02f, -9.63924751e-02f, -6.03401661e-02f, 1.99937671e-02f, -2.85978080e-03f, -6.53197467e-02f,
  -9.17179585e-02f, 3.75737213e-02f, -6.71788380e-02f, -3.37990336e-02f, -3.53871174e-02f, 4.55036983e-02f, 5.50169088e-02f, -1.06989138e-01f, 1.22996293e-01f, -7.40508689e-03f,
  6.22416623e-02f, -2.71836929e-02f, 7.54169226e-02f, -5.78420237e-02f, -2.30934545e-02f, -1.60807986e-02f, -3.49604785e-02f, -2.37124227e-02f, -6.24570735e-02f, 9.34374332e-02f,
  3.42804752e-02f, -3.99366654e-02f, -1.24289259e-01f, 2.13104635e-02f, -1.06185898e-02f, -8.89630464e-04f, -3.12520899e-02f, -4.64331619e-02f, -8.78289938e-02f, -2.17832893e-01f,
  1.78845435e-01f, 7.42851198e-03f, 1.59046441e-01f, 1.59314558e-01f, 7.53844604e-02f, 9.49053243e-02f, 1.65447190e-01f, 4.76808064e-02f, 1.54641703e-01f, -1.73489302e-02f,
  2.35772040e-02f, -5.00016101e-02f, -4.18425053e-02f, 4.10492858e-03f, -6.84815124e-02f, 2.61128843e-02f, 9.37628597e-02f, -3.31534892e-02f, 1.33409500e-01f, 7.23721012e-02f,
  6.51952252e-02f, 1.11271506e-02f, -7.95114562e-02f, 7.47474506e-02f, 7.37611577e-02f, 2.75465976e-02f, -2.80896854e-02f, -9.96320993e-02f, -4.96854261e-02f, 1.01080099e-02f,
  -1.18932247e-01f, 1.44715905e-01f, -8.28437805e-02f, 3.44695151e-02f, 8.51676241e-02f, 2.27449574e-02f, 5.02055287e-02f, 4.32542078e-02f, -6.40133629e-03f, -4.59464546e-03f,
  -2.42063813e-02f, -5.96938170e-02f, 4.64568101e-02f, 3.87557372e-02f, 7.76863098e-02f, -4.14737910e-02f, 7.11437389e-02f, 3.06085143e-02f, -2.14524940e-03f, -6.14663847e-02f,
  5.29227953e-04f, 1.69668831e-02f, -2.30603032e-02f, -9.16784331e-02f, -5.38964719e-02f, -8.22508242e-03f, 1.68435031e-03f, 1.08173795e-01f, 8.89726821e-03f, 4.72991914e-02f,
  -6.35461062e-02f, 1.64876021e-02f, 1.24924764e-01f, -3.33212502e-02f, -7.80051053e-02f, -6.76206797e-02f, 2.51595471e-02f, -5.45489416e-02f, -5.22614270e-02f, -7.89128467e-02f,
  -3.54480394e-03f, 5.30471615e-02f, 7.83896260e-03f, 4.66048568e-02f, -9.72641855e-02f, -1.36557491e-02f, 6.32232726e-02f, -4.39267159e-02f, 2.28248537e-02f, 3.34637277e-02f,
  3.70865688e-02f, 8.88882950e-02f, 2.76898500e-02f, -1.23913707e-02f, 5.59133850e-02f, 1.07940275e-03f, -1.94688197e-02f, -8.76892880e-02f, -2.27374327e-03f, -2.60562468e-02f,
  1.56949542e-03f, 5.38382046e-02f, -1.63736254e-01f, -4.55356315e-02f, 6.01718649e-02f, -6.70120046e-02f, -2.32054591e-02f, -7.06699863e-02f, 1.31995097e-01f, 5.61916865e-02f,
  -5.76536879e-02f, 1.81340910e-02f, -1.99665874e-02f, -9.39836949e-02f, 5.56778274e-02f, 4.05209921e-02f, -3.58263329e-02f, 8.99554119e-02f, 6.17898852e-02f, 3.36013362e-02f,
  2.75805146e-02f, 7.53147006e-02f, 3.78995785e-03f, -4.82263416e-02f, -1.48769924e-02f, -7.27782995e-02f, 2.94797905e-02f, -6.23548916e-03f, 7.36594871e-02f, 8.52743685e-02f,
  1.48288846e-01f, -1.31560579e-01f, -6.94225356e-02f, -2.11983006e-02f, 2.77072471e-02f, -9.63174477e-02f, -1.76291801e-02f, -1.01479158e-01f, -2.81387120e-02f, -1.29886463e-01f,
  -1.12536922e-02f, -6.36040047e-02f, -1.50327431e-02f, -6.37499839e-02f, 2.53292341e-02f, -1.27133444e-01f, -4.15598005e-02f, 1.63100585e-02f, 8.23984668e-02f, 1.68064125e-02f,
  -1.02106944e-01f, 5.37486076e-02f, 8.55976269e-02f, -1.36203999e-02f, -1.47780374e-01f, 3.84494811e-02f, -7.10306084e-03f, -9.70807597e-02f, -1.35699213e-01f, -1.62956938e-02f,
  -1.48782000e-01f, -2.86764577e-02f, -5.19497506e-02f, 4.48648147e-02f, -5.98060666e-03f, 9.00013149e-02f, -2.67248191e-02f, 2.31342316e-02f, 4.24894504e-02f, -6.44339696e-02f,
  -3.65753993e-02f, 6.62815291e-03f, -8.26661810e-02f, 4.12696935e-02f, -5.90636581e-02f, -1.26322694e-02f, 3.37974206e-02f, 1.12772010e-01f, -5.79065457e-02f, 5.91932647e-02f,
  1.08448102e-03f, 1.10999845e-01f, 7.07547516e-02f, 1.63876377e-02f, -7.10838102e-03f, 3.84019092e-02f, -2.98310481e-02f, 5.41754253e-02f, -6.80760369e-02f, 8.41342360e-02f,
  9.27741360e-03f, -2.07586214e-02f, -1.18364152e-02f, 5.21207415e-02f, 4.18778881e-02f, -2.66815796e-02f, 1.44278081e-02f, 3.40773985e-02f, 3.10842544e-02f, -2.01826426e-03f,
  4.94461283e-02f, 6.26550615e-02f, -2.17607040e-02f, -7.92628974e-02f, -8.56260583e-03f, -4.37760875e-02f, 6.35494813e-02f, -2.07386147e-02f, 2.33628764e-03f, -1.06418757e-02f,
  5.23261167e-02f, -7.23124743e-02f, 4.01216038e-02f, -8.36889893e-02f, 4.42200974e-02f, -5.92697114e-02f, 3.02262716e-02f, -9.64332148e-02f, -1.16717391e-01f, -5.91279343e-02f,
  8.02457184e-02f, 8.10215846e-02f, -5.56318238e-02f, -2.99384240e-02f, 9.53828171e-02f, -4.10978608e-02f, 2.26329789e-02f, -4.50090244e-02f, 7.31033683e-02f, -7.13122776e-03f,
  -4.01511416e-02f, 1.36436233e-02f, -5.45345396e-02f, 4.24985886e-02f, 8.35537985e-02f, 8.79734159e-02f, -3.39756310e-02f, 2.20902842e-02f, -1.51783079e-02f, -7.24204704e-02f,
  -5.81607372e-02f, 1.57291871e-02f, 1.02509961e-01f, -2.49337085e-04f, -4.76843230e-02f, 1.00672975e-01f, -4.76954058e-02f, 6.95206523e-02f, 3.70203541e-03f, 1.33909017e-01f,
  9.76416841e-02f, -1.01369672e-01f, -1.99949145e-01f, 1.23275392e-01f, -1.12972453e-01f, -6.45633861e-02f, -1.43342271e-01f, 1.18073948e-01f, 9.61953104e-02f, -8.22127387e-02f,
  -2.36586854e-03f, -5.66867273e-03f, 3.55580822e-02f, 2.86902823e-02f, 2.15044860e-02f, -1.53227493e-01f, -1.78582355e-01f, -8.29174891e-02f, 1.27830803e-01f, 2.77913432e-03f,
  2.49369387e-02f, -5.32690510e-02f, 6.92912489e-02f, 5.79119362e-02f, 1.59365162e-02f, -8.08276981e-02f, -2.31454268e-01f, -1.38162374e-01f, -2.19832584e-01f, -2.75640190e-01f,
  -2.30294541e-01f, 1.24526605e-01f, 4.63018492e-02f, -4.45074290e-02f, -1.24501279e-02f, -1.13004735e-02f, 8.14705044e-02f, 3.25109586e-02f, -4.94957529e-03f, 5.93689308e-02f,
  1.45283863e-02f, 6.60248026e-02f, 1.23539388e-01f, -3.41896750e-02f, 9.36661437e-02f, 1.41315246e-02f, 8.97349566e-02f, 4.24051248e-02f, 2.31719464e-02f, -3.60671654e-02f,
  1.94905512e-02f, -7.93651268e-02f, -9.09102894e-03f, -7.52449129e-03f, 5.95886447e-02f, -1.41143473e-02f, -9.86813605e-02f, -6.39115274e-02f, -3.58011108e-03f, -4.57004160e-02f,
  -4.80830483e-02f, -7.44702518e-02f, -1.02274962e-01f, 1.13418892e-01f, -4.31784689e-02f, 8.03381875e-02f, -2.30417959e-02f, -5.82808293e-02f, 5.00226917e-04f, 4.38511744e-03f,
  7.86315426e-02f, 4.62886058e-02f, 6.88761771e-02f, 4.88965735e-02f, -1.12027295e-01f, -2.31036879e-02f, -5.33548556e-02f, -4.46691141e-02f, -3.97659093e-03f, -1.20132407e-02f,
  4.98998836e-02f, -2.87676062e-02f, 5.07711899e-03f, -5.89043833e-02f, -5.03865704e-02f, -4.25692312e-02f, 3.03902104e-02f, 3.85910645e-02f, 4.17086184e-02f, 8.83872584e-02f,
  1.95020542e-01f, -1.31671518e-01f, -2.41659693e-02f, 6.76646084e-02f, -1.46168913e-03f, 5.48832193e-02f, -3.19571747e-03f, -2.57272348e-02f, 1.52318540e-03f, -2.07781512e-02f,
  1.47818250e-03f, -5.91462664e-02f, 7.56201148e-02f, 4.38595796e-03f, 3.08753364e-02f, 8.78758132e-02f, 1.05469681e-01f, -1.12208799e-01f, -1.28427390e-02f, -5.82508557e-03f,
  1.11026624e-02f, 4.98234741e-02f, -3.69779766e-02f, 3.22253630e-02f, 3.27160284e-02f, -3.78830656e-02f, 5.94600709e-03f, -5.94085827e-02f, 6.06334358e-02f, -1.78553294e-02f,
  -1.63400859e-01f, -2.39651427e-02f, -2.42210110e-03f, -1.82437807e-01f, -7.04910159e-02f, -3.49825025e-02f, -6.66840747e-02f, -9.10190269e-02f, -5.96554801e-02f, -8.03741291e-02f,
  2.75990106e-02f, 5.30980825e-02f, 2.72047333e-02f, 6.05967082e-02f, 3.29890922e-02f, 8.04835334e-02f, -5.13469279e-02f, 7.17898086e-02f, -6.09287433e-02f, -3.49808224e-02f,
  1.95223037e-02f, -1.61277428e-01f, -1.29638508e-01f, -9.42470431e-02f, 1.44012074e-03f, 8.84335041e-02f, -6.96539506e-02f, -2.55063046e-02f, -3.79816140e-03f, -6.20433129e-02f,
  2.35470235e-01f, -1.16392069e-01f, -5.10598086e-02f, -4.62324060e-02f, -1.50848618e-02f, -7.08714947e-02f, -6.15708530e-02f, -1.22536570e-02f, -9.15997326e-02f, -8.70335549e-02f,
  -5.74673563e-02f, -6.71900287e-02f, -5.99733368e-02f, -5.07096201e-02f, 3.11374068e-02f, 5.21161454e-03f, 1.12905391e-02f, 4.43450026e-02f, 6.19770922e-02f, 8.86985585e-02f,
  7.99249560e-02f, -1.57684681e-03f, -7.94232190e-02f, -5.26339300e-02f, -1.02569833e-02f, -2.84060428e-04f, -5.83799519e-02f, 5.61358780e-02f, -1.28269317e-02f, 7.86226243e-02f,
  7.33922496e-02f, 8.85038730e-03f, 6.70717806e-02f, 2.08889078e-02f, 5.97804673e-02f, 7.90093020e-02f, -1.19203711e-02f, -3.65717406e-03f, -6.64989790e-03f, 1.33937625e-02f,
  -4.30172309e-02f, -4.25698012e-02f, 1.72406919e-02f, -7.87969772e-03f, 3.30645591e-02f, -7.01311231e-02f, 1.41582545e-02f, -6.37457669e-02f, 1.10421004e-03f, -1.26243522e-02f,
  3.19450423e-02f, -5.63215166e-02f, -5.75242518e-03f, 9.57164094e-02f, -9.49693173e-02f, -7.23432451e-02f, 4.35535610e-02f, -5.51319961e-03f, -3.63135303e-04f, -6.72216639e-02f,
  1.06728949e-01f, 1.00721689e-02f, 7.83027783e-02f, 4.17573052e-03f, 8.49455781e-03f, -6.00760058e-03f, 8.46120715e-02f, 8.54902565e-02f, -1.32802334e-02f, -1.69847123e-02f,
  4.97062318e-02f, -2.79520862e-02f, 3.53062972e-02f, -4.83177193e-02f, -7.41541758e-02f, -1.93262249e-02f, -1.95031567e-03f, 1.90334525e-02f, -2.84421183e-02f, -3.21309492e-02f,
  1.55513342e-02f, 3.61195281e-02f, -6.70081452e-02f, -8.92113149e-02f, 4.92804721e-02f, 1.27551518e-02f, -2.13074256e-02f, 4.71797325e-02f, 5.89234941e-02f, 6.80108443e-02f,
  -1.54512525e-01f, -1.89832244e-02f, 1.13527849e-02f, 2.98162159e-02f, -7.37610757e-02f, -3.08465902e-02f, -2.91108824e-02f, -4.90134396e-02f, 3.59043255e-02f, 6.66345209e-02f,
  -1.01263091e-01f, -9.62831602e-02f, 7.37382770e-02f, -5.68804443e-02f, 3.66450138e-02f, 9.32007432e-02f, 6.55938536e-02f, 5.61328456e-02f, -2.04590689e-02f, -1.24775656e-01f,
  -4.49603703e-03f, -8.19516405e-02f, -1.52506009e-01f, -1.11583096e-03f, -1.76873691e-02f, -2.49802619e-02f, -5.20813167e-02f, -9.38410237e-02f, 7.31429160e-02f, 1.20454855e-01f,
  -9.03700199e-03f, -1.68256685e-02f, 6.71270862e-02f, -3.34928446e-02f, -3.42584699e-02f, -2.70042885e-02f, 3.10968533e-02f, 1.96562577e-02f, -4.20341827e-02f, 9.19510517e-03f,
  8.99331644e-02f, -5.12417220e-02f, 1.34094059e-03f, -4.94284406e-02f, -1.35224879e-01f, 5.24909496e-02f, 1.01300925e-02f, 4.53097261e-02f, 5.41912690e-02f, -9.73857567e-02f,
  -2.19068788e-02f, -7.48522356e-02f, -5.73397093e-02f, 6.26458880e-03f, -8.21227580e-02f, -8.75657946e-02f, -4.17828327e-03f, 7.69457640e-03f, 3.08843469e-03f, -2.62415409e-02f,
  -5.47807328e-02f, -3.48555781e-02f, 7.93026481e-03f, 5.45490086e-02f, -1.86911821e-02f, 8.16176906e-02f, 6.51925430e-02f, 4.46765199e-02f, 5.73142543e-02f, 4.49991375e-02f,
  -3.27554531e-02f, -3.40798050e-02f, -4.23485450e-02f, 7.59171471e-02f, -2.68933661e-02f, -1.10123076e-01f, 4.68497165e-02f, 4.57822643e-02f, -2.16961838e-02f, 1.67437326e-02f,
  -2.07751635e-02f, -2.75590457e-02f, -8.75865167e-04f, -5.82835190e-02f, -1.33066615e-02f, 1.01374015e-01f, -6.61421791e-02f, 4.09058221e-02f, -3.27548459e-02f, 8.62837490e-03f,
  -1.03081562e-01f, 8.56737606e-03f, 1.96934510e-02f, -1.86372194e-02f, -7.98357278e-02f, 7.23355934e-02f, -5.68475947e-02f, 8.16358104e-02f, -1.02448784e-01f, 2.07535969e-03f,
  -1.86875332e-02f, 1.18062776e-02f, -2.32116841e-02f, 1.73706021e-02f, -1.30023554e-01f, 7.49573261e-02f, 6.43048529e-03f, 6.34458987e-03f, -2.70093363e-02f, -1.23673946e-01f,
  8.58604256e-03f, -9.29992497e-02f, -1.32457048e-01f, -1.86796710e-02f, -3.13067213e-02f, -8.71284828e-02f, 2.42179688e-02f, -8.39707106e-02f, -6.33969754e-02f, -1.91796888e-02f,
  -1.97884873e-01f, 1.02832332e-01f, -1.96909253e-02f, -3.10252625e-02f, 4.66034003e-02f, -4.41995822e-02f, 2.92571411e-02f, 7.99006745e-02f, 9.41730440e-02f, -1.42160486e-02f,
  1.77834872e-02f, -4.69018333e-02f, 8.69239867e-02f, -6.09272569e-02f, 1.77536272e-02f, -3.38383652e-02f, 1.84464157e-02f, 5.80360517e-02f, -1.26559123e-01f, -6.87885508e-02f,
  5.26549928e-02f, -8.84537101e-02f, -1.07635431e-01f, 2.34894417e-02f, -3.43475863e-03f, 5.73285148e-02f, 5.20753488e-03f, -2.46162508e-02f, 6.61660805e-02f, 1.08097225e-01f,
  8.59782249e-02f, -2.29100883e-02f, 4.12755795e-02f, 2.14677490e-02f, 3.72663327e-02f, 7.44091496e-02f, 8.85428712e-02f, 8.47510770e-02f, 7.89249837e-02f, -6.20681681e-02f,
  1.21633284e-01f, -4.08760309e-02f, -2.76735034e-02f, 2.97910869e-02f, -8.94610211e-02f, -5.71849272e-02f, -4.11921479e-02f, -5.48800104e-04f, -3.38690430e-02f, -1.92259382e-02f,
  1.66829210e-02f, -7.45918974e-02f, -1.03207961e-01f, -8.49647149e-02f, -8.40878114e-02f, -5.94160445e-02f, 7.06961751e-02f, 4.30132337e-02f, 7.33254617e-03f, -8.96880869e-03f,
  1.04885772e-02f, -6.70493320e-02f, -4.61979024e-02f, -3.72230895e-02f, -5.94240576e-02f, 6.03210516e-02f, 4.98743728e-02f, 6.30084872e-02f, 2.46823411e-02f, 2.95444429e-02f,
  -7.03741461e-02f, 4.02731746e-02f, -1.51911108e-02f, 5.62095828e-02f, 1.47328889e-02f, -6.77540302e-02f, 8.84931237e-02f, -2.56098416e-02f, -7.42223263e-02f, 3.03740781e-02f,
  -1.82028394e-02f, -2.90329065e-02f, 4.93547656e-02f, -3.67791988e-02f, 3.61901075e-02f, -5.03151305e-02f, -7.00427517e-02f, 2.07192749e-02f, -4.01602276e-02f, 8.77584815e-02f,
  8.35222304e-02f, -5.43222353e-02f, 7.79927671e-02f, 9.19999182e-03f, -4.83442061e-02f, -4.92967367e-02f, 9.52275191e-03f, -9.91347656e-02f, -4.14329581e-02f, -8.21959823e-02f,
  3.27126831e-02f, 1.89803150e-02f, 7.41718411e-02f, -5.68819679e-02f, 5.73501848e-02f, 2.98767928e-02f, 5.04019223e-02f, -1.57869607e-02f, -6.51336759e-02f, -7.67345950e-02f,
  -2.23437417e-02f, -7.75991380e-02f, -3.30727338e-03f, -7.14610517e-02f, -3.39705013e-02f, -6.14157878e-02f, -2.02437583e-02f, 3.68183218e-02f, 1.82630587e-02f, 2.52751373e-02f,
  6.52711615e-02f, -5.66186681e-02f, -3.20802256e-02f, 1.00874498e-01f, 6.47997558e-02f, 1.24647934e-02f, 7.99353346e-02f, -1.95919666e-02f, -5.71514331e-02f, 3.59909330e-03f,
  4.97348867e-02f, 5.41862808e-02f, 6.04723440e-03f, -1.69459498e-03f, 1.06623061e-01f, 9.75539442e-03f, 3.52880880e-02f, 1.18499091e-02f, 5.56167625e-02f, 1.24287389e-01f,
  1.19248874e-01f, 7.53717124e-02f, 3.90387736e-02f, 7.83718750e-02f, -1.91199370e-02f, 1.00892752e-01f, -1.40380077e-02f, -8.46098736e-03f, -5.03016151e-02f, 4.57411222e-02f,
  1.02711655e-01f, 7.81388655e-02f, 7.62462169e-02f, 1.14546239e-01f, 3.78166288e-02f, 2.93393340e-02f, 1.75318941e-02f, 6.57700673e-02f, -6.68718815e-02f, -5.70524558e-02f,
  6.30494058e-02f, 4.86286022e-02f, -5.30795902e-02f, 7.62651786e-02f, 5.63625954e-02f, -8.19633827e-02f, -4.67267409e-02f, -5.74678667e-02f, 9.17522982e-02f, 6.30859882e-02f,
  6.27350211e-02f, -4.73712608e-02f, -1.78413503e-02f, -1.17717974e-01f, -1.70490369e-02f, 8.86769816e-02f, -3.99171710e-02f, 7.79741108e-02f, 7.36994436e-03f, 8.44435692e-02f,
  -3.41870636e-02f, -1.37196621e-02f, 3.49940471e-02f, -9.42668170e-02f, 3.39321122e-02f, 5.96836731e-02f, -3.69925722e-02f, -9.20727104e-03f, -7.91252926e-02f, 3.21086720e-02f,
  -3.68406735e-02f, 5.28891012e-02f, 9.28474739e-02f, -8.93950686e-02f, 1.09428011e-01f, 8.20813030e-02f, 6.81233555e-02f, -3.88402380e-02f, -8.27926025e-03f, 2.64785681e-02f,
  -6.85621351e-02f, 1.07286654e-01f, 7.06476122e-02f, -3.47595476e-02f, -5.98759428e-02f, 9.95619744e-02f, -6.02387218e-03f, -6.48442889e-03f, 2.68446505e-02f, 4.04816717e-02f,
  -2.42045755e-03f, 1.49830386e-01f, -1.71790458e-02f, -3.53996530e-02f, -3.23115811e-02f, -8.23689438e-03f, -7.11428467e-03f, 4.06192504e-02f, 5.85503988e-02f, -4.93857414e-02f,
  -6.15338236e-02f, 7.66147226e-02f, -4.38085161e-02f, 3.47147472e-02f, -6.42197430e-02f, 7.71780089e-02f, -7.09565505e-02f, 6.85348287e-02f, 6.64295554e-02f, 1.46056404e-02f,
  -4.71224897e-02f, 1.74151082e-02f, -6.13474026e-02f, -3.83314746e-03f, 2.24234853e-02f, -7.86622614e-03f, 7.09843710e-02f, 7.12742880e-02f, 2.30344906e-02f, -9.14407223e-02f,
  2.60154426e-01f, -2.47231975e-01f, -1.35491639e-01f, 1.01191118e-01f, -7.05148801e-02f, -6.22156821e-02f, -1.17706694e-01f, -5.39103374e-02f, -5.32812923e-02f, -5.03336973e-02f,
  5.98469842e-03f, 2.18331724e-01f, 1.88402653e-01f, 9.60486457e-02f, 1.08940296e-01f, -1.30375519e-01f, -5.14222682e-02f, 1.94577888e-01f, 2.88080454e-01f, -3.90613987e-03f,
  4.74277809e-02f, 1.46734547e-02f, 5.91284521e-02f, 8.09739083e-02f, -1.39682904e-01f, 2.52859481e-02f, -6.60565346e-02f, -1.96735889e-01f, -1.19127460e-01f, -1.53501973e-01f,
  9.38261598e-02f, -3.32071334e-02f, 3.84957045e-02f, 6.43855110e-02f, -9.00206789e-02f, -7.77343893e-03f, 5.89192845e-02f, -3.25283930e-02f, -4.03598957e-02f, -7.64760152e-02f,
  2.23188940e-02f, -6.83296472e-02f, 6.17816448e-02f, -6.40799329e-02f, -5.87874278e-02f, 2.21820623e-02f, -9.15696174e-02f, -3.94032821e-02f, -4.45199385e-03f, -2.86755748e-02f,
  -6.45594224e-02f, -8.32762569e-02f, 4.65792720e-04f, 2.26009339e-02f, -2.24000262e-03f, 2.09106114e-02f, -1.27434641e-01f, -7.37717375e-02f, -8.31744596e-02f, -6.48946241e-02f,
  -2.36354489e-02f, -3.44262496e-02f, 8.41596816e-03f, 4.29277122e-02f, 9.02005211e-02f, -5.26850000e-02f, 6.78294152e-03f, 4.90806997e-04f, 4.38324921e-02f, -2.10665260e-03f,
  -1.87751036e-02f, 8.69621560e-02f, -2.43195333e-02f, -2.71076965e-03f, 3.61354947e-02f, -6.56548291e-02f, -5.17329574e-02f, 2.67916117e-02f, -5.34540787e-02f, 4.91025597e-02f,
  8.41033384e-02f, 9.37474426e-03f, -6.24585487e-02f, 1.24571873e-02f, -3.00868247e-02f, -4.90056025e-03f, -2.05219500e-02f, -4.88556437e-02f, 5.06783836e-02f, 4.43916507e-02f,
  1.26087219e-01f, 3.52652371e-02f, 1.45887351e-02f, 8.86163488e-02f, -6.35888055e-02f, -3.72928567e-02f, 3.35186571e-02f, 4.18107919e-02f, -1.79986563e-02f, -2.10256875e-02f,
  1.44175058e-02f, 3.84191982e-02f, -4.68901433e-02f, -9.45272446e-02f, 9.32426378e-02f, -5.31979278e-02f, -2.53102388e-02f, 1.40183672e-01f, 2.68102391e-03f, -7.77377784e-02f,
  -2.03892309e-02f, 4.39498462e-02f, 2.36029088e-01f, 7.75029138e-02f, -3.80937709e-03f, 2.02981830e-01f, 7.04122782e-02f, -4.83339950e-02f, 1.92346796e-01f, 2.94663385e-02f,
  9.79182869e-02f, 1.25498861e-01f, -1.32955283e-01f, 6.32157847e-02f, -5.93381189e-02f, -7.43547529e-02f, -9.80403870e-02f, 7.30462149e-02f, -2.61095986e-02f, 7.76625946e-02f,
  -7.96371475e-02f, -8.60444084e-02f, 6.78491890e-02f, -4.22586203e-02f, 1.12955540e-01f, 1.68158367e-04f, 5.21654375e-02f, 1.00799739e-01f, -8.17846581e-02f, -8.53131562e-02f,
  6.95936531e-02f, 7.94255808e-02f, -4.55992222e-02f, -5.06898090e-02f, 8.78027901e-02f, -6.50918186e-02f, 7.30820447e-02f, -2.35227905e-02f, -4.35700268e-02f, 1.39075801e-01f,
  -2.64977720e-02f, -3.40876058e-02f, -1.31077379e-01f, -4.76540662e-02f, -7.04730898e-02f, 4.14468274e-02f, 4.45976779e-02f, -2.53561456e-02f, 4.44027893e-02f, -1.65177844e-02f,
  -4.88305949e-02f, 3.74632664e-02f, 3.60926539e-02f, 5.05497344e-02f, 7.22386688e-03f, 3.79677564e-02f, 2.58342680e-02f, 1.11930639e-01f, 9.16028675e-03f, 7.76000693e-02f,
  1.04632095e-01f, 3.76326963e-02f, 8.89503434e-02f, 2.97996234e-02f, 1.14518758e-02f, -5.17458580e-02f, -9.87493768e-02f, 1.04801618e-01f, -6.00424521e-02f, -1.41561655e-02f,
  -6.47423193e-02f, 1.74969528e-02f, -5.70272394e-02f, 5.32211512e-02f, 9.26725939e-03f, -9.63065922e-02f, -1.53675200e-02f, -2.36649085e-02f, -3.70623767e-02f, 6.68395311e-02f,
  1.64028071e-02f, 3.07630319e-02f, 8.07204917e-02f, 7.27978349e-02f, 8.34634677e-02f, 5.99822700e-02f, -4.65288758e-02f, -9.36360937e-03f, 9.47567821e-02f, 2.85675209e-02f,
  -5.73575199e-02f, 7.47553334e-02f, 3.17422226e-02f, 2.73967329e-02f, 1.24821393e-02f, -8.44649523e-02f, -3.31232622e-02f, 2.81323511e-02f, 1.82803143e-02f, -5.34987543e-04f,
  -1.66073188e-01f, -1.29688978e-01f, 4.75059673e-02f, -6.09509938e-04f, -6.16946965e-02f, -1.18344408e-02f, -5.46113513e-02f, 1.00442268e-01f, -5.20884851e-03f, -3.60197909e-02f,
  4.05669399e-03f, -4.87577468e-02f, 2.99841836e-02f, -1.45364674e-02f, 3.38335559e-02f, -6.85410649e-02f, 6.23796508e-02f, -2.90366430e-02f, -4.49658232e-03f, -1.11305311e-01f,
  -1.53093534e-02f, 4.34261449e-02f, -5.09864986e-02f, 9.72826686e-03f, -3.33323181e-02f, -1.14679225e-01f, 2.16332916e-02f, -6.39162436e-02f, -4.18760106e-02f, -1.31441168e-02f,
  -5.31688333e-02f, -5.52940667e-02f, 2.45925579e-02f, -7.89274573e-02f, -2.10869852e-02f, -1.71295300e-01f, -1.43415585e-01f, -1.16493516e-01f, 6.01654276e-02f, 9.09420997e-02f,
  8.63551795e-02f, 9.51219648e-02f, 3.08472896e-03f, 3.79308984e-02f, -1.19734354e-01f, -6.02546372e-02f, 6.61072955e-02f, -1.22072011e-01f, -5.75050451e-02f, 5.79616893e-03f,
  -2.99329273e-02f, 2.06349771e-02f, -5.01677282e-02f, -1.21920295e-01f, -2.22504977e-02f, -5.35936616e-02f, 7.83112571e-02f, -4.18292023e-02f, -6.21019043e-02f, 2.10343152e-01f,
  9.92133617e-02f, 2.49942988e-02f, -8.87371898e-02f, -4.87754904e-02f, 4.77007963e-02f, -7.38567784e-02f, 5.73570020e-02f, -7.67875239e-02f, -3.05767935e-02f, 1.42684812e-02f,
  7.66077936e-02f, -6.81102723e-02f, 9.79635343e-02f, -5.13079315e-02f, -2.54466832e-02f, 7.30482116e-02f, -3.90416048e-02f, -4.61454466e-02f, -2.57819910e-02f, 6.48548361e-03f,
  7.85139948e-02f, 4.38157059e-02f, 1.64990909e-02f, -6.03436939e-02f, -7.85893574e-02f, 7.89494962e-02f, -2.83466522e-02f, -2.28824243e-02f, 1.34631963e-02f, -2.95187235e-02f,
  4.36682105e-02f, -5.70246577e-02f, 3.38141657e-02f, 6.36698678e-02f, 4.80029657e-02f, 4.19305041e-02f, 8.01907927e-02f, -6.73282817e-02f, 6.61259226e-04f, 7.14609176e-02f,
  -4.75707725e-02f, -1.69138853e-02f, 3.99286635e-02f, 3.66392247e-02f, 2.43614689e-02f, -2.77916938e-02f, -4.78132144e-02f, 9.76642407e-03f, 6.55097188e-03f, -1.31301247e-02f,
  -7.14841932e-02f, -6.56956583e-02f, 5.81597537e-02f, -3.78950946e-02f, 9.33470204e-03f, -2.00873744e-02f, 1.67733636e-02f, -4.80320230e-02f, 2.48129033e-02f, 4.30939347e-02f,
  2.34447909e-03f, 3.46564502e-03f, 2.61417106e-02f, -4.44666035e-02f, -4.81103137e-02f, 8.21025521e-02f, 5.98092303e-02f, -7.99672529e-02f, -4.01730649e-02f, -8.39371681e-02f,
  7.30034634e-02f, -2.08470915e-02f, -1.18279811e-02f, -1.80222448e-02f, 6.02433905e-02f, 1.08875977e-02f, 3.93188894e-02f, -6.42227605e-02f, -4.61078584e-02f, 4.52268049e-02f,
  2.08355952e-03f, -1.14267588e-01f, -4.94955517e-02f, -3.32274176e-02f, -2.42232028e-02f, -8.38872343e-02f, -1.16019145e-01f, 6.29376471e-02f, -1.17064707e-01f, -7.25173205e-02f,
  -1.05919212e-01f, 3.03766434e-03f, -1.40050694e-01f, 1.19143374e-01f, -5.10635413e-02f, -1.97460443e-01f, -2.54669905e-01f, -2.25139588e-01f, -3.89325358e-02f, -6.01434475e-03f,
  -4.82234024e-02f, 1.89707249e-01f, 3.80583368e-02f, 4.13063206e-02f, 7.67862126e-02f, -5.54622635e-02f, 1.40635803e-01f, 1.96968973e-01f, -4.19988073e-02f, 1.19382352e-01f,
  1.21200360e-01f, 1.02834739e-01f, 8.58679414e-02f, 1.40648410e-02f, 2.12172151e-01f, 6.02949858e-02f, 2.86668055e-02f, 2.03601737e-02f, -2.76896749e-02f, 3.82820457e-01f,
  -5.61807379e-02f, -1.59193516e-01f, 9.84212905e-02f, 5.38364835e-02f, 2.43859384e-02f, -1.36846825e-01f, -2.02561785e-02f, -1.47200450e-02f, -4.83162738e-02f, -1.93470251e-02f,
  -2.75145890e-03f, -3.80062349e-02f, -2.26761196e-02f, -3.83324996e-02f, -7.94591978e-02f, -1.95141672e-03f, -6.01980947e-02f, -3.12169343e-02f, -5.96138053e-02f, -4.71922606e-02f,
  3.25385891e-02f, 6.21336065e-02f, 3.79556194e-02f, -7.99102616e-03f, -1.23996817e-01f, 3.85423712e-02f, -1.50841668e-01f, -9.73562896e-02f, -8.20279792e-02f, 8.03815760e-03f,
  5.55275902e-02f, -6.45209895e-03f, -4.75170799e-02f, 1.00305434e-02f, 1.05483439e-02f, 2.34842841e-02f, 4.03300114e-02f, 5.90848774e-02f, -3.15486193e-02f, 1.02702565e-01f,
  -4.54984568e-02f, 5.06259724e-02f, -6.69280440e-02f, 1.76719166e-02f, -2.87892129e-02f, 2.68293899e-02f, -1.12250909e-01f, 5.08851632e-02f, -3.26563343e-02f, -5.14668338e-02f,
  6.63336292e-02f, -7.14926198e-02f, 5.24817705e-02f, 6.81741685e-02f, 5.21175563e-02f, -2.22883411e-02f, -3.95310819e-02f, -1.14827789e-02f, -6.31639436e-02f, 5.00350781e-02f,
  -6.65974766e-02f, 5.70211699e-03f, 9.02555734e-02f, 4.07610610e-02f, -4.75700013e-02f, 1.00847671e-03f, 7.39839599e-02f, -2.32039206e-02f, 1.06352888e-01f, -4.70437147e-02f,
  1.29523745e-03f, -3.66161093e-02f, 6.59999698e-02f, -7.13953748e-02f, 7.55053619e-03f, -6.88314363e-02f, 4.38925736e-02f, 6.41117170e-02f, 8.67514461e-02f, -1.46359295e-01f,
  2.79394723e-02f, -1.25014618e-01f, -8.44571088e-03f, -7.25559890e-02f, -2.87106894e-02f, 2.83871349e-02f, -7.34726116e-02f, -1.26537189e-01f, -1.98072255e-01f, -4.21688966e-02f,
  -5.76593615e-02f, -3.42897922e-02f, -1.65435866e-01f, -1.25970036e-01f, -2.13878285e-02f, -1.75752863e-02f, 1.14966728e-01f, -1.90227013e-02f, -7.26631954e-02f, 3.06352340e-02f,
  -8.39848258e-03f, 2.76980158e-02f, -9.80087146e-02f, 4.05601375e-02f, -2.69583650e-02f, -3.70423682e-02f, -3.59631106e-02f, -1.36992961e-01f, 4.79910374e-02f, -9.79235023e-02f,
  4.76297997e-02f, -1.39006495e-01f, -8.47619772e-02f, 1.56349372e-02f, -4.82039638e-02f, -1.15818046e-01f, -1.45493209e-01f, -5.44771217e-02f, 1.95286963e-02f, -2.34673265e-02f,
  1.17536701e-01f, -1.04210585e-01f, -4.39423099e-02f, 9.77953244e-03f, 2.50873640e-02f, -3.73445898e-02f, 5.29845431e-02f, -6.91214502e-02f, -3.72124054e-02f, -5.55233210e-02f,
  -9.01322588e-02f, 1.42900012e-02f, -7.14511350e-02f, -7.16315284e-02f, 4.23367433e-02f, -4.86582443e-02f, 9.29829106e-03f, -3.47009883e-03f, -5.80277592e-02f, 4.04302627e-02f,
  -8.90054554e-02f, -4.74694893e-02f, -9.92257241e-03f, -7.32439756e-02f, -1.16143199e-02f, -9.78443697e-02f, 3.92506681e-02f, -8.64078254e-02f, -6.66100085e-02f, 2.57595591e-02f,
  -4.90009487e-02f, -5.12347110e-02f, -6.93894643e-03f, 9.25516188e-02f, -2.29102578e-02f, -4.18025181e-02f, -4.50644700e-04f, 8.88124779e-02f, -3.37973684e-02f, 2.53224783e-02f,
  -8.83254260e-02f, 4.01489213e-02f, 6.16834164e-02f, 4.37975824e-02f, 6.47872984e-02f, 2.16444172e-02f, -1.40601816e-02f, -2.28851754e-02f, 4.61347355e-03f, -8.19353089e-02f,
  2.63141897e-02f, 1.09527424e-01f, -2.46146377e-02f, 3.50159965e-02f, -2.54149139e-02f, 1.49664599e-02f, -4.05177586e-02f, 4.11085226e-02f, 8.21178034e-02f, -3.59390192e-02f,
  6.95811287e-02f, -6.35845885e-02f, 1.69400852e-02f, -1.12058353e-02f, -7.46665969e-02f, 2.84934677e-02f, 4.51497585e-02f, 5.74339516e-02f, 5.64780310e-02f, -3.98213863e-02f,
  -4.17098030e-03f, 1.33158388e-02f, -1.25546493e-02f, 3.63641977e-02f, 6.87270015e-02f, -3.80368866e-02f, 2.20512152e-02f, -9.74117965e-02f, 2.44959798e-02f, -4.23775464e-02f,
  2.30785012e-02f, -5.60898073e-02f, 7.29798898e-02f, 2.73875482e-02f, 4.42840159e-02f, 4.86825965e-02f, -1.30706057e-02f, 8.91778544e-02f, 8.88292417e-02f, -1.31649980e-02f,
  3.23639736e-02f, -9.58357099e-03f, -1.01789668e-01f, 9.07335952e-02f, 5.56000099e-02f, 8.60869363e-02f, -1.13538221e-01f, -4.89973724e-02f, 5.30789159e-02f, 5.61673678e-02f,
  -5.62055632e-02f, 5.20993322e-02f, 2.64691431e-02f, -1.40107438e-01f, -9.31449234e-02f, -2.01451927e-01f, -3.25619504e-02f, -6.06557801e-02f, -9.14522558e-02f, 1.09824063e-02f,
  2.51020063e-02f, -1.09275263e-02f, -1.12939358e-01f, 4.60586399e-02f, -2.55608261e-02f, -2.38846652e-02f, -2.15066001e-02f, -3.77926081e-02f, -1.39912501e-01f, -2.42361072e-02f,
  -2.38618515e-02f, 9.78551880e-02f, -6.84966967e-02f, 1.81311965e-02f, 7.19115362e-02f, -2.03714911e-02f, 4.70225289e-02f, 6.08830072e-04f, 6.78124577e-02f, -3.54308337e-02f,
  1.82428937e-02f, -3.09945494e-02f, -5.83082018e-03f, 1.09003028e-02f, -9.79039632e-03f, -3.23014446e-02f, 2.71723489e-03f, -7.02920705e-02f, 4.52541560e-02f, 1.61713678e-02f,
  2.32727677e-02f, -9.09826979e-02f, -1.09682783e-01f, -9.59245488e-02f, 4.36498076e-02f, -3.55650075e-02f, -8.53390396e-02f, 5.83641119e-02f, 4.03212663e-03f, 1.27417874e-02f,
  3.69621813e-02f, 7.82513933e-04f, 6.47638515e-02f, -2.10381020e-03f, -4.74978164e-02f, -8.80137272e-03f, -3.70560251e-02f, 9.51353554e-03f, 7.28408918e-02f, -4.01321687e-02f,
  3.04065226e-03f, 1.00836739e-01f, -1.45559944e-02f, -4.11426313e-02f, 1.00544631e-01f, 3.90136577e-02f, 3.40460404e-03f, -3.66192241e-03f, -1.27398446e-02f, -3.14693414e-02f,
  -6.03776351e-02f, -1.57030132e-02f, 8.24111030e-02f, -6.51780888e-02f, -7.41726607e-02f, -1.70245953e-02f, 2.19737552e-02f, -9.08341035e-02f, -1.88329369e-02f, 7.80206397e-02f,
  9.35201645e-02f, -1.51422143e-01f, 4.29235846e-02f, -2.93119960e-02f, 2.11588852e-02f, 1.98460203e-02f, 4.65599261e-02f, -2.10001841e-02f, 1.07754499e-01f, 4.28108685e-02f,
  -3.04538780e-03f, 4.05980013e-02f, -2.12864894e-02f, -6.96981698e-02f, 7.46829435e-02f, -3.27159627e-03f, -7.58456588e-02f, 1.10371215e-02f, -9.41413343e-02f, 5.97147420e-02f,
  6.40688390e-02f, -3.87966856e-02f, -3.11391405e-03f, -8.53371993e-02f, -4.11943197e-02f, -3.77159156e-02f, -2.47723311e-02f, -3.20732896e-03f, -7.08087236e-02f, -1.11933790e-01f,
  -1.43726394e-01f, 1.13488436e-02f, -4.87639196e-02f, 1.45528585e-01f, 4.19212803e-02f, 1.76062770e-02f, -9.42262413e-04f, -5.03560789e-02f, 1.09398074e-01f, 3.96093018e-02f,
  -1.69743985e-01f, 4.62456383e-02f, 1.98706109e-02f, 9.18280408e-02f, 1.39392659e-01f, 1.16065271e-01f, 1.34082273e-01f, 6.31764112e-03f, 4.21467684e-02f, -5.45054562e-02f,
  1.74228270e-02f, -1.96525641e-02f, -2.66730469e-02f, 5.68213053e-02f, 1.12281464e-01f, 5.31277545e-02f, 1.06555279e-02f, -1.08090766e-01f, -9.03173611e-02f, 8.78243446e-02f,
  -1.20266810e-01f, -6.84960261e-02f, -1.93970911e-02f, 1.46177774e-02f, 1.61862373e-03f, 6.25525117e-02f, -4.53640036e-02f, -8.48483667e-02f, -1.01213649e-01f, 7.74855614e-02f,
  9.07108039e-02f, -7.22286627e-02f, 1.00096136e-01f, -6.18812144e-02f, -4.79166433e-02f, -3.41355763e-02f, 5.21853706e-03f, -4.31247577e-02f, 5.22428080e-02f, -3.79778370e-02f,
  -3.72470431e-02f, -7.25659505e-02f, 5.18173836e-02f, -4.75051962e-02f, 1.25271857e-01f, -2.97662877e-02f, -9.70486104e-02f, -1.88202318e-02f, 2.39208038e-03f, -5.51817194e-02f,
  4.71578166e-03f, -8.10641795e-02f, -6.97000697e-02f, 3.55892181e-02f, -4.91075441e-02f, -8.28005653e-03f, -1.89130511e-02f, 9.38335136e-02f, 1.69413760e-02f, -1.53025342e-02f,
  5.54735065e-02f, -5.81444092e-02f, -8.32263082e-02f, 2.70491298e-02f, 1.52933300e-02f, -3.74295376e-02f, 3.96235064e-02f, -2.96744592e-02f, -8.47695842e-02f, -2.97994092e-02f,
  3.72956321e-02f, 2.28975937e-02f, -8.36747438e-02f, 9.61509794e-02f, -9.61597562e-02f, -7.79984798e-03f, 7.25900158e-02f, -2.56834291e-02f, -6.29476365e-03f, -9.41826850e-02f,
  -5.51712848e-02f, -1.38433799e-01f, 5.20867296e-02f, 1.51865318e-01f, 1.33537218e-01f, 2.25363132e-02f, 1.71059351e-02f, -1.81934889e-02f, -2.78991535e-02f, 9.42133076e-04f,
  -1.72890332e-02f, 9.19252113e-02f, 2.71297358e-02f, -3.28413732e-02f, -3.65753099e-02f, -7.94376284e-02f, -1.44641045e-02f, 3.16160098e-02f, -2.65279338e-02f, 1.24727581e-02f,
  1.38347909e-01f, 1.65762287e-02f, -7.00951889e-02f, -1.01867076e-02f, -2.54986044e-02f, -2.34288134e-04f, -6.02574795e-02f, -3.56207602e-02f, 5.50666777e-03f, 4.70731780e-02f,
  7.97265917e-02f, -1.97384953e-02f, 1.12446509e-01f, 2.74784029e-01f, 5.47986738e-02f, 1.27472028e-01f, 1.05927043e-01f, 1.99096128e-01f, 8.44805390e-02f, 3.14565934e-02f,
  7.84798898e-03f, -9.26694367e-03f, 5.10733537e-02f, 4.27425699e-03f, 9.35952291e-02f, 1.29321650e-01f, 2.07927853e-01f, 6.99496195e-02f, 6.90621063e-02f, 9.78477970e-02f,
  -5.75130433e-02f, 7.69907683e-02f, -4.31728475e-02f, 2.56256703e-02f, 4.75782566e-02f, 1.85334496e-02f, 5.06597981e-02f, 9.00104921e-03f, -8.50848407e-02f, 1.82241768e-01f,
  -9.10516456e-02f, 9.33769792e-02f, 7.10837319e-02f, -9.75456908e-02f, 4.71736392e-04f, -5.46054915e-02f, -2.19979268e-02f, 3.37631740e-02f, -1.69967916e-02f, -7.39841536e-02f,
  3.99629511e-02f, 1.10135507e-02f, -4.22991924e-02f, 1.64430574e-04f, 8.00147876e-02f, -4.04027589e-02f, 5.00217080e-03f, 6.25783280e-02f, -3.44640575e-02f, -5.88036031e-02f,
  -6.71225563e-02f, -2.70159263e-03f, -3.93260345e-02f, 2.86811069e-02f, 1.20432116e-01f, -7.36760767e-03f, -8.22050311e-03f, 6.54985458e-02f, -7.20248965e-04f, 2.09591649e-02f,
  4.67334501e-02f, 5.11585623e-02f, 6.43276200e-02f, -3.07767428e-02f, 7.71995774e-03f, 9.15033892e-02f, -3.42905186e-02f, 8.09756443e-02f, 1.87558890e-03f, -2.89864186e-02f,
  -5.40040694e-02f, 9.72218141e-02f, 5.39154373e-02f, 1.20263342e-02f, 7.53291026e-02f, 1.93811152e-02f, 2.20743939e-02f, -5.96042676e-03f, 7.90518820e-02f, -3.56773697e-02f,
  -1.02338329e-01f, -2.75220536e-02f, -2.15402581e-02f, 3.64198126e-02f, -2.92583033e-02f, 5.04847839e-02f, -4.92491352e-04f, 5.98703884e-02f, 2.97349617e-02f, -3.13301831e-02f,
  -1.96349293e-01f, -3.50097120e-02f, 7.88994804e-02f, 7.41206259e-02f, -5.29940687e-02f, -6.78966520e-04f, -9.09456536e-02f, -1.93799175e-02f, 2.76971818e-03f, -5.76004870e-02f,
  -8.96232799e-02f, -7.06564486e-02f, -7.95450434e-02f, -7.66164972e-04f, -3.67337465e-02f, -7.90172815e-02f, 3.95243019e-02f, -5.04690520e-02f, -3.01031936e-02f, -2.91648731e-02f,
  -5.69255650e-03f, 5.88294603e-02f, 2.25581415e-02f, 5.66998273e-02f, 5.47998995e-02f, -5.02458364e-02f, -3.61961797e-02f, -2.86571439e-02f, -7.36897858e-03f, -7.65181631e-02f,
  1.67297885e-01f, 2.82749766e-03f, -9.91449133e-02f, -4.53170799e-02f, 8.17937851e-02f, -7.92658553e-02f, -4.58139405e-02f, 2.11479310e-02f, -5.95101453e-02f, -2.84679178e-02f,
  1.07152909e-01f, 1.66105792e-01f, 1.04918621e-01f, 9.99525487e-02f, 9.66902301e-02f, -4.35380116e-02f, -3.07287322e-03f, 5.52433543e-02f, 1.08800888e-01f, 1.15594506e-01f,
  5.03687374e-02f, -4.17382047e-02f, 2.71445196e-02f, -6.75244108e-02f, 1.51763875e-02f, 1.89024247e-02f, -9.70604271e-02f, -6.71357438e-02f, -7.43090734e-02f, -7.91902244e-02f,
  2.10400224e-02f, 6.81817457e-02f, 7.98828751e-02f, -4.51505482e-02f, -7.19438642e-02f, 8.02313685e-02f, -2.14592516e-02f, -6.28460273e-02f, 3.04494649e-02f, 4.66593429e-02f,
  -1.28220711e-02f, -6.01332895e-02f, 5.64032048e-02f, 6.41370416e-02f, -1.89449266e-02f, 4.17486280e-02f, 7.26938248e-02f, -2.64115841e-03f, -3.79785306e-05f, -2.52336338e-02f,
  -1.11792497e-01f, 7.79211372e-02f, 7.98126217e-03f, -6.00832365e-02f, 2.11835206e-02f, 7.88658392e-03f, -7.55813420e-02f, -4.90010977e-02f, -4.48732749e-02f, -5.59647009e-02f,
  -4.36689667e-02f, 3.67361866e-02f, 7.87931010e-02f, -1.88812260e-02f, 3.34860422e-02f, 6.92324638e-02f, -5.96571853e-03f, -2.06254330e-02f, -9.26976837e-03f, 2.90465429e-02f,
  1.98037553e-04f, -2.21604239e-02f, -7.91550726e-02f, -5.04971854e-02f, 6.84805736e-02f, -7.40340576e-02f, -5.86024597e-02f, 6.02526143e-02f, 7.91794732e-02f, -7.16097802e-02f,
  1.47284027e-02f, 8.84705633e-02f, -3.00913788e-02f, 2.95765847e-02f, 7.65621662e-02f, 4.35938016e-02f, -2.81281583e-02f, 9.56888199e-02f, 5.89287505e-02f, 5.53713292e-02f,
  -3.32427118e-03f, 3.79178338e-02f, 7.89258182e-02f, 8.77127144e-03f, -9.40565169e-02f, 5.99537566e-02f, -5.74022196e-02f, -3.19392011e-02f, -8.21895245e-03f, -4.07580432e-04f,
  8.07775557e-03f, -3.92249264e-02f, -3.38860904e-03f, -7.37523660e-02f, 7.86703378e-02f, -2.14454010e-02f, 4.87428792e-02f, 1.96661185e-02f, 1.59257837e-02f, -3.29136625e-02f,
  -7.97406062e-02f, 2.39234082e-02f, 5.94423674e-02f, 1.29850255e-02f, 5.91350496e-02f, -3.19130979e-02f, 4.96959947e-02f, 1.31652588e-02f, -2.67666485e-02f, -1.23707369e-01f,
  -2.57595420e-01f, -1.75502058e-02f, -1.21344510e-03f, -4.50779125e-02f, -7.44128376e-02f, -7.89185986e-02f, 8.70428805e-04f, -2.12353803e-02f, 1.25858769e-01f, 9.43970773e-03f,
  2.05979627e-02f, 1.14403971e-01f, -1.77654345e-02f, 2.00084001e-02f, 9.01821777e-02f, 1.01910099e-01f, 4.08802219e-02f, 5.21412194e-02f, 6.86188564e-02f, -7.29872659e-02f,
  -6.36643870e-03f, -9.56716612e-02f, -7.40392655e-02f, 9.78229754e-03f, 1.03470728e-01f, -5.50206006e-02f, 8.23637098e-02f, 3.43752429e-02f, 8.08270462e-03f, 2.33974066e-02f,
  -9.04491916e-02f, -1.01136133e-01f, -3.94522026e-02f, -4.70699966e-02f, -1.11795992e-01f, -6.67867390e-03f, -2.76548997e-03f, 9.04955268e-02f, 4.41402607e-02f, -4.82926629e-02f,
  -6.57674074e-02f, -3.52602527e-02f, -8.17857459e-02f, -2.80035138e-02f, -3.91871147e-02f, -1.09477051e-01f, -3.52201089e-02f, 2.60418635e-02f, -1.73918940e-02f, -1.13944016e-01f,
  5.31441458e-02f, -1.78789720e-03f, -2.20616125e-02f, -4.05952446e-02f, 1.21367173e-02f, -3.08653321e-02f, -3.73191647e-02f, 2.95521338e-02f, -5.61628826e-02f, -2.43394058e-02f,
  -8.16021860e-03f, 1.15428520e-02f, -5.99700846e-02f, 2.33831275e-02f, -2.28991918e-02f, 7.04603717e-02f, 1.10240474e-01f, 1.60726458e-02f, 1.58536416e-02f, -1.93793960e-02f,
  -3.85504551e-02f, 3.76267284e-02f, 3.59098352e-02f, -3.78294587e-02f, 3.05571537e-02f, 4.73161824e-02f, -4.24279869e-02f, -1.46565645e-03f, 9.55028161e-02f, 1.20164650e-02f,
  5.33002196e-03f, -3.80020179e-02f, -2.68043224e-02f, 2.82652546e-02f, 2.41375528e-02f, 8.89230967e-02f, 4.63483781e-02f, -5.77095896e-02f, -2.15387940e-02f, -5.35571016e-02f,
  4.02325913e-02f, 1.65757582e-01f, 5.70550561e-02f, -6.84595704e-02f, 9.09805968e-02f, 6.17311075e-02f, -7.15860501e-02f, -3.94165739e-02f, -7.07649365e-02f, 4.33194079e-02f,
  -1.11351088e-01f, 2.21882779e-02f, -3.32913287e-02f, -2.36039646e-02f, -1.09849080e-01f, -1.12892441e-01f, 4.31557186e-03f, 5.38749471e-02f, 1.58557706e-02f, 2.34797467e-02f,
  -2.75345594e-02f, -2.74368674e-02f, 4.85655479e-02f, -6.18946925e-02f, 1.21640041e-02f, -9.34677944e-02f, -7.12834895e-02f, -9.87631604e-02f, -1.18107222e-01f, -1.17008433e-01f,
  -1.82906732e-01f, -1.60063162e-01f, -5.37996069e-02f, 2.69261152e-02f, -6.59083650e-02f, 4.53801639e-02f, -1.65272996e-01f, -7.18339309e-02f, 6.44934736e-03f, -7.58622587e-02f,
  6.82259053e-02f, -3.50411683e-02f, 6.11905903e-02f, 6.73424266e-03f, -6.15317002e-02f, -8.37947130e-02f, -4.45683207e-03f, 1.17293680e-02f, -1.04236938e-01f, 8.64359885e-02f,
  -3.69006731e-02f, 4.75947373e-02f, -2.93649416e-02f, 2.12486796e-02f, -1.08955838e-02f, -2.22242493e-02f, -6.46220073e-02f, 1.12546466e-01f, -3.54554690e-02f, 5.99148162e-02f,
  8.37530270e-02f, 2.40558721e-02f, 6.65534213e-02f, 3.62958089e-02f, 2.85087600e-02f, -1.62063763e-02f, -2.48112679e-02f, 7.69899487e-02f, 2.20555607e-02f, -7.84807578e-02f,
  -1.17988274e-01f, -8.23273957e-02f, 2.72231735e-02f, 1.70357823e-02f, -5.07526193e-03f, -6.29821196e-02f, -9.28175896e-02f, -8.91636536e-02f, -5.69944344e-02f, -8.56662467e-02f,
  -4.06585969e-02f, 6.41965494e-02f, -9.98536572e-02f, 2.73039788e-02f, -4.75017540e-02f, 2.37139799e-02f, 1.38908802e-02f, -8.55931863e-02f, 5.12832776e-02f, -6.78458288e-02f,
  8.76538604e-02f, 2.75307186e-02f, 1.38527702e-03f, 7.61698037e-02f, -9.12549123e-02f, -9.48627107e-03f, -3.60111659e-03f, -3.95043753e-02f, 2.99911182e-02f, -6.64143171e-03f,
  -5.23534119e-02f, 5.48047721e-02f, -5.37569337e-02f, 9.95256454e-02f, 1.42277230e-03f, 4.17728443e-03f, 1.25115691e-02f, 7.17677996e-02f, -5.58265336e-02f, 1.54498946e-02f,
  5.04920483e-02f, -7.40838051e-02f, -5.11042662e-02f, -3.13255675e-02f, -4.79483418e-02f, 1.09046191e-01f, 3.06786913e-02f, -5.65690473e-02f, 7.25926384e-02f, -9.77186300e-03f,
  -1.25830188e-01f, 5.15587721e-03f, 2.06650700e-02f, -1.78022981e-02f, -4.98109795e-02f, -2.72398684e-02f, 6.58098385e-02f, -6.48886198e-04f, 2.92334780e-02f, -4.64049578e-02f,
  -1.26265377e-01f, -9.07163918e-02f, -5.42428195e-02f, -1.08139943e-02f, 1.46311587e-02f, -1.13808855e-01f, -2.67833043e-02f, 4.22077104e-02f, 5.55665940e-02f, -3.67675647e-02f,
  -6.13472648e-02f, -3.54857706e-02f, -1.01634741e-01f, -6.25172779e-02f, -3.85455042e-02f, 7.46759325e-02f, -1.30490690e-01f, -3.24662775e-02f, -5.79478443e-02f, -1.84134096e-01f,
  -2.03921229e-01f, -1.23609759e-01f, 6.15789406e-02f, 5.94064668e-02f, 1.72809944e-01f, 1.95268467e-01f, 1.39946386e-01f, 7.07231881e-03f, 5.66354655e-02f, -7.44952308e-03f,
  -6.12152601e-03f, 5.60660511e-02f, 3.66103835e-02f, -2.91197430e-02f, -5.27452789e-02f, 8.26011449e-02f, 1.01653300e-01f, -3.07304636e-02f, 1.85937732e-01f, 1.54811472e-01f,
  1.22019939e-01f, -5.11187091e-02f, -1.27531275e-01f, 4.46987757e-03f, 4.39568236e-02f, 6.30315468e-02f, -9.84279718e-03f, -1.96097307e-02f, -5.68423718e-02f, 1.22387772e-02f,
  1.15712672e-01f, -1.96718678e-01f, 1.85150787e-01f, -4.16549481e-02f, -3.17238420e-02f, -1.48114152e-02f, -4.32050647e-03f, -6.48816600e-02f, -5.34224138e-02f, 5.01000471e-02f,
  -3.09968218e-02f, -2.14849319e-02f, 4.30735461e-02f, -9.09432955e-03f, -4.25937064e-02f, 5.90351410e-03f, -1.69233739e-01f, -6.15171902e-02f, 7.39345253e-02f, -7.45261908e-02f,
  -1.03390388e-01f, -8.23095143e-02f, -6.71498850e-02f, 1.48023471e-01f, -7.10685253e-02f, 3.16794030e-02f, -3.84190939e-02f, -8.22293162e-02f, 2.67059952e-02f, -7.86934346e-02f,
  -3.05783376e-02f, -3.16989943e-02f, -3.22224610e-02f, 3.12613174e-02f, 1.72801800e-02f, -2.09616777e-02f, 3.28873210e-02f, -4.56983224e-03f, -5.72316125e-02f, -4.41085026e-02f,
  8.81334022e-02f, -2.38319114e-02f, 3.56578198e-03f, 2.54167933e-02f, -1.50840078e-02f, 1.26323514e-02f, 3.75981778e-02f, -1.31427739e-02f, -8.90104398e-02f, 9.49145183e-02f,
  3.22644762e-03f, 1.73015893e-02f, 5.14719859e-02f, -6.86308146e-02f, 5.54465353e-02f, 5.55235595e-02f, -4.28523943e-02f, 2.35326309e-02f, -4.63961298e-03f, -8.96036159e-03f,
  2.06312642e-01f, -9.53221098e-02f, 9.20554325e-02f, -8.52692649e-02f, 6.68949122e-03f, 5.91675490e-02f, 5.44904582e-02f, -7.26424158e-02f, 3.36419977e-02f, 4.41076756e-02f,
  -3.18554859e-03f, -5.26996590e-02f, 4.03525904e-02f, 1.21932989e-03f, 3.68110314e-02f, 7.29173869e-02f, -1.31416783e-01f, 2.74176686e-03f, 3.36579755e-02f, 6.95444420e-02f,
  -6.99433461e-02f, 7.17634857e-02f, 7.24186525e-02f, 1.15858195e-02f, 8.51680413e-02f, 3.87052186e-02f, 1.03418268e-01f, 1.05744153e-01f, -2.05928646e-02f, 1.43946245e-01f,
  -1.15439676e-01f, -6.02257140e-02f, 4.15836349e-02f, -9.99280345e-03f, 4.41183262e-02f, -2.11496502e-02f, -7.76313320e-02f, 5.77031150e-02f, 8.78376961e-02f, -1.36163086e-02f,
  -3.60255055e-02f, -8.32745656e-02f, -9.33109894e-02f, -4.25639935e-02f, -7.65754804e-02f, 7.64357252e-03f, 3.33936624e-02f, -5.52249886e-02f, 1.37103617e-03f, -5.42978710e-03f,
  6.61650347e-03f, 4.69606705e-02f, 5.06623983e-02f, 6.38020709e-02f, 3.06389872e-02f, 9.59780905e-03f, 6.19826727e-02f, -7.30303973e-02f, 3.58538441e-02f, -3.39759029e-02f,
  -4.14081924e-02f, -2.55952906e-02f, -6.84601143e-02f, -1.90563258e-02f, 7.06215501e-02f, -1.54576469e-02f, -3.63775231e-02f, -6.76464140e-02f, 1.70083791e-02f, -4.90270667e-02f,
  -7.41344467e-02f, -6.60220385e-02f, 1.12088872e-02f, 7.25633418e-03f, -7.19597004e-03f, 2.30102222e-02f, 7.29823904e-03f, 4.04322185e-02f, -6.54050335e-02f, 8.71925578e-02f,
  -2.90439185e-03f, -2.59962920e-02f, 9.47471708e-02f, -4.34113294e-02f, -9.52836573e-02f, -6.98961988e-02f, 1.81819461e-02f, -3.35524529e-02f, 5.90824150e-02f, 4.62228805e-02f,
  -7.37794638e-02f, -4.83231768e-02f, 6.44914135e-02f, -5.97012751e-02f, 2.66221091e-02f, 7.74278194e-02f, -6.79645315e-02f, 7.66199380e-02f, -7.22027868e-02f, 8.41630343e-03f,
  -6.41971454e-03f, -6.26976863e-02f, -2.68468764e-02f, 7.76037499e-02f, 7.37305805e-02f, -1.85053870e-02f, 2.74345148e-02f, 8.54538530e-02f, 1.60995182e-02f, -2.88476422e-02f,
  8.10722634e-02f, -8.07213709e-02f, -2.73846034e-02f, 9.54943448e-02f, -3.30038667e-02f, 1.87971219e-02f, 7.43427202e-02f, 7.76871368e-02f, 9.64821875e-02f, 3.21149416e-02f,
  2.49427352e-02f, 8.60309526e-02f, -1.30380513e-02f, -6.42246231e-02f, 5.70577979e-02f, -3.28831710e-02f, 7.19960555e-02f, 9.55143720e-02f, 1.13974415e-01f, 1.11971959e-01f,
  4.99287173e-02f, -1.49808517e-02f, 6.31030649e-02f, -4.71318141e-02f, -1.30945584e-02f, -2.84810532e-02f, 7.20714405e-02f, 8.49107653e-02f, 9.75786522e-03f, 7.40179196e-02f,
  -2.18789838e-02f, 4.50255536e-02f, 1.78116877e-02f, 4.66410406e-02f, -3.40621583e-02f, 1.47597957e-02f, -1.80455856e-02f, 5.02737202e-02f, -1.92036573e-02f, 1.16760999e-01f,
  -4.98762242e-02f, -8.47770050e-02f, -2.61776388e-01f, -1.42494783e-01f, -1.28429443e-01f, -3.70136872e-02f, -3.18723284e-02f, -1.20502384e-02f, -8.36448818e-02f, -6.62654713e-02f,
  -6.72097653e-02f, 1.62905771e-02f, -1.36621287e-02f, 5.29221147e-02f, 6.39015052e-05f, -8.26880783e-02f, -1.24245524e-01f, 2.09323000e-02f, 6.61442354e-02f, 4.50482741e-02f,
  -8.40207264e-02f, -5.32273427e-02f, -8.20737928e-02f, -1.93707994e-03f, -6.68671206e-02f, -7.23350421e-03f, -1.73853636e-01f, -1.79846697e-02f, 1.15258880e-01f, -2.13401150e-02f,
  6.21257424e-02f, -1.09989733e-01f, 1.42702973e-02f, -4.11724225e-02f, -8.83024111e-02f, -1.97790433e-02f, 4.08387706e-02f, -4.03002053e-02f, 6.37743324e-02f, 7.61803016e-02f,
  -6.74712509e-02f, 9.70225185e-02f, 3.89637128e-02f, 2.84650479e-04f, -1.83659345e-02f, -1.80073138e-02f, -1.17428832e-01f, -6.63207993e-02f, -6.65184930e-02f, -5.36929071e-02f,
  -2.32637990e-02f, -9.12586600e-03f, 3.47397253e-02f, -8.73473436e-02f, -1.59704275e-02f, 9.32963658e-03f, -6.42995909e-02f, -7.87963048e-02f, -3.15031037e-02f, 6.89555407e-02f,
  -1.62943844e-02f, -3.15851085e-02f, -4.25217859e-02f, -4.36918475e-02f, -1.78070031e-02f, -5.42026646e-02f, 7.34200105e-02f, 7.50705078e-02f, 2.41999757e-02f, 4.85967435e-02f,
  -4.92048599e-02f, -3.61003540e-02f, 1.17639722e-02f, -5.12108505e-02f, 4.29430418e-03f, -1.00339927e-01f, 8.58961642e-02f, -7.97211230e-02f, 4.99011837e-02f, 4.04148176e-02f,
  -5.81508540e-02f, -1.21071413e-02f, -7.68926144e-02f, 7.69640058e-02f, -1.63737997e-01f, -1.94259156e-02f, 3.23343463e-02f, 5.16853221e-02f, 3.40484083e-02f, -1.34146698e-02f,
  1.72701195e-01f, -1.70823019e-02f, 7.18459412e-02f, 1.05545305e-01f, -8.10475275e-02f, 4.59185392e-02f, -1.39367944e-02f, -3.90838720e-02f, 1.66255571e-02f, -3.26296017e-02f,
  -6.06405968e-03f, -1.02958409e-02f, 2.02801917e-03f, 9.99300461e-03f, 5.59411850e-03f, -4.16177772e-02f, -2.29126811e-02f, 2.92355772e-02f, -9.15923789e-02f, -1.61198135e-02f,
  -6.58522407e-03f, -1.94872580e-02f, 1.12592906e-01f, -4.51307967e-02f, 2.76134368e-02f, 1.01678587e-01f, 9.99395624e-02f, 6.95358440e-02f, 7.62006119e-02f, 1.07809871e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.50598520e-02f, 1.22696802e-01f, 1.31395739e-02f, 2.55793393e-01f, 5.73268123e-02f, 2.26329714e-02f, 1.03467591e-01f, 1.13856234e-01f, 1.27912402e-01f, -3.50829288e-02f,
  2.27323025e-01f, -3.25397141e-02f, 6.76448718e-02f, 5.84692471e-02f, -1.46983108e-02f, -7.22825974e-02f, 1.41921937e-01f, 3.33988890e-02f, 1.65786237e-01f, 1.19973116e-01f,
  8.44093859e-02f, 1.15131699e-01f, 1.55766830e-02f, 4.85881381e-02f, -2.20491998e-02f, 1.29150614e-01f, 2.37017810e-01f, -1.23946769e-02f, 6.44689575e-02f, 1.92785725e-01f,
  8.96955505e-02f, -5.48434108e-02f, 1.90323126e-02f, 4.16135341e-02f, 7.11796880e-02f, 3.72034609e-02f, 8.81439447e-02f, -8.60375836e-02f, 1.39557282e-02f, 2.26968843e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -5.12063131e-02f, 1.48984957e-02f, -5.40824309e-02f, 5.69077544e-02f, 6.64126277e-02f, 5.38484864e-02f, -7.93938874e-04f, 4.50655930e-02f, 1.22374572e-01f, 1.08670697e-01f,
  6.07935190e-02f, 1.92463383e-01f, 2.63111815e-02f, 1.86516512e-02f, -1.20677806e-01f, -3.88806276e-02f, -1.38860345e-02f, -1.86512601e-02f, -1.33791968e-01f, 1.96204539e-02f,
  -6.40337467e-02f, 1.53015971e-01f, -1.23843458e-03f, -1.52043790e-01f, 9.86190140e-03f, 1.53358057e-01f, 1.11238629e-01f, 1.91342145e-01f, -3.28734219e-02f, -1.45274609e-01f,
  3.56706195e-02f, 1.04789220e-01f, 1.28407538e-01f, 6.32516816e-02f, 1.55061617e-01f, -8.96993950e-02f, -8.39409232e-02f, -9.74400714e-03f, 8.24205056e-02f, -9.23893414e-03f,
  -1.84648670e-02f, 1.94610402e-01f, 3.45883034e-02f, -1.02437332e-01f, -1.63255081e-01f, 7.70935714e-02f, -2.66386215e-02f, -6.76552281e-02f, 9.24265664e-03f, 2.03873776e-02f,
  2.52039522e-01f, -1.77193925e-01f, -3.81768644e-02f, -1.38940156e-01f, -4.97544818e-02f, 5.13272127e-03f, -7.64098838e-02f, 1.18548349e-01f, 7.68102035e-02f, -6.59828112e-02f,
  8.13087448e-02f, 9.29193646e-02f, -6.77707940e-02f, 1.10480793e-01f, -2.42545968e-03f, -3.39029916e-02f, 1.18022561e-01f, -1.56374946e-01f, 3.28762010e-02f, -6.16484024e-02f,
  -1.15935318e-01f, 1.13791309e-01f, -6.94616046e-03f, 3.55347395e-02f, -7.55662844e-02f, 4.21275422e-02f, 8.10382515e-03f, -1.83331177e-01f, -7.77219459e-02f, 1.09208845e-01f,
  -2.40809545e-02f, 1.93658732e-02f, -8.70893821e-02f, 2.24831671e-01f, -2.11993940e-02f, -8.06594081e-03f, 6.84901467e-03f, -7.06119910e-02f, 1.18296981e-01f, 8.08794573e-02f,
  -3.59238684e-02f, -5.10987528e-02f, -6.77940398e-02f, 2.23671421e-02f, 6.47025108e-02f, -1.96223482e-01f, 2.13956404e-02f, 7.13404417e-02f, -5.16231768e-02f, -1.10234156e-01f,
  -2.36164182e-01f, -1.80756464e-03f, 6.19919365e-03f, 1.50988428e-02f, 3.86484973e-02f, -3.08265984e-02f, -1.18110746e-01f, 9.37487483e-02f, 1.05272792e-01f, 5.23882583e-02f,
  1.85310349e-01f, -6.74184114e-02f, -5.98901398e-02f, -6.61985530e-03f, 9.85566676e-02f, -1.30619273e-01f, 1.38055524e-02f, -1.94759406e-02f, 1.33781612e-01f, -1.05398402e-01f,
  -7.74813294e-02f, 8.74581262e-02f, -1.01886764e-01f, -1.44473463e-01f, -8.94558281e-02f, 1.51576206e-01f, 6.34245425e-02f, 1.96472540e-01f, -4.65413071e-02f, -1.68331880e-02f,
  -1.86130684e-03f, 4.81854454e-02f, -1.30935997e-01f, 9.59965214e-02f, 9.83412191e-02f, -2.45928556e-01f, 1.44278452e-01f, -1.57695159e-01f, 1.26015842e-01f, -1.45696290e-02f,
  -1.39207751e-01f, -4.83537503e-02f, -8.43480304e-02f, 1.15836017e-01f, -7.64570087e-02f, -5.17662466e-02f, -1.10362209e-01f, -1.69872001e-01f, 1.40760429e-02f, -8.93905852e-03f,
  5.00549264e-02f, -1.40508041e-01f, 9.32800584e-03f, -8.77689049e-02f, 7.19236732e-02f, 7.50580505e-02f, 2.40416676e-02f, -2.26314254e-02f, 1.31429657e-01f, 3.27855684e-02f,
  -4.92973402e-02f, 1.20804692e-02f, 1.55830547e-01f, 1.61116973e-01f, -1.10907793e-01f, 8.95553157e-02f, -8.22306052e-03f, -1.73857257e-01f, -6.44987226e-02f, -2.36303266e-02f,
  7.70887062e-02f, -1.77840635e-01f, 3.48859765e-02f, 6.93570217e-03f, 1.99284013e-02f, -1.26087114e-01f, 8.92652795e-02f, -2.80990843e-02f, -1.17362000e-01f, -3.39351185e-02f,
  -6.27810229e-03f, 5.14471829e-02f, 4.96405624e-02f, 8.90160054e-02f, 9.47370380e-02f, -9.28784683e-02f, 7.12966993e-02f, 6.81352690e-02f, 7.82265216e-02f, -5.30922711e-02f,
  -1.01416603e-01f, 4.92599830e-02f, -1.15238443e-01f, -4.43906784e-02f, -9.72137302e-02f, 2.22462658e-02f, -7.76847303e-02f, 2.13321876e-02f, -2.59986967e-02f, 1.31598756e-01f,
  7.84296468e-02f, 8.43656659e-02f, -7.38593144e-03f, 1.68289058e-02f, -1.02640036e-02f, 9.30682570e-02f, -3.22924294e-02f, 7.56221488e-02f, -5.52551225e-02f, 8.38358849e-02f,
  3.50255072e-02f, -3.22731622e-02f, -2.70451792e-02f, 1.75193157e-02f, -1.09534495e-01f, 8.34614113e-02f, 4.18678708e-02f, -4.24417816e-02f, -8.44105408e-02f, -1.40437692e-01f,
  -1.83027461e-02f, -1.23739451e-01f, 6.46713898e-02f, 4.91850786e-02f, 3.16335559e-02f, -1.92716289e-02f, -8.67996439e-02f, -9.46707055e-02f, -4.20999005e-02f, -9.19339061e-02f,
  1.14765830e-01f, 3.03736776e-02f, 3.51724587e-02f, 8.78384933e-02f, -1.42266318e-01f, 1.31754771e-01f, -4.21777256e-02f, -1.64329428e-02f, 5.25134765e-02f, 7.21234605e-02f,
  1.07011937e-01f, -6.09730743e-02f, 7.32910931e-02f, -7.64076561e-02f, -1.01299211e-01f, -1.32528648e-01f, -4.21449989e-02f, -8.03767592e-02f, -5.87502755e-02f, -1.05367929e-01f,
  2.47165076e-02f, -1.15994185e-01f, -9.66119021e-02f, 1.24847576e-01f, 4.40213084e-02f, 1.41109452e-01f, 2.36998782e-01f, 6.01146817e-02f, 1.32350639e-01f, -7.76036978e-02f,
  3.55642773e-02f, 2.00166851e-01f, 9.45499241e-02f, 3.25850219e-01f, 8.04158151e-02f, 8.18243846e-02f, -4.50584516e-02f, 5.92503026e-02f, 1.04520507e-01f, -3.39543134e-01f,
  -1.99274540e-01f, -6.10094927e-02f, 1.99812159e-01f, -1.98472589e-02f, 1.93606719e-01f, 2.11095393e-01f, 1.51935771e-01f, 1.89889044e-01f, -1.68212457e-03f, -8.57709572e-02f,
  1.09688034e-02f, -3.97979543e-02f, 1.13955334e-01f, 1.77635044e-01f, 1.30401729e-02f, 8.25051144e-02f, -4.87575121e-02f, -7.13996729e-03f, 4.24063876e-02f, 6.47138581e-02f,
  6.92033619e-02f, -8.22358429e-02f, -2.54687995e-01f, 2.25943029e-02f, -1.18151523e-01f, 1.27240747e-01f, -7.53631815e-02f, 2.06246749e-01f, -9.58625823e-02f, 1.07402936e-01f,
  -1.07715353e-02f, -3.21632661e-02f, -2.39495393e-02f, 1.77228022e-02f, 1.62897054e-02f, -5.65266646e-02f, 2.03633025e-01f, 9.93753746e-02f, -1.20244458e-01f, -9.02039409e-02f,
  6.66510910e-02f, -7.56952465e-02f, 1.55485910e-03f, -4.28181812e-02f, -1.78908389e-02f, -3.55292670e-02f, -6.46593869e-02f, 1.56077623e-01f, -1.93725228e-02f, 7.78132677e-02f,
  2.26352289e-02f, 5.32506555e-02f, -3.63399200e-02f, 1.34309545e-01f, -4.11905050e-02f, 4.34569977e-02f, -2.28901282e-02f, 1.30905315e-01f, 6.22099563e-02f, -4.82557826e-02f,
  -5.44188777e-03f, -3.56002301e-02f, -6.68971464e-02f, -1.45519868e-01f, 4.98521365e-02f, 6.05906248e-02f, 1.47217661e-01f, -5.44715812e-03f, -1.35723680e-01f, 1.36990756e-01f,
  -6.77362680e-02f, 7.33200610e-02f, 9.17816386e-02f, 7.49359280e-02f, -3.07947700e-03f, -1.27616838e-01f, 1.63247079e-01f, 1.40971854e-01f, -1.26845121e-01f, -4.63955663e-02f,
  -1.31987512e-01f, 1.63893700e-02f, 7.89487734e-02f, 1.38672218e-01f, 1.21752813e-01f, -1.31794512e-01f, -1.43687978e-01f, 1.14846909e-02f, 4.47102711e-02f, 1.30008101e-01f,
  1.43162102e-01f, 7.05677122e-02f, 2.18269322e-02f, -1.17990106e-01f, 4.07382287e-02f, 9.31379050e-02f, 3.76378745e-02f, -1.15899205e-01f, 1.02974020e-01f, -6.33771997e-03f,
  -6.54355213e-02f, -3.26790176e-02f, -7.21276850e-02f, -1.37113675e-01f, -8.71855691e-02f, -1.08207151e-01f, 1.10349379e-01f, 1.29595160e-01f, 1.53754801e-01f, 3.05890366e-02f,
  -6.73174113e-02f, 6.01520054e-02f, -4.19264659e-02f, 1.41873911e-01f, 1.06557384e-01f, -5.10456041e-03f, 1.06808841e-01f, -2.63532847e-02f, 8.18185359e-02f, 1.83044076e-01f,
  1.42061403e-02f, 7.82326460e-02f, 3.31902094e-02f, -4.83693630e-02f, -8.59208256e-02f, -1.25776291e-01f, -6.46066889e-02f, 4.99504022e-02f, -1.18202850e-01f, 4.13937978e-02f,
  -1.19909354e-01f, -2.57684682e-02f, -6.93871304e-02f, -4.12059948e-02f, 1.70606580e-02f, 4.15166467e-02f, -1.14603221e-01f, -7.24872872e-02f, -4.89254743e-02f, 1.09529011e-01f,
  3.05198301e-02f, 1.41273011e-02f, 5.78297190e-02f, 1.65857375e-01f, -1.85554653e-01f, 1.70571387e-01f, 1.47983665e-03f, 5.15593924e-02f, 4.38839979e-02f, -7.19863996e-02f,
  8.91947448e-02f, -3.93418856e-02f, 7.07552582e-02f, -1.32317115e-02f, 5.29907905e-02f, 1.31505430e-01f, -8.99732858e-02f, 6.47746772e-02f, 8.47205985e-03f, -1.26765952e-01f,
  -1.26496822e-01f, 5.62891737e-02f, 5.15035018e-02f, 1.44000828e-01f, 5.12770563e-02f, 1.09284282e-01f, -5.56877106e-02f, 1.91715389e-01f, -1.50131434e-01f, 2.63348557e-02f,
  6.92499429e-02f, 5.26181571e-02f, 4.82706614e-02f, 7.01838313e-03f, 4.57717329e-02f, 8.93269479e-02f, -2.88579036e-02f, -1.37461141e-01f, -1.09711953e-01f, 1.34642720e-01f,
  -1.69729635e-01f, 1.26871973e-01f, 8.04827578e-05f, -2.22121894e-01f, 8.54731798e-02f, 2.01464929e-02f, 1.45075426e-01f, 1.55928750e-02f, 3.13953124e-02f, 6.28515780e-02f,
  -7.39467591e-02f, -1.14840284e-01f, -1.29196897e-01f, 1.33507952e-01f, -4.15944010e-02f, 1.65221497e-01f, -1.13258906e-01f, 9.88153666e-02f, -6.56246245e-02f, 2.83487495e-02f,
  -4.01694216e-02f, -2.00413540e-03f, 1.46864802e-01f, -4.49568890e-02f, 8.60318094e-02f, 1.42914742e-01f, -1.52731583e-01f, -5.25467880e-02f, 1.22750387e-01f, 3.18444259e-02f,
  -3.01483530e-03f, -1.50671406e-02f, 7.14843422e-02f, 8.15549958e-03f, -1.22883081e-01f, -9.58356112e-02f, 2.56364904e-02f, -5.86769469e-02f, -1.18412569e-01f, 2.01538950e-02f,
  5.41535988e-02f, 8.07915162e-03f, -8.15337971e-02f, 1.63484633e-01f, 1.78362742e-01f, -7.68083781e-02f, 2.58969832e-02f, -1.62340130e-03f, -1.13697827e-01f, -1.40098095e-01f,
  -1.36516809e-01f, -2.63847142e-01f, 5.86924925e-02f, 8.34626183e-02f, -1.80516407e-01f, -1.18992843e-01f, -1.83420861e-03f, 2.74855532e-02f, 3.21187451e-02f, -7.18287826e-02f,
  1.02901757e-02f, 1.52063202e-02f, 5.94262630e-02f, 2.65943278e-02f, 1.20198496e-01f, 3.93558703e-02f, -3.16772722e-02f, 9.95890051e-02f, -9.56994575e-03f, -1.53695986e-01f,
  -1.20174512e-01f, 1.28999101e-02f, 5.76090217e-02f, -1.34291261e-01f, 2.47979332e-02f, 1.28135383e-01f, 9.60787684e-02f, 5.40643670e-02f, 1.28808558e-01f, -1.23310246e-01f,
  4.47324365e-02f, -2.83670705e-02f, 2.08352972e-02f, -2.11108610e-01f, 1.14540411e-02f, 1.51712790e-01f, -3.88431288e-02f, -3.00154369e-02f, -7.50779584e-02f, -1.94922388e-01f,
  1.18721284e-01f, 1.46577373e-01f, -7.74777234e-02f, 3.16857770e-02f, 6.71834499e-02f, -7.20828548e-02f, 1.95501167e-02f, -6.94850134e-03f, 2.78490060e-03f, -6.07950687e-02f,
  9.27684829e-02f, 8.16816315e-02f, -6.93372935e-02f, 8.07880163e-02f, -5.76473735e-02f, 1.32867545e-01f, 1.24516405e-01f, -1.35656133e-01f, -1.35919705e-01f, 1.39245331e-01f,
  -9.39673260e-02f, 1.56524986e-01f, 8.89980060e-04f, 4.00775000e-02f, 1.17344461e-01f, 2.94495046e-01f, -6.77706003e-02f, -9.94906425e-02f, 7.76027888e-02f, 7.04062209e-02f,
  -9.07878056e-02f, 6.74812943e-02f, -5.86324558e-02f, 5.88056147e-02f, 2.41870563e-02f, -1.80277556e-01f, -1.72239348e-01f, 9.49131921e-02f, 3.28744017e-02f, -7.59254918e-02f,
  -8.46450850e-02f, -3.31164077e-02f, -1.63657457e-01f, 1.07448645e-01f, 9.74856392e-02f, -1.53113618e-01f, -3.27654779e-02f, -1.13767147e-01f, -8.83673579e-02f, -1.11071825e-01f,
  -2.05853730e-01f, 3.55652869e-02f, 8.29133391e-03f, -9.04221311e-02f, 9.90048721e-02f, 1.40917143e-02f, -1.30904481e-01f, 2.17787679e-02f, 3.62835787e-02f, -8.63075182e-02f,
  -7.35797873e-03f, 1.50147289e-01f, 1.45061374e-01f, 1.16998665e-01f, 3.01990788e-02f, -1.04320496e-01f, -1.10759465e-02f, 1.21603966e-01f, -3.33456248e-02f, -7.93228745e-02f,
  8.18196386e-02f, 1.85184814e-02f, 2.14689272e-03f, 1.09803945e-01f, -1.86299141e-02f, 9.05142874e-02f, -1.20321028e-01f, -3.08403783e-02f, 5.45631647e-02f, -7.76669802e-03f,
  -1.12866469e-01f, 4.80604395e-02f, 9.35472026e-02f, 4.67082858e-02f, -1.09584153e-01f, 8.95493329e-02f, 1.09739296e-01f, -1.33893818e-01f, 2.78914571e-02f, -1.68350980e-01f,
  -2.80779507e-02f, -7.93561190e-02f, -1.20823264e-01f, -1.09688863e-01f, 1.18388601e-01f, -1.91842616e-02f, 7.76988119e-02f, 1.15514845e-01f, -5.86455502e-02f, -9.88701284e-02f,
  1.88567787e-02f, -5.98926097e-02f, -1.51568830e-01f, -7.66569749e-03f, -6.03554286e-02f, -3.29187810e-02f, -1.56499166e-02f, -5.33666909e-02f, 3.49237137e-02f, -4.24554534e-02f,
  -1.32993624e-01f, 2.51253229e-02f, -2.26934217e-02f, -1.25324428e-01f, -6.83820248e-02f, 1.04112223e-01f, 1.24652348e-01f, 6.95948163e-03f, 1.26525268e-01f, 4.47617732e-02f,
  4.53201085e-02f, -8.90577510e-02f, -8.03662166e-02f, -2.03226402e-01f, 5.35186939e-02f, -1.17285646e-01f, 8.10880736e-02f, 2.09384173e-01f, -1.02618031e-01f, -5.27326651e-02f,
  9.67921168e-02f, -1.31359175e-01f, 5.51753268e-02f, -2.13213898e-02f, 1.95356563e-01f, -5.50427623e-02f, -1.27163053e-01f, -1.05619967e-01f, -1.15161978e-01f, 6.19267039e-02f,
  8.71049706e-03f, -1.13739781e-01f, 1.28187137e-02f, -1.82960957e-01f, -1.35065168e-01f, 2.58718506e-02f, 6.30658343e-02f, 1.43803686e-01f, -2.99079008e-02f, -1.39209569e-01f,
  3.41306031e-02f, -1.44759178e-01f, -9.86745283e-02f, -1.53192133e-01f, 2.40972042e-02f, -8.68770182e-02f, 1.14137512e-02f, -5.57582974e-02f, -3.81274372e-02f, 5.06680682e-02f,
  7.17855766e-02f, 2.33997144e-02f, 1.15595199e-01f, -2.69393390e-03f, -1.14268502e-02f, -4.32262337e-03f, -1.51966019e-02f, -1.26867428e-01f, -3.82218808e-02f, -1.07086278e-01f,
  6.15728013e-02f, -1.28975324e-02f, 5.02798371e-02f, -1.18365861e-01f, -1.54303135e-02f, -9.50584412e-02f, -3.99701521e-02f, 1.09302185e-01f, -3.90317626e-02f, -4.97912019e-02f,
  1.20513238e-01f, 2.08880752e-02f, 4.92779650e-02f, 8.91155824e-02f, -1.27898678e-01f, -6.77975565e-02f, -1.07314289e-01f, 5.97384246e-03f, 1.43685326e-01f, -4.50554565e-02f,
  1.38699830e-01f, 1.61305293e-01f, 9.67333186e-03f, -1.09641187e-01f, 1.52787685e-01f, -1.50752231e-01f, 2.29374431e-02f, -7.61233866e-02f, 1.79086179e-01f, -3.51174138e-02f,
  1.31976744e-02f, 3.78677659e-02f, 5.52573038e-05f, -1.76049531e-01f, 4.07819189e-02f, -1.82775080e-01f, 1.33801371e-01f, -3.26704755e-02f, -5.84443274e-04f, 7.62520954e-02f,
  5.74686415e-02f, 9.84484889e-03f, -1.00464590e-01f, -1.08606443e-02f, -1.38162717e-01f, -4.06190120e-02f, -1.04557157e-01f, -1.50218427e-01f, -2.67475452e-02f, -1.37317013e-02f,
  -1.64145574e-01f, -1.88125059e-01f, -6.03509657e-02f, -1.23641782e-01f, 1.23568237e-01f, -2.38049086e-02f, 1.27777711e-01f, 8.57275352e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.28382891e-01f, 4.33043800e-02f, 6.50737658e-02f, 6.80809394e-02f, 1.59454897e-01f, 1.24511220e-01f, 2.65698712e-02f, 1.14318341e-01f, -2.42856983e-02f, -8.58049840e-03f,
  8.14847201e-02f, -6.58814283e-03f, 9.46499035e-02f, -1.99198164e-02f, -1.09086379e-01f, -5.43699078e-02f, 9.16180853e-03f, -3.60244066e-02f, 1.26097873e-01f, -1.30047062e-02f,
  9.96095389e-02f, 7.74517236e-03f, 9.83277038e-02f, 3.79132032e-02f, -1.21599399e-01f, 8.18423703e-02f, -7.54495338e-02f, 1.42311767e-01f, -5.24844527e-02f, -8.68888665e-03f,
  4.02366277e-03f, 1.08549178e-01f, 5.67153990e-02f, 1.53242927e-02f, -9.14253145e-02f, 1.39964566e-01f, 1.30383521e-01f, 1.02748923e-01f, 6.45865276e-02f, -7.74774626e-02f,
  7.66036510e-02f, 2.96414979e-02f, 2.01526955e-02f, -1.25605106e-01f, -8.76460150e-02f, 3.63688916e-02f, 4.87881973e-02f, -6.13404065e-02f, -9.11125764e-02f, -1.58103555e-02f,
  6.98088631e-02f, 1.18345186e-01f, -5.77221476e-02f, 1.60688087e-01f, -6.67788535e-02f, -6.43094182e-02f, 1.12263970e-01f, 1.48363799e-01f, -2.60883812e-02f, 1.43558234e-01f,
  1.50750458e-01f, 1.08071499e-01f, 4.57397178e-02f, -6.06325939e-02f, 8.94839615e-02f, 7.06882477e-02f, 1.01094864e-01f, 1.43265381e-01f, 1.35145709e-01f, 1.86617494e-01f,
  -5.34954597e-06f, -3.66875269e-02f, -6.07451946e-02f, 2.63045523e-02f, 6.75302148e-02f, -4.10619825e-02f, -8.01779628e-02f, 1.44850895e-01f, 8.78981650e-02f, 6.57437593e-02f,
  -5.12995012e-02f, -1.62658751e-01f, 2.37727240e-01f, -1.40609279e-01f, -5.97818941e-02f, -2.42489856e-03f, 1.35543933e-02f, -2.23288491e-01f, -3.55975442e-02f, 5.02916835e-02f,
  1.30027272e-02f, 1.26235098e-01f, 6.18039668e-02f, 3.76758575e-02f, 1.44052669e-01f, -1.83207728e-02f, -3.08057982e-02f, 1.92359015e-02f, 1.23059504e-01f, 1.05412856e-01f,
  1.43287718e-01f, -7.91856572e-02f, 5.42171150e-02f, -1.40936106e-01f, -1.02243617e-01f, -1.67411372e-01f, 2.73475707e-01f, -1.38331190e-01f, -1.31788924e-01f, -5.77268526e-02f,
  -3.95380706e-02f, 3.17611210e-02f, -2.67873146e-02f, 1.39188349e-01f, -1.30052239e-01f, 9.83688235e-02f, 1.64901450e-01f, 1.19291194e-01f, -7.45928660e-02f, -5.40103912e-02f,
  3.07736155e-02f, 2.62065139e-02f, 8.16036165e-02f, 2.12829798e-01f, 1.90266579e-01f, -5.64803332e-02f, -9.87495179e-04f, -1.54888004e-01f, 7.13213831e-02f, -6.43569529e-02f,
  -8.31938311e-02f, -1.01626895e-01f, -1.15777394e-02f, 5.66484965e-02f, -6.10744990e-02f, -1.80287510e-02f, 6.49234653e-02f, 3.82032841e-02f, 5.28107546e-02f, 1.18180506e-01f,
  -5.62872319e-03f, -5.58248302e-03f, 3.59578505e-02f, 7.25946650e-02f, 4.13506627e-02f, -3.78307253e-02f, 3.44205424e-02f, -7.41319209e-02f, 1.24681257e-01f, -4.54745814e-02f,
  8.22361261e-02f, -6.07649125e-02f, -7.06304461e-02f, -2.77213324e-02f, 7.29201064e-02f, -3.97343375e-02f, 6.30640658e-03f, 1.12245575e-01f, -9.24339518e-02f, 6.05099797e-02f,
  -6.79552183e-02f, -8.11510906e-02f, -8.51568654e-02f, 3.44138183e-02f, -1.74385197e-02f, -5.81005774e-03f, -1.14889834e-02f, 5.68156354e-02f, -8.97176489e-02f, -1.34551570e-01f,
  -4.48608883e-02f, -3.22617106e-02f, -1.99718922e-02f, 1.97661202e-02f, 7.19887717e-03f, -7.53652751e-02f, -9.70639754e-04f, 8.18189755e-02f, -7.64944702e-02f, 1.07558630e-01f,
  9.54910144e-02f, -8.49330425e-02f, -9.46414918e-02f, -1.47171160e-02f, 4.58242930e-02f, 8.97170827e-02f, -1.25540987e-01f, 7.83885419e-02f, -3.45726050e-02f, 5.29839769e-02f,
  -4.98381443e-03f, 7.96975121e-02f, 6.52768835e-02f, 7.37748072e-02f, 1.23406149e-01f, 1.06614880e-01f, 9.24491361e-02f, -9.91701931e-02f, -1.12233542e-01f, 2.19259068e-01f,
  1.52748659e-01f, 2.64259744e-02f, 1.87751263e-01f, 1.15466408e-01f, 6.08303510e-02f, 8.63424595e-03f, -9.03330371e-02f, -7.34221637e-02f, -1.06659755e-01f, -1.09890990e-01f,
  -1.55490026e-01f, -1.22235961e-01f, -1.44132584e-01f, 1.07199326e-01f, -6.55269064e-03f, 6.70164600e-02f, 9.71260220e-02f, -7.87392855e-02f, -4.36498336e-02f, 9.64095443e-02f,
  -1.31280109e-01f, 2.04090290e-02f, -1.84552073e-01f, 9.04689133e-02f, 1.37793064e-01f, 7.19267055e-02f, 1.78583786e-01f, -1.02083802e-01f, -2.08832975e-03f, -1.00070365e-01f,
  8.13466161e-02f, 1.49465501e-01f, 1.42051071e-01f, 8.63527805e-02f, -2.23889574e-01f, 3.73624265e-02f, 7.68124461e-02f, -7.89549761e-03f, -8.20992738e-02f, -2.22337320e-02f,
  -9.90699306e-02f, 3.35235670e-02f, 1.44597396e-01f, -1.03054799e-01f, -1.53473213e-01f, -5.55679910e-02f, 8.49437043e-02f, -1.45198509e-01f, -3.91474739e-02f, 1.43485054e-01f,
  1.23249322e-01f, -1.02559872e-01f, 5.22975586e-02f, -1.63686708e-01f, -3.59771377e-03f, -1.44396173e-02f, -2.33592116e-03f, 1.61922246e-01f, -5.61648719e-02f, 9.77366045e-02f,
  1.73287258e-01f, -6.14530593e-02f, 2.20023409e-01f, 1.01437478e-03f, 2.96287090e-01f, 1.46572724e-01f, 3.00495028e-01f, 1.26606926e-01f, -2.77341884e-02f, 2.42135510e-01f,
  -1.31122977e-01f, -1.75431184e-02f, 2.86601651e-02f, 1.15902334e-01f, -2.97700524e-01f, -2.07916498e-01f, -1.16944201e-01f, -1.66190535e-01f, 3.32230888e-02f, 6.88819215e-02f,
  -2.58309618e-02f, 6.67525968e-03f, -2.63783596e-02f, 2.31705830e-01f, 5.06836548e-03f, 1.19930372e-01f, -9.92857814e-02f, 3.01194377e-02f, 7.20101073e-02f, 7.46845603e-02f,
  1.65142298e-01f, 7.36668408e-02f, 1.53739348e-01f, 5.77394618e-03f, 6.22326583e-02f, -1.60668809e-02f, -3.99958603e-02f, -7.20093623e-02f, -1.61685888e-02f, 6.79515228e-02f,
  2.04051286e-03f, 3.06886345e-01f, -9.58611295e-02f, -2.63665766e-02f, -1.29115835e-01f, 4.99617197e-02f, 1.04355685e-01f, 1.01947397e-01f, -7.73343295e-02f, 1.62372380e-01f,
  9.88416448e-02f, 1.77794635e-01f, -8.70062709e-02f, 1.81882888e-01f, 1.32860160e-02f, 9.44052264e-02f, 1.52935013e-01f, -2.26530120e-01f, -6.95140138e-02f, -2.41898838e-02f,
  -5.83416596e-02f, -1.30838957e-02f, 9.27583501e-02f, 6.04011156e-02f, -5.88170812e-02f, 2.09371567e-01f, 3.51640768e-02f, -6.95555732e-02f, 3.76832485e-02f, 3.72595713e-02f,
  -5.47145754e-02f, 4.73563708e-02f, 9.83636826e-02f, 1.50125638e-01f, 2.67633256e-02f, -3.33630331e-02f, 7.32362568e-02f, -1.42621547e-01f, 5.01944758e-02f, 1.85592808e-02f,
  3.79153080e-02f, 4.63330746e-02f, 1.19713373e-01f, -1.38572633e-01f, 6.47248626e-02f, 4.19642143e-02f, -1.75712798e-02f, 4.89250645e-02f, 1.09400362e-01f, 1.03363104e-01f,
  -7.94492215e-02f, 5.46212494e-02f, 1.32176921e-01f, -3.29264775e-02f, 8.92384537e-03f, 9.51452255e-02f, 1.06628343e-01f, 2.74456944e-03f, -8.67168978e-02f, 1.18651837e-01f,
  -6.22790754e-02f, 2.01912746e-02f, -5.99808246e-02f, 5.63415587e-02f, 7.08371177e-02f, -3.17902751e-02f, 5.25197480e-03f, -2.14713681e-02f, -3.54728140e-02f, 4.13104966e-02f,
  1.29025891e-01f, 5.81027344e-02f, 9.12433490e-02f, 1.98139787e-01f, -1.57952622e-01f, -5.19245900e-02f, 9.66352448e-02f, 1.51200041e-01f, -1.05361894e-01f, -5.38561009e-02f,
  -6.58407286e-02f, 1.37469143e-01f, -5.17534092e-02f, 7.31683597e-02f, 1.78851992e-01f, 1.72336832e-01f, 8.25199261e-02f, 1.34468526e-01f, 2.38174684e-02f, 8.05787668e-02f,
  1.15822375e-01f, 5.39309457e-02f, 5.28512821e-02f, 1.33852959e-01f, -4.59162109e-02f, 7.81304240e-02f, 1.36914432e-01f, 2.51645111e-02f, -2.87948232e-02f, -1.02382213e-01f,
  -1.04492195e-01f, -2.16026142e-01f, 1.54948622e-01f, -2.63996758e-02f, 1.15205280e-01f, -1.27176329e-01f, 4.86097038e-02f, 1.97864175e-02f, 5.81433773e-02f, 8.18696618e-03f,
  -7.12059066e-02f, 1.58358783e-01f, 8.07091594e-02f, 1.91772282e-01f, -1.72442734e-01f, -1.44128092e-02f, -5.81532419e-02f, 5.09570092e-02f, -2.40588095e-02f, -2.87043341e-02f,
  5.50736561e-02f, 2.88674552e-02f, -1.36127070e-01f, 4.41187397e-02f, 1.36852294e-01f, 1.21219054e-01f, 9.25345644e-02f, -6.08352944e-02f, 4.07262072e-02f, -4.96192202e-02f,
  -8.93590823e-02f, -2.03932635e-02f, -7.04883114e-02f, 6.09272793e-02f, 1.68392107e-01f, -5.15721627e-02f, 7.68441111e-02f, 1.78111866e-02f, -1.07737854e-01f, -1.30024955e-01f,
  2.16546789e-01f, 6.21417649e-02f, -7.54223317e-02f, -3.55815552e-02f, 1.17394745e-01f, 1.33785054e-01f, -5.59785888e-02f, 2.77552120e-02f, -1.95966121e-02f, -1.12871639e-01f,
  6.05888888e-02f, 2.45331395e-02f, -4.07225192e-02f, -2.17373520e-02f, 5.96675277e-02f, -1.81089379e-02f, -1.95988901e-02f, 1.30042508e-01f, 7.49238804e-02f, 1.19181335e-01f,
  8.17741156e-02f, 8.81929472e-02f, 3.37717161e-02f, 2.23006681e-02f, 1.93485003e-02f, 7.30717704e-02f, 9.82362181e-02f, -6.60310015e-02f, 1.15316600e-01f, -8.28275681e-02f,
  -2.93855965e-02f, 1.82596222e-02f, -3.94059047e-02f, 6.74599856e-02f, 3.58116478e-02f, -1.52256051e-02f, -1.04088001e-02f, 6.02369197e-02f, -5.29806390e-02f, 1.24309793e-01f,
  4.26818356e-02f, 8.86918753e-02f, 9.07509848e-02f, 1.17520094e-01f, 5.32780588e-02f, 1.25404119e-01f, -8.79445300e-02f, -9.10874903e-02f, 5.41448444e-02f, 2.08522659e-02f,
  2.58514285e-02f, -1.33446962e-01f, -3.56901512e-02f, -8.60127434e-02f, -1.62767048e-03f, 1.15240011e-02f, 1.33915097e-01f, 9.44358930e-02f, -8.06492195e-02f, -4.07289201e-03f,
  1.09303325e-01f, 1.92550749e-01f, -6.81811944e-02f, 3.36901061e-02f, 1.05431341e-01f, -2.10590903e-02f, -7.40489643e-03f, 1.53629631e-01f, 7.48341456e-02f, 2.23610383e-02f,
  6.20234497e-02f, -1.70035679e-02f, 1.09622419e-01f, -2.89382320e-02f, 2.20519811e-01f, 3.80362310e-02f, 5.08731119e-02f, 1.20533466e-01f, 8.05504248e-02f, -9.29481629e-03f,
  -2.08221041e-02f, 4.22871076e-02f, -1.82820231e-01f, 5.77051938e-02f, 6.06254898e-02f, -1.16229378e-01f, -3.48708150e-03f, -4.02604006e-02f, -5.68844117e-02f, -3.44787957e-03f,
  2.67042577e-01f, 1.34358525e-01f, 1.45685673e-01f, -3.86270434e-02f, -7.21197724e-02f, -7.33900741e-02f, 1.00307263e-01f, 2.61552050e-03f, -6.97032660e-02f, 8.60282704e-02f,
  7.03035146e-02f, -2.04575174e-02f, -7.76315853e-02f, -9.99534801e-02f, -6.53939694e-02f, 4.34135608e-02f, 2.09364318e-03f, -3.01809027e-03f, -3.09088230e-02f, 7.64288381e-02f,
  -8.58730525e-02f, 5.50679862e-02f, 3.70153226e-02f, 1.73048452e-02f, 1.32815503e-02f, -7.29101524e-03f, -3.56074758e-02f, -5.58168776e-02f, 1.74167812e-01f, 1.98422134e-01f,
  9.51268151e-02f, -1.31050438e-01f, 5.77170542e-03f, -3.79129201e-02f, -1.67981051e-02f, 4.32896502e-02f, 1.68653294e-01f, -1.12000339e-01f, 1.74937755e-01f, 1.03249783e-02f,
  -1.85612038e-01f, 1.35075122e-01f, 1.20514840e-01f, 2.60407329e-01f, 7.50435367e-02f, 6.70270249e-02f, 3.51445451e-02f, -8.09784457e-02f, 5.61605468e-02f, -8.04169551e-02f,
  4.95523624e-02f, -6.03325106e-02f, -8.88604298e-02f, -4.66471463e-02f, -6.95182160e-02f, 3.26123685e-02f, -2.63714176e-02f, 4.36705686e-02f, 6.39797002e-02f, 3.20063718e-02f,
  -8.74354094e-02f, 2.31489190e-04f, 5.81981502e-02f, -5.78952059e-02f, -1.25184646e-02f, -1.13965059e-02f, -7.41593689e-02f, 1.08630769e-02f, -5.57552241e-02f, 7.66705126e-02f,
  9.42942351e-02f, -1.11862920e-01f, -3.90028059e-02f, 3.80081721e-02f, -2.91529931e-02f, -1.27153665e-01f, 7.89703056e-02f, 1.20933346e-01f, -1.37042562e-02f, -3.58193889e-02f,
  -3.26916538e-02f, 2.87506469e-02f, -1.18940577e-01f, -7.12105678e-03f, 1.07712694e-01f, 6.16562515e-02f, -5.16060069e-02f, 2.31505595e-02f, -1.40756639e-02f, -4.92700981e-03f,
  2.37127151e-02f, -1.93883553e-02f, 1.70086734e-02f, -1.14596732e-01f, -1.85096227e-02f, 1.00933991e-01f, 7.19537437e-02f, -6.51645064e-02f, -9.43060685e-03f, -1.18877769e-01f,
  -4.57432233e-02f, 3.32138464e-02f, -8.55472460e-02f, 9.67272297e-02f, 5.12791239e-02f, -4.26376425e-02f, -1.14300596e-02f, -6.68646172e-02f, -7.16145188e-02f, -2.78077424e-02f,
  6.75473809e-02f, -1.19838245e-01f, -8.53640959e-02f, -1.14914820e-01f, 4.19271104e-02f, 5.15258461e-02f, 1.13695323e-01f, -1.89283732e-02f, -9.64872725e-03f, -1.06315725e-01f,
  -8.60181227e-02f, 6.32345751e-02f, 5.65658100e-02f, 5.05741592e-03f, 1.06514513e-01f, 1.36166029e-02f, 7.63620883e-02f, -7.35498220e-02f, 3.45735215e-02f, -3.01156472e-02f,
  -6.84289038e-02f, 8.13603029e-02f, -6.18823841e-02f, -1.10762283e-01f, -5.66497184e-02f, -4.67727222e-02f, 4.37446721e-02f, -1.06555074e-01f, -1.07090078e-01f, 4.60807197e-02f,
  1.32795637e-02f, 7.70805255e-02f, 1.00547345e-02f, 3.01876385e-02f, -8.68827850e-02f, -2.28582346e-03f, -1.09159894e-01f, 5.31909727e-02f, 4.45350669e-02f, 6.63938299e-02f,
  -5.64515255e-02f, -5.20018898e-02f, -1.17499292e-01f, -4.16568108e-02f, 2.22412292e-02f, -1.24382367e-02f, -6.37687817e-02f, -6.88172430e-02f, -6.29959255e-02f, -1.19816393e-01f,
  -1.22501850e-01f, -9.60932523e-02f, -7.04795122e-02f, 3.71148288e-02f, -1.17577679e-01f, 5.07939160e-02f, 2.86508119e-03f, -8.65447447e-02f, 5.49383573e-02f, 1.08850207e-02f,
  6.61607012e-02f, -1.21757379e-02f, -4.54018787e-02f, 8.50932449e-02f, 1.38356760e-01f, 6.37160540e-02f, 3.09229735e-02f, 4.19185590e-03f, -5.86285163e-03f, 9.14229900e-02f,
  -4.74613579e-03f, -2.56198496e-02f, 6.75731897e-02f, -1.32395960e-02f, 5.67697622e-02f, -1.04263842e-01f, -5.13624884e-02f, -1.44516870e-01f, -2.60288361e-03f, 8.61677974e-02f,
  6.88393041e-03f, 4.76818234e-02f, 1.55292466e-01f, 9.56795365e-02f, 7.52291307e-02f, -3.13947052e-02f, 4.57342863e-02f, -1.19890776e-02f, -4.64085117e-03f, 7.91367888e-02f,
  1.01417169e-01f, -7.41263703e-02f, -7.92193227e-03f, 6.08107671e-02f, -1.04907155e-01f, 1.28825128e-01f, 8.54036137e-02f, 8.58397596e-03f, -1.99381281e-02f, 1.19169667e-01f,
  5.97411580e-02f, -4.65378724e-03f, -5.10211550e-02f, -1.88594703e-02f, -4.66515273e-02f, -3.36237974e-03f, 4.05682251e-02f, 1.01510428e-01f, -1.32076399e-04f, -8.44968576e-03f,
  6.48804083e-02f, 1.38246035e-02f, 1.23875752e-01f, -1.10121757e-01f, -1.17686085e-01f, 1.18714735e-01f, 1.13567933e-01f, -6.64686188e-02f, -4.46255356e-02f, 4.97554466e-02f,
  -3.92034203e-02f, 5.99000975e-03f, -5.93109662e-03f, 3.29264700e-02f, 8.96773487e-02f, -6.78739920e-02f, -1.12389155e-01f, -1.03742100e-01f, 1.17477305e-01f, -1.03971526e-01f,
  1.40622452e-01f, 1.64418630e-02f, 9.62971151e-02f, 6.32034168e-02f, -2.82239541e-02f, -2.88937762e-02f, -1.03932939e-01f, 5.13951145e-02f, -6.29225280e-03f, -5.45427687e-02f,
  5.34280874e-02f, 1.21227443e-01f, -2.06413455e-02f, 6.43308312e-02f, 7.06457943e-02f, 1.75875891e-02f, 9.82146859e-02f, -8.42796862e-02f, 4.72378284e-02f, -1.24779515e-01f,
  4.10100802e-05f, -2.60590892e-02f, 1.14275016e-01f, -4.73291725e-02f, 9.26892161e-02f, 1.79892518e-02f, 1.34202927e-01f, 5.43572195e-02f, -2.76995841e-02f, 3.30616720e-02f,
  1.28214002e-01f, -6.82766512e-02f, -1.19425759e-01f, 1.23480499e-01f, 6.13155030e-02f, -4.65732478e-02f, 4.97619063e-02f, 8.52162018e-02f, 1.02123030e-01f, -1.21436184e-02f,
  1.69111237e-01f, 9.61963981e-02f, 8.24400410e-02f, 1.08327782e-02f, 9.33970138e-03f, 2.98339445e-02f, -5.59300631e-02f, -3.16835493e-02f, -1.58865750e-02f, 1.24039866e-01f,
  -2.15943567e-02f, 7.14346617e-02f, 2.45889719e-03f, -1.19290054e-01f, -5.63565530e-02f, -4.16597202e-02f, 4.17092368e-02f, 9.39013138e-02f, -6.90800399e-02f, 4.01183553e-02f,
  4.31932658e-02f, 3.27760614e-02f, -6.92145079e-02f, 1.83160126e-01f, -8.21767971e-02f, 1.01056099e-01f, 1.52295992e-01f, 1.08524166e-01f, -4.14616913e-02f, -1.37826532e-01f,
  2.95964211e-01f, 1.32172748e-01f, 2.51454979e-01f, 1.36022463e-01f, -2.92114854e-01f, 1.62870884e-01f, -2.75490522e-01f, 2.13757288e-02f, 9.20732319e-02f, 3.46742719e-01f,
  -5.89473769e-02f, -8.89521092e-02f, -2.69558817e-01f, -1.69142529e-01f, -1.18395472e-02f, -1.56430811e-01f, -5.40251583e-02f, 5.45566492e-02f, 1.89289212e-01f, 3.56831610e-01f,
  -1.01664603e-01f, -1.75457016e-01f, 1.63066819e-01f, 9.72098336e-02f, 1.18584029e-01f, -8.73893723e-02f, 3.34104657e-01f, 7.23158792e-02f, -9.82826948e-02f, 5.75298592e-02f,
  1.08396016e-01f, -1.33113146e-01f, 9.51051041e-02f, 4.66617085e-02f, -4.48945118e-03f, -2.38682494e-01f, 1.01188235e-01f, 3.72353405e-01f, 7.24763423e-03f, 2.32077222e-02f,
  -1.02109380e-01f, 7.32007902e-03f, 1.21268533e-01f, -2.05988079e-01f, 4.64234091e-02f, 7.78052211e-02f, 1.16132557e-01f, 2.19466299e-01f, 2.43292283e-02f, -1.79021239e-01f,
  1.76099256e-01f, -7.91837275e-03f, 8.46355483e-02f, -1.06120460e-01f, 1.73063040e-01f, 1.18698806e-01f, 2.38658655e-02f, 1.29798904e-01f, 1.55867785e-01f, 1.40914053e-01f,
  5.59412129e-02f, 1.49895579e-01f, -9.03413966e-02f, 1.95019454e-01f, -9.61135477e-02f, 4.29903641e-02f, 1.39823034e-01f, 7.09410161e-02f, -7.38483444e-02f, -1.74742922e-01f,
  -1.04157791e-01f, -4.38067168e-02f, 1.33677125e-01f, -1.21771596e-01f, -5.20548709e-02f, -7.73003548e-02f, -1.22135207e-01f, 8.31349865e-02f, 2.05337219e-02f, 9.50340405e-02f,
  2.27152668e-02f, 2.01912239e-01f, -1.13395993e-02f, 1.20572835e-01f, -6.62615225e-02f, -6.38775527e-02f, -2.29592443e-01f, -9.90177467e-02f, 4.78389151e-02f, 3.13227884e-02f,
  1.20965295e-01f, -1.34442240e-01f, -2.84906346e-02f, -5.70913889e-02f, -2.73112468e-02f, 1.82963669e-01f, 5.67029230e-02f, 2.24974960e-01f, -1.41530991e-01f, -1.80758201e-02f,
  1.56058714e-01f, -1.30700126e-01f, -8.14556554e-02f, -1.23275466e-01f, -5.86931109e-02f, 8.80246237e-02f, 2.63369650e-01f, 1.11072116e-01f, -1.44022673e-01f, 1.09805800e-01f,
  -9.46452841e-02f, -7.41311386e-02f, 1.72601253e-01f, 6.70060366e-02f, 1.16761945e-01f, 1.04115568e-01f, -1.25011399e-01f, 6.36158958e-02f, 6.84140027e-02f, 1.11275479e-01f,
  -3.60983424e-02f, -8.48620161e-02f, -4.34913598e-02f, 1.85067594e-01f, 1.52047396e-01f, 8.86456445e-02f, 5.02866618e-02f, -1.24970078e-01f, 1.31178826e-01f, 7.73098692e-02f,
  2.22328305e-01f, 9.26630571e-02f, -8.10732543e-02f, 1.62997782e-01f, 2.35306732e-02f, -9.63294357e-02f, 1.96967274e-02f, 1.28988490e-01f, -7.70470425e-02f, 3.05400789e-02f,
  -1.34266540e-01f, -3.15132029e-02f, 2.52625234e-02f, 1.14717484e-01f, -1.04145408e-01f, 3.70904133e-02f, 1.33638149e-02f, -2.79074945e-02f, 4.53511104e-02f, -1.46920919e-01f,
  1.49076089e-01f, 5.09243943e-02f, -9.94985178e-02f, -9.55012590e-02f, 1.38626322e-01f, 7.63045475e-02f, 5.16809113e-02f, 6.11780817e-03f, 9.80647132e-02f, 3.25494297e-02f,
  4.08624811e-03f, -6.90573975e-02f, 1.56176165e-01f, -1.35021374e-01f, -1.07466802e-01f, 1.68861195e-01f, -4.63871472e-02f, -2.52973698e-02f, 4.36507538e-03f, -1.02852106e-01f,
  -3.12321447e-02f, -1.03413805e-01f, 9.85446945e-02f, 7.16084465e-02f, 5.72540574e-02f, -1.72817744e-02f, -8.69438052e-02f, -1.04972169e-01f, -8.92014951e-02f, -2.83246059e-02f,
  1.15949653e-01f, -9.99601111e-02f, 1.16170116e-01f, -1.42852962e-01f, -4.41974364e-02f, 1.07043520e-01f, 9.47631672e-02f, -6.98008481e-03f, 2.50763111e-02f, -9.34511125e-02f,
  2.25723609e-02f, 4.44195382e-02f, 1.10956514e-02f, 1.03795744e-01f, 8.48607421e-02f, 5.46010025e-02f, -2.73311678e-02f, 3.01350374e-02f, 8.19470435e-02f, -9.57353860e-02f,
  -1.12863705e-01f, -9.76917669e-02f, -1.05383240e-01f, -1.56937137e-01f, 6.11713231e-02f, -1.10364012e-01f, 8.29896331e-02f, 3.39275301e-02f, -1.18939817e-01f, -7.39404485e-02f,
  -5.15765250e-02f, -8.18581954e-02f, 1.23546615e-01f, -9.04397815e-02f, -1.54412361e-02f, 1.26252949e-01f, 5.97669072e-02f, -1.18243985e-01f, 1.72462855e-02f, 7.91648924e-02f,
  -5.51138334e-02f, -9.04104710e-02f, 5.43087795e-02f, 1.81514304e-02f, -6.42770603e-02f, 3.14316973e-02f, 1.70866743e-01f, -5.67425005e-02f, -1.31688803e-01f, -2.64626145e-02f,
  5.45103438e-02f, -1.30034715e-01f, -4.62761195e-03f, 8.09675977e-02f, -5.14526218e-02f, 8.30360427e-02f, 1.22921303e-01f, -8.93810485e-03f, 6.05879575e-02f, 3.90626341e-02f,
  -1.05272904e-01f, 1.94490086e-02f, -8.15020651e-02f, 2.56967824e-02f, 1.65785447e-01f, -1.66205302e-01f, 1.06736444e-01f, 6.22879677e-02f, 2.08879188e-01f, 1.40584216e-01f,
  1.15381978e-01f, -5.53951412e-02f, 1.17334239e-01f, -9.80366766e-02f, 1.12249084e-01f, 1.79990023e-01f, -7.81444192e-04f, 2.05334395e-01f, -8.93032998e-02f, 9.61482078e-02f,
  -4.37938422e-02f, -1.69380218e-01f, 1.45750597e-01f, 6.91989437e-02f, 8.95683318e-02f, -9.58511606e-02f, 1.59650967e-01f, -6.21982384e-03f, 1.36589766e-01f, 7.75090680e-02f,
  -8.36274028e-02f, 1.90472119e-02f, 1.34760410e-01f, -2.73681637e-02f, 8.56971517e-02f, -3.94251756e-02f, 2.44616140e-02f, -3.53875235e-02f, 1.85204804e-01f, 3.28989066e-02f,
  -1.01269431e-01f, 9.33820084e-02f, -1.51485905e-01f, -6.68556616e-02f, -6.50021285e-02f, 1.44818291e-01f, -1.17277302e-01f, -6.29812106e-02f, -1.99335739e-02f, -4.85087223e-02f,
  1.45120591e-01f, -3.58205475e-02f, -2.03653332e-02f, -1.64867774e-01f, 4.09498774e-02f, 1.50615498e-01f, 1.25145903e-02f, 5.81564009e-02f, 6.55099824e-02f, 2.72707697e-02f,
  9.63507518e-02f, -1.15101039e-01f, 1.21007830e-01f, -6.81288093e-02f, -7.56236725e-03f, -6.54064640e-02f, -1.92355052e-01f, 5.21485023e-02f, 3.27508785e-02f, 4.03089225e-02f,
  6.27153460e-03f, 1.05004922e-01f, 3.70723419e-02f, -5.34188300e-02f, 1.22762308e-01f, 6.03189655e-02f, 8.79251882e-02f, 1.21007115e-01f, 1.10631585e-01f, 6.34254292e-02f,
  5.53563470e-03f, -8.33083838e-02f, -1.40501037e-02f, 1.31729946e-01f, 5.57205314e-03f, -7.88584724e-02f, 1.88237876e-01f, 4.58224230e-02f, -4.24656235e-02f, -1.37680396e-01f,
  -5.43609727e-03f, -3.15244496e-02f, -6.07284643e-02f, 6.46555349e-02f, -1.04609601e-01f, 2.37348620e-02f, -7.06950277e-02f, 1.10838525e-01f, -5.31893782e-02f, -1.21626936e-01f,
  7.28421435e-02f, 8.00768435e-02f, -1.38566166e-01f, 6.90388726e-03f, -1.14938170e-01f, 5.96020520e-02f, -1.27644390e-01f, 1.12738624e-01f, -3.17030549e-02f, -8.24158564e-02f,
  4.68042865e-02f, 8.37477669e-02f, 3.02316472e-02f, 8.84286687e-02f, 6.66422173e-02f, -2.38593090e-02f, 2.52222214e-02f, 6.16997853e-03f, 2.95568779e-02f, -1.24544615e-03f,
  -7.13007599e-02f, -1.19564198e-01f, -1.46334013e-02f, 1.13069771e-04f, -4.87254150e-02f, 2.78586783e-02f, -2.66519245e-02f, -1.50511572e-02f, 1.35039121e-01f, -7.08800852e-02f,
  -5.05437888e-02f, -9.47978944e-02f, 6.25692904e-02f, -3.67125347e-02f, 2.81338755e-04f, -9.19195041e-02f, 9.03350860e-02f, -3.07129696e-02f, -7.21995160e-02f, 1.06754728e-01f,
  4.65165600e-02f, 1.95167154e-01f, 1.54740110e-01f, 1.41346883e-02f, 3.79112139e-02f, 7.36226663e-02f, 1.67514756e-01f, -2.98865102e-02f, 8.20417597e-04f, 5.41087724e-02f,
  -4.72395532e-02f, -1.13483489e-01f, -8.28565732e-02f, 1.23074129e-01f, 1.03717495e-03f, -4.91963588e-02f, -1.24956019e-01f, -3.76275517e-02f, 5.89095987e-02f, 1.12873629e-01f,
  6.13172725e-02f, 5.04714549e-02f, -7.70459622e-02f, 1.89332828e-01f, -9.94822085e-02f, -9.09314081e-02f, 7.68314004e-02f, 7.73941353e-03f, 3.48432139e-02f, 8.62806290e-02f,
  2.02791393e-01f, 9.61378738e-02f, 6.71076402e-02f, 9.82620269e-02f, 6.53541759e-02f, -9.24356654e-02f, 4.96223867e-02f, -8.36716294e-02f, 9.60606113e-02f, -1.62621647e-01f,
  1.05206758e-01f, 1.09034061e-01f, -5.61981276e-02f, 2.43782680e-02f, -4.54535596e-02f, -2.61538550e-02f, -1.31887436e-01f, -8.79877731e-02f, 4.97910567e-02f, 9.98815522e-02f,
  3.10343001e-02f, 1.56465814e-01f, -3.09058335e-02f, -1.73237324e-01f, 3.23485211e-02f, 1.12845190e-01f, -3.53101664e-03f, -1.38975561e-01f, 6.78737685e-02f, -8.83265510e-02f,
  2.73919161e-02f, -8.64441246e-02f, -9.38653648e-02f, 9.58026852e-03f, -7.63565162e-03f, -2.51625646e-02f, 5.80971763e-02f, -5.39645106e-02f, 1.41099736e-01f, 1.25641569e-01f,
  9.41367522e-02f, -1.19919507e-02f, 1.15909584e-01f, 9.63671282e-02f, 1.19721524e-01f, 4.58326377e-02f, -2.39433087e-02f, -1.33235350e-01f, -1.28506735e-01f, -2.05082055e-02f,
  5.60617857e-02f, 7.49670193e-02f, 9.93656516e-02f, -2.43156552e-02f, -1.93000883e-02f, -3.56133953e-02f, 1.10135891e-01f, -4.52925265e-02f, 2.56507732e-02f, 8.23221132e-02f,
  3.85809168e-02f, 3.13586704e-02f, 5.14573194e-02f, 5.16139194e-02f, -3.78830656e-02f, 7.76977912e-02f, 3.46755683e-02f, -6.31857291e-02f, 8.34595039e-02f, -4.35373299e-02f,
  -8.60870630e-02f, -3.65676470e-02f, -7.91589618e-02f, 5.49716167e-02f, -5.37206493e-02f, 6.37592673e-02f, 1.48479454e-02f, -4.02611271e-02f, -1.08611695e-01f, 2.08227001e-02f,
  1.11120321e-01f, 1.79890152e-02f, -4.13374044e-02f, -5.47208190e-02f, -3.09507009e-02f, -9.23714787e-02f, -3.98824811e-02f, 4.31025736e-02f, -7.79456869e-02f, -3.56941205e-03f,
  2.94386297e-02f, -7.48589486e-02f, -4.06590337e-03f, -5.51462695e-02f, 5.52657992e-03f, -6.92913383e-02f, -1.02956191e-01f, 8.10955614e-02f, -3.10280751e-02f, -2.59818770e-02f,
  -4.07554433e-02f, -1.29254431e-01f, 1.83716770e-02f, -1.29275456e-01f, -4.81210425e-02f, 1.12290129e-01f, -3.85676473e-02f, -1.01451442e-01f, 9.08640325e-02f, 8.73269439e-02f,
  -1.65997054e-02f, 7.68843144e-02f, 9.83582661e-02f, -2.03644317e-02f, 3.84447351e-02f, 6.39828220e-02f, -2.33407915e-02f, 1.16580755e-01f, -1.21026114e-01f, -2.35395450e-02f,
  8.08022991e-02f, -9.17810760e-03f, -9.93679985e-02f, -4.15772870e-02f, -3.51393037e-02f, -4.60277312e-02f, 4.18005288e-02f, 5.02318442e-02f, -8.26341584e-02f, 1.18510857e-01f,
  7.19138607e-02f, 3.41897495e-02f, -8.27765092e-02f, 3.69391516e-02f, 5.23525178e-02f, 1.23487726e-01f, -1.84851531e-02f, 1.24481417e-01f, -3.47424299e-02f, -7.21268281e-02f,
  -7.23396987e-02f, -2.73805577e-02f, -1.92292687e-02f, -2.91710962e-02f, -3.92446481e-02f, 7.84018785e-02f, 5.30778766e-02f, -1.26997575e-01f, 2.38306317e-02f, 1.18138038e-01f,
  -1.18647739e-01f, 6.25253618e-02f, -1.13804027e-01f, 9.97646600e-02f, -1.13570355e-01f, 9.15596336e-02f, -2.18102392e-02f, 4.03927825e-02f, -1.41538277e-01f, 5.21200858e-02f,
  3.61780785e-02f, 7.00600445e-02f, 1.29831374e-01f, 1.63486972e-01f, 1.72004718e-02f, -1.93328619e-01f, 6.65321723e-02f, 5.00076078e-03f, -7.64678791e-03f, 9.43463668e-02f,
  7.35141784e-02f, 2.54823774e-01f, -1.06271282e-01f, 6.62526861e-02f, -3.83912101e-02f, -3.44277546e-02f, -6.90952316e-02f, -1.29071206e-01f, 5.74735999e-02f, 2.94416491e-02f,
  5.32571152e-02f, -1.74021497e-01f, 8.20226818e-02f, 2.72000004e-02f, -5.37943132e-02f, 1.03235215e-01f, 8.94882083e-02f, -2.27227304e-02f, 2.09302709e-01f, 1.25190288e-01f,
  -9.94811133e-02f, -1.34681493e-01f, 1.13822781e-01f, -1.74349884e-03f, 2.27897391e-02f, 1.01783946e-01f, 1.15380153e-01f, -8.73000026e-02f, 8.88794959e-02f, -6.67075217e-02f,
  2.24181950e-01f, 6.92733899e-02f, -2.42849104e-02f, 4.64619026e-02f, 2.34367023e-03f, -1.02221809e-01f, 1.37019977e-01f, 1.64383486e-01f, -8.03300962e-02f, -3.81027497e-02f,
  1.53509334e-01f, 1.99691311e-01f, -9.08548757e-02f, 1.30433589e-02f, -8.77590254e-02f, 9.87859592e-02f, -7.71562681e-02f, -3.31326388e-02f, 1.26994789e-01f, 6.81678811e-03f,
  5.71324602e-02f, -7.12569132e-02f, -4.80258558e-03f, 1.05902240e-01f, 1.01376750e-01f, 4.87293899e-02f, 1.40189126e-01f, 1.93334609e-01f, -6.37552291e-02f, -2.99266111e-02f,
  -3.65131609e-02f, 1.04258440e-01f, -5.33082150e-02f, 1.86596531e-02f, -7.79496282e-02f, 1.91057455e-02f, 1.64072350e-01f, 7.23453462e-02f, -1.57935083e-01f, -2.21200153e-01f,
  7.03504756e-02f, -1.41201302e-01f, -4.23887894e-02f, -1.50638402e-01f, 3.68798822e-02f, -1.60094112e-01f, 4.39918600e-02f, 2.15561385e-03f, -1.12734787e-01f, -1.19769350e-01f,
  7.95180630e-03f, 3.63423340e-02f, 7.28308931e-02f, 1.18392237e-01f, -9.37242061e-02f, -5.11603616e-02f, -6.12617545e-02f, 9.54592302e-02f, 1.66527301e-01f, 2.23284215e-02f,
  -9.89947692e-02f, 9.68746394e-02f, 6.31161481e-02f, 8.98368061e-02f, 1.64682582e-01f, 1.01573087e-01f, -8.80586132e-02f, -3.89156444e-03f, 2.47984938e-02f, 1.44294068e-01f,
  1.31856963e-01f, 8.85281041e-02f, -1.35620221e-01f, -4.83692475e-02f, -3.44268158e-02f, 2.06592709e-01f, 8.82130302e-03f, -8.44339002e-03f, 1.35938361e-01f, 1.80238128e-01f,
  1.27312824e-01f, 1.47028595e-01f, 1.69710830e-01f, -5.93152083e-02f, 1.86917577e-02f, -7.13062957e-02f, 1.50869787e-01f, 9.77912620e-02f, -1.61666214e-01f, 3.77306454e-02f,
  1.11062452e-01f, 1.59175247e-01f, -1.17969669e-01f, 7.38631636e-02f, 1.06709979e-01f, -1.82550587e-02f, 1.34839758e-01f, 1.22280918e-01f, -7.63282031e-02f, -1.12786375e-01f,
  -3.26164573e-01f, 7.40705952e-02f, -6.38842061e-02f, 6.40605167e-02f, -2.21332446e-01f, 9.35971066e-02f, -1.88880578e-01f, 1.27093829e-02f, 8.91888738e-02f, -1.22731917e-01f,
  1.06269168e-02f, 9.52660069e-02f, 1.15551941e-01f, 3.47537547e-01f, -1.50015891e-01f, 1.26115233e-01f, -1.63061798e-01f, 4.75373976e-02f, 2.52956033e-01f, 1.65776864e-01f,
  3.61779392e-01f, -8.84884447e-02f, -1.75021321e-01f, -9.15427282e-02f, -6.14761673e-02f, 1.85891852e-01f, 1.44297928e-01f, 1.53654397e-01f, -1.42285824e-02f, 7.97669813e-02f,
  1.64565220e-01f, 1.06113084e-01f, 1.47737898e-02f, -5.47512956e-02f, -1.26345694e-01f, 2.00478192e-02f, 4.16627824e-01f, 4.37449850e-03f, -1.66893870e-01f, -7.05834404e-02f,
  2.34373137e-02f, -1.23353437e-01f, -1.37107288e-02f, 9.81430113e-02f, 8.51127431e-02f, 1.48016334e-01f, -9.16385185e-03f, 1.17469333e-01f, -1.41823336e-01f, 1.92760065e-01f,
  7.89081007e-02f, 2.18343779e-01f, 1.93627685e-01f, 1.95843756e-01f, 9.47965607e-02f, -1.48502380e-01f, -4.66459338e-03f, 3.40204626e-01f, -3.00823152e-02f, 1.69786111e-01f,
  -1.25919646e-02f, 3.21784765e-02f, 9.28668305e-02f, -5.07053249e-02f, 3.67866755e-02f, 8.47733114e-03f, -6.79996088e-02f, -1.78318068e-01f, -8.56912434e-02f, 7.54646063e-02f,
  -1.66366398e-01f, 1.94327533e-01f, -4.21172008e-02f, 1.15518630e-01f, -9.99033153e-02f, 8.46687406e-02f, 5.15472591e-02f, 7.01493025e-02f, 6.25289511e-03f, -9.80973542e-02f,
  -1.95918590e-01f, 1.02463700e-02f, 9.16767344e-02f, 1.41833141e-01f, 1.05829656e-01f, -1.91263080e-01f, 7.59812146e-02f, 4.57156729e-03f, 8.77388269e-02f, 8.88395458e-02f,
  9.67876334e-03f, 2.17423588e-01f, -2.58758098e-01f, 1.67877138e-01f, 5.99956624e-02f, -4.08883207e-02f, 1.38315156e-01f, -1.50801972e-01f, -1.05470873e-01f, 2.35762931e-02f,
  2.28859127e-01f, 2.49215644e-02f, 1.60685889e-02f, -1.73801392e-01f, 9.91540179e-02f, -5.54670729e-02f, -3.69854160e-02f, 1.34733468e-01f, 1.60768002e-01f, -2.16581792e-01f,
  -1.16631836e-01f, 1.37770489e-01f, 8.24207440e-03f, 1.68187693e-01f, 6.24323599e-02f, -6.07546717e-02f, 7.91255326e-04f, 5.78824207e-02f, 9.67917684e-03f, -5.92377000e-02f,
  -4.79854271e-02f, -5.16976714e-02f, 1.02803119e-01f, -8.36427733e-02f, 1.20923586e-01f, -5.87242171e-02f, 2.61471979e-02f, 1.73676729e-01f, -4.28964198e-02f, 4.77806516e-02f,
  -5.88975176e-02f, -8.68957713e-02f, 9.23614297e-03f, -5.89310452e-02f, -1.37788743e-01f, 2.33696569e-02f, 2.36908104e-02f, 3.63667752e-03f, 4.17418107e-02f, 1.45262182e-01f,
  4.72757742e-02f, -1.37067884e-01f, -1.24325797e-01f, 3.67683452e-03f, 7.62243718e-02f, -2.87827421e-02f, 5.76630682e-02f, -1.16631418e-01f, -4.87270691e-02f, -7.51386210e-02f,
  7.46076405e-02f, -1.08024299e-01f, 1.91813502e-02f, -1.08192980e-01f, 1.55060478e-02f, -2.23592762e-02f, -7.96724632e-02f, 1.15148768e-01f, -4.73545827e-02f, -1.15734406e-01f,
  -5.09271808e-02f, -5.66711137e-03f, -5.02683632e-02f, 1.92583073e-02f, 1.02468848e-01f, -5.18566370e-02f, 1.22894026e-01f, 4.69369963e-02f, -2.65853703e-02f, 9.83760431e-02f,
  -1.01720855e-01f, 1.18240014e-01f, 9.77077410e-02f, 1.71228801e-03f, 2.12953910e-02f, 9.04278085e-02f, 1.05901830e-01f, 5.70126586e-02f, 1.01927379e-02f, -6.19607083e-02f,
  -1.11841425e-01f, 8.19947273e-02f, -7.64694437e-02f, -4.97450195e-02f, 3.42987701e-02f, -8.14654306e-03f, -9.51229781e-02f, 1.12918332e-01f, -1.53074125e-02f, -5.94579577e-02f,
  7.83246830e-02f, -1.24828324e-01f, -2.05106065e-02f, 1.49846524e-02f, -8.17743093e-02f, -8.69200900e-02f, -2.66174451e-02f, -6.96126446e-02f, 5.57738468e-02f, 3.35678011e-02f,
  -9.78103355e-02f, 7.49245435e-02f, 5.84324859e-02f, -9.07386914e-02f, 1.12017933e-02f, 7.28673935e-02f, 8.28228053e-03f, -1.39855295e-02f, -9.55599472e-02f, -4.39963751e-02f,
  -1.01727337e-01f, 3.12437341e-02f, -7.02231452e-02f, -1.08665332e-01f, -1.15061507e-01f, -9.69407987e-03f, -9.93968323e-02f, 5.43695576e-02f, -1.16970308e-01f, 3.87336724e-02f,
  -9.00238231e-02f, -5.49300872e-02f, -4.60773446e-02f, 1.07919969e-01f, 2.63542701e-02f, 1.22651849e-02f, 1.22216806e-01f, 6.09348295e-03f, -7.57097453e-02f, 1.22951992e-01f,
  -1.18140005e-01f, -1.03515022e-01f, -8.66838172e-02f, 1.23720437e-01f, 1.20820031e-01f, -7.96822309e-02f, 7.05139562e-02f, -1.15861326e-01f, 4.95475195e-02f, 4.43455428e-02f,
  1.60302885e-03f, -9.61349756e-02f, -7.65256733e-02f, 2.97490377e-02f, -1.15147889e-01f, -9.01795924e-02f, -1.25006601e-01f, -9.47009027e-02f, -9.15240198e-02f, 1.42155411e-02f,
  -1.11887790e-03f, 7.48648420e-02f, 4.33423370e-02f, 4.40659598e-02f, -2.35493705e-02f, -6.32558167e-02f, -3.07030845e-02f, -4.97914702e-02f, 9.03486237e-02f, 3.69018130e-02f,
  -5.82771823e-02f, -7.37487897e-02f, 7.13310018e-02f, 4.73710187e-02f, -1.05144367e-01f, -7.73223937e-02f, -6.53276145e-02f, -1.72710861e-03f, -6.35535493e-02f, -3.79891694e-02f,
  -6.80440143e-02f, -3.67604531e-02f, 1.06247611e-01f, 1.07601017e-01f, 2.38825642e-02f, 1.29530197e-02f, -2.00591478e-02f, -6.51048571e-02f, -7.79386237e-02f, 5.54372892e-02f,
  8.19397420e-02f, 8.68784040e-02f, -2.36246530e-02f, -9.30247530e-02f, 1.47656966e-02f, 4.72870655e-02f, -4.16330881e-02f, -4.85976003e-02f, 3.86348926e-02f, -6.12942874e-02f,
  4.60307598e-02f, -6.99283555e-02f, 5.05092330e-02f, -1.23900414e-01f, -1.11730069e-01f, -1.11325465e-01f, -1.24507301e-01f, -1.33559974e-02f, 1.10452443e-01f, -8.70340466e-02f,
  -8.70924965e-02f, -3.06689423e-02f, 4.43213843e-02f, 9.16477442e-02f, 3.57170291e-02f, -4.68510129e-02f, 1.45103365e-01f, 4.09075692e-02f, -6.26956373e-02f, 2.59732679e-02f,
  1.65647507e-01f, 2.22560167e-01f, 5.20645045e-02f, -8.27859268e-02f, 3.68031673e-02f, 5.42363487e-02f, 1.94922343e-01f, 5.20318374e-02f, 1.41494935e-02f, 2.30543599e-01f,
  8.63053352e-02f, 4.34355550e-02f, -1.70584098e-02f, -5.13260923e-02f, 1.45465061e-01f, -2.38453984e-01f, 1.08737931e-01f, -2.48184707e-02f, 1.80179067e-02f, 2.85329912e-02f,
  -1.50236517e-01f, -1.62749644e-02f, 3.86984795e-02f, 1.15497589e-01f, 1.80800244e-01f, 1.04539409e-01f, -9.23487991e-02f, 9.29216817e-02f, -1.57359034e-01f, -8.11999142e-02f,
  1.10416591e-01f, 5.27102798e-02f, 1.82867378e-01f, -9.48066190e-02f, -1.10107049e-01f, 1.95864066e-02f, 1.39063314e-01f, -7.94726387e-02f, 3.79174389e-02f, -1.78925656e-02f,
  3.59211266e-02f, -1.34520262e-01f, -6.00578189e-02f, 9.17202905e-02f, 9.76213887e-02f, -2.83285081e-02f, -8.35014284e-02f, -3.28168869e-02f, 1.79130435e-01f, 2.32101381e-01f,
  -7.93812722e-02f, -2.70279795e-02f, 6.75351918e-02f, 6.74341172e-02f, -4.23381366e-02f, 1.72853604e-01f, 1.30861014e-01f, -1.41941503e-01f, 8.04535225e-02f, -1.66327432e-01f,
  -1.20883085e-01f, -4.44519222e-02f, -3.57859172e-02f, 1.64202712e-02f, -6.69751167e-02f, 8.97306278e-02f, -7.14880601e-02f, 2.60793865e-02f, -6.42328337e-02f, -1.10973924e-01f,
  -6.33615479e-02f, -9.29593369e-02f, -5.79517893e-02f, 7.35800341e-02f, 3.90139781e-02f, -1.49905710e-02f, 1.48832118e-02f, -1.17754430e-01f, -4.90443930e-02f, 6.12558424e-02f,
  -2.04533562e-02f, -8.76198187e-02f, -5.61609529e-02f, 6.48568496e-02f, -2.58607697e-02f, 2.15254813e-01f, 4.17702980e-02f, 6.55668182e-03f, 7.01319277e-02f, -6.60679564e-02f,
  -9.44331288e-02f, 6.45997077e-02f, 1.67635441e-01f, 2.79049668e-02f, -6.92323297e-02f, -4.92745452e-02f, 9.79774669e-02f, 1.22205801e-01f, 4.62253205e-02f, -2.29744222e-02f,
  9.23907757e-02f, 1.00832656e-01f, -3.64024937e-02f, 1.05375394e-01f, 2.72370894e-02f, -9.24787484e-03f, -7.96099287e-03f, -4.75854799e-02f, 8.51741806e-02f, 1.12347826e-01f,
  9.80650410e-02f, 7.12176636e-02f, -8.34277179e-03f, -4.05475684e-02f, 3.27757150e-02f, -5.21446839e-02f, -5.51206805e-02f, -1.56605035e-01f, -4.47619818e-02f, -7.95099959e-02f,
  -8.84283110e-02f, 9.66394320e-02f, 1.39511541e-01f, -3.31801213e-02f, 5.80384769e-02f, -4.18050252e-02f, -9.80893672e-02f, -4.71557677e-02f, 6.23522140e-02f, -5.48556410e-02f,
  -3.43393907e-02f, 5.23736328e-02f, 2.14822721e-02f, -3.19328229e-03f, -1.01012826e-01f, -9.37835872e-03f, -1.56281907e-02f, 6.86015412e-02f, -8.21760297e-03f, -3.31749842e-02f,
  -8.40433314e-02f, 1.48746828e-02f, 9.73038003e-03f, 6.07945248e-02f, -7.08300471e-02f, -1.49596304e-01f, 2.27863099e-02f, 7.91645348e-02f, 4.62405309e-02f, 1.73294768e-01f,
  -4.53389175e-02f, 4.31823991e-02f, 8.89300928e-02f, -7.27641284e-02f, -8.32209662e-02f, -5.99486530e-02f, 2.16806754e-02f, -1.10874489e-01f, 5.76285943e-02f, -1.04433790e-01f,
  2.23640669e-02f, 2.79721040e-02f, -9.94964838e-02f, -2.41625570e-02f, -1.01652093e-01f, 1.10050544e-01f, 5.07416986e-02f, 7.67445713e-02f, 5.52472472e-02f, -3.67372632e-02f,
  -1.43669900e-02f, 7.93862864e-02f, -1.08789997e-02f, 5.91172725e-02f, 1.33415923e-01f, 4.07331027e-02f, -5.32521978e-02f, 1.17672943e-01f, -1.00394778e-01f, -1.01664420e-02f,
  -1.04434863e-01f, 1.42650574e-01f, -1.03260711e-01f, -7.35990256e-02f, -5.55481482e-03f, 1.39058633e-02f, -1.08427502e-01f, -1.97279938e-02f, -1.77118570e-01f, 1.01272799e-01f,
  2.34708395e-02f, 7.78420791e-02f, 9.65026692e-02f, -2.33707130e-02f, -8.69097114e-02f, -7.87600353e-02f, 1.47172555e-01f, 1.14456847e-01f, 4.64925393e-02f, 1.09679036e-01f,
  -1.78852677e-03f, 1.33488685e-01f, 7.47533813e-02f, 1.29735738e-01f, -1.07540786e-01f, 6.92427298e-03f, -3.53276208e-02f, -1.56644762e-01f, 2.51670089e-02f, -1.10106125e-01f,
  2.93005048e-03f, 4.48501222e-02f, 7.79322386e-02f, 1.88119531e-01f, 1.37216106e-01f, 6.97677135e-02f, -1.37829810e-01f, -3.46333012e-02f, 6.32941946e-02f, -2.72192690e-03f,
  1.61508158e-01f, 1.23620704e-01f, 1.93139110e-02f, -3.00869253e-03f, -3.98152769e-02f, -1.15266167e-01f, 5.06072901e-02f, -8.50756839e-02f, 1.25731692e-01f, 8.13382044e-02f,
  -1.06623612e-01f, -5.70832789e-02f, -4.69778478e-02f, 1.12229541e-01f, -1.85507517e-02f, -1.30478084e-01f, 8.21320191e-02f, 5.11355810e-02f, 2.97644455e-03f, 7.72529468e-02f,
  4.90261242e-02f, -5.85379824e-02f, -6.61088526e-02f, -2.16506459e-02f, 7.73669332e-02f, -6.70969188e-02f, -1.24106836e-02f, -1.26491040e-02f, 6.51915595e-02f, 1.07058272e-01f,
  -3.70956734e-02f, 7.02692196e-02f, -1.72219127e-02f, 2.62808166e-02f, 9.23852436e-03f, 8.05575121e-03f, 4.72306758e-02f, -6.47527128e-02f, 3.38766165e-02f, 1.39282957e-01f,
  1.27958521e-01f, -4.12088633e-02f, 1.22536160e-02f, -3.59852836e-02f, 3.95818241e-02f, -1.43537790e-01f, -4.65352237e-02f, 4.08686958e-02f, -2.42654271e-02f, 8.30967203e-02f,
  -8.52484554e-02f, 1.23340331e-01f, -5.34978285e-02f, 5.22706471e-02f, 6.79640472e-03f, 7.63239563e-02f, -2.11471394e-02f, -3.59441107e-03f, -6.73839822e-02f, -6.57193735e-02f,
  7.02814907e-02f, -6.08408563e-02f, 4.29573357e-02f, 4.35643904e-02f, -4.79466133e-02f, -9.19380859e-02f, -2.89558843e-02f, -1.22812077e-01f, -5.65920807e-02f, 7.49903545e-02f,
  -3.34657989e-02f, -3.42797786e-02f, -1.75088197e-02f, 5.06993942e-02f, -2.42920369e-02f, 3.55090350e-02f, 1.45478159e-01f, -3.78526635e-02f, 5.00632524e-02f, -2.30174549e-02f,
  6.17762469e-02f, -1.01625375e-01f, 4.54436243e-02f, -3.54775116e-02f, -1.13058023e-01f, 6.16055243e-02f, -8.83689746e-02f, 5.91892973e-02f, 1.01620823e-01f, -9.92690325e-02f,
  -2.77159549e-02f, -5.94302192e-02f, -1.10060342e-01f, 1.25180349e-01f, 1.05058469e-01f, 1.18175790e-01f, 1.93515867e-01f, 1.44220382e-01f, 1.81800246e-01f, 1.17651969e-01f,
  1.40119538e-01f, 1.54292896e-01f, 2.29117405e-02f, 4.36411649e-02f, 4.58529592e-02f, -3.76682030e-03f, -4.61306609e-02f, 1.30199581e-01f, 6.04969449e-02f, -1.32600456e-01f,
  6.12922683e-02f, -1.10787228e-01f, -1.50559954e-02f, -2.10104901e-02f, -9.64218900e-02f, 5.60288364e-03f, 3.06283999e-02f, 4.93624173e-02f, 5.96024022e-02f, -1.94093939e-02f,
  -2.96362732e-02f, 1.96196381e-02f, -1.22324191e-01f, 9.26252231e-02f, 9.42368135e-02f, -8.74357997e-04f, -1.84383184e-01f, -2.80661546e-02f, -2.30723955e-02f, -1.17127232e-01f,
  2.06093695e-02f, -9.03541669e-02f, -1.17303841e-02f, -5.79147711e-02f, 5.20704091e-02f, 1.18217282e-01f, 2.05934525e-01f, 4.95839566e-02f, -1.13227934e-01f, 3.22249569e-02f,
  1.45490155e-01f, -3.86044197e-02f, -9.19701159e-02f, 7.48286843e-02f, 1.09794252e-01f, 2.64796745e-02f, 2.03182325e-01f, 5.88589311e-02f, 4.97954637e-02f, 2.44649068e-01f,
  -1.14767306e-01f, 2.78232154e-02f, 1.82837859e-01f, 2.03873932e-01f, -6.07487448e-02f, 9.83502343e-02f, -5.32291979e-02f, 2.23457720e-02f, -2.84051094e-02f, -6.47648722e-02f,
  1.09517999e-01f, 1.98082328e-02f, 2.10886106e-01f, 3.91614363e-02f, -4.15812843e-02f, 1.72381222e-01f, 1.37149155e-01f, 1.92504346e-01f, -7.98303038e-02f, 1.44955561e-01f,
  -1.56145439e-01f, 1.26863226e-01f, -5.46046533e-02f, -3.10633600e-01f, -1.99817330e-01f, -3.68593857e-02f, 1.76888138e-01f, -7.53436163e-02f, -4.86806454e-03f, 2.01448008e-01f,
  1.27744377e-01f, 3.10415532e-02f, -9.71792359e-03f, 1.49507280e-02f, -9.57921089e-04f, -9.65549424e-03f, 6.77201003e-02f, 1.47986591e-01f, -2.60626357e-02f, -4.11531217e-02f,
  5.54616703e-03f, -6.37336224e-02f, 2.61177272e-02f, 1.41781241e-01f, 1.03463568e-01f, -6.61700517e-02f, -2.10692242e-01f, -4.24760915e-02f, -1.09038018e-01f, -9.49771516e-03f,
  -5.07351607e-02f, 1.84247196e-01f, 8.23325366e-02f, 3.10020000e-02f, 1.35626107e-01f, 9.16700587e-02f, 1.03969581e-01f, 4.09540609e-02f, -1.22875655e-02f, -1.19540393e-01f,
  2.25504428e-01f, -1.04500420e-01f, 3.34434696e-02f, -1.97483432e-02f, -2.14890447e-02f, -1.09706633e-01f, 1.69528753e-01f, 5.69977351e-02f, -1.21598497e-01f, 2.41035204e-02f,
  4.61025760e-02f, 3.35251726e-02f, -1.37223333e-01f, 1.76416725e-01f, 2.18667895e-01f, 1.57287315e-01f, 2.31889293e-01f, 1.29031628e-01f, 1.92583725e-01f, 2.98897140e-02f,
  2.14006931e-01f, 1.89657539e-01f, -3.74099053e-02f, 2.34895989e-01f, -3.69573459e-02f, -2.92699542e-02f, -9.59510356e-03f, -2.33637750e-01f, 1.52384952e-01f, -1.17216319e-01f,
  -7.30741173e-02f, -1.18752509e-01f, 3.07088166e-01f, 1.48029670e-01f, 1.11869693e-01f, -2.65117474e-02f, 9.72071365e-02f, 1.01196162e-01f, 2.10716665e-01f, 1.08869769e-01f,
  8.47435817e-02f, 3.55853401e-02f, -4.24816795e-02f, 5.64940572e-02f, 1.98200449e-01f, -5.82275763e-02f, -1.06248662e-01f, 8.06106851e-02f, -2.10483432e-01f, -1.52626321e-01f,
  1.51150957e-01f, 1.41258771e-02f, -1.30230844e-01f, 1.84336212e-02f, -8.12567919e-02f, -2.68245605e-03f, 6.99187070e-02f, 1.42238081e-01f, -3.42993177e-02f, -2.62935787e-01f,
  2.41627023e-01f, 2.20080510e-01f, 1.53720900e-01f, 4.29137573e-02f, -1.36359125e-01f, 3.47616859e-02f, 1.04725257e-01f, -1.35985345e-01f, 2.23302796e-01f, -4.13217023e-02f,
  4.92470851e-03f, -6.12397045e-02f, -7.98951238e-02f, 6.00280352e-02f, 4.59313020e-02f, 2.79210925e-01f, -7.90487826e-02f, 9.93636474e-02f, 1.68631479e-01f, -7.05974102e-02f,
  2.22858936e-02f, 4.79420535e-02f, 1.06376961e-01f, -2.55833529e-02f, -2.75850333e-02f, -1.08642057e-01f, 8.39324668e-02f, 1.25305116e-01f, -7.22424686e-02f, 1.62537739e-01f,
  1.43857775e-02f, -1.91375520e-02f, 1.06574856e-01f, -9.45011079e-02f, -1.23491347e-01f, 1.09213941e-01f, -6.04006238e-02f, -1.50363808e-02f, -9.64884704e-04f, -9.76581126e-02f,
  -1.23297870e-02f, 1.75226286e-01f, -7.59164393e-02f, -3.76319326e-02f, 6.58885986e-02f, -1.45189777e-01f, 4.76631746e-02f, 1.61744598e-02f, -4.39788681e-03f, 1.39122918e-01f,
  -1.03798592e-02f, -8.85935575e-02f, -8.73634294e-02f, 1.02124713e-01f, 1.20940439e-01f, 9.61469933e-02f, 6.38640001e-02f, -4.53943051e-02f, -2.34316383e-03f, 3.92952003e-02f,
  5.05719446e-02f, 9.65493452e-03f, -7.95990042e-03f, -2.37944406e-02f, -1.16074570e-01f, -8.09097141e-02f, -5.20735271e-02f, 1.37626410e-01f, -1.43742979e-01f, -3.98912057e-02f,
  1.70625478e-01f, 6.48332164e-02f, -3.82551476e-02f, 1.38414383e-01f, 4.91993241e-02f, 1.76377073e-02f, -7.45143667e-02f, -9.97279435e-02f, 3.49192172e-02f, -1.03625722e-01f,
  -3.96202169e-02f, 5.68436310e-02f, 2.29976568e-02f, -8.87300745e-02f, -1.02974204e-02f, -7.91117176e-02f, -9.62668136e-02f, -4.53988351e-02f, 4.87851165e-02f, -1.13370113e-01f,
  -1.08887799e-01f, -1.73117255e-03f, -8.00398528e-04f, 3.22905369e-02f, -5.94502389e-02f, -8.96103829e-02f, -3.55774388e-02f, -1.16631515e-01f, -6.96218461e-02f, 8.16207007e-02f,
  2.93230973e-02f, 4.11395207e-02f, -5.53870313e-02f, 6.96604624e-02f, 1.13813676e-01f, 1.12905875e-01f, -8.43134299e-02f, -6.94958642e-02f, -1.07094474e-01f, -8.75070505e-03f,
  2.96507566e-03f, 7.13057518e-02f, -7.95018673e-02f, 1.05981782e-01f, -4.11177054e-02f, 4.18262975e-03f, -8.93758982e-02f, 7.77199641e-02f, 3.65951210e-02f, 1.97224952e-02f,
  5.22399954e-02f, -8.52544606e-03f, 3.25641483e-02f, -1.20157832e-02f, -9.74309295e-02f, 6.20737895e-02f, -2.66946368e-02f, 7.44800866e-02f, -1.06512748e-01f, 4.80994908e-03f,
  -6.19069673e-02f, -7.76092038e-02f, 2.79819295e-02f, -4.03025188e-02f, -3.70452851e-02f, -8.16655606e-02f, 9.75781828e-02f, 4.25588563e-02f, -2.74649588e-03f, -6.89104199e-02f,
  -1.63376443e-02f, 6.05496056e-02f, -4.25833687e-02f, 1.11903965e-01f, -2.43988335e-02f, -4.06089835e-02f, 1.30270988e-01f, 6.82154894e-02f, -1.47525460e-01f, -3.03559136e-02f,
  2.56363936e-02f, 8.97981226e-02f, -8.60548869e-04f, -1.36345834e-01f, 1.35775447e-01f, 1.08072549e-01f, 1.89862788e-01f, -3.24426405e-02f, -6.81621358e-02f, 1.03573196e-01f,
  -9.18111727e-02f, 7.10468665e-02f, -6.67740628e-02f, 1.83198735e-01f, -1.05300061e-01f, -8.56149718e-02f, -1.77953973e-01f, -1.28042802e-01f, 2.94425394e-02f, 8.18783045e-02f,
  -1.34327477e-02f, -5.62041663e-02f, 9.24103186e-02f, 1.74117491e-01f, -2.43312377e-03f, 6.13093115e-02f, 8.34154934e-02f, -1.12813674e-01f, 2.08893195e-01f, 1.23063356e-01f,
  2.53437191e-01f, 2.56085359e-02f, -1.64845809e-01f, 4.71457802e-02f, -4.82983664e-02f, 7.04764351e-02f, -4.50994521e-02f, -7.62274191e-02f, 7.81254619e-02f, -1.48363337e-01f,
  1.07547961e-01f, 3.04142356e-01f, -1.18278161e-01f, -1.01455390e-01f, 9.74359661e-02f, 1.08683214e-01f, -5.19930460e-02f, -1.95027858e-01f, 6.11631200e-02f, -6.76125940e-03f,
  1.52737513e-01f, 1.11656636e-01f, -7.81066762e-03f, -1.45222351e-01f, -3.31683271e-02f, -6.30937633e-04f, 8.60864073e-02f, -8.55171829e-02f, 2.85663661e-02f, 1.25645339e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  2.75025726e-03f, -7.46845379e-02f, -9.47657898e-02f, -1.79785192e-02f, 1.18274271e-01f, 7.93771073e-02f, 1.61248930e-02f, -9.23483372e-02f, -3.54687311e-02f, -3.48570235e-02f,
  5.46546727e-02f, 6.43429086e-02f, 6.16824739e-02f, 1.57824665e-01f, 7.09885210e-02f, -3.73835489e-02f, 3.58641744e-02f, 1.93382055e-01f, 2.98079010e-02f, 1.24544486e-01f,
  3.85760553e-02f, 8.77482370e-02f, 1.22262258e-03f, 1.80186108e-01f, 1.16699539e-01f, 1.15975946e-01f, 8.60690847e-02f, -4.59700823e-02f, -1.24501862e-01f, 1.55808702e-01f,
  2.40410380e-02f, -1.55451775e-01f, 5.17861992e-02f, 6.82536736e-02f, 1.93882510e-01f, 2.31431760e-02f, 1.55979455e-01f, 1.82324275e-01f, 8.53452981e-02f, 1.70399711e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.17132083e-01f, -2.08002124e-02f, 7.74046406e-02f, -4.40563187e-02f, 1.48920089e-01f, 7.86152631e-02f, 1.89709216e-02f, -9.55495983e-02f, -1.05942879e-02f, -1.11997753e-01f,
  9.97351184e-02f, 6.28873054e-03f, 8.12732950e-02f, -4.26697917e-02f, 1.54968247e-01f, -1.20597757e-01f, -1.43155698e-02f, 1.41502842e-01f, 3.05702575e-02f, 8.49121064e-02f,
  2.85729151e-02f, 9.03000236e-02f, -4.79952403e-04f, 1.17793433e-01f, 5.55456616e-02f, -9.51141641e-02f, -1.22322626e-01f, 2.72829961e-02f, 5.94257414e-02f, -1.49528891e-01f,
  -4.13950682e-02f, 2.37747207e-02f, -3.37553360e-02f, -5.00424393e-02f, 1.02212792e-02f, -8.94513503e-02f, -3.18748802e-02f, 1.70838431e-01f, -1.42853186e-01f, -3.33792455e-02f,
  -1.01476014e-01f, -1.28045350e-01f, -1.03773605e-02f, -1.22968573e-02f, -5.27481660e-02f, 3.11427284e-02f, 2.06939764e-02f, 9.27738175e-02f, -9.49230194e-02f, 4.43612188e-02f,
  1.30570829e-01f, 1.16298467e-01f, -1.55053847e-02f, 1.26131818e-01f, 7.69511908e-02f, -4.10591178e-02f, 9.31969583e-02f, 1.04202770e-01f, -2.47217692e-03f, -8.19084048e-02f,
  -1.36154070e-01f, 7.94935003e-02f, 1.16976134e-01f, 1.89511880e-01f, -1.19759694e-01f, -1.10267192e-01f, -1.26762420e-01f, -3.71829867e-02f, 6.47869781e-02f, -7.69920796e-02f,
  -1.23330891e-01f, 1.10155419e-02f, 8.51949677e-02f, 6.10192344e-02f, 2.21606027e-02f, -8.27821624e-03f, -2.08654311e-02f, -1.94184497e-01f, 5.42690679e-02f, -6.80920780e-02f,
  -2.29510162e-02f, -1.21274784e-01f, 1.60209283e-01f, -8.12205747e-02f, 1.17999325e-02f, 3.15172062e-03f, 9.31479260e-02f, 8.80697817e-02f, 5.77071263e-03f, 1.11426428e-01f,
  -2.82974150e-02f, 5.06977737e-02f, 1.08857259e-01f, 3.74318622e-02f, 1.06378287e-01f, 6.25056028e-03f, -1.85543329e-01f, 2.04250980e-02f, -2.61873417e-02f, -1.36720255e-01f,
  -5.43146133e-02f, 1.59438774e-01f, 1.20583750e-01f, 1.45996781e-02f, 8.16366747e-02f, -2.22010881e-01f, 8.04639608e-02f, 1.22280665e-01f, -1.00322224e-01f, -4.74191085e-02f,
  5.86098246e-02f, 5.98678812e-02f, 1.91262320e-01f, -1.13299079e-01f, -5.70127927e-02f, 9.72683802e-02f, -1.16245702e-01f, 6.26594722e-02f, -5.22113033e-02f, 1.58190042e-01f,
  4.77211438e-02f, -1.10638514e-02f, 7.72334933e-02f, -1.64344460e-01f, -1.94728315e-01f, -4.25702557e-02f, 7.71622062e-02f, 1.80994138e-01f, -1.82457134e-01f, 5.13693551e-03f,
  -3.92124616e-02f, -1.18610203e-01f, -7.88908452e-02f, 2.70581655e-02f, -1.72817141e-01f, -7.74012655e-02f, -9.71416384e-02f, 6.90932870e-02f, -9.67109054e-02f, 6.73039481e-02f,
  -9.98700317e-03f, -9.45738330e-02f, 1.47040799e-01f, -4.24879827e-02f, 7.38677308e-02f, -1.14647955e-01f, 3.17053981e-02f, -1.29025849e-03f, 1.05678521e-01f, 7.62501657e-02f,
  1.18604116e-01f, -6.86152130e-02f, 6.19544610e-02f, 1.67820215e-01f, -8.54526088e-02f, -2.28182524e-02f, -5.72168967e-03f, 1.08489439e-01f, 1.09155260e-01f, 1.12229899e-01f,
  -6.62634103e-03f, -3.18086036e-02f, -1.21188305e-01f, -8.39058980e-02f, 1.31693706e-01f, -7.79275596e-02f, 1.00873686e-01f, -6.32997602e-02f, -7.64227435e-02f, -9.43972543e-03f,
  -4.07273546e-02f, -1.15094572e-01f, -7.96179399e-02f, 1.05679989e-01f, 3.01320963e-02f, 9.98303816e-02f, 2.07417458e-01f, 3.02322730e-02f, -6.73347153e-04f, 7.24017322e-02f,
  -1.10365741e-01f, 7.43752420e-02f, -4.63324785e-02f, 1.10486433e-01f, 5.54911382e-02f, -1.02841713e-01f, 8.52127839e-03f, -1.08549573e-01f, -1.05771445e-01f, -2.37311944e-02f,
  3.09123695e-02f, -4.53073010e-02f, -6.42972365e-02f, 5.87354638e-02f, 1.26559228e-01f, -1.18392907e-01f, 9.21808258e-02f, 2.07803305e-02f, 4.20125201e-02f, -1.00510471e-01f,
  -1.32266700e-01f, -1.20798573e-01f, 1.25744551e-01f, -1.46519348e-01f, -1.65664285e-01f, 2.25822460e-02f, 8.06829482e-02f, -7.49738887e-02f, -1.41325956e-02f, -7.10607097e-02f,
  1.19142845e-01f, -1.55726478e-01f, 1.75291345e-01f, -7.17489868e-02f, -2.47371476e-02f, 8.67541973e-03f, 1.79290563e-01f, 2.35678121e-01f, -4.50753868e-02f, -1.50231510e-01f,
  -1.48864478e-01f, -4.25532460e-02f, 1.24260768e-01f, 1.94238916e-01f, 1.15743369e-01f, -6.14531673e-02f, 1.06659129e-01f, 1.18758217e-01f, 1.68942258e-01f, -1.39561087e-01f,
  -2.78662946e-02f, 9.36155617e-02f, -2.56855618e-02f, 5.19794226e-03f, -1.48566598e-02f, 4.62239049e-02f, -2.03206595e-02f, -6.91987872e-02f, -2.93357181e-03f, 2.51836210e-01f,
  3.38283181e-02f, -2.67370701e-01f, -9.46039930e-02f, -8.62053037e-02f, -9.09303576e-02f, 1.81494132e-01f, -9.88089070e-02f, 5.54057881e-02f, 4.18630615e-02f, -8.20075348e-02f,
  1.21904209e-01f, -5.48590831e-02f, 6.46621436e-02f, -5.37337083e-03f, 1.89143084e-02f, -8.46192464e-02f, -4.01609354e-02f, 1.27948552e-01f, -2.76755113e-02f, 4.14014794e-03f,
  1.39125675e-01f, 2.01803762e-02f, -1.01361066e-01f, -4.89862412e-02f, -2.01544911e-02f, 6.78522512e-02f, 8.22032467e-02f, 6.53327703e-02f, -4.41286080e-02f, -2.09910169e-01f,
  -5.76566719e-02f, -1.90685809e-01f, -2.08288491e-01f, -1.20256014e-01f, 1.20719440e-01f, -7.90289119e-02f, 8.95519629e-02f, 1.19900398e-01f, -5.49980216e-02f, 5.73512316e-02f,
  1.09686010e-01f, 1.71201721e-01f, 6.96501881e-02f, -7.97488391e-02f, 1.57274723e-01f, 1.90055799e-02f, 1.07833102e-01f, 6.11829981e-02f, -7.53964335e-02f, -1.21394351e-01f,
  -6.93990514e-02f, 4.90407981e-02f, 8.81742164e-02f, 2.18448639e-01f, -7.19776377e-02f, 6.70048743e-02f, -4.28778939e-02f, 7.40831494e-02f, -6.32576225e-03f, 1.83064595e-01f,
  8.98114368e-02f, 4.25344482e-02f, 1.55930594e-01f, 3.11361980e-02f, -1.91008687e-01f, -6.83750659e-02f, -1.31101355e-01f, -5.38009889e-02f, -9.59478915e-02f, 1.76529035e-01f,
  7.85048977e-02f, -9.70762223e-02f, -4.91578281e-02f, -4.88801077e-02f, 2.88530197e-02f, -1.24069430e-01f, -1.67889133e-01f, 2.05852054e-02f, -5.13098873e-02f, 8.68311971e-02f,
  -2.17781618e-01f, 3.37073170e-02f, 5.00672162e-02f, -6.81268647e-02f, 5.68880979e-03f, -5.38970493e-02f, 2.63636615e-02f, -1.22726388e-01f, -1.34123281e-01f, -1.26747504e-01f,
  -1.11311875e-01f, -5.36565389e-03f, 4.54264879e-03f, -2.74282172e-02f, -5.80619043e-03f, 2.35832334e-02f, 1.10685630e-02f, -2.06340555e-04f, -6.36400469e-03f, -9.72422026e-03f,
  -1.36215910e-01f, 1.24442019e-01f, 6.00001700e-02f, 5.36862761e-02f, -1.03877187e-01f, -8.78447518e-02f, 1.17791958e-01f, 2.56000072e-01f, 1.77337736e-01f, -5.15056364e-02f,
  3.75293791e-02f, -2.79953908e-02f, -1.22970380e-01f, 4.97225896e-02f, -6.44563884e-02f, -1.67529866e-01f, -1.34008840e-01f, 6.29786178e-02f, 1.38590217e-01f, 1.60196517e-02f,
  -2.22659707e-02f, -1.85681164e-01f, 4.08631936e-02f, -3.44165452e-02f, 2.87484825e-02f, -5.96976560e-03f, -3.71290334e-02f, -1.54376313e-01f, 2.63527453e-01f, 2.13948905e-01f,
  -2.01612636e-02f, 7.69360363e-02f, -9.20081809e-02f, 9.20299068e-02f, 3.50674801e-02f, -4.26992141e-02f, 5.51163740e-02f, -1.57076046e-02f, -1.03068545e-01f, 1.02950009e-02f,
  -3.09503883e-01f, -1.49672121e-01f, 5.93622141e-02f, 9.29997191e-02f, -7.79782981e-02f, -1.03948846e-01f, -5.97146302e-02f, 7.80014321e-02f, 7.99834952e-02f, -8.88459012e-02f,
  -8.39966536e-02f, -6.30048737e-02f, 1.11557171e-02f, -3.61962058e-02f, 1.27940759e-01f, 1.21384179e-02f, 1.01313852e-02f, 9.78898853e-02f, -5.32191694e-02f, 1.32507116e-01f,
  1.36254787e-01f, -6.74673095e-02f, 5.09797335e-02f, 8.66726413e-02f, -1.23065384e-02f, -1.27094612e-01f, -8.75612199e-02f, -1.46843806e-01f, -9.02441069e-02f, -1.92498356e-01f,
  -1.41659500e-02f, 3.30634899e-02f, -1.46651210e-03f, 4.64853644e-02f, 1.67016491e-01f, -1.33148864e-01f, 3.15706171e-02f, -7.30557814e-02f, -2.00752560e-02f, -7.12951049e-02f,
  -1.79079007e-02f, -1.60771847e-01f, 1.66028291e-01f, -1.50079995e-01f, -1.52777904e-03f, 5.18970601e-02f, -8.87251943e-02f, -1.59237504e-01f, 7.71295950e-02f, -3.51582980e-03f,
  -1.04996718e-01f, -1.25201762e-01f, 5.32425642e-02f, 1.61427394e-01f, 2.55909003e-02f, 2.35733241e-02f, -4.21157330e-02f, -8.30971375e-02f, 9.03290287e-02f, 1.13837749e-01f,
  7.54817948e-03f, 3.89050432e-02f, 1.02442436e-01f, 1.15702875e-01f, 4.92412820e-02f, 1.87077038e-02f, -5.05829155e-02f, -9.76425037e-02f, -1.91188080e-03f, 5.45974746e-02f,
  -6.05848059e-02f, -1.16392083e-01f, 4.91292961e-02f, -6.85956031e-02f, -5.21537438e-02f, -1.37683138e-01f, 2.16636271e-03f, -6.57739630e-03f, 2.00741049e-02f, 7.44512230e-02f,
  -2.88979858e-02f, 3.33596626e-03f, 9.16542038e-02f, 7.85041004e-02f, -3.01871933e-02f, -4.21160236e-02f, -4.35370812e-03f, 1.20967492e-01f, 6.53255079e-03f, -1.08225614e-01f,
  -3.11792027e-02f, 1.52331278e-01f, 1.03372604e-01f, -9.57839116e-02f, -8.07225239e-03f, -6.99988529e-02f, 8.74239504e-02f, 2.20526885e-02f, -1.35110751e-01f, 1.07547738e-01f,
  -1.40096590e-01f, 4.85241935e-02f, 3.35946232e-02f, -2.14552116e-02f, -5.23576047e-03f, 2.03729004e-01f, -1.98707799e-03f, 8.88198242e-02f, -4.81030308e-02f, -1.15604900e-01f,
  -3.03914677e-02f, -5.88101149e-02f, -1.25393301e-01f, -6.59584021e-03f, 1.41316205e-01f, -1.18313141e-01f, 2.23885670e-01f, -1.57356933e-01f, -3.77829559e-02f, 1.78295039e-02f,
  -1.15789704e-01f, 7.10979253e-02f, 1.48586065e-01f, -7.07743689e-02f, -8.90693441e-02f, -3.84009928e-02f, -1.38025075e-01f, 1.37085691e-01f, -6.42707422e-02f, -6.17005602e-02f,
  -8.69300887e-02f, 1.24235272e-01f, -1.60673007e-01f, 6.07747696e-02f, -7.32892845e-03f, 9.07571986e-02f, -1.68844184e-03f, -7.61514576e-03f, 4.17584889e-02f, -1.24475313e-03f,
  6.90172985e-02f, 6.49240464e-02f, -1.02896914e-01f, 9.60165709e-02f, 1.00750968e-01f, 1.87813610e-01f, -9.13721398e-02f, -4.17121593e-03f, 1.95486024e-01f, -5.09839244e-02f,
  -1.65759120e-02f, -1.29674338e-02f, -1.18206531e-01f, -7.85622920e-04f, 1.15814537e-01f, 7.78052839e-04f, -6.42925724e-02f, 3.13971862e-02f, 7.01597780e-02f, 1.42002910e-01f,
  -9.02645960e-02f, 1.46441817e-01f, 1.19584650e-01f, -1.14815637e-01f, 6.93142973e-03f, -7.93591142e-02f, 1.22640366e-02f, 7.81680569e-02f, -1.10102408e-01f, -9.59496126e-02f,
  2.44514406e-01f, -1.31805807e-01f, -1.27913028e-01f, -6.44039512e-02f, -3.31812724e-02f, -1.54753804e-01f, 1.24228530e-01f, 1.35635704e-01f, -1.10253662e-01f, 1.01470143e-01f,
  2.97417969e-01f, 1.92957759e-01f, -8.40535089e-02f, 9.91766080e-02f, -1.03157334e-01f, -1.72793239e-01f, 5.44113182e-02f, 4.31846716e-02f, 2.22430155e-02f, 1.09756522e-01f,
  1.24402866e-01f, 9.93299931e-02f, 1.23531468e-01f, -1.19252816e-01f, -3.40277404e-02f, -1.10670120e-01f, -7.54777193e-02f, 1.32725999e-01f, 1.20283023e-01f, -3.82987820e-02f,
  2.07063839e-01f, 6.93918988e-02f, -3.01595535e-02f, 1.50160834e-01f, 9.47211012e-02f, -7.68577121e-03f, -7.81997144e-02f, 3.53912041e-02f, 2.35665049e-02f, 3.10882106e-02f,
  9.54844728e-02f, 8.34765451e-05f, -2.45299079e-02f, -1.14748538e-01f, 2.75267325e-02f, 2.05194935e-01f, -1.59995735e-01f, -5.82959205e-02f, 9.61823687e-02f, 1.18292555e-01f,
  -1.17262140e-01f, 7.51278326e-02f, -1.22944728e-01f, -1.64402932e-01f, 2.05915570e-01f, 3.42845842e-02f, -9.50531960e-02f, -9.39223543e-02f, 6.58199610e-03f, -2.92772718e-04f,
  -1.20259345e-01f, -1.04419589e-01f, -1.04956262e-01f, 7.72455037e-02f, -2.10923254e-01f, 1.85515106e-01f, 1.36568755e-01f, 2.94867326e-02f, -1.09362893e-01f, 6.12997934e-02f,
  3.12222410e-02f, 5.51834423e-03f, 1.62209481e-01f, 2.89040996e-04f, -8.32979158e-02f, -1.83830500e-01f, -4.16601188e-02f, -1.15093425e-01f, -1.43617271e-02f, -7.25488588e-02f,
  -2.32737102e-02f, -1.14351280e-01f, -1.20853730e-01f, -7.53686903e-03f, -1.04906015e-01f, -1.74620822e-01f, -1.25164747e-01f, 9.08179581e-02f, -1.28351506e-02f, 8.03221092e-02f,
  -2.03625202e-01f, 6.49376912e-03f, -1.37361810e-01f, -3.60888205e-02f, -1.25091568e-01f, -6.10466003e-02f, 1.09467559e-01f, 1.53050125e-01f, -7.79615641e-02f, 6.45756200e-02f,
  -1.55565619e-01f, -2.67117508e-02f, 1.85562968e-01f, 1.53771982e-01f, 2.92630270e-02f, 1.21139549e-01f, 4.93922196e-02f, -1.11130297e-01f, -6.94633275e-02f, 2.16316313e-01f,
  -2.01950043e-01f, 1.20901465e-01f, 1.14648357e-01f, 3.13056223e-02f, 3.90120409e-02f, -1.66247740e-01f, -1.49051502e-01f, 7.99243525e-02f, -1.25920787e-01f, -7.69562423e-02f,
  -3.01877316e-02f, -4.28731367e-02f, -1.24483548e-01f, -8.65293145e-02f, 4.91492897e-02f, -6.34886548e-02f, 4.18609940e-03f, 3.25702801e-02f, 1.97159529e-01f, -2.86946483e-02f,
  1.02309175e-01f, 1.45241603e-01f, -1.30494088e-01f, -7.84753412e-02f, -1.98664628e-02f, 5.21426350e-02f, -7.22157508e-02f, -1.72404274e-01f, 2.62363553e-01f, 1.96098968e-01f,
  1.57347113e-01f, -6.21595159e-02f, -9.72602963e-02f, -1.94994763e-01f, 7.41371363e-02f, -2.70509217e-02f, 1.56735197e-01f, -5.74623495e-02f, -8.13438594e-02f, 1.44968271e-01f,
  1.17733754e-01f, -4.24290970e-02f, 1.98224909e-03f, 6.79285750e-02f, -1.43280208e-01f, -9.01978761e-02f, 6.33349940e-02f, -1.14336209e-02f, 3.24234851e-02f, -7.98573792e-02f,
  -7.41427690e-02f, 7.27171004e-02f, -5.18358126e-02f, -1.48745170e-02f, 5.78805730e-02f, 1.94625720e-01f, 1.86486617e-01f, -7.41624981e-02f, -2.27374528e-02f, -2.12822855e-02f,
  2.03118861e-01f, 1.48105904e-01f, -9.11908671e-02f, 1.52374581e-01f, -2.25910068e-01f, 1.07779108e-01f, 1.76427513e-01f, 9.09716040e-02f, -1.56511620e-01f, 8.26012194e-02f,
  1.58473365e-02f, 1.89973220e-01f, 6.14502877e-02f, -1.54974744e-01f, -2.08712995e-01f, -6.51078820e-02f, -8.60821530e-02f, 1.07706957e-01f, 9.69568118e-02f, 1.17179602e-01f,
  -2.76582073e-02f, 1.85725510e-01f, -4.08140570e-02f, 7.40834549e-02f, 6.39414927e-03f, -6.51553944e-02f, -1.40773863e-01f, 2.01853752e-01f, -7.20873773e-02f, 5.71552813e-02f,
  -1.60275877e-01f, -1.11954056e-01f, 1.81807309e-01f, 1.24285845e-02f, -8.90522636e-03f, -6.92253262e-02f, 2.32741442e-02f, 6.22934476e-02f, -1.00224866e-02f, 1.77484639e-02f,
  7.68036470e-02f, 1.19171277e-01f, -1.23747684e-01f, -4.01865877e-02f, -5.25246002e-02f, -1.68642730e-01f, -3.32231782e-02f, 1.02646433e-01f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -5.77596575e-02f, 7.56169856e-02f, 4.41015810e-02f, 1.89232916e-01f, 1.86993286e-01f, 1.32297114e-01f, 7.26807639e-02f, 1.39621437e-01f, 7.80034438e-02f, 1.84448853e-01f,
  5.20465076e-02f, 6.63080588e-02f, -8.27253703e-03f, -1.94239676e-01f, 1.71679825e-01f, -5.23242950e-02f, -1.57908931e-01f, -7.02717975e-02f, -5.67172514e-03f, 6.70592636e-02f,
  -7.80869499e-02f, -1.22497253e-01f, -1.53429702e-01f, 1.37810990e-01f, 1.99120063e-02f, 1.51593894e-01f, 4.80832011e-02f, 5.57496063e-02f, 3.09494972e-01f, 6.74821809e-02f,
  -9.22330916e-02f, 7.87597895e-02f, -2.28135716e-02f, -8.42182040e-02f, -1.11026779e-01f, 6.93160444e-02f, -1.11406762e-03f, 3.34291905e-01f, -5.96217625e-02f, 1.71413243e-01f,
  9.71265659e-02f, -1.87045112e-01f, -9.73158851e-02f, 1.64328322e-01f, 4.96473126e-02f, -3.38920876e-02f, 8.30019414e-02f, 1.99861750e-02f, 6.20112568e-02f, 6.66592047e-02f,
  2.55956734e-03f, -1.19854875e-01f, 2.64929049e-02f, 9.06120017e-02f, -3.31596509e-02f, 6.20829388e-02f, 1.58489376e-01f, -7.31737539e-02f, -1.16347291e-01f, -2.00309336e-01f,
  -1.78091973e-01f, 9.86222103e-02f, -8.47986490e-02f, 1.80748731e-01f, 1.50631413e-01f, -4.68067564e-02f, 4.66199070e-02f, 8.63391906e-02f, 1.61871746e-01f, -7.32906312e-02f,
  -7.14037195e-02f, 5.77250347e-02f, -4.79368726e-03f, 1.15815572e-01f, -8.56950507e-02f, -2.35162247e-02f, 3.22811119e-02f, 5.50499931e-02f, -1.23788327e-01f, 5.96988946e-02f,
  -7.25319907e-02f, -9.87629518e-02f, 1.19854830e-01f, 4.80763934e-04f, 4.11175340e-02f, -9.77988020e-02f, 3.55701782e-02f, -1.26718953e-01f, 8.12688693e-02f, -1.24268688e-01f,
  1.25628337e-01f, 7.58676305e-02f, 4.74607543e-04f, -6.10958561e-02f, 7.78667405e-02f, -6.24845326e-02f, -1.29916102e-01f, 5.22271905e-04f, -6.57019243e-02f, -5.02332300e-02f,
  -7.83152133e-02f, 5.84896803e-02f, 1.22492678e-01f, 1.16407402e-01f, 7.47748390e-02f, -6.35607243e-02f, -9.05537605e-02f, 5.10280067e-03f, -7.98132420e-02f, -2.01070588e-02f,
  1.12926930e-01f, 1.35960519e-01f, -6.95765838e-02f, 6.70976639e-02f, 1.09715633e-01f, 8.26352686e-02f, -6.01918027e-02f, -8.27247947e-02f, -1.95782399e-03f, -2.71786898e-02f,
  -4.54269685e-02f, -5.54065928e-02f, -2.82254107e-02f, -6.70876261e-03f, -5.03425822e-02f, 1.32617369e-01f, 3.08164191e-02f, 1.13316052e-01f, -4.74687219e-02f, 6.88956231e-02f,
  6.84403032e-02f, 1.07278094e-01f, -1.10105120e-01f, -1.22989841e-01f, -5.90455346e-02f, -2.85819685e-03f, 2.45457515e-02f, -1.02940783e-01f, -1.13251656e-01f, 6.20800704e-02f,
  4.36317287e-02f, -6.27092645e-02f, 9.53461975e-02f, 1.14290610e-01f, 1.11258201e-01f, -1.70541811e-04f, 5.73502928e-02f, -6.38984144e-02f, -3.70511482e-03f, 3.98483388e-02f,
  -8.36614296e-02f, 1.62362354e-03f, 9.36571043e-03f, 1.87773667e-02f, 1.80019252e-02f, 1.10545509e-01f, 7.92615488e-02f, 6.77024797e-02f, -8.62818584e-02f, 1.07511275e-01f,
  1.02299890e-02f, 1.10664077e-01f, 3.38848457e-02f, 8.83395746e-02f, 7.39230737e-02f, 4.54056114e-02f, -9.12795365e-02f, -1.22274615e-01f, -5.83677217e-02f, -1.00421600e-01f,
  -8.31324980e-02f, 9.11089256e-02f, -1.00341417e-01f, -5.98777644e-02f, -4.24112231e-02f, -5.88473268e-02f, -5.91642000e-02f, -9.27046761e-02f, 8.56833681e-02f, 1.19210519e-01f,
  -5.51387260e-04f, -1.11707970e-01f, -9.54802334e-02f, 1.19053587e-01f, -3.92175019e-02f, -5.11955544e-02f, -1.02829754e-01f, 1.07057638e-01f, 6.03564940e-02f, 3.10311355e-02f,
  -1.21712558e-01f, 1.53490563e-03f, 1.78840920e-01f, -1.55969337e-02f, 1.56153217e-01f, 9.64612588e-02f, -6.37264401e-02f, -6.28781170e-02f, -6.67663664e-02f, 8.07529837e-02f,
  1.60621166e-01f, -2.15814412e-02f, -5.33706546e-02f, 1.50204554e-01f, 1.15417466e-01f, 8.13986212e-02f, -1.84074473e-02f, 3.21183726e-02f, 1.09070137e-01f, -2.34541781e-02f,
  -3.75237539e-02f, -4.52665761e-02f, 2.01297440e-02f, 6.17931336e-02f, 6.91111833e-02f, 1.37125507e-01f, -7.37233534e-02f, -6.45299326e-04f, -8.73795599e-02f, -5.19009344e-02f,
  7.78651312e-02f, 6.67833388e-02f, -6.05109781e-02f, 4.96895723e-02f, 1.27413467e-01f, 5.38525023e-02f, 1.00612432e-01f, -2.46240292e-03f, 5.23241721e-02f, -6.46559224e-02f,
  -1.46477237e-01f, 2.14640349e-02f, -4.48885337e-02f, 1.93546891e-01f, -2.16815211e-02f, 4.83966805e-02f, -4.12486820e-03f, -8.73203427e-02f, -1.05473269e-02f, -7.72006065e-02f,
  1.00717433e-02f, 1.34625047e-01f, -1.35589596e-02f, 1.17951162e-01f, 3.93340625e-02f, -9.59428027e-02f, 9.55152046e-03f, 9.78492871e-02f, -1.19316624e-02f, 1.18649021e-01f,
  1.46497246e-02f, -8.33464861e-02f, 2.33299032e-01f, 1.26031950e-01f, -1.16701595e-01f, 6.14134455e-03f, 2.87657958e-02f, 2.14454249e-01f, 1.44858807e-01f, 1.85092509e-01f,
  2.82042176e-02f, 3.91780771e-02f, 3.37885357e-02f, 1.51601940e-01f, 8.18326995e-02f, -5.29046170e-03f, 8.36573355e-03f, -2.00116541e-03f, 5.06567471e-02f, -1.93423018e-01f,
  8.87182206e-02f, -1.27628744e-01f, -1.66400790e-01f, 2.84235440e-02f, -2.89814104e-03f, -2.09756777e-01f, 1.73468009e-01f, 5.80765232e-02f, -1.90675572e-01f, -1.23167664e-01f,
  -4.39273827e-02f, 2.71551073e-01f, 4.11003269e-03f, -2.20299847e-02f, 3.39305043e-01f, 1.97608545e-01f, 1.37225792e-01f, 2.16252473e-03f, -8.21808912e-03f, -8.59172121e-02f,
  8.17893818e-02f, 3.87979974e-03f, 5.13361171e-02f, 2.61424571e-01f, 6.62106797e-02f, 1.58211425e-01f, 4.46226150e-02f, -2.06869900e-01f, 3.63609195e-02f, 1.46010622e-01f,
  3.07907201e-02f, 8.45719427e-02f, 2.75140226e-01f, 2.24798396e-01f, -7.48440549e-02f, -1.41799614e-01f, 7.48873502e-02f, -4.00793441e-02f, -1.08657345e-01f, 3.47038925e-01f,
  1.38796583e-01f, 9.24110487e-02f, 1.89560112e-02f, -4.44108015e-03f, 1.84686139e-01f, -1.48042902e-01f, -1.86934873e-01f, 3.16086747e-02f, -1.19577833e-01f, 1.02256879e-01f,
  6.48417398e-02f, 1.25248417e-01f, 5.82231097e-02f, 4.81915250e-02f, 4.52361517e-02f, -6.58640042e-02f, 1.51739091e-01f, 1.43765230e-02f, 1.10679276e-01f, -9.55925286e-02f,
  1.23977982e-01f, 1.87891662e-01f, 1.22166626e-01f, -1.00445010e-01f, -1.39139351e-02f, 1.55823037e-01f, 1.99939925e-02f, -5.00217453e-02f, -1.75856780e-02f, -9.61908549e-02f,
  1.21259414e-01f, -1.06042951e-01f, -1.16710931e-01f, -7.25499243e-02f, -6.52298182e-02f, -1.68204725e-01f, -1.62021481e-02f, 9.00409818e-02f, 1.94725931e-01f, -8.68675485e-02f,
  -9.18899328e-02f, 1.87222548e-02f, -8.71129259e-02f, -8.36776495e-02f, -6.97427429e-03f, 7.17361569e-02f, -1.20691408e-03f, 1.08283415e-01f, -1.69569347e-02f, 3.91705856e-02f,
  4.49273400e-02f, -2.49512810e-02f, 3.66956741e-02f, 4.32743058e-02f, 7.93348402e-02f, -4.88785580e-02f, 7.62968324e-03f, -1.47409901e-01f, -8.38828459e-02f, 2.44646579e-01f,
  -2.39448249e-03f, -2.19042320e-02f, -9.78119597e-02f, 6.18172213e-02f, 7.70432055e-02f, 1.35351300e-01f, 1.39905438e-01f, -4.31873500e-02f, 3.63593884e-02f, -1.44783661e-01f,
  3.72969992e-02f, 1.47726730e-01f, 1.02835298e-02f, 7.17099905e-02f, 2.50428207e-02f, 2.16329560e-01f, 1.44344136e-01f, 1.44414499e-01f, 1.33358657e-01f, 6.99419379e-02f,
  9.36865732e-02f, 1.55742720e-01f, -6.63128262e-03f, 4.89274710e-02f, 1.17087834e-01f, 5.31004108e-02f, 2.42907658e-01f, 2.03528553e-02f, 1.14436209e-01f, -4.95539382e-02f,
  -1.88428611e-01f, -4.95308824e-02f, -1.51013255e-01f, 1.93436503e-01f, 2.83018351e-02f, -1.00204557e-01f, 2.06185654e-02f, -3.29362564e-02f, 4.38349098e-02f, 4.69403192e-02f,
  -7.91078880e-02f, -1.41287223e-01f, 1.42036751e-01f, -1.31529113e-02f, -9.32593867e-02f, -3.81079614e-02f, -1.37447491e-01f, -7.66242743e-02f, 2.64703277e-02f, -6.03059158e-02f,
  3.82311828e-02f, 2.71178186e-01f, -1.49677798e-01f, 2.48170093e-01f, 1.70830190e-01f, 5.80461994e-02f, -1.14832945e-01f, 2.63301283e-01f, 8.17290228e-03f, -4.40463005e-03f,
  2.06899270e-01f, 1.41411781e-01f, -3.63214314e-02f, -1.73257023e-01f, 2.75626089e-02f, 2.71873306e-02f, 1.41693857e-02f, -1.06598828e-02f, 1.07440077e-01f, -3.06656472e-02f,
  4.23252806e-02f, 1.16093129e-01f, -9.02163312e-02f, -1.10982016e-01f, -3.96312550e-02f, 3.09052654e-02f, 6.67030588e-02f, 1.84450462e-01f, -1.07273795e-01f, 5.20134196e-02f,
  -4.17312607e-02f, 8.12897012e-02f, 5.96984513e-02f, -3.67283039e-02f, 4.48312946e-02f, -2.15339707e-04f, 1.02021933e-01f, -1.50701031e-02f, 8.37553665e-02f, 8.77144486e-02f,
  -5.03493175e-02f, -1.49848029e-01f, 3.65196168e-02f, -1.17746040e-01f, -1.07008621e-01f, -2.84391642e-02f, 7.84816295e-02f, 6.95549250e-02f, 1.02796525e-01f, -2.38697454e-02f,
  2.42787562e-02f, -6.96563721e-02f, -1.45141575e-02f, -2.37241983e-02f, -5.71358986e-02f, -3.96557637e-02f, 1.41291574e-01f, -7.83083066e-02f, -2.72717252e-02f, -5.16543053e-02f,
  -1.28439859e-01f, 5.70230410e-02f, -2.34802533e-02f, -6.95668310e-02f, 9.72498581e-02f, 2.42261529e-01f, 1.73680261e-01f, 9.85874683e-02f, 1.19118251e-01f, -8.83836001e-02f,
  6.00381382e-02f, -2.91360598e-02f, -1.29928842e-01f, 8.95304680e-02f, 1.48339961e-02f, -1.10686697e-01f, 4.63520437e-02f, 1.20327100e-01f, 5.92739768e-02f, 5.87493405e-02f,
  2.34968867e-02f, 3.63231152e-02f, -6.22290112e-02f, 1.07847221e-01f, 1.00019522e-01f, 5.98273501e-02f, 1.28229916e-01f, -7.30294585e-02f, -2.43707389e-01f, -3.14074792e-02f,
  2.61476748e-02f, 1.82325363e-01f, -1.35283515e-01f, 5.66351488e-02f, 5.88556528e-02f, -7.02138897e-03f, 1.74624510e-02f, -1.12594470e-01f, 4.75053973e-02f, 6.84094056e-02f,
  -1.39624244e-02f, -5.30700795e-02f, 1.15748964e-01f, -9.67989787e-02f, -9.11625624e-02f, 8.70164707e-02f, -8.96464363e-02f, -6.52710870e-02f, -2.22624950e-02f, 3.99194956e-02f,
  -7.28285164e-02f, -2.00095717e-02f, -9.43320021e-02f, -1.08653210e-01f, -1.78536754e-02f, 8.79855081e-02f, -7.77160004e-02f, 3.73578817e-02f, 1.45155098e-03f, -7.76951388e-02f,
  -1.15092613e-01f, 7.39211440e-02f, 1.11048445e-01f, 2.50327773e-02f, -5.72269522e-02f, 1.04874186e-01f, -1.13874152e-02f, -1.11988850e-01f, -9.17177871e-02f, -8.09410438e-02f,
  -4.56098765e-02f, -3.20627391e-02f, 1.12149566e-01f, -5.73095691e-04f, -8.49528834e-02f, 3.99938077e-02f, 1.21884033e-01f, -1.61303338e-02f, 3.49620059e-02f, -1.32108271e-01f,
  1.14068575e-01f, 1.27711333e-02f, -6.13446422e-02f, -3.73632833e-02f, 7.50507042e-02f, -9.06922966e-02f, 1.19557746e-01f, -8.20798278e-02f, 1.16989836e-01f, -1.11184634e-01f,
  5.10119274e-02f, 1.40000433e-01f, -3.87951210e-02f, -1.04560152e-01f, 5.84767871e-02f, 1.30211085e-01f, -1.97693616e-01f, 7.15427175e-02f, -1.03934892e-01f, 1.26865655e-01f,
  8.83168504e-02f, -8.42612144e-03f, 1.95505284e-02f, -1.07266195e-01f, -1.22409351e-01f, 8.89697224e-02f, 4.06891201e-03f, -4.00588736e-02f, 1.55977950e-01f, -1.68370660e-02f,
  1.42152116e-01f, 4.20216508e-02f, -4.31402616e-04f, 9.25741270e-02f, -6.79528490e-02f, 2.24962413e-01f, -1.04529448e-01f, 3.14035192e-02f, 1.70918554e-01f, 2.04300240e-01f,
  9.94120389e-02f, 5.29959425e-03f, -6.63890794e-04f, 6.41157404e-02f, 3.13081771e-01f, 6.87457025e-02f, -1.07585266e-01f, 5.45313060e-02f, -9.72138196e-02f, -6.79296702e-02f,
  1.14661448e-01f, 2.62606051e-03f, -5.32195196e-02f, 4.26164448e-01f, 7.55825639e-02f, 1.22965336e-01f, 9.89134610e-02f, -6.93759322e-02f, -9.73113030e-02f, 1.95297509e-01f,
  -7.07832128e-02f, 8.83515030e-02f, 5.49151897e-02f, -1.26950011e-01f, 4.02804494e-01f, -6.22582361e-02f, -1.23797640e-01f, -8.18384811e-02f, -5.20185009e-02f, 6.18715324e-02f,
  -8.24054703e-02f, 6.76342845e-02f, 2.89436821e-02f, -5.94200343e-02f, 1.46939263e-01f, 1.10472843e-01f, -2.50117809e-01f, -6.33982196e-02f, 3.38253975e-02f, 3.12786072e-01f,
  -8.50407407e-02f, -1.02972165e-01f, 1.98375247e-02f, 3.41172926e-02f, 1.05031565e-01f, 1.18189827e-01f, -7.65852183e-02f, 1.17925897e-01f, -2.01974604e-02f, -1.09165059e-02f,
  -2.82079224e-02f, 1.21456608e-01f, -7.50882030e-02f, -1.48521187e-02f, -4.98370975e-02f, 9.21971500e-02f, -6.30658567e-02f, 8.87489393e-02f, 7.12231128e-03f, 1.82906650e-02f,
  -1.08090684e-01f, -6.82150796e-02f, 3.79046872e-02f, 5.10514826e-02f, -9.30630565e-02f, -1.21776000e-01f, -8.88891444e-02f, -1.04699120e-01f, -8.65486916e-03f, -8.05722103e-02f,
  4.13976945e-02f, -7.51658231e-02f, -5.70232980e-02f, 1.13043949e-01f, -5.57785146e-02f, 9.44557935e-02f, -7.98142180e-02f, -3.54173444e-02f, -7.87227452e-02f, 3.46436016e-02f,
  -6.53168708e-02f, -6.01313524e-02f, 1.00364208e-01f, -4.51443382e-02f, 6.59709610e-03f, -5.41356020e-02f, 3.02689131e-02f, -3.36341374e-02f, -7.93081522e-02f, -8.47705361e-03f,
  -3.50675397e-02f, -5.58206402e-02f, 7.40966350e-02f, -4.51903977e-02f, -8.09013769e-02f, -2.63508931e-02f, 3.55585925e-02f, 1.21181749e-01f, 5.35755903e-02f, -1.14994019e-01f,
  -9.73754078e-02f, -8.22594836e-02f, -1.98259316e-02f, -2.15669512e-03f, 4.01872657e-02f, 1.05262347e-01f, 2.12499365e-01f, 1.46155491e-01f, -8.96636918e-02f, 1.73090383e-01f,
  2.20190644e-01f, 4.04347405e-02f, 1.80819891e-02f, 9.20186788e-02f, 2.65176982e-01f, 3.37745412e-04f, 8.04168805e-02f, 8.14768448e-02f, -1.55523613e-01f, -1.06542923e-01f,
  3.14081520e-01f, 1.93333492e-01f, -1.35259777e-01f, 6.20615818e-02f, -6.95081428e-02f, -9.05614421e-02f, -2.47454159e-02f, -9.85421836e-02f, 3.36015858e-02f, -1.48673341e-01f,
  2.66575497e-02f, -8.83825570e-02f, -9.73428860e-02f, 1.60655100e-02f, -1.41268224e-02f, -5.79051599e-02f, 2.55250186e-01f, 5.51185124e-02f, -9.76860449e-02f, -2.13811696e-02f,
  4.02136967e-02f, -3.52232307e-02f, 2.07281381e-01f, -9.29408744e-02f, -1.39829218e-01f, 1.56547636e-01f, -9.95629095e-03f, -2.19278391e-02f, -4.86915447e-02f, 4.20813169e-03f,
  -1.66174203e-01f, 3.67698036e-02f, 4.52150069e-02f, 2.51790702e-01f, -1.57110304e-01f, 6.77217320e-02f, -4.96972315e-02f, 3.33610997e-02f, -1.64128751e-01f, 3.73905487e-02f,
  -1.34699315e-01f, 1.41824275e-01f, 2.09990829e-01f, 3.34180206e-01f, 3.25575203e-01f, -9.80772600e-02f, 1.38433110e-02f, -3.16084884e-02f, -1.94722220e-01f, 1.20146282e-01f,
  -2.58556027e-02f, 1.54222146e-01f, -1.89135615e-02f, 9.03436244e-02f, 7.42066652e-02f, 2.19526086e-02f, 1.08833037e-01f, 2.27046385e-01f, 2.14964971e-01f, 2.78129950e-02f,
  2.80833304e-01f, 7.34157488e-02f, 2.32392028e-01f, -9.03737098e-02f, 2.68740535e-01f, 2.16424569e-01f, -9.71510261e-02f, 3.77204657e-01f, -3.29460710e-01f, 1.98189601e-01f,
  1.78715870e-01f, 1.01583891e-01f, 7.52358958e-02f, 5.50265908e-02f, -2.87180319e-02f, 9.97361243e-02f, 1.35948554e-01f, -8.18305165e-02f, 2.83499509e-02f, -8.38379003e-03f,
  1.45705238e-01f, -4.45391983e-02f, 1.21295258e-01f, 4.01867367e-02f, -5.50076403e-02f, 4.43738043e-01f, -4.08493504e-02f, -3.84876840e-02f, 1.07744522e-01f, 1.30772078e-02f,
  -1.10351697e-01f, 1.66274831e-01f, 2.81545743e-02f, 2.50847656e-02f, 1.50778472e-01f, -6.11614734e-02f, 2.00470820e-01f, 1.08505122e-01f, -1.17782272e-01f, 7.37954816e-03f,
  6.81190565e-02f, -3.54002006e-02f, -1.44459412e-01f, 8.33417550e-02f, -3.62009667e-02f, -8.04075897e-02f, -9.41789374e-02f, 1.42171681e-01f, 1.67242587e-01f, 2.60997042e-02f,
  1.74649246e-02f, 2.08433688e-01f, -1.02027267e-01f, -8.62767547e-02f, -1.02269299e-01f, 3.91936041e-02f, 1.07209250e-01f, -3.06431819e-02f, 2.10124161e-02f, -1.00935094e-01f,
  5.15772190e-05f, 2.04482581e-02f, 4.74369004e-02f, -4.20911647e-02f, 2.70712748e-02f, -1.14697166e-01f, -7.82360956e-02f, 3.56324390e-02f, -7.56248906e-02f, 1.02230959e-01f,
  4.31550108e-02f, 8.95490199e-02f, 1.17639221e-01f, -4.62148804e-03f, 2.37962026e-02f, 1.11736409e-01f, -7.20580891e-02f, -1.12392366e-01f, 1.39926551e-02f, 1.02140456e-01f,
  -5.42983003e-02f, -8.65692347e-02f, -9.95506942e-02f, 1.25309169e-01f, -2.53093988e-02f, -2.78945081e-02f, 9.35893953e-02f, -6.43544942e-02f, 5.99105284e-02f, 7.89547786e-02f,
  -7.11298659e-02f, 3.00820358e-02f, -8.41010734e-02f, -7.52852261e-02f, 3.94482836e-02f, 2.70380322e-02f, -7.51638561e-02f, 5.35387965e-03f, -1.09032460e-01f, 1.07448295e-01f,
  -8.69612694e-02f, -4.55899164e-02f, 5.34415022e-02f, 6.85103238e-02f, -8.14667568e-02f, -8.24946463e-02f, 1.17955863e-01f, -4.63467166e-02f, 7.18183666e-02f, 7.63050988e-02f,
  6.07201681e-02f, 7.63790263e-03f, 8.48837048e-02f, -2.81308908e-02f, -7.65724555e-02f, -4.18769429e-03f, -8.03296342e-02f, 2.59626564e-02f, -3.83120514e-02f, 5.89041524e-02f,
  -7.11104274e-02f, 5.30633070e-02f, -9.27973688e-02f, -1.43891647e-01f, -1.70127481e-01f, 1.54833883e-01f, 1.71822354e-01f, -1.58113599e-01f, 1.95665032e-01f, -1.27696633e-01f,
  1.49786681e-01f, -9.20165181e-02f, 1.35534018e-01f, 1.33754700e-01f, 9.58472714e-02f, -3.81916598e-03f, -8.21934361e-03f, 1.63701460e-01f, 1.30714193e-01f, -2.87940893e-02f,
  1.43507183e-01f, 1.11883981e-02f, -1.12985214e-02f, 4.52890759e-03f, 3.26797217e-01f, 1.09218750e-02f, 5.99765331e-02f, 4.72250059e-02f, -5.61841875e-02f, -6.18829988e-02f,
  3.03226598e-02f, -9.52865928e-02f, -7.90676847e-02f, 4.46446240e-01f, 7.57779600e-03f, 8.92586168e-03f, -2.26258803e-02f, -1.95892006e-01f, -7.75589421e-02f, 2.20187411e-01f,
  7.59562943e-03f, -5.13152294e-02f, 5.59122674e-02f, 3.35515626e-02f, 2.83714026e-01f, -3.60740605e-03f, 4.12638076e-02f, 1.23449557e-01f, 3.08272522e-02f, 4.43478860e-02f,
  -1.32910952e-01f, 8.37155581e-02f, 2.24460233e-02f, -9.40414667e-02f, -5.22141010e-02f, 9.08404142e-02f, -2.19723493e-01f, 2.56735180e-03f, 1.68610103e-02f, 1.92545414e-01f,
  -1.12572759e-01f, -5.91387860e-02f, 7.50218630e-02f, -5.90977482e-02f, 2.52449345e-02f, -1.17240399e-01f, -1.15050383e-01f, -1.08336836e-01f, -6.04969598e-02f, -2.60047931e-02f,
  -5.12900911e-02f, 3.67385969e-02f, -8.52702856e-02f, -2.67946683e-02f, -6.22006087e-03f, -2.72150468e-02f, -1.19128145e-01f, 1.18436038e-01f, -1.27708018e-01f, 1.13025583e-01f,
  9.90335867e-02f, 5.67872822e-03f, -8.42247531e-02f, -1.00052372e-01f, -1.73838194e-02f, 5.88357598e-02f, 4.29704040e-02f, 1.15182981e-01f, 1.12533331e-01f, -2.37974748e-02f,
  -1.13849640e-01f, -4.56625670e-02f, 2.95101069e-02f, 8.39994997e-02f, 4.43778299e-02f, -1.14535667e-01f, 3.79386656e-02f, 8.17867517e-02f, 1.18676126e-01f, 3.18102129e-02f,
  -3.48079838e-02f, -1.08668864e-01f, -1.02930099e-01f, -6.08392730e-02f, 8.02330226e-02f, -5.89378886e-02f, -9.04923156e-02f, 9.74222571e-02f, -1.10729203e-01f, -9.62493941e-02f,
  8.67910311e-02f, -4.18485031e-02f, 1.31658297e-02f, 6.65161386e-03f, -8.50661024e-02f, 5.06038889e-02f, 9.50797424e-02f, -7.38675669e-02f, 1.14017524e-01f, 3.84719064e-03f,
  -3.43983136e-02f, -1.52083198e-02f, -9.76288244e-02f, -1.15361907e-01f, -8.13793316e-02f, 1.03254123e-02f, 1.45546883e-01f, 1.05010018e-01f, -1.92764372e-01f, 1.65027343e-02f,
  -8.76451731e-02f, 8.68509039e-02f, -7.14131221e-02f, -5.33258170e-02f, 1.94356143e-01f, -1.39660001e-01f, 8.25469643e-02f, 3.98651809e-02f, 3.52808721e-02f, 8.74440148e-02f,
  2.44693607e-01f, 2.06839353e-01f, -8.90893340e-02f, -7.70977885e-02f, 1.19433459e-02f, 1.44358248e-01f, 9.73357409e-02f, -7.47644305e-02f, 1.62270665e-01f, -5.03539890e-02f,
  1.02979438e-02f, 1.17843524e-01f, -3.97805832e-02f, 1.47990912e-01f, 1.86479136e-01f, -1.08286619e-01f, 2.26008952e-01f, -2.34605558e-02f, 9.74338427e-02f, -5.46327084e-02f,
  1.02347746e-01f, 1.25727460e-01f, 2.64538050e-01f, -1.39036208e-01f, -9.50140879e-02f, -5.70576601e-02f, -4.81756851e-02f, 5.83348759e-02f, 4.28680563e-03f, 1.15171194e-01f,
  -1.87516659e-01f, 8.49455148e-02f, 3.33380878e-01f, 1.97541952e-01f, -1.65888518e-02f, 3.34993489e-02f, 1.68283042e-02f, -1.33635640e-01f, 9.11101792e-03f, -5.38095506e-03f,
  -6.86070174e-02f, 8.93169343e-02f, 2.29748368e-01f, 3.07961345e-01f, 6.75171465e-02f, -8.64697769e-02f, 1.18612163e-01f, -1.67126227e-02f, -1.23770095e-01f, -5.90122677e-02f,
  -8.64129961e-02f, 8.26352984e-02f, -4.33457419e-02f, -9.20329019e-02f, 9.08606946e-02f, -9.14382711e-02f, 9.72087085e-02f, 7.43643418e-02f, -2.10297909e-02f, -7.87334815e-02f,
  -3.42350714e-02f, -9.13247094e-03f, 9.88988131e-02f, -1.77075788e-02f, -2.37758402e-02f, -2.72158328e-02f, -7.07290471e-02f, -9.02720764e-02f, -7.46323988e-02f, 1.39130861e-01f,
  1.10025518e-01f, 5.98366074e-02f, -4.62360829e-02f, 1.57857295e-02f, 4.43422161e-02f, -2.13155504e-02f, -4.95239571e-02f, -2.98622474e-02f, -3.06987725e-02f, 3.73637378e-02f,
  2.60290708e-02f, -1.01403788e-01f, 4.69273664e-02f, 6.12045228e-02f, -1.18857650e-02f, 3.21455635e-02f, 2.64678616e-02f, 8.89484286e-02f, -2.36154092e-03f, 1.08734198e-01f,
  -1.21623814e-01f, 8.03664103e-02f, 6.01737164e-02f, 1.16790019e-01f, -5.96366599e-02f, 1.15896918e-01f, 1.93011630e-02f, 3.61984484e-02f, -7.04110488e-02f, 1.07059747e-01f,
  1.04573496e-01f, 5.34182638e-02f, -1.78982522e-02f, -2.03077942e-02f, 9.00409818e-02f, 9.49190632e-02f, 3.45561020e-02f, 2.89211627e-02f, -5.85156493e-03f, -4.29210532e-03f,
  5.96930720e-02f, 2.44962033e-02f, 6.68986067e-02f, -7.22151846e-02f, 8.22483599e-02f, 6.13265447e-02f, -8.31079260e-02f, -3.06236967e-02f, -7.92066678e-02f, 2.55227350e-02f,
  9.74753872e-02f, 4.07089442e-02f, -9.64379534e-02f, 5.27598895e-02f, -3.37574398e-03f, 4.57994416e-02f, -9.28811654e-02f, 8.49728882e-02f, 1.18387535e-01f, -1.24401405e-01f,
  -9.19486582e-02f, -6.89187497e-02f, -1.10641561e-01f, -9.59424898e-02f, -1.00030960e-03f, 4.18423936e-02f, -2.02119555e-02f, 1.60172321e-02f, -8.97338465e-02f, 4.68342118e-02f,
  -2.60013081e-02f, 4.14954759e-02f, -5.83320297e-02f, -1.17128104e-01f, -8.13576803e-02f, -7.87411556e-02f, 4.45619412e-02f, -1.02322765e-01f, 1.06386632e-01f, -6.89128712e-02f,
  9.64869112e-02f, -5.45956306e-02f, -1.20623538e-03f, 2.98820771e-02f, -1.18039563e-01f, -2.76177917e-02f, 3.59617434e-02f, 3.60516794e-02f, -7.20537305e-02f, 2.44434066e-02f,
  -1.45725412e-02f, -9.73509811e-03f, -9.42881033e-02f, -2.52335574e-02f, -1.07621573e-01f, -7.98028484e-02f, -6.78815246e-02f, -8.83531421e-02f, 8.56295880e-03f, -1.18360020e-01f,
  -4.93985079e-02f, 5.79110719e-02f, 8.81604031e-02f, 5.50008714e-02f, 5.57344295e-02f, 9.74235535e-02f, 1.04038507e-01f, -7.53735453e-02f, 1.56822037e-02f, 6.81636902e-03f,
  8.09529871e-02f, -1.74591653e-02f, -8.98664519e-02f, -8.97304434e-03f, -5.90891875e-02f, -9.67127308e-02f, -3.63360681e-02f, -8.84727910e-02f, 4.80128592e-03f, 5.56435362e-02f,
  3.73917446e-02f, -9.32867974e-02f, 7.48275444e-02f, 3.03731263e-02f, -7.53211528e-02f, -4.16685157e-02f, 2.70066448e-02f, -2.06791703e-02f, -4.80495095e-02f, -6.81638792e-02f,
  -4.40091230e-02f, -1.33293673e-01f, 7.58354440e-02f, 1.12265982e-01f, 6.46582842e-02f, 1.32044435e-01f, -1.33059090e-02f, 1.09211326e-01f, -4.60571945e-02f, 4.32460159e-02f,
  1.10990688e-01f, -3.43707986e-02f, 6.36756569e-02f, 8.97847489e-02f, 5.58344880e-03f, 4.87249829e-02f, 8.68975371e-03f, -9.52612534e-02f, 7.53005296e-02f, 2.35322677e-02f,
  1.08805597e-01f, -6.85289428e-02f, -9.31134820e-02f, 1.49670783e-02f, -7.41351545e-02f, -3.94025967e-02f, -5.29009663e-03f, 9.43382159e-02f, -8.57780501e-02f, 4.48456965e-02f,
  7.08497241e-02f, 1.62871219e-02f, 8.11533257e-02f, -1.07390851e-01f, 7.41692185e-02f, -3.30820400e-03f, 9.51159149e-02f, -4.42947224e-02f, -6.98109120e-02f, 1.16594590e-01f,
  -1.81930572e-01f, -9.84788984e-02f, 3.49481553e-02f, 8.29362497e-02f, -3.88028771e-02f, -2.63751838e-02f, 1.30549490e-01f, -7.06630871e-02f, -9.20654181e-03f, -7.20754173e-03f,
  1.17835730e-01f, 2.11685300e-02f, 1.38398156e-01f, 1.81131631e-01f, -1.50072351e-01f, 8.29140991e-02f, 1.08525835e-01f, 9.47437808e-02f, 1.70344636e-01f, -1.04644530e-01f,
  3.02780885e-02f, -5.88345975e-02f, 4.92408406e-03f, 2.81569436e-02f, -9.01539698e-02f, -8.38212892e-02f, -5.88368513e-02f, 1.79264858e-01f, 1.35534227e-01f, 8.56056362e-02f,
  7.33881071e-02f, -6.34395629e-02f, -4.29795757e-02f, -2.69080382e-02f, -4.55156118e-02f, 3.06610763e-02f, -2.25247014e-02f, 1.01665579e-01f, 2.32757404e-01f, 4.70353290e-02f,
  1.17735388e-02f, -1.02945104e-01f, 1.10261805e-01f, 6.57510757e-03f, 6.19811900e-02f, -5.87540399e-03f, -1.10327512e-01f, -1.97605602e-02f, 2.39022762e-01f, 1.82622194e-01f,
  5.69888055e-02f, 1.07817523e-01f, 9.17305946e-02f, -1.24734484e-01f, 7.62250498e-02f, -7.37618133e-02f, 3.47022787e-02f, 2.58277766e-02f, 2.00512558e-01f, 4.59508831e-03f,
  -1.80608675e-01f, -1.05044879e-02f, -2.94071063e-02f, -7.67536759e-02f, 6.46409318e-02f, 3.55654173e-02f, 3.77102643e-02f, -5.55494195e-03f, 7.22718611e-02f, -7.58104175e-02f,
  -4.98138405e-02f, -8.28047022e-02f, -1.33770183e-01f, -1.28641725e-01f, -6.56474829e-02f, -4.50997241e-02f, -1.27862900e-01f, -1.43047005e-01f, -2.95024482e-03f, -8.46176669e-02f,
  -8.49262103e-02f, -3.82400118e-02f, 3.45618115e-04f, -9.15377811e-02f, 1.54935375e-01f, 4.74581607e-02f, -1.24221548e-01f, -1.65083945e-01f, 1.53518513e-01f, -6.86720014e-02f,
  -1.11857757e-01f, 2.18430251e-01f, 7.38694742e-02f, 1.78227037e-01f, 4.13404219e-02f, 9.93951708e-02f, 1.36875166e-02f, -4.55387011e-02f, -2.65693963e-02f, 8.82560760e-02f,
  2.26253383e-02f, 6.45983964e-02f, 2.05072537e-01f, -9.62073356e-02f, 1.18211851e-01f, -1.42905265e-01f, 1.46235123e-01f, 7.76337683e-02f, -2.27259099e-02f, -1.45267010e-01f,
  6.74165459e-03f, 1.50794432e-01f, 1.60793141e-01f, 1.42045841e-01f, 1.51574671e-01f, -1.08535774e-01f, 2.94339447e-03f, 1.58319518e-01f, 1.38075158e-01f, -2.93841362e-02f,
  7.89948702e-02f, 4.28312644e-02f, 2.08703771e-01f, -3.88568104e-03f, -2.88649071e-02f, -6.84344918e-02f, -1.83822997e-02f, 3.35929729e-02f, 1.39038013e-02f, -4.60788095e-03f,
  5.47618195e-02f, 9.39508602e-02f, -8.23404640e-02f, -1.02450259e-01f, -1.02144755e-01f, -1.09845236e-01f, -9.96857658e-02f, -7.03264251e-02f, -1.54765025e-01f, 8.91396776e-02f,
  5.89107722e-02f, 6.69913292e-02f, -1.17942177e-01f, 6.09049350e-02f, 1.09744914e-01f, -8.84872153e-02f, -6.42785728e-02f, -1.37142375e-01f, 7.77952224e-02f, 7.03559071e-02f,
  8.53224620e-02f, -2.83160899e-02f, 8.32341611e-02f, -5.33571579e-02f, -2.79742740e-02f, -4.54055406e-02f, -1.54430587e-02f, 1.66006133e-01f, -9.54091474e-02f, 5.69805852e-04f,
  6.44808263e-02f, -1.53460214e-02f, 7.91788250e-02f, 1.27554014e-01f, 7.39982501e-02f, 5.62620498e-02f, 1.38162658e-01f, 1.61419378e-03f, 1.18358426e-01f, -1.31982401e-01f,
  7.37234578e-02f, 6.73261955e-02f, 1.38528859e-02f, 1.94112456e-03f, -4.56950404e-02f, 1.29209846e-01f, 2.13075787e-01f, 4.28957008e-02f, 1.69650912e-01f, -4.21523899e-02f,
  1.07511997e-01f, 1.84006952e-02f, 2.22458810e-01f, 6.08055405e-02f, 1.84139162e-01f, -6.05594926e-02f, -9.09581706e-02f, -1.40430406e-01f, -4.30164114e-02f, -5.03153261e-03f,
  1.06774174e-01f, -1.13084130e-01f, 5.47377467e-02f, 8.34179595e-02f, -7.10300729e-02f, 8.61694589e-02f, 3.04243639e-02f, -9.78010595e-02f, -1.12577036e-01f, -7.73777291e-02f,
  -2.84165423e-02f, -3.23751383e-02f, 7.99600258e-02f, -1.02181509e-01f, -5.84860146e-02f, -1.66236907e-02f, -1.14197902e-01f, -1.02768324e-01f, 9.71661508e-02f, 9.47725624e-02f,
  -5.68522699e-02f, 6.08135888e-04f, 4.85180914e-02f, -2.35584024e-02f, -1.26797587e-01f, 7.71263838e-02f, -9.98409465e-02f, -1.15264609e-01f, 1.14152767e-01f, -8.65067095e-02f,
  -5.02482988e-02f, -7.56641477e-02f, 1.37598023e-01f, -1.79156289e-02f, 9.29712057e-02f, -7.29399994e-02f, -1.13318592e-01f, 8.94937366e-02f, 6.78863674e-02f, -7.65098631e-02f,
  3.46874334e-02f, 1.04296163e-01f, 4.56937775e-02f, 7.71177635e-02f, -2.86857449e-02f, 8.01066682e-02f, -1.28132194e-01f, -6.75699711e-02f, 4.08233441e-02f, -8.57556388e-02f,
  1.26293063e-01f, 3.82195190e-02f, 1.52129503e-02f, -8.29699915e-03f, -8.99298582e-03f, -2.52466425e-02f, -1.12248577e-01f, 8.47289488e-02f, -3.98466028e-02f, -4.84954417e-02f,
  2.19041646e-01f, 1.12737253e-01f, -1.09271780e-01f, 4.37001958e-02f, 6.06475212e-02f, -1.73703711e-02f, 2.40672361e-02f, 3.47822644e-02f, 4.32467274e-02f, 9.24701318e-02f,
  1.36610925e-01f, -2.49132868e-02f, 2.67205555e-02f, 2.15133447e-02f, 3.04039549e-02f, 9.75327417e-02f, 1.08775809e-01f, 1.08203039e-01f, 2.38192141e-01f, -3.75156701e-02f,
  1.07177421e-01f, -8.27504545e-02f, 1.04946412e-01f, 2.43415907e-02f, -1.68440491e-01f, 2.68243074e-01f, -2.18158275e-01f, 9.46572423e-02f, 1.68305531e-01f, 1.29953012e-01f,
  -9.15190652e-02f, 1.55545771e-01f, -1.29948407e-01f, 5.76786920e-02f, 2.16484383e-01f, 7.16881230e-02f, -3.24032195e-02f, -6.89679459e-02f, -1.21659137e-01f, -3.72790992e-02f,
  6.98696226e-02f, 4.86389697e-02f, -7.84404483e-03f, 3.00566733e-01f, 2.96146516e-02f, 6.94358796e-02f, 1.21424899e-01f, 9.71372053e-02f, -1.63254663e-01f, 5.87158129e-02f,
  -7.12616518e-02f, -1.02345683e-02f, -2.27570161e-03f, 9.06747431e-02f, 5.28058559e-02f, -3.81026193e-02f, 8.61881375e-02f, 3.57180201e-02f, 8.82422626e-02f, 1.34886116e-01f,
  5.95517121e-02f, 1.03359394e-01f, 1.07606180e-01f, -7.32355639e-02f, -1.27139747e-01f, -5.75746596e-02f, 1.02436794e-02f, 3.09374873e-02f, -8.04450363e-02f, 1.96385175e-01f,
  9.79991630e-02f, -2.97744889e-02f, 1.63919151e-01f, 1.07700549e-01f, 1.77843854e-01f, 1.62586749e-01f, 7.27067366e-02f, -1.30213536e-02f, 9.08060744e-02f, 3.42005678e-02f,
  -6.12675622e-02f, 5.88555597e-02f, 2.02446505e-02f, -2.12496236e-01f, 5.95743209e-02f, 3.77187021e-02f, -3.83557342e-02f, -1.43681452e-01f, -1.05450928e-01f, 5.02352528e-02f,
  8.69147852e-02f, 2.67847199e-02f, -7.64826685e-02f, 6.48323372e-02f, 1.11181803e-01f, 2.55942255e-01f, 1.13700673e-01f, -7.34457746e-02f, 1.19280852e-02f, 2.54004505e-02f,
  -2.23473758e-02f, 1.12008788e-01f, 5.75899286e-03f, 9.88479480e-02f, 6.58332035e-02f, -2.03880519e-02f, 2.07624994e-02f, 1.73553675e-01f, -2.16827681e-03f, 2.32259676e-01f,
  1.56064972e-01f, -5.12451679e-02f, -1.01751931e-01f, 6.54281378e-02f, 2.26449426e-02f, 1.39959361e-02f, 2.04995975e-01f, 1.12412125e-01f, -1.78867981e-01f, -1.59204215e-01f,
  -3.22808027e-02f, -1.22989513e-01f, 7.57929236e-02f, 9.71980914e-02f, -1.04680240e-01f, 6.08237423e-02f, -1.57207903e-02f, -1.28561854e-01f, 8.21946040e-02f, -1.26343891e-01f,
  1.71693668e-01f, 1.75464414e-02f, 6.41612858e-02f, 1.22156329e-01f, -7.92236999e-03f, 1.66878495e-02f, 1.32550582e-01f, 2.12638691e-01f, 4.16620076e-02f, -2.00201049e-02f,
  2.58578539e-01f, 1.72403485e-01f, 2.77169608e-02f, 2.01300338e-01f, 1.26573071e-01f, 5.15564233e-02f, 2.53959179e-01f, 2.15423509e-01f, -1.09879270e-01f, 1.55013800e-01f,
  1.53245106e-01f, 1.55572757e-01f, -9.64738354e-02f, 2.02536106e-01f, -2.55123615e-01f, 7.98565298e-02f, 6.06278405e-02f, 1.40942642e-02f, -1.13081140e-02f, -1.64173797e-01f,
  -1.27328575e-01f, 2.39204526e-01f, 2.90316612e-01f, -1.71607643e-01f, -1.08624008e-02f, -8.01019222e-02f, -1.74809963e-01f, -6.28596619e-02f, 1.21860551e-02f, -8.90913084e-02f,
  -1.38299227e-01f, 2.55021691e-01f, 9.43120196e-02f, 4.15193588e-02f, 6.29865984e-03f, 1.42851561e-01f, 4.05114368e-02f, 2.76918001e-02f, 1.21781953e-01f, -1.03785396e-01f,
  -4.60549705e-02f, -7.81453326e-02f, 8.93713757e-02f, 3.27179939e-01f, -1.32115008e-02f, -2.72337943e-02f, -1.11921176e-01f, -1.82789892e-01f, -1.16451964e-01f, 5.08229807e-03f,
  6.98423535e-02f, 9.95303243e-02f, -3.78863439e-02f, 1.57567486e-02f, -7.21399626e-03f, -9.56103355e-02f, 1.11932065e-02f, 1.99530125e-01f, -8.42927396e-02f, 3.27615179e-02f,
  -1.07867561e-01f, -2.58863438e-02f, 9.41698626e-02f, 6.73938692e-02f, -1.50964055e-02f, -7.36173168e-02f, 2.71786358e-02f, 8.64516497e-02f, -9.66433361e-02f, -1.77790746e-02f,
  -1.04853302e-01f, 4.93825488e-02f, -3.06987967e-02f, 5.38039878e-02f, -6.15299121e-02f, -6.91899359e-02f, -1.00446321e-01f, -3.81585024e-02f, 7.48435780e-02f, -6.55964687e-02f,
  9.97408479e-02f, -9.52093154e-02f, 5.08674011e-02f, -1.18019648e-01f, -7.32360929e-02f, -7.42457211e-02f, -5.16866110e-02f, 5.89519180e-02f, 6.86266050e-02f, -1.10292442e-01f,
  5.07561751e-02f, -8.01883712e-02f, 2.76645329e-02f, -1.03406757e-01f, -1.03528060e-01f, -1.21356450e-01f, -1.20433107e-01f, -3.90145108e-02f, -3.85727286e-02f, 4.31846827e-02f,
  1.50102777e-02f, -9.19557586e-02f, 4.35626172e-02f, 9.24831405e-02f, -8.48646834e-02f, -7.35896826e-02f, -8.78433511e-02f, 6.49440065e-02f, 3.54020968e-02f, -1.13404617e-01f,
  9.83489528e-02f, 1.21281192e-01f, -1.09848194e-02f, -7.13854134e-02f, 2.78062988e-02f, -8.88015404e-02f, -1.98278315e-02f, -2.06317678e-02f, -3.01483646e-02f, -1.58407986e-02f,
  -5.91562763e-02f, -3.99030186e-02f, 1.96486507e-02f, -7.63303265e-02f, 6.24417700e-02f, -8.88052490e-03f, -5.19453771e-02f, 1.11808278e-01f, 7.17812330e-02f, 1.30391151e-01f,
  1.03772856e-01f, 1.21737584e-01f, 9.25806537e-02f, -3.95059437e-02f, 1.49724418e-02f, 1.04899734e-01f, -9.72039476e-02f, 4.53532673e-02f, 2.02712744e-01f, -1.48918647e-02f,
  1.05959713e-01f, 9.23597720e-03f, -9.38290134e-02f, -1.11423992e-02f, 5.06932214e-02f, 6.34892955e-02f, 1.31889090e-01f, 1.10609837e-01f, 1.04015768e-01f, -1.52184203e-01f,
  -1.94503427e-01f, -4.39973399e-02f, 1.25395223e-01f, -1.32485041e-02f, 2.64625460e-01f, -1.07394777e-01f, 9.33552906e-02f, 1.13579027e-01f, -1.80537812e-02f, 8.74289870e-02f,
  1.43901646e-01f, 1.77261941e-02f, -3.53779923e-03f, 2.37047315e-01f, -7.19915628e-02f, -8.81320015e-02f, -1.19193539e-01f, -8.26388821e-02f, -1.02215052e-01f, 6.98904274e-03f,
  5.47780693e-02f, -7.17240758e-03f, -1.42677248e-01f, 6.20480739e-02f, -2.07024254e-02f, 2.86224950e-02f, 2.56788414e-02f, 1.82162859e-02f, 3.85690294e-02f, 9.62312073e-02f,
  -2.23850440e-02f, 1.66379377e-01f, 1.36504516e-01f, -1.73288181e-01f, -4.14410979e-02f, -1.21046029e-01f, -1.97678372e-01f, 1.37437567e-01f, -1.30209150e-02f, 1.90092046e-02f,
  -3.39560769e-02f, -3.10858432e-02f, -9.93534178e-02f, -1.20639637e-01f, -3.66255790e-02f, -8.09134636e-03f, 5.61424438e-03f, -1.36337876e-01f, 1.54802725e-01f, 9.71464738e-02f,
  -6.46723201e-03f, -9.43469852e-02f, -2.40366422e-02f, 2.14923806e-02f, 1.51270479e-01f, -1.16011858e-01f, 1.29450276e-01f, -1.97298136e-02f, -1.01997651e-01f, -2.84157153e-02f,
  8.12967345e-02f, -1.57152832e-01f, -3.02800387e-02f, 2.27537647e-01f, 1.71170130e-01f, 9.74402949e-02f, 9.35890302e-02f, -4.42947745e-02f, -1.33292466e-01f, -8.34376067e-02f,
  8.13571885e-02f, -5.75598404e-02f, -1.21900953e-01f, 1.03172906e-01f, 1.90412581e-01f, 1.66405104e-02f, -1.23977736e-01f, 2.51486581e-02f, -5.93587495e-02f, -5.17947860e-02f,
  1.42764831e-02f, 4.28138636e-02f, -1.30598351e-01f, 7.51304105e-02f, 3.05708528e-01f, 1.75606444e-01f, 6.52782619e-02f, -2.70097591e-02f, -1.06517337e-01f, -3.81847098e-02f,
  -4.55006845e-02f, 1.00367166e-01f, -7.76717365e-02f, -8.56418815e-03f, 2.12867171e-01f, 2.76662111e-02f, -2.15419531e-01f, 5.60090467e-02f, 6.97774515e-02f, 1.56226471e-01f,
  -1.96038242e-02f, 3.62985916e-02f, -1.04622059e-01f, -2.53646858e-02f, 2.30689198e-02f, 7.89711177e-02f, -7.22988397e-02f, -2.07526907e-02f, 1.02351598e-01f, -5.88241480e-02f,
  -9.21001434e-02f, 5.87957120e-03f, 9.00068656e-02f, -7.29875872e-03f, -5.92144430e-02f, 5.60451904e-03f, -3.55064794e-02f, -8.09241235e-02f, 1.01290934e-01f, 5.38522564e-02f,
  1.11588307e-01f, 7.86485821e-02f, -4.71878238e-02f, 6.98255152e-02f, 4.56902459e-02f, -8.43177959e-02f, 1.08011879e-01f, 4.29708138e-02f, -7.87379518e-02f, 7.76326358e-02f,
  -4.06739861e-02f, -5.81557676e-02f, 3.46084721e-02f, -1.03940874e-01f, -3.55982520e-02f, 2.16153376e-02f, 1.94399636e-02f, -5.61986864e-02f, 9.69842449e-02f, -9.91138667e-02f,
  1.05544358e-01f, 3.31942737e-02f, -8.85944441e-02f, -3.88268046e-02f, 8.07882026e-02f, 3.66987586e-02f, -6.92700129e-03f, -4.57335748e-02f, 8.44273344e-02f, 9.00810584e-02f,
  1.40869409e-01f, -1.77963357e-02f, -6.73593283e-02f, 3.78944241e-02f, 6.34413362e-02f, 9.22325179e-02f, -5.05863465e-02f, -1.07215419e-02f, 1.22245990e-01f, 4.81373025e-03f,
  -7.98489898e-02f, -4.15525921e-02f, -7.54783601e-02f, -1.12927802e-01f, 2.02516854e-01f, 1.79000676e-01f, 2.40708545e-01f, 1.60251200e-01f, 1.17087580e-01f, 2.61019528e-01f,
  2.27374360e-01f, 1.87616199e-01f, 5.58741800e-02f, 5.32793142e-02f, 1.54944077e-01f, 2.58939862e-01f, 8.28253403e-02f, -9.08005461e-02f, -9.92422625e-02f, -1.20822214e-01f,
  1.50088817e-01f, -1.09223963e-03f, 1.06819928e-01f, -1.73331305e-01f, 1.51280642e-01f, 4.60504442e-02f, 3.15259956e-02f, -9.08745155e-02f, 1.00638829e-01f, -2.43971422e-02f,
  1.19659685e-01f, 1.40075043e-01f, 3.83835770e-02f, 1.59157962e-01f, 2.25104913e-01f, 1.36713833e-01f, 2.69456625e-01f, -1.15785785e-01f, 3.62536088e-02f, 1.42586902e-01f,
  1.89662504e-03f, -2.36606061e-01f, 4.75812890e-02f, -6.97322041e-02f, 4.92959656e-02f, 2.13847190e-01f, 1.25069797e-01f, 1.25718981e-01f, 1.05718169e-02f, -6.63255006e-02f,
  -1.48930117e-01f, 1.14223324e-02f, -8.50372836e-02f, 1.53695151e-01f, 8.86470824e-02f, -2.66285762e-02f, 1.00770362e-01f, 2.34305426e-01f, -1.22218058e-01f, -1.16112508e-01f,
  -1.03195705e-01f, 1.38082176e-01f, 2.06076875e-01f, 8.98963511e-02f, 4.56380427e-01f, 1.81885004e-01f, 2.40062419e-02f, -8.56155232e-02f, -1.05099082e-01f, -1.42767848e-02f,
  3.87241505e-02f, -8.07966590e-02f, -8.39998275e-02f, 4.16173972e-02f, 8.69916677e-02f, 7.28683248e-02f, 8.64685774e-02f, -1.51300384e-02f, 3.72716747e-02f, -1.29984587e-01f,
  -4.90196161e-02f, 8.83426145e-02f, -3.19201685e-03f, -8.27240124e-02f, 1.14394896e-01f, 8.71960670e-02f, -9.20207128e-02f, 1.48644093e-02f, 1.07816290e-02f, 1.01632565e-01f,
  1.02628721e-02f, -7.49847069e-02f, 2.59101694e-03f, 1.12913549e-02f, 7.60951564e-02f, -9.83876884e-02f, 7.25011975e-02f, -5.31483069e-02f, -1.05891526e-01f, 1.00065164e-01f,
  7.52429217e-02f, 4.46888916e-02f, 9.76977274e-02f, 8.46978128e-02f, 9.99625996e-02f, -9.87758711e-02f, 3.33162881e-02f, 2.88357083e-02f, -1.17126234e-01f, 2.64290068e-02f,
  3.96670848e-02f, -1.17889993e-01f, -1.08492322e-01f, -4.59607095e-02f, 4.42067757e-02f, -6.95647150e-02f, -1.62215456e-02f, -9.56613421e-02f, 1.23338923e-01f, -1.38953570e-02f,
  -5.34196161e-02f, 3.80100496e-02f, -7.53574595e-02f, 1.22814447e-01f, -2.61081252e-02f, 4.28932495e-02f, -1.22819699e-01f, -2.52693724e-02f, 3.84700820e-02f, -8.40807185e-02f,
  -8.75747874e-02f, -3.27201397e-03f, 1.29349023e-01f, 6.77269399e-02f, 1.48888737e-01f, 1.45982325e-01f, 1.58877015e-01f, 7.59905502e-02f, 1.21968761e-01f, 1.15579821e-01f,
  1.56009302e-01f, -6.89961687e-02f, 7.87513405e-02f, 1.22931309e-01f, -8.62893313e-02f, -2.15274230e-01f, 9.43520144e-02f, -4.36714888e-02f, -2.96843052e-01f, 2.59374809e-02f,
  -7.41817579e-02f, -1.83866709e-01f, -2.76786145e-02f, -1.12950519e-01f, -1.93565100e-01f, -1.34602323e-01f, 1.21660173e-01f, 1.26715899e-02f, -2.30280254e-02f, -4.56642509e-02f,
  6.80327788e-02f, -1.69682857e-02f, 9.47994739e-02f, -7.73222074e-02f, -1.19804591e-01f, 4.54490744e-02f, -5.87297231e-02f, -1.06577151e-01f, -1.73941888e-02f, 1.38271883e-01f,
  -1.06639005e-01f, 1.74846157e-01f, 1.69845879e-01f, -1.53400868e-01f, -1.05489820e-01f, 8.47784355e-02f, 1.21294148e-01f, -9.84323397e-02f, -6.13006623e-03f, 9.56036076e-02f,
  -9.44474712e-02f, 6.69945180e-02f, 1.68203309e-01f, 7.88663700e-02f, 1.39625166e-02f, 3.36359181e-02f, 1.21360958e-01f, 7.53280371e-02f, 1.00976355e-01f, 8.22536796e-02f,
  -2.82759331e-02f, -1.35693967e-01f, -6.71364665e-02f, 1.84607089e-01f, -4.49990630e-02f, -2.70936098e-02f, 8.23352709e-02f, 6.91009089e-02f, 9.50092226e-02f, 9.41689014e-02f,
  -9.68134701e-02f, 1.80950779e-02f, -3.89631800e-02f, -2.03269292e-02f, 1.61827571e-04f, 6.25931099e-02f, -1.29152350e-02f, -5.75151481e-03f, -1.00846998e-01f, -6.07689396e-02f,
  -7.75003061e-02f, 6.00040741e-02f, -7.03952163e-02f, -1.09169357e-01f, -1.09952986e-01f, 8.69030878e-02f, 8.46076906e-02f, -1.24345556e-01f, -1.72177963e-02f, -1.33800162e-02f,
  -9.99310613e-02f, 6.70898482e-02f, 4.64953743e-02f, -8.92158002e-02f, -1.10806838e-01f, -1.04122823e-02f, -4.42107320e-02f, 1.27737015e-01f, 6.33630753e-02f, 1.11613333e-01f,
  8.48826244e-02f, 3.49272080e-02f, 1.02062240e-01f, 6.68967664e-02f, 1.27635226e-01f, 8.94239396e-02f, 3.31627205e-02f, 4.56996188e-02f, -1.24461402e-03f, 4.60820127e-04f,
  5.41443080e-02f, 1.16122916e-01f, 1.23348579e-01f, -2.61113606e-02f, -9.47486460e-02f, 1.45793483e-01f, 4.50104941e-03f, 3.70651111e-02f, 6.68564439e-02f, -5.95991127e-03f,
  4.84581962e-02f, -1.23693720e-01f, 1.37072027e-01f, 9.18613523e-02f, 3.22071556e-03f, 6.93601519e-02f, 6.66218773e-02f, -5.15677035e-02f, 6.25641569e-02f, -1.43818855e-02f,
  2.55404681e-01f, 7.86984190e-02f, 2.10279062e-01f, 2.90464610e-03f, 1.99207410e-01f, 2.42573544e-01f, -4.62980159e-02f, -1.69437192e-02f, 9.93159413e-02f, 7.45456815e-02f,
  1.81664020e-01f, 9.96497571e-02f, -4.37695608e-02f, -1.44196719e-01f, 5.35446815e-02f, -3.19198407e-02f, -1.90906957e-01f, -1.81302801e-01f, 1.21770121e-01f, -6.96135983e-02f,
  2.27479741e-01f, -1.24220930e-01f, -4.38628159e-02f, -1.42423660e-01f, 8.76092166e-02f, 3.39121103e-01f, 1.15830816e-01f, -1.13082543e-01f, 1.61724046e-01f, 1.96160525e-01f,
  1.55761287e-01f, 1.92446783e-01f, -9.61452164e-03f, -4.09705266e-02f, -1.26241334e-02f, -6.64010122e-02f, 6.67890161e-02f, -4.71181534e-02f, 5.50469607e-02f, 1.05339803e-01f,
  1.01413652e-01f, 1.55066207e-01f, -5.53703792e-02f, 2.23807315e-03f, 7.49941692e-02f, 5.59339561e-02f, 1.64903194e-01f, 2.93552995e-01f, -1.45869344e-01f, -1.48044974e-01f,
  6.46285852e-03f, -5.44457994e-02f, 9.33683589e-02f, 3.53308558e-01f, 1.74610913e-01f, -9.57553610e-02f, -4.06885445e-02f, -1.52327538e-01f, 1.58014625e-01f, -6.61826655e-02f,
  2.53647983e-01f, 1.18640102e-01f, -1.11263499e-01f, -4.35715169e-02f, 8.05302262e-02f, 1.47677720e-01f, 6.42673597e-02f, 1.59633562e-01f, -6.63512796e-02f, -3.38972881e-02f,
  1.94711283e-01f, 1.65021032e-01f, 4.11979127e-04f, 1.40938416e-01f, 2.18879804e-02f, 1.21407397e-01f, 7.21009402e-03f, 9.43211541e-02f, -9.47077945e-02f, -6.68764636e-02f,
  1.90639973e-01f, -1.01551913e-01f, 1.62618369e-01f, -1.79086566e-01f, 8.55911896e-02f, -1.96939465e-02f, -1.52582794e-01f, -1.99065149e-01f, 1.80387631e-01f, 8.78826007e-02f,
  -7.46470764e-02f, 1.71778083e-01f, 3.85579430e-02f, 7.26641268e-02f, 2.26268336e-01f, -1.91981755e-02f, 1.07709087e-01f, -4.75595370e-02f, -7.50916749e-02f, 2.50782887e-03f,
  2.15102062e-02f, -8.33081976e-02f, 1.72791213e-01f, -1.44200638e-01f, 2.54853256e-02f, 6.46390617e-02f, -5.65004861e-03f, 2.90494505e-03f, -9.54661518e-02f, -3.65664414e-03f,
  2.24584639e-02f, 1.02479108e-01f, 8.70716646e-02f, 1.87672481e-01f, -1.03340328e-01f, -1.16588295e-01f, 5.02154380e-02f, 1.67234495e-01f, -1.33376032e-01f, -8.15866292e-02f,
  -1.57702863e-01f, 1.19599506e-01f, 6.18076399e-02f, 2.29041636e-01f, 2.08669826e-01f, 1.32796928e-01f, -1.12321407e-01f, -5.28088436e-02f, 1.41160926e-02f, -2.33990932e-03f,
  -5.20174801e-02f, -1.03948593e-01f, -6.56378046e-02f, -8.17103386e-02f, 2.86151264e-02f, -9.49798822e-02f, -2.70236353e-03f, -1.17961302e-01f, -7.13338703e-02f, 7.76836202e-02f,
  6.81753084e-03f, 1.11330576e-01f, 6.23268746e-02f, -2.86402088e-02f, 9.38320383e-02f, -1.00255802e-01f, 8.75724107e-02f, 6.02016151e-02f, -4.37776744e-02f, 1.00948349e-01f,
  -2.08409782e-02f, 1.63110029e-02f, 1.18827514e-01f, -1.88985519e-04f, 9.10081789e-02f, 3.89675424e-02f, -7.91156292e-02f, 1.40162379e-01f, -4.02740538e-02f, -8.60535800e-02f,
  -1.32240281e-02f, 1.18657432e-01f, 5.15283011e-02f, 6.54489845e-02f, 1.34681687e-01f, 8.51991475e-02f, 7.24199414e-02f, -6.56084120e-02f, 9.55103636e-02f, -9.96851027e-02f,
  1.70388278e-02f, -1.13509767e-01f, 1.25363886e-01f, 9.97052565e-02f, 2.29858197e-02f, 7.64654204e-02f, -8.67713168e-02f, -3.36244106e-02f, 7.25299641e-02f, -6.85012937e-02f,
  1.25251666e-01f, 7.87748396e-02f, 8.91447961e-02f, -6.66288212e-02f, 6.47608489e-02f, -5.01974188e-02f, -8.45076516e-02f, -6.64006844e-02f, 1.36691993e-02f, -2.94535998e-02f,
  -1.87095366e-02f, 1.04045026e-01f, -1.82533357e-02f, 5.39533086e-02f, 9.57563594e-02f, -7.49479160e-02f, -1.12642623e-01f, -7.95452818e-02f, 6.62002936e-02f, -2.86268932e-03f,
  3.25985812e-03f, -1.18362598e-01f, 4.45695184e-02f, 2.17685737e-02f, 3.26524489e-02f, 5.31287156e-02f, -9.01193470e-02f, 1.11723781e-01f, -3.95813100e-02f, 2.19124537e-02f,
  -5.52700348e-02f, 4.94548157e-02f, 5.94685897e-02f, 1.07521161e-01f, 5.64326383e-02f, -9.52687263e-02f, -4.89052460e-02f, -7.76487216e-02f, -1.17177337e-01f, 5.25833257e-02f,
  1.01910435e-01f, 2.72879098e-02f, -9.25094560e-02f, 1.58761907e-02f, 4.57967073e-02f, 5.62817184e-03f, -5.51511459e-02f, -4.07358147e-02f, -8.19897503e-02f, -6.29450381e-02f,
  -4.29815277e-02f, -3.09807844e-02f, 7.44679868e-02f, -8.34505856e-02f, -1.13761067e-01f, -3.22940499e-02f, 7.58859217e-02f, -6.83970302e-02f, 1.46923987e-02f, -1.72652323e-02f,
  -3.74894887e-02f, -6.13225736e-02f, 5.21936268e-02f, 1.12806916e-01f, -1.18024208e-01f, -1.21749556e-02f, -8.32031388e-03f, 3.95437591e-02f, -9.85643268e-02f, -6.72054663e-02f,
  3.28701101e-02f, 6.76292777e-02f, -1.10347793e-01f, 7.34516606e-02f, 3.72183435e-02f, 1.13678038e-01f, 1.49551749e-01f, -5.21906130e-02f, 1.36132881e-01f, -7.79698193e-02f,
  -1.11137494e-03f, 1.49341181e-01f, -4.08552997e-02f, 1.09376349e-01f, 8.63028392e-02f, 9.70854908e-02f, -4.79472317e-02f, -8.24104354e-04f, -1.43934283e-02f, -2.46548411e-02f,
  -6.07105158e-03f, -1.54905254e-02f, -9.64341909e-02f, 5.89257739e-02f, -4.87762243e-02f, -1.50243551e-01f, 4.44219597e-02f, -1.35053098e-01f, -2.13421788e-02f, -8.68181698e-03f,
  1.40599266e-01f, 1.47262245e-01f, -5.35371453e-02f, 3.83153139e-03f, 1.22445330e-01f, -4.03043441e-02f, 1.53031945e-01f, -4.97573130e-02f, -1.34369731e-01f, -3.06225996e-02f,
  -9.16958228e-02f, 6.80817515e-02f, 7.96036571e-02f, -1.90504521e-01f, -5.25424480e-02f, -5.51055148e-02f, 6.96172863e-02f, -8.77905861e-02f, 6.50177747e-02f, 6.08565509e-02f,
  1.43114254e-01f, -5.46955466e-02f, 1.10087685e-01f, 1.28233343e-01f, -1.12505719e-01f, -8.35834537e-03f, -9.95049328e-02f, -6.50206534e-03f, -7.88556263e-02f, 3.09985764e-02f,
  9.58127379e-02f, -4.78427298e-02f, 4.78845872e-02f, -9.81588215e-02f, 1.81246459e-01f, -1.20844379e-01f, -8.14852268e-02f, 6.27846876e-03f, 5.57481386e-02f, -1.92791410e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  1.02767818e-01f, 1.58847749e-01f, -1.22427806e-01f, -6.98546022e-02f, -3.21082324e-02f, 1.43123348e-03f, 1.55397430e-01f, -3.41251008e-02f, 9.77085605e-02f, 9.56562683e-02f,
  -1.10845186e-01f, 6.13162816e-02f, 1.36144325e-01f, -3.73236239e-02f, 1.24010615e-01f, 3.61954384e-02f, -7.95426518e-02f, -1.24764152e-01f, -1.03170246e-01f, 2.36147586e-02f,
  -5.25906086e-02f, 9.73046049e-02f, -9.68920887e-02f, 1.16700366e-01f, 6.98027834e-02f, 1.12858653e-01f, 1.76498160e-01f, -8.18399712e-02f, 1.49563253e-01f, -6.60069957e-02f,
  1.05847150e-01f, 1.48089111e-01f, -9.38588679e-02f, -5.23031168e-02f, -3.10058566e-03f, 5.34892939e-02f, 9.08316299e-02f, 1.04043029e-01f, 2.99302842e-02f, 5.75343287e-03f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  2.90713236e-02f, 1.93020672e-01f, 1.04246087e-01f, 4.10696380e-02f, 1.25964031e-01f, 9.83065963e-02f, 8.59241337e-02f, -8.19119439e-03f, 1.38639258e-02f, 1.43670544e-01f,
  3.78103033e-02f, -1.27689064e-01f, 2.91233957e-02f, -1.38274297e-01f, 5.02862828e-03f, 1.72326919e-02f, 3.20034064e-02f, -7.28879571e-02f, -1.94403213e-02f, 7.88822994e-02f,
  1.73154980e-01f, 2.72503756e-02f, -2.89117126e-03f, -1.33673117e-01f, -2.31129602e-01f, -5.13788536e-02f, 1.18954979e-01f, -5.52881919e-02f, -1.37438625e-01f, -6.01655655e-02f,
  -9.76298563e-03f, -1.16406843e-01f, -2.81481240e-02f, -2.46743709e-02f, 1.39811300e-02f, 1.25523627e-01f, -6.93273470e-02f, 1.14818044e-01f, -1.70510396e-01f, 1.75310373e-02f,
  5.42052574e-02f, 3.09422426e-02f, -4.90941107e-02f, 1.06493555e-01f, -1.24472558e-01f, -1.58375040e-01f, -3.15379016e-02f, 1.04693495e-01f, -1.17735460e-01f, -4.89606755e-03f,
  -3.49216722e-02f, -1.07813373e-01f, -2.41657393e-03f, -7.64237940e-02f, -7.83418715e-02f, 2.88281828e-01f, 8.23588669e-02f, -1.69353902e-01f, 8.45810473e-02f, 1.51024193e-01f,
  1.20592304e-01f, 8.11722651e-02f, -7.04121813e-02f, -7.05475360e-02f, -8.61678943e-02f, 1.83227547e-02f, -5.45820072e-02f, -3.07447053e-02f, 6.82037696e-02f, -1.42464995e-01f,
  -1.95903465e-01f, -4.65666614e-02f, -6.23829886e-02f, -2.38845706e-01f, 2.65269191e-03f, -2.11744338e-01f, -3.63265760e-02f, 6.06680661e-02f, 2.52289791e-02f, 4.46674787e-02f,
  -7.40168467e-02f, 1.61638781e-01f, 5.09929657e-02f, -1.17315026e-02f, -1.01161815e-01f, -1.08759120e-01f, -1.11856706e-01f, -1.83735847e-01f, 1.75725557e-02f, -7.11925328e-02f,
  -2.56929919e-03f, -1.50850281e-01f, 1.05143167e-01f, -6.10199980e-02f, 5.94516359e-02f, 1.00216649e-01f, 1.09614708e-01f, 1.77072987e-01f, 3.74810919e-02f, -1.75389200e-01f,
  4.31273878e-02f, -1.54987536e-02f, 9.73147005e-02f, 7.16147721e-02f, 4.18963134e-02f, -1.20802149e-02f, -6.71775714e-02f, 9.17741284e-03f, 1.75512098e-02f, 7.92670771e-02f,
  1.07068017e-01f, 1.22866735e-01f, -1.23392127e-01f, -5.11887670e-02f, 3.58413020e-03f, -1.18926249e-01f, -2.83948192e-03f, 1.61514834e-01f, -1.03932144e-02f, -6.54571950e-02f,
  -1.09289616e-01f, 7.09169507e-02f, -8.86809453e-02f, -1.77690402e-01f, -6.24528080e-02f, -1.19558834e-01f, -3.01436521e-03f, -1.32175937e-01f, -3.16889398e-02f, -1.27367333e-01f,
  1.11315206e-01f, -1.01252109e-01f, -2.14667618e-01f, 1.67525411e-01f, 8.52319896e-02f, 9.50121433e-02f, 1.75134748e-01f, -1.05416745e-01f, 5.10774069e-02f, 4.36748238e-03f,
  -4.59872931e-02f, 1.46227717e-01f, -9.87810269e-02f, 1.34533316e-01f, 2.91901022e-01f, 4.87763621e-02f, -1.56687975e-01f, -1.80199593e-02f, -1.24598131e-01f, -9.56612974e-02f,
  -2.53833503e-01f, -1.21420845e-01f, 1.61621556e-01f, 1.29470840e-01f, 7.33509287e-02f, -1.50405973e-01f, 2.25174695e-01f, -6.45428002e-02f, 1.76418990e-01f, 1.38001338e-01f,
  -1.77416094e-02f, -1.36146456e-01f, -9.62534696e-02f, -3.56464237e-02f, -1.10153936e-01f, 7.50042796e-02f, 1.17543019e-01f, -2.10744180e-02f, -2.98001140e-01f, -4.12571877e-02f,
  5.15774898e-02f, -9.58574414e-02f, -2.21602201e-01f, -9.53771845e-02f, -2.11699918e-01f, 1.32996053e-01f, -5.03938124e-02f, 9.89581645e-02f, -2.52233446e-01f, 3.51397134e-02f,
  1.26066646e-02f, -1.54188335e-01f, -1.31978542e-01f, -3.36697362e-02f, -2.78639812e-02f, 8.31085294e-02f, 1.98481418e-02f, 2.15079099e-01f, -1.31357340e-02f, -1.74666177e-02f,
  7.25196004e-02f, 1.58115491e-01f, -4.36772332e-02f, 1.22605066e-03f, -5.74609861e-02f, -1.20042317e-01f, 1.35713324e-01f, 3.04126786e-03f, 1.37885422e-01f, -1.07023396e-01f,
  4.44108956e-02f, -6.84848875e-02f, 2.86234152e-02f, -1.77687868e-01f, -2.24631769e-03f, -1.91813141e-01f, -1.62164923e-02f, -3.22627835e-02f, 1.40084913e-02f, -1.57455996e-01f,
  -2.03555264e-02f, 3.37032527e-02f, 2.04690129e-01f, -1.44297719e-01f, 3.95954363e-02f, 7.27982298e-02f, -2.63168246e-01f, -1.32210366e-02f, 1.51215810e-02f, -2.44546197e-02f,
  -2.18388140e-01f, -1.68453351e-01f, -1.96302161e-01f, -1.52287647e-01f, -1.25091106e-01f, -1.62108481e-01f, 1.94185488e-02f, 3.28469753e-01f, 9.96950939e-02f, 3.62443924e-02f,
  3.72917615e-02f, 4.86624567e-03f, 5.55231236e-02f, -4.21200581e-02f, 2.80727241e-02f, -1.12951003e-01f, -7.70160183e-03f, -1.40528098e-01f, 3.00616957e-02f, 1.03111133e-01f,
  -1.17814183e-01f, -1.26363849e-02f, -1.21884942e-01f, 1.18684307e-01f, 2.18312889e-01f, -1.84255809e-01f, -1.01142377e-01f, 9.70927030e-02f, -6.57285377e-02f, -1.87015533e-01f,
  -6.19399101e-02f, 9.62397456e-02f, 1.04330229e-02f, -5.98451355e-03f, 5.05307950e-02f, 2.41132714e-02f, -1.71602875e-01f, -3.06990538e-02f, -1.71139494e-01f, -1.37263313e-01f,
  -1.46570295e-01f, -1.59279481e-01f, -2.01103866e-01f, -4.85766754e-02f, -8.91373307e-02f, 1.63818207e-02f, 1.16644695e-01f, -9.95551944e-02f, -8.29592273e-02f, 1.40669137e-01f,
  -6.38167113e-02f, -9.03319642e-02f, 1.42426908e-01f, 3.06915343e-02f, -1.38468832e-01f, 6.00424558e-02f, -4.42608586e-03f, 2.21458077e-01f, -3.17675360e-02f, 1.00441441e-01f,
  2.00829312e-01f, 8.96716341e-02f, 9.74072069e-02f, 2.18059346e-02f, 5.30110039e-02f, 4.71019335e-02f, 2.06095248e-01f, 1.07876584e-01f, -1.16975822e-01f, 8.81095380e-02f,
  -1.11014105e-01f, -2.54715502e-01f, -5.25768809e-02f, -2.09535994e-02f, 6.26466796e-02f, -4.11048811e-03f, 3.50787006e-02f, 1.26415685e-01f, -2.88345572e-02f, -4.21878546e-02f,
  -1.15747184e-01f, -4.29383218e-02f, 1.07958451e-01f, 8.61005113e-03f, 1.37042120e-01f, 5.34587391e-02f, -9.77519900e-02f, -3.22402618e-03f, -1.50110438e-01f, 1.19418465e-01f,
  -2.74502933e-02f, -2.25660950e-01f, -1.86659005e-02f, 4.84046899e-02f, -9.08504725e-02f, -5.54505736e-02f, -1.42730758e-01f, 3.16064134e-02f, -9.37615260e-02f, 1.07389271e-01f,
  -5.69207482e-02f, -8.34607705e-02f, -1.33388832e-01f, -3.29851508e-02f, 5.11950292e-02f, -1.12093881e-01f, -9.84526053e-02f, -3.89190800e-02f, 4.30480428e-02f, -1.33461580e-01f,
  -6.36228994e-02f, -9.38211381e-03f, -1.55076712e-01f, -5.34234121e-02f, 5.09477453e-03f, -4.99242805e-02f, -7.89846256e-02f, -3.30048054e-02f, 1.92211211e-01f, -1.45773381e-01f,
  1.48952872e-01f, -1.94459930e-01f, -5.22104539e-02f, -2.98228174e-01f, -1.73328221e-01f, 9.84965637e-02f, 1.06559329e-01f, 1.11943901e-01f, 2.01484356e-02f, 1.25121186e-02f,
  -1.82337612e-01f, -6.27578124e-02f, -5.45930602e-02f, -1.17857978e-01f, -1.15771830e-01f, 1.63907632e-01f, -1.69839397e-01f, -9.61950794e-02f, -1.22849561e-01f, -3.10949869e-02f,
  1.51515424e-01f, 6.12554960e-02f, -2.49794703e-02f, 5.65941818e-02f, -5.20090461e-02f, 5.89698032e-02f, -6.89613000e-02f, 5.39400382e-03f, -2.15157688e-01f, -1.83502883e-02f,
  -1.93740696e-01f, -5.44875935e-02f, 5.89988343e-02f, 5.54487556e-02f, -8.49153548e-02f, 1.21001944e-01f, 1.09410219e-01f, -1.23898715e-01f, -1.12101652e-01f, 2.32159477e-02f,
  1.05670780e-01f, 2.23438609e-02f, -2.53597014e-02f, 1.36572838e-01f, -1.34838477e-01f, 5.37000895e-02f, -1.37366384e-01f, 1.44797161e-01f, -1.09887570e-02f, -5.43871634e-02f,
  -6.72375560e-02f, 1.75836664e-02f, -3.77955511e-02f, -1.21675897e-02f, 3.94501910e-02f, -4.85982597e-02f, -3.90631482e-02f, 1.03095904e-01f, -2.80485731e-02f, -1.83737442e-01f,
  3.44984233e-02f, 1.22698613e-01f, -8.42178091e-02f, 1.12219609e-01f, -8.66016299e-02f, 1.23718493e-01f, 5.95981702e-02f, 4.50803973e-02f, 2.80530035e-01f, 6.32889122e-02f,
  7.44854882e-02f, -7.50423893e-02f, -1.82230640e-02f, 1.12169519e-01f, 1.92259252e-01f, 1.47298411e-01f, -9.45487171e-02f, 7.74002001e-02f, -3.47183309e-02f, -1.26337215e-01f,
  -1.13921888e-01f, 1.90108865e-02f, 6.02046540e-03f, 8.53474811e-02f, -6.19614683e-02f, -9.29391831e-02f, -2.71570217e-02f, -5.09330072e-03f, 6.87085688e-02f, 1.09173715e-01f,
  1.07127301e-01f, 7.00126262e-03f, 9.42260325e-02f, 1.46235861e-02f, 1.23657823e-01f, 1.11006655e-01f, -2.04250276e-01f, 1.49867266e-01f, 1.11207895e-01f, -1.33584976e-01f,
  1.13419853e-01f, 1.83442399e-01f, 2.01659612e-02f, -9.59144980e-02f, -1.46173626e-01f, 5.29560074e-02f, 1.05961859e-01f, -1.06829116e-02f, -1.08607873e-01f, 1.00537539e-01f,
  -4.54874486e-02f, 8.87372345e-02f, -4.09376323e-02f, 4.48503569e-02f, 5.13881333e-02f, -1.18267769e-02f, -3.60278487e-02f, -5.11676781e-02f, 7.83423707e-02f, -3.00585553e-02f,
  5.06179295e-02f, 4.73157205e-02f, -5.12445904e-02f, -9.94721800e-02f, 1.11116823e-02f, 1.56424180e-01f, -6.26286045e-02f, 1.58847317e-01f, -5.35540730e-02f, 1.36872843e-01f,
  -5.65678589e-02f, 7.33357444e-02f, 1.67599112e-01f, 6.78736195e-02f, -6.54489845e-02f, -1.28003970e-01f, 1.24754369e-01f, 5.29979058e-02f, 2.62836665e-01f, -7.03505799e-02f,
  -7.44732050e-03f, 4.80806269e-02f, -6.47698790e-02f, -8.36069584e-02f, 1.45760283e-01f, -3.50959115e-02f, 9.85686705e-02f, 1.21772259e-01f, -1.98104709e-01f, 9.06044692e-02f,
  1.07250191e-01f, -3.59832719e-02f, -7.72144124e-02f, -1.60384774e-02f, -5.20836972e-02f, -1.01634122e-01f, -9.41268168e-03f, 8.30073506e-02f, 2.90408731e-02f, -8.16449448e-02f,
  -5.99760562e-02f, 1.10620864e-01f, -7.98987523e-02f, -2.72106022e-01f, -1.20812189e-02f, -4.77249101e-02f, 1.75471827e-02f, 1.15606142e-02f, -9.81950313e-02f, -3.76863927e-02f,
  1.04610898e-01f, 1.48434788e-02f, -1.08510301e-01f, -8.36949125e-02f, -7.62536749e-02f, -1.45521268e-01f, 4.16289046e-02f, 7.53777102e-03f, -8.31278190e-02f, -9.05421674e-02f,
  -1.01553008e-01f, 6.00259081e-02f, 7.91681639e-04f, 5.00627607e-02f, -9.82429609e-02f, -1.51200920e-01f, 3.90903577e-02f, -1.23819016e-01f, -1.87627539e-01f, 1.26426145e-01f,
  4.75819446e-02f, 6.68454915e-02f, 2.06829280e-01f, -1.04906827e-01f, -1.07044660e-01f, -3.29510346e-02f, -1.51073113e-01f, -7.81626925e-02f, -1.02206757e-02f, -1.79505963e-02f,
  -2.16977075e-01f, 1.00679874e-01f, -2.43959397e-01f, -1.22784432e-02f, 9.77271274e-02f, -3.18961740e-02f, 1.23804368e-01f, 2.96848193e-02f, 3.19301896e-02f, -1.16142537e-02f,
  9.49267205e-03f, 1.97218694e-02f, 1.28558815e-01f, -4.51639555e-02f, -9.24185216e-02f, 1.37034962e-02f, 2.16798320e-01f, 1.51083067e-01f, 9.74899307e-02f, -1.00295067e-01f,
  3.29550244e-02f, -1.95889935e-01f, 6.93081617e-02f, 1.02293551e-01f, 1.68196931e-01f, 1.47087380e-01f, 1.02273963e-01f, 2.17708312e-02f, 6.05260879e-02f, -1.65287137e-01f,
  6.43593743e-02f, -1.24072604e-01f, 1.26456842e-01f, -7.45217800e-02f, 5.23888916e-02f, 9.75264385e-02f, -1.09979935e-01f, -1.16713285e-01f, 9.13945287e-02f, 1.27247557e-01f,
  -8.64484608e-02f, 1.87713727e-02f, 1.22270733e-02f, 8.86856616e-02f, 1.46580532e-01f, -6.84883296e-02f, -1.60340458e-01f, 9.72545594e-02f, 1.08008452e-01f, 3.16607393e-02f,
  8.35314244e-02f, 1.48640826e-01f, 1.64701074e-01f, 4.66733947e-02f, -1.85428843e-01f, 3.94889787e-02f, -2.03778654e-01f, -2.38809753e-02f, -2.27615178e-01f, -3.89056578e-02f,
  2.30569735e-01f, -8.48405883e-02f, -6.36764094e-02f, -1.07913807e-01f, 6.96576387e-02f, -1.02899291e-01f, 5.85415587e-02f, -8.79860148e-02f, -1.24633737e-01f, -1.27748791e-02f,
  8.18230137e-02f, -2.73684025e-01f, 1.52451187e-01f, -1.08269267e-02f, 2.01637521e-01f, -1.70822841e-05f, -7.63411298e-02f, 4.14862949e-03f, 9.21622291e-02f, 6.59788102e-02f,
  -1.67262539e-01f, 1.37953281e-01f, 1.06772006e-01f, -1.52795568e-01f, 1.86059289e-02f, 1.64070651e-01f, -1.90459520e-01f, -2.96335742e-02f, -4.07869592e-02f, -1.28581852e-01f,
  -7.15143979e-02f, -3.85625921e-02f, 6.20996505e-02f, 7.19008148e-02f, 8.90691392e-03f, 1.41239166e-01f, -4.44058180e-02f, -4.43351641e-02f, -1.12954818e-01f, 3.22671956e-03f,
  5.04553206e-02f, -1.81185156e-02f, 9.70043615e-02f, 1.26748279e-01f, 3.22991726e-03f, -9.25448090e-02f, 3.98043692e-02f, -1.84816401e-03f, 7.64362738e-02f, -2.70471796e-02f,
  -1.88946724e-02f, -1.23980558e-02f, 9.18507501e-02f, 1.06979437e-01f, -1.53338835e-02f, 1.73657656e-01f, 1.69866666e-01f, -1.06395751e-01f, -9.33202431e-02f, 1.20943841e-02f,
  7.01603442e-02f, -9.32503119e-02f, -1.03161305e-01f, 4.42559794e-02f, -7.01508448e-02f, -5.91267310e-02f, -1.70512323e-03f, -1.32030502e-01f, 5.39214015e-02f, -2.29550481e-01f,
  9.14160684e-02f, -1.44318808e-02f, 8.83527473e-02f, -2.81744841e-02f, 1.04548991e-01f, 3.50498743e-02f, 1.16007559e-01f, -9.80784670e-02f, -2.79025286e-02f, -2.73281001e-02f,
  8.68028030e-02f, 4.71116602e-02f, 2.33990327e-02f, -1.24573648e-01f, -1.14548519e-01f, 6.80444092e-02f, 1.02350377e-01f, -3.19367275e-02f, -5.90355918e-02f, -3.58563848e-02f,
  -9.34410095e-02f, 5.52906208e-02f, 1.29171893e-01f, -3.24599259e-02f, -9.44570377e-02f, 4.50622290e-02f, 8.13432634e-05f, -9.06644836e-02f, -8.72051418e-02f, 2.27182806e-02f,
  1.90719645e-02f, -3.09851803e-02f, 1.05147913e-01f, 5.20353280e-02f, -7.65193179e-02f, -8.70380625e-02f, -1.72695960e-03f, -5.93343861e-02f, -1.41689032e-01f, 5.13536558e-02f,
  -1.05854832e-01f, 8.80056024e-02f, 1.39652446e-01f, -8.19688588e-02f, 3.73898745e-02f, -1.02394313e-01f, -1.70234200e-02f, 1.79977417e-01f, 1.40418321e-01f, 1.64772436e-01f,
  1.78060129e-01f, -4.66756485e-02f, -1.47861421e-01f, -2.89132334e-02f, -1.23146184e-01f, 1.02265343e-01f, -7.78275654e-02f, -1.18763270e-02f, -8.41520876e-02f, 4.51203398e-02f,
  -6.81804046e-02f, -2.45657507e-02f, 1.33970156e-01f, -1.12890422e-01f, -1.46954060e-01f, -1.24936409e-01f, -1.17962658e-01f, -2.10755646e-01f, 1.23958543e-01f, -1.64888188e-01f,
  -8.01277608e-02f, 1.98850781e-02f, -1.14127606e-01f, -5.13616316e-02f, 1.24402486e-01f, 4.99232411e-02f, -3.26380730e-02f, -2.87227165e-02f, -4.65249270e-02f, 2.21014529e-01f,
  2.03575909e-01f, 6.38411045e-02f, 6.64120093e-02f, 1.53625801e-01f, -2.33719513e-01f, 1.22300185e-01f, -1.15282804e-01f, -4.84553911e-02f, 8.33337232e-02f, 3.41918580e-02f,
  6.53222203e-04f, 8.51920247e-02f, 4.13190275e-02f, 2.94179142e-01f, 4.56898361e-02f, 1.19481333e-01f, -6.58747107e-02f, 1.90720111e-02f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  5.59345260e-02f, 1.70551792e-01f, -2.01713592e-02f, 1.68290555e-01f, 2.19384860e-02f, 1.52451590e-01f, 1.21581465e-01f, 1.48180887e-01f, 1.02161862e-01f, 5.64517407e-03f,
  1.04861915e-01f, -4.45889682e-02f, 7.50341744e-04f, -7.04630315e-02f, 5.90182561e-03f, -7.23573342e-02f, 1.24814041e-01f, -1.87897399e-01f, -1.24412753e-01f, 1.50187481e-02f,
  -1.34820104e-01f, -9.95912589e-03f, -6.37223870e-02f, -1.76308647e-01f, 1.03772894e-01f, 5.17233387e-02f, 1.85121782e-02f, 2.49178335e-02f, 2.89934933e-01f, 2.46255666e-01f,
  1.56004012e-01f, 1.24487758e-01f, -9.27591100e-02f, -1.29923090e-01f, 1.10274278e-01f, -3.18109281e-02f, -2.00527266e-01f, -4.76787388e-02f, -1.63352594e-01f, 4.61117886e-02f,
  -2.71327794e-02f, -8.38144273e-02f, 5.60018048e-02f, -4.47480083e-02f, -7.30767325e-02f, -9.66343936e-03f, 5.97182401e-02f, 1.01370916e-01f, -1.03691593e-01f, 7.01644421e-02f,
  1.39569655e-01f, -1.03628442e-01f, -1.14882812e-01f, 1.16524316e-01f, 1.00952193e-01f, 2.09591657e-01f, 2.63604578e-02f, 1.02761045e-01f, 9.27928165e-02f, 1.32065922e-01f,
  9.08985808e-02f, -6.48803338e-02f, 8.96811113e-02f, 9.26349387e-02f, 6.93875458e-03f, 1.26016766e-01f, 3.83207127e-02f, -4.21152823e-02f, -8.84168968e-02f, 9.46970060e-02f,
  -7.37759843e-02f, 4.04655226e-02f, 1.01609498e-01f, 7.69990683e-02f, 6.42492995e-02f, 2.26811077e-02f, -1.38490088e-02f, 9.57928505e-03f, -1.05131492e-01f, -1.41218349e-01f,
  -1.34929821e-01f, 1.09976746e-01f, -1.06480882e-01f, 3.46180820e-03f, 1.04569241e-01f, -2.21583564e-02f, 1.04728587e-01f, 7.93934166e-02f, 3.39273997e-02f, -5.63904829e-02f,
  6.46265671e-02f, 1.21983521e-01f, -1.38432952e-02f, 1.82481501e-02f, -3.15102227e-02f, 8.75940770e-02f, -7.39146769e-03f, -9.01171044e-02f, 1.16053022e-01f, 1.71026841e-01f,
  1.18980125e-01f, -7.76182278e-05f, -1.03245869e-01f, 1.18562259e-01f, -2.74988282e-02f, -3.24232690e-02f, -3.10717393e-02f, -3.40859182e-02f, 8.11226368e-02f, 5.39090633e-02f,
  5.28079923e-03f, -1.19763566e-02f, -2.64485925e-02f, -8.88414234e-02f, -1.49643635e-02f, -5.66621646e-02f, -1.66565981e-02f, -1.19329523e-02f, -2.43787132e-02f, 1.22313894e-01f,
  -3.80759165e-02f, -8.49838629e-02f, 9.28953812e-02f, -1.35292053e-01f, -4.10855152e-02f, 6.70048371e-02f, -1.85767151e-02f, -1.32438943e-01f, -1.10042192e-01f, 8.69905949e-02f,
  6.62889928e-02f, -3.99836376e-02f, 8.62808749e-02f, -9.99200419e-02f, 9.06764045e-02f, 7.02200830e-02f, -1.22709125e-01f, -1.61696583e-01f, -4.04823422e-02f, -3.21269818e-02f,
  -1.30412400e-01f, -9.38974917e-02f, 2.91495640e-02f, 1.32439926e-01f, 4.49262187e-03f, 7.88663924e-02f, 6.08736016e-02f, -8.84982049e-02f, -6.57363236e-02f, -1.02030151e-01f,
  -6.48859935e-03f, -1.01903290e-01f, -7.32112676e-02f, -1.10158630e-01f, -1.09479740e-01f, 2.65547708e-02f, 4.97839078e-02f, -1.59104049e-01f, -1.71156049e-01f, -7.02595487e-02f,
  -1.08100846e-01f, -7.84254670e-02f, 1.08738311e-01f, 1.72277853e-01f, -2.74336580e-02f, -9.82952118e-02f, -2.66358834e-02f, -9.84144136e-02f, 6.97873235e-02f, 1.13804959e-01f,
  3.79136694e-03f, -1.02496915e-01f, 8.99512693e-02f, 1.19896896e-01f, -4.39169183e-02f, 1.66458324e-01f, -6.95696771e-02f, 4.13645096e-02f, -1.59381986e-01f, 4.97631058e-02f,
  1.71373680e-01f, 3.40569951e-02f, 1.43393919e-01f, 5.84629811e-02f, -2.44087912e-03f, -1.71170682e-01f, -2.86766216e-02f, 3.99696529e-02f, -2.15799455e-02f, -4.36628535e-02f,
  1.20146371e-01f, -1.17959976e-02f, 5.52710257e-02f, 1.72867626e-01f, -1.11596674e-01f, 6.61768019e-02f, 4.11624759e-02f, 6.78038746e-02f, -7.89400637e-02f, 1.42058775e-01f,
  2.06652448e-01f, 3.52707170e-02f, 4.39393194e-03f, 4.08869572e-02f, -4.43451293e-03f, -6.86473504e-04f, -8.31598714e-02f, 1.17064551e-01f, 5.27749909e-03f, -2.49089068e-03f,
  9.54363216e-03f, 6.88317567e-02f, -4.06134166e-02f, 3.20146531e-02f, 2.47269291e-02f, 2.23866656e-01f, 7.56793469e-02f, -1.21762566e-01f, -1.20421261e-01f, -7.76359141e-02f,
  -2.02008821e-02f, 7.66815096e-02f, 4.59238067e-02f, 7.49363704e-03f, -5.15524745e-02f, -4.29993272e-02f, -1.22396678e-01f, 1.30665928e-01f, 6.42434359e-02f, -4.07422036e-02f,
  -6.79040840e-03f, 1.65559945e-03f, -8.85843113e-03f, 3.86997014e-02f, -5.20427823e-02f, 1.78442616e-02f, -1.35885447e-01f, 4.15948033e-02f, 2.19237898e-02f, -3.00741997e-02f,
  1.75294608e-01f, 5.86748980e-02f, -4.08638492e-02f, -6.42876560e-03f, -2.97584385e-03f, -4.63196971e-02f, 8.50447044e-02f, 1.04572684e-01f, -1.38132684e-02f, 3.58306356e-02f,
  2.10505648e-04f, 1.97272860e-02f, -3.86062786e-02f, -1.12854995e-01f, 1.23999357e-01f, 4.62246202e-02f, 3.57025452e-02f, -1.07762486e-01f, 5.35832085e-02f, -7.18215597e-04f,
  1.07100017e-01f, -7.38644972e-02f, -2.51608505e-03f, -1.08597890e-01f, -1.12990670e-01f, -2.96772774e-02f, -1.04381114e-01f, -3.78635619e-03f, -9.26104039e-02f, 1.00492716e-01f,
  7.78898075e-02f, 1.21312819e-01f, -4.57575545e-02f, 3.41651365e-02f, 4.23690043e-02f, 6.02426305e-02f, -1.01022974e-01f, -8.29504579e-02f, -7.26934150e-02f, 6.26112968e-02f,
  1.26453172e-02f, -7.76994973e-03f, -4.93465662e-02f, 9.80921369e-03f, 3.31828604e-03f, -1.00485601e-01f, 9.60257500e-02f, -5.45011722e-02f, -8.73744860e-02f, -1.24388576e-01f,
  -9.02217552e-02f, -1.09691620e-01f, 6.33711070e-02f, 6.94622919e-02f, 7.71721080e-02f, -2.27231011e-02f, -8.15233886e-02f, -2.64749117e-02f, 4.79502231e-02f, -1.09963849e-01f,
  2.07975078e-02f, 7.10674971e-02f, -2.98086647e-03f, -7.99471363e-02f, 2.72247083e-02f, 1.14858992e-01f, -4.79219705e-02f, 7.44808614e-02f, -3.23584746e-03f, -2.47973739e-03f,
  7.34882951e-02f, 9.95962769e-02f, 7.20705837e-02f, -9.87077951e-02f, -8.00132453e-02f, -2.44886130e-02f, -8.64886120e-02f, -1.84681602e-02f, -2.81784758e-02f, -4.81082983e-02f,
  -1.12276688e-01f, 7.52594545e-02f, 2.90485341e-02f, -1.33882448e-01f, -7.29313865e-03f, 8.62315006e-04f, 8.29885378e-02f, 3.50808427e-02f, 3.92706599e-03f, 8.84344988e-03f,
  6.65233210e-02f, -1.05943821e-01f, 7.03537911e-02f, 4.27369541e-03f, -2.11820304e-02f, 1.03689125e-02f, -3.57345998e-04f, -3.96769196e-02f, -3.34813595e-02f, -3.61858569e-02f,
  8.20051730e-02f, -2.09552851e-02f, 9.42988694e-02f, 3.01819462e-02f, -1.60952900e-02f, 1.06087759e-01f, 5.49749322e-02f, -1.42657906e-01f, -6.66310936e-02f, -1.01213539e-02f,
  1.56666841e-02f, 1.20359100e-01f, -4.42315042e-02f, 1.82107747e-01f, -1.22379914e-01f, -6.56177253e-02f, 1.05869845e-01f, -6.01033308e-03f, 2.20882833e-01f, -4.99304198e-02f,
  -7.60969669e-02f, 9.05604437e-02f, -9.29547325e-02f, 7.20312744e-02f, 7.54797161e-02f, 1.61051989e-01f, -8.76569673e-02f, -4.61151563e-02f, 6.70875162e-02f, 1.03397984e-02f,
  1.02257863e-01f, 8.49894211e-02f, 2.61629000e-02f, -1.01739373e-02f, -1.29456660e-02f, -5.80502786e-02f, 9.86064002e-02f, -3.18548530e-02f, 4.76756645e-03f, -5.32724150e-02f,
  -4.90724668e-02f, -8.68750513e-02f, 6.61959499e-02f, -1.20503202e-01f, 9.95135605e-02f, 5.29978387e-02f, 7.93232769e-02f, 1.08465627e-01f, -1.74624592e-01f, 6.11370914e-02f,
  -4.46441062e-02f, 4.16668765e-02f, 8.95717368e-02f, 7.31571317e-02f, -6.37634918e-02f, 1.31231591e-01f, -5.33359759e-02f, -4.81037721e-02f, 1.08771078e-01f, -3.05339042e-03f,
  1.00100227e-01f, -1.75410584e-01f, -1.88983649e-01f, -1.17151730e-01f, -1.63681041e-02f, -1.09175190e-01f, -2.38644928e-01f, -1.99599758e-01f, 1.87592283e-01f, 1.12245634e-01f,
  -7.18263313e-02f, -5.51987812e-03f, 2.97956288e-01f, 6.75246641e-02f, 1.42337784e-01f, -9.07521322e-02f, 1.06007934e-01f, -1.93912506e-01f, 1.03221864e-01f, -2.02772930e-01f,
  -9.93696973e-03f, 2.37392001e-02f, 2.97942273e-02f, -9.01592523e-02f, -2.78643370e-01f, -1.12718632e-02f, -3.82602215e-02f, 1.15458794e-01f, -1.14322677e-01f, 3.78036462e-02f,
  5.52352183e-02f, -6.68808632e-03f, -2.19371412e-02f, 5.49353287e-02f, -8.81928355e-02f, -5.75646609e-02f, -1.25997767e-01f, -1.52712137e-01f, 9.00752172e-02f, 2.66811192e-01f,
  6.08365200e-02f, 2.49295279e-01f, 7.32781142e-02f, 3.78630579e-01f, 1.43510982e-01f, -3.02369669e-02f, -1.22839436e-02f, 7.01912120e-02f, -1.40631646e-02f, -1.78144854e-02f,
  -8.53702053e-02f, -1.67138260e-02f, -2.74518621e-03f, -1.05425864e-01f, -7.70591199e-02f, 1.72748638e-03f, 3.14891636e-02f, -9.82871205e-02f, -1.18908845e-01f, 9.45478976e-02f,
  -9.13087279e-02f, -5.67721613e-02f, -7.35625178e-02f, 8.14099237e-02f, 1.08710341e-01f, 6.91241845e-02f, -9.82204080e-02f, 2.36328458e-03f, -5.45609556e-02f, 1.09683134e-01f,
  1.98465995e-02f, 3.82238701e-02f, -8.28163400e-02f, -1.07222497e-01f, 1.13727339e-02f, -2.17958633e-02f, 1.08057752e-01f, -4.40614112e-02f, -2.97964457e-02f, -7.87845850e-02f,
  -1.01753816e-01f, -6.19707555e-02f, 3.94034907e-02f, -2.19881181e-02f, -4.40786360e-03f, -4.98078167e-02f, -7.89147019e-02f, -7.42463320e-02f, -6.72094300e-02f, 9.05232057e-02f,
  -1.23163916e-01f, 4.80165333e-02f, -1.07897550e-01f, -9.34990197e-02f, 9.59707499e-02f, -5.83062768e-02f, -1.09334879e-01f, 9.03767869e-02f, -1.04355231e-01f, 4.30150218e-02f,
  3.72443721e-02f, -1.19032599e-01f, 1.51209934e-02f, -7.00035319e-03f, -7.25154728e-02f, -1.39677385e-02f, -4.83173430e-02f, -6.06076084e-02f, 4.16908301e-02f, -1.24334291e-01f,
  2.65469146e-03f, -7.96519890e-02f, -6.81300163e-02f, -6.86006562e-04f, 1.20680623e-01f, 1.63610607e-01f, -9.36347544e-02f, 1.61677003e-01f, 6.31995425e-02f, 1.46011651e-01f,
  7.08292350e-02f, 8.02847371e-02f, 1.02206998e-01f, 1.47728994e-01f, 1.80515703e-02f, 2.31522624e-03f, 6.08239174e-02f, 5.11003323e-02f, 1.38050377e-01f, -8.59608948e-02f,
  -9.43330601e-02f, -7.24223703e-02f, -2.08319768e-01f, 5.20518534e-02f, -2.66339719e-01f, -9.26638320e-02f, 2.06918418e-01f, 5.47980033e-02f, 5.09458445e-02f, 9.05925706e-02f,
  1.64568692e-01f, 3.77013013e-02f, -3.56475525e-02f, -8.62246454e-02f, -5.86162135e-02f, -9.00185630e-02f, -1.04162052e-01f, -1.29211275e-02f, -1.09600969e-01f, 1.22269444e-01f,
  3.35721523e-02f, 2.24625394e-02f, -2.62985021e-01f, 9.16426331e-02f, -6.82562664e-02f, -5.21321818e-02f, -1.22050896e-01f, 1.31154075e-01f, 4.60932031e-02f, -1.61436692e-01f,
  7.57491812e-02f, 1.57030642e-01f, -3.56982499e-02f, 2.80900728e-02f, -1.81722835e-01f, -2.78986874e-03f, 1.67465035e-03f, 1.72093824e-01f, -8.85799602e-02f, 2.00341135e-01f,
  3.64456535e-03f, 2.82914519e-01f, -7.30389133e-02f, 7.91318342e-02f, 4.60660830e-02f, 7.68905059e-02f, 8.49295408e-02f, -3.93823721e-02f, -7.09322318e-02f, -1.41223639e-01f,
  2.94198692e-02f, 1.15986601e-01f, 9.82601717e-02f, 6.52209520e-02f, -4.07223850e-02f, -4.03036587e-02f, -7.54200220e-02f, 4.50753532e-02f, 2.10798252e-02f, 1.40014619e-01f,
  6.29204065e-02f, 5.35457768e-02f, 5.08568957e-02f, 1.20838933e-01f, -1.38518378e-01f, -7.70116132e-03f, -1.77516267e-02f, 1.17613105e-02f, -2.21880585e-01f, 1.66964218e-01f,
  1.93155825e-01f, 2.79432931e-03f, -7.25704953e-02f, -8.26396793e-02f, 3.95050943e-01f, -3.43703628e-02f, -2.56167240e-02f, 2.39913940e-01f, 7.51705468e-02f, 2.55958378e-01f,
  -6.79190978e-02f, -2.06363425e-01f, -1.90423373e-02f, -5.84645756e-03f, 3.14430147e-01f, -1.03583045e-01f, -2.18828619e-02f, -9.06894505e-02f, 6.38509989e-02f, 1.38799772e-01f,
  -5.85011430e-02f, 2.11649507e-01f, 5.88780157e-02f, 9.54867378e-02f, 1.04578286e-01f, 1.57574683e-01f, -7.11476654e-02f, 6.28267229e-02f, -1.36657720e-02f, 1.94563434e-01f,
  2.86756065e-02f, 4.28451113e-02f, 7.08662942e-02f, 1.08253539e-01f, -6.15795106e-02f, 1.57615617e-01f, 1.66489974e-01f, -3.02901417e-02f, 1.47658801e-02f, -1.32846143e-02f,
  -1.93073023e-02f, -6.53090104e-02f, -3.53150032e-02f, 8.15397501e-02f, -1.28076002e-01f, 1.40181988e-01f, 3.15237865e-02f, -1.70278326e-02f, 1.09775513e-01f, -7.39141107e-02f,
  1.91160858e-01f, -1.00066210e-03f, 3.46462838e-02f, 2.42959902e-01f, 1.22287504e-01f, -6.98404312e-02f, 3.28750834e-02f, 8.03671479e-02f, -2.02795833e-01f, 3.21752250e-01f,
  -8.05118587e-03f, 3.51534069e-01f, 4.91984263e-02f, 2.88305789e-01f, 2.99678117e-01f, -8.57960340e-03f, 1.73421707e-02f, -1.15217576e-02f, 2.38436162e-01f, 1.02875322e-01f,
  4.04763579e-01f, 2.83151418e-01f, -9.42474082e-02f, 6.18917763e-01f, -2.51006708e-02f, -1.25499859e-01f, 4.26504225e-01f, -5.58339898e-03f, 4.20699626e-01f, -6.09664097e-02f,
  -2.74571944e-02f, 6.87320009e-02f, -2.05777753e-02f, 9.05833021e-02f, 7.06656724e-02f, -7.08462819e-02f, 4.20960225e-02f, 1.05676420e-01f, 3.64354789e-01f, 1.53586298e-01f,
  1.44884571e-01f, 4.38611135e-02f, -1.80497289e-01f, -6.73584044e-02f, 1.08799502e-01f, -2.69389778e-01f, -2.90165637e-02f, 3.35537046e-02f, -1.10440060e-01f, -8.75643194e-02f,
  -1.97773591e-01f, 6.01891689e-02f, 3.85467745e-02f, -5.41622937e-02f, -6.45544678e-02f, 1.29824951e-01f, 5.32869473e-02f, 7.01176003e-02f, 6.82314262e-02f, 1.39669865e-01f,
  -7.41852298e-02f, -5.65345623e-02f, 1.25559852e-01f, -3.61949690e-02f, 4.85919565e-02f, 9.00946334e-02f, -2.28516106e-03f, -1.48581162e-01f, -1.77916989e-01f, 3.20099555e-02f,
  -1.14896953e-01f, -1.18828177e-01f, 6.87593147e-02f, -1.57275852e-02f, 1.35685503e-01f, 9.55780149e-02f, 1.23651244e-01f, -7.41328299e-02f, -7.11473972e-02f, 2.68072850e-04f,
  2.61890441e-02f, 1.28309473e-01f, -2.04020038e-01f, 1.35740325e-01f, 6.98998496e-02f, 1.35198357e-02f, 2.59075239e-02f, -2.86782417e-03f, -6.63685873e-02f, 7.56058395e-02f,
  1.57584980e-01f, 1.26303183e-02f, -4.63784188e-02f, 6.89099878e-02f, 1.35182917e-01f, 8.69683176e-02f, -9.03045461e-02f, 5.45295849e-02f, 2.29163421e-03f, -2.37455666e-02f,
  -5.29522412e-02f, 8.20795596e-02f, 3.49902175e-02f, -8.08514506e-02f, 8.21595138e-04f, 7.22717717e-02f, 2.57429145e-02f, 3.92896496e-02f, 6.29693046e-02f, 1.39426053e-01f,
  3.86624038e-02f, -2.55209655e-02f, 1.06405676e-03f, -8.55397210e-02f, 4.41735387e-02f, 1.09106474e-01f, 3.99803184e-02f, -1.41481191e-01f, 1.80331327e-03f, -3.77455205e-02f,
  2.40781810e-02f, -1.01529323e-01f, -3.96177024e-02f, -6.69632033e-02f, 3.81264500e-02f, -9.05953124e-02f, 5.84935881e-02f, -4.94142435e-02f, -5.77399284e-02f, -6.28349930e-02f,
  6.25735596e-02f, -3.84458266e-02f, 8.01071525e-02f, 1.08856902e-01f, -2.33828183e-02f, 1.61395222e-02f, -1.06935509e-01f, -2.78760716e-02f, 5.27674481e-02f, 3.21340971e-02f,
  -3.80826220e-02f, -1.32177696e-02f, -9.14271250e-02f, 7.22068921e-02f, -5.89735620e-02f, -9.23151523e-02f, 1.50406659e-01f, -7.18848361e-03f, 8.85237306e-02f, -6.32074848e-02f,
  -9.84052718e-02f, 1.38073534e-01f, 3.18985730e-02f, -2.60425732e-02f, 2.01970696e-01f, 5.21094678e-03f, 1.50904119e-01f, 2.25259438e-02f, -5.96053451e-02f, -4.72333506e-02f,
  3.88649963e-02f, 1.67227853e-02f, -1.01575166e-01f, -1.24927253e-01f, -8.07158202e-02f, -5.58301657e-02f, 5.81930242e-02f, 9.94765833e-02f, 2.22472753e-02f, -8.36311057e-02f,
  2.08643880e-02f, 9.65482295e-02f, -4.71272692e-02f, -3.91548239e-02f, -1.04220867e-01f, -6.59614429e-02f, 3.09810266e-02f, 5.82453124e-02f, -9.55020040e-02f, 7.85061717e-02f,
  4.04429995e-02f, 6.70796931e-02f, -9.75541491e-03f, 1.51824923e-02f, 8.71503502e-02f, -1.21975653e-01f, -2.17090044e-02f, -1.86546110e-02f, -7.54982531e-02f, -5.97899035e-02f,
  -1.56785920e-02f, 6.03956021e-02f, -1.22102238e-01f, -9.26977620e-02f, -3.85969688e-05f, -1.18252356e-02f, -8.46692249e-02f, -1.06686905e-01f, -5.34663275e-02f, 7.36284927e-02f,
  9.90306139e-02f, 1.84728913e-02f, -6.63844794e-02f, 1.16239339e-01f, 4.07767221e-02f, -1.11448593e-01f, -2.79181395e-02f, 3.44088972e-02f, -3.26879993e-02f, 9.36015472e-02f,
  -8.58460590e-02f, 3.36923003e-02f, 5.14832288e-02f, 1.03637747e-01f, -1.06711082e-01f, -1.99013837e-02f, -1.18150935e-01f, 8.46736059e-02f, -9.39824954e-02f, -4.48572114e-02f,
  3.65970321e-02f, -9.42866057e-02f, -9.45079029e-02f, -8.11580941e-02f, -8.58057216e-02f, 8.72089937e-02f, 1.00885987e-01f, 1.87500454e-02f, -9.44347233e-02f, -1.20988734e-01f,
  -4.96571325e-02f, 5.55698536e-02f, -1.11202076e-01f, 7.35852867e-02f, 1.27890697e-02f, 3.00001781e-02f, 7.93840587e-02f, 4.77210805e-02f, -7.88091719e-02f, -1.62109511e-03f,
  -7.29650781e-02f, 2.40034852e-02f, -3.44343483e-02f, 3.05775627e-02f, -1.18337780e-01f, -1.68827716e-02f, 1.20581523e-01f, -5.44648841e-02f, -3.67637090e-02f, -6.15513027e-02f,
  -6.87873214e-02f, -2.12697661e-03f, -1.12458766e-02f, 7.66283944e-02f, 5.32677732e-02f, -7.64459968e-02f, -3.62517722e-02f, -1.68792643e-02f, -1.16739750e-01f, 1.18722379e-01f,
  7.20134825e-02f, -5.96364029e-02f, -8.26825649e-02f, -4.27007256e-03f, 2.91460715e-02f, -1.62409730e-02f, 9.93224978e-02f, -3.55424173e-02f, 1.49849094e-02f, -1.14032671e-01f,
  -8.84561315e-02f, -1.35426410e-03f, -1.22859932e-01f, 6.68385401e-02f, 7.43695349e-02f, -1.18286490e-01f, 5.38010560e-02f, -1.05490394e-01f, -7.23791420e-02f, 3.84506881e-02f,
  -1.10810496e-01f, -5.14512733e-02f, -9.22069922e-02f, -8.60896930e-02f, 5.46827614e-02f, -1.20223816e-02f, 2.22458821e-02f, -7.96708912e-02f, -2.98291836e-02f, 1.16677277e-01f,
  -8.00127983e-02f, -1.06694838e-02f, -1.23055249e-01f, -6.79459572e-02f, -8.99504684e-03f, -7.23762885e-02f, 3.34879905e-02f, 2.79432088e-02f, -6.79450482e-02f, -5.36782667e-02f,
  -1.61989722e-02f, -2.41238773e-02f, -1.00248992e-01f, 3.46904434e-02f, -6.87129200e-02f, 2.41585914e-02f, -4.94924448e-02f, -1.11432048e-02f, -3.60772535e-02f, 1.04458652e-01f,
  1.56747907e-01f, 3.21002044e-02f, -5.52389845e-02f, 3.14358205e-01f, 3.63866426e-02f, 1.80605203e-01f, 1.53037280e-01f, 1.45571202e-01f, 1.99210227e-01f, 1.56723827e-01f,
  3.69417042e-01f, 2.99639553e-01f, 7.75083080e-02f, -6.60204515e-02f, -4.15445352e-03f, -1.47564873e-01f, 9.19303820e-02f, -1.78226709e-01f, -1.79638222e-01f, 8.95808488e-02f,
  -5.87824546e-02f, 1.20435931e-01f, 1.60138354e-01f, 1.04168728e-01f, 6.34099245e-02f, 4.84858826e-02f, 1.40672252e-02f, 1.32416502e-01f, 5.31241484e-02f, 1.45140901e-01f,
  2.32667804e-01f, -6.24396950e-02f, -1.20842770e-01f, -7.73974508e-02f, 9.41755176e-02f, -2.98561994e-02f, 2.27449894e-01f, -4.70010675e-02f, -1.07090265e-01f, -4.22299504e-02f,
  -1.89875081e-01f, -3.49616148e-02f, -1.60162197e-03f, -1.01724029e-01f, -1.55923992e-01f, -2.19762817e-01f, -6.33012578e-02f, -4.79885899e-02f, 2.69535631e-01f, 2.29899958e-01f,
  1.02403253e-01f, -9.90746021e-02f, -9.67003703e-02f, -1.65195465e-01f, 3.73652801e-02f, 1.31644100e-01f, -1.53048895e-02f, 1.13930199e-02f, -1.50562320e-02f, 1.12680815e-01f,
  1.50991917e-01f, 6.67398199e-02f, -4.53011841e-02f, -8.65988061e-02f, 3.30723487e-02f, 2.61435118e-02f, 1.68769360e-01f, 2.46200800e-01f, 2.21986100e-01f, -1.78650357e-02f,
  1.52990669e-01f, -9.79783386e-03f, -9.45428088e-02f, 2.39560306e-02f, 1.63170919e-02f, -1.27499439e-02f, -1.07222855e-01f, 6.37175590e-02f, -1.59613311e-01f, -1.36523306e-01f,
  -1.39484003e-01f, 2.42135320e-02f, -9.97041911e-02f, -1.05875256e-02f, 2.37193093e-01f, 7.40482584e-02f, 2.89305925e-01f, 1.20398447e-01f, 1.39825478e-01f, 4.02761176e-02f,
  -1.22076049e-02f, -2.91456897e-02f, -7.46077895e-02f, 8.02421123e-02f, 1.93876326e-01f, 5.23612555e-03f, -7.74510130e-02f, 2.62272328e-01f, -4.07906659e-02f, 1.87656373e-01f,
  3.72927278e-01f, -2.43595932e-02f, 1.52004227e-01f, 8.27008858e-02f, 1.25156015e-01f, 1.03941515e-01f, -3.12435534e-02f, 1.14514485e-01f, -4.06345539e-02f, -2.96216719e-02f,
  -1.51698843e-01f, -1.13365566e-02f, 2.33171687e-01f, 7.14298189e-02f, 4.54598635e-01f, 5.20436801e-02f, -5.07992227e-03f, 1.12638779e-01f, 4.10704128e-02f, -6.93434030e-02f,
  -6.62399679e-02f, -1.40675545e-01f, -4.16652001e-02f, -1.00860618e-01f, -5.89222126e-02f, -6.80317953e-02f, 2.05918755e-02f, -8.95931795e-02f, 1.32948151e-02f, -6.49706274e-02f,
  2.08415002e-01f, 4.69667353e-02f, 2.01107875e-01f, 1.55933173e-02f, 8.87824297e-02f, 1.56923637e-01f, -2.04076134e-02f, 1.72234982e-01f, -3.63577902e-03f, -3.69210541e-02f,
  6.69366568e-02f, -1.27002433e-01f, 8.92507955e-02f, -1.64037803e-04f, -8.69539008e-02f, 9.04895086e-03f, 1.80794537e-01f, -1.94273442e-01f, 2.05105707e-01f, -2.26072833e-01f,
  2.19164148e-01f, -9.50750411e-02f, -2.91617513e-02f, -6.12810662e-04f, -1.17521286e-01f, -5.74987642e-02f, -2.06808314e-01f, 1.32859675e-02f, -1.49595916e-01f, -4.60438170e-02f,
  -9.98468325e-02f, -3.98898125e-02f, -2.89067216e-02f, 3.89414489e-01f, 2.05493256e-01f, -3.74440737e-02f, 1.14337459e-01f, 1.87216215e-02f, 3.02059442e-01f, -1.18853222e-03f,
  4.87588756e-02f, -4.95267622e-02f, 2.20767289e-01f, 1.78153217e-02f, -2.01202139e-01f, -1.88518539e-02f, 1.14859249e-02f, -2.09294543e-01f, 1.54775679e-01f, 1.83098391e-02f,
  1.16885737e-01f, 1.74848720e-01f, 3.44579108e-02f, 3.22223216e-01f, -4.84247766e-02f, -9.19764563e-02f, 4.43271324e-02f, -3.43377218e-02f, 3.27780843e-01f, -1.16220236e-01f,
  2.91228704e-02f, -2.39730924e-02f, -6.18735813e-02f, 5.38122654e-02f, 4.15816195e-02f, -1.66766171e-03f, -1.06420822e-01f, -7.75367320e-02f, 2.25205310e-02f, 7.88319558e-02f,
  -3.70388776e-02f, -8.59637111e-02f, 1.94148812e-02f, -7.38681331e-02f, -3.72286029e-02f, 1.58809930e-01f, 1.55905709e-01f, -1.00587159e-01f, -4.41183597e-02f, 1.22352883e-01f,
  1.56818867e-01f, 8.16572532e-02f, 5.00770696e-02f, -6.65944517e-02f, 1.30044207e-01f, -5.77978678e-02f, 1.43939435e-01f, 1.00860156e-01f, -1.02251232e-01f, -4.73481826e-02f,
  1.69235006e-01f, -8.26766789e-02f, -5.63768260e-02f, 2.10979283e-02f, 2.19779536e-02f, 8.67430493e-02f, -6.91916868e-02f, 5.10837100e-02f, 2.26948969e-02f, -4.30076160e-02f,
  2.39283264e-01f, 8.28774571e-02f, 1.76765192e-02f, 4.43021655e-02f, -8.49730074e-02f, -4.88852337e-02f, 4.92375828e-02f, 6.25780523e-02f, 3.22967544e-02f, 1.35124743e-01f,
  -1.30564108e-01f, -1.51160643e-01f, -4.44307998e-02f, -3.17683211e-03f, 4.40087020e-02f, 1.06014132e-01f, -3.63798104e-02f, 6.73899846e-03f, -4.87800725e-02f, -4.42222171e-02f,
  5.55029046e-03f, 1.90965664e-02f, 3.02574504e-02f, -8.69037025e-03f, 2.54495367e-02f, 3.12039722e-02f, -2.28920151e-02f, 1.33492842e-01f, 4.64408435e-02f, 1.02975769e-02f,
  7.47049227e-02f, 9.83548351e-04f, -2.16711983e-02f, 9.53161418e-02f, -1.06045350e-01f, -7.62808844e-02f, -4.05890904e-02f, -8.29928145e-02f, -3.35326232e-02f, -9.07751322e-02f,
  -4.17918488e-02f, 6.83965161e-02f, -3.83484364e-02f, 1.40728667e-01f, 1.35700271e-01f, 5.95571510e-02f, -6.07275553e-02f, -1.29360110e-01f, 2.66338699e-02f, 3.35858613e-02f,
  -1.50136650e-01f, 1.20478906e-02f, -4.97648865e-02f, 4.97519150e-02f, 7.40445266e-03f, 6.69883639e-02f, -1.27682332e-02f, -2.79560108e-02f, -1.00056985e-02f, -3.91301215e-02f,
  -5.65087795e-02f, 1.71732128e-01f, 2.23665312e-02f, -7.88997486e-02f, -6.69981465e-02f, -8.10981914e-03f, 1.91275209e-01f, -1.09106287e-01f, 6.17048964e-02f, 8.88135731e-02f,
  1.30072668e-01f, 1.96950044e-02f, -8.66751932e-03f, 1.19828030e-01f, -4.60346825e-02f, -1.79001078e-01f, 6.94459828e-04f, 9.37402919e-02f, 5.71974143e-02f, 1.86667472e-01f,
  1.23363517e-01f, 6.23566546e-02f, 5.79228215e-02f, 5.27040176e-02f, 6.59641400e-02f, -4.69342396e-02f, 1.39810279e-01f, -3.01843863e-02f, 9.42995623e-02f, -1.01591669e-01f,
  9.96423885e-02f, 7.12612085e-03f, 5.22544421e-02f, -9.34526101e-02f, 1.32860765e-01f, 9.68973269e-04f, 1.44537076e-01f, -4.07054015e-02f, -1.51620463e-01f, -1.24625765e-01f,
  -2.27841899e-01f, -6.68464005e-02f, -1.32317126e-01f, 3.27190273e-02f, 2.10413143e-01f, 1.72482096e-02f, -1.26269355e-01f, -9.73419324e-02f, -7.16946796e-02f, 7.96955451e-02f,
  5.51120937e-02f, -1.82214558e-01f, 5.90076745e-02f, -3.15971635e-02f, -1.27240852e-01f, -5.78906350e-02f, 1.18509181e-01f, -9.38919932e-02f, -7.13894591e-02f, -3.83872329e-03f,
  -9.42253768e-02f, 6.75489604e-02f, 7.87492618e-02f, 5.67687713e-02f, -7.18137771e-02f, 2.72024572e-01f, 2.28509128e-01f, -1.18256528e-02f, 2.40914166e-01f, -9.79222581e-02f,
  3.47733051e-01f, 4.28426042e-02f, -4.76413183e-02f, -6.50318563e-02f, 3.31235975e-02f, -6.39523268e-02f, -1.55626297e-01f, 7.15320185e-03f, -4.64126244e-02f, -1.19984582e-01f,
  -5.88257387e-02f, 2.28981506e-02f, 2.08235025e-01f, 1.89494208e-01f, -1.30858272e-02f, 2.43667021e-01f, 6.41526207e-02f, -2.40414172e-01f, 3.47376168e-02f, -1.83615759e-02f,
  2.46225327e-01f, 1.94493514e-02f, -7.21968189e-02f, -1.38006248e-02f, 1.13677867e-02f, -9.70698670e-02f, -6.04635701e-02f, -3.76577266e-02f, 2.77005769e-02f, -1.20909333e-01f,
  1.01023488e-01f, -4.45251428e-02f, -5.47601022e-02f, 1.11208975e-01f, -3.40836570e-02f, -9.19041261e-02f, -8.91565830e-02f, -5.08853719e-02f, -1.05451815e-01f, 5.90079799e-02f,
  -1.24563806e-01f, -8.76333341e-02f, 8.08340311e-02f, -9.09578726e-02f, -1.01330295e-01f, 2.75876056e-02f, -1.06822688e-03f, -1.13109104e-01f, -1.23934597e-01f, 9.12052172e-04f,
  -1.44468118e-02f, -6.49852380e-02f, 1.06168270e-01f, -3.17853577e-02f, 2.88892500e-02f, 7.13602155e-02f, -1.81885678e-02f, 1.15005509e-03f, -9.48179960e-02f, -7.83717930e-02f,
  3.01797614e-02f, 1.20564662e-01f, 5.06260013e-03f, -6.04379587e-02f, -9.42371488e-02f, -6.52114069e-03f, -7.26907700e-02f, 6.68502077e-02f, -7.08349273e-02f, -5.44980839e-02f,
  5.56797013e-02f, -1.08977063e-02f, 9.33559686e-02f, 8.12215433e-02f, 2.31394311e-03f, 9.89323407e-02f, -5.40631525e-02f, -5.71264811e-02f, 1.20828919e-01f, -1.27603918e-01f,
  -4.08977009e-02f, -1.28083408e-01f, -1.66890603e-02f, 6.48771077e-02f, 6.53557032e-02f, -7.15814307e-02f, -1.14876613e-01f, -1.69739481e-02f, 3.32956128e-02f, 6.03012368e-02f,
  -8.50218907e-02f, -4.97036166e-02f, 1.05673932e-01f, -8.75680819e-02f, -1.13554865e-01f, -3.44638787e-02f, 6.52282387e-02f, -7.46938065e-02f, 1.23039342e-03f, 2.13928502e-02f,
  -9.17383004e-04f, -8.12561512e-02f, 4.38106433e-02f, -1.02429688e-01f, 9.40825045e-02f, -7.94890374e-02f, 6.52758107e-02f, 4.54030782e-02f, 1.16265759e-01f, -1.20393358e-01f,
  -2.37683132e-02f, 3.01529504e-02f, -1.08158395e-01f, 5.98043092e-02f, -1.19413160e-01f, 4.68165725e-02f, -4.88998480e-02f, -8.36684033e-02f, 7.97520876e-02f, -2.30297800e-02f,
  -7.04166666e-02f, -1.07609011e-01f, -6.47040159e-02f, -8.31157640e-02f, -5.82250431e-02f, -1.03100687e-01f, 3.00982855e-02f, 8.31591412e-02f, -9.28408429e-02f, 5.84431328e-02f,
  -1.00870259e-01f, -2.97420304e-02f, -3.73036191e-02f, -4.73382846e-02f, -4.67575528e-02f, 8.62648264e-02f, 4.27387990e-02f, 4.31762487e-02f, 1.92773230e-02f, -1.52572487e-02f,
  1.48715405e-03f, -7.41293430e-02f, 7.92686939e-02f, -1.09898485e-01f, 6.78708032e-02f, 1.22865558e-01f, 1.19551711e-01f, -7.51406923e-02f, 1.14240937e-01f, -9.19697136e-02f,
  1.16314776e-01f, 5.84697584e-03f, 9.38198622e-03f, -8.85953456e-02f, -3.06490120e-02f, -8.06735307e-02f, -7.31984377e-02f, -9.59444642e-02f, -9.79563668e-02f, 1.88657064e-02f,
  -1.30857110e-01f, 1.30477874e-03f, 1.13118753e-01f, 3.57978158e-02f, 1.30117506e-01f, 4.71971184e-02f, 3.75290401e-02f, 1.08941831e-01f, 4.32965793e-02f, -7.40927737e-03f,
  -7.62401521e-02f, -4.81757484e-02f, -5.92572317e-02f, -2.10548341e-02f, -5.56816719e-02f, 1.29863948e-01f, 6.14304580e-02f, -6.44522086e-02f, 6.25517517e-02f, -9.98203382e-02f,
  -3.57810147e-02f, 8.24614540e-02f, 5.41601777e-02f, 7.43952245e-02f, -6.29346222e-02f, 4.45684455e-02f, -3.60947917e-03f, 7.72756636e-02f, -8.99102911e-02f, -7.41582876e-03f,
  8.10965747e-02f, 2.24954858e-02f, 1.91759448e-02f, -1.29743785e-01f, -4.50239182e-02f, -5.77373132e-02f, 1.85405295e-02f, 2.14534495e-02f, 5.48215723e-03f, 9.63941514e-02f,
  -9.95160341e-02f, 3.61406691e-02f, -7.91762024e-02f, 1.41868619e-02f, 6.81684986e-02f, -6.49483576e-02f, 1.64277796e-02f, -5.95509745e-02f, 9.78070050e-02f, 1.03010900e-01f,
  1.09526284e-01f, 1.00387514e-01f, -1.80826746e-02f, -3.88916512e-03f, -1.23814359e-01f, -1.03967600e-01f, 1.23066315e-02f, 3.71479057e-02f, 1.85435101e-01f, 1.74866691e-01f,
  1.05115637e-01f, 3.99904847e-02f, 1.03859827e-01f, 3.96499634e-02f, 5.16223162e-02f, 8.52819160e-02f, 1.45882577e-01f, 1.69347033e-01f, -6.75729588e-02f, -9.74842254e-03f,
  -1.64296299e-01f, 1.98144570e-01f, -9.74494126e-03f, -1.99983910e-01f, 9.96448025e-02f, -2.26070791e-01f, 5.39297760e-02f, -1.28229365e-01f, -2.65319496e-01f, -3.69796306e-01f,
  -8.67771059e-02f, 1.23079643e-01f, 1.10714808e-01f, -2.56148539e-02f, 5.74529171e-02f, 1.84475496e-01f, 1.76679362e-02f, 6.01442009e-02f, -8.25538635e-02f, -3.13769728e-01f,
  -3.77361551e-02f, 1.59607098e-01f, -4.06120211e-01f, 1.08940363e-01f, -2.85795480e-01f, -1.22221157e-01f, -9.92921069e-02f, 9.55995694e-02f, 1.06561117e-01f, 9.91547406e-02f,
  1.38299555e-01f, 1.38828471e-01f, -2.44049709e-02f, -5.42617887e-02f, -2.60140181e-01f, 1.67569622e-01f, -1.99529529e-01f, 1.15392506e-01f, -1.29104301e-01f, -4.05078270e-02f,
  1.13874488e-01f, 3.90322953e-01f, -8.00417289e-02f, 1.66332543e-01f, -2.67068055e-02f, 3.49504560e-01f, 3.00814569e-01f, 1.13479726e-01f, -1.13997698e-01f, 2.54300445e-01f,
  -1.19117834e-01f, 3.85097228e-02f, 1.30850971e-02f, -1.01506174e-01f, -2.40113698e-02f, -9.15238336e-02f, -1.13608249e-01f, 4.63471636e-02f, 3.99930999e-02f, -1.09193698e-01f,
  5.22601120e-02f, 1.22615069e-01f, -1.18450522e-01f, -2.74329763e-02f, 1.23958373e-02f, 1.18195333e-01f, 7.04393238e-02f, -8.63514319e-02f, 6.36876225e-02f, 1.92775242e-02f,
  -2.23887395e-02f, -1.11422658e-01f, -4.11767587e-02f, -1.01507261e-01f, -7.04837069e-02f, 1.00432195e-01f, -6.98487833e-03f, -1.04216874e-01f, -8.81400481e-02f, 1.06269009e-02f,
  -1.73948079e-04f, -6.26127869e-02f, 6.52904510e-02f, -5.95518686e-02f, 2.60047093e-02f, 2.54463479e-02f, -1.17261313e-01f, -1.19708002e-01f, 4.12001796e-02f, -1.11985952e-01f,
  -7.20847920e-02f, 9.16113108e-02f, -4.88014221e-02f, -1.20696023e-01f, -8.81003961e-02f, -1.04322948e-01f, -3.26524153e-02f, 1.23015009e-01f, -6.77547976e-02f, -4.18495722e-02f,
  9.55992788e-02f, -1.50707169e-02f, 1.51858311e-02f, -4.18389402e-02f, 1.02912433e-01f, -1.17529966e-01f, 1.14285767e-01f, -4.31580432e-02f, -1.78429000e-02f, -1.51559925e-02f,
  1.23622373e-01f, 6.40915558e-02f, -3.63840386e-02f, 1.05359092e-01f, 1.68060347e-01f, -5.06856618e-03f, 1.69923648e-01f, 1.39429644e-01f, 1.20200858e-01f, 1.60469934e-01f,
  1.83252364e-01f, 9.24165547e-02f, -3.16916071e-02f, -1.89072993e-02f, 9.18502361e-02f, 6.83565587e-02f, -1.28495798e-01f, -8.76714066e-02f, -7.46708959e-02f, -9.73036811e-02f,
  -1.60758227e-01f, -1.20623959e-02f, 6.35884106e-02f, -9.16071981e-02f, 1.56018570e-01f, -9.66470391e-02f, 1.67455405e-01f, 1.48095312e-02f, -1.69985965e-01f, 6.63457513e-02f,
  -4.30686064e-02f, -1.00543005e-02f, -1.99352309e-01f, 1.83881894e-01f, 2.63472516e-02f, 1.12204365e-01f, 6.19381033e-02f, -1.65763915e-01f, 1.00907385e-01f, 1.44430444e-01f,
  8.90341625e-02f, -9.75917429e-02f, -1.64372280e-01f, -5.48974387e-02f, 1.05202720e-02f, -6.83254153e-02f, 1.25750244e-01f, 3.65517708e-03f, 2.95249373e-02f, -4.42676768e-02f,
  -1.21404216e-01f, -1.23093906e-03f, -1.29346922e-01f, -1.46637335e-01f, 2.26966888e-01f, -1.20043620e-01f, 8.53530467e-02f, 2.72976141e-02f, 9.34061781e-03f, 9.55354646e-02f,
  8.45702458e-03f, -7.34668151e-02f, 1.19362816e-01f, -1.37358353e-01f, 2.05565259e-01f, -7.35254064e-02f, 1.10474057e-01f, 4.91557084e-02f, -5.08276969e-02f, 1.07051045e-01f,
  1.12229191e-01f, -6.18402585e-02f, -1.82670414e-01f, 1.63232967e-01f, -1.02065176e-01f, 1.76410809e-01f, 1.68431640e-01f, 1.45055205e-01f, 3.88841517e-03f, 1.51856855e-01f,
  1.37186721e-01f, 2.10389286e-01f, 1.13549113e-01f, 3.69860604e-02f, 2.22850516e-01f, 3.05318385e-02f, 4.20882814e-02f, 2.17227861e-02f, -3.80804315e-02f, 9.17271897e-03f,
  -2.85316408e-01f, -1.21883333e-01f, 1.41628176e-01f, 1.27933487e-01f, 8.52794647e-02f, 6.64840871e-03f, 2.01100722e-01f, 1.16494261e-01f, 8.39715153e-02f, -1.48198670e-02f,
  -4.94865216e-02f, -6.04275763e-02f, 2.03715209e-02f, -2.95640733e-02f, -1.63894191e-01f, 8.30117315e-02f, 5.59891202e-03f, -1.20890900e-01f, -1.56162009e-01f, -4.59301956e-02f,
  -5.83343673e-03f, 6.95337057e-02f, -5.04766069e-02f, 3.80077288e-02f, 1.24536365e-01f, 5.16358539e-02f, 1.28803119e-01f, 5.20457141e-02f, -9.70729291e-02f, -1.21141799e-01f,
  4.81381156e-02f, -8.19479525e-02f, 1.15423515e-01f, 1.74300119e-01f, -5.98291717e-02f, 3.13614123e-03f, 1.84041411e-02f, 1.69594154e-01f, -8.16868618e-03f, -1.05645530e-01f,
  5.51708788e-02f, 1.11423150e-01f, -7.83572868e-02f, 8.13262090e-02f, -2.46467199e-02f, -2.39383522e-02f, -1.11138977e-01f, -1.01624385e-01f, 9.91316214e-02f, -4.45140898e-02f,
  -1.13742538e-02f, -9.30581391e-02f, -4.62342519e-03f, -1.20727815e-01f, -4.99175936e-02f, 6.39624149e-02f, 9.27309617e-02f, -6.36350811e-02f, -3.38570960e-02f, -5.91383427e-02f,
  7.41082802e-02f, 1.70611013e-02f, 9.74137783e-02f, -6.42610714e-02f, -6.11008890e-02f, -3.32814641e-02f, -1.13300011e-01f, 9.67390239e-02f, -1.24963127e-01f, 1.12350704e-02f,
  -2.84737404e-02f, 4.27724421e-02f, -1.88465193e-02f, -3.53343450e-02f, 7.96299875e-02f, 1.46061301e-01f, 4.37997170e-02f, -7.52227455e-02f, 8.87795985e-02f, 1.09934643e-01f,
  1.00444905e-01f, -4.65033501e-02f, 4.74965461e-02f, -7.25559220e-02f, -1.01249486e-01f, 5.68043776e-02f, 3.21009755e-02f, 2.49210596e-02f, 2.30694190e-02f, -1.15049057e-01f,
  9.71765518e-02f, -1.01144157e-01f, 1.82451550e-02f, 1.70860104e-02f, -9.61119831e-02f, 1.25167653e-01f, 7.92640373e-02f, 6.83574099e-03f, 4.54376750e-02f, -6.36596754e-02f,
  6.30583614e-02f, 1.18176788e-02f, -1.25658922e-02f, 1.03020668e-01f, -7.00733513e-02f, 4.23741899e-02f, 1.17083460e-01f, 1.02093726e-01f, 2.29396358e-01f, 1.29406214e-01f,
  5.16421907e-02f, 6.96150661e-02f, 2.50127852e-01f, -1.79193038e-02f, 2.27443948e-01f, 1.32512644e-01f, -3.61237489e-02f, 2.05916002e-01f, 3.91863585e-02f, 3.67721692e-02f,
  1.91753803e-04f, 1.46946922e-01f, 1.00516677e-01f, -2.01588973e-01f, 2.47692987e-02f, -1.82574749e-01f, 2.13367250e-02f, 1.48613276e-02f, -2.66628027e-01f, -1.08748086e-01f,
  -2.21569501e-02f, -2.70416364e-02f, -4.39291894e-02f, -5.38823344e-02f, 3.65174189e-02f, 3.91006991e-02f, -1.23144880e-01f, 5.70332855e-02f, -1.00489423e-01f, -2.12729156e-01f,
  9.18530822e-02f, -7.36342892e-02f, -1.49248138e-01f, -4.54529189e-02f, -1.20766856e-01f, 3.57389599e-02f, -6.78533763e-02f, -7.46548250e-02f, 5.95607907e-02f, 5.05655482e-02f,
  -1.40466139e-01f, 1.87433630e-01f, -1.39571860e-01f, -1.02801099e-01f, -1.38671055e-01f, 1.52830943e-01f, 2.51227943e-03f, 7.63994157e-02f, -4.14301790e-02f, -1.65420830e-01f,
  -1.08435631e-01f, 4.18266237e-01f, -7.78236017e-02f, 1.85740516e-01f, -2.64885370e-02f, 3.12527567e-01f, 2.29882181e-01f, 5.70185669e-02f, -6.87076198e-03f, 1.93472490e-01f,
  1.31421939e-01f, 1.81363642e-01f, 6.00399487e-02f, 2.41608351e-01f, 1.43391550e-01f, 1.68568641e-01f, 2.04960629e-01f, -5.63022010e-02f, 7.03196302e-02f, 1.82078883e-01f,
  1.14114314e-01f, 1.73505113e-01f, 1.52358323e-01f, -3.36441435e-02f, -1.44972265e-01f, -2.26841673e-01f, -1.43721206e-02f, 1.89569116e-01f, 1.10481985e-01f, -2.13449169e-02f,
  2.40904480e-01f, 9.32487920e-02f, 8.33677053e-02f, 1.78345531e-01f, 1.79332584e-01f, 8.10009614e-02f, -5.26304878e-02f, -2.35890113e-02f, -2.21825629e-01f, 6.20771796e-02f,
  -4.71642278e-02f, 2.56294012e-03f, -1.34315670e-01f, 1.12011515e-01f, 9.80316997e-02f, 6.27765879e-02f, 3.80654186e-01f, -9.82243568e-02f, 2.07257837e-01f, 2.64644474e-02f,
  7.65578374e-02f, -1.08498394e-01f, 1.04558423e-01f, -2.56490111e-02f, 7.03658685e-02f, -3.69999856e-02f, -2.98058521e-03f, 7.67252371e-02f, 1.83110699e-01f, -8.59654471e-02f,
  5.29207945e-01f, 4.98026572e-02f, 8.63610953e-02f, 3.24608088e-02f, 3.46333832e-02f, 1.25570163e-01f, 3.95143181e-02f, -3.65894549e-02f, -4.55396287e-02f, -2.50534713e-01f,
  4.55215164e-02f, 1.13947853e-01f, -8.02306682e-02f, -4.08190787e-02f, 4.84758094e-02f, 7.97355548e-02f, 7.30489567e-02f, -9.99623463e-02f, 3.73705886e-02f, -1.84088331e-02f,
  -2.60885507e-02f, -5.83517477e-02f, -8.71486403e-03f, 1.65831335e-02f, 4.52615060e-02f, 6.22931421e-02f, -1.04232565e-01f, 1.01096801e-01f, 3.95546481e-02f, -4.16961908e-02f,
  -7.22995400e-02f, -2.06805840e-02f, 4.71516885e-02f, 4.67033163e-02f, -1.04178853e-01f, 9.01860371e-02f, 6.47230670e-02f, 5.12655377e-02f, -3.80338281e-02f, 1.02804430e-01f,
  1.17124945e-01f, -6.83784205e-03f, 7.98695013e-02f, -1.00436345e-01f, 1.39206305e-01f, -6.74479604e-02f, -5.36472350e-02f, -3.69326919e-02f, 3.78408805e-02f, 2.08419282e-02f,
  4.76789847e-02f, -4.77600060e-02f, 1.07768439e-02f, -1.64346751e-02f, -7.89586082e-02f, -9.28934664e-02f, 4.87377681e-02f, -3.32285278e-02f, -1.18126318e-01f, -8.61535817e-02f,
  -6.50411705e-03f, -1.20768189e-01f, 8.33524317e-02f, 9.23772231e-02f, -6.86091930e-02f, 1.05758816e-01f, -1.17732823e-01f, -6.23160340e-02f, 1.09645374e-01f, -4.31407169e-02f,
  8.45464841e-02f, -2.66252514e-02f, -2.23758165e-03f, 2.10574362e-02f, -1.29198566e-01f, -7.97909051e-02f, 1.06144212e-01f, -5.57356514e-02f, 1.90262254e-02f, 1.05077691e-01f,
  -6.67776540e-02f, -2.41845008e-02f, 2.94416118e-02f, -9.43830684e-02f, 9.60365906e-02f, -8.55807886e-02f, 1.25593902e-03f, 1.56347543e-01f, 1.01457611e-01f, -1.14264108e-01f,
  8.37242305e-02f, -1.26458108e-01f, -1.10744566e-01f, -7.35018775e-02f, -5.77542670e-02f, 7.25255767e-03f, 1.40509203e-01f, -7.62479305e-02f, 1.19917430e-01f, -1.93966746e-01f,
  2.27709651e-01f, -3.12379710e-02f, -2.24464964e-02f, 6.24497980e-02f, -4.18745913e-03f, 8.52112100e-02f, -2.04156265e-01f, -4.46657203e-02f, -1.11015327e-01f, 4.12111878e-02f,
  -3.33126485e-02f, 1.78525671e-01f, -2.70822551e-02f, 2.24020816e-02f, 1.53384730e-01f, -4.04509529e-02f, 4.27138731e-02f, 7.14282766e-02f, 2.11763203e-01f, 1.65543407e-02f,
  3.94775830e-02f, 9.02272612e-02f, 1.55202344e-01f, 4.55701277e-02f, -4.31758873e-02f, 1.42963797e-01f, 3.99232209e-02f, -2.23392233e-01f, 2.56897897e-01f, -3.54483202e-02f,
  -7.06091970e-02f, 1.29667908e-01f, 5.88241331e-02f, 6.31610677e-02f, 2.33561881e-02f, -9.36082602e-02f, -1.56555817e-01f, -2.49307334e-01f, 1.33649781e-01f, 1.21276947e-02f,
  1.37094222e-02f, -6.27547875e-02f, 1.03544243e-01f, -1.01147585e-01f, -7.42898509e-02f, -8.13542008e-02f, -3.48276906e-02f, -8.20459705e-03f, -1.06315456e-01f, 8.57066065e-02f,
  9.91466492e-02f, 4.60038371e-02f, 7.69178271e-02f, 6.65857568e-02f, -6.04303889e-02f, 4.56981845e-02f, -1.14162937e-02f, 2.23129559e-02f, -4.24028523e-02f, 4.25097570e-02f,
  -1.06390126e-01f, -5.21296002e-02f, -4.54498790e-02f, -4.26713601e-02f, 1.22915305e-01f, -1.07664607e-01f, -5.65795153e-02f, 4.53047790e-02f, 6.81191236e-02f, -1.00197069e-01f,
  -5.74205816e-02f, -1.24724716e-01f, 6.26985505e-02f, -1.02065869e-01f, 5.34423627e-02f, -1.04528181e-01f, -6.68833330e-02f, 2.64143962e-02f, -7.58795813e-02f, 1.20952442e-01f,
  -8.40029493e-02f, -4.91764918e-02f, 1.03306726e-01f, 7.56765753e-02f, 1.44761978e-02f, 2.26725359e-02f, -1.07434699e-02f, 2.26359386e-02f, -6.98720589e-02f, 9.15890336e-02f,
  -5.33837862e-02f, -6.08434416e-02f, -7.86786377e-02f, 7.85440356e-02f, 1.01431645e-01f, -1.52843026e-02f, -1.03156583e-03f, -5.48217893e-02f, 7.58720115e-02f, -6.55031428e-02f,
  5.63854445e-03f, 1.27965361e-01f, -8.77924412e-02f, -9.47969127e-03f, -8.25503990e-02f, 9.47028100e-02f, 1.47572961e-02f, -3.37588973e-02f, 9.78400279e-03f, -3.00403424e-02f,
  -9.24520642e-02f, 1.26467422e-01f, -6.55620992e-02f, 1.95497811e-01f, 8.92134607e-02f, 4.68922593e-03f, -5.69026656e-02f, 2.01285213e-01f, 3.23959365e-02f, 4.97685075e-02f,
  -4.16389517e-02f, 1.56728864e-01f, 4.54259142e-02f, -2.19242632e-01f, -1.70658976e-01f, -6.83372468e-02f, -7.92478994e-02f, -1.26744024e-02f, -4.60999757e-02f, 2.67790351e-02f,
  8.68171751e-02f, -6.03615232e-02f, -1.09450296e-01f, 1.03438027e-01f, 1.35496825e-01f, 6.16331771e-02f, 1.54856905e-01f, 5.03113829e-02f, -5.12958951e-02f, 4.09465879e-02f,
  -2.49530897e-02f, -1.05771042e-01f, 9.23481956e-02f, 4.58067060e-02f, 2.06597485e-02f, -7.74203315e-02f, -7.40502551e-02f, -2.89809313e-02f, -9.56207514e-02f, 9.16256830e-02f,
  -1.77656338e-01f, 1.31026775e-01f, 1.64147660e-01f, -1.97525565e-02f, -4.66989614e-02f, 1.92711413e-01f, -1.64932340e-01f, 8.40800479e-02f, 1.24250077e-01f, -1.10970296e-01f,
  -6.97456524e-02f, 1.71303883e-01f, -4.75970507e-02f, 4.76791039e-02f, 1.71707317e-01f, 3.17711294e-01f, 7.22627267e-02f, 1.42316639e-01f, 6.01416640e-02f, -1.05812252e-01f,
  8.34817886e-02f, -1.36618868e-01f, -1.41315132e-01f, -5.09280339e-02f, -1.57254953e-02f, -6.79078475e-02f, -1.59050953e-02f, -3.03812120e-02f, 3.32109071e-02f, 5.70381060e-02f,
  1.09378166e-01f, -3.76569405e-02f, 5.77754900e-02f, -5.04516847e-02f, 8.50212947e-02f, 8.46918225e-02f, 2.60974746e-03f, 7.83488527e-03f, -3.40208896e-02f, 1.91725232e-02f,
  4.28999215e-02f, -7.72601441e-02f, 9.49342176e-02f, 6.04544990e-02f, 1.15711764e-01f, 6.05778024e-02f, 3.90790179e-02f, -5.45202978e-02f, -9.86636654e-02f, 6.34091571e-02f,
  -6.56892136e-02f, -3.19747929e-03f, 1.14940312e-02f, 3.08849923e-02f, -6.11927435e-02f, 3.08490936e-02f, -2.58065090e-02f, -3.26301008e-02f, 3.57024488e-04f, -7.68021587e-03f,
  1.05886690e-01f, 2.22174153e-02f, 9.79300309e-03f, 6.72526881e-02f, -1.59327835e-02f, 1.28192350e-01f, 8.22551399e-02f, 2.53169779e-02f, 1.28957793e-01f, 3.02013420e-02f,
  3.21580470e-03f, 1.22512460e-01f, -5.84558770e-03f, 1.28514087e-02f, 4.05714323e-04f, -3.33424658e-02f, 1.21901065e-01f, -1.37822786e-02f, 1.21781148e-01f, -1.52885271e-02f,
  -1.17371909e-01f, 7.28286877e-02f, -2.31390987e-02f, 2.04263628e-02f, -1.08932637e-01f, -5.84110133e-02f, 3.81352678e-02f, 8.00467581e-02f, -2.24297456e-02f, -5.25981607e-03f,
  -1.38090476e-02f, -4.94210944e-02f, 4.64628600e-02f, -1.05567388e-01f, 6.42807633e-02f, -6.16310872e-02f, -1.33035839e-01f, 6.98476806e-02f, 4.94527966e-02f, -3.96015197e-02f,
  -8.31866413e-02f, 9.25563052e-02f, 7.02594742e-02f, -2.91920900e-02f, -1.14779338e-01f, -5.62663265e-02f, -6.98855473e-03f, -1.71688825e-01f, 1.49230305e-02f, 6.80276528e-02f,
  4.34653461e-02f, -5.47396801e-02f, 4.02527563e-02f, 1.58475339e-02f, -9.34213698e-02f, 4.80280668e-02f, 9.24870670e-02f, -7.07400292e-02f, -1.13618679e-01f, 9.28778797e-02f,
  -1.34404227e-01f, 6.07170090e-02f, -9.89941210e-02f, 2.97562983e-02f, 1.80033892e-01f, -8.34727883e-02f, 6.52380884e-02f, -1.11230366e-01f, 1.31246090e-01f, 4.32323702e-02f,
  -8.48424286e-02f, 7.70891493e-04f, 5.71893342e-02f, 5.90613037e-02f, -9.75653343e-03f, 9.02706932e-04f, -6.77837478e-03f, -8.42020568e-03f, 1.44781312e-02f, 5.55309504e-02f,
  1.15704797e-01f, -1.00148208e-01f, 4.24941741e-02f, -5.22565320e-02f, 1.86391741e-01f, -1.17549650e-01f, 8.83622989e-02f, -1.09013908e-01f, -4.94146794e-02f, 1.74003571e-01f,
  4.31789756e-02f, -1.09346077e-01f, 1.48826569e-01f, 8.39328207e-03f, 9.73207802e-02f, 1.87097788e-01f, 3.06419749e-02f, -2.58014426e-02f, 7.58471936e-02f, -9.41651016e-02f,
  1.13550149e-01f, 1.77449048e-01f, -7.33122453e-02f, 4.54336926e-02f, 1.55533671e-01f, -5.18684834e-02f, -5.71666509e-02f, 8.83906931e-02f, -6.28582984e-02f, 4.83326018e-02f,
  -8.85129720e-02f, 1.03100739e-01f, 4.02697250e-02f, 9.83180702e-02f, -3.88381816e-02f, -1.53461233e-01f, 2.67105907e-01f, 1.17750140e-02f, 5.77023327e-02f, 1.79679573e-01f,
  3.74463126e-02f, 4.37585823e-02f, -4.05759551e-02f, 1.28547952e-01f, -1.03447892e-01f, -9.72815156e-02f, 5.92024885e-02f, -5.62712885e-02f, 1.12248696e-01f, -1.09279715e-01f,
  -9.71100181e-02f, -3.13145667e-02f, -4.47661094e-02f, 1.45566031e-01f, 5.25778867e-02f, 1.47751361e-01f, -8.97047147e-02f, 1.25558540e-01f, -8.97348598e-02f, -1.11834615e-01f,
  -1.32168874e-01f, 1.41121790e-01f, -4.21445295e-02f, 2.53631081e-02f, -1.22941904e-01f, 1.08321495e-01f, 6.16591051e-02f, 2.20683351e-01f, 1.41501978e-01f, 5.81430271e-02f,
  -3.16653773e-02f, 3.05861328e-02f, 2.67505020e-01f, 2.35514581e-01f, 1.11120224e-01f, 2.45721519e-01f, 2.02177152e-01f, 2.72976488e-01f, 5.21419523e-03f, 2.54762948e-01f,
  2.91977942e-01f, 1.32868156e-01f, 2.65761137e-01f, 3.15900594e-01f, -6.67882636e-02f, -3.27075064e-01f, -1.33510008e-01f, -1.27068013e-01f, -8.30512643e-02f, -3.19492459e-01f,
  -1.33809119e-01f, 8.70642439e-02f, 2.80505091e-01f, 1.44321978e-01f, 3.43181133e-01f, 1.82593450e-01f, 2.13282891e-02f, 1.03553506e-02f, 1.10502727e-01f, 2.96341419e-01f,
  -2.48904184e-01f, -1.13698699e-01f, 2.12640792e-01f, -1.44693032e-01f, 6.03383370e-02f, -7.95404986e-02f, -4.94752824e-02f, 3.85577500e-01f, 3.12196970e-01f, 2.20755674e-02f,
  -1.23637699e-01f, -7.57986605e-02f, 7.24411802e-03f, 2.70306859e-02f, -1.62466522e-02f, -8.02338347e-02f, -3.17743063e-01f, -3.11838776e-01f, -1.79759026e-01f, 6.02807328e-02f,
  2.65018851e-01f, 1.66172415e-01f, 1.34476706e-01f, -1.10401213e-01f, 2.96568513e-01f, -3.66226882e-01f, -1.29951611e-01f, 2.99963862e-01f, -9.31899473e-02f, -9.06947181e-02f,
  1.20285071e-01f, 3.77791785e-02f, 8.18979554e-03f, 8.05999786e-02f, 5.38001359e-02f, -9.12678391e-02f, -1.94223803e-02f, -2.26474758e-02f, -5.60550727e-02f, -1.80002734e-01f,
  -3.90287198e-04f, -1.39515892e-01f, 3.22033502e-02f, -1.86285805e-02f, 3.70540284e-02f, -6.45030141e-02f, -2.69408256e-01f, -3.56521383e-02f, -1.40398860e-01f, -2.95655616e-02f,
  1.26090363e-01f, 1.85981482e-01f, -1.24357402e-01f, 2.10368596e-02f, 7.90512636e-02f, -1.01374380e-01f, -1.46908127e-02f, -1.78055495e-01f, -5.49571589e-02f, -2.09041629e-02f,
  2.03590821e-02f, -1.60469785e-01f, 1.08313456e-01f, -1.42625049e-01f, -6.05635606e-02f, -2.24755883e-01f, -3.13376775e-03f, -1.07122213e-01f, -2.45668143e-02f, 1.17862314e-01f,
  1.51040358e-02f, 9.93157029e-02f, 7.75143206e-02f, 3.73234525e-02f, 4.23692465e-02f, -9.24661979e-02f, 2.20486596e-01f, 1.38988167e-01f, -7.58432820e-02f, -9.59444139e-03f,
  -6.11957088e-02f, 1.50689408e-01f, -7.99112245e-02f, -3.00459191e-02f, -2.88305711e-02f, 7.43047744e-02f, -2.89586913e-02f, 6.02450594e-03f, 5.43755144e-02f, 4.24189158e-02f,
  3.03815175e-02f, 6.30954206e-02f, -1.26857171e-02f, -1.54420495e-01f, -2.48771757e-02f, 1.47368535e-01f, 1.41309023e-01f, -6.40083104e-02f, -7.77726322e-02f, -8.03210437e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  1.50828436e-01f, -6.25138432e-02f, -7.20326453e-02f, -1.37170460e-02f, 5.33639714e-02f, -1.10255316e-01f, 5.49103599e-03f, 6.11856803e-02f, 3.17536034e-02f, -6.37799427e-02f,
  7.96617270e-02f, -6.07835613e-02f, -9.11438987e-02f, -9.96294171e-02f, -8.19014087e-02f, 8.80624354e-02f, 1.23474851e-01f, 1.16658553e-01f, -5.76843321e-02f, -4.36203368e-02f,
  9.21272784e-02f, -1.12538591e-01f, 6.06019460e-02f, 7.35939527e-03f, 7.79731795e-02f, -8.31716061e-02f, 1.83051139e-01f, -5.17585948e-02f, -2.02446841e-02f, 4.82047312e-02f,
  1.14348121e-01f, -5.00504300e-02f, -8.68981108e-02f, -6.18001726e-03f, 1.73544958e-01f, -6.41023964e-02f, 1.02672026e-01f, 1.40667364e-01f, 2.51828820e-01f, -2.92775221e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -2.79909402e-01f, -2.56164730e-01f, -3.29417065e-02f, -2.37643763e-01f, -2.50031829e-01f, -1.51162595e-01f, -1.65253654e-01f, -2.27978259e-01f, 1.57048330e-01f, -2.20743179e-01f,
  5.42549826e-02f, -2.62333095e-01f, -3.48929651e-02f, 2.52273947e-01f, -2.31956825e-01f, 1.81680754e-01f, 4.46955919e-01f, -1.60305366e-01f, 8.99798870e-02f, -1.31978974e-01f,
  -1.35225832e-01f, 1.21386640e-01f, -1.52712567e-02f, -3.86080295e-02f, -4.35709506e-01f, 7.29261935e-02f, 1.06155157e-01f, -1.63588785e-02f, -7.97079131e-02f, 2.48132765e-01f,
  -2.67655909e-01f, -8.42392221e-02f, -1.74673751e-01f, 8.23699608e-02f, 7.32807398e-01f, -4.89465483e-02f, 1.97899938e-01f, -8.42929631e-02f, 9.51160789e-02f, -2.30769232e-01f,
  2.58283734e-01f, -3.33384097e-01f, 1.87756360e-01f, -6.07765503e-02f, 4.02979143e-02f, -1.01163739e-03f, -3.72434445e-02f, 1.78215839e-02f, -3.08425635e-01f, 1.19829802e-02f,
  -1.10303804e-01f, -1.93670452e-01f, 8.62951800e-02f, -2.19801724e-01f, 2.21104637e-01f, -4.24718596e-02f, 1.77469030e-02f, -1.42981270e-02f, -2.55792797e-01f, 4.66058031e-02f,
  -1.04152009e-01f, -1.70194283e-01f, -2.40096405e-01f, 7.79644623e-02f, -2.75778566e-02f, -5.14591523e-02f, -6.21963479e-02f, 1.21759607e-04f, 2.06152827e-01f, -2.38140464e-01f,
  3.53380404e-02f, 1.58285439e-01f, -7.29892775e-02f, -5.62978759e-02f, 9.34184641e-02f, -4.77441512e-02f, -2.23329678e-01f, 3.07476729e-01f, -7.90839195e-02f, -1.51319116e-01f,
  -2.31353566e-01f, -9.84150823e-03f, 1.67007893e-01f, 4.57213707e-02f, 4.37895894e-01f, -1.90260187e-01f, -8.25533550e-03f, 2.69138455e-01f, -2.63957143e-01f, 5.50971851e-02f,
  6.07614592e-02f, -1.20548703e-01f, -7.01129660e-02f, 1.64756775e-01f, -2.32552901e-01f, -6.91326037e-02f, -9.24782529e-02f, 1.14172779e-01f, -5.92562705e-02f, 3.06288693e-02f,
  2.67928485e-02f, -1.04439422e-01f, 9.07602832e-02f, -4.38485086e-01f, 3.48359942e-01f, 4.15667951e-01f, 2.10806370e-01f, 1.60564274e-01f, 4.33994442e-01f, 9.17427149e-03f,
  1.60780810e-02f, 1.04042470e-01f, -1.15774378e-01f, 2.68733315e-03f, -1.50193395e-02f, -1.24289677e-01f, 7.57107511e-02f, -1.92974910e-01f, 2.74944603e-01f, 8.27018637e-03f,
  3.84762973e-01f, 6.30129054e-02f, -4.37565923e-01f, -9.22532603e-02f, 1.99200269e-02f, -8.70861951e-03f, -5.55188894e-01f, 2.59996891e-01f, 1.74955651e-02f, -3.58985667e-03f,
  2.17900798e-02f, -2.83691406e-01f, 2.70119756e-01f, -2.13831812e-01f, 3.16978276e-01f, 3.36171091e-01f, 1.43873706e-01f, -1.46553099e-01f, -4.66365218e-02f, 3.75226319e-01f,
  -2.33504444e-01f, -1.41921103e-01f, 3.88647348e-01f, -2.92669326e-01f, -1.04686074e-01f, -5.26865840e-01f, 5.73791303e-02f, 1.60400465e-01f, -2.60178030e-01f, 2.71908194e-01f,
  1.49984255e-01f, 3.12290668e-01f, -7.05929771e-02f, -5.26703447e-02f, -1.66070629e-02f, 1.20042600e-01f, -2.14569196e-02f, 2.69735791e-02f, 6.88842162e-02f, -1.21576741e-01f,
  1.60277694e-01f, 3.00233036e-01f, 3.01784426e-01f, -1.88718870e-01f, 9.32617784e-02f, 8.55424851e-02f, 8.25559422e-02f, 2.53183693e-01f, -4.71758991e-02f, 5.16607251e-04f,
  1.38098449e-01f, -5.73030710e-02f, 1.21287681e-01f, 6.10043406e-02f, -5.31034209e-02f, 6.96217567e-02f, -2.73593187e-01f, 4.25835187e-03f, -5.18315434e-02f, 2.32144490e-01f,
  -1.89206246e-02f, 1.42398164e-01f, 9.00188386e-02f, -6.81132078e-02f, -2.04833105e-01f, 4.78199981e-02f, 1.85110331e-01f, 6.95370361e-02f, 1.57795902e-02f, 4.08208221e-02f,
  -8.65579173e-02f, 1.01460516e-01f, 3.40273887e-01f, 4.68644127e-02f, 3.84875298e-01f, 1.93001181e-01f, 2.87470907e-01f, -2.88346618e-01f, 1.64079264e-01f, -7.92738050e-02f,
  -5.82893379e-02f, 2.06134334e-01f, -8.57978314e-02f, 2.64040202e-01f, 2.98308916e-02f, -6.51331916e-02f, -3.49316210e-01f, -3.24599475e-01f, 1.92112342e-01f, -7.34965354e-02f,
  7.78070241e-02f, 2.86425799e-01f, -4.96051669e-01f, 2.62667656e-01f, 3.06601256e-01f, -2.09974438e-01f, -1.57824799e-01f, 7.32150748e-02f, -4.78531197e-02f, 2.31363028e-01f,
  9.55717117e-02f, 5.86911365e-02f, -1.22007795e-01f, 9.81477946e-02f, -4.22676951e-02f, -1.71423405e-01f, 1.01785637e-01f, 1.89215377e-01f, 1.52826995e-01f, 8.36592242e-02f,
  6.10902011e-02f, 4.38166082e-01f, 1.07497744e-01f, -7.88700134e-02f, -1.65833563e-01f, -2.08305970e-01f, 9.92408395e-02f, 7.63942152e-02f, -1.22732326e-01f, -3.73751633e-02f,
  -3.20019305e-01f, -3.03639211e-02f, -2.53332973e-01f, -1.11691177e-01f, -1.10636823e-01f, -2.89761666e-02f, -4.90635866e-03f, -9.43620503e-02f, -1.21171325e-01f, 8.22466705e-03f,
  1.34655848e-01f, -1.34553745e-01f, 4.42179330e-02f, 2.90258136e-02f, 8.59864235e-01f, 9.00357664e-02f, -1.79082260e-01f, 1.34619027e-02f, 1.62179083e-01f, -3.23248118e-01f,
  -4.56035733e-02f, 6.25516027e-02f, -3.34906340e-01f, -3.56370121e-01f, -2.76303947e-01f, -1.39216855e-01f, 1.48676142e-01f, 1.50605127e-01f, -3.20792288e-01f, 4.23887670e-02f,
  1.84709370e-01f, -7.15512261e-02f, 5.82855582e-01f, -6.08756803e-02f, 2.15593204e-01f, 4.45753857e-02f, -2.80099027e-02f, -2.29261406e-02f, 1.47280013e-02f, -3.80446106e-01f,
  9.49090198e-02f, 4.80617508e-02f, -7.76669085e-02f, 1.25826433e-01f, 4.84617241e-02f, -6.11082166e-02f, 2.82174852e-02f, -1.96320079e-02f, 1.38911203e-01f, 1.21051431e-01f,
  5.30080318e-01f, 3.04694343e-02f, -1.38670402e-02f, 8.45070928e-02f, -6.78901598e-02f, 2.60224730e-01f, 1.24035448e-01f, -4.74466264e-01f, -9.98319834e-02f, 5.14213629e-02f,
  -2.79983222e-01f, 1.18681841e-01f, 5.71647771e-02f, -8.10705051e-02f, -2.86080509e-01f, -1.29917625e-03f, -8.85450616e-02f, 1.81299716e-01f, -9.20811519e-02f, -4.56033289e-01f,
  6.56709895e-02f, 8.37861151e-02f, -2.89902121e-01f, 1.78237073e-02f, 2.24992588e-01f, -7.04872096e-03f, 1.05358727e-01f, 8.66944119e-02f, 2.74555653e-01f, 3.39771993e-02f,
  3.17475677e-01f, 1.18444480e-01f, -1.59062758e-01f, 1.09108090e-01f, 2.32742190e-01f, 5.11222035e-02f, 1.48531362e-01f, 3.27350497e-01f, 4.41835701e-01f, 8.96095634e-02f,
  9.25789550e-02f, -3.32162291e-01f, -6.71881065e-02f, -2.38465428e-01f, -5.23295701e-01f, -2.61789829e-01f, -3.16293269e-01f, -2.23003477e-01f, 3.20255250e-01f, 1.87620595e-01f,
  1.90359816e-01f, -3.24595332e-01f, -1.77056208e-01f, -2.32924402e-01f, 4.00242135e-02f, 2.41878256e-01f, -1.26681924e-01f, 1.83746964e-01f, -1.28771542e-02f, 1.55836508e-01f,
  -3.76044780e-01f, -2.05326919e-02f, -1.93495348e-01f, -9.85196326e-03f, 1.01804949e-01f, 2.46057153e-01f, -7.66773075e-02f, -6.22947626e-02f, -7.19347671e-02f, 1.60873592e-01f,
  1.58062965e-01f, 9.22546014e-02f, 8.39254633e-02f, 5.74467070e-02f, -7.73218349e-02f, -4.20712158e-02f, -9.24832597e-02f, -3.89922522e-02f, 6.05911855e-03f, 2.00112369e-02f,
  8.56131911e-02f, -1.07916750e-01f, -8.50324482e-02f, -2.01892316e-01f, 4.56658036e-01f, 7.32867643e-02f, 2.90714532e-01f, 1.23269372e-01f, -9.53757763e-02f, 4.12480868e-02f,
  -1.42982498e-01f, 2.35606909e-01f, 2.52560914e-01f, -3.28259081e-01f, 9.21493918e-02f, -1.19869433e-01f, -3.64860147e-01f, -1.37618765e-01f, 1.37481079e-01f, 3.85417789e-01f,
  9.57692340e-02f, 6.06137887e-02f, -2.08805799e-01f, -2.19286203e-01f, -2.87539879e-04f, -1.04040973e-01f, 1.04954518e-01f, 8.64757411e-03f, 1.18403614e-01f, -3.73092204e-01f,
  -2.99762666e-01f, 2.22218096e-01f, -6.01449534e-02f, -2.64512300e-01f, -3.01222950e-01f, 3.26053083e-01f, -6.95690960e-02f, 4.39496450e-02f, 2.37360537e-01f, 3.92969511e-03f,
  -2.13630125e-01f, 1.25990853e-01f, 1.89179685e-02f, -1.10154331e-01f, 4.21314925e-01f, -8.62637684e-02f, 4.41259742e-01f, -4.90769632e-02f, -6.58979297e-01f, 9.03460663e-03f,
  -1.37503192e-01f, -2.46078111e-02f, 9.84044746e-04f, -9.09935236e-02f, -4.68249559e-01f, -2.75681287e-01f, -7.06844777e-02f, -2.09049493e-01f, -1.49533972e-01f, -1.13278985e-01f,
  -2.31976677e-02f, -8.97853374e-02f, 5.01797140e-01f, 8.13382119e-02f, -2.18764022e-01f, 2.40549490e-01f, -1.10957444e-01f, 5.55491567e-01f, -3.22873086e-01f, 6.29729256e-02f,
  -1.04498222e-01f, 8.43237638e-02f, 1.46206468e-01f, 9.35688391e-02f, 6.12259768e-02f, -4.09319401e-02f, -4.62173879e-01f, 2.56781541e-02f, -2.29679972e-01f, -8.38049278e-02f,
  -1.66860223e-02f, 1.84045732e-01f, -2.40858138e-01f, -2.15473086e-01f, -2.99494743e-01f, -1.60371378e-01f, 7.14576337e-03f, 1.34863879e-03f, -1.71531007e-01f, -2.37611204e-01f,
  2.28852138e-01f, 9.78702381e-02f, 4.41575170e-01f, 4.20858085e-01f, -4.25468683e-02f, 4.05196965e-01f, -1.93340346e-01f, -3.41187388e-01f, -1.32306514e-03f, -1.31879356e-02f,
  8.23723301e-02f, 1.78746730e-01f, -6.89320266e-02f, -1.15250172e-02f, 3.13532889e-01f, 3.47402692e-02f, 4.84700408e-03f, -4.75934036e-02f, 1.58833206e-01f, 8.71243253e-02f,
  3.85878608e-02f, 1.20806612e-01f, -2.11151034e-01f, -7.68694133e-02f, -1.09494783e-01f, 3.07279453e-02f, 8.98864213e-03f, -5.68623424e-01f, -5.00433564e-01f, 1.05780974e-01f,
  9.18087810e-02f, 9.31762457e-02f, 3.41790229e-01f, -1.00739941e-01f, 9.76148397e-02f, -1.06662810e-01f, 4.36271250e-01f, -1.12264171e-01f, -1.61927119e-01f, 1.71186253e-01f,
  -8.53045732e-02f, 2.88118392e-01f, -5.03690124e-01f, 9.90105271e-02f, -1.68707520e-01f, 1.01378210e-01f, 1.06359616e-01f, -1.13190621e-01f, 1.29318580e-01f, 2.06610098e-01f,
  -2.90165603e-01f, 3.67075473e-01f, -1.51060954e-01f, -1.16296619e-01f, 7.22175464e-02f, 6.18629195e-02f, -1.38133764e-01f, -1.51643828e-01f, -2.57606983e-01f, -3.34750384e-01f,
  -4.73893210e-02f, -2.75314093e-01f, -8.97111073e-02f, -2.94406917e-02f, 1.04819775e-01f, 6.72382340e-02f, -2.30378464e-01f, 5.94376624e-01f, 1.69158224e-02f, 4.36332345e-01f,
  -2.45882690e-01f, -9.63995531e-02f, 9.88191068e-02f, -2.85323203e-01f, 1.20820133e-02f, -2.95495749e-01f, 1.15912288e-01f, 1.79205745e-01f, 2.07773581e-01f, -2.15985119e-01f,
  -2.22758409e-02f, 5.36435880e-02f, -1.76948443e-01f, -8.00669566e-02f, -2.23564014e-01f, -4.47938055e-01f, -3.90657067e-01f, 2.93694437e-01f, 1.09626517e-01f, 5.26309460e-02f,
  -9.87081304e-02f, -1.44607678e-01f, -1.85107574e-01f, 3.78158987e-01f, 7.51051083e-02f, 2.22201914e-01f, 2.98646152e-01f, -7.13922409e-03f, 6.42880723e-02f, 3.80452797e-02f,
  4.19948727e-01f, 3.72664742e-02f, 4.65722054e-01f, -3.30647439e-01f, 1.07538618e-01f, -3.12981904e-02f, -9.64083895e-02f, -1.62798241e-02f, 1.69437990e-01f, -1.59967355e-02f,
  -8.81618336e-02f, 9.67475474e-02f, 2.44296402e-01f, -1.67258710e-01f, 1.59119591e-01f, 3.82114612e-02f, 3.79228406e-02f, 1.38703242e-01f, -1.26714423e-01f, -1.73255339e-01f,
  2.50592321e-01f, 4.29312587e-02f, 5.66391498e-02f, -3.77401188e-02f, -1.84869468e-01f, -1.97195828e-01f, 5.71075045e-02f, -5.77648133e-02f, -2.45190695e-01f, 1.69793263e-01f,
  -4.48623039e-02f, 5.13412692e-02f, 2.03748062e-01f, -2.51351923e-01f, 2.46989548e-01f, 1.99433655e-01f, 2.64267437e-02f, -6.09944761e-02f, 6.61778525e-02f, 1.34245485e-01f,
  1.74299851e-01f, -8.26414302e-03f, 9.87916887e-02f, -1.08743705e-01f, 1.97818037e-02f, -1.63046345e-01f, 3.83450776e-01f, 6.33695871e-02f, 3.54107380e-01f, 3.19580823e-01f,
  2.24812955e-01f, -1.63623411e-02f, 1.21078409e-01f, 4.45057973e-02f, 3.25826779e-02f, 5.84386364e-02f, -3.78553689e-01f, -4.30667549e-01f, 7.78994635e-02f, -7.64454082e-02f,
  -3.44538480e-01f, -6.69395849e-02f, -5.88795915e-02f, 9.90129709e-02f, 1.50358364e-01f, 5.57092056e-02f, -7.50399753e-02f, 2.86329240e-01f, 2.96707675e-02f, 2.65921708e-02f,
  -5.38204908e-01f, -4.32139263e-03f, -1.38854623e-01f, 5.06845191e-02f, 2.73378462e-01f, -5.36339097e-02f, -3.82001661e-02f, 2.24751025e-01f, -4.32390243e-01f, -1.27954304e-01f,
  5.06282225e-03f, -2.88685083e-01f, -2.66454607e-01f, 2.05670729e-01f, -2.47569591e-01f, 4.88363683e-01f, -9.10668299e-02f, 1.70694992e-01f, 7.07438737e-02f, 1.02755807e-01f,
  4.45024930e-02f, -3.20944875e-01f, 3.26261260e-02f, -2.75709808e-01f, -1.29250646e-01f, 2.91188896e-01f, -4.45841625e-02f, -1.25241622e-01f, -1.54940516e-01f, -3.47865313e-01f,
  6.25279471e-02f, -7.06458883e-03f, -4.57362458e-02f, -2.03876466e-01f, -3.61390114e-01f, 1.73564896e-01f, -2.23481759e-01f, 6.20597936e-02f, -7.69665241e-02f, -1.92108154e-01f,
  -2.14224562e-01f, 8.18862393e-02f, -8.15242454e-02f, -4.09338951e-01f, -4.40101445e-01f, 2.46425241e-01f, -4.73107360e-02f, 2.02167174e-03f, 2.41398141e-02f, 9.21622738e-02f,
  2.95826823e-01f, 2.64589459e-01f, -8.78188461e-02f, 8.95058550e-03f, 1.84539348e-01f, -3.67260501e-02f, -1.15299590e-01f, -4.48234156e-02f, -3.26110214e-01f, 1.19248830e-01f,
  3.04357171e-01f, -9.04770792e-02f, -5.27593158e-02f, -1.20439313e-01f, 3.36788207e-01f, -7.38232359e-02f, 1.07097380e-01f, -9.80481412e-03f, -5.64818941e-02f, -7.29812160e-02f,
  -2.18118548e-01f, -4.87443596e-01f, 6.85521126e-01f, 9.11293402e-02f, 1.17507786e-01f, -3.79529446e-02f, 2.40357563e-01f, 1.89462066e-01f, -9.18210447e-02f, 3.71684283e-01f,
  2.08672330e-01f, 1.76339760e-01f, 3.24721396e-01f, 4.33612019e-02f, 8.96399468e-02f, 4.65285301e-01f, 1.40769824e-01f, -8.81314352e-02f, 8.60258788e-02f, -1.52551904e-01f,
  -2.46949777e-01f, 2.47612774e-01f, -9.62103233e-02f, -1.65635809e-01f, -1.33254975e-01f, -1.84876412e-01f, -5.15914559e-02f, 1.19759701e-01f, 1.67031959e-01f, -5.10152318e-02f,
  -7.01820180e-02f, -6.50592148e-02f, 3.57883051e-02f, 1.14263436e-02f, 2.75141150e-01f, -5.62317856e-02f, 2.77416348e-01f, -2.42794693e-01f, -4.31607485e-01f, 2.41834931e-02f,
  -1.70686573e-01f, 1.19839311e-01f, 2.79832594e-02f, 2.76880622e-01f, 5.24370745e-02f, 6.37710914e-02f, -1.53889254e-01f, -9.97833163e-02f, -2.87604541e-01f, 5.24912439e-02f,
  8.85200053e-02f, -1.21879131e-01f, 5.15681386e-01f, 4.01723608e-02f, 2.54993439e-01f, 8.51607248e-02f, -7.28139430e-02f, 3.97990286e-01f, 2.67145187e-01f, 1.13323770e-01f,
  -1.26332119e-01f, -1.19404513e-02f, -1.51575223e-01f, -6.67928234e-02f, 2.01149788e-02f, -1.54895186e-01f, 1.73060551e-01f, -2.49915078e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -6.48728833e-02f, -7.83344507e-02f, 2.85491701e-02f, 1.89177934e-02f, -1.12478947e-02f, -2.92343404e-02f, -1.08703226e-01f, -4.15852517e-02f, -7.75948763e-02f, -1.01689726e-01f,
  -1.21521264e-01f, -2.43205372e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    