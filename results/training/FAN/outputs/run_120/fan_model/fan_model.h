/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.17968105e-02f, 2.53686488e-01f, 1.89585220e-02f, 9.44487303e-02f, -4.97053564e-02f, -1.71099991e-01f, -3.07912119e-02f, 4.21101563e-02f, 1.57086760e-01f, 1.84640542e-01f,
  -1.75882235e-01f, 1.97690144e-01f, -1.30221605e-01f, -4.60231192e-02f, -2.27690563e-01f, -9.02458876e-02f, -1.66408643e-01f, -1.01120770e-01f, -2.49084663e-02f, -6.18386529e-02f,
  -8.44619274e-02f, -1.27707839e-01f, -2.38561630e-01f, 4.21468914e-02f, -3.85446735e-02f, 5.94913289e-02f, -1.37745038e-01f, -7.06719235e-02f, -1.47965685e-01f, 8.65296870e-02f,
  -5.63738197e-02f, 4.06176224e-02f, -2.01357588e-01f, -9.57093984e-02f, -1.42687485e-01f, -5.33478148e-02f, -1.46345794e-01f, -1.16480149e-01f, -4.27619591e-02f, 1.92156695e-02f,
  -6.48948103e-02f, 4.37079510e-03f, 4.23209406e-02f, -7.58909583e-02f, 7.89388940e-02f, 9.21545550e-02f, -4.18950543e-02f, -5.61537482e-02f, 2.84478813e-02f, -2.89152116e-02f,
  7.68165756e-03f, 3.68324853e-02f, 8.37661773e-02f, 1.13252914e-02f, 2.34725024e-03f, 6.00201786e-02f, 8.10810700e-02f, 1.04012685e-02f, 8.35255627e-03f, 1.43169954e-01f,
  -2.07723286e-02f, -3.75198312e-02f, 1.88001525e-02f, -6.21145405e-03f, 1.85083095e-02f, 4.22754325e-02f, 1.42995879e-01f, 3.13950889e-02f, 5.19951954e-02f, -7.01045096e-02f,
  -2.40479875e-02f, -5.21914251e-02f, -2.50527188e-02f, -2.08722875e-02f, -5.42817526e-02f, 3.90704870e-02f, -1.06381066e-01f, -1.33424075e-02f, 6.17176294e-02f, -3.93607803e-02f,
  -2.81715281e-02f, 3.42225283e-02f, -2.62400811e-03f, -2.78954413e-02f, 3.35725136e-02f, -1.08490838e-02f, 6.16818527e-03f, 7.67412595e-03f, -1.01549067e-01f, -1.03159547e-01f,
  -6.97685033e-02f, 5.54574840e-02f, -6.30744025e-02f, -7.53063783e-02f, 3.73641960e-02f, -4.55784090e-02f, -1.35080338e-01f, -3.14077325e-02f, -1.12215104e-02f, 3.42250965e-03f,
  -1.01924248e-01f, -7.69762173e-02f, 7.94275105e-02f, 5.06043024e-02f, -8.73923674e-03f, 9.26632062e-02f, -8.89389717e-04f, -6.88385293e-02f, 9.29778367e-02f, 8.33874643e-02f,
  -4.83910879e-03f, 1.10351285e-02f, -2.48195603e-02f, -4.24473025e-02f, -9.81082581e-03f, -5.35102654e-03f, -2.04870999e-02f, 4.64089885e-02f, -2.36432049e-02f, 4.10651714e-02f,
  1.17996216e-01f, -1.34624749e-01f, -1.57268703e-01f, 1.34934455e-01f, 2.16829970e-01f, 6.16840720e-02f, 3.34880017e-02f, 1.61148518e-01f, 5.07385423e-03f, 9.49275959e-03f,
  9.91204232e-02f, -1.87182382e-01f, -1.57098696e-01f, 9.74127874e-02f, 6.33812472e-02f, -1.60944924e-01f, 1.91637382e-01f, 6.71503425e-04f, 8.98361392e-03f, 1.53147891e-01f,
  -7.15746209e-02f, 2.87655175e-01f, -1.14189938e-01f, 9.55988914e-02f, 2.04781175e-01f, -9.98798534e-02f, 1.89686403e-01f, -1.61986902e-01f, 1.37898713e-01f, 3.36039551e-02f,
  1.04111940e-01f, -2.38004932e-03f, -4.37150896e-02f, -5.02282940e-02f, 8.94921571e-02f, -2.09489185e-02f, -2.25939136e-02f, -6.96234554e-02f, 3.56721282e-02f, 3.07038575e-02f,
  -2.04346981e-03f, 4.45144065e-02f, 7.54507259e-02f, -1.01889662e-01f, 1.32560544e-02f, -4.57084971e-03f, 1.00833029e-01f, -5.62915355e-02f, 4.97885458e-02f, 1.42563516e-02f,
  -2.25690491e-02f, 1.01867476e-02f, 2.63536740e-02f, 9.42892022e-03f, -6.94185346e-02f, -2.96624582e-02f, -3.12797204e-02f, -4.28721830e-02f, 9.77891982e-02f, -1.19083654e-02f,
  -1.76143516e-02f, 5.26878424e-02f, 1.90215912e-02f, 8.15805197e-02f, 1.97200123e-02f, 1.57185365e-02f, 4.83043604e-02f, 2.48066988e-02f, -4.90782112e-02f, 1.62158832e-02f,
  8.10742080e-02f, 1.97645314e-02f, 4.70128730e-02f, 2.34943684e-02f, 3.05355769e-02f, 3.68895717e-02f, 6.56621307e-02f, 5.32466210e-02f, 1.49126381e-01f, 6.55145794e-02f,
  -2.27379147e-02f, -2.67346241e-02f, 9.26084369e-02f, 2.63449978e-02f, 5.84113561e-02f, -7.88963363e-02f, 7.98084028e-03f, -1.93825737e-03f, 1.18855841e-01f, -2.42909268e-02f,
  8.11131857e-03f, -3.34305242e-02f, 7.81271257e-04f, 8.09160993e-02f, -4.06497065e-03f, -5.52544631e-02f, -9.95637998e-02f, -1.49118165e-02f, -4.65555349e-03f, -1.97487343e-02f,
  9.68840346e-02f, 7.76724964e-02f, 1.36245210e-02f, 2.71162130e-02f, -2.09603887e-02f, -2.61096619e-02f, 8.28473270e-02f, -4.69734240e-03f, 1.23018615e-01f, 1.06475085e-01f,
  3.75158228e-02f, 8.68532881e-02f, 3.02726831e-02f, -2.10474227e-02f, 4.67606857e-02f, 1.01976670e-01f, 2.13617762e-03f, -3.57786193e-02f, -4.81195264e-02f, 1.38199953e-02f,
  -7.96497911e-02f, 7.15925246e-02f, -2.14127392e-01f, 5.46650849e-02f, -7.08005726e-02f, -3.43257695e-01f, -2.18575895e-01f, -7.11946115e-02f, 2.00134143e-02f, 1.25723526e-01f,
  -1.35940136e-02f, 8.20285380e-02f, 2.09211297e-02f, -2.02093888e-02f, -2.43430123e-01f, 4.06295853e-03f, -1.95814848e-01f, -8.28239173e-02f, 1.27745360e-01f, -9.50727612e-02f,
  -2.44216733e-02f, 2.47417856e-03f, -1.71924993e-01f, 1.40363783e-01f, -4.14413176e-02f, 9.92383882e-02f, 8.63916352e-02f, 2.01960411e-02f, -1.50246531e-01f, -4.94559556e-02f,
  -7.96091557e-02f, 2.02289829e-03f, -2.52888631e-02f, -2.07544304e-02f, -1.73453718e-01f, -9.63090062e-02f, -1.42156631e-01f, -2.18366385e-02f, -5.61997518e-02f, 1.28796138e-03f,
  4.42913845e-02f, -1.83829423e-02f, 2.04270706e-02f, -4.25341539e-04f, 1.12143271e-02f, 5.86023889e-02f, 3.13059166e-02f, -1.18236855e-01f, -2.89733093e-02f, -1.72458999e-02f,
  -1.44704189e-02f, -4.12799641e-02f, 3.99733745e-02f, 6.02058768e-02f, 6.01088367e-02f, -2.92012887e-03f, -2.09556520e-02f, 2.34728251e-02f, -3.62415761e-02f, 6.43075034e-02f,
  2.71074697e-02f, 7.10523129e-02f, 3.85977253e-02f, -3.01249214e-02f, 8.53142887e-03f, -1.64894070e-02f, -1.66327842e-02f, 4.84305099e-02f, 1.23724990e-01f, -6.25352049e-03f,
  -5.57341464e-02f, -1.92052089e-02f, -3.44180763e-02f, -1.78724136e-02f, 3.80399674e-02f, -3.44414189e-02f, -1.15203317e-02f, 3.90972719e-02f, 1.26316715e-02f, -5.42155616e-02f,
  -6.80034107e-04f, 5.41389780e-03f, -2.93541085e-02f, -3.91502045e-02f, -4.66035381e-02f, 3.24970298e-02f, 5.05908988e-02f, 3.35313976e-02f, -3.57463509e-02f, -3.45672853e-02f,
  -2.76806653e-02f, 6.89652264e-02f, -2.56482866e-02f, -5.18403724e-02f, 9.97700170e-03f, -3.98232080e-02f, -6.11211210e-02f, 1.18120143e-03f, 1.55305490e-02f, 2.06570420e-02f,
  -1.82471294e-02f, 2.61119055e-03f, -9.12626833e-02f, 1.37510560e-02f, 6.97714388e-02f, 1.37321293e-01f, -5.61999939e-02f, 8.98541138e-03f, -1.94725879e-02f, 6.86266599e-03f,
  -4.30769995e-02f, -3.68891247e-02f, 5.47088124e-02f, -2.35617943e-02f, -7.16859894e-03f, -9.72023904e-02f, -2.48880293e-02f, -1.15006128e-02f, 4.69550043e-02f, -3.38249654e-02f,
  -1.17851995e-01f, -4.54691797e-02f, 5.26960492e-02f, 1.46637768e-01f, -1.10796154e-01f, 1.45724148e-01f, 3.05746287e-01f, -4.22852933e-02f, 7.94979557e-02f, 1.43664405e-01f,
  9.79353264e-02f, 1.02164000e-01f, -4.49927524e-02f, 2.56490141e-01f, 2.85949320e-01f, 1.44019142e-01f, 1.85401917e-01f, 9.07584056e-02f, -6.31446913e-02f, -8.50824714e-02f,
  5.79497125e-03f, 6.50127679e-02f, 1.54034227e-01f, -1.52872711e-01f, -7.25937411e-02f, -1.47007585e-01f, -6.76207319e-02f, 1.81907061e-02f, 1.03065126e-01f, 1.04700319e-01f,
  -6.46639988e-02f, -1.34497151e-01f, 4.92355204e-04f, 3.49301994e-02f, -5.46946824e-02f, 1.01495542e-01f, -6.11702017e-02f, 2.48595513e-02f, 5.54866940e-02f, -1.71970800e-02f,
  -2.44746841e-02f, -7.34935999e-02f, 6.64083436e-02f, 4.87991422e-02f, -1.06599502e-01f, 1.07626477e-02f, 8.02094415e-02f, 3.91457491e-02f, -3.09388358e-02f, 3.40341888e-02f,
  3.62728797e-02f, 8.51460323e-02f, -3.80196981e-02f, 2.74853967e-02f, 6.09592795e-02f, 7.08265677e-02f, 1.23955078e-01f, 5.90755530e-02f, 6.52896389e-02f, 2.54946332e-02f,
  -6.48880005e-02f, 4.92071128e-03f, 1.65748298e-02f, 3.83073522e-04f, -1.86959989e-02f, -6.65248744e-03f, 3.57905813e-02f, 4.38962989e-02f, -1.91581044e-02f, -2.87421588e-02f,
  8.09917897e-02f, -3.66932862e-02f, -4.31807153e-02f, 5.95824569e-02f, 1.94208603e-02f, -4.14671861e-02f, -1.07307084e-01f, -5.03870510e-02f, -2.48663258e-02f, 6.91622645e-02f,
  8.85040127e-03f, 3.30721634e-03f, -3.64311151e-02f, 2.61758100e-02f, -9.80815850e-03f, 5.59131205e-02f, -6.16110675e-02f, 3.24057811e-03f, 7.66481040e-03f, -4.46130820e-02f,
  -2.18755394e-01f, -1.58457533e-01f, 1.24514714e-01f, 3.11583374e-03f, -3.90007347e-02f, 7.51633421e-02f, 1.01756547e-02f, 6.81289658e-02f, -2.85585709e-02f, -4.96038608e-03f,
  -9.94669572e-02f, -1.24942111e-02f, -1.58273848e-04f, 1.03607103e-02f, 5.75943701e-02f, 5.70644736e-02f, -1.83827430e-02f, -2.97558494e-02f, -9.80057344e-02f, -7.13636354e-02f,
  -5.25029898e-02f, -5.39997704e-02f, -3.64265554e-02f, 2.43805721e-02f, 4.73296084e-03f, 1.85478162e-02f, -2.91242935e-02f, -1.99129526e-03f, 1.18280333e-02f, 3.42489104e-03f,
  1.95040599e-01f, -1.90421015e-01f, -4.59606349e-02f, 2.26690248e-01f, -5.90520278e-02f, -4.97023202e-02f, 4.53255847e-02f, -7.64200538e-02f, -1.15095628e-02f, -4.36754599e-02f,
  4.76490408e-02f, 6.09221905e-02f, -8.79626628e-03f, -3.19568068e-03f, 4.49909061e-01f, 1.19262286e-01f, 5.52858412e-02f, 1.16816171e-01f, -6.61036521e-02f, -3.74873094e-02f,
  3.71643230e-02f, 2.64488142e-02f, 1.00358829e-01f, -1.53304756e-01f, -1.03169203e-01f, -9.07500274e-03f, 1.55551881e-01f, 1.20121764e-03f, -4.52293046e-02f, -5.45702968e-03f,
  -9.75984931e-02f, -1.11977339e-01f, 9.43643600e-03f, -4.48889285e-02f, -3.77153250e-04f, -1.46097001e-02f, 1.19045161e-01f, -5.72186410e-02f, 1.24760242e-02f, -4.98075038e-02f,
  -1.83243938e-02f, 5.29020466e-02f, -1.24616260e-02f, 6.72729462e-02f, -3.64681222e-02f, 1.01517588e-01f, -2.84844860e-02f, 8.43700022e-02f, -1.75174121e-02f, 1.36476487e-01f,
  2.28485875e-02f, 4.63028066e-02f, -3.60109992e-02f, -2.14489419e-02f, 4.27598916e-02f, 4.06023599e-02f, 4.73446772e-02f, 3.69058959e-02f, 6.16315193e-02f, 8.06098357e-02f,
  -3.00327229e-04f, -3.49611491e-02f, -4.14818190e-02f, -5.33732958e-02f, -8.45349953e-02f, -8.65193903e-02f, -2.34971754e-02f, 4.00091056e-04f, 6.48166016e-02f, -4.58723456e-02f,
  4.22043204e-02f, -9.41864960e-03f, -2.94249170e-02f, -1.78965647e-03f, 4.42759730e-02f, 1.32646888e-01f, 1.22766998e-02f, -6.50673062e-02f, -2.63485499e-03f, 3.47495154e-02f,
  -4.40212898e-02f, 4.26839180e-02f, 2.79589463e-02f, 1.13112255e-04f, -4.80398946e-02f, 3.21614221e-02f, -7.43609592e-02f, -3.10522020e-02f, -1.10628642e-03f, -1.46863237e-02f,
  -9.46471617e-02f, -3.04755326e-02f, -5.67551702e-02f, -4.40691821e-02f, -1.05066583e-01f, -1.27449892e-02f, -1.39989480e-02f, 4.16699471e-03f, -1.18063137e-01f, -3.82566941e-03f,
  -6.94406927e-02f, -6.84431866e-02f, -3.80597599e-02f, 1.62573121e-02f, -8.32958147e-02f, 3.68797109e-02f, 4.29902188e-02f, 2.81984750e-02f, 2.30092388e-02f, -2.10664701e-02f,
  2.44828369e-02f, -1.86144989e-02f, 2.34839823e-02f, -4.73930202e-02f, -1.19854771e-02f, -2.05708481e-02f, 6.02251254e-02f, 2.27002483e-02f, 3.65537964e-02f, 3.33177485e-02f,
  1.48580465e-02f, 1.99290216e-02f, -1.55803159e-01f, -2.26700947e-01f, 8.27577114e-02f, -2.25467950e-01f, -1.34888813e-01f, -6.69235438e-02f, -1.21136956e-01f, 3.11822947e-02f,
  -1.10881113e-01f, -8.49941894e-02f, -9.05672554e-03f, -3.01189899e-01f, -2.57380933e-01f, -2.53365725e-01f, -1.48655966e-01f, -1.51513174e-01f, 7.42243975e-02f, 2.18336172e-02f,
  -5.15147038e-02f, 2.48659030e-02f, -8.47861171e-02f, 2.05594361e-01f, 3.98695236e-03f, 1.76586464e-01f, 1.82224646e-01f, 4.64983508e-02f, -5.28238937e-02f, -6.99599609e-02f,
  -8.23230371e-02f, 6.10499457e-02f, 5.53695634e-02f, 4.59977873e-02f, -1.80199221e-02f, 1.64071843e-02f, 7.98297077e-02f, 3.34097631e-02f, 3.03624873e-03f, -6.80853650e-02f,
  5.92428669e-02f, 7.92334825e-02f, -4.33202125e-02f, -2.12727189e-02f, -5.08164912e-02f, -1.19668312e-01f, 6.53939834e-03f, 1.32185258e-02f, 1.43817533e-02f, -1.59585029e-01f,
  -3.42266001e-02f, -1.39701307e-01f, -1.64777189e-02f, -1.55474976e-01f, 2.85749231e-02f, -1.14139386e-01f, -1.77846029e-02f, -8.43719915e-02f, -9.97729450e-02f, -7.73545504e-02f,
  -4.41231951e-02f, 6.92039356e-02f, -6.21508807e-02f, -1.35966642e-02f, 2.74119731e-02f, 8.85663480e-02f, 5.19597232e-02f, 3.03743221e-02f, 1.65251677e-03f, -2.56219995e-03f,
  -6.22089878e-02f, -2.46577561e-02f, -3.87400109e-03f, -5.46788126e-02f, -4.03224416e-02f, 1.30282585e-02f, 2.83608269e-02f, 5.18473648e-02f, -5.44465855e-02f, 5.06239338e-03f,
  2.32347623e-02f, 3.77073102e-02f, 3.23302411e-02f, 8.14851001e-02f, -9.55067500e-02f, -9.30918157e-02f, 7.12574348e-02f, -1.59664657e-02f, 1.32247014e-02f, -3.45202573e-02f,
  1.11808069e-01f, 2.07702100e-01f, 6.81925043e-02f, 4.77457270e-02f, -1.48014969e-03f, -8.77147689e-02f, 7.35860839e-02f, -2.67795008e-02f, 6.83056936e-02f, 9.62785073e-03f,
  4.69265543e-02f, 4.19358071e-03f, 6.49376735e-02f, -1.20874867e-02f, 5.03876321e-02f, -7.33230487e-02f, -5.61253540e-03f, 6.45470917e-02f, -3.14658321e-02f, 6.10974757e-03f,
  -1.81798935e-02f, -5.15842773e-02f, -3.01710088e-02f, -7.84511864e-02f, 1.00321226e-01f, 4.09521349e-02f, 8.50476995e-02f, -3.91603932e-02f, 7.75203630e-02f, -1.31169662e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.77273881e-02f, -3.76731120e-02f, -5.24522327e-02f, 5.51787438e-03f, 8.71754438e-02f, 5.59023991e-02f, -1.84304342e-01f, 1.22946158e-01f, -5.38443550e-02f, -3.79645936e-02f,
  7.01886276e-03f, -1.15646403e-02f, -1.92968309e-01f, 1.69336870e-01f, 1.26034170e-01f, -1.48703039e-01f, 1.46407753e-01f, -2.02231426e-02f, -9.44606066e-02f, 2.77786013e-02f,
  4.58682142e-03f, 1.71074226e-01f, 1.35487720e-01f, 2.24500313e-01f, 6.92888647e-02f, 1.86449841e-01f, 2.35502914e-01f, -2.42571030e-02f, 1.74263820e-01f, 1.02866113e-01f,
  -6.62995055e-02f, -4.88879308e-02f, -6.46152422e-02f, -1.42988205e-01f, 1.26534015e-01f, -1.06500357e-01f, -9.95625183e-02f, 9.38691199e-02f, -9.08041745e-02f, 7.00839981e-02f,
  -1.05122942e-02f, -5.84175996e-02f, 4.59950678e-02f, 2.56103892e-02f, 6.13107830e-02f, -1.22446683e-03f, 8.49025790e-03f, 5.03080338e-02f, 4.30058949e-02f, -6.70965016e-02f,
  6.67858943e-02f, 4.70413901e-02f, -1.26926709e-04f, 4.27334048e-02f, 8.50833803e-02f, 3.34865451e-02f, 4.37051766e-02f, 9.54179764e-02f, -2.78910734e-02f, 1.44516736e-01f,
  3.56267765e-02f, -2.73193885e-02f, -6.20583519e-02f, -1.29157200e-01f, -2.04397389e-03f, 6.37659151e-03f, -4.89889979e-02f, -2.49939039e-03f, -7.52690481e-03f, -3.43821347e-02f,
  -8.89558159e-03f, 7.97381476e-02f, 2.47601569e-02f, 5.21791875e-02f, 2.33198609e-02f, -1.75827723e-02f, -2.67652180e-02f, 5.34787262e-03f, 5.01821600e-02f, 3.20305042e-02f,
  -1.14504747e-01f, 1.41062871e-01f, 8.44654590e-02f, 1.15988567e-01f, 1.04358628e-01f, 2.13339813e-02f, -3.07088029e-02f, 4.92590200e-03f, 6.90999031e-02f, -5.91210946e-02f,
  1.36860773e-01f, 2.18757853e-01f, -1.10202730e-02f, -9.24561620e-02f, -1.76808443e-02f, 4.76361997e-03f, -8.33452567e-02f, 6.15908578e-02f, 4.31955941e-02f, 6.10643029e-02f,
  7.79440776e-02f, -5.77764809e-02f, 7.62218423e-03f, -2.45100223e-02f, 4.92175901e-03f, -9.30179469e-03f, -5.00167236e-02f, -3.46273668e-02f, 6.40763640e-02f, 7.55504593e-02f,
  4.41648178e-02f, 3.60455737e-02f, -4.86106910e-02f, -7.80401230e-02f, 5.07673956e-02f, 5.20262681e-03f, 1.06508151e-01f, 5.72736599e-02f, -6.84336871e-02f, 6.53381553e-03f,
  -2.62257487e-01f, 1.47358283e-01f, -3.08689505e-01f, 1.44142896e-01f, -2.77656257e-01f, 1.03908628e-01f, 2.96880782e-01f, -5.53001352e-02f, 1.34196177e-01f, 2.98255771e-01f,
  2.63761193e-01f, -5.96783757e-02f, 3.27051803e-02f, 4.19569999e-01f, -2.63931245e-01f, 2.58966208e-01f, 2.98739731e-01f, 2.76476055e-01f, -1.04422852e-01f, -9.64448974e-02f,
  -6.90940991e-02f, 1.35703057e-01f, -5.04416041e-03f, -7.17094019e-02f, -8.14147443e-02f, -1.85057491e-01f, 1.14232106e-02f, -2.51620263e-01f, 9.05335769e-02f, -1.68149155e-02f,
  -1.92969758e-02f, -6.76787049e-02f, -6.07563667e-02f, -1.03313215e-01f, -4.08326425e-02f, -1.28978565e-01f, -1.05373345e-01f, -6.79907724e-02f, -1.40231485e-02f, -7.11933151e-02f,
  2.58909389e-02f, -1.29517704e-01f, -1.22163054e-02f, -5.97366923e-03f, -2.75620688e-02f, -9.15838704e-02f, -7.27103045e-03f, 1.70060210e-02f, -6.62273318e-02f, -8.66560638e-03f,
  1.43365264e-02f, -3.70805361e-03f, 7.68775940e-02f, 2.49218643e-02f, 6.25917241e-02f, -3.79535444e-02f, 7.96274468e-02f, -1.12879872e-01f, 1.07267924e-01f, -5.69077730e-02f,
  -3.57025526e-02f, 2.91695585e-03f, 2.09962409e-02f, -6.32488728e-03f, -2.25544013e-02f, -3.88070755e-02f, -3.79038975e-05f, 3.30714285e-02f, -6.32338971e-02f, 3.07075400e-02f,
  1.84774641e-02f, 1.39245559e-02f, -1.58935413e-03f, 5.32112159e-02f, 4.03605737e-02f, 9.46600661e-02f, 4.44693007e-02f, -1.02459259e-01f, -1.39616895e-02f, 6.75384402e-02f,
  4.43056114e-02f, -1.24845110e-01f, 1.39063317e-02f, 1.02228567e-01f, 6.97625801e-02f, -2.41372734e-03f, -6.86304048e-02f, -4.87075895e-02f, 1.06307350e-01f, -1.21677354e-01f,
  3.04301875e-03f, -7.29292482e-02f, 3.06004416e-02f, -6.83113635e-02f, 6.20252341e-02f, 3.19266953e-02f, -6.24147505e-02f, -1.43308453e-02f, -4.50869054e-02f, 4.14246833e-03f,
  -2.46199835e-02f, 5.78463636e-02f, 5.07886373e-02f, 2.44136788e-02f, 1.63964611e-02f, -8.84065311e-03f, 3.53666991e-02f, -1.16673997e-02f, -2.76515968e-02f, 5.44711656e-04f,
  -4.69698049e-02f, -3.37403230e-02f, 5.58624417e-02f, 5.82708344e-02f, 1.20646574e-01f, -1.62706356e-02f, -1.03862911e-01f, -6.88618571e-02f, -7.71022141e-02f, 9.13041383e-02f,
  -1.44190013e-01f, 2.41595238e-01f, 3.59113336e-01f, -4.86185364e-02f, 1.97565377e-01f, 9.04303715e-02f, 1.05180994e-01f, 1.67256758e-01f, -2.08267719e-02f, -3.76685038e-02f,
  -1.82989135e-01f, 3.88371944e-02f, -1.10435717e-01f, -2.04146504e-02f, -5.25767021e-02f, 9.90661327e-03f, 5.68504408e-02f, -1.60798788e-01f, 8.72864760e-03f, -7.76522979e-02f,
  7.45422542e-02f, -1.00235693e-01f, 1.44762114e-01f, -5.53943291e-02f, 8.76834691e-02f, 2.23393533e-02f, -1.79290712e-01f, 5.67163527e-02f, -2.68358309e-02f, 5.29522002e-02f,
  -1.24332890e-01f, -5.14545478e-02f, -6.57950640e-02f, -5.40351570e-02f, -8.10866419e-04f, -8.25672224e-02f, -1.41491383e-01f, 1.49094108e-02f, -1.07810907e-02f, 2.26300247e-02f,
  -1.04061224e-01f, -1.09454200e-01f, -1.09746016e-03f, -6.13909587e-02f, 5.37532791e-02f, 3.47412005e-02f, 9.71499681e-02f, 1.72316447e-01f, 7.30633363e-02f, 1.09417289e-01f,
  1.22487284e-01f, 4.32108939e-02f, 4.13468108e-02f, 7.07624108e-02f, 3.07966787e-02f, 4.60595191e-02f, -1.11528961e-02f, 1.72844157e-02f, 1.84965879e-02f, 1.05610117e-01f,
  1.76711362e-02f, 2.91909128e-02f, 1.03355482e-01f, -2.48410646e-02f, 5.21213822e-02f, 1.84431765e-03f, -1.18776476e-02f, -1.50617212e-01f, -3.84185016e-02f, 8.50674510e-02f,
  4.62809205e-03f, -3.64491977e-02f, -1.10920474e-01f, -5.31115523e-03f, -5.54094389e-02f, -6.28710091e-02f, -3.44453864e-02f, 5.62944170e-03f, 2.77442653e-02f, 6.94720447e-02f,
  2.14125775e-02f, 2.51475386e-02f, 1.79718365e-03f, -4.19694521e-02f, 5.13559906e-04f, -1.26154557e-01f, -1.14838935e-01f, 3.74146290e-02f, -1.55052589e-02f, -7.17642996e-03f,
  -3.00420612e-01f, -2.50420302e-01f, -1.43667951e-01f, -8.10293332e-02f, 6.08008215e-03f, -6.50970414e-02f, -1.50717795e-01f, -1.22249387e-01f, -9.22499131e-03f, -1.13221340e-01f,
  -4.42893244e-03f, -4.50074747e-02f, -1.39461622e-01f, -7.54831731e-02f, 1.96104906e-02f, 5.65055571e-02f, -4.83506992e-02f, 3.10872085e-02f, -1.33332228e-02f, -1.28550464e-02f,
  -2.71864738e-02f, -5.46212830e-02f, 5.62377786e-03f, -4.24011312e-02f, -4.05497923e-02f, 3.79845873e-02f, 9.35002416e-03f, 7.48975351e-02f, 6.41414374e-02f, 1.90226603e-02f,
  -1.00485563e-01f, -2.05407236e-02f, -2.08728507e-01f, -2.38523960e-01f, -2.16329154e-02f, -8.61493796e-02f, -1.25277251e-01f, 1.07439131e-01f, -1.26840040e-01f, 3.17059606e-02f,
  6.37264922e-02f, -1.38565540e-01f, 1.31915778e-01f, -5.26203886e-02f, -2.15690404e-01f, 7.29033574e-02f, -6.72599599e-02f, -1.02662660e-01f, 4.32644002e-02f, -4.53880578e-02f,
  -1.20188326e-01f, 1.03896456e-02f, -2.29841098e-02f, 2.05715925e-01f, -1.30181029e-01f, -4.36747670e-02f, -1.12633564e-01f, 7.22231865e-02f, -1.94231555e-01f, 3.74144502e-02f,
  5.61099276e-02f, 2.55978126e-02f, 6.57218993e-02f, 2.22772900e-02f, -5.88881038e-03f, -1.42697696e-04f, -6.31988272e-02f, -4.68100235e-02f, -4.78004850e-02f, 5.37114516e-02f,
  -9.82703641e-02f, 2.95486543e-02f, -7.92299658e-02f, -5.85923530e-02f, -9.02509242e-02f, 3.51553895e-02f, -5.05199507e-02f, 4.12625819e-02f, 7.80503750e-02f, 1.13582220e-02f,
  1.48588140e-02f, -2.56021135e-03f, -1.62171841e-01f, -5.74634932e-02f, -8.24572891e-02f, 2.73255669e-02f, -1.28487706e-01f, 5.60581498e-02f, -8.32797065e-02f, -1.01824507e-01f,
  -4.10508215e-02f, -7.05649331e-02f, -3.58689390e-02f, 5.63842803e-02f, -4.06194143e-02f, 7.98020586e-02f, -2.11759694e-02f, 6.66413456e-02f, -1.11665286e-01f, 2.89393868e-03f,
  8.63225833e-02f, -4.12725993e-02f, 1.90428078e-01f, 1.80764217e-02f, -1.47223219e-01f, 5.10588214e-02f, -7.86319934e-03f, 7.67986849e-02f, -5.89151122e-02f, 8.04140568e-02f,
  2.37699561e-02f, -8.04031566e-02f, 6.20265305e-02f, 3.09667643e-02f, 7.84080774e-02f, -4.49374877e-02f, -1.13507016e-02f, 1.07966386e-01f, 1.51774824e-01f, 5.03064366e-03f,
  -6.97745085e-02f, -9.43880305e-02f, -1.23164244e-02f, 2.70907898e-02f, 8.08815807e-02f, 8.76773428e-03f, -2.92808842e-02f, -1.04583435e-01f, -3.63187380e-02f, 2.42515225e-02f,
  -6.44129887e-02f, 1.27204973e-02f, 7.76426354e-03f, 5.54835163e-02f, 2.86703836e-02f, -6.75624907e-02f, 9.04812887e-02f, 2.49196533e-02f, 3.82904373e-02f, 1.04841925e-01f,
  3.55442688e-02f, 7.51068024e-03f, -1.03445037e-03f, 5.67088015e-02f, -1.80229232e-01f, -4.57181260e-02f, -1.26196831e-01f, -8.76437407e-03f, -1.41263142e-01f, -5.18611819e-02f,
  -1.05348393e-01f, 3.12922269e-01f, 3.00548643e-01f, 4.41296011e-01f, -8.43134448e-02f, -1.82300746e-01f, -1.90567106e-01f, 1.11198984e-01f, 2.28465050e-01f, -7.18390122e-02f,
  -2.09707841e-01f, 1.31004900e-01f, -2.71805618e-02f, 1.50970504e-01f, 2.16182515e-01f, 4.73023616e-02f, 9.61437002e-02f, 2.11381521e-02f, 1.38942003e-01f, 1.24256089e-01f,
  1.68199733e-01f, -2.04142798e-02f, 2.00350136e-01f, 1.16937689e-01f, 1.02758840e-01f, 1.23584740e-01f, 2.77874947e-01f, 4.12132442e-02f, 7.42361248e-02f, -2.99124811e-02f,
  -1.21220201e-01f, -2.41526943e-02f, -4.79838513e-02f, -8.45136046e-02f, 2.84599550e-02f, -6.93318769e-02f, 3.01530231e-02f, -3.36400606e-02f, 1.13375867e-02f, -1.20232522e-01f,
  -1.17145255e-01f, -7.02715293e-02f, 1.98087338e-02f, 9.10143331e-02f, -1.76754519e-02f, 3.31121311e-02f, -5.66339456e-02f, 5.47379144e-02f, 9.51310992e-02f, -5.24446741e-02f,
  1.12268090e-01f, -4.00485331e-03f, -2.60895193e-02f, 4.75222711e-03f, 6.02591112e-02f, 1.07671075e-01f, 6.07888736e-02f, 1.59522936e-01f, 7.89263919e-02f, 6.54387847e-03f,
  -2.78951209e-02f, -2.45042355e-03f, -1.33636119e-02f, 3.22557688e-02f, 5.38172126e-02f, 1.02647521e-01f, 3.77906039e-02f, -7.52777606e-02f, -8.15064386e-02f, 7.38020241e-03f,
  4.52842936e-02f, 2.32751071e-02f, -3.02026682e-02f, 2.10034996e-02f, 6.03605956e-02f, -7.26327077e-02f, 1.84442699e-02f, 2.00199429e-03f, 8.30868911e-03f, -4.89773415e-02f,
  1.40504912e-02f, -1.14920735e-03f, -1.47676738e-02f, -2.86162607e-02f, -5.53036556e-02f, 4.68336195e-02f, -1.72714423e-02f, -1.21758893e-01f, 5.36380671e-02f, 6.28659576e-02f,
  2.04221010e-01f, 3.63862604e-01f, 3.61066498e-02f, -8.74049664e-02f, 2.19163317e-02f, -1.82682723e-02f, -1.79889891e-02f, 2.47846488e-02f, 1.62053242e-01f, -2.60902550e-02f,
  -7.36281723e-02f, -2.87040845e-02f, 7.47836241e-03f, -2.84392666e-02f, 8.68716463e-02f, 1.58101827e-01f, 1.34387584e-02f, 1.96457922e-01f, 1.12534426e-01f, 5.59429526e-02f,
  -6.13982305e-02f, -3.61882560e-02f, -7.93886036e-02f, 9.83077437e-02f, -7.42051527e-02f, 2.23578010e-02f, 4.02979553e-02f, 1.70645881e-02f, -5.15254028e-03f, -1.26485052e-02f,
  2.15906546e-01f, -3.54410291e-01f, -2.20430456e-02f, 2.32087597e-01f, 2.80046582e-01f, 1.95540145e-01f, 1.38807118e-01f, -1.34057403e-01f, 1.57166254e-02f, -2.76468664e-01f,
  8.59812088e-03f, -1.14055239e-01f, -3.41487713e-02f, -1.33861884e-01f, 3.49401087e-01f, -2.14811996e-01f, -1.21872544e-01f, -9.24644023e-02f, 3.33709083e-02f, -2.32856330e-02f,
  1.52164981e-01f, -3.25793922e-02f, -1.51198581e-02f, -9.71134473e-03f, 8.85693952e-02f, 7.48733059e-02f, -4.89076227e-02f, 5.25733940e-02f, 1.36647038e-02f, 6.43155351e-02f,
  1.21728070e-01f, 9.37612914e-03f, 2.79463939e-02f, -2.94412728e-02f, 5.74845262e-02f, 2.80968025e-02f, -2.69855205e-02f, 4.38119052e-03f, 9.46614221e-02f, -6.97438568e-02f,
  -6.55037090e-02f, -4.27547619e-02f, 7.78280124e-02f, 1.19282015e-01f, 7.81689808e-02f, 2.84785107e-02f, 6.11321721e-03f, -6.82321005e-03f, -1.02011554e-01f, -8.27640593e-02f,
  2.03100755e-03f, -6.56917412e-03f, 5.86433336e-03f, 4.66625579e-03f, 8.32741037e-02f, 5.47035233e-05f, 2.88225394e-02f, 2.88870167e-02f, -8.10159966e-02f, -6.99820518e-02f,
  -7.58010522e-02f, -3.67378742e-02f, 1.81121044e-02f, -3.35070700e-03f, 1.05098682e-02f, 9.46300849e-03f, -1.05641462e-01f, 2.66672187e-02f, 1.13748178e-01f, -4.86737117e-02f,
  -2.92948401e-03f, -5.70610985e-02f, -5.75714521e-02f, 6.11037202e-02f, -4.40117195e-02f, -3.10262176e-03f, -9.34915245e-02f, -7.41535844e-03f, 1.29642682e-02f, 7.81819373e-02f,
  -6.96845469e-04f, 2.54607070e-02f, 8.12335014e-02f, -1.03132538e-01f, 2.62391996e-02f, 1.29155397e-01f, -8.24967027e-03f, -2.01384425e-02f, -5.08269668e-02f, -5.20673953e-02f,
  -3.21254358e-02f, -4.50549066e-01f, 8.50627013e-03f, -4.76513337e-03f, -9.76684969e-03f, 3.53068039e-02f, 2.03382317e-02f, 3.62479384e-03f, -6.91800471e-03f, -4.35984023e-02f,
  2.17417236e-02f, 9.16913431e-03f, -4.50656824e-02f, 1.06879503e-01f, 4.54960577e-02f, -4.30683829e-02f, -3.60871479e-02f, -3.75868417e-02f, -8.10383484e-02f, -1.20712325e-01f,
  2.39193887e-02f, -6.57142028e-02f, -1.48029730e-01f, 1.86629128e-02f, 3.01343948e-03f, -9.69315320e-03f, 5.84137924e-02f, 3.78436819e-02f, -1.26275212e-01f, -1.46133438e-01f,
  -2.73345023e-01f, 2.48974562e-01f, -1.67134225e-01f, -3.14089239e-01f, 1.41034707e-01f, -1.14845643e-02f, -2.94969290e-01f, 2.23556366e-02f, -1.37067102e-02f, -4.86503728e-02f,
  -1.92170799e-01f, 2.91746091e-02f, -4.17488220e-04f, -2.58792192e-01f, -9.74987596e-02f, 7.27263018e-02f, -2.59985685e-01f, -1.60922274e-01f, 7.33054653e-02f, -1.22551443e-02f,
  -3.11584901e-02f, -8.32736865e-02f, -6.66479617e-02f, 8.26046243e-02f, -1.34628966e-01f, 1.99468266e-02f, -1.39541268e-01f, 1.56782210e-01f, -1.62911415e-01f, 5.79940528e-02f,
  -9.02564153e-02f, -1.19104989e-01f, -2.22199246e-01f, -1.76724643e-01f, -2.62101777e-02f, 5.63828200e-02f, -1.49137959e-01f, -5.48584498e-02f, -1.96132250e-02f, -6.12214021e-02f,
  7.02092275e-02f, -3.54523733e-02f, 1.56287663e-02f, 2.94391345e-02f, -1.38806915e-02f, 2.45273933e-02f, -2.21449714e-02f, -1.66443780e-01f, -9.61922631e-02f, 9.15962458e-02f,
  2.66609783e-03f, 1.18732955e-02f, -6.88838437e-02f, 2.99015231e-02f, -6.84903061e-04f, -6.74164668e-02f, -7.33298436e-02f, -3.97739783e-02f, 2.40347702e-02f, 1.30945072e-02f,
  2.18242124e-01f, 7.54478276e-02f, -2.95888446e-02f, -4.95418720e-02f, -3.02107129e-02f, 1.31436773e-02f, 9.23847407e-02f, 3.70099135e-02f, -5.59073640e-03f, 5.48672043e-02f,
  -5.30463308e-02f, 5.68225235e-03f, 2.45099925e-02f, -5.67703582e-02f, 1.31572962e-01f, -9.09643844e-02f, -8.02168474e-02f, -1.13581978e-01f, -2.64476221e-02f, -2.48953197e-02f,
  -8.43309909e-02f, -6.42480031e-02f, -3.58491428e-02f, 3.18348594e-02f, 1.57406200e-02f, 3.28881899e-03f, 8.13164189e-02f, 4.43358496e-02f, -1.40931820e-02f, 2.90288758e-02f,
  -7.99294859e-02f, -2.17876077e-01f, -4.91075888e-02f, -6.95869923e-02f, -9.05988142e-02f, -5.84866735e-04f, 7.24272281e-02f, -7.81058222e-02f, -8.29105303e-02f, 3.62798492e-05f,
  -4.83178534e-02f, -1.44194022e-01f, -6.06929548e-02f, 1.16544433e-01f, -3.69350426e-03f, 2.39357427e-02f, -3.24360542e-02f, -1.51809350e-01f, -4.38174680e-02f, 8.91902298e-02f,
  -8.44255760e-02f, 9.44334418e-02f, 2.74841040e-02f, 2.81889532e-02f, -5.62168136e-02f, 1.18998298e-02f, -9.31513682e-03f, 4.20971885e-02f, 3.60474885e-02f, -7.09392224e-03f,
  9.59000289e-02f, -7.06325248e-02f, -1.74949035e-01f, 5.16792424e-02f, -4.02329536e-03f, -1.17208153e-01f, -2.25433528e-01f, -1.43905878e-01f, -1.47345603e-01f, -2.26494581e-01f,
  -1.66052014e-01f, 2.89374143e-02f, -2.82351285e-01f, 1.10685527e-01f, 2.85863876e-01f, -1.38672709e-01f, 1.33495063e-01f, 2.64260918e-02f, 1.01315632e-01f, 3.52224894e-02f,
  1.85730338e-01f, 2.75561541e-01f, 1.42868236e-01f, 2.42296353e-01f, 1.18850917e-01f, 1.63072050e-01f, 1.83648184e-01f, 6.93240687e-02f, 2.03311503e-01f, 1.50238380e-01f,
  -1.00138858e-02f, 3.14468052e-03f, -3.87642384e-02f, 5.27724577e-03f, -3.93371060e-02f, 5.06132841e-02f, 4.36124168e-02f, 6.52319267e-02f, 3.69140059e-02f, -2.71007288e-02f,
  -5.72005585e-02f, 1.20978124e-01f, 6.65988773e-03f, 1.54595271e-01f, 1.11997172e-01f, -1.82473343e-02f, 1.42496472e-04f, 5.95782213e-02f, 1.45703694e-02f, -6.94118487e-03f,
  5.79034816e-03f, -1.89073645e-02f, 4.26072069e-02f, 1.30283237e-02f, -4.24789004e-02f, -5.66379279e-02f, 2.23275665e-02f, -1.32091157e-02f, 6.16045250e-03f, -2.57082358e-02f,
  2.22880151e-02f, -3.89460176e-02f, -3.80552188e-02f, -4.93401513e-02f, -3.51376794e-02f, -4.91545945e-02f, 4.38864250e-03f, -9.84059274e-02f, 4.77270335e-02f, -1.27420500e-02f,
  -5.66496402e-02f, -2.46532168e-02f, -4.06877957e-02f, -1.18544906e-01f, 4.68263403e-02f, 1.83330141e-02f, 2.18776055e-02f, 4.60591428e-02f, -3.21303047e-02f, -7.45835826e-02f,
  8.48230615e-04f, 8.58885571e-02f, -1.32609919e-01f, 1.56987421e-02f, 9.58115794e-03f, -4.27169017e-02f, -1.27331738e-03f, 2.39482243e-02f, 4.71354760e-02f, -8.84147510e-02f,
  3.78490835e-02f, -1.68304215e-03f, -7.62292072e-02f, -1.54295582e-02f, -5.35043934e-03f, -2.76147071e-02f, 1.81480616e-01f, -5.41132642e-03f, 6.32704236e-03f, -4.82530631e-02f,
  4.42741364e-02f, 5.71061186e-02f, -2.94222087e-02f, 2.62755826e-02f, 8.54316577e-02f, -2.70894319e-02f, -1.17028514e-02f, -8.29099268e-02f, -2.69729868e-02f, -1.68545749e-02f,
  -4.51235659e-02f, -6.70408979e-02f, -3.70412804e-02f, -7.11812228e-02f, -1.33312326e-02f, -1.17680497e-01f, 2.89214421e-02f, -9.27970111e-02f, -5.15252911e-02f, -1.32985190e-01f,
  6.31356090e-02f, -3.96090448e-02f, -1.20927006e-01f, -4.80019711e-02f, 2.27644648e-02f, -2.26474434e-01f, -3.06320161e-01f, -1.52480692e-01f, -1.86017737e-01f, -1.41747728e-01f,
  2.88670138e-02f, 3.79418433e-02f, 6.59786165e-02f, -2.15703864e-02f, 2.14120358e-01f, 1.47152975e-01f, -1.56980589e-01f, 1.20665962e-02f, 1.61980227e-01f, 5.93621880e-02f,
  1.25282466e-01f, 4.43095900e-02f, 1.95126861e-01f, 4.12770100e-02f, -1.80893078e-01f, 6.67431056e-02f, 1.72785491e-01f, -4.87440340e-02f, -6.45553470e-02f, -1.08386934e-01f,
  4.87345923e-03f, 7.16367215e-02f, -8.74404982e-02f, -1.42599419e-01f, 1.18660992e-02f, -4.94245365e-02f, -1.11129493e-01f, -6.68358803e-02f, 1.66466366e-02f, 2.21518427e-02f,
  -1.49727508e-01f, -2.38440000e-02f, -3.05075329e-02f, -6.93592504e-02f, 1.18140861e-01f, 6.18582070e-02f, 1.09826319e-01f, -1.91322137e-02f, 5.52216507e-02f, 1.05286390e-01f,
  -7.06102252e-02f, 1.65494923e-02f, 1.79575197e-02f, 1.13961451e-01f, 1.12251617e-01f, -2.13949084e-02f, 5.26208095e-02f, 2.60044020e-02f, 5.47372624e-02f, -1.09981019e-02f,
  1.17880486e-01f, -6.13614209e-02f, -2.02855263e-02f, -7.71953613e-02f, -9.70598087e-02f, 7.72032095e-03f, -2.20746044e-02f, 1.22697085e-01f, -1.34397103e-02f, 2.20428612e-02f,
  5.11020832e-02f, -7.86368251e-02f, 1.03237908e-02f, -1.13395350e-02f, -1.32977292e-01f, 6.45575747e-02f, -7.69684166e-02f, -3.13815773e-02f, 7.81562924e-02f, -2.56293826e-02f,
  5.12078442e-02f, 1.24384701e-01f, -9.09483135e-02f, 2.90328115e-02f, -5.67929447e-02f, 3.75602804e-02f, -1.32177815e-01f, -4.33953218e-02f, -7.77439475e-02f, -1.65060699e-01f,
  3.85041758e-02f, 4.83031273e-02f, 1.84483603e-02f, -1.42630339e-01f, 7.66448751e-02f, 4.15466959e-03f, -4.51090373e-02f, 3.85624939e-03f, -5.28889429e-03f, 1.34936213e-01f,
  -3.45858745e-02f, -8.40214640e-02f, 9.63358767e-03f, 7.94212744e-02f, -6.88155964e-02f, -2.88440678e-02f, 6.53770491e-02f, -4.51072231e-02f, 6.33408204e-02f, 1.53772682e-01f,
  3.57197337e-02f, 2.87690759e-02f, 2.41937116e-02f, -4.08550575e-02f, -5.14115468e-02f, -4.48931418e-02f, 2.16028728e-02f, 9.57545545e-03f, 8.49755928e-02f, -5.37454560e-02f,
  -8.51016268e-02f, 1.63781643e-01f, 1.93109572e-01f, 2.97683209e-01f, -1.82246312e-01f, -2.51415879e-01f, -2.15091586e-01f, -1.87113266e-02f, 5.82598746e-02f, -1.51624322e-01f,
  6.94834664e-02f, 2.08751768e-01f, -2.42700383e-01f, 2.46149689e-01f, 5.81938662e-02f, -7.34336674e-02f, 4.17871885e-02f, -1.34664048e-02f, 6.60600513e-03f, -4.17438522e-02f,
  2.05082577e-02f, 4.25624140e-02f, 2.09155306e-01f, 1.13860248e-02f, 1.11683510e-01f, 1.69430941e-01f, 8.95628110e-02f, -9.06643551e-03f, 1.67233109e-01f, 3.85548547e-02f,
  3.44022177e-02f, 1.73876900e-02f, 2.56548859e-02f, 4.11158651e-02f, 1.01267896e-03f, -8.74064118e-02f, 3.84324230e-02f, -7.92219564e-02f, -4.52883542e-02f, 4.70217578e-02f,
  4.20034155e-02f, -3.43203312e-04f, 1.42442575e-02f, -8.18036273e-02f, -3.04889195e-02f, 7.74382204e-02f, 2.38536987e-02f, -3.84892933e-02f, 8.94740522e-02f, -9.44951177e-03f,
  -1.71579216e-02f, -5.62194828e-03f, 6.15656115e-02f, 3.72350253e-02f, 7.33586820e-03f, 3.50904360e-04f, -4.70636338e-02f, 9.12720244e-03f, 1.53236628e-01f, 3.00690755e-02f,
  4.60159034e-02f, -1.01604775e-01f, -9.40509140e-03f, -6.60889894e-02f, -1.19134970e-01f, 6.59013614e-02f, 4.00554501e-02f, -1.57856438e-02f, 2.52045169e-02f, 2.91161928e-02f,
  2.91028973e-02f, 6.38726652e-02f, 1.97452772e-02f, -5.21981679e-02f, 1.70520227e-02f, -9.04942676e-03f, 1.42586755e-03f, 2.78027710e-02f, 8.73552412e-02f, -5.37996218e-02f,
  8.41684118e-02f, -4.76481579e-02f, 8.47799629e-02f, 5.99567359e-03f, -1.03136644e-01f, 6.91812905e-03f, 2.31345594e-02f, 8.10791925e-02f, -3.51144113e-02f, -2.88880281e-02f,
  9.61299241e-02f, 3.43021572e-01f, 5.57440929e-02f, 9.88277420e-02f, 1.14256714e-03f, -3.62166390e-02f, -5.16190417e-02f, 3.14331464e-02f, 1.47196293e-01f, 7.80170187e-02f,
  -9.08471569e-02f, 8.34868290e-03f, 5.91882989e-02f, -3.16988863e-03f, 4.44793627e-02f, 1.91927385e-02f, 5.76152187e-03f, 3.30483653e-02f, 8.79643336e-02f, -1.90026332e-02f,
  -4.84039411e-02f, -3.11857369e-02f, 7.21940678e-03f, -8.97233933e-02f, 4.16407920e-03f, 1.62119806e-01f, -1.29255876e-01f, -3.43350284e-02f, 8.79147425e-02f, 1.07034147e-01f,
  1.68710381e-01f, -1.59917876e-01f, -1.38097405e-01f, -8.44949037e-02f, -7.90938642e-03f, 9.62281674e-02f, -1.68415070e-01f, -7.69230276e-02f, -1.34048924e-01f, -2.27994635e-03f,
  1.39310863e-02f, -1.25506192e-01f, -1.13975585e-01f, -5.06960899e-02f, 1.09915305e-02f, -1.44598961e-01f, -2.75513232e-02f, -1.85682271e-02f, 2.08764635e-02f, 1.22340396e-01f,
  1.15306251e-01f, 1.19919054e-01f, 6.11893497e-02f, 1.32752761e-01f, 6.97727501e-02f, 4.09144759e-02f, 9.64006335e-02f, 1.24092311e-01f, 1.52146474e-01f, 1.72680169e-02f,
  2.80726030e-02f, 7.48520717e-02f, -2.32447963e-02f, 4.26687412e-02f, 1.49546668e-01f, 1.01450481e-01f, 5.07743247e-02f, 3.72911710e-03f, 4.44027707e-02f, 2.58929878e-02f,
  6.24430887e-02f, -4.47112471e-02f, 4.41263653e-02f, 7.77681172e-02f, -1.86022632e-02f, 9.68342498e-02f, -1.67617276e-02f, 3.34918462e-02f, -1.23595908e-01f, 1.22537194e-02f,
  -3.73553741e-03f, -9.86331701e-03f, -5.69522753e-02f, -4.14160080e-02f, -9.23067704e-02f, -6.74572214e-03f, -2.29263511e-02f, 9.87735167e-02f, -8.10361430e-02f, 9.13616940e-02f,
  1.01921111e-01f, 1.93575921e-03f, 2.30059903e-02f, -1.38395298e-02f, 1.94461972e-01f, -5.21661527e-02f, -8.64651874e-02f, 4.35781851e-02f, 1.35439150e-02f, 6.48097694e-02f,
  -4.96971384e-02f, 3.52787450e-02f, 8.14570785e-02f, 9.32811648e-02f, -5.28141148e-02f, 3.10943229e-03f, 1.52218547e-02f, -7.32930377e-02f, 1.19724728e-01f, -9.70001519e-02f,
  -1.10589406e-02f, 7.96335712e-02f, 7.83356726e-02f, -8.46896917e-02f, -6.28927797e-02f, 8.25384483e-02f, 3.16385776e-02f, 1.14126384e-01f, -1.53767150e-02f, -8.59480798e-02f,
  -3.67861949e-02f, 3.77642550e-02f, -5.15099727e-02f, -3.15312482e-02f, -3.47202793e-02f, 2.96326522e-02f, 1.45594003e-02f, -1.38322562e-01f, 5.91764748e-02f, -5.29044122e-03f,
  9.45242122e-02f, -1.11427501e-01f, -1.53588885e-02f, 3.19543667e-02f, -1.25496432e-01f, 9.93865952e-02f, 7.01890364e-02f, 6.07037209e-02f, -1.29876792e-01f, 9.70200002e-02f,
  1.87884513e-02f, -1.86280534e-02f, -1.84020884e-02f, -1.50610179e-01f, -1.04967423e-01f, -9.39239860e-02f, 1.29744425e-01f, 1.56809986e-02f, -1.45808384e-02f, 2.06330456e-02f,
  2.21367419e-01f, -1.22463837e-01f, -1.33146301e-01f, 6.99390331e-03f, 9.91941467e-02f, -5.77922026e-03f, -5.42366244e-02f, 1.66105311e-02f, -6.11001365e-02f, -9.64900479e-02f,
  1.27080202e-01f, -1.02438681e-01f, -2.64912963e-01f, 2.26043314e-01f, 2.86547244e-01f, -2.61364698e-01f, 1.89712837e-01f, 3.84980552e-02f, -6.69965297e-02f, 1.94816515e-01f,
  1.23094812e-01f, 3.10692191e-01f, 9.50102732e-02f, 2.25718632e-01f, 1.59815952e-01f, 6.81612045e-02f, 1.45380154e-01f, -4.23476063e-02f, 1.78378001e-01f, 1.47079686e-02f,
  3.15599628e-02f, 8.15643743e-02f, -6.06664643e-02f, 3.74584235e-02f, -2.17391066e-02f, 2.84751784e-02f, -5.51429279e-02f, 7.35074058e-02f, 4.33797389e-02f, -5.55538833e-02f,
  2.26766877e-02f, 2.67791878e-02f, 9.66980681e-02f, 6.54987525e-03f, 5.73994629e-02f, 4.68003713e-02f, 9.30676688e-05f, 2.60046490e-05f, -3.51392552e-02f, 4.48024385e-02f,
  -4.74852249e-02f, -2.98187649e-03f, 6.60627857e-02f, -8.45408440e-02f, -1.29788741e-01f, -2.75952392e-03f, 7.54560605e-02f, -3.00379805e-02f, -3.54703330e-02f, 2.01319475e-02f,
  1.04551606e-01f, 1.18930908e-02f, 7.53331408e-02f, 2.37490293e-02f, -4.73541021e-02f, -5.81957959e-02f, 2.86998600e-02f, -1.04013108e-01f, -4.26095314e-02f, -7.57682696e-02f,
  -9.05509964e-02f, 3.51381749e-02f, 2.64440831e-02f, -2.24227887e-02f, 4.58117090e-02f, 1.17486240e-02f, -2.60804575e-02f, -1.24412067e-01f, -8.82687494e-02f, -6.44961223e-02f,
  3.22923926e-03f, 7.82359987e-02f, -3.92438956e-02f, 5.10045476e-02f, 1.36849387e-02f, 2.43190564e-02f, 4.96909246e-02f, -1.46980407e-02f, -7.03216940e-02f, -7.69822448e-02f,
  -3.39399986e-02f, 6.31772960e-03f, -6.59817085e-02f, 3.93184461e-02f, -3.10202669e-02f, -2.33244244e-02f, 1.10531775e-02f, 6.56637177e-02f, 4.97582033e-02f, -4.67119403e-02f,
  8.06673709e-03f, 4.46888544e-02f, -3.10733616e-02f, -3.56013179e-02f, 1.94391212e-03f, 1.04028154e-02f, -6.38714358e-02f, -6.88891709e-02f, -1.39252886e-01f, 4.29149903e-02f,
  -1.36429258e-02f, -1.33817345e-01f, 2.70499429e-03f, -6.93943128e-02f, -2.65457984e-02f, -9.41437483e-02f, -5.51302638e-03f, 1.02310769e-01f, -6.50201179e-03f, -6.71650320e-02f,
  -3.43794450e-02f, -2.75517516e-02f, -4.79472242e-02f, -2.81285346e-01f, -2.74422336e-02f, -1.53836861e-01f, -1.45903781e-01f, 5.52979112e-02f, 2.34722406e-01f, 1.15921222e-01f,
  1.42918408e-01f, -9.47324187e-02f, 1.11231104e-01f, -2.26197913e-01f, -3.41990553e-02f, -6.37330413e-02f, -3.93494874e-01f, -3.52405548e-01f, -9.64916497e-02f, -1.73725575e-01f,
  -2.19480574e-01f, -2.29910985e-01f, -1.75769851e-01f, -1.00147665e-01f, -1.91135764e-01f, 2.57903375e-02f, 2.31355000e-02f, 6.84448183e-02f, -9.57503021e-02f, -1.33272028e-02f,
  -8.94991681e-02f, 1.61958396e-01f, 4.84714583e-02f, 6.51591197e-02f, -8.37773383e-02f, -5.44030368e-02f, -1.45298913e-01f, -3.52945291e-02f, 3.31753939e-02f, 5.89717440e-02f,
  -1.26037717e-01f, 3.54750194e-02f, 1.05328545e-01f, 6.63205832e-02f, 6.89040050e-02f, -2.11745817e-02f, -6.40105307e-02f, 3.76986898e-02f, -2.41096076e-02f, 3.82122141e-03f,
  -1.03065051e-01f, 4.40236814e-02f, 2.28514671e-02f, 5.98739050e-02f, -5.16087227e-02f, 8.40810910e-02f, 1.48408758e-02f, -2.57510245e-02f, 2.90509071e-02f, 4.72541898e-02f,
  -7.09486455e-02f, -1.47404969e-02f, -7.79982284e-02f, -1.17797346e-03f, -3.08396090e-02f, 1.85164567e-02f, -5.38592301e-02f, -3.11999079e-02f, 2.50170603e-02f, 2.54111439e-02f,
  1.86435785e-02f, 9.40265581e-02f, -2.43558194e-02f, 7.31335953e-03f, -1.44255236e-01f, 4.61029485e-02f, -9.75974426e-02f, -4.71058637e-02f, -4.40746062e-02f, -9.07035358e-03f,
  -1.12805873e-01f, -5.28037809e-02f, 9.37332213e-02f, -1.16573207e-01f, 3.95099632e-02f, 8.07378069e-02f, -1.25390058e-03f, -6.16184436e-02f, 4.96464111e-02f, -1.73954085e-01f,
  -5.24188615e-02f, 5.55887781e-02f, 4.89789508e-02f, -4.88826185e-02f, 6.85627759e-02f, -2.53587812e-02f, -2.99361954e-03f, 4.66108043e-03f, -1.84411984e-02f, 5.66041768e-02f,
  -5.29295132e-02f, -4.40371707e-02f, -7.31344074e-02f, 1.37604401e-01f, -3.58396918e-02f, -1.58148389e-02f, 2.20663715e-02f, -3.85793229e-03f, -1.22852303e-01f, 5.31049296e-02f,
  -2.58802269e-02f, 9.56555381e-02f, 1.25157451e-02f, -1.91368256e-02f, -1.45347118e-01f, -9.57501121e-04f, 1.27797714e-02f, -2.17789691e-02f, -7.26132765e-02f, 2.57797670e-02f,
  -6.90525249e-02f, 3.67861837e-02f, 1.62198350e-01f, -2.00620815e-01f, 2.24410649e-02f, 3.75059158e-01f, 9.39307138e-02f, 2.34652862e-01f, 2.74700969e-01f, -1.52296394e-01f,
  -9.70527008e-02f, -1.76984757e-01f, 1.07955009e-01f, -2.53415108e-01f, 2.41432816e-01f, 7.42131844e-02f, 7.82732144e-02f, -1.86734021e-01f, 1.86348647e-01f, 3.74055617e-02f,
  -4.91942726e-02f, -2.59688228e-01f, -8.96883532e-02f, -6.18861094e-02f, -2.50739455e-01f, -1.24540828e-01f, -2.38810956e-01f, -4.52900790e-02f, -2.24267915e-01f, -2.54021566e-02f,
  5.03028464e-03f, 1.94045454e-02f, 9.86430049e-02f, 1.27231866e-01f, 8.40532482e-02f, -1.60734802e-02f, -8.02899748e-02f, 5.43406745e-03f, 1.62020430e-01f, -4.65481654e-02f,
  -2.29965504e-02f, -6.33584931e-02f, -2.86228620e-02f, -7.47686923e-02f, 4.60112430e-02f, 3.84405591e-02f, -3.76970433e-02f, 1.13066576e-01f, 1.12095259e-01f, 2.86110453e-02f,
  -6.87929466e-02f, 2.14744117e-02f, 3.14936042e-02f, -1.33925192e-02f, -8.73782337e-02f, 6.58908486e-02f, -5.85851595e-02f, 9.20326449e-03f, 5.07220551e-02f, -5.11739254e-02f,
  -6.58136383e-02f, -3.49700125e-03f, -6.24581538e-02f, 2.27982830e-02f, 2.76064519e-02f, 6.66867709e-03f, -5.90838492e-02f, -9.33977589e-02f, -3.20862979e-02f, 2.99088843e-02f,
  3.70391011e-02f, -4.06768844e-02f, 9.51076858e-03f, 1.57693341e-01f, -5.02310768e-02f, 2.21840311e-02f, -2.34418828e-02f, 4.84944843e-02f, 1.08092643e-01f, 9.58422497e-02f,
  -6.83034137e-02f, 4.42833230e-02f, -3.23266513e-03f, -1.13955788e-01f, 6.50468394e-02f, -2.38023046e-02f, -8.68461803e-02f, -1.59497000e-02f, 1.22754893e-03f, -2.24828068e-02f,
  1.33773819e-01f, 1.04340380e-02f, 2.36786829e-04f, -4.84462921e-03f, -5.87397814e-03f, 5.02482876e-02f, -4.02551517e-02f, 9.17476118e-02f, 7.60901570e-02f, -9.22041479e-03f,
  -2.89180279e-02f, -1.26397878e-01f, 3.48688066e-02f, -9.18975472e-03f, 6.65791631e-02f, -8.31138864e-02f, 3.90854701e-02f, 1.13703944e-01f, 2.93284631e-03f, 7.45406747e-02f,
  6.71183988e-02f, -2.36063264e-02f, 5.48341759e-02f, -8.88247788e-02f, -2.37334948e-02f, 1.82181541e-02f, -8.53180420e-03f, 1.00178860e-01f, -8.50124881e-02f, 3.05622164e-02f,
  1.15619525e-01f, -4.37113643e-02f, -2.07173988e-01f, -1.94861796e-02f, 1.51244625e-01f, 2.22740203e-01f, -1.24158114e-01f, -4.78203334e-02f, -1.95739478e-01f, 6.14466984e-03f,
  -1.65364444e-02f, -1.38669610e-01f, -3.23705971e-01f, 3.05745192e-02f, 7.77383847e-03f, -2.80527651e-01f, 1.73910543e-01f, 4.16190342e-05f, -4.38964851e-02f, 1.84915513e-02f,
  3.84917413e-03f, 1.87687770e-01f, -4.49993648e-02f, 2.70572692e-01f, 1.68416381e-01f, -1.98663361e-02f, 1.40030712e-01f, 4.66926070e-03f, 2.36521497e-01f, 1.28947794e-01f,
  5.00233248e-02f, -8.03947896e-02f, -1.32889405e-01f, -6.14906065e-02f, 5.64260501e-03f, 5.68673164e-02f, -7.76355565e-02f, -1.99594884e-03f, 2.88793091e-02f, -8.10704604e-02f,
  5.93520589e-02f, -2.77870186e-02f, 5.00434153e-02f, 6.55411407e-02f, 3.76330614e-02f, 7.86539074e-03f, -2.88379062e-02f, -3.99746411e-02f, -1.13339230e-01f, -7.11279362e-02f,
  -1.46549940e-01f, 9.52212438e-02f, -3.53177823e-02f, 2.92680115e-02f, 5.85713191e-03f, -7.41552413e-02f, 1.91067699e-02f, -4.87857200e-02f, 8.97825882e-02f, -1.86946895e-02f,
  4.72300872e-02f, -4.39314917e-03f, 3.51877585e-02f, 2.43930928e-02f, 3.56297232e-02f, 6.36495352e-02f, -3.72877438e-03f, -7.45176300e-02f, 9.42823477e-03f, -1.66180022e-02f,
  3.99147496e-02f, -5.82147464e-02f, -9.78664234e-02f, 6.11678548e-02f, -3.28262560e-02f, 3.78777906e-02f, 7.29900226e-02f, -3.23829204e-02f, -9.21752006e-02f, -3.68753225e-02f,
  6.21104101e-03f, 4.41430286e-02f, 1.40855601e-02f, 2.64996402e-02f, 5.92233762e-02f, -3.47792841e-02f, 4.71064486e-02f, -1.15065277e-01f, 1.04729943e-02f, 4.77517117e-03f,
  4.35784161e-02f, 1.14036985e-01f, -1.70426115e-01f, 7.56647959e-02f, -4.89449129e-02f, 1.17308244e-01f, -5.74692385e-03f, -9.72907990e-03f, 1.34419026e-02f, -5.34961671e-02f,
  1.20234974e-01f, -4.16175835e-02f, 4.48667742e-02f, -1.06508834e-02f, 3.53671759e-02f, -4.46088426e-02f, -8.65818262e-02f, -6.87452033e-02f, -2.40229201e-02f, 3.23861688e-02f,
  4.00893614e-02f, 4.26402688e-02f, -1.29207149e-02f, 2.11951602e-03f, 3.66137885e-02f, -7.77471587e-02f, 1.11096181e-01f, -7.26629188e-03f, -1.13988398e-02f, -7.10702837e-02f,
  1.27514854e-01f, -3.27660769e-01f, 2.80486971e-01f, 1.57117158e-01f, 1.16037793e-01f, -3.82844508e-02f, 1.36407927e-01f, -8.26722234e-02f, 2.04566913e-03f, -1.68666497e-01f,
  -1.16762124e-01f, 1.05242662e-01f, -1.67078301e-01f, -1.05055586e-01f, 4.14043576e-01f, -2.16491353e-02f, -5.94368316e-02f, -1.92181133e-02f, 1.72673650e-02f, -1.28623113e-01f,
  8.19002390e-02f, -3.48640494e-02f, 1.66941732e-01f, -3.91700529e-02f, -4.22810540e-02f, 2.14710850e-02f, 3.74080031e-03f, 1.96461156e-01f, 4.33456860e-02f, 1.48722187e-01f,
  -1.11375682e-01f, 1.47268595e-02f, -1.64563015e-01f, -1.27103373e-01f, -8.10590461e-02f, 3.90454940e-03f, 1.37351960e-01f, 4.63800356e-02f, 5.67408651e-02f, -6.68120862e-04f,
  7.76508823e-02f, 1.02128819e-01f, -3.29290479e-02f, -1.41243348e-02f, -1.23804577e-01f, -3.71756591e-02f, 1.38106514e-02f, -3.32776643e-02f, 4.90272567e-02f, 1.03730010e-02f,
  1.76495072e-02f, -3.35516892e-02f, -1.21052608e-01f, 3.30961458e-02f, 2.20649671e-02f, 4.78821527e-03f, 8.90122801e-02f, 7.01805949e-02f, -4.75834273e-02f, 5.06918207e-02f,
  -2.17869505e-02f, 6.21821033e-03f, -8.15042704e-02f, -1.05849929e-01f, -5.02509326e-02f, -1.75346732e-02f, -8.93206596e-02f, 4.86375876e-02f, 5.11082821e-02f, -6.93927258e-02f,
  -3.16054001e-02f, -6.49449788e-03f, -1.44645069e-02f, -9.78114679e-02f, 5.28532341e-02f, 2.57205293e-02f, -5.80086969e-02f, 5.72176203e-02f, 1.66302435e-02f, 5.16403429e-02f,
  -1.12990346e-02f, 6.49879798e-02f, 4.83113788e-02f, 1.23854600e-01f, -5.54153845e-02f, 3.36412340e-02f, -2.74846815e-02f, -3.45144495e-02f, -3.62140909e-02f, 1.94634893e-03f,
  -4.00099576e-01f, -3.14738899e-01f, -6.64445013e-02f, -2.70049088e-02f, -3.83504815e-02f, 4.06817496e-02f, 6.40296489e-02f, -8.59474838e-02f, -8.07525665e-02f, 1.30143926e-01f,
  -9.92709845e-02f, 7.59067237e-02f, 9.93001391e-04f, 1.61351543e-02f, -6.00291826e-02f, -8.02753866e-02f, 1.42599493e-02f, -1.16691694e-01f, -3.50232050e-03f, -1.63445294e-01f,
  -9.73833129e-02f, 3.12718712e-02f, -8.11175164e-03f, 2.54375264e-02f, 5.18780686e-02f, 1.30764008e-01f, 3.57858837e-02f, -1.03426047e-01f, -1.14455540e-02f, -1.49283484e-02f,
  1.18749082e-01f, 2.24823028e-01f, 3.65599066e-01f, -6.28899410e-02f, 1.26884338e-02f, -3.14689502e-02f, -1.36726364e-01f, -3.26087065e-02f, 4.76446114e-02f, 1.98027655e-01f,
  -2.39314884e-01f, 2.89367199e-01f, -1.33670911e-01f, -8.75518285e-03f, -3.67831498e-01f, -2.64173836e-01f, -1.61394536e-01f, 7.96814337e-02f, -6.83447421e-02f, -6.74742907e-02f,
  -1.34747073e-01f, -3.19626689e-01f, -1.07801534e-01f, -1.58880502e-01f, 1.07218161e-01f, 1.66344061e-01f, -1.47261351e-01f, -1.26388937e-01f, 1.30371317e-01f, -3.23048048e-02f,
  1.64948593e-04f, -5.59010245e-02f, 9.56632122e-02f, 2.46446040e-02f, -5.24345711e-02f, 1.29189352e-02f, -1.32469520e-01f, 2.58645676e-02f, -7.93455634e-03f, 3.50041389e-02f,
  1.47188827e-02f, 2.96417903e-03f, 1.87736899e-02f, 4.34964523e-02f, 2.72022523e-02f, 7.24476874e-02f, -5.90913370e-02f, 9.91736874e-02f, 6.90851063e-02f, 6.70560449e-02f,
  -1.02373706e-02f, 6.42892569e-02f, 1.02968886e-01f, 2.33321125e-03f, 7.42645934e-02f, 8.23953375e-02f, 5.17058969e-02f, 9.01474282e-02f, 6.66247681e-02f, 1.05895363e-01f,
  -6.27659038e-02f, -1.33963078e-01f, 1.47265964e-03f, 3.13347392e-02f, -5.53345606e-02f, 3.74803655e-02f, -5.88213280e-02f, -4.83415872e-02f, -9.44658928e-03f, -7.58192241e-02f,
  2.29314696e-02f, 1.57441497e-01f, -9.11652893e-02f, 8.64849314e-02f, -1.13550022e-01f, -1.80316027e-02f, 1.04544722e-02f, -3.38000478e-04f, -3.22960988e-02f, 4.49163914e-02f,
  -1.01592727e-01f, 7.37481657e-03f, -4.14328538e-02f, -5.49955070e-02f, -6.74065799e-02f, -6.06038198e-02f, 4.68697250e-02f, -8.91042314e-03f, -1.84930991e-02f, -7.39858076e-02f,
  1.22722881e-02f, -1.60759524e-01f, -9.10314023e-02f, 2.08696034e-02f, -2.09617112e-02f, 1.36668133e-02f, -1.25970885e-01f, 9.56061259e-02f, -2.56953090e-02f, -1.32219687e-01f,
  1.51318014e-02f, 2.33260896e-02f, 1.69748603e-03f, 4.00392413e-02f, -8.85452852e-02f, 9.24384128e-03f, -5.54107204e-02f, -6.29462972e-02f, 2.13442426e-02f, -7.83011168e-02f,
  -2.60888468e-02f, -7.46664777e-02f, -6.04285114e-02f, -6.10247673e-03f, 1.30846500e-02f, 8.09104443e-02f, 5.66278361e-02f, 5.20417020e-02f, 3.07995416e-02f, 6.12454265e-02f,
  2.77131230e-01f, -1.20800190e-01f, 1.91968232e-02f, 2.38980055e-01f, 1.29646257e-01f, 1.63525999e-01f, 2.88344979e-01f, 9.82570574e-02f, 4.65556949e-01f, 1.65765062e-02f,
  1.89034250e-02f, -1.38351828e-01f, -1.50037423e-01f, 1.51766673e-01f, 5.55028394e-02f, 1.19178891e-01f, 2.27364048e-01f, 9.02816504e-02f, 1.67283505e-01f, 1.01512969e-01f,
  1.64961204e-01f, -2.84706000e-02f, -1.24005713e-01f, -1.73824936e-01f, 4.93631475e-02f, -5.31803705e-02f, -1.80281892e-01f, -9.23555568e-02f, -1.97525427e-01f, 2.60425452e-02f,
  1.42095059e-01f, 4.84185182e-02f, -2.57544983e-02f, -2.34227683e-02f, -9.32896882e-02f, -6.26871362e-02f, -4.18152250e-02f, -7.29445145e-02f, -6.74124137e-02f, 8.82328767e-03f,
  5.65728061e-02f, -2.15527751e-02f, 8.19117129e-02f, 9.07673910e-02f, 6.66128322e-02f, -1.08168395e-02f, 3.49518321e-02f, 5.63239790e-02f, -1.35992527e-01f, 4.86014935e-04f,
  8.62515047e-02f, 7.15913028e-02f, 2.71868985e-02f, 5.05863456e-03f, 1.94111019e-02f, 1.19244486e-01f, 8.78122635e-03f, -7.14311227e-02f, 7.24833459e-02f, 8.68712515e-02f,
  -4.12736908e-02f, -3.07551911e-03f, 4.70384248e-02f, -1.26316594e-02f, 1.01562804e-02f, 6.06484935e-02f, 2.81571336e-02f, -5.60835190e-02f, 1.44217044e-01f, -6.00196384e-02f,
  7.54247308e-02f, 7.83511698e-02f, 5.92050999e-02f, -1.09792948e-01f, 6.02292605e-02f, -7.94245396e-03f, -9.53639969e-02f, 5.18006906e-02f, 2.28441339e-02f, -7.97569901e-02f,
  9.51665454e-03f, 1.16425999e-01f, -1.69475213e-01f, -7.35712796e-02f, -9.83773842e-02f, 4.11662534e-02f, -2.69910228e-02f, 3.06605529e-02f, 2.74210870e-02f, -2.34096404e-02f,
  8.77188817e-02f, -1.97907053e-02f, 1.74894426e-02f, 4.52787988e-02f, -1.81961823e-02f, -7.46876746e-02f, 3.78947482e-02f, 8.29799771e-02f, -7.20938062e-03f, -2.27462575e-02f,
  -1.55898966e-02f, 6.20219409e-02f, 7.47500826e-03f, 3.99793349e-02f, -9.04164016e-02f, -4.28933427e-02f, 2.98823579e-03f, -3.43029872e-02f, -3.12674120e-02f, -3.84975411e-02f,
  -2.17752717e-02f, 2.62102075e-02f, 4.43268083e-02f, 5.68942465e-02f, 8.08755029e-03f, -1.17493346e-01f, 6.21541031e-02f, -4.51939665e-02f, 2.95000952e-02f, 7.49535337e-02f,
  2.54005045e-01f, -1.54667214e-01f, -4.52506077e-03f, 3.05281907e-01f, 3.87241960e-01f, 2.36542672e-01f, 1.52588442e-01f, 2.36801043e-01f, 5.39109647e-01f, -2.35746186e-02f,
  1.05644815e-01f, 1.62974689e-02f, -1.15832075e-01f, 4.03026529e-02f, 2.03086615e-01f, -3.45702246e-02f, 2.04894319e-01f, 9.41656306e-02f, 1.64515898e-01f, 1.16660349e-01f,
  1.64414510e-01f, 1.71837602e-02f, -2.47614309e-01f, -1.94206104e-01f, 6.89003691e-02f, -1.34151906e-01f, -2.42443055e-01f, -1.09791093e-01f, -1.73429236e-01f, 4.29432392e-02f,
  8.65096878e-03f, 3.85111496e-02f, -9.58091542e-02f, -8.12446997e-02f, 3.47464085e-02f, -1.34251356e-01f, -5.55519834e-02f, -8.07467625e-02f, -2.48064343e-02f, -6.91797584e-02f,
  -1.32245287e-01f, -3.87780108e-02f, 1.42325476e-01f, 5.08654304e-02f, 1.43808395e-01f, -6.04209453e-02f, 2.44805124e-03f, -2.75549479e-02f, 8.18651821e-03f, 5.43917120e-02f,
  -3.93805392e-02f, 1.76710971e-02f, 3.18073593e-02f, -7.95750916e-02f, -6.13145418e-02f, 2.99317632e-02f, -4.99982834e-02f, -8.80934447e-02f, 1.66129619e-02f, 9.67692062e-02f,
  1.61159523e-02f, 2.21336987e-02f, -1.31467700e-01f, 8.06406699e-03f, -5.88355176e-02f, -2.25421377e-02f, -2.87786257e-02f, -9.15823579e-02f, 2.89071426e-02f, 4.42831889e-02f,
  -6.61392882e-02f, 7.66081316e-03f, 6.20226264e-02f, -6.25835657e-02f, -7.83796459e-02f, -3.70573886e-02f, -3.88375819e-02f, -4.67724018e-02f, 3.63378040e-02f, 5.62105328e-02f,
  8.78098533e-02f, -1.28768086e-02f, -7.02185109e-02f, 1.29991714e-02f, 2.28546914e-02f, -2.12454535e-02f, 4.18680236e-02f, 6.89681992e-03f, -6.07854798e-02f, -6.34530261e-02f,
  1.80240586e-01f, 3.89126688e-02f, -4.15440425e-02f, -4.85749729e-02f, -1.40284328e-02f, 1.55734509e-01f, 1.15737833e-01f, 4.69175354e-02f, 6.46012556e-03f, 1.63290706e-02f,
  2.85506789e-02f, 8.57773498e-02f, -6.62515163e-02f, -3.72441299e-02f, -8.37950855e-02f, -4.75236960e-02f, -2.67224535e-02f, 7.55828666e-03f, 8.25593695e-02f, -3.67662162e-02f,
  -2.73238216e-02f, 6.32840320e-02f, 8.37723762e-02f, 2.59533431e-02f, -4.39833477e-02f, -6.48455024e-02f, 3.68530713e-02f, -1.04737030e-02f, -3.75730917e-02f, 1.12418614e-01f,
  2.71116316e-01f, -1.88858226e-01f, -9.71480608e-02f, 1.60664126e-01f, 2.48905048e-01f, 1.35011703e-01f, 9.69007835e-02f, 2.03033593e-02f, -2.98119802e-02f, -1.45744890e-01f,
  -8.08002334e-03f, -2.06018105e-01f, -1.66798875e-01f, 8.51249043e-03f, 2.16099605e-01f, -5.86903952e-02f, 8.43071938e-02f, 7.28909001e-02f, 1.42822880e-03f, -3.26110683e-02f,
  3.67657803e-02f, 1.94807127e-01f, 6.14139065e-03f, -6.87971935e-02f, 1.76305026e-01f, -1.77586393e-03f, 8.85267258e-02f, -9.07991901e-02f, 3.95344682e-02f, 5.52242361e-02f,
  1.18973013e-02f, 5.68602867e-02f, 1.00717030e-01f, 8.32477584e-03f, -1.04665764e-01f, 1.19996276e-02f, 2.15423154e-03f, -2.83225086e-02f, 8.41355417e-03f, -4.79095131e-02f,
  -9.69484355e-03f, 3.97740714e-02f, 7.31180906e-02f, -8.34709629e-02f, 1.50879234e-01f, 9.13792402e-02f, -2.89731640e-02f, 4.01174203e-02f, 3.73289697e-02f, -9.05477442e-03f,
  -3.95914912e-02f, -4.68859263e-02f, 8.74860287e-02f, -4.64661568e-02f, -1.22850332e-02f, -7.34027661e-03f, 6.15049638e-02f, -4.52023260e-02f, -1.53441234e-02f, 1.38787359e-01f,
  -1.24071995e-02f, 4.68750708e-02f, -8.59179348e-02f, 7.32005462e-02f, -2.14912947e-02f, 6.86111972e-02f, -2.74836309e-02f, -3.43448482e-02f, -5.64046800e-02f, 8.83355364e-02f,
  -1.13786822e-02f, -6.80877417e-02f, 8.16003382e-02f, -8.24644566e-02f, 1.01933770e-01f, 1.16449855e-01f, 3.70896570e-02f, -2.71590352e-02f, -7.01567158e-02f, 6.55539408e-02f,
  3.03535331e-02f, -3.98178101e-02f, 3.86477122e-03f, -1.84470788e-02f, -2.07619704e-02f, -6.00610338e-02f, -7.69330487e-02f, -1.95268914e-02f, 3.72433700e-02f, -9.67245921e-03f,
  -2.54982442e-01f, -3.14159721e-01f, 5.29912151e-02f, 9.08552930e-02f, -1.39355853e-01f, -9.02564153e-02f, -3.85950814e-04f, 9.21098515e-02f, -6.32431582e-02f, -3.37072052e-02f,
  2.35484610e-03f, 6.12322949e-02f, -8.57065618e-03f, -1.42262563e-01f, 1.23744383e-01f, -5.48241585e-02f, -5.51305674e-02f, 7.01835304e-02f, 1.49796724e-01f, 8.30428600e-02f,
  -4.78453375e-02f, -8.47569257e-02f, 9.95187089e-02f, -6.38426049e-03f, -4.36207913e-02f, -4.88569811e-02f, -2.32919045e-02f, 9.83850099e-03f, -8.59923288e-02f, -4.53799926e-02f,
  -2.80662864e-01f, -1.46186844e-01f, -1.89660370e-01f, 2.98298448e-02f, 7.06521347e-02f, 1.96661949e-01f, 1.90138981e-01f, -1.63842872e-01f, -1.74621388e-01f, 1.35951415e-01f,
  3.82350653e-01f, -9.64815845e-04f, 5.36371674e-03f, 1.49640501e-01f, 1.08600318e-01f, 2.74598529e-03f, 1.27915502e-01f, 9.34048146e-02f, -2.28830293e-01f, -1.71319276e-01f,
  -1.48336083e-01f, 1.75302431e-01f, 1.00045897e-01f, -7.50619024e-02f, 6.25522956e-02f, -1.36231035e-01f, 1.67900428e-01f, 5.23350462e-02f, 1.20909214e-01f, 6.90161660e-02f,
  -2.24892665e-02f, -2.83907592e-01f, -8.93789902e-03f, -1.33313835e-01f, 1.49128144e-03f, 2.14343946e-02f, -6.56933663e-03f, 1.51027098e-01f, 4.47124690e-02f, 3.45827383e-03f,
  -3.78339067e-02f, -2.57135313e-02f, 1.35046300e-02f, -4.90676053e-03f, -1.10118926e-01f, -8.58957767e-02f, 3.78656127e-02f, 2.01151639e-01f, -6.95817843e-02f, 3.99621651e-02f,
  -4.44358848e-02f, 5.31148501e-02f, 6.32784367e-02f, 1.15525976e-01f, 2.32971869e-02f, 7.95960575e-02f, -3.44658419e-02f, -8.94971266e-02f, -8.42203014e-03f, 7.03934580e-02f,
  -6.80503622e-02f, -1.50515018e-02f, -1.62802279e-01f, 4.93639987e-03f, 4.98692952e-02f, 1.10056207e-01f, -1.09581777e-03f, 1.13061979e-01f, 4.03105877e-02f, -4.87607792e-02f,
  9.33273137e-02f, -2.74167949e-04f, 2.91502364e-02f, 2.83473339e-02f, -1.05859376e-02f, 8.60214010e-02f, 1.89204663e-02f, -2.09374893e-02f, 3.60820368e-02f, -5.70333824e-02f,
  5.64760976e-02f, 2.79175993e-02f, 5.76252490e-02f, -1.04837678e-02f, -1.09796366e-02f, 4.59437519e-02f, 6.55844659e-02f, -1.94154158e-02f, 8.37230384e-02f, 7.64388964e-02f,
  -1.24203630e-01f, -2.72044897e-01f, -5.09760007e-02f, 3.55817378e-02f, -3.85867693e-02f, -3.94325443e-02f, 1.34613225e-02f, 8.57278612e-03f, -1.40569191e-02f, -1.40043152e-02f,
  -8.63250196e-02f, -1.08167641e-02f, -5.14106639e-02f, 6.07676208e-02f, 7.11980695e-03f, -3.76939140e-02f, 3.03596966e-02f, 7.57033005e-02f, -8.92094709e-03f, -8.43541846e-02f,
  -2.34305602e-03f, -6.61894307e-02f, 4.64108884e-02f, -1.03455052e-01f, 4.16976660e-02f, 3.46750841e-02f, -6.54127598e-02f, -4.24187109e-02f, 1.19782072e-02f, 5.19299693e-02f,
  -1.30195007e-01f, -1.21581424e-02f, -3.46487254e-01f, -1.84573740e-01f, -8.54452979e-03f, 1.30681425e-01f, 6.50172755e-02f, 4.81338203e-02f, -2.68389225e-01f, 2.87257433e-01f,
  3.36561829e-01f, -2.69979924e-01f, 8.92855078e-02f, 2.22267821e-01f, -3.42001766e-01f, -4.58645262e-02f, 1.60434231e-01f, 9.23018903e-02f, -1.16556548e-01f, -2.35877503e-02f,
  -1.77701086e-01f, 2.08958387e-01f, -1.62129313e-01f, 2.06155598e-01f, 9.33775976e-02f, -8.78332853e-02f, 2.58679926e-01f, -3.36356163e-02f, 1.98661849e-01f, -2.96314247e-04f,
  6.60459325e-02f, 4.60416265e-02f, -9.22053754e-02f, -8.14341530e-02f, 1.24371462e-01f, 1.28316671e-01f, 5.35924174e-02f, 1.23045743e-02f, -1.32804334e-01f, -3.09611969e-02f,
  7.78339729e-02f, -4.68625985e-02f, 1.69123895e-03f, -1.58342585e-01f, 5.27667766e-03f, -6.19459637e-02f, -1.88955368e-04f, -4.86772619e-02f, 4.79010642e-02f, 4.70763855e-02f,
  -7.27178976e-02f, -1.72090624e-02f, 4.91085276e-02f, -3.12370621e-02f, -2.98770536e-02f, 1.47268130e-02f, -1.06170595e-01f, -5.42016793e-03f, 1.07439823e-01f, -1.33683849e-02f,
  5.40056154e-02f, 5.41443788e-02f, 6.07037693e-02f, 5.38674295e-02f, -6.85341582e-02f, 9.73908082e-02f, 3.96108329e-02f, 9.77780595e-02f, -1.28707603e-01f, 5.41807003e-02f,
  1.78172141e-02f, 1.88096496e-03f, 1.07685655e-01f, 1.50245065e-02f, -5.82892299e-02f, -4.66937236e-02f, 1.12168081e-02f, -3.59605849e-02f, -8.10542852e-02f, 1.51766539e-02f,
  1.10238455e-01f, 1.87222958e-02f, 7.12545961e-02f, 1.30869687e-01f, 3.67392153e-02f, -5.24489284e-02f, -2.82908068e-03f, -7.16458261e-02f, 6.37028888e-02f, -9.63233353e-04f,
  8.71789902e-02f, -3.22970338e-02f, -9.66021689e-05f, -8.90001431e-02f, -1.21755078e-02f, 5.66193163e-02f, -4.35981266e-02f, -5.28597571e-02f, -5.20918556e-02f, 3.61397862e-02f,
  8.01797863e-03f, -4.08917246e-03f, 7.30932504e-02f, -3.31576616e-02f, -5.15495129e-02f, 4.64144573e-02f, 7.48750269e-02f, -3.76937278e-02f, -4.58231159e-02f, -2.36385111e-02f,
  1.23264670e-01f, 1.34350449e-01f, -8.95889774e-02f, 4.58040424e-02f, 4.94356118e-02f, 9.68165025e-02f, 2.04693470e-02f, 4.19126004e-02f, 2.71331500e-02f, -3.88789400e-02f,
  6.37699366e-02f, 7.41787553e-02f, -1.28644183e-01f, -1.61679491e-01f, 1.63800701e-01f, -4.52595316e-02f, -3.59606766e-03f, -3.37460563e-02f, -1.26950681e-01f, 2.13307738e-01f,
  -8.19302201e-02f, -1.01065353e-01f, -1.03570290e-01f, -2.57110566e-01f, -2.97242880e-01f, -2.61179239e-01f, -1.85746282e-01f, -8.13519210e-02f, -1.51445925e-01f, 1.63927987e-01f,
  -1.02156565e-01f, 1.05269728e-02f, -1.75285012e-01f, 1.40344426e-01f, 8.22214782e-02f, 2.02309355e-01f, 2.45698676e-01f, 1.53918490e-01f, 1.35690153e-01f, -6.76340237e-02f,
  -1.22624375e-01f, -4.66187000e-02f, -5.69421500e-02f, -3.22815925e-02f, 8.50486383e-02f, 7.38143995e-02f, 9.80962887e-02f, -1.00237980e-01f, -5.16753234e-02f, -1.95838474e-02f,
  -6.08215109e-02f, -1.50377385e-03f, -4.31121662e-02f, 1.40179200e-02f, 3.13716419e-02f, 8.64408985e-02f, -2.76301224e-02f, 1.35794897e-02f, 1.22475775e-03f, -3.82516882e-03f,
  -4.70359586e-02f, 9.06179026e-02f, 7.01582208e-02f, -8.75954181e-02f, -1.24293655e-01f, 1.15030473e-02f, 9.49918926e-02f, 9.22844000e-03f, 1.04147814e-01f, -3.94883305e-02f,
  8.98069143e-02f, 1.27529934e-01f, 1.88131947e-02f, -1.08297177e-01f, 6.53637648e-02f, -5.46042547e-02f, 8.80941842e-03f, 6.77273085e-04f, 8.80201012e-02f, 4.72234376e-02f,
  2.95821074e-02f, -3.84787358e-02f, -1.38759658e-01f, -8.36604927e-03f, -7.84567371e-03f, -1.00987107e-01f, 8.06825310e-02f, -9.49273352e-03f, -5.11622317e-02f, -3.08543220e-02f,
  -9.83657762e-02f, -2.47975886e-02f, -4.07964960e-02f, -1.00040331e-01f, -1.19323440e-01f, -4.41069975e-02f, -5.28101772e-02f, -9.75446925e-02f, 7.87661504e-03f, 4.07827972e-03f,
  -5.88231012e-02f, 6.65569752e-02f, 1.80078950e-02f, 6.91445265e-03f, 7.33402604e-03f, 4.30698432e-02f, 4.85043004e-02f, -7.64841437e-02f, 2.34696027e-02f, 4.98105139e-02f,
  3.24807428e-02f, 1.05130211e-01f, 7.91210309e-02f, -6.93482310e-02f, -6.04966916e-02f, 8.13603327e-02f, 1.04645751e-01f, -6.45290613e-02f, 1.31425172e-01f, -9.69700813e-02f,
  2.06689872e-02f, 2.28922721e-02f, -9.50072706e-03f, 7.77940676e-02f, 3.25359777e-02f, 4.78724577e-02f, 5.26743867e-02f, 6.92859516e-02f, 8.09100643e-02f, -2.61164829e-02f,
  7.20467269e-02f, 3.91952962e-01f, 7.65525363e-03f, 1.88212693e-01f, -7.76736587e-02f, 9.65472534e-02f, 2.27851167e-01f, -4.53413948e-02f, 1.33417500e-02f, 2.92323530e-01f,
  -8.27323198e-02f, 1.41660403e-02f, 1.09259412e-01f, 3.17954510e-01f, -5.09649189e-03f, 1.32631147e-02f, 2.26185679e-01f, 1.10512532e-01f, -8.45803320e-02f, 2.22266436e-01f,
  1.01798981e-01f, 2.40567654e-01f, 4.06991690e-02f, -2.20007077e-02f, 1.86192870e-01f, 2.75661703e-02f, 9.20502916e-02f, -1.32060274e-01f, 1.11166947e-01f, -1.18584268e-01f,
  5.77113293e-02f, 6.27824385e-03f, 2.47598216e-02f, 9.47878882e-03f, 1.29686728e-01f, 4.42862287e-02f, -5.39426021e-02f, 5.61015643e-02f, -9.44539458e-02f, -3.47255394e-02f,
  -1.89474598e-02f, -4.48331311e-02f, -4.61972244e-02f, -7.45587945e-02f, 8.18607882e-02f, -5.16014844e-02f, -1.07239345e-02f, 5.48331067e-02f, 4.70082741e-03f, 3.39890234e-02f,
  7.46865794e-02f, 1.14628904e-01f, 1.18370928e-01f, 1.79696202e-01f, -1.16934162e-02f, 3.66070424e-03f, 4.48461622e-02f, 6.98356479e-02f, -6.89554773e-03f, 8.06972235e-02f,
  -5.14750145e-02f, 2.58893073e-02f, -6.35653455e-03f, -4.89229858e-02f, 8.59334916e-02f, -4.05915128e-03f, -3.11291162e-02f, -5.69689758e-02f, -8.12533647e-02f, 5.61428741e-02f,
  -6.55600578e-02f, 3.43052391e-03f, -3.64959426e-02f, 6.16249163e-03f, -2.20154971e-02f, 2.17509463e-01f, -1.23528853e-01f, -7.76407644e-02f, 5.73464669e-02f, -7.74933770e-02f,
  -2.23854110e-02f, -4.81456704e-02f, -2.49387790e-03f, -9.62287560e-02f, -1.06614091e-01f, -7.17235878e-02f, -4.05809619e-02f, -1.07643213e-02f, -7.34045804e-02f, -1.26011044e-01f,
  1.61824614e-01f, 2.39142656e-01f, -1.53252587e-03f, 1.76166203e-02f, 1.51611781e-02f, 1.03354096e-01f, -1.97067112e-03f, -1.11737084e-02f, 4.43926714e-02f, 5.34181632e-02f,
  1.08016476e-01f, -2.88235117e-02f, 1.04361102e-01f, -7.14883814e-03f, -6.52441159e-02f, 2.07223564e-01f, 1.25737533e-01f, -7.57605657e-02f, 1.70444120e-02f, -9.10676569e-02f,
  -2.09122542e-02f, 1.92066059e-01f, -8.76265317e-02f, 7.02816620e-02f, -4.95414846e-02f, 8.49510636e-03f, 1.24435201e-02f, 1.58521190e-01f, 6.01118654e-02f, 2.90928911e-02f,
  9.56468433e-02f, 2.05073063e-03f, -1.49453014e-01f, -1.12145349e-01f, -1.85783565e-01f, -6.47950619e-02f, -6.90346211e-02f, -2.90185094e-01f, 1.31015122e-01f, -1.67984590e-02f,
  -1.82674050e-01f, 2.67119884e-01f, 1.14964321e-01f, -2.92448908e-01f, 3.95669192e-01f, 1.97980046e-01f, -7.00045750e-02f, -4.94851731e-03f, -9.91669521e-02f, 2.02157870e-02f,
  -2.10333383e-03f, -1.00386865e-01f, -1.46968901e-01f, -2.43613333e-01f, -2.45034799e-01f, -1.38085753e-01f, -1.15625583e-01f, -1.86060295e-01f, -3.35993558e-01f, -2.68113278e-02f,
  -2.07535420e-02f, 2.92689037e-02f, -7.63009042e-02f, 5.28628379e-02f, -1.31858988e-02f, 1.43624507e-02f, -1.55649334e-01f, 3.19745811e-03f, 9.78799816e-03f, -6.62958622e-02f,
  1.07770085e-01f, 6.51891902e-02f, 2.20151115e-02f, 7.33535290e-02f, -1.68399524e-03f, -1.04040066e-02f, -1.36711551e-02f, -8.85406286e-02f, -1.85390282e-02f, 6.73114508e-02f,
  4.10493650e-02f, 5.47851361e-02f, 1.72283314e-02f, 3.27465357e-03f, 2.36524895e-04f, -1.73745044e-02f, 3.12173106e-02f, 5.09884730e-02f, 8.03392008e-02f, 1.16417177e-01f,
  -1.18485475e-02f, 8.95426795e-02f, 5.85324271e-03f, -4.85876538e-02f, -6.85083568e-02f, -1.52611127e-02f, 5.80846108e-02f, -6.80851657e-03f, -4.80245007e-03f, 3.50993476e-03f,
  -6.65140972e-02f, -5.97163998e-02f, -2.69181821e-02f, 9.19557661e-02f, -2.52642725e-02f, 1.10174092e-02f, -4.76439893e-02f, -4.64783907e-02f, -4.96295877e-02f, 4.59503829e-02f,
  3.53660807e-02f, 1.14162736e-01f, -1.78985745e-02f, -1.38296798e-01f, -1.32618815e-01f, 2.51704399e-02f, -3.78764607e-02f, 3.26592326e-02f, -3.36584412e-02f, -2.80197151e-02f,
  4.31456454e-02f, 3.52564566e-02f, -5.99329323e-02f, 4.05884795e-02f, 1.27533013e-02f, 5.37709706e-02f, -5.46040908e-02f, 3.39152925e-02f, -3.70590426e-02f, 1.09606288e-01f,
  -2.32002102e-02f, 6.02543317e-02f, -3.85791920e-02f, -3.44235636e-02f, -8.18368699e-03f, -1.00460146e-02f, -5.47522381e-02f, -3.50597277e-02f, -1.20437387e-02f, -3.12722214e-02f,
  -1.53606711e-02f, 3.03884968e-02f, 1.87620312e-01f, 1.30140707e-01f, 2.64055356e-02f, -9.98629350e-03f, 5.82860373e-02f, -3.43586653e-02f, 4.00381535e-02f, 6.22345656e-02f,
  3.34366262e-01f, 2.44457647e-01f, 2.98274249e-01f, 2.55751580e-01f, -5.87344356e-02f, -1.90619558e-01f, -7.69340768e-02f, 4.44077440e-02f, 4.76683080e-02f, -3.91235352e-02f,
  -1.75772503e-01f, 2.67124891e-01f, -1.56379059e-01f, 2.24597633e-01f, -2.21605331e-01f, -1.96606129e-01f, 4.98749986e-02f, 2.92897783e-02f, -2.34844070e-02f, 1.35650471e-01f,
  7.53759071e-02f, -2.30358094e-01f, 3.65744568e-02f, -2.48041764e-01f, 9.27498639e-02f, 1.10428534e-01f, -1.94420382e-01f, -3.66745405e-02f, 8.76330137e-02f, -1.35499552e-01f,
  -1.66492746e-03f, 9.58337076e-03f, 1.26972690e-01f, -3.79628874e-02f, 3.97375971e-02f, 3.98255065e-02f, -2.89293639e-02f, -1.89019591e-01f, -2.53374781e-02f, 9.19934735e-02f,
  7.37284273e-02f, -4.11544442e-02f, -5.34033542e-03f, -7.14476407e-02f, -4.02740166e-02f, 6.70539215e-02f, 1.39805585e-01f, 2.40064070e-01f, 5.10205980e-03f, 1.61895216e-01f,
  1.44862771e-01f, 1.41737685e-01f, 1.25570193e-01f, -1.31592783e-03f, 2.08821874e-02f, 6.57770485e-02f, 3.45296897e-02f, 8.18730742e-02f, -5.95697612e-02f, 1.15623690e-01f,
  6.23615868e-02f, 1.76584292e-02f, -5.58442436e-02f, -1.13719814e-01f, -8.78494158e-02f, -2.98677739e-02f, -3.20622814e-03f, -4.61901575e-02f, -4.66992408e-02f, 7.70407841e-02f,
  -1.22437567e-01f, 7.98949078e-02f, -4.03649267e-03f, 2.26441659e-02f, 5.77902347e-02f, -5.84608167e-02f, -4.19728644e-02f, 1.94197241e-02f, 1.25093032e-02f, 2.49362513e-02f,
  -6.27060682e-02f, -5.78169785e-02f, -5.30698299e-02f, -4.68560383e-02f, -9.73012298e-02f, -1.44525636e-02f, 1.53308362e-01f, 2.61763092e-02f, -4.22535017e-02f, 5.75393550e-02f,
  1.68370716e-02f, 3.16265151e-02f, -4.60063592e-02f, -5.63168526e-02f, -2.37320326e-02f, -2.70048007e-02f, -8.18205774e-02f, 5.08553125e-02f, 1.15300855e-02f, -1.01771168e-01f,
  7.89838731e-02f, -1.95701583e-03f, -1.12316769e-03f, -2.38229521e-02f, -7.88222849e-02f, -8.24419316e-03f, 4.74072993e-02f, -3.67598678e-03f, 1.40600190e-01f, 3.46905477e-02f,
  8.50308463e-02f, -1.11052580e-01f, 4.82915118e-02f, 5.20114265e-02f, -4.12559399e-04f, 1.16192056e-02f, 8.66865814e-02f, 4.80879918e-02f, 3.51857878e-02f, 7.67315477e-02f,
  2.98581749e-01f, 8.53976831e-02f, 1.61383986e-01f, 2.95967191e-01f, -2.66023785e-01f, 7.49196038e-02f, 1.27297297e-01f, 7.72108436e-02f, 3.21508080e-01f, 1.71243533e-01f,
  -2.16337174e-01f, 3.16109061e-01f, -1.78635657e-01f, 7.30889365e-02f, -2.22709849e-01f, 2.77575068e-02f, -2.86220629e-02f, 6.68264031e-02f, -7.77553320e-02f, 5.49548045e-02f,
  -1.46151870e-01f, -1.84163034e-01f, -1.27157733e-01f, -1.41784161e-01f, 1.19409345e-01f, 1.22231498e-01f, -3.31938654e-01f, -1.29660919e-01f, 1.35240396e-02f, -1.74442306e-01f,
  -1.27231553e-01f, 2.68083643e-02f, -4.50816564e-02f, 1.04649022e-01f, -3.13763805e-02f, -1.62229917e-04f, 2.73768278e-03f, -1.05624616e-01f, -9.77613032e-02f, 3.92680913e-02f,
  1.74694747e-01f, 1.83083296e-01f, 8.05569515e-02f, -3.93026322e-02f, 7.07871243e-02f, 3.98497544e-02f, 1.58353850e-01f, 1.85738113e-02f, 3.98878083e-02f, -1.38093652e-02f,
  9.55173671e-02f, 1.18611455e-01f, -6.99710334e-03f, -4.14101481e-02f, 3.46300714e-02f, 1.23496661e-02f, 1.53681457e-01f, 3.87659390e-03f, 4.52138856e-02f, 1.15985319e-01f,
  3.64153795e-02f, -1.39676258e-01f, -1.11792065e-01f, 2.33092252e-02f, 1.02943624e-03f, -1.27597779e-01f, 1.51212096e-01f, -1.93597376e-01f, -6.67886660e-02f, -6.89747110e-02f,
  -1.49396639e-02f, -2.03045225e-03f, 8.11858922e-02f, -3.14008035e-02f, -9.06028301e-02f, 7.75091499e-02f, -6.23264909e-02f, 5.36874793e-02f, 1.32660344e-01f, -4.08747606e-03f,
  5.06983697e-02f, 3.68660055e-02f, -7.95996189e-02f, -1.66461840e-01f, 1.24776084e-02f, 4.98081408e-02f, 1.05836838e-01f, -1.57760102e-02f, 1.67664196e-02f, -1.66357204e-01f,
  -1.52128592e-01f, -1.33553728e-01f, -1.42045096e-01f, 9.92633551e-02f, -3.01467776e-02f, -6.73492849e-02f, 2.87577305e-02f, 1.46257147e-01f, -9.27232057e-02f, 1.33763686e-01f,
  3.24057043e-02f, 1.27115011e-01f, 1.24059223e-01f, 4.74493206e-02f, -7.51488260e-04f, -1.58546641e-01f, -4.49595191e-02f, 6.29489869e-03f, -1.51029766e-01f, -4.33010161e-02f,
  -1.50172845e-01f, -9.50519368e-03f, -8.97016749e-02f, 3.19869854e-02f, -5.60346693e-02f, -2.42501013e-02f, -2.41431221e-02f, -9.21296254e-02f, -1.13707885e-01f, -8.35963264e-02f,
  -4.74806011e-01f, 2.54930574e-02f, 1.91542387e-01f, -3.51919770e-01f, -3.04843113e-02f, 2.86236703e-02f, -3.64514068e-02f, 1.72457285e-02f, -1.16927125e-01f, -3.39404754e-02f,
  -3.35210599e-02f, 7.21068233e-02f, 7.97837600e-02f, 2.63755806e-02f, 8.18566531e-02f, 3.76685299e-02f, -9.97768044e-02f, -9.16233063e-02f, 3.75792161e-02f, -1.90319777e-01f,
  -3.11412662e-02f, -5.59638515e-02f, 3.01101543e-02f, 1.58835247e-01f, 7.77457878e-02f, -5.19897938e-02f, -5.80733493e-02f, 6.72339499e-02f, 6.39806613e-02f, 1.71790451e-01f,
  -1.74571842e-01f, -2.47740790e-01f, -2.08249047e-01f, 9.88512635e-02f, -3.81834945e-03f, -2.75854766e-02f, -5.45688756e-02f, 1.01092301e-01f, -1.67606696e-01f, 6.34539053e-02f,
  -3.01891062e-02f, 2.22872142e-02f, 7.16906860e-02f, 5.32678328e-02f, -9.13469866e-02f, 1.47143174e-02f, 1.10754244e-01f, -9.54478048e-03f, 1.08090937e-01f, -4.86046076e-02f,
  1.27461910e-01f, -2.13509356e-03f, 2.56960448e-02f, -1.57013640e-03f, 6.35390207e-02f, -2.72636898e-02f, -5.09184450e-02f, 6.05843402e-02f, -1.75236631e-02f, 9.89040639e-03f,
  6.00245222e-02f, -5.91469835e-03f, 3.04160919e-02f, 7.11120218e-02f, 4.44521159e-02f, 1.14357091e-01f, -3.01253796e-02f, -3.42289954e-02f, -6.44809799e-03f, 6.40144646e-02f,
  -7.02054203e-02f, -7.39397332e-02f, 2.12059766e-02f, -2.39696763e-02f, 3.73485312e-02f, 3.77512202e-02f, -4.09167521e-02f, -4.57620211e-02f, 5.73489442e-02f, -2.42101848e-02f,
  5.04224412e-02f, 1.81338005e-03f, 1.45037435e-02f, -7.97736496e-02f, -8.77123997e-02f, 4.21073259e-04f, -4.86518256e-02f, -2.09244676e-02f, -3.38287689e-02f, 1.64560042e-02f,
  -4.03441131e-01f, -2.85809726e-01f, -9.46254283e-02f, -3.23987305e-02f, -4.84156832e-02f, -4.96638939e-02f, -6.27280176e-02f, 3.57497931e-02f, -9.52491835e-02f, 3.04214973e-02f,
  3.81204858e-02f, 6.39392436e-02f, 1.96472444e-02f, 3.60652506e-02f, 9.59312469e-02f, -6.51730448e-02f, -6.49190471e-02f, -2.06751730e-02f, -1.47625878e-01f, 7.24554658e-02f,
  4.06063050e-02f, -1.46660153e-02f, -6.21248363e-03f, -3.35754380e-02f, -2.27273926e-02f, -3.44222481e-03f, -1.04456075e-01f, 1.16797984e-01f, 6.30659685e-02f, -1.24541586e-02f,
  1.53491065e-01f, -5.36547415e-02f, -1.91368684e-02f, -5.88856917e-03f, -1.23968609e-01f, -3.19678575e-01f, -1.87648714e-01f, -1.02724306e-01f, -1.77429989e-01f, -4.07389272e-03f,
  -1.11937597e-01f, 2.48574261e-02f, -5.61493263e-03f, 2.66329274e-02f, 1.09932467e-01f, -1.25874072e-01f, 2.15552114e-02f, -2.04706624e-01f, -3.68401706e-02f, 2.16540247e-01f,
  6.06919527e-02f, 2.08005995e-01f, 1.18233442e-01f, 1.55880779e-01f, 4.60968353e-02f, 9.23722461e-02f, 3.17121506e-01f, 6.71778023e-02f, 6.83052689e-02f, -5.36374450e-02f,
  -4.53169979e-02f, 9.32261497e-02f, -4.27150317e-02f, -2.55155880e-02f, 8.93297493e-02f, 1.03150364e-02f, -9.69040021e-02f, -2.53461320e-02f, -4.95888293e-02f, 5.37863979e-03f,
  -6.05880171e-02f, 6.95014521e-02f, 2.54112687e-02f, 6.07372671e-02f, 7.86378011e-02f, -6.70333579e-02f, 7.58715793e-02f, -7.63448477e-02f, -5.49822971e-02f, 1.57888964e-01f,
  5.60409203e-02f, -1.26909455e-02f, 5.66364527e-02f, 1.07200090e-02f, 7.07948953e-02f, 1.20301880e-01f, 5.93632869e-02f, 4.04052101e-02f, -7.95389637e-02f, 6.13163924e-03f,
  4.05291021e-02f, -2.17707884e-02f, 2.63013151e-02f, -1.63050696e-01f, 3.57934926e-03f, 4.49669324e-02f, -3.24858800e-02f, -4.40110825e-02f, -1.42548112e-02f, 2.99180881e-03f,
  -1.35465309e-01f, 2.67681926e-02f, -3.54581326e-03f, -8.59475210e-02f, 7.45564923e-02f, -9.85242613e-03f, -8.42633322e-02f, -2.48079710e-02f, -6.46756887e-02f, -1.24957457e-01f,
  -1.33076876e-01f, 4.66833897e-02f, -9.84171480e-02f, 4.57105190e-02f, -5.99123985e-02f, 4.35216799e-02f, 9.89149958e-02f, -4.03529927e-02f, -3.87005843e-02f, -1.18310332e-01f,
  -1.62406098e-02f, 6.18011765e-02f, -7.01556739e-04f, -7.39941001e-02f, -2.64100395e-02f, -3.76395620e-02f, 2.46996265e-02f, -2.63820793e-02f, 7.22021535e-02f, 8.69608298e-03f,
  -4.26791981e-02f, 7.19182640e-02f, 1.91356670e-02f, 2.45194137e-02f, -5.46800718e-02f, 5.31826727e-02f, 1.76030844e-01f, -1.34954065e-01f, -1.44105041e-02f, -1.89311747e-02f,
  7.66139179e-02f, -1.33083342e-02f, 1.77398026e-02f, -1.39307573e-01f, 4.08440009e-02f, -3.02962493e-02f, 7.36868232e-02f, 7.57844653e-03f, 5.77367432e-02f, -3.55579965e-02f,
  1.97628047e-03f, -1.34101838e-01f, 3.19765478e-01f, -8.55167732e-02f, 1.42535090e-01f, 9.26545411e-02f, 1.26050055e-01f, -1.72237098e-01f, -2.14885652e-01f, -3.26448023e-01f,
  -6.19477741e-02f, 1.53468058e-01f, 5.75470068e-02f, 2.14568190e-02f, 5.55149429e-02f, -2.61873845e-02f, -8.52913186e-02f, -6.13923371e-02f, 6.62985817e-02f, 1.61750242e-02f,
  -9.86425504e-02f, -1.14531167e-01f, 1.94542080e-01f, -2.35651299e-01f, 1.08146466e-01f, -3.83583046e-02f, -1.09884068e-01f, 1.00561090e-01f, -8.89151394e-02f, 4.34579700e-02f,
  3.07915658e-02f, -8.42384845e-02f, 1.74096882e-01f, -2.92332377e-02f, -3.48029211e-02f, 6.90204427e-02f, 9.67749953e-02f, 1.38838425e-01f, 9.35880393e-02f, 4.44944836e-02f,
  8.57720301e-02f, -3.13937254e-02f, -6.20360905e-03f, 1.24269098e-01f, -8.28340724e-02f, 1.14533447e-01f, -3.09536476e-02f, 8.18284750e-02f, 6.79652989e-02f, 7.11811557e-02f,
  2.83218268e-02f, 9.75927636e-02f, 8.93122852e-02f, 8.70603509e-03f, 1.80851743e-02f, 6.27437755e-02f, 5.18553704e-02f, 7.41886124e-02f, 1.00967214e-02f, -7.54597187e-02f,
  -5.95043339e-02f, -8.59805271e-02f, -8.05811808e-02f, -3.80729362e-02f, -1.03049733e-01f, 4.10388224e-02f, 8.19484293e-02f, 1.23781152e-02f, -4.89519816e-03f, -1.17261589e-01f,
  -1.52304992e-01f, 5.62285818e-02f, -4.79752645e-02f, 7.99307302e-02f, -1.48602232e-01f, -3.58926728e-02f, 2.10541099e-01f, -6.07916154e-03f, -1.36125758e-01f, -4.27425429e-02f,
  -1.41246673e-02f, 3.06269377e-02f, 5.41619677e-03f, 1.31131768e-01f, -1.43786147e-01f, 1.16364889e-01f, 3.94615252e-03f, 4.76134419e-02f, 3.11339796e-02f, -2.39967052e-02f,
  -2.62419373e-01f, -2.70406604e-01f, -3.29489894e-02f, -1.12696877e-03f, -2.76002884e-02f, 2.10857596e-02f, 3.76149341e-02f, 2.13603526e-02f, -5.10171056e-02f, 3.21131498e-02f,
  2.72007845e-02f, -3.10086105e-02f, -1.09568700e-01f, 8.27924609e-02f, -3.53597142e-02f, 5.29744439e-02f, -6.49081841e-02f, -7.67945945e-02f, -1.16011359e-01f, -8.99436790e-03f,
  -9.73157585e-02f, -6.20183088e-02f, -7.54979486e-03f, -1.15577579e-02f, -7.87443966e-02f, -9.30650681e-02f, -3.48992757e-02f, -1.00593001e-01f, 9.90414992e-02f, 2.23514121e-02f,
  -9.04035717e-02f, -2.59374768e-01f, 8.96126404e-02f, -7.11674988e-02f, -8.61676261e-02f, 1.68554440e-01f, 2.46682748e-01f, -2.17567310e-01f, -2.45612934e-01f, -1.26626506e-01f,
  6.41913861e-02f, -9.05492529e-03f, 2.35218808e-01f, -8.53690431e-02f, 3.34665924e-01f, 2.03335851e-01f, 1.89012624e-02f, 7.44512975e-02f, -1.21575318e-01f, -2.20463008e-01f,
  -8.89595002e-02f, -1.68440834e-01f, 1.12600371e-01f, -3.00179601e-01f, -2.19815567e-01f, -1.07472591e-01f, 7.75817141e-04f, 1.33238509e-01f, -1.60414249e-01f, 1.79340113e-02f,
  -1.74710061e-02f, -2.72398770e-01f, -9.55660939e-02f, -6.39023259e-02f, -8.86406228e-02f, -3.99506688e-02f, 1.33177107e-02f, 1.81814224e-01f, -2.09944509e-02f, -8.68373513e-02f,
  5.63909821e-02f, 2.56576631e-02f, -8.90803188e-02f, 2.20315773e-02f, -1.38080316e-02f, -5.35866693e-02f, -6.82404218e-03f, -7.68927950e-03f, -3.85256447e-02f, -3.36077139e-02f,
  -3.78461145e-02f, -4.44771126e-02f, -2.74328496e-02f, 6.86190352e-02f, 6.84999302e-02f, -2.65757591e-02f, 2.73820627e-02f, 6.65211454e-02f, -8.05831999e-02f, -1.32295683e-01f,
  -8.99270326e-02f, 8.19880143e-02f, 4.91397716e-02f, -2.58707087e-02f, -1.60663333e-02f, 3.25355828e-02f, 5.89699671e-02f, -4.92222644e-02f, 2.81723682e-02f, -2.51497012e-02f,
  -1.90787800e-02f, -9.81249139e-02f, -2.10910644e-02f, 3.23506370e-02f, 4.36856188e-02f, 1.38644995e-02f, -2.84509156e-02f, -7.78090060e-02f, -4.13766839e-02f, 5.04120477e-02f,
  8.33014473e-02f, -4.29340005e-02f, 2.12014448e-02f, 2.91391220e-02f, 1.18798204e-03f, 8.33993778e-02f, -1.34234995e-01f, -6.32199347e-02f, -2.64002625e-02f, 1.24680726e-02f,
  -8.15030634e-02f, -1.81697026e-01f, -3.86234298e-02f, -1.55527532e-01f, -2.12171618e-02f, 1.64195653e-02f, -1.48423880e-01f, -3.23172919e-02f, -3.50904129e-02f, -4.56894375e-02f,
  -4.92904969e-02f, 1.17783666e-01f, -3.36341783e-02f, -1.52234603e-02f, -2.55443901e-02f, -8.34345743e-02f, 1.40354186e-01f, 6.30479753e-02f, 3.68732475e-02f, -5.51852509e-02f,
  -3.07444879e-03f, -4.38979035e-03f, 3.35539319e-02f, -7.78161511e-02f, -8.74654204e-02f, 3.87011915e-02f, -2.52882261e-02f, 4.35987040e-02f, -4.90063094e-02f, -8.22200347e-03f,
  -7.34347329e-02f, 1.05411157e-01f, -1.25952721e-01f, -9.59903076e-02f, 9.45273042e-02f, -3.51382464e-01f, -2.13030919e-01f, -8.18261653e-02f, 3.51368636e-02f, -2.75871586e-02f,
  7.34549575e-03f, 1.33472815e-01f, 1.30456626e-01f, -1.32469207e-01f, -3.24294150e-01f, -1.72595620e-01f, -3.36570978e-01f, -1.87103599e-01f, 3.74901183e-02f, -4.68365252e-02f,
  -1.42429292e-01f, -5.14061674e-02f, -1.87417671e-01f, 6.01962991e-02f, -1.19103499e-01f, 3.70393731e-02f, 1.12349734e-01f, 1.55503228e-01f, -1.56721503e-01f, -7.80053213e-02f,
  -5.26470691e-02f, -5.84888831e-02f, -1.20785749e-02f, -1.30780980e-01f, -1.29362255e-01f, -3.48492898e-02f, -1.13916576e-01f, 2.92560901e-04f, 6.04031468e-03f, -3.69481109e-02f,
  1.75036356e-01f, -4.70327958e-02f, -5.79426251e-02f, 6.65364191e-02f, -7.97543582e-03f, -8.17422643e-02f, 7.82973599e-04f, 1.03471391e-01f, -2.63887178e-02f, 2.35815886e-02f,
  -5.44609549e-03f, -8.14890116e-02f, -3.35348584e-02f, 8.24479014e-02f, 2.88778972e-02f, 3.64957079e-02f, -5.89348450e-02f, 6.00583218e-02f, -1.00381095e-02f, -7.52101541e-02f,
  -2.94976756e-02f, 5.60758114e-02f, -1.21401576e-02f, 9.98625066e-03f, -6.26172572e-02f, 2.96322647e-02f, -3.85447480e-02f, 1.05693549e-01f, 1.66781843e-02f, -1.22792773e-01f,
  7.10666105e-02f, 3.12859342e-02f, 4.63910736e-02f, -9.04259384e-02f, 8.58266503e-02f, 1.45112891e-02f, 1.77411083e-02f, 4.90198135e-02f, -2.97368951e-02f, -1.13588728e-01f,
  -1.51261454e-02f, -3.74233834e-02f, -2.81053428e-02f, 8.09559822e-02f, -6.10616691e-02f, 2.97717601e-02f, 5.57615608e-03f, -8.73588994e-02f, 4.50366689e-03f, 3.92059945e-02f,
  -8.36436450e-02f, -1.21772788e-01f, -7.74611160e-03f, -6.79587945e-02f, -5.58939911e-02f, -1.06066458e-01f, -5.24592884e-02f, 1.29028223e-02f, -2.46280571e-04f, -4.06946875e-02f,
  2.79675219e-02f, 1.85026359e-02f, -1.54854491e-01f, 6.02879450e-02f, 8.68614390e-02f, -8.08555856e-02f, 7.49976337e-02f, 6.54276386e-02f, -5.84785528e-02f, 3.16575728e-02f,
  3.36782262e-02f, 4.46536727e-02f, 5.85718267e-02f, -1.21100299e-01f, 1.01915665e-03f, -7.77183175e-02f, 3.87752540e-02f, -1.76490862e-02f, 1.15058720e-02f, -6.24983348e-02f,
  6.46450147e-02f, 1.68335974e-01f, -8.95805135e-02f, -6.95623830e-02f, 1.22370116e-01f, -1.52326673e-01f, -6.12137392e-02f, 7.98058063e-02f, -8.90650600e-02f, 1.30670607e-01f,
  2.99347546e-02f, -1.88190993e-02f, -1.63143724e-01f, -6.44816309e-02f, -1.56745791e-01f, -3.25609356e-01f, 2.62665818e-03f, -1.04128286e-01f, -4.08893861e-02f, 9.54191908e-02f,
  -5.33828028e-02f, 9.06069502e-02f, 5.71478307e-02f, 1.55483961e-01f, 1.97521932e-02f, 1.59897879e-01f, 2.08501399e-01f, -3.44165936e-02f, 1.93220481e-01f, -1.17202632e-01f,
  -8.14142749e-02f, -6.90549612e-04f, 5.42364232e-02f, -1.79539640e-02f, -1.67279746e-02f, 5.90584315e-02f, -9.90341008e-02f, 1.29514663e-02f, -4.11897898e-02f, 6.41055824e-03f,
  -3.45321037e-02f, 7.89633300e-03f, 5.46901226e-02f, -7.24327043e-02f, 1.66525282e-02f, 3.20201032e-02f, -5.08187562e-02f, -3.44432704e-02f, -1.03856571e-01f, 2.47868113e-02f,
  2.22103409e-02f, 3.00787501e-02f, -2.80858725e-02f, -6.08054660e-02f, -7.42486641e-02f, -5.99641614e-02f, -3.55143547e-02f, 4.00858670e-02f, 5.69859818e-02f, -6.67051645e-03f,
  7.91937411e-02f, 4.70264368e-02f, -3.32022272e-02f, -1.22476213e-01f, -9.00209025e-02f, 4.04624175e-03f, -9.03742015e-02f, 6.80225044e-02f, -2.31704060e-02f, -3.56666520e-02f,
  5.62468469e-02f, -1.02184042e-01f, 2.97667682e-02f, 3.24538499e-02f, -5.68825342e-02f, -1.47225829e-02f, -4.83450145e-02f, -3.45978588e-02f, -1.84046349e-03f, -1.46064833e-01f,
  -1.02230623e-01f, -3.90760899e-02f, -1.23766705e-01f, 1.23716015e-02f, 2.04452965e-02f, 5.37115000e-02f, 8.72237384e-02f, -1.01781242e-01f, 1.14133701e-01f, 4.00566161e-02f,
  -2.29390822e-02f, 1.78232849e-01f, -4.82323244e-02f, -1.08421125e-01f, -6.26259968e-02f, -1.47256464e-01f, -4.63405177e-02f, -7.85259977e-02f, -2.25401409e-02f, -1.28196523e-01f,
  4.42602597e-02f, 5.99765740e-02f, -9.43320245e-02f, -3.40372324e-02f, 3.79669154e-03f, 2.29028822e-03f, 9.61682498e-02f, -5.68689741e-02f, -3.56563330e-02f, -2.25251131e-02f,
  3.27444449e-02f, 8.74421373e-02f, -3.78993563e-02f, -3.07471585e-02f, 9.76605341e-02f, -3.43071856e-02f, 2.50579156e-02f, -4.95321341e-02f, 9.26354155e-02f, -3.19790281e-02f,
  -5.73046058e-02f, 6.98573664e-02f, 1.87305696e-02f, -3.14780176e-01f, 1.35216370e-01f, 1.00100040e-01f, -2.45433912e-01f, -1.82467446e-01f, -5.99076673e-02f, -1.97322085e-01f,
  -1.89879447e-01f, 1.18121896e-02f, 1.13343820e-01f, -2.93569684e-01f, 2.64817894e-01f, 2.70735770e-01f, -7.51655549e-02f, -1.48123503e-01f, -1.10679187e-01f, -2.17381552e-01f,
  2.00939309e-02f, -1.91135064e-01f, 1.03933617e-01f, -8.28442201e-02f, -9.43951085e-02f, -1.01204656e-01f, 8.81480705e-03f, -9.10918266e-02f, -2.60516107e-01f, 7.20579363e-03f,
  -1.45396339e-02f, -1.98437899e-01f, 8.87596142e-03f, 9.17381719e-02f, -9.53046046e-03f, 6.33085296e-02f, -1.33444695e-03f, 5.58384843e-02f, 2.27764864e-02f, 2.15877853e-02f,
  -5.12154251e-02f, 3.83716412e-02f, 1.64140873e-02f, 2.62287557e-02f, -1.28308445e-01f, -4.16362286e-02f, 1.23936664e-02f, -2.96023255e-03f, 1.49809755e-02f, 1.78740490e-02f,
  2.51220688e-02f, 5.12177199e-02f, -6.95530400e-02f, -8.43085945e-02f, 5.63714355e-02f, -1.33017236e-02f, 1.02221787e-01f, 1.14386752e-01f, 6.73788786e-02f, -6.08593412e-02f,
  9.18067023e-02f, -5.66698553e-04f, 8.16996619e-02f, 4.85158712e-02f, -5.39956130e-02f, -1.08512109e-02f, 3.28126885e-02f, -2.59179790e-02f, -4.15222868e-02f, -5.24959266e-02f,
  -1.61023345e-02f, -4.92860340e-02f, 2.19528023e-02f, -5.31498194e-02f, -1.53572708e-01f, 3.50414664e-02f, 6.16296344e-02f, 5.56366555e-02f, 4.46512662e-02f, -7.51693621e-02f,
  -8.48860666e-02f, 4.26450185e-02f, -2.99905036e-02f, -9.18308571e-02f, 3.72416079e-02f, 1.19290231e-02f, -2.85915914e-03f, 6.63942024e-02f, -1.03451066e-01f, 1.68851204e-02f,
  4.58445027e-02f, -1.92379311e-01f, 6.28676414e-02f, -1.30225062e-01f, 1.21081628e-01f, -4.23997380e-02f, 7.05670267e-02f, 1.18415646e-01f, -6.06905632e-02f, -9.28371102e-02f,
  -9.30273309e-02f, -1.11855187e-01f, -5.36806360e-02f, 3.97368446e-02f, -1.46327555e-04f, 1.81159675e-02f, -1.05007291e-02f, -1.18216857e-01f, -5.73344808e-03f, 4.93274368e-02f,
  1.86213676e-03f, 3.39262933e-02f, -1.45313237e-02f, -2.18405295e-02f, 6.92237616e-02f, -5.81370369e-02f, 8.89959708e-02f, 4.27474342e-02f, -1.02564869e-02f, -5.25046736e-02f,
  -7.10085332e-01f, 2.14969829e-01f, 2.82414556e-01f, -3.56630027e-01f, 5.06402999e-02f, 1.11990511e-01f, -3.56112123e-02f, 1.19150840e-01f, -4.56517190e-02f, 2.13231400e-01f,
  -2.33900547e-02f, -2.70033389e-01f, 2.05121711e-01f, 1.69484138e-01f, -2.40852222e-01f, 1.52893618e-01f, 5.75346611e-02f, 5.69511652e-02f, 8.89524296e-02f, -4.73334156e-02f,
  -6.38962090e-02f, 7.46401474e-02f, 1.09608270e-01f, 2.21675083e-01f, 2.53732875e-03f, -7.16831684e-02f, -7.63560832e-02f, -3.92354530e-04f, -4.09003207e-03f, 9.97435078e-02f,
  -2.83788919e-01f, -2.68074602e-01f, -1.09498398e-02f, 9.92271304e-02f, -3.47048938e-02f, -7.33286049e-03f, -4.70907725e-02f, -7.82192200e-02f, -1.06589369e-01f, -1.88233256e-02f,
  -1.30746111e-01f, 6.29061088e-02f, -1.05252415e-02f, -1.83514189e-02f, -1.98290944e-02f, 5.12901433e-02f, 1.16664544e-01f, -4.04294289e-04f, -2.51230709e-02f, 7.29631633e-02f,
  4.44129407e-02f, -4.26096134e-02f, 1.11011252e-01f, 5.11894375e-02f, -7.98289292e-03f, -9.10341740e-03f, 7.23211989e-02f, 5.51112462e-03f, -2.77469214e-02f, 2.17973962e-02f,
  3.04755755e-02f, -3.59658785e-02f, -1.05261691e-01f, 2.79353019e-02f, 3.74509394e-02f, 4.67095077e-02f, 1.93649102e-02f, 1.38523877e-02f, -4.30882387e-02f, -3.62934656e-02f,
  -3.83668952e-02f, -2.75956169e-02f, -5.27119897e-02f, -3.43099982e-02f, -1.50121665e-02f, -1.54620586e-02f, 1.35810962e-02f, -3.19524258e-02f, 4.01130244e-02f, -5.22440486e-02f,
  3.08099925e-03f, 2.48622298e-02f, 5.43470718e-02f, 8.37019552e-03f, -2.45552249e-02f, 2.33180914e-02f, 2.49043165e-04f, -5.73593229e-02f, 6.92226179e-03f, -1.29466429e-01f,
  -3.77713740e-01f, -3.73468101e-01f, -8.67059156e-02f, -9.97840017e-02f, -4.46872553e-03f, 1.74288917e-03f, 2.11699517e-03f, -1.20103573e-02f, -3.24987955e-02f, -5.99923208e-02f,
  3.29818428e-02f, 9.63676944e-02f, -5.11321276e-02f, 1.88936591e-02f, -2.75242347e-02f, 7.42021352e-02f, -9.73822996e-02f, -2.91486271e-02f, -7.46906102e-02f, 1.24321533e-02f,
  -1.08614050e-01f, -5.18916026e-02f, -2.03698222e-03f, 4.24287356e-02f, -6.80394843e-02f, -5.31207472e-02f, -3.53010781e-02f, -3.52072120e-02f, -5.84849268e-02f, 1.09588780e-01f,
  1.92539081e-01f, -1.14993393e-01f, -2.13190511e-01f, -1.62619233e-01f, -1.83566548e-02f, -3.58849652e-02f, -1.52360961e-01f, -9.08691213e-02f, -1.15741342e-01f, 1.50801376e-01f,
  6.13200478e-02f, -7.43922517e-02f, -4.45839874e-02f, -1.81067400e-02f, 1.02396257e-01f, 5.88850826e-02f, 4.52637672e-02f, -6.00655824e-02f, -2.34240759e-02f, -7.88454860e-02f,
  1.49231657e-01f, 1.53293788e-01f, -2.17283845e-01f, 7.28541836e-02f, -1.27061326e-02f, -7.86071867e-02f, 1.05688378e-01f, -1.18458740e-01f, 7.16727376e-02f, 1.79311843e-03f,
  -1.59927551e-02f, 1.78914443e-02f, -3.49390805e-02f, -6.41617253e-02f, -1.28214248e-02f, 1.61919724e-02f, -8.22852179e-02f, 1.49564877e-01f, -9.60276201e-02f, -1.24005489e-01f,
  6.30655289e-02f, 4.41440232e-02f, 1.16768494e-01f, 2.24755667e-02f, 3.11815962e-02f, -1.39633110e-02f, -2.70414837e-02f, -5.80410361e-02f, -1.37722388e-01f, 1.24642059e-01f,
  1.64445909e-03f, -3.91419455e-02f, -4.66485731e-02f, -9.55839157e-02f, -2.44840588e-02f, 3.17277126e-02f, -1.20245889e-02f, -2.00530491e-03f, 9.43518281e-02f, 2.58664582e-02f,
  -2.74974550e-03f, 1.20598994e-01f, 5.66392951e-02f, -6.32821172e-02f, -1.56348236e-02f, -6.53419420e-02f, -2.04978492e-02f, -6.32171556e-02f, -5.23100905e-02f, -5.44958562e-02f,
  -6.36082962e-02f, -3.96309868e-02f, 7.05768839e-02f, -2.04174723e-02f, 1.25362976e-02f, 4.68667261e-02f, -1.78867225e-02f, -7.06662759e-02f, -2.60467641e-02f, -1.06625281e-01f,
  -5.42778112e-02f, 3.01995650e-02f, -8.32884610e-02f, 6.08851202e-04f, 7.71238431e-02f, 5.36363497e-02f, 7.95011297e-02f, 1.50048425e-02f, 1.66981108e-02f, 3.95279638e-02f,
  -2.89162546e-02f, 3.11391111e-02f, -3.23332027e-02f, 2.01561917e-02f, -1.53255627e-01f, 3.00107896e-02f, 3.60887125e-03f, 6.48996532e-02f, -1.45953745e-02f, -9.27092433e-02f,
  2.45726407e-02f, -2.96811629e-02f, 6.37432635e-02f, -3.22705694e-02f, -9.32976529e-02f, 1.57695934e-01f, 5.75836599e-02f, -1.28081754e-01f, -1.49485856e-01f, 1.87887549e-02f,
  3.73358354e-02f, 2.76724342e-02f, 1.91377755e-02f, -1.22516733e-02f, 6.45990390e-03f, -5.86029142e-02f, -7.30071403e-03f, 5.15564205e-03f, 1.50578558e-01f, -4.56841961e-02f,
  -3.21387500e-02f, 7.32353106e-02f, -1.12495519e-01f, -1.08515687e-01f, 8.73484313e-02f, -1.23085886e-01f, -7.50383660e-02f, 1.09762549e-01f, 3.38487297e-01f, -2.59843469e-02f,
  -1.11478634e-01f, 7.39048719e-02f, 2.66722180e-02f, -1.88534930e-01f, -5.85884303e-02f, 1.49760410e-01f, -5.87662309e-02f, 2.58901138e-02f, 2.12404042e-01f, -1.83672920e-01f,
  -2.99796406e-02f, -1.47353962e-01f, -2.38634869e-01f, -1.61651567e-01f, -1.49087042e-01f, -1.05272606e-01f, -1.74509510e-01f, 9.98686254e-03f, -1.80196330e-01f, 4.40188050e-02f,
  -1.18836552e-01f, 7.82470107e-02f, 4.84752581e-02f, 2.39024945e-02f, -4.85145580e-03f, -8.10929090e-02f, -5.93606802e-03f, 2.16255710e-02f, 3.13489325e-02f, -4.60439175e-02f,
  8.32879469e-02f, -2.00265031e-02f, 3.12204883e-02f, 2.61862092e-02f, 6.48575872e-02f, -4.39430065e-02f, -3.75262126e-02f, -1.73167407e-03f, -5.67558780e-02f, -3.06078722e-03f,
  -2.07061112e-01f, 3.28645669e-02f, -5.69323003e-02f, -3.34571674e-03f, 2.24967487e-02f, 3.64136323e-02f, 2.10907217e-02f, -1.07176397e-02f, -5.76663874e-02f, 5.26213534e-02f,
  1.03220217e-01f, -9.58374050e-03f, -6.11927267e-03f, -9.32494774e-02f, -5.71654690e-03f, 4.98198941e-02f, 5.02163954e-02f, -1.58986114e-02f, 9.45602059e-02f, -7.20677227e-02f,
  -4.85649146e-02f, 5.18355854e-02f, 3.06981392e-02f, -8.55954885e-02f, -8.08109343e-03f, 2.27222890e-02f, 1.32310521e-02f, 3.97523418e-02f, -5.00819571e-02f, -8.47832114e-02f,
  2.43914616e-03f, 3.87971872e-03f, -6.04437403e-02f, -2.93038366e-03f, -1.50622074e-02f, -5.02711814e-03f, -9.72846672e-02f, 2.73961592e-02f, 5.07400418e-03f, -8.01890716e-02f,
  9.48465541e-02f, 1.63000613e-01f, 5.26037402e-02f, 5.78639843e-02f, 5.45614921e-02f, -6.62969574e-02f, 2.50971112e-02f, 3.67056653e-02f, 4.61150296e-02f, 9.41607729e-02f,
  6.61682263e-02f, 7.72554195e-03f, -3.89814451e-02f, 9.09506381e-02f, 2.98470762e-02f, -4.70674671e-02f, -8.35571885e-02f, 4.59467545e-02f, 7.27621987e-02f, -3.16740870e-02f,
  -1.55678496e-01f, -4.80753556e-02f, 1.58630669e-01f, 1.23621419e-01f, 1.01985119e-01f, 1.44088389e-02f, 4.58458401e-02f, 4.56411391e-02f, 1.16993785e-01f, 7.89689496e-02f,
  -2.85998762e-01f, 5.70516698e-02f, 6.96577430e-02f, -8.93201604e-02f, 1.96620822e-01f, 1.34306312e-01f, -2.01286390e-01f, 9.46660787e-02f, -1.30901843e-01f, -2.70680785e-01f,
  -2.68973410e-01f, -1.10446982e-01f, -1.80985332e-01f, -2.89403796e-02f, -1.41446918e-01f, -5.57897426e-02f, -6.79357350e-02f, -1.46384105e-01f, 2.04746425e-01f, 1.46819130e-02f,
  1.07976265e-01f, 1.63093686e-01f, -1.50019734e-03f, 3.33278716e-01f, 1.65836796e-01f, 4.46846448e-02f, -1.22713566e-01f, 8.41685236e-02f, 6.72388151e-02f, 1.49947613e-01f,
  -6.10847846e-02f, -9.97411460e-02f, -1.57940060e-01f, -1.03837349e-01f, -1.63655475e-01f, 1.86546259e-02f, -9.44414064e-02f, 7.40553886e-02f, -5.17995376e-03f, -2.07306910e-02f,
  -1.05505109e-01f, -7.24522844e-02f, 8.74975622e-02f, 6.90841898e-02f, -2.97182593e-02f, 1.04324102e-01f, 3.60219553e-02f, -4.22731526e-02f, 4.40043136e-02f, 5.61385602e-03f,
  3.13460864e-02f, -2.35149097e-02f, -1.12495922e-01f, -1.05396561e-01f, -1.14239454e-02f, -3.45143862e-02f, 1.04866624e-01f, 9.28647071e-02f, 4.25100923e-02f, -2.47560367e-02f,
  8.06104466e-02f, 2.12368779e-02f, -1.33923907e-02f, 2.96660885e-02f, 4.76236530e-02f, -4.79158573e-03f, -1.84401944e-02f, -3.60080041e-02f, -9.07641575e-02f, 5.10733575e-03f,
  -1.14536203e-01f, -3.28120636e-03f, 3.35908160e-02f, 8.60901400e-02f, -3.69973443e-02f, -5.05636521e-02f, 2.11917479e-02f, -8.53819016e-04f, -3.56490761e-02f, -2.10407213e-03f,
  -1.25596561e-02f, 8.81779473e-03f, 1.18815796e-02f, -8.76349863e-03f, -2.38190964e-03f, -5.63056059e-02f, 1.22758120e-01f, 5.24455644e-02f, -6.12001382e-02f, 2.35590376e-02f,
  -2.52962291e-01f, -2.76275188e-01f, 5.45971878e-02f, -9.52658057e-03f, -5.88799231e-02f, -6.14783391e-02f, 5.08472957e-02f, 4.13721763e-02f, -1.24815345e-01f, -1.05529968e-02f,
  -7.69274831e-02f, -5.76370247e-02f, -9.65537354e-02f, 1.23314612e-01f, 1.55570619e-02f, 1.70019865e-02f, -1.00202523e-01f, -1.55150160e-01f, -1.57177687e-01f, 1.14293722e-02f,
  -8.34344625e-02f, 5.48220798e-02f, -3.34098823e-02f, 6.70982376e-02f, -2.67760940e-02f, -1.28594592e-01f, 1.26205757e-01f, 9.52471569e-02f, 6.75288737e-02f, -4.22752835e-03f,
  -1.95650727e-01f, -4.87017026e-03f, -8.29871371e-02f, -6.43671304e-02f, 1.33858278e-01f, -1.96936369e-01f, 7.81113841e-03f, 1.16833836e-01f, -1.13154901e-02f, 1.26388982e-01f,
  -1.98261272e-02f, -1.53928936e-01f, 1.67562738e-01f, -2.45658964e-01f, -2.52829313e-01f, -2.50019282e-01f, -2.29304343e-01f, -2.44006395e-01f, -4.81717885e-02f, 2.93893758e-02f,
  -1.13460898e-01f, -5.38570061e-02f, -1.44509315e-01f, 1.80513054e-01f, -1.11880256e-02f, 2.64524460e-01f, 1.86227098e-01f, 1.94142506e-01f, -3.63755152e-02f, 6.86464533e-02f,
  -6.23721816e-02f, 4.83618416e-02f, 1.45627141e-01f, 3.05968290e-03f, 6.88847601e-02f, -6.61010444e-02f, -4.19683680e-02f, 2.33475305e-02f, -1.34647973e-02f, -6.06798679e-02f,
  -6.42127991e-02f, 1.16304029e-02f, -6.90432265e-02f, 3.76946032e-02f, 1.28921881e-01f, -8.49224627e-03f, -1.77063033e-04f, 2.69462764e-02f, -5.08149862e-02f, -3.13089415e-02f,
  -1.61613852e-01f, 4.42900055e-04f, -3.87676666e-03f, 9.58272591e-02f, 4.45164852e-02f, 1.98045205e-02f, -9.78353694e-02f, 4.54310700e-03f, -5.15294112e-02f, 1.40930386e-02f,
  1.17045797e-01f, -7.81043470e-02f, -1.47397637e-01f, -3.23341452e-02f, -3.32009443e-03f, 2.86560040e-02f, -6.84947297e-02f, 5.35539314e-02f, 1.29027233e-01f, -5.56377508e-02f,
  4.95902784e-02f, 1.20646227e-02f, -1.61715373e-02f, -5.79284988e-02f, -2.35319268e-02f, 5.08007854e-02f, -3.04700993e-02f, -3.17560025e-02f, -4.13133986e-02f, -5.70879467e-02f,
  -6.50434941e-02f, -4.90562953e-02f, 2.84087174e-02f, 1.51692228e-02f, -1.00261360e-01f, 3.41976508e-02f, -1.00577928e-01f, -6.94147348e-02f, -8.92922580e-02f, -3.26703042e-02f,
  7.97645003e-02f, 1.17034875e-01f, 1.21484376e-01f, 7.47764483e-02f, -4.77542169e-03f, -6.61727041e-02f, -1.19827464e-01f, -3.79273184e-02f, -1.09639632e-05f, 3.59563567e-02f,
  7.19249472e-02f, 6.09168736e-03f, -9.30086300e-02f, 3.00000235e-02f, 9.51385424e-02f, 5.26535586e-02f, 3.07549872e-02f, 6.79851882e-03f, 1.83631480e-01f, -3.44899781e-02f,
  1.04948338e-02f, -7.30140582e-02f, -9.05140713e-02f, 3.57254632e-02f, -1.09160412e-02f, 3.53697017e-02f, 5.11936657e-02f, 5.45697957e-02f, 8.96864384e-03f, 6.28043897e-03f,
  2.04656169e-01f, 4.71785292e-02f, -1.50226712e-01f, -1.26062026e-02f, -8.38091597e-02f, 6.54316992e-02f, 6.25683069e-02f, 2.52985135e-02f, -5.31716123e-02f, 2.59831429e-01f,
  6.92159981e-02f, 1.02899872e-01f, 3.48203294e-02f, 3.34594011e-01f, 3.71904612e-01f, 9.23289359e-02f, 2.28819117e-01f, 8.79931226e-02f, -2.18113009e-02f, 8.20692182e-02f,
  1.30843699e-01f, 3.12143981e-01f, -1.06832802e-01f, 6.18672818e-02f, 1.32123321e-01f, -2.51994491e-01f, 3.30028590e-03f, -1.80243298e-01f, -4.94820524e-05f, 1.04430370e-01f,
  1.34003293e-02f, -1.29308999e-02f, 2.81860493e-02f, -4.20255810e-02f, -7.17325211e-02f, -4.25298586e-02f, -9.14237872e-02f, 2.47772522e-02f, -1.25372157e-01f, 2.73469388e-02f,
  7.91905262e-03f, -3.46955359e-02f, 6.55766204e-02f, -6.82228282e-02f, 1.30760595e-01f, 3.71468589e-02f, -9.79783460e-02f, -1.23764411e-01f, -1.36984494e-02f, 5.58176450e-02f,
  -9.61273611e-02f, -4.98671718e-02f, -8.12924132e-02f, -3.83448005e-02f, -6.61240593e-02f, 3.44342813e-02f, 3.36567722e-02f, -7.79501647e-02f, 4.50002514e-02f, 2.38306709e-02f,
  1.02463901e-01f, -2.97334548e-02f, 5.92382737e-02f, -3.13314199e-02f, 6.28383607e-02f, -2.76140473e-03f, 7.16714188e-02f, -7.44023547e-02f, 1.40913688e-02f, -8.91077518e-02f,
  -5.69483452e-02f, -1.80255566e-02f, 1.23966094e-02f, 5.83082810e-02f, 1.38888583e-01f, 6.50134590e-03f, -1.33212889e-02f, 3.53383459e-02f, -6.70730770e-02f, -5.75871654e-02f,
  -2.50644814e-02f, 1.26451984e-01f, 5.43085262e-02f, -4.03668880e-02f, -5.78904990e-04f, 8.72078016e-02f, 8.81883204e-02f, -1.68465283e-02f, -1.18066877e-01f, -3.39317508e-02f,
  2.15398557e-02f, 6.52642325e-02f, 2.01948956e-02f, -8.60251710e-02f, -5.02135605e-03f, 9.33486447e-02f, 9.93033499e-02f, 1.16596214e-01f, -4.62668426e-02f, 3.54676396e-02f,
  -3.81170772e-02f, 6.96389616e-05f, 2.98453830e-02f, -4.70140725e-02f, -7.84774348e-02f, -1.33600570e-02f, 4.52784598e-02f, -1.26629084e-01f, -2.30352432e-02f, 2.18185969e-02f,
  -4.48889751e-03f, 2.28447914e-02f, 1.99378394e-02f, -3.84358503e-02f, 1.36505943e-02f, -6.44351020e-02f, 2.99702473e-02f, -1.03414841e-01f, 7.80672133e-02f, 5.35253696e-02f,
  -4.32475179e-01f, 7.25568682e-02f, 3.04363072e-01f, -7.16803521e-02f, -1.28000915e-01f, 3.20917249e-01f, 2.56157458e-01f, 2.29000417e-03f, 1.74654618e-01f, 5.63451946e-02f,
  -9.78283510e-02f, 4.56513790e-03f, 5.82201891e-02f, 2.28758901e-02f, 1.98859707e-01f, 2.28590518e-01f, 1.89416975e-01f, 6.59239292e-02f, -6.17149174e-02f, -1.64667293e-01f,
  -1.25069812e-01f, -8.28653276e-02f, 1.34707063e-01f, -5.71513921e-02f, -1.31578058e-01f, -1.42782107e-01f, -4.93531339e-02f, 3.02920267e-02f, -1.42238393e-01f, -2.72555389e-02f,
  -1.73384532e-01f, -1.76105291e-01f, -1.37888730e-01f, -8.39502662e-02f, -1.40947774e-01f, -1.02043925e-02f, 6.39497349e-03f, 2.80112848e-02f, -5.65459952e-02f, 3.56561244e-02f,
  -8.00407082e-02f, 1.60038788e-02f, -3.03188842e-02f, -2.66809966e-02f, -2.42636558e-02f, 7.47531140e-03f, 5.70255257e-02f, -8.71401802e-02f, -4.33240943e-02f, -1.68309826e-02f,
  -1.64769369e-03f, -6.27804995e-02f, -2.84398887e-02f, 6.12252690e-02f, 8.83343518e-02f, -4.11227113e-03f, 8.86181146e-02f, -2.67165080e-02f, -1.00522786e-01f, 3.79168689e-02f,
  7.86671694e-03f, 1.25871375e-01f, 1.34920329e-01f, -1.30022153e-01f, -7.78668895e-02f, -9.58701596e-02f, 2.87110675e-02f, -5.32622784e-02f, -3.92572396e-02f, -1.19885281e-01f,
  -9.84481350e-02f, -3.51298340e-02f, -2.28377674e-02f, -1.17778080e-02f, -1.19969383e-01f, -1.26861893e-02f, 2.41836011e-02f, 3.43257859e-02f, -3.00101768e-02f, -9.45026726e-02f,
  4.09956463e-02f, -5.00099435e-02f, -6.84721163e-03f, 3.71460281e-02f, -2.42279489e-02f, -6.45438209e-02f, -5.66076748e-02f, -1.12748090e-02f, 5.08294441e-02f, -2.99320761e-02f,
  -1.19179860e-01f, -1.39572110e-03f, -1.12220675e-01f, -3.32189873e-02f, -9.55140218e-02f, 7.25729316e-02f, -2.23000832e-02f, -4.09360342e-02f, 4.57191234e-03f, 1.48482835e-02f,
  6.86607882e-02f, 3.56341824e-02f, 3.62128839e-02f, 5.56762442e-02f, -3.17838192e-02f, 3.65015976e-02f, -9.78099275e-03f, -5.64450510e-02f, 4.84260432e-02f, -8.48798454e-02f,
  -6.92135394e-02f, -7.40660951e-02f, -7.12228566e-02f, -3.26759629e-02f, 6.71000034e-02f, -5.66565059e-02f, -2.91412994e-02f, -4.29010913e-02f, 8.39696601e-02f, 9.49830934e-02f,
  -1.74502075e-01f, -1.42767787e-01f, 7.02965558e-02f, -3.16441134e-02f, 2.10706413e-01f, 1.69226304e-01f, -2.39209607e-01f, -6.00304455e-02f, -2.86846131e-01f, -9.60262343e-02f,
  -9.01292786e-02f, -7.57033452e-02f, -1.95271373e-01f, 1.85428653e-02f, 1.29584759e-01f, -1.02275863e-01f, 2.40887236e-02f, 7.62048215e-02f, -5.08546550e-03f, -4.31193747e-02f,
  1.95330773e-02f, 4.30151075e-02f, 4.07576598e-02f, 2.20802680e-01f, 1.59944847e-01f, 3.46073918e-02f, -5.30832820e-02f, -3.05319205e-02f, 2.68149793e-01f, 2.21397579e-01f,
  6.27481267e-02f, -2.60411620e-01f, 4.37131599e-02f, 1.42869234e-01f, -2.61274986e-02f, 3.47642489e-02f, 7.71190375e-02f, 9.52015724e-03f, -9.34023857e-02f, -1.98100116e-02f,
  -6.55352101e-02f, 4.94680516e-02f, 1.27951369e-01f, -1.42697962e-02f, -1.48488395e-03f, 1.22854948e-01f, -6.41283840e-02f, 7.77404457e-02f, -2.02701483e-02f, -1.95990074e-02f,
  -5.50177917e-02f, 1.30607605e-01f, -1.99644733e-02f, 6.19147485e-03f, -1.57045871e-01f, -1.16657361e-01f, -1.61338341e-03f, -8.17165896e-02f, -4.73495461e-02f, 8.03009346e-02f,
  -1.10641457e-01f, 1.58062335e-02f, -1.94511693e-02f, 2.71054637e-02f, 1.10685069e-03f, -9.43355029e-04f, 1.05155677e-01f, 5.51912673e-02f, 1.17387928e-01f, -5.67007847e-02f,
  1.22914463e-03f, -5.26843872e-03f, -5.46939038e-02f, -3.90305221e-02f, 3.75065170e-02f, 7.61929452e-02f, 1.68753877e-01f, -1.06277773e-02f, -1.27708584e-01f, 1.11781642e-01f,
  -3.14243953e-04f, 7.57341534e-02f, 8.82677641e-03f, 7.12136403e-02f, -1.21672302e-02f, -3.57266441e-02f, 3.74879949e-02f, -6.59601996e-03f, -4.24812809e-02f, 7.76037276e-02f,
  -1.10385995e-02f, -1.62957802e-01f, 8.74579605e-03f, 1.04807004e-01f, 4.15775962e-02f, 1.35270253e-01f, 1.17086537e-01f, 7.45675862e-02f, -2.82327309e-02f, -9.97850597e-02f,
  -2.20965371e-02f, 1.12211376e-01f, -3.52747552e-02f, 7.65048340e-02f, 6.49415404e-02f, -1.43607743e-02f, -1.35913819e-01f, -2.24742136e-04f, -8.65289047e-02f, 2.53560040e-02f,
  4.35172254e-03f, -2.43080389e-02f, -6.02899194e-02f, 6.45739734e-02f, -7.93205351e-02f, -2.68399995e-02f, 1.56698134e-02f, -1.76174322e-03f, 2.58427560e-02f, -3.46007794e-02f,
  -1.65051714e-01f, 6.88919425e-02f, 1.92480847e-01f, 3.22608769e-01f, -1.20818026e-01f, -1.49974525e-01f, -2.70599246e-01f, 5.35820387e-02f, -1.08849511e-01f, -5.21287620e-02f,
  1.20343296e-02f, 6.58822656e-02f, -1.19112402e-01f, 2.68065006e-01f, 1.43166408e-01f, 5.26020862e-03f, 2.11644955e-02f, -7.83549547e-02f, 3.19412388e-02f, 8.75228941e-02f,
  1.15272351e-01f, 1.14228651e-01f, 2.62822241e-01f, 2.21201807e-01f, 1.94259569e-01f, 1.04719013e-01f, 2.30484888e-01f, 1.74056552e-02f, 3.05591464e-01f, 2.03112885e-02f,
  -5.74055277e-02f, -2.47064065e-02f, 7.58505519e-03f, -1.67466160e-02f, -2.99766287e-02f, -7.31487498e-02f, -4.37148325e-02f, -4.83321398e-02f, -5.30786738e-02f, -3.96418869e-02f,
  -2.27761399e-02f, 9.65262181e-04f, 5.95167950e-02f, 8.18043947e-03f, -7.30805397e-02f, 6.98843226e-02f, -5.41615523e-02f, 1.75523758e-03f, -4.80096564e-02f, -8.20543864e-05f,
  3.18080150e-02f, -6.68928772e-03f, -1.90916657e-02f, 6.60311291e-03f, 1.02300562e-01f, 4.49149162e-02f, -1.23348963e-02f, -3.14429775e-02f, 7.27442428e-02f, 3.26931551e-02f,
  4.67303619e-02f, -9.90737882e-03f, 5.58791645e-02f, 5.35775628e-03f, 9.31333192e-03f, 1.00537809e-02f, 5.47512397e-02f, -2.11991854e-02f, -7.68908951e-03f, -4.42543812e-02f,
  3.88126522e-02f, -1.29029388e-02f, -2.77074091e-02f, -7.16695189e-03f, -2.57122219e-02f, -3.07064299e-02f, -7.63119087e-02f, 1.57644115e-02f, 1.73353702e-02f, 1.08954525e-02f,
  -2.63778642e-02f, 3.18337902e-02f, 2.83847898e-02f, -3.29573192e-02f, -6.17386438e-02f, 3.21422704e-02f, 1.26704620e-02f, -5.53863198e-02f, 4.72889580e-02f, -1.14568412e-01f,
  3.01225558e-02f, 1.28109097e-01f, 1.16390437e-02f, -1.02063209e-01f, -3.63103487e-02f, 6.45310804e-02f, -4.99022156e-02f, 8.84118527e-02f, 2.19044369e-02f, 9.52557847e-03f,
  -7.52257556e-02f, 4.43648808e-02f, -8.48532375e-03f, -3.51326391e-02f, 1.77979991e-02f, 4.95563820e-02f, 1.24535263e-02f, -5.35444170e-02f, 7.68794194e-02f, -1.47020966e-02f,
  4.97808419e-02f, -3.29892822e-02f, -4.65841368e-02f, 2.95161493e-02f, -1.50075108e-02f, -4.00838442e-02f, 2.29268689e-02f, -7.45149106e-02f, 5.83143272e-02f, -2.33776998e-02f,
  7.24287182e-02f, -4.32822794e-01f, 5.97298183e-02f, 1.19051725e-01f, 1.95432127e-01f, 4.53487830e-03f, 1.38753876e-02f, -1.33642107e-01f, -8.72339085e-02f, -2.72755444e-01f,
  4.75537702e-02f, 5.30886948e-02f, -1.62343889e-01f, 6.16019079e-03f, 2.12216839e-01f, -1.42540798e-01f, -3.83030996e-02f, -5.21104932e-02f, 7.00918734e-02f, 1.98579356e-02f,
  1.26718730e-01f, 1.23111330e-01f, 4.30046208e-02f, -9.51590911e-02f, -5.38133979e-02f, -2.94570327e-02f, -2.43237428e-02f, -7.83261657e-02f, 1.44239202e-01f, 2.50486247e-02f,
  -7.62135610e-02f, -6.78689778e-02f, 3.79849188e-02f, -1.58817634e-01f, 2.38746479e-02f, -9.50892270e-02f, 4.68255840e-02f, -7.05028251e-02f, 5.40318154e-02f, 6.02977052e-02f,
  7.61436252e-03f, 1.80417839e-02f, 9.96542126e-02f, 5.82061335e-02f, 1.26427086e-02f, 1.93770677e-02f, 1.32268686e-02f, -1.03647104e-02f, -1.32463217e-01f, 9.11455695e-03f,
  -4.65023667e-02f, 1.09770987e-02f, 3.72771174e-02f, 1.30679905e-01f, 4.98162918e-02f, 9.39424410e-02f, -5.23596182e-02f, -1.59542356e-02f, 2.01963186e-02f, -9.23877284e-02f,
  -5.21937646e-02f, -5.90015389e-03f, -3.15012783e-02f, 4.79728207e-02f, -1.03110000e-01f, 9.87206027e-02f, 6.57294020e-02f, 2.55632843e-03f, 4.75732163e-02f, -7.44811296e-02f,
  5.34324721e-02f, 3.80696207e-02f, 3.70289311e-02f, -4.75351326e-02f, 5.11281937e-02f, 3.01759318e-02f, 2.66898461e-02f, 9.30203125e-02f, -1.68334067e-01f, 8.69924016e-03f,
  1.46337241e-01f, 3.01151685e-02f, 1.96969286e-02f, 8.75147432e-02f, 3.98155302e-02f, 1.81031588e-03f, -5.54984137e-02f, -9.30440277e-02f, 1.74143314e-02f, -3.88982706e-02f,
  -4.10321355e-01f, -3.47892880e-01f, 2.50042919e-02f, -1.44932270e-01f, -7.16533512e-02f, -1.53067619e-01f, 3.45106125e-02f, 6.84129633e-03f, -4.11076136e-02f, 1.54751968e-02f,
  -4.38825972e-02f, 4.80193794e-02f, -1.55641958e-01f, -7.53461290e-03f, 2.94587873e-02f, -6.57258183e-02f, -4.82685938e-02f, -1.49753109e-01f, -8.80354494e-02f, -1.52841555e-02f,
  -3.68468687e-02f, 3.77609953e-02f, 1.33403465e-01f, 6.54213727e-02f, -2.18252353e-02f, 6.67571574e-02f, -9.22139138e-02f, 2.93067638e-02f, 4.25647339e-03f, 8.32640752e-03f,
  5.46055920e-02f, 3.15795057e-02f, -2.23701388e-01f, 3.58712934e-02f, 3.02729219e-01f, 1.79645956e-01f, 8.67803395e-02f, 1.67999282e-01f, -1.39126152e-01f, 8.25993121e-02f,
  1.14638031e-01f, 6.12642951e-02f, -2.03754261e-01f, 2.59608388e-01f, 2.18041703e-01f, -2.64963597e-01f, 2.11261585e-01f, 7.64761120e-02f, -1.05576515e-01f, 9.80168208e-02f,
  9.10593756e-03f, 3.56490135e-01f, -1.25656109e-02f, 9.53784734e-02f, 2.21704021e-01f, -4.22674790e-02f, 1.47652999e-01f, -1.63402632e-01f, 2.42352739e-01f, 7.58146122e-02f,
  -3.83685268e-02f, 7.38844182e-03f, 5.37566096e-02f, -7.72264153e-02f, 6.82135001e-02f, -5.26192249e-04f, -3.34437266e-02f, -7.13981241e-02f, -2.31921356e-02f, 3.58357169e-02f,
  -5.26033267e-02f, 9.81840491e-02f, 6.90541193e-02f, 1.18318766e-01f, -1.57701375e-03f, 6.90611452e-02f, 5.48972487e-02f, 2.17649266e-02f, -8.09397642e-03f, 5.24233952e-02f,
  1.93755678e-03f, -5.36415353e-02f, -3.75665203e-02f, -6.60615116e-02f, 4.00765426e-02f, 1.23622790e-01f, 8.35594162e-02f, 6.04364388e-02f, 2.11036317e-02f, 1.47648290e-01f,
  6.98401332e-02f, -5.74528724e-02f, -5.19055175e-03f, -5.89721985e-02f, 5.92410229e-02f, 9.85680819e-02f, 2.85426807e-02f, 4.42881361e-02f, 2.84071751e-02f, 7.10961372e-02f,
  -6.53998107e-02f, 1.29021313e-02f, -7.16949776e-02f, 6.09674901e-02f, 5.68372905e-02f, -6.56900629e-02f, -6.34236336e-02f, 4.29744087e-02f, 8.44124518e-03f, -1.74947921e-02f,
  -6.70893267e-02f, -4.73554581e-02f, -6.88832393e-03f, -1.90575793e-02f, -1.53369200e-03f, 9.77473035e-02f, 2.94779129e-02f, 5.79053126e-02f, -3.38195451e-02f, -8.25038925e-03f,
  3.04988138e-02f, 1.02613159e-01f, -3.60878296e-02f, -3.79978977e-02f, -7.86340144e-03f, 1.02117233e-01f, 9.76163223e-02f, 7.34910518e-02f, -5.89297377e-02f, -4.38673003e-03f,
  2.48962808e-02f, -8.14475566e-02f, -1.92643572e-02f, -5.56025729e-02f, -5.65037737e-03f, -1.51057476e-02f, -1.72727741e-02f, 2.88618561e-02f, 1.14702106e-01f, 4.52249199e-02f,
  -3.78418192e-02f, 1.27061680e-01f, -4.32517603e-02f, 1.04744680e-01f, 7.52030537e-02f, 5.73194679e-03f, 1.37713611e-01f, 1.89148299e-02f, -1.01568401e-02f, 3.92335057e-02f,
  4.57712030e-03f, 1.57578364e-01f, 3.21765915e-02f, -2.63339788e-01f, -8.52743611e-02f, -2.13131800e-01f, -2.90125877e-01f, 5.58320098e-02f, 7.45439827e-02f, 4.99347039e-02f,
  -2.10612893e-01f, 1.84638932e-01f, 1.21324100e-01f, -1.33195996e-01f, -2.19511017e-01f, -1.66207239e-01f, -2.62728572e-01f, -2.24227712e-01f, -2.89897658e-02f, -2.28648722e-01f,
  -5.33154532e-02f, -1.99334860e-01f, -1.66822940e-01f, -1.98424328e-02f, -2.96649393e-02f, 2.08123354e-03f, 1.75482016e-02f, -2.24941112e-02f, -3.59674059e-02f, 8.37861374e-02f,
  -5.50682954e-02f, -6.64111525e-02f, 9.00866166e-02f, 8.55321065e-03f, -7.78941289e-02f, 5.92785375e-03f, -4.04443741e-02f, 9.01123043e-03f, -7.04255886e-03f, 2.89451666e-02f,
  1.64459795e-02f, -2.42000297e-02f, 2.81683877e-02f, 1.06398806e-01f, -2.44671777e-02f, 3.67094129e-02f, 1.21526457e-02f, -1.24031333e-02f, -8.19259062e-02f, 2.03652307e-02f,
  -8.62511322e-02f, 3.19507234e-02f, -2.60825157e-02f, 3.46784368e-02f, 1.06680259e-01f, -2.63919327e-02f, 2.65945997e-02f, 1.42964691e-01f, -4.67309803e-02f, 1.34481583e-02f,
  -1.56298280e-01f, 2.03782953e-02f, 5.24214767e-02f, 3.27561721e-02f, 3.40331569e-02f, -7.85676241e-02f, 4.03813161e-02f, 6.09084032e-02f, -4.75237556e-02f, 1.48205261e-03f,
  8.61307383e-02f, 8.42531100e-02f, -6.32597804e-02f, -7.30554909e-02f, -6.61175400e-02f, 1.10454552e-01f, -5.39773516e-02f, 6.57561189e-03f, 3.24876755e-02f, 6.25818446e-02f,
  9.44207832e-02f, -2.57064030e-02f, -1.09607100e-01f, -1.13293380e-01f, -1.19443797e-01f, 2.50531547e-02f, 7.19224662e-02f, -4.85766008e-02f, -3.95367332e-02f, 9.70419403e-03f,
  -9.00705159e-02f, -6.34459853e-02f, 5.46011776e-02f, -3.05645131e-02f, -2.79971454e-02f, -7.32887238e-02f, -5.07540256e-02f, 1.37451559e-01f, -2.00322759e-03f, -3.18880305e-02f,
  8.60222131e-02f, 7.60584185e-03f, 1.03116035e-02f, 6.94622472e-02f, -4.78524342e-02f, 3.58870700e-02f, -1.39507372e-02f, 7.40954326e-03f, -6.68796077e-02f, 1.55371979e-01f,
  -3.24479379e-02f, 1.95756722e-02f, -2.21560597e-02f, -8.83064866e-02f, 3.44179645e-02f, 6.10189661e-02f, 9.07120183e-02f, 7.41984919e-02f, -2.66894847e-02f, -4.64851856e-02f,
  1.91356644e-01f, -2.08401829e-01f, 6.18776791e-02f, 2.64011174e-01f, 6.41349927e-02f, -1.81947455e-01f, -8.58044624e-02f, 1.20145343e-01f, 4.29916829e-02f, -9.88373309e-02f,
  3.89578491e-02f, -2.92037010e-01f, -3.16157252e-01f, -1.69297799e-01f, -6.00889735e-02f, -1.59032121e-01f, -8.40156525e-02f, -1.46173239e-01f, -1.68975353e-01f, 2.47714985e-02f,
  1.05280921e-01f, 5.68829849e-03f, -7.28287622e-02f, 1.30324915e-01f, 6.57106265e-02f, 2.22281486e-01f, 1.57494187e-01f, 1.45731837e-01f, 1.67270586e-01f, -1.22017823e-01f,
  -9.20575112e-02f, -1.06951185e-01f, -2.68434137e-02f, -1.09558553e-02f, 7.53132105e-02f, -1.81166958e-02f, -6.96618259e-02f, -1.53823942e-01f, 3.13703902e-03f, 7.77029768e-02f,
  -1.63564920e-01f, -4.47064526e-02f, -5.93882538e-02f, -3.37291472e-02f, 1.25714794e-01f, 5.80845997e-02f, -4.84645441e-02f, 3.13828662e-02f, -1.41941473e-01f, 1.47307655e-02f,
  9.54042375e-02f, 8.47454369e-03f, 4.08405252e-02f, -1.30069749e-02f, -9.87516716e-03f, -6.03996143e-02f, -6.31179055e-03f, 6.12400584e-02f, 4.94889915e-02f, -1.00314785e-02f,
  5.32209910e-02f, 6.25093132e-02f, -7.39959255e-02f, -7.41490275e-02f, 1.08337037e-01f, 1.60979684e-02f, -5.54811619e-02f, -9.47297513e-02f, 1.66020449e-02f, -1.10149905e-01f,
  1.32199913e-01f, 7.73973465e-02f, -3.41351591e-02f, 1.55858681e-01f, 3.15537676e-02f, -2.01446991e-02f, -5.17337956e-02f, -6.45197704e-02f, -1.23400772e-02f, 1.16907852e-02f,
  -1.00397944e-01f, 4.44050878e-02f, -7.74875879e-02f, -7.86561072e-02f, -4.97123376e-02f, 1.93361565e-01f, 1.11462944e-03f, 6.74904734e-02f, 2.76061241e-02f, 1.79725718e-02f,
  2.80707851e-02f, -1.25704985e-02f, -8.92808586e-02f, -3.55905406e-02f, 3.61251719e-02f, 1.36801973e-01f, -6.57854006e-02f, -2.19700504e-02f, 5.83441295e-02f, 3.42733935e-02f,
  -1.00821070e-01f, 2.96521746e-02f, 7.29048252e-02f, -4.33153706e-03f, -9.99741629e-02f, 2.07628727e-01f, 2.18884069e-02f, -5.58184534e-02f, -1.08762674e-01f, 5.73732927e-02f,
  9.66515243e-02f, 7.08280057e-02f, 4.65165637e-03f, 5.50923683e-02f, 5.97506948e-02f, 1.89408455e-02f, -3.20517318e-03f, 1.07237354e-01f, -5.45341559e-02f, -2.63345838e-02f,
  -4.11946289e-02f, 2.37880006e-01f, 1.51562989e-01f, 2.90533334e-01f, -1.80409640e-01f, -7.49083562e-03f, 8.84844363e-02f, 6.68172762e-02f, 1.11285262e-01f, 2.25655615e-01f,
  1.17461011e-02f, 1.30045637e-01f, -6.50060410e-03f, 1.00894146e-01f, -2.06170186e-01f, -3.65213044e-02f, 4.53906730e-02f, 9.71671417e-02f, -7.89695457e-02f, 6.91710487e-02f,
  -6.46132678e-02f, -1.24531552e-01f, 1.27088964e-01f, -1.70405701e-01f, -4.48195916e-03f, 1.66831911e-01f, -1.03006966e-01f, -3.16083096e-02f, -8.77220407e-02f, -4.45786417e-02f,
  1.00418366e-01f, 1.54053777e-01f, 1.06085263e-01f, 9.04999860e-03f, 2.83193383e-02f, -8.23499635e-02f, 3.69842947e-02f, 2.09744107e-02f, -6.98355734e-02f, -8.54191780e-02f,
  8.61635581e-02f, -9.52387005e-02f, -3.42032500e-02f, -1.01919897e-01f, -2.40171291e-02f, 3.50891761e-02f, 1.13386720e-01f, 9.82305631e-02f, 8.59706104e-02f, 8.31914693e-03f,
  8.91260505e-02f, 9.85119194e-02f, 1.43106291e-02f, 3.53039913e-02f, -2.38575041e-02f, 2.44761612e-02f, 9.68683809e-02f, -2.51690537e-04f, 1.07456461e-01f, -8.07725638e-02f,
  -1.86012089e-01f, 1.28309831e-01f, 9.20133516e-02f, 8.92192125e-02f, 8.33403878e-03f, 7.86532238e-02f, -4.05016206e-02f, 5.08002080e-02f, -5.77370590e-03f, 8.41259137e-02f,
  1.69553220e-01f, 7.31221288e-02f, 5.16800545e-02f, 5.03035039e-02f, -1.62164539e-01f, -9.74249933e-03f, -3.81316468e-02f, 9.72022489e-03f, -2.72683389e-02f, 2.03165859e-02f,
  6.04924671e-02f, -1.25176564e-01f, 4.65691909e-02f, 1.31354526e-01f, 5.75375706e-02f, -1.42246147e-03f, -9.91795361e-02f, 4.31167670e-02f, -4.64226166e-03f, 5.97358635e-03f,
  -1.77290197e-02f, -3.40013243e-02f, 1.80978209e-01f, 4.01208736e-02f, 1.13811620e-01f, -1.00890942e-01f, 1.57462116e-02f, -1.47680249e-02f, -9.82573330e-02f, -1.33605868e-01f,
  -9.32792798e-02f, 3.32073011e-02f, -8.61568451e-02f, -8.14499035e-02f, 1.41305283e-01f, 3.69776413e-02f, 3.47210169e-02f, 3.89077440e-02f, -1.35940994e-04f, 5.07643539e-03f,
  5.13353758e-02f, 3.53189595e-02f, 8.56338441e-02f, 5.73350452e-02f, -8.91882367e-03f, -4.41527963e-02f, -6.80586025e-02f, 1.15937881e-01f, -9.83805433e-02f, -9.66421589e-02f,
  -4.24209356e-01f, 1.66650847e-01f, 6.27975538e-02f, 6.59601297e-03f, -1.70666099e-01f, -5.06739438e-01f, -9.19575170e-02f, 4.38452139e-02f, 1.91728398e-02f, 3.21285754e-01f,
  1.40255094e-01f, 1.10754482e-01f, 1.15956627e-01f, 2.20693856e-01f, -3.68767530e-01f, 8.70819613e-02f, -1.62956774e-01f, -6.02742992e-02f, 4.00361307e-02f, 1.33652687e-02f,
  -1.41061813e-01f, 1.47739649e-01f, -1.24937281e-01f, 1.32122606e-01f, 1.60921335e-01f, 5.41526191e-02f, -8.51988643e-02f, 5.68585768e-02f, -1.33549264e-02f, 1.15170121e-01f,
  -1.02587990e-01f, 2.84634590e-01f, 7.89616033e-02f, -6.17847890e-02f, -1.16152950e-01f, -6.30258918e-02f, -8.81238356e-02f, -1.71942860e-02f, 7.19816536e-02f, 1.87252928e-02f,
  -6.92603439e-02f, 3.11682988e-02f, -4.09150645e-02f, -1.13901291e-02f, 2.23475712e-04f, 4.79633920e-02f, -1.86718162e-02f, -1.76362813e-01f, -3.77160423e-02f, 5.30069806e-02f,
  4.50235978e-02f, -2.79353168e-02f, 7.62244686e-02f, -3.51398289e-02f, -4.38634455e-02f, -5.48589928e-03f, -1.15547841e-02f, -1.15219660e-01f, -1.05749831e-01f, 3.85150453e-03f,
  5.98538220e-02f, -1.07172988e-01f, 4.20404114e-02f, 4.03125724e-03f, 3.77997793e-02f, -3.00636552e-02f, 4.36972119e-02f, -5.19584194e-02f, 4.12535220e-02f, 1.13144591e-02f,
  -1.59112453e-01f, 5.33482544e-02f, 3.39400652e-03f, -4.32874002e-02f, -1.02711990e-02f, 4.66312990e-02f, -2.44363658e-02f, 1.00554958e-01f, -2.29251049e-02f, -2.03593876e-02f,
  4.72818725e-02f, -1.22294845e-02f, -8.43592361e-02f, -1.79938421e-01f, -6.82249516e-02f, 2.67486125e-02f, 3.62329222e-02f, 1.17966542e-02f, -1.90292764e-02f, -8.86489525e-02f,
  -2.14260831e-01f, -2.29087118e-02f, 2.67263148e-02f, 4.46919724e-02f, 4.41577062e-02f, -1.75704770e-02f, -2.51779016e-02f, -1.26882970e-01f, 7.34710321e-02f, -5.43833785e-02f,
  3.58854048e-02f, -3.23342420e-02f, -8.56557041e-02f, 1.84245463e-02f, -3.73741575e-02f, -1.02075422e-02f, -2.65822299e-02f, 3.19152623e-02f, -7.71019384e-02f, -9.01174694e-02f,
  -3.94498594e-02f, 1.56879332e-02f, -1.12747990e-01f, -3.91895212e-02f, -5.97086437e-02f, -2.97232438e-02f, 8.95893946e-02f, -2.93236449e-02f, -6.63759038e-02f, -2.03301124e-02f,
  -2.61923904e-03f, -2.37541467e-01f, 1.31750643e-01f, -2.43338719e-02f, 4.06719595e-02f, 1.30672231e-01f, 2.04826832e-01f, -1.80160657e-01f, -1.53221786e-01f, -2.80216575e-01f,
  -6.02413043e-02f, 2.63803042e-02f, 1.83680281e-01f, -1.01077989e-01f, 3.82387429e-01f, 1.23844475e-01f, -1.37727335e-01f, -1.41108826e-01f, -3.62737812e-02f, 1.03263045e-02f,
  2.03713626e-02f, -2.21060678e-01f, 1.96234480e-01f, -2.99371749e-01f, -3.07283085e-02f, -7.55614042e-02f, -1.81175955e-02f, 1.77159026e-01f, -1.68568209e-01f, 9.41473693e-02f,
  -9.95202735e-02f, 5.56211807e-02f, 7.17137083e-02f, -1.03601843e-01f, -9.80731398e-02f, 4.56036665e-02f, 5.60699329e-02f, 1.55373558e-01f, 8.06241259e-02f, -6.32754564e-02f,
  8.54299739e-02f, -2.52504405e-02f, 7.12473271e-03f, 8.41637235e-03f, 3.40158492e-02f, 5.17883943e-03f, -2.09500249e-02f, -2.42822357e-02f, -6.48678327e-03f, 2.09404137e-02f,
  1.22396350e-01f, 5.26345298e-02f, 9.36483294e-02f, -4.01940420e-02f, 1.01106301e-01f, 7.05798864e-02f, 9.44019482e-02f, 1.87756076e-01f, -3.22818942e-02f, -1.98744267e-01f,
  -1.49145480e-02f, -2.17305031e-02f, 3.64588052e-02f, -1.08136423e-01f, -3.27967219e-02f, 6.66958094e-03f, -1.81077998e-02f, 1.47574693e-02f, 2.97710039e-02f, 1.04402736e-01f,
  -1.22501410e-03f, -8.93423334e-02f, 5.22132516e-02f, 3.79943289e-02f, -1.13638721e-01f, -1.23348042e-01f, 2.14481894e-02f, 1.29876016e-02f, -6.50290400e-02f, -1.00534320e-01f,
  1.04017749e-01f, 9.72315893e-02f, 4.83128875e-02f, 2.73002330e-02f, 1.60380732e-02f, 1.12976693e-01f, 2.87157595e-02f, 2.85651311e-02f, 9.44392476e-03f, 8.06077048e-02f,
  -1.35459885e-01f, -1.17302619e-01f, -4.13489155e-02f, -1.21467561e-01f, -4.67673838e-02f, -7.82980397e-02f, -5.58170751e-02f, -4.12948541e-02f, -8.79196543e-03f, -7.25961477e-02f,
  -3.24893408e-02f, -1.99285224e-02f, 2.67031044e-02f, -5.76502495e-02f, -5.56158237e-02f, -8.96075442e-02f, 4.86196019e-02f, -7.96219148e-03f, 1.28580714e-02f, -1.10767007e-01f,
  -2.83213519e-02f, 1.65411253e-02f, -1.98613014e-02f, -1.24226697e-02f, -7.25245103e-02f, 7.21335933e-02f, -1.87813472e-02f, -4.23189700e-02f, 3.68592106e-02f, -5.70414327e-02f,
  3.65839511e-01f, 1.37219757e-01f, 3.12738508e-01f, 3.21474895e-02f, 2.25003242e-01f, -6.24046624e-02f, 2.63044238e-02f, 6.54854849e-02f, 2.45256543e-01f, -8.62132534e-02f,
  -1.50487423e-01f, 1.63370714e-01f, -1.04544878e-01f, -4.59367223e-02f, -2.00038359e-01f, -3.15577000e-01f, -1.13697372e-01f, -1.45232782e-01f, -5.26215546e-02f, -8.30669031e-02f,
  -7.09208027e-02f, -2.06504792e-01f, 8.32573846e-02f, -5.16388491e-02f, 1.64192662e-01f, 1.19411945e-01f, -7.84752741e-02f, -4.84780557e-02f, -5.88160828e-02f, 3.14028263e-02f,
  -2.00613979e-02f, 1.83459729e-01f, 7.83142373e-02f, 1.46516096e-02f, 9.57288072e-02f, -1.20194675e-02f, -5.33552058e-02f, 1.06767587e-01f, -7.43427500e-03f, -5.37940972e-02f,
  -1.74296219e-02f, -7.77797699e-02f, -5.01059368e-03f, 9.20650661e-02f, 1.44620031e-01f, 1.19440578e-01f, 6.23744316e-02f, 5.73413558e-02f, 1.79210678e-01f, 8.45054910e-02f,
  2.60170866e-02f, 1.72117084e-01f, 1.21002525e-01f, 4.34504747e-02f, 5.44684082e-02f, 7.20195323e-02f, 4.84764613e-02f, 6.15889505e-02f, -4.67269644e-02f, 4.33364846e-02f,
  9.68474662e-04f, -8.89730677e-02f, 2.29120981e-02f, -6.59833625e-02f, -8.81683752e-02f, -5.86133637e-03f, 5.80695979e-02f, -1.97185483e-02f, -4.38986048e-02f, -1.25903785e-01f,
  -3.27884336e-03f, 5.92813231e-02f, -5.82473166e-02f, 2.62698997e-02f, 2.13545859e-02f, -3.08536608e-02f, -1.09337404e-01f, -8.60212967e-02f, 1.99119318e-02f, -3.36888619e-02f,
  -7.18091801e-02f, -1.21302180e-01f, -3.87522392e-02f, -7.31735975e-02f, 6.91894963e-02f, -3.13208885e-02f, -1.42511889e-01f, -2.12414619e-02f, -2.76919790e-02f, 4.21391465e-02f,
  -2.33569682e-01f, -1.70699015e-01f, -3.38815302e-02f, -1.05166817e-02f, 1.87001955e-02f, -1.81718376e-02f, -2.38054004e-02f, -3.11130285e-02f, -1.54748121e-02f, 1.12499697e-02f,
  3.36880311e-02f, 8.57427809e-03f, -2.02831011e-02f, -1.63639300e-02f, -2.59797722e-02f, 1.08121455e-01f, -6.37208149e-02f, -5.95223121e-02f, 9.27660987e-02f, -7.53169581e-02f,
  -1.71980131e-02f, 8.14011507e-03f, -6.82419911e-02f, 2.47630253e-02f, 2.47218311e-02f, 1.05245151e-01f, -2.76776776e-02f, 6.40008003e-02f, -9.67275277e-02f, -9.67608616e-02f,
  3.98747742e-01f, -2.48029560e-01f, -6.78333044e-02f, 2.92309314e-01f, 3.13125581e-01f, -2.94875968e-02f, 1.46669447e-01f, 1.76136494e-01f, 3.14518362e-01f, -2.74507701e-01f,
  2.91826501e-02f, -1.03422359e-01f, -2.57280767e-01f, 2.05278862e-02f, 1.52560472e-01f, -1.60432160e-01f, 6.67431429e-02f, -1.69323072e-01f, 6.11796491e-02f, 1.23435613e-02f,
  1.03525348e-01f, 1.01418465e-01f, -1.42506938e-02f, 3.97887081e-02f, 1.32446617e-01f, 1.11777365e-01f, -1.13239521e-02f, -1.74464941e-01f, -2.93949451e-02f, -2.32029408e-02f,
  4.96251956e-02f, 7.62646496e-02f, 7.56120756e-02f, -9.07371193e-02f, -1.98145746e-03f, 2.67933751e-03f, -1.18744910e-01f, -1.38855875e-02f, 1.02354504e-01f, -4.50358354e-02f,
  -3.08247562e-02f, 4.99869846e-02f, 4.25824113e-02f, -5.31391706e-03f, 4.39136103e-02f, 8.40452984e-02f, 7.01322034e-02f, 2.24673990e-02f, 3.96951661e-02f, 8.26847479e-02f,
  5.20564243e-02f, -5.76589331e-02f, 1.40835389e-01f, -1.51089132e-02f, 5.22572696e-02f, 1.63791314e-01f, 5.48795015e-02f, -5.87930195e-02f, -6.66686743e-02f, 1.22235432e-01f,
  -7.95323700e-02f, -3.19633596e-02f, 2.43457537e-02f, 7.65512288e-02f, -6.64167702e-02f, 1.51203096e-01f, 1.01621756e-02f, -2.60092560e-02f, -9.65640172e-02f, -8.23565349e-02f,
  4.06020284e-02f, 5.08902594e-02f, -1.48575511e-02f, 4.37996462e-02f, -2.28639282e-02f, 8.06856751e-02f, -6.44836575e-02f, -7.09780380e-02f, -4.33981568e-02f, 9.11082774e-02f,
  3.68035771e-02f, 3.53491865e-02f, -9.13567767e-02f, 1.05746742e-02f, -1.17823720e-01f, 2.56090108e-02f, -5.00977933e-02f, -8.71016756e-02f, 5.62967397e-02f, -3.22504789e-02f,
  -3.87678176e-01f, -2.76470482e-01f, -9.66974646e-02f, -1.38013721e-01f, -6.85126260e-02f, -7.59689808e-02f, -8.19154829e-02f, 3.85143496e-02f, -6.48550540e-02f, 3.43713462e-02f,
  -4.35188860e-02f, 1.66172124e-02f, -6.21795356e-02f, 1.79617200e-02f, -2.82927696e-02f, 8.29313397e-02f, -8.35836083e-02f, -7.31814876e-02f, 4.17826371e-03f, -8.81503969e-02f,
  -7.70899802e-02f, -4.36546393e-02f, 2.58700587e-02f, 1.18477747e-01f, -4.82420059e-04f, -4.43508588e-02f, -1.95167176e-02f, 1.98841318e-02f, -9.39672440e-02f, -2.98692100e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  7.28706270e-02f, 5.27449837e-03f, 2.17316195e-01f, 1.54369161e-01f, 7.36230537e-02f, 2.12463707e-01f, 1.67607591e-01f, 2.80171279e-02f, -1.27875563e-02f, 1.28753901e-01f,
  9.98904854e-02f, 4.62466925e-02f, -2.25463957e-02f, 6.63498342e-02f, 1.59528181e-01f, 1.26222879e-01f, 5.07624373e-02f, 1.59328789e-01f, 3.18307467e-02f, 6.21022955e-02f,
  1.19940400e-01f, 2.15546235e-01f, 1.67520493e-01f, 7.11463615e-02f, 2.02750593e-01f, 1.22992583e-01f, 1.25611261e-01f, 1.51936278e-01f, -6.52235076e-02f, 9.48144868e-02f,
  8.91150534e-02f, 6.48216009e-02f, 2.23174915e-01f, 6.12845421e-02f, 1.93027198e-01f, 3.92444432e-02f, 5.49415387e-02f, 1.98234230e-01f, 1.74529463e-01f, 1.81200579e-01f,
  2.64038473e-01f, 1.49471998e-01f, -1.40240297e-01f, 7.50850439e-02f, 2.39450559e-02f, 1.38254821e-01f, 1.19024426e-01f, 2.72007078e-01f, 1.35954380e-01f, 8.93955380e-02f,
  4.77728583e-02f, 1.23144031e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  3.88557352e-02f, 2.96751522e-02f, 1.04628481e-01f, 1.73625782e-01f, 7.60373697e-02f, 2.52194852e-02f, -5.85321784e-02f, 5.29519506e-02f, -7.28772208e-02f, 6.60181642e-02f,
  2.05088273e-01f, -1.73045412e-01f, 8.65533054e-02f, -1.66192725e-01f, -2.22851019e-02f, -4.48671840e-02f, 2.40700662e-01f, -2.37071645e-02f, 1.78781748e-02f, 1.40211299e-01f,
  1.73419118e-01f, 1.23314597e-01f, -6.73901439e-02f, -5.63014019e-03f, -2.27614474e-02f, 2.13897169e-01f, 8.75894330e-04f, 1.61795646e-01f, -1.79690003e-01f, 1.10507332e-01f,
  1.77399129e-01f, -4.36184071e-02f, -1.04376465e-01f, -1.73845455e-01f, -1.08638756e-01f, -3.76767106e-02f, 2.72899151e-01f, 2.72069089e-02f, -2.21692938e-02f, -5.15612178e-02f,
  8.15838352e-02f, -1.08136199e-02f, 1.44778252e-01f, -8.15748498e-02f, -2.71263234e-02f, 7.91034549e-02f, -2.39080518e-01f, -7.46408924e-02f, 6.88222572e-02f, -1.89344168e-01f,
  -9.81623530e-02f, 9.04302523e-02f, 7.59903938e-02f, -4.40948121e-02f, 3.31015773e-02f, 1.34741031e-02f, -7.26492936e-03f, -8.87306780e-03f, -2.49422658e-02f, -8.36807117e-02f,
  -1.24058396e-01f, 2.39074975e-01f, -1.62812784e-01f, -2.42179520e-02f, -6.10521995e-02f, 4.95547615e-02f, 9.65392124e-03f, -6.58701509e-02f, -6.70276582e-02f, -8.73246565e-02f,
  9.50207859e-02f, -8.29707161e-02f, 1.05796583e-01f, -6.24970496e-02f, 1.35794813e-02f, 2.53693685e-02f, 3.68923414e-03f, 2.81854898e-01f, -4.92954161e-03f, -4.03531967e-03f,
  2.69719422e-01f, -2.60970920e-01f, 5.09274602e-02f, -2.15777233e-01f, -1.13411926e-01f, 9.38555691e-03f, -1.19162992e-01f, -1.04478389e-01f, -3.58583219e-02f, -2.43639112e-01f,
  -1.40609384e-01f, -2.19470218e-01f, 1.15563840e-01f, 5.56981079e-02f, -5.91567680e-02f, -7.36245140e-02f, -8.43245685e-02f, 2.81820204e-02f, 8.19854736e-02f, 1.81450874e-01f,
  -2.94250157e-02f, 1.00917824e-01f, 2.23114192e-01f, -7.10577592e-02f, -9.65044051e-02f, -1.03692293e-01f, -1.49512470e-01f, 7.54815266e-02f, 6.24155216e-02f, -1.20803006e-01f,
  1.22352429e-01f, -6.95432201e-02f, 1.13649599e-01f, 4.13442962e-02f, -2.85644922e-02f, -3.83111299e-03f, 4.95445579e-02f, -1.81125820e-01f, 7.73703903e-02f, -1.74386635e-01f,
  -1.16879627e-01f, -1.88120157e-02f, 3.09695955e-02f, 2.10774079e-01f, 2.96618104e-01f, -1.44335315e-01f, 1.69090368e-02f, -1.03471033e-01f, 1.24020432e-03f, -1.23985857e-01f,
  -1.01654362e-02f, -8.31850525e-03f, -6.87144995e-02f, -2.83905528e-02f, -1.13849111e-01f, -5.25717512e-02f, -1.93466410e-01f, 5.37941791e-03f, 3.43057476e-02f, -4.76415306e-02f,
  -6.70070294e-03f, -2.07041249e-01f, 1.66762516e-01f, -2.79121567e-02f, -2.90159851e-01f, 1.29776314e-01f, -4.62926291e-02f, 2.63599474e-02f, 1.59611776e-02f, -7.45777413e-02f,
  4.98790108e-02f, 1.05074994e-01f, -5.04991561e-02f, 1.50894493e-01f, 6.75020739e-02f, 1.46260023e-01f, 2.19280452e-01f, -4.02242802e-02f, -1.34371251e-01f, 5.33737056e-02f,
  -3.59735489e-02f, -4.94149402e-02f, -1.46231065e-02f, -2.73580432e-01f, -1.34627353e-02f, 1.37034416e-01f, -6.98753027e-03f, 1.83855355e-01f, -5.55336140e-02f, 1.89063743e-01f,
  2.21125539e-02f, -7.67901689e-02f, -3.92771363e-02f, 2.38459893e-02f, -1.10429423e-02f, -1.41989112e-01f, -7.28376731e-02f, 8.56871977e-02f, -7.79628456e-02f, -1.51281595e-01f,
  -2.09238026e-02f, 2.10002288e-01f, -1.35297120e-01f, 2.22817600e-01f, -3.10641732e-02f, 1.04859672e-01f, -1.16130248e-01f, -3.37215178e-02f, -2.43631899e-01f, 1.29853576e-01f,
  2.09121346e-01f, 8.90280902e-02f, -1.08269237e-01f, -1.14215218e-01f, -1.24548003e-01f, 2.45537516e-02f, -8.16596225e-02f, 7.06155971e-02f, -5.28931059e-02f, -2.59581715e-01f,
  -4.50361185e-02f, 1.79330945e-01f, 3.05445096e-03f, 9.60444938e-03f, 7.45356902e-02f, 8.39135870e-02f, 3.50870453e-02f, 6.97767437e-02f, 9.57698822e-02f, 2.00108923e-02f,
  -9.39232484e-03f, 7.09767416e-02f, 1.56828269e-01f, 2.80992508e-01f, 1.00873457e-02f, 4.83290553e-02f, -5.69024868e-02f, -2.76893899e-02f, 7.21724108e-02f, 7.59562775e-02f,
  1.23474725e-01f, -1.98951811e-01f, -2.79905915e-01f, -3.57316399e-04f, 1.47073746e-01f, 5.48970252e-02f, -9.87375453e-02f, 5.19570783e-02f, 3.02418061e-02f, 1.88792497e-01f,
  4.28230949e-02f, 1.33620486e-01f, 2.11245730e-03f, 1.92442060e-01f, 2.39487365e-01f, 7.75493169e-03f, 6.45116270e-02f, 5.29348552e-02f, 9.37065482e-02f, -1.04515448e-01f,
  -6.79277629e-02f, 1.13763260e-02f, -1.36424258e-01f, -9.96862054e-02f, 5.13480753e-02f, 1.27312884e-01f, 1.57021761e-01f, 9.77551267e-02f, -9.73497331e-03f, 3.27953063e-02f,
  -2.34021693e-02f, 1.47134945e-01f, 1.55370280e-01f, 5.58488220e-02f, -2.67929640e-02f, -2.05223024e-01f, 7.47748315e-02f, -5.85674793e-02f, 9.88015532e-03f, -5.11038750e-02f,
  1.73737705e-02f, -1.07141599e-01f, 1.22531746e-02f, 1.85732946e-01f, -8.78750980e-02f, 3.14509049e-02f, -1.86365917e-02f, 2.48324219e-02f, 1.60441637e-01f, -8.41351375e-02f,
  -1.09813452e-01f, 1.60948575e-01f, 1.97127640e-01f, 1.53800128e-02f, 6.31093755e-02f, 1.71768934e-01f, 1.44661725e-01f, 5.34234010e-02f, 1.16710633e-01f, 1.03583351e-01f,
  7.32623935e-02f, 1.55008793e-01f, 1.81788146e-01f, -7.43279755e-02f, -2.36387804e-01f, 1.30329162e-01f, 1.70988560e-01f, 5.91813400e-02f, -1.31126121e-01f, 1.02359623e-01f,
  9.21295360e-02f, 6.96129277e-02f, 1.05208904e-01f, -1.05568275e-01f, -5.49122617e-02f, -1.32562429e-01f, 6.18254431e-02f, -2.00583860e-01f, -2.22760826e-01f, -6.71447022e-03f,
  5.39098084e-02f, -1.21321857e-01f, -1.28310844e-01f, 1.76725760e-02f, 7.09501281e-02f, 8.47622380e-02f, 8.54912251e-02f, 1.71059400e-01f, -4.10207659e-02f, -5.41369664e-03f,
  1.18196554e-01f, 2.61404496e-02f, 2.12971881e-01f, -1.17483281e-01f, 3.13244164e-01f, 2.00498644e-02f, -1.96490601e-01f, -1.62503526e-01f, -1.33164868e-01f, 1.16521768e-01f,
  2.70010307e-02f, 5.12192436e-02f, 7.16263726e-02f, 4.84980829e-03f, -7.22044036e-02f, -7.89069943e-03f, 1.60865989e-02f, -3.27515975e-02f, 1.02766328e-01f, 1.24583066e-01f,
  -2.73782071e-02f, 1.09380879e-01f, -5.18485233e-02f, 1.40418738e-01f, 1.37530997e-01f, -1.40581369e-01f, -4.79173958e-02f, -8.80056992e-02f, 6.94990084e-02f, -1.72581106e-01f,
  -1.15120240e-01f, 5.74149787e-02f, -1.70447737e-01f, -1.81701570e-03f, -7.95621127e-02f, -1.50266767e-01f, -2.00383812e-01f, -1.74074192e-02f, 1.56599000e-01f, -1.21525852e-02f,
  -5.51798195e-02f, -1.87244955e-02f, -3.18639539e-02f, -6.23736754e-02f, -8.69547054e-02f, 4.44030315e-02f, -7.27962554e-02f, 8.94848108e-02f, 2.50706166e-01f, 1.00972630e-01f,
  -4.59355451e-02f, 6.49364218e-02f, 4.67308722e-02f, 2.34447625e-02f, 6.38886616e-02f, -1.19891725e-01f, 1.66661039e-01f, -5.80783859e-02f, 5.83469421e-02f, 1.01225384e-01f,
  -1.04109071e-01f, -6.19357415e-02f, 9.58661083e-04f, -1.40746906e-01f, -3.85181010e-02f, 7.28026778e-02f, -9.73642543e-02f, 7.08895968e-03f, -2.25519702e-01f, 6.45699501e-02f,
  1.48705304e-01f, -5.87897114e-02f, 9.20246616e-02f, 1.37375966e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.61386445e-01f, -1.99801642e-02f, -3.59137394e-02f, 5.38264820e-03f, 9.66820307e-03f, 1.84079111e-02f, 9.01009291e-02f, 9.25577953e-02f, 1.02144599e-01f, -1.43505424e-01f,
  -1.55628687e-02f, 1.88679323e-02f, 8.67668167e-02f, 1.88677967e-01f, -5.72807975e-02f, 1.52853858e-02f, 6.42678961e-02f, -5.16904593e-02f, 1.45395637e-01f, 1.34090871e-01f,
  2.17054680e-01f, 6.44609034e-02f, 5.73849976e-02f, 1.50459990e-01f, 1.42996490e-01f, -8.36635679e-02f, 1.06347434e-01f, -1.00703754e-01f, -5.94281554e-02f, -3.13691385e-02f,
  6.94386214e-02f, 7.91591629e-02f, 1.79792166e-01f, 1.94545373e-01f, 4.48557921e-02f, 1.56571731e-01f, 1.60447657e-01f, -1.38640031e-01f, -2.33101949e-01f, -5.61816385e-03f,
  1.79902300e-01f, -1.77363679e-01f, -2.46466659e-02f, 2.07835585e-01f, 1.00952856e-01f, 1.54952675e-01f, 9.51565523e-03f, 1.42340526e-01f, 9.90113094e-02f, -8.36509317e-02f,
  2.79083941e-02f, 2.04687670e-01f, -6.12714179e-02f, -6.23564608e-02f, -1.91083718e-02f, -4.21062000e-02f, 2.27484688e-01f, 7.00656101e-02f, 3.93934697e-02f, -6.74008206e-02f,
  -1.64178386e-02f, -4.78730872e-02f, -9.57220793e-02f, -8.72818902e-02f, 2.80769765e-02f, 4.21466529e-02f, 4.89358343e-02f, 3.72403562e-02f, 1.25867520e-02f, 9.40800086e-02f,
  -2.18180679e-02f, 1.16791725e-02f, -8.58881101e-02f, 1.48164362e-01f, -3.88366659e-03f, -1.01483196e-01f, 1.63654432e-01f, 5.10133766e-02f, 9.38096642e-02f, -6.10276647e-02f,
  1.12079829e-01f, 3.72023089e-03f, 1.66835990e-02f, 1.97120711e-01f, 1.37622744e-01f, 1.71268225e-01f, 7.53942057e-02f, 5.49099371e-02f, -9.02676582e-02f, 2.69256197e-02f,
  1.65803879e-01f, 6.83802068e-02f, -3.43894847e-02f, -1.83476582e-01f, -1.29729614e-01f, -1.19222235e-02f, 7.98049867e-02f, -7.51947388e-02f, -2.53668968e-02f, 8.44513327e-02f,
  -1.01759650e-01f, 2.86998563e-02f, -1.10046789e-01f, 2.04848871e-01f, 7.00993612e-02f, 6.99866563e-02f, 2.17897490e-01f, -1.02264129e-01f, -1.49592143e-02f, 1.14489771e-01f,
  1.64305180e-01f, -3.87166031e-02f, -1.03212558e-01f, 9.59202051e-02f, -6.25864789e-02f, 5.18221557e-02f, 7.30727613e-02f, 2.64249742e-01f, 8.68508965e-02f, 1.89077288e-01f,
  8.83762464e-02f, -9.17633176e-02f, -1.72421131e-02f, -4.30750512e-02f, -8.81593451e-02f, 4.17653397e-02f, -7.75716230e-02f, -6.30241185e-02f, 1.29997522e-01f, 2.80653238e-01f,
  1.95721924e-01f, 2.87221164e-01f, 5.76344468e-02f, 7.33080953e-02f, 5.96130975e-02f, -1.42926246e-01f, 1.12077288e-01f, -7.72663429e-02f, -9.38303210e-03f, 1.33906007e-01f,
  5.56629896e-02f, -1.47410095e-01f, -1.81381200e-02f, 3.49358544e-02f, 4.22629833e-01f, -2.50363648e-01f, 1.82970047e-01f, 6.77487403e-02f, 5.39440699e-02f, 1.81944534e-01f,
  -1.23155065e-01f, -1.35420248e-01f, 1.62148327e-01f, 1.02880448e-01f, -4.74919491e-02f, -3.47378403e-02f, -8.16588998e-02f, -4.52773198e-02f, 8.87768790e-02f, -2.42812067e-01f,
  -1.53621137e-01f, -1.29088625e-01f, -1.44656077e-02f, 9.32351798e-02f, 1.26862720e-01f, 9.33997519e-03f, 1.08598560e-01f, 3.02740671e-02f, 1.07106499e-01f, -6.19392917e-02f,
  4.44418527e-02f, 1.41013011e-01f, 1.02078617e-01f, 1.25696331e-01f, 9.52529758e-02f, -1.03492044e-01f, 2.70024896e-01f, 1.42834276e-01f, 1.38023466e-01f, 2.22964510e-02f,
  1.37556881e-01f, -1.58212334e-01f, 1.80586964e-01f, -2.01063931e-01f, -3.48569453e-02f, 1.70454338e-01f, -7.33027060e-04f, -5.94192185e-02f, 1.87848717e-01f, 6.46086261e-02f,
  -1.12613514e-01f, -1.51647180e-01f, -1.61431730e-02f, -1.62152231e-01f, -1.73164681e-02f, 1.49697587e-01f, -7.23897666e-02f, 5.25334813e-02f, -1.63749009e-01f, 4.31834571e-02f,
  -5.06422520e-02f, 1.21561047e-02f, 2.23915175e-01f, 6.63662925e-02f, -4.93118986e-02f, -2.35247567e-01f, -4.25746217e-02f, -4.07172851e-02f, -1.74573958e-01f, 3.19089770e-01f,
  6.98377844e-04f, 1.11658603e-01f, -3.72730121e-02f, -1.81493729e-01f, -1.69272609e-02f, 9.14566293e-02f, 1.19898193e-01f, 9.93514359e-02f, 2.41142567e-02f, 2.06882656e-01f,
  -2.08485752e-01f, 5.65280020e-02f, 1.46879166e-01f, 2.26359978e-01f, -4.82697338e-02f, -1.31837592e-01f, -7.89017305e-02f, -3.31304669e-01f, 3.85294072e-02f, 5.95211685e-02f,
  -8.57536914e-04f, 7.78325018e-04f, -6.07667789e-02f, 1.43764257e-01f, 3.85341309e-02f, -1.03871688e-01f, -5.77994972e-04f, -2.73516681e-02f, -1.55703560e-01f, -1.08909927e-01f,
  -6.39444143e-02f, 1.54823646e-01f, -8.37595295e-03f, -1.29508927e-01f, -6.29245443e-03f, 1.22077994e-01f, -1.59226596e-01f, 2.42137954e-01f, -1.65800788e-02f, -8.07112977e-02f,
  1.25914499e-01f, -4.40583788e-02f, -2.16261834e-01f, 2.30892926e-01f, 1.74208939e-01f, 3.58366191e-01f, 7.34608620e-02f, 1.42839491e-01f, 1.18992239e-01f, 5.45913130e-02f,
  1.46539910e-02f, 3.85064855e-02f, 7.48179033e-02f, -1.04234079e-02f, 1.57139659e-01f, -3.39578748e-01f, -1.29824609e-01f, 3.17861438e-01f, -5.74219786e-02f, -1.51030168e-01f,
  -1.71871454e-01f, 2.18671113e-02f, -1.46858186e-01f, -1.49905095e-02f, 1.23968571e-01f, -2.60390610e-01f, -1.27251804e-01f, -7.17345923e-02f, -1.04958629e-02f, -1.54508114e-01f,
  7.66773447e-02f, -1.72625542e-01f, 9.32476521e-02f, -8.55707973e-02f, -3.00795045e-02f, -8.62836912e-02f, -4.31550369e-02f, -7.15483353e-02f, 4.02834639e-02f, 2.14860320e-01f,
  2.82743543e-01f, -1.02371305e-01f, -1.87500834e-01f, -1.17444396e-02f, -1.24780357e-01f, -1.49421440e-02f, -1.30467996e-01f, -5.29539213e-02f, -1.67651877e-01f, 2.14952484e-01f,
  2.43105978e-01f, -9.82107446e-02f, -4.63358909e-02f, -6.94654975e-03f, 3.28269638e-02f, 5.06667374e-03f, 3.44776988e-01f, -1.90633193e-01f, -1.54263303e-01f, 1.55222425e-02f,
  -1.74668729e-01f, -4.05372493e-02f, 1.11125603e-01f, 1.10606343e-01f, 1.65281311e-01f, 3.75308772e-03f, 1.55657336e-01f, -6.42784908e-02f, -2.71305791e-03f, -2.31977999e-02f,
  2.89178174e-02f, -5.25533333e-02f, 2.95505021e-02f, -1.50684314e-03f, 6.86420947e-02f, 9.05503556e-02f, -4.52006385e-02f, -9.37513635e-03f, 3.21836509e-02f, 9.07529667e-02f,
  4.14490104e-02f, -7.30354935e-02f, -2.13721730e-02f, 1.68304622e-01f, -1.09321535e-01f, -6.49391636e-02f, -1.31170362e-01f, 6.38529733e-02f, -7.42010400e-02f, -2.83492915e-02f,
  7.97821134e-02f, 4.26953472e-02f, 9.05215293e-02f, -6.50925338e-02f, -1.71472162e-01f, 6.13127798e-02f, -6.38327152e-02f, 3.75718437e-02f, -1.59844741e-01f, 3.14825028e-02f,
  -5.78762256e-02f, 5.31807058e-02f, 1.63758650e-01f, 1.51743308e-01f, -1.48783848e-01f, 1.10221654e-01f, 1.61820650e-01f, -7.62723684e-02f, -1.17708594e-01f, -1.16869345e-01f,
  -2.95954868e-02f, 1.02386385e-01f, 2.11289331e-01f, 6.22777715e-02f, -1.20784417e-01f, 3.62657867e-02f, -2.93182172e-02f, 1.01009279e-01f, 2.34223418e-02f, -1.77651361e-01f,
  -1.58705220e-01f, 1.71614274e-01f, 1.84842482e-01f, -1.13697387e-01f, -1.45271927e-01f, 2.48276331e-02f, -2.93259080e-02f, -9.54081416e-02f, -6.79079145e-02f, 6.89648762e-02f,
  1.28033962e-02f, 1.18195385e-01f, -1.28494188e-01f, -1.06034942e-01f, 2.01757386e-01f, 6.73447475e-02f, 1.38441950e-01f, 2.23547518e-02f, 1.35941267e-01f, 3.25902216e-02f,
  -6.59376336e-03f, 2.09191322e-01f, -6.66572750e-02f, 1.48786488e-03f, -1.68174103e-01f, 1.20481625e-01f, -2.79111378e-02f, 5.39929457e-02f, 1.80409238e-01f, 4.42743786e-02f,
  -1.95464551e-01f, 1.35165721e-01f, 5.81622012e-02f, 2.44370271e-02f, -1.38853788e-01f, -2.54344434e-01f, 1.37714878e-01f, 1.52158320e-01f, 3.87787335e-02f, 8.82892013e-02f,
  2.32057601e-01f, 2.73457728e-02f, 1.02054700e-01f, 2.14643687e-01f, 2.23100230e-01f, 1.67568028e-01f, 8.02825168e-02f, 2.32708052e-01f, 2.28662714e-01f, 3.76474299e-03f,
  -1.86559394e-01f, 7.01298639e-02f, 3.51696126e-02f, 1.43921658e-01f, -8.80326182e-02f, -3.60453390e-02f, -1.64849311e-01f, -1.29290640e-01f, 9.10973325e-02f, -5.74920587e-02f,
  1.95257634e-01f, 1.53599996e-02f, -3.24352533e-02f, 1.60829023e-01f, 7.50722885e-02f, 9.44057480e-02f, 6.55511161e-03f, 1.60818696e-01f, -1.83371529e-01f, 5.33336066e-02f,
  1.84161499e-01f, 2.74702329e-02f, 1.25778794e-01f, -5.02546877e-02f, -2.47136950e-01f, -1.02895722e-01f, 2.37247944e-01f, 1.97560981e-01f, 2.27597892e-01f, 1.24395378e-01f,
  6.18358068e-02f, -5.34726195e-02f, 8.27920958e-02f, 8.62837732e-02f, 7.87708685e-02f, 1.81908026e-01f, 9.73652825e-02f, -2.42755100e-01f, -1.73435315e-01f, 2.01059625e-01f,
  1.17755271e-01f, 2.03426331e-01f, -8.70146155e-02f, 5.05396202e-02f, -2.02393495e-02f, -4.55810539e-02f, 1.30982548e-01f, -2.64600664e-02f, 7.15734959e-02f, -3.55436653e-03f,
  1.77217066e-01f, 8.82272720e-02f, 1.05346248e-01f, -1.85657173e-01f, 1.71057880e-01f, -1.59351826e-01f, -1.83480922e-02f, -6.63565174e-02f, 8.94558504e-02f, 7.34650642e-02f,
  2.00450942e-01f, 1.63376972e-01f, 2.52961040e-01f, 1.66387260e-01f, -3.21535580e-02f, 4.66618873e-03f, -1.81666538e-01f, -7.88997337e-02f, 1.88434780e-01f, -2.44106233e-01f,
  -7.13266432e-02f, 2.05872804e-01f, 1.69210076e-01f, 8.44180211e-02f, -1.08085304e-01f, 2.21931800e-01f, 4.76730503e-02f, -1.01098128e-01f, 1.19373828e-01f, 2.40276039e-01f,
  -8.33103508e-02f, -3.11965542e-03f, -9.83518958e-02f, -1.81496799e-01f, 2.52264172e-01f, 6.62277788e-02f, 1.68091252e-01f, -1.10519759e-01f, -1.03080124e-01f, -1.23561949e-01f,
  -1.00008130e-01f, -1.08839534e-01f, 6.52834699e-02f, 1.84620187e-01f, 1.95072778e-02f, -4.86026481e-02f, 1.38044968e-01f, 1.39200762e-01f, 4.18088548e-02f, -9.11628306e-02f,
  1.00615524e-01f, 2.57274434e-02f, -1.22704789e-01f, 6.58040047e-02f, -1.56361923e-01f, 1.76831394e-01f, 1.08975708e-01f, 1.64980456e-01f, -1.47683382e-01f, -6.48782477e-02f,
  1.17265798e-01f, -4.21012901e-02f, 2.97095552e-02f, -1.11688346e-01f, 1.58818141e-01f, -7.15537444e-02f, 1.25229470e-02f, -1.06066659e-01f, 1.28622323e-01f, -1.50938928e-01f,
  2.03782126e-01f, -1.38994098e-01f, -2.76128143e-01f, 4.30584773e-02f, 1.10918753e-01f, 2.72334188e-01f, 1.60107628e-01f, 1.09749161e-01f, -2.59490281e-01f, 7.92730749e-02f,
  1.01914614e-01f, 2.28338629e-01f, -1.52412415e-01f, 1.57765880e-01f, 2.55431188e-03f, 9.24661197e-03f, 1.02219678e-01f, -2.82524973e-02f, 3.76074255e-01f, -5.87441958e-02f,
  -9.26767215e-02f, 1.33843377e-01f, 9.10700411e-02f, -4.97507788e-02f, 2.48803087e-02f, 1.59339085e-01f, -5.35918400e-02f, -6.06854027e-03f, -1.71935663e-01f, 7.83362463e-02f,
  -4.78982292e-02f, 1.89028844e-01f, 1.61791131e-01f, -6.88525662e-02f, 2.25256875e-01f, -4.52880748e-02f, 8.68655294e-02f, 1.09409913e-01f, 8.22011903e-02f, -2.49377247e-02f,
  1.31480962e-01f, 1.36277124e-01f, 1.14958338e-01f, -9.56682861e-02f, -7.75989965e-02f, 1.43344060e-01f, -4.35010828e-02f, -1.27821699e-01f, 2.85170507e-02f, 3.35079908e-01f,
  1.54392524e-02f, -7.85777718e-02f, 3.77640724e-02f, -1.79231793e-01f, -1.50529712e-01f, -8.65878016e-02f, -1.59116283e-01f, 1.78304166e-01f, -7.38200471e-02f, -5.30814379e-02f,
  -2.33841851e-01f, 3.29470560e-02f, 4.05716188e-02f, -8.84683877e-02f, -6.36951476e-02f, 2.93636322e-01f, 1.32955328e-01f, -3.64673622e-02f, 5.06691858e-02f, 5.09553589e-02f,
  -8.65875855e-02f, 2.12382734e-01f, 1.52177736e-01f, 5.71886897e-02f, 2.15591744e-01f, -1.80959180e-01f, -3.99292968e-02f, -1.16246834e-01f, 5.63603714e-02f, -8.39992240e-02f,
  5.34802526e-02f, -1.28772885e-01f, 6.06633946e-02f, 7.27554858e-02f, 2.89250594e-02f, -1.74589798e-01f, -8.11183751e-02f, 1.78029612e-01f, 1.32018328e-01f, -1.56991109e-01f,
  -7.09352270e-03f, -1.89981475e-01f, 4.15032469e-02f, -2.06253231e-01f, -9.78332758e-02f, 1.40493602e-01f, 9.84156132e-02f, -1.87809631e-01f, 5.11447387e-03f, -1.04592852e-01f,
  1.26748383e-01f, -7.35714883e-02f, 9.05172899e-03f, 7.86435902e-02f, 7.17343464e-02f, 2.15547811e-02f, -5.89481480e-02f, 1.92433938e-01f, -3.70522216e-02f, 4.76477966e-02f,
  2.05340050e-02f, 4.86930683e-02f, 1.45154640e-01f, -2.94683641e-03f, -6.44056350e-02f, -7.27528557e-02f, -5.44968173e-02f, 1.13439381e-01f, -8.71147439e-02f, 1.74612522e-01f,
  -3.43210064e-02f, 1.35271456e-02f, -7.97210354e-03f, 1.76284626e-01f, 2.10117605e-02f, 1.46078646e-01f, 9.56574902e-02f, 1.34052962e-01f, -1.23954631e-01f, 7.82996193e-02f,
  9.79680121e-02f, 4.30213474e-02f, 6.30536154e-02f, 3.07695009e-02f, 1.28103480e-01f, -7.29157478e-02f, 2.80287042e-02f, -4.19982150e-02f, -1.09744765e-01f, -5.37067987e-02f,
  1.29801380e-02f, -1.50757983e-01f, 1.29645532e-02f, -4.60539944e-02f, 1.16740234e-01f, -1.07330747e-01f, -1.52091250e-01f, -9.40401629e-02f, -1.32709205e-01f, 2.84949448e-02f,
  1.12436175e-01f, -4.37863544e-03f, -9.27790105e-02f, 9.69554037e-02f, 3.41643244e-02f, 1.34145051e-01f, 2.14836612e-01f, -1.28597751e-01f, 1.44000411e-01f, 4.64651957e-02f,
  -1.13100797e-01f, -4.33041379e-02f, 1.03262544e-01f, 2.67263889e-01f, -3.83043885e-02f, 2.35802997e-02f, 7.74472430e-02f, 1.72973946e-01f, -3.89366932e-02f, 5.13139647e-03f,
  1.14055768e-01f, -1.86273269e-02f, 4.23256047e-02f, 4.71987808e-03f, -8.54795724e-02f, -9.88318250e-02f, 5.82906492e-02f, -1.15131296e-01f, 1.39747128e-01f, 1.34715494e-02f,
  3.08322251e-01f, -8.78534168e-02f, 2.02209819e-02f, 1.34970814e-01f, 8.82177204e-02f, 2.61509627e-01f, -8.46633911e-02f, 1.20919771e-01f, 8.23169351e-02f, 4.73909713e-02f,
  5.16731888e-02f, 7.85651430e-02f, 8.19249451e-02f, -1.50645837e-01f, -1.51437983e-01f, -7.73781165e-02f, -1.75668579e-02f, -1.40559867e-01f, -3.61627899e-02f, -3.52789793e-04f,
  -2.45021120e-01f, 1.96520537e-01f, 2.62355566e-01f, 6.47535026e-02f, -2.35342011e-02f, 1.07602023e-01f, -9.25092027e-02f, -1.06734643e-02f, 1.76199198e-01f, -1.52327362e-02f,
  2.82943666e-01f, -1.30351976e-01f, -3.36748287e-02f, 3.38164032e-01f, 1.60429165e-01f, -4.36630026e-02f, 4.51202388e-04f, 2.97206670e-01f, 3.29486638e-01f, 1.08410560e-01f,
  3.93074714e-02f, 4.52843495e-03f, 2.77426597e-02f, 1.76137447e-01f, 3.83961439e-01f, -1.03886709e-01f, 1.49714062e-02f, 4.69026230e-02f, -1.17386412e-03f, 1.57040298e-01f,
  1.03919350e-01f, 7.86429867e-02f, 1.62597537e-01f, -6.52533546e-02f, 3.20811383e-02f, -5.76531366e-02f, -1.75781529e-02f, -2.25334629e-01f, -1.32107243e-01f, 1.54279888e-01f,
  -6.72538429e-02f, -1.06010824e-01f, 1.32944733e-01f, 2.69978177e-02f, -1.35159075e-01f, 1.27058879e-01f, 9.32443962e-02f, -1.82793289e-01f, -9.06954035e-02f, -1.71524838e-01f,
  -7.69735547e-03f, -5.00143468e-02f, 5.39133772e-02f, 2.36915182e-02f, 2.65126652e-03f, -1.27404770e-02f, 1.97570279e-01f, 1.99629501e-01f, 4.14704382e-02f, -2.61197034e-02f,
  -6.89780340e-02f, 8.40562358e-02f, 1.58841476e-01f, -8.21527690e-02f, -2.57530212e-01f, 2.28651136e-01f, 1.45687312e-01f, 4.09476273e-02f, -8.97050202e-02f, 1.74726859e-01f,
  -1.55830055e-01f, 1.36005953e-01f, 1.36876643e-01f, -1.25262991e-01f, 1.02146752e-01f, -6.31288588e-02f, -6.17444655e-03f, 1.90245360e-01f, 3.12052995e-01f, -2.04546213e-01f,
  -1.09266199e-01f, -2.88097244e-02f, -1.35831431e-01f, -1.83870120e-03f, -1.02916054e-01f, 1.08262554e-01f, 6.02153614e-02f, 9.55699086e-02f, 1.64618433e-01f, -8.10994506e-02f,
  2.17016354e-01f, 9.00560692e-02f, 1.32718965e-01f, 1.63547024e-01f, 1.48034245e-01f, 8.98428485e-02f, 1.99589953e-01f, 7.71768764e-02f, -3.07147298e-02f, -7.70010501e-02f,
  -1.84146091e-01f, 1.33480117e-01f, -5.29962182e-02f, -2.39161223e-01f, -1.18794940e-01f, 1.08759321e-01f, 1.89942405e-01f, 1.12923637e-01f, -4.12817970e-02f, 3.85763566e-03f,
  -4.47101370e-02f, -4.18862179e-02f, 4.24670428e-03f, -8.52658898e-02f, 1.28196836e-01f, 3.10693793e-02f, -2.06770942e-01f, 8.83664191e-02f, -3.06412466e-02f, -2.25359388e-02f,
  1.11200966e-01f, 5.93698658e-02f, -9.12616402e-02f, 1.23809889e-01f, 4.75063287e-02f, -4.24564742e-02f, -5.22128120e-02f, 2.05535039e-01f, -5.73976524e-03f, 9.38742980e-02f,
  4.27561887e-02f, 8.74541551e-02f, -8.39151517e-02f, 2.19750866e-01f, 1.44310907e-01f, -1.62788868e-01f, -6.44431636e-02f, 1.08181469e-01f, 2.25849524e-01f, 3.57477181e-02f,
  -9.87103656e-02f, -1.36138037e-01f, -1.28448278e-01f, 7.66895711e-02f, 2.37588540e-01f, 3.18408222e-03f, -6.29136711e-02f, 5.96568825e-05f, -6.57688007e-02f, -9.43685323e-02f,
  -2.57300854e-01f, 1.65053606e-01f, 5.58899827e-02f, 1.33924142e-01f, 1.17520258e-01f, -7.25846291e-02f, 9.26994607e-02f, -7.37110749e-02f, -3.09276074e-04f, -4.27457877e-02f,
  9.14455652e-02f, -1.24382162e-02f, 4.90591154e-02f, 1.10078402e-01f, 6.41833618e-02f, 5.54453805e-02f, 6.64670020e-02f, -7.11141899e-02f, 1.08048022e-01f, 2.14346424e-01f,
  -4.37513478e-02f, -2.14923564e-02f, 1.62306577e-01f, 6.77300841e-02f, 1.30099268e-03f, 1.67309165e-01f, 2.07762256e-01f, 5.57246432e-02f, 9.98949409e-02f, 1.69882953e-01f,
  4.43821028e-02f, 6.89776838e-02f, -8.24357104e-03f, -3.83935822e-03f, -1.59497857e-01f, 1.58555329e-01f, 1.90224722e-01f, 2.22365018e-02f, 7.46016949e-03f, 3.28579172e-02f,
  -4.39010039e-02f, 1.70830980e-01f, 2.46012747e-01f, -5.20205386e-02f, -3.23517136e-02f, -6.66142553e-02f, 1.34655699e-01f, -1.64239377e-01f, 1.09053567e-01f, 9.10462141e-02f,
  -3.87179735e-03f, 1.60380341e-02f, -1.90498471e-01f, 1.50941551e-01f, 7.89612010e-02f, -1.47072986e-01f, -1.32252112e-01f, 2.17054114e-01f, 2.73787342e-02f, -1.21385694e-01f,
  2.81987730e-02f, -2.10816730e-02f, 1.70846477e-01f, 2.71483008e-02f, 1.40031785e-01f, -6.31883973e-03f, -3.31233442e-02f, -9.43239871e-03f, -1.15935110e-01f, 6.07446395e-02f,
  1.67757589e-02f, 4.48323525e-02f, 5.07641286e-02f, 1.25091314e-01f, 4.62135300e-02f, 3.99995334e-02f, 1.89403877e-01f, -2.24799171e-01f, 1.18260682e-01f, -1.78669497e-01f,
  -6.48666471e-02f, 1.48907229e-01f, -1.04733162e-01f, -1.90965042e-01f, -1.15050785e-02f, 1.11689411e-01f, 5.90917328e-03f, -1.06396317e-01f, 2.59519339e-01f, -1.15285918e-01f,
  7.84805939e-02f, -5.46960160e-02f, -1.15155622e-01f, -1.35253787e-01f, 2.33844295e-01f, -2.72771027e-02f, 2.23062783e-02f, 5.58649041e-02f, 2.37144157e-02f, -5.64707592e-02f,
  -7.61130452e-02f, -1.53178632e-01f, -1.04955606e-01f, 4.96377945e-02f, 1.81613594e-01f, -4.74741422e-02f, 8.79199356e-02f, -1.73671231e-01f, 8.47375020e-02f, 1.66571721e-01f,
  5.32650761e-03f, -3.09654530e-02f, 1.66743379e-02f, 1.59328192e-01f, 3.55668962e-02f, 6.72299713e-02f, 5.98345250e-02f, 3.93815488e-02f, 1.63266122e-01f, 1.45024627e-01f,
  1.31089970e-01f, -6.18865378e-02f, 9.78930518e-02f, 2.10696887e-02f, -1.97371421e-03f, -4.48797531e-02f, -6.45258948e-02f, 1.11943446e-01f, 6.14886358e-03f, -9.84648988e-02f,
  2.48411715e-01f, -2.78939009e-02f, 4.34653601e-03f, -7.89188668e-02f, 9.76430103e-02f, 1.80657178e-01f, 1.28706351e-01f, -7.67359585e-02f, 1.40166387e-01f, 1.24840796e-01f,
  2.57647652e-02f, 2.87542082e-02f, 2.52350867e-02f, -2.69072615e-02f, -1.85426082e-02f, 4.33872417e-02f, 8.57396051e-02f, 2.73412496e-01f, -2.71051889e-03f, 1.01807639e-02f,
  1.88417509e-01f, -1.93809524e-01f, -4.73850816e-02f, -6.15957007e-02f, 1.54214218e-01f, 1.00054011e-01f, 1.29410207e-01f, 9.72074196e-02f, -1.95483774e-01f, -1.18706159e-01f,
  3.73878777e-02f, -2.51242369e-01f, 1.10611595e-01f, 1.06487073e-01f, 7.86771998e-02f, -4.71315868e-02f, 6.69538528e-02f, 1.38947427e-01f, 1.10231511e-01f, 1.34403124e-01f,
  -1.92416962e-02f, 2.40567327e-01f, 8.60084146e-02f, -2.02019006e-01f, 1.98131233e-01f, -6.70456737e-02f, -1.21444510e-02f, 3.56877260e-02f, 5.76558560e-02f, -9.39513668e-02f,
  -6.95568249e-02f, 3.27064730e-02f, -3.75467874e-02f, -2.56460994e-01f, 3.92184444e-02f, 1.87369317e-01f, 3.80662978e-02f, -1.30669713e-01f, -1.24001447e-02f, -1.45026892e-01f,
  -1.74260791e-02f, -2.33611465e-03f, -8.82560760e-03f, 9.85224694e-02f, 8.90231598e-03f, -9.20199081e-02f, 5.35070747e-02f, -1.68195695e-01f, 9.33969170e-02f, 3.15989181e-02f,
  6.13654070e-02f, 2.71821655e-02f, -1.93952583e-02f, 2.77265906e-03f, -1.40124783e-01f, 3.54459621e-02f, -8.27425942e-02f, 8.62893462e-02f, 5.74124455e-02f, -1.19594842e-01f,
  7.68358558e-02f, 1.01229258e-01f, -3.59269716e-02f, -1.47715677e-02f, 8.84787962e-02f, -1.10842735e-02f, -1.94660231e-01f, 2.58944668e-02f, 1.62311524e-01f, 1.93865582e-01f,
  7.75482208e-02f, 4.08118963e-03f, -1.39802769e-01f, -1.35714769e-01f, 4.93658409e-02f, -3.11906822e-02f, -9.47958454e-02f, -1.50552675e-01f, 2.61107869e-02f, -1.25134001e-02f,
  1.56930059e-01f, 4.50783372e-02f, -8.81345868e-02f, 6.54133931e-02f, -1.11283392e-01f, 7.57777691e-02f, -2.44834319e-01f, -1.10650165e-02f, 2.10148469e-01f, 5.59754893e-02f,
  9.07973424e-02f, -6.70168698e-02f, 7.92772919e-02f, -3.58180739e-02f, -8.36099982e-02f, -4.16160794e-03f, -1.10827543e-01f, -1.30540460e-01f, 3.11261714e-02f, 6.68082982e-02f,
  -2.78045405e-02f, -2.86955014e-02f, 1.86307997e-01f, -6.70549721e-02f, 1.58130795e-01f, -1.39746979e-01f, -3.98330055e-02f, -3.13058719e-02f, 1.29911989e-01f, 1.90063030e-01f,
  -1.11827485e-01f, -3.38892564e-02f, 1.06097586e-01f, 2.72927076e-01f, 8.54393020e-02f, 1.65912211e-01f, 1.51694790e-01f, 8.84020478e-02f, 1.51237464e-02f, -9.65868868e-03f,
  -4.98840287e-02f, -1.21537879e-01f, -6.68954700e-02f, -9.38557386e-02f, 3.52603346e-02f, 4.38446440e-02f, 1.65269390e-01f, -1.04508355e-01f, 2.42466152e-01f, -1.37980491e-01f,
  7.79873654e-02f, -1.30286843e-01f, 2.12690216e-02f, -1.05486261e-02f, -3.77452783e-02f, -1.77280754e-02f, -2.22743358e-02f, -4.34370637e-02f, -3.58400531e-02f, -1.87571961e-02f,
  3.90767194e-02f, 2.00114980e-01f, 1.89742342e-01f, -6.78296164e-02f, -9.61959884e-02f, -2.56043188e-02f, 9.62087810e-02f, 2.16803968e-01f, -3.15597728e-02f, 1.19705096e-01f,
  2.21600249e-01f, 8.51059426e-03f, 4.94861715e-02f, -4.81326357e-02f, -1.50124714e-01f, -7.66817257e-02f, 1.52239753e-02f, -8.66393670e-02f, 1.19789809e-01f, -1.15531877e-01f,
  8.35586190e-02f, 3.43336947e-02f, 1.58549234e-01f, -1.30115519e-03f, 1.71860263e-01f, -1.48757845e-01f, 9.44916531e-02f, -1.43919379e-01f, -6.26871958e-02f, -6.54350920e-03f,
  4.38234769e-02f, 1.84467494e-01f, 3.60178314e-02f, 2.46186722e-02f, 1.44776076e-01f, -4.35007922e-03f, 1.57585517e-01f, 1.23728596e-01f, 2.65448362e-01f, -3.31295724e-03f,
  3.68013456e-02f, -2.83550862e-02f, -3.16420048e-02f, 2.64404386e-01f, -9.37698483e-02f, -4.79478277e-02f, -1.29272863e-01f, -8.15805327e-03f, 2.17474222e-01f, 4.15353030e-02f,
  4.87749390e-02f, -1.03526600e-01f, -1.51465908e-01f, 3.68195474e-02f, -3.00894119e-02f, 1.07866034e-01f, -5.98565768e-03f, -2.61173546e-02f, 1.61910176e-01f, 2.40079463e-01f,
  -6.18107207e-02f, -1.03077322e-01f, 2.04282790e-01f, -9.10086557e-02f, 6.73627108e-02f, 8.36312100e-02f, 1.72525540e-01f, 1.98937356e-01f, 1.17090009e-01f, 1.17349021e-01f,
  2.23893836e-01f, 1.50675923e-01f, -6.32449538e-02f, 1.19589090e-01f, -9.63469297e-02f, -6.81548491e-02f, 1.33023551e-02f, -1.24257810e-01f, -1.42941326e-01f, -1.72044188e-02f,
  1.57412142e-01f, -2.16594949e-01f, -1.46682665e-01f, -1.24035608e-02f, -1.70101032e-01f, -7.79334968e-03f, 5.26186600e-02f, 9.63996574e-02f, -9.43540409e-02f, 1.06484279e-01f,
  -1.97160393e-02f, -1.62186362e-02f, 1.81665525e-01f, -3.26759042e-03f, 2.20207110e-01f, -8.56133327e-02f, -2.32331619e-01f, -1.83060646e-01f, 7.93304443e-02f, 1.46574974e-01f,
  1.49365189e-02f, -1.80665054e-03f, 7.06428080e-04f, 2.96428055e-02f, -4.97299209e-02f, -7.37611484e-03f, 9.32120457e-02f, -1.67433009e-01f, 1.74711078e-01f, -1.19470581e-01f,
  -4.35367711e-02f, 1.05280884e-01f, 9.27292854e-02f, -1.48440391e-01f, 1.91386491e-02f, -5.13840951e-02f, 1.09203652e-01f, -1.00774437e-01f, 1.42286032e-01f, 4.69961297e-03f,
  1.11861546e-02f, 1.87708318e-01f, -7.25036254e-03f, -6.27116486e-02f, 2.05065161e-01f, -1.32227689e-01f, -1.28160268e-01f, 5.77388555e-02f, 1.96478203e-01f, -1.27614945e-01f,
  -6.84332177e-02f, -1.41880363e-01f, 5.05900867e-02f, -1.51064619e-01f, 1.10762954e-01f, 2.70655304e-02f, -6.92002848e-02f, 1.88357800e-01f, 1.55495033e-01f, 1.60338789e-01f,
  6.69741333e-02f, 9.35703665e-02f, -2.94381939e-02f, 1.96181759e-01f, 1.45909071e-01f, 4.58703153e-02f, 9.15891007e-02f, -7.59903749e-04f, 1.43477932e-01f, 2.04481319e-01f,
  2.50397213e-02f, -2.29836069e-02f, -6.00241125e-02f, 1.48241654e-01f, 1.83798254e-01f, -2.42815427e-02f, -3.09123844e-02f, 2.11881503e-01f, -4.13888274e-03f, 1.29685566e-01f,
  2.28806287e-01f, 5.17480820e-02f, 2.90511064e-02f, -3.36128101e-02f, -1.77852847e-02f, -3.65769491e-03f, 1.47429714e-02f, 1.72584400e-01f, 2.67914739e-02f, 9.46335942e-02f,
  4.28255908e-02f, -1.12601720e-01f, 1.88189764e-02f, 3.58091593e-02f, 6.93365559e-02f, 3.50615978e-02f, -1.19950352e-02f, -1.10622257e-01f, 8.98289084e-02f, -5.16926404e-03f,
  5.01142442e-02f, -5.21081537e-02f, 1.38743177e-01f, -1.95662547e-02f, 9.04001966e-02f, 1.59304608e-02f, 2.86720395e-02f, -4.67955731e-02f, 1.26945242e-01f, 1.81259170e-01f,
  -5.41308559e-02f, 4.70896885e-02f, 8.64645839e-02f, -1.49167284e-01f, -1.79809723e-02f, -4.79959100e-02f, 1.23237520e-02f, -1.28293246e-01f, -1.69389367e-01f, -4.79674600e-02f,
  2.67066032e-01f, -6.84413984e-02f, -2.55090948e-02f, 1.31758094e-01f, 4.72033732e-02f, 5.34062237e-02f, 1.75750926e-01f, 9.46044177e-02f, -2.03707442e-01f, 2.30070174e-01f,
  -6.11154027e-02f, 8.02551880e-02f, 1.51551530e-01f, -3.80829312e-02f, -1.34619281e-01f, -2.65516173e-02f, 1.38488591e-01f, -5.53873554e-02f, -5.78206033e-02f, 1.42491804e-02f,
  -3.37255783e-02f, 2.58234739e-01f, -1.12732969e-01f, -1.56881526e-01f, -1.69012129e-01f, 1.45362109e-01f, -9.46823284e-02f, -6.89569488e-02f, 1.29667446e-01f, 1.44221812e-01f,
  1.68969810e-01f, 1.46611437e-01f, 2.26432577e-01f, 2.38803193e-01f, 1.18516952e-01f, -1.86177611e-01f, -1.52368858e-01f, 2.16015205e-01f, -4.91228811e-02f, -1.65839478e-01f,
  2.35206243e-02f, 1.60651840e-02f, 1.52673006e-01f, -8.31454098e-02f, 1.68434739e-01f, -1.33974254e-01f, 7.34244362e-02f, -3.61157991e-02f, -1.42287061e-01f, 3.85842137e-02f,
  -1.03271037e-01f, -1.08157530e-01f, -1.13155223e-01f, 2.11934522e-01f, 5.05947918e-02f, 6.44114688e-02f, 1.71729013e-01f, 2.22762853e-01f, 1.67442158e-01f, 2.25279736e-03f,
  -9.18263048e-02f, -1.43500909e-01f, -3.41573730e-02f, 9.79270265e-02f, 1.67758867e-01f, 9.61456224e-02f, 2.26769194e-01f, 2.25882921e-02f, -8.22233632e-02f, 3.82333286e-02f,
  5.33608161e-02f, -1.79402798e-01f, -9.39808190e-02f, 1.84124019e-02f, 1.42277375e-01f, -4.14294973e-02f, 2.73648612e-02f, 4.35515009e-02f, -1.07275017e-01f, 2.38628447e-04f,
  2.98933417e-01f, -4.66121882e-02f, -6.08488433e-02f, -1.35760039e-01f, -9.01005641e-02f, 4.08678222e-03f, -1.66667655e-01f, 1.01504661e-01f, -6.75681457e-02f, -7.13819787e-02f,
  8.30676630e-02f, -1.06358305e-01f, -5.22189483e-04f, 8.46615247e-03f, -1.31321877e-01f, 9.89560857e-02f, -2.29804348e-02f, -2.92897895e-02f, 8.48388821e-02f, -1.38443813e-01f,
  1.29304305e-01f, -1.57399222e-01f, 8.10569450e-02f, 6.74848109e-02f, -1.76557973e-01f, -1.48291677e-01f, -7.86737725e-03f, 1.29664123e-01f, -1.12055972e-01f, 5.81454672e-02f,
  2.21393064e-01f, -9.70483124e-02f, 9.79617462e-02f, -2.88493205e-02f, -5.30249067e-02f, -1.45917863e-01f, 1.67573839e-01f, 8.31232872e-03f, -1.86741129e-01f, 1.06049575e-01f,
  -2.17875540e-02f, -9.54332501e-02f, -6.28731102e-02f, -8.59766304e-02f, -2.79674120e-02f, -8.72306153e-02f, -3.18760723e-02f, -1.37323409e-01f, 1.74133807e-01f, -2.28132933e-01f,
  -9.23997834e-02f, 1.41425148e-01f, 7.10551254e-03f, 3.86913195e-02f, 2.14028239e-01f, 2.83193737e-01f, -1.07272349e-01f, 2.66445428e-01f, 1.72475222e-02f, 8.30766484e-02f,
  1.87941208e-01f, 5.67502081e-02f, 7.35930540e-03f, -1.25492021e-01f, 4.37945835e-02f, -4.70258817e-02f, -3.11759356e-02f, 6.40141517e-02f, -1.09310463e-01f, 1.97670922e-01f,
  -9.80949253e-02f, -7.85604790e-02f, 2.43331835e-01f, 1.69042900e-01f, -1.11785010e-01f, -1.98385287e-02f, 1.27864435e-01f, 3.31458077e-02f, 1.82513222e-01f, 1.22627541e-01f,
  6.93273842e-02f, 1.77260302e-03f, 8.24407339e-02f, -9.64386091e-02f, 1.82115704e-01f, -2.91342020e-01f, -3.61691266e-02f, 2.25372851e-01f, -6.19515739e-02f, -1.31344721e-01f,
  3.41691040e-02f, -2.39995085e-02f, -6.52589053e-02f, 7.67661110e-02f, 1.29859164e-01f, -1.69608265e-01f, -8.73518214e-02f, -1.17526270e-01f, -3.89704593e-02f, -5.30850962e-02f,
  2.46396642e-02f, -2.43656844e-01f, -4.41681920e-03f, 6.36472106e-02f, 2.84893662e-01f, 7.36529846e-03f, -4.65270057e-02f, 4.53769006e-02f, 1.62749942e-02f, 3.54654305e-02f,
  2.82402694e-01f, -6.86196461e-02f, -1.03535175e-01f, 2.94488490e-01f, 1.88268930e-01f, 4.82700318e-02f, -1.13043956e-01f, 1.74126625e-01f, 4.60948981e-03f, 2.11731389e-01f,
  2.06247732e-01f, -1.00997411e-01f, -8.51403847e-02f, 5.86158410e-03f, -2.62948871e-03f, -2.13609301e-02f, 2.29484066e-01f, -2.08271652e-01f, -1.83470488e-01f, 6.88323081e-02f,
  -1.26268461e-01f, 3.17328535e-02f, -1.03541892e-02f, 1.80362284e-01f, 1.68704674e-01f, 8.37930515e-02f, 2.49262564e-02f, -1.35683129e-02f, 2.43463770e-01f, 1.25627831e-01f,
  4.26892973e-02f, 5.98666780e-02f, 1.08903594e-01f, 1.52574226e-01f, 1.69750396e-02f, 1.04094103e-01f, -1.71435863e-01f, 2.19817627e-02f, -2.27675866e-03f, -1.08427964e-01f,
  2.37789646e-01f, 2.06479337e-02f, -1.30102597e-02f, -4.61183786e-02f, 1.26353472e-01f, -2.12342948e-01f, 1.15127832e-01f, 2.27789581e-01f, -1.61835566e-01f, -9.66743976e-02f,
  -4.99378331e-02f, 8.68747942e-03f, -3.72770987e-02f, -1.61615107e-02f, -1.73993245e-01f, -1.21029563e-01f, -3.33233625e-02f, 1.78539291e-01f, -1.84819140e-02f, 3.25894579e-02f,
  1.22098878e-01f, 1.15478709e-01f, 1.04163826e-01f, -1.38500005e-01f, 5.28046675e-02f, 1.01317223e-02f, -1.06823668e-02f, 2.93362796e-01f, 1.10195495e-01f, -1.52550992e-02f,
  -2.36315988e-02f, 1.76566511e-01f, 1.40282571e-01f, -8.92221928e-02f, 1.86504304e-01f, -1.55308560e-01f, -3.72683167e-01f, -1.33220971e-01f, -1.64681688e-01f, -7.69324601e-02f,
  5.15404902e-03f, -9.89212468e-02f, -1.87076807e-01f, -2.14579087e-02f, 1.00182615e-01f, 2.13277906e-01f, 2.09590048e-02f, 3.92029900e-03f, 1.76185399e-01f, 1.88646346e-01f,
  1.47953741e-02f, 2.19487786e-01f, 8.96647274e-02f, 2.84610122e-01f, 8.90158042e-02f, 1.57591905e-02f, 1.07491985e-01f, 8.76743421e-02f, 8.47857296e-02f, 6.94205761e-02f,
  -7.25513250e-02f, -1.24833889e-01f, -5.51139237e-03f, 8.93898904e-02f, 1.54312924e-01f, 2.31626574e-02f, 5.97853065e-02f, 1.52483687e-01f, -6.48313165e-02f, 1.86469425e-02f,
  -1.32697001e-01f, 1.26497805e-01f, -6.05939478e-02f, -1.82387903e-01f, -1.03302874e-01f, 1.44555755e-02f, -3.81218418e-02f, -6.26508668e-02f, -1.48769855e-01f, -3.57428268e-02f,
  -4.58980054e-02f, 1.20125070e-01f, -7.38233775e-02f, 2.59137005e-01f, 1.53897390e-01f, 1.00918680e-01f, 9.29553285e-02f, 1.66522653e-03f, -7.09907785e-02f, 3.99945267e-02f,
  5.95617257e-02f, 3.37057672e-02f, 8.46160501e-02f, -7.73264542e-02f, -1.12520568e-01f, 1.03767529e-01f, 1.66055709e-01f, -4.40183207e-02f, 2.45145033e-03f, -9.20473486e-02f,
  -1.94432363e-01f, -1.96225792e-02f, -4.60567325e-02f, -9.25861821e-02f, 2.61479411e-02f, -1.00533320e-02f, 1.47059895e-02f, -6.34309649e-02f, -7.46563822e-02f, 5.31274043e-02f,
  -9.52978134e-02f, -1.05439022e-01f, 9.27339643e-02f, 1.53741226e-01f, 2.69126575e-02f, 7.56220967e-02f, 4.36782185e-03f, 1.41833097e-01f, -9.66983810e-02f, 2.08454534e-01f,
  -9.32446495e-02f, 1.79713685e-02f, 1.28128886e-01f, 1.21859431e-01f, -4.08624373e-02f, -1.98948473e-01f, 1.04629070e-01f, -4.43918332e-02f, -9.16937888e-02f, 7.28201345e-02f,
  -1.89465150e-01f, 1.18517555e-01f, -4.39616619e-03f, 2.18464553e-01f, -4.79807220e-02f, -1.10600151e-01f, 1.35634586e-01f, 2.60762423e-02f, 3.62459794e-02f, 5.60375974e-02f,
  -1.36607802e-02f, -1.52482763e-01f, 1.80870622e-01f, 1.48801267e-01f, -1.53603896e-01f, -1.98490564e-02f, -1.54250115e-01f, -5.75181879e-02f, -1.25074103e-01f, -9.81364101e-02f,
  4.48882654e-02f, 1.03204198e-01f, -1.03597604e-01f, -5.87374531e-02f, -2.86443364e-02f, -2.31068745e-01f, 6.12289608e-02f, 2.79754966e-01f, -5.09536825e-02f, 5.95756583e-02f,
  1.09919004e-01f, 3.75671014e-02f, -9.18837711e-02f, 1.07210398e-01f, 4.52382475e-01f, -5.00853285e-02f, 1.00339569e-01f, 2.22217277e-01f, 4.67234217e-02f, -4.05483469e-02f,
  2.16721684e-01f, 3.75947058e-02f, 1.16369808e-02f, 7.97981247e-02f, -1.47177860e-01f, 7.51055926e-02f, -1.45678356e-01f, 3.38167734e-02f, 2.57018059e-01f, 1.84103381e-02f,
  -1.26906797e-01f, -7.95132518e-02f, 3.96402739e-02f, 4.99617457e-02f, 6.20129444e-02f, -2.42997676e-01f, 6.40319213e-02f, 7.51900971e-02f, 6.15203660e-03f, -5.96689098e-02f,
  -6.22267723e-02f, 2.00530723e-01f, 3.85471880e-02f, -1.35453209e-01f, -4.48019169e-02f, 2.59309232e-01f, -5.60872369e-02f, 1.83001742e-01f, -1.10581659e-01f, 1.63664334e-02f,
  2.84752008e-02f, 1.10050306e-01f, 1.41096756e-01f, -4.78955870e-03f, 1.26217291e-01f, 1.04208231e-01f, -1.03325471e-01f, 3.36062238e-02f, 1.05816409e-01f, -2.21176376e-03f,
  -1.45177953e-02f, 1.67198796e-02f, -1.72156822e-02f, 9.15836617e-02f, 1.10538922e-01f, 8.57682377e-02f, -1.08992532e-01f, 2.63372660e-01f, 1.42911464e-01f, -9.93694514e-02f,
  -9.75918248e-02f, 1.10055812e-01f, -8.17026943e-02f, 1.43048167e-02f, 1.63153648e-01f, -8.81945565e-02f, -2.44803857e-02f, 6.06319457e-02f, 1.85610846e-01f, 1.44406512e-01f,
  2.67562624e-02f, -1.83411479e-01f, -2.37359971e-01f, 1.41595468e-01f, 2.02676132e-01f, 5.45572452e-02f, 1.52299190e-02f, 2.93581560e-02f, -1.02239465e-02f, -5.78679293e-02f,
  -7.39420950e-02f, 7.68540651e-02f, 6.26624003e-02f, 5.89648820e-02f, -9.47615132e-02f, -8.73935744e-02f, 1.05475150e-01f, -5.66209555e-02f, 9.58617926e-02f, -5.29862605e-02f,
  1.22216009e-01f, -3.65698710e-03f, -1.07919209e-01f, 2.69940495e-01f, -5.20609878e-02f, 1.91981450e-01f, -4.46449453e-03f, -9.60239954e-03f, 1.79138314e-02f, 1.30038619e-01f,
  8.32286701e-02f, 9.08214673e-02f, -2.17994779e-01f, 1.20861031e-01f, -6.70392066e-03f, 3.00572179e-02f, 7.70409480e-02f, -7.60465786e-02f, 6.26029894e-02f, 1.24431282e-01f,
  -8.23716819e-03f, -3.41725871e-02f, 1.85027495e-01f, 4.33279090e-02f, -1.01784319e-01f, 1.46777660e-01f, 8.22867975e-02f, 1.85288787e-01f, 1.91977337e-01f, 2.22559854e-01f,
  -8.28377828e-02f, 1.44402822e-02f, -6.28378615e-02f, -1.32766083e-01f, -1.84519008e-01f, 5.68166301e-02f, -3.03164069e-02f, -8.15548748e-02f, 1.82014033e-02f, -8.50074589e-02f,
  5.48103452e-02f, -7.18771741e-02f, 1.63872793e-01f, 1.07760578e-01f, -1.68468773e-01f, -3.15576941e-02f, -1.76305428e-01f, 1.98390514e-01f, -9.75084316e-04f, 1.79193452e-01f,
  -1.99225187e-01f, 1.24922395e-01f, 2.41024807e-01f, -1.89472958e-01f, 1.13529488e-02f, 7.28035392e-03f, -6.06609359e-02f, -8.66940320e-02f, 5.91233075e-02f, 1.94395930e-01f,
  8.90533477e-02f, 5.51472493e-02f, 6.50889333e-03f, 1.88367575e-01f, 7.22739333e-03f, 8.37805420e-02f, -6.36164919e-02f, -1.42512016e-03f, -7.68248364e-02f, 4.34355205e-03f,
  -6.42198399e-02f, -5.81577569e-02f, 9.49724317e-02f, -2.72224844e-01f, 2.16020808e-01f, -3.19462642e-02f, 3.69649157e-02f, 1.69885606e-01f, 1.48522496e-01f, 1.99731529e-01f,
  7.42548630e-02f, 1.11602485e-01f, -2.10016295e-02f, 2.20386945e-02f, 1.31664544e-01f, 1.05245344e-01f, 2.04220146e-01f, 2.20576853e-01f, 1.45247713e-01f, -7.33432397e-02f,
  2.68694293e-02f, 8.41694102e-02f, -4.04711179e-02f, -2.10572511e-01f, -8.76812488e-02f, -2.68690497e-01f, 6.58835843e-02f, 1.37566805e-01f, 5.50050363e-02f, 1.97012857e-01f,
  -1.07389815e-01f, 1.51663750e-01f, -1.95879582e-03f, -4.83152196e-02f, -5.22906557e-02f, 1.65545821e-01f, 1.49547666e-01f, -1.19012639e-01f, 8.08995366e-02f, 3.26836199e-01f,
  6.14855960e-02f, -1.49982795e-01f, 5.54170683e-02f, 2.95157492e-01f, 1.22933432e-01f, 2.83041686e-01f, 3.12673338e-02f, 1.71634853e-01f, -5.67973331e-02f, 1.17136315e-01f,
  7.61862695e-02f, 8.06644931e-02f, 9.26769674e-02f, 1.07882045e-01f, 2.37597767e-02f, -7.27167130e-02f, -7.38601908e-02f, 1.83764026e-01f, 7.28977984e-03f, 1.37378842e-01f,
  -3.64109799e-02f, 2.89207809e-02f, 5.98350167e-02f, -8.29855353e-02f, 1.97115332e-01f, 2.69499086e-02f, 1.57339334e-01f, -4.75388095e-02f, -1.05876207e-01f, -6.99325129e-02f,
  8.71753767e-02f, 7.69831911e-02f, 3.67543027e-02f, 1.93913162e-01f, 2.23436773e-01f, 1.90777168e-01f, 9.03232694e-02f, 1.63268849e-01f, 1.34488687e-01f, 6.85096830e-02f,
  1.76897403e-02f, 1.68682680e-01f, -8.70956257e-02f, -1.47268340e-01f, -2.22637933e-02f, -5.85935041e-02f, 3.90542224e-02f, -1.29096091e-01f, -1.27689555e-01f, 2.14554816e-02f,
  2.29629576e-01f, 2.75440812e-02f, -2.00677007e-01f, 1.51086198e-02f, 1.37788147e-01f, -2.93668192e-02f, 2.67445952e-01f, 1.13824032e-01f, 6.73392043e-02f, 1.79584131e-01f,
  -2.46496022e-01f, -1.04541797e-02f, 1.85159966e-03f, -1.29452571e-01f, -6.36987463e-02f, 7.41091520e-02f, -4.05686386e-02f, 4.09076512e-02f, 1.91468909e-01f, 1.14770345e-01f,
  1.18252710e-01f, 1.11567944e-01f, 1.30872622e-01f, -5.46658896e-02f, -5.03518358e-02f, 9.66504216e-02f, -8.54284465e-02f, 6.06725141e-02f, 8.55881348e-02f, 1.72612250e-01f,
  1.35166720e-01f, 4.74294499e-02f, 5.39072789e-02f, 1.72148868e-01f, 4.78797592e-02f, -1.93687260e-01f, 1.21348977e-01f, 9.52876136e-02f, -2.43084803e-02f, 4.10162881e-02f,
  -1.60616949e-01f, 9.33920443e-02f, 1.25950888e-01f, 1.54870167e-01f, -1.29736796e-01f, 1.10913470e-01f, -7.12906150e-03f, -1.79494083e-01f, 1.16083631e-02f, 1.05901631e-02f,
  -1.23286843e-02f, -1.65811092e-01f, -7.41443709e-02f, -2.22088881e-02f, -1.52388588e-01f, 1.60362482e-01f, 7.98287839e-02f, -7.07312375e-02f, -1.86380178e-01f, -1.77773945e-02f,
  6.31263200e-03f, 9.90881249e-02f, -9.90282297e-02f, 3.58130448e-02f, 9.22767892e-02f, 1.38091505e-01f, 1.90708637e-01f, 1.55331179e-01f, -2.18432203e-01f, 1.88649267e-01f,
  6.16427623e-02f, -1.91831421e-02f, 4.19018716e-02f, 8.91987756e-02f, 1.59274891e-01f, -7.22607300e-02f, -4.03430499e-02f, 3.74149047e-02f, 6.15417250e-02f, -1.10065863e-01f,
  1.26030877e-01f, 6.91926153e-03f, -9.71403811e-03f, 1.13310322e-01f, -2.12355152e-01f, 1.09366462e-01f, -9.93271694e-02f, 1.58639804e-01f, 3.48684132e-01f, 1.46678805e-01f,
  1.73779935e-01f, 1.58424750e-01f, -2.84424983e-02f, 1.86031401e-01f, -6.14149161e-02f, 2.52488181e-02f, 1.08434990e-01f, 1.82621062e-01f, -6.00891486e-02f, -2.60882795e-01f,
  6.05193786e-02f, 1.41720906e-01f, 2.38349140e-02f, -1.93945449e-02f, -2.28499636e-01f, -1.77827813e-02f, 1.53307468e-01f, 2.18284965e-01f, -1.68699101e-01f, -3.07944696e-03f,
  1.87925041e-01f, -5.38446754e-02f, 7.17060789e-02f, 7.93765411e-02f, -4.83485823e-03f, -1.64130092e-01f, 1.85322985e-01f, 1.46368429e-01f, -9.05454382e-02f, 2.07914591e-01f,
  -5.50288185e-02f, -2.34880999e-01f, -1.71534911e-01f, -1.07286751e-01f, 1.73428342e-01f, -2.01952551e-02f, -1.42859876e-01f, -6.49599060e-02f, 4.14061040e-04f, -1.50324911e-01f,
  -1.08832777e-01f, 2.38108367e-01f, -5.11642359e-02f, 2.46135518e-01f, 2.03880414e-01f, 1.15250021e-01f, -1.34796962e-01f, 3.07574332e-01f, 3.10161591e-01f, -4.25236560e-02f,
  5.68513349e-02f, 1.41788140e-01f, 7.12324083e-02f, -9.82764289e-02f, 8.06942433e-02f, 1.91857353e-01f, -1.81820393e-02f, 1.10368267e-01f, -2.04007164e-01f, 1.26219481e-01f,
  -2.77366668e-01f, 9.60234031e-02f, 1.85870379e-01f, 2.65948743e-01f, -2.50516031e-02f, -1.92836642e-01f, 2.52113074e-01f, 6.74546584e-02f, 2.77111381e-01f, 9.75739807e-02f,
  1.67935446e-01f, 1.26324752e-02f, -6.64122626e-02f, 1.56638697e-01f, -7.04929307e-02f, -2.36458763e-01f, -3.40659730e-02f, 1.37228027e-01f, 9.97291878e-02f, -6.48867413e-02f,
  2.00507361e-02f, -1.28250271e-01f, 6.02279007e-02f, 6.04878366e-02f, -5.29328696e-02f, 7.88202286e-02f, -4.19382378e-03f, -6.04350679e-02f, 1.25503987e-01f, 1.23099849e-01f,
  -7.09472746e-02f, -2.16449216e-01f, -4.90565784e-03f, -8.27825144e-02f, 1.94087744e-01f, -1.80801600e-02f, 1.67903095e-01f, 8.61085299e-03f, 9.40497406e-03f, 1.93797261e-01f,
  2.52501458e-01f, 1.68404859e-02f, -1.84908375e-01f, 2.57413447e-01f, 6.47835508e-02f, -1.78769574e-01f, 1.96293816e-01f, -6.48524729e-04f, -4.57620434e-02f, -4.57066223e-02f,
  9.15752277e-02f, -1.78931192e-01f, -2.10650921e-01f, 9.32576209e-02f, -1.81242123e-01f, -1.31734610e-01f, 1.44329548e-01f, 7.58524612e-02f, -1.49892583e-01f, 1.63885560e-02f,
  6.72512036e-03f, -3.56350653e-02f, 2.35497937e-01f, 2.11556889e-02f, 1.65329605e-01f, 3.71535011e-02f, -1.22765005e-01f, -7.85146058e-02f, 4.87975553e-02f, -4.26224843e-02f,
  4.91890647e-02f, 1.24950878e-01f, -5.47364801e-02f, 8.21029395e-03f, 1.65851176e-01f, 9.96627137e-02f, -5.19641601e-02f, -1.63919091e-01f, 8.92762765e-02f, 6.02591336e-02f,
  -8.82124342e-03f, 6.22758754e-02f, -1.89437136e-01f, 1.38414100e-01f, 7.09971227e-03f, 1.06779292e-01f, -7.29067996e-02f, 8.89555290e-02f, 8.02521631e-02f, -2.08263248e-02f,
  9.51661617e-02f, -1.16388939e-01f, -3.92914340e-02f, -1.85585737e-01f, 2.35668924e-02f, -2.94086989e-02f, -7.39617124e-02f, 7.46074468e-02f, -1.66651458e-01f, -4.46920991e-02f,
  -2.42240459e-01f, -9.00771841e-02f, 1.17303923e-01f, 1.50081113e-01f, 2.50677932e-02f, 1.77658089e-02f, -7.29006762e-03f, -2.51454532e-01f, -2.57099979e-02f, 1.71371132e-01f,
  -8.95954520e-02f, 2.01175377e-01f, 1.90962210e-01f, 2.39345022e-02f, -9.65285487e-03f, 1.69774428e-01f, 3.36195379e-01f, 3.27046253e-02f, -8.81574079e-02f, -2.75978073e-02f,
  1.47605807e-01f, -1.03262417e-01f, 1.91109389e-01f, 1.26938932e-02f, -6.94839656e-02f, 1.07265236e-02f, -1.96359068e-01f, 6.43863983e-04f, -9.24277604e-02f, 1.14033744e-01f,
  2.31412917e-01f, 1.03372112e-01f, -2.25151554e-02f, -4.79967929e-02f, -2.29555294e-02f, 2.22973004e-01f, 1.97820455e-01f, 2.30173826e-01f, 8.90148059e-02f, -2.87730731e-02f,
  1.60607308e-01f, -1.36812657e-01f, 6.00985670e-03f, -6.17550761e-02f, -1.45277306e-01f, 1.11989370e-02f, 5.04528508e-02f, 5.99706592e-03f, 2.16961339e-01f, 2.55912039e-02f,
  2.52373993e-01f, -3.83690409e-02f, 6.73016012e-02f, -5.40595464e-02f, -1.58701614e-01f, 8.28731805e-02f, 4.79672961e-02f, -7.80745819e-02f, 1.83579233e-03f, -4.88644093e-02f,
  -7.30421394e-02f, 2.22016480e-02f, 2.42659822e-01f, 6.20371215e-02f, 5.34507073e-02f, -8.35980847e-02f, -1.64007246e-01f, -5.82568012e-02f, 1.50421903e-01f, 1.21996403e-01f,
  -1.27271891e-01f, 2.51402885e-01f, 3.13749969e-01f, 4.15496603e-02f, -8.44877511e-02f, 1.36060417e-01f, -1.66819111e-01f, 7.55570233e-02f, 1.27617061e-01f, -3.42248566e-02f,
  1.37584552e-01f, -1.32332668e-01f, 1.19874306e-01f, 1.91448003e-01f, 2.23668620e-01f, -1.08080782e-01f, 3.99895720e-02f, -6.32332172e-03f, 7.58566707e-02f, -1.61605347e-02f,
  -1.32811725e-01f, 1.63098246e-01f, 5.49851581e-02f, 1.48605242e-01f, 1.77301064e-01f, -1.01938464e-01f, 7.47763738e-02f, -2.72013657e-02f, -8.10053200e-03f, -1.58456683e-01f,
  5.28797358e-02f, -2.12951470e-02f, -6.93866834e-02f, 1.01288401e-01f, -8.31139311e-02f, 1.13253556e-01f, -1.26657203e-01f, 1.36924997e-01f, 4.34798859e-02f, -9.14163440e-02f,
  6.77656606e-02f, 1.87056705e-01f, -1.19252115e-01f, -2.67942436e-03f, -1.74305618e-01f, 1.94950432e-01f, -1.80225447e-01f, 9.26284865e-02f, -5.74073382e-02f, 1.50815859e-01f,
  9.19863731e-02f, 1.82564668e-02f, -1.79163158e-01f, -6.97108209e-02f, 1.46108896e-01f, 1.79709256e-01f, -5.03657274e-02f, 1.10439742e-02f, -1.43286631e-01f, 1.38354093e-01f,
  2.35549539e-01f, 1.48042440e-01f, -8.01029950e-02f, -4.06882428e-02f, 3.58790532e-02f, -1.46617800e-01f, -2.90999234e-01f, 1.04922960e-02f, -6.48674294e-02f, 1.02146521e-01f,
  2.09331423e-01f, 2.49983724e-02f, -1.89704518e-03f, -8.86781793e-03f, 2.88413297e-02f, -1.20483831e-01f, -2.12803915e-01f, -7.49633601e-03f, -1.98778376e-01f, -3.23752686e-02f,
  7.72307515e-02f, 1.51566729e-01f, -1.74349211e-02f, 1.84880495e-01f, 1.65856063e-01f, -1.75584942e-01f, -8.73246342e-02f, 2.15097498e-02f, 4.08633873e-02f, 1.39814332e-01f,
  -3.00977565e-02f, -5.93570410e-04f, 1.18826851e-01f, 4.19360586e-03f, -5.36339916e-02f, -1.76793024e-01f, -3.84679176e-02f, 7.36972839e-02f, 3.83014940e-02f, -1.82422504e-01f,
  1.14776462e-01f, 2.48341873e-01f, -4.02438678e-02f, -1.21196829e-01f, -9.34004858e-02f, 2.62991101e-01f, 5.94126396e-02f, 1.49921075e-01f, 4.15204465e-02f, -1.60639897e-01f,
  -5.48162498e-02f, -7.95880333e-02f, 5.06651737e-02f, 9.00321007e-02f, -1.58831626e-02f, -9.40408111e-02f, -8.16966519e-02f, -3.30509357e-02f, 2.39356197e-02f, -2.40514018e-02f,
  -1.30912006e-01f, 1.54777393e-01f, -1.86893180e-01f, -7.27249170e-03f, 6.11559600e-02f, 2.30899304e-01f, -3.04226205e-03f, 1.97227582e-01f, -8.84567425e-02f, -1.83693007e-01f,
  9.57517922e-02f, -6.26318099e-04f, -5.83201349e-02f, -1.25720039e-01f, 2.66806483e-02f, -2.60443538e-02f, -7.92024583e-02f, -1.37550086e-01f, 2.11844385e-01f, -9.35449544e-03f,
  5.01825847e-02f, -1.07059769e-01f, -3.35488841e-02f, -3.78398895e-02f, 1.28624663e-01f, -2.77699344e-02f, 8.42138566e-03f, -4.43331152e-02f, -1.45430073e-01f, -1.27785698e-01f,
  -4.23101410e-02f, 2.70310879e-01f, 2.73551285e-01f, -9.01806504e-02f, -6.46606386e-02f, -1.83153134e-02f, 4.51165773e-02f, 1.78936288e-01f, 1.65730447e-01f, 6.32491633e-02f,
  1.58757195e-01f, 7.47479722e-02f, -4.19297488e-03f, -1.21614821e-01f, -1.18998690e-02f, 4.30653468e-02f, -2.60898704e-03f, -5.13473488e-02f, -8.71829106e-05f, -1.10125400e-01f,
  1.62977055e-01f, -3.03540640e-02f, -8.15379024e-02f, 1.99318275e-01f, 2.40612086e-02f, -1.18642356e-02f, 1.86162181e-02f, -1.43407509e-01f, 7.95537531e-02f, -9.08220485e-02f,
  7.17238337e-02f, 8.04300085e-02f, 5.45581207e-02f, 2.36440554e-01f, 8.81599039e-02f, 8.54476541e-02f, -8.76430348e-02f, 4.13481034e-02f, 2.50775982e-02f, -8.04308988e-03f,
  -5.09315804e-02f, -1.59782954e-02f, 1.45304296e-02f, 5.89235052e-02f, 4.62970883e-02f, 1.38031468e-01f, -2.07658648e-01f, 2.49365836e-01f, 1.14210896e-01f, -8.62939879e-02f,
  -5.48669733e-02f, 1.78658590e-02f, 1.37441918e-01f, -2.34258343e-02f, -9.62182954e-02f, 1.79769740e-01f, 8.78613517e-02f, -1.71975195e-01f, 1.25394925e-01f, 1.99226514e-02f,
  -6.85189739e-02f, 1.17543682e-01f, -1.81151718e-01f, 3.65750752e-02f, -6.67799488e-02f, 8.37771446e-02f, 4.38684821e-02f, 1.79939896e-01f, 9.07311663e-02f, 1.21562719e-01f,
  3.24701369e-02f, 1.12621754e-01f, -5.10288030e-02f, -4.63038608e-02f, 4.08558734e-02f, 1.28957152e-01f, -1.58544853e-01f, -1.14980057e-01f, -4.17733565e-02f, 1.38715297e-01f,
  1.29502974e-02f, -1.41655743e-01f, -1.65683523e-01f, 1.29022608e-02f, 5.45180775e-02f, 1.23629622e-01f, -1.37410164e-01f, 1.63838968e-01f, -3.81680839e-02f, -1.02410160e-01f,
  1.09101631e-01f, -1.53985262e-01f, 1.53854713e-01f, -1.60023823e-01f, 2.37398930e-02f, 3.05289328e-02f, -1.56904519e-01f, 1.60408318e-01f, -8.31676275e-02f, -2.49537942e-03f,
  -1.75418854e-01f, 1.12481546e-02f, 1.21981889e-01f, 1.33016944e-01f, -1.09308876e-01f, 3.35201584e-02f, 1.40016392e-01f, -1.90823078e-01f, -1.45333707e-01f, 2.03937188e-01f,
  -6.12732582e-02f, 2.42638960e-01f, 2.03725159e-01f, -3.34478170e-02f, -1.28828421e-01f, 1.86481357e-01f, 1.56860948e-01f, -6.79306407e-03f, -1.62576631e-01f, -3.36154848e-02f,
  7.15788975e-02f, -1.86194200e-02f, 1.24717943e-01f, 5.26552722e-02f, -3.74822170e-02f, -2.80368105e-02f, -1.81999758e-01f, 7.20395818e-02f, -1.69999495e-01f, 8.45009312e-02f,
  7.97708631e-02f, 2.85708994e-01f, 7.67320544e-02f, 5.57808788e-04f, 1.84661686e-01f, 7.55511075e-02f, 5.98009899e-02f, 2.25469559e-01f, 1.29486367e-01f, 1.68117762e-01f,
  2.23618243e-02f, -5.61020076e-02f, -1.62686482e-02f, 1.56244934e-01f, 7.06456304e-02f, -3.37991528e-02f, 6.07921593e-02f, -1.73611883e-02f, -4.17590588e-02f, -9.48475227e-02f,
  1.66955844e-01f, 1.39810264e-01f, -6.79831207e-02f, 5.48638143e-02f, -1.08868286e-01f, 1.62681654e-01f, -1.07393883e-01f, -9.76243317e-02f, -1.41185001e-01f, 8.54408219e-02f,
  -1.26102611e-01f, 1.54632747e-01f, -1.79228261e-01f, 2.72257119e-01f, 2.62190431e-01f, 4.91150841e-02f, -2.33481437e-01f, -2.60077298e-01f, -4.89314869e-02f, -6.50180727e-02f,
  2.14916945e-01f, 3.45068574e-02f, 2.07020670e-01f, -1.69562995e-01f, 2.90287193e-02f, -2.26393919e-02f, 1.80773064e-01f, -1.10196710e-01f, -3.16472873e-02f, 4.43280749e-02f,
  -2.37826884e-01f, -5.60218804e-02f, 1.62929580e-01f, -1.35038048e-01f, 2.26353705e-02f, -1.78197194e-02f, 1.60260201e-01f, -1.69475541e-01f, 2.53125001e-02f, 3.34448516e-02f,
  -1.77808315e-01f, -1.79951921e-01f, 1.00501545e-01f, 1.87369853e-01f, -1.44181415e-01f, 1.73556179e-01f, -6.42176792e-02f, 2.07103208e-01f, -2.21700892e-02f, 1.62018955e-01f,
  4.28503081e-02f, 1.40379697e-01f, 1.00722894e-01f, 7.00127482e-02f, 1.55693561e-01f, 6.74998388e-02f, 1.26423255e-01f, -2.06012174e-01f, -1.19409293e-01f, 1.71484038e-01f,
  -7.62369931e-02f, -7.80664235e-02f, 4.80251797e-02f, 1.14006631e-01f, -6.84327334e-02f, -1.20810322e-01f, 3.16787302e-01f, 1.21610977e-01f, 4.94263507e-02f, -1.46235228e-01f,
  1.13278210e-01f, -3.77537496e-02f, 2.68960983e-01f, 1.49179131e-01f, 8.38705450e-02f, -4.92533147e-02f, 6.81094602e-02f, -1.38081536e-01f, 4.09334973e-02f, -7.35949799e-02f,
  -8.77394304e-02f, 1.08379731e-02f, 1.07592314e-01f, -9.45488736e-02f, 1.45871744e-01f, -1.31086111e-01f, 1.21702388e-01f, 1.17980510e-01f, 1.48037955e-01f, 3.76875163e-04f,
  3.40163633e-02f, 1.78476512e-01f, 3.68591468e-03f, 2.36106560e-01f, 1.70324624e-01f, 1.83719546e-01f, 2.47670576e-01f, 5.12466952e-02f, 7.71694025e-03f, 6.71768934e-02f,
  1.37983575e-01f, -5.35049848e-02f, -1.04412504e-01f, -9.42567885e-02f, -6.57744855e-02f, 2.03306988e-01f, -1.08246088e-01f, -1.37655780e-01f, -8.15312937e-03f, -1.21531926e-01f,
  -7.93842077e-02f, -1.93200752e-01f, 2.12387949e-01f, 3.11577655e-02f, 2.33619615e-01f, 1.83865488e-01f, 1.68341458e-01f, 1.73198894e-01f, 9.53276604e-02f, 3.89397070e-02f,
  -7.15527758e-02f, 2.04152986e-01f, 8.06674063e-02f, -1.38530225e-01f, 2.13543456e-02f, 2.55736440e-01f, 2.03231603e-01f, 1.02206524e-02f, 6.00866182e-03f, 2.07614079e-01f,
  -4.56137955e-02f, -1.03223331e-01f, -2.55817436e-02f, -3.31185311e-02f, 3.70323006e-03f, -4.87755910e-02f, -1.21668600e-01f, 1.38877213e-01f, 1.93540566e-02f, 2.95664556e-02f,
  3.52564752e-02f, 2.34575376e-01f, 1.71474218e-01f, 1.45692483e-01f, -3.65934223e-02f, -1.25027105e-01f, -4.08277735e-02f, 1.30046651e-01f, 1.27107054e-01f, 1.83333345e-02f,
  2.37770110e-01f, 1.05232187e-02f, -1.36059672e-01f, 1.31513253e-01f, 9.50739831e-02f, -1.72700450e-01f, -5.98464943e-02f, -2.50855181e-02f, 3.23741361e-02f, 6.75896779e-02f,
  2.52785645e-02f, -1.10641778e-01f, -1.24519788e-01f, 1.37003928e-01f, 2.26278231e-01f, -1.25340104e-01f, -1.94198772e-01f, 8.15337077e-02f, -1.74995139e-02f, -2.66765822e-02f,
  4.59093153e-02f, 1.65527716e-01f, -5.05799167e-02f, 1.19907565e-01f, 1.70117363e-01f, 1.86910853e-01f, -8.48241709e-03f, -3.00719421e-02f, 4.11391892e-02f, 1.48202658e-01f,
  4.44901697e-02f, 7.26886913e-02f, 1.70754746e-01f, -1.09927744e-01f, 8.09038207e-02f, 5.04459068e-02f, 5.90751655e-02f, -1.78682860e-02f, 7.21918419e-02f, -7.46349469e-02f,
  1.82904944e-01f, -1.38132647e-01f, 3.73729438e-01f, -1.61078766e-01f, -2.18698725e-01f, 6.50666980e-03f, 4.99973446e-02f, 3.05868775e-01f, -3.40546321e-05f, 4.66771349e-02f,
  -1.69466496e-01f, -1.61087528e-01f, -4.26439419e-02f, -7.34970123e-02f, 2.76611328e-01f, -1.15111843e-01f, -6.16817847e-02f, -1.72504708e-01f, -2.58219354e-02f, -3.31270784e-01f,
  -3.17767682e-03f, 8.90814662e-02f, 1.52774438e-01f, 3.66880924e-01f, 2.99286544e-01f, -3.37643623e-02f, 5.73114417e-02f, 1.43814355e-01f, -1.07308470e-01f, 4.25471105e-02f,
  1.90757781e-01f, -4.34864983e-02f, -2.41010815e-01f, -7.94901177e-02f, 1.13474593e-01f, 4.55011576e-02f, -1.50099352e-01f, 2.93626059e-02f, -6.75206482e-02f, 6.48977831e-02f,
  1.67795539e-01f, 1.19290361e-02f, -2.08030269e-03f, 1.92576572e-01f, 1.31164953e-01f, 1.19334020e-01f, 3.04000173e-02f, 4.10515927e-02f, 1.34941727e-01f, -2.67924424e-02f,
  6.51885346e-02f, 7.69524574e-02f, 9.97864082e-02f, 2.70494878e-01f, 5.23607619e-02f, 1.43580660e-01f, -2.22690888e-02f, 1.14611760e-01f, -4.70628105e-02f, -1.20236829e-01f,
  -9.41245332e-02f, 3.63505855e-02f, 2.01878741e-01f, -1.62006557e-01f, 5.09999208e-02f, -9.44557716e-04f, 2.62308598e-01f, -1.11729071e-01f, 2.24162161e-01f, 1.42181769e-01f,
  5.94081357e-02f, 1.51806444e-01f, 2.55043488e-02f, 1.18254624e-01f, 1.92550540e-01f, 2.42644042e-01f, -3.29597061e-03f, 9.80989821e-03f, -1.21106161e-02f, 1.63113438e-02f,
  1.48868158e-01f, -1.19659817e-02f, -3.84809412e-02f, -1.00312479e-01f, 4.62291613e-02f, -4.27027009e-02f, 1.46058694e-01f, -1.25973776e-01f, 6.52075559e-02f, 8.86631906e-02f,
  3.83924916e-02f, -7.46797100e-02f, 1.04177497e-01f, 4.90115136e-02f, 4.30254489e-02f, 1.61207408e-01f, 2.71091424e-03f, -4.01341468e-02f, 2.00638577e-01f, 1.36397064e-01f,
  1.01932846e-01f, 8.77327919e-02f, 7.44901896e-02f, 1.26274377e-01f, 7.69333243e-02f, 4.41829860e-02f, 9.66232195e-02f, 2.11477757e-01f, 1.32965475e-01f, -1.12832561e-01f,
  -1.45148426e-01f, -5.46415977e-04f, -8.91334340e-02f, -8.72975513e-02f, 1.10426173e-01f, 1.95939764e-01f, 2.28722230e-01f, 2.47258976e-01f, 1.13624267e-01f, 1.68131754e-01f,
  6.73799142e-02f, 5.59384897e-02f, -7.74495676e-02f, 2.37438548e-02f, 3.76310125e-02f, -3.08771897e-02f, 1.68680727e-01f, -1.68297812e-01f, 1.94144160e-01f, -8.73365700e-02f,
  1.91152304e-01f, 9.35829207e-02f, 1.03787884e-01f, 8.37629363e-02f, 3.27571481e-03f, 5.77985495e-02f, -3.78583781e-02f, 1.83860771e-02f, 1.16645738e-01f, 2.70294696e-01f,
  1.59563869e-01f, 1.34674013e-01f, -5.40480167e-02f, 1.85907796e-01f, 3.26458812e-01f, 7.68834651e-02f, -6.26917630e-02f, -1.99879497e-01f, 8.07894673e-03f, 2.23673359e-02f,
  2.93518275e-01f, 8.80862847e-02f, 2.32329413e-01f, -7.83721637e-03f, -6.06139675e-02f, -1.32869487e-03f, 6.29321337e-02f, -1.34382144e-01f, -7.37014264e-02f, 1.59095421e-01f,
  -1.02455243e-01f, -6.47645220e-02f, 1.63351327e-01f, 1.61468670e-01f, 4.63526510e-02f, 1.11989550e-01f, 1.36194706e-01f, -2.14568637e-02f, -1.13804653e-01f, 9.23521146e-02f,
  1.08271115e-01f, 4.29533310e-02f, 6.54932708e-02f, -6.82846159e-02f, -2.67044336e-01f, 2.66327467e-02f, 3.32948403e-03f, 1.72225520e-01f, 3.98638174e-02f, 9.62970480e-02f,
  1.54170483e-01f, 7.45029524e-02f, 1.48976117e-01f, 2.05146849e-01f, -7.36995712e-02f, -2.32415274e-01f, -7.42836595e-02f, 8.57247934e-02f, 1.13151141e-01f, -8.60499665e-02f,
  -6.70409650e-02f, 8.77901465e-02f, 1.67791560e-01f, -4.37496528e-02f, -2.70616617e-02f, 5.89554459e-02f, -1.24954216e-01f, -7.40390345e-02f, -3.23207490e-02f, 4.33587283e-03f,
  3.03199459e-02f, -1.56065464e-01f, -9.86810252e-02f, 3.02103441e-02f, -1.29179865e-01f, 8.32139179e-02f, 1.38692126e-01f, 1.43432185e-01f, -1.06396958e-01f, -4.04357649e-02f,
  3.58995162e-02f, -7.18337372e-02f, -5.29418960e-02f, 1.14870392e-01f, 7.01802224e-02f, 1.40514269e-01f, 1.09146245e-01f, 8.48563239e-02f, -1.84580192e-01f, 2.29644477e-01f,
  9.77500454e-02f, -1.56798869e-01f, -1.19364172e-01f, 4.92071509e-02f, 6.19385466e-02f, -7.98916370e-02f, -8.95780474e-02f, -1.27173774e-02f, -3.99246626e-02f, -6.02536500e-02f,
  1.55091390e-01f, -3.05453930e-02f, -5.13955317e-02f, 8.23143125e-02f, -2.37633467e-01f, -1.44143729e-02f, -1.05248921e-01f, 1.94257960e-01f, 6.15045577e-02f, 1.14070043e-01f,
  1.52630553e-01f, 1.09382635e-02f, -6.09737411e-02f, -1.39037952e-01f, 1.71407945e-02f, 4.59088460e-02f, -1.19952187e-01f, -1.71575442e-01f, -8.16163495e-02f, 1.09002970e-01f,
  4.06149663e-02f, -3.79513018e-02f, 7.11797252e-02f, 7.69487470e-02f, -1.88148133e-02f, -7.39322901e-02f, 7.09510222e-02f, -5.74432425e-02f, -6.25489727e-02f, 1.57039225e-01f,
  -9.40131918e-02f, -5.28823733e-02f, -2.04419568e-02f, -1.17399827e-01f, -8.16839486e-02f, 1.00016557e-01f, -1.56658713e-03f, 6.38040388e-03f, -2.43333988e-02f, 1.19391762e-01f,
  -1.07205741e-01f, 2.28897214e-01f, 2.02895626e-01f, 1.61637485e-01f, -1.86262861e-01f, -1.28565729e-01f, 2.07440592e-02f, -1.93204239e-01f, 1.70118660e-02f, 1.40543282e-01f,
  2.00221479e-01f, -8.43066573e-02f, -9.88804623e-02f, 5.84929474e-02f, -9.21098217e-02f, -1.03069089e-01f, 3.95702347e-02f, -1.43703952e-01f, -2.44248345e-01f, -1.15660392e-01f,
  6.66360743e-03f, 1.42514303e-01f, 7.80278817e-02f, -1.63854033e-01f, -1.19594090e-01f, -9.88416374e-03f, -8.42038617e-02f, 2.41196826e-01f, -1.72255002e-02f, -2.38072593e-02f,
  2.38047108e-01f, 6.40705600e-02f, -1.56307876e-01f, -4.27400209e-02f, 2.20389977e-01f, 3.95321220e-01f, 7.85260089e-03f, -2.28639282e-02f, 5.20957261e-02f, -6.78500384e-02f,
  7.07653090e-02f, 1.03536412e-01f, -1.38826087e-01f, 1.33001938e-01f, -4.42237258e-02f, 7.43444562e-02f, -9.75854173e-02f, -2.35519540e-02f, 1.26081198e-01f, 1.38878629e-01f,
  -1.63049161e-01f, 4.86589447e-02f, -1.50965691e-01f, 7.75318965e-02f, -1.36141568e-01f, 1.31011665e-01f, 1.36765346e-01f, -6.25658184e-02f, 7.64074922e-02f, 1.40753970e-01f,
  -1.72741622e-01f, -2.03597367e-01f, 1.06509410e-01f, -1.30416900e-01f, -3.22383121e-02f, -2.46291179e-02f, 7.36419298e-03f, 9.16743279e-02f, 2.41977572e-01f, 3.36954117e-01f,
  1.54162839e-01f, 7.38305971e-02f, -8.89134705e-02f, -1.35762528e-01f, -3.14425200e-01f, -5.65219745e-02f, -4.19666409e-04f, -9.77929235e-02f, 1.25865370e-01f, 2.03834586e-02f,
  1.36566326e-01f, -1.20867930e-01f, 8.93324837e-02f, 1.39429092e-01f, -1.51010886e-01f, -5.57936318e-02f, -4.56704274e-02f, 2.10615620e-01f, 1.61508229e-02f, 1.54511780e-01f,
  8.20086803e-03f, 7.23806396e-03f, 2.01132506e-01f, -1.28580585e-01f, 5.25560156e-02f, -9.42648798e-02f, 5.34210689e-02f, -6.83512315e-02f, -6.32440373e-02f, -8.66336077e-02f,
  3.51152159e-02f, 5.62162027e-02f, 9.09604430e-02f, 6.19827136e-02f, 2.40017124e-03f, 3.85019854e-02f, 7.10022449e-02f, -1.67715341e-01f, 6.60420954e-02f, -1.03717431e-01f,
  1.05579600e-01f, -4.58330382e-03f, -5.64706437e-02f, -1.73050612e-01f, 1.29735097e-01f, 1.12367664e-02f, -8.30460712e-02f, 2.09003717e-01f, 8.98703709e-02f, -4.41372693e-02f,
  -5.21795731e-03f, -3.34570892e-02f, -1.02321915e-02f, -8.53652954e-02f, 2.44750544e-01f, 3.09503097e-02f, -6.87712133e-02f, 1.81000575e-01f, 1.05989739e-01f, 7.91701302e-02f,
  1.09632976e-01f, 4.39982936e-02f, -1.42753065e-01f, -1.09084286e-01f, 6.33086711e-02f, -1.89403072e-01f, 1.53498322e-01f, 1.18026055e-01f, 4.37674001e-02f, 9.01571959e-02f,
  -7.70382881e-02f, 1.43337891e-01f, 5.80628477e-02f, 2.31559202e-02f, -3.92037258e-02f, 1.71341881e-01f, 5.87405339e-02f, -1.06431976e-01f, 8.68842378e-02f, 6.63696676e-02f,
  1.05460882e-01f, -1.42367929e-01f, 8.10182840e-02f, -1.18235929e-03f, -1.18446127e-01f, 1.54524788e-01f, -7.11935982e-02f, 1.24513678e-01f, -6.00985601e-04f, -3.56399082e-02f,
  -6.99882656e-02f, 8.65783244e-02f, 1.45871684e-01f, 2.02135682e-01f, -8.87227058e-02f, -1.83196682e-02f, 1.09571815e-01f, 6.19269721e-02f, 2.88756192e-02f, 1.58099324e-01f,
  -1.52829006e-01f, 1.77469049e-02f, -6.73527569e-02f, 5.51197343e-02f, 1.13802411e-01f, 4.19626534e-02f, 2.38061622e-02f, -2.77693540e-01f, -5.29229036e-03f, -1.64743468e-01f,
  1.33323418e-02f, 1.13830917e-01f, -1.10788709e-02f, 1.32594183e-01f, -1.78502388e-02f, 8.53253156e-03f, -2.79869381e-02f, 7.58669451e-02f, -5.85149899e-02f, 4.47296584e-03f,
  2.34780870e-02f, 2.24980161e-01f, -9.97686014e-02f, 5.03590740e-02f, -1.06414538e-02f, 1.05532452e-01f, 1.22285299e-01f, -1.00756481e-01f, -4.81071770e-02f, -2.74622798e-01f,
  -2.50252597e-02f, -3.89964357e-02f, -1.09477252e-01f, 9.57010239e-02f, -5.04555590e-02f, 1.50377810e-01f, 2.53904581e-01f, -5.17128408e-02f, -8.86336789e-02f, 7.65397921e-02f,
  -2.15309262e-02f, -1.88648224e-01f, -8.55456889e-02f, 2.00255990e-01f, 1.91103797e-02f, -9.19272229e-02f, 3.03183217e-02f, 2.70796180e-01f, 9.10032317e-02f, 3.02520186e-01f,
  -1.93439722e-02f, -6.81071505e-02f, 6.22052811e-02f, -3.23584303e-02f, -6.58822805e-02f, 1.64477959e-01f, -2.19427645e-02f, 2.20304236e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  1.31880343e-01f, 2.82823611e-02f, 1.45370036e-01f, 1.13726214e-01f, -2.12679543e-02f, -3.73846875e-03f, 1.85255915e-01f, 1.25850484e-01f, 5.79731800e-02f, 1.06655478e-01f,
  2.65327040e-02f, 2.38391999e-02f, 1.23463683e-01f, 1.41920894e-01f, 1.11242861e-01f, 4.25324477e-02f, 2.19757408e-02f, 1.04118660e-01f, 8.76863971e-02f, 1.97440624e-01f,
  8.05923045e-02f, 4.22286289e-03f, 1.79074973e-01f, -5.75577915e-02f, 4.91462573e-02f, 1.04557559e-01f, 1.38928801e-01f, 1.72076672e-01f, 4.31606025e-02f, 5.93545251e-02f,
  9.77418721e-02f, -3.01433168e-02f, 1.32411152e-01f, 1.61869243e-01f, 1.96642354e-01f, 8.72090310e-02f, 8.75317529e-02f, 4.82390337e-02f, 4.39084135e-02f, 4.45448607e-02f,
  1.46785423e-01f, 2.48380937e-02f, 1.59683704e-01f, 1.85994968e-01f, -1.00658357e-03f, 1.18405491e-01f, 9.95297581e-02f, 6.50852323e-02f, -1.09760344e-01f, 9.46516842e-02f,
  2.58393567e-02f, -8.14314410e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -5.10463826e-02f, -2.44743973e-02f, 4.22606431e-02f, -2.71248650e-02f, -5.44252135e-02f, -8.18641260e-02f, 6.52466118e-02f, 1.39755523e-02f, 3.40678282e-02f, 5.51481470e-02f,
  2.46047769e-02f, 3.69543135e-02f, -1.00179426e-01f, 2.72090957e-02f, -1.08803213e-01f, 1.01111822e-01f, -7.92946815e-02f, 2.52770316e-02f, 4.96365428e-02f, -1.68008357e-01f,
  -8.39189887e-02f, 8.72826427e-02f, 4.94925417e-02f, 3.47907059e-02f, -9.02298652e-03f, 7.95000717e-02f, 9.99106020e-02f, -1.24730863e-01f, 3.71424034e-02f, -4.58095409e-02f,
  7.59214237e-02f, 7.88626373e-02f, -6.71626925e-02f, -1.67296012e-03f, 2.72967685e-02f, -1.01368159e-01f, -2.01080721e-02f, 1.21132545e-01f, 1.65620089e-01f, -1.06308475e-01f,
  4.82490510e-02f, 3.28184143e-02f, 9.15687978e-02f, 7.19829202e-02f, -5.97843193e-02f, -7.30170757e-02f, -1.12177525e-02f, -1.22127563e-01f, 9.02655814e-03f, 4.85410653e-02f,
  8.78993794e-02f, -3.77428196e-02f, -4.81677949e-02f, 8.63889158e-02f, -6.99910745e-02f, 9.89949778e-02f, 1.05495743e-01f, -4.83895130e-02f, 4.60826531e-02f, 1.10224113e-01f,
  2.03328148e-01f, 2.08359193e-02f, -3.49582620e-02f, 1.92051642e-02f, 7.84139484e-02f, -3.26005742e-02f, 2.03585010e-02f, -4.39878106e-02f, 3.47940996e-02f, 1.06218476e-02f,
  -1.35226980e-01f, 1.55210555e-01f, 3.62394415e-02f, 1.19344287e-01f, -1.53258052e-02f, 4.81895283e-02f, 5.20419776e-02f, 1.03721127e-01f, -4.10207585e-02f, -1.47690862e-01f,
  1.21991150e-01f, 6.83194175e-02f, 6.94230720e-02f, 1.66926160e-01f, 1.21604078e-01f, 3.18067111e-02f, -1.30153727e-02f, 6.12455793e-02f, 9.43226591e-02f, -1.11106664e-01f,
  1.31999291e-02f, 1.29650146e-01f, 7.18049705e-02f, -6.45795017e-02f, -1.20925739e-01f, 9.69465375e-02f, 1.20627925e-01f, -1.75954122e-02f, -6.78459331e-02f, 6.70988113e-02f,
  4.90842462e-02f, -1.43149868e-01f, 6.50041103e-02f, 9.13235545e-03f, 3.94607373e-02f, 1.34970129e-01f, -1.09292649e-01f, -5.24716079e-03f, -5.26849739e-02f, 7.17530251e-02f,
  2.04584617e-02f, -5.04223555e-02f, 8.34975168e-02f, 1.81653187e-01f, 3.38071072e-03f, -6.11159252e-03f, -1.32726818e-01f, -8.93677846e-02f, 5.08193262e-02f, -4.77232002e-02f,
  1.24733420e-02f, -9.70993191e-02f, -9.71068963e-02f, -1.27699450e-01f, -2.02629283e-01f, 1.20475098e-01f, 1.81568470e-02f, -1.07758865e-01f, -8.90038311e-02f, -8.32738876e-02f,
  -7.17442706e-02f, -3.48223513e-03f, 9.61949602e-02f, 6.00641482e-02f, -5.55990301e-02f, 6.05119914e-02f, 3.57714929e-02f, -1.26366448e-02f, -1.56124309e-01f, 8.95986259e-02f,
  -5.01972511e-02f, -7.10540563e-02f, -8.11454803e-02f, -4.26549502e-02f, 1.72087848e-01f, 9.36864018e-02f, 4.17113900e-02f, -3.60418335e-02f, 1.54225051e-01f, -5.18501252e-02f,
  -4.84358519e-02f, -6.57465484e-04f, 1.37752607e-01f, 9.21668708e-02f, -1.64209098e-01f, -7.50429882e-03f, -6.85149282e-02f, -4.11423249e-03f, 8.64128843e-02f, -1.12195671e-01f,
  -3.00992671e-02f, -1.45642594e-01f, 8.17840025e-02f, -1.29528776e-01f, 1.26773849e-01f, -7.52146319e-02f, 7.10553825e-02f, 1.10886566e-01f, 6.50236383e-03f, -5.78766651e-02f,
  -3.16710956e-02f, -1.73312217e-01f, 1.14093751e-01f, 1.06574267e-01f, 7.17783645e-02f, 2.12073430e-01f, 4.59471680e-02f, -3.12589854e-02f, 6.91044256e-02f, 5.82421310e-02f,
  1.01855412e-01f, 1.49538899e-02f, 2.97422893e-02f, -8.14244598e-02f, -2.37749033e-02f, -1.07715674e-01f, -2.30687819e-02f, 1.21860191e-01f, 3.15758735e-02f, 3.43832001e-02f,
  -1.43610174e-02f, 2.37143002e-02f, 1.50003940e-01f, 7.55922496e-02f, -1.71049181e-02f, 3.04602738e-02f, -2.26074867e-02f, 4.00042124e-02f, -6.04014434e-02f, -2.23179236e-01f,
  -9.46086738e-03f, -2.50244290e-01f, 1.54893458e-01f, 1.88269408e-03f, 1.21584191e-04f, -1.43488869e-01f, 1.17850848e-01f, 8.43411908e-02f, 6.58035204e-02f, -5.13626374e-02f,
  1.97193205e-01f, 1.31408736e-01f, 2.44129710e-02f, -6.99055940e-02f, -1.41840447e-02f, -1.52858973e-01f, 1.10883646e-01f, -1.77607909e-02f, 2.30582897e-02f, 6.97117299e-02f,
  -1.12267800e-01f, -5.67698814e-02f, 3.79311405e-02f, 1.96424257e-02f, -3.60744931e-02f, 4.25199009e-02f, -6.35003597e-02f, 6.08103685e-02f, -2.50703674e-02f, -1.19005069e-01f,
  -3.32752541e-02f, 1.06227480e-01f, -7.51519501e-02f, 7.91393071e-02f, 2.15624701e-02f, -2.22020745e-01f, -1.02463942e-02f, -8.40734839e-02f, -3.90858054e-02f, 8.03326443e-02f,
  -6.93803281e-02f, -1.42659709e-01f, -1.24437235e-01f, 4.21591811e-02f, -5.08704297e-02f, -1.18916564e-01f, 3.62784602e-02f, -7.40031153e-02f, -2.76233673e-01f, 1.09843358e-01f,
  1.45685092e-01f, -1.71734846e-05f, 6.21418245e-02f, 3.11466455e-02f, 1.23339698e-01f, -1.31267503e-01f, 1.05676912e-01f, -4.87830378e-02f, 4.71702106e-02f, 1.36329345e-02f,
  5.45185171e-02f, 2.30731294e-02f, 1.14666217e-03f, -1.47862911e-01f, 1.35008410e-01f, -3.25162597e-02f, -6.35028034e-02f, 1.11418627e-02f, -1.29056573e-01f, 4.63268571e-02f,
  -6.57954440e-02f, 1.13102406e-01f, -1.07266888e-01f, 2.78897909e-03f, 1.17300078e-01f, -2.63363160e-02f, -6.66173398e-02f, -8.84034112e-02f, 1.90553237e-02f, -3.83458212e-02f,
  5.34625426e-02f, 6.19968101e-02f, -1.09142639e-01f, 3.75886448e-02f, -1.10176295e-01f, 1.07508246e-02f, -1.41234677e-02f, 7.49051422e-02f, -4.72124666e-02f, 2.09831670e-02f,
  1.13753892e-01f, -9.46510285e-02f, 6.14243448e-02f, 9.00095031e-02f, 9.51017439e-02f, -5.62993437e-02f, 4.17182669e-02f, 8.35194811e-02f, 1.28677249e-01f, -9.24152583e-02f,
  8.52772072e-02f, -1.03841349e-01f, 7.73015916e-02f, -5.26198708e-02f, -1.13125093e-01f, -5.39823249e-02f, -4.84516956e-02f, 8.46693218e-02f, 6.75624982e-02f, 1.28075574e-02f,
  -4.93667535e-02f, 8.37007654e-04f, 1.05161861e-01f, -8.06606859e-02f, 1.41644523e-01f, 1.18976913e-01f, 9.34846327e-03f, -7.64043629e-02f, 8.57982785e-03f, 6.36854991e-02f,
  -4.06467058e-02f, 3.97335812e-02f, -1.67057791e-03f, -1.48407608e-01f, 4.12222818e-02f, 1.54995639e-02f, 1.06561676e-01f, 7.48287980e-03f, 1.48979323e-02f, 8.79940912e-02f,
  -4.74434271e-02f, -1.39682740e-02f, -1.02195153e-02f, 1.77579913e-02f, 2.13958789e-02f, 1.33482307e-01f, -1.39641240e-01f, -6.39529973e-02f, -1.10434428e-01f, -1.32880017e-01f,
  -1.89883873e-01f, -1.33392122e-02f, 1.55677229e-01f, 2.03948449e-02f, -4.63261008e-02f, -1.13662489e-01f, -9.94030572e-03f, -2.66725384e-02f, 2.40219552e-02f, 1.82562582e-02f,
  -2.53956206e-02f, -2.52230670e-02f, 1.18727637e-02f, 2.50932258e-02f, 2.85866596e-02f, -9.75746196e-03f, 1.55665819e-03f, 2.20534965e-01f, 5.36942994e-03f, -5.30456603e-02f,
  -1.19260319e-01f, -1.19504504e-01f, 6.51198030e-02f, 1.42643437e-01f, 5.07530198e-02f, -1.58524454e-01f, 3.25208716e-02f, -1.65216193e-01f, 6.24306453e-03f, 1.03320787e-03f,
  -2.91203726e-02f, 1.59187522e-02f, 1.87484617e-03f, 2.00841114e-01f, -5.10079670e-04f, 1.06032588e-01f, 2.04997823e-01f, 5.49511500e-02f, 1.55246660e-01f, -3.38761806e-02f,
  8.80843028e-02f, -1.15511201e-01f, -8.73931404e-03f, 6.30818456e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -7.81899225e-03f, -9.87238213e-02f, -7.28422105e-02f, 5.47089428e-02f, -6.89265132e-02f, 7.36023784e-02f, 7.27148652e-02f, -9.36213210e-02f, 1.35398567e-01f, 4.80641052e-02f,
  -1.32492883e-02f, -1.28526479e-01f, 9.61797014e-02f, 8.58025178e-02f, -2.10234299e-01f, 1.17886782e-01f, -5.72952628e-02f, 1.54585510e-01f, 2.94714049e-02f, 1.49740607e-01f,
  -1.29896224e-01f, -1.01137348e-02f, 1.26778543e-01f, 4.42439280e-02f, -1.62519097e-01f, 1.17054038e-01f, 5.36989048e-02f, -8.36924091e-02f, -2.29013572e-03f, 1.24019325e-01f,
  -1.05566658e-01f, 4.99838553e-02f, -7.85976648e-03f, 5.20361699e-02f, -1.04705349e-01f, 1.46613240e-01f, -8.32089484e-02f, 3.12944502e-02f, -9.06842109e-03f, -1.05508059e-01f,
  9.36841592e-02f, 1.37297213e-01f, 9.41559523e-02f, 9.56546292e-02f, -1.21293873e-01f, 5.86231090e-02f, 1.18631564e-01f, -9.81463417e-02f, -2.05364719e-01f, 2.31398016e-01f,
  -1.60527229e-01f, 7.23235384e-02f, 3.27704884e-02f, -2.71736849e-02f, -1.27361387e-01f, -2.19446290e-02f, -5.81042469e-02f, 8.40972364e-02f, 5.02763800e-02f, -6.50901198e-02f,
  -1.10139772e-01f, 1.47337198e-01f, -4.32590842e-02f, 1.07808717e-01f, 1.41481176e-01f, 9.18011144e-02f, 9.83272791e-02f, 7.98641518e-02f, -4.25750203e-02f, 2.01911088e-02f,
  -2.98256248e-01f, -5.17528541e-02f, 1.51830260e-02f, -1.39904439e-01f, 7.97144324e-02f, 6.80007711e-02f, 1.24146864e-01f, -8.77535567e-02f, -2.11294234e-01f, 5.17271608e-02f,
  3.12494159e-01f, -5.51616885e-02f, 2.33755991e-01f, 2.29301736e-01f, 3.10488701e-01f, 7.99319521e-03f, 7.07760155e-02f, -1.56645805e-01f, 2.43493050e-01f, 9.86071303e-02f,
  5.41052185e-02f, 2.86998674e-02f, 1.56871274e-01f, -7.56748766e-02f, 1.18904643e-01f, 2.05216050e-01f, -1.68842189e-02f, -2.32540622e-01f, -1.68735176e-01f, -8.55763704e-02f,
  2.09432542e-01f, 5.33747151e-02f, 7.76057392e-02f, -1.44815072e-01f, -4.07917760e-02f, 1.37381166e-01f, -9.44843814e-02f, -2.01202795e-01f, 1.45484611e-01f, -1.79101601e-01f,
  1.59307107e-01f, 7.53695145e-02f, 1.67777650e-02f, 4.86840233e-02f, 1.36143625e-01f, 9.00862291e-02f, 6.22152649e-02f, -1.11333691e-01f, 5.53236715e-02f, 6.69251084e-02f,
  -1.15150079e-01f, -2.31806248e-01f, -1.73102230e-01f, -1.55022908e-02f, 1.65072948e-01f, 1.74214214e-01f, 1.03572398e-01f, -1.52667761e-01f, 8.16718265e-02f, 3.45107913e-02f,
  8.78239796e-02f, 9.54808518e-02f, 7.24218041e-02f, -7.06072748e-02f, -7.87384287e-02f, 9.67482552e-02f, -9.20238346e-02f, -1.15592234e-01f, 4.59900796e-02f, 1.96501955e-01f,
  -1.05727911e-01f, -1.41398668e-01f, -1.26764461e-01f, -2.88566966e-02f, 8.20634365e-02f, -1.94038916e-02f, 2.19000325e-01f, 8.02348033e-02f, 5.74720763e-02f, 1.86106071e-01f,
  6.13003820e-02f, 1.38261607e-02f, 1.42518878e-01f, -4.05301414e-02f, 6.45957747e-03f, -1.91612672e-02f, 5.51086962e-02f, -1.45593047e-01f, 8.42705145e-02f, 1.46997511e-01f,
  -6.37753904e-02f, -1.66960314e-01f, 1.20199574e-02f, -2.04720646e-01f, 2.72380024e-01f, 1.72231734e-01f, 1.29207790e-01f, -3.12566429e-01f, -7.87192732e-02f, 2.62012668e-02f,
  4.28147390e-02f, -9.59119573e-02f, 8.55736136e-02f, -3.40907335e-01f, 9.57515761e-02f, -1.82172805e-01f, 1.65561393e-01f, -1.15969524e-01f, -1.12351917e-01f, -2.10380144e-02f,
  -2.64590323e-01f, 5.84836304e-02f, -1.11826025e-01f, 1.65801525e-01f, 1.60490751e-01f, -7.73050189e-02f, 1.31324768e-01f, -2.41542421e-02f, 1.80592492e-01f, -1.28094316e-01f,
  4.23691608e-02f, -5.86820021e-02f, 9.87643301e-02f, 1.52963921e-01f, 2.10133791e-02f, 1.13689624e-01f, 1.12888794e-02f, 1.06913753e-01f, 1.88719034e-02f, 8.50128755e-03f,
  -1.01174064e-01f, -1.50210500e-01f, 2.27767915e-01f, 5.52147888e-02f, -1.95110519e-03f, 4.89498209e-03f, 2.96183173e-02f, -5.86361401e-02f, 3.33229512e-01f, -1.44921347e-01f,
  2.17178106e-01f, 1.54061496e-01f, -3.31470720e-03f, 1.19432941e-01f, 7.14658871e-02f, 2.05788016e-01f, 9.44446474e-02f, -8.52792785e-02f, -1.25713209e-02f, 8.56797323e-02f,
  3.21498476e-02f, 1.94995124e-02f, 1.23167306e-01f, 2.20352203e-01f, 5.24044000e-02f, -1.89205661e-01f, 7.04696029e-02f, -6.62928149e-02f, 4.62504774e-02f, 1.31287292e-01f,
  1.79455459e-01f, -2.55990792e-02f, -1.55081287e-01f, 9.30580422e-02f, 9.89324152e-02f, -6.37364313e-02f, -1.30791917e-01f, -2.36891612e-01f, 2.55723178e-01f, -1.84591338e-01f,
  2.16276824e-01f, -3.50751318e-02f, -8.90323222e-02f, -1.09308958e-01f, -2.53789574e-01f, 1.12291344e-01f, -2.11481787e-02f, -1.89714190e-02f, 3.94686386e-02f, 1.23954155e-01f,
  1.49013817e-01f, -9.57218930e-02f, 7.00378790e-02f, 3.20953913e-02f, -7.31479153e-02f, 7.91148469e-02f, 3.75405289e-02f, 1.38552800e-01f, 1.12637967e-01f, 6.86694756e-02f,
  4.45925966e-02f, 8.08327943e-02f, -3.29286903e-02f, -1.43222287e-01f, -1.02584571e-01f, -2.49754429e-01f, 2.11462587e-01f, -4.26856466e-02f, 3.44149992e-02f, 2.26427577e-02f,
  1.35580957e-01f, 1.81601979e-02f, 1.42165378e-01f, 2.68750750e-02f, 3.45865153e-02f, 1.93034768e-01f, -6.88189939e-02f, 3.34763899e-02f, 4.56597693e-02f, 7.61887664e-03f,
  5.74090183e-02f, -8.60071257e-02f, 1.40951216e-01f, 6.01601787e-03f, 1.11927681e-01f, -3.36215310e-02f, 1.01364151e-01f, 1.20191947e-01f, -1.03973173e-01f, -1.45245656e-01f,
  -5.03317453e-02f, -1.58419043e-01f, 1.24644853e-01f, 7.77089447e-02f, 5.72959632e-02f, -2.54767060e-01f, -1.40028834e-01f, 1.87488105e-02f, 1.69740301e-02f, 5.83275743e-02f,
  -7.67582911e-04f, -3.28208059e-01f, 2.33387053e-01f, -1.06792122e-01f, 7.91758578e-03f, -7.51911625e-02f, -1.51343882e-01f, 5.73811792e-02f, -1.78656429e-01f, 6.79948255e-02f,
  -8.04622397e-02f, 5.12097329e-02f, -4.42182869e-02f, 2.30887197e-02f, 1.49747744e-01f, -5.72913513e-02f, 1.73564777e-01f, 4.58500953e-03f, -6.37136400e-02f, -4.50487062e-02f,
  -6.42833412e-02f, 2.21763328e-01f, 2.57671215e-02f, -8.85070011e-04f, 1.21289842e-01f, 1.62462145e-01f, 1.49944469e-01f, -8.86667147e-02f, -1.89153492e-01f, -2.15015694e-01f,
  2.47468874e-01f, 5.57089671e-02f, -1.01623967e-01f, -6.31797165e-02f, 2.22303480e-01f, 3.95340025e-02f, 1.37011662e-01f, -6.72861561e-02f, 3.46317366e-02f, 1.27130831e-02f,
  -1.11859299e-01f, 1.64107516e-01f, 8.53017643e-02f, 8.71253908e-02f, 1.35359034e-01f, -7.66869858e-02f, 1.48147076e-01f, -1.15997149e-02f, 9.25580561e-02f, 4.86346819e-02f,
  2.72312284e-01f, 3.36562805e-02f, 7.18278661e-02f, -1.47925690e-01f, 1.04667753e-01f, -1.12505779e-01f, 8.54114592e-02f, 1.84446335e-01f, 8.80370066e-02f, -1.52136981e-01f,
  -1.03854664e-01f, -1.56051502e-01f, -1.10903062e-01f, -7.87349567e-02f, -1.32755702e-02f, -1.77600950e-01f, 2.10229203e-01f, -6.66079521e-02f, 1.03550509e-01f, -2.17049882e-01f,
  -9.06057432e-02f, -4.31278683e-02f, -8.28913897e-02f, 3.03708225e-01f, -4.68306839e-02f, 1.08113654e-01f, 1.10798202e-01f, 5.87236136e-02f, 7.20407218e-02f, 2.28215940e-02f,
  1.11452393e-01f, -2.03707367e-01f, -7.30343536e-03f, -3.97071056e-02f, -1.84062477e-02f, -5.74593842e-02f, 4.30986471e-02f, 7.51270875e-02f, -8.35304614e-04f, -6.12591319e-02f,
  -4.72435653e-02f, 1.10113889e-01f, 1.97354611e-02f, -1.65105537e-02f, -6.94806352e-02f, 3.35325971e-02f, 1.41196430e-01f, -2.05196273e-02f, 1.67687431e-01f, -6.86609596e-02f,
  2.10137039e-01f, -2.15138018e-01f, 3.93248014e-02f, 7.57621005e-02f, 1.06312722e-01f, -2.57844687e-01f, 7.16211349e-02f, 2.56014377e-01f, 1.65694430e-01f, -1.93246424e-01f,
  -1.16358824e-01f, 2.57043034e-01f, 3.08866017e-02f, 2.20354237e-02f, 2.14843322e-02f, -3.87346111e-02f, 2.63070315e-01f, 1.03262596e-01f, -1.51490644e-01f, 1.95134893e-01f,
  2.60591120e-01f, 2.77675572e-03f, -1.01775587e-01f, 1.34214655e-01f, -1.11748070e-01f, -7.13013560e-02f, 1.34872660e-01f, 5.69133125e-02f, 1.32501110e-01f, 1.47866338e-01f,
  -4.07090299e-02f, 4.66488814e-03f, 1.97653085e-01f, 6.42234758e-02f, -1.01722673e-01f, -7.93823693e-03f, -6.29232749e-02f, -2.16003731e-01f, 2.36272916e-01f, -2.00512603e-01f,
  2.03698039e-01f, 2.02491492e-01f, 2.27959156e-02f, -1.80120587e-01f, -3.85641754e-02f, 9.25169513e-02f, 1.04713421e-02f, 8.13361034e-02f, 1.21156678e-01f, 1.79175884e-01f,
  8.78327265e-02f, 7.73584694e-02f, 8.97185728e-02f, 1.29169762e-01f, 7.98696801e-02f, 1.22700799e-02f, 4.00558189e-02f, -9.85452011e-02f, 2.59660911e-02f, 4.82794158e-02f,
  -1.21039927e-01f, -4.08978872e-02f, 5.73712066e-02f, 4.43969574e-03f, 6.44817203e-02f, -1.42634004e-01f, 1.54072016e-01f, -1.38721451e-01f, 3.33239473e-02f, -8.66134688e-02f,
  -2.52009630e-02f, -5.96646927e-02f, 1.21661879e-01f, 3.83304991e-02f, 4.55179298e-03f, 1.41406089e-01f, -9.05664787e-02f, -2.32303649e-01f, 2.13914350e-01f, 1.74779315e-02f,
  1.02821790e-01f, 1.38380066e-01f, 1.81886464e-01f, 5.82530256e-03f, 2.31168345e-01f, 7.03413188e-02f, 1.08589649e-01f, 4.71029095e-02f, -1.10968120e-01f, -1.76133603e-01f,
  1.39792293e-01f, 2.21782848e-02f, 1.29949391e-01f, 8.05561990e-02f, 2.06690910e-03f, -6.64742813e-02f, 1.65585339e-01f, -2.09589496e-01f, -1.99069098e-01f, 5.35669476e-02f,
  9.88118630e-03f, 8.43515620e-02f, 1.27410486e-01f, -3.69600803e-02f, 9.55375880e-02f, 1.42532974e-01f, 3.24821293e-01f, 2.89989375e-02f, 6.18953109e-02f, -2.00906813e-01f,
  2.31693015e-01f, 1.29008545e-02f, 6.78536668e-02f, -1.41170919e-01f, 3.57293971e-02f, 4.88571748e-02f, -6.98451400e-02f, 5.67554198e-02f, -1.27954438e-01f, -6.86718225e-02f,
  2.90515274e-01f, 2.05613360e-01f, -3.15747529e-01f, 1.76146209e-01f, -1.77071482e-01f, 2.14065716e-01f, -2.51232773e-01f, 9.63739306e-02f, -1.30756944e-01f, -3.81834097e-02f,
  9.10393372e-02f, -1.41511649e-01f, 2.58969754e-01f, -1.50769681e-01f, -8.10766418e-04f, 1.19481698e-01f, 1.32496282e-01f, 1.57146677e-01f, -1.81207880e-01f, -1.08164787e-01f,
  -9.06350836e-03f, -6.70259371e-02f, -4.72488776e-02f, 3.34605984e-02f, 3.46011855e-02f, -2.56250035e-02f, 1.28413364e-01f, -1.81816339e-01f, 1.49006397e-01f, 1.98435441e-01f,
  2.21278146e-02f, -3.68650965e-02f, 8.53148252e-02f, 4.60689478e-02f, 2.01107815e-01f, -9.37355012e-02f, 1.49309754e-01f, 2.14089036e-01f, -5.80231994e-02f, 1.84765697e-01f,
  1.55356973e-02f, 2.80350715e-01f, -5.79884909e-02f, 2.12517962e-01f, 1.01222664e-01f, -3.02843183e-01f, -8.66123512e-02f, 1.33090124e-01f, 2.04300866e-01f, -6.15330003e-02f,
  4.17403597e-03f, 1.37555674e-01f, 6.52181059e-02f, 3.54924351e-02f, 1.02231465e-01f, 2.12808982e-01f, 1.09682627e-01f, 1.29895851e-01f, -4.87156473e-02f, 3.01414984e-03f,
  1.95784971e-01f, 4.13372042e-03f, 3.36714312e-02f, 1.39000416e-01f, -1.68590739e-01f, 1.74633324e-01f, -3.98623832e-02f, 1.92813754e-01f, 4.43332531e-02f, 1.58582732e-01f,
  2.20010310e-01f, -2.86020637e-01f, -8.88066217e-02f, -9.50926840e-02f, 3.23791616e-03f, -5.39694354e-02f, 1.33502752e-01f, 1.46819741e-01f, -1.43512696e-01f, 2.92415112e-01f,
  8.73286426e-02f, 1.42648652e-01f, -2.53379773e-02f, 7.09764585e-02f, 7.39414915e-02f, 1.57527402e-02f, 1.60333931e-01f, -1.66568369e-01f, 3.11943348e-02f, -6.43162131e-02f,
  2.29767516e-01f, -8.21185187e-02f, -1.17953114e-01f, -2.13171050e-01f, -4.57945578e-02f, 3.57212663e-01f, 1.08248204e-01f, -6.29274696e-02f, 8.81109461e-02f, -1.69809118e-01f,
  1.94416851e-01f, 1.28160194e-01f, -2.01417774e-01f, 1.91394955e-01f, 2.66402274e-01f, -3.99670489e-02f, 2.49634832e-01f, 2.97451187e-02f, -1.53891509e-02f, -3.03288791e-02f,
  2.05410272e-01f, -5.60795888e-02f, 1.81558505e-01f, 1.05442561e-01f, 5.46792038e-02f, 1.34571195e-01f, -7.04069510e-02f, 1.34936976e-03f, -1.21929482e-01f, -7.76130185e-02f,
  2.60593653e-01f, -4.55112420e-02f, 1.36133403e-01f, 6.57092929e-02f, -3.19681726e-02f, 4.75814715e-02f, 1.67859629e-01f, -1.62114128e-01f, 1.71107903e-01f, -9.27591771e-02f,
  1.03636079e-01f, 1.76836532e-02f, 1.01882376e-01f, 1.19152777e-01f, 2.36309636e-02f, 1.76233083e-01f, -2.49770254e-01f, -8.64429176e-02f, 1.96537599e-01f, -2.09762920e-02f,
  -1.59061328e-01f, -1.14355013e-01f, 1.44365758e-01f, 1.66121516e-02f, -1.17290817e-01f, 6.27033859e-02f, 1.79437250e-01f, 3.52549404e-02f, -1.71781197e-01f, -1.26172632e-01f,
  2.15661582e-02f, 1.02808498e-01f, -2.09237337e-02f, 1.65317863e-01f, 2.18779027e-01f, 6.24754205e-02f, -7.21405074e-02f, -5.19705564e-02f, -5.76838143e-02f, 5.58795221e-02f,
  7.64001831e-02f, 1.37830973e-01f, 2.66193002e-01f, 1.00139201e-01f, -8.85636285e-02f, 3.58002819e-02f, -4.91031967e-02f, -9.17837024e-02f, -2.35952903e-02f, 6.12421297e-02f,
  -1.60204306e-01f, 1.56177089e-01f, 3.45399231e-02f, -8.01080763e-02f, 1.69737816e-01f, 1.31524071e-01f, -2.90080998e-02f, 2.17667237e-01f, 2.67446071e-01f, -8.88221785e-02f,
  7.27975145e-02f, -6.11041971e-02f, 1.70928657e-01f, 1.57662809e-01f, -1.01631097e-01f, -1.57424793e-01f, 6.06497377e-02f, 3.45047154e-02f, -1.08418673e-01f, 1.57407865e-01f,
  1.63245983e-02f, -1.38573006e-01f, 1.95400029e-01f, -2.03948412e-02f, 2.80313008e-02f, -2.21786544e-01f, 1.05965517e-01f, 6.13956228e-02f, -4.83054370e-02f, 1.94605470e-01f,
  1.23016469e-01f, -6.29080785e-03f, 5.23407543e-05f, 4.51691709e-02f, -2.21326515e-01f, -1.72975302e-01f, 2.78452724e-01f, -5.29584326e-02f, -5.88737726e-02f, -9.26119983e-02f,
  -9.61530115e-03f, 4.11372073e-02f, -9.30866878e-03f, 1.23006389e-01f, 5.54088354e-02f, 2.02974901e-01f, -2.01845374e-02f, 6.18775822e-02f, -1.59954995e-01f, 5.66283762e-02f,
  6.50467426e-02f, 2.75625497e-01f, 2.22927257e-01f, -1.63404256e-01f, -1.05865277e-01f, 6.58651888e-02f, 2.11074263e-01f, 2.32728735e-01f, 5.26415668e-02f, 4.96667549e-02f,
  8.51337537e-02f, -6.48990199e-02f, -1.36310637e-01f, 1.76027551e-01f, -1.55447543e-01f, 1.44156605e-01f, 1.01105146e-01f, 3.99095528e-02f, -1.39779493e-01f, 4.03923132e-02f,
  1.82922166e-02f, 2.09957495e-01f, 2.25780800e-01f, 2.33978871e-02f, 8.08005631e-02f, 6.73945695e-02f, 1.57825813e-01f, 3.11719805e-01f, 4.04539518e-02f, 1.70541987e-01f,
  1.57462105e-01f, 8.48173648e-02f, 1.48383528e-01f, 3.62327918e-02f, 9.57823917e-02f, -2.82448810e-02f, -5.08622527e-02f, -1.05883919e-01f, 7.34976307e-02f, 6.42372891e-02f,
  -8.45894441e-02f, -1.52530428e-02f, -4.31749097e-04f, 8.24556798e-02f, -1.04601331e-01f, 9.02653858e-02f, 8.93158391e-02f, -1.57891572e-01f, -1.23726360e-01f, 2.19227329e-01f,
  6.94213854e-03f, -2.54842546e-03f, -5.45008704e-02f, 1.22505449e-01f, -1.90827791e-02f, -3.09295300e-02f, -3.08879539e-02f, -1.06306858e-01f, 2.34733056e-02f, -1.55230267e-02f,
  -1.26024380e-01f, -3.52337323e-02f, 6.80686384e-02f, -6.27181679e-02f, -1.48821101e-01f, 5.57729229e-02f, 2.15417117e-01f, -2.16471143e-02f, 2.29729451e-02f, 1.24132903e-02f,
  -2.36123148e-03f, -1.04905084e-01f, 5.49694374e-02f, -8.15954432e-02f, -1.46624014e-01f, 2.20456608e-02f, 8.19761977e-02f, 2.73829065e-02f, 3.67056280e-02f, 3.99767943e-02f,
  -2.78772172e-02f, 2.68252790e-01f, -5.31282090e-03f, 2.54779130e-01f, -1.22782759e-01f, 5.08352183e-02f, 1.81806371e-01f, 1.38873905e-02f, 3.66061218e-02f, -3.18126306e-02f,
  9.05689746e-02f, -6.10718727e-02f, -1.31340828e-02f, -8.62115771e-02f, 9.65390280e-02f, 3.35939508e-03f, 8.00616667e-02f, 2.19744183e-02f, -1.11783259e-01f, 6.00622743e-02f,
  2.36891452e-02f, -6.04776293e-02f, -4.02169079e-02f, 1.00536518e-01f, -8.07263702e-02f, 2.20990594e-04f, 1.88065559e-01f, 6.03767298e-03f, 2.80720323e-01f, -2.24361435e-01f,
  1.89208582e-01f, 1.26157120e-01f, 2.27236569e-01f, -1.82914987e-01f, -4.41676788e-02f, 2.53487915e-01f, 2.74931431e-01f, -5.96387796e-02f, -1.57768950e-01f, 1.82114288e-01f,
  3.46514247e-02f, -2.38849893e-02f, 1.43018126e-01f, 7.79455453e-02f, 1.64488271e-01f, -8.20291713e-02f, -4.10893485e-02f, 1.50915338e-02f, 3.14767420e-01f, 7.74492789e-03f,
  7.90880248e-03f, 5.72801307e-02f, -2.76538372e-01f, -8.11911300e-02f, 1.49757743e-01f, -9.88629162e-02f, 1.05293013e-01f, 8.81221592e-02f, 2.06742302e-01f, 2.34321617e-02f,
  2.97698587e-01f, -1.25268549e-01f, -1.81459695e-01f, 1.21086784e-01f, 2.97416523e-02f, -1.53781414e-01f, 7.74623081e-02f, -1.53858230e-01f, 9.34012160e-02f, 5.05534112e-02f,
  -5.26253656e-02f, -6.62209764e-02f, 6.44943267e-02f, -6.04666620e-02f, 1.92142874e-02f, 2.26160996e-02f, 1.47223815e-01f, 5.45015857e-02f, 6.98956549e-02f, 7.53420368e-02f,
  1.32835731e-01f, 1.32951164e-03f, 8.20695236e-02f, -6.74838647e-02f, 4.05519903e-02f, -6.78804219e-02f, -6.94137588e-02f, 2.15716109e-01f, -1.59148097e-01f, -8.10532644e-03f,
  3.41699384e-02f, -3.12465206e-02f, -2.80097704e-02f, -5.40530086e-02f, 1.00515954e-01f, -1.38446480e-01f, 1.03437789e-02f, 9.10843983e-02f, -9.03863832e-02f, 4.37651016e-03f,
  1.56164378e-01f, 1.57212973e-01f, -2.02497259e-01f, -6.40749782e-02f, -2.45162118e-02f, -6.81512952e-02f, 1.40691206e-01f, 1.63614731e-02f, -1.10462895e-02f, -7.24321231e-02f,
  2.31415868e-01f, -1.18748069e-01f, 1.04792617e-01f, 9.81444493e-02f, -2.36472897e-02f, -6.18008375e-02f, -5.94311915e-02f, 3.50270085e-02f, 5.41436560e-02f, -1.11080192e-01f,
  1.47994205e-01f, 4.56701219e-02f, -3.05463374e-02f, -7.10998699e-02f, 2.06010789e-01f, -1.72331929e-01f, -1.13786682e-01f, 8.81449655e-02f, 4.54401970e-02f, -9.45239067e-02f,
  3.96703742e-03f, 2.14382485e-01f, 8.55353847e-02f, -1.23015717e-01f, 1.67007536e-01f, 1.57449052e-01f, -4.39300276e-02f, -8.52711722e-02f, -2.59987470e-02f, -6.87694773e-02f,
  1.16625234e-01f, 1.45435199e-01f, 1.36277884e-01f, 7.57923722e-02f, 9.53817293e-02f, 9.22688097e-02f, 1.86424568e-01f, -1.86442569e-01f, -1.48242246e-02f, -1.08057953e-01f,
  1.68427855e-01f, 3.79422456e-02f, 8.49051028e-02f, 5.38015887e-02f, 8.87869522e-02f, 1.31085128e-01f, -1.82345554e-01f, -5.93273677e-02f, 3.70513760e-02f, -9.43962708e-02f,
  -1.81973368e-01f, -2.02271063e-02f, 1.45345807e-01f, 7.98385963e-02f, -2.72322316e-02f, 1.09416157e-01f, 1.01391360e-01f, 9.03459918e-03f, -8.51774737e-02f, -6.80976640e-03f,
  -5.05168363e-03f, -1.82475820e-02f, 7.40383938e-03f, 1.69332281e-01f, 9.68941152e-02f, 3.08536030e-02f, -2.17744976e-01f, 1.19682658e-03f, -1.00781932e-01f, 9.58340615e-02f,
  6.83043301e-02f, 2.04734299e-02f, 2.26210117e-01f, 1.78545907e-01f, -6.55199364e-02f, -9.18923877e-03f, -8.79423171e-02f, -9.02454779e-02f, -7.59953037e-02f, -8.46425444e-02f,
  -2.57636886e-02f, 8.38000886e-03f, 9.96341482e-02f, 9.59819555e-02f, 5.26685044e-02f, 9.37580690e-02f, 6.01136126e-02f, 2.57020444e-01f, 2.91850924e-01f, 3.68859917e-02f,
  3.78823318e-02f, -1.61895037e-01f, 1.65048435e-01f, 5.82964532e-02f, -1.44876152e-01f, -1.02534138e-01f, 7.76559636e-02f, -1.24454312e-01f, -7.88747445e-02f, -1.49160355e-01f,
  -1.80565882e-02f, 1.52733997e-01f, 9.69159305e-02f, 1.37985393e-01f, -1.59650147e-01f, 5.44253774e-02f, -1.04615964e-01f, 5.97935170e-02f, -1.82317682e-02f, -1.68561172e-02f,
  1.41667062e-02f, -1.43171370e-01f, -2.30683498e-02f, -1.29059365e-03f, 2.55781207e-02f, -8.32290724e-02f, 5.92980981e-02f, 1.51726753e-01f, 9.20303166e-02f, 5.33117773e-03f,
  4.89645228e-02f, -1.24702089e-01f, 7.02625737e-02f, 9.54913795e-02f, 6.10276684e-02f, 7.54728764e-02f, 1.52301550e-01f, -5.49764261e-02f, -3.11475936e-02f, -1.77303463e-01f,
  1.19927108e-01f, 2.71215707e-01f, 4.72509228e-02f, -2.32399955e-01f, -1.91204876e-01f, -8.16199258e-02f, 1.12698205e-01f, 5.83919957e-02f, 1.20268531e-01f, -1.29875168e-01f,
  2.51779348e-01f, -1.97121412e-01f, 2.07243845e-01f, 9.09683574e-03f, -1.04486242e-01f, -2.54351944e-02f, -1.59145892e-01f, 6.43529445e-02f, -1.50254413e-01f, 4.88414951e-02f,
  3.59133273e-01f, 3.85641232e-02f, 1.16522042e-02f, 1.17399268e-01f, 1.39703512e-01f, 1.36026600e-02f, -8.81269500e-02f, 7.82838315e-02f, 1.73316747e-02f, -1.34120211e-01f,
  -1.44442488e-02f, 4.64693122e-02f, -4.83525768e-02f, -7.65467733e-02f, -3.91773283e-02f, -3.48748751e-02f, 5.23857251e-02f, -5.59901111e-02f, -1.30670294e-01f, 1.93721335e-02f,
  -9.49416086e-02f, 4.89363596e-02f, -3.20672810e-01f, 3.24107081e-01f, -3.52672720e-03f, 1.99548095e-01f, 2.29818095e-02f, -6.95866346e-02f, 2.32159663e-02f, 5.73445633e-02f,
  1.44042298e-01f, -1.85372308e-01f, -1.03392035e-01f, 1.46505579e-01f, 1.26985222e-01f, -1.00023411e-01f, -8.67713317e-02f, 2.74928305e-02f, -5.13049774e-03f, -2.93678064e-02f,
  -2.07653269e-01f, -1.23144493e-01f, -1.22455105e-01f, -6.20511919e-02f, -2.21971446e-03f, 2.44753361e-01f, 2.47568190e-01f, -9.61832628e-02f, 1.20773204e-01f, 2.48349458e-01f,
  -5.90411909e-02f, 6.69521466e-02f, 1.13147803e-01f, 4.77286149e-03f, -5.82626723e-02f, 5.67966960e-02f, -2.07647517e-01f, 1.55633807e-01f, 5.31709753e-02f, 1.09024711e-01f,
  1.69360131e-01f, 1.40742287e-01f, -2.50750601e-01f, 1.77248061e-01f, -2.61965811e-01f, -1.75626457e-01f, 4.16211449e-02f, 4.12809812e-02f, 2.61344045e-01f, 2.16728076e-02f,
  1.23435277e-02f, 1.19596735e-01f, 1.95723474e-01f, 1.11013852e-01f, 1.23741537e-01f, 1.77048389e-02f, -1.32865487e-02f, 9.55144167e-02f, -4.13843393e-02f, -3.01131755e-02f,
  1.64171696e-01f, -1.04597002e-01f, 1.15612328e-01f, -1.14031266e-02f, -7.53854364e-02f, 5.66860922e-02f, 5.84497191e-02f, 4.58098128e-02f, 1.66749343e-01f, -2.25068390e-01f,
  2.82220006e-01f, -6.83120340e-02f, 1.61625519e-01f, -2.39617601e-01f, 1.35303244e-01f, 1.49236530e-01f, 1.65716141e-01f, 3.11918724e-02f, -2.30825812e-01f, 1.36214837e-01f,
  -2.17468649e-01f, -1.61918327e-01f, 9.66313332e-02f, 9.74495858e-02f, -1.19651277e-02f, -1.23615377e-01f, -5.47245853e-02f, -1.30106047e-01f, -4.31724377e-02f, -9.54810753e-02f,
  -4.18714136e-02f, 1.17666885e-01f, -1.76819161e-01f, 1.00138508e-01f, 1.81469947e-01f, -2.20042527e-01f, 5.55621199e-02f, 5.17297685e-02f, 9.62156132e-02f, 1.31363109e-01f,
  1.14201300e-01f, -9.30875987e-02f, 5.19661047e-02f, 1.51497141e-01f, -6.27387837e-02f, -2.36344606e-01f, 1.29170567e-01f, -5.94320558e-02f, -3.05915177e-01f, 1.19302459e-01f,
  1.24753587e-01f, -1.41760021e-01f, 6.61350489e-02f, 7.14469552e-02f, 6.96678236e-02f, 4.64321114e-02f, 1.37669846e-01f, -3.28625180e-02f, 1.09731197e-01f, 1.59488022e-01f,
  2.83433292e-02f, 2.36861072e-02f, -1.06429927e-01f, -1.11826703e-01f, 1.57401953e-02f, 9.15669054e-02f, -9.10014585e-02f, -2.07296815e-02f, 9.62571800e-02f, 1.16905466e-01f,
  8.44212133e-04f, 4.19305265e-02f, 1.71746776e-01f, 4.74157743e-02f, 2.21188635e-01f, 1.00524530e-01f, 3.14321429e-01f, -6.23376854e-02f, -3.75342444e-02f, -4.75502834e-02f,
  1.17913239e-01f, 3.63044776e-02f, -1.01107173e-01f, -9.48965922e-03f, -8.63094628e-02f, 5.00639901e-02f, 3.20884511e-02f, -5.39740957e-02f, -7.50745758e-02f, -1.40566543e-01f,
  1.36831207e-02f, -2.34400239e-02f, 8.34881235e-03f, 6.48102015e-02f, -8.92376527e-03f, 2.08782241e-01f, 2.12870061e-01f, 2.70210892e-01f, 2.82377973e-02f, -6.60147741e-02f,
  1.30338624e-01f, 1.67704195e-01f, -5.91653846e-02f, 3.33408535e-01f, -8.03418383e-02f, 2.52562284e-01f, 2.08894536e-01f, 1.54632643e-01f, 2.83452213e-01f, -2.57609338e-01f,
  -6.56396076e-02f, 5.29435724e-02f, -3.04019481e-01f, -1.38121247e-01f, -1.86472490e-01f, 7.50501528e-02f, -2.79495232e-02f, 2.96796620e-01f, -1.27120884e-02f, 1.42933220e-01f,
  1.96016803e-01f, 8.98245201e-02f, 1.44088209e-01f, 1.15505774e-02f, 7.51212519e-03f, -5.15327491e-02f, -1.00472346e-01f, -1.51488319e-01f, 8.24310109e-02f, -5.92819639e-02f,
  1.18914716e-01f, 7.91517124e-02f, 4.62716538e-03f, -3.93830100e-03f, -1.86266482e-01f, 1.28288731e-01f, -3.12977694e-02f, -3.02355736e-02f, 3.14684838e-01f, 3.23210657e-02f,
  2.30414703e-01f, -5.63961007e-02f, 1.34951606e-01f, 4.19885889e-02f, -5.11133783e-02f, 4.59824428e-02f, -1.50683895e-02f, -3.75712141e-02f, 6.80245236e-02f, -1.91285014e-02f,
  1.29370883e-01f, 2.84884036e-01f, -1.65677428e-01f, -4.72934283e-02f, 9.24962237e-02f, -1.81547448e-01f, -5.20916022e-02f, -1.11907735e-01f, 5.47389276e-02f, -2.37479107e-03f,
  5.04548028e-02f, 3.12696993e-01f, -4.97790519e-03f, -1.38852850e-01f, 5.63087780e-03f, -5.48080727e-02f, 4.65279445e-02f, -3.54451723e-02f, 2.38064975e-02f, 3.30093801e-02f,
  9.17858481e-02f, 4.59166318e-02f, 2.65147910e-02f, -2.47403219e-01f, 2.56197751e-02f, 1.64042935e-01f, -2.30716079e-01f, 5.45666851e-02f, 4.02380265e-02f, 5.44741191e-02f,
  1.21694960e-01f, 2.10702881e-01f, 9.41392258e-02f, 1.12677537e-01f, 1.56193793e-01f, 2.43690476e-01f, 1.22167736e-01f, -9.76321567e-03f, 1.24594368e-01f, 1.88180774e-01f,
  1.06618576e-01f, -2.87720747e-02f, -1.60723031e-01f, -1.10921517e-01f, 1.79733634e-01f, -1.49458930e-01f, 1.93747729e-01f, -2.34853067e-02f, 9.78539065e-02f, -1.69369683e-01f,
  -2.76690554e-02f, 1.68132991e-01f, -2.30252501e-02f, 2.39353240e-01f, -2.01505087e-02f, 1.77548170e-01f, 1.04353689e-02f, -1.48433864e-01f, 4.42999043e-02f, 1.87823176e-01f,
  1.36726409e-01f, -4.58530113e-02f, 1.60999313e-01f, 7.43024349e-02f, 1.66125119e-01f, 7.37822950e-02f, -1.60604358e-01f, 3.21158171e-02f, 2.36815751e-01f, -5.28018847e-02f,
  -6.94750398e-02f, -1.00566380e-01f, 7.39937574e-02f, 4.13934514e-02f, 1.05051957e-01f, 3.05114146e-02f, -2.59869754e-01f, -1.81713477e-02f, -8.95377398e-02f, -9.37347859e-02f,
  8.67952630e-02f, 7.41060078e-02f, -4.44567278e-02f, -6.85564056e-02f, 1.13435172e-01f, -5.35072200e-02f, 1.17105357e-01f, 1.01063780e-01f, 5.78396134e-02f, 1.96861416e-01f,
  -1.55869797e-01f, 8.19040611e-02f, 1.02114774e-01f, 5.92706539e-02f, -2.88873523e-01f, 6.39801398e-02f, -1.07827939e-01f, -1.20891534e-01f, 8.43915716e-02f, 1.56588882e-01f,
  8.77216384e-02f, 2.57052686e-02f, -1.07180448e-02f, 1.66134298e-01f, 1.74798936e-01f, -1.13986462e-01f, -2.01706558e-01f, -1.47899941e-01f, 1.66216135e-01f, -1.39888018e-01f,
  2.21903548e-01f, 3.63088138e-02f, 1.90136760e-01f, -1.19994149e-01f, 1.60632461e-01f, -2.73387730e-02f, 3.59323397e-02f, 2.11958036e-01f, -2.37823337e-01f, 1.05742134e-01f,
  2.47322507e-02f, -2.22754136e-01f, -4.46403697e-02f, -4.07637749e-03f, 7.71864355e-02f, 7.59477168e-02f, 6.68279976e-02f, 3.29951465e-04f, 3.65577564e-02f, 5.57812713e-02f,
  2.48890314e-02f, 1.33808434e-01f, 1.21683575e-01f, 1.07496649e-01f, -3.04673556e-02f, -2.98364405e-02f, -2.31263135e-02f, -8.72667059e-02f, -2.42209584e-02f, 6.98710456e-02f,
  -1.38682619e-01f, 1.62146911e-01f, -1.97682992e-01f, -1.37470141e-01f, 2.01452971e-01f, -5.42565025e-02f, -1.03481509e-01f, -4.66133431e-02f, -1.30213559e-01f, -8.20331834e-03f,
  -9.30595845e-02f, 4.07396257e-02f, 2.03465879e-01f, -3.45991068e-02f, 3.02096158e-02f, 2.00707614e-01f, 1.62636966e-01f, -1.09060325e-01f, -1.98309794e-01f, 9.95790586e-02f,
  -5.17496988e-02f, -1.42468363e-01f, 1.80367827e-02f, 1.48212135e-01f, 7.27970526e-02f, 8.83382335e-02f, -1.43557480e-02f, 7.67453834e-02f, 8.56509805e-02f, -8.63188356e-02f,
  -1.10499924e-02f, 7.23275021e-02f, -9.08534750e-02f, -5.33175515e-03f, -2.97321845e-02f, 1.08847454e-01f, 1.49385825e-01f, -2.77552791e-02f, -1.89127680e-02f, 4.74343263e-02f,
  -1.61932632e-02f, 6.96079358e-02f, 5.57917431e-02f, 1.50779888e-01f, -9.32700261e-02f, 4.14910167e-03f, 2.93976683e-02f, 2.16632232e-01f, -6.35685995e-02f, -9.29000601e-02f,
  2.28040576e-01f, 1.51840180e-01f, 1.22218102e-01f, 8.43736902e-02f, -6.92325532e-02f, -1.71778668e-02f, 2.24652290e-01f, -8.28322992e-02f, 8.56562853e-02f, 1.78883284e-01f,
  1.10084236e-01f, -1.49004489e-01f, -1.02155283e-02f, -8.20124298e-02f, -1.59465969e-01f, 6.22130837e-03f, 2.03168094e-02f, 4.28372994e-02f, 1.82479769e-01f, 9.14954767e-02f,
  1.44401476e-01f, -5.42992912e-02f, -9.95775685e-03f, 1.02843605e-01f, 8.31327736e-02f, 7.44075142e-03f, -1.23356260e-01f, 8.29686597e-02f, 1.93476856e-01f, -5.78176565e-02f,
  -5.14386557e-02f, 2.04486728e-01f, -2.25783214e-01f, 1.49260173e-02f, -5.62150590e-03f, -1.09229393e-01f, 1.05832461e-02f, -1.06020488e-01f, 3.04495655e-02f, 9.82279480e-02f,
  1.03682116e-01f, 1.06875367e-01f, 1.05048969e-01f, -6.13909811e-02f, -1.10701010e-01f, 2.19376087e-02f, -1.82239339e-01f, 2.96926475e-03f, 1.20561518e-01f, 1.42370716e-01f,
  2.32289642e-01f, 2.22064778e-02f, -3.83706801e-02f, 4.48792651e-02f, -8.23744852e-03f, -6.82999985e-03f, 5.05377613e-02f, -5.03655449e-02f, -5.02174571e-02f, 1.14981987e-01f,
  -7.72442743e-02f, 1.69641599e-01f, -5.65306209e-02f, 1.75849929e-01f, -8.19602385e-02f, 5.75111993e-02f, 9.12933946e-02f, -2.40127295e-01f, 2.93081626e-02f, 1.47979423e-01f,
  -3.93024348e-02f, 2.08451554e-01f, -1.53416038e-01f, -4.96055633e-02f, -6.52619079e-02f, 2.72427410e-01f, 3.36240083e-02f, -1.01310514e-01f, 6.89758360e-03f, 1.95301678e-02f,
  1.93649530e-01f, 3.47844541e-01f, -2.27981597e-01f, 2.16093242e-01f, -6.47731870e-02f, -2.19260249e-02f, 4.95213196e-02f, 1.45862758e-01f, 1.59244284e-01f, -1.20453320e-01f,
  7.93711692e-02f, -6.64151758e-02f, -6.45460337e-02f, 8.18671659e-02f, 2.43269075e-02f, 8.30470324e-02f, -1.81847334e-01f, -1.48522304e-02f, 4.72609699e-02f, 4.73956876e-02f,
  2.02027842e-01f, 1.78155899e-01f, 1.07328467e-01f, 1.52157769e-01f, 1.08726121e-01f, 7.33442931e-03f, 2.18656510e-01f, -2.50006944e-01f, -1.99404582e-02f, -6.47071451e-02f,
  1.01114132e-01f, -2.24003438e-02f, 8.34635943e-02f, 6.02394082e-02f, -5.60481772e-02f, 1.44243136e-01f, -2.36912802e-01f, 7.07259253e-02f, 3.82295959e-02f, 4.09646146e-02f,
  -4.15884666e-02f, 6.61784634e-02f, -4.83371597e-03f, -1.99297547e-01f, -1.37183368e-01f, 8.22623074e-02f, 9.63588059e-02f, -8.12321529e-03f, -5.56131154e-02f, -8.00467804e-02f,
  -4.29462492e-02f, 7.66397342e-02f, -4.18713316e-02f, 1.09375246e-01f, 2.63334572e-01f, 4.70332429e-02f, -2.11342528e-01f, -1.22039020e-01f, -8.50955173e-02f, 5.22674918e-02f,
  2.67615020e-01f, 1.20835446e-01f, 1.25878856e-01f, 1.01818472e-01f, -2.62926240e-02f, 1.52300462e-01f, -6.66595846e-02f, 5.57292998e-02f, -7.72076026e-02f, -6.74401447e-02f,
  6.65635914e-02f, 1.91756748e-02f, 8.71543661e-02f, -1.80289093e-02f, 1.60484493e-01f, 2.34655380e-01f, -8.82844403e-02f, 1.93475392e-02f, 2.07762703e-01f, 1.31512627e-01f,
  -5.52041195e-02f, 2.66319998e-02f, 1.48905277e-01f, 3.49200256e-02f, -1.20578848e-01f, -1.73881218e-01f, 7.66141415e-02f, -9.04399715e-03f, -4.17321920e-02f, -3.60869709e-03f,
  8.37463513e-02f, -6.86761513e-02f, 2.31974542e-01f, 6.06290698e-02f, -1.07194632e-01f, 5.91082163e-02f, -9.85406488e-02f, 2.00289205e-01f, 9.21377614e-02f, 2.74643600e-01f,
  -1.34282216e-01f, -2.53395699e-02f, 8.41429010e-02f, -1.93826318e-01f, -1.49295747e-01f, -1.21543162e-01f, 1.62814006e-01f, 2.94292629e-01f, -1.09130396e-02f, -4.08813469e-02f,
  -1.65215321e-02f, -1.98488161e-02f, -1.70607820e-01f, -5.62539808e-02f, 1.47569582e-01f, -2.13417951e-02f, 8.70828032e-02f, 1.16266966e-01f, 6.51951581e-02f, -1.06108807e-01f,
  9.06385258e-02f, 2.52267689e-01f, -5.19300327e-02f, -8.46493319e-02f, -1.04304954e-01f, 6.90948069e-02f, 2.80024081e-01f, 1.92518085e-01f, 1.78386569e-02f, 4.76815179e-02f,
  7.42668100e-03f, -6.55750483e-02f, 9.68266055e-02f, -2.11500488e-02f, -9.76214930e-02f, 1.84605703e-01f, -3.96056138e-02f, 1.38669208e-01f, -1.46962389e-01f, 1.15585841e-01f,
  2.83516288e-01f, 1.32409185e-01f, 2.83910483e-01f, 1.15969673e-01f, 2.33875945e-01f, -1.68715939e-01f, 1.58282936e-01f, 1.70037404e-01f, -8.69411379e-02f, 9.36340261e-03f,
  5.10960296e-02f, 3.21056470e-02f, 2.21451163e-01f, 8.06684047e-02f, 1.71758413e-01f, 3.69767398e-02f, -1.77325532e-01f, 5.22374846e-02f, -1.39572635e-01f, 9.36197490e-02f,
  -3.44039649e-02f, -6.24833889e-02f, 1.77909762e-01f, 2.19814889e-02f, -6.32104501e-02f, 1.30987585e-01f, -1.81731656e-01f, -1.04355723e-01f, -1.07155569e-01f, 8.05171058e-02f,
  -1.02413386e-01f, 8.19964930e-02f, -1.53179644e-02f, 7.72681385e-02f, -5.47995977e-03f, 1.77010581e-01f, -8.37704763e-02f, -1.59659702e-02f, 4.65929769e-02f, -2.09299892e-01f,
  1.43038705e-01f, 1.41441032e-01f, 2.11274877e-01f, 1.57040849e-01f, 2.89172772e-02f, 9.32427198e-02f, 1.67043015e-01f, 1.52075797e-01f, -5.50608784e-02f, -9.91581082e-02f,
  1.82679519e-01f, 1.09941483e-01f, 2.60773122e-01f, 2.53469914e-01f, -8.80243629e-02f, 2.15363503e-01f, 8.72355923e-02f, -9.77743641e-02f, -5.19041643e-02f, 1.84092969e-01f,
  1.15993597e-01f, 2.95120180e-01f, 4.98587452e-02f, 1.30192414e-01f, 1.84481934e-01f, 1.31543800e-01f, 6.38122186e-02f, 2.21746147e-01f, -2.91444454e-02f, -1.43576443e-01f,
  1.17657274e-01f, -1.38030527e-02f, 8.04361030e-02f, 2.17729788e-02f, 5.46595268e-02f, 4.61727194e-03f, -1.54892029e-02f, 5.54592684e-02f, -4.34811972e-02f, -7.92379156e-02f,
  -1.16301223e-03f, -3.91507857e-02f, 1.48461223e-01f, -1.69321120e-01f, 2.28330642e-01f, 3.29500474e-02f, -2.43693292e-02f, -1.09278010e-02f, 1.38630748e-01f, 3.77092510e-02f,
  1.57244787e-01f, 2.41962999e-01f, -9.78889093e-02f, -1.47447467e-01f, 1.46727979e-01f, -1.13819540e-01f, -1.46884441e-01f, -1.24741934e-01f, 2.02119380e-01f, 5.52923419e-02f,
  1.11022331e-01f, 8.12974200e-02f, -1.29231200e-01f, 2.84978211e-01f, -2.75191702e-02f, 9.52242911e-02f, -1.64440736e-01f, 1.68525368e-01f, 7.59570897e-02f, -9.67863202e-03f,
  6.01924583e-03f, -8.28584805e-02f, 4.89259362e-02f, 1.19308390e-01f, 3.65215763e-02f, 1.11549497e-01f, -1.86665639e-01f, -1.34024650e-01f, 1.93932682e-01f, -1.11480303e-01f,
  -6.17091134e-02f, 7.82136992e-02f, -2.21324563e-01f, -1.06728047e-01f, -4.61916141e-02f, -2.35294923e-01f, 5.59110716e-02f, -8.43407810e-02f, -3.13006602e-02f, 1.84812501e-01f,
  8.91778767e-02f, -2.32610971e-01f, -4.39896211e-02f, 1.88967109e-01f, 3.66310887e-02f, -5.93162104e-02f, -2.51039304e-02f, 9.64060351e-02f, 5.46998344e-02f, 1.26262441e-01f,
  -2.48776283e-02f, 5.55555895e-02f, 1.56132966e-01f, -8.70236531e-02f, -1.26750723e-01f, 2.06272993e-02f, 4.28306870e-02f, -1.26960248e-01f, 1.70489877e-01f, 2.15642154e-01f,
  2.07233071e-01f, -1.18409261e-01f, -1.62183657e-01f, 4.06357348e-02f, -8.50113183e-02f, 1.33301541e-01f, -2.06133261e-01f, 6.08770363e-02f, 1.63910966e-02f, 3.08135748e-02f,
  -2.65613079e-01f, -4.64693680e-02f, 2.00839624e-01f, 4.67950776e-02f, 1.77805528e-01f, 1.75457418e-01f, 1.35284230e-01f, 1.25028074e-01f, -3.62009071e-02f, 1.08640902e-01f,
  1.14279956e-01f, 7.20152557e-02f, -1.69194698e-01f, -8.60880762e-02f, 7.71803036e-03f, -2.94132978e-02f, 1.29725412e-01f, 4.19676267e-02f, 2.96009779e-02f, 2.33343735e-01f,
  -1.07697636e-01f, -4.07238267e-02f, 4.58566882e-02f, -6.36966079e-02f, -7.11725652e-02f, 8.87284875e-02f, -1.95475724e-02f, -1.95763424e-01f, -1.26069054e-01f, 3.32174115e-02f,
  6.92636222e-02f, -1.66157298e-02f, 7.34039247e-02f, 2.02709794e-01f, 1.56969696e-01f, -2.65163984e-02f, -2.36845121e-01f, 1.45077407e-01f, -1.33927301e-01f, 1.86464898e-02f,
  4.37674746e-02f, 9.31231230e-02f, 9.68284011e-02f, -7.59962052e-02f, 3.73940766e-02f, 6.48856983e-02f, 7.90682733e-02f, -4.30257656e-02f, -6.99051246e-02f, -1.39115542e-01f,
  9.36957449e-02f, 1.96187962e-02f, -1.69192553e-01f, -1.79247603e-01f, 1.87318828e-02f, 1.15938246e-01f, -2.56258193e-02f, -8.16874206e-02f, -3.96546209e-03f, -3.50300819e-02f,
  -1.62139460e-01f, 1.91501394e-01f, 8.21732432e-02f, -4.41116728e-02f, 1.54849112e-01f, 1.15334630e-01f, -1.37528926e-02f, 1.74333323e-02f, -5.07778563e-02f, -1.49873167e-01f,
  1.32990628e-01f, -1.91829633e-02f, -1.56008955e-02f, -8.60561710e-03f, 1.35260850e-01f, -1.99242290e-02f, 1.21999763e-01f, 8.98256898e-02f, 1.66996613e-01f, -9.99737009e-02f,
  -7.20385090e-02f, -1.67488188e-01f, -3.92498681e-03f, -7.46729895e-02f, 9.69043672e-02f, -1.54445127e-01f, 3.76598747e-03f, -9.38041359e-02f, 2.19618857e-01f, -1.97616681e-01f,
  -1.54570103e-01f, 1.31460667e-01f, -1.35248289e-01f, 2.73231745e-01f, -7.71585181e-02f, 1.23281091e-01f, 2.10280657e-01f, 1.87516529e-02f, 1.92978486e-01f, 1.73278004e-01f,
  1.44840539e-01f, -2.57083505e-01f, 1.30346417e-01f, -7.16889426e-02f, 1.40262932e-01f, 5.03252074e-02f, 3.87509093e-02f, 4.64263279e-03f, 3.86926606e-02f, 2.65263394e-02f,
  7.19999894e-02f, -1.01265490e-01f, 1.11087956e-01f, 2.91977916e-02f, -2.33328924e-01f, 1.29211351e-01f, -2.56743342e-01f, -4.26937044e-02f, 2.84519810e-02f, 4.04664129e-02f,
  -1.18873827e-01f, -4.78489026e-02f, -2.69652139e-02f, -2.45944947e-01f, 6.55072108e-02f, -2.34297030e-02f, -9.48564261e-02f, 1.44464653e-02f, 6.39737025e-02f, 2.61368573e-01f,
  -1.54347137e-01f, -1.37029588e-01f, -7.46601969e-02f, -8.78632963e-02f, 3.42331715e-02f, -2.80234963e-02f, -2.31487006e-02f, 5.57179078e-02f, 2.61694759e-01f, -1.72775254e-01f,
  3.73919979e-02f, 1.19830452e-01f, 1.48659363e-01f, -1.13935173e-01f, 4.30441648e-03f, -7.44986534e-02f, 9.79802683e-02f, -8.61428976e-02f, 1.32040218e-01f, 1.16359666e-01f,
  1.07048415e-02f, 3.47853601e-02f, 8.79238024e-02f, -3.91393341e-02f, -8.33719373e-02f, 1.15969226e-01f, 1.06835470e-01f, 4.83417884e-02f, -8.67038220e-02f, 2.49765024e-01f,
  2.50316054e-01f, 9.62810125e-03f, 1.56716928e-01f, 2.53220350e-01f, -1.60606392e-03f, -1.74812719e-01f, 1.45779967e-01f, 1.04944251e-01f, -3.40880291e-03f, -1.08701728e-01f,
  -1.20329469e-01f, 2.91755609e-03f, -3.58775705e-02f, -2.83384323e-02f, -1.83415189e-02f, -8.93992111e-02f, 5.40511385e-02f, 5.77850789e-02f, -1.28636107e-01f, 8.64939205e-03f,
  1.11518867e-01f, 1.63999274e-01f, -1.05764575e-01f, 1.71133146e-01f, -7.91900158e-02f, 1.26959503e-01f, 1.41929807e-02f, 1.44055620e-01f, -2.92115435e-02f, -1.05676673e-01f,
  3.56279872e-02f, -1.53594825e-03f, -1.10396177e-01f, 1.35181829e-01f, 4.19141948e-02f, -1.14062466e-01f, 2.30971780e-02f, 2.01142907e-01f, -1.53207213e-01f, -5.13834786e-03f,
  -4.54798080e-02f, -8.02832246e-02f, -1.79180026e-01f, 8.45529288e-02f, -4.20919098e-02f, 1.16174690e-01f, 1.04307584e-01f, -6.61130324e-02f, 1.32338613e-01f, 1.56518787e-01f,
  -3.47811840e-02f, 8.29885248e-03f, -4.10912000e-02f, 7.66781941e-02f, -1.09575763e-02f, 5.21576069e-02f, -1.51944339e-01f, 2.49817863e-01f, -4.64453474e-02f, -8.02142732e-03f,
  1.40447393e-01f, -1.50830196e-02f, -1.61884323e-01f, 1.07976563e-01f, -1.25688851e-01f, -1.13413729e-01f, -1.01861954e-02f, 1.13872513e-02f, -2.20911875e-02f, 2.27953494e-01f,
  7.84971006e-03f, 1.92058042e-01f, -3.52162980e-02f, 1.04606122e-01f, -2.06795316e-02f, -5.11231571e-02f, 2.03709621e-02f, -4.00132351e-02f, 1.54167954e-02f, -7.00161830e-02f,
  -1.46800786e-01f, -5.63646816e-02f, 8.80507529e-02f, -1.38581961e-01f, 2.10863292e-01f, -2.98568550e-02f, 1.56996384e-01f, -1.12318859e-01f, -6.32748753e-03f, 3.28465775e-02f,
  -3.10267806e-02f, 7.33573586e-02f, -1.72357440e-01f, -2.18026638e-02f, -3.62959504e-02f, -2.14593634e-01f, -9.83310565e-02f, -1.75832972e-01f, 1.88941404e-01f, 1.99316755e-01f,
  1.56111959e-02f, 4.47508134e-02f, -2.10989900e-02f, 7.84420781e-03f, 8.81443024e-02f, 2.03588486e-01f, -3.54809053e-02f, 1.88675955e-01f, 9.22435597e-02f, -1.02991156e-01f,
  -1.80536043e-02f, -1.98083743e-03f, 5.87559268e-02f, -4.52102683e-02f, -4.26079184e-02f, 1.97322756e-01f, -4.99869585e-02f, 3.40822153e-02f, 9.50104445e-02f, -2.62495223e-02f,
  -6.94560111e-02f, -1.27230972e-01f, -1.05932370e-01f, -9.52701345e-02f, -7.72162480e-03f, -2.42338255e-02f, 8.16097856e-02f, -1.19936727e-02f, 5.69926910e-02f, 9.08478126e-02f,
  1.82197653e-02f, -1.58877194e-01f, -1.29966348e-01f, 1.85707323e-02f, 5.74690588e-02f, -1.59767017e-01f, 7.55550489e-02f, -3.01328301e-02f, -3.93361971e-02f, 7.03620864e-03f,
  2.06225350e-01f, 1.23872295e-01f, -1.97696257e-02f, -1.37556084e-02f, -3.79239842e-02f, -5.62422164e-02f, -2.70423293e-02f, 1.71501130e-01f, -7.15765357e-02f, -1.08844168e-01f,
  8.81763920e-02f, 1.82381466e-01f, 9.33319256e-02f, 8.14849809e-02f, -4.58436320e-03f, -1.45488515e-01f, 1.26543581e-01f, 3.42825777e-03f, -1.07628293e-01f, 1.86399743e-01f,
  1.56418934e-01f, 1.32807359e-01f, -4.26175259e-02f, 1.03884786e-01f, -4.24043462e-02f, -7.12895766e-02f, 1.81043953e-01f, -2.04843864e-01f, -4.68725264e-02f, -1.29712271e-02f,
  6.49170801e-02f, 5.64831728e-03f, 5.34328520e-02f, 7.67591819e-02f, 1.70309931e-01f, 1.16645932e-01f, -7.72933289e-02f, -9.78497416e-02f, 6.49363324e-02f, -8.66788104e-02f,
  1.87743768e-01f, 1.96907848e-01f, -1.44240782e-01f, 1.54165179e-01f, 1.68302983e-01f, -8.58621076e-02f, 9.06533673e-02f, 1.20449737e-01f, 1.78230867e-01f, 7.79120848e-02f,
  -1.95254218e-02f, 1.06426388e-01f, 7.36222193e-02f, 4.71023172e-02f, 1.48978755e-01f, 1.73722357e-01f, 9.28628892e-02f, -1.24222785e-01f, 1.70677379e-01f, 4.14208099e-02f,
  7.35965222e-02f, 7.41654560e-02f, -7.32814847e-03f, -4.67920788e-02f, -8.50918517e-02f, -8.37178975e-02f, 1.18466072e-01f, -8.79415683e-03f, -6.30486310e-02f, 1.07500859e-01f,
  -1.23529747e-01f, 6.52025566e-02f, 9.29125547e-02f, 1.29572213e-01f, 1.41515449e-01f, -2.26663619e-01f, -2.59664834e-01f, 9.31904241e-02f, -1.30306914e-01f, 1.42389223e-01f,
  5.42929918e-02f, 2.33468100e-01f, -1.24098971e-01f, -9.16295946e-02f, -1.49685383e-01f, 2.22703680e-01f, 3.47622596e-02f, -2.23014187e-02f, 2.59016514e-01f, 5.97223788e-02f,
  1.30457073e-01f, 3.52590084e-02f, 9.74395052e-02f, 1.32692844e-01f, 1.50605246e-01f, 8.69194120e-02f, -9.88273248e-02f, 4.89659570e-02f, -7.56228389e-03f, -6.90053776e-02f,
  2.25899890e-01f, -3.21988612e-02f, -4.38328385e-02f, 5.69856092e-02f, 8.82617310e-02f, 1.61697567e-01f, 1.11731939e-01f, 1.47420680e-02f, 4.66871895e-02f, 8.52674805e-03f,
  7.11028129e-02f, 5.61637245e-02f, 1.37585908e-01f, -4.62483242e-02f, 1.58720091e-01f, 1.93098411e-01f, 2.30829909e-01f, -7.26849437e-02f, 3.07145994e-03f, 1.41728520e-01f,
  -2.44059056e-01f, -2.74076797e-02f, 3.22325081e-02f, -2.39402130e-01f, -1.85383037e-02f, 1.87977716e-01f, 1.03234947e-01f, 1.20078944e-01f, 1.53854728e-01f, 8.13486800e-02f,
  5.23551106e-02f, -2.87969224e-02f, -1.17842950e-01f, -6.21060617e-02f, 1.98359370e-01f, -1.54537067e-01f, -1.37522630e-02f, -3.49081531e-02f, 2.27988452e-01f, 7.99575895e-02f,
  2.26210386e-01f, -1.45209460e-02f, 7.86703359e-03f, 1.21508121e-01f, -4.23485301e-02f, -2.70321425e-02f, 1.26654040e-02f, -2.37879172e-01f, 1.14643328e-01f, -1.49262547e-01f,
  -5.82601652e-02f, 2.29468092e-01f, 1.20652784e-02f, -1.46659955e-01f, -3.68159227e-02f, 1.62833091e-02f, 4.22594249e-02f, 1.38756976e-01f, 1.69044837e-01f, 1.97885394e-01f,
  4.64753946e-03f, -6.86831400e-02f, 6.37102826e-03f, 8.37782398e-02f, -1.03733569e-01f, -1.27050221e-01f, 8.10240284e-02f, 3.94788757e-02f, 6.80677146e-02f, 2.01326579e-01f,
  4.21983236e-03f, 1.25260472e-01f, -2.72391532e-02f, -9.31818597e-03f, -1.24344960e-01f, 1.20450974e-01f, -1.71287023e-02f, 2.10786700e-01f, 2.41168663e-01f, -2.73906719e-02f,
  -1.51701048e-01f, 1.12967327e-01f, 1.80361867e-01f, -1.20452143e-01f, -1.60685584e-01f, -2.96349940e-03f, 1.75453871e-01f, -2.65564732e-02f, 4.96600755e-02f, 4.66505811e-02f,
  -1.93232875e-02f, 5.72075807e-02f, -4.93930019e-02f, 7.20942467e-02f, 7.21983537e-02f, 9.57314149e-02f, -1.60464108e-01f, 2.53123879e-01f, -6.91373274e-02f, -1.95461810e-02f,
  -1.27479987e-04f, 2.70924598e-01f, 6.91428110e-02f, -2.27735862e-01f, -2.50112295e-01f, 9.12154093e-02f, -1.05582759e-01f, -5.94641268e-02f, 9.40501317e-02f, 2.81113505e-01f,
  6.49413094e-02f, 3.16531211e-01f, -1.22437790e-01f, 1.27669126e-01f, 3.39839794e-02f, -9.96320844e-02f, 2.36692384e-01f, 2.19054013e-01f, 1.90828279e-01f, 8.74756649e-02f,
  2.57294681e-02f, -5.98585606e-02f, 1.06057711e-01f, -1.16871975e-01f, -2.28715166e-01f, 1.93579961e-02f, 9.07113180e-02f, 1.60404503e-01f, 1.92218736e-01f, -5.78279793e-03f,
  -3.58918905e-02f, 5.55783138e-02f, 1.08926453e-01f, 6.27480680e-03f, -7.81413820e-03f, 1.69230569e-02f, 1.94952652e-01f, 1.46458909e-01f, 2.32927039e-01f, -6.56759739e-03f,
  -9.11082327e-02f, 9.89047214e-02f, -1.12086967e-01f, -2.40797605e-02f, 2.48145089e-01f, -9.70054697e-03f, 7.44899660e-02f, 5.04467189e-02f, -2.05925569e-01f, 8.93187001e-02f,
  -1.89308658e-01f, 1.94807295e-02f, 1.42311871e-01f, 1.65447250e-01f, 8.93270150e-02f, 7.05639049e-02f, 1.01678990e-01f, 3.57432328e-02f, 2.59031565e-03f, 6.85822032e-03f,
  -1.47104874e-01f, -7.65415058e-02f, 2.22900108e-01f, 7.88012296e-02f, -5.67326206e-04f, -1.44741580e-01f, -4.93501611e-02f, 6.97581023e-02f, -1.42470580e-02f, -1.80049539e-02f,
  2.13159740e-01f, 5.71396947e-03f, 9.61173885e-03f, 2.28269756e-01f, -2.19158977e-02f, -1.00760095e-01f, 2.41714075e-01f, 4.61622812e-02f, 1.35440324e-02f, -6.74645556e-03f,
  4.01083194e-02f, -1.73434094e-01f, 2.26891786e-01f, 1.93763465e-01f, -1.12082846e-01f, -9.75794792e-02f, 2.32476026e-01f, -2.22095728e-01f, 5.02500460e-02f, 1.40530616e-01f,
  9.41732749e-02f, -1.66893438e-01f, -1.93420555e-02f, 2.75051128e-02f, -1.41636372e-01f, -2.23827913e-01f, -2.47629397e-02f, -2.61255354e-01f, 9.67183188e-02f, -9.22292992e-02f,
  1.56945765e-01f, -1.55881807e-01f, 1.28904074e-01f, 8.55930597e-02f, -1.06562890e-01f, 1.60224348e-01f, -2.95398571e-02f, 2.35888705e-01f, 5.35484627e-02f, -1.74161587e-02f,
  4.61581908e-02f, 1.56798307e-02f, 1.65281221e-01f, -9.50473100e-02f, 3.68379094e-02f, -2.29432538e-01f, -1.48594305e-01f, 1.14439443e-01f, -2.57497951e-02f, 6.77186921e-02f,
  1.09440736e-01f, 7.87205324e-02f, -3.76162045e-02f, 1.76563248e-01f, -2.87295341e-01f, 2.24774843e-03f, 8.28001499e-02f, 1.23935834e-01f, 1.18148014e-01f, 1.02918372e-02f,
  1.29761294e-01f, -4.71243449e-02f, 1.70501560e-01f, -3.12520098e-03f, -6.51219115e-02f, -1.26197450e-02f, 5.75663485e-02f, 2.37896249e-01f, -1.56796768e-01f, 4.99358661e-02f,
  2.36043464e-02f, -2.53930613e-02f, 9.38172713e-02f, 9.73921716e-02f, 2.33131535e-02f, -1.21684097e-01f, 7.49280602e-02f, -2.63514400e-01f, 8.80694687e-02f, -4.62323874e-02f,
  9.40045342e-03f, 1.66547179e-01f, -1.23172887e-01f, -6.30341321e-02f, 2.70770546e-02f, 3.29466283e-01f, 1.66136727e-01f, -3.19243222e-02f, -1.30401775e-01f, -1.09010264e-01f,
  1.33272007e-01f, 1.23912618e-01f, -3.16739559e-01f, 2.38593295e-01f, 3.99954282e-02f, -7.75699764e-02f, 3.38700086e-01f, 1.13903917e-02f, 7.24248961e-02f, 1.06601618e-01f,
  6.45407662e-02f, -3.52444164e-02f, -1.43273205e-01f, -1.45605747e-02f, -9.75419283e-02f, -9.30399224e-02f, -1.83052700e-02f, -9.25861821e-02f, 7.44752632e-03f, -1.59517422e-01f,
  -4.61296225e-03f, -5.88293485e-02f, 2.01073289e-02f, 3.78043507e-03f, 3.30491215e-02f, 8.22089165e-02f, 7.86363855e-02f, -8.54316950e-02f, -1.58971116e-01f, -3.95898819e-02f,
  4.48873118e-02f, 7.58199617e-02f, -6.16185777e-02f, 1.97034585e-03f, -5.46578877e-02f, 1.49820969e-01f, -2.58442402e-01f, 2.24986255e-01f, 1.46775439e-01f, -1.09723918e-02f,
  -5.15722148e-02f, 2.31878325e-01f, 5.07437177e-02f, -1.50386721e-01f, -1.79008573e-01f, 6.52705431e-02f, 1.27755523e-01f, -1.26218125e-01f, -5.19407950e-02f, -5.29438369e-02f,
  9.06762294e-03f, 8.59645680e-02f, -1.90439194e-01f, -3.22278328e-02f, 1.40384704e-01f, -8.32024664e-02f, -1.92439348e-01f, 1.36714935e-01f, 2.20242620e-01f, -8.22588950e-02f,
  1.45783186e-01f, 2.07854122e-01f, -1.27479985e-01f, -4.91016619e-02f, -6.23115972e-02f, -1.08064100e-01f, -2.09257573e-01f, 8.97662435e-03f, -1.06636763e-01f, 1.56005904e-01f,
  1.21445835e-01f, 2.46941093e-02f, 1.68418080e-01f, 2.39228860e-01f, -5.03453650e-02f, 2.10387871e-01f, -2.06115812e-01f, -1.69040561e-01f, 1.25146344e-01f, 5.53230122e-02f,
  7.48294219e-02f, 1.41665190e-01f, 5.04621910e-03f, 9.07304734e-02f, 1.84004679e-02f, 1.71920568e-01f, -4.92393300e-02f, 1.30302623e-01f, -8.22650641e-03f, 1.47478119e-01f,
  2.19963014e-01f, 1.23307742e-02f, -1.96112633e-01f, -7.00018629e-02f, 8.27314109e-02f, -5.37004881e-02f, 6.24611191e-02f, 1.35744229e-01f, 2.00960353e-01f, -2.22026646e-01f,
  -1.30512953e-01f, -7.06624705e-03f, 1.25310030e-02f, -4.01899107e-02f, -2.97905028e-01f, 8.67763534e-02f, 9.20100436e-02f, 8.46306756e-02f, -2.10114732e-01f, 1.08609788e-01f,
  8.81222188e-02f, -5.95395789e-02f, 1.52156115e-01f, 1.66585252e-01f, 2.24633753e-01f, 7.21049458e-02f, -7.85680637e-02f, -4.15663756e-02f, 6.48024529e-02f, -4.12462726e-02f,
  -2.30894089e-01f, 1.22746173e-02f, -4.10316102e-02f, -8.58685151e-02f, 1.32515598e-02f, 2.28987969e-02f, -9.83571783e-02f, 2.30850801e-02f, -2.11016491e-01f, -9.30445790e-02f,
  1.30107582e-01f, -1.66123539e-01f, 1.78141706e-02f, 1.41145487e-04f, -9.41005573e-02f, -1.70317948e-01f, -1.61846489e-01f, 1.66469917e-01f, -3.32500450e-02f, 1.09518036e-01f,
  6.95051700e-02f, 5.35299480e-02f, 6.50871843e-02f, -8.76519680e-02f, -2.30395168e-01f, -3.88303176e-02f, -1.85031846e-01f, -3.79102938e-02f, 9.57284868e-03f, 6.67159334e-02f,
  1.42757103e-01f, 1.51720345e-01f, 1.09309703e-01f, 3.55953723e-02f, -1.03806712e-01f, 1.39849275e-01f, -1.96662411e-01f, -7.57579282e-02f, 1.09112822e-01f, 1.30587786e-01f,
  1.98246628e-01f, -1.54729141e-02f, 1.92116335e-01f, -2.89303929e-01f, 1.04421988e-01f, 4.50647362e-02f, 5.73686771e-02f, 1.77318305e-01f, 2.46553242e-01f, 2.28192449e-01f,
  -2.07828745e-01f, 5.06273657e-02f, 1.84943691e-01f, 1.41005561e-01f, 2.60124598e-02f, 6.99592903e-02f, 3.00393999e-01f, 7.55342394e-02f, 1.73758313e-01f, 8.83560032e-02f,
  1.00682750e-01f, -3.83364893e-02f, 9.40450057e-02f, 2.77862269e-02f, 1.24594262e-02f, -1.53709456e-01f, -6.82964027e-02f, 2.37468779e-01f, 5.71500249e-02f, 6.49540350e-02f,
  2.62263045e-03f, -1.25113130e-01f, 2.85483915e-02f, 1.36311248e-01f, 1.34365514e-01f, 9.32775885e-02f, 1.46378040e-01f, -1.20288469e-01f, 1.47059992e-01f, 4.45682779e-02f,
  -4.24338467e-02f, -2.01703057e-01f, 3.28666568e-01f, -2.33656354e-02f, 2.98282802e-02f, 2.57383976e-02f, 4.41709394e-03f, -5.25282398e-02f, -2.26603091e-01f, 1.04062699e-01f,
  9.04615521e-02f, -2.68805802e-01f, 6.18857034e-02f, 1.95711195e-01f, 1.18776798e-01f, 1.24529578e-01f, -9.29632187e-02f, 6.91502467e-02f, -7.67908851e-03f, -5.52295893e-02f,
  -1.98100492e-01f, -1.82359621e-01f, 1.54229432e-01f, -1.08324708e-02f, 8.45867321e-02f, -1.54676624e-02f, 1.02068633e-01f, -1.85792521e-01f, 1.10838644e-01f, 9.70061570e-02f,
  1.87267080e-01f, 2.61851430e-01f, 5.45000890e-03f, 2.08134159e-01f, 1.10657714e-01f, -1.83087692e-01f, 4.66248468e-02f, -1.48638310e-02f, 9.80212837e-02f, -5.06754182e-02f,
  1.73123613e-01f, 5.06456606e-02f, 1.70196310e-01f, 1.95405498e-01f, -1.65457800e-01f, -1.60270467e-01f, 8.13143142e-03f, -1.72271058e-01f, 9.34748873e-02f, 1.01899490e-01f,
  3.50501724e-02f, -1.88194782e-01f, 1.59062058e-01f, 1.61537558e-01f, -2.88153857e-01f, -9.55584794e-02f, -9.02824178e-02f, -2.47882962e-01f, 8.34373161e-02f, -1.03779882e-01f,
  6.61235722e-03f, -6.53901920e-02f, 4.53553982e-02f, -3.70850377e-02f, -1.41217589e-01f, 2.11848989e-02f, 2.29640678e-02f, 1.37078673e-01f, -1.81112960e-01f, 7.69741014e-02f,
  -5.68442745e-03f, 2.75852084e-02f, -5.12415320e-02f, 2.14271188e-01f, -4.75612208e-02f, -1.74858421e-01f, 1.01967476e-01f, -7.63572231e-02f, 1.03824083e-02f, 6.72142208e-02f,
  -1.14098592e-02f, 1.19197585e-01f, 1.46659827e-02f, -4.00729999e-02f, 1.18089594e-01f, 7.13995844e-02f, -3.34754623e-02f, -6.32391647e-02f, 4.38244604e-02f, 1.14570342e-01f,
  -2.25505918e-01f, 1.65302873e-01f, -5.04310019e-02f, 2.11394116e-01f, 1.51068896e-01f, 7.91980624e-02f, 8.08272660e-02f, 1.03645280e-01f, 3.25258933e-02f, -1.59125090e-01f,
  -1.38880119e-01f, 1.23976216e-01f, 3.66195999e-02f, -8.31303671e-02f, -7.31600972e-04f, -3.29873860e-02f, -3.77185456e-02f, 6.30620942e-02f, -1.26326561e-01f, 7.17383921e-02f,
  3.94034237e-02f, 8.72061239e-04f, -5.17855361e-02f, -2.17148662e-02f, 1.42762080e-01f, 7.87457302e-02f, 1.78529948e-01f, 1.48384720e-01f, 6.89056292e-02f, 6.19573854e-02f,
  1.03677966e-01f, 1.21192425e-01f, -8.10917765e-02f, 1.41869098e-01f, -1.63858265e-01f, 2.36393496e-01f, 5.39298877e-02f, 8.84423330e-02f, 1.64731890e-01f, 5.80037292e-03f,
  8.91754404e-03f, 1.55545980e-01f, -1.50634825e-01f, -1.02380579e-02f, 3.61003615e-02f, 8.40089694e-02f, -3.52544524e-02f, 1.99914604e-01f, 3.05765867e-02f, 7.52397478e-02f,
  1.77154750e-01f, 8.33238587e-02f, 1.17996357e-01f, 1.99910596e-01f, 7.78535083e-02f, 8.23553875e-02f, 8.08719993e-02f, -1.80828422e-01f, 8.24701041e-02f, -5.11617959e-02f,
  -1.27535965e-02f, -2.71195453e-02f, 4.17679884e-02f, -1.12983510e-02f, 1.37598842e-01f, 2.30895560e-02f, 9.59271416e-02f, 2.15545204e-02f, -1.51316468e-02f, 4.72295657e-02f,
  -8.26088246e-03f, -1.18496358e-01f, -7.98097849e-02f, -2.00542763e-01f, -6.56203702e-02f, 1.12151176e-01f, -5.79503514e-02f, 1.32710919e-01f, -3.52825187e-02f, -4.87912484e-02f,
  8.87558833e-02f, -3.73866111e-02f, -9.57755256e-04f, 2.02546209e-01f, 1.26204873e-02f, 1.29915804e-01f, 7.36902356e-02f, -1.61458001e-01f, -7.05148801e-02f, 3.76827046e-02f,
  -7.34040067e-02f, 1.52335148e-02f, 9.86114070e-02f, -6.87323976e-03f, -1.49933388e-02f, 2.76255399e-01f, 2.06527542e-02f, 9.02374610e-02f, 2.12050451e-04f, -9.32971248e-04f,
  -2.28783771e-01f, 1.34422794e-01f, 1.41596407e-01f, -9.06318873e-02f, 2.80543178e-01f, -4.92671691e-02f, -1.08350784e-01f, 1.54388845e-01f, 1.25996858e-01f, 2.95064002e-02f,
  -2.08228365e-01f, -4.52850908e-02f, 1.49577454e-01f, 2.75652055e-02f, 1.67547628e-01f, -3.21799815e-02f, 4.01955284e-02f, 7.82843754e-02f, -9.26789269e-02f, -6.98254034e-02f,
  -6.34311065e-02f, -9.95968189e-03f, 1.50488362e-01f, 1.04457520e-01f, 9.65443999e-02f, -1.15902603e-01f, 1.37264550e-01f, 2.90966004e-01f, -8.81508812e-02f, 2.95228418e-02f,
  -3.85636948e-02f, -2.69056540e-02f, 1.16891444e-01f, 1.31613523e-01f, -1.98870408e-03f, -4.95457910e-02f, 6.85206875e-02f, 1.84440061e-01f, -9.72223654e-02f, 6.90069795e-02f,
  1.55335173e-01f, -2.15180609e-02f, 2.72474512e-02f, 9.44400132e-02f, -8.66155699e-02f, 2.24896476e-01f, 8.40547830e-02f, 4.19429922e-03f, -2.40402892e-02f, 4.43810876e-03f,
  -1.06009364e-01f, -8.48627239e-02f, -1.01745158e-01f, 1.68199837e-02f, 9.26497877e-02f, 1.49819225e-01f, 1.27757356e-01f, 1.65205821e-01f, -1.85438260e-01f, 3.69410850e-02f,
  8.03792998e-02f, -9.27833617e-02f, -4.99794632e-02f, 1.26445904e-01f, -3.40286307e-02f, -1.33223504e-01f, -1.26310363e-01f, -3.32575589e-01f, 9.63650495e-02f, 1.27051165e-02f,
  2.67722383e-02f, 1.41902104e-01f, -1.66807827e-02f, -1.55122712e-01f, -8.89473855e-02f, 1.66373134e-01f, -8.97143558e-02f, 1.27793953e-01f, 2.20287293e-02f, 1.05625847e-02f,
  -9.90599860e-03f, -5.93233779e-02f, 7.89273903e-02f, 9.39186011e-03f, 9.33471173e-02f, -9.06550139e-03f, -1.66096121e-01f, -6.61995858e-02f, 1.85470536e-01f, 1.27331745e-02f,
  3.21619399e-02f, -8.17930847e-02f, -4.53672782e-02f, 2.41377316e-02f, -1.77036390e-01f, 2.20732749e-01f, -1.09665713e-03f, 3.97912823e-02f, -8.92789066e-02f, 2.29831830e-01f,
  6.94971308e-02f, -1.19073980e-01f, -6.42418861e-02f, 1.80773243e-01f, 1.49102643e-01f, -1.39373243e-01f, -2.70604547e-02f, -3.77032608e-02f, 9.91985872e-02f, 8.86046141e-02f,
  -1.76399544e-01f, -8.24147612e-02f, 8.70402381e-02f, -1.26638457e-01f, -2.14160472e-01f, 1.03305303e-01f, 2.16336891e-01f, -7.40167499e-02f, 1.75739959e-01f, 1.75504640e-01f,
  -1.05343513e-01f, -7.16979243e-03f, 5.59911132e-02f, -1.12172492e-01f, -1.54816359e-02f, 1.15140736e-01f, -1.61353543e-01f, 1.23668306e-01f, 2.00022683e-01f, 7.07614124e-02f,
  1.10688405e-02f, 2.79371530e-01f, -2.52155103e-02f, 2.74932206e-01f, -1.90277964e-01f, -1.75161406e-01f, 7.61412084e-02f, -1.91150475e-02f, 1.26980186e-01f, 2.08959579e-02f,
  -4.73638950e-03f, 7.90324062e-02f, 1.13394246e-01f, -1.30633432e-02f, 3.27933654e-02f, 3.09718437e-02f, 4.84326109e-02f, 1.67914256e-01f, 3.44838202e-02f, 6.11673715e-03f,
  7.29651228e-02f, 7.28027597e-02f, 4.83516678e-02f, 5.32865301e-02f, -1.49745822e-01f, 1.18785836e-01f, 9.25196160e-04f, 1.93166181e-01f, -9.82663482e-02f, 8.30923244e-02f,
  9.53631252e-02f, -9.62331370e-02f, 1.37281016e-01f, 5.53055629e-02f, 1.33443713e-01f, 2.91275568e-02f, -9.70536619e-02f, 1.00569800e-01f, 1.34581793e-02f, -1.31649733e-01f,
  -1.45463705e-01f, -6.10456727e-02f, -5.31566190e-03f, -3.30264084e-02f, -1.30212888e-01f, 3.74722444e-02f, 1.06360711e-01f, -1.01556413e-01f, -1.41982779e-01f, 7.14637861e-02f,
  2.95923278e-02f, 6.29051402e-02f, 8.54711086e-02f, 1.89726055e-01f, 1.38646901e-01f, -6.46913201e-02f, -2.80130375e-02f, 1.66194186e-01f, -1.85305774e-01f, 1.09471135e-01f,
  -1.15488045e-01f, 7.05868900e-02f, 1.21414289e-01f, 1.52137488e-01f, 9.46142301e-02f, -1.23541355e-02f, -1.17348827e-01f, 1.59023657e-01f, -9.55440626e-02f, 9.02728960e-02f,
  1.54282331e-01f, 1.78434819e-01f, 5.75702339e-02f, -5.75108491e-02f, -5.59563115e-02f, 1.89095885e-01f, -1.59565344e-01f, -1.81621592e-02f, -1.21204657e-02f, -4.99416096e-03f,
  -2.37745233e-02f, 6.89417645e-02f, -1.34975538e-01f, 1.73843235e-01f, -7.19228312e-02f, -5.96886501e-02f, 6.09766133e-02f, -1.15167923e-01f, 7.17861876e-02f, -1.03787787e-01f,
  1.64519206e-01f, -2.57805176e-02f, 3.47690493e-01f, -1.48644730e-01f, 4.63140085e-02f, 1.79746538e-01f, -5.17354310e-02f, -9.34411436e-02f, 1.14370733e-01f, 7.86102638e-02f,
  1.06209077e-01f, -2.57959485e-01f, -4.10054773e-02f, 5.42292520e-02f, -4.84516807e-02f, -1.19058369e-02f, 1.03819422e-01f, 3.72767858e-02f, 1.67882949e-01f, -2.79926360e-02f,
  -1.39330149e-01f, 5.45313209e-02f, 3.10537547e-01f, 2.34225512e-01f, 5.56327142e-02f, -9.77116227e-02f, -1.71259701e-01f, -1.31076887e-01f, 5.54537959e-02f, 1.25153750e-01f,
  2.78753396e-02f, -6.98467717e-02f, 1.52368858e-01f, -6.56427667e-02f, 1.56550422e-01f, 1.12691503e-02f, -1.44207448e-01f, -8.97667110e-02f, -1.59699842e-01f, 7.36648962e-02f,
  8.79375115e-02f, -1.11892074e-01f, 1.23975821e-01f, 7.24085569e-02f, 7.22325444e-02f, -8.68352875e-02f, 1.27372608e-01f, -8.77715647e-02f, 6.91925809e-02f, 1.81495659e-02f,
  -1.53380170e-01f, -1.02190100e-01f, -8.71031806e-02f, -1.28905579e-01f, -4.23437543e-02f, -9.34950784e-02f, -5.42063862e-02f, 1.32254943e-01f, 3.55505268e-03f, 4.75311056e-02f,
  -5.22015430e-02f, 8.45237449e-02f, -8.00121669e-03f, -8.79201740e-02f, -6.49212599e-02f, 1.59873754e-01f, -3.57030109e-02f, 9.02416110e-02f, -5.78809269e-02f, -3.39002721e-02f,
  1.31108135e-01f, 1.75567433e-01f, 4.06640954e-02f, 1.13544182e-03f, 3.30628525e-03f, 8.01166520e-02f, 4.57231216e-02f, -1.06448732e-01f, 1.41615033e-01f, 6.50410280e-02f,
  5.51842637e-02f, 3.86747159e-02f, -8.94173142e-03f, -1.02919884e-01f, -7.12101441e-03f, -1.47908822e-01f, 9.96809080e-02f, 2.40333706e-01f, 1.98333651e-01f, -1.10146098e-01f,
  8.16121101e-02f, 1.02883942e-01f, -9.30427685e-02f, 4.56766933e-02f, 2.07220376e-01f, -7.41335824e-02f, 3.97625146e-03f, 1.87827982e-02f, -2.44318526e-02f, 1.27359167e-01f,
  1.52985334e-01f, 3.18101351e-03f, 1.65978059e-01f, 2.04272285e-01f, -2.69112140e-01f, 3.26538249e-03f, 7.98959434e-02f, -1.12263843e-01f, -1.49286464e-01f, 1.46098062e-01f,
  1.42525181e-01f, -4.03542491e-03f, -2.71004420e-02f, 1.29661322e-01f, -3.44241053e-01f, -1.96626931e-01f, -7.32690841e-02f, -4.42351364e-02f, -1.87624488e-02f, 1.06985318e-02f,
  1.32705867e-01f, 1.20133497e-01f, -3.96060263e-04f, 1.73583210e-01f, -1.60661131e-01f, -8.44883323e-02f, 8.72334873e-04f, 9.43878889e-02f, 1.72306508e-01f, 5.80094680e-02f,
  1.78070083e-01f, 2.79119872e-02f, -3.12646717e-01f, 2.68750712e-02f, -1.68350026e-01f, -2.28249863e-01f, -1.52123002e-02f, 1.82180136e-01f, -6.06957674e-02f, -6.57876432e-02f,
  1.06614932e-01f, 5.33504598e-02f, -4.23111574e-04f, 2.14173317e-01f, -4.64036539e-02f, -1.65397599e-01f, 2.24135995e-01f, 1.41731292e-01f, -1.37667790e-01f, 2.40994334e-01f,
  3.51256654e-02f, 1.53627425e-01f, 2.24273279e-02f, 9.63819474e-02f, -1.46306872e-01f, -6.31723106e-02f, 1.52525887e-01f, 2.60910690e-01f, 1.17201820e-01f, 2.09095329e-01f,
  4.60931994e-02f, 5.76554388e-02f, -8.69943667e-03f, 2.11061627e-01f, -1.11102805e-01f, 5.56133967e-03f, 7.98635632e-02f, 5.69521487e-02f, -1.33230060e-01f, -1.30737916e-01f,
  1.35680556e-01f, 1.70214012e-01f, 4.28852849e-02f, -8.07835236e-02f, -1.20328471e-01f, 5.55630103e-02f, 4.32796329e-02f, 2.64451683e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  -3.91250141e-02f, 1.25411749e-01f, -4.47834991e-02f, 1.11529477e-01f, 2.72695664e-02f, 3.20529342e-02f, 2.23065987e-02f, -2.37391125e-02f, 6.95829913e-02f, 9.11676511e-02f,
  -1.01971216e-02f, 9.08664614e-02f, 6.58375174e-02f, -2.18694247e-02f, 3.82708758e-02f, -3.38823870e-02f, 3.61847854e-03f, 7.01017305e-02f, 4.09539603e-02f, 4.75920662e-02f,
  2.61826068e-02f, 5.73771894e-02f, 7.46376812e-02f, 9.97862890e-02f, 1.22117631e-01f, 1.08052112e-01f, 3.26198377e-02f, 7.47910812e-02f, 8.27456638e-02f, 1.30220190e-01f,
  -3.12982872e-02f, -5.16087115e-02f, 4.05858159e-02f, 1.01078153e-01f, 7.59364516e-02f, -1.84834097e-02f, 1.00751825e-01f, 1.05633222e-01f, 1.45906016e-01f, 2.10690834e-02f,
  9.54933539e-02f, -2.63131689e-02f, 1.54969156e-01f, -1.06432727e-02f, 9.00804810e-03f, 6.95222989e-02f, -4.41044345e-02f, 7.25979879e-02f, 1.06777474e-01f, -4.43337895e-02f,
  -5.65626426e-03f, -6.03824109e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -2.63301916e-02f, 4.34521362e-02f, -3.20439413e-02f, 7.01771230e-02f, 6.33655339e-02f, -4.26599421e-02f, 2.87364572e-02f, 1.57238394e-01f, -2.94890418e-03f, -2.34029576e-01f,
  -2.26422086e-01f, -7.27493092e-02f, -1.97692305e-01f, 1.84053600e-01f, -8.12006146e-02f, -3.59470993e-01f, -2.62335062e-01f, -3.13955426e-01f, -2.08631903e-01f, -3.15383643e-01f,
  1.32962286e-01f, 2.10954934e-01f, -4.09503549e-01f, -3.25571388e-01f, 3.53174284e-02f, -2.49649704e-01f, 1.78990215e-02f, -2.17788830e-01f, -1.48994803e-01f, 1.43034831e-01f,
  -9.91751328e-02f, 2.66095787e-01f, 1.78136036e-01f, 1.38096899e-01f, -2.86098599e-01f, 1.02849215e-01f, 1.08982902e-02f, 7.49820322e-02f, -2.85444528e-01f, -1.02889352e-01f,
  -1.74955174e-01f, -7.77576342e-02f, -2.66615480e-01f, -3.43985707e-02f, 5.26438914e-02f, -2.17834890e-01f, -4.07339893e-02f, 1.31041944e-01f, -2.61631846e-01f, 2.17833415e-01f,
  6.98444694e-02f, 3.27247560e-01f, 1.51776418e-01f, -2.47387782e-01f, 1.08030461e-01f, 3.38451713e-02f, 1.38837785e-01f, -1.80454105e-01f, -8.93620700e-02f, 1.90945745e-01f,
  1.02178723e-01f, -2.45988682e-01f, 2.17405185e-01f, -3.55032206e-01f, 9.07738954e-02f, -1.71932913e-02f, 5.51412674e-03f, 1.48655385e-01f, 5.60399704e-02f, 1.45240709e-01f,
  7.76147544e-02f, 1.70711398e-01f, -2.53654927e-01f, 6.27237037e-02f, 1.55934030e-02f, -3.20457101e-01f, 1.92503184e-01f, 1.58441007e-01f, 4.09218520e-02f, 6.84930608e-02f,
  4.05878834e-02f, -5.10339700e-02f, -1.12457402e-01f, -3.58101606e-01f, -1.03841379e-01f, -2.15097964e-01f, 2.01703552e-02f, -4.91922311e-02f, 4.52423058e-02f, -2.51104891e-01f,
  3.47370133e-02f, -4.28171195e-02f, -2.60301441e-01f, 1.03957713e-01f, -1.64997831e-01f, 3.69030833e-02f, 1.77200705e-01f, 1.90250695e-01f, 2.20881671e-01f, 1.05728425e-01f,
  -1.41845807e-01f, 1.21216848e-01f, -3.25189084e-01f, -3.98488611e-01f, 1.80504620e-01f, 1.05267972e-01f, -2.29845703e-01f, -1.08017288e-01f, 1.58336028e-01f, 8.62658620e-02f,
  -3.56753021e-01f, 1.62053481e-01f, -1.49538025e-01f, -5.74008264e-02f, 2.92744786e-02f, -2.21639246e-01f, 1.36213079e-01f, 1.07303329e-01f, 9.56427976e-02f, 2.29046598e-01f,
  1.35107100e-01f, -1.59970075e-02f, 1.06542498e-01f, 1.35295168e-01f, -1.03054360e-01f, -2.51807809e-01f, -6.33061007e-02f, -2.16933802e-01f, -6.81017041e-02f, -7.73926079e-02f,
  -7.12006316e-02f, 3.11077461e-02f, -2.07067147e-01f, 3.29837203e-02f, 6.15321798e-03f, 2.25239411e-01f, -6.92036897e-02f, -2.26420790e-01f, 7.34531656e-02f, 2.63786584e-01f,
  2.73755461e-01f, -1.36013046e-01f, 4.32458073e-02f, 1.28667668e-01f, -7.42267594e-02f, -3.27231795e-01f, 1.05034962e-01f, -2.55964756e-01f, 1.52368903e-01f, -1.30655229e-01f,
  2.16214269e-01f, 2.49839276e-01f, 1.38348958e-03f, -5.34170829e-02f, -2.91660607e-01f, 5.83504476e-02f, 1.32037878e-01f, 5.17618880e-02f, 6.37201965e-02f, -2.15545073e-02f,
  1.18769675e-01f, -3.13439459e-01f, -5.82281537e-02f, -1.18063912e-01f, -3.00523907e-01f, -8.99192765e-02f, 2.77965248e-01f, -4.08587188e-01f, 1.67795002e-01f, 5.78061491e-02f,
  -2.85554707e-01f, -1.60845846e-01f, 1.59423098e-01f, -2.24123821e-01f, -2.94259638e-01f, -3.18769842e-01f, -2.97595769e-01f, 6.62522065e-03f, -3.54890853e-01f, -2.79765781e-02f,
  4.21178751e-02f, -2.62691956e-02f, -4.09839660e-01f, -1.09864473e-01f, 1.36909962e-01f, -2.92995125e-01f, 2.47437701e-01f, -6.52833879e-02f, 8.25987607e-02f, 5.18403724e-02f,
  -3.58692817e-02f, 8.51560757e-02f, -1.78780809e-01f, -1.68187454e-01f, 1.06925266e-02f, -3.77445258e-02f, -1.96691260e-01f, -8.99468958e-02f, 3.28737162e-02f, 1.26096889e-01f,
  9.84887127e-03f, 4.87276688e-02f, -1.97566032e-01f, -1.05980664e-01f, 6.13983236e-02f, 1.54309496e-02f, -1.44618392e-01f, 7.01785088e-02f, -3.52533638e-01f, 1.39268776e-02f,
  2.31371984e-01f, 9.30456519e-02f, -1.41640767e-01f, 1.44186780e-01f, -3.69682997e-01f, -4.00298238e-01f, -2.91096866e-01f, 2.68091619e-01f, -3.65350731e-02f, -3.31379145e-01f,
  -2.01569021e-01f, 1.61097553e-02f, 1.35783836e-01f, 1.14316732e-01f, -3.95013064e-01f, -3.96416306e-01f, -1.81877613e-01f, -2.47920007e-01f, 2.29034603e-01f, -3.44361246e-01f,
  -2.88665533e-01f, 1.48816124e-01f, -2.87684888e-01f, -3.77584368e-01f, -4.22565863e-02f, -2.36420780e-01f, 8.07086527e-02f, -1.57958955e-01f, 1.91441864e-01f, -2.24161759e-01f,
  8.30293670e-02f, -2.62274563e-01f, -2.02152580e-01f, 3.40124190e-01f, -4.38371822e-02f, -9.26281437e-02f, 2.39203855e-01f, -3.17826837e-01f, -2.50094503e-01f, 9.88910794e-02f,
  -2.33322144e-01f, -5.26032746e-02f, -3.37162614e-01f, 8.06801245e-02f, -1.78134829e-01f, 1.77107960e-01f, 1.53338045e-01f, 9.55853090e-02f, -1.09044202e-02f, 1.62779763e-02f,
  2.15420976e-01f, 9.13455337e-02f, -1.76471770e-01f, -5.68714142e-02f, 1.93629622e-01f, 1.86125875e-01f, 2.00975686e-01f, -2.46866882e-01f, -1.30469665e-01f, -1.36536792e-01f,
  -2.42448539e-01f, -1.38698727e-01f, -1.43762305e-01f, -1.33121371e-01f, -3.90679687e-02f, 1.30844474e-01f, 2.22298920e-01f, 1.88643351e-01f, 1.59050792e-01f, -1.52093634e-01f,
  -3.50071527e-02f, 7.30881393e-02f, 1.95289150e-01f, 9.26536620e-02f, -2.63353586e-01f, -1.69084951e-01f, 2.96046078e-01f, 1.76266551e-01f, 1.74708724e-01f, -8.65284875e-02f,
  -2.26865605e-01f, 1.40117509e-02f, 1.57942489e-01f, 1.66345090e-01f, 9.01831537e-02f, 3.70265776e-03f, -1.23800956e-01f, -1.08629629e-01f, -1.25237614e-01f, 1.56631634e-01f,
  -1.30567521e-01f, -3.19545269e-01f, 1.08473144e-01f, 2.36373693e-02f, -1.33312084e-02f, -2.41845343e-02f, -7.22160488e-02f, -6.13170713e-02f, -2.08559141e-01f, -1.76809296e-01f,
  9.94648933e-02f, -2.50125706e-01f, 2.08427720e-02f, 1.93548813e-01f, 1.18872970e-01f, -2.58151889e-01f, 1.06328771e-01f, -3.04944038e-01f, -3.47852528e-01f, -1.89000875e-01f,
  9.98036861e-02f, 8.41293111e-02f, 1.68157652e-01f, 3.39362002e-03f, 6.04355857e-02f, 1.23528995e-01f, 1.33402795e-01f, -2.79464692e-01f, 1.34283409e-01f, -1.49468660e-01f,
  1.20357364e-01f, 2.06622466e-01f, -1.83570057e-01f, -2.86096036e-01f, 1.04403473e-01f, 1.06603764e-01f, -3.61476019e-02f, 1.96887076e-01f, -4.13732082e-01f, 1.05349809e-01f,
  -2.66870379e-01f, 1.30099297e-01f, -1.15476837e-02f, -2.14519233e-01f, 2.27159306e-01f, -2.41979197e-01f, 1.25940457e-01f, 1.21534422e-01f, -4.47690338e-02f, -1.96823597e-01f,
  -1.41750455e-01f, -2.43145704e-01f, -1.04121879e-01f, 2.55801409e-01f, 1.72244683e-01f, 7.01415911e-02f, -4.41301242e-02f, 1.21908903e-01f, -1.82124469e-02f, 1.06241055e-01f,
  -2.69198775e-01f, 1.45817831e-01f, 2.15050906e-01f, 1.02487065e-01f, -3.19095373e-01f, -5.14202863e-02f, 8.28210451e-03f, 6.07193634e-02f, 1.22533061e-01f, 1.74405798e-01f,
  1.88824475e-01f, 1.91312775e-01f, 5.31810448e-02f, 2.14010417e-01f, 3.80952954e-02f, 1.55362696e-03f, -1.16777178e-02f, -4.35086526e-03f, -2.30655223e-01f, 1.48366317e-01f,
  1.35984719e-02f, -1.45320207e-01f, -1.34754956e-01f, -2.29859054e-01f, 1.43423947e-02f, -1.77093163e-01f, 1.37112647e-01f, -2.95474231e-02f, -5.27009889e-02f, -2.68762428e-02f,
  -6.25155419e-02f, -9.94460955e-02f, 6.06182963e-02f, 2.55812258e-01f, 4.82971966e-03f, 1.18622473e-02f, -1.14997990e-01f, 1.27590567e-01f, 2.73530900e-01f, 1.33063179e-02f,
  1.75278261e-01f, 2.95571864e-01f, -1.45433843e-01f, 8.44035819e-02f, 1.46413771e-02f, -3.31649929e-01f, 1.52127832e-01f, 1.37915328e-01f, 1.45345911e-01f, 2.95326859e-02f,
  1.24484777e-01f, 1.60003498e-01f, 2.48952582e-02f, 1.97270900e-01f, 9.98798385e-02f, -6.44915104e-02f, 1.84750542e-01f, -1.17650390e-01f, -2.17817068e-01f, -6.32824302e-02f,
  -2.73487091e-01f, 4.67814766e-02f, 2.44555593e-01f, -8.98674279e-02f, -1.29295647e-01f, -3.69423896e-01f, 2.21921757e-01f, 7.26151839e-02f, -2.59291418e-02f, -1.42348148e-02f,
  9.03485492e-02f, -3.46943557e-01f, -1.25685900e-01f, -4.11087602e-01f, 2.38249362e-01f, -1.67208403e-01f, 7.08065480e-02f, -2.14219615e-01f, -3.79151314e-01f, -8.69723335e-02f,
  -6.23481199e-02f, -1.51561365e-01f, -2.56695062e-01f, 1.25412673e-01f, 3.24577838e-02f, -6.87299017e-03f, 6.66154474e-02f, -2.93072045e-01f, -1.30948992e-02f, -4.33314778e-03f,
  1.31758004e-02f, 1.70677062e-02f, 2.83160377e-02f, 6.73562810e-02f, -1.16843916e-01f, -7.61371776e-02f, -1.58290401e-01f, 3.11545022e-02f, -1.26613691e-01f, 2.60877371e-01f,
  -6.44191578e-02f, -2.48388618e-01f, -1.04909331e-01f, -3.51287961e-01f, -7.58514330e-02f, -2.13569239e-01f, 1.53037131e-01f, 1.51018515e-01f, -2.64028788e-01f, 2.06607603e-03f,
  1.68760136e-01f, 5.44935241e-02f, -2.01605305e-01f, -1.41480610e-01f, -3.20724636e-01f, 1.71305448e-01f, -1.78917751e-01f, -1.92744091e-01f, -2.27449760e-01f, -2.72481531e-01f,
  -2.55502671e-01f, -1.01576641e-01f, 1.73531666e-01f, -3.99548829e-01f, 7.35550299e-02f, 1.81678638e-01f, -7.70157995e-03f, 1.54610440e-01f, 1.32963076e-01f, 8.50544646e-02f,
  -1.37598589e-01f, -1.99576825e-01f, -1.44028798e-01f, 2.87860781e-01f, -3.11852098e-02f, 1.01268277e-01f, 2.35025421e-01f, -3.37419778e-01f, -1.53442875e-01f, 1.62877470e-01f,
  -1.74951047e-01f, -1.09205939e-01f, 3.38747762e-02f, -1.18453398e-01f, -5.81739433e-02f, 1.74804404e-01f, 2.52636243e-02f, -1.91088945e-01f, -1.69892311e-01f, 9.25804004e-02f,
  -8.71092230e-02f, 9.88150164e-02f, 6.23169541e-02f, 4.56722677e-02f, -7.21919313e-02f, -1.62864462e-01f, -5.30287670e-03f, -1.29145667e-01f, 1.43435866e-01f, -1.19014338e-01f,
  1.24863070e-02f, -1.57637417e-01f, -9.22361910e-02f, 1.95836112e-01f, 6.99166879e-02f, -1.80985317e-01f, -1.77964658e-01f, 1.25884473e-01f, 1.14721671e-01f, 1.54610202e-01f,
  1.37694821e-01f, -2.62707978e-01f, -2.60270983e-01f, 2.72931773e-02f, -1.32611200e-01f, 1.74316958e-01f, -2.37988308e-01f, 4.86087389e-02f, -1.07810251e-01f, 3.25827971e-02f,
  2.46657267e-01f, -3.22567493e-01f, -2.56484836e-01f, -2.19669059e-01f, -2.71661222e-01f, 4.81590442e-02f, 8.68818387e-02f, 1.63002968e-01f, -1.07426129e-01f, -2.95490772e-01f,
  1.18453771e-01f, -1.14799917e-01f, 6.01078942e-02f, 1.69811457e-01f, -1.44995019e-01f, -1.55718476e-01f, 9.06749219e-02f, 3.45642194e-02f, -1.38147473e-01f, 6.07968792e-02f,
  -3.28538328e-01f, 2.34362736e-01f, -1.70430645e-01f, -4.20761369e-02f, -1.73480079e-01f, 2.46210992e-01f, 2.16234159e-02f, 1.14512861e-01f, -2.39774823e-01f, -2.33588368e-01f,
  7.74152130e-02f, -2.97527045e-01f, -2.13521421e-01f, 1.83086917e-01f, 9.45568904e-02f, 2.84845650e-01f, 7.53141865e-02f, -8.76600668e-02f, 2.00048927e-02f, 1.24671400e-01f,
  -3.12943935e-01f, 7.03431964e-02f, 3.07094574e-01f, -2.33846322e-01f, 1.21412911e-01f, -2.60224372e-01f, 1.49666846e-01f, 1.99308008e-01f, 1.84057683e-01f, -2.34000102e-01f,
  -3.27457637e-01f, -4.45083290e-01f, -2.70771831e-01f, -9.09250379e-02f, -2.57726133e-01f, -2.86829062e-02f, 2.18456909e-01f, -2.77536124e-01f, -3.12290024e-02f, 2.19964176e-01f,
  4.30965088e-02f, -2.70304978e-01f, 3.88256386e-02f, -1.01796314e-02f, -8.13066810e-02f, 2.23158970e-01f, -3.39263797e-01f, 1.80324376e-01f, -9.26936790e-02f, 1.71862915e-02f,
  -3.68449651e-02f, 1.26266047e-01f, 1.41623378e-01f, 5.09872250e-02f, 1.16148457e-01f, 1.22190557e-01f, -1.01372220e-01f, -1.32808343e-01f, 1.06313257e-02f, 1.50137365e-01f,
  2.25320771e-01f, -1.37689365e-02f, 6.08378798e-02f, 1.96239664e-04f, 2.56983042e-02f, -1.55933365e-01f, -2.83674330e-01f, -2.83058196e-01f, 7.52184018e-02f, -2.45886907e-01f,
  -3.99396211e-01f, -3.97671551e-01f, 1.90627530e-01f, 1.32655695e-01f, -2.54126012e-01f, 3.51307206e-02f, 3.28776911e-02f, -1.35609776e-01f, 5.09506240e-02f, 2.25992292e-01f,
  -8.80676061e-02f, -1.44073159e-01f, 1.84359223e-01f, -2.37319693e-01f, 1.46230578e-01f, 4.90522422e-02f, -2.17570156e-01f, 7.72346705e-02f, 2.33194754e-01f, 2.93592989e-01f,
  -9.45932046e-02f, -2.65880108e-01f, -2.07750767e-01f, 2.93985695e-01f, 1.48609549e-01f, 2.49652550e-01f, 1.82291225e-01f, 1.48796827e-01f, 6.51402920e-02f, 1.19115472e-01f,
  -1.66409045e-01f, -1.96846232e-01f, -3.16499472e-01f, 5.86488023e-02f, -2.80108958e-01f, 1.89241782e-01f, -4.57942821e-02f, -3.78290921e-01f, 1.58990398e-02f, -2.40694106e-01f,
  2.64531702e-01f, 8.31532925e-02f, 8.87214765e-02f, 1.28170803e-01f, 1.78404436e-01f, 1.22116812e-01f, -2.87369668e-01f, -3.42995465e-01f, -3.31154585e-01f, -2.63801455e-01f,
  2.24460274e-01f, -1.67586252e-01f, 2.87501179e-02f, -2.88771302e-01f, -2.60252267e-01f, -3.61626185e-02f, -1.46920189e-01f, -3.32132369e-01f, 2.27917463e-01f, -3.54523659e-01f,
  2.38351718e-01f, -1.49469212e-01f, -2.55464435e-01f, -2.22251087e-01f, 1.52998716e-01f, 2.79657602e-01f, -1.14936411e-01f, 1.04033396e-01f, -8.05615112e-02f, -1.88571796e-01f,
  -2.08814323e-01f, 2.73031652e-01f, -1.86860397e-01f, -2.88115472e-01f, 7.12484568e-02f, 1.00586191e-01f, -4.70072106e-02f, 1.74456015e-02f, 4.17361148e-02f, 8.83006025e-03f,
  3.84615287e-02f, 1.36801079e-01f, 9.77425426e-02f, -2.43432909e-01f, 9.71863493e-02f, 7.16076717e-02f, -6.10609613e-02f, 1.38356552e-01f, 3.64364594e-01f, 3.12634818e-02f,
  -8.48452523e-02f, 7.77490214e-02f, -2.05618143e-02f, 1.59513116e-01f, 2.95192987e-01f, 6.59921765e-02f, -2.14258537e-01f, -2.13268071e-01f, -8.81909654e-02f, 1.92691535e-01f,
  2.61517435e-01f, -2.33643949e-01f, 3.23736131e-01f, -9.31626111e-02f, -1.73856601e-01f, -2.36859858e-01f, -6.94838464e-02f, -2.69686759e-01f, -1.83014780e-01f, 2.04871207e-01f,
  -1.78702772e-01f, -3.28552753e-01f, 1.03912510e-01f, 3.24736536e-02f, -6.39409870e-02f, -2.98856288e-01f, 2.24658400e-01f, 2.54471332e-01f, -1.03611961e-01f, -1.64569303e-01f,
  8.35807025e-02f, 1.90543026e-01f, -2.12841824e-01f, -7.42184604e-03f, 2.19161063e-01f, -3.66020918e-01f, -3.10900956e-01f, -2.29652703e-01f, 1.44982934e-01f, -1.32282987e-01f,
  -1.92237556e-01f, -7.19543770e-02f, -1.39761135e-01f, -2.19950661e-01f, -3.06576401e-01f, 9.83373374e-02f, 4.57763113e-02f, -1.28917128e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.05774903e-03f, 7.36933425e-02f, 5.04395515e-02f, 2.03528441e-02f, 9.16357562e-02f, 5.21686999e-03f, -1.34667397e-01f, -1.38414174e-01f, 7.17508718e-02f, 1.08913198e-01f,
  -1.47002004e-02f, -1.31114453e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    