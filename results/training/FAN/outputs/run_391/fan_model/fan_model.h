/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.26196989e-02f, 3.61443251e-01f, 1.77851439e-01f, 3.83925065e-02f, -4.15829003e-01f, 4.90351282e-02f, 5.61294496e-01f, -7.42269680e-02f, 1.28117517e-01f, 3.12088966e-01f,
  -2.12547362e-01f, 2.76407659e-01f, 1.67394266e-01f, -2.56279349e-01f, -5.14852166e-01f, 3.85914221e-02f, -1.96790695e-01f, 1.50779456e-01f, -1.04574285e-01f, -6.29338324e-02f,
  -1.37687430e-01f, -3.24517637e-01f, -9.88490433e-02f, -1.99230343e-01f, -5.44440895e-02f, 1.36116609e-01f, -1.50866896e-01f, 2.02833787e-01f, -1.96305260e-01f, -3.98997180e-02f,
  -1.39630646e-01f, 8.93281028e-02f, -1.45477280e-02f, 8.46804529e-02f, -3.87486145e-02f, -2.77107535e-03f, 9.31907371e-02f, 4.05960828e-02f, -5.90720549e-02f, 1.73401466e-04f,
  8.32748786e-02f, -3.72523032e-02f, -2.66004540e-03f, 8.84204283e-02f, -8.19217190e-02f, 5.96178882e-03f, -4.98760007e-02f, -4.94278036e-02f, 8.14379379e-02f, -1.93864368e-02f,
  3.05520184e-02f, -1.02418303e-01f, -2.69625559e-02f, 8.98801088e-02f, 6.52073249e-02f, 1.18108973e-01f, 6.55802935e-02f, 3.74942683e-02f, 8.56907368e-02f, 3.09212320e-02f,
  -3.25407386e-02f, 2.36073378e-02f, 2.94187684e-02f, -2.03266442e-02f, -3.49292606e-02f, -5.13385087e-02f, -6.84272498e-02f, -1.76243447e-02f, 1.72228720e-02f, -4.47588600e-03f,
  6.23797625e-02f, -5.44330887e-02f, 3.46413478e-02f, -4.54264730e-02f, -8.00173637e-03f, -5.04822694e-02f, -3.64119858e-02f, 5.70143312e-02f, 1.29241377e-01f, -8.00612122e-02f,
  1.37127386e-02f, 2.56390721e-02f, 1.02175854e-01f, 3.83456401e-03f, -4.18605134e-02f, -1.11230098e-01f, 1.91329084e-02f, -1.33935027e-02f, -5.50850220e-02f, 1.02681458e-01f,
  -1.69050286e-03f, 2.58163482e-01f, 1.11952424e-01f, 2.10397691e-02f, 5.27169183e-03f, -4.04413454e-02f, -3.40839513e-02f, -6.56370297e-02f, 1.05552524e-01f, -4.88749482e-02f,
  -7.39591196e-02f, 1.14859425e-01f, 5.73273264e-02f, -1.93092391e-01f, 3.00255753e-02f, 2.12145168e-02f, 9.93080288e-02f, 1.06780022e-01f, 1.40685029e-02f, -2.68415399e-02f,
  8.10500756e-02f, 1.76368151e-02f, 1.70798331e-01f, -6.92342892e-02f, -1.17427975e-01f, 1.64063424e-02f, -4.65408154e-02f, 1.11152597e-01f, -8.86694789e-02f, 3.12787443e-02f,
  7.80928805e-02f, 2.75314692e-02f, 3.72290462e-02f, -4.51423079e-01f, 3.65872271e-02f, 6.68748379e-01f, -2.57695526e-01f, -2.85506528e-02f, -4.00227010e-01f, 4.20663133e-02f,
  -1.02999486e-01f, 1.97017565e-01f, -2.92957842e-01f, 9.45550129e-02f, 1.48417890e-01f, -1.26338229e-01f, 1.29751667e-01f, 8.39571059e-02f, -5.20913526e-02f, -8.46807584e-02f,
  8.05210730e-04f, 3.39672081e-02f, -1.43716663e-01f, 1.27420187e-01f, 7.29554221e-02f, -7.61071444e-02f, -2.50686437e-01f, 6.71556816e-02f, 1.76441759e-01f, 1.98720828e-01f,
  9.03859958e-02f, -3.73567194e-01f, 3.48089822e-02f, 6.88903108e-02f, -5.59423417e-02f, 8.01072568e-02f, 3.29167657e-02f, 3.77992578e-02f, -6.64706901e-02f, -5.40008955e-02f,
  9.26079322e-03f, 4.38950621e-02f, -2.95009036e-02f, -1.05137425e-02f, 3.12739164e-02f, 4.55615520e-02f, -9.41682514e-03f, 4.71162312e-02f, -5.90999126e-02f, 1.30609617e-01f,
  -2.55742706e-02f, 6.42252415e-02f, -3.90478820e-02f, -9.61600393e-02f, -6.98930994e-02f, -1.85622636e-03f, 2.24749465e-02f, 5.63229956e-02f, -5.27685545e-02f, 3.61277126e-02f,
  1.30625486e-01f, -2.69695669e-02f, -7.37407012e-04f, -1.69493805e-03f, -5.74054867e-02f, -7.75183439e-02f, 2.63364371e-02f, 1.06021538e-01f, -8.17101896e-02f, 9.45107266e-02f,
  -6.57120869e-02f, 6.96060732e-02f, -3.20223011e-02f, 6.95047453e-02f, 8.57534446e-03f, -2.99623441e-02f, 9.45662111e-02f, -4.23147157e-03f, -7.47279599e-02f, -2.22897232e-02f,
  -4.52778973e-02f, -1.95642579e-02f, -1.54171977e-02f, 2.26045642e-02f, -1.48698678e-02f, 2.31222995e-02f, 6.38528317e-02f, 7.06915408e-02f, -1.91539213e-01f, -2.95267329e-02f,
  1.28030643e-01f, 8.96591544e-02f, -9.20508727e-02f, 2.67728437e-02f, -1.61526948e-02f, 2.18478888e-02f, 2.23246925e-02f, 1.08996294e-01f, 6.17207773e-02f, 1.73429865e-02f,
  4.60642390e-02f, -3.10325176e-02f, -4.83059473e-02f, 4.72821072e-02f, -1.99050717e-02f, -1.32647203e-02f, -1.74556263e-02f, -3.16917105e-03f, 2.79502217e-02f, 1.02697797e-02f,
  -7.90646672e-02f, -2.63099354e-02f, -2.79062409e-02f, -3.43847312e-02f, 4.26704511e-02f, -6.13472750e-03f, 1.30373865e-01f, -3.34603265e-02f, 1.21813387e-01f, -4.64502163e-02f,
  6.28883243e-01f, 1.83659405e-01f, 3.67565393e-01f, 2.13806052e-02f, 2.71807641e-01f, 4.27356623e-02f, -1.92689359e-01f, 2.02474535e-01f, 5.17995155e-04f, -1.40548065e-01f,
  -1.65088370e-01f, -6.74373284e-02f, -1.89519793e-01f, -1.84197016e-02f, -6.37260854e-01f, -2.27494091e-01f, -2.62468398e-01f, -7.84569383e-02f, 6.74227104e-02f, 1.45038068e-01f,
  2.93580107e-02f, -4.17200997e-02f, -4.06469814e-02f, 1.91685215e-01f, 2.78328836e-01f, 2.04496875e-01f, -6.88401088e-02f, 1.71113759e-01f, 2.09875293e-02f, -1.56893000e-01f,
  1.80181101e-01f, 1.96274668e-01f, 1.86485514e-01f, 8.22183117e-02f, 5.64994067e-02f, -8.20584744e-02f, 1.20000832e-01f, 3.12516280e-02f, -5.38866259e-02f, -5.82162812e-02f,
  -5.64719215e-02f, -5.83122373e-02f, -3.12432852e-02f, -8.36180449e-02f, 3.15882452e-02f, 5.85157014e-02f, 1.38981596e-01f, 7.08159208e-02f, 3.53558250e-02f, 3.16813961e-02f,
  -6.72926009e-02f, -1.44963250e-01f, -9.57022421e-03f, -8.70332718e-02f, 3.57072093e-02f, 3.46102156e-02f, -1.27699198e-02f, -2.08232887e-02f, -7.68073425e-02f, 9.37716290e-02f,
  -1.08951693e-02f, -1.08689182e-01f, 6.48676082e-02f, -1.13214873e-01f, 1.87160056e-02f, -3.09587400e-02f, -6.24925606e-02f, 5.63072637e-02f, -1.00879613e-02f, -1.31903216e-02f,
  4.55521829e-02f, -1.06638419e-02f, -7.35697970e-02f, -1.21772736e-02f, -4.87534255e-02f, 2.04170048e-02f, 4.10254374e-02f, -3.24627087e-02f, 5.42566329e-02f, 6.03991970e-02f,
  -1.27273783e-01f, 3.04884519e-02f, 3.19094025e-02f, -2.81235520e-02f, -1.23519808e-01f, -2.71354318e-02f, -5.74076374e-04f, -3.04466076e-02f, 2.16979366e-02f, 9.03250743e-03f,
  -4.73815873e-02f, -3.54088694e-02f, 2.89471354e-03f, 2.16492359e-02f, -8.12170934e-03f, -8.04517642e-02f, -6.23489432e-02f, -1.23239774e-02f, -4.78209443e-02f, 1.15050264e-01f,
  6.92434609e-02f, 1.58971757e-01f, 7.42057944e-03f, 4.43635462e-03f, 5.02416715e-02f, -1.55118834e-02f, -1.17984571e-01f, -4.61641280e-03f, -9.86452401e-02f, 6.63162321e-02f,
  2.30712052e-02f, 3.56979035e-02f, -3.38514894e-02f, 1.18249379e-01f, 1.96540225e-02f, -7.35278055e-02f, 7.12646693e-02f, 2.20247097e-02f, -1.15872376e-01f, -5.71504943e-02f,
  1.69253543e-01f, 3.18597890e-02f, 1.32530937e-02f, 2.42880359e-01f, -1.41632125e-01f, -2.44010597e-01f, 5.63332662e-02f, -3.73352915e-01f, 1.72750697e-01f, -1.77863121e-01f,
  1.31706178e-01f, 2.17974454e-01f, 2.02697694e-01f, 3.72226760e-02f, 4.99343961e-01f, 3.26649606e-01f, 2.22987622e-01f, 2.25928023e-01f, 3.57362181e-02f, 1.47139251e-01f,
  7.28356466e-02f, -5.54747954e-02f, -1.23144509e-02f, -3.26698810e-01f, -3.02826256e-01f, -2.42834985e-01f, -6.67802989e-02f, -1.88722149e-01f, -7.78391808e-02f, -2.82154907e-03f,
  -1.24010392e-01f, 2.15187646e-03f, -1.08132683e-01f, 5.43064997e-02f, -1.23968348e-03f, -4.93912771e-02f, 5.31952046e-02f, -4.34105583e-02f, 8.80494714e-02f, 6.34219646e-02f,
  8.78566131e-02f, 1.21829785e-01f, 1.74498670e-02f, -5.31314015e-02f, -3.57619971e-02f, 4.17517349e-02f, 1.02621004e-01f, -1.63081422e-01f, -6.17675558e-02f, -5.63703775e-02f,
  -7.24720806e-02f, -2.93990597e-02f, 1.04665585e-01f, 1.35156542e-01f, 9.40870941e-02f, 6.62571788e-02f, -3.21162604e-02f, -6.12208014e-03f, 3.93833406e-03f, -1.01844877e-01f,
  5.46190627e-02f, 2.19610729e-03f, -3.04205641e-02f, -6.28871098e-02f, -4.37400378e-02f, -4.57641147e-02f, 7.33844414e-02f, -3.02724894e-02f, 2.93987617e-03f, -9.36057344e-02f,
  2.92064641e-02f, -1.79616511e-02f, 4.14793789e-02f, -9.38170701e-02f, -1.24493279e-02f, -1.12683713e-01f, 7.04249442e-02f, -1.13402933e-01f, -7.00608715e-02f, -7.02805594e-02f,
  -6.97714686e-02f, 6.51188418e-02f, -6.26522377e-02f, 3.30484053e-03f, -1.70771051e-02f, 5.71111441e-02f, -5.45247607e-02f, -6.49606064e-02f, -6.95829242e-02f, -9.77072306e-03f,
  1.73737735e-01f, 1.00432910e-01f, -3.58242020e-02f, -4.49215919e-02f, 4.66089621e-02f, 2.60989219e-02f, 8.43453407e-02f, 9.21079610e-03f, 4.56893109e-02f, -1.41017688e-02f,
  6.45730346e-02f, 6.32390901e-02f, -1.25546649e-04f, 1.06065273e-02f, 1.80725437e-02f, -4.31927592e-02f, 4.96411808e-02f, 9.37829614e-02f, -2.69523710e-02f, 6.54428825e-02f,
  4.45681065e-02f, 3.39360759e-02f, 3.40536074e-03f, -1.31704643e-01f, -1.03626013e-01f, -1.59350485e-02f, 1.07172700e-02f, -4.56139408e-02f, -3.27221043e-02f, 1.63111523e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.89126258e-02f, -1.86868954e+00f, 3.10289294e-01f, -3.22618723e-01f, 6.98413312e-01f, 2.15070754e-01f, 1.46832868e-01f, -3.77983868e-01f, -5.15434504e-01f, -1.35670853e+00f,
  -1.43109679e-01f, -3.39823604e-01f, -3.97628874e-01f, -4.29567605e-01f, 1.28724098e+00f, -3.21520329e-01f, -2.30284035e-01f, -6.11753948e-02f, 2.00491585e-02f, -1.88627675e-01f,
  5.63202679e-01f, -6.43374994e-02f, 6.40076160e-01f, -7.55992010e-02f, 2.03001946e-01f, 1.02914639e-01f, 2.23618448e-01f, 4.94091332e-01f, -1.73857793e-01f, 3.64118308e-01f,
  -4.99376319e-02f, -2.91263312e-01f, 2.08539695e-01f, -5.96889900e-03f, -1.05373293e-01f, 6.92332089e-02f, 7.83178881e-02f, 4.31495845e-01f, 3.60172391e-01f, -9.77923796e-02f,
  -1.90070551e-02f, 1.41445875e-01f, 1.76398479e-03f, 2.32499465e-01f, -1.10433161e-01f, -1.35150934e-02f, 9.89639461e-02f, 1.94749553e-02f, -2.02080175e-01f, 8.50249231e-02f,
  1.08867712e-01f, -8.72616172e-02f, 1.13445908e-01f, -1.50575563e-01f, 1.93142101e-01f, 1.30065262e-01f, -4.07440178e-02f, 6.48368225e-02f, -3.54671814e-02f, 5.03035150e-02f,
  -7.03586265e-02f, 4.19185013e-02f, -7.55373016e-02f, -1.42369047e-02f, -1.54176086e-01f, 3.16724405e-02f, -8.33945423e-02f, -1.25938114e-02f, 1.63208663e-01f, -1.62319526e-01f,
  1.10224068e-01f, -1.03114374e-01f, 3.46579850e-02f, -9.36307237e-02f, 2.13933289e-02f, -1.90473750e-01f, 1.31545022e-01f, 5.71429953e-02f, 5.57423569e-02f, 4.13497910e-02f,
  4.81898859e-02f, 1.06927842e-01f, -8.50577280e-02f, 1.29584432e-01f, 2.23547649e-02f, -7.16924816e-02f, 1.95019227e-02f, -2.50262260e-01f, 9.73414034e-02f, 2.94937938e-01f,
  -7.83726454e-01f, -1.33411908e+00f, -9.62977558e-02f, -4.94908094e-02f, -6.53951168e-02f, -5.28504960e-02f, 1.13142505e-01f, -3.01328838e-01f, -2.33236462e-01f, 1.96087803e-03f,
  1.06909059e-01f, 2.68727273e-01f, -2.36153364e-01f, 1.59912586e-01f, 1.39160469e-01f, -6.15441352e-02f, -2.14853249e-02f, -1.77130923e-02f, 6.65391013e-02f, -1.35903747e-05f,
  -8.87977481e-02f, -2.85811815e-02f, 2.02538356e-01f, 5.75262606e-02f, -1.20459184e-01f, -6.48515746e-02f, -1.62722856e-01f, -1.11868810e-02f, -6.02123253e-02f, -1.23512827e-01f,
  6.29809797e-01f, 1.48824796e-01f, 1.08051598e+00f, 9.08478796e-02f, 5.47034713e-03f, -1.00809544e-01f, -3.87776673e-01f, 3.33451837e-01f, 1.31603742e+00f, -4.09362406e-01f,
  -7.25327909e-01f, 3.96919519e-01f, -2.18844727e-01f, -5.50041616e-01f, 7.62766480e-01f, 2.33941257e-01f, 1.95284888e-01f, -5.91902295e-04f, 5.02107382e-01f, -1.62063211e-01f,
  3.62486273e-01f, -1.00144911e+00f, 6.50702491e-02f, -4.77284431e-01f, -3.91624153e-01f, 2.64682062e-02f, -1.08181107e+00f, 3.74391326e-03f, -7.28335500e-01f, -5.78286499e-02f,
  -1.04679033e-01f, 4.85444665e-02f, -7.67168254e-02f, 2.60662764e-01f, 1.04261957e-01f, 8.51868093e-02f, -1.06972173e-01f, -7.28951320e-02f, 1.05957434e-01f, 1.24769591e-01f,
  -8.19357336e-02f, -1.93819730e-03f, -6.51349276e-02f, 1.16020046e-01f, 2.76630878e-01f, 1.84811488e-01f, 1.93626717e-01f, -3.26008871e-02f, 3.96699943e-02f, 1.89384073e-01f,
  4.39880431e-01f, 2.81102419e-01f, 1.02195472e-01f, -1.03629552e-01f, -2.77699102e-02f, 1.88892484e-02f, 7.22350031e-02f, 2.35104095e-02f, 3.36539075e-02f, 2.04794943e-01f,
  -8.64365026e-02f, 1.48126349e-01f, -1.20093234e-01f, -4.97041978e-02f, -9.40929949e-02f, 6.92458227e-02f, -1.19372951e-02f, -2.21038297e-01f, 1.15103565e-01f, -9.90864933e-02f,
  -1.99137732e-01f, -4.89714108e-02f, 2.23783404e-03f, 1.40634283e-01f, -1.20118158e-02f, 3.52433920e-02f, -6.75326213e-02f, 6.85823523e-03f, 7.67741203e-02f, 7.23746940e-02f,
  -7.67724440e-02f, 4.93254326e-02f, -1.36589095e-01f, 9.93695557e-02f, 8.38941708e-02f, 1.13433443e-01f, -4.82197739e-02f, 1.11554295e-01f, 9.12239868e-03f, -1.30240619e-01f,
  -2.03340098e-01f, -3.60365927e-01f, -7.91132227e-02f, -1.00598775e-01f, -1.26273051e-01f, -1.32227823e-01f, 9.97398123e-02f, 4.88979854e-02f, 6.10681958e-02f, -9.25851092e-02f,
  8.10798034e-02f, -1.62570596e-01f, -1.10278539e-01f, -4.13485207e-02f, -9.86668020e-02f, -2.31834650e-02f, -1.10387594e-01f, -9.35397074e-02f, -2.11297140e-01f, -4.70551774e-02f,
  -5.11797629e-02f, -1.02985054e-01f, 7.80832991e-02f, 1.38532650e-03f, -2.71666888e-02f, -1.73066080e-01f, 2.69855857e-02f, 1.34923115e-01f, -9.25304741e-02f, -3.20270192e-03f,
  1.16644394e+00f, -1.81371525e-01f, 7.89873838e-01f, 8.12044322e-01f, -6.12949841e-02f, -1.57839790e-01f, 1.09315586e+00f, -4.86550391e-01f, 4.26789038e-02f, -5.59791505e-01f,
  2.44202185e-03f, 5.75972676e-01f, 1.02638394e-01f, -1.52640492e-01f, -2.94447690e-01f, -5.33807635e-01f, -3.71721834e-01f, 1.55707762e-01f, -1.53040811e-01f, -4.21686843e-02f,
  -6.10116608e-02f, -8.91528547e-01f, 1.29102573e-01f, -1.15661490e+00f, 4.80617642e-01f, -5.36773503e-02f, -5.04427850e-01f, 1.49843052e-01f, -2.30209053e-01f, 4.81427833e-02f,
  -1.77924320e-01f, -5.60790151e-02f, 2.03886360e-01f, -4.95058112e-02f, -1.11924425e-01f, 1.46702444e-02f, 2.98344493e-01f, 1.49318308e-01f, 9.00040939e-02f, -9.73390937e-02f,
  3.87828380e-01f, -3.06720138e-01f, -1.82599902e-01f, -3.91551144e-02f, -2.17610478e-01f, -2.27184333e-02f, -7.85477906e-02f, 1.86334983e-01f, 2.64545828e-01f, 1.55462697e-01f,
  2.81652421e-01f, 1.17363386e-01f, 1.19917780e-01f, 2.73040235e-02f, 1.92191079e-01f, -1.20772488e-01f, 1.10353179e-01f, 3.76995057e-01f, -7.80345649e-02f, -1.80834770e-01f,
  -5.99277625e-03f, -2.30424199e-02f, 1.50135756e-01f, -1.50932699e-01f, -2.98765190e-02f, -5.68536520e-02f, -1.13213537e-02f, 3.75917107e-02f, 1.29966483e-01f, -1.02311984e-01f,
  -1.35136530e-01f, 1.12814739e-01f, -1.91784024e-01f, 7.95189291e-02f, 1.79272965e-01f, 1.06059499e-01f, 9.56292525e-02f, -4.44042124e-02f, -1.81459948e-01f, -4.23048399e-02f,
  3.66248749e-02f, -7.73608387e-02f, -1.02247484e-01f, 3.31682377e-02f, -1.06968373e-01f, 2.39599258e-01f, -1.39619961e-01f, 2.41352051e-01f, 1.23027325e-01f, 8.88272002e-02f,
  -1.08013976e+00f, -1.09970284e+00f, -1.02553010e-01f, 5.97877204e-02f, -1.08025044e-01f, -4.74541411e-02f, 7.35295238e-03f, -1.30024910e-01f, -1.44247949e-01f, 1.56089544e-01f,
  -1.83161467e-01f, 9.04745832e-02f, -1.35419890e-01f, -8.41078982e-02f, -9.84549820e-02f, -1.91800460e-01f, -6.47422895e-02f, -1.35967344e-01f, -1.14387646e-01f, -2.79642493e-02f,
  1.94935780e-02f, 2.10502534e-03f, -2.57789772e-02f, -3.09763942e-02f, 1.08213857e-01f, 1.27250627e-01f, 9.39099714e-02f, -1.01246618e-01f, 5.44537716e-02f, -2.65762985e-01f,
  -3.77599932e-02f, 3.19880098e-01f, 3.00477743e-01f, 6.34260297e-01f, -1.21464804e-01f, -8.15880060e-01f, -1.01891494e+00f, 7.04643250e-01f, -4.14298117e-01f, -2.87983082e-02f,
  1.05441459e-01f, -1.31323785e-01f, -6.77569270e-01f, 5.00762939e-01f, -6.17939770e-01f, -1.03117168e+00f, 1.58829674e-01f, 9.15915817e-02f, -2.64275879e-01f, 6.78009272e-01f,
  2.12725043e-01f, 2.57050753e-01f, 3.03670257e-01f, 7.16649950e-01f, 2.87552685e-01f, 9.23293710e-01f, 9.10405040e-01f, 1.73210084e-01f, 1.14380765e+00f, -1.61045603e-02f,
  -2.80694991e-01f, 2.41387188e-01f, -2.95642745e-02f, -5.90984151e-02f, 2.40043432e-01f, 9.72040147e-02f, -8.61426219e-02f, -1.65931061e-01f, -6.59193657e-03f, 2.05203027e-01f,
  -8.54695141e-02f, -4.76218127e-02f, 2.45443761e-01f, -1.91283301e-01f, 7.10942224e-02f, 3.33684891e-01f, 1.23173155e-01f, -1.97578952e-01f, -5.41085042e-02f, 1.21034592e-01f,
  1.76305801e-01f, 2.01725855e-01f, 1.88500822e-01f, 3.14476229e-02f, 2.43811548e-01f, -1.57760859e-01f, 6.31723702e-02f, 8.40023831e-02f, 6.69799969e-02f, 1.85329035e-01f,
  2.38938123e-01f, -1.26429036e-01f, -7.82562494e-02f, -1.08483180e-01f, -1.03127636e-01f, 2.70930361e-02f, 1.50404754e-03f, -1.10604621e-01f, -8.54962245e-02f, -1.13509528e-01f,
  -1.01456858e-01f, 4.56110982e-04f, 8.05291533e-02f, -7.41943642e-02f, 1.39586151e-01f, 2.18697980e-01f, -1.48005739e-01f, 1.77956447e-01f, 1.22315325e-01f, 5.53403655e-03f,
  1.87487602e-01f, -6.82245642e-02f, -1.13717824e-01f, -2.17654645e-01f, -1.17427923e-01f, 1.33140519e-01f, 2.28704765e-01f, 3.76450852e-03f, -4.93007638e-02f, 1.20882294e-03f,
  1.67201698e-01f, 6.05068207e-01f, -2.08595410e-01f, 1.74387079e-02f, -9.47488472e-02f, -1.30504355e-01f, -2.13386312e-01f, 2.73652643e-01f, 2.42267743e-01f, -3.78840029e-01f,
  2.49258518e-01f, 1.41896293e-01f, -1.97044536e-02f, -2.49462537e-02f, 2.18287066e-01f, 1.43652679e-02f, 2.09624603e-01f, -8.70895199e-03f, 2.56211996e-01f, 3.50752026e-01f,
  5.22430122e-01f, -6.58989772e-02f, 1.63028449e-01f, -8.66908729e-02f, 2.35534534e-01f, 8.11848789e-02f, -2.36296654e-02f, -4.23347466e-02f, 2.18951449e-01f, 1.22655537e-02f,
  1.35532737e+00f, -2.97880083e-01f, -9.67383087e-01f, 3.74155372e-01f, 5.76082766e-01f, 1.09821475e+00f, 7.30873287e-01f, 4.75617886e-01f, 6.39610410e-01f, 5.49317338e-02f,
  4.22072649e-01f, -3.72003734e-01f, -6.07735574e-01f, 9.20418739e-01f, 3.56895447e-01f, -3.46625239e-01f, 7.79375434e-01f, 3.35375756e-01f, 4.41620015e-02f, 2.78054088e-01f,
  3.44669551e-01f, 9.61889625e-01f, -7.65495718e-01f, 2.56957293e-01f, 5.90178967e-01f, -2.93068826e-01f, -4.68214035e-01f, -5.48505843e-01f, -2.62201130e-02f, 1.96984038e-01f,
  3.23733687e-02f, 5.67127503e-02f, -1.51848659e-01f, -5.77827021e-02f, 7.40901753e-03f, -6.76145181e-02f, -3.08173239e-01f, -2.60327220e-01f, -9.99252275e-02f, -2.10882295e-02f,
  4.78165187e-02f, -1.14072904e-01f, 2.34166607e-01f, -3.41501646e-02f, 2.99116313e-01f, -1.89574845e-02f, 2.75422465e-02f, -9.79924351e-02f, -3.31432790e-01f, 1.30450338e-01f,
  2.39630118e-02f, -2.21578404e-01f, 8.93637389e-02f, -7.16511235e-02f, -1.51948676e-01f, 2.17414349e-01f, -3.13076973e-02f, -2.01304525e-01f, -7.94912279e-02f, 3.07715267e-01f,
  1.10973060e-01f, 4.07294333e-02f, 5.38633280e-02f, -2.21888535e-02f, -7.04654604e-02f, -9.22205448e-02f, -5.21449335e-02f, -2.03843012e-01f, -6.44313246e-02f, -5.23318239e-02f,
  4.31018658e-02f, -5.16026020e-02f, 1.51141062e-01f, 1.24782786e-01f, 2.08870947e-01f, 1.42241240e-01f, -8.38323757e-02f, 6.57147989e-02f, 4.65677045e-02f, -6.24951050e-02f,
  -4.27344553e-02f, 1.18256830e-01f, -1.87767655e-01f, 5.01395762e-02f, -6.73607811e-02f, -1.47360295e-01f, 1.22270361e-01f, 1.05739281e-01f, -1.24357224e-01f, -9.00321305e-02f,
  -9.69201997e-02f, -1.40210062e-01f, -1.46906432e-02f, -5.43798581e-02f, -4.45134789e-02f, 1.63586587e-01f, 7.45642930e-02f, 1.87981963e-01f, -8.68136659e-02f, 1.32770360e-01f,
  1.02931902e-01f, 1.13113150e-01f, 1.24546466e-02f, 8.85937214e-02f, -2.49501139e-01f, 9.98518988e-02f, -6.03287630e-02f, 1.21014073e-01f, 5.59139811e-02f, -1.84664458e-01f,
  -3.51894982e-02f, 1.22081243e-01f, 1.04520842e-02f, -5.59472777e-02f, 1.09268509e-01f, -3.78108174e-02f, 2.04331875e-02f, -7.46207833e-02f, -4.40927073e-02f, -1.61798745e-01f,
  -2.56219506e+00f, 7.46615469e-01f, 3.67364377e-01f, -8.46415341e-01f, -1.36745021e-01f, 3.22389781e-01f, 2.26143181e-01f, 2.85361856e-01f, -2.22053498e-01f, 5.11271477e-01f,
  6.13694526e-02f, -2.99314141e-01f, 9.33769882e-01f, 6.88026071e-01f, -6.53562963e-01f, 9.80558038e-01f, -2.38272116e-01f, -2.85782851e-02f, 1.55089170e-01f, -4.33328450e-01f,
  -4.75601822e-01f, 7.71121830e-02f, 2.14214295e-01f, 2.64904946e-01f, -2.77968138e-01f, -5.27901471e-01f, -4.95369345e-01f, 2.66104937e-01f, -1.60760164e-01f, 1.13291197e-01f,
  -7.92740703e-01f, -5.86551785e-01f, -1.52853146e-01f, -1.75804049e-01f, -2.60640204e-01f, -2.62918979e-01f, -1.83270052e-01f, 3.67037877e-02f, -2.29632869e-01f, -6.89348727e-02f,
  5.23121282e-02f, 1.59125049e-02f, -1.68852121e-01f, 1.49691999e-01f, -1.79080829e-01f, -9.45199281e-02f, 1.53924152e-01f, -5.28095588e-02f, 1.31211225e-02f, 2.21788049e-01f,
  5.15357971e-01f, 5.41454703e-02f, -1.65167496e-01f, -6.39976040e-02f, 2.13425774e-02f, 3.53067406e-02f, 1.49431005e-01f, 8.14105943e-02f, -7.70319179e-02f, -2.17611313e-01f,
  5.46317250e-02f, -7.63683170e-02f, 2.61102736e-01f, -1.06205903e-01f, 4.70325723e-02f, -1.55562520e-01f, 1.54829621e-01f, -3.30719426e-02f, -9.46309492e-02f, 2.76119392e-02f,
  -1.67565078e-01f, -2.05414072e-01f, -9.27771032e-02f, -1.84173752e-02f, 2.38166610e-03f, -2.40257196e-02f, 3.31446640e-02f, -1.86563000e-01f, -1.87144667e-01f, -2.19258383e-01f,
  6.76979870e-02f, -7.13422000e-02f, 1.78807542e-01f, -1.88889522e-02f, -1.08259469e-01f, 1.96698487e-01f, -2.47194529e-01f, -3.93681116e-02f, -6.46282956e-02f, -2.26222768e-01f,
  -1.26966059e+00f, -1.20551395e+00f, 1.27172604e-01f, -2.04574674e-01f, -1.45279184e-01f, -3.83358598e-02f, 7.85145909e-02f, 7.94306099e-02f, -1.77469224e-01f, -7.03638196e-02f,
  -8.69849622e-02f, -6.97266981e-02f, -2.01334387e-01f, 3.48632596e-02f, -1.68573782e-02f, 3.49770561e-02f, -1.15036547e-01f, -7.80581683e-02f, -2.97058314e-01f, -2.63378650e-01f,
  -8.66900235e-02f, -1.89449206e-01f, 1.25227585e-01f, -1.32679909e-01f, 3.30245458e-02f, -1.85856938e-01f, -2.61403650e-01f, 9.54494551e-02f, -2.28278279e-01f, 1.29080802e-01f,
  5.94816744e-01f, 3.47350389e-01f, -4.35479552e-01f, -2.17060119e-01f, -6.88472614e-02f, -1.30299532e+00f, -9.21873510e-01f, -2.99412936e-01f, 2.70355433e-01f, 2.98490711e-02f,
  -3.54229152e-01f, 6.26750529e-01f, 6.99997768e-02f, -4.67528641e-01f, -8.13645601e-01f, 1.92325946e-03f, -1.04188514e+00f, -1.45021170e-01f, 3.58616889e-01f, -4.20253843e-01f,
  -1.57753944e-01f, -3.73539567e-01f, -4.59526658e-01f, 1.69553563e-01f, -3.39415699e-01f, 1.88078001e-01f, -1.67054981e-01f, 3.31576824e-01f, -2.39689887e-01f, 1.28696546e-01f,
  -7.12980703e-02f, 5.76334000e-01f, -3.93899642e-02f, 5.41945584e-02f, -4.87960577e-01f, -4.31848466e-02f, -4.76868115e-02f, 7.62736052e-02f, 2.47029468e-01f, 6.71713799e-02f,
  1.90589428e-01f, 2.90503174e-01f, -1.52328713e-02f, 1.21626526e-01f, 2.99181789e-01f, 2.27894172e-01f, 1.47405550e-01f, -1.84332296e-01f, 9.67763439e-02f, 1.32217303e-01f,
  -6.12414144e-02f, -2.61950213e-02f, -9.84666646e-02f, 2.22908352e-02f, 4.87914123e-02f, 1.11905716e-01f, -1.62165254e-01f, -1.15733422e-01f, -5.86677566e-02f, 1.86675519e-01f,
  2.22203046e-01f, -3.74384969e-02f, -2.18601096e-02f, 8.57429951e-02f, -7.42600933e-02f, -8.91898666e-03f, 6.26498237e-02f, -3.79981995e-02f, -6.27155229e-03f, -5.33516854e-02f,
  -8.03879723e-02f, 6.92966804e-02f, 1.87696740e-01f, -1.39916807e-01f, -5.51899336e-02f, 2.31973335e-01f, 1.37074040e-02f, 2.08674029e-01f, -3.90433937e-01f, -2.58544803e-01f,
  2.68697828e-01f, -9.68466252e-02f, 1.30421552e-03f, 9.54579860e-02f, -6.08385429e-02f, 4.81072702e-02f, 5.81753217e-02f, 1.92570195e-01f, -1.88164413e-01f, -3.13053042e-01f,
  -3.90992194e-01f, -3.26686591e-01f, -7.00162575e-02f, 1.17372870e-01f, -1.22090504e-02f, -1.69511616e-01f, -2.99155354e-01f, -1.12565026e-01f, -1.24477461e-01f, -1.48017779e-01f,
  -1.06411979e-01f, -7.49448612e-02f, -1.23893820e-01f, 9.61955711e-02f, -4.00790833e-02f, -2.48287752e-01f, -3.40692252e-02f, 6.41787350e-02f, -2.95056134e-01f, -4.71781678e-02f,
  6.39024898e-02f, 1.18168555e-01f, 2.97137704e-02f, -1.91356570e-01f, -5.48411943e-02f, -3.93989049e-02f, -3.19230705e-02f, 1.68758288e-01f, 4.96760085e-02f, -1.49058789e-01f,
  -6.57198489e-01f, -5.60439229e-01f, -5.27568638e-01f, -1.26892304e+00f, 3.44834715e-01f, -3.19959819e-02f, -9.68046188e-01f, 5.16503565e-02f, -7.81466186e-01f, 2.70214707e-01f,
  4.86797094e-02f, -6.60093427e-01f, 3.46918970e-01f, -1.26378107e+00f, -5.24989665e-01f, -4.80212271e-01f, -9.79655981e-01f, -6.75591350e-01f, -2.15281039e-01f, -2.68265784e-01f,
  -3.25413972e-01f, -6.97320223e-01f, -7.42958248e-01f, 4.41297829e-01f, -4.08273607e-01f, 8.68626088e-02f, 6.97253048e-01f, 3.75999391e-01f, -9.76881757e-02f, -3.55264664e-01f,
  -3.63232732e-01f, -3.28816473e-01f, -1.06982209e-01f, 1.10098727e-05f, 2.49756202e-01f, 2.32339591e-01f, 7.50291124e-02f, -1.13109306e-01f, -1.10363156e-01f, -1.78299859e-01f,
  1.82892069e-01f, 8.08961981e-04f, -4.03863579e-01f, 4.67604585e-02f, 6.85270280e-02f, 8.84505361e-03f, -8.99385959e-02f, 7.12679327e-02f, -5.86793572e-03f, -2.02648908e-01f,
  -2.42241308e-01f, 5.87835275e-02f, 1.27292708e-01f, -7.31987506e-02f, -3.42883244e-02f, -5.36981374e-02f, -4.21913825e-02f, 1.53648630e-01f, 1.26558766e-01f, 9.83245894e-02f,
  6.75082058e-02f, 1.28032938e-01f, 1.24888614e-01f, -6.55758679e-02f, -2.61123432e-03f, -1.37702584e-01f, 3.36586162e-02f, -9.25350338e-02f, -6.35574460e-02f, 5.23245446e-02f,
  7.24263489e-03f, -1.52908817e-01f, -9.55927223e-02f, -4.45256941e-02f, -1.32613694e-02f, -1.39333680e-01f, 4.15173210e-02f, 5.81634827e-02f, -4.12165523e-01f, -2.03626320e-01f,
  -3.47697549e-02f, 1.86044257e-02f, -1.78632006e-01f, 1.17163777e-01f, 1.74194112e-01f, 9.64923128e-02f, 2.13369131e-01f, -5.92324659e-02f, -1.37661010e-01f, 9.12114009e-02f,
  -5.29933423e-02f, 6.60042316e-02f, -3.53641063e-01f, -4.47952636e-02f, -6.36182129e-02f, 1.43286977e-02f, -8.20896402e-02f, -3.63176048e-01f, -8.59512463e-02f, 1.91298947e-01f,
  1.99490204e-01f, 9.20071006e-02f, 4.73037004e-01f, -4.98972610e-02f, -1.04690500e-01f, -5.71669377e-02f, 1.71528548e-01f, -3.03080957e-02f, -6.15768656e-02f, 1.20762378e-01f,
  1.99799657e-01f, 1.22124158e-01f, -8.27365369e-02f, 7.68627748e-02f, 1.28044501e-01f, 1.02300383e-01f, 4.11802754e-02f, -5.45186996e-02f, 2.01389883e-02f, 1.59171969e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  8.49135578e-01f, 1.75316441e+00f, 8.47067177e-01f, 1.35834253e+00f, 1.30637920e+00f, 1.10538244e+00f, 3.78773898e-01f, 1.06349063e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  1.11228502e+00f, 7.44786203e-01f, -1.78899169e+00f, 6.22407019e-01f, -1.76630288e-01f, -1.38064575e+00f, -6.96542859e-01f, 1.25138223e+00f, -8.86350334e-01f, -2.20698380e+00f,
  6.90703690e-02f, -6.71592534e-01f, -4.01854098e-01f, 1.22047126e+00f, -1.04996765e+00f, -1.10119665e+00f, 1.24650247e-01f, -7.94396363e-03f, -3.83934587e-01f, 1.17032540e+00f,
  -1.78808963e+00f, 1.63242292e+00f, -9.59380567e-01f, 8.45944703e-01f, -1.00794554e+00f, -2.31144738e+00f, -1.14570129e+00f, -1.93247721e-01f, 1.42286086e+00f, -8.88647676e-01f,
  4.49912846e-01f, -5.41288480e-02f, -1.40236723e+00f, -8.88669372e-01f, -7.10167348e-01f, -1.19907475e+00f, 4.22737092e-01f, 1.06031799e+00f, 7.15734661e-02f, -8.21593106e-01f,
  1.12367892e+00f, -1.16767609e+00f, -9.90685225e-01f, 4.05768245e-01f, 4.10300910e-01f, -1.33190703e+00f, -1.54081511e+00f, -1.33118939e+00f, -1.14609778e+00f, -9.67502475e-01f,
  2.44322494e-01f, -9.15722787e-01f, 4.95289981e-01f, -1.03752398e+00f, 1.43853736e+00f, -1.27898824e+00f, -1.79923248e+00f, -1.18670237e+00f, -1.14140403e+00f, -3.54996145e-01f,
  -1.16319132e+00f, 8.40033591e-01f, 1.02316535e+00f, 2.70177633e-01f, 3.43683928e-01f, 3.29519182e-01f, 1.12083590e+00f, 8.83373499e-01f, -8.91555011e-01f, 1.48828638e+00f,
  -2.76600569e-01f, -2.25075197e+00f, 4.75611210e-01f, 7.49704361e-01f, -8.54891300e-01f, -9.25048828e-01f, -2.11208463e+00f, 8.26239944e-01f, -1.47311115e+00f, 1.45029858e-01f,
  5.04988968e-01f, 9.08346295e-01f, 1.06000304e+00f, -4.99562442e-01f, 2.50567937e+00f, 8.54722112e-02f, -1.45589483e+00f, 1.49936044e+00f, -2.10997009e+00f, 1.16221881e+00f,
  -2.92205185e-01f, -6.27969265e-01f, 4.15630698e-01f, -4.45058405e-01f, -1.17127407e+00f, -9.59127367e-01f, 3.95635515e-01f, -6.04615092e-01f, -2.42681369e-01f, -3.38452220e-01f,
  -1.18224311e+00f, -1.81083810e+00f, 2.07995558e+00f, -1.52485144e+00f, 1.96001291e-01f, 7.75158763e-01f, 4.95482236e-01f, -8.72980177e-01f, 6.56182289e-01f, -1.80010188e+00f,
  -7.14325845e-01f, -1.28936923e+00f, 6.88129425e-01f, -9.51288402e-01f, 3.22158486e-01f, -5.38129330e-01f, -9.60292757e-01f, -4.64470774e-01f, -8.80485594e-01f, 1.40131700e+00f,
  -6.95610642e-01f, 5.96436083e-01f, -5.16835034e-01f, -1.31192172e+00f, -1.52256978e+00f, -4.99531835e-01f, 1.01503909e+00f, 5.11702895e-01f, 2.58754492e-01f, -6.79961383e-01f,
  7.38990664e-01f, -4.56997892e-03f, -8.18409979e-01f, -1.60230029e+00f, 4.47248399e-01f, 6.63904071e-01f, -2.36445129e-01f, -2.26457208e-01f, -1.08185196e+00f, 1.24483454e+00f,
  -1.09136009e+00f, -6.51483178e-01f, -4.72325593e-01f, -9.68508661e-01f, 1.93246827e-01f, 3.13734859e-01f, 7.14964271e-01f, -8.22542980e-03f, -2.21193269e-01f, 5.98663211e-01f,
  -1.39962006e+00f, 1.21848106e+00f, 1.16142094e+00f, -1.47970900e-01f, 9.34272826e-01f, -1.35915864e+00f, -1.24584472e+00f, -2.92857081e-01f, -8.97695363e-01f, -7.83416450e-01f,
  4.63524163e-01f, 6.43997788e-01f, 1.21504031e-01f, -6.51366234e-01f, 1.19259846e+00f, 6.02697074e-01f, 8.36863101e-01f, -8.55538070e-01f, -5.91012061e-01f, -9.86740708e-01f,
  -1.06678128e+00f, 3.86235774e-01f, -4.78068560e-01f, -9.49998081e-01f, -8.51184487e-01f, 1.39539051e+00f, -9.35230315e-01f, 2.09544823e-01f, -2.80188203e-01f, 4.82382447e-01f,
  1.00459301e+00f, 7.34300077e-01f, 1.12118471e+00f, -1.08065915e+00f, -1.61136580e+00f, 6.39062107e-01f, 1.23535800e+00f, 2.37852141e-01f, -1.11688542e+00f, -1.00236607e+00f,
  5.72039247e-01f, -1.15742755e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  6.23396575e-01f, -1.89593688e-01f, -2.48726428e-01f, -4.06891793e-01f, 6.42180443e-01f, 8.55706394e-01f, -6.63646877e-01f, -6.69358790e-01f, -9.30543467e-02f, -4.51049656e-01f,
  -3.76652867e-01f, -3.11581850e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    