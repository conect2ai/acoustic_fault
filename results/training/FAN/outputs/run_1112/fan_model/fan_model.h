/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.91133377e-02f, 1.59361497e-01f, 3.44085470e-02f, -2.69912314e-02f, -4.00954753e-01f, -2.70242155e-01f, -1.29871145e-01f, -9.52795744e-02f, -4.77303714e-02f, 7.83000216e-02f,
  -4.56922613e-02f, 6.30962253e-02f, 4.62448895e-02f, 1.24211960e-01f, 1.90981463e-01f, 1.39922142e-01f, 1.40552148e-01f, 5.33926301e-02f, -7.10729957e-02f, -9.32854414e-02f,
  4.87292223e-02f, 7.69479424e-02f, 1.80379376e-01f, 1.14648968e-01f, 3.36632058e-02f, 1.07748404e-01f, 2.75183618e-02f, 2.82883756e-02f, 3.11223627e-03f, 1.17781065e-01f,
  1.14771962e-01f, -8.87342989e-02f, 1.20425753e-01f, 2.19858233e-02f, -3.55092883e-02f, 1.34333447e-01f, 8.05181563e-02f, -4.44422243e-03f, 4.98919515e-03f, 2.27074642e-02f,
  8.89265984e-02f, -5.48858643e-02f, 4.97801118e-02f, 3.71734574e-02f, -2.48218104e-02f, 1.19910002e-01f, 1.39403939e-01f, 1.90581128e-01f, 1.44112766e-01f, 1.07337788e-01f,
  5.32331057e-02f, -1.15655459e-01f, 2.82006841e-02f, 8.88600200e-02f, 2.80076042e-02f, -3.75506319e-02f, 2.52957493e-02f, 7.53058493e-02f, -3.05449609e-02f, 1.20613568e-01f,
  -9.15398225e-02f, -4.96103577e-02f, -3.50269675e-02f, -9.12191346e-02f, 1.59667544e-02f, -1.79906692e-02f, -1.24183972e-03f, -3.45242880e-02f, 3.71369161e-02f, 6.43280707e-03f,
  -5.72239459e-02f, -3.09841875e-02f, 3.22274081e-02f, -1.70978066e-02f, 5.47262989e-02f, -1.07070021e-01f, -2.76701599e-02f, 5.70670068e-02f, -5.50209917e-02f, 8.56132992e-03f,
  4.31343280e-02f, -5.04752845e-02f, 2.00573429e-02f, 1.01201430e-01f, -2.19710097e-02f, 3.25724743e-02f, 2.23156568e-02f, 6.94419909e-03f, -4.37862128e-02f, -1.19371325e-01f,
  2.22985372e-01f, 2.56712083e-02f, 7.94908926e-02f, 2.24120077e-02f, -5.47944717e-02f, 9.57610309e-02f, -5.96059998e-03f, 6.45482913e-02f, -1.64704658e-02f, 1.37343612e-02f,
  -3.55977789e-02f, -2.28078216e-02f, 1.59470916e-01f, 1.69586614e-01f, 2.29936298e-02f, 3.33609506e-02f, 7.51403943e-02f, 1.09734945e-02f, -6.27510576e-03f, 1.18843250e-01f,
  9.80829671e-02f, 5.94987795e-02f, -6.95423484e-02f, 1.10406823e-01f, -3.01238690e-02f, -2.39949375e-02f, 1.11148879e-01f, 1.23346858e-01f, -1.25259953e-02f, 1.50662526e-01f,
  1.27303019e-01f, -1.31524444e-01f, -1.53992206e-01f, -1.28944255e-02f, -7.17875659e-02f, 1.25364453e-01f, 7.33800307e-02f, 1.26843125e-01f, 9.78762135e-02f, 5.49710654e-02f,
  9.40878913e-02f, 1.94781482e-01f, 4.02531549e-02f, 1.86118647e-01f, 1.60226256e-01f, 6.94703385e-02f, -5.19428067e-02f, -7.40541145e-02f, 1.60567686e-01f, 2.24580735e-01f,
  1.83332991e-02f, 9.98735242e-03f, 3.73747125e-02f, -7.58831799e-02f, -6.71161637e-02f, 4.25177477e-02f, 1.56420320e-02f, -1.16039187e-01f, -1.10330418e-01f, -1.71132699e-01f,
  8.00376385e-02f, -4.73967940e-02f, 1.19115368e-01f, 5.56769706e-02f, 2.95235049e-02f, 7.47951958e-03f, -1.64681897e-02f, -6.55941218e-02f, 9.47885066e-02f, -9.81638860e-03f,
  -2.90537775e-02f, 7.12675080e-02f, -1.13037780e-01f, 4.36256565e-02f, -4.58344407e-02f, 8.65754858e-03f, 5.19803688e-02f, 1.13684043e-01f, 6.11292422e-02f, 5.50283454e-02f,
  5.40011749e-02f, 3.78033854e-02f, 6.35003075e-02f, 7.83139542e-02f, 9.24774073e-03f, 7.41630346e-02f, -4.78680618e-03f, 2.81850565e-02f, -2.44689044e-02f, 1.18617505e-01f,
  8.17604288e-02f, 1.49002597e-01f, -2.63577197e-02f, 1.67799685e-02f, -6.32291602e-04f, -8.63803700e-02f, 4.78472281e-03f, -5.92287853e-02f, 5.87236993e-02f, 8.07038695e-03f,
  4.08850089e-02f, 1.58010088e-02f, -8.01501200e-02f, 3.93559225e-02f, -1.14962488e-01f, -4.38849851e-02f, 1.76044609e-02f, -7.07849860e-02f, -1.16300188e-01f, -8.67680013e-02f,
  -1.04311496e-01f, -2.72451155e-02f, -7.36051127e-02f, -8.60101283e-02f, -7.85039291e-02f, -2.31385287e-02f, -7.09347054e-02f, -9.53227133e-02f, -7.93552622e-02f, -2.06359290e-02f,
  1.43195614e-01f, 4.65577543e-02f, 2.35993806e-02f, 5.17808199e-02f, -1.18135549e-02f, 5.11769280e-02f, 1.60788782e-02f, 8.19638222e-02f, 1.01848785e-02f, -5.98112773e-03f,
  -2.13404074e-02f, 8.13155249e-02f, 4.09206748e-03f, 5.56325465e-02f, 1.23387530e-01f, 2.41974872e-02f, 4.91310246e-02f, 9.28601623e-02f, 1.80478953e-02f, 4.95698638e-02f,
  -7.44507834e-03f, 9.94394049e-02f, 1.06787056e-01f, -6.80836244e-03f, -1.32597191e-02f, 2.95031797e-02f, 1.40242651e-01f, 1.53936982e-01f, 5.57347611e-02f, 1.68405741e-01f,
  9.98661220e-02f, 8.40519145e-02f, 2.07609117e-01f, 3.10547594e-02f, -1.10625342e-01f, 4.83530797e-02f, 9.64252204e-02f, 1.77887574e-01f, -1.49515900e-03f, 8.09653196e-03f,
  -1.40743256e-01f, -1.93146259e-01f, -1.76191553e-01f, -4.61531468e-02f, 3.85420658e-02f, 2.11805895e-01f, 2.73461714e-02f, -7.03825727e-02f, -8.19080025e-02f, -1.33534655e-01f,
  -2.35348433e-01f, -1.78702772e-01f, 1.12924250e-02f, 1.32365571e-02f, 1.09239593e-01f, -6.80509359e-02f, 4.70674671e-02f, -6.22409768e-02f, 2.97599360e-02f, 7.85739720e-02f,
  -8.00881684e-02f, 3.18655640e-01f, -5.10571525e-02f, -2.56946087e-02f, 4.07042541e-02f, 1.53633416e-01f, 8.58759601e-03f, 8.63442943e-02f, 6.94676489e-02f, 1.08711526e-01f,
  4.39633057e-02f, -5.78409247e-02f, 5.06914444e-02f, 8.37026089e-02f, 1.88251678e-02f, -2.30923668e-02f, 1.31784081e-01f, 1.14030562e-01f, 1.02627270e-01f, 6.59349263e-02f,
  -1.03861012e-01f, 1.21367030e-01f, 1.78856943e-02f, 2.21607555e-02f, 4.09095734e-02f, -4.04716022e-02f, 8.14491659e-02f, 1.66116446e-01f, 4.05422337e-02f, 1.11581646e-01f,
  2.30898708e-02f, 5.07875718e-02f, -3.30559649e-02f, -3.52840424e-02f, 8.39957520e-02f, 3.22653167e-02f, 5.27809374e-02f, -7.63481334e-02f, -5.56996930e-03f, 4.99306917e-02f,
  1.92556847e-02f, -1.13796808e-01f, -8.23890343e-02f, -3.60371172e-02f, -1.48491651e-01f, 2.63322983e-02f, -1.02978960e-01f, -1.38089553e-01f, -9.89716351e-02f, -5.41149192e-02f,
  -8.92833620e-02f, -3.01026106e-02f, -2.59904936e-02f, 3.64514737e-04f, 4.09247959e-03f, -6.64980635e-02f, 2.94463821e-02f, -9.93498361e-06f, -9.36982632e-02f, -9.83759016e-02f,
  -2.72290617e-01f, -5.84023818e-02f, 2.65976060e-02f, 1.18143491e-01f, 1.24991313e-02f, 1.12485997e-02f, 1.09608229e-02f, -3.20487097e-02f, -4.87271883e-03f, -1.26461992e-02f,
  7.97410589e-03f, -7.61296973e-02f, 7.29952008e-02f, -2.39661932e-02f, 5.31134717e-02f, 7.12649748e-02f, -3.31246853e-02f, -1.11514581e-02f, 7.53034949e-02f, 3.73836532e-02f,
  -6.14511631e-02f, -7.91025162e-02f, -1.06322557e-01f, -1.27905812e-02f, 1.07867355e-02f, -2.86446158e-02f, -3.82017046e-02f, -4.39711213e-02f, -3.99014242e-02f, -8.32443833e-02f,
  5.29602077e-03f, -3.90756540e-02f, 2.77631879e-01f, -1.09949149e-02f, -6.32804334e-02f, 1.54931203e-01f, 7.47512728e-02f, 4.94969077e-02f, -9.62390304e-02f, 2.20499374e-02f,
  -2.36368075e-01f, -2.85292476e-01f, -2.52206534e-01f, -1.43206626e-01f, 6.32280260e-02f, 1.73038259e-01f, 1.29871875e-01f, 1.92885309e-01f, 6.34573698e-02f, 1.37181738e-02f,
  -9.07770246e-02f, 8.56820643e-02f, 2.28227332e-01f, 8.18634704e-02f, 1.33746445e-01f, -6.26752600e-02f, 9.93373170e-02f, 1.70804188e-01f, 1.21167846e-01f, 1.22453116e-01f,
  2.49445334e-01f, 1.21274769e-01f, -6.65804092e-03f, -5.06220497e-02f, 8.14900473e-02f, 1.12660229e-02f, -3.02907415e-02f, 7.58742914e-02f, -7.54446685e-02f, 8.87496993e-02f,
  -3.64739746e-02f, 6.87542483e-02f, -7.64602944e-02f, 6.73996508e-02f, 5.26930653e-02f, 6.06423877e-02f, -1.37078296e-02f, 1.02445476e-01f, -9.80397034e-03f, 5.53503679e-03f,
  -8.84216875e-02f, 8.53854120e-02f, 1.22132391e-01f, 9.00779963e-02f, -3.60204801e-02f, 8.90516788e-02f, 5.57463765e-02f, 6.06477298e-02f, 8.87931287e-02f, 1.41567320e-01f,
  -1.02075331e-01f, -4.25857045e-02f, -6.64508790e-02f, 1.72399413e-02f, -2.08878685e-02f, -7.21002594e-02f, -6.87657297e-02f, -1.95701909e-03f, 4.24505537e-03f, 6.84079602e-02f,
  -1.73067078e-02f, -4.72952761e-02f, 1.03873536e-02f, 2.07953583e-02f, 1.50321110e-03f, 4.34911326e-02f, 5.99772073e-02f, -2.14327616e-03f, 7.33574182e-02f, -1.75696317e-04f,
  -6.34240210e-02f, 1.62313376e-02f, -7.73184421e-03f, -4.11226191e-02f, 5.26723452e-02f, -3.42519511e-03f, 7.94912037e-03f, -8.28462243e-02f, -9.14622396e-02f, 6.92081405e-03f,
  -1.05456315e-01f, -5.43796942e-02f, -8.07244144e-03f, 2.02984586e-02f, 7.92061538e-02f, 1.95024256e-02f, -2.85188016e-02f, 8.00404027e-02f, -2.89418153e-03f, 1.09900795e-01f,
  3.53176035e-02f, 4.17657606e-02f, 4.26023267e-02f, 2.21064910e-02f, 1.22903042e-01f, -2.89900750e-02f, -3.44695896e-02f, 1.67861301e-02f, 9.01907533e-02f, 2.43458673e-02f,
  5.82334623e-02f, 1.36424512e-01f, 4.93792333e-02f, -9.57097951e-03f, 1.18023820e-01f, -4.99959178e-02f, 9.04513970e-02f, 1.79979935e-01f, 1.34749696e-01f, 1.88518703e-01f,
  -2.26511955e-01f, 1.31206168e-02f, 1.99964851e-01f, -4.94910516e-02f, 3.02229226e-01f, 3.02741408e-01f, 3.86859119e-01f, 3.19391005e-02f, -4.21509705e-03f, 2.49486007e-02f,
  -2.90887225e-02f, -3.32000703e-01f, -1.92214549e-01f, -1.38479307e-01f, -3.43191624e-02f, 1.64546415e-01f, 3.00829142e-01f, 9.01384205e-02f, -1.02622621e-01f, -4.25946154e-02f,
  -2.86574122e-02f, -6.12538494e-02f, -1.20650291e-01f, -1.42329186e-02f, 1.49790691e-02f, -5.14387153e-02f, 1.39688365e-02f, 9.33020487e-02f, 3.69773097e-02f, -1.37771562e-01f,
  -2.08729923e-01f, 4.27230224e-02f, 8.95719379e-02f, -1.25590563e-01f, 9.28718969e-03f, -9.07478407e-02f, -4.32398394e-02f, -7.50286728e-02f, 5.46223344e-03f, 5.57800159e-02f,
  -6.99105933e-02f, -4.60141934e-02f, -2.58992463e-02f, -3.75734940e-02f, -2.46099811e-02f, 6.41094372e-02f, 7.67857879e-02f, 1.41384611e-02f, 2.49057524e-02f, 4.64231661e-03f,
  5.62758818e-02f, 1.32935792e-01f, 1.28296793e-01f, 7.15100318e-02f, -3.98396328e-03f, 4.08396237e-02f, -4.84067537e-02f, -1.58462394e-02f, -4.34116367e-03f, -3.94560117e-03f,
  7.74994269e-02f, -6.60926253e-02f, -5.59501648e-02f, -1.28308246e-02f, -6.67839721e-02f, 2.71263011e-02f, -3.74963097e-02f, -5.95743507e-02f, 5.30995578e-02f, -2.48024147e-02f,
  -7.75488019e-02f, 6.55792952e-02f, 6.39862269e-02f, -5.93826622e-02f, -4.32184786e-02f, 1.70326605e-03f, 1.21235000e-02f, -5.70265688e-02f, -3.82361561e-02f, 2.10931664e-03f,
  -3.41193900e-02f, 1.99938957e-02f, -1.09033912e-01f, -6.83689117e-02f, -4.16378193e-02f, -7.65295029e-02f, -6.43722489e-02f, -1.12527683e-01f, 3.22339498e-02f, 7.59433880e-02f,
  -2.50576228e-01f, 1.83641165e-01f, -1.26028433e-01f, -2.87576932e-02f, 6.54636174e-02f, -3.09303813e-02f, -5.83842956e-02f, -2.97105759e-02f, -6.73862398e-02f, 1.90498191e-03f,
  -4.56766644e-03f, -1.74545422e-02f, -3.23264822e-02f, 1.53517788e-02f, 7.12453872e-02f, 6.83127493e-02f, 7.27716312e-02f, -8.07024073e-03f, -1.75629221e-02f, -4.90441173e-02f,
  6.72556087e-02f, 1.40363753e-01f, -8.11405107e-02f, 8.01734626e-02f, 4.11683582e-02f, -1.47159286e-02f, -8.87717679e-02f, 9.85658541e-02f, 7.28637278e-02f, -6.09943494e-02f,
  4.03521836e-01f, -1.31645188e-01f, -7.56898150e-02f, 7.91498423e-02f, -2.94777334e-01f, -2.51565605e-01f, -1.85040966e-01f, 7.93914497e-02f, 4.86038402e-02f, -3.34329791e-02f,
  -1.77331254e-01f, 6.43632188e-02f, 1.44866303e-01f, 1.64910495e-01f, 2.40778446e-01f, -9.59186722e-03f, -1.24012552e-01f, 2.13037595e-01f, 2.92990357e-01f, 4.68010232e-02f,
  -1.21688038e-01f, 8.85613784e-02f, 1.81329608e-01f, 8.18705782e-02f, -1.30096853e-01f, -2.40638442e-02f, -5.59452623e-02f, -9.40319002e-02f, -1.58086553e-01f, -1.80296764e-01f,
  -8.33730176e-02f, -9.75238830e-02f, -1.82862468e-02f, -7.54028708e-02f, -2.08824679e-01f, 5.53759411e-02f, -4.07382362e-02f, -2.28673015e-02f, -8.13740715e-02f, 4.95585240e-02f,
  -1.74122557e-01f, 8.03897996e-03f, -9.61544365e-02f, -1.22498110e-01f, -1.35523394e-01f, -6.07410930e-02f, -5.18313125e-02f, 7.11768195e-02f, -6.75191507e-02f, -3.54214050e-02f,
  -1.64652944e-01f, -1.53769270e-01f, 1.12093007e-02f, 1.36651983e-02f, 3.67419631e-03f, -1.26190009e-02f, -1.19021706e-01f, -4.30337451e-02f, 1.00769937e-01f, 1.47848189e-01f,
  -7.00774137e-03f, 1.28352627e-01f, 6.60916865e-02f, 4.97714058e-02f, 9.54527259e-02f, 5.61972111e-02f, 2.01954581e-02f, 1.00969233e-01f, 7.85212368e-02f, 8.76287743e-02f,
  1.99669767e-02f, -4.75808978e-02f, 1.19875096e-01f, 2.34402232e-02f, 7.58271217e-02f, 2.39462499e-03f, 5.80035560e-02f, 9.31957364e-02f, 5.42152440e-03f, -1.01053817e-02f,
  1.09742291e-01f, 5.24122342e-02f, 3.43372710e-02f, 9.92985889e-02f, -6.10692799e-02f, -1.65355448e-02f, 1.08940624e-01f, 4.25909460e-02f, 3.71917561e-02f, -4.13966961e-02f,
  1.21250041e-01f, -9.97471213e-02f, -4.06149216e-03f, 9.47437882e-02f, -1.67165369e-01f, -7.85603151e-02f, -1.39839843e-01f, -5.69774061e-02f, -9.68702435e-02f, -2.11811662e-02f,
  -5.64291738e-02f, 3.83964070e-04f, 7.89194182e-03f, 1.51397791e-02f, 2.75532734e-02f, -1.23172581e-01f, -4.13705967e-02f, -3.67349349e-02f, -9.06021297e-02f, -1.18888043e-01f,
  -8.49014446e-02f, 6.25084341e-02f, 1.07527338e-01f, 1.10756859e-01f, 1.42755657e-02f, 3.98617573e-02f, 6.31339177e-02f, -5.54236025e-02f, 8.03399459e-02f, 1.57930613e-01f,
  -1.30949080e-01f, -1.61295518e-01f, -9.44386944e-02f, -1.74275979e-01f, -7.71670938e-02f, -7.49185160e-02f, -1.02765441e-01f, -1.16565153e-01f, -4.42812145e-02f, -1.61644995e-01f,
  -8.33527297e-02f, 2.26184987e-02f, -3.30264214e-04f, -1.61960095e-01f, -2.15148121e-01f, -1.27256766e-01f, -3.06646883e-01f, -1.91071659e-01f, -1.79827511e-01f, -1.51692107e-01f,
  -2.22834740e-02f, -2.95409616e-02f, -1.63835049e-01f, -2.45030932e-02f, -1.23878270e-01f, -1.02318354e-01f, 2.18106657e-02f, -3.73703763e-02f, -8.68241210e-03f, -1.28854528e-01f,
  -6.35560974e-02f, 7.35226497e-02f, 9.62678120e-02f, -1.02919653e-01f, 6.28859103e-02f, -2.14729253e-02f, -8.95526558e-02f, -5.24550397e-03f, -1.49981137e-02f, -1.11416660e-01f,
  -9.23942626e-02f, 7.86289759e-03f, -1.01521574e-01f, 2.96052825e-02f, -4.81813103e-02f, -5.27752712e-02f, -1.08165912e-01f, -1.41812563e-01f, -3.96658480e-02f, 7.98179675e-03f,
  -9.40041244e-02f, -1.86558031e-02f, -9.51510072e-02f, 3.73419039e-02f, -4.05541807e-02f, 9.14908871e-02f, 3.98305878e-02f, -6.17818236e-02f, 3.88957895e-02f, -1.14331871e-01f,
  -1.61181539e-01f, -1.01719936e-02f, 3.14500518e-02f, -1.11381812e-02f, -3.45145129e-02f, 2.37292964e-02f, -8.02828595e-02f, -2.45409627e-02f, 1.56295933e-02f, -1.69624202e-02f,
  9.93856136e-03f, -7.63526093e-03f, -6.33254498e-02f, -4.36948128e-02f, -5.65013811e-02f, -8.34958926e-02f, 5.06657660e-02f, -1.66310929e-02f, 6.17471710e-02f, -7.19196978e-04f,
  6.29518367e-03f, 1.83954388e-02f, 1.57222040e-02f, 4.09251032e-03f, -1.40307918e-06f, -3.63468528e-02f, -4.12294567e-02f, 9.87403542e-02f, 5.28588369e-02f, 9.85665619e-03f,
  3.98266353e-02f, 1.70396477e-01f, -3.39228772e-02f, -5.34198806e-02f, -1.81803014e-02f, -3.26558426e-02f, 8.73959810e-02f, 4.93249390e-03f, 3.12919952e-02f, 4.19225320e-02f,
  6.58019334e-02f, -1.26856670e-01f, 1.73306223e-02f, 5.44921793e-02f, 8.88643265e-02f, 4.34776815e-03f, -9.83585268e-02f, 3.95462587e-02f, -1.36467004e-02f, 6.94709048e-02f,
  -7.38085657e-02f, -2.35198885e-02f, 6.08586892e-03f, -3.34549583e-02f, -1.75735801e-02f, -3.32569554e-02f, -3.48072350e-02f, 1.13218300e-01f, -5.10468557e-02f, -4.63272147e-02f,
  -3.20556641e-01f, -3.90424132e-01f, 1.86302826e-01f, 3.29937041e-02f, 2.76820838e-01f, 1.76065400e-01f, -1.40186191e-01f, -2.35930130e-01f, -6.34780377e-02f, 4.44712862e-02f,
  1.24668583e-01f, 9.29049328e-02f, 6.00592569e-02f, 1.98306330e-02f, -1.36786968e-01f, 9.67343058e-03f, 1.15084097e-01f, 2.23684579e-01f, 1.84467629e-01f, 2.35133953e-02f,
  9.84302606e-04f, -6.74005002e-02f, -8.65690559e-02f, -1.43054739e-01f, -8.80480185e-02f, 1.34320945e-01f, -3.77597734e-02f, 1.42256185e-01f, 7.53453150e-02f, 6.64843246e-02f,
  2.97583491e-01f, -1.39575824e-01f, 1.49170160e-01f, -7.41271360e-05f, 9.61377397e-02f, -1.37915909e-01f, 7.99284317e-03f, -1.01854891e-01f, 3.67143452e-02f, -2.84389295e-02f,
  1.07918918e-01f, 3.76773663e-02f, -3.67371999e-02f, -2.59509683e-02f, -7.46453926e-02f, -1.64245851e-02f, -7.06240088e-02f, -1.22337557e-01f, -8.21386054e-02f, -6.07933365e-02f,
  1.07419835e-02f, 6.78466409e-02f, 1.81168124e-01f, -7.22781792e-02f, 3.29560079e-02f, 1.43034920e-01f, 4.59757913e-03f, -8.35957453e-02f, 5.67648709e-02f, -7.56315142e-02f,
  9.49179605e-02f, 9.62590203e-02f, -4.91284393e-02f, 4.69100513e-02f, -6.44500405e-02f, 5.14920130e-02f, 8.66075382e-02f, 9.02621970e-02f, 1.55253056e-02f, 4.42793011e-04f,
  2.19039600e-02f, 2.48882398e-02f, -2.97214258e-02f, -1.89568736e-02f, 5.66654354e-02f, 6.46451414e-02f, -9.03283712e-03f, -6.26210645e-02f, -2.09347773e-02f, -5.06094918e-02f,
  -2.60115620e-02f, 6.23879172e-02f, 2.01376472e-02f, 2.21458307e-04f, 5.53623028e-02f, -2.74600722e-02f, -5.41573428e-02f, -6.70467988e-02f, -5.19491136e-02f, 7.32542127e-02f,
  1.53879091e-01f, 4.56157438e-02f, 7.91711658e-02f, -7.40867630e-02f, 6.34553954e-02f, -3.66014019e-02f, 4.90202219e-04f, -4.87591326e-02f, -2.32020374e-02f, -5.75744510e-02f,
  1.30338955e-03f, -3.77343446e-02f, -3.12310196e-02f, -9.92552787e-02f, 1.17027229e-02f, 8.32241476e-02f, -1.08398870e-02f, 1.35874689e-01f, -2.21783370e-02f, -7.37423226e-02f,
  -4.96333987e-02f, 1.52422741e-01f, 7.37678856e-02f, 1.37652114e-01f, 5.19393571e-03f, 2.40789860e-01f, 1.13420285e-01f, 3.57939601e-02f, 5.51808700e-02f, -4.43579108e-02f,
  1.88316599e-01f, 2.01659516e-01f, -1.46259815e-02f, 1.72851861e-01f, -1.84014633e-01f, -1.14963733e-01f, 4.06073518e-02f, 3.70228589e-02f, 3.87065299e-02f, 1.09593853e-01f,
  -2.35635310e-01f, -3.05774182e-01f, -3.81485410e-02f, -4.79362020e-03f, 1.70098376e-02f, 1.73567176e-01f, 2.90167123e-01f, 2.00798109e-01f, 1.66085046e-02f, 4.30505276e-02f,
  7.34873936e-02f, 2.16655612e-01f, 1.59734666e-01f, 1.56489685e-01f, 1.16087958e-01f, -2.05526464e-02f, 3.80173549e-02f, 1.06491752e-01f, 9.09296051e-02f, 2.91973531e-01f,
  1.44768760e-01f, -2.09517628e-02f, -6.13224059e-02f, -7.97075629e-02f, 2.30985712e-02f, 1.46034047e-01f, 1.04205208e-02f, 4.48632874e-02f, 5.79543710e-02f, 1.00476325e-01f,
  -2.12122127e-02f, -1.80044044e-02f, -1.02930944e-02f, -4.89386991e-02f, 9.18642655e-02f, -5.98830841e-02f, 5.62982261e-03f, 1.78481862e-01f, 3.40944827e-02f, 1.08388938e-01f,
  -1.05247445e-01f, -1.09223418e-01f, 9.46001858e-02f, -4.88990881e-02f, 4.57519852e-02f, 1.34009561e-02f, 1.12670762e-02f, 5.62931672e-02f, 9.33734179e-02f, 2.83765405e-01f,
  1.07292995e-01f, 7.29698911e-02f, -1.16922870e-01f, -9.82657890e-04f, -1.07368212e-02f, -3.87159288e-02f, -3.73083875e-02f, -7.87960887e-02f, 7.22946227e-02f, 2.61254460e-02f,
  -7.17340261e-02f, -9.83358398e-02f, 1.02906059e-02f, 2.08411310e-02f, -4.85578328e-02f, -2.49924744e-03f, -1.78915355e-03f, 8.29888694e-03f, -1.20268255e-01f, -9.13340300e-02f,
  -3.68884243e-02f, -5.79226166e-02f, 2.27816850e-02f, 1.17720170e-02f, -1.33999690e-01f, 1.39773590e-02f, -4.88778427e-02f, -5.74119389e-02f, 1.55210011e-02f, 4.08176407e-02f,
  1.98123470e-01f, -2.34725922e-01f, 1.03425823e-01f, 5.56153506e-02f, -3.43056582e-02f, 4.99899872e-02f, 5.75668700e-02f, -2.52974220e-02f, -6.75225407e-02f, 1.53419804e-02f,
  -2.08061002e-02f, 7.93970153e-02f, 6.19896017e-02f, 3.26077044e-02f, 4.00955006e-02f, 1.02419600e-01f, 5.63408472e-02f, 3.56355682e-02f, -1.05542075e-02f, -8.20406992e-03f,
  1.22123085e-01f, 1.42634109e-01f, 5.92055321e-02f, 9.26423371e-02f, 1.36900604e-01f, -8.69487040e-03f, 1.27127081e-01f, 1.54323593e-01f, 4.48869169e-02f, 3.35937917e-01f,
  4.44225222e-01f, 1.09202646e-01f, -1.62450686e-01f, 1.30046144e-01f, -2.09949970e-01f, -2.43154705e-01f, -2.83188611e-01f, -1.14620082e-01f, -7.77557446e-03f, -5.31357639e-02f,
  8.49589705e-02f, -6.28377823e-03f, -1.08428292e-01f, -3.33221555e-02f, -2.77348608e-01f, -2.86029041e-01f, -2.91654110e-01f, -2.23960817e-01f, -2.59249598e-01f, -2.34923437e-01f,
  -1.75775602e-01f, 2.71504503e-02f, 1.08164348e-01f, -1.56534776e-01f, -1.43342018e-01f, -1.88659564e-01f, -1.44859433e-01f, -1.97591633e-01f, -1.94188088e-01f, -2.96316557e-02f,
  -9.70069394e-02f, 1.22406356e-01f, -1.94096982e-01f, 6.05806650e-04f, -1.22938864e-01f, -3.39674763e-02f, -3.37819643e-02f, -7.19517283e-03f, -1.38130203e-01f, -8.68722447e-04f,
  -1.60503894e-01f, -2.39048507e-02f, -7.81676918e-02f, -2.93959696e-02f, -5.26380837e-02f, -6.49273172e-02f, -5.75039648e-02f, -1.75853893e-01f, -2.15225860e-01f, -2.99602076e-02f,
  -1.05381414e-01f, -1.16752461e-01f, -9.08518806e-02f, -2.35139444e-01f, -2.05085173e-01f, -1.50238410e-01f, -1.61529079e-01f, -1.78718954e-01f, -2.39111707e-01f, -2.58996114e-02f,
  7.94128627e-02f, -3.16329300e-02f, 4.37224936e-03f, 2.13802494e-02f, -2.86982767e-02f, 3.42029240e-03f, -2.93901060e-02f, -6.32398278e-02f, -4.19924371e-02f, -8.37393627e-02f,
  5.80987073e-02f, -7.02911317e-02f, -8.88227895e-02f, -6.28154874e-02f, -1.20967990e-02f, -9.54206809e-02f, -6.76495284e-02f, -6.73172530e-03f, -6.39096275e-02f, 4.49069813e-02f,
  5.84050603e-02f, -9.56664532e-02f, -9.16176811e-02f, -4.56757098e-02f, -5.27999438e-02f, -3.07723582e-02f, 2.28469912e-02f, 5.82445003e-02f, 6.36395067e-02f, -2.40018498e-02f,
  5.26663139e-02f, -1.46515489e-01f, 4.87793423e-02f, 4.97690681e-03f, -8.63173753e-02f, -1.53134435e-01f, -2.39670686e-02f, -2.79190894e-02f, -7.00956509e-02f, -6.69044256e-02f,
  -1.44454494e-01f, -1.32780641e-01f, -9.30290222e-02f, -1.46496341e-01f, -1.35007948e-01f, -1.48392826e-01f, -1.41012996e-01f, -8.35166946e-02f, -8.78437981e-02f, -1.86337918e-01f,
  -1.97598562e-01f, -1.65711701e-01f, -1.24940164e-01f, -1.24281190e-01f, -8.87908116e-02f, -2.31175646e-01f, -1.58441111e-01f, -2.46537879e-01f, -2.29345798e-01f, -1.71505406e-01f,
  -2.54973561e-01f, 9.16637555e-02f, -1.17747121e-01f, -5.44540845e-02f, -1.90309417e-02f, 7.87418932e-02f, 4.02490161e-02f, 1.01995662e-01f, 7.93778524e-02f, 1.26710817e-01f,
  2.54160821e-01f, 2.51514554e-01f, 1.72714934e-01f, 2.05511227e-01f, 4.24796008e-02f, -6.28264099e-02f, -1.15191385e-01f, -1.53330024e-02f, -5.84527105e-02f, 1.49385840e-01f,
  2.70351410e-01f, -4.00555469e-02f, -8.12648609e-03f, -4.30452414e-02f, 2.24645048e-01f, 1.67502418e-01f, 5.75597733e-02f, 1.35866459e-02f, 2.04160944e-01f, 1.67830795e-01f,
  1.58265173e-01f, -5.78540079e-02f, 1.61736608e-01f, 2.67556012e-01f, 2.34633401e-01f, 1.21532328e-01f, 1.65450335e-01f, 1.52510136e-01f, 9.06608477e-02f, 1.79276168e-01f,
  1.68624207e-01f, 1.42377794e-01f, 9.49795693e-02f, 2.02764541e-01f, 5.10852672e-02f, 1.60882667e-01f, 3.11896224e-02f, 8.85493159e-02f, 1.16244905e-01f, 2.52631754e-01f,
  3.27848136e-01f, 1.10774487e-01f, 9.17592421e-02f, 9.58136991e-02f, 1.52624205e-01f, 9.63841006e-02f, 2.52357066e-01f, 2.25388587e-01f, 5.65726869e-02f, 2.61610001e-01f,
  2.18964405e-02f, -8.75841081e-02f, -8.19774047e-02f, -5.98956645e-02f, -1.11377709e-01f, -4.40334380e-02f, -7.21508414e-02f, -8.31418261e-02f, -1.13898464e-01f, -7.81200305e-02f,
  -2.10974440e-02f, -1.01761885e-01f, -3.58982608e-02f, -1.12067796e-01f, -4.55456004e-02f, -1.36039943e-01f, -4.60428298e-02f, -3.77561189e-02f, -5.30800782e-02f, -1.32712960e-01f,
  -4.10596207e-02f, -8.30231328e-03f, -1.28842384e-01f, -1.20473847e-01f, -1.59872358e-03f, -4.09359857e-02f, -1.77027564e-02f, -6.80846795e-02f, -7.82764181e-02f, -6.79921880e-02f,
  2.19185427e-01f, -1.56789627e-02f, 8.65932629e-02f, 1.13498263e-01f, 1.43082798e-01f, 1.69786662e-01f, 2.05709651e-01f, 9.83808339e-02f, 1.35964885e-01f, 1.59951687e-01f,
  1.97740644e-01f, 8.34480152e-02f, 1.91173464e-01f, 1.55695572e-01f, 1.16172850e-01f, 9.78881940e-02f, 1.14330076e-01f, 1.13748215e-01f, 6.31296113e-02f, 2.53638715e-01f,
  1.26515314e-01f, 9.88077968e-02f, 5.45021445e-02f, 3.49313468e-02f, 1.49841070e-01f, -4.41338541e-03f, 2.27711082e-01f, 1.56352952e-01f, -2.84068268e-02f, 2.01401800e-01f,
  8.26738328e-02f, -1.04337204e-02f, -1.63189277e-01f, 2.16630176e-01f, -1.28917262e-01f, -1.81967586e-01f, -4.61430922e-02f, -9.80760716e-03f, 2.04457372e-01f, 1.18397921e-01f,
  -2.24270914e-02f, 1.77189395e-01f, 2.32747674e-01f, 1.17906272e-01f, -3.94794866e-02f, 3.61422449e-03f, 1.11551471e-01f, -1.50235415e-01f, -4.25898880e-02f, -6.72438368e-02f,
  2.10422963e-01f, 1.62281513e-01f, 3.48591967e-03f, 9.79675949e-02f, 1.97253928e-01f, 1.59728333e-01f, -3.50504294e-02f, -5.55342361e-02f, -1.59009129e-01f, 2.15213552e-01f,
  3.46613601e-02f, -1.49601996e-01f, -2.61783935e-02f, -4.31183167e-02f, -1.57838136e-01f, 5.08958893e-03f, -9.44093429e-03f, -1.33477151e-01f, -4.94379774e-02f, 3.62897366e-02f,
  -1.05200924e-01f, -5.04338741e-02f, -7.48868436e-02f, -4.83777486e-02f, -3.39882448e-02f, 6.94464846e-03f, 4.61299419e-02f, 1.79107068e-03f, -1.39734996e-02f, -7.31461942e-02f,
  3.48052796e-04f, -1.54449910e-01f, -1.40962049e-01f, -9.73033533e-02f, -1.50986105e-01f, -1.97351724e-02f, -1.68149278e-01f, -7.26351067e-02f, -7.34568089e-02f, 8.39554220e-02f,
  -2.11603753e-02f, -4.99053970e-02f, 4.27462459e-02f, -3.92407998e-02f, 3.69079001e-02f, 7.60325864e-02f, -6.46316214e-03f, 2.79991105e-02f, -1.41208367e-02f, -8.96547921e-03f,
  6.50371239e-02f, -1.78107079e-02f, -3.90141420e-02f, 1.20967269e-01f, 7.05067515e-02f, -1.32860951e-02f, 2.40196232e-02f, 8.55656788e-02f, 3.33723761e-02f, -1.39749667e-03f,
  5.20114340e-02f, -2.83073192e-03f, 3.55692245e-02f, 1.01412699e-01f, 6.39124736e-02f, -9.94473547e-02f, -4.74111587e-02f, -9.46003711e-05f, 2.13686097e-02f, 2.83865239e-02f,
  3.12210888e-01f, -2.82259971e-01f, 1.52933583e-01f, 1.86338145e-02f, 1.30715594e-02f, 2.35321466e-02f, 6.32883012e-02f, 7.96507020e-03f, -7.51326755e-02f, 2.03061085e-02f,
  -7.83127248e-02f, 7.03242868e-02f, 2.66968249e-03f, -4.01224382e-02f, -2.49707773e-02f, 6.74029961e-02f, 8.87475312e-02f, 7.63078406e-02f, -5.85220493e-02f, -3.35113555e-02f,
  1.06450170e-02f, -2.88173389e-02f, 5.50657101e-02f, 1.24540150e-01f, -4.86903936e-02f, 4.98117767e-02f, 1.35018602e-01f, 5.77009432e-02f, -6.20094277e-02f, 2.76713282e-01f,
  5.08463085e-01f, -3.60215694e-01f, -3.09919178e-01f, 7.96802640e-02f, -5.13963886e-02f, -2.13887811e-01f, -1.66571558e-01f, -5.13566360e-02f, -2.16017999e-02f, -1.12477362e-01f,
  -2.14999989e-01f, 8.52176324e-02f, 4.51983884e-02f, 8.41141641e-02f, -4.40212004e-02f, -2.89051652e-01f, -2.68168360e-01f, 2.35978439e-01f, 3.98759693e-01f, 3.13061714e-01f,
  6.35560453e-02f, 1.89659685e-01f, 2.75498122e-01f, 3.59722115e-02f, -1.41674951e-01f, 1.68409571e-02f, -1.36701882e-01f, -9.48135257e-02f, -2.53453910e-01f, -1.13810688e-01f,
  1.77217461e-02f, -1.22733697e-01f, 2.08075002e-01f, 9.43905767e-03f, 5.38810492e-02f, 2.47564744e-02f, -1.28298048e-02f, -2.71977149e-02f, -5.09601273e-02f, -2.92540193e-02f,
  -6.26159087e-02f, 5.45420647e-02f, -8.22656695e-03f, 4.23020171e-03f, -1.19442185e-02f, 5.80827594e-02f, 4.45144176e-02f, -2.47657150e-02f, 4.51429486e-02f, -7.84717947e-02f,
  -5.04064150e-02f, -7.73126259e-02f, -9.76612791e-02f, -5.82333170e-02f, -4.94925715e-02f, 2.03324288e-01f, -6.16549067e-02f, 8.46386924e-02f, -4.48077824e-03f, 1.17237158e-01f,
  8.59099180e-02f, -2.51627453e-02f, 6.52430058e-02f, 2.59972736e-02f, -2.52049626e-03f, -6.38742819e-02f, 5.11012301e-02f, -1.02028675e-01f, 3.56510505e-02f, 3.01676374e-02f,
  -2.87130214e-02f, -4.10433784e-02f, 3.69697660e-02f, -5.77127114e-02f, -5.80611788e-02f, -8.02885462e-03f, -6.06084205e-02f, -8.54710117e-02f, 3.87195178e-06f, -5.52179739e-02f,
  4.66798469e-02f, -6.11595884e-02f, 5.77716082e-02f, 2.65484005e-02f, -4.98176999e-02f, -3.75980251e-02f, 8.69687647e-02f, 8.41886625e-02f, 3.96785699e-02f, -3.54438759e-02f,
  7.16011971e-02f, -3.85391377e-02f, -1.98627878e-02f, 2.00073272e-02f, -9.74035263e-02f, -7.14877695e-02f, -1.00658163e-02f, -8.79996922e-03f, -7.69941928e-03f, 5.66015542e-02f,
  1.20376761e-03f, 4.80173454e-02f, -1.54944241e-01f, -1.69492774e-02f, 1.23462677e-01f, -1.86103359e-02f, -4.29432373e-03f, 4.97276261e-02f, -2.15198118e-02f, -9.87986252e-02f,
  -1.44318447e-01f, 2.85777003e-02f, 6.73630610e-02f, 2.13031359e-02f, 1.87962782e-02f, 9.68788862e-02f, 1.06821597e-01f, 3.58078294e-02f, 5.45019209e-02f, 9.89994630e-02f,
  -2.05476210e-02f, 1.01797193e-01f, 1.54163167e-01f, -9.66318697e-02f, -8.88815373e-02f, 8.91615928e-04f, -6.92518381e-03f, 1.07734248e-01f, 7.93726668e-02f, -6.51748618e-03f,
  3.29303980e-01f, 3.04859787e-01f, 2.09686473e-01f, 1.24041699e-01f, 2.55739421e-01f, -1.43782618e-02f, -2.45123869e-03f, -7.04580173e-02f, 7.43162334e-02f, -1.77051499e-01f,
  -1.02097489e-01f, -1.90436512e-01f, -1.35158688e-01f, -1.08981013e-01f, -9.84146520e-02f, 3.91984321e-02f, 6.03522696e-02f, -2.83761341e-02f, 2.73222420e-02f, -1.27396807e-01f,
  2.15746179e-01f, 1.43014461e-01f, -2.33549140e-02f, 4.58002575e-02f, 1.10452965e-01f, 5.63790761e-02f, 1.15298711e-01f, 2.48766765e-02f, 3.25254500e-02f, -5.50819449e-02f,
  9.00009796e-02f, 8.98294821e-02f, 5.90861365e-02f, -2.31709536e-02f, 2.83560213e-02f, 5.61115257e-02f, 1.19764488e-02f, -2.87567936e-02f, 7.47997239e-02f, 1.10059448e-01f,
  -4.92930934e-02f, 3.50090265e-02f, 1.66474938e-01f, 1.28028035e-01f, 1.25938222e-01f, 5.37954969e-03f, 9.20419395e-02f, 4.51932326e-02f, 1.34346560e-01f, -9.72377211e-02f,
  -2.81741153e-02f, -3.04785389e-02f, 1.10512646e-02f, -8.16753954e-02f, 2.39844322e-02f, 6.65160120e-02f, -9.58646834e-02f, -1.13837635e-02f, -2.87997667e-02f, -1.00732245e-01f,
  -3.41835581e-02f, 3.99852954e-02f, 4.10989746e-02f, -9.41989869e-02f, -2.15046220e-02f, 8.88093710e-02f, 2.94248685e-02f, -6.82677478e-02f, -1.76131073e-02f, 2.14065686e-02f,
  1.19657903e-04f, 7.01594502e-02f, -3.86271067e-02f, -2.27093580e-03f, 2.58163307e-02f, -7.71810263e-02f, -3.99779342e-02f, -6.60658032e-02f, 5.07476414e-03f, -7.53150508e-02f,
  7.09712580e-02f, 2.28587702e-01f, -1.73146389e-02f, -6.81487992e-02f, 4.62016091e-02f, 1.40624726e-02f, -2.53100954e-02f, 1.08474586e-02f, 1.98315387e-03f, -5.18996036e-04f,
  1.12833075e-01f, 3.46834073e-03f, 1.36495277e-01f, 4.50516790e-02f, 5.82541563e-02f, -6.67991042e-02f, 4.69173305e-02f, 7.00173900e-02f, 6.39959425e-02f, 1.46155814e-02f,
  -9.50594097e-02f, 4.09178808e-02f, 3.19975950e-02f, 7.95367658e-02f, 7.24929897e-03f, 1.51065826e-01f, 6.23269379e-02f, 7.52179846e-02f, 4.83554751e-02f, -1.37974501e-01f,
  -2.67255992e-01f, -3.59191746e-01f, -3.14033851e-02f, -1.98016629e-01f, 1.87439620e-01f, 2.75736779e-01f, 3.32949281e-01f, 8.05056021e-02f, 3.95412445e-02f, -8.97114500e-02f,
  -7.53709748e-02f, -3.02967336e-02f, -5.57784960e-02f, 4.59633842e-02f, 6.15263842e-02f, 4.74871211e-02f, 7.85982087e-02f, 8.15037936e-02f, 3.00238550e-01f, 2.59799540e-01f,
  4.67615277e-02f, -8.62277150e-02f, -1.74714729e-01f, -4.08823155e-02f, -1.84639499e-01f, -2.40531135e-02f, -2.08119348e-01f, -1.09808289e-01f, -7.65193701e-02f, -2.99272656e-01f,
  -9.68157724e-02f, -1.50015712e-01f, 1.97931960e-01f, -1.32283047e-01f, -1.53410032e-01f, -6.87355325e-02f, 1.07865687e-02f, -1.65486544e-01f, -5.64198606e-02f, -1.19811825e-01f,
  -1.66882440e-01f, -7.70240203e-02f, -7.07392618e-02f, -1.26712456e-01f, -1.64774582e-02f, 4.77677472e-02f, -4.06239554e-02f, -1.45074978e-01f, -4.58143018e-02f, -4.05042581e-02f,
  -3.07857208e-02f, -1.38754919e-01f, 3.05319577e-02f, 7.09142238e-02f, 8.08134617e-04f, -6.62319958e-02f, -1.48390636e-01f, -1.04809618e-02f, 2.87964698e-02f, -1.40466526e-01f,
  7.03837276e-02f, 3.34176458e-02f, 5.71706481e-02f, 6.04500435e-02f, -4.43458441e-04f, 2.69498932e-03f, -2.35687308e-02f, -1.97400409e-03f, 1.01846993e-01f, -1.38730826e-02f,
  -1.25023695e-02f, 4.71257977e-03f, 5.88994613e-03f, -3.11811827e-02f, 4.19947393e-02f, -1.69808641e-02f, 7.81066939e-02f, 2.00747829e-02f, -4.07785699e-02f, 8.58465657e-02f,
  2.89605763e-02f, 4.38402258e-02f, -1.24923006e-01f, -1.09816836e-02f, -1.71413198e-02f, -7.59545267e-02f, 2.07726359e-02f, 1.09691784e-01f, -4.58107032e-02f, -6.01437911e-02f,
  4.66959961e-02f, -1.59974548e-03f, 7.00253397e-02f, -2.92296726e-02f, -1.28636137e-01f, -8.00588131e-02f, -1.27251089e-01f, -1.05769992e-01f, -7.51401857e-02f, 4.10951301e-03f,
  -4.07519862e-02f, -3.22054625e-02f, -1.31278649e-01f, 2.93840189e-02f, 3.94858941e-02f, -5.45113459e-02f, -5.62228002e-02f, 1.79435723e-02f, 4.54692617e-02f, -2.93554664e-02f,
  -5.02581708e-02f, 1.48012534e-01f, 2.78102029e-02f, 1.03290163e-01f, 2.83030663e-02f, 1.45802066e-01f, 6.31395131e-02f, 1.36846110e-01f, 9.79703292e-02f, 9.53577831e-02f,
  2.52207577e-01f, -3.42731982e-01f, -1.86596870e-01f, 1.29599512e-01f, 2.17151828e-02f, -1.42690409e-02f, -9.95369256e-02f, 1.29126191e-01f, 1.13163754e-01f, -1.84455648e-01f,
  -7.92717561e-02f, 1.72029868e-01f, 1.42712340e-01f, 1.41657576e-01f, 1.41406402e-01f, -7.13374987e-02f, -2.41814051e-02f, 2.42270634e-01f, 1.92943469e-01f, 4.55044247e-02f,
  7.58627150e-03f, 5.72513044e-02f, 1.54874548e-01f, 6.59215972e-02f, -8.53243172e-02f, -5.95849976e-02f, -2.19324678e-01f, -3.02233584e-02f, -1.87174991e-01f, -2.26662010e-01f,
  -1.95568427e-01f, -9.55046564e-02f, 8.87161046e-02f, 1.46990672e-01f, -1.15114667e-01f, 6.28229184e-03f, -1.41120069e-02f, -1.65698193e-02f, 3.35730948e-02f, -9.97123569e-02f,
  -4.13035341e-02f, -4.63973768e-02f, -2.41136309e-02f, -5.74670397e-02f, -4.56532724e-02f, -4.86388914e-02f, 3.20161059e-02f, 7.47079179e-02f, 2.34080218e-02f, -1.50119424e-01f,
  -3.14775407e-02f, -1.30645111e-01f, -3.17633636e-02f, 4.89350557e-02f, 2.93602068e-02f, 1.09518193e-01f, -2.24258490e-02f, 5.00165336e-02f, 4.31058370e-02f, -3.39487121e-02f,
  1.22958839e-01f, 1.30022326e-02f, 2.11308543e-02f, 8.29482451e-02f, -3.76531221e-02f, 1.35417618e-02f, -6.63340241e-02f, 4.64211255e-02f, 1.08335325e-02f, -1.09559000e-02f,
  -5.63152097e-02f, -1.30798342e-02f, 9.35112685e-02f, 1.12056667e-02f, 4.59554456e-02f, -6.84529468e-02f, -4.76183789e-03f, 2.50783786e-02f, -6.08233586e-02f, -9.17059183e-03f,
  -4.09311242e-02f, 3.07262242e-02f, -8.49958062e-02f, -1.55199179e-02f, 4.39376123e-02f, 4.49422980e-03f, -2.62432247e-02f, 4.58574295e-02f, 8.42504203e-03f, -7.72398487e-02f,
  -1.44547284e-01f, 1.85373530e-01f, -1.83833726e-02f, 7.13523244e-03f, -4.35939543e-02f, -5.99655993e-02f, -6.57502040e-02f, -4.69472818e-02f, -4.07262482e-02f, -9.81553458e-03f,
  -3.88454385e-02f, 6.22526333e-02f, 1.79820473e-03f, 6.06596190e-03f, 4.68343049e-02f, 8.81151929e-02f, 4.31333389e-03f, 5.07818833e-02f, 2.30875500e-02f, -7.67250732e-02f,
  -1.23318054e-01f, 1.22956179e-01f, 9.77791324e-02f, 2.82904841e-02f, 8.43730476e-03f, 1.27692536e-01f, 1.98089276e-02f, -3.02298833e-02f, 5.07429801e-02f, -5.96646965e-02f,
  -1.61501393e-01f, 9.56916660e-02f, 1.54730499e-01f, 3.26322392e-02f, 2.45301321e-01f, 2.06896469e-01f, 1.71274558e-01f, 5.21165915e-02f, 1.80647299e-02f, 1.34736449e-01f,
  9.54674557e-02f, 1.56474367e-01f, 1.75268039e-01f, 2.16833621e-01f, 2.05636710e-01f, 2.98117906e-01f, 2.24874422e-01f, 2.57802129e-01f, 2.37272218e-01f, 1.41605318e-01f,
  2.08248645e-01f, 1.49393305e-01f, 1.24392010e-01f, 1.02445364e-01f, 1.12283297e-01f, 9.96564776e-02f, 1.59336850e-01f, 1.45332143e-01f, 1.23454183e-01f, 1.33584350e-01f,
  2.57107079e-01f, 1.15722403e-01f, 1.26638561e-01f, 5.14898151e-02f, 2.05983091e-02f, -1.62126366e-02f, 3.94817963e-02f, -4.46517095e-02f, -7.63977543e-02f, 2.24908721e-02f,
  9.76375043e-02f, 1.35265276e-01f, 8.37807544e-03f, 3.40962969e-02f, 9.90988463e-02f, 1.59338117e-01f, -4.05685417e-03f, 1.53155655e-01f, 5.06202281e-02f, 7.45417038e-03f,
  1.39506012e-02f, -1.66308451e-02f, 1.07475817e-01f, -3.16197537e-02f, 1.39035517e-02f, 1.00852899e-01f, 5.59770428e-02f, 9.03248489e-02f, 1.56979635e-01f, 4.97655384e-02f,
  -7.61024207e-02f, -6.44890890e-02f, -4.08213213e-02f, -9.47180167e-02f, -9.10118818e-02f, -6.17592484e-02f, -5.65262251e-02f, -4.72333431e-02f, -6.68153465e-02f, -8.14658925e-02f,
  -9.77872536e-02f, 4.21464629e-02f, -1.16067663e-01f, -5.11331074e-02f, 7.73618510e-03f, -1.53385364e-02f, -1.41973034e-01f, 1.18312230e-02f, -9.91348699e-02f, -7.33189732e-02f,
  7.37663284e-02f, -5.06065041e-02f, -1.24840252e-02f, 3.70578468e-02f, -3.84290852e-02f, -1.51591850e-02f, -9.50305685e-02f, -9.99685377e-02f, 5.25264032e-02f, -4.29635234e-02f,
  2.20851332e-01f, 9.23177153e-02f, 7.42645413e-02f, 3.13685834e-02f, 1.53808221e-01f, 1.19778933e-02f, 5.58483005e-02f, 1.31637707e-01f, 7.85199984e-04f, 1.79872200e-01f,
  1.13471031e-01f, 6.92280531e-02f, 7.24879280e-02f, 3.85003686e-02f, 9.38849375e-02f, 1.11543208e-01f, 2.22107116e-02f, 1.17955200e-01f, 1.45325691e-01f, 2.51920316e-02f,
  1.18605755e-01f, 1.23059645e-01f, 5.29463850e-02f, 1.34210542e-01f, 2.51394622e-02f, 1.33644357e-01f, 1.82166383e-01f, 5.36822788e-02f, 1.37379557e-01f, 1.32242888e-01f,
  3.50008279e-01f, 4.40642657e-03f, -1.96542427e-01f, 7.56689385e-02f, -5.01132337e-03f, -1.19146079e-01f, 4.25717682e-02f, 5.89935817e-02f, -3.13801356e-02f, -1.98550033e-03f,
  1.05000652e-01f, 2.59819031e-02f, -2.04839595e-02f, -1.79495782e-01f, -1.39387906e-01f, -1.42115861e-01f, -1.86163962e-01f, -2.59064049e-01f, -2.46244401e-01f, -1.28035486e-01f,
  -1.56818569e-01f, -5.04737981e-02f, -4.95780073e-02f, -6.70201555e-02f, -2.29139507e-01f, -1.02957249e-01f, -2.46181399e-01f, 5.05981920e-03f, -1.60943642e-01f, -3.29654157e-01f,
  -2.60531008e-01f, 1.04238376e-01f, -1.52023971e-01f, 5.07321954e-02f, -6.07335716e-02f, -1.29834980e-01f, -9.19255391e-02f, -1.23819336e-01f, -4.56128642e-02f, -1.11496530e-01f,
  -1.18804686e-01f, -1.18779071e-01f, -1.27023950e-01f, -7.76754245e-02f, 7.53901200e-04f, -1.08213484e-01f, -1.38044342e-01f, -4.18692753e-02f, -2.04333425e-01f, -9.75207835e-02f,
  -4.95416299e-02f, -1.01223886e-01f, 1.65288579e-02f, -1.04293145e-01f, -1.64294213e-01f, -5.59560806e-02f, -1.00090139e-01f, -7.91164711e-02f, -6.26758561e-02f, -1.73786074e-01f,
  9.47606005e-03f, 1.67736132e-02f, 8.44800249e-02f, 1.06688984e-01f, 1.67379022e-01f, 2.74124946e-02f, 1.37392923e-01f, 4.68269847e-02f, 1.35760292e-01f, 1.80986732e-01f,
  1.54222250e-01f, 4.13757190e-02f, -2.15289015e-02f, 1.13274992e-01f, -1.17792347e-02f, 4.47075292e-02f, 8.20373669e-02f, 5.45282029e-02f, 9.06425621e-03f, 9.38582718e-02f,
  1.48665234e-01f, 9.08863619e-02f, 6.30017594e-02f, 7.05588087e-02f, 7.57296085e-02f, -5.83984563e-03f, 8.37678164e-02f, 1.44195363e-01f, 7.74397627e-02f, 7.52826110e-02f,
  6.87854737e-02f, -7.88276084e-04f, -2.69913767e-02f, -8.66205618e-02f, -1.56997681e-01f, -1.07444718e-01f, -1.17849134e-01f, -8.36814046e-02f, -5.11451550e-02f, -1.01289168e-01f,
  -1.10175736e-01f, -4.28714277e-03f, -1.45261725e-02f, -5.69353290e-02f, -1.36270568e-01f, -8.98939222e-02f, -9.12025720e-02f, -1.60756081e-01f, -1.80472419e-01f, -3.12633924e-02f,
  -1.29625991e-01f, -2.02170685e-02f, 7.77636543e-02f, -1.83408096e-01f, -8.72602835e-02f, 7.42211379e-03f, -1.22226954e-01f, -6.15412146e-02f, -9.76965651e-02f, -1.36487424e-01f,
  -3.40650856e-01f, -2.08872691e-01f, -2.71183580e-01f, -1.21534169e-02f, 1.51811182e-01f, -5.20928316e-02f, -1.32852271e-01f, -6.53481781e-02f, 6.58996254e-02f, 7.30688050e-02f,
  7.65430927e-02f, 1.03578620e-01f, -1.93094593e-02f, -5.65024130e-02f, -1.19214915e-01f, -8.19955841e-02f, -2.05964148e-01f, -2.22734213e-01f, 7.41350232e-03f, 6.05280064e-02f,
  4.01673503e-02f, -1.47077680e-01f, -9.22923535e-02f, -1.04199663e-01f, 1.19280711e-01f, -3.35200876e-02f, 1.84970777e-02f, -1.55991791e-02f, -5.10328785e-02f, -6.72489032e-02f,
  -2.29899198e-01f, -5.06760702e-02f, 9.87608284e-02f, 2.05237284e-01f, 1.66205645e-01f, 5.95374557e-04f, 1.13382638e-01f, 4.20938851e-03f, 3.58885378e-02f, 1.10696614e-01f,
  5.03645800e-02f, 8.99990872e-02f, 1.16390534e-01f, 5.85723296e-02f, 5.98378032e-02f, 1.36172682e-01f, -2.29235124e-02f, -9.26337764e-02f, 8.29007328e-02f, -1.24326795e-02f,
  1.03993721e-01f, 5.48510738e-02f, -1.43573945e-02f, 1.09265387e-01f, 3.53437252e-02f, 3.17313001e-02f, -5.74559160e-02f, 7.83884153e-02f, 3.80590409e-02f, -2.47441605e-02f,
  -3.98851782e-02f, -1.18250117e-01f, 1.07801519e-02f, -1.17149279e-01f, -4.44016010e-02f, -8.43764544e-02f, 1.19206579e-02f, -9.03935060e-02f, -1.18669658e-03f, -9.23713073e-02f,
  -5.47828618e-03f, -1.21593855e-01f, -6.03062399e-02f, -1.09190740e-01f, -7.09933937e-02f, -2.46527810e-02f, -1.47181660e-01f, 2.85703223e-03f, -6.26279116e-02f, -3.67001109e-02f,
  -1.47140354e-01f, 2.07327865e-03f, -9.24739465e-02f, -7.28509203e-03f, -1.35510296e-01f, -1.37735486e-01f, -1.30000055e-01f, -2.41315202e-03f, -6.70972690e-02f, -1.11096948e-01f,
  1.22331697e-02f, 2.03660816e-01f, -5.02775982e-02f, -3.32979895e-02f, 8.24861322e-03f, 9.96082947e-02f, 6.56845942e-02f, 6.59136772e-02f, 1.88261960e-02f, -2.08302401e-02f,
  1.24784864e-01f, 2.32153200e-02f, 4.87596020e-02f, 5.95705062e-02f, -1.37867425e-02f, 2.59959418e-02f, 9.58840270e-03f, -4.44341749e-02f, 5.66411838e-02f, 3.01658437e-02f,
  8.95855054e-02f, -7.56671652e-02f, -1.51526660e-01f, 3.10135516e-03f, 5.66080026e-02f, -8.15272927e-02f, -4.64364775e-02f, 1.38447247e-02f, 8.53216648e-03f, -9.46104005e-02f,
  4.28876020e-02f, 2.07128853e-01f, 1.70510113e-01f, -1.51874097e-02f, -2.11651046e-02f, 2.24815294e-01f, 3.50139618e-01f, 2.29876295e-01f, -9.16283857e-03f, -6.78943843e-03f,
  -1.66286543e-01f, -4.02784437e-01f, -1.33717835e-01f, -4.16478217e-02f, 7.50378221e-02f, 2.09477484e-01f, 2.63895154e-01f, 6.98190331e-02f, -7.26030543e-02f, -6.84216693e-02f,
  -1.80284843e-01f, 9.81805474e-03f, -8.06277916e-02f, -2.32829638e-02f, -6.38792813e-02f, -7.16664419e-02f, 1.60162061e-01f, 4.83640581e-02f, 6.38151169e-02f, 1.02447949e-01f,
  -2.25395262e-01f, 8.58492032e-02f, -1.50306717e-01f, -8.99692178e-02f, -6.58407733e-02f, 5.42256273e-02f, -8.22063908e-02f, -7.66394567e-03f, 1.17510417e-02f, 8.52574781e-02f,
  -9.11581591e-02f, 3.01467385e-02f, -4.00141589e-02f, 2.01264247e-02f, 7.00957775e-02f, -9.23975836e-03f, 1.21277817e-01f, 1.16991088e-01f, 1.10659571e-02f, 8.79184380e-02f,
  -2.56393850e-02f, -7.67356828e-02f, 5.82885146e-02f, 1.00950494e-01f, 1.47227332e-01f, -1.05245657e-01f, 7.99934939e-02f, -5.79967164e-02f, 3.65249142e-02f, 5.84750772e-02f,
  -1.33561209e-01f, 3.93374525e-02f, -5.16593829e-02f, -3.07579562e-02f, -8.93708691e-02f, -1.03712184e-02f, 6.35812506e-02f, -2.15424988e-02f, -5.26055209e-02f, -7.06542581e-02f,
  3.72100063e-02f, 2.85349414e-02f, 6.69339448e-02f, 8.84902403e-02f, 1.20672258e-02f, 6.34886771e-02f, 6.30835444e-02f, -4.31965776e-02f, -2.84528751e-02f, -2.97302920e-02f,
  -3.19061391e-02f, 6.01005629e-02f, -5.44485301e-02f, 1.24751301e-02f, 1.63882095e-02f, 3.20277847e-02f, -1.05521418e-02f, 4.90509532e-03f, -1.01355679e-01f, -3.67932655e-02f,
  -1.68713212e-01f, 1.17415031e-02f, -1.05971172e-01f, -2.95296987e-03f, 3.80639620e-02f, -6.41372474e-03f, -1.16998926e-01f, -3.02151311e-02f, -1.12612289e-03f, -5.86441010e-02f,
  -2.85645085e-03f, -9.78225656e-03f, 7.51813427e-02f, 4.54934835e-02f, -1.03647046e-01f, -1.29364833e-01f, -2.12054756e-02f, -1.86135136e-02f, 7.36248493e-03f, -2.16029789e-02f,
  9.57515314e-02f, 4.21389239e-03f, -5.83631545e-02f, -8.81818607e-02f, 6.22332096e-03f, -5.95900305e-02f, -1.34329885e-01f, 5.10867778e-03f, -6.46555200e-02f, -8.57603475e-02f,
  -1.35494471e-01f, 5.07521033e-02f, -1.20004334e-01f, -1.26453951e-01f, 3.09458543e-02f, 2.60183275e-01f, 2.16018707e-01f, 2.00516015e-01f, 1.43102212e-02f, 1.28027573e-01f,
  5.66599816e-02f, -7.53261987e-03f, 8.07214007e-02f, 4.21560183e-02f, 1.60720497e-01f, 3.50410938e-02f, -6.04702309e-02f, -6.79121763e-02f, -1.49367511e-01f, -5.17308004e-02f,
  4.82519204e-03f, -1.50692984e-01f, -7.97176585e-02f, -8.75207633e-02f, -2.86553383e-01f, -8.24974701e-02f, -1.76385015e-01f, -7.05843940e-02f, -2.31368989e-02f, -3.08468908e-01f,
  -2.33860940e-01f, -1.73571602e-01f, -8.40337798e-02f, -6.28158823e-02f, -1.54437721e-01f, -2.04799190e-01f, -6.23325631e-03f, -2.17853069e-01f, -4.30565439e-02f, -1.13156095e-01f,
  -1.39353275e-01f, -1.34634361e-01f, -1.64817005e-01f, -1.58904269e-01f, -1.24688655e-01f, -1.27902061e-01f, -2.00928316e-01f, -2.08757594e-01f, -9.61379856e-02f, -7.61113688e-02f,
  -9.66130421e-02f, 8.77890270e-03f, -3.37156542e-02f, -2.75363699e-02f, -2.04117581e-01f, -7.41579309e-02f, -1.07687555e-01f, -2.11138427e-01f, -1.28143743e-01f, -9.49554518e-02f,
  2.35463560e-01f, 2.33604424e-02f, 6.57607568e-03f, 1.07383251e-01f, 8.66992548e-02f, 2.18303502e-02f, -1.94754228e-02f, 1.31440997e-01f, 9.98219550e-02f, 8.46359972e-03f,
  7.19413534e-02f, 2.18791552e-02f, -1.03408732e-02f, 3.40702087e-02f, -5.94028970e-03f, 4.48832549e-02f, -1.65773686e-02f, 7.09105134e-02f, -6.07908852e-02f, -6.91098673e-03f,
  -6.57889247e-02f, 5.00539802e-02f, -3.08578741e-03f, -3.22342627e-02f, -4.25130725e-02f, -4.29344997e-02f, 6.06643632e-02f, 4.31450121e-02f, 4.02599536e-02f, 8.14046115e-02f,
  1.80620521e-01f, 1.43872602e-02f, -1.31632194e-01f, -1.04761288e-01f, -8.98219869e-02f, -1.84233531e-01f, -2.41889395e-02f, -3.18958350e-02f, -4.73129526e-02f, -1.06935263e-01f,
  -1.48535535e-01f, -1.18053138e-01f, -3.03014014e-02f, -1.44677714e-01f, -9.59757268e-02f, -3.15283984e-02f, -3.96017730e-02f, -1.32883750e-02f, -1.39469998e-02f, -1.22891828e-01f,
  6.54009287e-04f, -1.63529534e-02f, 9.12306830e-02f, 5.89256324e-02f, -1.76385525e-04f, -2.97155511e-03f, -3.20049375e-02f, -7.06282407e-02f, 1.34575009e-01f, 7.25216493e-02f,
  -4.95950371e-01f, -3.06942374e-01f, 3.03705126e-01f, -2.86765486e-01f, 2.28001133e-01f, 2.70337313e-01f, 2.60776311e-01f, 4.44486551e-02f, -3.04050863e-01f, -1.46862686e-01f,
  -1.93800807e-01f, -2.31553048e-01f, -2.33788997e-01f, -1.20477915e-01f, -1.22343920e-01f, -3.55040655e-02f, 7.05144480e-02f, 1.49424272e-02f, 1.35508776e-01f, 1.85859680e-01f,
  -8.37053508e-02f, -1.68644607e-01f, -5.80098666e-02f, -9.20601562e-02f, -1.87783152e-01f, -1.56283528e-01f, -8.10266584e-02f, 8.10451061e-02f, 1.03618294e-01f, -2.50685632e-01f,
  1.72312543e-01f, 8.75512213e-02f, 5.80728650e-02f, -6.60212114e-02f, -2.86640543e-02f, -6.95758462e-02f, 2.87734307e-02f, -1.76141113e-02f, -1.18033089e-01f, -1.41646013e-01f,
  -3.49520184e-02f, -4.25977632e-02f, -2.26708152e-03f, -9.43678692e-02f, -6.37762994e-02f, 3.78100909e-02f, -6.50060782e-03f, -1.47232413e-01f, -6.41865432e-02f, 2.18508430e-02f,
  -5.99683300e-02f, -3.75508144e-02f, 1.25934049e-01f, 7.01676647e-04f, -2.60431673e-02f, -7.02771842e-02f, -2.53149439e-02f, -4.11122069e-02f, -3.10626961e-02f, -1.86857790e-01f,
  -5.38056716e-02f, -2.48040203e-02f, 1.38209194e-01f, -1.00892754e-02f, 1.25873804e-01f, -2.09802715e-03f, 1.06314771e-01f, 3.84606607e-02f, 9.06386897e-02f, 7.72769302e-02f,
  2.32557096e-02f, 8.16504210e-02f, 3.27388048e-02f, -4.97751869e-02f, 4.41014096e-02f, 3.07447501e-02f, 1.52782612e-02f, 1.56240920e-02f, 1.07555933e-01f, 3.48448306e-02f,
  1.89337283e-02f, 1.60702959e-01f, -2.18159496e-03f, 4.13940335e-03f, 3.61465253e-02f, -2.15469059e-02f, -1.12672886e-02f, 1.10588856e-01f, 7.42425863e-03f, 5.09329922e-02f,
  -1.64866179e-01f, 8.91717896e-02f, -7.99929574e-02f, -8.91077816e-02f, 1.78910661e-02f, -1.06524713e-01f, -7.32047036e-02f, -1.02472439e-01f, 3.06026787e-02f, -1.64705645e-02f,
  4.63258065e-02f, 9.07460600e-03f, -7.52141178e-02f, 1.74915530e-02f, 3.12276650e-02f, 3.64415944e-02f, -1.18301131e-01f, -1.18282370e-01f, -8.57812688e-02f, -7.42453411e-02f,
  -8.33635330e-02f, -2.70511061e-02f, -9.64111090e-03f, -1.11169502e-01f, -5.29067479e-02f, -7.82297403e-02f, 9.42787603e-02f, 6.88199550e-02f, 5.80161214e-02f, -1.68609172e-01f,
  -4.52188700e-01f, 6.91824779e-03f, 2.08429113e-01f, -3.75774562e-01f, -1.80126637e-01f, -8.38793516e-02f, -5.33568300e-02f, -1.78749055e-01f, -2.75063843e-01f, -6.37802035e-02f,
  -2.40533128e-02f, -2.20875278e-01f, -1.91419870e-01f, 5.40041998e-02f, 5.39275557e-02f, -4.02950756e-02f, -1.17128715e-01f, -9.11640748e-03f, 5.07201739e-02f, -4.46740128e-02f,
  -1.17936358e-01f, -1.87842861e-01f, 5.07320203e-02f, -1.32806987e-01f, -6.68087527e-02f, -1.02512784e-01f, -4.85910960e-02f, 8.35836381e-02f, 8.65173936e-02f, -1.68613568e-01f,
  5.74378520e-02f, -5.88841329e-04f, -7.89283663e-02f, -9.41626430e-02f, -2.30050040e-03f, 2.29999777e-02f, -1.17643528e-01f, -3.25039811e-02f, -1.00225136e-02f, -3.03056166e-02f,
  -2.14321874e-02f, -5.78904003e-02f, -9.03871953e-02f, -2.70075276e-02f, 1.91548001e-02f, -7.24524260e-02f, -1.02377394e-02f, -4.05922420e-02f, 6.02013655e-02f, 5.65328188e-02f,
  -5.61838448e-02f, -5.13134748e-02f, 1.48129351e-02f, 2.06793770e-02f, 6.95416778e-02f, -9.69622508e-02f, 6.76370338e-02f, -1.95217971e-02f, 7.42619857e-02f, -1.40886977e-01f,
  -1.38464686e-03f, 2.10341644e-02f, -2.09265272e-03f, 2.46600192e-02f, 2.47329529e-02f, -3.56953293e-02f, -7.08974525e-02f, -3.02714836e-02f, 8.02541971e-02f, 1.17815593e-02f,
  7.64645562e-02f, -5.38778603e-02f, 1.12941995e-01f, -4.01420929e-02f, 4.29104343e-02f, -2.55833603e-02f, 6.44708127e-02f, -2.77660298e-03f, 8.07242692e-02f, -7.80009897e-04f,
  4.88539226e-02f, 7.87284747e-02f, 3.42942216e-03f, 1.38303965e-01f, 5.69580644e-02f, -3.43795978e-02f, -8.39534998e-02f, 5.18811867e-02f, 6.71653673e-02f, 6.00626282e-02f,
  -3.33470106e-01f, 7.16722906e-02f, -2.24321097e-01f, -1.44334540e-01f, -5.52864820e-02f, -8.88599306e-02f, -2.44422778e-02f, -6.25963286e-02f, -5.25481738e-02f, -9.47938338e-02f,
  8.15322064e-03f, -5.16024604e-02f, -2.22768839e-02f, -1.36479381e-02f, -1.35352045e-01f, -2.79817171e-02f, -3.66242416e-02f, -3.75719182e-02f, -9.56856534e-02f, -2.34886054e-02f,
  -3.17708179e-02f, -2.08751485e-01f, -1.76832512e-01f, -1.26076028e-01f, -4.54258882e-02f, -1.89697504e-01f, -6.37322739e-02f, -1.37485117e-01f, -2.13678449e-01f, -3.19693804e-01f,
  2.09659219e-01f, 1.98761612e-01f, 2.78979599e-01f, 2.94193625e-01f, 8.68380889e-02f, 7.12319911e-02f, 1.94186345e-01f, 1.44199148e-01f, 7.59586394e-02f, 1.45966470e-01f,
  7.86912292e-02f, -1.93284750e-02f, 4.62226532e-02f, 2.35672835e-02f, 6.23168610e-02f, 1.05033688e-01f, 8.40087906e-02f, 5.13155907e-02f, 1.34936348e-01f, 1.23903446e-01f,
  1.26608387e-01f, 1.19229876e-01f, 1.20622993e-01f, 1.91346034e-01f, 2.01247036e-01f, 9.17309001e-02f, 2.11829975e-01f, 2.28460729e-01f, 1.99063808e-01f, 2.53761888e-01f,
  1.33037940e-01f, 1.66084304e-01f, -1.31000146e-01f, -1.20965242e-01f, 1.61525235e-02f, -1.13725930e-01f, -6.72262385e-02f, -2.15123240e-02f, -5.82598932e-02f, -5.15914857e-02f,
  5.65696992e-02f, -6.64632767e-02f, 5.84171899e-02f, 2.49418914e-02f, -7.54089653e-02f, 3.48782316e-02f, 4.70070057e-02f, 1.08347386e-01f, 6.18027970e-02f, 1.57537137e-03f,
  6.34551197e-02f, 5.91464043e-02f, 1.11197866e-01f, -7.83895180e-02f, 1.01502664e-01f, 2.34976504e-02f, 6.30171746e-02f, 1.45535961e-01f, -1.96313933e-02f, 6.09705076e-02f,
  1.12369200e-02f, 4.22160961e-02f, 7.15349540e-02f, -1.13669448e-02f, 5.14011271e-02f, 1.26365852e-02f, 7.17678070e-02f, 9.50620137e-03f, 7.63922036e-02f, 1.40133295e-02f,
  7.35551268e-02f, 2.56063370e-03f, -2.85814237e-02f, 6.80271760e-02f, 7.04966486e-02f, 3.13148685e-02f, 4.70230840e-02f, 2.26164404e-02f, -4.32620160e-02f, -5.05048297e-02f,
  4.13289852e-03f, -3.21961269e-02f, -2.40132455e-02f, 3.75980549e-02f, 1.07840240e-01f, 2.61015203e-02f, -1.69755593e-02f, 5.49325906e-02f, 4.38426733e-02f, 8.70772526e-02f,
  7.04469234e-02f, -6.98874816e-02f, -9.45128053e-02f, 3.79727781e-02f, -2.70548295e-02f, -8.37876052e-02f, -9.30250213e-02f, -8.70985836e-02f, -4.16045114e-02f, -2.48481464e-02f,
  -6.51920261e-03f, -6.35422319e-02f, -3.09658628e-02f, -7.74739608e-02f, 4.30405848e-02f, 6.69801086e-02f, -3.81407961e-02f, 1.41186621e-02f, -2.35326570e-02f, -1.08707063e-01f,
  7.21519142e-02f, -5.45421429e-02f, -1.05726548e-01f, -7.19063878e-02f, -1.26832514e-03f, 3.64216268e-02f, -1.03345200e-01f, -4.78795208e-02f, 5.72814420e-02f, 2.02365667e-02f,
  9.77289751e-02f, -2.92729497e-01f, 4.41019163e-02f, -1.76084995e-01f, -1.56374186e-01f, 9.15230904e-03f, -1.32276639e-01f, 4.34316359e-02f, -6.95501566e-02f, -6.28409386e-02f,
  -6.05879463e-02f, 1.13223717e-01f, 1.53723329e-01f, 2.12558448e-01f, 9.51753482e-02f, -1.87166452e-01f, -1.17198907e-01f, 1.54000193e-01f, 3.75326604e-01f, 1.81683481e-01f,
  -1.66116450e-02f, -1.32501781e-01f, 1.05028637e-01f, 1.04425758e-01f, -2.43972257e-01f, -1.11933857e-01f, -1.46752074e-01f, -4.63350862e-02f, -5.41112199e-02f, -2.90059656e-01f,
  1.29246771e-01f, 1.66449726e-01f, 1.27890527e-01f, 4.10310701e-02f, -7.81532526e-02f, 5.54833077e-02f, 6.87848851e-02f, 4.81258109e-02f, -5.78876399e-02f, -3.52180675e-02f,
  -4.66924049e-02f, -3.38245928e-02f, 4.15860629e-03f, 1.26917046e-02f, 6.34422153e-02f, -3.09915375e-02f, 9.01486725e-03f, 9.03990120e-02f, 2.66480390e-02f, -3.13460864e-02f,
  -8.32204372e-02f, -1.04260154e-01f, 1.75487146e-01f, 1.28966123e-01f, 3.01588029e-02f, 1.38575405e-01f, 9.10355672e-02f, 1.64577618e-01f, 1.00171827e-01f, -1.32694229e-01f,
  -2.92300619e-02f, -1.01982411e-02f, -8.55146497e-02f, -6.73425943e-02f, -1.42316490e-01f, 5.48003893e-03f, -2.49242876e-02f, -9.05723125e-02f, -8.75882879e-02f, -5.19436374e-02f,
  6.65515065e-02f, -5.77322990e-02f, -4.88425791e-02f, -4.48357267e-03f, 3.84365804e-02f, -2.36753952e-02f, 2.95568518e-02f, -6.07489189e-03f, 6.28230199e-02f, -8.72846544e-02f,
  -7.56233335e-02f, 2.43967753e-02f, -3.16035151e-02f, 5.69197349e-03f, -3.61347161e-02f, 5.78259081e-02f, -4.51726168e-02f, 6.14438839e-02f, 7.00092986e-02f, -5.37475990e-03f,
  6.19490584e-03f, 2.03257218e-01f, -3.90079105e-04f, 4.53231595e-02f, -9.97348279e-02f, -5.74859008e-02f, -1.06459968e-01f, -4.93635312e-02f, -3.52238491e-02f, 5.70520945e-03f,
  8.47339481e-02f, 2.46259128e-03f, -1.79031084e-03f, -2.76031792e-02f, 5.80203645e-02f, -6.01570308e-02f, -1.84897512e-01f, -5.27589507e-02f, 1.03294954e-01f, 3.08720767e-02f,
  -6.13453165e-02f, -5.83788827e-02f, -5.17746108e-03f, -1.04298617e-03f, 6.37302175e-02f, 8.71210098e-02f, -5.04863523e-02f, -3.16443527e-03f, 1.06480360e-01f, -1.39563650e-01f,
  6.67878147e-03f, -8.59159082e-02f, -1.23695470e-01f, -1.09409288e-01f, 1.70103535e-02f, 6.63044900e-02f, 8.00824612e-02f, 1.62254006e-01f, 9.84350145e-02f, -2.08663065e-02f,
  1.28046855e-01f, 1.26886323e-01f, 2.19512403e-01f, 1.06512681e-01f, 1.36484653e-01f, -1.17822900e-01f, -1.74025178e-01f, 7.02542588e-02f, 1.06935650e-01f, 3.15677375e-02f,
  5.43173328e-02f, -1.22418813e-01f, -1.97491106e-02f, 2.69213151e-02f, -3.94613445e-02f, -5.97568080e-02f, -7.42595345e-02f, -7.16231912e-02f, -4.56440262e-02f, -1.34469256e-01f,
  6.65777326e-02f, -5.59483171e-02f, 6.67545125e-02f, -2.57234499e-02f, -3.50055546e-02f, -2.93024480e-02f, -2.51212213e-02f, -6.54782876e-02f, -4.15611155e-02f, 4.20595407e-02f,
  -3.43117700e-03f, 2.71125045e-02f, -2.54620928e-02f, -5.43462336e-02f, -4.24175449e-02f, 1.22398594e-02f, -8.21118727e-02f, -8.59357417e-02f, -7.10136294e-02f, -1.38776647e-02f,
  -2.80344374e-02f, -8.56349170e-02f, -1.27828613e-01f, 1.30966529e-02f, 3.31900716e-02f, 3.10757998e-02f, -9.92633700e-02f, -6.63716421e-02f, -5.67173623e-02f, -1.13006994e-01f,
  -1.64503753e-01f, 9.16351154e-02f, -2.62601934e-02f, -3.79237048e-02f, 4.21547778e-02f, 8.68376121e-02f, 2.40409859e-02f, 7.93890730e-02f, 3.33203264e-02f, -5.28934337e-02f,
  -2.57259570e-02f, 1.33127868e-01f, 5.28203212e-02f, 5.58274090e-02f, -2.16198782e-03f, -5.53840734e-02f, 1.26563979e-03f, 1.40864160e-02f, 1.09627746e-01f, 5.77704199e-02f,
  1.73937064e-02f, 5.38585894e-02f, 1.21673336e-02f, 4.12557833e-02f, 7.93388188e-02f, 9.50822234e-02f, 2.68622078e-02f, 4.26938683e-02f, -3.07444688e-02f, -6.59132153e-02f,
  1.18075244e-01f, 1.60771847e-01f, 6.55551702e-02f, 9.49632600e-02f, -9.42038149e-02f, 5.83431264e-03f, -1.49135133e-02f, -2.29963232e-02f, -1.16244927e-02f, 7.74170458e-02f,
  6.11965694e-02f, 3.94037701e-02f, 5.24257310e-02f, -5.57470284e-02f, -6.63506379e-03f, 7.81536475e-02f, -6.61626011e-02f, 4.34004888e-02f, -8.25058855e-03f, -8.54192972e-02f,
  1.24401215e-03f, -7.80530497e-02f, 6.51885814e-04f, 8.10034797e-02f, -1.63445752e-02f, 1.60683215e-01f, 1.21081937e-02f, 5.73785342e-02f, 1.48730138e-02f, -4.69762422e-02f,
  -1.07330360e-01f, -2.02568576e-01f, -1.83482915e-01f, -2.22538918e-01f, -3.29863250e-01f, -2.87541449e-01f, -2.81781465e-01f, -1.67795613e-01f, -1.87540159e-01f, -1.99697778e-01f,
  -2.93169081e-01f, -1.48668855e-01f, -1.04999132e-01f, -1.45966589e-01f, -7.65981227e-02f, -1.11632220e-01f, -1.03257723e-01f, 1.08310785e-02f, -3.15406285e-02f, -2.86236554e-01f,
  -2.23139495e-01f, -1.66139141e-01f, -6.71828166e-02f, -1.21734492e-01f, -1.42865032e-01f, -6.26103207e-02f, -5.19060008e-02f, -2.13604659e-01f, -7.94964209e-02f, -2.53015518e-01f,
  -4.00372773e-01f, -5.61552420e-02f, -4.63852435e-02f, -2.89301947e-02f, -1.30318895e-01f, -5.73664308e-02f, -1.18102178e-01f, 5.01901768e-02f, -8.99924412e-02f, -1.00772053e-01f,
  -1.13499649e-01f, -1.03876226e-01f, -1.00791752e-01f, -2.08686873e-01f, -1.04237877e-01f, -9.73781049e-02f, 2.38220557e-03f, -8.85790680e-04f, -1.11453734e-01f, -1.68389827e-02f,
  -2.29667366e-01f, -6.27515316e-02f, -8.48807767e-02f, -4.53192219e-02f, 4.96327691e-03f, -1.21454701e-01f, -1.07816778e-01f, 1.04742199e-02f, 6.59914762e-02f, -1.00087011e-02f,
  -3.97691689e-02f, 7.40066916e-02f, 1.16720699e-01f, 1.43876866e-01f, 1.17928535e-02f, 4.68877740e-02f, 6.61896355e-03f, -1.84489950e-03f, 3.98774743e-02f, 1.20166518e-01f,
  2.00698860e-02f, 4.74617295e-02f, 2.80676619e-03f, 1.08504720e-01f, 2.91765612e-02f, 4.43695560e-02f, -4.93370593e-02f, 7.30497018e-02f, 2.58682445e-02f, -2.39489153e-02f,
  5.92166893e-02f, 4.38073315e-02f, 7.38654211e-02f, 1.14729270e-01f, 6.67842776e-02f, 6.97201863e-02f, 5.56622408e-02f, 4.23873663e-02f, 7.40874186e-02f, 2.18139086e-02f,
  -2.36695990e-01f, 6.30307943e-02f, -1.08544573e-01f, 4.64509381e-03f, -8.38259682e-02f, 4.19776440e-02f, -1.57298237e-01f, 4.48013879e-02f, -2.39727180e-03f, -6.37164265e-02f,
  -2.64679585e-02f, -4.09758799e-02f, -9.13470089e-02f, -5.84016740e-02f, -8.03439468e-02f, -8.57538655e-02f, -7.64476135e-02f, -2.63820775e-02f, -1.59390867e-02f, -1.23942168e-02f,
  -5.14516272e-02f, 9.15864855e-03f, -7.45632648e-02f, -5.68838269e-02f, -1.06295226e-02f, 2.59466041e-02f, -1.03943527e-01f, -4.77167517e-02f, 6.01550005e-02f, -7.47496709e-02f,
  -1.65016159e-01f, -2.31766552e-01f, -3.31591338e-01f, 9.49559286e-02f, 2.74995387e-01f, 2.92140603e-01f, 1.89239219e-01f, 3.03522825e-01f, 1.74092531e-01f, 2.57119425e-02f,
  4.53574546e-02f, -5.96169308e-02f, -8.48849639e-02f, -1.81228653e-01f, -7.10029975e-02f, -1.19458452e-01f, -7.35160112e-02f, -3.47175777e-01f, -6.06922023e-02f, 8.75379294e-02f,
  3.76325808e-02f, -1.26570985e-01f, -1.82082653e-01f, -6.66254237e-02f, -2.54891720e-02f, -1.05589479e-01f, -1.24740802e-01f, -6.56173229e-02f, -1.18501291e-01f, -3.18582833e-01f,
  -3.16336721e-01f, -6.01517363e-03f, -4.57286201e-02f, -3.46579142e-02f, -1.35382302e-02f, -9.62395221e-02f, -3.09837349e-02f, -1.06297202e-01f, 7.17253387e-02f, 3.35622206e-02f,
  3.48292589e-02f, -3.27062123e-02f, -4.25294936e-02f, -3.28055583e-02f, 2.22265758e-02f, -5.31971380e-02f, -9.10647810e-02f, -1.22211270e-01f, -8.12720358e-02f, -4.64416668e-02f,
  -3.56744193e-02f, -9.89599377e-02f, -1.52097747e-01f, 4.50755097e-02f, 6.32084087e-02f, -8.96510319e-05f, -2.12596711e-02f, -2.13380940e-02f, 3.07103172e-02f, -3.24970596e-02f,
  7.06886277e-02f, -5.49212024e-02f, 3.53656895e-02f, 6.91556036e-02f, 4.73529212e-02f, 1.36727288e-01f, -7.95133412e-03f, -4.83732969e-02f, -3.91431525e-02f, 3.93810719e-02f,
  -3.56464088e-02f, 1.12732328e-01f, -3.73000503e-02f, 4.48704623e-02f, 5.53923398e-02f, -5.76295815e-02f, -7.39954934e-02f, -5.86579256e-02f, 5.77189960e-02f, -9.32975765e-03f,
  -4.56192605e-02f, 8.27284977e-02f, 3.21976766e-02f, 2.99038664e-02f, 4.55374345e-02f, 3.60042825e-02f, -5.43255992e-02f, 6.02971986e-02f, 2.71387845e-02f, 4.51194458e-02f,
  -1.26638368e-01f, 1.51824616e-02f, -5.09390607e-02f, -3.56911384e-02f, -7.20132142e-02f, 5.78016266e-02f, -2.90837996e-02f, -2.17115730e-02f, 1.49757667e-02f, -5.33090346e-02f,
  -6.21282645e-02f, 1.90011039e-02f, -2.86542457e-02f, 3.35696526e-02f, 1.09563554e-02f, -2.48718150e-02f, 7.23631959e-03f, -6.19484074e-02f, 7.29401484e-02f, 6.11374043e-02f,
  1.01586096e-01f, 9.43551287e-02f, 3.11253238e-02f, -4.68367785e-02f, 9.36253518e-02f, -8.77936929e-02f, -1.31253988e-01f, -2.61416174e-02f, -1.13423496e-01f, 9.18609872e-02f,
  -2.85195429e-02f, -4.52953964e-01f, -3.00523490e-02f, 2.37547606e-01f, -6.22496754e-03f, -7.90154189e-02f, -2.15032190e-01f, -1.51483193e-02f, 1.31864280e-01f, -9.10285786e-02f,
  -8.91834497e-02f, 1.48917399e-02f, 5.36435992e-02f, -3.88480350e-02f, -8.57873186e-02f, -2.48376355e-01f, -2.47181542e-02f, 1.51290342e-01f, 2.41084844e-01f, 1.05389267e-01f,
  6.95838332e-02f, 1.80148467e-01f, 2.60054708e-01f, 7.82100558e-02f, -7.25012785e-03f, 1.98221520e-01f, 6.18095919e-02f, -2.03338191e-02f, -1.20767854e-01f, -5.61725609e-02f,
  -2.10153162e-02f, -2.36927137e-01f, 1.49722993e-01f, 9.49136466e-02f, 2.36725854e-03f, 4.58944701e-02f, -2.69478392e-02f, 1.61982536e-01f, 4.43455763e-02f, 6.05878308e-02f,
  1.82270482e-02f, -1.95775107e-02f, 2.96660159e-02f, -1.01672504e-02f, 9.38923210e-02f, 6.74456209e-02f, -3.45861800e-02f, 4.55354825e-02f, -2.89895777e-02f, -1.27449378e-01f,
  -7.09700435e-02f, 2.12927442e-03f, -1.71758719e-02f, -1.36944443e-01f, -1.59867816e-02f, 1.45716310e-01f, -1.23550281e-01f, -5.13370149e-02f, -1.04722172e-01f, 5.90239577e-02f,
  1.43909335e-01f, 1.65570155e-02f, -5.39718568e-02f, -5.21090031e-02f, -8.70625023e-04f, -1.00404181e-01f, 4.34501184e-04f, -3.89114246e-02f, -6.36252016e-02f, 7.17377290e-02f,
  -5.23332134e-02f, -8.17116722e-02f, -4.43447680e-05f, -1.06520616e-01f, -5.31809889e-02f, -3.06832176e-02f, -7.76751190e-02f, -1.06607981e-01f, -1.08848296e-01f, -7.64347389e-02f,
  -9.06036422e-02f, -4.06832434e-02f, 2.88391318e-02f, -1.02751590e-01f, -1.10148646e-01f, -6.44529313e-02f, -5.78665826e-03f, -3.87715176e-02f, 1.56771597e-02f, -1.83101632e-02f,
  2.39664942e-01f, -5.02089709e-02f, 2.80739665e-02f, 2.93666497e-03f, -3.66075500e-03f, 8.90323818e-02f, 1.10492691e-01f, 1.33666754e-01f, -2.75243092e-02f, 5.10678664e-02f,
  1.86912324e-02f, 4.00360934e-02f, 3.18680182e-02f, 4.98142317e-02f, 1.11513570e-01f, 1.30772278e-01f, -5.74316233e-02f, 4.12431993e-02f, -5.73650980e-03f, -2.62899436e-02f,
  2.76912861e-02f, 4.73362021e-03f, 1.60334632e-01f, 9.34276581e-02f, 9.52962935e-02f, 1.48531944e-01f, 1.54914752e-01f, 1.37068897e-01f, 8.72053355e-02f, 1.72021493e-01f,
  -4.02648479e-01f, -4.69049662e-01f, 3.39242429e-01f, -7.14882612e-02f, 1.29041567e-01f, 5.33762649e-02f, -1.57075539e-01f, -1.67101666e-01f, -1.39104158e-01f, -2.65720338e-01f,
  5.49186245e-02f, 1.54461861e-01f, 5.51808253e-02f, 2.35329434e-01f, 3.03395689e-02f, -6.71448708e-02f, 1.48386788e-03f, 2.84305722e-01f, 3.49490434e-01f, 1.28380850e-01f,
  7.33335083e-03f, -1.02317236e-01f, -1.00622382e-02f, -2.51426864e-02f, 1.22208218e-03f, 7.80090764e-02f, -8.86045247e-02f, 4.95559862e-03f, 3.24271321e-02f, -1.61261708e-02f,
  2.97316492e-01f, -4.99097481e-02f, 2.00669065e-01f, 7.35234246e-02f, 4.21323627e-02f, -3.51628810e-02f, -4.60038595e-02f, 6.11081533e-02f, 1.13172177e-02f, -9.36804339e-02f,
  8.16372037e-02f, 5.88294081e-02f, 1.18549205e-02f, 6.21259883e-02f, 8.99664313e-02f, 3.52518703e-03f, 3.69772278e-02f, 1.19650647e-01f, 1.44433334e-01f, 4.91278432e-02f,
  8.52027684e-02f, 5.84935322e-02f, 9.32765678e-02f, 1.61313862e-02f, 1.50235966e-01f, 1.04658574e-01f, 7.61412680e-02f, 1.71687633e-01f, 2.64381599e-02f, -1.09597594e-01f,
  -4.60425988e-02f, -2.17149630e-02f, 1.04564475e-02f, -7.63319731e-02f, -2.34282613e-02f, -1.08014653e-02f, -1.07660517e-02f, -1.73433181e-02f, 1.95716340e-02f, -5.71164861e-02f,
  -7.17308000e-02f, -5.33440895e-02f, -3.23061384e-02f, -6.54381514e-02f, 1.13982419e-02f, -7.13522881e-02f, -6.09178506e-02f, 2.14728396e-02f, 7.34767169e-02f, 2.50587333e-02f,
  1.73869543e-02f, 7.99635053e-02f, 5.95793352e-02f, -4.25744355e-02f, -1.54252443e-02f, -4.99990284e-02f, 5.01667522e-03f, -5.46649657e-03f, -1.00409202e-01f, -4.06427756e-02f,
  -8.00316185e-02f, 2.64305919e-01f, 2.43262872e-02f, -2.29788069e-02f, 1.22520611e-01f, 1.32354319e-01f, -3.46307196e-02f, 1.44934841e-02f, 8.34592506e-02f, 9.00084600e-02f,
  4.91555668e-02f, -2.31377129e-02f, 1.37727829e-02f, 1.30173817e-01f, 1.37247801e-01f, 4.37335931e-02f, -8.36921856e-02f, 1.20963573e-01f, 3.99463251e-02f, 5.96518107e-02f,
  -5.01877181e-02f, -6.72130436e-02f, -1.76314116e-02f, 2.30649542e-02f, -6.62427116e-03f, 9.19153318e-02f, -2.36655641e-02f, 7.65385926e-02f, 5.44200204e-02f, -2.50060022e-01f,
  2.03440726e-01f, -9.05979574e-02f, -2.90647089e-01f, -1.21158943e-01f, -1.93342701e-01f, -1.35984480e-01f, -6.61910251e-02f, -3.56728546e-02f, 3.26738507e-02f, -6.51033148e-02f,
  -5.64936064e-02f, -1.41769350e-02f, -4.39087711e-02f, -4.92208824e-02f, -9.42957252e-02f, -5.90352751e-02f, -3.26191843e-01f, -2.33570784e-01f, -2.46139809e-01f, -1.79401129e-01f,
  -2.29611173e-01f, -2.18245044e-01f, -1.36405915e-01f, -1.53837949e-01f, -1.65139243e-01f, -1.13261595e-01f, -2.06357092e-01f, -2.90614486e-01f, -1.61916301e-01f, -3.04977447e-01f,
  -4.16036136e-02f, -1.58369407e-01f, -1.99562564e-01f, -6.10589981e-02f, -8.87670368e-02f, -2.18615383e-02f, -5.50356992e-02f, -1.49806857e-01f, -1.46951647e-02f, -1.71428561e-01f,
  -2.11605549e-01f, -5.04388474e-02f, -1.68593705e-01f, -5.88580817e-02f, -1.04846343e-01f, -1.09844722e-01f, -1.94396794e-01f, -1.38447493e-01f, -1.37485936e-01f, -1.23589523e-01f,
  -1.02778710e-01f, -2.09379032e-01f, -2.39322707e-01f, -4.43224013e-02f, -1.52273700e-01f, -1.53372616e-01f, -1.68660611e-01f, -2.00405762e-01f, -1.01295903e-01f, -2.46599000e-02f,
  1.32220894e-01f, 6.79550469e-02f, 4.21754010e-02f, 1.53752193e-01f, 7.52330720e-02f, 8.36301968e-02f, -2.08451860e-02f, 9.41034406e-02f, 1.46486759e-01f, 1.45530075e-01f,
  6.16070293e-02f, 2.04061955e-01f, 1.66501291e-02f, 9.83238965e-02f, 1.03776902e-01f, 4.93664108e-03f, 1.51162865e-02f, 3.24907303e-02f, 7.09692165e-02f, -2.41134991e-03f,
  1.41802937e-01f, 3.48944031e-02f, 3.92007865e-02f, 6.42660260e-02f, -1.34021891e-02f, -3.45295817e-02f, 4.37357686e-02f, 8.74973238e-02f, 7.20051378e-02f, 1.28487512e-01f,
  1.81469843e-01f, -1.36760026e-01f, -1.29524335e-01f, -3.79274413e-02f, -1.91442400e-01f, -7.72114769e-02f, -6.99759200e-02f, -6.56981915e-02f, -1.86948389e-01f, -8.92984867e-02f,
  -7.06413854e-03f, -1.73101738e-01f, -1.07771091e-01f, -1.02631196e-01f, -7.80360624e-02f, -1.40092820e-01f, 3.63994064e-03f, -1.97190091e-01f, -1.84193164e-01f, -5.57374321e-02f,
  -1.69581603e-02f, -7.85545912e-03f, -1.11997351e-02f, -4.17317748e-02f, -9.55957249e-02f, -1.20077003e-02f, -8.05723369e-02f, -1.37748495e-01f, -1.07923642e-01f, 9.57501382e-02f,
  -2.53737092e-01f, -1.14176087e-01f, -1.48180090e-02f, -1.32982254e-01f, 1.43788174e-01f, 9.33630317e-02f, 1.60335079e-01f, -7.94844404e-02f, -4.05153930e-02f, -3.51290628e-02f,
  -2.47414365e-01f, -3.14356029e-01f, -2.47398317e-01f, -1.07883066e-01f, 8.91065411e-03f, 1.13323763e-01f, 1.03704594e-01f, 7.79644549e-02f, 9.40147191e-02f, 1.97573319e-01f,
  1.78520948e-01f, 8.92435536e-02f, 6.31005988e-02f, 2.78438646e-02f, 8.51441845e-02f, -9.82016474e-02f, -4.28282619e-02f, 1.25651821e-01f, 1.14515655e-01f, 2.79578939e-03f,
  -2.18721956e-01f, -1.21906929e-01f, 2.19297651e-02f, 6.31301329e-02f, 1.15539879e-01f, 3.24767902e-02f, 7.63415769e-02f, -1.10736508e-02f, -6.54148012e-02f, 6.39754310e-02f,
  -3.94597277e-02f, -3.05319112e-03f, -1.15450487e-01f, -2.46226266e-02f, -9.90420952e-02f, -3.81675474e-02f, 5.87493554e-02f, -8.17285702e-02f, -6.96459860e-02f, -2.13120338e-02f,
  -2.52659936e-02f, 3.04724351e-02f, -2.84176935e-02f, -9.12988558e-02f, -8.48431513e-02f, 5.16455472e-02f, -1.25061153e-02f, 2.05903258e-02f, -3.90072688e-02f, 3.73486802e-02f,
  -2.21220832e-02f, 7.55604580e-02f, 2.21707094e-02f, 5.72570935e-02f, 7.69587830e-02f, 7.59015605e-02f, -1.76297966e-02f, -2.14278158e-02f, -9.16363373e-02f, 5.93601689e-02f,
  6.04668595e-02f, 3.56144346e-02f, 1.62804350e-02f, -2.25813948e-02f, -3.03573310e-02f, -4.06062566e-02f, 4.83665317e-02f, -2.56637242e-02f, 1.14217862e-01f, 7.65278190e-02f,
  3.94574665e-02f, 4.16186601e-02f, 3.56884822e-02f, -2.41680611e-02f, 4.89376336e-02f, 5.12729175e-02f, 7.37301409e-02f, -3.16491723e-02f, -1.17439535e-02f, 1.11824155e-01f,
  -3.48646134e-01f, 7.60122091e-02f, -7.32164383e-02f, -7.44360834e-02f, 7.89494216e-02f, -2.18088012e-02f, -1.24450617e-01f, -4.89986409e-03f, -2.63001416e-02f, -5.95032088e-02f,
  6.67457730e-02f, -5.66066839e-02f, -1.42490372e-01f, 4.20865975e-02f, -5.65423518e-02f, -5.43580540e-02f, 2.62692478e-02f, -2.54267920e-02f, 3.11979223e-02f, -6.06969511e-03f,
  3.34322415e-02f, -1.28016755e-01f, -7.35174790e-02f, -1.41867250e-01f, -9.56493318e-02f, -8.88743848e-02f, -8.52595940e-02f, -7.86368921e-02f, -1.88178048e-02f, 7.15311170e-02f,
  2.59397328e-01f, -3.81486624e-01f, 3.39326933e-02f, 5.35409823e-02f, -1.42777026e-01f, -4.57599945e-02f, -6.68002516e-02f, 1.14522383e-01f, 2.51162443e-02f, -7.42572397e-02f,
  -1.29496366e-01f, 5.57153486e-02f, 1.33386999e-01f, 8.94208029e-02f, 1.48180932e-01f, -9.49062407e-02f, -7.26251602e-02f, 1.98275641e-01f, 3.61042500e-01f, 2.16413319e-01f,
  -4.99482341e-02f, 2.43120994e-02f, 2.20583782e-01f, 4.39395942e-02f, -2.07334980e-01f, -3.95214334e-02f, -1.31085366e-01f, -3.79925966e-03f, -7.95778036e-02f, -1.83077112e-01f,
  -2.05550231e-02f, -7.61458501e-02f, 2.75632963e-02f, 1.22717721e-02f, -2.83288136e-02f, -5.86888567e-03f, 7.91935846e-02f, 4.88932692e-02f, 6.69465736e-02f, -3.17226797e-02f,
  -3.65717262e-02f, -5.94216539e-03f, -7.10593686e-02f, -8.65105074e-03f, 9.49902460e-02f, 1.14586473e-01f, 1.09167658e-01f, 9.71876904e-02f, 4.66539599e-02f, 2.18908079e-02f,
  -9.99059007e-02f, 6.74332157e-02f, 1.46751076e-01f, 1.31559759e-01f, -2.60379375e-03f, 1.35708928e-01f, 1.26945525e-01f, 1.17459156e-01f, 1.92680210e-01f, -2.83563379e-02f,
  -6.87015650e-04f, -2.66510360e-02f, -6.57688975e-02f, 4.30431869e-03f, -2.70921830e-02f, -5.15273213e-02f, 1.73946060e-02f, 2.13747751e-02f, 4.22697067e-02f, -7.34263361e-02f,
  -3.35069522e-02f, -9.16393474e-02f, 6.56208843e-02f, -1.54026207e-02f, -5.57044744e-02f, 7.11577088e-02f, -8.74228999e-02f, 2.10535787e-02f, 1.94002390e-02f, 8.74936304e-05f,
  -7.79798487e-03f, 1.69987511e-02f, -4.25655730e-02f, -1.52375242e-02f, 8.52276478e-03f, 5.83557561e-02f, 1.80032440e-02f, 3.93139161e-02f, -4.23106551e-02f, 4.28211987e-02f,
  1.64333433e-01f, 1.45433530e-01f, 3.44987251e-02f, 9.41235051e-02f, -3.27108800e-02f, 9.21422914e-02f, -1.04315095e-01f, 1.74860749e-02f, -4.96272668e-02f, 1.10355793e-02f,
  2.27879956e-02f, 1.09000988e-01f, -1.38643533e-02f, -3.29894908e-02f, 2.74129882e-02f, -3.01741697e-02f, -4.30355296e-02f, 7.54476190e-02f, 8.41991231e-02f, 2.59590987e-02f,
  5.03974520e-02f, 1.64933428e-01f, 1.96217656e-01f, 6.50780201e-02f, 1.03969499e-01f, 9.15070698e-02f, 1.19862042e-01f, 9.84948874e-02f, 2.04360440e-01f, 8.85753781e-02f,
  -1.41182348e-01f, 3.70456800e-02f, -1.40446991e-01f, -2.20658943e-01f, -2.45167106e-01f, -2.67136365e-01f, -1.90027341e-01f, 6.87144920e-02f, -3.63528989e-02f, -1.23235255e-01f,
  -5.54164983e-02f, 5.43025807e-02f, 1.19201869e-01f, 9.42823663e-02f, 2.25671992e-01f, 2.29747947e-02f, -1.14170648e-01f, 1.14751924e-02f, -8.06886051e-03f, -1.08233884e-01f,
  -1.58686072e-01f, -1.43039133e-02f, 2.15395186e-02f, 3.64913978e-02f, -2.07269087e-01f, -1.21330738e-03f, -1.67285830e-01f, -1.39040783e-01f, -5.22793494e-02f, -1.96181998e-01f,
  -1.13769822e-01f, -1.54107153e-01f, 5.98502904e-02f, 5.85231408e-02f, 4.54443395e-02f, 4.61993217e-02f, -6.35471195e-02f, -3.26004326e-02f, 5.06994911e-02f, 2.76392438e-02f,
  -7.75989145e-02f, 6.63309023e-02f, -6.91846758e-02f, 5.84462471e-02f, 5.14767654e-02f, -5.15139513e-02f, 6.17954321e-03f, 1.37880638e-01f, 1.18625835e-01f, -4.70516495e-02f,
  -8.01713243e-02f, -1.81861386e-01f, -1.34717330e-01f, 1.10492207e-01f, 5.07895127e-02f, 1.80785591e-03f, 6.03690445e-02f, -7.48030469e-02f, 1.68233961e-02f, 7.09050223e-02f,
  -1.16322027e-03f, 1.73734464e-02f, -7.16219842e-02f, 8.48243162e-02f, -6.24346472e-02f, 4.13819142e-02f, -2.61518527e-02f, -2.19484214e-02f, -7.83785433e-02f, 4.18946929e-02f,
  -5.47514781e-02f, -1.65268946e-02f, -4.37163487e-02f, -9.23166946e-02f, -7.80745745e-02f, -8.91925916e-02f, -8.21088552e-02f, 4.96341102e-02f, 1.88405253e-02f, -7.57131279e-02f,
  -7.90859014e-02f, 4.63446938e-02f, -3.67429778e-02f, -4.17717174e-02f, -6.38745949e-02f, 1.00171892e-02f, -1.14534572e-02f, -8.43788832e-02f, 7.07267877e-03f, -8.26749429e-02f,
  1.77546576e-01f, 8.16497579e-02f, -7.04040825e-02f, 5.15973866e-02f, -3.25168706e-02f, 3.81071456e-02f, 6.96329623e-02f, 4.27531488e-02f, 5.37779592e-02f, -7.65183344e-02f,
  5.99872991e-02f, 1.34854568e-02f, 1.77365858e-02f, 2.08920687e-02f, -7.11112171e-02f, 7.05081224e-02f, 1.09004430e-01f, -6.27052709e-02f, 1.05285220e-01f, 7.56547451e-02f,
  -4.02826257e-02f, -1.05854735e-01f, -1.13982379e-01f, -2.29020361e-02f, 2.26391032e-02f, -1.02692492e-01f, 8.56267735e-02f, -7.74683012e-03f, 5.61233424e-02f, -5.33347484e-03f,
  1.06752589e-01f, -2.40742102e-01f, -4.27479669e-03f, 3.40886414e-02f, -1.68676391e-01f, -1.90887347e-01f, -2.75577217e-01f, -8.06405246e-02f, -1.25675023e-01f, -1.11170955e-01f,
  -3.76555906e-03f, 2.32585683e-01f, 1.58486694e-01f, 9.90846083e-02f, -5.35975210e-02f, -2.84136713e-01f, -2.53075361e-01f, 1.02695301e-01f, 1.41806766e-01f, 3.50270867e-02f,
  -1.12800583e-01f, 2.93378960e-02f, 6.39264286e-03f, 7.03353062e-02f, -1.67070746e-01f, 2.28754524e-03f, -5.30273281e-02f, -1.56546965e-01f, -1.25654623e-01f, -2.82559395e-01f,
  9.06629264e-02f, 1.08460858e-02f, -6.25938457e-03f, 9.55626555e-03f, 1.18744848e-02f, 6.66384026e-02f, 1.96392611e-02f, 1.88068263e-02f, 7.71764442e-02f, -8.50900188e-02f,
  -4.33312841e-02f, -6.68384284e-02f, -5.47786839e-02f, -2.58972626e-02f, 1.94945820e-02f, 3.38744670e-02f, -6.34079799e-02f, -6.25182176e-03f, -1.16102852e-01f, -1.26833975e-01f,
  2.41226517e-03f, 2.25786702e-03f, -1.36833951e-01f, -1.56479150e-01f, -3.92042939e-03f, 9.97668877e-02f, -1.07047120e-02f, -5.12229428e-02f, 4.19403128e-02f, -2.12513149e-01f,
  4.60725697e-03f, -8.44564587e-02f, -6.97215199e-02f, -8.33420157e-02f, -1.25265550e-02f, -6.69801906e-02f, -5.17309159e-02f, -6.58986494e-02f, -2.62939977e-03f, -4.28142399e-03f,
  1.75032020e-02f, -1.26132567e-03f, -3.52981500e-02f, -5.11813164e-02f, 2.29941923e-02f, -5.97520694e-02f, -7.28341341e-02f, -1.25773057e-01f, 1.88591313e-02f, -2.95489747e-02f,
  -5.45170018e-03f, 1.96343623e-02f, -6.87105209e-02f, -5.45741506e-02f, -3.38604935e-02f, -8.44812579e-03f, -8.73530582e-02f, -8.29838067e-02f, -2.94297766e-02f, -7.83919021e-02f,
  3.16575803e-02f, 1.73214316e-01f, -5.91991767e-02f, 4.59472016e-02f, -6.62618205e-02f, 2.84686703e-02f, -2.67601805e-03f, -6.28314391e-02f, 1.10445924e-01f, 4.77286540e-02f,
  5.63409142e-02f, 2.42136046e-02f, 6.54324368e-02f, -8.11066031e-02f, -1.66095402e-02f, -6.39914721e-02f, 6.16820492e-02f, 2.91966163e-02f, -1.92046561e-03f, -1.17920160e-01f,
  1.42465560e-02f, -3.57460752e-02f, -2.61811749e-03f, -2.68504620e-02f, 1.16612874e-02f, -3.34119089e-02f, -1.47825778e-01f, -8.92237201e-02f, -4.81706858e-02f, -7.47072846e-02f,
  -2.38479018e-01f, -2.29246944e-01f, -2.86785290e-02f, -9.51031744e-02f, -7.85743892e-02f, -1.57354381e-02f, -1.47062227e-01f, -2.95239524e-03f, 1.90249532e-02f, -1.33644551e-01f,
  8.30784533e-03f, 6.12439439e-02f, 2.76645534e-02f, 2.12481111e-01f, 4.56832573e-02f, -5.51443957e-02f, 1.06410325e-01f, 4.53631356e-02f, 6.98467195e-02f, 7.74867907e-02f,
  5.48235625e-02f, -2.33229753e-02f, 1.24619000e-01f, 1.72405899e-01f, -9.25694481e-02f, 9.37401578e-02f, 9.96775366e-03f, 1.23501411e-02f, -2.61082053e-02f, -1.97533984e-02f,
  -1.32446527e-01f, -2.57260841e-03f, 1.16240978e-01f, 7.38619044e-02f, -7.09080696e-02f, -3.56745198e-02f, -3.55751961e-02f, -1.30581602e-01f, 2.47991886e-02f, -3.53571363e-02f,
  6.27978817e-02f, 8.90136659e-02f, -6.52507544e-02f, -3.90953831e-02f, -3.57478000e-02f, -2.80599687e-02f, -3.81307304e-02f, 8.64823684e-02f, -6.95106685e-02f, 4.36321460e-02f,
  1.33508444e-02f, -1.39965355e-01f, -1.24015860e-01f, -6.24920689e-02f, 8.18030015e-02f, -7.48621598e-02f, -3.17843780e-02f, -6.95787743e-02f, -2.01446451e-02f, -2.70311870e-02f,
  -7.54881427e-02f, -2.86502633e-02f, -5.44339120e-02f, -1.76809505e-02f, 4.80007604e-02f, 4.29656506e-02f, 6.24595471e-02f, -3.26412097e-02f, 4.41241115e-02f, -6.68007061e-02f,
  5.35915382e-02f, -1.00759491e-01f, 9.23313648e-02f, 9.14969132e-04f, 1.04051545e-01f, -9.60280560e-03f, -1.17044384e-02f, -5.21941595e-02f, 2.96254288e-02f, 3.46609987e-02f,
  -6.38282895e-02f, 5.71206957e-03f, -8.75508636e-02f, 1.10628061e-01f, 6.37753904e-02f, -4.69983667e-02f, -2.59145033e-02f, 6.29660264e-02f, 2.60537490e-02f, -5.55510744e-02f,
  -1.33962944e-01f, 7.52823502e-02f, -4.99588288e-02f, 1.54477190e-02f, -9.71675292e-02f, 1.67515930e-02f, -6.95539173e-03f, 2.08859239e-02f, 1.97905675e-02f, -9.87097770e-02f,
  -8.43520463e-02f, 9.01950523e-03f, -4.59480286e-02f, -6.58845715e-03f, -1.20774888e-01f, 4.86522205e-02f, -2.04408802e-02f, 1.86679866e-02f, 1.78009495e-02f, -7.47235417e-02f,
  -1.88760040e-03f, -4.14848886e-02f, -1.95222199e-01f, -1.44954994e-01f, -1.46821499e-01f, -1.31953970e-01f, -1.36872023e-01f, -1.45155475e-01f, -1.59834161e-01f, -2.25376576e-01f,
  -2.62993108e-02f, -3.84864569e-01f, -6.33031502e-02f, -1.03552856e-01f, -8.82833451e-02f, -1.41725838e-02f, -7.49922395e-02f, 9.60695650e-03f, -2.33254973e-02f, -1.33455321e-01f,
  1.05753928e-01f, 1.16501838e-01f, 4.08643708e-02f, 2.02540904e-01f, 1.18166961e-01f, -4.02178764e-02f, -1.66384969e-03f, 2.12561321e-02f, 2.31131792e-01f, 1.11491501e-01f,
  -6.11027889e-02f, -1.85847297e-01f, -1.12897635e-01f, -1.62908480e-01f, -3.43607217e-01f, -1.53950080e-01f, -1.54231176e-01f, -2.73411214e-01f, -1.31183952e-01f, -3.29829395e-01f,
  -2.67041177e-02f, -8.67106244e-02f, 9.92268696e-02f, -9.98900309e-02f, -9.36075449e-02f, -1.73800010e-02f, -9.73343328e-02f, 2.23632641e-02f, -3.89747620e-02f, -6.80113956e-02f,
  1.30619826e-02f, -1.56278182e-02f, -9.38408300e-02f, -1.29739448e-01f, -6.27749264e-02f, -1.07842740e-02f, -9.15898532e-02f, -5.30582704e-02f, -3.15019041e-02f, -5.62414005e-02f,
  -9.42131802e-02f, -4.28076573e-02f, -6.77531064e-02f, -1.66428208e-01f, -4.83104773e-02f, -1.47914011e-02f, -1.28226265e-01f, -1.30588025e-01f, -6.73257634e-02f, -3.00094813e-01f,
  -9.49123278e-02f, 1.25189990e-01f, 1.07547797e-01f, -2.30568219e-02f, 9.72380415e-02f, 7.03337863e-02f, 3.68071496e-02f, 4.51689251e-02f, 1.56864356e-02f, -5.42497821e-02f,
  4.58321422e-02f, 8.91222209e-02f, 6.68753982e-02f, 1.37398047e-02f, 1.46854565e-01f, -1.12651754e-02f, 8.13231394e-02f, 2.19677277e-02f, -1.48731582e-02f, 6.36090338e-02f,
  4.37769219e-02f, 8.26810524e-02f, -2.20310572e-03f, 9.89296846e-03f, 1.43880015e-02f, 1.22281276e-01f, 1.02253847e-01f, -6.46859291e-04f, 1.17580272e-01f, 1.06901042e-02f,
  -2.72932410e-01f, 2.37652227e-01f, -4.27414514e-02f, -6.98514059e-02f, -5.05821444e-02f, -3.81035544e-02f, 5.11812605e-02f, 3.81975845e-02f, -4.43577487e-03f, -1.06340669e-01f,
  -1.01742661e-02f, -6.03095070e-02f, -1.14042483e-01f, -2.98030172e-02f, -3.68461348e-02f, -3.08142696e-02f, -5.28931282e-02f, -8.25960860e-02f, -9.20028836e-02f, -2.02784836e-02f,
  -5.20947389e-02f, -4.97275181e-02f, -9.71604809e-02f, -3.03932689e-02f, -1.59079701e-01f, 2.25915220e-02f, -1.96968034e-01f, -1.64323404e-01f, -7.09724203e-02f, -2.92935014e-01f,
  -2.30776057e-01f, 4.04138193e-02f, 2.41565835e-02f, -6.37574941e-02f, -1.30961508e-01f, -2.53665358e-01f, -2.44735688e-01f, -1.60736755e-01f, -1.16290726e-01f, -3.56758349e-02f,
  9.66430381e-02f, 1.48472879e-02f, -8.55799578e-03f, -3.06662545e-02f, -1.84173182e-01f, -2.33679608e-01f, -1.71268478e-01f, -1.14337578e-01f, -1.44322202e-01f, -4.37569879e-02f,
  -6.31199107e-02f, -4.25846018e-02f, 6.30681738e-02f, -7.51305744e-02f, 1.60040602e-01f, -1.33688338e-02f, 1.21544205e-01f, -4.70639346e-03f, -1.26708388e-01f, 8.06622058e-02f,
  1.65414050e-01f, 9.95021984e-02f, -1.73707694e-01f, -1.78909361e-01f, -3.86650823e-02f, -5.79707772e-02f, -9.41810682e-02f, 1.91930383e-02f, -6.15301244e-02f, -2.01018434e-02f,
  1.76314916e-02f, -1.66950542e-02f, -9.53212157e-02f, 4.43395153e-02f, -1.10465817e-01f, -9.50090289e-02f, -1.00310370e-01f, 2.64337230e-02f, -9.95887667e-02f, 1.31279593e-02f,
  -1.71815515e-01f, -3.48496363e-02f, -1.09535716e-01f, 1.02555603e-02f, -1.07057050e-01f, -8.76487717e-02f, 3.91102023e-03f, -1.07970750e-02f, -6.85805455e-02f, 1.09602727e-01f,
  6.98258877e-02f, 4.91941608e-02f, 3.28418165e-02f, 9.07502770e-02f, 8.15507025e-02f, -6.00612583e-03f, 6.01668172e-02f, 1.11639783e-01f, -1.64605007e-02f, 1.18676394e-01f,
  1.12335116e-01f, 5.34015000e-02f, 5.46496212e-02f, 1.43984333e-01f, 2.95155253e-02f, 1.08199395e-01f, 6.26255944e-02f, 6.47343770e-02f, 2.03350112e-02f, 1.07577436e-01f,
  5.65438438e-03f, 1.03641950e-01f, 8.61204714e-02f, 1.26840800e-01f, 3.37341279e-02f, 7.51637071e-02f, 6.98937625e-02f, 1.19480915e-01f, 4.78655174e-02f, 9.33982730e-02f,
  6.74384087e-02f, -3.47930670e-01f, -9.13164318e-02f, -3.72233859e-04f, -1.38160244e-01f, -1.33940578e-01f, -3.59994248e-02f, -1.06403120e-01f, -7.00571388e-02f, -4.97541018e-02f,
  -1.11598469e-01f, -4.60272990e-02f, -1.08144343e-01f, -1.18732728e-01f, -8.35086405e-02f, -2.31445674e-02f, -1.22924164e-01f, -9.25783664e-02f, -6.08492531e-02f, 1.62219126e-02f,
  -1.29768714e-01f, -1.77681133e-01f, -2.05778062e-01f, -1.21014275e-01f, -1.41554415e-01f, -2.36759633e-01f, -1.17643960e-01f, -5.27166575e-02f, -2.06876442e-01f, -1.63174063e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.52255762e-01f, -4.51799721e-01f, -3.02905440e-01f, -2.07317576e-01f, -1.16810642e-01f, -1.08162545e-01f, -3.50230247e-01f, 6.21485822e-02f, -3.01588140e-02f, -4.89097208e-01f,
  -3.42102528e-01f, 2.66804218e-01f, 2.37511486e-01f, 2.53327668e-01f, 2.99753129e-01f, -3.18870842e-01f, -5.17894737e-02f, 3.00539166e-01f, 5.30636430e-01f, 1.34873137e-01f,
  -5.89119270e-02f, -1.47161752e-01f, 9.15101096e-02f, 2.00904101e-01f, -3.99395227e-01f, 9.84569415e-02f, -2.75100976e-01f, -2.59821415e-01f, -2.16727480e-01f, -1.78659961e-01f,
  -4.53289449e-01f, -7.74319693e-02f, 2.11497113e-01f, 2.63126880e-01f, -1.07715853e-01f, 3.33946384e-02f, -1.73760891e-01f, -1.76008474e-02f, 1.32616414e-02f, -2.10183740e-01f,
  -1.67899117e-01f, 1.04197882e-01f, -4.58123088e-02f, 8.83787349e-02f, -1.27566159e-01f, 1.15530983e-01f, 1.10846378e-01f, 2.20335320e-01f, -3.10165249e-03f, -9.38141271e-02f,
  -1.13888197e-01f, -7.60885254e-02f, 1.57324970e-01f, 3.91907804e-02f, 2.04027161e-01f, 2.14987352e-01f, -5.97180873e-02f, 3.41853909e-02f, -8.99042413e-02f, -6.38445854e-01f,
  -8.37808102e-02f, 3.82004050e-03f, -1.29767120e-01f, 1.70489997e-01f, -2.02871915e-02f, -1.25240266e-01f, -2.68624071e-02f, 2.92038694e-02f, 1.23131685e-01f, -3.83821316e-02f,
  1.69138968e-01f, 2.07774322e-02f, 2.60576636e-01f, -1.42707750e-01f, -3.72576923e-03f, -1.34206042e-01f, -9.84651744e-02f, -7.61381313e-02f, -1.11767575e-02f, 8.82646516e-02f,
  1.92812800e-01f, 3.75735713e-03f, -1.53085679e-01f, 8.73709768e-02f, -5.42102680e-02f, 5.38107976e-02f, -1.13961488e-01f, 8.40779766e-02f, -2.10961923e-01f, -1.22582763e-01f,
  -1.50091484e-01f, 1.39623418e-01f, -4.14478123e-01f, 1.35923803e-01f, 6.02000393e-02f, -9.46608279e-03f, -7.85232633e-02f, 7.95935169e-02f, 1.85569584e-01f, -1.90383401e-02f,
  1.46489881e-03f, -1.05030060e-01f, -1.99527621e-01f, 1.65390804e-01f, 1.40900731e-01f, -5.39385416e-02f, -9.48637128e-02f, 8.24914724e-02f, 8.08365121e-02f, -1.54944479e-01f,
  -8.57143626e-02f, -1.07125998e-01f, -2.01053277e-01f, -5.50537510e-03f, -2.61356264e-01f, 9.71139446e-02f, -1.93310902e-01f, -1.63993001e-01f, -1.97256669e-01f, -7.43064225e-01f,
  -2.14114413e-01f, 3.82614255e-01f, -6.58387467e-02f, 1.07471101e-01f, 2.22146139e-02f, 5.79702891e-02f, 5.98505810e-02f, 4.55050617e-02f, 3.69781256e-02f, 4.49612439e-02f,
  1.27344996e-01f, 1.63663581e-01f, 1.74359336e-01f, 1.12170391e-01f, 1.67819530e-01f, 2.59935647e-01f, 2.85256773e-01f, -1.15712527e-02f, -1.39852270e-01f, 6.56093732e-02f,
  2.02663794e-01f, 2.41141587e-01f, 1.64438616e-02f, 9.07949060e-02f, 2.61516988e-01f, 1.75828859e-01f, 2.28904769e-01f, 1.84208900e-01f, 2.42429972e-01f, 4.84241933e-01f,
  2.09951937e-01f, 9.71807688e-02f, -4.47364226e-02f, -5.02623282e-02f, -1.12931706e-01f, -9.74728987e-02f, -5.63928001e-02f, -1.36504874e-01f, -2.13512313e-02f, -3.15496977e-03f,
  -5.92689551e-02f, -5.66614047e-02f, -6.90450966e-02f, -4.25315760e-02f, -1.44069433e-01f, -1.87931582e-01f, -9.76888165e-02f, -9.85662546e-03f, 1.51283965e-01f, 8.64349827e-02f,
  8.72725621e-02f, -3.83343212e-02f, -1.98203754e-02f, -1.29344001e-01f, -7.64538422e-02f, -1.37142688e-01f, -4.98383567e-02f, -3.31395604e-02f, -1.07626282e-01f, -3.03613953e-02f,
  -1.94067910e-01f, -8.59907493e-02f, 3.07699237e-02f, -6.97719008e-02f, -2.07649410e-01f, -1.97457522e-01f, -8.23320821e-03f, -6.34669885e-02f, -7.40180835e-02f, -1.15588598e-01f,
  -8.41933563e-02f, -7.68837482e-02f, -9.10951942e-02f, -1.52282640e-01f, -1.00487977e-01f, -8.06402694e-03f, -2.86365319e-02f, -1.24528952e-01f, -1.50502697e-01f, 8.71655121e-02f,
  2.46407893e-02f, -1.70104182e-03f, -4.80971262e-02f, -7.75110200e-02f, 1.77727966e-03f, -8.79568160e-02f, -9.17769000e-02f, -6.93126172e-02f, -4.73221950e-02f, 3.79681401e-02f,
  2.90049016e-01f, -1.76620185e-01f, 7.59276301e-02f, 2.48025775e-01f, 1.49499193e-01f, 3.88446748e-02f, -4.65371795e-02f, 1.27736852e-01f, 3.02775949e-02f, 7.66900480e-02f,
  2.21459530e-02f, -5.84182963e-02f, -4.42074100e-03f, -3.78704183e-02f, -1.69857800e-01f, -1.31165922e-01f, -6.85763136e-02f, 1.67005360e-01f, 1.18218392e-01f, 5.53269610e-02f,
  1.15330126e-02f, 2.83941766e-03f, -2.77004149e-02f, -8.33594054e-02f, -5.05583249e-02f, -1.30673498e-01f, -1.43024355e-01f, 2.28107758e-02f, -1.32389545e-01f, -2.74055690e-01f,
  -1.26840875e-01f, -4.39006597e-01f, -4.67117459e-01f, -5.80885887e-01f, -2.13419452e-01f, 1.95762932e-01f, 1.91172048e-01f, 1.73164979e-02f, -4.02165264e-01f, -2.97375947e-01f,
  -3.24112587e-02f, 7.98270330e-02f, -4.01008219e-01f, -7.63463005e-02f, 2.18451977e-01f, -3.32332283e-01f, -3.55484873e-01f, -1.50870785e-01f, 4.25944358e-01f, 3.35627496e-01f,
  4.58942540e-02f, -1.75640404e-01f, -5.53573631e-02f, -1.87083274e-01f, -4.17456329e-01f, -2.84182042e-01f, -5.42706072e-01f, -3.83145124e-01f, -3.11585311e-02f, -5.64708710e-01f,
  -3.61291945e-01f, -8.68151486e-02f, 5.97031042e-02f, 2.55652564e-03f, -1.44973397e-01f, 1.72100570e-02f, -8.12097341e-02f, -1.79416358e-01f, -1.02339439e-01f, -2.48981863e-01f,
  -1.87160984e-01f, 8.92119482e-02f, 1.72792524e-02f, -8.56689215e-02f, -5.73696792e-02f, 6.33075908e-02f, -1.62912175e-01f, 3.83799896e-02f, 6.08985238e-02f, -4.77053560e-02f,
  4.75122929e-02f, 1.99689552e-01f, 7.86385685e-02f, 1.48559287e-01f, 2.48816218e-02f, 5.31147383e-02f, -9.24906209e-02f, 2.19050735e-01f, 1.94876313e-01f, -2.65920967e-01f,
  2.31534779e-01f, 4.80233878e-03f, 7.99928606e-02f, 1.02755446e-02f, 4.38402630e-02f, -6.38755485e-02f, -7.83170909e-02f, 9.37850326e-02f, 1.65871531e-02f, -1.46188226e-03f,
  -1.41137028e-02f, -1.74436606e-02f, 1.84676945e-02f, -2.28387527e-02f, -2.64172517e-02f, 3.66172045e-02f, 4.27584797e-02f, -8.39179233e-02f, 6.57797679e-02f, 3.06207463e-02f,
  9.72572789e-02f, 7.59934038e-02f, -7.12280814e-03f, -3.40750590e-02f, 1.17121957e-01f, -3.03858984e-02f, 2.09774226e-02f, 8.31241459e-02f, 6.78647384e-02f, 1.34307384e-01f,
  -4.71353084e-01f, 3.18412483e-01f, -8.28627348e-02f, 3.55334654e-02f, -3.42847966e-02f, -4.26793471e-02f, -1.39879555e-01f, -1.22992903e-01f, -1.15147360e-01f, -1.91584751e-01f,
  9.85236093e-02f, -2.03671064e-02f, -4.19807769e-02f, -6.17189221e-02f, 1.96456239e-02f, 5.51852696e-02f, 7.70165250e-02f, 7.98145030e-03f, 9.74935815e-02f, -8.31215158e-02f,
  -2.87052039e-02f, 2.91779101e-01f, 1.95786372e-01f, 5.06813377e-02f, 1.54119849e-01f, 3.19904029e-01f, 8.24931860e-02f, 1.59580499e-01f, 3.78290921e-01f, -4.07676101e-02f,
  -3.86668473e-01f, 4.94708233e-02f, -1.95953503e-01f, -1.90162882e-02f, -1.94907114e-01f, -1.73275009e-01f, 7.80330971e-02f, 1.42444506e-01f, -1.39162332e-01f, -1.89939067e-01f,
  -4.19721127e-01f, -1.70888618e-01f, -8.72293264e-02f, -2.25114394e-02f, 1.17140599e-01f, 7.33379573e-02f, 1.97762445e-01f, 2.86114544e-01f, 1.35639042e-01f, 1.34596974e-01f,
  1.94584399e-01f, 2.43165240e-01f, 2.32997000e-01f, 2.64248252e-01f, 1.65406451e-01f, 5.68400696e-03f, -5.09690195e-02f, 8.44148453e-03f, -3.44939344e-02f, 1.39584303e-01f,
  -5.00956535e-01f, -2.63858318e-01f, 6.11711517e-02f, -1.64985448e-01f, -1.49149761e-01f, 3.24487716e-01f, 2.54296094e-01f, 2.22844362e-01f, 1.17926121e-01f, 2.60182709e-01f,
  -1.04146726e-01f, 1.01131871e-01f, 7.69525021e-02f, 1.71345711e-01f, 1.11651957e-01f, 8.63443501e-03f, 3.07915092e-01f, 1.47732332e-01f, 1.23276629e-01f, 1.29465088e-02f,
  5.71644604e-02f, -3.90296757e-01f, -4.32595044e-01f, -1.19363546e-01f, 1.31667823e-01f, -1.59066953e-02f, -2.85286643e-02f, -6.57509500e-03f, -1.51290804e-01f, 2.66626142e-02f,
  7.48565942e-02f, 5.24809957e-02f, 1.09302878e-01f, 2.44632795e-01f, 1.97685942e-01f, -7.81726651e-03f, 1.15896001e-01f, -3.88000645e-02f, 1.10691199e-02f, 4.97265384e-02f,
  -1.92525592e-02f, -1.13597639e-01f, -3.43485028e-02f, -9.84294713e-02f, -1.06833525e-01f, -2.78283563e-02f, -1.41789168e-01f, -7.76230693e-02f, -1.14480801e-01f, -1.14011310e-01f,
  -1.19996078e-01f, -3.85033973e-02f, -8.37904774e-03f, 1.87499911e-01f, -8.68924186e-02f, 2.64815036e-02f, -2.24108994e-02f, 8.68739188e-03f, 9.60828066e-02f, 7.83775002e-02f,
  -8.39021206e-02f, 1.01609297e-01f, -2.10798457e-01f, 5.14113829e-02f, -2.76280552e-01f, -9.80839208e-02f, -1.51558697e-01f, -2.04447992e-02f, -1.77584186e-01f, 3.98727991e-02f,
  -4.49148864e-02f, 1.25818700e-01f, 5.95735908e-02f, 1.66521192e-01f, 1.26033753e-01f, -1.74110249e-01f, 1.62363462e-02f, -2.19741240e-01f, -5.67754433e-02f, -4.41731177e-02f,
  9.65596512e-02f, -2.51772970e-01f, -3.61089528e-01f, -2.11697951e-01f, 1.78735964e-02f, -2.96179444e-01f, -1.44159392e-01f, -1.36787206e-01f, -3.13462615e-01f, -2.29571179e-01f,
  7.44791925e-01f, 6.00735426e-01f, -2.67184436e-01f, 3.40573013e-01f, -1.35678411e-01f, -3.93302023e-01f, -1.13295406e-01f, 7.31129423e-02f, 1.91686228e-01f, 3.14531595e-01f,
  1.06851198e-01f, -4.48402762e-01f, -3.29163700e-01f, -4.69985396e-01f, -4.20550466e-01f, 7.76891038e-02f, 5.26704676e-02f, -4.92042005e-01f, -6.85790062e-01f, -2.21471459e-01f,
  7.09794462e-02f, 4.63918835e-01f, 5.20253360e-01f, -2.68269368e-02f, 3.57506603e-01f, -6.96797743e-02f, 3.94402802e-01f, 4.21743631e-01f, -3.85233834e-02f, 3.20358843e-01f,
  -9.18584466e-02f, 4.19907987e-01f, -5.96706152e-01f, -1.68504920e-02f, 5.07637784e-02f, -6.57539144e-02f, -1.77033246e-01f, -4.12058551e-03f, -2.43720442e-01f, -5.01748659e-02f,
  -1.54744640e-01f, -2.06366271e-01f, -2.86749184e-01f, -8.72528329e-02f, 4.93828431e-02f, -3.96886617e-01f, 2.75356770e-01f, -1.18719734e-01f, -1.27200142e-01f, 6.29893020e-02f,
  -1.17782325e-01f, -3.40164150e-03f, -2.02392146e-01f, 2.85910424e-02f, -1.77504316e-01f, -1.96779594e-01f, 1.04835585e-01f, -4.73735817e-02f, -2.98087653e-02f, 7.58411348e-01f,
  2.96542440e-02f, -1.21924907e-01f, -1.64233923e-01f, 2.34841064e-01f, 5.57498597e-02f, -8.34275484e-02f, 5.23125604e-02f, 1.18173100e-02f, -1.35992691e-01f, -6.80259168e-02f,
  -1.67772681e-01f, 9.77162868e-02f, -6.14955649e-02f, 7.16030225e-02f, -4.23151404e-02f, 6.63408777e-03f, -2.77743280e-01f, 2.35472143e-01f, 3.88288684e-02f, 4.54562642e-02f,
  -4.60713021e-02f, -1.59885526e-01f, 3.39404978e-02f, -7.44975358e-02f, 1.23456709e-01f, -6.61712959e-02f, 7.02220351e-02f, -3.20375115e-02f, 1.02398232e-01f, 2.14765966e-01f,
  1.92373037e-01f, -2.10838154e-01f, -4.30390798e-02f, -7.96627998e-03f, 2.33242456e-02f, -9.52290148e-02f, 1.92852393e-01f, 4.48576696e-02f, -2.15619570e-03f, -1.59702092e-01f,
  -2.33131453e-01f, -3.20357084e-01f, -1.02124095e-01f, -1.69575810e-02f, -9.19984356e-02f, -1.47436365e-01f, 2.98247576e-01f, -1.25894457e-01f, 8.89946893e-02f, 1.49028063e-01f,
  2.43200794e-01f, 6.98609650e-02f, -2.44875289e-02f, -3.16144787e-02f, 8.56530964e-02f, -1.34814069e-01f, -2.44555529e-02f, -2.33014282e-02f, -3.73664856e-01f, 5.92126489e-01f,
  -6.72766984e-01f, 6.22793555e-01f, -1.89120859e-01f, -4.18209523e-01f, -3.94758373e-01f, -2.29313761e-01f, 5.89044392e-01f, -9.88448970e-03f, -4.83372450e-01f, 4.38210756e-01f,
  2.10782722e-01f, -4.06962097e-01f, -3.35776567e-01f, -8.82558972e-02f, 3.14185694e-02f, 5.69709122e-01f, 1.69334784e-01f, -3.22091728e-01f, -5.34129560e-01f, -8.80421400e-02f,
  1.31671891e-01f, -1.69309512e-01f, -3.73063564e-01f, -2.88998008e-01f, -1.67944998e-01f, -3.25156242e-01f, -4.61983681e-02f, -3.21897984e-01f, 4.29364555e-02f, -1.73654817e-02f,
  3.93674344e-01f, -4.32229787e-01f, -1.96127892e-01f, -2.32803732e-01f, -5.92948943e-02f, -1.49400204e-01f, -5.73404022e-02f, -3.77252311e-01f, -1.41957253e-01f, 4.98361923e-02f,
  -3.29593599e-01f, -2.05691233e-01f, -2.95893162e-01f, -9.95477196e-03f, -2.00283021e-01f, -1.03233069e-01f, -1.07636616e-01f, -2.78387457e-01f, -7.19770640e-02f, 2.45607689e-01f,
  4.11943823e-01f, -9.09483954e-02f, -1.34930283e-01f, 1.23393223e-01f, -1.81429744e-01f, -2.38123417e-01f, 1.59609839e-02f, -1.53906837e-01f, -1.00597776e-01f, 4.16050255e-01f,
  2.11415797e-01f, 1.07094511e-01f, -6.31276444e-02f, -4.38612103e-02f, 1.37416482e-01f, 1.33533711e-02f, -9.40540060e-02f, -1.47320759e-02f, -8.40427950e-02f, -4.33132537e-02f,
  8.72063115e-02f, 1.90823168e-01f, -2.94919536e-02f, 1.77460741e-02f, 2.57786941e-02f, -1.18913151e-01f, 7.80665874e-02f, 2.18626276e-01f, -1.91030595e-02f, -1.30622000e-01f,
  -1.57580540e-01f, -1.76685572e-01f, -1.56652451e-01f, 5.14386334e-02f, -4.77687642e-02f, -1.30893409e-01f, 2.43457910e-02f, 8.30942988e-02f, -8.41622427e-02f, -8.22208673e-02f,
  7.73287565e-02f, -1.91845849e-01f, 1.77384362e-01f, -1.31500825e-01f, 6.41017267e-03f, -1.35120302e-01f, -1.31170616e-01f, 7.27368146e-02f, -8.47366154e-02f, 1.25047565e-01f,
  -1.66038707e-01f, 3.01023796e-02f, -1.09014446e-02f, 3.46061811e-02f, -1.04531243e-01f, -5.63343391e-02f, 2.96322376e-01f, 9.00777802e-02f, 2.04657316e-02f, 5.68724163e-02f,
  2.44202167e-01f, 2.09445924e-01f, 1.91270962e-01f, 1.64179236e-01f, -5.05002886e-02f, -7.85368234e-02f, 2.29063094e-01f, 2.55144220e-02f, 9.55150351e-02f, 7.58095920e-01f,
  2.04031795e-01f, -7.87934363e-02f, -7.12769032e-02f, 9.27839950e-02f, 1.16717219e-01f, -3.71593721e-02f, -9.94810909e-02f, -1.10710703e-01f, 1.59664601e-01f, 1.37049630e-01f,
  2.47062027e-01f, 3.21784288e-01f, 3.32455814e-01f, 2.54512638e-01f, 1.24800928e-01f, 2.40599290e-02f, 1.64190438e-02f, 9.44192335e-02f, 1.49495438e-01f, 8.84412825e-02f,
  4.90400866e-02f, -2.65893806e-02f, -1.49279851e-02f, 3.33770551e-02f, 6.53910115e-02f, 1.53850362e-01f, -4.41884110e-03f, -1.34299234e-01f, 1.82486270e-02f, -1.39729053e-01f,
  -4.97166291e-02f, -6.72413409e-02f, 2.06957638e-01f, 8.36133137e-02f, -2.02598125e-02f, -9.17356089e-03f, 8.16287659e-03f, -1.82055861e-01f, -1.84977382e-01f, -6.92978129e-02f,
  -4.42368863e-03f, -6.72059804e-02f, -9.63400900e-02f, -3.36809419e-02f, -1.20730840e-01f, -1.29680559e-01f, -1.11003697e-01f, -4.54226136e-02f, -7.81734362e-02f, 7.62942210e-02f,
  9.61912796e-02f, 5.58415912e-02f, -6.35595992e-02f, 1.56466067e-01f, 5.58627881e-02f, 1.09809622e-01f, 5.40052094e-02f, 1.64401322e-03f, 7.00099990e-02f, -3.19020972e-02f,
  1.83585554e-01f, 1.38787523e-01f, 2.70827025e-01f, 5.38235269e-02f, 1.47492751e-01f, 3.41813713e-02f, -2.43100245e-02f, 2.78450977e-02f, 1.61489233e-01f, -4.45977300e-02f,
  -6.31052107e-02f, 9.73014683e-02f, 1.06996253e-01f, 6.75851479e-02f, 1.09256357e-01f, 8.61184523e-02f, 3.39966342e-02f, 8.69709030e-02f, 8.24436769e-02f, -6.90027773e-02f,
  -6.21601380e-02f, -1.73716724e-01f, -1.50516331e-01f, -7.42665827e-02f, -1.06948532e-01f, 1.37436062e-01f, 4.79928814e-02f, 1.33659706e-01f, 9.52783823e-02f, -7.83237368e-02f,
  -1.57642037e-01f, 2.84955382e-01f, 5.57503216e-02f, 2.76966169e-02f, -8.18038136e-02f, -8.20410997e-02f, 1.72317073e-01f, -5.29655740e-02f, -2.00083822e-01f, -1.88813910e-01f,
  -7.93296471e-02f, -1.26704782e-01f, 3.74916336e-03f, -1.52377084e-01f, -2.79053915e-02f, 6.60716221e-02f, -1.36910649e-02f, 3.16730067e-02f, 8.75668004e-02f, -2.05623433e-02f,
  2.50796992e-02f, -1.20862825e-02f, 1.23885795e-01f, 1.15282185e-01f, 1.91358238e-01f, 1.56479165e-01f, 6.08888417e-02f, -5.36351129e-02f, 1.41615808e-01f, 5.18681780e-02f,
  5.84256984e-02f, 7.70013258e-02f, -7.50943124e-01f, -9.01183635e-02f, -4.45901483e-01f, -6.10621154e-01f, -2.12753952e-01f, 2.36228898e-01f, 1.53558701e-01f, -6.71823844e-02f,
  -4.58581261e-02f, -6.14642650e-02f, -9.08846557e-02f, -2.22905993e-01f, -5.13278916e-02f, -2.43118837e-01f, -4.86188561e-01f, -3.69106323e-01f, -4.62289125e-01f, -4.94028255e-02f,
  -1.31753892e-01f, -8.01342577e-02f, -7.74183497e-02f, -1.11363411e-01f, -1.27208337e-01f, -3.09204817e-01f, -4.38700706e-01f, -3.64235967e-01f, -3.36328954e-01f, -4.54706281e-01f,
  -2.41785750e-01f, -2.74700642e-01f, 4.57235007e-03f, 7.05103353e-02f, -4.09849221e-03f, 2.46093459e-02f, 4.09933068e-02f, -9.99588072e-02f, 1.87826797e-01f, -3.39938402e-02f,
  -1.42835096e-01f, 1.26211181e-01f, -6.92126080e-02f, -1.74217764e-02f, -7.76095316e-02f, -5.24571799e-02f, -1.46968633e-01f, -2.38702774e-01f, -1.93909422e-01f, -1.22531176e-01f,
  -7.02213272e-02f, -4.82608229e-01f, -3.17515969e-01f, -9.25507024e-02f, -1.77488983e-01f, -2.07048386e-01f, -8.44235644e-02f, -1.20135739e-01f, -2.45277122e-01f, 1.46509558e-01f,
  2.85685807e-02f, -4.04821783e-02f, -8.46689288e-03f, 1.74259081e-01f, 7.77981505e-02f, 2.71317754e-02f, 6.57207146e-02f, 9.53332894e-03f, 6.20769821e-02f, 1.19900346e-01f,
  -1.73767041e-02f, 5.73179638e-03f, -9.18512493e-02f, -1.55329332e-02f, -8.70628506e-02f, -1.21050268e-01f, 7.34636262e-02f, 1.11666359e-01f, -1.05509363e-01f, 2.30040308e-02f,
  -7.20456764e-02f, 8.92835390e-03f, -8.66606012e-02f, 9.69737247e-02f, -6.71260282e-02f, 5.21779582e-02f, 2.58298460e-02f, 9.45862979e-02f, 9.20139030e-02f, -2.08531879e-02f,
  3.87030691e-01f, -3.35869640e-01f, 2.51844555e-01f, 3.29237618e-02f, -7.95759857e-02f, -5.07167801e-02f, 2.09640190e-02f, -3.80110219e-02f, -8.70772265e-03f, 7.87683055e-02f,
  5.10724224e-02f, 1.31749839e-01f, -5.01847751e-02f, 8.92236829e-02f, -1.04771964e-01f, 6.50243321e-03f, 1.26975864e-01f, -8.33503082e-02f, -9.73834619e-02f, 1.29686236e-01f,
  1.80819049e-01f, -1.07758958e-02f, 2.93332845e-01f, 1.10602193e-01f, 1.06459633e-01f, 3.52573395e-02f, 1.19483165e-01f, 1.81936905e-01f, 1.10451519e-01f, 4.18909967e-01f,
  1.26164734e+00f, -4.83082682e-01f, -3.31115156e-01f, 6.24865353e-01f, -2.45873816e-02f, -3.56591254e-01f, -5.59007704e-01f, -4.53152098e-02f, 5.00408292e-01f, -1.99635759e-01f,
  -6.64551437e-01f, -4.87400711e-01f, -3.01191472e-02f, -4.09183800e-01f, -4.71363395e-01f, -2.82095045e-01f, 3.96925732e-02f, -1.42397717e-01f, -5.03470659e-01f, -7.70116210e-01f,
  -4.35811102e-01f, 7.04218000e-02f, 8.03400949e-02f, -1.78293213e-01f, 6.53968826e-02f, -7.14983344e-02f, 7.62951300e-02f, -1.75344363e-01f, -5.20814478e-01f, -6.61186278e-02f,
  -4.24205184e-01f, -1.50591731e-01f, -3.02002996e-01f, -5.78464270e-02f, 9.48709920e-02f, 1.38606712e-01f, -1.27152517e-01f, 7.69868344e-02f, -8.26042669e-04f, 9.30923820e-02f,
  -2.91124940e-01f, -2.34718978e-01f, -1.50071710e-01f, -2.56623387e-01f, -1.23890348e-01f, -1.36348277e-01f, -6.16473146e-02f, -1.64964601e-01f, 1.13513932e-01f, -3.05171341e-01f,
  -4.03201371e-01f, -2.82326192e-01f, 9.43747908e-02f, -7.53261074e-02f, -1.49592996e-01f, 9.92219150e-02f, -2.55239010e-01f, -2.15701029e-01f, -3.73608954e-02f, 3.22283745e-01f,
  3.80956978e-02f, 3.93198356e-02f, -6.64501190e-02f, -2.09629554e-02f, 6.91191927e-02f, 6.02895208e-02f, 3.27246077e-02f, -6.01063147e-02f, -1.73316568e-01f, -1.34759739e-01f,
  -1.27461687e-01f, -1.31819800e-01f, 7.73676187e-02f, 1.46979958e-01f, -3.58986929e-02f, 4.21730652e-02f, 3.60884480e-02f, -1.24487095e-01f, -7.65541627e-04f, 2.03266650e-01f,
  4.73809093e-02f, 4.10398804e-02f, 1.57495797e-01f, -3.23124044e-02f, -2.57453740e-01f, -5.11093847e-02f, 1.46394581e-01f, -1.61424562e-01f, -3.30313831e-03f, 3.32629569e-02f,
  3.80435258e-01f, -3.58283252e-01f, 3.90194595e-01f, 6.08078297e-03f, 1.68366611e-01f, 2.84909713e-03f, 7.85932224e-03f, 2.23955903e-02f, 1.75848976e-01f, -9.16597173e-02f,
  -5.42852163e-01f, -1.86643288e-01f, 1.18612558e-01f, 3.27158011e-02f, -9.33786780e-02f, -1.85657322e-01f, -2.68181682e-01f, -3.21972929e-02f, -4.78076711e-02f, 2.84380466e-02f,
  2.81096160e-01f, 2.24967107e-01f, 4.43204254e-01f, 2.83858925e-01f, 1.19988769e-01f, 4.34075594e-01f, 1.76377431e-01f, -7.75100216e-02f, 1.19189061e-01f, 6.52015448e-01f,
  -6.06086910e-01f, -2.53561176e-02f, -8.16497862e-01f, -1.68040916e-01f, -6.65989295e-02f, 3.11746180e-01f, 6.49881482e-01f, 4.23780173e-01f, 2.82735258e-01f, 1.77948847e-01f,
  -6.00121580e-02f, -2.05582634e-01f, -1.89190626e-01f, 4.05455194e-02f, 2.68162400e-01f, 3.14025581e-01f, 7.75034875e-02f, -3.55340391e-01f, -1.53771445e-01f, 4.14811939e-01f,
  5.05268157e-01f, 5.82447462e-02f, -2.04100847e-01f, 2.97788605e-02f, -2.96118781e-02f, -3.40161123e-03f, -2.98235983e-01f, -1.89260870e-01f, 2.83389278e-02f, -3.26142967e-01f,
  -5.31041145e-01f, -4.60623354e-01f, 7.11951628e-02f, -2.41327822e-01f, -3.93550992e-01f, -7.92551413e-02f, -6.73481748e-02f, -3.47499162e-01f, -5.22816889e-02f, 3.66985090e-02f,
  -3.06617230e-01f, -1.67813212e-01f, -1.11414172e-01f, 1.27605662e-01f, 2.75205057e-02f, 5.38951010e-02f, -1.71281807e-02f, -3.13212365e-01f, -2.43022978e-01f, -3.15000832e-01f,
  2.08056271e-01f, -4.10182089e-01f, -6.59256279e-01f, 1.31994719e-02f, -3.77709828e-02f, -2.31034040e-01f, -1.87300324e-01f, -2.04881489e-01f, -2.57153034e-01f, -2.39945993e-01f,
  -6.78860694e-02f, -7.20253401e-03f, -1.79607626e-02f, -2.22010408e-02f, 1.87056661e-01f, 1.34515703e-01f, 3.01094167e-02f, 6.77939802e-02f, 3.99830863e-02f, 1.58188120e-02f,
  -1.60503179e-01f, 4.29869518e-02f, -6.54434636e-02f, -6.89884201e-02f, 1.28922435e-02f, -7.60254413e-02f, 9.01930630e-02f, 1.12222575e-01f, -2.68372409e-02f, 6.10459782e-02f,
  6.34550757e-04f, -4.90317084e-02f, -1.01643443e-01f, 1.07052088e-01f, -5.60733192e-02f, 3.02573969e-03f, 3.82627994e-02f, 7.86159784e-02f, -1.48172200e-01f, 8.98966864e-02f,
  2.82971114e-01f, 7.12413192e-02f, 1.65180769e-02f, 2.77155023e-02f, -1.57473907e-01f, 1.50169507e-02f, 5.12141772e-02f, 1.05632536e-01f, -6.51694760e-02f, -4.02773917e-02f,
  -4.92257823e-04f, -1.35604097e-02f, 1.85475145e-02f, 1.37952313e-01f, 1.41146436e-01f, 1.58503547e-01f, 1.43423781e-01f, -1.46026343e-01f, 7.88243487e-02f, 6.35810867e-02f,
  2.57924944e-01f, 1.68241262e-01f, -1.41621605e-01f, 5.38309515e-02f, 4.84692311e-04f, 2.46697441e-02f, -9.78133380e-02f, 1.47079051e-01f, -7.14615509e-02f, 4.37502325e-01f,
  -5.35888791e-01f, 7.37685323e-01f, -5.53425133e-01f, -2.41665065e-01f, -1.20513402e-01f, 7.65632167e-02f, 7.23824203e-01f, 5.05352736e-01f, 2.27804139e-01f, 3.34712356e-01f,
  1.34731054e-01f, -4.63078260e-01f, -3.92016500e-01f, -2.84078419e-01f, 7.72807971e-02f, 6.38643801e-01f, 1.97369248e-01f, -5.26102364e-01f, -6.39656305e-01f, 2.35630032e-02f,
  4.95055020e-02f, -1.29273653e-01f, -4.67967749e-01f, -1.54084042e-01f, -1.08541064e-01f, -3.12695086e-01f, -1.59828290e-01f, -3.50921214e-01f, -1.37213349e-01f, -3.28932822e-01f,
  -5.86521804e-01f, -2.48995200e-01f, -1.28424957e-01f, -3.27866405e-01f, -5.42086456e-03f, 5.74764647e-02f, 8.34436864e-02f, -2.16504797e-01f, -1.19446136e-01f, 1.21076414e-02f,
  -2.84076303e-01f, 1.74393743e-01f, 1.74176451e-02f, -4.37000602e-01f, -2.81989068e-01f, -2.16646209e-01f, -1.09597571e-01f, -3.68371934e-01f, -1.54047221e-01f, 9.94763523e-02f,
  1.30145729e-01f, -4.11760956e-01f, -5.69283307e-01f, 1.30285069e-01f, 3.01984698e-01f, -3.18384141e-01f, -1.09264672e-01f, -2.45398417e-01f, -3.59768033e-01f, -3.12770545e-01f,
  3.77269596e-01f, -1.20324641e-01f, 3.30238976e-03f, -7.34127639e-03f, 9.72037986e-02f, -1.18776426e-01f, -6.41475022e-02f, -4.57583368e-02f, -5.47293834e-02f, -1.64367072e-02f,
  8.45992640e-02f, -5.38275875e-02f, -5.14550284e-02f, 2.67576486e-01f, 4.10468951e-02f, -1.54993404e-02f, 6.49069771e-02f, 1.29533514e-01f, -3.33086662e-02f, 2.18535930e-01f,
  -1.44277781e-01f, 5.34960479e-02f, -6.62249029e-02f, 1.28647452e-02f, 5.74194081e-02f, 1.93846807e-01f, 1.12177335e-01f, -2.28811041e-01f, -9.67031196e-02f, 1.60494432e-01f,
  -2.30059117e-01f, 4.62612174e-02f, -3.23888838e-01f, 1.36456370e-01f, -1.50499567e-01f, 9.86867305e-03f, 9.48673859e-02f, 1.50818959e-01f, -8.10977444e-02f, 1.06435791e-01f,
  2.00957015e-01f, 1.23206742e-01f, -9.19364616e-02f, -2.40247741e-01f, -1.46186888e-01f, 7.25337490e-02f, 1.40537724e-01f, -2.73265779e-01f, -2.50569284e-02f, -2.12119073e-01f,
  1.44547492e-01f, 3.14015001e-02f, -2.10752338e-01f, -1.59647748e-01f, 1.94153398e-01f, -2.89118111e-01f, -3.54739428e-01f, -2.25107506e-01f, -2.59593934e-01f, 1.60032928e-01f,
  -3.37222397e-01f, -5.21176383e-02f, -2.00403675e-01f, -2.77438998e-01f, 1.33119494e-01f, 6.92336336e-02f, -2.56750017e-01f, -1.42808836e-02f, 1.02067553e-01f, -3.33455682e-01f,
  6.07747585e-02f, 2.22722858e-01f, -2.83424944e-01f, -4.13500220e-01f, -7.72663653e-01f, -7.68430650e-01f, -7.53225327e-01f, -6.32999182e-01f, -1.89795956e-01f, 1.78294092e-01f,
  4.99579236e-02f, -1.40244812e-01f, -2.39865705e-01f, -5.40182590e-02f, 3.24621201e-01f, 7.67476633e-02f, -3.48196109e-03f, -5.03547303e-02f, 1.57012569e-03f, -1.38129517e-01f,
  -5.78435659e-02f, 3.44365448e-01f, 9.03425068e-02f, 6.85590357e-02f, -4.29134965e-02f, -6.48589106e-03f, 2.34230161e-02f, 6.33577481e-02f, 5.08004911e-02f, -1.10760950e-01f,
  8.03960264e-02f, 1.85300387e-03f, 4.92830500e-02f, 7.47665614e-02f, -1.77172214e-01f, -2.73890086e-02f, -1.59920678e-01f, -2.69814938e-01f, -2.89180338e-01f, 6.21849904e-03f,
  7.59955049e-02f, -1.43632414e-02f, -2.59882510e-01f, -1.06987640e-01f, -1.22287376e-02f, -1.11356206e-01f, 2.83829629e-01f, 4.87941474e-01f, -2.08538137e-02f, 1.14120252e-01f,
  -1.18740951e-03f, -9.75800529e-02f, 3.69693078e-02f, 1.22840535e-02f, -1.45684168e-01f, 3.02796084e-02f, -5.51193841e-02f, -1.80904314e-01f, 2.53653899e-02f, -4.24006991e-02f,
  -2.56870426e-02f, -6.14360999e-03f, 2.73784809e-02f, -4.93062548e-02f, -5.04758768e-02f, -4.51406501e-02f, -5.72857819e-02f, -8.09133127e-02f, -1.09633077e-02f, -5.67034557e-02f,
  2.68826950e-02f, 2.54494157e-02f, 1.07638940e-01f, 3.93844955e-02f, 6.09051362e-02f, -1.60771444e-01f, 3.83209134e-03f, 1.12371311e-01f, 1.19142989e-02f, 7.03349989e-03f,
  3.41175236e-02f, -1.60439223e-01f, -1.48169473e-01f, -1.68304697e-01f, -9.23605785e-02f, 9.85207334e-02f, 7.03077316e-02f, -9.01879668e-02f, 1.19625658e-01f, 1.69638321e-02f,
  1.63529560e-01f, -3.71790342e-02f, -2.58518219e-01f, 7.77175836e-03f, -5.06199012e-03f, 1.60924509e-01f, -4.03252751e-01f, -1.42242596e-01f, -2.04386681e-01f, 1.37615725e-01f,
  -2.48052433e-01f, -4.60570902e-01f, -6.75152302e-01f, -3.65574747e-01f, -3.35178226e-02f, -1.52680010e-01f, -1.83212116e-01f, 1.23564988e-01f, -4.25007701e-01f, -4.72785920e-01f,
  8.40718091e-01f, 2.91798472e-01f, 2.66629308e-01f, 1.60945117e-01f, 7.79213682e-02f, 5.87535091e-02f, 8.39613825e-02f, 9.51222423e-03f, -1.91302795e-03f, 1.62001893e-01f,
  2.57636786e-01f, 2.38340363e-01f, 9.98261347e-02f, 2.18048945e-01f, 1.21803045e-01f, -1.05845228e-01f, -1.70059919e-01f, 1.26622841e-01f, 8.79596844e-02f, 3.82715277e-02f,
  4.89733368e-03f, -6.22115172e-02f, 6.55573830e-02f, 1.16797954e-01f, -1.52453214e-01f, -7.70873874e-02f, 9.12314579e-02f, 7.28510693e-03f, -5.61650656e-02f, -1.60124138e-01f,
  -2.06135586e-01f, 1.49095684e-01f, -1.13194719e-01f, -1.77890435e-02f, -3.61768231e-02f, -1.08879060e-01f, 1.79651808e-02f, -9.59517062e-02f, -1.64592043e-01f, -1.01990052e-01f,
  -1.52534261e-01f, 3.26082446e-02f, 8.78344774e-02f, -9.91389528e-02f, -6.39139935e-02f, -1.31515011e-01f, 3.95747982e-02f, 2.19803751e-02f, -7.51788495e-03f, -3.46415117e-02f,
  -7.72353411e-02f, -4.96681593e-02f, -9.48325451e-03f, -5.01383059e-02f, 7.33104348e-02f, 1.04402266e-01f, 2.58867387e-02f, 8.62015784e-02f, 1.13596343e-01f, 3.51620130e-02f,
  2.79162843e-02f, 1.50921091e-01f, 1.98838875e-01f, 5.85539900e-02f, 3.83406952e-02f, -4.25012968e-03f, -5.30857332e-02f, -2.79203104e-03f, 2.94669289e-02f, 4.25007753e-02f,
  -8.18865523e-02f, 1.06966183e-01f, 6.15637610e-03f, 2.70252936e-02f, -2.29356196e-02f, -1.03395149e-01f, 9.16547608e-03f, -6.15185611e-02f, 1.08650617e-01f, -9.86356512e-02f,
  -5.07278508e-03f, -6.54082969e-02f, 1.52898934e-02f, -5.95736988e-02f, -9.01995152e-02f, 4.29197252e-02f, -1.57356098e-01f, 3.62744294e-02f, 9.14858375e-03f, -5.58879785e-02f,
  -3.72314334e-01f, 3.13771009e-01f, 3.11163999e-02f, 1.10176019e-02f, 1.36070652e-02f, 5.58736771e-02f, 1.00673124e-01f, 2.26031849e-03f, -6.99933916e-02f, -7.86292031e-02f,
  -1.26264036e-01f, 1.09860353e-01f, -2.76854914e-02f, -1.04222232e-02f, -5.60638681e-02f, -9.76405069e-02f, -1.34651950e-02f, 8.35871398e-02f, -6.79304525e-02f, -2.27769893e-02f,
  5.95935900e-03f, -3.31836455e-02f, -2.54096985e-02f, 3.64695713e-02f, -3.97991352e-02f, 7.26922899e-02f, -6.94287717e-02f, -9.29362923e-02f, 2.69281808e-02f, 3.19430185e-03f,
  5.56578875e-01f, 1.87346227e-02f, 1.01020992e-01f, 3.76096666e-01f, -2.83131182e-01f, -8.01577747e-01f, -7.46016979e-01f, -3.36138725e-01f, 1.96992680e-01f, 1.86066836e-01f,
  -2.55176634e-01f, -2.80214071e-01f, 5.11990264e-02f, -1.18209615e-01f, -2.65746087e-01f, 4.45032194e-02f, 1.86626643e-01f, 3.81561480e-02f, -4.77114916e-01f, -6.12827837e-01f,
  -2.63793558e-01f, 1.53123587e-01f, 3.21463972e-01f, 6.66067898e-02f, 3.91661495e-01f, 3.78538796e-04f, 3.86499882e-01f, 1.63567260e-01f, 1.80676933e-02f, 4.70079571e-01f,
  2.19323099e-01f, 2.64111876e-01f, -4.44964349e-01f, 3.10472591e-04f, 3.80384140e-02f, 1.90700889e-01f, -2.79017001e-01f, 2.20595062e-01f, -1.31083235e-01f, 9.70191583e-02f,
  -1.22696579e-01f, 2.74826605e-02f, -1.79259121e-01f, -1.66388769e-02f, -1.89714190e-02f, -3.02409142e-01f, 2.83459455e-01f, -4.57531847e-02f, 8.86696503e-02f, -8.01202282e-02f,
  -3.33983630e-01f, -1.73640147e-01f, -1.67560264e-01f, -2.61741400e-01f, -4.32611592e-02f, -1.80611148e-01f, -2.14788273e-01f, -2.39523381e-01f, 4.81870212e-02f, 4.50662017e-01f,
  -1.24848681e-02f, -1.87818762e-02f, 7.44757056e-03f, 1.12781553e-02f, -5.21693416e-02f, -7.93546736e-02f, 2.62830183e-02f, -6.89298213e-02f, 2.89935563e-02f, 2.87372060e-02f,
  -3.27746272e-02f, 7.65738785e-02f, -3.89095284e-02f, 6.58594444e-02f, 2.76758932e-02f, 3.92995887e-02f, -1.66398257e-01f, -4.84228740e-03f, 6.95054531e-02f, 9.41751525e-02f,
  -1.09424710e-01f, -8.09508469e-03f, 1.35248154e-01f, -2.10699181e-05f, -3.70726697e-02f, 7.18552545e-02f, 4.03121822e-02f, -1.72843516e-01f, 8.68493095e-02f, -2.39125267e-03f,
  8.96203071e-02f, -4.28445011e-01f, 1.26803607e-01f, -7.03981444e-02f, -9.17323772e-03f, -5.59505150e-02f, 2.56519690e-02f, -1.31676942e-01f, 5.25801145e-02f, -7.62373358e-02f,
  -2.87654936e-01f, -6.66845292e-02f, 1.79249078e-01f, -1.86041459e-01f, -1.76031455e-01f, -4.77668643e-02f, 2.86247302e-02f, -2.05127880e-01f, -2.44637594e-01f, -7.35118538e-02f,
  5.64693063e-02f, -3.84848714e-01f, -1.42550811e-01f, -1.29641071e-02f, -5.82120754e-02f, -4.00182158e-01f, -2.25594655e-01f, -3.36135864e-01f, -3.04919660e-01f, 2.17351496e-01f,
  -6.80333316e-01f, -9.36077610e-02f, 3.13186705e-01f, -4.01804775e-01f, 1.91534996e-01f, 4.68674928e-01f, 5.09264469e-01f, 2.11286053e-01f, -9.68691930e-02f, -1.44887000e-01f,
  -2.13967100e-01f, -2.08140314e-01f, -3.49754781e-01f, -1.34888992e-01f, 2.00195741e-02f, 3.06451410e-01f, 1.82532668e-01f, 1.56362563e-01f, 1.51071295e-01f, 1.40341237e-01f,
  9.37138423e-02f, -4.53957729e-02f, -2.21975222e-01f, -2.25873843e-01f, -9.92955416e-02f, -1.76424339e-01f, -1.02478601e-01f, -8.54830891e-02f, 1.32663891e-01f, -1.91587023e-02f,
  3.89524817e-01f, -2.20034286e-01f, -1.52820814e-03f, -3.00033599e-01f, -1.28535882e-01f, -5.38666137e-02f, 2.76369993e-02f, -1.27736375e-01f, -5.80265634e-02f, -1.10171020e-01f,
  -1.94375232e-01f, -4.17227782e-02f, -2.60872431e-02f, 3.64645794e-02f, 7.09413737e-02f, -3.75391059e-02f, -1.48902342e-01f, -9.92664322e-02f, -2.43858155e-02f, -4.30777073e-02f,
  -9.41248238e-02f, -3.50588970e-02f, 1.18910134e-01f, 1.20793454e-01f, 4.86164093e-02f, 1.40185254e-02f, -7.06875697e-02f, -4.41137441e-02f, -1.33361546e-02f, -7.35153630e-02f,
  -4.39524278e-02f, -6.68770522e-02f, -5.95038757e-02f, 9.72108450e-04f, -1.19231157e-02f, 1.05048092e-02f, 1.18406095e-01f, 1.12890966e-01f, 1.32960364e-01f, 9.89713818e-02f,
  1.54433638e-01f, 1.70437217e-01f, 9.74569544e-02f, 2.16657668e-02f, -6.40970320e-02f, 2.84260362e-02f, 5.11349961e-02f, 3.57158855e-02f, -4.97032180e-02f, -6.28305450e-02f,
  7.94371441e-02f, 6.99891001e-02f, -4.75852713e-02f, 6.41278177e-02f, 1.02849014e-01f, 1.16812307e-02f, 3.80063914e-02f, -5.99872367e-03f, 5.83814345e-02f, -3.82256769e-02f,
  3.06714009e-02f, 8.28851387e-02f, 9.94861573e-02f, -4.96674068e-02f, -5.61334789e-02f, -2.94297729e-02f, -1.70436576e-02f, 9.17055237e-04f, -5.06865755e-02f, 6.77790418e-02f,
  -3.03264782e-02f, 3.85039560e-02f, 7.83327967e-02f, 1.39811963e-01f, 1.62132844e-01f, 4.91570681e-02f, -7.96256587e-02f, -2.31616385e-02f, -6.13653250e-02f, 9.62278917e-02f,
  -6.91643283e-02f, 2.20436156e-01f, 2.93373108e-01f, 1.17705867e-01f, 1.29535958e-01f, 1.52451009e-01f, 1.79884851e-01f, 2.26098284e-01f, 1.73299700e-01f, 2.65229642e-01f,
  4.41335648e-01f, 6.11883283e-01f, -7.62198269e-01f, 3.98065239e-01f, 3.92203242e-01f, -6.05243556e-02f, -2.66687870e-02f, -1.50603622e-01f, 2.89312135e-02f, 3.06754820e-02f,
  4.90837604e-01f, 8.22509825e-02f, -1.29354194e-01f, -2.94737339e-01f, -5.46739459e-01f, -4.62830395e-01f, -6.24699116e-01f, -7.20980346e-01f, -5.15478194e-01f, 3.48958611e-01f,
  6.47306979e-01f, 5.34081697e-01f, 1.48423702e-01f, -1.20427661e-01f, 2.74246424e-01f, -6.28716424e-02f, -2.02641100e-01f, 4.18812037e-01f, -8.51623155e-03f, -2.11165175e-01f,
  -3.40211660e-01f, 1.77388582e-02f, -2.64615476e-01f, 2.49479324e-01f, 8.87519941e-02f, -2.88011998e-01f, -1.04605712e-01f, -3.16111326e-01f, 5.66005856e-02f, -6.08092733e-02f,
  4.13884073e-01f, 1.25626892e-01f, 1.24835342e-01f, 3.18317972e-02f, 2.82027453e-01f, -7.99563155e-02f, -1.62050962e-01f, -5.21930456e-01f, -6.08202934e-01f, -6.91082478e-02f,
  2.99705267e-01f, 3.52068514e-01f, -1.60521403e-01f, -1.45351768e-01f, -4.54045892e-01f, -1.87997475e-01f, -2.20239535e-03f, -2.87369013e-01f, -6.00556910e-01f, -7.56903514e-02f,
  -1.04638990e-02f, 1.50153756e-01f, 1.69032946e-01f, 1.96480900e-01f, 1.49723262e-01f, -1.30350348e-02f, 5.00734430e-03f, -5.33040287e-03f, -1.86443962e-02f, 1.42449409e-01f,
  -6.93074316e-02f, -1.44566581e-01f, -4.84331176e-05f, -1.26966268e-01f, -2.40957085e-03f, -1.14856899e-01f, -7.30804726e-02f, -6.09439127e-02f, -3.37653048e-02f, -1.49454191e-01f,
  -2.30898466e-02f, -1.10436283e-01f, 2.02314649e-02f, -1.27227738e-01f, -5.07391542e-02f, -1.23826765e-01f, -5.47898225e-02f, -9.65621248e-02f, -7.85444975e-02f, 3.98851745e-02f,
  1.71673462e-01f, -9.24182683e-02f, -1.34565532e-01f, -5.95338047e-02f, 1.07582144e-01f, -3.26966192e-03f, 2.20705613e-01f, -1.04161546e-01f, 1.14079922e-01f, -2.84766350e-02f,
  1.04211167e-01f, -7.98115507e-02f, 2.41794974e-01f, -1.80197041e-03f, -2.21160445e-02f, -7.76747242e-02f, 2.15626463e-01f, 3.73957306e-02f, -6.66154176e-03f, 1.28098622e-01f,
  1.00577950e-01f, 6.82018399e-02f, -3.67961191e-02f, -1.33808032e-01f, 2.66120762e-01f, -2.88439039e-02f, -1.52835235e-01f, -1.29374534e-01f, -4.78177965e-01f, -7.69106448e-02f,
  -6.66596174e-01f, -3.69176209e-01f, -4.11299348e-01f, 3.70648772e-01f, 4.99449581e-01f, -2.20022395e-01f, -6.81646466e-01f, -1.30988151e-01f, 4.65005815e-01f, -3.07012379e-01f,
  3.02535705e-02f, 3.40360671e-01f, 9.94907245e-02f, -1.88762769e-02f, -5.58515549e-01f, -5.51916838e-01f, -1.37692437e-01f, -1.51176214e-01f, -7.23377317e-02f, 7.50825927e-02f,
  2.25765571e-01f, 1.68772787e-01f, -1.04169898e-01f, 1.56440467e-01f, 4.96896982e-01f, 2.74727702e-01f, 1.23998329e-01f, 2.05507115e-01f, -2.30420232e-01f, 1.38018623e-01f,
  -4.28974450e-01f, -1.69131175e-01f, -3.92348655e-02f, 2.91045398e-01f, 2.18346983e-01f, -2.80911505e-01f, -1.67433366e-01f, 7.06313327e-02f, -4.49707210e-02f, -2.62254626e-01f,
  1.25872850e-01f, -4.13324460e-02f, 2.62359589e-01f, 3.63648608e-02f, -2.70000044e-02f, -2.77820170e-01f, -4.76635732e-02f, -1.50955752e-01f, -3.33846092e-01f, -2.66998410e-01f,
  3.41798693e-01f, 1.64381012e-01f, -2.57205427e-01f, -1.31419018e-01f, -1.43666148e-01f, -2.81684771e-02f, -2.13996977e-01f, -2.39562280e-02f, -4.03701693e-01f, -3.33270639e-01f,
  1.32354721e-01f, 1.65879093e-02f, 1.24750352e-02f, -5.43737188e-02f, -9.79320239e-03f, 4.27984409e-02f, 1.25474170e-01f, -9.13340691e-03f, 2.02622898e-02f, -4.17417251e-02f,
  1.00597948e-01f, 3.66700776e-02f, 4.45708334e-02f, 5.63146509e-02f, 1.16933708e-03f, 7.57399648e-02f, 4.75232787e-02f, -9.84987989e-02f, -6.97738379e-02f, -5.96917085e-02f,
  -6.95036873e-02f, -5.62098399e-02f, 1.70818731e-01f, 1.72052532e-01f, -2.19329167e-02f, -1.13606408e-01f, -8.65901858e-02f, 1.66350510e-02f, -1.37913480e-01f, -1.70705900e-01f,
  -5.00348695e-02f, -2.71704316e-01f, -2.03606889e-01f, -3.92088760e-03f, 6.19220771e-02f, 1.81514993e-01f, -1.57909598e-02f, -3.80043052e-02f, 2.21764166e-02f, -4.43244465e-02f,
  -2.52001822e-01f, -1.26262769e-01f, -4.19736188e-03f, -8.89956299e-03f, -2.09523126e-01f, -8.41683447e-02f, -1.16749346e-01f, -4.77809161e-02f, -4.89585213e-02f, 1.76221684e-01f,
  -1.58059988e-02f, -2.67266184e-01f, -3.59459221e-01f, -3.16401482e-01f, 3.83083336e-02f, -1.78435653e-01f, -1.62619382e-01f, -1.15472905e-01f, -4.96750474e-01f, -6.07943237e-01f,
  -5.04656494e-01f, -3.22636515e-01f, -1.75617978e-01f, -5.21645904e-01f, -4.22087371e-01f, -3.97495627e-01f, -7.26289332e-01f, -3.68849128e-01f, -2.04542696e-01f, -5.82294106e-01f,
  -4.32753973e-02f, 3.54624748e-01f, 4.78399456e-01f, 1.13521814e-01f, -2.75141802e-02f, -4.46837872e-01f, -3.98257077e-01f, -1.30980108e-02f, -2.68329438e-02f, -4.61356014e-01f,
  -3.74835014e-01f, -2.64420927e-01f, -6.38351142e-02f, 1.16959736e-02f, -4.17895988e-02f, 2.09320381e-01f, 1.08039737e-01f, -1.46058232e-01f, -1.59732569e-02f, -9.56892297e-02f,
  1.18743457e-01f, -2.92840660e-01f, 1.16454236e-01f, 1.69773713e-01f, -1.27759976e-02f, -8.68498534e-02f, -4.57897559e-02f, 2.06572652e-01f, -6.40264675e-02f, -1.03626855e-01f,
  -9.77911651e-02f, 5.78544512e-02f, 6.93338439e-02f, -7.29333051e-03f, -3.12635154e-01f, -2.20276505e-01f, -1.03327319e-01f, 1.59613919e-02f, 8.04189965e-02f, -1.10542163e-01f,
  -1.95494965e-01f, -2.81439036e-01f, 7.85370395e-02f, 1.84160635e-01f, 1.67657603e-02f, 3.68440673e-02f, 1.99046239e-01f, -4.05725278e-02f, 1.84437528e-01f, 8.37104768e-02f,
  -9.89888087e-02f, 9.37011465e-02f, -1.66108340e-01f, -1.57755874e-02f, -4.37615439e-02f, 1.09105103e-01f, 8.13674107e-02f, -4.44682166e-02f, 1.61007062e-01f, 1.39616117e-01f,
  4.32175472e-02f, -2.69434005e-02f, 2.19481349e-01f, -6.39547408e-02f, 1.30374238e-01f, -3.14320251e-02f, -8.36931244e-02f, 7.41160288e-02f, 2.83148736e-02f, -9.96847674e-02f,
  -9.48835071e-03f, 5.98527351e-03f, 7.71035030e-02f, 8.52270275e-02f, -1.22514874e-01f, -1.02758035e-01f, -1.67914987e-01f, -4.50443737e-02f, -6.68132454e-02f, -2.19408199e-01f,
  4.55283225e-01f, 5.11420444e-02f, 3.66309620e-02f, 4.05438468e-02f, -1.01132333e-01f, 2.44833622e-02f, 7.31963664e-02f, 1.59280375e-02f, 9.23467577e-02f, -9.43775177e-02f,
  -1.08559944e-01f, -2.38852538e-02f, 2.35065907e-01f, 1.59851179e-01f, -7.91475251e-02f, -1.61140919e-01f, -2.69149750e-01f, 2.37781741e-02f, 4.27068546e-02f, -1.22988075e-01f,
  -1.35499731e-01f, -2.99184799e-01f, 2.92052869e-02f, 2.73975283e-01f, 8.12990498e-03f, -3.16659138e-02f, 2.72687167e-01f, 1.26238286e-01f, 3.39497030e-02f, 7.09848255e-02f,
  -5.01371682e-01f, 2.41018921e-01f, -2.56745934e-01f, 1.22016646e-01f, 2.52600461e-01f, 2.87795901e-01f, 3.17706555e-01f, 2.50111192e-01f, 8.04939196e-02f, 1.26223356e-01f,
  1.10632695e-01f, 1.66752636e-01f, 2.22941265e-01f, 1.16177589e-01f, 1.60498485e-01f, 2.08779097e-01f, 1.19611666e-01f, 5.87216876e-02f, 4.53814566e-02f, 1.49308622e-01f,
  2.87696689e-01f, 1.93060234e-01f, 4.60736863e-02f, 8.43675882e-02f, 1.72054023e-01f, 1.54066429e-01f, 2.39491493e-01f, 1.52467817e-01f, 2.19971418e-01f, -1.01756737e-01f,
  -2.30602920e-01f, -9.29454267e-02f, -4.45919074e-02f, -5.35794534e-02f, -2.45537423e-02f, -1.71704233e-01f, -8.65567029e-02f, -1.28868699e-01f, 2.92074028e-02f, -1.20241530e-02f,
  -1.86652448e-02f, -5.48137957e-03f, -1.29143717e-02f, -9.72822979e-02f, -3.98946740e-03f, -9.59410742e-02f, -9.49314237e-02f, -8.29122663e-02f, -3.25600691e-02f, -1.01179592e-01f,
  4.87611722e-03f, -6.60092086e-02f, 5.83373010e-02f, 1.02008842e-01f, 2.94337962e-02f, 5.00046611e-02f, -5.67050651e-02f, -4.28721048e-02f, -7.27733448e-02f, -1.97106183e-01f,
  -7.07344040e-02f, -9.74549800e-02f, -4.94299345e-02f, -1.22357614e-01f, -5.41341156e-02f, 3.24325971e-02f, -1.74653344e-02f, 1.74183771e-02f, 5.83207533e-02f, 1.76156815e-02f,
  -7.26092532e-02f, -1.37836128e-01f, -9.37821642e-02f, -5.21881431e-02f, 4.67427447e-02f, 2.30336469e-03f, -1.07169136e-01f, -7.05240443e-02f, 3.65279168e-02f, 5.16680107e-02f,
  5.74479625e-03f, -1.38524780e-02f, -1.43996701e-01f, -7.98296928e-02f, -3.75846736e-02f, -1.73387185e-01f, 1.06477123e-02f, 8.72983970e-03f, 7.12122917e-02f, 3.90353310e-03f,
  4.07755286e-01f, 2.64841855e-01f, -7.04796165e-02f, -1.02885179e-01f, -1.91671222e-01f, -2.24793747e-01f, -1.97821438e-01f, -6.86803386e-02f, -9.59360003e-02f, -6.67919442e-02f,
  -7.75735378e-02f, -1.35131717e-01f, 9.97229218e-02f, -5.17646689e-03f, -1.02153875e-01f, -1.03667386e-01f, -1.10798098e-01f, -3.64741571e-02f, 1.02221206e-01f, -8.40315372e-02f,
  4.63436777e-03f, -4.28443251e-04f, -1.55427381e-01f, -3.35519947e-02f, 1.88527685e-02f, 4.62188646e-02f, -6.48495778e-02f, -1.37898251e-01f, -7.18207657e-02f, -6.02354333e-02f,
  -2.37241089e-01f, -2.84718752e-01f, 2.79930025e-01f, -6.22886717e-01f, -1.91188648e-01f, 1.75189916e-02f, -6.60956681e-01f, -3.24089050e-01f, -2.28323951e-01f, -4.93840158e-01f,
  1.32571191e-01f, 2.10547596e-01f, 9.77304801e-02f, 1.59230575e-01f, -2.17486635e-01f, -5.21415591e-01f, -3.10988367e-01f, -3.58098485e-02f, 1.16266809e-01f, -1.53392330e-01f,
  -2.69922197e-01f, -3.38429213e-01f, -2.42593393e-01f, -3.16569060e-01f, -5.62096238e-01f, -1.14918590e-01f, -2.99979985e-01f, -3.60898048e-01f, 1.94039836e-03f, -3.59303594e-01f,
  -3.17015469e-01f, 1.18093565e-01f, 2.29104728e-01f, 2.53842324e-01f, -5.56839593e-02f, 1.58047289e-01f, 1.48855057e-02f, -8.25428292e-02f, 9.60852429e-02f, -7.31581450e-02f,
  2.88686752e-02f, 1.34175017e-01f, 1.98251735e-02f, -4.48130444e-02f, -3.49422157e-01f, 4.98392992e-02f, -6.45141006e-02f, 1.09594110e-02f, 9.59320441e-02f, 6.88678026e-02f,
  7.66620338e-02f, 1.34757712e-01f, 1.28744826e-01f, 2.49970220e-02f, -1.33612128e-02f, 3.04465204e-01f, -1.10117465e-01f, 9.12178680e-02f, 1.03020467e-01f, -5.76340914e-01f,
  -2.36995205e-01f, 9.57057402e-02f, -4.65473011e-02f, -5.50200082e-02f, -6.01952290e-03f, 1.27019482e-02f, -7.35758021e-02f, -1.94228575e-01f, 6.40267804e-02f, -1.54968634e-01f,
  -7.94666335e-02f, 2.10612435e-02f, 1.69096440e-02f, -1.08513750e-01f, 1.13802636e-02f, -4.07006480e-02f, -5.02218567e-02f, -1.81982592e-01f, -7.63630196e-02f, 1.20336071e-01f,
  1.82239220e-01f, 1.97351947e-02f, -7.57294893e-02f, -1.24076746e-01f, 1.67931795e-01f, -9.12429988e-02f, 4.68817316e-02f, 1.20255008e-01f, -1.91207558e-01f, 6.94301073e-03f,
  -4.35255319e-01f, 4.60653067e-01f, -4.14322376e-01f, 9.70420428e-03f, -1.43915698e-01f, 1.55126169e-01f, 3.72819342e-02f, 1.08520813e-01f, 8.10348317e-02f, -1.39920041e-01f,
  4.24133651e-02f, -1.26889735e-01f, -1.49479166e-01f, 1.06264323e-01f, -7.42206499e-02f, 3.49149667e-02f, -1.24102451e-01f, -1.40769064e-01f, 2.83197373e-01f, 1.38847306e-01f,
  8.64190683e-02f, -1.23584844e-01f, -1.82612360e-01f, -1.18916310e-01f, -1.51360139e-01f, 5.87903112e-02f, -1.89587012e-01f, -3.51795815e-02f, 2.72923969e-02f, -6.30173385e-01f,
  1.39750645e-01f, -1.21668778e-01f, 2.36925185e-01f, 2.26020247e-01f, -2.08797544e-01f, -2.32733235e-01f, -3.03423703e-01f, -1.59939751e-01f, -6.40535774e-03f, -1.53085724e-01f,
  -1.67476907e-01f, 1.53267562e-01f, 2.01571077e-01f, 3.64900291e-01f, 3.24689120e-01f, 1.05161905e-01f, 3.69929284e-01f, 4.88827288e-01f, 3.85142475e-01f, 7.14568272e-02f,
  2.33777434e-01f, 7.84142315e-02f, 2.58899093e-01f, 3.24724406e-01f, 3.60739499e-01f, 2.81881034e-01f, -7.75838969e-03f, 1.74918950e-01f, 1.44458935e-01f, 4.76448715e-01f,
  -1.05886338e-02f, -2.60643274e-01f, -1.27339847e-02f, 3.30500193e-02f, -3.40033174e-02f, 1.06107377e-01f, -2.81767361e-02f, 6.85923547e-03f, -5.24903908e-02f, 6.32797703e-02f,
  -6.23833202e-02f, -5.15419282e-02f, -5.39235212e-02f, 5.67838885e-02f, -4.91602495e-02f, -2.17600062e-01f, 1.44183993e-01f, 2.20197573e-01f, 2.04151750e-01f, 1.11578576e-01f,
  1.68693125e-01f, -1.03300370e-01f, -2.39574701e-01f, -1.78033337e-01f, -3.91615322e-03f, 2.55054802e-01f, -2.18092538e-02f, 9.07106996e-02f, -1.22031026e-01f, 1.01002805e-01f,
  5.27074523e-02f, 9.20439288e-02f, 3.18280570e-02f, 1.27635062e-01f, 6.73929453e-02f, -3.21744457e-02f, 1.58235386e-01f, 6.25855476e-03f, -1.23865940e-02f, 8.23422447e-02f,
  9.54864472e-02f, 3.24145425e-03f, 6.71711639e-02f, 4.76908572e-02f, 8.39650705e-02f, 1.09295271e-01f, 1.01672135e-01f, 1.57702610e-01f, 5.97409196e-02f, -6.76415414e-02f,
  -4.11558934e-02f, 1.01713642e-01f, -3.16549800e-02f, 9.59091261e-02f, 1.21340506e-01f, 1.63825303e-02f, 5.28830551e-02f, -1.42024726e-01f, -1.06816657e-01f, -1.53972417e-01f,
  -3.86608809e-01f, -2.98829585e-01f, 8.66545737e-02f, 9.50771347e-02f, -5.12350909e-02f, -2.70266443e-01f, -1.59778446e-02f, 6.45921156e-02f, -1.21486858e-02f, 1.19765941e-02f,
  -3.21555465e-01f, -5.34753725e-02f, -1.73996374e-01f, -1.39601324e-02f, -4.40014489e-02f, -1.90177783e-01f, -7.29837641e-02f, 9.56697837e-02f, -8.64488408e-02f, -3.47221419e-02f,
  -2.62710806e-02f, -2.97572851e-01f, -1.99124247e-01f, -2.08871841e-01f, -2.44484618e-01f, -1.61058739e-01f, -2.58905381e-01f, -2.62645662e-01f, -3.72471243e-01f, -3.24551910e-01f,
  -7.79569507e-01f, -5.66621006e-01f, 5.38856089e-01f, -6.65572584e-01f, -2.13985890e-01f, -7.11488947e-02f, -4.13687915e-01f, -3.12990457e-01f, -2.71656871e-01f, -3.76966715e-01f,
  -1.95043221e-01f, -2.74681062e-01f, 1.24794193e-01f, 1.24074228e-01f, 7.81495720e-02f, -1.76229656e-01f, 1.21104479e-01f, 4.40423578e-01f, 3.29713732e-01f, -3.09801787e-01f,
  -4.16030407e-01f, -3.10857296e-01f, 1.57001298e-02f, 9.14562494e-02f, -3.71214151e-01f, -1.79622155e-02f, 2.46113390e-01f, -1.07283488e-01f, 1.45046979e-01f, -2.53024220e-01f,
  1.67167515e-01f, -1.16494074e-01f, 2.14255109e-01f, 1.55581571e-02f, -9.77496356e-02f, -4.33490984e-02f, -3.91865335e-02f, 1.03252321e-01f, -2.01769829e-01f, 1.64583642e-02f,
  -2.48477384e-01f, -7.21557066e-02f, -2.06593528e-01f, -1.30383074e-01f, -2.42075354e-01f, -1.63269043e-01f, 1.61426753e-01f, 1.96101427e-01f, 5.16350642e-02f, 5.57472780e-02f,
  -4.81432736e-01f, -4.30582523e-01f, 1.19605906e-01f, 1.92292839e-01f, 5.58457486e-02f, 1.27412990e-01f, 2.00772882e-01f, 1.92090608e-02f, 4.59531873e-01f, -2.33286470e-01f,
  -1.89177185e-01f, 1.58888981e-01f, 7.30749592e-02f, 1.21386610e-02f, -1.45980224e-01f, 1.46541116e-03f, 4.02933434e-02f, -6.48437366e-02f, 7.08325475e-04f, -1.72347963e-01f,
  -6.76014498e-02f, 7.31915142e-03f, 6.48035556e-02f, -1.03099495e-01f, 3.38506773e-02f, -1.53951824e-01f, -1.95624027e-02f, 1.11306690e-01f, 1.82533786e-01f, -1.06973067e-01f,
  -3.05778664e-02f, -1.19366676e-01f, -5.35498885e-03f, 1.22324914e-01f, 1.38397455e-01f, 9.10761356e-02f, -1.43159717e-01f, 1.43411517e-01f, -3.01247612e-02f, 3.60679664e-02f,
  -1.18960910e-01f, 4.31593627e-01f, -3.70721579e-01f, 2.05594495e-01f, -2.06220932e-02f, 3.59651148e-01f, -7.47548342e-02f, 7.69544914e-02f, -1.27947591e-02f, -2.87414882e-02f,
  1.49509758e-01f, -1.93346366e-01f, -1.47126451e-01f, -4.57065105e-02f, -2.15157077e-01f, -1.93228409e-01f, -3.40244293e-01f, -2.64754206e-01f, -2.22930666e-02f, -2.14012891e-01f,
  -3.12685907e-01f, -3.03764045e-01f, -3.17163378e-01f, -2.24107578e-01f, -2.46521428e-01f, -1.51853576e-01f, 2.48557106e-01f, 6.19340278e-02f, 9.62994322e-02f, -3.18731636e-01f,
  3.98592383e-01f, 3.61371815e-01f, -1.92351580e-01f, -1.85684115e-02f, -1.67905539e-01f, 8.99550691e-02f, 2.64952064e-01f, 6.65157378e-01f, 2.85364598e-01f, -5.48372641e-02f,
  -2.93708239e-02f, -4.28827405e-01f, -2.53378510e-01f, -1.06585100e-01f, 1.09493062e-01f, -9.16338190e-02f, -2.64282405e-01f, -2.19030663e-01f, -6.54565394e-02f, -3.35911550e-02f,
  -2.89913684e-01f, 4.15133983e-02f, -1.36134187e-02f, 8.75716060e-02f, 1.70593411e-01f, -1.61293656e-01f, -3.05986702e-02f, -2.51185484e-02f, -8.09411146e-03f, -3.37094337e-01f,
  -1.21593311e-01f, 8.58832538e-01f, -3.03482980e-01f, -1.26568034e-01f, -1.56285852e-01f, -4.98200096e-02f, 1.30176231e-01f, 9.36514512e-02f, -9.20064077e-02f, 3.43137607e-02f,
  -1.29849717e-01f, 1.44362420e-01f, -6.22893758e-02f, -1.47823289e-01f, 9.93225574e-02f, 3.64409238e-02f, 1.14776343e-02f, 1.37112364e-01f, -1.68365106e-01f, 3.08306992e-01f,
  -4.61367428e-01f, -1.40688747e-01f, 2.77705342e-01f, 2.98567206e-01f, 4.06634420e-01f, -3.90617788e-01f, 2.73126960e-01f, 3.07022572e-01f, 2.92978019e-01f, 4.76453900e-02f,
  -5.51860519e-02f, 2.47274549e-03f, 1.16935320e-01f, 2.12902725e-01f, 5.08446656e-02f, -1.05426617e-01f, -5.84124587e-03f, -1.04260193e-02f, 9.48766768e-02f, 1.17958166e-01f,
  3.09949741e-03f, -3.06578516e-03f, 2.18264893e-01f, 5.08294366e-02f, -2.26939231e-01f, -1.58068910e-01f, -4.81030457e-02f, 3.08397375e-02f, -1.35808542e-01f, -3.11769117e-02f,
  -9.88293365e-02f, -1.24552578e-01f, -1.25204071e-01f, 1.11519713e-02f, 3.07844244e-02f, -1.64154954e-02f, -6.21609911e-02f, 6.18796907e-02f, 1.51297793e-01f, 5.07836714e-02f,
  -2.26681039e-01f, -1.31145820e-01f, -2.74063021e-01f, 7.62719661e-02f, 8.25398639e-02f, -4.49802987e-02f, -8.88847411e-02f, 2.80841347e-02f, 7.54416957e-02f, -1.86480284e-02f,
  2.31030896e-01f, -6.55788630e-02f, -3.45163904e-02f, -7.29890764e-02f, -1.66933745e-01f, -2.08466705e-02f, -1.58004150e-01f, -3.84656191e-01f, -1.10353492e-01f, 3.89718562e-02f,
  -3.07999581e-01f, -3.79659384e-01f, -3.26192915e-01f, -3.91004652e-01f, 7.13376701e-02f, -5.48992634e-01f, -3.08343500e-01f, -8.94026831e-02f, -3.72395456e-01f, -4.35152024e-01f,
  4.02638584e-01f, -4.75335605e-02f, -5.89241862e-01f, -7.65031278e-02f, -4.05110210e-01f, -2.21304610e-01f, -3.04482013e-01f, -1.30790723e-02f, 6.06109649e-02f, -2.26524934e-01f,
  -4.55826931e-02f, -5.32867201e-02f, -1.18717492e-01f, -1.17510408e-01f, -7.51946196e-02f, -4.66773003e-01f, -3.28687549e-01f, -3.58149350e-01f, -2.18279570e-01f, -2.39765450e-01f,
  -6.56214133e-02f, -7.36087039e-02f, 1.53331235e-01f, 5.66728078e-02f, -1.81991577e-01f, -1.94080919e-01f, -2.87481278e-01f, -2.42334932e-01f, -3.37984532e-01f, -3.68899703e-01f,
  -4.61476833e-01f, 8.83771479e-02f, 7.45825693e-02f, 2.51427799e-01f, -2.19312613e-03f, 1.03709199e-01f, -1.45939840e-02f, 1.16256773e-01f, 1.58413216e-01f, 3.22652049e-02f,
  8.64335522e-02f, 7.28589445e-02f, -4.24596295e-02f, -1.41495064e-01f, -8.53072181e-02f, 7.37175196e-02f, 3.01567346e-01f, 2.16513827e-01f, 9.36122313e-02f, 1.21997772e-02f,
  -2.06989124e-02f, -1.34374592e-02f, 2.12586254e-01f, 2.56424397e-01f, 1.39478207e-01f, 1.54249996e-01f, 8.21822584e-02f, 9.85820144e-02f, 1.86615363e-01f, 2.13314056e-01f,
  -5.96132036e-03f, 1.23343505e-01f, 6.65387437e-02f, 1.21333972e-01f, 7.89450407e-02f, 5.12131229e-02f, 2.54416931e-02f, 8.53055567e-02f, 1.15981668e-01f, 1.02712229e-01f,
  7.86289647e-02f, 2.62504499e-02f, -6.22820202e-03f, 4.71358858e-02f, -3.13040055e-02f, -2.19719429e-02f, -1.89491548e-02f, 1.16088251e-02f, 3.51447500e-02f, 1.03829112e-02f,
  1.28342599e-01f, 8.36513862e-02f, -5.04615530e-02f, -1.07037209e-01f, -1.02096021e-01f, 8.00138861e-02f, 3.53257172e-02f, -4.48559523e-02f, -8.18109214e-02f, 2.63655111e-02f,
  8.10277537e-02f, 1.63589984e-01f, -1.17375128e-01f, -3.93775925e-02f, -9.21236426e-02f, 2.68644951e-02f, 3.65237184e-02f, 4.11231704e-02f, -1.78174287e-01f, -1.10843562e-01f,
  -6.28725141e-02f, -4.32198234e-02f, -5.95103018e-02f, 5.25405519e-02f, -6.79858476e-02f, -8.01527351e-02f, 1.30730063e-01f, 7.57223517e-02f, 1.15391664e-01f, -5.22133559e-02f,
  2.35486269e-01f, 1.90035224e-01f, 1.94890171e-01f, 8.50405917e-02f, 1.10800415e-01f, -3.10002230e-02f, -9.02979523e-02f, 7.30063915e-02f, -2.59582698e-02f, 7.69391730e-02f,
  8.63954067e-01f, 2.27280423e-01f, 3.60978425e-01f, 1.89469084e-01f, 6.40085787e-02f, 2.94050723e-01f, 3.92068088e-01f, 1.83205634e-01f, 1.47613168e-01f, 6.04212731e-02f,
  -2.07150117e-01f, -2.03294799e-01f, -2.17188731e-01f, -1.72079861e-01f, -5.01164682e-02f, 4.16632853e-02f, 3.07637788e-02f, 2.25943223e-01f, 2.69114166e-01f, 1.91077217e-01f,
  -1.02082156e-01f, 1.11478604e-01f, 3.04533631e-01f, 1.30701095e-01f, -8.59338567e-02f, -1.49155200e-01f, 8.98446217e-02f, 5.98958358e-02f, -2.41194312e-02f, -2.08452880e-01f,
  -2.53661156e-01f, 3.66482556e-01f, -1.06805801e-01f, -2.14899361e-01f, -1.41758874e-01f, -1.55793568e-02f, -6.52078986e-02f, -3.40460613e-02f, -8.62874836e-02f, -3.07744090e-02f,
  -1.57928169e-02f, -1.57648697e-01f, -1.14412129e-01f, -1.04752831e-01f, 1.07251063e-01f, -4.61762622e-02f, -7.06764534e-02f, -9.68990568e-03f, -2.27156088e-01f, -2.10795924e-02f,
  -3.33726376e-01f, 1.92916370e-03f, 7.39065409e-02f, -5.27336029e-03f, -3.32741775e-02f, -8.61108899e-02f, 2.80293263e-02f, 5.96206374e-02f, 7.08703920e-02f, 9.18073207e-02f,
  -2.97855318e-01f, 7.01020136e-02f, -1.12694770e-01f, -4.57687117e-02f, -1.26832545e-01f, 3.51534002e-02f, -4.27921768e-03f, -7.67757669e-02f, 3.14621702e-02f, -1.12795621e-01f,
  -1.14731826e-01f, -1.98931247e-01f, -1.60809651e-01f, -1.21777155e-01f, -2.98229903e-01f, -2.92281099e-02f, -6.42206296e-02f, -2.68479213e-02f, -1.23545878e-01f, -2.17289268e-03f,
  -3.91596928e-02f, 1.04393242e-02f, 6.52649393e-03f, -1.89593107e-01f, -1.19626060e-01f, -1.32955700e-01f, -1.70513511e-01f, -1.11885436e-01f, 5.07736243e-02f, -7.26478081e-03f,
  -4.23128992e-01f, -1.17430560e-01f, -1.34758130e-01f, -1.07624464e-01f, 2.95642093e-02f, 7.44630322e-02f, -1.36672929e-01f, -1.87902972e-02f, -4.42544110e-02f, 3.56803685e-02f,
  7.11323246e-02f, 3.45772505e-02f, -1.50264189e-01f, -8.65346715e-02f, 2.03508064e-02f, 8.47073644e-02f, -1.41162455e-01f, -4.00787033e-02f, -8.35834742e-02f, -6.80369809e-02f,
  -1.43349186e-01f, 9.26208496e-02f, 9.18730646e-02f, 1.26992713e-03f, -5.41973934e-02f, -5.10298163e-02f, -7.16754571e-02f, 6.40038624e-02f, 1.32499456e-01f, 1.07784085e-02f,
  -2.59844691e-01f, -3.70503753e-01f, -1.58744887e-01f, 1.50050446e-01f, 6.73408657e-02f, -4.50472347e-02f, -2.14312732e-01f, -3.22294515e-03f, 2.28090599e-01f, -1.23414807e-02f,
  9.88933817e-02f, 2.44265303e-01f, 2.26017118e-01f, 2.64522344e-01f, 5.38652539e-02f, 6.97738677e-02f, 1.42666459e-01f, 1.22489356e-01f, 1.13201223e-01f, 7.35526681e-02f,
  3.05572320e-02f, -1.62936021e-02f, 4.73020785e-02f, 6.83764666e-02f, 1.34339973e-01f, 2.57830918e-01f, 1.10471383e-01f, -3.39532904e-02f, 2.35564410e-04f, 1.36244893e-01f,
  -1.00749120e-01f, 1.39346763e-01f, 3.07659447e-01f, 1.62770167e-01f, 2.54068524e-02f, 7.53551126e-02f, 1.37955189e-01f, 1.20081201e-01f, 4.84928414e-02f, 2.01847926e-01f,
  1.34390667e-01f, 6.52133599e-02f, -2.67434511e-02f, -3.41835581e-02f, -5.34065184e-04f, 1.21734299e-01f, 7.71356225e-02f, 1.05030373e-01f, 9.75761265e-02f, 4.79010977e-02f,
  2.37340294e-03f, -2.83755604e-02f, 1.22099496e-01f, 1.30581111e-01f, 2.11768821e-01f, 7.63008818e-02f, 1.06958812e-03f, 1.55410111e-01f, 9.77977216e-02f, -3.46591473e-02f,
  1.73492476e-01f, -4.67941202e-02f, 4.72811386e-02f, 1.52537733e-01f, 7.83474650e-03f, 2.62526982e-02f, -5.41919051e-03f, -1.42882690e-01f, 5.26069328e-02f, -3.34861502e-02f,
  3.47427540e-02f, 1.63900495e-01f, 2.36222129e-02f, 1.03819162e-01f, 1.07536033e-01f, -5.98641559e-02f, -7.28638917e-02f, 1.44076213e-01f, 6.66513965e-02f, 4.76366580e-02f,
  6.57820180e-02f, -5.80850169e-02f, 8.65253806e-02f, 9.23938304e-02f, 9.24562886e-02f, 1.05586044e-01f, 5.47531410e-04f, -3.21366042e-02f, -1.02092087e-01f, -1.39513016e-01f,
  1.52308434e-01f, 4.18578893e-01f, -1.97131085e-04f, 3.82153131e-02f, 1.65571738e-02f, 1.61778349e-02f, 1.21081937e-02f, 4.47251834e-02f, 8.87049139e-02f, 3.66960913e-02f,
  8.43893588e-02f, 3.56549770e-02f, 3.18527333e-02f, -1.33692278e-02f, -3.67052946e-03f, 1.26009822e-01f, 6.25235513e-02f, 3.68870944e-02f, 1.68045387e-01f, 1.45713408e-02f,
  2.85866437e-03f, -7.39703253e-02f, 1.21142389e-02f, 7.31894001e-02f, 4.93139438e-02f, 1.73277736e-01f, -9.38694030e-02f, -1.00766309e-01f, -4.99403402e-02f, 2.28876546e-02f,
  -7.53747076e-02f, -3.54105830e-02f, 1.53191820e-01f, 1.09739028e-01f, 3.88371199e-01f, 3.21235210e-01f, 2.92962730e-01f, 2.15353906e-01f, 1.27997771e-01f, 1.54020101e-01f,
  -1.32961169e-01f, -1.66673824e-01f, -1.75923347e-01f, -8.89885351e-02f, -2.29074880e-01f, -9.34678130e-03f, 1.53206810e-01f, -1.08351558e-02f, 1.03255380e-02f, 1.11842602e-01f,
  -5.65012824e-03f, 1.61992982e-01f, -1.33576272e-02f, -1.34983647e-03f, 3.22816446e-02f, -9.99124795e-02f, -4.81257960e-02f, 1.07439123e-01f, -1.17909230e-01f, -1.38578892e-01f,
  -3.58565867e-01f, -2.57283062e-01f, 5.45646884e-02f, -1.13481402e-01f, -1.06306501e-01f, -3.76030430e-02f, -1.06478065e-01f, 1.34941489e-01f, 1.01527005e-01f, 1.36361673e-01f,
  -3.92759964e-02f, -8.80969390e-02f, 2.54410654e-02f, 1.26040965e-01f, 2.37422317e-01f, 4.82795089e-02f, 7.00994506e-02f, 1.43936398e-02f, 1.97723955e-02f, 3.95715423e-02f,
  -8.04691389e-02f, 1.06807113e-01f, 2.24414602e-01f, 5.64291030e-02f, -6.52658269e-02f, -1.09015144e-02f, -5.84889352e-02f, -3.84536423e-02f, 5.26677296e-02f, -1.32722864e-02f,
  -4.15728912e-02f, 2.26185378e-03f, -1.50495470e-01f, -1.90956355e-03f, -9.13161878e-03f, 1.04718968e-01f, 8.63263234e-02f, 3.39292027e-02f, 2.68956553e-02f, 6.96853995e-02f,
  2.51036227e-01f, -6.11687303e-02f, 2.37801690e-02f, -3.49380076e-02f, -3.93657498e-02f, -4.02236320e-02f, -4.39309739e-02f, -1.50522366e-02f, -1.57384232e-01f, -5.03691137e-02f,
  7.56207993e-03f, 4.80996929e-02f, 3.01808920e-02f, 1.75350681e-02f, 7.17284158e-02f, 1.57350719e-01f, -9.31920111e-03f, -4.36208285e-02f, 9.94553268e-02f, 3.03513240e-02f,
  1.78243935e-01f, -4.84159738e-01f, -2.16138288e-01f, -1.61520898e-01f, 4.02373914e-03f, -7.74871781e-02f, -2.51557559e-01f, -1.41948611e-02f, 1.03789486e-01f, 1.14618644e-01f,
  -3.17638144e-02f, -6.14182353e-02f, -1.06017441e-01f, 4.98283617e-02f, 9.66044962e-02f, 1.24260657e-01f, -8.79457369e-02f, 1.33610725e-01f, -2.73522716e-02f, -3.69490646e-02f,
  1.46102637e-01f, 1.59290940e-01f, 1.65221870e-01f, 1.47701830e-01f, -1.05379567e-01f, -1.75674842e-03f, 1.60152271e-01f, 1.43379290e-02f, 5.02074957e-02f, 2.71316379e-01f,
  -1.17636472e-01f, 5.30614108e-02f, -3.93682212e-01f, -3.59409675e-02f, 2.24872291e-01f, -9.30163562e-02f, -1.87149718e-01f, -3.43650162e-01f, -2.08152175e-01f, -1.49401249e-02f,
  1.40812367e-01f, 2.37081066e-01f, 5.44403531e-02f, 3.98466699e-02f, -1.59903362e-01f, -3.88611369e-02f, 1.64224878e-01f, 6.42582700e-02f, 1.25347972e-01f, 2.27642477e-01f,
  3.41035873e-01f, 1.25802130e-01f, -1.13860697e-01f, -4.44835387e-02f, 2.86694467e-01f, 1.91533282e-01f, -2.42181972e-01f, 6.94859922e-02f, 3.00977498e-01f, 4.85558093e-01f,
  1.40134797e-01f, -2.75888532e-01f, -2.32688263e-01f, 1.98538184e-01f, 2.20435292e-01f, -1.77557126e-01f, -1.29065812e-01f, -2.70125121e-02f, -6.23336248e-02f, 3.67621258e-02f,
  1.84722170e-01f, -5.31917810e-02f, 7.88783878e-02f, 9.12796482e-02f, -9.22048986e-02f, -1.27381474e-01f, -1.92799762e-01f, -1.63993180e-01f, -2.76926696e-01f, -1.99713148e-02f,
  7.75104463e-01f, 4.70253587e-01f, -2.66399056e-01f, -2.98242092e-01f, -3.00592333e-01f, -4.11140099e-02f, -1.53201982e-01f, -1.19368002e-01f, -5.17580867e-01f, -7.16065764e-02f,
  -5.60110509e-02f, -1.64876431e-02f, -9.11670402e-02f, -1.40439212e-01f, 1.08666137e-01f, -5.30383252e-02f, 9.88778174e-02f, 1.80742919e-01f, -2.52317134e-02f, 3.81505899e-02f,
  -6.55639991e-02f, 1.51823116e-02f, -1.21596590e-01f, -4.73230928e-02f, -3.23220417e-02f, -5.02792932e-02f, 2.82434970e-01f, 5.37702329e-02f, -6.01676293e-02f, -1.68133512e-01f,
  -7.74223078e-03f, -1.25273457e-02f, -1.64443359e-01f, -2.24579200e-02f, -6.12040870e-02f, -2.27339730e-01f, -2.26110145e-02f, 1.20339833e-01f, -1.03833973e-01f, -3.80220264e-02f,
  -5.69577813e-01f, -5.30040383e-01f, 2.39846706e-02f, -1.10692233e-01f, 1.90473944e-02f, 5.63213117e-02f, 4.79541207e-03f, 7.48901963e-02f, -1.30460873e-01f, -1.02908708e-01f,
  -4.42024060e-02f, 3.26590240e-02f, -3.09068888e-01f, -2.30673701e-02f, -5.89846075e-02f, -1.74930811e-01f, -1.78791471e-02f, 5.53497039e-02f, -1.98644489e-01f, -1.97549835e-02f,
  -3.60361189e-02f, -1.38533249e-01f, -2.61672795e-01f, -2.31486514e-01f, -2.94405788e-01f, -2.35472232e-01f, -2.94083506e-01f, -3.06147784e-01f, -4.46391910e-01f, -4.48502153e-01f,
  4.63173121e-01f, -2.28687376e-01f, 3.25648725e-01f, 3.61250848e-01f, 2.80900389e-01f, 3.77747178e-01f, 3.55374217e-01f, 2.81128287e-01f, 2.20452964e-01f, 1.12218484e-01f,
  5.94169311e-02f, 8.99201259e-02f, 2.73641963e-02f, 1.21137872e-01f, 8.25069472e-02f, 1.15015037e-01f, 1.56389371e-01f, 7.39614815e-02f, 2.76849568e-01f, -1.66259967e-02f,
  1.37494700e-02f, 1.10731259e-01f, 5.79429343e-02f, 7.62915686e-02f, -1.62511338e-02f, -5.59906336e-03f, -4.99194209e-03f, 1.64414179e-02f, -5.79664297e-02f, -3.13277155e-01f,
  -9.97239724e-02f, 2.27048863e-02f, -1.30054366e-03f, -2.57216804e-02f, -1.25127718e-01f, -1.53268963e-01f, 5.08916639e-02f, -1.46690220e-01f, -1.06591076e-01f, -2.14177325e-01f,
  -2.54662521e-02f, 4.53115255e-02f, 1.03321031e-01f, 5.88221066e-02f, -3.43627855e-02f, 3.08205709e-02f, -5.21729402e-02f, 6.38036057e-02f, 7.57886097e-02f, -9.77912471e-02f,
  -4.13138941e-02f, 1.37473464e-01f, 2.94093397e-02f, 1.59232348e-01f, 3.93503010e-02f, 7.85941109e-02f, 5.13445996e-02f, -6.96151331e-02f, -8.36962089e-03f, -5.96137904e-02f,
  1.75835714e-01f, 1.07788846e-01f, 1.61448762e-01f, 4.28739600e-02f, 1.77224278e-01f, 1.39958724e-01f, 2.47120876e-02f, 9.05388370e-02f, 1.26811579e-01f, 1.97887644e-02f,
  -3.00994068e-02f, 1.76888824e-01f, 5.19604869e-02f, 5.54635040e-02f, 3.59101370e-02f, 3.65556292e-02f, -4.06655408e-02f, 5.58815673e-02f, 4.92400154e-02f, 1.44814476e-01f,
  1.74348697e-01f, 6.99102283e-02f, 3.95992920e-02f, 5.93900755e-02f, -6.79942444e-02f, 1.44342810e-01f, 1.38740996e-02f, -8.93551186e-02f, -5.80389351e-02f, -7.53492713e-02f,
  -1.51079753e-02f, 2.80342221e-01f, 3.23278946e-03f, 1.58540104e-02f, -7.85968900e-02f, -1.20592803e-01f, 1.32059202e-01f, -6.88505843e-02f, -1.88157350e-01f, -1.97092056e-01f,
  -1.46110198e-02f, -1.00468166e-01f, 4.83049564e-02f, -9.55252629e-03f, 6.20725825e-02f, 1.13868073e-01f, -1.22376978e-01f, -1.36340782e-02f, -6.32659048e-02f, -1.30461618e-01f,
  -3.46400626e-02f, 1.98416114e-01f, 1.61420539e-01f, 1.26866966e-01f, -6.26951233e-02f, 1.11264482e-01f, 8.34449288e-03f, 9.33175832e-02f, 1.03406131e-01f, 1.56910904e-02f,
  6.59592509e-01f, 1.40194461e-01f, 3.03487182e-02f, 2.31164947e-01f, 1.83302373e-01f, 1.75134733e-01f, 7.88934678e-02f, 3.67510132e-02f, -1.33358687e-01f, 1.96856558e-01f,
  2.24488452e-01f, 1.08845130e-01f, 3.21275517e-02f, -3.87739353e-02f, 1.32441372e-01f, -1.73902512e-01f, -4.93453406e-02f, 2.98681390e-02f, 6.67023007e-03f, 1.07638910e-01f,
  3.48258181e-03f, 1.94598868e-01f, 1.92232594e-01f, 1.30640253e-01f, 4.98409523e-03f, -1.01208100e-02f, 1.48240030e-01f, 2.01157093e-01f, 1.11051463e-01f, -3.81505527e-02f,
  4.74026352e-02f, 2.55800337e-01f, -1.77519932e-01f, 9.71935987e-02f, 2.41666913e-01f, 6.89567253e-02f, 1.20856918e-01f, -1.92805845e-02f, 1.66808646e-02f, -8.15898627e-02f,
  8.55504125e-02f, 1.21447779e-01f, 1.14517361e-01f, 4.97721694e-02f, 1.18398264e-01f, -6.01997152e-02f, 5.61542995e-03f, 4.32278998e-02f, -8.38903189e-02f, 3.78406756e-02f,
  -2.38397587e-02f, 1.69577658e-01f, 1.03355214e-01f, -4.29675058e-02f, 3.71807478e-02f, -5.16718328e-02f, -4.03591357e-02f, 9.14285406e-02f, 5.21070585e-02f, -1.76944938e-02f,
  2.31305972e-01f, 3.50140393e-01f, 2.98444182e-01f, 1.55813098e-01f, 1.73603863e-01f, 2.18714371e-01f, 8.94193873e-02f, 2.07056299e-01f, 1.42491251e-01f, 8.37463737e-02f,
  -2.19949079e-03f, 2.20724300e-01f, 2.49122560e-01f, 1.62376806e-01f, 1.90532774e-01f, 2.73144841e-01f, 1.29359797e-01f, 1.08555913e-01f, 2.01752335e-01f, 1.78581759e-01f,
  1.35873407e-01f, 6.40319511e-02f, 5.55295050e-02f, -6.20002709e-02f, 7.22535923e-02f, 2.18419805e-01f, 1.27420947e-01f, 2.58313805e-01f, 1.99686140e-01f, 2.55025506e-01f,
  -3.18852574e-01f, 4.05740321e-01f, -1.31698161e-01f, -6.79549947e-02f, 1.11233197e-01f, 1.69009159e-04f, 5.84836192e-02f, 8.71642958e-04f, 7.07385316e-03f, -2.04435289e-01f,
  -8.45869854e-02f, 3.10584679e-02f, 2.38500893e-01f, -4.47241880e-04f, -1.20930843e-01f, -1.00475952e-01f, 1.11230701e-01f, -7.93068632e-02f, -3.89213557e-03f, -1.97095647e-01f,
  -1.38173893e-01f, -4.02908586e-02f, -9.73666459e-02f, -2.29754776e-01f, -7.80098364e-02f, 1.24242958e-02f, -1.45446315e-01f, -9.85008851e-02f, -8.88698399e-02f, -1.21696867e-01f,
  7.99583554e-01f, 3.09031345e-02f, 1.95802137e-01f, 3.26126933e-01f, 1.26303464e-01f, -4.33069700e-03f, 3.90808433e-02f, 8.52680579e-02f, 8.85995850e-02f, 7.31061623e-02f,
  1.20868802e-01f, 1.46553367e-01f, 4.75124009e-02f, 1.36646256e-01f, 1.57288417e-01f, 3.91018838e-02f, -1.50936013e-02f, 3.13604355e-01f, 2.08401248e-01f, 1.06418021e-01f,
  1.60067499e-01f, 1.04719825e-01f, 1.90029636e-01f, 1.35814369e-01f, 8.29313919e-02f, 1.36774719e-01f, 7.87556991e-02f, 1.84824154e-01f, 1.74707294e-01f, 9.60623547e-02f,
  2.76699781e-01f, 2.48209357e-01f, -1.71719581e-01f, -3.92728746e-02f, -2.77820174e-02f, -5.48451431e-02f, -1.32276595e-03f, -1.15530953e-01f, -6.68143108e-02f, -2.62517016e-02f,
  -1.00349531e-01f, 1.00465128e-02f, -2.14887876e-02f, -1.34456251e-02f, -1.22434445e-01f, -3.84345353e-02f, -8.35352764e-02f, -1.62895489e-02f, -9.46370736e-02f, -2.22073328e-02f,
  -1.02299951e-01f, 4.59479401e-03f, -7.47636482e-02f, -1.54602826e-01f, 4.97783236e-02f, 5.26033826e-02f, 3.50097641e-02f, -2.64510307e-02f, -6.84019551e-02f, 1.53103732e-02f,
  -4.16782424e-02f, 9.56628397e-02f, 2.47876063e-01f, 1.76035285e-01f, 2.33588293e-01f, 6.34834468e-02f, -7.10543320e-02f, -7.39236623e-02f, 7.66342804e-02f, 2.94637438e-02f,
  9.73888527e-05f, 2.03393266e-01f, 2.40557678e-02f, -1.59048364e-02f, -2.98146475e-02f, -4.27607670e-02f, -1.97102115e-01f, -1.77723035e-01f, 7.45802140e-03f, -6.23581372e-02f,
  1.65475130e-01f, -4.14137542e-03f, -4.57738303e-02f, -6.81005279e-03f, -9.43383947e-02f, 8.36591050e-02f, 1.04200199e-01f, -4.93246429e-02f, 2.85802875e-02f, 3.71507294e-02f,
  -3.10431868e-01f, 8.59505162e-02f, 1.84670404e-01f, -1.13646410e-01f, -7.26903304e-02f, -2.54520066e-02f, 5.19661680e-02f, -4.28388640e-02f, -1.05603062e-01f, 4.44827341e-02f,
  6.49431795e-02f, 6.41722977e-02f, -6.50556684e-02f, -8.01081359e-02f, 1.68372225e-02f, -6.70298636e-02f, -6.90240413e-02f, -8.86261612e-02f, -1.47098765e-01f, -1.22045591e-01f,
  -2.16406241e-01f, -1.43204629e-01f, 1.15316417e-02f, -7.70891309e-02f, -7.56599158e-02f, 5.21644987e-02f, -6.07733242e-02f, -7.62815997e-02f, -7.88619965e-02f, -1.19924389e-01f,
  -4.35427666e-01f, -4.96282697e-01f, 2.04613283e-02f, -1.84764028e-01f, -7.71944225e-02f, -1.85810089e-01f, -6.80153787e-01f, -2.75145203e-01f, 9.37138796e-02f, -2.63641298e-01f,
  4.16995883e-02f, 4.17069972e-01f, 1.93753451e-01f, 5.76396100e-02f, -2.23402545e-01f, -4.97095466e-01f, -2.37967417e-01f, -5.06002344e-02f, 1.30723372e-01f, -1.06450334e-01f,
  -6.71199188e-02f, 8.55587199e-02f, 2.13856563e-01f, 1.44753531e-01f, -2.98223019e-01f, 5.67319505e-02f, 1.43948626e-02f, -5.29273525e-02f, -2.23133415e-01f, -3.48550737e-01f,
  -3.29511672e-01f, -4.88184333e-01f, 1.55735582e-01f, 1.04681857e-01f, -1.12854345e-02f, -1.39478341e-01f, -2.39450544e-01f, 2.03697607e-01f, 4.86595184e-02f, -1.06660128e-01f,
  1.64722428e-01f, -3.27454098e-02f, -1.24980085e-01f, 4.33581136e-02f, -7.09223980e-03f, -1.35841481e-02f, 3.58888596e-01f, 1.27592925e-02f, 9.47816223e-02f, 7.90852010e-02f,
  -1.13295563e-01f, 4.96086329e-02f, 2.23674206e-03f, 7.61718228e-02f, -4.93113548e-02f, 2.51242965e-01f, -2.48508668e-03f, -8.77538100e-02f, -2.07874551e-02f, -4.66938943e-01f,
  1.58710644e-01f, 1.83026828e-02f, 3.28103676e-02f, -3.14813270e-03f, 1.44997076e-03f, 7.92184696e-02f, -6.92871436e-02f, -6.22373149e-02f, -3.70778590e-02f, 1.00525983e-01f,
  1.39499903e-01f, 4.00860235e-02f, -9.77519620e-03f, -2.21696630e-01f, 3.77502963e-02f, 1.19880423e-01f, 5.70497997e-02f, -1.64212659e-02f, 1.15738712e-01f, 6.39401674e-02f,
  3.89065407e-02f, -6.52506128e-02f, 3.11915755e-01f, -6.59109578e-02f, -2.10644193e-02f, 4.06007022e-02f, 4.87049744e-02f, 1.85726732e-01f, 1.29032210e-01f, 1.65088281e-01f,
  -1.98918469e-02f, 2.13284746e-01f, -4.41712946e-01f, -3.53940912e-02f, -1.18723556e-01f, 3.09572279e-01f, 9.08124596e-02f, 1.07631385e-01f, -6.26913831e-02f, -1.20430224e-01f,
  -1.24681830e-01f, -3.88258062e-02f, -3.12967598e-02f, 5.07299304e-02f, -1.39732482e-02f, -5.80582069e-03f, 2.43924484e-02f, 1.60846915e-02f, 9.04122293e-02f, 1.86114401e-01f,
  -5.21918386e-02f, -9.00951996e-02f, -2.18666449e-01f, -1.45334437e-01f, -1.78237498e-01f, 6.56367615e-02f, -2.85098314e-01f, -2.82733083e-01f, -2.46275842e-01f, -6.96133196e-01f,
  3.25712800e-01f, 2.01141492e-01f, 2.74691761e-01f, 3.76846045e-01f, 3.46887171e-01f, 4.10536855e-01f, 5.54537117e-01f, 3.53124171e-01f, 2.22088307e-01f, 2.58847922e-01f,
  2.13610113e-01f, 2.02808037e-01f, 1.46733016e-01f, 6.70976937e-02f, 2.78940380e-01f, 2.30427489e-01f, 2.62156457e-01f, 1.29323348e-01f, 1.52976051e-01f, 2.63419300e-01f,
  1.38737395e-01f, 2.10676298e-01f, 1.40212879e-01f, 1.96868271e-01f, 3.73292081e-02f, 1.40340328e-02f, 1.56975880e-01f, 1.71486400e-02f, -9.01137106e-03f, -9.55146998e-02f,
  -3.33580643e-01f, 1.06688170e-02f, -1.56110629e-01f, -1.54254198e-01f, -2.00352043e-01f, -6.94641545e-02f, -2.15018727e-02f, 1.88427269e-02f, -4.68707085e-02f, -7.70947486e-02f,
  -1.82185441e-01f, -6.14570938e-02f, -6.64229691e-02f, 2.52265316e-02f, 5.38804121e-02f, 9.60138720e-03f, 1.10555971e-02f, 1.69276953e-01f, 9.00110602e-02f, -6.14834949e-02f,
  -1.16960704e-02f, -3.02766301e-02f, 2.90563926e-02f, -2.46355999e-02f, 5.32263704e-03f, -1.47306263e-01f, -5.20652831e-02f, -1.20682888e-01f, 7.87420794e-02f, 5.28134927e-02f,
  7.62523636e-02f, -3.14608812e-02f, 1.05563849e-02f, 1.38301805e-01f, -2.62893084e-02f, -6.46598116e-02f, -1.49947312e-02f, 2.20909230e-02f, 1.31301254e-01f, -2.20851339e-02f,
  6.78463979e-03f, 5.90280369e-02f, 1.31935418e-01f, 1.08591445e-01f, -2.79888473e-02f, -4.98296581e-02f, 2.76987776e-02f, 6.22611493e-02f, -7.79946521e-02f, -1.09695718e-01f,
  -6.95920438e-02f, 2.12463811e-02f, -1.81121472e-02f, 5.06928796e-03f, -6.06592558e-02f, 2.83887181e-02f, 3.99713032e-02f, 1.13948220e-02f, 1.33695742e-02f, -1.88567881e-02f,
  4.34744358e-03f, -3.12941298e-02f, -8.30568001e-02f, -2.78843865e-02f, -2.21418701e-02f, -2.08815157e-01f, -2.31081583e-02f, -7.66568258e-02f, -1.98708281e-01f, -6.25266731e-02f,
  -1.63805950e-02f, -2.11972464e-02f, -3.28572541e-02f, 2.65415236e-02f, -1.04983496e-02f, 3.35367694e-02f, 8.47262982e-03f, 1.21891841e-01f, -2.60704663e-02f, -1.13860264e-01f,
  1.24126207e-02f, 1.65333137e-01f, 1.48601621e-01f, 1.18031517e-01f, -7.57906586e-02f, 2.81896275e-02f, -9.46519300e-02f, -2.74507422e-02f, -6.14616387e-02f, 9.91799161e-02f,
  -2.12522373e-01f, -4.90762949e-01f, -3.85588169e-01f, -4.02542949e-01f, -4.18082625e-01f, -2.93851376e-01f, -4.72867966e-01f, -2.82300115e-01f, -2.22180158e-01f, -5.33018887e-01f,
  -2.05210924e-01f, 3.26339230e-02f, -2.20059082e-02f, -1.05688900e-01f, -2.48420224e-01f, -5.29438972e-01f, -3.98365736e-01f, -2.96134174e-01f, -1.53498575e-01f, -3.57947379e-01f,
  -4.52277511e-01f, -4.72328097e-01f, -3.27841759e-01f, -2.68295437e-01f, -2.22566754e-01f, -6.40804023e-02f, -3.12061578e-01f, -2.98959076e-01f, -2.15307400e-01f, -2.13980392e-01f,
  3.83979008e-02f, 9.53134671e-02f, 6.48115650e-02f, -4.02070023e-02f, -1.67405665e-01f, 8.47320110e-02f, -4.23473641e-02f, -8.64827912e-03f, 2.14793570e-02f, -6.92135841e-02f,
  -7.89056867e-02f, -6.22488186e-02f, 7.32427612e-02f, 5.50697334e-02f, -9.51587334e-02f, 2.05645226e-02f, -1.05309516e-01f, -1.35519192e-01f, -2.21965592e-02f, 1.57346297e-02f,
  -8.07722136e-02f, -8.88989121e-02f, 9.18864012e-02f, 3.08431685e-02f, -3.76758236e-03f, 1.51898980e-01f, 5.49060367e-02f, 1.71752498e-01f, 9.24098864e-02f, 2.65047420e-02f,
  -1.90529272e-01f, -9.50744748e-03f, 2.50626844e-03f, 5.72180701e-03f, 3.99106294e-02f, 1.83869917e-02f, 7.20247403e-02f, -5.80083765e-02f, -2.33572368e-02f, -3.31312716e-02f,
  -4.73847575e-02f, -3.00614126e-02f, -9.80658550e-03f, -1.73021033e-02f, 2.03493983e-02f, -1.07341204e-02f, -6.46106675e-02f, -5.89256547e-02f, 7.39027783e-02f, -2.00653356e-03f,
  -5.26681691e-02f, -8.26053729e-04f, -1.22475721e-01f, 2.38317437e-02f, 5.01944358e-03f, -8.92036259e-02f, 4.81537879e-02f, 1.01202272e-01f, -4.60799522e-04f, 9.72912014e-02f,
  1.09680854e-01f, -7.42939487e-02f, 2.73756892e-03f, 1.76841840e-01f, 1.08210079e-01f, -5.24881594e-02f, 1.20430239e-01f, -1.30812600e-02f, 8.70259330e-02f, 5.38066775e-02f,
  9.66351703e-02f, -2.43968479e-02f, -8.94275457e-02f, 1.22732753e-02f, -4.87112403e-02f, -9.36313272e-02f, -1.90802082e-01f, 7.95284752e-03f, 9.02413577e-02f, 4.26525995e-02f,
  -1.63440004e-01f, 1.63655300e-02f, 8.79661143e-02f, 2.43130047e-02f, 8.52802694e-02f, 1.40284523e-01f, 1.75784200e-01f, 8.33685882e-03f, 9.17575434e-02f, -4.36030179e-02f,
  -1.51593298e-01f, -1.67399824e-01f, -4.22829956e-01f, 1.32198676e-01f, 1.77180886e-01f, -3.03208036e-03f, -2.88688570e-01f, 5.24422377e-02f, 2.67865598e-01f, -1.02223396e-01f,
  2.12804265e-02f, -1.13560602e-01f, -4.21995312e-01f, -3.46568912e-01f, -7.07315743e-01f, -6.30021989e-01f, -4.31436568e-01f, -6.16221309e-01f, -4.40261245e-01f, 3.72269861e-02f,
  1.09710291e-01f, -1.34308532e-01f, -1.72278285e-01f, -1.55413628e-01f, 3.84463072e-01f, -5.52355796e-02f, -1.51365504e-01f, -8.65033418e-02f, -1.16440475e-01f, -7.30959252e-02f,
  -2.66344935e-01f, -2.19869930e-02f, -3.09460908e-02f, -1.05120830e-01f, 5.49087264e-02f, 1.02702327e-01f, 3.00807389e-03f, 3.00895181e-02f, 5.54728927e-03f, -6.50848961e-03f,
  7.31485114e-02f, 1.63170204e-01f, 8.57698545e-02f, 3.98023576e-02f, 3.02792396e-02f, -5.22873849e-02f, -9.96382758e-02f, -2.25497305e-01f, -1.58374563e-01f, 1.88601404e-01f,
  1.18743084e-01f, -1.50658891e-01f, -3.44193637e-01f, -7.60928914e-02f, 7.37498030e-02f, -1.36266187e-01f, 1.04640402e-01f, 1.96433082e-01f, -1.96942553e-01f, -7.73934200e-02f,
  1.25237972e-01f, -3.73455845e-02f, 4.29534577e-02f, 1.03886977e-01f, -8.41525048e-02f, 8.57671425e-02f, 9.56279598e-03f, -8.42454955e-02f, 1.25828192e-01f, -2.53656115e-02f,
  -2.10160222e-02f, -2.99236011e-02f, 6.43242747e-02f, -4.50970754e-02f, -1.20796554e-01f, -1.21518031e-01f, -1.22556239e-01f, -4.60979268e-02f, -1.83748409e-01f, -6.31665885e-02f,
  -6.10614307e-02f, -3.02141742e-03f, -2.23825928e-02f, 3.44101116e-02f, -1.98332127e-02f, 3.15630399e-02f, 3.43079008e-02f, -1.69366580e-02f, 4.04354930e-02f, -1.27107203e-02f,
  1.05602015e-02f, -2.29714364e-01f, -1.41663954e-01f, -1.19236328e-01f, 9.44425687e-02f, 1.34878606e-01f, 5.18995635e-02f, -3.21820527e-02f, -8.01074691e-03f, 6.19347505e-02f,
  -2.16806191e-03f, 8.44352990e-02f, -3.57067809e-02f, 5.31554744e-02f, -1.05988629e-01f, 1.10802129e-01f, -4.36027944e-02f, -1.00236058e-01f, -1.25612676e-01f, 2.51324654e-01f,
  -5.55883236e-02f, -3.57378304e-01f, -4.94131237e-01f, -8.43967199e-02f, 1.10278286e-01f, -3.33195299e-01f, -1.45592704e-01f, -7.82688856e-02f, -4.01910901e-01f, -2.15143502e-01f,
  -6.23045862e-01f, 6.89176500e-01f, 5.46159685e-01f, -7.75441349e-01f, -6.61013499e-02f, 3.82732928e-01f, 6.72061384e-01f, -5.82524128e-02f, -4.40454632e-01f, 2.82877207e-01f,
  4.74748105e-01f, -2.99124926e-01f, -1.83398761e-02f, -1.35480583e-01f, -3.75042632e-02f, 2.20384777e-01f, -2.04399034e-01f, -3.16431701e-01f, -4.83877152e-01f, -1.53516978e-01f,
  -1.96127862e-01f, -3.28858763e-01f, -3.43706161e-01f, -2.05810264e-01f, -1.11267924e-01f, -1.38928160e-01f, 2.50406146e-01f, -1.37595944e-02f, 2.23016039e-01f, -2.96683222e-01f,
  4.39998657e-01f, 3.39740753e-01f, -2.11050972e-01f, -3.28760773e-01f, 2.00614005e-01f, -3.22989315e-01f, -1.14396565e-01f, -1.59173459e-01f, -1.40034512e-01f, -3.91981192e-02f,
  -5.24870455e-02f, -4.67970669e-02f, -2.86133498e-01f, -1.12436555e-01f, -1.95706338e-01f, -1.08947463e-01f, -2.46606514e-01f, -8.95898193e-02f, -2.49526948e-02f, 4.12617147e-01f,
  1.37683645e-01f, 1.34289071e-01f, 2.44299069e-01f, 2.06009790e-01f, 2.16356650e-01f, -1.97179496e-01f, 4.67835546e-01f, -1.61168724e-02f, 2.18664303e-01f, -1.05498217e-01f,
  -1.09481193e-01f, 4.67542335e-02f, -8.35608840e-02f, -2.41081100e-02f, -1.18451916e-01f, 7.15670735e-02f, -8.58259797e-02f, -1.33982932e-04f, -9.75302756e-02f, 7.61147961e-02f,
  6.57703206e-02f, 1.89611882e-01f, 5.07716984e-02f, -3.65316160e-02f, -1.76693842e-01f, -8.86018798e-02f, -1.51471980e-02f, -2.43600868e-02f, -3.68130929e-03f, -3.57826538e-02f,
  -2.14110568e-01f, -9.76240076e-03f, 1.03457877e-02f, -9.70997568e-03f, 1.90461099e-01f, -1.75143052e-02f, -5.79506382e-02f, 7.01948032e-02f, 4.00257623e-03f, 1.66794658e-01f,
  -2.25276142e-01f, 2.01640531e-01f, -4.63579409e-02f, -1.57665268e-01f, -7.02533424e-02f, 1.52880877e-01f, -6.56356066e-02f, -3.20019573e-02f, 8.60826299e-02f, 1.15959823e-01f,
  2.40254313e-01f, -4.51647863e-02f, 2.91823000e-01f, -9.02821347e-02f, -1.03431344e-01f, -5.12173921e-02f, -2.47907609e-01f, -6.00080974e-02f, -6.49931952e-02f, 3.05126496e-02f,
  -1.63186833e-01f, -5.63902929e-02f, -2.32635811e-01f, -4.29437384e-02f, 1.02090621e-02f, -3.43061388e-01f, 1.09864593e-01f, -5.25904261e-02f, 6.88656494e-02f, -7.54162073e-02f,
  -5.75272977e-01f, -4.56557646e-02f, -1.06098875e-01f, 2.18803898e-01f, 2.10217327e-01f, 2.17626110e-01f, 6.52334169e-02f, 1.10002890e-01f, 2.28252038e-01f, 1.37898386e-01f,
  1.03344537e-01f, 2.38398269e-01f, 1.31915689e-01f, 2.33581737e-01f, 1.56611294e-01f, 1.77883893e-01f, 1.54819086e-01f, -6.39808178e-02f, 9.67111737e-02f, 9.20564905e-02f,
  2.47008651e-01f, 7.20337108e-02f, -1.08678654e-01f, 7.49557391e-02f, 1.17767774e-01f, 2.55816072e-01f, 8.26427564e-02f, 3.11198849e-02f, 5.24895824e-02f, 1.84573993e-01f,
  5.85776344e-02f, -3.41700166e-01f, 4.94804345e-02f, 1.16577838e-02f, -2.06646144e-01f, -5.15136011e-02f, -4.07039188e-02f, -5.16408831e-02f, -7.05536082e-02f, 4.52123070e-03f,
  -8.78178179e-02f, -1.27589956e-01f, -2.84901280e-02f, -5.42386062e-02f, -6.50576428e-02f, -1.73736170e-01f, -1.58210963e-01f, -1.25632761e-03f, -1.11016457e-03f, -9.30732861e-02f,
  6.51604980e-02f, -9.99745280e-02f, 3.68970484e-02f, 9.81149748e-02f, 2.15986222e-02f, -6.35576919e-02f, -1.35319695e-01f, -6.31045252e-02f, 8.11395526e-04f, 6.56839311e-02f,
  1.22499801e-01f, -8.47845674e-02f, -9.52550843e-02f, 3.71236764e-02f, -6.74251020e-02f, 1.19483016e-01f, 2.00988129e-02f, 7.93329328e-02f, 3.32411490e-02f, -2.59129200e-02f,
  1.71503335e-01f, 9.92637426e-02f, -7.04066711e-04f, 1.30232230e-01f, 4.54633236e-02f, -7.31772035e-02f, -9.33633521e-02f, -7.49102384e-02f, -2.22791031e-01f, -2.30833977e-01f,
  1.82508864e-02f, 9.93309659e-04f, -1.25670403e-01f, -5.08158393e-02f, -3.46470848e-02f, 1.00349009e-01f, 1.59081705e-02f, -2.91774198e-02f, -7.33154714e-02f, 4.64788266e-02f,
  4.45653886e-01f, -1.79448202e-01f, 1.45931169e-01f, -6.48399144e-02f, -1.90155044e-01f, -1.10435858e-01f, -7.19255209e-02f, -1.48250401e-01f, 1.49163976e-02f, 6.68327734e-02f,
  -5.86632751e-02f, -1.41496211e-01f, -7.04688206e-02f, -6.65169302e-03f, 4.61995192e-02f, -7.40522742e-02f, -2.59140898e-02f, 4.56740335e-02f, 2.33731177e-02f, -5.28011806e-02f,
  -5.49446903e-02f, 1.89455166e-01f, 2.02940524e-01f, 1.35624141e-01f, 1.91577584e-01f, 2.60744035e-01f, 5.71992025e-02f, 1.40051901e-01f, 1.03279710e-01f, 1.85019106e-01f,
  -3.76296341e-01f, 5.44924438e-01f, 3.00721467e-01f, -8.43159035e-02f, 2.91029930e-01f, 4.56302971e-01f, 6.14316344e-01f, 2.28000879e-01f, -1.75984725e-01f, 1.91521823e-01f,
  2.15952888e-01f, -1.91111490e-01f, -2.97574233e-02f, 2.18860433e-02f, 5.06892614e-02f, 2.64531940e-01f, 1.22649163e-01f, -1.94124728e-01f, -4.37067628e-01f, -1.84115142e-01f,
  -1.46278128e-01f, -2.49816358e-01f, -3.38596106e-01f, -2.80517578e-01f, -9.82110053e-02f, -1.04514472e-01f, 2.69439518e-01f, 2.10727543e-01f, 2.87010550e-01f, -2.09854543e-01f,
  -1.44750923e-01f, 3.30593735e-01f, -4.15701419e-01f, -4.19331938e-02f, 9.56481546e-02f, -2.34325558e-01f, -1.24222822e-01f, -5.34218848e-02f, 2.19091754e-02f, -1.75304040e-01f,
  4.22546268e-02f, -6.02785796e-02f, 1.56712204e-01f, 1.55466571e-01f, 1.01714842e-01f, -6.91277813e-03f, -5.73374145e-03f, -1.68362603e-01f, -2.02320442e-01f, -1.76375613e-01f,
  -1.78403184e-02f, 1.45906685e-02f, 2.35236555e-01f, 2.08946586e-01f, 9.01125148e-02f, -2.08026648e-01f, 2.11013943e-01f, -2.61510283e-01f, -1.41678423e-01f, -3.67402375e-01f,
  -2.42387310e-01f, 5.35051748e-02f, 5.31145930e-02f, -9.35096294e-02f, 7.41683692e-02f, -4.27447408e-02f, 6.60209134e-02f, 1.27690658e-01f, 3.89952064e-02f, -1.25475582e-02f,
  -2.95440499e-02f, -2.16001138e-01f, -8.50489959e-02f, 2.06598714e-02f, -2.66965151e-01f, 1.42596196e-02f, 6.33347919e-03f, 5.74144721e-02f, 1.37291729e-01f, -7.88417831e-02f,
  -2.88761668e-02f, -5.59845939e-02f, -1.30285680e-01f, -5.09194732e-02f, -9.63720456e-02f, -4.11929004e-02f, -2.16323823e-01f, -3.47457975e-01f, -1.69604734e-01f, -1.75685827e-02f,
  -2.61357784e-01f, 1.96120128e-01f, -4.94794965e-01f, 3.45397592e-02f, 3.15898478e-01f, 7.36510679e-02f, 1.10492907e-01f, 1.07634798e-01f, 2.39196181e-01f, -1.02992661e-01f,
  1.42741883e-02f, 1.08341873e-02f, 2.12008446e-01f, -2.13095415e-02f, -2.40877897e-01f, -5.42875752e-02f, 1.39257371e-01f, -3.73743312e-03f, -3.83112878e-02f, -8.12660754e-02f,
  -1.82504579e-02f, -3.77859980e-01f, -3.38777214e-01f, -8.00376851e-03f, -3.22744101e-01f, -5.61619878e-01f, -3.33598673e-01f, -3.89337480e-01f, -9.40532014e-02f, -3.30637157e-01f,
  -1.99152887e-01f, -4.45015103e-01f, -4.90254730e-01f, -9.81724262e-02f, 9.53335240e-02f, -3.56882036e-01f, -7.66966999e-01f, -5.20917237e-01f, -7.49583915e-02f, -1.92833498e-01f,
  2.02944353e-01f, 3.55321497e-01f, -1.95559770e-01f, -8.57242495e-02f, -2.43508279e-01f, -3.78085673e-01f, -3.59082729e-01f, -1.16314180e-01f, 1.47567719e-01f, 5.89769781e-01f,
  4.15190995e-01f, 4.41842586e-01f, 3.60981524e-01f, 1.09157294e-01f, 2.74573147e-01f, 2.74973273e-01f, -7.25869611e-02f, 1.70525908e-01f, 1.71378240e-01f, -7.48324692e-02f,
  1.68602318e-02f, -1.38521329e-01f, 1.20419547e-01f, 4.06181216e-01f, 2.50973642e-01f, -2.23630339e-01f, -6.93710670e-02f, -1.33639514e-01f, -2.08303288e-01f, -1.46817341e-01f,
  3.81043166e-01f, 2.35165402e-01f, 4.26677801e-02f, 6.17677160e-02f, 2.17566714e-01f, -9.00833681e-02f, 1.29493307e-02f, -4.03079063e-01f, -4.42649484e-01f, 1.38148628e-02f,
  6.71590716e-02f, 2.23255917e-01f, -3.38816464e-01f, -4.20324504e-01f, -2.99157619e-01f, 5.05807437e-02f, -8.58005062e-02f, 1.36739612e-01f, -1.51516452e-01f, -2.56150842e-01f,
  -1.05702363e-01f, 6.36522546e-02f, 5.25738746e-02f, -1.33483425e-01f, -1.03519857e-01f, -1.25743851e-01f, -1.04180627e-01f, 2.91237533e-02f, 8.08560923e-02f, -1.29222080e-01f,
  -2.03929231e-01f, 1.37882624e-02f, -1.32401079e-01f, -9.79460850e-02f, 1.30844995e-01f, -1.77661125e-02f, -2.91043893e-02f, 4.32068435e-03f, 1.00254215e-01f, 3.19594555e-02f,
  -1.39762796e-02f, 3.23341414e-02f, 1.64003819e-01f, -2.01197371e-01f, 1.55964000e-02f, 9.39505454e-03f, 6.68115020e-02f, 1.25322968e-01f, 8.47999677e-02f, 5.85128553e-02f,
  1.54232040e-01f, 8.30380619e-02f, -1.30626783e-01f, 2.97145732e-02f, 2.50539966e-02f, 7.75869414e-02f, 8.26308429e-02f, 6.28957450e-02f, -1.04647219e-01f, -8.55226219e-02f,
  5.92603385e-02f, -3.00239678e-02f, 2.21802574e-02f, -2.24412326e-02f, 2.37875268e-01f, 8.91614929e-02f, 1.04283884e-01f, -1.96695998e-01f, -1.57053530e-01f, 1.09965287e-01f,
  -3.59035373e-01f, -3.03420991e-01f, -3.28026682e-01f, -4.70203429e-01f, -1.07143588e-01f, -9.67540592e-02f, -2.31354371e-01f, -1.00163452e-01f, -3.75353307e-01f, -5.04357219e-01f,
  7.81967700e-01f, 5.94173610e-01f, 3.81748676e-01f, 1.28267854e-01f, -2.71165848e-01f, -6.23154379e-02f, 5.35781533e-02f, 1.40324473e-01f, 3.27498168e-02f, 1.31049886e-01f,
  1.60309777e-01f, -1.13756977e-01f, 7.18332008e-02f, 3.95933306e-03f, 1.64728180e-01f, 9.48697776e-02f, -4.17724587e-02f, 2.01166943e-01f, 7.41382539e-02f, -1.25467733e-01f,
  -1.43910810e-01f, 8.82224366e-02f, 3.69453937e-01f, 2.62914121e-01f, 4.09512073e-02f, -1.26637012e-01f, 2.38405298e-02f, 6.79886714e-02f, 1.11699209e-01f, 1.48447156e-01f,
  -8.26659426e-02f, 2.33862981e-01f, -1.10201091e-01f, 7.18823597e-02f, 2.69337222e-02f, 2.27139100e-01f, 8.58837515e-02f, 9.71394628e-02f, 5.71516454e-02f, 1.70362759e-02f,
  -7.49722943e-02f, 1.15611561e-01f, 1.16519695e-02f, -9.21951905e-02f, 7.31982067e-02f, 7.09981769e-02f, 1.23742335e-01f, 8.73647183e-02f, -1.07697463e-02f, -5.81081845e-02f,
  2.28937902e-02f, -1.17682982e-02f, -6.88209087e-02f, -9.65070575e-02f, 2.27527153e-02f, -1.18599430e-01f, 1.76753271e-02f, 4.89690937e-02f, -6.34301826e-03f, 8.33132118e-02f,
  6.27957806e-02f, 1.45061612e-01f, -4.28165793e-02f, -1.54885694e-01f, -1.98587984e-01f, -4.77335490e-02f, -1.59798965e-01f, -1.52737051e-01f, 2.19985005e-02f, 6.34048581e-02f,
  -1.88507050e-01f, -1.34466723e-01f, -9.61797163e-02f, -1.29914761e-01f, -9.73264202e-02f, 6.20556436e-02f, 1.07234567e-02f, 1.07686920e-02f, -4.88857552e-02f, -4.33245264e-02f,
  -1.83838397e-01f, -2.32147705e-02f, -4.27299663e-02f, -8.05397928e-02f, -2.19652453e-03f, -1.09848961e-01f, -5.90153150e-02f, -1.11755677e-01f, -1.57727823e-02f, -1.61504112e-02f,
  -3.20917547e-01f, -2.84249067e-01f, -4.04853448e-02f, 1.98052242e-01f, 5.17888442e-02f, 2.53611237e-01f, 3.05019766e-02f, -1.20021887e-02f, -1.81418043e-02f, -1.08367682e-01f,
  -2.56549940e-02f, 1.79580241e-01f, 8.39634910e-02f, 4.22574915e-02f, -1.78449705e-01f, -7.82405287e-02f, 3.48214842e-02f, 5.11651300e-02f, -9.74038523e-03f, 4.91811382e-03f,
  1.50273398e-01f, -6.43283203e-02f, -1.92357346e-01f, -1.07055321e-01f, -1.59667492e-01f, -1.37246728e-01f, -3.33574936e-02f, -8.17344636e-02f, -7.41883740e-02f, -6.25336021e-02f,
  5.80473840e-01f, 1.88058615e-01f, 1.79961488e-01f, 2.76991159e-01f, -1.26439884e-01f, -3.95914257e-01f, -8.02657247e-01f, -2.23097041e-01f, 3.34601134e-01f, 1.20035730e-01f,
  -3.42966616e-02f, 1.00033917e-01f, 6.13731481e-02f, -2.54770756e-01f, -5.06007969e-01f, -2.02141926e-01f, -1.38021186e-01f, -1.58492699e-01f, -4.26278949e-01f, -4.00425315e-01f,
  -2.70560026e-01f, -1.30417012e-02f, -6.26437292e-02f, 3.73130888e-02f, 5.92211843e-01f, 9.12892222e-02f, 3.45225513e-01f, 2.43711069e-01f, 6.04603216e-02f, 5.88141203e-01f,
  3.96082282e-01f, 4.42066789e-01f, -4.00473922e-01f, 7.99544305e-02f, 8.20433125e-02f, 3.51855531e-02f, -7.15984181e-02f, 2.53431648e-01f, 4.04985473e-02f, 9.85052437e-02f,
  1.93972781e-01f, 1.82932779e-01f, 1.37718335e-01f, 9.80312843e-03f, 5.01645319e-02f, -1.34075880e-01f, 5.59500083e-02f, -1.11371711e-01f, -1.89918932e-02f, 6.73897117e-02f,
  -1.81024581e-01f, -5.46995103e-02f, 3.08832694e-02f, -1.02704324e-01f, -1.17215933e-02f, 9.22741834e-03f, -6.90337718e-02f, 1.72094762e-01f, -1.53271733e-02f, 3.83387595e-01f,
  -3.04339948e-04f, 9.27292258e-02f, -3.83468121e-02f, 1.97226219e-02f, -5.80531880e-02f, 1.69739917e-01f, 1.25461251e-01f, -7.12781996e-02f, -5.99768646e-02f, 4.73514944e-02f,
  -1.82871986e-02f, 2.91811675e-02f, -3.42047401e-02f, 2.17634458e-02f, 1.04361296e-01f, 9.99578163e-02f, -4.33852263e-02f, -3.25678624e-02f, -4.00900505e-02f, 1.54818580e-01f,
  1.95977092e-02f, 5.88549115e-02f, 1.27207130e-01f, -6.26012608e-02f, 1.05805598e-01f, 5.98537918e-05f, 1.65253252e-01f, 7.76845170e-03f, 8.13085884e-02f, 1.61786407e-01f,
  -1.89832151e-01f, -4.52872068e-01f, 1.24159500e-01f, -5.80804348e-02f, 1.04804136e-01f, 3.67879309e-02f, 1.29690617e-01f, -1.88386694e-01f, 8.74265954e-02f, -7.40516037e-02f,
  5.14565222e-03f, 1.24005945e-02f, 1.54202253e-01f, -6.39961362e-02f, -1.73533708e-01f, -9.28477645e-02f, -9.26807746e-02f, -1.93302408e-01f, -1.32981732e-01f, 7.99664389e-03f,
  -1.44727424e-01f, -5.10953426e-01f, -4.86463934e-01f, -4.05933976e-01f, -1.41529977e-01f, -4.54969794e-01f, -1.42051265e-01f, -2.68247932e-01f, -4.25697148e-01f, -4.73223954e-01f,
  -4.78778750e-01f, -1.09220430e-01f, -7.40289390e-02f, 4.39928889e-01f, 4.90180403e-01f, -3.22932273e-01f, -5.57436883e-01f, -4.88850832e-01f, 2.11771801e-01f, 1.52526632e-01f,
  2.32088268e-01f, 4.51652884e-01f, 4.32311654e-01f, 1.55382439e-01f, -4.20819134e-01f, -8.28996971e-02f, 4.04908583e-02f, -2.10092053e-01f, -4.36857373e-01f, -1.57879949e-01f,
  2.41546318e-01f, -3.69829610e-02f, -3.16576153e-01f, -2.00761765e-01f, 2.94217974e-01f, 3.02080035e-01f, 1.30331069e-01f, 9.99360904e-02f, 6.16930202e-02f, 4.67043668e-01f,
  1.60485044e-01f, -3.92485738e-01f, -6.42499253e-02f, 1.97697207e-01f, 1.44039601e-01f, -2.16673836e-01f, -3.01862419e-01f, -6.60960600e-02f, -7.13143647e-02f, -2.29236186e-01f,
  2.60952145e-01f, -1.66833028e-02f, 1.50166512e-01f, 1.89792458e-02f, -9.46321115e-02f, -4.09761697e-01f, -2.14115590e-01f, -4.47486997e-01f, -3.85396332e-01f, -3.17198515e-01f,
  4.29365128e-01f, -1.23685105e-02f, -2.34372586e-01f, -1.74141094e-01f, -3.20962846e-01f, 1.68397650e-01f, -4.04087782e-01f, -2.35542655e-01f, -5.14307678e-01f, -4.34875846e-01f,
  8.32796935e-03f, 1.02108739e-01f, -2.29889899e-02f, -1.52614629e-02f, -3.52627896e-02f, 1.46319807e-01f, 1.57399356e-01f, -1.48964161e-03f, 5.19355088e-02f, -5.52254636e-03f,
  3.43719125e-02f, -1.07433684e-01f, -1.01688191e-01f, -1.52550220e-01f, -1.49739515e-02f, -1.19223744e-01f, 6.08590059e-02f, -1.20910384e-01f, -2.65540451e-01f, -1.35617211e-01f,
  -3.96639518e-02f, -5.33519685e-02f, 1.16432026e-01f, -2.15359688e-01f, -9.02285427e-02f, -9.65373218e-02f, 2.58064922e-02f, 4.52857316e-02f, 8.74496773e-02f, -5.61299035e-03f,
  2.49941573e-01f, -2.86644965e-01f, 2.02719122e-01f, -1.48679093e-01f, 1.19968532e-02f, 3.78967188e-02f, 1.75939083e-01f, 2.16942150e-02f, 1.51609927e-01f, -2.44540870e-02f,
  -3.11123073e-01f, -1.77220330e-01f, 1.83585584e-01f, -4.29744087e-02f, -9.01509449e-02f, 8.84941295e-02f, 1.04935192e-01f, 1.49646237e-01f, -1.14230819e-01f, -1.31670618e-02f,
  1.59171999e-01f, -3.94048899e-01f, -1.46079123e-01f, -9.74714234e-02f, 4.07172227e-03f, 6.89927563e-02f, -1.89445205e-02f, -8.48604962e-02f, -2.96073765e-01f, -3.34432662e-01f,
  5.03889799e-01f, -2.63593435e-01f, 2.63527721e-01f, 8.40395838e-02f, -2.11456016e-01f, -1.75351709e-01f, -2.18059942e-01f, 1.73446257e-02f, 8.74218494e-02f, -1.81433018e-02f,
  -1.79829448e-01f, -6.31275848e-02f, 4.85302806e-02f, 2.47622989e-02f, 2.38254115e-01f, 2.22135782e-01f, 1.92177281e-01f, 3.33670557e-01f, 2.96494097e-01f, 1.96805626e-01f,
  7.74180964e-02f, 6.59882873e-02f, 2.73172855e-01f, 2.71169960e-01f, 1.46074906e-01f, 4.15067635e-02f, 1.18116051e-01f, -7.15266764e-02f, 4.15227786e-02f, 2.64476746e-01f,
  1.75373163e-03f, 5.52592203e-02f, -3.64925861e-02f, -5.14090620e-02f, -1.84339821e-01f, 1.15386099e-01f, 2.97384672e-02f, 2.72261985e-02f, -6.59051239e-02f, 1.00184917e-01f,
  -5.52306585e-02f, 1.12352548e-02f, -6.69816658e-02f, -7.62985274e-02f, -5.52422851e-02f, -7.60732889e-02f, 1.14468247e-01f, 1.48593500e-01f, 1.26735598e-01f, 2.45421045e-02f,
  -1.54045731e-01f, -1.89916953e-01f, -1.47635549e-01f, -1.17604740e-01f, 6.38774335e-02f, -1.33582890e-01f, -3.67007665e-02f, 4.13680375e-02f, -1.01256303e-01f, 1.13992646e-01f,
  -7.03917220e-02f, -1.19937129e-01f, 7.15360194e-02f, 1.51128560e-01f, 5.51373176e-02f, 7.54207745e-02f, 8.18593428e-02f, 7.40096122e-02f, 5.55424690e-02f, 5.95590100e-02f,
  1.15055591e-01f, 3.85422260e-02f, 1.36670902e-01f, 1.27541959e-01f, 8.16245656e-03f, -1.87190138e-02f, -1.32804155e-01f, -1.22841962e-01f, -8.78537893e-02f, -6.14957921e-02f,
  9.64045674e-02f, 1.34392604e-01f, 6.91435412e-02f, 4.17507365e-02f, 3.21491808e-02f, -8.27508047e-02f, 4.65618521e-02f, -1.14975974e-01f, -9.71016735e-02f, 3.54423709e-02f,
  -3.58234286e-01f, -1.79050922e-01f, 2.52511233e-01f, 8.58193785e-02f, -1.08313568e-01f, -1.64153218e-01f, 5.66795953e-02f, -2.73785740e-02f, -1.01603538e-01f, 2.61465404e-02f,
  -9.24034566e-02f, 4.83673960e-02f, -1.44959942e-01f, 1.05663538e-01f, 2.28845384e-02f, -2.88543701e-02f, -3.90379056e-02f, 6.52871728e-02f, 1.01405047e-02f, -5.24754683e-03f,
  -1.02814145e-01f, -1.48515642e-01f, -1.93506971e-01f, -2.56314706e-02f, -7.75875151e-02f, 1.56660692e-03f, -1.23768650e-01f, -3.43737775e-04f, -1.45115405e-01f, 5.09804487e-02f,
  3.26859981e-01f, -5.21680951e-01f, -3.34845245e-01f, -1.55967046e-02f, -3.35299641e-01f, -4.04370755e-01f, -4.81009454e-01f, -1.12400055e-01f, -1.97556153e-01f, -4.26039964e-01f,
  -1.61852986e-01f, 5.17679513e-01f, 3.11751425e-01f, 3.70032281e-01f, 3.40435684e-01f, -5.40254831e-01f, -5.16163230e-01f, 1.56899974e-01f, 5.39899111e-01f, 1.39008686e-01f,
  2.40077954e-02f, 9.62857008e-02f, 3.84336799e-01f, 1.47298723e-01f, -3.95657659e-01f, 1.64734080e-01f, -5.40479004e-01f, -3.04979235e-01f, -3.02407146e-01f, -6.10708654e-01f,
  1.89307868e-01f, -3.27562213e-01f, -5.38865663e-02f, 8.02621990e-02f, -4.94589582e-02f, -1.98170617e-02f, -6.79531097e-02f, -1.95900708e-01f, -1.78994671e-01f, -1.87409535e-01f,
  -1.49079800e-01f, -2.72848154e-03f, 9.90562513e-02f, -2.84346398e-02f, 8.99967104e-02f, 1.27140135e-01f, -2.47253962e-02f, 4.16468345e-02f, -1.82302408e-02f, 9.62647796e-03f,
  -1.65545288e-02f, -1.06638156e-01f, -2.92403921e-02f, -5.88272661e-02f, -1.06560394e-01f, 1.32394940e-01f, -1.38145369e-02f, -4.75291274e-02f, -2.38631349e-02f, -3.29811782e-01f,
  -3.61137427e-02f, -3.30296606e-02f, -3.20033059e-02f, 2.76066996e-02f, -1.89100429e-02f, -1.22719444e-01f, 7.94931129e-03f, -4.47258390e-02f, -8.36739540e-02f, 3.78548494e-03f,
  1.01426318e-01f, -1.20402277e-01f, 2.35535763e-02f, -1.96388587e-01f, -5.64566106e-02f, -1.72697663e-01f, -5.33936210e-02f, 1.16237126e-01f, 9.87823587e-03f, -1.14939816e-01f,
  2.11927705e-02f, -1.21173568e-01f, 6.32649660e-02f, 5.39865643e-02f, -1.95140958e-01f, 1.08148530e-01f, -2.32134759e-02f, 6.74447715e-02f, 2.22995386e-01f, -8.14735442e-02f,
  6.90615475e-01f, 2.72974968e-01f, -3.36042121e-02f, -1.62164662e-02f, -1.32407963e-01f, -1.64366528e-01f, -1.76092848e-01f, -1.34747520e-01f, -5.94871156e-02f, 7.12945014e-02f,
  -3.57632153e-02f, 5.59659004e-02f, 9.08057205e-03f, 5.46888784e-02f, -6.92922913e-05f, -3.03980317e-02f, -2.05093436e-02f, 6.71943128e-02f, -1.53425977e-01f, -3.64637934e-02f,
  -9.21567529e-02f, -1.40075712e-02f, 2.14310870e-01f, 1.64574862e-01f, -1.92652270e-02f, 2.32978642e-01f, 1.78284392e-01f, 3.96175915e-03f, 1.29181653e-01f, -3.87473963e-02f,
  6.93015516e-01f, -4.12310600e-01f, -4.74072471e-02f, 1.47844866e-01f, 1.01606503e-01f, 7.05225617e-02f, -2.20489372e-02f, -4.82667647e-02f, 3.85999456e-02f, -1.29368395e-01f,
  1.22089041e-02f, -2.66552288e-02f, 3.83839495e-02f, -8.36631805e-02f, 1.00357281e-02f, -1.14775412e-01f, -6.54933695e-03f, -3.79701518e-02f, 1.46777228e-01f, 1.83060672e-02f,
  -4.98829670e-02f, -9.37295929e-02f, 5.11082374e-02f, -1.45573407e-01f, -1.85255259e-01f, -8.18469971e-02f, -5.10537475e-02f, -5.89751601e-02f, -1.64492592e-01f, -2.33356580e-01f,
  -4.42349821e-01f, -6.00876212e-02f, -5.77140264e-02f, -5.06621338e-02f, -1.19240500e-01f, 3.86931933e-02f, -7.03396723e-02f, -1.95213094e-01f, 3.59341986e-02f, 1.13922788e-03f,
  -1.11816734e-01f, -5.99975474e-02f, -6.73636980e-03f, -1.61934614e-01f, 3.56990332e-03f, -1.56336829e-01f, -3.30524258e-02f, -1.31431064e-02f, -7.92910531e-02f, -1.73366651e-01f,
  -1.81062549e-01f, 5.26458770e-02f, -6.83137551e-02f, -6.79147914e-02f, 1.47933006e-01f, 1.07768111e-01f, -3.58552560e-02f, 4.53774631e-02f, 3.39706615e-02f, -1.45525448e-02f,
  -3.74644727e-01f, -4.07172032e-02f, -1.69148713e-01f, 1.03396006e-01f, 1.58118501e-01f, 1.33788642e-02f, 7.54711255e-02f, -3.42120305e-02f, 3.29284533e-03f, 5.27140573e-02f,
  -9.69550386e-03f, 5.59394769e-02f, 2.71480065e-02f, -9.94110331e-02f, -4.94206101e-02f, -1.02254771e-01f, -1.40962362e-01f, -1.76262796e-01f, -1.25982031e-01f, 1.81764029e-02f,
  -5.03105707e-02f, -1.17668651e-01f, -4.60600443e-02f, -1.67426348e-01f, -1.06740989e-01f, -1.75131828e-01f, -9.91012603e-02f, -1.95450619e-01f, -1.35152176e-01f, -7.40116369e-03f,
  -2.36003295e-01f, 2.54636765e-01f, 1.51968852e-01f, 9.61446613e-02f, 5.76786362e-02f, -1.64705262e-01f, 1.35987952e-01f, -5.38305193e-02f, -2.49253586e-02f, -3.98830324e-02f,
  3.66351530e-02f, -1.60382092e-02f, 3.79542634e-03f, 5.60011677e-02f, 1.56054959e-01f, 9.76398960e-02f, 6.04782775e-02f, 2.49788328e-03f, -7.39461929e-02f, -1.74559787e-01f,
  -9.27562639e-02f, 1.32522866e-01f, 1.10398382e-01f, 1.72224492e-01f, 2.69945621e-01f, 2.00729534e-01f, 1.05041191e-01f, 2.07477026e-02f, 1.68605149e-01f, 2.20512688e-01f,
  -1.00625348e+00f, -7.06067234e-02f, 6.61048353e-01f, -5.91045678e-01f, 1.32400058e-02f, -4.48354380e-03f, -3.26949418e-01f, -4.35927123e-01f, -2.53562003e-01f, -7.29091614e-02f,
  -1.27699912e-01f, -1.73264027e-01f, 1.98119193e-01f, 2.46742979e-01f, 1.09842844e-01f, 5.18981636e-01f, 7.05904841e-01f, 3.87898505e-01f, -1.83138654e-01f, -5.77626586e-01f,
  -8.44669938e-02f, -3.76358777e-01f, -3.22983414e-01f, 4.72938381e-02f, -3.60637493e-02f, 1.26281187e-01f, 3.70016813e-01f, 6.54111207e-02f, 2.67921984e-01f, 5.77152550e-01f,
  -1.50623634e-01f, -3.46688986e-01f, 1.41192093e-01f, -8.89970809e-02f, 6.11379109e-02f, -1.74883038e-01f, -1.73801586e-01f, 1.22030221e-01f, -9.96713527e-03f, 5.72024360e-02f,
  -5.02578877e-02f, 1.96464807e-01f, 5.74105568e-02f, -7.03566521e-02f, -4.10716027e-01f, -3.52735549e-01f, -9.61032063e-02f, -6.60222173e-02f, 2.71688774e-03f, -2.68160492e-01f,
  1.75612599e-01f, -2.61585534e-01f, -3.18885863e-01f, 5.81279546e-02f, -1.52234599e-01f, -1.53544217e-01f, -1.64758518e-01f, -3.44690830e-01f, -1.63099289e-01f, -3.77544463e-01f,
  1.22330949e-01f, 4.65563089e-02f, 9.20070186e-02f, 5.24202362e-02f, 2.91651208e-03f, 1.39791757e-01f, 1.20994098e-01f, 7.19808489e-02f, 1.90878153e-01f, -1.78794086e-01f,
  7.49578923e-02f, -1.05920844e-01f, -1.56228989e-01f, -2.49745813e-03f, -6.58754120e-03f, -1.63755327e-01f, -4.49245609e-02f, 1.23293027e-01f, 8.99453685e-02f, -9.60665345e-02f,
  -6.45020902e-02f, -7.61072934e-02f, 1.08139150e-01f, 2.65446752e-02f, 2.22111776e-01f, 2.43656680e-01f, -1.07802287e-01f, -6.27540052e-02f, -1.28268361e-01f, -7.33366907e-02f,
  -4.36685354e-01f, 4.79108542e-01f, -1.94198519e-01f, -5.20877987e-02f, -1.11390883e-02f, 4.50514033e-02f, -2.87881251e-02f, -1.47958808e-02f, -1.41914152e-02f, -2.20657900e-01f,
  -1.40189007e-01f, -7.84028508e-03f, 1.16630062e-01f, 3.21446247e-02f, -2.84396917e-01f, -4.22033034e-02f, -7.90842921e-02f, -9.83161107e-02f, -1.02321409e-01f, -1.90814883e-01f,
  4.61191498e-02f, -4.87437069e-01f, -5.83344281e-01f, -3.54503870e-01f, -4.86128330e-01f, -5.21217108e-01f, -1.79751962e-01f, -4.07126904e-01f, -4.31824684e-01f, -7.80768037e-01f,
  -6.93986595e-01f, -5.31908989e-01f, 1.72414929e-01f, -1.75757959e-01f, 3.08859825e-01f, 3.98760021e-01f, 3.88786882e-01f, 2.00066179e-01f, 5.40905818e-02f, -9.04206261e-02f,
  -5.47806501e-01f, -4.97666985e-01f, -4.03513461e-01f, -1.73874468e-01f, -8.90988335e-02f, 3.97247553e-01f, 3.63488138e-01f, 1.51645973e-01f, 1.98962793e-01f, 2.32413337e-01f,
  1.33374572e-01f, -1.38674647e-01f, -3.82733256e-01f, -1.05129942e-01f, 1.06578171e-02f, -1.66114271e-01f, -1.36199947e-02f, -1.03549853e-01f, 7.16332421e-02f, -8.78892243e-02f,
  -3.31741273e-01f, -4.10372466e-01f, 2.53307462e-01f, -1.26368180e-01f, -1.79481462e-01f, -1.30198672e-01f, -9.26464871e-02f, -1.52166158e-01f, -1.85501859e-01f, 2.78715398e-02f,
  -4.97052707e-02f, -8.27635080e-02f, -1.14144325e-01f, -3.90232876e-02f, -4.99805398e-02f, 1.22814579e-02f, -1.70905527e-03f, -2.04613164e-01f, -1.98095813e-01f, -7.60253286e-04f,
  1.97753720e-02f, 9.51665118e-02f, -4.61977385e-02f, 1.90341190e-01f, 7.62117878e-02f, 2.04056278e-02f, -1.46094710e-01f, -4.35887016e-02f, -5.12565020e-03f, -2.04424441e-01f,
  2.97856480e-01f, -6.12746477e-02f, -2.69598840e-03f, -5.85316531e-02f, -6.15670159e-02f, -5.23016714e-02f, 5.87240309e-02f, -1.07594214e-01f, -6.83956891e-02f, -1.10773504e-01f,
  -1.00028209e-01f, -8.16624314e-02f, -4.27910462e-02f, -4.59153019e-02f, -1.68806404e-01f, -2.85585187e-02f, 1.70962885e-02f, -2.02487528e-01f, -7.51332194e-02f, -7.29786009e-02f,
  -8.54462460e-02f, 3.95891555e-02f, -6.48171157e-02f, 5.75744696e-02f, 2.84096766e-02f, -8.23459625e-02f, 2.03342158e-02f, -7.89543837e-02f, -3.93908657e-02f, -2.05173120e-02f,
  -3.19627106e-01f, 2.57997721e-01f, -3.89271788e-02f, -5.14317118e-02f, 4.71160114e-02f, -1.02498278e-01f, -1.20510079e-01f, 1.05799483e-02f, -7.78149515e-02f, 7.96305016e-02f,
  2.95630358e-02f, -7.04413950e-02f, -5.81988283e-02f, -3.13814655e-02f, 1.86443239e-01f, 9.73851681e-02f, 1.75484680e-02f, 2.20014080e-02f, 1.25988618e-01f, -1.77789163e-02f,
  8.63545313e-02f, 1.81084991e-01f, -1.16683483e-01f, 6.68638647e-02f, 1.99658275e-01f, 1.93540007e-01f, 1.40245091e-02f, 6.59776479e-02f, 1.89204648e-01f, 1.79119915e-01f,
  3.95755708e-01f, -3.75184268e-01f, -9.06493664e-01f, 9.44305398e-03f, -1.74017653e-01f, -5.97057864e-02f, -1.36386976e-01f, 1.45511240e-01f, 1.29196182e-01f, -2.39604130e-01f,
  -6.91022724e-02f, 3.50305051e-01f, 1.27116472e-01f, 3.11477482e-01f, 2.87154257e-01f, -2.37958625e-01f, -3.09757203e-01f, 2.73262840e-02f, 4.93447781e-01f, 4.15893614e-01f,
  3.63664538e-01f, 1.39242411e-01f, 2.13664263e-01f, 1.47700056e-01f, -2.47726128e-01f, 8.55701640e-02f, -5.82121730e-01f, -1.83114529e-01f, -2.12490767e-01f, -3.04975450e-01f,
  -3.89627159e-01f, -2.00740576e-01f, 1.66651756e-01f, 3.79048467e-01f, -6.47295266e-02f, 4.09738421e-02f, 6.63103983e-02f, -1.26997113e-01f, 7.05938339e-02f, -1.65123135e-01f,
  -1.38257861e-01f, 1.26436815e-01f, 1.74852028e-01f, 8.33112653e-03f, -6.23895600e-02f, -6.96822489e-03f, 4.76509556e-02f, 3.29186134e-02f, -6.09975718e-02f, -1.29344285e-01f,
  2.50330985e-01f, -1.13057708e-02f, -2.92710751e-01f, -1.04209468e-01f, -1.07024126e-01f, 1.36031181e-01f, -2.93194771e-01f, -8.82156938e-02f, -4.78506349e-02f, -3.43578666e-01f,
  1.32161364e-01f, -1.13456413e-01f, -1.45704165e-01f, -1.31413892e-01f, 1.85101315e-01f, -2.08642378e-01f, -5.28535880e-02f, 7.15021044e-03f, 2.19806023e-02f, -9.77082998e-02f,
  3.51908617e-02f, -4.58243787e-02f, 1.20191909e-02f, -7.50245750e-02f, 2.56369002e-02f, -5.52053154e-02f, -4.67124991e-02f, -6.44888580e-02f, 6.89196885e-02f, 1.59387831e-02f,
  1.12906285e-01f, -3.03403474e-02f, -1.45361453e-01f, 2.10688278e-01f, -5.94606996e-02f, 4.21107262e-02f, -7.45913684e-02f, 1.36588961e-01f, 1.42231837e-01f, -4.63226065e-02f,
  2.43571356e-01f, 1.17855735e-01f, -2.37722546e-01f, 1.04184434e-01f, -4.60355319e-02f, -8.06335956e-02f, -8.15696046e-02f, -7.59045556e-02f, -1.23414025e-01f, -4.03083079e-02f,
  -8.65073800e-02f, 1.35296937e-02f, -1.97474867e-01f, -1.19081125e-01f, 1.06200896e-01f, -1.31140143e-01f, 1.39139682e-01f, 3.15892994e-02f, -7.63135105e-02f, -2.89895177e-01f,
  -1.20873868e-01f, 2.12721467e-01f, 4.09604982e-02f, -8.74036029e-02f, -1.04894795e-01f, 2.65980095e-01f, -4.65913266e-01f, -1.73098594e-01f, 1.34748137e-02f, -1.69016674e-01f,
  3.67812127e-01f, -1.51068404e-01f, -7.75498867e-01f, -1.96821988e-01f, -4.77898926e-01f, -2.99957186e-01f, 9.74964276e-02f, 1.90375626e-01f, -1.42632097e-01f, -1.44073173e-01f,
  -4.27772813e-02f, 9.55203027e-02f, -1.82328433e-01f, 2.59309448e-02f, 1.66415125e-01f, -2.75343865e-01f, -3.66527140e-01f, -2.50167131e-01f, 1.35082468e-01f, 3.62765968e-01f,
  1.86938614e-01f, 2.16614217e-01f, 1.45051837e-01f, -8.37418076e-04f, -3.27847064e-01f, -1.04201570e-01f, -4.33822036e-01f, -3.24266851e-01f, -1.73853070e-01f, -4.94079083e-01f,
  -4.15369540e-01f, -2.90542334e-01f, 4.04290110e-02f, 9.55194235e-02f, -3.40528600e-02f, 2.19435915e-01f, 1.27978131e-01f, 9.30305347e-02f, 1.15280241e-01f, 6.47538230e-02f,
  -7.06337765e-02f, 1.60825163e-01f, 4.01968919e-02f, -2.44271266e-03f, -5.63999563e-02f, -2.08264831e-02f, -1.49638206e-01f, -2.98014861e-02f, -2.18278579e-02f, -1.20778844e-01f,
  -4.32605185e-02f, -2.15353966e-01f, -3.08720291e-01f, -5.23731373e-02f, 1.08775506e-02f, -1.68866694e-01f, -1.49737328e-01f, -1.79666698e-01f, -1.02143548e-01f, -8.15269575e-02f,
  -1.27644343e-02f, -6.19162917e-02f, -6.46698251e-02f, 1.10067632e-02f, 2.19129622e-01f, 4.80947347e-04f, 1.52858216e-02f, 4.97730449e-02f, 1.91021338e-01f, 3.45147513e-02f,
  -3.48104089e-02f, 8.66501853e-02f, -5.00965957e-03f, 9.76460502e-02f, -3.04723857e-03f, -1.17367893e-01f, 2.59232409e-02f, 1.57792997e-02f, -3.83647680e-02f, 1.02223739e-01f,
  1.86928164e-03f, -5.15287668e-02f, -6.38675690e-02f, 1.28139988e-01f, -2.95296200e-02f, -1.83849782e-02f, -8.92390683e-03f, 1.67279616e-01f, 5.61267175e-02f, -1.62295982e-01f,
  2.20068425e-01f, -9.27851498e-02f, -7.36533254e-02f, -4.68866229e-02f, -1.11405410e-01f, -8.11845586e-02f, -1.17391132e-01f, 1.38524532e-01f, -3.62110161e-03f, 1.01859644e-01f,
  -3.97439376e-02f, 2.28009969e-01f, -5.45357205e-02f, 8.35474394e-03f, 1.37529388e-01f, 7.82149807e-02f, 1.89341724e-01f, -8.62931535e-02f, 3.36537547e-02f, -1.60441667e-01f,
  7.76752606e-02f, 1.46333992e-01f, 1.38698861e-01f, 5.23237027e-02f, -3.53196561e-02f, 8.49573389e-02f, -3.41416225e-02f, -1.26932994e-01f, 7.48783648e-02f, 2.85728306e-01f,
  -9.34920251e-01f, 3.72279108e-01f, 4.82737660e-01f, -4.79055673e-01f, -6.87444508e-02f, -3.38982716e-02f, 1.56417206e-01f, -3.46331537e-01f, -4.05458808e-01f, 3.34105641e-01f,
  3.81149769e-01f, -1.68491662e-01f, -1.57120809e-01f, -3.12925011e-01f, -3.68300706e-01f, 3.70723195e-02f, -1.23315372e-01f, -4.31011051e-01f, -5.96029162e-01f, -4.88206148e-01f,
  -3.81428987e-01f, -4.41661119e-01f, -4.98652875e-01f, -3.28050077e-01f, 1.05382554e-01f, -1.83938786e-01f, 2.23539054e-01f, -8.35654289e-02f, 1.30015165e-01f, 2.77013313e-02f,
  4.06336963e-01f, 1.23729363e-01f, -1.85494021e-01f, -2.31924757e-01f, 1.16713103e-02f, -7.04710335e-02f, -3.62209529e-02f, -1.05233431e-01f, -2.18865019e-03f, 9.98103395e-02f,
  -2.13391855e-02f, -7.81878978e-02f, 3.49314511e-02f, 1.34884909e-01f, -7.98540888e-04f, 6.09786287e-02f, 4.59841527e-02f, -7.25721242e-03f, 2.84712967e-02f, 3.39856386e-01f,
  2.51111984e-01f, 1.90815985e-01f, 4.57537733e-02f, 7.73047656e-02f, 2.07010992e-02f, -4.49872948e-02f, 2.11661786e-01f, 1.34078283e-02f, 7.26129338e-02f, -3.14449705e-02f,
  -1.86061725e-01f, 5.92817599e-03f, -7.53575414e-02f, 5.44050932e-02f, 3.00564524e-02f, 5.41728772e-02f, 1.22948354e-02f, 2.05361540e-03f, -1.88624218e-01f, 1.56736299e-02f,
  3.86122949e-02f, 1.68840066e-01f, 9.74327624e-02f, -1.30327987e-02f, -3.46598402e-02f, 3.79741117e-02f, 8.63121003e-02f, 3.37187871e-02f, 1.12711117e-01f, -5.00875264e-02f,
  -1.10782739e-02f, 1.09292313e-01f, 3.22646312e-02f, -2.50216201e-03f, 9.41474363e-02f, 6.99407011e-02f, 1.04943275e-01f, 1.04559653e-01f, 5.24333073e-03f, -7.34548569e-02f,
  -2.40927245e-02f, -3.82656530e-02f, 6.95174038e-02f, -1.51652917e-01f, 1.08493842e-01f, 4.24794070e-02f, 1.88331172e-01f, -4.47580144e-02f, 5.64803407e-02f, -4.97723334e-02f,
  1.57403901e-01f, -3.65430340e-02f, 2.46950343e-01f, 1.21942490e-01f, -1.02681145e-01f, -6.51330128e-02f, 1.09360620e-01f, 8.17414224e-02f, 5.23152296e-03f, 1.51883438e-01f,
  1.57357275e-01f, -8.07045251e-02f, -1.69642717e-01f, -4.93511409e-02f, 7.79823884e-02f, -1.03657067e-01f, 1.65198833e-01f, 1.01333797e-01f, 1.70974769e-02f, -1.46607921e-01f,
  5.80673695e-01f, -1.33918747e-01f, 9.86389350e-04f, 1.91122189e-01f, 8.84684622e-02f, 2.03789130e-01f, 8.37079808e-02f, 1.05764247e-01f, 1.89215720e-01f, 1.08088709e-01f,
  1.66255996e-01f, 2.26849139e-01f, 8.31011906e-02f, 8.49610269e-02f, -2.89390814e-02f, -3.25438194e-02f, -5.37163131e-02f, -2.40786001e-03f, 9.43298340e-02f, 6.41083121e-02f,
  5.21266945e-02f, -2.46563125e-02f, -1.34373501e-01f, -1.10080905e-01f, -1.07635707e-01f, 1.07899398e-01f, -8.10900703e-02f, -8.25604424e-02f, -1.27449185e-01f, -2.99704850e-01f,
  -3.38725388e-01f, -8.60953778e-02f, 1.17554486e-01f, -1.17007807e-01f, -4.03573513e-02f, -3.46567519e-02f, 4.68219891e-02f, 2.15791222e-02f, -1.35489497e-02f, -5.05325310e-02f,
  -1.68325566e-02f, -1.13349997e-01f, -1.07371263e-01f, 2.96730082e-03f, -1.19564898e-01f, -1.05926692e-01f, -1.17708836e-02f, 1.96036920e-02f, 5.47739342e-02f, -5.13048191e-03f,
  3.26230526e-02f, -1.61618162e-02f, 8.71294215e-02f, 4.95515652e-02f, 9.81006771e-02f, 6.74796179e-02f, -2.60176789e-02f, 6.02643043e-02f, 1.18516676e-01f, 9.22245607e-02f,
  8.95583183e-02f, 1.47296295e-01f, 3.89782675e-02f, 2.01415718e-02f, 6.59650043e-02f, 1.21151082e-01f, 7.35980272e-02f, -2.59763524e-02f, 3.46565880e-02f, -8.58817920e-02f,
  -7.74667561e-02f, 5.41966297e-02f, 4.42905501e-02f, 4.00676019e-02f, -7.62102976e-02f, -6.25255331e-02f, -7.56530464e-02f, -3.00909840e-02f, -2.84511386e-03f, 3.52623388e-02f,
  -6.68214913e-03f, -1.07638560e-01f, -1.38426825e-01f, -1.33127376e-01f, -1.69264704e-01f, 1.94944348e-02f, -4.42094654e-02f, -5.12104668e-02f, 4.83112112e-02f, -5.97042553e-02f,
  -1.25028253e-01f, -1.84952968e-03f, -6.31874502e-02f, -2.65044160e-03f, -1.68044508e-01f, 1.69893764e-02f, -9.05169025e-02f, -7.81922042e-02f, -1.57179222e-01f, -1.49562657e-01f,
  -1.47079498e-01f, -9.81536880e-02f, -3.91776348e-03f, 2.27995440e-02f, 7.30410516e-02f, 2.89966241e-02f, 2.51065195e-02f, 7.72283077e-02f, -4.01593260e-02f, 1.93377100e-02f,
  -2.58887094e-02f, 1.79044545e-01f, 1.21114105e-01f, 1.23068519e-01f, -6.58654375e-03f, 1.57222241e-01f, 7.20813647e-02f, 5.07124178e-02f, 5.34859858e-02f, 1.97776601e-01f,
  -7.32354820e-01f, 1.91044629e-01f, -1.70260668e-02f, -2.43390396e-01f, -1.08237341e-01f, -2.93550044e-01f, -7.50541762e-02f, -4.93398607e-02f, -7.15974644e-02f, 4.32952978e-02f,
  -2.67817974e-02f, -1.52257025e-01f, -2.02533491e-02f, -2.39172708e-02f, -2.85592049e-01f, -4.28821072e-02f, -2.74256647e-01f, -4.69269246e-01f, -5.05895376e-01f, -1.40383333e-01f,
  -1.60470650e-01f, -3.96239102e-01f, -4.56088305e-01f, -1.97426304e-01f, 1.63302854e-01f, -1.40876949e-01f, -2.47118529e-03f, -3.43711466e-01f, -3.14838827e-01f, -2.65661597e-01f,
  3.02028865e-01f, -3.63048643e-01f, -6.81747869e-02f, -4.00894694e-02f, 1.20231457e-01f, -1.23364395e-02f, -3.23240310e-02f, 1.28467739e-01f, -3.64724733e-02f, 5.00065386e-02f,
  -7.86513090e-02f, -5.17806746e-02f, 1.17865941e-02f, 6.99589401e-02f, 1.25885587e-02f, 1.08218066e-01f, 1.36891067e-01f, 6.47760108e-02f, 2.13241950e-02f, 1.13562576e-01f,
  7.73148090e-02f, -2.62144748e-02f, -3.02560162e-02f, 2.08608732e-02f, 5.86356148e-02f, -1.49815008e-01f, -3.77787575e-02f, -7.69799994e-03f, -1.45725653e-01f, 6.68239295e-02f,
  1.39849812e-01f, 3.11037153e-01f, 3.22954846e-03f, 9.02094245e-02f, 9.69316661e-02f, 4.60330248e-02f, -1.06565719e-02f, 1.62151486e-01f, -7.75343403e-02f, 1.05302155e-01f,
  9.05615240e-02f, -3.75617035e-02f, -1.26840442e-01f, 1.19851222e-02f, -3.35122719e-02f, -4.00067009e-02f, -1.42163172e-01f, 2.15742160e-02f, 4.59037628e-03f, -6.24848297e-03f,
  -7.38268122e-02f, -8.20839126e-03f, -1.79160517e-02f, -4.85314168e-02f, 2.96081154e-04f, 1.65291540e-02f, -1.15019135e-01f, -1.76424198e-02f, 6.94547743e-02f, -1.32988960e-01f,
  2.50164419e-01f, -4.96203572e-01f, 4.06494401e-02f, -3.65759432e-02f, 4.53387201e-02f, 1.38532087e-01f, -2.60942485e-02f, 5.53403376e-03f, -1.03369519e-01f, 8.90148953e-02f,
  4.44622189e-02f, 4.54459488e-02f, 1.30092874e-01f, 1.63227960e-01f, -1.09314481e-02f, 3.95335257e-02f, -1.19469957e-02f, 2.26324014e-02f, -2.61220820e-02f, 2.42714196e-01f,
  1.96607307e-01f, 5.04508130e-02f, 2.93864310e-02f, 1.17415629e-01f, -1.58901475e-02f, -1.58932090e-01f, 1.35441393e-01f, 1.52280748e-01f, 2.52153240e-02f, 1.23239838e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  5.49017727e-01f, 2.29979619e-01f, 1.19281918e-01f, 5.61251938e-01f, 8.20424676e-01f, 4.55567956e-01f, 3.27376992e-01f, 4.72270787e-01f, 6.24929249e-01f, 5.04453480e-01f,
  5.80488145e-01f, 1.14266351e-01f, 4.33611184e-01f, 5.73198140e-01f, 7.16087759e-01f, 5.13641059e-01f, 2.48709947e-01f, 3.77345234e-01f, 2.79228419e-01f, 4.59929556e-01f,
  3.84998709e-01f, 6.65138662e-01f, 4.43241209e-01f, 1.66505694e-01f, 5.92639983e-01f, 2.10948259e-01f, 2.22695366e-01f, 1.19517773e-01f, 5.55498958e-01f, 5.22830009e-01f,
  4.92098033e-01f, 5.11063337e-01f, 3.20857823e-01f, 2.22524740e-02f, 2.66463876e-01f, 6.77939832e-01f, 5.32669008e-01f, 3.81491661e-01f, 1.78154558e-01f, 2.03670606e-01f,
  3.74194682e-01f, 2.57752270e-01f, 3.76019925e-01f, 6.58465683e-01f, 6.19555533e-01f, 6.75019562e-01f, 7.98876941e-01f, 4.86497134e-01f, 2.86622614e-01f, 6.85402632e-01f,
  2.44494766e-01f, 3.52555603e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.50679678e-01f, -6.39992654e-02f, -2.34501854e-01f, -6.27978370e-02f, -7.73978606e-02f, 1.18635088e-01f, -5.14212251e-02f, -1.52498513e-01f, -2.16383457e-01f, 2.95251291e-02f,
  -1.12184279e-01f, -2.29538772e-02f, -1.08014748e-01f, 8.81202705e-03f, -9.46920216e-02f, -4.40168791e-02f, -1.56039119e-01f, -7.86287785e-02f, -1.28641650e-01f, -8.96873623e-02f,
  -2.88696885e-02f, -5.03228717e-02f, 1.01696141e-01f, 1.24125905e-01f, -2.12940618e-01f, -1.16385669e-01f, 4.28220890e-02f, -3.55262578e-01f, -1.74396500e-01f, -2.01058101e-05f,
  -5.65342344e-02f, -1.34453833e-01f, 6.55079484e-02f, -1.39861897e-01f, -5.22171482e-02f, -1.84322208e-01f, -1.18292190e-01f, -3.62041593e-02f, -1.10106491e-01f, 1.50570825e-01f,
  4.79826480e-02f, 3.97579633e-02f, -2.20254302e-01f, 9.72989053e-02f, -9.81355384e-02f, -3.03829253e-01f, -6.94989562e-02f, -2.95401756e-02f, 1.39883950e-01f, -1.18248299e-01f,
  4.02766705e-01f, -1.23725474e-01f, 1.89353570e-01f, 2.49627292e-01f, -3.61840352e-02f, -1.57952130e-01f, 1.02006406e-01f, -1.88319787e-01f, -2.43872046e-01f, 1.34009495e-01f,
  7.06190169e-02f, -1.54038072e-02f, 2.85416186e-01f, 1.19145051e-01f, 4.62346710e-02f, 6.49231859e-03f, 1.40682876e-01f, 2.57084519e-01f, -1.06670223e-01f, 1.31845012e-01f,
  2.60162771e-01f, -8.32819194e-02f, 2.35060066e-01f, 6.18809983e-02f, -1.65477291e-01f, 5.34684472e-02f, 3.48486871e-01f, -3.98392320e-01f, 4.00839597e-01f, 2.30616674e-01f,
  -2.18579054e-01f, -4.29019541e-01f, -1.37675092e-01f, 1.71521708e-01f, -4.39927340e-01f, 2.85288125e-01f, 3.91679481e-02f, 3.38610291e-01f, -8.61215815e-02f, -7.82345414e-01f,
  -2.59940147e-01f, 3.34201157e-01f, 3.25688004e-01f, 5.95646873e-02f, -5.15424833e-02f, 9.31357369e-02f, 2.99954563e-02f, -1.80272162e-02f, 2.81544298e-01f, 2.76363790e-01f,
  -2.46517316e-01f, 1.75015792e-01f, 1.65382579e-01f, 1.19546227e-01f, -2.00800315e-01f, -5.55650890e-01f, -1.26726955e-01f, 2.23186046e-01f, -3.26281071e-01f, 1.16648398e-01f,
  2.81771272e-01f, -2.27069587e-01f, -3.31886411e-01f, -5.40513933e-01f, 4.32251215e-01f, -1.62666757e-02f, -4.55905914e-01f, -4.27712262e-01f, 5.39079867e-02f, 2.77558476e-01f,
  -1.40992194e-01f, -7.02517927e-01f, -3.25468183e-01f, 6.01698518e-01f, 2.65017807e-01f, -2.31948122e-01f, 1.12844128e-02f, -1.11407749e-01f, 1.73251882e-01f, 9.48783085e-02f,
  8.73755291e-02f, 1.92733064e-01f, -8.41863304e-02f, -7.50003308e-02f, -7.47196302e-02f, 3.19871336e-01f, 9.21903476e-02f, 1.46371037e-01f, -7.02423463e-03f, -2.85147596e-03f,
  -9.04650986e-02f, -3.03301886e-02f, 8.24807733e-02f, -9.03572366e-02f, -4.45360467e-02f, -8.69426578e-02f, 4.53976281e-02f, -1.00499243e-01f, 2.58715241e-03f, 3.39601375e-02f,
  -2.11702101e-02f, -2.65588671e-01f, -4.12940159e-02f, 3.99924517e-02f, -2.10302815e-01f, 1.04223564e-01f, 4.74188514e-02f, 1.00140199e-01f, 4.84036617e-02f, -3.45600545e-02f,
  -3.74268927e-02f, 7.02513568e-03f, 5.22112800e-03f, 8.25329870e-02f, 1.72855899e-01f, 1.56047307e-02f, -8.97646770e-02f, 2.70138651e-01f, -1.37374535e-01f, -3.36867630e-01f,
  -2.20101595e-01f, 2.92077333e-01f, 1.29046952e-02f, 2.47484624e-01f, -2.84304500e-01f, 4.15682495e-02f, -2.96024680e-01f, 1.17030136e-01f, 2.07897231e-01f, 3.57377410e-01f,
  1.20259240e-01f, 3.96792382e-01f, -4.33102436e-02f, 1.53052345e-01f, 5.98096177e-02f, -1.41674623e-01f, 2.00891197e-01f, -2.82544822e-01f, -1.65446922e-01f, 2.12089401e-02f,
  2.61938184e-01f, 2.81733155e-01f, -7.72644058e-02f, -3.27399862e-03f, 5.02268896e-02f, -9.59147513e-03f, 1.64182529e-01f, -4.60465521e-01f, 2.51784474e-01f, 1.53248489e-01f,
  4.23513055e-01f, -2.40392108e-02f, 2.81694651e-01f, -2.66948819e-01f, 2.86276519e-01f, -1.89524040e-01f, 4.84267890e-01f, -7.56129861e-01f, -1.23365676e+00f, -7.63357282e-01f,
  2.30194315e-01f, 1.61218107e-01f, 1.61356747e-01f, -4.08068568e-01f, -8.89081895e-01f, -3.50265026e-01f, 3.71406257e-01f, -4.16518718e-01f, -2.46372491e-01f, -4.77884382e-01f,
  -5.24250984e-01f, 3.50528717e-01f, -3.15951109e-02f, 4.56985205e-01f, 2.17513833e-02f, -6.84990436e-02f, -2.85545945e-01f, 2.46368036e-01f, 5.50442822e-02f, 3.81485112e-02f,
  -2.07205638e-01f, -6.14919923e-02f, 1.72577247e-01f, 4.02616709e-02f, 4.67966348e-01f, 1.93723336e-01f, 9.08800289e-02f, 3.24718297e-01f, -4.62185025e-01f, -5.08797705e-01f,
  2.99749468e-02f, -2.57561743e-01f, -6.68542206e-01f, -3.74341942e-02f, -3.53353143e-01f, 3.17971483e-02f, 1.55926257e-01f, 5.30622244e-01f, 2.89668947e-01f, -5.81208408e-01f,
  -4.69550133e-01f, 6.78968728e-01f, 2.93338180e-01f, -6.09522700e-01f, 1.65204436e-01f, -3.61480862e-01f, 3.70185524e-02f, 2.05283195e-01f, 2.19781082e-02f, 1.14862122e-01f,
  2.92257383e-03f, -3.90470820e-03f, 1.63670197e-01f, -9.06154811e-02f, 1.13321617e-01f, 1.04755037e-01f, -1.45069435e-02f, 1.86266322e-02f, 3.69419940e-02f, 8.00773501e-02f,
  1.08356856e-01f, -9.35766287e-03f, 2.37357870e-01f, 4.38812710e-02f, 1.94840163e-01f, 2.37901788e-02f, 2.17219040e-01f, 2.96633363e-01f, -4.12606709e-02f, 2.27743223e-01f,
  2.51251236e-02f, 4.94052507e-02f, 2.74812672e-02f, -9.02178604e-03f, 2.94297896e-02f, -7.09272921e-02f, 3.77633832e-02f, -4.65791300e-02f, 1.26392081e-01f, 5.48062809e-02f,
  -8.30202922e-02f, -7.80313686e-02f, -5.15873246e-02f, 8.93063173e-02f, 7.31557757e-02f, -3.12006362e-02f, -2.14603413e-02f, 3.44463515e-05f, 1.75510913e-01f, 2.32842326e-01f,
  1.11830615e-01f, 1.64197236e-01f, -1.05775803e-01f, -8.48379880e-02f, -6.40518889e-02f, -1.46230429e-01f, 2.46146053e-01f, 6.32136613e-02f, -2.11082801e-01f, 2.60610640e-01f,
  -3.62911522e-02f, -1.02341779e-01f, -1.10024139e-02f, 2.72483714e-02f, -2.31374726e-01f, 4.49332595e-02f, 2.78116882e-01f, -1.58584878e-01f, 3.14581215e-01f, -1.53385952e-01f,
  2.54296124e-01f, -1.34474114e-01f, 3.39782208e-01f, 3.64512056e-01f, -2.89555758e-01f, 1.61318660e-01f, 2.63204068e-01f, 2.92434752e-01f, 2.52180517e-01f, 2.40590721e-01f,
  2.72134900e-01f, 5.70425242e-02f, 5.49923420e-01f, -3.17149401e-01f, -1.96436480e-01f, 3.37909371e-01f, -2.39830375e-01f, -4.33376759e-01f, 6.42563626e-02f, -6.28946245e-01f,
  -2.32746363e-01f, -4.97162163e-01f, -4.06160742e-01f, -5.05612373e-01f, -1.37570882e-02f, 1.26658708e-01f, -2.48933196e-01f, -5.73557973e-01f, 2.47229427e-01f, 1.71699226e-01f,
  -1.25112697e-01f, 3.01784366e-01f, 3.14386249e-01f, 8.79205227e-01f, -4.19525802e-01f, -8.20890442e-03f, -1.93133712e-01f, 2.24686608e-01f, -1.53551951e-01f, -2.69248635e-01f,
  1.06133357e-01f, -1.00708894e-01f, -2.90327311e-01f, 5.90221941e-01f, -4.23656225e-01f, -3.46320212e-01f, -3.92115265e-01f, -2.19174445e-01f, -3.99981916e-01f, -2.39219546e-01f,
  1.92784816e-01f, 6.98254406e-02f, -2.65364259e-01f, -1.41564414e-01f, 7.09576830e-02f, 2.53435642e-01f, -4.71543148e-02f, 5.48122704e-01f, 2.07201123e-01f, 1.59724489e-01f,
  -3.65093768e-01f, -4.99064237e-01f, -2.21547574e-01f, -1.02238223e-01f, -2.11393926e-02f, 1.62660591e-02f, -7.86683410e-02f, 1.53161874e-02f, -9.51474980e-02f, -2.39686593e-01f,
  -5.52829541e-02f, 1.67422965e-01f, -1.96217567e-01f, 1.65137686e-02f, -1.07697234e-01f, -2.20708922e-01f, -2.04659209e-01f, -8.88091251e-02f, -5.29832356e-02f, -3.97178195e-02f,
  1.81512445e-01f, 2.02042252e-01f, -2.11774305e-01f, 9.65404212e-02f, 4.06468622e-02f, -2.22874016e-01f, -2.18895033e-01f, 4.44396362e-02f, 6.21312521e-02f, -6.67860061e-02f,
  9.28801298e-02f, -4.85377014e-02f, -3.12315803e-02f, 1.50624728e-02f, 2.24045385e-02f, 4.05408703e-02f, -9.36390609e-02f, -2.91877724e-02f, 3.38682719e-02f, -7.09985867e-02f,
  -3.44776958e-01f, 7.92817771e-02f, -1.14789955e-01f, 3.90186831e-02f, 1.10919848e-01f, -4.84222323e-02f, 4.00684863e-01f, -3.17888618e-01f, 1.47807196e-01f, -1.21870577e-01f,
  1.75447688e-02f, -8.17417949e-02f, 1.20322317e-01f, -4.25442427e-01f, -5.57641029e-01f, 2.07691237e-01f, 2.75757372e-01f, -1.81911528e-01f, -2.34170347e-01f, -1.69355154e-01f,
  1.03191741e-01f, 3.34883243e-01f, 9.15064365e-02f, 1.19032383e-01f, 1.25948742e-01f, -1.23972483e-01f, 1.31418899e-01f, -3.23962197e-02f, 2.48707324e-01f, 2.50889927e-01f,
  -5.18626332e-01f, 1.88483551e-01f, -2.93795466e-02f, 5.10343730e-01f, -1.35946408e-01f, 1.33423582e-01f, -1.77705631e-01f, 1.66728914e-01f, -8.18766803e-02f, -3.18021268e-01f,
  -2.72780983e-03f, -4.69579399e-01f, 4.12193298e-01f, -9.06146020e-02f, -2.75877476e-01f, 5.63138664e-01f, 1.90557912e-01f, -1.10286646e-01f, -1.19766724e+00f, 2.81785578e-01f,
  4.27855551e-01f, 3.41272503e-02f, -2.12146655e-01f, -7.02279449e-01f, 4.34075296e-01f, -4.33329433e-01f, -4.36648071e-01f, -8.02765042e-02f, -2.41793633e-01f, 2.64993817e-01f,
  -2.35606089e-01f, 3.49945098e-01f, 1.40607394e-02f, -1.91733569e-01f, -3.84581566e-01f, -3.80346864e-01f, -1.44776583e-01f, 1.42796217e-02f, -2.39957139e-01f, -4.48164523e-01f,
  -1.99725643e-01f, 3.75884622e-02f, -4.05900389e-01f, -5.56071894e-03f, -3.41166854e-02f, 5.00418544e-01f, -2.26406202e-01f, 4.52178329e-01f, -6.89946860e-02f, -3.58447611e-01f,
  -7.39110708e-01f, -5.12586892e-01f, -1.80230230e-01f, -7.71669865e-01f, -5.17719984e-01f, 5.28678715e-01f, 5.30649304e-01f, -2.98539162e-01f, -7.14640915e-02f, 4.14796710e-01f,
  5.21744788e-02f, 3.08973994e-02f, -5.95519207e-02f, -9.08414647e-02f, -1.77292936e-02f, -2.00897947e-01f, 1.01496436e-01f, -5.88846952e-02f, -2.26021037e-01f, 6.49938360e-02f,
  -1.08464442e-01f, -1.74920529e-01f, -9.81778093e-03f, 8.55302960e-02f, 1.03607595e-01f, -1.01309873e-01f, 4.05541249e-02f, -3.65871117e-02f, -2.31071264e-01f, 8.39538202e-02f,
  2.27118540e-03f, 2.76028272e-02f, 4.64767590e-02f, -3.74248587e-02f, -2.58937385e-02f, -2.28717953e-01f, -3.53269763e-02f, 3.11004259e-02f, -7.24549890e-02f, 8.35844874e-02f,
  -3.27373967e-02f, -1.81988865e-01f, 3.95779610e-02f, -2.74275467e-02f, -1.95758432e-01f, 1.58401191e-01f, -2.58300938e-02f, -3.03317122e-02f, -5.73577657e-02f, -1.32293239e-01f,
  -2.76116226e-02f, -1.26097873e-01f, 2.04621896e-01f, -1.38985753e-01f, 2.03617383e-02f, -1.49703562e-01f, 4.55242731e-02f, -3.85216996e-02f, -1.60801113e-01f, 1.59289807e-01f,
  2.54018843e-01f, 5.67787252e-02f, -5.21495342e-01f, 1.14637278e-01f, -3.50613892e-01f, -1.37476161e-01f, -7.46495426e-02f, 2.77555399e-02f, 1.94791555e-01f, 2.27119792e-02f,
  -1.45284906e-01f, -2.03084126e-01f, 1.59641534e-01f, -1.27870068e-01f, -1.16531819e-01f, 1.56108644e-02f, 1.65192291e-01f, 2.05515236e-01f, 3.79401259e-02f, 7.68652782e-02f,
  1.55292049e-01f, -2.60786235e-01f, -1.81132853e-01f, 2.43618950e-01f, -1.93880707e-01f, 3.31777632e-02f, 2.45105281e-01f, 1.58086345e-01f, -2.11628646e-01f, 4.37538624e-02f,
  -5.79923630e-01f, -3.87047648e-01f, 2.02001616e-01f, -2.60946363e-01f, 4.52156216e-02f, 2.21937411e-02f, 2.58874029e-01f, -3.98593873e-01f, 2.68705208e-02f, 2.20918924e-01f,
  3.90725285e-02f, 4.24236745e-01f, -5.12710154e-01f, -4.30379882e-02f, 2.99948841e-01f, 1.79531172e-01f, -2.31424168e-01f, 7.34139606e-02f, -4.95029092e-01f, 1.42273009e-01f,
  2.31743544e-01f, -9.69225764e-02f, -2.04320922e-01f, 3.35855497e-04f, 1.06353253e-01f, -8.03264678e-01f, 1.05723575e-01f, -2.23831013e-01f, -4.98387188e-01f, 2.29793921e-01f,
  1.20395645e-01f, 2.03061044e-01f, 2.26804659e-01f, 1.29112184e-01f, 3.61459628e-02f, 5.04003130e-02f, -5.86419068e-02f, 2.52742320e-02f, 5.95435500e-01f, 4.22555357e-01f,
  -1.33635715e-01f, -4.04576182e-01f, -3.45520079e-01f, 9.20041800e-02f, -4.27528560e-01f, -8.54792833e-01f, -4.80372846e-01f, 4.54816580e-01f, 1.02185078e-01f, 3.76564562e-01f,
  6.25752732e-02f, 1.16275683e-01f, -1.56488270e-02f, 7.18308911e-02f, 9.44089815e-02f, 1.10222824e-01f, 1.19948953e-01f, 1.22861452e-01f, 1.25877902e-01f, 8.77188444e-02f,
  -4.20086607e-02f, -3.20528112e-02f, 2.94177860e-01f, 3.71390805e-02f, 2.07845166e-01f, 1.74608722e-01f, 2.97309412e-03f, -1.61667854e-01f, 1.00968048e-01f, 2.25707114e-01f,
  3.64529006e-02f, 8.12081397e-02f, -4.83439751e-02f, 9.65126008e-02f, 1.21283635e-01f, 8.62506330e-02f, 8.69394243e-02f, 6.88443482e-02f, 2.48765364e-01f, -2.10239172e-01f,
  -1.10149786e-01f, -4.67094146e-02f, 3.82152945e-01f, -6.73282370e-02f, -2.76984945e-02f, 1.52096495e-01f, 4.60950397e-02f, 1.28103644e-01f, 1.68614119e-01f, 2.48946827e-02f,
  -1.35214373e-01f, -2.74530172e-01f, -1.80596650e-01f, 2.95950919e-01f, 2.31159657e-01f, -3.86387497e-01f, 2.23589242e-01f, 2.95096099e-01f, 3.31997871e-02f, 3.11137855e-01f,
  2.10909113e-01f, -3.35892200e-01f, -1.37831289e-02f, 4.15128060e-02f, -1.74571827e-01f, 2.98453003e-01f, 5.29855974e-02f, -8.98206457e-02f, 3.04061592e-01f, -4.82355744e-01f,
  -3.16448569e-01f, -1.04819782e-01f, -4.42349464e-01f, -5.31388149e-02f, 1.83867797e-01f, 2.82877475e-01f, 5.88945784e-02f, -5.05503476e-01f, 2.71313101e-01f, 1.35761753e-01f,
  -5.92551101e-03f, 4.77423929e-02f, -3.33284922e-02f, -6.16334304e-02f, -1.48606747e-01f, -1.17264368e-01f, -7.65344381e-01f, -4.70417142e-02f, -1.86790928e-01f, 2.85024673e-01f,
  6.43660367e-01f, 4.69879955e-01f, -2.95103878e-01f, 4.50849771e-01f, 4.81674701e-01f, 5.82865894e-01f, 3.49273950e-01f, -3.83018970e-01f, -2.03856796e-01f, 3.45272630e-01f,
  -4.30015683e-01f, 6.02736294e-01f, -2.84052759e-01f, -1.07001685e-01f, 2.19593763e-01f, -6.10634804e-01f, -5.80013871e-01f, -5.65735817e-01f, -1.14612669e-01f, 1.74172118e-01f,
  6.47047758e-02f, -3.49491723e-02f, 2.80397773e-01f, -5.39932132e-01f, -3.12624007e-01f, 5.05145006e-02f, -2.04201698e-01f, -2.33382836e-01f, 4.88825366e-02f, -9.19926688e-02f,
  2.02882253e-02f, -4.89830285e-01f, 1.14790544e-01f, -4.84716803e-01f, 1.11004598e-01f, 2.18156427e-02f, -5.05189776e-01f, 4.32911068e-02f, -2.05125138e-01f, -1.47856057e-01f,
  -6.67087454e-03f, -7.79485106e-01f, -1.94408819e-01f, 2.92070657e-01f, 4.92696851e-01f, -3.79729509e-01f, 9.81406271e-02f, 2.28770629e-01f, -4.44546491e-02f, -7.08990842e-02f,
  7.53537714e-02f, -8.04360807e-02f, 1.31950989e-01f, 9.76581499e-02f, -1.01363927e-01f, -9.23656859e-03f, -2.35369518e-01f, -4.80917580e-02f, 7.09297061e-02f, 1.20837770e-01f,
  1.93738803e-01f, -1.25446737e-01f, -1.83362871e-01f, 7.79368505e-02f, 1.10964380e-01f, -3.12981545e-04f, -9.07148123e-02f, 4.29237410e-02f, -1.01768091e-01f, -1.14933580e-01f,
  7.84528330e-02f, -1.08014464e-01f, 2.86088530e-02f, -1.15792274e-01f, 7.70212933e-02f, -2.71970630e-01f, 1.63616091e-02f, -1.44638505e-03f, 7.97722414e-02f, 1.30621055e-02f,
  1.29812822e-01f, 1.40217006e-01f, 1.12981372e-01f, 7.95062035e-02f, -3.74256237e-03f, -3.75707522e-02f, 2.89055735e-01f, -1.49169624e-01f, 3.94991428e-01f, 3.57303023e-01f,
  -2.05486149e-01f, 2.45092198e-01f, -3.19186896e-01f, -4.96500731e-01f, 4.03836548e-01f, 3.20399404e-01f, -2.26209566e-01f, 1.10348076e-01f, -2.59298552e-02f, -2.04249606e-01f,
  -1.94836453e-01f, -1.18688293e-01f, 8.32463056e-02f, -9.46414843e-02f, -2.04767659e-01f, 2.57114053e-01f, -2.88978040e-01f, -2.13774592e-01f, 1.56884402e-01f, 2.71616250e-01f,
  6.48128763e-02f, -1.44990668e-01f, -3.53631973e-02f, -2.61049628e-01f, -1.64438292e-01f, -1.98920384e-01f, -1.85929433e-01f, -1.61483549e-02f, 1.03566404e-02f, -1.02125898e-01f,
  -4.82197246e-03f, 1.50844324e-02f, -2.34554514e-01f, 3.72479856e-01f, -7.49341445e-03f, 3.04928631e-01f, -1.83393762e-01f, 3.86907935e-01f, 3.40171576e-01f, -1.85767114e-01f,
  -2.96242416e-01f, -2.70929664e-01f, -1.07511379e-01f, -4.92794991e-01f, -2.31883720e-01f, -5.52303553e-01f, -2.39809956e-02f, 5.39138436e-01f, -1.45368963e-01f, -5.52470386e-01f,
  -4.37901020e-01f, -4.72073078e-01f, -5.36906660e-01f, -5.65316677e-01f, 3.79994184e-01f, -1.06631584e-01f, 3.41343492e-01f, -2.62135923e-01f, 1.47163838e-01f, -1.03678182e-01f,
  -3.58391017e-01f, 7.31454790e-02f, -3.39205950e-01f, -8.09622258e-02f, 3.09874177e-01f, -6.06107652e-01f, -1.62483439e-01f, -2.11486787e-01f, -5.07616997e-01f, -4.98923361e-01f,
  -3.62763435e-01f, -5.92315197e-01f, -2.47413725e-01f, 3.89528304e-01f, 4.74888116e-01f, -7.91574240e-01f, 5.09972155e-01f, -2.36680418e-01f, -9.87325385e-02f, -6.72248974e-02f,
  -5.71387947e-01f, -2.88996607e-01f, -1.26100004e-01f, -6.44258022e-01f, -2.38169506e-01f, -1.11785613e-01f, -9.96366795e-03f, -2.37356097e-01f, 3.49617116e-02f, -6.40549650e-03f,
  -9.93990824e-02f, -6.31230846e-02f, -1.48848459e-01f, -1.61189362e-01f, -3.35074514e-02f, -9.88340676e-02f, 4.64977957e-02f, -1.15881816e-01f, -3.32297593e-01f, -9.99220014e-02f,
  2.75203604e-02f, -1.16584182e-01f, -2.35562660e-02f, -2.41434842e-01f, -1.95569620e-02f, -1.69146061e-01f, -4.82994393e-02f, -1.33863673e-01f, 3.37308436e-03f, 2.86028385e-02f,
  -2.36803800e-01f, -7.45740235e-02f, -2.75353845e-02f, -5.44160679e-02f, -4.38034609e-02f, -1.76744640e-01f, -7.51840621e-02f, -7.57800192e-02f, -2.02209592e-01f, -1.18794344e-01f,
  -1.29958227e-01f, -9.75181609e-02f, -1.34147391e-01f, -9.91388317e-03f, -9.58138332e-02f, -1.45339906e-01f, 3.24538685e-02f, -1.72834367e-01f, 3.94238532e-02f, -2.14757711e-01f,
  -1.33044749e-01f, 2.15246025e-02f, -1.43344045e-01f, -2.49233082e-01f, -9.15296003e-02f, 1.64894536e-01f, -3.22939426e-01f, -1.87493175e-01f, 2.99522094e-02f, -1.20460533e-01f,
  1.79411530e-01f, -8.01955536e-02f, 4.00381573e-02f, 1.66192546e-01f, 2.79197454e-01f, 1.44438013e-01f, -1.82892144e-01f, 1.13707654e-01f, -1.67489856e-01f, -1.06678605e-01f,
  -9.64385271e-02f, 1.35390222e-01f, -2.01355532e-01f, -2.48610172e-02f, -1.06235676e-01f, 2.95604225e-02f, -1.04846090e-01f, -1.60669059e-01f, -5.83976507e-02f, 1.23800360e-01f,
  -5.62876388e-02f, -1.15583971e-01f, 1.72100723e-01f, 1.99819967e-01f, -1.22916065e-01f, 2.99722075e-01f, -1.62354469e-01f, -6.88170120e-02f, 7.75158480e-02f, -3.37805569e-01f,
  -1.18353233e-01f, 4.19633299e-01f, 4.22493845e-01f, -1.90607503e-01f, -2.36514017e-01f, -4.10209268e-01f, 1.41639009e-01f, 1.14622153e-01f, 4.73253489e-01f, -2.72293150e-01f,
  2.73702323e-01f, -3.41153920e-01f, 7.79487416e-02f, -3.35173458e-01f, -3.03365827e-01f, -4.08714175e-01f, -5.60645580e-01f, 1.22664705e-01f, -4.77722771e-02f, 1.99688658e-01f,
  9.31027532e-02f, -4.91368085e-01f, -3.78402114e-01f, -2.61301100e-01f, 9.91563722e-02f, -1.50259137e-01f, 4.29960676e-02f, -3.69786114e-01f, 2.30260149e-01f, 3.88974994e-01f,
  -7.63739944e-01f, -2.66581714e-01f, -2.06953257e-01f, 4.42639410e-01f, -8.03866163e-02f, -7.16610625e-02f, -2.56394744e-01f, 2.95731127e-01f, 3.39476466e-01f, 2.53886990e-02f,
  -4.45702136e-01f, -2.60374188e-01f, -6.41941652e-03f, -2.34019414e-01f, 2.51162916e-01f, -5.49855568e-02f, 1.87018514e-01f, -2.85586596e-01f, 3.76906730e-02f, 9.79530439e-02f,
  3.74241099e-02f, -3.01664043e-02f, -1.27932742e-01f, -2.91916788e-01f, -2.26620454e-02f, 2.93669164e-01f, -1.35604173e-01f, 1.74921587e-01f, -4.02342863e-02f, 1.66535124e-01f,
  -1.37554452e-01f, 9.12345424e-02f, 2.48405412e-02f, 1.13132857e-01f, 3.22186887e-01f, -1.91987082e-02f, -4.28980999e-02f, 6.15884624e-02f, 2.31793717e-01f, 3.50529291e-02f,
  -1.79715641e-02f, 1.51114479e-01f, -2.78935605e-03f, 1.58188522e-01f, 9.20101032e-02f, 1.04649045e-01f, -1.34729117e-01f, -1.61659330e-01f, 1.81585744e-01f, -5.64467534e-02f,
  5.88912182e-02f, 3.43655911e-03f, -1.61495775e-01f, 2.15983181e-03f, -3.48013081e-02f, 4.43807602e-01f, 4.05520827e-01f, 9.46935266e-02f, -3.14350039e-01f, 4.27097380e-01f,
  4.12498474e-01f, -3.05144876e-01f, -3.43300790e-01f, -7.63455499e-03f, 2.81167120e-01f, -3.03658605e-01f, 4.01714861e-01f, 1.71688184e-01f, 2.18641728e-01f, -1.68266892e-01f,
  -2.27286756e-01f, 1.71587065e-01f, -1.47460587e-02f, 3.74179155e-01f, -2.60643721e-01f, 2.37272874e-01f, -2.11748898e-01f, -2.18502283e-01f, -9.97562855e-02f, 1.13657266e-01f,
  4.32509422e-01f, 1.07511237e-01f, -9.43455622e-02f, 2.59789050e-01f, 1.65062010e-01f, -3.29495847e-01f, -3.94039035e-01f, -2.23290071e-01f, -2.69985855e-01f, -2.08301619e-01f,
  -3.47426504e-01f, -4.35802460e-01f, 1.21380948e-01f, -1.76411435e-01f, -1.55897602e-01f, -3.68628919e-01f, -1.17136136e-01f, -5.57247758e-01f, 7.22556114e-01f, 4.85153198e-02f,
  -3.61429214e-01f, -2.48168647e-01f, -3.60464245e-01f, -1.31785423e-01f, 4.46754068e-01f, -7.55889356e-01f, -2.73417085e-01f, -4.42842275e-01f, -2.27626905e-01f, -2.92002499e-01f,
  -4.03643139e-02f, -1.65080711e-01f, -4.87475067e-01f, -4.97180790e-01f, 4.62431192e-01f, -1.52830735e-01f, 3.08638662e-01f, -8.93618092e-02f, 2.36827210e-01f, -4.31950875e-02f,
  1.00222401e-01f, -3.69460732e-01f, 6.89707547e-02f, -7.74533898e-02f, -2.30086789e-01f, -6.75080538e-01f, 7.94158280e-02f, -4.05487329e-01f, -1.96475849e-01f, -4.14761931e-01f,
  -2.85769761e-01f, -2.83980280e-01f, 1.79718316e-01f, -2.69989558e-02f, 3.21572185e-01f, -7.74201304e-02f, 7.50811398e-01f, -5.54515541e-01f, -2.44019359e-01f, -4.89739418e-01f,
  4.56902534e-02f, -1.28397882e-01f, -4.74072732e-02f, 3.68149988e-02f, 1.28127187e-01f, 2.98553314e-02f, -4.34607565e-02f, 8.55627209e-02f, 1.36379972e-01f, -3.11683081e-02f,
  7.59743601e-02f, -1.58378586e-01f, -3.76744680e-02f, 8.72426182e-02f, 1.00526154e-01f, -7.99040571e-02f, -2.25049376e-01f, -1.68173030e-01f, -5.49143888e-02f, 1.71743743e-02f,
  4.79000099e-02f, 1.18749313e-01f, -6.77088872e-02f, 1.48027344e-02f, 8.58786851e-02f, 2.37342656e-01f, -4.59760651e-02f, -8.53660181e-02f, -7.32711796e-03f, -4.96652462e-02f,
  2.54642181e-02f, 1.74412593e-01f, -1.00362316e-01f, -8.20809789e-03f, -1.06741376e-01f, -1.64033368e-01f, 2.31151679e-03f, -4.16530389e-03f, 8.23863596e-02f, -3.10592819e-02f,
  -6.64780140e-02f, -1.78707615e-01f, -3.32710952e-01f, -3.17217827e-01f, -1.85152546e-01f, -3.45381290e-01f, 2.95612752e-01f, 3.97378892e-01f, -1.28104985e-01f, 1.72788978e-01f,
  1.90010011e-01f, 1.78814009e-01f, 1.14787266e-01f, -1.14030086e-01f, -2.41107702e-01f, -2.03654438e-01f, -2.87989825e-01f, 8.63136947e-02f, 1.89993277e-01f, -4.14422691e-01f,
  -1.27655372e-01f, -2.50949651e-01f, -1.20424420e-01f, -1.21351048e-01f, -3.64126444e-01f, -1.10088758e-01f, -1.64514482e-01f, -2.63022393e-01f, 8.73778313e-02f, 1.29146859e-01f,
  3.78063023e-02f, 7.51800388e-02f, -2.86167711e-01f, -1.85055926e-01f, 6.60226718e-02f, 1.12511165e-01f, -5.42883426e-02f, 1.58806473e-01f, -1.12357810e-01f, 2.74596870e-01f,
  -2.22845167e-01f, -3.10838550e-01f, 1.71032205e-01f, -1.90424085e-01f, 1.93981797e-01f, -3.38012248e-01f, -4.98249047e-02f, -8.27789783e-01f, -7.95379043e-01f, 4.35928315e-01f,
  -1.53092474e-01f, 1.94789529e-01f, -2.89127499e-01f, 5.86137891e-01f, 4.63943511e-01f, -3.80481035e-01f, -1.64115965e-01f, 4.92557101e-02f, 9.56041664e-02f, -8.19773316e-01f,
  -7.82480240e-01f, -1.72567323e-01f, -5.00750721e-01f, 7.28303567e-02f, -2.77776659e-01f, 4.87680078e-01f, -3.30865681e-01f, 2.91046679e-01f, 1.20936312e-01f, 1.05997324e-02f,
  -4.92325187e-01f, -3.54358137e-01f, 3.61555904e-01f, -2.15873823e-01f, 6.71941862e-02f, -2.05659911e-01f, 5.56305766e-01f, -1.26297116e-01f, 4.03338671e-01f, 7.95005143e-01f,
  -2.05274582e-01f, -4.70537424e-01f, 1.40432343e-01f, 4.46498804e-02f, -3.99164826e-01f, 2.45606303e-02f, -2.80075908e-01f, 2.01590568e-01f, -2.97609806e-01f, -4.44369614e-01f,
  -1.05962358e-01f, 9.03687850e-02f, -8.95256698e-02f, 3.52508686e-02f, -8.26690998e-03f, 8.30270872e-02f, 2.00328350e-01f, -4.87795323e-02f, 3.58415954e-02f, 7.94797912e-02f,
  -4.86844964e-02f, 4.47880477e-03f, 1.33438677e-01f, -4.99984948e-03f, -6.53866306e-02f, 6.66015744e-02f, 1.40579656e-01f, -1.09909298e-02f, 1.21848591e-01f, -1.37341827e-01f,
  2.97538965e-04f, 1.06734671e-01f, 1.79773226e-01f, 8.41191038e-02f, 1.19508058e-02f, 1.41685065e-02f, 1.80916131e-01f, -2.76371427e-02f, 1.04424410e-01f, 4.27636467e-02f,
  -4.77957539e-02f, 5.61889559e-02f, 9.49902385e-02f, 3.23797576e-04f, 2.49198009e-03f, 4.88154553e-02f, 1.20585144e-01f, -4.71433662e-02f, 3.75420719e-01f, 1.75198913e-01f,
  -2.94604093e-01f, -6.67770132e-02f, -3.28787684e-01f, 2.78831720e-01f, 5.97968251e-02f, 4.02358651e-01f, 2.35275373e-01f, -2.59740204e-01f, 1.99436381e-01f, 3.62091124e-01f,
  8.32173079e-02f, 3.07083786e-01f, 1.66201085e-01f, -3.01084280e-01f, 3.43049675e-01f, -1.31072402e-01f, -2.16144800e-01f, -3.26505572e-01f, 2.53560990e-01f, 3.45545322e-01f,
  -1.94603708e-02f, -2.68955052e-01f, 7.50668123e-02f, 2.74537116e-01f, -1.83585092e-01f, -3.36532921e-01f, 2.05837831e-01f, 1.87207922e-01f, 1.11490779e-01f, -2.74590164e-01f,
  4.37435284e-02f, 1.87466547e-01f, 3.26438248e-02f, -2.01541334e-01f, -9.49773639e-02f, 3.62732321e-01f, -4.25345629e-01f, 3.84997874e-02f, -3.34819168e-01f, 2.46290453e-02f,
  -6.04587853e-01f, 6.11110270e-01f, 6.71359524e-02f, 2.45114356e-01f, -5.13306022e-01f, 2.49513924e-01f, -4.75954175e-01f, -1.32294774e-01f, -2.23360956e-01f, -5.80868363e-01f,
  4.90561068e-01f, -5.06178677e-01f, -3.51820737e-01f, 4.60214823e-01f, 7.93466866e-02f, -6.34695113e-01f, -7.24765807e-02f, 2.67346621e-01f, -3.72299612e-01f, -6.55916512e-01f,
  -4.08341467e-01f, -4.69128698e-01f, -3.80172394e-02f, -8.16702247e-02f, -3.19643974e-01f, -3.57993633e-01f, -3.79752010e-01f, -4.17969853e-01f, -3.39494526e-01f, 1.12148106e-01f,
  -4.95344669e-01f, 4.11982894e-01f, 4.91586924e-01f, -4.85863775e-01f, -3.58032137e-01f, -1.98459655e-01f, -2.91013390e-01f, 1.49396017e-01f, -2.66755372e-01f, 4.76320446e-01f,
  -1.42461121e-01f, -3.37789446e-01f, -2.63948649e-01f, -3.00694138e-01f, -1.10129587e-01f, 4.14572656e-01f, -1.23747304e-01f, 4.50435698e-01f, 4.48675379e-02f, 1.19193103e-02f,
  -6.15713932e-02f, 8.09228867e-02f, 5.05402982e-02f, 8.58608559e-02f, 9.67905447e-02f, 4.04919647e-02f, 1.61029994e-01f, 3.74583267e-02f, -1.04414701e-01f, -2.65345067e-01f,
  -1.10517614e-01f, 1.20065786e-01f, 3.41086425e-02f, 9.03994069e-02f, 3.43809575e-02f, 7.61839673e-02f, 1.08401002e-02f, -1.73574239e-01f, 1.48476079e-01f, 1.25686035e-01f,
  1.52987301e-01f, -4.26227711e-02f, 8.43878537e-02f, -2.73280516e-02f, -1.27020869e-02f, 1.57312259e-01f, -2.07454845e-01f, 6.18727989e-02f, 4.37046364e-02f, -4.96197380e-02f,
  5.61293513e-02f, -5.75479195e-02f, 2.17949953e-02f, 9.47578326e-02f, -3.96180302e-02f, 9.72096771e-02f, -3.06372851e-01f, -2.30372131e-01f, 3.08211595e-01f, 1.24148011e-01f,
  3.55175018e-01f, -2.45302528e-01f, -1.05138151e-02f, -2.15880081e-01f, -2.05758363e-01f, 1.24646793e-03f, -2.60827273e-01f, -4.55576390e-01f, -3.69241446e-01f, 2.26878643e-01f,
  -2.89285362e-01f, -2.85258085e-01f, 2.72444487e-02f, 2.83107132e-01f, -1.29575565e-01f, 3.88997018e-01f, 1.23984918e-01f, 2.73829550e-01f, 2.78858393e-01f, 6.52917102e-02f,
  -6.70758858e-02f, -1.16158657e-01f, -2.45240759e-02f, 7.18119321e-03f, -4.10456181e-01f, -2.20289886e-01f, -1.00155644e-01f, 9.80231166e-02f, -1.50997847e-01f, -1.95134923e-01f,
  -7.73679614e-02f, -3.18974137e-01f, -1.09811336e-01f, -7.22964108e-02f, -4.40127075e-01f, -1.05176289e-02f, -7.60369971e-02f, -4.49360043e-01f, 2.02557907e-01f, -6.17170557e-02f,
  -5.08169889e-01f, -3.86054784e-01f, -2.75490671e-01f, -5.57309985e-01f, 4.29405347e-02f, -1.60245955e-01f, 3.04401040e-01f, -2.52481729e-01f, 1.77588791e-01f, 4.87648726e-01f,
  -3.47126603e-01f, -2.20762148e-01f, 1.97410196e-01f, -1.71994805e-01f, -4.28126812e-01f, -1.69516981e-01f, 5.25008380e-01f, -6.76896647e-02f, 4.35872495e-01f, -3.42173457e-01f,
  3.44595574e-02f, -2.73435205e-01f, 1.71511874e-01f, 3.66495639e-01f, 1.41129479e-01f, -3.31781864e-01f, 1.46653041e-01f, -3.08019459e-01f, -2.55290508e-01f, 6.66045845e-01f,
  -7.03810811e-01f, 7.49389470e-01f, -1.26480684e-01f, 1.32696971e-01f, -9.41529125e-02f, -6.20661199e-01f, -3.87146682e-01f, -1.04289465e-01f, -2.59848267e-01f, -3.53891939e-01f,
  -4.83849466e-01f, -5.19173443e-01f, -2.12076038e-01f, 4.84589100e-01f, -1.95210859e-01f, -4.84839410e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.55961537e-01f, 1.59706995e-01f, 7.62786046e-02f, -7.11559653e-02f, -3.18288840e-02f, -4.60248888e-02f, 4.06506099e-02f, -9.72535238e-02f, 1.53984860e-01f, 1.08484685e-01f,
  1.50481746e-01f, 9.47645083e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    