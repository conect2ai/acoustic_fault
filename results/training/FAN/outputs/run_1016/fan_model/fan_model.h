/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.55515051e-01f, 3.31310660e-01f, 3.07350725e-01f, -1.53960720e-01f, -2.67135590e-01f, -5.45041300e-02f, 2.06617013e-01f, 6.35562697e-03f, -2.42843568e-01f, -3.98151726e-02f,
  -1.37206495e-01f, -2.32506201e-01f, 2.53284443e-02f, -9.90463328e-03f, 1.40355602e-01f, 3.96496624e-01f, 3.63430679e-01f, 6.13469854e-02f, -4.14874613e-01f, -4.28731084e-01f,
  -2.33542904e-01f, -1.68822140e-01f, -1.69179291e-01f, 5.91261219e-03f, -6.24191575e-03f, -7.08398223e-02f, 4.76775497e-01f, 5.12155034e-02f, 2.06105530e-01f, 1.54304147e-01f,
  -1.87545761e-01f, -4.93378192e-02f, -1.07228704e-01f, -1.31025091e-01f, -1.61457453e-02f, -1.05773769e-01f, -3.84044461e-02f, 4.33073901e-02f, -1.07803799e-01f, -5.76915741e-02f,
  -9.94572043e-02f, -7.87834302e-02f, -9.00206417e-02f, -7.55253881e-02f, -1.81583717e-01f, -1.53593585e-01f, 6.93147480e-02f, -1.87740289e-02f, 6.74781874e-02f, -1.53756350e-01f,
  -3.92915979e-02f, -1.44997939e-01f, -6.21001087e-02f, -1.68842878e-02f, 3.08840815e-02f, -9.40483883e-02f, 4.29616012e-02f, -1.65925518e-01f, -1.14605308e-03f, -1.20672964e-01f,
  -2.31736954e-02f, -8.40035453e-03f, 6.26945728e-03f, 7.02827200e-02f, 5.52491583e-02f, 6.19156621e-02f, 5.54826595e-02f, -2.27512717e-02f, -4.32687737e-02f, 2.61604562e-02f,
  -8.67189653e-03f, 4.08546403e-02f, -4.68182974e-02f, 1.25952214e-01f, -2.43914104e-03f, -2.65881512e-02f, 1.38251688e-02f, 7.48259351e-02f, 2.58683842e-02f, -2.19027437e-02f,
  -1.13601442e-02f, 3.67135219e-02f, 5.81397191e-02f, 1.76180340e-02f, 1.37102544e-01f, 4.93344180e-02f, -9.48619912e-04f, 9.18780081e-03f, 3.26773189e-02f, 2.03495808e-02f,
  -1.10055894e-01f, 1.03157111e-01f, -1.54276907e-01f, -1.36884540e-01f, -7.31475055e-02f, 1.75079163e-02f, -1.10846832e-01f, -6.22086972e-02f, -4.75038849e-02f, -1.52477399e-01f,
  -1.52074069e-01f, -1.28638104e-01f, 5.49617186e-02f, -9.81236324e-02f, -2.39022732e-01f, -1.31094590e-01f, -4.88597117e-02f, -6.30290583e-02f, -9.97674912e-02f, -1.12412438e-01f,
  7.05912635e-02f, -2.11671323e-01f, -2.67620265e-01f, -7.79503733e-02f, -1.61394134e-01f, -1.58614278e-01f, -7.29834288e-03f, -9.09319744e-02f, -6.48036748e-02f, -8.81015614e-04f,
  -5.41336596e-01f, -1.48861185e-01f, 2.10711025e-02f, -1.12410404e-01f, 1.89652681e-01f, 2.18417898e-01f, 3.54835957e-01f, 8.00641626e-02f, -1.74052015e-01f, -1.38420165e-01f,
  -4.87377606e-02f, -2.39609063e-01f, -1.55102864e-01f, -8.41008350e-02f, -9.14925337e-02f, 1.44550860e-01f, 7.01655149e-02f, -7.44777843e-02f, -3.98321711e-02f, 2.41916180e-02f,
  -6.92724735e-02f, -1.49056271e-01f, -1.70982257e-01f, -1.49724722e-01f, -1.86733216e-01f, -1.65428743e-01f, -9.34903473e-02f, -2.08325803e-01f, 3.61663513e-02f, -2.27957100e-01f,
  -3.74196768e-01f, -4.02209789e-01f, -5.51323593e-02f, -1.33853152e-01f, -1.68782234e-01f, -2.48564020e-01f, -1.68888390e-01f, -2.16632232e-01f, -1.11415662e-01f, -7.87918642e-02f,
  -1.30901158e-01f, -2.02695057e-01f, -1.66143313e-01f, -2.30322346e-01f, -1.40823543e-01f, -1.93130836e-01f, -1.33693531e-01f, -1.91000968e-01f, -1.32663503e-01f, -2.41185829e-01f,
  -5.34679815e-02f, -1.25287786e-01f, -1.21265285e-01f, -8.95308927e-02f, -1.77125677e-01f, -4.78173979e-02f, -2.02600434e-01f, -2.43289694e-01f, -1.58211336e-01f, -3.28253388e-01f,
  1.34622797e-01f, 1.34900331e-01f, 2.22265095e-01f, 1.21254690e-01f, 1.54873416e-01f, 2.26090983e-01f, 2.06389323e-01f, 1.33589223e-01f, 2.49680340e-01f, 1.48095727e-01f,
  6.42003492e-02f, 1.73725992e-01f, 1.07701339e-01f, 1.00903295e-01f, 1.75340071e-01f, 2.19375491e-01f, 1.96888432e-01f, 1.32028535e-01f, 7.02478364e-02f, 1.37144744e-01f,
  1.94449782e-01f, 1.68799087e-01f, 1.35216400e-01f, 6.88950941e-02f, 9.29747969e-02f, 1.34044811e-01f, 1.72365755e-01f, 8.91177356e-02f, 6.59690946e-02f, 1.64395422e-01f,
  -2.51525283e-01f, 7.01144412e-02f, -2.08806053e-01f, -2.53995329e-01f, -1.16336189e-01f, -2.24096477e-01f, -2.35900059e-01f, -1.56458095e-01f, -1.40948817e-01f, -1.70861766e-01f,
  -1.41840592e-01f, -1.76455289e-01f, -1.81741267e-01f, -1.83077633e-01f, -8.02367274e-03f, -1.23396918e-01f, -1.64838225e-01f, -1.26302809e-01f, -8.57554004e-02f, -1.90951630e-01f,
  -1.11916646e-01f, 3.38760130e-02f, 9.12038386e-02f, -2.55955849e-02f, -7.93615803e-02f, -5.09746112e-02f, 2.44452823e-02f, -4.80373725e-02f, 1.14601674e-02f, -5.41675054e-02f,
  1.27294958e-01f, -4.53129411e-01f, 1.18889540e-01f, 7.86646008e-02f, -1.61645606e-01f, -3.08022469e-01f, -5.41566312e-01f, -3.24175805e-01f, -4.04809453e-02f, -2.47715730e-02f,
  -1.10291578e-01f, 1.28230035e-01f, 1.79952428e-01f, 1.90541670e-01f, -7.01043755e-02f, -1.58389136e-01f, -1.94317117e-01f, 1.61356851e-01f, 2.54884541e-01f, 1.02940470e-01f,
  1.20564764e-02f, 6.10277019e-02f, 2.47124329e-01f, 8.03182274e-02f, 1.65711433e-01f, 2.47309834e-01f, -1.93751268e-02f, 9.78643671e-02f, 1.08957201e-01f, 3.36781383e-01f,
  4.52373296e-01f, -2.31715187e-01f, 1.31348759e-01f, -5.48551157e-02f, -5.75137399e-02f, 8.24039709e-03f, 5.05397189e-03f, 1.16333522e-01f, -2.99173105e-03f, 5.70430830e-02f,
  3.61137744e-03f, 5.88531494e-02f, -1.94406777e-03f, 5.79731166e-02f, -1.03298761e-01f, -1.83768086e-02f, -2.06108224e-02f, 2.58712620e-02f, -6.13979883e-02f, -3.35102975e-02f,
  -1.01534516e-01f, -6.14396483e-02f, -1.69413865e-01f, -1.37811139e-01f, -1.51068136e-01f, -7.82076716e-02f, -3.34141850e-02f, 1.98188480e-02f, 4.75553833e-02f, 2.09570043e-02f,
  4.92256470e-02f, 1.28678277e-01f, 8.81932452e-02f, 2.53326390e-02f, -4.31927145e-02f, 3.06358039e-02f, 1.95382070e-02f, 6.81691840e-02f, 8.76059756e-02f, 7.04902932e-02f,
  7.37428889e-02f, -2.29198784e-02f, -3.59971225e-02f, 3.27699408e-02f, 1.28510714e-01f, 6.70820400e-02f, 8.10936615e-02f, 7.73732737e-02f, 5.80598935e-02f, 6.04330450e-02f,
  3.13007496e-02f, 8.93535838e-02f, 6.86512664e-02f, 1.27339527e-01f, 8.01770575e-03f, 9.99737680e-02f, 1.57120317e-01f, 8.47273692e-02f, 8.07124749e-02f, -4.60655848e-03f,
  1.46976069e-01f, -1.90090984e-01f, 1.71609849e-01f, 9.58956704e-02f, 7.09782690e-02f, -6.01880392e-03f, 8.30538422e-02f, -1.26287248e-03f, -6.01332374e-02f, -9.49569687e-04f,
  -2.80631501e-02f, -3.65739204e-02f, -1.02791330e-02f, 1.31933898e-01f, 8.57884213e-02f, 2.72982046e-02f, 1.13165295e-02f, 8.54230076e-02f, -2.40642242e-02f, -5.25551550e-02f,
  -1.16516970e-01f, -9.81814042e-02f, -2.82002869e-03f, -6.58087581e-02f, -4.38148901e-02f, 2.21971013e-02f, 1.10748276e-01f, 1.03400443e-02f, 4.42982391e-02f, 6.11903220e-02f,
  7.00032711e-01f, -3.56584698e-01f, -4.59478259e-01f, 2.17363298e-01f, -2.43179232e-01f, -3.19842666e-01f, -3.39824051e-01f, 1.55108243e-01f, 1.32878616e-01f, -2.13787481e-01f,
  -3.04749101e-01f, 1.92987666e-01f, -3.68900076e-02f, 7.66831711e-02f, 1.30646899e-01f, -3.35867196e-01f, -1.98074952e-01f, 1.61407858e-01f, 4.29538518e-01f, 2.25196630e-01f,
  1.36075646e-01f, 3.06924820e-01f, 2.33564645e-01f, 2.29680732e-01f, -2.71749478e-02f, 6.50275080e-03f, -3.21137130e-01f, -2.16100663e-01f, -2.89408892e-01f, -1.44253209e-01f,
  -1.61468938e-01f, -8.51423070e-02f, 2.18888655e-01f, 1.09058604e-01f, 2.22871569e-03f, 1.18250750e-01f, 5.78563809e-02f, 1.28823876e-01f, 9.42087546e-02f, 1.30733579e-01f,
  -4.94134463e-02f, 1.30811021e-01f, 1.47368684e-01f, 9.09696445e-02f, 1.71205103e-01f, 8.28377977e-02f, 1.52396202e-01f, 1.75556526e-01f, 1.24908127e-01f, 5.41441096e-03f,
  -9.22702998e-03f, 6.81282766e-03f, -1.16680540e-01f, -4.90621775e-02f, 4.21492718e-02f, 3.16917896e-02f, -9.53480303e-02f, 1.28421590e-01f, 1.10106785e-02f, 1.39537379e-01f,
  6.11284897e-02f, -9.87221971e-02f, -6.67094141e-02f, 2.55919364e-03f, -8.29667333e-05f, -9.55028608e-02f, -5.47709242e-02f, -2.64607184e-02f, 4.40541655e-02f, -1.83218922e-02f,
  8.47736746e-03f, -4.99708429e-02f, 4.63401936e-02f, -4.09291871e-02f, 2.38419436e-02f, -4.86198924e-02f, 1.22677744e-03f, 4.89993654e-02f, -3.34372884e-03f, 4.26057205e-02f,
  4.00837101e-02f, -3.74123789e-02f, -1.62357911e-02f, 1.08282946e-01f, -3.55215296e-02f, 3.03169899e-03f, -5.23180561e-03f, 1.84858181e-02f, -7.86408037e-03f, -1.84080601e-02f,
  2.99339533e-01f, -3.73680107e-02f, 6.15246594e-02f, 1.42753527e-01f, -3.98829281e-02f, 2.43715234e-02f, 4.44637425e-02f, 1.36239994e-02f, 2.44155852e-03f, 1.83087066e-01f,
  -1.59354527e-02f, 6.13893047e-02f, -3.40637788e-02f, 2.76354086e-02f, 1.08724676e-01f, 6.65063486e-02f, 4.43217643e-02f, 8.35146382e-02f, -1.64024606e-02f, -4.01081555e-02f,
  2.79325340e-02f, 8.82813856e-02f, 1.00127757e-01f, 6.34269789e-02f, 4.65609021e-02f, 8.83403197e-02f, -1.07260540e-01f, 1.01123750e-01f, 5.71806096e-02f, 1.11920610e-01f,
  9.86414626e-02f, -1.02691598e-01f, 1.17717370e-01f, 2.09062696e-01f, -2.23921940e-01f, -3.29096556e-01f, -3.06854278e-01f, -8.77831951e-02f, 1.11276440e-01f, -1.08805634e-01f,
  6.74219355e-02f, 1.33751258e-01f, 2.41665281e-02f, 1.38256093e-02f, -4.06152569e-02f, -2.38166526e-01f, -1.44603014e-01f, 1.29853422e-02f, 3.41380872e-02f, -7.13749304e-02f,
  -5.56301959e-02f, 1.99633807e-01f, 3.49367023e-01f, 4.05703411e-02f, -1.62439480e-01f, -2.65730977e-01f, -2.69547421e-02f, -1.02760017e-01f, -2.17351809e-01f, -2.56821960e-01f,
  7.50306249e-02f, 1.55774340e-01f, -5.90396347e-03f, 1.00545429e-01f, 8.35026801e-02f, -6.49444610e-02f, -1.37606857e-03f, 9.89106894e-02f, 7.93700963e-02f, 7.05806389e-02f,
  8.89858827e-02f, 2.20354553e-02f, 6.11305721e-02f, 2.05466002e-02f, 9.79355872e-02f, 5.25372662e-02f, 1.42609119e-01f, 2.38453642e-01f, 4.21506651e-02f, 6.28994033e-02f,
  3.37965563e-02f, 3.98820750e-02f, -8.53529666e-04f, -3.65688764e-02f, 2.70100832e-02f, -7.00327531e-02f, 1.50679108e-02f, -7.99000412e-02f, -3.08074784e-02f, -8.93970504e-02f,
  -1.62169412e-01f, 5.47499172e-02f, 1.24707343e-02f, 4.69237715e-02f, -1.25688076e-01f, -5.15464731e-02f, -4.93526012e-02f, -6.28385097e-02f, -4.33074310e-02f, 2.79670525e-02f,
  -1.69595163e-02f, -4.76660468e-02f, -1.34969258e-03f, -6.16968423e-02f, -1.26695568e-02f, -1.69039760e-02f, -1.09041691e-01f, -4.56525721e-02f, -6.17256239e-02f, 4.05726954e-03f,
  7.66894296e-02f, -1.05437957e-01f, -6.53327629e-03f, -9.51962769e-02f, 2.74077859e-02f, -3.43446881e-02f, 2.17927508e-02f, 1.03795990e-01f, 1.82513949e-02f, 6.99770600e-02f,
  3.03844780e-01f, 3.93668152e-02f, -6.41583502e-02f, 2.24946085e-02f, 7.30698346e-04f, 8.68570954e-02f, -8.58995393e-02f, 1.28734916e-01f, 9.45428386e-03f, 1.59759242e-02f,
  6.23489097e-02f, -2.89144479e-02f, 1.01720113e-02f, 2.29945909e-02f, -1.09862328e-01f, -7.56464666e-03f, 5.11670336e-02f, -1.00132704e-01f, 4.52192314e-02f, 2.49947663e-02f,
  2.95124818e-02f, -1.11334026e-01f, -6.65407479e-02f, -1.56419173e-01f, -7.50343278e-02f, -1.55427203e-01f, -1.51725501e-01f, -2.07186624e-01f, -2.49803245e-01f, -2.18604624e-01f,
  5.47126472e-01f, -2.57289886e-01f, 1.92240104e-02f, -3.62026803e-02f, -4.92287546e-01f, -4.32069182e-01f, -4.16549206e-01f, -1.38326198e-01f, -9.28656086e-02f, -1.63181439e-01f,
  -2.43959039e-01f, -8.21104124e-02f, -1.34967603e-02f, 5.75770736e-02f, 1.79561004e-02f, -1.62301153e-01f, -1.79646909e-01f, 1.81639224e-01f, 2.40693495e-01f, -7.39750341e-02f,
  -1.67970896e-01f, 8.83070901e-02f, 3.22678268e-01f, 9.14916769e-02f, -8.53956416e-02f, 2.40583140e-02f, -6.06050454e-02f, -1.39210960e-02f, -1.52508408e-01f, 9.93131027e-02f,
  1.85614750e-01f, 4.84774308e-03f, -1.33200856e-02f, 5.92480637e-02f, -1.41870007e-01f, 9.01143551e-02f, -1.01614460e-01f, -7.63907563e-04f, -8.70065838e-02f, -2.48397272e-02f,
  -1.09015100e-01f, -2.33546961e-02f, -6.69834167e-02f, -3.87949683e-02f, -5.84423728e-02f, -4.57861312e-02f, 9.47733745e-02f, 8.45510811e-02f, 5.47726192e-02f, -1.06224380e-01f,
  -1.09144025e-01f, -1.72261015e-01f, -8.87432024e-02f, -4.69656959e-02f, -1.27734700e-02f, -4.93230149e-02f, -9.59574208e-02f, 3.09211686e-02f, 9.70333144e-02f, 2.63886899e-01f,
  4.34366008e-03f, -5.28700091e-02f, -4.16782461e-02f, -1.24762831e-02f, -2.69730128e-02f, -3.84307839e-02f, -7.56854564e-02f, -6.39494834e-03f, 2.88152546e-02f, 9.76264551e-02f,
  2.13585291e-02f, 4.90257740e-02f, 1.54336367e-03f, 6.63644895e-02f, 1.08772554e-01f, 5.63714877e-02f, 7.45649217e-03f, 8.20384249e-02f, 4.11221758e-02f, 9.14519802e-02f,
  7.58190304e-02f, -1.88269056e-02f, 8.79566744e-02f, 8.07958171e-02f, 2.96382718e-02f, 4.91435453e-02f, 5.40255047e-02f, 7.04523474e-02f, 1.16578445e-01f, 6.50327057e-02f,
  2.16016799e-01f, -2.67455518e-01f, 5.48923537e-02f, -6.44682301e-03f, -1.70361642e-02f, -4.77067055e-03f, -1.46770656e-01f, -4.18378077e-02f, -1.14544071e-01f, -1.04613036e-01f,
  -1.47968471e-01f, 3.29438713e-03f, -6.84257820e-02f, -1.45355286e-02f, -8.93806592e-02f, -1.00618839e-01f, -9.42969173e-02f, -2.80649737e-02f, -1.21251851e-01f, -4.66329195e-02f,
  -1.05234936e-01f, -1.06598763e-02f, 7.65339807e-02f, -6.72235489e-02f, -9.21884105e-02f, -1.04536731e-02f, -1.23880520e-01f, 3.71896401e-02f, 3.87648270e-02f, 1.16492443e-01f,
  -4.19985019e-02f, 6.29807413e-01f, -5.80114499e-02f, -1.39462985e-02f, -2.17952430e-02f, -2.55089074e-01f, 2.38393098e-01f, -1.52832150e-01f, -7.18056113e-02f, 3.59684229e-01f,
  3.64585429e-01f, 5.08004874e-02f, 6.98266700e-02f, -5.11343926e-02f, -1.86918333e-01f, 2.90553749e-01f, -3.52891833e-02f, -3.43772560e-01f, -5.45663834e-01f, -1.12572387e-01f,
  1.79818839e-01f, 1.33038834e-02f, -6.10880181e-02f, -1.17560633e-01f, 9.08812582e-02f, -8.09599012e-02f, 9.74870548e-02f, -5.72991818e-02f, 1.68355793e-01f, 3.69227856e-01f,
  1.15453102e-01f, 7.65889212e-02f, -1.49410129e-01f, 8.05861354e-02f, 1.01549059e-01f, 2.58289054e-02f, 1.08023070e-01f, 1.51643634e-01f, 5.96187189e-02f, 1.47064641e-01f,
  3.35640721e-02f, 4.79863696e-02f, 6.07382692e-02f, 1.55269861e-01f, 1.24492981e-01f, 7.16682002e-02f, 2.49191485e-02f, -7.44038150e-02f, 3.73602621e-02f, 1.82057425e-01f,
  3.00271869e-01f, 1.90179750e-01f, 2.51125451e-02f, -4.65825349e-02f, -6.61384389e-02f, -1.29488215e-01f, 9.20955241e-02f, 1.24886213e-02f, -1.46563679e-01f, 2.20602751e-01f,
  -3.90751660e-02f, 4.72559482e-02f, -1.18979678e-01f, -5.51373092e-03f, -1.74545422e-02f, -9.44771916e-02f, -3.28710116e-03f, -3.78603004e-02f, -1.25035271e-01f, -5.72559014e-02f,
  -3.47626470e-02f, 4.34311712e-03f, 1.36370771e-02f, 1.69794969e-02f, -2.11089831e-02f, 7.80205382e-03f, -3.70064676e-02f, 3.39319780e-02f, 3.39698568e-02f, 3.38281766e-02f,
  1.00687041e-03f, -1.13818601e-01f, -3.69613618e-02f, 2.56772665e-03f, -6.63810372e-02f, -3.52089666e-02f, -5.01045957e-02f, -2.78993174e-02f, -1.55902877e-02f, -5.16217726e-04f,
  1.43342748e-01f, -1.42885625e-01f, 1.41019821e-01f, 6.33688867e-02f, 8.46853405e-02f, 9.36337113e-02f, 1.49285913e-01f, 1.22914419e-01f, 1.53969824e-01f, 1.55351445e-01f,
  4.72144298e-02f, -1.75226852e-02f, 1.02514230e-01f, 1.27396852e-01f, 4.05925326e-03f, 5.72440103e-02f, 2.16727108e-01f, 3.97171266e-02f, -3.06075159e-02f, 1.71258047e-01f,
  1.15042530e-01f, 2.34304257e-02f, 5.13770171e-02f, 1.15334533e-01f, -4.10514176e-02f, -6.97584227e-02f, 7.96004608e-02f, -1.81809049e-02f, -1.06081158e-01f, 3.12567532e-01f,
  -2.32218191e-01f, 1.96029887e-01f, -2.85533160e-01f, -3.04899085e-03f, 2.25450516e-01f, 2.04102799e-01f, 1.05625458e-01f, -6.37118742e-02f, -1.12349335e-02f, 5.80406450e-02f,
  4.41094249e-01f, 1.68750882e-01f, -6.52385131e-02f, -1.99133202e-01f, -3.67705256e-01f, -3.68459225e-01f, -4.44332987e-01f, -4.54525650e-01f, -3.25380445e-01f, 5.06223068e-02f,
  1.51180953e-01f, -1.00751512e-01f, -1.78848401e-01f, -1.27343610e-01f, 3.90364490e-02f, -8.17707404e-02f, 3.87747176e-02f, 6.43934757e-02f, 1.38874382e-01f, -2.10500732e-01f,
  -8.58147219e-02f, 1.03448935e-01f, -1.57540888e-02f, -7.57061988e-02f, 3.83355208e-02f, -9.53428969e-02f, -3.48900035e-02f, 1.94439199e-02f, 5.71963005e-02f, -7.37647489e-02f,
  8.86729658e-02f, 1.42533943e-01f, 3.10965981e-02f, 2.96855234e-02f, -2.83141211e-02f, 1.07512496e-01f, -4.26346175e-02f, -1.69774503e-01f, -1.28756508e-01f, 6.49254993e-02f,
  1.37171522e-01f, 8.10139552e-02f, -2.65692156e-02f, -3.32585024e-03f, -1.01345204e-01f, -5.31381704e-02f, -7.97014777e-03f, 7.75165251e-03f, -2.71881726e-02f, -1.10370673e-01f,
  -1.75494095e-03f, -9.79694724e-02f, -4.66734543e-02f, 9.39450040e-02f, 1.51434103e-02f, 3.76657620e-02f, -7.40865618e-02f, -9.71247703e-02f, -1.29867762e-01f, -9.12354793e-03f,
  4.35123295e-02f, 1.57238841e-02f, -6.79637119e-02f, -8.95310864e-02f, -3.08031775e-02f, -1.59962699e-02f, -2.92388573e-02f, -6.22725487e-03f, -2.07458977e-02f, 5.30663133e-02f,
  4.47742678e-02f, -1.79822464e-02f, 1.50183812e-01f, -7.46745393e-02f, -9.44029819e-03f, -5.46069033e-02f, 4.45324816e-02f, 1.59042343e-01f, 1.64996415e-01f, 1.26964092e-01f,
  1.80628493e-01f, -2.49781590e-02f, -1.02984264e-01f, 1.63456649e-02f, -5.88014070e-03f, 8.43194649e-02f, 9.35256109e-02f, 6.31018216e-03f, 1.65042445e-01f, 2.20767446e-02f,
  1.00407705e-01f, -1.04320319e-02f, 2.97024902e-02f, 1.79329794e-02f, -2.14049648e-02f, 5.55615835e-02f, 4.33480591e-02f, -3.21224518e-02f, 3.59749533e-02f, 1.30621091e-01f,
  4.47454527e-02f, -5.37394434e-02f, -5.02613522e-02f, -1.03729203e-01f, 2.09774282e-02f, -6.42187148e-02f, 5.43640926e-02f, 8.38415101e-02f, -7.97715858e-02f, -4.47500423e-02f,
  5.46650171e-01f, 2.01102182e-01f, -2.67632186e-01f, 3.86033386e-01f, 1.26281455e-01f, -3.31016392e-01f, -3.20870668e-01f, -3.21731716e-01f, 1.21925667e-01f, 1.48408413e-01f,
  2.37241715e-01f, 3.36614907e-01f, 3.56721908e-01f, 9.02977958e-02f, -8.59507695e-02f, -1.10580787e-01f, 7.42875561e-02f, 3.87826823e-02f, -1.50116310e-01f, -2.28788078e-01f,
  1.08685002e-01f, 7.99052939e-02f, 2.02315170e-02f, -4.71610390e-02f, 1.54383227e-01f, 2.55094975e-01f, 2.17292272e-03f, -5.27751818e-03f, -1.21020181e-02f, 2.74133444e-01f,
  1.57651797e-01f, -1.43656701e-01f, 8.44180584e-02f, 1.75601751e-01f, 1.00678757e-01f, -2.81197950e-02f, 5.44805340e-02f, -1.46904420e-02f, 1.31239623e-01f, 9.50274896e-03f,
  1.52019411e-01f, -4.85615805e-03f, 1.10365056e-01f, -8.13346356e-03f, 6.52598292e-02f, -3.78965512e-02f, -3.69300283e-02f, 3.03805689e-04f, 8.51396993e-02f, 2.89906887e-03f,
  1.32558376e-01f, 1.51997861e-02f, 8.11909512e-02f, -8.86658877e-02f, -1.84360147e-01f, 1.04429185e-01f, -1.06567703e-01f, -1.49272159e-01f, -1.21450678e-01f, -2.97769047e-02f,
  2.20688502e-03f, -1.65163167e-02f, -1.08221583e-01f, -8.09046403e-02f, -5.51558062e-02f, -4.43226621e-02f, -8.89199786e-04f, -2.82699913e-02f, -9.65822265e-02f, -6.09150119e-02f,
  -1.24035478e-01f, -9.57213268e-02f, -9.82579440e-02f, 7.90713448e-03f, -2.41130367e-02f, -3.80516276e-02f, -6.20066449e-02f, 2.57590949e-03f, -7.38524869e-02f, -1.31094843e-01f,
  -8.16721022e-02f, -1.31599486e-01f, -9.15223849e-04f, -2.05662057e-01f, -1.14155397e-01f, -1.14787169e-01f, -6.34468645e-02f, -1.18772052e-01f, -1.49714187e-01f, -3.17488797e-02f,
  4.12648052e-01f, -5.66689186e-02f, 1.56672776e-01f, -2.34229807e-02f, 7.04311281e-02f, -3.63122346e-03f, 1.15408950e-01f, 3.58976908e-02f, 1.12037696e-01f, 3.83745618e-02f,
  -8.86175558e-02f, -2.98099220e-02f, 4.14922908e-02f, -8.79671145e-03f, -1.32535328e-03f, 6.75969943e-02f, 1.15734130e-01f, 1.23527206e-01f, -2.88891736e-02f, 5.03227413e-02f,
  4.18929569e-02f, 1.87655389e-01f, 2.50087768e-01f, 1.27457157e-01f, 2.60093194e-02f, 2.75993556e-01f, 1.69854909e-01f, 5.35499677e-02f, 5.32513969e-02f, 2.73337930e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.13616681e-01f, 3.44220549e-01f, 1.54909745e-01f, 3.20616901e-01f, 6.23422801e-01f, 6.01255178e-01f, 4.82429415e-01f, 1.48216635e-01f, -1.45858094e-01f, 1.53610319e-01f,
  4.07369494e-01f, 2.25688860e-01f, 3.78785096e-02f, -6.35184720e-02f, -6.21703006e-02f, -1.10521048e-01f, -2.60236382e-01f, -1.86045274e-01f, -1.13533966e-01f, 9.27234292e-02f,
  -4.14618179e-02f, -3.23764123e-02f, -1.34903237e-01f, -1.08976290e-01f, -5.04492596e-02f, 2.60539595e-02f, 2.96735521e-02f, 2.18787581e-01f, 3.27186674e-01f, -1.99232444e-01f,
  3.65445197e-01f, 3.37232471e-01f, -2.45520383e-01f, 6.37138309e-03f, 4.40378152e-02f, -3.31888646e-01f, -2.16546088e-01f, -2.03005016e-01f, 4.19642553e-02f, -1.30624518e-01f,
  1.86685883e-02f, -9.56305340e-02f, 6.60788640e-02f, -4.04387005e-02f, -2.45198444e-03f, 3.20908725e-02f, -2.45427772e-01f, -2.65404463e-01f, -1.65274084e-01f, -2.01552995e-02f,
  5.84999584e-02f, 2.46005163e-01f, 1.27515167e-01f, -2.16837646e-03f, 3.49799618e-02f, 1.20594747e-01f, 1.42414868e-01f, -1.64520880e-03f, -2.11917497e-02f, -1.55144840e-01f,
  -1.41801625e-01f, 5.64361103e-02f, 2.27275625e-01f, -1.80681258e-01f, 3.16840820e-02f, -1.00489810e-01f, -6.60281107e-02f, 1.61491498e-01f, 4.27201390e-02f, -3.81004326e-02f,
  -2.08411381e-01f, -6.46901801e-02f, -2.04870969e-01f, -1.02929883e-01f, 1.17636122e-01f, 9.07176211e-02f, -5.46669737e-02f, 6.56986162e-02f, 2.69888580e-01f, -5.08110076e-02f,
  1.31194323e-01f, -3.45757455e-02f, -7.04776645e-02f, -2.01326191e-01f, -7.09287673e-02f, -3.01226806e-02f, 3.48505676e-02f, -7.15639368e-02f, 4.45140973e-02f, 2.42679827e-02f,
  -4.26205218e-01f, 1.55463129e-01f, -2.34614238e-01f, -1.90306246e-01f, 1.75604999e-01f, 9.37737990e-03f, 1.33409873e-01f, 6.82608783e-02f, 1.32573262e-01f, -1.55577183e-01f,
  1.45018622e-01f, 2.59960443e-02f, -3.28057893e-02f, -1.47872746e-01f, -1.63771704e-01f, -1.35660581e-02f, -1.47893177e-02f, -2.15759635e-01f, -2.82128453e-01f, -2.20091611e-01f,
  -1.86444536e-01f, -1.54796690e-01f, -6.51095659e-02f, -1.68467879e-01f, -1.04322307e-01f, -9.37321484e-02f, -4.80104871e-02f, -1.46401107e-01f, -9.45537314e-02f, -4.34192538e-01f,
  9.70043600e-01f, 4.14618880e-01f, 1.62020773e-01f, 4.37872142e-01f, -4.50180545e-02f, -9.39380974e-02f, 4.93895300e-02f, 2.39914674e-02f, 1.37277484e-01f, 3.20589691e-01f,
  2.01855719e-01f, 1.69179961e-01f, 6.92412555e-02f, 1.77744716e-01f, 1.54044896e-01f, 1.00642398e-01f, 1.59586519e-01f, 2.84059614e-01f, -3.44663044e-03f, 3.82923096e-01f,
  4.40201759e-01f, 2.13522062e-01f, 3.42309266e-01f, 2.80081064e-01f, 4.55529630e-01f, 1.45690396e-01f, 1.11123040e-01f, 2.58966148e-01f, 1.92969009e-01f, 6.09318376e-01f,
  7.68603981e-01f, 4.41219509e-01f, -3.37570250e-01f, -8.07266310e-02f, -8.95129740e-02f, -7.23085329e-02f, 6.79813279e-03f, -1.92094415e-01f, 2.76902989e-02f, 1.08415864e-01f,
  -7.28807598e-02f, -7.36548752e-02f, -5.72770238e-02f, -4.42700759e-02f, -4.41999957e-02f, 2.55227070e-02f, -6.06481433e-02f, 1.81561232e-01f, -5.64254858e-02f, -1.91622786e-02f,
  1.28876669e-02f, -2.99113933e-02f, -9.68347564e-02f, -2.11687416e-01f, 1.23787403e-01f, -5.51084317e-02f, -9.17366222e-02f, -3.15177180e-02f, -1.20174058e-01f, 1.31556019e-01f,
  2.56216973e-01f, 2.20808506e-01f, 2.42221355e-01f, 3.50315601e-01f, 3.93658787e-01f, 2.63113696e-02f, 3.82084735e-02f, 2.90618110e-02f, 1.90083131e-01f, 5.75968474e-02f,
  -1.72997445e-01f, 4.62036766e-02f, 7.86848515e-02f, -4.68580127e-02f, 9.89224017e-02f, 1.88187584e-02f, 7.64662474e-02f, -3.12033910e-02f, 6.78011635e-03f, -4.77483757e-02f,
  -8.27733874e-02f, -1.15231305e-01f, -1.69546291e-01f, 1.07343160e-01f, -9.49267074e-02f, 6.51371628e-02f, 1.77587122e-01f, -3.98372002e-02f, -1.24074565e-02f, -4.43509221e-02f,
  -6.18870258e-01f, -4.23968315e-01f, 2.37728402e-01f, -7.88955837e-02f, -3.96672189e-02f, -1.79725036e-01f, 1.45416602e-01f, -1.08319625e-01f, -3.04208584e-02f, -1.88619047e-02f,
  -7.43060112e-02f, -4.71826270e-03f, -5.61601892e-02f, -8.35486129e-02f, -1.66256309e-01f, -1.48968846e-01f, -1.31948292e-02f, -8.05947632e-02f, -2.23901033e-01f, -3.34331468e-02f,
  -2.48842940e-01f, -4.33368146e-01f, -4.71478462e-01f, -2.26101220e-01f, -8.50857869e-02f, -2.82450825e-01f, -1.74573988e-01f, -2.04884037e-01f, -3.40312600e-01f, -3.98032337e-01f,
  -2.49472652e-02f, 5.18640816e-01f, -7.02142715e-01f, 5.38204968e-01f, 1.96469873e-01f, 1.63520843e-01f, 6.15099490e-01f, 3.19415808e-01f, 3.56384069e-01f, 2.71617889e-01f,
  -2.06128240e-01f, -2.74587184e-01f, -4.24281433e-02f, -1.96393326e-01f, -1.02017321e-01f, 3.13241512e-01f, 3.80150914e-01f, -4.37223583e-01f, -4.68450695e-01f, -7.25054145e-02f,
  3.58205467e-01f, 4.17746753e-01f, -6.67266315e-03f, 1.24730974e-01f, 2.07566515e-01f, 4.18475792e-02f, 1.27922118e-01f, 6.65661246e-02f, -9.38927755e-02f, -3.34204398e-02f,
  -8.84098709e-01f, -3.44753116e-01f, -6.86671138e-02f, 1.08731963e-01f, -3.13489765e-01f, -2.29331300e-01f, -1.80581406e-01f, -2.88767397e-01f, -2.25849301e-02f, -2.96468418e-02f,
  -1.48213655e-01f, -1.96691588e-01f, -1.03754297e-01f, -6.62265196e-02f, 1.33721146e-03f, -1.98541999e-01f, -9.67067406e-02f, -2.34012574e-01f, -1.11414276e-01f, -3.09784770e-01f,
  5.36548765e-03f, -3.24022770e-01f, -2.93855041e-01f, 6.38380367e-03f, -2.71887273e-01f, -1.66070014e-01f, -3.14178646e-01f, -3.09051901e-01f, -2.30502486e-01f, 1.27491340e-01f,
  -1.11587986e-01f, -1.77469496e-02f, -3.36150974e-02f, 7.91499838e-02f, 5.21379299e-02f, 2.36124173e-03f, -3.08345482e-02f, 1.24338679e-01f, 3.92289497e-02f, 6.03647120e-02f,
  2.67983079e-02f, -1.05554372e-01f, 6.45581931e-02f, 6.29154816e-02f, 9.80074331e-03f, 2.21095458e-02f, -3.14754397e-02f, 1.01368405e-01f, -2.74823094e-03f, 1.19725995e-01f,
  -1.62539691e-01f, -2.41313595e-02f, 2.86282152e-02f, 2.92651281e-02f, -2.90936437e-02f, -1.54571265e-01f, 4.67694215e-02f, -6.81429431e-02f, 4.84028496e-02f, 1.02621555e-01f,
  8.04413676e-01f, -2.06977308e-01f, -8.63224268e-03f, 3.28814797e-02f, 4.45062015e-03f, 7.59673715e-02f, -4.61880565e-02f, 1.08780013e-02f, 8.12357068e-02f, 5.03723137e-02f,
  -1.69870052e-02f, -1.98827144e-02f, 8.98670405e-02f, 1.60788178e-01f, 2.55586319e-02f, 1.25020707e-03f, 3.03978384e-01f, 1.30017295e-01f, 1.48277745e-01f, 9.56418291e-02f,
  2.45163217e-01f, 2.38402769e-01f, 2.01898113e-01f, 1.11891843e-01f, 6.65721968e-02f, 1.70817822e-01f, -1.92321837e-02f, 4.01948653e-02f, 3.20993774e-02f, 6.97006941e-01f,
  -1.53915942e+00f, 4.73274738e-01f, 5.73187768e-01f, -8.71728241e-01f, -2.19495699e-01f, 2.94256628e-01f, 7.49349833e-01f, -5.41165993e-02f, -5.73526621e-01f, 7.40700914e-03f,
  1.00713953e-01f, -8.48543271e-02f, 1.18346557e-01f, 2.32189238e-01f, 4.65245306e-01f, 5.43564081e-01f, 3.81347537e-01f, 9.00429189e-02f, 1.36492386e-01f, 1.59099810e-02f,
  8.46546963e-02f, -2.51108110e-01f, -5.00250161e-01f, -3.10341030e-01f, -2.31392145e-01f, -4.31418493e-02f, 2.25025564e-02f, -9.53584909e-02f, 1.24939002e-01f, 1.51161551e-01f,
  4.31745678e-01f, -4.33892548e-01f, 4.50639427e-02f, -8.81281644e-02f, 6.31581172e-02f, -1.41360357e-01f, -5.48523404e-02f, -1.59380689e-01f, -8.02107006e-02f, 6.76625818e-02f,
  -4.68471572e-02f, -2.63350643e-02f, -1.61789432e-02f, 7.21090063e-02f, -9.93334055e-02f, -1.49809629e-01f, -7.13798404e-02f, 1.04415171e-01f, 3.04286808e-01f, 3.16560388e-01f,
  1.41557708e-01f, 1.25939893e-02f, 2.21107826e-01f, 2.04377979e-01f, 9.29607823e-02f, -2.92052701e-02f, 1.44229576e-01f, -1.29287299e-02f, 5.68366945e-02f, -2.64717519e-01f,
  6.81233257e-02f, -6.09156415e-02f, -1.05620222e-02f, 1.82886068e-02f, 2.43741199e-02f, 3.88313383e-02f, 8.77587497e-02f, 1.23997599e-01f, 1.33081034e-01f, -1.95652172e-02f,
  5.43601103e-02f, 1.57141015e-01f, 6.69518486e-02f, 7.05725141e-03f, -2.11001523e-02f, -1.39013696e-02f, 9.63711441e-02f, 3.80040929e-02f, 2.19475515e-02f, -1.05952471e-01f,
  -1.02262720e-01f, -3.47847119e-02f, -1.03442468e-01f, 1.73911288e-01f, 1.12419136e-01f, 2.97096968e-02f, 2.03312421e-03f, 1.29152045e-01f, 3.92584801e-02f, -2.31590848e-02f,
  1.21742144e-01f, 1.79018542e-01f, -2.66304482e-02f, -6.09933026e-02f, -1.83096737e-01f, -2.63862312e-01f, -5.03116213e-02f, -9.61709023e-02f, 2.78456360e-02f, 9.66412947e-02f,
  -3.46560106e-02f, -8.65060538e-02f, 1.75735001e-02f, 9.63102560e-03f, -1.30305737e-01f, -1.16245829e-01f, 7.31411437e-03f, 9.67462920e-03f, 7.74322972e-02f, -5.70005924e-02f,
  3.00796367e-02f, -1.20258570e-01f, -2.81988946e-03f, 4.34158146e-02f, -4.50560115e-02f, -8.88966843e-02f, 2.11192340e-01f, 7.02365339e-02f, 1.39046654e-01f, -1.15206137e-01f,
  -1.10086727e+00f, 5.62155426e-01f, -7.68363297e-01f, -2.71559775e-01f, -5.71390033e-01f, -5.33042610e-01f, 1.61870062e-01f, 5.51583171e-01f, 2.17221286e-02f, 2.47085169e-01f,
  1.06373422e-01f, -1.45215347e-01f, -1.70584306e-01f, -1.61312029e-01f, -4.80065525e-01f, -5.01695871e-01f, -1.13028979e+00f, -1.16901779e+00f, -5.02486587e-01f, 2.18169108e-01f,
  1.91025972e-01f, 2.38610003e-02f, -3.98472160e-01f, -1.60469100e-01f, 2.21963495e-01f, -4.47015017e-02f, -4.10281047e-02f, -3.19445580e-01f, -2.91453749e-01f, -4.46686000e-01f,
  2.56905735e-01f, -3.20882916e-01f, -6.88221902e-02f, -5.17995119e-01f, 3.25655460e-01f, -1.18705601e-01f, 4.44611087e-02f, -9.01850909e-02f, -1.34878561e-01f, -1.47292437e-02f,
  -2.00317293e-01f, 2.16034904e-01f, -5.22090197e-01f, -2.68377215e-01f, -1.52414590e-01f, -2.77907282e-01f, -1.87445477e-01f, -2.52643585e-01f, -2.62099743e-01f, 1.49951443e-01f,
  -2.97936231e-01f, -6.44970119e-01f, -1.42266944e-01f, 1.35160252e-01f, 2.83568949e-02f, -3.45388830e-01f, 4.69321012e-01f, 2.50348691e-02f, -1.90427408e-01f, 4.82088208e-01f,
  1.82626292e-01f, 1.57623038e-01f, -4.85015959e-02f, 2.59472191e-01f, 1.60153851e-01f, -2.27143526e-01f, 1.57404300e-02f, 1.60146594e-01f, 2.75771338e-02f, 3.05857182e-01f,
  1.65947318e-01f, 9.30402875e-02f, 8.62996653e-02f, 1.26025259e-01f, 8.47320072e-03f, -1.53955072e-01f, -1.33598208e-01f, 2.19625965e-01f, 1.63314845e-02f, -2.88792580e-01f,
  -1.27633691e-01f, -2.27545165e-02f, 5.83447590e-02f, 1.74940452e-01f, -2.77819604e-01f, -2.03893870e-01f, -1.33097798e-01f, 2.53844202e-01f, 5.97500354e-02f, -3.87908787e-01f,
  8.43204677e-01f, -6.01264834e-01f, 1.36133522e-01f, -3.68529558e-03f, -1.86790153e-01f, -1.99126616e-01f, -3.60673331e-02f, -7.95858204e-02f, -6.72116801e-02f, 1.99729010e-01f,
  -1.45445898e-01f, 2.04832092e-01f, -2.08516777e-01f, 1.48105487e-01f, 3.96449380e-02f, 3.37984674e-02f, -1.21603213e-01f, -8.04637522e-02f, -2.46787548e-01f, 2.22754166e-01f,
  -9.66806337e-02f, -1.94470331e-01f, -4.75111306e-02f, 2.57120728e-01f, 2.30136901e-01f, -3.39675546e-01f, 2.83325493e-01f, 4.88815367e-01f, -2.71187276e-01f, 6.48508251e-01f,
  9.82648611e-01f, -3.85636538e-01f, 2.49190554e-01f, 2.26855174e-01f, 9.80297551e-02f, 2.83505291e-01f, 8.76262859e-02f, 1.74114510e-01f, 9.69140977e-02f, -2.23268643e-02f,
  6.35995269e-02f, 4.35707830e-02f, 8.13866109e-02f, 3.56949270e-02f, 2.34970823e-01f, -1.55199721e-01f, -1.08369462e-01f, 2.14342475e-01f, 2.59576887e-01f, 1.01406619e-01f,
  -2.15773776e-01f, 9.82719362e-02f, 3.71211201e-01f, 1.29542157e-01f, -4.52683836e-01f, -2.54782066e-02f, -8.25577304e-02f, -1.10650346e-01f, -1.59903929e-01f, -5.63243747e-01f,
  -4.85415548e-01f, 2.21805125e-01f, -3.53610106e-02f, -1.50745958e-01f, -1.16529346e-01f, -2.85950340e-02f, -2.47218870e-02f, -1.64946035e-01f, -2.05647513e-01f, -2.02342927e-01f,
  -3.49747837e-02f, -1.43332109e-01f, 1.47721078e-02f, -1.03433460e-01f, 1.01977363e-02f, 5.62221818e-02f, -9.35075358e-02f, 8.37484822e-02f, -1.04680195e-01f, -6.97748289e-02f,
  -1.56531930e-01f, 9.32485163e-02f, 4.78104129e-02f, 3.84586826e-02f, 7.97653496e-02f, 7.77555928e-02f, -2.09060367e-02f, 8.95130541e-03f, 9.76011902e-02f, -1.20061422e-02f,
  9.44605917e-02f, 7.89514706e-02f, -2.36814041e-02f, 1.12005658e-01f, 1.00762755e-01f, 3.80926430e-02f, -1.18534140e-01f, 4.98568304e-02f, 3.29255641e-01f, 1.53517857e-01f,
  -1.69123575e-01f, 2.04030097e-01f, 1.40670881e-01f, 4.56278957e-02f, -2.87379026e-02f, -7.22364113e-02f, -1.25324696e-01f, -3.59766185e-02f, 2.28378966e-01f, 2.96622049e-02f,
  1.23149298e-01f, -4.15349714e-02f, -2.66596861e-02f, -1.49547547e-01f, -1.81188300e-01f, -8.51855204e-02f, -4.89032045e-02f, -6.85892850e-02f, -5.85835502e-02f, -8.19147974e-02f,
  -4.81479615e-01f, 7.35948324e-01f, -7.48360232e-02f, -7.05497935e-02f, 1.26358103e-02f, -9.05896798e-02f, 1.43590212e-01f, -1.25944316e-01f, -3.10599983e-01f, -2.14453012e-01f,
  -3.06689274e-02f, 4.05299617e-03f, 2.27478761e-02f, 1.03113778e-01f, 1.56357497e-01f, 1.96620613e-01f, 7.34882131e-02f, 4.93672267e-02f, -8.51874240e-03f, -1.84986740e-01f,
  -1.44905243e-02f, 1.70382276e-01f, 2.22703040e-01f, 2.71075547e-01f, 1.74428374e-01f, 3.01681489e-01f, 4.60518636e-02f, 6.81614280e-02f, 2.22672150e-01f, 2.89606061e-02f,
  6.92862272e-01f, -3.72635812e-01f, -9.17144775e-01f, 2.49920692e-02f, -3.90126169e-01f, -1.55248195e-01f, -7.81236291e-02f, 5.86690128e-01f, 4.95623648e-01f, -4.19086963e-03f,
  2.46041894e-01f, 4.57277745e-01f, 1.17050789e-01f, -2.50333920e-02f, -4.26436178e-02f, -4.77153957e-01f, -5.33282220e-01f, -5.01669228e-01f, -8.44378769e-02f, 2.00643420e-01f,
  1.41402274e-01f, -6.35097250e-02f, 1.14461146e-02f, -1.27095968e-01f, -2.92796820e-01f, -2.22105294e-01f, -5.29056609e-01f, -4.67637956e-01f, -3.35202515e-01f, -7.29329705e-01f,
  -6.77114964e-01f, -1.11711062e-01f, 2.49976411e-01f, 1.71289265e-01f, -1.08043186e-01f, 8.45502168e-02f, -4.48283628e-02f, 2.10071862e-01f, 2.14985073e-01f, 1.91170096e-01f,
  1.31130386e-02f, -3.19276191e-02f, 5.11896312e-02f, 2.88927797e-02f, 4.30785529e-02f, 6.90375119e-02f, 3.17013532e-01f, 2.27098852e-01f, -2.07736739e-03f, -4.40525077e-02f,
  7.05537796e-02f, 1.75548065e-02f, 1.28306642e-01f, 2.05789745e-01f, 1.86139315e-01f, 2.32355539e-02f, 5.67659773e-02f, -2.44580535e-03f, 2.67149974e-03f, 2.01965392e-01f,
  -1.91198453e-01f, 1.44036282e-02f, 1.19714290e-01f, 3.91661711e-02f, 2.04944357e-01f, 1.88648522e-01f, 5.58931567e-02f, -4.84509990e-02f, -5.43411598e-02f, -6.40095538e-03f,
  1.21751845e-01f, -3.65557186e-02f, 1.01290017e-01f, 6.49908883e-03f, -1.83200121e-01f, -1.42430859e-02f, 1.11681290e-01f, 7.77427340e-03f, -1.48892617e-02f, 1.48097575e-01f,
  6.04811162e-02f, -7.09369034e-02f, -1.18460611e-01f, -7.54059181e-02f, 9.66381654e-03f, -5.93585931e-02f, -9.98725444e-02f, -2.71928329e-02f, -3.61045403e-03f, 1.10220417e-01f,
  4.68530327e-01f, -4.23827022e-02f, 1.97497532e-02f, 5.38616441e-02f, -2.74844557e-01f, -9.54598784e-02f, -2.10303873e-01f, -3.66890281e-02f, -8.28171894e-02f, -2.83509009e-02f,
  -8.21578875e-02f, -6.24186285e-02f, -1.23322606e-01f, -1.03429565e-02f, -2.16583721e-03f, 6.17044792e-02f, 1.64775550e-01f, 1.51280279e-03f, -5.67915477e-02f, -1.98208272e-01f,
  2.93782968e-02f, 2.34875426e-01f, 3.24807137e-01f, 8.93168524e-02f, -7.74071738e-02f, -2.41525918e-02f, -1.82872608e-01f, 8.25419091e-03f, -1.04400188e-01f, 9.48186293e-02f,
  -2.04038247e-01f, -3.67437065e-01f, -6.72934592e-01f, 6.63532436e-01f, 1.81566492e-01f, -8.74913454e-01f, -1.43405926e+00f, -6.62789643e-01f, 4.72078443e-01f, -3.85561556e-01f,
  -4.16338503e-01f, 2.79433221e-01f, 2.26007998e-01f, -1.50860429e-01f, -5.60678482e-01f, -2.07021236e-01f, 3.18962485e-01f, -1.40152827e-01f, -4.82896358e-01f, -3.93127620e-01f,
  2.84038305e-01f, 4.86163050e-01f, -1.31994570e-02f, 2.06152454e-01f, 8.71783316e-01f, 4.12025243e-01f, 3.77689213e-01f, 5.77583730e-01f, -1.38810113e-01f, 1.00887573e+00f,
  -3.85204881e-01f, -1.31860927e-01f, -3.56216073e-01f, 3.80984426e-01f, 1.00668900e-01f, -1.66343600e-01f, -3.89980108e-01f, 1.79396212e-01f, -3.22079174e-02f, 3.87719162e-02f,
  2.46748507e-01f, -2.59395868e-01f, 2.23786518e-01f, -8.52396786e-02f, -1.73420906e-01f, -3.66107404e-01f, -1.02928458e-02f, -1.80522114e-01f, -2.49097005e-01f, -4.18060035e-01f,
  2.80015588e-01f, 2.96943247e-01f, -4.41747487e-01f, -3.04713249e-01f, -2.68062890e-01f, 3.20063502e-01f, -2.52224684e-01f, -5.53849638e-02f, -6.21152580e-01f, 1.35247111e-01f,
  -3.46663520e-02f, 8.57184902e-02f, -3.96013856e-02f, -2.08784208e-01f, -1.34986252e-01f, 3.62871750e-03f, 1.15419693e-01f, 1.32895812e-01f, 2.40748543e-02f, -7.78934881e-02f,
  -2.33526174e-02f, -1.67721570e-01f, 9.90028977e-02f, -7.39029646e-02f, 2.59837788e-02f, 1.50373802e-01f, -2.98957583e-02f, 1.05591729e-01f, -9.81711149e-02f, -1.47061944e-01f,
  -9.01730284e-02f, 1.22822173e-01f, 2.43390277e-01f, 3.21218193e-01f, -1.96143076e-01f, 4.21448313e-02f, 8.07630494e-02f, 9.28441435e-02f, 6.76482543e-02f, -8.43488518e-03f,
  -3.80016193e-02f, -4.05205548e-01f, 6.38195453e-03f, 1.92222431e-01f, -7.76216714e-03f, 1.29049513e-02f, 8.28968138e-02f, -1.37017578e-01f, 8.39346722e-02f, -1.38491139e-01f,
  -4.83386368e-01f, -1.53542727e-01f, -5.80920875e-02f, -5.44971004e-02f, -4.26401019e-01f, -1.36471599e-01f, -1.08350538e-01f, -9.48428214e-02f, -1.65764958e-01f, 1.58326730e-01f,
  7.35720992e-02f, -6.68598056e-01f, -5.76619506e-01f, -4.56657916e-01f, 1.55466020e-01f, -4.84301239e-01f, -3.85031700e-01f, -4.06289995e-01f, -9.99309659e-01f, -9.54873860e-01f,
  1.00715506e+00f, 7.07203925e-01f, 5.57868481e-01f, -1.26096427e-01f, 3.67935821e-02f, 3.06666195e-01f, 7.12211370e-01f, 5.20001769e-01f, 4.56479043e-02f, 1.32806227e-01f,
  -5.83959579e-01f, -1.16026795e+00f, -7.67429292e-01f, -5.52564383e-01f, -1.30771488e-01f, 4.82912034e-01f, 2.44644105e-01f, 1.44706756e-01f, 1.49681596e-02f, -7.43756294e-02f,
  -6.24070287e-01f, 1.13431290e-01f, 1.49531484e-01f, 6.36081025e-02f, 2.43542522e-01f, -4.36080426e-01f, 2.87482113e-01f, 2.22144380e-01f, 1.12021966e-02f, 9.63517353e-02f,
  2.31153239e-02f, 8.96037817e-01f, -4.38305646e-01f, -4.10899371e-01f, -1.45362288e-01f, -2.15291992e-01f, -3.99355888e-02f, 1.73538283e-01f, -3.58863771e-02f, 1.03928007e-01f,
  -2.69855589e-01f, -7.51587674e-02f, -1.45218939e-01f, -7.27726445e-02f, 6.88092187e-02f, 1.67848207e-02f, 1.56090915e-01f, 2.89668292e-01f, -6.80453479e-02f, -1.41008526e-01f,
  -6.22716904e-01f, -7.23895058e-02f, 3.23212445e-01f, 5.55732995e-02f, 1.94910970e-02f, -3.02858889e-01f, 2.78205693e-01f, 1.21162258e-01f, 7.34244063e-02f, 2.63736844e-01f,
  -3.26356024e-01f, 6.20184503e-02f, 5.59892170e-02f, -1.32407278e-01f, -1.36652336e-01f, -9.94665697e-02f, 3.44627863e-03f, -1.19668417e-01f, -6.56847060e-02f, 1.92630559e-01f,
  -1.14910282e-01f, -6.29839972e-02f, -5.43246157e-02f, 5.43926209e-02f, -2.00866044e-01f, 1.08352847e-01f, 1.11180209e-02f, 7.44044185e-02f, 1.05225250e-01f, 5.64510785e-02f,
  -2.46940963e-02f, 8.04253444e-02f, 4.91593890e-02f, -1.36754001e-02f, -3.44544053e-02f, 1.18354764e-02f, -1.78082764e-01f, -1.54500157e-01f, -1.22175895e-01f, 6.61639273e-02f,
  -4.60413367e-01f, -5.13279557e-01f, -1.12354785e-01f, 2.63317913e-01f, 2.79967606e-01f, 5.24706692e-02f, -1.78123757e-01f, 6.30379841e-02f, 1.86320320e-01f, 1.89210400e-01f,
  4.71301489e-02f, -2.30041325e-01f, -9.76948440e-03f, 9.06970277e-02f, -4.55592610e-02f, 3.06594875e-02f, -2.87020028e-01f, -7.93203339e-02f, -1.68697640e-01f, 4.14452851e-02f,
  -1.62222996e-01f, 6.79768622e-02f, -1.51511312e-01f, -1.22306496e-01f, -1.46908104e-01f, -4.06736493e-01f, 4.04071324e-02f, 2.54423451e-02f, -4.72878804e-03f, 9.25867185e-02f,
  1.98019058e-01f, -8.80468309e-01f, -1.21803291e-01f, -2.83817768e-01f, -4.97352779e-01f, -3.84100676e-01f, -1.03642178e+00f, -2.08274219e-02f, -2.37223834e-01f, -9.37158346e-01f,
  -2.23626748e-01f, 9.87820745e-01f, 5.17025948e-01f, 7.42219567e-01f, 8.18475187e-01f, -1.03458035e+00f, -6.72003925e-01f, 7.22318828e-01f, 1.28545415e+00f, 2.90209144e-01f,
  -3.13395023e-01f, -2.24277049e-01f, 6.35305166e-01f, 3.17926735e-01f, -7.33125150e-01f, -2.40729153e-02f, -6.87616229e-01f, -3.65776479e-01f, -4.39082921e-01f, -1.18282247e+00f,
  -2.30251789e-01f, -3.17308664e-01f, 2.98955441e-01f, 2.79242903e-01f, -1.68954074e-01f, 1.70642827e-02f, -3.91570758e-03f, -1.21459484e-01f, 1.41135128e-02f, -2.81068593e-01f,
  -5.87224811e-02f, 2.41526827e-01f, 5.22420965e-02f, -4.40579876e-02f, -2.49911979e-01f, -2.02235207e-01f, -5.33460863e-02f, 1.08246721e-01f, 1.63463965e-01f, -2.17183813e-01f,
  -3.09874147e-01f, -1.55427262e-01f, 1.63708284e-01f, -1.96169332e-01f, 6.85482845e-02f, 1.63509980e-01f, -3.16584110e-01f, 8.05840939e-02f, 5.28015733e-01f, -1.02900064e+00f,
  -2.61785209e-01f, 9.65842884e-03f, 1.06016636e-01f, -3.03750634e-02f, -1.24109887e-01f, 5.44893444e-02f, -4.78480756e-02f, -6.15899265e-02f, 1.87983271e-02f, -8.63626152e-02f,
  1.02829359e-01f, -1.31955639e-01f, 1.42407432e-01f, -6.69869930e-02f, -5.66918775e-02f, 2.49512051e-03f, 6.63511232e-02f, -8.89414251e-02f, 6.19947538e-03f, -9.50524956e-02f,
  3.94109972e-02f, 8.11130404e-02f, 2.92792376e-02f, 9.40245390e-02f, 7.04491287e-02f, 1.75481215e-01f, 1.82363130e-02f, 1.28264964e-01f, 1.17535837e-01f, -2.94800937e-01f,
  2.78659344e-01f, 5.47059894e-01f, -3.23019445e-01f, 3.68315637e-01f, -4.95464467e-02f, 8.14544782e-02f, -1.22684397e-01f, 1.14956655e-01f, 2.62158155e-01f, 2.10770383e-01f,
  1.41582474e-01f, 1.21708795e-01f, -1.53565615e-01f, -1.30302608e-01f, -4.09905473e-03f, -1.72811188e-02f, -1.29177257e-01f, 1.66875169e-01f, 7.14597553e-02f, -1.88318342e-01f,
  -3.67569625e-01f, -5.57634979e-02f, 1.66927487e-01f, 1.45637348e-01f, -1.48097783e-01f, 2.73039222e-01f, -2.09074676e-01f, -1.38198733e-01f, 5.08720040e-01f, -7.20703304e-01f,
  -1.27447999e+00f, -3.41160148e-01f, 9.13503706e-01f, -5.85723579e-01f, 5.25355935e-01f, -2.97861621e-02f, -7.66132116e-01f, -7.54666805e-01f, -9.02075469e-02f, 2.95495912e-02f,
  4.84804362e-01f, 1.46078423e-01f, 9.16823372e-02f, -1.66897297e-01f, -1.16783953e+00f, -6.29508257e-01f, -2.01941520e-01f, -4.78653550e-01f, -7.64340699e-01f, -8.46557438e-01f,
  -3.78540128e-01f, -4.44438040e-01f, -4.74561602e-01f, -3.40203017e-01f, 5.74215576e-02f, 1.58895567e-01f, 7.82400846e-01f, 3.50441158e-01f, 4.29143667e-01f, 3.86386186e-01f,
  1.78723875e-02f, -1.50547042e-01f, 1.77199259e-01f, 1.80189028e-01f, 6.05090737e-01f, -2.07396358e-01f, -5.45818925e-01f, 1.39577582e-01f, -4.19685990e-02f, 9.44677517e-02f,
  1.24302052e-01f, 8.10947120e-02f, 3.72317918e-02f, 1.96531445e-01f, -4.40747440e-01f, -3.25298488e-01f, 5.50308302e-02f, -3.44493747e-01f, -1.95886120e-01f, -5.64910024e-02f,
  1.12998588e-02f, 1.22534931e-01f, -1.66156992e-01f, 2.38873944e-01f, -2.16304138e-01f, 2.07752749e-01f, 2.44541079e-01f, 6.57387450e-03f, 1.66006371e-01f, -4.07001525e-01f,
  -9.79014188e-02f, 1.29302025e-01f, 1.42073408e-01f, 1.79343969e-02f, -2.30323896e-01f, 9.66615677e-02f, -2.17222758e-02f, -6.33938834e-02f, 1.57194987e-01f, -1.28514320e-01f,
  1.13586085e-02f, 1.05837636e-01f, -2.09299266e-01f, -5.84792346e-02f, -8.54036286e-02f, -8.59968439e-02f, -1.39072031e-01f, 4.07041535e-02f, -3.03004980e-02f, 1.10032827e-01f,
  -2.58750647e-01f, 5.92435487e-02f, 4.70402762e-02f, -8.43274146e-02f, 3.02264422e-01f, 8.88545662e-02f, 7.77452514e-02f, -1.98836345e-02f, -8.63208845e-02f, 1.44482747e-01f,
  -4.21683460e-01f, 7.99361050e-01f, -4.44834203e-01f, -3.89656842e-01f, 2.00601164e-02f, 2.50149995e-01f, 4.51726615e-01f, 4.52656671e-02f, 2.97421634e-01f, -1.04154117e-01f,
  1.29508421e-01f, -2.63544410e-01f, 1.91338137e-02f, 1.82388783e-01f, -2.92857021e-01f, 5.47449552e-02f, -4.19059247e-01f, -8.34416598e-02f, -1.08978979e-01f, 9.44981948e-02f,
  -2.83480197e-01f, -6.47358894e-01f, -8.68583798e-01f, -3.96737278e-01f, -3.86630446e-01f, -6.60498202e-01f, -3.41542691e-01f, -3.47864002e-01f, -6.41808689e-01f, -1.24936473e+00f,
  -3.84870946e-01f, -3.21182281e-01f, -1.53284061e+00f, -8.66954267e-01f, -8.51058066e-01f, -3.86284471e-01f, 4.32080597e-01f, 3.29499036e-01f, 1.48551494e-01f, 1.22988624e-02f,
  -3.07713747e-01f, -7.66925097e-01f, -6.21146023e-01f, -2.68946737e-01f, -1.09216988e-01f, 2.42083997e-01f, -1.63385779e-01f, -6.55687034e-01f, -8.56377661e-01f, -1.65701374e-01f,
  2.30721414e-01f, -5.90143919e-01f, -6.63942218e-01f, -3.61788839e-01f, -4.41658765e-01f, -7.71825850e-01f, -7.59313941e-01f, -7.35434473e-01f, -2.55807698e-01f, -5.60379505e-01f,
  -8.14732850e-01f, -6.38032317e-01f, -1.54124931e-01f, 1.53945107e-02f, -2.69245476e-01f, 1.54495314e-01f, 7.03715021e-03f, -3.82799447e-01f, 2.43797675e-01f, -6.86797127e-02f,
  -5.24658978e-01f, 7.85354152e-03f, -3.50577086e-01f, -3.30067188e-01f, -6.78934932e-01f, 2.66804011e-03f, -3.97850066e-01f, -2.43134141e-01f, -2.98784912e-01f, 1.29217327e-01f,
  6.09385073e-02f, -3.39399874e-02f, -2.03654811e-01f, 1.62412047e-01f, -9.72272381e-02f, -1.48553818e-01f, -4.15121675e-01f, -1.37907207e-01f, -2.36650303e-01f, 1.14692874e-01f,
  4.53234345e-01f, -8.52778181e-03f, 1.01012602e-01f, -1.91685572e-01f, 1.54993042e-01f, -3.87737993e-03f, -9.63413268e-02f, 2.99940646e-01f, -1.07511453e-01f, -2.79423475e-01f,
  -4.73075509e-02f, 2.23003298e-01f, -1.05291843e-01f, 1.84964854e-02f, -2.09760815e-01f, -5.16765937e-02f, 4.29986566e-01f, 1.26136422e-01f, -8.85411352e-03f, -1.41602635e-01f,
  -8.06234106e-02f, -7.74488896e-02f, -1.65430889e-01f, 1.55128598e-01f, 2.51751006e-01f, -1.02195077e-01f, 4.97284196e-02f, 1.86217472e-01f, -2.11248659e-02f, 2.73221582e-01f,
  -4.47643578e-01f, -5.03145158e-02f, 1.23906516e-01f, 4.44543570e-01f, -8.45221654e-02f, -6.88595101e-02f, -3.11220646e-01f, 2.86724091e-01f, 1.22737303e-01f, 1.09082617e-01f,
  -8.24099407e-02f, -4.03106995e-02f, -2.55733520e-01f, -8.15949813e-02f, -5.24157047e-01f, 8.38593170e-02f, 2.10758194e-01f, -1.80348635e-01f, 6.99498281e-02f, 2.78498195e-02f,
  2.89088815e-01f, 4.59026426e-01f, 2.71329731e-01f, 1.32968143e-01f, 3.16484123e-02f, 7.96930492e-02f, -9.27589238e-02f, 1.97316661e-01f, 3.58962625e-01f, 5.77512622e-01f,
  -1.33650589e+00f, -4.16908085e-01f, -6.77588284e-01f, -8.64356875e-01f, 2.55645156e-01f, 4.71491009e-01f, 4.77776527e-01f, 2.37844616e-01f, -4.40316170e-01f, -4.63184059e-01f,
  -1.85525581e-01f, -2.57104859e-02f, -4.91279691e-01f, 1.49839744e-01f, 2.81573415e-01f, 7.06783384e-02f, 1.07506514e-01f, 2.12780446e-01f, 7.47192144e-01f, 9.32502389e-01f,
  5.24246752e-01f, -1.01752684e-01f, -1.16143726e-01f, 2.09270477e-01f, -2.08993554e-01f, -7.69064575e-02f, -5.85618377e-01f, -2.59218752e-01f, 1.60948992e-01f, -2.30886668e-01f,
  -7.04899907e-01f, -5.54201603e-01f, 3.93760622e-01f, 5.49514443e-02f, -9.74500701e-02f, -4.55742031e-01f, 1.90788563e-02f, -4.25395399e-01f, 1.61540341e-02f, -8.71594027e-02f,
  -1.70890674e-01f, 7.02608973e-02f, -2.04089373e-01f, -2.83482391e-02f, -1.23678532e-03f, 1.33620873e-01f, -1.54495507e-01f, -2.93705110e-02f, -2.36151427e-01f, 2.02179607e-02f,
  4.36561763e-01f, 2.09849211e-03f, -3.84221464e-01f, 2.65159220e-01f, 1.72099441e-01f, -5.09465449e-02f, 2.82875728e-02f, 4.08773571e-01f, -6.34271950e-02f, -4.39534843e-01f,
  1.64829835e-01f, -4.05485369e-02f, -7.13664740e-02f, -1.45601770e-02f, 6.73854351e-02f, -1.90305337e-01f, -7.52866864e-02f, 8.98936987e-02f, 6.83353022e-02f, -4.95898575e-02f,
  1.52839288e-01f, -1.21629164e-02f, 9.71396267e-02f, -1.16225138e-01f, -2.15283912e-02f, -7.45621771e-02f, 2.19731051e-02f, -4.60340828e-02f, -6.23878092e-02f, -1.15256175e-01f,
  3.93638276e-02f, 5.98005503e-02f, -2.07966194e-01f, 2.19438583e-01f, 7.18221292e-02f, -9.07200947e-03f, -1.85882106e-01f, 1.94482490e-01f, -1.78314492e-01f, -7.20334649e-02f,
  -7.02813447e-01f, 5.34294128e-01f, -7.02772796e-01f, 5.41615523e-02f, -1.43595085e-01f, -4.58360538e-02f, -2.24932060e-01f, 3.51546556e-02f, -2.39584669e-01f, 1.19827695e-01f,
  2.19816774e-01f, -5.49410135e-02f, -3.67870629e-01f, 3.01192433e-01f, 3.16286236e-01f, -7.38071948e-02f, -3.25468689e-04f, -2.74751056e-02f, 9.14464965e-02f, 3.30810174e-02f,
  3.84778678e-02f, 2.11944491e-01f, -3.69424909e-01f, -1.77086771e-01f, 2.66994275e-02f, -2.97530919e-01f, -2.87240565e-01f, 6.19359352e-02f, -4.62191492e-01f, -5.50500035e-01f,
  -5.28162777e-01f, -1.40264452e+00f, 5.98896623e-01f, 1.93709880e-01f, 5.19152582e-01f, 3.60259265e-01f, 9.51502845e-02f, -1.42611280e-01f, 2.59095971e-02f, -2.05978423e-01f,
  -4.70905870e-01f, -3.32068563e-01f, -1.79576874e-01f, -1.86201885e-01f, -1.90586939e-01f, 1.89103946e-01f, 4.00375396e-01f, 5.82539141e-01f, 6.97736979e-01f, 2.94047922e-01f,
  -7.44457766e-02f, -9.16915089e-02f, -1.52275607e-01f, 9.71976519e-02f, -2.40687236e-01f, 1.98262185e-01f, -8.23249742e-02f, -2.29561388e-01f, -3.25998187e-01f, -3.05375993e-01f,
  3.41931522e-01f, -6.09511077e-01f, 2.79319823e-01f, -1.48063347e-01f, -1.42525807e-01f, -1.05518617e-01f, 4.81517613e-02f, -5.48930615e-02f, -1.02761827e-01f, -5.21463044e-02f,
  -1.55764759e-01f, -9.12125856e-02f, -5.91531545e-02f, 2.94549838e-02f, 4.62640487e-02f, 7.80013427e-02f, -1.00791000e-01f, -1.87954769e-01f, -2.50364572e-01f, -6.48306906e-02f,
  -1.57209396e-01f, -7.33309612e-02f, 9.02866125e-02f, -2.30034664e-02f, -1.81405485e-01f, -2.32252516e-02f, -1.87576339e-01f, -7.48990774e-02f, -1.58048645e-01f, 1.34379473e-02f,
  1.73102155e-01f, 5.46912774e-02f, -1.13087423e-01f, 8.38873629e-03f, 3.03467307e-02f, 5.79504929e-02f, 1.59634292e-01f, -9.02197435e-02f, 2.68945992e-02f, 5.59098497e-02f,
  -5.51725477e-02f, -1.18426614e-01f, -1.75930828e-01f, 9.13705735e-04f, -2.87318267e-02f, -8.35206807e-02f, -9.34168603e-03f, -1.00320928e-01f, -1.45965576e-01f, -6.88498244e-02f,
  -1.40076384e-01f, 4.04591439e-03f, 1.92298312e-02f, -2.75666956e-02f, -1.25562206e-01f, -9.57443193e-02f, 1.22741261e-03f, -7.15700760e-02f, 4.43790182e-02f, -8.21282994e-03f,
  1.57735884e-01f, 7.74657428e-02f, 2.11421818e-01f, -1.52310520e-01f, -1.08558789e-01f, -1.59897983e-01f, -3.98213975e-02f, 1.00179210e-01f, -6.01924695e-02f, 2.53313296e-02f,
  -1.61501661e-01f, -8.97685345e-03f, -1.19641408e-01f, -4.43385839e-02f, 3.50735426e-01f, 1.57793522e-01f, -1.45800263e-01f, 1.24163158e-01f, -1.16636097e-01f, -1.01051010e-01f,
  -1.40558764e-01f, 1.35166019e-01f, 2.89711177e-01f, 8.44937712e-02f, -7.53739700e-02f, 3.46862435e-01f, 2.94912487e-01f, 2.06579179e-01f, 2.06628099e-01f, 2.47371897e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  4.91363168e-01f, 7.04599321e-01f, 8.23142767e-01f, 1.12904668e+00f, 8.03671002e-01f, 9.15358782e-01f, 3.32202047e-01f, 1.10596168e+00f, 1.41639304e+00f, 4.30466801e-01f,
  6.82901382e-01f, 9.65076029e-01f, 5.75412273e-01f, 1.17378438e+00f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -1.87330410e-01f, -6.56482950e-02f, -9.26595777e-02f, -1.72537133e-01f, -4.79033291e-01f, 2.52326787e-01f, -2.46544644e-01f, -5.82371891e-01f, -1.28566623e-01f, -5.43043077e-01f,
  -1.76587105e-01f, -1.46417409e-01f, 3.93598825e-01f, -2.38705776e-04f, -2.13542268e-01f, -5.13476372e-01f, -1.46632075e-01f, -3.21005493e-01f, -6.26473367e-01f, -5.18013895e-01f,
  -5.91510653e-01f, -1.40148199e+00f, 3.11408728e-01f, -2.82300770e-01f, 4.54352021e-01f, -2.38465860e-01f, -9.65938330e-01f, 6.06826305e-01f, -4.07529324e-01f, 3.97169068e-02f,
  9.67222989e-01f, -3.81116480e-01f, -1.29979914e-02f, 7.14163436e-03f, 5.74070252e-02f, -2.11732239e-01f, 2.29769535e-02f, 1.72091499e-02f, 9.83064994e-02f, -7.14184791e-02f,
  -1.92853183e-01f, -3.25204372e-01f, -4.49197888e-02f, 8.67268965e-02f, 1.68533951e-01f, -8.99831206e-02f, 1.41925290e-01f, -5.07586360e-01f, -2.51743734e-01f, 3.01072568e-01f,
  5.09970903e-01f, 4.36415225e-01f, -4.62338775e-01f, -8.79553258e-01f, -7.07470953e-01f, 8.56885672e-01f, 3.27899009e-01f, -1.41312826e+00f, -1.56109786e+00f, 1.61010635e+00f,
  -1.19015515e+00f, 2.39316761e-01f, -5.61312973e-01f, -3.04738522e-01f, 2.79602200e-01f, 2.24743187e-01f, 1.03590965e-01f, 1.31858438e-01f, -1.99663594e-01f, 2.84127027e-01f,
  -1.51272625e-01f, -3.09224464e-02f, 2.48961866e-01f, 4.29570735e-01f, 6.95055500e-02f, 3.49743307e-01f, 2.49267831e-01f, 4.54969466e-01f, 3.82791966e-01f, -6.74395204e-01f,
  -8.28618228e-01f, -4.07942414e-01f, -8.57035637e-01f, -6.85862422e-01f, -1.06667006e+00f, -7.42058158e-01f, -1.29139614e+00f, 4.43807811e-01f, -4.54460084e-02f, 2.34296292e-01f,
  -7.21069634e-01f, 1.00545871e+00f, 6.15988135e-01f, -1.52231359e+00f, 7.52027988e-01f, 3.65715399e-02f, -2.53238082e-01f, 3.90553214e-02f, -1.08450510e-01f, -3.60457987e-01f,
  7.46504292e-02f, -2.44132712e-01f, -1.03263780e-01f, -1.14421733e-01f, -4.45463985e-01f, 1.91477701e-01f, 5.45774326e-02f, -3.81402105e-01f, -3.45405817e-01f, -2.65650094e-01f,
  -3.47721636e-01f, -2.19215713e-02f, 1.03538714e-01f, -4.24642771e-01f, 2.16519102e-01f, -7.37793088e-01f, -8.06687117e-01f, 5.52555025e-01f, -2.83745974e-01f, -8.17050278e-01f,
  -7.25930333e-01f, -1.56363285e+00f, -4.75076318e-01f, -5.92441738e-01f, 4.86249119e-01f, 6.24194503e-01f, 9.20398295e-01f, -3.70145768e-01f, -4.31504399e-02f, -8.18066895e-02f,
  -1.01308353e-01f, -4.64365177e-04f, -5.04566848e-01f, -1.09871060e-01f, 8.17415118e-02f, -2.99090177e-01f, 1.94607809e-01f, 4.60424781e-01f, -2.47085854e-01f, -2.85265092e-02f,
  -6.75430417e-01f, 8.31583068e-02f, -3.82635862e-01f, 4.57690299e-01f, 6.05452120e-01f, -1.85469121e-01f, -9.38579321e-01f, -7.84235299e-01f, -1.01236689e+00f, -6.26386330e-02f,
  2.87382185e-01f, 1.62076447e-02f, 8.77240971e-02f, 4.42931890e-01f, 2.09020346e-01f, -7.47935474e-01f, 6.95167124e-01f, -8.88109580e-02f, -1.61369133e+00f, -3.14464420e-01f,
  3.83836538e-01f, -1.67324301e-02f, 4.13489901e-02f, 1.32050931e-01f, 6.01831734e-01f, 1.57397687e-01f, 2.89435089e-01f, 3.28682005e-01f, 7.62817040e-02f, 7.86576886e-03f,
  1.29896715e-01f, 8.85477662e-03f, 4.90475446e-01f, -4.16359156e-02f, 7.21052871e-04f, 1.67314455e-01f, 4.42283839e-01f, 4.47626799e-01f, 2.42365286e-01f, -2.56810546e-01f,
  1.11085737e+00f, -1.79285026e+00f, 2.88402021e-01f, -2.05058321e-01f, 3.30379963e-01f, -4.15333323e-02f, -8.91846716e-01f, -9.13178563e-01f, -1.27572227e+00f, 6.94819272e-01f,
  -1.18841898e+00f, -2.14437395e-01f, 2.67437398e-01f, -2.87296958e-02f, 3.55338663e-01f, 2.31710449e-01f, 1.74157128e-01f, -1.33730203e-01f, 2.90431112e-01f, -7.29937434e-01f,
  4.69900608e-01f, 4.03901517e-01f, -5.53637028e-01f, 4.78981197e-01f, 4.72063184e-01f, 2.80721754e-01f, 7.97775924e-01f, 3.50825757e-01f, -8.13343823e-01f, 6.15455722e-03f,
  -9.13040221e-01f, 6.51408195e-01f, -1.48405182e+00f, -6.59099340e-01f, -8.69971275e-01f, -1.16035771e+00f, -1.34151471e+00f, 1.63295656e-01f, 1.02287829e+00f, -9.97364581e-01f,
  -1.13698566e+00f, -4.17188078e-01f, -4.60905045e-01f, -1.36304569e+00f, -4.84277636e-01f, -2.20324442e-01f, -8.09944570e-02f, -2.57075578e-01f, -5.20527840e-01f, -6.78373992e-01f,
  -4.02273208e-01f, -2.86576569e-01f, -2.38195583e-01f, 4.07211453e-01f, 2.04338849e-01f, -4.92694736e-01f, -1.28198028e-01f, -2.62179554e-01f, -2.99769223e-01f, -1.84827551e-01f,
  -2.77273476e-01f, -2.13477656e-01f, -1.63873881e-01f, -7.20256865e-02f, 7.96611369e-01f, 8.66295934e-01f, -1.11737967e+00f, -6.28959894e-01f, -1.16609931e+00f, 4.01977688e-01f,
  -6.48485124e-01f, -1.03894174e+00f, -3.85563195e-01f, -9.33189332e-01f, 6.86493814e-01f, -3.20888698e-01f, -1.84920356e-01f, -5.28130829e-02f, 2.54074901e-01f, 1.23700932e-01f,
  -3.78663391e-01f, -1.14843667e-01f, 1.15218490e-01f, -1.24149069e-01f, 2.29518861e-01f, -2.23586500e-01f, 2.66291916e-01f, 1.12165853e-01f, 1.61746442e-01f, -4.40910757e-01f,
  5.44683263e-02f, -6.44476473e-01f, -3.54510367e-01f, 8.75868648e-02f, -5.61419904e-01f, -5.75285316e-01f, 3.28548729e-01f, -2.69778520e-02f, -1.05010426e+00f, 4.49642479e-01f,
  -8.55878592e-01f, -5.15414953e-01f, 6.03682220e-01f, -8.08781922e-01f, -4.83394057e-01f, -1.41110018e-01f, -3.61742675e-01f, 1.26823461e+00f, 2.06559703e-01f, -6.39631152e-02f,
  7.23346248e-02f, 1.69786543e-01f, 5.42563140e-01f, 5.01572788e-01f, -3.62452008e-02f, 5.56220829e-01f, -8.87864977e-02f, -8.90457749e-01f, -3.44694443e-02f, 2.09767878e-01f,
  1.86345667e-01f, 5.47582388e-01f, -1.99741334e-01f, 7.35931754e-01f, 8.63018155e-01f, 7.43765831e-01f, 3.94546658e-01f, 4.27951127e-01f, -1.11604500e+00f, -1.30719328e+00f,
  -7.14886546e-01f, -1.37954342e+00f, -5.24417162e-01f, 1.13078380e+00f, -1.70084572e+00f, -1.33736181e+00f, 7.09462941e-01f, -7.60527849e-01f, -7.99207464e-02f, -6.59036636e-01f,
  7.42616579e-02f, 3.62262018e-02f, 8.77957419e-03f, 8.32098052e-02f, 1.62410274e-01f, -3.38591896e-02f, 9.45852883e-03f, 3.13925713e-01f, 6.81123063e-02f, 2.66222078e-02f,
  2.22906366e-01f, 1.36780441e-01f, -3.94341975e-01f, -4.42193717e-01f, 1.24809630e-01f, 3.26317221e-01f, 2.70468384e-01f, 2.21054316e-01f, -4.47463512e-01f, -5.11579156e-01f,
  -4.60693926e-01f, 6.74562037e-01f, 9.85955834e-01f, -1.25277448e+00f, -8.09146106e-01f, -9.17218804e-01f, -1.06396675e+00f, 1.79733038e-01f, -1.04396760e+00f, -3.00387353e-01f,
  -9.57228184e-01f, 7.64347970e-01f, 8.23102891e-02f, 1.21742792e-01f, -1.38771251e-01f, 1.44281378e-02f, 2.08974540e-01f, -4.22543772e-02f, 1.46801502e-01f, 5.97385466e-01f,
  1.61332078e-02f, 1.18983872e-01f, -3.11713703e-02f, -4.58285242e-01f, -5.73193312e-01f, 9.16904658e-02f, -3.38888675e-01f, 1.31754652e-02f, 2.71851897e-01f, -3.84640038e-01f,
  6.71505570e-01f, -2.20679030e-01f, -2.42446780e-01f, 4.20635462e-01f, -7.82288015e-01f, -4.83187400e-02f, -6.45732284e-02f, -1.27075887e+00f, 1.24246502e+00f, -2.72024006e-01f,
  3.57359558e-01f, -6.45721018e-01f, -4.95538473e-01f, -1.52473247e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.58628088e-01f, -3.54220301e-01f, 4.07783002e-01f, -1.05622530e+00f, 5.72355092e-01f, 3.20199221e-01f, 5.81065059e-01f, -9.18686390e-03f, -6.07135415e-01f, 2.04369292e-01f,
  -7.67682672e-01f, -5.12437880e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    