/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.26456062e-03f, -3.46896589e-01f, -1.36369660e-01f, -2.42440805e-01f, 5.37495166e-02f, 6.05700836e-02f, 1.12486288e-01f, 9.72453877e-02f, -5.24495915e-02f, -1.43042564e-01f,
  -4.13239226e-02f, 1.35955930e-01f, -5.06609306e-02f, -3.62021178e-02f, 4.27919701e-02f, -8.23498666e-02f, -1.46976829e-01f, -6.07554466e-02f, 1.87556237e-01f, 5.87381385e-02f,
  -7.31648579e-02f, -9.84892920e-02f, -1.94399152e-02f, -1.30231068e-01f, -3.01897228e-01f, -4.09136191e-02f, -2.30300725e-01f, -7.85969943e-02f, -1.70485452e-01f, -2.80796796e-01f,
  8.17471463e-03f, -3.79407480e-02f, 9.85326916e-02f, 5.74283339e-02f, -8.28054100e-02f, -1.14158243e-02f, 4.67499904e-02f, -1.28356621e-01f, -2.13867697e-05f, -1.22926615e-01f,
  -1.69833209e-02f, -1.10734534e-02f, -1.00327320e-01f, -1.38158932e-01f, -7.89555982e-02f, -9.06055123e-02f, -6.97002187e-02f, -9.44504961e-02f, -1.14047199e-01f, -1.36060014e-01f,
  -5.14881983e-02f, 1.37254400e-02f, 2.13685427e-02f, -5.11197709e-02f, 1.71262641e-02f, -3.14465389e-02f, -7.24488348e-02f, -1.42069504e-01f, 6.32870793e-02f, -2.19180152e-01f,
  2.35125665e-02f, 5.00093177e-02f, 2.10224986e-02f, -4.75353450e-02f, -1.68233144e-03f, 5.66551369e-03f, -3.84253613e-03f, 3.37625928e-02f, 4.05157655e-02f, -9.36200726e-04f,
  -2.04322189e-02f, 8.41743425e-02f, 6.57480508e-02f, -4.73316163e-02f, 7.04259276e-02f, 4.48661819e-02f, 9.02211368e-02f, -2.63727885e-02f, 9.45264846e-03f, 1.96162034e-02f,
  1.60550885e-02f, 2.42344979e-02f, 4.57622483e-02f, 8.03926811e-02f, -1.62465386e-02f, 8.91702902e-03f, 2.95541435e-02f, 2.24529970e-02f, 5.82361147e-02f, 2.96822116e-02f,
  -8.85378793e-02f, 1.28121391e-01f, -5.85503355e-02f, -7.01763555e-02f, -2.96605714e-02f, -8.40575695e-02f, 2.89538479e-03f, -1.02061883e-03f, 3.20548564e-03f, -5.65585345e-02f,
  -7.63928238e-03f, -7.14732930e-02f, -2.61009727e-02f, -3.03752050e-02f, 1.07513927e-02f, -9.32621881e-02f, -7.65275955e-02f, -1.05162926e-01f, 5.17142117e-02f, -3.17124873e-02f,
  -2.94353478e-02f, 5.51329926e-02f, 4.54051271e-02f, 5.20418845e-02f, -4.67390977e-02f, 1.14724122e-01f, -7.11602643e-02f, 2.24391394e-03f, 1.18725024e-01f, 2.68516466e-02f,
  -1.03645764e-01f, 1.69926569e-01f, 5.19447505e-01f, -5.25107570e-02f, 1.60737097e-01f, 3.36747378e-01f, 3.09029251e-01f, 1.47840902e-01f, 8.51423305e-04f, 4.70271371e-02f,
  1.21248746e-03f, -2.12649181e-01f, -6.89015388e-02f, -8.80126506e-02f, 1.48459509e-01f, 1.89385921e-01f, 1.99144572e-01f, 2.70182103e-01f, 1.85862601e-01f, 4.01010662e-02f,
  3.99190187e-02f, -8.90952274e-02f, -1.39224246e-01f, -3.41157392e-02f, 1.48517013e-01f, 8.15286115e-02f, 1.24355309e-01f, 1.22216232e-01f, 2.84938663e-02f, 8.60381424e-02f,
  1.31266549e-01f, 1.19099557e-01f, 4.24313806e-02f, -1.73944175e-01f, 4.79016639e-02f, 1.25868514e-01f, 7.77489468e-02f, -1.84971914e-02f, -1.36426566e-02f, 6.26711845e-02f,
  1.00266412e-01f, -5.17437793e-03f, 2.47350056e-02f, 9.16258916e-02f, 3.88957784e-02f, 7.97648430e-02f, 3.93276922e-02f, -5.95770217e-03f, 4.76448936e-03f, 6.16062619e-02f,
  7.64559880e-02f, 3.07960194e-02f, 1.22901894e-01f, 1.86208904e-01f, 7.19363764e-02f, -3.00850514e-02f, 1.49269491e-01f, 1.87531412e-01f, 1.46664307e-01f, 1.06398158e-01f,
  9.85646695e-02f, -4.92046699e-02f, -8.56882408e-02f, -3.08857057e-02f, -4.60042618e-02f, -8.18146616e-02f, -4.37158309e-02f, -5.46637923e-02f, -5.99744543e-02f, 1.88726676e-03f,
  -4.89978343e-02f, -1.82482213e-01f, -6.96719438e-02f, -3.53334211e-02f, -1.20483097e-02f, -8.11466016e-03f, -1.29019603e-01f, -6.25964999e-02f, -1.21804275e-01f, -1.82196483e-01f,
  -1.23859905e-01f, -1.88118871e-02f, -1.27977178e-01f, 1.64990295e-02f, 2.49566743e-03f, -3.84868272e-02f, -4.32733446e-02f, -1.02547430e-01f, -3.47628854e-02f, -4.15685922e-02f,
  -7.17716888e-02f, -7.59414062e-02f, 3.71057577e-02f, 7.41501246e-03f, 9.37438291e-03f, -6.76804930e-02f, -4.25327104e-03f, -4.82573844e-02f, 3.44176777e-02f, 9.98108909e-02f,
  -3.34182841e-04f, 4.74574752e-02f, 6.69327155e-02f, -2.47004833e-02f, 1.59271434e-01f, 5.77871315e-02f, -2.00224258e-02f, 7.22278431e-02f, 6.00205603e-05f, 4.56221178e-02f,
  -5.58532123e-03f, 1.10989138e-01f, -4.32373099e-02f, 1.69738799e-01f, 6.79199249e-02f, 6.80465922e-02f, 1.61616996e-01f, 1.57258973e-01f, 1.21607646e-01f, 1.57385260e-01f,
  2.37398222e-01f, 1.67396232e-01f, 3.22578788e-01f, -1.78259403e-01f, -9.39868316e-02f, 1.48427799e-01f, 2.06613764e-01f, 1.43715113e-01f, -2.18880624e-01f, -8.43926799e-03f,
  -1.12868421e-01f, -1.39008626e-01f, -6.60955757e-02f, -1.12490691e-02f, 2.53202438e-01f, 5.11556789e-02f, 3.28351445e-02f, 7.30941519e-02f, 2.26763189e-01f, 2.45183762e-02f,
  -2.23721817e-01f, -7.03660026e-02f, 5.59995584e-02f, -1.41060010e-01f, -2.16753796e-01f, -1.45406798e-01f, 2.88664401e-02f, -1.70847163e-01f, -1.31471930e-02f, -2.05169916e-01f,
  1.75737903e-01f, -2.28166338e-02f, 1.77470222e-02f, -2.17877001e-01f, -1.04339138e-01f, -6.42736778e-02f, -2.12160242e-03f, -2.55655553e-02f, -1.53676346e-01f, -1.05136096e-01f,
  -1.10212408e-01f, 1.42137883e-02f, -8.71592462e-02f, -1.66286319e-01f, -3.97700518e-02f, 2.70306747e-02f, 5.75966984e-02f, -9.62453615e-03f, 3.50199118e-02f, -1.90514531e-02f,
  -2.05531478e-01f, -1.39785543e-01f, 8.82232115e-02f, 1.29995108e-01f, 2.09740438e-02f, 1.98508557e-02f, -3.10151326e-03f, -1.14477761e-01f, 9.83954892e-02f, 1.60399154e-02f,
  -5.47760585e-03f, 1.26507640e-01f, 4.30495255e-02f, 2.06453092e-02f, 7.35225528e-02f, -7.96699524e-02f, 6.29929900e-02f, 8.78668278e-02f, 3.60085256e-02f, 9.46855396e-02f,
  4.94775595e-03f, 7.35934870e-03f, 1.27194211e-01f, -1.29523631e-02f, 5.78228459e-02f, 1.51531056e-01f, 4.83105481e-02f, 7.99045265e-02f, 1.41065568e-02f, -1.45796323e-02f,
  4.10078326e-03f, 3.44524346e-02f, -4.68664430e-02f, 3.78333628e-02f, 5.19591337e-03f, 1.32224888e-01f, 9.15597975e-02f, 1.08702183e-01f, 8.65366459e-02f, 6.16386458e-02f,
  5.90757504e-02f, 2.45600209e-01f, -1.90685652e-02f, -1.21802673e-01f, -8.03160891e-02f, -6.35285899e-02f, -5.69311939e-02f, -5.25005944e-02f, -9.09174904e-02f, -4.18489501e-02f,
  -3.68947163e-02f, 6.13786690e-02f, 1.86104216e-02f, 1.77819151e-02f, -1.61262136e-02f, -8.54602782e-04f, -2.10354365e-02f, 6.54207319e-02f, -6.71357438e-02f, -5.24112992e-02f,
  -4.16035652e-02f, 1.01326808e-01f, 1.37800127e-01f, -7.69396406e-03f, -3.84127274e-02f, 1.26761362e-01f, 1.59467831e-01f, 7.60863423e-02f, 1.32606447e-01f, 4.61556837e-02f,
  3.81048232e-01f, 2.14521345e-02f, 2.86240190e-01f, -1.48872361e-01f, -2.29290828e-01f, -2.65687525e-01f, -3.97759497e-01f, -2.67964870e-01f, -2.40876630e-01f, 2.21508313e-02f,
  5.10141894e-04f, 1.58268362e-01f, 1.95039690e-01f, 1.33038864e-01f, 8.18039402e-02f, -1.73652947e-01f, -9.40123945e-02f, 2.04169542e-01f, 1.80365011e-01f, -3.84572186e-02f,
  -1.89712077e-01f, -1.03780292e-01f, 3.14889811e-02f, 4.02424345e-03f, -8.71060193e-02f, 6.34605289e-02f, -7.18734041e-02f, 1.41119594e-02f, -5.68140373e-02f, 2.34084204e-02f,
  4.15382504e-01f, 3.35703939e-02f, -7.10738376e-02f, 2.93955393e-02f, 2.71135271e-02f, -5.60857505e-02f, -2.75160410e-02f, -2.49306019e-02f, -6.08302690e-02f, -8.56375787e-03f,
  4.31825742e-02f, 5.16856462e-03f, 2.70922575e-02f, -7.74582196e-03f, -2.58135423e-02f, 2.61556711e-02f, -4.96276580e-02f, -1.19339265e-02f, 3.76941971e-02f, 3.19306403e-02f,
  -5.41910604e-02f, 7.72503987e-02f, 1.14098161e-01f, -1.27183124e-01f, -8.86352640e-03f, 7.63841495e-02f, -6.24318887e-03f, -3.28889117e-02f, -9.94249508e-02f, -1.97785944e-02f,
  -7.92103559e-02f, 1.02830268e-01f, 2.09894665e-02f, -3.46680470e-02f, -4.13701609e-02f, 1.90902185e-02f, 1.22397328e-02f, -2.60610711e-02f, 9.54565480e-02f, -5.39635867e-02f,
  3.70477475e-02f, 1.90152600e-02f, 5.28516620e-02f, 2.44326238e-02f, -1.39232650e-02f, 5.60237840e-02f, 6.32851664e-03f, 4.43402305e-02f, 2.73632668e-02f, -6.69516400e-02f,
  1.13384292e-01f, -2.93624774e-02f, 6.90352172e-02f, -2.74891779e-02f, 3.60256955e-02f, -4.73162197e-02f, 2.32610409e-03f, 2.48510540e-02f, 5.01495041e-03f, -5.08687831e-02f,
  8.36926848e-02f, 7.70242289e-02f, 1.32668003e-01f, 4.89768796e-02f, 8.72486085e-03f, 1.72196347e-02f, 6.19233772e-02f, 2.24364195e-02f, 2.31395289e-02f, 6.95903320e-03f,
  2.84452606e-02f, -2.21203707e-04f, 1.06135294e-01f, -2.80459374e-02f, 4.84573171e-02f, -1.13037266e-02f, -5.19396476e-02f, 1.33760460e-02f, 1.93135859e-03f, 2.18623541e-02f,
  -7.96300545e-02f, -1.07508548e-01f, 7.33540878e-02f, 5.50920293e-02f, 1.41721200e-02f, 4.80572022e-02f, 3.22206169e-02f, 6.40164539e-02f, 7.83382431e-02f, -2.91705597e-02f,
  -2.86917686e-01f, 2.89620310e-01f, 5.61484834e-03f, -1.59630865e-01f, 8.38964507e-02f, 3.04219007e-01f, 3.51115704e-01f, 2.32892156e-01f, -4.20092233e-03f, 1.36309445e-01f,
  -8.97804499e-02f, -1.99866563e-01f, -1.52728796e-01f, 4.20607626e-02f, 6.17609471e-02f, 2.87037313e-01f, 2.79644936e-01f, -7.75408596e-02f, -1.05989061e-01f, 1.87239656e-03f,
  2.17981567e-03f, -6.06354214e-02f, -1.51641935e-01f, 1.44073386e-02f, 3.62586938e-02f, 1.23978890e-01f, 1.71340242e-01f, 6.46226704e-02f, 2.16877431e-01f, 7.83652365e-02f,
  -5.56539223e-02f, -7.82986283e-02f, -2.06233505e-02f, -9.93489176e-02f, -1.11093685e-01f, -9.22867507e-02f, -3.99220809e-02f, -1.25348896e-01f, -2.23163404e-02f, -7.34804347e-02f,
  -4.70487438e-02f, -1.25774354e-01f, -6.45643398e-02f, -8.98437202e-02f, -8.76096711e-02f, 1.91558655e-02f, -1.26685679e-01f, -1.05692931e-01f, -1.28950223e-01f, -4.83957492e-02f,
  2.68677599e-03f, -6.59596361e-03f, 6.24564616e-03f, 1.43817952e-02f, 3.89525518e-02f, 1.16357189e-02f, 4.20180820e-02f, 7.29497224e-02f, 1.28473878e-01f, 2.08428174e-01f,
  -7.89275691e-02f, -6.99598044e-02f, 3.94492149e-02f, 6.57894015e-02f, 1.11125544e-01f, -6.07851855e-02f, 4.72555310e-02f, 3.28086317e-02f, -1.60931423e-02f, 8.43073130e-02f,
  -3.54561768e-02f, 6.05057254e-02f, 1.39001571e-02f, 9.01539251e-02f, 6.93243220e-02f, 7.80239031e-02f, 1.61632374e-01f, 4.40989584e-02f, 1.01995215e-01f, 4.70103957e-02f,
  -1.87397413e-02f, 3.79451215e-02f, -1.38677713e-02f, 5.23737781e-02f, 2.61131376e-02f, 4.70844507e-02f, -1.00795003e-02f, 6.17845543e-02f, -1.09469621e-02f, -6.83524460e-03f,
  7.53997788e-02f, -3.71622201e-03f, 5.23728877e-02f, -9.36979800e-02f, -8.67277291e-03f, -1.26423180e-01f, 1.45787261e-02f, -1.02671690e-01f, -1.50676891e-01f, -1.96288060e-02f,
  -2.11095121e-02f, 2.23702984e-03f, -4.14732806e-02f, 1.71882380e-02f, -6.44014450e-03f, -8.53997171e-02f, 6.77974522e-02f, 1.12882303e-02f, -2.86868904e-02f, -4.85265478e-02f,
  5.14386445e-02f, 1.22892581e-01f, 8.93259645e-02f, 1.56722844e-01f, 6.27952367e-02f, 8.21833834e-02f, 1.14229947e-01f, 1.37850940e-01f, 1.59416348e-01f, 2.39592910e-01f,
  4.06935871e-01f, 5.70226635e-04f, -5.66084236e-02f, 1.70664653e-01f, 8.54344442e-02f, 1.32678926e-01f, 1.33332700e-01f, 8.68789703e-02f, 1.33357525e-01f, 1.51917174e-01f,
  2.04683527e-01f, 1.40150756e-01f, -2.92963963e-02f, 1.29680913e-02f, -9.31204483e-03f, -1.54064283e-01f, -1.65582821e-01f, -1.72583893e-01f, -7.54841790e-02f, 4.54779044e-02f,
  -3.76471952e-02f, -1.78295728e-02f, -5.40905520e-02f, -2.96562295e-02f, -1.76653005e-02f, -4.90360968e-02f, -1.15398638e-01f, -1.26976501e-02f, -1.89500928e-01f, -1.51659817e-01f,
  3.23028751e-02f, 1.64341331e-01f, -8.38674158e-02f, -5.74312434e-02f, 2.50227787e-02f, -9.92548987e-02f, -3.07484134e-03f, -9.42586288e-02f, 2.34470591e-02f, -2.05315445e-02f,
  9.21271667e-02f, -6.69883341e-02f, -9.13207605e-02f, -1.44222518e-02f, -4.07905281e-02f, -5.27324192e-02f, -2.36092042e-02f, -2.02549924e-03f, -1.07866943e-01f, 1.72587652e-02f,
  -7.88970962e-02f, 4.19625118e-02f, 2.03396683e-03f, -8.12416896e-03f, -7.15141445e-02f, -1.34771736e-02f, 3.25165205e-02f, -6.02402166e-02f, -8.29013661e-02f, -7.02942088e-02f,
  -5.97885586e-02f, 6.35002106e-02f, 1.12876676e-01f, 2.86171120e-02f, 1.48428634e-01f, 8.75596888e-03f, 1.24894097e-01f, 4.14875988e-03f, 9.07913875e-03f, 3.10933813e-02f,
  1.32085487e-01f, 1.62587956e-01f, 7.63162076e-02f, 5.70379123e-02f, 1.32428512e-01f, 1.65598802e-02f, 5.47321551e-02f, 7.50951245e-02f, 1.28351465e-01f, 1.27876654e-01f,
  1.47021571e-02f, 1.56923175e-01f, 1.98322758e-02f, -2.05757562e-02f, 8.05424899e-02f, 6.09626621e-02f, 1.71668097e-01f, 4.44164872e-02f, 9.03284624e-02f, 1.89515308e-01f,
  1.70528531e-01f, -5.69697507e-02f, 6.18101545e-02f, -2.41094572e-03f, 2.04287207e-04f, 2.19353288e-03f, -4.99548167e-02f, -2.13917121e-02f, 2.85424814e-02f, -1.83749963e-02f,
  9.33243260e-02f, 2.04667915e-02f, 4.75649685e-02f, 1.27530880e-02f, 4.57394645e-02f, -1.53269237e-02f, -2.02740878e-02f, -3.81598785e-03f, -1.72287114e-02f, 6.03905879e-02f,
  -4.28056382e-02f, 9.28844735e-02f, 9.81056094e-02f, 3.61878201e-02f, 1.25366032e-01f, 1.18879922e-01f, 6.48390222e-03f, 1.48303986e-01f, 9.19720605e-02f, 3.36084031e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.79928279e-01f, -4.40143436e-01f, 2.13780940e-01f, 3.04648757e-01f, 4.32069212e-01f, 2.96035379e-01f, 1.10768296e-01f, 2.15464950e-01f, 1.89783871e-01f, -5.11766374e-02f,
  -1.54879794e-01f, 4.47941087e-02f, 2.06396058e-01f, 2.16846272e-01f, 1.45156190e-01f, 2.66617626e-01f, 5.63876331e-01f, 4.21663821e-01f, 3.49493176e-01f, 1.60559162e-01f,
  1.61818326e-01f, 2.01160416e-01f, 1.44201770e-01f, 1.98242009e-01f, 7.30232745e-02f, 3.80663246e-01f, 2.22818583e-01f, 2.37195730e-01f, 9.46890935e-02f, 1.25116244e-01f,
  -2.00965479e-01f, -2.15432405e-01f, 2.11661443e-01f, -2.81653125e-02f, -9.57283825e-02f, -1.39951006e-01f, 3.63577418e-02f, -2.94482615e-02f, -5.78543991e-02f, 9.77493897e-02f,
  4.76642419e-03f, -1.05451994e-01f, -3.05002350e-02f, -8.26422647e-02f, 9.45318490e-02f, -3.19549106e-02f, -1.67556748e-01f, 1.77185219e-02f, -3.69647145e-02f, -1.21399522e-01f,
  -3.21336687e-02f, -3.61761148e-03f, 1.96755558e-01f, 6.18997365e-02f, -6.54637516e-02f, 1.84692889e-01f, -8.99799615e-02f, 2.40242239e-02f, 1.09069765e-01f, 5.99791436e-03f,
  3.75446156e-02f, -2.22420823e-02f, 7.20247179e-02f, 1.97270177e-02f, -1.87377315e-02f, -3.89814470e-03f, 1.01442980e-02f, 1.45212505e-02f, 1.08962812e-01f, -2.48931255e-03f,
  1.66188940e-01f, 9.25600007e-02f, -4.74922210e-02f, -9.74730682e-03f, 1.13272786e-01f, 7.11456686e-02f, -1.27514973e-01f, -7.89707154e-02f, -2.59353369e-02f, 7.87569284e-02f,
  6.93997666e-02f, 1.46788612e-01f, 4.74449806e-02f, -7.55371898e-02f, 4.53800671e-02f, 7.41253495e-02f, 1.28355518e-01f, 4.11843136e-02f, 9.65226963e-02f, -3.00258175e-02f,
  1.91891998e-01f, 1.50614023e-01f, -5.31217828e-02f, -1.41789481e-01f, -1.03959858e-01f, -2.27997497e-01f, -1.26341745e-01f, -1.71588346e-01f, -1.04415670e-01f, 5.70903569e-02f,
  3.87908705e-02f, -1.02072604e-01f, -1.89610779e-01f, 2.60860678e-02f, 1.14113979e-01f, 5.55938929e-02f, -1.82362080e-01f, -5.80206700e-02f, 5.27439006e-02f, -7.43397102e-02f,
  -7.49353021e-02f, 9.39961374e-02f, 9.26153585e-02f, 1.56596273e-01f, 1.36152148e-01f, 2.21130833e-01f, -3.57429832e-02f, -6.22612759e-02f, 1.66607022e-01f, 1.89878449e-01f,
  -6.00186251e-02f, -1.08963167e-02f, -6.43592715e-01f, -7.58744895e-01f, -5.82569599e-01f, -1.28264934e-01f, 3.76043260e-01f, 3.41105312e-02f, -3.23270798e-01f, -5.77349514e-02f,
  2.62750149e-01f, 3.12990278e-01f, 9.82455760e-02f, 2.76735008e-01f, 5.91172278e-01f, -1.06406391e-01f, -4.07316387e-01f, -1.74873799e-01f, 1.18901476e-01f, 2.45247886e-01f,
  8.88499245e-02f, -2.35135660e-01f, -2.73164243e-01f, -3.25503141e-01f, -5.92056513e-01f, -3.31245095e-01f, -6.57216668e-01f, -4.99740779e-01f, -9.11203548e-02f, -5.58786869e-01f,
  4.98647392e-02f, -2.88880944e-01f, 3.61067019e-02f, 4.58915643e-02f, -1.10900365e-01f, -3.11056934e-02f, -5.63080749e-03f, -2.01073751e-01f, 7.34550729e-02f, -1.64903402e-01f,
  -2.78593391e-01f, 1.26326531e-01f, 3.05782408e-02f, -1.37949720e-01f, -1.69613510e-01f, -9.87596065e-02f, -3.49882364e-01f, -1.31524190e-01f, -6.16217852e-02f, 1.28552482e-01f,
  1.78023890e-01f, -4.79666218e-02f, -4.84997220e-02f, 8.45990404e-02f, -1.27958521e-01f, -1.61440507e-01f, -4.97484952e-02f, -4.97377589e-02f, -2.45683063e-02f, -2.05585390e-01f,
  -2.04932336e-02f, -1.01108737e-01f, 2.01725215e-02f, -9.45375189e-02f, 7.94060603e-02f, 4.49484475e-02f, -1.64081872e-01f, 4.68925759e-02f, 1.01756699e-01f, 6.40328899e-02f,
  2.81432029e-02f, 6.29843995e-02f, 2.72137336e-02f, 1.96130946e-02f, 6.53615668e-02f, 1.38921618e-01f, 1.56915307e-01f, 7.92098492e-02f, 1.38419271e-02f, 2.18184367e-02f,
  1.76913515e-01f, 2.71232687e-02f, -1.02678977e-01f, 2.18567565e-01f, 1.12198301e-01f, -7.39597306e-02f, -3.05272285e-02f, 1.02003559e-01f, -9.62670427e-03f, -3.98757830e-02f,
  1.96485996e-01f, 5.07175267e-01f, 3.29388422e-03f, 1.53584972e-01f, -1.32691428e-01f, -1.14150703e-01f, -6.29552975e-02f, -1.16965517e-01f, -1.94965571e-01f, -9.30866674e-02f,
  8.29137862e-02f, 2.26440668e-01f, -2.92779785e-03f, -1.07086517e-01f, -1.85861327e-02f, -4.64345030e-02f, 9.75714028e-02f, -4.30365354e-02f, 1.48329273e-01f, -9.25800279e-02f,
  9.59842503e-02f, 3.18957716e-01f, 4.02087033e-01f, 2.37123847e-01f, 1.28596686e-02f, 1.45057544e-01f, 1.58297509e-01f, 1.48529500e-01f, 2.25004539e-01f, 1.62560284e-01f,
  3.49870101e-02f, -7.61749893e-02f, -4.54248041e-01f, 2.47610047e-01f, 6.02460504e-01f, 2.78169543e-01f, -7.05461130e-02f, -3.09118897e-01f, -1.17703587e-01f, 6.28829375e-02f,
  3.83882374e-01f, 8.87345001e-02f, -2.70360470e-01f, -1.82779044e-01f, -3.71283710e-01f, -2.95364499e-01f, -6.68628514e-02f, -2.74988651e-01f, 5.13101071e-02f, 5.00394881e-01f,
  4.71389621e-01f, 3.58867556e-01f, 1.26777172e-01f, 5.98026626e-03f, 2.75004357e-01f, 3.18458498e-01f, -2.51955062e-04f, 3.03228080e-01f, 7.48697892e-02f, -2.65657324e-02f,
  -1.45689026e-01f, -2.23663315e-01f, -7.14142099e-02f, 2.41517112e-01f, 2.70758420e-01f, -1.44193634e-01f, -4.94554974e-02f, -1.04304954e-01f, -8.44294205e-03f, -6.47523440e-03f,
  2.15776324e-01f, 8.22989121e-02f, 2.27493018e-01f, 1.72594581e-02f, 5.04297949e-02f, -2.03068065e-03f, -5.01277260e-02f, -4.68964577e-01f, -4.67503875e-01f, 6.68461248e-02f,
  2.70651400e-01f, 2.95057118e-01f, -9.83605161e-04f, -1.78930536e-01f, -2.73891449e-01f, 1.81112781e-01f, -7.77138025e-02f, -9.94460508e-02f, -3.66232961e-01f, -3.24139297e-01f,
  1.19285071e-02f, -3.29907723e-02f, -3.10692675e-02f, -1.23098724e-01f, 7.36306533e-02f, -5.61607294e-02f, -6.20157011e-02f, -5.99813759e-02f, 3.04119792e-02f, 2.52590794e-03f,
  -1.52350247e-01f, -1.04912274e-01f, -1.47096366e-01f, -9.21026915e-02f, 3.77163216e-02f, 1.91974994e-02f, -6.88048750e-02f, -9.77177098e-02f, -7.73392022e-02f, -8.03545639e-02f,
  -1.00884624e-01f, -1.20583959e-01f, -4.66023423e-02f, -2.37137109e-01f, -2.92928591e-02f, -1.67106137e-01f, 5.14757223e-02f, 1.08777829e-01f, -2.15842761e-03f, 6.54473677e-02f,
  5.69432043e-02f, -9.10015870e-03f, -3.35075743e-02f, -1.31154239e-01f, 4.37241942e-02f, -3.24300975e-02f, -5.64731359e-02f, -1.16267249e-01f, -1.34079620e-01f, -1.08389661e-01f,
  2.91407052e-02f, -2.97946513e-01f, -1.65797099e-01f, -1.08959921e-01f, 7.36224875e-02f, 2.62324065e-02f, 1.70460045e-01f, -9.96180326e-02f, -1.95811823e-01f, -3.62294875e-02f,
  -1.49243504e-01f, 1.34933190e-02f, 3.61140892e-02f, -3.62968743e-01f, -1.82527348e-01f, 1.99463852e-02f, -2.63189413e-02f, -4.76749204e-02f, -1.61870450e-01f, 3.47998030e-02f,
  7.32295871e-01f, -2.02517748e-01f, 3.61643016e-01f, 2.89092600e-01f, 6.19095489e-02f, 2.03399286e-01f, 1.92767024e-01f, 2.93486089e-01f, 1.64948046e-01f, -1.37997949e-02f,
  -2.23318279e-01f, -1.73072934e-01f, 1.29628945e-02f, -2.84369867e-02f, 1.78740114e-01f, 1.20170549e-01f, 1.18226327e-01f, 2.94941783e-01f, 2.58038402e-01f, 1.01525411e-01f,
  -1.35408156e-02f, 8.44095051e-02f, 2.29618594e-01f, 1.77114859e-01f, -7.96092972e-02f, 3.71020176e-02f, -6.70112371e-02f, -4.51553129e-02f, -8.31755102e-02f, -3.01172938e-02f,
  -1.40551463e-01f, 2.48612314e-02f, -6.37959167e-02f, -1.91783473e-01f, -2.71567792e-01f, 2.47233566e-02f, 9.47284549e-02f, -1.37117237e-01f, -6.81744069e-02f, 1.99124180e-02f,
  -1.26306728e-01f, -4.05330658e-02f, -1.62676215e-01f, -6.26236026e-04f, -1.84120554e-02f, -1.19075961e-02f, -5.89986891e-02f, 2.36045066e-02f, 6.18157238e-02f, -5.61053343e-02f,
  -2.51595795e-01f, -1.03786342e-01f, -3.64700472e-03f, -8.87170061e-02f, 9.77158919e-02f, 4.97232899e-02f, -8.29410087e-03f, -3.92381474e-02f, -1.61728226e-02f, 1.19567700e-02f,
  -3.27081885e-03f, 1.00522339e-02f, 7.04785511e-02f, 1.68187886e-01f, 1.17364205e-01f, 2.15416215e-02f, 3.39614563e-02f, 9.70301777e-03f, 1.63233027e-01f, 8.58613476e-02f,
  5.10024652e-02f, 8.14961120e-02f, 2.02378985e-02f, 6.63239956e-02f, -2.11639684e-02f, -9.63743255e-02f, -6.09684400e-02f, -1.47491232e-01f, -6.71693012e-02f, 8.52601230e-02f,
  1.94589257e-01f, -3.45350653e-02f, 2.46687606e-02f, 4.11147401e-02f, 5.89032955e-02f, -3.25619280e-02f, 6.75448254e-02f, -2.18576938e-02f, -8.12484920e-02f, -7.20213056e-02f,
  -2.11257100e-01f, -1.48425564e-01f, 1.68533519e-01f, 3.39553691e-02f, -1.33465052e-01f, -1.50102034e-01f, -8.39299709e-03f, -1.56005532e-01f, -5.10276966e-02f, 7.23699033e-02f,
  -1.98608264e-02f, 4.84217405e-02f, -1.24316409e-01f, -5.74054644e-02f, 1.60587475e-01f, -2.18245573e-02f, -1.99134022e-01f, 2.03205217e-02f, -6.12067804e-02f, -1.19295925e-01f,
  -1.35295808e-01f, 3.36847566e-02f, 7.78535940e-03f, 8.43552053e-02f, -4.43613268e-02f, 1.07002385e-01f, 5.39526939e-02f, 1.96473766e-02f, 1.14484951e-01f, 2.05618097e-04f,
  7.68181682e-01f, -5.85673302e-02f, -6.07213259e-01f, 1.22112125e-01f, -3.79727840e-01f, -6.19096637e-01f, -5.27195692e-01f, -4.14247215e-01f, 1.44121319e-01f, -5.60003594e-02f,
  1.94089161e-03f, 2.50605792e-01f, -1.80096641e-01f, -4.13685411e-01f, -6.25385880e-01f, -5.53690970e-01f, -4.75849479e-01f, -5.17633855e-01f, -7.03431964e-01f, -4.17767078e-01f,
  -1.00908607e-01f, -1.60187304e-01f, -2.14146286e-01f, -3.40693265e-01f, -6.04917109e-02f, -1.65424868e-01f, -3.45039338e-01f, -3.55841279e-01f, -3.59555930e-01f, -1.22361496e-01f,
  -4.60652977e-01f, -2.90015817e-01f, -2.42514268e-01f, 1.92326322e-01f, -1.77467242e-01f, 2.24347502e-01f, -3.74182127e-02f, -5.12839481e-02f, 2.96819925e-01f, -5.78474812e-02f,
  -2.92312372e-02f, 4.65652198e-02f, 1.34490719e-02f, -2.52456963e-01f, -1.32392347e-01f, -2.22233251e-01f, -6.55487999e-02f, -2.64919728e-01f, -2.38367140e-01f, -1.44720599e-01f,
  3.63289714e-01f, -1.16261482e-01f, -4.27687675e-01f, -2.86131322e-01f, -4.07434642e-01f, -1.33037224e-01f, -5.34887254e-01f, -4.01795089e-01f, -4.90342885e-01f, 1.83757365e-01f,
  1.31368563e-01f, 1.47307664e-01f, -7.01905340e-02f, -1.30017012e-01f, 2.22666543e-02f, 1.50894774e-02f, -4.62012030e-02f, -7.16758296e-02f, -9.43540223e-03f, -1.05222076e-01f,
  -4.22429517e-02f, 8.95148963e-02f, 6.66639134e-02f, 4.60943542e-02f, -9.74669456e-02f, -1.69109166e-01f, 1.19433599e-02f, -5.63910045e-02f, -4.15675528e-02f, 5.69530874e-02f,
  -9.67101604e-02f, -1.53203547e-01f, 5.97956367e-02f, 8.38756710e-02f, -2.67527085e-02f, -2.03055203e-01f, 2.32167589e-03f, -2.01766193e-01f, -5.63423894e-02f, 1.18100747e-01f,
  -1.59914028e-02f, -2.49438077e-01f, 4.98312875e-05f, -5.98813295e-02f, -1.73642457e-01f, 5.70861138e-02f, 1.47437558e-01f, 3.01899165e-02f, 2.44664997e-01f, -1.35573857e-02f,
  -3.78699124e-01f, 1.32129669e-01f, -2.95338221e-02f, 1.13622479e-01f, -1.45888835e-01f, -3.95568833e-02f, 1.88982472e-01f, 1.04804605e-01f, -1.99936479e-01f, 2.17647329e-01f,
  3.87108028e-02f, -2.59768544e-03f, 2.35530645e-01f, 1.59079164e-01f, -5.44244200e-02f, 8.76557902e-02f, -3.10914665e-01f, -9.27302018e-02f, -1.99752301e-01f, 3.17787111e-01f,
  4.87907887e-01f, 1.61956072e-01f, 3.35706472e-01f, 1.41727952e-02f, -2.12024853e-01f, -2.11437955e-01f, -2.23054111e-01f, -6.22116588e-02f, -1.09230042e-01f, 5.13572991e-03f,
  -1.34434760e-01f, -3.08810472e-01f, -2.63630331e-01f, -4.67775501e-02f, 4.60005254e-02f, 7.71940276e-02f, 2.94571429e-01f, 3.71761590e-01f, 3.50854695e-01f, 1.22689359e-01f,
  1.12482674e-01f, 3.34279209e-01f, 5.04381180e-01f, 3.44113111e-01f, 2.97885835e-02f, -1.87137246e-01f, 1.09829061e-01f, 1.98790774e-01f, -1.91159286e-02f, -7.84962922e-02f,
  -3.74285467e-02f, 2.85971463e-01f, -1.40891626e-01f, 1.53941229e-01f, -3.30146140e-04f, 8.15395787e-02f, 3.86863551e-03f, 2.29680732e-01f, 1.52869262e-02f, -6.98346347e-02f,
  -4.36255671e-02f, 6.50203926e-03f, -1.02419779e-01f, -1.17682077e-01f, 7.70559069e-03f, 1.54197228e-03f, 1.31528914e-01f, 1.12852022e-01f, -1.12732448e-01f, -1.07630966e-02f,
  -1.98733330e-01f, -1.46702334e-01f, 8.75422880e-02f, -2.25876823e-01f, -2.33664185e-01f, -2.13354796e-01f, -8.01282898e-02f, -1.31876245e-01f, 5.93976080e-02f, 4.73692566e-02f,
  -2.04956457e-01f, -3.39398272e-02f, -7.51407817e-02f, -2.04827234e-01f, -1.74986079e-01f, -1.15043618e-01f, -2.01039746e-01f, -5.92095256e-02f, -6.12392947e-02f, -1.51426869e-03f,
  -2.05812261e-01f, -2.95021296e-01f, -2.31710970e-01f, 7.61461956e-03f, -1.48409968e-02f, -9.03995484e-02f, -1.69027418e-01f, 4.20058295e-02f, -1.49830226e-02f, -1.56071484e-02f,
  -1.23944528e-01f, -1.53857432e-02f, 1.59007326e-01f, 4.70721275e-02f, -2.03177165e-02f, -8.04892108e-02f, -8.92689079e-02f, -1.09328441e-01f, 2.08989933e-01f, 7.29002953e-02f,
  -9.07376707e-02f, 2.86349617e-02f, -2.02637136e-01f, 3.57331731e-03f, 1.89999491e-02f, -3.58654652e-03f, -2.11641356e-01f, 8.96205101e-03f, -7.82567821e-03f, -1.14516251e-01f,
  5.53860143e-02f, 1.35681823e-01f, -5.54847382e-02f, -1.66996364e-02f, -3.23582930e-03f, -5.50257275e-03f, 5.56956679e-02f, -1.53129920e-01f, -9.05058626e-03f, -5.88442162e-02f,
  5.82165644e-02f, 7.78665347e-03f, -4.71043326e-02f, -9.08727273e-02f, -1.61165729e-01f, -2.33355332e-02f, -7.46976435e-02f, -5.64244902e-03f, 5.27020283e-02f, 3.03736210e-01f,
  -5.71469784e-01f, -2.77955681e-01f, 4.45169508e-01f, -1.05588622e-01f, 5.59212901e-02f, 1.10328265e-01f, 3.76998633e-01f, 8.25516507e-02f, -5.17708026e-02f, 4.24755752e-01f,
  -2.21216157e-01f, -6.11823618e-01f, -2.58928448e-01f, -2.14087501e-01f, -5.15453778e-02f, 6.83160365e-01f, 3.61512780e-01f, 1.23622321e-01f, -1.20445624e-01f, -1.29883021e-01f,
  -1.25112310e-01f, -3.88613418e-02f, -4.08376157e-01f, -2.83536553e-01f, 1.58431325e-02f, -5.38662896e-02f, 1.35236025e-01f, -1.29841492e-01f, -2.28353679e-01f, 1.79316059e-01f,
  5.87561131e-01f, -5.02292454e-01f, 1.83031991e-01f, -5.99715531e-01f, -1.44302275e-03f, 2.68385839e-02f, 3.00883234e-01f, -6.68895692e-02f, -2.69336134e-01f, 1.09002829e-01f,
  -1.80541262e-01f, -2.36086577e-01f, -1.14934407e-01f, -3.93948257e-02f, -5.39871026e-03f, 5.07295877e-03f, -1.39117137e-01f, -2.14023411e-01f, -2.66919702e-01f, -1.67567819e-01f,
  -2.94288039e-01f, -1.84850425e-01f, -1.46447554e-01f, 3.30496803e-02f, -4.70793135e-02f, -1.37830049e-01f, -6.83059171e-02f, -2.80806810e-01f, -3.58083278e-01f, 1.87066689e-01f,
  1.68376878e-01f, 5.21936342e-02f, -1.74996257e-01f, 1.46712750e-01f, -2.32163612e-02f, -2.44258773e-02f, -2.29224861e-01f, -1.78326871e-02f, 2.25444790e-02f, 1.09706208e-01f,
  -2.57471770e-01f, 1.88843518e-01f, 1.24845117e-01f, 8.86899456e-02f, -8.72612149e-02f, 3.57983112e-02f, -9.47516598e-03f, 1.75672919e-02f, -1.75524071e-01f, 1.93783298e-01f,
  -3.85691933e-02f, 1.53642505e-01f, -1.14619620e-01f, 2.13147476e-01f, 3.15275341e-02f, -7.74390846e-02f, 1.53450385e-01f, -6.60850033e-02f, -1.07629284e-01f, 7.63399303e-02f,
  1.73727125e-01f, -4.78249699e-01f, 4.17282671e-01f, -1.98043510e-01f, 2.90002525e-02f, -1.66884214e-01f, 3.33860354e-03f, -4.67411019e-02f, -1.05003022e-01f, -1.42734528e-01f,
  -2.98186749e-01f, -1.18416183e-01f, -4.77935150e-02f, -9.48423054e-03f, 1.89953879e-01f, 1.31803781e-01f, -1.30572189e-02f, -1.53784119e-02f, -9.21024568e-03f, 2.20418051e-01f,
  -1.50654227e-01f, 1.84163570e-01f, 4.54523623e-01f, 3.44483882e-01f, 1.06551889e-02f, 1.32856384e-01f, 4.25762534e-01f, 2.90085763e-01f, 7.27639720e-02f, 6.49221182e-01f,
  1.91415131e-01f, 1.72771707e-01f, 1.51028961e-01f, 1.95841521e-01f, 2.97005057e-01f, -3.30900341e-01f, -6.74039185e-01f, -4.20685023e-01f, 1.76046848e-01f, 6.89651743e-02f,
  2.72873014e-01f, 6.04192168e-02f, 2.81347465e-02f, -2.15975538e-01f, -4.83881503e-01f, -4.09784794e-01f, -3.62474293e-01f, -3.97593766e-01f, -5.60630143e-01f, -5.36671638e-01f,
  -1.46579951e-01f, 1.23793576e-02f, -2.88339471e-03f, 1.21911557e-03f, 6.03004932e-01f, 2.11400285e-01f, 4.70944405e-01f, 3.53101373e-01f, 7.47848079e-02f, 3.50556970e-01f,
  2.60597348e-01f, 3.97828817e-01f, -2.38225251e-01f, 9.22042653e-02f, 2.98420101e-01f, -7.02427104e-02f, -1.33823946e-01f, 2.85096653e-03f, -3.06775179e-02f, 3.90770286e-02f,
  2.85447896e-01f, 1.43310800e-01f, -3.52561027e-02f, -1.04241505e-01f, -4.32170108e-02f, -2.17784092e-01f, -1.38645038e-01f, -1.23201072e-01f, -1.34206295e-01f, 2.00659242e-02f,
  -9.13877711e-02f, 1.40768051e-01f, 2.30124697e-01f, -9.39906389e-02f, 8.62925686e-03f, 6.80476800e-02f, 7.99881816e-02f, 2.54249394e-01f, 2.01812219e-02f, 2.42797196e-01f,
  -9.39294398e-02f, -7.07983878e-03f, 7.38683913e-04f, 4.04520333e-02f, 1.34262955e-02f, 6.25611171e-02f, 7.11910948e-02f, -4.68778461e-02f, 3.70362252e-02f, -4.30412963e-02f,
  -4.18792181e-02f, -8.50382894e-02f, 1.44050727e-02f, 7.28000775e-02f, 1.02260888e-01f, 1.51028559e-01f, 7.00425764e-04f, -6.59927204e-02f, 2.74736006e-02f, 9.32152346e-02f,
  4.51859534e-02f, 5.76656219e-03f, 1.00389183e-01f, 5.86714072e-04f, 2.54443586e-02f, 4.02245000e-02f, 5.62066138e-02f, 2.53657205e-03f, 1.12677060e-01f, 7.17024803e-02f,
  -2.17954908e-02f, -3.38143200e-01f, 6.68276846e-02f, -8.68902504e-02f, 1.75875589e-01f, 1.18167184e-01f, 2.23021522e-01f, -2.45120436e-01f, 1.59174442e-01f, -1.51460797e-01f,
  -6.04634322e-02f, -6.94284067e-02f, 1.97252426e-02f, -6.79434314e-02f, -2.24686146e-01f, 3.80729847e-02f, -2.28872180e-01f, -1.08455285e-01f, -1.93018734e-01f, 2.19488367e-01f,
  -9.87223387e-02f, -3.66117060e-01f, -4.14740711e-01f, -2.55782366e-01f, -8.38731527e-02f, -3.12112451e-01f, -2.04531208e-01f, -4.94045950e-02f, -4.42818880e-01f, -3.23332548e-01f,
  4.41521466e-01f, 4.99050349e-01f, -2.59269141e-02f, 2.96495289e-01f, 1.01453505e-01f, 2.15795055e-01f, 4.21503246e-01f, 3.39831948e-01f, 3.28098983e-01f, 1.72145084e-01f,
  2.60100335e-01f, 3.40901822e-01f, 2.57192224e-01f, 3.06206763e-01f, 3.54184896e-01f, 3.10214102e-01f, 1.91791654e-01f, -2.66576856e-02f, -3.00842989e-02f, -3.41049209e-02f,
  1.85260445e-01f, 5.51081263e-02f, 6.59988075e-02f, -1.03428110e-03f, 1.17353246e-01f, 2.67615356e-02f, 1.94907382e-01f, 1.55682743e-01f, 1.33328468e-01f, 1.96695685e-01f,
  -2.23606333e-01f, 1.65719822e-01f, -6.24939241e-02f, -3.09092253e-02f, -1.34184897e-01f, -7.64525831e-02f, -2.78460439e-02f, -1.75253332e-01f, -3.55430357e-02f, -2.10035164e-02f,
  -1.51230097e-01f, -1.39204845e-01f, -1.26042292e-01f, -9.48591307e-02f, -9.46026221e-02f, -2.18728885e-01f, 9.03373770e-03f, 8.76005813e-02f, 1.26125440e-01f, -7.47384951e-02f,
  9.45930481e-02f, -1.38891295e-01f, -9.54831690e-02f, 1.15638137e-01f, 7.90626332e-02f, -9.61901918e-02f, -7.04876781e-02f, 4.33399715e-02f, 4.01448943e-02f, 5.64479716e-02f,
  -1.61260285e-03f, 1.21401072e-01f, -7.16386065e-02f, -5.75870536e-02f, -3.29109170e-02f, -1.54401109e-01f, -4.79422063e-02f, 1.19310990e-02f, -2.61635762e-02f, -1.36105001e-01f,
  -7.09356144e-02f, 6.19044155e-02f, -5.42681441e-02f, -1.22971237e-01f, -1.94515720e-01f, -3.43546420e-02f, -2.07330305e-02f, -9.88254026e-02f, -1.07928582e-01f, 2.26077829e-02f,
  5.79222552e-02f, -9.64367464e-02f, -2.43023530e-01f, -1.06586263e-01f, -5.89865297e-02f, -1.17738515e-01f, -1.34529933e-01f, -2.12054010e-02f, -1.11625992e-01f, 3.81470248e-02f,
  1.80119678e-01f, -7.98625350e-02f, 1.25389382e-01f, 1.93956465e-01f, 3.29833515e-02f, 1.22741992e-02f, 1.53690279e-01f, 9.89519618e-03f, -1.80563211e-01f, -3.57796922e-02f,
  -1.60434872e-01f, -3.34490463e-02f, -2.62297504e-02f, -5.41460365e-02f, -2.21196637e-01f, -6.62851110e-02f, 1.41222268e-01f, 2.26097777e-01f, 2.51583318e-04f, -1.03899673e-01f,
  7.58730546e-02f, -4.65127565e-02f, -5.27359992e-02f, -3.85742374e-02f, 5.78794703e-02f, -4.10224088e-02f, -2.34938040e-01f, -1.64089099e-01f, -2.10901499e-01f, -1.20348938e-01f,
  6.41260028e-01f, 2.57846892e-01f, -5.56231499e-01f, 7.24811673e-01f, -4.23029006e-01f, -6.92628741e-01f, -6.11280322e-01f, 3.34212072e-02f, 2.94167012e-01f, 2.35919550e-01f,
  -3.00834864e-01f, -3.32659602e-01f, -1.04017004e-01f, -1.95498616e-01f, -3.40341538e-01f, -3.68164890e-02f, 9.64920148e-02f, -2.39223287e-01f, -4.98485208e-01f, -3.72609258e-01f,
  9.01608840e-02f, 4.64250326e-01f, 5.11767030e-01f, 8.98604840e-02f, 2.69592494e-01f, -1.14282086e-01f, 6.36242926e-02f, 1.06639288e-01f, -2.49320447e-01f, 3.14380676e-01f,
  -1.62093490e-01f, 1.17077403e-01f, -4.11081374e-01f, 3.26650406e-05f, -3.81485522e-02f, 2.07873918e-02f, -1.60765171e-01f, 6.93154708e-02f, -1.43328846e-01f, -3.63693051e-02f,
  -2.59532511e-01f, -1.28235608e-01f, -2.08026960e-01f, -1.43956095e-01f, -7.88616538e-02f, -3.27398449e-01f, 2.71945894e-01f, -1.43792331e-02f, 4.98156659e-02f, -1.79626063e-01f,
  -1.33439392e-01f, -2.71812201e-01f, -3.45036030e-01f, -2.28438124e-01f, -1.21005177e-01f, -1.89734101e-01f, -2.51280665e-01f, -2.72956908e-01f, -2.17828274e-01f, 4.71683323e-01f,
  1.38120875e-02f, 8.29342846e-03f, 2.53902990e-02f, 1.21801393e-02f, 1.46711811e-01f, -7.26186037e-02f, 1.05998307e-01f, 2.14761216e-02f, -6.60516927e-03f, -2.84306370e-02f,
  -8.40833783e-02f, 5.07120267e-02f, -1.71930656e-01f, -9.06474739e-02f, -1.50518585e-03f, 4.99922689e-03f, -1.91189721e-01f, 5.99493310e-02f, 8.99814963e-02f, 7.07035139e-03f,
  4.19287011e-02f, -5.36201894e-02f, -3.10605410e-02f, -2.10731197e-02f, -6.28072992e-02f, -4.10576463e-02f, 1.28332749e-01f, 8.84620547e-02f, 2.51808632e-02f, 3.37900817e-02f,
  3.22090000e-01f, -4.71014768e-01f, 1.37542516e-01f, -2.99894280e-04f, -1.65547896e-02f, -1.30862370e-01f, 1.87095825e-03f, -1.69339292e-02f, -4.76261973e-02f, -9.78525355e-02f,
  -2.63905883e-01f, -1.44719303e-01f, -2.34842282e-02f, -9.82866213e-02f, -3.32416654e-01f, -5.45345098e-02f, 4.53619696e-02f, -1.96105510e-01f, -9.99962091e-02f, 4.53460001e-04f,
  4.02267188e-01f, -6.36743307e-02f, -1.41095314e-02f, -6.27192184e-02f, 1.87657088e-01f, -1.20528512e-01f, -1.55963227e-01f, -8.17150697e-02f, -3.78476918e-01f, 4.68887717e-01f,
  7.82056034e-01f, -4.36526686e-01f, -8.07006598e-01f, 3.98298293e-01f, -5.37697375e-01f, -5.58527172e-01f, -6.52291954e-01f, 2.21830845e-01f, 5.05516648e-01f, -4.45092708e-01f,
  -2.33690768e-01f, 3.59358877e-01f, 1.26201302e-01f, 1.05657853e-01f, 2.44811118e-01f, -6.26893282e-01f, -5.61243474e-01f, -1.73177764e-01f, 2.30681822e-01f, 6.30052909e-02f,
  9.08545181e-02f, 3.67310435e-01f, 4.55252767e-01f, 1.94946587e-01f, -3.74449968e-01f, -1.15011178e-01f, -3.99834514e-01f, -3.84218454e-01f, -4.12599057e-01f, -7.80829191e-01f,
  -4.92174476e-01f, -3.12524468e-01f, -3.28422035e-03f, 2.22156316e-01f, -6.79457337e-02f, 1.73756897e-01f, 7.96353146e-02f, -6.89552799e-02f, 1.27845138e-01f, -1.34703800e-01f,
  -9.12156105e-02f, 2.15485394e-01f, 8.15663710e-02f, -7.93475881e-02f, -2.32565049e-02f, 1.86691340e-02f, 1.49912789e-01f, 9.39979330e-02f, -6.17501214e-02f, -2.02726707e-01f,
  -2.96274513e-01f, -4.47349072e-01f, -2.03456864e-01f, -2.04885572e-01f, -1.34920239e-01f, -6.04745783e-02f, -3.46934319e-01f, -3.23386848e-01f, -2.13132411e-01f, -3.14654499e-01f,
  4.62223813e-02f, -3.24535817e-02f, -4.62040603e-02f, 7.22381771e-02f, 1.84751540e-01f, -8.25327635e-02f, 1.37656210e-02f, -1.47956625e-01f, 3.13209295e-02f, -1.39686555e-01f,
  6.68490455e-02f, -5.22653237e-02f, -3.51302279e-03f, -6.02640323e-02f, -1.35327727e-01f, -3.98684032e-02f, -1.33039162e-01f, -9.12198201e-02f, -1.09794833e-01f, -5.50691411e-02f,
  -1.13704661e-02f, 1.78223886e-02f, 1.96745675e-02f, 3.86748537e-02f, -1.36250004e-01f, 1.75951552e-02f, -3.34692677e-03f, 8.68597776e-02f, 1.44088641e-01f, -1.44956373e-02f,
  4.08445030e-01f, -6.43920898e-02f, -1.08867072e-01f, 5.63982129e-02f, -1.18545197e-01f, 3.43224802e-03f, 2.83779837e-02f, 4.37891344e-03f, 3.54630873e-02f, 3.23960967e-02f,
  -1.53850093e-01f, 2.03937784e-01f, 7.38038048e-02f, 4.92597520e-02f, -7.75061361e-03f, -1.85229571e-03f, 9.45340246e-02f, -1.34720325e-01f, -2.97247898e-02f, 2.68191863e-02f,
  6.91854581e-02f, -4.97887507e-02f, 2.30208144e-01f, 7.77081698e-02f, 8.71368125e-03f, 2.43877381e-01f, -3.54127109e-01f, -2.59097159e-01f, 9.19832140e-02f, -2.20872185e-04f,
  -3.36206019e-01f, 2.88510084e-01f, 6.22083902e-01f, -2.09031612e-01f, -1.46084324e-01f, -1.68895632e-01f, -2.32137173e-01f, -3.04426372e-01f, -3.36707546e-03f, 1.63776428e-01f,
  6.71467632e-02f, -4.47648376e-01f, -1.52063698e-01f, -3.58641177e-01f, -3.94347101e-01f, 9.71483514e-02f, 1.08243696e-01f, -1.80156857e-01f, -3.93550962e-01f, -5.76825440e-01f,
  -4.89721894e-01f, -4.28578645e-01f, -1.45523801e-01f, -6.13852963e-02f, 1.29157886e-01f, -1.86306760e-01f, 4.45819885e-01f, 6.95257783e-02f, 6.42886013e-03f, 2.25378916e-01f,
  2.51707047e-01f, 4.29826945e-01f, -1.00551344e-01f, -1.19870342e-01f, -2.65736710e-02f, -6.72001168e-02f, -2.22128540e-01f, 2.13960901e-01f, -1.24194838e-01f, 1.97496399e-01f,
  -5.92810959e-02f, -1.42309263e-01f, -8.54163840e-02f, 5.32489456e-03f, -4.01914492e-02f, -2.14012548e-01f, 8.80749449e-02f, 1.70473605e-01f, 8.20281804e-02f, 1.42557293e-01f,
  -4.46422935e-01f, -1.92956850e-01f, 3.88029590e-02f, 1.02774590e-01f, 2.43481010e-01f, -2.67214954e-01f, 1.53198600e-01f, 5.98264970e-02f, -2.58112233e-02f, -7.26467222e-02f,
  -1.51683480e-01f, 7.77862743e-02f, 6.07216172e-02f, -7.77670369e-02f, -9.36472118e-02f, 9.98982713e-02f, -3.78680527e-02f, -1.15536407e-01f, -1.70118492e-02f, 3.26573364e-02f,
  7.56597072e-02f, 2.36351672e-03f, 5.59856072e-02f, 8.43483210e-02f, -2.47938782e-02f, 5.78294173e-02f, -1.06527545e-01f, -1.12029850e-01f, 6.01761602e-03f, -9.49670300e-02f,
  -1.39578924e-01f, -7.81115815e-02f, 9.57080803e-04f, -1.02075741e-01f, 1.75710991e-01f, 2.65785307e-02f, -4.25918214e-02f, -1.35504663e-01f, 4.69873212e-02f, 9.01784226e-02f,
  -2.68152744e-01f, 2.81764492e-02f, -1.86102077e-01f, -8.29514191e-02f, 4.94076461e-02f, 3.82539034e-02f, 1.84880290e-02f, -9.36696529e-02f, 7.01538753e-03f, -1.72987893e-01f,
  -4.15556021e-02f, -2.30147034e-01f, 4.51542400e-02f, -6.47206306e-02f, -1.46946177e-01f, 1.93798412e-02f, -2.75051832e-01f, -1.80165306e-01f, -1.43836409e-01f, -8.03117082e-02f,
  -1.85237095e-01f, -5.65190256e-01f, -5.84359109e-01f, -2.81313747e-01f, -2.30480760e-01f, -6.04779422e-01f, -4.58826989e-01f, -4.07166570e-01f, -4.95613098e-01f, -6.58163249e-01f,
  8.03574502e-01f, 1.79561853e-01f, -1.73198670e-01f, -3.16534713e-02f, -4.40939218e-02f, 1.33147817e-02f, 2.65416913e-02f, 1.13844171e-01f, 1.46544099e-01f, 1.07093565e-01f,
  2.91451454e-01f, 2.81357020e-01f, 1.95727959e-01f, 1.41393393e-01f, -1.26196695e-02f, -2.31717855e-01f, -2.64660686e-01f, -6.78569600e-02f, 3.01385093e-02f, -1.21586934e-01f,
  -1.03982300e-01f, -7.65309185e-02f, -2.13937256e-02f, -1.49948820e-02f, -6.62807226e-02f, 4.44535213e-03f, 2.95139402e-02f, -7.03071654e-02f, -1.60738260e-01f, -3.42014492e-01f,
  -6.70363486e-01f, 1.35645615e-02f, 9.45167318e-02f, -4.65308176e-03f, 5.89843690e-02f, 1.07744291e-01f, 9.05466303e-02f, 8.16129968e-02f, 4.93609905e-02f, -7.06881061e-02f,
  -2.18397696e-02f, -6.35481924e-02f, -9.45880115e-02f, 1.06387086e-01f, -3.46841142e-02f, 4.18292917e-02f, 2.17848554e-01f, 1.29346132e-01f, -1.12792544e-01f, -8.39948803e-02f,
  3.64764258e-02f, 1.54145099e-02f, -2.08318587e-02f, 1.49185121e-01f, 1.16905637e-01f, 6.75937301e-03f, 6.22975156e-02f, 1.67158365e-01f, 2.08865672e-01f, 2.88850397e-01f,
  1.74394742e-01f, 1.94285586e-01f, 2.14203689e-02f, 2.14373082e-01f, 1.57790512e-01f, 2.82181837e-02f, -3.94930430e-02f, 5.41713387e-02f, 1.45457923e-01f, 7.14153945e-02f,
  -1.35412784e-02f, -2.35400181e-02f, 1.42741010e-01f, -1.65640801e-01f, -1.52065367e-01f, -5.99348098e-02f, -1.68743998e-01f, -8.30732211e-02f, -7.80244768e-02f, -8.74863416e-02f,
  -1.04341201e-01f, -1.03569783e-01f, -2.12705433e-01f, -2.29217693e-01f, -5.84327057e-02f, 4.87140864e-02f, -1.24507174e-01f, 9.02834162e-02f, -2.15861406e-02f, -1.61158338e-01f,
  -2.52141804e-01f, -4.49340604e-02f, -5.35682961e-02f, -9.56764370e-02f, -7.70369172e-02f, 5.36214858e-02f, -1.20428540e-01f, -7.15575665e-02f, -9.44245905e-02f, -1.07521981e-01f,
  -1.11726299e-01f, -2.77281068e-02f, -1.60453066e-01f, -4.86362502e-02f, -5.81406541e-02f, -1.23541066e-02f, 5.36929742e-02f, 2.38667633e-02f, -1.09473139e-01f, -6.26363382e-02f,
  5.61459213e-02f, 1.31138578e-01f, 1.73417464e-01f, 1.22907765e-01f, 8.79846439e-02f, 6.76430464e-02f, -1.02580324e-01f, 6.63082749e-02f, -1.44936955e-02f, 2.52161831e-01f,
  7.28499293e-01f, -2.88374543e-01f, -4.97775152e-02f, 1.62895292e-01f, 1.64549928e-02f, -3.97225929e-04f, -3.29363793e-02f, 1.32332861e-01f, 1.04805984e-01f, 1.68703217e-02f,
  1.51186258e-01f, 1.10103905e-01f, 2.08418861e-01f, 7.47590810e-02f, 1.34375274e-01f, -1.06903538e-01f, -8.16878118e-03f, 7.23446384e-02f, 2.06253707e-01f, 1.34533206e-02f,
  3.41914818e-02f, 2.88992748e-02f, 1.41983360e-01f, 1.71137601e-02f, -1.21806666e-01f, 5.51871955e-02f, 4.63692413e-04f, 8.46837685e-02f, -1.14733525e-01f, -1.82719335e-01f,
  -1.20358802e-01f, 1.70843095e-01f, 1.46671563e-01f, 7.62773529e-02f, 4.39220620e-03f, 4.97685671e-02f, 1.17545359e-01f, 1.54154729e-02f, -1.56777397e-01f, -5.54619655e-02f,
  -2.94987997e-03f, 7.32527673e-02f, 8.21401924e-02f, 8.32560062e-02f, 8.13605860e-02f, 1.28076881e-01f, 1.52261421e-01f, 4.99207750e-02f, -4.66180742e-02f, -3.93975787e-02f,
  8.50154012e-02f, 9.55030695e-02f, 9.19876993e-02f, -4.37207706e-02f, -8.36138614e-03f, 1.69035077e-01f, -4.21577655e-02f, -3.72028947e-02f, 1.43023849e-01f, 1.80176366e-02f,
  3.24244678e-01f, 3.90968680e-01f, 2.91175544e-01f, 1.74920574e-01f, -9.35432967e-03f, 2.67295539e-02f, 1.22979842e-01f, 4.31297757e-02f, 2.07907617e-01f, 3.23810488e-01f,
  5.43579087e-02f, 3.70880999e-02f, 8.49248394e-02f, 7.81727508e-02f, 2.31555730e-01f, 3.58925670e-01f, 1.10868327e-01f, 1.30775824e-01f, 2.45244175e-01f, 1.22314855e-01f,
  9.51587483e-02f, 7.49246851e-02f, 2.12246537e-01f, 1.28084987e-01f, -7.00921640e-02f, 1.94707602e-01f, 1.44065663e-01f, 1.14891991e-01f, 2.42318213e-01f, 2.04988629e-01f,
  -1.90039068e-01f, 2.71017224e-01f, 6.45206273e-02f, -7.56577253e-02f, 1.93804335e-02f, -1.34155704e-02f, 8.50034803e-02f, -1.72777459e-01f, -3.20368469e-01f, -2.70678788e-01f,
  -1.39290020e-01f, 5.90120209e-03f, 4.28650156e-03f, -5.10600731e-02f, 8.30541626e-02f, 3.56066786e-03f, -7.13965250e-03f, 1.27445638e-01f, -2.18921468e-01f, -5.04064709e-02f,
  -7.94685036e-02f, 5.31013981e-02f, 6.79115206e-02f, 3.25329369e-03f, -5.37167303e-02f, 2.60125667e-01f, -7.20315352e-02f, 1.02203889e-02f, 1.23938307e-01f, 2.18489710e-02f,
  -6.52723387e-02f, 4.38642323e-01f, -1.10344455e-01f, 1.52393207e-01f, -2.05992401e-01f, -4.47996348e-01f, -2.16257766e-01f, -2.05263853e-01f, 2.55311131e-02f, 2.93606460e-01f,
  1.46466538e-01f, -2.72281119e-03f, 1.91010814e-02f, -2.05820516e-01f, -4.14879322e-01f, 1.76196814e-01f, 4.77574542e-02f, -2.23238781e-01f, -5.65764964e-01f, -4.70575333e-01f,
  -4.82715033e-02f, 6.45102412e-02f, -1.65570289e-01f, -9.78711545e-02f, 2.52822995e-01f, 1.25556812e-01f, 3.08072865e-01f, 1.33939823e-02f, 9.84190702e-02f, 3.82940084e-01f,
  2.49599084e-01f, -1.19475223e-01f, -1.63586438e-01f, 5.92335910e-02f, 1.38422370e-01f, -3.21656242e-02f, 7.19054881e-03f, -3.25619206e-02f, 1.64854582e-02f, 1.02187119e-01f,
  -2.19076406e-02f, 3.17925587e-03f, -9.53446105e-02f, -5.40528931e-02f, -5.41151082e-03f, -1.57916501e-01f, 1.29679395e-02f, -1.61868691e-01f, -1.12351075e-01f, 6.16718642e-02f,
  8.51275772e-02f, -1.22714557e-01f, -1.73554599e-01f, -5.09695783e-02f, -1.36005566e-01f, -1.23590283e-01f, -9.09448601e-03f, -1.50183454e-01f, -3.30740750e-01f, 2.98016101e-01f,
  -8.66485760e-02f, 6.43087104e-02f, 1.11102853e-02f, 7.45036006e-02f, 1.33545160e-01f, -2.95364689e-02f, 1.43166706e-01f, 1.19522616e-01f, -1.18611760e-01f, 1.06757574e-01f,
  -4.33684997e-02f, 5.78649491e-02f, 9.77800973e-03f, 5.42686880e-02f, 5.00736721e-02f, -1.41953584e-03f, -1.89235304e-02f, 1.04469351e-01f, 4.89278398e-02f, 3.47630940e-02f,
  3.99946943e-02f, -6.77764714e-02f, 1.84814170e-01f, 7.68272728e-02f, 9.50100273e-03f, 2.53235847e-02f, -2.06671916e-02f, -7.61752650e-02f, -7.26885814e-03f, -1.03603154e-02f,
  3.58253986e-01f, -3.80013913e-01f, 3.13844681e-01f, -5.38048968e-02f, 1.19720489e-01f, 1.09468333e-01f, 7.43137896e-02f, 1.45562693e-01f, 7.72387460e-02f, 1.34610593e-01f,
  -8.21917653e-02f, -3.62041965e-02f, 9.55497324e-02f, -2.03879625e-02f, -1.08610511e-01f, -1.01044029e-01f, 1.31799996e-01f, 1.44478887e-01f, -6.87955096e-02f, 8.09448212e-02f,
  1.88268960e-01f, -5.70370108e-02f, -3.97520438e-02f, 1.22989431e-01f, -9.11741108e-02f, -1.56575829e-01f, 9.40637141e-02f, 8.34339187e-02f, -1.30199686e-01f, 3.13718021e-01f,
  2.48176113e-01f, 3.61296594e-01f, 8.40286165e-02f, 3.32189918e-01f, 5.28125405e-01f, 4.40323770e-01f, 2.79213995e-01f, 1.39544040e-01f, -2.95725986e-02f, 2.88150609e-01f,
  4.32175010e-01f, 3.75609040e-01f, 1.63586453e-01f, 1.29097268e-01f, 1.62464473e-02f, -6.64017126e-02f, -1.42613292e-01f, -2.46892244e-01f, -2.27343589e-01f, 1.76510215e-01f,
  2.21338362e-01f, 1.41831204e-01f, -7.10859969e-02f, 2.44174451e-02f, 2.29176193e-01f, 2.50361621e-01f, 1.09936170e-01f, 4.28214490e-01f, 2.20588684e-01f, -6.96721897e-02f,
  -6.53991923e-02f, 1.05381005e-01f, -3.45340908e-01f, 5.97836785e-02f, 1.18853457e-01f, -3.09685826e-01f, -6.42567277e-02f, -1.76336646e-01f, -5.40507734e-02f, -9.66321081e-02f,
  6.02410659e-02f, -8.24334472e-02f, 1.22119971e-01f, -1.47169754e-01f, 3.87150049e-02f, -1.99605256e-01f, -1.50751129e-01f, -2.05313534e-01f, -6.75266907e-02f, -6.62016943e-02f,
  1.59748822e-01f, 1.34665564e-01f, 1.11444779e-02f, -9.75083839e-03f, 8.42552409e-02f, 7.62534216e-02f, -1.25215268e-02f, -9.17452052e-02f, -9.07542035e-02f, -1.48642585e-01f,
  -4.36454415e-02f, -9.34347138e-03f, 1.67638749e-01f, 1.93241946e-02f, -3.84607092e-02f, -2.10492350e-02f, -5.67054749e-02f, 1.80621386e-01f, 3.86708714e-02f, -8.33005533e-02f,
  -8.47158767e-03f, -8.42203945e-02f, -1.10709578e-01f, -1.43285748e-02f, -2.84073921e-03f, 2.39649899e-02f, -1.24059364e-01f, -3.52411810e-03f, 5.66315390e-02f, -2.96968017e-02f,
  -1.58158783e-02f, -1.61480755e-01f, -9.96934026e-02f, -4.19905409e-02f, -1.73127264e-01f, -5.63497953e-02f, -1.46267876e-01f, 7.70737752e-02f, 1.17886446e-01f, -1.83410108e-01f,
  -6.11157604e-02f, 4.97635528e-02f, -1.34384230e-01f, -1.81299016e-01f, 6.66719154e-02f, -6.87296242e-02f, 3.69862318e-02f, -6.72968477e-02f, 3.29953507e-02f, -1.36990115e-01f,
  -2.78773298e-03f, -9.63731483e-02f, 5.20085134e-02f, -9.30429474e-02f, -1.76685542e-01f, -1.52798757e-01f, 1.14192568e-01f, -1.08151965e-01f, -1.34575546e-01f, -1.03330284e-01f,
  -7.74034706e-05f, -7.60881901e-02f, -1.69483438e-01f, -1.08171500e-01f, -9.52115208e-02f, -5.20856678e-02f, -8.62101391e-02f, -4.93829884e-02f, -8.69714767e-02f, -1.38395086e-01f,
  -1.16572082e+00f, -7.89402276e-02f, 7.32784986e-01f, -3.24974775e-01f, 3.39289159e-01f, 1.28520997e-02f, -3.17629308e-01f, -3.50385994e-01f, -1.18258171e-01f, -3.06531824e-02f,
  -4.65649851e-02f, -1.42848626e-01f, 3.09736699e-01f, 1.86127394e-01f, -3.21612686e-01f, 1.97681457e-01f, 5.99350512e-01f, 1.32229194e-01f, -2.45696232e-01f, -7.05496609e-01f,
  -1.37268692e-01f, -1.46923125e-01f, -4.36728209e-01f, -1.63838100e-02f, 7.34430924e-02f, 1.47953808e-01f, 5.15375972e-01f, 2.00265311e-02f, 6.57102391e-02f, 2.20816955e-01f,
  -3.60369802e-01f, -4.01091009e-01f, 2.77065426e-01f, 8.90034810e-02f, 3.42254639e-01f, -1.58429772e-01f, -1.95517480e-01f, 9.57535356e-02f, -1.90952748e-01f, 8.38952065e-02f,
  1.43210888e-01f, -1.49162769e-01f, 9.21839997e-02f, -9.51753557e-03f, -2.92521447e-01f, -2.78897732e-01f, 3.35674435e-02f, -2.08851561e-01f, -5.67264408e-02f, -2.56398946e-01f,
  -5.49968053e-03f, -2.41422832e-01f, -5.34535497e-02f, 2.11260654e-02f, -2.28450909e-01f, 2.27472596e-02f, -1.73205182e-01f, -5.15981376e-01f, -3.25456500e-01f, -5.88727772e-01f,
  -1.06748901e-01f, 6.69882074e-02f, 6.51900321e-02f, -7.37677887e-02f, -1.21933140e-01f, 1.02940507e-01f, 8.09493810e-02f, 9.41866934e-02f, 2.57680435e-02f, -6.14839979e-02f,
  1.34300202e-01f, -1.34767368e-01f, 2.28589028e-02f, 2.01245683e-04f, -1.73405707e-01f, -1.73141900e-02f, -9.09557268e-02f, -1.01182563e-02f, 5.21929376e-02f, 5.82657522e-03f,
  -9.51062739e-02f, -3.81652452e-02f, 2.38571763e-01f, -1.34805232e-01f, 1.37404084e-01f, 1.59271762e-01f, 2.24252921e-02f, -1.23811044e-01f, -5.38144894e-02f, -8.96035060e-02f,
  -2.34342158e-01f, 5.13888657e-01f, -1.44888461e-01f, 3.10743768e-02f, 1.30545914e-01f, 1.68702051e-01f, 3.92184593e-02f, -1.76944118e-02f, -8.91509838e-03f, -1.64474875e-01f,
  -2.51181871e-01f, -1.55546248e-01f, 1.61491171e-01f, 5.75727746e-02f, -2.02144161e-01f, -8.31597857e-03f, 5.15521169e-02f, 1.20352753e-01f, -7.89638236e-03f, -5.05602919e-02f,
  2.27295890e-01f, -4.39383119e-01f, -4.89377707e-01f, -2.18959540e-01f, -2.44670510e-01f, -3.18687856e-01f, -2.18196183e-01f, -3.39988351e-01f, -2.19262823e-01f, -7.38890946e-01f,
  6.01278424e-01f, -4.19370919e-01f, -2.63860524e-02f, 3.28719884e-01f, 2.93581337e-01f, 8.41423944e-02f, 1.29801825e-01f, 1.35318607e-01f, 2.62895226e-01f, 2.73607895e-02f,
  -1.38598651e-01f, -1.75705463e-01f, -9.03927442e-03f, -2.03451112e-01f, -1.11505061e-01f, 9.69168842e-02f, 1.66158006e-01f, 9.58958119e-02f, 1.37924939e-01f, -6.14906959e-02f,
  -1.25761777e-01f, 1.04087651e-01f, 5.40718585e-02f, -1.35464936e-01f, -2.28904709e-01f, 4.35749516e-02f, -7.44935274e-02f, -1.70181841e-01f, -3.41824383e-01f, -2.63897985e-01f,
  -2.79685855e-01f, -4.12188023e-01f, 1.48083746e-01f, -1.77451745e-01f, -2.62083709e-02f, 1.87336020e-02f, 4.25665863e-02f, -1.03750542e-01f, 1.10858660e-02f, 9.27219540e-02f,
  -7.36105070e-02f, -9.46149454e-02f, -8.07617307e-02f, -9.12495926e-02f, -2.61084568e-02f, 4.67411429e-02f, -1.36914939e-01f, -5.21475263e-02f, -2.13097021e-01f, -2.22891077e-01f,
  -2.55160302e-01f, -1.86860323e-01f, 1.56021127e-02f, -6.02637138e-03f, -1.24775946e-01f, 9.61294631e-04f, -1.46149978e-01f, -2.28906665e-02f, -1.94910597e-02f, 1.47509515e-01f,
  -1.06893621e-01f, -4.09412244e-03f, -2.25772917e-01f, -2.66801193e-02f, -1.38155920e-02f, 1.07896186e-01f, -6.20678486e-03f, -3.34394276e-02f, -3.31530795e-02f, 6.53582290e-02f,
  2.26435927e-03f, -5.56105711e-02f, -4.28690463e-02f, 1.04857519e-01f, -1.70533702e-01f, -2.50063360e-01f, -1.33503480e-02f, -8.77139196e-02f, -1.43530250e-01f, -1.51628613e-01f,
  -1.23658739e-01f, -1.08835861e-01f, -3.12404726e-02f, -2.30691880e-01f, -2.44791403e-01f, -1.39982617e-02f, -1.13059007e-01f, -1.19718626e-01f, -4.60980833e-02f, 6.46292046e-02f,
  2.04561092e-03f, -2.68455178e-01f, 1.16012879e-01f, -1.26434609e-01f, -5.16042039e-02f, -7.39849508e-02f, -2.27955416e-01f, 8.16019194e-04f, 8.11395422e-03f, -4.10890728e-02f,
  -5.15606441e-02f, 4.70543392e-02f, -4.04092297e-02f, -2.31565367e-02f, 1.80885211e-01f, 3.82157206e-03f, -2.39977390e-02f, 2.75354125e-02f, -4.73145209e-02f, -9.32368562e-02f,
  -1.21598132e-01f, 2.13321477e-01f, 2.17070803e-01f, 2.23377004e-01f, 1.77666649e-01f, 2.97126412e-01f, 2.18460575e-01f, 1.27568468e-01f, 2.34684348e-01f, 5.19590318e-01f,
  -8.03604603e-01f, -3.02158415e-01f, -3.15402240e-01f, -3.56749266e-01f, 9.18932706e-02f, 4.48042423e-01f, 5.90446293e-01f, 1.71668261e-01f, -1.98634461e-01f, -2.74497211e-01f,
  -3.28517944e-01f, -2.78389364e-01f, -3.60665023e-01f, 6.57360777e-02f, 1.12539440e-01f, 2.10510746e-01f, 2.64018148e-01f, 4.37023230e-02f, 3.49882901e-01f, 4.33632910e-01f,
  2.43398055e-01f, -1.42251357e-01f, -2.15213418e-01f, 5.81492595e-02f, -5.25438152e-02f, -4.40615490e-02f, -2.14902073e-01f, -4.48096320e-02f, 2.01433580e-02f, 2.53284127e-02f,
  -7.53544688e-01f, -2.48342812e-01f, 3.50944370e-01f, -2.19155535e-01f, -2.41154194e-01f, -5.73475435e-02f, 9.33029950e-02f, -1.70002371e-01f, -3.67536731e-02f, -1.25306677e-02f,
  -1.23065054e-01f, 6.86203912e-02f, -2.12256432e-01f, 1.94859300e-02f, -1.68104827e-01f, 3.23017105e-03f, 1.58385318e-02f, 6.97858185e-02f, -7.98835978e-02f, -7.25994632e-02f,
  2.58226156e-01f, -9.89995375e-02f, -2.37046108e-01f, 2.98932284e-01f, 7.37492889e-02f, -2.60829657e-01f, -2.85962899e-03f, 1.04880400e-01f, -9.66744572e-02f, -2.94477403e-01f,
  1.66649353e-02f, -8.33280087e-02f, 5.41984588e-02f, -6.65480494e-02f, 3.08036357e-02f, 5.93929440e-02f, 1.14711113e-01f, 1.18243679e-01f, -1.79835726e-02f, 2.29966789e-02f,
  7.26731494e-02f, -5.01665883e-02f, 1.05103277e-01f, -9.90583301e-02f, -1.56329870e-01f, -4.26083282e-02f, 8.79855156e-02f, 5.24426661e-02f, 2.02084128e-02f, -7.41225407e-02f,
  -5.57719208e-02f, 1.81226917e-02f, -7.14911148e-02f, 1.56346858e-01f, 1.13915496e-01f, 5.86778671e-02f, -1.17836513e-01f, -2.45466884e-02f, -2.10787192e-01f, 2.76259109e-02f,
  -4.52766806e-01f, 2.38927171e-01f, -2.45533958e-01f, 7.54534379e-02f, -1.09611936e-01f, -6.03495501e-02f, -4.23676856e-02f, -5.14018573e-02f, -1.34498775e-01f, 3.98879088e-02f,
  3.64204347e-02f, -2.61551365e-02f, -2.02319488e-01f, 2.29923934e-01f, 9.93827656e-02f, 8.18521380e-02f, 1.43891275e-01f, 1.21854313e-01f, -1.31603200e-02f, -3.36396210e-02f,
  2.10324042e-02f, 1.98099524e-01f, -3.02671075e-01f, -5.98405264e-02f, 2.27448680e-02f, -1.75665617e-01f, -1.07217126e-01f, -9.34878066e-02f, -5.68507612e-02f, -1.87995806e-01f,
  -6.87853098e-01f, 3.05978227e-02f, -4.96395677e-01f, -1.87950179e-01f, 2.55664617e-01f, -1.30498797e-01f, -4.16238040e-01f, -6.82411551e-01f, -7.75898099e-02f, 2.23453552e-01f,
  4.19986099e-01f, 4.51037467e-01f, -3.05032264e-02f, -1.10526256e-01f, -3.84298474e-01f, -1.85680985e-01f, -3.24170142e-01f, -4.85203892e-01f, -2.47142375e-01f, 3.53624761e-01f,
  5.44825613e-01f, -3.43086794e-02f, -1.37958780e-01f, -1.86872959e-01f, 1.87989339e-01f, 2.43359730e-01f, -6.81029260e-02f, 1.78818762e-01f, 2.55960166e-01f, 2.98454493e-01f,
  3.25348169e-01f, -4.09924954e-01f, -1.45208225e-01f, 7.82438889e-02f, 1.07826933e-01f, -1.49467662e-01f, -4.75770794e-02f, -2.27456406e-01f, -7.74628595e-02f, -9.45088193e-02f,
  1.88281730e-01f, 8.85153189e-02f, -6.16543144e-02f, 1.59474760e-01f, 1.14637814e-01f, -2.74132453e-02f, -1.48494408e-01f, -5.31818092e-01f, -4.53092247e-01f, 3.08278818e-02f,
  4.18035328e-01f, 2.01691926e-01f, -1.41718000e-01f, -2.92673916e-01f, -2.22938716e-01f, 8.32050964e-02f, 5.15546091e-02f, -4.93650623e-02f, -5.59538066e-01f, -1.60146177e-01f,
  1.60142303e-01f, 1.33896619e-01f, 9.57048312e-02f, 6.53153565e-03f, 1.56329706e-01f, 6.67924732e-02f, 1.08279213e-02f, 1.67578638e-01f, -5.83207346e-02f, -8.35035369e-02f,
  3.00031081e-02f, -1.35545060e-01f, -9.67162549e-02f, -2.13989004e-01f, -1.06741078e-01f, -6.25673775e-03f, 8.70472342e-02f, -1.35270075e-03f, -9.06991139e-02f, -4.95767556e-02f,
  1.56900927e-01f, -7.83531293e-02f, 1.08024096e-02f, -8.82062167e-02f, 2.26053208e-01f, -1.77648757e-02f, 7.04270154e-02f, 1.17460467e-01f, -3.34973484e-02f, 1.39354259e-01f,
  2.03248620e-01f, -1.98648810e-01f, 2.38850653e-01f, -5.73933497e-02f, -3.64646688e-03f, 9.13257673e-02f, 1.96771756e-01f, 2.20557377e-02f, -9.87931434e-03f, -8.27723071e-02f,
  9.12718475e-03f, -1.14177510e-01f, 7.66109973e-02f, 9.44367498e-02f, 1.56903625e-01f, 9.73148197e-02f, 1.44273967e-01f, 8.09818506e-02f, -5.72172701e-02f, 1.21093795e-01f,
  -1.53855607e-01f, -1.83507532e-01f, -5.80205657e-02f, -2.17747614e-01f, 1.94337696e-01f, -3.33385319e-02f, -4.92187515e-02f, -6.66915700e-02f, -3.22406650e-01f, -2.32925147e-01f,
  6.01759404e-02f, -1.72314614e-01f, 1.96460128e-01f, 1.70245588e-01f, 5.55667281e-03f, -1.09560899e-01f, -2.61320055e-01f, -1.13594919e-01f, 4.49353392e-04f, 2.73851007e-02f,
  -1.97074991e-02f, 2.51174718e-01f, 2.53819108e-01f, 2.32654035e-01f, 2.34550849e-01f, 1.50824085e-01f, 1.80998296e-01f, 3.27375591e-01f, 2.31509909e-01f, 6.59408718e-02f,
  1.49518996e-01f, 2.40303442e-01f, 2.22345889e-01f, 2.22618416e-01f, 3.60467881e-02f, 2.45293155e-01f, 1.52569905e-01f, 1.14896797e-01f, 5.54498844e-02f, 1.76883668e-01f,
  -1.62356645e-01f, -9.03194770e-02f, 1.35270312e-01f, 7.80919492e-02f, -1.38695417e-02f, -1.43717900e-01f, -6.47662207e-02f, -3.42186578e-02f, 2.86277793e-02f, -1.21908225e-01f,
  -8.79817009e-02f, -5.81636243e-02f, -6.90951124e-02f, -1.15087941e-01f, -9.19438973e-02f, -6.37705401e-02f, 8.53984952e-02f, 1.49631709e-01f, 9.61463004e-02f, -1.89430062e-02f,
  5.31591550e-02f, -1.68863580e-01f, -1.60734028e-01f, -6.80900738e-02f, 9.29381624e-02f, 1.74373955e-01f, 1.58228986e-02f, -9.91552472e-02f, 1.14353085e-02f, -1.72373235e-01f,
  1.20555706e-01f, 7.00084344e-02f, 2.18618512e-01f, 2.43042856e-01f, 1.50920361e-01f, 2.60522068e-02f, 1.37022749e-01f, 1.38304876e-02f, 4.75970656e-02f, -1.10363290e-01f,
  8.70720595e-02f, 1.04105636e-01f, 4.34197970e-02f, -5.93982488e-02f, 1.47955254e-01f, 3.48526606e-04f, -4.87582199e-02f, 9.18031260e-02f, -4.37091105e-02f, -5.67904732e-04f,
  1.43715829e-01f, 6.20199181e-02f, -3.89376581e-02f, 8.11316893e-02f, -1.91160180e-02f, 9.18484256e-02f, 1.46345384e-02f, -6.52205646e-02f, 4.55666743e-02f, -7.32137337e-02f,
  -1.00352094e-01f, 2.08608255e-01f, -8.69583711e-02f, -1.98995750e-02f, -1.15207329e-01f, -7.61885270e-02f, -9.25612971e-02f, -1.96619749e-01f, -1.76976740e-01f, -1.26847848e-01f,
  -8.88725370e-02f, -1.79135185e-02f, -2.68784333e-02f, -4.31617014e-02f, -3.37117091e-02f, -5.96612059e-02f, -7.54589867e-03f, 6.45097420e-02f, -4.12837192e-02f, -2.40696505e-01f,
  -8.08302984e-02f, -1.52158946e-01f, -3.28025848e-01f, -1.23254076e-01f, -1.30165964e-01f, -1.24539308e-01f, -1.17050782e-01f, -1.76398009e-01f, -2.29880005e-01f, -2.96159625e-01f,
  -5.28589666e-01f, -3.58974963e-01f, -7.36057997e-01f, -7.92522848e-01f, -3.98933053e-01f, -4.96646166e-02f, 1.82344899e-01f, 2.98131675e-01f, -8.44250768e-02f, -3.00604612e-01f,
  -1.32316992e-01f, -2.18292713e-01f, -5.16472459e-01f, -6.77177459e-02f, 1.49654970e-01f, -2.35791415e-01f, -4.65290010e-01f, -4.12061095e-01f, -1.60425808e-02f, 3.73300254e-01f,
  1.16112232e-01f, -1.82626083e-01f, -2.70025671e-01f, -1.75515577e-01f, -3.75398844e-01f, -3.41086060e-01f, -6.43483281e-01f, -4.11203891e-01f, -3.59882712e-02f, -5.15127063e-01f,
  -4.75708246e-01f, -1.53023496e-01f, 6.37888387e-02f, 1.15848430e-01f, -2.93556333e-01f, 2.84824520e-03f, 2.55154427e-02f, -1.83720663e-01f, 2.85686366e-03f, -6.48220256e-02f,
  -1.95758924e-01f, 9.97025296e-02f, -1.51037559e-01f, -2.63336655e-02f, -2.22330227e-01f, 6.15482219e-02f, -1.77120432e-01f, -4.80051264e-02f, -1.08010620e-01f, 1.48880273e-01f,
  2.26753086e-01f, 2.15835497e-02f, -8.15286711e-02f, 9.03479308e-02f, 2.56118000e-01f, -2.21691970e-02f, 4.01349850e-02f, 2.68719554e-01f, 1.86731324e-01f, -2.63370216e-01f,
  6.63213432e-02f, -7.83452168e-02f, 4.92691360e-02f, 1.12382226e-01f, 1.29574522e-01f, 4.36311923e-02f, -1.11492366e-01f, -3.22140567e-02f, 1.29401743e-01f, -1.12976711e-02f,
  -7.74063021e-02f, -1.32515123e-02f, -3.22459973e-02f, 6.38694391e-02f, -1.06755234e-01f, -9.03794989e-02f, 3.65308300e-02f, -2.31556855e-02f, 1.80780478e-02f, 5.58251739e-02f,
  3.67582776e-02f, 5.82197309e-02f, -2.00325057e-01f, 9.58564803e-02f, 1.10944629e-01f, -4.76659611e-02f, -4.89992462e-02f, 2.12885842e-01f, 1.03371449e-01f, 1.33409575e-01f,
  -4.99990523e-01f, 2.12228492e-01f, -2.66622543e-01f, 1.08436316e-01f, -1.49488509e-01f, -8.34801793e-02f, -1.70697942e-01f, 1.46356836e-01f, -1.00847200e-01f, -1.01298496e-01f,
  1.58948079e-01f, -6.12681806e-02f, -2.43510827e-01f, -6.54582679e-02f, 8.25070068e-02f, 1.27642736e-01f, 1.68347627e-01f, -2.23378360e-01f, 1.86380342e-01f, 1.19134940e-01f,
  6.24097213e-02f, 2.75062382e-01f, 1.75815895e-02f, -1.18641600e-01f, 1.64946914e-01f, 8.30983464e-03f, -5.27901463e-02f, 1.22990012e-01f, 1.40459672e-01f, 2.86494065e-02f,
  -7.68822610e-01f, -1.24807864e-01f, 3.19276422e-01f, -7.56002665e-01f, -2.26960137e-01f, 3.18872094e-01f, 4.00521308e-01f, 7.31629655e-02f, -4.65338528e-01f, -7.56865218e-02f,
  -1.46273330e-01f, -2.45110273e-01f, -2.69438386e-01f, 1.40398756e-01f, 3.29673409e-01f, 2.20193952e-01f, 1.61434352e-01f, 2.66084820e-01f, 3.36839974e-01f, 3.79164100e-01f,
  1.94110990e-01f, -1.49858370e-01f, -5.38051799e-02f, -5.81893250e-02f, -2.55809814e-01f, -1.59332901e-01f, -9.86408815e-02f, -7.39146844e-02f, 1.85039386e-01f, -2.73163199e-01f,
  3.41689497e-01f, -3.69010359e-01f, 7.53305629e-02f, -1.45059839e-01f, 2.92461701e-02f, -7.93120340e-02f, -4.91419621e-02f, -9.93918255e-02f, -2.37428173e-01f, -6.70409650e-02f,
  -2.95068502e-01f, -8.39329809e-02f, -3.20312053e-01f, 7.82832801e-02f, -1.17676735e-01f, -4.17191011e-04f, 8.06781426e-02f, 1.64315775e-01f, 2.33583823e-02f, 2.01266944e-01f,
  1.28446454e-02f, -5.33474572e-02f, -6.60593882e-02f, 2.38412365e-01f, 1.26254797e-01f, 1.97678767e-02f, 9.49904025e-02f, 4.21357974e-02f, 8.48719329e-02f, -7.10404366e-02f,
  5.92823885e-02f, 5.19432463e-02f, 3.57164219e-02f, -6.43747672e-03f, 2.92479377e-02f, -1.10332491e-02f, 2.46527176e-02f, 1.45366518e-02f, -3.83324437e-02f, -1.69837162e-01f,
  -8.51550698e-02f, 9.15685892e-02f, 5.57216629e-03f, -1.19050883e-01f, -8.77027661e-02f, -4.09505256e-02f, -1.95568148e-02f, -3.50338407e-02f, 3.37836668e-02f, -9.47029069e-02f,
  -1.04871824e-01f, -4.18519489e-02f, -1.51264369e-01f, 8.18330329e-03f, 2.07839742e-01f, 4.64531295e-02f, -8.44153017e-02f, 4.28004935e-02f, -5.87845333e-02f, 3.00074536e-02f,
  -1.54419001e-02f, 2.73322254e-01f, -2.80330479e-01f, -1.30998164e-01f, -1.80096015e-01f, -9.20907781e-02f, -1.69480383e-01f, -3.89128625e-02f, -1.87864646e-01f, -8.96856785e-02f,
  2.08635721e-02f, -9.27875564e-02f, -1.04149863e-01f, 5.21997660e-02f, 1.58378586e-01f, -1.95885692e-02f, -7.38583431e-02f, -1.54582858e-01f, -8.20861459e-02f, 1.09200917e-01f,
  7.30527863e-02f, -4.78387959e-02f, 4.56738584e-02f, -4.34271768e-02f, -1.19065762e-01f, -5.90279885e-02f, 7.84687176e-02f, 1.29967079e-01f, 2.14568704e-01f, 1.25604883e-01f,
  6.89744115e-01f, -4.84312952e-01f, 7.37269670e-02f, -1.42205507e-01f, -3.71949881e-01f, -2.70563632e-01f, -5.08382976e-01f, -2.13114098e-01f, 1.40183568e-02f, -3.67065817e-01f,
  -4.19019252e-01f, -2.00171202e-01f, -8.84052143e-02f, -2.56114453e-02f, 7.65223652e-02f, -2.46171653e-02f, 3.32165286e-02f, 3.74516457e-01f, 3.61681879e-01f, -3.14668939e-02f,
  -6.50734603e-02f, 1.31159276e-01f, 2.59582192e-01f, 1.36813521e-01f, -3.91049981e-02f, -5.59930950e-02f, -1.68984458e-01f, -1.66967481e-01f, -2.91587561e-01f, -6.39522299e-02f,
  2.23578070e-03f, 1.02289602e-01f, 2.17903450e-01f, 1.02867633e-01f, 6.42877594e-02f, 1.31641790e-01f, 6.46610335e-02f, -5.42248711e-02f, -3.69593240e-02f, -3.33092138e-02f,
  9.12398398e-02f, 6.94744242e-03f, 7.99758807e-02f, -1.09764440e-02f, 3.66407484e-02f, 5.54961972e-02f, 8.11794400e-02f, 6.18495746e-03f, -1.62579075e-01f, -1.06555521e-01f,
  -1.22101337e-01f, -4.46579456e-02f, -4.39411439e-02f, -1.12788947e-02f, 1.25051126e-01f, 8.36135224e-02f, -7.24164769e-02f, 1.11153737e-01f, 9.72384736e-02f, -3.36219333e-02f,
  2.89931223e-02f, 4.02858593e-02f, 1.02769114e-01f, 2.84984969e-02f, -2.62270495e-02f, -1.65134519e-02f, -2.82912944e-02f, 5.13444096e-02f, 9.66180190e-02f, 1.15113467e-01f,
  -1.70702711e-01f, -8.09261873e-02f, -9.11361501e-02f, 8.10829997e-02f, 8.08483362e-02f, -7.24556074e-02f, -1.37808084e-01f, 1.21747881e-01f, 1.36236086e-01f, 1.97739843e-02f,
  9.44583341e-02f, -8.50151852e-02f, -4.26594131e-02f, 7.00698271e-02f, -3.78636867e-02f, 1.65034495e-02f, -2.60422193e-02f, -1.03766598e-01f, 6.43581599e-02f, -1.74943693e-02f,
  -3.11223328e-01f, 3.00862819e-01f, 3.19682896e-01f, 1.85431585e-01f, 9.88522321e-02f, 2.54228953e-02f, 1.34185359e-01f, 1.10832609e-01f, -1.04821108e-01f, 5.37880436e-02f,
  2.25804597e-02f, 1.43355414e-01f, 1.38551250e-01f, 2.31354800e-03f, 1.83303252e-01f, 1.19272381e-01f, -6.35077152e-03f, -1.00668676e-01f, -4.76913303e-02f, -1.13171458e-01f,
  -4.73889932e-02f, -3.68077904e-02f, -2.32971627e-02f, -9.12074447e-02f, 1.12133779e-01f, 7.99959302e-02f, 5.26370704e-02f, 5.21615669e-02f, 1.20162584e-01f, -1.23968743e-01f,
  4.80674058e-01f, 1.03131933e-02f, 4.18424547e-01f, 8.23088810e-02f, 6.25508428e-02f, 2.68445760e-01f, 2.83333480e-01f, -4.26298827e-02f, -1.06387720e-01f, -2.65770797e-02f,
  -3.07135820e-01f, -3.99652600e-01f, -3.51310134e-01f, -2.89749920e-01f, -1.72065601e-01f, -1.70516048e-03f, 4.74831127e-02f, 2.77337283e-01f, 2.58029908e-01f, 2.23956391e-01f,
  -3.10954861e-02f, 2.15364888e-01f, 2.92447537e-01f, -1.37487734e-02f, 1.00115590e-01f, -1.51024029e-01f, -8.24391916e-02f, 5.65492287e-02f, 6.50271550e-02f, 1.31260663e-01f,
  3.54764521e-01f, 3.05915505e-01f, -1.72614858e-01f, -2.45424300e-01f, -1.56561852e-01f, -3.53217833e-02f, -4.69359569e-02f, 4.78886953e-03f, -4.51889746e-02f, 7.21120462e-03f,
  -1.16655745e-01f, 6.91830739e-02f, 3.93483900e-02f, -8.91690105e-02f, 7.43020028e-02f, 1.69713818e-03f, -1.19414218e-01f, -9.68065932e-02f, -7.39631206e-02f, -1.43537045e-01f,
  -1.53942302e-01f, -1.12671433e-02f, 1.71344280e-01f, -1.14015140e-01f, -1.68171391e-01f, -1.89108625e-01f, 3.24660726e-02f, -5.20883426e-02f, -6.26693666e-02f, 5.38676493e-02f,
  -1.34386033e-01f, -4.71940357e-03f, -5.37703894e-02f, -8.32662582e-02f, -4.84074391e-02f, -4.02427651e-02f, -1.64695438e-02f, -4.79076020e-02f, -7.11469576e-02f, -1.22253941e-02f,
  -1.08151175e-01f, -9.52211395e-02f, -1.33475080e-01f, -1.16850778e-01f, -2.15323254e-01f, 5.04543148e-02f, -1.23085426e-02f, -1.47892818e-01f, -9.73520577e-02f, -1.35275573e-01f,
  -4.66720462e-02f, 1.90079231e-02f, -9.12273973e-02f, -6.38644695e-02f, -1.47319853e-01f, -8.28555226e-02f, -6.98952079e-02f, -1.84215918e-01f, -9.04072821e-02f, 6.51702210e-02f,
  -3.15579891e-01f, -1.66962788e-01f, 7.65386596e-02f, 1.13151744e-01f, 1.26652807e-01f, -4.55546677e-02f, -1.50947452e-01f, -8.59604999e-02f, 4.65721823e-02f, -3.10022570e-03f,
  8.26200247e-02f, 2.87021440e-03f, -2.97427382e-02f, -3.20223421e-02f, -1.37643353e-03f, 3.48250940e-02f, -7.34321177e-02f, -4.59406078e-02f, -1.93590745e-01f, -1.21623673e-01f,
  -7.74593800e-02f, -1.17669953e-02f, 5.19518070e-02f, -6.67998791e-02f, -7.23147020e-02f, -8.51995274e-02f, -3.63063179e-02f, 7.72469118e-02f, 4.14248779e-02f, 1.83923598e-02f,
  9.13830847e-02f, -5.41892469e-01f, 8.88708830e-02f, -2.03171581e-01f, 9.49278399e-02f, 1.21067412e-01f, -2.66893897e-02f, -8.34528953e-02f, -2.34191827e-02f, -1.39563978e-01f,
  5.94706014e-02f, 3.65435779e-01f, 3.95313978e-01f, 2.87870497e-01f, 3.17837596e-01f, 4.63122539e-02f, 4.65868460e-03f, 3.92681062e-01f, 3.33895057e-01f, -2.93005593e-02f,
  -1.28546372e-01f, -1.71909451e-01f, -1.50597408e-01f, -2.13524133e-01f, -3.24480325e-01f, 1.02748759e-01f, -2.25013569e-01f, -1.48575470e-01f, -5.98674193e-02f, -1.68747425e-01f,
  4.24958766e-01f, -1.38260573e-01f, 1.57845423e-01f, -1.38560101e-01f, -1.46338120e-01f, -1.53232634e-01f, 5.62647060e-02f, -7.87644684e-02f, -1.19320594e-01f, -8.15082043e-02f,
  -7.95876458e-02f, -1.50668368e-01f, 2.03868039e-02f, -1.79730654e-01f, -1.43599734e-01f, -1.52764678e-01f, -2.22119451e-01f, -1.16365187e-01f, -5.90488985e-02f, -9.92042273e-02f,
  -1.16059758e-01f, -5.56084216e-02f, 1.40678033e-01f, 2.60132179e-03f, -4.33656164e-02f, 1.88765228e-01f, -5.58212809e-02f, -4.65405025e-02f, -1.24991881e-02f, -9.32988226e-02f,
  -8.69199708e-02f, 2.43755151e-02f, 1.46250024e-01f, 3.48895565e-02f, 2.14510933e-01f, 1.57751683e-02f, 1.02128193e-01f, 5.44470288e-02f, 9.12786499e-02f, -5.07913269e-02f,
  3.85146476e-02f, 1.04114242e-01f, 2.13518459e-02f, -4.75310646e-02f, 2.79749185e-03f, -5.03319278e-02f, -4.12888341e-02f, -1.97676465e-01f, 3.39672752e-02f, -4.49015535e-02f,
  1.08653970e-01f, 1.20094614e-02f, -7.69967958e-02f, -8.86822492e-02f, -1.67710543e-01f, -4.25213203e-03f, -1.18492074e-01f, -9.48610902e-02f, -4.55156825e-02f, -4.63028401e-02f,
  2.15435922e-01f, 2.40598336e-01f, 1.90567747e-01f, 1.15693118e-02f, -1.46192750e-02f, -2.59219129e-02f, 5.77357151e-02f, -6.66945875e-02f, -7.33615831e-02f, 3.26232379e-03f,
  -9.61158946e-02f, 8.48650336e-02f, -4.48562438e-03f, -7.84372762e-02f, 3.61114889e-02f, 5.80878742e-02f, -3.06923855e-02f, 1.66830018e-01f, 4.96639721e-02f, -1.65776044e-01f,
  -1.61550209e-01f, 1.40958756e-01f, 2.86711663e-01f, 2.75209427e-01f, 1.03515543e-01f, 3.70718896e-01f, 1.44991413e-01f, 8.87872279e-02f, 2.09149197e-01f, 7.84585476e-02f,
  2.14754939e-01f, 1.76225808e-02f, -1.20154945e-02f, 4.30948406e-01f, 4.02179331e-01f, 3.89206260e-01f, 3.67188483e-01f, 2.98494399e-01f, 2.68779814e-01f, 2.71238774e-01f,
  2.15969488e-01f, 1.86923489e-01f, 2.16382101e-01f, 1.74993247e-01f, 1.89716503e-01f, 1.09958678e-01f, 6.96250200e-02f, 9.60258767e-03f, 8.33197162e-02f, 9.10795107e-02f,
  2.07293153e-01f, 1.70795962e-01f, -1.76437199e-02f, 9.45541337e-02f, -4.12947573e-02f, 2.15112478e-01f, -2.30332818e-02f, -7.26360083e-02f, -2.72898190e-02f, -2.33301789e-01f,
  -3.72313231e-01f, -1.86873719e-01f, 1.38155431e-01f, -9.16102082e-02f, -2.46561915e-01f, -1.62711576e-01f, 2.46841088e-02f, -1.77575916e-01f, 5.23849055e-02f, -1.10941559e-01f,
  -8.00171494e-02f, -2.03733206e-01f, 5.97619787e-02f, -1.03087112e-01f, -8.63129944e-02f, -1.12214297e-01f, -2.01724231e-01f, -8.89109746e-02f, -2.90244003e-03f, -1.05190754e-01f,
  -8.12653154e-02f, -9.18763652e-02f, -3.29471403e-03f, -2.26564892e-02f, 3.97262760e-02f, -7.71419629e-02f, -1.70018300e-01f, -1.29258335e-01f, -3.08647230e-02f, -6.30188584e-02f,
  7.42627829e-02f, -1.89591363e-01f, -5.77518232e-02f, -1.14494592e-01f, 9.35606658e-02f, -9.37342197e-02f, -1.34025455e-01f, -9.76047441e-02f, -2.21358687e-02f, 4.05549742e-02f,
  -5.49209416e-02f, -8.06354173e-03f, -9.76932421e-02f, 5.98645099e-02f, 2.39797998e-02f, -1.34920478e-01f, -2.11153235e-02f, -5.15698865e-02f, 5.20784073e-02f, -6.04305491e-02f,
  7.65548199e-02f, -1.55061156e-01f, -9.00114998e-02f, -1.64324597e-01f, -4.97279614e-02f, -5.44910543e-02f, 1.04015619e-01f, 6.13912642e-02f, 8.79520476e-02f, 8.88707787e-02f,
  -2.53330879e-02f, 1.35417894e-01f, -6.05408810e-02f, -2.14475513e-01f, -8.35794285e-02f, -2.22519375e-02f, 7.63040558e-02f, -7.84831345e-02f, -7.57851899e-02f, 4.98465449e-02f,
  -1.59930736e-01f, -8.27632546e-02f, -8.20008572e-03f, -2.94888439e-03f, 2.10836576e-03f, -3.31150391e-03f, 1.48597937e-02f, -7.06051216e-02f, -1.38323873e-01f, -1.36448696e-01f,
  -9.74868909e-02f, 9.44630727e-02f, 7.45244548e-02f, 1.53865144e-01f, -2.34516673e-02f, 9.80721340e-02f, -9.33511630e-02f, 5.08192461e-03f, 1.90151334e-02f, 1.58837423e-01f,
  -4.56902623e-01f, 1.83410302e-01f, 1.47542313e-01f, 2.16442823e-01f, 1.53548419e-01f, 4.99134921e-02f, -1.09927975e-01f, -9.81882028e-03f, 4.84890044e-02f, -1.53653219e-01f,
  -9.76020470e-02f, 1.41636521e-01f, 1.62941024e-01f, 2.39467412e-01f, 4.97535355e-02f, 9.64163765e-02f, 2.17503548e-01f, 1.85729995e-01f, -2.44132519e-01f, -2.26380289e-01f,
  1.47388265e-01f, 8.07594508e-02f, -1.91212654e-01f, -6.31727129e-02f, 9.54348966e-02f, 7.07849711e-02f, 1.24495544e-01f, 2.48463191e-02f, 2.97946297e-02f, 1.85568899e-01f,
  -3.15598279e-01f, -2.95373559e-01f, -1.34053722e-01f, -5.03931604e-02f, 1.73837751e-01f, -3.06915134e-01f, -1.70924559e-01f, -3.05139218e-02f, -1.03172354e-01f, -3.41539651e-01f,
  1.70845184e-02f, -7.63238519e-02f, 1.74205720e-01f, -3.94605920e-02f, -1.32075965e-01f, -1.09878264e-01f, -3.69265117e-02f, -5.62806986e-02f, 6.84270263e-03f, -2.55291373e-01f,
  1.67589143e-01f, -5.65197086e-03f, 4.77307029e-02f, -1.45442739e-01f, -1.82802200e-01f, 1.42360687e-01f, -1.18697532e-01f, -1.43390253e-01f, -2.33505130e-01f, -1.72204539e-01f,
  -1.38972476e-01f, -7.47974589e-02f, 9.31391418e-02f, 2.06688289e-02f, -1.08742861e-04f, -6.61068335e-02f, 2.01890897e-02f, 8.90503526e-02f, -1.24341808e-02f, 2.65060784e-03f,
  6.63527176e-02f, -1.30201146e-01f, -1.52632907e-01f, 3.96802537e-02f, 1.10231817e-01f, 7.64719443e-03f, -1.45927668e-01f, -1.90994143e-02f, -3.05061825e-02f, -1.91557795e-01f,
  8.05343315e-02f, 2.13378891e-02f, 6.83591589e-02f, -6.32625371e-02f, -2.65016500e-02f, -2.06553619e-02f, -1.99907213e-01f, -9.96901318e-02f, 6.08942062e-02f, -5.36972806e-02f,
  -1.93399325e-01f, 1.22111350e-01f, -3.31303716e-01f, 1.76182855e-02f, 2.26990506e-02f, -4.50449735e-02f, -2.29108357e-03f, -3.50626521e-02f, 1.63261279e-01f, -1.12458348e-01f,
  -2.15826958e-01f, -2.97926255e-02f, 1.65017605e-01f, 1.11798897e-01f, -6.87509552e-02f, -1.16278611e-01f, -2.66077276e-02f, -3.02130580e-02f, 4.22999971e-02f, -9.06410068e-02f,
  1.01788692e-01f, -2.33224362e-01f, -1.03550710e-01f, -5.45261279e-02f, -1.35911271e-01f, -8.59925821e-02f, -1.12338617e-01f, -1.67364448e-01f, -3.18961591e-01f, -3.56108636e-01f,
  -3.94845128e-01f, 2.38780022e-01f, -4.22160849e-02f, -8.78795795e-03f, -2.59818345e-01f, -2.60645390e-01f, -3.69736776e-02f, -6.23224899e-02f, -1.80358380e-01f, 8.54867473e-02f,
  -2.31067580e-03f, 1.82142243e-01f, 2.79728740e-01f, 5.51675074e-02f, 6.47801906e-02f, 2.45487005e-01f, 1.83016792e-01f, -9.78244096e-02f, 3.09389667e-03f, 2.67723985e-02f,
  2.37551972e-01f, 4.58286777e-02f, -6.38171881e-02f, 3.89976688e-02f, 1.76765412e-01f, 2.72194624e-01f, 1.70334876e-01f, 2.30525527e-02f, 6.71531260e-02f, 4.56118375e-01f,
  4.59959805e-01f, -2.00746864e-01f, 5.27835637e-02f, -8.77964422e-02f, -1.52907312e-01f, -6.67317659e-02f, -4.85579558e-02f, 1.39105855e-03f, -4.67369929e-02f, 1.66210218e-03f,
  -1.46065354e-01f, -6.16956241e-02f, -2.37357616e-02f, -2.25057341e-02f, -5.75285517e-02f, -1.43433571e-01f, -1.58454284e-01f, 7.53303915e-02f, 5.92400208e-02f, 4.56302911e-02f,
  -2.65889568e-03f, -1.60775274e-01f, -7.13933855e-02f, -1.69449195e-01f, -1.25361875e-01f, -2.11685643e-01f, -1.56206982e-02f, -1.38538867e-01f, -9.44774449e-02f, 5.11757992e-02f,
  -2.94443280e-01f, -2.06139863e-01f, -1.47908628e-01f, -1.42494276e-01f, -7.62849078e-02f, -1.74173668e-01f, 1.41424071e-02f, 1.25065213e-02f, -3.69104333e-02f, -5.99856898e-02f,
  1.14252679e-01f, 7.18638822e-02f, -1.12146631e-01f, 3.33303697e-02f, -8.23409259e-02f, -7.92230442e-02f, 1.04303546e-02f, -1.83972761e-01f, -2.38735691e-01f, -1.39140382e-01f,
  -7.16049075e-02f, 7.61984289e-02f, -7.05303857e-03f, 1.49034755e-02f, -4.54563349e-02f, -1.23317823e-01f, -4.25120965e-02f, -4.43748794e-02f, -7.29508847e-02f, 5.04874811e-02f,
  5.78317285e-01f, -2.62457758e-01f, 2.74953514e-01f, 2.91103870e-01f, 1.95868835e-02f, -1.19045198e-01f, 1.43637687e-01f, 1.28606915e-01f, 7.43233636e-02f, 6.49934858e-02f,
  -1.90266356e-01f, -4.08359841e-02f, 1.58906393e-02f, 2.00701002e-02f, -1.54117346e-02f, -5.75445853e-02f, 3.85296042e-03f, 1.60607845e-01f, 1.14629947e-01f, 1.70770474e-02f,
  1.15958275e-02f, 5.05868345e-02f, 1.47958145e-01f, 7.23845586e-02f, -8.99029076e-02f, -5.47855115e-03f, 1.47618398e-01f, -3.63385119e-02f, -1.01762570e-01f, 3.10113002e-02f,
  1.60649866e-01f, 2.37966955e-01f, -2.22024083e-01f, -1.95507333e-01f, 2.91761070e-01f, 3.56946290e-01f, 2.78388292e-01f, 2.59898394e-01f, 1.93592221e-01f, 1.05148703e-01f,
  4.36400920e-01f, -1.70005783e-01f, -5.75669646e-01f, -5.88380158e-01f, -6.32058501e-01f, -5.97166598e-01f, -7.10941613e-01f, -6.62892997e-01f, -4.66746271e-01f, 3.02424222e-01f,
  8.40900559e-03f, -1.30645171e-01f, -2.47987345e-01f, -3.41861784e-01f, -8.90647843e-02f, -3.58788133e-01f, -2.90378749e-01f, -2.75216289e-02f, -2.59115070e-01f, -6.32306576e-01f,
  -1.96947753e-01f, 3.69463354e-01f, 4.14616540e-02f, -1.85112078e-02f, 4.47060855e-04f, -2.20272303e-01f, 6.71077073e-02f, -1.17751345e-01f, 1.86551437e-02f, -6.06378503e-02f,
  5.64468727e-02f, 8.86120349e-02f, 4.37694527e-02f, -4.77725565e-02f, 2.57891059e-01f, -1.39993206e-01f, -1.24966644e-01f, -2.69037634e-01f, -4.53753412e-01f, 2.21144199e-01f,
  5.62575087e-02f, 1.69829175e-01f, -1.00866280e-01f, -2.15722015e-03f, -2.34266549e-01f, -2.95542568e-01f, 2.87359238e-01f, 7.03520775e-02f, -2.99974680e-01f, -1.75830111e-01f,
  -1.50444373e-01f, -7.67793506e-02f, 1.95391804e-01f, 1.83854744e-01f, 2.86883414e-02f, 7.24586025e-02f, -1.22569688e-01f, -2.33915318e-02f, -1.01044416e-01f, 7.76376277e-02f,
  -1.13906547e-01f, 1.73500776e-01f, 8.38367715e-02f, 3.99012454e-02f, -3.42131704e-01f, -2.26410199e-02f, -1.16230905e-01f, -1.18955083e-01f, -1.90716371e-01f, -1.04222715e-01f,
  -1.36342540e-01f, -3.37182748e-04f, 3.24839443e-01f, -9.08729434e-02f, 4.17048298e-02f, -7.82953799e-02f, 2.08438300e-02f, 1.55420110e-01f, 2.14483738e-01f, 4.73078713e-02f,
  -1.45376831e-01f, 2.27370840e-02f, -1.88826814e-01f, -1.21917084e-01f, -1.10828854e-01f, -5.86918974e-03f, -1.15764730e-01f, -6.41005188e-02f, 3.59819122e-02f, 1.06850244e-01f,
  1.29374146e-01f, -3.65258195e-02f, 3.42302285e-02f, -2.66618524e-02f, 1.29818335e-01f, -2.29511783e-01f, -3.02000463e-01f, -3.01883221e-01f, -3.29345137e-01f, 2.71998793e-01f,
  -1.41601071e-01f, -2.85983324e-01f, -5.13839483e-01f, -3.11641067e-01f, -8.86780769e-03f, -4.00133014e-01f, -3.42216104e-01f, -2.34748408e-01f, -5.94869077e-01f, -5.64672112e-01f,
  3.55413407e-02f, 4.32978928e-01f, 5.04076362e-01f, 3.69437821e-02f, 3.29082347e-02f, -1.78771511e-01f, -1.25406012e-01f, -2.82242388e-01f, -4.02227677e-02f, 2.75276065e-01f,
  2.90389955e-01f, -3.07106972e-01f, 5.73569089e-02f, -3.31613243e-01f, -3.59262794e-01f, 2.27744386e-01f, 1.37381062e-01f, -2.58751690e-01f, -6.29365742e-01f, -7.69039750e-01f,
  -3.36783499e-01f, -2.69935369e-01f, -1.78397283e-01f, -1.23449706e-01f, 4.05125886e-01f, -1.12755179e-01f, 4.94157493e-01f, 3.05292100e-01f, 3.20787996e-01f, 4.83459920e-01f,
  4.59140688e-01f, 5.18695891e-01f, -4.46801931e-01f, -2.70564139e-01f, 1.29419476e-01f, -5.48104532e-02f, -8.60394910e-03f, 7.07952157e-02f, -7.33152479e-02f, 8.98364633e-02f,
  6.81577399e-02f, 4.54022326e-02f, 1.46218270e-01f, -2.73264516e-02f, -7.65344203e-02f, -3.92202586e-01f, -2.49018483e-02f, -2.32303187e-01f, -2.14288905e-01f, 9.09868479e-02f,
  -2.16017395e-01f, -6.23652665e-03f, 2.91876405e-01f, -9.17362198e-02f, -2.13230755e-02f, -2.48375922e-01f, 2.42312193e-01f, -5.19028232e-02f, 7.96871558e-02f, 2.89747030e-01f,
  -5.26822247e-02f, 1.35797663e-02f, 8.58074054e-02f, 1.13851964e-01f, -2.29487240e-01f, 9.71377790e-02f, 8.76463577e-02f, -8.21312666e-02f, -1.04680017e-01f, -7.89548084e-02f,
  -9.41649005e-02f, -3.16798985e-02f, -8.46136212e-02f, 7.11146295e-02f, -2.85495128e-02f, 1.02467932e-01f, -1.01402536e-01f, -2.79412162e-03f, 9.18191299e-02f, 3.06997495e-03f,
  -1.99569568e-01f, -5.66893667e-02f, 5.61171658e-02f, -6.90641254e-02f, 1.95677876e-01f, -8.51049051e-02f, 7.40825906e-02f, -6.23324513e-02f, -4.93923947e-02f, 8.99850428e-02f,
  -3.73198956e-01f, -2.33317882e-01f, 1.57790437e-01f, -2.46533573e-01f, 6.90332204e-02f, 7.17862099e-02f, 1.10496089e-01f, -6.28231764e-02f, 1.44196376e-01f, -6.20080419e-02f,
  7.16257142e-03f, -1.10173754e-01f, 2.28097215e-01f, -2.83466987e-02f, -2.93882608e-01f, -1.11253530e-01f, -5.05202971e-02f, -2.49932170e-01f, -2.61026353e-01f, -4.04818356e-02f,
  -8.93092975e-02f, -3.22030902e-01f, -3.60245317e-01f, -2.52906173e-01f, -6.25905916e-02f, -5.29751301e-01f, -1.17044769e-01f, -2.69668579e-01f, -2.64970839e-01f, -3.03566337e-01f,
  -7.70713270e-01f, 1.04923926e-01f, -1.07338801e-01f, -3.32248509e-01f, -1.61314279e-01f, 1.42394453e-01f, 2.38012403e-01f, 4.67216223e-02f, -1.50138825e-01f, 1.78899050e-01f,
  2.00525448e-01f, -1.99175462e-01f, -3.02803725e-01f, -1.04812875e-01f, -1.62784904e-01f, -1.29541978e-02f, -3.32721651e-01f, -5.05217671e-01f, -4.07705665e-01f, 1.00953430e-01f,
  -2.25832295e-02f, -3.47331285e-01f, -4.61434722e-01f, -2.29374558e-01f, -5.17854095e-02f, -3.32354307e-01f, -2.06819236e-01f, -3.70515078e-01f, -1.45055175e-01f, -3.55654776e-01f,
  2.92254716e-01f, -7.62536228e-02f, -1.76244870e-01f, -2.47939214e-01f, 7.95063376e-02f, 1.25816166e-01f, 1.69776276e-01f, -1.22493744e-01f, -1.04392916e-01f, 2.07263976e-01f,
  -4.75675352e-02f, 7.09105432e-02f, -2.41686050e-02f, 8.75747353e-02f, 1.11855246e-01f, 1.02979474e-01f, 2.59810463e-02f, -2.17612848e-01f, -1.24550648e-01f, 3.64006788e-01f,
  1.82300270e-01f, -8.36771056e-02f, -1.96485013e-01f, 1.88216180e-01f, 1.92794234e-01f, -1.26635373e-01f, 2.48043358e-01f, 1.03642829e-01f, -2.41776332e-02f, -2.67733876e-02f,
  1.39336348e-01f, 1.07601687e-01f, -8.27413723e-02f, 3.23964059e-02f, 1.75464824e-02f, 2.89862398e-02f, -7.35252798e-02f, -3.37352157e-02f, -6.72515035e-02f, 1.13485001e-01f,
  1.38698354e-01f, 2.08223745e-01f, 1.48838609e-01f, -1.06705174e-01f, 1.46693243e-02f, -1.87249362e-01f, -6.55914657e-03f, 1.52934700e-01f, 1.13828644e-01f, -7.48374220e-03f,
  -7.59550035e-02f, -6.84813224e-03f, -1.42075485e-02f, -1.52757093e-02f, 8.64553228e-02f, 1.09581985e-01f, 1.03709273e-01f, 4.38775979e-02f, 1.70813091e-02f, 1.05858043e-01f,
  1.85247391e-01f, -2.97042429e-01f, 4.99610864e-02f, -1.40825555e-01f, -2.37341113e-02f, 1.16975158e-01f, 5.41579276e-02f, -6.90424964e-02f, -1.80310264e-01f, 9.49169770e-02f,
  4.08885926e-02f, 1.46845862e-01f, 3.53296548e-02f, 2.18176886e-01f, 2.14667432e-02f, 1.43224299e-01f, -4.05167229e-02f, -1.24710552e-01f, 2.08955780e-02f, 2.80063093e-01f,
  1.26638576e-01f, -6.60606697e-02f, -1.91397011e-01f, 3.27840857e-02f, -3.27786356e-02f, -1.63963392e-01f, 1.30932570e-01f, 6.53112158e-02f, -1.93822503e-01f, 1.37485236e-01f,
  4.89850760e-01f, -2.89914310e-01f, -9.68952291e-03f, 3.53602827e-01f, 2.99255431e-01f, -1.05724245e-01f, -3.40991557e-01f, -2.37320319e-01f, 2.17183918e-01f, 2.34718964e-01f,
  2.85477847e-01f, 4.05752927e-01f, 1.48847207e-01f, 4.73732352e-02f, -1.44250244e-01f, -1.52786613e-01f, 2.61585112e-03f, 1.37662366e-01f, 1.12016849e-01f, 2.98796982e-01f,
  2.82929301e-01f, 1.35119826e-01f, 9.71965492e-02f, 7.46084424e-03f, 1.34279728e-01f, 1.95550367e-01f, -3.45291235e-02f, 9.54026263e-03f, 1.69535831e-01f, 2.29639992e-01f,
  4.02507275e-01f, -1.19948499e-01f, 7.60797486e-02f, 1.54019952e-01f, 7.53854960e-02f, -6.72227964e-02f, -5.22902645e-02f, -7.76839033e-02f, -5.46471737e-02f, -1.36347681e-01f,
  1.21005671e-02f, -6.27649277e-02f, -7.25214407e-02f, 9.67674982e-03f, -1.92888334e-01f, -1.28964921e-02f, -1.84182033e-01f, -2.30803728e-01f, -1.20745584e-01f, -9.12515372e-02f,
  1.55332267e-01f, 1.23366244e-01f, -1.46487474e-01f, -9.61674303e-02f, -9.20001417e-02f, 1.56290069e-01f, -1.92614168e-01f, -3.95698613e-03f, -1.04565226e-01f, -2.40695849e-02f,
  7.54159167e-02f, -9.41868592e-03f, 2.12298825e-01f, 4.47105523e-03f, 4.44031022e-02f, -7.18957707e-02f, 7.02380240e-02f, 1.53391033e-01f, 8.55713675e-04f, 3.23810527e-05f,
  2.79633738e-02f, 2.19838679e-01f, -1.17430270e-01f, 3.04264612e-02f, 3.33234936e-01f, 5.82136363e-02f, 1.60172153e-02f, -2.74100597e-03f, 8.53888690e-02f, 6.98305145e-02f,
  9.03282166e-02f, -8.43640640e-02f, 3.76110375e-02f, -3.68510038e-02f, -3.22531871e-02f, 1.10495739e-01f, 2.05470145e-01f, 5.89224063e-02f, 1.09232381e-01f, 7.28946552e-02f,
  -1.16939031e-01f, -2.98710316e-01f, 2.68544436e-01f, -1.39461815e-01f, 1.20752491e-02f, -8.43956470e-02f, 3.53847221e-02f, -1.16888613e-01f, 1.63450819e-02f, -5.45899011e-02f,
  -1.77399009e-01f, -1.03826329e-01f, -1.88661203e-01f, -1.41007155e-01f, -2.37380248e-02f, 2.07570828e-02f, -6.90844208e-02f, -9.51077715e-02f, -8.60927477e-02f, -1.37381360e-01f,
  -1.14524864e-01f, -7.85594508e-02f, 2.66811233e-02f, -1.54070109e-01f, -3.20815705e-02f, 2.27497309e-01f, -8.22834671e-02f, -9.91569310e-02f, -1.66566014e-01f, -1.25602067e-01f,
  1.62977844e-01f, -5.93640625e-01f, -2.60564893e-01f, -2.35932097e-01f, -3.38106573e-01f, -3.73792201e-01f, -8.39045882e-01f, -3.28844249e-01f, -1.63790166e-01f, -5.66422403e-01f,
  1.44197360e-01f, 9.36155677e-01f, 6.90184236e-01f, 6.35842562e-01f, 6.22578204e-01f, -8.45707059e-01f, -7.98948765e-01f, 1.53482452e-01f, 6.72619820e-01f, 2.33637094e-02f,
  -3.48176122e-01f, -3.66497487e-01f, -1.58331599e-02f, -7.91783854e-02f, -4.67051119e-01f, 2.54835248e-01f, -4.50194478e-01f, -4.09738034e-01f, -2.78784871e-01f, -7.02064216e-01f,
  3.89773339e-01f, -1.43026561e-01f, 1.34280518e-01f, 6.79000989e-02f, -1.84102342e-01f, 7.08137676e-02f, 6.79910630e-02f, -1.98844001e-01f, 1.08895190e-02f, -1.74792171e-01f,
  -8.85996968e-02f, 9.69644927e-04f, 5.86071834e-02f, -5.35343923e-02f, -1.36005506e-01f, -9.01416615e-02f, -3.03135365e-01f, -8.58112276e-02f, -1.60304695e-01f, -9.36120823e-02f,
  -2.89061338e-01f, -2.53219157e-01f, 1.85680240e-01f, 1.44887548e-02f, 1.23199545e-01f, 2.52177507e-01f, 1.10320777e-01f, 1.38543174e-01f, 1.88633233e-01f, -3.53194892e-01f,
  -8.82023796e-02f, -2.91869622e-02f, -1.38252750e-01f, -8.80807415e-02f, -7.68361911e-02f, -9.32102352e-02f, 8.89269449e-03f, -3.28811221e-02f, 3.19921970e-02f, -3.19548021e-03f,
  4.02775817e-02f, -7.29377046e-02f, 6.25414401e-02f, -1.37841448e-01f, -2.70579308e-02f, -1.35011476e-04f, -7.84307271e-02f, -7.73013104e-03f, 7.31873885e-02f, -1.12632804e-01f,
  -8.15681368e-02f, -7.60989189e-02f, -7.53697986e-03f, -2.59330906e-02f, -8.03606063e-02f, -2.36440767e-02f, -1.02058664e-01f, 1.62800491e-01f, 4.78409715e-02f, -1.36047363e-01f,
  5.99980175e-01f, 1.96328461e-01f, 9.19133574e-02f, 9.90567058e-02f, -2.80194640e-01f, -7.48372823e-02f, -1.25768542e-01f, -1.89456448e-01f, 1.44250866e-03f, 3.07235941e-02f,
  -2.31114086e-02f, 1.11608148e-01f, -1.02589406e-01f, -1.18099086e-01f, -1.86524913e-02f, -7.96850249e-02f, -2.11689979e-01f, -8.10422897e-02f, -1.70099348e-01f, -2.22824022e-01f,
  -4.44435120e-01f, -1.66698098e-01f, 2.08059087e-01f, 1.72900066e-01f, 2.48140078e-02f, 3.07653308e-01f, 2.71221966e-01f, 8.08327049e-02f, 3.85831892e-01f, -2.64780760e-01f,
  -5.79224527e-01f, -1.32493109e-01f, -8.77659202e-01f, 1.03220843e-01f, 2.88819581e-01f, 1.03729829e-01f, -2.23299451e-02f, 7.04517066e-02f, 1.40080288e-01f, -2.92843670e-01f,
  1.14332087e-01f, 1.89685971e-01f, -1.38026923e-01f, 7.18953758e-02f, -1.26496211e-01f, -9.92269367e-02f, 8.87776762e-02f, -2.74798125e-01f, 7.42036179e-02f, 5.58959544e-01f,
  5.92546225e-01f, 2.76715338e-01f, -6.99857920e-02f, 1.16498256e-02f, 2.33109757e-01f, 1.32473275e-01f, -2.06935942e-01f, -5.74598014e-02f, 2.60715596e-02f, -2.98626777e-02f,
  -5.83705842e-01f, -5.56424558e-01f, 1.10303789e-01f, 2.15320736e-01f, -3.48241776e-02f, -4.28529829e-01f, -6.82922304e-02f, -2.62839943e-01f, -5.74105419e-02f, -1.31965101e-01f,
  1.01642773e-01f, -8.69384408e-02f, 2.22121045e-01f, -5.77083007e-02f, -2.26820130e-02f, -2.76010066e-01f, -2.85368025e-01f, -3.05283517e-01f, -5.47209620e-01f, -3.80351722e-01f,
  7.71219194e-01f, 7.01893419e-02f, -3.99604350e-01f, -1.96118951e-01f, -4.72227722e-01f, -1.74692467e-01f, -4.07741994e-01f, -2.15969056e-01f, -5.69635689e-01f, -3.58236909e-01f,
  7.55703449e-02f, 4.54286039e-02f, 9.05208886e-02f, -3.94360833e-02f, 1.15778744e-01f, 4.12214957e-02f, 8.95868689e-02f, 1.60475358e-01f, 2.47129239e-02f, -8.54451396e-03f,
  9.80062485e-02f, -6.55741841e-02f, 1.82642788e-02f, -5.76246344e-02f, 1.53779507e-01f, -3.29937227e-02f, 1.10263741e-02f, 7.11848661e-02f, 1.40760854e-01f, -1.30132660e-01f,
  3.59838456e-03f, -1.73268273e-01f, 3.61060463e-02f, 1.22449644e-01f, -2.04275757e-01f, -4.00757603e-02f, -1.19582959e-01f, -1.41568959e-01f, -1.10614836e-01f, -1.47604987e-01f,
  5.59983887e-02f, -7.43679106e-02f, -2.79165030e-01f, 8.92512202e-02f, 6.50541186e-02f, -4.63937894e-02f, 8.82186403e-04f, -4.14163321e-02f, -1.06890924e-01f, -2.48590618e-01f,
  -6.03075884e-02f, -5.10132462e-02f, -2.03799587e-02f, -6.30680844e-02f, -1.06606238e-01f, -2.16496810e-01f, 1.39551610e-01f, 2.00532675e-02f, -3.84030417e-02f, -3.28621864e-02f,
  8.13435018e-02f, -2.23837607e-02f, -2.88926333e-01f, -3.30739379e-01f, 2.96032317e-02f, 5.19302227e-02f, -3.44407201e-01f, -5.45497909e-02f, -4.77642387e-01f, -2.31245041e-01f,
  -3.65430117e-02f, -1.12023264e-01f, 2.07860261e-01f, 2.83893734e-01f, -6.54200092e-02f, -3.65254700e-01f, -3.62889737e-01f, -1.18222766e-01f, -1.27063245e-01f, -1.13578804e-01f,
  -3.91864568e-01f, -2.75535285e-01f, -3.84482816e-02f, 2.90446859e-02f, 1.64757192e-01f, 3.15361708e-01f, 5.66471219e-01f, 5.61475158e-01f, 3.73812467e-01f, 1.36413261e-01f,
  1.43222883e-01f, 3.50781739e-01f, 3.79554898e-01f, 5.23846924e-01f, 4.07988966e-01f, -2.78453790e-02f, 2.89871986e-03f, 7.99964815e-02f, 5.99573962e-02f, 6.04504108e-01f,
  -4.24363315e-01f, -2.77283162e-01f, -9.00206268e-02f, -1.17283374e-01f, 5.18593453e-02f, 1.18899584e-01f, 1.67470589e-01f, 1.50722772e-01f, 2.54558190e-03f, 2.96552032e-01f,
  6.03229403e-02f, 3.85469012e-02f, 2.37730071e-02f, 9.14964173e-03f, 9.22138151e-03f, -2.01021001e-01f, 2.02379674e-01f, 1.72238544e-01f, 3.96458767e-02f, 2.10146345e-02f,
  9.88999475e-03f, -1.19738460e-01f, -2.64428467e-01f, -6.09150007e-02f, 6.80145174e-02f, -1.45394206e-01f, -2.31565401e-01f, -1.05414450e-01f, -2.71067649e-01f, 1.18891358e-01f,
  -1.35709301e-01f, 3.49022895e-02f, -1.18213922e-01f, 9.93461628e-03f, 7.66296387e-02f, 7.07606003e-02f, 1.00189552e-01f, 6.16992265e-02f, 1.25336051e-01f, 2.50129074e-01f,
  1.07187316e-01f, -4.95963283e-02f, 1.84218749e-01f, 7.40646571e-02f, -1.63831368e-01f, -6.88194716e-03f, 3.46863478e-01f, -9.98722762e-02f, -6.25123829e-02f, -1.23441190e-01f,
  -1.78072229e-01f, 7.65945166e-02f, 1.37844071e-01f, 1.58893183e-01f, -7.21643865e-02f, -7.33503401e-02f, 1.66953593e-01f, -2.50451174e-02f, -2.34536782e-01f, -3.73903057e-03f,
  -4.93935525e-01f, -3.35228622e-01f, -4.68155034e-02f, 3.36243883e-02f, -4.67832051e-02f, -2.45617658e-01f, -1.50327519e-01f, -1.17515519e-01f, -6.24807514e-02f, 3.57965007e-02f,
  -7.13415220e-02f, -2.75799613e-02f, -3.02967448e-02f, 1.08877055e-01f, -6.93935230e-02f, -2.52223104e-01f, 2.11880840e-02f, 2.79070530e-02f, -2.02978238e-01f, 1.00420192e-01f,
  5.44883274e-02f, -1.74119726e-01f, -1.62590131e-01f, -4.09358889e-01f, -1.99607298e-01f, -4.45726961e-01f, -1.25765964e-01f, -1.14163198e-01f, -4.94986862e-01f, -1.19733535e-01f,
  -6.44224063e-02f, -2.85953254e-01f, 4.57752317e-01f, 4.44027893e-02f, 6.75163329e-01f, 3.98470163e-01f, 7.06636012e-02f, -2.57599860e-01f, -2.18858868e-01f, -2.73276389e-01f,
  -1.32660372e-02f, -2.88921952e-01f, -4.37962323e-01f, -3.71140748e-01f, -2.44674787e-01f, -2.00132206e-01f, 2.01476723e-01f, 2.94088960e-01f, 1.55708551e-01f, 2.42631346e-01f,
  1.10685430e-01f, 2.00946227e-01f, 1.46726593e-01f, -1.62891418e-01f, 2.76455041e-02f, -1.31021608e-02f, 1.69932604e-01f, 3.83564383e-01f, 1.78867206e-01f, 3.69708287e-03f,
  7.93391988e-02f, -9.88783538e-02f, 4.67950217e-02f, -1.74984470e-01f, 1.56225890e-01f, -3.18723798e-01f, -8.68620947e-02f, -5.21552525e-02f, -7.20404834e-02f, -1.39083177e-01f,
  9.75555331e-02f, 3.92624550e-02f, 4.46897410e-02f, -5.74206337e-02f, 6.06572814e-02f, -1.59736618e-01f, -5.27759921e-03f, -1.44322112e-01f, -2.53697336e-01f, -1.29291356e-01f,
  -9.66806933e-02f, 4.48673308e-01f, 2.97737330e-01f, -1.85784832e-01f, -3.80832165e-01f, 2.85230130e-01f, 9.86872390e-02f, -1.49350166e-02f, -1.18522711e-01f, -2.26310030e-01f,
  3.74054424e-02f, 6.14936911e-02f, -4.55749668e-02f, 1.47729712e-02f, -3.23090479e-02f, -2.16534976e-02f, 4.55489935e-04f, 4.11693603e-02f, 5.12660183e-02f, 1.42268240e-01f,
  3.35302651e-02f, 4.57730107e-02f, -4.94435243e-02f, -1.35121882e-01f, -4.61049005e-02f, 4.96157706e-02f, 2.86587998e-02f, -1.04553565e-01f, 3.95746604e-02f, -1.87016893e-02f,
  4.96929139e-02f, 1.69537833e-03f, 3.70403528e-02f, -1.08730964e-01f, -8.04852694e-02f, -3.63481138e-03f, -9.31422934e-02f, -3.71821932e-02f, 2.93229688e-02f, 1.85777783e-01f,
  -2.92878449e-01f, 1.89661652e-01f, -2.31767386e-01f, -2.18613267e-01f, 1.33282751e-01f, -6.52933121e-02f, 1.03323549e-01f, 1.42979482e-02f, 2.19048440e-01f, -1.35158405e-01f,
  -7.02892840e-02f, -5.15935123e-02f, -7.43219033e-02f, -3.15924026e-02f, 1.53031096e-01f, -5.46902195e-02f, 5.12267463e-02f, 2.43721362e-02f, -8.83303657e-02f, 5.97514957e-02f,
  -1.41663561e-02f, 1.02712065e-01f, 1.10556170e-01f, -1.32845998e-01f, -4.46808524e-02f, 1.42114848e-01f, 1.42804831e-01f, -2.47566029e-03f, 6.24829568e-02f, -1.08798049e-01f,
  -3.97450000e-01f, -5.86167753e-01f, 1.21720567e-01f, 1.08500622e-01f, -1.60550162e-01f, -3.13091338e-01f, -7.02911019e-01f, -2.27498889e-01f, -1.04112243e-02f, -2.04591736e-01f,
  -1.00297481e-01f, 4.85251546e-02f, 8.36199969e-02f, -1.60124570e-01f, -2.71266371e-01f, -5.64533770e-01f, -3.04893494e-01f, -3.42629775e-02f, -1.81312896e-02f, -9.94210020e-02f,
  -2.14513689e-01f, -2.13509634e-01f, -4.87231370e-03f, 5.11552170e-02f, 1.26820952e-01f, 8.73805061e-02f, -1.19572133e-02f, -4.48176004e-02f, -1.05992988e-01f, -1.53298050e-01f,
  2.84455031e-01f, 2.53283948e-01f, 3.19099873e-02f, 6.33884817e-02f, -1.13008812e-01f, -7.47567341e-02f, 3.02887782e-02f, 6.91304132e-02f, -1.46547198e-01f, -7.19110146e-02f,
  5.03518172e-02f, 7.36362711e-02f, 1.01658270e-01f, 1.92783922e-02f, 1.48362473e-01f, 1.51060537e-01f, 1.88521057e-01f, 4.35547084e-02f, 1.23953763e-02f, 9.80251729e-02f,
  8.69621709e-02f, 6.74825981e-02f, 1.13240583e-02f, 9.34923366e-02f, 3.80635560e-02f, 1.38784915e-01f, 3.55791859e-02f, 1.69527903e-01f, 2.33124360e-01f, 4.03894000e-02f,
  1.73194125e-01f, -8.71013179e-02f, 1.05803415e-01f, 1.49060532e-01f, -9.44914147e-02f, 1.68335848e-02f, -9.58743468e-02f, -1.89096436e-01f, -8.02824795e-02f, -5.78011796e-02f,
  -6.43358752e-02f, 4.79803532e-02f, -5.87220006e-02f, -6.39339164e-02f, 6.47553355e-02f, -2.25745831e-02f, -1.28528669e-01f, -8.16083141e-03f, 1.41861096e-01f, -4.94983457e-02f,
  -3.52425799e-02f, -6.56191781e-02f, 8.98187533e-02f, -4.00075205e-02f, -5.88640478e-03f, 6.47023618e-02f, 3.68294083e-02f, 8.38571638e-02f, 2.56658588e-02f, -1.69926867e-01f,
  3.75580639e-01f, 2.32856184e-01f, -1.09593749e-01f, -1.06699191e-01f, -6.17144909e-03f, 1.24205055e-03f, 5.24245165e-02f, -3.03382203e-02f, -1.44784376e-02f, 1.14488386e-01f,
  -5.81137463e-03f, 2.17297003e-02f, 8.19881558e-02f, 7.44357929e-02f, 2.97896028e-03f, 1.03918575e-01f, -2.59216242e-02f, -6.86448663e-02f, -8.36952925e-02f, 4.04517576e-02f,
  6.03274722e-03f, -1.67891592e-01f, -1.13280572e-01f, 2.22473182e-02f, 4.19742465e-02f, 6.95026070e-02f, -4.21598442e-02f, 7.54475370e-02f, 2.10792124e-02f, -2.38871366e-01f,
  7.19707906e-01f, -3.50022465e-01f, -2.13012740e-01f, 1.38732329e-01f, -6.21390462e-01f, -6.47919118e-01f, -7.22656012e-01f, -2.55529612e-01f, -1.48836344e-01f, -3.23165208e-01f,
  -3.73415172e-01f, 1.11308418e-01f, -2.51604747e-02f, 1.21701792e-01f, 1.23022877e-01f, -2.67368913e-01f, 7.27266446e-02f, 4.75317031e-01f, 5.66046417e-01f, 2.01588631e-01f,
  1.20631792e-01f, 4.52876270e-01f, 6.49164855e-01f, 4.69487101e-01f, -1.01892650e-02f, 1.13123208e-01f, -7.98187684e-03f, 7.59722963e-02f, -1.27524078e-01f, 2.10189775e-01f,
  1.85935423e-01f, -5.65293245e-02f, -3.64469215e-02f, 1.39035836e-01f, -2.94679366e-02f, 1.45532608e-01f, 2.46459059e-02f, 3.23172987e-01f, -1.39306828e-01f, -1.88602746e-01f,
  -1.61658123e-01f, 1.69240907e-02f, -2.01214135e-01f, 6.38187304e-02f, 5.62510192e-02f, -1.21661991e-01f, 2.25296825e-01f, 2.60249615e-01f, 2.05832317e-01f, 6.42821491e-02f,
  -2.21884638e-01f, -1.83879286e-01f, -3.58597726e-01f, -3.73593807e-01f, -1.83780510e-02f, 1.73848242e-01f, -2.32041374e-01f, 2.63801459e-02f, 7.79102510e-03f, 1.39350638e-01f,
  4.26106714e-02f, -3.44774947e-02f, -2.47987602e-02f, -1.17174394e-01f, 2.13577673e-02f, -2.23640159e-01f, -1.16334677e-01f, 5.74082583e-02f, 1.98538676e-02f, -6.38229847e-02f,
  -1.64606739e-02f, 7.90397972e-02f, 6.92475140e-02f, -7.50315469e-03f, 2.90531106e-02f, 8.76772404e-02f, -9.30883139e-02f, 2.75560021e-01f, 2.41554573e-01f, 4.72613722e-02f,
  4.39572744e-02f, -5.91398142e-02f, -3.46868858e-02f, 9.17005166e-02f, -7.80170113e-02f, 1.75946921e-01f, 1.67373821e-01f, 6.22976497e-02f, 9.35434029e-02f, -1.01330936e-01f,
  3.39799486e-02f, -1.00015789e-01f, -1.96217224e-01f, 3.71171418e-03f, -1.11161321e-01f, 2.66793836e-02f, -1.84759125e-02f, -2.03646421e-02f, -7.13961869e-02f, -1.88991487e-01f,
  -2.22196400e-01f, -8.80031437e-02f, -1.69493973e-01f, 7.10597709e-02f, -1.07686268e-02f, -2.50557721e-01f, -8.13584849e-02f, -2.35542759e-01f, -4.97939028e-02f, -9.51455459e-02f,
  -2.28767097e-01f, -2.64363170e-01f, -3.77051473e-01f, -5.20142019e-01f, -2.79378682e-01f, -2.19597295e-01f, -2.97458291e-01f, -3.30962896e-01f, -4.84435290e-01f, -3.62380892e-01f,
  -1.53652862e-01f, 8.21985662e-01f, -8.29750776e-01f, 1.44210085e-01f, -3.90091926e-01f, -4.67045724e-01f, 2.95080692e-01f, 1.96683556e-01f, 4.71471734e-02f, 2.39815891e-01f,
  1.02536954e-01f, -1.55461878e-01f, -3.32173780e-02f, -5.26387896e-03f, 1.15221724e-01f, 1.92841664e-01f, -3.36939096e-02f, -5.66213012e-01f, -3.82588446e-01f, 5.09302914e-02f,
  4.07224625e-01f, 3.74834776e-01f, 3.96357328e-01f, 4.10109870e-02f, 1.85403213e-01f, -1.16953239e-01f, 1.81296587e-01f, 3.25977132e-02f, -7.46758431e-02f, -2.09951490e-01f,
  -6.66200966e-02f, -1.67268008e-01f, -3.36278260e-01f, -2.22857133e-01f, -1.93843782e-01f, 7.88320601e-03f, 5.59933186e-02f, -2.53472716e-01f, -7.53325075e-02f, 1.58360079e-01f,
  -2.30302244e-01f, -3.30066346e-02f, -5.84350154e-02f, 1.33565545e-01f, 1.45744354e-01f, -1.04019269e-02f, 1.46220446e-01f, -4.31972556e-02f, -1.29702777e-01f, -7.96960816e-02f,
  5.16437292e-02f, -5.27316451e-01f, -5.38718700e-01f, -7.20559582e-02f, -3.03715557e-01f, -3.75880301e-01f, -2.88848300e-02f, -2.11832687e-01f, -3.42703849e-01f, 4.63302284e-01f,
  1.52098564e-02f, 6.35425001e-02f, -6.43391311e-02f, 1.12740710e-01f, 2.98367769e-01f, -7.84305260e-02f, 8.67246985e-02f, 1.02426380e-01f, 6.26605600e-02f, 1.31551549e-01f,
  -1.30620927e-01f, 2.23733727e-02f, -6.70563728e-02f, 1.43331230e-01f, 1.33973718e-01f, -7.69371018e-02f, -5.99047095e-02f, 3.12206745e-01f, -4.66392040e-02f, -3.12971510e-02f,
  -1.20738462e-01f, -1.48724824e-01f, -2.99685448e-02f, 2.76916027e-02f, -1.72017753e-01f, -2.07803860e-01f, 1.01811765e-02f, 4.98647057e-02f, 3.98365147e-02f, 8.54511335e-02f,
  6.70163929e-01f, -1.57704249e-01f, 1.89292267e-01f, -2.71803141e-02f, -8.17213878e-02f, -6.76594488e-03f, 2.27511555e-01f, -9.32199061e-02f, -6.58978289e-03f, 2.64621407e-01f,
  3.28228660e-02f, -3.69435549e-02f, 1.53755367e-01f, 5.24585545e-02f, -3.11212447e-02f, -1.31908894e-01f, 2.78245836e-01f, -1.58914819e-01f, -2.86910981e-02f, -2.60827341e-03f,
  3.16543639e-01f, 1.27488868e-02f, 1.17802590e-01f, -6.65552169e-02f, 1.76665895e-02f, -8.23114887e-02f, 1.48891792e-01f, 1.63916409e-01f, -1.06470115e-01f, 8.58167827e-01f,
  8.26297522e-01f, 5.28355241e-01f, 3.87623221e-01f, 1.57005012e-01f, 5.87651553e-03f, 1.15865313e-01f, 3.22233677e-01f, 6.61588907e-02f, -5.57087734e-02f, 2.22091481e-01f,
  2.00973362e-01f, -1.29515931e-01f, -3.65078300e-02f, -1.18734226e-01f, 7.61640668e-02f, 1.57607973e-01f, -1.10265642e-01f, 1.38024017e-01f, 9.25704688e-02f, 8.56353492e-02f,
  5.05383536e-02f, 2.31574208e-01f, 1.86434686e-01f, 1.03334337e-01f, -3.70001933e-03f, -1.44827411e-01f, 1.09158187e-04f, 9.46287364e-02f, 1.86343834e-01f, 1.14305764e-01f,
  1.92229211e-01f, 5.19618571e-01f, -3.76084715e-01f, -6.86804503e-02f, 1.16342679e-01f, -6.22396208e-02f, -1.22671910e-01f, 8.50900449e-03f, -6.29983693e-02f, -5.70463426e-02f,
  -1.74803250e-02f, -3.35055292e-02f, 2.77477689e-03f, 1.01089515e-01f, 1.21714912e-01f, -5.67833483e-02f, 1.18463404e-01f, 1.45859987e-01f, -7.53342137e-02f, 9.61079597e-02f,
  -1.21902637e-01f, 6.34888262e-02f, 7.59909749e-02f, -1.07633837e-01f, 1.00198261e-01f, -1.76851749e-02f, 1.07849509e-01f, 9.45595801e-02f, 1.00669987e-01f, 6.23804890e-02f,
  -1.21942386e-01f, 2.07524002e-01f, 2.08517283e-01f, 1.14370838e-01f, 1.07843712e-01f, 3.73197533e-02f, 6.09129202e-03f, 5.00255935e-02f, 5.35417646e-02f, 8.73359367e-02f,
  4.48556943e-03f, 1.19594425e-01f, -5.99068068e-02f, 7.20859319e-03f, -1.21655568e-01f, 1.00134090e-02f, -4.08499241e-02f, 2.70623956e-02f, 1.56210596e-02f, -3.35694887e-02f,
  5.20292744e-02f, -5.10973744e-02f, 6.28449172e-02f, -1.35556771e-03f, -1.13750942e-01f, -1.96931697e-02f, -5.62419295e-02f, -1.65234376e-02f, 1.08517870e-01f, -1.81112103e-02f,
  -5.99489033e-01f, -1.32331043e-01f, -5.19321673e-02f, 1.44948252e-02f, 8.20796862e-02f, 2.48834062e-02f, -2.30319053e-02f, -9.99488235e-02f, -1.25220761e-01f, -8.42044596e-03f,
  -3.07494309e-02f, 1.39599100e-01f, 5.28072715e-02f, -1.83145031e-02f, -1.34445548e-01f, -9.90639552e-02f, -3.20383869e-02f, -8.16026628e-02f, -1.31435260e-01f, -1.41258568e-01f,
  -1.20869190e-01f, -1.69601575e-01f, -1.32525697e-01f, -2.02605873e-01f, -5.77819906e-02f, -1.68892860e-01f, -2.02162683e-01f, -8.47763717e-02f, -6.52889237e-02f, -6.97202161e-02f,
  2.01217011e-01f, 1.71408489e-01f, 7.34264106e-02f, 1.66045073e-02f, -3.51458967e-01f, -4.19673234e-01f, -3.68255913e-01f, -2.37888470e-01f, 3.20085464e-03f, -9.65160728e-02f,
  -2.98115820e-01f, -1.99123118e-02f, 5.05899778e-03f, 1.62862033e-01f, 1.40809178e-01f, 2.27993011e-01f, 2.30389655e-01f, 2.60781437e-01f, 1.80114016e-01f, 1.26180664e-01f,
  1.54781207e-01f, 1.88826203e-01f, 1.09083273e-01f, 1.61049575e-01f, 2.93232769e-01f, 1.56450167e-01f, -4.38124128e-02f, -1.08482160e-01f, -5.54663427e-02f, 4.94443625e-01f,
  4.01779771e-01f, -1.93190333e-02f, -7.14773983e-02f, -7.05203190e-02f, 1.64351128e-02f, 1.78090826e-01f, 3.06826755e-02f, 2.70165317e-02f, 2.84968801e-02f, 1.43654644e-01f,
  -5.36489561e-02f, 1.17253795e-01f, -1.17716538e-02f, -3.72258015e-02f, -1.10834196e-01f, 2.07885671e-02f, 1.51888937e-01f, 2.21976101e-01f, 1.41371027e-01f, 1.97445512e-01f,
  3.46949659e-02f, -9.52971354e-02f, -2.77587384e-01f, -2.79950112e-01f, 6.74442248e-03f, -1.63152039e-01f, -1.80285886e-01f, 8.68639499e-02f, -1.13221474e-01f, 1.60661399e-01f,
  -1.15677513e-01f, -9.26055312e-02f, -1.01941086e-01f, -9.31593962e-03f, -3.92436460e-02f, -4.81962562e-02f, -6.06661476e-02f, 2.35209782e-02f, -3.23529243e-02f, 5.04403561e-03f,
  -2.33635437e-02f, -1.67824868e-02f, -3.01786680e-02f, -2.01203786e-02f, 8.14936087e-02f, -1.05931489e-02f, 7.69754201e-02f, -3.35842036e-02f, -1.71848804e-01f, -5.71560464e-04f,
  -2.94553656e-02f, -2.71889903e-02f, -5.64602539e-02f, 1.95947159e-02f, 2.70380285e-02f, -2.25727763e-02f, 1.02176555e-01f, -6.54637218e-02f, 1.53778642e-02f, 4.54747677e-02f,
  -1.94630951e-01f, -4.68599766e-01f, 2.50564188e-01f, 2.16047868e-01f, 1.13437451e-01f, 1.69562902e-02f, 1.82108253e-01f, 4.92514372e-02f, 8.11543241e-02f, 7.85188228e-02f,
  -2.58416813e-02f, 4.84012254e-02f, 5.78982718e-02f, 6.00194559e-02f, -8.18631798e-02f, -1.50424004e-01f, -4.95705083e-02f, 9.65979844e-02f, -3.91100533e-02f, 3.72881517e-02f,
  4.71383184e-02f, -1.78398505e-01f, -2.79835492e-01f, -2.05718219e-01f, -3.12516391e-02f, -1.63820148e-01f, -1.63910896e-01f, -1.83698192e-01f, -3.48925471e-01f, -1.88600466e-01f,
  9.92421269e-01f, -5.30319154e-01f, -2.34249115e-01f, 6.67853832e-01f, 1.06175407e-03f, -1.70744628e-01f, -1.20851152e-01f, 2.99210966e-01f, 4.58664447e-01f, -1.09870926e-01f,
  -6.77896142e-01f, -6.01872623e-01f, -4.20702249e-01f, -4.22929317e-01f, -1.65756815e-03f, 1.50114477e-01f, 3.73404950e-01f, 1.44666538e-01f, -7.64071122e-02f, -3.32721740e-01f,
  -2.24607542e-01f, 3.91867012e-01f, 2.46141419e-01f, -9.09512769e-03f, -2.34289289e-01f, -1.99976549e-01f, -1.79945812e-01f, -2.02353314e-01f, -5.96788585e-01f, -2.88547873e-01f,
  -3.05340737e-01f, -1.37913033e-01f, -7.00594559e-02f, -8.59258622e-02f, -9.94908512e-02f, -5.74558415e-03f, -2.08428595e-02f, 7.08490238e-02f, -4.57204394e-02f, -2.62130164e-02f,
  -4.38395031e-02f, -1.05185427e-01f, -2.19231788e-02f, -2.52204627e-01f, 8.89129043e-02f, 3.25103477e-02f, -9.85479541e-03f, -1.72425479e-01f, 7.92125519e-03f, -6.93135411e-02f,
  -2.91625947e-01f, -5.22067547e-02f, -2.08590124e-02f, -2.83769667e-02f, -1.32147059e-01f, 5.03948852e-02f, -1.99038371e-01f, -1.95768192e-01f, -1.66263487e-02f, 2.59567201e-02f,
  1.77201420e-01f, 7.61815459e-02f, -2.95657441e-02f, -2.04600077e-02f, 9.41848382e-02f, 5.30876257e-02f, 1.24871314e-01f, 2.11156979e-02f, 1.32119013e-02f, 6.04147129e-02f,
  9.89129320e-02f, 6.31805360e-02f, -3.70519087e-02f, -4.69130725e-02f, -3.30202398e-03f, -3.37233655e-02f, 1.42879099e-01f, -1.26203343e-01f, -9.40191522e-02f, 7.72209764e-02f,
  -1.53666819e-02f, -5.60864322e-02f, 7.28383511e-02f, -3.07523720e-02f, -8.03785622e-02f, -1.19994573e-01f, 2.90418286e-02f, -2.29826078e-01f, -8.25744681e-03f, 1.14737585e-01f,
  3.00730467e-01f, -1.45324618e-01f, 3.13258827e-01f, -1.54088410e-02f, -5.39427958e-02f, -6.56421781e-02f, -7.50167891e-02f, -3.67274061e-02f, -1.45739377e-01f, -1.02954186e-01f,
  -3.50225747e-01f, 3.21515873e-02f, -6.09670430e-02f, -8.47538188e-02f, 9.62259620e-02f, -1.63410269e-02f, -2.41221875e-01f, 3.92328836e-02f, -1.51184276e-01f, 7.58150816e-02f,
  3.98250334e-02f, 2.73903698e-01f, 4.28737700e-01f, 2.28689551e-01f, 5.80836758e-02f, 2.19792038e-01f, 2.29363278e-01f, 9.07658413e-02f, 1.20615706e-01f, 4.50289905e-01f,
  5.72938085e-01f, 3.68089646e-01f, 5.16611695e-01f, 4.26966846e-01f, 2.91777432e-01f, 2.00326189e-01f, 9.81867760e-02f, 5.84657490e-02f, -1.02747850e-01f, 1.88177362e-01f,
  1.16163835e-01f, -1.25820324e-01f, -2.17381001e-01f, -8.12318772e-02f, 7.09138438e-02f, 1.76257670e-01f, 5.78260794e-02f, 1.47997245e-01f, 1.45917103e-01f, 2.52742112e-01f,
  1.29525229e-01f, 2.20047515e-02f, 1.30825400e-01f, 1.84604675e-01f, 2.12476194e-01f, -8.82140249e-02f, -1.72448512e-02f, 7.41089061e-02f, 1.47829548e-01f, 2.88416415e-01f,
  1.55762777e-01f, 2.12260842e-01f, -2.08514631e-01f, -1.53339997e-01f, -7.14036301e-02f, -1.43920854e-01f, 6.02625757e-02f, -3.96192074e-02f, -1.22658372e-01f, -2.44674888e-02f,
  8.09782092e-03f, 1.46445809e-02f, -9.74204317e-02f, -2.11401749e-02f, 7.43211538e-04f, -1.40862688e-01f, -1.86160415e-01f, -9.36191622e-03f, -6.22749440e-02f, 1.08183950e-01f,
  -2.46764775e-02f, 6.30503297e-02f, 2.00194314e-01f, -1.09036444e-02f, 7.84680098e-02f, -1.83372900e-01f, -1.24652497e-01f, 3.70452702e-02f, -9.17088017e-02f, 2.13257581e-01f,
  -1.74806818e-01f, 2.03631133e-01f, 2.30623394e-01f, -5.81409857e-02f, 6.18292615e-02f, 3.51487771e-02f, 3.46519984e-02f, -5.38394088e-03f, -4.43111872e-03f, 9.82363299e-02f,
  -2.11260673e-02f, 1.46615997e-01f, 7.19697624e-02f, 3.95038463e-02f, 8.03958550e-02f, 1.14116132e-01f, 9.07508433e-02f, 3.61384191e-02f, -1.07995339e-01f, -8.00012723e-02f,
  4.23225053e-02f, -8.95893201e-02f, -5.84925003e-02f, -1.24887168e-01f, -2.20799506e-01f, -2.67571304e-03f, 6.31847978e-02f, -8.53054896e-02f, -6.91034272e-02f, -1.28734007e-01f,
  -6.44788742e-01f, -3.72347772e-01f, -1.37042599e-02f, -1.14442684e-01f, -2.87477877e-02f, -4.91824299e-02f, -4.32388783e-02f, -1.01662733e-01f, -1.69353962e-01f, -6.35482147e-02f,
  3.99521291e-02f, 1.41375596e-02f, -2.56029591e-02f, -1.26256198e-01f, -2.75613144e-02f, -1.59512833e-01f, -1.69237219e-02f, -2.35528704e-02f, -1.29931301e-01f, -3.71906091e-03f,
  -4.12045307e-02f, -2.25399397e-02f, 6.89655244e-02f, 3.49655598e-02f, -3.56231630e-02f, -2.12376043e-01f, -1.46188587e-01f, -1.30182272e-02f, -1.54607803e-01f, -1.38859987e-01f,
  -5.94203591e-01f, 8.57669652e-01f, 3.22250336e-01f, -4.78466868e-01f, 1.11218460e-01f, 5.48197627e-01f, 9.15127754e-01f, 2.94737786e-01f, -2.07041293e-01f, 4.52865630e-01f,
  4.26603615e-01f, -3.49195153e-01f, -8.88542235e-02f, -3.32000442e-02f, 1.25645652e-01f, 5.23194611e-01f, 4.06770825e-01f, -3.24040830e-01f, -7.15019405e-01f, -5.05856276e-01f,
  -2.30577648e-01f, -4.48069960e-01f, -5.52955627e-01f, -2.78239787e-01f, -1.53510347e-01f, -2.91315347e-01f, 2.93765068e-01f, 4.16282751e-03f, 2.98212945e-01f, -1.79157883e-01f,
  -4.85577732e-02f, 1.72269568e-01f, -3.90530050e-01f, -3.87135625e-01f, -4.04596515e-03f, -1.87733844e-01f, 1.34689182e-01f, -1.72391549e-01f, 9.79396924e-02f, -3.69466767e-02f,
  -6.03853501e-02f, -5.16473129e-02f, -1.61496550e-02f, -1.33787589e-02f, -1.53904840e-01f, -5.63706132e-03f, -1.18581772e-01f, -1.53619111e-01f, -2.27946982e-01f, -4.60853949e-02f,
  1.77660063e-02f, -3.96706238e-02f, 4.96785454e-02f, 1.79467514e-01f, 7.71976262e-02f, -1.83476314e-01f, 1.77614599e-01f, -4.03127074e-01f, -7.70381987e-02f, -3.73021603e-01f,
  -1.69026241e-01f, -3.49226408e-02f, -9.86199733e-03f, 6.06938712e-02f, -9.57836583e-03f, -4.21573408e-02f, 3.68220583e-02f, -9.09917802e-03f, 2.82421689e-02f, -2.35031303e-02f,
  1.01626955e-01f, 2.61967033e-02f, -1.30681679e-01f, 1.19416103e-01f, -1.11737132e-01f, 5.41384742e-02f, -4.53243554e-02f, 1.65245350e-04f, 1.65383518e-01f, 8.30921680e-02f,
  -2.54470035e-02f, -1.09179772e-01f, -1.37033746e-01f, -1.23714335e-01f, 3.66496071e-02f, 1.45038590e-01f, 9.35309678e-02f, -1.13284744e-01f, -7.77029246e-02f, 4.16859388e-01f,
  -3.03965151e-01f, 2.82761931e-01f, -1.30346045e-01f, 1.02945697e-02f, 7.07714781e-02f, -9.28260535e-02f, 1.29484981e-01f, 1.28632560e-01f, 1.11520723e-01f, -1.19307928e-01f,
  7.37867225e-03f, 2.99636684e-02f, 2.77948856e-01f, 6.80265995e-03f, -2.28916556e-01f, 1.11863859e-01f, 6.98710456e-02f, -1.74759164e-01f, -7.34177709e-04f, -1.50761113e-01f,
  4.72928695e-02f, -1.26145780e-01f, -2.95046300e-01f, -8.68778452e-02f, -4.31183875e-02f, -2.53396302e-01f, -8.29324424e-02f, -3.02746445e-01f, 3.53379990e-03f, -1.40116513e-01f,
  5.24538934e-01f, 4.18349177e-01f, -1.15107626e-01f, 1.23256639e-01f, 1.27922371e-01f, 2.42070749e-01f, 2.66730338e-01f, 1.29256129e-01f, -8.80843252e-02f, 7.25514516e-02f,
  9.52596441e-02f, -1.13870822e-01f, -1.31774366e-01f, -1.13989621e-01f, -2.32741266e-01f, -3.14658672e-01f, -3.21910650e-01f, -3.39262784e-01f, -1.14232309e-01f, 6.56917393e-02f,
  -5.09054810e-02f, 2.69867837e-01f, 2.09116563e-01f, -1.90034926e-01f, 7.46459886e-02f, -2.28606761e-01f, -1.51189581e-01f, 1.43706039e-01f, -8.35131332e-02f, -3.23505104e-01f,
  1.61379665e-01f, 3.30488086e-01f, -1.24212749e-01f, 4.97722924e-02f, 1.04437001e-01f, -3.76464501e-02f, -9.26140845e-02f, 4.28852672e-03f, 2.04990685e-01f, -6.44341931e-02f,
  4.07299362e-02f, 1.19308710e-01f, 1.41183302e-01f, 1.24971300e-01f, 2.05425352e-01f, 2.10387483e-01f, 1.91024244e-01f, 7.75033385e-02f, -4.89802733e-02f, 4.76016179e-02f,
  1.43177092e-01f, 1.84159160e-01f, 2.10978121e-01f, -6.59064800e-02f, -1.27436459e-01f, -1.39398938e-02f, 2.56278459e-02f, -6.83238953e-02f, -5.71898036e-02f, -7.74671137e-02f,
  -1.74287558e-01f, -1.68078676e-01f, -3.86143997e-02f, -1.76868290e-02f, -3.18615623e-02f, 7.36073181e-02f, 3.55227590e-02f, -4.24415357e-02f, -1.60470828e-01f, 1.05231009e-01f,
  -1.61481015e-02f, -7.12629706e-02f, 5.48646487e-02f, -3.42612676e-02f, -1.63855135e-01f, 1.07234597e-01f, 1.45726487e-01f, -9.31452587e-03f, 1.15413005e-02f, 1.06266014e-01f,
  -9.11477357e-02f, 5.67677468e-02f, 1.04487956e-01f, 1.92201301e-01f, 1.88959867e-01f, 5.00341691e-02f, -5.59505634e-02f, 6.19645789e-02f, 1.44735510e-02f, 5.11741005e-02f,
  1.72100753e-01f, -3.97427706e-03f, -2.13955045e-01f, -1.50578111e-01f, 7.54148886e-02f, 1.25514448e-01f, -3.42135914e-02f, 7.11723343e-02f, 1.58009097e-01f, 1.40206842e-02f,
  5.00015542e-02f, -1.15567684e-01f, 2.16492385e-01f, -1.41630489e-02f, 6.96355551e-02f, 5.21898419e-02f, 1.62925661e-01f, 3.94865796e-02f, -1.54828504e-02f, 4.66786698e-02f,
  2.21156348e-02f, -1.66192427e-02f, 2.82797758e-02f, -1.59036323e-01f, -1.41220063e-01f, -6.13158531e-02f, 2.46550981e-02f, 1.09032445e-01f, 3.64559703e-02f, -1.31760225e-01f,
  7.31690705e-01f, -3.62473220e-01f, -3.56686562e-01f, 2.21276090e-01f, -2.11035423e-02f, 7.97941759e-02f, -8.61979946e-02f, 9.44112688e-02f, 2.00074434e-01f, 1.04235023e-01f,
  5.68707027e-02f, 3.10698688e-01f, 2.64757454e-01f, 8.09463486e-02f, 6.34773448e-02f, -1.88762501e-01f, -2.73291916e-01f, 5.31673990e-02f, 1.56627521e-01f, 2.51512788e-02f,
  1.52435917e-02f, -2.46971659e-02f, 2.59141415e-01f, 4.00686860e-02f, -1.76004171e-01f, -4.60466035e-02f, -2.90435493e-01f, -1.85435623e-01f, -2.54654288e-01f, -3.67472559e-01f,
  -1.70255631e-01f, -3.17384638e-02f, 2.83241775e-02f, -4.33474593e-02f, -8.32862109e-02f, 1.67082008e-02f, -7.40978420e-02f, -2.09863767e-01f, 3.92653886e-03f, -7.62315542e-02f,
  -1.09084308e-01f, 1.89596787e-02f, -2.81275585e-02f, -1.47961020e-01f, -6.97603151e-02f, -5.70152327e-02f, -3.81013714e-02f, 7.16013787e-03f, -8.22787955e-02f, -6.17649220e-02f,
  -1.77890226e-01f, -4.57037091e-02f, -9.47010741e-02f, -1.33060329e-02f, 2.93441694e-02f, 1.09187014e-01f, -1.17447264e-01f, -2.97032595e-02f, -1.18875727e-01f, -1.14284776e-01f,
  2.33679824e-02f, 1.85885187e-03f, 4.57978994e-02f, 1.29934713e-01f, 1.58306494e-01f, 2.73317359e-02f, -2.91578565e-03f, -3.44334170e-02f, 9.78481174e-02f, -8.24780315e-02f,
  -1.86113805e-01f, 5.53554334e-02f, 1.27848059e-01f, 4.71572541e-02f, 5.47023751e-02f, -6.63930774e-02f, -7.68303573e-02f, -9.54286456e-02f, 2.87580080e-02f, -1.12675456e-02f,
  1.58439621e-01f, -8.78186524e-02f, 2.99187452e-02f, -8.59700085e-04f, -8.12810734e-02f, 5.70615940e-02f, -7.95141459e-02f, 8.02501012e-03f, -5.41870221e-02f, -1.77340526e-02f,
  3.65843885e-02f, 2.50984192e-01f, 8.80695060e-02f, 6.64828718e-02f, -1.68409675e-01f, -5.02895080e-02f, -7.16260355e-03f, -3.76395062e-02f, -1.67311691e-02f, 3.89393866e-02f,
  -2.37622857e-02f, 3.80165391e-02f, 2.70831771e-02f, -9.37504619e-02f, 2.11363472e-02f, -2.87211547e-03f, 3.38841639e-02f, 1.51600242e-01f, 6.46645725e-02f, -1.31719604e-01f,
  -6.11574091e-02f, 1.33745521e-01f, 1.84323400e-01f, 1.11066073e-01f, -2.84141004e-02f, 2.71682352e-01f, 5.47615550e-02f, 1.23549541e-02f, 1.77431762e-01f, 7.31737465e-02f,
  3.92218798e-01f, 3.52631181e-01f, -1.94527820e-01f, 2.09164590e-01f, 1.00052610e-01f, 1.22025058e-01f, 4.49849814e-01f, 3.59923065e-01f, 1.82936475e-01f, 8.66395459e-02f,
  -3.31988364e-01f, -4.72992539e-01f, -4.31617558e-01f, -3.82904500e-01f, -2.08522603e-01f, 3.30615312e-01f, 1.69752121e-01f, -3.90254110e-01f, -3.68948013e-01f, -1.17006540e-01f,
  7.84396231e-02f, 3.67936671e-01f, 3.52631174e-02f, 7.46258497e-02f, 2.59208053e-01f, -1.11493170e-01f, 1.85196012e-01f, 2.48495955e-02f, -8.93776119e-02f, -6.36050627e-02f,
  -5.37885070e-01f, -2.55088951e-03f, -1.86815068e-01f, -1.39720529e-01f, -1.15315042e-01f, -9.29335132e-02f, -2.44306326e-02f, -1.52486846e-01f, -6.16426505e-02f, -5.55283614e-02f,
  -1.33005142e-01f, -1.69939578e-01f, -1.16579659e-01f, 2.00884254e-03f, 1.01405308e-01f, 7.16318027e-04f, 5.42077720e-02f, -1.56496495e-01f, -2.02312261e-01f, -1.09965339e-01f,
  -1.64345875e-01f, -1.05697326e-01f, -1.16187204e-02f, 7.44708925e-02f, -1.48064077e-01f, -2.24469617e-01f, 6.16756221e-03f, -1.34804085e-01f, -1.37472332e-01f, 2.18614906e-01f,
  -2.73889005e-02f, -3.60933580e-02f, -9.73318052e-03f, 1.25722021e-01f, 5.30383550e-02f, -8.25647078e-03f, -1.74488442e-03f, -4.33616014e-03f, 6.11223921e-04f, 1.27735421e-01f,
  -3.10206898e-02f, -4.76190113e-02f, 2.22318879e-04f, -2.72076018e-03f, -1.30506054e-01f, 4.62668501e-02f, -6.74351072e-03f, 5.35198264e-02f, -4.67867926e-02f, 1.26342431e-01f,
  -2.61109509e-02f, -1.08653326e-02f, 3.54386196e-02f, 6.21482581e-02f, -1.24390600e-02f, 2.24044360e-02f, -4.32402901e-02f, -6.30936027e-02f, -1.69593021e-02f, 5.13913520e-02f,
  2.64298677e-01f, -2.45225176e-01f, 3.26315463e-02f, 6.57813922e-02f, -5.88294771e-03f, -4.94434908e-02f, -1.27306640e-01f, -1.54507384e-01f, -1.69408489e-02f, -8.24220031e-02f,
  -1.85959369e-01f, -1.53935775e-01f, -1.04099467e-01f, -1.08430743e-01f, 6.59296662e-02f, 6.71107043e-03f, 1.45916222e-02f, -3.13576870e-02f, -6.20675832e-03f, -2.34948248e-02f,
  2.07096152e-02f, 1.24595024e-01f, 9.60049108e-02f, 1.15193598e-01f, 6.84275851e-02f, 1.42818792e-02f, -5.51668145e-02f, -9.74968600e-04f, 2.59942859e-02f, 2.52751291e-01f,
  -3.38783711e-02f, -3.52955759e-01f, -4.28250581e-02f, 1.63594514e-01f, -1.01103321e-01f, -1.93606511e-01f, -2.07252368e-01f, 7.38377050e-02f, 8.55826065e-02f, 7.55120069e-02f,
  -7.29681030e-02f, -8.56536701e-02f, 6.68316483e-02f, -2.66976178e-01f, -3.18532348e-01f, -6.25767931e-02f, -1.42889023e-01f, -1.68520585e-01f, -2.34841809e-01f, -8.06314349e-02f,
  -6.98995963e-02f, 6.89147711e-02f, -9.30703208e-02f, 8.01961217e-03f, 1.68457538e-01f, -2.55233236e-02f, 5.12955375e-02f, -2.02602550e-01f, -3.99215996e-01f, -1.54573888e-01f,
  2.06312001e-01f, -3.90030265e-01f, -3.32438610e-02f, -2.96290189e-01f, -3.40592046e-03f, 1.22827768e-01f, 1.45267416e-02f, 2.07027674e-01f, 1.48354992e-01f, 1.91739142e-01f,
  -5.08368090e-02f, -1.31521071e-03f, 8.27556029e-02f, 4.62533385e-02f, 1.09597012e-01f, -2.16907654e-02f, -8.73363540e-02f, 2.45731864e-02f, -1.78914368e-02f, 4.69428487e-02f,
  -1.49995536e-01f, -9.23315212e-02f, -4.58851159e-02f, -7.63058960e-02f, -5.86228594e-02f, -1.28172025e-01f, -3.96262333e-02f, -9.12353024e-02f, -1.91053793e-01f, 1.43311813e-01f,
  -7.37152249e-02f, 2.36581296e-01f, 1.55976593e-01f, 8.09404477e-02f, 2.16124773e-01f, 1.57029495e-01f, 1.23186573e-01f, 2.29622368e-02f, 5.35107180e-02f, 6.12908639e-02f,
  1.02081038e-01f, 4.81697358e-02f, 5.67968236e-03f, 1.81900598e-02f, -7.37149939e-02f, -3.75746153e-02f, -3.92938927e-02f, -8.34623650e-02f, 5.90577489e-03f, 8.34873766e-02f,
  -5.00875302e-02f, -2.45662034e-02f, -4.92446274e-02f, -7.83102065e-02f, -2.13372871e-01f, -1.39256850e-01f, -8.71871412e-02f, -6.61674738e-02f, 5.67163490e-02f, -1.21687233e-01f,
  3.28483045e-01f, -4.25715357e-01f, 9.15506631e-02f, -7.04933032e-02f, 4.82695438e-02f, 5.41429315e-03f, -3.61772403e-02f, -7.59678287e-03f, 1.57081634e-01f, 1.67932231e-02f,
  -1.85349450e-01f, 8.63525644e-02f, 1.21189848e-01f, 5.38689122e-02f, 1.98134735e-01f, 1.33588873e-02f, -4.05544154e-02f, 6.49528727e-02f, -8.81332979e-02f, 6.09956831e-02f,
  -3.98394726e-02f, 7.37959892e-02f, 2.02692255e-01f, 2.00194538e-01f, -7.73968920e-02f, 7.72959143e-02f, 1.18496083e-01f, 1.54119089e-01f, -5.07683791e-02f, 3.21332574e-01f,
  -1.09686232e+00f, 3.35204422e-01f, 1.43489420e-01f, -4.98308361e-01f, -2.66324162e-01f, -1.75957620e-01f, 1.65236965e-01f, -9.05481055e-02f, -3.44841570e-01f, 2.73399591e-01f,
  1.43388957e-01f, -2.40021661e-01f, -1.21293008e-01f, -6.82023093e-02f, -8.08828697e-02f, 4.69636023e-01f, 2.69404799e-01f, -3.93207699e-01f, -5.52338898e-01f, -3.88728261e-01f,
  -1.17907807e-01f, -3.66847247e-01f, -5.54854274e-01f, -1.71233252e-01f, -6.81312829e-02f, -2.91731298e-01f, 2.55828619e-01f, -2.16539860e-01f, -8.58944207e-02f, 1.77342266e-01f,
  3.74937743e-01f, -3.87965113e-01f, -6.61246106e-02f, -1.28654286e-01f, 5.37731461e-02f, -9.10719782e-02f, -3.33640538e-02f, -5.21070063e-02f, 1.41053190e-02f, -1.92747675e-02f,
  -7.90679455e-02f, -1.16042696e-01f, -5.60783520e-02f, 5.96281663e-02f, -2.25828141e-02f, -4.16010171e-02f, -6.22838698e-02f, -8.56913105e-02f, 6.40493557e-02f, 2.32480332e-01f,
  2.68089086e-01f, -2.61091348e-02f, 2.68399250e-02f, 4.95246835e-02f, -2.31321119e-02f, -1.90049306e-01f, -2.71670874e-02f, -1.78692818e-01f, 1.49013875e-02f, -5.58750853e-02f,
  1.93509936e-01f, 6.20206743e-02f, -1.01817705e-01f, -3.97639051e-02f, 1.26256491e-03f, 1.91719513e-02f, 9.14679095e-03f, 2.87099741e-02f, -9.10932291e-03f, 5.93477748e-02f,
  -2.18042522e-03f, 7.03541636e-02f, -7.33382925e-02f, -6.82698786e-02f, -4.95557487e-02f, -1.33375868e-01f, -1.34755448e-01f, 1.37705043e-01f, 1.08675480e-01f, -2.59290133e-02f,
  -1.00973420e-01f, 6.62681535e-02f, -5.76599240e-02f, -5.29749377e-04f, 3.04724276e-02f, 7.36064697e-03f, 5.49551249e-02f, -3.49162035e-02f, 1.11729428e-02f, -1.80327386e-01f,
  1.09141216e-01f, -1.21441126e-01f, 6.96789995e-02f, 3.82137112e-02f, -1.98235898e-03f, 2.50361133e-02f, -4.23314720e-02f, -3.09053436e-02f, -1.06308712e-02f, -6.69353306e-02f,
  -5.35506122e-02f, 4.94360887e-02f, 1.53624564e-01f, 6.36922568e-02f, -6.32247031e-02f, -8.25073570e-02f, 8.67396221e-02f, 7.14420602e-02f, 6.87588379e-02f, 1.58523917e-01f,
  3.15554947e-01f, 4.47854437e-02f, 1.54147506e-01f, 1.13955334e-01f, 1.10880628e-01f, -1.07299849e-01f, 1.85840979e-01f, 7.43031502e-02f, 3.00428551e-02f, 2.80225039e-01f,
  -8.10383499e-01f, -3.67270023e-01f, 1.14651166e-01f, -4.93205398e-01f, -5.76751009e-02f, 3.02149445e-01f, 1.82396308e-01f, 1.08535610e-01f, -5.59990294e-02f, -2.08350196e-01f,
  -6.40045777e-02f, -1.90040112e-01f, -2.65656203e-01f, 1.61820222e-02f, 4.97867726e-02f, 1.23839498e-01f, 5.69159314e-02f, 4.73393984e-02f, 2.40056783e-01f, 3.14897388e-01f,
  -6.67118803e-02f, -1.90169588e-01f, -2.51625329e-01f, -1.12482697e-01f, -3.70665759e-01f, -2.88373381e-01f, -1.10980511e-01f, -3.54039222e-01f, 2.44509727e-02f, -3.69691938e-01f,
  -4.58319247e-01f, -3.73399556e-01f, 2.97340035e-01f, -1.64404765e-01f, 4.39501889e-02f, -4.26107459e-02f, 6.29355311e-02f, 4.60918818e-04f, 7.16226175e-02f, -6.87788352e-02f,
  -2.74805158e-01f, 3.31559405e-02f, -1.63876101e-01f, -4.82075810e-02f, -8.76040533e-02f, -6.85242638e-02f, 1.04722440e-01f, 3.23370360e-02f, -5.26907854e-02f, 1.52468160e-01f,
  6.74685240e-02f, -3.41026485e-01f, -3.73831749e-01f, 1.40087306e-01f, 1.16881818e-01f, -1.14659965e-02f, -1.20295808e-01f, -6.11065924e-02f, 2.09559873e-02f, -5.04429519e-01f,
  -3.13204224e-03f, 1.39953449e-01f, 1.81194678e-01f, 9.43554491e-02f, 2.97561623e-02f, -7.75961652e-02f, -1.66974828e-01f, -3.53380181e-02f, 3.76662165e-02f, -1.00756273e-01f,
  8.04268569e-02f, 8.23910087e-02f, -4.44193855e-02f, -1.59033477e-01f, -5.15553989e-02f, -1.43712953e-01f, 5.49242049e-02f, -2.35059354e-02f, -5.57705723e-02f, 7.87857268e-03f,
  -1.62926912e-02f, -1.55419484e-01f, 1.79702267e-02f, -1.29045956e-02f, 3.44591625e-02f, -3.14667337e-02f, -9.11632925e-02f, 6.51041865e-02f, -1.73625555e-02f, -8.30343813e-02f,
  -3.73753726e-01f, 4.24897432e-01f, -4.77829814e-01f, 3.02189942e-02f, -5.43047972e-02f, 1.23515643e-01f, -3.43181938e-02f, 1.31463036e-01f, -7.75682777e-02f, -8.10584649e-02f,
  5.63670993e-02f, -1.50151327e-01f, -2.11268649e-01f, -2.34439205e-02f, -4.19760980e-02f, -2.18684617e-02f, -1.85249552e-01f, -3.70116472e-01f, 4.44530807e-02f, -1.35360345e-01f,
  -4.96165380e-02f, -2.87904054e-01f, -5.67681611e-01f, -2.63102293e-01f, -1.58690780e-01f, -3.13925683e-01f, -2.29618669e-01f, -2.21032545e-01f, -2.46376202e-01f, -5.96141219e-01f,
  -7.98314512e-02f, -5.83241642e-01f, 1.52029634e-01f, -1.21086210e-01f, -1.03416711e-01f, -3.14912379e-01f, -8.35713267e-01f, -5.15064061e-01f, -9.20571610e-02f, -7.24433780e-01f,
  -8.32968950e-02f, 6.06557548e-01f, 5.36702693e-01f, 2.39108488e-01f, -2.35752791e-01f, -7.76679575e-01f, -5.64106643e-01f, 1.29759669e-01f, 4.29898649e-01f, -8.34349021e-02f,
  -1.41468480e-01f, 1.57513231e-01f, 2.71665663e-01f, 2.15424038e-02f, -2.00581402e-01f, 1.86189607e-01f, -1.68680727e-01f, 6.63730353e-02f, -2.91203618e-01f, -1.88160241e-01f,
  6.96665123e-02f, -1.52782604e-01f, 2.50941336e-01f, 1.87398940e-01f, 1.15834430e-01f, -4.51650796e-03f, -2.28375629e-01f, 1.67437971e-01f, 8.92904997e-02f, -1.51178196e-01f,
  1.70589224e-01f, 8.86352919e-03f, 2.13256776e-01f, 8.65080357e-02f, -2.34113395e-01f, -6.48346245e-02f, -1.45963281e-01f, 3.78996804e-02f, -2.78720409e-02f, -1.16478883e-01f,
  -2.17365086e-01f, -1.04259932e-02f, 1.65155336e-01f, -2.58871675e-01f, -1.32317305e-01f, 4.27576542e-01f, -3.78540605e-02f, -3.00486194e-04f, -1.89601436e-01f, -5.00454545e-01f,
  -1.18993014e-01f, 9.81353596e-02f, -8.84333402e-02f, 8.45120251e-02f, 1.40528353e-02f, 5.98802827e-02f, 2.35726535e-02f, -5.78423664e-02f, 6.38339147e-02f, 3.75496112e-02f,
  -7.40621164e-02f, -1.00317616e-02f, 1.71258941e-01f, -1.33525223e-01f, 1.46996945e-01f, -9.00187343e-02f, -1.40904440e-02f, -1.03326634e-01f, 4.04192321e-02f, 7.04147248e-03f,
  3.73606421e-02f, 1.83239244e-02f, 2.89534610e-02f, 1.49579849e-02f, -9.98177379e-02f, -6.94371462e-02f, 1.45257473e-01f, 4.07972857e-02f, 5.44771440e-02f, -8.51979852e-02f,
  2.45133668e-01f, 3.00330110e-03f, -2.40630016e-01f, 8.30995813e-02f, -2.30526835e-01f, 1.20507099e-01f, 5.89887686e-02f, 1.49245039e-01f, 1.88621402e-01f, -1.11913018e-01f,
  -1.22320829e-02f, -1.61844715e-01f, -1.88424900e-01f, 1.40652116e-02f, -4.81653586e-02f, 6.87637627e-02f, -3.33373696e-01f, 2.13312864e-01f, 1.11360274e-01f, 7.29984418e-02f,
  -2.71617949e-01f, -2.63904810e-01f, -1.06220111e-01f, -1.99501440e-01f, 5.50069800e-03f, 1.75059453e-01f, -8.69531259e-02f, -1.00393474e-01f, -1.89387843e-01f, -5.63876390e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  3.01199913e-01f, 3.57252598e-01f, 3.39990437e-01f, 5.44247389e-01f, 6.30743921e-01f, 5.01891136e-01f, 6.91120982e-01f, 3.36931378e-01f, 2.33623981e-01f, 7.54073501e-01f,
  4.61918890e-01f, 4.46654290e-01f, 1.33703738e-01f, 1.86915979e-01f, 7.21374869e-01f, 2.33123243e-01f, 5.19598246e-01f, 6.08720601e-01f, 4.37035233e-01f, 3.73320669e-01f,
  4.16317225e-01f, 1.83977529e-01f, 7.56443322e-01f, 5.23123384e-01f, 5.61604321e-01f, 5.89602828e-01f, 2.87034333e-01f, 2.90258527e-01f, 5.28933764e-01f, 4.19517606e-01f,
  4.18331802e-01f, 5.16739666e-01f, 2.90153772e-01f, 5.03821194e-01f, 1.91244692e-01f, 4.36839402e-01f, 6.55574739e-01f, 2.63740271e-01f, 5.80244601e-01f, 5.81159174e-01f,
  3.25498611e-01f, 2.48228103e-01f, 6.88183427e-01f, 3.97939205e-01f, 6.27938211e-01f, 3.34561497e-01f, 6.62087023e-01f, 6.11753106e-01f, 4.93639171e-01f, 6.67988956e-01f,
  4.04372305e-01f, 5.57001293e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -1.50519624e-01f, -2.28259608e-01f, -9.85456854e-02f, -2.27069631e-01f, -3.36000741e-01f, 5.87233715e-03f, 2.07785711e-01f, 1.03584871e-01f, -1.49529561e-01f, -2.51437545e-01f,
  8.21096376e-02f, 1.48963422e-01f, -3.06631655e-01f, 1.23081468e-01f, 3.37557644e-01f, -1.48441468e-03f, 1.13091998e-01f, -6.90144122e-01f, -8.68298769e-01f, -2.73642004e-01f,
  -1.57653302e-01f, -2.90045768e-01f, 4.15180624e-01f, -1.69516936e-01f, 1.80125773e-01f, -7.04637766e-01f, -7.44946003e-01f, -3.24006259e-01f, -5.03124952e-01f, -4.25371140e-01f,
  3.77388030e-01f, 1.48945138e-01f, -2.02147022e-01f, 4.42012131e-01f, 7.50044268e-03f, 1.29561856e-01f, -2.43047222e-01f, -4.31704611e-01f, -3.89096946e-01f, -5.47822237e-01f,
  -1.99133292e-01f, 4.22750235e-01f, -1.16478562e+00f, 7.54318833e-02f, -1.08929917e-01f, 1.86638102e-01f, 5.04088163e-01f, 1.23893999e-01f, -4.84099299e-01f, 3.22542131e-01f,
  1.72909439e-01f, 1.19162546e-02f, -2.59028792e-01f, -3.51006299e-01f, -2.61248350e-01f, -1.42844155e-01f, -4.09169793e-01f, 1.92544267e-01f, 9.83979926e-02f, -2.73491502e-01f,
  -1.14236273e-01f, -7.39180267e-01f, 1.92479327e-01f, 3.01338464e-01f, -1.97241619e-01f, -2.58873906e-02f, 1.41037717e-01f, 1.20699462e-02f, 1.64657220e-01f, -7.55801005e-03f,
  2.45293543e-01f, -2.11973220e-01f, 1.25026599e-01f, 3.58652234e-01f, -3.34329873e-01f, 2.18553260e-01f, -7.99749196e-02f, 5.21078825e-01f, -3.16775829e-01f, 2.44745478e-01f,
  2.77175993e-01f, -1.65057644e-01f, -6.37989879e-01f, -9.11161423e-01f, 6.42567873e-02f, -4.97374475e-01f, 5.37401557e-01f, -6.56174362e-01f, 2.22765371e-01f, 2.23989844e-01f,
  -5.96197784e-01f, 1.98404610e-01f, -7.55157888e-01f, 5.06778359e-02f, -5.03347576e-01f, -6.57435656e-01f, 2.16276795e-01f, 2.60876268e-01f, -5.50570369e-01f, 1.92893639e-01f,
  -2.55430162e-01f, 4.52613115e-01f, 3.40556115e-01f, -4.19125445e-02f, -4.95859683e-02f, -1.11911297e+00f, -6.35989308e-01f, -3.40438426e-01f, 3.22741210e-01f, 6.70627236e-01f,
  -4.13985521e-01f, -5.57923794e-01f, -5.19871056e-01f, 8.91386569e-02f, -1.70455933e-01f, -7.44437933e-01f, 1.95861742e-01f, -6.98886663e-02f, 1.03193246e-01f, 3.44214708e-01f,
  -7.59985924e-01f, -2.28427500e-01f, 4.71224338e-01f, -4.34435099e-01f, -1.80969134e-01f, -7.38075078e-01f, -3.70869249e-01f, 5.68641901e-01f, 2.67815679e-01f, 2.62127221e-01f,
  5.25328629e-02f, -7.46373981e-02f, 5.23391515e-02f, 7.78800696e-02f, 5.18281292e-03f, -3.93517405e-01f, 2.90590655e-02f, 3.08954030e-01f, -4.40078437e-01f, -3.89584124e-01f,
  1.17041998e-01f, -6.31268024e-01f, -4.06121880e-01f, -4.84289862e-02f, -6.01156116e-01f, 2.50376850e-01f, -3.03715467e-01f, -2.81971246e-01f, -6.30784452e-01f, 6.88930228e-02f,
  2.32992589e-01f, 2.23476470e-01f, -1.04542859e-01f, 8.02957639e-02f, -3.79513144e-01f, -6.38610840e-01f, 7.16913044e-01f, -3.95436492e-03f, 7.78448060e-02f, -5.37409365e-01f,
  4.41062689e-01f, -5.61450481e-01f, 3.42757046e-01f, 2.79296398e-01f, -2.96193451e-01f, 5.67490188e-03f, -5.40053606e-01f, 2.60443896e-01f, -2.11397469e-01f, -8.16254795e-01f,
  -5.36482155e-01f, -3.23090643e-01f, -2.01792225e-01f, 3.63418862e-04f, -1.51206419e-01f, 2.70941108e-01f, 4.39675063e-01f, 2.81688899e-01f, 6.10396147e-01f, -3.06869417e-01f,
  -5.77780545e-01f, -5.65349162e-02f, 4.00579447e-04f, -6.04945838e-01f, -5.13352275e-01f, -5.87217547e-02f, 8.66288692e-02f, -5.10595918e-01f, -3.76791596e-01f, -2.33544692e-01f,
  4.48862374e-01f, 6.27318144e-01f, -2.74658129e-02f, 4.82958443e-02f, 1.97896436e-01f, 5.61881661e-02f, 2.38131940e-01f, -6.46520182e-02f, 2.64479488e-01f, 1.79138988e-01f,
  2.64192790e-01f, -4.10984814e-01f, 6.55768812e-02f, -2.44584724e-01f, -1.83860511e-01f, 3.62523109e-01f, -3.72007638e-01f, -8.72122124e-02f, -7.92473480e-02f, -3.03527147e-01f,
  -3.91380526e-02f, -5.32453001e-01f, -2.98576236e-01f, -1.09311533e+00f, -5.66316366e-01f, 2.52204239e-01f, -1.82531223e-01f, -6.27128422e-01f, -4.11788583e-01f, -3.50519568e-01f,
  3.93186390e-01f, -4.95385468e-01f, 4.48988348e-01f, 1.47117108e-01f, -4.29986149e-01f, 3.98800939e-01f, 8.35791349e-01f, -5.51233411e-01f, -6.34002388e-02f, -2.66988128e-01f,
  -8.71095881e-02f, -2.29127690e-01f, -7.27602184e-01f, 9.67966467e-02f, 1.89577609e-01f, 2.72912264e-01f, -5.42058349e-01f, -3.41763556e-01f, -7.68200904e-02f, -2.31876016e-01f,
  1.04045317e-01f, -3.86204034e-01f, -8.16115856e-01f, -2.28714988e-01f, -2.57030219e-01f, -2.82187700e-01f, -1.11937475e+00f, -1.12234637e-01f, 5.99671960e-01f, -6.45719826e-01f,
  -6.07875526e-01f, -6.78788602e-01f, -5.47877610e-01f, 7.65004158e-01f, 4.46185857e-01f, -3.45919102e-01f, 1.71537384e-01f, 1.85032442e-01f, 8.94916430e-03f, 1.77503731e-02f,
  -1.89038202e-01f, -6.62573949e-02f, -2.52017379e-01f, -1.50136501e-01f, -3.74133140e-01f, -2.13639647e-01f, -2.79462785e-01f, 1.53662115e-01f, 5.56052662e-02f, -4.50768292e-01f,
  -1.03970778e+00f, -1.69624165e-01f, 8.10578465e-02f, -1.55728072e-01f, -2.20095739e-01f, 6.97108328e-01f, 1.92157388e-01f, 2.51979262e-01f, -1.33685783e-01f, 4.60061103e-01f,
  1.71920359e-01f, 5.47559466e-03f, 3.36892843e-01f, -2.00873718e-01f, 4.30710733e-01f, -3.58714581e-01f, -7.78503656e-01f, -1.21991206e-02f, -3.22902262e-01f, -3.09019417e-01f,
  -7.39664018e-01f, -4.86473292e-01f, -1.89742520e-01f, -3.98922712e-01f, -1.96653813e-01f, 1.13371767e-01f, 5.00907153e-02f, 1.48337290e-01f, 7.27040350e-01f, 2.45855659e-01f,
  -3.49207610e-01f, -9.32327062e-02f, -2.71535575e-01f, -7.40024269e-01f, -6.17725253e-01f, 1.67323709e-01f, -3.12842637e-01f, -2.11212575e-01f, -1.48547441e-01f, -3.79371852e-01f,
  -2.25633457e-01f, -4.68324631e-01f, 1.09670445e-01f, -1.64770428e-02f, -3.49630088e-01f, 6.41137287e-02f, 8.26887265e-02f, 4.53104049e-01f, -7.09774420e-02f, 2.34362915e-01f,
  1.43336564e-01f, 7.09891543e-02f, 5.47982380e-02f, 1.01783030e-01f, 7.79277757e-02f, 2.08801758e-02f, -5.59448749e-02f, -3.31158280e-01f, 1.82865262e-01f, -1.00583799e-01f,
  3.20697367e-01f, 1.27847269e-01f, -1.25149891e-01f, 1.11094281e-01f, 2.61125565e-01f, -1.39070794e-01f, 3.90772253e-01f, 2.76219249e-01f, 1.43810600e-01f, -6.64428890e-01f,
  -1.12694781e-02f, 9.09401894e-01f, 3.10792685e-01f, -4.35111493e-01f, 2.10885733e-01f, -5.62626943e-02f, 5.24484932e-01f, -8.79178755e-03f, -6.47852600e-01f, 2.71964818e-01f,
  -5.80390215e-01f, -3.30349244e-02f, 3.17710601e-02f, -6.80240169e-02f, -4.53390807e-01f, -1.57603264e-01f, -6.20845482e-02f, -6.22205973e-01f, 2.79560596e-01f, -1.78247198e-01f,
  4.87826243e-02f, -1.72793910e-01f, -6.54233694e-01f, -7.44376332e-02f, -8.79338235e-02f, -5.35918951e-01f, 5.06692342e-02f, -4.48631078e-01f, -5.59527338e-01f, -5.41812599e-01f,
  1.38051674e-01f, 9.75646138e-01f, -4.24585938e-01f, -2.96359152e-01f, 4.35431987e-01f, -7.18899190e-01f, -1.43559158e-01f, 2.93177813e-02f, 6.64057024e-03f, 5.29865503e-01f,
  4.03228283e-01f, -3.93239968e-02f, -2.90158004e-01f, -8.34970534e-01f, -2.68607169e-01f, 2.16736253e-02f, 1.63562730e-01f, -8.93693864e-02f, 2.53863931e-01f, 7.33572803e-03f,
  -2.36755162e-01f, 1.15912229e-01f, -8.24525282e-02f, 3.02907437e-01f, -1.43396944e-01f, -1.81953996e-01f, -7.47587085e-01f, -2.41941780e-01f, -6.74208999e-01f, 3.36084723e-01f,
  -7.95761287e-01f, 3.89578938e-01f, 1.12246908e-01f, 1.07315592e-01f, 2.08858997e-01f, 4.61493671e-01f, -7.39563525e-01f, 2.84201562e-01f, -1.32433519e-01f, -1.87440798e-01f,
  1.60054862e-01f, -4.22627062e-01f, -9.95579839e-01f, -2.76368409e-01f, -2.63134688e-02f, -1.16072154e+00f, 8.69100243e-02f, -2.72161812e-01f, -1.29299581e-01f, 2.63227940e-01f,
  2.25758389e-01f, -4.98665124e-01f, -5.54508209e-01f, -1.52171090e-01f, 1.71699047e-01f, -7.24738061e-01f, 3.57254624e-01f, -2.60584861e-01f, -9.21041444e-02f, -6.08036518e-01f,
  -7.17851520e-01f, 5.48528850e-01f, -4.92621362e-01f, -6.38472199e-01f, 5.93708754e-01f, 6.50688037e-02f, 4.10092711e-01f, 5.01982391e-01f, -2.64068637e-02f, 3.91945451e-01f,
  -6.94754481e-01f, -5.53304665e-02f, -2.50409573e-01f, -1.45800248e-01f, -2.92200357e-01f, -3.54103655e-01f, -6.26111865e-01f, -5.01404107e-01f, -2.00305313e-01f, -3.44857097e-01f,
  -1.33645043e-01f, -2.49616541e-02f, -1.25122875e-01f, -1.75349846e-01f, -1.48772135e-01f, 3.62502396e-01f, -2.70980060e-01f, -2.59011418e-01f, 2.37540886e-01f, -2.37353683e-01f,
  3.12271625e-01f, -6.06704116e-01f, -1.29594818e-01f, -1.35262266e-01f, -2.82958895e-01f, -6.73981607e-01f, 1.77592121e-03f, -3.64703834e-01f, 2.57997274e-01f, -1.91449523e-01f,
  -3.30793142e-01f, -2.34817490e-01f, -1.83355659e-01f, -3.67732495e-01f, 2.29100034e-01f, 1.90839209e-02f, 5.23173571e-01f, -4.12638396e-01f, 6.23793423e-01f, 2.73822825e-02f,
  1.01614118e-01f, -6.95386946e-01f, -8.40977654e-02f, -1.15169011e-01f, -4.42173749e-01f, 1.56169057e-01f, 2.78591830e-02f, 3.32940221e-01f, 2.33533651e-01f, -4.32975113e-01f,
  -1.46612272e-01f, -3.86127740e-01f, -3.75121623e-01f, -5.35715580e-01f, 5.19743562e-01f, 1.87375739e-01f, -1.81865752e-01f, -2.33029053e-01f, -6.92330956e-01f, 3.45663056e-02f,
  -4.20987248e-01f, -5.44959195e-02f, -2.03515649e-01f, -1.80325866e-01f, 4.59067047e-01f, -2.64918953e-01f, -3.92661959e-01f, 3.42001289e-01f, -4.54128414e-01f, 4.37964290e-01f,
  6.64520040e-02f, -3.47591996e-01f, 6.69256523e-02f, -5.60582541e-02f, -9.32651982e-02f, 1.86657816e-01f, -1.56275705e-01f, 5.43441251e-02f, 2.91628152e-01f, 3.06040525e-01f,
  1.77103996e-01f, -2.36463457e-01f, 2.57187158e-01f, 8.75870436e-02f, 2.94460922e-01f, -4.72155988e-01f, 2.45921686e-01f, 2.82481551e-01f, -4.51423734e-01f, 2.43715748e-01f,
  7.87409842e-01f, -4.87189621e-01f, -4.64966655e-01f, -2.84581840e-01f, -6.98359609e-01f, -3.32519352e-01f, -3.32871050e-01f, 2.11263552e-01f, -5.03391445e-01f, -6.57110393e-01f,
  -3.07490001e-03f, 4.97096986e-01f, 2.11537659e-01f, -3.38983864e-01f, -4.14045602e-01f, -4.23897266e-01f, 2.95277596e-01f, 1.29802093e-01f, 4.48336035e-01f, 2.55489677e-01f,
  1.36765778e-01f, -3.28698397e-01f, -8.10852423e-02f, -4.62454617e-01f, -5.20522475e-01f, -3.53627741e-01f, 3.56902443e-02f, -4.92639452e-01f, -2.96449929e-01f, 3.53444099e-01f,
  5.80905497e-01f, -1.51962891e-01f, -5.28041959e-01f, -7.38960385e-01f, -4.05770004e-01f, -2.97180772e-01f, 7.30302453e-01f, 1.24954745e-01f, -5.26740432e-01f, -3.68310302e-01f,
  9.63039845e-02f, 5.61741114e-01f, 2.61029840e-01f, -5.93006492e-01f, -1.74155638e-01f, -3.84195805e-01f, -1.23018846e-01f, -1.61506124e-02f, -4.42486316e-01f, -1.74553946e-01f,
  -8.00492167e-02f, -3.04717049e-02f, -2.88408369e-01f, -3.87693971e-01f, -2.40919948e-01f, 2.50691980e-01f, -2.86654949e-01f, -9.46558267e-02f, -3.67654264e-01f, -5.70205092e-01f,
  6.00658655e-01f, -4.90949482e-01f, 5.30591428e-01f, -6.54764101e-02f, -3.35163355e-01f, 4.84018773e-01f, -1.02152437e-01f, 1.51643902e-01f, -4.32363063e-01f, -1.09295204e-01f,
  -4.62286025e-01f, 1.54274091e-01f, 3.92284244e-01f, 1.65395990e-01f, -4.71967943e-02f, -1.11218370e-01f, -3.75996768e-01f, 9.38798428e-01f, -1.37509974e-02f, -6.56895995e-01f,
  -7.14472294e-01f, -1.92211252e-02f, -1.46348238e-01f, -3.51332016e-02f, -3.53731453e-01f, 1.40459627e-01f, 4.32830125e-01f, 2.83731729e-01f, 9.46747735e-02f, -3.36212397e-01f,
  5.36233902e-01f, -7.58540869e-01f, 3.18939805e-01f, 2.04158900e-03f, 4.26299006e-01f, 1.34689838e-01f, 1.36167720e-01f, -4.06563342e-01f, -1.47102639e-01f, 6.34352863e-02f,
  -5.88015437e-01f, 4.52401862e-02f, -8.85364592e-01f, 1.33260444e-01f, -3.14130664e-01f, -9.10362780e-01f, -4.50539619e-01f, -7.18510270e-01f, -7.39606082e-01f, 2.79031277e-01f,
  1.63217671e-02f, 1.96462706e-01f, -1.16080917e-01f, -6.06856085e-02f, 2.48549972e-03f, 3.10250986e-02f, 2.16374341e-02f, 3.22020650e-01f, 3.20384413e-01f, 4.80003625e-01f,
  3.99719417e-01f, 4.62312717e-03f, -4.52402234e-01f, 2.98659921e-01f, -6.54383153e-02f, -3.55687588e-01f, -5.84000528e-01f, -2.48044893e-01f, 7.28634059e-01f, -5.76984107e-01f,
  -5.64658225e-01f, -3.86379004e-01f, -6.70310020e-01f, -4.93759096e-01f, -4.78968590e-01f, -5.50054967e-01f, 4.12095636e-01f, -1.63123578e-01f, -1.82684466e-01f, -1.85725819e-02f,
  -4.74905312e-01f, 3.75214726e-01f, -1.49477124e-01f, -5.08427083e-01f, 7.01528072e-01f, -5.23588359e-01f, 3.48169059e-02f, 5.05079091e-01f, -1.63580403e-01f, -2.29919553e-01f,
  4.46300596e-01f, -5.12200356e-01f, -3.64973098e-01f, 1.35636121e-01f, -5.53517491e-02f, 4.38954353e-01f, -5.20922422e-01f, -1.46844476e-01f, -3.34373027e-01f, -1.32810324e-01f,
  -4.67188686e-01f, 5.73401272e-01f, -1.50603801e-01f, 1.93372414e-01f, -3.90622050e-01f, -1.01018175e-01f, 2.76302285e-02f, -6.07926190e-01f, -3.21576416e-01f, -1.66701481e-01f,
  3.02689910e-01f, 3.46774817e-01f, -5.28816879e-01f, 5.49094006e-02f, 4.72827144e-02f, 2.04909574e-02f, 1.38111413e-01f, 6.88832700e-02f, 2.10345551e-01f, 1.07243806e-01f,
  -2.95914132e-02f, 2.63098121e-01f, 5.34152448e-01f, 5.07832728e-02f, 2.42548928e-01f, 2.45286494e-01f, -5.61931074e-01f, 1.63108394e-01f, 2.27573395e-01f, -3.42129953e-02f,
  -4.67377990e-01f, 3.78087580e-01f, -3.82026434e-01f, 1.60809591e-01f, -1.54967373e-02f, -6.83186352e-01f, -3.73421520e-01f, 2.79357433e-01f, -3.20854843e-01f, 2.40578964e-01f,
  -5.14078081e-01f, 4.30426449e-01f, -2.62754232e-01f, -5.96736431e-01f, -3.81402373e-01f, -7.80328691e-01f, -1.89209178e-01f, -4.99010295e-01f, 3.99841927e-02f, -5.81857204e-01f,
  5.26958287e-01f, -4.21568930e-01f, -9.94044691e-02f, -5.11165336e-03f, -1.25625074e-01f, 5.31316757e-01f, 4.92660135e-01f, 8.99140239e-02f, -7.10243940e-01f, -2.39543721e-01f,
  -4.95635509e-01f, -3.89950901e-01f, 4.89985555e-01f, -1.30827233e-01f, -6.33279264e-01f, -1.99484423e-01f, 5.68469584e-01f, -5.52296162e-01f, -2.03267962e-01f, 3.25885952e-01f,
  6.61736310e-01f, 6.09050274e-01f, -1.09151982e-01f, 3.74407381e-01f, -5.61388969e-01f, -2.12268338e-01f, -4.55647528e-01f, -2.88397521e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.88886964e-01f, 1.16381533e-01f, 1.81864023e-01f, 9.97835919e-02f, -3.56814228e-02f, 7.33335093e-02f, 1.19892947e-01f, 4.76844832e-02f, 7.83380419e-02f, -2.92665069e-03f,
  -8.54502320e-02f, 1.75222405e-04f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    