/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.31101489e-01f, -2.73979336e-01f, 2.91146129e-01f, -2.01331332e-01f, 2.21408814e-01f, 4.59580094e-01f, 5.46103954e-01f, 1.55084103e-01f, -8.28727186e-02f, -2.15240754e-02f,
  -3.53689678e-02f, -4.40307818e-02f, -1.58304349e-01f, 5.86001165e-02f, 1.62671044e-01f, 2.48320028e-01f, 1.00703344e-01f, 1.96997657e-01f, 3.28526556e-01f, 2.51201034e-01f,
  -3.21153365e-03f, -4.62123007e-02f, -1.58635244e-01f, -1.31265000e-01f, -3.37101579e-01f, -2.42776684e-02f, -2.74030864e-02f, -1.47747517e-01f, 9.93302315e-02f, -1.96955979e-01f,
  -2.69776046e-01f, -2.18313888e-01f, 1.54096678e-01f, -1.31821454e-01f, -9.17089358e-02f, -6.06098026e-02f, -1.05967410e-02f, -1.84307426e-01f, -2.91621741e-02f, -6.40533566e-02f,
  -6.64664507e-02f, -3.74335833e-02f, -1.59300923e-01f, -8.43931586e-02f, -9.25828964e-02f, -1.78931765e-02f, -7.82898813e-02f, -1.31509602e-01f, 2.14279741e-02f, -2.70194151e-02f,
  -7.87985027e-02f, 3.24215293e-02f, 3.40679400e-02f, 7.47542083e-02f, 2.87300963e-02f, 6.50941506e-02f, 5.32355830e-02f, -6.85287714e-02f, 7.13822171e-02f, -1.69802457e-01f,
  -1.08593013e-02f, 1.66125745e-01f, 1.14678338e-01f, -2.72089313e-03f, 8.42105746e-02f, 1.21961713e-01f, -1.96141955e-02f, 7.55093917e-02f, 8.79282430e-02f, 2.47729216e-02f,
  9.52514336e-02f, 1.09380826e-01f, 6.99032173e-02f, 2.03322656e-02f, 2.44744923e-02f, 1.45275235e-01f, 1.47830755e-01f, 7.89286792e-02f, 9.14868191e-02f, 7.18617812e-02f,
  1.45830870e-01f, 1.48021236e-01f, 7.09749460e-02f, 8.82330462e-02f, 1.05112731e-01f, 1.04969531e-01f, 1.84543449e-02f, 1.35688633e-01f, -1.58022158e-02f, 5.48165552e-02f,
  -2.88399667e-01f, 2.61235416e-01f, -1.33061975e-01f, -1.52012380e-02f, -3.94919589e-02f, -6.75606802e-02f, -3.00056785e-02f, 4.78797518e-02f, -3.57323363e-02f, -7.01264665e-02f,
  4.63028215e-02f, 5.35533251e-03f, -9.49202552e-02f, 1.07071521e-02f, 4.83510680e-02f, -1.82575751e-02f, -7.70120248e-02f, 7.04488307e-02f, 8.48111063e-02f, -8.52214321e-02f,
  -3.72989476e-03f, 1.58829197e-01f, 8.78049880e-02f, 8.91245380e-02f, -4.86728363e-02f, 1.24770939e-01f, 5.66087896e-03f, 1.16699055e-01f, 2.81871915e-01f, -3.42063718e-02f,
  2.37215251e-01f, 1.03777284e-02f, 4.54250425e-01f, 3.35212648e-01f, 7.59553462e-02f, -5.35603762e-02f, -1.15207613e-01f, -4.57104556e-02f, 1.32754102e-01f, 4.46535386e-02f,
  -2.63228297e-01f, 1.48238400e-02f, -1.05872072e-01f, -1.37089536e-01f, -2.21662551e-01f, 1.55441120e-01f, 3.12810928e-01f, 1.90540954e-01f, 9.15064383e-03f, -7.06964657e-02f,
  1.61011536e-02f, 7.36944079e-02f, 7.27442056e-02f, 7.53781870e-02f, 3.46748322e-01f, 7.28982240e-02f, 2.27408245e-01f, 1.43165186e-01f, 1.68077163e-02f, 5.39064705e-01f,
  2.00341806e-01f, 1.83513343e-01f, -9.18039829e-02f, -1.00013360e-01f, 5.42974286e-03f, -2.93788295e-02f, -4.52293567e-02f, 1.40947104e-01f, 3.69588658e-03f, 6.68865070e-02f,
  9.05834958e-02f, 8.09653029e-02f, 3.05945389e-02f, 5.60234375e-02f, 7.09816888e-02f, 8.22604001e-02f, 7.80482367e-02f, 1.72237396e-01f, 1.31854221e-01f, 1.35478944e-01f,
  1.09713964e-01f, 6.33158982e-02f, 4.04512025e-02f, -2.47991253e-02f, -4.90018018e-02f, -1.55943502e-02f, -3.09807975e-02f, 7.73411021e-02f, -5.89131601e-02f, 2.05396742e-01f,
  -1.34055272e-01f, -5.28367199e-02f, 1.72400307e-02f, -6.68736622e-02f, -8.42056647e-02f, 7.22601190e-02f, 3.29192216e-03f, -1.08275758e-02f, -7.27612227e-02f, -5.61794192e-02f,
  -4.31700721e-02f, -4.57246276e-03f, -7.71307871e-02f, 3.40656540e-03f, -8.79846513e-02f, 2.10542884e-02f, 1.73816327e-02f, -1.28539041e-01f, -6.35242164e-02f, -1.59188807e-02f,
  -5.92918620e-02f, -1.09968692e-01f, -4.30815220e-02f, -3.32562849e-02f, -1.14123099e-01f, -8.65878421e-04f, -3.34724877e-03f, -1.65365323e-01f, -7.42926002e-02f, 7.78501900e-03f,
  -2.19347015e-01f, -2.69663662e-01f, 1.16725795e-01f, 3.52985412e-02f, 2.87024248e-02f, 8.96196738e-02f, 9.39050540e-02f, 4.10742685e-02f, 1.22826196e-01f, 1.12563372e-01f,
  -5.41718751e-02f, -3.36186513e-02f, 7.78746381e-02f, 6.15661144e-02f, 2.19187308e-02f, -2.43135728e-02f, -1.03205048e-01f, 9.96451601e-02f, 9.40679107e-03f, 8.88509750e-02f,
  2.79176328e-02f, -2.21918859e-02f, -5.42064905e-02f, -1.90625116e-02f, 4.98455428e-02f, -1.15793593e-01f, 4.72575091e-02f, 9.12639219e-03f, -1.89114138e-01f, 3.52409924e-03f,
  1.45915166e-01f, 6.44213706e-02f, 3.21970046e-01f, 4.59629565e-01f, 4.29985017e-01f, 2.73067355e-01f, 2.74155378e-01f, -6.35463186e-03f, 2.17899933e-01f, 2.31803030e-01f,
  1.78047195e-01f, 1.69672698e-01f, 1.63178012e-01f, 3.37340459e-02f, 2.96738301e-03f, 1.15722589e-01f, 3.00304919e-01f, 1.76487744e-01f, 1.27419785e-01f, 3.70864570e-01f,
  3.13664973e-01f, 3.67000967e-01f, 2.49237970e-01f, 1.26894727e-01f, 2.19850987e-01f, 3.00568193e-01f, 2.32053548e-01f, 3.37460101e-01f, 1.44871548e-01f, 2.91150987e-01f,
  4.52439308e-01f, -1.36044305e-02f, 1.50344774e-01f, 5.85512258e-02f, 2.31978223e-01f, 8.03202242e-02f, 1.97062299e-01f, -2.10084114e-02f, 1.17273331e-01f, 8.78827199e-02f,
  1.02224089e-01f, 1.37293771e-01f, 1.37067661e-01f, 9.14785713e-02f, 1.66366175e-01f, 8.94530267e-02f, 9.41736177e-02f, -1.44429747e-02f, 5.21434285e-02f, 1.16112446e-02f,
  2.22429201e-01f, 1.45421177e-01f, -1.18622063e-02f, 6.22354224e-02f, 1.05380580e-01f, 1.70819476e-01f, 8.13600793e-02f, 1.17601559e-01f, -7.11427478e-04f, 1.02220595e-01f,
  -6.82931626e-03f, -6.00814857e-02f, -9.71036628e-02f, -1.56531766e-01f, -6.88747764e-02f, -8.73955414e-02f, -6.49863854e-02f, -5.97022101e-02f, -9.97835025e-02f, -1.45668089e-01f,
  -3.81212421e-02f, -7.05181062e-02f, -8.26211572e-02f, -5.44117428e-02f, -1.88988205e-02f, -1.07820876e-01f, -1.01189427e-01f, -3.71561162e-02f, -1.43454000e-01f, -1.19982280e-01f,
  -1.25969350e-01f, -1.31405845e-01f, 1.54317180e-02f, -8.27639699e-02f, -1.16498642e-01f, -6.56271949e-02f, -2.41114143e-02f, -1.52598515e-01f, -1.65001035e-01f, -1.05425112e-01f,
  1.61622345e-01f, 1.04519419e-01f, 1.31277502e-01f, -7.04836398e-02f, 1.01384692e-01f, 6.38294891e-02f, 1.14123195e-01f, -2.19256408e-03f, 1.06623538e-01f, 1.49016574e-01f,
  4.66966033e-02f, 1.22465633e-01f, 1.34121791e-01f, 9.73267406e-02f, 2.47972727e-01f, 5.10360487e-02f, 9.87623334e-02f, 1.37709975e-01f, 4.49798070e-03f, 1.08806379e-01f,
  -2.07562521e-02f, 7.13642910e-02f, 7.10325968e-03f, -1.27075911e-02f, 8.43007267e-02f, 8.72608498e-02f, 5.33878617e-02f, -6.11223951e-02f, 1.02787293e-01f, 4.36085090e-02f,
  5.42020977e-01f, 7.85669148e-01f, -1.74158812e-01f, -3.96825634e-02f, -1.76095635e-01f, -2.56198309e-02f, 2.28237525e-01f, 6.18916079e-02f, -1.10436291e-01f, 2.36613657e-02f,
  -1.83486268e-01f, -3.59900683e-01f, -2.43309438e-01f, -3.35398614e-01f, -7.51673952e-02f, 3.48684229e-02f, -8.18367302e-03f, -2.66833514e-01f, -3.88393044e-01f, -3.16203892e-01f,
  -1.33406609e-01f, -1.36582687e-01f, -5.45622744e-02f, -1.97595432e-01f, 6.21590801e-02f, -2.20967367e-01f, -7.97406211e-02f, -1.29378811e-02f, 3.58190835e-02f, 1.38615370e-01f,
  -3.34703892e-01f, 3.41147959e-01f, -3.42006654e-01f, -9.46808085e-02f, -6.61611184e-02f, -1.53935596e-01f, -6.16602115e-02f, -9.61797610e-02f, -1.78291481e-02f, -3.70643288e-02f,
  -1.70627564e-01f, -1.88673232e-02f, -1.00312106e-01f, -8.05579424e-02f, -1.88307688e-02f, -1.14546485e-01f, -4.23185714e-03f, -2.02961583e-02f, -7.74111003e-02f, -1.49214908e-01f,
  -1.12512380e-01f, -1.02681546e-02f, 1.26548661e-02f, -1.07052341e-01f, -6.21277168e-02f, -1.73951551e-01f, -1.24293335e-01f, -2.56513897e-03f, -2.38117259e-02f, 9.68493372e-02f,
  1.52670056e-01f, 1.24110967e-01f, 7.90289268e-02f, 9.48112085e-02f, 2.56294068e-02f, 8.95641670e-02f, 1.44895032e-01f, -4.39456291e-02f, 4.85564931e-04f, 4.85215709e-02f,
  2.23808680e-02f, -1.58609077e-02f, 7.48233795e-02f, 5.65731972e-02f, -8.81421939e-02f, 3.80001366e-02f, 3.23881544e-02f, 1.35529814e-02f, -5.67835523e-03f, 5.18142655e-02f,
  1.60647631e-02f, -1.69506352e-02f, 2.43337285e-02f, 6.05344139e-02f, 7.06265420e-02f, 3.02621666e-02f, 2.17797309e-02f, 1.05179539e-02f, 5.47033921e-02f, 1.96474250e-02f,
  -3.18202674e-01f, -1.40406847e-01f, -1.21549726e-01f, -8.82475749e-02f, -1.84700862e-01f, -5.19970655e-02f, -2.12806091e-01f, -1.45770833e-01f, -1.30020335e-01f, -1.41241193e-01f,
  -1.52538195e-01f, -3.30645405e-02f, -1.71078444e-02f, -1.74334839e-01f, -2.35462338e-01f, -1.91069052e-01f, -5.20022698e-02f, -1.69400424e-01f, -1.15163393e-01f, -1.47732824e-01f,
  -7.96627775e-02f, -1.29204631e-01f, -2.58090764e-01f, -1.06669120e-01f, -5.54319099e-02f, -2.37068161e-01f, -2.06786603e-01f, -2.49581084e-01f, -2.63742626e-01f, -1.76263765e-01f,
  3.10084432e-01f, -2.47952603e-02f, -3.27729315e-01f, 1.00767277e-01f, -3.28753106e-02f, 3.49973217e-02f, 3.56837101e-02f, 7.68318400e-02f, 4.85036224e-02f, 2.06439365e-02f,
  -1.33125320e-01f, -3.08983654e-01f, -4.14708406e-01f, -3.15091431e-01f, -3.41840506e-01f, -2.95879006e-01f, -3.19536120e-01f, -3.97504359e-01f, -3.88915837e-02f, 2.46046811e-01f,
  1.40427858e-01f, 1.61257237e-01f, 1.75233871e-01f, 6.10090084e-02f, 1.16524458e-01f, -1.25021487e-01f, -1.53028399e-01f, 1.26189282e-02f, -2.76301671e-02f, 9.77508053e-02f,
  1.80921592e-02f, 4.06646550e-01f, -2.42566280e-02f, 6.20341524e-02f, 8.59987810e-02f, 1.03865847e-01f, 8.32644328e-02f, 8.16731006e-02f, 8.94863065e-03f, 1.56204373e-01f,
  1.18282728e-01f, 1.02377072e-01f, -2.94717588e-02f, 6.26256391e-02f, 2.00986251e-01f, 1.16993092e-01f, 7.97006413e-02f, 6.32819012e-02f, -4.89719808e-02f, 4.38485555e-02f,
  1.38706803e-01f, 1.30526289e-01f, 6.20164610e-02f, 2.07215995e-02f, 5.23958020e-02f, -3.93542871e-02f, 1.07278675e-02f, 2.26747066e-01f, 9.86642987e-02f, 2.17294097e-01f,
  8.98485407e-02f, -3.59282009e-02f, -2.09773276e-02f, -6.63113268e-03f, -3.40659008e-03f, -7.57655129e-02f, -2.32727907e-04f, 5.65980235e-03f, -3.67802046e-02f, -3.03838169e-03f,
  7.38660572e-03f, -3.98103893e-02f, -3.19623761e-02f, -1.45898620e-03f, -3.85429598e-02f, -2.64066327e-02f, 1.02877691e-02f, 1.29649101e-03f, 1.96091551e-02f, 8.24220702e-02f,
  5.20576760e-02f, 3.21911951e-03f, -3.07752863e-02f, -3.85254286e-02f, -6.73254952e-02f, -2.35603154e-02f, 7.37811951e-03f, 5.68060391e-02f, -3.04360967e-02f, 2.43899412e-03f,
  -5.61287589e-02f, -3.04748416e-01f, 7.07570687e-02f, -3.20455525e-03f, -1.43401208e-03f, -3.42253856e-02f, -8.80637690e-02f, 7.35744759e-02f, 5.98145351e-02f, 3.37558538e-02f,
  -3.94122355e-04f, 1.21453637e-02f, -1.71701203e-03f, 1.09897546e-01f, 1.33278474e-01f, 3.64897810e-02f, 9.67304260e-02f, -9.10262316e-02f, -5.77503303e-03f, 1.11163743e-01f,
  -8.71375948e-02f, 1.59462783e-02f, -1.32245883e-01f, -1.30175650e-01f, 6.03061914e-02f, -2.18675002e-01f, -7.58517459e-02f, 2.96081286e-02f, -1.99575692e-01f, -8.36420208e-02f,
  -7.51792908e-01f, -8.78036171e-02f, -7.15254769e-02f, -4.40825194e-01f, -1.03195772e-01f, -2.04885036e-01f, -2.80836433e-01f, -2.78891861e-01f, -1.43197700e-01f, -2.02123523e-01f,
  2.12693866e-02f, 3.46095525e-02f, -6.25467598e-02f, 2.71508396e-01f, 1.16542056e-01f, 6.39164075e-02f, 1.32436588e-01f, 1.74272787e-02f, 8.99894312e-02f, 8.20622891e-02f,
  1.57583296e-01f, -1.74700648e-01f, -1.33967295e-01f, 1.30429178e-01f, -1.34030029e-01f, 6.51484653e-02f, -7.91110471e-02f, -1.85935363e-01f, 1.75477728e-01f, 6.38866723e-02f,
  -5.29583660e-04f, -1.10291451e-01f, 2.24697575e-01f, 1.73230276e-01f, 2.07092911e-01f, 6.73703402e-02f, 7.52711967e-02f, 4.81817089e-02f, 4.10549622e-03f, 4.70032170e-02f,
  5.89483902e-02f, 1.00803956e-01f, 5.69001175e-02f, 1.38886839e-01f, 9.91071016e-02f, 2.68936600e-03f, 1.85696140e-01f, 5.13828583e-02f, 7.46222138e-02f, 7.50907958e-02f,
  2.44996026e-01f, -2.61922609e-02f, -1.64562002e-01f, 1.30074546e-01f, 2.72495113e-02f, 1.78788081e-01f, 3.63234915e-02f, -1.26440991e-02f, 1.60585016e-01f, 3.95210050e-02f,
  -1.62848122e-02f, -1.86337586e-02f, -2.29217093e-02f, -4.02606092e-02f, -3.02926265e-02f, -5.34448884e-02f, -5.60200028e-02f, -5.79774305e-02f, -5.90666309e-02f, -4.68818173e-02f,
  -1.99161023e-02f, -1.24593955e-02f, -3.24907005e-02f, -6.68065920e-02f, -2.16026418e-02f, -4.93506789e-02f, -1.07019089e-01f, 3.07922941e-02f, 4.37515974e-02f, -1.76774375e-02f,
  -9.50092673e-02f, -1.13135375e-01f, -5.42761162e-02f, -4.63823862e-02f, -1.88210849e-02f, 1.35251656e-02f, -3.50975711e-03f, 2.82173865e-02f, -2.87494566e-02f, -8.85622576e-02f,
  -2.24696472e-01f, 3.50871295e-01f, -1.19190827e-01f, 5.72371297e-03f, 2.62629073e-02f, 7.70037472e-02f, 2.89522037e-02f, 9.25721005e-02f, 1.03811519e-02f, 2.40941590e-04f,
  5.12323342e-02f, -9.86965001e-03f, 4.18858193e-02f, 5.44826724e-02f, -2.37061270e-03f, -4.89273779e-02f, 1.40585201e-02f, -5.78480698e-02f, -1.43316863e-02f, 2.48093437e-02f,
  4.20089439e-03f, -1.63066819e-01f, -3.21376681e-01f, -1.55652910e-01f, -6.73191845e-02f, -1.57020658e-01f, -7.03284293e-02f, -1.61106557e-01f, -1.40932739e-01f, -2.34992325e-01f,
  -1.94624975e-01f, 4.28927779e-01f, 4.72948849e-01f, -2.02893049e-01f, -2.23834664e-01f, 1.13284655e-01f, 1.90723181e-01f, 1.85910508e-01f, 6.21941909e-02f, 6.39799610e-02f,
  -3.67748626e-02f, -8.32864568e-02f, -3.49256024e-02f, 2.23359838e-03f, 1.69864103e-01f, 1.63347527e-01f, -2.68142037e-02f, -5.34080714e-02f, -5.64302914e-02f, -2.60648400e-01f,
  -2.68287688e-01f, -1.89737573e-01f, -5.88964447e-02f, 1.00385122e-01f, -2.02212706e-01f, -5.44243492e-02f, 3.00175339e-01f, 4.61485498e-02f, 1.49654955e-01f, -2.83845276e-01f,
  2.39787027e-02f, 2.02583730e-01f, -1.06489941e-01f, -9.10650715e-02f, -8.23328122e-02f, 3.94716114e-02f, -6.15639426e-02f, 7.98187181e-02f, -8.01636651e-03f, 3.79592180e-02f,
  -1.58429354e-01f, -6.42259791e-02f, -1.30377650e-01f, -4.13295403e-02f, 6.45752251e-02f, 3.50546762e-02f, 3.43771977e-03f, 8.85692984e-03f, 5.90743423e-02f, 9.12965834e-02f,
  -2.48917207e-01f, -2.69122094e-01f, 3.31826955e-02f, 1.39467448e-01f, 3.98739204e-02f, -2.87245903e-02f, 2.01623794e-02f, 1.32637829e-01f, 8.41979533e-02f, 9.31398943e-02f,
  -5.18205725e-02f, 1.97856024e-01f, 7.98901021e-02f, 1.74814507e-01f, 9.05025303e-02f, 1.04229189e-01f, 2.96160895e-02f, 4.32977267e-02f, 3.41795236e-02f, 1.17011905e-01f,
  9.48811695e-02f, 5.98719902e-02f, 1.68770645e-02f, 3.94641235e-02f, 5.34477737e-03f, 4.61739786e-02f, 3.32648456e-02f, 6.98576346e-02f, 1.17241964e-01f, 8.90636444e-02f,
  9.35873613e-02f, 3.81691158e-02f, 6.61919862e-02f, 8.32859948e-02f, -2.43423949e-03f, 1.13409363e-01f, 1.01829274e-02f, 8.58957097e-02f, 3.49813066e-02f, -2.04769149e-02f,
  1.50408402e-01f, 1.44959733e-01f, -1.53880075e-01f, -5.60014732e-02f, -1.19237974e-01f, -8.41303840e-02f, -1.19452335e-01f, -1.48771983e-02f, -7.05254897e-02f, -2.55171284e-02f,
  2.24669613e-02f, -7.04908231e-03f, 9.19432640e-02f, -4.47344929e-02f, -1.24587014e-01f, -1.56662930e-02f, -1.47763699e-01f, -1.70702055e-01f, 4.01593857e-02f, -7.30881169e-02f,
  -4.85302769e-02f, -2.39922985e-01f, -1.69745058e-01f, 2.44491287e-02f, -2.99070999e-02f, -1.87091365e-01f, 6.32593110e-02f, -3.76627408e-02f, -6.89973608e-02f, 6.27543554e-02f,
  -8.08976889e-01f, 4.48284388e-01f, 2.29578212e-01f, -2.07716450e-01f, 9.10647213e-02f, 6.69659078e-02f, 2.45771214e-01f, -2.81792164e-01f, -2.67527938e-01f, 3.80331837e-02f,
  1.07404023e-01f, -1.56737834e-01f, -1.18427724e-01f, -2.07604870e-01f, -2.46311039e-01f, 2.04693854e-01f, 1.02990806e-01f, -1.37330070e-01f, -3.86001021e-01f, -2.75029540e-01f,
  -9.64012742e-02f, -1.68747917e-01f, -3.15351397e-01f, -1.60285488e-01f, 7.78973103e-02f, -8.94198939e-02f, 6.74705058e-02f, 1.14654176e-01f, 2.07642019e-01f, 1.39910787e-01f,
  1.00156970e-01f, -1.26197889e-01f, -2.42953718e-01f, -1.88776076e-01f, 2.73559745e-02f, -1.43429175e-01f, -1.15162522e-01f, -1.04722194e-01f, -9.38881189e-02f, -9.43502486e-02f,
  -3.56695317e-02f, -1.13120399e-01f, -9.73226037e-03f, -1.20479219e-01f, -7.56457970e-02f, -1.40603900e-01f, -1.87558562e-01f, -1.78961858e-01f, -9.96870846e-02f, -1.01528995e-01f,
  4.98447008e-02f, 1.31185353e-01f, 8.81424919e-03f, -9.31132138e-02f, -1.54035673e-01f, -7.27507025e-02f, -1.46160508e-02f, -4.41298150e-02f, -2.12741449e-01f, -1.76915333e-01f,
  -3.58023830e-02f, 1.10571869e-01f, 1.18985616e-01f, 1.12212725e-01f, 1.30555362e-01f, 1.14716381e-01f, 1.59042507e-01f, 7.84933195e-02f, 5.63413985e-02f, 5.20093963e-02f,
  9.61009264e-02f, 1.00908965e-01f, 4.39124405e-02f, 1.27666906e-01f, 1.19287044e-01f, 1.34469941e-01f, 1.33097261e-01f, 9.93923098e-02f, 2.03487799e-01f, 1.10184588e-01f,
  1.18473016e-01f, 6.42113760e-02f, 1.04324132e-01f, 8.13719034e-02f, 1.68244705e-01f, 1.40549242e-01f, 1.15919650e-01f, 6.16429448e-02f, 1.41780917e-02f, 8.94896835e-02f,
  -3.06529194e-01f, -1.18337370e-01f, -1.70474857e-01f, -2.06035927e-01f, -8.22350010e-02f, -2.03084886e-01f, -5.52180223e-02f, -1.45575896e-01f, -8.70851874e-02f, -2.21902415e-01f,
  -1.05792664e-01f, -2.10097373e-01f, -3.30065936e-02f, -8.56003389e-02f, -2.20511690e-01f, -1.19929165e-01f, -7.54490495e-02f, -5.29819280e-02f, -1.42975390e-01f, -1.42392099e-01f,
  -3.54869999e-02f, -2.07315117e-01f, -2.35183120e-01f, -2.05569848e-01f, -1.09305799e-01f, -2.18987092e-01f, -1.23084905e-02f, -1.52799770e-01f, -1.55982390e-01f, -2.75074571e-01f,
  8.79604220e-01f, 1.78870514e-01f, 2.89020300e-01f, 2.95742422e-01f, -2.79989123e-01f, -2.88755924e-01f, -1.13133572e-01f, 5.70775867e-02f, 8.07007626e-02f, 2.13271782e-01f,
  -1.55351669e-01f, -6.93209767e-02f, 6.84215352e-02f, 1.97137576e-02f, -9.47273895e-03f, 2.96967119e-01f, 1.41774565e-01f, 2.80019075e-01f, -7.35098347e-02f, -3.10418427e-01f,
  -3.04652065e-01f, 9.63865593e-02f, 2.84454137e-01f, -1.15173105e-02f, -1.16454855e-01f, -1.68379918e-01f, 8.20953175e-02f, -4.29956168e-02f, -6.64082542e-02f, 1.43133208e-01f,
  2.18882054e-01f, 1.98540837e-01f, 2.01009610e-03f, -4.39021401e-02f, 6.22531399e-03f, 1.39532879e-01f, -2.25113928e-02f, 6.79154173e-02f, 1.18417569e-01f, 7.88369551e-02f,
  -2.82371342e-02f, 1.41258165e-02f, -5.08184470e-02f, -1.01798624e-01f, 7.92830437e-02f, 5.49208559e-02f, 6.54506758e-02f, 1.35297909e-01f, 6.69229105e-02f, -2.87045315e-02f,
  -1.52432740e-01f, -1.13319881e-01f, 1.17528640e-01f, -2.67239027e-02f, -7.53542185e-02f, 2.83083450e-02f, -6.08213916e-02f, -8.24170038e-02f, -3.48788872e-03f, 1.55429214e-01f,
  2.09366232e-02f, -1.56254973e-02f, -1.01374514e-01f, -5.59422895e-02f, -4.51543331e-02f, -1.47167081e-03f, 5.40844798e-02f, -1.35272682e-01f, -4.44623940e-02f, 2.31491704e-03f,
  -4.62166257e-02f, 8.27972498e-03f, -3.56534906e-02f, 1.48561984e-01f, -6.62565511e-03f, 2.89876703e-02f, 4.72312681e-02f, 5.33341710e-03f, -3.39676253e-02f, 7.59312436e-02f,
  2.69323010e-02f, -7.95682485e-04f, 3.83399311e-03f, 5.53681105e-02f, -3.90073657e-02f, 1.76334884e-02f, 3.47103439e-02f, -9.06861201e-02f, -8.55272263e-02f, 1.02242241e-02f,
  2.79941022e-01f, -3.12391855e-02f, 2.14888617e-01f, 5.70218600e-02f, 2.31350604e-02f, 2.02037953e-02f, 6.83953837e-02f, 7.68242851e-02f, 7.47665167e-02f, 4.94883619e-02f,
  -1.07850820e-01f, 8.97583291e-02f, 1.32836357e-01f, -5.26767671e-02f, -7.12998137e-02f, -8.15996826e-02f, -1.04306012e-01f, 5.64947799e-02f, -5.89747773e-03f, -3.02441083e-02f,
  -7.18003660e-02f, 9.43796784e-02f, 1.64104238e-01f, 6.91288337e-02f, -1.07701525e-01f, 1.27318159e-01f, 3.35614495e-02f, -3.99571210e-02f, 1.43467680e-01f, 2.43721053e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.15010595e+00f, 7.15933383e-01f, -1.06535070e-01f, 1.91205621e-01f, -4.38992567e-02f, -1.92232981e-01f, -1.97641194e-01f, 4.58441786e-02f, 6.68928400e-02f, 2.74626195e-01f,
  4.57682431e-01f, 1.70686185e-01f, 1.54479027e-01f, 7.56190941e-02f, -1.59544796e-01f, -3.93874913e-01f, -3.96788031e-01f, -4.22724560e-02f, -1.87659964e-01f, -1.55256748e-01f,
  -1.23900406e-01f, 2.55523980e-01f, 3.70593756e-01f, 1.31951034e-01f, 3.07787396e-02f, -2.11578012e-01f, -4.77610268e-02f, 9.47268754e-02f, -1.09535873e-01f, -2.32848957e-01f,
  -3.82877648e-01f, 1.67443424e-01f, -9.62011665e-02f, 3.34770262e-01f, 3.23405653e-01f, 3.54469359e-01f, -3.99603089e-03f, 1.48323029e-01f, 1.17557913e-01f, -7.73825198e-02f,
  5.55530302e-02f, 1.31142095e-01f, 9.85007435e-02f, -5.11573702e-02f, -4.13724631e-02f, 1.00777760e-01f, 1.40773743e-01f, -2.19704419e-01f, -2.07308754e-01f, 2.85678008e-03f,
  2.08323300e-01f, -2.54975967e-02f, -1.58052966e-01f, -2.49269143e-01f, -7.95409530e-02f, -4.75458391e-02f, 1.23339750e-01f, -7.27888718e-02f, -1.36638001e-01f, -1.00244470e-01f,
  2.02034339e-02f, 1.04994342e-01f, 3.90545167e-02f, -1.32627815e-01f, 3.67950574e-02f, -2.86346208e-02f, -1.80846319e-01f, -1.39700979e-01f, -3.52304056e-02f, 1.87399372e-01f,
  -1.66844577e-01f, -2.78771788e-01f, -1.54906943e-01f, -1.67751372e-01f, 7.78239816e-02f, -4.26419601e-02f, 5.11896983e-03f, -9.60589126e-02f, 4.16314751e-02f, 1.06729716e-01f,
  -1.19000345e-01f, -8.26094076e-02f, 1.54044151e-01f, 6.00108737e-03f, -1.71203077e-01f, -3.91461700e-02f, -5.87408580e-02f, 4.94571850e-02f, 1.68438002e-01f, 1.51488885e-01f,
  -2.04911828e-01f, -1.93422824e-01f, -2.45375261e-01f, -1.50814489e-01f, 7.26513416e-02f, 2.13392049e-01f, -5.27730323e-02f, -1.69957846e-01f, 8.98471773e-02f, -2.00073764e-01f,
  6.55819923e-02f, 1.02686934e-01f, 8.39873403e-02f, 3.95285562e-02f, -7.75229037e-02f, -1.13108031e-01f, 1.28867671e-01f, 4.70961742e-02f, -4.90925722e-02f, 5.97723722e-02f,
  1.85836211e-01f, 9.41024423e-02f, 2.44513340e-02f, -6.12396486e-02f, -4.42440473e-02f, -7.89705142e-02f, 1.57860965e-02f, -1.03215769e-01f, -1.30412530e-03f, 1.93300709e-01f,
  1.05528533e+00f, -9.84755516e-01f, -7.56293297e-01f, -1.65167093e-01f, -1.30530596e-01f, 2.43229493e-01f, -1.36607677e-01f, 1.05960764e-01f, 1.72719479e-01f, -4.34916139e-01f,
  -2.96929091e-01f, 1.41573101e-01f, -5.65574765e-02f, -8.57680663e-02f, 8.26259851e-02f, -4.04038310e-01f, -4.55598801e-01f, 1.94620073e-01f, 8.95988941e-01f, 6.73096061e-01f,
  1.34983361e-01f, 8.22280124e-02f, 3.46132666e-01f, 1.06945783e-02f, -5.08222222e-01f, -9.72289369e-02f, -6.13288224e-01f, -4.21117246e-01f, -3.38973165e-01f, -7.54977524e-01f,
  -4.53084737e-01f, -1.74211394e-02f, 2.33855143e-01f, 1.00791641e-01f, -1.51814491e-01f, 5.83830997e-02f, 1.21358961e-01f, -3.98457423e-02f, 5.83217219e-02f, -7.22143278e-02f,
  -1.03375427e-01f, -3.69380191e-02f, -2.22019833e-02f, -7.22482353e-02f, 3.28265019e-02f, 1.31179899e-01f, 2.90777162e-02f, 7.70975128e-02f, -2.46782415e-02f, -1.42304957e-01f,
  -2.14754269e-01f, 6.31219596e-02f, 1.60990804e-01f, 6.78568855e-02f, 7.62731805e-02f, 2.14421108e-01f, -5.71381953e-03f, 9.45420712e-02f, 1.14280477e-01f, 5.15813120e-02f,
  2.79786736e-02f, -7.99299702e-02f, 1.62186593e-01f, 1.98288545e-01f, 2.09847763e-01f, 7.70699931e-04f, 4.97969389e-02f, 2.10186541e-02f, 2.20286250e-01f, 9.21391621e-02f,
  -6.32971227e-02f, -1.40450904e-02f, 4.24411222e-02f, -4.02839631e-02f, -1.50992721e-01f, -7.87696764e-02f, -6.22208454e-02f, -9.35123339e-02f, -3.87385525e-02f, -1.33787896e-02f,
  2.08020896e-01f, 3.54858600e-02f, -1.23467088e-01f, -7.41872787e-02f, -8.15192983e-02f, -1.32560153e-02f, 8.57601017e-02f, 5.42479455e-02f, -3.54290777e-03f, 4.17305082e-02f,
  -1.15094483e-01f, 2.62629569e-01f, -1.21142916e-01f, 1.32059216e-01f, -1.02775238e-01f, -9.73423198e-02f, -6.16909713e-02f, -4.92775720e-03f, -2.61178106e-01f, 6.12447970e-02f,
  4.25880961e-03f, 1.04302287e-01f, -1.31078452e-01f, 4.08026278e-02f, 3.12937111e-01f, 2.29672432e-01f, 5.22243157e-02f, 2.87785884e-02f, -7.47748315e-02f, -2.31006950e-01f,
  -1.91458419e-01f, 1.56833425e-01f, 2.39878729e-01f, 1.77334473e-01f, 1.35529861e-01f, 2.68055022e-01f, 4.39232364e-02f, 4.54149097e-02f, 2.49460310e-01f, 6.20126761e-02f,
  -5.82494438e-01f, -3.84959012e-01f, 1.67570717e-03f, 2.40200639e-01f, 7.24073648e-01f, -1.51460588e-01f, -1.16273618e+00f, -7.35253692e-01f, 3.24196965e-01f, -3.35427940e-01f,
  3.24472785e-01f, 7.03932464e-01f, -1.69172123e-01f, -4.97607082e-01f, -1.27689719e+00f, -1.09019077e+00f, -8.38072419e-01f, -7.81654239e-01f, -4.33142275e-01f, -8.88398439e-02f,
  2.18200326e-01f, -6.97863773e-02f, -3.14081103e-01f, -8.73599946e-02f, 5.69185674e-01f, 4.98858780e-01f, 1.96083546e-01f, 2.86003113e-01f, -1.15169454e-02f, 1.31073102e-01f,
  1.53325111e-01f, -1.32454149e-02f, 5.08916900e-02f, 2.26851538e-01f, 3.99983019e-01f, -2.97713190e-01f, -2.38107413e-01f, -8.06202646e-03f, 1.52149424e-01f, 7.01337773e-03f,
  4.61414367e-01f, 9.03669447e-02f, 1.31535336e-01f, 6.40242398e-02f, 7.87768215e-02f, -2.41182789e-01f, -3.21182698e-01f, -6.09715819e-01f, -6.32440865e-01f, -2.82958329e-01f,
  4.32332963e-01f, 8.40281323e-02f, -1.57912597e-01f, -4.30069804e-01f, -3.89384925e-01f, -4.59274128e-02f, 1.26711547e-01f, -4.29655705e-03f, -6.82999432e-01f, -4.40067440e-01f,
  8.73619765e-02f, -2.39778366e-02f, 1.40461728e-01f, 6.85665831e-02f, -2.07355879e-02f, 3.44009429e-01f, 1.11698620e-02f, 3.55087444e-02f, 9.99060571e-02f, -8.16078205e-03f,
  -1.86738819e-01f, -2.64179707e-02f, -6.28187880e-02f, -1.76155135e-01f, -8.24281946e-02f, 4.42418680e-02f, -6.73276037e-02f, -3.50626498e-01f, -4.33838442e-02f, -1.23647802e-01f,
  -9.46370959e-02f, 1.03277743e-01f, 2.38691881e-01f, -2.30779853e-02f, 1.76882576e-02f, -2.09245428e-01f, 1.54169604e-01f, 1.47930644e-02f, 7.68207833e-02f, -8.73687491e-02f,
  4.94851798e-01f, -7.87741393e-02f, -2.32206523e-01f, -1.23133034e-01f, 2.26106234e-02f, 2.50633389e-01f, 1.76088810e-01f, -1.01178475e-01f, 1.31488755e-01f, -6.07212260e-02f,
  -6.87668547e-02f, -2.84634382e-01f, 1.24992482e-01f, 2.45613992e-01f, 1.15445599e-01f, 1.00902177e-01f, -2.35089928e-01f, -8.17375164e-03f, -3.41825128e-01f, 3.84364665e-01f,
  -1.38233826e-01f, -6.52947068e-01f, -6.04996622e-01f, -4.16172206e-01f, -1.10386491e-01f, -3.90872449e-01f, -2.71330208e-01f, -2.47176319e-01f, -9.41406727e-01f, -9.70323741e-01f,
  -4.95023310e-01f, 7.94308782e-01f, -7.23119140e-01f, -4.41070884e-01f, -2.63149619e-01f, -3.10450613e-01f, 9.05687436e-02f, 2.43460238e-01f, 4.72198069e-01f, 6.42744839e-01f,
  2.33731031e-01f, -5.57246625e-01f, -4.49258596e-01f, -4.82259005e-01f, -6.27072275e-01f, 1.00313932e-01f, -3.95374686e-01f, -1.02873623e+00f, -1.32272351e+00f, -7.08689511e-01f,
  -5.64987779e-01f, -7.69233942e-01f, -8.18264663e-01f, -3.32534671e-01f, 1.54357031e-01f, -5.65111399e-01f, -1.41274825e-01f, -5.03116786e-01f, -2.51065344e-01f, -2.58977953e-02f,
  -5.29491961e-01f, -1.66470930e-01f, -2.75672704e-01f, 8.75254199e-02f, 1.85866877e-02f, 9.38873813e-02f, -1.43620759e-01f, 5.01419008e-02f, 3.50520700e-01f, 2.48546615e-01f,
  -1.19726218e-01f, 3.05301063e-02f, -1.86063666e-02f, -6.43907413e-02f, -2.71620184e-01f, -1.74047157e-01f, 1.36864766e-01f, -1.15226857e-01f, 1.53849110e-01f, 3.73393059e-01f,
  2.22053319e-01f, -7.61809647e-02f, 5.22039980e-02f, 3.20448667e-01f, 1.42734736e-01f, -1.76741779e-01f, 9.35785100e-02f, 1.04054339e-01f, 4.25174199e-02f, 3.11564654e-01f,
  2.61055112e-01f, 1.99613005e-01f, 2.96767540e-02f, 1.88554432e-02f, 1.18934326e-01f, 6.40184805e-02f, 6.54205214e-03f, 1.13607414e-01f, -8.55200961e-02f, 1.50277555e-01f,
  2.45894670e-01f, 2.04084352e-01f, -8.32636878e-02f, -6.66400269e-02f, -4.49149162e-02f, -3.13218385e-02f, 2.02150643e-02f, 7.38589987e-02f, 2.80298349e-02f, 1.39406651e-01f,
  -8.61947909e-02f, -4.62966189e-02f, -5.92795871e-02f, -7.82425627e-02f, 1.95496321e-01f, 1.51274234e-01f, 3.57997008e-02f, -7.54504502e-02f, -7.95956850e-02f, 4.83851768e-02f,
  -4.70470876e-01f, -3.89589578e-01f, 7.54833743e-02f, -4.94756587e-02f, -3.16902697e-02f, 2.28430703e-01f, -1.17202327e-01f, 7.48610198e-02f, 3.84139754e-02f, 5.05764633e-02f,
  -4.50597629e-02f, -2.61165258e-02f, 4.18548137e-02f, 1.91531226e-01f, -1.72038347e-01f, -1.05652392e-01f, 2.87045211e-01f, -2.81811599e-02f, 7.16548786e-02f, 3.09006989e-01f,
  4.29997236e-01f, 2.01122940e-01f, -6.13752641e-02f, 5.88200875e-02f, 1.64919600e-01f, -3.04847926e-01f, -1.58488065e-01f, 6.46391883e-02f, -8.31855014e-02f, 3.49821985e-01f,
  -9.30516005e-01f, -8.17922711e-01f, 1.19177783e+00f, -1.09543276e+00f, -7.88393766e-02f, 4.17001933e-01f, -5.51601574e-02f, -5.97571909e-01f, -6.63312197e-01f, -2.80770808e-01f,
  -1.37843743e-01f, -1.83726996e-01f, 1.40875950e-01f, 1.43470494e-02f, -1.29849017e-02f, 1.64498597e-01f, 5.00839651e-01f, 6.60988986e-01f, 7.02176929e-01f, -1.35919258e-01f,
  -6.27670944e-01f, -6.87317014e-01f, -5.23770630e-01f, -1.00165635e-01f, -6.34855568e-01f, -4.94197831e-02f, 2.34563410e-01f, -3.74020666e-01f, -8.25473666e-02f, -4.95135754e-01f,
  2.87713051e-01f, -4.67900068e-01f, 1.42803401e-01f, -2.85923988e-01f, 3.39572616e-02f, -3.59155163e-02f, -3.87289524e-02f, -6.06842637e-02f, -6.48892438e-03f, -5.07856272e-02f,
  -1.10351607e-01f, -1.32281855e-01f, -4.48014997e-02f, -9.52399001e-02f, -1.49707228e-01f, 4.43349518e-02f, -1.18089013e-01f, -2.42413536e-01f, -6.29380792e-02f, -1.80650335e-02f,
  -1.05029330e-01f, -8.14807713e-02f, 1.67124048e-01f, 1.87914565e-01f, 4.33331355e-02f, 1.06030285e-01f, 5.15436977e-02f, -7.55236149e-02f, 2.01075196e-01f, -2.14058161e-01f,
  2.62674093e-01f, 1.03305452e-01f, -3.18891108e-02f, 7.19966646e-03f, -1.12979084e-01f, -9.91312321e-03f, 3.67421508e-02f, -1.67123992e-02f, 3.82416807e-02f, -1.37647495e-01f,
  -1.19583696e-01f, 7.79769868e-02f, -1.26214875e-02f, -1.79280907e-01f, -3.31437662e-02f, -1.88327506e-01f, -1.70732681e-02f, -1.20425947e-01f, 1.06413901e-01f, -1.72627330e-01f,
  -2.34609321e-01f, -6.61609545e-02f, -7.27962777e-02f, -6.96301907e-02f, -3.09604350e-02f, 6.30011782e-02f, 1.39636546e-03f, 8.82751569e-02f, 9.41559821e-02f, -7.01735839e-02f,
  -4.54932809e-01f, 5.26863456e-01f, -1.79901674e-01f, -1.66552976e-01f, -2.84283459e-02f, -7.53215179e-02f, 6.65909201e-02f, 6.09195344e-02f, -3.97840552e-02f, -4.96116243e-02f,
  6.69433922e-02f, -1.46957543e-02f, 6.95805848e-02f, -1.78072438e-01f, 6.39349297e-02f, 1.21017434e-01f, -1.62419587e-01f, -7.30224401e-02f, -3.20208631e-02f, -1.18253961e-01f,
  1.62048582e-02f, 1.79231212e-01f, 1.44672439e-01f, 1.90156221e-01f, 4.46756147e-02f, 3.20950300e-01f, 2.83054769e-01f, 6.68388307e-02f, 3.23695689e-01f, 3.24852765e-02f,
  -3.65513504e-01f, -5.87252736e-01f, 3.25457215e-01f, 5.97736061e-01f, 5.59642315e-01f, 5.75399220e-01f, 3.18699509e-01f, 2.70490319e-01f, 4.85199392e-01f, 3.20304453e-01f,
  -5.08398227e-02f, 3.70457739e-01f, 3.89043599e-01f, 2.99378932e-01f, 1.58887178e-01f, 4.34055865e-01f, 6.29536986e-01f, 2.82009363e-01f, 3.62203449e-01f, 3.10494363e-01f,
  3.51374775e-01f, 1.94855744e-03f, -2.85405070e-01f, 1.83747694e-01f, 7.48726027e-03f, 2.25837901e-01f, 1.68150857e-01f, 4.21601534e-02f, -7.47119635e-02f, 2.68555731e-01f,
  -2.87412852e-01f, -4.23153847e-01f, 3.47836256e-01f, -3.37202102e-02f, -2.02853724e-01f, -2.73222297e-01f, 3.96185741e-02f, -1.81180790e-01f, -2.60043502e-01f, -6.49909116e-03f,
  -8.60619172e-02f, -1.70805946e-01f, -1.27811655e-01f, -1.37683004e-01f, -2.21578747e-01f, -1.00011453e-01f, -4.54107523e-02f, 1.86856002e-01f, 2.36440614e-01f, -3.94341126e-02f,
  2.67570727e-02f, 5.30514903e-02f, 1.17452420e-01f, 2.14306220e-01f, -3.68683040e-02f, 1.11128621e-01f, -2.24028483e-01f, -6.29598573e-02f, 2.23269183e-02f, -2.54496615e-02f,
  2.23035425e-01f, 1.80322483e-01f, 1.14340745e-01f, 1.67198896e-01f, -8.47096834e-03f, 2.15424225e-01f, 1.08419545e-01f, 8.76871124e-02f, 2.12541178e-01f, 3.24597843e-02f,
  1.15634184e-02f, 1.32216811e-01f, 6.85231909e-02f, 6.81831315e-02f, 9.83994976e-02f, 8.17224830e-02f, -1.42318770e-01f, -6.76774681e-02f, -7.10969493e-02f, -1.57508001e-01f,
  -2.89598554e-02f, -5.85930459e-02f, -1.38871148e-01f, -7.88808987e-02f, -6.72026426e-02f, 1.89316019e-01f, 7.40943179e-02f, -1.19224764e-01f, -8.61416832e-02f, -5.97406998e-02f,
  3.00330967e-01f, 1.75598279e-01f, 1.34273931e-01f, -4.26803306e-02f, -1.33594081e-01f, -3.01836222e-01f, 7.32745379e-02f, -1.38501301e-01f, -2.32629761e-01f, 5.84733561e-02f,
  -1.39401630e-01f, -2.62454897e-01f, -3.07529539e-01f, -6.41146526e-02f, 2.50894129e-02f, -1.06585816e-01f, -1.81067884e-01f, 1.93668798e-01f, 7.46937022e-02f, -9.12741721e-02f,
  -4.09888774e-02f, 2.90811479e-01f, 3.41527194e-01f, 1.92606330e-01f, 2.74259336e-02f, 1.39352083e-01f, -4.21967953e-02f, -4.72292863e-02f, 7.06867576e-02f, -8.91448185e-03f,
  -1.36232173e+00f, 4.63577271e-01f, -1.36840761e+00f, -4.21880692e-01f, 2.57977486e-01f, 1.22671917e-01f, 7.09071517e-01f, 2.34735072e-01f, -1.32282093e-01f, -4.63796183e-02f,
  1.46606892e-01f, 4.80474606e-02f, -1.87653050e-01f, 2.18165249e-01f, 2.59121656e-01f, 4.59279537e-01f, 2.67063051e-01f, -4.45287645e-01f, -1.01090766e-01f, 6.42737806e-01f,
  8.64517450e-01f, 5.46804816e-02f, -5.50860524e-01f, -1.33297369e-01f, -1.51163861e-02f, 1.32414445e-01f, -3.14124942e-01f, -1.35433406e-01f, 2.97149062e-01f, 9.80423018e-03f,
  -7.08417177e-01f, -6.46882832e-01f, 1.05609410e-01f, -1.69434860e-01f, -3.01819444e-01f, -2.76707798e-01f, -1.03339635e-01f, -4.20747876e-01f, -1.94879830e-01f, -2.72433877e-01f,
  -3.65675896e-01f, -1.87025219e-01f, -7.24445060e-02f, 2.97047317e-01f, 1.51279032e-01f, -2.52210088e-02f, 2.02717483e-02f, -5.11735201e-01f, -5.60425699e-01f, -3.08387220e-01f,
  7.84266531e-01f, -1.12499982e-01f, -8.53566587e-01f, 1.82199329e-01f, -7.48397782e-02f, -5.45717299e-01f, -4.50704485e-01f, -4.58930284e-01f, -6.60012901e-01f, -3.11667621e-01f,
  1.48541421e-01f, -4.66694012e-02f, 5.65484017e-02f, -7.46045336e-02f, 2.44226620e-01f, -4.76240814e-02f, 1.64700910e-01f, 2.23059893e-01f, 5.49208149e-02f, -9.74988341e-02f,
  -4.09148671e-02f, -4.34485748e-02f, -1.05986007e-01f, -1.65401846e-01f, -1.09344877e-01f, -7.93711469e-02f, 3.06625180e-02f, 1.28786266e-01f, 6.00986220e-02f, 9.03948024e-02f,
  -1.29484758e-01f, -4.76753078e-02f, 2.83303596e-02f, 1.28148541e-01f, 1.29707009e-01f, -1.72318608e-01f, -1.76143706e-01f, 5.27506545e-02f, -2.18453854e-01f, -1.48212239e-01f,
  -3.19281477e-03f, 1.76058829e-01f, -2.18445197e-01f, 2.10173786e-01f, -1.84005387e-02f, -3.96663621e-02f, 1.44095579e-02f, 3.07374131e-02f, -2.50048280e-01f, -2.40164250e-01f,
  1.52681261e-01f, -1.31312698e-01f, -4.34132926e-02f, 8.25062767e-02f, -7.56965801e-02f, -1.23044260e-01f, 4.53952074e-01f, -1.82307124e-01f, 2.06503853e-01f, -5.32930829e-02f,
  2.06321731e-01f, 2.72626281e-01f, -7.87855610e-02f, -3.67242582e-02f, 1.51811048e-01f, -1.49868801e-01f, -1.81117058e-01f, -4.30665649e-02f, -2.62033314e-01f, 9.88851711e-02f,
  8.31206739e-01f, -5.27038634e-01f, 4.49392051e-01f, 8.88108015e-01f, -1.68143719e-01f, -5.81702590e-01f, -7.28851378e-01f, -7.54190907e-02f, 2.83009917e-01f, 2.51858920e-01f,
  -6.28082097e-01f, -8.08524966e-01f, -3.22583225e-03f, -4.17150885e-01f, -5.63538849e-01f, 3.78973722e-01f, 7.83069551e-01f, 3.55658054e-01f, -4.03649122e-01f, -6.99842453e-01f,
  -3.98931265e-01f, 5.07722735e-01f, 5.60056031e-01f, 5.16886637e-02f, 1.27824247e-01f, -3.93356942e-02f, 5.75443447e-01f, 1.46188721e-01f, -2.80392498e-01f, 2.73477793e-01f,
  -3.42019945e-02f, 7.05701783e-02f, -1.66269183e-01f, -2.44317979e-01f, 4.67944657e-03f, 5.38781546e-02f, -1.46964505e-01f, 1.50834888e-01f, -3.28777939e-01f, -8.60391483e-02f,
  -6.96334988e-02f, -3.24433029e-01f, -1.69954017e-01f, -1.97335482e-01f, -2.33079553e-01f, -1.48262307e-01f, 2.33511284e-01f, -1.00060396e-01f, 4.45579626e-02f, -4.38043594e-01f,
  -8.16134512e-01f, -3.71694714e-01f, -1.66691065e-01f, -2.59713680e-01f, -9.56284255e-02f, -1.88696489e-01f, -1.32223591e-01f, -5.25975883e-01f, -8.87318999e-02f, 2.57152677e-01f,
  -1.08496465e-01f, -4.21930850e-03f, 9.04148668e-02f, 7.39095435e-02f, 4.92395386e-02f, 5.60805425e-02f, 2.09733218e-01f, 9.75446403e-03f, -2.90054474e-02f, -9.99028832e-02f,
  -1.25308290e-01f, 1.79638341e-02f, -8.68899077e-02f, 2.25699171e-02f, 2.04993039e-02f, -3.77917364e-02f, -1.27907127e-01f, 1.73815474e-01f, 9.35434178e-02f, 1.56807452e-01f,
  7.86044821e-02f, -4.66775987e-03f, 1.99738517e-01f, -1.93230495e-01f, -2.22084254e-01f, 6.78521581e-03f, 1.72945887e-01f, -1.93123505e-01f, 4.23288047e-02f, 1.82919074e-02f,
  2.30386555e-01f, -2.61204988e-01f, 1.73131570e-01f, 1.03850611e-01f, 2.00231627e-01f, -4.61926088e-02f, 7.86983594e-02f, 4.05609421e-02f, -7.81533718e-02f, -4.17199820e-01f,
  -2.26496205e-01f, -1.19532645e-01f, 1.90495685e-01f, -9.71557572e-02f, -1.97031293e-02f, -3.22576538e-02f, 1.88432857e-01f, -3.43421191e-01f, -8.05989727e-02f, -9.62280482e-02f,
  2.44655043e-01f, 8.25099275e-02f, 1.59237459e-01f, 2.34780356e-01f, 3.52439642e-01f, 4.17446010e-02f, 1.04567535e-01f, 5.73428608e-02f, -5.34666926e-02f, 5.26987135e-01f,
  4.75407243e-01f, 1.75574511e-01f, -5.21147132e-01f, 3.60622108e-02f, -2.50067472e-01f, -1.85629472e-01f, 6.72879934e-01f, 2.17994943e-01f, -6.11959621e-02f, 4.36244458e-01f,
  -2.26033628e-01f, -5.63811958e-01f, -5.80106318e-01f, -3.97625029e-01f, -2.71547943e-01f, 3.97564471e-01f, 1.16704173e-01f, -2.86947489e-01f, -1.70723677e-01f, 3.39019477e-01f,
  4.50125128e-01f, 6.50102139e-01f, 3.70982379e-01f, -8.75650346e-02f, -1.21637424e-02f, -2.61050671e-01f, 1.25607604e-03f, -1.03385359e-01f, -1.95302352e-01f, 4.95859198e-02f,
  2.72762299e-01f, -5.52837789e-01f, -1.35875255e-01f, -3.78679633e-01f, -3.05167139e-01f, 1.98670894e-01f, 1.12496398e-01f, -2.91620374e-01f, -7.76719376e-02f, 1.86608359e-01f,
  -7.44930506e-02f, -2.12656260e-02f, -1.84543192e-01f, 1.75866067e-01f, 2.94824928e-01f, -3.45790423e-02f, -9.83408615e-02f, -1.75483420e-01f, -1.93719283e-01f, -6.16213530e-02f,
  -2.24817619e-01f, -3.23368251e-01f, -3.66155952e-01f, -3.20263863e-01f, -3.64773035e-01f, -4.26735193e-01f, -1.40878811e-01f, -4.06775266e-01f, -5.11535525e-01f, 2.56084383e-01f,
  6.65378347e-02f, 1.83801278e-01f, -8.40807185e-02f, 2.25103393e-01f, 3.32779169e-01f, -5.12140058e-02f, 6.13600155e-03f, 1.92579930e-03f, 1.58755407e-01f, 1.90693825e-01f,
  -1.04812235e-01f, 9.55526084e-02f, -5.01779988e-02f, -8.23680088e-02f, -5.80422133e-02f, -1.52862445e-01f, -6.77556964e-04f, 1.93626776e-01f, -2.05537483e-01f, 1.50489493e-03f,
  -1.28557190e-01f, -6.56473800e-04f, 1.95104461e-02f, 2.34720975e-01f, -1.77625105e-01f, -2.51088500e-01f, -3.97548527e-02f, 2.51981001e-02f, 6.66354299e-02f, 1.36970207e-01f,
  7.16167867e-01f, -5.38180232e-01f, 2.57563770e-01f, -1.89375743e-01f, -1.25333309e-01f, -2.71049678e-01f, -3.36078927e-02f, -1.84224814e-01f, 2.25076918e-02f, 1.97224513e-01f,
  -1.97218418e-01f, 3.05811260e-02f, 2.51703081e-03f, 1.18707478e-01f, 5.59631102e-02f, -1.49099696e-02f, 2.32370466e-01f, -4.28993106e-02f, -5.64939193e-02f, 2.08707497e-01f,
  1.72278449e-01f, 2.87838370e-01f, 5.03757954e-01f, -8.58171377e-03f, -8.33817720e-02f, 2.03055562e-03f, 2.74822056e-01f, 2.31861115e-01f, -2.81014596e-03f, 1.04156828e+00f,
  1.29310942e+00f, -8.05633247e-01f, -1.01889479e+00f, 5.11970818e-01f, -3.29716176e-01f, -6.86364233e-01f, -1.16534889e+00f, -2.06102610e-01f, 3.60906839e-01f, -5.79850793e-01f,
  -1.10127695e-01f, 8.25886369e-01f, 4.42339003e-01f, 6.05964005e-01f, 4.49106276e-01f, -8.89294207e-01f, -5.22862554e-01f, 3.64997208e-01f, 6.88018143e-01f, 1.77468508e-01f,
  2.49096617e-01f, 3.95164818e-01f, 7.14701056e-01f, 3.03911984e-01f, -5.90496480e-01f, 8.41896683e-02f, -8.30327749e-01f, -2.61760741e-01f, -5.41834831e-01f, -8.50243628e-01f,
  -4.75657731e-01f, -6.62332535e-01f, 3.29273671e-01f, 5.19431889e-01f, -1.45941585e-01f, 2.66733140e-01f, -2.78961688e-01f, -2.05478504e-01f, -3.84011790e-02f, -1.55034497e-01f,
  1.18599772e-01f, 6.00936636e-02f, 3.29450727e-01f, -1.26482546e-01f, -9.22686458e-02f, -6.64291456e-02f, 1.33317962e-01f, -1.96181852e-02f, -1.22729793e-01f, -3.82880181e-01f,
  -1.19612299e-01f, -1.76873535e-01f, -2.78360814e-01f, -5.38430154e-01f, -3.27657074e-01f, 2.68529683e-01f, -7.22180724e-01f, -3.41139048e-01f, -4.51374799e-01f, -5.59857249e-01f,
  6.35836720e-02f, 3.64651754e-02f, 1.54258739e-02f, -1.18784830e-01f, 4.67739888e-02f, -1.47982612e-02f, -2.06407681e-01f, 3.30403484e-02f, -2.75087785e-02f, -1.65195048e-01f,
  -1.16145559e-01f, -1.91332866e-03f, -2.81602032e-02f, -8.66080448e-02f, 9.55039561e-02f, -9.04570818e-02f, -4.28821295e-02f, -1.93809550e-02f, 1.72672182e-01f, 5.75713068e-02f,
  1.76124766e-01f, -4.39465642e-02f, 4.39061113e-02f, 1.49638895e-02f, -1.18501566e-01f, -8.14948156e-02f, 5.58861233e-02f, 1.66721120e-01f, 2.71731675e-01f, -2.13826850e-01f,
  4.77147490e-01f, 5.00534832e-01f, -2.24408224e-01f, 1.14485264e-01f, -2.02706262e-01f, -1.13160267e-01f, -2.60737032e-01f, -3.54574956e-02f, 7.31653199e-02f, -7.50662535e-02f,
  -1.35349959e-01f, -3.38278199e-03f, -2.06949472e-01f, -1.30358651e-01f, 1.66900218e-01f, -2.70081051e-02f, 1.25403211e-01f, 1.09703578e-01f, -5.16721383e-02f, -2.32155528e-02f,
  1.33785829e-01f, -6.58332929e-02f, 4.10732478e-01f, 6.34391978e-02f, 5.82960993e-02f, 5.40558934e-01f, -2.91170299e-01f, -3.34788620e-01f, 2.15050410e-02f, -2.53902376e-01f,
  -6.71568140e-02f, -3.16028118e-01f, -2.58740097e-01f, -3.20272326e-01f, -8.53995681e-01f, -8.64018559e-01f, -1.18272579e+00f, -1.48054004e-01f, -1.54101595e-01f, -7.04870582e-01f,
  -2.47424975e-01f, 5.37501872e-01f, 6.84962094e-01f, 3.58662724e-01f, 1.39202848e-01f, -7.09625244e-01f, -9.13174450e-01f, -2.59448051e-01f, -3.13823074e-02f, -4.75476891e-01f,
  -6.77676499e-01f, -3.66802454e-01f, -9.41432938e-02f, 1.53329536e-01f, 3.02995499e-02f, 2.14189798e-01f, -1.46733671e-01f, -2.31683940e-01f, -4.27465081e-01f, -2.86924303e-01f,
  4.23874676e-01f, -2.09227800e-01f, -5.82257956e-02f, -2.73203161e-02f, -1.11203760e-01f, 4.73083183e-02f, 4.78349216e-02f, -1.90646891e-02f, -1.39375269e-01f, 4.05808631e-03f,
  -1.29779622e-01f, -1.72344819e-01f, 2.17939802e-02f, 5.30225225e-02f, -7.68730491e-02f, -5.60239516e-02f, -6.84778690e-02f, -8.47023204e-02f, -1.42521545e-01f, -1.01579539e-01f,
  -1.78044170e-01f, -3.45921904e-01f, 7.01103657e-02f, 1.19724542e-01f, -3.83816287e-02f, 1.60428677e-02f, 1.21419884e-01f, -6.41193464e-02f, 9.67993736e-02f, 1.32243037e-01f,
  -1.00430027e-01f, 3.15387160e-01f, -9.50078201e-03f, 1.20219819e-01f, 7.12753907e-02f, 2.40180944e-03f, 5.67975640e-02f, -5.96306771e-02f, 9.37204286e-02f, 1.25733778e-01f,
  1.30928131e-02f, 9.05323029e-03f, 1.60176098e-01f, -3.33369076e-02f, -1.54853957e-02f, -5.12173958e-02f, -5.42437620e-02f, 8.30966458e-02f, 5.63229099e-02f, -7.06694350e-02f,
  -3.73313203e-02f, -2.48091836e-02f, 3.35057452e-02f, 1.18862577e-01f, -2.12725922e-01f, -6.19529709e-02f, 1.03596099e-01f, 1.08200483e-01f, 6.12458512e-02f, -2.06721157e-01f,
  9.23582494e-01f, -3.05290729e-01f, 5.40276021e-02f, 1.62046820e-01f, -4.57944013e-02f, -1.24662809e-01f, 5.60190603e-02f, -3.80159356e-02f, 4.86543439e-02f, 1.54929206e-01f,
  -2.49248311e-01f, -3.79529484e-02f, 8.53902921e-02f, 1.85904056e-02f, -7.09289536e-02f, -2.03242078e-01f, -1.68752968e-01f, -5.49288653e-02f, -2.61592641e-02f, -1.44808479e-02f,
  -1.43770397e-01f, -1.10960506e-01f, 2.81189531e-01f, 1.99415013e-01f, 1.11910075e-01f, 1.47262856e-01f, 3.73536348e-01f, 1.53002441e-01f, 1.62329316e-01f, 2.08711624e-01f,
  8.81874979e-01f, 5.36239088e-01f, 7.09038198e-01f, 3.98514777e-01f, 5.58869660e-01f, 8.03396285e-01f, 1.10171354e+00f, 5.08407295e-01f, -1.81789801e-01f, 1.53657034e-01f,
  -1.11398496e-01f, -6.94036961e-01f, -4.52510685e-01f, -3.62579972e-01f, 3.91713455e-02f, 2.36187011e-01f, 8.00476894e-02f, 5.35121709e-02f, -6.41955435e-02f, 1.16372801e-01f,
  -3.06148380e-01f, -7.31149688e-02f, -1.89985529e-01f, -1.86376423e-01f, 3.16009596e-02f, -2.62856305e-01f, 1.59368321e-01f, 3.71681631e-01f, 2.39488840e-01f, -3.19242328e-01f,
  -1.99047491e-01f, 7.13547885e-01f, -4.22657400e-01f, -4.39506352e-01f, -2.35515777e-02f, -2.56482035e-01f, -1.06330156e-01f, -2.34661177e-01f, -2.04896942e-01f, -1.18217707e-01f,
  8.30271319e-02f, -1.05970666e-01f, 5.29311486e-02f, 6.03287444e-02f, 2.31312424e-01f, 1.62036955e-01f, 1.97105668e-02f, 3.20262387e-02f, -1.21466583e-02f, 2.98409741e-02f,
  -2.66814351e-01f, 1.05993971e-01f, 4.70761001e-01f, 1.98515788e-01f, 9.14966762e-02f, -2.87161559e-01f, 6.85741380e-02f, -1.66559983e-02f, 5.80420345e-02f, -1.12166144e-01f,
  -3.90857577e-01f, -8.75940621e-02f, 1.57486096e-01f, -4.12875004e-02f, -4.77260128e-02f, -8.66819471e-02f, -1.36055856e-03f, 1.39408559e-01f, 1.07914887e-01f, 7.92094991e-02f,
  -3.34111899e-02f, 3.05452049e-02f, -2.81898043e-04f, -5.30338194e-03f, -2.42727876e-01f, -1.09084900e-02f, 2.33678669e-01f, -6.20789379e-02f, 1.14522934e-01f, 1.07688494e-01f,
  -1.86489373e-02f, 1.03985056e-01f, 5.06920815e-02f, 1.00217931e-01f, -1.63878098e-01f, 1.62610654e-02f, -1.55804694e-01f, -1.58529684e-01f, -1.15311287e-01f, -9.15733278e-02f,
  -4.48896825e-01f, 1.36769876e-01f, -2.86191553e-01f, -3.51374447e-01f, 1.90159902e-01f, -1.40027227e-02f, 3.26653905e-02f, -2.37413242e-01f, 1.61969308e-02f, -1.63610831e-01f,
  5.78762479e-02f, -3.66938789e-03f, 4.78285067e-02f, 7.10679814e-02f, -1.20351374e-01f, -1.25867724e-01f, -1.30899608e-01f, 1.14946619e-01f, -1.30124837e-01f, -5.84297348e-03f,
  -2.29813471e-01f, 5.24642728e-02f, -3.06544453e-03f, -9.72414985e-02f, -2.72131622e-01f, -5.39132893e-01f, -1.02391116e-01f, -3.15119103e-02f, 3.99218537e-02f, -3.40982527e-01f,
  3.08514148e-01f, -7.57307112e-01f, 6.20232582e-01f, 9.79081392e-02f, -6.42608583e-01f, -6.18771791e-01f, -7.09682822e-01f, -3.07598740e-01f, -2.40101233e-01f, -4.38062459e-01f,
  -1.07371807e+00f, -3.27232748e-01f, -2.99147125e-02f, 2.22761676e-01f, 4.73807633e-01f, 2.52961546e-01f, 7.11152554e-01f, 1.19962418e+00f, 8.73714030e-01f, -1.55264800e-02f,
  -1.33245066e-01f, 2.19025970e-01f, 6.82740927e-01f, 8.04255664e-01f, 3.68432492e-01f, 7.37892836e-03f, 3.55192982e-02f, -1.92853641e-02f, -9.47314128e-02f, 8.31980288e-01f,
  -1.29304677e-01f, -2.81145126e-01f, 1.04368322e-01f, -2.12972209e-01f, -2.12605037e-02f, 3.57521296e-01f, 1.19436450e-01f, 2.08077312e-01f, 4.24331874e-02f, 3.32566261e-01f,
  -2.13276193e-01f, -2.62629539e-02f, -1.92981869e-01f, -2.86925267e-02f, -1.82588249e-01f, -2.42142603e-01f, 3.41518402e-01f, 4.28490490e-01f, 2.97932267e-01f, -1.10652857e-01f,
  -4.12340701e-01f, -4.03737366e-01f, -9.57030728e-02f, -1.56597570e-01f, -3.19539919e-03f, 8.58099908e-02f, -2.76213765e-01f, 2.58136559e-02f, -2.13180333e-01f, 3.76369208e-02f,
  6.62378669e-02f, 1.11494921e-01f, 3.05214208e-02f, 9.49334577e-02f, 3.61024924e-02f, -8.18314552e-02f, 4.54999693e-02f, 7.55568268e-03f, 1.67947710e-01f, 1.83145106e-01f,
  1.37362763e-01f, 1.21740624e-01f, 1.04056560e-01f, 1.39254406e-02f, 3.26476172e-02f, 9.43584889e-02f, 3.04178484e-02f, -1.84905659e-02f, -2.34823190e-02f, 2.77570356e-02f,
  5.72994426e-02f, -8.91589187e-03f, 1.31651297e-01f, 3.20125550e-01f, 8.06797370e-02f, 1.98290393e-01f, 3.02278623e-02f, -1.22625856e-02f, -7.90228508e-03f, -1.24841817e-01f,
  -5.13811350e-01f, -1.30934075e-01f, -3.25487629e-02f, 1.89991519e-01f, -1.48693606e-01f, -1.36460170e-01f, -1.24366879e-01f, -4.87053208e-02f, -6.87939599e-02f, 2.50294685e-01f,
  -1.92658916e-01f, 1.94839630e-02f, -2.21745625e-01f, 2.56017387e-01f, -5.91260865e-02f, -1.64252654e-01f, -1.76425949e-01f, 1.49185911e-01f, 5.33711687e-02f, 5.89487478e-02f,
  1.28522530e-01f, -3.92149776e-01f, -4.29064900e-01f, -2.88737744e-01f, -4.66147125e-01f, -4.49045658e-01f, -1.42993242e-01f, -1.54041767e-01f, -3.86123449e-01f, -4.63236988e-01f,
  1.38562477e+00f, 5.58789730e-01f, 1.82323888e-01f, 4.38877940e-01f, 1.65344670e-01f, -6.68353960e-02f, -2.00570986e-01f, -3.03094506e-01f, -1.54782221e-01f, 2.40548760e-01f,
  5.24428368e-01f, 2.87601173e-01f, 1.58405140e-01f, -7.75929447e-03f, 2.74057742e-02f, -8.75452757e-02f, -1.95662826e-01f, 6.19904436e-02f, 6.90789567e-03f, 3.05045903e-01f,
  1.78804383e-01f, 3.64530712e-01f, 3.24034870e-01f, 1.07455611e-01f, 1.43387869e-01f, 5.69086857e-02f, -5.97759560e-02f, 3.27857554e-01f, 3.36362422e-01f, 3.57971579e-01f,
  7.61442244e-01f, 4.80450869e-01f, -3.40653121e-01f, 1.63808297e-02f, 1.33541673e-01f, -2.32338384e-02f, 1.69709027e-02f, -4.90455739e-02f, -9.08702761e-02f, -4.94637080e-02f,
  -3.15214023e-02f, 1.01849861e-01f, 1.61223710e-01f, -4.83253039e-02f, 4.04228009e-02f, -1.67628692e-03f, -3.99953984e-02f, -3.21995728e-02f, -2.96665505e-02f, -2.51893029e-02f,
  1.95175726e-02f, 1.80011883e-01f, 1.66276973e-02f, -2.48614863e-01f, 1.44620284e-01f, 1.05693646e-01f, -5.77808870e-03f, 1.78657600e-03f, -7.49611109e-02f, 1.78742662e-01f,
  2.08799109e-01f, 2.56399989e-01f, 2.73775250e-01f, 2.72321552e-01f, 3.71331722e-01f, 1.27188787e-02f, -2.26903725e-02f, 1.84496213e-02f, 8.90068933e-02f, 2.66574174e-02f,
  -1.13268010e-01f, 1.50275379e-01f, -1.02808923e-01f, 1.99152268e-02f, 1.16388135e-01f, 1.85583174e-01f, -7.54793733e-02f, -1.57094643e-01f, 1.42531261e-01f, -1.58042014e-01f,
  1.90131217e-01f, -1.09359704e-01f, -1.30636662e-01f, -1.96926340e-01f, -9.62001681e-02f, 4.85087186e-02f, 8.90295729e-02f, 6.94632456e-02f, 1.20510504e-01f, 1.91700663e-02f,
  -6.64664745e-01f, -1.33895501e-01f, 1.13653190e-01f, -1.43299922e-01f, 7.88374767e-02f, -4.26955223e-02f, 1.58480301e-01f, 1.33266533e-02f, -9.94990952e-03f, -1.25226364e-01f,
  -1.59708504e-02f, 3.18593085e-02f, -5.66653423e-02f, -1.95178464e-01f, -3.04536641e-01f, -2.23593563e-01f, -3.49984393e-02f, -2.05806613e-01f, -1.21909164e-01f, -1.63751081e-01f,
  -9.93845835e-02f, -3.42204601e-01f, -2.24647149e-01f, -2.91992724e-01f, -1.39008746e-01f, -9.08214226e-02f, -9.83308405e-02f, -1.11793980e-01f, -2.22896114e-01f, -1.43924013e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  9.55616176e-01f, 7.77558982e-01f, 1.45954624e-01f, 1.29003382e+00f, 1.47772670e+00f, 3.90654773e-01f, 1.09444618e+00f, 1.51195812e+00f, 1.28947031e+00f, 8.45952034e-01f,
  3.70302469e-01f, 9.49142873e-01f, 9.43917155e-01f, 8.42124104e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -8.18072557e-02f, -4.69556779e-01f, -2.06051365e-01f, -2.75009215e-01f, -1.40588731e-01f, -2.09666371e-01f, 1.23852469e-01f, -1.65297091e-01f, -4.15851384e-01f, 7.24810991e-04f,
  -2.88060129e-01f, 7.44322538e-02f, -2.03234717e-01f, 3.80369067e-01f, 1.49617359e-01f, -1.98140502e-01f, -3.66266459e-01f, -2.33300418e-01f, 6.86962083e-02f, 6.25992239e-01f,
  3.29592675e-01f, -2.12007701e-01f, -8.32710981e-01f, -7.63877213e-01f, 5.02594769e-01f, -1.76912582e+00f, -7.47372150e-01f, 7.37351954e-01f, 2.21777618e-01f, -4.64096129e-01f,
  -2.55455703e-01f, -7.07147896e-01f, 1.30437329e-01f, -1.33416846e-01f, -2.49221861e-01f, 1.94314599e-01f, -8.88392404e-02f, 2.24470854e-01f, 6.06072322e-02f, -3.10541868e-01f,
  -7.66609386e-02f, 2.27331683e-01f, -2.62857854e-01f, -5.17746620e-02f, -2.01281205e-01f, -2.29816020e-01f, -4.17158544e-01f, -3.49697284e-02f, -3.57945591e-01f, 2.45962411e-01f,
  -3.77445878e-03f, 6.60767794e-01f, -1.60655916e+00f, -5.43665588e-01f, -1.57899126e-01f, 1.75815269e-01f, -1.36632657e+00f, -6.13809168e-01f, -1.18735194e+00f, 1.54905713e+00f,
  5.07917225e-01f, 2.58994699e-01f, -7.11128831e-01f, 4.66540188e-01f, 1.85106128e-01f, 1.50065258e-01f, 3.23164105e-01f, 2.51182050e-01f, 7.94429481e-02f, -2.80548245e-01f,
  2.72980452e-01f, -8.18558596e-03f, 1.35395618e-03f, 2.24835157e-01f, 3.21698129e-01f, 1.43609382e-02f, -4.28673297e-01f, -4.51459795e-01f, 4.38485384e-01f, 1.81195587e-01f,
  -1.34426340e-01f, -6.38513193e-02f, 3.12195539e-01f, 1.92752797e-02f, -1.58294782e-01f, -1.06298769e+00f, 2.69311994e-01f, -4.96326178e-01f, -7.53252685e-01f, 4.63472515e-01f,
  -1.27062201e+00f, 5.92647970e-01f, -4.33881819e-01f, -9.90711689e-01f, 1.32386196e+00f, -1.21135294e+00f, -4.28475231e-01f, -4.47243065e-01f, -1.71346106e-02f, 3.71852756e-01f,
  6.07419163e-02f, -7.66460836e-01f, -6.37908518e-01f, 9.83720347e-02f, -7.08208919e-01f, 7.35148609e-01f, -4.92152333e-01f, -3.07130098e-01f, 1.18077435e-01f, 5.00285588e-02f,
  5.70783198e-01f, 4.43569362e-01f, 4.57423598e-01f, -4.73182082e-01f, -1.43795061e+00f, -9.03808057e-01f, -2.07357947e-02f, 5.74075341e-01f, 1.06125557e+00f, -5.96395254e-01f,
  7.79839277e-01f, -1.54248035e+00f, -4.36491489e-01f, -1.30119371e+00f, -8.10400128e-01f, -1.95603997e-01f, -2.59459645e-01f, -4.77435678e-01f, 2.36042552e-02f, 5.03174603e-01f,
  -2.53438056e-02f, -3.06001723e-01f, -1.10198386e-01f, 3.41167778e-01f, -4.12612438e-01f, -8.53062943e-02f, 3.12192321e-01f, -7.67414629e-01f, 2.17122138e-01f, -5.07112443e-01f,
  3.14315557e-02f, 8.73645321e-02f, 1.38371512e-02f, 5.48666179e-01f, 8.71454701e-02f, -3.28597903e-01f, 1.30393818e-01f, -1.65470600e+00f, 7.09431648e-01f, 6.40214026e-01f,
  -3.80867124e-01f, 2.79670388e-01f, -5.75915039e-01f, 4.68028843e-01f, -1.00533116e+00f, -5.99663019e-01f, 2.43736178e-01f, -4.42138672e-01f, -6.64651573e-01f, -4.10426557e-01f,
  1.23151787e-01f, 7.65866786e-02f, 3.61751840e-02f, 3.31836462e-01f, 6.25593960e-02f, 1.60408486e-02f, 2.53088325e-01f, 1.40298471e-01f, 2.53244907e-01f, -3.63338202e-01f,
  -5.81095576e-01f, -3.46056849e-01f, 2.24214807e-01f, 2.25366792e-03f, -2.28119627e-01f, 1.44716904e-01f, -4.83251750e-01f, 2.84322351e-01f, 3.00369442e-01f, -2.02402532e-01f,
  -8.96494269e-01f, 4.08498704e-01f, -1.31578648e+00f, 2.21964922e-02f, 1.77324370e-01f, 7.58112192e-01f, 1.18349791e+00f, 2.81210631e-01f, -3.60264391e-01f, -7.05858886e-01f,
  -1.21917093e+00f, -4.79792684e-01f, -4.29575354e-01f, -6.25569582e-01f, 6.64880872e-02f, -4.22421932e-01f, -1.58601671e-01f, 3.28466862e-01f, 6.38529435e-02f, 2.20247984e-01f,
  -4.48841184e-01f, -6.94283605e-01f, 1.20936982e-01f, 3.16409737e-01f, 6.11067235e-01f, 4.60837930e-01f, -6.43234104e-02f, 4.39046957e-02f, -1.25886053e-01f, 6.32515192e-01f,
  4.75668728e-01f, -1.06365645e+00f, -1.31887150e+00f, -1.42737722e+00f, -8.15153480e-01f, -6.76265419e-01f, -1.52666378e+00f, 6.02202177e-01f, 3.16438287e-01f, -8.89200807e-01f,
  -5.60591258e-02f, -2.68647283e-01f, 1.04984903e+00f, 1.67787209e-01f, 9.36137736e-02f, 7.28378072e-02f, -1.94156349e-01f, -2.62265861e-01f, -1.54725477e-01f, 9.11845565e-02f,
  -9.19616818e-02f, -6.02043509e-01f, -1.66812107e-01f, 1.68603942e-01f, 4.72600847e-01f, 1.78965881e-01f, 1.64829910e-01f, -2.42195621e-01f, -1.24650620e-01f, -2.07236201e-01f,
  5.28818890e-02f, -1.82846576e-01f, -4.90726769e-01f, -8.91698837e-01f, -2.23914221e-01f, -1.14325464e+00f, -3.56049687e-01f, 5.36652744e-01f, 1.23122692e+00f, -6.85350895e-01f,
  -3.05600852e-01f, -8.35662544e-01f, -2.61760235e-01f, -2.10689887e-01f, -1.31164700e-01f, -7.89427936e-01f, -3.01976413e-01f, 3.32396448e-01f, -1.01176135e-01f, 1.92938134e-01f,
  7.67218620e-02f, -3.37330997e-01f, -1.24762887e-02f, 3.82526033e-02f, -1.31433114e-01f, 5.13928294e-01f, 2.00896055e-01f, 2.10184008e-01f, -2.89035767e-01f, 3.03494334e-02f,
  -3.21815938e-01f, -4.91389304e-01f, -3.29591542e-01f, 2.30193198e-01f, -6.85666502e-01f, 5.98063469e-01f, -5.35107136e-01f, -1.28512895e+00f, 7.70000756e-01f, 3.48753721e-01f,
  -9.83345568e-01f, 6.97373092e-01f, 9.12456512e-01f, -1.09407949e+00f, -7.65255570e-01f, 3.91072363e-01f, 6.72229007e-02f, -9.41178977e-01f, -4.14787024e-01f, -2.88057476e-01f,
  -1.22558437e-02f, 7.27746785e-01f, -1.11846022e-01f, 1.36566535e-01f, -3.06891322e-01f, -2.52275378e-01f, 3.77826273e-01f, -6.03780806e-01f, 7.52343833e-01f, 5.62144555e-02f,
  7.11072832e-02f, 3.16907875e-02f, 2.40807056e-01f, -1.06295025e+00f, 2.81742036e-01f, -1.47227094e-01f, 1.33774802e-01f, -8.97941351e-01f, 1.09868252e+00f, -3.44015241e-01f,
  -1.35606539e+00f, -5.00518560e-01f, 1.64309200e-02f, 6.28618002e-02f, -5.99180281e-01f, 2.43505582e-01f, -1.05750716e+00f, -7.94170737e-01f, 4.90963794e-02f, 7.43806124e-01f,
  2.35040396e-01f, 9.84078087e-03f, 2.92325139e-01f, -5.61609983e-01f, -4.92234994e-03f, 4.61295009e-01f, 1.68749824e-01f, 1.12013347e-01f, 5.82374156e-01f, 8.71873577e-04f,
  -4.03300792e-01f, -1.94844872e-01f, -2.99633414e-01f, -3.56381595e-01f, -4.12993312e-01f, 4.77934837e-01f, 3.99658173e-01f, -2.16228560e-01f, -8.26226175e-01f, -7.74089158e-01f,
  -8.40587616e-01f, -8.69756043e-01f, 8.46017778e-01f, -5.60565442e-02f, 2.40248054e-01f, -1.04206097e+00f, 9.30830836e-01f, -1.18532658e+00f, 1.09220266e+00f, -8.22761714e-01f,
  -5.49640059e-01f, -3.92071187e-01f, 4.25071150e-01f, 3.90254706e-01f, 1.03311189e-01f, -3.67504299e-01f, -2.34439373e-02f, -3.08049973e-02f, 3.92095625e-01f, 5.31505980e-02f,
  1.82363838e-01f, 2.42674693e-01f, 2.02081546e-01f, 1.24998972e-01f, 1.72161072e-01f, 3.04430038e-01f, -5.13928413e-01f, 4.66934592e-01f, 2.94192195e-01f, 5.34440391e-02f,
  1.77543405e-02f, -1.06248282e-01f, -7.73698032e-01f, 5.54070771e-02f, -4.68540937e-01f, -8.30724001e-01f, -7.41268039e-01f, -6.20058358e-01f, -2.04364955e-01f, -1.05653703e+00f,
  -3.38882327e-01f, 1.40714347e+00f, -1.04909766e+00f, 6.48132265e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.35040301e-01f, -1.48321420e-01f, -7.20899254e-02f, 2.88450569e-02f, -1.60528660e-01f, -7.11305812e-03f, 2.17424005e-01f, 1.71389595e-01f, -1.09666936e-01f, 3.65259916e-01f,
  6.69458732e-02f, -2.41286997e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    