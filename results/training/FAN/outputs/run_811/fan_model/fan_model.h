/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.36399883e-01f, 5.35883307e-01f, -1.37447724e-02f, 7.87362363e-03f, -1.25846555e-02f, -1.99055478e-01f, 2.62048960e-01f, 1.46644339e-01f, -5.81722818e-02f, 1.97788849e-01f,
  -1.63677223e-02f, -1.11554943e-01f, -2.56257147e-01f, -8.13950002e-02f, 2.83601638e-02f, 1.03438795e-02f, 9.31039080e-02f, -1.34177968e-01f, -1.93648502e-01f, 6.27149865e-02f,
  -1.70820922e-01f, 1.01133667e-01f, -5.20242900e-02f, -1.59923047e-01f, 3.39155108e-01f, -5.82138598e-02f, 6.55774325e-02f, 7.64876977e-02f, -1.81827262e-01f, 3.03894609e-01f,
  6.19829074e-02f, 1.86580434e-01f, -1.72744825e-01f, -7.69854477e-03f, -3.45397815e-02f, 1.29158460e-02f, 6.97440282e-02f, 4.69074100e-02f, -1.11405455e-01f, 1.72601528e-02f,
  -2.95782033e-02f, -5.10613993e-02f, -8.70313775e-03f, 1.64438020e-02f, 4.73972745e-02f, 1.73530634e-02f, 1.03305990e-03f, 3.08621470e-02f, -2.26098262e-02f, 1.59003455e-02f,
  -8.17893296e-02f, 8.40420201e-02f, 1.17710367e-01f, 2.74313381e-03f, -4.98318076e-02f, -9.71485153e-02f, -2.75116414e-02f, -1.18917264e-02f, 2.71420111e-03f, 1.79545000e-01f,
  3.05026714e-02f, 3.44813354e-02f, -3.34933847e-02f, 4.44775298e-02f, -1.59737505e-02f, 2.89475601e-02f, -1.74020883e-02f, 2.98064500e-02f, -1.16327126e-02f, 1.14903115e-02f,
  -7.67321289e-02f, 1.53240589e-02f, -1.83398947e-02f, -9.99587681e-03f, -1.13043010e-01f, 8.24794266e-03f, 3.35501656e-02f, 2.54938425e-03f, -1.31976917e-01f, 9.75769460e-02f,
  -3.47943492e-02f, -3.90467010e-02f, 3.24171744e-02f, -3.12209334e-02f, 1.85775068e-02f, 2.95187663e-02f, 5.00828307e-03f, -1.45062171e-02f, -3.64981219e-02f, 3.39485519e-02f,
  -9.98663157e-02f, -1.99279562e-01f, 5.34204543e-02f, -4.14316691e-02f, 1.47604384e-02f, -1.90932900e-02f, -3.59452181e-02f, -3.41431759e-02f, -1.98334474e-02f, 2.84520611e-02f,
  2.16401145e-02f, 2.03505866e-02f, -6.29586652e-02f, -5.67406416e-02f, 4.90752459e-02f, -1.25720399e-02f, -4.10593338e-02f, -3.31072323e-02f, -4.18804288e-02f, 3.26257385e-02f,
  -7.99912587e-02f, 1.04950055e-01f, 7.61868432e-02f, 1.07039228e-01f, 2.89845020e-02f, 2.54911050e-04f, 4.79415013e-03f, -1.75896951e-03f, -6.31996244e-02f, 4.64273430e-02f,
  5.67093231e-02f, -1.36988074e-01f, -3.29003096e-01f, -1.40103949e-02f, -1.06736757e-02f, 1.64359450e-01f, -3.56783122e-02f, 1.90149456e-01f, 1.83604270e-01f, -2.31897503e-01f,
  -9.81845707e-02f, 1.16304688e-01f, -1.62278637e-01f, 2.71361191e-02f, 1.12408260e-02f, -2.77041048e-01f, -1.98354885e-01f, -6.09167963e-02f, 3.27386945e-01f, 4.89048988e-01f,
  7.77014270e-02f, 1.35745779e-01f, 9.00172815e-02f, 2.19869182e-01f, -1.40456840e-01f, -3.96653526e-02f, -2.70042062e-01f, -1.73187479e-01f, -7.54869431e-02f, -5.00419915e-01f,
  -2.13471368e-01f, 5.08496026e-03f, 2.30912343e-02f, 8.77049845e-03f, -1.46292493e-01f, -9.85934678e-03f, -1.56740565e-02f, -6.55785874e-02f, 1.47000886e-02f, 1.82156190e-02f,
  -1.73876323e-02f, 4.71870154e-02f, 3.40669714e-02f, -6.99300542e-02f, -1.98275540e-02f, 2.33044103e-02f, 5.18193617e-02f, 6.86281314e-03f, -1.87982842e-02f, -9.78836641e-02f,
  -8.71321112e-02f, 1.17063090e-01f, 1.21449873e-01f, -2.27823537e-02f, 5.95552549e-02f, 1.37112990e-01f, 5.75587004e-02f, 5.90024181e-02f, -3.50139439e-02f, -1.80905133e-01f,
  2.17893831e-02f, -5.20602800e-02f, -1.21001629e-02f, 3.60428952e-02f, -2.35965364e-02f, -8.02464609e-04f, -3.19047109e-03f, -7.17035234e-02f, 2.59686727e-02f, -9.68712103e-03f,
  -3.97087494e-03f, 1.45360064e-02f, -4.47005918e-03f, -9.16593596e-02f, 1.19008170e-02f, -4.39096726e-02f, -8.77625961e-03f, -3.52913179e-02f, 1.45034827e-02f, 3.31892259e-02f,
  5.09943329e-02f, 1.50193218e-02f, 7.14363414e-04f, 6.91123456e-02f, 9.05750133e-03f, -1.95080433e-02f, 2.67527755e-02f, 5.54066198e-03f, 2.81796362e-02f, 1.27379661e-02f,
  -3.60259376e-02f, 2.61491872e-02f, -7.39403740e-02f, 6.22233115e-02f, -9.16322097e-02f, 4.01353501e-02f, -7.41527677e-02f, 3.03722546e-02f, -4.22789678e-02f, -1.97618864e-02f,
  6.42144457e-02f, 7.86525838e-04f, -5.59544899e-02f, -1.94272846e-02f, 5.40579930e-02f, -1.02606174e-02f, -1.95333380e-02f, -6.31463975e-02f, 3.69352102e-02f, 2.48497538e-02f,
  5.47651807e-03f, 1.86422803e-02f, -1.21956028e-03f, -1.34094685e-01f, -2.24498715e-02f, -8.18718150e-02f, -8.41611922e-02f, -2.05493439e-02f, 8.32434185e-03f, -1.92378491e-01f,
  1.17260838e+00f, -1.09945469e-01f, -1.91805631e-01f, 4.27947044e-01f, -8.77471790e-02f, -4.60163467e-02f, -3.48331928e-02f, 9.84909087e-02f, 1.82068512e-01f, 1.00142762e-01f,
  -1.38094410e-01f, -1.38478085e-01f, 5.93881942e-02f, -6.51056543e-02f, 2.74535239e-01f, 1.58937737e-01f, 2.54233330e-01f, 1.76155001e-01f, 3.51863191e-03f, -6.67537674e-02f,
  -6.23502135e-02f, 1.20743781e-01f, 1.59180164e-01f, -7.36162625e-03f, -1.23672588e-02f, -1.72499582e-01f, 3.51978354e-02f, -1.69428512e-02f, -2.56971598e-01f, 1.03961490e-01f,
  -1.42207697e-01f, 5.92219345e-02f, -1.01357527e-01f, 1.07451104e-01f, -7.08743185e-02f, 1.58821363e-02f, 8.08372572e-02f, 2.12897602e-02f, -4.02722917e-02f, -6.53829053e-02f,
  -1.34886503e-02f, -9.54498127e-02f, 2.81707272e-02f, -1.07561365e-01f, -3.55896018e-02f, 1.39218971e-01f, -7.81544521e-02f, 9.26519930e-02f, 1.76105082e-01f, -2.95301024e-02f,
  -1.10712327e-01f, 5.62372501e-04f, -7.33146891e-02f, -4.94949780e-02f, -3.39588267e-03f, 4.67823073e-02f, -9.46309716e-02f, -7.00842887e-02f, 5.97993881e-02f, 4.07191887e-02f,
  9.08615161e-03f, -1.08934166e-02f, -2.05442552e-02f, -3.15647647e-02f, 4.43230197e-02f, -1.49496654e-02f, 1.63596440e-02f, -5.64392172e-02f, -1.43245198e-02f, -2.23370213e-02f,
  9.01839789e-03f, -3.09978612e-03f, -3.21975499e-02f, 6.40740097e-02f, 1.90374106e-02f, -2.64954101e-02f, 7.60435220e-03f, 3.59619642e-03f, -6.71731727e-03f, -2.36332566e-02f,
  5.93405217e-03f, -2.48698667e-02f, 1.26159564e-02f, -2.40707751e-02f, 5.02619743e-02f, -7.05736410e-03f, 1.83732454e-02f, -7.98360184e-02f, 1.98673494e-02f, 2.21222769e-02f,
  1.42731499e-02f, 7.27942027e-03f, 9.55432132e-02f, 1.85549613e-02f, -1.15481373e-02f, -2.78136041e-03f, -4.78892811e-02f, -1.61381066e-02f, -9.89087205e-03f, 6.82227090e-02f,
  -1.04249818e-02f, 3.63837592e-02f, -1.89990029e-02f, -2.35049855e-02f, 3.99652719e-02f, -9.92636289e-03f, 6.64755628e-02f, -2.30601840e-02f, -9.39896703e-02f, -1.97923253e-03f,
  -2.18202639e-03f, 5.27807735e-02f, 1.43132433e-01f, 2.58635096e-02f, 3.51318307e-02f, 1.80581436e-02f, -1.02187976e-01f, -7.99589232e-02f, 1.34590948e-02f, 1.07157014e-01f,
  -8.05297717e-02f, -2.10075192e-02f, 2.53772587e-01f, 2.34969169e-01f, 1.77833766e-01f, -1.14973687e-01f, 1.40162170e-01f, -6.04110062e-02f, -9.31691527e-02f, -3.28793786e-02f,
  1.41933843e-01f, 4.85617556e-02f, -1.56851307e-01f, -2.98359133e-02f, 1.21120522e-02f, 9.55497380e-03f, 2.29239866e-01f, 1.09684229e-01f, 1.19726107e-01f, 2.05732316e-01f,
  -7.83913285e-02f, 7.20501319e-02f, 2.02967152e-01f, -1.86599120e-02f, 1.81563437e-01f, -2.18681112e-01f, 1.57518871e-02f, 2.32711479e-01f, -4.67068031e-02f, 4.09697860e-01f,
  -3.03700343e-02f, 1.59814939e-01f, 6.14261217e-02f, 3.43672521e-02f, -5.26597276e-02f, -8.90501291e-02f, 2.48009013e-03f, 3.40990908e-02f, -3.49999964e-02f, 4.41731177e-02f,
  4.43607830e-02f, -6.13773018e-02f, -3.12319901e-02f, -2.81605721e-02f, 6.74109161e-02f, 1.82282496e-02f, -2.18916386e-02f, 5.49852625e-02f, -9.37543809e-02f, 9.11949482e-03f,
  8.29243138e-02f, 7.45685324e-02f, 2.26313323e-01f, 2.39621219e-03f, -8.08921158e-02f, -6.63510291e-03f, 9.16824117e-02f, 8.74244049e-02f, 5.28532378e-02f, 1.32502437e-01f,
  -1.39721641e-02f, -4.64229770e-02f, 5.52623272e-02f, 1.77254844e-02f, -2.28164233e-02f, 1.18947281e-02f, 2.10977811e-02f, 3.42517793e-02f, -5.08577446e-04f, -3.72867994e-02f,
  -5.72728401e-04f, -2.63807401e-02f, 8.20986461e-03f, -4.01450880e-02f, -1.90774687e-02f, 4.05460186e-02f, -2.61987150e-02f, -2.82459799e-02f, 4.76498194e-02f, -7.84347858e-03f,
  1.57942565e-03f, 4.44463305e-02f, -3.83451842e-02f, -2.23604534e-02f, 5.71860857e-02f, -3.24231153e-03f, -2.72748321e-02f, 8.60587731e-02f, -7.80333877e-02f, 7.46849850e-02f,
  -1.25903189e-01f, 6.02169633e-02f, 1.15173571e-02f, 1.74997617e-02f, -1.99692715e-02f, -3.67678665e-02f, 5.74968047e-02f, -3.88707370e-02f, -2.29013935e-02f, -2.48903725e-02f,
  1.67040825e-02f, -1.19024864e-03f, 1.63985379e-02f, -6.06652291e-04f, 9.34380013e-03f, 1.21314302e-02f, -1.65901333e-02f, 3.13881487e-02f, -9.74042062e-03f, -5.39832711e-02f,
  -6.36004284e-02f, -6.47068955e-03f, -1.30620182e-01f, -1.29359690e-02f, -3.73953232e-03f, 1.22365616e-01f, 2.11440250e-02f, -1.19727872e-01f, 4.02314179e-02f, -4.46356714e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.05633396e-01f, 9.15257111e-02f, -3.86752235e-03f, -1.50493205e-01f, -9.05955657e-02f, -1.05233610e-01f, -6.57340139e-02f, 3.19563672e-02f, 3.75787877e-02f, -7.25707114e-02f,
  -4.23507690e-02f, 5.94572686e-02f, -8.20317343e-02f, -6.90573379e-02f, -7.88647234e-02f, -7.49589875e-02f, -1.81946546e-01f, -1.44077614e-01f, -6.28112927e-02f, 2.64507234e-02f,
  -1.53850511e-01f, -1.50523037e-01f, -1.37361258e-01f, 1.33919409e-02f, 5.74984439e-02f, -5.37694106e-03f, -4.73087312e-05f, -1.30945668e-01f, -7.54466876e-02f, -1.52003616e-01f,
  7.28422105e-02f, 6.77849818e-03f, -8.60195309e-02f, -1.09385483e-01f, -1.72945298e-02f, -7.95957539e-03f, 4.22107317e-02f, -1.07358610e-02f, -2.05591433e-02f, 9.28467810e-02f,
  2.44828593e-02f, 6.82071000e-02f, -3.32011878e-02f, -1.10672019e-01f, 1.17916614e-02f, 4.86598760e-02f, 2.00131931e-03f, -3.50732729e-02f, -6.04884606e-03f, -6.75063441e-03f,
  -3.39847207e-02f, 3.45069803e-02f, 8.95981491e-02f, 8.53902698e-02f, 1.04770124e-01f, -1.08265430e-02f, 5.20158485e-02f, 8.61108154e-02f, 4.03660163e-02f, -4.25380133e-02f,
  -1.13065407e-01f, 1.05462037e-01f, 4.08588685e-02f, -2.94689846e-04f, -3.21338400e-02f, 2.74385810e-02f, -1.02142207e-01f, -1.31614460e-02f, -9.06099845e-03f, 3.90010700e-02f,
  -4.89720292e-02f, -2.63579246e-02f, 3.94444838e-02f, -7.08866343e-02f, -1.87153611e-02f, -1.14038344e-02f, -7.24111870e-02f, -5.54151312e-02f, -2.50628032e-03f, -1.72196552e-02f,
  2.49869376e-02f, 5.93883432e-02f, -2.14936212e-02f, 3.76517288e-02f, -1.39047116e-01f, -5.96679607e-03f, 7.65935257e-02f, 6.42167628e-02f, 2.74564791e-02f, 4.43574004e-02f,
  -2.32350570e-03f, -6.79285899e-02f, -1.79439597e-02f, -5.23879379e-02f, -1.25065833e-01f, 1.13000348e-02f, 5.96686304e-02f, -7.19800591e-02f, -6.69748709e-02f, -4.20210846e-02f,
  6.46305736e-03f, -5.13258167e-02f, 6.05386915e-03f, -3.20690870e-02f, 1.85369086e-02f, 5.12576848e-02f, -6.28857091e-02f, -5.27810529e-02f, 3.38854380e-02f, 1.12969398e-01f,
  5.61479367e-02f, 8.35602432e-02f, 9.71076488e-02f, 6.10426813e-02f, -4.45318371e-02f, 1.93571839e-02f, 3.70353274e-02f, 1.26226451e-02f, 7.63354450e-02f, 3.67133357e-02f,
  1.20614178e-01f, -3.07264984e-01f, 6.30365163e-02f, 1.29985496e-01f, 6.46427944e-02f, -2.15904593e-01f, -5.52446246e-01f, -2.33580425e-01f, 1.30724669e-01f, -1.42182305e-01f,
  8.92198533e-02f, 1.75897956e-01f, -1.06208913e-01f, 2.53978241e-02f, -2.32895300e-01f, -3.57268304e-01f, -9.05355290e-02f, 9.85537991e-02f, 2.41397023e-02f, 1.45103959e-02f,
  9.01809335e-02f, 2.30884135e-01f, 7.82414675e-02f, 1.91736817e-02f, 2.30676103e-02f, 2.59551667e-02f, 1.62642058e-02f, 1.16449624e-01f, -4.58671637e-02f, 2.85593927e-01f,
  1.18263148e-01f, -4.00570780e-02f, -5.78750484e-02f, 2.50744307e-03f, 1.42128646e-01f, -5.63704185e-02f, 1.22911558e-02f, 8.68105739e-02f, 5.77681921e-02f, 4.04932834e-02f,
  9.04868692e-02f, 9.36107710e-02f, 3.15821692e-02f, 1.24957912e-01f, -2.11786628e-02f, 2.94874460e-02f, -1.76745020e-02f, -1.03957038e-02f, -4.39563133e-02f, 4.08396078e-03f,
  1.09685786e-01f, 1.57869324e-01f, 3.48916128e-02f, -7.89320320e-02f, -1.31982505e-01f, 5.35081625e-02f, 3.83222550e-02f, 1.62912384e-02f, -7.14971721e-02f, 8.90306830e-02f,
  3.57675701e-02f, 3.84509191e-02f, -1.41202947e-02f, -2.89083570e-02f, -3.90418544e-02f, 4.63161059e-03f, 4.50257808e-02f, 3.08153406e-02f, 3.39928782e-03f, -5.88255636e-02f,
  1.06563354e-02f, -2.27682712e-03f, 9.13232751e-03f, 1.19065037e-02f, -8.11682548e-03f, 1.59224644e-02f, 2.51186397e-02f, -1.90597009e-02f, -5.78114297e-03f, 2.01884639e-02f,
  -3.37333344e-02f, -6.67080469e-03f, 3.01888008e-02f, 2.65762769e-02f, -2.64138635e-02f, 2.72536390e-02f, 6.30892217e-02f, -3.43999974e-02f, -2.89831823e-03f, 3.24233919e-02f,
  -1.49728328e-01f, -2.78880578e-02f, 6.26857057e-02f, 2.06461363e-02f, 1.16592180e-02f, -2.09891684e-02f, 1.54007962e-02f, -1.11014964e-02f, 5.93788661e-02f, -6.49268366e-03f,
  -5.65989129e-02f, -5.60919791e-02f, -4.91091311e-02f, -7.13122040e-02f, 1.75436877e-03f, -6.51843846e-02f, -3.35997343e-02f, -2.52460539e-02f, 1.46872653e-02f, -9.56450589e-03f,
  -1.10442020e-01f, -1.56331927e-01f, -1.56769291e-01f, -1.72496542e-01f, 8.47882107e-02f, -8.63022506e-02f, -1.68338284e-01f, -5.40466234e-02f, -1.83962241e-01f, -3.69679093e-01f,
  -4.79006171e-02f, -8.38889927e-02f, -1.40696645e-01f, 6.21546954e-02f, 2.46822819e-01f, 1.60723016e-01f, -2.51160632e-03f, 1.83039591e-01f, 3.91424261e-02f, -1.12674460e-01f,
  -4.24278565e-02f, 1.06852084e-01f, -9.01020691e-02f, 8.44260752e-02f, -1.15005106e-01f, -2.30304316e-01f, -2.97585696e-01f, -1.19099334e-01f, 8.43529105e-02f, 3.25748444e-01f,
  4.89043258e-02f, -4.31345440e-02f, -2.86557223e-03f, 3.19288746e-02f, -1.39744105e-02f, -1.07841685e-01f, -2.63365269e-01f, -1.50896376e-02f, -1.02455877e-01f, -2.27494344e-01f,
  -9.66058075e-02f, 1.41189918e-01f, 9.02529731e-02f, -1.71029530e-02f, 1.33755319e-02f, 3.70923765e-02f, 2.30431519e-02f, 4.97179106e-03f, -1.41411591e-02f, -1.10103846e-01f,
  -3.46745960e-02f, -2.80966554e-02f, 7.24500194e-02f, 4.80241105e-02f, 2.27013584e-02f, 7.67619163e-02f, -5.15392497e-02f, 5.96327446e-02f, -1.99718550e-02f, 2.97271218e-02f,
  -1.92694087e-03f, 8.40290263e-03f, 1.97321046e-02f, 6.93845227e-02f, 8.68742839e-02f, -1.17042484e-02f, 6.59274980e-02f, 1.35518551e-01f, 2.06448119e-02f, -5.56606567e-03f,
  -4.15774025e-02f, -1.05024256e-01f, -6.93138596e-03f, 6.45488575e-02f, 7.21037295e-03f, -7.98187405e-03f, 3.30093354e-02f, -6.91275066e-03f, -4.23739068e-02f, 3.79729532e-02f,
  5.25286533e-02f, -5.56621002e-04f, 4.53750454e-02f, 4.18643169e-02f, -3.71006206e-02f, 4.88731936e-02f, -3.72017585e-02f, 1.04539413e-02f, -1.63354632e-02f, 5.10240765e-03f,
  1.20026516e-02f, -7.11086914e-02f, 2.87981573e-02f, -1.91836972e-02f, 1.67081747e-02f, -4.70398590e-02f, -1.43036889e-02f, 6.43865392e-02f, 3.69590446e-02f, -1.54275792e-02f,
  1.02900788e-01f, -1.07478105e-01f, -1.46957159e-01f, 2.09777104e-03f, -4.14367095e-02f, 4.72886264e-02f, -6.35508448e-02f, 3.81828099e-02f, -6.31539449e-02f, 4.05808911e-02f,
  7.84359053e-02f, 2.39963381e-04f, -7.59522445e-05f, -1.94456670e-02f, 6.61396608e-03f, 4.06300602e-03f, -2.08898112e-02f, -1.20384775e-01f, -4.27206531e-02f, 8.97116661e-02f,
  -1.97750647e-02f, -5.34901917e-02f, -4.84568365e-02f, -6.04414865e-02f, -2.99380254e-02f, -6.87048286e-02f, -3.89481969e-02f, -1.51545946e-02f, -5.10425903e-02f, -1.24726333e-01f,
  -1.50902107e-01f, -5.04488871e-02f, -1.77357748e-01f, -1.31444782e-01f, -7.58614615e-02f, 2.12095484e-01f, 4.50843479e-03f, 1.11885183e-01f, 1.11769490e-01f, -9.69855338e-02f,
  1.01083726e-01f, -1.45102832e-02f, -1.60713688e-01f, -3.79730873e-02f, -7.27672055e-02f, 3.65471020e-02f, -1.44817486e-01f, -1.59635365e-01f, 1.00770518e-01f, 2.31188312e-01f,
  1.25930324e-01f, -1.60026535e-01f, -1.27165556e-01f, 7.48009533e-02f, 8.05780571e-03f, -1.14872856e-02f, -1.37178272e-01f, -7.25812092e-02f, 2.62259930e-01f, -2.62166649e-01f,
  -6.31536841e-02f, 8.59426558e-02f, -6.95751561e-03f, -7.15653524e-02f, 8.60904716e-03f, -7.46506676e-02f, 2.31251877e-04f, -4.79509868e-02f, 1.10049754e-01f, 7.56234676e-02f,
  -5.75548373e-02f, 6.83347285e-02f, -1.18622117e-01f, 2.16969438e-02f, 9.64063685e-03f, -1.96905155e-02f, 1.11913450e-01f, -3.18109542e-02f, 9.31521356e-02f, -3.26261180e-03f,
  1.09626658e-01f, 1.41147643e-01f, 8.52591544e-02f, 7.70834908e-02f, 1.20657701e-02f, 4.67137210e-02f, 3.26882489e-02f, 1.63646013e-01f, 1.52637705e-01f, -1.17288262e-01f,
  9.99505669e-02f, 2.53022742e-02f, 2.76125688e-03f, 2.24347552e-03f, -4.80362698e-02f, 5.65849766e-02f, 1.00401938e-01f, 3.60428616e-02f, 2.06987467e-02f, -5.34424260e-02f,
  5.40753379e-02f, 3.51166539e-02f, 5.97016476e-02f, 4.83517163e-02f, 7.14234076e-03f, -3.52599360e-02f, 1.76035184e-02f, 9.71743762e-02f, -2.73946580e-03f, 6.37505427e-02f,
  -3.71417915e-03f, -1.61463320e-02f, 1.31201744e-02f, 3.61542217e-02f, -4.89420630e-02f, -6.66291863e-02f, -4.38659154e-02f, 9.79872048e-03f, -1.42155439e-01f, -6.70057833e-02f,
  -2.15361029e-01f, 2.91007757e-02f, -7.70109072e-02f, 1.10293202e-01f, 2.65889093e-02f, 3.02957557e-02f, -9.32438448e-02f, -7.34671131e-02f, -1.22653060e-01f, -1.56192388e-02f,
  -2.29283012e-02f, 1.17392056e-02f, -1.54004216e-01f, 2.86779795e-02f, -1.27922907e-01f, -2.05790866e-02f, 1.55649604e-02f, -8.17596242e-02f, 7.38004446e-02f, 1.18892796e-01f,
  -2.22854968e-02f, -2.02201176e-04f, -1.03834003e-01f, 4.39071581e-02f, 5.21371067e-02f, -4.92199585e-02f, 1.98760275e-02f, 8.69683325e-02f, -6.88355640e-02f, -1.70208231e-01f,
  -7.20669031e-02f, -3.25995237e-01f, 3.62412602e-01f, 6.97644278e-02f, 4.69019622e-01f, 4.01754290e-01f, 5.04551291e-01f, 1.01124547e-01f, 8.30564573e-02f, 1.46437898e-01f,
  -1.19604617e-01f, -3.14398050e-01f, -4.79383200e-01f, -3.47327262e-01f, -7.99511448e-02f, 1.42239124e-01f, 3.51514041e-01f, -6.87900558e-02f, 3.77066210e-02f, 2.81960160e-01f,
  -1.32868990e-01f, 3.69916554e-03f, -2.69828767e-01f, -1.27083823e-01f, -1.14925727e-02f, -1.47855163e-01f, 1.60755828e-01f, 1.46908984e-01f, -2.51152903e-01f, -2.28637263e-01f,
  8.65353364e-03f, 8.81491005e-02f, -9.94257480e-02f, -7.98775405e-02f, 7.97537118e-02f, -1.02781646e-01f, 4.19188105e-02f, -3.04486230e-03f, 5.11083473e-03f, 4.86148857e-02f,
  2.59985253e-02f, -7.12696090e-02f, 4.18913402e-02f, 2.73082182e-02f, 2.08884150e-01f, 1.61123183e-02f, 3.71513027e-03f, -8.98371413e-02f, -1.65420305e-02f, -3.21252900e-03f,
  -5.20367175e-02f, 1.49828270e-01f, 2.59485275e-01f, 1.84045702e-01f, 1.36376321e-01f, 9.22758412e-03f, -2.66429111e-02f, -9.57437158e-02f, -2.63982508e-02f, -1.84772953e-01f,
  -2.74148323e-02f, 4.72455397e-02f, 1.08680474e-02f, 4.88187652e-03f, -2.43604444e-02f, 5.66382706e-02f, 4.30417852e-03f, -1.72143858e-02f, -3.24637443e-02f, 2.55875178e-02f,
  -4.51897420e-02f, 2.54641920e-02f, 6.71630576e-02f, 2.06307787e-03f, -5.83669245e-02f, 1.06905408e-01f, 1.23069594e-02f, -3.28801312e-02f, 2.59246584e-02f, 5.58183677e-02f,
  -9.16071460e-02f, 8.82696360e-02f, -6.67569635e-04f, 3.63843217e-02f, -3.28162350e-02f, -6.71201572e-02f, -2.35190447e-02f, 5.49608171e-02f, -7.15378001e-02f, 7.27993026e-02f,
  -1.12950429e-01f, 5.87841347e-02f, -6.83746263e-02f, -1.13224469e-01f, 2.46816352e-02f, -6.69834167e-02f, -5.46922535e-02f, -5.28191887e-02f, -5.16383275e-02f, 6.97726989e-03f,
  9.21893399e-03f, 2.46003047e-02f, 2.68585682e-02f, -7.98957646e-02f, -6.44977689e-02f, 7.89791197e-02f, -1.32673290e-02f, 2.43269801e-02f, -1.26786744e-02f, 2.40812432e-02f,
  -9.05941240e-03f, 1.72279309e-02f, 1.49102537e-02f, -8.45554024e-02f, -8.61365423e-02f, 4.34489995e-02f, 9.24642980e-02f, -7.04397913e-03f, 2.31647372e-01f, -1.49114072e-01f,
  5.01658320e-01f, -3.27005059e-01f, 3.34977433e-02f, 4.64086920e-01f, 9.50595140e-02f, -1.09186722e-02f, -1.60820737e-01f, -1.89469066e-02f, 2.03099161e-01f, -2.45829336e-02f,
  1.55654317e-02f, 3.59899819e-01f, 3.41427207e-01f, 5.04570827e-02f, -7.58099183e-02f, -9.75281373e-02f, 3.59339640e-02f, 1.44353807e-01f, 3.41354668e-01f, 1.72539074e-02f,
  1.11974888e-01f, -9.56673026e-02f, -1.26855373e-01f, 1.36098713e-01f, -1.39527217e-01f, 4.10941392e-01f, -1.04039900e-01f, -3.92723709e-01f, -1.08514465e-01f, -9.70181078e-02f,
  -4.65479866e-03f, -1.08390599e-01f, 2.35994846e-01f, 1.46904334e-01f, -5.82368821e-02f, -9.17045698e-02f, -5.16753942e-02f, -3.76805589e-02f, 7.32227638e-02f, -2.48326007e-02f,
  8.27549025e-02f, -1.38011187e-01f, 3.54351848e-02f, -4.19340422e-03f, -1.22305304e-01f, 4.19458300e-02f, -6.00723699e-02f, 1.16244722e-02f, -4.55149598e-02f, 2.47649662e-02f,
  -3.13840657e-02f, 2.10496020e-02f, 7.58624896e-02f, 1.28132120e-01f, -5.59505187e-02f, 2.20657766e-01f, -4.07454967e-02f, -5.30312024e-02f, 5.89073114e-02f, -1.89919978e-01f,
  1.06805719e-01f, -2.65676174e-02f, 2.20073666e-02f, -1.51515119e-02f, -1.44915478e-02f, 1.50556387e-02f, -1.95296276e-02f, 8.06308016e-02f, 3.13561447e-02f, -7.82222152e-02f,
  -5.86766656e-03f, -2.19081603e-02f, 1.59153920e-02f, 2.35601459e-02f, -1.00748248e-01f, -7.02989404e-04f, -2.47193016e-02f, -4.32432368e-02f, -2.69322898e-02f, 4.50180471e-02f,
  -2.97862552e-02f, -1.69626204e-03f, -3.62087376e-02f, -1.37536734e-01f, 2.67602280e-02f, 2.54670698e-02f, 8.91371667e-02f, 4.23160866e-02f, 2.21643667e-03f, -9.88959800e-03f,
  -1.26739606e-01f, 1.99498862e-01f, 3.04781999e-02f, -7.22252503e-02f, 6.87616989e-02f, -1.26752079e-01f, 1.57304734e-01f, -9.24427994e-03f, -4.92402948e-02f, 2.32322998e-02f,
  -4.14156765e-02f, 7.11595044e-02f, -5.86663783e-02f, -8.47379565e-02f, 1.59635037e-01f, 4.76735458e-02f, -1.49611488e-01f, 1.55731410e-01f, -6.79149032e-02f, -9.65236798e-02f,
  -1.51672751e-01f, 1.49007455e-01f, 1.57271415e-01f, 1.41702071e-01f, 1.01474203e-01f, 1.82475999e-01f, 7.89073575e-03f, -9.53463688e-02f, 1.80022418e-02f, -6.12711050e-02f,
  -1.70473494e-02f, -2.11688191e-01f, -1.48272201e-01f, -2.67788976e-01f, -8.72843564e-02f, 1.58888638e-01f, 7.92123601e-02f, -7.61702433e-02f, 2.13846676e-02f, -2.08598688e-01f,
  -1.08043253e-01f, -2.26646334e-01f, -2.54161388e-01f, -4.56204638e-02f, -5.73232099e-02f, 1.64852999e-02f, 5.06690405e-02f, 3.90544115e-03f, 5.69460467e-02f, -2.44849715e-02f,
  -3.84304151e-02f, -3.29610676e-01f, -2.74851143e-01f, 4.42435173e-03f, -1.31571263e-01f, -8.49849284e-02f, -2.06667319e-01f, -9.03275087e-02f, 1.43925205e-01f, -1.42256141e-01f,
  -1.55750513e-01f, -1.72357515e-01f, -5.52451201e-02f, -3.12554203e-02f, -7.69268945e-02f, 1.74553484e-01f, 6.41872957e-02f, -3.59192342e-02f, 3.26814614e-02f, -3.89550030e-02f,
  -3.33112851e-02f, 4.65972908e-02f, -2.01673433e-02f, -2.18433570e-02f, -4.85357456e-02f, -3.72490776e-03f, -5.13242409e-02f, -9.77020934e-02f, -3.92293674e-04f, 6.39414564e-02f,
  -6.82808366e-03f, 2.59110071e-02f, -7.82888103e-03f, 9.21878815e-02f, -1.06260059e-02f, -9.24884602e-02f, -3.59568931e-02f, 1.49552720e-02f, 5.05764000e-02f, 2.25295895e-03f,
  -3.17679532e-02f, 2.62460355e-02f, 8.09679832e-03f, -3.07979770e-02f, 2.92931776e-02f, 2.96763834e-02f, 1.40612079e-02f, 2.44310359e-03f, 1.22824330e-02f, -5.71930334e-02f,
  -4.51849657e-04f, -5.12250923e-02f, 1.26757780e-02f, 1.09058740e-02f, -5.01498654e-02f, 2.59884604e-04f, 6.23008125e-02f, -3.13748196e-02f, -2.54949797e-02f, 2.16107499e-02f,
  -3.10484525e-02f, 4.84836772e-02f, -3.36167752e-03f, -2.26985365e-02f, 1.50686102e-02f, 4.80314195e-02f, 4.32683490e-02f, -4.49330807e-02f, 2.24682689e-02f, 7.74986371e-02f,
  -1.20256044e-01f, 1.44623104e-03f, -4.20332849e-02f, -5.36818467e-02f, 6.50327727e-02f, 2.73937117e-02f, -1.05673097e-01f, 7.40571320e-02f, 3.53642665e-02f, 4.81990352e-03f,
  -3.69816534e-02f, 1.61466356e-02f, 6.01567440e-02f, -1.14159314e-02f, 9.73997870e-04f, -2.55479235e-02f, 7.85006285e-02f, 1.18780108e-02f, 4.85178307e-02f, -6.96496740e-02f,
  -4.74092625e-02f, 1.13324516e-01f, 6.98338449e-02f, 5.03996899e-03f, 2.79018916e-02f, -1.10496338e-02f, -3.48660424e-02f, 5.80012947e-02f, 1.75149336e-01f, 1.23858422e-01f,
  -1.13986552e-01f, -3.69306887e-04f, -1.36343330e-01f, -7.99341276e-02f, 5.71324974e-02f, 1.94544308e-02f, 2.99920905e-02f, 1.44262597e-01f, 6.86227679e-02f, -3.02362517e-02f,
  1.88957136e-02f, 2.37084273e-02f, -6.72030821e-02f, -3.51717556e-03f, -8.64638016e-02f, -9.14885774e-02f, -1.64621070e-01f, -1.42144293e-01f, 4.01603766e-02f, 7.63930529e-02f,
  -6.33746609e-02f, -2.69348592e-01f, -1.64451092e-01f, 6.57675834e-03f, -1.35552227e-01f, -2.19580740e-01f, -2.53428340e-01f, -2.34995306e-01f, 3.71706411e-02f, -3.88681740e-01f,
  -1.19576648e-01f, 1.64408889e-02f, -9.12188068e-02f, -6.01915382e-02f, -9.64124054e-02f, 3.56913693e-02f, 6.34209067e-02f, -5.44567592e-02f, 9.70580503e-02f, 7.55628720e-02f,
  -3.08735445e-02f, 2.61982325e-02f, 2.75068404e-03f, 6.62752613e-02f, 4.15833183e-02f, 4.94192876e-02f, 3.09239235e-02f, 4.50930111e-02f, -1.12592489e-01f, 1.13957845e-01f,
  -1.31180659e-01f, -6.24518618e-02f, -1.72123402e-01f, -2.27763206e-02f, -1.18752485e-02f, -6.31445274e-02f, -5.83313182e-02f, -7.25857392e-02f, -1.07017152e-01f, -2.49075145e-01f,
  -4.41910187e-03f, 4.61992621e-02f, 4.02788334e-02f, 7.65643269e-02f, -9.84078720e-02f, -9.17371083e-03f, -7.18103498e-02f, -2.72073485e-02f, 2.21843384e-02f, -3.72544825e-02f,
  4.35611187e-03f, -2.60363594e-02f, 3.92228886e-02f, -2.40634233e-02f, 1.29852276e-02f, 2.82127950e-02f, -5.57619706e-02f, -2.60817353e-02f, -6.36215732e-02f, -9.32477862e-02f,
  -5.08465320e-02f, 1.44261047e-02f, -2.08530985e-02f, 4.63878922e-02f, 1.74740758e-02f, 4.96222191e-02f, 1.18029127e-02f, -4.45013493e-03f, 1.09124221e-01f, 8.87414590e-02f,
  -3.27034667e-02f, -3.72503065e-02f, -6.35249466e-02f, -2.26128697e-02f, 7.35363215e-02f, -5.80072105e-02f, -4.62681577e-02f, 6.01497814e-02f, -1.13713248e-02f, 9.21898335e-03f,
  6.43713586e-03f, -1.65957063e-02f, -9.87423491e-03f, 1.17047513e-02f, 4.75242920e-02f, 8.10292065e-02f, -4.68619987e-02f, -1.21114485e-01f, -1.46570860e-03f, -4.96911407e-02f,
  -8.39769915e-02f, -1.16746008e-01f, -5.79451434e-02f, -1.22399017e-01f, 4.89175087e-03f, -1.34775221e-01f, -1.18186459e-01f, -1.16727561e-01f, -1.69918671e-01f, -1.47358134e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  3.96864004e-02f, 1.78329706e-01f, -8.38846415e-02f, 6.99021220e-02f, 1.28262043e-01f, 2.77862936e-01f, 2.16160268e-01f, -2.26781555e-02f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  2.33131871e-01f, 1.94700539e-01f, -1.79480091e-01f, 8.97572115e-02f, 5.11541128e-01f, -3.10789824e-01f, 3.36660832e-01f, 4.67935771e-01f, -2.80066967e-01f, -2.97318906e-01f,
  -1.44391194e-01f, -6.52733967e-02f, 6.76937222e-01f, 1.13780580e-01f, 2.54622009e-02f, -1.79413363e-01f, -3.52163732e-01f, 2.18259096e-01f, 6.77294061e-02f, -1.61959514e-01f,
  4.92471069e-01f, 1.73005685e-01f, 3.54671746e-01f, 2.13792130e-01f, -1.03438273e-01f, -3.81860852e-01f, -1.98196143e-01f, 2.38883421e-01f, 4.22553718e-01f, -3.11574280e-01f,
  -3.01665545e-01f, 1.14395440e-01f, 1.58126995e-01f, -2.67043617e-02f, -2.83189297e-01f, 2.24344909e-01f, -2.17985585e-01f, 1.17160259e-02f, 1.92502707e-01f, -2.65827000e-01f,
  1.00763701e-01f, -4.17277753e-01f, -1.04374193e-01f, 2.32251704e-01f, -1.31934300e-01f, 5.50135612e-01f, 3.50160390e-01f, -7.91457761e-03f, -2.78568901e-02f, 1.30553450e-03f,
  4.53472078e-01f, -4.39171880e-01f, 4.66644526e-01f, -6.02645166e-02f, 3.01254243e-02f, 4.56375748e-01f, -7.15475995e-03f, 5.18166959e-01f, 3.52420211e-01f, -1.49961889e-01f,
  3.29237394e-02f, -3.18907499e-01f, -3.48606765e-01f, 2.82700300e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  7.59181529e-02f, -5.24085879e-01f, -2.64703959e-01f, 2.06194684e-01f, 6.33549467e-02f, -1.62532359e-01f, -5.03848016e-01f, -2.97221899e-01f, 3.90208185e-01f, 3.86212878e-02f,
  2.95503587e-01f, 2.92182505e-01f, 1.39270067e-01f, -2.44707391e-01f, -4.81472686e-02f, 2.02051878e-01f, -5.52154407e-02f, -3.05484593e-01f, 1.25034228e-01f, 9.75886639e-03f,
  2.75038451e-01f, 3.05825472e-01f, 2.43225053e-01f, 1.83047906e-01f, -1.07059114e-01f, 9.51954797e-02f, 1.07751757e-01f, 1.23383209e-01f, 1.52666017e-01f, -2.54177123e-01f,
  5.87292388e-02f, 2.24237263e-01f, -1.58019841e-01f, -6.28357172e-01f, -4.57714945e-02f, 4.78505343e-01f, 8.02555978e-02f, -4.98439297e-02f, -4.76399601e-01f, -5.75081781e-02f,
  1.96159646e-01f, -2.52613962e-01f, 3.67823243e-01f, 4.99465525e-01f, -1.92402929e-01f, -1.57825842e-01f, 6.86560646e-02f, 4.05622244e-01f, -2.58570343e-01f, -4.34134573e-01f,
  -2.20197961e-02f, 3.78035158e-02f, 8.06435663e-03f, 2.95220643e-01f, -2.64875352e-01f, -5.12845963e-02f, -3.16892862e-02f, 1.64036945e-01f, 2.46979624e-01f, 6.48755729e-02f,
  4.06739376e-02f, -2.66694665e-01f, 1.05732664e-01f, 3.11062455e-01f, 8.22785422e-02f, 5.50302505e-01f, 6.12998009e-01f, 2.89337456e-01f, -3.88542503e-01f, 1.86146908e-02f,
  2.48202115e-01f, -3.02146256e-01f, -3.29046771e-02f, -7.25495696e-01f, -2.34375536e-01f, 3.17341089e-01f, 5.87219596e-01f, 1.48041859e-01f, 6.73452795e-01f, 5.20348132e-01f,
  -7.12935254e-02f, 2.01662540e-01f, -4.22030747e-01f, -4.53896001e-02f, -5.76156490e-02f, 1.60989359e-01f, 1.67731151e-01f, 7.70297721e-02f, -1.70760259e-01f, -2.07416803e-01f,
  9.97375250e-02f, -2.95500457e-03f, -1.23835757e-01f, 6.53254151e-01f, -1.44267410e-01f, 3.05065542e-01f, -7.18268678e-02f, -4.37111482e-02f, -1.93626225e-01f, -2.81761616e-01f,
  8.09134543e-02f, -1.98000520e-01f, -2.76020378e-01f, -1.47792883e-02f, 2.49100953e-01f, 1.71139538e-01f, 8.07597637e-02f, 4.98362668e-02f, 1.43234104e-01f, 2.46564716e-01f,
  -1.30929828e-01f, 2.42854759e-01f, -1.72235906e-01f, -4.05560404e-01f, -9.42561030e-02f, 3.42079341e-01f, 1.90364674e-01f, 2.94674695e-01f, -2.64869153e-01f, -1.33011848e-01f,
  -9.35492143e-02f, -5.52181378e-02f, 4.11876202e-01f, 4.61667240e-01f, -2.36105323e-02f, -1.92716479e-01f, 1.60215080e-01f, 2.35239610e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  8.42936188e-02f, -5.73320221e-03f, 1.19053006e-01f, 1.74652904e-01f, 3.35016310e-01f, -3.48758064e-02f, 2.69143581e-01f, -6.09102286e-02f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  4.18615699e-01f, 1.52453452e-01f, 6.22933246e-02f, -2.04407021e-01f, -7.33641028e-01f, -6.69350803e-01f, 2.09964871e-01f, -5.53506054e-02f, 2.25615874e-01f, -1.06304266e-01f,
  5.15538394e-01f, 4.35794920e-01f, -4.17642295e-01f, -2.51028776e-01f, -2.90946394e-01f, 2.19522730e-01f, 1.36647895e-01f, -2.60818005e-01f, 5.66149533e-01f, 5.15202060e-02f,
  -5.52257150e-02f, 8.01433809e-03f, -1.81089699e-01f, 6.97169602e-01f, 4.26492631e-01f, 3.68755192e-01f, 8.45583603e-02f, 5.18036112e-02f, -4.81190264e-01f, -3.84553850e-01f,
  1.73385218e-01f, -1.32236093e-01f, -5.94758153e-01f, -3.56997967e-01f, 2.24889278e-01f, 1.58197582e-01f, 2.08428040e-01f, 2.99688160e-01f, -3.19549181e-02f, 3.98195297e-01f,
  -3.79631552e-03f, 3.12355787e-01f, -6.66315155e-03f, -6.10183366e-02f, -1.13913203e-02f, -3.78105700e-01f, -2.56033421e-01f, 5.68604916e-02f, -3.82069916e-01f, -2.06647992e-01f,
  -1.79779738e-01f, -3.73283237e-01f, -2.55580425e-01f, -1.05043702e-01f, 9.25725792e-03f, -2.60060668e-01f, -1.29521683e-01f, -2.53646672e-02f, 1.73751757e-01f, 1.60081297e-01f,
  1.74356416e-01f, 4.06729162e-01f, -1.07281201e-01f, 3.72892618e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  9.01838720e-01f, 5.93357146e-01f, 4.13009435e-01f, 3.48710239e-01f, -6.00738287e-01f, -4.53389108e-01f, 3.02857399e-01f, -3.23697895e-01f, -2.50861675e-01f, -3.24524105e-01f,
  -1.11356415e-01f, -1.59288764e-01f, 5.51291168e-01f, 1.11563288e-01f, 1.52585223e-01f, -2.21009195e-01f, -3.02308828e-01f, 4.59399045e-01f, 7.05723822e-01f, 3.10039818e-01f,
  2.64980465e-01f, 3.95106137e-01f, -3.88479754e-02f, 5.41563511e-01f, -3.11124653e-01f, -1.26509815e-01f, -2.66565770e-01f, 3.05278122e-01f, 3.50005120e-01f, -3.14517945e-01f,
  2.91681979e-02f, -2.47738421e-01f, -4.04652357e-01f, -1.21414170e-01f, 3.60590398e-01f, 2.48971835e-01f, -1.75259784e-01f, 6.30734768e-03f, -5.79467937e-02f, -8.33492726e-02f,
  4.74600822e-01f, 2.89354622e-01f, 6.63468719e-01f, 3.90756965e-01f, 3.30234408e-01f, -2.26888925e-01f, 1.22903079e-01f, 5.01468658e-01f, -5.16475022e-01f, 3.53603423e-01f,
  1.90759286e-01f, 4.27616477e-01f, 4.05637085e-01f, 7.15591192e-01f, 1.42914757e-01f, 1.13957524e-02f, -3.34108442e-01f, 2.31948957e-01f, 1.25865176e-01f, 2.44580060e-01f,
  1.10725272e+00f, -7.33824223e-02f, -2.83655643e-01f, 1.70018613e-01f, 1.89701915e-01f, 4.72558796e-01f, -1.75313354e-01f, 3.59262466e-01f, -2.08763704e-01f, -2.74035394e-01f,
  4.19272363e-01f, -4.73531514e-01f, 2.30028909e-02f, -1.07100122e-01f, -2.18078285e-01f, 5.84771931e-02f, 5.80717802e-01f, -1.87788501e-01f, -2.79214114e-01f, -2.37115517e-01f,
  6.07550800e-01f, 4.02509421e-01f, 2.88926601e-01f, 4.26527679e-01f, 1.43591478e-01f, -4.50174481e-01f, -2.67353892e-01f, 5.02848446e-01f, -1.32720187e-01f, 1.01172701e-01f,
  -2.33762652e-01f, 6.61073178e-02f, -1.58254087e-01f, -2.71562546e-01f, 3.08187306e-01f, 5.74168302e-02f, 2.16818646e-01f, -2.34300122e-01f, -1.14570215e-01f, -2.20953226e-01f,
  1.17512174e-01f, -5.97491451e-02f, -2.05624163e-01f, -1.61415428e-01f, -8.94674063e-02f, -2.07807776e-02f, -9.58628282e-02f, 1.40620872e-01f, 6.42543584e-02f, -1.73966199e-01f,
  -1.66673064e-01f, -2.09785998e-01f, -1.59197927e-01f, 1.41615883e-01f, 3.93302500e-01f, 5.41849911e-01f, -5.84604859e-01f, -5.07207870e-01f, 4.11371857e-01f, -3.62508208e-01f,
  5.40778518e-01f, -1.05281770e-01f, 7.15882599e-01f, 3.33456755e-01f, 5.90949416e-01f, -1.28874229e-02f, 1.72982588e-01f, 5.30575752e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  3.54012847e-01f, 6.54052496e-01f, 2.02101562e-02f, 1.18684791e-01f, 3.19190949e-01f, 5.50196648e-01f, -7.23445192e-02f, 3.12949002e-01f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  4.55810338e-01f, 4.88377750e-01f, 3.67834061e-01f, 4.79654968e-03f, 1.59574628e-01f, 2.51321316e-01f, -8.20237026e-02f, -4.66826767e-01f, 1.16016313e-01f, -1.60367857e-03f,
  -2.87542641e-01f, -5.62049039e-02f, -6.89201653e-02f, 6.83041751e-01f, 1.34130254e-01f, -3.63932550e-01f, -8.23947266e-02f, -2.46573076e-01f, -1.63024336e-01f, -2.57439852e-01f,
  -6.13815010e-01f, -6.99827731e-01f, 1.70767263e-01f, -5.01201510e-01f, 2.99853712e-01f, 1.29727468e-01f, -4.65056390e-01f, 4.41437453e-01f, 1.95775121e-01f, -9.38402340e-02f,
  -1.58443496e-01f, -2.52065748e-01f, -4.77272570e-01f, -1.99341863e-01f, -3.80209744e-01f, -9.16598216e-02f, 2.72486269e-01f, 9.16362479e-02f, -1.25225540e-02f, 3.33587676e-01f,
  -1.15981527e-01f, -4.88398969e-01f, 2.41166621e-01f, 1.20069981e-01f, -1.29050523e-01f, -1.30516574e-01f, -1.48276329e-01f, 3.01954478e-01f, -5.48769347e-02f, -5.14447808e-01f,
  -4.55857038e-01f, -3.22069943e-01f, 5.09510934e-01f, -2.73033708e-01f, -3.72337282e-01f, 4.11786973e-01f, 4.14931953e-01f, -3.73628885e-01f, -1.24018461e-01f, -3.14703882e-01f,
  1.62520528e-01f, -2.08580136e-01f, -1.98819917e-02f, 3.87929022e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -2.81548887e-01f, 2.15253532e-01f, 1.11530073e-01f, 1.79622754e-01f, 3.95171314e-01f, -1.08962525e-02f, 1.61816001e-01f, -6.39798865e-02f, -2.64916599e-01f, -3.44469219e-01f,
  5.72415531e-01f, -2.60942072e-01f, -7.56677911e-02f, -3.71792078e-01f, -1.40357852e-01f, 6.62099898e-01f, -1.96485430e-01f, 6.74177930e-02f, -1.06579252e-01f, -7.09236115e-02f,
  -1.74491361e-01f, -2.20832050e-01f, 1.07090157e-02f, 3.87434401e-02f, 4.74698655e-03f, -9.46728289e-02f, -8.16808939e-02f, -1.61777258e-01f, 1.83498949e-01f, 1.21742435e-01f,
  -1.55948788e-01f, 2.08866775e-01f, -3.90831590e-01f, 1.64695725e-01f, 5.26271701e-01f, 4.31962637e-03f, -6.62976861e-01f, 2.83312984e-02f, 4.93020177e-01f, -6.62276754e-03f,
  -4.41820443e-01f, 9.92419183e-01f, 3.53800416e-01f, 1.11492908e+00f, -9.16917175e-02f, -1.11129075e-01f, -2.17806309e-01f, 3.77970904e-01f, -2.12638810e-01f, -5.14567131e-04f,
  -3.10346454e-01f, 2.10886925e-01f, -2.45479301e-01f, -1.65271774e-01f, 4.38953131e-01f, 3.31024796e-01f, -2.05285341e-01f, 2.55590469e-01f, 1.24316618e-01f, 3.60571951e-01f,
  6.05329350e-02f, -2.96734691e-01f, -8.14910531e-02f, -1.64521202e-01f, -5.81562072e-02f, 4.16416377e-01f, 6.01965249e-01f, 3.92395884e-01f, -7.90444136e-01f, 3.28140110e-01f,
  2.02213481e-01f, -5.56838453e-01f, -5.18699944e-01f, 6.70570910e-01f, -2.30780467e-01f, 3.61429662e-01f, -3.07458848e-01f, 3.61534983e-01f, -1.20014258e-01f, -5.85990667e-01f,
  1.96229629e-02f, -4.66415197e-01f, 2.25723386e-01f, 1.70887753e-01f, 1.14351086e-01f, -8.36976051e-01f, -4.62983608e-01f, 2.94849306e-01f, 8.03253889e-01f, 1.23661041e-01f,
  2.89527982e-01f, 6.11965060e-01f, 9.23634589e-01f, -3.08974624e-01f, -3.18112224e-02f, 7.89971113e-01f, 8.70155096e-01f, 5.52237630e-01f, 4.52402860e-01f, 4.83769476e-01f,
  7.68723667e-01f, 4.00804579e-01f, -3.80696058e-01f, -4.09279853e-01f, 1.11820316e+00f, 4.06911701e-01f, -4.56436217e-01f, -6.66948974e-01f, 2.17889413e-01f, 8.24016750e-01f,
  1.53309211e-01f, 4.11309361e-01f, -1.53543502e-01f, 6.49675071e-01f, 2.00980455e-01f, 2.89610803e-01f, 2.50990838e-01f, 3.07712734e-01f, -1.32030234e-01f, 2.23725289e-01f,
  -3.53290915e-01f, 1.88759658e-02f, 6.97216272e-01f, -2.02581796e-04f, -2.91596472e-01f, 4.40026540e-03f, 1.96522951e-01f, 8.87967288e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  1.57131314e-01f, -1.54703438e-01f, 4.46309857e-02f, -1.16421618e-01f, 5.59332788e-01f, -4.84705577e-03f, 3.21311623e-01f, -7.58528262e-02f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -1.60300136e-01f, -2.77633190e-01f, -6.44690216e-01f, -3.68384331e-01f, -6.76535740e-02f, 7.10483119e-02f, 8.05303678e-02f, 2.83115506e-01f, 4.21888828e-01f, -1.31293416e-01f,
  3.63461703e-01f, 1.20838217e-01f, -2.97842592e-01f, -8.53925496e-02f, -7.25269020e-01f, 7.94165313e-01f, -5.43455333e-02f, 2.08851904e-01f, 2.18122214e-01f, -6.51710629e-01f,
  -6.31752133e-01f, 5.44180512e-01f, 5.73322833e-01f, 2.72130787e-01f, -4.87913311e-01f, 1.74147822e-02f, -5.73378265e-01f, 1.11795828e-01f, -1.32125989e-02f, 7.56978273e-01f,
  -1.86192840e-02f, -6.93507135e-01f, -1.83592170e-01f, 8.94322336e-01f, 3.88236970e-01f, 1.10375512e+00f, 7.20154643e-01f, -3.16987723e-01f, -3.05793166e-01f, 5.35175979e-01f,
  -4.91687000e-01f, -5.45310602e-02f, -5.30234814e-01f, 1.55172288e-01f, -7.44501531e-01f, -2.13884655e-02f, 9.25811768e-01f, 5.69414012e-02f, -9.13301930e-02f, -1.55398577e-01f,
  -7.64146268e-01f, 1.10957757e-01f, -3.51707339e-02f, -8.06161761e-01f, 4.64871861e-02f, -2.09727168e-01f, 2.93687165e-01f, 1.58461139e-01f, -3.24347228e-01f, 1.65801808e-01f,
  -1.49175435e-01f, 6.74228013e-01f, -4.93613362e-01f, 2.36896321e-01f, -3.98312569e-01f, -1.03644156e+00f, -4.75587577e-01f, -3.14472914e-01f, -6.21778309e-01f, -4.81386423e-01f,
  8.79425943e-01f, 7.16195285e-01f, 4.21404302e-01f, -1.67285074e-02f, 1.87746957e-01f, 1.88861877e-01f, -6.62942976e-02f, -1.20301977e-01f, 3.36840779e-01f, 5.87530196e-01f,
  7.66594827e-01f, -4.77536589e-01f, -2.96425432e-01f, 6.49165928e-01f, 1.88705355e-01f, 3.39769304e-01f, -2.11577296e-01f, 6.79819584e-01f, -3.13872606e-01f, -1.16439704e-02f,
  2.18889594e-01f, -1.89742580e-01f, -6.47738278e-01f, 3.35626006e-01f, 3.54423344e-01f, -4.53132331e-01f, -4.52229291e-01f, 6.70401096e-01f, 5.94676808e-02f, -5.39674580e-01f,
  7.02619016e-01f, 3.28538448e-01f, -4.74258900e-01f, -4.83994275e-01f, -2.51731545e-01f, 1.60636723e-01f, 3.49021226e-01f, -3.95222604e-01f, 1.09935760e+00f, -1.00554860e+00f,
  4.86318097e-02f, -1.64737836e-01f, 4.08567846e-01f, -4.84425336e-01f, 1.08814880e-01f, -2.23578587e-01f, 3.70618314e-01f, 7.31863081e-01f, -5.91492772e-01f, -6.10611379e-01f,
  -2.80901372e-01f, -1.87658202e-02f, 3.99211287e-01f, -2.01874465e-01f, 7.05439091e-01f, 2.33594462e-01f, -2.40914598e-01f, 5.05496971e-02f, -1.25754520e-01f, -2.32892811e-01f,
  1.83363721e-01f, 7.29885697e-01f, -8.13157976e-01f, 2.51190037e-01f, -1.45633653e-01f, -1.40487805e-01f, -2.30706692e-01f, -2.01394692e-01f, 4.93847162e-01f, 4.44516659e-01f,
  -1.99463844e-01f, 5.27155042e-01f, -9.74378705e-01f, -3.72155845e-01f, -6.52038813e-01f, 7.54726529e-01f, 6.64538145e-02f, 5.74994922e-01f, 3.98612857e-01f, -3.52164537e-01f,
  -2.29111299e-01f, -8.89200151e-01f, 5.99302165e-02f, 1.36944681e-01f, -6.40210390e-01f, -4.61636856e-02f, 4.18459207e-01f, -8.66574943e-01f, 9.85035896e-01f, -3.34925234e-01f,
  5.12598574e-01f, -3.94137688e-02f, 5.93393981e-01f, -3.01330775e-01f, 1.45598069e-01f, -8.52067709e-01f, 7.14040399e-01f, 9.09117818e-01f, 4.09983069e-01f, 2.99367487e-01f,
  -1.07149696e+00f, 2.01453380e-02f, -4.36494946e-01f, 1.21137187e-01f, 6.92380846e-01f, 2.50644475e-01f, 4.23299998e-01f, 2.80020446e-01f, 3.06035221e-01f, -2.29743525e-01f,
  -1.46657944e-01f, 7.70358324e-01f, -3.21081400e-01f, -2.30874553e-01f, -9.19517577e-02f, -2.17409417e-01f, 9.00506258e-01f, 6.34717464e-01f, 6.43555105e-01f, -8.35072041e-01f,
  -1.14567566e+00f, 3.03935409e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -5.17203510e-01f, -8.58536921e-03f, -1.75910532e-01f, -2.35781267e-01f, -3.88083428e-01f, 3.44949737e-02f, 1.69494465e-01f, 1.90496296e-01f, -3.88222694e-01f, 4.21565652e-01f,
  -3.07033241e-01f, 4.02648538e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    