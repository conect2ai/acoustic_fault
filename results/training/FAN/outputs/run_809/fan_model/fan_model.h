/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.78922260e-01f, -1.56935945e-01f, 5.22481441e-01f, -1.26955693e-03f, 6.65306300e-02f, -2.81330268e-03f, -2.46892646e-01f, -2.24706456e-02f, -8.89695957e-02f, -6.28330484e-02f,
  1.04046062e-01f, -1.77165806e-01f, -6.97566569e-02f, 5.11394115e-03f, -1.04057282e-01f, -2.32740864e-02f, 5.73204458e-02f, 3.63991857e-02f, -1.34501696e-01f, -6.45759776e-02f,
  -1.34543031e-01f, 9.70674083e-02f, 1.76001132e-01f, 1.59228116e-01f, 1.01566024e-01f, -3.28675419e-01f, 1.23811178e-01f, 7.43046030e-02f, 1.38305917e-01f, 2.72135943e-01f,
  -5.76789957e-03f, 1.94671333e-01f, -5.59547134e-02f, -1.62831764e-03f, 1.33992322e-02f, -1.51199743e-01f, -4.00502644e-02f, 2.01702062e-02f, 3.04138195e-02f, 2.74490397e-02f,
  1.08915016e-01f, 1.10070668e-01f, -5.77465296e-02f, -2.92991102e-02f, 4.31470461e-02f, -5.54612651e-02f, 1.29511848e-01f, 1.57461047e-01f, 1.17681809e-02f, 3.29352804e-02f,
  9.97515768e-02f, 1.88394547e-01f, 1.11416943e-01f, 1.30341515e-01f, 4.05848362e-02f, 1.24760672e-01f, 1.26215875e-01f, 2.21183181e-01f, 2.74295181e-01f, 6.22108243e-02f,
  2.94053741e-02f, -9.51449666e-03f, -1.01907263e-02f, -6.16916828e-02f, 5.62210493e-02f, -6.34575933e-02f, 6.56334981e-02f, -4.09703925e-02f, 5.57381939e-03f, -5.00712432e-02f,
  4.49112430e-02f, 2.85306666e-03f, -2.62849778e-02f, -3.33507769e-02f, 5.76737449e-02f, 5.37514500e-02f, 2.20047142e-02f, -2.02372298e-02f, 4.11005393e-02f, -5.15571535e-02f,
  -3.27650979e-02f, 5.63371181e-02f, -3.70323919e-02f, 1.07550565e-02f, 1.72402598e-02f, 4.45963480e-02f, -3.44024263e-02f, -1.03321988e-02f, -5.80776632e-02f, 3.97733636e-02f,
  -3.19100261e-01f, 1.33808479e-01f, -1.58484578e-01f, -2.35070866e-02f, 7.61209475e-03f, 1.75872166e-02f, 1.61521621e-02f, 7.05950186e-02f, 5.09310029e-02f, -5.48316240e-02f,
  -3.70182320e-02f, -6.97983354e-02f, 3.06397043e-02f, 5.07015027e-02f, -5.57483137e-02f, -1.92905515e-02f, -7.29257837e-02f, -8.68452489e-02f, -2.00885925e-02f, -4.02395092e-02f,
  -5.77544533e-02f, -1.88316107e-01f, -4.00642693e-01f, -2.31346756e-01f, -1.48540780e-01f, -2.23193973e-01f, -1.93184152e-01f, -1.85848206e-01f, -3.41266990e-01f, -6.25785708e-01f,
  -9.18564975e-01f, 1.45683229e-01f, 2.84204066e-01f, -2.82956492e-02f, 3.21904659e-01f, -8.25569928e-02f, 1.20413139e-01f, -1.87799428e-02f, 2.32191682e-02f, 1.09384380e-01f,
  -8.10956284e-02f, -1.56933546e-01f, -1.90570563e-01f, -4.87043634e-02f, -2.52654225e-01f, 1.76962972e-01f, 2.07738444e-01f, -1.85115501e-01f, -1.23209432e-01f, -4.36916836e-02f,
  1.63016036e-01f, 2.10489422e-01f, -1.48512676e-01f, -5.56704067e-02f, 2.22093895e-01f, -9.64119285e-02f, 2.54449189e-01f, -1.46372756e-02f, -5.44532686e-02f, 1.36764944e-01f,
  -9.72889066e-02f, -2.57304758e-02f, -8.57148878e-03f, -1.46269500e-02f, 4.61034030e-02f, -9.10106152e-02f, -4.23505791e-02f, 2.93845013e-02f, -2.22610007e-03f, -1.06403725e-02f,
  8.70230421e-02f, 6.06434941e-02f, -1.45011982e-02f, 3.33640128e-02f, 7.25551918e-02f, -3.40012535e-02f, 4.75938916e-02f, -8.89153406e-02f, -8.22067261e-02f, -3.73674855e-02f,
  1.05778299e-01f, 1.84104517e-02f, -1.35530513e-02f, 8.17415342e-02f, -8.59567299e-02f, -1.53284650e-02f, 6.96203038e-02f, 8.21400657e-02f, -7.77109154e-03f, 4.19900641e-02f,
  3.73143591e-02f, -3.29333022e-02f, -2.39069797e-02f, -3.11326905e-04f, 3.71928029e-02f, -1.72341652e-02f, 4.19289395e-02f, -2.21458841e-02f, 2.30226968e-03f, -1.34502538e-02f,
  2.46130899e-02f, -3.11053060e-02f, 3.13497111e-02f, -1.52640687e-02f, 2.21383814e-02f, 1.77317504e-02f, -1.34618813e-02f, 1.09610502e-02f, -4.69914228e-02f, -8.13094061e-03f,
  -1.73263848e-02f, 3.09404340e-02f, 1.51475463e-02f, -2.95788608e-02f, 1.69304814e-02f, 1.54243559e-02f, -1.71185527e-02f, -3.12610380e-02f, -4.05378314e-03f, 1.25476718e-02f,
  -2.34161802e-02f, -1.26989797e-01f, -3.41613754e-03f, 3.68229039e-02f, -5.36721526e-03f, 4.24129106e-02f, 2.07166243e-02f, 2.53977794e-02f, 6.79876190e-03f, -1.60512608e-02f,
  -4.71221134e-02f, -6.69528469e-02f, 9.15595330e-03f, 3.38143632e-02f, -1.34096537e-02f, 5.97461243e-04f, -2.79210787e-03f, -1.76870003e-02f, -5.40004717e-03f, 6.28740191e-02f,
  2.15681233e-02f, -2.05230601e-02f, -1.90602764e-01f, -8.50173309e-02f, 7.14494963e-04f, -1.00553431e-01f, -3.98881845e-02f, -1.96170509e-02f, -1.89668462e-01f, -2.01184843e-02f,
  2.52164036e-01f, -1.92617223e-01f, 2.26086639e-02f, 6.63551129e-03f, -1.43190563e-01f, 1.31009802e-01f, 1.35803118e-01f, 1.75431713e-01f, 1.20323204e-01f, -1.59623474e-02f,
  -2.47393861e-01f, -6.01466782e-02f, -6.41227663e-02f, -1.43640086e-01f, 9.48329195e-02f, -4.12409790e-02f, -5.90389632e-02f, -3.88456583e-02f, 1.81807548e-01f, 1.53806359e-01f,
  1.68579239e-02f, 4.07484397e-02f, 1.29018379e-02f, -3.58303636e-02f, -2.25671139e-02f, 5.32110184e-02f, -6.85615838e-02f, -7.55392015e-02f, -2.44119942e-01f, -1.34464324e-01f,
  -5.77315390e-02f, 4.71181748e-03f, -5.65248588e-03f, -5.36842011e-02f, -7.76616186e-02f, 9.17172283e-02f, 1.46945473e-02f, 1.75602995e-02f, -1.54550718e-02f, 7.35453516e-02f,
  -4.84908670e-02f, -1.02735564e-01f, -8.40597972e-03f, 1.31350588e-02f, 4.72888947e-02f, 7.17599243e-02f, -6.09797426e-02f, 1.38753979e-02f, 1.01611011e-01f, 1.20324828e-01f,
  2.73748003e-02f, -1.04007058e-01f, -1.69895276e-01f, 7.06263781e-02f, 1.19303510e-01f, -1.31020501e-01f, 1.68897342e-02f, 5.99205531e-02f, -1.27027839e-01f, 2.40417123e-02f,
  -1.45790037e-02f, 3.28468950e-03f, -6.29599392e-03f, 7.48516247e-03f, -9.90620721e-03f, -2.30827723e-02f, -8.34052935e-02f, -5.28816925e-03f, -3.31513584e-02f, 3.82706262e-02f,
  -7.71751404e-02f, -6.42332211e-02f, 3.08919027e-02f, -1.70371048e-02f, -7.37501010e-02f, -3.43372785e-02f, -4.05670144e-02f, -2.72469074e-02f, -5.12664840e-02f, 5.00885509e-02f,
  -1.73615888e-02f, -1.57038234e-02f, 2.63705514e-02f, 7.64982700e-02f, 9.12352186e-03f, -3.67767476e-02f, -7.29725137e-03f, 3.14565338e-02f, 7.78214559e-02f, -9.42901708e-03f,
  -2.46562567e-02f, -2.46514663e-01f, -3.21329236e-02f, 6.23668022e-02f, 1.71992145e-02f, -2.97199376e-02f, -9.40358452e-03f, -4.47520539e-02f, -2.51222607e-02f, 3.69722284e-02f,
  2.62750406e-02f, 4.53072228e-02f, 3.23998965e-02f, -9.62576121e-02f, 7.66956881e-02f, 5.98527715e-02f, -5.41127995e-02f, -2.77577285e-02f, -7.03203119e-03f, -3.92955467e-02f,
  2.59018615e-02f, 3.34396586e-02f, 1.15177490e-01f, 5.04129417e-02f, 1.66599900e-02f, 3.80261540e-02f, 4.42439057e-02f, -1.16800442e-02f, 2.02051122e-02f, 1.40746057e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.88479578e-01f, -1.36223629e-01f, 3.19570005e-01f, -2.68336147e-01f, -9.58295353e-03f, 1.59861758e-01f, -1.21994376e-01f, -6.59330934e-02f, -1.60425916e-01f, -1.03973135e-01f,
  -4.31219339e-02f, 5.05017489e-02f, -2.73141954e-02f, 1.48281306e-01f, -5.24695665e-02f, -4.66485545e-02f, -8.46319571e-02f, 2.21255962e-02f, 5.68927117e-02f, 1.88460916e-01f,
  -1.22521333e-01f, -1.99082807e-01f, 1.33655472e-02f, 1.21776119e-01f, 6.81198612e-02f, 1.04648761e-01f, 2.65357047e-02f, 1.87366884e-02f, 1.85821667e-01f, -1.56320445e-02f,
  1.95943028e-01f, -3.07245612e-01f, -2.05473471e-02f, 2.65863501e-02f, 4.21251543e-02f, 1.61371510e-02f, 6.65090308e-02f, -3.45871523e-02f, -3.95023040e-02f, 9.23902318e-02f,
  1.24936979e-02f, -1.19929656e-01f, -6.16435446e-02f, 3.13096605e-02f, -1.10900417e-01f, -2.40478814e-02f, 5.83371297e-02f, 2.78487578e-02f, 1.14483498e-02f, 1.08945705e-01f,
  -2.36146301e-02f, 5.89472726e-02f, 8.77748355e-02f, 7.77747557e-02f, 1.66932009e-02f, 4.68950644e-02f, 1.79595873e-01f, 1.13091938e-01f, 1.05984926e-01f, 1.39272586e-01f,
  -4.59963940e-02f, -4.22834652e-03f, 1.10346237e-02f, 5.81191736e-04f, 3.51392217e-02f, -6.85836449e-02f, -1.35120815e-02f, 1.34223467e-02f, 2.26239804e-02f, -4.97247614e-02f,
  -3.83077599e-02f, -6.59564212e-02f, -4.79916064e-03f, -1.55343618e-02f, 1.52046829e-01f, 6.38908297e-02f, -9.11071226e-02f, 7.50947595e-02f, 7.29055032e-02f, -2.82745250e-02f,
  -2.99584027e-02f, 6.44811708e-03f, -1.71136912e-02f, 4.76894416e-02f, 1.15030982e-01f, 5.26694357e-02f, 2.96856801e-04f, -5.64911515e-02f, 3.17218415e-02f, 4.12608534e-02f,
  5.61983623e-02f, 1.69183955e-01f, -1.30160630e-01f, -7.07045710e-03f, -2.45899949e-02f, 4.39756401e-02f, -1.42864184e-02f, 2.13745106e-02f, -3.98449376e-02f, -1.15902526e-02f,
  9.42016020e-02f, 3.83125357e-02f, -2.28767702e-03f, 4.83997576e-02f, 5.10888621e-02f, 7.83220753e-02f, -3.61920074e-02f, -5.90143204e-02f, 9.30578541e-03f, 7.68025517e-02f,
  6.27501160e-02f, -5.94949946e-02f, -3.69922630e-02f, -2.37732977e-02f, -2.09018160e-02f, -2.38139387e-02f, 7.45606646e-02f, 3.66332196e-02f, 1.01670548e-01f, 2.82572191e-02f,
  2.58092936e-02f, 2.32541263e-01f, -2.60891076e-02f, -1.05137040e-03f, 3.54189239e-02f, 3.72993224e-03f, 1.70545399e-01f, -6.67326972e-02f, -8.62594247e-02f, 1.03929460e-01f,
  5.82723245e-02f, 6.04749881e-02f, 1.24833398e-02f, -6.84876889e-02f, 1.66155603e-02f, 2.14555184e-03f, -8.02139118e-02f, -2.90152095e-02f, 2.65066084e-02f, 5.04106395e-02f,
  1.14648966e-02f, -8.37418735e-02f, 7.29789585e-03f, 2.03741901e-02f, -2.72639990e-02f, -1.45747527e-01f, 2.13336349e-02f, 1.35319814e-01f, 4.17138115e-02f, 3.96764576e-02f,
  -1.14479987e-02f, 9.94204432e-02f, -4.33766991e-02f, 4.64241020e-02f, 7.59567767e-02f, -4.92989719e-02f, 7.68748000e-02f, 2.67363153e-02f, -5.31955138e-02f, 1.58457439e-02f,
  9.11784619e-02f, -8.02232884e-03f, -8.06812793e-02f, -1.56236049e-02f, -2.23172102e-02f, -3.45997177e-02f, -8.04169923e-02f, -5.86714922e-03f, 7.36697912e-02f, -5.04411645e-02f,
  1.80410966e-02f, 5.58256321e-02f, 1.85770690e-02f, -4.66858000e-02f, 5.98179139e-02f, -2.63369512e-02f, -4.66839634e-02f, 2.13808520e-03f, -5.04069589e-02f, -6.57709092e-02f,
  -3.04119885e-01f, -8.46990123e-02f, 1.28453244e-02f, -5.19983210e-02f, -1.05547704e-01f, -1.09024324e-01f, -3.98103409e-02f, -9.60624591e-02f, 8.30632150e-02f, -9.93148088e-02f,
  -8.67966339e-02f, -1.51559860e-01f, 4.28131856e-02f, -3.55368033e-02f, -7.97474831e-02f, 5.78820053e-03f, -3.30419838e-02f, -1.60236791e-01f, 8.07275623e-02f, -1.53086586e-02f,
  -8.70666578e-02f, 7.11276010e-02f, 4.92175147e-02f, 1.46738380e-01f, -1.05688706e-01f, -5.83374314e-02f, -1.05555750e-01f, -2.11206954e-02f, -4.12789546e-02f, 3.96820009e-02f,
  7.28071555e-02f, 8.69211033e-02f, -4.69245166e-02f, 5.11029251e-02f, 1.45243585e-01f, 5.03956005e-02f, -3.06221806e-02f, -1.92533061e-02f, 1.78027563e-02f, 6.95287734e-02f,
  7.83055797e-02f, -1.11754254e-01f, 3.12069636e-02f, -5.45403808e-02f, -5.12075275e-02f, -6.77787587e-02f, -2.79957280e-02f, 1.54559212e-02f, 9.21815559e-02f, 9.94188711e-02f,
  7.18208924e-02f, 9.39574540e-02f, -9.72562507e-02f, 3.18728723e-02f, -3.18627395e-02f, -8.93092602e-02f, 9.78841111e-02f, -1.56201292e-02f, 2.84957718e-02f, -1.67235821e-01f,
  1.59404382e-01f, 7.20997006e-02f, -3.34938690e-02f, 1.05036922e-01f, -4.77427095e-02f, -4.04437073e-02f, 8.45466740e-03f, 3.30368541e-02f, -3.43950763e-02f, 9.36762989e-02f,
  1.88842434e-02f, -9.60897952e-02f, 5.43684959e-02f, -1.31669074e-01f, -3.09325848e-02f, -7.43509233e-02f, -9.09880623e-02f, -4.61253040e-02f, -1.70183927e-01f, -6.02034777e-02f,
  9.71204415e-02f, 4.98477332e-02f, -6.71084300e-02f, 8.41753259e-02f, -4.26890934e-03f, 2.33073272e-02f, 8.73794407e-02f, 1.15713663e-01f, 8.24184418e-02f, 1.03589624e-01f,
  -1.45668043e-02f, -6.42669797e-02f, -4.84363437e-02f, 4.80634859e-03f, 2.77650752e-03f, -2.80034766e-02f, -4.28421311e-02f, 6.56597540e-02f, 1.11000966e-02f, 1.03601091e-01f,
  -4.12066653e-02f, 5.19227376e-03f, -7.28284866e-02f, 2.83505004e-02f, -5.77883013e-02f, -9.32397041e-03f, -5.91328554e-02f, 2.64345352e-02f, -6.95371768e-03f, -3.50060388e-02f,
  7.12889656e-02f, 1.42580364e-02f, 3.62056047e-02f, 8.32960159e-02f, 3.80084850e-02f, -6.00544475e-02f, 8.37915614e-02f, -8.98948908e-02f, 5.41266473e-03f, 8.74877255e-03f,
  4.34476361e-02f, -1.08219748e-02f, 1.39807230e-02f, -7.11674942e-03f, 2.60696113e-02f, -6.38840050e-02f, 5.67103326e-02f, 4.53754887e-02f, -3.91493812e-02f, 5.59570082e-03f,
  1.20412065e-02f, -6.46622255e-02f, 5.11528626e-02f, -2.65874118e-02f, -2.42089462e-02f, 6.15522899e-02f, 8.09001550e-03f, 3.63039225e-03f, 2.57384516e-02f, 2.31346544e-02f,
  -2.98828688e-02f, -1.29876509e-02f, 5.87743409e-02f, -3.14225513e-03f, -8.76787677e-02f, 2.01150607e-02f, 4.05176245e-02f, -4.24300209e-02f, -1.04250528e-01f, 2.60277372e-02f,
  -1.23810582e-02f, -1.64852232e-01f, -3.51335034e-02f, 5.36315516e-02f, -8.99664238e-02f, 5.54962307e-02f, 7.94458836e-02f, -2.63896100e-02f, -2.58098692e-02f, -2.92223971e-02f,
  8.63245782e-03f, -1.47233326e-02f, 2.47787461e-02f, -9.11726952e-02f, -7.27989525e-02f, 1.95701346e-02f, -6.40823692e-02f, -7.96406269e-02f, -4.62335022e-03f, 1.10013958e-03f,
  -4.66465391e-03f, -5.22380881e-02f, -1.93466488e-02f, -1.01913594e-01f, -4.59810980e-02f, -6.83686361e-02f, -9.09096077e-02f, -3.10856430e-03f, -3.73491049e-02f, -3.97685058e-02f,
  -4.95267287e-02f, -2.38948822e-01f, -1.10970691e-01f, -8.63835067e-02f, -4.01203036e-02f, -1.05103932e-01f, -1.93060100e-01f, -1.83793366e-01f, -9.18204933e-02f, -3.37807871e-02f,
  -8.72060880e-02f, -8.77342373e-02f, -9.56452265e-02f, -7.01691881e-02f, -2.79949337e-01f, -2.75592446e-01f, -5.85564449e-02f, -9.52175111e-02f, -2.48316661e-01f, -7.41997287e-02f,
  -1.79351941e-01f, -8.81122723e-02f, -1.36813223e-01f, 2.58707209e-03f, 4.81232367e-02f, 4.79906090e-02f, -1.00136176e-01f, -3.60367261e-02f, -8.70552585e-02f, -7.02116191e-02f,
  -1.42211169e-01f, 7.57639995e-03f, 9.56004187e-02f, 5.85959740e-02f, -8.86349082e-02f, 4.37336750e-02f, -7.78765976e-02f, -4.62760106e-02f, -7.53340721e-02f, 5.19322455e-02f,
  2.95210145e-02f, -8.18785056e-02f, 9.86593738e-02f, 8.62841979e-02f, 3.08412369e-02f, -8.27853009e-02f, -1.22339599e-01f, -1.86659694e-02f, -2.20562753e-04f, 4.60211374e-02f,
  -6.89834207e-02f, 4.03678603e-02f, -7.72140101e-02f, -4.62071933e-02f, 3.97433713e-02f, -1.08822873e-02f, 1.31197097e-02f, 1.39141321e-01f, 8.80372152e-02f, 9.00472105e-02f,
  -2.18969714e-02f, -3.13935205e-02f, 9.26682912e-03f, 1.19168893e-03f, -1.65831205e-02f, 6.91991625e-03f, -8.24849904e-02f, -8.07287842e-02f, 3.55404392e-02f, -4.72856276e-02f,
  -2.99028624e-02f, -8.30576196e-02f, 2.41189376e-02f, 8.02416131e-02f, 9.16691124e-02f, -2.91202068e-02f, -4.44010310e-02f, -5.43160252e-02f, 4.21452224e-02f, 7.38159642e-02f,
  -6.05865866e-02f, 4.95634824e-02f, -5.01804315e-02f, -7.16058984e-02f, 5.39263561e-02f, -7.23465979e-02f, 3.85517739e-02f, 5.03552100e-03f, 7.22652376e-02f, -4.28436650e-03f,
  -2.42685713e-02f, -1.17785364e-01f, 1.73077174e-02f, 1.55933360e-02f, -3.45968083e-03f, 5.34788966e-02f, 5.40429838e-02f, 1.14044163e-03f, -6.04995489e-02f, -6.12991117e-03f,
  -1.97886533e-04f, -4.16964205e-04f, -1.12425506e-01f, -1.39816944e-03f, 4.73630764e-02f, 8.70428905e-02f, -4.95780632e-02f, -8.18788260e-02f, -2.49453634e-02f, -4.89929877e-02f,
  -7.19617233e-02f, -9.72715467e-02f, -4.51472253e-02f, 1.15187541e-02f, -1.60126630e-02f, 8.82693380e-02f, 3.98105271e-02f, 7.89806545e-02f, 2.76684333e-02f, -1.83140382e-01f,
  -3.85957271e-01f, 1.74110472e-01f, -2.02735722e-01f, -1.71926737e-01f, 1.17473975e-01f, 1.90438077e-01f, 2.79219747e-01f, 1.51017830e-01f, 9.84736234e-02f, 8.11699033e-02f,
  1.14797287e-01f, 1.31754071e-01f, 1.07378975e-01f, 2.75173709e-02f, 1.17978185e-01f, 2.12784216e-01f, 7.40115866e-02f, -1.63938217e-02f, -5.98700158e-02f, 3.98652926e-02f,
  2.20355377e-01f, 3.61555703e-02f, -2.16420963e-01f, 5.74079454e-02f, -1.69949941e-02f, -1.72981501e-01f, -2.60855053e-02f, 4.19292748e-02f, 1.62471727e-01f, -1.18745342e-01f,
  -9.75669026e-02f, 1.60543211e-02f, 2.55290400e-02f, -2.20605750e-02f, 1.42414402e-02f, -1.43685549e-01f, -1.14239892e-03f, -8.67150202e-02f, -3.22172269e-02f, -5.14300130e-02f,
  3.51151191e-02f, 6.71900734e-02f, -3.56983654e-02f, -5.86098172e-02f, 7.68341646e-02f, 7.33206421e-02f, 1.92405004e-02f, 1.22663967e-01f, 8.87519568e-02f, 1.35764256e-01f,
  1.66118324e-01f, 3.73480506e-02f, -1.08492501e-01f, 1.51704744e-01f, 1.12575427e-01f, -1.96058769e-02f, -8.17606896e-02f, 3.21368389e-02f, -2.44359747e-02f, -2.32782885e-01f,
  2.76128240e-02f, -3.11739016e-02f, -1.05606511e-01f, -2.02393793e-02f, 3.40115950e-02f, 1.08197378e-02f, 1.31746102e-02f, 8.83994848e-02f, 4.49970849e-02f, -1.20403618e-01f,
  -7.29023591e-02f, 4.85135987e-02f, 2.12887898e-02f, -3.40356939e-02f, 1.46790342e-02f, 7.06626475e-02f, -4.27813381e-02f, -4.12691869e-02f, 1.16912484e-01f, -5.05069084e-03f,
  -8.53242353e-03f, -7.09464494e-03f, -5.48933223e-02f, 5.73145524e-02f, 8.45678300e-02f, -3.65586840e-02f, -2.95317862e-02f, 5.67646325e-02f, 3.05351894e-02f, 6.33952171e-02f,
  -2.70075381e-01f, 1.11819677e-01f, 3.81504931e-02f, 3.13264355e-02f, -7.59303896e-03f, -4.95285429e-02f, -1.39611885e-01f, -8.59630406e-02f, 5.76204062e-02f, -2.54188124e-02f,
  -1.23983726e-01f, -9.55632329e-02f, -1.53880101e-02f, -5.70870414e-02f, -6.62442967e-02f, -1.89944897e-02f, 2.48649698e-02f, 6.89324588e-02f, 8.05407241e-02f, -5.07407300e-02f,
  -1.82847511e-02f, -4.89517711e-02f, -1.19012579e-01f, 9.88064799e-03f, 6.61864877e-02f, 4.14415300e-02f, -1.23343311e-01f, -1.33592501e-01f, -8.29079598e-02f, -2.73639411e-01f,
  -2.16297612e-01f, -3.62306446e-01f, 9.50752273e-02f, 2.07829908e-01f, 2.06291437e-01f, 2.67447382e-01f, 3.05701464e-01f, 1.32988766e-01f, 1.23004027e-01f, 8.53421763e-02f,
  -1.62210524e-01f, 6.98114857e-02f, 7.04136416e-02f, -2.62631774e-02f, 3.55711542e-02f, 2.18535826e-01f, 2.73282200e-01f, 1.26997977e-01f, 2.07761437e-01f, 9.55527797e-02f,
  9.64499861e-02f, 5.43941278e-03f, 4.43233885e-02f, 9.31957364e-02f, 4.79472727e-02f, 1.93563089e-01f, 1.35560796e-01f, -7.09729791e-02f, 6.37590373e-03f, 7.24220946e-02f,
  -1.80580139e-01f, -2.76438117e-01f, 1.57900915e-01f, -5.08888178e-02f, 2.11653803e-02f, 8.88777226e-02f, -4.37626848e-03f, -5.31777181e-02f, -3.46090458e-02f, -6.29272684e-02f,
  1.33467382e-02f, 3.75730284e-02f, 3.64818461e-02f, -7.30177313e-02f, -9.38911885e-02f, -9.37634632e-02f, -8.51944387e-02f, -5.24876174e-03f, 9.93730873e-02f, -6.16534539e-02f,
  3.26415598e-02f, 3.36979479e-02f, 1.30896777e-01f, 1.36460900e-01f, 7.33229294e-02f, 1.08669877e-01f, 8.37661419e-03f, -3.50573212e-02f, 1.20882593e-01f, 1.51303709e-02f,
  4.81160171e-03f, -5.39040891e-03f, -2.21558549e-02f, 2.65048370e-02f, -1.00423731e-02f, -5.92931993e-02f, 1.24236774e-02f, 7.06058554e-03f, 3.90076414e-02f, 2.40840670e-03f,
  -5.65063916e-02f, 1.25102699e-01f, -1.68062225e-02f, 1.45828292e-01f, -8.73284563e-02f, 1.16872061e-02f, 1.90072483e-03f, -8.28612149e-02f, -1.17720068e-02f, -6.31936938e-02f,
  -7.79025704e-02f, 2.81591509e-02f, -4.49988395e-02f, -1.22528650e-01f, -4.55177538e-02f, -7.62865879e-03f, 4.69662575e-03f, -1.31181283e-02f, -4.56321314e-02f, 3.04410420e-02f,
  -6.47692308e-02f, 1.64351434e-01f, 1.41956285e-01f, -3.89519371e-02f, 7.19348863e-02f, -1.65270492e-01f, 4.36399728e-02f, -1.63601652e-01f, -1.71912722e-02f, 4.16898951e-02f,
  -9.55374390e-02f, -3.57364342e-02f, -1.15886882e-01f, 2.00330019e-02f, -1.94044858e-02f, 1.02496678e-02f, -9.02209282e-02f, 9.10515636e-02f, 7.00939298e-02f, 5.15407100e-02f,
  -1.78898394e-04f, 1.87836543e-01f, 1.15055993e-01f, 3.46583091e-02f, 6.23750463e-02f, 1.19701460e-01f, -1.13843046e-02f, 1.06973052e-01f, 5.37484102e-02f, 4.93631177e-02f,
  -5.38995206e-01f, 4.80760522e-02f, 1.17606474e-02f, -5.56592584e-01f, 1.10895686e-01f, 3.48666459e-01f, 1.88531876e-01f, 2.23282710e-01f, 1.65312141e-01f, 3.11504696e-02f,
  2.30676681e-02f, -9.42704976e-02f, -3.78980525e-02f, 2.80922092e-02f, 5.91161549e-02f, 9.45355520e-02f, -2.63444006e-01f, -2.07576215e-01f, -7.21305683e-02f, 1.85609341e-01f,
  -3.90504785e-02f, -3.34592581e-01f, -3.54945838e-01f, -1.69780627e-01f, -2.82814577e-02f, -1.47557184e-01f, -1.03992999e-01f, -1.18914515e-01f, 2.46622905e-01f, -2.46336102e-01f,
  -3.60636250e-03f, -6.24196418e-02f, 9.62176025e-02f, -3.49808782e-02f, -2.95665283e-02f, 5.67370355e-02f, -5.11703305e-02f, -4.24489714e-02f, 7.74616562e-03f, -2.87424102e-02f,
  -1.60294846e-01f, 1.07800297e-01f, -1.37557045e-01f, 2.59845098e-03f, 2.67144497e-02f, 5.65405451e-02f, 2.64030583e-02f, -4.73705679e-02f, 1.60480458e-02f, 7.25360736e-02f,
  5.09913219e-03f, -4.03776951e-02f, -5.59095666e-02f, 6.51059821e-02f, -1.73290297e-02f, -1.32562503e-01f, -6.78087538e-03f, 1.39842853e-01f, 1.99809626e-01f, 9.05927271e-02f,
  1.12245223e-02f, 6.90084323e-02f, 3.59777547e-02f, -3.71446088e-02f, 1.48029542e-02f, 5.51972259e-03f, -7.08731860e-02f, -1.95494890e-02f, -1.25523470e-02f, -6.75504729e-02f,
  -5.63415838e-03f, 7.03734681e-02f, 1.26735624e-02f, -9.61677879e-02f, -6.96481168e-02f, 5.87184504e-02f, -7.58540183e-02f, -1.41030941e-02f, 5.83039634e-02f, 6.03024997e-02f,
  1.84689835e-02f, 3.02494559e-02f, -4.83614998e-03f, 3.86757776e-02f, 3.90251577e-02f, 2.21767346e-03f, -2.77774222e-02f, 6.41464666e-02f, -4.47154455e-02f, -1.31293982e-02f,
  -3.25723439e-01f, 6.94731623e-02f, 4.59387340e-02f, 8.12923536e-03f, -3.47030312e-02f, 4.72572036e-02f, -7.66640678e-02f, 4.60285097e-02f, -1.91812068e-02f, 5.40889725e-02f,
  1.27896974e-02f, -3.97436437e-04f, -3.47868279e-02f, 2.68131401e-02f, -3.17166559e-02f, 8.50999169e-03f, -3.64646204e-02f, -2.50758603e-02f, 1.20219737e-01f, 3.32466979e-03f,
  6.96826801e-02f, 1.22909710e-01f, -6.94563314e-02f, 2.16181111e-02f, 8.10804740e-02f, -2.33673509e-02f, -2.22283602e-02f, -1.10651135e-01f, -4.45947908e-02f, -1.72388092e-01f,
  -2.61015743e-01f, -3.14066440e-01f, -6.67683259e-02f, -1.88434407e-01f, 9.59289894e-02f, -3.18875944e-04f, -3.05999428e-01f, -2.15604417e-02f, -9.89613775e-03f, -2.25459114e-01f,
  -4.29335497e-02f, 3.31112370e-02f, -5.29444851e-02f, 1.68478172e-02f, -1.06461033e-01f, -3.62716705e-01f, -2.12438971e-01f, 5.21326251e-02f, 1.36744380e-01f, 1.81980148e-01f,
  2.75732968e-02f, 2.21555810e-02f, 3.38255130e-02f, 1.46900356e-01f, -1.53856993e-01f, -9.41608846e-02f, -9.68312323e-02f, -2.86747818e-03f, -8.80579576e-02f, -4.05465424e-01f,
  -1.99201196e-01f, 1.05525292e-01f, 8.63082483e-02f, -9.07310322e-02f, 1.93059593e-02f, -3.55424527e-05f, -6.42293915e-02f, -1.41964378e-02f, 6.00742921e-03f, -4.60510068e-02f,
  -2.46187579e-02f, 1.12411283e-01f, -1.85352878e-03f, -3.83893102e-02f, -1.41123831e-02f, -4.60914634e-02f, 7.94119015e-02f, 8.73676389e-02f, -2.75470223e-02f, 6.83415160e-02f,
  7.81362178e-04f, -2.32126582e-02f, -7.29751885e-02f, 1.05729505e-01f, 5.91863990e-02f, 1.04633316e-01f, -2.17880905e-02f, -1.65139902e-02f, 9.11821052e-02f, -2.52926111e-01f,
  1.73667818e-03f, 3.93920839e-02f, -4.24350845e-03f, 2.58698575e-02f, -3.54864560e-02f, -9.27671732e-04f, 2.74218898e-02f, -2.96610827e-03f, -5.02552018e-02f, -5.72214648e-03f,
  6.41086698e-02f, -1.26289884e-02f, -2.68574711e-02f, 2.17760447e-03f, -2.95823421e-02f, -2.19423790e-03f, 1.70878526e-02f, 2.83809472e-03f, -4.49210107e-02f, -1.70111991e-02f,
  -6.18847907e-02f, 1.83341671e-02f, -3.23978849e-02f, 4.98146079e-02f, -3.29633206e-02f, 6.83240499e-03f, 4.25650440e-02f, -3.55851999e-03f, 2.19886433e-02f, -5.01188869e-03f,
  -1.99235022e-01f, 2.07937956e-02f, -2.34083772e-01f, 3.16278115e-02f, -8.35951194e-02f, -1.00290822e-02f, 8.22073082e-04f, 2.20538601e-02f, -1.45254331e-02f, 4.19119326e-03f,
  -1.98218115e-02f, -1.58456862e-02f, 1.10723227e-02f, 1.52926035e-02f, -2.01635305e-02f, -2.38473024e-02f, -8.14588368e-02f, -4.10071649e-02f, -6.16550595e-02f, 8.20983667e-03f,
  -1.33723885e-01f, -1.76408559e-01f, -2.57473379e-01f, -9.07621011e-02f, -9.54181850e-02f, -1.92621067e-01f, -1.10235810e-01f, -1.98368207e-02f, -2.25414127e-01f, -4.77113992e-01f,
  -2.51655102e-01f, 4.14347559e-01f, 2.32260838e-01f, -6.88764378e-02f, 3.03753585e-01f, 2.84127414e-01f, 4.84180093e-01f, 7.63711482e-02f, -1.49647906e-01f, 1.64555982e-01f,
  1.90250114e-01f, -2.65792280e-01f, -2.91928463e-02f, -2.52592210e-02f, 2.58240867e-02f, 2.31189266e-01f, 1.71463847e-01f, -2.95695782e-01f, -3.64976823e-01f, -1.46816403e-01f,
  -2.02726331e-02f, -1.66564584e-01f, -3.37730169e-01f, -1.28526822e-01f, -5.67182107e-03f, -1.93105593e-01f, 3.09458002e-02f, -1.96975488e-02f, 1.63447335e-01f, -9.37852114e-02f,
  -6.23382221e-05f, 1.60533264e-01f, -1.81948096e-01f, -1.45748883e-01f, 1.55534688e-02f, -1.20085841e-02f, -6.60385862e-02f, -8.87059867e-02f, 1.62738468e-02f, -3.77561562e-02f,
  6.01767860e-02f, -6.20546788e-02f, 8.74674693e-03f, 2.87405625e-02f, -1.13101387e-02f, -3.56986299e-02f, -5.22784553e-02f, -7.87787363e-02f, -2.94585945e-03f, -5.73429540e-02f,
  1.78696558e-01f, 1.04518235e-01f, 1.27247602e-01f, 1.01546757e-01f, 6.63660690e-02f, -3.83617803e-02f, 2.37352893e-01f, 8.57784152e-02f, 1.06362872e-01f, -2.63288505e-02f,
  -1.72475055e-02f, 9.38214213e-02f, 8.60398039e-02f, 5.90411760e-02f, 1.80989783e-02f, -8.48260615e-03f, -8.33607744e-03f, -2.80936938e-02f, -7.07082599e-02f, 5.86417578e-02f,
  -1.73042882e-02f, 2.70676892e-02f, -8.34613666e-02f, -3.34679149e-02f, -9.68934000e-02f, 8.02776124e-03f, -3.33901420e-02f, -2.69539803e-02f, -7.27951005e-02f, 2.09968816e-02f,
  -1.74146090e-02f, 6.00679778e-02f, 3.07091251e-02f, 4.51155566e-02f, 2.35764068e-02f, 9.24473703e-02f, -1.05845571e-01f, 6.07517771e-02f, -5.33334762e-02f, -8.71777311e-02f,
  -2.70596951e-01f, 6.83756545e-02f, -1.65262789e-01f, -6.71938136e-02f, 5.81975915e-02f, 3.75944329e-03f, 1.27284825e-02f, 2.90853400e-02f, 7.22147105e-03f, 9.39584821e-02f,
  3.16971317e-02f, 2.34117638e-03f, 9.58474651e-02f, -1.30004868e-01f, -2.53725108e-02f, 3.12345587e-02f, -5.81011139e-02f, -9.32019576e-02f, -5.97519763e-02f, 3.45290639e-02f,
  1.35480110e-02f, -5.06161228e-02f, -2.15787396e-01f, 1.33356834e-02f, -8.74869823e-02f, -1.54407144e-01f, -7.37259611e-02f, -2.00340226e-01f, -6.50395900e-02f, -2.21013561e-01f,
  8.95296875e-03f, -6.57488182e-02f, -1.77757405e-02f, 4.52864505e-02f, 6.47718161e-02f, 1.12513058e-01f, 1.50969505e-01f, 3.38919833e-02f, -8.11180025e-02f, 2.39350945e-02f,
  -1.22346602e-01f, -3.76634821e-02f, -1.55401498e-01f, -1.19601697e-01f, -6.54761642e-02f, 2.47142185e-02f, -7.30006769e-02f, -1.44868800e-02f, 1.28245339e-01f, 1.08728789e-01f,
  -1.89770330e-02f, -4.13046591e-02f, -9.96641666e-02f, -9.08947587e-02f, -1.41050220e-01f, -7.77888000e-02f, -8.78810510e-02f, -1.04582682e-02f, 2.08910760e-02f, -8.65448862e-02f,
  3.12036276e-02f, -6.95475489e-02f, 5.04225269e-02f, -1.12105243e-01f, -3.28336917e-02f, -3.09376866e-02f, -1.55635877e-02f, -1.28222212e-01f, -1.05543420e-01f, -1.13789877e-02f,
  -8.86055157e-02f, 1.02251312e-02f, -6.58252761e-02f, -3.89744440e-04f, 1.16516892e-02f, 5.08922674e-02f, -1.14828125e-01f, -4.68442403e-02f, -7.06450120e-02f, -3.43754292e-02f,
  -1.19626015e-01f, 1.19931495e-03f, 9.59804207e-02f, -4.62503172e-02f, -3.55497152e-02f, 8.59856308e-02f, -6.92696795e-02f, -8.86941403e-02f, 8.91712606e-02f, 1.33315865e-02f,
  -7.17211664e-02f, 1.30266454e-02f, -3.92885692e-02f, -7.67126232e-02f, 2.07710862e-02f, 3.57934944e-02f, 5.45956008e-02f, -8.04401748e-03f, 3.52383405e-03f, 3.02603077e-02f,
  9.23999026e-02f, -2.91593038e-02f, 4.60139140e-02f, 5.95955253e-02f, 3.17356288e-02f, -3.01942173e-02f, 4.85519357e-02f, -5.91055900e-02f, 3.69842760e-02f, -1.30484216e-02f,
  6.46038055e-02f, 5.47826327e-02f, 9.56350937e-02f, -4.84938435e-02f, 6.07993230e-02f, -7.51508623e-02f, 7.06076473e-02f, -4.65747304e-02f, -4.92708273e-02f, -4.93542999e-02f,
  -2.43809987e-02f, 5.45099340e-02f, -8.28436390e-03f, 1.86681543e-02f, 6.28206208e-02f, -5.82926720e-02f, -1.28787667e-01f, 2.18603201e-02f, -8.43297131e-03f, -2.33250055e-02f,
  1.46286851e-02f, -9.42078605e-03f, -8.22118968e-02f, -3.69304642e-02f, 6.99275658e-02f, 1.41796535e-02f, 4.34323698e-02f, -4.70684357e-02f, -5.44244349e-02f, 4.74208640e-03f,
  -2.96210647e-02f, 2.17097446e-01f, 9.12137553e-02f, 6.10078201e-02f, 7.71495029e-02f, 1.15840010e-01f, 7.91249238e-03f, 1.03621557e-02f, 9.01899263e-02f, 1.47085369e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  2.55320147e-02f, -5.52713275e-02f, -4.66573332e-03f, 2.23805918e-03f, 6.81213960e-02f, 1.66041330e-01f, -9.72945243e-02f, -2.90917493e-02f, 5.21593429e-02f, 7.62536749e-02f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  4.00747359e-02f, -4.34244394e-01f, 1.19233929e-01f, -4.70580161e-03f, -4.93532568e-01f, 3.75592232e-01f, -3.20844054e-01f, -3.26819718e-02f, 3.19320112e-01f, 1.20923303e-01f,
  -4.56195325e-02f, 2.52211362e-01f, -5.42582750e-01f, 5.63790388e-02f, 1.38423353e-01f, -1.86692312e-01f, 6.85579300e-01f, -6.61963820e-02f, -1.07670300e-01f, 5.83626091e-01f,
  2.42636278e-01f, -3.49871755e-01f, 9.26913917e-02f, 2.35917628e-01f, -7.32252374e-02f, 1.22323014e-01f, 3.27480823e-01f, 2.89331563e-02f, 1.86955661e-01f, 4.78669018e-01f,
  1.24549001e-01f, -2.86021084e-01f, 1.37056917e-01f, -6.02003813e-01f, 5.07932723e-01f, 4.31809649e-02f, -3.53444107e-02f, -1.96389467e-01f, -2.98512846e-01f, 2.98353791e-01f,
  1.05713442e-01f, 3.80246609e-01f, 1.72176421e-01f, -3.17078650e-01f, -1.49967328e-01f, -2.17566609e-01f, 6.44795358e-01f, -2.03978017e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.01984495e-01f, 7.56287634e-01f, 1.68016642e-01f, 3.84047371e-03f, -3.71845998e-02f, 3.52268666e-01f, 3.12652707e-01f, 2.06895381e-01f, -2.05901146e-01f, 2.63299048e-02f,
  -2.61465400e-01f, 5.23630738e-01f, 3.71832073e-01f, 4.89975721e-01f, -3.89232516e-01f, 1.65904924e-01f, 3.91978383e-01f, -4.78055000e-01f, 2.88904458e-02f, -1.15869954e-01f,
  1.18694417e-01f, -1.74223274e-01f, -1.18020743e-01f, 1.89805645e-02f, -2.04854906e-01f, -1.39855653e-01f, 4.92657810e-01f, 5.38102269e-01f, -2.46958062e-03f, -4.89149243e-02f,
  3.40865046e-01f, -1.38296977e-01f, 1.36204019e-01f, 1.62472993e-01f, 1.68516979e-01f, -1.30134568e-01f, 1.39450178e-01f, 1.97622165e-01f, -2.13953946e-03f, 4.95832376e-02f,
  1.60398781e-01f, 1.44406646e-01f, 2.47405451e-02f, -7.45254904e-02f, 1.12663656e-01f, -2.21592769e-01f, -6.28726631e-02f, 2.56308138e-01f, -3.74423377e-02f, 1.16841182e-01f,
  -7.25075752e-02f, -3.96304965e-01f, -1.58498421e-01f, 3.85804862e-01f, -2.64228672e-01f, -6.76606968e-02f, -1.32575646e-01f, 2.80285358e-01f, 9.62338001e-02f, 6.82740137e-02f,
  5.48023097e-02f, 4.87661660e-01f, -1.29359975e-01f, 1.99327111e-01f, 1.39315680e-01f, 1.08059123e-01f, -2.10484922e-01f, -1.17855191e-01f, 1.87258452e-01f, -1.29192779e-02f,
  -1.51762709e-01f, -1.39086381e-01f, -1.88361004e-01f, -7.12727830e-02f, 1.66638061e-01f, 3.27070117e-01f, -1.26228049e-01f, -1.79319456e-02f, -2.45342344e-01f, 4.45677713e-02f,
  2.30777740e-01f, 5.03168516e-02f, 1.66429758e-01f, 9.45093036e-02f, 2.81322688e-01f, -3.20037276e-01f, -1.43494532e-01f, 2.39865661e-01f, 1.42197579e-01f, 8.89582112e-02f,
  4.26457971e-01f, 7.97643661e-02f, 1.27171800e-01f, -1.25923812e-01f, 3.75345051e-01f, -1.24645703e-01f, -4.33128625e-02f, 6.90499619e-02f, -1.56108230e-01f, 8.11681822e-02f,
  1.37716860e-01f, -2.25625113e-01f, 4.67385530e-01f, -1.15076512e-01f, 8.54065120e-02f, -1.91324905e-01f, -2.68542390e-05f, -1.60079494e-01f, 4.26545918e-01f, 2.62442201e-01f,
  -5.93089424e-02f, -8.02503750e-02f, 3.22020829e-01f, -7.02368677e-01f, 3.69633526e-01f, -6.24913394e-01f, -1.12801552e-01f, 4.93687391e-01f, -3.60542446e-01f, -2.29292363e-01f,
  -1.94290802e-01f, 1.41491041e-01f, 1.43142208e-01f, 5.02674162e-01f, -3.16774622e-02f, -5.99338599e-02f, -1.59831598e-01f, 2.39995569e-01f, 5.65263391e-01f, 6.33092463e-01f,
  -1.18474573e-01f, 4.10877496e-01f, 9.20025110e-02f, -3.70004803e-01f, 5.79159558e-02f, 1.39957368e-02f, 1.71551436e-01f, 3.87522936e-01f, 3.26522142e-01f, -2.24408999e-01f,
  7.34183013e-01f, 6.02839291e-01f, 5.13455093e-01f, 1.23427115e-01f, -2.02021785e-02f, 2.18998402e-01f, 1.35655746e-01f, -3.85723799e-01f, 6.01831973e-02f, -4.05741408e-02f,
  6.60816804e-02f, -3.01347733e-01f, 1.57967106e-01f, -1.09568857e-01f, -2.65101403e-01f, -2.71899290e-02f, 6.07602671e-02f, 8.94963592e-02f, -5.02073914e-02f, -1.57184064e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  3.19199115e-01f, -1.81778315e-02f, 2.76997209e-01f, -7.88186789e-02f, -2.75150649e-02f, -1.66826040e-01f, -1.48678765e-01f, 4.63673472e-01f, 1.93466887e-01f, -2.22774222e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.68938267e-01f, 6.68398499e-01f, -1.63642928e-01f, 1.02968737e-01f, -2.36796990e-01f, -7.15929329e-01f, 5.61250627e-01f, -1.16932295e-01f, -1.19785778e-01f, 2.67753035e-01f,
  -4.93694246e-02f, -3.42569113e-01f, -2.03502506e-01f, 2.42900401e-01f, -4.23865288e-01f, 2.32525483e-01f, -2.32585683e-01f, 3.74984533e-01f, 3.51165272e-02f, 2.65232027e-01f,
  -3.06472927e-01f, 7.20322609e-01f, -8.11051488e-01f, 2.72385955e-01f, -2.61778623e-01f, -3.21754277e-01f, -1.88484967e-01f, 2.07439572e-01f, -1.17669284e-01f, 2.92479545e-01f,
  -3.28808427e-01f, -1.81654364e-01f, -2.91929364e-01f, 4.59594280e-02f, 4.10332829e-01f, -4.11481321e-01f, 2.48433515e-01f, 2.35523820e-01f, 9.08410847e-02f, 1.39663368e-01f,
  1.21319763e-01f, -3.25212657e-01f, -1.43543810e-01f, 2.09571555e-01f, 1.00666337e-01f, -4.69483912e-01f, 4.00140285e-01f, -3.06817982e-02f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  5.13756275e-01f, 1.52750775e-01f, 3.50794196e-01f, 1.31521106e-01f, 8.15103650e-02f, -5.77778459e-01f, 3.35300565e-01f, -3.62133443e-01f, -4.58387583e-02f, 1.45332336e-01f,
  -5.42638265e-02f, 9.59896576e-03f, -2.21209913e-01f, -2.95455456e-01f, 1.80512831e-01f, 1.62342191e-01f, -2.84939464e-02f, -1.46727130e-01f, -9.88011658e-02f, -4.62145656e-01f,
  5.58681488e-01f, 3.47679734e-01f, 1.40132517e-01f, -2.89690882e-01f, 2.64403131e-02f, -5.52227944e-02f, -1.45235002e-01f, -7.23403767e-02f, 2.92912215e-01f, 5.99516705e-02f,
  1.04098666e+00f, -2.34637961e-01f, -5.40495478e-02f, -1.36981741e-01f, 1.18884474e-01f, -3.86528492e-01f, 4.68457282e-01f, -1.69158027e-01f, 3.93269032e-01f, 1.71479940e-01f,
  -9.47640538e-02f, -1.15734600e-01f, 3.04163229e-02f, -1.04221098e-01f, 2.65457273e-01f, 2.00940490e-01f, 6.01516783e-01f, -4.05511931e-02f, -1.77542463e-01f, -5.01626246e-02f,
  1.67352967e-02f, -1.76934600e-01f, 1.91593766e-01f, -2.25233193e-02f, -2.06740409e-01f, 2.91309953e-02f, -1.62131265e-01f, -7.91801289e-02f, 1.41313627e-01f, -1.06900059e-01f,
  1.28117681e-01f, -8.92244428e-02f, -2.10951895e-01f, 1.67461500e-01f, 7.64636934e-01f, 5.68401515e-01f, -4.70632613e-02f, 8.51701438e-01f, 1.34247974e-01f, 8.48256648e-01f,
  -2.88824886e-01f, 4.56996411e-01f, 2.02296674e-01f, 2.95245826e-01f, -2.54828721e-01f, 2.19100684e-01f, -4.87815380e-01f, 6.08988106e-01f, 2.12935477e-01f, -1.17312595e-01f,
  -2.14317963e-01f, -1.15274675e-02f, -1.60034031e-01f, 2.39971653e-01f, -9.62155983e-02f, -1.68616667e-01f, -1.19841255e-01f, 4.42047901e-02f, -1.40680045e-01f, -6.69555068e-02f,
  -9.14707258e-02f, -9.41732712e-03f, 9.44442526e-02f, 3.37970108e-01f, 1.09057650e-01f, -2.43544616e-02f, 3.78044248e-01f, -7.37668946e-02f, 3.22611332e-01f, -1.24706864e-01f,
  4.83212434e-02f, -7.91946232e-01f, 2.55983084e-01f, -4.42055523e-01f, 2.80833274e-01f, 3.75418574e-01f, -2.54841745e-01f, -3.20178479e-01f, 1.26328185e-01f, -1.43347293e-01f,
  3.38193119e-01f, -9.78449732e-02f, -3.86323072e-02f, 8.70134160e-02f, -1.44780442e-01f, -2.42867954e-02f, -6.27089590e-02f, 2.07298756e-01f, -1.83897302e-01f, 1.90585047e-01f,
  -3.86886559e-02f, -2.11022809e-01f, 1.12574466e-01f, 6.49770126e-02f, 1.47144496e-01f, -1.88466668e-01f, -1.27799854e-01f, 9.78231579e-02f, 4.38134998e-01f, -2.82894131e-02f,
  1.06927874e-02f, -8.18529949e-02f, 4.93611276e-01f, -1.25857610e-02f, 1.57582968e-01f, -3.02164048e-01f, -7.91759491e-02f, -2.53673762e-01f, -2.00462997e-01f, -5.49451038e-02f,
  2.15844065e-01f, -4.11398441e-01f, 4.59288985e-01f, -1.94543928e-01f, 5.47103107e-01f, 4.12061065e-01f, 4.59980845e-01f, 1.36391386e-01f, -7.31162906e-01f, -5.87043464e-01f,
  2.23762617e-01f, -1.54496133e-01f, 2.17576981e-01f, 1.31566241e-01f, 1.31964624e-01f, -3.36755723e-01f, -7.23760400e-04f, 5.74393749e-01f, -3.70034605e-01f, 1.69148013e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  2.16007501e-01f, 2.01059580e-01f, 2.12257937e-01f, -8.71782750e-02f, 8.08858156e-01f, -1.26098156e-01f, 3.65138292e-01f, -2.36942291e-01f, 3.13656807e-01f, 2.99950987e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -5.20545542e-01f, -6.76081419e-01f, -4.69206452e-01f, 4.53597605e-01f, 9.44487512e-01f, -6.76119745e-01f, -8.11677128e-02f, -3.48368675e-01f, -1.22613497e-01f, 8.78315885e-03f,
  2.77973503e-01f, -7.41614476e-02f, -1.09491974e-01f, 4.08656746e-02f, -2.37254962e-01f, 1.49233609e-01f, -1.85044691e-01f, 1.18677311e-01f, 4.57290292e-01f, 6.47507131e-01f,
  -8.87834132e-01f, 1.96384937e-01f, 3.59715611e-01f, -3.83122504e-01f, 8.18434954e-02f, -3.16970080e-01f, -1.41785398e-01f, -3.70952813e-03f, 2.16470119e-02f, -1.13619186e-01f,
  -1.96422458e-01f, 6.09641790e-01f, -1.58283673e-02f, 4.95121390e-01f, 3.01678389e-01f, 7.35145509e-01f, 6.68066025e-01f, -1.04930811e-01f, -1.74208522e-01f, -3.63839447e-01f,
  -2.80100346e-01f, 6.11032955e-02f, 4.39331084e-01f, -1.70135275e-02f, -1.86056212e-01f, -2.28152677e-01f, -2.09979281e-01f, 3.91550899e-01f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -1.71114057e-01f, 5.33666387e-02f, -3.34218949e-01f, -8.85017589e-02f, -3.03133756e-01f, 1.76171035e-01f, -2.29310274e-01f, 2.32069939e-01f, -5.03896223e-03f, 1.34359747e-01f,
  1.18389897e-01f, 1.51257426e-01f, -1.28812790e-01f, -1.66006982e-01f, 3.43573391e-01f, 1.87455546e-02f, -6.68753982e-01f, -2.64069259e-01f, -2.65278935e-01f, -2.44162176e-02f,
  -9.23671946e-02f, -2.25800186e-01f, 1.00070462e-01f, 5.63707948e-01f, 3.07501972e-01f, 1.15407921e-01f, 4.57010977e-03f, 4.78451140e-02f, 4.04670179e-01f, -7.83139467e-02f,
  2.20521584e-01f, 3.40448678e-01f, -3.42506289e-01f, -2.10655436e-01f, -3.47843647e-01f, 1.34473100e-01f, -1.66279063e-01f, -3.45652401e-01f, -4.00808378e-04f, 2.70312607e-01f,
  -1.42012835e-02f, -2.53830671e-01f, 1.56751916e-01f, 6.25271723e-02f, 3.17724720e-02f, -2.90894628e-01f, -2.12524340e-01f, 3.98301989e-01f, 8.22324395e-01f, 8.31857979e-01f,
  4.97953415e-01f, -4.69269037e-01f, 5.13399661e-01f, 3.84342790e-01f, 1.58014089e-01f, 3.07129771e-01f, 2.45273542e-02f, -1.23405501e-01f, 1.53360200e+00f, 1.01212576e-01f,
  -1.92433298e-01f, 7.04318807e-02f, 1.09025411e-01f, 1.08975634e-01f, -1.48548558e-01f, -7.48119593e-01f, -8.64393543e-03f, 3.51214677e-01f, -5.68366289e-01f, 2.45414376e-01f,
  -1.33516908e-01f, 3.40543211e-01f, 3.73628378e-01f, 1.67705521e-01f, -2.73354679e-01f, -2.28096768e-01f, 1.11300699e-01f, 6.34056851e-02f, 2.07147509e-01f, 1.74635202e-01f,
  9.56135929e-01f, 1.26895487e-01f, 5.97608574e-02f, -6.19611084e-01f, -5.07415056e-01f, 6.99434698e-01f, 4.14561212e-01f, 3.64928320e-02f, -1.32588714e-01f, -9.24862456e-04f,
  2.92902231e-01f, -2.71747977e-01f, -7.08172619e-02f, -2.60686129e-01f, 5.41304350e-01f, -1.59528926e-01f, 7.21305907e-01f, 8.84679198e-01f, 5.76905549e-01f, 9.34624791e-01f,
  -1.05128074e+00f, 3.68704468e-01f, 7.21411169e-01f, -2.16064021e-01f, -1.51199669e-01f, 1.46412134e-01f, -5.54785073e-01f, -3.41810495e-01f, 8.61133039e-01f, -1.10907726e-01f,
  3.11712563e-01f, 1.93510443e-01f, -3.10098499e-01f, 7.77048111e-01f, 3.97895813e-01f, 8.76723409e-01f, 7.52442032e-02f, -5.21140218e-01f, 3.24171215e-01f, -4.24830496e-01f,
  -4.00851548e-01f, -2.86830068e-01f, 3.43163550e-01f, 1.47536516e-01f, 3.99922818e-01f, -2.53947591e-03f, -3.86408865e-01f, 9.69216287e-01f, -6.25430167e-01f, 2.99976498e-01f,
  -4.08913255e-01f, 2.10306793e-01f, -1.72745883e-01f, -2.65800595e-01f, 5.49109913e-02f, 5.76813281e-01f, 3.02659810e-01f, -1.35131359e-01f, -1.49203241e-01f, -1.79430991e-01f,
  4.75571910e-03f, 5.42437509e-02f, -6.52373657e-02f, 1.69792071e-01f, -9.34172794e-02f, -8.85652065e-01f, -1.96515307e-01f, -3.93292487e-01f, 2.66411882e-02f, 8.03992897e-02f,
  5.10766029e-01f, 6.18704259e-01f, 6.30774617e-01f, 7.67675862e-02f, -2.09773093e-01f, 1.80928767e-01f, 6.15563035e-01f, -1.71671733e-01f, 3.66100192e-01f, -1.47577927e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  2.84084469e-01f, -1.44107461e-01f, -4.85850386e-02f, 2.54262745e-01f, 5.23350686e-02f, 1.57258451e-01f, 6.61989152e-01f, 4.31555152e-01f, 2.32875183e-01f, -1.12665445e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  4.09640551e-01f, -3.11029196e-01f, -2.06512958e-01f, -1.78261533e-01f, -4.45216566e-01f, -5.83527684e-01f, -3.11634362e-01f, 4.87347990e-01f, -2.00937971e-01f, 1.04434155e-01f,
  -3.18709403e-01f, -2.19872087e-01f, 4.06423032e-01f, -2.81998038e-01f, 1.19713776e-01f, 5.73864102e-01f, -4.06352639e-01f, 4.46165144e-01f, -6.40235603e-01f, 8.24312925e-01f,
  4.79270995e-01f, 1.41564414e-01f, 7.53622316e-03f, 5.07740900e-02f, 3.66266854e-02f, 5.18553615e-01f, -2.19839379e-01f, -3.23031306e-01f, -7.46996939e-01f, 7.03402519e-01f,
  5.59983850e-02f, -7.09657520e-02f, -2.79493272e-01f, 6.39629886e-02f, -2.08218440e-01f, -5.50999224e-01f, 8.02108109e-01f, -8.88253868e-01f, -1.94058836e-01f, -1.14082351e-01f,
  1.52923003e-01f, -5.80708921e-01f, 4.91763979e-01f, 3.67215782e-01f, 7.33052313e-01f, -5.40653586e-01f, -4.57561970e-01f, 4.78683203e-01f, -3.61625493e-01f, -1.85929984e-01f,
  -1.37028202e-01f, -4.74923640e-01f, -5.00211775e-01f, -3.61455709e-01f, 2.74485111e-01f, 7.04612613e-01f, 2.30817258e-01f, -7.78926373e-01f, 5.77253580e-01f, -7.70834088e-01f,
  -4.64045495e-01f, -2.62434483e-01f, 6.93054438e-01f, 3.87923777e-01f, -4.33408439e-01f, -4.25929666e-01f, -4.95285958e-01f, -3.50501761e-02f, -5.70318401e-01f, -1.56192780e-01f,
  7.16209412e-02f, 1.98144302e-01f, -1.26166895e-01f, 7.45321112e-03f, 1.93482637e-01f, 4.01374638e-01f, -7.99086571e-01f, -3.19071382e-01f, -3.80101979e-01f, 9.24197316e-01f,
  4.36603695e-01f, -1.20086901e-01f, -7.60203540e-01f, 6.29824400e-01f, 4.21618491e-01f, 4.36070323e-01f, -2.85024494e-01f, -4.06826705e-01f, -2.23745704e-02f, -8.96325335e-02f,
  -2.77555645e-01f, -2.76575893e-01f, 5.05805612e-01f, 9.49410498e-01f, -2.74957240e-01f, -2.84217715e-01f, -1.88104108e-01f, 7.20468014e-02f, 8.17893386e-01f, -9.85158741e-01f,
  8.19464266e-01f, 4.95651066e-01f, 1.32356390e-01f, -3.15454423e-01f, -2.12129697e-01f, 2.82337725e-01f, -3.05733860e-01f, 2.37067565e-01f, 8.41337085e-01f, 1.51129022e-01f,
  -2.28653789e-01f, -7.55248129e-01f, 3.08467746e-01f, 2.94735134e-01f, -3.45866829e-01f, 9.38121319e-01f, -7.81692564e-01f, 9.54635799e-01f, -3.24935883e-01f, -1.46985620e-01f,
  -1.31722629e-01f, 9.46338415e-01f, -4.65220064e-02f, -9.78196785e-02f, -7.50591397e-01f, -4.58659679e-01f, -4.59297150e-01f, -2.28247583e-01f, 5.07279992e-01f, -5.97974837e-01f,
  3.62116694e-01f, 6.83208227e-01f, 2.92200614e-02f, 1.01497376e+00f, -3.90067473e-02f, 4.64536637e-01f, 5.82637846e-01f, -6.20936871e-01f, -2.03309488e-02f, -3.49072009e-01f,
  -1.09469496e-01f, 7.89525509e-01f, 2.80360520e-01f, -3.33443373e-01f, -7.51195908e-01f, 9.16287661e-01f, 7.00694382e-01f, 1.06882200e-01f, 2.56620586e-01f, -9.87998366e-01f,
  -1.18078604e-01f, -2.14101359e-01f, 7.79809728e-02f, 3.20694238e-01f, -7.84771070e-02f, 7.17114747e-01f, 7.77510047e-01f, -7.03037441e-01f, -1.57629475e-01f, -3.55509907e-01f,
  5.04336536e-01f, -5.96826196e-01f, 6.72493756e-01f, -5.10460317e-01f, 7.54809007e-02f, 2.31844082e-01f, 3.63316038e-03f, 2.39228860e-01f, -2.53572345e-01f, -1.06967843e+00f,
  4.83921140e-01f, -4.55129236e-01f, 1.14849949e+00f, 1.36575490e-01f, 5.25931194e-02f, -7.82495067e-02f, -5.92357993e-01f, 4.34740275e-01f, 5.28526902e-01f, -6.14403427e-01f,
  -7.64821410e-01f, -2.76700854e-01f, 3.32005411e-01f, -7.87539349e-04f, -2.31192112e-01f, 6.70145154e-01f, -2.97223836e-01f, 5.54127514e-01f, -4.78727758e-01f, -4.65754122e-01f,
  -3.63610648e-02f, -1.82379350e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.18716136e-01f, -7.51414150e-02f, 1.49376199e-01f, 2.12257177e-01f, 1.37533262e-01f, 1.46472916e-01f, 9.46652964e-02f, 3.05760931e-02f, 6.90707415e-02f, 2.16242820e-01f,
  1.27817303e-01f, 1.21229231e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    