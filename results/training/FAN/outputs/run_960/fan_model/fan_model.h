/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.89362633e-01f, 3.24668109e-01f, 3.11553389e-01f, -1.51991531e-01f, 9.79536176e-02f, 2.44985208e-01f, 4.20714557e-01f, 3.33092362e-02f, -1.85625821e-01f, 1.28964007e-01f,
  -8.93103629e-02f, -3.82558793e-01f, -3.11548114e-01f, -1.95368454e-01f, -1.04141414e-01f, 3.79159421e-01f, 4.16428566e-01f, -6.27774447e-02f, -1.20673165e-01f, 1.45451605e-01f,
  1.21240437e-01f, 1.95203826e-01f, -7.60146454e-02f, 1.00125214e-02f, 1.15422875e-01f, -1.61041275e-01f, 2.26583794e-01f, 7.58558214e-02f, 9.94479731e-02f, 3.55143338e-01f,
  6.77019730e-02f, -1.13281235e-01f, -2.77387053e-02f, -1.23287559e-01f, 5.23721687e-02f, 9.80927423e-03f, -1.67661197e-02f, 4.20806482e-02f, -4.83609550e-02f, 1.01510949e-01f,
  -4.99299392e-02f, -3.40426192e-02f, -3.80753428e-02f, 8.09663441e-04f, 2.04772428e-02f, -5.34909405e-02f, 3.36017907e-02f, -6.72690123e-02f, -3.88055254e-04f, -2.40006857e-02f,
  5.91797419e-02f, 9.59698930e-02f, -2.83646788e-02f, 8.97148252e-03f, -8.64597782e-02f, -1.46517664e-01f, -1.26663465e-02f, -8.76116082e-02f, 6.34073466e-03f, -1.20653454e-02f,
  3.59981996e-03f, -5.46652563e-02f, 4.88663279e-03f, -4.26261462e-02f, 3.95064475e-03f, -3.22221555e-02f, -1.18456492e-02f, 3.70798074e-02f, 3.11477929e-02f, -3.03655174e-02f,
  3.51208411e-02f, 8.22861865e-02f, 6.58562183e-02f, 2.04032641e-02f, 6.45272508e-02f, 5.35953231e-02f, 3.74473743e-02f, 2.57479437e-02f, -9.09905974e-03f, 4.98196296e-02f,
  -1.08591029e-02f, 1.91063192e-02f, 6.45699725e-02f, 5.35066389e-02f, 9.01279226e-02f, -2.25939658e-02f, -2.80318540e-02f, 7.37385999e-04f, 5.08526787e-02f, 3.94879840e-02f,
  -6.18315935e-02f, -6.69727102e-02f, -2.16977652e-02f, 1.31791399e-03f, 4.37822454e-02f, -1.70755330e-02f, -7.14747831e-02f, 2.77505163e-02f, 4.49262969e-02f, 6.30358160e-02f,
  -3.15605253e-02f, -1.03534080e-01f, -8.02408718e-03f, 1.40054747e-02f, -2.87174410e-03f, -3.09355296e-02f, 2.44190283e-02f, -4.24498096e-02f, 2.85919998e-02f, 4.04533111e-02f,
  8.82355645e-02f, -3.53067741e-02f, -5.43982908e-02f, 2.59054694e-02f, -4.34613898e-02f, -3.26053835e-02f, 1.87796298e-02f, 3.50371040e-02f, -5.98984659e-02f, 1.25380397e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.28115988e-01f, -2.45498329e-01f, 7.71669075e-02f, 2.94356674e-01f, 9.63661134e-01f, 1.53336674e-01f, -7.89711833e-01f, -4.21933055e-01f, 2.08346933e-01f, -6.48212135e-02f,
  5.95820069e-01f, 6.15148604e-01f, 3.27457249e-01f, 1.26392663e-01f, -6.43833458e-01f, -5.39223611e-01f, -2.77586222e-01f, -3.59854162e-01f, -3.53606373e-01f, 5.32290749e-02f,
  3.05727482e-01f, -1.15057684e-01f, -5.16252756e-01f, -3.48538190e-01f, 2.44041190e-01f, 3.67249995e-01f, -1.59864277e-02f, 4.99000698e-02f, 1.15361996e-01f, 6.85250163e-02f,
  -8.92131007e-04f, -3.93889174e-02f, 4.68104593e-02f, 3.65980655e-01f, 4.67487365e-01f, -2.73927182e-01f, -2.72054106e-01f, -1.13954671e-01f, -4.10983860e-02f, -1.85175344e-01f,
  3.50408792e-01f, 3.40091474e-02f, 2.09955335e-01f, -5.03977276e-02f, -2.34376833e-01f, -2.63976753e-01f, -2.86243111e-01f, -5.71440399e-01f, -4.86180693e-01f, -1.26169220e-01f,
  2.97990233e-01f, 4.63493675e-01f, -2.89962620e-01f, -4.40113068e-01f, -5.88618338e-01f, 9.26857665e-02f, -2.58141905e-01f, -4.18727219e-01f, -8.65777552e-01f, -1.03454387e+00f,
  2.74948440e-02f, 1.13480330e-01f, 1.54950902e-01f, -5.80563471e-02f, -1.41365066e-01f, 1.38649762e-01f, 9.03581530e-02f, 5.73592670e-02f, 1.31977722e-01f, -1.95434242e-01f,
  1.25506639e-01f, 1.29119858e-01f, 1.14025302e-01f, -1.18632458e-01f, 2.00448837e-02f, -1.24015220e-01f, 5.99889904e-02f, -3.80378336e-01f, 3.29626724e-02f, -7.06251785e-02f,
  -1.18915271e-02f, -1.05749175e-01f, -3.67211215e-02f, -3.15784186e-01f, 4.53762934e-02f, -8.89591947e-02f, -1.14637777e-01f, 8.66491422e-02f, 1.45789916e-02f, -1.21738724e-01f,
  -1.25055566e-01f, 3.13044921e-03f, 9.34234262e-02f, -1.45701453e-01f, 1.02816463e-01f, 1.46263942e-01f, 1.27553746e-01f, 2.16220543e-02f, 2.58133024e-01f, -2.22090036e-02f,
  -6.95236325e-02f, -2.33763188e-01f, -5.39595298e-02f, -1.86847657e-01f, -1.55668259e-01f, -4.26838771e-02f, -1.00769982e-01f, 1.55995429e-01f, -2.89669652e-02f, 4.65033911e-02f,
  -2.14427739e-01f, -5.28856218e-01f, -3.43164057e-01f, -3.11412752e-01f, -1.73221692e-01f, -1.36076333e-02f, -5.22759378e-01f, -2.80265808e-01f, -6.39108539e-01f, -1.11397707e+00f,
  -5.44354141e-01f, -2.02998072e-02f, 5.59520602e-01f, -3.10662866e-01f, -7.01205194e-01f, -8.28163266e-01f, -9.58757102e-01f, -6.16558194e-01f, -3.15920293e-01f, -4.86635298e-01f,
  -1.23893149e-01f, 1.74165174e-01f, 8.70620966e-01f, 2.68041253e-01f, 6.66466206e-02f, -2.30067372e-01f, 9.72683132e-02f, 1.56697512e-01f, -5.20231724e-01f, -1.28577507e+00f,
  -9.97006595e-01f, -3.25807869e-01f, -8.59780163e-02f, 1.62776224e-02f, -2.38445073e-01f, 7.93778896e-02f, 6.06735528e-01f, -1.01671383e-01f, -1.29303500e-01f, -7.02732429e-02f,
  -2.30130889e-02f, -2.61834741e-01f, 1.57274082e-01f, -8.54262244e-03f, 1.14957206e-01f, -3.35308194e-01f, -1.54626384e-01f, 2.42237255e-01f, 3.72899212e-02f, -5.17102778e-02f,
  -1.37068070e-02f, -4.08401430e-01f, -1.11521725e-02f, -1.95731014e-01f, -3.75579089e-01f, -5.20714104e-01f, -2.37555802e-02f, -1.51906461e-01f, 2.71446884e-01f, -8.53086337e-02f,
  -5.29403806e-01f, -4.11665529e-01f, 2.58613795e-01f, 2.13373899e-01f, 9.04460624e-02f, 3.15432608e-01f, 7.35876039e-02f, -1.86356738e-01f, 2.71443278e-01f, 6.40636217e-03f,
  -1.95272695e-02f, 3.14340264e-01f, -1.52999595e-01f, -1.39965594e-01f, -2.61734217e-01f, 1.67767763e-01f, 7.63781071e-02f, -2.26658821e-01f, -1.08415455e-01f, 9.99560207e-02f,
  -5.44654243e-02f, 5.44048958e-02f, 9.87056494e-02f, 1.27732262e-01f, 5.54014593e-02f, -7.42303208e-02f, 8.71150102e-03f, 1.26801629e-03f, 4.00370993e-02f, -1.36090949e-01f,
  5.34156449e-02f, -9.13480893e-02f, 2.16070831e-01f, 1.87400542e-02f, -1.67813957e-01f, 1.81222092e-02f, 1.77041180e-02f, -3.51639261e-04f, 4.34710346e-02f, -2.21153304e-01f,
  5.75173974e-01f, 4.87502038e-01f, -1.00158192e-01f, 6.83730235e-03f, -1.28575593e-01f, 2.47050207e-02f, 2.70084530e-01f, -1.38966605e-01f, 2.52507657e-01f, -1.56302750e-01f,
  -2.24298701e-01f, 1.11598849e-01f, 3.10395718e-01f, 6.02218024e-02f, -2.49997929e-01f, -2.17491776e-01f, -3.56372803e-01f, -2.83532709e-01f, -1.67065650e-01f, -1.32804856e-01f,
  -4.44046222e-02f, -3.25104654e-01f, 2.06246809e-03f, 3.71029317e-01f, -1.63751155e-01f, 1.09060459e-01f, 2.65283316e-01f, 5.37549406e-02f, 2.57286429e-01f, -3.21282521e-02f,
  -2.30387345e-01f, 4.07143205e-01f, -1.60823748e-01f, 6.10525429e-01f, 6.55156136e-01f, 1.63029686e-01f, 4.65416275e-02f, -1.58989221e-01f, -1.02764256e-02f, 1.43186301e-01f,
  2.88693637e-01f, 4.04235989e-01f, 4.56252426e-01f, 3.48397881e-01f, -5.18739223e-02f, -1.53005153e-01f, 9.59084183e-02f, 1.25971496e-01f, -1.63370129e-02f, 1.82254985e-01f,
  6.13683522e-01f, 4.02053535e-01f, 2.50231661e-02f, 6.49506971e-02f, 4.37154800e-01f, 6.99502945e-01f, 3.56606126e-01f, 6.09122992e-01f, 3.63568217e-01f, 5.74088395e-01f,
  3.31006408e-01f, -2.40174830e-01f, -1.13776945e-01f, 2.91425914e-01f, 1.26422092e-01f, -2.03391299e-01f, -2.17583448e-01f, -2.48798549e-01f, -2.37560887e-02f, -2.47006014e-01f,
  1.75575808e-01f, -3.42744328e-02f, 3.74838203e-01f, -9.49618872e-03f, -1.45278737e-01f, -2.75973320e-01f, -4.52409714e-01f, -5.86155653e-01f, -2.28088707e-01f, -3.45785618e-01f,
  5.63541651e-01f, 3.78472209e-01f, -2.09328815e-01f, -3.13881546e-01f, -1.10262975e-01f, 3.61053556e-01f, -1.31754220e-01f, 6.42257854e-02f, -2.95717001e-01f, -4.05914128e-01f,
  1.47063911e-01f, -1.36015043e-01f, 1.16941519e-02f, -2.10730106e-01f, 4.96556610e-02f, 2.49735061e-02f, 6.05885275e-02f, 1.03144150e-03f, -1.78642541e-01f, -1.47128984e-01f,
  1.66015495e-02f, -2.02504858e-01f, -3.89582545e-01f, -5.92257641e-02f, 1.33378893e-01f, 6.87073991e-02f, 7.99263828e-03f, -1.94060374e-02f, -6.05214424e-02f, -2.27546573e-01f,
  -4.48343419e-02f, -6.53283671e-02f, -1.12333439e-01f, -2.01620445e-01f, -1.86779484e-01f, 2.60214303e-02f, -5.95877953e-02f, 2.16176622e-02f, 1.95525199e-01f, 4.96288165e-02f,
  1.98199242e-01f, 5.21426983e-02f, -3.64620537e-01f, -2.04024985e-01f, -1.68790370e-02f, -3.27908508e-02f, 1.61336631e-01f, -2.03784667e-02f, 2.16915354e-01f, -8.58198702e-02f,
  -2.53043771e-02f, -8.20121765e-02f, -2.08339076e-02f, -2.15371400e-01f, -1.63889546e-02f, -1.83131173e-01f, 5.98259550e-03f, 9.78481695e-02f, -3.90634656e-01f, -5.39462268e-01f,
  -1.80807635e-01f, -4.45518762e-01f, -2.35408664e-01f, -3.36690634e-01f, -1.94114491e-01f, -5.15659191e-02f, -2.03051150e-01f, -2.59920359e-01f, -4.15783614e-01f, -5.68726718e-01f,
  -1.79933921e-01f, 5.12967527e-01f, -9.37838972e-01f, -9.91013572e-02f, -4.02692586e-01f, -3.71532172e-01f, 3.65172386e-01f, -1.25497550e-01f, -7.30241090e-02f, 3.08545649e-01f,
  9.20003429e-02f, 2.76329666e-01f, 5.44768393e-01f, 4.28062290e-01f, 4.81353670e-01f, 5.34000397e-01f, 3.96587729e-01f, -6.72210008e-02f, -6.75389707e-01f, -6.32190049e-01f,
  2.40180284e-01f, 1.34196691e-02f, -2.54614186e-02f, -4.09469344e-02f, -2.84562796e-01f, -2.79431287e-02f, -3.55248200e-03f, -4.13545728e-01f, -4.71203402e-02f, -8.46757665e-02f,
  -3.89304578e-01f, -5.10428309e-01f, 9.73817334e-02f, 2.77107120e-01f, -2.41040856e-01f, -2.29645427e-03f, -1.05132312e-01f, -3.22827190e-01f, -7.93460160e-02f, -1.73816711e-01f,
  -2.18132943e-01f, -1.19644634e-01f, 1.54499739e-01f, 2.07066890e-02f, -2.57169068e-01f, -8.16198736e-02f, -4.31097448e-02f, -3.18318427e-01f, -3.62063311e-02f, -3.40000331e-01f,
  4.15143371e-01f, -5.78041315e-01f, -5.96701324e-01f, -2.33411446e-01f, -4.41878885e-01f, -4.64881696e-02f, -8.42278063e-01f, -1.05471969e+00f, -4.42756772e-01f, -5.28651297e-01f,
  -2.46080887e-02f, -5.20167453e-03f, 4.23279684e-03f, 3.59264389e-02f, 3.18436503e-01f, -6.31913841e-02f, -3.42836305e-02f, 1.21788055e-01f, 5.57553917e-02f, -5.48779480e-02f,
  1.13414712e-02f, 1.33650769e-02f, -2.04783559e-01f, 2.18323261e-01f, 1.13437757e-01f, -1.54094314e-02f, 2.35768761e-02f, 1.30591646e-01f, 8.43953639e-02f, 7.15229958e-02f,
  -4.61607911e-02f, -1.21486522e-02f, 3.78434472e-02f, 6.53211921e-02f, -1.09240592e-01f, 1.14885800e-01f, 9.13779289e-02f, -5.57855181e-02f, 8.41270164e-02f, 1.19267978e-01f,
  6.32891953e-01f, 3.60865265e-01f, 5.28412051e-02f, 5.79331145e-02f, -7.52292424e-02f, -1.79998323e-01f, 5.40541895e-02f, 1.92484614e-02f, -4.02356572e-02f, -8.43283460e-02f,
  -2.50994623e-01f, 1.48283377e-01f, 2.80910403e-01f, 2.67504510e-02f, -9.01925117e-02f, 1.11322314e-01f, 4.03135717e-01f, 1.60713971e-01f, 2.37073362e-01f, -2.88319498e-01f,
  3.59679282e-01f, 2.73485422e-01f, 4.30121720e-01f, 3.15783918e-01f, -3.07100676e-02f, 9.97739434e-02f, -6.26383349e-02f, -2.55304724e-01f, 9.76345316e-02f, 6.49634004e-01f,
  5.24963021e-01f, 7.77363181e-01f, 4.11600262e-01f, 4.10198838e-01f, 1.62846744e-01f, 3.86474222e-01f, 5.92587709e-01f, 5.12559533e-01f, 3.79063994e-01f, 2.65351564e-01f,
  2.25163266e-01f, 1.64612129e-01f, 2.91921288e-01f, 3.13306808e-01f, 3.86406630e-01f, 4.79643643e-01f, 5.40699780e-01f, 2.03169391e-01f, -2.57628169e-02f, 1.89035714e-01f,
  1.63681537e-01f, 6.31183386e-02f, 6.96018431e-03f, 1.86819717e-01f, 2.37272933e-01f, 6.12487793e-02f, 2.36653164e-01f, 1.66542038e-01f, 1.97897136e-01f, 3.56569618e-01f,
  -1.63829036e-03f, 4.29075539e-01f, -2.83232890e-02f, -6.80769607e-02f, -2.38460273e-01f, -4.29898500e-02f, -1.26543105e-01f, -2.01411366e-01f, -2.28421435e-01f, -2.91163139e-02f,
  -2.21025318e-01f, -2.00587213e-01f, -2.03197710e-02f, -1.88452035e-01f, -1.52690455e-01f, -2.75905848e-01f, -1.19308347e-03f, 1.27323225e-01f, 2.06103593e-01f, 9.59451795e-02f,
  -6.57779351e-02f, -1.26955703e-01f, -7.51881599e-02f, 1.09601907e-01f, 2.00714737e-01f, -1.39779329e-01f, -1.01874419e-01f, -3.75401182e-03f, -4.42583933e-02f, 1.93704307e-01f,
  2.61278562e-02f, 1.81749210e-01f, 1.11864045e-01f, 2.12353364e-01f, 2.82121240e-03f, -4.38424535e-02f, -1.00989833e-01f, -9.37079117e-02f, 2.17874236e-02f, -3.25225368e-02f,
  -1.06652200e-01f, 3.83773334e-02f, 1.07408144e-01f, -7.65004158e-02f, -5.68261147e-02f, -5.83634665e-03f, -3.27374339e-02f, -1.31130507e-02f, -1.29573360e-01f, -3.53661925e-02f,
  -3.76341082e-02f, 2.62186062e-02f, -2.91367322e-01f, -4.32817079e-02f, -5.15002832e-02f, -9.79984328e-02f, -1.69882983e-01f, -1.64962694e-01f, -8.03982094e-02f, -7.95661956e-02f,
  1.18678734e-01f, -1.82594195e-01f, 1.66551590e-01f, 1.33784994e-01f, -1.12521714e-02f, -2.12378860e-01f, -3.47407050e-02f, -1.11404516e-01f, -1.41774386e-01f, -3.43044996e-02f,
  -2.00862452e-01f, -6.53616711e-02f, -8.89125168e-02f, -1.22996181e-01f, -4.06029016e-01f, -3.29864115e-01f, -8.76111239e-02f, 1.34212181e-01f, 1.36187881e-01f, -5.07588722e-02f,
  -5.67790158e-02f, -1.13207683e-01f, -2.59086013e-01f, -1.52705526e-02f, -1.41946636e-02f, -1.37373269e-01f, -2.13961691e-01f, -7.80111551e-02f, -2.11159453e-01f, -4.80144396e-02f,
  1.39843714e+00f, -8.93974066e-01f, 6.48287117e-01f, 3.42183828e-01f, -1.55651033e-01f, 1.66103430e-02f, -3.55808467e-01f, -1.29532978e-01f, 2.58884013e-01f, -2.49210924e-01f,
  -5.23677826e-01f, -2.02895105e-01f, -5.59788495e-02f, -7.85061419e-02f, 7.21494555e-02f, -7.73908338e-04f, 1.84122562e-01f, 6.77944362e-01f, 7.05479503e-01f, 1.72173277e-01f,
  -3.04014713e-01f, 1.56606093e-01f, 4.01894450e-01f, 2.52055734e-01f, -3.30490440e-01f, 6.25449792e-03f, -6.89746588e-02f, -2.26180449e-01f, -3.47356081e-01f, -1.32306576e-01f,
  -1.23478003e-01f, -6.72603548e-02f, 1.99593395e-01f, -1.77865345e-02f, -1.46354571e-01f, 1.04835160e-01f, 7.57518262e-02f, 7.88930431e-03f, -9.38707441e-02f, -1.13982774e-01f,
  -8.77896100e-02f, -2.38697696e-03f, -2.04056855e-02f, -1.26437247e-01f, 2.42805779e-02f, 4.63586152e-02f, -7.22217560e-02f, 8.46279263e-02f, -3.10862977e-02f, -2.42798179e-01f,
  -4.73352313e-01f, -1.73352823e-01f, 8.21754783e-02f, 1.10032894e-02f, -2.71606371e-02f, 2.08130836e-01f, -2.35901698e-01f, -5.90010546e-02f, 1.62822008e-01f, 9.40721259e-02f,
  7.16180354e-02f, 7.68204927e-02f, 3.81106250e-02f, -2.08510133e-03f, 1.00630216e-01f, 1.90502480e-01f, 4.41999324e-02f, 1.88634694e-02f, 2.16905504e-01f, -2.21670344e-02f,
  -1.27241209e-01f, 2.19298415e-02f, 3.38410698e-02f, -1.11889876e-01f, -5.85025512e-02f, -7.15635717e-02f, 3.64790484e-02f, -9.72080082e-02f, -6.37428164e-02f, 4.59858216e-02f,
  3.14516723e-02f, 6.50090054e-02f, -8.19228515e-02f, -1.57441080e-01f, -2.23364979e-01f, -2.78545935e-02f, -4.27795621e-03f, -9.98069197e-02f, -1.12350166e-01f, -1.09881476e-01f,
  -5.10412395e-01f, 2.82538980e-01f, 2.27544844e-01f, 1.05661035e-01f, 4.23665941e-02f, -8.16450119e-02f, 2.22831424e-02f, 1.45276906e-02f, -6.86655194e-02f, 3.44691612e-02f,
  -1.56494381e-03f, 7.15350360e-02f, -1.71343967e-01f, -3.70824523e-02f, 1.06519915e-01f, 8.54489300e-03f, -1.62436664e-01f, 8.72652307e-02f, -5.71020097e-02f, -2.79472113e-01f,
  -2.08457053e-01f, 1.15546577e-01f, 2.46057719e-01f, 1.46534935e-01f, 2.15750430e-02f, 2.74013817e-01f, -9.56301298e-03f, 6.07979633e-02f, 1.41740561e-01f, 4.25231010e-02f,
  1.12360656e+00f, -3.58763367e-01f, 3.35525990e-01f, 2.45247468e-01f, 3.86021882e-01f, 4.58630294e-01f, 3.05664897e-01f, 5.38180061e-02f, 2.03384515e-02f, 1.09092586e-01f,
  2.22959623e-01f, 2.47946128e-01f, 4.02594656e-02f, 5.50654493e-02f, 2.53872536e-02f, -1.93787649e-01f, -1.96152627e-01f, 1.08390667e-01f, 2.27116659e-01f, 2.02708632e-01f,
  -3.31106298e-02f, -6.61749318e-02f, 1.44414589e-01f, -4.03319299e-02f, -2.52138346e-01f, -1.41979650e-01f, -1.14456095e-01f, -2.19504982e-02f, -5.83999231e-02f, -4.26601082e-01f,
  3.45880166e-02f, 3.15387934e-01f, 3.67419831e-02f, -1.34857371e-01f, -5.82234152e-02f, -1.35761097e-01f, 5.21549508e-02f, -4.16187868e-02f, -1.27615973e-01f, -2.58826017e-01f,
  -6.69774115e-02f, 4.66495380e-02f, 8.94528031e-02f, 3.13980575e-03f, -7.60191726e-03f, 1.62998363e-01f, 4.29539150e-03f, -3.32133984e-03f, 5.31198317e-03f, -2.25497205e-02f,
  -1.79292008e-01f, 2.11175352e-01f, 3.09587300e-01f, 1.11687981e-01f, -9.12567228e-03f, 1.62550822e-01f, -2.57050544e-02f, -4.48268838e-02f, 1.23074733e-01f, -1.21611275e-01f,
  -1.40413865e-02f, 3.50607544e-01f, 3.21381211e-01f, 1.83194444e-01f, -8.14824402e-02f, -4.41286713e-03f, -1.11211650e-01f, 2.05400243e-01f, 1.03361227e-01f, 1.64950103e-01f,
  9.11835581e-03f, 3.37843560e-02f, -1.17251374e-01f, 1.45428181e-01f, 2.45969266e-01f, 3.22648257e-01f, 1.52954921e-01f, -1.05537087e-01f, 2.43999228e-01f, 2.32291464e-02f,
  8.30335692e-02f, -1.05722090e-02f, 1.62703127e-01f, -1.22898720e-01f, 1.33313984e-02f, 2.08897635e-01f, 8.91832858e-02f, 9.53062400e-02f, 7.94836506e-02f, -1.49918854e-01f,
  -3.70759398e-01f, 4.25781101e-01f, -4.91141267e-02f, -1.91900507e-01f, 9.97446701e-02f, -9.03606787e-02f, 4.48796228e-02f, -2.00568199e-01f, -4.31771457e-01f, -4.17738378e-01f,
  -1.52776107e-01f, -1.12746703e-02f, 1.72152482e-02f, -8.40199217e-02f, 9.54250544e-02f, -4.21218164e-02f, 5.38252220e-02f, 1.08181059e-01f, -1.11093253e-01f, -1.49972498e-01f,
  -1.23841122e-01f, 1.77949503e-01f, 2.45877251e-01f, 1.29128043e-02f, 7.70749105e-03f, 2.13126957e-01f, -1.08282916e-01f, 1.87081862e-02f, 2.13852331e-01f, -8.41237754e-02f,
  2.10731208e-01f, 1.06925869e+00f, 6.97851241e-01f, -4.21340942e-01f, 3.61552507e-01f, 5.48427761e-01f, 9.89740968e-01f, 1.58508912e-01f, -3.62382263e-01f, 6.37329578e-01f,
  6.81798756e-01f, -7.94342399e-01f, -4.54108387e-01f, -4.80174482e-01f, -2.11202800e-01f, 4.80812728e-01f, 1.32755578e-01f, -5.09986281e-01f, -8.87223125e-01f, -6.75205469e-01f,
  -4.28995997e-01f, -3.87820542e-01f, -4.42372888e-01f, -3.47936928e-01f, 1.53301001e-01f, -4.20416951e-01f, 5.29425383e-01f, 3.96633446e-01f, 5.73159933e-01f, 1.69860810e-01f,
  3.58133465e-01f, 7.66590297e-01f, -9.89344180e-01f, -1.40389904e-01f, 2.34823033e-01f, -1.55362666e-01f, -1.52972773e-01f, -1.07632764e-01f, 3.46152075e-02f, 3.58198546e-02f,
  1.67930096e-01f, -2.58374354e-03f, 1.96311012e-01f, 2.84532849e-02f, 6.98705912e-02f, -1.98729318e-02f, -3.84027697e-02f, -1.58644930e-01f, -2.12821469e-01f, 1.61236748e-01f,
  2.13583205e-02f, 3.50670934e-01f, 2.05670044e-01f, 9.47300345e-03f, 4.76274006e-02f, -2.76688933e-01f, 5.35509169e-01f, 1.50133356e-01f, 2.69590706e-01f, 1.17360335e-02f,
  -2.25532264e-01f, 2.66652346e-01f, 1.76812395e-01f, -3.11931539e-02f, 1.54964421e-02f, -5.24348952e-02f, -2.38374007e-04f, -2.18925979e-02f, -8.43498856e-02f, -2.52036098e-02f,
  -5.72261177e-02f, -7.06093328e-04f, -1.16333142e-01f, 1.69183314e-02f, -2.63891011e-01f, 6.43789619e-02f, 1.24074064e-01f, -4.07517552e-02f, 6.64035976e-02f, -2.26005614e-02f,
  -1.76259965e-01f, 1.51048023e-02f, -9.65181217e-02f, -1.18674926e-01f, 4.22007591e-02f, 1.26174893e-02f, -1.40922740e-01f, 7.31488392e-02f, -1.52819261e-01f, 1.16417319e-01f,
  -7.53139555e-01f, -1.63907129e-02f, -2.66110688e-01f, -1.05543233e-01f, 3.01787406e-01f, 1.41804218e-01f, -7.34362304e-02f, 1.20778464e-01f, 1.13948686e-02f, -1.14693709e-01f,
  2.00604916e-01f, -3.18385899e-01f, 4.01112556e-01f, -1.53058052e-01f, -2.42245361e-01f, -1.67658076e-01f, -1.16844937e-01f, -2.73686409e-01f, -7.79326633e-02f, 1.59508005e-01f,
  1.24541581e-01f, -4.86249745e-01f, -7.03271568e-01f, -4.86267030e-01f, -3.65944892e-01f, -9.22736764e-01f, -2.39023730e-01f, -2.82442242e-01f, -1.38801306e-01f, -3.76436412e-01f,
  -9.78077292e-01f, -7.25742638e-01f, -4.28510547e-01f, -1.29917133e+00f, -5.77842891e-01f, 1.81774218e-02f, -7.61959478e-02f, -3.13478798e-01f, -5.68643510e-01f, -5.80861866e-01f,
  4.87490445e-01f, 9.55444336e-01f, 4.06716764e-01f, 7.10188270e-01f, 8.49637330e-01f, -5.68513274e-01f, -9.83823180e-01f, 9.49064568e-02f, 1.03035414e+00f, 7.05318213e-01f,
  3.06389958e-01f, -5.49696684e-01f, -3.29634935e-01f, -2.81607836e-01f, -8.19161177e-01f, 1.13389879e-01f, -6.79744303e-01f, -5.54151833e-01f, 1.88744515e-01f, -9.74755406e-01f,
  5.23396432e-01f, -6.08572125e-01f, 2.13691428e-01f, 1.40384898e-01f, -2.86042392e-01f, -2.12672986e-02f, 1.03719205e-01f, -2.80764967e-01f, -1.52016848e-01f, -3.06404233e-01f,
  -1.74199492e-01f, -3.39881778e-02f, -9.68770310e-02f, 2.43920862e-04f, -3.30178142e-01f, 1.04581550e-01f, -2.57140666e-01f, -2.38922849e-01f, -2.11558789e-01f, 5.97597212e-02f,
  8.81785825e-02f, 6.18986823e-02f, 2.26260692e-01f, -9.95543133e-03f, 1.18698485e-01f, 4.65942174e-02f, 1.74262509e-01f, 1.64901353e-02f, 6.48996159e-02f, -4.93178576e-01f,
  4.33498733e-02f, -1.52743191e-01f, -1.12350285e-01f, -4.11492437e-02f, 1.14986181e-01f, 1.43483624e-01f, -1.34202421e-01f, -7.39501556e-03f, 6.13365769e-02f, 7.23312795e-02f,
  2.68484075e-02f, -1.66178569e-01f, 5.31441197e-02f, -2.35793795e-02f, 5.88976254e-04f, -9.84957665e-02f, 5.18824495e-02f, -1.33683354e-01f, 4.51068906e-03f, -1.53758958e-01f,
  1.54667790e-03f, -1.18884355e-01f, -1.47627473e-01f, 1.40893902e-03f, -7.92584866e-02f, -1.01485081e-01f, -4.19281423e-02f, 1.99816525e-01f, 4.20274548e-02f, -9.63514149e-02f,
  3.84930491e-01f, 1.93642452e-01f, 1.57066453e-02f, 1.45786002e-01f, -2.64799476e-01f, -8.24449286e-02f, -1.69763118e-01f, -1.70531571e-01f, -1.34746030e-01f, 4.46095355e-02f,
  3.62261645e-02f, 3.40298377e-02f, -1.30701303e-01f, -7.82018378e-02f, 1.46950617e-01f, 1.92220971e-01f, 1.30522773e-02f, 9.84685216e-03f, -1.04232758e-01f, -1.22352473e-01f,
  -2.24942207e-01f, 5.72155695e-03f, 3.77962142e-01f, 1.53037578e-01f, -6.84643090e-02f, 3.25684756e-01f, 1.66847616e-01f, 1.58482611e-01f, 3.12262625e-01f, -3.09673458e-01f,
  -3.53709579e-01f, -1.07970752e-01f, 6.22760713e-01f, 2.24199370e-01f, -6.10384047e-01f, -9.69753921e-01f, -1.31593907e+00f, -7.17314482e-01f, -5.27533051e-03f, 1.39456779e-01f,
  -7.16483817e-02f, 1.09721549e-01f, 3.20772350e-01f, 3.76476459e-02f, -3.76607478e-01f, -1.12448987e-02f, 3.95727247e-01f, 1.59365505e-01f, -3.44538629e-01f, -5.74890733e-01f,
  -1.94360837e-01f, 1.34525016e-01f, 4.13297527e-02f, 5.15488163e-02f, 7.46595442e-01f, 2.63850033e-01f, 6.87157571e-01f, 2.52272397e-01f, 6.24247901e-02f, 1.13584626e+00f,
  8.75048637e-01f, -1.67222425e-01f, -3.25178742e-01f, -5.31468466e-02f, 1.98591873e-01f, 9.53209996e-02f, -7.57411569e-02f, 3.14555258e-01f, -3.64084020e-02f, 1.33489355e-01f,
  1.03732869e-01f, -5.22108860e-02f, -4.20276001e-02f, 1.32931471e-01f, -1.18289344e-01f, -9.53510404e-02f, 1.98844686e-01f, -1.76338758e-02f, 2.16134623e-01f, 1.70346856e-01f,
  8.56942236e-02f, -5.77524640e-02f, -4.26306427e-02f, -9.92247462e-02f, 4.17895168e-02f, 6.42183051e-02f, -2.05419853e-01f, -9.65189189e-02f, -2.20816433e-01f, 3.91656578e-01f,
  -9.38390791e-02f, 2.41400264e-02f, 7.36498311e-02f, -5.75954840e-02f, 6.30301610e-03f, 9.16657448e-02f, 1.87808499e-01f, -5.16011305e-02f, -6.47655502e-02f, 1.50498122e-01f,
  -1.18075438e-01f, -2.75263172e-02f, -4.73113656e-02f, -9.94802266e-02f, 8.42102841e-02f, 2.02823341e-01f, 3.94974016e-02f, -2.12318506e-02f, -1.28605843e-01f, 1.29713088e-01f,
  -1.34463489e-01f, 2.92873960e-02f, 2.80191332e-01f, -9.28368792e-02f, 1.39261559e-01f, 1.51149658e-02f, 1.38143837e-01f, -2.09913626e-02f, 4.29686159e-03f, -1.38459906e-01f,
  2.60403872e-01f, -9.29761350e-01f, 3.04194927e-01f, 4.91857231e-02f, 6.35196343e-02f, 1.35765240e-01f, 2.75178999e-01f, -1.59314707e-01f, 1.44275334e-02f, 2.73374338e-02f,
  -2.34089643e-01f, -9.20344070e-02f, 1.11284517e-01f, 3.13658603e-02f, -2.54600316e-01f, 1.87413171e-01f, 4.60130945e-02f, 9.47211459e-02f, -3.57614905e-01f, 4.39237319e-02f,
  1.09953880e-01f, -4.03901935e-01f, -3.94131035e-01f, -2.44255811e-01f, -6.59418106e-02f, -1.99248284e-01f, -3.15582454e-01f, -1.68900907e-01f, -5.52459061e-01f, -7.38065481e-01f,
  1.04410613e+00f, -7.03325421e-02f, -1.64211845e+00f, 4.59611475e-01f, -3.86872858e-01f, -9.05747652e-01f, -5.87677479e-01f, 7.41656721e-02f, 5.19557893e-01f, 3.33211005e-01f,
  9.93039906e-02f, 7.17831682e-03f, -5.79757452e-01f, -4.70160514e-01f, -9.57609773e-01f, -8.23444188e-01f, -8.47234488e-01f, -1.35538304e+00f, -1.04032147e+00f, 1.81073055e-01f,
  4.57807660e-01f, 2.91642636e-01f, 7.74799883e-02f, -1.94174379e-01f, 2.44581789e-01f, -1.80592209e-01f, -5.07749438e-01f, -3.47813487e-01f, -5.04902065e-01f, -4.65225309e-01f,
  -8.36917937e-01f, -2.48347372e-01f, -1.31010965e-01f, 5.08147120e-01f, -1.07494071e-01f, -5.16789928e-02f, -2.04935357e-01f, -2.52379268e-01f, 1.70874283e-01f, -1.47581697e-01f,
  -8.70549232e-02f, 1.95780754e-01f, -5.95977083e-02f, -1.30325571e-01f, -1.53273702e-01f, -1.78347647e-01f, 6.42904043e-02f, -2.61320531e-01f, -4.27901268e-01f, -1.95053294e-01f,
  4.86207783e-01f, -2.14695036e-01f, -6.98106527e-01f, 6.47004321e-02f, -4.97996181e-01f, -3.43926340e-01f, -3.15340042e-01f, -1.38496175e-01f, -5.61877191e-01f, 2.01721862e-01f,
  7.66908526e-02f, -5.70872314e-02f, -2.48999614e-02f, -2.09672051e-03f, 2.40944564e-01f, 2.11883360e-03f, 7.50020966e-02f, 2.43098158e-02f, -1.55587010e-02f, -4.67715189e-02f,
  3.17790806e-02f, -1.75948385e-02f, -4.74914759e-02f, -1.43977478e-01f, -9.69100073e-02f, -6.19728677e-02f, 1.36572123e-01f, 7.06257746e-02f, -1.83274165e-01f, 6.97084470e-03f,
  -7.23431557e-02f, -3.67462672e-02f, -1.46184489e-01f, 6.50565997e-02f, -1.45329490e-01f, 8.28046724e-03f, -3.32777314e-02f, 2.51786411e-01f, 3.48395705e-02f, -4.17873673e-02f,
  1.78116173e-01f, -2.49118403e-01f, -6.64270744e-02f, -4.95381616e-02f, -1.65969044e-01f, 3.47966477e-02f, 1.29330620e-01f, 2.73258388e-01f, -1.77179072e-02f, -9.64475945e-02f,
  -2.14866474e-01f, 1.08994111e-01f, -1.59431338e-01f, 3.84071022e-02f, -2.02083021e-01f, -9.91057009e-02f, 1.65134668e-01f, -1.30088896e-01f, -6.29171729e-02f, 2.70662427e-01f,
  2.42503494e-01f, -6.23108521e-02f, 4.59974036e-02f, 3.89628997e-03f, 1.68918952e-01f, -2.39015743e-01f, -2.70573020e-01f, 2.51027346e-01f, -3.59015286e-01f, 4.89019692e-01f,
  -1.76134455e+00f, -5.33354938e-01f, 4.27336991e-01f, -6.27360821e-01f, 1.60140142e-01f, 6.61544025e-01f, 6.09109402e-01f, 5.23947403e-02f, -3.28924894e-01f, -4.76027280e-01f,
  -5.01653910e-01f, -6.56030178e-01f, -5.63181818e-01f, 1.68277100e-02f, 1.86147779e-01f, 4.87056911e-01f, 6.60676658e-01f, 3.17937255e-01f, 4.24495608e-01f, 3.63537610e-01f,
  2.80868232e-01f, -2.35482514e-01f, -4.42578018e-01f, 1.45898700e-01f, -2.04526559e-01f, -7.81888217e-02f, -2.24218294e-02f, -2.15692520e-01f, 3.94929469e-01f, -2.13775933e-01f,
  -8.88815820e-01f, -7.46755302e-01f, 4.34732229e-01f, -2.83313334e-01f, -1.75789669e-01f, -2.37895876e-01f, -8.60017166e-02f, -4.18341547e-01f, -2.45242581e-01f, -5.77573292e-02f,
  -4.35145676e-01f, -1.35172933e-01f, -3.39517176e-01f, -5.58391474e-02f, -2.84151644e-01f, -1.69176906e-01f, -1.08405210e-01f, 1.16436861e-01f, 8.19311440e-02f, 1.40134543e-01f,
  2.98151106e-01f, -2.47611955e-01f, -4.00971770e-01f, 4.07416999e-01f, 2.24933609e-01f, 1.15309082e-01f, -1.25885587e-02f, -3.06098908e-01f, -3.34779844e-02f, -1.12710953e+00f,
  1.06002882e-01f, -5.20528369e-02f, 1.77891359e-01f, -9.44366306e-02f, -1.47598490e-01f, -1.73641890e-01f, 1.72591284e-02f, -6.20299987e-02f, 3.54686799e-03f, -8.24899897e-02f,
  6.27737120e-02f, -9.27914008e-02f, 9.01538581e-02f, -1.97135419e-01f, -2.25207284e-02f, -9.96252447e-02f, 1.69535667e-01f, 7.87660256e-02f, -2.24378482e-02f, 3.42537910e-02f,
  -1.55062735e-01f, 8.62417519e-02f, 4.78805564e-02f, 3.07923295e-02f, 2.32871264e-01f, 4.60184574e-01f, -3.37229334e-02f, -8.13317373e-02f, -1.22405402e-01f, -2.73941487e-01f,
  -7.43661165e-01f, 6.31004989e-01f, -6.49294794e-01f, -3.11845783e-02f, -2.74853438e-01f, 7.71649107e-02f, -9.89450142e-02f, 4.62772995e-02f, -2.51465082e-01f, -1.30749330e-01f,
  -5.65327220e-02f, -2.67758638e-01f, -2.80222178e-01f, 2.63756007e-01f, 2.20237002e-01f, -1.59835622e-01f, -3.00057624e-02f, -1.64606259e-03f, 1.42677769e-01f, -9.91733447e-02f,
  2.31470242e-01f, 4.56204414e-02f, -5.83457172e-01f, -2.99987346e-01f, -4.22173887e-02f, -2.87283272e-01f, -4.55060661e-01f, -2.46581674e-01f, -1.70239896e-01f, -7.50262856e-01f,
  1.03208043e-01f, -3.41925174e-02f, -4.10525888e-01f, 5.50444245e-01f, 3.01211745e-01f, 7.50975311e-02f, 5.41647792e-01f, 3.46861780e-01f, 2.30305001e-01f, 4.11055475e-01f,
  -4.00441885e-01f, -5.86068273e-01f, -5.38647413e-01f, -6.04783714e-01f, -7.45086074e-01f, 2.36081302e-01f, 2.64812130e-02f, -6.56600714e-01f, -3.30855578e-01f, 1.15712598e-01f,
  1.65029779e-01f, 4.53190267e-01f, 1.85095981e-01f, -1.64717898e-01f, 3.33122581e-01f, 9.25465450e-02f, 2.44367570e-01f, -1.28045827e-01f, -5.74414194e-01f, -3.49698722e-01f,
  -2.89247930e-03f, -5.74061036e-01f, -2.36493707e-01f, -4.21842456e-01f, -1.46838635e-01f, 7.97323044e-03f, 2.09734231e-01f, -1.70936152e-01f, -2.25524381e-01f, 7.47799575e-02f,
  -2.64979362e-01f, -2.21706703e-01f, -2.90324599e-01f, -9.55223441e-02f, 3.47348362e-01f, -4.46544215e-02f, -2.08889842e-02f, -3.50847393e-01f, -4.07526731e-01f, -1.93928167e-01f,
  -3.36518437e-01f, -4.12997782e-01f, -2.51775771e-01f, -1.30737573e-01f, -2.86816150e-01f, -4.13996994e-01f, -4.41400185e-02f, -2.53344953e-01f, -4.19490665e-01f, 5.21933198e-01f,
  -1.83016825e-02f, 1.69133708e-01f, 7.55393207e-02f, 2.58859806e-02f, 1.20774940e-01f, -1.48728237e-01f, 1.90118358e-01f, 4.14573997e-02f, 1.40318424e-01f, 2.27913141e-01f,
  -4.95770425e-02f, -9.09677595e-02f, 2.29740627e-02f, 1.60774723e-01f, -6.25961125e-02f, -6.17193207e-02f, -9.68535542e-02f, 2.44957507e-01f, -2.36969411e-01f, 1.72573194e-01f,
  -1.90410376e-01f, -1.03771918e-01f, 6.02576770e-02f, -7.25883245e-02f, -3.17456037e-01f, -1.50945365e-01f, -9.29994434e-02f, -8.71962458e-02f, 2.61237286e-02f, -1.26659811e-01f,
  8.26344728e-01f, -6.25313044e-01f, 3.82473320e-01f, -3.00845176e-01f, -3.87895927e-02f, -1.86910093e-01f, 2.63405908e-02f, -2.69316196e-01f, -1.77352741e-01f, -7.89918005e-02f,
  -2.55505353e-01f, -4.61028554e-02f, 6.92064613e-02f, 4.65803109e-02f, 2.83890098e-01f, 7.40896612e-02f, -3.76382545e-02f, -2.39420477e-02f, 3.53700072e-02f, 2.99991250e-01f,
  -1.84244420e-02f, 2.88768113e-01f, 4.81103361e-01f, 3.21507692e-01f, 8.79955590e-02f, -2.09366605e-02f, 5.49295187e-01f, 4.17568415e-01f, -1.32172540e-01f, 1.02778113e+00f,
  1.01175737e+00f, -2.81423479e-01f, -4.22463566e-01f, 6.52921721e-02f, -6.02687776e-01f, -7.37881184e-01f, -7.79458642e-01f, 1.88281425e-04f, 4.05298686e-03f, -5.38160861e-01f,
  -4.87825722e-01f, 1.35262713e-01f, -1.63298920e-01f, -1.15138143e-01f, -5.53540885e-02f, -7.28441715e-01f, -4.20365214e-01f, 1.52545869e-01f, 6.39741957e-01f, 6.31926835e-01f,
  3.10855925e-01f, 6.57730401e-01f, 9.18177903e-01f, 4.65761453e-01f, 1.11435741e-01f, -8.63363221e-02f, -2.57840246e-01f, 2.34948069e-01f, -1.74710855e-01f, -9.82189998e-02f,
  -2.14735985e-01f, 5.71315646e-01f, -4.47311133e-01f, 2.13393733e-01f, 4.90480512e-02f, -2.27060914e-02f, -1.37617469e-01f, 3.36969495e-01f, -3.53609910e-04f, -1.96779549e-01f,
  -1.31161913e-01f, 2.36646067e-02f, -2.56430991e-02f, -8.43740031e-02f, 1.89013928e-01f, 2.32949983e-02f, 4.07522857e-01f, 3.51300746e-01f, 1.74087510e-01f, -7.15087280e-02f,
  -1.93785936e-01f, 3.32068473e-01f, -1.29698887e-01f, -1.49938911e-01f, 5.92406839e-04f, -2.15077475e-01f, -6.20915666e-02f, 2.75019765e-01f, -7.77090937e-02f, 6.79364502e-02f,
  -1.06710352e-01f, 4.71540578e-02f, 6.14993535e-02f, 7.79021084e-02f, -8.96711498e-02f, -2.40274653e-01f, 7.74345873e-03f, -2.02057973e-01f, 4.03330997e-02f, 5.27866520e-02f,
  -5.80606684e-02f, -1.27571940e-01f, 2.89736271e-01f, 5.70061989e-02f, 5.20178378e-02f, -2.34168787e-02f, -1.42778441e-01f, 1.84223831e-01f, 1.91958517e-01f, 6.10838644e-02f,
  2.03751288e-02f, -1.49911448e-01f, 1.77670687e-01f, 2.08158344e-01f, -1.92058459e-01f, 1.22534178e-01f, 4.53550033e-02f, 2.40869984e-01f, 1.25945836e-01f, -7.03012198e-02f,
  -1.04423478e-01f, -6.67303652e-02f, -4.42506611e-01f, 2.65260339e-01f, -1.29984781e-01f, 1.36197910e-01f, -1.81456387e-01f, -2.86313921e-01f, -1.88350618e-01f, -7.53868595e-02f,
  -7.82651305e-02f, -1.31352514e-01f, -1.99852079e-01f, -1.21001258e-01f, -1.80324957e-01f, -2.60058403e-01f, -2.96660841e-01f, -6.59121573e-01f, -1.29040420e-01f, -1.36644123e-02f,
  -2.97092319e-01f, -4.25971210e-01f, -6.73726499e-01f, -6.56947136e-01f, -2.03865603e-01f, -6.09900951e-01f, -6.28409088e-01f, -6.41659379e-01f, -8.76805663e-01f, -9.13060606e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.47242665e-01f, 8.29180896e-01f, 8.39483678e-01f, 1.01830673e+00f, 3.43163013e-01f, 1.30115223e+00f, 1.03998005e+00f, 1.24393749e+00f, 7.76904106e-01f, 1.28754783e+00f,
  9.90942955e-01f, 1.11308455e+00f, 1.27064908e+00f, 8.70269358e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -4.90847379e-01f, -8.80370498e-01f, 2.83218443e-01f, -6.46314502e-01f, -9.65204060e-01f, -1.16390109e+00f, -3.39656025e-01f, -8.33910525e-01f, -7.60295391e-01f, -1.67446709e+00f,
  4.84478116e-01f, -1.30000663e+00f, 7.03366399e-01f, 2.52995074e-01f, -1.55082449e-01f, 7.87320733e-01f, -1.18291545e+00f, -6.85122430e-01f, 5.70781808e-03f, 5.76410055e-01f,
  2.39750415e-01f, 4.61954951e-01f, 5.51888011e-02f, 7.53766179e-01f, 4.00740266e-01f, -1.03881299e+00f, 3.98123115e-01f, -1.27820909e+00f, -6.82024807e-02f, -1.58724618e+00f,
  -9.72949266e-01f, -6.11692131e-01f, 2.17439234e-01f, -1.73651814e-01f, -3.90289426e-01f, 6.31968915e-01f, -3.57243836e-01f, -1.79378819e-02f, -1.23537219e+00f, 5.65584242e-01f,
  -4.84396160e-01f, -1.40553081e+00f, -9.34696615e-01f, 8.08936730e-02f, -9.54346061e-01f, 9.11541522e-01f, -1.05094743e+00f, 6.97343349e-01f, 2.05164835e-01f, 1.49761021e+00f,
  1.81021407e-01f, -2.83904880e-01f, -1.23618746e+00f, 2.10297287e-01f, -9.03970301e-01f, -1.13418853e+00f, -6.71159983e-01f, 9.14373279e-01f, 9.90853608e-01f, -1.41089892e+00f,
  -3.16367686e-01f, 1.09993935e+00f, -1.06223702e+00f, -1.58143377e+00f, 1.10094793e-01f, -2.39001229e-01f, 6.59437537e-01f, 6.93701267e-01f, -2.14793468e+00f, -6.91152155e-01f,
  2.62982696e-01f, -1.22386348e+00f, -2.35757172e-01f, 3.49274337e-01f, -5.38918912e-01f, 8.02259743e-01f, 9.31455791e-02f, -3.84997308e-01f, -4.75434661e-02f, -3.46857905e-01f,
  6.09067202e-01f, -5.64339936e-01f, -7.91675806e-01f, -1.70693800e-01f, 3.66427422e-01f, 8.60249102e-01f, 1.91328749e-01f, -2.43201092e-01f, -9.35446560e-01f, -1.64454329e+00f,
  -1.39000082e+00f, -8.36525202e-01f, 9.16887343e-01f, -9.50539589e-01f, 9.94692266e-01f, -3.77145350e-01f, 1.93175636e-02f, -9.46371257e-02f, -2.00660563e+00f, -1.56261432e+00f,
  -1.84220731e-01f, -1.45739794e+00f, 1.72636330e-01f, -2.43589375e-02f, -8.71301115e-01f, 1.52939677e-01f, -8.18553388e-01f, 8.73155594e-01f, -1.35055506e+00f, -9.07099783e-01f,
  -3.65347296e-01f, 1.09845865e+00f, -2.94757068e-01f, 4.76936132e-01f, 1.45129502e-01f, -6.47817791e-01f, 1.18180506e-01f, 8.06710243e-01f, 3.80405545e-01f, -1.30142260e+00f,
  -9.31764603e-01f, -3.98183703e-01f, -8.38428676e-01f, -5.36132932e-01f, -8.50818872e-01f, 6.71835601e-01f, -3.80574912e-01f, -1.01461065e+00f, 9.57408398e-02f, 6.90091491e-01f,
  -5.73794022e-02f, -1.16188157e+00f, -1.56656787e-01f, -9.27058995e-01f, -5.09792209e-01f, 8.66240859e-01f, 4.31005687e-01f, -8.52320194e-01f, -8.76154661e-01f, -7.26674914e-01f,
  -1.36531603e+00f, 2.49560967e-01f, 1.57333648e+00f, -9.99265134e-01f, -1.63265958e-01f, 5.47961667e-02f, 7.32222497e-01f, -9.84649777e-01f, 6.46287739e-01f, -5.33878386e-01f,
  -8.29638004e-01f, -1.07072735e+00f, 1.18891455e-01f, -6.60204470e-01f, -1.60134864e+00f, 7.99654961e-01f, 5.19564450e-01f, -9.81325150e-01f, -5.47114015e-01f, 2.31666520e-01f,
  1.49310052e-01f, 3.35710198e-01f, -6.10636175e-01f, 7.40717471e-01f, -6.84797987e-02f, 2.81231314e-01f, -4.64300454e-01f, -1.33304572e+00f, -6.71903551e-01f, -7.66290963e-01f,
  8.21633220e-01f, 2.36524153e-03f, -1.71682870e+00f, -6.11538887e-01f, 9.48962808e-01f, -7.50747263e-01f, 3.36084783e-01f, 4.71366197e-01f, -4.08269733e-01f, -7.14725316e-01f,
  1.33718491e-01f, -1.12730622e+00f, -3.94675851e-01f, -7.03236282e-01f, 4.12317842e-01f, 1.66919613e+00f, 2.41058618e-01f, -1.66151583e+00f, -1.04283929e+00f, -7.59393275e-01f,
  -2.00650290e-01f, 1.12728670e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  4.42469090e-01f, -1.97141081e-01f, 6.71175838e-01f, -4.49668467e-01f, 4.47776765e-02f, 3.54740679e-01f, -1.33857653e-01f, -1.96509525e-01f, -3.96321267e-01f, -6.90136105e-02f,
  -1.08575237e+00f, -2.20917508e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    