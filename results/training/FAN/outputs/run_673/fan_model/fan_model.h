/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.70396045e-01f, -2.22035721e-01f, -2.20770523e-01f, -5.30460924e-02f, -6.11957982e-02f, -3.37911621e-02f, -1.88601062e-01f, 1.13392211e-01f, 3.94583680e-02f, -2.92865708e-02f,
  1.02938399e-01f, 2.53498524e-01f, 1.53384194e-01f, 1.21458709e-01f, 1.44198164e-01f, -2.47986481e-01f, -1.50087625e-01f, -8.37202221e-02f, 1.37722522e-01f, 5.80677427e-02f,
  4.02471647e-02f, -6.31190985e-02f, -5.99158742e-02f, 7.00902268e-02f, -1.47165671e-01f, -4.41574603e-02f, -2.08348840e-01f, -2.39160746e-01f, -2.45562658e-01f, -3.79613817e-01f,
  -1.53248087e-01f, 8.59796330e-02f, 1.84754416e-01f, 7.81358257e-02f, 3.30574475e-02f, 1.20321341e-01f, 7.11084381e-02f, 1.23749681e-01f, 9.79242697e-02f, -4.25433144e-02f,
  -1.64025780e-02f, 3.42489891e-02f, 9.14592594e-02f, -4.32756320e-02f, 5.59879765e-02f, -1.67978345e-04f, 2.18501706e-02f, 1.02161974e-01f, 7.42810965e-02f, -1.07261799e-02f,
  9.21031758e-02f, 2.81917099e-02f, -1.20291129e-01f, -7.90976360e-02f, 8.58847499e-02f, 1.72838382e-02f, -6.96600303e-02f, -3.50911245e-02f, -3.67398001e-02f, -2.23670214e-01f,
  2.23242361e-02f, -7.93776959e-02f, -2.27137432e-02f, -4.32280526e-02f, -1.02060266e-01f, -1.18231297e-01f, -8.01606029e-02f, -1.65127009e-01f, -8.38805810e-02f, -1.32486030e-01f,
  -4.99182642e-02f, -1.20710827e-01f, -6.95080906e-02f, -1.71143964e-01f, -8.78618956e-02f, -7.79006183e-02f, -1.61087260e-01f, -6.06319159e-02f, -9.80366170e-02f, -8.59036017e-03f,
  -1.28668576e-01f, -5.68508245e-02f, -8.50596204e-02f, -1.35381505e-01f, -1.13722697e-01f, -6.17682263e-02f, -9.87372175e-02f, -1.26105711e-01f, -5.27882352e-02f, -8.45011473e-02f,
  -7.59847313e-02f, 2.61242360e-01f, -9.68190935e-03f, 1.66221000e-02f, -5.70219755e-02f, 7.18480796e-02f, 6.72615618e-02f, 8.10808502e-03f, 1.09254792e-01f, 4.86793034e-02f,
  7.47538805e-02f, 1.14739448e-01f, -1.39683280e-02f, -1.94620416e-02f, 4.52027516e-03f, 3.17053078e-03f, 9.50218178e-03f, -4.47123237e-02f, 5.38615324e-02f, 7.95076340e-02f,
  3.81450430e-02f, -9.17269811e-02f, -4.68712449e-02f, -5.57838231e-02f, -3.57870869e-02f, 1.08730197e-02f, -1.04792029e-01f, -1.00053802e-01f, -2.47586444e-02f, -1.56494275e-01f,
  1.61544368e-01f, 2.17343554e-01f, -1.47491917e-01f, -1.77460954e-01f, -1.68621376e-01f, -2.28921790e-02f, 6.45095408e-02f, -2.45910306e-02f, 1.66800953e-02f, -5.86390570e-02f,
  1.15679845e-01f, 6.85307607e-02f, 3.66228558e-02f, -8.56127366e-02f, 1.58324800e-02f, -8.35530013e-02f, -2.74881303e-01f, -6.85045421e-02f, -7.19117299e-02f, -5.57450345e-03f,
  -1.36493832e-01f, -1.60487890e-01f, -9.06206444e-02f, -1.46588236e-01f, -1.61976963e-01f, -8.50546062e-02f, -1.74203917e-01f, -9.76263359e-03f, -9.12608206e-02f, -2.36086458e-01f,
  -5.29887751e-02f, 1.61076337e-01f, -7.56923854e-02f, 8.49937126e-02f, -1.95792853e-03f, 4.81064878e-02f, 7.04990933e-03f, 9.67088565e-02f, 8.75654444e-02f, -8.05834457e-02f,
  3.12211625e-02f, 8.10046270e-02f, 5.35183549e-02f, -1.89726092e-02f, 4.89326902e-02f, 3.56026031e-02f, 1.14439549e-02f, -4.97900285e-02f, 3.68807502e-02f, 5.90651557e-02f,
  2.73976661e-02f, -2.39373967e-02f, 9.24434960e-02f, -4.07885835e-02f, -6.13383995e-03f, -1.12301722e-01f, 3.74545418e-02f, 8.85702744e-02f, 1.15509816e-02f, 8.54628906e-03f,
  -1.00483492e-01f, -1.76679697e-02f, -4.80077863e-02f, 6.40702574e-03f, 1.63922124e-02f, 2.07125824e-02f, -2.92400457e-02f, -1.35973692e-02f, 4.57487181e-02f, 7.43692517e-02f,
  -1.07491249e-02f, -4.81278561e-02f, -3.02924272e-02f, -6.89356625e-02f, -9.35637057e-02f, -2.25276779e-02f, 3.43655050e-02f, -1.71060376e-02f, -5.44566028e-02f, -5.08427136e-02f,
  -6.71932697e-02f, -7.64819086e-02f, -7.89144263e-03f, -5.71353957e-02f, -4.08677459e-02f, -1.05602026e-01f, -8.35106596e-02f, -5.34692854e-02f, 4.94459365e-03f, -7.64601165e-03f,
  2.12294534e-01f, -8.12266767e-02f, 5.06249890e-02f, 5.79894483e-02f, -1.43074896e-02f, 5.12517542e-02f, 1.04473673e-01f, -4.54669539e-03f, -3.71412933e-03f, 5.24560325e-02f,
  6.99222833e-02f, 8.48409012e-02f, -1.82073656e-02f, 4.39213812e-02f, -4.77014529e-03f, 1.65947601e-02f, 1.11511238e-01f, -4.66355029e-03f, -9.45723876e-02f, 5.54245263e-02f,
  -3.33171040e-02f, 1.31427675e-01f, 7.55211040e-02f, 9.83763486e-02f, 3.12529244e-02f, 4.21367772e-02f, 1.44342139e-01f, -2.45756209e-02f, 8.22154507e-02f, 6.80380613e-02f,
  -5.70698857e-01f, -4.05768424e-01f, -2.26429440e-02f, -2.01640233e-01f, 4.64483984e-02f, -7.79732764e-02f, -2.92260259e-01f, -1.04666360e-01f, -2.92130541e-02f, -1.06139779e-01f,
  -9.60677564e-02f, -2.49442775e-02f, -8.02379698e-02f, -5.08381538e-02f, -2.58197159e-01f, -2.67675340e-01f, -3.36389728e-02f, 6.38781395e-03f, 1.34386972e-01f, 3.44980531e-03f,
  1.19009770e-01f, -4.07946445e-02f, 1.98599137e-02f, -7.93579891e-02f, 7.37746879e-02f, 3.67236175e-02f, -1.16944246e-01f, -3.04261800e-02f, 7.51483366e-02f, 9.49001610e-02f,
  -4.52120751e-02f, -2.98458070e-01f, -1.18022501e-01f, -1.18193083e-01f, -5.70765659e-02f, -1.61282197e-01f, -1.04756340e-01f, -8.30228627e-02f, -4.00922783e-02f, -1.42444506e-01f,
  -1.50722548e-01f, -2.47890875e-02f, -1.99701637e-01f, -1.04155205e-01f, -1.13522463e-01f, -1.04035735e-01f, -1.24971285e-01f, -2.08051100e-01f, -9.26434994e-02f, -1.41248420e-01f,
  -2.77465209e-02f, -1.34276748e-01f, -1.73270091e-01f, -1.38517663e-01f, -8.41923952e-02f, -1.73180044e-01f, -1.87982976e-01f, -1.51949823e-01f, -2.36357585e-01f, -1.82062134e-01f,
  1.52783662e-01f, 1.73783347e-01f, 1.46669701e-01f, 8.59736279e-02f, 1.35223523e-01f, 9.66831148e-02f, 2.09896132e-01f, 1.95846424e-01f, 1.85180992e-01f, 9.51182172e-02f,
  2.11801708e-01f, 1.03179164e-01f, 1.65342838e-01f, 1.30421519e-01f, 1.63207680e-01f, 1.02246843e-01f, 1.95812643e-01f, 8.58736336e-02f, 7.02365562e-02f, 1.76851764e-01f,
  1.49831250e-01f, 9.01803747e-02f, 1.90791368e-01f, 1.69957399e-01f, 4.62159291e-02f, 2.99084950e-02f, 5.31322733e-02f, 1.51933178e-01f, 1.68336242e-01f, 1.54156938e-01f,
  -1.86119944e-01f, -1.15572721e-01f, -2.45690674e-01f, -1.57196417e-01f, -1.43894836e-01f, -2.21924126e-01f, -1.44375548e-01f, -2.30416209e-01f, -2.19463348e-01f, -1.78989813e-01f,
  -1.54837415e-01f, -1.57074735e-01f, -2.87091494e-01f, -1.36151120e-01f, -1.95841432e-01f, -2.07257241e-01f, -3.17532927e-01f, -1.20884985e-01f, -2.14510709e-01f, -2.33541161e-01f,
  -2.69444078e-01f, -2.76752293e-01f, -2.54395068e-01f, -2.11571679e-01f, -1.71123803e-01f, -1.73156217e-01f, -2.34067440e-01f, -2.13700205e-01f, -3.31097275e-01f, -3.12680781e-01f,
  -4.86464947e-01f, 3.50424260e-01f, -8.07705615e-03f, -1.67665377e-01f, 3.88691276e-02f, 9.74456370e-02f, 3.28469753e-01f, 7.66065270e-02f, -1.88877508e-01f, 1.23612888e-01f,
  1.06476665e-01f, 2.99019981e-02f, 9.77722183e-03f, 9.34704691e-02f, -3.40631930e-03f, 1.95066065e-01f, 1.73000395e-01f, -4.61583994e-02f, -2.23616421e-01f, -6.31596297e-02f,
  1.18737698e-01f, -6.67797625e-02f, -1.78925082e-01f, 2.27468070e-02f, 1.81601152e-01f, 1.05208948e-01f, 1.99399769e-01f, 1.86616927e-01f, 2.70685524e-01f, 2.38458544e-01f,
  1.59599066e-01f, 9.31971446e-02f, 2.18138527e-02f, 1.39412377e-02f, 2.08186191e-02f, -5.18862344e-02f, 1.17666163e-01f, -1.64839868e-02f, 4.28408794e-02f, 5.44355949e-03f,
  1.04077220e-01f, 4.33314033e-03f, 6.41990826e-02f, 4.50977497e-02f, 7.34107867e-02f, -1.79324839e-02f, -4.20244709e-02f, 4.42931708e-03f, 2.14838032e-02f, 5.19978479e-02f,
  1.11060783e-01f, 1.00174338e-01f, 4.88136820e-02f, 1.47296386e-02f, 4.70060967e-02f, -5.86973429e-02f, 1.94381207e-01f, 1.46449238e-01f, 8.04151893e-02f, 2.23613679e-01f,
  -3.25954147e-02f, -8.60028565e-02f, -1.11724563e-01f, -5.66417500e-02f, -3.74386720e-02f, -1.22485273e-01f, -7.06527382e-02f, -6.11909367e-02f, -1.04749627e-01f, -1.43030345e-01f,
  -5.14855497e-02f, -6.91511855e-02f, -8.72531608e-02f, -1.27954304e-01f, -1.11742087e-01f, -1.04380175e-01f, -8.44703335e-03f, -3.96539085e-02f, -4.61210050e-02f, -7.03947768e-02f,
  -9.20411721e-02f, -1.38049498e-01f, -2.02027768e-01f, -5.12519553e-02f, -7.26760104e-02f, -8.46644342e-02f, -1.53280497e-01f, -9.51137766e-02f, -1.69890657e-01f, -1.43084794e-01f,
  -9.09599066e-02f, -1.22778818e-01f, 1.07211962e-01f, 3.54045839e-03f, 1.42346889e-01f, 5.17777316e-02f, 3.17962207e-02f, 2.76563242e-02f, 8.16789418e-02f, 8.53765979e-02f,
  1.49835333e-01f, -4.70439764e-03f, 1.06833950e-01f, 5.43269441e-02f, 2.58009043e-02f, 1.03544094e-01f, 1.61567479e-01f, 2.66520381e-02f, 1.11395299e-01f, 8.28884393e-02f,
  9.58229452e-02f, 2.95916423e-02f, 1.09695770e-01f, 1.32041857e-01f, 1.06942944e-01f, 3.50220390e-02f, 1.16367497e-01f, 8.74448493e-02f, 4.19037566e-02f, 2.68954560e-02f,
  -1.83986232e-01f, -2.45950699e-01f, -1.92724794e-01f, -2.68366677e-03f, -4.32766192e-02f, 3.50823626e-02f, -3.41885388e-02f, 1.66683748e-01f, 1.34518653e-01f, -1.94578394e-01f,
  -3.66235226e-01f, -6.62645474e-02f, -5.21085784e-02f, 1.91837490e-01f, 1.63880855e-01f, -7.90528655e-02f, 9.46460739e-02f, 1.67906702e-01f, 3.82143587e-01f, 1.52707592e-01f,
  7.03131482e-02f, 5.08168079e-02f, 1.16100684e-02f, 1.82177588e-01f, -9.51655805e-02f, 1.56896278e-01f, -1.41383827e-01f, -1.04275621e-01f, -1.03656784e-01f, -1.06174693e-01f,
  -3.29128832e-01f, -3.15149158e-01f, 1.02162749e-01f, -3.06519214e-02f, -9.90401581e-02f, -1.03186771e-01f, -9.50183198e-02f, -1.52677232e-02f, -1.35616452e-01f, -1.71681732e-01f,
  -1.07152507e-01f, -1.37941957e-01f, -1.36753696e-03f, -1.12328187e-01f, -9.69218984e-02f, -4.33131531e-02f, -1.03306070e-01f, 5.32353483e-02f, -4.69873799e-03f, -1.51596099e-01f,
  -2.17486843e-01f, -1.88385934e-01f, -1.67494982e-01f, -1.04919337e-01f, -1.00364074e-01f, 5.03502525e-02f, -2.07274809e-01f, -8.04682225e-02f, -2.05143839e-02f, -1.21329211e-01f,
  1.64055489e-02f, -5.59869260e-02f, -2.43617706e-02f, 2.15828419e-02f, -8.73636603e-02f, 1.69557345e-03f, -4.64830026e-02f, -7.49069527e-02f, 9.67355371e-02f, -8.47797468e-02f,
  1.05119077e-02f, 7.32085342e-03f, -9.22613125e-03f, -7.21898116e-03f, -1.76490340e-02f, -3.95884477e-02f, 1.72403771e-02f, -4.52610143e-02f, -1.61555577e-02f, 3.74046117e-02f,
  -3.22302170e-02f, -3.08521055e-02f, -4.81873751e-02f, 2.58064661e-02f, 2.74689905e-02f, 9.03469231e-03f, 2.09865952e-03f, -6.61869496e-02f, -2.03447826e-02f, -8.75365362e-02f,
  -3.85225117e-02f, 6.35233596e-02f, -1.46900997e-01f, -5.24305440e-02f, -8.72856528e-02f, -4.67736349e-02f, -1.87846333e-01f, -4.02116515e-02f, -3.97540778e-02f, -6.93507269e-02f,
  -1.66555211e-01f, -1.02963420e-02f, -1.10807791e-01f, -3.73248607e-02f, 3.83340791e-02f, -8.27763826e-02f, -8.97271261e-02f, -3.91234457e-02f, -1.59435086e-02f, -9.28602889e-02f,
  -9.47106928e-02f, 6.29355386e-02f, -3.02956924e-02f, 1.70024503e-02f, -5.86743467e-02f, 1.10687487e-01f, -2.17353310e-02f, -6.57553300e-02f, 2.93071233e-02f, 5.69275906e-03f,
  -2.86718518e-01f, -2.44903848e-01f, -4.97428477e-02f, -1.65346172e-02f, -2.29442231e-02f, -1.23650610e-01f, -3.14796895e-01f, -1.36151165e-01f, 3.68112139e-02f, -1.82307344e-02f,
  4.64561246e-02f, 1.66895881e-01f, 1.25902906e-01f, 2.32008304e-02f, -5.78270741e-02f, -1.27179012e-01f, -2.12169975e-01f, -1.08036369e-01f, 8.60847682e-02f, 1.80216820e-03f,
  -1.05842076e-01f, -4.07449342e-02f, -7.28439093e-02f, -7.53392354e-02f, -1.40217587e-01f, 1.39572164e-02f, -1.14566848e-01f, -1.03288200e-02f, -2.82472912e-02f, -1.19764782e-01f,
  2.43236959e-01f, 1.61323939e-02f, 1.37789816e-01f, 1.00970790e-01f, -2.18501408e-02f, 3.36932130e-02f, 5.45516126e-02f, 5.22684902e-02f, 4.95908149e-02f, 2.26002410e-02f,
  2.48445887e-02f, 5.30492850e-02f, 4.10395861e-02f, -1.20924041e-02f, -1.11559555e-02f, -8.54483433e-03f, 4.67180349e-02f, -5.89893162e-02f, 4.68768440e-02f, 5.11115231e-02f,
  -4.38874811e-02f, -1.07431248e-01f, 5.71888983e-02f, 7.72101805e-02f, -4.13213857e-02f, 1.17656268e-01f, 4.93875481e-02f, -5.51165119e-02f, -5.21647185e-02f, -1.88455403e-01f,
  -5.46322949e-02f, 1.03606088e-02f, 2.92927269e-02f, -7.07335696e-02f, 2.79015750e-02f, -5.68523630e-02f, -2.57218666e-02f, 2.65692156e-02f, -2.85632256e-02f, -9.72037911e-02f,
  -6.30064681e-02f, -7.46567696e-02f, -1.24238953e-01f, -7.79048875e-02f, -1.94006634e-03f, -6.90496117e-02f, 4.15651826e-03f, -1.96732376e-02f, 1.01771727e-01f, -1.97857358e-02f,
  -5.09684980e-02f, -2.57380772e-02f, 1.86055005e-02f, -1.25748873e-01f, -1.32150561e-01f, -5.14940917e-02f, 6.69810595e-03f, 2.58375658e-03f, 4.66956869e-02f, 5.92817739e-02f,
  2.68541545e-01f, 1.33306652e-01f, 3.02029308e-02f, 4.38025035e-02f, 7.25919455e-02f, 4.40293737e-02f, 1.14528164e-01f, 8.79642442e-02f, 1.09173454e-01f, 6.01316504e-02f,
  5.67328036e-02f, 5.48835192e-03f, 1.20564848e-01f, -1.57778664e-03f, 1.02280192e-02f, 3.21111456e-02f, -1.44325374e-02f, -5.05365394e-02f, 1.08003058e-01f, -1.64658930e-02f,
  7.41196275e-02f, 1.22158661e-01f, 1.29656926e-01f, 1.21421209e-02f, 6.97025657e-02f, 8.54064971e-02f, 4.47827913e-02f, 1.27002105e-01f, 9.27334577e-02f, -7.25527760e-03f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.54823256e-01f, -2.16788188e-01f, -3.21082890e-01f, -9.09161717e-02f, 1.12183794e-01f, -1.11906514e-01f, -3.02370220e-01f, -1.40890539e-01f, -2.38979086e-01f, -4.21501577e-01f,
  -1.01693168e-01f, 1.34601057e-01f, -1.62500039e-01f, 1.29320934e-01f, 1.57642122e-02f, -2.11312711e-01f, 4.64078970e-02f, 1.53822675e-01f, 3.76410455e-01f, 3.90531033e-01f,
  3.70940745e-01f, 1.68862581e-01f, 1.44361690e-01f, 2.75805056e-01f, 1.01298019e-02f, 1.09261960e-01f, -1.95277527e-01f, 8.64483491e-02f, 3.90383713e-02f, 3.30528766e-02f,
  -4.46993381e-01f, -3.09445947e-01f, -1.05092973e-02f, 1.74463600e-01f, 7.02461153e-02f, -1.23445943e-01f, -5.26909605e-02f, -4.20338586e-02f, -6.26029521e-02f, -1.84151828e-01f,
  1.84506904e-02f, 2.48163119e-02f, -5.37526011e-02f, 7.30870897e-03f, 8.21007490e-02f, 1.09101869e-02f, 8.01121220e-02f, 1.58632230e-02f, -4.18486260e-02f, -1.20707937e-01f,
  2.79872119e-01f, 1.06420359e-02f, -2.30734721e-01f, 1.23793175e-02f, -4.51758504e-02f, 2.20897216e-02f, -1.06275082e-01f, -1.96635593e-02f, -2.48429134e-01f, -3.18875521e-01f,
  1.25771806e-01f, 7.00898394e-02f, 6.46812245e-02f, -6.74749315e-02f, -9.61179845e-03f, -1.60922498e-01f, -2.20531486e-02f, 5.12943268e-02f, -1.76926572e-02f, -3.57591751e-04f,
  8.28188062e-02f, -9.42373499e-02f, 1.52668003e-02f, -9.89287868e-02f, 4.11468670e-02f, -8.44551809e-03f, -5.85306250e-02f, 1.46910511e-02f, -2.42860410e-02f, -7.58498460e-02f,
  1.06744185e-01f, -2.82956157e-02f, 3.43594886e-02f, 7.75424689e-02f, -6.56571761e-02f, 2.03188378e-02f, -5.34030311e-02f, -4.91548441e-02f, 1.20255258e-02f, -2.61517931e-02f,
  -3.65007460e-01f, 7.99045488e-02f, -3.05286705e-01f, 1.83273792e-01f, -1.61005020e-01f, 9.59898233e-02f, -1.14199013e-01f, -3.53862322e-03f, -8.91726166e-02f, 5.37903514e-03f,
  -8.25273395e-02f, -8.49392787e-02f, -2.30616808e-01f, 4.73372303e-02f, -4.40105833e-02f, -1.85241833e-01f, 5.43443374e-02f, -1.18767552e-01f, 7.25680888e-02f, -2.21650694e-07f,
  -5.07871807e-02f, -1.92288756e-01f, -3.35457712e-01f, -2.44249135e-01f, 1.00804912e-02f, -1.85273930e-01f, -2.26017088e-01f, -1.89600781e-01f, -3.17916334e-01f, -5.78254640e-01f,
  3.88213247e-02f, 1.72470987e-01f, -6.13833845e-01f, 1.56174362e-01f, -3.00107509e-01f, -3.60345870e-01f, -2.49092475e-01f, 8.05224776e-02f, 1.41327441e-01f, 1.32449389e-01f,
  9.09925625e-03f, -1.77376807e-01f, -1.88326791e-01f, -2.57381260e-01f, -2.84386903e-01f, -2.12452725e-01f, -3.13588202e-01f, -5.98938704e-01f, -6.63635612e-01f, -2.65845686e-01f,
  -2.44778797e-01f, -2.51645714e-01f, -4.07618582e-01f, -1.77479044e-01f, 1.01650812e-01f, -2.77638674e-01f, -3.10663462e-01f, -4.20577884e-01f, -5.66811562e-01f, -2.27368236e-01f,
  -2.85553396e-01f, -1.61551401e-01f, 1.10421691e-03f, 6.68196976e-02f, 7.16853589e-02f, 1.75737381e-01f, 6.71926811e-02f, 5.31581044e-02f, 2.40124106e-01f, 1.88576922e-01f,
  5.86492755e-02f, 2.06964370e-02f, -8.60835612e-02f, 1.18352793e-01f, 1.10406466e-02f, -5.59167936e-02f, 1.37648180e-01f, 8.45218636e-03f, -6.89994991e-02f, 1.10594288e-01f,
  8.47166181e-02f, -1.46916389e-01f, -1.71958774e-01f, 4.96950932e-02f, -1.60659507e-01f, -3.06369692e-01f, -1.28426040e-02f, 2.46287938e-02f, -1.67718649e-01f, 2.99967885e-01f,
  6.84199482e-03f, 2.43402019e-01f, 8.15331414e-02f, 4.96557280e-02f, 1.41005620e-01f, 1.60681710e-01f, 5.93629219e-02f, 9.96023789e-02f, -4.45677079e-02f, 1.12506732e-01f,
  1.48120359e-01f, 9.06612277e-02f, 2.08426658e-02f, -1.11745246e-01f, -4.79457453e-02f, -1.14839105e-02f, -6.87672347e-02f, 1.06767841e-01f, -4.76557389e-02f, 6.89292476e-02f,
  3.60278320e-03f, 6.62507787e-02f, -1.17178895e-02f, -7.46378601e-02f, -6.55191317e-02f, 7.02271610e-02f, -8.93756896e-02f, 1.22399360e-03f, -3.16073820e-02f, 1.72029026e-02f,
  2.20173866e-01f, -4.16105211e-01f, 1.43353939e-01f, 1.59716442e-01f, 7.98053145e-02f, 1.03072159e-01f, 1.41145485e-02f, 6.63513616e-02f, 5.34243919e-02f, 5.80475815e-02f,
  1.84643697e-02f, 1.31121829e-01f, -9.63637698e-03f, 1.97782382e-01f, -1.38374651e-02f, -5.97423799e-02f, 1.06131695e-01f, 3.87044698e-02f, -3.86747569e-02f, 2.37366915e-01f,
  2.64808923e-01f, 9.27732419e-03f, 2.00482994e-01f, 1.40642226e-01f, 6.35469109e-02f, -1.10895284e-01f, -1.34074735e-02f, 1.12725027e-01f, -8.35558996e-02f, 3.72625023e-01f,
  4.96149629e-01f, -6.09567389e-02f, 2.29152724e-01f, 2.54259020e-01f, -6.45977080e-01f, -6.44245684e-01f, -4.77954775e-01f, 1.08203240e-01f, 5.26235849e-02f, 2.34090127e-02f,
  -4.92942154e-01f, -4.38833147e-01f, 8.63927156e-02f, -3.81540209e-02f, 3.79362628e-02f, 2.80573010e-01f, 3.34621042e-01f, 3.22978854e-01f, -1.97220787e-01f, -6.48490429e-01f,
  -4.83859837e-01f, 2.14469098e-02f, 3.02395999e-01f, 1.65855736e-01f, 1.37117058e-01f, -1.36884287e-01f, 3.57663423e-01f, -1.47234853e-02f, -5.69068715e-02f, 4.36853349e-01f,
  2.09626660e-01f, 3.21499795e-01f, -1.90829650e-01f, -1.77696794e-01f, -1.77232921e-01f, 1.20194793e-01f, -7.58336186e-02f, 2.01526344e-01f, -9.35866162e-02f, 6.59423620e-02f,
  -2.42029741e-01f, -1.90525025e-01f, -7.02839196e-02f, 5.46542332e-02f, -8.03792775e-02f, -1.23973869e-01f, 3.25752854e-01f, 3.53406519e-01f, 2.60373205e-01f, -1.08849123e-01f,
  -5.12107253e-01f, -3.71779680e-01f, -2.57884040e-02f, 4.97652441e-02f, 5.22076897e-02f, -1.35167047e-01f, 1.48992296e-02f, -8.29057619e-02f, 1.83268428e-01f, 4.00055021e-01f,
  -3.09742317e-02f, 5.24150617e-02f, 1.88013408e-02f, 1.30785793e-01f, -4.72587310e-02f, -2.16810945e-02f, 3.36119421e-02f, 4.03683865e-03f, -7.77898654e-02f, 1.85588922e-03f,
  -5.41309714e-02f, -5.40552288e-02f, -8.15971196e-02f, 3.16715203e-02f, 3.49177755e-02f, 3.52429748e-02f, -1.44356653e-01f, 1.12847291e-01f, 1.18968375e-01f, 7.36566111e-02f,
  -9.82948020e-02f, -1.24906348e-02f, -2.83733867e-02f, 1.49167567e-01f, -8.70722532e-02f, 1.03764966e-01f, -1.73277467e-01f, -1.50661543e-01f, 6.40126541e-02f, -2.07004517e-01f,
  6.40108390e-03f, -1.58889040e-01f, -1.05537564e-01f, 7.73319835e-03f, 7.90120959e-02f, -8.12912658e-02f, -7.43134022e-02f, -5.19866683e-02f, -3.64696011e-02f, -1.10573761e-01f,
  -2.63677299e-01f, -1.15988992e-01f, 1.23995677e-01f, 5.43811433e-02f, -1.65550560e-01f, -1.26003385e-01f, -1.07995935e-01f, -1.33396283e-01f, -7.30111375e-02f, -1.70322761e-01f,
  -2.68687736e-02f, -2.12227494e-01f, 3.87798026e-02f, 3.33796144e-02f, -4.51970361e-02f, -3.41936201e-01f, 2.36471202e-02f, -1.47190362e-01f, -3.25120874e-02f, 2.28277564e-01f,
  7.24435806e-01f, -1.42188877e-01f, 3.66839677e-01f, 9.89049524e-02f, 3.26285101e-02f, 9.36094075e-02f, -1.11408204e-01f, -7.95226619e-02f, -4.27441346e-03f, -8.12493172e-03f,
  -1.22009620e-01f, 7.68208802e-02f, -5.60265444e-02f, 6.69261143e-02f, 1.53241083e-01f, -4.87806536e-02f, -1.51821867e-01f, 3.58761251e-01f, 3.86324167e-01f, -1.43360738e-02f,
  -2.26751983e-01f, -7.15205520e-02f, 1.39706105e-01f, -1.82761066e-02f, -2.73846656e-01f, -3.82890254e-02f, -3.47053744e-02f, -5.62189110e-02f, -1.87100843e-01f, -2.73015678e-01f,
  -1.48207560e-01f, 1.66945904e-01f, -2.19102297e-03f, -6.22376762e-02f, -1.40345087e-02f, -1.60983021e-04f, 8.89732614e-02f, 2.58413702e-03f, -1.21509112e-01f, -1.32257715e-01f,
  -1.38569161e-01f, -1.52092390e-02f, -1.72101299e-03f, -4.70004454e-02f, -9.73961726e-02f, -4.47687693e-02f, 3.06179598e-02f, 3.20649631e-02f, -7.89821520e-02f, 3.42673101e-02f,
  -4.94592115e-02f, 2.69342717e-02f, 5.86956888e-02f, -1.15634436e-02f, 7.43411332e-02f, 1.30806386e-01f, 4.62235771e-02f, -3.99649404e-02f, 2.61166431e-02f, -9.24467742e-02f,
  4.43749800e-02f, 1.27125427e-01f, 8.31972584e-02f, 1.12410776e-01f, 5.50144650e-02f, 1.82628587e-01f, 3.29745784e-02f, -5.40527180e-02f, 1.69268966e-01f, 9.89945978e-02f,
  8.18230808e-02f, 1.70986831e-01f, 1.85181051e-01f, 2.33272128e-02f, 1.68213099e-01f, 1.66219264e-01f, 1.66144952e-01f, -7.05328509e-02f, 1.17892675e-01f, -3.87831777e-02f,
  9.61104631e-02f, 6.39585033e-02f, 9.63686109e-02f, 4.81532840e-03f, 1.49676427e-02f, 1.33546248e-01f, 4.59958538e-02f, 5.11341952e-02f, -2.90254690e-02f, 1.40178408e-02f,
  -3.14753562e-01f, 2.25523710e-01f, -4.27049324e-02f, -7.67854899e-02f, -1.50486105e-03f, -3.84816714e-02f, -5.65645937e-03f, -1.81985289e-01f, -2.39436358e-01f, -1.76053733e-01f,
  -1.02642857e-01f, -1.33556314e-03f, 1.35270670e-01f, -5.74776046e-02f, 5.71098924e-02f, -6.75825169e-03f, -9.73285288e-02f, 5.25222197e-02f, -9.29959491e-02f, -2.42510755e-02f,
  -1.41784117e-01f, 1.21918462e-01f, 1.16103925e-01f, 7.80892298e-02f, 3.91343608e-02f, 1.98342979e-01f, 4.00425727e-03f, -7.04446360e-02f, 4.96594757e-02f, -1.25256583e-01f,
  6.29345059e-01f, -2.40239203e-01f, -4.86499071e-01f, -2.68938188e-02f, -2.24477053e-01f, -2.17557937e-01f, -1.12554640e-01f, 5.49728982e-02f, 1.34556666e-01f, 4.61337492e-02f,
  2.62672007e-01f, 6.96393251e-01f, 4.23505694e-01f, 2.72334754e-01f, 3.84012848e-01f, -4.09586519e-01f, -4.98723626e-01f, -1.16953790e-01f, 4.44611371e-01f, 4.75138962e-01f,
  1.92463964e-01f, 1.98194087e-01f, 1.16748646e-01f, -5.76009043e-02f, -2.83326834e-01f, 5.21507263e-02f, -4.93872643e-01f, -2.13724285e-01f, -1.81875810e-01f, -5.40802777e-01f,
  2.76861370e-01f, -1.98870450e-01f, -6.46822378e-02f, 8.87234285e-02f, -1.21842451e-01f, 2.64687501e-02f, -1.17535003e-01f, -2.22734421e-01f, -1.95979308e-02f, -2.17049345e-01f,
  -1.04352377e-01f, 5.06624132e-02f, -4.82326001e-02f, -2.66676806e-02f, -9.92759168e-02f, 3.25992331e-02f, -2.68699080e-01f, -1.82326704e-01f, -9.79110971e-02f, -6.04692055e-03f,
  -1.36272892e-01f, -6.14915788e-02f, -1.43608019e-01f, -1.11193314e-01f, -1.46761894e-01f, -1.47995604e-02f, -2.62848973e-01f, -7.39491731e-02f, -6.40898272e-02f, -1.75045714e-01f,
  1.19353592e-01f, -6.14248402e-02f, -2.01532722e-01f, -1.30842119e-01f, 6.48836568e-02f, -3.45746651e-02f, 4.65459842e-03f, -1.30130192e-02f, -1.12732060e-01f, -3.26935053e-02f,
  -4.84565608e-02f, 9.86719877e-02f, 8.57539326e-02f, -5.41495346e-02f, 4.30066250e-02f, -1.35159075e-01f, 1.08708795e-02f, 9.69683565e-03f, -2.46842559e-02f, 6.08071573e-02f,
  1.98802888e-01f, -6.58421144e-02f, -2.78522782e-02f, 2.06770655e-02f, -3.59009043e-03f, 2.52271835e-02f, 4.50332137e-03f, 1.25121614e-02f, 8.36056937e-03f, -3.62843042e-03f,
  4.10009563e-01f, -5.53292874e-03f, 2.35339161e-02f, 1.01116039e-01f, -1.12667404e-01f, -1.09223366e-01f, 2.80716084e-03f, 9.38181207e-03f, -3.47688682e-02f, 7.13557974e-02f,
  5.63956276e-02f, 1.40990198e-01f, -9.31303203e-02f, -1.74789757e-01f, 1.04377024e-01f, 9.39576775e-02f, 8.95818323e-03f, 1.11917473e-01f, 7.34227672e-02f, -9.61828511e-03f,
  -1.01137750e-01f, 9.98375937e-02f, 2.06379086e-01f, 1.06827833e-01f, 1.25563964e-02f, 3.20870936e-01f, 7.27455020e-02f, 3.65078188e-02f, 1.89483941e-01f, 1.48229256e-01f,
  1.62163794e-01f, -9.15438309e-02f, 1.70753181e-01f, 3.09904546e-01f, 2.45902181e-01f, 3.59072864e-01f, 3.43839854e-01f, 2.93530136e-01f, 3.43833774e-01f, 2.70907313e-01f,
  8.67983177e-02f, 3.08392048e-01f, 2.17488259e-01f, 1.42272443e-01f, 2.54139185e-01f, 1.92904323e-01f, 2.36399442e-01f, 9.99156982e-02f, 1.66328251e-01f, 2.24002853e-01f,
  2.44880542e-01f, 9.04312730e-02f, -4.65756580e-02f, 1.61273718e-01f, 9.20309313e-03f, 2.26574495e-01f, 6.13593496e-02f, 1.24427602e-01f, 4.71031033e-02f, 1.09017603e-01f,
  -1.78185254e-01f, -1.32460147e-01f, 8.58439878e-03f, -1.23667754e-01f, -1.84664056e-01f, -8.38910639e-02f, -1.15927840e-02f, -1.84934333e-01f, -2.19162747e-01f, -7.45819658e-02f,
  -3.42061222e-02f, -2.01164484e-02f, -1.09050423e-01f, -1.85682356e-01f, -1.37522280e-01f, -1.28873944e-01f, 3.13254446e-02f, 1.68122292e-01f, 3.20248283e-03f, -1.02042109e-01f,
  6.04766794e-02f, 7.41437683e-03f, 7.07161576e-02f, 9.16485339e-02f, 9.73514002e-03f, -8.30282196e-02f, -1.48761526e-01f, -4.96056080e-02f, -6.18952932e-03f, -2.59771515e-02f,
  2.50165105e-01f, 9.81048346e-02f, 1.32849276e-01f, 1.99768394e-01f, 1.53453529e-01f, 8.74006078e-02f, 3.64366286e-02f, 1.93249077e-01f, 1.60878584e-01f, 8.85282233e-02f,
  -7.82125741e-02f, 5.31866960e-02f, 5.86347133e-02f, 2.15608537e-01f, 1.27542345e-02f, 9.00426507e-03f, 2.30629873e-02f, 3.74057926e-02f, -3.76883149e-02f, -1.36436582e-01f,
  -2.96135359e-02f, -1.38816014e-01f, -2.93731123e-01f, -2.15931386e-01f, -2.60224678e-02f, -1.16267979e-01f, 2.31323596e-02f, 1.35313405e-03f, -1.65238217e-01f, -1.84653819e-01f,
  9.03830305e-02f, 5.15299253e-02f, 7.12277219e-02f, 6.02446795e-02f, -5.14252745e-02f, -2.60757983e-01f, 1.37987062e-01f, -6.31685555e-02f, -1.87401056e-01f, -1.40288181e-03f,
  -6.53670356e-02f, -1.31990999e-01f, -1.01752102e-01f, 9.06468257e-02f, 1.02637699e-02f, 1.60976835e-02f, 8.54210332e-02f, 1.25504106e-01f, 6.49098307e-02f, -5.58195077e-02f,
  -4.40099165e-02f, 2.26505622e-01f, 2.03085363e-01f, 1.33550659e-01f, 8.74907449e-02f, 4.38008085e-02f, -8.99069980e-02f, 3.84105034e-02f, -4.79581878e-02f, 1.44549251e-01f,
  6.75194025e-01f, -2.97041506e-01f, -8.15765798e-01f, 2.50802070e-01f, -4.22426999e-01f, -4.96757686e-01f, -5.05301476e-01f, -3.91709618e-03f, 1.46071821e-01f, -3.62221122e-01f,
  -3.55317205e-01f, 3.68477926e-02f, -2.61461381e-02f, -1.48484811e-01f, -1.34649407e-02f, -5.51882088e-01f, -4.97814715e-01f, -3.05265695e-01f, -6.63409382e-02f, -1.18055657e-01f,
  -9.93487388e-02f, 1.52554110e-01f, 2.09442496e-01f, 3.84016633e-02f, -1.40426159e-01f, -1.52278334e-01f, -4.75039065e-01f, -2.32527673e-01f, -3.53513986e-01f, -4.18993384e-01f,
  -4.90624875e-01f, -2.56841984e-02f, -2.82348748e-02f, 1.41625240e-01f, -1.62817225e-01f, 7.17541948e-02f, 4.13111262e-02f, 8.68277177e-02f, 3.79576311e-02f, -3.59752476e-02f,
  -7.51300901e-02f, 1.45404148e-04f, 8.25849921e-02f, -1.21578664e-01f, -1.18214764e-01f, -1.98136200e-03f, -4.73071523e-02f, -1.21011175e-01f, -8.38645920e-02f, -1.19165041e-01f,
  -1.89697802e-01f, -1.42764047e-01f, -5.05886823e-02f, -1.95022941e-01f, -4.11331356e-02f, -7.67902983e-03f, -1.65748566e-01f, -7.28325024e-02f, -1.77375227e-01f, 3.61372158e-03f,
  2.43496262e-02f, 8.34315084e-03f, -2.87299440e-03f, 1.17033608e-01f, 1.98598251e-01f, -4.03366275e-02f, 3.61552685e-02f, 1.83537230e-02f, 6.61367625e-02f, 5.59547395e-02f,
  -7.59391189e-02f, -7.69088343e-02f, -3.27400081e-02f, 3.24513689e-02f, -1.17723644e-02f, 1.33101316e-02f, 1.51551841e-02f, -3.05791833e-02f, 8.84303823e-02f, -1.16887754e-02f,
  2.27974355e-03f, 4.36438695e-02f, 2.54269186e-02f, 8.33245739e-02f, -2.11879477e-01f, -6.52616844e-02f, 3.56384106e-02f, 2.04507951e-02f, 1.31622016e-01f, -3.89509238e-02f,
  2.54246354e-01f, -2.55934775e-01f, 1.33765385e-01f, 1.57293767e-01f, -1.68376476e-01f, -6.53234869e-02f, -1.37197882e-01f, 6.29441217e-02f, 3.36090885e-02f, -1.23649435e-02f,
  -1.68552816e-01f, -2.68347375e-03f, -4.11306210e-02f, -5.76230809e-02f, -7.11219907e-02f, -3.83444875e-02f, -2.83044986e-02f, -1.46248251e-01f, -9.29136481e-03f, -2.69206818e-02f,
  -4.29724976e-02f, 6.83820993e-02f, 2.51807094e-01f, 2.16383860e-02f, 8.08900744e-02f, 1.95120677e-01f, -1.02934673e-01f, -3.78471762e-02f, 2.85645146e-02f, 1.86889678e-01f,
  -6.27678752e-01f, -3.94382142e-02f, 2.56660819e-01f, 2.12775901e-01f, 4.96957570e-01f, -8.44677091e-02f, -5.21328449e-01f, -4.92366672e-01f, -3.71157676e-02f, 7.00402781e-02f,
  3.10754061e-01f, 2.89611399e-01f, 3.09953481e-01f, 4.18562330e-02f, -4.06595856e-01f, -4.27607335e-02f, 1.99374542e-01f, -1.58571541e-01f, -3.99508893e-01f, -3.44898552e-01f,
  8.49781260e-02f, -1.15623012e-01f, -4.37208444e-01f, -2.90978014e-01f, 2.30185673e-01f, 1.68443188e-01f, 1.90424040e-01f, 1.93606436e-01f, 9.71207991e-02f, 4.42875564e-01f,
  1.14243962e-01f, -2.26760909e-01f, 3.62060815e-02f, 1.77549273e-01f, 3.37894678e-01f, -2.60746062e-01f, -2.25632325e-01f, -4.02607992e-02f, -9.03555006e-02f, -3.13616954e-02f,
  2.41822198e-01f, 8.57784227e-03f, 1.74505666e-01f, -1.02910452e-01f, -7.02889413e-02f, -2.16982827e-01f, -1.64186314e-01f, -4.41682756e-01f, -3.39565992e-01f, -1.22197546e-01f,
  2.60229200e-01f, 1.18199132e-01f, -5.34011461e-02f, -2.47302368e-01f, -2.81317085e-01f, 1.85299329e-02f, -2.10440621e-01f, -2.59734869e-01f, -4.94901806e-01f, -2.60064244e-01f,
  1.20350067e-02f, 1.37172967e-01f, 2.40972359e-02f, -9.46842656e-02f, -1.00701284e-02f, 1.48619190e-01f, 9.78287458e-02f, 7.77597204e-02f, 4.19959314e-02f, -1.02298409e-01f,
  3.24614197e-02f, -1.71843581e-02f, -9.13200453e-02f, -3.99503931e-02f, 1.81057650e-04f, -6.62706122e-02f, -2.63302978e-02f, -1.02484889e-01f, 6.17748871e-02f, -7.74753466e-02f,
  -4.26693931e-02f, 6.84528723e-02f, -1.16834659e-02f, -7.73893595e-02f, 4.05348698e-03f, -4.57464643e-02f, 4.81217839e-02f, 5.63054020e-03f, -7.85949305e-02f, -1.51549831e-01f,
  -3.36628109e-02f, -2.42185816e-02f, 1.10541493e-01f, -4.90683839e-02f, 1.00563504e-01f, 1.51164472e-01f, 1.59251273e-01f, 2.37122439e-02f, 1.65776342e-01f, -6.38617128e-02f,
  -1.29035056e-01f, -1.04901575e-01f, 1.11913845e-01f, -1.66001339e-02f, -8.85374695e-02f, 5.87810799e-02f, 9.73941013e-02f, 1.25338569e-01f, -1.96433157e-01f, 7.80888051e-02f,
  8.92876312e-02f, -3.28555346e-01f, -2.26247489e-01f, -6.26011714e-02f, 2.68593673e-02f, -9.40236673e-02f, -1.62341639e-01f, -2.16943771e-01f, -3.36703300e-01f, -4.74589527e-01f,
  1.62961632e-02f, 5.59225440e-01f, -2.50415862e-01f, 1.25821710e-01f, 2.32209474e-01f, 1.38900429e-02f, 1.51344210e-01f, -8.93464983e-02f, 4.02215449e-03f, 1.26049444e-01f,
  1.39354616e-01f, -4.50389907e-02f, 9.47780255e-03f, -8.65215585e-02f, -5.22139296e-02f, 7.94484541e-02f, 2.38844231e-01f, -1.83509558e-01f, -3.41972470e-01f, -4.04768661e-02f,
  2.57776767e-01f, 2.39255190e-01f, 9.30906460e-02f, -5.53925661e-03f, 1.36062115e-01f, 3.77432518e-02f, 1.99741408e-01f, 2.89180607e-01f, 9.69712287e-02f, 1.61134034e-01f,
  -2.98829049e-01f, -1.56412189e-05f, -2.38940045e-01f, 1.81300923e-01f, 1.30906001e-01f, -1.64682850e-01f, -1.92452237e-01f, 2.03838069e-02f, 1.13284118e-01f, -1.50076404e-01f,
  3.62955123e-01f, 5.33912703e-02f, 2.13765249e-01f, 5.90154491e-02f, 4.07192931e-02f, -1.73034355e-01f, 1.22656107e-01f, -2.62646705e-01f, -3.50317299e-01f, -8.34502205e-02f,
  3.43411416e-01f, 3.91617000e-01f, -4.37740386e-02f, -1.14897884e-01f, -3.42061013e-01f, -1.69787049e-01f, -1.18125826e-01f, -2.45875806e-01f, -2.08202839e-01f, -1.26086324e-01f,
  -3.39860022e-02f, -1.06140293e-01f, 9.29645970e-02f, -8.31985846e-03f, 1.41174138e-01f, 1.63719729e-02f, -1.45105883e-01f, -9.92214656e-04f, -3.55211385e-02f, 8.54462460e-02f,
  -8.72041881e-02f, -3.83579344e-01f, -3.05268437e-01f, -1.30155280e-01f, -2.32282039e-02f, 6.95556402e-02f, -1.34050846e-01f, -7.91157857e-02f, 6.34733811e-02f, -6.91368878e-02f,
  9.75337159e-03f, -1.89713463e-01f, 7.55710378e-02f, -1.99233010e-01f, -2.85028964e-02f, -2.40273654e-01f, -1.35163248e-01f, -8.86136219e-02f, -1.50769493e-02f, 1.19552881e-01f,
  7.91478902e-02f, -1.55074161e-03f, -3.86718184e-01f, -3.31195220e-02f, -7.03484416e-02f, -1.74289510e-01f, -1.97735444e-01f, -1.13621689e-01f, -2.03424945e-01f, -3.72795165e-01f,
  -2.78009512e-02f, -4.10339743e-01f, 1.09760933e-01f, -1.73232183e-01f, -1.54491231e-01f, -1.76961839e-01f, 1.23968847e-01f, -5.30097634e-02f, -3.10656160e-01f, -2.41311446e-01f,
  1.02544144e-01f, -7.18146339e-02f, -6.16636947e-02f, -2.50191361e-01f, -2.06632212e-01f, -5.26595339e-02f, -8.66022408e-02f, -1.29638135e-01f, -8.35362747e-02f, 2.44522113e-02f,
  6.23914525e-02f, 5.69980145e-01f, 5.30525506e-01f, -3.67106080e-01f, -2.74606026e-03f, 2.72585362e-01f, 4.60023940e-01f, 1.06486969e-01f, -2.22898543e-01f, 3.30978423e-01f,
  2.65813887e-01f, -4.00439978e-01f, -1.40261069e-01f, -2.45619848e-01f, -1.05535701e-01f, 1.96433529e-01f, 1.44512055e-03f, -2.17161626e-01f, -4.14943486e-01f, -2.86985755e-01f,
  -4.05071408e-01f, -3.28771502e-01f, -1.29601642e-01f, -5.56971915e-02f, -1.21986894e-02f, -2.91103274e-01f, 3.23312849e-01f, 1.87373206e-01f, 2.85153061e-01f, -5.45455085e-04f,
  2.86722273e-01f, 5.69468141e-01f, -4.80153471e-01f, -3.06401730e-01f, 5.64402118e-02f, -7.44082406e-02f, 9.66140721e-03f, -2.19370052e-02f, -8.93942080e-03f, 5.74793853e-02f,
  -1.54079154e-01f, 1.53366506e-01f, -3.24321203e-02f, -4.27375063e-02f, 3.32558490e-02f, -9.37741771e-02f, 7.59116188e-02f, 4.31014225e-02f, -3.06679755e-02f, 2.96529382e-01f,
  -2.70269692e-01f, 3.07406969e-02f, 3.44200552e-01f, 1.16315812e-01f, 1.74791709e-01f, -3.76602709e-01f, 2.05449983e-01f, 8.90371278e-02f, 3.17090005e-01f, 5.90833090e-02f,
  -8.13360587e-02f, -5.84181100e-02f, 1.00250840e-02f, 6.16549253e-02f, -1.83185011e-01f, -5.84007148e-03f, -1.06363028e-01f, 3.92225990e-03f, -7.98997730e-02f, -1.31339043e-01f,
  7.13700354e-02f, 6.22165911e-02f, 2.02008039e-02f, 1.95066571e-01f, -1.20478757e-01f, -3.92747521e-02f, -3.97452675e-02f, 1.28620386e-01f, 1.61749035e-01f, 1.33635804e-01f,
  -9.64572132e-02f, 1.24370540e-03f, 3.35192531e-02f, -6.81850612e-02f, 1.45382896e-01f, 3.22817266e-02f, -2.55277175e-02f, -4.06252779e-02f, -4.52220365e-02f, 1.49035379e-01f,
  -4.00586903e-01f, 7.83328041e-02f, -2.24029779e-01f, -1.93501115e-01f, 6.09349124e-02f, 4.89535108e-02f, 5.03403284e-02f, 3.34924422e-02f, 2.50568576e-02f, 2.38483939e-02f,
  1.81229755e-01f, -2.99732061e-03f, 9.64847952e-02f, 2.03082431e-02f, -1.72087565e-01f, 9.05489270e-03f, -6.52737841e-02f, -1.64811462e-01f, -1.04282252e-01f, 3.82072628e-02f,
  -1.77167162e-01f, -2.61528730e-01f, -3.84812593e-01f, -2.07551599e-01f, -1.86935082e-01f, -5.65065324e-01f, -2.29915798e-01f, -2.64588714e-01f, -1.71154693e-01f, -3.03724319e-01f,
  -7.90872395e-01f, 3.73240769e-01f, 2.15481713e-01f, -3.89342576e-01f, 1.87195465e-01f, 3.07141602e-01f, 4.11040604e-01f, 1.89045742e-01f, 4.20610979e-02f, 3.43720689e-02f,
  -3.13897729e-02f, -1.53408334e-01f, 5.29015809e-02f, -2.37034168e-02f, -8.70613090e-04f, 2.99680263e-01f, 3.05881292e-01f, -2.09502161e-01f, -3.20198536e-01f, -2.23736241e-01f,
  -4.34188321e-02f, -3.34251642e-01f, -5.57710588e-01f, -1.41316757e-01f, -2.21379306e-02f, -1.32491425e-01f, 1.20130174e-01f, -4.27075736e-02f, 2.14984819e-01f, 2.04710234e-02f,
  -3.01132411e-01f, -1.07056715e-01f, -1.19607933e-01f, -2.82702744e-01f, -1.02535069e-01f, -1.12744667e-01f, -5.48159480e-02f, -1.85311288e-01f, -2.25466136e-02f, -2.96520777e-02f,
  -1.26949891e-01f, 5.18816477e-03f, -1.27000501e-03f, -1.71486121e-02f, -1.88909128e-01f, -1.04569815e-01f, -1.43947825e-01f, -1.12372085e-01f, -4.87228036e-02f, 5.43114990e-02f,
  2.49781683e-01f, -2.45056301e-01f, -2.19208091e-01f, 1.86346173e-01f, 1.25584543e-01f, -1.57874733e-01f, 2.18899152e-03f, -7.38277659e-02f, -4.52662036e-02f, -2.88870364e-01f,
  -3.26560922e-02f, -2.43740082e-02f, 4.31390516e-02f, 1.30151287e-01f, 2.72746366e-02f, 1.10550582e-01f, 8.92797187e-02f, 1.30325869e-01f, -5.88277495e-03f, -1.00173458e-01f,
  1.84177652e-01f, -1.79527812e-02f, 5.09305950e-03f, -1.04440153e-02f, -4.42534164e-02f, -6.96376860e-02f, 2.69805584e-02f, 3.39944214e-02f, 1.86101813e-02f, 1.79520100e-02f,
  -5.65771386e-02f, -2.97995843e-02f, -5.38781136e-02f, -1.55933201e-02f, 4.79075350e-02f, 6.92605078e-02f, -1.42542988e-01f, -6.34454340e-02f, -7.23258555e-02f, 1.13106303e-01f,
  -2.06594422e-01f, 5.17431460e-02f, -3.51352215e-01f, -8.18992481e-02f, -1.02945775e-01f, -2.62150019e-02f, -8.71670782e-04f, -3.92485559e-02f, -2.44264156e-02f, -3.31448242e-02f,
  2.74314191e-02f, 2.35777628e-02f, 8.16720054e-02f, 1.51205193e-02f, -1.34293884e-01f, -2.59732120e-02f, -1.21858977e-01f, -1.73888907e-01f, -1.18013293e-01f, -8.26482251e-02f,
  6.01161122e-02f, -3.09342444e-01f, -5.28667867e-01f, -8.76049250e-02f, -1.53208345e-01f, -3.86227876e-01f, -1.90996006e-01f, -2.51033306e-01f, -1.93554118e-01f, -4.40869898e-01f,
  -6.66381240e-01f, 1.11964814e-01f, -1.90935940e-01f, -4.75886583e-01f, -2.53445894e-01f, -1.50076672e-02f, 2.41706684e-01f, 7.55162463e-02f, -1.68958023e-01f, 1.26969501e-01f,
  1.26672462e-01f, -1.08690180e-01f, -2.70778596e-01f, -1.25960916e-01f, -8.63958225e-02f, 3.76100801e-02f, -3.11300129e-01f, -4.33282286e-01f, -1.74606323e-01f, 1.91950232e-01f,
  5.63212335e-02f, -2.44901791e-01f, -2.99370348e-01f, -1.90416545e-01f, -7.77948126e-02f, -1.49866164e-01f, -1.98714614e-01f, -3.08767885e-01f, -1.52167812e-01f, -3.89889807e-01f,
  4.13659185e-01f, -2.82141507e-01f, 1.43754501e-02f, -3.73863161e-01f, 1.06079549e-01f, 2.44845543e-02f, 1.08854301e-01f, -1.16657995e-01f, -1.96114168e-01f, 6.63689896e-02f,
  -2.60520071e-01f, 5.85644245e-02f, -1.78955585e-01f, -1.31585188e-02f, 1.31736780e-02f, 4.93275002e-02f, -1.26894549e-01f, -1.27169132e-01f, -7.78670013e-02f, 2.27353066e-01f,
  9.33876634e-02f, -3.05992961e-01f, -1.69324726e-01f, 1.56982705e-01f, 1.46283016e-01f, -1.47234783e-01f, 1.93663523e-01f, 6.33215383e-02f, -1.53396070e-01f, 6.77700192e-02f,
  1.64283171e-01f, 4.71823402e-02f, 1.20274890e-02f, 1.33718967e-01f, 7.67119303e-02f, 9.08986572e-03f, 1.07959695e-01f, 4.97421362e-02f, 5.16969711e-02f, 9.00367424e-02f,
  4.65448536e-02f, 1.12680860e-01f, 1.09328300e-01f, -7.41993485e-04f, -7.58222193e-02f, -4.52462584e-02f, -1.53950145e-02f, 1.44313872e-01f, 1.36139030e-02f, -9.50322971e-02f,
  -1.91268668e-01f, 2.32668407e-02f, -5.30158952e-02f, 1.15172625e-01f, -7.91573152e-02f, 7.97069073e-03f, -2.08797473e-02f, 7.18594044e-02f, 4.11708057e-02f, -5.29607721e-02f,
  2.02809319e-01f, -1.84513837e-01f, 4.65158513e-03f, -1.53069302e-01f, -2.27250764e-03f, 3.03489808e-02f, -5.61866350e-02f, 3.29890251e-02f, -1.78994849e-01f, 1.01261005e-01f,
  -3.64789590e-02f, 1.61375359e-01f, 3.75189334e-02f, 1.02554649e-01f, 1.10011913e-01f, 3.73607166e-02f, 6.58433512e-02f, -1.05981678e-01f, -9.42916125e-02f, 1.34465963e-01f,
  -5.94152696e-02f, -1.95414722e-01f, -1.11130647e-01f, 4.83675301e-02f, 2.60617025e-02f, -2.00412691e-01f, 1.63334027e-01f, 1.03053086e-01f, -1.68352768e-01f, 3.25042129e-01f,
  -8.81849527e-01f, -3.09186783e-02f, 1.54589534e-01f, -4.96442690e-02f, 2.02647611e-01f, 1.88128680e-01f, 2.92955577e-01f, 2.18672946e-01f, 1.64808601e-01f, 3.40181440e-02f,
  3.28403190e-02f, -6.88890517e-02f, -7.15495571e-02f, 4.34501702e-03f, -5.59299737e-02f, 1.93121091e-01f, 2.43890464e-01f, -9.95495170e-02f, -1.54166408e-02f, 1.29430041e-01f,
  2.11828258e-02f, -2.05823466e-01f, -2.82032162e-01f, -5.02134487e-02f, 2.08797351e-01f, -4.88139950e-02f, 5.72215058e-02f, -4.25890908e-02f, 1.33357598e-02f, 2.28241906e-01f,
  2.91309953e-01f, -2.40475938e-01f, 9.91690010e-02f, -2.77944654e-02f, -1.00516923e-01f, 2.04419773e-02f, -6.17800541e-02f, 1.06752791e-01f, 2.20993310e-02f, 1.07668132e-01f,
  2.72582788e-02f, 4.04542452e-03f, -1.31299153e-01f, -3.95941772e-02f, 1.26055285e-01f, 5.80591261e-02f, 3.63443010e-02f, -3.20839249e-02f, 1.56843245e-01f, 1.95957229e-01f,
  3.69986519e-02f, 1.15944818e-01f, 1.29839912e-01f, 1.82972718e-02f, -2.07550913e-01f, 7.21129328e-02f, -6.95925653e-02f, 1.84425376e-02f, -8.60707462e-03f, -5.00243157e-02f,
  1.08613804e-01f, 1.81838393e-01f, -8.67199302e-02f, -1.36396259e-01f, -1.89453408e-01f, 8.33688229e-02f, -7.23476894e-03f, -3.39830071e-02f, -1.26520783e-01f, -2.39266619e-01f,
  1.28191277e-01f, 4.64804359e-02f, 7.16221705e-02f, -1.51517048e-01f, 1.92209668e-02f, 1.37825891e-01f, 5.36801992e-03f, 3.37075293e-02f, -2.07623448e-02f, 7.20389634e-02f,
  -1.26668304e-01f, 8.11877921e-02f, 2.26791725e-02f, 1.18410960e-01f, 1.52007505e-01f, 5.98330013e-02f, 4.43283841e-02f, -2.27619931e-02f, 1.13105979e-02f, 1.69671476e-01f,
  2.97490925e-01f, -3.24560612e-01f, 9.16631799e-03f, -3.73224984e-03f, -2.26216279e-02f, -6.75482675e-02f, -9.02058259e-02f, -4.15023603e-02f, 7.70159811e-02f, 1.20507941e-01f,
  8.29917863e-02f, 2.58102324e-02f, 2.86276452e-02f, -4.13207477e-03f, -4.85262573e-02f, -9.97260138e-02f, -9.54794697e-03f, 8.03098381e-02f, 1.47119507e-01f, 2.12360382e-01f,
  1.41962871e-01f, 8.66491720e-02f, 1.82690188e-01f, 3.85794267e-02f, -9.52394158e-02f, -4.88750152e-02f, -2.64436305e-02f, -2.17327080e-03f, 1.03194397e-02f, 2.87222099e-02f,
  8.45021129e-01f, -5.60268164e-01f, -6.31539583e-01f, 2.35798940e-01f, 1.32926792e-01f, 3.01656630e-02f, -1.64315430e-03f, 2.05052212e-01f, 2.03065544e-01f, -1.88853905e-01f,
  -9.89857614e-02f, 5.36631122e-02f, -1.79778948e-01f, -1.00826196e-01f, 1.05380833e-01f, -2.70557195e-01f, -3.36767018e-01f, -2.51983013e-02f, 4.45688784e-01f, 3.92934978e-01f,
  2.25977749e-01f, 2.87884504e-01f, 3.83875400e-01f, 2.84177214e-02f, -2.47626752e-01f, -3.89118306e-02f, -3.97937715e-01f, -1.36871979e-01f, -2.94895887e-01f, -4.52377111e-01f,
  -4.56461668e-01f, -1.63184091e-01f, 1.78700760e-01f, 2.91104820e-02f, -9.20313448e-02f, 7.33854398e-02f, 6.34204298e-02f, 8.46574549e-03f, 4.88645621e-02f, -7.35975355e-02f,
  -1.22760087e-02f, 8.25321004e-02f, -7.35538527e-02f, -4.17752825e-02f, 3.22994888e-02f, -7.20337629e-02f, -5.56050800e-02f, 4.95264679e-03f, -3.73139642e-02f, -5.41150980e-02f,
  -2.53135830e-01f, -5.62215857e-02f, 8.04596245e-02f, -1.02630600e-01f, -9.27200634e-03f, 1.04308138e-02f, -7.02415779e-02f, -9.23051313e-02f, -5.22102825e-02f, -7.26431832e-02f,
  -1.00978941e-01f, -6.68982556e-03f, 2.20716119e-01f, 2.66511410e-01f, 1.54999599e-01f, 1.11884758e-01f, 5.95441163e-02f, 2.02192858e-01f, 1.43396348e-01f, -5.65131311e-04f,
  1.17420837e-01f, 1.48564251e-02f, 7.73613527e-02f, 1.81835499e-02f, -1.95342582e-02f, -1.50601584e-02f, 4.94369380e-02f, 1.98139763e-03f, 3.59674655e-02f, 1.40777960e-01f,
  1.80942908e-01f, 1.72640041e-01f, 9.20900106e-02f, 6.56873956e-02f, 6.02265783e-02f, 1.88667718e-02f, 5.56014385e-03f, 4.84688021e-02f, 1.82353094e-01f, 5.44068217e-02f,
  1.45417908e-02f, 2.88244337e-02f, -9.31365788e-02f, -6.26759380e-02f, -7.47125968e-02f, -1.03720188e-01f, -1.23481922e-01f, 1.17362656e-01f, -3.96245942e-02f, 7.58392224e-03f,
  6.30173013e-02f, 7.35238418e-02f, -1.42002285e-01f, -4.20366041e-02f, 2.18958125e-01f, 1.46609709e-01f, -5.58324764e-03f, -1.27684530e-02f, -1.37860058e-02f, -1.13047019e-01f,
  -9.63025466e-02f, 1.18944496e-01f, 1.32577196e-01f, 1.90647449e-02f, -2.25290563e-03f, 2.37454057e-01f, 7.11396784e-02f, 8.01065639e-02f, 8.39566216e-02f, 1.03232838e-01f,
  7.10135579e-01f, 4.02782142e-01f, 2.05162689e-01f, 3.25586379e-01f, 3.60437930e-01f, 2.59600133e-01f, 1.46959901e-01f, -2.65338365e-02f, -1.61315911e-02f, 1.59673929e-01f,
  2.83039749e-01f, 1.70903280e-01f, 1.11423060e-01f, -6.62503764e-02f, -9.30447206e-02f, -1.05647989e-01f, -1.88324139e-01f, 1.95807200e-02f, 8.80903527e-02f, 1.34461090e-01f,
  1.25281960e-01f, 1.04721844e-01f, 1.53020635e-01f, 2.28788592e-02f, 1.44564658e-01f, 1.05783418e-01f, 1.00669689e-01f, 2.57738203e-01f, 1.59069240e-01f, 7.40564615e-02f,
  3.06575894e-01f, 3.24620366e-01f, -2.47757792e-01f, 4.83418554e-02f, 1.94231510e-01f, -1.80367738e-01f, 4.74129841e-02f, -1.03056237e-01f, -2.95571443e-02f, -1.59570515e-01f,
  8.04100838e-03f, 3.66249541e-03f, 1.36962578e-01f, -5.36609031e-02f, -2.98266299e-02f, 1.90140102e-02f, -1.14222065e-01f, -6.15881346e-02f, -1.04571126e-01f, 4.37090062e-02f,
  1.45964622e-01f, 1.62483931e-01f, 1.61045611e-01f, -3.33111137e-02f, 1.66471992e-02f, 1.43821076e-01f, 1.16813511e-01f, 2.32402440e-02f, -3.34415287e-02f, 5.66360587e-03f,
  2.36326292e-01f, 3.54043037e-01f, 3.60274017e-01f, 4.64035869e-02f, 1.31045446e-01f, -3.56939659e-02f, -1.17571600e-01f, 6.40256479e-02f, 3.16828266e-02f, 1.08178064e-01f,
  -7.36783594e-02f, 9.02001560e-02f, -1.37057722e-01f, 4.91489172e-02f, 1.55908437e-02f, 1.55725509e-01f, 5.25480509e-02f, 3.65650281e-03f, 1.36130244e-01f, -8.11813399e-02f,
  8.48458707e-02f, -1.51154831e-01f, -6.00240044e-02f, -1.28765568e-01f, -4.60389294e-02f, 8.81698057e-02f, 1.37350738e-01f, 1.55076414e-01f, 1.56260014e-01f, 1.74695313e-01f,
  -3.09958160e-01f, 5.17039038e-02f, -1.81100219e-01f, -2.16179922e-01f, 1.39283597e-01f, -1.01107448e-01f, 1.34670481e-01f, -1.30566582e-01f, 3.02166529e-02f, -7.21827373e-02f,
  -4.79422435e-02f, 1.58951432e-02f, -4.24307920e-02f, -8.38745683e-02f, -1.26529798e-01f, -7.76522905e-02f, -2.64383666e-02f, -9.33958143e-02f, -2.08455563e-01f, -2.36040473e-01f,
  -1.92433536e-01f, -1.78534895e-01f, -1.61609486e-01f, -2.42547035e-01f, -9.37371403e-02f, -1.46932080e-01f, -1.67006820e-01f, -5.25152590e-03f, -1.22920938e-01f, -1.77472323e-01f,
  9.45266187e-02f, -5.26092112e-01f, 2.83201128e-01f, 2.24863797e-01f, 3.29111606e-01f, 3.18460733e-01f, 3.49143535e-01f, 1.67424202e-01f, 1.30241439e-01f, -1.25257134e-01f,
  -1.07029945e-01f, -7.74234310e-02f, -7.62611115e-03f, -4.31980528e-02f, 1.16153937e-02f, 6.78124651e-02f, 1.70489445e-01f, 3.06678146e-01f, 2.70673513e-01f, -4.23668884e-02f,
  -1.43056005e-01f, -8.66520554e-02f, 2.62454357e-02f, -7.99131915e-02f, -2.79545546e-01f, -7.59873614e-02f, 2.41367761e-02f, 7.52231926e-02f, -7.24840462e-02f, -3.46077472e-01f,
  1.35401174e-01f, 3.27410936e-01f, -2.11393144e-02f, -3.76257971e-02f, -1.08343765e-01f, -7.25506619e-02f, 3.26347277e-02f, -7.18901306e-02f, -1.66644417e-02f, -8.88542160e-02f,
  6.25961795e-02f, 3.33539546e-02f, 1.65264621e-01f, 1.52829541e-02f, 8.39865953e-02f, 1.31359771e-01f, 7.10589662e-02f, 9.77609828e-02f, 6.45371750e-02f, 5.44734597e-02f,
  -1.02964565e-01f, 2.33628809e-01f, 3.38528484e-01f, 2.37559244e-01f, 1.21274807e-01f, 1.06086157e-01f, 8.27510953e-02f, 1.97930485e-02f, 9.69725624e-02f, -7.33288527e-02f,
  2.05056548e-01f, 1.28150536e-02f, 1.90633014e-01f, 1.40028760e-01f, 1.41016215e-01f, 1.22302853e-01f, -7.65467156e-03f, 7.76101649e-02f, 1.58216149e-01f, 1.20811500e-01f,
  -2.39366442e-02f, 1.22054935e-01f, 1.20125555e-01f, 2.61176806e-02f, -3.23017240e-02f, -1.84207410e-02f, 1.81358180e-03f, 3.69053669e-02f, 1.41222969e-01f, 1.46581575e-01f,
  2.06774741e-01f, 1.39712635e-02f, -8.17114860e-02f, 5.75686842e-02f, -1.00461379e-01f, 8.61320943e-02f, 8.19391459e-02f, -2.41520908e-02f, 2.99045183e-02f, -1.92985177e-01f,
  2.13763312e-01f, 6.40415728e-01f, -1.47785917e-01f, -5.65783717e-02f, -1.30940020e-01f, -2.02451691e-01f, 3.25026480e-03f, -1.72130197e-01f, -9.63329822e-02f, 8.23417678e-02f,
  6.33490011e-02f, -6.09860420e-02f, 8.00759122e-02f, 1.73604451e-02f, 1.16453230e-01f, -8.80246162e-02f, -2.10281000e-01f, -8.66037607e-02f, -5.98904416e-02f, -1.30610198e-01f,
  -1.05283409e-01f, -1.56655861e-03f, 1.06862515e-01f, 8.91452581e-02f, -5.69701679e-02f, 4.03317213e-02f, -8.09911862e-02f, -1.79533362e-02f, 1.39618963e-01f, -8.20535645e-02f,
  -4.20144737e-01f, -6.65408432e-01f, 6.86412752e-01f, -7.00589642e-02f, 3.56806397e-01f, 2.84872830e-01f, 1.78402871e-01f, -2.82413568e-02f, -7.85459671e-03f, 1.06756754e-01f,
  -2.31255218e-01f, -3.23475629e-01f, -2.62527853e-01f, -2.83580542e-01f, -2.57329583e-01f, 1.56022713e-01f, 2.90641308e-01f, 2.30711952e-01f, 2.55312860e-01f, 2.13522017e-02f,
  -2.67697096e-01f, -1.15691602e-01f, -3.10666591e-01f, -8.09926242e-02f, -4.70861560e-03f, 3.88218760e-02f, 9.57235843e-02f, -1.51343867e-01f, -9.23506394e-02f, 3.88806127e-02f,
  3.82171333e-01f, -4.62794602e-01f, 1.85988545e-01f, -3.07876945e-01f, -3.84597108e-02f, -1.47114441e-01f, 6.65496588e-02f, -6.48679510e-02f, -1.22495361e-01f, 2.68331589e-03f,
  -9.12703350e-02f, -2.24599212e-01f, -9.83781368e-02f, -4.55843471e-02f, -2.15882785e-03f, 5.82273714e-02f, -2.33383358e-01f, -2.10077226e-01f, -1.72546536e-01f, -1.10605143e-01f,
  -3.70917916e-01f, -7.57474303e-02f, 1.70972481e-01f, 4.62021958e-03f, -1.42210186e-01f, -6.37354255e-02f, -3.25647295e-02f, -1.58200055e-01f, 1.70885511e-02f, 1.09939471e-01f,
  4.48489375e-02f, 9.59052220e-02f, -9.14106518e-02f, 1.18966118e-01f, -1.10978493e-02f, 2.07101349e-02f, 4.79069166e-02f, -1.91002879e-02f, 8.82650763e-02f, 1.50980040e-01f,
  -6.40504584e-02f, 4.27834056e-02f, 1.10459775e-01f, -8.30371752e-02f, 3.17930686e-03f, 2.60004960e-02f, 9.66298506e-02f, -1.00859329e-01f, 5.24561852e-02f, -1.71751902e-02f,
  -1.23325147e-01f, 4.08993773e-02f, 9.79909557e-04f, 2.75498275e-02f, -4.02096957e-02f, -1.16389906e-02f, -2.61815395e-02f, -4.36141714e-02f, -3.52187529e-02f, -1.31514529e-02f,
  1.63158059e-01f, -2.96592742e-01f, 1.06185980e-01f, -1.53845236e-01f, -3.51605304e-02f, -2.56763726e-01f, -1.28194734e-01f, -1.36311784e-01f, -2.60498207e-02f, -4.42618579e-02f,
  -2.37755433e-01f, -8.76915157e-02f, -3.17496173e-02f, -2.77839825e-02f, 3.11160028e-01f, 8.82990938e-03f, -1.26724452e-01f, 1.05507195e-01f, -9.41704214e-02f, 6.32005855e-02f,
  -6.94488138e-02f, 6.64896071e-02f, 2.76951909e-01f, 1.93840593e-01f, 3.34125161e-02f, 2.83959121e-01f, 2.87426025e-01f, 2.37065136e-01f, 2.31119886e-01f, 2.21955150e-01f,
  6.49793267e-01f, 3.53329480e-01f, 8.75287503e-02f, 1.24871634e-01f, -9.93464589e-02f, -2.45277006e-02f, 2.49419972e-01f, 6.03840165e-02f, 5.69009967e-02f, 1.27765536e-01f,
  4.19201422e-03f, -1.17786810e-01f, 7.85733536e-02f, 5.01903817e-02f, 2.11779505e-01f, 2.05846280e-01f, 7.15593696e-02f, 2.35627741e-01f, 1.59465402e-01f, 1.06750429e-01f,
  5.35558723e-02f, 1.21124893e-01f, 1.79244086e-01f, 8.91234353e-02f, 6.94948956e-02f, -9.84365121e-03f, 6.69702590e-02f, 1.12911217e-01f, 5.36116064e-02f, 2.36334965e-01f,
  2.65436739e-01f, 2.72442132e-01f, -3.12154651e-01f, -1.42980635e-01f, -7.74337947e-02f, 7.62278140e-02f, -9.50306561e-03f, -9.79035795e-02f, -5.94369359e-02f, -2.32001171e-02f,
  -9.00396630e-02f, -4.44829538e-02f, -6.23238720e-02f, -4.66909725e-03f, -9.58849713e-02f, 3.36204991e-02f, 1.22292973e-02f, 5.53867482e-02f, 7.24186152e-02f, -5.64450212e-02f,
  -1.66183516e-01f, -4.07605581e-02f, -1.59861550e-01f, -6.53096363e-02f, 6.32154047e-02f, -1.35563985e-01f, -4.52161185e-04f, 1.53549612e-02f, -6.02238812e-02f, -3.22606415e-02f,
  -6.04623407e-02f, 4.14982550e-02f, 6.42528608e-02f, 9.10960659e-02f, 1.69951037e-01f, 8.03606659e-02f, -1.73068903e-02f, -3.65856923e-02f, 1.07381687e-01f, 7.67280115e-03f,
  -4.31094207e-02f, -4.49881256e-02f, 4.19148430e-02f, -7.83859119e-02f, -5.95500730e-02f, -5.40128276e-02f, -3.38603999e-03f, 6.92383647e-02f, 5.04946746e-02f, -8.99851620e-02f,
  2.93505494e-03f, 1.42209763e-02f, -1.05327092e-01f, 3.79013568e-02f, -2.02303361e-02f, -5.94798513e-02f, -3.38148698e-02f, -8.91481619e-03f, -1.90007985e-02f, 5.03399372e-02f,
  -1.60753265e-01f, -1.90164417e-01f, 3.98036204e-02f, -2.63964925e-02f, -7.98788108e-03f, -1.21997394e-01f, 3.73701528e-02f, -5.39706685e-02f, -2.30627712e-02f, 2.20572166e-02f,
  -6.88228011e-02f, -3.82940844e-02f, -2.48326845e-02f, 2.88664456e-02f, -5.44064231e-02f, -1.67242154e-01f, -7.40951970e-02f, 3.48602943e-02f, -1.15988322e-01f, -1.30764514e-01f,
  -8.57614949e-02f, -2.19390616e-01f, -2.70948708e-01f, -8.57727975e-02f, -6.29186109e-02f, -1.29282728e-01f, -1.71424046e-01f, -1.73405409e-01f, -2.15382665e-01f, -1.49478808e-01f,
  8.83039013e-02f, -3.12583856e-02f, -2.93073028e-01f, 1.22859649e-01f, 2.87482351e-01f, -9.37958732e-02f, -3.26505840e-01f, -2.36128062e-01f, 1.66046456e-01f, -4.66524288e-02f,
  2.29148805e-01f, 1.06764540e-01f, -1.14613071e-01f, -2.86719799e-01f, -6.51461363e-01f, -5.14156997e-01f, -5.25975883e-01f, -6.13310516e-01f, -4.37704861e-01f, -9.04052984e-03f,
  1.92391634e-01f, -5.66966366e-04f, -1.98163882e-01f, -1.30244449e-01f, 3.52104813e-01f, 1.65789366e-01f, 4.01932411e-02f, 1.36864007e-01f, -2.32877415e-02f, 8.25387910e-02f,
  -3.67737859e-02f, 4.11542319e-02f, -1.07511498e-01f, 9.62151866e-03f, 1.04936354e-01f, -4.62328531e-02f, -1.02669671e-01f, -5.80206551e-02f, -8.76266286e-02f, -4.46324125e-02f,
  1.72375023e-01f, -8.65491405e-02f, 5.02330437e-02f, -1.66639201e-02f, -2.55648810e-02f, -1.19655967e-01f, -1.16381496e-01f, -3.17479134e-01f, -2.34008774e-01f, -5.28111979e-02f,
  1.09178081e-01f, 8.12960565e-02f, -2.01490849e-01f, -1.22409046e-01f, -1.27268225e-01f, -3.29826139e-02f, 1.08830482e-01f, 1.81595936e-01f, -6.21202327e-02f, 1.67417809e-01f,
  -5.56755960e-02f, -5.03483601e-02f, 3.33662666e-02f, 8.76950391e-04f, 2.41307802e-02f, 1.43258154e-01f, 4.33536107e-03f, -6.77072480e-02f, -1.18356361e-03f, -7.85579830e-02f,
  -7.50587136e-02f, 1.86321437e-02f, 3.84028926e-02f, -4.27927598e-02f, 3.06872670e-02f, 4.12643794e-03f, -3.04873046e-02f, -3.83876562e-02f, -7.91431218e-02f, -6.02760650e-02f,
  -8.24278295e-02f, 3.85493040e-02f, 1.47663504e-01f, 1.24164009e-02f, -4.94302660e-02f, -6.85576797e-02f, 7.02175722e-02f, 9.40633472e-03f, 1.09197106e-02f, -1.44873140e-02f,
  4.53685410e-02f, -1.14933647e-01f, 4.16168710e-03f, -1.93261474e-01f, -1.00953564e-01f, 8.68481472e-02f, 8.27386156e-02f, -3.03859096e-02f, -3.69356647e-02f, 1.60311684e-02f,
  -7.60104954e-02f, -8.20583180e-02f, 7.13139623e-02f, -1.37657691e-02f, -4.63285185e-02f, 5.62898628e-02f, -1.10399574e-01f, -2.82500591e-02f, -1.12502307e-01f, 2.10915729e-01f,
  -1.38522997e-01f, -2.20873699e-01f, -1.86052859e-01f, -1.71940416e-01f, 3.14874016e-02f, -1.29958838e-01f, -1.52663901e-01f, 3.33344266e-02f, -3.57723057e-01f, -2.29980111e-01f,
  4.97511685e-01f, -1.22541353e-01f, 1.23914436e-01f, -1.97633747e-02f, -1.66584983e-01f, -1.77214310e-01f, -3.60198438e-01f, -1.57307506e-01f, -1.04338685e-02f, 1.06688887e-02f,
  1.66293487e-01f, 1.21507384e-01f, 1.31197408e-01f, 1.88393563e-01f, -4.55052219e-02f, -1.72091499e-01f, -1.20759048e-01f, 2.18357146e-01f, 5.07752523e-02f, -8.61626863e-02f,
  -9.78607088e-02f, -2.86969752e-03f, 1.92906916e-01f, 9.26512554e-02f, 5.79976887e-02f, 6.77884594e-02f, -3.07148229e-03f, -4.67829071e-02f, 8.52621347e-03f, 1.37979209e-01f,
  2.75135100e-01f, 2.46395051e-01f, 6.38233051e-02f, 8.76670144e-03f, 9.18127447e-02f, 3.50373657e-03f, 2.18833536e-02f, 2.95452140e-02f, -2.06778854e-01f, -1.47070020e-01f,
  -6.39052242e-02f, 1.61655307e-01f, 1.06074944e-01f, 3.40204351e-02f, -1.17512390e-01f, -1.08071268e-02f, 7.85750374e-02f, -2.61382684e-02f, -1.29794732e-01f, 8.49444717e-02f,
  3.95332910e-02f, -5.43251038e-02f, -6.49231821e-02f, -2.13930458e-01f, 1.04736956e-02f, 5.10003045e-02f, 5.04063107e-02f, -1.12734232e-02f, 1.69540802e-03f, -1.15112789e-01f,
  5.95714897e-03f, -1.31292179e-01f, 1.21747352e-01f, 1.75580859e-01f, 8.48552659e-02f, -4.90316786e-02f, -5.31095937e-02f, -7.09915608e-02f, -3.77105363e-02f, 5.18449098e-02f,
  -1.57431275e-01f, 3.32642943e-02f, 6.83196634e-02f, -2.67731072e-03f, 2.94761002e-01f, 1.46431088e-01f, 2.93677524e-02f, 3.42122279e-02f, 7.69973621e-02f, 1.30446538e-01f,
  1.04698554e-01f, -6.60198182e-02f, -9.62311868e-03f, -1.11600116e-01f, 2.23219357e-02f, -1.12557963e-01f, -8.85090381e-02f, 2.08469275e-02f, 1.18904606e-01f, -5.34729846e-02f,
  -1.32106259e-01f, 4.56909597e-01f, 2.53276020e-01f, 1.38013750e-01f, 4.48403414e-03f, 1.25682428e-02f, 1.51862249e-01f, -4.53677811e-02f, -9.32038650e-02f, -1.93324927e-02f,
  8.07361007e-02f, 1.44122615e-01f, 2.70245448e-02f, -9.36340988e-02f, -4.94111776e-02f, 2.87164561e-02f, 9.19400603e-02f, 9.67861433e-03f, 2.98260916e-02f, 3.00176553e-02f,
  -5.15834130e-02f, -1.31887540e-01f, 2.31140070e-02f, -9.30943154e-03f, -3.35638896e-02f, 1.38505772e-01f, 9.05127004e-02f, -1.09796152e-01f, 7.31384382e-02f, -1.99514210e-01f,
  -2.49949947e-01f, -5.17279863e-01f, 5.80389500e-02f, -3.12444031e-01f, -9.31824185e-03f, 3.59067738e-01f, 1.74311340e-01f, -1.05404019e-01f, -1.64002493e-01f, -3.03275675e-01f,
  -3.04477155e-01f, -1.06690317e-01f, -3.08665276e-01f, -1.25062838e-01f, -2.34733999e-01f, -2.53768682e-01f, -3.56493473e-01f, -3.42982798e-03f, 3.37558091e-01f, 3.84672254e-01f,
  7.98621215e-03f, -1.11138292e-01f, -1.69952288e-01f, -2.01023743e-01f, -2.42469192e-01f, -6.35392964e-02f, -3.24742436e-01f, -3.18687528e-01f, -1.10856548e-01f, -4.93379325e-01f,
  2.09355325e-01f, -4.40743156e-02f, 1.13224857e-01f, -7.97342509e-02f, 4.11069319e-02f, -9.02630985e-02f, 4.73781861e-02f, 6.16148897e-02f, 8.76553804e-02f, 3.63096669e-02f,
  -1.00055322e-01f, -4.26645204e-02f, 6.84975535e-02f, -3.74910975e-04f, 1.20432757e-01f, 1.75820783e-01f, 7.57117197e-02f, -2.12423261e-02f, -1.23674072e-01f, 1.86613656e-03f,
  -6.30538119e-03f, 1.03331059e-01f, 1.46034017e-01f, 1.59426451e-01f, 1.49912789e-01f, 2.78450307e-02f, 1.04365699e-01f, 1.07527927e-01f, 1.11728773e-01f, 1.45292535e-01f,
  1.41748250e-01f, 1.55669540e-01f, 1.41810447e-01f, 2.56893486e-01f, 2.10517183e-01f, 2.08020806e-01f, 1.14680544e-01f, -2.68360339e-02f, -6.24715388e-02f, -4.94278073e-02f,
  -1.51533216e-01f, -6.32826090e-02f, 5.93353771e-02f, -1.09176323e-01f, 1.04503129e-02f, -2.15137657e-02f, -7.35811293e-02f, 4.90030721e-02f, -7.46460855e-02f, -1.62149951e-01f,
  -1.47541344e-01f, -1.75824806e-01f, -1.48797914e-01f, -6.15668334e-02f, -1.22991741e-01f, 3.56135145e-02f, 5.60107119e-02f, -3.70606408e-03f, -9.95406136e-02f, -1.70229986e-01f,
  -1.15178376e-02f, 6.89449981e-02f, -1.82542488e-01f, -1.66021094e-01f, -1.04218230e-01f, -6.09144382e-02f, -4.42509428e-02f, -1.00418240e-01f, -8.82453546e-02f, 1.94467753e-01f,
  7.68200532e-02f, 5.47947995e-02f, -1.00387454e-01f, 8.15035924e-02f, 1.92839861e-01f, 1.66038573e-01f, 2.18183175e-02f, -5.12650535e-02f, -7.50565827e-02f, -1.65771842e-01f,
  -1.10367268e-01f, 6.67416900e-02f, 7.81869367e-02f, 3.91121097e-02f, 8.11959952e-02f, 5.74040562e-02f, 1.86565891e-01f, 1.81941390e-01f, 1.09043047e-01f, 7.58712739e-02f,
  1.78915173e-01f, 8.32469240e-02f, -5.11985049e-02f, 2.00305492e-01f, -2.01648194e-03f, -7.38923326e-02f, 9.44382548e-02f, -1.96563173e-02f, 4.01476212e-02f, 1.65303379e-01f,
  1.57970741e-01f, -6.55335039e-02f, -1.25674875e-02f, -1.08233616e-01f, -1.38388395e-01f, -2.11578850e-02f, -6.36436492e-02f, -2.78791308e-01f, -4.26906377e-01f, -3.79193604e-01f,
  -2.21033916e-01f, -7.40669891e-02f, -1.14619806e-02f, -5.70793375e-02f, -1.15534328e-01f, -2.04182476e-01f, 3.00789028e-02f, -1.08510800e-01f, -1.07358247e-01f, -1.41915083e-01f,
  -1.23449855e-01f, -8.14595148e-02f, -2.12262049e-01f, -1.08906217e-01f, 7.44010285e-02f, 1.19326569e-01f, 3.58319171e-02f, 5.88763617e-02f, 1.30210027e-01f, 1.87840879e-01f,
  -1.34787867e-02f, 1.84972379e-02f, 1.00266263e-01f, 6.75891712e-02f, 9.69045311e-02f, 1.53239584e-02f, 1.29592031e-01f, -3.51532884e-02f, 3.87765877e-02f, 5.56667224e-02f,
  7.31303468e-02f, -3.38965021e-02f, 7.08645508e-02f, -1.56015474e-02f, -1.91568986e-01f, -1.21442236e-01f, -2.72513777e-02f, -1.12925701e-01f, -1.34039789e-01f, 7.91173354e-02f,
  2.22123623e-01f, 2.05510020e-01f, 1.72159791e-01f, 1.21002175e-01f, 1.53584465e-01f, 2.12830454e-01f, 8.88893157e-02f, 2.12562546e-01f, 6.59022629e-02f, 1.18368156e-01f,
  2.03838572e-01f, 2.09316865e-01f, 6.89080283e-02f, 3.25150818e-01f, 2.61932224e-01f, 2.97111660e-01f, 3.17943037e-01f, 4.05713111e-01f, 3.82030785e-01f, 3.62364918e-01f,
  6.67985231e-02f, 2.08388254e-01f, 1.44381583e-01f, 8.44367072e-02f, 8.40678290e-02f, 5.46424538e-02f, 2.18623161e-01f, 1.56877577e-01f, 2.61623651e-01f, 1.42020717e-01f,
  5.76806962e-02f, -9.01883543e-02f, -6.09072633e-02f, -1.55603319e-01f, -1.23637170e-02f, 1.36578307e-01f, 1.14064962e-01f, -2.03044042e-02f, 6.32171780e-02f, 8.87169763e-02f,
  -6.60052523e-02f, 1.26400247e-01f, 6.02496341e-02f, 3.72841186e-03f, 4.03857976e-02f, 3.34219560e-02f, 1.71789810e-01f, -2.45157105e-04f, -2.35728901e-02f, 1.02909856e-01f,
  -6.68034636e-06f, 1.36982203e-01f, 1.00010283e-01f, 3.67972925e-02f, -1.28745347e-01f, -9.92388837e-03f, 3.59619595e-02f, -6.44136816e-02f, 8.95811319e-02f, 1.94619969e-01f,
  -4.43064004e-01f, 2.24097133e-01f, -5.16957760e-01f, -5.30730426e-01f, -3.43249649e-01f, -7.77816549e-02f, 3.67992908e-01f, 1.11234948e-01f, -3.63709360e-01f, -3.30019891e-02f,
  7.94492811e-02f, -1.62588730e-01f, -2.32898101e-01f, 2.50661056e-02f, 2.93665916e-01f, 2.34667379e-02f, -3.41859847e-01f, -3.36782336e-01f, 2.67827027e-02f, 2.61318713e-01f,
  1.65051118e-01f, -1.52598366e-01f, -8.64184648e-02f, -1.30480930e-01f, -2.67377645e-01f, -2.63845205e-01f, -3.31325501e-01f, -1.69999197e-01f, 8.74196589e-02f, -2.73688436e-01f,
  1.94114417e-01f, -1.34164467e-01f, -5.76944947e-02f, -1.87163159e-01f, -2.35043585e-01f, -1.37892559e-01f, -7.23925307e-02f, -3.34275007e-01f, -1.53872252e-01f, -8.72470960e-02f,
  -2.61734635e-01f, -8.00730810e-02f, -1.13339566e-01f, 9.99795925e-03f, -1.19725078e-01f, -1.05521128e-01f, -9.96936634e-02f, -3.11547648e-02f, -1.05868712e-01f, 2.57163525e-01f,
  1.98203847e-01f, -2.57753357e-02f, 4.52611111e-02f, 2.02703610e-01f, 1.73431799e-01f, -1.63564205e-01f, 1.72229454e-01f, 5.35082445e-02f, -1.20239154e-01f, 4.36187051e-02f,
  -7.75377005e-02f, -8.82420763e-02f, 1.24528989e-01f, 1.34920478e-01f, 1.22309998e-01f, 3.88279147e-02f, -2.78745331e-02f, 1.37614176e-01f, 3.78308035e-02f, 1.18237644e-01f,
  4.23774198e-02f, 1.05690822e-01f, 4.90733385e-02f, -3.19955610e-02f, -8.13265666e-02f, 3.25878453e-03f, 1.83930770e-01f, 1.89665392e-01f, -6.92036301e-02f, -5.06399758e-02f,
  -6.58503845e-02f, 3.91838215e-02f, -7.26957470e-02f, 9.45400447e-02f, 1.19197898e-01f, -1.04297139e-01f, -2.64996253e-02f, 1.95110887e-01f, 3.42169553e-02f, -1.45287573e-01f,
  1.38380513e-01f, 2.49959096e-01f, -4.20581251e-02f, -5.12289535e-03f, -2.12759241e-01f, -1.92228213e-01f, -1.22900307e-01f, -7.28209838e-02f, -1.42847314e-01f, 2.36984398e-02f,
  9.89345387e-02f, 2.94101536e-02f, -2.80139092e-02f, 1.31519109e-01f, 6.03143265e-03f, -2.68881582e-02f, 1.83356434e-01f, -3.33276880e-03f, -5.60896378e-03f, -6.28253492e-03f,
  2.27952093e-01f, 1.17576964e-01f, 2.39842147e-01f, 1.32184178e-01f, 8.67667273e-02f, -3.85093465e-02f, 1.37827709e-01f, 2.55724251e-01f, 4.76197638e-02f, 2.94157267e-01f,
  4.45407033e-01f, 2.21223921e-01f, 9.18195769e-02f, 3.03217679e-01f, 3.69705856e-02f, -4.52415258e-01f, -4.99519467e-01f, -2.48629674e-01f, 1.95762038e-01f, 7.93623105e-02f,
  2.43680608e-02f, -8.11470971e-02f, 2.73577720e-02f, -1.19245812e-01f, -3.92340511e-01f, -8.18693340e-02f, -1.34003581e-02f, -4.89418879e-02f, -4.17139381e-01f, -4.66038942e-01f,
  -1.40416995e-01f, -3.24246357e-03f, -1.79401264e-02f, -8.55803192e-02f, 3.81223619e-01f, 4.64420691e-02f, 2.30105385e-01f, 1.69112429e-01f, 7.12745264e-02f, 5.36398768e-01f,
  4.23971027e-01f, 2.83953220e-01f, -3.53511453e-01f, -1.04696359e-02f, 2.20585957e-01f, -2.34629936e-03f, -2.69288719e-02f, 2.23079711e-01f, -6.71840310e-02f, 1.43043250e-01f,
  1.01818874e-01f, 4.99366447e-02f, 9.91639867e-02f, -6.35643974e-02f, 2.26615407e-02f, -8.84371623e-02f, 1.72995427e-03f, -1.03489742e-01f, -4.23891135e-02f, 9.48872492e-02f,
  -2.33183466e-02f, -8.38087872e-03f, 1.01864636e-01f, -1.88686460e-01f, 3.19165103e-02f, -1.69177516e-03f, -1.90198850e-02f, 4.16316874e-02f, -9.08936188e-02f, 3.10988873e-01f,
  -7.23728240e-02f, 1.25448123e-01f, 4.72491002e-03f, 1.10203527e-01f, -7.72682577e-02f, 1.53811023e-01f, 2.10169435e-01f, 6.49737939e-03f, -9.04719532e-03f, -8.66698101e-02f,
  3.97880860e-02f, 7.14615826e-03f, 1.08871140e-01f, 2.63381675e-02f, 2.18598526e-02f, 1.15231998e-01f, -2.86877044e-02f, -3.85086015e-02f, -9.01747216e-03f, 1.57688752e-01f,
  -1.41130509e-02f, 4.01745662e-02f, 2.26351261e-01f, -3.24305519e-02f, 2.43542362e-02f, 8.15579519e-02f, 8.61102417e-02f, -9.42845047e-02f, -1.46802817e-03f, 4.55058105e-02f,
  -6.49649501e-02f, -4.68168110e-01f, 2.41101533e-01f, 3.49927577e-03f, 1.36442661e-01f, 7.14656711e-02f, 6.11730441e-02f, -9.87493619e-02f, 2.23736942e-01f, -6.28593564e-02f,
  -4.20925654e-02f, 3.78473997e-02f, 1.27683342e-01f, -9.10853222e-02f, -1.51316315e-01f, 2.54629161e-02f, -3.82216275e-02f, -2.04059742e-02f, -9.02706087e-02f, 9.47466195e-02f,
  -2.74700616e-02f, -2.55236477e-01f, -3.37478399e-01f, -1.96641251e-01f, -3.08658909e-02f, -1.64780244e-01f, -8.56018439e-02f, -1.54060885e-01f, -2.93586075e-01f, -2.33225361e-01f,
  6.17872238e-01f, -6.75881803e-01f, -2.03929275e-01f, 1.22650854e-01f, 1.52691588e-01f, 2.50210404e-01f, -2.55949143e-02f, -4.50647213e-02f, -3.10843699e-02f, -2.33165771e-01f,
  -2.14600459e-01f, -9.68126208e-02f, -2.03688815e-01f, -2.01636836e-01f, -2.51794755e-01f, -4.91081625e-01f, -3.50142300e-01f, -4.62830178e-02f, 2.08353058e-01f, 1.74955577e-01f,
  -1.04240015e-01f, 3.45210955e-02f, 1.37568235e-01f, -8.68667513e-02f, -2.75114566e-01f, -1.40872225e-01f, -3.05471390e-01f, -1.37943670e-01f, -2.61014760e-01f, -5.08502424e-01f,
  -1.59999669e-01f, 2.68154263e-01f, 1.16440929e-01f, -2.00135112e-01f, 4.52322029e-02f, -1.79760728e-03f, -8.94730724e-03f, -1.17786296e-01f, -1.54381059e-02f, 7.58626545e-03f,
  -3.72500531e-02f, 1.90884117e-02f, 7.83086494e-02f, -1.78897940e-02f, 1.66010603e-01f, 6.77120537e-02f, 8.54212940e-02f, 8.53173435e-02f, -3.39651853e-02f, -8.78910050e-02f,
  -1.10461667e-01f, 2.08302498e-01f, 1.06551684e-01f, 1.33798480e-01f, 2.42951885e-01f, 6.62004352e-02f, -8.93329177e-03f, 3.52566428e-02f, 1.49991438e-01f, 7.32394978e-02f,
  -6.87805861e-02f, -1.03088915e-02f, 1.11775830e-01f, 1.16500147e-01f, 2.09305629e-01f, 1.27261326e-01f, 1.69072211e-01f, 7.14132190e-02f, 1.25522569e-01f, 3.82148139e-02f,
  -9.77239385e-02f, 5.43863773e-02f, 7.52154291e-02f, 1.30198210e-01f, 9.15148109e-03f, -4.73134173e-03f, 7.96411783e-02f, 4.75982726e-02f, 5.04096262e-02f, 1.62954219e-02f,
  8.99581611e-02f, -3.96787226e-02f, -1.15441404e-01f, 2.88332384e-02f, -5.96127994e-02f, -6.32166266e-02f, 2.97367442e-02f, -6.22989796e-02f, -5.46449497e-02f, -9.94317457e-02f,
  4.95720247e-04f, 2.59145349e-01f, -5.44718914e-02f, -2.01032832e-02f, 1.24223121e-01f, -9.61165503e-02f, 7.67718852e-02f, -8.66745934e-02f, -5.93793020e-02f, 1.20153919e-01f,
  7.64226392e-02f, 7.74588902e-03f, 8.75773206e-02f, 1.09775521e-01f, 2.01087832e-01f, 2.53615499e-01f, 8.23135599e-02f, 1.09960288e-01f, -8.37732255e-02f, -2.49224707e-01f,
  -2.23898709e-01f, 9.50567275e-02f, 1.70076098e-02f, 1.31027341e-01f, 1.55114606e-01f, 1.61961704e-01f, 3.89316306e-02f, 1.39315039e-01f, 7.70087317e-02f, 7.51024634e-02f,
  1.39460430e-01f, 1.51325658e-01f, -3.77283186e-01f, -1.99863568e-01f, -3.64990085e-01f, -3.75952035e-01f, -1.46205291e-01f, -2.34969735e-01f, -3.40332150e-01f, -6.85128942e-02f,
  1.22598089e-01f, 2.79808700e-01f, 2.77456939e-01f, 1.93289742e-01f, 3.99312109e-01f, 6.06169626e-02f, -1.64900512e-01f, 9.29778218e-02f, 1.53246254e-01f, -5.31048365e-02f,
  1.63807198e-02f, 5.81915267e-02f, 1.51686281e-01f, -3.68129686e-02f, -2.56090730e-01f, 6.19690642e-02f, -2.05457747e-01f, -2.15205804e-01f, -1.41105846e-01f, -1.59676477e-01f,
  4.09611881e-01f, -4.10147756e-01f, -1.00098900e-01f, -1.46903560e-01f, -9.49889570e-02f, -1.06568165e-01f, -2.34849192e-02f, -1.32023379e-01f, -7.72553757e-02f, -1.58555269e-01f,
  -8.46070722e-02f, -2.49039661e-02f, 2.74352860e-02f, 1.88122073e-03f, -3.33437547e-02f, -1.75394509e-02f, -1.22141996e-02f, -1.43827751e-01f, -1.57941580e-01f, -7.36261457e-02f,
  -6.16117083e-02f, -1.53500110e-01f, -4.85340059e-02f, -5.88327236e-02f, -2.52315730e-01f, -3.01511791e-02f, -9.86657143e-02f, -2.34767064e-01f, -1.77063122e-01f, -4.76321429e-02f,
  -1.31451041e-01f, -2.40510120e-03f, -9.59466100e-02f, -8.17323476e-02f, 2.85675656e-02f, 1.12349167e-01f, 7.13173822e-02f, 1.43807098e-01f, 1.16935872e-01f, 9.40439403e-02f,
  -2.90792659e-02f, -9.14920643e-02f, 4.51319702e-02f, 2.37337314e-02f, 4.66332957e-02f, -4.39287350e-02f, 2.84360982e-02f, 5.69967330e-02f, -1.30259646e-02f, -6.06993213e-02f,
  -1.37086794e-01f, -6.27562851e-02f, -2.71596201e-02f, -3.25347334e-02f, -9.70690995e-02f, -2.87261792e-02f, -1.50387615e-01f, 2.45795716e-02f, 1.26300026e-02f, -6.45642057e-02f,
  5.86623430e-01f, -8.21571797e-02f, 1.01786487e-01f, -1.48608729e-01f, -2.56493837e-01f, -9.59931388e-02f, 4.64315228e-02f, -4.30859923e-02f, 3.86545882e-02f, 4.33315486e-02f,
  -2.03975856e-01f, 1.37104541e-01f, 1.73781469e-01f, 2.04887916e-03f, 6.59210980e-02f, 1.45400260e-02f, 1.47139236e-01f, 2.26629786e-02f, -8.32790062e-02f, -1.62066370e-01f,
  1.24863405e-02f, 4.86496873e-02f, 3.45379710e-01f, 1.06617704e-01f, -7.27458447e-02f, 1.72845140e-01f, 2.12250978e-01f, 6.31621405e-02f, 2.11273342e-01f, 3.62380087e-01f,
  -5.47813058e-01f, -5.55350780e-01f, 4.84154791e-01f, -5.53687572e-01f, -2.74755865e-01f, -1.01229511e-01f, -4.33945984e-01f, -1.00535356e-01f, -1.83500886e-01f, -5.14999032e-01f,
  -1.65141761e-01f, -1.28872721e-02f, 5.88494278e-02f, 3.56319211e-02f, 1.29795283e-01f, -4.02997255e-01f, -2.35651404e-01f, 2.05253914e-01f, 2.65231401e-01f, -1.95545688e-01f,
  -4.38499689e-01f, -1.46612704e-01f, 1.24747314e-01f, 1.15167879e-01f, -6.36654854e-01f, -1.75573945e-01f, -4.90843207e-02f, -2.24005923e-01f, -1.34431735e-01f, -5.84350824e-01f,
  -3.57102811e-01f, 1.09871872e-01f, 2.50569105e-01f, 7.04433545e-02f, -8.11971277e-02f, 1.77366026e-02f, -2.18090825e-02f, 1.55083701e-01f, 3.60023305e-02f, -5.93545986e-03f,
  5.51182814e-02f, 2.86656544e-02f, -3.39006186e-02f, -4.39364649e-02f, -9.80040506e-02f, -2.36495268e-02f, 2.73386501e-02f, 1.41786203e-01f, 6.52786642e-02f, -1.31102011e-01f,
  -2.41840705e-01f, -1.87318146e-01f, 1.06696330e-01f, 1.06844790e-01f, 6.39473349e-02f, 1.78398982e-01f, -1.42676532e-02f, -6.31576255e-02f, 1.82480037e-01f, -5.57453573e-01f,
  -1.12204082e-01f, 4.52655321e-03f, -1.55700622e-02f, 1.06605835e-01f, 6.11748025e-02f, 1.13810316e-01f, -1.07239939e-01f, 1.38953803e-02f, 6.93481490e-02f, -1.57309964e-01f,
  -2.98568849e-02f, 7.90135339e-02f, 1.85977872e-02f, -1.72293216e-01f, -1.45993471e-01f, -7.40513131e-02f, -5.16860932e-02f, -5.35203367e-02f, -5.44233210e-02f, -7.07911104e-02f,
  -2.11955495e-02f, -9.60146040e-02f, 4.53762598e-02f, -8.25964883e-02f, 4.46091220e-02f, 3.19014601e-02f, 3.36791500e-02f, 5.29898517e-02f, -8.57656673e-02f, 7.98747689e-02f,
  -2.08441898e-01f, 5.26463389e-01f, -3.06807667e-01f, 3.78817469e-02f, -8.64256918e-02f, 2.09429227e-02f, -5.13727739e-02f, 1.86027274e-01f, -4.94305380e-02f, -1.73981056e-01f,
  4.78411578e-02f, -2.13460371e-01f, -7.97053128e-02f, -3.80368461e-03f, -4.35580835e-02f, 3.62222232e-02f, -2.07554892e-01f, -1.43929034e-01f, 1.04872063e-01f, -1.37806982e-01f,
  -1.63765207e-01f, -2.03112260e-01f, -2.92069852e-01f, -1.61091223e-01f, -2.53734469e-01f, -5.52071221e-02f, -1.98221028e-01f, -2.29013160e-01f, -5.63799702e-02f, -5.79394519e-01f,
  8.22415650e-01f, -2.48814479e-01f, 1.01031020e-01f, 1.10350296e-01f, -4.05283839e-01f, -2.25772500e-01f, -3.30811709e-01f, 2.43204366e-02f, 1.22052945e-01f, 4.90308143e-02f,
  -1.67821929e-01f, 1.66560173e-01f, 3.32367539e-01f, 2.16717020e-01f, 3.15772504e-01f, 1.21866867e-01f, 3.23997177e-02f, 4.65328485e-01f, 2.98283696e-01f, 2.99415085e-02f,
  -1.32278591e-01f, -2.26841476e-02f, 3.41253161e-01f, 1.66433528e-01f, -1.46697521e-01f, 6.83964789e-03f, -1.13048643e-01f, -1.04996741e-01f, -1.88335806e-01f, 1.07229702e-01f,
  -1.90399900e-01f, -6.34552259e-03f, 8.05161670e-02f, 1.44528002e-02f, -1.71867236e-01f, 1.07652113e-01f, -7.57500576e-03f, -4.96124290e-02f, -1.49444267e-01f, -1.41486108e-01f,
  -1.56065926e-01f, -9.47271511e-02f, -1.22650918e-02f, -4.57008034e-02f, -1.43512711e-01f, -3.28106154e-03f, 1.27169609e-01f, 8.11694860e-02f, 4.68654372e-02f, -1.11402914e-01f,
  -1.15461655e-01f, -1.93132102e-01f, -1.39787242e-01f, -6.96427748e-02f, 6.03948906e-02f, -1.71984416e-02f, -1.27692387e-01f, 6.86855167e-02f, 2.72550862e-02f, 1.35125577e-01f,
  -6.27766252e-02f, 1.72663569e-01f, 1.17669739e-01f, 1.84440076e-01f, 1.16497226e-01f, 1.32684454e-01f, 3.17310041e-04f, -3.19242626e-02f, 1.40015900e-01f, 1.05335005e-01f,
  -2.14695763e-02f, 1.04702652e-01f, 2.52778362e-02f, 6.83852583e-02f, 1.15064360e-01f, 5.35348170e-02f, -9.84073337e-03f, -4.33516949e-02f, 2.82759108e-02f, 1.14245139e-01f,
  1.66328892e-01f, 7.05870315e-02f, 2.79788822e-02f, -4.84094024e-02f, -5.02341539e-02f, -2.13505086e-02f, 2.68229153e-02f, -4.44074487e-03f, -6.53055832e-02f, -6.36387691e-02f,
  -3.06035995e-01f, 1.67162508e-01f, 2.42285237e-01f, 1.83188304e-01f, -1.23777233e-01f, -7.34809190e-02f, 4.14672978e-02f, -1.11043431e-01f, -1.83609784e-01f, -8.67323130e-02f,
  -5.18898666e-02f, 1.45196989e-01f, 6.34845486e-03f, -1.17280409e-02f, 3.10107488e-02f, -2.89254151e-02f, -1.05854226e-02f, 4.50793095e-02f, -1.34416129e-02f, -1.40254825e-01f,
  -6.16212413e-02f, -2.41792994e-03f, 5.70039090e-04f, -4.44422942e-03f, 3.16897519e-02f, 1.52719080e-01f, 6.43545091e-02f, 4.83405590e-02f, 1.33490488e-01f, 2.24672873e-02f,
  9.32123125e-01f, 8.91337097e-02f, 3.79121870e-01f, -4.80758063e-02f, 4.49871197e-02f, 3.14048827e-01f, 5.79859495e-01f, 3.76645654e-01f, -5.85422665e-02f, 2.34714877e-02f,
  -3.38126183e-01f, -5.97070396e-01f, -4.13293362e-01f, -3.64690572e-01f, -7.41064772e-02f, 2.33249560e-01f, 1.75885469e-01f, 2.28968635e-01f, 2.61422098e-01f, 1.23143211e-01f,
  -3.02391231e-01f, 1.28791481e-01f, 2.45836928e-01f, 1.32473439e-01f, -9.57111269e-02f, -1.95592523e-01f, 3.68347690e-02f, 1.74110472e-01f, 6.17546635e-03f, -5.26641682e-02f,
  -2.06542999e-01f, 3.73918891e-01f, -7.82348290e-02f, -1.67593107e-01f, -1.18735604e-01f, -2.56088190e-02f, -1.95654929e-02f, -9.29283164e-03f, -3.50544415e-02f, 4.34341654e-02f,
  -4.01114002e-02f, -1.62051041e-02f, -1.13825269e-01f, -1.62376948e-02f, 9.97023955e-02f, 2.75955312e-02f, -5.59063219e-02f, 2.67654695e-02f, -1.60373271e-01f, -1.96408764e-01f,
  -4.51986581e-01f, -1.89339668e-02f, 1.80691823e-01f, 9.97393671e-03f, -1.29622743e-02f, -1.15271546e-01f, -3.11913639e-02f, 1.12549081e-01f, 1.19060222e-02f, -1.84982680e-02f,
  -3.52056414e-01f, -4.81421649e-02f, -1.41115621e-01f, -2.03125373e-01f, -6.21523336e-02f, -5.80380373e-02f, -1.63247705e-01f, -1.34118602e-01f, -3.88521105e-02f, -3.37940454e-02f,
  -1.26254976e-01f, -1.97361380e-01f, -1.13872059e-01f, -1.01561122e-01f, -3.85789514e-01f, -7.63704255e-02f, -4.17105034e-02f, -8.32299516e-02f, -1.62755758e-01f, -3.46804336e-02f,
  -7.14836419e-02f, 5.38789146e-02f, -6.80009201e-02f, -1.19200245e-01f, -1.51205778e-01f, -1.04517803e-01f, -9.15929377e-02f, -1.87354907e-01f, 2.10784096e-02f, -8.98626633e-03f,
  -4.75460410e-01f, -2.98733711e-01f, -1.20499320e-01f, 1.03926361e-01f, 7.71982595e-02f, 3.58322114e-02f, -1.70041069e-01f, -1.21073261e-01f, -1.73653867e-02f, 2.49668024e-02f,
  8.88584107e-02f, 7.31971711e-02f, -6.31663352e-02f, -3.36223235e-03f, 1.35261849e-01f, -5.25291562e-02f, -1.12467811e-01f, -1.85199276e-01f, -1.82089880e-01f, -9.84434038e-02f,
  -9.64729860e-02f, -2.16842797e-02f, 2.08784565e-02f, -1.05605267e-01f, -1.27047762e-01f, -1.44347057e-01f, -6.21687956e-02f, 3.44247855e-02f, 6.94067106e-02f, 2.62237549e-01f,
  5.64077914e-01f, 2.23715484e-01f, -6.46192431e-01f, 1.67353272e-01f, -3.75406533e-01f, -5.16419828e-01f, -4.04472172e-01f, -1.36607885e-01f, 1.29837573e-01f, 1.71818495e-01f,
  -4.41248976e-02f, -4.29487154e-02f, -2.47638658e-01f, -1.36950046e-01f, 8.37036818e-02f, -6.87712803e-02f, -1.80575967e-01f, -6.16794638e-02f, 7.31702372e-02f, 5.19439876e-01f,
  3.15907329e-01f, 3.51160914e-01f, 5.03792405e-01f, 1.87397107e-01f, 3.22877616e-01f, 8.11257660e-02f, -1.98004737e-01f, 1.10335536e-01f, -2.84149311e-02f, 2.27514312e-01f,
  1.76027164e-01f, 1.88005015e-01f, -2.17528239e-01f, 4.86273244e-02f, -1.27093747e-01f, 3.73175770e-01f, 2.33606115e-01f, 5.04473969e-02f, 3.43723707e-02f, 2.83272475e-01f,
  2.04458497e-02f, 1.86161771e-01f, 4.07656766e-02f, 1.78532526e-01f, 3.71378332e-01f, 3.16419825e-02f, -6.61000982e-02f, -2.53615268e-02f, -1.83168724e-01f, 8.48359019e-02f,
  -7.34574571e-02f, -1.78247064e-01f, -5.21698534e-01f, -3.19142431e-01f, -9.64940488e-02f, -2.37082407e-01f, -1.81710422e-01f, 1.39664784e-01f, -3.19308549e-01f, 2.70397276e-01f,
  -8.66760463e-02f, 2.54007075e-02f, -4.07951698e-02f, -1.36379208e-02f, 1.24709159e-01f, -6.59831315e-02f, -1.77509803e-02f, 5.40604368e-02f, 1.85581148e-01f, 6.07102662e-02f,
  -1.23260893e-01f, 4.50793952e-02f, 9.92923602e-02f, 7.31727853e-02f, 1.17746472e-01f, 4.36066417e-03f, 3.39525901e-02f, 7.11263418e-02f, 6.56778365e-02f, 1.19370051e-01f,
  3.97931319e-03f, -9.94462892e-02f, 1.01133049e-01f, 1.32875472e-01f, -1.41042601e-02f, -2.55299229e-02f, 1.18491381e-01f, 1.69066474e-01f, 1.47131726e-01f, 1.33210793e-01f,
  1.25759229e-01f, -4.51053351e-01f, 2.76489556e-01f, -9.46457777e-03f, -7.91745856e-02f, -9.73767694e-03f, -5.15078716e-02f, 4.51127551e-02f, 1.16023896e-02f, 2.71730423e-01f,
  1.08863927e-01f, 7.67713487e-02f, 2.85129026e-02f, -3.14407162e-02f, 9.94621962e-02f, -9.86680165e-02f, 1.78928316e-01f, -3.19499403e-01f, -1.36539862e-01f, 1.58874646e-01f,
  -2.40594491e-01f, -1.39062583e-01f, -2.17255726e-01f, -4.41550493e-01f, -4.05279323e-02f, -2.23900184e-01f, -2.17766359e-01f, -3.44987474e-02f, -4.26274031e-01f, -2.81232409e-02f,
  6.14475667e-01f, 2.23011389e-01f, -6.08885467e-01f, 5.39672136e-01f, -9.85952839e-02f, -3.76921266e-01f, -3.19254667e-01f, -3.39030772e-02f, 4.74418223e-01f, 2.39011317e-01f,
  -1.03023797e-02f, -2.14008018e-01f, -1.28830671e-01f, -3.31546962e-01f, -4.70694095e-01f, -3.08329821e-01f, -2.41609305e-01f, -5.92926502e-01f, -6.30819082e-01f, -3.29279155e-01f,
  2.75269169e-02f, 2.22664893e-01f, 1.74296632e-01f, -1.75810941e-02f, 3.18808913e-01f, 5.24054170e-02f, 2.13564381e-01f, 2.11063266e-01f, -1.73731193e-01f, 5.88472746e-02f,
  -1.02158464e-01f, 1.67000636e-01f, -3.61388028e-01f, -4.61421087e-02f, -2.22660303e-02f, -5.31606488e-02f, -2.48905599e-01f, 2.06907224e-02f, -1.50277883e-01f, 2.14084089e-02f,
  -2.31032088e-01f, -1.40840843e-01f, -1.72378123e-01f, -8.87049437e-02f, -4.52339686e-02f, -6.67665377e-02f, -2.60559674e-02f, -2.57695138e-01f, -4.77112830e-02f, -6.74886405e-02f,
  -1.05852798e-01f, -8.63719806e-02f, -2.64692128e-01f, -8.52879584e-02f, -1.54067650e-01f, -2.88050443e-01f, -1.10143743e-01f, -4.85509373e-02f, -1.76994532e-01f, 3.01085562e-01f,
  6.66829869e-02f, 1.60381477e-02f, 1.47845056e-02f, 8.12636241e-02f, 1.17812902e-01f, -7.83074647e-03f, 7.37737566e-02f, -3.41931395e-02f, -8.71085841e-03f, 4.16092831e-07f,
  -2.73700915e-02f, 5.74765876e-02f, -5.11278689e-04f, 4.30779196e-02f, -5.27258776e-02f, -4.29205857e-02f, -1.08583150e-02f, 9.81023759e-02f, -1.25639141e-01f, 3.63748660e-03f,
  -7.94126019e-02f, -3.43231112e-02f, 3.55429202e-02f, -4.91870195e-02f, -4.01926562e-02f, -4.28777710e-02f, 9.87231657e-02f, -4.89782356e-02f, -8.41808766e-02f, 7.30179399e-02f,
  3.95588249e-01f, -3.47535908e-01f, 1.83896884e-01f, -1.89380020e-01f, 4.99348529e-02f, -2.18978953e-02f, 1.72873184e-01f, -5.21358587e-02f, 5.55704115e-03f, -7.83824548e-02f,
  -2.08947241e-01f, -1.57874927e-01f, -6.12234958e-02f, -1.05862916e-01f, -1.06883273e-01f, 5.37384767e-03f, -6.60011470e-02f, -6.24370240e-02f, -8.68671760e-02f, 3.92815247e-02f,
  2.16306210e-01f, 3.18483263e-02f, 1.45165976e-02f, -1.58017837e-02f, 1.48929968e-01f, -9.45029929e-02f, -9.64433029e-02f, 3.04350965e-02f, -3.13776106e-01f, 3.93302619e-01f,
  -7.61643827e-01f, -2.96395928e-01f, -3.26858640e-01f, -7.88762867e-01f, -4.03266072e-01f, 1.62135214e-02f, -2.25227047e-02f, -7.34646842e-02f, -3.90216708e-01f, -2.21739113e-01f,
  2.65934709e-02f, 7.28287315e-03f, -1.80389643e-01f, -7.25156143e-02f, 4.53987308e-02f, -2.76407212e-01f, -2.73022681e-01f, -4.09607142e-01f, -1.78576007e-01f, -1.53804347e-01f,
  -2.33975574e-01f, -5.80875278e-01f, -4.33879077e-01f, -3.13971192e-01f, -4.81698930e-01f, -2.47653037e-01f, -2.60117173e-01f, -4.10155982e-01f, -3.19818594e-02f, -4.63707775e-01f,
  -7.54682571e-02f, -1.31110072e-01f, -1.69787016e-02f, 1.57268401e-02f, -2.00798884e-01f, 8.48921388e-02f, -1.10150881e-01f, -1.31958723e-01f, -3.51107642e-02f, -1.32961035e-01f,
  -1.74617469e-01f, -3.10856616e-03f, -1.20655492e-01f, 3.57101075e-02f, -1.65550515e-01f, -4.07896154e-02f, -9.69717279e-02f, -1.32543445e-01f, 2.81491391e-02f, 3.03635985e-01f,
  1.41713202e-01f, -1.28291799e-02f, -3.82731035e-02f, 2.32610375e-01f, 1.50775716e-01f, 4.77443859e-02f, 1.74373657e-01f, 1.43561304e-01f, 1.98242202e-01f, -2.44871244e-01f,
  -1.68112397e-01f, -1.11470044e-01f, -3.78392786e-02f, -8.38090852e-02f, 4.87519130e-02f, -8.51581804e-03f, -1.96423277e-01f, -1.19770348e-01f, 2.52467208e-02f, -2.04549536e-01f,
  -1.02063388e-01f, 1.38007849e-01f, -3.59135047e-02f, -1.35182440e-01f, -1.21199079e-01f, -9.30533931e-02f, -3.42052765e-02f, -4.10849862e-02f, 4.07412276e-02f, -1.37719467e-01f,
  6.85296431e-02f, 6.50618598e-03f, -1.16942964e-01f, -6.58182101e-03f, 9.12776738e-02f, 3.03173494e-02f, 1.42835543e-01f, 1.19839877e-01f, -6.48043817e-03f, 4.14891466e-02f,
  -2.63591051e-01f, 9.87265632e-02f, -1.61339775e-01f, -2.39541028e-02f, -5.32642938e-02f, 8.64320770e-02f, 1.10698022e-01f, 5.12698926e-02f, -1.25654206e-01f, -1.44879282e-01f,
  1.77950382e-01f, -1.17456548e-01f, -7.35209659e-02f, -4.60406914e-02f, -9.28735286e-02f, -5.67185804e-02f, 5.66075854e-02f, -1.85273603e-01f, 2.20008880e-01f, 1.25847504e-01f,
  2.98258802e-03f, 8.87148976e-02f, 8.68415553e-03f, -8.64143297e-02f, 4.08913344e-02f, 2.17205752e-02f, -5.40279374e-02f, 3.37839238e-02f, 1.26558959e-01f, -3.05771559e-01f,
  1.40112758e-01f, -4.40004200e-01f, 2.84956813e-01f, 4.47989292e-02f, -3.71292114e-01f, -5.33713043e-01f, -6.78650975e-01f, -4.04922545e-01f, -7.34738633e-02f, -1.91051856e-01f,
  -2.96571523e-01f, 1.24051534e-01f, 1.46908343e-01f, 1.48583487e-01f, 2.50183403e-01f, 6.41738996e-02f, 5.08545399e-01f, 6.24161184e-01f, 3.28519464e-01f, 1.51406944e-01f,
  1.10977434e-01f, 1.44263491e-01f, 3.68869692e-01f, 4.37075198e-01f, 3.19249779e-01f, 2.15357006e-01f, -4.47572581e-03f, -6.30140491e-03f, -2.41788626e-02f, 4.46013391e-01f,
  1.81763604e-01f, -2.45719701e-01f, -1.47795975e-01f, -4.14590798e-02f, -2.93749701e-02f, -4.32258211e-02f, -1.17988110e-01f, 7.66091347e-02f, 7.05238283e-02f, 7.86528587e-02f,
  -2.60872804e-02f, 3.37117203e-02f, -1.89077631e-01f, 7.15409666e-02f, -4.71811667e-02f, 5.15031777e-02f, 2.53950477e-01f, 2.50991195e-01f, 5.97096980e-02f, 4.54354286e-02f,
  -6.27443865e-02f, -6.56838492e-02f, -9.95468944e-02f, -2.41042420e-01f, -9.96405259e-02f, 4.76983674e-02f, -8.79726335e-02f, 2.44258009e-02f, -1.72834307e-01f, -1.38799809e-02f,
  -3.67020406e-02f, 1.62604619e-02f, 8.60641897e-02f, 5.64714856e-02f, 4.62679453e-02f, 5.87843098e-02f, 1.16801798e-01f, 3.07862572e-02f, -9.38367564e-03f, 1.90613493e-01f,
  2.41589230e-02f, -9.59693566e-02f, 4.15786020e-02f, -8.30896795e-02f, 8.05418789e-02f, 8.53040889e-02f, 9.45308805e-02f, 7.59556964e-02f, 5.58446869e-02f, 4.82679717e-02f,
  3.29305567e-02f, 9.17818546e-02f, 4.93598431e-02f, 2.25597173e-01f, 8.13099556e-04f, 9.73892957e-02f, 1.54212326e-01f, -3.80668715e-02f, -6.76680058e-02f, -4.35855649e-02f,
  -4.26242024e-01f, -3.80345166e-01f, 1.68703064e-01f, 2.16963693e-01f, 9.18637663e-02f, -1.47503735e-02f, -6.82636201e-02f, 9.05956849e-02f, -4.40085456e-02f, 6.33079410e-02f,
  -1.62658960e-01f, -4.30535227e-02f, -2.82084912e-01f, 4.50673923e-02f, 8.65480453e-02f, 6.90504014e-02f, 1.53774649e-01f, 1.42891318e-01f, -4.89645191e-02f, 2.42490739e-01f,
  1.04005173e-01f, -5.64709604e-02f, -1.90449506e-01f, -2.26863772e-01f, -2.19180822e-01f, -2.45043710e-01f, -2.54809231e-01f, -1.53240055e-01f, -4.22970831e-01f, -3.69843960e-01f,
  2.21465766e-01f, -4.22087371e-01f, 3.98925781e-01f, -2.67496645e-01f, -4.57149506e-01f, -2.91451573e-01f, -3.26108992e-01f, -1.94608614e-01f, -1.10745378e-01f, -3.09175014e-01f,
  -2.87839800e-01f, -1.17241122e-01f, 1.71339795e-01f, 1.45134881e-01f, 2.51827955e-01f, 9.51035172e-02f, 1.86676443e-01f, 5.51869392e-01f, 3.27546835e-01f, -1.28678903e-01f,
  -2.69725323e-01f, -1.35553330e-01f, 1.43122077e-01f, 1.30651742e-01f, -1.99367344e-01f, 6.25119952e-04f, -1.63251050e-02f, -1.19809851e-01f, -1.34350881e-01f, 6.21660911e-02f,
  1.74792647e-01f, -6.09670170e-02f, 9.48259234e-02f, -1.14187226e-01f, -1.37359753e-01f, 9.24077183e-02f, 3.68231870e-02f, 3.84413600e-02f, -1.79581970e-01f, -7.62249231e-02f,
  -9.78659540e-02f, -7.93373138e-02f, 1.12555493e-02f, -1.62912831e-02f, -8.63792282e-03f, -4.96703982e-02f, -1.39587512e-02f, -5.82559109e-02f, -8.12339261e-02f, -6.35506958e-02f,
  -1.20129153e-01f, -2.01497272e-01f, -1.82956289e-02f, -6.61543533e-02f, -8.98037255e-02f, 4.45465036e-02f, -3.17982808e-02f, -1.35476515e-01f, 6.79153055e-02f, -5.75625151e-02f,
  1.37709796e-01f, -6.80786604e-03f, -1.93553232e-02f, -2.89905258e-02f, -1.02436975e-01f, -1.54222548e-01f, -3.96266319e-02f, -1.07971847e-01f, 4.95145991e-02f, -4.34102006e-02f,
  -1.37263760e-01f, -1.35066256e-01f, -8.23015794e-02f, -1.38065055e-01f, -3.53548452e-02f, -4.65719141e-02f, -1.17271468e-01f, -7.70291686e-02f, 4.81583700e-02f, -9.95276794e-02f,
  -6.10864423e-02f, -2.39456613e-02f, -2.69345986e-03f, -6.70829490e-02f, -9.72386673e-02f, 5.99230938e-02f, 4.99891341e-02f, -6.79299748e-03f, -2.71816887e-02f, -1.45437986e-01f,
  -9.67879966e-02f, 1.09564312e-01f, 5.51151000e-02f, 1.80246562e-01f, -2.37411745e-02f, -4.39894153e-03f, 1.27569750e-01f, -3.93401571e-02f, 2.78484933e-02f, 1.65512890e-01f,
  6.31927475e-02f, 1.90129191e-01f, 5.47501259e-02f, -4.54093553e-02f, -3.04640904e-02f, -1.17572425e-02f, -8.52234587e-02f, -9.51091722e-02f, -6.21809484e-03f, -8.22799727e-02f,
  -5.95527999e-02f, -2.81221494e-02f, 1.42613843e-01f, 4.95476685e-02f, -7.12180063e-02f, 1.90675125e-01f, 6.85957670e-02f, -1.47918016e-02f, 1.62806243e-01f, -7.48340636e-02f,
  6.42905477e-03f, 3.62093374e-02f, 4.86339837e-01f, 1.47845283e-01f, -1.23170421e-01f, -4.63569283e-01f, -6.85436070e-01f, -4.05513585e-01f, -4.12171707e-02f, 1.83139425e-02f,
  6.02879263e-02f, 3.72175984e-02f, 2.37155393e-01f, -4.82145101e-02f, -4.08504516e-01f, -2.12085426e-01f, 1.39031738e-01f, 1.47566989e-01f, -3.30364585e-01f, -5.04088819e-01f,
  -2.46127963e-01f, 4.48804796e-02f, 4.16544974e-02f, -6.35318051e-04f, 3.93601865e-01f, 2.01310739e-01f, 3.91362846e-01f, 3.07774395e-01f, 1.84919894e-01f, 5.49361467e-01f,
  4.24065560e-01f, 2.51064785e-02f, -1.56316742e-01f, 6.23931438e-02f, 5.89866973e-02f, -1.17142864e-01f, -1.29825160e-01f, 1.47689730e-01f, -4.61978316e-02f, 6.22885302e-02f,
  1.23019412e-01f, 1.76002644e-02f, 3.78663838e-02f, -9.31537524e-02f, -1.26553625e-01f, -2.21251860e-01f, -2.01682653e-02f, -1.36516526e-01f, -6.50332272e-02f, -1.13409124e-01f,
  -1.37717262e-01f, 4.10720408e-02f, 7.53690526e-02f, -2.00481907e-01f, 4.00121848e-04f, 7.67743513e-02f, -1.09888744e-02f, 4.63915914e-02f, -1.11273840e-01f, 2.25296557e-01f,
  8.49055722e-02f, -5.49915805e-02f, 4.89745550e-02f, 3.45530733e-02f, -2.40237527e-02f, 1.17548481e-01f, 3.07968203e-02f, -2.16044337e-02f, -9.14521143e-03f, -3.66371684e-02f,
  9.85157955e-03f, 1.84673257e-02f, -3.51776257e-02f, 2.97493525e-02f, 2.07606219e-02f, 1.35559574e-01f, -7.67863169e-02f, -1.80921238e-02f, 2.44569238e-02f, -3.82887125e-02f,
  2.13374030e-02f, 5.47281466e-03f, 1.85790166e-01f, 1.17016900e-02f, 5.94504438e-02f, 1.77782809e-03f, 6.45125806e-02f, -3.67372222e-02f, 1.13301732e-01f, -7.27926102e-03f,
  1.99657343e-02f, -3.72041225e-01f, -5.33853173e-02f, -6.67397752e-02f, 8.96369945e-03f, 9.74010900e-02f, 1.50576815e-01f, -8.26356336e-02f, 1.40704503e-02f, -6.88597411e-02f,
  -1.33463845e-01f, -2.62268949e-02f, 8.51166993e-02f, -6.64051697e-02f, -1.67909145e-01f, 2.10164394e-02f, -1.14028435e-02f, -5.37484176e-02f, -2.37648442e-01f, -1.50157034e-01f,
  -9.95056704e-02f, -4.19746518e-01f, -3.12716961e-01f, -2.13465154e-01f, -9.54180285e-02f, -2.87040651e-01f, -9.43295062e-02f, -8.30023885e-02f, -2.99482435e-01f, -3.76898140e-01f,
  -3.59791964e-01f, 6.58836126e-01f, -2.19975099e-01f, -5.48028536e-02f, 1.35509491e-01f, 2.12913617e-01f, 5.92199385e-01f, 3.82974684e-01f, 1.32655442e-01f, 3.12632531e-01f,
  3.18232268e-01f, -2.28347048e-01f, -1.42800584e-01f, -1.72776505e-01f, -1.13224238e-01f, 3.79723072e-01f, 2.00882733e-01f, -5.84316492e-01f, -7.61109710e-01f, -3.70016456e-01f,
  -8.66404325e-02f, -7.83471763e-02f, -3.49394947e-01f, -1.94129348e-01f, 8.89088809e-02f, -4.14698243e-01f, 1.07653730e-01f, -9.78463516e-02f, -2.86756605e-01f, -3.69405329e-01f,
  -5.28404534e-01f, 1.47515401e-01f, -2.96134323e-01f, -1.02771312e-01f, 2.89091449e-02f, -1.47605926e-01f, -9.31428075e-02f, -5.13093509e-02f, 1.03204347e-01f, 1.03639523e-02f,
  8.71069804e-02f, -8.40447396e-02f, 1.10231079e-01f, -2.76285820e-02f, 1.44762322e-01f, -3.88530525e-03f, 2.81398207e-01f, -1.37951985e-01f, -2.07164735e-01f, 1.01172915e-02f,
  1.15657888e-01f, -9.16865095e-02f, 7.18990117e-02f, 1.14414059e-01f, -2.51381043e-02f, -2.03493193e-01f, 9.66432467e-02f, -3.00302446e-01f, -3.52251947e-01f, -2.30475277e-01f,
  -1.35864735e-01f, 6.84879124e-02f, 1.66497845e-02f, 8.17986354e-02f, 1.63101759e-02f, 3.41938846e-02f, -1.15031507e-02f, -2.03303695e-02f, -2.69094352e-02f, 1.17927320e-01f,
  6.63824081e-02f, -5.38843945e-02f, -9.34218392e-02f, 8.63437578e-02f, -1.37937650e-01f, 7.77019188e-02f, -1.14346661e-01f, -6.96317246e-03f, 9.23534855e-03f, 6.05255924e-02f,
  -3.59844156e-02f, 3.34207602e-02f, -1.84261668e-02f, -5.60566895e-02f, 1.99153125e-02f, -3.48405987e-02f, -4.26795036e-02f, -9.42577794e-02f, 2.98049464e-03f, 2.15733096e-01f,
  -9.10452083e-02f, -3.38788554e-02f, -9.48919356e-02f, 1.20500185e-01f, -4.15645503e-02f, 8.06412771e-02f, -7.92755783e-02f, -5.01370020e-02f, -3.60265211e-03f, -3.30305062e-02f,
  5.24840830e-03f, 8.50297436e-02f, 1.58857942e-01f, 5.08516468e-02f, 2.41627917e-03f, 7.39788115e-02f, 1.95151165e-01f, -7.80974478e-02f, 6.49001822e-02f, 1.21743619e-01f,
  2.94706047e-01f, -7.76674040e-03f, -9.30485502e-02f, -2.01768745e-02f, 2.23400770e-04f, -2.16023296e-01f, -4.92490530e-02f, -2.77271479e-01f, -2.90762991e-01f, 1.22652724e-01f,
  -1.13728875e-02f, -3.96758411e-03f, -1.94225207e-01f, 4.44911979e-02f, 1.49392456e-01f, -1.15610749e-01f, -3.07446778e-01f, -2.75902867e-01f, 8.53234679e-02f, 8.45287461e-03f,
  2.13078469e-01f, 1.32578105e-01f, -1.80835217e-01f, -2.91616797e-01f, -5.32447517e-01f, -4.87729549e-01f, -4.62517440e-01f, -5.16886890e-01f, -4.11930501e-01f, -1.07988613e-02f,
  1.09185740e-01f, -1.15696609e-01f, -3.09806406e-01f, -1.81979284e-01f, 1.96233988e-01f, -1.03970179e-02f, -3.53767388e-02f, -7.49094412e-04f, -5.96031733e-02f, 3.14944312e-02f,
  3.11038387e-03f, 3.32339033e-02f, -5.69188334e-02f, 3.74641083e-02f, 9.51363966e-02f, -1.58827733e-02f, -7.09796920e-02f, -4.29899171e-02f, 3.48188914e-02f, -1.23533770e-01f,
  7.72257820e-02f, 1.06109865e-02f, 2.78976038e-02f, 6.13309592e-02f, -4.77456339e-02f, -1.18686460e-01f, -1.06826514e-01f, -2.32365668e-01f, -1.40572652e-01f, -2.79832054e-02f,
  1.48154497e-01f, 1.72778759e-02f, -2.25254908e-01f, -2.33560234e-01f, -1.96325883e-01f, -1.53741896e-01f, -8.58023018e-02f, 1.28447153e-02f, -2.65233487e-01f, 3.98363627e-04f,
  2.24751607e-02f, 2.95426082e-02f, 9.52505227e-03f, -2.22267006e-02f, -6.10473379e-02f, 5.98766841e-02f, -4.49984632e-02f, -4.46108915e-02f, 6.53083026e-02f, -3.38746049e-02f,
  -6.25716969e-02f, 3.47696766e-02f, 4.35310826e-02f, 2.17025783e-02f, 2.19849474e-03f, -3.59004512e-02f, 3.93165573e-02f, -6.93739504e-02f, -2.39070337e-02f, -1.14532091e-01f,
  -3.63572724e-02f, 2.98061268e-03f, 8.40466768e-02f, -3.19118723e-02f, 2.84107327e-02f, -8.54550973e-02f, 6.13369122e-02f, -1.04549937e-02f, -1.43179875e-02f, -3.56394760e-02f,
  -5.50478436e-02f, -1.57484293e-01f, 7.58042336e-02f, -1.11868046e-01f, -5.73696718e-02f, 8.05245638e-02f, 1.94465443e-01f, -2.79639196e-03f, 5.95592149e-02f, -8.53176266e-02f,
  -4.12886888e-02f, -5.39640971e-02f, 6.74430397e-04f, -1.75148770e-02f, -1.02382610e-02f, -8.38667713e-03f, -6.64634481e-02f, 6.57437518e-02f, -2.77524460e-02f, 1.95761919e-01f,
  -1.09192640e-01f, -2.12302685e-01f, -3.10398608e-01f, -2.43771911e-01f, -7.79515728e-02f, -1.93830118e-01f, -1.85416594e-01f, -1.12442113e-01f, -3.44752192e-01f, -3.68984491e-01f,
  -9.53258812e-01f, 1.72878001e-02f, 2.28555158e-01f, -4.18741768e-03f, -1.11213997e-01f, -2.63295949e-01f, -3.92469997e-03f, -9.94504988e-02f, -1.54893816e-01f, 1.06491605e-02f,
  1.44024059e-01f, 3.26257765e-01f, 3.11950713e-01f, 2.79075354e-01f, 1.65496469e-01f, 2.18537480e-01f, 2.64655128e-02f, 1.43804708e-02f, 4.77551408e-02f, -3.75783555e-02f,
  7.95001835e-02f, 1.67391032e-01f, 8.47773068e-03f, -3.92706916e-02f, 1.41869053e-01f, 1.86545089e-01f, 2.37103432e-01f, 2.04644486e-01f, 1.79903567e-01f, 2.05464706e-01f,
  7.42577791e-01f, -1.47797763e-01f, 3.16611864e-02f, -1.48696341e-02f, -4.41103950e-02f, -1.04074247e-01f, -7.91671798e-02f, -6.28366768e-02f, -5.35162315e-02f, -3.00534628e-02f,
  1.77907981e-02f, -9.24985483e-02f, 6.67492822e-02f, 8.63720775e-02f, 2.53244936e-02f, -5.80172800e-02f, -1.66306123e-01f, -4.60540093e-02f, 1.04367986e-01f, 1.18668832e-01f,
  -2.12839656e-02f, -9.33606401e-02f, 9.18804333e-02f, 5.46590611e-02f, -9.69529524e-02f, -7.81001225e-02f, 7.14579672e-02f, -5.44230901e-02f, -9.03861895e-02f, -3.53580080e-02f,
  -1.69662789e-01f, -1.66284546e-01f, 8.94804485e-03f, -1.02939513e-02f, -4.46296521e-02f, -1.43988058e-01f, -1.01589039e-01f, -6.81597739e-03f, -2.79529532e-03f, 6.46842923e-03f,
  3.47345434e-02f, 6.65469766e-02f, 1.42071433e-02f, -2.37947740e-02f, -1.25944952e-03f, -2.51017511e-03f, -1.17835149e-01f, -5.11945337e-02f, -2.74038631e-02f, 2.75711920e-02f,
  -1.20942593e-01f, -1.01406716e-01f, 1.02781594e-01f, -1.55464364e-02f, -9.28047970e-02f, -1.50906518e-01f, -7.13776499e-02f, -2.05443129e-02f, 3.27851400e-02f, -1.38569698e-01f,
  7.66170025e-01f, 2.69663185e-02f, 8.39641541e-02f, -7.83783663e-03f, -1.15230069e-01f, -2.41549864e-01f, -1.64189085e-03f, -1.19704351e-01f, -5.30568846e-02f, -3.46555561e-03f,
  -2.02701837e-01f, -1.08635992e-01f, 1.85542889e-02f, -8.14079959e-03f, -1.37750357e-01f, -6.29925579e-02f, -2.30889529e-01f, 7.46709853e-02f, -3.61095481e-02f, 4.08633873e-02f,
  -1.65532425e-01f, -1.74755931e-01f, 4.03524414e-02f, 4.43395302e-02f, -1.48266628e-01f, -1.71439156e-01f, 1.62720934e-01f, 1.04454095e-02f, 2.77377106e-02f, -1.80777768e-03f,
  9.59950626e-01f, 3.83359730e-01f, 7.19987834e-03f, 1.02171928e-01f, -2.92940527e-01f, -1.76256120e-01f, -2.45046020e-01f, -6.48050830e-02f, 9.64208692e-02f, 1.28168151e-01f,
  1.90436125e-01f, 2.71798283e-01f, 2.10726723e-01f, 2.31289238e-01f, 1.30854547e-01f, -5.92760630e-02f, -6.82631955e-02f, 1.69026494e-01f, 5.42741157e-02f, 1.56970955e-02f,
  2.33578179e-02f, 1.13055177e-01f, 2.59948373e-01f, 8.86358395e-02f, 1.42152114e-02f, 2.48566903e-02f, 1.61287282e-02f, -2.18918063e-02f, -1.01763338e-01f, 7.13637844e-02f,
  -1.52154952e-01f, 7.94832334e-02f, 7.51437573e-03f, 1.58580095e-01f, 9.55481678e-02f, 1.95683122e-01f, 1.00391351e-01f, 4.43065204e-02f, 2.25460697e-02f, -1.18118785e-01f,
  -1.11188442e-02f, -6.57760678e-03f, -4.93080653e-02f, 5.09440601e-02f, -1.26991987e-01f, 1.06660835e-01f, 5.11240773e-02f, 7.51150493e-03f, -6.65599257e-02f, -5.75323552e-02f,
  -2.26985049e-02f, -2.08424687e-01f, -1.86710134e-01f, -8.59690532e-02f, -3.71048041e-02f, 5.45395128e-02f, -2.00302191e-02f, -1.11854142e-02f, -1.43217491e-02f, 7.92008862e-02f,
  -2.31085256e-01f, -1.33507952e-01f, -1.51628166e-01f, -1.84624881e-01f, -1.88603461e-01f, -1.30426317e-01f, -1.22307308e-01f, -1.06620654e-01f, -6.35973364e-02f, 9.55934599e-02f,
  -1.01286389e-01f, -1.01011500e-01f, -9.47234333e-02f, -4.34292853e-02f, 4.77336980e-02f, -2.16431975e-01f, -8.60259831e-02f, -1.10849850e-01f, -1.00086480e-01f, -1.72781751e-01f,
  -1.77432254e-01f, -1.42759129e-01f, 1.89419314e-02f, -1.12963542e-01f, -1.81093454e-01f, -3.96505035e-02f, -3.95847037e-02f, -5.52185997e-02f, 5.09853475e-02f, -7.39731863e-02f,
  -1.30287603e-01f, -1.09487422e-01f, 1.02390058e-01f, 8.60883147e-02f, 3.70710343e-02f, 2.12899372e-01f, -2.61669084e-02f, -5.37560657e-02f, -1.48671553e-01f, -7.41650239e-02f,
  -9.36780423e-02f, 1.49781555e-01f, 1.01960681e-01f, 7.36437961e-02f, 8.23841244e-02f, 1.01684019e-01f, 5.17406762e-02f, 4.86735255e-02f, -1.10765368e-01f, -3.36709134e-02f,
  -1.05850608e-03f, -1.69580262e-02f, -2.97263190e-02f, 6.21635057e-02f, 2.42736526e-02f, 1.31147563e-01f, 7.47972950e-02f, -1.01609483e-01f, -3.94316725e-02f, 3.80463041e-02f,
  1.87103823e-01f, -1.30263017e-02f, 1.85149044e-01f, 5.35777472e-02f, 4.17655289e-01f, 3.34074706e-01f, 5.26870728e-01f, 3.26695710e-01f, 7.55438805e-02f, 7.31190443e-02f,
  -2.15586022e-01f, -4.70945269e-01f, -5.04917800e-01f, -3.55788440e-01f, -2.31424272e-01f, 1.41628131e-01f, 1.99973583e-01f, -1.65207788e-01f, -1.31500721e-01f, 9.45021436e-02f,
  1.42171336e-02f, 2.99701244e-01f, 1.48072794e-01f, -7.30312318e-02f, 5.03042154e-02f, -1.15308799e-01f, 2.68244296e-01f, 2.73944944e-01f, -2.41803098e-03f, -1.74907431e-01f,
  -3.07298571e-01f, 2.14157984e-01f, -5.31083420e-02f, -6.73685223e-02f, -6.06230274e-02f, -1.31121665e-01f, 1.46643352e-02f, -7.11435974e-02f, -2.27263391e-01f, -1.25077233e-01f,
  -1.17615655e-01f, -9.40899849e-02f, -1.02779187e-01f, 1.28203500e-02f, 6.85283765e-02f, -1.65964961e-02f, -7.66624212e-02f, -1.84560806e-01f, -2.07264304e-01f, -1.83700308e-01f,
  -1.78070739e-01f, 6.38566539e-02f, 1.19041406e-01f, 2.12786682e-02f, -1.23022854e-01f, -1.29902914e-01f, -1.16867218e-02f, -3.25716510e-02f, 3.39948237e-02f, 4.98917699e-02f,
  5.03511876e-02f, 1.23945596e-02f, 3.52681167e-02f, 1.16961777e-01f, -6.52439147e-02f, -3.76996771e-02f, 1.84709840e-02f, -4.08530608e-02f, 2.29152795e-02f, 6.42364174e-02f,
  -1.18674472e-01f, -3.69646996e-02f, 1.67934932e-02f, 8.27418491e-02f, -4.59669642e-02f, 1.33293681e-02f, 7.49542564e-02f, -1.62170604e-01f, -5.65807289e-03f, 1.29261106e-01f,
  -5.08729964e-02f, 3.48631404e-02f, -4.38235961e-02f, -1.01801474e-02f, -7.06743747e-02f, -1.24177830e-02f, -6.58528507e-02f, 2.88148038e-03f, 7.02493340e-02f, 2.42002353e-01f,
  -8.74493718e-02f, 2.18939758e-03f, -1.62963852e-01f, -4.87919943e-03f, 1.46324903e-01f, 2.61783623e-03f, 1.12210950e-02f, 1.33142211e-02f, 1.68456584e-02f, 4.10033390e-03f,
  -1.13538601e-01f, -1.05474100e-01f, -7.97770619e-02f, -3.58339176e-02f, 7.55059198e-02f, 5.09607904e-02f, -1.58287045e-02f, -1.46986423e-02f, -1.11251503e-01f, 1.78959910e-02f,
  -9.52248573e-02f, 1.92106783e-01f, 1.19424105e-01f, -2.27392931e-02f, 5.46372272e-02f, 1.29012644e-01f, 8.10807347e-02f, 6.00608326e-02f, 7.10111111e-02f, 3.61750931e-01f,
  2.48241201e-01f, 5.57929873e-02f, -2.75753498e-01f, 2.41654471e-01f, 1.97690085e-01f, 1.00734353e-01f, 2.39050314e-01f, 3.00370395e-01f, 2.78632969e-01f, 2.78933614e-01f,
  1.17996827e-01f, 3.27267617e-01f, 2.17769817e-01f, 2.76672065e-01f, 2.24345729e-01f, 1.04696311e-01f, 8.43168423e-02f, 1.23527721e-02f, -9.19184610e-02f, 3.54425572e-02f,
  2.23017320e-01f, 7.06504509e-02f, -1.05372399e-01f, 5.49174771e-02f, 4.55265231e-02f, 1.61430225e-01f, -1.07062615e-01f, -2.01205939e-01f, -8.81762952e-02f, -6.96548540e-03f,
  -2.80003399e-01f, -2.30008796e-01f, 7.32544288e-02f, 3.28336209e-02f, -2.25101501e-01f, 5.49691282e-02f, 8.74969736e-02f, -1.68006033e-01f, 5.76983904e-03f, -1.83436852e-02f,
  -1.70668080e-01f, -9.95350331e-02f, -8.73312801e-02f, -1.54504627e-01f, -1.15475826e-01f, -7.76223168e-02f, -1.97951093e-01f, -1.25336438e-01f, -2.35968437e-02f, -9.33377743e-02f,
  -2.70904843e-02f, -1.67563230e-01f, -1.68541849e-01f, -3.15473080e-02f, 8.62181261e-02f, 4.53733373e-03f, -4.50059436e-02f, -1.99232966e-01f, -9.50627923e-02f, -7.41635114e-02f,
  1.81745261e-01f, -5.18079437e-02f, 5.55007299e-03f, -1.11975066e-01f, 1.11444660e-01f, -1.73768159e-02f, -1.81782786e-02f, -1.42258734e-01f, 7.40703894e-03f, -1.25606373e-01f,
  -4.08638269e-02f, 3.96876335e-02f, -7.33186752e-02f, 8.14255103e-02f, 1.61320388e-01f, -5.66433072e-02f, -1.52759803e-02f, -5.65837659e-02f, -1.07502319e-01f, 5.93223348e-02f,
  4.68009897e-02f, -7.35887587e-02f, -1.08492665e-01f, -6.07079677e-02f, -2.82485876e-02f, -9.10549015e-02f, 1.15299240e-01f, 1.86112002e-02f, 5.61583973e-02f, -7.50226434e-04f,
  1.16219088e-01f, 4.80894595e-02f, 1.32063329e-01f, -1.50448546e-01f, -1.61378667e-01f, -7.91819617e-02f, 1.68974267e-03f, -1.72187462e-01f, -6.81724846e-02f, 4.84505668e-02f,
  -3.76043208e-02f, -1.40868679e-01f, 3.08022853e-02f, -7.60906562e-02f, -1.29959732e-01f, -6.12620339e-02f, -2.12049205e-02f, -6.15251958e-02f, 1.60620699e-03f, -8.62528384e-02f,
  -5.66238500e-02f, -3.90881188e-02f, 8.77415091e-02f, 8.08295906e-02f, 1.16162360e-01f, 1.74121290e-01f, -1.03269868e-01f, -1.29861951e-01f, 5.71912862e-02f, 1.98086336e-01f,
  8.46814394e-01f, -2.35345647e-01f, -8.21137249e-01f, 4.10497367e-01f, -2.01676115e-01f, -5.05221307e-01f, -5.51209450e-01f, -1.53044730e-01f, 2.98675954e-01f, -2.61944205e-01f,
  -1.90378919e-01f, 2.26995945e-01f, 3.75094032e-03f, -1.25389859e-01f, -2.35635683e-01f, -5.22286654e-01f, -4.99735415e-01f, -2.22716868e-01f, -1.57664418e-01f, -1.13452874e-01f,
  1.02073625e-01f, 2.78172016e-01f, 2.84108341e-01f, 1.41130751e-02f, 3.30862403e-02f, 3.76683213e-02f, -3.82920682e-01f, -4.08776253e-02f, -3.56058657e-01f, -1.47492275e-01f,
  -3.12297463e-01f, -1.58883646e-01f, -2.36316204e-01f, 2.24334732e-01f, -6.76888824e-02f, 1.02066629e-01f, -4.40322906e-02f, -4.10630782e-05f, 9.32674408e-02f, -1.32646590e-01f,
  -3.27592865e-02f, 5.36158904e-02f, 9.12809372e-02f, -5.84048964e-02f, -6.03935868e-02f, -1.46144712e-02f, 5.13938554e-02f, -5.47005385e-02f, -1.14302061e-01f, -1.34528980e-01f,
  -1.07326858e-01f, -6.18208535e-02f, -1.22198783e-01f, -2.07296044e-01f, -1.37713224e-01f, 3.09458543e-02f, -2.22436279e-01f, -1.28829986e-01f, -2.36777678e-01f, -2.00001430e-02f,
  -1.74457178e-01f, -7.68654868e-02f, -2.54729278e-02f, 2.44874340e-02f, 6.53746948e-02f, -2.81785373e-02f, -9.04655457e-02f, -1.59325719e-01f, -9.24430490e-02f, -1.23825170e-01f,
  -2.52748281e-02f, -9.68862548e-02f, -6.16224892e-02f, -1.46398306e-01f, -2.15571038e-02f, -5.69360964e-02f, -9.74790975e-02f, -7.77551681e-02f, 2.99648587e-02f, 5.92701957e-02f,
  3.53856497e-02f, 5.10301022e-03f, 1.26178145e-01f, 6.06767349e-02f, -1.99793249e-01f, -8.25443119e-02f, 2.28019897e-02f, -1.27201691e-01f, 9.54035968e-02f, -5.32534011e-02f,
  2.38116547e-01f, -2.77772039e-01f, 8.51368234e-02f, -9.09099802e-02f, -1.55306011e-01f, -5.18183876e-03f, -2.56629810e-02f, -7.36410990e-02f, 1.25509679e-01f, 3.05695496e-02f,
  -2.52729833e-01f, 1.96756050e-02f, -4.02586237e-02f, -6.99704736e-02f, -7.99899995e-02f, 3.34021784e-02f, 2.64936350e-02f, 1.81276482e-02f, -1.56558424e-01f, 7.71691725e-02f,
  2.34664679e-02f, -6.67911470e-02f, 3.06284189e-01f, 5.35813011e-02f, 2.81842938e-03f, 1.40773460e-01f, -9.28066596e-02f, -1.43920347e-01f, -1.02939539e-01f, 8.08826685e-02f,
  9.44422007e-01f, 2.30517015e-01f, -3.74813437e-01f, 1.63483724e-01f, -3.98417898e-02f, -9.75673739e-03f, 3.03813666e-02f, 5.96085787e-02f, 1.69609129e-01f, 6.76098913e-02f,
  2.78359503e-01f, 3.46049964e-01f, 2.73311913e-01f, 5.43784983e-02f, 2.13447899e-01f, -7.77629465e-02f, -1.84239447e-01f, -2.19241843e-01f, -2.54364666e-02f, -1.02812849e-01f,
  -1.13673404e-01f, -4.45568636e-02f, 9.75252613e-02f, -5.29503748e-02f, -1.77898183e-01f, -5.92005700e-02f, -3.49744484e-02f, -2.36001372e-01f, -1.82876363e-01f, -3.20667773e-01f,
  -6.30314469e-01f, -4.99042198e-02f, 3.31257954e-02f, -5.55918999e-02f, 5.71343936e-02f, 1.53388875e-02f, -8.17466434e-03f, 4.01407853e-02f, 1.56024531e-01f, -5.34498543e-02f,
  -1.27950326e-01f, -7.99102783e-02f, 5.43997250e-02f, -5.97357191e-02f, -6.34250566e-02f, -7.00905249e-02f, 1.11488797e-01f, 3.63349393e-02f, 8.04754421e-02f, -3.43486518e-02f,
  1.11191031e-02f, 1.01205995e-02f, -8.69288743e-02f, 1.56836987e-01f, 1.71238825e-01f, 1.53134599e-01f, 6.69166446e-04f, 2.71449275e-02f, 1.29271284e-01f, 1.74939200e-01f,
  -9.60315540e-02f, 2.28981480e-01f, 5.05788848e-02f, 1.11156285e-01f, 1.76491171e-01f, 4.11670245e-02f, 4.31004800e-02f, 1.15335807e-01f, 1.00490823e-01f, 1.19844921e-01f,
  -3.43278497e-02f, -7.81797096e-02f, 8.67722705e-02f, -2.66462211e-02f, -3.61809582e-02f, -3.43204327e-02f, -3.62206362e-02f, -7.10143149e-02f, -1.61038950e-01f, -2.78940927e-02f,
  6.07598983e-02f, -3.38336863e-02f, -1.67035639e-01f, -1.88443914e-01f, -1.87817559e-01f, -5.94704412e-02f, -1.20269895e-01f, 8.38444829e-02f, -1.76430624e-02f, -5.01975752e-02f,
  -8.61966237e-02f, 2.51296768e-03f, 4.44122665e-02f, 9.03839990e-02f, -1.05907969e-01f, -6.08825460e-02f, 4.50920686e-02f, -8.06413740e-02f, -1.40417039e-01f, -1.02804974e-01f,
  -1.03544869e-01f, -3.59792151e-02f, -1.44603133e-01f, -1.14151314e-02f, -1.02533363e-02f, -8.12064111e-02f, 1.76828772e-01f, 4.10575457e-02f, -9.76771787e-02f, -1.02139518e-01f,
  -6.84505515e-03f, 7.16101006e-02f, 1.18569694e-01f, 8.03114325e-02f, 1.23168677e-01f, 1.21358186e-02f, -1.26309479e-02f, -2.99791880e-02f, -1.10601142e-01f, 1.94873333e-01f,
  5.25439560e-01f, 3.43713403e-01f, 4.13258970e-01f, 1.89460427e-01f, 2.25517556e-01f, 1.88734725e-01f, 2.86833763e-01f, -9.01766643e-02f, -5.78187257e-02f, 6.33448139e-02f,
  1.04444087e-01f, -1.09427623e-01f, -9.39327851e-02f, -1.21529683e-01f, 5.93084563e-03f, 5.43221198e-02f, 3.52830961e-02f, 7.25279078e-02f, -5.95585007e-05f, 5.63166151e-03f,
  -3.78174037e-02f, 7.81069556e-03f, -9.88265127e-03f, 6.06971309e-02f, 7.35231936e-02f, -7.82282203e-02f, 8.10123142e-03f, 2.12607592e-01f, 1.01628140e-01f, 2.60575891e-01f,
  7.30053633e-02f, 8.31874236e-02f, -3.36958289e-01f, -8.91202986e-02f, -4.12108116e-02f, -1.47681415e-01f, -1.16550229e-01f, -1.43643469e-01f, -1.23345621e-01f, -4.76143025e-02f,
  1.64948702e-02f, -1.31969564e-02f, 3.45693342e-02f, -1.77590232e-02f, 1.87268853e-02f, -7.66876638e-02f, -1.37130484e-01f, 7.18211895e-03f, -5.48942052e-02f, -3.33078653e-02f,
  1.65411029e-02f, 4.40289937e-02f, 7.68289268e-02f, -1.16199501e-01f, -2.41288054e-03f, -8.66204277e-02f, -5.47089167e-02f, 4.03324105e-02f, -1.36928633e-01f, -6.91226870e-02f,
  -2.53051549e-01f, 2.36369949e-02f, 8.94293785e-02f, -1.03050828e-01f, -7.19222873e-02f, -1.41036242e-01f, 3.15988176e-02f, 1.04490727e-01f, -4.56890352e-02f, -8.03780109e-02f,
  -1.46383092e-01f, 5.23559228e-02f, -4.48489524e-02f, -2.00375095e-01f, -3.08238324e-02f, 7.55887330e-02f, 1.64028540e-01f, 3.86928767e-02f, 3.76476976e-03f, -1.80076495e-01f,
  1.86912827e-02f, 4.81353188e-03f, -1.31758070e-02f, -2.10921187e-02f, -2.49380961e-01f, -1.35739908e-01f, -7.44616166e-02f, -8.70046169e-02f, -1.87064305e-01f, -4.86632325e-02f,
  -3.72887939e-01f, -3.11405621e-02f, -1.34997785e-01f, -2.02976149e-02f, 1.15204021e-01f, 1.83864105e-02f, 8.85310248e-02f, 2.11430956e-02f, -3.43272574e-02f, -1.22037008e-01f,
  5.88654950e-02f, -6.36155084e-02f, -3.33107007e-03f, -4.28153574e-02f, -2.39873007e-01f, -1.23142913e-01f, -8.22821632e-02f, 3.79925198e-03f, -7.67751634e-02f, -3.64556117e-03f,
  -1.38913557e-01f, -1.29256882e-02f, -1.08825721e-01f, -2.22906917e-01f, -1.71517044e-01f, -3.18425685e-01f, -1.92288622e-01f, -2.44685113e-01f, -2.87568003e-01f, -1.93495944e-01f,
  -5.78851521e-01f, -2.99215406e-01f, -8.59044716e-02f, -3.87865394e-01f, 1.36264861e-01f, -4.77257185e-02f, -1.77547157e-01f, -2.32064858e-01f, -2.48301819e-01f, -1.88918650e-01f,
  7.90535212e-02f, 1.30735263e-01f, -1.78694487e-01f, 7.41852447e-03f, -9.65707526e-02f, -1.74556717e-01f, -9.27584171e-02f, 3.76580022e-02f, 2.31689587e-01f, 4.12881702e-01f,
  2.87470311e-01f, 1.27712980e-01f, 2.52651833e-02f, 4.62926030e-02f, -2.13948056e-01f, -8.81485455e-03f, -1.13323458e-01f, 3.75760980e-02f, 8.13738927e-02f, -1.70516297e-01f,
  -2.51356900e-01f, -4.66627985e-01f, 1.52395114e-01f, 1.02358699e-01f, 9.16895270e-02f, -9.00313109e-02f, -6.81732744e-02f, -1.02398872e-01f, -2.22088993e-02f, -1.13266647e-01f,
  9.92981344e-03f, 1.29838428e-02f, -1.08226143e-01f, 6.08980320e-02f, -5.22443764e-02f, -5.37890866e-02f, -1.70424134e-02f, -1.30231589e-01f, -1.29719496e-01f, 1.27382157e-03f,
  1.31585941e-01f, 5.40428348e-02f, -2.15318680e-01f, -3.37292477e-02f, -1.98793158e-01f, -3.68895801e-03f, -7.18572959e-02f, -5.82809411e-02f, -1.37862623e-01f, -2.92945594e-01f,
  2.08964437e-01f, 9.17012915e-02f, 3.57671790e-02f, -9.59714279e-02f, 7.76851848e-02f, 1.33760246e-02f, -7.76112527e-02f, 7.82940239e-02f, 1.03518493e-01f, -9.04935524e-02f,
  -1.96252204e-03f, 7.92471692e-02f, -1.53095480e-05f, -4.71143685e-02f, 1.40627893e-02f, 8.12009200e-02f, 1.58582628e-02f, 7.52922595e-02f, 1.30721644e-01f, 8.72305110e-02f,
  -4.85444851e-02f, -3.92180160e-02f, 3.82318422e-02f, 1.37517950e-03f, 2.80120485e-02f, -1.98310874e-02f, 2.94826292e-02f, 1.55686168e-02f, -4.32998426e-02f, -4.97615300e-02f,
  -2.61300713e-01f, 3.97551596e-01f, -2.27718100e-01f, 2.23850403e-02f, -8.04380625e-02f, 1.61435217e-01f, 1.12006497e-02f, 6.93931356e-02f, -1.02779210e-01f, 2.72759348e-02f,
  -7.34117329e-02f, -1.38076842e-01f, -2.26989627e-01f, 7.44013116e-02f, 1.41543744e-03f, -1.28463358e-01f, 3.20982039e-02f, -1.01287723e-01f, 4.07223143e-02f, 2.55607925e-02f,
  -1.97505787e-01f, -1.03391916e-01f, -3.76967758e-01f, -2.87123799e-01f, -1.17459647e-01f, -1.80173710e-01f, -1.73678800e-01f, -1.79706529e-01f, -2.10418373e-01f, -4.36179608e-01f,
  -7.77624696e-02f, 2.87980705e-01f, -3.18904579e-01f, 2.63042569e-01f, 8.07792172e-02f, 1.79817155e-02f, 4.43329781e-01f, 3.09440970e-01f, 2.47597873e-01f, 3.75877053e-01f,
  -3.16406310e-01f, -7.07189202e-01f, -5.22724926e-01f, -3.27209115e-01f, -1.71929672e-01f, 7.42078722e-01f, 5.02450705e-01f, -2.73268908e-01f, -4.40370649e-01f, -9.56139788e-02f,
  3.42104077e-01f, 3.50865394e-01f, -7.57565871e-02f, -1.59291416e-01f, 1.07761122e-01f, -1.83564126e-01f, 1.73947141e-01f, 6.77658711e-03f, -1.06649488e-01f, 1.72468916e-01f,
  -1.83591828e-01f, -4.31054324e-01f, -3.28722596e-02f, -3.02391917e-01f, -6.45284951e-02f, 3.62998322e-02f, 1.51334181e-01f, -5.42622581e-02f, -1.63704529e-01f, 1.82893008e-01f,
  -1.73258185e-01f, -1.49562836e-01f, -2.57835925e-01f, -1.00088166e-02f, -6.52072877e-02f, -8.51204321e-02f, -6.36406289e-03f, -2.12124810e-01f, -1.48828119e-01f, -2.02386349e-01f,
  -5.21055758e-02f, -2.91203439e-01f, -4.07684684e-01f, -9.57147405e-03f, -2.52466410e-01f, -2.50706047e-01f, -2.48307526e-01f, -4.69095528e-01f, -3.72397095e-01f, 2.91463375e-01f,
  1.10957831e-01f, -4.85236719e-02f, 5.24292188e-03f, 1.07134670e-01f, 2.04682440e-01f, 4.90251854e-02f, 3.58801298e-02f, 1.81804574e-03f, 1.99497826e-02f, -2.40127519e-02f,
  -1.30660027e-01f, 1.00548975e-01f, -1.07213497e-01f, -2.46042423e-02f, -2.56949943e-02f, -1.65076591e-02f, 4.32400554e-02f, 1.64979666e-01f, -8.85259584e-02f, 5.26745357e-02f,
  -1.10335147e-03f, -5.40677421e-02f, -2.57752109e-02f, 5.52296154e-02f, -1.10151730e-02f, -9.71034318e-02f, 6.06417358e-02f, -7.83986598e-02f, -4.26315330e-02f, 8.25884473e-03f,
  3.53432387e-01f, -2.36159325e-01f, 2.46387035e-01f, 4.57494035e-02f, 4.83549424e-02f, -1.20774060e-01f, 9.54318345e-02f, -9.66476073e-05f, -7.81065747e-02f, -7.36942813e-02f,
  -1.71176389e-01f, -1.51582986e-01f, -1.51193410e-01f, 5.90629280e-02f, -6.80087805e-02f, 4.38560843e-02f, 1.82652399e-01f, 4.88921143e-02f, 9.73430723e-02f, 1.71795323e-01f,
  3.11786115e-01f, 2.55787313e-01f, 2.61072874e-01f, 1.19064525e-01f, 2.16075376e-01f, 6.55675977e-02f, 1.78777084e-01f, 9.03104804e-03f, 1.24331735e-01f, 8.73018682e-01f,
  -5.27239144e-01f, -2.82606065e-01f, 1.32774174e-01f, -5.69202900e-01f, -3.63983691e-01f, -1.18175030e-01f, -3.87947410e-01f, -3.73169482e-01f, -3.76624912e-01f, -4.14434314e-01f,
  1.55551173e-02f, 2.49688685e-01f, 3.94673944e-01f, 2.61516850e-02f, -9.83288661e-02f, -3.21833074e-01f, -4.16007042e-01f, -1.60741329e-01f, -1.46177202e-01f, -4.23437417e-01f,
  -4.52909738e-01f, -5.49947858e-01f, -4.54073310e-01f, -2.43848518e-01f, -1.03603207e-01f, 4.82996292e-02f, 5.90503514e-02f, -1.73040837e-01f, -1.21082693e-01f, -1.87722683e-01f,
  2.10722536e-01f, 6.94824848e-03f, 3.87571454e-02f, 6.72833472e-02f, -5.77730648e-02f, -1.40822576e-02f, 7.83180445e-02f, 8.00280347e-02f, 2.64961813e-02f, 7.99817592e-03f,
  -7.25004170e-03f, -3.80602553e-02f, 1.17556289e-01f, -6.80766329e-02f, -9.10613611e-02f, -1.23127483e-01f, -1.25488713e-01f, -3.95445041e-02f, 7.44240731e-02f, 1.08100651e-02f,
  -4.51622121e-02f, -3.96166705e-02f, 1.26469567e-01f, 9.27886143e-02f, 1.28799796e-01f, 7.63716474e-02f, 1.87369019e-01f, 2.08566412e-01f, 1.63098678e-01f, 7.39851967e-04f,
  -2.02461034e-01f, 1.48155734e-01f, 1.19226668e-02f, 7.19671473e-02f, 8.18193480e-02f, 8.94314274e-02f, 1.04843475e-01f, 5.24303392e-02f, 9.36892256e-02f, 8.03579763e-02f,
  -2.59742420e-02f, -1.81942631e-03f, 1.54133486e-02f, 1.78611986e-02f, 1.33160308e-01f, 5.86813800e-02f, -4.93052825e-02f, -5.56737697e-03f, 1.06017537e-01f, 6.95714355e-02f,
  1.08246200e-01f, 1.18521050e-01f, -8.08590930e-03f, 1.39688596e-01f, -3.20830904e-02f, 1.16060907e-02f, -2.38076802e-02f, 9.26142931e-02f, 9.69657451e-02f, -4.28845249e-02f,
  1.93361506e-01f, 1.83689311e-01f, -1.42802382e-02f, 1.27963156e-01f, 7.00294301e-02f, -1.55830942e-02f, 4.62306701e-02f, -8.13422129e-02f, 1.54525518e-01f, 7.54098818e-02f,
  9.79616791e-02f, -1.11351773e-01f, -2.17583627e-02f, -1.44598251e-02f, 4.30350367e-04f, -5.67941600e-03f, -2.24418923e-01f, -1.64493583e-02f, 5.47872782e-02f, -8.03083330e-02f,
  -1.84815541e-01f, -1.10140406e-01f, 4.69738208e-02f, 2.57768720e-01f, 5.53210787e-02f, 1.15057424e-01f, 1.73068359e-01f, 1.78053051e-01f, 2.57929772e-01f, -2.26062357e-01f,
  -3.28458577e-01f, -1.53506622e-01f, -1.42183587e-01f, -6.46591187e-01f, -3.03836644e-01f, -2.53792834e-02f, 1.43240109e-01f, -1.98987350e-01f, -2.86517829e-01f, 2.54355092e-02f,
  -2.85917763e-02f, -2.57135183e-01f, -2.75564075e-01f, -6.37011081e-02f, 1.65627688e-01f, 3.86433125e-01f, 1.89832985e-01f, 1.00952595e-01f, -1.18660055e-01f, -1.87979519e-01f,
  -1.34122685e-01f, -3.78016651e-01f, -3.05706769e-01f, -2.46410921e-01f, -4.79600877e-01f, -2.56414711e-01f, -2.55096644e-01f, -2.90034056e-01f, 1.03241198e-01f, -1.10919975e-01f,
  -1.02825537e-01f, -2.01832891e-01f, 5.81678189e-02f, -6.63898960e-02f, -1.10387847e-01f, 6.64995015e-02f, -3.00222207e-02f, -2.37506956e-01f, -1.02073327e-01f, -1.20468467e-01f,
  -1.94483191e-01f, -1.23550430e-01f, -1.09660909e-01f, -2.26891160e-01f, -2.70561546e-01f, -6.26302734e-02f, -9.25558507e-02f, -1.81882735e-02f, 5.43132015e-02f, 5.11837713e-02f,
  9.44340527e-02f, 1.34400949e-01f, 2.45952848e-02f, 9.80527177e-02f, -8.20140913e-03f, 3.19918618e-02f, -8.88919309e-02f, 2.87524816e-02f, 1.09445877e-01f, -7.14205727e-02f,
  1.56780005e-01f, 5.00641167e-02f, -1.43688275e-02f, -4.21083644e-02f, 1.12995636e-02f, 1.61052004e-01f, -2.77501680e-02f, 1.90036241e-02f, 1.81099828e-02f, -2.40406524e-02f,
  -2.88998690e-02f, 6.90098628e-02f, 1.46928960e-02f, 2.07141954e-02f, -7.94921294e-02f, 2.47629196e-03f, 2.24560052e-01f, 1.17034195e-02f, -3.73352133e-02f, 1.12973139e-01f,
  -1.35061368e-02f, -3.89303686e-03f, -7.94841275e-02f, 3.60949785e-02f, 1.95501849e-01f, 1.92630440e-02f, 2.74175070e-02f, 4.38665859e-02f, -1.08450472e-01f, 3.05779763e-02f,
  -3.73954743e-01f, 4.25795555e-01f, 4.70305681e-02f, -2.06866842e-02f, 6.82494545e-04f, -3.83636653e-02f, -4.01356332e-02f, -1.03613250e-02f, -1.72400147e-01f, -6.41741827e-02f,
  -1.50798261e-01f, 2.89799902e-03f, -1.89722523e-01f, -3.30625623e-02f, -2.95067877e-02f, 2.10242602e-03f, 7.10854009e-02f, -2.57047787e-02f, 1.34408042e-01f, -1.06521115e-01f,
  1.96764752e-01f, 2.42876694e-01f, 1.79840192e-01f, 1.54965043e-01f, 8.41132402e-02f, 2.15817630e-01f, 1.04764728e-02f, 4.08174656e-02f, 2.79170215e-01f, 1.55517623e-01f,
  -9.61300358e-02f, 1.15702279e-01f, 4.04323906e-01f, 2.22681135e-01f, 2.61977464e-01f, 3.02058220e-01f, 3.68256688e-01f, 2.46820927e-01f, -1.87551081e-02f, 3.68868709e-02f,
  -2.07656994e-01f, -1.81096569e-01f, -3.93145420e-02f, -2.07424425e-02f, 9.06499103e-02f, 2.26808459e-01f, 2.02179641e-01f, 1.88686058e-01f, 9.22386255e-03f, -3.43052894e-02f,
  -9.68883745e-03f, -2.43242215e-02f, -1.73008025e-01f, 1.19262552e-02f, 1.18853025e-01f, -2.47671548e-02f, -7.34172463e-02f, 1.42833190e-02f, -3.97807918e-03f, 2.47891396e-01f,
  -6.84680566e-02f, -3.15122992e-01f, -5.81942983e-02f, -3.15601408e-01f, -2.01512337e-01f, -4.83973771e-02f, 2.33171470e-02f, -6.01808690e-02f, -2.20691934e-02f, 2.76910551e-02f,
  -1.18597336e-01f, -8.96729827e-02f, -8.60057026e-02f, -1.34611741e-01f, -5.33503480e-02f, 2.28125099e-02f, -8.80146213e-03f, 5.26872389e-02f, 8.30579251e-02f, 6.16889633e-02f,
  -1.80691238e-02f, -8.65644068e-02f, 2.66863853e-02f, 7.00453520e-02f, 1.62441641e-01f, -7.12373257e-02f, 5.03960438e-03f, -4.14672755e-02f, -6.76449686e-02f, -9.07474291e-03f,
  -1.25210375e-01f, 5.35739288e-02f, 7.74212033e-02f, -1.11430824e-01f, -2.60173269e-02f, 2.10854895e-02f, 7.36556277e-02f, 6.05914705e-02f, -1.62222460e-02f, 6.93872645e-02f,
  -7.43000675e-03f, 2.01629158e-02f, 1.15478106e-01f, 9.51102562e-03f, 5.55287153e-02f, 4.30238917e-02f, 1.39041081e-01f, -7.31685385e-02f, -1.09315924e-01f, -1.20301381e-01f,
  -1.18203107e-02f, 3.91178094e-02f, -1.66738614e-01f, 2.31442824e-02f, -9.54262689e-02f, -8.54815245e-02f, -7.78461993e-02f, -1.30856782e-01f, -9.69582349e-02f, -1.33118361e-01f,
  -2.47779891e-01f, -3.60789329e-01f, 4.94350307e-02f, -1.20577075e-01f, -1.19046316e-01f, -1.88317254e-01f, -1.49706841e-01f, -1.51295230e-01f, -6.34905547e-02f, -3.16902548e-02f,
  -4.40265164e-02f, -3.48168984e-02f, -5.98670915e-02f, -3.97836752e-02f, 5.56829236e-02f, -9.98294130e-02f, -1.49184644e-01f, 6.26265183e-02f, -4.25218605e-02f, 5.32533787e-02f,
  1.04023054e-01f, -3.50076146e-02f, 9.34438556e-02f, 1.10122524e-01f, -8.50934684e-02f, -1.77018866e-01f, 1.19212940e-01f, -2.58308798e-02f, -6.80668205e-02f, 5.62622659e-02f,
  -5.75735807e-01f, -3.06909382e-01f, -6.49787560e-02f, 1.46599337e-01f, 4.15471166e-01f, 3.01941752e-01f, 9.10640880e-02f, 7.80343637e-02f, 1.70791760e-01f, -2.78253891e-02f,
  -1.36205941e-01f, -8.17903057e-02f, 7.04692071e-03f, -1.11970872e-01f, -6.07722849e-02f, 2.27378443e-01f, 2.27764025e-01f, -7.35652167e-03f, -8.00919309e-02f, 1.52990341e-01f,
  2.22150758e-01f, 1.52021334e-01f, -1.56318575e-01f, -2.05220189e-04f, 3.73644046e-02f, 1.57765582e-01f, 1.55881375e-01f, 1.46052793e-01f, 9.79716405e-02f, 1.28669351e-01f,
  -1.25528127e-01f, -1.42269328e-01f, -1.24710035e-02f, -6.68505803e-02f, -2.40115687e-01f, -2.87413895e-01f, -1.04944907e-01f, -1.60051033e-01f, 9.63060092e-03f, 7.11630806e-02f,
  -4.62370440e-02f, -8.18341970e-02f, -9.83424261e-02f, -1.26720555e-02f, 2.48363540e-02f, -4.16943803e-02f, -2.19653189e-01f, -9.17403549e-02f, 3.27215530e-02f, -5.53260967e-02f,
  -1.05308771e-01f, 2.25158706e-02f, 8.05157796e-02f, -6.21462837e-02f, -1.32782772e-01f, 3.87832373e-02f, -1.13694139e-01f, -1.13039874e-01f, -1.01666644e-01f, 2.07178271e-03f,
  -2.30922520e-01f, -2.13591293e-01f, -2.31907621e-01f, -2.72526555e-02f, -3.30062546e-02f, -4.33783010e-02f, 5.43920882e-02f, 4.78732511e-02f, 3.03784683e-02f, -4.45415312e-03f,
  1.95767760e-01f, 7.88786542e-03f, -5.97397424e-02f, 1.18155353e-01f, -1.95614353e-01f, -1.64061531e-01f, -6.96226135e-02f, -2.08882511e-01f, -1.11127399e-01f, -1.12253241e-01f,
  7.10300356e-02f, 9.54922885e-02f, -9.73091051e-02f, -7.54234195e-02f, -7.65369758e-02f, 6.19320050e-02f, 7.78678581e-02f, -1.80747081e-02f, -4.38975841e-02f, 1.75734445e-01f,
  3.93820196e-01f, -9.97686535e-02f, 1.83773011e-01f, -8.04714188e-02f, 1.01976670e-01f, -2.17177406e-01f, -1.12809859e-01f, 1.81274079e-02f, 1.01928301e-02f, 1.08793110e-01f,
  -7.44992644e-02f, -6.76527768e-02f, -9.49428901e-02f, 1.34042755e-01f, 1.60951987e-01f, 5.05392738e-02f, -1.36109814e-01f, 5.83384857e-02f, 2.29503773e-02f, 9.44646522e-02f,
  -4.20906693e-02f, 1.71083122e-01f, 2.02436149e-01f, 2.04730093e-01f, 1.52347192e-01f, 9.92437303e-02f, 9.23831537e-02f, 1.76835731e-01f, 3.54502648e-02f, 2.63119340e-01f,
  -2.85417944e-01f, -3.76549810e-01f, -1.53454110e-01f, 9.19334739e-02f, 6.58915937e-02f, -2.66905487e-01f, -3.43392700e-01f, -1.99646890e-01f, -2.06492860e-02f, -1.44381300e-01f,
  2.48541012e-02f, 3.54955405e-01f, 3.66351008e-01f, 2.41699770e-01f, 4.05482501e-02f, -1.89963460e-01f, 7.01698428e-03f, 1.83414191e-01f, 1.86067760e-01f, 8.25554784e-03f,
  1.21527530e-01f, 1.00769386e-01f, 7.31432289e-02f, 1.04158588e-01f, -9.43572074e-02f, 2.57848799e-01f, 4.25802842e-02f, 3.75695936e-02f, -4.15236242e-02f, -1.00877769e-01f,
  -1.97553828e-01f, -3.96651894e-01f, 1.82439268e-01f, 1.08215190e-01f, 9.55345202e-03f, -1.44276083e-01f, -8.60255361e-02f, -7.97080770e-02f, -7.90242478e-02f, -4.29275259e-02f,
  6.96746781e-02f, -1.15214251e-02f, 1.12915076e-01f, -3.02068982e-02f, -6.75753579e-02f, -1.29656538e-01f, -4.38170042e-03f, -8.48112255e-02f, 4.78390269e-02f, -9.66240689e-02f,
  -2.93806437e-02f, -1.27786785e-01f, -1.01589754e-01f, 2.86000911e-02f, -3.04966625e-02f, 1.50206327e-01f, -6.91383183e-02f, -1.06383018e-01f, 3.36354300e-02f, -1.48947105e-01f,
  8.50170404e-02f, 8.65214169e-02f, 1.02234587e-01f, -2.50168499e-02f, 1.06156580e-02f, 2.13099774e-02f, 7.08608776e-02f, 5.78953810e-02f, -3.40483189e-02f, -9.02661607e-02f,
  5.69388270e-02f, 5.65079562e-02f, 2.83478983e-02f, 2.27917265e-02f, 1.01101123e-01f, 4.74874687e-04f, -5.08383512e-02f, 6.70741126e-02f, 1.03039145e-02f, -6.75790310e-02f,
  4.48372997e-02f, -2.16206238e-02f, -1.72993094e-02f, 1.12901218e-02f, 1.01225721e-02f, 1.49014024e-02f, -2.65439078e-02f, 9.87762511e-02f, 8.06638896e-02f, -1.53931305e-01f,
  2.27217570e-01f, 2.74524689e-01f, -3.05209681e-03f, -3.52700353e-02f, -6.13488518e-02f, 2.78232917e-02f, -7.07214996e-02f, 6.69102818e-02f, 1.38490426e-03f, -7.76001289e-02f,
  -1.04121186e-01f, 1.20716291e-02f, -5.68175018e-02f, -6.19247444e-02f, -2.49877269e-03f, -5.02162315e-02f, -1.73542334e-03f, 7.82015398e-02f, 6.79820925e-02f, -1.26849025e-01f,
  4.10896428e-02f, -1.62056670e-01f, 2.49511339e-02f, 5.39586358e-02f, 4.42369394e-02f, 1.30803630e-01f, 2.92901434e-02f, -4.18510474e-02f, 4.09161709e-02f, -1.31388798e-01f,
  -5.08413851e-01f, -1.02671564e-01f, -4.43857640e-01f, -2.92938262e-01f, 2.26839736e-01f, 2.05213189e-01f, 2.52829701e-01f, -5.25891893e-02f, -1.27693862e-01f, -4.88349572e-02f,
  8.92025083e-02f, 7.06297159e-02f, -5.09800157e-03f, 2.25223184e-01f, 2.48458758e-01f, 1.75624073e-01f, 1.49759606e-01f, -4.59891669e-02f, 1.25986397e-01f, 2.49585301e-01f,
  2.64372170e-01f, -7.26872357e-03f, -1.87202230e-01f, 6.80423947e-03f, -2.23903418e-01f, -1.35601591e-02f, -1.69888183e-01f, -7.45814890e-02f, 2.67910779e-01f, 7.69416019e-02f,
  -2.25499392e-01f, -3.38406086e-01f, 8.84805918e-02f, 1.16293103e-01f, 3.80860642e-02f, -1.92392007e-01f, -8.95357132e-02f, -1.47014275e-01f, 2.70661823e-02f, -9.83144343e-02f,
  -1.09740226e-02f, -4.54375930e-02f, -1.53918529e-03f, 2.09008623e-02f, -2.11938918e-01f, -9.24375877e-02f, -1.08597048e-01f, -9.24176127e-02f, -2.26012498e-01f, -1.25344500e-01f,
  4.14803803e-01f, 2.53521297e-02f, -2.83313364e-01f, -1.38924107e-01f, -2.88290292e-01f, -5.49540073e-02f, -2.08739117e-01f, -1.55536592e-01f, -2.42595702e-01f, -2.61116415e-01f,
  2.70450264e-02f, 2.47165579e-02f, 1.21411409e-04f, -9.89891142e-02f, 1.03868306e-01f, 5.92662394e-03f, 2.29462069e-02f, 1.55210897e-01f, 9.46724564e-02f, -1.13188140e-01f,
  -1.03688858e-01f, -4.91684303e-03f, -3.61952484e-02f, -6.73110634e-02f, 1.68888997e-02f, -1.03816232e-02f, 4.63555269e-02f, 1.32495640e-02f, 9.40617174e-02f, 1.20304957e-01f,
  1.44073829e-01f, 4.58552223e-03f, -1.50046960e-01f, 5.31318560e-02f, 9.96168405e-02f, 9.64763835e-02f, -4.71061505e-02f, 5.56256855e-03f, -3.42130214e-02f, -2.20359657e-02f,
  -4.01460111e-01f, 1.87103704e-01f, -2.36339480e-01f, 9.25191268e-02f, -4.40499745e-02f, -5.12849353e-02f, 5.69716154e-04f, 6.37114272e-02f, -1.55705875e-02f, -4.25943471e-02f,
  4.04775701e-02f, -5.19693121e-02f, -9.69994441e-02f, 3.23789828e-02f, 4.32861224e-02f, -6.33392856e-02f, 1.96077913e-01f, 7.79357776e-02f, -9.65590626e-02f, -6.80391565e-02f,
  -1.06343739e-02f, 5.80808669e-02f, -1.62963510e-01f, -1.78001836e-01f, -8.37497711e-02f, -3.98127399e-02f, -1.50340572e-01f, -1.56201482e-01f, -1.68249398e-01f, -1.96920857e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  3.84515315e-01f, 5.57096243e-01f, 4.56818432e-01f, 6.44265056e-01f, 6.77549124e-01f, 2.89254248e-01f, 1.93289384e-01f, 2.18865514e-01f, 3.50537628e-01f, 4.70852703e-01f,
  2.11429894e-01f, 3.53057414e-01f, 3.18390906e-01f, 5.94812691e-01f, 3.64293784e-01f, 5.64406276e-01f, 6.22787654e-01f, 2.41546690e-01f, 1.05670683e-01f, 4.20088202e-01f,
  3.14353526e-01f, 2.38430128e-01f, 3.85121495e-01f, 3.33884060e-01f, 3.76019776e-01f, 4.23261493e-01f, 6.09934449e-01f, 5.11802077e-01f, 5.14521956e-01f, 3.79096091e-01f,
  4.04108286e-01f, 3.48227471e-01f, 5.35907388e-01f, 5.44757545e-01f, 3.41784775e-01f, 7.87757158e-01f, -1.95392948e-02f, 3.54651392e-01f, 2.28856280e-01f, 5.37762344e-01f,
  4.83575106e-01f, 4.84165490e-01f, 3.81112814e-01f, 3.70725811e-01f, 3.70294601e-01f, 6.89131677e-01f, 1.34770542e-01f, 3.33756655e-01f, 3.13229293e-01f, 5.04666865e-01f,
  5.24750710e-01f, 2.69316763e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -1.95812255e-01f, -5.15687056e-02f, -1.49069905e-01f, -3.51750851e-01f, -7.68452957e-02f, -1.59916267e-01f, -9.28009897e-02f, -8.87944177e-02f, 8.80095437e-02f, -1.38677284e-01f,
  3.60081613e-01f, -7.97700435e-02f, 5.98293483e-01f, 4.34232429e-02f, -9.75696087e-01f, -3.43916535e-01f, 3.74548942e-01f, -4.72525120e-01f, 4.19304073e-01f, -6.01287842e-01f,
  -6.84728146e-01f, -4.78869200e-01f, -1.87844038e-01f, 2.49060333e-01f, 1.06152818e-01f, 3.88219118e-01f, -1.93954930e-01f, 1.94516391e-01f, -5.78023612e-01f, -2.53944367e-01f,
  3.05203795e-01f, -1.07114211e-01f, 2.77173638e-01f, -6.38972402e-01f, 2.54023135e-01f, -6.69789672e-01f, 3.92042190e-01f, -3.75603557e-01f, 1.61049783e-01f, -5.09776473e-01f,
  -4.31746751e-01f, 4.90338087e-01f, 2.04685307e-03f, 1.12140954e-01f, -6.23696893e-02f, -4.69054788e-01f, -7.89871812e-01f, -2.61116534e-01f, 2.44922668e-01f, -4.38577026e-01f,
  -1.42620340e-01f, -1.02130644e-01f, -2.32609317e-01f, 3.04845840e-01f, -4.15347191e-03f, -1.92661390e-01f, 4.05648142e-01f, -8.16198230e-01f, -7.29669407e-02f, -3.72649521e-01f,
  -7.23276958e-02f, -6.28321886e-01f, 1.00208707e-01f, 2.89171755e-01f, 5.79685606e-02f, -1.73361659e-01f, -2.78230500e-03f, -1.21856421e-01f, 1.50897466e-02f, -1.76811710e-01f,
  3.42038363e-01f, 1.28294244e-01f, -2.19658524e-01f, -2.96688944e-01f, -1.04557108e-02f, 7.24832490e-02f, -5.90989172e-01f, -2.83572465e-01f, -2.00281337e-01f, 3.05232197e-01f,
  8.14114034e-01f, 1.43866226e-01f, 5.05993426e-01f, -1.73916742e-01f, -6.50185525e-01f, -5.94243288e-01f, -5.37066102e-01f, -7.56179154e-01f, -3.15678626e-01f, 2.51357049e-01f,
  4.28647220e-01f, -1.50967548e-02f, -3.36850613e-01f, 1.17673971e-01f, -5.46497583e-01f, 5.72696216e-02f, -5.89930378e-02f, -3.29146162e-02f, -6.28267229e-02f, -2.66590506e-01f,
  2.07220048e-01f, 3.49539995e-01f, 3.65423113e-01f, 3.57392013e-01f, -9.37706828e-02f, -6.87158704e-01f, -5.77830017e-01f, 3.93533222e-02f, -1.92664385e-01f, 9.89335552e-02f,
  -6.51305318e-01f, -9.15794611e-01f, -4.41547036e-01f, -2.38248155e-01f, 6.76058903e-02f, -5.80179155e-01f, 3.84945005e-01f, 5.20617068e-01f, 3.21756452e-01f, 1.93715721e-01f,
  -4.11270469e-01f, -1.13319075e+00f, 2.56113976e-01f, 3.49743783e-01f, 8.10892880e-02f, -1.12649553e-01f, 2.24548906e-01f, -4.68743816e-02f, 2.03076489e-02f, 3.48179489e-02f,
  -1.98235750e-01f, 1.26463205e-01f, -8.34686309e-03f, 3.38738829e-01f, 1.75039083e-01f, -2.48574674e-01f, 2.26529241e-01f, -2.87434697e-01f, 4.84653562e-01f, -6.27938807e-02f,
  5.82767546e-01f, -4.26006228e-01f, 5.22478104e-01f, 3.23604345e-01f, -3.88169050e-01f, -6.01263821e-01f, -3.12759787e-01f, 1.12242594e-01f, -2.35545084e-01f, -1.91650108e-01f,
  -8.07019770e-02f, -3.81148070e-01f, -4.15273905e-02f, -3.68931331e-02f, -5.43748796e-01f, 1.94912985e-01f, -7.34841079e-02f, -3.25755775e-01f, -4.59328115e-01f, 2.35433802e-01f,
  -2.02872343e-02f, -2.51689315e-01f, -3.76894921e-01f, -1.49478182e-01f, 9.37148333e-02f, -5.23242578e-02f, 7.68706441e-01f, 2.10282952e-01f, -3.08385879e-01f, -4.50104743e-01f,
  -5.45814812e-01f, -2.88110018e-01f, 4.85619068e-01f, 4.19336855e-01f, 2.93461770e-01f, -4.90430713e-01f, -5.03171921e-01f, 1.36172753e-02f, 1.10703208e-01f, -2.56268829e-01f,
  -4.53756332e-01f, -1.96060184e-02f, -2.87083864e-01f, -2.64406383e-01f, 5.30345082e-01f, -2.97974139e-01f, -2.06693977e-01f, -1.15452632e-01f, -1.17496260e-01f, -2.85189390e-01f,
  5.77581942e-01f, 1.35573208e-01f, -1.26793887e-02f, 1.24103248e-01f, -1.48480788e-01f, 1.51843816e-01f, 8.80968198e-02f, 1.99999288e-01f, 6.33364543e-02f, 4.63845432e-02f,
  4.85650860e-02f, 3.01984608e-01f, 2.83383653e-02f, 1.26717180e-01f, -4.20953371e-02f, -9.51104835e-02f, -5.38147092e-01f, -2.04599991e-01f, -4.98909086e-01f, -2.72549540e-01f,
  -7.65444219e-01f, 7.95964226e-02f, -2.22996175e-01f, 5.95567048e-01f, 5.55163920e-01f, 3.61694306e-01f, 1.73756912e-01f, -7.15711534e-01f, -2.53574967e-01f, -2.74304330e-01f,
  -3.44427936e-02f, -7.33212382e-02f, -2.46433958e-01f, -3.14562231e-01f, 2.12620109e-01f, -1.76189274e-01f, 5.08041739e-01f, -7.29480743e-01f, -6.14178956e-01f, -4.12594318e-01f,
  3.25237006e-01f, -1.39885888e-01f, -1.61062434e-01f, -1.36229321e-01f, -8.05606067e-01f, 5.42507887e-01f, -4.05570596e-01f, -2.89850891e-01f, -4.49355304e-01f, 2.76770085e-01f,
  3.91989481e-03f, -6.10053599e-01f, -5.28259456e-01f, -6.96204752e-02f, -1.12630680e-01f, -1.18388259e+00f, -3.99540663e-01f, -6.76191002e-02f, 3.69653314e-01f, 3.36613017e-03f,
  1.62623450e-01f, 7.52564073e-01f, 1.08233988e-02f, -1.13422863e-01f, -4.75507706e-01f, 4.92468625e-01f, -1.49445444e-01f, 5.66756055e-02f, -6.17030077e-02f, -2.37380173e-02f,
  6.01888523e-02f, -4.18091714e-02f, 1.82010561e-01f, 1.62679106e-01f, 1.40464604e-02f, -2.96113640e-03f, -2.84753352e-01f, 1.75046146e-01f, -4.31408852e-01f, 3.58186632e-01f,
  5.80460370e-01f, -1.16485953e-01f, -5.78714728e-01f, 1.55638412e-01f, -1.06979474e-01f, 5.16145647e-01f, -2.03841463e-01f, 3.21423650e-01f, 9.25108492e-02f, 9.35026258e-03f,
  2.01128200e-01f, -7.99515128e-01f, -5.12929142e-01f, 1.72228236e-02f, -2.19424758e-02f, -4.18597370e-01f, 3.21913898e-01f, -1.26217389e-02f, -2.19931260e-01f, 1.34531319e-01f,
  -4.44468915e-01f, 4.55663115e-01f, -4.49037164e-01f, -4.50071126e-01f, 1.07520102e-02f, 1.01673615e-03f, -2.19604760e-01f, -2.72053391e-01f, 5.29587865e-01f, 2.02942431e-01f,
  -1.42633557e-01f, -9.14324299e-02f, 5.35050213e-01f, 4.46313828e-01f, 2.97875762e-01f, 1.05612427e-02f, -1.22256977e-02f, 7.61219114e-02f, -1.69888481e-01f, -1.77300841e-01f,
  9.34733823e-02f, -3.76854539e-01f, -2.20455527e-01f, -5.52562594e-01f, 3.04208398e-01f, -4.34340358e-01f, -3.54930311e-01f, -1.77969649e-01f, -1.29553214e-01f, -7.69308805e-01f,
  1.54768884e-01f, -1.02351986e-01f, 2.31672734e-01f, 1.57804444e-01f, 1.91414282e-02f, 2.06721410e-01f, -5.71560673e-02f, 3.11903451e-02f, -1.41271889e-01f, -3.73157144e-01f,
  -1.58812508e-01f, 3.39418314e-02f, -3.14248204e-01f, 3.61159146e-01f, 4.45670187e-01f, -6.23033106e-01f, 1.02169663e-01f, -6.80914000e-02f, 4.70711499e-01f, -4.60482717e-01f,
  4.57481086e-01f, -7.17571378e-01f, -6.25124574e-01f, 1.20477505e-01f, 1.99506059e-02f, 1.14164241e-01f, -8.21134672e-02f, -3.84397894e-01f, -4.46513027e-01f, -1.17124185e-01f,
  -5.12230173e-02f, -4.58047777e-01f, -2.12131426e-01f, 2.08732620e-01f, 2.32491985e-01f, -1.83608368e-01f, -1.85436070e-01f, 2.36447677e-01f, -8.05647433e-01f, -1.03002369e-01f,
  1.23986891e-02f, 5.71090758e-01f, 8.91745508e-01f, -3.78199786e-01f, -8.33547592e-01f, -5.25366545e-01f, -5.25532603e-01f, 1.68660209e-01f, -1.10273592e-01f, -2.59783238e-01f,
  1.36887729e-01f, 2.46400997e-01f, 3.09819877e-01f, 4.69233155e-01f, 1.97712332e-01f, -4.09009010e-01f, -2.04027757e-01f, 8.62593532e-01f, -6.16076648e-01f, 9.86701995e-02f,
  -6.44407749e-01f, 5.81750646e-02f, -8.04334786e-03f, -1.09309979e-01f, 1.94548219e-02f, -1.27917258e-02f, 1.06733344e-01f, 1.59426957e-01f, 5.15259467e-02f, -2.75785446e-01f,
  -1.13781266e-01f, -9.71323401e-02f, -3.64225693e-02f, 6.83244169e-02f, -1.11054108e-01f, -2.81954736e-01f, -1.24774821e-01f, -4.75262702e-01f, 9.46119130e-01f, 3.89200822e-02f,
  -6.11015499e-01f, -2.85625279e-01f, -2.78252184e-01f, -8.82926226e-01f, -2.27716744e-01f, 3.16512823e-01f, -2.20615387e-01f, -1.11385830e-01f, 7.23563656e-02f, -2.46257603e-01f,
  -1.33677915e-01f, -5.49861073e-01f, -1.74752668e-01f, 3.65718186e-01f, -6.52730465e-01f, 2.33882651e-01f, -7.05697596e-01f, -3.13329369e-01f, -1.18207596e-01f, 3.92714649e-01f,
  -5.33915877e-01f, -1.94339886e-01f, -5.55035710e-01f, 4.14465755e-01f, 1.89396784e-01f, 7.49724627e-01f, 1.15879305e-01f, -2.87694126e-01f, 5.06205261e-01f, 4.16420788e-01f,
  2.78924674e-01f, -5.72273433e-01f, -6.17724121e-01f, -2.73324668e-01f, 2.66703248e-01f, -3.71851593e-01f, -3.66127700e-01f, -1.24465033e-01f, -1.05257869e-01f, 1.45606428e-01f,
  -8.16522896e-01f, -6.38442561e-02f, -3.58602017e-01f, -1.80174172e-01f, 1.15144223e-01f, -5.01080453e-01f, -6.56599343e-01f, -5.75399876e-01f, -7.03547969e-02f, -1.74897447e-01f,
  -1.36510774e-01f, -3.48411083e-01f, -1.56320125e-01f, -4.42494780e-01f, 7.55534545e-02f, -2.00073440e-02f, 1.64880697e-03f, 1.46008387e-01f, 3.13964069e-01f, -8.73829350e-02f,
  2.80595899e-01f, -3.95792276e-01f, -1.36392057e-01f, -4.83215570e-01f, -7.44682014e-01f, 1.75972909e-01f, -1.00214675e-01f, 3.81694794e-01f, 2.35324085e-01f, -2.99576491e-01f,
  6.51372492e-01f, -3.16197723e-01f, 2.52985537e-01f, -3.88709486e-01f, -3.86180878e-01f, 1.29837766e-01f, -1.94255248e-01f, -1.18906230e-01f, -1.03607126e-01f, -1.87955439e-01f,
  -5.90696692e-01f, -3.05584162e-01f, -2.16899127e-01f, -8.98020994e-03f, -3.89007956e-01f, -2.42493272e-01f, -3.84909183e-01f, -1.80423260e-01f, -4.55608904e-01f, -5.00356555e-01f,
  -1.73296273e-01f, -3.01114142e-01f, -2.28784844e-01f, 4.71870927e-03f, -2.58623123e-01f, 4.58763123e-01f, -9.87962559e-02f, 2.44584739e-01f, -1.91395417e-01f, -3.05477320e-03f,
  1.67224035e-01f, -1.95909232e-01f, -2.03204915e-01f, -2.31238753e-02f, -3.09178568e-02f, 5.80368400e-01f, -1.17993444e-01f, -3.90849650e-01f, 2.87677526e-01f, 2.42859244e-01f,
  6.02574609e-02f, 4.08528984e-01f, 2.64169071e-02f, 2.48897839e-02f, 9.83483940e-02f, 1.71725512e-01f, 1.46339923e-01f, 6.64857700e-02f, -3.19248557e-01f, -2.28578791e-01f,
  -2.61934072e-01f, -1.39022380e-01f, 3.39707047e-01f, -1.05269598e-02f, -2.46936709e-01f, -7.88280964e-01f, -2.20543772e-01f, 2.31003523e-01f, -1.71683118e-01f, 5.17070666e-02f,
  -2.07703441e-01f, -1.15242176e-01f, -2.61127740e-01f, -5.46733379e-01f, -4.87762064e-01f, -2.95644343e-01f, -1.30694425e-02f, 3.68031383e-01f, -3.06353629e-01f, 6.67145327e-02f,
  8.37619245e-01f, -3.31652641e-01f, -1.50540397e-01f, -2.28322595e-01f, 4.37467933e-01f, 8.39070007e-02f, -7.15478718e-01f, -1.72329560e-01f, 2.58623600e-01f, -1.94277838e-01f,
  -2.65185177e-01f, -2.81670671e-02f, 6.41599596e-01f, -3.72359782e-01f, -3.97293866e-01f, -3.86252016e-01f, -9.49957445e-02f, 3.53710562e-01f, -1.38567284e-01f, -5.42496324e-01f,
  -9.89412889e-02f, -4.89173114e-01f, -4.79937017e-01f, 6.42332077e-01f, -5.11845089e-02f, -1.68787763e-01f, -4.17715430e-01f, -3.98070477e-02f, -7.53788576e-02f, 6.79198563e-01f,
  -3.72262269e-01f, 7.80692622e-02f, 4.53107327e-01f, 4.37492251e-01f, -2.74773031e-01f, -1.73790485e-01f, 8.99908990e-02f, 1.37362179e-06f, -2.79171199e-01f, -1.07105926e-03f,
  -1.73102438e-01f, 2.94551998e-01f, 2.85780970e-02f, 1.87809542e-01f, 1.85089171e-01f, 9.10557359e-02f, -2.28441522e-01f, -1.24532990e-01f, 2.95102835e-01f, -3.52751613e-02f,
  -6.60011649e-01f, -1.64722919e-01f, -1.84753075e-01f, -3.94062072e-01f, -1.47705749e-01f, 8.01756144e-01f, 3.64689827e-01f, -4.35472548e-01f, -5.04165828e-01f, -6.25653148e-01f,
  -1.21532887e-01f, -3.19038868e-01f, 4.17048275e-01f, -7.13877261e-01f, -3.07660282e-01f, -1.98453575e-01f, 6.08726025e-01f, 4.02514666e-01f, -3.54772151e-01f, 2.29064375e-01f,
  -3.49865019e-01f, 4.64938134e-01f, 5.45876957e-02f, -3.45196754e-01f, -8.76864314e-01f, -2.23925769e-01f, -5.83316028e-01f, 2.74245858e-01f, 3.83081496e-01f, -5.52404761e-01f,
  1.70592055e-01f, -1.13904193e-01f, 5.19557536e-01f, -7.68637478e-01f, 6.65945947e-01f, 2.82427132e-01f, 1.47541568e-01f, -2.90754735e-01f, -3.49015027e-01f, 4.35700208e-01f,
  -5.77539623e-01f, 9.47999060e-02f, 1.79523915e-01f, -6.72621846e-01f, -3.37484092e-01f, -3.75944287e-01f, -3.39836985e-01f, 3.51618350e-01f, 6.72633275e-02f, 1.93206921e-01f,
  1.03165656e-01f, 1.02785565e-02f, 1.94757193e-01f, 5.26649468e-02f, 1.12752050e-01f, -5.14646731e-02f, -1.93262115e-01f, 1.72872186e-01f, 9.19020735e-03f, 3.21262658e-01f,
  -1.04462281e-01f, 1.29637331e-01f, -2.39762381e-01f, -3.90226617e-02f, -4.34939474e-01f, -2.61524439e-01f, 2.95291632e-01f, -3.62645298e-01f, -3.08758467e-01f, -2.12853909e-01f,
  -1.90691665e-01f, -4.43602830e-01f, -4.23095226e-01f, 5.56752503e-01f, -9.36904922e-03f, -2.55146116e-01f, -3.72459352e-01f, -5.09393215e-01f, 5.75189590e-01f, -2.98523158e-01f,
  -4.56740141e-01f, -2.43818521e-01f, 3.26719403e-01f, -9.66677908e-03f, 4.75883573e-01f, -1.04436629e-01f, -5.59214830e-01f, 6.56869471e-01f, -5.98523915e-01f, -3.19474310e-01f,
  -3.16599220e-01f, -2.04703584e-01f, -5.16563714e-01f, -2.44830456e-02f, -1.74461737e-01f, 2.94659853e-01f, -6.62272498e-02f, -2.84617513e-01f, -4.02800262e-01f, 7.45569170e-01f,
  -4.03257698e-01f, -4.07609612e-01f, -1.21232167e-01f, -6.69875920e-01f, -2.04135686e-01f, -2.52050012e-01f, -3.61353248e-01f, 1.42026976e-01f, 4.29154336e-01f, -1.11662321e-01f,
  2.49170363e-01f, -6.41803145e-02f, 2.34787151e-01f, -1.34132728e-01f, 4.50170003e-02f, 1.57047614e-01f, -3.38822640e-02f, 4.17844281e-02f, -1.48006231e-01f, -1.37842625e-01f,
  -2.17535168e-01f, 8.62426609e-02f, -1.04954898e-01f, 2.87405044e-01f, -4.07755226e-01f, -1.66562214e-01f, -2.41655916e-01f, -4.38339353e-01f, -3.59146774e-01f, 3.70683253e-01f,
  -8.75331983e-02f, -2.74037749e-01f, -2.76973188e-01f, -3.96299124e-01f, 2.88765311e-01f, 8.36370885e-01f, 9.87339858e-03f, -2.86629736e-01f, -4.44140017e-01f, -2.22006753e-01f,
  4.41616207e-01f, 2.78211623e-01f, -3.65621537e-01f, 2.44621128e-01f, -1.22991920e-01f, -8.84773955e-02f, -1.54326871e-01f, 3.19359899e-01f, 1.47663563e-01f, 1.07057028e-01f,
  2.80052334e-01f, -1.86227128e-01f, 1.72967479e-01f, -6.95982158e-01f, 6.49388492e-01f, -3.05788457e-01f, -1.73826605e-01f, -2.37607837e-01f, -7.06052184e-01f, -4.06756908e-01f,
  -2.92365402e-01f, 5.01916766e-01f, -2.92701036e-01f, 1.15082756e-01f, -2.64826983e-01f, 5.21045864e-01f, -6.07674062e-01f, -4.25019175e-01f, -1.11199044e-01f, 5.10509670e-01f,
  -2.01892287e-01f, -5.54313779e-01f, -1.20016545e-01f, -3.30042362e-01f, 7.99935460e-02f, -3.77854556e-01f, -3.54145974e-01f, -2.67409205e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.29919836e-01f, -5.38074039e-03f, 2.61093289e-01f, 2.50373851e-03f, 5.68095595e-02f, 1.30417779e-01f, 7.45743290e-02f, 6.70058131e-02f, -7.55199715e-02f, 1.73329905e-01f,
  -1.56977884e-02f, 1.32853046e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    