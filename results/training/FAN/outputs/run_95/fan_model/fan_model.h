/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.29904577e-01f, -8.84441137e-02f, -1.84412971e-01f, -2.76776846e-03f, 1.13772400e-01f, 2.59371966e-01f, 2.49856710e-01f, 5.04387245e-02f, 2.04668954e-01f, 3.04140747e-02f,
  1.19896278e-01f, -1.30364671e-01f, 8.98047984e-02f, 9.44908187e-02f, 1.56455323e-01f, 1.30875066e-01f, 7.79085904e-02f, -1.05422968e-03f, 6.10663779e-02f, -8.55252221e-02f,
  5.56889065e-02f, 1.74804166e-01f, -6.19927570e-02f, -4.18796651e-02f, -6.76311255e-02f, -1.39430821e-01f, -1.62847236e-01f, -7.61302486e-02f, -4.20939848e-02f, -2.65085232e-02f,
  1.15520924e-01f, 1.25427067e-01f, -5.55716269e-02f, 9.82752256e-03f, -9.88531187e-02f, -4.97936495e-02f, -3.49901952e-02f, 4.24865931e-02f, 1.28084782e-03f, -3.95708755e-02f,
  -1.57738384e-03f, 2.40145978e-02f, 1.65216662e-02f, 2.50966325e-02f, -1.69259384e-02f, -6.54322281e-03f, 2.21737754e-02f, -5.74611127e-03f, -2.93890927e-02f, -2.49761958e-02f,
  -6.88998923e-02f, -5.74988797e-02f, -7.80700287e-03f, -1.95642505e-02f, -4.55174707e-02f, 8.18674862e-02f, -3.87222916e-02f, -6.50512502e-02f, -3.72071564e-02f, 4.56707031e-02f,
  1.13585694e-02f, 4.90234122e-02f, -5.31607680e-02f, 2.37116646e-02f, -1.95799372e-03f, 2.91313920e-02f, 6.27582818e-02f, -5.28262742e-02f, -5.31416759e-03f, 3.16512324e-02f,
  8.79527186e-04f, -4.84709106e-02f, 7.31935054e-02f, 1.60720479e-02f, 6.03195094e-02f, -5.35514299e-03f, -4.02504466e-02f, -7.54600838e-02f, -2.84002572e-02f, -6.90117627e-02f,
  8.30574706e-02f, 3.74981947e-02f, -2.53396370e-02f, -1.43981529e-02f, 1.02821030e-01f, -2.41812188e-02f, 1.98062379e-02f, 6.84707314e-02f, -1.02937646e-01f, -3.26524191e-02f,
  5.68264490e-03f, -1.80684980e-02f, 4.86865267e-02f, 5.93959503e-02f, -4.74522337e-02f, 6.30260445e-03f, 4.29605246e-02f, -1.10022677e-02f, -4.90515642e-02f, 6.35593235e-02f,
  -3.85151021e-02f, -4.99126464e-02f, -4.77147512e-02f, -3.58587764e-02f, 1.27192698e-02f, -1.38241490e-02f, 3.60995308e-02f, 9.37380770e-04f, -7.38381594e-02f, 1.00863537e-04f,
  -1.48675460e-02f, 5.07888757e-03f, -1.84939317e-02f, -5.78327291e-02f, -3.70099954e-02f, -6.52161166e-02f, -2.77249757e-02f, -1.64576564e-02f, -2.40571145e-02f, 2.66795978e-02f,
  -1.10882640e-01f, -4.79453728e-02f, 2.28381529e-01f, -5.34554869e-02f, 2.23417170e-02f, 1.09331056e-01f, -4.30478854e-03f, -3.80990840e-02f, 1.22189395e-01f, -2.75108874e-01f,
  -1.80333257e-01f, 2.68097837e-02f, 2.74036527e-02f, -1.59016311e-01f, 1.44009754e-01f, 1.05242476e-01f, -8.02879184e-02f, -5.58879524e-02f, 1.40111059e-01f, -1.68277964e-01f,
  9.95419249e-02f, -2.25863710e-01f, 5.67812063e-02f, -7.16262218e-03f, -2.38079354e-01f, 5.67801036e-02f, -1.91362426e-01f, 1.10798538e-01f, -1.57025456e-01f, 1.85083859e-02f,
  -7.42700174e-02f, -1.08748145e-01f, -2.60337275e-02f, 8.80949870e-02f, -3.82145979e-02f, 5.22734672e-02f, 4.47398089e-02f, 7.25243092e-02f, 5.42955026e-02f, -8.55892599e-02f,
  -2.79052928e-02f, -1.71692315e-02f, -3.59264128e-02f, 3.94312330e-02f, 9.61811393e-02f, 3.59620224e-03f, 2.11962387e-02f, -6.97820485e-02f, 1.83587912e-02f, -2.12928988e-02f,
  7.76044698e-03f, 3.28582115e-02f, -3.42369662e-03f, 1.82185769e-02f, 8.61559138e-02f, -3.41185741e-03f, 6.50714561e-02f, -5.82785681e-02f, -1.06117232e-02f, -1.57768261e-02f,
  -1.23105515e-02f, 8.38831142e-02f, -2.75435634e-02f, -6.54881448e-02f, -1.19097754e-01f, -1.14239842e-01f, -1.29304985e-02f, -1.75998267e-02f, 3.38188298e-02f, -1.63493888e-03f,
  -8.47712606e-02f, -5.09317070e-02f, 2.25938037e-02f, 3.08795776e-02f, -2.60112509e-02f, -3.24132554e-02f, -2.53226142e-02f, -7.78343007e-02f, -4.79162484e-03f, -8.46606568e-02f,
  -5.63900620e-02f, -3.25711519e-02f, 3.93138230e-02f, 2.62552015e-02f, 2.57909037e-02f, 2.78789159e-02f, -5.95769286e-02f, 1.03234611e-02f, 6.24417551e-02f, 1.93286105e-03f,
  -2.41504814e-02f, 3.67762744e-02f, 2.21655099e-03f, -5.11271739e-03f, -2.40256991e-02f, 4.04849984e-02f, 9.38800797e-02f, -4.93236259e-02f, 4.43680063e-02f, 7.20858425e-02f,
  3.88135053e-02f, -2.40758713e-02f, -1.30101927e-02f, -3.01890522e-02f, -4.88288291e-02f, 8.09636991e-03f, -8.29295516e-02f, 1.54170562e-02f, -5.07030450e-02f, 4.68909815e-02f,
  -4.29716194e-03f, -1.72364004e-02f, -2.78154425e-02f, -8.31465796e-02f, -8.04466009e-03f, -1.96075570e-02f, 2.29074107e-03f, 1.81580752e-01f, 9.80492011e-02f, 5.35648875e-02f,
  3.34716178e-02f, 8.45709667e-02f, 1.05468072e-01f, -8.91010463e-02f, -2.51337048e-02f, -3.34972233e-01f, -2.42174938e-01f, 8.38399753e-02f, -1.00937955e-01f, 2.88722627e-02f,
  -1.18691795e-01f, 1.25651643e-01f, 1.07464775e-01f, -7.12820292e-02f, -4.07675862e-01f, -9.73516703e-02f, -2.31529519e-01f, -1.20685818e-02f, -7.65309557e-02f, 1.51526988e-01f,
  -7.74703622e-02f, -1.03571132e-01f, 5.67604974e-02f, 1.03518449e-01f, 9.89852175e-02f, 1.58936217e-01f, 1.24369897e-01f, 6.55135736e-02f, 5.40012866e-02f, -5.83362654e-02f,
  5.08259386e-02f, 1.72365308e-01f, 1.49850801e-01f, 1.23951368e-01f, -2.23194249e-02f, 2.27808510e-03f, 1.19012460e-01f, -5.75667322e-02f, 3.30289709e-03f, -6.46742135e-02f,
  1.43984882e-02f, -9.88874212e-03f, -5.17246760e-02f, -4.51379083e-02f, -1.35305931e-03f, 6.07460625e-02f, 7.79649392e-02f, 2.19856575e-02f, 4.29204553e-02f, -5.15882112e-02f,
  -1.16567807e-02f, -5.25802113e-02f, 5.72806261e-02f, -1.68884620e-02f, 1.09383753e-02f, -7.30286026e-03f, 4.95006293e-02f, -3.24980579e-02f, 2.54843552e-02f, 3.81617516e-04f,
  2.83305068e-02f, -1.07187174e-01f, 2.88231000e-02f, -1.42526785e-02f, 2.05874424e-02f, -2.36646105e-02f, 3.21082845e-02f, 4.14360091e-02f, -5.68840355e-02f, 5.90438433e-02f,
  -9.72166583e-02f, 6.99593802e-04f, 2.48570330e-02f, -4.89076823e-02f, 1.39767043e-02f, 2.11111107e-03f, 1.78416315e-02f, 2.91515850e-02f, -6.54717833e-02f, 2.56917384e-02f,
  -2.19806470e-02f, -1.48715433e-02f, -1.49479276e-02f, 5.89934923e-02f, -6.07485250e-02f, 7.55206915e-03f, 1.40963960e-02f, 3.15084606e-02f, 2.00639069e-02f, -3.05678323e-02f,
  2.38488466e-01f, 8.75826702e-02f, -2.89941137e-03f, -3.52110453e-02f, 4.49716300e-02f, 4.99844598e-03f, 1.87147688e-02f, 4.06874232e-02f, -6.05929643e-03f, -5.79865240e-02f,
  7.10353181e-02f, 6.43831715e-02f, -2.70142611e-02f, -5.58403842e-02f, 1.48808500e-02f, -2.38423310e-02f, -1.25288600e-02f, -8.84731114e-02f, 1.73323825e-02f, 9.62445438e-02f,
  1.34486064e-01f, -3.46016418e-03f, -9.74599421e-02f, -6.32331446e-02f, -1.12120761e-02f, -2.43628528e-02f, -5.73845170e-02f, 2.01333072e-02f, -4.96787541e-02f, -1.56332012e-02f,
  3.39679122e-01f, -1.65629789e-01f, 5.65488674e-02f, 1.18953615e-01f, 1.00576773e-01f, -3.23083013e-01f, -3.29379261e-01f, 5.19018807e-02f, -3.02184988e-02f, -2.60424703e-01f,
  -2.10220277e-01f, -3.17509681e-01f, -2.44091779e-01f, -1.43443018e-01f, -6.72154129e-02f, -1.33794278e-01f, 4.45521735e-02f, -5.80136664e-02f, 6.21680021e-02f, 4.33664769e-02f,
  1.22717619e-01f, 5.73277511e-02f, 3.65913822e-03f, 8.57118517e-02f, 4.32445444e-02f, 1.55854151e-01f, 9.38123167e-02f, -8.55182856e-02f, 1.73544530e-02f, -1.29701123e-01f,
  1.97728258e-02f, -5.98329492e-02f, 2.41711121e-02f, -3.97537313e-02f, 7.73452893e-02f, 2.41777562e-02f, 2.44144090e-02f, -7.23240301e-02f, -4.70569730e-02f, -2.70945523e-02f,
  1.50375348e-03f, 2.46398598e-02f, 1.34077761e-02f, -3.49239889e-03f, 1.12599200e-02f, 4.36052820e-03f, 6.84808344e-02f, 4.82315123e-02f, 3.59285101e-02f, 1.36778373e-02f,
  -1.87473092e-02f, -6.93010017e-02f, -4.67651226e-02f, -5.30914054e-04f, -8.97965115e-03f, -2.90381685e-02f, -3.69460694e-02f, -1.18903823e-01f, -2.47978419e-02f, -2.55393218e-02f,
  1.26290899e-02f, -4.57936078e-02f, 7.22803622e-02f, 9.37187001e-02f, -2.72630230e-02f, 1.17746547e-01f, 1.06564555e-02f, -1.23477932e-02f, 2.83877761e-03f, -1.41824242e-02f,
  7.16549307e-02f, -2.00612955e-02f, -5.51732536e-03f, -1.65497307e-02f, 1.96027048e-02f, 2.93405633e-02f, -5.10195643e-02f, -9.04651731e-02f, -7.99150765e-03f, -2.72303764e-02f,
  -3.34681273e-02f, -3.50097269e-02f, -7.50561878e-02f, -2.46266481e-02f, 3.65313105e-02f, -7.92605504e-02f, 1.90025587e-02f, -6.07226789e-02f, 1.13797339e-03f, 6.43636361e-02f,
  -4.30024154e-02f, -7.88490027e-02f, 5.07484265e-02f, -7.81615227e-02f, 5.14939288e-03f, 2.87465304e-02f, -5.29558472e-02f, -7.33415410e-03f, -8.33924189e-02f, 2.31907964e-02f,
  -2.77485307e-02f, -2.07612198e-02f, -9.09273848e-02f, -5.93172647e-02f, -5.15699424e-02f, -3.31058092e-02f, -3.29308659e-02f, 1.29827112e-02f, -7.46871252e-03f, 1.43805062e-02f,
  3.37301716e-02f, -1.02999496e-04f, 5.71363196e-02f, 3.51239070e-02f, -1.56732537e-02f, 2.77254749e-02f, 3.05030216e-03f, 2.21449938e-02f, 2.85821911e-02f, -2.25363672e-02f,
  -1.13383755e-02f, -1.94903240e-01f, -4.33518857e-01f, -1.79170534e-01f, 1.11910850e-01f, 2.29017064e-01f, 1.36614144e-01f, -5.55202700e-02f, -2.12392688e-01f, 2.60800809e-01f,
  1.83785990e-01f, -2.45717660e-01f, -8.95822421e-02f, 1.81093603e-01f, 7.61184692e-02f, -2.63130423e-02f, 1.94817424e-01f, 1.23851791e-01f, -1.37150809e-01f, -4.10228409e-02f,
  -5.52654341e-02f, 2.18663216e-01f, -8.51502568e-02f, 4.29089889e-02f, -4.31789905e-02f, -1.64198861e-01f, 2.88268089e-01f, -2.39902213e-02f, 2.24804893e-01f, 5.41127697e-02f,
  1.85758695e-02f, -8.47550184e-02f, -5.54182045e-02f, -3.86852548e-02f, 8.19037855e-02f, 6.60955906e-02f, 4.12120074e-02f, -7.88395330e-02f, -4.79427539e-02f, -3.19493143e-03f,
  5.82914846e-03f, 1.47316826e-03f, -1.39651550e-02f, -5.10484390e-02f, -1.60619877e-02f, -1.03142485e-01f, -5.56457303e-02f, -4.64481190e-02f, -3.47369872e-02f, -2.56306268e-02f,
  -3.56178917e-02f, -4.03111689e-02f, 1.88759714e-02f, 3.80613618e-02f, -8.09534565e-02f, -1.39632383e-02f, -1.64370332e-02f, 1.61192957e-02f, 1.27576431e-02f, -5.01033030e-02f,
  -1.67363859e-03f, 5.73720643e-03f, -1.37441084e-02f, 6.88783452e-02f, -7.11029768e-02f, 3.16593274e-02f, 2.96967514e-02f, 8.48271474e-02f, -2.05825940e-02f, 3.00110206e-02f,
  1.54728945e-02f, 2.23268513e-02f, 1.42062893e-02f, -3.80971059e-02f, 2.02324446e-02f, 4.19943295e-02f, -2.15086043e-02f, -3.28359054e-03f, 6.73793256e-03f, 2.10154075e-02f,
  4.77662077e-03f, -3.64842750e-02f, -4.37703915e-03f, 4.21758816e-02f, -1.05522936e-02f, 3.12016569e-02f, 1.58542600e-02f, -4.43517305e-02f, -5.94457835e-02f, 8.82647410e-02f,
  6.79983273e-02f, 3.63432243e-02f, -3.30338255e-02f, -3.31977643e-02f, 1.84157118e-02f, 4.93717231e-02f, -4.05164296e-03f, 4.22934443e-02f, -4.95237596e-02f, -1.58510134e-02f,
  5.53128831e-02f, -1.60399619e-02f, -5.32454951e-03f, 1.41011300e-02f, -4.19571437e-02f, 1.22446626e-01f, 5.05339615e-02f, -2.85439678e-02f, 3.39488126e-02f, 6.95301816e-02f,
  4.45585996e-02f, 2.12479699e-02f, -7.13828281e-02f, -3.97984274e-02f, 1.08839711e-02f, 2.97652110e-02f, -6.87021203e-03f, 1.85538623e-02f, 1.23868316e-01f, -9.40676872e-03f,
  -2.30448976e-01f, -1.13455415e-01f, 1.06833197e-01f, -1.96795359e-01f, -1.62575424e-01f, -3.96627598e-02f, 1.23060837e-01f, -2.11182356e-01f, -3.05740952e-01f, 3.70180160e-02f,
  -5.54000698e-02f, -1.59977050e-03f, 1.18086852e-01f, -1.06035009e-01f, 4.97446992e-02f, 1.66952625e-01f, -1.82934284e-01f, 3.96502623e-03f, -2.09022183e-02f, -1.05394036e-01f,
  -1.05711468e-01f, -8.07432830e-02f, 1.58925831e-01f, -5.22855669e-02f, 5.57280295e-02f, -8.92152488e-02f, -4.74892594e-02f, 1.03754677e-01f, -8.78280774e-02f, 5.04899845e-02f,
  6.23298772e-02f, -1.84729567e-03f, 9.14408918e-03f, -6.28049253e-04f, -3.19825928e-03f, -7.46396482e-02f, 9.42074507e-02f, 1.46457642e-01f, -4.68855798e-02f, -7.90159181e-02f,
  3.00879637e-03f, -6.03147224e-02f, -7.26209357e-02f, -5.72523661e-02f, -8.04902464e-02f, -2.23730411e-02f, 2.51197852e-02f, -3.96756455e-02f, 1.95327178e-02f, 8.45267624e-02f,
  -5.05278818e-03f, 7.35238045e-02f, -1.16579700e-02f, -1.88129731e-02f, -4.26435769e-02f, -1.01191206e-02f, -2.22488623e-02f, 8.06740858e-03f, -2.08312869e-02f, -5.67137562e-02f,
  3.23093608e-02f, -2.86807418e-02f, 2.82725375e-02f, -2.89083607e-02f, 5.83492629e-02f, 3.81352827e-02f, -8.61319061e-03f, 5.14418557e-02f, 2.49733459e-02f, -7.71309882e-02f,
  -5.10967597e-02f, -3.71099673e-02f, 1.26793738e-02f, -8.44455976e-03f, -7.01325666e-03f, -6.00255001e-03f, 2.07301956e-02f, -1.53916227e-02f, -1.49984343e-03f, -4.08368930e-02f,
  4.35713902e-02f, -8.72512255e-03f, 2.55963448e-02f, -4.20977473e-02f, 4.77966443e-02f, 3.03218402e-02f, -6.17036484e-02f, -1.49425045e-02f, 3.63927074e-02f, 5.43711372e-02f,
  -6.17207913e-03f, -1.36990607e-01f, 6.51018247e-02f, -3.74504132e-03f, 1.34260952e-01f, 5.52563183e-03f, -4.19003740e-02f, -5.47412746e-02f, -2.73430161e-02f, -1.94160063e-02f,
  -1.05370842e-02f, 1.71516370e-02f, -3.05898935e-02f, -1.94900129e-02f, 7.88205490e-02f, 3.16001922e-02f, 5.92199825e-02f, -4.17507701e-02f, -2.29214747e-02f, 3.22109684e-02f,
  5.78844324e-02f, -2.33021788e-02f, 3.23788151e-02f, -6.58212528e-02f, -2.18791142e-02f, 4.36747540e-03f, -6.02500066e-02f, 2.67564412e-02f, -5.95946622e-04f, -1.29200220e-02f,
  1.34378120e-01f, -3.57988089e-01f, -1.48124842e-03f, 9.00241733e-02f, 2.20545888e-01f, 9.04047117e-02f, 7.69866556e-02f, -9.97833982e-02f, 1.31225735e-01f, -3.10461432e-01f,
  4.04050061e-03f, -1.01410255e-01f, -9.09320191e-02f, -1.58861116e-01f, 1.50615260e-01f, 4.18241359e-02f, -1.43383052e-02f, -5.57292774e-02f, 3.43501754e-02f, -9.88962129e-02f,
  -3.53103727e-02f, 9.08880755e-02f, 2.97618136e-02f, 1.41170165e-02f, -7.26128221e-02f, 1.34909702e-02f, 2.62713023e-02f, 2.61446927e-02f, -6.38469458e-02f, 8.70243311e-02f,
  1.18989684e-03f, -3.10420822e-02f, 3.52689885e-02f, -2.63688061e-02f, -6.35673329e-02f, -6.45167008e-02f, -1.82769280e-02f, 3.72315422e-02f, 7.93920979e-02f, -1.15310056e-02f,
  -1.54929131e-03f, 6.01485670e-02f, 3.95963416e-02f, 3.10266502e-02f, 3.75287347e-02f, 4.89275753e-02f, 1.08610392e-02f, -2.19956301e-02f, 3.49144451e-02f, -5.00549227e-02f,
  9.60973836e-03f, -4.44888324e-02f, 3.22272279e-03f, 3.87193612e-03f, -1.11501999e-02f, 1.43366540e-02f, -3.47121842e-02f, -8.37060735e-02f, -2.52968017e-02f, -1.44456876e-02f,
  -7.28861466e-02f, -1.51123339e-02f, 4.09353301e-02f, 2.07905862e-02f, 5.12699001e-02f, 7.96641260e-02f, 8.05841107e-03f, 2.59130239e-03f, -3.14965472e-02f, -7.43435174e-02f,
  5.95351681e-02f, -5.54112298e-03f, -4.56457809e-02f, -2.83316020e-02f, -3.99932601e-02f, -5.06479479e-02f, 3.02976859e-03f, -4.81574498e-02f, 4.96353097e-02f, -5.39640225e-02f,
  6.78235292e-02f, 4.81430143e-02f, -3.89610603e-03f, -2.96456404e-02f, 6.70603886e-02f, 3.14312871e-03f, -2.44497079e-02f, -3.56678851e-02f, -4.63939160e-02f, 1.95050091e-02f,
  -1.63625613e-01f, -1.58106849e-01f, -9.43345055e-02f, -3.64822559e-02f, -2.87271962e-02f, -1.00579016e-01f, 3.54463495e-02f, -5.64216301e-02f, -5.29473759e-02f, -2.97011517e-04f,
  6.13702741e-03f, -7.92922527e-02f, 2.54932251e-02f, 3.62159126e-02f, 5.87249212e-02f, 1.03039702e-03f, -2.95031965e-02f, -4.32045721e-02f, -3.39604616e-02f, -3.83593403e-02f,
  -5.30080907e-02f, -3.72526459e-02f, -2.88594570e-02f, 4.44191583e-02f, -1.96835920e-02f, -7.32930526e-02f, -2.30678953e-02f, 5.08002937e-02f, -6.66867709e-03f, 4.32612607e-03f,
  -3.43430191e-01f, -2.51973420e-01f, -2.65313298e-01f, -1.50925554e-02f, 3.03974431e-02f, -7.91955516e-02f, -2.05612052e-02f, -3.12107820e-02f, -1.37026608e-01f, 8.17940757e-02f,
  6.18253723e-02f, -2.28463963e-01f, -8.10389593e-02f, 5.64516746e-02f, -4.54947166e-02f, 3.98499966e-02f, 3.21894661e-02f, 3.07512525e-02f, 3.84102091e-02f, 2.41021756e-02f,
  1.25240972e-02f, 2.15781435e-01f, -9.88599937e-03f, 5.56671694e-02f, -6.51844069e-02f, -7.24863857e-02f, 2.06903249e-01f, -3.88393179e-02f, 5.31422021e-03f, -2.52305474e-02f,
  1.89507809e-02f, -5.67274131e-02f, -5.58530316e-02f, -2.88203005e-02f, 2.63842065e-02f, 5.28266132e-02f, -3.95127200e-03f, 7.35769048e-03f, 2.87990831e-02f, -7.20763579e-02f,
  -6.36420697e-02f, -5.13136946e-02f, -1.51679607e-03f, -7.47671397e-03f, 3.68135571e-02f, -6.74775764e-02f, -6.15470558e-02f, -4.72898185e-02f, -1.06359562e-02f, -1.26812816e-01f,
  -4.68120612e-02f, -4.53622453e-02f, 5.25288051e-04f, -4.14750427e-02f, -2.73405593e-02f, -8.59341212e-03f, 1.65172957e-03f, -6.60383478e-02f, -4.55533974e-02f, 1.73992701e-02f,
  1.21029168e-02f, 5.19328564e-02f, -2.09458694e-02f, -4.89828060e-04f, -6.85836151e-02f, 3.38245369e-02f, -5.89715969e-03f, 2.36424860e-02f, 8.34180973e-03f, 7.02807382e-02f,
  1.82965305e-02f, -6.50463104e-02f, 2.92270388e-02f, 1.42450090e-02f, 6.40502498e-02f, -3.81457806e-02f, 5.24655357e-02f, -3.56811248e-02f, 2.37922054e-02f, -1.18181370e-02f,
  -8.78284592e-03f, 2.53657252e-02f, 6.76736818e-04f, -2.25377213e-02f, 3.42193767e-02f, -3.06502953e-02f, -3.40064685e-03f, -8.42267796e-02f, -1.49279116e-02f, -3.19183096e-02f,
  1.11797750e-01f, 1.27729520e-01f, 3.41325253e-02f, -3.92338969e-02f, -9.36189294e-03f, 3.36688720e-02f, -1.78244226e-02f, -1.09108925e-01f, 1.28027141e-01f, 3.11770234e-02f,
  -1.65579487e-02f, 3.84663008e-02f, 2.95926016e-02f, 2.15195436e-02f, -3.54984626e-02f, 2.54315417e-02f, 8.19663480e-02f, 9.15836841e-02f, 2.53481362e-02f, 3.52817029e-02f,
  3.12621929e-02f, 7.58160045e-03f, -4.95523959e-02f, 5.42628244e-02f, 1.00298248e-01f, 2.43163258e-02f, -1.21029746e-02f, -6.35660961e-02f, 5.89791089e-02f, 3.94276343e-02f,
  2.03697681e-02f, -1.55182272e-01f, 9.25785489e-03f, -2.55649596e-01f, -6.97746351e-02f, 1.01274364e-01f, 1.88247159e-01f, -9.07140598e-02f, -5.49576804e-02f, -8.26171488e-02f,
  1.73829317e-01f, -2.33887330e-01f, 1.97283864e-01f, -1.13773733e-01f, 1.19647779e-01f, 2.47817621e-01f, 2.47229561e-02f, 6.45415932e-02f, -4.31686379e-02f, 9.13129421e-04f,
  3.01504023e-02f, 1.19898058e-01f, 1.74908072e-01f, 2.47522574e-02f, 1.84929874e-02f, 1.52552780e-02f, -6.06012307e-02f, 3.50049324e-02f, -5.72398901e-02f, -1.36790816e-02f,
  1.35500580e-01f, 9.14162956e-03f, 1.49544794e-02f, -5.82917854e-02f, 1.18894026e-01f, 8.61470494e-03f, 7.32279420e-02f, 1.41010198e-04f, -3.56313474e-02f, 1.38204042e-02f,
  3.91782224e-02f, -1.11154661e-01f, -7.42656318e-03f, 1.02272099e-02f, -2.99856942e-02f, -3.82335484e-02f, -1.64446980e-02f, -1.38868522e-02f, -4.81813587e-02f, 2.50265319e-02f,
  -7.68618518e-03f, -4.46973741e-02f, 3.28686498e-02f, 9.57301445e-03f, 1.40881920e-02f, 2.14806683e-02f, 1.40881063e-02f, -5.60295880e-02f, -1.11362971e-02f, -6.01214021e-02f,
  5.98947667e-02f, -1.71597376e-02f, -9.98920389e-03f, -4.08946909e-02f, -3.32346819e-02f, 5.02870753e-02f, 2.81809121e-02f, 5.15740970e-03f, 1.41127147e-02f, 3.65019105e-02f,
  -6.73556998e-02f, -2.81053968e-02f, 3.15981098e-02f, 3.39819081e-02f, 8.61749128e-02f, 6.97235316e-02f, 3.32162194e-02f, -2.03824490e-02f, -2.15073712e-02f, 5.47227962e-03f,
  -5.59894070e-02f, 2.06323154e-02f, -2.12555211e-02f, 9.17452574e-02f, 2.77604256e-02f, -5.26556000e-03f, -9.83517542e-02f, 3.83653259e-03f, 5.44682443e-02f, 6.91906288e-02f,
  -7.37548470e-02f, -5.77785447e-02f, 1.64870881e-02f, -6.22009113e-03f, -1.09909019e-02f, -1.01238051e-02f, -2.10395977e-02f, 1.21705169e-02f, 8.47991183e-02f, 1.29724946e-02f,
  3.07895485e-02f, 5.98023981e-02f, -8.72427896e-02f, 6.11027470e-04f, -9.44037363e-03f, -3.25881951e-02f, 3.36259715e-02f, -6.66558072e-02f, 8.42364330e-04f, -1.46245454e-02f,
  6.48039654e-02f, 2.36466862e-02f, 3.48211043e-02f, 6.58969879e-02f, 3.74172116e-03f, 4.86278236e-02f, -3.46990004e-02f, -1.83107555e-02f, -1.00156572e-02f, -1.64108276e-02f,
  6.29115939e-01f, -5.19691482e-02f, 2.63960101e-02f, 4.98976260e-02f, -1.41759589e-01f, -1.03358485e-01f, 8.58126506e-02f, -9.16188136e-02f, 1.31685073e-02f, 1.27578378e-01f,
  1.28220722e-01f, 8.74015540e-02f, 1.11169629e-01f, 5.88809028e-02f, 1.44357160e-01f, 5.41630946e-02f, 9.04688761e-02f, 7.23485723e-02f, -5.11199161e-02f, 7.70985782e-02f,
  -4.07383405e-03f, -4.42668274e-02f, 9.25554633e-02f, -1.35267004e-01f, 2.05268469e-02f, -9.33824629e-02f, 4.94758934e-02f, -1.70634970e-01f, -9.32510197e-02f, -8.31329972e-02f,
  1.05877027e-01f, -2.08684951e-02f, 2.17692330e-02f, -2.04038937e-02f, 3.87501009e-02f, 1.31383501e-02f, -1.03356987e-02f, -7.37618506e-02f, 3.09149665e-03f, 4.23207022e-02f,
  8.38558972e-02f, -8.16828683e-02f, 4.68930118e-02f, -3.96310315e-02f, -2.99546076e-03f, -8.33740458e-02f, -7.13028461e-02f, -7.44113745e-03f, -4.53953855e-02f, 3.28781120e-02f,
  -1.76585279e-02f, 2.72226357e-03f, 9.41908546e-03f, -7.31383776e-03f, 6.24342216e-03f, -4.26028669e-02f, -3.44756222e-03f, -4.68812399e-02f, -8.20085965e-03f, -4.95823435e-02f,
  2.82771718e-02f, 4.10141237e-02f, -5.94516210e-02f, 4.13177684e-02f, -1.38414115e-01f, 5.95948584e-02f, 3.18831950e-02f, 3.46634388e-02f, -8.97073299e-02f, 1.69744194e-02f,
  1.67043991e-02f, -2.00219117e-02f, -7.09938072e-03f, 1.29032498e-02f, -2.17741411e-02f, 2.82194223e-02f, 3.11677577e-03f, 2.10394571e-03f, 9.46266726e-02f, 4.56536338e-02f,
  -3.58134019e-03f, 1.95925757e-02f, 2.85875853e-02f, -3.87589424e-03f, 3.90654281e-02f, -3.47441179e-03f, -1.78195760e-02f, -2.70090755e-02f, 2.62136031e-02f, 7.09184930e-02f,
  -7.65956417e-02f, -5.00437468e-02f, -3.09000965e-02f, -2.47635022e-02f, -1.26755023e-02f, 1.57603994e-02f, -3.00110946e-03f, 3.26328725e-02f, -5.18889055e-02f, -6.73582852e-02f,
  3.20279896e-02f, 6.55395612e-02f, 6.74063414e-02f, 2.39625275e-02f, -8.41555446e-02f, 5.38991056e-02f, 6.43470734e-02f, 1.76147707e-02f, -4.02877182e-02f, 4.39313576e-02f,
  6.46792650e-02f, 4.39150026e-03f, 3.55573068e-03f, -7.02189729e-02f, 1.39119197e-02f, 2.89518200e-02f, 2.43984666e-02f, 4.12377194e-02f, 2.64525004e-02f, 1.09492801e-01f,
  -6.02172554e-01f, 2.20648088e-02f, 2.90011428e-03f, -1.78734347e-01f, -7.17326403e-02f, 4.86977138e-02f, -1.12768888e-01f, 1.37099735e-02f, -1.88628167e-01f, 1.28762685e-02f,
  1.89597532e-02f, -6.30391687e-02f, -2.40191054e-02f, 1.01083685e-02f, 6.58834502e-02f, 6.60358220e-02f, -7.17915744e-02f, -5.92707423e-03f, 7.53671229e-02f, 1.86931361e-02f,
  1.08664762e-02f, 1.52678132e-01f, 5.10202162e-02f, 1.42582849e-01f, -1.03821410e-02f, -9.19826236e-03f, 5.05310223e-02f, 9.20156687e-02f, 4.49994616e-02f, 5.08705080e-02f,
  4.81229648e-02f, 6.46243021e-02f, -5.84497452e-02f, 3.11875176e-02f, 8.23079869e-02f, -8.04041550e-02f, 4.07072380e-02f, 8.06347933e-04f, -6.12591719e-03f, 3.04707384e-04f,
  -3.31621356e-02f, -1.54751865e-02f, 4.12451141e-02f, 4.12174538e-02f, 6.51684776e-03f, -1.75342318e-02f, -7.09491782e-03f, -1.31711243e-02f, -2.79751271e-02f, -4.35762629e-02f,
  -7.34323561e-02f, 8.82822275e-03f, 2.91816089e-02f, 2.07631271e-02f, -1.09239798e-02f, -4.56670037e-04f, -3.91932484e-03f, -1.32196313e-02f, 5.99980429e-02f, 8.20303857e-02f,
  7.51859918e-02f, -4.37643118e-02f, -3.00461277e-02f, -1.97395403e-02f, 4.30536969e-03f, 3.04114334e-02f, 1.27085708e-02f, 5.53388223e-02f, -6.66970462e-02f, -2.37696990e-02f,
  -5.37041500e-02f, -6.85343817e-02f, -1.17559703e-02f, -3.46378936e-03f, -6.38755932e-02f, -5.66885769e-02f, 7.35619338e-03f, 6.80180416e-02f, 2.49384088e-03f, -6.69705682e-03f,
  -2.68850159e-02f, 5.65710030e-02f, -9.06993542e-03f, 1.99520811e-02f, 4.48821485e-02f, -1.39448978e-02f, 4.61969264e-02f, 7.79365748e-03f, -1.73940174e-02f, 7.19859749e-02f,
  9.90213677e-02f, 2.57187158e-01f, 6.14178590e-02f, -5.98144792e-02f, -2.96012294e-02f, 7.97421020e-03f, -3.79804359e-03f, 6.80860505e-02f, 4.36766222e-02f, -3.52713801e-02f,
  3.96380015e-02f, -4.90910523e-02f, 3.34631349e-03f, 2.73695458e-02f, 6.35836199e-02f, 2.89963949e-02f, -9.40568221e-04f, 4.49546315e-02f, 1.03830677e-02f, 5.04191630e-02f,
  4.62320168e-03f, -3.77580784e-02f, 4.74976264e-02f, 1.50568886e-02f, -1.43487994e-02f, -3.48258927e-03f, 5.05004451e-03f, 4.24714833e-02f, 2.98829470e-02f, 2.61344891e-02f,
  3.88216764e-01f, -2.64311671e-01f, 2.09131464e-01f, -2.23576754e-01f, 1.01065747e-01f, 2.33882330e-02f, 1.52709708e-01f, -1.47097111e-01f, 3.63283940e-02f, -2.51985610e-01f,
  -2.35995837e-02f, 5.45875914e-02f, 3.05644255e-02f, -1.98436722e-01f, 3.08973670e-01f, 1.96238719e-02f, -6.80368617e-02f, -1.40125811e-01f, 8.66129696e-02f, 2.59727575e-02f,
  1.07351430e-01f, -6.77818954e-02f, 7.37055242e-02f, -4.24650647e-02f, 1.01461783e-02f, -2.03010868e-02f, 7.61691928e-02f, 8.25985819e-02f, -6.97102696e-02f, -8.89089629e-02f,
  -2.01013125e-02f, -1.82227880e-01f, 6.43598884e-02f, 7.66422153e-02f, 3.53580378e-02f, -4.82889935e-02f, 7.66225830e-02f, 5.66021241e-02f, -4.86228839e-02f, -5.22963852e-02f,
  4.38842997e-02f, -1.39518129e-02f, -3.16275433e-02f, 6.34171888e-02f, 2.37129107e-02f, -5.55906631e-02f, -4.43454236e-02f, -4.28741090e-02f, -3.53630483e-02f, 7.57586444e-03f,
  -5.33994175e-02f, 3.62404669e-03f, 6.91976456e-04f, 1.60158705e-02f, 3.01692039e-02f, -8.95804539e-02f, -3.08952406e-02f, 7.77029395e-02f, -1.21539403e-02f, -2.21718010e-02f,
  9.34553295e-02f, 9.31907594e-02f, -4.68706787e-02f, -2.79439054e-03f, 2.15531401e-02f, -6.81567416e-02f, -8.24024528e-03f, 3.49270850e-02f, 1.30402157e-02f, 5.18803149e-02f,
  5.94335496e-02f, -2.17175391e-02f, 1.75156090e-02f, -7.99120683e-03f, -2.47324593e-02f, -5.87540381e-02f, 1.11141331e-01f, -2.14828178e-02f, 6.31508604e-03f, 1.23191178e-02f,
  -2.00197436e-02f, 6.16998412e-02f, -8.19606334e-02f, 5.36334934e-03f, -5.37903123e-02f, 8.57885852e-02f, -4.19747494e-02f, -2.33541448e-02f, -4.77418862e-02f, 5.20997532e-02f,
  -1.10428303e-01f, 4.53362949e-02f, -7.46685592e-03f, -4.07194160e-02f, 3.13446647e-03f, 2.81095840e-02f, 3.75759453e-02f, -1.38101876e-02f, 4.73286211e-03f, -1.33907087e-02f,
  -9.99528989e-02f, 2.38789357e-02f, 5.55009842e-02f, 2.74006333e-02f, 3.17747034e-02f, -6.68153465e-02f, -1.65675394e-02f, 2.76461951e-02f, 5.44418693e-02f, -5.48206642e-03f,
  -2.06570383e-02f, 5.80447130e-02f, 4.45257872e-02f, -2.16650106e-02f, 3.71160805e-02f, 4.96963486e-02f, 4.31434363e-02f, 1.34908529e-02f, -1.01932446e-02f, 5.43869995e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.41635996e-01f, 1.24118989e-02f, -3.30731630e-01f, -1.00574404e-01f, -2.36576244e-01f, -4.33050931e-01f, -3.06633443e-01f, -1.77675083e-01f, 5.07064834e-02f, 1.45856217e-01f,
  -5.13105765e-02f, -1.16604701e-01f, 1.38532147e-01f, 5.78803383e-02f, -1.54980779e-01f, 3.61967057e-01f, -8.93823355e-02f, -7.51720369e-02f, 6.12538122e-02f, -1.10594086e-01f,
  -5.51510416e-02f, 2.47258265e-02f, 4.12423648e-02f, 4.38410323e-03f, -2.08790898e-01f, -4.93484735e-02f, 8.16729218e-02f, -1.67080611e-01f, -1.28762349e-01f, -1.48888797e-01f,
  -4.76260521e-02f, -1.33200720e-01f, -5.82068674e-02f, 1.48938205e-02f, -1.46223754e-01f, -7.88586289e-02f, -5.78925349e-02f, -2.16802396e-03f, 2.03358638e-03f, -6.70498163e-02f,
  -7.86853023e-04f, -7.95113575e-03f, -1.57929957e-02f, 5.25323302e-02f, -3.77696194e-02f, -2.46137735e-02f, -4.51558195e-02f, -2.82865978e-04f, -2.78757382e-02f, -1.20859565e-02f,
  -5.12693934e-02f, 1.42260268e-02f, 2.65068584e-03f, 1.42152950e-01f, -4.46639955e-02f, -2.96039917e-02f, 9.85626802e-02f, -6.78071007e-03f, -1.14373140e-01f, -7.61595145e-02f,
  -7.63576329e-02f, 4.18154337e-02f, -2.84156911e-02f, -1.84902698e-02f, -1.20188855e-02f, -8.95505864e-03f, -2.28990279e-02f, -2.09959373e-02f, 2.86031626e-02f, 4.95602489e-02f,
  1.32133607e-02f, -5.45281656e-02f, -5.73407523e-02f, 4.00041901e-02f, -1.23491902e-02f, -6.04700763e-03f, 6.70817941e-02f, -1.26998678e-01f, -1.02397450e-03f, -4.21058349e-02f,
  2.73703262e-02f, -7.21901730e-02f, 2.90312078e-02f, 6.60110563e-02f, -7.40741715e-02f, 6.68182820e-02f, 4.21001911e-02f, 7.05938339e-02f, -4.09214012e-02f, -8.93272310e-02f,
  -2.54509717e-01f, -4.04279172e-01f, -2.69936235e-03f, -4.26369756e-02f, 6.48717284e-02f, -1.04367761e-02f, 7.31181726e-02f, -7.08996281e-02f, -9.00317058e-02f, -5.45048751e-02f,
  -4.71113212e-02f, 2.77060680e-02f, -7.55093768e-02f, 1.54014770e-02f, 4.02354896e-02f, -3.01833618e-02f, -3.90640274e-03f, 3.06920061e-04f, -6.13790331e-03f, -1.26946315e-01f,
  -8.63781646e-02f, 9.11112782e-03f, 2.79963873e-02f, -7.84033909e-03f, 8.07394609e-02f, -1.29057588e-02f, -1.16250992e-01f, 2.98462063e-02f, -8.50051343e-02f, -3.71105298e-02f,
  3.19380671e-01f, -1.07122406e-01f, 9.08560380e-02f, 2.22106948e-01f, 2.56752431e-01f, 1.14894755e-01f, 1.39551118e-01f, 1.86344266e-01f, 5.14918089e-01f, -1.42800272e-01f,
  -7.10932119e-03f, -2.23684475e-01f, -4.92911264e-02f, -5.07203639e-02f, -5.59658408e-02f, -4.14877525e-03f, 6.80012703e-02f, -4.94525321e-02f, 2.93455303e-01f, 1.00955386e-02f,
  2.67628282e-01f, 1.33680413e-02f, -3.07472926e-02f, -1.13384254e-01f, 7.44363293e-02f, 1.93833672e-02f, -1.90574810e-01f, 9.41858813e-02f, -2.12754413e-01f, 5.06261480e-04f,
  7.79603943e-02f, 1.28492743e-01f, -2.55493969e-02f, -2.43681925e-03f, 1.12905972e-01f, -2.09597927e-02f, -6.13722280e-02f, -1.05572835e-01f, 6.34666830e-02f, -7.46773109e-02f,
  -3.68902795e-02f, -3.71015966e-02f, -8.06806982e-03f, 5.33221802e-03f, 7.42104948e-02f, 5.75062912e-03f, 4.71939519e-02f, 5.16217947e-02f, -4.66082320e-02f, -3.01373396e-02f,
  -3.97301745e-03f, 4.78733778e-02f, 1.03471979e-01f, -6.04766831e-02f, -6.08343706e-02f, 8.69433060e-02f, -1.37968985e-02f, -2.25373656e-02f, -7.51009863e-03f, 4.41581272e-02f,
  -1.02467798e-02f, -5.39544690e-03f, -3.63621712e-02f, -5.03934473e-02f, 1.26573481e-02f, 3.47552523e-02f, -2.16087122e-02f, 3.39092724e-02f, 6.33054078e-02f, -2.51215585e-02f,
  -8.86000022e-02f, 4.11054539e-03f, 3.95015441e-02f, 1.91161502e-02f, 3.66358869e-02f, -5.99464476e-02f, 9.54200607e-03f, -3.52214016e-02f, 5.73471002e-02f, -6.19368674e-03f,
  -4.77553718e-02f, -8.53600800e-02f, 7.98602309e-03f, -4.05520760e-02f, 5.55213802e-02f, 2.46162321e-02f, 1.37045549e-03f, -1.59266759e-02f, 5.66595346e-02f, -2.72493791e-02f,
  5.23635857e-02f, 4.07456569e-02f, 6.87667355e-02f, -4.39133868e-03f, 3.59582976e-02f, -4.79323529e-02f, 1.57178603e-02f, -6.45172084e-03f, 1.50510162e-01f, -4.01773527e-02f,
  -7.26627856e-02f, 1.78184093e-03f, -4.50555533e-02f, 7.48110516e-03f, -9.61686485e-03f, 3.16864066e-02f, 5.93648665e-02f, 3.78629938e-02f, 1.21182315e-02f, -1.44909723e-02f,
  -8.86462480e-02f, 1.78678036e-02f, 1.07314391e-02f, 4.72287880e-03f, 1.11496327e-02f, -2.04688590e-02f, -2.57081166e-02f, -3.02016307e-02f, -3.96159803e-03f, 8.45008045e-02f,
  5.89596108e-02f, -3.31335634e-01f, -1.03305332e-01f, -1.17223985e-01f, 5.54942489e-02f, -3.52667034e-01f, -2.16425195e-01f, -2.15480283e-01f, 7.06721246e-02f, -1.78503841e-01f,
  -3.72082666e-02f, 1.53856546e-01f, 1.76332533e-01f, -2.82442600e-01f, 2.80481249e-01f, 1.28587425e-01f, -1.95573077e-01f, -1.44136727e-01f, -3.14155556e-02f, -3.45181406e-01f,
  -4.78692353e-02f, -2.23843277e-01f, -5.69632393e-04f, -2.73583055e-01f, -3.20123434e-01f, 4.83649746e-02f, 1.81308001e-01f, -6.90877112e-03f, -1.78599760e-01f, 1.02567576e-01f,
  -1.03776634e-01f, 7.51524419e-02f, -7.78360963e-02f, 2.84168869e-02f, -8.09814259e-02f, -3.14092897e-02f, -6.28377646e-02f, 1.85831577e-01f, 4.94838469e-02f, 5.57864122e-02f,
  -1.51098240e-02f, 6.16449378e-02f, -2.45106053e-02f, -3.05597298e-02f, -4.93870080e-02f, 6.60242066e-02f, 5.40935062e-02f, -2.23206133e-02f, 4.73344587e-02f, 2.02080123e-02f,
  -4.71969098e-02f, 5.14757484e-02f, -1.27657443e-01f, -1.07709607e-02f, 3.27791683e-02f, 2.07528286e-02f, 4.86688204e-02f, 7.78545961e-02f, 9.54644196e-03f, 1.47841554e-02f,
  -9.66458097e-02f, -6.76288679e-02f, -3.29906009e-02f, -1.17068188e-02f, 8.61407549e-04f, -8.30382779e-02f, 1.67035814e-02f, 1.01374332e-02f, 3.95694673e-02f, 2.06058305e-02f,
  -2.03097123e-03f, 4.77547124e-02f, 3.31407115e-02f, -7.09436834e-02f, -9.76609215e-02f, 4.20099311e-02f, -3.47262733e-02f, 7.87631422e-02f, -1.53538644e-01f, -1.44991735e-02f,
  1.90483388e-02f, 1.26774115e-02f, -5.12015074e-02f, -5.41599886e-03f, -3.33641917e-02f, 1.00463510e-01f, 6.55196160e-02f, -2.41116602e-02f, 2.29803957e-02f, -2.81670503e-03f,
  -2.07434576e-02f, -1.27126137e-02f, 4.53328639e-02f, 2.26157065e-02f, -5.11082076e-02f, 3.98700911e-04f, -1.48724109e-01f, -1.14121519e-01f, -2.95888670e-02f, -6.40157238e-02f,
  -1.08229943e-01f, 3.94528359e-02f, 1.57472752e-02f, -2.75889859e-02f, -3.50058302e-02f, -4.98273559e-02f, -3.31271142e-02f, 9.18589905e-02f, -2.47183237e-02f, -7.21844360e-02f,
  3.02689592e-03f, -3.62285785e-02f, 1.09894378e-02f, 2.24457169e-03f, -1.05326705e-01f, -4.05825116e-02f, 1.71206892e-02f, -3.07269320e-02f, 4.39672964e-03f, -2.85705812e-02f,
  -5.15505433e-01f, -9.43279713e-02f, -1.42873079e-01f, -3.49062294e-01f, 8.65859613e-02f, 8.72963853e-03f, -6.21795952e-02f, 7.38407671e-02f, -8.44809264e-02f, 9.87835154e-02f,
  1.15301564e-01f, -2.79047281e-01f, 8.72453675e-02f, -4.02075857e-01f, -3.80467117e-01f, -1.75828010e-01f, -3.78360212e-01f, -1.37461066e-01f, -2.00331137e-01f, -3.83143984e-02f,
  -7.68873617e-02f, -1.24362953e-01f, -3.18858683e-01f, 1.35582447e-01f, -1.09306276e-01f, 1.64478585e-01f, 1.52980238e-01f, 1.06219351e-01f, -1.19791292e-01f, -9.83615667e-02f,
  -7.69283921e-02f, 2.21362617e-02f, 8.06910619e-02f, 4.33431705e-03f, 5.41238077e-02f, 4.89501841e-02f, 5.49193807e-02f, -2.43453216e-02f, -1.82834491e-02f, -4.57533374e-02f,
  4.58392911e-02f, -5.05179167e-02f, -2.49662492e-02f, 1.00765238e-03f, -4.07452770e-02f, -1.35586197e-02f, -9.15091410e-02f, -1.82814766e-02f, -7.12189749e-02f, -2.39888430e-02f,
  -1.24487624e-01f, -2.62498409e-02f, 1.02727242e-01f, -1.15848519e-02f, -8.05870723e-03f, -7.16450671e-03f, -1.48691507e-02f, 2.63803080e-02f, -6.21844493e-02f, -3.30380686e-02f,
  1.21735912e-02f, 5.33990487e-02f, -5.12626581e-02f, -2.13845409e-02f, -9.19965655e-02f, 6.70789629e-02f, -3.98080908e-02f, 7.03909528e-03f, 1.00169210e-02f, 2.63376981e-02f,
  3.29607166e-02f, -1.15825748e-02f, 5.07538840e-02f, 1.59818958e-02f, 6.52857572e-02f, -1.72834762e-03f, 3.41650695e-02f, -9.83803160e-03f, -3.77036892e-02f, -1.44240167e-02f,
  9.42444429e-03f, -4.43243124e-02f, 7.55945453e-03f, 5.11174724e-02f, 9.59976669e-03f, 6.52443757e-03f, -5.19736819e-02f, -2.46521377e-04f, 3.26027088e-02f, 2.28215754e-02f,
  1.97753549e-01f, 1.15021765e-01f, -5.33729829e-02f, 2.76586190e-02f, 2.15420891e-02f, -4.33755480e-02f, -4.54853624e-02f, -5.23183867e-03f, 2.79465299e-02f, 6.28513545e-02f,
  3.66911739e-02f, 5.50859682e-02f, 4.27757204e-02f, -5.28163575e-02f, -4.97784428e-02f, 5.70887588e-02f, 4.76908386e-02f, 1.79972164e-02f, -4.51162495e-02f, -8.12230725e-03f,
  2.55559515e-02f, 7.25035444e-02f, -6.44949079e-02f, 2.99041718e-02f, -4.42426950e-02f, 9.94843543e-02f, 6.92680702e-02f, 1.27701154e-02f, 9.01706237e-03f, 1.16684148e-02f,
  2.17270732e-01f, -4.53189403e-01f, -2.07572475e-01f, 2.55082007e-02f, 1.62182853e-01f, 2.87606120e-01f, 3.35571803e-02f, -9.31804329e-02f, -2.26994678e-01f, -1.59964234e-01f,
  7.60442615e-02f, -9.92883667e-02f, -3.63984644e-01f, 1.84126243e-01f, 2.39006028e-01f, -4.38380390e-01f, 4.97538820e-02f, 6.58710599e-02f, -1.81935176e-01f, -7.65913352e-02f,
  1.80354081e-02f, 3.12795579e-01f, -3.19326892e-02f, 1.39476985e-01f, 1.04867503e-01f, -1.24541290e-01f, 1.11979544e-02f, -1.75919086e-02f, 2.55334944e-01f, 2.98940241e-01f,
  7.99676105e-02f, -2.71741282e-02f, 2.01782417e-02f, 5.48579246e-02f, -3.52116860e-02f, 8.75596330e-02f, 1.10072298e-02f, 7.54285902e-02f, -4.75627594e-02f, -1.25076011e-01f,
  1.75670553e-02f, 2.19542580e-03f, 8.86490047e-02f, 1.04036294e-02f, 4.11865041e-02f, -1.77207179e-02f, -2.33556312e-02f, -5.74963130e-02f, -1.11026511e-01f, -3.13561894e-02f,
  -1.93440273e-01f, -1.66755281e-02f, -4.03960906e-02f, 5.54421777e-03f, -9.45107192e-02f, -1.28836362e-02f, -3.14626796e-03f, -5.70583828e-02f, -2.10854709e-02f, -2.12641573e-03f,
  3.66782621e-02f, -3.82184424e-02f, -2.63818260e-02f, 6.68573380e-03f, -1.64770277e-03f, 8.49934295e-02f, -2.10160445e-02f, -3.53964530e-02f, -4.29102108e-02f, -7.89382122e-03f,
  -8.75587687e-02f, 2.71931682e-02f, -3.04707736e-02f, 5.22155687e-02f, 5.76512851e-02f, -1.00560999e-02f, 8.55722558e-03f, 4.23212051e-02f, -8.17496926e-02f, -3.99347916e-02f,
  1.20872736e-03f, -4.81897444e-02f, 3.21015343e-02f, 5.95475826e-03f, -3.41229141e-02f, 4.55100276e-02f, -3.00009572e-03f, 1.37289762e-02f, 8.98823317e-04f, 1.55908046e-02f,
  -5.87011650e-02f, -2.14092433e-01f, -3.85250188e-02f, 6.52255863e-02f, 6.51934976e-03f, 9.14314482e-03f, -1.24882273e-02f, 9.34950076e-03f, -2.87675541e-02f, -1.67722087e-02f,
  8.50987583e-02f, 2.07331846e-03f, -1.56813543e-02f, 4.09726724e-02f, 8.76067504e-02f, 1.18957954e-02f, -3.67596075e-02f, 1.15611181e-01f, 7.92027116e-02f, -2.38195900e-02f,
  3.99916470e-02f, -5.84609956e-02f, 3.25995986e-03f, -7.54697323e-02f, 2.91605815e-02f, 4.41543907e-02f, -5.65169714e-02f, -1.00361621e-02f, 2.78578280e-03f, -8.59979168e-02f,
  3.58166933e-01f, -3.72671992e-01f, -8.38810578e-02f, -5.00507727e-02f, -3.47168520e-02f, -2.15771511e-01f, 2.15776712e-02f, -2.07488850e-01f, -1.53849453e-01f, -4.02142614e-01f,
  5.78190982e-02f, 6.02008849e-02f, 3.04457545e-02f, -2.89440453e-01f, 3.09281856e-01f, 1.03199847e-01f, -1.83140635e-01f, -1.57365520e-02f, 6.88635856e-02f, -1.72100231e-01f,
  -7.35917240e-02f, -1.04757711e-01f, -8.23352262e-02f, -2.38340512e-01f, -1.11964546e-01f, -6.00554533e-02f, 1.09949946e-01f, 1.00017078e-01f, -1.72362894e-01f, 6.67616203e-02f,
  1.75845370e-01f, 6.07635900e-02f, -3.38923559e-02f, -3.62140909e-02f, -4.27810512e-02f, -7.49082789e-02f, 9.60247517e-02f, 9.94926542e-02f, 3.97727787e-02f, -6.16242960e-02f,
  5.30964248e-02f, 8.49225298e-02f, -6.89030364e-02f, -3.12501155e-02f, -1.14354335e-01f, -5.92070520e-02f, 6.98013464e-03f, 8.16261768e-02f, -7.90394023e-02f, 3.81798185e-02f,
  -2.45734528e-02f, -2.49875337e-02f, 1.34362718e-02f, -5.19098341e-02f, 3.13872248e-02f, -6.18324280e-02f, 2.65472643e-02f, 9.72902998e-02f, 4.77183657e-03f, -1.78637449e-02f,
  -3.10502201e-02f, -9.13040563e-02f, 1.41976168e-02f, -4.89357151e-02f, -1.62786767e-02f, -3.17870639e-02f, 4.27974481e-03f, 3.78123634e-02f, 8.11219588e-02f, -8.46908707e-03f,
  2.31708363e-02f, -2.37370059e-02f, -5.60009666e-02f, 4.12586667e-02f, -5.19874506e-03f, -5.39602451e-02f, 5.14944270e-02f, 1.63939670e-02f, -2.82854550e-02f, 7.00617656e-02f,
  4.94058169e-02f, -5.07963859e-02f, -8.22526142e-02f, -7.73138739e-03f, 1.02367671e-02f, -7.88999125e-02f, -9.12007317e-03f, -6.49822652e-02f, -7.64594227e-03f, 1.24169113e-02f,
  1.06710702e-01f, -1.83723614e-01f, 1.95315164e-02f, -1.46240024e-02f, 2.18519196e-02f, -4.23973389e-02f, 3.67523134e-02f, 6.58315513e-03f, -1.14932032e-02f, 6.04387932e-02f,
  -4.21961658e-02f, 3.11377142e-02f, -6.74308762e-02f, -9.37862415e-03f, -2.26694513e-02f, -7.05085769e-02f, 1.33144511e-02f, -2.37691626e-02f, -7.44322985e-02f, -2.70312577e-02f,
  1.46863814e-02f, 3.19982730e-02f, 6.10743351e-02f, -4.09926809e-02f, 1.95118319e-02f, 6.40387610e-02f, -3.12209427e-02f, 9.70259961e-03f, 2.66436953e-02f, 7.21350033e-03f,
  -5.70088446e-01f, 1.08799383e-01f, -1.79864585e-01f, -2.03589335e-01f, 2.42173057e-02f, -2.53671408e-01f, -1.83302104e-01f, -7.82231335e-04f, -1.45709515e-01f, -1.80971935e-01f,
  -1.59127250e-01f, 7.27360994e-02f, 4.35510129e-02f, -7.22085163e-02f, -1.07247420e-01f, 9.71785560e-02f, -3.29015672e-01f, -1.32425025e-01f, 1.30981669e-01f, -1.68028131e-01f,
  -1.58502348e-02f, -9.60131437e-02f, 1.36763193e-02f, 1.68128341e-01f, -7.41924047e-02f, -1.25750914e-01f, -2.81010959e-02f, 4.23062369e-02f, -7.44693354e-02f, 8.14517513e-02f,
  -3.60597968e-01f, -2.90461242e-01f, -1.19744375e-01f, -4.54647690e-02f, -1.61437958e-01f, -5.70159331e-02f, -6.73558637e-02f, -1.06283482e-02f, 1.87450706e-03f, 2.19028406e-02f,
  4.06129919e-02f, 4.28391322e-02f, -9.05422121e-03f, -2.65683373e-03f, -4.50456589e-02f, -3.88485752e-02f, 4.41509783e-02f, -2.52081454e-02f, 2.88388934e-02f, 1.17609113e-01f,
  7.92517811e-02f, -3.50612253e-02f, -1.29215375e-01f, -7.29402602e-02f, -5.29094860e-02f, -7.00648129e-02f, -8.16460401e-02f, 2.11464986e-02f, -4.97455299e-02f, -1.01081565e-01f,
  9.32586417e-02f, -5.57655410e-04f, 5.76700345e-02f, 7.08926395e-02f, -2.69104727e-02f, 5.60530126e-02f, 1.92627572e-02f, 1.42380698e-02f, -1.09905116e-01f, 3.29398960e-02f,
  -3.82300429e-02f, 7.23095611e-02f, -7.19088987e-02f, -6.17941990e-02f, -1.70100667e-02f, 1.82890221e-02f, -2.96806009e-03f, 1.60327822e-03f, 5.28342500e-02f, 2.57466305e-02f,
  -1.69773549e-02f, 3.92760197e-03f, 4.26498465e-02f, -8.39807764e-02f, 3.07988133e-02f, 3.51035371e-02f, -1.00834286e-02f, 2.21869182e-02f, -2.10805535e-02f, -1.03791608e-02f,
  -4.12669778e-01f, -4.39967632e-01f, 4.80569564e-02f, -1.06976636e-01f, 6.13908954e-02f, -2.27198787e-02f, -3.27354185e-02f, -3.97170186e-02f, -1.10594012e-01f, -1.23912422e-02f,
  -8.09157267e-02f, -6.55793548e-02f, -7.81913102e-02f, 2.00747605e-02f, -3.90124768e-02f, -3.22751515e-02f, -5.61135449e-02f, -7.66901895e-02f, -3.64490300e-02f, 4.60451543e-02f,
  -3.83724319e-03f, 2.29600891e-02f, 4.58265878e-02f, -2.02020612e-02f, 5.69244323e-04f, -9.40403342e-03f, 3.22516798e-03f, -2.14347504e-02f, -9.01274674e-04f, 7.08179027e-02f,
  2.33358126e-02f, -1.11666068e-01f, -3.23566608e-02f, 3.25495958e-01f, -7.69787133e-02f, -4.02727574e-01f, -2.80402422e-01f, 1.87131241e-01f, -1.69757977e-01f, -1.42383963e-01f,
  1.10961415e-01f, -4.54347767e-02f, -1.17381804e-01f, 2.30951294e-01f, 3.20585608e-01f, -6.08368516e-02f, 1.84489861e-01f, -5.25348112e-02f, -1.16417333e-02f, 1.37025803e-01f,
  1.90711781e-01f, 2.25336745e-01f, 2.91851640e-01f, 2.75929749e-01f, -5.25844321e-02f, 1.83155954e-01f, 3.45448673e-01f, -4.59784344e-02f, 2.40290657e-01f, 6.22650869e-02f,
  -5.74916266e-02f, -7.22629800e-02f, 7.53674685e-05f, -4.32320833e-02f, 7.99619034e-02f, -1.12546854e-01f, -2.60468274e-02f, 5.05719222e-02f, 1.00005075e-01f, 3.97679657e-02f,
  -1.30503058e-01f, 7.33278915e-02f, 1.56369489e-02f, -4.40065041e-02f, -1.91214390e-03f, 4.73736115e-02f, 1.93566587e-02f, -1.13958232e-01f, -2.30123140e-02f, 4.93209735e-02f,
  -5.94802462e-02f, 1.43747777e-02f, -1.19505292e-02f, 4.91606593e-02f, 1.74256060e-02f, 8.19584578e-02f, -4.29033749e-02f, -1.87753025e-03f, -2.16445643e-02f, 9.24066603e-02f,
  7.18931900e-04f, -8.26503187e-02f, -1.11739196e-01f, -2.41626836e-02f, -2.15164870e-02f, -7.31451949e-03f, -1.81819405e-02f, 4.86624567e-03f, -3.01780924e-03f, -5.23369387e-03f,
  2.08360124e-02f, 1.08986059e-02f, -1.51875345e-02f, -4.10269201e-02f, -2.68406309e-02f, -4.35425229e-02f, -3.10120564e-02f, -5.20175126e-05f, 1.34209739e-02f, 4.99789454e-02f,
  -7.77976438e-02f, 7.42498711e-02f, -8.57889932e-03f, -1.98633298e-02f, 3.17210704e-02f, 2.57415548e-02f, 4.85282466e-02f, 2.46480349e-02f, -1.57268606e-02f, -2.17746850e-02f,
  3.21907178e-02f, 1.86645254e-01f, -4.79807844e-03f, -3.09385918e-02f, -3.14369723e-02f, -5.58589958e-02f, -5.83046004e-02f, 7.07091624e-03f, 6.40559196e-02f, 1.78888980e-02f,
  8.93400013e-02f, 3.35182034e-04f, -5.82336225e-02f, 9.64754671e-02f, 6.55675083e-02f, -4.35365438e-02f, 3.18527147e-02f, -2.31487700e-03f, 6.27423748e-02f, 1.13805138e-01f,
  2.23081559e-02f, -8.14122206e-04f, 4.77641746e-02f, -2.68490091e-02f, 6.08205609e-02f, -1.09279811e-01f, 1.01005845e-01f, -9.79307294e-03f, 4.90881912e-02f, 4.87221107e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  8.46560951e-03f, 1.54677778e-01f, -9.49154422e-02f, 1.73652619e-01f, 2.81557143e-02f, 2.68075988e-02f, 1.71476956e-02f, -2.93216035e-02f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.34811729e-01f, 2.18302547e-03f, -5.18324263e-02f, 1.09547071e-01f, -1.10251732e-01f, -7.80512840e-02f, -8.25033057e-03f, 1.96828306e-01f, 1.05822156e-03f, -1.36736855e-01f,
  -1.39640927e-01f, -3.25981885e-01f, 3.16261560e-01f, -3.34751420e-02f, 8.14863760e-03f, -2.40852192e-01f, -2.22077221e-01f, 9.69172791e-02f, 5.36456034e-02f, -3.68608326e-01f,
  2.42978603e-01f, 2.17131838e-01f, -1.50126711e-01f, -1.51223792e-02f, 2.81149056e-02f, 1.93744451e-01f, 2.38139808e-01f, -2.36846805e-01f, -1.06911808e-01f, 6.93922415e-02f,
  1.53513893e-01f, -3.19916159e-01f, 1.73470508e-02f, 3.86071689e-02f, -1.49904126e-02f, 7.39426306e-03f, 2.64879409e-02f, -3.42798270e-02f, -6.64606765e-02f, 3.41829062e-02f,
  1.09315343e-01f, -1.15466945e-01f, -1.15367763e-01f, -6.00126050e-02f, 4.26731668e-02f, -2.74918348e-01f, 6.60014823e-02f, 1.68441415e-01f, 9.09558013e-02f, -1.04189813e-01f,
  6.84241951e-02f, 3.15772206e-01f, -5.60429227e-03f, -1.48301005e-01f, 1.05729133e-01f, 4.28431928e-02f, -5.08650020e-02f, -1.02220230e-01f, -3.65599059e-02f, 2.92488784e-01f,
  2.85325229e-01f, 4.30366434e-02f, 2.16418859e-02f, -9.41930860e-02f, 8.18798877e-03f, -2.01603368e-01f, 1.35308066e-02f, 6.23381622e-02f, -4.46424842e-01f, -1.21206418e-01f,
  -1.22213788e-01f, -7.40271760e-03f, 1.48667246e-01f, -1.98543686e-02f, -2.57675182e-02f, 2.98018046e-02f, -2.15510167e-02f, -2.97282696e-01f, 2.39024743e-01f, 2.66828179e-01f,
  3.11057717e-01f, -1.11891255e-01f, -2.29017869e-01f, 2.98172742e-01f, 7.21089393e-02f, 1.05141960e-01f, 6.37607602e-03f, -1.34210154e-01f, -1.55712277e-01f, -2.18623906e-01f,
  -1.70955598e-01f, 6.68134168e-02f, 2.41518945e-01f, 5.31659909e-02f, -2.03703418e-01f, 3.48678410e-01f, -1.20732293e-01f, 6.48742244e-02f, -2.06636637e-01f, 2.07027525e-01f,
  1.29564896e-01f, 2.09890217e-01f, 1.78977430e-01f, -1.96620226e-01f, 2.29455475e-02f, -5.69479316e-02f, -1.04242802e-01f, 3.83131772e-01f, -1.59111559e-01f, 2.80388594e-01f,
  2.95842499e-01f, 3.68831195e-02f, -2.51685739e-01f, -4.68097366e-02f, -8.93053710e-02f, -2.57508487e-01f, -2.99003065e-01f, -1.40076578e-01f, 2.09753916e-01f, 1.27329096e-01f,
  -2.28853732e-01f, 1.38113782e-01f, -7.07751364e-02f, 1.81110591e-01f, -3.71366382e-01f, -4.78614777e-01f, 1.71236336e-01f, 1.11956649e-01f, 2.01495916e-01f, -7.31961876e-02f,
  1.84988201e-01f, -1.23952538e-01f, 2.92008221e-01f, -1.94073290e-01f, 2.62394790e-02f, 1.85340345e-01f, -7.61850998e-02f, -3.30751777e-01f, -5.13087139e-02f, -7.19638392e-02f,
  9.98867452e-02f, 1.61031783e-01f, -1.47491187e-01f, 9.61312205e-02f, -2.24059463e-01f, -2.69651599e-02f, 8.77870545e-02f, -1.67843044e-01f, -5.84157370e-02f, -4.38993163e-02f,
  1.31578445e-01f, 3.38663310e-02f, 1.01547293e-01f, 2.79628187e-01f, 1.81414217e-01f, 1.12585556e-02f, -2.43666708e-01f, 2.79641058e-02f, 1.92340776e-01f, -1.28731638e-01f,
  1.04323588e-01f, 2.05371063e-02f, 7.57439062e-02f, -1.83087423e-01f, -3.38073894e-02f, -1.41392872e-01f, -1.64257184e-01f, 1.53056509e-03f, 1.01966999e-01f, 9.13294405e-02f,
  -1.04224406e-01f, -9.11250561e-02f, 1.75032929e-01f, -6.96861222e-02f, -3.09046298e-01f, -1.77098066e-01f, 2.78843075e-01f, 3.57452892e-02f, 3.90315391e-02f, 9.41350609e-02f,
  1.61339760e-01f, 2.38333851e-01f, -1.68462038e-01f, 4.18383703e-02f, 1.23182021e-01f, 2.06479996e-01f, 7.97830597e-02f, -1.27536997e-01f, 2.46780947e-01f, 4.19999868e-01f,
  -1.61847785e-01f, 3.79520208e-02f, -8.95881429e-02f, -9.30189341e-02f, -1.28843576e-01f, 2.45802663e-02f, -2.99553555e-02f, 6.34162501e-02f, 2.80137241e-01f, 7.88929760e-02f,
  -1.25250235e-01f, 1.11662582e-01f, 1.63247108e-01f, 9.97443050e-02f, -5.43661267e-02f, -4.22146805e-02f, 5.19389175e-02f, -2.84123778e-01f, 3.01467150e-01f, 7.71565363e-02f,
  -2.73631990e-01f, 1.85855687e-01f, 1.13362439e-01f, -1.07115544e-01f, 2.90712446e-01f, -1.55280903e-01f, -8.35117400e-02f, -1.42977074e-01f, -2.15618804e-01f, 4.03762132e-01f,
  -1.54171765e-01f, -5.03408909e-02f, -8.14689472e-02f, -3.88572723e-01f, 3.16310436e-01f, -1.87284023e-01f, 8.02311897e-02f, 8.03129449e-02f, -1.24860518e-02f, -2.37993374e-01f,
  1.51640519e-01f, 2.72036105e-01f, -1.88986689e-01f, -1.37575448e-01f, 1.01914629e-01f, -3.02514285e-01f, 2.21481413e-01f, 2.17353374e-01f, -2.99150795e-01f, -3.59505743e-01f,
  2.10621104e-01f, 3.13841283e-01f, 2.10380241e-01f, 2.66619056e-01f, 1.54544637e-01f, -4.99214739e-01f, 5.13718188e-01f, 4.44412827e-02f, 1.79714322e-01f, -1.95206136e-01f,
  8.23353231e-02f, 2.55004764e-01f, 1.34955764e-01f, 1.45524457e-01f, 4.22112465e-01f, -1.94969445e-01f, 4.51477431e-02f, -1.44843265e-01f, 2.32951969e-01f, -9.89336055e-03f,
  3.05916727e-01f, -1.52776420e-01f, -5.39617501e-02f, 2.03487694e-01f, 8.54894519e-02f, -1.80766801e-04f, -7.34782442e-02f, 1.08486392e-01f, 2.30850667e-01f, 8.43980536e-02f,
  -7.92080909e-02f, 2.64424179e-02f, -4.93832901e-02f, -2.12558076e-01f, 1.80085152e-01f, -2.40214113e-02f, 1.52109489e-01f, 2.45128959e-01f, -7.91210681e-02f, 1.91120580e-01f,
  -1.13099124e-02f, 2.00188875e-01f, 3.84662412e-02f, -1.22625105e-01f, -1.37579650e-01f, 9.89175215e-02f, -1.29794911e-01f, -1.93745688e-01f, 7.90068582e-02f, 7.43244737e-02f,
  1.75597578e-01f, 1.47071555e-02f, 1.30093783e-01f, 1.95176974e-02f, -1.42053112e-01f, -4.94388342e-02f, -9.00620315e-03f, 6.16832227e-02f, 5.46196848e-02f, -7.11987168e-02f,
  -3.05880845e-01f, 1.99625641e-01f, -3.33179422e-02f, 2.62530953e-01f, -3.26371491e-02f, 1.56650797e-01f, 2.84165651e-01f, -4.51022424e-02f, 4.59324569e-02f, 5.05938306e-02f,
  -2.55798772e-02f, 3.07614028e-01f, -2.83755898e-01f, -1.17761053e-01f, 1.74280733e-01f, 6.03296384e-02f, 1.01946846e-01f, -7.67581835e-02f, -1.15099907e-01f, -7.80425295e-02f,
  7.89621621e-02f, -6.70731589e-02f, 7.99194127e-02f, 2.27763858e-02f, 2.25268654e-03f, -5.94696850e-02f, -6.45258725e-02f, 1.00147381e-01f, -5.37889190e-02f, 6.11818694e-02f,
  -9.91400331e-02f, -7.49011561e-02f, 8.08259621e-02f, 1.05768584e-01f, -1.78119659e-01f, -6.65053278e-02f, 2.88470797e-02f, -8.76444057e-02f, 2.15106025e-01f, -1.95496410e-01f,
  1.69927254e-01f, 6.33095130e-02f, -2.42518842e-01f, 1.22030385e-01f, -1.96004584e-01f, 1.78739548e-01f, -2.51660883e-01f, -4.00492251e-01f, 1.08543150e-01f, -4.69002835e-02f,
  -1.70001775e-01f, -6.43559098e-02f, 5.96105121e-03f, 1.41559944e-01f, -9.05596763e-02f, -1.46853700e-01f, -1.39244929e-01f, -2.25290153e-02f, -1.98839813e-01f, -1.69578027e-02f,
  -7.83947483e-02f, 1.26859933e-01f, -8.25442001e-02f, 1.33961998e-02f, 8.67503136e-03f, -1.73913613e-01f, -1.59719765e-01f, 9.66912042e-03f, -1.74991833e-03f, -1.75407857e-01f,
  -2.19450425e-02f, -2.01462150e-01f, -8.43985900e-02f, 1.91349566e-01f, -2.43904725e-01f, -6.31878972e-02f, -8.48903880e-02f, 1.80897817e-01f, -1.52127787e-01f, -4.42243755e-01f,
  2.71264259e-02f, 3.22932042e-02f, -1.79772481e-01f, 2.46425033e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.24490166e-01f, 1.47304088e-01f, -5.86342290e-02f, 1.07485808e-01f, 2.27442488e-01f, 3.23543280e-01f, 2.18525335e-01f, 8.71381164e-02f, 1.54078797e-01f, 6.20727576e-02f,
  7.14967996e-02f, 5.42077869e-02f, -1.65206239e-01f, -1.63881779e-02f, 1.06465422e-01f, 6.99679404e-02f, -2.52831757e-01f, 8.44947696e-02f, -5.12119345e-02f, 2.58834541e-01f,
  -1.82886690e-01f, -3.28574210e-01f, 2.93849796e-01f, -5.88344708e-02f, 1.88536718e-01f, -6.12334199e-02f, 7.49989897e-02f, 5.46512365e-01f, -2.32469454e-01f, -7.32196867e-02f,
  3.99236739e-01f, -9.59272322e-04f, 3.31735402e-01f, 4.55050319e-02f, 1.96163088e-01f, 1.25806913e-01f, 1.12540655e-01f, 3.63605060e-02f, 2.95506269e-01f, 2.80549496e-01f,
  -1.15264393e-02f, 2.44691774e-01f, 3.46509606e-01f, -3.18263620e-02f, 1.31712958e-01f, 6.28714859e-02f, -2.74128795e-01f, -3.72354716e-01f, 2.99394280e-01f, 9.30181742e-02f,
  3.24588902e-02f, 6.97037578e-02f, 1.03758372e-01f, 6.60278872e-02f, 1.61076292e-01f, -2.11680949e-01f, 3.04279894e-01f, 2.91454084e-02f, 1.64463609e-01f, -2.30105236e-01f,
  4.94701564e-01f, 1.45358920e-01f, 2.05237195e-01f, 8.98209661e-02f, 1.93181187e-01f, 6.15391938e-04f, 4.72521521e-02f, -1.06408693e-01f, 1.11004941e-01f, 1.43992573e-01f,
  9.75073054e-02f, -1.13761500e-02f, 6.45691007e-02f, 1.35885954e-01f, 1.87353179e-01f, -7.88207129e-02f, 1.97115272e-01f, -1.25084996e-01f, -1.57653466e-01f, -2.62162089e-01f,
  1.36681721e-01f, 8.28536972e-02f, -9.60398838e-02f, 2.14958534e-01f, 5.40711060e-02f, 6.25692904e-02f, 3.77774313e-02f, -2.73322433e-01f, 6.90756798e-01f, 4.42432724e-02f,
  2.63339221e-01f, 7.16102198e-02f, -2.32360110e-01f, 1.46482453e-01f, 3.00584346e-01f, -7.83415809e-02f, -1.75047237e-02f, 1.60451144e-01f, 3.51585060e-01f, -4.63731866e-03f,
  5.80957532e-01f, 1.44248959e-02f, 1.01728387e-01f, 1.64750010e-01f, 3.58741045e-01f, 6.06835969e-02f, 1.22300379e-01f, 1.47416189e-01f, 4.43545789e-01f, 2.98197120e-01f,
  -1.69066861e-01f, -9.39677209e-02f, -1.22729719e-01f, -2.84994781e-01f, 2.49783486e-01f, -1.31171167e-01f, 9.71286818e-02f, 2.27446377e-01f, -2.61451960e-01f, 3.03426832e-01f,
  -3.31340045e-01f, 3.77521276e-01f, -4.45032455e-02f, 1.25434259e-02f, -2.06349611e-01f, 1.08196780e-01f, -3.49020123e-01f, -2.39529058e-01f, 1.54490456e-01f, 1.21940695e-01f,
  -1.25427306e-01f, 1.41489521e-01f, -8.02436247e-02f, 3.24859589e-01f, 2.11753532e-01f, 2.68264353e-01f, 2.66282558e-01f, 8.93493742e-02f, 5.47295697e-02f, 3.83057773e-01f,
  1.04976958e-02f, -1.99107796e-01f, 1.82477847e-01f, 5.08267917e-02f, 2.14167655e-01f, -3.72538045e-02f, -1.67188451e-01f, 1.96190938e-01f, -8.92582238e-02f, -4.34866026e-02f,
  2.20654771e-01f, -1.70433387e-01f, -2.28238069e-02f, 3.90828736e-02f, -2.17046916e-01f, 2.44853809e-01f, 1.10256486e-01f, -6.63960204e-02f, 8.38284865e-02f, 4.37545359e-01f,
  8.38879049e-02f, -4.23926674e-02f, 2.30165407e-01f, 1.34593189e-01f, 1.85780972e-01f, 7.77911991e-02f, 6.08370267e-02f, 3.56259272e-02f, 2.10605375e-02f, -1.56181091e-02f,
  3.70870298e-03f, 1.80938486e-02f, -1.32073686e-01f, 3.03974479e-01f, -1.59412727e-01f, -5.73515259e-02f, 5.83480783e-02f, 1.35452181e-01f, 7.54431710e-02f, -1.46728769e-01f,
  2.39774197e-01f, 2.92576045e-01f, 1.01544417e-01f, 1.80626705e-01f, 2.31193125e-01f, -3.91452983e-02f, 6.04333818e-01f, -9.98366848e-02f, 8.58352259e-02f, 2.60208040e-01f,
  1.88652873e-01f, -6.24734946e-02f, -6.87168539e-02f, 2.30326667e-01f, 2.10002154e-01f, -3.43604907e-02f, 6.73373416e-02f, 2.19456211e-01f, 1.68794110e-01f, 3.11862946e-01f,
  2.43443057e-01f, 1.64195150e-01f, 1.45419344e-01f, 3.14923942e-01f, 2.12877199e-01f, -1.09661445e-01f, -1.58531383e-01f, 2.17408895e-01f, 1.12940453e-01f, -4.19693768e-01f,
  1.70894831e-01f, 1.52718619e-01f, -1.32159740e-01f, 2.97503769e-02f, -1.80976972e-01f, 1.42222643e-01f, -2.55965263e-01f, 3.12156767e-01f, -8.25629011e-03f, 1.32853776e-01f,
  2.81647086e-01f, 5.67061864e-02f, -3.59077454e-01f, 3.86296749e-01f, 2.80688126e-02f, 2.72635281e-01f, 1.06580801e-01f, -4.07091081e-02f, 2.93970615e-01f, 1.80136308e-01f,
  -3.43285389e-02f, 2.73011088e-01f, 3.63252729e-01f, 1.17222302e-01f, 7.66332820e-02f, -4.71695513e-03f, -1.27089530e-01f, -1.37278214e-01f, -4.50913459e-02f, 3.17778945e-01f,
  -2.26716027e-02f, -4.68086749e-02f, 3.91260922e-01f, -1.15707815e-01f, 2.72570550e-02f, -9.47872177e-02f, -1.08225323e-01f, 3.50066155e-01f, -3.28120172e-01f, 1.39176726e-01f,
  2.65222974e-02f, -2.05953568e-01f, 3.48909587e-01f, 2.90209621e-01f, -2.56529480e-01f, 4.34586644e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  8.99367705e-02f, 1.70165718e-01f, -2.83664186e-03f, 1.65089145e-02f, 2.63389021e-01f, -5.29858563e-03f, 1.07370257e-01f, 3.09200495e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -2.11152107e-01f, -2.20506471e-02f, 8.33896473e-02f, 4.51561958e-02f, 2.82928045e-03f, -1.03373185e-01f, -1.92619473e-01f, 2.35762950e-02f, 8.43764320e-02f, -1.09914295e-01f,
  -2.85081625e-01f, -1.33968085e-01f, -7.48558715e-02f, 2.91635841e-01f, 2.71220535e-01f, -4.05195765e-02f, -1.18975937e-01f, -1.80988625e-01f, -8.18188936e-02f, -2.62912780e-01f,
  -1.99516237e-01f, -8.70767236e-02f, 7.49792084e-02f, 8.33832473e-02f, 2.13630959e-01f, -1.79845855e-01f, -1.00329541e-01f, -6.04929961e-02f, 2.58876264e-01f, -1.63672298e-01f,
  3.01236182e-01f, 8.06560740e-02f, 2.39221230e-01f, 8.21477792e-04f, -3.74557264e-02f, 8.22047796e-03f, -5.64519279e-02f, 7.28239715e-02f, 1.19312167e-01f, 9.34079513e-02f,
  -1.65955111e-01f, -1.06734231e-01f, 7.42184371e-02f, -3.42055899e-03f, 1.36649862e-01f, 7.73098394e-02f, -2.94453889e-01f, 4.20453399e-02f, 3.59877497e-01f, 8.92688259e-02f,
  3.18575472e-01f, 4.06147510e-01f, 8.63157660e-02f, -2.38016739e-01f, 6.83735758e-02f, -2.36983225e-01f, 1.20982118e-01f, 2.12037459e-01f, 2.41201073e-01f, -4.72821146e-02f,
  -1.87889621e-01f, -7.92962760e-02f, -5.48435450e-02f, -2.09441707e-01f, 1.70755640e-01f, 4.89587858e-02f, 5.22402376e-02f, 3.08652204e-02f, 1.03333443e-01f, -2.31977012e-02f,
  -1.21345930e-01f, 1.89310953e-01f, 2.99707204e-02f, -4.74043414e-02f, -1.77411497e-01f, 2.35091839e-02f, -1.68749064e-01f, 1.73407599e-01f, 1.53823057e-02f, 7.02686012e-02f,
  -1.88316748e-01f, -1.83696561e-02f, 3.55390996e-01f, 6.17335960e-02f, 3.86074111e-02f, -2.54552335e-01f, -2.46605128e-01f, 3.22018154e-02f, 1.96654439e-01f, -1.84695184e-01f,
  2.12010965e-01f, -9.24294889e-02f, 1.81626990e-01f, -4.31424797e-01f, 5.81432767e-02f, -5.34032285e-01f, 1.09725021e-01f, 1.64881945e-02f, -1.00175978e-03f, -1.39416650e-01f,
  -1.35819213e-02f, -4.63124812e-02f, 1.50814071e-01f, -3.70683491e-01f, 8.27623978e-02f, 7.38757104e-02f, 9.56825018e-02f, 6.99971914e-02f, -9.39658284e-02f, -2.80808867e-03f,
  -2.26717964e-02f, 3.85188937e-01f, -1.58796698e-01f, -3.32985133e-01f, 3.08133978e-02f, 3.05489134e-02f, -2.02740550e-01f, 3.97070237e-02f, -8.40906873e-02f, -4.78597805e-02f,
  1.51521593e-01f, -1.47006348e-01f, -6.56666905e-02f, -3.50329965e-01f, 6.16114251e-02f, -1.81622311e-01f, -3.20298746e-02f, -1.29303187e-01f, -1.55188339e-02f, -2.89412532e-02f,
  1.16369417e-02f, -1.86645031e-01f, -1.11870907e-01f, 1.57678246e-01f, -9.04383212e-02f, 1.94287717e-01f, 2.37432376e-01f, -9.81857255e-02f, 1.39797390e-01f, 2.15276808e-01f,
  5.73807321e-02f, -2.48468459e-01f, 1.45083413e-01f, -4.93583888e-01f, -2.07712963e-01f, 2.25654796e-01f, -1.76364467e-01f, 1.01159483e-01f, -3.57105024e-02f, 7.64312521e-02f,
  4.95814607e-02f, 2.24595353e-01f, -3.47435176e-01f, 1.88887656e-01f, 1.51804075e-01f, -2.80326724e-01f, -1.18036993e-01f, 3.15671951e-01f, 6.53357580e-02f, 1.35972261e-01f,
  -1.12828374e-01f, -1.77264735e-01f, 1.17172472e-01f, -1.57550529e-01f, -1.14141449e-01f, -6.13985397e-02f, 5.28430566e-03f, 1.52970284e-01f, 1.19440258e-01f, -3.38819064e-02f,
  -5.58371022e-02f, -1.09276719e-01f, -2.43517131e-01f, 2.16590375e-01f, 4.03572261e-01f, 3.75806056e-02f, -2.67751008e-01f, -1.43680975e-01f, 1.66815341e-01f, 4.81735691e-02f,
  -1.99885875e-01f, 5.96741028e-03f, -1.80369347e-01f, -2.75151916e-02f, 1.53872177e-01f, 7.77533948e-02f, -2.63488200e-03f, -3.96619648e-01f, 2.90163815e-01f, -2.64118731e-01f,
  9.39473286e-02f, -3.15438174e-02f, -1.44949540e-01f, -6.22856505e-02f, 1.57658048e-02f, -7.80531392e-02f, -4.80989106e-02f, -5.64089268e-02f, 7.36659300e-03f, 3.68507653e-01f,
  1.06990784e-01f, -2.63379458e-02f, -2.04568833e-01f, -1.50163770e-01f, -1.60960019e-01f, 2.72263080e-01f, 3.04777563e-01f, -1.22718215e-01f, -2.36730710e-01f, 1.10776991e-01f,
  2.15406790e-01f, 2.34825596e-01f, -3.05129727e-03f, 5.45046814e-02f, -1.72084957e-01f, -6.28299490e-02f, 2.42734998e-01f, -3.37774632e-03f, 2.74811815e-02f, -2.02351362e-01f,
  2.66104937e-01f, 1.43556282e-01f, 7.53187165e-02f, -5.82562014e-03f, 1.97481558e-01f, 8.22688919e-04f, -5.94835654e-02f, 1.66272953e-01f, -1.96920037e-01f, -2.98046842e-02f,
  1.04798138e-01f, -6.18137307e-02f, -9.31175575e-02f, 1.00936666e-01f, -4.01864573e-02f, -2.00736567e-01f, -1.05673552e-01f, 4.55803461e-02f, -1.64490625e-01f, 2.32078850e-01f,
  2.25508243e-01f, -1.42926425e-01f, 1.50538638e-01f, 2.47982353e-01f, 9.93974134e-03f, -1.85723647e-01f, -1.15145676e-01f, -1.97405249e-01f, 9.34734568e-02f, -6.06941283e-02f,
  3.20126295e-01f, -1.41113430e-01f, 7.67128691e-02f, 3.40729393e-02f, -9.74761397e-02f, -2.57632315e-01f, -8.55965316e-02f, -1.17636144e-01f, 7.30189234e-02f, -1.58229813e-01f,
  1.31360248e-01f, 9.51161683e-02f, -2.22645979e-03f, -2.33544379e-01f, 1.83161646e-01f, -2.01434121e-02f, 1.90077648e-01f, 1.31300211e-01f, 1.46942914e-01f, -1.29818961e-01f,
  1.73571423e-01f, 9.83990133e-02f, -2.82652766e-01f, -5.35186902e-02f, -1.03845403e-01f, -1.69749737e-01f, -4.17787507e-02f, -1.59062117e-01f, -5.49694709e-02f, 1.63522005e-01f,
  -8.83300900e-02f, -1.43121541e-01f, 1.09820500e-01f, -3.82678472e-02f, 2.59724017e-02f, -1.84970170e-01f, 6.98793083e-02f, -5.95655479e-02f, 2.40742356e-01f, 1.43692596e-03f,
  -2.15544492e-01f, -3.63775752e-02f, 1.97468445e-01f, 1.98075399e-01f, 4.61737692e-01f, -7.75803402e-02f, 2.10992634e-01f, -1.19203389e-01f, 5.50857961e-01f, 1.73657522e-01f,
  -1.77136250e-02f, -1.78530514e-01f, -2.37097636e-01f, 2.19876394e-01f, -1.15052586e-04f, 1.01568907e-01f, 2.76396424e-01f, 2.37659141e-01f, 1.58252612e-01f, -7.61417076e-02f,
  3.50662880e-02f, -5.84513359e-02f, -2.68277586e-01f, 2.00418189e-01f, -2.65516844e-02f, -4.27968381e-03f, -7.17517128e-03f, 3.07497494e-02f, -1.64709195e-01f, -3.60786587e-01f,
  3.56263489e-01f, 6.68352172e-02f, -2.72467732e-03f, -6.59844801e-02f, 7.53802340e-03f, -4.91948053e-02f, 3.73089314e-01f, -1.56236380e-01f, 2.53881156e-01f, 1.92439273e-01f,
  8.97394270e-02f, -1.20067716e-01f, 1.93097651e-01f, -1.83294103e-01f, -3.47438067e-01f, 3.25505808e-02f, 2.86581308e-01f, -1.43502920e-03f, 6.64613917e-02f, 3.35380107e-01f,
  -3.85122607e-04f, -2.73754120e-01f, -6.72290474e-02f, 5.63560100e-03f, 5.87307177e-02f, 1.15689777e-01f, 9.35659632e-02f, -2.44377837e-01f, -7.26244822e-02f, 2.11735815e-01f,
  -1.07123367e-01f, -1.45062938e-01f, 2.14711174e-01f, 1.05671160e-01f, -1.11862138e-01f, 1.60208493e-01f, 4.48929146e-02f, -1.29055992e-01f, 1.75664008e-01f, 1.73028424e-01f,
  -6.05642386e-02f, -3.17837074e-02f, -2.68397480e-01f, -1.41580477e-01f, 9.85224545e-02f, 5.46363294e-02f, -1.36418879e-01f, 1.60647511e-01f, 3.70524645e-01f, 2.79265456e-02f,
  2.24124134e-01f, 4.01021361e-01f, 1.01178080e-01f, -2.19995737e-01f, -1.50749728e-01f, -2.58347690e-01f, 2.75714755e-01f, -2.16608047e-02f, 1.48595735e-01f, -1.54364958e-01f,
  3.05485073e-02f, 1.89377874e-01f, -1.05361298e-01f, -1.16154186e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -5.56433648e-02f, 1.02619201e-01f, -9.55103636e-02f, 8.81483555e-02f, 7.68398419e-02f, 3.06022316e-01f, 3.05076957e-01f, -1.24955513e-01f, 2.20337257e-01f, 1.39376402e-01f,
  2.53388315e-01f, -1.75886045e-04f, -2.67647684e-01f, -2.18719468e-01f, 1.83634296e-01f, 5.29847801e-01f, -2.47043937e-01f, -3.11885267e-01f, -7.78269321e-02f, -2.68146366e-01f,
  -9.15937647e-02f, -1.01842970e-01f, -3.00020754e-01f, 2.81156097e-02f, 1.82473063e-01f, 8.14256966e-02f, -1.54626817e-01f, 2.32162297e-01f, 4.24123734e-01f, -1.35754213e-01f,
  1.44085541e-01f, 2.15230614e-01f, 6.46996945e-02f, 1.36309192e-01f, 6.94425851e-02f, -1.38637070e-02f, 3.15132260e-01f, 6.81353137e-02f, 1.56369761e-01f, 2.98662692e-01f,
  3.50524276e-01f, -2.07764745e-01f, 3.48359227e-01f, 4.71160084e-01f, 3.10505033e-01f, 4.34792563e-02f, 1.51187489e-02f, -7.30891347e-01f, -4.16436523e-01f, 5.35794914e-01f,
  2.09210798e-01f, 4.39688176e-01f, -3.18878181e-02f, -1.83542967e-01f, 1.84726506e-01f, -5.97912483e-02f, -3.70478809e-01f, 4.39994097e-01f, 1.15418471e-01f, -2.48171374e-01f,
  3.68267065e-03f, -6.68619499e-02f, -1.55138578e-02f, 1.43876389e-01f, 2.25315586e-01f, 1.31133512e-01f, 1.18496127e-01f, 8.93118903e-02f, 2.19184473e-01f, 1.99716628e-01f,
  -1.07551273e-02f, -9.08472613e-02f, -2.13895850e-02f, 4.17077541e-01f, 8.43872651e-02f, 1.18421622e-01f, -1.46767706e-01f, -7.16413558e-02f, -2.87521333e-01f, 4.88143265e-01f,
  2.23779649e-01f, -3.34260911e-01f, -1.60705075e-02f, -4.89404500e-01f, 3.94818522e-02f, -1.84497342e-01f, -6.30859286e-02f, -3.34199034e-02f, 4.15931731e-01f, -1.62527889e-01f,
  -1.72555879e-01f, 4.07606006e-01f, 1.56905621e-01f, -1.89212393e-02f, 2.87797898e-01f, 1.43588141e-01f, 4.80252534e-01f, 2.30797902e-01f, 1.94763571e-01f, 1.08645968e-01f,
  1.79210171e-01f, 2.61063159e-01f, 2.55131006e-01f, -2.96759568e-02f, 4.44592744e-01f, 3.29388738e-01f, 2.37678409e-01f, 2.15559691e-01f, -1.24947187e-02f, -6.50101677e-02f,
  6.15308108e-03f, -4.31057960e-02f, 1.26128435e-01f, -2.30233502e-02f, 4.62774366e-01f, 3.50022197e-01f, -1.10576093e-01f, -4.96134192e-01f, -4.18132782e-01f, -2.15491965e-01f,
  6.25632763e-01f, 5.72920859e-01f, 7.46453404e-01f, -1.79842800e-01f, 5.00484288e-01f, 1.39471099e-01f, -1.39116254e-02f, -1.15118466e-01f, -3.68499607e-02f, 5.29633882e-03f,
  7.09816813e-02f, 2.08170265e-01f, 1.86770648e-01f, 1.88631475e-01f, 7.50436708e-02f, 4.06674594e-01f, -9.84903947e-02f, 1.72121435e-01f, -1.27838738e-02f, 3.34416449e-01f,
  1.11464247e-01f, -1.80450007e-01f, -1.13246091e-01f, -2.90026307e-01f, 3.44401859e-02f, 3.99219632e-01f, -2.78517473e-02f, -2.21161306e-01f, 3.23851228e-01f, -1.62546337e-01f,
  3.52327794e-01f, 2.11282566e-01f, -2.36801893e-01f, 1.53849170e-01f, -9.78511721e-02f, 6.89308167e-01f, 5.94450012e-02f, 1.15772575e-01f, 4.79282081e-01f, 2.50781506e-01f,
  -8.35375674e-03f, 2.82807857e-01f, 4.25133891e-02f, 7.02356100e-02f, 2.32080564e-01f, 2.75770396e-01f, 4.17870402e-01f, -3.04118305e-01f, 7.02952668e-02f, 2.21078306e-01f,
  2.42213085e-01f, 2.51388073e-01f, -7.00627044e-02f, -3.44935894e-01f, 5.30482046e-02f, 4.52764690e-01f, -2.21857652e-01f, -1.29304692e-01f, -2.74001509e-01f, -6.96135938e-01f,
  -5.13393655e-02f, -3.38602275e-01f, -1.98635701e-02f, 4.19800609e-01f, -1.93892956e-01f, 6.46087229e-02f, -1.76386014e-01f, 1.84404001e-01f, 4.12149578e-01f, -1.01510793e-01f,
  4.19500142e-01f, 3.79435658e-01f, -3.58419806e-01f, -8.99302289e-02f, -1.41339134e-02f, 1.05954036e-02f, 1.17976516e-02f, -1.19371284e-02f, -2.00161815e-01f, 1.46492809e-01f,
  2.06947133e-01f, 1.29958302e-01f, 9.80282128e-02f, -1.74120426e-01f, -3.46832961e-01f, 4.79868531e-01f, 5.03985047e-01f, -1.97242215e-01f, -4.32505429e-01f, 2.85096765e-02f,
  -2.97260851e-01f, -9.59826335e-02f, -2.28850573e-01f, -1.57334641e-01f, -1.45912245e-01f, 3.21062028e-01f, -2.28226837e-03f, 2.66880363e-01f, -3.23494285e-01f, -9.42742676e-02f,
  4.03678894e-01f, -8.03978294e-02f, 4.75333840e-01f, 4.06999022e-01f, 8.66764784e-02f, 1.28901735e-01f, -9.92835015e-02f, 1.00050300e-01f, 1.21859431e-01f, 1.65440902e-01f,
  1.80850461e-01f, 3.74113590e-01f, 1.74208879e-02f, 2.13761255e-01f, 1.11583397e-01f, -1.57624371e-02f, 2.78855979e-01f, -4.48930934e-02f, -3.22525233e-01f, -3.32266212e-01f,
  3.85403574e-01f, 3.91788274e-01f, -2.26288900e-01f, 1.56179711e-01f, 3.25048804e-01f, 1.16690464e-01f, 2.67570406e-01f, -1.83983713e-01f, -1.87882200e-01f, 3.50463957e-01f,
  2.31022567e-01f, 6.49558425e-01f, -8.58688056e-02f, 6.47882938e-01f, 3.60445738e-01f, 3.56976658e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  2.72097707e-01f, 1.72047526e-01f, 2.63947040e-01f, 4.34497029e-01f, 2.64093965e-01f, 2.54133165e-01f, -3.37816961e-02f, 1.71471015e-01f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  1.08020902e-01f, 2.35069796e-01f, -2.33067125e-01f, -1.66211650e-01f, -1.95463654e-02f, -1.59420818e-01f, -1.78843185e-01f, 2.61135343e-02f, -5.41490093e-02f, 2.43218988e-01f,
  9.54399332e-02f, 3.09452713e-02f, -9.83321853e-03f, -2.70066142e-01f, -3.06386370e-02f, -1.85364291e-01f, 2.85082400e-01f, -1.49813160e-01f, -2.02294171e-01f, -1.14660449e-01f,
  -4.39095125e-02f, -2.00999349e-01f, -1.88330278e-01f, -2.11360097e-01f, -2.28952020e-01f, 7.88415670e-02f, -1.46568209e-01f, -2.12274902e-02f, 4.56044823e-02f, -3.47413830e-02f,
  -1.03028193e-01f, 1.87069818e-01f, -1.19206704e-01f, 1.02360241e-01f, -1.65220618e-01f, 1.05077595e-01f, -3.87138873e-02f, 8.59945342e-02f, 2.46098973e-02f, 8.26032683e-02f,
  1.46843325e-02f, 1.16311414e-02f, 8.70867670e-02f, 1.90704152e-01f, -7.83458631e-03f, 5.33018000e-02f, 1.42459616e-01f, 2.31945068e-01f, -9.21290889e-02f, -3.37306894e-02f,
  -6.68483600e-02f, 7.01411292e-02f, 1.07613310e-01f, 2.68224776e-01f, 2.27139965e-01f, 1.47064924e-01f, -3.57762538e-02f, 2.44405165e-01f, 1.51394382e-02f, 2.16362104e-01f,
  -1.74600124e-01f, -1.90344691e-01f, -4.77082655e-02f, -1.02496222e-01f, 5.15476540e-02f, -4.50299680e-02f, -2.42296532e-02f, -1.28257349e-01f, -1.47568300e-01f, 8.95433947e-02f,
  -1.04591869e-01f, -1.89993694e-01f, -1.86904609e-01f, 1.78296089e-01f, -1.65299475e-01f, -1.93386182e-01f, 2.87192374e-01f, -9.66693014e-02f, -1.72663465e-01f, 2.74486654e-02f,
  3.23193371e-02f, 3.14112991e-01f, 1.32583395e-01f, -2.99509782e-02f, 3.98041420e-02f, -2.68160135e-01f, -1.86900929e-01f, -3.01621199e-01f, 2.85383202e-02f, -3.32466185e-01f,
  -1.29907548e-01f, -4.27859128e-02f, -9.43885297e-02f, 1.10809550e-01f, 2.83585340e-01f, -1.28362492e-01f, 6.57238439e-02f, -7.62742013e-02f, 1.27080262e-01f, 5.32989502e-02f,
  5.32728322e-02f, 1.03193134e-01f, -1.18006207e-01f, -1.88344512e-02f, 2.26118509e-02f, -1.28072187e-01f, 9.91337001e-02f, 6.64214939e-02f, 2.21294791e-01f, -1.18300080e-01f,
  1.24845587e-01f, 1.59345474e-02f, -1.50283501e-02f, 1.37174115e-01f, -2.96388548e-02f, -1.51546791e-01f, 1.50124818e-01f, -2.07673892e-01f, -2.01140553e-01f, -1.82270154e-01f,
  9.96337156e-04f, -6.73670247e-02f, 1.19826019e-01f, -7.19964579e-02f, 1.30070955e-01f, 1.72599092e-01f, 3.19777220e-01f, -1.77007213e-01f, 9.74749401e-03f, 1.13526605e-01f,
  -2.92458206e-01f, 6.52956665e-02f, -1.12614021e-01f, -1.70613319e-01f, -2.60189295e-01f, -3.31555009e-02f, 1.70563459e-02f, -1.01859448e-03f, -5.76494075e-02f, 1.33242145e-01f,
  1.71576038e-01f, -3.64343137e-01f, 1.48607194e-01f, -2.11127907e-01f, 1.04006335e-01f, -5.48648611e-02f, -1.79896802e-02f, -2.30042100e-01f, 5.38075455e-02f, -1.94352344e-01f,
  -3.97968054e-01f, 2.81917956e-02f, -1.93989370e-02f, 2.23032176e-01f, -1.23169646e-01f, -5.26244268e-02f, 2.90498555e-01f, -1.34267002e-01f, 1.01847939e-01f, 1.64098948e-01f,
  1.80813700e-01f, -7.57874027e-02f, 3.42797190e-01f, 3.21680866e-02f, 3.11409384e-01f, 2.19251230e-01f, 1.63414061e-01f, 3.70448045e-02f, 1.66394766e-02f, -3.28266501e-01f,
  1.82314426e-01f, 2.14952916e-01f, 4.06800844e-02f, -1.65388256e-01f, 2.07789354e-02f, 4.02498916e-02f, -1.11533597e-01f, -6.78552091e-02f, -3.22289467e-01f, -1.85886566e-02f,
  2.15718240e-01f, 1.89180955e-01f, -4.21214476e-02f, -3.44135165e-02f, -1.99373588e-02f, -9.99568850e-02f, 9.46912095e-02f, -6.33215457e-02f, 1.22822613e-01f, 3.25685918e-01f,
  -1.50728807e-01f, -3.88593115e-02f, 7.95756876e-02f, 9.07008126e-02f, 5.91291301e-02f, 1.01300254e-01f, -5.41737229e-02f, 1.71100810e-01f, 1.57702968e-01f, 1.13047488e-01f,
  5.04345037e-02f, -1.37167528e-01f, 8.66882801e-02f, -9.24725085e-03f, -2.36801967e-01f, 1.42457467e-02f, 1.06054939e-01f, -3.52316611e-02f, 1.50428742e-01f, -4.55673076e-02f,
  -1.59023166e-01f, 1.66011509e-02f, 4.53532264e-02f, 3.26531589e-01f, 3.40990573e-01f, 2.61151716e-02f, -2.12157480e-02f, 3.39170128e-01f, -1.61286995e-01f, 3.23805287e-02f,
  -1.92085560e-02f, 4.57533868e-03f, -1.81812063e-01f, -4.32954207e-02f, 1.04399826e-02f, -8.30868259e-03f, -1.29269093e-01f, 7.48507231e-02f, 3.20715606e-02f, -4.18853052e-02f,
  -1.02650478e-01f, -2.46476859e-01f, -1.07953642e-02f, -5.73456474e-02f, 8.18336010e-02f, 3.73983905e-02f, 2.55817771e-01f, -7.74044618e-02f, 1.04459994e-01f, 1.32996559e-01f,
  2.73635727e-03f, 3.56121004e-01f, 8.18347558e-02f, -1.21768922e-01f, 1.71825096e-01f, -3.09727758e-01f, -1.00335121e-01f, -1.23853669e-01f, 1.53630868e-01f, -9.88671705e-02f,
  9.13256481e-02f, -3.86984460e-02f, -7.43343234e-02f, 2.10850984e-02f, 3.29790801e-01f, -1.89112410e-01f, 7.50475973e-02f, 8.37318413e-03f, -4.73185163e-03f, 2.42409240e-02f,
  -3.10482886e-02f, 1.48503296e-03f, -5.48584051e-02f, -1.86644092e-01f, -8.84321183e-02f, -4.99171158e-03f, -9.07093659e-02f, -3.13567162e-01f, -1.50564432e-01f, 2.61687845e-01f,
  -1.68031707e-01f, -1.71013579e-01f, -2.85838842e-01f, -1.45396575e-01f, 4.95142601e-02f, 1.51967540e-01f, -2.78446764e-01f, 7.73665458e-02f, 1.86405048e-01f, 8.75694230e-02f,
  -2.61241794e-01f, -1.85380057e-01f, 2.13721558e-01f, -6.36049062e-02f, -4.07012179e-03f, -1.72030419e-01f, -1.09680116e-01f, 2.74202436e-01f, 1.39827669e-01f, 2.49836892e-02f,
  2.23213255e-01f, -2.63977349e-02f, -8.30604136e-02f, 4.97472025e-02f, 1.53272212e-01f, -8.85026604e-02f, 5.68534471e-02f, -7.84814060e-02f, -1.79518592e-02f, -5.58085628e-02f,
  -1.48643345e-01f, 4.23185378e-01f, -1.52123094e-01f, -1.62276566e-01f, -1.45343468e-01f, -3.60771477e-01f, 7.87040889e-02f, 2.59977192e-01f, -2.78566986e-01f, 2.14299768e-01f,
  1.81536391e-01f, 1.73692882e-01f, -8.62184763e-02f, -1.60479009e-01f, -7.91182891e-02f, 5.26534878e-02f, -8.54753144e-03f, -1.63786188e-01f, -2.57776767e-01f, 2.53765415e-02f,
  8.33861902e-03f, -9.44090337e-02f, -1.31469518e-01f, -1.30855784e-01f, -8.93479735e-02f, -2.48418704e-01f, 4.30722907e-02f, -2.16431379e-01f, 7.72091523e-02f, -8.92408714e-02f,
  4.14164662e-02f, -1.85583815e-01f, 1.52509481e-01f, 3.01785618e-02f, -1.47555187e-01f, -1.22234166e-01f, -2.99093544e-01f, 3.45037840e-02f, 3.17906551e-02f, 6.85923547e-02f,
  -1.60873637e-01f, -6.09001294e-02f, -9.33230966e-02f, -5.94228692e-02f, 2.56460309e-02f, -2.43755654e-01f, 1.30654350e-01f, -1.67119220e-01f, 1.94946155e-01f, -5.63774630e-02f,
  6.41265735e-02f, 1.58853009e-01f, -2.16050655e-01f, -3.78635675e-01f, 6.30354211e-02f, 9.74905044e-02f, -9.67590138e-03f, -7.14488178e-02f, 1.60609111e-01f, 7.62575641e-02f,
  -1.26027569e-01f, -1.55859262e-01f, -7.10670054e-02f, 1.73173606e-01f, -2.05825582e-01f, 1.96347535e-01f, -1.23637632e-01f, -3.60846460e-01f, 1.02680750e-01f, 3.11262403e-02f,
  3.25113654e-01f, -2.87678018e-02f, -1.06205620e-01f, 1.96349427e-01f, 1.91134378e-01f, 2.73890913e-01f, 1.36613294e-01f, 2.26534560e-01f, -3.58412474e-01f, 1.76519044e-02f,
  8.30622949e-03f, 1.50244355e-01f, 1.71062261e-01f, 1.92705810e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  7.61022121e-02f, -1.21644773e-02f, 7.59416342e-01f, 3.38368326e-01f, 6.21061265e-01f, 2.32205495e-01f, 2.82109737e-01f, 4.26679462e-01f, 1.57114372e-01f, -3.38297039e-01f,
  -4.99919765e-02f, 1.20001733e-01f, -2.78052151e-01f, 2.35798825e-02f, -3.21301997e-01f, 3.37918937e-01f, -7.59411514e-01f, -4.59567606e-01f, -4.33715165e-01f, 3.35294932e-01f,
  6.45794272e-02f, 2.86747515e-01f, -2.51259834e-01f, 1.68221608e-01f, 6.17047250e-01f, -6.85258687e-01f, 7.89050460e-01f, 5.91520257e-02f, 8.04800838e-02f, 5.72339296e-01f,
  -2.22051963e-01f, 1.70260608e-01f, -9.51800942e-02f, 6.41913489e-02f, -1.48485959e-01f, -2.08895788e-01f, -2.50231951e-01f, -2.11665630e-01f, 9.62455422e-02f, -3.23040962e-01f,
  1.03286706e-01f, 1.85159370e-01f, 1.91317901e-01f, 5.23401797e-02f, 2.23411530e-01f, -3.06185991e-01f, -3.26723725e-01f, -4.69282538e-01f, 6.16715074e-01f, -6.78180456e-02f,
  1.95023671e-01f, -6.37851179e-01f, -8.26128796e-02f, -2.42358521e-01f, -4.01212275e-01f, -5.01090944e-01f, -2.73511689e-02f, 5.69063544e-01f, 9.66803357e-02f, -5.09007350e-02f,
  8.59192014e-01f, 4.29758549e-01f, 5.81867874e-01f, 9.27570224e-01f, 2.99625933e-01f, -3.05217654e-01f, 2.59095520e-01f, -5.41524366e-02f, 1.50346011e-01f, 2.59512097e-01f,
  2.29562417e-01f, 4.53452878e-02f, -7.02048019e-02f, 2.15725303e-01f, 1.37594789e-01f, -1.20023862e-01f, 2.36584529e-01f, -1.19104594e-01f, -8.19160268e-02f, 4.97111559e-01f,
  9.03146192e-02f, 4.63650167e-01f, 7.75911519e-03f, -3.41303706e-01f, 4.53620881e-01f, 6.86125979e-02f, 3.61420840e-01f, -5.85991859e-01f, 2.42453039e-01f, -2.84478039e-01f,
  2.84540981e-01f, 7.46985301e-02f, -1.50086313e-01f, 6.14475489e-01f, -5.43132499e-02f, -5.89461863e-01f, 2.05205917e-01f, 3.06247622e-01f, 4.61966246e-01f, 4.44976240e-02f,
  4.19561237e-01f, 1.59183979e-01f, 4.77556378e-01f, 5.80773056e-01f, 2.90903091e-01f, -3.96149121e-02f, 1.57538861e-01f, 3.76772732e-01f, -4.35318202e-01f, 3.41063619e-01f,
  -8.85342434e-03f, -4.00059074e-01f, 3.50340039e-01f, -5.09703875e-01f, -2.12823138e-01f, 4.34336849e-02f, -1.96559709e-02f, 7.42625594e-01f, 3.82856458e-01f, 1.83431834e-01f,
  -4.45998758e-02f, 3.38670969e-01f, -1.71749748e-03f, 3.70844603e-01f, 4.90490228e-01f, 9.01479423e-02f, -4.99880642e-01f, 4.11561340e-01f, -4.12333727e-01f, -2.51355097e-02f,
  -4.38102275e-01f, 8.57278779e-02f, -2.05482855e-01f, -4.03172284e-01f, -3.73546183e-01f, 6.50531426e-03f, -5.66272959e-02f, 1.38794094e-01f, 6.89014345e-02f, 5.72134787e-03f,
  3.05254906e-01f, -2.29067117e-01f, 1.99771479e-01f, 8.43939856e-02f, -2.81366974e-01f, 1.82332724e-01f, 3.18871319e-01f, 9.98676047e-02f, -5.47398441e-02f, -5.67052662e-01f,
  -4.91888851e-01f, 2.09731415e-01f, 2.38677129e-01f, -1.57749504e-01f, 4.68460619e-02f, 2.98984826e-01f, -6.81955218e-02f, 2.04207927e-01f, 6.78817391e-01f, -1.39661729e-01f,
  1.49968132e-01f, -7.05340505e-02f, 1.51462480e-01f, 2.70815283e-01f, -5.62731363e-02f, 4.58646417e-01f, 1.46565273e-01f, -2.62834936e-01f, 2.93618701e-02f, 4.49105233e-01f,
  -5.10655940e-01f, -7.09794164e-01f, -2.50466794e-01f, 5.20894825e-01f, -1.02401584e-01f, 1.98592823e-02f, 2.19924033e-01f, -2.84668524e-02f, 5.86795568e-01f, 6.27464831e-01f,
  -4.49671507e-01f, 2.57686734e-01f, 5.00789940e-01f, 1.20546065e-01f, -2.90988415e-01f, -7.66660795e-02f, -6.03248691e-03f, 9.47187304e-01f, -4.02529061e-01f, -5.92509091e-01f,
  -6.84153497e-01f, 9.59131271e-02f, 3.13177764e-01f, 4.54309471e-02f, 3.28066081e-01f, 3.89318615e-01f, 1.15723215e-01f, 2.88170308e-01f, 1.92002222e-01f, 4.05061364e-01f,
  4.11825657e-01f, -2.37196773e-01f, 3.32186848e-01f, 2.40374297e-01f, 1.44726083e-01f, -1.39293090e-01f, 4.60366249e-01f, 2.00381175e-01f, 2.93504614e-02f, 3.87763798e-01f,
  1.31162465e-01f, 5.08244075e-02f, 3.68339121e-01f, 4.39316750e-01f, 1.92601442e-01f, 2.22254783e-01f, 5.63847125e-01f, 4.94996428e-01f, 4.20473777e-02f, 6.54007375e-01f,
  -1.16706811e-01f, 4.17066991e-01f, 4.38863724e-01f, -4.79694605e-01f, 9.68265906e-03f, 9.55189541e-02f, -2.69975185e-01f, -1.86163336e-02f, -1.24227367e-01f, -2.60935217e-01f,
  -2.55887389e-01f, -3.02964896e-02f, 1.32080138e-01f, 1.74397856e-01f, 3.36195640e-02f, 1.25281764e-02f, 3.09434593e-01f, -1.40222847e-01f, 2.88928807e-01f, 2.88380444e-01f,
  -2.49036327e-01f, 1.27294138e-01f, 1.22724034e-01f, 1.19013108e-01f, -9.84961633e-03f, -3.28994066e-01f, -1.63882777e-01f, 2.99945120e-02f, 3.13294500e-01f, -2.88192481e-01f,
  4.00157541e-01f, 2.56611407e-01f, -1.70257017e-01f, -9.85225737e-02f, 1.31388485e-01f, -4.61865604e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  4.77512367e-02f, 6.66108206e-02f, 2.43141085e-01f, 2.00929493e-01f, 3.23769674e-02f, 3.52578461e-01f, 2.79408365e-01f, 1.04754284e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  3.81922424e-01f, -4.37393069e-01f, -1.95682958e-01f, 7.48997927e-02f, 1.63788036e-01f, 2.46435598e-01f, -5.11947989e-01f, 6.92023188e-02f, 2.97353476e-01f, 2.18852758e-01f,
  -4.39328194e-01f, -9.10710692e-02f, -3.04103971e-01f, -1.97501783e-03f, 2.23634735e-01f, -2.97565371e-01f, 1.02981858e-01f, -2.09496737e-01f, 1.28415123e-01f, -1.50430545e-01f,
  -2.58234531e-01f, 6.12817071e-02f, -7.03370199e-02f, -9.65481624e-02f, -9.02406156e-01f, -4.37551945e-01f, -4.22287852e-01f, 2.18314499e-01f, -2.66187102e-01f, 4.09934491e-01f,
  2.86982387e-01f, -4.46102411e-01f, 2.29110837e-01f, 4.49186444e-01f, 4.37679678e-01f, -4.52745184e-02f, -1.73997730e-02f, 2.14019895e-01f, 1.33514628e-01f, 4.94583726e-01f,
  -4.86437410e-01f, -4.31557715e-01f, -9.33926553e-02f, -1.56087503e-01f, 7.94833899e-02f, 2.68720180e-01f, -4.71545339e-01f, 5.15734971e-01f, 4.69937265e-01f, 3.36229533e-01f,
  3.95761102e-01f, 3.44777763e-01f, -1.05180174e-01f, -3.96652669e-01f, -5.92149556e-01f, 2.94917136e-01f, -6.29931688e-01f, 1.63391411e-01f, 1.78704616e-02f, 3.51511640e-04f,
  -2.24033207e-01f, -5.75900614e-01f, 4.66664404e-01f, -2.38844246e-01f, 1.53864577e-01f, -2.69667476e-01f, -2.27313906e-01f, -1.86184764e-01f, 6.22877218e-02f, 7.43664503e-02f,
  7.42170727e-04f, -2.96981215e-01f, -1.14086434e-01f, 2.82877614e-03f, -5.49589358e-02f, 7.03683356e-03f, 5.44626787e-02f, -4.19843197e-01f, 4.09865290e-01f, -1.29218027e-01f,
  -1.63894333e-02f, -6.58234805e-02f, -4.06917751e-01f, 1.51327044e-01f, -2.31405273e-01f, 1.30652860e-01f, 3.81960243e-01f, -1.89590529e-01f, -5.32307386e-01f, 4.42676961e-01f,
  -2.85901070e-01f, -7.26364970e-01f, 2.43489370e-01f, -1.31227612e-01f, 4.19002436e-02f, -2.42284328e-01f, -1.02021240e-01f, -7.59181380e-02f, 3.29212427e-01f, 2.32113257e-01f,
  -1.38008580e-01f, -1.40981063e-01f, 9.66042951e-02f, 1.48220345e-01f, 3.42555016e-01f, 3.22135031e-01f, 1.17232285e-01f, -2.71851500e-03f, -3.47146481e-01f, 2.84495264e-01f,
  1.45405158e-01f, -8.05277899e-02f, -3.00952584e-01f, -4.01093751e-01f, -2.02754438e-01f, 4.43778038e-01f, 1.81307971e-01f, 9.44799185e-02f, -4.12296988e-02f, -4.04984534e-01f,
  -6.17123008e-01f, -4.26364988e-01f, 4.24205452e-01f, -6.89779460e-01f, 3.57352458e-02f, 6.05261564e-01f, 3.36232446e-02f, 3.69934350e-01f, -2.66295880e-01f, -5.73890582e-02f,
  -3.01908940e-01f, 1.92166954e-01f, -2.51716703e-01f, 3.28542709e-01f, 2.27253765e-01f, 2.04038963e-01f, 1.04062200e-01f, 6.82317913e-02f, 3.25475127e-01f, 2.47322559e-01f,
  -1.84640601e-01f, 3.53227854e-01f, -3.72414917e-01f, -1.92250326e-01f, -3.16807359e-01f, 2.83919722e-01f, 2.60708928e-01f, -2.59958446e-01f, 5.14170945e-01f, 3.76548171e-01f,
  -3.04320872e-01f, 3.20295751e-01f, 6.78460658e-01f, -8.97962570e-01f, -4.46722627e-01f, -2.45629512e-02f, -3.70636225e-01f, 3.08899343e-01f, 3.09966989e-02f, -3.10831785e-01f,
  5.24775803e-01f, 3.02826673e-01f, -1.70398623e-01f, 4.06790882e-01f, 5.22052944e-01f, -2.38345280e-01f, 1.27606720e-01f, -3.41732502e-01f, 1.62648618e-01f, 3.95480901e-01f,
  2.25165576e-01f, -1.50671527e-01f, -1.18342794e-01f, -3.30302268e-01f, 3.36709619e-01f, 9.75470543e-02f, 2.80576110e-01f, 1.03061266e-01f, -3.21237184e-02f, -2.38491312e-01f,
  9.93531570e-02f, 2.88889050e-01f, 2.61337936e-01f, 3.67451310e-01f, 5.35225213e-01f, -1.07716054e-01f, -5.99547982e-01f, 3.61542165e-01f, -3.22501808e-01f, -5.88257670e-01f,
  -1.50637209e-01f, -6.08708411e-02f, -2.90216357e-01f, -4.84990954e-01f, 4.26813662e-01f, -1.66805252e-01f, -2.82841295e-01f, -2.76933879e-01f, -2.10371509e-01f, 3.48611772e-01f,
  1.40847221e-01f, -4.34324533e-01f, -4.88079697e-01f, 5.06286502e-01f, 3.42025131e-01f, 1.13482609e-01f, -4.72636998e-01f, 4.49333042e-01f, -6.89729676e-02f, 2.45102599e-01f,
  -7.03621268e-01f, -1.79705799e-01f, 1.99748859e-01f, -2.18665689e-01f, 1.72115475e-01f, -2.84949780e-01f, 2.11643323e-01f, 3.71165901e-01f, -1.92496404e-01f, -4.18095626e-02f,
  -1.56660855e-01f, -2.63519466e-01f, -6.14479601e-01f, -1.46244332e-01f, 9.73190814e-02f, 2.21219599e-01f, 1.68497145e-01f, -3.06326479e-01f, 8.60790908e-02f, -2.29232118e-01f,
  2.62963593e-01f, -2.02999324e-01f, -2.95996815e-01f, -4.75675166e-02f, 1.72266662e-01f, -2.38214463e-01f, 4.51183200e-01f, 1.93104193e-01f, -3.79086375e-01f, -1.76961556e-01f,
  1.67726781e-02f, -4.82511967e-01f, 2.66692266e-02f, 3.73700517e-03f, 1.82813719e-01f, 2.50248104e-01f, -8.63261819e-02f, 2.23871738e-01f, -3.23459923e-01f, 1.50162559e-02f,
  -1.06354743e-01f, 1.35397896e-01f, -8.31656232e-02f, 6.84715927e-01f, -9.06816602e-01f, -9.18923989e-02f, -2.07563609e-01f, -4.78683300e-02f, -3.35880637e-01f, -2.81497687e-01f,
  1.61211879e-03f, -2.49398082e-01f, -2.80275464e-01f, -1.80055931e-01f, -1.27889723e-01f, -1.05730236e-01f, 1.30940685e-02f, -5.05975820e-02f, 1.07582405e-01f, -4.09724861e-01f,
  3.37151289e-01f, -1.70836478e-01f, -1.35296255e-01f, 2.81916529e-01f, -1.99735582e-01f, -1.59726024e-01f, 1.89817861e-01f, 1.87013671e-01f, -6.62277639e-02f, 5.23375273e-01f,
  2.71701068e-01f, -6.80016577e-02f, 5.39864898e-01f, -6.30924761e-01f, 1.74857602e-01f, -2.78757870e-01f, 1.11790478e-01f, 2.21404657e-02f, -3.26339990e-01f, 3.41826886e-01f,
  -2.78028369e-01f, -5.49434647e-02f, -3.52061421e-01f, 4.54398453e-01f, 4.26415280e-02f, -4.81963843e-01f, 2.50028580e-01f, 3.51608813e-01f, 2.59385228e-01f, -3.60039145e-01f,
  4.25193280e-01f, -5.49900718e-02f, 3.47590148e-01f, -5.94948649e-01f, 1.79012850e-01f, -1.27547666e-01f, 4.63928133e-01f, -2.75904983e-01f, 4.29540306e-01f, -1.30191311e-01f,
  5.44059038e-01f, 1.85491368e-01f, -9.37199295e-01f, 3.82510424e-01f, 2.76992237e-03f, 3.74782175e-01f, -2.76098996e-01f, -6.35015488e-01f, -6.60117209e-01f, 7.17685670e-02f,
  6.72791377e-02f, -7.19951913e-02f, 2.46448487e-01f, -1.57834124e-02f, 2.76914507e-01f, 2.94800907e-01f, -1.85989618e-01f, -1.67561382e-01f, -1.96324810e-01f, -2.83443034e-01f,
  6.70882538e-02f, 2.05390930e-01f, -2.70420700e-01f, 4.88328457e-01f, 2.64767930e-02f, 4.65545595e-01f, 2.81895071e-01f, -4.31196988e-01f, -3.41257900e-01f, 2.65923321e-01f,
  -4.68188167e-01f, -5.11380911e-01f, -5.13291359e-02f, -2.87935108e-01f, 1.82172805e-01f, -5.03855944e-01f, -4.01878744e-01f, -4.22152936e-01f, 5.61751842e-01f, -6.66655838e-01f,
  2.03836218e-01f, 5.09327948e-01f, 1.66818097e-01f, 1.69027194e-01f, 1.84649780e-01f, 4.46237177e-02f, -1.19496889e-01f, -3.48780781e-01f, 1.85563400e-01f, 2.60398239e-01f,
  -9.74410921e-02f, -4.45812196e-02f, 9.63511644e-04f, 2.82810569e-01f, -2.30168864e-01f, 2.55497873e-01f, -1.85931399e-01f, 3.44558507e-01f, -3.52097392e-01f, -8.03828053e-03f,
  2.20298037e-01f, 3.43488380e-02f, -2.81617433e-01f, -4.57503319e-01f, -3.40450197e-01f, -6.39013171e-01f, 5.40714145e-01f, -5.87574422e-01f, 6.42037272e-01f, -9.20262411e-02f,
  -5.92002094e-01f, -7.09585786e-01f, 2.02896133e-01f, -4.89522628e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  3.20782885e-02f, 1.13789707e-01f, -1.49345607e-01f, -3.53681818e-02f, -7.12652039e-03f, -1.68189645e-01f, 1.31783977e-01f, 1.00915544e-02f, -1.47205219e-01f, 1.67768031e-01f,
  -9.57987532e-02f, 8.00295696e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    