/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.03279590e-02f, 3.49626616e-02f, 1.27006054e-01f, -7.68999979e-02f, -1.36217341e-01f, -1.50023010e-02f, -2.80246913e-01f, -5.42521290e-02f, -3.91614407e-01f, 4.86015761e-03f,
  -1.86822772e-01f, 3.05063337e-01f, -2.08356872e-01f, -7.41138356e-03f, 2.03865364e-01f, -1.93492070e-01f, 3.33953537e-02f, 6.59805015e-02f, -1.38566926e-01f, 5.80965020e-02f,
  2.18018633e-03f, -1.82932261e-02f, 1.41144514e-01f, -2.95187440e-02f, 8.69789943e-02f, 9.95481759e-02f, 2.64588237e-01f, -1.40320390e-01f, 3.39369148e-01f, 1.20260544e-01f,
  -1.02039374e-01f, -7.56132007e-02f, 1.29164636e-01f, -2.94156978e-03f, -4.68862941e-03f, -6.35732636e-02f, 8.73343740e-03f, 1.23469699e-02f, -5.75655587e-02f, 2.13072598e-02f,
  -4.73745465e-02f, 2.84267087e-02f, -2.04151422e-02f, 1.97654329e-02f, -7.05645978e-03f, 7.31232762e-03f, 1.40623778e-01f, 2.27421001e-02f, 5.93087589e-03f, 1.05727918e-01f,
  7.13923648e-02f, 2.02674177e-02f, 2.60488484e-02f, -6.99278153e-03f, 9.09481794e-02f, -3.19177657e-02f, 1.29425749e-02f, 6.54989406e-02f, 7.60028064e-02f, 5.28294267e-03f,
  -1.57457236e-02f, -4.37232405e-02f, -4.67542522e-02f, -3.44748832e-02f, -2.92576849e-02f, -7.68244043e-02f, 2.36160904e-02f, -4.20325957e-02f, -3.45079452e-02f, -4.05456237e-02f,
  -7.74744898e-02f, 7.42780743e-04f, -5.35229258e-02f, -1.75877160e-03f, -3.11954189e-02f, -8.10715333e-02f, 1.08769862e-02f, -3.84500585e-02f, -6.42966181e-02f, 4.59323563e-02f,
  -7.26669133e-02f, -1.04860747e-02f, 3.42452750e-02f, -5.56542911e-02f, 8.41299631e-03f, -2.68684495e-02f, 2.82527227e-02f, -2.27720402e-02f, -2.29813624e-02f, -3.61160859e-02f,
  8.23658258e-02f, -7.85240252e-03f, -3.06641654e-04f, 3.51708569e-02f, 3.14666741e-02f, 8.61560330e-02f, -6.26327470e-03f, 6.66338503e-02f, -3.86581570e-02f, -7.96762183e-02f,
  8.97977650e-02f, -2.24257875e-02f, 6.71568066e-02f, 1.43906921e-02f, 5.76219819e-02f, 1.42574562e-02f, -4.31318209e-02f, 1.29122818e-02f, 1.53641477e-02f, 5.62024973e-02f,
  8.38049687e-03f, -2.09618211e-02f, -8.85110907e-03f, -9.45858937e-03f, -1.94429029e-02f, 1.67459492e-02f, -2.45840736e-02f, 4.07365561e-02f, -9.55096725e-03f, -4.20654565e-02f,
  1.10277809e-01f, 1.10629708e-01f, 3.39519590e-01f, 5.50580630e-03f, -7.95151889e-02f, 9.84530151e-02f, 1.25834167e-01f, 4.85806447e-03f, 2.55778521e-01f, -1.33467510e-01f,
  -8.64310712e-02f, 3.52334492e-02f, 1.06889673e-01f, -1.24868236e-01f, -7.12203234e-02f, 1.33676246e-01f, -1.94222376e-01f, -9.18067321e-02f, 1.30147889e-01f, -1.76759452e-01f,
  2.93826479e-02f, -3.90731096e-01f, 1.25893103e-02f, -1.09943725e-01f, -1.17629245e-01f, 6.55071810e-02f, -3.98831427e-01f, 1.15910560e-01f, -2.57292897e-01f, -1.76193360e-02f,
  -9.98319387e-02f, 1.31618276e-01f, 1.20717831e-01f, 8.10925961e-02f, -1.01223022e-01f, 1.23403911e-02f, -4.61641662e-02f, 6.79658055e-02f, 7.21538514e-02f, 2.67593786e-02f,
  2.31044106e-02f, -2.49340124e-02f, -1.67541094e-02f, 8.04584473e-02f, 8.14288557e-02f, 6.34157136e-02f, 3.98233943e-02f, 5.14488108e-02f, 1.95811316e-02f, 8.88369530e-02f,
  9.03598219e-02f, 2.75589470e-02f, 3.17592174e-02f, -1.60713866e-02f, 5.27837053e-02f, 4.91268598e-02f, 8.29260703e-03f, 2.44449899e-02f, -3.82311344e-02f, 2.11303867e-02f,
  4.70339842e-02f, -2.14959923e-02f, -1.41943982e-02f, -1.39109567e-02f, -2.52449289e-02f, -2.14331467e-02f, 8.41626525e-03f, -5.42169437e-02f, -6.61157584e-03f, -4.66114655e-02f,
  -2.88101099e-02f, -1.22212432e-02f, 3.97966690e-02f, 4.52567376e-02f, -6.66279495e-02f, 3.23030092e-02f, -3.47245820e-02f, -2.15238016e-02f, 6.03522779e-03f, 9.12651420e-04f,
  1.98840462e-02f, -1.04384935e-02f, -8.43805261e-03f, -2.11454239e-02f, 4.49154228e-02f, 2.25526262e-02f, 1.21418503e-04f, 7.42392763e-02f, 9.90485586e-03f, -8.83329213e-02f,
  -3.11547190e-01f, -2.70384610e-01f, 1.38690847e-03f, 5.45768254e-02f, -6.42733499e-02f, -3.88071202e-02f, -1.98126752e-02f, 2.12649908e-02f, -8.19372237e-02f, -1.33871036e-02f,
  8.35435931e-03f, 7.03088287e-03f, -8.18742141e-02f, 2.17816196e-04f, 1.27073452e-02f, -6.81624934e-03f, -9.28657129e-02f, -7.80657679e-02f, -5.93740493e-02f, -7.37466961e-02f,
  -5.23530878e-02f, -2.38785539e-02f, 1.04749864e-02f, -5.04717603e-02f, -1.90818384e-02f, -6.61492422e-02f, 6.70620706e-04f, 7.09252506e-02f, -4.54443246e-02f, -5.05770110e-02f,
  2.33610988e-01f, -2.56108791e-01f, 6.74042255e-02f, 1.64886445e-01f, 8.96034315e-02f, 1.20800555e-01f, 6.34035692e-02f, 8.70082974e-02f, -1.26426175e-01f, -2.61347800e-01f,
  1.39788523e-01f, -1.77800193e-01f, -1.28882810e-01f, 2.14884728e-01f, 4.92530257e-01f, -4.99970540e-02f, 2.16652483e-01f, 1.64946690e-02f, 1.15794828e-02f, 7.06509948e-02f,
  1.69236019e-01f, 1.47377536e-01f, 2.05360994e-01f, -2.05578115e-02f, 1.78183004e-01f, -2.62571555e-02f, 1.52679831e-01f, -1.07218750e-01f, 1.08503766e-01f, 3.68569307e-02f,
  1.06917895e-01f, -6.58020973e-02f, 1.63336862e-02f, -9.86493845e-03f, 8.02956149e-02f, -2.27224343e-02f, 4.26168032e-02f, 7.26776570e-02f, 4.47216071e-02f, -7.99769349e-03f,
  -1.20278886e-02f, 2.15877872e-02f, -7.12145632e-03f, 3.84112890e-03f, 2.23221779e-02f, 8.05995427e-03f, 4.75010648e-02f, 6.45398945e-02f, -6.90869763e-02f, 1.91805158e-02f,
  -3.55177261e-02f, 7.26269856e-02f, 9.13587287e-02f, -1.39709413e-02f, 4.86265272e-02f, 1.37297334e-02f, 7.37325009e-03f, 3.09047680e-02f, -5.70387617e-02f, 1.95044894e-02f,
  3.15207839e-02f, -3.86028253e-02f, -1.98482405e-02f, -6.09451579e-03f, 3.08534093e-02f, -1.06068002e-02f, 1.82367908e-03f, 4.02058139e-02f, -2.03278847e-02f, 4.81398590e-03f,
  -2.63682492e-02f, 2.66516414e-02f, -1.03847152e-02f, 3.43048573e-02f, 4.77699898e-02f, -1.08482111e-02f, 1.41695258e-03f, -5.16214147e-02f, -2.88498076e-03f, 7.07223043e-02f,
  1.29375455e-03f, -1.59476344e-02f, -3.97763811e-02f, 5.75261330e-03f, -1.47596747e-02f, 4.35033478e-02f, -2.92830914e-02f, -7.28476420e-03f, 2.65257270e-03f, 5.20077571e-02f,
  -1.44081498e-02f, -1.62206218e-01f, -7.63434172e-02f, -1.16390988e-01f, -4.12683636e-02f, 4.13260870e-02f, -2.26098186e-04f, -4.29348834e-03f, 4.98263957e-03f, 3.62486369e-03f,
  -1.79152489e-02f, -6.52386108e-03f, 3.74832414e-02f, 7.02089537e-03f, 1.64337512e-02f, -1.15570119e-02f, -6.06027432e-02f, -1.88521072e-02f, 5.09851910e-02f, 8.49841628e-03f,
  1.83046032e-02f, -3.03234980e-02f, 4.46298998e-03f, 5.62397167e-02f, 2.88568269e-02f, -8.26837029e-03f, -2.20025983e-02f, -5.64841591e-02f, 5.45516349e-02f, -7.99184293e-03f,
  8.28872323e-02f, -2.22160563e-01f, 1.79813415e-01f, 1.39809638e-01f, -1.09889239e-01f, 2.27385268e-01f, 2.44741619e-01f, -6.70323847e-03f, 8.99871346e-03f, -3.10466617e-01f,
  5.20380959e-02f, -8.40666518e-02f, 1.22051358e-01f, 5.33471368e-02f, 7.22281277e-01f, 2.17840791e-01f, 1.50920287e-01f, -3.72898318e-02f, 7.82788470e-02f, -4.52153869e-02f,
  7.46508241e-02f, -4.49809283e-02f, 2.19304875e-01f, -1.53136507e-01f, -1.35568112e-01f, -1.56999335e-01f, 1.22304074e-02f, -3.11456192e-02f, -7.09728599e-02f, 8.22679624e-02f,
  5.97943887e-02f, -1.22976661e-01f, -1.98066123e-02f, -2.80674808e-02f, -8.25438835e-03f, -3.90447825e-02f, 9.89815872e-03f, 6.79227486e-02f, 8.38024616e-02f, -1.14880572e-03f,
  -4.62675877e-02f, -4.97516710e-03f, -2.60994323e-02f, 2.21251268e-02f, -8.05074573e-02f, 2.47831475e-02f, 1.99812790e-03f, -2.69616004e-02f, -4.95651625e-02f, 4.56500649e-02f,
  2.67413619e-04f, -2.15818323e-02f, -4.19624671e-02f, -6.16752990e-02f, 4.90823425e-02f, 3.16393338e-02f, 2.86082104e-02f, 2.92440169e-02f, -5.11581860e-02f, -2.60849185e-02f,
  -6.55011460e-02f, 8.82529188e-03f, 2.65403949e-02f, 8.08645855e-04f, 3.30104902e-02f, -1.79019198e-02f, 1.00489296e-02f, -4.00608107e-02f, 9.56057478e-03f, -5.91570232e-03f,
  3.30841020e-02f, -9.51013155e-03f, -5.53646497e-03f, -1.06858341e-02f, -2.42457222e-02f, -2.87815239e-02f, 1.40614407e-02f, -2.42770482e-02f, -1.49291586e-02f, 2.68546678e-02f,
  1.09490538e-02f, 3.97026390e-02f, -3.22345681e-02f, 1.75874233e-02f, 5.51142842e-02f, 2.36461274e-02f, -5.43146729e-02f, -2.72624213e-02f, -5.63911675e-03f, 7.43891075e-02f,
  2.67904229e-03f, -6.06226474e-02f, 3.51204872e-02f, -3.20768356e-02f, 1.53541071e-02f, 9.54604242e-03f, 1.98823661e-02f, -2.81811282e-02f, 1.15735075e-02f, 5.03606303e-03f,
  -3.00749950e-02f, -2.21459474e-03f, -6.13383390e-03f, -4.13770378e-02f, 3.88292037e-02f, 2.65957564e-02f, 7.80744990e-03f, -7.68134603e-03f, 2.34666597e-02f, -1.39258010e-02f,
  -2.77614649e-02f, -2.36303620e-02f, 7.69339576e-02f, -1.90213677e-02f, -2.77285632e-02f, -4.20593983e-03f, 4.82727867e-03f, -2.47773565e-02f, -3.91281355e-04f, -3.74473333e-02f,
  -7.42164627e-02f, 4.91957925e-03f, -2.69338965e-01f, -1.25368237e-01f, -3.46943170e-01f, -4.16270792e-01f, -2.37280443e-01f, -8.30393806e-02f, -3.74877870e-01f, 3.67323935e-01f,
  1.12828471e-01f, -5.11417873e-02f, 1.50084957e-01f, 6.34704251e-03f, -2.16911897e-01f, -9.83535647e-02f, -1.76248983e-01f, -1.03459090e-01f, -1.48667440e-01f, -3.60241868e-02f,
  -1.01661362e-01f, 1.02098502e-01f, -4.11167927e-03f, 1.34615287e-01f, -1.17214628e-01f, 8.72446150e-02f, 3.54835957e-01f, -5.31098694e-02f, 1.92088827e-01f, -1.26312926e-01f,
  -1.45278528e-01f, -8.80542397e-02f, 6.31438121e-02f, 6.64561335e-03f, 8.76228139e-03f, -1.97748467e-02f, -1.26943672e-02f, -1.72497220e-02f, -3.19324024e-02f, -8.32857750e-03f,
  6.71851560e-02f, -4.37233113e-02f, 4.92438860e-02f, -6.46961033e-02f, -1.06513157e-01f, 4.47935797e-02f, -9.34201255e-02f, -1.42181115e-02f, -3.99290100e-02f, -1.62984863e-01f,
  -9.25225988e-02f, -8.32998231e-02f, -6.99840784e-02f, -6.42948151e-02f, -1.91849303e-02f, -3.17209847e-02f, -5.73988184e-02f, -4.28815596e-02f, -6.08136654e-02f, -6.02242164e-02f,
  -2.72296369e-02f, -6.50641918e-02f, 1.65215768e-02f, 2.28644814e-02f, -4.79008583e-03f, 8.52105990e-02f, 6.14413584e-04f, 4.39778268e-02f, -6.90989848e-03f, 1.57616921e-02f,
  -5.30038541e-03f, 3.40500623e-02f, -4.83104698e-02f, -1.07496465e-02f, 4.57502492e-02f, 2.36349963e-02f, 1.20474203e-02f, 3.03231217e-02f, -2.17216611e-02f, 2.59568468e-02f,
  -1.97478253e-02f, -4.27455595e-03f, 7.33806342e-02f, 2.33843122e-02f, -3.36263441e-02f, -1.86906867e-02f, 1.99026391e-02f, -3.18253785e-02f, 1.07076382e-02f, -1.00636799e-02f,
  -4.13591117e-02f, 1.59562886e-01f, 6.79898486e-02f, 2.37256009e-02f, 5.23703881e-02f, 4.77812216e-02f, -4.62995097e-02f, -1.88325923e-02f, -2.28989683e-02f, 1.92402527e-02f,
  -1.59263462e-02f, 7.74034783e-02f, -4.31169122e-02f, -1.01543451e-02f, 4.22340557e-02f, 8.25035945e-03f, 6.85548633e-02f, -2.30725240e-02f, -5.05145965e-03f, 6.00333214e-02f,
  6.54434040e-02f, 2.41412185e-02f, 2.20862571e-02f, 3.98142748e-02f, 5.81069812e-02f, 4.35313992e-02f, 6.25660866e-02f, -5.55938594e-02f, 2.91812290e-02f, -2.02421751e-02f,
  5.39671659e-01f, -1.99609905e-01f, 1.72298700e-01f, 1.45873800e-01f, 1.49291053e-01f, -5.01336753e-01f, -2.19551310e-01f, 2.03749947e-02f, 1.22982159e-01f, -2.09038094e-01f,
  -9.59869325e-02f, 1.13539793e-01f, -1.69953316e-01f, -2.60295272e-01f, -2.58663327e-01f, -2.37283379e-01f, -2.99990863e-01f, -1.07045695e-01f, 9.89367515e-02f, 5.18398136e-02f,
  6.14198018e-03f, -3.03943634e-01f, -7.67642036e-02f, -9.00469348e-02f, 1.37187149e-02f, 1.60473093e-01f, 2.55333562e-03f, 9.20931324e-02f, -1.15785629e-01f, -1.19178720e-01f,
  7.72577673e-02f, 2.17953935e-01f, 9.42377374e-02f, 5.19125015e-02f, 1.01956911e-02f, 7.45086595e-02f, 5.04815914e-02f, 1.27043976e-02f, 6.92001358e-02f, -2.79173665e-02f,
  1.82511266e-02f, 1.03216367e-02f, -4.14694473e-02f, -6.49329796e-02f, 2.15170030e-02f, 7.49490261e-02f, -6.89834729e-02f, -1.99750226e-04f, -4.40401927e-04f, -1.52275441e-02f,
  -1.98550448e-02f, -1.95050053e-02f, -1.54907629e-02f, -9.39802378e-02f, -1.63871218e-02f, -5.80815272e-03f, 9.26817767e-03f, -7.20016798e-03f, -6.03969358e-02f, -7.80604081e-03f,
  1.09686879e-02f, 7.88546056e-02f, 6.53200271e-03f, 2.31667552e-02f, 2.21334603e-02f, 7.71994442e-02f, -3.65168862e-02f, 1.24354111e-02f, 6.20508082e-02f, -3.98222506e-02f,
  -7.59462919e-03f, 8.44324082e-02f, 1.50282672e-02f, -2.18262263e-02f, -8.09753314e-03f, 6.69290200e-02f, 1.72304939e-02f, -3.65512026e-03f, -1.17142955e-02f, -1.73660903e-03f,
  2.79403204e-04f, -4.51082624e-02f, 1.55393621e-02f, 1.91567279e-03f, -6.81799650e-02f, -8.47797003e-03f, -1.68525539e-02f, -9.01380461e-03f, 3.17760557e-02f, -1.91755649e-02f,
  -1.14257865e-01f, -1.07935108e-01f, -1.33498176e-03f, -2.93295272e-02f, -1.60649791e-02f, -5.42966649e-02f, -6.43474460e-02f, -3.28058712e-02f, -9.10790116e-02f, 1.19854519e-02f,
  -1.39510101e-02f, 3.36746536e-02f, 9.00146179e-03f, 2.00283388e-03f, -8.49455222e-02f, -7.33918548e-02f, 3.27504613e-02f, 9.95009541e-05f, -5.50589226e-02f, -1.82416998e-02f,
  -1.07845329e-02f, -2.85256598e-02f, 3.61547582e-02f, 5.14981411e-02f, 3.39053199e-02f, -9.33504198e-03f, 7.04251155e-02f, 2.64790617e-02f, -3.36335301e-02f, -2.13533593e-03f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.05145180e-01f, 1.85999855e-01f, 2.40763873e-01f, -4.69945163e-01f, 9.71615966e-03f, 1.69655457e-01f, -1.19324684e-01f, -1.52772777e-02f, -2.06047088e-01f, 3.16731036e-01f,
  7.70490617e-02f, -2.39708066e-01f, 3.22522521e-01f, -1.86377205e-03f, -3.02563965e-01f, 2.67594904e-01f, 1.41637903e-02f, -4.62566465e-02f, -4.23030443e-02f, -2.16122016e-01f,
  -7.68389553e-02f, -1.06746987e-01f, 1.68956041e-01f, 1.33321658e-01f, -3.34178396e-02f, -6.86703920e-02f, -6.17788583e-02f, 5.50440773e-02f, -2.54217144e-02f, -7.15638548e-02f,
  -4.82321717e-02f, -1.14137456e-01f, 1.48146912e-01f, 1.00810647e-01f, 9.16278958e-02f, 5.06286360e-02f, 5.75037524e-02f, 1.00406267e-01f, -3.15644331e-02f, 1.56694967e-02f,
  7.99714867e-03f, 5.14988936e-02f, -4.50726077e-02f, -6.14973344e-02f, -2.60554664e-02f, 1.90680642e-02f, 3.38920243e-02f, 4.40242440e-02f, -1.11353258e-03f, 2.56116856e-02f,
  3.83023359e-02f, 5.86482622e-02f, 4.73731011e-02f, 9.18693561e-03f, 1.00346068e-02f, 3.68744582e-02f, 9.05391052e-02f, -4.63393517e-02f, -2.30977703e-02f, -8.17500278e-02f,
  7.96451047e-02f, 3.02166532e-04f, 5.38800545e-02f, -1.21876765e-02f, -6.49845079e-02f, 4.06783819e-02f, -3.13862413e-02f, 1.07312687e-02f, -3.93847860e-02f, -2.22860258e-02f,
  6.08294178e-03f, 1.28695173e-02f, -2.70697977e-02f, 6.79366365e-02f, -7.49900611e-03f, 2.11379826e-02f, -1.29338419e-02f, 8.75946973e-03f, -3.84378061e-02f, -2.59173829e-02f,
  4.63281125e-02f, -6.61599785e-02f, 3.75219584e-02f, 3.23640592e-02f, 4.31006514e-02f, -1.16722807e-02f, 4.65652086e-02f, 4.24089842e-02f, 7.47171044e-02f, -8.41296613e-02f,
  -1.54847771e-01f, -3.24819952e-01f, 7.35681737e-03f, -7.63636678e-02f, 2.24892925e-02f, 8.54903907e-02f, 4.11437564e-02f, -3.96167077e-02f, -8.42371583e-02f, -3.45747136e-02f,
  -2.27681138e-02f, -1.75100546e-02f, -4.00953814e-02f, -2.38942746e-02f, 1.22034852e-03f, 3.85254212e-02f, -3.14351320e-02f, 1.35622201e-02f, -9.01045725e-02f, -3.11907697e-02f,
  -1.83606632e-02f, -5.29937707e-02f, 5.76366438e-03f, 3.99616025e-02f, 7.66296219e-03f, -4.54960614e-02f, -1.55195862e-01f, -2.99096610e-02f, -7.61168599e-02f, 5.15186787e-02f,
  2.85097361e-01f, -3.76882926e-02f, -4.05171305e-01f, -3.03077489e-01f, 2.55699068e-01f, 2.62088507e-01f, 3.90255563e-02f, -1.23029677e-02f, -7.66653419e-02f, 1.94765195e-01f,
  2.06412822e-01f, -1.93029031e-01f, -6.47249818e-02f, -7.36751407e-02f, -3.40368487e-02f, -1.13758996e-01f, 1.22180797e-01f, 6.81909099e-02f, -7.49571472e-02f, 1.41663104e-01f,
  3.67764197e-02f, 2.26211116e-01f, -2.49240384e-01f, 5.64193353e-02f, 1.52159527e-01f, -9.13487002e-02f, 6.80465847e-02f, -8.54776949e-02f, 3.90097499e-02f, -1.13189854e-01f,
  -3.15877572e-02f, 4.28103283e-03f, -1.61551852e-02f, -6.57345951e-02f, 1.51833668e-01f, 1.35522485e-01f, -2.57229228e-02f, -1.55920107e-02f, -6.55984208e-02f, -2.26373281e-02f,
  8.75957906e-02f, -6.06066585e-02f, 4.75271456e-02f, -2.97253150e-02f, 1.89593714e-02f, -6.33573765e-03f, -1.12689696e-01f, 4.96583357e-02f, -1.20397605e-01f, -2.68258527e-02f,
  -8.37110654e-02f, 3.59429158e-02f, -3.37468227e-03f, -6.97333664e-02f, -7.65707642e-02f, 1.77038985e-03f, -5.85184619e-02f, 7.56473839e-02f, 6.60934113e-03f, 6.99786469e-02f,
  2.06503853e-01f, 8.84754881e-02f, 4.34129983e-02f, -8.83386284e-03f, -4.84888963e-02f, -1.13085732e-02f, -9.61907282e-02f, 2.51132925e-03f, -3.99330445e-02f, 1.76704712e-02f,
  1.37660317e-02f, -2.00316571e-02f, -2.88702659e-02f, 1.22842286e-02f, 1.04474556e-02f, 4.78255562e-02f, 6.72756787e-03f, 3.18912044e-02f, 6.79394454e-02f, -1.59020107e-02f,
  -9.62766111e-02f, 7.62055144e-02f, -3.69648798e-03f, -1.21423872e-02f, -7.76510611e-02f, -3.53718847e-02f, 9.49850902e-02f, 3.60338874e-02f, -3.77587527e-02f, 5.64690381e-02f,
  5.32933162e-04f, 1.85659230e-01f, -2.87269112e-02f, -9.58734080e-02f, 1.28240017e-02f, 1.27555430e-01f, -5.63051142e-02f, -7.38701522e-02f, -1.03931855e-02f, 3.10944170e-02f,
  1.47737890e-01f, -1.82071812e-02f, 4.11583707e-02f, -8.63806680e-02f, -8.81351829e-02f, 2.17826724e-01f, 5.51452488e-03f, -7.52917528e-02f, -3.06567922e-02f, 1.94091797e-02f,
  7.84720033e-02f, 7.90457353e-02f, 7.09559247e-02f, -1.20985601e-02f, -3.70672867e-02f, 1.05843335e-01f, 7.20726922e-02f, 5.23871705e-02f, 2.12923530e-02f, -7.13321343e-02f,
  1.63882419e-01f, -8.46676230e-01f, -3.67652804e-01f, 1.95723921e-01f, 5.18437386e-01f, 1.72762096e-01f, 7.49504706e-03f, 6.15564398e-02f, -2.18374699e-01f, -3.07907552e-01f,
  1.95542257e-02f, -3.52941215e-01f, -6.41596973e-01f, 1.00079060e-01f, 1.62029743e-01f, -5.01786411e-01f, 1.64821655e-01f, 2.53053084e-02f, -1.37177050e-01f, -4.59898375e-02f,
  2.28965864e-01f, 3.70619893e-01f, -1.89661309e-02f, 2.56802142e-01f, 2.37887621e-01f, 1.53042540e-01f, 1.99324921e-01f, -9.35524851e-02f, 3.56341988e-01f, 1.38314992e-01f,
  3.18004750e-02f, -1.15276508e-01f, -1.04231779e-02f, -3.78552489e-02f, 2.55054478e-02f, 1.33486703e-01f, 2.30578966e-02f, 8.81840587e-02f, 2.47515701e-02f, -8.05346221e-02f,
  -2.71777064e-02f, 9.62598175e-02f, 8.12031254e-02f, 3.19697075e-02f, 8.95256698e-02f, 3.85909341e-02f, -1.75624453e-02f, -5.98257631e-02f, -2.66340487e-02f, -1.66582137e-01f,
  -1.73188195e-01f, -4.34716903e-02f, 3.45788361e-03f, 4.02519740e-02f, -1.07727699e-01f, 2.49284822e-02f, 5.60614765e-02f, -6.11578859e-02f, -1.32046463e-02f, 3.60053256e-02f,
  3.56256850e-02f, -4.19559190e-03f, -6.77831098e-02f, -1.16706663e-03f, -8.82909168e-03f, 1.69397760e-02f, 2.34917868e-02f, -8.77329633e-02f, -4.46393862e-02f, 3.63280065e-02f,
  5.03795259e-02f, -4.05780561e-02f, -4.14340961e-04f, 5.30943759e-02f, 3.62017192e-02f, 5.77866137e-02f, 2.56532766e-02f, -2.88012624e-02f, 1.22610386e-03f, -3.74452993e-02f,
  -3.51332389e-02f, 8.27779025e-02f, 1.96907446e-02f, 3.65667529e-02f, -3.66823487e-02f, -5.48905768e-02f, 7.00476114e-03f, -1.00347504e-01f, 3.09130996e-02f, 4.72591482e-02f,
  -6.50480986e-02f, -3.19906443e-01f, -6.30693659e-02f, 4.97215018e-02f, -1.09501421e-01f, 3.39955427e-02f, -6.68236613e-02f, -3.51587050e-02f, -2.03251243e-02f, 6.64981781e-03f,
  1.23428531e-01f, 6.35781363e-02f, 8.92726984e-03f, -3.77718499e-03f, 1.22936722e-02f, -1.22194169e-02f, 4.22983430e-03f, 6.65360913e-02f, 1.52038574e-01f, 1.59234814e-02f,
  -1.24635268e-02f, -2.70461012e-02f, -9.69097763e-03f, 1.31135538e-01f, 9.42822099e-02f, 5.14795519e-02f, 6.97715729e-02f, 2.54039299e-02f, 8.28468613e-03f, -3.22851166e-02f,
  3.14426273e-01f, -3.80143821e-01f, 7.98792094e-02f, 8.84347968e-03f, 1.20003673e-03f, 1.29778728e-01f, 5.78761935e-01f, -4.22916085e-01f, -2.65340745e-01f, -2.81905949e-01f,
  1.07466131e-02f, 1.83028102e-01f, 2.52376527e-01f, -1.59100652e-01f, 4.99688685e-01f, 1.50198400e-01f, -2.03598082e-01f, 9.98978540e-02f, -1.36470437e-01f, -5.79829386e-04f,
  -7.26259202e-02f, -6.99616373e-02f, 7.00596794e-02f, -4.26937193e-01f, -2.23476607e-02f, -1.69760063e-01f, -3.25860791e-02f, 2.26486325e-01f, -1.62409097e-01f, 1.85419858e-01f,
  -5.42218350e-02f, -5.53348511e-02f, -3.70572098e-02f, -3.38391960e-02f, -1.73918752e-03f, 7.15598091e-02f, 1.17014967e-01f, 2.75097400e-01f, 1.33322012e-02f, -4.50974330e-02f,
  1.18451230e-01f, 1.67785808e-02f, -1.33440748e-01f, 6.79009780e-02f, 6.46420231e-04f, -1.59020826e-01f, -4.35400940e-02f, -1.06577352e-01f, -2.59694029e-02f, 4.92170975e-02f,
  -1.74031425e-02f, -2.93653663e-02f, -8.57114419e-03f, -3.73034626e-02f, 2.23658420e-02f, -8.33842680e-02f, 3.94659899e-02f, 1.44946143e-01f, -1.02033697e-01f, -3.79863381e-02f,
  7.77496174e-02f, -4.11211252e-02f, 8.78268182e-02f, -3.73027809e-02f, 2.91938242e-02f, -3.83479595e-02f, 1.32374866e-02f, -2.55695414e-02f, -5.11085764e-02f, 5.86695075e-02f,
  -2.27666870e-02f, -5.43105602e-02f, 1.45949132e-04f, -2.60294732e-02f, 5.15285581e-02f, 7.17072114e-02f, 1.45399660e-01f, -2.11103354e-02f, -4.18187380e-02f, -3.84245664e-02f,
  1.59281604e-02f, 1.74260791e-03f, 7.14335963e-03f, -4.05546091e-02f, -1.13344053e-02f, 3.11716413e-03f, -9.29055735e-03f, 8.11611302e-04f, -1.74610596e-02f, 1.17393941e-01f,
  -1.18388481e-01f, 5.50652072e-02f, -5.54330088e-02f, -7.33212978e-02f, -1.06252961e-01f, -9.54633504e-02f, -2.62089092e-02f, -2.12720428e-02f, 4.08279561e-02f, 1.29669216e-02f,
  -4.31849174e-02f, 1.71590317e-03f, 2.12363470e-02f, -6.26037940e-02f, 4.34140712e-02f, -7.45681748e-02f, 3.65349501e-02f, 2.58274060e-02f, -2.57971156e-02f, -1.09271333e-01f,
  4.45298031e-02f, 1.12384465e-02f, 3.41080464e-02f, -2.14849086e-03f, -9.18807387e-02f, 7.75220320e-02f, -8.03936124e-02f, -7.96419904e-02f, 2.47255545e-02f, -1.63127817e-02f,
  -1.45358786e-01f, 2.06843138e-01f, -2.80220926e-01f, -3.15880664e-02f, -9.51898564e-03f, 1.25850886e-01f, 9.86880362e-02f, 1.70661211e-01f, -5.02400957e-02f, 2.73391545e-01f,
  2.56932825e-01f, 3.42784934e-02f, 9.73095819e-02f, 4.73325364e-02f, -1.30748600e-01f, -6.92271516e-02f, 1.33783534e-01f, 9.63164493e-02f, -8.78223926e-02f, 2.37762466e-01f,
  -8.25542398e-03f, 2.32288867e-01f, -2.76758969e-01f, 1.33948356e-01f, 8.87709931e-02f, -5.09164156e-03f, 7.82356411e-02f, -1.45414937e-03f, -1.69326011e-02f, -3.04646641e-02f,
  -3.04774977e-02f, 2.10098773e-02f, -8.55157673e-02f, -7.84179047e-02f, 9.56230313e-02f, -3.01311202e-02f, 2.64751632e-02f, -6.12819828e-02f, -6.12207204e-02f, -5.61553724e-02f,
  1.17577970e-01f, 7.53556192e-02f, -7.99820051e-02f, -2.26015858e-02f, 1.45983929e-03f, -3.49852182e-02f, -2.61550061e-02f, -9.77572724e-02f, 7.07544712e-03f, 3.96811329e-02f,
  -1.38352215e-01f, -5.01039885e-02f, 7.40267038e-02f, 4.35737632e-02f, -4.74379994e-02f, -6.53257314e-03f, 9.28791519e-03f, -6.88134208e-02f, 6.57284856e-02f, 3.43834795e-02f,
  5.13030961e-02f, 6.82084337e-02f, 3.15226475e-03f, -5.90790622e-03f, 2.32001748e-02f, -3.53422128e-02f, 6.50623590e-02f, -1.09094167e-02f, 4.89445142e-02f, 5.29166721e-02f,
  -9.75830629e-02f, -5.57184108e-02f, -3.86773720e-02f, 8.24147910e-02f, 1.69411558e-03f, -7.59955216e-03f, -2.72167623e-02f, -2.46459320e-02f, -1.03865284e-02f, -1.12305380e-01f,
  2.87120901e-02f, -1.48438588e-02f, 3.30317244e-02f, -5.30198775e-02f, 3.05668684e-03f, 6.26696646e-02f, 3.67766395e-02f, -5.19546978e-02f, 3.81391421e-02f, 3.19638383e-03f,
  1.57064691e-01f, 3.07236403e-01f, 7.10072815e-02f, 8.88399500e-03f, -4.99603674e-02f, 5.57030588e-02f, 1.03447111e-02f, 2.62092892e-03f, -3.58050503e-02f, 4.07733731e-02f,
  9.18558836e-02f, -5.45038879e-02f, 8.24886039e-02f, -6.02878891e-02f, -1.45024424e-02f, 9.63375196e-02f, 7.24802092e-02f, -3.54013704e-02f, 1.29126951e-01f, -2.11299788e-02f,
  6.15613684e-02f, 1.10872410e-01f, -8.07836000e-03f, 8.35323557e-02f, 2.64311302e-02f, 3.49582992e-02f, 6.16970286e-02f, -6.30809441e-02f, -3.97161394e-02f, 1.69040542e-02f,
  6.69247285e-02f, -8.37051645e-02f, -2.18323290e-01f, -1.79244518e-01f, -1.95652917e-01f, -2.68236995e-01f, -2.83715427e-01f, -2.29547307e-01f, 5.88621907e-02f, -9.88484025e-02f,
  -2.04291567e-01f, 1.51588619e-01f, 1.75976261e-01f, -3.56035858e-01f, 3.39292139e-01f, 2.27825463e-01f, -2.27891386e-01f, -8.55565220e-02f, 2.61248574e-02f, -1.77247316e-01f,
  9.16106906e-03f, -1.18303448e-01f, -8.92127827e-02f, -2.23677218e-01f, -3.31916422e-01f, -8.75838622e-02f, 9.12155285e-02f, -2.72873849e-01f, -3.86322707e-01f, -1.38252407e-01f,
  -2.48089105e-01f, -4.19207253e-02f, -4.13858816e-02f, -6.59339875e-02f, -1.09991230e-01f, 3.22598666e-02f, -6.55696243e-02f, 2.57068817e-02f, -2.99240127e-02f, 3.69955413e-02f,
  4.89687957e-02f, -2.13384777e-02f, -4.06946838e-02f, 8.61349329e-02f, -4.91478667e-02f, -3.54462937e-02f, -5.42441718e-02f, 5.00226356e-02f, -2.86184973e-03f, -6.19179979e-02f,
  -1.43495901e-02f, -5.24029098e-02f, -7.73967104e-03f, 4.45209332e-02f, -2.17168909e-02f, -9.57781300e-02f, 5.74544594e-02f, -1.25539489e-02f, 2.70128716e-03f, -2.71148086e-02f,
  6.48112968e-02f, 9.43504050e-02f, -1.09463833e-01f, -5.71818054e-02f, 6.64885491e-02f, -1.24024525e-02f, 3.97728048e-02f, 5.45261102e-03f, 4.35592495e-02f, -4.36052382e-02f,
  -1.45731391e-02f, 9.00619477e-03f, -2.94506643e-02f, 6.44515678e-02f, 1.50309978e-02f, 3.18901539e-02f, -3.17018330e-02f, 2.48869639e-02f, -1.64920799e-02f, -2.14180462e-02f,
  2.36321278e-02f, -1.27734514e-02f, -5.29681593e-02f, 2.69296318e-02f, 6.26258254e-02f, 9.09044743e-02f, -6.72618449e-02f, -3.53107229e-02f, 4.27889749e-02f, -1.76031142e-03f,
  -6.10136874e-02f, 9.76433828e-02f, -6.40776157e-02f, 4.93625626e-02f, 6.78595901e-02f, 3.33577842e-02f, -2.70975605e-02f, -9.41198841e-02f, 7.79843405e-02f, 6.41979873e-02f,
  -1.94392148e-02f, 3.62052731e-02f, -5.21851878e-04f, 4.48423326e-02f, -5.35416454e-02f, -1.78461690e-02f, 6.30223304e-02f, 8.09946507e-02f, 5.23508973e-02f, 3.36019322e-02f,
  2.18197033e-02f, 4.31158245e-02f, 2.82632876e-02f, 9.86558422e-02f, 2.85443384e-02f, 3.93741317e-02f, 3.21098492e-02f, 8.53527188e-02f, 4.40217517e-02f, -3.40715386e-02f,
  -1.90872550e-01f, 8.98397863e-02f, 1.52527347e-01f, 5.37391901e-02f, 9.48690623e-03f, -2.53860056e-01f, -1.57073900e-01f, 7.99890384e-02f, -1.46055417e-02f, 4.25093882e-02f,
  -3.51052918e-02f, -4.44497615e-02f, -6.15783669e-02f, 1.07872069e-01f, -1.22604765e-01f, 1.08247716e-02f, -9.47487652e-02f, -1.18718244e-01f, 6.98589385e-02f, 1.30248457e-01f,
  6.20364584e-02f, 8.49422216e-02f, 2.06495747e-01f, 2.47609809e-01f, 9.57507044e-02f, 1.79933697e-01f, 1.12167954e-01f, 1.13737412e-01f, 1.12423413e-01f, 1.83642022e-02f,
  -1.13943353e-01f, 5.00653349e-02f, 4.68755141e-03f, -9.31837112e-02f, 4.14682217e-02f, -1.20136710e-02f, 4.96187545e-02f, -4.65105064e-02f, 3.37020606e-02f, 3.96459224e-03f,
  -6.93410188e-02f, -1.21476278e-02f, 2.56873276e-02f, -3.32013369e-02f, -1.00415856e-01f, -1.78314336e-02f, 3.42519842e-02f, -7.35480636e-02f, -5.24957944e-03f, 9.90446657e-03f,
  -1.65266339e-02f, -4.84281480e-02f, -5.73482700e-02f, -5.10016158e-02f, -6.93479031e-02f, 3.60856876e-02f, -4.75903489e-02f, 2.02776329e-03f, -1.84463821e-02f, 2.13947650e-02f,
  -4.71705422e-02f, 6.21835403e-02f, 3.51032652e-02f, -3.96705456e-02f, 9.07079577e-02f, -1.89562272e-02f, -1.63500123e-02f, -6.40847087e-02f, -4.72056568e-02f, -8.88923034e-02f,
  -3.98160145e-02f, 2.01780759e-02f, -4.33162712e-02f, 6.48059091e-03f, -1.43864192e-02f, 5.24199195e-02f, 2.12837197e-02f, -9.75284949e-02f, -2.55951248e-02f, -3.28116789e-02f,
  7.07727373e-02f, 3.70683670e-02f, 7.45669007e-03f, -6.55804724e-02f, 2.19920408e-02f, 4.76629548e-02f, 2.90074921e-03f, -7.68991187e-02f, 7.54453391e-02f, 8.76377970e-02f,
  -1.42985448e-01f, 1.10484794e-01f, 1.25283366e-02f, -5.39668538e-02f, 4.07207198e-03f, -9.43911299e-02f, -5.04346751e-02f, 5.20496331e-02f, 4.25047837e-02f, 2.49747448e-02f,
  1.60641168e-04f, -1.48626575e-02f, 4.37306017e-02f, -2.90370733e-02f, 1.04922049e-01f, 4.16793264e-02f, -3.48891802e-02f, -8.37879181e-02f, -8.28964915e-03f, 1.05746247e-01f,
  1.09629624e-01f, -5.71653759e-03f, 5.67638651e-02f, -9.30525213e-02f, -7.86802266e-03f, 3.66439931e-02f, -3.42239179e-02f, 2.46897265e-02f, 8.78301263e-02f, 2.69922856e-02f,
  -9.54314694e-02f, -2.14663316e-02f, -5.85551634e-02f, 1.43975884e-01f, 7.03791752e-02f, -2.39515945e-01f, -2.44274452e-01f, 3.89422514e-02f, -2.16119081e-01f, 1.75884441e-02f,
  8.58704373e-02f, -1.96521491e-01f, -1.62051752e-01f, -1.62358403e-01f, 1.85793173e-02f, -2.37325937e-01f, 8.47303197e-02f, -5.96410483e-02f, -1.55767798e-01f, 1.77758113e-01f,
  1.09926261e-01f, 1.30692154e-01f, 1.00547977e-01f, 1.91291004e-01f, 3.98486592e-02f, 3.29604477e-01f, 4.67400581e-01f, 1.71907932e-01f, 3.12529504e-01f, -2.30018571e-02f,
  -1.16934158e-01f, 1.88401993e-02f, -3.09091676e-02f, -1.20515786e-01f, 1.38735488e-01f, 1.07451841e-01f, 9.76106375e-02f, 9.53360274e-03f, 5.01808971e-02f, -1.60051808e-02f,
  -6.16496205e-02f, -4.46367040e-02f, -4.80592400e-02f, -8.41103843e-04f, -8.91431642e-04f, 4.19021919e-02f, 5.12081943e-02f, 4.17255312e-02f, 3.32251973e-02f, 2.68866848e-02f,
  -3.79279926e-02f, -3.94667126e-02f, 2.04863716e-02f, 1.82656627e-02f, 1.84196942e-02f, -5.78734390e-02f, -3.02357469e-02f, 6.94123581e-02f, 3.16384844e-02f, -1.01943789e-02f,
  1.77996054e-01f, 2.26338804e-02f, -1.02340706e-01f, -1.07683346e-01f, -2.76860185e-02f, 1.70598067e-02f, 5.60584627e-02f, 4.56455760e-02f, -3.85467242e-03f, 2.71954145e-02f,
  6.15964048e-02f, -4.51755570e-03f, -2.50988379e-02f, -1.91533323e-02f, 8.99417624e-02f, -8.40508416e-02f, 8.55019167e-02f, 1.62014868e-02f, 7.15682283e-02f, -2.28484534e-02f,
  3.33303958e-02f, -4.38113622e-02f, -2.03961749e-02f, 2.36324482e-02f, -1.92659870e-02f, 7.33654620e-03f, 4.43396606e-02f, 1.27682439e-03f, -3.41870375e-02f, 3.92395677e-03f,
  1.01863809e-01f, 3.26141238e-01f, 1.67773310e-02f, -6.10827208e-02f, -3.94476205e-02f, 1.41242789e-02f, -9.23446044e-02f, -2.66983937e-02f, 7.50182196e-02f, 7.99137540e-03f,
  9.79052410e-02f, 8.21121857e-02f, -3.06079406e-02f, -2.26373915e-02f, 3.06393113e-02f, 5.26467301e-02f, 8.33714008e-02f, 6.07519522e-02f, 9.95605486e-04f, 6.94589987e-02f,
  4.19789627e-02f, 5.63542731e-02f, -6.45697303e-03f, 1.00800628e-02f, 7.50403926e-02f, -1.60390045e-02f, 1.85237937e-02f, 4.67483364e-02f, 1.49369892e-02f, -1.51170706e-02f,
  8.21889266e-02f, -2.65280493e-02f, 3.10901523e-01f, 1.32540882e-01f, 1.31460577e-01f, -3.87575924e-02f, 2.87523735e-02f, 2.35500291e-01f, 1.67494684e-01f, -2.77962297e-01f,
  -1.31148204e-01f, -1.45924643e-01f, -1.30622357e-01f, 2.91311238e-02f, 1.27212062e-01f, 1.00396879e-01f, 1.26420498e-01f, -3.46767604e-02f, 2.60027945e-01f, 1.05799809e-01f,
  2.36274511e-01f, -1.86641552e-02f, 2.87199438e-01f, 9.46923122e-02f, 1.00946672e-01f, 1.07448891e-01f, -1.15651488e-01f, -1.47175975e-02f, -9.73172039e-02f, -5.16059250e-02f,
  3.80896255e-02f, 1.94991425e-01f, 1.63551658e-01f, -3.44437361e-02f, 4.39424589e-02f, -1.05356976e-01f, -1.24652453e-01f, -1.52463272e-01f, 9.23965275e-02f, 2.46233456e-02f,
  -7.32520521e-02f, -4.46705632e-02f, -2.71946397e-02f, -9.79164708e-03f, -1.12264855e-02f, 3.43141519e-02f, 6.36846870e-02f, 1.08747177e-01f, 6.72709271e-02f, -1.15614273e-02f,
  8.12178478e-03f, 8.88301730e-02f, 1.58095628e-01f, 1.70630366e-02f, 7.44366199e-02f, 1.53091568e-02f, -7.50016645e-02f, -4.35813423e-03f, 5.26086725e-02f, 5.80851845e-02f,
  1.06217615e-01f, -8.53186846e-02f, -3.63105349e-02f, -3.56997922e-02f, 5.40584736e-02f, 3.16200033e-02f, 6.81492761e-02f, -1.02716967e-01f, 3.01317703e-02f, -5.74382916e-02f,
  -7.45093524e-02f, -4.81524505e-02f, -3.95956961e-03f, -6.08785003e-02f, -5.53748831e-02f, -4.33010943e-02f, 4.47226241e-02f, -1.01955822e-02f, 1.23666018e-01f, 2.06316691e-02f,
  -1.18465543e-01f, 3.07655185e-02f, -1.73439961e-02f, -3.69251929e-02f, 1.32193333e-02f, -2.86594033e-02f, -8.55737552e-03f, -4.72397693e-02f, 5.17110750e-02f, -8.52760822e-02f,
  -3.63001674e-02f, -8.76680464e-02f, 1.06515056e-02f, -4.02706210e-03f, -6.31455854e-02f, -1.08180940e-02f, -3.81615013e-02f, 2.62414925e-02f, 4.62919399e-02f, 2.47283876e-02f,
  3.89829837e-02f, -8.44827965e-02f, 1.73381865e-02f, -5.60602546e-03f, 6.93239048e-02f, 1.97231993e-02f, -1.66166928e-02f, -1.23770550e-01f, -6.46829158e-02f, -2.28389483e-02f,
  3.57113369e-02f, -8.33073929e-02f, -5.32612652e-02f, 3.41014862e-02f, -3.53358872e-03f, -4.16504368e-02f, -1.55563373e-02f, -1.05976537e-02f, -4.43514287e-02f, 2.22557373e-02f,
  7.34634399e-02f, 5.42463005e-01f, 5.96438527e-01f, 4.29666787e-01f, -3.14880133e-01f, -4.27319467e-01f, -1.69936404e-01f, 1.22699298e-01f, 7.57121220e-02f, -3.43955457e-02f,
  -1.42791808e-01f, 4.22803044e-01f, 4.72742319e-03f, 6.43962100e-02f, -9.19270143e-02f, -1.65281519e-01f, 6.93443716e-02f, -6.08327724e-02f, -5.18274633e-03f, 2.84507513e-01f,
  1.54985026e-01f, -1.61120087e-01f, 3.25141549e-01f, 2.14656647e-02f, 1.85870498e-01f, 3.23348969e-01f, 5.10698482e-02f, 6.24952056e-02f, 2.42836788e-01f, -8.69282410e-02f,
  -5.92546947e-02f, 6.96191192e-02f, 1.76088244e-01f, 8.13959464e-02f, 1.33574083e-02f, 6.95447810e-03f, -2.12225481e-03f, -3.87480371e-02f, -4.06566635e-02f, -4.19902653e-02f,
  4.94312868e-02f, 4.68660966e-02f, 4.98071797e-02f, -3.49695459e-02f, -1.92338321e-02f, 1.12876303e-01f, 5.46446480e-02f, 1.36637703e-01f, 1.06613606e-01f, 7.85513148e-02f,
  1.35384664e-01f, 7.43956119e-02f, 3.66315395e-02f, 1.33120209e-01f, 1.12532146e-01f, 2.03370955e-02f, 9.49128345e-03f, 9.53451991e-02f, 3.48102562e-02f, 1.02105506e-01f,
  2.63900254e-02f, -1.54016718e-01f, -7.35695735e-02f, -9.59862303e-03f, -9.15701464e-02f, 6.63293479e-03f, -3.24261151e-02f, -2.22144034e-02f, -4.14036140e-02f, 1.87689289e-02f,
  2.35752631e-02f, 3.70291658e-02f, -4.11963798e-02f, 1.70559611e-03f, -8.25638510e-03f, 6.26890920e-03f, -5.75256944e-02f, -7.55643006e-03f, 5.43019809e-02f, 4.22376022e-02f,
  3.32494034e-03f, -1.66452620e-02f, 1.87696831e-03f, 2.59576067e-02f, -1.11771919e-01f, 2.62673143e-02f, 4.57413197e-02f, 4.06358540e-02f, 1.69645548e-02f, 3.33845243e-02f,
  5.18193729e-02f, 4.06866848e-01f, 7.46618286e-02f, -2.08126754e-02f, -1.84661560e-02f, -1.23596810e-01f, -2.90038586e-02f, 9.21387225e-02f, 1.48315713e-01f, 4.82595852e-03f,
  2.47660261e-02f, -6.19495362e-02f, 7.51630822e-03f, 3.68293077e-02f, -1.35666849e-02f, 5.62558360e-02f, 3.12555358e-02f, 2.20700242e-02f, 8.56907442e-02f, 9.77773741e-02f,
  2.28879787e-02f, -8.13124999e-02f, -9.08377115e-03f, 2.38779020e-02f, -5.13721295e-02f, 6.08645976e-02f, -1.57345291e-02f, 9.69967768e-02f, 1.40187293e-01f, 6.05579503e-02f,
  -3.38059545e-01f, 2.59322315e-01f, -2.36048400e-01f, 1.48540527e-01f, -3.60264629e-01f, 2.24864647e-01f, 2.96092689e-01f, -2.16599833e-02f, 2.74450243e-01f, 3.84771049e-01f,
  1.89023768e-03f, 6.18792884e-02f, 9.84794721e-02f, 2.69188046e-01f, 1.76745802e-02f, 3.10414225e-01f, 3.36257368e-01f, 3.31665486e-01f, 2.48448011e-02f, -4.95027266e-02f,
  -8.14863518e-02f, 1.17761664e-01f, -1.12875715e-01f, -1.36330679e-01f, -1.18655667e-01f, -1.99047342e-01f, -6.46287873e-02f, -1.70427561e-01f, 7.68732429e-02f, -8.49760994e-02f,
  3.84821333e-02f, -1.04844764e-01f, -7.89015442e-02f, -3.89489979e-02f, -7.48778209e-02f, -4.97725420e-03f, 1.77017320e-02f, -4.57314262e-03f, -3.43072489e-02f, -2.93539967e-02f,
  -3.83773148e-02f, -6.90752938e-02f, 4.76892404e-02f, -2.74586789e-02f, 4.06185649e-02f, -2.59609129e-02f, -5.93963377e-02f, -2.62444206e-02f, -1.20774778e-02f, -1.84237212e-01f,
  -8.24072510e-02f, -2.80559678e-02f, -4.43969294e-02f, 4.71120030e-02f, -5.85513040e-02f, 3.07736937e-02f, 5.15800081e-02f, -6.77993288e-03f, 1.80463661e-02f, -1.21566430e-02f,
  9.46562663e-02f, -2.09028963e-02f, -1.68787614e-02f, -6.38908744e-02f, -1.34185711e-02f, -3.73752452e-02f, 1.00971591e-02f, -6.61080778e-02f, -8.13012570e-02f, 6.55923085e-03f,
  -1.18123526e-02f, -5.89358099e-02f, -6.66476926e-03f, 1.39237866e-02f, -4.70075815e-04f, 1.86890941e-02f, 2.11010966e-02f, -4.47700266e-04f, 4.62969691e-02f, -1.89460851e-02f,
  2.92448159e-02f, -2.46428419e-02f, -4.64233011e-03f, 4.30515260e-02f, 5.69335930e-02f, -1.89516954e-02f, 1.68149024e-02f, 2.41245539e-03f, 3.93271958e-03f, -3.64044607e-02f,
  1.14798188e-01f, 2.56793231e-01f, -1.90748386e-02f, 1.70137957e-02f, 7.74902776e-02f, -3.23459543e-02f, 7.65184090e-02f, -7.55849481e-02f, 7.75901750e-02f, 1.68883316e-02f,
  -6.68213740e-02f, -3.39490036e-03f, 5.37170097e-02f, -3.54191773e-02f, 4.75585125e-02f, 2.97840945e-02f, -1.28450280e-03f, 4.19268198e-02f, 4.61870208e-02f, -3.27364430e-02f,
  -3.98501940e-02f, 4.39652428e-02f, -2.43836008e-02f, 1.13323946e-02f, 6.34435788e-02f, -1.48482816e-02f, -4.96308785e-03f, -4.21879999e-02f, -8.06885492e-03f, 9.16308165e-02f,
  -2.73792654e-01f, -2.81806756e-02f, -1.62418514e-01f, -3.27835053e-01f, 2.70712793e-01f, -1.16416611e-01f, -4.06005010e-02f, 1.78766519e-01f, -2.44927853e-02f, 1.98803857e-01f,
  5.89556098e-02f, -1.68101504e-01f, 1.14630856e-01f, -4.75870639e-01f, -6.00499272e-01f, -3.22538912e-01f, -3.17916602e-01f, -2.53433913e-01f, -8.80845860e-02f, -8.70002359e-02f,
  -1.81378663e-01f, 6.82975864e-03f, -2.15007931e-01f, 3.56148690e-01f, 3.87930893e-03f, 1.83212191e-01f, 1.04570441e-01f, 2.89849818e-01f, -1.93576738e-02f, -1.31072872e-03f,
  -7.44035691e-02f, 3.94310476e-03f, 1.06530368e-01f, -1.79001968e-02f, 9.79866385e-02f, 8.96950066e-03f, 7.57179931e-02f, 2.48882156e-02f, 1.27479006e-02f, -6.53003156e-02f,
  -4.86103818e-03f, -4.80809361e-02f, -6.78201839e-02f, 1.27084374e-01f, 8.19192529e-02f, -1.30613502e-02f, -3.07792425e-02f, -9.14839969e-04f, 7.16263354e-02f, -1.07782176e-02f,
  -1.99092389e-03f, -8.21976438e-02f, 2.91724410e-02f, -5.40481247e-02f, -3.87000516e-02f, 9.58681107e-02f, -5.01083359e-02f, -7.88591877e-02f, 3.32165286e-02f, -5.89717552e-02f,
  2.04132292e-02f, 1.54269598e-02f, -3.40783149e-02f, 1.37654319e-02f, 3.01688183e-02f, -3.35598104e-02f, -4.67746742e-02f, 4.52712514e-02f, 1.13871228e-02f, 2.31710356e-02f,
  -3.64991054e-02f, 6.15643337e-02f, 5.76077066e-02f, -7.94895366e-02f, 2.00774148e-02f, 9.16248653e-03f, -5.77276759e-03f, 2.61858739e-02f, -6.60519749e-02f, 3.45017277e-02f,
  7.02513084e-02f, -3.50511484e-02f, 3.72257531e-02f, -2.12864727e-02f, -6.38658106e-02f, 4.18608412e-02f, 4.74593081e-02f, -3.80179510e-02f, 3.95719074e-02f, 4.08095568e-02f,
  1.81974173e-02f, 4.57530208e-02f, 4.03868034e-02f, 4.24478576e-02f, -4.09076735e-02f, 7.26203024e-02f, -9.53746364e-02f, -4.26560082e-02f, 1.92371793e-02f, -2.96199247e-02f,
  4.74897865e-03f, -2.04977463e-03f, -1.84599552e-02f, 1.28946565e-02f, -8.41922965e-03f, 5.97405732e-02f, -2.42749825e-02f, 6.24396540e-02f, 7.77432397e-02f, 2.34674700e-02f,
  8.92169029e-02f, 4.70929146e-02f, -7.98965693e-02f, 8.92363340e-02f, 8.26461613e-03f, 2.70931814e-02f, 6.08727261e-02f, 4.50211801e-02f, 1.16768051e-02f, -5.94066978e-02f,
  -6.99995339e-01f, 4.81466740e-01f, 1.33163810e-01f, -3.43897492e-01f, 9.34220180e-02f, -4.13831957e-02f, -4.70682643e-02f, 8.44767913e-02f, -2.29988247e-01f, -9.16694701e-02f,
  8.56609419e-02f, -1.05363242e-01f, 2.75531441e-01f, -6.71093315e-02f, -1.37172952e-01f, 2.07025319e-01f, -3.38639438e-01f, -2.60581911e-01f, 1.00225769e-01f, -1.39420003e-01f,
  -1.92579329e-01f, -6.93802163e-03f, 5.90472817e-02f, 2.22645119e-01f, -1.58980742e-01f, -9.59718153e-02f, -1.63650215e-01f, 2.67004162e-01f, -7.29816779e-02f, 1.05095685e-01f,
  -2.30691656e-01f, -2.48405203e-01f, -2.15880543e-01f, -1.26440182e-01f, -2.21570551e-01f, -1.34123966e-01f, -1.09859981e-01f, 4.16368060e-03f, -9.13089588e-02f, -3.13635692e-02f,
  -7.75626227e-02f, 2.80707721e-02f, -4.65318486e-02f, 6.55662343e-02f, -2.57845204e-02f, -3.97160910e-02f, 1.37859732e-01f, 2.47673430e-02f, 8.79679099e-02f, 1.08359374e-01f,
  9.91360843e-02f, -1.86131895e-02f, -8.70614499e-02f, -9.49316770e-02f, -2.46808622e-02f, 1.85841031e-03f, -6.50548860e-02f, 3.42615172e-02f, -9.91135016e-02f, -6.69563143e-03f,
  -6.38808087e-02f, -7.55203068e-02f, -4.31075087e-03f, 8.38908134e-04f, -3.76492031e-02f, 7.10064545e-02f, -2.53770836e-02f, -6.24030270e-02f, -4.14206693e-03f, 5.40079325e-02f,
  -5.97100519e-02f, -1.01837248e-01f, -2.07081772e-02f, -5.60373664e-02f, -4.25986685e-02f, -8.78348872e-02f, 3.74512724e-03f, -2.64623314e-02f, -5.01742493e-03f, 9.34457785e-05f,
  1.17457090e-02f, -2.87267063e-02f, 2.13558041e-03f, -5.73280407e-03f, -2.08480004e-02f, 5.01586543e-03f, 7.35701760e-03f, 4.95999381e-02f, -1.27925910e-02f, -2.66293716e-02f,
  -4.06985283e-01f, -4.62613493e-01f, -5.82290851e-02f, -9.57585871e-02f, -6.87351450e-02f, -4.75682206e-02f, -6.70971349e-02f, -7.73116872e-02f, -2.68146824e-02f, 7.02753244e-03f,
  -5.28399833e-02f, -6.50032759e-02f, -5.45069985e-02f, -3.74695435e-02f, 1.00643784e-02f, -2.50907633e-02f, -9.26705599e-02f, -1.08861744e-01f, -1.15065284e-01f, -2.73267683e-02f,
  -8.12069178e-02f, -3.36230397e-02f, 3.39637771e-02f, -2.53462302e-03f, -1.58546165e-01f, -6.66545406e-02f, -4.95230108e-02f, -5.81777804e-02f, 6.28210977e-03f, 4.15732600e-02f,
  2.80980378e-01f, -1.27841696e-01f, -2.25795478e-01f, -2.27561861e-01f, -1.43566534e-01f, -3.67105603e-01f, -3.52009863e-01f, 3.62361334e-02f, 1.14784345e-01f, 1.52530625e-01f,
  1.14792496e-01f, -5.69881983e-02f, 1.99230447e-01f, -3.49760503e-02f, -3.40409614e-02f, 3.18214625e-01f, -1.79242924e-01f, -5.34282764e-03f, -7.07930280e-03f, -1.69060469e-01f,
  3.31233889e-02f, -2.84996293e-02f, -4.25241254e-02f, -5.40693998e-02f, -3.03117633e-02f, 2.64017750e-02f, 9.27027464e-02f, -8.58657435e-02f, -8.73040482e-02f, -3.25041749e-02f,
  1.49283901e-01f, 2.09128484e-01f, 1.79409180e-02f, 7.26186484e-02f, -7.16838390e-02f, -5.77934943e-02f, -9.57673341e-02f, 1.36521682e-02f, -6.20112754e-03f, -3.14799547e-02f,
  -7.79740959e-02f, 3.61628830e-02f, -7.76560903e-02f, 1.71114728e-02f, 3.42821777e-02f, 5.38082235e-02f, 1.03126056e-02f, -4.74565178e-02f, -8.16082060e-02f, 1.00447260e-01f,
  -1.02010936e-01f, 3.42404358e-02f, -1.12277381e-02f, -5.55414408e-02f, -1.52476598e-02f, 2.83463858e-02f, 1.93792079e-02f, -1.71333458e-02f, -7.01718777e-02f, 2.32333951e-02f,
  1.05006164e-02f, -2.69738007e-02f, 2.42829043e-02f, 5.04665412e-02f, 1.06299361e-02f, 1.95257515e-02f, -3.15379389e-02f, -6.84910491e-02f, -2.07579229e-02f, -7.69792274e-02f,
  -9.32878479e-02f, -1.64545141e-02f, 1.31244389e-02f, 5.14275953e-02f, 2.04528831e-02f, 2.28625014e-02f, -8.40766914e-03f, -3.17923799e-02f, -5.98828383e-02f, 2.55445354e-02f,
  9.47126448e-02f, -3.60663864e-04f, 9.07807145e-03f, -2.63702143e-02f, 2.05322262e-02f, -8.49807411e-02f, 1.37879914e-02f, 2.05335002e-02f, -3.21645997e-02f, -4.88581881e-02f,
  -7.42919976e-03f, 5.94147518e-02f, 4.87706847e-02f, 4.56942357e-02f, -7.37381652e-02f, -8.06089118e-02f, 4.49258164e-02f, -3.59160416e-02f, -9.47548449e-03f, 5.31798899e-02f,
  -5.03577590e-02f, -3.12897144e-03f, 2.61013545e-02f, 7.39854798e-02f, -2.50692163e-02f, -7.89430663e-02f, -7.19041824e-02f, -4.51835729e-02f, -2.88737118e-02f, -1.21905461e-01f,
  -2.24234853e-02f, -6.92970157e-02f, -9.16263759e-02f, -1.01196375e-02f, -1.32190540e-01f, -9.20251608e-02f, -5.86479567e-02f, -6.01517446e-02f, -2.76277289e-02f, -6.06665947e-02f,
  1.75984338e-01f, 2.94929773e-01f, 9.32263136e-02f, 1.37448430e-01f, -8.90101865e-02f, 1.05910450e-01f, -4.34848294e-02f, -1.29557252e-01f, -9.78610218e-02f, 2.02380955e-01f,
  -4.69814688e-02f, 2.50951439e-01f, -9.49147046e-02f, 1.76871363e-02f, -1.65381059e-01f, -1.69943944e-01f, 1.45316124e-01f, 8.34946111e-02f, -3.93124558e-02f, 2.00508162e-01f,
  -3.26716006e-02f, -9.83973742e-02f, -1.07317895e-01f, -7.35464366e-03f, 2.04751119e-01f, 1.01265855e-01f, -2.37559602e-02f, -1.88687101e-01f, 1.33174673e-01f, -3.30514237e-02f,
  -7.32060000e-02f, -9.86373518e-03f, 5.86637482e-02f, 7.92287961e-02f, 5.50119542e-02f, 1.20810568e-01f, -6.98534725e-03f, -1.34643510e-01f, -5.04729198e-03f, 2.67317612e-02f,
  1.20326430e-01f, -4.69715670e-02f, 5.63305393e-02f, -4.78750467e-02f, -3.54866013e-02f, 2.80671325e-02f, 9.42884982e-02f, -2.01031975e-02f, 8.51780176e-02f, 1.07737109e-01f,
  6.28997982e-02f, 5.28625287e-02f, 8.01010728e-02f, 4.09757271e-02f, -5.11039346e-02f, 6.05533682e-02f, 1.10605791e-01f, 2.32163090e-02f, 1.12118572e-01f, -2.51746643e-02f,
  1.79229286e-02f, -4.55634929e-02f, -7.11365119e-02f, -9.80845988e-02f, 1.07272360e-02f, 2.97925174e-02f, 3.73584079e-03f, 1.53488517e-02f, -5.94431572e-02f, 5.92255667e-02f,
  4.82413284e-02f, -4.20476869e-02f, 1.18190488e-02f, 5.58936074e-02f, 8.28680471e-02f, -4.22304049e-02f, -3.70290875e-02f, 2.83405390e-02f, 5.37690371e-02f, -5.52680790e-02f,
  2.15973221e-02f, -4.80624139e-02f, 6.26247004e-02f, 2.64310576e-02f, 1.42812431e-02f, -7.00443238e-02f, 6.51561767e-02f, 1.19478470e-02f, -8.69725570e-02f, -1.18058026e-02f,
  5.71621209e-02f, 4.56840917e-02f, 3.59048061e-02f, -5.65970503e-02f, 1.08918711e-03f, 7.58800656e-02f, -3.53883840e-02f, -4.39224467e-02f, 9.07823667e-02f, 6.25460893e-02f,
  1.10920109e-01f, -4.95936163e-02f, -1.60584264e-02f, -2.28658393e-02f, -2.89148968e-02f, 5.38613508e-03f, -3.79066095e-02f, 5.41064255e-02f, 1.05198905e-01f, 5.06311245e-02f,
  6.89423457e-02f, 7.05344453e-02f, -1.80493332e-02f, -1.67195164e-02f, 5.10977290e-04f, -1.22015383e-02f, 1.52611256e-01f, 9.27619785e-02f, -6.86055375e-03f, 7.24892393e-02f,
  1.25857577e-01f, 1.99544251e-01f, 4.60249819e-02f, 2.34242052e-01f, -1.35139480e-01f, 4.69691455e-02f, 1.95709065e-01f, 8.43658894e-02f, 6.47612393e-01f, 7.02252313e-02f,
  -3.19149315e-01f, 1.61518142e-01f, -1.59865156e-01f, -8.27114061e-02f, 2.31832623e-01f, 6.78944960e-02f, 1.83383495e-01f, 6.93182573e-02f, 2.40402982e-01f, 4.14592996e-02f,
  4.27122936e-02f, -1.23851396e-01f, -1.94174916e-01f, -2.45775864e-01f, -2.83164799e-01f, 2.29026992e-02f, -3.13374013e-01f, -1.03344992e-01f, -2.58023351e-01f, -9.67894197e-02f,
  -7.27198124e-02f, 1.03809364e-01f, -1.67479098e-01f, -2.29334235e-02f, 6.27976134e-02f, -6.10096641e-02f, -7.82830864e-02f, -2.81402301e-02f, 2.64380425e-02f, 7.82857910e-02f,
  9.47848260e-02f, 2.30643107e-03f, 5.80614395e-02f, -6.98372722e-02f, 6.17262945e-02f, 4.54735905e-02f, -1.43946651e-02f, -8.86015072e-02f, 9.70600825e-03f, -1.09620921e-01f,
  -1.47774788e-02f, 6.57118333e-04f, 1.31862061e-02f, 3.58502418e-02f, 3.16333026e-02f, 6.32971674e-02f, 3.00980508e-02f, 7.76196783e-03f, -1.83666181e-02f, 1.30350024e-01f,
  4.81029749e-02f, 8.46985504e-02f, -2.79600155e-02f, -3.54840420e-02f, -7.71844387e-02f, -5.86993173e-02f, -5.44264205e-02f, 2.24377122e-02f, 8.92961994e-02f, -7.85996858e-03f,
  2.59532388e-02f, -2.37437580e-02f, 9.47793797e-02f, -2.76059993e-02f, 3.53529453e-02f, 5.37011772e-02f, -9.50165093e-02f, -4.25658934e-03f, 3.64094004e-02f, -2.84888167e-02f,
  -6.57752603e-02f, 7.71024898e-02f, -9.51413363e-02f, -9.99884158e-02f, -2.24931650e-02f, -6.05044775e-02f, 4.22820635e-02f, -1.50524192e-02f, -4.01654094e-03f, -6.65859133e-02f,
  1.88151717e-01f, 3.65370542e-01f, 9.09623876e-02f, -5.57649918e-02f, 7.75596574e-02f, -3.41566168e-02f, 5.30028455e-02f, -1.80530902e-02f, 1.31787419e-01f, 2.71107387e-02f,
  9.72013362e-03f, 5.05166613e-02f, 1.23878028e-02f, -2.18926463e-02f, 8.34955499e-02f, -7.28613883e-02f, 9.84513462e-02f, 8.68849307e-02f, 2.95236968e-02f, -8.07240233e-03f,
  -6.01532720e-02f, 3.03694122e-02f, 8.24084878e-02f, 3.06754783e-02f, -1.06578683e-02f, 1.14150550e-02f, 5.47998585e-02f, -6.53315037e-02f, -3.01460568e-02f, 1.10661842e-01f,
  5.84918439e-01f, -3.99046689e-02f, 1.63941935e-01f, 5.24469733e-01f, 2.15210661e-01f, -7.71066025e-02f, 5.21195121e-03f, 2.27846056e-01f, 5.33611953e-01f, -9.97298583e-02f,
  -3.81385535e-02f, 2.30199218e-01f, -4.12657261e-01f, 2.08875433e-01f, -3.25420767e-01f, -2.58677304e-01f, 4.70769107e-02f, 2.46950146e-02f, 5.82705699e-02f, 1.91212878e-01f,
  1.86534107e-01f, -7.95076862e-02f, -1.65258825e-01f, -1.71932101e-01f, 2.27061898e-01f, 1.55246466e-01f, -2.66813755e-01f, -2.92471677e-01f, 5.26225492e-02f, -1.38570175e-01f,
  2.60925498e-02f, 1.45049438e-01f, 1.45711005e-02f, -1.00842724e-02f, -4.99902517e-02f, 6.42689168e-02f, -7.49785267e-03f, -1.03430592e-01f, 6.17820174e-02f, 2.13727616e-02f,
  5.61756175e-03f, 5.87575585e-02f, 1.40783116e-01f, -4.66123670e-02f, 1.46245152e-01f, 1.08083569e-01f, 6.86948895e-02f, 9.45597887e-02f, 7.91640058e-02f, 1.13276333e-01f,
  1.24534346e-01f, 6.91967085e-02f, 1.46331891e-01f, -1.05826519e-01f, 4.12567817e-02f, 4.53520268e-02f, -6.26926422e-02f, -8.43376890e-02f, -8.47618841e-03f, 9.37830135e-02f,
  -5.95724955e-02f, -7.69435987e-02f, -1.26796868e-02f, 6.87519386e-02f, -6.54757628e-03f, 8.75109155e-03f, -3.96131203e-02f, -8.44685808e-02f, 1.05454465e-02f, -4.15204614e-02f,
  7.29088411e-02f, 9.32833403e-02f, 1.02229724e-02f, 4.46209237e-02f, 5.06054498e-02f, 4.04007733e-02f, -4.38366421e-02f, 4.32784259e-02f, 1.70752276e-02f, 7.83947557e-02f,
  -4.29521240e-02f, -2.34216843e-02f, -4.23602909e-02f, 5.12804091e-02f, -2.70838290e-02f, -5.45994639e-02f, 4.33846898e-02f, 6.45627752e-02f, 3.93262170e-02f, -3.06760967e-02f,
  -2.25857124e-01f, -3.06634426e-01f, -6.47526756e-02f, -2.95042265e-02f, -3.89561541e-02f, -4.24958329e-04f, 4.51679230e-02f, 7.40902275e-02f, -1.43127233e-01f, 4.40147296e-02f,
  4.44188807e-03f, 4.65045311e-02f, -1.96149703e-02f, -2.80148238e-02f, -8.51288289e-02f, 4.92459536e-02f, -7.30866417e-02f, -4.42024246e-02f, -9.67207924e-02f, -4.83698472e-02f,
  -1.07251257e-02f, -5.08537814e-02f, -5.55507466e-02f, 1.50063023e-01f, 2.16271989e-02f, -3.00952625e-02f, 1.25837829e-02f, -7.15148225e-02f, -4.90894206e-02f, -8.56861100e-02f,
  -7.75332898e-02f, -1.35786071e-01f, 4.10047174e-02f, -1.47839680e-01f, -1.52109908e-02f, -5.23382099e-03f, -1.39083833e-01f, -4.29222509e-02f, -1.10951290e-01f, -1.84004560e-01f,
  -2.37928391e-01f, -9.01606083e-02f, 5.15858792e-02f, -2.75239557e-01f, 3.09104294e-01f, 2.15073645e-01f, -9.73122343e-02f, 7.93136284e-03f, -1.83082521e-02f, -2.74324417e-01f,
  -3.99014875e-02f, -3.74265105e-01f, 3.02400943e-02f, -1.91321269e-01f, -3.45085114e-01f, -1.09106310e-01f, 9.63748768e-02f, -9.43234097e-03f, -1.52984172e-01f, 3.64770964e-02f,
  -1.72217116e-01f, -1.91796660e-01f, -1.73758924e-01f, 4.55119535e-02f, -4.18763701e-03f, -6.38354495e-02f, 1.22681953e-01f, -1.21462150e-02f, 4.22796467e-03f, -6.32640943e-02f,
  4.64374498e-02f, -2.34266650e-02f, -3.27704735e-02f, 2.89028026e-02f, -5.33379018e-02f, -3.78909819e-02f, -2.86087058e-02f, -3.76332775e-02f, 1.67712215e-02f, 7.55877374e-03f,
  -2.83747073e-02f, 7.03963935e-02f, -3.21903825e-02f, 2.01945957e-02f, 6.66147619e-02f, 3.19080567e-03f, 6.63223267e-02f, 3.51616405e-02f, -2.36908365e-02f, -1.91416070e-02f,
  2.61130575e-02f, 1.72490049e-02f, -5.05960099e-02f, -2.83652861e-02f, -1.02054723e-01f, -2.41280422e-02f, -1.12708304e-02f, 1.80368908e-02f, 1.25651238e-02f, -3.28393211e-03f,
  -3.23502943e-02f, -7.89213646e-03f, -1.71707571e-02f, 6.23609200e-02f, -7.00147972e-02f, -4.55940366e-02f, 7.05948621e-02f, 1.98972858e-02f, -3.06341499e-02f, 6.02463521e-02f,
  -1.08478358e-02f, 5.92566915e-02f, 2.26559788e-02f, 4.31896970e-02f, -2.24727299e-02f, 9.66378674e-02f, 5.68654388e-02f, 3.90613638e-02f, -4.51762341e-02f, 1.02185465e-01f,
  -7.32911378e-02f, -1.03297651e-01f, -9.12585557e-02f, -8.36465657e-02f, 7.36488923e-02f, -4.23014052e-02f, 4.89039458e-02f, -1.07003255e-02f, -3.82871032e-02f, -1.18047938e-01f,
  -1.07682152e-02f, -3.00300140e-02f, -3.98294702e-02f, -3.92335802e-02f, 8.12531039e-02f, -5.60463183e-02f, -6.57863915e-03f, -1.58651173e-02f, -1.74272917e-02f, 6.62183911e-02f,
  -2.62786895e-02f, 3.02537922e-02f, 7.05037266e-02f, 7.88411796e-02f, 5.46938106e-02f, 2.10573431e-02f, -1.23289144e-02f, -4.24161814e-02f, 1.04550771e-01f, 1.76219959e-02f,
  -1.51858807e-01f, 2.58329093e-01f, -4.01427865e-01f, 1.04643414e-02f, 8.73169452e-02f, 2.35019773e-01f, 9.58753377e-02f, 1.68304250e-01f, -1.09445244e-01f, 3.22798073e-01f,
  2.42658511e-01f, -3.97988893e-02f, -1.15420073e-01f, 4.65167195e-01f, 1.63798898e-01f, 1.82944819e-01f, 4.36496228e-01f, 1.83174551e-01f, -1.11848605e-03f, 1.01200484e-01f,
  -4.80662240e-03f, 4.07516420e-01f, -9.49496403e-03f, 1.30669817e-01f, 1.72649071e-01f, -1.72975123e-01f, -1.38324182e-02f, -2.61084676e-01f, 2.99708456e-01f, 1.18091740e-01f,
  1.27289087e-01f, -6.03978857e-02f, -1.04070358e-01f, -8.24163184e-02f, -1.95040759e-02f, -3.14036310e-02f, -5.80951944e-02f, -1.03473164e-01f, -2.87525188e-02f, -2.78460723e-03f,
  -9.52012315e-02f, -5.94046861e-02f, 3.89012396e-02f, -3.09454799e-02f, 4.10220074e-03f, -4.33996879e-02f, -1.98888201e-02f, 5.02953865e-02f, -1.49616343e-03f, 7.58589879e-02f,
  -6.50357381e-02f, 7.60459248e-03f, -1.16999168e-02f, 1.17109772e-02f, 1.80002935e-02f, -1.94122568e-02f, -3.30036469e-02f, -4.22631167e-02f, -1.24230701e-02f, 8.82024840e-02f,
  1.16198547e-02f, -5.30115776e-02f, 3.39806154e-02f, -6.25166446e-02f, 3.70976813e-02f, -2.25329529e-02f, 8.29243511e-02f, -2.47399230e-02f, -2.15774290e-02f, 8.00298229e-02f,
  -7.00397277e-03f, 3.58771831e-02f, 1.94604564e-02f, 3.07232272e-02f, 5.59998415e-02f, 6.75522462e-02f, -2.19832733e-02f, 8.60532280e-03f, -7.77210966e-02f, -4.89250831e-02f,
  -3.58840190e-02f, 2.51833685e-02f, 1.19387461e-02f, -1.93644650e-02f, 5.12186773e-02f, 2.43433677e-02f, 1.28787411e-02f, 5.17579541e-02f, -2.91275680e-02f, -3.11035756e-03f,
  1.33486569e-01f, 1.65020406e-01f, 1.75162051e-02f, 4.06350307e-02f, -6.69909194e-02f, 8.78407434e-02f, 5.04030287e-03f, 8.26377869e-02f, -2.15895753e-02f, -5.14979027e-02f,
  -2.50707939e-02f, 1.27109028e-02f, 7.81147648e-03f, 9.23229977e-02f, 2.82642059e-02f, 5.84938712e-02f, 6.71120062e-02f, -8.74347389e-02f, -4.44245376e-02f, -1.30782239e-02f,
  -5.66665605e-02f, -4.23946641e-02f, -4.79102172e-02f, -4.33891080e-02f, 3.73206623e-02f, -2.80741253e-03f, 8.91987048e-03f, -8.10127035e-02f, 4.75380495e-02f, -4.28907946e-02f,
  -2.22723261e-01f, -4.27125208e-02f, 1.28193378e-01f, 1.00018546e-01f, -3.39859128e-01f, 1.57852769e-02f, 4.11156476e-01f, -3.86220932e-01f, -5.96518144e-02f, 2.03475058e-01f,
  2.12329075e-01f, -8.45613107e-02f, 1.43881634e-01f, 2.91383296e-01f, -1.60710916e-01f, 1.66226998e-01f, 1.91877767e-01f, 3.01604271e-01f, -9.76809785e-02f, -5.78893274e-02f,
  -5.93457595e-02f, -1.39207318e-01f, 2.06616595e-01f, -3.51415545e-01f, 3.19258906e-02f, -3.65381613e-02f, -1.20829530e-02f, -1.15390398e-01f, -3.70704941e-02f, -1.28016457e-01f,
  -5.99805005e-02f, -7.74445534e-02f, 5.46138734e-03f, -6.44463003e-02f, -3.10392063e-02f, 6.11648187e-02f, 1.58031769e-02f, -2.59537045e-02f, 4.16513681e-02f, -2.89316569e-02f,
  2.11018734e-02f, -1.25832066e-01f, -1.00950316e-01f, 2.50751693e-02f, -5.96758090e-02f, -6.80892840e-02f, -2.08724639e-03f, 1.04475982e-01f, 2.07376815e-02f, -2.26654112e-02f,
  8.49351063e-02f, -3.86981294e-03f, 1.63150311e-01f, 1.26395717e-01f, -8.22130311e-03f, -1.53081529e-02f, 5.49495518e-02f, 5.34301028e-02f, -7.21201152e-02f, -8.23995024e-02f,
  -9.32448953e-02f, 2.16654781e-02f, 3.13563645e-02f, 9.91431624e-03f, -1.96051430e-02f, 6.09684177e-02f, 5.08130342e-03f, 4.75364737e-02f, 3.80890816e-02f, -2.24157088e-02f,
  -3.79128344e-02f, -1.27843032e-02f, -2.01039799e-02f, 2.85732821e-02f, 1.36473840e-02f, 1.91643108e-02f, 2.43509766e-02f, -4.45160381e-02f, 9.41283926e-02f, 5.44471070e-02f,
  7.28272125e-02f, 6.37966162e-03f, -9.41834971e-03f, 8.52278396e-02f, 2.21253689e-02f, -3.01429890e-02f, 6.69353455e-02f, -2.11296231e-02f, 9.36060026e-02f, -4.20511700e-02f,
  -3.03922206e-01f, -3.40873241e-01f, -3.62060629e-02f, -4.24015708e-02f, 1.59259904e-02f, -4.78699207e-02f, -5.34657724e-02f, -8.17891136e-02f, -1.63779944e-01f, -4.89735603e-02f,
  8.34897533e-03f, 7.30594769e-02f, -8.74773040e-02f, 6.60671620e-03f, -3.33583765e-02f, -4.41911556e-02f, 1.75442975e-02f, -2.04425063e-02f, -8.26163217e-02f, -5.57332225e-02f,
  -3.69223244e-02f, -2.82542966e-03f, -2.79498585e-02f, -7.05088908e-03f, -7.04733422e-03f, 8.30116775e-03f, -1.24219477e-01f, 4.89243045e-02f, -7.73546770e-02f, 2.85439324e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  4.15173233e-01f, 2.05183625e-01f, 5.65979958e-01f, 3.17538857e-01f, 3.04379344e-01f, 9.57001671e-02f, 1.27297297e-01f, 1.79487959e-01f, 3.49687219e-01f, 3.29753071e-01f,
  2.25304812e-01f, 3.16990465e-01f, 2.96181142e-01f, 6.87994957e-02f, 2.22826228e-01f, 2.34314099e-01f, 3.93342078e-01f, 1.90003052e-01f, 1.97583586e-01f, 1.14749290e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  2.00994406e-02f, 2.79959947e-01f, 9.30797309e-02f, 2.61719257e-01f, 2.85037130e-01f, -4.46998924e-01f, -2.52839774e-01f, -2.97723681e-01f, 4.10416424e-02f, -3.82860340e-02f,
  6.49725139e-01f, -4.97157425e-02f, 6.72060549e-01f, 1.48061123e-02f, -4.24022555e-01f, -3.37794840e-01f, 2.03235507e-01f, -1.92048967e-01f, -6.66838363e-02f, -3.27833354e-01f,
  -1.18573301e-01f, -2.77580082e-01f, 6.54707670e-01f, -3.57775718e-01f, 5.83470352e-02f, 3.23739380e-01f, 6.02665963e-03f, -3.20944309e-01f, -3.66690397e-01f, -1.22519612e-01f,
  4.82861489e-01f, 8.92725468e-01f, 3.99397105e-01f, -3.77239525e-01f, -5.30351838e-03f, 5.45268595e-01f, 3.37719209e-02f, -5.08386672e-01f, 1.68768227e-01f, -7.48944700e-01f,
  4.87696767e-01f, 1.06276646e-01f, -1.00903340e-01f, -4.13534969e-01f, -4.34172750e-01f, 7.96586514e-01f, 1.50575474e-01f, 2.13694528e-01f, 4.10887748e-01f, -1.18623286e-01f,
  -2.61408657e-01f, -1.44741625e-01f, -1.26791462e-01f, -4.07656968e-01f, 2.16704145e-01f, -2.00466797e-01f, -2.91448116e-01f, 3.35129619e-01f, 2.99237967e-01f, -3.65543753e-01f,
  2.58540865e-02f, -2.85548806e-01f, 1.01231992e+00f, -3.94028544e-01f, -4.04451191e-02f, -2.46253490e-01f, -5.72993398e-01f, -1.86753049e-01f, 3.72638434e-01f, 2.08952799e-01f,
  4.72727239e-01f, -4.86691952e-01f, 2.07729608e-01f, 3.33045907e-02f, 1.00878932e-01f, -1.98115066e-01f, -2.28726521e-01f, -3.20699811e-01f, 1.33904922e+00f, -2.92593658e-01f,
  -3.67856503e-01f, -1.42730504e-01f, 1.49573520e-01f, 1.50842190e-01f, -3.06870136e-02f, -3.23235929e-01f, -4.74802777e-02f, -1.76728040e-01f, -3.43396604e-01f, -4.82983701e-02f,
  -3.79138552e-02f, -1.74860865e-01f, 7.52996728e-02f, 3.18311490e-02f, 2.66725957e-01f, -3.13634515e-01f, -5.68275116e-02f, 3.70171130e-01f, -5.94268441e-01f, -6.10816002e-01f,
  -1.67942539e-01f, 4.34315130e-02f, -3.16967010e-01f, 3.89840990e-01f, -2.02542856e-01f, -5.35775125e-01f, 5.91789424e-01f, 4.29918885e-01f, 3.97982985e-01f, -1.46918282e-01f,
  -5.94628096e-01f, -2.09280863e-01f, 1.66649520e-01f, -2.29830787e-01f, 3.08358014e-01f, -1.37242109e-01f, -2.78250694e-01f, -6.36788011e-02f, -2.10304126e-01f, 7.64697909e-01f,
  8.79464030e-01f, 3.06444287e-01f, -2.74710894e-01f, -1.38981625e-01f, -9.56687778e-02f, -3.36383253e-01f, -1.12925977e-01f, -2.17504874e-01f, 3.57820660e-01f, -3.27404380e-01f,
  3.66694152e-01f, 6.61769569e-01f, 2.83159822e-01f, 3.03901657e-02f, 4.53999192e-02f, 4.18320864e-01f, -6.89847320e-02f, 4.06171292e-01f, -8.12293470e-01f, -5.42261183e-01f,
  8.29079926e-01f, 1.39376268e-01f, -2.07591191e-01f, -3.07276130e-01f, -3.19863707e-01f, -3.14212799e-01f, 9.01846290e-02f, -1.64258093e-01f, 3.85706156e-01f, -1.60778705e-02f,
  -3.22650671e-01f, 6.31121397e-02f, 9.39894855e-01f, 1.73470601e-01f, -1.70367599e-01f, -2.43282616e-01f, -2.90296614e-01f, 3.12488943e-01f, 2.65210066e-02f, -1.97694495e-01f,
  -1.94160879e-01f, 4.06294256e-01f, 2.59191245e-01f, 4.57870185e-01f, -3.83794457e-01f, 2.06629530e-01f, -2.50713587e-01f, 2.90928423e-01f, -4.93497372e-01f, 3.53718668e-01f,
  -6.10647619e-01f, -7.29291618e-01f, -2.29804486e-01f, -3.86590324e-02f, -3.41520190e-01f, 4.47174050e-02f, 2.52944261e-01f, 2.56449282e-01f, -1.14639513e-01f, -1.59058228e-01f,
  5.19602448e-02f, 1.29346833e-01f, 7.43711114e-01f, -3.11829567e-01f, -4.07042116e-01f, -1.62384957e-01f, 2.92047173e-01f, 9.58872855e-01f, -8.85636434e-02f, -6.41174540e-02f,
  6.22926503e-02f, -1.72367543e-01f, -1.30416140e-01f, -1.29316244e-02f, 1.19255790e-02f, 8.89775753e-02f, -4.29614067e-01f, -7.79893026e-02f, -5.46129763e-01f, 5.99722803e-01f,
  5.82769692e-01f, 4.82670426e-01f, -2.42330566e-01f, 5.27717888e-01f, -2.39224032e-01f, 7.43233711e-02f, 5.21611154e-01f, -1.85171083e-01f, -3.02297115e-01f, -2.16307506e-01f,
  -1.31596267e-01f, -2.37832367e-01f, 5.88806927e-01f, -3.50389391e-01f, -3.56646389e-01f, 1.43314585e-01f, -3.61423433e-01f, 9.35082287e-02f, -1.15986392e-01f, 3.44360441e-01f,
  1.04746318e+00f, -1.58289760e-01f, -2.56759822e-01f, 1.29103646e-01f, -3.00049186e-01f, -2.20337287e-02f, -2.70836830e-01f, 1.90875970e-03f, 3.22759598e-02f, -2.50610411e-01f,
  2.88411289e-01f, -4.74493504e-02f, -1.58694029e-01f, -4.57240455e-02f, 4.08240199e-01f, 1.32038966e-01f, 1.20311178e-01f, -1.81867704e-02f, -4.29367185e-01f, 4.04866487e-02f,
  -1.93023592e-01f, 9.88449454e-01f, -1.22777961e-01f, -1.20779738e-01f, -1.97778329e-01f, -2.37989038e-01f, -2.12528855e-01f, -1.37220845e-01f, 1.49136275e-01f, 5.28170943e-01f,
  -5.86688928e-02f, 1.26540288e-01f, -2.55570829e-01f, 7.10385740e-01f, -1.67893514e-01f, -2.02846482e-01f, -3.39573562e-01f, -3.81949812e-01f, -1.07100122e-01f, 4.85874787e-02f,
  -1.36636227e-01f, -3.27608958e-02f, 2.39060909e-01f, -3.76198143e-01f, 3.74070823e-01f, 2.98708171e-01f, 5.49764454e-01f, 1.00204922e-01f, -3.14991862e-01f, -1.74180865e-01f,
  -1.51427403e-01f, -1.53328851e-01f, 1.28379658e-01f, -5.00571802e-02f, 5.25148571e-01f, 6.57456458e-01f, 3.40221584e-01f, 1.03090632e+00f, -1.26167089e-01f, -3.53287637e-01f,
  -2.37926781e-01f, -2.87182853e-02f, 1.14940658e-01f, 1.46152673e-03f, -8.58648121e-02f, -4.93954867e-02f, 1.14603862e-01f, -2.66247213e-01f, 2.80526698e-01f, 2.71510035e-01f,
  1.18718497e-01f, -4.62719321e-01f, -1.03942314e-02f, 5.08242607e-01f, -9.98939648e-02f, 4.62754369e-01f, 5.20161986e-01f, 5.23760319e-01f, -4.98023778e-01f, 8.89600813e-03f,
  -1.69493183e-01f, -1.48827419e-01f, 8.18507299e-02f, 1.20588791e+00f, -2.27919668e-01f, 2.17225194e-01f, -1.13492534e-01f, -2.56600916e-01f, -6.49979189e-02f, -1.45671964e-01f,
  -2.98006177e-01f, -1.47414625e-01f, -2.99319383e-02f, -3.71077269e-01f, -1.01791456e-01f, -4.11980361e-01f, -3.97307396e-01f, 2.90119290e-01f, -3.30534577e-01f, 3.56456518e-01f,
  2.48871911e-02f, 1.40694678e-01f, 1.51496544e-01f, -3.71708840e-01f, -2.26006225e-01f, 2.22671703e-01f, 1.70612320e-01f, -6.75287604e-01f, -6.39665484e-01f, -5.68705320e-01f,
  5.27529418e-01f, 3.77163827e-01f, 1.38431132e-01f, 5.10164857e-01f, 3.78745198e-01f, -2.26358280e-01f, 4.02828366e-01f, -1.67977456e-02f, 6.52785227e-02f, 5.31410813e-01f,
  -4.35147107e-01f, -1.96017727e-01f, -5.38462587e-02f, 8.01265597e-01f, -2.48664364e-01f, -3.51774991e-01f, 1.83284089e-01f, -2.46759281e-01f, -2.54085034e-01f, 3.23827029e-03f,
  -1.06470734e-01f, -1.57194510e-01f, 1.15937069e-01f, 2.71227118e-02f, 5.03486767e-02f, -2.77389616e-01f, 2.68894106e-01f, -2.39138350e-01f, 5.33927083e-01f, 4.98355091e-01f,
  -5.86002052e-01f, -7.50588536e-01f, -2.31837660e-01f, 6.25712216e-01f, 3.23873274e-02f, -1.41518489e-01f, -4.29012895e-01f, -2.97415614e-01f, -1.50501236e-01f, -2.31330112e-01f,
  6.88953400e-02f, -2.63623208e-01f, 9.05038714e-02f, 8.01874876e-01f, -2.36669764e-01f, -5.22909574e-02f, -1.45839229e-01f, -8.88374150e-02f, 5.97176731e-01f, -1.62547678e-02f,
  8.55891228e-01f, -2.15257466e-01f, -6.56507909e-02f, 1.88520074e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.00506791e-01f, -1.04914354e-02f, -2.41644531e-01f, -9.13914386e-03f, 2.58136779e-01f, 3.34164917e-01f, 4.38703261e-02f, -2.14576170e-01f, -2.98426002e-01f, 1.00135721e-01f,
  -8.25929195e-02f, 1.54206768e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    