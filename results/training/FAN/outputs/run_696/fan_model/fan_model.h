/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.11459059e-01f, -1.50767580e-01f, 2.10293874e-01f, 6.03236817e-02f, -1.32536560e-01f, -9.49880853e-02f, -1.68014333e-01f, -7.92230740e-02f, 2.71385349e-02f, -1.16583772e-01f,
  -1.79941297e-01f, -1.49222702e-01f, -9.53381062e-02f, -1.15477666e-01f, -3.44060250e-02f, -1.45230172e-02f, -1.02686301e-01f, 1.80849090e-01f, 7.86240324e-02f, -2.01075431e-02f,
  -9.96926948e-02f, 1.10915720e-01f, 1.74538195e-01f, 5.19537479e-02f, -7.03608766e-02f, 4.96920459e-02f, 8.38175267e-02f, -3.40846740e-02f, -5.85636385e-02f, 3.01555563e-02f,
  3.10741425e-01f, 2.60738712e-02f, 4.00112905e-02f, -6.61376305e-03f, -4.76449840e-02f, 6.75550923e-02f, -5.64537458e-02f, 4.33988534e-02f, -5.57965934e-02f, 5.43556474e-02f,
  -5.98091856e-02f, -4.63165008e-02f, -9.57099572e-02f, -1.03836410e-01f, 1.93046927e-02f, -2.84610726e-02f, -4.87609468e-02f, -3.97775508e-02f, -9.74716153e-03f, 1.77113861e-02f,
  -1.58040613e-01f, -1.87044278e-01f, -1.13920299e-02f, -1.13807857e-01f, -3.79094598e-03f, 3.08669079e-02f, -9.54025909e-02f, -5.45129292e-02f, -7.43879527e-02f, -7.24238381e-02f,
  -1.64706893e-02f, 1.33099295e-02f, 2.25552567e-03f, 5.43330982e-02f, -7.61210024e-02f, 8.44589844e-02f, 1.48073230e-02f, -4.56340797e-02f, -2.75456700e-02f, 2.51414143e-02f,
  -2.00388450e-02f, 3.90155129e-02f, 2.64645997e-03f, -4.52574380e-02f, -4.62925062e-02f, 1.15383649e-02f, 1.82203408e-02f, -1.94939021e-02f, -8.33917991e-04f, 2.11366639e-02f,
  -6.90422952e-02f, 2.82677840e-02f, 1.76025275e-02f, -2.88742799e-02f, -8.66979584e-02f, 9.51657910e-03f, 6.04148246e-02f, -1.22044183e-01f, -7.81798810e-02f, -6.87338859e-02f,
  2.20259264e-01f, -5.35339192e-02f, 7.31199384e-02f, -9.19127241e-02f, -2.08997056e-02f, -5.31440154e-02f, -3.60497343e-03f, 5.44835851e-02f, -7.19194934e-02f, -8.76610447e-03f,
  1.08355088e-02f, 5.46969883e-02f, 1.39800692e-02f, -2.65359972e-02f, 5.34846224e-02f, -6.15314655e-02f, -6.09978400e-02f, -5.67716546e-02f, -7.53080174e-02f, -1.10601187e-02f,
  -2.27871630e-02f, 1.09999711e-02f, 1.28672048e-01f, -1.40381977e-02f, -1.59052052e-02f, 1.49710821e-02f, 2.33004373e-02f, 2.90443823e-02f, 5.60908094e-02f, 1.66417554e-01f,
  4.41836387e-01f, -6.48510158e-02f, -4.92698029e-02f, 7.98489675e-02f, -2.06666756e-02f, -5.08962087e-02f, -4.53936197e-02f, 7.84932151e-02f, -1.51763519e-03f, -7.37502202e-02f,
  -3.00397654e-03f, 1.30571797e-01f, 1.98291540e-01f, 1.42495437e-02f, 1.58891261e-01f, -2.45680679e-02f, -9.81590077e-02f, 3.48670483e-02f, 2.15113193e-01f, 5.53921126e-02f,
  -7.69641399e-02f, -2.72847037e-03f, 1.10943973e-01f, 1.15092993e-01f, -1.58050731e-01f, 1.73757281e-02f, -5.14223501e-02f, -1.31569847e-01f, -3.31245945e-03f, -9.12299827e-02f,
  1.98755875e-01f, 1.21958233e-01f, 5.26069514e-02f, 5.90101741e-02f, -8.17820653e-02f, -9.24194511e-03f, 1.53907925e-01f, -1.48128644e-02f, 9.09642652e-02f, 9.52243954e-02f,
  8.02772213e-03f, 9.55364406e-02f, 8.93619061e-02f, -2.26418599e-02f, 4.67077941e-02f, 8.64331573e-02f, -4.82157096e-02f, 5.37760854e-02f, 3.90059687e-02f, 1.00761883e-01f,
  -5.59632257e-02f, 6.11484684e-02f, 1.37192011e-01f, 1.10785067e-01f, 8.55749846e-02f, 4.63011228e-02f, 5.78178689e-02f, 1.05069399e-01f, 1.43036425e-01f, 1.29214108e-01f,
  -5.19352779e-02f, -1.21396594e-01f, -2.06552036e-02f, -6.32037073e-02f, -1.15825478e-02f, -4.79445718e-02f, 1.55513082e-03f, -7.84782171e-02f, 2.93461811e-02f, -1.09682545e-01f,
  -1.34179637e-01f, -6.12739511e-02f, -2.75352784e-02f, -9.40339193e-02f, -5.32338955e-02f, -9.86898094e-02f, -5.01638278e-02f, 9.24496166e-03f, -4.84743081e-02f, -1.08720496e-01f,
  -1.44891338e-02f, -1.05116852e-01f, -7.24363104e-02f, -3.96302938e-02f, -9.89855006e-02f, -1.65706519e-02f, -5.50731905e-02f, 2.42867153e-02f, -7.97683373e-02f, -8.47954229e-02f,
  5.43802083e-02f, 8.76575187e-02f, 8.18974301e-02f, 1.15826525e-01f, 8.33495483e-02f, 6.72907308e-02f, 2.82543395e-02f, 9.10254791e-02f, -6.85473485e-03f, 4.45746891e-02f,
  1.35708094e-01f, 6.15899265e-02f, 8.03460106e-02f, 5.76743111e-02f, 7.32396320e-02f, 7.61610791e-02f, 5.17012104e-02f, 9.02665779e-02f, 7.07346052e-02f, 5.38034663e-02f,
  -7.45275337e-03f, 9.23113450e-02f, 7.67582282e-02f, 4.79797982e-02f, 1.30667493e-01f, 1.53243244e-01f, 3.87569405e-02f, 4.28095460e-02f, 1.16491385e-01f, 1.05951108e-01f,
  5.40907197e-02f, -4.37348187e-02f, 1.15474081e-02f, -6.58563748e-02f, 9.66364145e-02f, 5.10598980e-02f, 1.66385069e-01f, 7.77057037e-02f, -5.58327325e-02f, 5.40238544e-02f,
  -1.06190816e-01f, -4.12172452e-02f, -1.41627640e-01f, -1.05275325e-01f, 6.80119321e-02f, -1.64399501e-02f, 4.00721245e-02f, 1.35234911e-02f, 7.73500204e-02f, 4.08623479e-02f,
  -3.52468230e-02f, -5.61097227e-02f, -4.20438908e-02f, 5.50143467e-03f, -1.00067876e-01f, -9.79043245e-02f, -1.48436502e-01f, -1.21143483e-01f, -1.41283095e-01f, -1.89930409e-01f,
  -4.74136434e-02f, -7.11406767e-02f, -1.71340827e-04f, 6.29311725e-02f, 1.11075677e-02f, 1.30285900e-02f, 9.99777764e-02f, -7.63362497e-02f, 2.25216784e-02f, -1.90873407e-02f,
  -8.41396898e-02f, -4.22163159e-02f, 9.14972648e-02f, -7.58485422e-02f, -7.59832561e-02f, 3.84731181e-02f, 1.14380848e-03f, -7.66262710e-02f, -7.20195174e-02f, 4.76978980e-02f,
  1.08488694e-01f, 4.03549112e-02f, 1.09617328e-02f, -4.92331944e-02f, 2.59696636e-02f, -5.84216081e-02f, -4.13281210e-02f, 3.17941629e-03f, -2.26199776e-02f, -4.40118127e-02f,
  3.68217789e-02f, -2.77775656e-02f, -3.46800275e-02f, 1.46251277e-03f, -7.35337660e-02f, -2.73874346e-02f, -4.52967882e-02f, 3.47679015e-04f, -8.53703532e-04f, -1.75097696e-02f,
  5.16772829e-02f, -3.31391953e-02f, 7.23815933e-02f, 4.78434302e-02f, -6.00608699e-02f, -3.12745832e-02f, -2.17577145e-02f, 2.63120327e-02f, -2.29989588e-02f, 4.01995555e-02f,
  -4.46896963e-02f, -3.54000330e-02f, -8.83410275e-02f, 2.68778764e-02f, 7.12708533e-02f, -7.61113688e-02f, 2.79201344e-02f, 5.17628416e-02f, -4.43989411e-02f, -2.75095217e-02f,
  1.32746652e-01f, 1.00239098e-01f, 9.40286219e-02f, 8.53650272e-02f, 1.12848552e-02f, 6.58786967e-02f, 9.12904739e-03f, 1.93409417e-02f, -2.17818208e-02f, 1.08048664e-02f,
  2.18081605e-02f, 3.57533135e-02f, 4.59202416e-02f, -5.26626967e-02f, 1.22149006e-01f, -1.36121991e-03f, -4.78049703e-02f, 3.83112095e-02f, 9.80134234e-02f, 1.52067197e-02f,
  -1.94076297e-03f, 1.45787954e-01f, 9.07112285e-02f, 1.11221738e-01f, -1.01399114e-02f, 8.23388472e-02f, 1.38927162e-01f, 1.42685682e-01f, 8.54367390e-02f, 2.27300569e-01f,
  1.82525307e-01f, -7.47248381e-02f, -1.89580858e-01f, 1.62787795e-01f, 4.97631319e-02f, 2.11610839e-01f, 8.68681595e-02f, 1.64265931e-01f, 4.49215621e-02f, -2.77832132e-02f,
  9.66252238e-02f, 1.68169379e-01f, -2.53482852e-02f, 1.40535338e-02f, -2.90315710e-02f, -1.29538164e-01f, -1.29112884e-01f, -5.38017824e-02f, 6.55109510e-02f, 1.15326464e-01f,
  7.67800286e-02f, -7.22519010e-02f, -7.69328885e-03f, 8.50120857e-02f, -2.69925203e-02f, 1.31573588e-01f, -1.48815989e-01f, -1.40606925e-01f, -8.75658467e-02f, -1.23954497e-01f,
  -7.74979144e-02f, -2.08818793e-01f, 3.26135606e-02f, -8.57862681e-02f, -1.14094988e-01f, 5.75219505e-02f, -1.03915622e-02f, -1.34422213e-01f, 1.60048790e-02f, 2.00127605e-02f,
  -7.82799870e-02f, -7.49226958e-02f, -8.12680572e-02f, -7.97273144e-02f, -8.04290920e-02f, -8.65238160e-02f, -2.34543696e-01f, -1.53718695e-01f, -9.97159034e-02f, -4.75347862e-02f,
  -5.44092096e-02f, -9.32306808e-04f, -8.24734196e-02f, -1.32687073e-02f, 2.14165244e-02f, -9.26030055e-02f, -3.00709624e-02f, -1.66340955e-02f, -2.10177004e-02f, -1.24825232e-01f,
  4.66196127e-02f, -2.06343867e-02f, 5.75316772e-02f, -2.27625016e-02f, 2.19209306e-02f, 5.20383045e-02f, -2.76394878e-02f, -3.49682011e-03f, 2.13746564e-03f, -3.12222727e-02f,
  -6.06331974e-02f, -2.77307583e-03f, -4.03285120e-03f, 4.92891446e-02f, 4.49138582e-02f, 4.36009094e-03f, 1.31779341e-02f, 1.18190870e-02f, -1.67663023e-02f, -4.48556095e-02f,
  6.75225481e-02f, -4.41575423e-02f, 3.42125297e-02f, 6.29819781e-02f, -5.64940684e-02f, -6.39911890e-02f, 3.08063850e-02f, 4.31909692e-03f, 3.74727622e-02f, 6.24672510e-02f,
  7.56165758e-02f, -1.92475110e-01f, -9.90516618e-02f, -1.33805335e-01f, -1.46617158e-03f, -1.37381271e-01f, 1.05735706e-02f, -4.53252532e-02f, -6.89883158e-03f, 3.65769304e-02f,
  2.64764503e-02f, -4.76558656e-02f, -9.97635201e-02f, -5.52182235e-02f, 4.80671227e-02f, -4.39956002e-02f, -4.29319963e-02f, -6.55179620e-02f, -1.70454923e-02f, 7.79529102e-04f,
  -7.40775913e-02f, 5.97992092e-02f, 9.27182585e-02f, 1.08368127e-02f, -8.87999963e-03f, 7.76611790e-02f, -5.30102104e-02f, -8.05047229e-02f, 4.59647961e-02f, 1.97647419e-02f,
  6.11582138e-02f, 2.02781707e-01f, -4.93974285e-03f, 1.15222685e-01f, -5.96170686e-02f, -2.54747212e-01f, -2.73710579e-01f, -7.35183656e-02f, -4.19056341e-02f, 6.23246469e-02f,
  1.20952778e-01f, 9.40921232e-02f, 7.10947737e-02f, -7.65869319e-02f, -3.76230292e-02f, -3.68638102e-05f, 7.19204322e-02f, -1.36697710e-01f, -2.18415067e-01f, -5.76657504e-02f,
  -1.31547721e-02f, 8.22981745e-02f, 2.29988173e-02f, -2.18510185e-03f, 2.91342646e-01f, -9.67257284e-03f, 1.94308117e-01f, 1.69034258e-01f, 1.23907439e-01f, 3.74421686e-01f,
  1.24867462e-01f, 1.96550786e-01f, -7.82833844e-02f, 1.06538251e-01f, 6.88954517e-02f, -3.57501134e-02f, 4.32055369e-02f, 9.68318507e-02f, 2.14462215e-03f, 5.90691380e-02f,
  9.10984054e-02f, 1.12315848e-01f, 1.46671734e-03f, 3.58043984e-02f, 6.97017685e-02f, 1.99494846e-02f, 2.10795343e-01f, -2.05497118e-03f, 5.55988774e-02f, 8.16863924e-02f,
  9.85202789e-02f, 4.43403638e-04f, -1.34755271e-02f, -7.36185014e-02f, 8.43579844e-02f, -7.45387003e-02f, 7.80247804e-03f, 8.67470801e-02f, -6.81061521e-02f, 1.99839965e-01f,
  -8.59490484e-02f, -6.70647472e-02f, -9.71884504e-02f, -6.93168938e-02f, -9.24585387e-02f, -1.33071825e-01f, -2.15653945e-02f, 1.32753951e-02f, -8.16819668e-02f, -9.61041749e-02f,
  -2.98772231e-02f, -1.19909130e-01f, -1.16236106e-01f, -5.44257723e-02f, -8.14320669e-02f, -9.83054265e-02f, -6.92351907e-02f, 2.08692104e-02f, -1.24884158e-01f, -6.13015853e-02f,
  -3.18545625e-02f, -1.28048152e-01f, -3.99403833e-02f, 9.46314074e-03f, -3.67299654e-02f, -1.19161248e-01f, -3.75777744e-02f, -3.62124257e-02f, -7.71334171e-02f, -8.77509639e-02f,
  -2.24123914e-02f, -8.96505564e-02f, 1.05393127e-01f, 3.84643786e-02f, 1.02084354e-01f, 3.39550748e-02f, 4.07102965e-02f, 6.69023246e-02f, 6.04819469e-02f, 4.97876666e-02f,
  5.32757863e-02f, -6.29317686e-02f, -7.35667208e-03f, 7.33862370e-02f, 5.86075056e-03f, -2.88103037e-02f, 2.46976130e-02f, 1.93696972e-02f, -7.76118785e-03f, 5.02391532e-02f,
  3.80793549e-02f, 3.96209173e-02f, -8.24762285e-02f, -4.85938750e-02f, 1.01005815e-01f, -1.58872306e-01f, 1.35585824e-02f, -6.14347830e-02f, -9.50837880e-02f, -1.18435338e-01f,
  4.49088037e-01f, -1.83874384e-01f, 9.15648788e-02f, 4.83392105e-02f, -1.18696280e-01f, -6.27088826e-04f, 2.63689063e-03f, -3.11389659e-02f, -6.64420873e-02f, -1.59573574e-02f,
  -1.82976156e-01f, -1.69926763e-01f, -1.84807822e-01f, -9.10701156e-02f, 7.25672320e-02f, -1.76484108e-01f, -2.70238612e-02f, 1.85713589e-01f, 2.31866434e-01f, 6.79814741e-02f,
  -1.36886507e-01f, 7.93919638e-02f, 2.26766050e-01f, 3.18538137e-02f, -7.11242408e-02f, -7.80990645e-02f, -1.79670542e-01f, -4.88228351e-02f, -1.11851722e-01f, -1.80375353e-01f,
  1.34238407e-01f, 9.62402523e-02f, -5.88589199e-02f, -5.28414994e-02f, -1.11643851e-01f, 7.69393966e-02f, -4.53488901e-02f, 1.02448359e-01f, -4.89885546e-02f, -2.19732840e-02f,
  8.93343892e-03f, -5.47522418e-02f, 1.42017426e-02f, -2.95608472e-02f, -8.13897420e-03f, 5.43005094e-02f, 2.49597821e-02f, 6.15001023e-02f, -1.79587826e-02f, -5.78244068e-02f,
  -2.18945205e-01f, 2.64919251e-02f, 1.40326500e-01f, 3.35153528e-02f, -9.41939559e-03f, -4.41318490e-02f, 1.21083269e-02f, 2.63900459e-02f, 5.86458407e-02f, -4.35717814e-02f,
  -4.07217331e-02f, 4.34852876e-02f, 1.90621968e-02f, -2.97802463e-02f, -3.23248841e-02f, 3.66606675e-02f, 3.71985883e-02f, 4.74311300e-02f, -6.37067307e-04f, 2.34785825e-02f,
  -2.17807796e-02f, -3.27214040e-02f, -2.98135988e-02f, 6.61966726e-02f, 2.63444576e-02f, -1.29472231e-02f, 8.42841715e-02f, -6.64383546e-02f, 2.50476506e-02f, -1.75036881e-02f,
  6.50476962e-02f, 7.70884231e-02f, -6.74433410e-02f, -1.04458146e-02f, 1.01103060e-01f, 7.26183131e-03f, 3.16373818e-02f, -4.96610440e-02f, -2.27995235e-02f, 6.20974898e-02f,
  -1.42016560e-01f, -1.32149160e-01f, 2.23532747e-02f, -3.53425033e-02f, 6.44026250e-02f, -2.09446996e-02f, -4.53036558e-03f, -2.43338440e-02f, -5.64014688e-02f, -1.19167464e-02f,
  -6.88339397e-02f, 1.09604754e-01f, -5.63619919e-02f, -3.25505883e-02f, 4.00487259e-02f, 8.89906660e-03f, -1.21593878e-01f, -2.88762841e-02f, -9.05332118e-02f, -9.73464996e-02f,
  -6.21682629e-02f, -4.25487421e-02f, 1.98280364e-02f, -8.60851556e-02f, -5.91084510e-02f, -1.17806122e-02f, -4.16367464e-02f, -4.08995524e-02f, 1.05799399e-02f, -4.38448451e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.11051455e-01f, 1.40244409e-01f, -1.02295332e-01f, 1.67498037e-01f, -1.35001652e-02f, -1.87463939e-01f, -4.31117415e-02f, -1.29200205e-01f, -7.27111027e-02f, 5.72430007e-02f,
  -5.96519001e-02f, -1.06486268e-01f, -9.95134637e-02f, -1.12193532e-01f, -9.21528600e-03f, 9.88207385e-02f, 7.82931820e-02f, 2.07794514e-02f, -1.30648091e-01f, 2.70245690e-02f,
  1.33081391e-01f, 1.21628121e-01f, 7.10813403e-02f, -5.33673279e-02f, 2.34542847e-01f, 3.68801877e-02f, -5.38764931e-02f, -3.00549753e-02f, 9.16903913e-02f, 2.26783127e-01f,
  -5.42615354e-02f, -1.61920831e-01f, -5.44458143e-02f, 1.55198947e-01f, -1.19918585e-01f, 1.36031210e-01f, 7.15875626e-02f, -5.59676485e-03f, 4.03074250e-02f, 7.90110528e-02f,
  6.03152104e-02f, 2.48574540e-02f, 1.09681457e-01f, 2.16591805e-02f, 7.03945905e-02f, -4.68205623e-02f, -2.07843166e-02f, -2.78297793e-02f, -1.61116749e-01f, -3.63120623e-02f,
  1.68199882e-01f, 9.75160748e-02f, -2.24580944e-01f, -7.10844845e-02f, -1.48338139e-01f, -2.07758337e-01f, -1.73730209e-01f, -4.10438254e-02f, -2.84705311e-01f, 9.85465050e-02f,
  -4.78089415e-02f, -1.00526428e-02f, -9.98576730e-03f, 1.31991684e-01f, -2.64143180e-02f, 2.83175111e-02f, -8.68229195e-02f, -4.46093641e-02f, -6.02634884e-02f, 9.96278524e-02f,
  -1.19848335e-02f, -1.08782612e-01f, -2.89950557e-02f, 7.65012503e-02f, -4.57579792e-02f, -4.15338278e-02f, -5.58510013e-02f, -3.17015825e-03f, -6.70646131e-02f, -8.12355801e-03f,
  -6.42394722e-02f, -9.57392156e-02f, -1.33123994e-01f, -7.84000754e-02f, -7.02399984e-02f, -6.68328851e-02f, -7.85258412e-02f, -4.11410630e-03f, 4.86067198e-02f, -8.78916532e-02f,
  -3.80011052e-02f, -2.93252021e-01f, 1.03236020e-01f, 6.54695854e-02f, -9.93279144e-02f, -1.11377954e-01f, -4.12020832e-02f, -1.20312110e-01f, -1.14740930e-01f, 3.45727131e-02f,
  -7.08635077e-02f, -1.32282274e-02f, 1.32618903e-03f, -1.67204738e-02f, 4.09178659e-02f, -5.33064790e-02f, 6.60041422e-02f, 8.95386413e-02f, -1.10572815e-01f, 8.89446028e-03f,
  1.08572906e-02f, 7.52740121e-03f, -1.29114002e-01f, -2.87694018e-02f, -5.04580550e-02f, -1.19507916e-01f, -1.71932191e-01f, -1.66636780e-02f, -2.41623536e-01f, -4.57969904e-02f,
  -3.90635610e-01f, 2.29391113e-01f, 7.72267208e-02f, -3.41790080e-01f, -1.38409331e-01f, -7.08832815e-02f, 1.84918806e-01f, -1.50403410e-01f, -1.84858590e-01f, 1.92211971e-01f,
  1.29671529e-01f, -1.23901218e-01f, 4.22763079e-02f, -4.62403055e-03f, 7.05300132e-03f, 1.41128555e-01f, 4.04306017e-02f, -8.27733129e-02f, -3.04983526e-01f, -2.10285962e-01f,
  3.69849760e-04f, -2.16418356e-01f, -2.04245910e-01f, -1.36044353e-01f, -1.18109301e-01f, -8.69399533e-02f, 1.19257770e-01f, -8.32572207e-02f, 3.38361338e-02f, -1.12191632e-01f,
  2.92383105e-01f, -1.60670459e-01f, 2.98665371e-02f, -1.43767998e-01f, 1.34144515e-01f, -2.81945467e-02f, -2.77962647e-02f, 1.54322842e-02f, -8.84288028e-02f, -9.04458947e-03f,
  -1.08633265e-01f, 2.99502481e-02f, -4.67046387e-02f, 9.82825062e-04f, -4.00958955e-02f, 6.12231623e-03f, 9.88757610e-02f, -1.05373710e-01f, 1.29380100e-03f, 1.83692455e-01f,
  7.32568055e-02f, -8.15247074e-02f, -5.57339080e-02f, -4.30226885e-02f, -2.51663066e-02f, 1.71005130e-02f, -1.29152238e-02f, -1.82837635e-01f, 6.52838964e-03f, 8.90047848e-02f,
  1.03145624e-02f, 1.02350950e-01f, -1.23678381e-02f, 6.99456632e-02f, -2.07152385e-02f, 7.74585083e-02f, 3.98913249e-02f, 4.72085215e-02f, 1.74364243e-02f, -8.39712024e-02f,
  2.87020244e-02f, 9.80234705e-03f, 7.27891997e-02f, 2.86585242e-02f, -9.99134704e-02f, -1.81134716e-02f, -6.19377233e-02f, 9.40397456e-02f, -6.24619536e-02f, -1.25339538e-01f,
  -1.57174304e-01f, -3.50000821e-02f, -6.39007241e-02f, 1.74660496e-02f, 5.73559431e-03f, -4.54016365e-02f, -6.18424173e-03f, -9.73599218e-03f, 3.77521068e-02f, 5.57657145e-03f,
  1.54570714e-01f, 7.82818533e-03f, 2.30527134e-03f, 6.03371523e-02f, -2.65324805e-02f, -4.64983024e-02f, -5.95519990e-02f, 4.85985056e-02f, 1.41044112e-03f, 5.08392602e-02f,
  2.05230974e-02f, -6.87939152e-02f, 8.72568600e-03f, 9.57318246e-02f, -2.34331265e-02f, -1.42707661e-01f, 1.34381771e-01f, -4.82591540e-02f, 7.07021207e-02f, 5.05212918e-02f,
  8.24914649e-02f, 7.61265773e-03f, 1.25375539e-01f, 1.59100339e-01f, 6.81593418e-02f, 1.32910050e-02f, 1.75062627e-01f, 1.04066776e-02f, 7.48031735e-02f, 1.55269265e-01f,
  4.48079884e-01f, 3.39134455e-01f, 1.82825223e-01f, 5.24783470e-02f, -1.03412613e-01f, -1.96754500e-01f, -2.21988782e-01f, -1.57162517e-01f, -9.32187065e-02f, 7.97283798e-02f,
  1.24166951e-01f, -1.54910656e-02f, -1.04854442e-01f, -1.90485138e-02f, 2.24836785e-02f, -3.74600105e-02f, 1.37494804e-04f, 1.09951906e-01f, -1.00002609e-01f, 3.82669419e-02f,
  -8.02708194e-02f, 1.18374825e-02f, 4.83651459e-02f, 9.96183455e-02f, 7.26818070e-02f, -2.58133709e-02f, -6.80114403e-02f, 3.26045342e-02f, 1.34173883e-02f, 1.36444688e-01f,
  3.91391903e-01f, 3.26774627e-01f, -8.44809785e-02f, 6.51184767e-02f, 1.52876288e-01f, 1.02019593e-01f, -3.21526229e-02f, 4.00923900e-02f, -1.05134919e-02f, 6.46454468e-02f,
  5.34118786e-02f, 7.06946999e-02f, -8.09159949e-02f, -6.45269454e-02f, -6.16795197e-02f, 8.34483467e-03f, 6.33364171e-02f, -2.54012458e-02f, 7.72231370e-02f, 1.30678400e-01f,
  2.08312552e-02f, 1.02019578e-01f, -4.92436662e-02f, -1.30802095e-01f, 9.00602490e-02f, 2.49920301e-02f, 9.20679569e-02f, 1.13949634e-01f, 1.03382759e-01f, 1.65428698e-01f,
  -1.11724593e-01f, -8.18542019e-02f, 9.86773968e-02f, -1.80763789e-02f, -1.15366429e-01f, -1.37025163e-01f, -3.21108811e-02f, -4.14056778e-02f, -1.35895759e-01f, -7.81200081e-02f,
  -7.16560483e-02f, 9.46229603e-03f, -2.25250795e-02f, -2.04666480e-02f, -4.46261764e-02f, 5.70770465e-02f, 9.96856913e-02f, 9.67427343e-02f, 4.87796329e-02f, -4.04375792e-03f,
  1.21200010e-02f, -4.33010794e-02f, -5.02968244e-02f, 3.50783058e-02f, 6.86974153e-02f, 8.44176917e-04f, 5.98324463e-02f, 8.55358839e-02f, -6.26115873e-02f, -8.84161294e-02f,
  -1.07855782e-01f, -6.02635667e-02f, 5.61718643e-02f, 3.60868089e-02f, 5.16637303e-02f, 1.00101374e-01f, 2.28773981e-01f, 1.13620497e-01f, 1.97753385e-02f, 6.33530170e-02f,
  1.11021519e-01f, 1.35013774e-01f, 3.54734436e-02f, -2.85012107e-02f, -6.55270144e-02f, 9.62165371e-03f, 1.72025993e-01f, 7.11297393e-02f, -2.00594421e-02f, 4.79133092e-02f,
  9.83225182e-02f, -4.04477343e-02f, -7.48717114e-02f, -2.16768626e-02f, -7.94100687e-02f, -6.10070638e-02f, -6.11239187e-02f, 1.86076704e-02f, 5.49367815e-02f, -1.82019919e-01f,
  4.68146503e-01f, 2.04664037e-01f, 2.08861560e-01f, 1.09565198e-01f, 6.31649569e-02f, 1.10782191e-01f, 2.75406569e-01f, 1.61749467e-01f, 7.80407116e-02f, 3.08175441e-02f,
  1.27211913e-01f, -5.34718633e-02f, -7.08652064e-02f, -6.44227071e-03f, 1.87702283e-01f, 8.23390335e-02f, 4.74435017e-02f, 1.68000683e-01f, 1.09639421e-01f, 8.53343531e-02f,
  4.42778878e-02f, 6.86778426e-02f, 7.39517063e-02f, 4.03644294e-02f, 3.72364707e-02f, 3.83156054e-02f, 1.67043116e-02f, 6.29469976e-02f, 1.20307192e-01f, -1.76443369e-03f,
  1.70426518e-01f, 1.91075519e-01f, -6.77307770e-02f, -1.14734575e-01f, 8.91317241e-03f, -5.18253222e-02f, 7.17273206e-02f, -5.49409501e-02f, -1.14221521e-01f, 3.89737524e-02f,
  -9.81974974e-02f, -8.15574303e-02f, 8.82027149e-02f, -1.77663285e-02f, 5.53737059e-02f, -1.25589631e-02f, 5.66400439e-02f, 3.53789888e-02f, -2.67001074e-02f, -2.57955138e-02f,
  8.13381746e-02f, 4.62109223e-02f, -4.40577939e-02f, -1.71533730e-02f, 1.78171962e-01f, -1.05383016e-01f, 4.95309830e-02f, 2.58430988e-02f, -1.75902358e-04f, 1.23236999e-01f,
  4.47239578e-02f, 1.84618365e-02f, 9.72330943e-03f, -2.77457628e-02f, 1.20170720e-01f, 1.35399640e-01f, 5.82721494e-02f, -8.19426496e-03f, 1.51548132e-01f, 9.40042287e-02f,
  -8.22475478e-02f, 1.01860076e-01f, 2.14151926e-02f, 7.96742439e-02f, -4.34056995e-03f, 3.90055589e-02f, -4.48116958e-02f, -7.09725544e-02f, 7.20218942e-02f, 4.76950891e-02f,
  2.82631218e-02f, 8.21042508e-02f, -1.77434254e-02f, 9.17156860e-02f, -1.26412127e-03f, 1.45808443e-01f, 8.29902515e-02f, 1.25707537e-02f, -3.97652984e-02f, 3.50132622e-02f,
  -3.24872494e-01f, -1.58153363e-02f, 7.31881112e-02f, -6.10407777e-02f, 4.15268019e-02f, -1.28925433e-02f, -2.94271149e-02f, -1.39431998e-01f, -2.68309377e-02f, 6.01666421e-03f,
  6.67744130e-03f, -6.94971764e-04f, 5.69735877e-02f, 5.95647655e-02f, 4.97004343e-03f, -7.35362843e-02f, 6.02694578e-04f, -8.01241323e-02f, -1.32663734e-02f, -1.44073203e-01f,
  -7.52451345e-02f, -1.64117709e-01f, -2.71729324e-02f, 2.39891894e-02f, -8.00774768e-02f, -1.89254403e-01f, -8.19745511e-02f, -1.12439625e-01f, -1.36582712e-02f, -1.12004004e-01f,
  9.24705807e-03f, -5.90992831e-02f, -3.21673125e-01f, -4.62503992e-02f, -1.82953373e-01f, -8.88384413e-03f, 1.07180011e-02f, -4.21156827e-03f, -5.83724156e-02f, -1.70474630e-02f,
  1.22249544e-01f, 1.89320967e-01f, 1.62813410e-01f, 1.55551642e-01f, 2.24829108e-01f, -1.19716942e-01f, -2.39406869e-01f, -2.51183417e-02f, 1.95641905e-01f, 1.98210821e-01f,
  5.03440872e-02f, 3.98611724e-02f, 7.91954771e-02f, 5.88078573e-02f, -3.76516059e-02f, 5.31517416e-02f, -2.30024174e-01f, -1.79717153e-01f, -9.61800367e-02f, -2.77804136e-01f,
  1.28668174e-01f, -2.25432366e-01f, 8.88510048e-03f, 7.84173459e-02f, -4.16979976e-02f, -6.57109842e-02f, 1.86185203e-02f, -1.36797190e-01f, 6.25188882e-03f, -1.56631887e-01f,
  -2.21365057e-02f, -7.90547729e-02f, -1.34815753e-01f, -4.91707399e-02f, -8.94873962e-02f, 4.96727526e-02f, -1.12213895e-01f, -1.06410287e-01f, -7.15966001e-02f, -8.94460678e-02f,
  -3.12876180e-02f, -6.44928068e-02f, -8.01301450e-02f, -7.00869709e-02f, 2.35664509e-02f, -1.12942327e-02f, -3.86467092e-02f, -1.17649743e-02f, -3.05391811e-02f, -5.62997498e-02f,
  -9.59468856e-02f, -2.97603756e-02f, -6.42773807e-02f, -9.99802724e-02f, -8.17795470e-02f, -1.11419417e-01f, 2.33577248e-02f, 1.00170076e-01f, 6.27997145e-02f, -2.66671199e-02f,
  -5.08043217e-03f, 4.52311337e-02f, 8.41971710e-02f, -1.39975557e-02f, 8.12225118e-02f, -1.48457184e-01f, 2.09597554e-02f, 1.23311244e-02f, -8.21448267e-02f, -2.18682811e-02f,
  -6.39125481e-02f, -3.96031328e-02f, -1.90602720e-01f, -8.22224841e-02f, -1.10316552e-01f, -9.81193557e-02f, -8.44438672e-02f, 7.19296038e-02f, 6.41544014e-02f, -1.23399481e-01f,
  3.07190418e-01f, -1.05085261e-01f, 1.05133250e-01f, 7.57127553e-02f, -9.49222967e-02f, -3.73851880e-02f, -3.56435813e-02f, 1.98170375e-02f, -8.57116282e-02f, 1.06597513e-01f,
  2.91665606e-02f, 1.65991724e-01f, -2.80684978e-02f, -1.61921699e-02f, 6.85410649e-02f, -9.97254774e-02f, -7.53410161e-02f, 4.32415716e-02f, -1.01262271e-01f, -2.86345761e-02f,
  -4.71820012e-02f, 9.36009586e-02f, 4.29486530e-03f, 1.79187190e-02f, -2.36866828e-02f, 1.45343155e-01f, -3.79128791e-02f, 9.59096998e-02f, 6.89061806e-02f, 8.07039291e-02f,
  1.07157258e-02f, -1.62318617e-01f, -2.63949186e-01f, -3.44921127e-02f, -1.44811243e-01f, -7.16225058e-02f, 7.50530958e-02f, 2.09066093e-01f, 1.34570763e-01f, -9.77404639e-02f,
  -7.95865338e-03f, 4.73808944e-02f, -3.66548598e-02f, -1.56274047e-02f, -1.86962187e-02f, -1.47366196e-01f, -2.18824640e-01f, -1.02483451e-01f, 2.27719396e-02f, 2.09737703e-01f,
  -1.07264677e-02f, 1.33599013e-01f, 1.69224083e-01f, 3.94773670e-02f, -1.33277386e-01f, -4.72876094e-02f, -1.98261172e-01f, -5.05824052e-02f, -8.69431570e-02f, -3.03993136e-01f,
  -3.01555455e-01f, -1.61186323e-01f, -7.93208256e-02f, -2.00313143e-02f, -1.65014580e-01f, -3.80770192e-02f, -8.49846676e-02f, -5.02837710e-02f, 8.91552418e-02f, -8.72698426e-03f,
  1.62910633e-02f, 6.00341447e-02f, 3.12945321e-02f, 3.33427452e-02f, 7.21689090e-02f, 7.35790133e-02f, 6.33745566e-02f, -4.38216552e-02f, -1.09770037e-01f, 2.70748306e-02f,
  -5.77684231e-02f, -1.68261528e-01f, -1.85517699e-01f, -8.29887837e-02f, 1.99663360e-03f, -4.29734066e-02f, -1.43859208e-01f, -8.00832454e-03f, -4.79891598e-02f, -1.95192158e-01f,
  5.21289334e-02f, 3.77796404e-02f, -4.43985462e-02f, 4.10176739e-02f, 1.01531349e-01f, -2.17877962e-02f, -4.29536663e-02f, -5.31274565e-02f, 9.00937766e-02f, 1.64272767e-02f,
  -7.26374984e-02f, 1.45836221e-02f, 5.15822833e-03f, -8.56536552e-02f, -5.83630688e-02f, -4.27091196e-02f, 8.15313309e-02f, -8.06536153e-02f, -6.24294318e-02f, 5.27527034e-02f,
  1.01411734e-02f, -2.78883222e-02f, 1.75487027e-02f, 1.21566825e-01f, -6.73291683e-02f, -4.80363891e-02f, 3.49464640e-02f, 6.14274628e-02f, 5.63331731e-02f, 1.24126464e-01f,
  -1.36980880e-02f, -3.12258862e-02f, -3.05587575e-02f, -7.01586306e-02f, -1.03386544e-01f, 1.53006837e-02f, -1.26438394e-01f, -3.60324420e-02f, 2.70704716e-03f, 7.72352219e-02f,
  1.23065762e-01f, 1.15469262e-01f, -1.09457627e-01f, 4.43652309e-02f, 1.06489636e-01f, -2.03024782e-02f, 5.81305027e-02f, -8.78955647e-02f, 1.64231416e-02f, 8.56836438e-02f,
  4.29530255e-02f, 3.39824893e-02f, 1.43825999e-02f, -4.56361249e-02f, 7.43487896e-03f, -8.10236484e-02f, -2.94157881e-02f, -6.75614253e-02f, 5.44838514e-03f, 8.07713792e-02f,
  -2.51109421e-01f, -1.74821243e-02f, 1.16928667e-01f, -2.71490127e-01f, -8.34436193e-02f, 5.59837781e-02f, 2.51451164e-01f, 5.65164238e-02f, -1.04792431e-01f, 1.98849067e-01f,
  -1.26075298e-02f, -7.32341781e-02f, -2.67848447e-02f, 3.47728580e-02f, 1.76868811e-02f, 2.61267841e-01f, 6.34373799e-02f, 1.76509582e-02f, -8.89506638e-02f, -6.50267452e-02f,
  5.42326309e-02f, 1.62492543e-02f, -1.55840978e-01f, -8.45978409e-02f, -4.74597178e-02f, -3.26930452e-03f, 2.66929762e-03f, -1.44702971e-01f, 3.23083512e-02f, -7.98017681e-02f,
  2.28406832e-01f, -2.39395246e-01f, 4.24140040e-03f, -2.48853937e-01f, 6.27540797e-02f, -7.92474747e-02f, 1.90566294e-02f, -6.18739352e-02f, -1.57189786e-01f, 8.39170516e-02f,
  -1.50747672e-01f, -1.80579498e-02f, -1.18479453e-01f, -1.15333363e-01f, -3.66223790e-02f, -5.37778847e-02f, -4.06347774e-02f, -1.72862560e-01f, -1.30547971e-01f, -1.24888323e-01f,
  -1.57790869e-01f, -1.44435450e-01f, -6.67859986e-03f, 6.40480220e-02f, -1.02398053e-01f, -8.74866918e-02f, -3.23179588e-02f, -7.75086954e-02f, -1.17007338e-01f, 1.16439246e-01f,
  -5.12128957e-02f, 6.18673861e-02f, -2.93742009e-02f, -2.11977474e-02f, -6.48688525e-02f, -1.17286101e-01f, -4.73302091e-03f, 2.01524459e-02f, 3.85342836e-02f, 3.58150192e-02f,
  -2.16253959e-02f, 4.30049226e-02f, 1.11131467e-01f, 1.60233732e-02f, 4.42989767e-02f, 4.81909029e-02f, 1.19745553e-01f, 3.94514464e-02f, 3.25537956e-04f, 1.10353135e-01f,
  1.25932634e-01f, 1.62151307e-01f, 4.81134430e-02f, 8.80534723e-02f, -4.89743426e-02f, -1.49068972e-02f, 6.37640357e-02f, 5.99060059e-02f, -4.32957895e-02f, -1.37613058e-01f,
  1.56296000e-01f, -3.45761552e-02f, 1.83320478e-01f, -7.47107118e-02f, 6.57673180e-02f, 3.32239717e-02f, 4.99005392e-02f, 6.80600181e-02f, -3.11807636e-02f, 1.31396398e-01f,
  -2.98980623e-03f, -5.70530444e-02f, -1.19742833e-01f, 1.37286130e-02f, 5.40802255e-02f, -3.03098578e-02f, 3.39623727e-02f, -1.86630990e-02f, -7.40853837e-03f, 9.69861150e-02f,
  -7.38151968e-02f, 1.36604682e-01f, 1.63617998e-01f, 3.80404070e-02f, -5.14662117e-02f, 6.45967722e-02f, 9.99502465e-02f, 1.34837180e-01f, 6.48166761e-02f, 2.18663350e-01f,
  -4.24172133e-01f, 1.35097846e-01f, 2.32456923e-01f, -1.22162655e-01f, 4.99756970e-02f, 1.35006905e-01f, 1.24840185e-01f, -7.83168525e-02f, -6.43450096e-02f, 5.93766421e-02f,
  3.41217257e-02f, -9.55464169e-02f, 1.02916956e-02f, -5.06559797e-02f, -5.57610095e-02f, 1.74217269e-01f, 1.71044037e-01f, -9.80503634e-02f, -2.51662493e-01f, -2.22541496e-01f,
  -2.29063956e-03f, -2.50809699e-01f, -1.37469813e-01f, -1.46768257e-01f, -7.66204223e-02f, -6.17682785e-02f, -8.50613788e-03f, -6.56593218e-02f, 1.42095476e-01f, 2.26319544e-02f,
  6.66460693e-02f, 1.46712945e-03f, -1.54620167e-04f, -6.15802109e-02f, 4.34840992e-02f, -2.66114026e-02f, 1.83023959e-02f, -2.43801326e-02f, 1.22350879e-01f, 6.90070819e-03f,
  1.03928655e-01f, -9.02426168e-02f, -2.93286312e-02f, -7.45132286e-03f, -5.69219105e-02f, -8.90007243e-02f, -4.01811749e-02f, -1.45516649e-01f, 6.42282814e-02f, 9.77554470e-02f,
  8.67254511e-02f, 3.33579630e-02f, 6.57254681e-02f, 4.74852957e-02f, -1.60699170e-02f, -4.86311466e-02f, 2.42338268e-04f, -8.08507130e-02f, 5.44571020e-02f, -1.73729211e-01f,
  -3.16244811e-02f, -6.58489168e-02f, 1.34381711e-01f, -5.89056276e-02f, 5.17203771e-02f, -6.13559484e-02f, 1.76850855e-02f, -1.02018528e-01f, -5.70655838e-02f, -7.71701783e-02f,
  1.28427916e-03f, 8.68220162e-03f, 1.51835596e-02f, -2.02690810e-02f, 8.34310204e-02f, 3.03249322e-02f, -3.57916951e-02f, -2.91298255e-02f, 5.49403951e-02f, 8.46759304e-02f,
  -1.24107040e-02f, -1.69740412e-02f, 4.72518429e-02f, -8.57448950e-02f, 1.29583284e-01f, -2.55882200e-02f, 8.11074115e-03f, -1.81738883e-02f, -2.09153723e-02f, 8.43560696e-02f,
  -3.28652233e-01f, 1.73841372e-01f, 4.88600582e-02f, -7.97325075e-02f, 1.01703806e-02f, 4.61505912e-02f, 5.71711212e-02f, 7.89118484e-02f, -1.14260074e-02f, -1.02561019e-01f,
  -1.78394211e-03f, -5.07929400e-02f, 8.24396312e-03f, -1.82192475e-02f, -2.86468584e-02f, 8.62499513e-03f, 1.27812615e-02f, -6.41564578e-02f, 9.56062078e-02f, 6.79331739e-03f,
  3.99890244e-02f, -4.51274402e-02f, -4.76469249e-02f, -1.06134906e-01f, -7.62999877e-02f, -1.09943308e-01f, -9.06990245e-02f, -6.89353421e-02f, 2.02742708e-03f, -1.68542445e-01f,
  -3.56227160e-02f, -2.63125747e-01f, -3.44369382e-01f, -2.07528740e-01f, -2.55553126e-01f, -1.04071759e-01f, -1.11398008e-02f, 5.96813448e-02f, -7.83694312e-02f, -2.27080330e-01f,
  -4.90867235e-02f, 7.06659704e-02f, 2.19602231e-02f, 5.89540303e-02f, 1.59718931e-01f, -1.94927514e-01f, -1.77037105e-01f, 8.85325298e-03f, 1.05932593e-01f, 6.12499751e-02f,
  4.82524447e-02f, 2.82524582e-02f, 1.41530365e-01f, 7.17971846e-02f, -1.84971794e-01f, 9.81448218e-03f, -1.92329898e-01f, -1.54697865e-01f, -5.08678593e-02f, -2.84694910e-01f,
  -2.68394977e-01f, -4.19361852e-02f, -1.06343990e-02f, 1.46510705e-01f, -7.35248700e-02f, 5.58449589e-02f, 3.28985113e-03f, -1.93801537e-01f, 6.37909919e-02f, -4.45329361e-02f,
  -6.90095872e-02f, -2.65445914e-02f, -4.19372506e-02f, -1.84186865e-02f, -1.13135710e-01f, 5.07865995e-02f, -4.94815484e-02f, -8.42981115e-02f, -2.33829604e-03f, 5.10505997e-02f,
  6.18772246e-02f, -7.37294853e-02f, -4.82190996e-02f, 7.67699033e-02f, 9.01919696e-03f, -2.61008982e-02f, -6.87763467e-02f, -6.51971623e-02f, 5.12579195e-02f, -1.84571762e-02f,
  -2.24055275e-02f, -2.69799288e-02f, -7.30447993e-02f, -6.65654382e-03f, -5.14745712e-03f, 2.07215995e-02f, 1.34860736e-03f, 3.72406542e-02f, -3.67197171e-02f, -2.97889928e-03f,
  1.36187032e-01f, 2.52545290e-02f, -5.38137145e-02f, -7.03672618e-02f, 1.21209119e-02f, -2.56636068e-02f, 4.12116572e-02f, 3.26193087e-02f, 4.13348004e-02f, -1.39246192e-02f,
  -1.54941799e-02f, 6.52785823e-02f, -1.17815010e-01f, 2.64676381e-02f, -6.92143163e-04f, -5.57614006e-02f, 2.66188998e-02f, 6.71333522e-02f, -5.14954515e-02f, 2.30592731e-02f,
  -7.17273057e-02f, 1.20935671e-01f, -5.66367880e-02f, 6.51215855e-03f, -4.73959520e-02f, -3.29458416e-02f, -8.83636326e-02f, 1.82159711e-02f, -3.98860127e-03f, -9.19527486e-02f,
  -3.46480012e-02f, -3.41971684e-03f, -9.28837731e-02f, -2.64297538e-02f, -4.68202718e-02f, -1.87128577e-02f, 9.10458714e-02f, 8.26752111e-02f, 7.69643784e-02f, -3.74546251e-03f,
  2.98340991e-02f, 1.74848691e-01f, 2.05981638e-02f, 7.84794688e-02f, 4.53832336e-02f, 6.15658723e-02f, 5.13176322e-02f, 2.84463614e-02f, 2.03718930e-01f, 5.23938984e-02f,
  3.79076242e-01f, -2.02332720e-01f, 7.39390217e-03f, 1.09499589e-01f, 2.06254750e-01f, 1.24362506e-01f, -1.54844224e-02f, 1.89418942e-02f, 1.73425794e-01f, 1.64971858e-01f,
  1.49538606e-01f, 1.33521736e-01f, 2.32617855e-01f, 6.33000061e-02f, 5.97770251e-02f, 1.76776629e-02f, 9.05770734e-02f, -2.69176513e-02f, 1.38258711e-01f, 4.68356833e-02f,
  3.46686170e-02f, -3.60827707e-02f, -1.16193242e-01f, 2.75281407e-02f, -6.47423416e-02f, 1.38739377e-01f, 4.87154610e-02f, -7.25156292e-02f, 4.52920981e-02f, -1.84880897e-01f,
  -2.70087391e-01f, -1.47794530e-01f, 1.00455202e-01f, 1.63344871e-02f, -6.15298562e-02f, -1.01511709e-01f, -3.87655608e-02f, -1.31182939e-01f, -1.29335925e-01f, -3.34160998e-02f,
  -1.31947979e-01f, -5.83446063e-02f, -7.48752207e-02f, -5.82327545e-02f, -6.62212968e-02f, -7.62339458e-02f, -1.55913532e-01f, 6.65977374e-02f, 6.04064763e-02f, 8.21665209e-03f,
  7.63981417e-02f, 1.00721821e-01f, 1.34459689e-01f, 9.99268889e-02f, 5.30889854e-02f, 4.00601961e-02f, -3.15531008e-02f, -4.87502757e-03f, 1.58766851e-01f, 9.04154126e-03f,
  1.48090541e-01f, 1.46092847e-01f, -2.53036134e-02f, 4.22656313e-02f, 7.65681441e-04f, 4.41958942e-02f, 3.89990993e-02f, 9.34235007e-02f, 1.16227061e-01f, -5.94599657e-02f,
  -6.53519183e-02f, 9.24412012e-02f, -2.49697547e-02f, 6.56234771e-02f, 5.68412840e-02f, -7.04086870e-02f, -3.58012542e-02f, -1.17386699e-01f, -1.03490084e-01f, -2.87543237e-02f,
  6.75901026e-02f, -1.24187479e-02f, -1.13634586e-01f, -1.23699240e-01f, -2.22090743e-02f, 1.17361307e-01f, 6.53009862e-02f, -9.75156203e-02f, -2.92225350e-02f, -4.32715937e-02f,
  -5.51840849e-02f, 1.67426959e-01f, 9.33106914e-02f, -3.58854644e-02f, -2.01437443e-01f, -1.34385854e-01f, -6.78388448e-03f, -1.59043700e-01f, -1.08412214e-01f, -1.04813181e-01f,
  -2.69839764e-02f, -1.23855941e-01f, -4.76988666e-02f, 4.68113422e-02f, 4.48707081e-02f, -3.13715301e-02f, -1.03176363e-01f, 1.18482977e-01f, -5.30819967e-03f, -1.16617590e-01f,
  -5.91180399e-02f, 1.01020329e-01f, 2.41325051e-01f, 2.43240297e-01f, 2.04853252e-01f, 1.62956983e-01f, 8.61646309e-02f, 3.70800607e-02f, 4.96850759e-02f, 3.90199088e-02f,
  -4.33333009e-01f, 2.38026068e-01f, 1.20297022e-01f, -2.79200137e-01f, 1.64170936e-01f, 2.04866931e-01f, 2.62756288e-01f, 1.81835920e-01f, -1.15868323e-01f, 9.99200940e-02f,
  7.91804492e-02f, -1.54221997e-01f, 3.19140814e-02f, 9.29947421e-02f, 8.34458545e-02f, 2.86417693e-01f, 1.15170568e-01f, 7.43917050e-03f, -1.74619511e-01f, -1.44362360e-01f,
  4.89735045e-02f, -2.02442363e-01f, -3.43751729e-01f, -1.14009850e-01f, -4.10325937e-02f, -1.48364566e-02f, 4.85549383e-02f, -8.31112191e-02f, 1.83845967e-01f, -1.40741244e-02f,
  -1.80642202e-01f, -2.18907863e-01f, 8.65190998e-02f, -8.09569210e-02f, -8.46598595e-02f, -7.77211115e-02f, 3.70720625e-02f, -5.62494993e-02f, 2.21694391e-02f, -7.58773647e-03f,
  -9.61929038e-02f, -1.41087979e-01f, -1.54550485e-02f, -4.63957861e-02f, -8.79112110e-02f, -8.46133847e-03f, 3.91833708e-02f, -1.25349253e-01f, -6.08238466e-02f, 1.97562426e-02f,
  1.17588863e-01f, 2.60345954e-02f, -6.91814423e-02f, 3.48806120e-02f, 1.16991296e-01f, -4.39184122e-02f, -2.33614049e-03f, -1.36589840e-01f, 6.00354746e-02f, -1.00652412e-01f,
  2.70790476e-02f, 5.87449595e-02f, 2.70689409e-02f, -3.99581566e-02f, -1.35473937e-01f, 1.81078271e-03f, -3.25458776e-03f, -3.51196229e-02f, 2.26561707e-02f, -8.22637528e-02f,
  8.68438929e-02f, 7.95225799e-02f, -5.46266846e-02f, -6.62767142e-02f, 5.54122664e-02f, 5.14674895e-02f, 6.42813649e-03f, 3.07271946e-02f, -4.68972996e-02f, 8.58608559e-02f,
  -6.94814324e-02f, 8.66289344e-03f, -6.09761290e-02f, -7.22918510e-02f, 6.60684798e-03f, 5.11791855e-02f, 3.90649103e-02f, 7.75568709e-02f, -4.43787202e-02f, 6.56118691e-02f,
  -2.91201115e-01f, -2.45998260e-02f, -7.44348345e-03f, -5.01170717e-02f, -1.44368082e-01f, -4.49360162e-03f, -1.13845163e-03f, -3.17756012e-02f, 9.03802738e-02f, -1.15502002e-02f,
  1.08936556e-01f, -3.32197621e-02f, -5.00196330e-02f, 1.67108756e-02f, 3.46845202e-02f, 5.98297976e-02f, 1.85567662e-02f, 5.56701720e-02f, -2.79889647e-02f, 1.52357835e-02f,
  9.78123769e-02f, 5.01630269e-03f, -1.39883325e-01f, 9.67058390e-02f, 6.20764829e-02f, -6.57583475e-02f, -6.19583391e-03f, -5.06132729e-02f, 6.10361397e-02f, -8.95880312e-02f,
  8.57332572e-02f, 2.51575291e-01f, 6.60683066e-02f, 7.46237263e-02f, 1.63261682e-01f, 1.74306735e-01f, 3.15060467e-01f, 1.73803687e-01f, -4.29034494e-02f, 2.21702512e-02f,
  1.03316873e-01f, 7.49363601e-02f, -4.09019478e-02f, 5.66307306e-02f, -2.12650094e-02f, 3.77426557e-02f, -1.38823688e-01f, -1.28274187e-01f, 1.31589100e-02f, 3.81308123e-02f,
  -7.51540661e-02f, -1.00738704e-01f, -3.50276344e-02f, -5.89607581e-02f, 5.21131195e-02f, -1.76012535e-02f, -8.83736182e-03f, -4.00499254e-02f, -2.52908636e-02f, -1.26164109e-01f,
  5.97013161e-02f, 1.67582333e-01f, -1.02532804e-02f, 3.33300047e-02f, -1.90645887e-03f, 1.73930209e-02f, -3.07966974e-02f, -8.99465382e-02f, 6.88630342e-02f, -1.11793995e-01f,
  -9.38623864e-03f, 7.26075992e-02f, 1.31630525e-01f, -2.63524968e-02f, 6.07422106e-02f, 2.14758180e-02f, 3.76689807e-02f, 7.28569329e-02f, -3.01496200e-02f, 1.08373322e-01f,
  3.40051427e-02f, 5.19970953e-02f, 1.38360515e-01f, -1.02022337e-02f, 1.92741781e-01f, -6.39908761e-02f, 2.82697808e-02f, 1.51154548e-01f, 6.44199476e-02f, 2.13217689e-03f,
  -5.01371250e-02f, 4.46868055e-02f, -9.16510224e-02f, 8.81867930e-02f, 2.78601721e-02f, 9.79824141e-02f, -8.42239261e-02f, 2.33043656e-02f, 7.78278932e-02f, 5.44723049e-02f,
  -1.33492071e-02f, 6.74916431e-02f, 9.72153619e-03f, 9.30161849e-02f, 3.67062576e-02f, 2.06435518e-03f, 5.11779338e-02f, 5.71408346e-02f, 2.97446437e-02f, 1.00225039e-01f,
  7.21053183e-02f, 6.02468178e-02f, 6.41787723e-02f, -6.22347137e-03f, 4.12869826e-02f, -3.00135482e-02f, 1.39881242e-02f, -3.48735973e-02f, 6.16807565e-02f, -4.71044928e-02f,
  -2.43446767e-01f, 1.56683609e-01f, -1.79419622e-01f, -8.51498023e-02f, 5.04313745e-02f, -6.62965849e-02f, -8.28841701e-02f, -4.73462567e-02f, -2.64426153e-02f, -1.25118747e-01f,
  -1.13869950e-01f, -1.19762041e-01f, 5.05213961e-02f, -4.71755341e-02f, -1.20103158e-01f, -6.71665296e-02f, -3.47203482e-03f, 4.78004152e-03f, -1.00706862e-02f, -1.01672653e-02f,
  -3.42747979e-02f, -1.36038318e-01f, -1.98751882e-01f, -1.22457601e-01f, -3.75940166e-02f, -1.61864951e-01f, -2.66358964e-02f, -1.00748673e-01f, -2.26372443e-02f, -1.15637727e-01f,
  -9.51726437e-02f, 3.49382639e-01f, 2.12528735e-01f, -2.17773303e-01f, 1.89242259e-01f, 2.12541983e-01f, 4.33586091e-01f, 8.16978812e-02f, -1.59225166e-01f, 8.73603746e-02f,
  2.27688342e-01f, -1.41018003e-01f, -2.78838743e-02f, 6.83991462e-02f, 1.68209240e-01f, 1.10243715e-01f, -5.17779626e-02f, -6.56651929e-02f, -1.16767608e-01f, -1.61264896e-01f,
  -7.35715106e-02f, -1.42813683e-01f, -2.63753861e-01f, -1.61955938e-01f, -2.01293007e-01f, -1.74882263e-01f, 6.57149628e-02f, 8.32473263e-02f, 8.04329142e-02f, -2.29414821e-01f,
  -1.09742254e-01f, 1.91923082e-01f, -8.84994864e-02f, -3.30284946e-02f, 9.93003920e-02f, -1.73455328e-01f, -7.01287761e-02f, -9.43447277e-02f, 1.14558097e-02f, -1.48018003e-01f,
  5.74007891e-02f, 2.70102918e-02f, -3.57851349e-02f, 1.33081130e-03f, -7.83480238e-03f, -2.29567848e-03f, -1.04688443e-01f, 4.70802141e-03f, 7.22879078e-03f, 9.30060670e-02f,
  -4.64066714e-02f, 8.18604454e-02f, 1.13140173e-01f, 5.79684079e-02f, 5.02684079e-02f, -8.44038054e-02f, 2.07266092e-01f, 2.06394382e-02f, 2.92376932e-02f, -1.78827584e-01f,
  -8.34675804e-02f, 7.91151971e-02f, -1.98347420e-02f, -4.86613512e-02f, 2.07207184e-02f, -2.58248328e-04f, 3.29932868e-02f, 6.37372360e-02f, -8.93960707e-03f, -8.55367258e-02f,
  9.53915436e-03f, -4.00600247e-02f, 2.97227912e-02f, -4.12528627e-02f, -5.81819005e-02f, -1.18313928e-03f, 3.14477943e-02f, -4.06055264e-02f, 7.61963129e-02f, -7.67953172e-02f,
  -2.60832272e-02f, -2.88313255e-02f, -4.06855792e-02f, -1.23794436e-01f, -5.99409081e-02f, 8.95571057e-03f, -1.97866574e-01f, -8.92963856e-02f, -1.60944402e-01f, -4.77482341e-02f,
  -1.73500687e-01f, 4.86681163e-02f, -2.01390669e-01f, 3.69470529e-02f, 1.10900998e-01f, 7.24447817e-02f, 1.51581481e-01f, -1.48057593e-02f, 1.25671551e-01f, 2.05595270e-02f,
  8.23154226e-02f, -4.78029735e-02f, 4.03697304e-02f, 3.77500132e-02f, -4.11120802e-02f, 5.61631359e-02f, -4.48787846e-02f, -2.05130689e-02f, -2.70889848e-02f, -1.87804662e-02f,
  6.75591175e-03f, -9.72606391e-02f, -1.76589116e-01f, -1.63887814e-01f, -3.29790205e-01f, -1.75626189e-01f, -1.88809801e-02f, -1.29546389e-01f, -3.19383852e-03f, -1.91677511e-01f,
  -1.62849426e-01f, -2.13437542e-01f, 1.33643880e-01f, -2.95673497e-02f, -9.90988985e-02f, -1.99471608e-01f, -3.34642172e-01f, -1.03313737e-02f, -4.79535982e-02f, -7.61000514e-02f,
  -4.06406522e-02f, 5.61092459e-02f, 1.60382971e-01f, 1.12336807e-01f, 3.02985869e-02f, -1.27958298e-01f, 2.90770419e-02f, 2.44724706e-01f, 2.00870231e-01f, 6.57102019e-02f,
  -2.60968190e-02f, 2.87412535e-02f, 1.62023947e-01f, 2.29432598e-01f, 1.36890888e-01f, -1.32310865e-02f, 7.58661255e-02f, 3.15038934e-02f, 4.06212024e-02f, 7.79678300e-02f,
  -8.30465648e-03f, 2.39190776e-02f, 2.64660586e-02f, -2.43913680e-02f, -4.43201549e-02f, -1.12064434e-02f, -2.70968582e-02f, 8.66551772e-02f, -4.49910853e-03f, 3.68981361e-02f,
  -9.78779420e-02f, -1.57114416e-02f, -1.08703896e-01f, -2.80240010e-02f, -1.41388088e-01f, -8.75426009e-02f, 1.14968829e-02f, 5.16161621e-02f, 1.25133157e-01f, 3.72363720e-03f,
  -1.08583190e-01f, -1.03248879e-02f, -3.18411761e-03f, -5.12890778e-02f, 3.87683604e-03f, 4.48579229e-02f, 7.94845074e-02f, 3.65220383e-02f, 1.46617964e-02f, -5.39297909e-02f,
  5.15468530e-02f, 9.96437483e-03f, -1.01268001e-01f, -6.40782565e-02f, -8.51630792e-02f, 2.60531921e-02f, 3.62532996e-02f, 5.56628406e-03f, 4.45135050e-02f, -1.29952326e-01f,
  3.46809924e-02f, 4.53237481e-02f, 4.64796424e-02f, 6.58439174e-02f, 1.55028805e-01f, -2.71463711e-02f, -2.18737256e-02f, 5.49465083e-02f, 8.12954307e-02f, -4.71956853e-04f,
  5.91865145e-02f, 2.48678252e-02f, -2.36908775e-02f, 1.79529432e-02f, 7.28543773e-02f, 6.47893846e-02f, -1.96943339e-02f, -3.53102665e-03f, 1.15665756e-01f, 3.04326490e-02f,
  -1.91909298e-01f, 5.82739748e-02f, -1.37556061e-01f, -1.32346034e-01f, -4.62091947e-03f, 5.25374971e-02f, -5.28378263e-02f, -8.83988338e-04f, -5.32450005e-02f, 1.59324345e-03f,
  -3.00848149e-02f, 7.89605156e-02f, -7.87870213e-02f, -6.54079253e-03f, -1.21655881e-01f, -5.46360724e-02f, -2.20215619e-01f, -1.18863918e-01f, -6.23593247e-03f, -5.21348976e-02f,
  -1.15100600e-01f, -2.26904184e-01f, -2.09823504e-01f, -1.55503631e-01f, -1.12098813e-01f, -1.83504760e-01f, -2.59630773e-02f, -2.20413804e-02f, -1.94755688e-01f, -2.83224702e-01f,
  2.00692162e-01f, 2.43009150e-01f, 2.23911032e-01f, 2.48637289e-01f, 1.74229607e-01f, 1.59686550e-01f, 1.80564910e-01f, 1.77202150e-01f, 8.23497847e-02f, 2.15854257e-01f,
  8.16959441e-02f, 8.55079740e-02f, 2.25646615e-01f, 8.64519551e-02f, 2.25617155e-01f, 2.01547787e-01f, 9.85983312e-02f, 7.89875537e-02f, 1.25032496e-02f, 1.63889289e-01f,
  1.04566962e-01f, 9.54160541e-02f, -3.34806293e-02f, 6.44445345e-02f, 4.56700921e-02f, 1.00423306e-01f, 1.11589529e-01f, 1.36408210e-01f, 1.20601825e-01f, 8.13649222e-02f,
  -7.43606389e-02f, 8.83470997e-02f, -7.22327381e-02f, -5.62426932e-02f, -4.43750918e-02f, -9.30376872e-02f, -4.49079201e-02f, 3.13737579e-02f, 3.45021039e-02f, 9.64264423e-02f,
  -7.48058185e-02f, -8.27961639e-02f, -1.12558208e-01f, -5.80270626e-02f, 8.87416489e-03f, -1.27152771e-01f, -1.04415677e-01f, 7.24537447e-02f, 2.58818436e-02f, 5.91898710e-02f,
  9.78204608e-03f, -3.88270104e-03f, -5.95648997e-02f, 2.01636050e-02f, 3.40973809e-02f, -7.24307746e-02f, -2.98046693e-02f, -8.58382806e-02f, -3.73103432e-02f, 6.36291504e-02f,
  1.71979368e-01f, 5.43594081e-03f, 2.82757753e-03f, 8.52950104e-03f, 2.28335522e-02f, -7.87816197e-02f, -2.26799212e-02f, 5.67100849e-03f, 8.88078213e-02f, -1.19936086e-01f,
  -1.02159925e-01f, 6.55099526e-02f, 9.64659899e-02f, 3.64995375e-02f, 3.19796316e-02f, -3.39779742e-02f, 1.52706625e-02f, 1.75592061e-02f, -1.33074760e-01f, -1.57575294e-01f,
  -3.48260105e-02f, 1.78564955e-02f, -1.39555261e-01f, -5.85758537e-02f, 2.69263424e-02f, -2.02716142e-03f, 4.62447479e-03f, -5.87673709e-02f, -9.82319862e-02f, -3.06584942e-03f,
  -4.36017215e-02f, -7.04283491e-02f, -9.34916511e-02f, -5.05133718e-02f, -1.02663159e-01f, -4.95985299e-02f, 6.19778819e-02f, 6.70009032e-02f, 7.12791830e-02f, 5.71715459e-02f,
  -3.85726131e-02f, -3.42137665e-02f, -1.22057669e-01f, -1.59038052e-01f, -7.01809525e-02f, -2.14791596e-02f, -1.35105914e-02f, 6.42355010e-02f, 7.67765045e-02f, 9.91281029e-03f,
  2.22391915e-02f, 8.31056312e-02f, 2.09735371e-02f, 2.72041317e-02f, 3.99322771e-02f, -9.49366987e-02f, -4.94712479e-02f, -1.46908641e-01f, -7.67267048e-02f, -3.38494070e-02f,
  2.46880725e-02f, -2.34620467e-01f, -2.10857108e-01f, -6.85068965e-02f, -1.10098004e-01f, -2.16476172e-01f, -2.77637064e-01f, -7.50262290e-03f, 9.90596488e-02f, -2.92016655e-01f,
  -1.23276763e-01f, 9.97842476e-02f, -3.20122316e-02f, 7.84685835e-02f, 1.30447432e-01f, -2.55238712e-01f, -8.17066059e-02f, 5.10933660e-02f, 2.45288253e-01f, 7.59545490e-02f,
  -4.14419845e-02f, 1.04286574e-01f, 1.19076565e-01f, 4.75946181e-02f, -1.90968037e-01f, -7.29981214e-02f, -1.35021999e-01f, -8.55948925e-02f, -1.26455858e-01f, -3.28027248e-01f,
  -2.55739570e-01f, -1.02189489e-01f, 1.01807334e-01f, 1.42134577e-01f, -4.35319245e-02f, 9.49144661e-02f, -7.44585842e-02f, 9.39382687e-02f, 7.72984549e-02f, -6.95991963e-02f,
  -1.23070367e-01f, 6.57351315e-02f, 1.05072848e-01f, -7.28405192e-02f, -4.09435146e-02f, -1.19639570e-02f, 8.18718374e-02f, 1.29144877e-01f, 3.66702788e-02f, -2.38702167e-02f,
  -6.25274256e-02f, -1.34915560e-01f, -1.06307350e-01f, -2.83595622e-02f, -3.32329655e-03f, 1.03319377e-01f, -1.06902592e-01f, -2.61738207e-02f, 5.51367179e-02f, -2.57298291e-01f,
  -7.78690577e-02f, -7.22103044e-02f, 3.62247638e-02f, -1.50034325e-02f, 5.15791364e-02f, 6.46119565e-02f, -6.88712969e-02f, -2.56120395e-02f, 7.92406723e-02f, -1.25048747e-02f,
  1.07199177e-02f, 1.32047655e-02f, 7.90888667e-02f, 2.30844300e-02f, -7.03540118e-03f, 6.33271486e-02f, -9.11741983e-03f, -4.96351346e-03f, -1.20059755e-02f, 5.97963519e-02f,
  -7.17205405e-02f, -3.04354094e-02f, 1.67707149e-02f, 7.46100768e-03f, -1.01601288e-01f, -1.41266426e-02f, -3.76555026e-02f, 2.56884135e-02f, -6.38714582e-02f, -6.35911524e-02f,
  -5.42090237e-02f, 1.65754393e-01f, -1.95385188e-01f, 1.63400285e-02f, -2.85953786e-02f, 1.56388860e-02f, -1.35555610e-01f, 9.66740027e-02f, -1.80130545e-03f, -6.78830296e-02f,
  -6.47255452e-03f, 5.27780503e-02f, -5.57407215e-02f, 7.04833027e-03f, 8.04389939e-02f, 8.91545322e-03f, -1.30819036e-02f, 2.85287425e-02f, 2.58526765e-02f, 6.59197122e-02f,
  6.33154511e-02f, -6.87376931e-02f, 8.82977322e-02f, 1.20282844e-01f, 8.64795130e-03f, 1.06165826e-01f, -5.23620322e-02f, -1.33968711e-01f, 8.54493454e-02f, -9.79137570e-02f,
  -2.56359041e-01f, -4.70470414e-02f, 5.04412018e-02f, -1.95298865e-02f, 2.98903789e-02f, -7.05859810e-02f, -2.98961878e-01f, -2.40793869e-01f, -1.63470209e-02f, -1.00281216e-01f,
  2.61047892e-02f, 1.35000393e-01f, -9.42786876e-03f, -2.88779438e-02f, -2.14327350e-01f, 8.18074960e-03f, 1.19022235e-01f, 5.86862564e-02f, -1.28200829e-01f, -5.62891513e-02f,
  1.25164270e-01f, 3.81214991e-02f, 1.38590494e-02f, 1.79798324e-02f, 1.17128186e-01f, -8.64229538e-03f, 1.11714169e-01f, 2.68222392e-02f, 1.55086771e-01f, 3.41416121e-01f,
  8.38073716e-02f, -1.27947271e-01f, -1.08475581e-01f, 8.73812139e-02f, -3.78556270e-03f, -1.76416361e-04f, -8.13025534e-02f, 7.24655809e-03f, -5.91961443e-02f, -6.29674196e-02f,
  1.88052319e-02f, 6.67364672e-02f, 5.96384481e-02f, -1.42932191e-01f, -1.61774397e-01f, -1.99450627e-01f, -1.02777248e-02f, -1.46433324e-01f, -8.43256563e-02f, -9.47230533e-02f,
  9.08723027e-02f, 8.11416432e-02f, -8.06632712e-02f, -1.09448873e-01f, -8.15643296e-02f, 2.16518771e-02f, -1.27670959e-01f, -2.87987255e-02f, -1.84651673e-01f, -1.12530224e-01f,
  -2.18176618e-02f, 1.20640630e-02f, -2.80740354e-02f, 1.04571946e-01f, -3.99699342e-03f, -1.27522480e-02f, 1.44181758e-01f, 2.63533201e-02f, -5.69446385e-02f, 5.40747717e-02f,
  3.13099008e-04f, -1.90838650e-02f, 4.31948975e-02f, -2.30349973e-03f, 2.97269039e-02f, -8.09346698e-03f, 8.38070922e-03f, -1.62371788e-02f, 4.49792802e-04f, -4.98693855e-03f,
  4.62731346e-02f, 3.09613962e-02f, 4.31458512e-03f, 6.95878714e-02f, 6.49187788e-02f, -8.29155818e-02f, 3.15581970e-02f, -1.31039051e-02f, -1.25966817e-02f, -1.98875386e-02f,
  -1.64171562e-01f, 8.92873406e-02f, -4.99552824e-02f, -6.89032972e-02f, -1.36650242e-02f, -5.65639175e-02f, 1.24253899e-01f, 2.30040532e-02f, 2.37791166e-02f, -1.12613134e-01f,
  -1.40604004e-01f, -6.76808134e-02f, -3.95178422e-02f, -5.93475439e-02f, -1.71495095e-01f, -1.16149835e-01f, -5.75489253e-02f, -8.29456374e-02f, -8.28310996e-02f, -3.20673641e-03f,
  -7.45519297e-03f, -2.23820746e-01f, -1.92175910e-01f, -1.51468351e-01f, -1.09335430e-01f, -1.67855665e-01f, -1.69621617e-01f, -5.63132279e-02f, -2.62140930e-01f, -2.18354672e-01f,
  -5.18775523e-01f, -9.27759111e-02f, 6.17360622e-02f, -2.53515095e-01f, -1.55406341e-01f, 2.91378833e-02f, 1.80373732e-02f, -3.35918218e-02f, -1.54842019e-01f, -5.59557378e-02f,
  1.46587715e-02f, 9.27767809e-03f, 4.12559174e-02f, 1.62962914e-01f, 9.01597552e-03f, 1.07533410e-01f, -9.57721248e-02f, 7.33709112e-02f, 3.46547626e-02f, -2.48183981e-02f,
  -6.47111088e-02f, -1.31844550e-01f, -1.93556964e-01f, -2.03952312e-01f, -1.14694171e-01f, -9.02132764e-02f, -6.95363879e-02f, -1.19729951e-01f, -8.68410319e-02f, -2.19105110e-01f,
  4.82594341e-01f, 6.03499562e-02f, -1.79731182e-03f, -1.10788411e-02f, 2.57848669e-02f, -1.16027102e-01f, -6.60565868e-03f, 6.37173280e-02f, 2.71764137e-02f, 6.79536462e-02f,
  9.28625185e-03f, 1.67082343e-02f, 4.75293435e-02f, 1.11039095e-01f, 1.29827902e-01f, 3.03558633e-02f, -4.28269058e-02f, 1.38717249e-01f, 1.65049344e-01f, 1.32395267e-01f,
  -3.07832900e-02f, 1.20642252e-01f, 1.86211616e-01f, 1.26855820e-01f, 7.46488273e-02f, -2.84736860e-03f, 1.49321482e-01f, 7.34884068e-02f, 1.12304300e-01f, 2.76018959e-02f,
  2.28296425e-02f, -1.06183171e-01f, 6.52123466e-02f, 4.02372256e-02f, 8.69068876e-02f, 1.12046644e-01f, 1.27421349e-01f, 5.48884086e-02f, 3.28554325e-02f, 5.98711185e-02f,
  7.10594803e-02f, 1.61021113e-01f, 8.28266144e-02f, -5.67907840e-02f, -6.26034513e-02f, -3.48383784e-02f, -4.81940210e-02f, 1.49006993e-02f, 2.11290121e-02f, 5.74179664e-02f,
  4.27077338e-02f, -4.48616520e-02f, -1.94856867e-01f, 5.10510895e-03f, -2.40296759e-02f, 9.00396407e-02f, 1.13534378e-02f, -7.21858861e-03f, -5.89298494e-02f, -6.48576319e-02f,
  2.66189635e-01f, 1.32806152e-01f, 8.17475934e-03f, -1.76435709e-01f, -1.71927452e-01f, -5.92644066e-02f, -7.01556578e-02f, -8.26104283e-02f, -8.99182912e-03f, 1.36535689e-01f,
  1.00486574e-03f, -2.48270817e-02f, 4.50324314e-03f, 9.88059863e-02f, -1.68344770e-02f, -4.37921248e-02f, 3.58928042e-03f, 5.95944040e-02f, -5.47779202e-02f, -5.94974943e-02f,
  -5.23866042e-02f, -5.34394123e-02f, 1.54679298e-01f, 1.23357154e-01f, -2.51563862e-02f, 9.52163488e-02f, 1.41898215e-01f, 1.09116711e-01f, 2.57308204e-02f, 8.11266899e-02f,
  1.65651172e-01f, -6.03705645e-02f, -5.03794074e-01f, 1.13748372e-01f, -1.88913479e-01f, -1.93545058e-01f, -1.58317685e-01f, 8.95879939e-02f, 1.61585763e-01f, -5.48684970e-02f,
  -9.70592257e-03f, 5.01863137e-02f, 2.50896290e-02f, -1.21803038e-01f, -2.08808258e-01f, -3.11097652e-01f, -2.16585815e-01f, -3.52401286e-01f, -1.95956916e-01f, -7.18220994e-02f,
  -1.44748285e-01f, -1.28571182e-01f, -1.56325251e-01f, -1.07651100e-01f, -1.47388488e-01f, -1.83283776e-01f, -2.79005945e-01f, -3.03739280e-01f, -2.78447270e-01f, -3.88167888e-01f,
  -3.88806313e-01f, -1.27254128e-01f, 5.40299602e-02f, 6.68861121e-02f, 5.80846108e-02f, 7.41525143e-02f, 5.83132766e-02f, 1.76035210e-01f, 1.97090581e-01f, 8.76616463e-02f,
  -2.35084593e-02f, -9.53864958e-03f, 8.43298584e-02f, 1.72126312e-02f, -1.76532548e-02f, 1.00749359e-01f, 6.65019229e-02f, 5.92342438e-03f, 3.07514351e-02f, 1.28626525e-01f,
  1.39271900e-01f, -3.24376076e-02f, 3.66383418e-02f, 3.81666198e-02f, -4.90088947e-02f, 3.90819907e-02f, -8.54449943e-02f, -2.32025422e-02f, -1.73521247e-02f, 4.59758081e-02f,
  1.77251827e-02f, -4.69349064e-02f, -4.89624403e-02f, -3.39562912e-03f, 1.31404310e-01f, 5.07643484e-02f, -5.75405918e-02f, 1.61495768e-02f, -4.16034944e-02f, 3.12834829e-02f,
  1.85311064e-01f, -2.87428275e-02f, 8.35596099e-02f, -6.06927052e-02f, -1.27883434e-01f, -7.83637911e-02f, -1.10724181e-01f, 2.88534025e-03f, 4.41817120e-02f, 1.35031745e-01f,
  1.17127419e-01f, 2.49871574e-02f, -1.06654555e-01f, -3.91124971e-02f, -3.27043049e-02f, -3.63635533e-02f, -6.90082684e-02f, -1.17556779e-02f, 3.40580801e-03f, 1.64169054e-02f,
  9.56087038e-02f, -2.22923383e-01f, -6.48482293e-02f, -4.98420850e-04f, -5.03080934e-02f, 5.16731516e-02f, 9.44446474e-02f, 8.12537521e-02f, 1.10808555e-02f, 3.39478254e-02f,
  2.98140775e-02f, -4.64705527e-02f, 8.54998082e-02f, 1.44186974e-01f, 9.18796137e-02f, -1.03002936e-02f, 8.72307122e-02f, -8.77392758e-03f, -1.05048552e-01f, 4.13381793e-02f,
  1.46840796e-01f, 1.63786560e-01f, 1.32383943e-01f, 8.29120427e-02f, 1.72262155e-02f, -9.76199955e-02f, -1.22832142e-01f, -7.81312585e-02f, -1.79239675e-01f, 3.42103988e-02f,
  -1.90910757e-01f, -4.23462801e-02f, -1.45713836e-01f, 8.27663168e-02f, 2.23294109e-01f, -1.47527874e-01f, -2.06875965e-01f, -3.18621904e-01f, 3.68234590e-02f, -3.14240344e-02f,
  1.19519934e-01f, 1.88144594e-01f, 1.13659531e-01f, -5.32520190e-02f, -1.87036917e-01f, -1.34799629e-01f, 7.49296546e-02f, 2.90837903e-02f, -1.14241675e-01f, 5.53048104e-02f,
  2.13638946e-01f, 1.55036822e-01f, -2.36892328e-02f, -6.53688088e-02f, 1.22262441e-01f, 1.74029931e-01f, -4.06235777e-04f, 9.78424326e-02f, 4.18839678e-02f, 2.81528503e-01f,
  4.81554195e-02f, -9.62840393e-02f, 6.62818626e-02f, 2.11409584e-01f, 3.63788456e-02f, -9.83570740e-02f, -1.66178979e-02f, -7.37124160e-02f, -8.02029893e-02f, -9.32645127e-02f,
  1.73962727e-01f, 3.37591358e-02f, 1.20311677e-01f, 3.54232378e-02f, -6.91575035e-02f, -1.05636723e-01f, -1.35080546e-01f, -1.81986332e-01f, -2.12573558e-01f, -1.68667912e-01f,
  1.74206316e-01f, 1.91524938e-01f, -1.38915733e-01f, -2.35575780e-01f, -1.60970271e-01f, 6.27049804e-02f, -7.19356090e-02f, -6.29155487e-02f, -2.79973298e-01f, -1.38469636e-01f,
  -6.80571198e-02f, -1.59843415e-02f, -8.63422453e-02f, -4.84949052e-02f, -3.21458839e-03f, 1.08368546e-01f, 8.04529861e-02f, 1.04968362e-01f, 1.69684980e-02f, -6.57493845e-02f,
  -6.44356757e-02f, -2.15877797e-02f, -3.33537646e-02f, -9.97250974e-02f, 5.43392487e-02f, 1.93553921e-02f, 1.46593200e-02f, -8.88190418e-02f, -5.00487275e-02f, -3.40005793e-02f,
  -2.51849536e-02f, 6.94970712e-02f, 8.73052999e-02f, 3.33625823e-02f, -2.24952977e-02f, -4.10333127e-02f, -2.52953451e-03f, -1.90952588e-02f, -1.38498574e-01f, 1.84640680e-02f,
  4.36718995e-03f, -4.10145968e-02f, 1.08168181e-02f, 5.81464320e-02f, 6.53253347e-02f, 2.97624934e-02f, -8.93432274e-03f, -2.67292885e-03f, 8.21796432e-03f, -7.75311887e-02f,
  -9.93218720e-02f, -5.94875515e-02f, 4.32038084e-02f, 8.07812158e-03f, -1.25939539e-02f, 7.94342486e-04f, 1.98283065e-02f, 1.17458757e-02f, -2.18100883e-02f, 3.53955105e-02f,
  -1.51932286e-02f, -1.42167330e-01f, -1.38822824e-01f, -1.07561007e-01f, -1.83951743e-02f, 1.23319039e-02f, -7.31345192e-02f, -6.18589409e-02f, -1.10193454e-01f, -2.52521068e-01f,
  1.62447900e-01f, -1.18844518e-02f, 1.46046743e-01f, 6.75318297e-03f, -9.23428088e-02f, -9.30008963e-02f, -8.34828615e-02f, -7.21342713e-02f, -1.10303998e-01f, 2.26862635e-02f,
  -2.19752244e-03f, 5.00197746e-02f, 1.23620443e-01f, 8.05929303e-02f, 1.87499896e-01f, 1.74612418e-01f, 1.40586168e-01f, 3.23476315e-01f, 1.33223578e-01f, 5.57004362e-02f,
  7.68107325e-02f, 7.78363794e-02f, 6.70196488e-02f, 1.29663525e-02f, 1.13784045e-01f, 5.46413697e-02f, -1.40445689e-02f, 1.00290142e-01f, 3.64731289e-02f, 1.19464725e-01f,
  6.98744655e-02f, -8.79211873e-02f, -1.51129782e-01f, 1.04856238e-01f, 8.38083699e-02f, -8.11610520e-02f, -1.31590575e-01f, -7.00722774e-03f, -3.30223627e-02f, -9.48025957e-02f,
  8.58651772e-02f, 2.54884250e-02f, 2.21751798e-02f, 2.09296457e-02f, -4.91939150e-02f, 2.30877604e-02f, 2.29388326e-01f, 2.21176341e-01f, 2.15759709e-01f, 2.35827807e-02f,
  -7.36347691e-04f, -9.11334455e-02f, -1.25642896e-01f, -3.43769528e-02f, -3.71468440e-02f, 7.64708742e-02f, 1.41638992e-02f, 5.80332987e-02f, -3.93502600e-02f, 1.02019526e-01f,
  -2.65956540e-02f, 3.79186980e-02f, 1.01362012e-01f, 6.59887269e-02f, 3.30873989e-02f, -1.27998710e-01f, 5.52541204e-02f, -2.73738392e-02f, 5.65997371e-03f, -2.16915887e-02f,
  -3.98015603e-02f, -1.63427833e-03f, -8.05162042e-02f, -9.05079916e-02f, -4.57219221e-03f, -4.01820056e-02f, -2.98042241e-02f, -5.60929403e-02f, -1.24152517e-02f, -9.16272327e-02f,
  5.53644821e-03f, -3.38809974e-02f, -1.16366789e-01f, 7.56535903e-02f, -3.54030579e-02f, 5.59861362e-02f, -3.21790716e-03f, -1.08315192e-01f, 4.26806882e-03f, -8.45125094e-02f,
  -1.70755222e-01f, -6.56095818e-02f, 1.57315377e-02f, 1.22263823e-02f, 6.46234751e-02f, 2.06031650e-02f, -1.10607244e-01f, 6.76521659e-02f, -4.18429673e-02f, -5.25922514e-02f,
  -7.55852386e-02f, -3.27998698e-02f, -8.75140354e-02f, -9.73422378e-02f, 9.60185472e-03f, -1.58511605e-02f, 1.31206131e-02f, 6.39755726e-02f, 6.19575866e-02f, 3.24065425e-02f,
  -2.68035326e-02f, -2.03422263e-01f, -2.11760193e-01f, -1.46509200e-01f, -1.69380799e-01f, -2.24479392e-01f, -1.98385194e-01f, -9.02008191e-02f, -1.51493594e-01f, -1.88007534e-01f,
  -2.04356834e-01f, -2.24057272e-01f, -1.02660038e-01f, -2.41918832e-01f, 7.58969560e-02f, -7.55953193e-02f, -9.67498198e-02f, -1.07830897e-01f, -5.11862710e-02f, -1.18971422e-01f,
  -1.39644638e-01f, 5.87714016e-02f, -6.01176657e-02f, -1.88897531e-02f, -1.14671595e-01f, -2.81538129e-01f, -1.09909117e-01f, -1.07348382e-01f, 9.94005650e-02f, 1.85759097e-01f,
  2.63423752e-02f, 5.91264665e-02f, -1.20949745e-02f, -1.76248197e-02f, -4.16385084e-02f, -3.44048776e-02f, -1.33262994e-02f, 2.25377977e-02f, 5.53215593e-02f, -5.88160753e-02f,
  -1.35648325e-01f, 6.07236149e-03f, 1.02412015e-01f, 5.93590811e-02f, -4.63785902e-02f, 5.86953424e-02f, 9.49578956e-02f, -5.87278455e-02f, 1.42943338e-02f, 1.12074753e-02f,
  -3.40900011e-02f, 1.40694946e-01f, 5.89426188e-03f, 1.20347952e-02f, 1.29872829e-01f, 2.85492558e-02f, 2.72581377e-03f, -6.84295595e-03f, -6.10961169e-02f, 7.50665069e-02f,
  1.94086670e-03f, -6.21328652e-02f, -1.64551213e-01f, -9.15718079e-02f, 1.12602226e-01f, 3.08714528e-02f, 1.53598130e-01f, 1.18369870e-01f, 7.78475925e-02f, -1.30614802e-01f,
  -2.64839698e-02f, -3.56540754e-02f, 3.73605196e-03f, 6.21262155e-02f, -6.45603314e-02f, -4.84342948e-02f, -4.04124446e-02f, -5.77912368e-02f, 8.45431909e-02f, 6.81541488e-03f,
  -3.32798027e-02f, 1.07820377e-01f, 6.47631139e-02f, -1.24086022e-01f, -2.67288312e-02f, -1.10710770e-01f, -2.39981320e-02f, -1.04464576e-01f, -1.07193418e-01f, 6.75313249e-02f,
  2.27473322e-02f, 6.73786327e-02f, -2.48106886e-02f, -8.05870071e-02f, -1.77845042e-02f, -9.15200487e-02f, 7.48199448e-02f, 1.32315382e-01f, 1.15632571e-01f, 2.74222549e-02f,
  -3.07107389e-01f, -7.09761232e-02f, -1.48257196e-01f, 3.88240218e-02f, -1.27711166e-02f, -7.56278913e-03f, -9.75731760e-02f, -5.42909577e-02f, 2.86608674e-02f, -7.02536851e-02f,
  1.20037764e-01f, -6.87272996e-02f, -1.17367633e-01f, 1.11023821e-01f, 1.13996848e-01f, 1.83754507e-02f, -2.03784257e-01f, -8.11674222e-02f, 1.46597233e-02f, -3.00529972e-02f,
  -1.27913788e-01f, -1.70584321e-01f, -2.19054148e-01f, -2.59342402e-01f, 9.26802587e-03f, -1.66032925e-01f, -2.49700900e-02f, -2.05180086e-02f, -2.02062294e-01f, -1.91223487e-01f,
  8.45636502e-02f, -3.83157939e-01f, -1.33890629e-01f, -5.51477596e-02f, -1.01224646e-01f, -1.10485405e-01f, -2.32072681e-01f, -1.11685053e-01f, -3.25642875e-03f, -2.96745926e-01f,
  -1.11381426e-01f, 2.22952724e-01f, 1.39616877e-01f, 1.52770042e-01f, 1.70197770e-01f, -3.30637455e-01f, -1.02367677e-01f, 1.17581740e-01f, 2.64518201e-01f, -1.08451843e-02f,
  -1.58768564e-01f, 1.26781389e-02f, 1.60805240e-01f, 6.49592280e-02f, -1.70409113e-01f, -6.11837581e-02f, -2.23591059e-01f, -4.76504490e-02f, -1.60450175e-01f, -3.59261096e-01f,
  -2.15487480e-01f, -2.15373915e-02f, 2.34933734e-01f, 1.44352421e-01f, -1.65332913e-01f, 4.20869254e-02f, 4.62855995e-02f, -8.33925009e-02f, 5.79606332e-02f, -6.19280227e-02f,
  5.61503656e-02f, 7.62042105e-02f, 8.71566907e-02f, -7.67732859e-02f, 4.97578345e-02f, 8.08839351e-02f, -4.40279804e-02f, 1.15838975e-01f, 9.11129192e-02f, -4.85412143e-02f,
  -4.09266986e-02f, -6.47745444e-04f, 1.09872438e-01f, -6.20913729e-02f, 5.14687933e-02f, 1.00260653e-01f, -1.11110128e-01f, 4.52630594e-02f, -2.47026738e-02f, -2.94966102e-01f,
  -1.11847334e-02f, 2.68781092e-03f, -7.24862963e-02f, 2.42354218e-02f, -3.33533697e-02f, -7.82354455e-03f, 8.20175838e-03f, 2.48466879e-02f, 9.82122123e-02f, -5.40846679e-03f,
  3.95112187e-02f, 7.20133334e-02f, -3.27312611e-02f, 4.97954711e-02f, 1.02356020e-02f, 3.58357280e-02f, -1.07378006e-01f, -1.86305512e-02f, 7.21317753e-02f, -1.41760828e-02f,
  3.93668655e-03f, -6.71694847e-03f, 4.57083695e-02f, -8.75684153e-03f, 3.29224057e-02f, -8.75709951e-03f, -5.88432886e-02f, -8.35663006e-02f, -4.96128127e-02f, -5.20680360e-02f,
  -1.23536184e-01f, 2.50213444e-01f, -5.52399494e-02f, -3.43247037e-03f, 4.04061787e-02f, -4.46920767e-02f, -4.12558168e-02f, -6.70099333e-02f, -4.37962376e-02f, -6.25831932e-02f,
  4.23397906e-02f, -6.92561045e-02f, -5.65720983e-02f, -1.02775060e-02f, 6.82902243e-03f, 3.15213092e-02f, -1.37649542e-02f, 4.91162911e-02f, 1.23884112e-01f, 6.66489005e-02f,
  -8.34360272e-02f, -1.03743717e-01f, 7.79463574e-02f, -3.71292606e-02f, -2.44908547e-03f, 1.69673152e-02f, -5.37012368e-02f, -9.22646150e-02f, 9.74855497e-02f, -3.28399867e-01f,
  2.65310407e-01f, 2.33873576e-01f, -2.83807330e-02f, 2.50983424e-02f, -3.44722480e-01f, -2.34929755e-01f, -1.18369013e-01f, 6.95758015e-02f, 7.67616183e-02f, -5.92881404e-02f,
  -1.21683307e-01f, -9.56380144e-02f, -7.75426477e-02f, -4.99022938e-03f, 1.65756509e-01f, 1.10464618e-01f, 1.69258043e-01f, 7.18302876e-02f, 1.55862749e-01f, 5.50691299e-02f,
  7.04394327e-03f, 1.26939192e-01f, 6.84543252e-02f, 1.13902003e-01f, -7.46615604e-02f, 1.99305452e-02f, 4.57831994e-02f, -7.62302577e-02f, -1.90149061e-02f, 1.77666351e-01f,
  -7.51825050e-02f, -4.08331379e-02f, -1.37618601e-01f, -2.15395670e-02f, -1.00403510e-01f, -2.20711231e-02f, 2.49925610e-02f, -4.04141210e-02f, -1.07092835e-01f, 6.03087619e-02f,
  -8.88509452e-02f, -4.90119122e-02f, -5.59257492e-02f, -9.54407156e-02f, -3.32232155e-02f, -3.05475909e-02f, 8.38839635e-02f, 1.64826214e-01f, 3.76635306e-02f, -9.58863925e-03f,
  1.98839661e-02f, -1.47882342e-01f, -6.14736900e-02f, -1.07528329e-01f, -2.22938154e-02f, -1.48474202e-01f, -1.46046624e-01f, -9.17857066e-02f, -4.04882915e-02f, 2.48426013e-02f,
  -1.26507550e-01f, -5.89009672e-02f, 6.27571717e-02f, 1.71217054e-01f, 5.38501553e-02f, -7.86285195e-03f, 3.60026136e-02f, 1.66196693e-02f, 9.83687490e-02f, 1.11981489e-01f,
  -2.56939884e-02f, 5.35072014e-02f, -2.41612755e-02f, 2.83507779e-02f, 9.01690871e-03f, 1.50494725e-02f, 6.33568168e-02f, 2.72648726e-02f, -3.64976041e-02f, -1.21559739e-01f,
  -6.27577379e-02f, 1.09401103e-02f, 7.22681731e-02f, 1.13432273e-01f, 2.74224244e-02f, 4.07526046e-02f, 2.70872414e-02f, 4.10194173e-02f, -5.19394204e-02f, 5.07772528e-02f,
  -7.56794959e-03f, -2.41017699e-01f, 7.72279799e-02f, 9.02001485e-02f, -5.64092696e-02f, -1.75721288e-01f, -8.94648060e-02f, 2.05071922e-02f, -1.90316364e-01f, -6.90940693e-02f,
  -4.73401397e-02f, -6.05549570e-03f, -1.02355309e-01f, -4.47313376e-02f, -2.91203875e-02f, -8.86346996e-02f, -1.03411794e-01f, -8.07801709e-02f, 7.95527026e-02f, -1.15826093e-02f,
  3.60609703e-02f, 1.04632955e-02f, -6.20124582e-03f, -9.90842134e-02f, -6.58249632e-02f, -2.13623479e-01f, -1.09086551e-01f, -1.00269318e-01f, -7.16898264e-03f, 1.28144771e-01f,
  4.48149383e-01f, 3.46327759e-02f, -3.97559345e-01f, 1.40996769e-01f, -1.33471325e-01f, -1.37366816e-01f, -8.16491097e-02f, 8.28081891e-02f, 1.57069594e-01f, -2.88584493e-02f,
  -5.61756901e-02f, 7.98913985e-02f, 1.97629221e-02f, 3.86347845e-02f, -4.53037806e-02f, -4.73547690e-02f, 2.43675523e-02f, -1.45974800e-01f, -1.35305777e-01f, 5.62951267e-02f,
  1.28938392e-01f, 1.38572827e-01f, 5.23598343e-02f, 4.01723012e-02f, 2.13378370e-02f, 6.89238757e-02f, -1.23247273e-01f, -1.09967776e-01f, -6.15623929e-02f, -3.77824791e-02f,
  -1.77433625e-01f, -1.61040574e-02f, -1.55050471e-01f, -4.04186957e-02f, -1.79187283e-01f, 2.59413533e-02f, -3.98387313e-02f, -1.70552507e-01f, -8.01001042e-02f, 3.27391773e-02f,
  -1.35046571e-01f, -1.17009602e-01f, -1.63442999e-01f, 1.44360298e-02f, 3.34026553e-02f, 3.88441570e-02f, -2.38727462e-02f, -7.97187835e-02f, -1.36233941e-02f, -4.99818884e-02f,
  1.30517036e-01f, -4.32517081e-02f, -2.21653432e-01f, -2.11250167e-02f, -5.21332882e-02f, -6.05387315e-02f, -1.09767228e-01f, -1.37606353e-01f, -1.37125924e-01f, 5.81786558e-02f,
  1.35684267e-01f, 2.54160771e-03f, 1.07854873e-01f, -1.73567552e-02f, 1.21220844e-02f, -3.22480313e-02f, -1.77281967e-03f, 7.79599771e-02f, 4.69657267e-03f, 9.74357575e-02f,
  -4.86401431e-02f, -4.03247550e-02f, 1.05102425e-02f, 4.60691117e-02f, -8.05744249e-03f, 6.02028780e-02f, -7.04410821e-02f, 1.25424892e-01f, 9.80791524e-02f, 9.25355926e-02f,
  4.47414927e-02f, 4.27948348e-02f, 1.93828642e-02f, 4.19646166e-02f, 5.76697439e-02f, 6.53517246e-03f, -1.44227259e-02f, 1.19241826e-01f, 9.10333768e-02f, -1.96924694e-02f,
  1.67013317e-01f, -1.94057785e-02f, 1.13636248e-01f, -1.07088968e-01f, 4.50122021e-02f, -8.02867338e-02f, -1.89416502e-02f, 1.36461277e-02f, -7.26689547e-02f, 2.22773403e-02f,
  -9.92490128e-02f, -1.09126829e-02f, -8.58721286e-02f, 2.74219867e-02f, 1.38268329e-03f, 5.95101267e-02f, 8.98732767e-02f, 1.98613387e-02f, 6.75627366e-02f, -2.28186119e-02f,
  2.99005117e-02f, 5.73764741e-02f, 1.43654570e-01f, -1.78170726e-02f, 3.98047119e-02f, 9.61902142e-02f, -6.46909401e-02f, 5.47296181e-02f, 1.09500773e-01f, 1.57658443e-01f,
  9.45027694e-02f, -2.57853299e-01f, -3.00463289e-01f, -2.23888099e-01f, -1.27831668e-01f, 7.30955824e-02f, -6.47229655e-03f, 1.44711569e-01f, 5.35989627e-02f, -1.31769881e-01f,
  1.44451424e-01f, 2.72968858e-01f, 1.34983644e-01f, 1.04945250e-01f, 1.74778432e-01f, -2.06800565e-01f, -2.55089045e-01f, 1.60102304e-02f, 3.12911510e-01f, 1.90255612e-01f,
  -2.01901160e-02f, -1.02562957e-01f, 9.86189619e-02f, 5.12112044e-02f, -2.06911460e-01f, 1.79351568e-02f, -2.76702166e-01f, -1.56647995e-01f, 1.56398432e-03f, -3.41886789e-01f,
  1.02196924e-01f, -1.00804351e-01f, -4.98329697e-04f, 1.33470327e-01f, -1.24556432e-02f, 8.83238539e-02f, 4.22635041e-02f, -7.44350553e-02f, 5.91626838e-02f, -6.86482340e-02f,
  -8.61392468e-02f, 2.52056736e-02f, 3.42497900e-02f, 4.15927060e-02f, -1.09707229e-01f, -5.38240857e-02f, -1.20940782e-01f, -7.12551773e-02f, -7.66064823e-02f, 6.34725094e-02f,
  -1.55563504e-01f, -1.24936424e-01f, -6.83069825e-02f, -6.32550791e-02f, -4.52471301e-02f, 1.09388940e-01f, -2.79311053e-02f, -2.73091774e-02f, -4.94172648e-02f, -2.83257246e-01f,
  -9.42648947e-02f, -7.18477508e-03f, 4.19089617e-03f, -2.71981265e-02f, -1.84421055e-02f, 4.14668545e-02f, -2.60052085e-02f, 7.19597414e-02f, 1.10836364e-01f, -7.89261982e-02f,
  6.39187247e-02f, -1.94878913e-02f, 9.13771838e-02f, -4.42594886e-02f, -5.19496799e-02f, -4.98078316e-02f, -8.80171731e-02f, -7.40916356e-02f, 6.11622706e-02f, -6.77795261e-02f,
  -7.32682971e-03f, 6.30441457e-02f, -1.13774128e-01f, 2.05851207e-03f, 6.04846887e-02f, -1.96466353e-02f, -5.83439134e-02f, 1.04779199e-01f, 5.88309728e-02f, -1.35593675e-02f,
  -4.61780950e-02f, 1.23532481e-01f, 9.25449803e-02f, 4.96359579e-02f, -1.15936689e-01f, 3.78609672e-02f, -1.46228261e-02f, 1.11982845e-01f, 7.64328465e-02f, 1.49470998e-03f,
  3.75415683e-02f, 6.31856322e-02f, -5.76797053e-02f, -3.87058854e-02f, 8.45667645e-02f, 3.24944891e-02f, 3.00281215e-02f, 8.89871791e-02f, 2.85886470e-02f, -4.27825414e-02f,
  -1.05937123e-01f, 9.65034775e-03f, 1.09285712e-01f, -1.37020368e-02f, -6.80112690e-02f, 1.06044710e-01f, 4.33037430e-02f, -6.27974942e-02f, 1.65055439e-01f, -3.57493088e-02f,
  -3.57742041e-01f, -8.14259276e-02f, -1.17683955e-01f, -2.98281759e-01f, -1.47622377e-01f, -1.24049462e-01f, 1.22022594e-03f, -1.10336818e-01f, -1.69822857e-01f, 3.69880162e-02f,
  1.06279738e-01f, 2.35524997e-02f, 1.14628360e-01f, 5.92567734e-02f, -1.19491471e-02f, -9.82982889e-02f, -1.39358729e-01f, -2.52052933e-01f, -6.07924908e-02f, 4.55491208e-02f,
  7.22025782e-02f, -3.97318825e-02f, -1.89255327e-01f, 7.82785639e-02f, 1.79568678e-01f, 2.00646147e-02f, 1.45808637e-01f, 4.94014174e-02f, 1.37452841e-01f, 8.04011896e-02f,
  1.77140787e-01f, -6.59016967e-02f, 6.23205537e-03f, -7.67610595e-02f, 1.92772225e-02f, -6.44251192e-03f, -2.00236980e-02f, -7.88223743e-02f, -4.20808159e-02f, -3.26400809e-02f,
  -1.21619694e-01f, -2.31835227e-02f, -1.90722421e-01f, -3.45189236e-02f, -1.33079410e-01f, -2.43695918e-02f, -1.25566021e-01f, -8.44196901e-02f, -6.24679178e-02f, 1.93604350e-03f,
  1.69363432e-02f, -2.55363006e-02f, -5.44386283e-02f, 1.53154120e-01f, 4.34942544e-02f, -5.93952760e-02f, 1.31202683e-01f, 9.26866829e-02f, 1.30465701e-01f, 9.37409699e-02f,
  -3.21887396e-02f, 9.84887928e-02f, 4.53991331e-02f, 1.82837378e-02f, -7.66040012e-03f, 7.26767108e-02f, -2.68778130e-02f, 5.14972471e-02f, 4.85531166e-02f, -6.92089796e-02f,
  -4.50618714e-02f, 4.30993475e-02f, -4.31118309e-02f, -7.32575953e-02f, 5.83854616e-02f, -5.38849793e-02f, 2.34954599e-02f, 3.47512290e-02f, 1.71934981e-02f, -4.70959991e-02f,
  -8.46541449e-02f, 6.29633712e-03f, -2.72697303e-02f, -4.70872223e-02f, -5.69398366e-02f, -3.22744660e-02f, -5.51480614e-02f, 2.94707846e-02f, 1.02337841e-02f, -3.04909889e-02f,
  5.18151447e-02f, -1.88968033e-02f, -7.97420964e-02f, -2.07908843e-02f, -1.24678627e-01f, -6.40607178e-02f, -4.69824485e-02f, -1.47369802e-01f, -1.25445798e-01f, 4.90824971e-03f,
  4.26593050e-02f, -7.23111480e-02f, 1.17177665e-02f, -5.30171171e-02f, -7.57651627e-02f, 2.78016273e-02f, -6.01527430e-02f, -3.16003636e-02f, 9.34570357e-02f, 6.32525012e-02f,
  -9.32898298e-02f, -5.57553247e-02f, -3.15398686e-02f, 9.17742625e-02f, 1.29102170e-01f, 2.41435822e-02f, 6.09398298e-02f, 4.64186165e-03f, 2.13500895e-02f, 1.31664574e-01f,
  -4.11603332e-01f, -4.26330343e-02f, -1.85364075e-02f, -8.64709690e-02f, 2.28015840e-01f, 2.57883519e-01f, 3.24610233e-01f, 1.12956859e-01f, 1.24930628e-01f, 7.05575198e-02f,
  -8.88688862e-02f, -1.29290447e-01f, 3.03725805e-02f, -5.86241856e-02f, -3.80695872e-02f, 2.05111593e-01f, 1.78918481e-01f, 4.40215506e-02f, 9.42771956e-02f, 1.27068639e-01f,
  1.78405434e-01f, -8.15574974e-02f, -2.32407317e-01f, -5.37615605e-02f, 1.30753621e-01f, -3.15876827e-02f, 8.27706978e-02f, 1.43629938e-01f, 1.45433873e-01f, -5.69918491e-02f,
  -2.09691953e-02f, -7.08040372e-02f, 8.80000219e-02f, -1.59904644e-01f, -1.21520171e-02f, -1.76282153e-01f, -8.11850769e-04f, -1.92073643e-01f, -8.55241865e-02f, -3.43017187e-03f,
  -1.07008807e-01f, 2.95043900e-03f, 4.11230698e-03f, -7.43738040e-02f, -2.88268812e-02f, -1.32942544e-02f, -8.39289501e-02f, -1.24963909e-01f, 6.15154617e-02f, -9.87705961e-02f,
  6.30099624e-02f, 7.29333162e-02f, 1.03416987e-01f, 1.58979371e-01f, 7.80473351e-02f, 6.64784908e-02f, -9.09430720e-03f, -4.22403365e-02f, -2.49570608e-02f, -7.05539435e-02f,
  -4.68583219e-02f, -2.31559927e-04f, -1.00398675e-01f, -8.36206507e-03f, -3.92264361e-03f, 3.42347696e-02f, 6.62036333e-03f, 1.28151476e-01f, 1.86707228e-01f, 1.32550791e-01f,
  -7.57563263e-02f, 2.17464170e-03f, -3.30683477e-02f, 6.59525618e-02f, -2.02052407e-02f, -3.76963802e-02f, 7.37918466e-02f, -7.10961819e-02f, -2.05678232e-02f, 1.57059338e-02f,
  2.17240509e-02f, 1.34310290e-01f, -6.14806116e-02f, 7.29813725e-02f, 1.02637019e-02f, -3.79835479e-02f, -5.04318997e-02f, -2.56697088e-02f, -1.18978480e-02f, -4.86352108e-02f,
  1.40103891e-01f, 1.05602846e-01f, -7.01809600e-02f, 1.02577262e-01f, 8.27546325e-03f, -1.38342559e-01f, 5.70948496e-02f, -4.37600426e-02f, 1.85216330e-02f, 1.96981505e-02f,
  1.75808743e-02f, -1.07171185e-01f, -9.33898315e-02f, -6.66573867e-02f, 1.88205857e-02f, -7.93021247e-02f, -6.10674359e-02f, 7.26868659e-02f, -5.00513092e-02f, 3.56406942e-02f,
  -2.54979543e-03f, 1.30045190e-01f, 5.60237654e-02f, 1.29533157e-01f, 2.55133994e-02f, 1.56095892e-01f, -2.72234064e-02f, -5.02101332e-02f, 5.16923703e-02f, 6.01044670e-02f,
  3.43867064e-01f, -2.15784416e-01f, -1.85279176e-01f, 5.53826392e-02f, -1.60909593e-01f, -1.30113512e-01f, -2.11537123e-01f, -2.49149129e-02f, 1.05597638e-01f, -2.32500955e-01f,
  3.03422026e-02f, 1.83774263e-01f, 7.63659701e-02f, -5.91074023e-03f, 5.89994416e-02f, -3.85896593e-01f, -3.55362833e-01f, -9.65197384e-02f, 3.42557505e-02f, -7.41403177e-02f,
  -1.16690658e-01f, -2.11108238e-01f, 2.07476858e-02f, -6.96608797e-02f, -1.32342726e-01f, 7.44906440e-02f, -2.67307222e-01f, -5.09736165e-02f, -3.45535390e-02f, -1.28917783e-01f,
  -1.30067080e-01f, -8.02617595e-02f, -2.19050385e-02f, -1.99890943e-04f, -1.38524145e-01f, 1.35269724e-02f, 7.94327855e-02f, -3.54525000e-02f, -5.49015440e-02f, -6.38015494e-02f,
  7.94151202e-02f, -6.49559870e-02f, 1.98620692e-01f, 1.07133657e-01f, -7.97496438e-02f, -2.80190706e-02f, -1.00498512e-01f, -1.14294171e-01f, -1.21485412e-01f, -1.31185204e-01f,
  -1.67101800e-01f, -1.65458452e-02f, 6.69373423e-02f, -8.87966603e-02f, 1.03588566e-01f, 1.14467598e-01f, -3.47870439e-02f, 1.68818876e-01f, 6.11825250e-02f, -2.09606051e-01f,
  -1.27471238e-01f, 5.02541028e-02f, -3.36813158e-03f, 6.83618127e-04f, -1.61640957e-01f, -3.09594572e-02f, -1.48014026e-02f, -6.83648810e-02f, -9.08218175e-02f, -2.00505201e-02f,
  1.32337520e-02f, -2.46521533e-02f, -8.65917280e-02f, -8.16605240e-02f, -5.22251092e-02f, -1.64225176e-02f, 6.13561571e-02f, -1.21600479e-01f, -6.18807115e-02f, -2.87308209e-02f,
  -1.49768889e-02f, -8.65793228e-02f, 6.20337799e-02f, -4.33915341e-03f, -2.11166199e-02f, 3.35586965e-02f, 3.95399705e-02f, 8.61401036e-02f, 1.09954938e-01f, -1.72711536e-02f,
  1.55161366e-01f, 8.25929418e-02f, -1.52293511e-03f, -2.23749988e-02f, -7.60537758e-02f, -9.00544897e-02f, 3.90431960e-03f, -1.15472883e-01f, 3.33545953e-02f, 5.10112904e-02f,
  -2.17662901e-02f, 1.43516183e-01f, 1.00361861e-01f, -7.43011087e-02f, -5.64711243e-02f, -3.51021290e-02f, -6.88873604e-02f, -2.99457293e-02f, -4.06251252e-02f, -9.95862558e-02f,
  -2.18434706e-01f, -7.85091743e-02f, 3.99900079e-02f, -6.40498882e-04f, 3.81300859e-02f, 1.80850103e-01f, 1.89611223e-02f, 1.93534680e-02f, 1.27246857e-01f, -1.79757789e-01f,
  5.37661314e-02f, 1.03630155e-01f, -1.38271764e-01f, -1.19409747e-02f, -3.76216359e-02f, -5.82888350e-02f, 4.99710673e-03f, 1.37174055e-01f, 9.38690007e-02f, 1.10877857e-01f,
  2.45777275e-02f, -1.65174186e-01f, -1.52087837e-01f, -1.21750824e-01f, -1.90665096e-01f, -3.64590921e-02f, -1.67243049e-01f, -2.87946850e-01f, -3.21269423e-01f, -1.06206380e-01f,
  4.27660234e-02f, 2.06629112e-02f, -7.43773952e-02f, -7.93047249e-02f, 1.06154375e-01f, -1.57147884e-01f, -5.54516129e-02f, -1.33450240e-01f, -1.75851092e-01f, -9.65941325e-02f,
  -1.64684862e-01f, -1.37834707e-02f, -8.15159604e-02f, 1.14844656e-02f, -4.03315201e-02f, -5.70130385e-02f, -1.57940716e-01f, -7.30793029e-02f, -3.54628544e-03f, -3.90857756e-02f,
  -1.52392939e-01f, -6.96764290e-02f, -1.32883012e-01f, -7.18687847e-02f, -3.25336047e-02f, -3.65387984e-02f, 4.18714657e-02f, -1.24611698e-01f, -3.92126516e-02f, -7.97730535e-02f,
  -6.91367611e-02f, -2.00600415e-01f, -2.24196747e-01f, -4.34568599e-02f, -9.30842012e-02f, -2.17985258e-01f, -4.86592613e-02f, -1.69094965e-01f, -1.00258254e-01f, 1.68265849e-01f,
  5.69220893e-02f, -4.55987751e-02f, -2.75228429e-03f, -4.21325751e-02f, 2.37163380e-02f, 5.89473769e-02f, -2.56553143e-02f, -1.46206394e-02f, -5.69169298e-02f, 5.96901290e-02f,
  -1.05313817e-02f, 2.19698511e-02f, -1.49426386e-02f, -3.42337377e-02f, -6.03725389e-02f, -7.79788941e-02f, 4.17134836e-02f, 1.08339870e-02f, -1.24236979e-02f, 2.14010589e-02f,
  -7.97689781e-02f, 8.70634615e-03f, 2.65209470e-02f, 4.72218804e-02f, -6.30994663e-02f, -1.09654423e-02f, -3.37240137e-02f, 2.34343857e-02f, -3.76077890e-02f, -1.32427830e-02f,
  7.03748614e-02f, -9.11437720e-02f, 1.90358888e-02f, -4.59943339e-03f, 4.34526093e-02f, 1.02376208e-01f, -6.81237057e-02f, -2.99088266e-02f, -7.04780146e-02f, 7.91190788e-02f,
  -9.90911052e-02f, -1.47600251e-03f, -6.42183200e-02f, -2.71962788e-02f, 1.62515286e-02f, -7.71937892e-02f, 1.90103357e-03f, -1.34245504e-03f, -1.25193924e-01f, 2.82183029e-02f,
  1.63379252e-01f, 4.67582121e-02f, 1.16338640e-01f, -4.96210828e-02f, -2.49093585e-02f, -8.84602293e-02f, -3.65127847e-02f, 1.96418874e-02f, -7.92812929e-03f, 3.25691730e-01f,
  -9.51566547e-02f, 2.51699612e-02f, -4.83321808e-02f, -7.60335773e-02f, 2.88249869e-02f, -4.89698313e-02f, -6.89530373e-02f, -9.76008475e-02f, 4.99563366e-02f, 1.90245863e-02f,
  6.12339079e-02f, -6.85865432e-02f, 2.03410890e-02f, -1.19878829e-01f, -3.91104907e-01f, -2.55576253e-01f, -1.24503195e-01f, -2.91031301e-01f, -2.67932773e-01f, -1.28339514e-01f,
  -8.22692439e-02f, -1.77062824e-02f, -1.88499317e-01f, -1.12952679e-01f, 1.91817179e-01f, -9.26733296e-03f, 1.28736226e-02f, 4.57739457e-02f, 6.49568141e-02f, 8.71519893e-02f,
  -2.49415357e-02f, 9.68883708e-02f, 2.59572044e-02f, 2.44890223e-03f, -8.94717686e-03f, 2.96285320e-02f, 1.05245210e-01f, 4.41055372e-02f, 7.54287988e-02f, -1.26242712e-02f,
  -2.19389750e-03f, -1.45111349e-04f, -2.96822563e-02f, -1.70021933e-02f, -9.93457958e-02f, -1.30183697e-01f, -1.02626532e-02f, -1.12478048e-01f, -1.76962223e-02f, 1.37255434e-02f,
  -7.85996541e-02f, -5.67636788e-02f, 2.17611790e-02f, -3.06902695e-02f, 7.99517613e-03f, 1.14148948e-02f, 1.06557950e-01f, 1.72360018e-01f, 1.30596682e-01f, 4.82314005e-02f,
  8.26802328e-02f, -3.70277017e-02f, -4.30834852e-02f, -5.91338649e-02f, -5.37562445e-02f, -6.10556221e-03f, 8.32595229e-02f, -1.17837586e-01f, -3.03581730e-02f, -3.09258811e-02f,
  -3.10904905e-02f, 2.55713612e-02f, -4.55219448e-02f, 9.86402109e-02f, 2.19314005e-02f, 2.94116214e-02f, -2.68939417e-02f, -7.18537252e-03f, -9.37041566e-02f, 7.17326626e-02f,
  2.73399949e-02f, -1.81844532e-02f, 5.08992709e-02f, 4.61883396e-02f, 5.98829910e-02f, 8.73392541e-03f, -2.48571951e-02f, -1.24198429e-01f, -6.93607107e-02f, 9.68239177e-03f,
  -1.26573071e-01f, -7.96428993e-02f, -2.61613764e-02f, -1.38071448e-01f, 1.81914661e-02f, 3.44123784e-03f, -2.33098362e-02f, -3.99457477e-02f, 4.21831869e-02f, -5.27619980e-02f,
  -1.55113675e-02f, -6.04556538e-02f, -1.33144734e-02f, -1.98981185e-02f, -4.12362395e-03f, -5.67089990e-02f, -1.37209043e-01f, -1.18122198e-01f, -1.12223975e-01f, 1.10918600e-02f,
  -7.82171935e-02f, -1.81900293e-01f, -2.54534125e-01f, -1.66219056e-01f, 1.89645607e-02f, -8.53517577e-02f, -1.39079779e-01f, -3.85814384e-02f, -5.94134964e-02f, -1.59241766e-01f,
  -4.64076638e-01f, -2.89524496e-01f, -7.49300495e-02f, -1.14772379e-01f, 8.99446458e-02f, -1.36508448e-02f, -1.36337653e-01f, -1.59570962e-01f, 3.92333530e-02f, -1.65591583e-01f,
  -6.63277730e-02f, 6.57959133e-02f, 9.84419659e-02f, 1.42253205e-01f, -5.78316823e-02f, 6.00649118e-02f, 1.19350940e-01f, 1.23990245e-01f, 1.69665162e-02f, 8.58145580e-02f,
  1.21353015e-01f, 9.08510108e-03f, 6.19965792e-02f, 3.53895314e-02f, -2.23386828e-02f, 8.47482830e-02f, 1.36778143e-03f, 1.17697299e-01f, 1.07686892e-01f, -5.48114516e-02f,
  -2.58613765e-01f, -2.70757586e-01f, 1.11179546e-01f, -6.46270160e-03f, 4.38619480e-02f, 2.04999442e-03f, 2.95579694e-02f, 8.32933411e-02f, 7.97574446e-02f, -6.93186652e-03f,
  2.10115314e-02f, -3.89883034e-02f, 4.35460247e-02f, -1.74862538e-02f, 7.12281093e-02f, -5.93091883e-02f, 1.66798055e-01f, 3.93822640e-02f, -8.98259431e-02f, 1.63828265e-02f,
  1.81836441e-01f, 1.06375471e-01f, -6.70914277e-02f, -5.00265248e-02f, -1.37079075e-01f, 1.27805650e-01f, -1.33428320e-01f, -1.29227400e-01f, -4.47606780e-02f, -2.66710609e-01f,
  8.32570717e-02f, 2.52164248e-02f, 3.50095481e-02f, -1.11073479e-01f, -3.38197388e-02f, 6.27209246e-02f, -1.14928558e-02f, 4.68688272e-02f, 5.85655533e-02f, -1.21631309e-01f,
  3.14499177e-02f, -3.49250734e-02f, -5.88902757e-02f, 1.73264351e-02f, 2.76187453e-02f, -7.70426244e-02f, -4.41778488e-02f, 3.34477499e-02f, 4.78398502e-02f, -3.41367424e-02f,
  3.70157836e-03f, -2.36732792e-02f, 4.44888994e-02f, -6.03357516e-03f, -1.09743908e-01f, 4.02866267e-02f, -3.72935794e-02f, -4.63112667e-02f, 2.69678738e-02f, -5.41120302e-03f,
  -2.04543605e-01f, 2.74019212e-01f, 2.04912182e-02f, -1.11615673e-01f, -3.76723446e-02f, 6.44462481e-02f, -2.84594074e-02f, 7.10699260e-02f, -3.85987982e-02f, -2.51893178e-02f,
  -1.03015110e-01f, -5.02049513e-02f, -7.00457767e-02f, 6.71762526e-02f, -1.57750305e-03f, -1.38851762e-01f, 3.38835567e-02f, -2.56256014e-02f, -5.38873151e-02f, 1.14252148e-02f,
  -3.41800414e-02f, -1.28854975e-01f, -2.05685750e-01f, -1.58864796e-01f, -3.98100726e-02f, 8.22154805e-03f, -1.38198897e-01f, -1.06545366e-01f, -1.54733881e-01f, -2.22085476e-01f,
  7.27059007e-01f, 2.49479920e-01f, -2.07174197e-01f, 1.45072341e-01f, -1.16700083e-01f, -1.49600998e-01f, -3.06968614e-02f, 1.00283958e-01f, 1.12091966e-01f, 3.44024263e-02f,
  1.41325474e-01f, 9.65405628e-02f, 4.36272882e-02f, -2.24725320e-03f, 9.78071317e-02f, -1.27095327e-01f, -1.00478955e-01f, -6.98082969e-02f, -5.98178208e-02f, -5.88573515e-03f,
  -6.37465939e-02f, 8.99346545e-02f, 1.87619448e-01f, 5.01212897e-03f, -8.22814628e-02f, 3.41557749e-02f, -1.44737512e-01f, -1.66035563e-01f, -1.47863030e-01f, -1.61249831e-01f,
  -3.69220257e-01f, -3.29974927e-02f, 3.67099494e-02f, 1.22200884e-01f, 4.76360843e-02f, 2.05415159e-01f, 1.15386657e-01f, 3.74274775e-02f, 1.87429916e-02f, -5.44258840e-02f,
  -9.45744812e-02f, -4.80579212e-02f, -2.58121919e-03f, -5.60823195e-02f, -7.30879754e-02f, 5.64031713e-02f, 3.94006632e-02f, 5.14900908e-02f, -3.50930206e-02f, -1.00855485e-01f,
  2.63421889e-02f, -1.36668861e-01f, -1.51336774e-01f, -1.50772426e-02f, -4.13206965e-02f, -6.50419444e-02f, 2.84671579e-02f, -5.48417754e-02f, -5.21660037e-02f, 1.28518403e-01f,
  -1.02187097e-01f, 7.64329433e-02f, -7.46949166e-02f, 7.03233480e-02f, 8.39451402e-02f, 1.11288009e-02f, -3.89489196e-02f, -6.83585629e-02f, 1.56711449e-03f, -5.09482156e-03f,
  8.54886025e-02f, -9.35776010e-02f, -9.37811211e-02f, -1.69213058e-03f, 7.70395913e-04f, -1.45723179e-01f, -2.12170091e-02f, 2.04332899e-02f, -5.78810014e-02f, 1.23273851e-02f,
  -5.83716668e-03f, -1.11973934e-01f, -8.88871029e-03f, -1.32662803e-01f, -4.02610973e-02f, -1.15670385e-02f, -8.46010633e-03f, -8.18923637e-02f, -4.23110425e-02f, -4.82003056e-02f,
  -2.50416752e-02f, -2.39257663e-01f, 5.18496931e-02f, -5.07114492e-02f, -1.08315907e-01f, 1.27845347e-01f, -5.02991378e-02f, -4.77420203e-02f, -5.00853360e-02f, -7.52098039e-02f,
  4.08785567e-02f, 1.29765749e-01f, 3.02807167e-02f, -7.60450512e-02f, 1.61617603e-02f, -7.09498972e-02f, 1.89832926e-01f, 8.11914876e-02f, 1.30560622e-02f, -6.20674677e-02f,
  2.13154815e-02f, 6.77667558e-02f, 1.24817424e-01f, 3.21445465e-02f, 2.12806594e-02f, 3.95550020e-02f, -2.18213093e-03f, 6.36461377e-02f, -2.58803628e-02f, 2.10446328e-01f,
  -2.19613895e-01f, 2.01749563e-01f, 2.52524257e-01f, -2.33921945e-01f, 1.20629057e-01f, 3.59021366e-01f, 3.75116110e-01f, 4.24826853e-02f, -2.43704900e-01f, 1.37751689e-02f,
  1.53204054e-01f, -2.64401764e-01f, -1.55226186e-01f, -1.13776118e-01f, 3.96918505e-03f, 8.56297612e-02f, -8.27208310e-02f, -8.42459500e-02f, 8.89628455e-02f, -3.05381324e-03f,
  -4.17193286e-02f, -1.73334092e-01f, 3.05133220e-02f, -1.38177425e-01f, -3.61691117e-01f, -2.26895869e-01f, 1.54377138e-02f, 1.01357192e-01f, 1.68388501e-01f, -3.59014183e-01f,
  -1.50988577e-02f, 3.14952165e-01f, -1.04603134e-01f, -5.71648739e-02f, 1.73307940e-01f, -4.07556370e-02f, -8.51450264e-02f, -1.23988174e-01f, -2.51317043e-02f, 3.97162959e-02f,
  2.43819114e-02f, -6.79349005e-02f, -4.77193557e-02f, 2.87031196e-02f, 8.88437778e-02f, -5.69144972e-02f, 1.15918726e-01f, 3.83286104e-02f, 1.05860323e-01f, 3.10739819e-02f,
  8.78543258e-02f, 1.82891682e-01f, 1.98720664e-01f, 9.00557116e-02f, 8.40185732e-02f, 3.79771776e-02f, 1.46079823e-01f, 1.45346746e-01f, 2.13982269e-01f, -1.32192910e-01f,
  -5.33047840e-02f, 2.04224084e-02f, 9.16681886e-02f, -1.64821800e-02f, -3.56864706e-02f, 3.62880230e-02f, -5.79988398e-02f, -9.93089005e-02f, 5.33422530e-02f, -9.57809016e-02f,
  8.57010707e-02f, 2.51144618e-02f, 1.15147419e-02f, 4.93633188e-02f, -1.09164203e-02f, 8.14463273e-02f, 3.69510837e-02f, 5.40939905e-02f, 6.89046225e-03f, -6.61431858e-03f,
  7.68090487e-02f, 4.47165333e-02f, -4.18690927e-02f, 3.92419919e-02f, 6.79117367e-02f, -1.14056338e-02f, 2.21416038e-02f, 1.22773528e-01f, -5.41382581e-02f, -1.52556066e-04f,
  -2.50812173e-01f, 3.00529212e-01f, -3.97260755e-01f, -1.58397965e-02f, -1.27212137e-01f, -7.70597607e-02f, -5.00198491e-02f, -2.36413302e-03f, -8.35337713e-02f, 3.17565957e-03f,
  8.26765895e-02f, -2.24844255e-02f, 2.31691860e-02f, 3.72996107e-02f, -1.07683100e-01f, -8.84116516e-02f, 6.54121339e-02f, -5.98058254e-02f, 5.98797239e-02f, 4.59069386e-03f,
  -5.47591373e-02f, -6.80397749e-02f, -2.22482368e-01f, -1.18069366e-01f, -2.57234108e-02f, -1.48765266e-01f, -1.25905141e-01f, -9.79986191e-02f, 9.74243507e-02f, -2.37855226e-01f,
  -4.51328665e-01f, 1.29193626e-02f, -4.53597866e-02f, -2.72066534e-01f, 5.54317757e-02f, 8.27916116e-02f, 1.99018449e-01f, 1.04702219e-01f, -1.18416391e-01f, -2.51934305e-02f,
  -4.78815064e-02f, -7.93096647e-02f, 1.61524618e-03f, 5.90026639e-02f, 1.12497151e-01f, 1.22247197e-01f, 2.01740354e-01f, 4.34579141e-02f, -1.24927342e-01f, -1.27997836e-02f,
  1.18895650e-01f, -6.68934286e-02f, -1.86104804e-01f, -5.02464697e-02f, -4.71350029e-02f, 8.91066194e-02f, 1.42148048e-01f, 1.84654957e-03f, 1.50437430e-01f, -5.72577901e-02f,
  -1.58952132e-01f, -3.27529877e-01f, 1.48596942e-01f, -1.38449788e-01f, -1.91830978e-01f, -5.28394766e-02f, -4.46499214e-02f, -6.03512414e-02f, -1.35436475e-01f, -2.85195075e-02f,
  -7.35711753e-02f, -8.19681212e-02f, 6.86725453e-02f, 1.32000640e-01f, -2.86945850e-02f, -4.63967733e-02f, 1.11173660e-01f, -6.02696501e-02f, -1.08120643e-01f, -8.94686356e-02f,
  1.66769102e-01f, -2.11194605e-01f, -2.00238109e-01f, -2.97356490e-02f, -1.24000609e-01f, -1.79845397e-03f, -1.05568819e-01f, -1.49224818e-01f, -6.21200213e-03f, -2.60747313e-01f,
  -1.76526178e-02f, -3.12463567e-02f, 7.34560043e-02f, -1.56007539e-02f, 6.21499605e-02f, 9.51358210e-03f, 1.90689210e-02f, -2.64022462e-02f, -4.66655456e-02f, 3.05033308e-02f,
  -9.60711762e-02f, -2.74404269e-02f, -6.61947876e-02f, -3.49880494e-02f, -2.73990799e-02f, -3.03676073e-02f, 5.14124520e-03f, 1.27149075e-01f, -5.62097803e-02f, 2.71714088e-02f,
  -1.00653462e-01f, -7.73660764e-02f, 7.67982425e-03f, -2.70769838e-02f, 3.82402875e-02f, 1.19435303e-02f, 4.93583828e-02f, -3.92199419e-02f, -3.60590429e-03f, -1.08254431e-02f,
  -6.49470091e-02f, 1.66357562e-01f, -5.76424822e-02f, 4.13295925e-02f, -6.54573664e-02f, 5.46540177e-05f, 1.02866642e-01f, -2.68531926e-02f, -8.86033550e-02f, -6.36505708e-02f,
  -4.32726964e-02f, 2.38997210e-02f, 1.11808419e-01f, 1.02663524e-01f, 2.29287036e-02f, -5.75524196e-02f, 1.44928232e-01f, 5.82934320e-02f, -3.14411595e-02f, -8.20781365e-02f,
  1.65611342e-01f, -3.92079027e-03f, -1.51869446e-01f, 2.17523668e-02f, 3.08883768e-02f, 7.11883381e-02f, 1.16120264e-01f, -4.12337892e-02f, -1.01247482e-01f, 6.10741489e-02f,
  -2.74818927e-01f, 9.31727588e-02f, -1.89708117e-02f, 2.24167988e-01f, 1.80367023e-01f, 1.52364999e-01f, 2.65092909e-01f, 1.74111590e-01f, 8.52924064e-02f, 8.42105248e-04f,
  8.51327106e-02f, 1.28131779e-02f, 9.77750644e-02f, 4.80382070e-02f, 9.57459658e-02f, 8.94854143e-02f, 1.77153945e-01f, -1.48665281e-02f, -3.81962135e-02f, -9.11692157e-02f,
  -6.17592409e-02f, -3.38025354e-02f, -2.39611864e-01f, -8.67058635e-02f, 6.33272082e-02f, 4.53965887e-02f, -1.37516148e-02f, 9.18394998e-02f, 8.01032186e-02f, 1.79105267e-01f,
  1.38111442e-01f, 1.55472547e-01f, -5.70332520e-02f, -8.79096836e-02f, -1.72451630e-01f, -1.40593618e-01f, -6.53041378e-02f, -1.02346785e-01f, -1.23481750e-02f, 4.86280769e-04f,
  5.77355623e-02f, -2.10005622e-02f, -6.11949116e-02f, -6.03664517e-02f, -1.53041944e-01f, -4.00409959e-02f, -1.37745857e-01f, -1.54137351e-02f, 1.58943191e-01f, -1.47473402e-02f,
  7.32783079e-02f, -4.33945879e-02f, 1.34249928e-03f, -1.48497603e-03f, 4.90252487e-02f, 4.36685495e-02f, -5.89633025e-02f, -1.26117300e-02f, -1.07026026e-01f, -1.88636482e-01f,
  -2.20956765e-02f, -2.46404856e-01f, -1.38776088e-02f, -4.45834026e-02f, -9.91265997e-02f, 1.01112433e-01f, 1.87230557e-01f, 1.37116179e-01f, -6.92740306e-02f, -1.98054090e-01f,
  -5.54885864e-02f, 8.84008184e-02f, -8.16790573e-03f, 7.57126836e-03f, -3.85967619e-03f, -5.74671254e-02f, -4.53236587e-02f, 2.11871900e-02f, -7.97346085e-02f, -1.57086477e-02f,
  9.75041687e-02f, 2.71678250e-02f, -2.75068078e-02f, 1.55797172e-02f, -6.84976950e-02f, -6.05751723e-02f, -7.60291098e-03f, -1.18703172e-01f, -9.47425365e-02f, -1.12309434e-01f,
  2.29426846e-01f, 1.01643831e-01f, 1.47597790e-01f, 5.63458130e-02f, 7.97482505e-02f, -3.83870502e-04f, 1.73167549e-02f, 1.19857557e-01f, 2.66663313e-01f, 1.65421665e-01f,
  4.82124612e-02f, 3.15844379e-02f, -1.25129551e-01f, -4.24191393e-02f, -1.44858241e-01f, -1.06364116e-01f, 5.00908075e-03f, 1.28247991e-01f, 1.39224857e-01f, 3.34751159e-02f,
  3.37187052e-02f, 8.75098705e-02f, 4.07740436e-02f, 1.44471824e-01f, 6.71865046e-02f, 7.06013441e-02f, 6.16255216e-02f, -5.11104204e-02f, 9.32376683e-02f, -1.52691603e-01f,
  9.18554440e-02f, -2.04327822e-01f, 1.09900013e-02f, -4.13130261e-02f, 9.40918252e-02f, 7.94325024e-02f, -8.73279795e-02f, 8.61251429e-02f, 2.94632688e-02f, -2.10006431e-01f,
  1.45617099e-02f, 2.05156595e-01f, 8.03395435e-02f, 1.28454864e-01f, 2.91859545e-02f, -1.93705305e-01f, -1.34885177e-01f, 7.46339038e-02f, 1.29864573e-01f, 8.61802474e-02f,
  2.10908102e-03f, 2.38621533e-02f, -4.51814048e-02f, 1.76784955e-02f, -1.91768974e-01f, -1.22596271e-01f, -1.90234035e-01f, -1.37186170e-01f, -2.26576835e-01f, -3.01301271e-01f,
  1.06187657e-01f, 6.95580468e-02f, 1.52656972e-01f, 7.08249211e-02f, -2.66176881e-03f, -9.94404331e-02f, -3.27270925e-02f, 2.29164697e-02f, 3.30537185e-02f, -5.16665131e-02f,
  -5.91801032e-02f, -9.40023735e-03f, -3.23847719e-02f, -1.39285205e-02f, 5.12022749e-02f, -1.13118077e-02f, -4.92957141e-03f, 5.72210923e-02f, 5.59317581e-02f, 3.17709260e-02f,
  -1.40144870e-01f, -7.41186365e-02f, -9.05486345e-02f, -3.34039144e-02f, 7.88457096e-02f, 8.09750482e-02f, 3.52609865e-02f, -7.90219977e-02f, 1.62085786e-03f, -2.71831453e-01f,
  -6.53553605e-02f, 1.15263477e-01f, 5.31359203e-02f, -1.33362086e-02f, 3.95362303e-02f, -5.00566587e-02f, -6.95285201e-02f, -2.44237520e-02f, 1.96653157e-02f, -2.10087933e-02f,
  5.88500611e-02f, -8.11043754e-03f, 6.52893633e-02f, -7.35152811e-02f, 3.72282900e-02f, -6.33770302e-02f, -7.40606189e-02f, -1.91814397e-02f, -1.28074110e-01f, -9.32969823e-02f,
  5.37730791e-02f, 1.05681736e-02f, -5.33051305e-02f, 8.64166617e-02f, 1.84363667e-02f, 4.17805351e-02f, 6.97681457e-02f, 1.05640814e-01f, 6.77510574e-02f, -1.17858648e-02f,
  7.57550523e-02f, 2.21236385e-02f, -1.12693630e-01f, -1.22831808e-02f, -1.31014690e-01f, -4.54852171e-02f, -1.16184376e-01f, 5.97758181e-02f, 1.09598927e-01f, -4.39066067e-02f,
  2.80573238e-02f, -6.58291131e-02f, -8.37281048e-02f, -4.14019823e-02f, 3.89586240e-02f, -4.37877513e-02f, -1.72754824e-01f, -2.67055444e-02f, -4.68808133e-03f, -6.82596788e-02f,
  -3.57491970e-02f, -2.59924913e-03f, -1.28180265e-01f, -1.34059384e-01f, -2.73410790e-02f, -4.49545085e-02f, -5.66318333e-02f, -1.60631135e-01f, 1.55866425e-03f, -3.18459958e-01f,
  1.46701820e-02f, -2.21068382e-01f, 1.82032585e-01f, 1.39394999e-02f, 2.23571494e-01f, 2.63884664e-01f, 1.78386167e-01f, 2.98071504e-02f, -1.01976413e-02f, -3.13797928e-02f,
  -6.05558455e-02f, -4.24289471e-03f, -4.82352190e-02f, -9.29282978e-02f, -3.38224620e-02f, 7.31588826e-02f, 4.47505265e-02f, 9.17322654e-03f, 6.81729540e-02f, -8.03471077e-03f,
  -5.30440621e-02f, 1.42425122e-02f, -8.00744519e-02f, -1.38530046e-01f, -1.46572515e-01f, -5.53098209e-02f, 4.45425697e-02f, -5.21105602e-02f, -4.38783504e-03f, -4.67235558e-02f,
  4.78895977e-02f, 8.95581841e-02f, 7.21679826e-04f, -1.44458622e-01f, -6.96088234e-03f, 1.66957844e-02f, -6.44474998e-02f, -1.43938839e-01f, 1.78425480e-02f, -9.30942073e-02f,
  6.11015782e-02f, -7.87814781e-02f, 1.96825340e-03f, -9.35690403e-02f, -3.89559893e-03f, -9.19460654e-02f, -3.77654433e-02f, -9.80921388e-02f, -8.59731212e-02f, -6.79742172e-02f,
  -5.41926362e-02f, 3.98206599e-02f, 1.90742269e-01f, 8.58132169e-02f, -4.55386937e-02f, -3.32439989e-02f, -7.31673166e-02f, 4.62577045e-02f, -2.26685032e-03f, 2.34760828e-02f,
  -7.05441518e-04f, 9.58441496e-02f, 6.99353889e-02f, 4.41605188e-02f, 8.68976042e-02f, 3.70296203e-02f, 6.27357140e-02f, 2.17141695e-02f, 1.84560120e-01f, 2.87637170e-02f,
  1.50632650e-01f, 2.14064568e-02f, 4.32656780e-02f, 1.53369412e-01f, 8.68214667e-02f, 4.29428443e-02f, 9.68499109e-02f, 3.86024788e-02f, 7.84886535e-03f, 1.47357639e-02f,
  9.16308612e-02f, 1.21393591e-01f, 9.59649533e-02f, 4.38742340e-02f, 2.51052827e-02f, -2.60591675e-02f, 1.32526830e-01f, -5.02165407e-02f, -1.30893728e-02f, 1.48081869e-01f,
  -6.37304708e-02f, 1.34109989e-01f, 4.24571671e-02f, -3.04530803e-02f, 1.03852361e-01f, -3.75331007e-02f, 1.15685882e-02f, -1.01437315e-01f, -3.25506367e-02f, 2.74146032e-02f,
  -4.00687233e-02f, -5.17610786e-03f, 1.49851171e-02f, -4.25796257e-03f, 5.38203008e-02f, 1.00407481e-01f, -7.13416338e-02f, -2.87101213e-02f, -1.18251726e-01f, -3.23534980e-02f,
  -5.39623052e-02f, 1.27628416e-01f, 1.05624318e-01f, -6.97930017e-03f, 9.51444656e-02f, 1.72285601e-01f, -9.32584051e-03f, 1.06740065e-01f, 4.08143178e-02f, 9.58961342e-03f,
  3.35823327e-01f, -2.08282694e-01f, 4.08185303e-01f, 2.10501696e-03f, -8.32546689e-03f, 1.86205596e-01f, 3.79584841e-02f, 7.57675767e-02f, -9.41871926e-02f, -4.91402708e-02f,
  -2.48278707e-01f, -3.19440752e-01f, -2.22716570e-01f, -2.52158970e-01f, -5.81944026e-02f, 1.44841313e-01f, 1.99625075e-01f, 3.07022452e-01f, 2.00440258e-01f, 1.45725176e-01f,
  -1.13127828e-01f, 1.36325493e-01f, 1.33478478e-01f, 1.20210990e-01f, -3.61623652e-02f, -7.31264427e-02f, 5.25301099e-02f, 1.20950975e-01f, -1.17529355e-01f, 3.67054529e-03f,
  1.04400225e-01f, 1.25106007e-01f, -5.43223508e-03f, -2.35539615e-01f, -9.84614119e-02f, 3.00857313e-02f, 3.11354566e-02f, 3.61691751e-02f, -1.32213727e-01f, 1.77031234e-02f,
  -1.05610698e-01f, 2.50603408e-02f, -1.71278715e-01f, -1.08452313e-01f, -1.52776511e-02f, 7.77462497e-02f, 4.26442660e-02f, 1.20883599e-01f, 7.92036504e-02f, -3.84779721e-02f,
  -1.89441755e-01f, -8.97807106e-02f, 6.67636991e-02f, -7.17338324e-02f, 3.11263464e-02f, 2.50653457e-02f, -2.88550910e-02f, 9.87211615e-02f, -6.99084904e-03f, 6.84048235e-02f,
  -3.43975723e-02f, 2.11376101e-02f, 5.62493391e-02f, 1.78638715e-02f, -6.00398146e-02f, -1.12961352e-01f, 1.50202531e-02f, -2.89878771e-02f, 6.15507923e-02f, 9.54831690e-02f,
  2.20320970e-02f, -9.25432798e-03f, 7.47169107e-02f, -5.44927046e-02f, -4.49106563e-03f, 6.38521463e-02f, 3.96255665e-02f, -4.59013321e-02f, 6.50197407e-03f, -1.47196427e-02f,
  1.65556010e-03f, -9.58186202e-03f, 9.38760489e-02f, -5.14922477e-02f, 4.84698378e-02f, 1.06924646e-01f, 2.64326800e-02f, -5.97033277e-03f, 3.48325334e-02f, -1.88535899e-02f,
  -2.80350208e-01f, -1.97987899e-01f, -5.12944534e-02f, -1.37627408e-01f, 1.03023246e-01f, -9.65788364e-02f, -1.10997714e-01f, -3.70432846e-02f, -8.40050951e-02f, 4.23298255e-02f,
  -3.49248685e-02f, -8.36203434e-03f, -8.00648406e-02f, -8.90302584e-02f, 4.87807877e-02f, -3.74972448e-02f, -1.64673582e-01f, 2.64792405e-02f, -8.09010938e-02f, 3.11879907e-02f,
  -1.05753057e-01f, 6.00656010e-02f, 2.62860917e-02f, -5.74689638e-03f, -3.77797484e-02f, 5.30534834e-02f, 3.38410563e-03f, -3.98762301e-02f, 9.82800424e-02f, -5.60068153e-03f,
  -4.01111871e-01f, -9.51624885e-02f, 1.00987881e-01f, -3.61780971e-01f, -1.47715630e-02f, 1.54195532e-01f, 1.34374350e-01f, 3.72688249e-02f, -4.92551923e-02f, 1.82569362e-02f,
  6.42145351e-02f, -1.95499778e-01f, -1.96998835e-01f, -2.28427351e-02f, -3.15162502e-02f, -7.01749399e-02f, -1.79348618e-01f, -1.74929276e-01f, -7.25737512e-02f, -1.91528015e-02f,
  -1.87568307e-01f, -3.12215328e-01f, -2.77213186e-01f, -2.70564586e-01f, -2.15128273e-01f, -3.48146915e-01f, -1.02157108e-01f, -1.05773814e-01f, -4.85846177e-02f, -2.81003565e-01f,
  2.55132783e-02f, 4.08444032e-02f, -3.75990644e-02f, -1.52859151e-01f, -8.02633241e-02f, -1.11407109e-01f, -2.87937988e-02f, 4.05159928e-02f, 2.80827470e-02f, 8.25580359e-02f,
  3.05025671e-02f, -6.65928647e-02f, -1.68890089e-01f, 1.38702065e-01f, -5.84628433e-02f, -2.59731896e-02f, 1.49593085e-01f, -4.48299460e-02f, 1.15416553e-02f, 6.52168989e-02f,
  2.17009466e-02f, 6.64078221e-02f, 2.57600266e-02f, 1.40702590e-01f, 1.45771012e-01f, -2.47663930e-02f, 8.77361670e-02f, 3.77186127e-02f, 1.50893971e-01f, -1.96992178e-02f,
  -1.89530489e-03f, 4.00421731e-02f, 9.04694125e-02f, -3.36729363e-02f, 5.72455153e-02f, 1.11137396e-02f, 5.39286295e-03f, -3.16843614e-02f, -3.39977853e-02f, -7.17975274e-02f,
  7.71206198e-03f, 7.16126114e-02f, -4.33010757e-02f, -1.83247596e-01f, 4.11166772e-02f, 6.84795603e-02f, -1.01874408e-03f, 7.78378099e-02f, 3.57849486e-02f, -2.56033372e-02f,
  3.64443101e-02f, 4.87609254e-03f, -8.88168067e-02f, 3.39281559e-02f, 7.75351608e-03f, 6.61020726e-02f, 1.42532781e-01f, 8.17290545e-02f, 1.37237012e-01f, 1.06341140e-02f,
  -7.66211674e-02f, -7.64450952e-02f, -1.83904380e-01f, -1.41788051e-02f, 5.22510931e-02f, -6.13992708e-03f, 8.49874765e-02f, 4.30838764e-03f, -1.18031524e-01f, 8.53502527e-02f,
  7.46360719e-02f, 6.39833882e-02f, 6.66013286e-02f, 7.58261532e-02f, -1.20532941e-02f, 6.78167269e-02f, 1.23339653e-01f, -8.27965513e-02f, 1.41378371e-02f, 1.81639571e-05f,
  1.15927003e-01f, 7.24633634e-02f, -1.19977824e-01f, 5.23428172e-02f, -2.10018884e-02f, -8.60656705e-03f, -6.15956970e-02f, 1.14872262e-01f, 5.64047545e-02f, -1.05104066e-01f,
  2.26584062e-01f, -2.46860921e-01f, -2.51395494e-01f, -1.23358175e-01f, -1.17646009e-01f, 6.84821084e-02f, -5.65942898e-02f, 1.14959255e-01f, 2.05541681e-02f, -2.18621910e-01f,
  -1.05038427e-01f, 1.77167624e-01f, 5.51188961e-02f, -7.79474911e-04f, 2.20283866e-01f, -1.92042187e-01f, -1.38968036e-01f, 1.66084081e-01f, 1.84543446e-01f, 1.58493936e-01f,
  5.13014570e-02f, 3.03881373e-02f, 1.14211924e-01f, 6.21810518e-02f, -1.85027435e-01f, -8.36286396e-02f, -2.28949338e-01f, -2.09322557e-01f, -1.76315203e-01f, -3.72251093e-01f,
  -1.59070328e-01f, -6.77881464e-02f, 4.38949130e-02f, 1.75349526e-02f, -1.34401739e-01f, 6.98418692e-02f, 4.13053706e-02f, -1.75260410e-01f, -4.76076789e-02f, -9.26780626e-02f,
  1.94190983e-02f, -1.23256510e-02f, -2.53282730e-02f, 4.98721004e-02f, -4.96575497e-02f, 1.38503662e-03f, -8.65459219e-02f, 7.25729670e-03f, 3.00041307e-02f, -7.87163079e-02f,
  -9.82219130e-02f, -2.29149703e-02f, -7.88221136e-02f, -3.30011882e-02f, 5.86251803e-02f, 1.15657873e-01f, -1.37791485e-01f, -6.65480122e-02f, 4.22339477e-02f, -1.91581890e-01f,
  7.71034807e-02f, -5.35543822e-03f, -5.82668278e-03f, 1.58191565e-02f, 9.40979123e-02f, -4.22274619e-02f, -1.09410416e-02f, -2.53485050e-02f, 3.41109857e-02f, -8.80865976e-02f,
  4.77367034e-03f, 1.04437731e-02f, 9.28813312e-03f, -5.09596802e-02f, 1.81702934e-02f, -6.58005029e-02f, -7.05911545e-03f, 7.97720924e-02f, 3.35896178e-03f, 3.78296077e-02f,
  6.54805228e-02f, 8.82407427e-02f, 2.29690666e-03f, -2.89592575e-02f, 3.35258879e-02f, -2.12354418e-02f, -9.79020223e-02f, 8.18415880e-02f, 5.62721454e-02f, 1.04894377e-02f,
  -3.01827528e-02f, 2.09996402e-01f, -1.00664183e-01f, 5.37630059e-02f, -8.65776762e-02f, 7.11121112e-02f, -1.07928794e-02f, -6.61925301e-02f, -5.44271469e-02f, 4.18412723e-02f,
  -9.49104130e-02f, -1.40652026e-03f, -9.67787206e-02f, 2.93255467e-02f, 3.08309812e-02f, 2.87388731e-02f, -3.59731987e-02f, 5.84857874e-02f, 5.93306012e-02f, -6.08014874e-02f,
  9.76165906e-02f, 8.85154158e-02f, 9.74440947e-02f, 1.55570880e-01f, 3.98510844e-02f, 1.23070531e-01f, -8.70992895e-03f, -5.36900898e-03f, 1.24595247e-01f, 2.28205100e-02f,
  9.40037742e-02f, 5.25516234e-02f, 6.23196997e-02f, 4.09677476e-02f, 3.03764105e-01f, 3.84308755e-01f, 3.00651699e-01f, 1.29496753e-01f, 1.31093800e-01f, 6.48264065e-02f,
  -1.10787600e-01f, -2.88502246e-01f, -2.14035869e-01f, -1.48680747e-01f, 1.87778305e-02f, 1.53183714e-01f, 1.71407804e-01f, 1.23352021e-01f, -2.18684096e-02f, 1.40285596e-01f,
  1.14135006e-02f, -3.61474021e-03f, -3.19632776e-02f, 1.09196514e-01f, -6.51615933e-02f, -5.04118763e-02f, 7.67373443e-02f, 8.20262656e-02f, 9.63837728e-02f, -1.35716632e-01f,
  -3.32897902e-01f, 7.74381608e-02f, -4.98750359e-02f, -2.84991767e-02f, -3.06750759e-02f, -1.55046970e-01f, -1.42133474e-01f, -1.01361237e-01f, -5.62411966e-03f, 1.69063185e-03f,
  -5.36304675e-02f, 3.35720591e-02f, 3.92815508e-02f, 1.87385660e-02f, 1.04041761e-02f, 5.20802438e-02f, 5.03281094e-02f, -1.14446104e-01f, -1.25518084e-01f, -8.91415700e-02f,
  -1.35312706e-01f, -4.24969569e-02f, 1.30378947e-01f, -4.23289724e-02f, 5.21212518e-02f, -1.09193005e-01f, -8.24240074e-02f, 1.58332381e-02f, -1.35824634e-02f, -1.05511732e-01f,
  -1.23121366e-01f, 2.77302824e-02f, -4.24670652e-02f, -5.40441237e-02f, -6.88738050e-03f, 5.26389554e-02f, 1.87144354e-02f, -2.77886223e-02f, 2.79751718e-02f, -4.51946259e-02f,
  -1.45150684e-02f, -6.71788901e-02f, -2.52954066e-01f, -1.24463715e-01f, -1.63310662e-01f, -1.19159497e-01f, -1.05117314e-01f, -4.87115793e-03f, -9.45235565e-02f, 2.12346353e-02f,
  2.10745260e-02f, 2.05154996e-02f, -7.17386752e-02f, -5.86902574e-02f, -2.36766674e-02f, -5.56381531e-02f, -1.31693467e-01f, -1.77345932e-01f, -2.53700539e-02f, -1.37946131e-02f,
  -3.50034028e-01f, -1.59561202e-01f, -1.40821204e-01f, -1.13608457e-01f, -5.99980056e-02f, -9.08803418e-02f, -2.08153859e-01f, -1.00472152e-01f, 5.75873815e-02f, 2.25747209e-02f,
  -5.81541546e-02f, -4.21365350e-02f, -6.54222667e-02f, -1.65488683e-02f, 1.19287716e-02f, -1.66122969e-02f, -5.01465723e-02f, -1.12966690e-02f, -9.99260545e-02f, 4.84651513e-03f,
  -1.09882150e-02f, 6.06526770e-02f, 6.92434534e-02f, 5.92629239e-03f, -4.71806712e-02f, 4.68015596e-02f, 7.05192536e-02f, 1.10280029e-01f, 1.54570684e-01f, 1.63974449e-01f,
  -4.37184870e-02f, 6.50751665e-02f, -1.32208578e-02f, -2.76960637e-02f, 4.78371792e-02f, -2.17382103e-01f, -2.10542589e-01f, -2.65364289e-01f, 3.16288788e-03f, 4.66506481e-02f,
  6.53554127e-02f, 3.28847244e-02f, -7.75564834e-02f, -9.76103395e-02f, -2.10989743e-01f, -3.97206508e-02f, -1.84627324e-02f, -1.20483607e-01f, -1.99792683e-01f, -1.55863389e-01f,
  -1.41404927e-01f, -1.48757011e-01f, -1.34559453e-01f, -1.42160758e-01f, 4.48948368e-02f, -1.03503183e-01f, 8.52636769e-02f, -8.88777897e-03f, 5.03686480e-02f, 1.77271694e-01f,
  2.55875736e-01f, 1.30910009e-01f, -1.31418794e-01f, -5.84353171e-02f, 1.09704688e-01f, 6.59745932e-02f, 4.10825834e-02f, 4.72426414e-02f, -1.17412088e-02f, -7.95423910e-02f,
  2.96752695e-02f, -9.25167277e-02f, -2.38430966e-02f, -1.08831622e-01f, -5.49159274e-02f, -1.29255474e-01f, -8.66788905e-03f, -1.69698209e-01f, -5.90718538e-02f, -3.64393592e-02f,
  -7.29813203e-02f, -4.90750149e-02f, -1.28101399e-02f, -1.24452680e-01f, -8.44962820e-02f, -3.26155610e-02f, -7.97746032e-02f, -1.20818168e-02f, -1.13559753e-01f, 1.70870442e-02f,
  -6.42474964e-02f, 5.58966696e-02f, -4.50776443e-02f, -3.19442898e-02f, -2.76716356e-03f, 1.01869814e-01f, 6.37615994e-02f, -7.22357482e-02f, -2.28464529e-02f, -4.47684675e-02f,
  5.39353378e-02f, 3.98867726e-02f, 4.32006642e-02f, 1.17450468e-02f, 8.47157370e-03f, -2.84741838e-02f, -2.98460238e-02f, -1.08817536e-02f, 3.39358188e-02f, 9.98487771e-02f,
  -2.17225533e-02f, -6.61490783e-02f, 2.77137291e-02f, -6.83310628e-02f, 7.78550729e-02f, 1.94785856e-02f, -1.16513316e-02f, -4.99081463e-02f, 7.20806122e-02f, -3.94777693e-02f,
  -2.32843347e-02f, -7.43899494e-02f, -2.97297388e-02f, -1.69192940e-01f, -4.53956686e-02f, -3.52642615e-03f, 4.42995988e-02f, -1.27652243e-01f, -4.98920493e-02f, -3.01058497e-02f,
  -1.28940850e-01f, 1.27404521e-03f, 8.99319202e-02f, -1.25643164e-01f, -1.18045241e-01f, -3.99976522e-02f, -2.84613706e-02f, -4.11385931e-02f, -1.75141618e-01f, 8.79995078e-02f,
  -1.49126828e-01f, -1.74074158e-01f, -1.32063612e-01f, -1.33465886e-01f, -3.74927074e-02f, -1.14288874e-01f, -2.81979907e-02f, -1.32944092e-01f, -2.29832262e-01f, -1.45837769e-01f,
  -5.95412366e-02f, -4.23205465e-01f, -2.32555553e-01f, -1.02376208e-01f, 4.63348702e-02f, 2.48832658e-01f, 4.95136417e-02f, 5.30312546e-02f, 3.72367911e-02f, -2.79499590e-01f,
  -2.83363640e-01f, -1.58833802e-01f, -2.22229868e-01f, -1.33534893e-01f, -1.38876632e-01f, -1.29338697e-01f, -9.74470079e-02f, 8.37123096e-02f, 2.06466675e-01f, 2.91180491e-01f,
  7.01644719e-02f, 1.43930048e-01f, 5.52630872e-02f, 8.86593610e-02f, -8.97102654e-02f, -5.04267104e-02f, -1.65340289e-01f, -3.72510515e-02f, -7.82122910e-02f, -2.96766788e-01f,
  -1.72089800e-01f, -2.04089463e-01f, 3.36445421e-02f, -1.22200297e-02f, -1.41480699e-01f, -8.74719620e-02f, -2.55813953e-02f, -1.00024708e-01f, 3.00268382e-02f, 1.29965204e-03f,
  -1.04902022e-01f, 2.90645361e-02f, -7.98963681e-02f, 2.77125975e-04f, 6.92793205e-02f, 1.49621502e-01f, -1.19856201e-01f, -1.99697137e-01f, -7.74258003e-02f, -9.24003795e-02f,
  -1.83641508e-01f, 3.18544246e-02f, 5.93116693e-02f, 2.48682182e-02f, 2.05053464e-02f, -8.49233344e-02f, -5.05511798e-02f, 5.70129678e-02f, 8.05899352e-02f, -8.21710825e-02f,
  5.41867018e-02f, -4.22605015e-02f, 9.85964388e-02f, 8.55877437e-03f, 7.16232806e-02f, 9.41431075e-02f, 7.91509971e-02f, 3.55366841e-02f, -5.80331264e-03f, -1.13774210e-01f,
  -7.34900609e-02f, 1.02593761e-03f, -8.53710175e-02f, -6.75694793e-02f, -1.06230326e-01f, -3.75682600e-02f, -8.38609263e-02f, -3.21512446e-02f, -3.77378501e-02f, -9.09588672e-03f,
  -1.17529906e-01f, -9.99790430e-02f, -1.94189921e-02f, -1.55066438e-02f, -1.68403089e-01f, -1.45272806e-01f, -1.18025150e-02f, 2.82423478e-02f, -2.44305786e-02f, -1.04113683e-01f,
  4.09212075e-02f, -4.04997468e-02f, -7.72937089e-02f, 6.66046441e-02f, 5.47176562e-02f, -3.37938294e-02f, -1.45401061e-01f, 2.78900564e-02f, -1.44971246e-02f, 9.29083973e-02f,
  3.99916656e-02f, 4.86628078e-02f, -3.69932279e-02f, -1.07082855e-02f, 2.00822100e-01f, 8.61982107e-02f, -1.31459041e-02f, -3.10564339e-02f, 1.05030918e-02f, -5.89222163e-02f,
  -1.18145989e-02f, 1.06353737e-01f, 1.29207969e-01f, 5.45842797e-02f, 7.29600266e-02f, 1.41559392e-01f, 1.44349888e-01f, 1.12128451e-01f, 2.08793864e-01f, 2.00312182e-01f,
  -4.43769097e-01f, -2.04003006e-01f, -2.02532351e-01f, 1.29468143e-01f, 1.92311406e-01f, -7.67519651e-03f, -1.22121885e-01f, -1.69941798e-01f, 8.54874551e-02f, 9.01773795e-02f,
  3.82968821e-02f, 1.52725920e-01f, 5.15257344e-02f, 1.16351256e-02f, -1.69856042e-01f, 2.10375339e-02f, 2.43703306e-01f, -6.50592521e-02f, -1.07990436e-01f, -6.98975241e-03f,
  2.50471592e-01f, 1.04699820e-01f, -8.93184990e-02f, -4.94265594e-02f, 3.00928771e-01f, 2.30542660e-01f, 4.96189557e-02f, 1.70856148e-01f, 2.06108525e-01f, 3.66294920e-01f,
  2.02026471e-01f, -1.83112144e-01f, 3.73312868e-02f, 1.26471624e-01f, -8.70783776e-02f, -9.05939639e-02f, 6.42262101e-02f, -1.13963701e-01f, -2.04172488e-02f, 7.86121488e-02f,
  1.95344031e-01f, -3.31928991e-02f, -7.21636564e-02f, 3.51930596e-02f, 7.95521215e-02f, 5.50156198e-02f, -1.44788325e-01f, -1.83511212e-01f, -7.24194869e-02f, -1.78053044e-03f,
  2.27110729e-01f, 2.65932400e-02f, 6.93996549e-02f, -1.31225839e-01f, -6.54972568e-02f, -2.14687884e-02f, -1.05287075e-01f, -7.62055069e-02f, -9.04332921e-02f, -1.26645893e-01f,
  -5.89301139e-02f, 2.44918354e-02f, 9.03021619e-02f, 4.57372703e-03f, 3.43968794e-02f, -3.32493186e-02f, 4.19408120e-02f, 8.11859369e-02f, 1.10169455e-01f, 8.18541367e-03f,
  5.69007918e-02f, 7.21940920e-02f, -3.61553975e-03f, -5.14859706e-02f, 1.09220423e-01f, 5.50281629e-02f, 1.04162633e-01f, 4.91955653e-02f, 8.19315910e-02f, 1.11626431e-01f,
  1.54937893e-01f, 2.73277182e-02f, -1.54501358e-02f, -2.25178748e-02f, -2.81422082e-02f, 2.05440484e-02f, 1.05937704e-01f, 1.25077635e-01f, 7.28122890e-02f, -3.45300883e-03f,
  1.65318206e-01f, -1.41897142e-01f, 9.57467332e-02f, -4.67263870e-02f, 8.26368928e-02f, -6.92004114e-02f, 8.47291052e-02f, 1.69433840e-03f, 1.56694770e-01f, 8.66923183e-02f,
  2.20441177e-01f, -9.05918330e-03f, -7.14242607e-02f, 3.59546542e-02f, 4.96894829e-02f, 1.08832359e-01f, 6.49342686e-02f, 1.98176429e-02f, 6.52095079e-02f, 7.08119273e-02f,
  -6.47762343e-02f, -7.02062855e-03f, -8.60439148e-03f, 6.02654472e-04f, 1.08761741e-02f, 1.49913989e-02f, 1.05528515e-02f, -3.57697941e-02f, -1.90309770e-02f, -1.79241985e-01f,
  -3.97027910e-01f, -5.00240587e-02f, 1.36277691e-01f, -8.53519607e-03f, -5.21183526e-03f, -2.21461244e-02f, 1.01698026e-01f, -6.14904761e-02f, -6.09795488e-02f, -2.50375643e-02f,
  -1.05282471e-01f, -1.46047369e-01f, -8.87441710e-02f, 1.25992158e-02f, 2.96014491e-02f, 1.24798134e-01f, 1.80591196e-01f, 9.34600160e-02f, 2.96148956e-02f, 3.19121629e-02f,
  1.58554778e-01f, 1.09287359e-01f, -5.51385917e-02f, -2.32599974e-02f, 6.91490918e-02f, -1.21460669e-02f, 8.78439844e-02f, -6.24511689e-02f, 7.45451599e-02f, -3.13093066e-02f,
  2.27743432e-01f, -1.49932653e-01f, -1.03777632e-01f, -1.08021855e-01f, -1.32872000e-01f, -9.63179991e-02f, -1.03325486e-01f, -6.58817366e-02f, -1.56834811e-01f, -9.12056416e-02f,
  -1.84156820e-01f, -8.42408165e-02f, -1.30111843e-01f, 5.05845109e-03f, -3.05053722e-02f, -1.59914009e-02f, -1.24169923e-01f, 1.63337588e-02f, 1.78909525e-02f, -5.04274443e-02f,
  -1.35722682e-01f, -8.96839723e-02f, 5.14931157e-02f, -1.31415591e-01f, -1.36099845e-01f, -4.56048623e-02f, -1.03996508e-01f, -4.79119197e-02f, -1.55067161e-01f, 4.53075357e-02f,
  3.92259173e-02f, -1.46732375e-01f, -1.62984878e-01f, 4.54721833e-03f, -5.48403971e-02f, 1.62118506e-02f, -5.86815253e-02f, -6.83923215e-02f, -1.58716172e-01f, 3.65239456e-02f,
  -2.04281379e-02f, 1.26215564e-02f, -2.05389801e-02f, 6.23793043e-02f, -8.14380571e-02f, -1.84734762e-01f, -5.93018755e-02f, -1.00413458e-02f, -8.07709172e-02f, -9.75878462e-02f,
  -1.30576462e-01f, -8.93853530e-02f, 1.71716996e-02f, 6.70834854e-02f, 7.34022483e-02f, -1.03593431e-01f, -6.25404269e-02f, -4.33768593e-02f, -1.06133632e-02f, -5.14809554e-03f,
  1.54844210e-01f, -1.71995953e-01f, 9.16098952e-02f, -3.90616804e-02f, 5.64333647e-02f, -9.10354480e-02f, -1.65798843e-01f, 1.01547413e-01f, 5.17259203e-02f, 1.25283286e-01f,
  -2.66735423e-02f, -8.05531666e-02f, 4.02963497e-02f, -3.50677557e-02f, 1.72089845e-01f, 3.47916298e-02f, -5.10389432e-02f, 1.21192284e-01f, 4.83154804e-02f, 1.39942825e-01f,
  2.03326959e-02f, 1.80795848e-01f, 1.18361101e-01f, 1.52703196e-01f, -5.31730801e-02f, 9.44203213e-02f, 2.12518021e-01f, 1.45678163e-01f, 1.55558482e-01f, 3.40440840e-01f,
  -3.92386734e-01f, -3.00434023e-01f, -9.66031030e-02f, -4.17394161e-01f, -3.05938542e-01f, 1.58606842e-03f, -1.40270978e-01f, -8.11118037e-02f, -2.62024313e-01f, -3.23789895e-01f,
  -1.93088964e-01f, 6.31299019e-02f, -9.31656659e-02f, 3.51408683e-02f, 7.91097283e-02f, -1.43711969e-01f, -1.32489696e-01f, 1.32417142e-01f, 2.72305757e-01f, 1.39779583e-01f,
  -4.77031134e-02f, -7.79734105e-02f, -6.54827245e-03f, 1.28509641e-01f, -1.05584502e-01f, 6.29138499e-02f, -2.69895718e-02f, -1.06980667e-01f, -1.11801689e-02f, -1.53404310e-01f,
  -1.16449669e-01f, -2.22392365e-01f, 3.39538567e-02f, 3.97303663e-02f, -1.47086039e-01f, 8.86288732e-02f, -1.12068191e-01f, -2.82700127e-03f, 1.12361053e-03f, 9.16730985e-03f,
  -1.59158707e-01f, 8.20190758e-02f, -1.15023382e-01f, -2.28513647e-02f, -1.37780458e-01f, -2.85098981e-02f, 6.49125595e-03f, 3.55361141e-02f, 6.09550811e-03f, -4.70979279e-03f,
  -6.97812289e-02f, 3.90308313e-02f, -8.52992833e-02f, 7.51926079e-02f, 6.68884888e-02f, 5.66353127e-02f, -1.63310058e-02f, 2.49894187e-02f, 5.09160683e-02f, -6.20190315e-02f,
  -1.85643490e-02f, 1.05951866e-03f, -5.07628720e-04f, 1.46902679e-02f, 3.78938951e-02f, -4.88134399e-02f, -5.28544746e-02f, 6.98419437e-02f, -1.96134560e-02f, 4.23928536e-02f,
  4.75362549e-03f, -8.91034082e-02f, -6.47710040e-02f, -6.72930405e-02f, 5.39307557e-02f, 2.83408426e-02f, -1.01107983e-02f, 5.48424833e-02f, 9.98916104e-02f, 4.05558608e-02f,
  7.48843923e-02f, 1.28941283e-01f, -6.64996728e-02f, 2.03242034e-01f, 2.92156879e-02f, 3.53389643e-02f, 4.64079827e-02f, 1.10500805e-01f, -7.20443651e-02f, -6.57218322e-02f,
  -5.31963818e-02f, 1.20927561e-02f, -2.33127475e-01f, -2.88813934e-02f, -1.17944023e-02f, 8.91230553e-02f, -8.27316716e-02f, 2.51676869e-02f, -9.52321514e-02f, -1.18157595e-01f,
  4.24049087e-02f, -4.64408658e-02f, -1.68827936e-01f, 1.86130535e-02f, 6.97568059e-02f, 9.57231075e-02f, 2.81526428e-02f, -5.22993058e-02f, 1.39932692e-01f, 9.44962073e-03f,
  1.56489462e-01f, 1.09938346e-01f, 3.20807882e-02f, 8.40802938e-02f, 1.19686261e-01f, 9.54445675e-02f, 8.40320215e-02f, -3.81110571e-02f, 1.83084413e-01f, -1.84037406e-02f,
  3.31771702e-01f, 9.84192863e-02f, 8.70441273e-02f, 9.28103030e-02f, 6.51474521e-02f, 3.79453525e-02f, 3.97129916e-02f, 5.03278002e-02f, -1.66308265e-02f, 1.21308975e-01f,
  1.89954683e-01f, 1.08542249e-01f, 1.26788437e-01f, 1.83800384e-01f, 9.86755639e-02f, 7.87486359e-02f, 1.10232392e-02f, 5.74103780e-02f, 1.48221090e-01f, 3.65443975e-02f,
  1.46327436e-01f, 8.96793008e-02f, 4.52232473e-02f, 1.19449914e-01f, 1.25786185e-01f, 1.89498588e-01f, 3.09882369e-02f, 1.40993282e-01f, 4.35755914e-03f, 1.93673238e-01f,
  1.21447019e-01f, 2.22353965e-01f, 1.39472753e-01f, -7.13918917e-03f, 9.04742330e-02f, -1.29269034e-01f, 5.89094684e-03f, -8.00823197e-02f, -1.01638533e-01f, 1.57851595e-02f,
  -5.89292310e-02f, -4.38911617e-02f, -3.62164155e-02f, 2.34848587e-03f, -2.86095664e-02f, 4.25205305e-02f, 7.35238567e-02f, 1.19930468e-01f, -3.29763107e-02f, -5.68551831e-02f,
  -6.14019064e-03f, 3.75051703e-03f, -1.63721591e-01f, 2.13097688e-03f, 1.03139803e-01f, 4.13586348e-02f, 4.96029258e-02f, 7.66023397e-02f, 2.74266917e-02f, -5.07788099e-02f,
  2.07035407e-01f, 7.05670267e-02f, 1.09539002e-01f, 1.17914572e-01f, 1.07542537e-01f, 1.21640131e-01f, 2.57989648e-03f, 3.72456796e-02f, 4.48724143e-02f, -5.63663282e-02f,
  1.76862869e-02f, -1.69204473e-02f, -1.15740918e-01f, -5.92127927e-02f, 2.85455603e-02f, -9.30868834e-02f, -1.73388600e-01f, 3.56166102e-02f, 7.62204379e-02f, -4.50708792e-02f,
  -1.23982672e-02f, -1.65455937e-02f, -4.58666012e-02f, -3.39265876e-02f, 6.22136611e-03f, -3.40126618e-03f, -3.66374999e-02f, -8.21143538e-02f, -9.18497071e-02f, 6.27287626e-02f,
  -2.29590639e-01f, 6.98072314e-02f, 7.89637044e-02f, -5.46010658e-02f, -2.40941104e-02f, -3.39078717e-03f, 3.22340913e-02f, -3.43673564e-02f, -9.41269770e-02f, -3.27175334e-02f,
  -6.70701787e-02f, 4.56712348e-03f, -4.04492542e-02f, 6.69621164e-03f, -8.12699273e-02f, -3.76292691e-02f, -3.64393294e-02f, -3.14264968e-02f, 2.00911313e-02f, -6.97812960e-02f,
  -6.96060508e-02f, -2.10052118e-01f, -2.03584462e-01f, -1.63035677e-03f, -3.81819950e-03f, 3.26801799e-02f, -3.87744829e-02f, -1.59913063e-01f, -1.57427877e-01f, -2.02870205e-01f,
  -1.79916546e-01f, 2.12628350e-01f, -1.56639874e-01f, -3.32009457e-02f, -6.68500140e-02f, -1.56004474e-01f, 1.68476924e-02f, 2.35032830e-02f, 1.59063056e-01f, 2.04501927e-01f,
  4.29389924e-02f, -1.60658464e-01f, -6.73568174e-02f, -8.28780532e-02f, -2.97130406e-01f, -9.69522521e-02f, -1.78852305e-01f, -2.76762605e-01f, -2.74386555e-01f, -2.43402705e-01f,
  2.68140193e-02f, -7.55538419e-02f, -1.60063922e-01f, 1.83641375e-03f, 4.85909283e-02f, 5.19749150e-02f, 1.25843510e-01f, -1.04014821e-01f, -1.04247659e-01f, 5.62010147e-02f,
  2.22739056e-02f, 8.87057409e-02f, -9.15752053e-02f, -2.08471358e-01f, 8.14051032e-02f, -6.18484765e-02f, -3.35639939e-02f, 3.52077372e-02f, -3.08277621e-03f, -1.18710585e-02f,
  -1.07213549e-01f, 6.82990626e-02f, -1.93304911e-01f, -9.25730690e-02f, -1.48236990e-01f, -2.38487907e-02f, -1.09621808e-02f, -2.88946498e-02f, -1.40898317e-01f, -8.53471607e-02f,
  -6.99132606e-02f, -1.79825932e-01f, -2.39068102e-02f, -1.60009712e-02f, -2.24882942e-02f, -1.19448915e-01f, -1.27540696e-02f, -9.54706073e-02f, -1.26800269e-01f, 2.35219806e-01f,
  3.60802598e-02f, -2.26217415e-02f, 3.59533392e-02f, 5.04542142e-02f, 2.84950696e-02f, -6.60904404e-03f, 3.10814679e-02f, 9.48342532e-02f, 1.72889829e-02f, 8.58098269e-03f,
  1.13468342e-01f, 1.77247897e-01f, 4.07655947e-02f, 8.56540278e-02f, 8.57929140e-02f, 7.00022131e-02f, 3.86249200e-02f, 6.72286972e-02f, 6.16076998e-02f, 6.73445240e-02f,
  1.44167570e-02f, 5.22726476e-02f, 1.30271185e-02f, -1.29857915e-03f, 5.35293408e-02f, 6.70975894e-02f, -4.73425798e-02f, 9.11618024e-02f, -1.00840569e-01f, -7.27993846e-02f,
  1.25201240e-01f, -1.80998623e-01f, 6.30891249e-02f, 3.42965536e-02f, -3.88784707e-02f, 4.54850420e-02f, 1.01134390e-01f, 4.57972549e-02f, 1.01360947e-01f, 1.20492369e-01f,
  -1.00594312e-01f, 1.32047698e-01f, -7.88937137e-02f, 4.13447656e-02f, -9.36686024e-02f, 1.57003794e-02f, -4.35539633e-02f, 3.05563435e-02f, -5.45699894e-02f, 6.38109958e-03f,
  -7.16178715e-02f, -2.12338679e-02f, -8.15920308e-02f, 8.75046998e-02f, -4.83923405e-03f, -1.08169630e-01f, 7.74567276e-02f, 3.89452092e-02f, -5.75336162e-05f, 3.43574673e-01f,
  -8.50520581e-02f, 6.79173693e-02f, 2.70133149e-02f, -7.55964592e-02f, 5.71054369e-02f, -2.10165352e-01f, -1.28021210e-01f, -1.47707969e-01f, -8.50046203e-02f, 2.56922282e-02f,
  -3.56094427e-02f, 8.86682235e-03f, 3.95305688e-03f, -5.30622303e-02f, -1.60063267e-01f, -2.94461697e-02f, -6.36327788e-02f, -1.83523387e-01f, -3.93922389e-01f, -1.43121049e-01f,
  -1.68200940e-01f, -1.48574665e-01f, -2.88640320e-01f, -1.22278109e-01f, 8.97260979e-02f, -5.16732112e-02f, 3.59673351e-02f, -5.87854683e-02f, -4.88251820e-02f, -7.39522725e-02f,
  6.16304018e-02f, -5.88095486e-02f, 1.79815257e-03f, -1.58758432e-01f, 1.66947305e-01f, -1.45597728e-02f, -5.55794239e-02f, -8.73126090e-03f, -4.83131036e-02f, -2.14072671e-02f,
  -1.04191922e-01f, -6.76093251e-02f, 3.65413949e-02f, 6.45825490e-02f, 1.43884541e-02f, -5.70740700e-02f, 1.00613952e-01f, -9.11045000e-02f, -5.81419095e-02f, 1.19687256e-03f,
  3.99130490e-03f, -1.43214716e-02f, -1.19581828e-02f, -3.41039598e-02f, 5.84424473e-02f, -3.06636021e-02f, -7.40576908e-02f, 4.23954278e-02f, -1.27075106e-01f, 8.64412487e-02f,
  -2.77478602e-02f, 1.17391460e-01f, 5.20601571e-02f, -3.24725509e-02f, -7.44343251e-02f, 3.95592041e-02f, 6.37187958e-02f, -7.36456290e-02f, -7.93582052e-02f, -3.21015120e-02f,
  2.27720477e-02f, -2.96503417e-02f, -3.70395817e-02f, -3.34864184e-02f, 2.75413021e-02f, -9.36443135e-02f, -1.61014453e-01f, -6.35708123e-02f, -6.73640296e-02f, -6.43844381e-02f,
  -6.26488253e-02f, -3.66296247e-02f, 3.05797793e-02f, 5.79426112e-03f, -9.66593176e-02f, -1.52036399e-01f, -1.53333014e-02f, -1.55644789e-01f, 6.18234910e-02f, -1.31901518e-01f,
  3.29641029e-02f, -2.01044649e-01f, -3.31475213e-02f, 1.00418534e-02f, 7.82805011e-02f, 5.90969622e-02f, 2.85040494e-02f, -4.33932804e-02f, -1.23689093e-01f, -1.26932383e-01f,
  -1.49239808e-01f, -1.85009483e-02f, 8.37396458e-02f, 1.53139951e-02f, -4.58180122e-02f, -1.22993417e-01f, 2.11346857e-02f, -1.82226915e-02f, 1.14685548e-02f, 1.49110228e-01f,
  1.23397768e-01f, -1.56300023e-01f, -1.28794387e-01f, -8.87244195e-02f, -6.05543852e-02f, -1.52725846e-01f, 5.87029792e-02f, -3.85687910e-02f, -6.49430305e-02f, -1.61773413e-02f,
  -5.20573813e-04f, -2.77600512e-02f, 4.08732966e-02f, 2.43957400e-01f, 2.40203217e-01f, 1.66200280e-01f, 2.45226070e-01f, 2.23405913e-01f, 2.04943165e-01f, 1.78282157e-01f,
  1.38725668e-01f, 2.34069809e-01f, 1.36553064e-01f, 7.54216388e-02f, 9.46917385e-02f, 1.20740511e-01f, 2.49512568e-02f, 3.30834799e-02f, 6.44079521e-02f, 1.11349024e-01f,
  2.10568964e-01f, 9.98246372e-02f, 3.17109413e-02f, 8.40047225e-02f, 6.26176968e-02f, 1.37466028e-01f, 1.15163773e-01f, 9.96587127e-02f, 2.10649967e-02f, 1.73322186e-02f,
  -3.09601985e-02f, 3.73201706e-02f, 2.52179466e-02f, -1.11767678e-02f, -1.60198748e-01f, -1.11058317e-01f, 5.30993156e-02f, -1.10251429e-02f, -1.25255838e-01f, -2.93263532e-02f,
  -8.42404589e-02f, -6.59176409e-02f, -3.73338629e-03f, -5.99027872e-02f, -2.08486477e-03f, -5.92302531e-02f, -1.00754939e-01f, -2.51961295e-02f, 7.05446601e-02f, -6.66017383e-02f,
  5.28094433e-02f, 8.30934644e-02f, 1.12671264e-01f, 6.50030673e-02f, -2.32432764e-02f, 8.96146372e-02f, -3.09529481e-03f, 9.14007351e-02f, 8.30245167e-02f, 4.26768661e-02f,
  2.39368394e-01f, 7.43057281e-02f, -5.16040251e-02f, -5.16903363e-02f, -4.20625806e-02f, -6.61975965e-02f, -6.17937520e-02f, -2.67955437e-02f, 3.94598916e-02f, -7.21648782e-02f,
  -4.57294546e-02f, 7.55436867e-02f, -3.05612516e-02f, 2.40502693e-02f, 1.10061672e-02f, -5.42621128e-02f, -1.10564679e-01f, -6.12593815e-02f, -6.76461607e-02f, -6.83258027e-02f,
  4.69284020e-02f, -3.90888266e-02f, -1.29289046e-01f, -1.45395458e-01f, -1.76825654e-03f, 1.19592786e-01f, 2.50104107e-02f, -4.91716713e-02f, 5.79310805e-02f, 1.51804956e-02f,
  -1.06412828e-01f, 1.09309532e-01f, -1.63665619e-02f, -6.61043301e-02f, -1.85406983e-01f, -9.36094671e-02f, -2.93079801e-02f, -3.31103951e-02f, -2.11995170e-01f, -6.19762428e-02f,
  -1.26743108e-01f, -1.23885602e-01f, -8.95229504e-02f, -1.04340389e-01f, -1.15074798e-01f, -1.30759224e-01f, -8.02872628e-02f, -1.32871252e-02f, -6.80475757e-02f, -6.45371974e-02f,
  -4.67256866e-02f, -6.17006607e-03f, 1.18458815e-01f, 5.24220690e-02f, 5.69380000e-02f, -1.63158157e-03f, -8.57542828e-02f, 9.03094374e-03f, -2.68724784e-02f, 2.52595579e-04f,
  2.83683240e-01f, -2.76876986e-01f, 1.62144691e-01f, 1.55727193e-01f, 1.14750952e-01f, 2.00215638e-01f, 1.14772901e-01f, 1.70616791e-01f, 9.18485597e-02f, 2.73926668e-02f,
  -1.13806184e-02f, -4.74831834e-02f, -1.63398057e-01f, -1.76918820e-01f, 6.62121326e-02f, -4.66170795e-02f, -7.48115554e-02f, 5.17594591e-02f, 2.09643841e-01f, 1.79815799e-01f,
  -5.77822179e-02f, -6.06839312e-03f, 1.86485067e-01f, 7.43338699e-03f, -1.36323705e-01f, -1.88362207e-02f, 1.08088953e-02f, 7.48384744e-02f, -4.20725942e-02f, -1.31619453e-01f,
  -1.38504103e-01f, 3.21319513e-02f, -3.70407291e-02f, -1.32896587e-01f, -1.24345332e-01f, -3.82158719e-02f, 2.47339010e-02f, -6.25058031e-03f, -8.07753950e-02f, -2.34146137e-02f,
  -4.12812680e-02f, 2.83488743e-02f, -1.15841357e-02f, 1.14233583e-01f, -1.65990889e-02f, 8.73898268e-02f, 6.77264994e-03f, 8.86237025e-02f, 7.45784072e-03f, -7.12638870e-02f,
  -4.82176319e-02f, 6.12744391e-02f, 2.71154884e-02f, -3.59839574e-02f, 3.73161340e-04f, 2.11198442e-02f, -5.25600240e-02f, -8.62556100e-02f, 7.39192069e-02f, -6.57101795e-02f,
  6.33607293e-03f, -5.89469038e-02f, -4.85581793e-02f, 4.43612039e-02f, 1.02553442e-01f, 7.14679584e-02f, 8.56664926e-02f, 1.07954443e-02f, 6.16393685e-02f, 6.89750016e-02f,
  1.60121508e-02f, -8.69123638e-03f, 1.56118423e-01f, 7.99092054e-02f, 3.40628736e-02f, -4.79890779e-02f, 1.14794888e-01f, 2.11716350e-02f, 4.01528366e-02f, 2.91878581e-02f,
  1.96180552e-01f, 8.65502283e-02f, 5.53346500e-02f, 8.85562822e-02f, -5.77226952e-02f, 3.80088799e-02f, 3.86743359e-02f, 6.48995712e-02f, -1.11857215e-02f, 6.16785809e-02f,
  -2.18610335e-02f, 7.20739141e-02f, -2.90824901e-02f, 1.03181517e-02f, 3.65583710e-02f, -2.56108865e-02f, -1.19063266e-01f, 4.13625239e-04f, -1.19858030e-02f, -1.20618999e-01f,
  3.39559391e-02f, 1.39499202e-01f, 3.18294913e-02f, 7.33204260e-02f, 2.17430219e-01f, -4.81847627e-03f, -1.43266633e-01f, 9.90030356e-03f, 1.43518429e-02f, -6.62732571e-02f,
  3.37960385e-02f, 1.00652896e-01f, 3.74452658e-02f, 1.12111136e-01f, -5.96940471e-03f, -9.53415502e-03f, -3.66885215e-02f, 8.05197358e-02f, 1.04782119e-01f, -1.82490908e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.26313969e-01f, 1.34278327e-01f, 1.07549645e-01f, 1.80650651e-01f, 1.80162698e-01f, 9.92181990e-03f, 6.35022596e-02f, 1.52045071e-01f, 1.29069909e-01f, -2.09888555e-02f,
  1.65847242e-01f, -3.45479883e-02f, 7.84796774e-02f, 2.37786204e-01f, 6.60592839e-02f, 9.18735191e-02f, 1.44289210e-01f, -1.35118902e-01f, 1.35118991e-01f, 6.52139410e-02f,
  2.59449959e-01f, 1.71728581e-01f, 1.12967014e-01f, 1.95453376e-01f, 2.33485639e-01f, 1.11759908e-01f, 2.82557067e-02f, 3.42497885e-01f, 7.02398419e-02f, 1.66747928e-01f,
  2.00398311e-01f, 2.54475474e-01f, 2.28415951e-01f, 2.54823297e-01f, 2.75722265e-01f, -1.38107315e-01f, 1.10732965e-01f, -1.18696771e-03f, 2.40877852e-01f, -5.62207215e-02f,
  1.30742967e-01f, 2.06654847e-01f, 7.95209929e-02f, 1.64471298e-01f, 7.21349567e-02f, 1.46269023e-01f, 2.64700174e-01f, 1.04143575e-01f, 2.20981613e-01f, 4.26683910e-02f,
  3.98925766e-02f, 2.15260894e-03f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  5.65015525e-02f, 5.06217591e-03f, 6.97259977e-02f, -6.99931383e-02f, -3.07212099e-02f, -5.92516437e-02f, -2.72769630e-02f, 5.42347357e-02f, -3.67450272e-03f, -2.11320873e-02f,
  -4.24366631e-02f, -9.47276596e-03f, -2.20030427e-01f, -8.55853409e-02f, 1.28599957e-01f, -1.38273835e-01f, 5.99069484e-02f, -9.43784118e-02f, 1.73287150e-02f, 2.02590190e-02f,
  -2.44994871e-02f, -3.57425697e-02f, -5.21560647e-02f, 7.37264380e-02f, 2.49334514e-01f, 3.37676778e-02f, -1.68078303e-01f, -1.30892824e-02f, 3.09027918e-02f, 2.29245231e-01f,
  -1.53938169e-02f, 5.72801009e-02f, -2.40411401e-01f, 2.08143145e-01f, 3.85996439e-02f, -1.46806225e-01f, -2.38032714e-01f, 1.32945985e-01f, 9.79302973e-02f, 8.90030190e-02f,
  8.33682269e-02f, -1.88532799e-01f, 1.58482209e-01f, -7.83245079e-03f, 1.56725794e-01f, 8.21776241e-02f, -1.06919043e-01f, 9.29448381e-02f, 2.62276739e-01f, 1.70803200e-02f,
  9.11976099e-02f, 8.20391104e-02f, -1.39603794e-01f, 1.72406435e-02f, -1.71301048e-02f, -3.66666281e-05f, -1.08273104e-01f, 1.00939497e-01f, -3.29537839e-02f, -2.02330686e-02f,
  4.34787422e-02f, -3.36984210e-02f, -1.63047820e-01f, -2.15321518e-02f, -9.22562033e-02f, -1.11263897e-02f, 8.11132416e-02f, -1.25203714e-01f, -8.32676217e-02f, 8.06074664e-02f,
  8.48525688e-02f, 2.14139253e-01f, 6.62093759e-02f, 7.60614201e-02f, -3.17291617e-02f, 5.84376268e-02f, 2.36308705e-02f, -2.45400473e-01f, 1.07431680e-01f, 4.88030128e-02f,
  1.42309204e-01f, 1.20206147e-01f, -1.46551192e-01f, -2.00670719e-01f, 9.53234062e-02f, 1.43939644e-01f, -1.81006521e-01f, -1.21861681e-01f, -2.32013330e-01f, -1.46359801e-02f,
  1.12701632e-01f, 2.31221303e-01f, -1.76146150e-01f, -2.12324280e-02f, 5.36334701e-02f, 1.15289867e-01f, 6.97461367e-02f, 1.23457752e-01f, 1.72140762e-01f, 4.49164817e-03f,
  2.21017599e-01f, 1.06332071e-01f, 1.11106997e-02f, -2.14541227e-01f, 1.09171413e-01f, -1.44580333e-02f, 6.39635720e-04f, -1.83800146e-01f, 4.77548614e-02f, -1.12817973e-01f,
  -1.81894928e-01f, 1.40037119e-01f, 8.53752345e-02f, 3.40598337e-02f, -2.21027449e-01f, -1.21137902e-01f, 9.86559391e-02f, -3.06016803e-01f, -8.98178294e-02f, -1.91426314e-02f,
  -4.84412350e-02f, -2.41843283e-01f, 1.98567156e-02f, -2.08734106e-02f, 8.75851139e-02f, 4.39383425e-02f, -5.44032939e-02f, -2.25799382e-02f, -8.77805725e-02f, -3.47285904e-02f,
  -2.39142030e-02f, 8.15786645e-02f, 9.14609432e-03f, -7.23115280e-02f, -1.42692879e-01f, -2.06644073e-01f, 1.07351594e-01f, -1.17749581e-02f, 1.06852844e-01f, -2.20593244e-01f,
  1.21350298e-04f, -1.20552957e-01f, -5.83218522e-02f, -4.79755662e-02f, -1.51588380e-01f, 2.04972446e-01f, -1.65071011e-01f, 2.48905253e-02f, 2.63667088e-02f, -2.42395960e-02f,
  2.83809721e-01f, -1.41566517e-02f, 5.68484794e-03f, 1.46688640e-01f, -7.88441077e-02f, 2.43871249e-02f, 1.75852776e-01f, -1.01049528e-01f, 1.85198307e-01f, 2.43730798e-01f,
  -7.17536211e-02f, 1.09118693e-01f, -1.47496507e-01f, -8.45308304e-02f, -4.25332896e-02f, -3.90722938e-02f, 1.48053795e-01f, 8.81162751e-03f, -2.58611500e-01f, 7.82110989e-02f,
  3.08408160e-02f, 2.51424849e-01f, -1.36173666e-01f, 4.74484637e-02f, 4.05240089e-01f, -1.99863508e-01f, -3.02042775e-02f, -6.89981356e-02f, -4.64993268e-02f, 1.00472480e-01f,
  -1.67103410e-02f, 1.40485242e-02f, -1.32440373e-01f, 9.83827487e-02f, 1.54176995e-01f, -7.44955987e-02f, 1.11164279e-01f, -6.12809265e-04f, -6.14606999e-02f, 9.45134684e-02f,
  7.15234354e-02f, -7.05161840e-02f, 8.06037989e-03f, 3.29995230e-02f, 2.19426472e-02f, 1.09349089e-02f, 4.44102809e-02f, -1.56441823e-01f, -1.90550797e-02f, 2.09019333e-02f,
  9.28070024e-02f, -9.38062817e-02f, -1.54047072e-01f, -1.63854733e-02f, -1.56525061e-01f, -1.20440414e-02f, -7.26910532e-02f, 5.43943271e-02f, 6.19407259e-02f, 1.12779602e-01f,
  1.30878776e-01f, -6.44020410e-03f, 1.70634985e-01f, 8.52116495e-02f, 1.03186406e-01f, -1.24319598e-01f, 1.97025090e-01f, 1.75632238e-02f, -9.76764634e-02f, 6.87971637e-02f,
  -1.31956294e-01f, 1.42685711e-01f, 9.89577174e-02f, -2.53714383e-01f, 4.04166766e-02f, 1.87617820e-02f, -2.37589683e-02f, 1.36819214e-01f, 2.82906555e-03f, 2.80713979e-02f,
  1.54903650e-01f, -2.35848036e-02f, -1.57175809e-01f, 1.11577868e-01f, 1.57940686e-02f, 7.22651929e-03f, 1.28943057e-05f, 1.06278606e-01f, 9.35777836e-03f, -1.17476076e-01f,
  9.01235268e-02f, -1.47456855e-01f, 8.95764902e-02f, 9.25186649e-02f, 7.13393763e-02f, 4.93956916e-02f, -8.18476826e-02f, 6.79267272e-02f, -1.46920174e-01f, -2.05941405e-02f,
  8.47253501e-02f, 4.38136086e-02f, 8.05054232e-02f, -2.24573463e-02f, -9.64580551e-02f, -8.78584906e-02f, -4.58264835e-02f, -3.92852118e-03f, 6.17845356e-02f, -3.41525003e-02f,
  4.19040583e-03f, -3.96030536e-03f, 4.29869294e-02f, 8.70349705e-02f, -1.87963713e-02f, 5.71417697e-02f, -1.16202533e-01f, 1.55919045e-01f, 1.06361516e-01f, -1.37244552e-01f,
  1.27546966e-01f, 1.40034370e-02f, -9.07919779e-02f, -9.53223370e-03f, 1.02496341e-01f, 5.90326712e-02f, 1.46359548e-01f, -1.84929594e-02f, 1.22549221e-01f, 2.84760837e-02f,
  -2.57050190e-02f, 4.37340476e-02f, 1.09065279e-01f, 1.21089056e-01f, -8.91051739e-02f, 7.83802867e-02f, -1.58931747e-01f, -2.45761216e-01f, -3.18713672e-02f, -1.12850986e-01f,
  1.94934428e-01f, 1.25202656e-01f, -3.69182266e-02f, 1.71817720e-01f, -2.05282047e-01f, 5.41695356e-02f, 1.17325753e-01f, -1.34803534e-01f, 1.77852996e-03f, -1.02176204e-01f,
  -1.01188682e-01f, 1.20937623e-01f, 7.75019303e-02f, 1.80140719e-01f, -6.36904836e-02f, 5.02614342e-02f, 2.27326646e-01f, -1.38458878e-01f, 1.43081039e-01f, 7.40936324e-02f,
  -9.25883651e-02f, -4.18973900e-03f, -1.94608092e-01f, 1.94969341e-01f, -1.31420316e-02f, -1.57449916e-01f, -2.11687639e-01f, -1.57188863e-01f, -7.43323565e-03f, -4.48830537e-02f,
  1.47254288e-01f, 1.41498270e-02f, 4.52778079e-02f, 8.37590620e-02f, 6.71960264e-02f, 3.71015705e-02f, -1.67689100e-01f, -4.68971618e-02f, -1.24551982e-01f, -2.35507071e-01f,
  2.49753147e-01f, -1.06168143e-01f, 5.32768890e-02f, 1.76857114e-01f, 1.74994200e-01f, 2.19869688e-02f, -2.88348552e-02f, -2.72017927e-03f, 1.60411909e-01f, 2.31205210e-01f,
  -7.29117766e-02f, -2.48774253e-02f, 2.38394916e-01f, 1.78743392e-01f, 3.25523585e-01f, -4.41270322e-02f, 9.98402853e-03f, -2.41627708e-01f, 1.97181404e-01f, 1.03901751e-01f,
  -2.13495120e-02f, 1.78762507e-02f, 1.79618597e-01f, -7.36396387e-02f, -9.59737971e-02f, 1.18817233e-01f, 1.97277684e-02f, -9.50881839e-02f, 4.87244651e-02f, 5.60662933e-02f,
  -1.86479151e-01f, 1.47545636e-02f, 6.78259060e-02f, -1.04475655e-02f, -8.16773698e-02f, 7.58985206e-02f, 8.83579478e-02f, -3.90215889e-02f, -3.19702476e-02f, -4.93451394e-02f,
  -1.54904395e-01f, 1.59303378e-02f, -1.84444323e-01f, 7.61519447e-02f, 1.84785753e-01f, -1.39698893e-01f, -9.01850834e-02f, 6.69847801e-02f, -1.29885241e-01f, -8.24510902e-02f,
  1.11520909e-01f, -3.46197747e-02f, -9.87379923e-02f, -9.01547298e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.40850291e-01f, 1.24780811e-01f, 6.75984100e-02f, 5.08879013e-02f, 7.87042156e-02f, 1.49590626e-01f, 1.65226698e-01f, 1.21678591e-01f, 2.26953775e-01f, 5.67649193e-02f,
  -2.09157854e-01f, 1.50026053e-01f, 8.70561972e-02f, -8.31120927e-03f, -1.43467143e-01f, -1.15419785e-02f, 4.41238135e-02f, 6.30003363e-02f, 2.08312422e-01f, 1.25850225e-02f,
  -1.21407256e-01f, -2.36692447e-02f, 5.86098284e-02f, -1.42312404e-02f, -9.73905325e-02f, -1.15637764e-01f, -9.26472023e-02f, -9.44884792e-02f, -5.37737124e-02f, -4.95488942e-02f,
  -1.33555576e-01f, -8.45606774e-02f, -6.82835355e-02f, -6.32363707e-02f, -1.98969379e-01f, -1.76993869e-02f, 1.15145147e-02f, 1.37398737e-02f, -2.38094181e-02f, 2.16657236e-01f,
  -2.27675259e-01f, -3.05131287e-03f, 6.18669903e-03f, -9.74897444e-02f, -1.22629568e-01f, -9.22038630e-02f, -6.03767671e-02f, 2.81427633e-02f, -1.03445522e-01f, 1.54127598e-01f,
  1.93505496e-01f, 9.25095677e-02f, 3.88333574e-02f, 1.85622886e-01f, 6.86276183e-02f, 3.66212696e-01f, 1.37728781e-01f, 1.24239773e-01f, -5.66497333e-02f, -1.51969671e-01f,
  1.10881096e-02f, -8.29927176e-02f, -5.08585088e-02f, 1.81060389e-01f, 6.02112301e-02f, 7.89608434e-02f, -1.63177811e-02f, 3.61858979e-02f, -1.87291522e-02f, -1.82346143e-02f,
  3.21391150e-02f, 2.85228044e-02f, -2.30022590e-03f, 6.28062524e-03f, 1.28544673e-01f, 1.72329798e-01f, 5.31041157e-03f, 2.11522114e-02f, 1.81743845e-01f, 1.46552265e-01f,
  8.58573914e-02f, -6.37671128e-02f, 7.52500445e-02f, -1.82117801e-02f, -8.11696053e-02f, 1.17014088e-01f, -1.36758639e-02f, 1.47768576e-02f, -1.56889055e-02f, 1.97000191e-01f,
  -6.07972741e-02f, -1.18607454e-01f, -4.92720976e-02f, -1.39946654e-01f, -1.51223570e-01f, -1.35495827e-01f, 1.25326455e-01f, 2.72236168e-02f, -8.69688764e-02f, 2.06075400e-01f,
  4.15133275e-02f, -2.19803341e-02f, 2.35131383e-02f, -1.33430883e-01f, 3.67470384e-02f, -6.77766055e-02f, -1.16579351e-03f, -1.79703116e-01f, 1.84122413e-01f, -8.67556185e-02f,
  -1.94868818e-01f, 3.16891968e-02f, 1.02733576e-03f, -1.37069032e-01f, 1.57504246e-01f, 1.31540880e-01f, -8.78931805e-02f, 2.88331360e-02f, 7.43081942e-02f, -2.84973979e-01f,
  -2.43014812e-01f, -2.13360280e-01f, -2.34181508e-01f, -1.27118006e-02f, -7.16665238e-02f, -5.34145012e-02f, 1.06807426e-02f, 2.32724845e-02f, 1.59951091e-01f, 1.96888462e-01f,
  2.82449014e-02f, 9.03165713e-02f, -1.82764849e-03f, 1.26786456e-01f, -6.20406792e-02f, -8.56039524e-02f, -2.13262871e-01f, 1.94908157e-02f, 1.08744793e-01f, -2.21143827e-01f,
  2.14003772e-02f, -1.15255006e-01f, -4.10004705e-02f, -9.65404809e-02f, -4.87180278e-02f, 6.20614588e-02f, -3.64184231e-02f, 3.59805243e-04f, -8.43654945e-02f, -2.02852543e-02f,
  -1.50082484e-01f, -1.22061875e-02f, -1.99322596e-01f, 1.64785862e-01f, -4.63661440e-02f, 7.77660012e-02f, 1.14379928e-01f, -1.03621334e-01f, 2.63506919e-01f, 1.55447841e-01f,
  -6.44119084e-02f, 8.11874419e-02f, -7.87206292e-02f, -1.14089385e-01f, 1.62178844e-01f, -6.26279861e-02f, 6.78749084e-02f, -7.95990676e-02f, -4.56504188e-02f, 1.73958734e-01f,
  8.64386484e-02f, 1.85312197e-01f, 1.05607517e-01f, -8.35695267e-02f, -1.93534911e-01f, -2.35432446e-01f, 5.46305999e-03f, -1.31982472e-02f, -1.86484039e-01f, -2.02694908e-02f,
  -5.21689206e-02f, 1.67461947e-01f, 6.41287193e-02f, 8.24938565e-02f, 3.40885401e-01f, -1.25710174e-01f, -1.30598724e-01f, 2.45094560e-02f, 8.43458176e-02f, 1.17555328e-01f,
  6.73016459e-02f, -2.18877252e-02f, -2.47017480e-02f, 1.41358618e-02f, 4.68645208e-02f, -6.78124353e-02f, -2.03080922e-02f, 1.15030393e-01f, 8.87513310e-02f, -2.96771340e-03f,
  8.69001523e-02f, 7.34482780e-02f, -2.18026210e-02f, -7.08345696e-02f, 7.77228326e-02f, 1.05367685e-02f, -1.61220223e-01f, 3.95478010e-02f, 3.10612321e-02f, 1.95606679e-01f,
  -4.76363376e-02f, -1.41721264e-01f, 7.44315237e-02f, -1.05892509e-01f, -1.66629016e-01f, -3.36084352e-03f, -1.57749146e-01f, -1.09962240e-01f, -2.28587948e-02f, 1.30049318e-01f,
  -1.72430158e-01f, -1.51773289e-01f, 1.67166758e-02f, 8.77393410e-02f, -7.89927468e-02f, -4.43450734e-02f, 6.67162538e-02f, 8.72896388e-02f, 7.81407952e-02f, 1.53691858e-01f,
  6.34477884e-02f, 2.62031890e-02f, -2.68497299e-02f, 9.10781920e-02f, -2.95307487e-02f, 4.99800034e-02f, 8.64767581e-02f, -2.55350173e-02f, 6.54526576e-02f, 5.98878227e-02f,
  7.27174105e-03f, -1.39396638e-01f, -7.86634088e-02f, 5.71601912e-02f, 2.05566555e-01f, -7.15076849e-02f, 8.14912654e-03f, 1.38181597e-01f, 4.10136394e-02f, 4.25222069e-02f,
  5.33257388e-02f, 7.91995898e-02f, 1.08963922e-01f, 1.35452542e-02f, -2.17723637e-03f, 4.25825343e-02f, 1.36397302e-01f, 1.21908814e-01f, 4.52363379e-02f, 1.21644273e-01f,
  5.48193045e-02f, 6.63500130e-02f, -1.32886693e-01f, -4.65843342e-02f, -1.13961704e-01f, 8.48831609e-02f, -1.02696218e-01f, -5.66008352e-02f, 4.74882610e-02f, 1.09587818e-01f,
  -1.69593208e-02f, -9.37585160e-02f, 9.12035331e-02f, 1.88712016e-01f, 8.71968046e-02f, 7.10346848e-02f, -1.07652254e-01f, 2.43189037e-02f, 1.83776300e-02f, -3.47570814e-02f,
  1.28808171e-01f, 6.45627230e-02f, -4.32126224e-03f, -1.47600815e-01f, -2.12188647e-03f, 3.73413786e-02f, 3.82117510e-01f, 1.36272699e-01f, -1.90509573e-01f, 2.95282453e-02f,
  -1.15033768e-01f, 4.29322533e-02f, 8.95359293e-02f, 7.58629739e-02f, 9.72579792e-02f, 4.55935523e-02f, -1.05563775e-02f, 1.28827125e-01f, 1.95517540e-01f, 7.51138255e-02f,
  -3.52099910e-02f, -1.20299961e-02f, -2.06110370e-03f, -1.66640222e-01f, 1.07528992e-01f, -6.78966343e-02f, -1.68345392e-01f, 2.43139297e-01f, -1.78602546e-01f, 1.06643975e-01f,
  6.83335587e-02f, -4.63637114e-02f, 1.39566168e-01f, 2.97272261e-02f, 4.96110544e-02f, 5.63090816e-02f, 2.17888191e-01f, 2.59764522e-01f, -4.77840006e-02f, -4.01908867e-02f,
  1.16784766e-01f, 2.01066434e-01f, 6.64113089e-02f, 1.20538510e-01f, -1.68783106e-02f, 1.10977881e-01f, 2.21014395e-01f, 1.15038060e-01f, -1.85467228e-01f, 3.44725735e-02f,
  6.97413906e-02f, -1.02600954e-01f, 1.34631336e-01f, -1.19223326e-01f, 2.39755824e-01f, 1.17708959e-01f, 6.79730028e-02f, -8.82739052e-02f, 1.38951465e-02f, -1.35058701e-01f,
  -7.05360919e-02f, -2.42365152e-01f, -1.79866239e-01f, -3.48518752e-02f, -2.03565255e-01f, 3.15136135e-01f, -2.28770971e-01f, 9.38234851e-02f, 1.88905418e-01f, 1.84305936e-01f,
  -1.46253243e-01f, 1.65972635e-01f, 9.27413404e-02f, 2.17235714e-01f, 2.05230832e-01f, 1.54815048e-01f, 1.59824993e-02f, 3.22981812e-02f, 1.13273874e-01f, -1.27465159e-01f,
  2.63041675e-01f, -3.32887098e-02f, 1.31828701e-02f, 1.98446605e-02f, -8.17285478e-03f, -6.28199652e-02f, -1.89912498e-01f, -1.23859957e-01f, 2.15131417e-01f, -5.73253371e-02f,
  1.79404289e-01f, 6.15848275e-03f, -5.17113972e-03f, -1.89820096e-01f, 4.55607139e-02f, 1.55582041e-01f, 9.67307165e-02f, 2.61141181e-01f, -3.18721309e-02f, 2.04411775e-01f,
  -6.60478976e-03f, 3.43183130e-02f, -2.38882706e-01f, -8.92681479e-02f, 6.75409660e-02f, -1.37771908e-02f, 2.80629210e-02f, 4.09374647e-02f, -5.88893332e-02f, 9.92097780e-02f,
  -5.55623993e-02f, -1.35265235e-02f, -2.04867214e-01f, 2.53112346e-01f, 9.96228382e-02f, 9.43697169e-02f, -7.59244943e-03f, -1.39244154e-01f, 2.32000679e-01f, -1.28828630e-01f,
  8.86870995e-02f, 1.62697673e-01f, -1.28858626e-01f, -2.04009160e-01f, -8.09225440e-02f, 1.55385554e-01f, -2.80050427e-01f, -7.87500218e-02f, -1.69180691e-01f, 1.33906096e-01f,
  1.06860615e-01f, -7.83345178e-02f, 1.44200148e-02f, 4.71446011e-03f, 1.35373682e-01f, 1.88196018e-01f, 4.59433757e-02f, 5.55777997e-02f, 3.25120799e-02f, 1.80471521e-02f,
  1.42311901e-01f, -7.23273531e-02f, 3.17342170e-02f, -8.13411698e-02f, 1.99675351e-01f, 1.14411570e-01f, 2.08972916e-01f, 8.10294524e-02f, 2.01012604e-02f, -5.92650548e-02f,
  -2.59533167e-01f, 3.11762486e-02f, 8.77966359e-02f, 1.21449329e-01f, -9.11347196e-02f, 9.80094001e-02f, 2.81618140e-03f, -1.10171191e-01f, 1.47915810e-01f, -4.69564945e-02f,
  2.20846638e-01f, -8.29799324e-02f, -1.21210814e-01f, 6.12025484e-02f, -6.67703710e-03f, 1.40351072e-01f, 2.15597466e-01f, -4.54085618e-02f, 5.96574582e-02f, 1.67260662e-01f,
  1.34270862e-01f, 1.43633232e-01f, 1.81654558e-01f, -3.07642501e-02f, 1.25101477e-01f, -1.09443627e-01f, 1.66485682e-01f, 4.73762713e-02f, -7.32896775e-02f, -1.09037176e-01f,
  1.69226095e-01f, 1.55718848e-01f, -2.85986453e-01f, -5.86273856e-02f, 6.51841089e-02f, 1.85276672e-01f, 3.02463531e-01f, -2.86535293e-01f, 9.50169042e-02f, -1.46734864e-02f,
  3.59423459e-02f, -1.07770473e-01f, -2.40469158e-01f, -2.62766808e-01f, -4.75941524e-02f, -3.74954268e-02f, -4.82783578e-02f, 1.76883042e-01f, 1.52185395e-01f, 1.34750992e-01f,
  4.51512448e-03f, -1.62762254e-01f, -3.27327371e-01f, 1.46090388e-01f, 7.99472481e-02f, -1.08828872e-01f, 1.21203236e-01f, 1.50454119e-01f, -2.24380031e-01f, 1.70149758e-01f,
  -2.74236202e-01f, 1.43124796e-02f, 2.18928546e-01f, -1.78733468e-01f, 4.25266653e-01f, -9.76250768e-02f, -1.89560637e-01f, -1.11095533e-01f, -5.95563576e-02f, -6.15661144e-02f,
  1.88468564e-02f, 3.19381692e-02f, -1.27681777e-01f, -7.39109796e-03f, 1.03175811e-01f, 1.14397325e-01f, 2.49972660e-02f, -6.35593310e-02f, 2.58582324e-01f, 1.20836712e-01f,
  6.46699965e-02f, 4.03432455e-03f, -9.13866982e-02f, 7.18799606e-02f, 1.30266203e-02f, 1.38193637e-01f, -6.65035695e-02f, -3.71659063e-02f, -7.44260550e-02f, 3.88150550e-02f,
  -1.37359694e-01f, 1.37114013e-03f, 1.58030614e-01f, -8.73247236e-02f, 2.37245858e-01f, -1.64613828e-01f, 1.99517354e-01f, -2.21022628e-02f, -2.55914815e-02f, -1.71910990e-02f,
  -1.17990340e-03f, -4.19539474e-02f, -3.92449275e-02f, -2.75790840e-01f, 2.35076584e-02f, -2.97536924e-02f, -5.12818098e-02f, 6.95651695e-02f, -3.09921987e-02f, -2.47782871e-01f,
  1.69927642e-01f, -2.75152475e-01f, -1.41623631e-01f, 2.13775262e-01f, 1.88500986e-01f, 1.09056458e-01f, -1.01914145e-01f, 1.62188992e-01f, 8.94255005e-03f, -2.52784550e-01f,
  -1.97582897e-02f, 6.99480996e-02f, -2.37382803e-04f, -3.43631580e-02f, 2.59246025e-03f, 1.12231851e-01f, -7.08935503e-03f, -8.29437152e-02f, 1.08328782e-01f, 1.60706356e-01f,
  -9.09378901e-02f, -7.77601497e-03f, -7.15340674e-02f, -1.13416009e-01f, -2.83112258e-01f, -1.04978353e-01f, 1.53679267e-01f, -9.51002985e-02f, 2.56203890e-01f, -3.67597044e-02f,
  -3.03371370e-01f, -4.08424065e-02f, -6.17399700e-02f, -8.81857499e-02f, -1.08261772e-01f, -9.38883722e-02f, 6.78008869e-02f, 1.57276317e-01f, 1.22794554e-01f, 1.67503119e-01f,
  -1.24194939e-02f, 2.16078222e-01f, 2.71714240e-01f, 2.12714057e-02f, -2.53734797e-01f, -1.67058870e-01f, 1.37581751e-01f, 9.01711285e-02f, -2.10471358e-02f, 9.19339955e-02f,
  -2.70509608e-02f, 4.32454310e-02f, -1.01473011e-01f, -2.10367516e-03f, -9.73257944e-02f, -2.15089731e-02f, 1.74938384e-02f, -1.92266226e-01f, -1.35785654e-01f, -1.03090130e-01f,
  -2.67574579e-01f, 2.66552359e-01f, 3.26032899e-02f, 5.95430918e-02f, 2.15942636e-01f, -1.70779720e-01f, 1.09581374e-01f, 2.22404510e-01f, 6.41908348e-02f, 8.50280281e-03f,
  2.22188476e-02f, 4.21884432e-02f, 1.59235194e-01f, -2.69062161e-01f, -7.06437230e-02f, -2.17567042e-01f, -4.67166677e-02f, 5.57439774e-02f, 1.70448363e-01f, 9.24079716e-02f,
  1.33226782e-01f, -2.30929062e-01f, -1.66918114e-01f, -2.28437811e-01f, 9.51126367e-02f, 7.28175119e-02f, 1.15459025e-01f, -1.04065552e-01f, -9.91276875e-02f, -4.59464602e-02f,
  2.77482808e-01f, -1.66748747e-01f, 1.20382771e-01f, 1.69828758e-01f, -1.10727318e-01f, 4.85520437e-02f, 4.12724465e-02f, 5.16596362e-02f, -9.38195661e-02f, 6.32413477e-02f,
  1.38277262e-01f, 4.59331013e-02f, 1.59710705e-01f, 6.54648915e-02f, 1.90393150e-01f, 3.94692607e-02f, 8.58446509e-02f, 1.50086418e-01f, 2.11636275e-01f, 1.83261380e-01f,
  -1.42275676e-01f, -4.13982160e-02f, 4.83007776e-03f, 3.24925371e-02f, -2.23570615e-01f, 1.50271490e-01f, 2.94850081e-01f, 3.70460115e-02f, 1.51739970e-01f, -1.82698071e-01f,
  1.92591637e-01f, 2.05764528e-02f, -1.54051080e-01f, -1.18375733e-01f, -2.20634192e-01f, -7.78505728e-02f, 8.49349424e-02f, -3.06439456e-02f, -2.44851574e-01f, -5.08720279e-02f,
  1.70810878e-01f, -9.00676399e-02f, -1.54195428e-01f, -2.13346869e-01f, 9.73653700e-03f, 1.65884830e-02f, 3.03963423e-01f, 1.63614899e-01f, 7.24748671e-02f, 9.90342349e-02f,
  2.09376752e-01f, 1.06911302e-01f, -1.73201948e-01f, -6.82629570e-02f, 1.92672163e-01f, -2.25955814e-01f, 1.59110446e-02f, -1.23858377e-02f, -6.32080063e-02f, -1.00513026e-01f,
  -2.11841434e-01f, -1.87922269e-01f, 1.17470428e-01f, -1.23598002e-01f, -5.60933687e-02f, 9.29030532e-04f, 8.48996416e-02f, 5.83354384e-02f, 6.93952665e-02f, 4.29565720e-02f,
  2.85114907e-02f, -8.95041451e-02f, 3.46524157e-02f, 1.24843091e-01f, 6.49527460e-02f, 1.03505827e-01f, 1.29915416e-01f, -3.06369290e-02f, 2.13134028e-02f, 7.20103830e-02f,
  -1.65520489e-01f, 5.97682074e-02f, 6.88986480e-02f, -1.32061094e-01f, -3.09957378e-02f, -9.77691486e-02f, -1.12621069e-01f, 5.71978465e-02f, 2.99206432e-02f, 1.86884061e-01f,
  2.53179669e-02f, 2.45928261e-02f, -1.35930806e-01f, -5.15087992e-02f, 9.92176756e-02f, 2.09852308e-01f, 4.00364287e-02f, 6.71315119e-02f, 1.49097741e-01f, -9.88736153e-02f,
  1.58682570e-01f, 1.97160631e-01f, -1.25998959e-01f, -1.81053765e-02f, 2.62140036e-01f, -5.37869371e-02f, -1.35961678e-02f, 7.49943405e-02f, 1.06567152e-01f, -5.99785894e-02f,
  7.95749202e-02f, 1.83904052e-01f, 1.43282980e-01f, 1.01129614e-01f, 2.02772558e-01f, 6.78832754e-02f, -3.78108840e-03f, 7.03610107e-03f, 1.57170102e-01f, 1.02768302e-01f,
  -9.05717462e-02f, 3.89161929e-02f, 1.45626247e-01f, -1.87288714e-03f, -9.33480076e-03f, 2.17540592e-01f, 1.03966609e-01f, 2.77341669e-03f, -3.86829935e-02f, -1.85032133e-02f,
  -2.09033698e-01f, -1.92076370e-01f, 2.22614229e-01f, 2.48633191e-01f, -4.17389572e-02f, 7.42398351e-02f, 1.94914669e-01f, -1.25787511e-01f, 1.72068626e-01f, 8.14600438e-02f,
  7.41669014e-02f, 9.22173038e-02f, 1.73127756e-01f, 1.82485148e-01f, 1.23112924e-01f, -9.65634268e-03f, -1.51967391e-01f, -1.42954320e-01f, -8.05493668e-02f, -2.99333315e-02f,
  -1.50013804e-01f, 1.60023719e-01f, 6.43446520e-02f, -2.11645067e-01f, 1.47077844e-01f, -1.67857762e-02f, 1.56514451e-01f, -1.88087568e-01f, -2.50360295e-02f, -1.45040423e-01f,
  -6.29065037e-02f, -1.34568021e-01f, -7.96771497e-02f, 1.96534798e-01f, -2.43712310e-02f, 2.70063356e-02f, -2.26706639e-02f, 3.40310633e-01f, -4.86442521e-02f, -1.28626060e-02f,
  1.58125740e-02f, 1.36965394e-01f, 8.01014677e-02f, -5.69178946e-02f, -1.96505919e-01f, 2.12191537e-01f, 2.62577504e-01f, -3.95086035e-03f, -1.03361212e-01f, -1.06599303e-02f,
  -5.95576055e-02f, 1.93504050e-01f, -1.29415318e-01f, 5.24236672e-02f, 2.23087236e-01f, -1.81436032e-01f, 2.59068012e-01f, -1.49373233e-01f, 4.80083236e-03f, 3.98548320e-03f,
  -6.74468502e-02f, -2.42732808e-01f, 4.93178926e-02f, 8.16505328e-02f, 5.23069650e-02f, 9.77745950e-02f, 1.67924210e-01f, -2.99392901e-02f, 1.03157200e-01f, 1.34972662e-01f,
  -7.06778988e-02f, -1.23269051e-01f, -4.45184950e-03f, 1.42518096e-02f, -2.46787667e-02f, 1.88090373e-02f, 1.12245217e-01f, -1.68557689e-02f, -8.99945050e-02f, -5.79807833e-02f,
  -3.79616916e-02f, 1.43144265e-01f, 2.46581286e-02f, -6.46510050e-02f, 3.84360924e-02f, -7.50294551e-02f, -3.85008715e-02f, 3.75264161e-03f, 1.00640275e-01f, 1.57597795e-01f,
  -4.79651354e-02f, -2.31263295e-01f, -1.59153789e-02f, -1.68090969e-01f, -1.20533310e-01f, -3.62780392e-02f, -4.16205861e-02f, 9.29214656e-02f, 4.39347439e-02f, -6.43069893e-02f,
  -2.02936260e-03f, -1.57247365e-01f, 1.66559666e-01f, 1.89679617e-04f, -1.14835158e-01f, 1.17763437e-01f, 4.88577932e-02f, 2.14356817e-02f, 8.49534869e-02f, 7.08089173e-02f,
  4.93924730e-02f, -2.85931323e-02f, 5.23052458e-03f, 1.43125415e-01f, 2.08519027e-01f, 1.05984516e-01f, -7.92039856e-02f, -5.76087832e-02f, -8.21756199e-03f, 2.48792898e-02f,
  1.31290719e-01f, -1.07565887e-01f, -6.96204975e-02f, 2.10701972e-02f, -7.08794817e-02f, 1.96162574e-02f, 9.47605744e-02f, 1.99827150e-01f, 2.55453959e-02f, -1.22984968e-01f,
  3.34672928e-02f, -9.48259011e-02f, 1.57480702e-01f, 3.77639085e-02f, -7.64841214e-03f, 8.41780901e-02f, 2.36952454e-01f, 1.38630852e-01f, 6.83270255e-03f, 1.72287807e-01f,
  1.62310377e-01f, 7.62256533e-02f, 2.46637091e-01f, 1.83345065e-01f, -9.27453786e-02f, -1.23054840e-01f, -7.87460618e-03f, 1.97875679e-01f, 1.26039639e-01f, 4.53813188e-02f,
  1.03497259e-01f, 2.86829397e-02f, -2.57718135e-02f, 1.39739409e-01f, -8.67103115e-02f, -9.18147787e-02f, -4.60524037e-02f, -2.42364720e-01f, -1.11084558e-01f, -2.37018093e-02f,
  -2.02872545e-01f, 3.00368816e-01f, 6.54476956e-02f, 1.44893214e-01f, 1.29874736e-01f, -2.22101629e-01f, 3.03442571e-02f, -1.20756797e-01f, 2.10659415e-01f, 4.45154794e-02f,
  3.22996266e-02f, 2.45235160e-01f, 1.12546176e-01f, -1.17169201e-01f, -1.36825755e-01f, -1.79771274e-01f, 7.62536898e-02f, 1.38103008e-01f, 3.74628492e-02f, -3.82786654e-02f,
  2.97834575e-01f, 2.37201806e-03f, -1.73379868e-01f, -1.56533152e-01f, 2.54631378e-02f, -2.24902816e-02f, 1.18237160e-01f, 8.86198953e-02f, 7.43193328e-02f, 2.42287349e-02f,
  1.53639525e-01f, -3.29575427e-02f, -3.13053936e-01f, 7.63732940e-03f, 2.47419695e-03f, 1.60219848e-01f, 5.69766723e-02f, 1.75795685e-02f, -2.08535910e-01f, -1.37488218e-02f,
  2.59869695e-01f, 8.98847356e-02f, 2.29952425e-01f, 1.19187474e-01f, 2.27132201e-01f, 1.75613880e-01f, 2.06279326e-02f, -1.10003918e-01f, -1.42978624e-01f, -3.43519934e-02f,
  1.46232650e-01f, -1.07717384e-02f, -7.53886532e-03f, 1.68957025e-01f, 2.17148438e-02f, 3.09814028e-02f, -4.10409048e-02f, -5.66006340e-02f, 8.83498490e-02f, 1.26456663e-01f,
  -2.92115156e-02f, -3.45919400e-01f, 2.60967702e-01f, 6.02993704e-02f, 2.95550376e-01f, 1.79307431e-01f, -5.50734717e-03f, 3.05043012e-02f, 2.33609840e-01f, -7.49057010e-02f,
  1.01650119e-01f, 3.05429250e-02f, 1.66249514e-01f, 1.21445827e-01f, 4.54812087e-02f, -1.97617281e-02f, -1.74848065e-01f, -4.46803793e-02f, -1.17031254e-01f, 1.05195075e-01f,
  -1.25701040e-01f, 1.06563326e-02f, 1.27288610e-01f, 1.02630883e-01f, -6.93152053e-03f, 4.46392506e-01f, 8.37581754e-02f, 6.03721812e-02f, 1.02244422e-01f, -1.74612198e-02f,
  1.80115961e-02f, 1.04490593e-01f, -5.79317585e-02f, 1.39934823e-01f, 1.13373816e-01f, -6.85233250e-02f, -5.15187439e-03f, 8.39705765e-02f, 4.10230784e-03f, 7.14002326e-02f,
  2.24679317e-02f, 1.27601981e-01f, -1.33787185e-01f, 1.16240725e-01f, 1.99620456e-01f, 1.25489756e-01f, 1.81069821e-01f, 3.67515385e-02f, 6.91442415e-02f, -7.14443699e-02f,
  -9.50247608e-03f, -8.78623798e-02f, -6.44647405e-02f, -2.41786763e-01f, -1.19558927e-02f, -1.58628561e-02f, -5.59550710e-02f, 4.23584580e-02f, 3.57327871e-02f, 1.30044147e-01f,
  -3.66418660e-02f, -5.37517965e-02f, -1.55591574e-02f, 2.20222510e-02f, -1.12225935e-01f, 1.62052631e-01f, 6.04864620e-02f, 8.72093290e-02f, 2.04743564e-01f, 6.42772987e-02f,
  1.73191670e-02f, 1.14335259e-02f, -3.46025229e-02f, 5.39210476e-02f, -3.96583974e-01f, -4.56827283e-02f, 1.08733617e-01f, 3.64471949e-03f, 1.10316299e-01f, 7.00490698e-02f,
  1.89867485e-02f, -8.97836965e-03f, -1.48069665e-01f, 2.27470338e-01f, -9.66343563e-03f, -4.93636839e-02f, -3.70291695e-02f, 1.58560723e-01f, -1.46195799e-01f, 2.51860768e-01f,
  1.56680584e-01f, 1.41794577e-01f, 8.57635587e-02f, -5.99857271e-02f, -1.04481876e-02f, -6.25738502e-02f, -7.07555041e-02f, 1.31555721e-01f, -4.50247200e-03f, -2.99859121e-02f,
  -7.68901631e-02f, -1.86054528e-01f, -1.65519747e-03f, 1.29382074e-01f, -3.24023142e-02f, -2.50003412e-02f, 1.79120284e-02f, -7.32247606e-02f, 5.91564588e-02f, 1.81076705e-01f,
  1.61643177e-01f, 1.29738986e-01f, 1.99283838e-01f, 1.97383732e-01f, -2.89003402e-02f, -6.42711893e-02f, -9.67357978e-02f, -2.11778998e-01f, 2.15595253e-02f, -2.62550600e-02f,
  8.03901479e-02f, -9.81853679e-02f, -7.19563589e-02f, 1.71270911e-02f, -1.00511029e-01f, 9.46616381e-02f, -4.63107675e-02f, 8.78463909e-02f, 5.29021062e-02f, -2.30743196e-02f,
  1.74509957e-01f, 9.90547687e-02f, 5.89043126e-02f, 1.52182400e-01f, -8.29101261e-03f, 1.89951643e-01f, 7.57331774e-02f, -1.53647214e-01f, 1.60866082e-02f, -3.54230497e-03f,
  2.49253303e-01f, 1.19273305e-01f, 1.51944190e-01f, 1.81032509e-01f, 5.22825643e-02f, -8.43210444e-02f, 1.50617817e-03f, 6.57236353e-02f, -1.06066745e-02f, 5.47156706e-02f,
  8.26191008e-02f, 2.50303924e-01f, -1.40533596e-02f, 2.12623179e-01f, 2.03464270e-01f, -1.19456761e-01f, 1.02564290e-01f, -5.31053506e-02f, 1.40544683e-01f, 1.10021070e-01f,
  -7.39726704e-03f, 1.51423618e-01f, 3.19270976e-02f, -2.62884162e-02f, -1.36777520e-01f, -2.16503814e-03f, 4.94226143e-02f, 1.41349927e-01f, 4.49481085e-02f, 2.94506494e-02f,
  -5.05564176e-02f, 1.25754878e-01f, 3.17037739e-02f, 6.05808422e-02f, 9.87168849e-02f, 1.54962286e-01f, 8.78914893e-02f, 1.96559727e-01f, -6.67770207e-02f, 1.12725236e-01f,
  -4.83111888e-02f, -2.08761897e-02f, -9.23108757e-02f, 6.79408908e-02f, -1.85016766e-01f, -5.80679588e-02f, -2.36416712e-01f, -2.97237206e-02f, 2.03862637e-02f, 1.44195020e-01f,
  2.93727256e-02f, 5.06726839e-02f, 2.55261481e-01f, 1.87227994e-01f, 1.52471960e-01f, -9.01455730e-02f, 4.64040190e-02f, 1.30437240e-01f, -7.03746155e-02f, 2.34460726e-01f,
  3.96924168e-02f, -4.98745516e-02f, 2.74408963e-02f, -1.62306316e-02f, 1.01461589e-01f, 2.42571577e-01f, 2.66580462e-01f, -1.33116901e-01f, -6.84347898e-02f, 2.47838557e-01f,
  7.92151466e-02f, -7.76741207e-02f, 2.00390130e-01f, -1.09536298e-01f, 8.17756355e-02f, 2.79795796e-01f, -4.49229181e-02f, 2.31693938e-01f, 1.21962965e-01f, -7.78264254e-02f,
  1.27563894e-01f, -1.87487174e-02f, -8.50244761e-02f, 8.75638798e-03f, 2.88185179e-01f, -1.19139068e-01f, -9.30107310e-02f, 1.45770714e-01f, -2.09239513e-01f, -8.17687511e-02f,
  3.23252469e-01f, 1.15707899e-02f, -1.23333655e-01f, -8.56713951e-02f, 1.15140319e-01f, 2.17436031e-01f, 2.54806250e-01f, 2.03484640e-01f, 9.25963521e-02f, 1.21439293e-01f,
  -3.83855067e-02f, 5.94997145e-02f, 3.16069454e-01f, 1.64959759e-01f, 1.69231281e-01f, 1.26038656e-01f, -8.90641883e-02f, 1.80647671e-01f, 1.66444242e-01f, -1.67791337e-01f,
  -1.39198989e-01f, 6.83349147e-02f, -1.46326199e-01f, -9.40168351e-02f, 1.06438667e-01f, -1.22661658e-01f, 7.06507415e-02f, -6.39850181e-03f, -1.49568364e-01f, -1.06930643e-01f,
  -2.41200730e-01f, 1.40616044e-01f, -5.13651744e-02f, -1.19430467e-01f, -3.33397835e-03f, -6.24063201e-02f, -8.66062418e-02f, 5.85216377e-03f, 1.78971231e-01f, -6.40970916e-02f,
  -2.81239748e-01f, 1.12791926e-01f, -1.13922134e-02f, -2.26390958e-01f, -2.12659404e-01f, 1.36973873e-01f, -3.50159943e-01f, 1.51411012e-01f, -1.56089321e-01f, 5.92079014e-02f,
  1.56723633e-01f, -2.21966013e-01f, -1.65578008e-01f, -1.42962590e-01f, -2.61711061e-01f, 3.41693312e-03f, 3.48481625e-01f, -1.32950366e-01f, 6.12423755e-02f, 2.83202916e-01f,
  -1.31501824e-01f, 4.64577615e-01f, 2.23757233e-02f, 2.10511357e-01f, 1.46943470e-03f, -1.04464740e-02f, -9.88941118e-02f, -2.22751245e-01f, 4.24903631e-02f, 1.33555397e-01f,
  -1.42659461e-02f, -8.02191347e-03f, 3.91830616e-02f, 6.02460429e-02f, 9.63681638e-02f, 3.46106440e-02f, -2.95424759e-01f, -1.84379414e-01f, -1.24069817e-01f, -6.30632788e-02f,
  6.46151751e-02f, -2.94219106e-01f, 2.80249491e-02f, 7.12241754e-02f, -1.21830441e-01f, -1.21243723e-01f, -1.36157364e-01f, -5.04541770e-02f, 2.49376837e-02f, 1.70354560e-01f,
  -4.33877856e-02f, 6.08495483e-03f, 2.73118466e-01f, -7.07618669e-02f, 2.37796307e-02f, 5.79345040e-02f, 1.97925270e-01f, 2.77743787e-02f, 1.55543923e-01f, 3.18493471e-02f,
  1.26549259e-01f, 1.69106290e-01f, -1.80311222e-02f, -8.70201364e-02f, -1.04102895e-01f, -8.36728513e-02f, 1.50364384e-01f, -1.07478976e-01f, 1.85907468e-01f, 5.14344908e-02f,
  4.71889153e-02f, 1.66921504e-02f, 1.39821172e-01f, 9.91056487e-02f, -8.36338401e-02f, -1.50009587e-01f, 1.04413353e-01f, 1.95796937e-01f, -1.02462687e-01f, -1.32426247e-01f,
  -2.56475717e-01f, -1.82333905e-02f, -2.11456552e-01f, 3.35936546e-02f, 1.34163126e-01f, -1.74527615e-01f, 2.44384363e-01f, 1.17365308e-01f, -6.44524843e-02f, 5.42117320e-02f,
  1.61347568e-01f, 2.13419825e-01f, 1.13862753e-01f, -8.42287540e-02f, -1.16942702e-02f, 1.18545871e-02f, 9.46031585e-02f, 2.79872697e-02f, 9.92753506e-02f, 1.00944869e-01f,
  -2.03477547e-01f, -1.37413234e-01f, 5.90320900e-02f, 1.66750252e-01f, 7.78795108e-02f, -1.71164393e-01f, 1.34506807e-01f, -1.21442959e-01f, -1.80278018e-01f, -9.00767818e-02f,
  9.17011499e-02f, 1.73803329e-01f, -1.39123350e-01f, 2.35167872e-02f, 5.83601035e-02f, -2.91941990e-03f, -3.29498313e-02f, 1.46498635e-01f, -1.81562692e-01f, -9.19520259e-02f,
  -1.13645464e-01f, 3.40994559e-02f, 1.70755297e-01f, -2.33101219e-01f, 3.97068650e-01f, 3.03075224e-01f, 6.80962279e-02f, 2.00789779e-01f, -4.75503951e-02f, 5.43643720e-02f,
  2.74005741e-01f, -7.83652067e-02f, 8.61347541e-02f, 1.48816183e-01f, 1.39936045e-01f, 2.96699822e-01f, 2.91471422e-01f, 1.38589501e-01f, 1.24846131e-01f, -1.48977727e-01f,
  6.40385970e-02f, 8.58420581e-02f, -1.10140078e-01f, 6.06151260e-02f, -1.70077831e-01f, -2.70828395e-03f, -7.49554262e-02f, 1.03269015e-02f, 5.81655204e-02f, -9.97332484e-03f,
  2.54688770e-01f, -1.03704758e-01f, -1.50465235e-01f, 1.20646134e-01f, 3.20420653e-01f, 1.13575377e-01f, -3.15350331e-02f, -7.80283660e-02f, 1.55884802e-01f, 1.44289657e-01f,
  1.78765833e-01f, 2.40629196e-01f, 2.14348957e-01f, 2.46598259e-01f, 1.78392246e-01f, -1.98514499e-02f, 5.30055426e-02f, -3.72967832e-02f, 7.67288283e-02f, -8.92674327e-02f,
  -5.40377423e-02f, 2.10584074e-01f, -2.17946514e-01f, -1.92038596e-01f, 4.71069515e-02f, -3.67225632e-02f, 2.29240298e-01f, -2.04101965e-01f, -1.04028665e-01f, -4.80323434e-02f,
  -8.05103779e-02f, -1.32166728e-01f, -1.46517500e-01f, 1.49119213e-01f, -5.91148771e-02f, 5.15139736e-02f, 6.95500523e-02f, 1.52413948e-02f, -6.85714856e-02f, 1.93209246e-01f,
  2.05963939e-01f, 1.69097949e-02f, -2.40104273e-01f, 7.16794003e-03f, 5.83130345e-02f, -1.31288931e-01f, 1.85056198e-02f, 1.03154168e-01f, -1.51202112e-01f, 2.44070590e-01f,
  -3.18158977e-02f, 2.10092634e-01f, 2.08106148e-03f, -1.71923980e-01f, 1.98118627e-01f, -1.47961870e-01f, -1.33590236e-01f, 1.05375789e-01f, -6.32486166e-03f, -7.27659985e-02f,
  5.65913389e-04f, 3.14159095e-02f, 6.73339367e-02f, 1.08755827e-01f, 2.37206575e-02f, 2.61360675e-01f, 1.37931388e-02f, 9.85748693e-02f, 2.56906539e-01f, 9.71043631e-02f,
  3.86664495e-02f, 9.50994343e-02f, 1.16581671e-01f, 6.92796633e-02f, 1.18544750e-01f, -4.63308580e-03f, 1.60479337e-01f, 5.69195151e-02f, -1.83704063e-01f, 5.98536916e-02f,
  5.88883907e-02f, 3.31907496e-02f, -8.70255157e-02f, -2.43359044e-01f, 1.43135011e-01f, 3.17611605e-01f, -1.93924353e-01f, -7.61879757e-02f, 1.58198997e-01f, 1.87412780e-02f,
  1.29244134e-01f, 1.85099214e-01f, 7.64784813e-02f, -1.39457034e-02f, 2.75293946e-01f, -3.39471512e-02f, 2.08830655e-01f, -7.11343065e-02f, 1.36224195e-01f, -3.37290391e-02f,
  1.28361478e-01f, 1.55326664e-01f, 4.92201149e-02f, 2.20663995e-01f, 6.09229133e-02f, -5.79676852e-02f, 4.68033776e-02f, -8.28988701e-02f, 4.33523394e-02f, 1.07954837e-01f,
  1.65556446e-01f, 2.62568265e-01f, 1.01168536e-01f, -1.35415364e-02f, 8.60142708e-02f, 1.32603228e-01f, -1.08827136e-01f, 6.87542707e-02f, 1.72597140e-01f, 1.16787434e-01f,
  -5.50918356e-02f, -8.71800780e-02f, -3.18579018e-01f, 4.94331829e-02f, 8.01006258e-02f, -2.93688662e-02f, 6.27654269e-02f, -1.80671662e-01f, 2.07366630e-01f, 1.52216777e-01f,
  7.31894076e-02f, 1.14418015e-01f, 1.26292840e-01f, -1.49929244e-02f, 2.65131891e-01f, -2.92520136e-01f, 4.19464968e-02f, 1.12604029e-01f, 8.08273330e-02f, 5.99419549e-02f,
  1.07263714e-01f, -3.50503018e-03f, 5.91890402e-02f, -1.89048529e-03f, -3.89969721e-02f, -7.74228526e-03f, -2.52689809e-01f, 7.23928621e-04f, -7.36514032e-02f, -9.94925871e-02f,
  -6.58817366e-02f, 4.48234119e-02f, 2.82066375e-01f, 1.26323432e-01f, 3.26590203e-02f, -4.87321429e-02f, 8.21130350e-02f, 1.75717264e-01f, -6.44264044e-03f, 5.92543446e-02f,
  -6.30768165e-02f, 1.04072772e-01f, -8.76537934e-02f, 1.61097765e-01f, 8.80416408e-02f, -1.66467264e-01f, 3.51204015e-02f, 6.07572608e-02f, 1.55057132e-01f, 2.20972016e-01f,
  2.75146633e-01f, -2.02773008e-02f, -4.14362177e-03f, 2.43552461e-01f, 9.70943123e-02f, 3.25427167e-02f, 1.95001125e-01f, 6.64553419e-02f, -1.12632789e-01f, 1.88115969e-01f,
  -1.81771755e-01f, -8.80402550e-02f, 1.24734856e-01f, -6.73693866e-02f, 8.06343183e-02f, -1.19962292e-02f, -1.13781944e-01f, 9.87025816e-03f, 3.11831206e-01f, -1.52686730e-01f,
  -9.97014865e-02f, 2.34974653e-01f, 5.60271293e-02f, -2.90988274e-02f, 3.04624915e-01f, 2.30217725e-02f, -1.27436399e-01f, -3.15749608e-02f, 1.55144110e-01f, 5.54962792e-02f,
  1.37938514e-01f, 5.39482459e-02f, 1.17301546e-01f, 5.16137965e-02f, 6.19537905e-02f, 2.20908616e-02f, -1.35819644e-01f, -1.02644056e-01f, -1.24804579e-01f, -1.44203782e-01f,
  5.66217005e-02f, 2.84358617e-02f, 7.36065151e-04f, -6.86232969e-02f, -4.28466871e-02f, -1.18535003e-02f, -4.94509190e-02f, 6.01609945e-02f, -1.55074984e-01f, 7.23586455e-02f,
  7.79864416e-02f, 1.90588564e-01f, -1.08011570e-02f, -3.72007713e-02f, -2.37293001e-02f, 2.42554590e-01f, -1.83029249e-01f, 1.77370638e-01f, 1.69435874e-01f, -1.29352570e-01f,
  2.40690261e-02f, 1.08186118e-01f, 2.19122227e-02f, 1.45106882e-01f, 2.72232801e-01f, -1.19773589e-01f, -2.07054973e-01f, 9.05720110e-04f, 3.33338194e-02f, -4.68567982e-02f,
  5.99305220e-02f, -3.88620570e-02f, 1.75001338e-01f, 2.84651756e-01f, -1.37739345e-01f, 6.54745102e-02f, -1.74365640e-02f, -1.49317741e-01f, 1.81735456e-01f, 6.52027801e-02f,
  2.79534073e-03f, 8.90316516e-02f, 1.43424809e-01f, -1.15016416e-01f, 7.94070587e-02f, 5.20307943e-02f, 1.10580139e-01f, -1.10497773e-01f, 1.62639588e-01f, 1.00926436e-01f,
  2.61352193e-02f, 2.22041868e-02f, -4.22092527e-02f, 6.32259026e-02f, 1.01070046e-01f, -4.06992063e-03f, 7.20500648e-02f, 6.32736133e-04f, 1.01369005e-02f, 4.39376086e-02f,
  8.00068825e-02f, -1.41438178e-03f, -2.66951602e-03f, -8.26086700e-02f, 1.04642257e-01f, 2.57751457e-02f, 1.08607367e-01f, -3.86380590e-02f, 7.69121423e-02f, -1.10647760e-01f,
  -4.43759793e-03f, -6.44337460e-02f, 3.94821540e-02f, -4.97203730e-02f, -3.52629982e-02f, 1.73388049e-01f, 2.39415243e-02f, -1.31766900e-01f, -1.34513125e-01f, 8.82830024e-02f,
  1.75597504e-01f, 5.54149821e-02f, 9.58694071e-02f, -1.18624061e-01f, -4.58735740e-03f, 1.33511305e-01f, 6.68811351e-02f, 9.01711658e-02f, -1.00870952e-01f, 1.83891550e-01f,
  1.04942612e-01f, -1.16819121e-01f, -1.49121480e-02f, 6.06685169e-02f, 7.03162625e-02f, 1.33834794e-01f, -6.22569211e-02f, 3.64130065e-02f, 1.03933565e-01f, -2.08837986e-01f,
  1.06977090e-01f, 2.44188700e-02f, -1.29823595e-01f, 1.42730489e-01f, 2.18111724e-02f, -2.09018648e-01f, 1.04846261e-01f, 6.78159595e-02f, 6.93131387e-02f, 9.84666049e-02f,
  2.05996215e-01f, 1.16841823e-01f, -1.25057399e-01f, 1.10527478e-01f, -6.39484003e-02f, -5.51062711e-02f, 4.01479900e-02f, 5.51102199e-02f, 4.88069952e-02f, 3.05999257e-02f,
  -3.94673832e-02f, 1.97317719e-01f, -1.35766879e-01f, 4.29332480e-02f, -6.45137578e-02f, 1.93976108e-02f, -1.31171286e-01f, 4.88905609e-03f, 2.70865172e-01f, -1.43649489e-01f,
  1.98485002e-01f, -1.69919565e-01f, 1.31668020e-02f, -4.89998907e-02f, -2.49047596e-02f, 5.09660505e-02f, -2.83898264e-01f, -7.52229691e-02f, -1.76883131e-01f, -9.94325653e-02f,
  -2.33064428e-01f, 3.59835401e-02f, -1.16176650e-01f, -4.45277691e-02f, -1.40592068e-01f, -8.81620944e-02f, 1.41712591e-01f, -1.54959932e-01f, 1.09408200e-01f, 3.02156150e-01f,
  -5.36936969e-02f, 8.28335732e-02f, 4.02830839e-02f, -8.09124485e-02f, 1.77600458e-01f, -1.53298035e-01f, 2.52061516e-01f, -1.46191284e-01f, 2.24250183e-01f, 1.47389814e-01f,
  2.96424925e-01f, -1.24570712e-01f, -8.21770448e-03f, -1.48589149e-01f, -3.35103452e-01f, -1.06138870e-01f, 1.97324548e-02f, 9.46713984e-02f, -1.10452697e-01f, 8.31096843e-02f,
  -3.01981777e-01f, -1.32458270e-01f, 1.57053396e-01f, -1.38644218e-01f, 3.24502259e-01f, -1.41141310e-01f, -1.34398505e-01f, 9.42537154e-04f, 1.59967154e-01f, 9.27030295e-02f,
  8.60818326e-02f, -1.43683657e-01f, 2.17687517e-01f, 2.16145828e-01f, 6.23428915e-03f, 2.73232073e-01f, 6.47601858e-03f, 5.99025153e-02f, 1.66887939e-01f, 9.68046545e-04f,
  1.22722521e-01f, -1.91349653e-04f, -1.05836369e-01f, -1.86268926e-01f, 1.76949531e-01f, 1.53937444e-01f, -3.93216848e-01f, -1.30696848e-01f, 7.80457184e-02f, 5.94792850e-02f,
  1.94373980e-01f, 4.54475321e-02f, 5.70586212e-02f, -7.55197629e-02f, 4.08871211e-02f, -2.10679010e-01f, -2.55685568e-01f, -1.11150518e-01f, 6.64784759e-02f, -1.30343363e-01f,
  -1.35755800e-02f, -4.33501340e-02f, -5.96932210e-02f, -2.03110389e-02f, -1.55604184e-01f, -4.71186377e-02f, -2.53845036e-01f, 1.52847944e-02f, 8.97540078e-02f, -2.28218898e-01f,
  7.88060278e-02f, 2.34134316e-01f, -1.26161516e-01f, 1.65015340e-01f, 1.04038045e-01f, -8.37599952e-03f, 6.42329007e-02f, -2.80132949e-01f, 1.95929229e-01f, -9.34569389e-02f,
  -1.09190494e-01f, 4.16469388e-02f, 3.16173494e-01f, -5.48083056e-03f, -4.09359634e-02f, 3.05840075e-01f, 1.78905070e-01f, 4.80570123e-02f, 7.99667090e-02f, 1.81332424e-01f,
  -5.57061732e-02f, -1.26443103e-01f, 3.40051115e-01f, 2.24737510e-01f, 4.15296070e-02f, 6.52872398e-02f, 9.46357921e-02f, 1.36961779e-02f, 3.72255258e-02f, -1.03918705e-02f,
  5.73465601e-02f, 8.68960097e-02f, -2.15326488e-01f, 3.44563685e-02f, 7.93184042e-02f, 8.54508579e-02f, -1.36187792e-01f, -1.33826464e-01f, 5.41522205e-02f, 2.59643853e-01f,
  -1.39866173e-01f, -3.49047431e-03f, 2.13328540e-01f, 2.14846522e-01f, 8.39207917e-02f, 1.09765425e-01f, 8.63564685e-02f, -5.53013682e-02f, 1.20448902e-01f, -4.95011248e-02f,
  -8.70049186e-03f, 6.34226426e-02f, -3.76110487e-02f, -1.11401699e-01f, -1.30169066e-02f, 6.02700785e-02f, -6.90513849e-02f, -8.39136168e-02f, 3.07879061e-03f, 2.17029318e-01f,
  -1.15814917e-01f, 6.31850064e-02f, -4.82631214e-02f, 9.19660777e-02f, 2.58452773e-01f, 5.98431937e-02f, 1.97731648e-02f, 4.15120833e-02f, 1.28705442e-01f, 6.69983625e-02f,
  -2.11548999e-01f, 4.54078242e-02f, 7.94551671e-02f, -1.78585351e-01f, 1.14242457e-01f, -8.26110914e-02f, -7.65429810e-02f, 1.65829241e-01f, -1.01793269e-02f, -1.12592727e-01f,
  5.06335422e-02f, -5.98289333e-02f, -8.16274807e-03f, 1.71754375e-01f, 1.15798771e-01f, 2.92867236e-03f, 2.11139455e-01f, 1.23555094e-01f, -7.66571015e-02f, -1.49910763e-01f,
  1.67980082e-02f, -5.58106489e-02f, -3.82067971e-02f, -3.58520523e-02f, 3.79965827e-02f, 1.03062041e-01f, 7.54770935e-02f, 1.51259363e-01f, 1.18544132e-01f, 1.67786956e-01f,
  -6.45147488e-02f, 1.15265891e-01f, 6.70988336e-02f, -1.65978864e-01f, -1.86045662e-01f, 2.19601557e-01f, 8.06245506e-02f, 5.51259145e-02f, 2.55833529e-02f, -3.37660730e-01f,
  1.84141755e-01f, 1.62269384e-01f, -1.67681888e-01f, 4.54024002e-02f, 8.19765553e-02f, -1.45116821e-01f, 1.18314497e-01f, 2.49453664e-01f, -2.29027480e-01f, -1.64630130e-01f,
  1.55740604e-01f, -1.58794910e-01f, -1.23660285e-02f, 4.71068025e-02f, 1.70993254e-01f, -9.35527962e-03f, 1.91660538e-01f, 1.14638582e-01f, -1.34066835e-01f, -1.66572109e-02f,
  1.62489846e-01f, 1.45838242e-02f, 1.81168132e-02f, -1.37102112e-01f, 1.16192043e-01f, 3.45278904e-02f, -1.26002297e-01f, -1.35467649e-01f, 8.13036412e-02f, 1.19217440e-01f,
  -2.62059998e-02f, -4.59359586e-02f, 2.85378158e-01f, 1.36104384e-02f, -1.38076738e-01f, 1.13039091e-01f, 5.83918132e-02f, -8.57026577e-02f, 1.57764405e-01f, 1.99575946e-01f,
  -1.13361940e-01f, -4.34944816e-02f, 1.23235576e-01f, 1.08693942e-01f, 3.56304944e-02f, 1.31678805e-01f, 1.62708491e-01f, 2.78186835e-02f, 1.01703428e-01f, 1.13525495e-01f,
  1.19203918e-01f, 1.40484050e-01f, 1.27602503e-01f, 1.68229207e-01f, -2.10570186e-01f, 6.74703792e-02f, -1.34450421e-01f, 6.47872835e-02f, -1.64391369e-01f, 5.10902256e-02f,
  2.48888016e-01f, 2.04591513e-01f, 6.60827607e-02f, -1.65015459e-01f, 2.88350791e-01f, -1.64818838e-02f, -1.62382293e-02f, -1.48067558e-02f, -5.76221533e-02f, 3.13440189e-02f,
  -3.67345288e-02f, 2.85077393e-01f, -5.21667376e-02f, -9.22464300e-03f, 1.42109200e-01f, -1.16532207e-01f, 2.23070029e-02f, -5.93407936e-02f, 1.39945641e-01f, 6.25743940e-02f,
  1.15364335e-01f, 3.11300099e-01f, 2.99370121e-02f, -1.07082166e-01f, 5.17868139e-02f, -4.88814432e-03f, -1.10340863e-01f, 1.19335912e-01f, 2.81961840e-02f, 1.30910665e-01f,
  1.46378368e-01f, -5.98245263e-02f, -5.95307089e-02f, -5.39818704e-02f, -1.35792777e-01f, -1.36287168e-01f, 2.30753809e-01f, -5.69491414e-03f, -1.36291593e-01f, 1.72331348e-01f,
  -9.63926464e-02f, 2.81666778e-03f, 2.08206668e-01f, 4.37694453e-02f, -1.16486527e-01f, -5.61830252e-02f, 7.33919665e-02f, -3.66793685e-02f, 2.32438907e-01f, -5.25712222e-03f,
  6.09406531e-02f, 2.20335811e-01f, 1.00661255e-02f, 1.88884754e-02f, 1.55915633e-01f, 1.16869938e-02f, 9.38691348e-02f, 1.24263063e-01f, -1.41216861e-02f, 2.13103909e-02f,
  4.00619619e-02f, 1.19751945e-01f, -7.00477436e-02f, 4.76110801e-02f, 1.36622600e-02f, 7.60387555e-02f, 1.25625789e-01f, -2.04970181e-01f, -6.87246323e-02f, 9.95295644e-02f,
  -7.43141174e-02f, -1.27062231e-01f, -3.36110383e-01f, -1.00423776e-01f, 9.34342444e-02f, -3.48461531e-02f, -1.48260534e-01f, -2.91864108e-02f, 7.23472238e-02f, -4.94264774e-02f,
  -1.67770907e-01f, -2.50549436e-01f, -1.56586140e-01f, 4.29199859e-02f, 1.43103629e-01f, 1.02710493e-01f, 4.23721131e-03f, 1.75262745e-02f, -1.41152948e-01f, 1.34644061e-01f,
  -1.97543591e-01f, -1.14757791e-01f, 1.08507112e-01f, -3.20043564e-01f, 2.43555501e-01f, 1.42298743e-01f, -1.82152763e-01f, 5.35374470e-02f, 7.47460350e-02f, -2.87350304e-02f,
  -3.48392851e-03f, 2.23331884e-01f, -5.44056147e-02f, 3.24958116e-01f, 2.24734873e-01f, 2.43624702e-01f, -8.50825831e-02f, -2.50631630e-01f, 1.91286445e-01f, 5.66555485e-02f,
  -7.32897297e-02f, 1.23732358e-01f, 1.23492710e-01f, 8.75738859e-02f, 1.40822545e-01f, 1.83920309e-01f, 2.17575520e-01f, 1.95985079e-01f, -4.77864631e-02f, -8.15312341e-02f,
  8.33225325e-02f, 4.50470522e-02f, 4.99661490e-02f, -1.18127599e-01f, -5.07947057e-02f, 1.83638230e-01f, 6.69649988e-02f, 4.07880880e-02f, 1.21553324e-01f, 9.13060978e-02f,
  8.32503363e-02f, -3.80582102e-02f, -1.35363713e-02f, -2.69314125e-02f, -8.13479051e-02f, 2.39836462e-02f, -4.55992930e-02f, 2.36072834e-03f, 3.18584405e-02f, -2.23686397e-02f,
  -1.41243368e-01f, -4.16800706e-03f, 1.85590670e-01f, -6.16944544e-02f, -1.20954044e-01f, -1.19635321e-01f, -1.39616221e-01f, 6.57802448e-02f, 1.20625667e-01f, 6.94807768e-02f,
  1.28807023e-01f, -2.38758791e-02f, -5.23963384e-02f, 2.41548672e-01f, 1.26124218e-01f, 6.47250414e-02f, 2.67686188e-01f, 3.12083345e-02f, 4.15153280e-02f, 2.64903046e-02f,
  2.55191009e-02f, 3.22799049e-02f, -6.99613094e-02f, 1.38151079e-01f, 7.26274848e-02f, 2.52654493e-01f, 8.71997625e-02f, -2.80498993e-02f, -1.50553763e-01f, 1.90289274e-01f,
  5.25439344e-02f, -6.55541196e-02f, 2.43155971e-01f, 8.36836323e-02f, 2.77599152e-02f, -6.24680109e-02f, 6.55028448e-02f, -2.02833302e-02f, -7.52020329e-02f, 1.42560750e-01f,
  -8.01320300e-02f, 1.07025094e-01f, -3.27931121e-02f, -5.08869179e-02f, -1.75568908e-01f, 5.88063411e-02f, 2.87709653e-01f, 1.88219056e-01f, 2.53068089e-01f, -1.50437370e-01f,
  1.92291588e-01f, 1.10684350e-01f, 9.89084542e-02f, -3.33709680e-02f, 2.63503361e-02f, -7.49726072e-02f, -9.89356861e-02f, -2.90932506e-01f, -1.55709460e-01f, 1.77534129e-02f,
  -1.93770692e-01f, 1.77355990e-01f, 3.50423157e-02f, -1.50769621e-01f, 2.06256688e-01f, -1.77275106e-01f, -2.06092298e-01f, -2.99566798e-02f, -6.91811508e-03f, 8.69504139e-02f,
  -1.46329060e-01f, 2.70774722e-01f, 9.89179164e-02f, -1.53334096e-01f, -1.26247853e-01f, -1.21472649e-01f, 4.65875380e-02f, -1.82632338e-02f, -6.28020465e-02f, -7.13521764e-02f,
  1.26002192e-01f, -3.67737859e-01f, -1.56948432e-01f, 5.88031486e-02f, -2.04823583e-01f, -1.92863926e-01f, 7.00316951e-02f, -2.68014222e-01f, -3.41628268e-02f, -1.64177939e-01f,
  -3.04122642e-02f, -1.14860572e-01f, 3.65667641e-02f, 6.96395785e-02f, -2.36374751e-01f, 9.33525488e-02f, -4.78696860e-02f, -7.70936385e-02f, -2.57612109e-01f, -2.27138072e-01f,
  1.74177974e-01f, 2.25012307e-03f, 4.04556468e-02f, 9.77858081e-02f, -4.06603292e-02f, -4.67070229e-02f, 8.52307081e-02f, 1.53586686e-01f, -9.19940546e-02f, -1.27954900e-01f,
  1.55558646e-01f, -1.29097790e-01f, 1.73286796e-01f, -7.70470724e-02f, 6.69860691e-02f, -7.06358105e-02f, -7.49634206e-02f, -4.90731634e-02f, -4.77044955e-02f, -2.28047045e-03f,
  -2.85189282e-02f, 1.26890764e-01f, 3.77137586e-02f, -1.06724486e-01f, -9.11020413e-02f, 1.33365408e-01f, -8.40567350e-02f, -8.10128823e-02f, 1.86337262e-01f, 3.36078852e-02f,
  -1.07008822e-01f, 2.41508991e-01f, 8.69716927e-02f, 9.59300175e-02f, -2.20742468e-02f, -4.21232991e-02f, 7.34797195e-02f, -5.74245155e-02f, -6.88833967e-02f, 8.94791260e-02f,
  4.30520214e-02f, -8.11861902e-02f, -1.05885742e-02f, 1.60274357e-01f, -2.26272926e-01f, -9.82541144e-02f, 1.12308539e-01f, 1.58659667e-01f, -3.32160108e-02f, 7.42308795e-02f,
  -2.56729890e-02f, -2.22205400e-01f, -4.34329472e-02f, -1.50232106e-01f, 1.01775907e-01f, 5.64991788e-04f, 2.62833387e-01f, 9.63465720e-02f, -1.51847929e-01f, 9.85068828e-02f,
  -6.27466440e-02f, -6.97023869e-02f, 6.03826009e-02f, -1.29887331e-02f, 8.57430100e-02f, -2.07055430e-03f, 8.79025087e-02f, 4.81085144e-02f, 9.82525647e-02f, 1.50060758e-01f,
  -1.90076958e-02f, 7.94413686e-03f, -8.91412944e-02f, 4.38570641e-02f, 8.37647319e-02f, -1.22134879e-01f, 1.03333667e-02f, 7.66136795e-02f, -4.42606695e-02f, 3.73720680e-03f,
  9.97763053e-02f, 4.94697690e-02f, 9.91467014e-03f, -4.61334875e-03f, -3.17538530e-02f, -1.19747259e-01f, 2.54484825e-02f, 7.64399990e-02f, 5.23722917e-02f, 3.23105231e-02f,
  -7.36021996e-02f, -8.08082744e-02f, 1.52385652e-01f, -5.46478033e-02f, 1.55127823e-01f, 1.04321510e-01f, -7.84031525e-02f, 1.59695953e-01f, -1.99011080e-02f, -1.75288599e-02f,
  -8.45719501e-02f, -2.77917832e-02f, 1.84439272e-01f, -1.03570661e-02f, 7.06459358e-02f, 4.85463068e-02f, 2.33282194e-01f, 3.25164199e-02f, -3.97842452e-02f, 5.86469769e-02f,
  -6.90869391e-02f, -1.16861850e-01f, 1.33828610e-01f, -3.56366336e-02f, -6.14109077e-02f, 7.54440650e-02f, -1.16421171e-01f, -5.78176118e-02f, 1.50188476e-01f, 1.00868285e-01f,
  9.68270898e-02f, -1.71686318e-02f, 6.99030235e-02f, -5.74422553e-02f, 1.89836115e-01f, 2.46616617e-01f, -1.42512321e-01f, -8.48732665e-02f, -1.80092782e-01f, -9.07532591e-03f,
  -1.20652780e-01f, -1.61845833e-01f, -8.19106679e-03f, -4.31859270e-02f, -3.41729932e-02f, 1.02486558e-01f, 5.24740741e-02f, 1.15120284e-01f, -1.88599616e-01f, 1.25983387e-01f,
  7.65155302e-03f, -6.92241341e-02f, 7.18368739e-02f, 6.91926330e-02f, 1.74167231e-01f, 1.50871024e-01f, -1.81895390e-01f, -2.38873720e-01f, 1.09754160e-01f, 1.28157750e-01f,
  -2.51189172e-01f, -3.22779603e-02f, -1.75985143e-01f, 3.57146077e-02f, 6.35316521e-02f, 1.25916824e-01f, -9.02505964e-02f, 8.97876918e-02f, 1.84675470e-01f, 4.05116156e-02f,
  -8.08148682e-02f, 2.10262731e-01f, 3.02930735e-02f, -5.11057712e-02f, -2.79769581e-02f, 1.74530298e-01f, 2.99220569e-02f, 2.49161348e-02f, 1.50533825e-01f, -1.10828169e-01f,
  4.98330183e-02f, 7.87193626e-02f, 1.20973669e-01f, 7.91076720e-02f, -6.81248605e-02f, 2.58197431e-02f, 1.03379622e-01f, -4.70339395e-02f, 1.03015518e-02f, 6.85999990e-02f,
  2.12750211e-01f, -1.63439840e-01f, -1.44083098e-01f, 1.79056585e-01f, 1.54491849e-02f, -1.92224130e-01f, -1.47085758e-02f, 1.13696441e-01f, -5.93860336e-02f, -7.43237287e-02f,
  1.77914396e-01f, 9.29955617e-02f, -7.90507812e-03f, -4.60885130e-02f, -1.34196477e-02f, -2.36590742e-03f, -9.59905908e-02f, 7.14077801e-03f, -9.64991003e-02f, -6.88819331e-04f,
  1.42723287e-03f, 2.27414630e-02f, -1.21817738e-01f, -1.75809145e-01f, -1.72945634e-02f, 2.12092802e-01f, -4.85070981e-02f, -7.70293996e-02f, 7.00318217e-02f, -6.12729602e-02f,
  1.01647437e-01f, 3.05609405e-01f, 3.12658027e-02f, 3.43544632e-02f, 1.28439829e-01f, 9.82672255e-03f, 2.08856508e-01f, 1.58164665e-01f, -1.18474029e-01f, -1.15967467e-01f,
  8.36491510e-02f, 5.76133728e-02f, -6.14677481e-02f, -1.69281319e-01f, -1.00092217e-01f, 8.28518495e-02f, -2.74935663e-02f, -6.40846416e-02f, -3.18813741e-01f, 1.35081723e-01f,
  1.79622650e-01f, 5.33457398e-02f, -5.36672957e-03f, 7.50200674e-02f, 1.02773920e-01f, -2.99799647e-02f, -1.37232378e-01f, 1.28868714e-01f, 3.92760150e-02f, -1.97390895e-02f,
  5.78840226e-02f, -7.35820876e-03f, -3.07533666e-02f, 2.01786280e-01f, -1.92457169e-01f, -1.04377277e-01f, 6.95981234e-02f, -7.80127421e-02f, -1.67067990e-01f, 1.96718290e-01f,
  1.29780071e-02f, -8.86062086e-02f, 1.66542456e-01f, 1.82684764e-01f, 4.56618611e-03f, -1.51076213e-01f, 5.89202978e-02f, 6.91200420e-02f, 2.28247091e-01f, 1.28387243e-01f,
  2.08416015e-01f, -3.86206270e-03f, -8.00870061e-02f, -9.19841230e-02f, 2.53451169e-01f, 7.62194023e-02f, -1.75529927e-01f, -4.81809070e-03f, 1.43947899e-02f, 1.11299887e-01f,
  -1.63339570e-01f, 1.79021731e-01f, 9.57907811e-02f, -2.04944834e-01f, 1.57802314e-01f, 2.11100921e-01f, -1.26481175e-01f, -3.12172137e-02f, 3.15568298e-01f, 1.99585155e-01f,
  3.89128894e-01f, -1.65643916e-01f, -3.77309807e-02f, -2.03930885e-01f, -9.63872746e-02f, 1.00407690e-01f, -1.61081329e-01f, -5.89835644e-02f, 6.12843297e-02f, -5.59343845e-02f,
  -8.47555883e-03f, -1.60418913e-01f, -1.26243919e-01f, 1.00464948e-01f, 1.21727481e-01f, 3.03916603e-01f, -3.66796367e-02f, -2.01409206e-01f, -3.15779559e-02f, -7.56625906e-02f,
  -2.42632613e-01f, 4.52484459e-01f, 9.45352465e-02f, -3.90250124e-02f, -2.37829071e-02f, 1.57339364e-01f, 1.70476213e-02f, 1.42479330e-01f, 7.42202476e-02f, 2.45993778e-01f,
  8.42056721e-02f, 1.46195710e-01f, -1.73127100e-01f, 8.46891180e-02f, 1.53284296e-01f, 7.79448450e-02f, -1.17476799e-01f, -1.34566694e-01f, 5.86215258e-02f, -6.02929713e-03f,
  1.16917282e-01f, 1.40450522e-01f, 1.81195095e-01f, 7.37128854e-02f, 2.70578940e-03f, 1.58479080e-01f, 2.09059924e-01f, 1.79045171e-01f, 8.19045827e-02f, -3.35415863e-02f,
  -1.04064792e-01f, 2.28338674e-01f, 2.14056317e-02f, 4.33830917e-02f, 4.93167564e-02f, 2.99544424e-01f, 2.89375745e-02f, -2.22731352e-01f, 1.40035957e-01f, -1.80631950e-02f,
  8.49992409e-03f, -8.50045308e-02f, 2.61157062e-02f, 2.09576339e-01f, 3.48560065e-01f, 1.13844074e-01f, 7.41796792e-02f, 4.32686560e-04f, -1.60501271e-01f, -1.03038065e-02f,
  -3.88647057e-02f, -2.61327624e-01f, 2.21509993e-01f, -6.22527413e-02f, 1.46095157e-01f, -4.81930971e-02f, -1.29638046e-01f, 2.26935655e-01f, -1.77988615e-02f, 4.29830924e-02f,
  2.12503016e-01f, -2.04377234e-01f, -9.37766954e-02f, -2.20037341e-01f, -9.79622006e-02f, 3.61316532e-01f, -2.22140878e-01f, -1.51758581e-01f, 3.60451974e-02f, 2.13292360e-01f,
  2.21381068e-01f, 1.47635907e-01f, 2.99971979e-02f, 1.84100702e-01f, 3.37559059e-02f, 2.59921908e-01f, -1.79587170e-01f, 1.95583813e-02f, 2.92026401e-01f, 4.58308682e-02f,
  -2.61297107e-01f, -1.82260200e-01f, -8.86066854e-02f, 2.39749297e-01f, 1.93928346e-01f, 1.03601471e-01f, 8.43701046e-03f, -6.29642606e-02f, -7.60732964e-02f, -6.59591556e-02f,
  1.50930017e-01f, 1.17848881e-01f, 1.36169270e-01f, -2.93900985e-02f, 6.04171343e-02f, -1.07008308e-01f, -1.44439824e-02f, -5.09881880e-03f, -2.44208463e-02f, 2.64378674e-02f,
  2.50830501e-01f, 5.68066873e-02f, 1.56379044e-01f, -2.22131535e-01f, 9.07217413e-02f, 1.94370911e-01f, -1.99433655e-01f, -6.34611249e-02f, -3.08041871e-01f, -1.64011165e-01f,
  1.53217316e-01f, 1.04393356e-01f, -1.25932485e-01f, 8.70173797e-02f, 6.47069290e-02f, 6.84053972e-02f, -1.53722195e-02f, -6.05886243e-02f, 9.44714174e-02f, 1.42088935e-01f,
  7.04123452e-02f, 1.66375652e-01f, 6.01046681e-02f, 8.47477093e-03f, 2.50268519e-01f, 1.33870989e-01f, -6.70018196e-02f, -1.08403921e-01f, 1.87710747e-01f, -1.72789201e-01f,
  1.26870155e-01f, -1.16243005e-01f, 8.65273029e-02f, 4.46555242e-02f, -1.73526570e-01f, 1.28094740e-02f, 8.44193548e-02f, -1.75813660e-01f, -6.20826408e-02f, 1.64388288e-02f,
  8.08881968e-02f, 5.45859523e-02f, 3.37003022e-02f, 1.83598414e-01f, 1.31459177e-01f, 2.21513752e-02f, 6.59560487e-02f, -1.19409963e-01f, 1.67246014e-01f, 1.03583857e-01f,
  9.66504142e-02f, 1.14430159e-01f, 1.70218155e-01f, 1.53214365e-01f, -2.38519050e-02f, -4.53336090e-02f, -9.19509828e-02f, -1.10735513e-01f, -1.35861650e-01f, -6.41559958e-02f,
  -1.23914585e-01f, 1.58025980e-01f, -1.21869154e-01f, -9.45858136e-02f, 1.07771784e-01f, 8.61609727e-02f, 6.26618490e-02f, 2.10035801e-01f, 9.10223201e-02f, 2.76222304e-02f,
  1.92598790e-01f, -1.19149849e-01f, 1.39733076e-01f, 1.76090106e-01f, -3.64228711e-02f, 1.39575735e-01f, 4.06717919e-02f, 5.13412990e-02f, -1.53280854e-01f, -4.41862494e-02f,
  -1.31481979e-02f, 2.14462385e-01f, 2.06174001e-01f, -1.77056789e-02f, -1.00588463e-01f, 6.78783432e-02f, 7.53310844e-02f, -1.56794265e-02f, -8.46465603e-02f, -2.00532121e-03f,
  3.55194546e-02f, 2.47682661e-01f, -8.24661404e-02f, 2.18273193e-01f, 7.13164508e-02f, -2.46953629e-02f, 1.21257968e-01f, -1.30989164e-01f, 9.19052924e-04f, 7.56262168e-02f,
  1.90774977e-01f, -9.41046625e-02f, -1.26866281e-01f, 5.22941649e-02f, -6.70055673e-02f, 3.25199403e-02f, 1.62840396e-01f, -2.62022410e-02f, -4.95135365e-03f, -5.24346493e-02f,
  -8.35510269e-02f, -6.41722605e-02f, 8.18714350e-02f, 2.10411754e-02f, 8.93065184e-02f, 1.12009510e-01f, 1.10667579e-01f, 1.30951479e-01f, 2.40147486e-01f, 2.21716046e-01f,
  1.73427135e-01f, 6.65618107e-02f, -7.62578845e-02f, 2.66555101e-01f, -4.84850118e-03f, -1.09229237e-01f, -1.23642176e-01f, 2.74982333e-01f, 1.71552747e-01f, 9.29471999e-02f,
  -4.30601947e-02f, -9.07876194e-02f, 1.78814873e-01f, -5.07287905e-02f, -1.64989918e-01f, 5.19388355e-02f, -3.77968326e-02f, -1.76605172e-02f, 8.99860933e-02f, 1.44175023e-01f,
  -2.84871683e-02f, -2.58446991e-01f, 5.64735234e-02f, -2.38897160e-01f, 1.47428960e-01f, -1.81467995e-01f, 8.82892087e-02f, 1.20800897e-01f, 1.44296050e-01f, 2.02078521e-01f,
  -1.39483958e-01f, -1.92371998e-02f, 2.61480629e-01f, -4.04302552e-02f, 9.07155573e-02f, -1.63258255e-01f, -1.79430526e-02f, 6.87523708e-02f, -2.72407442e-01f, 7.87276495e-03f,
  5.58549240e-02f, 8.11440572e-02f, 2.21356496e-01f, -8.52080882e-02f, 2.42076173e-01f, 9.82395262e-02f, 4.81082983e-02f, 1.40131429e-01f, -8.68514702e-02f, -6.19270392e-02f,
  1.57406647e-02f, 2.51165122e-01f, -1.15466535e-01f, -9.91536379e-02f, 1.41549418e-02f, 5.92647195e-02f, -1.12140365e-01f, 3.44875082e-02f, -5.24350889e-02f, 9.00163949e-02f,
  -4.41272818e-02f, 1.74489543e-02f, -1.86421484e-01f, -1.45742461e-01f, 1.37013480e-01f, -7.09877536e-02f, -1.87103659e-01f, -1.98680833e-01f, 1.76619455e-01f, -4.08628695e-02f,
  -2.00650319e-01f, 5.88733554e-02f, -2.47613013e-01f, 1.57980900e-02f, 1.20754419e-02f, 3.07895213e-01f, 4.10412252e-02f, 1.15583248e-01f, 4.06582832e-01f, 5.70849739e-02f,
  1.45741478e-01f, -4.32117358e-02f, -1.40459621e-02f, 5.42350411e-02f, 1.21087216e-01f, 9.85528752e-02f, -1.19249046e-01f, 6.22332282e-03f, -5.88045456e-02f, 8.04453939e-02f,
  -1.05231643e-01f, -4.34271432e-02f, -2.30030771e-02f, 4.57861228e-03f, -7.85178840e-02f, 2.80547380e-01f, -6.83766305e-02f, -2.75559947e-02f, 3.48844565e-02f, -1.83100514e-02f,
  -2.24614769e-01f, 2.37800196e-01f, 2.42342100e-01f, 2.01670751e-01f, -1.76415652e-01f, 1.25594780e-01f, -2.17918977e-02f, 8.54592547e-02f, 3.86091955e-02f, 1.82821661e-01f,
  -5.43512069e-02f, 2.20770791e-01f, 8.96570608e-02f, 3.17329526e-01f, 4.08528522e-02f, -3.30055691e-02f, -7.51269236e-02f, -1.39332220e-01f, -9.77648236e-03f, -5.32504879e-02f,
  1.19708804e-03f, 1.09890305e-01f, 1.60072878e-01f, -9.87242609e-02f, 4.81502153e-02f, -3.89374942e-02f, 4.78617512e-02f, -2.06079096e-01f, -6.11191988e-02f, 9.79872718e-02f,
  -1.44706760e-02f, 2.41907891e-02f, 7.62533844e-02f, -2.34682467e-02f, 2.07271382e-01f, -8.38837624e-02f, -1.89321991e-02f, 1.66066319e-01f, 1.29304901e-02f, 1.36388242e-01f,
  6.30177185e-02f, 2.84500973e-04f, -1.23263979e-02f, -4.32476960e-02f, 8.18574727e-02f, 1.19156986e-01f, -3.45319271e-01f, 4.25733216e-02f, 4.58122529e-02f, 6.21986538e-02f,
  2.71969885e-01f, 6.74607903e-02f, -8.05916041e-02f, 1.46032915e-01f, 1.58912137e-01f, 4.55900766e-02f, -5.33711091e-02f, 8.15748498e-02f, -6.41826401e-03f, 3.30826491e-02f,
  1.83366567e-01f, 1.46560103e-01f, 2.31534973e-01f, 1.43469408e-01f, -8.71362537e-02f, 1.02232777e-01f, 2.64916159e-02f, 6.12830594e-02f, 4.22995612e-02f, -1.45463899e-01f,
  1.85194053e-02f, 2.07305014e-01f, 1.73587296e-02f, -4.28936146e-02f, 1.35911629e-01f, 1.21266194e-01f, -8.74848068e-02f, -2.10410416e-01f, 1.13288930e-03f, -6.52070791e-02f,
  8.17918181e-02f, 1.28419474e-01f, -1.88093930e-01f, 1.70892507e-01f, 1.38359711e-01f, 5.56617416e-02f, 1.85123891e-01f, 1.11845709e-01f, 1.43830687e-01f, 1.26687348e-01f,
  -8.78679678e-02f, 4.54747602e-02f, -8.80413353e-02f, -1.36133343e-01f, 2.27389216e-01f, 1.14413224e-01f, 1.02350123e-01f, -7.77796563e-03f, 4.28254604e-02f, 1.26434743e-01f,
  -2.54195854e-02f, -1.16937466e-01f, 5.63938578e-04f, 9.85495970e-02f, -5.96710294e-02f, -2.63118267e-01f, 1.16529651e-01f, 6.62405714e-02f, 3.64399374e-01f, 2.24925786e-01f,
  4.64471392e-02f, -5.00860922e-02f, 1.46191940e-01f, -1.43948749e-01f, -9.81661305e-02f, 1.41457077e-02f, 1.33844912e-01f, 2.39884723e-02f, 1.81261539e-01f, -2.17299815e-02f,
  -4.78667766e-02f, -1.82605386e-01f, -7.56036118e-02f, 4.77363653e-02f, -1.07010968e-01f, 5.33559406e-03f, 6.27586618e-02f, -8.38295817e-02f, -8.37689415e-02f, 4.29718822e-01f,
  9.25453082e-02f, 1.24235600e-01f, 1.50762545e-02f, 3.86593379e-02f, 3.87707315e-02f, 5.77175617e-02f, -4.25362848e-02f, 6.32831901e-02f, 1.10846989e-01f, -1.42211407e-01f,
  -1.01913266e-01f, -1.96237206e-01f, -5.25926650e-02f, 8.18046555e-02f, -6.55803159e-02f, 2.85484251e-02f, -7.71932527e-02f, -3.56405526e-02f, -6.04740977e-02f, 8.31603631e-02f,
  4.98618707e-02f, 4.97248359e-02f, 6.05178326e-02f, 5.00523895e-02f, 4.29924950e-02f, 3.70323062e-02f, -1.65245240e-03f, 1.72867458e-02f, -1.06599480e-01f, -4.11801673e-02f,
  6.00562394e-02f, 9.85963568e-02f, 4.15061489e-02f, -2.95151901e-02f, 1.80231020e-01f, 7.15968683e-02f, 9.29608271e-02f, 8.69073495e-02f, 1.95102580e-02f, 1.11113593e-01f,
  3.59494761e-02f, -6.65501505e-02f, 7.48399198e-02f, -1.04907013e-01f, 1.31863356e-01f, -3.44673428e-03f, -8.03355873e-03f, 1.70564458e-01f, -1.98429637e-02f, 1.27013475e-01f,
  -4.12581451e-02f, 1.35355964e-01f, -8.18646885e-03f, -7.83952400e-02f, -1.00863883e-02f, 1.39074937e-01f, 1.58630237e-01f, 3.13407443e-02f, -6.56693131e-02f, 1.54647520e-02f,
  -2.69072205e-02f, 2.37443268e-01f, -2.56154329e-01f, 1.73620865e-01f, 4.32412215e-02f, -8.03508330e-03f, 8.50699544e-02f, -6.02447055e-02f, -3.03400829e-02f, 1.45564884e-01f,
  5.14080487e-02f, -1.80303738e-01f, -4.05085422e-02f, -2.60733068e-02f, 1.93320528e-01f, -1.38714835e-01f, 1.57353669e-01f, 8.62611309e-02f, -1.00613222e-01f, 1.07833505e-01f,
  1.62549302e-01f, -9.43419635e-02f, -8.64807740e-02f, 1.25252977e-01f, 6.57504201e-02f, 6.84434921e-02f, -8.42512120e-03f, 1.44775972e-01f, 1.74919650e-01f, 3.84543836e-02f,
  2.02391386e-01f, 1.86818674e-01f, -4.58797887e-02f, 1.15204781e-01f, 2.32979283e-01f, -1.47926688e-01f, -1.01271734e-01f, 1.18155405e-01f, 2.52397984e-01f, 2.20608145e-01f,
  1.24156021e-01f, -3.31888855e-01f, 2.62406409e-01f, 1.06992953e-01f, -1.42860964e-01f, -4.24263366e-02f, -1.24692962e-01f, -9.51650664e-02f, -3.55813392e-02f, 2.46787161e-01f,
  -1.57653019e-01f, -2.10374609e-01f, 2.50748366e-01f, -1.56376585e-01f, 5.31841442e-02f, -9.47680846e-02f, -2.02854592e-02f, 2.31646657e-01f, 1.93820000e-01f, 1.18319735e-01f,
  -1.43586710e-01f, -1.83934718e-02f, 1.17262483e-01f, 3.02098691e-02f, -8.99851918e-02f, -1.76437154e-01f, 3.55374105e-02f, -1.83656216e-01f, -6.48829788e-02f, -1.47994816e-01f,
  -1.68887883e-01f, 4.60969172e-02f, 1.51512548e-01f, -2.96954475e-02f, 1.42597094e-01f, -1.74879991e-02f, 2.84798779e-02f, 9.91927534e-02f, -9.35052782e-02f, -2.90821213e-02f,
  1.78754050e-02f, 1.85848653e-01f, 3.32633480e-02f, -1.35044515e-01f, 4.23753336e-02f, 1.35007754e-01f, -1.21578544e-01f, 2.18123570e-02f, 5.64514473e-02f, -8.76578614e-02f,
  -1.42353714e-01f, 5.99140711e-02f, -1.54283777e-01f, -2.84169242e-02f, 2.50568807e-01f, 1.12099841e-01f, -2.67394811e-01f, -8.43851641e-02f, 1.14805274e-01f, 8.13932531e-03f,
  -2.34715089e-01f, 1.04200738e-02f, 1.11751571e-01f, 8.42631906e-02f, -6.52374849e-02f, 7.19931871e-02f, 1.63810998e-01f, 1.95824713e-01f, 3.18606496e-01f, 4.08207476e-02f,
  1.70475900e-01f, 7.95683414e-02f, 7.60522380e-04f, 6.33546209e-04f, -2.62942817e-02f, -3.02084908e-02f, -5.23990653e-02f, 2.42278576e-02f, 4.83906753e-02f, 1.82122886e-01f,
  1.31990463e-01f, -6.51628077e-02f, -1.31891906e-01f, 2.62014240e-01f, 5.27907871e-02f, 2.93770522e-01f, -6.95328191e-02f, 1.49825010e-02f, -9.97531638e-02f, 2.39466950e-01f,
  -2.05519333e-01f, 1.09119862e-01f, 2.06217736e-01f, 4.46516164e-02f, 1.46770040e-02f, 1.18598387e-01f, 2.68860068e-02f, 1.06566101e-01f, 1.70154527e-01f, 2.84453593e-02f,
  -9.20176432e-02f, 1.75685897e-01f, 1.80772454e-01f, 8.17858055e-02f, 1.36191770e-01f, 9.84612927e-02f, -2.20607623e-01f, -6.29062578e-02f, 1.07415356e-01f, 1.01303542e-02f,
  2.46534243e-01f, 1.61124319e-01f, 9.39382538e-02f, 2.05020547e-01f, 1.86190888e-01f, 1.05055004e-01f, -1.18411481e-01f, -1.04634672e-01f, -2.65209436e-01f, -1.55329883e-01f,
  7.85754248e-02f, -2.94346809e-01f, 9.92544666e-02f, 1.97118104e-01f, -9.39030107e-03f, -5.94406277e-02f, -3.35500389e-02f, -1.83072835e-01f, 1.20271049e-01f, 2.28594810e-01f,
  -9.16249380e-02f, -7.83657059e-02f, 1.50477484e-01f, -8.39978978e-02f, 1.34969521e-02f, 1.85760651e-02f, -1.49712771e-01f, -1.50056168e-01f, 2.40543470e-01f, 5.07368818e-02f,
  -1.19553253e-01f, 1.39678940e-01f, 2.09575191e-01f, 1.27960771e-01f, -4.47680615e-02f, 1.13381729e-01f, -5.92818595e-02f, -7.34449774e-02f, 1.58007428e-01f, 1.32913724e-01f,
  -3.80299613e-02f, 3.68473232e-02f, -3.55106518e-02f, 1.70217708e-01f, -6.64565563e-02f, 6.94816634e-02f, 1.95225164e-01f, 5.72365560e-02f, -5.49646541e-02f, 1.08539946e-01f,
  6.34619072e-02f, 9.03766900e-02f, -1.30936250e-01f, -8.71658474e-02f, 1.56574577e-01f, 2.89559159e-02f, 3.43354583e-01f, 3.85576010e-01f, 1.57569438e-01f, 1.20041005e-01f,
  7.78008699e-02f, 1.67058930e-01f, 3.94401327e-02f, -1.16518557e-01f, -3.57970744e-02f, 8.03728998e-02f, 5.31311445e-02f, 1.71041101e-01f, 3.87930572e-02f, 3.76133323e-02f,
  3.66769060e-02f, 8.53141956e-03f, -7.12950388e-03f, -3.66661064e-02f, 9.69656110e-02f, 1.95742235e-01f, 9.74341556e-02f, -1.15557708e-01f, 1.56871974e-01f, 1.23314552e-01f,
  1.76432937e-01f, -1.34979367e-01f, 2.12390479e-02f, -8.88152793e-03f, -8.05584043e-02f, -7.17982575e-02f, -2.53014937e-02f, -7.90596314e-05f, -5.92826419e-02f, 2.87025273e-02f,
  1.89169850e-02f, -1.88684449e-01f, 1.11013964e-01f, -3.05912167e-01f, -6.98574260e-02f, 5.70283979e-02f, 6.50332123e-02f, 7.37585872e-02f, -1.29520372e-01f, 2.11225107e-01f,
  6.84485510e-02f, -2.39361208e-02f, -4.85550091e-02f, -1.35677025e-01f, -2.41362713e-02f, -4.24227975e-02f, 4.03231606e-02f, -5.76578975e-02f, 1.86292946e-01f, -8.65888000e-02f,
  -1.76504791e-01f, 6.98797172e-03f, -1.61645859e-02f, 3.86743397e-02f, 1.34595618e-01f, -5.50668649e-02f, -1.85748339e-01f, 4.70627360e-02f, 1.49665019e-02f, -1.58910140e-01f,
  -6.11506961e-02f, -1.97667286e-01f, -1.79199830e-01f, 9.25716385e-02f, -6.21159934e-02f, -7.30505362e-02f, -1.83378498e-03f, -7.63955265e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  1.41938731e-01f, 2.96562929e-02f, 6.21453077e-02f, -9.49807391e-02f, 1.58850774e-01f, 1.41148329e-01f, -3.30016650e-02f, 2.02677697e-01f, 2.38500670e-01f, 7.43307695e-02f,
  2.13704228e-01f, 1.87607676e-01f, 1.89238310e-01f, 3.78609821e-02f, 1.85728341e-01f, 2.24272326e-01f, 8.56485441e-02f, 2.41062149e-01f, 1.99722394e-01f, 1.51912197e-01f,
  1.14991195e-01f, 2.02634245e-01f, 2.41728917e-01f, 2.35667706e-01f, 1.36361539e-01f, 1.52136952e-01f, 1.58464313e-01f, 2.07572073e-01f, 1.90194339e-01f, 6.78637326e-02f,
  9.28087756e-02f, 1.78812042e-01f, 8.99730697e-02f, 1.60133004e-01f, 1.80768296e-01f, 9.42974836e-02f, 5.74112236e-02f, -2.37379044e-01f, -4.39320616e-02f, 4.66723554e-02f,
  2.56256044e-01f, 7.19979107e-02f, 8.23650658e-02f, 5.31666912e-02f, 8.52693170e-02f, 3.92661877e-02f, 2.21740901e-01f, -1.28916413e-01f, 9.45364982e-02f, 5.66768721e-02f,
  2.75470674e-01f, 1.13955513e-01f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  9.75402892e-02f, -4.75881994e-02f, -5.10893129e-02f, -7.89615810e-02f, -4.40911129e-02f, -5.37862517e-02f, 1.97414383e-01f, -1.00966133e-01f, 1.77159220e-01f, -6.50072191e-03f,
  -1.73801467e-01f, -7.63465762e-02f, -3.79633084e-02f, 8.48403350e-02f, 1.04117140e-01f, 4.51526195e-02f, 7.10553378e-02f, -6.86644316e-02f, 2.67784540e-02f, -1.20310128e-01f,
  -5.42582348e-02f, -1.84884921e-01f, 9.62033942e-02f, 1.88381776e-01f, -3.52087314e-03f, 9.61602665e-03f, -1.96750030e-01f, 8.13608542e-02f, 4.24456000e-02f, -1.94862727e-02f,
  1.96687393e-02f, -1.53833285e-01f, -6.13596058e-03f, 1.21314988e-01f, -1.08286895e-01f, 1.76536277e-01f, 1.24394838e-02f, -3.83145572e-03f, -1.48642018e-01f, 1.97836936e-01f,
  -2.39141345e-01f, 9.72519219e-02f, 2.71051042e-02f, -3.62798944e-02f, -1.28904089e-01f, 7.70316049e-02f, -1.72924191e-01f, -1.76396027e-01f, 8.86282250e-02f, 1.81140423e-01f,
  -3.75702791e-02f, 2.45712638e-01f, 8.07486922e-02f, -4.34557945e-02f, -4.93619144e-02f, -1.62494540e-01f, 3.30518223e-02f, 1.00553237e-01f, 3.20595154e-03f, 6.88480362e-02f,
  -2.28975862e-02f, -2.54472382e-02f, -3.83340418e-02f, 9.28799435e-02f, -2.85228174e-02f, -8.08943808e-02f, -1.11683086e-01f, -4.67950944e-03f, -1.89954922e-01f, -1.12120964e-01f,
  1.05025478e-01f, -1.19423017e-01f, 1.73395306e-01f, -1.00111797e-01f, -1.08991437e-01f, -1.09583087e-01f, -1.13268010e-02f, -1.74030155e-01f, 7.58088380e-02f, -7.36982450e-02f,
  2.66891834e-03f, 1.54844180e-01f, -1.31068766e-01f, -2.10683104e-02f, 9.44865122e-02f, -1.17987074e-01f, -1.23619683e-01f, 8.54163605e-04f, 1.06343262e-01f, 8.48876778e-03f,
  -2.39089340e-01f, -5.37520535e-02f, 3.45006362e-02f, 1.08064659e-01f, 1.64893493e-02f, 2.22323313e-01f, 7.09356964e-02f, 2.05394104e-02f, 6.09968714e-02f, 5.58297932e-02f,
  1.38216987e-02f, -3.15000187e-03f, -1.33632541e-01f, 9.81522053e-02f, 1.65666893e-01f, 8.90128221e-03f, -9.01968032e-02f, -1.21829130e-01f, -3.46089490e-02f, 5.75847924e-02f,
  3.19809578e-02f, -9.54724252e-02f, 9.56709906e-02f, -2.43564621e-01f, -3.38880941e-02f, 1.96860313e-01f, -2.18891855e-02f, -1.11590974e-01f, 9.50108767e-02f, -1.31843820e-01f,
  6.71655908e-02f, 8.03701356e-02f, 2.04780772e-02f, -1.08913109e-01f, -1.21169887e-01f, -2.51638070e-02f, 1.52863264e-01f, -1.63442522e-01f, -2.55719479e-02f, -1.82428453e-02f,
  -1.36226919e-02f, -7.46877119e-03f, -1.91222072e-01f, 6.07299656e-02f, -2.76354235e-02f, 4.24726903e-02f, -6.40090629e-02f, -6.13518953e-02f, 5.18636033e-02f, 9.36837271e-02f,
  5.21447733e-02f, 6.51164800e-02f, 2.80879326e-02f, -9.10231099e-02f, -1.58892274e-01f, 9.76985544e-02f, -9.59922969e-02f, -1.73800718e-02f, 2.43862301e-01f, 2.12773934e-01f,
  -1.74176060e-02f, -1.30690992e-01f, -1.12967558e-01f, -1.33000910e-01f, -1.94558613e-02f, 9.73261744e-02f, 4.19425555e-02f, -2.47404585e-03f, -4.33610864e-02f, 2.16511950e-01f,
  -1.35593906e-01f, -7.44776875e-02f, 1.08846292e-01f, 6.96042776e-02f, -7.84882456e-02f, 1.25874162e-01f, -5.45454063e-02f, -4.01758626e-02f, 1.29468460e-02f, -7.88622871e-02f,
  -9.88845453e-02f, -1.01922274e-01f, -1.59046054e-02f, 1.92812067e-02f, 5.81479855e-02f, 6.74915463e-02f, -6.26612604e-02f, -1.32062584e-01f, 7.62815122e-03f, -4.78904471e-02f,
  1.22584894e-01f, -8.37385952e-02f, -7.04900399e-02f, -1.67598110e-02f, 3.46848145e-02f, -2.21526157e-02f, 4.36313115e-02f, 4.49910387e-03f, 9.15110633e-02f, -6.00831471e-02f,
  1.78312823e-01f, 1.52491301e-01f, 9.19534862e-02f, -9.04268026e-02f, -1.21689923e-02f, 7.99802095e-02f, 1.32032916e-01f, -3.57744247e-02f, -6.85963929e-02f, -1.24230990e-02f,
  -7.31626377e-02f, 1.37097314e-01f, 2.92339865e-02f, -2.56164789e-01f, 6.93270192e-02f, 4.61879522e-02f, 3.23458910e-02f, 2.92192940e-02f, -2.62304246e-02f, 1.61739588e-01f,
  -8.42233226e-02f, -1.53667167e-01f, -1.57861546e-01f, 5.71412034e-02f, 2.52412800e-02f, 1.19340152e-01f, -2.71761287e-02f, -2.23449860e-02f, 1.35238156e-01f, 1.36198374e-02f,
  3.30991149e-02f, 1.00652866e-01f, 1.21420622e-01f, 5.73261753e-02f, -1.17376290e-01f, -2.06204683e-01f, -6.24627843e-02f, -1.66835189e-02f, -3.49541418e-02f, 3.53208855e-02f,
  6.15119301e-02f, -1.99510261e-01f, -2.78426278e-02f, -8.54823440e-02f, 1.62043363e-01f, 1.45145491e-01f, -1.36943638e-01f, 1.04052104e-01f, -1.40320044e-02f, -6.19868301e-02f,
  -3.99836265e-02f, 2.08237112e-01f, -1.37030289e-01f, 1.02572128e-01f, 1.76521078e-01f, 1.49858668e-01f, 1.04588278e-01f, 7.08284527e-02f, -1.31822422e-01f, 2.14304045e-01f,
  -1.17206192e-02f, 1.12608157e-01f, 8.73608068e-02f, 2.94312593e-02f, -1.66138351e-01f, 2.92952470e-02f, 4.83155660e-02f, -6.45014122e-02f, 4.19131070e-02f, -1.82937533e-01f,
  6.43121600e-02f, -1.13327727e-01f, -3.77502404e-02f, -3.23491506e-02f, 2.06668451e-01f, 1.53780967e-01f, -1.93857700e-01f, -2.86288168e-02f, -3.64173315e-02f, -5.83782941e-02f,
  -3.97413895e-02f, 7.36190081e-02f, 7.26434588e-02f, -2.60931402e-01f, -1.68847833e-02f, 1.29715830e-01f, -7.71275908e-02f, -9.31845307e-02f, 4.56394907e-03f, 8.83311927e-02f,
  5.91909774e-02f, 1.19230613e-01f, -9.52715427e-02f, -5.45281731e-02f, 1.09522725e-02f, 2.28313301e-02f, -3.84234823e-02f, -2.35418677e-01f, 1.74844682e-01f, 1.33940339e-01f,
  7.52611458e-02f, 1.43382326e-01f, 5.63809238e-02f, 4.53637913e-02f, -7.42465034e-02f, -1.33436039e-01f, -1.75739884e-01f, 1.27526432e-01f, -7.06708571e-03f, 3.07453051e-02f,
  1.09533690e-01f, 9.18228626e-02f, -6.47349432e-02f, -1.48619227e-02f, 8.94990787e-02f, 1.59717575e-01f, -3.01417871e-03f, 2.35812422e-02f, -2.05399711e-02f, 3.70646194e-02f,
  1.35179445e-01f, -1.14077374e-01f, 7.37848505e-02f, 1.37496412e-01f, 2.93748323e-02f, 1.31425455e-01f, 4.19798940e-02f, -4.74280380e-02f, -1.02281764e-01f, -6.66224509e-02f,
  1.30714983e-01f, -2.29337402e-02f, -1.48206949e-01f, -3.46319862e-02f, -5.11226617e-02f, 4.81577478e-02f, 2.27973193e-01f, 1.60773713e-02f, 1.48786992e-01f, 1.07794674e-03f,
  4.37556915e-02f, -1.29544884e-01f, -8.13460797e-02f, 1.22995846e-01f, 6.26492426e-02f, 3.30127366e-02f, 3.77566018e-03f, 9.31885652e-03f, 1.98420569e-01f, -2.51817107e-01f,
  -1.11675702e-01f, -4.10213880e-03f, 7.53242895e-03f, 4.97422554e-02f, 4.83783334e-02f, 8.66168365e-02f, -1.40091494e-01f, -1.09923802e-01f, 7.86566287e-02f, -1.62595958e-01f,
  1.16148181e-01f, -1.05196141e-01f, -1.31199434e-01f, -1.14983298e-01f, 7.07252696e-02f, 6.20964170e-03f, 1.14784352e-01f, 1.07919395e-01f, -4.02655862e-02f, -5.77115901e-02f,
  -2.09986523e-01f, -3.24040949e-02f, 1.72863156e-01f, 5.23356684e-02f, 5.32947294e-02f, -7.72568733e-02f, -3.04626375e-01f, 1.10471517e-01f, 6.60969466e-02f, 1.77004516e-01f,
  -1.41989544e-01f, -5.15435934e-02f, -5.39935268e-02f, 1.43235326e-01f, 4.73533124e-02f, -1.56565458e-02f, -8.49885270e-02f, 2.20415033e-02f, 2.03375630e-02f, 3.79388034e-02f,
  6.06772350e-03f, 1.19359605e-01f, -1.59941047e-01f, -7.07190437e-03f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.54579328e-02f, 1.12109773e-01f, 3.26690733e-01f, 2.14504451e-02f, 3.36255550e-01f, 4.86241169e-02f, 4.44539711e-02f, 4.02487330e-02f, -2.91493654e-01f, -2.12260947e-01f,
  4.40720953e-02f, 4.21830624e-01f, -8.37552473e-02f, 1.10946596e-01f, 4.99906577e-02f, -8.40135589e-02f, 2.53813744e-01f, -4.15962934e-02f, 9.76709574e-02f, 4.82096197e-03f,
  1.91647798e-01f, 6.95768073e-02f, -5.11413924e-02f, 2.44045243e-01f, -2.75894642e-01f, -6.13919459e-02f, 1.03370138e-01f, 5.18693551e-02f, 2.92777807e-01f, -2.75650229e-02f,
  -2.15614974e-01f, -2.00465664e-01f, 1.14110537e-01f, 9.73006412e-02f, -1.40760019e-01f, 2.11917400e-01f, -2.18952358e-01f, -5.97934611e-02f, 1.24429978e-01f, 3.05068135e-01f,
  -9.17195529e-02f, -1.24019079e-01f, 2.66468562e-02f, -1.53987661e-01f, 3.42199691e-02f, 5.70342094e-02f, 1.15987152e-01f, 1.15480423e-01f, 1.23571955e-01f, 4.24365550e-02f,
  5.49320690e-03f, 1.66648120e-01f, 1.22080520e-01f, -2.43146569e-02f, -2.53594637e-01f, 1.53356075e-01f, 4.35326248e-02f, -3.15886289e-02f, 1.65838122e-01f, -9.31159481e-02f,
  1.38497338e-01f, 7.52067789e-02f, 2.35520732e-02f, 1.26211733e-01f, -6.47963304e-03f, -2.02136770e-01f, -2.09816977e-01f, -2.59455264e-01f, -3.65131982e-02f, -1.25023320e-01f,
  2.36568168e-01f, 1.05023220e-01f, 2.71974653e-01f, -4.26308997e-02f, -1.62833333e-01f, -1.62626356e-01f, -1.05736107e-02f, -8.94255117e-02f, -4.86703264e-03f, 6.08182959e-02f,
  -3.52019034e-02f, 6.58273976e-03f, 3.87577377e-02f, -1.49488300e-01f, 1.45427451e-01f, -1.19702525e-01f, -1.23171158e-01f, -1.21962307e-02f, -4.85130735e-02f, 6.23661652e-02f,
  -8.59529078e-02f, 9.32366848e-02f, -5.28429523e-02f, 1.33436158e-01f, 2.01049760e-01f, 1.25447912e-02f, 8.77826735e-02f, 7.05722347e-02f, -8.76479596e-02f, 8.98117349e-02f,
  1.26579866e-01f, 7.34137744e-02f, -8.85709524e-02f, 1.83253765e-01f, -6.90980032e-02f, 4.86783125e-02f, -6.23264257e-03f, 7.70335868e-02f, -2.59169161e-01f, -2.21791342e-02f,
  8.36174414e-02f, 1.88502386e-01f, 1.43570185e-01f, 2.15747520e-01f, 1.32820845e-01f, -2.22389363e-02f, -1.93434358e-01f, -1.65011451e-01f, 4.89871837e-02f, -1.57007501e-01f,
  2.08134070e-01f, 1.44284740e-01f, -2.26175622e-03f, 1.46369219e-01f, -6.94323033e-02f, 2.40476102e-01f, 1.23636723e-01f, -5.25457896e-02f, 2.03811064e-01f, -1.21438339e-01f,
  -6.38017654e-02f, 5.79207800e-02f, 2.74097025e-01f, 4.91573922e-02f, -2.49628738e-01f, 2.78927058e-01f, -1.17098488e-01f, 1.22644849e-01f, 1.82577997e-01f, -3.84045750e-01f,
  2.01675922e-01f, 1.71389610e-01f, 4.26855721e-02f, 2.06830874e-01f, -6.70815781e-02f, 1.04721583e-01f, 8.29171315e-02f, 2.19441473e-01f, 1.81631707e-02f, -1.18576601e-01f,
  2.46195555e-01f, 1.51274905e-01f, 2.24420335e-02f, 1.36041224e-01f, 1.28975838e-01f, -1.82178885e-01f, 4.76658083e-02f, 1.29411593e-01f, 1.18495248e-01f, 2.63513505e-01f,
  -9.61580276e-02f, 1.07218347e-01f, 1.10641494e-02f, -1.24288782e-01f, 4.18562070e-02f, -4.10423838e-02f, 1.40011892e-01f, -1.68224767e-01f, 2.61877570e-03f, 1.18878614e-02f,
  2.10615292e-01f, 2.69805998e-01f, 1.01443976e-01f, 7.64665380e-02f, 2.61647671e-01f, 4.20385599e-02f, -2.74273269e-02f, 2.71202236e-01f, -2.11745143e-01f, -1.68072388e-01f,
  -8.49856213e-02f, 8.36291388e-02f, -4.34633531e-02f, 1.59323364e-01f, 4.41665016e-02f, 1.29667312e-01f, -9.92149785e-02f, -1.86462209e-01f, 3.86435181e-01f, 1.62380993e-01f,
  -2.21431524e-01f, 1.10933527e-01f, 1.83368772e-01f, -2.99992830e-01f, -1.18095905e-01f, -1.61574528e-01f, 1.04753271e-01f, 3.19325849e-02f, 1.00561902e-01f, 1.56596482e-01f,
  -4.22481485e-02f, -6.93471134e-02f, 6.30701333e-02f, -2.48522028e-01f, -8.64590034e-02f, 8.06964114e-02f, 6.93515763e-02f, 4.91714999e-02f, 1.48999900e-01f, -1.29506551e-03f,
  -7.64281005e-02f, -9.49362013e-03f, -1.22009896e-01f, -8.66131037e-02f, 2.04476640e-01f, 6.16638958e-02f, 9.93006602e-02f, 2.73984093e-02f, -1.76774641e-03f, 5.00326604e-03f,
  -1.14291213e-01f, 2.84524597e-02f, 1.80433653e-02f, -1.22531593e-01f, -1.46385640e-01f, 5.58378138e-02f, 4.24001180e-02f, 7.88220689e-02f, 1.24006897e-01f, -8.19957778e-02f,
  -1.05513424e-01f, -1.19470663e-01f, -1.31568402e-01f, 1.60681114e-01f, 1.34531081e-01f, 2.00514913e-01f, -5.40803075e-02f, 1.46455035e-01f, -1.01811253e-01f, -1.13777779e-02f,
  1.19487613e-01f, 1.06431767e-01f, 3.96984071e-02f, 9.64651164e-03f, -5.83278313e-02f, 1.28690302e-01f, 1.61266863e-01f, 1.11483067e-01f, 2.88496185e-02f, 1.42315075e-01f,
  -1.41897708e-01f, 9.38804522e-02f, 2.89893359e-01f, 8.33982080e-02f, -1.10319205e-01f, -1.64878257e-02f, -9.76159424e-02f, 4.15713042e-02f, 1.38402283e-01f, 5.01880050e-02f,
  1.02672115e-01f, 1.78355113e-01f, 2.44240358e-01f, -1.09793646e-02f, 8.58829531e-04f, 7.15472996e-02f, -1.28943041e-01f, 3.74051295e-02f, -7.21989870e-02f, 1.11907370e-01f,
  -1.19538486e-01f, 6.59318939e-02f, 9.55013558e-02f, 1.03355378e-01f, 1.45932198e-01f, 2.50625491e-01f, -8.90044719e-02f, -9.38830338e-03f, 1.86005399e-01f, 2.22585335e-01f,
  1.32350579e-01f, 3.90222520e-02f, 1.39043257e-01f, -1.34064183e-01f, 1.35376588e-01f, 5.27143804e-03f, -1.18446738e-01f, -2.31289253e-01f, 1.81140706e-01f, 6.93926588e-02f,
  1.36342928e-01f, 2.58476138e-02f, 2.06883848e-02f, -5.03877513e-02f, -4.61987890e-02f, -8.19291398e-02f, 3.01803220e-02f, 1.56359687e-01f, 2.33521275e-02f, 1.45459563e-01f,
  4.25018817e-02f, 1.62681982e-01f, -7.28650987e-02f, -1.47085354e-01f, 1.34789795e-02f, 1.89350605e-01f, -6.60342202e-02f, -3.25171463e-02f, -9.33406726e-02f, 2.84793973e-01f,
  -6.16468452e-02f, 1.03724087e-02f, -2.34666169e-01f, -4.42441553e-02f, -1.71889082e-01f, 7.57824108e-02f, 1.64758801e-01f, -1.92569420e-01f, -1.44517664e-02f, 2.08462011e-02f,
  2.39134878e-01f, -8.33856910e-02f, 7.41100684e-02f, -8.01331364e-03f, 1.15636870e-01f, 8.30146372e-02f, -1.24947920e-01f, 2.30651334e-01f, -2.54482955e-01f, -5.70197962e-02f,
  2.09150463e-01f, -1.81792825e-02f, 3.61011401e-02f, 2.15081219e-02f, -1.02117240e-01f, 7.74757564e-02f, 9.80743468e-02f, -1.01034008e-01f, -8.11480358e-02f, 2.92335749e-01f,
  -5.70764542e-02f, -1.86407223e-01f, 3.27965766e-01f, 1.47512063e-01f, 1.00037359e-01f, -4.47047688e-02f, -1.55551493e-01f, -1.80453226e-01f, 1.80702116e-02f, -1.36547051e-02f,
  3.34314704e-02f, 1.96395535e-02f, -1.99947935e-02f, 7.66720399e-02f, 1.26742095e-01f, 1.44867837e-01f, 6.66745380e-02f, -1.19063631e-01f, 6.22750968e-02f, -1.21282272e-01f,
  1.03865527e-01f, -6.88543683e-03f, 1.78055912e-01f, 2.48181418e-01f, 1.56746253e-01f, 7.77965933e-02f, 3.25076170e-02f, -4.63882536e-02f, -8.54002777e-03f, -1.01697788e-01f,
  1.13190256e-01f, 1.33852661e-01f, -1.09303184e-01f, 1.11357741e-01f, 8.49395171e-02f, 3.20787914e-03f, 6.42355382e-02f, 9.01756585e-02f, -9.49490741e-02f, 1.80480164e-02f,
  2.23458201e-01f, -4.08718083e-03f, -2.47199163e-02f, 5.84007688e-02f, 2.41180733e-01f, 1.43683597e-01f, 2.50806361e-01f, 1.07514232e-01f, 1.56623527e-01f, 1.80244058e-01f,
  -2.19488773e-03f, 1.56102985e-01f, -1.55284137e-01f, -1.85635030e-01f, -6.17341883e-02f, 8.64470080e-02f, 2.46552099e-02f, 2.24269167e-01f, 2.52655327e-01f, 1.41461208e-01f,
  -8.90194848e-02f, 3.30403507e-01f, 2.14546412e-01f, -5.22005314e-04f, 2.02852905e-01f, 2.84567088e-01f, 9.23217982e-02f, 1.77037716e-01f, -1.21220209e-01f, 1.19572654e-01f,
  2.80765623e-01f, 1.75606713e-01f, -8.41973275e-02f, 6.97045624e-02f, 9.46208611e-02f, 8.62527937e-02f, -1.99016199e-01f, 2.37593308e-01f, 6.64410274e-03f, -1.51537389e-01f,
  1.57038361e-01f, 5.81949726e-02f, 4.73058373e-02f, 1.32783562e-01f, -2.12934226e-01f, -7.72915855e-02f, 1.78611621e-01f, -3.69432420e-02f, -4.16836217e-02f, 2.14974523e-01f,
  2.38101274e-01f, -7.97401890e-02f, 8.95199180e-02f, 1.34803906e-01f, -1.19279906e-01f, -1.53613538e-01f, 1.47909343e-01f, 9.74607989e-02f, -1.19570419e-01f, 2.90763140e-01f,
  -8.35663527e-02f, 1.96894646e-01f, 9.76253599e-02f, -1.74701676e-01f, 3.05335462e-01f, -1.47314295e-01f, 1.40944188e-02f, 1.02272280e-01f, 2.09441721e-01f, -4.59190756e-02f,
  -7.55560026e-02f, 2.58078903e-01f, 1.13125406e-01f, 3.87786403e-02f, -3.27992201e-01f, 2.71085590e-01f, -5.98142266e-01f, -1.40472949e-01f, 4.83565062e-01f, 2.17600361e-01f,
  -1.53480589e-01f, 1.91837326e-01f, -2.57082999e-01f, -3.35157737e-02f, -1.79017857e-01f, 2.59521119e-02f, -2.30589435e-02f, -3.83648872e-02f, 7.16825873e-02f, -1.13615282e-02f,
  4.45354320e-02f, 1.75964758e-01f, 9.93193686e-03f, -2.47822940e-01f, 1.20719098e-01f, 1.15254164e-01f, 2.55314797e-01f, 1.25106364e-01f, 1.20272703e-01f, -1.64201617e-01f,
  -2.38011211e-01f, -1.10188141e-01f, -6.16106316e-02f, 6.78794384e-02f, 1.76292002e-01f, -1.25746489e-01f, 1.43141747e-01f, -2.43557185e-01f, -2.25941509e-01f, -2.17441037e-01f,
  1.76229551e-01f, 1.46118581e-01f, -1.20623454e-01f, -7.03718215e-02f, 1.97930500e-01f, 1.13303587e-02f, -1.91043153e-01f, 9.47913080e-02f, -2.38567516e-01f, 1.22573502e-01f,
  1.64132580e-01f, -1.24346074e-02f, -5.78880236e-02f, 1.20592721e-01f, -1.10014377e-03f, -3.44489366e-02f, 2.47733176e-01f, -1.09287374e-01f, 2.47394502e-01f, -1.00878790e-01f,
  7.69813806e-02f, 1.67551845e-01f, 2.19862327e-01f, -4.19960693e-02f, 1.81852758e-01f, 1.07053854e-02f, 1.89572245e-01f, 1.05461814e-01f, -2.16292664e-01f, 2.15337142e-01f,
  -1.49231017e-01f, -2.54979506e-02f, -5.48924133e-02f, -1.22985497e-01f, 1.84686817e-02f, 4.03266139e-02f, 8.10200945e-02f, 6.15783781e-02f, -8.61352717e-04f, 7.11559802e-02f,
  -6.39665127e-02f, 1.55068040e-01f, 1.13450855e-01f, 5.91380522e-02f, 1.64111093e-01f, -7.79135386e-03f, 1.43879745e-02f, -1.10777333e-01f, -1.27628282e-01f, 9.58413631e-03f,
  3.82559560e-02f, -1.00199834e-01f, 6.67430088e-02f, -1.78828627e-01f, -2.78398283e-02f, 1.59027696e-01f, 1.15015395e-01f, 9.68645439e-02f, 9.10102203e-02f, -1.99652947e-02f,
  1.62421927e-01f, 1.19350269e-01f, -5.83156496e-02f, -3.76584902e-02f, 1.62123233e-01f, 9.44724679e-02f, 5.96184134e-02f, 1.54315919e-01f, 3.38056758e-02f, 1.66573301e-01f,
  1.96009893e-02f, -4.08046767e-02f, -1.93138152e-01f, -8.00496116e-02f, -1.21905364e-01f, 8.68598148e-02f, -5.06692640e-02f, 3.63616981e-02f, -1.75757874e-02f, -5.39315641e-02f,
  -5.52608781e-02f, -1.95248261e-01f, 1.44016042e-01f, 4.50479127e-02f, -9.25897062e-03f, 1.27651215e-01f, 6.76926877e-03f, -3.68570745e-01f, -3.79386127e-01f, -4.45725322e-02f,
  -1.10375158e-01f, -8.63151029e-02f, 2.30310366e-01f, 1.09475836e-01f, -2.25408182e-01f, -4.55718338e-02f, 1.32185459e-01f, -3.13978404e-01f, 1.22619249e-01f, 5.82817523e-03f,
  -6.65260851e-02f, -1.10631481e-01f, -4.96085174e-02f, 2.22808063e-01f, -8.31117034e-02f, -3.13988775e-02f, -9.59564000e-03f, -1.55066922e-01f, 1.04200080e-01f, -9.60252993e-03f,
  1.61631048e-01f, -3.64218354e-02f, -2.51649674e-02f, -1.04352394e-02f, 6.87891617e-02f, -4.61539775e-02f, 1.47612438e-01f, -9.73440930e-02f, 5.41787148e-02f, 1.67523995e-02f,
  -1.36328535e-03f, 1.71259522e-01f, 2.35074997e-01f, 1.19484313e-01f, 1.18135639e-01f, -9.86963436e-02f, -1.98226556e-01f, 3.55921164e-02f, 2.24584285e-02f, 1.78489283e-01f,
  -3.04026082e-02f, -1.02704607e-01f, -1.29829317e-01f, 2.04275280e-01f, -7.07703531e-02f, 2.21321926e-01f, 1.51261285e-01f, 3.63786072e-02f, 7.65754282e-02f, 8.44797567e-02f,
  7.94493034e-02f, -6.38053101e-03f, 1.57968909e-01f, 6.27222285e-02f, 2.43042782e-02f, 2.13866651e-01f, 7.91786090e-02f, 3.22605133e-01f, 1.70444399e-01f, -7.54740909e-02f,
  -5.47917560e-02f, 2.19529033e-01f, 2.17934057e-01f, -1.37440234e-01f, 1.69345081e-01f, 1.46397218e-01f, -1.58903599e-01f, 1.38175294e-01f, 2.97161460e-01f, -1.63388863e-01f,
  -3.98707956e-01f, 8.61211941e-02f, 3.59578170e-02f, -2.25529652e-02f, 2.97812700e-01f, -3.71819772e-02f, 5.75704277e-02f, 1.48952439e-01f, 1.90418974e-01f, 2.25365743e-01f,
  2.48537287e-01f, 3.11600059e-01f, 1.83331067e-05f, -1.37139991e-01f, -1.34106800e-01f, 7.25527108e-02f, 1.96298003e-01f, -2.40911879e-02f, 3.87257822e-02f, 1.44562259e-01f,
  -1.09759094e-02f, 2.60262340e-01f, 1.13680251e-01f, 1.75384685e-01f, 2.66293973e-01f, 2.99610775e-02f, -4.62250412e-02f, 1.99154802e-02f, 1.63794428e-01f, 2.80337572e-01f,
  2.03115374e-01f, -7.85915405e-02f, 2.19023544e-02f, 3.54457051e-02f, 3.68095189e-02f, 1.03876062e-01f, 3.31270903e-01f, 1.81134958e-02f, -9.64513198e-02f, -1.24096841e-01f,
  -1.91285804e-01f, -1.43953726e-01f, -2.80037194e-01f, 4.49464954e-02f, -3.65774594e-02f, -2.00494096e-01f, -4.12931032e-02f, -1.01252094e-01f, 8.46465006e-02f, -1.19375348e-01f,
  7.66828060e-02f, -8.18844661e-02f, 1.20191477e-01f, 5.80455028e-02f, 1.65712778e-02f, 5.60572278e-03f, 4.57841307e-02f, 2.43605915e-02f, 7.26372153e-02f, -2.96452064e-02f,
  3.99478793e-01f, -1.90061182e-01f, 8.93416479e-02f, 7.99596980e-02f, -7.12914169e-02f, 6.95153549e-02f, -2.77514998e-02f, 4.22122627e-02f, -3.63318399e-02f, 2.79569123e-02f,
  2.70060986e-01f, 8.45655650e-02f, 1.06487334e-01f, -2.35964030e-01f, -1.88435197e-01f, -1.46948904e-01f, -2.67990530e-01f, 6.64305612e-02f, 9.18754116e-02f, 1.73844576e-01f,
  -3.10603548e-02f, 2.87645280e-01f, -1.15424514e-01f, 1.34214282e-01f, 5.90338334e-02f, -2.27649584e-02f, 4.64453958e-02f, 4.71262373e-02f, -1.32163957e-01f, 1.32978380e-01f,
  5.40791079e-04f, 8.94909054e-02f, -2.74235845e-01f, 9.03178975e-02f, -1.72797024e-01f, 1.79271474e-01f, -8.99665207e-02f, -6.50678799e-02f, -3.40657294e-01f, 1.64206117e-01f,
  -1.33633554e-01f, -1.05848506e-01f, 1.12028219e-01f, 7.48189241e-02f, 2.64470339e-01f, 3.20694238e-01f, 1.93454519e-01f, -2.02044606e-01f, 7.13616312e-02f, -2.43914519e-02f,
  1.16688788e-01f, 1.77663922e-01f, 2.12499827e-01f, 3.46064903e-02f, -9.45257843e-02f, 1.87611163e-01f, -8.90581831e-02f, -8.48823190e-02f, 2.26749212e-01f, -1.78361565e-01f,
  -2.40553901e-01f, 2.67281711e-01f, -1.58237889e-01f, -9.11050737e-02f, 7.75275454e-02f, 1.20673165e-01f, -3.00371826e-01f, 3.19277383e-02f, 3.22614521e-01f, -1.07905366e-01f,
  -2.16528460e-01f, -9.99434665e-03f, -2.25222975e-01f, -1.95867810e-02f, 3.93042602e-02f, -2.93098651e-02f, 1.55720294e-01f, -2.43481621e-01f, -5.46613447e-02f, -1.17036521e-01f,
  1.05461627e-01f, 2.05951855e-01f, 1.09116308e-01f, -2.51426194e-02f, 3.97542939e-02f, 5.85685447e-02f, 2.14345291e-01f, 9.64348763e-02f, 1.96463257e-01f, -1.91581324e-01f,
  8.65013227e-02f, -1.21693626e-01f, -2.15580568e-01f, 1.04657546e-01f, 1.72420144e-01f, 1.27921745e-01f, -3.62111703e-02f, -2.31976777e-01f, -3.50528330e-01f, -7.19529390e-02f,
  7.89843723e-02f, 3.77819762e-02f, -1.84473753e-01f, 4.39039767e-02f, -1.42896533e-01f, 1.10492654e-01f, -4.17633504e-02f, 1.91458538e-01f, -3.14003900e-02f, 1.42089069e-01f,
  4.46360670e-02f, 1.45258427e-01f, 6.81229234e-02f, 1.35196880e-01f, 1.08780198e-01f, 1.68090403e-01f, 1.34003818e-01f, 9.66099352e-02f, -6.15932513e-03f, 3.55103351e-02f,
  -2.77696270e-02f, 9.87262093e-03f, 2.60105520e-01f, 3.11900843e-02f, 2.25772172e-01f, 2.62871772e-01f, 1.65691629e-01f, 1.90747939e-02f, -4.37907010e-01f, 1.47547066e-01f,
  -2.62661874e-01f, -8.60731769e-03f, 2.64302164e-01f, -1.61540061e-01f, 1.28464252e-01f, 7.21694380e-02f, -2.55024503e-03f, 2.48724017e-02f, 1.09159172e-01f, -3.19675319e-02f,
  -1.99333485e-03f, 2.45285079e-01f, -1.42934844e-01f, 5.44443950e-02f, 2.97962934e-01f, 1.62248723e-02f, -6.22315891e-02f, -1.20847791e-01f, 1.93422120e-02f, -1.60647705e-02f,
  1.54131532e-01f, -2.93973163e-02f, 7.01917754e-03f, 2.04532444e-01f, 2.22066659e-02f, 6.23924136e-02f, 5.11920042e-02f, 2.12462489e-02f, 1.31681621e-01f, -1.35213792e-01f,
  9.84623581e-02f, -1.31544724e-01f, 2.74616450e-01f, -1.39255628e-01f, 1.95662975e-01f, 2.31894404e-02f, 2.98705548e-01f, 1.86051130e-01f, -4.26185094e-02f, 1.13251783e-01f,
  -1.11302689e-01f, -7.98118263e-02f, -2.52667308e-01f, -1.26007032e-02f, 7.56846294e-02f, 1.21086180e-01f, -5.10418862e-02f, 2.39229590e-01f, 1.73469871e-01f, 7.70688951e-02f,
  -1.83983043e-01f, -1.40867010e-01f, 1.65900782e-01f, 8.46265107e-02f, -1.25562698e-01f, -1.42801832e-02f, 1.60915136e-01f, 1.29864305e-01f, 8.63771364e-02f, 1.67683899e-01f,
  2.51516071e-03f, 1.10143051e-01f, 4.33011465e-02f, -1.06080659e-01f, 9.10816062e-03f, 1.10886127e-01f, -5.13226390e-02f, 8.51052701e-02f, -4.83595394e-02f, -1.14991546e-01f,
  -1.07827745e-01f, -3.70765058e-03f, -1.85217410e-02f, 1.25115693e-01f, -2.26001769e-01f, 1.11833252e-01f, -6.90593496e-02f, 3.89364846e-02f, 1.56758204e-01f, 3.35713066e-02f,
  2.76266843e-01f, -3.52425389e-02f, -5.00572026e-02f, 1.34526253e-01f, 4.78505939e-02f, 7.56814182e-02f, 1.40156597e-01f, -1.57079488e-01f, 1.05917312e-01f, -1.89703852e-01f,
  1.16807304e-01f, 1.60251811e-01f, -3.00768781e-02f, 4.66648536e-03f, -1.96264520e-01f, -5.20884432e-02f, 2.46637105e-03f, 1.80315092e-01f, -1.14772275e-01f, 1.07388049e-01f,
  -1.86034553e-02f, 1.10100716e-01f, -1.46715254e-01f, -1.62269697e-01f, 4.18841168e-02f, -2.26781055e-01f, 1.45781025e-01f, 2.78450679e-02f, 4.99069840e-02f, 1.46110445e-01f,
  1.79366529e-01f, 2.24988554e-02f, -2.23683670e-01f, -2.30115298e-02f, -8.38197244e-04f, 7.41143823e-02f, -1.32519538e-02f, -2.01342076e-01f, 2.07728609e-01f, -1.30177453e-01f,
  -2.02990938e-02f, 1.21860698e-01f, 1.92767128e-01f, 2.19522119e-01f, 1.88444048e-01f, -2.04549339e-02f, -5.83963133e-02f, -1.02907382e-01f, -2.07161948e-01f, -7.82298148e-02f,
  3.35071862e-01f, 4.56824042e-02f, 1.98536143e-01f, 1.40631631e-01f, -1.51729330e-01f, -7.18462691e-02f, -1.37610778e-01f, 6.56484440e-02f, -1.82679713e-01f, 1.07700452e-01f,
  2.57644266e-01f, -6.07073829e-02f, 5.48762083e-02f, 9.59939137e-02f, -1.54030100e-01f, -9.06246454e-02f, 2.11743906e-01f, 8.86408836e-02f, 5.99739626e-02f, 1.74708351e-01f,
  -1.17485046e-01f, 2.88412750e-01f, -2.69921839e-01f, -1.77355587e-01f, -2.26121228e-02f, -1.99672669e-01f, -1.41961157e-01f, -2.27339938e-01f, -7.13095888e-02f, -1.39068693e-01f,
  1.20256133e-01f, -9.99017209e-02f, 5.19224405e-02f, 9.49459150e-02f, 1.67821169e-01f, 3.59885283e-02f, 2.08387628e-01f, -1.19396254e-01f, -1.41984180e-01f, -1.59117192e-01f,
  -6.04847781e-02f, 1.98552772e-01f, 1.11458160e-01f, -1.35442317e-01f, -1.60407916e-01f, 1.73986420e-01f, 3.42611410e-02f, -1.78660586e-01f, 2.21581250e-01f, -3.07707161e-01f,
  1.08114220e-01f, 5.58745349e-04f, -5.46978302e-02f, 1.83424458e-01f, -1.21950753e-01f, 2.39604950e-01f, 1.83103010e-01f, -3.77899781e-02f, -9.50751267e-03f, 4.74269912e-02f,
  -2.38269977e-02f, 1.01234213e-01f, 3.35801423e-01f, 7.64058605e-02f, -4.31586951e-01f, 9.96238086e-03f, 1.54467613e-01f, -5.04187122e-03f, 1.22344596e-02f, -4.69068028e-02f,
  -6.13661529e-03f, 6.51645660e-02f, 6.13771975e-02f, 1.31079614e-01f, 1.76888421e-01f, 1.18298516e-01f, -5.10237105e-02f, 4.49301712e-02f, 1.85840234e-01f, 1.38055086e-01f,
  -9.89644229e-03f, 1.10130049e-01f, -2.35502310e-02f, 1.83081642e-01f, 1.59404010e-01f, 2.70384341e-01f, 2.45949533e-03f, 1.21046081e-01f, 2.39523515e-01f, 6.37075752e-02f,
  4.67423648e-02f, 7.78416917e-02f, 5.82845397e-02f, 1.08476311e-01f, 1.17955141e-01f, 1.45947456e-01f, -1.99011713e-01f, 3.70914792e-03f, 8.62447359e-03f, 1.65245429e-01f,
  1.29164159e-01f, 7.22404616e-03f, 2.14080922e-02f, 1.09143235e-01f, -6.37913530e-04f, -1.47153303e-01f, -1.67258680e-01f, 6.88162744e-02f, 2.29243143e-03f, -1.92442954e-01f,
  -2.38814086e-01f, -7.85142109e-02f, -6.86448291e-02f, 1.08838730e-01f, 8.82197451e-03f, -1.48345113e-01f, 1.56223178e-01f, 4.36159223e-02f, 9.12785679e-02f, -9.21036524e-04f,
  1.23262368e-01f, 1.67429164e-01f, 4.12318558e-02f, 1.30636645e-02f, -6.63490966e-02f, -2.09954068e-01f, -1.69146165e-01f, -1.09203033e-01f, 1.99111268e-01f, 2.82342844e-02f,
  2.25104585e-01f, -4.27606814e-02f, -2.98071969e-02f, -1.14184305e-01f, 7.16286004e-02f, -1.15193697e-02f, -2.60636240e-01f, -8.59327614e-02f, 2.54490942e-01f, -8.03968385e-02f,
  -9.31280777e-02f, -9.68722701e-02f, -1.02547891e-01f, -6.95419461e-02f, -1.97469350e-02f, 2.55514234e-01f, 1.20146431e-01f, -1.45776682e-02f, -8.12499449e-02f, 2.23462239e-01f,
  -1.17542185e-01f, 3.71257067e-02f, 4.83394265e-02f, -6.30884618e-02f, -1.20487675e-01f, 4.07106476e-03f, 2.80400924e-02f, -5.01924716e-02f, 1.41035706e-01f, -1.39780836e-02f,
  -1.09072492e-01f, -7.30417669e-02f, -2.56688502e-02f, 1.32242873e-01f, 2.36164138e-01f, 7.97269717e-02f, 3.68965119e-02f, -1.40621364e-01f, -1.92614738e-02f, 2.70611852e-01f,
  6.80766478e-02f, -7.41109177e-02f, -6.70775399e-02f, -9.65216104e-03f, 1.75882146e-01f, 3.37714106e-02f, 6.17150739e-02f, -1.23284407e-01f, 8.68203118e-02f, 4.78940010e-02f,
  3.72946598e-02f, 1.25746325e-01f, 8.41365848e-03f, -4.84583229e-02f, -1.40252486e-02f, -1.02164783e-01f, 4.35354263e-02f, 2.95573901e-02f, -5.30772246e-02f, 7.96749163e-03f,
  4.77968231e-02f, 1.09322868e-01f, -4.46612313e-02f, 6.47689924e-02f, 4.41571549e-02f, -7.30956420e-02f, -1.07231177e-01f, 1.10257633e-01f, 1.22834720e-01f, -7.23023638e-02f,
  -1.41934246e-01f, 2.51366735e-01f, 1.81224570e-02f, -1.46347255e-01f, 2.11717606e-01f, 9.55925975e-03f, 7.00618029e-02f, -2.20502093e-02f, -6.22603185e-02f, 1.29128158e-01f,
  -9.58104357e-02f, -1.34217944e-02f, 9.39444080e-02f, -9.76695865e-02f, -3.38498130e-03f, -5.56461215e-02f, 1.48383826e-01f, 1.86361402e-01f, -7.28071928e-02f, -1.04453169e-01f,
  2.26767119e-02f, -1.73381194e-01f, 1.53689370e-01f, 2.01327205e-01f, 5.56682982e-02f, 8.81993864e-03f, -1.47707146e-02f, 8.22070241e-02f, -1.97438374e-02f, 5.66306859e-02f,
  3.26889381e-02f, -2.15975139e-02f, 1.02392614e-01f, 6.93363473e-02f, -1.15473486e-01f, -2.45008785e-02f, 1.70539364e-01f, -1.41614169e-01f, 7.53609538e-02f, -8.41189995e-02f,
  -5.75466231e-02f, 6.00186437e-02f, -1.68905146e-02f, 5.34836855e-03f, 1.79882884e-01f, -4.00251932e-02f, 7.52181485e-02f, 2.05586150e-01f, 7.01446161e-02f, 2.51324207e-01f,
  2.17719316e-01f, 4.60396595e-02f, 1.07398339e-01f, -1.31056696e-01f, -1.35874987e-01f, 3.52975838e-02f, 2.70181209e-01f, 2.58210123e-01f, -4.30498049e-02f, -4.52586710e-02f,
  -1.54351085e-01f, -9.98649001e-02f, -1.21304924e-02f, 2.68640649e-02f, -3.07554632e-01f, 1.96173087e-01f, -3.52171324e-02f, -9.87430196e-03f, -7.43457228e-02f, -1.08613551e-01f,
  3.11081082e-01f, -1.67390466e-01f, 9.51037928e-02f, 1.62040010e-01f, 1.11935280e-01f, 1.26472980e-01f, 1.16373405e-01f, 5.81859425e-02f, -2.40460306e-01f, -3.19047064e-01f,
  2.40403399e-01f, -2.50818208e-02f, 4.00827937e-02f, 5.54274805e-02f, 5.42572774e-02f, -2.45892897e-01f, 5.42885214e-02f, 3.72571796e-02f, -1.99526027e-01f, 4.70289076e-03f,
  2.82448065e-02f, 3.53029929e-02f, 1.31230131e-01f, 1.26923040e-01f, -9.90422368e-02f, -3.50684047e-01f, -1.60069857e-02f, 7.19495714e-02f, 3.20848703e-01f, 3.84515934e-02f,
  1.62996888e-01f, 6.37580901e-02f, -8.80543739e-02f, -2.61024177e-01f, 1.07661650e-01f, -6.65795803e-02f, -3.04981004e-02f, -8.87527410e-03f, 1.65127993e-01f, -5.47062047e-02f,
  2.23313440e-02f, -1.44552365e-01f, -2.14640826e-01f, 1.12146921e-01f, -1.90021649e-01f, -7.22616836e-02f, 5.39303906e-02f, 1.65522397e-02f, 6.67217150e-02f, -3.05729043e-02f,
  6.66618273e-02f, -2.29620203e-01f, -8.15050825e-02f, -1.61228985e-01f, 1.16473511e-01f, 7.06488863e-02f, 1.21267609e-01f, 2.91220635e-01f, 9.35092047e-02f, -2.43761703e-01f,
  -2.31052060e-02f, 1.28183350e-01f, -6.17797710e-02f, 1.40323713e-01f, 8.75601768e-02f, 3.66000645e-02f, 3.66006382e-02f, 2.28171684e-02f, -2.02295668e-02f, 2.02253476e-01f,
  2.66548634e-01f, -2.12558821e-01f, -1.55153153e-02f, 1.00027844e-01f, 8.44091028e-02f, -3.95023935e-02f, 1.03611968e-01f, 2.73478031e-01f, -7.23962765e-03f, 1.78421885e-01f,
  -2.68104315e-01f, 1.35340367e-03f, -1.33812902e-02f, 8.40889513e-02f, -1.67093575e-01f, 1.30779343e-02f, -2.18376607e-01f, 1.30177751e-01f, 4.90907021e-02f, 9.43734422e-02f,
  -2.66633239e-02f, 2.21048966e-02f, -4.97264192e-02f, -8.40250961e-03f, 2.10325107e-01f, 9.41421241e-02f, 7.14152455e-02f, 2.38341391e-01f, -2.74148192e-02f, -1.25243906e-02f,
  -9.11766961e-02f, 1.93892017e-01f, 3.55332904e-02f, -2.24961750e-02f, 5.88107482e-02f, 1.18742876e-01f, -6.21832386e-02f, 2.23549813e-01f, -1.90245777e-01f, 5.27695869e-04f,
  2.47822516e-02f, -2.62394045e-02f, 7.65861990e-03f, -9.02965292e-02f, -1.30908266e-02f, 2.03573316e-01f, 1.10676274e-01f, -2.28669584e-01f, 3.14700231e-02f, -1.11164354e-01f,
  7.54583478e-02f, -1.01742789e-01f, 1.41161472e-01f, 5.17851226e-02f, -6.77651837e-02f, -1.47759896e-02f, -2.02251419e-01f, 1.02388039e-01f, 3.68097069e-04f, -5.93857728e-02f,
  -1.19273387e-01f, 1.91281736e-01f, 2.05672652e-01f, 1.37971282e-01f, -4.98436242e-02f, -7.12097157e-03f, 2.99106836e-01f, 1.10591933e-01f, 6.19863532e-02f, 8.15073028e-02f,
  4.85620499e-02f, -4.35423478e-02f, 1.28455967e-01f, -7.57954270e-02f, 2.07652792e-01f, -1.26585513e-01f, -8.47291499e-02f, -1.98805511e-01f, 1.23510927e-01f, -1.11188658e-01f,
  -1.19657844e-01f, 1.27961367e-01f, 4.83393334e-02f, 6.59182742e-02f, 6.33851960e-02f, 3.67335603e-02f, -9.85168573e-03f, -7.65077472e-02f, 3.84778306e-02f, -1.27632529e-01f,
  2.53170282e-01f, -7.31328204e-02f, 2.01825231e-01f, 2.53598839e-01f, -3.18702579e-01f, 1.69587746e-01f, 3.03182840e-01f, -2.21369609e-01f, -1.84026897e-01f, 3.71735245e-01f,
  2.02415943e-01f, 8.90914202e-02f, 2.68482957e-02f, 7.27981911e-04f, 5.50781265e-02f, 8.74886438e-02f, 1.55265823e-01f, -6.92656562e-02f, -1.80981532e-01f, 3.82392883e-01f,
  2.90706637e-03f, 1.77619252e-02f, 2.14480579e-01f, 5.38596464e-03f, 9.68946815e-02f, 4.40293439e-02f, 6.20185994e-02f, 6.92149028e-02f, 1.54060557e-01f, 1.45622984e-01f,
  -8.27194899e-02f, 5.39346598e-02f, -1.21014029e-01f, -4.03906293e-02f, 1.25713333e-01f, 4.75437008e-02f, 1.29729673e-01f, 4.09378223e-02f, -1.30627528e-01f, 5.68765178e-02f,
  2.88975447e-01f, 2.47094393e-01f, 4.65323813e-02f, 2.23670140e-01f, -7.41263479e-02f, 7.07370937e-02f, 2.01872706e-01f, 3.26407105e-01f, 1.42109752e-01f, -9.90141109e-02f,
  -9.17583555e-02f, -1.75198779e-01f, 4.96901125e-02f, -6.80211633e-02f, 1.56123891e-01f, 1.16983369e-01f, -5.03971688e-02f, 3.88943520e-03f, -1.50197878e-01f, -2.19401628e-01f,
  -1.88820884e-01f, 1.72412768e-01f, -1.41958848e-01f, -2.12343439e-01f, 9.30048451e-02f, -1.25706449e-01f, 3.21101323e-02f, 1.49324546e-02f, -1.49086574e-02f, -5.79705350e-02f,
  1.05835289e-01f, 1.02043755e-01f, 1.27165234e-02f, 2.21304193e-01f, 1.19018637e-01f, 1.36163130e-01f, 9.36253518e-02f, 2.38516062e-01f, 8.15276243e-03f, -1.48932219e-01f,
  9.95985195e-02f, 1.77933007e-01f, -1.36984855e-01f, 6.06822111e-02f, 1.94337681e-01f, -1.61320031e-01f, 5.10785393e-02f, -1.24910297e-02f, 2.34204784e-01f, -3.65581736e-02f,
  -1.59778729e-01f, 2.72630334e-01f, -1.72531739e-01f, -4.59696427e-02f, 1.58781081e-01f, -4.83982749e-02f, 4.91089374e-02f, 8.28509778e-02f, -1.20965935e-01f, -2.56098863e-02f,
  -1.86549723e-02f, 3.26687619e-02f, -1.15101896e-01f, 2.57041991e-01f, -1.01500740e-02f, 1.11634880e-01f, 1.43143892e-01f, 6.74049780e-02f, -6.56760931e-02f, -3.97081971e-02f,
  6.06409321e-03f, -4.37319465e-02f, 2.80360430e-01f, 2.03681260e-01f, -6.62092790e-02f, 9.64443944e-03f, 2.06704602e-01f, 2.11469471e-01f, -1.02864690e-01f, -1.16488926e-01f,
  1.48153111e-01f, -2.74926841e-01f, 1.37819573e-01f, 6.93692565e-02f, -3.36361974e-02f, -1.47433830e-02f, 3.19192261e-02f, -3.24780233e-02f, -4.23551053e-02f, 6.83420673e-02f,
  -9.46486071e-02f, 1.21629715e-01f, -1.39897624e-02f, -1.73532397e-01f, 1.65836915e-01f, -1.00912295e-01f, -7.43346810e-02f, -5.19698225e-02f, -3.96022499e-02f, 5.86800463e-02f,
  4.12408784e-02f, -1.15462162e-01f, 6.31100237e-02f, 1.76532939e-01f, -4.26566042e-02f, -4.33993991e-03f, -1.44109845e-01f, 2.23018482e-01f, -4.03387621e-02f, -1.23696566e-01f,
  -6.33751750e-02f, -7.06040636e-02f, -3.44029092e-03f, 8.02850202e-02f, 1.11680344e-01f, 3.11109990e-01f, 1.37030005e-01f, -1.29026785e-01f, 6.98272958e-02f, 7.93339908e-02f,
  2.50066608e-01f, -3.63816507e-02f, -2.45444313e-01f, 4.64676805e-02f, 6.32041022e-02f, -8.13403279e-02f, -4.20463756e-02f, -8.65438432e-02f, 2.87600368e-01f, 1.08430222e-01f,
  1.89485922e-01f, 3.19048196e-01f, -6.73581567e-03f, -1.08170167e-01f, 1.48941323e-01f, 5.71270213e-02f, 1.36432245e-01f, 1.19257614e-01f, -1.00217186e-01f, 9.53536704e-02f,
  3.59764993e-02f, -9.23751444e-02f, 3.98463272e-02f, 1.84556559e-01f, -5.35138417e-03f, -1.10370748e-01f, -2.30922308e-02f, 6.95385709e-02f, -1.57844290e-01f, 2.58731812e-01f,
  -1.61305070e-02f, -1.92021415e-01f, -1.04548961e-01f, -2.38293409e-01f, -4.58975835e-03f, 1.28399342e-01f, -1.75054222e-01f, -8.17864686e-02f, 2.50585139e-01f, -1.23854741e-01f,
  1.56326875e-01f, 1.69103779e-02f, 1.22168712e-01f, -4.54243198e-02f, 6.52445629e-02f, -3.42825763e-02f, -7.61845708e-02f, -2.27733418e-01f, -2.15152018e-02f, 2.04950690e-01f,
  1.10493034e-01f, -1.75099507e-01f, 3.19657147e-01f, -6.30422309e-02f, -1.51210725e-01f, 2.78337467e-02f, 1.84893217e-02f, -5.62174357e-02f, -8.76277387e-02f, 1.77785411e-01f,
  -1.98743353e-03f, -2.68006027e-01f, 1.97877631e-01f, -5.03373472e-03f, 9.15022120e-02f, -8.45431313e-02f, -2.30382070e-01f, 1.14792980e-01f, 5.61377630e-02f, -8.41776952e-02f,
  7.61375278e-02f, 2.96743453e-01f, 4.17321660e-02f, -9.71399993e-02f, 1.86668068e-01f, 1.29308730e-01f, -9.14591998e-02f, -1.09636642e-01f, 8.75524133e-02f, -1.98168918e-01f,
  3.54443133e-01f, 2.35895179e-02f, -1.89485475e-02f, 1.73171863e-01f, 3.40669543e-01f, 2.31206700e-01f, -1.12044670e-01f, -5.33337407e-02f, -9.50016528e-02f, -7.37783387e-02f,
  4.14388478e-02f, 2.34017327e-01f, 2.37285092e-01f, -1.04724340e-01f, 1.43965364e-01f, 2.53181588e-02f, 3.24363887e-01f, -9.76785794e-02f, 2.60376092e-02f, 1.92386527e-02f,
  1.21508837e-01f, 5.48763350e-02f, 1.53655931e-01f, -1.99820735e-02f, -2.26603672e-02f, 3.63175124e-02f, -2.20442593e-01f, 3.42876762e-02f, -7.72984400e-02f, 3.87118533e-02f,
  -2.98470467e-01f, 2.41704613e-01f, 1.39194774e-02f, -2.87745446e-01f, -6.30785245e-03f, 2.42685243e-01f, -2.40000561e-02f, -6.92504570e-02f, 9.10326466e-02f, -9.70746577e-02f,
  -2.73163736e-01f, 2.79410958e-01f, 1.47599235e-01f, 6.58629090e-02f, 3.47943038e-01f, 1.75518245e-01f, -9.79391113e-02f, -2.15973377e-01f, -7.24730790e-02f, -1.74221933e-01f,
  1.54813200e-01f, -4.75966232e-03f, -4.00682688e-02f, 2.10360721e-01f, -3.11730616e-02f, 1.12552539e-01f, 1.96536095e-03f, 1.58937350e-01f, 1.12391807e-01f, 1.02243438e-01f,
  8.27685595e-02f, 7.52779841e-02f, 5.41856363e-02f, 9.63094458e-02f, -1.14137106e-01f, -2.04064608e-01f, -1.98240757e-01f, -5.90810813e-02f, 6.07396364e-02f, -1.10185102e-01f,
  1.83408126e-01f, 3.13084692e-01f, -1.89594448e-01f, -1.92063838e-01f, -2.32789189e-01f, -1.39301240e-01f, -6.64550066e-02f, -2.23367047e-02f, -4.06139642e-02f, -1.00148655e-01f,
  1.59584701e-01f, 5.39453477e-02f, 6.05092607e-02f, -1.44588659e-02f, -1.31302267e-01f, 9.72766206e-02f, 3.81654799e-01f, -7.86338281e-03f, 1.10849403e-01f, -4.02733199e-02f,
  -4.65829521e-02f, 1.87008095e-03f, 1.55937269e-01f, -3.85828130e-02f, 8.70046988e-02f, -2.11889565e-01f, 6.05731234e-02f, -6.57829940e-02f, 1.47283852e-01f, 8.48395899e-02f,
  3.33273895e-02f, -1.31053984e-01f, -8.29318315e-02f, -1.35558143e-01f, -1.02805540e-01f, -5.82191832e-02f, -3.74985158e-01f, 1.53555810e-01f, 1.52738933e-02f, -1.86918713e-02f,
  -1.39189169e-01f, -2.23396327e-02f, 2.44178697e-02f, -1.14116140e-01f, -5.44445496e-03f, 1.84363306e-01f, 7.59364441e-02f, 1.64515376e-01f, 1.01802111e-01f, -5.85780963e-02f,
  1.21442840e-01f, -2.26970799e-02f, 2.89313328e-02f, 1.37924656e-01f, 1.27078459e-01f, 6.56126291e-02f, -4.54025380e-02f, -3.05203170e-01f, 8.67207721e-02f, 3.77512374e-03f,
  -5.00986725e-02f, 1.10921085e-01f, 6.20188601e-02f, -7.98516572e-02f, -1.38630301e-01f, -2.55218409e-02f, -8.59242156e-02f, -2.61196792e-01f, 4.81819771e-02f, 2.76398510e-01f,
  4.07493860e-02f, -1.25698298e-01f, 1.72622845e-01f, -1.15382314e-01f, 1.84224784e-01f, -1.47425774e-02f, 9.41683725e-02f, -8.73214230e-02f, -1.38212949e-01f, 2.44325042e-01f,
  2.64734387e-01f, -4.80499603e-02f, -2.88176853e-02f, 2.16547474e-01f, 1.28341839e-01f, 7.65201822e-02f, 5.98462299e-02f, 7.26503432e-02f, -6.05462641e-02f, 7.93188997e-03f,
  1.53887242e-01f, 2.27274761e-01f, -3.17014679e-02f, -1.00780368e-01f, 2.70165056e-01f, -1.93629548e-01f, 1.85040608e-01f, 4.26991135e-02f, 1.47425950e-01f, -1.21793061e-01f,
  -1.27035335e-01f, 2.91503876e-01f, -5.02761779e-03f, 1.00463197e-01f, -5.15074655e-02f, -1.28420755e-01f, 1.46204308e-02f, 1.29125744e-01f, -1.57637801e-02f, -5.87501973e-02f,
  -1.38683975e-01f, -9.78080630e-02f, -1.54849768e-01f, 2.88155198e-01f, 1.65955290e-01f, 2.12838843e-01f, 2.70925075e-01f, -9.60776880e-02f, 3.86363640e-03f, -7.77904093e-02f,
  5.58273867e-02f, 5.20221563e-03f, 4.69928265e-01f, 2.16178764e-02f, 5.62396497e-02f, 1.65352412e-02f, 1.48325652e-01f, 5.84177673e-02f, -1.44166440e-01f, -6.68315142e-02f,
  1.38102964e-01f, -6.04208186e-02f, 4.65596281e-03f, 2.94664484e-02f, 3.71136628e-02f, -6.01697601e-02f, -1.03623129e-01f, -5.45016229e-02f, 1.75340116e-01f, -1.05553471e-01f,
  -1.91411719e-01f, -9.62681845e-02f, 7.96164945e-02f, 1.52892411e-01f, 1.82417214e-01f, -3.24472301e-02f, 2.46076718e-01f, -5.23141995e-02f, 4.60561290e-02f, 5.51055744e-02f,
  -1.79812759e-02f, 7.72123188e-02f, -8.68110210e-02f, 2.65644282e-01f, -2.13969611e-02f, -7.28789493e-02f, -7.10402057e-02f, -1.32323846e-01f, -9.81991217e-02f, -4.24818732e-02f,
  1.85353849e-02f, -7.21360743e-02f, 7.21828341e-02f, 2.06806839e-01f, 4.09138389e-02f, -8.84221122e-02f, -2.23866478e-01f, 1.02364734e-01f, -3.38223539e-02f, 2.23005787e-01f,
  2.03095449e-04f, 7.06852376e-02f, 1.36463165e-01f, -3.75473350e-02f, -2.48068701e-02f, 1.26628160e-01f, 1.33787736e-01f, -2.35499918e-01f, 1.96929276e-01f, 1.87130794e-01f,
  9.79750678e-02f, 6.92855194e-02f, 1.40011281e-01f, 1.53295353e-01f, 2.26526298e-02f, 1.13163866e-01f, -1.63548306e-01f, -6.64621741e-02f, 2.92959008e-02f, 1.75791726e-01f,
  4.00613211e-02f, 1.47345722e-01f, -2.61110246e-01f, 1.42477071e-02f, 1.39931872e-01f, 1.07199229e-01f, -1.11107796e-01f, -1.75416768e-01f, 2.62613762e-02f, 9.50718373e-02f,
  1.59317896e-01f, 1.03225254e-01f, -6.25581816e-02f, 1.57998130e-01f, -1.77185565e-01f, 1.39345929e-01f, -5.17736785e-02f, -4.65419888e-02f, -4.08758372e-02f, 3.43511999e-02f,
  8.71543512e-02f, -1.93630531e-01f, -1.29798949e-01f, 2.43040491e-02f, 1.09404206e-01f, -1.26827911e-01f, 6.85197301e-03f, -8.51190388e-02f, -3.09960872e-01f, 8.53345990e-02f,
  1.87655643e-01f, -1.77788511e-01f, 1.18876651e-01f, -6.41939193e-02f, -2.42184192e-01f, 1.15312971e-01f, 1.35456160e-01f, -1.07497595e-01f, -1.72438428e-01f, 1.61983877e-01f,
  6.69635907e-02f, -2.92238712e-01f, 2.02621669e-01f, -6.59442022e-02f, 3.95520963e-02f, -1.33370072e-01f, -1.18305877e-01f, 3.57352756e-02f, 1.34716675e-01f, -1.78300604e-01f,
  4.78089415e-02f, -2.44672447e-02f, -1.71811506e-02f, -6.16214275e-02f, -3.48050669e-02f, 2.50099778e-01f, 2.32022345e-01f, -1.10290438e-01f, 8.42450410e-02f, -1.68642968e-01f,
  1.80512354e-01f, 1.73620924e-01f, 1.80528298e-01f, 1.26800388e-01f, 1.57633334e-01f, 1.29493400e-01f, -1.38055965e-01f, 1.56413853e-01f, 1.10106707e-01f, -7.21173435e-02f,
  1.00316353e-01f, 2.99134254e-01f, 1.31305665e-01f, 5.02240360e-02f, 5.98925240e-02f, 1.92676634e-01f, 2.67732352e-01f, -5.81831038e-02f, 9.92702395e-02f, 1.15930863e-01f,
  1.79911181e-01f, 3.33397508e-01f, -1.74656715e-02f, 1.04768686e-01f, 6.06535841e-03f, -6.24927469e-02f, -4.96146306e-02f, 6.06118068e-02f, -4.58689826e-03f, 6.31087134e-03f,
  1.90849658e-02f, -7.68305585e-02f, 6.01028875e-02f, -2.32726838e-02f, 1.31423905e-01f, -2.48986691e-01f, 2.15751499e-01f, -6.68760836e-02f, -9.86733846e-03f, -7.82154799e-02f,
  8.53624120e-02f, 1.04102969e-01f, -6.58615604e-02f, -1.95760839e-02f, -5.48565723e-02f, 1.78606249e-02f, -1.20776772e-01f, -7.31928572e-02f, 1.26088291e-01f, 1.72649231e-02f,
  6.61624968e-02f, 1.32238567e-01f, 7.57344216e-02f, 1.03518613e-01f, 1.41908705e-01f, 6.72275051e-02f, -3.00573446e-02f, -2.95778029e-02f, 1.36816932e-03f, -8.63410607e-02f,
  9.43749323e-02f, -9.64425504e-03f, -2.74368189e-02f, -1.34787440e-01f, -1.86248288e-01f, -9.29357409e-02f, 1.57049090e-01f, 1.10904008e-01f, 8.72946084e-02f, -2.95420038e-03f,
  3.95981073e-02f, -2.96745892e-03f, -2.68481602e-03f, 2.34227210e-01f, -5.03122248e-02f, 1.49007484e-01f, 1.06022172e-01f, -2.10860521e-02f, 1.46097884e-01f, 4.19631787e-02f,
  -1.90645028e-02f, 1.64943248e-01f, 1.10095292e-01f, 4.84202914e-02f, 8.63636658e-02f, 7.94941708e-02f, -1.63792878e-01f, -7.10315853e-02f, -9.06600151e-04f, 1.58286750e-01f,
  -9.28658247e-02f, 4.81484383e-02f, 7.88658508e-04f, -2.69062780e-02f, 1.35223493e-01f, 9.79720727e-02f, -1.24706812e-01f, -1.91616148e-01f, 1.25609636e-02f, 2.29153380e-01f,
  -1.53722525e-01f, 1.16681904e-02f, -5.89525187e-03f, -6.47915378e-02f, 1.47062924e-03f, -1.32983476e-01f, 1.15070939e-01f, -6.01308122e-02f, 2.01819077e-01f, 7.49021843e-02f,
  -6.26231916e-03f, 1.56932712e-01f, -1.31746635e-01f, -1.16658896e-01f, 4.27576248e-03f, 1.36822551e-01f, 1.04792789e-01f, 7.97322094e-02f, -6.25218749e-02f, -1.01805087e-02f,
  2.01072246e-01f, 2.33551010e-01f, -1.09236643e-01f, 1.19746469e-01f, -1.80136323e-01f, -6.16786964e-02f, 8.55598077e-02f, 2.17451602e-01f, -5.45152612e-02f, -1.18675038e-01f,
  -1.70510286e-03f, -1.59756392e-01f, 3.19084227e-02f, -1.54313266e-01f, 1.52628258e-01f, 1.13545462e-01f, -1.48063460e-02f, -6.73549920e-02f, -8.17014575e-02f, 7.99585730e-02f,
  -8.43000039e-02f, -2.48349234e-02f, -1.67014688e-01f, 1.29072547e-01f, 8.72001648e-02f, -8.88568163e-02f, 1.64000213e-01f, -5.68010360e-02f, 7.35311955e-02f, 5.63234016e-02f,
  8.09837282e-02f, 9.35567394e-02f, 8.75223875e-02f, 3.41998483e-03f, 1.82208627e-01f, 4.13678512e-02f, 1.50504008e-01f, 3.24798450e-02f, 3.39392549e-03f, -5.29113924e-03f,
  2.11116195e-01f, 5.29265925e-02f, -3.47375013e-02f, -2.97633588e-01f, 6.47886172e-02f, 1.17550315e-02f, 1.06400855e-01f, 1.04527667e-01f, 7.65018463e-02f, -4.52194102e-02f,
  2.41439149e-01f, 7.45243654e-02f, -1.92036182e-01f, 1.05871279e-02f, 4.23782356e-02f, 2.06382513e-01f, -5.15830293e-02f, 1.74934685e-01f, 7.51623884e-02f, 2.35262141e-02f,
  8.24637339e-02f, -1.70804448e-02f, 1.13138132e-01f, 1.71287805e-01f, 3.13623808e-02f, 2.15849102e-01f, 1.98962241e-02f, 6.87665269e-02f, 8.03376362e-02f, 1.10025465e-01f,
  5.93915842e-02f, -5.16450144e-02f, 1.36889681e-01f, 1.83862019e-02f, 1.62302703e-01f, 2.56238990e-02f, 2.56002188e-01f, 1.69821158e-01f, -7.57190287e-02f, -5.35925478e-02f,
  -3.28954458e-02f, 1.60130247e-01f, -2.72793919e-01f, -2.40888536e-01f, -1.39373094e-01f, 1.03425741e-01f, -3.96561213e-02f, 1.49169877e-01f, -6.81612687e-03f, 1.57442659e-01f,
  -2.36572087e-01f, 6.05685487e-02f, 1.73044741e-01f, -2.52297986e-02f, -2.63600796e-01f, -2.68146712e-02f, 8.40196908e-02f, -2.41924599e-01f, -2.73570955e-01f, 4.53134701e-02f,
  9.78383422e-02f, 1.58540299e-03f, 6.83895312e-03f, 1.69685662e-01f, -2.37847388e-01f, -2.46841073e-01f, 1.53304085e-01f, 6.51703924e-02f, -9.99304876e-02f, -1.64682884e-02f,
  -6.28567487e-02f, 1.22947477e-01f, 1.07889774e-03f, -9.12107304e-02f, -1.50491014e-01f, -1.25383466e-01f, 1.57270789e-01f, -2.60096818e-01f, -1.56533979e-02f, 2.46534050e-01f,
  -7.85720050e-02f, -2.61304285e-02f, -6.20781966e-02f, 1.12471566e-01f, 1.89921573e-01f, 1.29965231e-01f, 2.08757296e-01f, -3.40286672e-01f, -3.18235606e-02f, 1.50947481e-01f,
  -1.23560652e-01f, 9.62348878e-02f, 2.04953015e-01f, 1.75881475e-01f, 5.30076912e-03f, -2.27544963e-01f, -3.39074224e-01f, 8.60435888e-02f, 2.23597646e-01f, 2.26041079e-01f,
  -2.69423962e-01f, -3.49208787e-02f, -7.87703320e-03f, -8.05964507e-03f, -8.15454274e-02f, -2.26806123e-02f, -1.10966749e-01f, 1.01604745e-01f, 1.86296597e-01f, 4.91382219e-02f,
  1.09064646e-01f, 1.73620537e-01f, 1.74869135e-01f, -7.02676699e-02f, 1.83166295e-01f, 3.77229825e-02f, -2.77896617e-02f, 1.76253796e-01f, 1.80543098e-03f, 6.30135313e-02f,
  -2.31315717e-02f, 2.07005311e-02f, -8.96727741e-02f, 5.75539023e-02f, 1.13324083e-01f, 1.43975347e-01f, -1.94209777e-02f, 2.63339207e-02f, 1.35838792e-01f, 1.18698232e-01f,
  -9.15810242e-02f, 8.40349197e-02f, -8.75826478e-02f, -1.37143448e-01f, 2.49356572e-02f, -8.28255992e-03f, 1.78730518e-01f, -1.98272124e-01f, -1.34332955e-01f, 2.95420200e-01f,
  -5.34517951e-02f, -1.58226043e-02f, 3.85277234e-02f, 3.68587151e-02f, 1.17282391e-01f, 1.89728383e-02f, 5.30385524e-02f, 1.65196732e-01f, 6.64373338e-02f, 1.87075287e-01f,
  -1.84169840e-02f, -7.66818672e-02f, 8.62883329e-02f, 1.15169622e-01f, 1.44361749e-01f, 7.41038024e-02f, 9.34089944e-02f, -2.39445884e-02f, -9.88147333e-02f, -1.56657636e-01f,
  2.68884134e-02f, 1.58466071e-01f, 3.38400006e-02f, 1.65483743e-01f, 7.03123584e-03f, 1.54762313e-01f, -1.68151617e-01f, -3.79232317e-02f, 8.29024389e-02f, 3.79031301e-02f,
  5.65050505e-02f, -7.66104087e-02f, -1.50124103e-01f, -1.06575407e-01f, 1.47452131e-01f, -1.47855312e-01f, 3.45433205e-02f, -3.91454324e-02f, 4.93360199e-02f, 3.98558602e-02f,
  8.43458921e-02f, 8.82943720e-02f, 6.37073666e-02f, -4.40240242e-02f, -2.19273970e-01f, 1.77432939e-01f, 2.52387851e-01f, -7.52380788e-02f, 7.48825967e-02f, 2.21950889e-01f,
  -9.20714960e-02f, 9.12981033e-02f, 1.91412330e-01f, -1.55229177e-02f, -3.44491005e-01f, 1.93781078e-01f, 8.50627050e-02f, -2.31503360e-02f, 2.58429408e-01f, -1.32068470e-02f,
  1.16678722e-01f, -1.02709860e-01f, 1.64571911e-01f, 1.21566288e-01f, 1.09113708e-01f, 1.88030809e-01f, -7.04953671e-02f, 1.39439793e-03f, -1.37871176e-01f, 1.53386936e-01f,
  2.20386878e-01f, 1.02569260e-01f, -1.53274328e-01f, 1.43347651e-01f, -5.73383132e-03f, 3.48639250e-01f, 2.92643066e-02f, 2.49201596e-01f, 6.94940463e-02f, -4.62631918e-02f,
  -9.69493240e-02f, 1.27640501e-01f, 2.27193728e-01f, 1.43346176e-01f, 2.32133731e-01f, 1.17261343e-01f, -9.71580595e-02f, 7.95561001e-02f, -1.54010681e-02f, 1.51804328e-01f,
  3.31167728e-01f, -7.65211182e-03f, 5.42277098e-02f, -1.36397108e-01f, 3.92546169e-02f, -1.56061903e-01f, -1.83841452e-01f, -2.06346065e-02f, 5.53539172e-02f, 1.05292927e-02f,
  -3.84553596e-02f, 5.46424463e-02f, -1.49988711e-01f, 5.43324417e-03f, 6.92397207e-02f, -4.73252200e-02f, 2.45618988e-02f, 2.17543349e-01f, 7.83960894e-03f, 7.66036436e-02f,
  2.40831953e-02f, 1.78767070e-01f, -1.35582730e-01f, 2.47093402e-02f, -7.50861391e-02f, 2.68755108e-01f, 8.30356032e-02f, 2.21393304e-03f, -1.17694937e-01f, -7.87304789e-02f,
  -1.11160561e-01f, 1.72285102e-02f, 1.74640507e-01f, 1.98708307e-02f, 6.88344836e-02f, 3.93403679e-01f, 1.66395679e-01f, -9.57134143e-02f, 1.00764655e-01f, 2.63956577e-01f,
  -1.96903408e-01f, -4.54132706e-02f, 2.15675518e-01f, 5.78939542e-02f, 1.67882264e-01f, 1.70766518e-01f, 3.97217413e-03f, 2.07701296e-01f, 1.31009370e-01f, 2.39398181e-01f,
  -1.01438329e-01f, 1.35726526e-01f, 1.06664285e-01f, -1.89853340e-01f, 2.16635957e-01f, 2.83147722e-01f, -5.27309217e-02f, 8.95483270e-02f, -2.88896393e-02f, -1.01474887e-02f,
  -2.20166132e-01f, -1.61435232e-02f, -1.74116492e-01f, -1.18697301e-01f, 1.06686026e-01f, -1.36077022e-02f, 5.56339808e-02f, -1.75648317e-01f, -1.26012057e-01f, -3.22995931e-01f,
  -1.36336789e-01f, -1.93112552e-01f, 1.53767630e-01f, -3.05016972e-02f, -1.90750360e-01f, 1.72097832e-01f, 3.99145223e-02f, -1.14248246e-01f, -2.41686210e-01f, 1.29707502e-02f,
  2.07709089e-01f, -7.21456409e-02f, 6.34080097e-02f, 2.32398093e-01f, 1.04552694e-01f, 6.04755729e-02f, 7.33602419e-02f, 1.40854076e-01f, -1.84880987e-01f, 1.08730391e-01f,
  8.23761821e-02f, -3.43554318e-02f, -1.79417461e-01f, 4.78083268e-02f, -9.97263417e-02f, -7.25821033e-02f, 1.03846185e-01f, 5.10991253e-02f, 9.63419152e-04f, -4.01788093e-02f,
  -1.49228781e-01f, 2.10253567e-01f, 1.06393576e-01f, 2.08580628e-01f, 1.87915713e-01f, -6.57949671e-02f, 8.59323740e-02f, 2.29132175e-02f, 2.54015744e-01f, 1.26939761e-02f,
  1.32959053e-01f, 1.48110792e-01f, -5.72540686e-02f, 1.11538945e-02f, 5.67608774e-02f, 1.96080983e-01f, 2.34628841e-01f, 4.89180014e-02f, -3.92367393e-02f, -3.42064234e-03f,
  2.46969629e-02f, -9.35935974e-02f, 9.00117308e-02f, -7.79283419e-02f, -1.53041691e-01f, -2.51263529e-02f, 1.50238305e-01f, 8.83536190e-02f, 3.05115674e-02f, 4.64028539e-03f,
  -1.20885313e-01f, -1.05958678e-01f, -1.67820692e-01f, -8.30160454e-02f, -1.53925136e-01f, -4.63495553e-02f, 3.71784009e-02f, -2.87064146e-02f, 3.69344205e-02f, -1.06979154e-01f,
  1.47460639e-01f, -8.79032761e-02f, 1.42945601e-02f, -1.83619335e-01f, 1.21754900e-01f, 7.25142658e-02f, 2.72542804e-01f, 1.37155145e-01f, -1.45386169e-02f, 3.16047221e-01f,
  -1.06590182e-01f, -9.93279964e-02f, -1.77603140e-01f, 1.44437954e-01f, -4.15298492e-01f, -7.05456883e-02f, 4.57901776e-01f, 1.49928242e-01f, 9.00300667e-02f, 1.17676303e-01f,
  -1.53962359e-01f, -1.27489239e-01f, -1.66721851e-01f, 4.61446613e-01f, 5.64093217e-02f, -3.17905903e-01f, 7.57284686e-02f, 1.01370044e-01f, 1.04952762e-02f, -1.04155326e-02f,
  1.80476025e-01f, -6.53229281e-02f, 3.67774010e-01f, 2.13279307e-01f, 1.17316201e-01f, 1.90830663e-01f, 2.55077899e-01f, 1.27543673e-01f, -3.74805510e-01f, -1.58934876e-01f,
  1.75802652e-02f, -1.56502903e-01f, 1.36276051e-01f, 2.54108548e-01f, 2.29015630e-02f, -1.18050329e-01f, -2.62936503e-01f, -2.28959069e-01f, 1.07704319e-01f, 1.58471778e-01f,
  3.25476602e-02f, -7.63142779e-02f, 3.21812965e-02f, 1.26289129e-01f, -1.57026291e-01f, 5.86812384e-02f, -1.55090794e-01f, 2.21538305e-01f, 3.33632112e-01f, -3.25307883e-02f,
  7.31657865e-03f, 3.31317455e-01f, -7.82858860e-03f, 1.42919704e-01f, 2.37417102e-01f, 9.85631719e-02f, -1.24580692e-02f, 1.33563340e-01f, 1.65148467e-01f, 1.42420337e-01f,
  6.90777227e-02f, 1.31170824e-01f, 8.34330916e-02f, 2.58435279e-01f, -5.09466529e-02f, 6.13553710e-02f, 1.24344610e-01f, -2.47658342e-01f, 2.06129774e-01f, 7.70115927e-02f,
  1.28300888e-02f, 2.63638586e-01f, -1.04781352e-01f, -2.01425657e-01f, 5.29346019e-02f, -4.28525778e-03f, 8.61294642e-02f, -1.21989377e-01f, -1.12592615e-01f, -1.42623276e-01f,
  -1.30741760e-01f, -3.45397927e-02f, -1.87228471e-01f, -1.96878463e-02f, 1.11232124e-01f, 1.58440061e-02f, 4.12922949e-02f, 2.13235170e-01f, 5.82078323e-02f, 1.42425373e-01f,
  2.00013474e-01f, -1.53067753e-01f, 1.12503067e-01f, 1.64929464e-01f, -2.52871457e-02f, 2.27576882e-01f, -1.31513560e-02f, 6.18417151e-02f, -2.02090219e-02f, 3.71948369e-02f,
  -7.08599538e-02f, 1.42833680e-01f, 3.70321013e-02f, -1.08978406e-01f, -3.44171107e-01f, 3.10352389e-02f, -2.05102310e-01f, -5.17237447e-02f, -1.93826715e-03f, -2.49590963e-01f,
  1.51161700e-01f, 1.96715027e-01f, 1.92069814e-01f, -2.58603156e-01f, 1.85844049e-01f, 2.93468814e-02f, 1.70382470e-01f, 1.38739198e-01f, 2.48719305e-01f, -5.20177856e-02f,
  -1.85957372e-01f, 1.90974306e-02f, 1.40041471e-01f, -9.09133926e-02f, 1.13043457e-01f, 2.00046182e-01f, 1.67995945e-01f, 1.05662122e-01f, 1.03065379e-01f, 1.80176035e-01f,
  6.01541661e-02f, 1.35279484e-02f, 6.82150945e-02f, 1.40802190e-01f, -8.14337134e-02f, 1.72366992e-01f, -2.37416215e-02f, -1.68905854e-01f, 6.74390048e-02f, -2.35731751e-02f,
  9.49379802e-02f, 1.59679465e-02f, -1.54429153e-01f, 1.17278650e-01f, -1.47234216e-01f, 1.65563880e-03f, 1.57839343e-01f, 1.09450884e-01f, 1.83586031e-01f, 9.01076049e-02f,
  9.99552980e-02f, 1.21570222e-01f, 3.30308154e-02f, 8.79901052e-02f, -2.65910886e-02f, -6.15110546e-02f, 1.34187028e-01f, -9.65510756e-02f, 2.23733231e-01f, 1.11807637e-01f,
  3.90332155e-02f, 8.09376035e-03f, -1.33787066e-01f, -1.46530092e-01f, 1.42002642e-01f, 8.82395208e-02f, -1.26029834e-01f, 1.00866348e-01f, -1.08506233e-02f, 1.29383817e-01f,
  -1.17559828e-01f, -2.00664505e-01f, 1.39489144e-01f, -2.05608740e-01f, -7.42555335e-02f, -9.46435630e-02f, 3.54393721e-02f, -8.24145321e-03f, 1.28870895e-02f, -7.22658336e-02f,
  -2.03313485e-01f, 1.43318444e-01f, 1.14155812e-02f, -6.24491926e-03f, -1.29167587e-01f, -1.97240785e-01f, 1.16703987e-01f, -1.52150750e-01f, 1.28207043e-01f, 3.02929670e-01f,
  1.65673703e-01f, 2.60221094e-01f, 1.28390463e-02f, 9.02575403e-02f, 1.33237034e-01f, -3.46909165e-01f, 3.25040221e-02f, 1.85325712e-01f, -3.06235650e-03f, 2.58500069e-01f,
  3.13574851e-01f, -9.78791565e-02f, 3.98157835e-02f, -1.71016797e-01f, 1.53807744e-01f, -2.55346317e-02f, -1.09196708e-01f, -1.45700961e-01f, -1.67688698e-01f, 4.57497314e-02f,
  -2.08630472e-01f, -1.27817756e-02f, 7.14181289e-02f, -1.00285985e-01f, 1.58248693e-01f, 1.48676500e-01f, 3.38215753e-02f, 9.28302929e-02f, 1.06947133e-02f, 3.46801966e-01f,
  4.50070277e-02f, -1.69454604e-01f, 1.03072315e-01f, -5.55402935e-02f, -4.71053831e-02f, 1.53907627e-01f, -5.60092889e-02f, -7.30497465e-02f, 1.05199799e-01f, -1.37744946e-02f,
  -1.58136815e-01f, -1.39320418e-01f, 5.37249818e-02f, 5.39735816e-02f, -2.11357519e-01f, -1.04892761e-01f, 1.53679818e-01f, -1.10045411e-01f, 1.78666472e-01f, 2.08959967e-01f,
  3.80125880e-01f, -2.07961485e-01f, 5.46418354e-02f, 2.05183718e-02f, 1.57072529e-01f, 1.79678500e-01f, 1.45209163e-01f, 9.87235829e-03f, -1.03536054e-01f, 4.30355854e-02f,
  2.32415542e-01f, 1.99318472e-02f, 2.39322763e-02f, -6.42724037e-02f, 4.45912220e-02f, 5.77944070e-02f, 3.67079079e-02f, -3.54602933e-02f, 1.36844307e-01f, 6.19449206e-02f,
  -3.63676064e-02f, 9.84406099e-02f, -7.70685375e-02f, -1.78775728e-01f, 1.95394978e-01f, -1.70229167e-01f, -2.32339110e-02f, 1.38836846e-01f, 9.24198329e-02f, 2.15536654e-02f,
  -1.19626634e-01f, 2.49312475e-01f, -4.90064509e-02f, -7.59449527e-02f, 2.41749391e-01f, -3.62763740e-02f, 2.37055212e-01f, 1.72990501e-01f, -1.13709033e-01f, -7.51424879e-02f,
  -9.24653783e-02f, -4.89819720e-02f, 9.17792767e-02f, 5.54116517e-02f, -1.48377150e-01f, -1.17004491e-01f, 1.78571165e-01f, -8.70792009e-03f, 1.31868109e-01f, -8.55802521e-02f,
  -1.67062543e-02f, -6.69077635e-02f, 1.51224032e-01f, 1.73789915e-02f, 1.25279501e-01f, 1.27001464e-01f, 6.39827698e-02f, -1.81547403e-02f, -5.20093068e-02f, 5.44666778e-03f,
  1.45862415e-01f, 1.79380909e-01f, -1.95697129e-01f, 3.62653583e-02f, 3.92150879e-02f, 1.92142263e-01f, -4.37088944e-02f, 6.80272505e-02f, -7.29826838e-02f, -5.14582098e-02f,
  -1.14236429e-01f, 6.34124354e-02f, 7.59930834e-02f, 1.77382082e-01f, -4.07879651e-02f, -2.98474971e-02f, 1.06763886e-02f, -4.83664200e-02f, -1.28700599e-01f, -2.27484573e-02f,
  5.09236939e-02f, -6.38873726e-02f, -3.07383165e-02f, -3.43849361e-02f, 1.94507688e-01f, -1.23249874e-01f, 8.78535882e-02f, 2.81007998e-02f, -1.17343068e-01f, -1.77709728e-01f,
  -1.15929551e-01f, -4.74298932e-02f, 3.48371714e-02f, -1.84561104e-01f, -1.44132987e-01f, 2.65115332e-02f, 7.74240261e-03f, -8.07760805e-02f, -1.62928194e-01f, 1.08581468e-01f,
  -4.16149572e-02f, -1.18239224e-01f, 3.85405794e-02f, 1.32336169e-01f, 2.24378332e-01f, 2.38431349e-01f, 1.71886340e-01f, -5.93742467e-02f, 1.11439943e-01f, 9.91418026e-03f,
  7.86015987e-02f, 2.08682314e-01f, 4.56989035e-02f, 1.09725058e-01f, -3.88083905e-02f, -2.79638052e-01f, -5.27796783e-02f, -4.38597724e-02f, -1.65565684e-01f, 4.05696481e-02f,
  -1.09680802e-01f, -9.71062183e-02f, 1.63243208e-02f, 6.86986372e-02f, -9.32007805e-02f, 3.39636020e-03f, 1.17620371e-01f, 8.13121647e-02f, -7.55898431e-02f, -2.07948700e-01f,
  6.67747334e-02f, -1.64612472e-01f, 3.04535836e-01f, -1.39134541e-01f, 6.47545755e-02f, 3.95059250e-02f, -3.66239995e-02f, 1.59003153e-01f, 1.42693862e-01f, -1.25330240e-01f,
  1.60280332e-01f, 1.83446184e-01f, 1.97078705e-01f, 1.74153671e-01f, 2.22847819e-01f, 1.52493760e-01f, 4.08490218e-04f, 1.38359681e-01f, -2.85068393e-01f, 6.06913026e-03f,
  1.87479645e-01f, 2.63154447e-01f, -1.41180173e-01f, 2.25235537e-01f, -1.45522142e-02f, -1.14629017e-02f, 1.32702142e-01f, 1.31296575e-01f, 8.35354477e-02f, -6.30678758e-02f,
  -3.71331349e-02f, 1.85238183e-01f, 1.01873122e-01f, 1.85739428e-01f, -1.36836201e-01f, 7.05610141e-02f, 2.65772909e-01f, 9.32824165e-02f, 1.08162798e-01f, 3.40070277e-02f,
  -2.60682148e-03f, -1.55644640e-01f, 1.49999997e-02f, 1.17454059e-01f, -7.86198899e-02f, -2.59426096e-03f, -2.29051616e-02f, 2.83593107e-02f, 1.44182906e-01f, 9.29136798e-02f,
  -2.89217941e-02f, 2.38017738e-03f, 7.96315726e-03f, 5.10805361e-02f, -1.28407031e-01f, 1.94650263e-01f, 1.56468764e-01f, -1.02477986e-02f, 9.19476077e-02f, 9.07216296e-02f,
  -1.55407161e-01f, -1.33963764e-01f, 1.09893523e-01f, 1.96809307e-01f, -1.36470124e-01f, 1.41504094e-01f, -1.60540909e-01f, 1.42160684e-01f, 5.92407882e-02f, -1.55323491e-01f,
  1.12156041e-01f, -2.15124175e-01f, -8.76444727e-02f, 1.98707417e-01f, -1.04346804e-01f, 4.38903980e-02f, -9.84800532e-02f, -1.93842053e-01f, -8.34050030e-02f, -2.56645009e-02f,
  3.22922736e-01f, -3.40087973e-02f, 2.65623391e-01f, 1.08738080e-01f, -2.73162544e-01f, -1.04310177e-02f, -2.68835179e-03f, -6.87831417e-02f, 1.56559169e-01f, 1.41520407e-02f,
  2.36727491e-01f, -1.85130406e-02f, 1.88417584e-01f, -1.04011120e-02f, 8.14480036e-02f, -1.38671286e-02f, -1.12856463e-01f, 1.03001587e-01f, 8.64911824e-02f, 2.11909503e-01f,
  -1.77194938e-01f, 1.65867999e-01f, -2.20281277e-02f, 1.08513258e-01f, 9.70803667e-03f, -1.38591707e-01f, 2.37106696e-01f, 3.23365241e-01f, 2.40741624e-03f, 3.50834161e-01f,
  1.03117764e-01f, 1.07982501e-01f, 1.05730064e-01f, 3.17660809e-01f, 3.02258916e-02f, 1.09441616e-01f, -6.91121370e-02f, -7.84560964e-02f, -1.61292478e-01f, -9.62003320e-02f,
  3.09909042e-02f, 1.00992762e-01f, 2.32866690e-01f, 1.08348124e-01f, 2.48361722e-01f, -2.45372392e-02f, -3.11026752e-01f, 4.47305366e-02f, 9.96917263e-02f, -2.10720658e-01f,
  1.71461299e-01f, 8.49528983e-03f, -5.40792160e-02f, 1.70689195e-01f, -1.61004364e-01f, -1.08165694e-02f, 1.06509238e-01f, -4.25419584e-03f, -3.82449105e-02f, 8.12167302e-02f,
  -8.20364952e-02f, 4.52254787e-02f, 4.95745018e-02f, 2.04789676e-02f, 3.74867439e-01f, -1.25127256e-01f, 2.03181028e-01f, -4.63752970e-02f, -1.65689528e-01f, 1.32682279e-01f,
  -5.26599623e-02f, 1.17785171e-01f, -6.01034984e-02f, -7.94536620e-02f, 8.99476036e-02f, 1.75616845e-01f, -8.93550590e-02f, 3.40720266e-02f, -7.51973614e-02f, -1.57014821e-02f,
  -1.37777999e-01f, 6.19372353e-02f, 2.30601475e-01f, 9.17043760e-02f, -4.50319285e-03f, 4.25132141e-02f, -2.49889493e-01f, 8.69062468e-02f, 1.54192045e-01f, -2.15325356e-02f,
  7.30200410e-02f, 5.08408248e-02f, -2.62953211e-02f, 6.60116225e-02f, 1.09400690e-01f, 7.85021633e-02f, -2.12619692e-01f, 1.08757786e-01f, 9.30818021e-02f, 2.68479079e-01f,
  -1.79641902e-01f, -4.51551862e-02f, -1.19232416e-01f, 2.89028473e-02f, -2.60318033e-02f, -1.34352043e-01f, 2.22438633e-01f, -5.52739725e-02f, 2.51197457e-01f, 1.40777573e-01f,
  3.55065838e-02f, -1.21693507e-01f, 3.51780094e-02f, -1.93931997e-01f, 4.38420661e-02f, 1.75235733e-01f, -6.28392994e-02f, 6.10940009e-02f, -1.31122202e-01f, 2.17076659e-01f,
  2.58934289e-01f, -6.31066114e-02f, -7.42563903e-02f, 1.29030496e-01f, 6.61043003e-02f, 1.11093521e-01f, 1.10424533e-01f, 6.98979348e-02f, 6.64431900e-02f, 1.69692710e-01f,
  -8.92914087e-02f, -2.36550137e-01f, 5.00617884e-02f, 1.79669514e-01f, 5.73249422e-02f, -1.07696719e-01f, 5.49180172e-02f, -4.54875231e-02f, 8.83466098e-03f, 1.37724772e-01f,
  1.84600241e-02f, -4.16439027e-02f, 3.48447829e-01f, 9.38622132e-02f, -8.32965299e-02f, -1.19408771e-01f, -2.96867341e-01f, -7.75498152e-02f, -1.10588912e-02f, 1.86890841e-01f,
  -1.35514691e-01f, 9.41331983e-02f, -1.09203011e-01f, 7.45679662e-02f, 1.61390796e-01f, 2.54631132e-01f, 4.68700975e-02f, 7.73531571e-02f, -1.02336079e-01f, 6.56254739e-02f,
  -1.34603027e-02f, 1.90929964e-01f, 2.58710515e-02f, -1.19587719e-01f, 6.15648553e-03f, -1.83298960e-01f, -2.82989386e-02f, -9.34615359e-02f, 1.48340404e-01f, 1.42063439e-01f,
  -9.53946412e-02f, -2.62732387e-01f, -9.87080336e-02f, 4.77046557e-02f, -1.83681324e-02f, -3.79254594e-02f, -2.25108743e-01f, 7.35401362e-02f, 9.57479998e-02f, -1.20548002e-01f,
  7.43675530e-02f, -7.97308087e-02f, 4.41845432e-02f, -3.41519504e-03f, 2.47960582e-01f, 1.75578326e-01f, 2.03050032e-01f, -9.53440787e-04f, -1.78073481e-01f, 2.70308293e-02f,
  7.51728490e-02f, -5.81277944e-02f, 6.98349401e-02f, -1.02238633e-01f, -9.01172385e-02f, -3.00709512e-02f, 5.23488298e-02f, 8.25109333e-02f, -8.06080773e-02f, -1.33949257e-02f,
  -1.22094214e-01f, -9.95837338e-03f, -6.28512725e-02f, -2.34801903e-01f, -9.64228157e-03f, -4.76751737e-02f, 1.10309804e-02f, -2.71311462e-01f, -5.84362112e-02f, 1.55916527e-01f,
  -1.49225026e-01f, -1.00431710e-01f, 2.22891252e-02f, 1.49890244e-01f, 5.73939309e-02f, 1.21988378e-01f, 1.56791002e-01f, -2.99860865e-01f, 1.00478075e-01f, 6.93773106e-02f,
  -1.27403185e-01f, 2.27662355e-01f, -9.85613614e-02f, 4.99546761e-03f, 4.83069196e-02f, -1.16725326e-01f, -1.52017280e-01f, 2.98681995e-03f, 1.58336580e-01f, 8.80574882e-02f,
  -2.70629108e-01f, -8.60389024e-02f, -7.76429027e-02f, -8.91020745e-02f, 7.72507070e-03f, -2.04285890e-01f, 6.37261942e-02f, 2.42927387e-01f, 5.19689023e-02f, -5.55742905e-02f,
  9.23490077e-02f, -3.98637280e-02f, 1.64456025e-01f, -1.89986750e-02f, 1.66572690e-01f, 4.55603981e-03f, 5.90374097e-02f, 1.68332979e-01f, -6.46692701e-03f, 1.54284328e-01f,
  2.04444230e-01f, 5.89492582e-02f, -1.47012323e-02f, -2.85170097e-02f, 2.45080590e-02f, 1.37986735e-01f, -2.22626343e-01f, 1.91828430e-01f, 2.12773576e-01f, 3.18324082e-02f,
  -1.08507231e-01f, -1.13419183e-01f, -1.00788541e-01f, -2.44718358e-01f, 3.79392095e-02f, 7.23871216e-02f, 9.08519551e-02f, 2.60491669e-01f, 1.14259869e-02f, -1.48654087e-02f,
  -1.10399552e-01f, 1.54547825e-01f, 1.49489030e-01f, -5.29150553e-02f, 2.91421711e-01f, -2.09066682e-02f, 1.28495738e-01f, 8.34107399e-02f, -1.46529287e-01f, 9.11564846e-03f,
  2.82359689e-01f, -5.91799282e-02f, -1.45637125e-01f, 2.75365002e-02f, 1.34193391e-01f, 1.36328056e-01f, 2.75920689e-01f, 2.01295167e-01f, -1.20547704e-01f, 7.83120245e-02f,
  -1.31610662e-01f, 5.97756393e-02f, 4.62241545e-02f, 2.25759253e-01f, -1.22455638e-02f, 2.20791385e-01f, -2.98621487e-02f, 5.61442226e-02f, 1.59962848e-01f, 7.93991089e-02f,
  -4.34350781e-02f, -4.25788872e-02f, -1.88840598e-01f, -2.60631386e-02f, 9.40014571e-02f, -4.25001932e-03f, -1.22940555e-01f, 1.03449360e-01f, 2.79597342e-02f, 9.10104662e-02f,
  -2.16740035e-02f, -6.70608804e-02f, 1.83049351e-01f, -1.78401813e-01f, 7.97087029e-02f, 1.44531220e-01f, 7.37924427e-02f, 3.92464362e-03f, 9.07787606e-02f, 1.84518024e-01f,
  -6.22951053e-03f, 8.01172405e-02f, 1.57182947e-01f, 3.41920145e-02f, -2.06432626e-01f, 8.88728630e-03f, -1.49121573e-02f, -2.50725746e-01f, 2.98844546e-01f, 7.18917400e-02f,
  2.55843222e-01f, -6.91242069e-02f, 7.29276463e-02f, 1.56734318e-01f, 9.17956233e-03f, 1.63649574e-01f, 5.17872609e-02f, -3.78965400e-02f, 4.80386661e-03f, 6.14290722e-02f,
  1.07076265e-01f, 1.40737876e-01f, -8.73926878e-02f, 5.78135811e-02f, 8.51922780e-02f, -1.61193646e-02f, 1.25270128e-01f, 2.85429955e-01f, 2.05213740e-01f, 1.13262475e-01f,
  9.64441448e-02f, 1.42985448e-01f, -1.51626065e-01f, 1.10102311e-01f, 2.44869351e-01f, 7.25727528e-02f, -1.08540960e-01f, 3.60672106e-03f, 2.86655780e-02f, 1.27169251e-01f,
  -3.42480317e-02f, 2.65981089e-02f, 1.89231858e-01f, -2.66183615e-01f, -2.89878957e-02f, -1.16892770e-01f, -1.67687461e-01f, 1.98597293e-02f, 1.96117256e-03f, -2.07483828e-01f,
  -1.52609631e-01f, 1.73112720e-01f, -2.69334149e-02f, 7.42858350e-02f, -6.56680837e-02f, -3.74817476e-02f, 1.70490324e-01f, -1.81656092e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  1.01988077e-01f, 5.64649738e-02f, -6.21128678e-02f, 5.30449254e-03f, -1.74636915e-02f, 1.25943363e-01f, 2.18748614e-01f, 2.83031404e-01f, 2.82374509e-02f, -1.57864410e-02f,
  9.96896029e-02f, 3.23911896e-03f, 4.37102243e-02f, 7.40631446e-02f, 1.52974755e-01f, 1.58050075e-01f, 2.59375311e-02f, 3.46592590e-02f, -4.40973938e-02f, -8.70960951e-03f,
  1.08727157e-01f, 1.75443590e-01f, 8.15563500e-02f, 3.86948697e-02f, 1.37507573e-01f, -8.10814323e-04f, 2.07070634e-01f, 1.34865433e-01f, 1.25985429e-01f, 1.59043804e-01f,
  5.58855906e-02f, 8.36467594e-02f, 4.83324938e-02f, -3.36576030e-02f, 1.84051804e-02f, -2.42221057e-02f, 8.60137492e-02f, 1.40062168e-01f, 1.53620422e-01f, 2.59666175e-01f,
  5.54255173e-02f, 1.27769159e-02f, 9.23167244e-02f, 9.07773152e-02f, 4.66922112e-02f, 1.80441782e-01f, -3.31427716e-02f, 6.20063841e-02f, 1.61901996e-01f, -2.07669358e-03f,
  1.88130196e-02f, -1.92216376e-03f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -2.10405797e-01f, 1.30993366e-01f, -9.78638828e-02f, -2.42137969e-01f, 5.38607389e-02f, -3.72103453e-01f, -1.42715469e-01f, 8.95577371e-02f, 1.82015136e-01f, -2.84091711e-01f,
  -1.88970077e-03f, 3.27007961e-03f, -3.93134326e-01f, 2.13717610e-01f, 1.51946858e-01f, 1.02411412e-01f, 7.53457621e-02f, -8.81351903e-02f, 1.23198912e-01f, -5.14685094e-01f,
  -6.57857284e-02f, 1.71941563e-01f, -7.46304244e-02f, 1.27878517e-01f, 1.09715067e-01f, -2.21203089e-01f, -4.37451079e-02f, -5.16217537e-02f, 6.28500506e-02f, 6.96654394e-02f,
  -7.67501369e-02f, -1.49542451e-01f, 2.03609228e-01f, -3.22867572e-01f, -2.04834625e-01f, -2.94469707e-02f, -1.73422739e-01f, -2.30460554e-01f, -1.54240727e-01f, -2.00655192e-01f,
  -5.92028722e-02f, 7.61653706e-02f, -3.09282690e-02f, 1.62773252e-01f, -2.09285721e-01f, 1.46927699e-01f, 1.04150176e-01f, 4.89701033e-02f, -5.84324077e-02f, 1.07502885e-01f,
  -2.02147543e-01f, -7.93746188e-02f, -2.96602305e-02f, -5.87007478e-02f, -1.93998769e-01f, 1.26423359e-01f, -1.71391413e-01f, -4.20393310e-02f, 9.18240920e-02f, 8.41972679e-02f,
  -6.34021834e-02f, -6.27132133e-02f, 9.36546400e-02f, 3.30511741e-02f, 2.07557157e-01f, -2.33025447e-01f, 5.20914458e-02f, -4.28668447e-02f, 1.09682158e-01f, -2.94130623e-01f,
  3.85701239e-01f, -1.63605198e-01f, -2.31289029e-01f, 1.40033811e-01f, 1.30911171e-01f, 3.93814355e-01f, 1.11244313e-01f, -2.50164092e-01f, 1.56011462e-01f, 1.03997260e-01f,
  3.72197442e-02f, 1.90880045e-01f, 1.12223312e-01f, 2.16320872e-01f, 1.25781044e-01f, 1.37542531e-01f, -2.69497961e-01f, -2.21456558e-01f, 2.51163453e-01f, 1.42626271e-01f,
  1.14121318e-01f, -4.78959344e-02f, -3.79336804e-01f, -1.04360618e-01f, -1.62354723e-01f, -2.47588441e-01f, 1.01133503e-01f, -4.16912287e-02f, -1.41589744e-02f, -3.05193931e-01f,
  -6.65013343e-02f, -3.39180753e-02f, -1.08035237e-01f, -3.25117618e-01f, -2.03096181e-01f, 1.70030370e-01f, 2.02050805e-01f, 4.24739905e-03f, 8.78193825e-02f, 3.67096439e-02f,
  2.14545414e-01f, -1.07858762e-01f, -3.08672249e-01f, -3.01434785e-01f, -1.55764103e-01f, 9.81164575e-02f, -4.54967082e-01f, -9.17027518e-02f, -2.73391217e-01f, 2.10915804e-02f,
  -2.65247315e-01f, 1.30280897e-01f, -2.08213896e-01f, -2.92311281e-01f, -5.28434180e-02f, 1.31135508e-01f, 9.33793485e-02f, -1.65411830e-01f, 1.58168927e-01f, 1.81378618e-01f,
  1.47559270e-01f, -1.07777975e-01f, 1.76556200e-01f, 4.45466153e-02f, -1.87498167e-01f, 6.78805262e-02f, 3.55275393e-01f, 3.20399225e-01f, -2.32398093e-01f, 1.91333294e-01f,
  -5.15417218e-01f, -1.18722036e-01f, -5.83993234e-02f, -2.31944308e-01f, -1.74235776e-01f, -2.74948895e-01f, 3.22352313e-02f, 1.04976319e-01f, -3.55315171e-02f, 1.28112197e-01f,
  1.27051454e-02f, -2.98076868e-01f, 1.16732702e-01f, -5.41615933e-02f, 1.94222718e-01f, -3.41877788e-01f, 1.32330254e-01f, -1.90304190e-01f, -2.08649650e-01f, 3.15867573e-01f,
  2.24554598e-01f, 3.81164029e-02f, -7.94932246e-02f, -1.10027730e-01f, -4.55018207e-02f, -9.34117064e-02f, 2.46442690e-01f, 2.88714528e-01f, -1.90112576e-01f, 1.17914729e-01f,
  -3.40959102e-01f, 1.19315043e-01f, -3.11004758e-01f, -1.03140935e-01f, 1.95544455e-02f, 7.50459060e-02f, -1.34291381e-01f, 2.83305228e-01f, 1.42320722e-01f, 2.96742588e-01f,
  1.31202281e-01f, 6.25479892e-02f, 1.77885041e-01f, -2.16531724e-01f, 2.18778357e-01f, -1.10691339e-01f, -2.76961774e-01f, -1.42913178e-01f, -2.54338980e-01f, -5.54968752e-02f,
  1.93713948e-01f, -1.76392198e-02f, -1.02505423e-01f, -1.67450458e-01f, -8.42634216e-02f, 6.49320036e-02f, -1.68424007e-02f, -7.23578036e-02f, -1.66025870e-02f, -1.06891155e-01f,
  1.44814979e-03f, 7.10077137e-02f, -1.03527807e-01f, -1.11888461e-01f, -2.81471074e-01f, 2.41934985e-01f, -2.14811206e-01f, 2.32445654e-02f, -3.44760507e-01f, 1.12866145e-02f,
  -5.13775229e-01f, -2.51697987e-01f, -1.14748083e-01f, 1.47280380e-01f, -2.38932863e-01f, 1.35559693e-01f, 8.55622999e-03f, -3.17902714e-01f, 1.17383085e-01f, -4.87500690e-02f,
  -5.56864440e-02f, -4.19825986e-02f, 1.52840525e-01f, -1.27215981e-01f, 1.27295643e-01f, -3.06807011e-02f, -3.21930557e-01f, 8.53340328e-02f, -1.35974720e-01f, 1.20889463e-01f,
  -3.07909727e-01f, 2.47404158e-01f, -7.35134557e-02f, 5.42062009e-03f, 1.25356510e-01f, 5.62429205e-02f, -3.07939440e-01f, -1.17215753e-01f, 1.05529681e-01f, 1.35091737e-01f,
  3.47120948e-02f, -9.11204591e-02f, -2.27452621e-01f, -2.00292140e-01f, 1.56529009e-01f, -6.27702177e-02f, 1.76763743e-01f, -1.80029720e-01f, 2.46716008e-01f, -2.81386703e-01f,
  9.95230153e-02f, 1.89583391e-01f, -3.43534410e-01f, 2.69496650e-01f, 2.88208779e-02f, 7.61200190e-02f, -3.09358120e-01f, -2.22281471e-01f, -6.96119070e-02f, -9.53677967e-02f,
  -3.79418284e-01f, 1.04210958e-01f, 1.63033962e-01f, 4.44223613e-01f, -2.58134425e-01f, 2.50469804e-01f, 3.57511640e-02f, -1.45455122e-01f, 1.54282212e-01f, -5.62280938e-02f,
  -2.22622991e-01f, -1.14571095e-01f, 1.08374305e-01f, -1.93606287e-01f, -4.79050986e-02f, -1.30585492e-01f, -1.72995999e-01f, -1.11896738e-01f, 1.47388643e-02f, 1.21675022e-01f,
  2.93534882e-02f, -2.09954381e-01f, 1.49199054e-01f, -5.50048910e-02f, 7.75674731e-02f, -2.40803435e-01f, -1.02275148e-01f, -1.92275017e-01f, 6.83998242e-02f, 6.26939610e-02f,
  2.24501386e-01f, 1.33056611e-01f, 2.49115527e-02f, -2.83006161e-01f, -4.38626975e-01f, -2.63235748e-01f, 5.57992645e-02f, 1.30204186e-01f, -2.50063151e-01f, -4.05366160e-02f,
  1.02335840e-01f, 1.16406620e-01f, -2.58149922e-01f, 2.76280642e-02f, 9.06654745e-02f, 1.11008048e-01f, -1.22918978e-01f, -3.63546818e-01f, 1.82321578e-01f, 1.23823427e-01f,
  2.09835172e-01f, -1.40211016e-01f, -2.59242833e-01f, 6.58688843e-02f, 1.55684724e-01f, 1.63925022e-01f, -2.08138064e-01f, -5.37361130e-02f, 2.60519385e-02f, 1.55264556e-01f,
  -3.92609611e-02f, -5.59457019e-02f, 1.02525122e-01f, 7.45233439e-04f, -4.77293618e-02f, 1.66365802e-01f, -1.18690863e-01f, -3.07911515e-01f, -2.71979094e-01f, 2.52536863e-01f,
  2.02650055e-01f, 6.66056350e-02f, 1.02871984e-01f, -2.45900705e-01f, 2.38338202e-01f, 5.77127002e-03f, 7.02071413e-02f, 1.33905441e-01f, 7.18450397e-02f, -9.47727412e-02f,
  1.52793661e-01f, -2.79750377e-01f, 2.70246983e-01f, -2.41237655e-01f, -2.03810453e-01f, 1.94200829e-01f, 1.20303124e-01f, 3.97704169e-02f, 9.16117579e-02f, -3.40685427e-01f,
  9.91186723e-02f, -2.89345533e-01f, -1.76335588e-01f, -2.59142131e-01f, 6.59481362e-02f, 2.01542765e-01f, -3.85241322e-02f, 6.77241758e-02f, -1.40747651e-01f, -2.62708306e-01f,
  2.21959323e-01f, -1.62697174e-02f, -6.77078813e-02f, -2.95559838e-02f, -6.31343797e-02f, 1.98235676e-01f, -2.32983291e-01f, 2.08112881e-01f, 2.48406097e-01f, -2.05466568e-01f,
  2.61738241e-01f, -3.66106480e-01f, -1.75928369e-01f, 1.21856995e-01f, -4.43143994e-01f, 7.35784695e-02f, -8.84240121e-02f, 2.37986557e-02f, -1.45165429e-01f, -2.22269818e-01f,
  -2.49728501e-01f, -8.77980590e-02f, 2.00956091e-02f, 1.86381921e-01f, -1.50262699e-01f, -1.61284015e-01f, -7.29771480e-02f, 1.01671129e-01f, -2.01070622e-01f, 3.98055790e-03f,
  -2.57193297e-01f, -2.21361905e-01f, 1.68326825e-01f, 2.32657805e-01f, -7.67082945e-02f, -1.53030694e-01f, 1.24306500e-01f, -1.74251214e-01f, 5.13939895e-02f, -8.85985270e-02f,
  -5.61273061e-02f, -8.32014084e-02f, 2.61834174e-01f, 1.53799266e-01f, -3.61168981e-02f, -3.00767779e-01f, 9.28905457e-02f, -3.65572304e-01f, -1.05561100e-01f, -1.00735016e-01f,
  -1.43479213e-01f, 3.03212076e-01f, -3.66014242e-02f, 1.50936171e-01f, 4.77911811e-03f, 2.41390437e-01f, -2.33793169e-01f, -2.55058646e-01f, 8.61376971e-02f, -1.41158953e-01f,
  -2.76670009e-01f, -2.70948976e-01f, 1.51282459e-01f, -2.43642569e-01f, -2.55090117e-01f, -3.90726149e-01f, -1.59012809e-01f, -7.03566596e-02f, 1.20837234e-01f, -2.32781053e-01f,
  -3.80516239e-02f, -2.89737940e-01f, 7.18087852e-02f, 9.48915705e-02f, 1.08476304e-01f, 2.16946021e-01f, -2.63552725e-01f, -2.32908055e-01f, -8.05121586e-02f, -5.26107140e-02f,
  -1.45875188e-02f, 1.82248458e-01f, -2.86181509e-01f, -1.88294858e-01f, 1.93666741e-01f, -2.19915226e-01f, -4.69657272e-01f, -3.33735555e-01f, 1.05632260e-01f, 6.07902817e-02f,
  5.32333665e-02f, -9.48288664e-02f, -5.03410473e-02f, -3.45712416e-02f, 1.22934818e-01f, 7.19543966e-03f, 6.85098693e-02f, -4.20909703e-01f, 2.15555131e-01f, -1.79242548e-02f,
  5.28786890e-02f, 1.61038324e-01f, -5.05261868e-02f, -1.55058786e-01f, -8.83358251e-03f, -3.34701948e-02f, -3.21648866e-01f, -4.60005254e-02f, -7.22027794e-02f, 1.05521016e-01f,
  -5.20430245e-02f, -1.38427988e-01f, 7.66936541e-02f, -1.12980723e-01f, -1.75457001e-01f, -3.31802107e-02f, -1.23221070e-01f, 7.20635876e-02f, 6.76636472e-02f, -7.24923834e-02f,
  -2.69707646e-02f, 1.41905546e-01f, 1.61975816e-01f, -1.67617083e-01f, 2.21259788e-01f, -9.76043418e-02f, 1.82530165e-01f, 3.15956652e-01f, 3.38777602e-02f, -1.57324523e-01f,
  4.75639552e-02f, -2.70921588e-01f, 1.43042490e-01f, -1.38138905e-01f, 1.49077162e-01f, 1.35218918e-01f, -1.61640093e-01f, -2.35801920e-01f, 8.63452479e-02f, -2.49709278e-01f,
  1.43568262e-01f, -2.16295257e-01f, -2.09897935e-01f, -1.63406238e-01f, 2.79537648e-01f, -2.20547557e-01f, 1.71236753e-01f, -6.51410734e-03f, 1.36482358e-01f, 1.67953163e-01f,
  -3.19818228e-01f, -6.43642768e-02f, 3.28101031e-02f, 2.40917668e-01f, 2.67879814e-02f, 2.57829595e-02f, -2.28975224e-03f, -2.93446500e-02f, -3.20432007e-01f, 1.89785287e-01f,
  1.63892046e-01f, 6.60893843e-02f, -2.90518761e-01f, -2.04570025e-01f, -1.12409323e-01f, 4.72251652e-03f, 1.83204219e-01f, -2.31088817e-01f, -3.16541284e-01f, 3.09610361e-04f,
  -1.25394121e-01f, -1.33370385e-01f, -3.51561271e-02f, 9.08999741e-02f, -7.77557567e-02f, -2.75000542e-01f, -1.25184044e-01f, 2.70544887e-01f, -2.02018231e-01f, 2.97697753e-01f,
  -1.81722566e-01f, 2.34146103e-01f, -1.73965454e-01f, 4.31698486e-02f, -9.46595625e-04f, 1.08696803e-01f, -3.30206119e-02f, 1.94211870e-01f, -1.61696002e-01f, 3.04082334e-01f,
  6.74200729e-02f, 4.28019464e-02f, 3.54019016e-01f, -3.28364640e-01f, 2.68187344e-01f, 1.34994835e-01f, -1.65992200e-01f, 8.38478804e-02f, -2.58416533e-01f, -2.86336631e-01f,
  -1.10396631e-01f, -1.45618498e-01f, -1.89952642e-01f, 1.05985053e-01f, -1.62965193e-01f, -2.38291770e-01f, 2.17215851e-01f, 1.46474853e-01f, -1.43558413e-01f, -3.09257209e-01f,
  -8.65382701e-02f, -2.48916045e-01f, 9.85783059e-03f, -2.34229356e-01f, -2.38025382e-01f, -2.02508971e-01f, 1.72472209e-01f, 1.98831454e-01f, -5.41804992e-02f, 2.00950727e-01f,
  9.76696610e-02f, 2.08064184e-01f, -8.31280649e-02f, 1.53140143e-01f, 2.24909410e-01f, -4.49459106e-01f, -3.44635099e-01f, -2.02701882e-01f, 9.16488767e-02f, 8.35986808e-02f,
  -4.15933907e-01f, -9.74776521e-02f, -3.42411488e-01f, -1.81423813e-01f, 1.71960250e-01f, -2.16737673e-01f, 1.65914103e-01f, -1.16607763e-01f, 2.75187701e-01f, -2.21009567e-01f,
  -4.09699559e-01f, -1.86583310e-01f, -3.89472723e-01f, -4.31259751e-01f, 1.45459101e-01f, -5.19448482e-02f, -1.39905080e-01f, -4.25966233e-01f, 1.57538891e-01f, -4.27775783e-03f,
  1.70300633e-01f, -2.30134323e-01f, -6.55805320e-03f, -2.86061347e-01f, 2.79517502e-01f, -2.14483812e-01f, -1.17199235e-01f, 2.72473432e-02f, -2.14574233e-01f, -1.73569396e-01f,
  1.15036540e-01f, -2.08102629e-01f, -1.34353973e-02f, -3.20631802e-01f, 1.21154949e-01f, 1.31449401e-01f, 9.60195586e-02f, -4.74768579e-02f, -9.28840935e-02f, -2.83231169e-01f,
  -1.71735331e-01f, -9.33396518e-02f, -1.75638109e-01f, -7.78729990e-02f, 1.55107602e-01f, -8.76386687e-02f, 2.59638101e-01f, -7.34137893e-02f, 7.16447681e-02f, 1.72677115e-01f,
  8.13198015e-02f, 3.70054245e-02f, 4.62973230e-02f, -6.37000725e-02f, -5.51406257e-02f, -8.91818553e-02f, 1.35441408e-01f, 2.62571394e-01f, -5.73424660e-02f, -1.12932913e-01f,
  5.53543679e-02f, -6.48393435e-03f, -9.29186270e-02f, -2.71586299e-01f, -2.85169244e-01f, -3.31783667e-04f, 2.01919466e-01f, 1.34229124e-01f, -4.03900504e-01f, -1.72526464e-01f,
  2.22025365e-02f, 1.41243488e-01f, -2.08036676e-01f, -1.03860736e-01f, -2.61156380e-01f, -1.40995488e-01f, 2.97753125e-01f, -1.85781658e-01f, 1.72186822e-01f, -1.80089414e-01f,
  2.49491572e-01f, 4.00275946e-01f, -2.79930353e-01f, -1.01854339e-01f, -2.65801430e-01f, 2.50105858e-01f, 3.11337918e-01f, 1.76540032e-01f, -1.23862028e-01f, 6.28847778e-02f,
  6.77731484e-02f, -1.74219027e-01f, 2.01725021e-01f, -9.46099013e-02f, -7.21496269e-02f, -3.04361254e-01f, -3.59956414e-01f, 7.75652602e-02f, -2.55137026e-01f, -1.68137491e-01f,
  -2.11688690e-02f, -1.75262943e-01f, -1.04749396e-01f, 1.10620342e-01f, 1.33541524e-02f, 2.84600705e-01f, -1.90092698e-01f, -2.44940922e-01f, -2.08421052e-02f, 1.72358483e-01f,
  -1.22512423e-01f, -2.55314171e-01f, 7.01563358e-02f, 4.83151637e-02f, 1.34581789e-01f, 2.03455895e-01f, 1.52552798e-01f, -1.01380646e-01f, 1.52964234e-01f, 3.74582224e-02f,
  3.63954782e-01f, -1.44838430e-02f, 1.12152249e-01f, 1.06214315e-01f, -1.43682107e-01f, -1.14619926e-01f, 1.73084572e-01f, -1.95261732e-01f, -2.78445691e-01f, -1.90772384e-01f,
  -3.56948674e-01f, -8.58713537e-02f, 3.44185159e-03f, 1.07230134e-01f, -5.27139902e-02f, -1.96105063e-01f, -2.47689441e-01f, 2.42320895e-01f, 1.01706661e-01f, -9.36167911e-02f,
  8.18984061e-02f, 1.59869120e-01f, -3.03613156e-01f, 2.10265771e-01f, -2.27964506e-01f, 1.36312380e-01f, -6.75992072e-02f, 2.39956342e-02f, -7.34948665e-02f, -1.08511917e-01f,
  -2.67968982e-01f, 4.92421389e-02f, -1.87450603e-01f, 1.81334540e-01f, -3.61184150e-01f, -2.73582667e-01f, 5.07122800e-02f, 1.06218360e-01f, 4.41642888e-02f, -3.46262366e-01f,
  2.29287684e-01f, -1.39023019e-02f, -3.00614804e-01f, -2.93391794e-01f, 2.71207057e-02f, 2.14431047e-01f, 3.39005142e-01f, 2.94987690e-02f, 2.60512054e-01f, -1.92004561e-01f,
  1.81193668e-02f, -5.46932034e-03f, -3.02600890e-01f, -8.15771520e-02f, -1.50435371e-02f, 2.69566178e-01f, -1.44360617e-01f, -1.71796888e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.61096931e-01f, 1.05984122e-01f, -4.66685221e-02f, -1.14395000e-01f, 4.16192338e-02f, 1.16093390e-01f, 1.88404582e-02f, -1.11786146e-02f, -4.57454793e-04f, -7.67018721e-02f,
  5.87331802e-02f, 1.25996500e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    