/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.14192504e-01f, -4.53688502e-02f, 8.10587332e-02f, 2.07694665e-01f, 2.82674450e-02f, -7.34323934e-02f, 3.39435302e-02f, -4.15259898e-02f, 1.06169000e-01f, -6.71738088e-02f,
  -8.32719132e-02f, 2.77761966e-01f, -1.90987676e-01f, 1.02087945e-01f, -6.56069070e-02f, -1.12558179e-01f, 9.93239284e-02f, 1.59274429e-01f, 8.14494267e-02f, 1.27080753e-01f,
  1.04827538e-01f, 8.18684101e-02f, -2.35065632e-02f, 1.03375595e-02f, 2.03071252e-01f, 6.98982924e-02f, -6.56561088e-03f, -2.15788446e-02f, 2.78031304e-02f, 1.26060806e-02f,
  -4.36598584e-02f, 3.98369394e-02f, 8.39156732e-02f, 2.26904117e-02f, 3.70695032e-02f, -6.93025673e-03f, -1.07658338e-02f, 6.03980757e-03f, 2.13952065e-02f, -4.53560874e-02f,
  2.14798544e-02f, 6.53364370e-03f, 3.51032466e-02f, 2.13934686e-02f, 5.16649298e-02f, -5.96970133e-02f, -3.58162932e-02f, -7.94381741e-03f, -5.34521304e-02f, -3.08695994e-02f,
  -2.07835473e-02f, -6.60262927e-02f, 1.86153017e-02f, -4.58020456e-02f, 3.51332948e-02f, -4.68900567e-03f, 3.24086137e-02f, 1.81819312e-02f, 4.60571162e-02f, 7.52634660e-04f,
  -1.71748810e-02f, 8.49746689e-02f, 7.29104728e-02f, 1.77570581e-02f, 5.44060767e-02f, -2.61389799e-02f, -3.37375738e-02f, -2.16140766e-02f, 1.08588658e-01f, 6.15109981e-04f,
  1.61816888e-02f, -2.73783575e-03f, -1.39133018e-02f, 2.30332520e-02f, 2.82624625e-02f, -4.02588807e-02f, 3.10632866e-02f, 4.29759100e-02f, 4.19966429e-02f, 2.24541072e-02f,
  -5.18929660e-02f, -9.42264777e-03f, -1.74079388e-02f, -3.12635005e-02f, -6.92338496e-02f, -9.29094758e-03f, 2.20693517e-02f, 1.38112037e-02f, 1.62584111e-02f, -1.85524020e-02f,
  -7.55494535e-02f, -1.77975491e-01f, -3.97268832e-02f, -5.56696765e-03f, -6.03721999e-02f, -1.23438716e-03f, 3.03216800e-02f, 4.29431610e-02f, -3.79607528e-02f, 3.82728279e-02f,
  -1.10278614e-02f, 7.78196147e-03f, -1.71514007e-03f, 2.65711511e-04f, 1.07394662e-02f, 6.73164288e-03f, 2.16529127e-02f, -1.95463672e-02f, 5.30983508e-02f, -4.49094772e-02f,
  -2.18968689e-02f, 3.25281993e-02f, 4.00175042e-02f, 2.86001358e-02f, -1.98085350e-03f, -6.05244562e-02f, 1.23110823e-02f, 1.71280783e-02f, -3.94004174e-02f, -3.77553366e-02f,
  -2.67682523e-01f, -1.69171870e-01f, 1.36055678e-01f, -2.00560868e-01f, 2.60948598e-01f, 2.41405368e-01f, 8.36181045e-02f, 3.28939222e-02f, -2.92601492e-02f, -1.76033676e-01f,
  -6.09173924e-02f, -5.45312688e-02f, -2.52490607e-03f, 2.85046212e-02f, 1.93177775e-01f, 9.08716992e-02f, 7.26033598e-02f, -1.17841028e-01f, 1.36217009e-02f, -8.12729225e-02f,
  -3.55825364e-03f, 6.99735358e-02f, 1.44185424e-01f, 1.51813820e-01f, 4.70086187e-02f, -1.20864831e-01f, -5.28127700e-02f, 1.11990064e-01f, -1.03824185e-02f, 8.18941519e-02f,
  -4.22239639e-02f, -2.19625413e-01f, 3.53669301e-02f, -1.62138976e-03f, 2.63895420e-03f, -1.52296703e-02f, -9.32646692e-02f, 1.02244750e-01f, -4.03778367e-02f, -9.87580139e-03f,
  -4.56842855e-02f, -8.65859445e-03f, 8.52228515e-03f, 1.53583558e-02f, -5.45751527e-02f, 1.04883090e-02f, 5.20168012e-03f, 3.91347259e-02f, 5.90163516e-03f, 6.44275844e-02f,
  2.23280266e-02f, -4.89675766e-03f, -1.65045857e-02f, -2.93888990e-02f, 7.98616037e-02f, 8.50487407e-03f, -1.39985913e-02f, 3.28722186e-02f, -5.87943494e-02f, 3.56118903e-02f,
  -6.62606284e-02f, -5.41209988e-02f, -6.33159429e-02f, -4.54123989e-02f, -5.05496264e-02f, -1.53021254e-02f, -3.93784381e-02f, -9.24263243e-03f, -4.86313961e-02f, 7.28389844e-02f,
  4.71093357e-02f, -2.27893423e-02f, 1.30294040e-02f, -3.94691378e-02f, -4.10508662e-02f, -7.32832700e-02f, 1.88234430e-02f, 1.24518212e-03f, 2.00741980e-02f, 6.53003110e-03f,
  -2.48988904e-02f, -1.75842084e-02f, -2.46420279e-02f, -4.26577739e-02f, 1.09590767e-02f, 2.05762424e-02f, 9.21405107e-03f, 3.99389975e-02f, -4.11128886e-02f, 3.23949307e-02f,
  -1.94360450e-01f, -2.31832504e-01f, 7.94862360e-02f, -5.98174110e-02f, 4.52433415e-02f, 8.73675942e-03f, -2.72929017e-02f, 2.19746996e-02f, -3.73762362e-02f, 3.00652515e-02f,
  -1.13178166e-02f, -4.02983278e-02f, -1.05863763e-02f, 3.50701213e-02f, 4.75027831e-03f, 7.81013966e-02f, -6.84153438e-02f, -6.76415453e-04f, -5.00216298e-02f, -2.79449369e-03f,
  -4.85132150e-02f, -1.22228768e-02f, 5.63106081e-03f, -1.18479505e-03f, -6.98486045e-02f, -2.44519133e-02f, -6.71582744e-02f, 1.96015142e-04f, -1.67900138e-03f, 1.21653499e-02f,
  4.86873053e-02f, -5.44530228e-02f, 2.20934674e-01f, 6.85488507e-02f, 3.54634337e-02f, -8.44871029e-02f, -1.67460978e-01f, 2.41952133e-04f, -6.11133501e-03f, -2.64073521e-01f,
  -1.44528970e-01f, 1.22749805e-01f, -1.80728491e-02f, -1.61264509e-01f, 2.03137502e-01f, -5.08137699e-03f, -1.24852039e-01f, -8.54226276e-02f, 6.42433912e-02f, -8.69278684e-02f,
  7.98823312e-02f, -2.23214164e-01f, 1.61445111e-01f, -4.86988947e-02f, -4.49309275e-02f, 1.13224708e-01f, 6.23334013e-02f, 2.58417912e-02f, 1.06495922e-03f, 1.02286957e-01f,
  -1.44395575e-01f, 5.29809222e-02f, 3.10351159e-02f, -4.00853679e-02f, -5.68596460e-02f, 7.34781194e-03f, -3.23206279e-03f, 2.11398881e-02f, 1.80482138e-02f, 2.02124249e-02f,
  -1.19054625e-02f, 5.51898070e-02f, 1.71298720e-03f, 1.24034006e-02f, 1.18899357e-03f, 3.56807448e-02f, 4.35187109e-02f, 1.15370164e-02f, 3.23404558e-02f, 5.58294170e-02f,
  9.03578103e-02f, 6.39190599e-02f, 4.20628022e-03f, -3.04788090e-02f, 1.12353757e-01f, -9.45307966e-03f, 3.48237865e-02f, 7.49791041e-02f, 4.01731767e-02f, 8.83570835e-02f,
  -2.94819400e-02f, 1.99595112e-02f, 1.03388475e-02f, -2.17123386e-02f, -1.05726328e-02f, 2.28464138e-03f, -2.43278462e-02f, 1.13476068e-02f, -6.94334460e-03f, 1.06865680e-02f,
  3.16021144e-02f, 6.34206180e-03f, 1.55873913e-02f, 2.00022422e-02f, -4.05890821e-03f, -6.48720935e-02f, 3.42087485e-02f, 1.88112911e-02f, 2.60815248e-02f, 2.87693031e-02f,
  1.82731822e-02f, 2.31913980e-02f, 6.64783083e-03f, -4.73954603e-02f, -1.94208063e-02f, 4.35575321e-02f, 3.52816936e-03f, -1.41554940e-02f, -3.51671204e-02f, 3.12973298e-02f,
  -1.77289799e-01f, -1.22956753e-01f, -6.23477809e-03f, 1.53704258e-02f, -3.33966240e-02f, 1.45883588e-02f, 3.44088785e-02f, -4.92188521e-03f, -3.37874517e-02f, -6.07621856e-02f,
  -4.79675569e-02f, -4.65774685e-02f, -2.89484244e-02f, -2.75825914e-02f, 4.77852020e-03f, 5.01747197e-03f, -7.57182497e-05f, -6.14276528e-02f, -4.69610319e-02f, 1.57047007e-02f,
  -4.93919887e-02f, -3.73372622e-02f, 4.50315699e-02f, 5.26876636e-02f, -5.12022600e-02f, -7.40577059e-04f, -2.83959024e-02f, 2.04254724e-02f, 4.76403013e-02f, -9.06722713e-03f,
  -4.24322546e-01f, 1.04261689e-01f, 9.79111716e-03f, -1.65452227e-01f, -1.48505613e-01f, -8.54143202e-02f, -1.59136504e-01f, 6.71269745e-02f, -7.71671608e-02f, 1.06414773e-01f,
  -1.03766665e-01f, -4.55168374e-02f, 1.88574761e-01f, -2.94864736e-02f, -1.17285319e-01f, 3.04915547e-01f, -1.81800097e-01f, -3.47572267e-02f, 1.15656063e-01f, -1.62049770e-01f,
  -7.57787656e-03f, -1.39042363e-01f, 1.18018672e-01f, 7.58394599e-02f, -1.64125517e-01f, -1.85416993e-02f, -6.21334426e-02f, 1.22290608e-02f, -6.17153831e-02f, -4.40898687e-02f,
  4.96828370e-02f, 8.22114125e-02f, 2.28473451e-02f, 1.05131611e-01f, -6.61356300e-02f, -8.07347819e-02f, -7.67298695e-03f, -1.22886794e-02f, -1.47089455e-02f, 4.16005999e-02f,
  -4.15026490e-03f, -2.26204637e-02f, -1.64334953e-03f, 7.06565604e-02f, -2.38634795e-02f, 5.37009872e-02f, 9.91508514e-02f, -1.50059797e-02f, -7.27051497e-02f, 3.86643112e-02f,
  6.81061149e-02f, -6.87792664e-03f, -8.03681687e-02f, 7.50877475e-03f, -9.35109928e-02f, 1.45767974e-02f, 4.32484001e-02f, -5.02644330e-02f, 1.54800965e-02f, -6.20463304e-03f,
  -4.12146598e-02f, -4.93395999e-02f, 1.47064282e-02f, 7.14604557e-02f, -1.18263047e-02f, 1.95930116e-02f, -9.96991806e-03f, 5.66634489e-03f, -1.86536219e-02f, 1.57809760e-02f,
  -3.34034599e-02f, -6.13883846e-02f, -1.79069694e-02f, -2.69334018e-02f, -3.40235084e-02f, 1.53190168e-02f, 9.43532586e-03f, 3.56276818e-02f, -3.07180136e-02f, 5.54529987e-02f,
  3.22165457e-03f, -5.49129918e-02f, 4.33417857e-02f, -2.68949904e-02f, 1.55331222e-02f, -9.02342983e-03f, -6.20598644e-02f, 2.49718688e-02f, -1.78008154e-02f, -6.06193505e-02f,
  -8.85625705e-02f, -2.01965779e-01f, -6.76577389e-02f, 3.51167955e-02f, 3.71874422e-02f, 3.96358557e-02f, 1.21303694e-02f, -2.37226039e-02f, -1.72212478e-02f, -4.53148186e-02f,
  -3.59441037e-03f, -9.95666138e-04f, -6.35386854e-02f, -1.52098369e-02f, 2.81670243e-02f, -7.68970922e-02f, -7.70534500e-02f, -3.39594670e-02f, -9.45683420e-02f, -6.83262721e-02f,
  -2.72356272e-02f, -5.23990169e-02f, 2.54826248e-03f, -3.41921076e-02f, -1.47143994e-02f, -3.96268629e-02f, -3.81312929e-02f, -4.66412958e-03f, -5.19677177e-02f, -3.26874629e-02f,
  6.45872772e-01f, 1.85148850e-01f, 3.31223831e-02f, 4.00984079e-01f, 8.81917626e-02f, 7.89152682e-02f, -2.54323035e-02f, 2.32762814e-01f, 3.74581724e-01f, 1.23079136e-01f,
  -5.21605462e-02f, 1.68367431e-01f, -2.44363964e-01f, 3.62719186e-02f, -2.39867195e-02f, -1.11859597e-01f, 2.51262277e-01f, 1.81156144e-01f, -1.55916642e-02f, 2.27700949e-01f,
  1.71949327e-01f, 5.95664838e-03f, -1.09513484e-01f, -3.26907560e-02f, 1.17576130e-01f, 1.01168729e-01f, -4.91349958e-02f, -1.84990838e-01f, 1.40239643e-02f, -1.93299949e-01f,
  2.41832864e-02f, 1.84839353e-01f, -5.20947129e-02f, 1.83177111e-03f, 2.22146064e-02f, 1.73560940e-02f, -4.30885181e-02f, -1.62528202e-01f, -2.59812959e-02f, 4.52195620e-03f,
  -3.14384550e-02f, 1.81636568e-02f, 3.44615765e-02f, -7.09670484e-02f, 6.44380823e-02f, 4.45055626e-02f, -1.52054625e-02f, 3.28400061e-02f, -1.09504648e-02f, -3.85232605e-02f,
  -6.64814934e-03f, 4.32702131e-04f, -1.50934304e-03f, -1.47486767e-02f, -2.68789735e-02f, 4.13511507e-02f, 2.03079847e-03f, -4.42285500e-02f, 1.09444568e-02f, 3.44613120e-02f,
  -2.17677671e-02f, -9.48263146e-03f, -5.73339500e-02f, -7.08770519e-03f, -4.61482853e-02f, -3.83623987e-02f, -1.84617110e-03f, -1.56780928e-02f, -2.32289080e-02f, 4.66663353e-02f,
  5.18697612e-02f, 6.60617575e-02f, -5.84750623e-03f, 2.67902538e-02f, -2.61958060e-03f, 6.50630286e-03f, 3.28091066e-03f, 5.99968359e-02f, 5.90933077e-02f, 4.89986725e-02f,
  2.46068742e-02f, 3.26565914e-02f, 1.87032241e-02f, -2.50607752e-03f, -2.04350743e-02f, -3.71985398e-02f, 3.98003981e-02f, -8.69793631e-03f, -3.42416875e-02f, 2.73131002e-02f,
  3.04919511e-01f, 3.26647490e-01f, -1.44944107e-02f, 3.54928412e-02f, -3.83005738e-02f, -2.64324807e-02f, 6.54388517e-02f, 4.63580154e-02f, 4.79224790e-03f, -3.64660122e-03f,
  3.80456559e-02f, 1.95244402e-02f, 4.28697243e-02f, 5.22442088e-02f, -1.38301505e-02f, 3.04224696e-02f, -1.27255265e-02f, 6.50696680e-02f, 3.80978510e-02f, 7.34178117e-03f,
  5.53547367e-02f, 1.20094167e-02f, -1.10339066e-02f, 3.70290950e-02f, 1.61315147e-02f, -1.01073748e-02f, 7.15851635e-02f, 1.96268335e-02f, -3.65516767e-02f, 4.46892194e-02f,
  -7.69676343e-02f, -1.72657922e-01f, -2.88774878e-01f, 5.66735603e-02f, 9.27986279e-02f, -3.63201462e-02f, -2.72168875e-01f, 1.33373082e-01f, -2.55460262e-01f, 2.18279511e-02f,
  1.05412230e-01f, -3.38491239e-02f, -1.12920612e-01f, 3.37021500e-02f, 1.97290421e-01f, -1.14373073e-01f, -1.56605244e-02f, 7.18634799e-02f, -1.58313699e-02f, 7.67228901e-02f,
  3.91134620e-02f, 2.85047174e-01f, 1.47827184e-02f, 2.57441938e-01f, 7.37129301e-02f, 1.02496214e-01f, 2.99026698e-01f, -8.21767673e-02f, 2.04552010e-01f, -5.77863678e-02f,
  -2.59660725e-02f, -1.25673458e-01f, 7.19042169e-03f, -4.75463606e-02f, 9.72892269e-02f, -2.95436732e-03f, 1.23839509e-02f, -4.30841483e-02f, -2.52003744e-02f, -7.94395711e-03f,
  -3.85205494e-03f, 1.55701879e-02f, -2.24755313e-02f, -4.62995423e-03f, -1.16066121e-01f, 9.15221311e-03f, -4.25085276e-02f, 5.32067660e-03f, -3.32933553e-02f, -9.83983427e-02f,
  -4.55731452e-02f, -5.98776201e-03f, -3.20155360e-02f, -2.03404780e-02f, -1.29069975e-02f, -6.39784709e-02f, 1.51527468e-02f, -1.47287445e-02f, 9.96929314e-03f, 9.11551120e-04f,
  -3.92234884e-02f, -6.72843233e-02f, 2.86862664e-02f, 1.11068450e-02f, 8.68363827e-02f, 3.12762260e-02f, 1.06904435e-03f, 1.98900588e-02f, 3.53550515e-03f, 2.44067535e-02f,
  8.68755803e-02f, 2.83062179e-03f, 3.70690832e-03f, -6.71474859e-02f, 4.43594418e-02f, -3.97608243e-02f, 4.41431142e-02f, -6.35638880e-03f, -3.82895842e-02f, 9.19712428e-03f,
  -3.67490500e-02f, -4.88714352e-02f, -5.38561167e-03f, 4.57786880e-02f, 2.03223131e-03f, 2.78571695e-02f, 5.42748906e-03f, -6.49508983e-02f, -2.64865328e-02f, 2.32501421e-02f,
  1.86761111e-01f, 2.93655753e-01f, 5.90294302e-02f, 4.07663733e-02f, 6.80903569e-02f, 6.62025362e-02f, 3.23994197e-02f, 1.98654626e-02f, 4.77965688e-03f, 2.33468413e-02f,
  3.25618908e-02f, -1.90571025e-02f, 1.31010804e-02f, -5.34370821e-03f, 2.62427535e-02f, -1.92919653e-02f, -2.99403444e-03f, 8.12274367e-02f, 7.19870850e-02f, 7.48298615e-02f,
  5.48622794e-02f, 4.37794924e-02f, 3.03402785e-02f, 1.33988768e-01f, -2.60846107e-03f, 3.71313430e-02f, 2.51552146e-02f, -3.69318551e-03f, 2.07458828e-02f, -8.23655128e-02f,
  -6.07014773e-03f, 3.42102796e-01f, 2.81748921e-02f, 1.38937339e-01f, -1.59130618e-01f, -2.12305844e-01f, -2.05862597e-01f, 1.18217632e-01f, 5.55233695e-02f, 4.77086045e-02f,
  -7.40792304e-02f, 9.29239467e-02f, -6.42645583e-02f, 1.65871218e-01f, -8.35750923e-02f, 1.38025299e-01f, 1.19289503e-01f, 6.44811541e-02f, 1.26147196e-01f, 5.77675663e-02f,
  9.79831666e-02f, 2.29208954e-02f, 1.44833907e-01f, 3.75807472e-02f, 4.11722586e-02f, 1.12777196e-01f, -4.59667295e-02f, -9.44015235e-02f, 8.34669732e-03f, -5.22821508e-02f,
  3.64125334e-02f, 1.83114037e-01f, 4.15793434e-02f, -5.64759634e-02f, -1.03574380e-01f, -8.73747244e-02f, -8.21118802e-02f, -8.54779631e-02f, -2.06530057e-02f, -7.10930396e-03f,
  -8.52369368e-02f, 1.81526188e-02f, 8.75154743e-04f, -2.07416210e-02f, -3.65693644e-02f, 3.66791822e-02f, 1.92239955e-02f, -5.26066236e-02f, -3.10790129e-02f, 3.29123847e-02f,
  6.37531234e-03f, -2.64922101e-02f, 2.98707969e-02f, 6.33086562e-02f, 1.60658602e-02f, -1.64920166e-02f, 2.96598542e-02f, -3.40760686e-02f, -7.10786059e-02f, 2.75612380e-02f,
  -1.11065554e-02f, -1.77198444e-02f, 4.58486527e-02f, -7.34855421e-03f, 4.94145676e-02f, -9.30400938e-03f, 4.58491594e-03f, -3.02132368e-02f, 1.82053689e-02f, -2.83355992e-02f,
  -6.70751929e-02f, -5.26100677e-03f, 7.41843507e-03f, 2.85847462e-03f, 3.62178609e-02f, 1.55056939e-02f, -2.80029792e-02f, 7.30572939e-02f, 3.51395225e-04f, 2.75765406e-03f,
  6.10025716e-04f, 3.25030237e-02f, 2.84378510e-02f, 2.16853172e-02f, -7.72791728e-02f, -7.73808360e-03f, 4.34597060e-02f, 5.99897429e-02f, -1.59844998e-02f, -3.96839119e-02f,
  3.69607620e-02f, 1.72829092e-01f, 6.19222745e-02f, -1.39034376e-03f, -1.50978360e-02f, -2.32578535e-02f, 3.71918716e-02f, -1.78429503e-02f, 1.90744512e-02f, -1.58034600e-02f,
  -1.75274815e-02f, 5.03508411e-02f, -3.67650315e-02f, 1.04012173e-02f, -3.83966137e-03f, -6.90714046e-02f, 4.51650135e-02f, 1.69173721e-02f, -2.53773071e-02f, -7.09052430e-03f,
  -1.95802730e-02f, -1.52646946e-02f, -6.67570275e-04f, -2.60533323e-03f, -5.63045368e-02f, 4.36458457e-03f, -1.65337175e-02f, 4.28929068e-02f, 2.83997897e-02f, -5.52511811e-02f,
  4.37190026e-01f, 1.11471564e-01f, 2.55901814e-01f, -1.66052714e-01f, 3.36338282e-02f, 1.54876992e-01f, 1.13668658e-01f, 6.66658953e-02f, 2.49166340e-01f, -7.30036423e-02f,
  -2.77369376e-02f, 3.41846198e-02f, 5.31161465e-02f, -1.29649818e-01f, -4.93004061e-02f, -3.78806219e-02f, -2.25105405e-01f, -1.35797858e-01f, -5.25174774e-02f, -2.53389720e-02f,
  -1.05418518e-01f, -2.71385342e-01f, -1.83493778e-01f, -2.00267166e-01f, 8.68099090e-03f, 4.17070091e-02f, -2.00330466e-01f, -3.15111354e-02f, -1.84321597e-01f, -3.71033736e-02f,
  -1.02079203e-02f, 1.95142671e-01f, 7.22666904e-02f, 3.64717431e-02f, 1.26744539e-03f, 1.26428157e-02f, -6.24726787e-02f, 1.78804137e-02f, 2.89579481e-02f, 3.07398252e-02f,
  1.61645059e-02f, 5.83105944e-02f, -6.00557104e-02f, -6.54923171e-03f, 6.42674193e-02f, 6.16410673e-02f, 3.45491245e-02f, 9.26972553e-03f, 3.32544670e-02f, -2.09671482e-02f,
  2.69732475e-02f, 2.16104146e-02f, 1.05683291e-02f, -1.56191783e-02f, 3.81292449e-03f, 4.92176116e-02f, -2.85581108e-02f, 3.14016938e-02f, 3.17455418e-02f, 5.77120185e-02f,
  7.21556544e-02f, -5.21703623e-02f, -1.87536934e-03f, -4.66114804e-02f, 9.40472179e-04f, -6.06575690e-04f, -6.69158176e-02f, -3.53714190e-02f, -2.05124225e-02f, -5.27236760e-02f,
  1.61537398e-02f, -3.46432924e-02f, 1.21053904e-02f, -2.04166950e-04f, -2.13736538e-02f, -1.43523775e-02f, -1.70741212e-02f, -1.02620803e-01f, -4.54317518e-02f, -6.59013316e-02f,
  1.14848390e-02f, -5.73558547e-03f, -3.11451610e-02f, 9.73982643e-03f, 2.48396234e-03f, -1.51044000e-02f, -3.63947973e-02f, 3.23249958e-02f, 4.08216380e-03f, -4.98255379e-02f,
  -3.04468907e-02f, -2.46340092e-02f, -7.68582849e-03f, 8.69114790e-03f, -5.05492017e-02f, 3.69117446e-02f, 1.15727894e-02f, 1.85235459e-02f, -1.47808790e-02f, 4.38477471e-02f,
  5.54268770e-02f, -4.91943359e-02f, 2.10977644e-02f, 6.34594448e-03f, -6.94161952e-02f, -2.49372236e-02f, -9.49722528e-02f, 3.43089700e-02f, -1.39101110e-02f, -6.95839450e-02f,
  -7.15475008e-02f, -1.69062763e-02f, -2.42768303e-02f, -1.17245158e-02f, -7.29415640e-02f, -1.14008179e-02f, 4.59787212e-02f, 1.87472627e-02f, -1.07897438e-01f, -2.02223770e-02f,
  -1.04647584e-01f, 3.08123410e-01f, 1.78002432e-01f, 2.52478719e-02f, 2.31252611e-02f, -1.89832970e-01f, -3.57530087e-01f, 2.72926778e-01f, 1.50125295e-01f, -1.05423830e-01f,
  -1.58451840e-01f, 6.67912746e-03f, -3.08306403e-02f, -5.93708940e-02f, -2.01283231e-01f, 2.53980402e-02f, -1.81875303e-01f, -9.70390290e-02f, 2.17974856e-01f, 1.00712257e-03f,
  6.97233528e-02f, -2.17627093e-01f, 7.53128901e-02f, 6.00861497e-02f, 8.13420340e-02f, 1.56738505e-01f, -1.36657387e-01f, 7.31830224e-02f, -7.30122626e-02f, -5.50087094e-02f,
  3.62103917e-02f, 8.21081996e-02f, 1.18201086e-02f, 4.11558002e-02f, -2.84859706e-02f, -2.47264449e-02f, -1.31137162e-01f, -6.05427288e-02f, 5.51842910e-04f, 8.99130013e-03f,
  -7.53570050e-02f, 1.69540849e-02f, 3.35594751e-02f, 6.85262680e-02f, 1.21209063e-02f, 1.23945616e-01f, 5.27239442e-02f, 1.59948580e-02f, 6.39218017e-02f, 9.17883664e-02f,
  1.51520660e-02f, 5.24228103e-02f, -3.43172736e-02f, -9.82614979e-02f, 2.57755648e-02f, 3.28440145e-02f, -3.97453383e-02f, -7.07830936e-02f, 1.96421389e-02f, -1.50655201e-02f,
  -6.46508262e-02f, 6.23860285e-02f, -6.21025562e-02f, 1.18212499e-01f, 1.33469724e-03f, 4.19469588e-02f, -2.75258664e-02f, -7.00419992e-02f, 6.04310632e-03f, -5.40471524e-02f,
  -4.70290445e-02f, 8.82136170e-03f, -1.49906310e-03f, 2.59208474e-02f, -1.47080384e-02f, -9.83520783e-03f, -4.46816944e-02f, -2.68874578e-02f, 3.45449289e-03f, 3.71197760e-02f,
  2.50369366e-02f, -5.30796424e-02f, 4.72246706e-02f, -1.59977823e-02f, 2.72560809e-02f, 1.09250052e-03f, -3.70690972e-03f, 5.56898601e-02f, 2.44826935e-02f, -7.31377453e-02f,
  -1.84019431e-01f, -5.67981750e-02f, 5.53203151e-02f, -3.49212699e-02f, 7.57016689e-02f, 1.35082649e-02f, 9.21529457e-02f, 3.31572220e-02f, 7.83608407e-02f, -3.22504081e-02f,
  -6.40159026e-02f, 1.06325569e-02f, -6.90670162e-02f, -5.50991558e-02f, -9.10277106e-03f, -4.02201973e-02f, -6.23854585e-02f, -2.91951522e-02f, -3.71376723e-02f, 2.32434161e-02f,
  -3.79515477e-02f, -7.14060217e-02f, -5.63796796e-02f, 1.95302851e-02f, -1.73788555e-02f, -1.21205725e-01f, -1.49182389e-02f, 4.25107824e-03f, -3.04821283e-02f, 4.98232432e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.69476444e-01f, 2.70878315e-01f, -8.63962620e-02f, -1.32490054e-01f, 1.12145752e-01f, -1.49109587e-01f, -7.77261853e-02f, 3.62485871e-02f, -7.08395466e-02f, 3.33929151e-01f,
  5.30952364e-02f, 1.34604007e-01f, 6.42495528e-02f, -1.59561336e-01f, -6.62139833e-01f, -2.48801276e-01f, -2.37340614e-01f, -2.89563532e-03f, -1.69615358e-01f, 7.94017762e-02f,
  -2.41771057e-01f, 1.35494452e-02f, -2.46087760e-01f, 1.85444251e-01f, 8.98489282e-02f, 1.09420709e-01f, -3.00641134e-02f, 1.52693912e-01f, -9.89801884e-02f, -8.08831211e-03f,
  6.99006543e-02f, 1.66735634e-01f, 1.29882306e-01f, 2.07233727e-02f, -4.48322371e-02f, -3.16374637e-02f, 7.34133879e-03f, 3.83845046e-02f, -6.66698292e-02f, -1.09635349e-02f,
  -2.17711274e-02f, 1.36655355e-02f, -6.70320615e-02f, -2.89088413e-02f, -1.82433687e-02f, 1.96015574e-02f, -3.03403158e-02f, -6.11354085e-03f, 9.11919251e-02f, -5.88424988e-02f,
  -5.00547187e-03f, -1.97945014e-02f, -6.43034745e-03f, -1.00058191e-01f, -6.81056753e-02f, 6.56782463e-02f, -9.16356593e-02f, 1.36242881e-02f, -3.86892036e-02f, -2.83713154e-02f,
  -5.90900928e-02f, -3.13670188e-02f, -3.76120023e-03f, -3.38854678e-02f, 4.00630906e-02f, 5.61859868e-02f, 3.16827558e-02f, 2.30369363e-02f, -3.77900377e-02f, 8.20960850e-02f,
  2.20064688e-02f, 3.41533218e-03f, -2.79030371e-02f, -5.81804886e-02f, -3.17015797e-02f, -3.16054164e-03f, -2.95063071e-02f, 5.58560491e-02f, -2.66024023e-02f, -2.86822524e-02f,
  1.61731038e-02f, 6.22006543e-02f, 3.40086557e-02f, -9.94016510e-03f, 5.99568933e-02f, -1.01553947e-02f, 2.97827162e-02f, 2.75790505e-03f, -4.01806831e-02f, -3.94106694e-02f,
  -4.08124588e-02f, -1.50485700e-02f, 5.21225072e-02f, 1.23129427e-01f, -3.16222273e-02f, -5.16328327e-02f, -7.06923380e-02f, -4.08424921e-02f, 2.08229618e-03f, -2.65093297e-02f,
  -4.83494215e-02f, 1.13727236e-02f, 1.07662193e-03f, 7.44949356e-02f, -5.87220825e-02f, -2.90579479e-02f, 1.24217300e-02f, -2.91809514e-02f, 6.34358227e-02f, 5.60215898e-02f,
  8.75643194e-02f, 7.53228441e-02f, -4.35046777e-02f, 6.75392598e-02f, -9.66393668e-03f, -3.39206532e-02f, 3.47245932e-02f, -3.02083744e-03f, 6.81298152e-02f, -2.29123812e-02f,
  3.20712090e-01f, 1.93374366e-01f, 7.11957142e-02f, 1.63667083e-01f, -3.23652983e-01f, -1.32928222e-01f, -3.52241211e-02f, -6.70774728e-02f, 4.33564425e-01f, 1.35719851e-01f,
  -2.39679724e-01f, 3.88663560e-01f, -3.54824215e-02f, -9.97142941e-02f, -4.53624438e-04f, 9.84980315e-02f, -1.60570871e-02f, 9.33869779e-02f, 1.03344150e-01f, -6.34211004e-02f,
  -8.54554772e-02f, -3.95443439e-01f, -3.03164512e-01f, -2.23895013e-01f, -1.72351405e-01f, 4.17186283e-02f, -2.89165527e-01f, -1.71946213e-01f, -1.02978304e-01f, -5.22658639e-02f,
  -1.01397678e-01f, 2.19472051e-01f, 5.31342663e-02f, 8.03096741e-02f, 7.38057494e-02f, -2.93993503e-02f, -1.16557498e-02f, -5.94948269e-02f, 1.01483405e-01f, 1.86081171e-01f,
  1.28906071e-01f, -1.39203034e-02f, 2.31304150e-02f, -5.85333556e-02f, -3.01637650e-02f, -1.02328882e-02f, 4.81146090e-02f, -8.45707301e-03f, -8.88008333e-04f, -9.79498774e-02f,
  5.32338955e-02f, 2.68261228e-02f, -6.44314885e-02f, 5.15482463e-02f, -6.65029511e-02f, -2.43646186e-02f, 9.30925831e-02f, 4.85555753e-02f, 2.37333067e-02f, 7.05602393e-02f,
  -4.95886132e-02f, -5.35592958e-02f, -5.16274122e-05f, -2.36170050e-02f, -2.46560071e-02f, -5.05491346e-02f, -3.56759652e-02f, -7.58569986e-02f, 9.99430194e-02f, -4.19716686e-02f,
  5.65646635e-03f, -1.16429841e-02f, -4.84658591e-02f, 3.11330520e-02f, -1.67103801e-02f, 3.13259102e-02f, -6.92983940e-02f, 1.47437723e-02f, 3.79722230e-02f, -4.65819053e-02f,
  -3.38659883e-02f, 2.46564113e-02f, -2.60976031e-02f, -3.74952219e-02f, 3.96627448e-02f, 1.26472265e-02f, -6.16173772e-03f, 4.00884338e-02f, -3.07634044e-02f, -7.96000436e-02f,
  2.25708038e-02f, 7.18332306e-02f, 9.38183814e-02f, 9.31375548e-02f, 3.19721252e-02f, -2.12317761e-02f, -8.45977664e-02f, 4.28095683e-02f, 5.22336885e-02f, -7.44056478e-02f,
  -1.40197221e-02f, 5.25305867e-02f, 2.24011485e-02f, -2.73015210e-03f, 8.39228034e-02f, -2.83038132e-02f, 2.90856436e-02f, 3.20816599e-02f, -1.89144257e-02f, -1.48791317e-02f,
  -5.67123555e-02f, 2.41010208e-02f, 1.05500713e-01f, 6.80498872e-03f, -2.78867851e-03f, 4.53441627e-02f, 5.58719821e-02f, 2.11908314e-02f, -2.88684424e-02f, 3.66280563e-02f,
  7.96453953e-02f, 1.76945135e-01f, 1.10995956e-01f, 1.09644637e-01f, 1.24299526e-02f, 1.73541918e-01f, -4.55681086e-02f, 1.43074915e-01f, 1.56068221e-01f, 5.09315096e-02f,
  1.10695092e-02f, 8.94520804e-02f, -8.23549926e-02f, 8.27011690e-02f, -3.47144939e-02f, 2.06376798e-02f, 1.57147035e-01f, -4.38895822e-02f, 2.91164052e-02f, 4.56625111e-02f,
  4.58788220e-03f, 1.99975539e-02f, -1.03364415e-01f, -9.61462557e-02f, -7.33958259e-02f, 4.97918874e-02f, -2.19129741e-01f, -9.52864587e-02f, 1.94053724e-02f, -5.55807389e-02f,
  -7.84714445e-02f, 6.60650507e-02f, 2.15317830e-02f, 8.60088244e-02f, 5.87054044e-02f, 1.05275996e-01f, 6.17308691e-02f, -7.00574219e-02f, -5.24621364e-03f, 1.79541167e-02f,
  1.19856849e-01f, -4.33726572e-02f, 2.94042169e-03f, -5.96351475e-02f, 2.11493690e-02f, 3.42758186e-02f, -2.71165222e-02f, -8.53132457e-02f, 3.72932553e-02f, -9.78089590e-03f,
  2.85557210e-02f, 5.51476069e-02f, 7.52269328e-02f, 6.93184435e-02f, 6.39769360e-02f, -3.45332921e-02f, -3.60887609e-02f, -5.33556640e-02f, 1.02438606e-01f, 6.59992695e-02f,
  3.65024917e-02f, 2.39671115e-02f, 7.01642260e-02f, -8.89659300e-02f, 5.59488200e-02f, 4.31588367e-02f, -1.63680669e-02f, -2.14656536e-02f, 3.85261215e-02f, -1.20778279e-02f,
  -9.96968523e-02f, 1.02863489e-02f, 7.77186155e-02f, 2.84185703e-03f, 1.03331581e-02f, 6.09177537e-02f, 3.37433033e-02f, -2.25297417e-02f, -4.91060428e-02f, -8.15204605e-02f,
  5.77117242e-02f, 1.32908216e-02f, -2.67006289e-02f, -1.79254799e-03f, -2.29238328e-02f, -4.89628464e-02f, 9.96766146e-03f, -7.17500672e-02f, -7.98412040e-02f, -3.62016670e-02f,
  5.72117530e-02f, -8.48042127e-03f, 2.55028568e-02f, -1.23325689e-02f, 4.61290665e-02f, -4.39258032e-02f, 1.00370415e-01f, 6.86923936e-02f, -7.18586147e-02f, 3.05332728e-02f,
  -5.46847507e-02f, -7.93748721e-02f, 7.40214288e-02f, -2.65178960e-02f, -7.28987530e-03f, 8.46781284e-02f, 3.04624047e-02f, 3.62871960e-02f, 8.19435939e-02f, 5.24462201e-02f,
  -5.74816912e-02f, -8.64183530e-03f, -5.09328842e-02f, 9.46636125e-03f, 6.24076165e-02f, -2.55067814e-02f, -4.39071693e-02f, -4.91985157e-02f, -2.37586945e-02f, 5.19982763e-02f,
  -4.21380579e-01f, 9.97245777e-03f, 8.56007561e-02f, 5.32227522e-03f, -2.22803816e-01f, 2.79911458e-01f, 5.56910992e-01f, -1.70192838e-01f, -5.07111195e-03f, 3.00094873e-01f,
  1.70676440e-01f, 1.06848098e-01f, 3.17326635e-01f, 1.64646819e-01f, 1.76384285e-01f, 2.52544731e-01f, 1.36010781e-01f, 1.82265311e-01f, -3.39454785e-02f, -2.72185914e-02f,
  -6.12981580e-02f, 5.61886840e-02f, 1.38654187e-01f, -2.74844646e-01f, -9.75211784e-02f, -2.03159183e-01f, -1.99710261e-02f, -1.84213892e-02f, -1.50233820e-01f, 4.21979092e-02f,
  1.28948212e-01f, -1.30641252e-01f, -5.01612872e-02f, 5.51995412e-02f, -1.03470897e-02f, -5.73175028e-02f, -1.47697963e-02f, 3.77236828e-02f, 5.42171998e-03f, 2.26787217e-02f,
  3.74581851e-02f, 2.69275624e-02f, 1.88055448e-03f, 1.59619413e-02f, -7.23646060e-02f, -4.55955975e-03f, -7.10304007e-02f, -2.51456760e-02f, -4.36347723e-02f, -1.64897814e-02f,
  7.69462660e-02f, 2.64329137e-03f, 3.76653261e-02f, 1.10042719e-02f, 2.32566372e-02f, 3.07640284e-02f, 4.11768109e-02f, 1.60139911e-02f, -7.59127457e-03f, -4.33775969e-02f,
  -5.69260903e-02f, 1.16266735e-01f, 5.46785370e-02f, 4.16262727e-03f, -2.98785325e-02f, 4.01738249e-02f, 5.88590428e-02f, 1.56379249e-02f, -2.15008929e-02f, 4.95391414e-02f,
  -2.43231598e-02f, 4.50377427e-02f, 1.71218067e-02f, 2.50930944e-03f, 3.75964046e-02f, 1.28011676e-02f, 2.91502401e-02f, 1.24877889e-03f, 4.83792201e-02f, 7.30216084e-03f,
  7.48333335e-02f, 6.28943741e-02f, 7.34803677e-02f, 2.03438457e-02f, 4.02224474e-02f, 7.47114606e-03f, -6.04190922e-04f, -2.08731182e-02f, -1.51919788e-02f, 1.80062596e-02f,
  7.36612603e-02f, 1.26939029e-01f, -4.74751368e-03f, 6.61441609e-02f, 6.67215744e-03f, -6.20281361e-02f, 7.87859783e-02f, -4.13067546e-03f, -2.31390796e-03f, -2.13993099e-02f,
  -2.15663817e-02f, -6.58284221e-03f, -9.53724161e-02f, -3.40865664e-02f, 1.31744295e-02f, -4.37797941e-02f, 9.76916626e-02f, -1.55986799e-02f, 1.05097912e-01f, -2.03344859e-02f,
  -4.15885374e-02f, -4.95755747e-02f, 6.39817938e-02f, -7.91175738e-02f, -2.59764381e-02f, 6.07754290e-03f, -4.27604727e-02f, 4.13977578e-02f, 2.36311601e-03f, 4.48809937e-03f,
  9.65877920e-02f, -7.22040385e-02f, -5.81083237e-04f, 8.37905630e-02f, 1.54582173e-01f, 6.92299828e-02f, -3.58624086e-02f, -8.44033360e-02f, -1.13432892e-01f, 8.92447084e-02f,
  -7.47309551e-02f, 6.85630664e-02f, -2.45198473e-01f, -2.28138175e-02f, -2.14841664e-01f, -1.63007542e-01f, -2.99906712e-02f, -8.58263206e-03f, -1.72395930e-01f, 4.65733418e-03f,
  -4.27154936e-02f, 4.70202751e-02f, 1.10770687e-02f, 3.69716212e-02f, 1.27727777e-01f, 2.03270450e-01f, -5.47887012e-03f, 1.16594415e-02f, 1.39124811e-01f, -5.34648821e-02f,
  3.78783755e-02f, -4.02365737e-02f, 7.20839128e-02f, 8.55912864e-02f, -1.47185065e-02f, 1.43046640e-02f, 7.94395506e-02f, 8.15829076e-03f, -7.08295731e-04f, -7.88332522e-02f,
  1.32396957e-02f, 1.09243326e-01f, 1.03314422e-01f, -3.49928550e-02f, 6.55267909e-02f, 8.82885456e-02f, -2.31770258e-02f, -4.60351929e-02f, -3.70695405e-02f, 3.97244953e-02f,
  -1.35200461e-02f, 5.69504052e-02f, -1.83547623e-02f, 4.72544432e-02f, -2.96528842e-02f, 2.69118473e-02f, 2.03247089e-02f, 7.98140988e-02f, 9.50381998e-03f, 2.37550307e-02f,
  3.23974602e-02f, 4.95047644e-02f, -3.92325968e-02f, -3.52327265e-02f, -6.21391535e-02f, -1.20463660e-02f, -5.96454404e-02f, -7.59949535e-02f, 4.30844687e-02f, -4.52075675e-02f,
  5.48578352e-02f, -3.38602103e-02f, 1.20830778e-02f, 6.81107938e-02f, -6.49148598e-03f, 3.07661165e-02f, 4.48612310e-02f, 2.20146738e-02f, -1.53524894e-02f, 2.65595894e-02f,
  3.47036198e-02f, -3.28557044e-02f, -8.91653001e-02f, -5.98256774e-02f, 5.53812906e-02f, -7.07251802e-02f, -3.81533951e-02f, 5.68081588e-02f, 3.26873027e-02f, -6.30235821e-02f,
  -5.53671084e-02f, -7.21805543e-02f, -1.70257054e-02f, 1.89980548e-02f, 3.33314352e-02f, 6.26069158e-02f, 3.57632749e-02f, -9.15925764e-03f, 2.38146205e-02f, -8.44733939e-02f,
  1.15915179e-01f, 7.92573392e-03f, 2.27618627e-02f, 5.09694777e-02f, -2.86266506e-02f, -2.64479633e-04f, -3.36211435e-02f, 1.09110773e-01f, 4.54373322e-02f, -2.51453258e-02f,
  2.31596474e-02f, -2.56069954e-02f, 7.33905137e-02f, 1.25982948e-02f, 6.27575442e-02f, -2.56216861e-02f, 5.49359210e-02f, -1.55385695e-02f, 6.62122816e-02f, -4.33962941e-02f,
  -1.15902700e-01f, 1.96935177e-01f, 2.64533520e-01f, 4.35080260e-01f, 1.53369997e-02f, -3.33719760e-01f, -2.51693934e-01f, 1.24283448e-01f, 2.05627736e-02f, -1.52103439e-01f,
  -4.02419381e-02f, 2.54988790e-01f, -1.25628352e-01f, 1.57150850e-01f, -2.18909625e-02f, -4.61484827e-02f, 1.46657407e-01f, 3.56482156e-02f, 2.89071333e-02f, 1.87090233e-01f,
  2.59009808e-01f, 3.73764783e-02f, 2.64214396e-01f, 3.78007605e-03f, 1.77233741e-01f, 1.46428615e-01f, 2.82511890e-01f, -3.40647660e-02f, 2.74454355e-01f, 6.66137189e-02f,
  -9.74408910e-02f, 5.78586645e-02f, 3.24913338e-02f, 4.30262312e-02f, 3.71347852e-02f, -1.42360955e-01f, -4.11036164e-02f, -2.39357576e-02f, 5.38940728e-03f, 2.31257416e-02f,
  -3.60851251e-02f, -7.43811131e-02f, -8.55770521e-03f, -9.46481712e-03f, -3.60787623e-02f, 6.63671494e-02f, 7.00430572e-02f, 3.86271998e-02f, 8.04861560e-02f, 4.81960103e-02f,
  1.52828261e-01f, -6.06924333e-02f, 3.95391583e-02f, -8.39117449e-03f, 1.90046411e-02f, 2.75321733e-02f, 1.87911149e-02f, 2.92837173e-02f, 5.64146899e-02f, 6.19817376e-02f,
  -3.32362838e-02f, 4.70946208e-02f, 4.81006056e-02f, 9.55849828e-04f, -2.23006159e-02f, 4.68927361e-02f, 2.71645766e-02f, -7.60115590e-03f, -6.40293881e-02f, 6.42811731e-02f,
  -1.68378279e-03f, 1.24269947e-01f, 2.01102644e-02f, 1.76391471e-02f, 5.93511667e-03f, -5.39900698e-02f, -4.37272675e-02f, -1.21729961e-02f, 1.90557390e-02f, 4.04172204e-02f,
  -1.95371453e-02f, 1.30398665e-02f, 6.32028207e-02f, -7.38937631e-02f, -4.96427715e-03f, -2.56082285e-02f, 9.05179381e-02f, 4.78374735e-02f, -9.23881978e-02f, 2.99641099e-02f,
  4.50304300e-02f, 4.29004312e-01f, -5.89403696e-02f, -5.27750999e-02f, -5.04970327e-02f, -3.40453088e-02f, 2.56269127e-02f, 1.52898319e-02f, 8.17491561e-02f, -2.52469890e-02f,
  3.26450430e-02f, -7.30188489e-02f, 6.53623119e-02f, 4.13048901e-02f, 6.44597877e-03f, 9.88733843e-02f, 1.85554996e-02f, 2.67130975e-02f, 8.86031687e-02f, 5.83156645e-02f,
  3.11375130e-02f, -5.27976342e-02f, 1.11097726e-03f, -1.28334135e-01f, -2.58803852e-02f, 4.02510613e-02f, 4.74865828e-03f, 1.90437343e-02f, -1.40010752e-02f, 7.00689331e-02f,
  -2.90415853e-01f, 9.13020968e-02f, -1.70715451e-01f, -7.31070191e-02f, 8.66734684e-02f, -2.59651363e-01f, -5.33873737e-02f, 4.20297869e-02f, -9.00527015e-02f, 2.52717346e-01f,
  8.29667747e-02f, -1.97035179e-01f, -9.03149694e-03f, -2.86771417e-01f, -5.42801261e-01f, -2.41775811e-01f, -2.90311098e-01f, -2.19587088e-01f, -1.07122980e-01f, 2.53114197e-03f,
  -8.05032700e-02f, 6.35021701e-02f, -2.33281806e-01f, 3.50102395e-01f, 1.15476482e-01f, 2.93552667e-01f, 3.60929489e-01f, 2.28907138e-01f, 1.27429441e-01f, -5.00284992e-02f,
  -1.48640081e-01f, 8.62994641e-02f, 1.40239717e-02f, -7.75199533e-02f, 7.27056861e-02f, 1.07547894e-01f, 4.61212471e-02f, -9.86135155e-02f, -4.33187839e-03f, -4.14750725e-02f,
  3.50421630e-02f, -5.78284785e-02f, -5.57708032e-02f, 2.45247427e-02f, 3.94120105e-02f, -7.60704428e-02f, -5.90640027e-03f, 4.92340252e-02f, -5.91438822e-02f, -1.30981728e-01f,
  -8.86147320e-02f, -4.61702608e-02f, 3.50739956e-02f, -2.55066063e-02f, 1.60460640e-02f, -1.41223483e-02f, 1.49438484e-02f, -2.72263363e-02f, -9.77098569e-03f, -2.59736329e-02f,
  5.98813817e-02f, 2.59101223e-02f, 2.13421285e-02f, -3.60888056e-02f, 3.11731864e-02f, -1.79973543e-02f, -3.75813469e-02f, -1.87420975e-02f, 6.51275218e-02f, 7.93236424e-04f,
  -1.58719151e-04f, -1.24957254e-02f, -9.57100932e-03f, 8.32208320e-02f, 2.23287921e-02f, -1.72542054e-02f, 3.26634496e-02f, -3.04902368e-03f, 3.94000253e-03f, 8.31943005e-03f,
  6.95225671e-02f, -3.33741941e-02f, 3.24123017e-02f, 6.94762766e-02f, -1.05254315e-01f, 1.88705605e-02f, 7.32078357e-03f, 2.19660103e-02f, -3.69836693e-03f, 1.51076885e-02f,
  7.32358098e-02f, 2.04672545e-01f, -4.36419388e-04f, 7.63979778e-02f, -1.89309362e-02f, 2.46080253e-02f, -8.06529671e-02f, -1.25277592e-02f, 1.11389933e-02f, 5.21948114e-02f,
  1.42120361e-01f, 2.99229510e-02f, 1.21081486e-01f, -8.19472075e-02f, 3.45240980e-02f, 4.15356234e-02f, 5.53964972e-02f, 6.48082122e-02f, 3.97943892e-02f, -3.83625440e-02f,
  8.78847167e-02f, 8.62324014e-02f, 2.92096846e-02f, 7.01411590e-02f, 1.05941370e-02f, 1.03946039e-02f, 5.55557311e-02f, -3.27745033e-03f, 5.51355705e-02f, 3.85457613e-02f,
  -2.18867466e-01f, -6.04529120e-02f, -4.22197521e-01f, -2.25280300e-01f, -2.86690354e-01f, -4.55933362e-01f, -3.15005422e-01f, -3.09810460e-01f, 9.95789394e-02f, 2.42834583e-01f,
  4.33637090e-02f, 1.28119905e-02f, 1.93947628e-01f, -1.20701529e-01f, -2.73880716e-02f, 3.89237523e-01f, -1.25879362e-01f, -8.00294150e-03f, -5.85572980e-02f, -3.00316989e-01f,
  -1.63861543e-01f, -2.39802562e-02f, -1.12916522e-01f, -1.59673765e-01f, -4.07484829e-01f, -1.12475999e-01f, 9.31762904e-02f, -2.23230660e-01f, -1.59395203e-01f, -5.90900928e-02f,
  -1.66444536e-02f, -3.35073248e-02f, -1.07602358e-01f, -4.90277484e-02f, -1.49467424e-01f, -4.62773368e-02f, -9.68531147e-02f, -3.37253436e-02f, 1.08920252e-02f, -4.07324359e-02f,
  2.28666924e-02f, -2.17159130e-02f, -2.16198023e-02f, 3.64952311e-02f, -1.73486564e-02f, -2.29187044e-05f, -9.24295485e-02f, -3.08930073e-02f, -1.34025309e-02f, -8.87060314e-02f,
  -9.39936414e-02f, -1.90506373e-02f, -1.07003674e-01f, 9.61937979e-02f, -2.87062693e-02f, -3.87739502e-02f, 1.93779115e-02f, -6.93638995e-03f, -8.72377455e-02f, -8.53499398e-02f,
  -9.18755233e-02f, -2.08124444e-02f, -3.65192397e-03f, -1.06972205e-02f, -1.84223836e-03f, -3.09082903e-02f, -1.05850948e-02f, 7.49341100e-02f, 1.48042357e-02f, 2.35620979e-02f,
  -4.00678575e-04f, 1.24823395e-02f, -2.99336687e-02f, 2.03553941e-02f, -4.40556481e-02f, -3.08537460e-03f, 1.90005191e-02f, -7.12569207e-02f, -4.96801026e-02f, 1.74311884e-02f,
  6.66648000e-02f, -6.22308962e-02f, 6.70113787e-03f, 3.00734807e-02f, -7.67360032e-02f, 5.50170103e-03f, -4.01971824e-02f, -3.54999714e-02f, -1.50146391e-02f, -9.88410413e-02f,
  -2.18321323e-01f, -1.75677687e-01f, 1.77234821e-02f, 3.37211229e-03f, 6.68126643e-02f, -7.62635171e-02f, -2.06792857e-02f, -8.32156688e-02f, -1.36679962e-01f, -1.07041754e-01f,
  -8.52820948e-02f, -7.90062454e-03f, -5.39189056e-02f, -1.84903741e-02f, 2.44550612e-02f, 3.29806050e-03f, -4.03443351e-02f, 5.81635945e-02f, -6.70039430e-02f, -2.06705742e-02f,
  8.32617190e-03f, 4.17039208e-02f, 5.19882031e-02f, 1.41342636e-03f, 5.80699183e-03f, 3.84242507e-03f, -3.46502252e-02f, -3.44760716e-02f, -7.58562610e-02f, 4.62592617e-02f,
  1.11344911e-01f, -8.98504779e-02f, 2.37726476e-02f, -1.21269822e-01f, 3.83759141e-02f, 2.24749502e-02f, 2.46910185e-01f, -1.67986244e-01f, -9.51927006e-02f, -8.37068707e-02f,
  -1.02487914e-01f, -1.25796441e-02f, 1.22094214e-01f, -1.81871525e-04f, 1.42454997e-01f, 8.07062462e-02f, 1.01621874e-01f, 1.12362981e-01f, 3.10330912e-02f, 4.51773492e-04f,
  -1.18883587e-01f, 6.41018376e-02f, 3.49098630e-02f, -1.04115784e-01f, -7.21997861e-03f, -7.29921758e-02f, 4.53887470e-02f, 2.81977914e-02f, 2.22098012e-03f, 4.85314503e-02f,
  -1.36826606e-02f, 4.92971279e-02f, 2.73605641e-02f, -2.99331322e-02f, 3.33703905e-02f, 4.20992002e-02f, 1.00067116e-01f, 1.89481564e-02f, 1.94932725e-02f, 2.85187531e-02f,
  -3.09071522e-02f, -8.90668184e-02f, -6.37573749e-02f, 4.46635559e-02f, -8.27638209e-02f, -1.19056210e-01f, -4.12986092e-02f, -1.27129644e-01f, -5.37982248e-02f, 3.41205262e-02f,
  1.91758052e-02f, -8.16963613e-03f, -2.54636370e-02f, 2.04018247e-03f, -1.14065878e-01f, 4.50097136e-02f, -2.69033946e-02f, 5.76716335e-03f, -3.64649110e-02f, 5.75156435e-02f,
  5.33233136e-02f, -5.03341742e-02f, 1.05139561e-01f, -1.43437851e-02f, -8.76382459e-03f, -1.03616148e-01f, -6.21742532e-02f, -5.70892766e-02f, -8.35911557e-02f, -2.19432022e-02f,
  -1.11842968e-01f, -1.21881319e-02f, -4.69372980e-02f, 2.31381948e-03f, -1.67396609e-02f, -5.78120127e-02f, -7.20266774e-02f, 1.13279307e-02f, -5.64223714e-03f, -3.59070338e-02f,
  -3.56001928e-02f, 1.21288132e-02f, -7.58846710e-03f, 5.77456169e-02f, 5.31161167e-02f, 2.79680323e-02f, 3.95069495e-02f, 3.24390493e-02f, -1.12036802e-01f, -1.68869663e-02f,
  8.16826373e-02f, 6.05861843e-02f, -3.63527127e-02f, 4.53460589e-02f, -1.66135598e-02f, -4.65979166e-02f, 1.41299432e-02f, -2.75458966e-04f, 2.14563683e-02f, -3.60436291e-02f,
  -4.25174646e-03f, 5.94863370e-02f, 8.58260915e-02f, -4.18953085e-03f, -8.14500637e-03f, 6.24725483e-02f, 6.02373593e-02f, 3.63856889e-02f, -2.32202113e-02f, 6.54413737e-03f,
  3.78461741e-03f, 2.46209763e-02f, -7.83881322e-02f, -5.28095141e-02f, 1.47016160e-02f, -3.15892585e-02f, 9.76645499e-02f, -4.25267173e-03f, 3.60338576e-02f, 4.04606797e-02f,
  2.53010213e-01f, -6.25402391e-01f, 2.16785427e-02f, 5.18015444e-01f, 3.57806325e-01f, -2.50079334e-02f, 1.30051851e-01f, 1.54594695e-02f, 1.69248790e-01f, -4.42286611e-01f,
  5.48198670e-02f, -1.33603975e-01f, -2.59913743e-01f, 1.47853242e-02f, 3.89417261e-01f, -1.65064856e-01f, 1.65054917e-01f, -3.04776635e-02f, -8.93867749e-04f, -5.89950494e-02f,
  2.70138413e-01f, 1.47481263e-01f, 9.32092220e-02f, -1.51536331e-01f, 1.01651907e-01f, 5.69019094e-02f, 2.55021397e-02f, -1.39223009e-01f, 2.32981611e-02f, 6.47526383e-02f,
  7.94647336e-02f, -2.75214612e-02f, 1.19574718e-01f, -4.81820740e-02f, -3.49219032e-02f, -1.95729565e-02f, -2.43574493e-02f, -4.38114535e-03f, 1.22711465e-01f, -3.82140465e-02f,
  -6.01695329e-02f, -1.02847358e-02f, 3.32317241e-02f, -6.36842195e-03f, 2.56220959e-02f, 6.32010549e-02f, 4.25126776e-02f, -3.77200334e-03f, -2.08530333e-02f, -4.46250588e-02f,
  5.73128462e-02f, -6.20049015e-02f, 9.86399427e-02f, -3.12486067e-02f, 2.05803141e-02f, 4.65469956e-02f, 2.00114194e-02f, -4.36034352e-02f, 2.91133523e-02f, 3.97559963e-02f,
  -1.47209406e-01f, 2.18281616e-02f, -2.60528289e-02f, 3.18585448e-02f, -5.45071624e-02f, 1.22350879e-01f, 1.57414738e-03f, -2.85509322e-02f, -1.36186415e-02f, -7.10346028e-02f,
  1.55425780e-02f, 4.29954417e-02f, 2.42129453e-02f, 2.71789487e-02f, 2.05257125e-02f, 4.11155410e-02f, -2.84940284e-02f, -1.17418142e-02f, 3.27703469e-02f, 7.25630904e-03f,
  2.13848567e-03f, 3.53599116e-02f, -3.27720158e-02f, -9.15579032e-03f, -2.08741352e-02f, 2.34841220e-02f, 3.42645869e-02f, -9.04391110e-02f, 4.41378728e-02f, -4.16228138e-02f,
  -3.16664636e-01f, -3.65709007e-01f, -4.07305919e-02f, 4.34471145e-02f, -1.13074437e-01f, -9.10485387e-02f, 2.26918180e-02f, -3.83699052e-02f, -9.63091999e-02f, -3.01651526e-02f,
  -3.60235348e-02f, 2.56897099e-02f, -8.18683729e-02f, 5.62923960e-02f, -7.73168867e-03f, -1.80256516e-02f, -4.67817634e-02f, -6.23000553e-03f, 4.72609438e-02f, -4.30188254e-02f,
  -2.34549008e-02f, -4.34055403e-02f, 8.55840743e-02f, 4.58538309e-02f, -1.56767908e-02f, 5.67936385e-03f, -1.35396011e-02f, -1.75707880e-02f, -1.11563198e-01f, -3.83820608e-02f,
  -2.73031265e-01f, 2.71780044e-01f, 4.73699421e-02f, 7.40094781e-02f, 5.51422909e-02f, 3.40608358e-01f, 2.66796172e-01f, 1.53189912e-01f, 2.67246187e-01f, 2.86799669e-01f,
  1.03003092e-01f, -4.24832059e-03f, 1.64733492e-02f, 1.09002270e-01f, 7.68653154e-02f, 2.17732951e-01f, 2.58720338e-01f, 1.60927624e-01f, -1.84443723e-02f, -5.35676852e-02f,
  3.05283517e-02f, 5.23954108e-02f, -7.71025419e-02f, -9.08431783e-02f, -8.53415206e-02f, -7.39673972e-02f, -2.53597889e-02f, -1.06354363e-01f, -1.80504136e-02f, -2.13455074e-02f,
  -8.61453116e-02f, -1.02284379e-01f, -8.64736736e-02f, -3.89463678e-02f, -4.62063663e-02f, -8.43344443e-03f, -9.82813071e-03f, -4.04130630e-02f, -9.99627262e-02f, 4.02736105e-02f,
  -2.88602747e-02f, -5.83143793e-02f, 9.41059832e-03f, -5.81920445e-02f, 9.42514762e-02f, 6.26487657e-03f, -4.56467904e-02f, 5.61725497e-02f, 3.06466501e-02f, -8.09463188e-02f,
  -1.19521962e-02f, -1.66185237e-02f, 6.06054254e-03f, 7.36599788e-02f, -6.14661723e-02f, 6.89550117e-03f, 8.02386180e-02f, -1.00263573e-01f, 2.84211915e-02f, 1.34494519e-02f,
  -4.22704667e-02f, 1.53002394e-02f, -2.74142977e-02f, 2.53010318e-02f, -3.09524424e-02f, -7.88887516e-02f, -3.74446716e-03f, 5.94510837e-03f, 4.03031567e-03f, 6.53278502e-03f,
  3.84388231e-02f, -5.65137044e-02f, -4.43274491e-02f, 6.68177893e-03f, -1.70852840e-02f, 1.67635456e-02f, -6.83868723e-03f, -1.33860633e-02f, 5.67550175e-02f, -2.00601369e-02f,
  3.51745286e-03f, -5.50790876e-03f, -1.98963936e-03f, 2.34610084e-02f, -1.10688042e-02f, -4.47074808e-02f, 5.98914661e-02f, -5.45745268e-02f, 5.73579744e-02f, -1.16780112e-02f,
  1.21879071e-01f, 1.74353361e-01f, -7.33312045e-04f, -1.80022847e-02f, -3.71460244e-02f, 4.00818884e-02f, 6.55664131e-02f, -3.50055955e-02f, 8.92106444e-02f, -1.50820250e-02f,
  -2.81364862e-02f, -4.81229275e-02f, 6.78215176e-02f, 2.26865597e-02f, 2.97557954e-02f, 1.03111334e-01f, 2.43465286e-02f, 1.83728170e-02f, 4.97984849e-02f, -3.08633260e-02f,
  -9.71751511e-02f, 3.58880721e-02f, 1.32011948e-02f, 1.65351555e-02f, -3.48351561e-02f, -3.40917446e-02f, -1.67247523e-02f, -4.21113148e-02f, 1.98825356e-02f, 4.22180109e-02f,
  1.53419539e-01f, 9.94780511e-02f, -3.89878362e-01f, 5.89560047e-02f, -7.90261626e-02f, 6.10865392e-02f, -7.51125887e-02f, 3.05046365e-02f, -1.98027238e-01f, 1.75524339e-01f,
  1.57093555e-01f, -1.20319091e-01f, -1.39829181e-02f, 4.05617863e-01f, 2.06218839e-01f, -2.91040614e-02f, 3.09154332e-01f, 9.52887610e-02f, 1.63074804e-03f, 1.42015010e-01f,
  5.75118931e-03f, 4.33154106e-01f, 1.26798060e-02f, 2.01968238e-01f, 1.44497573e-01f, 4.43381481e-02f, 1.29359379e-01f, -2.32537404e-01f, 2.15424180e-01f, 1.18492655e-01f,
  8.50322023e-02f, 7.17229694e-02f, -6.20192066e-02f, -3.19329165e-02f, 1.77463032e-02f, 5.89076802e-02f, -8.30482394e-02f, -8.10480863e-03f, -1.24497071e-01f, 5.80396093e-02f,
  -5.25805168e-02f, 7.05764741e-02f, 5.52652404e-02f, 1.62556823e-02f, -1.88945513e-02f, -8.12639222e-02f, 5.16039180e-03f, -5.21210507e-02f, -6.10660575e-02f, 1.93751547e-02f,
  -1.35069340e-01f, -7.81466812e-02f, -2.42535565e-02f, -6.11630781e-03f, -1.24305926e-01f, 2.46891025e-02f, 1.03923986e-02f, -5.62323537e-03f, -2.99611036e-02f, 2.82801446e-02f,
  5.90224378e-02f, -3.81328445e-03f, 3.88390422e-02f, 6.93195835e-02f, 2.37905700e-02f, 3.53675559e-02f, -3.37465182e-02f, 3.62307355e-02f, -7.05476850e-02f, 2.76443781e-03f,
  -1.86559837e-02f, -2.05067731e-02f, -3.29551585e-02f, 5.18827699e-02f, 9.36945751e-02f, -6.55906275e-02f, -5.38782552e-02f, -6.92626042e-03f, -3.25791538e-02f, 9.78665706e-03f,
  6.36084285e-03f, -1.66381299e-02f, -6.76689669e-03f, 1.48685593e-02f, -1.39705976e-02f, -2.65326761e-02f, 4.66247238e-02f, 3.29678110e-03f, -5.58637790e-02f, -9.22702700e-02f,
  2.76111793e-02f, 1.40169859e-01f, 5.18254898e-02f, 1.05002914e-02f, -3.00724898e-02f, 7.28172297e-03f, -1.52356960e-02f, 2.27869730e-02f, -3.16651091e-02f, 5.44738723e-03f,
  2.49221874e-03f, -4.86142449e-02f, 4.83294837e-02f, -1.70284864e-02f, -2.22801212e-02f, 6.57363161e-02f, 1.66388415e-02f, 1.48420250e-02f, 1.14905061e-02f, 1.28920190e-02f,
  1.40778255e-02f, 1.40662221e-02f, -4.08242978e-02f, -5.62370345e-02f, 1.05090432e-01f, -2.15013721e-03f, -3.82834487e-02f, -3.96922827e-02f, 8.03096518e-02f, 3.03250235e-02f,
  1.23618037e-01f, -1.24510586e-01f, -4.09197398e-02f, 6.50032610e-02f, 3.80333327e-02f, -1.52936496e-03f, -3.96964066e-02f, 3.40525284e-02f, 3.95010710e-02f, -6.19744956e-02f,
  9.97812226e-02f, -1.36929110e-01f, -6.54088408e-02f, 5.57804741e-02f, 8.34901109e-02f, -8.14946666e-02f, 1.61740463e-02f, -1.38489157e-03f, 7.83522874e-02f, 1.11417107e-01f,
  5.76035827e-02f, 3.80132068e-03f, -3.66322398e-02f, -2.76215840e-02f, -9.28735174e-03f, -4.63233367e-02f, 9.26819891e-02f, 1.56997032e-02f, 5.22647500e-02f, -1.25803888e-01f,
  3.30664068e-02f, 1.94374677e-02f, -1.02138795e-01f, -3.96402366e-02f, 5.11401407e-02f, -7.73015469e-02f, -3.57011780e-02f, -9.05265510e-02f, 4.78389300e-02f, -2.69852299e-02f,
  -5.96004538e-02f, 6.90377653e-02f, -7.29327947e-02f, 9.99151617e-02f, 6.81428984e-02f, -2.19087582e-02f, 6.86026644e-03f, 2.07269713e-02f, -1.21791391e-02f, 2.08424032e-02f,
  8.00362006e-02f, 6.12714030e-02f, -6.98939934e-02f, -5.47864102e-02f, 6.53623939e-02f, -2.14998499e-02f, -5.58553636e-02f, -5.03011467e-03f, 4.05381918e-02f, -6.82471916e-02f,
  1.19376943e-01f, -9.29655582e-02f, 6.97422773e-02f, -1.05501618e-02f, 3.19612958e-03f, 4.18603308e-02f, -6.70728758e-02f, 3.05016991e-02f, 3.20530050e-02f, 4.72854404e-03f,
  -5.32698780e-02f, 9.91463102e-03f, -6.01569340e-02f, -5.59697300e-02f, -1.52593898e-02f, -3.40120844e-03f, -3.29606570e-02f, -1.64837260e-02f, 6.80079237e-02f, -2.48463992e-02f,
  -7.69511908e-02f, 8.13141912e-02f, 9.60971639e-02f, 1.00981118e-03f, 7.79417828e-02f, 7.16178194e-02f, -3.90731953e-02f, 2.44834786e-03f, -5.60728647e-02f, -3.83547368e-03f,
  4.99123186e-02f, -2.50764675e-02f, -5.69468886e-02f, 9.32016317e-03f, 5.28309569e-02f, 4.39779796e-02f, -5.45889735e-02f, 8.07600692e-02f, 4.71341386e-02f, 9.95197427e-03f,
  2.74431258e-02f, 8.83207321e-02f, 3.35989445e-02f, 8.14530402e-02f, -6.12575561e-02f, -3.16651352e-02f, -2.35481784e-02f, -9.40867141e-02f, 3.01106405e-02f, 6.76952377e-02f,
  -4.33133096e-02f, 3.45550291e-03f, -1.86895598e-02f, -7.39751905e-02f, 4.07941155e-02f, -3.44579667e-02f, 5.82371205e-02f, -2.86246347e-03f, -1.31456750e-02f, -7.09768161e-02f,
  1.95602924e-01f, -2.83057570e-01f, -2.06084400e-01f, 2.78820265e-02f, 9.73507315e-02f, 1.10100873e-01f, -3.56913023e-02f, 3.09652928e-02f, 2.44827587e-02f, -1.22313999e-01f,
  8.36386755e-02f, -1.16343915e-01f, -3.14940065e-01f, 1.69333875e-01f, 1.50654867e-01f, -2.06106693e-01f, 7.12216720e-02f, -1.08643444e-02f, -3.95433567e-02f, -4.48008650e-04f,
  5.28900735e-02f, 2.37148240e-01f, -1.65913198e-02f, 1.19897336e-01f, 6.38010427e-02f, -5.93014210e-02f, 4.57275398e-02f, -1.56570256e-01f, 1.50795011e-02f, 1.68672174e-01f,
  7.77786002e-02f, -4.54792241e-03f, 2.75681335e-02f, 6.04765601e-02f, -3.71759161e-02f, -4.09769900e-02f, -3.00001483e-02f, 4.92801704e-03f, 1.34759992e-01f, 6.09579794e-02f,
  -9.79518071e-02f, 1.47287184e-02f, 1.34384885e-01f, -2.81536113e-02f, 1.18612118e-01f, 3.96039337e-02f, 4.93476354e-02f, -3.55282351e-02f, -5.74621782e-02f, 1.24088516e-02f,
  -1.38168603e-01f, 3.59566323e-02f, 2.72221342e-02f, 5.59532084e-03f, -9.47934315e-02f, -4.20552772e-03f, 7.48615107e-03f, -1.03641711e-01f, -2.82067116e-02f, 6.23243488e-02f,
  -1.05832748e-01f, -2.10710280e-02f, 1.31381806e-02f, 7.81338066e-02f, 3.33115645e-02f, -3.03590931e-02f, 9.31839645e-02f, 6.84174821e-02f, 1.65596083e-02f, 6.37124702e-02f,
  3.37604359e-02f, 3.96880507e-02f, 1.08669018e-02f, 7.01189041e-02f, 1.48923155e-02f, 2.11609136e-02f, 3.92992161e-02f, 2.46668998e-02f, -8.94432440e-02f, 5.61831798e-03f,
  2.50463765e-02f, -7.73832609e-04f, -9.79253370e-03f, 5.18632084e-02f, 8.11763778e-02f, -4.49632332e-02f, -5.46505153e-02f, 8.84032100e-02f, -2.08872743e-02f, -2.89556128e-03f,
  -5.26000410e-02f, -1.45688668e-01f, -1.16560459e-01f, 6.21910729e-02f, -8.89410824e-03f, 3.89008448e-02f, -9.54449642e-03f, 1.00539029e-01f, -8.35065022e-02f, -5.33720590e-02f,
  9.10227746e-02f, 8.04408044e-02f, 7.87277427e-03f, 2.88438611e-02f, 1.10016689e-01f, -1.21629611e-02f, 1.09881079e-02f, 4.58550267e-02f, 3.87510844e-02f, -3.46168084e-03f,
  1.97273176e-02f, 3.57422046e-02f, 1.60088018e-02f, -7.85667151e-02f, 1.90214328e-02f, -1.19798100e-02f, 7.36850426e-02f, 9.78112593e-03f, 5.79945110e-02f, 2.71090795e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.07561031e-01f, 2.65228093e-01f, 7.87199661e-02f, 3.91342700e-01f, 6.81907237e-02f, 1.82850093e-01f, 2.40225375e-01f, 1.25912696e-01f, 3.17282937e-02f, 1.55538470e-01f,
  1.08147927e-01f, 2.15880975e-01f, 3.89387682e-02f, 7.96896890e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  8.86465609e-03f, -2.35142455e-01f, -4.25422043e-02f, -5.52085042e-02f, 1.26868904e-01f, -1.76482975e-01f, -8.18627626e-02f, -1.52124554e-01f, 3.35914791e-02f, -3.31253648e-01f,
  3.88102204e-01f, 2.95476764e-01f, 2.12396398e-01f, -5.13788640e-01f, 2.55282134e-01f, -1.52550116e-01f, -2.59059817e-01f, -1.63816914e-01f, -2.16667488e-01f, -1.18267216e-01f,
  1.47203244e-02f, 2.31546834e-01f, -1.39847934e-01f, -2.28987262e-01f, -1.93676069e-01f, 6.80620894e-02f, 9.57470909e-02f, 3.04852396e-01f, 1.46946490e-01f, 3.00485462e-01f,
  4.58384454e-02f, 7.87463114e-02f, -5.83314858e-02f, 8.34826156e-02f, 1.90354168e-01f, -1.39687017e-01f, -7.17087835e-02f, -5.58832986e-03f, 1.36829287e-01f, -9.60866734e-02f,
  2.18334004e-01f, -2.39681050e-01f, 1.23825021e-01f, 1.58946544e-01f, 3.67774129e-01f, -3.03921878e-01f, -2.02371344e-01f, 2.07523003e-01f, -1.25070229e-01f, 4.80929881e-01f,
  2.26970986e-01f, 5.52552901e-02f, -1.57511428e-01f, -1.00986116e-01f, -7.10676387e-02f, 2.19487250e-01f, 3.06205451e-01f, 2.81627685e-01f, -1.15827195e-01f, 2.23020062e-01f,
  -1.05289802e-01f, -1.68205604e-01f, 1.08873174e-01f, 1.25864759e-01f, 8.76812637e-03f, -9.01858956e-02f, -2.55006831e-02f, -8.58274773e-02f, -2.16133565e-01f, 8.83186832e-02f,
  3.24562611e-03f, 2.06345111e-01f, -1.40563492e-03f, -8.90944824e-02f, -2.82556452e-02f, -2.33777508e-01f, 3.63286555e-01f, -1.57933265e-01f, -3.17682177e-01f, 2.64452577e-01f,
  1.65162031e-02f, 4.06647146e-01f, 6.71672150e-02f, 2.83259660e-01f, 2.53402203e-01f, 1.05781928e-01f, -9.13190693e-02f, 2.98576057e-01f, -2.89088666e-01f, 2.68224537e-01f,
  -2.00173706e-02f, -4.51654762e-01f, 3.52715701e-01f, 2.37043872e-01f, -2.10922331e-01f, -2.62038618e-01f, -2.88391024e-01f, -7.37714171e-02f, -5.79737090e-02f, -2.37608775e-01f,
  -1.46334112e-01f, -2.50804156e-01f, 1.23082072e-01f, -2.17119500e-01f, -1.36099696e-01f, -8.53002593e-02f, -2.42023036e-01f, 2.32586432e-02f, -2.35903576e-01f, 3.83226454e-01f,
  3.03197443e-01f, 1.98870063e-01f, 7.64781907e-02f, 1.39309525e-01f, -4.05738018e-02f, 1.02717593e-01f, 3.39678377e-02f, -3.63344163e-01f, 1.44476026e-01f, 3.22473139e-01f,
  8.28790814e-02f, -1.88996419e-01f, -3.02765012e-01f, 5.61544076e-02f, -1.14090726e-01f, 2.37402096e-01f, 1.24147855e-01f, 9.24248323e-02f, -1.80063322e-01f, -1.99624971e-01f,
  -3.31599653e-01f, -1.63634405e-01f, 1.31848782e-01f, -2.37338424e-01f, -3.12893599e-01f, -9.21589881e-02f, -1.92072377e-01f, -1.29735693e-01f, -1.05338067e-01f, 5.54824062e-02f,
  -1.06175460e-01f, -2.34827921e-01f, 2.54797012e-01f, 4.02760878e-02f, -4.26434070e-01f, -2.19244733e-01f, -3.89844656e-01f, 2.95155514e-02f, -8.96196142e-02f, 2.59545356e-01f,
  -1.85635924e-01f, 1.66191310e-01f, -3.18812460e-01f, 2.84426481e-01f, 1.44665554e-01f, -1.65387467e-01f, 1.77528620e-01f, 2.89038539e-01f, -1.43306069e-02f, 2.28287801e-02f,
  3.44742425e-02f, -7.04046041e-02f, 7.24915357e-04f, -4.59554307e-02f, 1.55949399e-01f, -1.44020483e-01f, -7.59780779e-02f, 1.40736163e-01f, 6.51568640e-04f, -1.23776533e-01f,
  3.12787861e-01f, -2.28936285e-01f, -8.76767784e-02f, 2.68122584e-01f, 9.28211808e-02f, 3.73971350e-02f, 4.51616719e-02f, -2.54945278e-01f, -2.57097840e-01f, -1.53857827e-01f,
  1.29048273e-01f, 2.43633464e-01f, 5.30022271e-02f, 1.21838963e-02f, -2.86487341e-01f, -2.40825742e-01f, 8.63391533e-02f, 2.52325177e-01f, 2.99026281e-01f, 3.18386137e-01f,
  1.14172310e-01f, 1.92500398e-01f, -7.65528083e-02f, 2.92151626e-02f, -2.85006046e-01f, 1.18264053e-02f, 1.23642288e-01f, -4.76602130e-02f, -2.34887078e-02f, -4.52122279e-02f,
  -1.03993610e-01f, -6.46220371e-02f, 1.82432801e-01f, -1.10818371e-01f, -2.55684167e-01f, -2.86650270e-01f, -1.26167491e-01f, -1.22423872e-01f, -1.58244044e-01f, -5.47008514e-01f,
  -3.39903921e-01f, -3.93420793e-02f, -2.43992686e-01f, 3.74609381e-01f, -7.83734620e-02f, -2.54942328e-01f, -2.33605728e-01f, 2.45704427e-01f, 1.53137565e-01f, 3.17429394e-01f,
  -1.43780470e-01f, -4.79021482e-02f, -1.13601491e-01f, 1.33046955e-01f, -5.01353666e-02f, -1.11130953e-01f, 2.56785870e-01f, 7.86687806e-02f, -1.37628511e-01f, 8.37474912e-02f,
  1.85377926e-01f, -1.73342228e-01f, -6.08482473e-02f, 2.18868047e-01f, 4.07208622e-01f, 3.62810522e-01f, 1.65824041e-01f, -4.09395069e-01f, -2.68419892e-01f, -1.02286721e-02f,
  3.12225342e-01f, 3.06738466e-01f, 2.26423323e-01f, -4.83882613e-02f, -1.00975923e-01f, -1.40761465e-01f, 1.33271605e-01f, -2.84298867e-01f, -1.85184423e-02f, -1.34470016e-01f,
  -6.59779971e-03f, 5.11809051e-01f, -2.85450548e-01f, -1.67067379e-01f, -1.08040594e-01f, 1.00558966e-01f, -2.61532694e-01f, -5.30216657e-02f, -1.10447459e-01f, -1.32777140e-01f,
  -5.21788187e-02f, -4.05460633e-02f, -2.21261933e-01f, -2.13043243e-01f, -1.10766530e-01f, -2.15109438e-01f, -1.68886960e-01f, 3.43786180e-02f, 1.98885843e-01f, -4.49839056e-01f,
  4.90472317e-02f, 2.09348902e-01f, -3.27078670e-01f, 3.07578832e-01f, 2.19086081e-01f, 2.10667998e-02f, -1.86355650e-01f, -1.29875645e-01f, -1.23152830e-01f, 2.36146033e-01f,
  -4.98596616e-02f, 3.25946331e-01f, -1.30934954e-01f, -3.48372132e-01f, -1.51919484e-01f, -2.99538616e-02f, -1.17543794e-01f, -2.30147317e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.22593544e-01f, -4.39229533e-02f, 1.30767569e-01f, -9.22760740e-02f, -1.12408772e-01f, -1.29308850e-01f, -6.59084320e-02f, 8.74597281e-02f, 1.40864372e-01f, 5.80428690e-02f,
  1.15527503e-01f, -1.41006142e-01f, -1.48084894e-01f, -9.40109119e-02f, 1.25994869e-02f, 2.41569057e-02f, -8.77342839e-03f, -1.17283866e-01f, 5.95674943e-03f, -8.13724846e-02f,
  1.56868741e-01f, -5.87679073e-02f, -1.52992755e-01f, 6.53588250e-02f, -9.81673151e-02f, 4.41764183e-02f, 1.51849657e-01f, -7.20075965e-02f, -2.11396310e-02f, 1.70438796e-01f,
  -1.11109108e-01f, 2.43021026e-02f, -8.20140094e-02f, 1.31507203e-01f, 1.99144363e-01f, -7.10325837e-02f, -4.74872552e-02f, -2.20119059e-01f, -1.77178681e-01f, -1.20322131e-01f,
  3.25074971e-01f, 5.78109026e-02f, -1.29443541e-01f, 8.63589123e-02f, -4.99188416e-02f, 2.12553531e-01f, 3.35929990e-01f, -1.04045414e-03f, -2.66426295e-01f, 6.95421966e-03f,
  1.06155708e-01f, -1.78925946e-01f, -5.47327437e-02f, -1.46805393e-02f, -8.81869867e-02f, 4.51610178e-01f, 3.56901497e-01f, -1.46628693e-01f, -6.56080842e-02f, 3.13151807e-01f,
  -9.56641510e-02f, 1.67384163e-01f, 5.72737772e-03f, -6.94679618e-02f, 4.02244508e-01f, 3.15285653e-01f, 1.75409675e-01f, 3.60166967e-01f, 1.95355546e-02f, 3.93984050e-01f,
  1.05582410e-02f, 3.27738762e-01f, 1.22198887e-01f, -1.74010679e-01f, -4.37925123e-02f, -3.34227890e-01f, 2.57978253e-02f, -4.79637563e-01f, -1.00706637e-01f, -2.03251332e-01f,
  -1.35388911e-01f, -4.90504235e-01f, 7.00749755e-01f, -4.29597080e-01f, -8.57458934e-02f, 6.46428943e-01f, 3.71142179e-02f, -2.64095068e-01f, 7.78694928e-01f, 1.31501630e-01f,
  1.47490710e-01f, -1.58570036e-01f, 1.59098074e-01f, 8.88378695e-02f, 1.70402303e-02f, -2.01112568e-01f, -4.31373268e-02f, 1.19135708e-01f, 3.17886136e-02f, 4.34445813e-02f,
  1.48092419e-01f, -3.82715352e-02f, 2.02120408e-01f, -1.27938837e-01f, -4.17341432e-03f, -1.31846488e-01f, 2.84879565e-01f, 1.01844603e-02f, 2.08183274e-01f, -3.21545362e-01f,
  -1.44936293e-02f, 3.44904810e-02f, -2.08705485e-01f, -7.13625643e-03f, 6.72176341e-03f, -7.79450834e-02f, 1.42305940e-02f, 4.60272163e-01f, 3.51234898e-02f, -9.06308144e-02f,
  -2.61915848e-03f, -9.55838803e-03f, -3.39726359e-02f, -2.61958619e-03f, 2.41819724e-01f, 2.11616203e-01f, -4.83222455e-02f, -6.47084191e-02f, 1.26740694e-01f, -1.57770708e-01f,
  -3.75140756e-02f, 6.01679534e-02f, 9.41797346e-02f, 2.80326270e-02f, -9.98698082e-03f, -1.61999226e-01f, -9.40716788e-02f, -1.55929387e-01f, 9.14228782e-02f, -9.44822356e-02f,
  3.93699370e-02f, -8.74329880e-02f, 1.33158369e-02f, 8.54975656e-02f, -1.99150611e-02f, 4.41684835e-02f, -5.03523611e-02f, -9.47249606e-02f, -1.25800252e-01f, -1.72748357e-01f,
  -8.41534063e-02f, 9.96052176e-02f, -6.88320622e-02f, -6.19391985e-02f, 9.19366702e-02f, -7.69927204e-02f, 8.49595014e-03f, -6.02568723e-02f, -1.97606534e-02f, 5.33761829e-02f,
  2.93063726e-02f, -2.62818504e-02f, -1.49419725e-01f, -1.26244426e-01f, -1.40075907e-02f, 1.72847491e-02f, 1.84001893e-01f, -1.02674931e-01f, -9.44123566e-02f, 1.82798401e-01f,
  -5.35422415e-02f, -1.73822209e-01f, -1.80586815e-01f, 2.89608300e-01f, -1.62766464e-02f, -9.17903706e-02f, 1.30525947e-01f, 1.40539512e-01f, -1.89355493e-01f, 1.24332957e-01f,
  -5.70872426e-02f, -1.03054561e-01f, 1.75972693e-02f, -1.60365224e-01f, -5.18857762e-02f, -6.42839447e-02f, -1.78603992e-01f, 3.16903502e-01f, 1.26582205e-01f, -6.31150454e-02f,
  1.58582270e-01f, 1.54886678e-01f, -1.55400345e-02f, 1.70831326e-02f, -2.79733841e-03f, -4.38496359e-02f, -7.51466257e-03f, 1.20975263e-01f, 1.33952036e-01f, 2.53148586e-01f,
  1.01834565e-01f, 1.58666030e-01f, 1.36118010e-01f, 1.62433058e-01f, 8.35562944e-02f, 3.12248506e-02f, -3.04529956e-03f, -6.00965619e-02f, 1.92680076e-01f, 8.21606740e-02f,
  -4.54718322e-02f, 2.40227610e-01f, -2.10891768e-01f, -8.35005343e-02f, -3.37999947e-02f, -6.64086491e-02f, 7.54127800e-02f, 4.01193559e-01f, 5.78136817e-02f, 1.65434852e-01f,
  -1.80117667e-01f, -1.35446519e-01f, 1.99127555e-01f, 1.06255420e-01f, 1.86102465e-01f, 2.31589884e-01f, 7.06921071e-02f, -8.68665874e-02f, 1.73875570e-01f, 1.99473917e-01f,
  2.06675962e-01f, 1.00233719e-01f, 2.62580067e-01f, 5.95592447e-02f, -3.23170483e-01f, 3.57266632e-03f, 4.32947725e-01f, 7.87314586e-03f, -5.20196676e-01f, 3.17978293e-01f,
  1.21444240e-01f, 1.48424312e-01f, 1.34351298e-01f, 7.45903194e-01f, 7.92535022e-02f, 2.72260398e-01f, 9.48961675e-02f, 1.09535307e-01f, -2.69021958e-01f, 8.89507711e-01f,
  -6.04874194e-02f, -7.69410878e-02f, 2.04562202e-01f, -3.31927687e-02f, -1.79584518e-01f, -2.17450827e-01f, -4.33882847e-02f, 1.78777874e-01f, 1.10644616e-01f, 3.00588518e-01f,
  2.59683162e-01f, -5.99114709e-02f, 2.64829814e-01f, 1.74458101e-01f, 9.63789001e-02f, 1.11719877e-01f, -5.14613241e-02f, -8.79498050e-02f, -4.40968007e-01f, -1.00983344e-01f,
  5.14373258e-02f, -4.05945808e-01f, 1.42310500e-01f, -2.36025214e-01f, -7.67493397e-02f, -1.75891072e-01f, -4.23027948e-02f, -1.04187049e-01f, 3.97431165e-01f, -2.73447126e-01f,
  3.59990329e-01f, -2.11900428e-01f, -1.14089966e-01f, 7.30566204e-01f, -3.34455431e-01f, 5.98709360e-02f, 6.87752962e-02f, 4.19861943e-01f, 3.72375250e-01f, 3.05346638e-01f,
  1.95945069e-01f, 2.88134456e-01f, -9.27555747e-03f, 2.78566390e-01f, 2.80754745e-01f, 4.58346844e-01f, 2.80462652e-01f, 4.16953385e-01f, 7.64142275e-02f, 2.16256499e-01f,
  -4.79377389e-01f, 8.05134058e-01f, -4.11180288e-01f, -2.82699671e-02f, 7.45256305e-01f, -7.68624619e-02f, -3.19431603e-01f, 6.78841472e-01f, 2.06371486e-01f, 2.14557141e-01f,
  -8.09366852e-02f, -2.74787452e-02f, -2.31825590e-01f, -3.18190813e-01f, 1.44967020e-01f, 3.68705064e-01f, 2.01928794e-01f, -2.00014368e-01f, -1.81815010e-02f, -4.64130566e-02f,
  -1.44031331e-01f, 2.28635538e-02f, 1.10471509e-02f, -1.08667076e-01f, 5.53474128e-02f, 7.06146657e-03f, 1.78904176e-01f, -1.17192358e-01f, -4.66894805e-02f, -1.84633918e-02f,
  4.71296497e-02f, -5.86253814e-02f, 2.64202580e-02f, -1.38174728e-01f, -3.43009941e-02f, -1.51537895e-01f, -7.82646760e-02f, -5.07870913e-02f, 3.07360709e-01f, -1.45700991e-01f,
  -7.49105290e-02f, -1.80170551e-01f, 1.45659581e-01f, 4.45692800e-02f, 1.13670066e-01f, -3.61896269e-02f, 8.59385729e-02f, 2.76061386e-01f, -1.29874691e-01f, -3.80020067e-02f,
  5.98661602e-02f, 2.41065130e-01f, 2.66255319e-01f, 1.77383181e-02f, 1.23364776e-01f, 4.89381701e-02f, 2.47644469e-01f, -3.82851027e-02f, 1.28302813e-01f, -2.73259915e-02f,
  1.19469073e-02f, 3.96292955e-02f, -2.74432868e-01f, -3.59771073e-01f, -3.06625217e-01f, 4.27586615e-01f, 6.65858269e-01f, 1.38542727e-01f, -4.49391752e-01f, -1.04348697e-01f,
  -2.29013696e-01f, -2.05385596e-01f, -2.04206631e-02f, 1.48483709e-01f, 2.44292274e-01f, 4.03933555e-01f, 2.44866595e-01f, 3.04500461e-01f, 1.94741830e-01f, -5.92833273e-02f,
  1.67598978e-01f, 7.40196586e-01f, 9.23034996e-02f, 3.34285766e-01f, -9.21516642e-02f, 8.50752965e-02f, -1.85982123e-01f, -1.74215183e-01f, -1.23258531e-02f, -1.01562306e-01f,
  4.82493863e-02f, -1.67319953e-01f, -3.21048982e-02f, -4.94492128e-02f, -1.09523050e-01f, 9.64994207e-02f, 1.59278527e-01f, 9.21619236e-02f, -3.39525416e-02f, -8.75913911e-03f,
  -1.39196619e-01f, 1.33451238e-01f, -5.22643439e-02f, 1.21629879e-01f, -1.24449931e-01f, 1.81684420e-01f, -1.60742939e-01f, 8.67814645e-02f, -3.57614048e-02f, -3.58548015e-02f,
  7.07904473e-02f, 5.32212220e-02f, -4.30542007e-02f, 3.51808853e-02f, -1.26949891e-01f, -8.89796242e-02f, -2.80119702e-02f, 2.52344370e-01f, 8.12141448e-02f, 8.02683160e-02f,
  2.09220320e-01f, -3.02331924e-01f, -1.74501196e-01f, -8.59770253e-02f, 1.90846622e-01f, 2.77470827e-01f, -3.45129728e-01f, 3.91211957e-01f, -1.70497429e-02f, 1.88289091e-01f,
  -4.61597368e-02f, 3.45226586e-01f, -1.76870957e-01f, 1.48984239e-01f, -1.73222981e-02f, 1.57072291e-01f, 1.41812876e-01f, -3.20367455e-01f, 1.69131353e-01f, 5.74338257e-01f,
  2.03119561e-01f, 2.32286066e-01f, -2.21068874e-01f, 3.60812485e-01f, -3.12539667e-01f, -2.48495303e-02f, 6.23695664e-02f, 1.20211080e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -8.05795640e-02f, 8.34541172e-02f, 6.61901385e-02f, 1.77915305e-01f, -2.13792220e-01f, 8.26188251e-02f, 1.62740260e-01f, 8.61143172e-02f, 2.31748179e-01f, 1.89213321e-01f,
  -7.84716755e-02f, 2.17060983e-01f, -1.51918545e-01f, 2.52333283e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -2.06674442e-01f, 1.16265059e-01f, -3.53457704e-02f, -5.72312891e-01f, 2.23664135e-01f, 1.21933647e-01f, 7.97557086e-03f, -1.73461080e-01f, 2.62855768e-01f, 3.29177469e-01f,
  -3.23479995e-02f, 3.15760016e-01f, -1.39914364e-01f, 5.00926554e-01f, 4.07287508e-01f, 6.69418573e-01f, -3.87048453e-01f, 9.44210291e-02f, 7.89638013e-02f, -1.45919144e-01f,
  5.86834311e-01f, 4.77043301e-01f, 1.25857919e-01f, 5.86676784e-02f, -3.23480189e-01f, 3.28450441e-01f, -2.65942603e-01f, -5.74386775e-01f, -4.91339043e-02f, 3.78371514e-02f,
  -3.02650724e-02f, -1.02586739e-01f, 3.27222347e-01f, -3.17541882e-02f, 4.73246425e-01f, 3.03335011e-01f, 2.83372253e-01f, -4.51558024e-01f, 3.58818203e-01f, -1.41886145e-01f,
  -3.19381714e-01f, 4.06833053e-01f, -9.24743533e-01f, -6.19563982e-02f, 3.22977453e-01f, 4.21803415e-01f, 2.83258617e-01f, 1.67103723e-01f, -5.85670948e-01f, -1.87418237e-01f,
  1.42361104e-01f, -1.81027666e-01f, 8.01669359e-02f, -4.02478725e-02f, 3.10616046e-02f, 1.59000650e-01f, -1.61017910e-01f, -6.17823601e-01f, 4.22043316e-02f, 2.81110872e-02f,
  -1.65981248e-01f, 8.97123754e-01f, -6.35664314e-02f, -4.54809308e-01f, -2.75166452e-01f, 1.87652618e-01f, -8.07019413e-01f, 1.97916821e-01f, 2.08461270e-01f, -1.74254581e-01f,
  2.65983827e-02f, -3.79725136e-02f, -3.84948403e-01f, 4.42419678e-01f, -1.00745447e-01f, -3.87648970e-01f, 4.67592686e-01f, 1.41496643e-01f, 2.74435788e-01f, 4.01642740e-01f,
  2.59175092e-01f, -1.22524783e-01f, -1.51487678e-01f, 3.26332510e-01f, -5.11176050e-01f, 5.64063340e-02f, 3.84788401e-02f, 5.08959666e-02f, -7.39983842e-02f, -4.93311912e-01f,
  6.81651354e-01f, -4.10727620e-01f, 4.06887800e-01f, 3.70281935e-01f, 9.93005838e-03f, 3.53451848e-01f, -1.32715881e-01f, -8.31831217e-01f, 1.82048842e-01f, -2.38742441e-01f,
  -4.46118742e-01f, -4.22999889e-01f, -9.20312330e-02f, 3.80181782e-02f, 2.88787395e-01f, -5.64003468e-01f, -2.17294469e-01f, 5.76033413e-01f, 2.35479418e-02f, 2.09333636e-02f,
  -5.80167413e-01f, -2.88687468e-01f, 4.81623381e-01f, 4.03302521e-01f, -6.75956607e-02f, -1.12714164e-01f, 7.96862960e-01f, -2.79327296e-02f, 1.47504061e-01f, -6.72895908e-02f,
  2.13352248e-01f, 1.54333174e-01f, -2.81259120e-01f, -5.93232214e-01f, 2.23494664e-01f, -4.46933478e-01f, -1.00025624e-01f, -1.49382085e-01f, 2.55940735e-01f, -2.47323915e-01f,
  2.80016720e-01f, -1.33548602e-01f, 5.20409167e-01f, 6.42002761e-01f, 8.48777950e-01f, 4.80700761e-01f, 8.22292387e-01f, 8.08424532e-01f, 6.72961473e-01f, 6.59799397e-01f,
  -5.62261164e-01f, -4.53934580e-01f, 9.50063393e-03f, -3.50134194e-01f, 9.65543866e-01f, -9.68539119e-02f, 2.64607440e-03f, -1.42975062e-01f, 5.49938753e-02f, 4.23014760e-01f,
  -1.05668575e-01f, 1.10960990e-01f, -1.48412166e-02f, 1.83236837e-01f, -2.97725618e-01f, -1.33232161e-01f, -1.23062924e-01f, -4.14620638e-01f, 5.52129522e-02f, -2.41496831e-01f,
  3.69188488e-01f, 1.81960046e-01f, -5.44500872e-02f, -6.48336783e-02f, 4.30244833e-01f, 1.92609996e-01f, 3.69825363e-01f, 3.21060565e-04f, -2.74262458e-01f, -5.47107160e-01f,
  -3.04717332e-01f, 3.72702301e-01f, -5.75008728e-02f, -1.70702651e-01f, 5.24104893e-01f, -3.79612632e-02f, -8.26289833e-01f, -3.88717115e-01f, 4.37949933e-02f, -8.07569027e-02f,
  -2.48613730e-01f, 3.38928541e-03f, 1.07095145e-01f, -7.99808055e-02f, -7.92476609e-02f, 4.67094839e-01f, -5.43107927e-01f, 9.60342407e-01f, 8.15663934e-02f, -1.17599912e-01f,
  6.65194169e-02f, -3.23053211e-01f, 3.11843127e-01f, -4.42561917e-02f, -1.41426772e-01f, 5.11814892e-01f, -5.52975833e-01f, 6.39822036e-02f, 2.43682474e-01f, -1.01304509e-01f,
  -5.12438238e-01f, -8.63648951e-02f, 3.54002528e-02f, -5.24993539e-01f, -1.18790492e-01f, -1.64949730e-01f, 4.11821663e-01f, 5.76348826e-02f, 4.72419411e-01f, 1.72947258e-01f,
  -1.75879076e-01f, 4.37357686e-02f, -6.48055315e-01f, -1.55265555e-01f, 1.06951721e-01f, 5.41602015e-01f, 2.79009670e-01f, -2.89123982e-01f, 4.11169142e-01f, 8.49695146e-01f,
  -2.74801962e-02f, -3.63863409e-01f, -1.58303037e-01f, 1.29512772e-01f, 2.35520422e-01f, -4.76936668e-01f, -1.62466794e-01f, 1.37953609e-01f, 2.71729290e-01f, -3.26640368e-01f,
  2.36452311e-01f, 4.13496792e-02f, -2.00964078e-01f, 1.26061797e-01f, 1.14745768e-02f, 2.26081267e-01f, 9.79170650e-02f, 6.41301334e-01f, -5.04504919e-01f, 9.62090306e-03f,
  -8.82448256e-02f, 7.17374325e-01f, -7.52418712e-02f, -2.59625614e-01f, -6.28692687e-01f, -8.93822089e-02f, -1.57745689e-01f, 7.42591769e-02f, 3.77461284e-01f, 8.33339393e-01f,
  -2.08097339e-01f, -4.08962488e-01f, -6.94966912e-02f, 1.04097813e-01f, -3.45935449e-02f, 3.01132739e-01f, -7.80229419e-02f, 4.49542701e-02f, 1.20136417e-01f, -1.18647411e-01f,
  2.11859688e-01f, 1.18914224e-01f, -2.03562990e-01f, -3.58808756e-01f, 2.86020935e-01f, -4.41806093e-02f, 2.63150424e-01f, 6.36116043e-02f, 5.91230392e-01f, 3.84642750e-01f,
  1.16073392e-01f, -4.54778880e-01f, -2.91213214e-01f, 3.75558347e-01f, -4.07265835e-02f, 5.80709815e-01f, -3.44439685e-01f, -1.51256815e-01f, -3.96641791e-02f, -1.09761730e-01f,
  -9.76242796e-02f, -3.26090127e-01f, -3.80299091e-01f, -3.76461327e-01f, -8.07446912e-02f, 5.06122649e-01f, -9.23699066e-02f, 7.31438935e-01f, -1.41247455e-02f, 3.61091346e-01f,
  3.26273501e-01f, -5.90220690e-01f, 3.46533984e-01f, 1.92190588e-01f, -4.54177469e-01f, -3.98521461e-02f, -3.34381223e-01f, 6.45283103e-01f, -1.84806257e-01f, -7.86181986e-01f,
  -4.79069382e-01f, -1.70805484e-01f, 2.88275033e-01f, 7.46521831e-01f, 5.58758199e-01f, -3.04312706e-01f, -1.11478329e-01f, -3.36777806e-01f, 4.20666277e-01f, 2.85502877e-02f,
  8.51627290e-02f, -1.85867056e-01f, 2.64550835e-01f, -3.10664356e-01f, 4.48822498e-01f, 5.11066139e-01f, 2.07160190e-02f, -5.91047943e-01f, 5.51005900e-02f, -2.90939867e-01f,
  -1.67363569e-01f, 6.74139988e-03f, -1.13015674e-01f, 1.37765661e-01f, -4.39363062e-01f, 9.03353021e-02f, -2.32874975e-01f, 1.67234659e-01f, 2.99516290e-01f, -4.26942378e-01f,
  3.02088916e-01f, -5.26422083e-01f, 7.28642941e-02f, -2.02817917e-01f, -5.47277570e-01f, -3.33664536e-01f, -4.42524672e-01f, -2.70931184e-01f, 1.03112953e-02f, 2.46947452e-01f,
  7.50982583e-01f, -1.79688364e-01f, -1.14822224e-01f, -1.97263375e-01f, -1.59538090e-01f, -5.76389730e-01f, 4.90146101e-01f, -3.57366353e-01f, 4.85181920e-02f, 1.30072027e-01f,
  -1.68692887e-01f, -1.24811739e-01f, -7.76623964e-01f, 2.10871547e-01f, 1.85652405e-01f, 2.63302118e-01f, -4.06039357e-01f, 2.34809905e-01f, -5.43332219e-01f, 2.30530515e-01f,
  2.84896195e-01f, -5.91577172e-01f, 2.02603996e-01f, 4.12652999e-01f, 2.73597479e-01f, -3.21780682e-01f, -6.38325930e-01f, -4.57080424e-01f, 3.12417597e-01f, -1.67892918e-01f,
  1.61851048e-01f, -2.70427287e-01f, -3.94226700e-01f, -2.73873001e-01f, 1.22306705e-01f, -5.84912412e-02f, 5.30414889e-03f, 4.23969001e-01f, 5.58661446e-02f, 5.61047196e-01f,
  9.56883579e-02f, -4.41066146e-01f, -1.24823377e-01f, 4.82235789e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.46642834e-01f, 1.97402939e-01f, -9.82922763e-02f, 1.34891182e-01f, 5.33529937e-01f, -1.64853096e-01f, 3.61791700e-02f, 2.70488597e-02f, -4.96705845e-02f, 3.35962176e-02f,
  3.08296159e-02f, 1.14512049e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    