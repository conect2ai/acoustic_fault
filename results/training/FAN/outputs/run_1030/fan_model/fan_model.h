/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.98097891e-02f, 5.41569814e-02f, -2.69308597e-01f, 2.47338951e-01f, -2.91988194e-01f, -4.29599017e-01f, -4.10030812e-01f, -1.55479252e-01f, 1.33395910e-01f, 1.35804743e-01f,
  -2.90762305e-01f, -7.62184188e-02f, 1.45054325e-01f, -2.32715495e-02f, -1.55657567e-02f, 5.21361977e-02f, 3.73455882e-01f, 1.95122197e-01f, -3.52429003e-01f, -2.88342685e-01f,
  -1.59618091e-02f, 1.95660934e-01f, 2.05675140e-01f, 5.08987270e-02f, 8.87529999e-02f, 7.06575066e-02f, 2.71686297e-02f, 3.81770320e-02f, -1.40674887e-02f, 4.87006962e-01f,
  -3.12863111e-01f, -1.79787278e-01f, -1.50140747e-01f, 2.99797542e-02f, -1.64472118e-01f, -3.96902822e-02f, -1.05804272e-01f, 3.16364728e-02f, -6.29671961e-02f, -4.30440307e-02f,
  -8.65014344e-02f, -6.38163313e-02f, -1.18588932e-01f, 2.42016781e-02f, -9.37776342e-02f, -1.12795472e-01f, 1.42205432e-01f, 2.06231955e-04f, -4.60511483e-02f, -1.83812410e-01f,
  6.27134740e-02f, -1.65425375e-01f, -2.30411857e-01f, -1.16984673e-01f, -8.79210085e-02f, -2.28037518e-02f, -1.38343573e-01f, -1.38430372e-01f, -8.44685584e-02f, 7.78801590e-02f,
  1.32421702e-01f, -8.06873664e-03f, -5.05851349e-04f, 5.27612194e-02f, 3.87764052e-02f, -8.56421422e-03f, 1.00121982e-01f, -4.19573905e-03f, 8.22997168e-02f, 2.25136057e-02f,
  -9.49868932e-02f, -8.29623360e-03f, -8.89862478e-02f, -6.12013601e-02f, -2.63029225e-02f, -5.55926515e-03f, -7.13854879e-02f, -1.95470788e-02f, -3.83671001e-02f, -1.31341085e-01f,
  -3.16899978e-02f, 4.10734955e-03f, 4.96220887e-02f, -1.06410868e-01f, -1.96956983e-03f, -2.24693324e-02f, 2.49799415e-02f, 2.62911967e-03f, 9.48444009e-02f, -5.58844721e-03f,
  2.65763327e-02f, -1.59051806e-01f, 1.12890815e-02f, 1.94686446e-02f, 1.68042874e-03f, 7.01611442e-03f, -6.96466416e-02f, -4.15290706e-02f, -3.41213942e-02f, -1.15199368e-02f,
  -1.37073636e-01f, -1.24936374e-02f, -8.77315924e-03f, -5.91920968e-03f, -8.93691406e-02f, -2.43614409e-02f, 4.61539105e-02f, -1.92438122e-02f, 7.56794168e-03f, -4.65852730e-02f,
  1.87555343e-01f, 2.05175132e-02f, -6.41952157e-02f, 7.61823133e-02f, 1.47543577e-02f, -2.65755430e-02f, -5.13670556e-02f, -1.16048172e-01f, -1.09096274e-01f, 5.50973527e-02f,
  -6.57104015e-01f, 4.31382284e-02f, -1.35817021e-01f, -2.13103220e-01f, 2.75402099e-01f, 2.05339715e-01f, 3.61149520e-01f, 2.04852208e-01f, -3.06590851e-02f, -7.26583460e-03f,
  1.25680253e-01f, 1.05765328e-01f, 8.16500634e-02f, 2.17268407e-01f, 7.22600296e-02f, 1.37263462e-01f, 1.76681653e-02f, -1.84552208e-01f, 8.16100612e-02f, 2.28828803e-01f,
  2.67370552e-01f, -1.37510836e-01f, -3.27585340e-01f, -5.06244786e-02f, 2.85440944e-02f, 7.15770274e-02f, -8.80827308e-02f, -5.80416359e-02f, 2.16003969e-01f, -4.24280092e-02f,
  -4.61765043e-02f, -1.83615893e-01f, 9.46876556e-02f, 2.24386789e-02f, -2.44112853e-02f, 1.57574974e-02f, 2.91351378e-02f, -8.40700641e-02f, -2.36040335e-02f, -7.15523437e-02f,
  8.86922851e-02f, 5.22225052e-02f, 8.30148067e-03f, 1.02468930e-01f, -3.08326278e-02f, 1.10111058e-01f, 1.63035858e-02f, -7.14428648e-02f, 2.83620291e-04f, 1.43899515e-01f,
  1.23119906e-01f, 1.78811029e-02f, -5.98082282e-02f, 1.16495036e-01f, 5.84311970e-02f, 1.18495651e-01f, -2.39522066e-02f, 8.02477077e-02f, 7.92130306e-02f, -8.40906128e-02f,
  -7.55519569e-02f, -4.14247699e-02f, -1.45666935e-02f, -5.69549650e-02f, 2.84855179e-02f, -2.04065889e-02f, -4.54903580e-02f, -5.28387018e-02f, -2.23112106e-02f, -7.96944052e-02f,
  1.60598997e-02f, 4.53850701e-02f, -5.30766435e-02f, -1.85648911e-02f, 1.28421616e-02f, -2.78674755e-02f, 5.53271696e-02f, 1.22313555e-02f, 3.48605849e-02f, -7.70330802e-02f,
  1.89822856e-02f, -1.96858793e-02f, -3.03935353e-02f, 1.18605662e-02f, 2.53953859e-02f, -4.09382619e-02f, 4.72444780e-02f, 6.01419918e-02f, 1.15367305e-03f, 5.76688610e-02f,
  -8.08213428e-02f, 1.00178905e-01f, -4.42628078e-02f, 1.44234568e-01f, 1.65845882e-02f, 1.54543342e-02f, -3.11088469e-02f, 9.99941118e-03f, 1.33335199e-02f, 6.03203848e-02f,
  1.16950758e-01f, 1.06238956e-02f, 2.83917915e-02f, -3.16002816e-02f, 2.13853456e-02f, 1.85455568e-02f, 1.32185705e-02f, 2.08390667e-03f, 7.50642121e-02f, -2.63517573e-02f,
  9.06986818e-02f, 8.91287327e-02f, 4.78656441e-02f, 8.30430165e-02f, 1.53974384e-01f, 2.59024519e-02f, 1.58504516e-01f, 1.59444600e-01f, 7.87016675e-02f, 1.68793678e-01f,
  -3.14404160e-01f, 5.19575119e-01f, 5.68858445e-01f, -2.75748998e-01f, -2.86783159e-01f, 4.56775241e-02f, 2.18362972e-01f, 1.73363641e-01f, -3.19510847e-01f, 2.48677969e-01f,
  1.50138214e-01f, -3.04999888e-01f, -6.60050735e-02f, 2.12865137e-02f, 1.55956671e-01f, 2.53090203e-01f, 5.28646037e-02f, -2.02348027e-02f, -1.07140556e-01f, -2.09660716e-02f,
  -2.05547810e-01f, -4.30805571e-02f, 9.02940184e-02f, 3.49399075e-02f, -1.17965713e-01f, -1.99235052e-01f, 2.24255264e-01f, 9.26751792e-02f, 2.55495697e-01f, -4.39939573e-02f,
  1.66724876e-01f, 2.34754100e-01f, -1.25778407e-01f, -7.49673694e-02f, 7.79890940e-02f, 3.25927958e-02f, 1.27574359e-03f, 5.22885323e-02f, -1.42431781e-02f, 1.06359236e-01f,
  -4.13730703e-02f, -2.06403937e-02f, -9.39600393e-02f, -5.17335050e-02f, 1.02642417e-01f, 2.36856341e-02f, 1.64775208e-01f, 1.07996322e-01f, 1.62305564e-01f, 6.41415194e-02f,
  -6.12428039e-02f, 7.18582720e-02f, 1.32524639e-01f, 1.90820798e-01f, 1.39850795e-01f, -1.28899723e-01f, 2.84054279e-01f, 1.64117321e-01f, 2.12618992e-01f, 9.50629786e-02f,
  5.68006523e-02f, 7.13349879e-03f, 2.55969651e-02f, -9.25193913e-03f, -2.13827435e-02f, -2.12075952e-02f, -3.12548503e-02f, -1.01873036e-02f, -2.38080192e-02f, -6.34603277e-02f,
  2.50065736e-02f, 1.75014921e-02f, 3.13133262e-02f, 3.59243667e-03f, -4.85279635e-02f, 1.01522170e-01f, -1.09607689e-02f, 1.11645516e-02f, -1.21413004e-02f, -1.91366374e-02f,
  1.99441407e-02f, -6.05260246e-02f, -7.84875732e-03f, -8.44203979e-02f, 5.92048280e-02f, 1.12563095e-04f, -1.98910888e-02f, -5.93355037e-02f, -5.14131524e-02f, 4.96265525e-03f,
  -1.61402851e-01f, 1.85335323e-01f, -7.56383091e-02f, 3.33055891e-02f, -2.60769110e-02f, -9.27169621e-03f, 1.07580908e-02f, -2.47102953e-03f, -2.37473212e-02f, 5.93788810e-02f,
  7.84164667e-02f, 4.60504182e-02f, 8.40986967e-02f, 7.64354914e-02f, -4.79403660e-02f, 2.24395767e-02f, 2.23819464e-02f, -1.02948554e-01f, 5.85284047e-02f, 7.33502284e-02f,
  9.66080129e-02f, -4.89027612e-02f, -1.05732471e-01f, -2.94309948e-03f, 4.39992212e-02f, -1.58883929e-01f, -5.19570010e-03f, -2.93418560e-02f, -5.49062267e-02f, -7.88070410e-02f,
  4.70401198e-01f, 2.57556170e-01f, -2.39933878e-01f, 2.23075569e-01f, 1.22008391e-01f, 4.97934446e-02f, 3.28417718e-02f, 5.09938970e-02f, 2.12150231e-01f, 4.91500162e-02f,
  3.26899111e-01f, 2.89320022e-01f, 3.06189895e-01f, 1.03593521e-01f, 2.08378509e-02f, -1.25389084e-01f, -2.53305525e-01f, -2.11078405e-01f, -5.81850111e-03f, -2.80102510e-02f,
  1.45072311e-01f, 5.43463975e-02f, 7.09333792e-02f, -9.59195569e-03f, 2.22150274e-02f, 3.44635099e-01f, 1.20851053e-02f, 5.50345518e-02f, 1.60810396e-01f, -2.25759208e-01f,
  -3.68234552e-02f, -1.43488705e-01f, 9.64235216e-02f, 2.23106727e-01f, 1.72873020e-01f, 6.19673170e-03f, 5.50824068e-02f, 1.18527934e-01f, 2.32965156e-01f, 1.15963079e-01f,
  2.25636199e-01f, 7.91312084e-02f, 9.92094576e-02f, 1.35119006e-01f, 3.35637666e-02f, 5.15518077e-02f, 2.52177548e-02f, -1.08982893e-02f, 2.44822167e-03f, 4.56208037e-03f,
  2.25073934e-01f, 9.68467146e-02f, 1.31751791e-01f, 1.33167878e-01f, 9.44880992e-02f, 1.27624974e-01f, 8.86774212e-02f, 2.74164788e-02f, 2.94522662e-02f, 1.60177678e-01f,
  6.07456826e-03f, -2.75881886e-02f, 3.07116173e-02f, -1.27431965e-02f, 1.31307036e-01f, 7.28987753e-02f, -7.62186153e-03f, 1.29533455e-01f, 6.57462329e-02f, -2.36110874e-02f,
  -2.70029623e-02f, 1.00939199e-02f, 2.30306871e-02f, 3.56237963e-02f, -8.73126276e-03f, -3.15123722e-02f, 4.76117805e-02f, 5.22820279e-02f, 5.16720340e-02f, -1.32378051e-03f,
  8.00177231e-02f, -5.05089499e-02f, 4.05753776e-02f, -5.75136580e-02f, -5.08053303e-02f, -3.07614282e-02f, -6.85835034e-02f, 1.03712259e-02f, -3.99895757e-02f, -1.14575587e-01f,
  3.74708623e-01f, 1.05464607e-01f, 8.32136497e-02f, -7.88704678e-03f, 9.70619619e-02f, 1.12024233e-01f, 1.42412961e-01f, 1.59402207e-01f, 1.68628469e-01f, 5.93135320e-02f,
  1.63305059e-01f, 1.93612322e-01f, 2.08240464e-01f, -2.95440201e-02f, 1.99885085e-01f, 1.82247713e-01f, 1.85155645e-01f, 7.89449364e-02f, 8.15465301e-02f, 6.57225102e-02f,
  1.56118050e-01f, 2.04581082e-01f, 2.00618446e-01f, 2.59452403e-01f, 1.30055442e-01f, 1.21943131e-01f, 2.41270378e-01f, 1.51162505e-01f, 1.33410662e-01f, 2.91979283e-01f,
  1.49530231e-03f, 1.26250193e-03f, -2.92251587e-01f, -1.83365736e-02f, -3.80550981e-01f, -1.90406859e-01f, -3.93566519e-01f, 1.02483653e-01f, 1.28801733e-01f, -1.31699055e-01f,
  1.54620379e-01f, 3.27285707e-01f, 4.07304525e-01f, 3.23219687e-01f, 3.12914431e-01f, -2.52946109e-01f, -2.88748831e-01f, -3.06911282e-02f, 1.12894952e-01f, -6.11646287e-02f,
  -4.54558469e-02f, -1.28844470e-01f, 2.02793747e-01f, 1.19782865e-01f, -2.32348591e-01f, 1.54229119e-01f, -1.94743782e-01f, -1.35809362e-01f, 2.58722082e-02f, -2.81226546e-01f,
  -5.74427433e-02f, -5.51069714e-02f, 5.22669703e-02f, 1.59421675e-02f, -3.95025052e-02f, 4.90481779e-02f, 2.47258097e-02f, -8.39865059e-02f, 3.91256399e-02f, -3.36289108e-02f,
  1.77394915e-02f, -2.19851406e-03f, -3.64459190e-03f, -1.83181651e-02f, 1.51257748e-02f, -4.61408645e-02f, 4.57460247e-02f, 1.10580094e-01f, 1.29400924e-01f, -6.30178303e-02f,
  7.17686266e-02f, -8.24690461e-02f, -1.14870653e-01f, 1.03274241e-01f, 4.22808789e-02f, 1.10015303e-01f, 5.13570979e-02f, -5.49255777e-03f, 8.95858631e-02f, -2.02064980e-02f,
  9.65300649e-02f, -2.47822329e-02f, -5.13971262e-02f, 4.19803932e-02f, 4.92195413e-02f, -3.02821142e-03f, -1.31580504e-02f, 7.24131381e-03f, 1.15454402e-02f, 1.73561126e-02f,
  7.38388002e-02f, 4.27256047e-04f, 8.14342722e-02f, 3.13892728e-03f, -2.78909151e-02f, -1.09449320e-01f, 1.59674673e-03f, 7.16768252e-03f, 9.37661007e-02f, 1.73194874e-02f,
  1.75342206e-02f, 1.79500524e-02f, -1.67855751e-02f, -4.95710131e-03f, 4.24684808e-02f, 1.83172489e-03f, 1.14363832e-02f, 6.30123764e-02f, 3.53924409e-02f, -4.38940525e-02f,
  2.69266516e-01f, 2.49597996e-01f, 3.20523009e-02f, 8.84136185e-02f, -1.76884141e-02f, 7.42155164e-02f, -1.02579277e-02f, 4.37668227e-02f, -8.65046754e-02f, 1.97579246e-02f,
  -4.07207571e-02f, 4.44185687e-03f, -3.12046148e-02f, 3.04071847e-02f, -4.85047214e-02f, -2.84850672e-02f, -1.78596508e-02f, 1.10280244e-02f, 5.11673130e-02f, -1.12065837e-01f,
  -2.29665153e-02f, -1.04227781e-01f, -6.38605356e-02f, 3.85508351e-02f, 8.50711465e-02f, -4.25683148e-02f, -2.72037443e-02f, -7.97250122e-02f, 8.39936659e-02f, 7.21190649e-04f,
  5.66254258e-01f, 2.40557760e-01f, -2.22952276e-01f, 4.56914082e-02f, 1.69513598e-02f, 2.68841404e-02f, 3.77792805e-01f, 7.88474530e-02f, 2.98962370e-02f, 1.95006818e-01f,
  -1.71119213e-01f, -3.10553342e-01f, -2.42015541e-01f, -3.07213098e-01f, -1.03530183e-01f, 2.46952489e-01f, 1.63796112e-01f, -1.21044509e-01f, -1.85102329e-01f, -1.10629372e-01f,
  3.45099755e-02f, 2.12663233e-01f, -2.94915903e-02f, -8.20169896e-02f, 1.18847586e-01f, 8.87819380e-02f, -2.76510284e-04f, 8.62194970e-02f, -7.43969902e-02f, 2.47427076e-01f,
  -1.83434948e-01f, 1.27777055e-01f, -9.64215398e-02f, 3.62680783e-03f, -6.18280694e-02f, 9.32125226e-02f, 1.08200535e-01f, -1.54652493e-02f, 6.25940636e-02f, 7.99439996e-02f,
  -4.17582057e-02f, -3.24984491e-02f, -2.84059849e-02f, -7.83508420e-02f, 7.76673704e-02f, 7.55523890e-02f, 1.60640143e-02f, 3.67856249e-02f, -1.86826214e-02f, 1.63817704e-02f,
  -1.92712229e-02f, -4.80951741e-02f, -1.80771202e-02f, -3.51201780e-02f, -1.25157619e-02f, 6.78866580e-02f, -8.82118195e-02f, 3.23245302e-02f, 4.14606854e-02f, 2.32387424e-01f,
  5.74755250e-03f, 4.07643430e-02f, -8.08404908e-02f, 1.72691625e-02f, 8.91209021e-02f, -1.05765602e-02f, -6.51910482e-03f, 5.95703162e-03f, -5.56778908e-02f, 4.34597731e-02f,
  -7.71810636e-02f, -7.31367022e-02f, 2.15706136e-02f, 6.66813329e-02f, -1.02994740e-01f, 3.70806195e-02f, 1.34188100e-04f, -2.60178349e-03f, -1.89361244e-01f, 2.94698533e-02f,
  -7.71687478e-02f, -3.60128353e-03f, 1.72798056e-03f, -6.05175719e-02f, -4.91702929e-02f, -2.10674722e-02f, 6.79380000e-02f, -5.35568260e-02f, 1.51895266e-02f, 6.28032833e-02f,
  6.23955280e-02f, -2.14552164e-01f, 7.53547698e-02f, 9.59764197e-02f, -3.12561914e-02f, -5.91706485e-02f, 2.86158752e-02f, -1.37803871e-02f, -1.81232654e-02f, 3.81812192e-02f,
  2.37585697e-02f, 3.50089557e-02f, 3.95246372e-02f, 3.99965094e-03f, -8.14688858e-03f, 5.18450364e-02f, 4.68516164e-02f, 1.36943357e-02f, 6.99828267e-02f, 8.45323596e-03f,
  1.04242146e-01f, 1.71738967e-01f, 3.19114253e-02f, 1.09267630e-01f, 5.76950647e-02f, 1.24923430e-01f, 8.86301547e-02f, 1.32385314e-01f, -1.95314698e-02f, 2.82648683e-01f,
  2.25560755e-01f, 1.21513464e-01f, 2.94349883e-02f, 1.88777745e-01f, -1.87700167e-01f, -2.29442924e-01f, -2.36365646e-01f, -1.15183711e-01f, 7.44189173e-02f, 1.16432272e-01f,
  2.54136268e-02f, 5.20694861e-03f, 1.61635444e-01f, 1.53968828e-02f, -5.09705544e-02f, -1.32455707e-01f, -8.26838687e-02f, -8.09489265e-02f, -2.42479980e-01f, -2.35953972e-01f,
  -1.26234204e-01f, 4.38940478e-03f, -3.11960839e-03f, -2.07286086e-02f, 5.92507422e-02f, -9.27828923e-02f, 1.19456284e-01f, 7.92692304e-02f, 6.64773062e-02f, 1.44358546e-01f,
  1.19161621e-01f, 2.18825266e-02f, -7.36552924e-02f, -3.01393345e-02f, 6.86019240e-03f, 4.97865304e-02f, 6.54184520e-02f, 4.60696258e-02f, 2.93475222e-02f, 5.63931651e-02f,
  1.55828493e-02f, -1.14630144e-02f, -4.33464646e-02f, -1.80606451e-02f, -4.48222068e-04f, 3.68783474e-02f, 5.15348129e-02f, 1.83457490e-02f, 1.03185929e-01f, 1.06178798e-01f,
  2.66373213e-02f, 1.11550614e-01f, 3.25834118e-02f, -1.34656150e-02f, 7.37591609e-02f, 1.52946621e-01f, -7.15913549e-02f, 9.50667039e-02f, 1.33085802e-01f, 3.30904350e-02f,
  6.64948002e-02f, -5.95345832e-02f, -8.07497371e-03f, 3.75101306e-02f, -2.05731485e-02f, 1.79986991e-02f, 8.01020712e-02f, 3.99313122e-02f, 1.35487085e-02f, 2.63804034e-03f,
  3.84463370e-02f, 5.58232330e-02f, 6.77031055e-02f, 1.13024436e-01f, 5.03037684e-02f, 5.27760647e-02f, 1.19145215e-02f, 9.27789789e-03f, 1.34360984e-01f, 6.54254630e-02f,
  2.09394190e-03f, 1.15623787e-01f, 6.05830774e-02f, -9.27519128e-02f, 1.06390819e-01f, 9.18045565e-02f, 9.81749780e-03f, -2.16650236e-02f, -1.04885269e-02f, 5.62093928e-02f,
  -1.34080350e-01f, 4.89218011e-02f, 8.16624537e-02f, -3.40682678e-02f, -2.22651158e-02f, 2.18035251e-01f, 1.85663104e-01f, 4.79244292e-02f, 8.82746205e-02f, 2.23521404e-02f,
  -1.71438958e-02f, 3.16370316e-02f, 8.64299163e-02f, 5.38216271e-02f, -3.37118544e-02f, -1.56811681e-02f, 7.38237053e-03f, -1.19371200e-02f, 5.53000197e-02f, 1.11473367e-01f,
  1.37148649e-01f, -1.01469427e-01f, -1.10113537e-02f, 2.58302875e-02f, -3.34323086e-02f, -1.04657196e-01f, -5.02117500e-02f, -9.97940302e-02f, -8.55316743e-02f, -1.96939170e-01f,
  2.03834623e-01f, -1.85806658e-02f, 2.77413607e-01f, 2.73892283e-01f, 4.65326995e-01f, 2.14913383e-01f, 8.68427753e-02f, -1.69799745e-01f, 1.21502746e-02f, -6.74720407e-02f,
  1.15535080e-01f, 1.39097432e-02f, -4.78956923e-02f, -8.93696100e-02f, -2.86279097e-02f, -3.27400975e-02f, 2.00095117e-01f, 1.95140973e-01f, 8.07952136e-02f, 1.06535152e-01f,
  8.92061442e-02f, 2.46278286e-01f, 2.77530938e-01f, 1.03944913e-01f, 7.76772201e-02f, 7.99791962e-02f, 1.18244708e-01f, 2.38184303e-01f, 2.14575931e-01f, 3.53887945e-01f,
  8.72733817e-02f, -3.47142294e-02f, -4.58583385e-02f, 4.72133830e-02f, 1.59324080e-01f, -7.77742863e-02f, -7.00178072e-02f, -5.64852171e-02f, -6.52687764e-03f, -1.47883594e-02f,
  7.74433166e-02f, -4.21256613e-04f, -3.63615118e-02f, 3.47983055e-02f, 5.49399145e-02f, -8.48154631e-03f, -9.65561569e-02f, -5.69522083e-02f, -5.74893318e-02f, 5.72700938e-03f,
  6.92602918e-02f, 7.31666014e-02f, -8.67672935e-02f, -5.90293370e-02f, -1.01436839e-01f, 1.07855722e-01f, -2.30139792e-02f, 4.84985579e-03f, -4.20922153e-02f, -1.34538352e-01f,
  1.15623344e-02f, 3.20435949e-02f, 3.21658030e-02f, -8.48162733e-03f, 5.78607693e-02f, -5.99949732e-02f, 8.79242346e-02f, 1.97709315e-02f, 1.09551169e-01f, -4.04155515e-02f,
  6.51707724e-02f, 1.17849991e-01f, 6.11743778e-02f, 5.51999174e-02f, 1.36911064e-01f, -2.52177250e-02f, 5.65590784e-02f, -1.73741449e-02f, 3.25082801e-02f, -1.62023329e-03f,
  3.87881920e-02f, 6.66145831e-02f, 9.43195373e-02f, -2.37829983e-03f, 1.21582069e-01f, 1.45655736e-01f, 7.72281513e-02f, 2.84206402e-02f, 3.63099985e-02f, -1.81778576e-02f,
  -6.88104853e-02f, 2.27127541e-02f, -1.00053601e-01f, -6.45802468e-02f, -7.44178332e-03f, -1.05010077e-01f, 6.20896965e-02f, -5.30118011e-02f, 6.44782260e-02f, -5.22611216e-02f,
  3.64474542e-02f, -2.86587458e-02f, -2.48832460e-02f, -6.16824394e-03f, 2.06119064e-02f, -5.83607256e-02f, -1.89255867e-02f, 3.43429632e-02f, -8.33961442e-02f, -7.94159323e-02f,
  1.58577284e-03f, -5.01522571e-02f, -1.79462418e-01f, -1.63146168e-01f, -4.86511700e-02f, -8.84539261e-02f, -9.96028110e-02f, -1.47977956e-02f, -3.72245386e-02f, -1.53572530e-01f,
  -6.51165068e-01f, 1.66661575e-01f, -8.86034220e-02f, -3.05180233e-02f, 1.48559898e-01f, -2.03094408e-01f, -2.54754931e-01f, -2.70597458e-01f, -3.55315022e-02f, 1.00554444e-01f,
  -7.21112117e-02f, 7.04962090e-02f, -3.90891843e-02f, -9.06851050e-03f, -2.51885086e-01f, 1.34259075e-01f, 1.84918359e-01f, -1.55391231e-01f, -1.98340267e-01f, -1.50868699e-01f,
  6.34384975e-02f, 6.21663500e-03f, -2.67406225e-01f, -1.07204579e-01f, 2.87330538e-01f, 2.41618887e-01f, 1.85744941e-01f, 4.50617447e-02f, 1.58503354e-01f, 5.23463070e-01f,
  2.71964282e-01f, -6.28678873e-02f, -6.62978739e-02f, 5.04329130e-02f, 9.42374468e-02f, -3.76494713e-02f, 1.56344846e-02f, 8.66599530e-02f, 8.52683093e-03f, 8.24761242e-02f,
  5.66863157e-02f, 3.18345660e-03f, 3.92519124e-02f, 5.54512516e-02f, 3.16589996e-02f, -2.86248215e-02f, -2.54898425e-02f, -7.05412924e-02f, -1.19008243e-01f, 3.68116312e-02f,
  7.34004602e-02f, 7.65776038e-02f, -1.46796992e-02f, 1.08609153e-02f, -2.17851415e-01f, -7.98968077e-02f, 3.63138057e-02f, -7.78054893e-02f, -8.65575671e-02f, 4.36406024e-02f,
  2.33109836e-02f, -6.00034045e-03f, -4.01493497e-02f, 1.32225994e-02f, -5.95519412e-03f, 2.99194781e-03f, 1.72117334e-02f, 5.03480360e-02f, -3.86756519e-03f, -1.90062053e-03f,
  3.48917805e-02f, 1.15890906e-03f, -2.34593600e-02f, -4.86443564e-02f, 8.99494290e-02f, 9.04652057e-04f, -3.72618227e-03f, 6.86884895e-02f, -3.28852236e-02f, -2.84712575e-02f,
  -4.59581688e-02f, -3.86464857e-02f, -1.05289300e-03f, 3.23529132e-02f, 2.03169952e-03f, -3.96766525e-04f, 6.79231212e-02f, -2.21112138e-03f, 1.20464889e-02f, -4.41309810e-03f,
  6.89990222e-02f, -2.34693274e-01f, 8.52048621e-02f, -1.15809692e-02f, 4.29487117e-02f, -2.30681021e-02f, 8.15046951e-02f, -3.80071141e-02f, 1.00861657e-02f, 1.42425923e-02f,
  -1.45907775e-02f, -4.19609584e-02f, -6.24061935e-03f, -2.55273581e-02f, -1.48312366e-02f, 5.79219982e-02f, 4.28112224e-02f, -5.57267619e-03f, 4.12196144e-02f, 6.89237565e-02f,
  9.85395908e-03f, -3.64407375e-02f, -2.38040574e-02f, -3.24770324e-02f, -6.26089843e-03f, 3.50055024e-02f, 7.12560192e-02f, 9.17437151e-02f, -1.61270499e-01f, 5.82519397e-02f,
  -7.86200687e-02f, 5.52055418e-01f, 6.46816790e-02f, 2.51189489e-02f, 2.21546385e-02f, -3.39535236e-01f, -7.47596771e-02f, -9.91605669e-02f, -4.29798104e-02f, 1.76059499e-01f,
  1.74883381e-01f, 7.37174526e-02f, 7.43423030e-02f, -3.58242467e-02f, -1.10736646e-01f, -4.07629460e-02f, 2.98026521e-02f, -2.82666355e-01f, -4.66344744e-01f, -2.43156031e-01f,
  4.89614829e-02f, 2.67246924e-02f, 7.11158216e-02f, -9.05646011e-02f, 1.39432341e-01f, -7.40950033e-02f, 7.62575269e-02f, 1.31769255e-01f, 1.65697321e-01f, 3.63444299e-01f,
  -3.29604894e-02f, 2.69782215e-01f, -4.90612350e-02f, 1.37888893e-01f, 7.46132582e-02f, 2.81925648e-02f, -5.34661487e-03f, 2.94008199e-02f, 7.52063468e-02f, 9.23804846e-03f,
  1.82546914e-01f, 2.95915976e-02f, 4.92165126e-02f, 6.71185479e-02f, -5.26001118e-02f, -2.85130776e-02f, 1.03477001e-01f, 5.69111258e-02f, 6.03335202e-02f, 8.25162753e-02f,
  4.02379632e-02f, 1.87615231e-01f, 9.41644460e-02f, 6.51800185e-02f, 2.89075915e-02f, -6.72591617e-03f, 2.72284281e-02f, 1.80367064e-02f, -4.18191776e-03f, 4.61027548e-02f,
  -1.03971399e-02f, -1.01158060e-02f, -4.90572937e-02f, -5.65135889e-02f, -1.23871602e-01f, -5.58479549e-03f, -9.52214450e-02f, 1.81554202e-02f, -3.69696096e-02f, 2.98559964e-02f,
  -7.74821565e-02f, -7.37540796e-02f, 2.24563405e-02f, -3.32565010e-02f, -1.98665764e-02f, 3.90938446e-02f, -3.18871662e-02f, -4.07428248e-04f, 7.11346567e-02f, -2.27429923e-02f,
  -5.31324297e-02f, 4.84513305e-02f, -1.15924748e-02f, 3.89214195e-02f, 1.19451880e-01f, -6.30876496e-02f, -6.40061721e-02f, 7.82081336e-02f, -7.18435645e-02f, -6.73187599e-02f,
  -1.95647925e-01f, 1.31122386e-02f, 8.95467773e-03f, 8.39313045e-02f, 7.57074058e-02f, 4.09761630e-02f, 1.88492864e-01f, 5.74621521e-02f, 1.93393808e-02f, 1.10239526e-02f,
  5.67485839e-02f, -1.72065888e-02f, 9.28644687e-02f, 3.31272408e-02f, -6.53400645e-02f, 1.23184547e-02f, 7.39348680e-02f, -4.49531786e-02f, 1.00278698e-01f, 6.83082193e-02f,
  6.70232251e-02f, -1.91308662e-01f, -2.47621462e-01f, -1.67237237e-01f, -8.03470016e-02f, -2.33751670e-01f, -1.66686743e-01f, -1.48017868e-01f, -3.31670135e-01f, -2.65060604e-01f,
  -1.54204860e-01f, -1.70682028e-01f, -1.32650748e-01f, -9.22482684e-02f, 3.41998711e-02f, 1.62822753e-03f, -3.48492801e-01f, -1.00884445e-01f, 9.92598310e-02f, -1.13951713e-01f,
  9.77516323e-02f, 2.85318345e-01f, 3.20750296e-01f, 2.40157083e-01f, -5.20584174e-02f, -2.92135179e-01f, -2.76497424e-01f, -6.79291934e-02f, 1.26530454e-01f, -7.89421201e-02f,
  -4.09112312e-02f, -1.47786096e-01f, -1.12734675e-01f, -1.87612362e-02f, -6.83724284e-02f, 2.63823897e-01f, -1.12123042e-01f, -2.06485137e-01f, -2.16349289e-02f, -1.54047221e-01f,
  1.87638551e-01f, -9.01601985e-02f, 6.81703836e-02f, 8.71867314e-02f, 9.68714338e-03f, 1.23172672e-02f, 7.14182109e-02f, 7.07050040e-02f, 5.14690429e-02f, -3.89570929e-02f,
  -7.19553381e-02f, -8.72725323e-02f, 3.01679820e-02f, 4.67738435e-02f, -8.14855620e-02f, -3.44636664e-02f, -1.22927196e-01f, -1.09974213e-01f, -1.04236938e-02f, 7.70235881e-02f,
  2.01250780e-02f, -1.55922979e-01f, -1.37502225e-02f, -8.29057395e-02f, -4.60348912e-02f, 9.11317691e-02f, -7.07290918e-02f, -4.49586436e-02f, 4.25975546e-02f, -2.06496939e-01f,
  1.63449287e-01f, 9.29489732e-02f, 6.61899894e-02f, -6.64048940e-02f, 7.67355114e-02f, 4.25803214e-02f, 3.58377211e-03f, -8.50524846e-03f, 8.03924166e-03f, -9.31593031e-02f,
  1.16042737e-02f, -6.42248914e-02f, 9.62301809e-03f, -7.61422962e-02f, 5.75502403e-02f, -1.02847842e-02f, -6.48276787e-03f, 1.40118450e-02f, 6.00574799e-02f, -4.54081073e-02f,
  3.90589535e-02f, 4.24445011e-02f, 1.18538830e-02f, -1.95715707e-02f, -1.72840934e-02f, -3.19685563e-02f, 9.33110341e-03f, -5.21974899e-02f, 6.97983131e-02f, 5.62345330e-03f,
  1.43620640e-01f, -1.25516616e-02f, 8.08435157e-02f, 2.79133301e-02f, 3.61193195e-02f, 4.65709157e-02f, -7.49148778e-04f, -7.57988095e-02f, -3.09770796e-02f, -3.09376046e-02f,
  -1.01520754e-02f, -2.17718277e-02f, -8.72568116e-02f, -4.27513309e-02f, -4.17058319e-02f, -5.22632711e-02f, -2.74717733e-02f, -6.13896968e-03f, -3.94314602e-02f, -8.23481381e-02f,
  -7.33433738e-02f, 4.05784510e-03f, 5.32062054e-02f, 5.33377007e-02f, 3.54117192e-02f, 1.10346787e-01f, -2.92619970e-02f, 3.64075005e-02f, 8.69870279e-03f, 5.69135733e-02f,
  2.49633819e-01f, 3.23265582e-01f, 1.19196065e-01f, 9.60443094e-02f, -5.31501472e-02f, 9.72811952e-02f, 3.17552537e-01f, 1.23688109e-01f, -1.79808103e-02f, 1.91360146e-01f,
  7.38515407e-02f, -1.54188871e-01f, -2.15948727e-02f, 7.40053505e-02f, 2.34106049e-01f, 4.54664141e-01f, 3.32523108e-01f, 1.46511570e-01f, 4.52627726e-02f, 9.82760638e-02f,
  5.17963469e-02f, -2.66152453e-02f, 4.93463874e-02f, -2.42995229e-02f, 1.33075848e-01f, 1.34465262e-01f, 9.02505517e-02f, 1.05683021e-01f, 1.57551721e-01f, 2.69692153e-01f,
  2.15209424e-01f, 1.80011820e-02f, 1.25358244e-02f, 2.45464500e-02f, 1.42701492e-01f, 1.57924071e-01f, 1.36311963e-01f, 1.11166008e-01f, 6.40510395e-02f, 1.12095580e-01f,
  7.54360929e-02f, 1.73580702e-02f, 2.03388929e-02f, 1.16559714e-02f, 8.97757038e-02f, 9.50868726e-02f, 1.33140936e-01f, 1.04358174e-01f, 8.56263563e-02f, 1.66330919e-01f,
  3.12196892e-02f, 1.56488463e-01f, 1.55914932e-01f, 6.56875819e-02f, 8.47379938e-02f, 1.56887900e-02f, 1.09434597e-01f, 1.31188363e-01f, 5.68112284e-02f, 1.89260200e-01f,
  -1.22051813e-01f, 7.16672987e-02f, 5.26612662e-02f, -3.34608480e-02f, 7.94939399e-02f, 6.28034770e-03f, -2.94301510e-02f, 2.42293365e-02f, -8.03639181e-03f, 2.59520374e-02f,
  -2.92048417e-03f, 5.38503304e-02f, 4.71808724e-02f, 2.05345936e-02f, 7.56733268e-02f, -2.19935868e-02f, 1.21757183e-02f, 4.73945476e-02f, 8.77640992e-02f, 2.94285566e-02f,
  1.76784005e-02f, -3.77505049e-02f, 9.89647675e-03f, -5.64734302e-02f, 9.85828266e-02f, -1.46687292e-02f, 3.85716520e-02f, 2.55632773e-02f, 9.67326760e-02f, -4.64653447e-02f,
  2.48646606e-02f, -8.91136974e-02f, 2.28638873e-01f, 1.45827144e-01f, 1.24334715e-01f, 1.87894180e-01f, 2.77049057e-02f, 1.71268031e-01f, -3.73398489e-03f, 1.27275944e-01f,
  1.04050256e-01f, 1.38225526e-01f, 1.15583912e-01f, 3.56096327e-02f, 2.37023756e-02f, 4.76628952e-02f, 1.88467726e-01f, 3.15697342e-02f, 5.95099963e-02f, 1.51009008e-01f,
  8.04336071e-02f, 2.22745731e-01f, 2.51366138e-01f, 1.48348480e-01f, 1.46778151e-01f, 1.32855579e-01f, 1.33584812e-01f, 6.08330444e-02f, 2.85459548e-01f, 3.36151868e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.36877191e+00f, 1.56788889e-03f, -5.89833021e-01f, -5.27264476e-01f, 2.65195042e-01f, 3.27611595e-01f, 8.38002980e-01f, -1.19114602e-02f, -2.66117811e-01f, 3.84841226e-02f,
  -6.34463504e-02f, -2.15124667e-01f, -1.65877312e-01f, 2.61186033e-01f, 1.79810479e-01f, 4.71480161e-01f, 3.98072839e-01f, -1.03927866e-01f, -1.33499637e-01f, 2.82779157e-01f,
  3.97027493e-01f, -3.28150034e-01f, -7.21645057e-01f, -1.26145110e-01f, -1.67473823e-01f, 1.51714673e-02f, -1.35508046e-01f, -2.26625383e-01f, 2.71309018e-01f, 2.36556590e-01f,
  -4.56357330e-01f, -3.20633918e-01f, 3.00857902e-01f, -5.79296835e-02f, -5.44880368e-02f, -1.75567463e-01f, 2.49295402e-02f, -2.47395545e-01f, -4.81220707e-02f, -8.39083567e-02f,
  -1.55932918e-01f, -7.67387077e-02f, -4.50416431e-02f, 3.89252268e-02f, -1.88796192e-01f, -3.03805526e-02f, -1.02299534e-01f, -1.33790225e-01f, -1.31767049e-01f, 6.81181699e-02f,
  3.84523362e-01f, 1.22590018e-02f, -3.83946866e-01f, 1.47198215e-01f, 1.90912753e-01f, 8.80246162e-02f, 1.87058337e-02f, 1.51244357e-01f, 8.26488137e-02f, -2.80069381e-01f,
  8.25863630e-02f, -5.28694950e-02f, 1.13424368e-01f, -1.14202425e-02f, 1.12777688e-01f, -7.57243633e-02f, 1.26216365e-02f, -2.60822512e-02f, -2.25260109e-02f, -1.66915715e-01f,
  7.34139383e-02f, 7.89196580e-04f, 7.37880822e-03f, -1.89101636e-01f, -1.11787347e-02f, -5.27772531e-02f, 8.10615495e-02f, -4.26727012e-02f, -1.85697235e-03f, -2.91768238e-02f,
  -7.29072317e-02f, 4.01119813e-02f, -1.63210183e-01f, 1.15927637e-01f, 1.58427760e-01f, -6.48338497e-02f, 1.51995365e-02f, -8.53627622e-02f, -5.09533770e-02f, 7.24733025e-02f,
  -4.31800008e-01f, 3.52649152e-01f, -2.78435618e-01f, -8.20255186e-03f, -4.63893339e-02f, -7.37683997e-02f, -2.03654930e-01f, -6.67208061e-02f, -4.67485711e-02f, -3.26003283e-02f,
  1.09261125e-01f, -8.70287344e-02f, -1.36949137e-01f, 7.14109987e-02f, 7.28166103e-02f, -8.08950737e-02f, 2.09478900e-01f, -5.50931096e-02f, 1.54195994e-01f, -6.45742640e-02f,
  8.32988471e-02f, 1.37384638e-01f, -2.29874179e-01f, -3.86961065e-02f, 4.82080951e-02f, -1.33838346e-02f, -2.68147200e-01f, -1.46606594e-01f, 1.35765135e-01f, -2.36653894e-01f,
  1.79528102e-01f, -7.03527153e-01f, 2.88995475e-01f, 5.01678765e-01f, 5.40119052e-01f, 4.16534424e-01f, 2.36066476e-01f, 2.05299661e-01f, 2.66367078e-01f, 8.20840057e-03f,
  -2.10327163e-01f, 1.23924665e-01f, 1.05741061e-01f, -2.37201136e-02f, 1.78581644e-02f, 2.41804391e-01f, 2.95034945e-01f, 2.13695154e-01f, 4.10325170e-01f, 2.95762539e-01f,
  1.48832723e-01f, -2.03006789e-01f, -2.19927788e-01f, -7.83636272e-02f, -4.29968648e-02f, 2.88210660e-01f, 4.28288803e-02f, -3.95134389e-02f, 1.39550641e-04f, 2.82867998e-01f,
  2.02189103e-01f, -2.69100934e-01f, 1.95297450e-01f, -2.30388969e-01f, -1.70669362e-01f, -3.27715904e-01f, -2.84964424e-02f, -1.19835988e-01f, -7.76310787e-02f, -1.39734775e-01f,
  -5.41215278e-02f, -1.43362731e-01f, -6.41231090e-02f, -1.25968605e-01f, -1.58056691e-02f, -1.44775793e-01f, -2.22829044e-01f, -9.28798765e-02f, 5.97025901e-02f, -1.34560596e-02f,
  -2.34649293e-02f, 6.55919835e-02f, 1.39699593e-01f, 1.55986115e-01f, 7.54634589e-02f, 8.25704485e-02f, -3.21398266e-02f, -3.12501937e-02f, -7.27070123e-03f, -9.59183425e-02f,
  2.42942661e-01f, 5.29688075e-02f, 3.32582816e-02f, -4.01089676e-02f, 3.08712982e-02f, 1.73322633e-02f, 1.56591475e-01f, 5.83578683e-02f, 1.30085006e-01f, -1.15874209e-01f,
  1.05228372e-01f, 1.91243052e-01f, 1.28914744e-01f, 1.96378864e-02f, 8.16480219e-02f, -2.79140822e-03f, -2.03929059e-02f, -7.99331963e-02f, -1.59080952e-01f, -1.77748855e-02f,
  3.79594117e-02f, 8.03330839e-02f, -1.19881958e-01f, -1.37954175e-01f, -1.32706672e-01f, 6.17806474e-03f, 5.45909256e-02f, 5.68024255e-03f, -1.62526011e-01f, -6.96965382e-02f,
  2.54705884e-02f, 1.85509682e-01f, 1.78431183e-01f, 5.13419658e-02f, -5.61640039e-02f, -1.80437163e-01f, 7.32880235e-02f, -8.95382091e-02f, 7.25888927e-03f, -1.72496103e-02f,
  -1.08096123e-01f, 2.01331005e-02f, -1.32976800e-01f, -2.01697648e-01f, 6.56383410e-02f, -2.36920678e-04f, -1.24482729e-01f, 2.33303800e-01f, 1.52374491e-01f, -5.54198287e-02f,
  -8.88321847e-02f, 1.87119395e-01f, 2.55781084e-01f, 2.98025608e-01f, 1.48534477e-01f, 2.74752825e-01f, 1.05310604e-01f, -3.67251551e-03f, 2.32974455e-01f, -1.18813328e-01f,
  -1.41232889e-02f, -5.83123386e-01f, -4.05889630e-01f, -3.18614870e-01f, -3.34976554e-01f, -1.80845663e-01f, -8.80766928e-01f, -4.15918492e-02f, 1.66344956e-01f, -7.28683949e-01f,
  -1.76603228e-01f, 4.83974338e-01f, 1.94092259e-01f, 2.22016275e-01f, 3.11997890e-01f, -8.23403180e-01f, -4.90484625e-01f, 3.05906266e-01f, 7.88756549e-01f, 2.77733237e-01f,
  1.42484814e-01f, -1.35127641e-02f, 5.02402604e-01f, 3.45749855e-01f, -6.84871554e-01f, 1.03306688e-01f, -4.28227991e-01f, -2.04809830e-01f, -1.32185176e-01f, -7.66742051e-01f,
  -4.90129143e-01f, -1.86850727e-01f, 2.81792164e-01f, 1.87368661e-01f, -2.04205111e-01f, 5.15030921e-02f, -1.38707869e-02f, -1.45591214e-01f, -1.41377255e-01f, -6.24126531e-02f,
  -3.37995440e-02f, 2.60052651e-01f, 2.36243397e-01f, 2.28553668e-01f, -4.16855440e-02f, 3.63040455e-02f, -3.87328118e-03f, -3.32315499e-03f, -6.84173927e-02f, -1.35102242e-01f,
  -4.06159572e-02f, 4.36591953e-02f, 1.21086370e-02f, -4.21349853e-02f, 1.45091042e-01f, 1.35679632e-01f, -2.97038686e-02f, 2.60293931e-02f, 1.94654763e-01f, -5.96531987e-01f,
  -4.60026339e-02f, 2.35502934e-03f, -5.79000749e-02f, 2.10937113e-02f, -1.93943791e-02f, -6.15237392e-02f, -1.69206094e-02f, -3.72355543e-02f, 1.71308890e-02f, -1.17786326e-01f,
  -2.86523644e-02f, -3.44689637e-02f, 6.28952309e-02f, -1.28889784e-01f, -7.20700771e-02f, 5.17070033e-02f, -3.40638943e-02f, -1.05722085e-01f, 5.74338511e-02f, 4.78669740e-02f,
  4.42617461e-02f, 3.38222608e-02f, -1.13510691e-01f, 8.51072520e-02f, -5.75377680e-02f, 1.81154776e-02f, -2.29617693e-02f, 1.84538722e-01f, -3.19267176e-02f, -5.06228842e-02f,
  -1.82635993e-01f, 3.65353674e-01f, -3.88805419e-01f, 1.26516046e-02f, 5.24789393e-02f, -1.39248118e-01f, -1.64038345e-01f, 7.00363293e-02f, 1.81368142e-01f, -1.25961530e-03f,
  2.43102357e-01f, -3.30759063e-02f, -1.27405375e-01f, 8.09431076e-03f, 1.58749595e-02f, 6.72515109e-02f, -5.83538599e-02f, 3.30535546e-02f, 2.14298397e-01f, -7.31619149e-02f,
  -7.27049112e-02f, -1.42933547e-01f, 7.15593388e-03f, -4.74239551e-02f, 7.02454299e-02f, 2.12840900e-01f, -5.11258617e-02f, -2.52744526e-01f, -1.16388276e-02f, -4.33706313e-01f,
  -1.33535135e+00f, 9.58649591e-02f, -1.96572751e-01f, -9.05529261e-01f, -2.25380629e-01f, -1.37620360e-01f, 1.75601959e-01f, 2.16347098e-01f, -3.98016453e-01f, -3.45060885e-01f,
  9.26573500e-02f, 1.27653554e-01f, -1.08225815e-01f, 1.50902033e-01f, -3.31845373e-01f, -4.40469563e-01f, -7.92787075e-01f, -6.03914559e-01f, -1.51057877e-02f, 5.10809541e-01f,
  2.72337884e-01f, -3.18045795e-01f, -3.68059605e-01f, 8.16744640e-02f, 2.51681387e-01f, 4.62638065e-02f, -1.58978477e-01f, -1.63112089e-01f, -9.30092931e-02f, -5.95208108e-01f,
  3.92439276e-01f, -2.32880339e-01f, -4.04085629e-02f, -2.75185347e-01f, -5.71461879e-02f, 2.20401660e-02f, 8.33231434e-02f, -3.66924554e-02f, -3.97528335e-02f, -1.45936936e-01f,
  -2.16291040e-01f, 9.55092162e-02f, -1.93396941e-01f, 1.92809418e-01f, -4.60883901e-02f, 9.63221639e-02f, 6.92545101e-02f, -7.53124133e-02f, -1.07875496e-01f, 3.20960134e-01f,
  2.05490544e-01f, -1.44845188e-01f, -4.59312573e-02f, 6.80000335e-02f, 2.30662093e-01f, 3.18522640e-02f, 2.23409906e-01f, 3.25645149e-01f, -4.02543396e-02f, -7.18916208e-02f,
  7.23074004e-02f, 3.11345551e-02f, 1.95428178e-01f, 5.02591813e-03f, -1.28694415e-01f, 1.86631654e-03f, -6.33249506e-02f, 5.15812822e-03f, 1.48864850e-01f, 6.16345815e-02f,
  2.89148819e-02f, -1.04566962e-01f, -1.04978131e-02f, -3.81326191e-02f, 6.81280484e-03f, -5.06094508e-02f, -8.41602609e-02f, -2.61554159e-02f, -4.51652445e-02f, -9.30946544e-02f,
  -1.14369169e-01f, -9.72368568e-02f, -1.26521394e-01f, 1.80430919e-01f, -7.83830807e-02f, -6.82150126e-02f, -1.21549957e-01f, 1.62067726e-01f, 7.97427744e-02f, -3.88783291e-02f,
  1.45042524e-01f, -5.09212077e-01f, -1.09321974e-01f, 1.50925443e-01f, -4.49756049e-02f, -6.47920668e-02f, -1.66458502e-01f, -9.91955549e-02f, -6.45987466e-02f, 3.56841721e-02f,
  1.98016781e-03f, 4.01683524e-02f, -7.05002621e-02f, 2.02983946e-01f, -2.92683691e-02f, 2.09000826e-01f, -8.58460665e-02f, -1.26083151e-01f, -1.07172124e-01f, 9.58459601e-02f,
  -3.02875997e-04f, -8.06462690e-02f, -1.17361834e-02f, -5.56980632e-02f, 1.45513564e-01f, -8.56376812e-02f, 1.62155241e-01f, 2.41634980e-01f, -8.12750608e-02f, 4.43341546e-02f,
  1.40958703e+00f, 1.61420792e-01f, 3.23511869e-01f, 1.52936369e-01f, -1.90507904e-01f, -5.48641868e-02f, -1.10961847e-01f, -4.03978936e-02f, -5.69799319e-02f, 1.21069267e-01f,
  1.63324758e-01f, 2.25094810e-01f, 2.82646000e-01f, 2.54633307e-01f, 2.41390347e-01f, -1.95953712e-01f, -2.34787896e-01f, 3.87301564e-01f, 2.62342632e-01f, -1.30862936e-01f,
  -1.92205146e-01f, -2.02333584e-01f, 2.55715281e-01f, 5.32731153e-02f, -6.04482442e-02f, -1.94197223e-02f, -4.89561446e-02f, -1.88585594e-01f, -6.63628206e-02f, -8.29503760e-02f,
  3.60188514e-01f, 4.62815046e-01f, 2.14520454e-01f, 2.90940534e-02f, 1.25814527e-01f, 8.55515599e-02f, 1.71457782e-01f, 1.74483415e-02f, -7.66324699e-02f, -1.42702267e-01f,
  6.72910959e-02f, 4.75911982e-02f, -4.87818755e-02f, -1.17171988e-01f, -1.34573817e-01f, -5.08403033e-02f, -1.06165305e-01f, -8.37281793e-02f, 2.03669374e-03f, 1.25468886e-02f,
  -1.59722224e-01f, -1.55297056e-01f, -2.52004284e-02f, 3.00911185e-03f, 1.45288795e-01f, 1.03774138e-01f, -3.11453603e-02f, 5.27896471e-02f, -3.59480432e-03f, -4.81672138e-02f,
  1.30113900e-01f, -3.46661881e-02f, 7.97465518e-02f, -1.25099063e-01f, 1.30898479e-04f, 4.11292585e-03f, -1.08083896e-01f, -2.46369056e-02f, 1.44752720e-02f, -3.46603952e-02f,
  -1.26492620e-01f, 5.74930459e-02f, 3.79354618e-02f, -2.86496393e-02f, 1.86026812e-01f, -8.93229023e-02f, 3.42373028e-02f, -6.30028695e-02f, 2.73021758e-02f, 4.34953719e-02f,
  -8.88108760e-02f, -4.55307923e-02f, 2.77660340e-02f, -8.43514875e-03f, 9.19087324e-03f, -5.16746230e-02f, -8.73859599e-02f, -6.59042746e-02f, -1.25282511e-01f, -2.31985319e-02f,
  -2.92254806e-01f, 2.95004666e-01f, 1.64237857e-01f, 1.32844001e-01f, 1.27299028e-02f, 1.08136453e-01f, 1.21147528e-01f, -1.08851999e-01f, -7.17945173e-02f, -2.24894471e-02f,
  -1.06406100e-01f, 5.89363351e-02f, -4.31307685e-03f, -9.76952910e-02f, -7.76718231e-03f, -9.04628709e-02f, 9.64693353e-03f, 1.48929372e-01f, -9.34011117e-03f, -7.84101337e-02f,
  -1.15182377e-01f, 2.57444624e-02f, 8.25826898e-02f, 1.31634578e-01f, -3.65003236e-02f, 9.09427628e-02f, -6.07470684e-02f, 1.97234917e-02f, 2.63728071e-02f, -2.44525880e-01f,
  -4.34838444e-01f, 5.53428948e-01f, 2.99170554e-01f, -1.24582686e-01f, 2.99769610e-01f, 3.20103168e-01f, 6.87482715e-01f, 6.39282390e-02f, -3.30264062e-01f, 2.10935250e-01f,
  1.44581392e-01f, -3.80682886e-01f, -9.39423293e-02f, -1.26335934e-01f, 4.40691151e-02f, 3.87942731e-01f, 1.75411001e-01f, -6.05437607e-02f, -3.84972692e-01f, -2.66661584e-01f,
  -9.48832408e-02f, -2.97654774e-02f, -4.15457398e-01f, -2.96435475e-01f, 3.58906724e-02f, -3.98904741e-01f, 2.16924459e-01f, 2.24437952e-01f, 1.15666203e-01f, 1.45603633e-02f,
  1.43087700e-01f, 3.44625235e-01f, -3.65141600e-01f, -1.15193695e-01f, 1.46442339e-01f, -1.87673736e-02f, 4.58505303e-02f, -1.02580667e-01f, 5.08921035e-02f, -1.59850210e-01f,
  1.87398657e-01f, 1.42502919e-01f, 1.82694495e-01f, 9.99131501e-02f, -9.03844535e-02f, 1.86254289e-02f, 4.73073348e-02f, 4.67228442e-02f, -2.26668343e-02f, -4.40095253e-02f,
  9.45975333e-02f, 5.84910363e-02f, 1.69819370e-01f, 9.21337306e-02f, 2.88258076e-01f, -1.55629590e-01f, 8.29758495e-02f, -6.98856562e-02f, 6.56542704e-02f, -1.67029366e-01f,
  -1.23879582e-01f, 6.40456900e-02f, 2.09606633e-01f, -1.68867968e-02f, 2.67366134e-02f, -5.61387315e-02f, 2.30531171e-02f, -1.29917273e-02f, 2.50893403e-02f, -6.21994771e-02f,
  -3.38686109e-02f, -1.42732710e-02f, 9.90659837e-03f, -1.63266417e-02f, -1.61732078e-01f, 3.59876305e-02f, 1.24279007e-01f, -5.97821956e-04f, 7.83004239e-02f, 7.12625533e-02f,
  1.54522015e-02f, 4.39265221e-02f, 1.16312481e-01f, 7.32401162e-02f, 4.34973789e-03f, -2.76577882e-02f, -9.22979489e-02f, 6.46579731e-03f, -1.34450616e-02f, 4.96617220e-02f,
  -1.72277808e-01f, 1.52413025e-01f, -2.97524124e-01f, -1.45002812e-01f, 1.48632318e-01f, -1.04442134e-01f, -6.21130653e-02f, -4.93021160e-02f, -8.07768374e-04f, -1.90279439e-01f,
  6.59935027e-02f, -2.12246962e-02f, 7.90183470e-02f, -5.16225472e-02f, -2.37142116e-01f, 7.16475863e-03f, 1.02219075e-01f, 4.47440296e-02f, 1.09009519e-01f, -9.47919190e-02f,
  5.97181788e-04f, -2.98047841e-01f, -3.87673944e-01f, -9.41562355e-02f, -2.09017500e-01f, -3.72876555e-01f, -1.16955623e-01f, -2.14904308e-01f, 3.32860500e-02f, -1.85931966e-01f,
  2.91534603e-01f, -2.57312745e-01f, 1.89771220e-01f, 3.41099769e-01f, -1.41867071e-01f, -5.34860075e-01f, -6.91675961e-01f, -3.80330771e-01f, 1.48709770e-02f, -1.77432760e-03f,
  -4.17182595e-02f, 3.96355569e-01f, 2.00105757e-01f, 2.16052219e-01f, -1.17563203e-01f, 9.32223499e-02f, 3.38686764e-01f, 5.47487557e-01f, 1.79349512e-01f, -2.64867581e-02f,
  2.51311094e-01f, 2.97479838e-01f, 3.58920515e-01f, 1.07334778e-01f, 3.43661189e-01f, 2.33915687e-01f, 6.93599209e-02f, 1.34116918e-01f, 1.96425095e-01f, 8.64952803e-01f,
  2.19456106e-01f, -1.84065271e-02f, 1.85813949e-01f, 2.25249976e-01f, 1.67251766e-01f, -2.35682372e-02f, -1.26939401e-01f, 1.18068330e-01f, -7.48495311e-02f, -3.90142798e-02f,
  8.85363370e-02f, 6.08562976e-02f, 3.44799384e-02f, 1.28105348e-02f, -1.67342290e-01f, -1.07986771e-01f, 1.23712935e-01f, -1.83409695e-02f, 7.43208593e-03f, -1.96886182e-01f,
  2.18794584e-01f, 1.21802725e-01f, -1.98494881e-01f, -2.62958884e-01f, -1.77487120e-01f, 2.86939889e-01f, -8.82771388e-02f, 1.39972255e-01f, -5.80304451e-02f, 1.26338616e-01f,
  -3.57482024e-02f, 6.72857612e-02f, 1.43809259e-01f, 2.59595923e-02f, 1.36684552e-01f, -9.74952593e-04f, 7.56537691e-02f, -5.66619337e-02f, 1.76130190e-01f, 5.38775101e-02f,
  -6.31846562e-02f, 3.24755087e-02f, -3.29602100e-02f, -1.22483671e-01f, 9.04120356e-02f, -3.02252918e-02f, -1.47448763e-01f, -2.38962378e-02f, 2.24881023e-02f, -6.24940097e-02f,
  9.58309323e-02f, -5.13390675e-02f, 1.11730568e-01f, 3.07952389e-02f, 6.12744540e-02f, 1.02266327e-01f, 1.06412336e-01f, -7.35948374e-03f, 1.38264270e-02f, -2.30444819e-02f,
  -4.86908883e-01f, 4.64441031e-02f, 2.25008905e-01f, 4.09919163e-03f, 4.04565111e-02f, -7.80520961e-02f, 1.63499266e-01f, 7.42810443e-02f, -3.33064087e-02f, -1.37709126e-01f,
  -1.06076963e-01f, 2.56083626e-02f, -7.75733292e-02f, 5.09454645e-02f, -8.19045380e-02f, -7.38512278e-02f, 3.61364409e-02f, -8.93284455e-02f, -5.87227456e-02f, -1.96182728e-01f,
  -1.26768172e-01f, -2.89842963e-01f, -3.42251390e-01f, -2.17994958e-01f, -7.20447078e-02f, -4.08623330e-02f, -4.68297414e-02f, -1.11315601e-01f, -2.41961360e-01f, -3.42030406e-01f,
  5.86728379e-02f, -8.18435624e-02f, 1.15556866e-01f, 8.19745660e-02f, 6.31451666e-01f, 9.23149958e-02f, -6.26166999e-01f, -3.03457677e-01f, 3.36680412e-01f, -3.05329077e-02f,
  4.40515041e-01f, 3.09944421e-01f, -5.45429699e-02f, -9.42211822e-02f, -7.75282502e-01f, -7.10883498e-01f, -4.38259721e-01f, -7.94692218e-01f, -7.78383851e-01f, -2.34985977e-01f,
  -1.04488909e-01f, -2.87681639e-01f, -5.02439201e-01f, -6.25183582e-02f, 3.93039525e-01f, 6.74513802e-02f, 3.46439183e-01f, 3.72414082e-01f, 2.08481804e-01f, 3.04540187e-01f,
  -6.39011711e-02f, 3.99135739e-01f, 8.56760144e-02f, 2.52147734e-01f, 2.31732622e-01f, -1.24258295e-01f, -1.61286905e-01f, -4.83782031e-02f, 1.00383967e-01f, -1.43203884e-01f,
  3.73084217e-01f, 1.20495357e-01f, -1.66923385e-02f, 1.28275260e-01f, -8.72111171e-02f, -1.88457713e-01f, -1.25345141e-01f, -3.02940279e-01f, -1.78941205e-01f, -1.64479297e-02f,
  1.34592786e-01f, 1.53135508e-01f, -1.84552390e-02f, 9.95459184e-02f, -2.08593145e-01f, -1.06161498e-01f, 1.61987841e-01f, 1.20996416e-01f, 3.70127186e-02f, 3.11682019e-02f,
  -6.27197996e-02f, 2.75188740e-02f, 1.35363251e-01f, 8.14561099e-02f, -1.98043525e-01f, 7.90869519e-02f, 4.33216915e-02f, -1.28798246e-01f, -6.98511526e-02f, -5.22165420e-03f,
  -1.04721926e-01f, 1.16522111e-01f, -4.05558422e-02f, -4.34070304e-02f, -5.33910189e-03f, 1.01865977e-01f, 1.25609815e-01f, -2.21823201e-01f, -5.64631522e-02f, 8.02849531e-02f,
  -1.14958189e-01f, 1.50699556e-01f, 1.50203601e-01f, -4.44256887e-02f, 4.37133089e-02f, 4.81412373e-02f, 7.51877725e-02f, 9.83428583e-03f, -7.13827014e-02f, 9.77992564e-02f,
  -1.98090404e-01f, 1.45705387e-01f, -8.79974738e-02f, -1.21823318e-01f, -3.68675590e-02f, 1.11497276e-01f, 2.89409846e-01f, -1.15543462e-01f, 2.79020220e-01f, -1.61415100e-01f,
  -2.09381264e-02f, -2.16994569e-01f, 1.27131820e-01f, -2.97757797e-03f, -2.35694185e-01f, 1.16496705e-01f, -1.56272799e-02f, 1.24065857e-02f, 2.91233789e-02f, 2.00365722e-01f,
  -1.13461278e-01f, -4.03604537e-01f, -3.97300512e-01f, -1.50515452e-01f, 1.62305191e-01f, -1.08663671e-01f, -2.68216610e-01f, -2.00345173e-01f, -2.90845871e-01f, -6.88795030e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  -1.56535432e-02f, 1.12657413e-01f, 2.78703511e-01f, 3.30451310e-01f, 2.12273300e-01f, 2.87187964e-01f, 5.23693025e-01f, 1.06802536e-02f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.38436913e-01f, -5.10244146e-02f, -3.07410181e-01f, 6.36601225e-02f, -1.89124823e-01f, 1.45740107e-01f, 5.65028116e-02f, -8.74791816e-02f, -2.01999635e-01f, -3.31965610e-02f,
  -2.95354664e-01f, -1.75619975e-01f, -4.00869995e-01f, 1.61913544e-01f, 2.73211569e-01f, 8.83738995e-02f, 8.99110436e-02f, -5.61031699e-01f, -1.23045444e-01f, 6.27964064e-02f,
  -2.44876325e-01f, -1.86321959e-01f, 1.51440054e-01f, -2.77559329e-02f, 5.07126451e-01f, 2.08397239e-01f, 2.58830547e-01f, -2.07016468e-02f, 2.41289765e-01f, 2.27491066e-01f,
  -4.71510470e-01f, -3.23690265e-01f, -1.33143649e-01f, -2.39789233e-01f, -6.22715475e-03f, -4.21591140e-02f, 1.34792432e-01f, 1.18447512e-01f, -1.24080464e-01f, -7.08907610e-03f,
  -1.80654824e-01f, 1.72778219e-02f, -1.38604656e-01f, -9.37819332e-02f, 2.68453360e-01f, 1.87188506e-01f, 3.61406952e-01f, 1.23702176e-01f, 2.55955514e-02f, -1.87824458e-01f,
  -6.13878341e-03f, -1.26584321e-01f, 6.37922823e-01f, 3.07193577e-01f, -1.16279870e-01f, -6.75235838e-02f, 3.49846901e-03f, -2.39366099e-01f, -6.26263082e-01f, 2.18443260e-01f,
  -1.05584599e-01f, 3.29769045e-01f, 8.06726865e-04f, 3.19189310e-01f, -1.10132866e-01f, 2.66591960e-04f, -1.07326306e-01f, 4.63515446e-02f, -6.54310733e-02f, -3.95929813e-01f,
  -1.31594792e-01f, 3.89081277e-02f, -1.37448594e-01f, -1.08096264e-01f, 9.20526460e-02f, -2.52705306e-01f, 1.74887002e-01f, -3.21390480e-02f, 1.22012340e-01f, -8.92149284e-02f,
  -3.36940944e-01f, 7.47809978e-03f, -1.00930303e-01f, 2.30550870e-01f, 1.64275706e-01f, 2.65580118e-01f, -1.28005221e-01f, -2.82070152e-02f, 2.07873240e-01f, -2.66900539e-01f,
  -2.81465948e-01f, -2.08872899e-01f, -1.93974614e-01f, 5.13322711e-01f, 3.28346789e-01f, 5.07554352e-01f, -1.09753199e-03f, 9.61780101e-02f, -7.95454457e-02f, -6.32368773e-02f,
  -8.65082219e-02f, 1.54189065e-01f, 2.91266013e-02f, -1.01278476e-01f, -6.78916723e-02f, -2.06344888e-01f, -6.62229806e-02f, -2.71348702e-03f, 5.61545379e-02f, 5.12734875e-02f,
  -1.45281792e-01f, 1.13637619e-01f, 1.39618352e-01f, 2.20394917e-02f, 1.00133024e-01f, -2.97788799e-01f, -1.02129579e-01f, -5.31629547e-02f, 1.28377005e-01f, -3.33261400e-01f,
  -7.28676915e-02f, -2.06289366e-01f, 5.52010655e-01f, -1.63350791e-01f, -2.83788472e-01f, -2.24742144e-01f, -1.03174582e-01f, 4.62215513e-01f, -5.19593805e-02f, 2.55075451e-02f,
  2.78658330e-01f, 1.29432837e-02f, 1.72211751e-01f, 1.41176566e-01f, -4.92754430e-02f, -1.94404840e-01f, 1.23244599e-01f, 4.09812406e-02f, -4.49700356e-02f, 1.39673710e-01f,
  -4.29694839e-02f, 2.84515582e-02f, 5.14267385e-03f, -1.58659499e-02f, -3.53157483e-02f, 2.62211472e-01f, -4.80431356e-02f, -8.92650038e-02f, 5.68199754e-02f, -1.36896148e-01f,
  -3.06212734e-02f, -2.92233601e-02f, -1.52282817e-02f, -9.57985893e-02f, -2.80588865e-01f, -2.95402724e-02f, -2.34012693e-01f, 6.73253834e-01f, -1.18523531e-01f, -2.05156252e-01f,
  5.48859499e-02f, 2.02752978e-01f, -1.35598883e-01f, -6.75542420e-03f, -1.45750493e-01f, 2.52846539e-01f, 5.88749275e-02f, -3.51738371e-02f, -2.98498333e-01f, 1.37116104e-01f,
  -4.49493639e-02f, 1.07563585e-01f, -3.40626091e-01f, 1.30179629e-01f, -2.20874801e-01f, 2.10049495e-01f, 2.93428063e-01f, -1.64740473e-01f, -5.56133538e-02f, -2.64335632e-01f,
  -4.02566105e-01f, -1.75789684e-01f, 2.48067498e-01f, 3.32397930e-02f, -1.07151978e-01f, -1.15454674e-01f, 2.46149618e-02f, 2.33406842e-01f, -1.23329975e-01f, -6.44111261e-02f,
  -1.97009504e-01f, 3.81524175e-01f, 1.53984308e-01f, 2.96955761e-02f, -1.38617381e-01f, 3.04864943e-02f, -1.30933985e-01f, -2.13894863e-02f, -8.54323506e-02f, -2.39094030e-02f,
  -4.35820997e-01f, 1.36376500e-01f, -1.61121100e-01f, -1.21310517e-01f, -2.01552004e-01f, 2.99280286e-01f, -8.88766255e-04f, 1.85356900e-01f, 2.96519399e-01f, -6.28992677e-01f,
  -2.22688913e-01f, -1.86591104e-01f, 1.10847754e-02f, -2.76611030e-01f, 3.79741639e-01f, -2.92025618e-02f, -4.30668771e-01f, 3.49003226e-02f, 7.00058043e-02f, 1.95048749e-01f,
  1.01669155e-01f, -1.36273831e-01f, -1.15929112e-01f, 3.29432696e-01f, -2.23056935e-02f, 9.73558053e-02f, 1.62575021e-02f, 1.61714256e-02f, 9.42082852e-02f, 1.41971121e-02f,
  2.54895147e-02f, 5.55334287e-03f, 1.32891938e-01f, 5.75754344e-02f, 1.47274926e-01f, 1.86698943e-01f, 1.40021294e-01f, -4.91367728e-02f, -8.77437517e-02f, 1.34622715e-02f,
  -3.01658846e-02f, 2.54565060e-01f, 1.19319163e-01f, -4.99263080e-03f, 3.49339135e-02f, 3.18967812e-02f, -1.81445241e-01f, -6.23662723e-03f, 2.18747437e-01f, 1.56189412e-01f,
  -4.66758400e-01f, 1.02237716e-01f, -1.64228067e-01f, 4.73269016e-01f, -3.79095435e-01f, -7.06429407e-02f, 8.98403078e-02f, -1.81617782e-01f, -1.89441338e-01f, 3.38604972e-02f,
  -5.15335649e-02f, -7.47079104e-02f, 9.79914144e-03f, -4.41169553e-02f, 1.75126404e-01f, 2.38920808e-01f, 6.23691678e-02f, 7.09497705e-02f, 9.17885974e-02f, -1.95518509e-01f,
  1.17724419e-01f, 2.26059966e-02f, 3.07115585e-01f, 3.83414738e-02f, 6.54691979e-02f, -8.95583779e-02f, -3.39329749e-01f, 1.44647256e-01f, -5.33776060e-02f, 6.90557510e-02f,
  -2.15384215e-01f, -3.48641634e-01f, 5.53417802e-01f, 1.95783734e-01f, -1.29299149e-01f, 3.82711053e-01f, 1.21863950e-02f, -3.83930951e-01f, -3.31130214e-02f, -1.72661021e-01f,
  -2.52651274e-01f, 1.29947647e-01f, -7.43697658e-02f, -6.97586164e-02f, -5.36946617e-02f, 7.42241275e-03f, -2.66307652e-01f, -4.31803204e-02f, -9.53885987e-02f, -8.59507620e-02f,
  -2.12128818e-01f, 6.85689822e-02f, 4.04373854e-02f, 1.06429532e-02f, -1.55949086e-01f, -2.49466628e-01f, 8.96796659e-02f, 2.82286197e-01f, 1.48500249e-01f, 8.74435380e-02f,
  -9.00788698e-03f, -1.35861158e-01f, 3.83061767e-01f, 3.39484990e-01f, -1.96328253e-01f, -3.36211860e-01f, -1.83856860e-02f, 4.86612171e-01f, 1.52510390e-01f, -2.48415254e-05f,
  -8.03497806e-02f, 1.40357271e-01f, 1.05464915e-02f, -2.79892515e-02f, -2.59524174e-02f, 1.07129052e-01f, -1.51725352e-01f, -2.90462941e-01f, 1.45532161e-01f, -6.28913939e-02f,
  1.44117042e-01f, 2.32699543e-01f, 1.20299280e-01f, -1.24522662e-02f, -3.10912371e-01f, 4.94225323e-02f, -3.99721712e-02f, 4.30308700e-01f, 9.92829129e-02f, -7.88915679e-02f,
  1.91366702e-01f, -2.02488512e-01f, -2.23977957e-02f, 8.36865103e-04f, -1.42838523e-01f, 5.56672402e-02f, -1.46661177e-01f, -1.96685642e-01f, 1.84014156e-01f, 1.68284565e-01f,
  -3.11058939e-01f, -1.88550189e-01f, 6.32420257e-02f, -2.26741284e-02f, -9.22171548e-02f, 8.18737224e-02f, -2.37377778e-01f, -1.42013311e-01f, -1.69348240e-01f, -9.22481567e-02f,
  1.55177396e-02f, -2.35571995e-01f, -1.51008248e-01f, -3.77101332e-01f, -1.98430702e-01f, -1.71518270e-02f, 2.03841537e-01f, -7.96454027e-02f, -2.19699696e-01f, 9.95432884e-02f,
  -1.67485148e-01f, 6.52015582e-02f, -6.50953293e-01f, 6.62003085e-02f, 3.29299048e-02f, 2.63090670e-01f, 1.21864699e-01f, 1.16065592e-01f, 2.42438540e-01f, -2.12497450e-02f,
  -1.46062151e-01f, 2.48811692e-01f, -2.94062495e-01f, 1.32666826e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.28969133e-01f, 5.87343633e-01f, 4.63858575e-01f, 4.37036216e-01f, 2.87710547e-01f, 1.80522427e-02f, -2.89621562e-01f, 1.46586806e-01f, 1.84942171e-01f, -3.92358035e-01f,
  3.23261321e-01f, -1.32182121e-01f, 1.73566192e-01f, -2.00048894e-01f, -5.60765743e-01f, 2.61087418e-01f, -2.04071864e-01f, 4.10097139e-03f, -2.79012829e-01f, -1.17672212e-01f,
  9.18545902e-01f, 3.37150306e-01f, 2.42306933e-01f, 7.58602843e-02f, -9.79791641e-01f, 1.71163872e-01f, -3.58931988e-01f, 4.40801442e-01f, -2.63565421e-01f, -1.60313085e-01f,
  2.23243888e-02f, 1.06906402e+00f, 1.30008429e-01f, 1.92795843e-01f, 1.58485085e-01f, 2.26362329e-02f, 7.17771128e-02f, 3.23975235e-01f, 2.56003201e-01f, -1.88537568e-01f,
  1.00718118e-01f, -2.82759935e-01f, -8.17406625e-02f, 1.87269077e-01f, -4.54756141e-01f, 3.46894711e-01f, -3.38417828e-01f, 2.15502918e-01f, -1.28293529e-01f, 5.70739508e-01f,
  -1.61634520e-01f, -2.03701079e-01f, -5.22931218e-01f, -5.53544521e-01f, 3.90784949e-01f, 4.62008178e-01f, 9.52977836e-01f, 5.56792319e-01f, 4.26169276e-01f, 4.12300140e-01f,
  -1.26675487e-01f, -1.68950796e-01f, 2.24625885e-01f, -6.90703511e-01f, 3.04275632e-01f, 4.99891669e-01f, 1.54850319e-01f, 2.41493195e-01f, 2.49390230e-01f, 1.66752502e-01f,
  -2.20570147e-01f, -2.33906910e-01f, 4.04223263e-01f, 3.89848262e-01f, 3.81578088e-01f, 2.80443698e-01f, 4.74082947e-01f, -4.25373346e-01f, -5.04188180e-01f, 4.11661148e-01f,
  3.82188588e-01f, 3.67503136e-01f, 7.49794766e-02f, -3.00383300e-01f, -5.88748217e-01f, -5.99330477e-02f, 1.04959525e-01f, -2.95338035e-01f, -1.01038158e+00f, -5.09402230e-02f,
  7.06123590e-01f, -2.42425315e-02f, 4.02510464e-01f, -7.21256807e-02f, 9.71086442e-01f, 5.75161457e-01f, -1.25639379e-01f, 3.32385331e-01f, 4.27256972e-01f, 3.29042882e-01f,
  5.51107347e-01f, -1.78607449e-01f, 1.56825364e-01f, 9.99239758e-02f, 4.32500452e-01f, 1.12108380e-01f, 6.15464926e-01f, 5.90292625e-02f, 1.03270356e-02f, 4.57819223e-01f,
  -4.38837647e-01f, 2.38580674e-01f, -4.16984648e-01f, 4.73959625e-01f, -3.16875726e-01f, -4.44317669e-01f, 6.29717767e-01f, -7.81131536e-02f, 9.98841301e-02f, 2.01499090e-01f,
  1.40064907e+00f, 2.02978849e-01f, -4.29378390e-01f, 1.02995753e+00f, -6.30017877e-01f, -1.25173733e-01f, -1.11267537e-01f, 1.15501273e+00f, 2.84259468e-01f, 5.24051130e-01f,
  3.58349860e-01f, 3.04851800e-01f, 9.70278144e-01f, -1.64030176e-02f, 5.04114091e-01f, 5.89728177e-01f, 5.97949803e-01f, 8.62429678e-01f, 7.49951780e-01f, 1.07003497e-02f,
  3.38581324e-01f, 2.23086029e-01f, -1.44186646e-01f, 3.36640805e-01f, 7.90436089e-01f, -3.21639657e-01f, 1.59633365e-02f, -8.05077970e-01f, -5.09059690e-02f, -1.94484398e-01f,
  1.67735010e-01f, -8.07434171e-02f, 6.97091281e-01f, -5.77834249e-01f, 4.44389969e-01f, 8.84450018e-01f, -6.89558685e-01f, -4.59261805e-01f, 1.80525303e-01f, 2.79774368e-01f,
  2.61312276e-01f, 3.71126711e-01f, 5.82448728e-02f, 2.04034716e-01f, 1.72813237e-01f, 2.55878806e-01f, 5.00965118e-01f, 2.51654118e-01f, 8.51257622e-01f, -2.75127888e-01f,
  3.00703317e-01f, 2.15891227e-01f, -3.11458558e-01f, -5.01895905e-01f, 4.33273435e-01f, -1.60369590e-01f, -4.27944005e-01f, 1.03396237e+00f, -1.40611887e-01f, 1.66802824e-01f,
  -9.64439750e-01f, 2.88586974e-01f, -4.24369097e-01f, 6.61691666e-01f, -7.19066501e-01f, -2.74050415e-01f, -4.44964737e-01f, -2.43144765e-01f, 1.42744660e-01f, 8.35730553e-01f,
  1.54405786e-02f, -1.26575176e-02f, 1.59783870e-01f, 4.74500477e-01f, 3.19367081e-01f, 1.81480289e-01f, -9.93409306e-02f, 3.21974486e-01f, 6.02548003e-01f, 4.51069713e-01f,
  3.10164303e-01f, 3.60654965e-02f, 1.59949332e-01f, 8.79186094e-02f, -5.48529267e-01f, 4.12935853e-01f, -2.42703512e-01f, 1.12221457e-01f, 3.14299613e-01f, -2.23736182e-01f,
  -1.51098192e-01f, -1.03246853e-01f, -4.43057120e-01f, -8.86958599e-01f, 4.65289176e-01f, 2.71762848e-01f, -4.49830145e-01f, -4.40219697e-03f, 9.56002951e-01f, 3.73008698e-01f,
  -8.40727091e-02f, -9.67675090e-01f, 5.56577295e-02f, -6.35737896e-01f, 1.01559512e-01f, 2.26337448e-01f, 3.14007193e-01f, -6.11737184e-03f, 2.50819057e-01f, 2.95345545e-01f,
  7.19372034e-02f, -1.07199781e-01f, 4.90806222e-01f, 5.65997474e-02f, 3.36324751e-01f, 2.97827393e-01f, 5.00647306e-01f, -3.38207990e-01f, -3.94395500e-01f, -2.45574459e-01f,
  1.05002865e-01f, -7.83265978e-02f, 3.26126277e-01f, 2.54228830e-01f, 3.03684294e-01f, 1.82664707e-01f, -1.79143056e-01f, -1.73956975e-01f, 1.45194137e+00f, 9.66194123e-02f,
  9.80464816e-01f, -2.64858961e-01f, 1.83187164e-02f, -5.61230443e-02f, 1.05484915e+00f, -4.21081305e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.73569286e-01f, 1.35300279e-01f, 4.73088443e-01f, 4.63245481e-01f, 2.76411653e-01f, 4.63401586e-01f, 2.76850373e-01f, 4.92286906e-02f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -1.60112634e-01f, -9.34867188e-02f, -6.24226630e-02f, -5.93415618e-01f, -1.01080573e+00f, -7.88461149e-01f, -2.97822416e-01f, -6.31754339e-01f, -3.92761469e-01f, 2.18503118e-01f,
  -8.53686571e-01f, -6.60729289e-01f, 3.81588489e-01f, -6.48219228e-01f, -2.79613048e-01f, 1.41836256e-01f, 1.94359366e-02f, -2.91444242e-01f, 1.88256443e-01f, -7.95475841e-01f,
  -4.58826050e-02f, -1.80938989e-01f, 1.07587934e-01f, 2.85546213e-01f, -4.32779908e-01f, -2.25633919e-01f, -4.13637012e-02f, 2.06475571e-01f, 3.83461207e-01f, 7.85867125e-02f,
  3.54715049e-01f, -2.40337700e-01f, -6.06687330e-02f, -8.26707661e-01f, -7.14573562e-01f, -7.96406865e-01f, 1.26092523e-01f, -2.70011663e-01f, -1.08023897e-01f, -3.89758259e-01f,
  -2.58638054e-01f, -4.27338690e-01f, 7.08088875e-01f, 1.78739965e-01f, 7.40957737e-01f, -8.26355293e-02f, -2.44696051e-01f, 1.83409572e-01f, -4.26626325e-01f, 7.25387037e-01f,
  5.08245170e-01f, -4.89262193e-01f, 2.16149502e-02f, -3.60619247e-01f, 5.20179808e-01f, 1.39165372e-01f, -1.03005421e+00f, 3.39556187e-01f, 4.96678472e-01f, -1.23654175e+00f,
  -3.75965923e-01f, -2.46938899e-01f, 3.54345411e-01f, 1.44058332e-01f, 2.22386703e-01f, 1.51888728e-01f, 3.46765965e-01f, 2.33374402e-01f, -5.01652062e-01f, 2.54364461e-01f,
  1.26667723e-01f, -5.90856433e-01f, -3.22015852e-01f, 4.37312156e-01f, -8.67472470e-01f, 1.94490422e-02f, -2.66368270e-01f, -4.01203305e-01f, -4.67015862e-01f, 6.56178832e-01f,
  -7.02812314e-01f, -6.60744011e-01f, 9.98363793e-02f, -5.55837870e-01f, 4.45676774e-01f, -3.05292696e-01f, -5.36216319e-01f, -7.14758158e-01f, -1.52051866e+00f, -9.45431352e-01f,
  2.21240476e-01f, -1.40085220e+00f, 5.05419970e-01f, -2.23515764e-01f, 2.36510798e-01f, 3.77229095e-01f, -4.33870792e-01f, 4.46939580e-02f, 1.86651587e-01f, 6.59872591e-01f,
  3.70878160e-01f, 2.75698900e-01f, 3.97094071e-01f, -6.02120578e-01f, -2.11914822e-01f, 5.13166487e-02f, -7.34191537e-01f, -2.49933273e-01f, 5.72978377e-01f, 5.61787896e-02f,
  3.43933880e-01f, 2.23150328e-01f, -1.13567993e-01f, 5.23154438e-01f, -1.73452213e-01f, 9.31036949e-01f, 7.26367533e-01f, 1.28867543e+00f, -3.66175324e-01f, 8.42630804e-01f,
  -6.03194714e-01f, 1.11501172e-01f, -1.60911131e+00f, 4.52564597e-01f, 6.08273387e-01f, -7.01027751e-01f, -8.74022841e-01f, -1.14348263e-01f, 4.73855138e-01f, -2.77224422e-01f,
  8.48884344e-01f, -1.11009240e-01f, -1.01617396e-01f, -1.59992188e-01f, -2.47205198e-01f, 7.70989835e-01f, 6.42924726e-01f, 7.06174150e-02f, -3.41153890e-01f, 6.12726390e-01f,
  -6.50490701e-01f, 1.27661490e+00f, 6.36706114e-01f, 2.95819163e-01f, -2.15656161e-01f, 6.31690204e-01f, 5.44414937e-01f, 5.07902689e-02f, 3.36855650e-01f, -7.83558309e-01f,
  -6.82581961e-01f, 1.85073555e-01f, 6.64884925e-01f, -3.10678542e-01f, 1.97338581e-01f, 2.65122980e-01f, -2.03973036e-02f, -2.70712316e-01f, -4.71792430e-01f, -5.61718941e-01f,
  6.36327118e-02f, 2.89691925e-01f, 1.70370460e-01f, 6.49797618e-01f, 1.71212569e-01f, 4.56619501e-01f, 6.46411121e-01f, 8.16559553e-01f, 5.19772530e-01f, -5.55643797e-01f,
  4.38896298e-01f, 5.85095733e-02f, -9.59064245e-01f, -9.17143226e-01f, -8.16567719e-01f, 6.02300823e-01f, 2.37958565e-01f, 8.69523808e-02f, -2.79268891e-01f, 5.89483023e-01f,
  6.62870824e-01f, -7.46757984e-01f, 7.91900098e-01f, -8.59217465e-01f, -2.97092825e-01f, -9.30470750e-02f, 3.70033145e-01f, 5.44746555e-02f, 1.58868372e-01f, -1.45138800e-01f,
  7.46439863e-03f, -3.58133823e-01f, -3.99438977e-01f, 1.29958421e-01f, 5.84565878e-01f, -2.41360709e-01f, 5.68701327e-01f, -7.49440491e-01f, -9.85436201e-01f, 2.01419353e-01f,
  4.33592677e-01f, 4.81068790e-01f, 2.98910499e-01f, -1.13492534e-01f, -1.93939894e-01f, 6.38328314e-01f, 4.32662040e-01f, -8.05485547e-01f, -5.71456671e-01f, -2.87997395e-01f,
  2.00499251e-01f, -8.69256735e-01f, 2.52509385e-01f, 2.50832021e-01f, -3.08554351e-01f, -7.08641410e-01f, -7.36946404e-01f, -7.17291534e-01f, 1.03966974e-01f, -1.46701717e+00f,
  -8.27453494e-01f, 5.19931376e-01f, -3.09376448e-01f, 4.72538024e-01f, 2.84406953e-02f, 2.56040722e-01f, -4.19403493e-01f, -3.23124498e-01f, -3.73564601e-01f, -6.88405037e-01f,
  -4.74446207e-01f, 5.62353842e-02f, -7.02940762e-01f, -5.30033946e-01f, -2.42497131e-01f, 5.30484080e-01f, 8.96533877e-02f, -3.29623789e-01f, 3.18774879e-01f, -1.69105642e-02f,
  4.99429584e-01f, -3.29459161e-01f, 6.09015673e-02f, 1.01006687e+00f, -3.46842319e-01f, -1.16714403e-01f, 6.25312507e-01f, 4.88932952e-02f, -1.54433146e-01f, 3.92584443e-01f,
  -4.47341979e-01f, 2.49581650e-01f, -6.01180375e-01f, -7.44623184e-01f, -2.72119194e-01f, 5.14222145e-01f, 7.56092668e-02f, -7.75390208e-01f, 7.19852149e-01f, -6.75244629e-02f,
  3.65788221e-01f, 7.10346103e-02f, 3.92318130e-01f, -2.69697875e-01f, -5.56129634e-01f, 6.71655416e-01f, 3.38503957e-01f, 5.60897961e-03f, -3.57231677e-01f, -4.35350597e-01f,
  -5.42579830e-01f, -6.37112260e-01f, -1.65254727e-01f, -6.03250265e-01f, -7.16929615e-01f, 2.47692123e-01f, -9.73338783e-01f, 5.42796731e-01f, 4.16335791e-01f, 7.73715675e-01f,
  4.55467075e-01f, 4.42207754e-01f, -4.74652797e-01f, 4.78379071e-01f, -1.43241644e+00f, 3.24299663e-01f, 2.40540624e-01f, -4.81618196e-01f, -9.16143119e-01f, 3.32739323e-01f,
  -6.03632145e-02f, 2.48962954e-01f, 1.34390771e-01f, 8.73828590e-01f, 6.32033169e-01f, -4.86973643e-01f, 1.33764029e-01f, 2.81298786e-01f, 4.80035871e-01f, -4.44726259e-01f,
  2.16626227e-01f, 1.62743032e-01f, 5.33112466e-01f, 2.26364657e-01f, -6.90181553e-01f, 1.31608531e-01f, -8.20996284e-01f, -5.68947017e-01f, -8.41081977e-01f, 2.02101842e-01f,
  -3.93267483e-01f, -1.84528321e-01f, 9.91460800e-01f, -7.04297304e-01f, 3.16981852e-01f, -6.90264478e-02f, -4.24160630e-01f, -8.00893784e-01f, -7.58702934e-01f, 1.44192308e-01f,
  2.54967123e-01f, 2.57684559e-01f, -7.38910437e-01f, 4.70139086e-01f, 8.28934554e-03f, 6.63748384e-02f, -5.17477453e-01f, -8.56680125e-02f, 5.26025891e-02f, 1.29412085e-01f,
  1.79776356e-01f, -2.51010120e-01f, 3.56402993e-01f, 6.40125692e-01f, -3.40778381e-01f, -1.95918173e-01f, 8.41157973e-01f, 6.53759360e-01f, 5.95604002e-01f, 6.58101380e-01f,
  -5.33702254e-01f, -5.90482593e-01f, -2.73041457e-01f, -8.59099507e-01f, 9.27052349e-02f, 3.51472050e-01f, -1.52043164e+00f, 4.68600810e-01f, 1.10371806e-01f, -1.07042778e+00f,
  5.42384684e-01f, -1.47362757e+00f, 5.40883780e-01f, 5.83435357e-01f, -2.20317513e-01f, 1.67087633e-02f, 2.54309684e-01f, 6.90376043e-01f, 4.47990537e-01f, 8.72988068e-03f,
  4.82669473e-01f, -6.02583706e-01f, 2.70414293e-01f, 1.30893573e-01f, 4.15235668e-01f, 1.24852337e-01f, 1.02768850e+00f, -4.30772901e-01f, 1.18398082e+00f, -2.91711330e-01f,
  -5.75240433e-01f, 1.44689798e+00f, 6.09434605e-01f, 5.50218821e-01f, -6.54354319e-02f, 1.04899859e+00f, -2.56768376e-01f, -7.24456966e-01f, 1.34014323e-01f, -4.31394041e-01f,
  -4.25776333e-01f, 9.14551437e-01f, -8.70478928e-01f, -6.02138877e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.02700490e-01f, -4.92611416e-02f, -1.90424800e-01f, -1.78720027e-01f, 2.66278356e-01f, 3.77868116e-02f, -8.73401761e-02f, 2.68624604e-01f, -2.41288602e-01f, -2.95801573e-02f,
  -2.39730358e-01f, 1.26083091e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    