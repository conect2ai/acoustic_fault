/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.39954114e-02f, 1.91776901e-01f, 1.08309515e-01f, -1.51110023e-01f, -1.02491893e-01f, 5.89546598e-02f, 1.01514243e-01f, -8.88943374e-02f, 2.13141248e-01f, -6.77491771e-04f,
  -1.39875486e-01f, 7.65045285e-02f, 9.51627269e-02f, -7.04683587e-02f, -1.74642906e-01f, 1.17309466e-01f, -9.94329751e-02f, -1.26266144e-02f, 1.05511531e-01f, -9.92454588e-02f,
  -5.47412932e-02f, -1.81591406e-01f, -4.90048230e-02f, -6.48823520e-03f, -7.07738549e-02f, -8.37172493e-02f, -1.33062035e-01f, 7.33376201e-03f, -2.13015050e-01f, 3.22100036e-02f,
  4.50942107e-03f, 3.51592004e-02f, 3.16950157e-02f, -9.51487571e-03f, -5.04545644e-02f, 2.57228152e-03f, -2.37459783e-02f, -2.25301422e-02f, 4.69255447e-02f, 4.00338694e-02f,
  3.70533615e-02f, -4.59281392e-02f, 4.62328084e-03f, -4.30002436e-02f, -2.00376641e-02f, 4.22413871e-02f, 2.49291193e-02f, 1.60099138e-02f, 6.87137842e-02f, 3.08225416e-02f,
  4.59287167e-02f, 8.63591861e-03f, -8.41087252e-02f, -3.71850915e-02f, -3.19845267e-02f, 2.62445770e-02f, -8.60154722e-03f, -5.97184598e-02f, 7.89005309e-04f, -7.76253343e-02f,
  -8.07592720e-02f, 1.92584954e-02f, -2.89970171e-02f, 4.76946309e-02f, 3.95576062e-04f, -4.20378521e-02f, -2.18232051e-02f, -4.82934006e-02f, -2.60009076e-02f, -7.32394680e-02f,
  4.84301383e-03f, -4.96887928e-03f, 1.98345855e-02f, -7.79897794e-02f, -7.36106336e-02f, 3.46003622e-02f, 1.70863327e-02f, -4.00059447e-02f, -1.02956290e-03f, -2.09399723e-02f,
  -5.94904320e-03f, -9.45914984e-02f, -7.33891502e-02f, 1.55817429e-02f, 6.15654737e-02f, 7.83425290e-03f, -8.71617496e-02f, -1.40902176e-02f, 6.12208135e-02f, -3.91040668e-02f,
  3.69819929e-03f, -1.18217535e-01f, 1.36976847e-02f, 4.75019068e-02f, 2.97154859e-02f, -5.61035015e-02f, -3.04667652e-02f, -3.60224694e-02f, -6.40271306e-02f, -6.46864250e-03f,
  -7.80162290e-02f, 1.87629219e-02f, -8.10695961e-02f, -6.84906356e-03f, 2.04787925e-02f, 8.27859994e-03f, -4.53378446e-03f, 1.23441573e-02f, -9.53042582e-02f, -5.18762730e-02f,
  -7.41057321e-02f, 2.33093649e-02f, -2.67117564e-02f, -1.49272606e-02f, -3.26965679e-03f, -3.23915705e-02f, -7.59789497e-02f, -1.27338925e-02f, -2.27355864e-02f, 6.46762401e-02f,
  7.37002492e-02f, -1.29919752e-01f, 3.40262502e-02f, 2.33019561e-01f, -2.02242151e-01f, -1.06016353e-01f, 1.61019176e-01f, -1.42119959e-01f, 1.69298083e-01f, -1.54978767e-01f,
  -4.77912128e-02f, 1.56340405e-01f, 7.62785599e-02f, 1.98537037e-02f, 3.08700532e-01f, 2.29618371e-01f, 1.72706470e-01f, 1.43877730e-01f, 8.73500407e-02f, -5.26048876e-02f,
  2.48151049e-02f, -4.39503929e-03f, 8.07854012e-02f, -1.41232416e-01f, -2.04752296e-01f, -7.76670873e-02f, -3.02148517e-02f, -5.64345233e-02f, -1.80026054e-01f, 4.54390794e-03f,
  1.05164796e-01f, 8.48049019e-03f, -5.88361993e-02f, 8.97464976e-02f, -4.63471860e-02f, -5.56412376e-02f, 7.43283145e-03f, 4.39304039e-02f, 7.83755928e-02f, 1.91865640e-03f,
  1.01937972e-01f, -3.65278460e-02f, -5.87257463e-03f, -3.44283022e-02f, -5.30373342e-02f, -4.37173843e-02f, -8.33641738e-02f, -1.09808445e-01f, 3.99677753e-02f, -4.32531647e-02f,
  7.31334612e-02f, 2.10806690e-02f, 6.48226812e-02f, 5.38022444e-02f, -1.58820767e-03f, 6.07083142e-02f, 5.49983196e-02f, 2.79453490e-02f, 6.89737080e-03f, -4.07869592e-02f,
  -4.34801280e-02f, -3.33072394e-02f, 8.57897922e-02f, -8.88507289e-04f, 4.51485477e-02f, -9.78849605e-02f, 4.19476628e-02f, -5.01535041e-03f, 2.83466838e-02f, -4.52626124e-02f,
  3.91379781e-02f, 2.48197094e-03f, -1.30580459e-02f, -6.23567812e-02f, -7.10766912e-02f, -5.88102825e-03f, 4.05299664e-02f, -7.11041456e-03f, 2.44001355e-02f, -7.41150454e-02f,
  2.36432347e-03f, 1.83050539e-02f, -4.80601378e-02f, -1.62894502e-02f, 3.56697515e-02f, -2.05670595e-02f, -5.61665976e-03f, -1.38430288e-02f, 5.53607345e-02f, 3.59788537e-03f,
  4.91551822e-03f, -6.92234486e-02f, -3.51294987e-02f, 7.41443504e-03f, 4.37645875e-02f, -1.70595217e-02f, 3.80944796e-02f, -5.84517457e-02f, -6.52587332e-04f, -4.33861837e-02f,
  -3.76269892e-02f, -3.20980251e-02f, -6.11300394e-02f, 5.40735982e-02f, -1.90318935e-02f, -3.38436291e-02f, 1.93517357e-02f, 7.69227445e-02f, -1.39199169e-02f, -4.76075597e-02f,
  -7.75223747e-02f, -8.51199850e-02f, -3.01930644e-02f, -7.08089173e-02f, -5.94845861e-02f, 3.56919803e-02f, -6.47841617e-02f, -6.42216951e-03f, -7.07454011e-02f, 9.56650898e-02f,
  -1.08986817e-01f, 9.37942639e-02f, 1.49235830e-01f, 3.22991282e-01f, -1.10536322e-01f, -3.53357894e-03f, 1.24774590e-01f, 1.21807188e-01f, 1.27528250e-01f, 1.17499389e-01f,
  -7.65325129e-02f, 1.05843402e-01f, 2.30793003e-02f, 2.58627266e-01f, -8.78183916e-02f, 8.42606649e-02f, 1.51015610e-01f, 4.00938988e-02f, 3.11169680e-02f, 2.62121949e-02f,
  1.38791674e-03f, -5.66855334e-02f, 1.72541216e-01f, -3.91269960e-02f, 6.22074679e-02f, -4.25508581e-02f, -9.44789648e-02f, -8.82594585e-02f, 2.93555111e-02f, -1.86649337e-02f,
  -7.29155391e-02f, 7.84469992e-02f, 1.06427066e-01f, 5.19737042e-02f, -3.66133824e-02f, -2.91179717e-02f, 2.81207114e-02f, -2.26717908e-02f, 1.61087178e-02f, -6.66128248e-02f,
  1.42494971e-02f, 4.98653278e-02f, 9.13279504e-02f, 1.76982991e-02f, 9.92654823e-03f, 5.96472025e-02f, -7.58436462e-03f, 8.30028132e-02f, 9.31293219e-02f, -6.71441853e-03f,
  1.56784818e-01f, 2.89403065e-03f, 1.12944059e-01f, 7.76617378e-02f, -3.84039409e-03f, 8.61666948e-02f, 4.97309528e-02f, -6.37419000e-02f, 8.78202356e-03f, -4.33527352e-03f,
  4.30362709e-02f, -1.59620773e-02f, -8.50005224e-02f, -6.13724366e-02f, -4.73379195e-02f, -1.20263938e-02f, 5.79657666e-02f, 2.31734174e-03f, -6.27710000e-02f, 2.36616842e-03f,
  2.37152502e-02f, -3.10639367e-02f, -2.47759260e-02f, 5.80384023e-02f, -1.73894409e-02f, 6.43078983e-03f, -2.99934251e-03f, 3.69733982e-02f, -3.75335217e-02f, 6.19909987e-02f,
  7.45085850e-02f, 1.77465789e-02f, -4.68845554e-02f, -7.25621404e-03f, 3.07482784e-03f, -4.90299501e-02f, -1.17083089e-02f, 8.29804018e-02f, -1.25426212e-02f, -4.96600755e-02f,
  -1.69815928e-01f, -1.51332140e-01f, -4.07687761e-02f, -3.82656455e-02f, -7.20493346e-02f, -9.66512319e-03f, 8.59639496e-02f, 8.53331834e-02f, -6.93413243e-02f, 5.48757128e-02f,
  -3.98123870e-03f, 3.44008207e-02f, -9.94651169e-02f, 8.42164678e-04f, 5.00766151e-02f, -1.20932564e-01f, -6.84463531e-02f, -7.83878639e-02f, -5.53097092e-02f, -5.95089644e-02f,
  -7.50225335e-02f, 5.44120222e-02f, 1.64255202e-02f, -7.27671683e-02f, -4.43312228e-02f, -7.47401360e-03f, -3.60639282e-02f, 8.33753869e-02f, -5.79886883e-02f, -2.32623983e-02f,
  -3.04363340e-01f, 3.06353182e-01f, -1.83697969e-01f, 1.71127707e-01f, -2.02524081e-01f, 2.49449182e-02f, 8.29501301e-02f, -4.57004234e-02f, 5.03113270e-02f, 1.42791167e-01f,
  8.39131400e-02f, 7.00982958e-02f, 6.66136667e-02f, 1.55085549e-01f, -9.31038558e-02f, 1.79523811e-01f, -4.46035229e-02f, 2.48722509e-02f, -4.44509238e-02f, -2.29338277e-02f,
  -2.78461799e-02f, 1.00958817e-01f, -1.14954919e-01f, -8.40383768e-02f, -1.11057781e-01f, -7.63607631e-03f, -8.38782042e-02f, -4.06984836e-02f, 3.23863029e-02f, 5.63845821e-02f,
  -5.68421967e-02f, 4.98881564e-02f, -1.12600483e-01f, -3.17305475e-02f, -8.07949826e-02f, -8.90484229e-02f, 3.14811766e-02f, -2.86863446e-02f, 6.89877337e-03f, -7.75447264e-02f,
  -9.56409052e-02f, -6.59798551e-03f, 6.37598485e-02f, 3.42196487e-02f, 4.83141802e-02f, -5.65357804e-02f, -1.16228126e-02f, -7.76594356e-02f, -1.92694813e-02f, 2.24414328e-03f,
  -9.08615720e-03f, 9.58816148e-03f, -2.93226559e-02f, 9.42614377e-02f, -3.48354429e-02f, 1.31961843e-02f, 8.79934728e-02f, 1.79870930e-02f, -4.73344848e-02f, 3.82689312e-02f,
  4.53496426e-02f, -7.90473968e-02f, 1.29011851e-02f, -2.66228206e-02f, 6.69992939e-02f, -2.85527073e-02f, 1.07633777e-01f, 2.02611443e-02f, -2.60737799e-02f, 5.21209575e-02f,
  -5.83147295e-02f, 5.80120161e-02f, 5.35896455e-04f, 6.19799234e-02f, 1.75977983e-02f, 1.60338264e-02f, 2.92493142e-02f, -1.42966527e-02f, -4.06682901e-02f, -2.96611376e-02f,
  4.53731157e-02f, 7.31913596e-02f, 2.36898120e-02f, -2.41880715e-02f, -2.40624323e-02f, -4.68438072e-03f, -4.38784696e-02f, 5.58337830e-02f, -8.34153146e-02f, -9.55476984e-02f,
  1.82324052e-02f, 1.12862781e-01f, 8.54175258e-03f, 5.58616892e-02f, 5.66021241e-02f, 2.24578474e-02f, 5.24375308e-03f, -9.37425718e-03f, 3.87256243e-03f, -5.43394051e-02f,
  3.30415033e-02f, -1.95891280e-02f, -5.07036485e-02f, -1.69885345e-02f, 5.23740537e-02f, 2.00082064e-02f, -3.73059511e-02f, -3.30127589e-02f, -6.77269921e-02f, -3.98196913e-02f,
  -1.10486299e-02f, -3.83016430e-02f, 2.97336895e-02f, -5.94004132e-02f, 3.24540026e-02f, -1.86347906e-02f, -2.83561777e-02f, 3.10704559e-02f, -1.04789101e-02f, -3.44372913e-02f,
  -7.43147219e-03f, -2.33968087e-02f, 1.33701349e-02f, 5.46033913e-03f, -1.76852688e-01f, 7.83354715e-02f, 1.86236605e-01f, -5.35848252e-02f, 1.93896815e-01f, -5.02397418e-02f,
  -1.83583312e-02f, -8.84889886e-02f, 7.81970173e-02f, 1.09940864e-01f, 2.09676117e-01f, 2.11814165e-01f, 8.11275691e-02f, -4.84081060e-02f, 5.52319698e-02f, -6.36018291e-02f,
  -3.02662142e-02f, 2.62664594e-02f, 1.09451070e-01f, 5.69535326e-03f, -1.25794739e-01f, -5.38643412e-02f, -8.88382569e-02f, -5.32412855e-03f, -1.51518881e-01f, -1.95662417e-02f,
  -6.47032559e-02f, 8.60831439e-02f, 4.31503616e-02f, 5.56011908e-02f, -1.14543751e-01f, 5.93818910e-03f, -2.76026987e-02f, 7.99260214e-02f, -4.17897329e-02f, 4.49567102e-02f,
  5.78728877e-02f, -5.43555096e-02f, -3.80243966e-03f, 7.45236501e-02f, -7.13900328e-02f, -1.32355653e-02f, -5.91317341e-02f, -1.30848559e-02f, -2.87354924e-02f, 6.05842322e-02f,
  8.44026729e-02f, -1.72250681e-02f, -4.28076051e-02f, 2.59931013e-02f, 3.26443762e-02f, -5.21449838e-03f, -1.52177587e-02f, -7.14518279e-02f, 3.61236483e-02f, 5.27981482e-02f,
  1.21043168e-01f, -3.72717343e-02f, 2.44492553e-02f, -5.06619103e-02f, -2.31468230e-02f, -2.95137689e-02f, 6.41679466e-02f, -2.53605023e-02f, -6.45485222e-02f, -1.42008131e-02f,
  -5.10297380e-02f, 2.69516166e-02f, -3.34892684e-04f, 1.01605639e-01f, 3.01456675e-02f, 9.31517631e-02f, 9.32071730e-02f, 3.88025530e-02f, 5.14566619e-03f, 5.64636197e-03f,
  5.06695136e-02f, 3.90483029e-02f, -3.29388538e-03f, -3.35174203e-02f, 6.26682490e-02f, -9.54795070e-03f, -4.40771952e-02f, 4.20854539e-02f, -1.88210476e-02f, -8.51051323e-03f,
  -1.42921254e-01f, -9.08482149e-02f, 1.51673025e-02f, -5.63360415e-02f, -3.73741537e-02f, 5.09266974e-03f, 4.26941663e-02f, -3.56657337e-03f, 8.58481303e-02f, 6.08790554e-02f,
  -2.60359049e-02f, -1.71143990e-02f, 3.28062545e-03f, 5.05398139e-02f, -1.47619322e-02f, -1.20620849e-03f, -5.84210828e-03f, -2.84616034e-02f, -1.78881083e-02f, -7.62282461e-02f,
  8.11193325e-03f, 6.33024052e-02f, 1.93165913e-02f, -3.64245363e-02f, -7.21007511e-02f, 3.42412926e-02f, -3.97485048e-02f, 5.11687919e-02f, -6.89240918e-02f, -1.26883090e-02f,
  1.88513711e-01f, 8.42788070e-03f, -6.53545484e-02f, 1.88449934e-01f, 4.95108105e-02f, 1.51715770e-01f, 1.23423435e-01f, 9.37553644e-02f, 1.57244250e-01f, -4.52605821e-02f,
  2.03303937e-02f, -7.16402605e-02f, -4.53037880e-02f, 1.31955162e-01f, 2.45383948e-01f, 1.54852584e-01f, 2.94862539e-01f, 5.96586317e-02f, -5.61964437e-02f, 1.04303852e-01f,
  1.22126758e-01f, 2.84135431e-01f, 8.98556113e-02f, -5.86241372e-02f, 5.46920449e-02f, -3.77007015e-02f, -2.80109141e-02f, -1.79430947e-01f, -3.53637300e-02f, -1.51843969e-02f,
  4.88113798e-02f, 7.18564540e-02f, -5.08875474e-02f, 2.57670321e-02f, -4.10704426e-02f, -2.54010819e-02f, -5.54301031e-02f, -9.96303558e-03f, 1.00462455e-02f, -7.37327784e-02f,
  -5.35899550e-02f, 2.23813262e-02f, 7.86726847e-02f, 2.83892080e-02f, 5.82783632e-02f, 4.62347344e-02f, -5.05745076e-02f, 2.43358780e-02f, -4.61618491e-02f, -2.40712147e-02f,
  9.76529438e-04f, 2.01571863e-02f, 1.01870246e-01f, 8.97557009e-03f, -1.13230925e-02f, -3.00165974e-02f, 4.08536755e-02f, -6.63430095e-02f, -8.75394270e-02f, 4.85439487e-02f,
  -1.81146786e-02f, -2.52365842e-02f, -3.00423615e-02f, -2.21038312e-02f, 3.09778992e-02f, -1.80158112e-02f, 4.27809022e-02f, -3.42964791e-02f, 6.88722532e-04f, -1.09521253e-02f,
  2.82199606e-02f, 6.68163598e-02f, 8.50322284e-03f, -3.27157788e-02f, 5.11419289e-02f, 3.97294946e-03f, -7.01093078e-02f, -3.86408791e-02f, 3.33893560e-02f, 2.08869241e-02f,
  -7.03840479e-02f, 6.56919694e-03f, -4.22981232e-02f, -5.91545813e-02f, -4.36591581e-02f, -8.84381309e-03f, 9.28215962e-03f, 1.57677382e-02f, -4.91566956e-02f, -1.45369405e-02f,
  1.29243201e-02f, -5.94574958e-02f, -2.97226049e-02f, -1.89903639e-02f, -1.30077787e-02f, -5.91149367e-03f, 4.32983190e-02f, 1.31113371e-02f, 6.18997067e-02f, 8.56070369e-02f,
  4.12969813e-02f, 4.82477527e-03f, -7.12127015e-02f, -3.69278230e-02f, -7.43710473e-02f, 4.48166169e-02f, -1.23358713e-02f, -4.18250151e-02f, -6.55800279e-04f, -1.18581916e-03f,
  -3.13954465e-02f, -1.50668602e-02f, -3.47120948e-02f, 2.10141204e-02f, 7.19893398e-03f, -1.85407624e-02f, 4.34927866e-02f, 5.65062370e-03f, -1.50120333e-02f, -3.95200122e-03f,
  -2.26215333e-01f, -9.52698886e-02f, -1.99393898e-01f, -1.90291241e-01f, -5.70987687e-02f, 2.25524381e-01f, 1.05122484e-01f, -1.14200465e-01f, -1.44318447e-01f, 7.98243582e-02f,
  1.02654144e-01f, -9.79915112e-02f, 1.99490830e-01f, 6.13041185e-02f, -5.46685560e-03f, 1.39411166e-01f, -7.81581253e-02f, -8.13882889e-06f, -1.05870910e-01f, -4.28922176e-02f,
  -1.57079756e-01f, 1.32344931e-01f, -1.06263213e-01f, 5.97604588e-02f, -9.03247446e-02f, -1.95178822e-01f, -3.11970944e-03f, -1.32505754e-02f, 1.49799930e-03f, 3.01934127e-02f,
  5.54203987e-03f, 3.14111821e-02f, -5.12584150e-02f, -3.22471038e-02f, -8.54462013e-03f, -1.27428398e-02f, -3.22890021e-02f, 8.62096995e-02f, 3.28842700e-02f, 2.09577568e-02f,
  1.43174315e-02f, -1.94419548e-02f, 1.32723060e-02f, 4.04136851e-02f, -2.06211414e-02f, -9.01056861e-04f, -1.90378185e-02f, -2.41313335e-02f, -3.29072885e-02f, 8.93798396e-02f,
  7.55970972e-03f, 1.13484599e-02f, -1.31572634e-02f, -6.34867698e-02f, -8.31025019e-02f, -2.96278764e-02f, 4.78623342e-03f, 4.81682941e-02f, 3.46463174e-02f, 6.70351973e-03f,
  -5.10937944e-02f, 3.63648776e-03f, 2.70373076e-02f, -1.05654616e-02f, -3.09327841e-02f, 2.14350801e-02f, -1.72271281e-02f, 7.66205788e-02f, -4.91642542e-02f, 1.64878573e-02f,
  -4.29784134e-02f, -5.28594255e-02f, 6.40625954e-02f, 6.14513503e-03f, 5.87282181e-02f, -3.66876796e-02f, 4.71090712e-02f, 3.10727302e-02f, -8.34520906e-02f, -7.94808101e-03f,
  5.40046208e-02f, 2.91589135e-03f, 7.42498366e-03f, 3.49408798e-02f, 7.28309527e-02f, 9.18446947e-03f, -1.71150994e-02f, -5.84407113e-02f, -5.61034679e-02f, 2.75406148e-03f,
  7.08962884e-03f, -1.15934275e-01f, 2.98540145e-02f, 7.17038512e-02f, 4.68103103e-02f, 4.04098593e-02f, 4.26099747e-02f, -1.28360003e-01f, -2.40133461e-02f, 4.28759605e-02f,
  9.13349446e-03f, 2.52778176e-02f, -7.70771084e-03f, -4.25802134e-02f, -4.45406660e-02f, 3.58778015e-02f, 9.41571221e-02f, -4.40764427e-02f, -1.05286082e-02f, -4.50543314e-02f,
  6.32536598e-03f, 5.17046712e-02f, 3.37535166e-04f, 1.74695160e-02f, 5.08138770e-03f, 1.57445185e-02f, -7.84695745e-02f, -5.92684820e-02f, -6.42635375e-02f, 1.68079790e-02f,
  1.66663826e-01f, -1.07973635e-01f, -3.46424319e-02f, -2.00547464e-02f, 1.71382964e-01f, 2.72517502e-01f, 1.84797019e-01f, 4.48412076e-02f, 2.08578244e-01f, -1.59878105e-01f,
  5.65140434e-02f, -2.16895312e-01f, -3.70479189e-02f, 1.04012378e-01f, 2.05964729e-01f, 1.23921216e-01f, 9.64643527e-03f, -6.77477717e-02f, 1.34453058e-01f, -1.07727975e-01f,
  6.52348772e-02f, 1.37812212e-01f, 4.66180108e-02f, -4.11454551e-02f, -4.66110632e-02f, -2.05497667e-01f, -1.92404389e-01f, -8.97413306e-03f, -1.12028524e-01f, 4.21043392e-03f,
  1.27592906e-01f, 2.22244915e-02f, -1.08872242e-02f, -1.60961822e-02f, -8.74422714e-02f, -4.71068099e-02f, -8.33412632e-04f, 3.56366076e-02f, 1.13757111e-01f, -3.05741373e-02f,
  -9.18856561e-02f, -1.14507303e-02f, 5.58258742e-02f, 8.30814540e-02f, 9.27358270e-02f, -2.27599367e-02f, -5.37784118e-03f, -7.52719864e-02f, -1.67255066e-02f, -3.17510739e-02f,
  1.42368739e-02f, -4.34774905e-02f, -4.11206000e-02f, -8.68007392e-02f, -4.56879772e-02f, 2.71164514e-02f, 2.80605685e-02f, -9.72238556e-02f, -1.26806628e-02f, -3.15092765e-02f,
  -1.07860342e-02f, 3.10002360e-02f, -4.03132513e-02f, 4.35772575e-02f, 8.77865106e-02f, 3.10128480e-02f, -6.41139457e-03f, -1.71813574e-02f, -1.04114767e-02f, 1.05100647e-02f,
  -1.79279689e-02f, -5.62091209e-02f, 1.34756798e-02f, 3.26464064e-02f, -4.28572744e-02f, 4.43568416e-02f, -2.60138251e-02f, -1.51816988e-02f, -9.32230651e-02f, -1.27203856e-02f,
  5.04858152e-04f, 1.22843221e-01f, -1.10690586e-01f, -6.38951827e-03f, 7.85949901e-02f, -1.26774367e-02f, -5.70631661e-02f, 4.96916436e-02f, 4.53751953e-03f, 8.65936000e-03f,
  -7.49344975e-02f, -1.12555303e-01f, -4.13799612e-03f, 4.86876965e-02f, -9.86057427e-03f, -2.87393946e-02f, -4.25923895e-03f, 1.75606739e-03f, 3.12522091e-02f, 4.00963165e-02f,
  -9.17905942e-02f, 3.58548155e-03f, -5.42462841e-02f, 1.09309983e-02f, 6.54609576e-02f, 1.22543806e-02f, 3.10076121e-02f, 4.24549840e-02f, -7.56540745e-02f, -2.42844168e-02f,
  -1.26723483e-01f, -4.25026752e-02f, -1.23665854e-02f, 1.63626019e-02f, -1.35166096e-02f, -6.01790361e-02f, -1.53607829e-02f, 4.02278639e-02f, -7.78864548e-02f, 2.06825766e-03f,
  3.37547213e-01f, -3.06379080e-01f, 7.00043887e-02f, -1.71898916e-01f, 4.61795405e-02f, -1.25324592e-01f, -1.03020288e-01f, 9.28171538e-03f, -1.57610267e-01f, -7.94270709e-02f,
  5.12011498e-02f, 4.22269925e-02f, -3.09642944e-02f, -1.66219875e-01f, 4.72111590e-02f, -1.28663093e-01f, -4.37884443e-02f, -4.91211079e-02f, -7.37959445e-02f, 7.95184076e-02f,
  -2.24338267e-02f, -6.21036217e-02f, -7.78743848e-02f, -4.45181541e-02f, 1.14902698e-01f, -8.54849592e-02f, 1.47509277e-01f, -7.52630010e-02f, 4.45373543e-02f, -4.60718647e-02f,
  7.45844468e-02f, 2.12795824e-01f, 5.79880178e-02f, 2.76460331e-02f, 1.05642848e-01f, 2.12120414e-02f, -2.51231971e-03f, 3.42295095e-02f, -1.20063138e-03f, -5.82356788e-02f,
  -1.53438479e-03f, 2.61658393e-02f, -4.23065163e-02f, -4.57767537e-03f, 6.54176623e-03f, -2.11905576e-02f, -6.04172237e-02f, 3.75289540e-03f, -2.87572816e-02f, -6.30040979e-03f,
  -9.41502675e-02f, 3.64225823e-03f, -1.45866554e-02f, -3.84306833e-02f, 4.66315076e-02f, -3.54884490e-02f, 1.15199998e-01f, 5.00201285e-02f, 3.34158316e-02f, 1.44102201e-02f,
  8.87862686e-03f, 2.74496414e-02f, -1.02575630e-01f, -1.78557802e-02f, -7.46132880e-02f, 5.39936200e-02f, 1.93723906e-02f, 4.60794778e-04f, -1.14092305e-01f, 4.05788198e-02f,
  -6.41242862e-02f, 4.01444584e-02f, 6.18687533e-02f, -3.40100308e-03f, -5.82712516e-02f, 3.99955660e-02f, 3.13270502e-02f, 1.44805685e-02f, -6.83699027e-02f, -2.40406196e-04f,
  -5.70136569e-02f, 6.47930205e-02f, -6.40404522e-02f, 2.32899208e-02f, -1.20567661e-02f, -2.45485343e-02f, -5.67189865e-02f, -1.52804228e-02f, -5.24826460e-02f, 2.92921457e-02f,
  2.18998510e-02f, 2.25252569e-01f, -4.74817678e-02f, -1.53827574e-02f, -9.17008445e-02f, 4.75347601e-03f, 5.86034283e-02f, -1.05834648e-01f, -7.06882328e-02f, -5.52776176e-03f,
  6.14126027e-02f, 8.99831802e-02f, 9.82872397e-02f, -6.83390200e-02f, -1.90530196e-02f, -2.72597447e-02f, 6.91084638e-02f, -1.77775677e-02f, 3.30551527e-02f, -3.36528793e-02f,
  2.80436594e-02f, 9.36907977e-02f, -3.65601182e-02f, 6.82438836e-02f, -9.28048417e-03f, 1.88307781e-02f, 6.89149881e-03f, -8.37603062e-02f, -2.57670716e-03f, -2.66874190e-02f,
  3.21044713e-01f, -2.22869411e-01f, 1.39907032e-01f, -1.90523341e-01f, 5.26019111e-02f, 5.01781106e-02f, 7.11693382e-03f, 4.41202968e-02f, -1.70331728e-02f, -2.40948442e-02f,
  1.65542029e-02f, -1.05744652e-01f, 1.27711266e-01f, -2.56160975e-01f, 6.50684834e-02f, 1.03479242e-02f, -5.36506698e-02f, -7.44402036e-02f, -9.91604105e-02f, -9.40264612e-02f,
  7.75770769e-02f, -1.81847289e-01f, 1.03137940e-01f, -1.46453515e-01f, 1.07717164e-01f, -2.32039616e-02f, 1.12220973e-01f, 5.16559370e-02f, -1.02201276e-01f, 5.88556565e-02f,
  5.70166223e-02f, 1.97147615e-02f, 1.18877389e-01f, 8.85664150e-02f, 1.03350595e-01f, 7.90335536e-02f, 6.73043430e-02f, -3.11686117e-02f, 4.87575829e-02f, -5.03457189e-02f,
  5.08387946e-02f, -2.40407189e-05f, 1.13352062e-02f, -1.61094256e-02f, -5.59210265e-03f, 3.26941046e-03f, -6.59737214e-02f, 3.21816243e-02f, -1.75140947e-02f, -1.59367756e-03f,
  1.01482542e-02f, -4.94731776e-02f, 1.04778027e-02f, -8.81111696e-02f, 3.57245728e-02f, 5.12861705e-04f, 2.52573881e-02f, -3.90408956e-03f, 9.94157884e-03f, -5.96280247e-02f,
  6.01724908e-02f, 9.68358964e-02f, 1.31128938e-03f, -4.19469476e-02f, -8.04825425e-02f, 6.72194734e-02f, -2.94387676e-02f, 1.31962849e-02f, -4.00703326e-02f, 4.81116818e-03f,
  -8.09247256e-04f, -9.02016535e-02f, -4.92611304e-02f, -1.01961847e-02f, 8.35439339e-02f, 1.15513382e-03f, -3.38237137e-02f, -2.20595635e-02f, 2.52671242e-02f, -1.09579742e-01f,
  -4.42620590e-02f, -2.96424963e-02f, -3.25061753e-02f, 1.22973494e-01f, 1.41467853e-02f, -4.63089114e-03f, -2.61713993e-02f, 5.37935607e-02f, 1.16773546e-01f, 9.12798122e-02f,
  5.96088544e-02f, 3.25337425e-02f, 5.44306748e-02f, 5.37958555e-02f, -7.13182986e-02f, 1.19934849e-01f, 5.36491023e-03f, -9.46595240e-03f, -4.84803953e-04f, 1.18582889e-01f,
  4.65949923e-02f, 4.12622169e-02f, 8.81439373e-02f, -3.38152722e-02f, -1.36433154e-01f, 4.66805063e-02f, 4.12557423e-02f, 2.26600692e-02f, 1.33068729e-02f, -9.57208723e-02f,
  2.12102029e-02f, 3.22398394e-02f, 5.81620783e-02f, -4.56768926e-03f, -6.59678923e-03f, -6.49763197e-02f, 8.99601914e-03f, 1.67413149e-02f, -6.27527609e-02f, -6.80075362e-02f,
  1.23416565e-01f, -1.00149527e-01f, 3.53521377e-01f, 2.28865468e-03f, -3.09664588e-02f, 1.73636496e-01f, 3.06191295e-02f, -2.88378168e-02f, 1.27796441e-01f, -1.85072571e-01f,
  -4.33959775e-02f, 1.96736559e-01f, 1.50321111e-01f, -8.40353593e-02f, 1.46183640e-01f, 4.68781777e-02f, -7.35805780e-02f, 7.83262253e-02f, -6.61304360e-03f, 2.39573345e-02f,
  1.74752980e-01f, -3.17760795e-01f, 1.86556384e-01f, -1.29525453e-01f, 8.17345828e-03f, -2.74650622e-02f, -1.37171194e-01f, 8.41164738e-02f, -6.32833615e-02f, -1.03875518e-01f,
  3.97026911e-03f, -2.43763551e-02f, -3.03204786e-02f, 6.83341920e-02f, -1.10200988e-02f, 1.10674528e-02f, 3.46741453e-02f, 5.33794090e-02f, 6.30953908e-02f, -1.94271542e-02f,
  3.11383866e-02f, 8.20315853e-02f, -3.46434116e-02f, -2.67573912e-02f, 2.91861854e-02f, 2.41445806e-02f, 7.23924041e-02f, 1.36351615e-01f, 7.70852715e-02f, 3.33650298e-02f,
  1.31319404e-01f, 6.79189339e-02f, 5.69553897e-02f, 2.24266741e-02f, 5.25330529e-02f, 8.23773369e-02f, 9.35437083e-02f, 3.83875184e-02f, -6.32181317e-02f, -4.28949594e-02f,
  -6.34336770e-02f, -1.05498573e-02f, 1.76871605e-02f, 9.33173448e-02f, -3.26221175e-02f, 9.30835586e-03f, 2.53215227e-02f, -1.28111355e-02f, 5.88388667e-02f, 1.86464377e-02f,
  2.49934494e-02f, -3.46344598e-02f, -7.71920681e-02f, 6.56246692e-02f, 8.53817631e-03f, -6.35857210e-02f, 1.04593612e-01f, 1.28673892e-02f, -1.27946939e-02f, -2.22627167e-02f,
  -1.11830319e-04f, -1.66476946e-02f, -1.56529043e-02f, 3.83777246e-02f, -3.84204872e-02f, 7.46126696e-02f, -2.16575358e-02f, 4.68395539e-02f, 1.39644528e-02f, 5.95468320e-02f,
  8.24334566e-03f, -9.36662406e-02f, -3.19090821e-02f, -3.40472013e-02f, 1.56225050e-02f, -3.65874283e-02f, -5.12212235e-03f, -3.85339418e-03f, -3.02171912e-02f, 4.89699766e-02f,
  1.44495480e-02f, 4.70439047e-02f, 1.94020346e-02f, 3.48175578e-02f, -1.98362935e-02f, 7.32921064e-02f, -4.45524231e-02f, -7.15083852e-02f, -5.34935147e-02f, -2.46638134e-02f,
  5.64530306e-02f, -1.65945068e-02f, 4.51589301e-02f, -2.95198914e-02f, -4.12330404e-02f, -2.73999684e-02f, -3.08594145e-02f, 7.55698700e-03f, 4.99051921e-02f, 6.26294091e-02f,
  2.15187415e-01f, -2.59634145e-02f, 1.40986502e-01f, 2.80573338e-01f, -7.36591071e-02f, -5.66118434e-02f, -1.18704729e-01f, 8.97880495e-02f, 1.06200546e-01f, -1.25350401e-01f,
  -2.08355449e-02f, -3.46163251e-02f, -4.13350239e-02f, -4.51864377e-02f, 1.48397535e-01f, -1.79008469e-01f, 2.07783058e-01f, 2.39469428e-02f, 2.13449802e-02f, 5.71146980e-02f,
  9.51905549e-02f, 2.90172417e-02f, 1.27653807e-01f, 7.65994340e-02f, 2.42858995e-02f, 8.49668011e-02f, 9.72912908e-02f, -1.16953775e-01f, 7.11248517e-02f, -1.25554636e-01f,
  -2.90373955e-02f, -8.00947174e-02f, -2.77032629e-02f, -8.31039697e-02f, 2.15524994e-02f, -2.29303520e-02f, -9.97175649e-02f, -8.18048641e-02f, 9.58705693e-03f, -7.87752792e-02f,
  -1.03465438e-01f, -4.30813022e-02f, -3.84842232e-02f, -3.82974409e-02f, 1.60682704e-02f, 3.07405852e-02f, 3.47000062e-02f, -3.93742882e-02f, 4.88875248e-02f, 6.77165836e-02f,
  -9.05373879e-03f, 4.30735685e-02f, -1.45643586e-02f, -2.25842148e-02f, -4.37346548e-02f, -9.02050640e-03f, -2.48460546e-02f, -6.30262643e-02f, 9.42035392e-03f, 2.65106279e-02f,
  -9.39538926e-02f, -2.00338941e-02f, 4.39902805e-02f, -1.74937565e-02f, 3.31040621e-02f, 6.12380356e-02f, -2.83533130e-02f, 1.27108209e-02f, 3.97867011e-03f, 1.31864045e-02f,
  1.09190881e-01f, 1.88523345e-02f, 3.22282091e-02f, 6.71747401e-02f, -3.79848629e-02f, -6.45549828e-03f, -5.49480431e-02f, 1.77567154e-02f, 1.03898998e-02f, 2.16495525e-02f,
  -4.10629995e-02f, 4.65217493e-02f, 1.83282085e-02f, 1.04242973e-02f, -2.87804138e-02f, 4.10695970e-02f, -4.34946734e-03f, 7.53622176e-03f, 1.28631266e-02f, 4.13034000e-02f,
  -5.95101416e-02f, 3.97154726e-02f, 2.59072408e-02f, -1.51158739e-02f, -9.12764072e-02f, 1.74883865e-02f, -3.66907082e-02f, 2.10566893e-02f, 2.26826202e-02f, 5.66569790e-02f,
  -4.08823555e-03f, 3.14401202e-02f, -1.13449566e-01f, 6.87975213e-02f, 3.67704476e-03f, 1.83180943e-02f, -2.06663460e-02f, -2.73843966e-02f, -2.36295685e-02f, 4.59388308e-02f,
  2.41918042e-02f, -4.91701774e-02f, -5.53949736e-02f, -3.35523523e-02f, -4.53921072e-02f, -3.00840586e-02f, 1.10486476e-02f, 7.74290711e-02f, -7.77262747e-02f, 8.01598560e-03f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.08603197e-01f, 1.27881065e-01f, 1.08041121e-02f, -1.56449333e-01f, 1.54735580e-01f, -7.77084455e-02f, -1.68630406e-01f, 2.69684531e-02f, 1.28324628e-01f, -1.19384930e-01f,
  -1.77119449e-01f, -5.91261052e-02f, 8.17769617e-02f, 1.57587845e-02f, -5.67706637e-02f, 1.13408692e-01f, -1.36991918e-01f, -1.53423578e-01f, 1.80240214e-01f, -1.38889432e-01f,
  -4.08429187e-03f, -7.67873973e-02f, 2.25319788e-02f, 1.11403555e-01f, -7.46535361e-02f, -4.09551635e-02f, -1.24384992e-01f, 8.17363560e-02f, -1.81970507e-01f, -2.21044421e-02f,
  -2.55322605e-01f, -1.72935978e-01f, -1.54909983e-01f, -1.78301767e-01f, -1.77788183e-01f, -5.38470708e-02f, -1.83002710e-01f, 6.68336218e-03f, -1.03678368e-02f, 8.97092149e-02f,
  -5.84515706e-02f, 2.85780746e-02f, -6.98372200e-02f, 6.19737729e-02f, 5.18430285e-02f, 7.65198143e-04f, 9.37111005e-02f, -3.79912741e-02f, 6.39908537e-02f, 1.58752069e-01f,
  -7.19619021e-02f, -5.58568127e-02f, -1.14113063e-01f, 2.75586620e-02f, 6.05386831e-02f, -6.87125251e-02f, -7.64785260e-02f, -4.48631607e-02f, -3.36831808e-02f, 2.75919754e-02f,
  4.49993014e-02f, 4.26279759e-04f, 4.02958170e-02f, -3.92050073e-02f, 2.09718309e-02f, 5.87423444e-02f, -4.99490686e-02f, -4.11544144e-02f, 1.85743403e-02f, -1.21926419e-01f,
  -4.78217229e-02f, 7.39330426e-03f, 1.04589827e-01f, 5.68986451e-03f, 5.55241890e-02f, -6.31545335e-02f, -8.50527883e-02f, 1.29040303e-02f, 7.17357732e-03f, -8.11287761e-02f,
  -3.95549126e-02f, 1.36616835e-02f, 8.73007551e-02f, 4.55099083e-02f, -9.25234929e-02f, -4.32909233e-04f, 4.39874753e-02f, 1.30832702e-01f, 9.22490954e-02f, -2.23698150e-02f,
  -2.70477623e-01f, -2.79562742e-01f, -9.11187157e-02f, -2.56866752e-03f, -1.09230570e-01f, 5.40594421e-02f, 7.47604715e-03f, 3.85371298e-02f, -1.51282977e-02f, -2.86879502e-02f,
  -1.77120902e-02f, 4.13591973e-02f, -2.18750425e-02f, 2.23969389e-02f, 4.71435785e-02f, -4.40177210e-02f, -1.04674675e-01f, -7.88297877e-02f, -1.82787001e-01f, -2.21161739e-04f,
  7.49158964e-04f, 3.72841246e-02f, -5.83750829e-02f, 1.91282295e-02f, -9.28220153e-02f, -7.01011764e-03f, -8.20595548e-02f, -2.19116844e-02f, 3.31259780e-02f, 3.75407860e-02f,
  6.55170977e-02f, -3.64654362e-01f, 4.95338403e-02f, 1.67609110e-01f, 1.36788577e-01f, 4.24374118e-02f, 9.04763415e-02f, -1.36034906e-01f, -4.53736074e-02f, -2.03029007e-01f,
  -1.04872957e-02f, 5.97167313e-02f, -1.57518774e-01f, 2.53473092e-02f, 2.52402633e-01f, -1.34615898e-01f, -6.51517138e-02f, 4.96089552e-03f, -9.73790698e-03f, 7.30823819e-03f,
  7.42091015e-02f, 1.26290187e-01f, 2.77583003e-02f, -1.09275989e-01f, 7.12837427e-05f, -1.77281187e-03f, -4.74589616e-02f, -4.16324548e-02f, 1.19083375e-01f, 1.72673777e-01f,
  2.76317392e-02f, -7.26839378e-02f, 6.85058087e-02f, -2.41183881e-02f, -9.59909186e-02f, 2.24902816e-02f, 1.37237879e-02f, 1.06243521e-01f, 5.58640994e-02f, 4.55954410e-02f,
  -2.82341111e-02f, 7.48087477e-04f, 1.16818294e-01f, 8.42968374e-02f, -2.01971792e-02f, -7.91674256e-02f, 1.14766303e-02f, 4.56532687e-02f, -2.63276603e-02f, -4.44123670e-02f,
  -7.29532093e-02f, -3.08916066e-02f, 6.73639169e-03f, 6.76414520e-02f, -3.93873677e-02f, 1.19776558e-02f, -5.53552844e-02f, 2.82842778e-02f, -6.63483813e-02f, 2.56575700e-02f,
  -6.31306544e-02f, -2.72707585e-02f, -3.83673236e-02f, 8.43124688e-02f, -1.33088995e-02f, 7.76116103e-02f, -1.88727602e-02f, -5.09286933e-02f, 5.62688746e-02f, -5.89318722e-02f,
  -1.11751165e-02f, 2.07262058e-02f, 8.49274453e-03f, -1.65327750e-02f, 3.92478667e-02f, -2.15964019e-02f, 3.33316363e-02f, 6.37475476e-02f, -2.99863163e-02f, -2.50174031e-02f,
  2.03111935e-02f, -6.12609740e-03f, -5.89022227e-02f, 2.18574628e-02f, -4.03998308e-02f, -3.28377374e-02f, -1.92585159e-02f, -4.35450822e-02f, 6.85929433e-02f, -2.18347721e-02f,
  -3.08278441e-01f, -3.62492114e-01f, 7.01968670e-02f, 5.95848598e-02f, 2.17853151e-02f, -3.60447355e-02f, -2.00165212e-02f, 8.74218158e-03f, -4.89380062e-02f, -1.04469575e-01f,
  -1.68694593e-02f, 1.09167159e-01f, -8.41330364e-02f, 1.17271952e-01f, 6.36715442e-02f, -1.74908396e-02f, -4.39462923e-02f, -3.89539860e-02f, 1.91417299e-02f, -3.82206105e-02f,
  2.52655782e-02f, -6.81036413e-02f, 8.58100802e-02f, -1.65024605e-02f, 1.76222976e-02f, 1.12939319e-02f, -5.63833863e-02f, 1.36715788e-02f, 2.65919715e-02f, 1.60121787e-02f,
  1.09796010e-01f, -1.47172719e-01f, 1.56062171e-01f, -2.50917524e-02f, 1.51334917e-02f, 2.66187638e-02f, 1.21127032e-01f, 6.44382834e-02f, 1.93142034e-02f, -2.60026399e-02f,
  -9.31205750e-02f, 7.04423636e-02f, 8.79251212e-02f, -2.67406464e-01f, 2.41862074e-01f, 4.19366285e-02f, 2.48911474e-02f, -5.34043871e-02f, -8.62568691e-02f, -3.20797637e-02f,
  -6.77828938e-02f, -1.87453374e-01f, -1.58875942e-01f, -7.76874870e-02f, -1.76176816e-01f, -1.53501362e-01f, -2.28658423e-01f, -7.13987947e-02f, -4.97966260e-02f, 4.50384170e-02f,
  3.01348697e-02f, 4.63408902e-02f, -3.51221450e-02f, -4.89238687e-02f, 3.80718075e-02f, 7.30425417e-02f, 2.45450810e-02f, 2.65151057e-02f, 1.61655545e-02f, 3.28905359e-02f,
  1.87593922e-02f, 5.64339235e-02f, 5.78426607e-02f, 5.81450947e-02f, -1.16103172e-01f, -1.43159539e-01f, -7.88921192e-02f, 7.89082423e-02f, -1.02041341e-01f, -7.78469369e-02f,
  -3.55085246e-02f, 1.07458851e-03f, -3.60730775e-02f, -1.53256699e-01f, 4.86743916e-03f, -7.01006055e-02f, 1.10552795e-01f, 6.57418277e-03f, -8.98135155e-02f, 4.79497090e-02f,
  -9.14547369e-02f, -7.91531056e-02f, -2.16234345e-02f, -7.63182566e-02f, -3.54044093e-03f, -3.18410471e-02f, 8.64487886e-02f, 9.27839801e-02f, 8.97446871e-02f, -1.24104815e-02f,
  -5.53627089e-02f, -3.90217602e-02f, -6.07953742e-02f, -1.34142488e-01f, -8.45865458e-02f, 6.79756179e-02f, -8.42527300e-02f, -1.00635208e-01f, -8.37254003e-02f, 9.82911587e-02f,
  5.83568774e-02f, 9.04213265e-02f, -8.65097493e-02f, -5.34329899e-02f, -5.15767522e-02f, 1.44017888e-02f, -1.35876715e-01f, -2.28421912e-02f, -5.44308089e-02f, 4.24896218e-02f,
  3.81720737e-02f, 5.22811450e-02f, 6.52307719e-02f, -1.81980580e-02f, 9.64911059e-02f, -9.10654590e-02f, -8.39220807e-02f, 6.92595467e-02f, 3.34771127e-02f, 3.65139730e-02f,
  -4.16128635e-02f, -7.03980848e-02f, 1.84523836e-01f, 1.14491209e-02f, 7.54584149e-02f, 4.92461212e-02f, -4.64224704e-02f, 2.75066271e-02f, -5.85338101e-02f, 2.57556010e-02f,
  -9.17100441e-03f, -9.12700742e-02f, -1.49025358e-02f, -1.55950084e-01f, -2.42664106e-02f, -3.49128656e-02f, 1.01753078e-01f, -1.47614017e-01f, 1.15473114e-01f, 1.10020116e-02f,
  1.50026038e-01f, 3.14016081e-02f, 1.01964541e-01f, 2.83814877e-01f, 4.00179215e-02f, -3.38347048e-01f, -7.96939060e-02f, 2.44448960e-01f, 1.74253598e-01f, -2.26520628e-01f,
  -6.40538484e-02f, -1.99754089e-02f, -1.36021525e-01f, 1.44843444e-01f, 8.61614197e-02f, -1.51209921e-01f, 1.19297430e-01f, -1.37884781e-01f, 9.75498185e-02f, 2.15207845e-01f,
  2.58416176e-01f, 9.70955566e-02f, 1.97010383e-01f, 3.96912433e-02f, 6.76459968e-02f, 2.69950330e-01f, 2.09040090e-01f, 6.36751726e-02f, 8.17017108e-02f, -1.39376998e-01f,
  2.27565728e-02f, 2.52567772e-02f, 1.23321719e-01f, 3.16409580e-02f, 1.10202201e-01f, -9.30658132e-02f, -3.19220573e-02f, 2.99867056e-02f, 4.22931202e-02f, 1.38391368e-02f,
  -8.27023163e-02f, -5.22750244e-02f, -2.40938105e-02f, 4.04440463e-02f, 7.77895795e-03f, 5.44121414e-02f, 2.44232044e-02f, -1.86215695e-02f, -4.01986111e-03f, 9.21937451e-03f,
  4.50248197e-02f, -4.30258214e-02f, 1.24059416e-01f, -3.86744365e-02f, 2.77209468e-02f, 6.59842119e-02f, -4.38142233e-02f, 3.56516503e-02f, -6.45866916e-02f, 1.40302896e-01f,
  1.19462714e-01f, -4.30185944e-02f, -7.55468979e-02f, -1.22810394e-01f, 2.80607343e-02f, -2.50650793e-02f, -1.12728775e-01f, -6.22871472e-03f, 2.65953504e-03f, -3.39912251e-02f,
  -2.17829160e-02f, 1.03989184e-01f, -2.06074137e-02f, -5.48981167e-02f, 6.00699559e-02f, -6.18763566e-02f, -1.28762005e-03f, -1.47276357e-01f, 8.49115849e-02f, 1.59485582e-02f,
  1.20417951e-02f, -7.04524890e-02f, -9.71330737e-04f, 5.73237464e-02f, -1.26298934e-01f, 4.67303954e-02f, 2.63231546e-02f, 2.62323674e-03f, -7.80479051e-03f, 2.03173421e-02f,
  3.56318918e-03f, 1.64144635e-01f, 7.19636902e-02f, 5.00875860e-02f, -7.86004290e-02f, -1.20951958e-01f, -4.33335304e-02f, 4.90665399e-02f, 4.94664675e-03f, -8.22174326e-02f,
  9.04432610e-02f, 5.20538632e-03f, 2.38973065e-03f, -5.80134355e-02f, 6.17001727e-02f, 7.97869414e-02f, 4.81139906e-02f, 1.68201290e-02f, 8.89015868e-02f, 5.25655076e-02f,
  4.06808183e-02f, -1.05744325e-01f, 5.53328507e-02f, 2.44483035e-02f, 2.70904042e-02f, -5.30032292e-02f, -5.97329661e-02f, 1.10267801e-02f, 3.51556949e-02f, -6.65287971e-02f,
  -3.18051279e-01f, -1.34976313e-01f, -2.32934386e-01f, 1.07982457e-01f, -4.18093354e-02f, 4.90866117e-02f, 7.79673904e-02f, 4.79565375e-02f, -2.51772732e-01f, 4.03337320e-03f,
  1.28088132e-01f, -1.19650386e-01f, 2.45999265e-02f, 2.81690150e-01f, 1.43153846e-01f, 7.23815174e-04f, 2.41879433e-01f, 3.15843942e-03f, -2.51761749e-02f, 1.21450890e-02f,
  1.69467404e-01f, 2.19387412e-01f, 1.08619958e-01f, 1.95244044e-01f, 1.40296504e-01f, 1.03131428e-01f, 1.88792512e-01f, 3.65542583e-02f, 2.08783075e-01f, 5.46572618e-02f,
  -1.49284760e-02f, -2.90107653e-02f, -1.61855996e-01f, -1.30561262e-01f, 7.66805336e-02f, 4.61161621e-02f, 7.86780864e-02f, 4.28698258e-04f, -3.23241800e-02f, -7.43283331e-02f,
  -1.94663443e-02f, 3.16949487e-02f, 5.14586307e-02f, -1.65796392e-02f, -7.24996701e-02f, 2.65180096e-02f, 1.62423570e-02f, 4.63572852e-02f, 7.46752173e-02f, -1.55716548e-02f,
  -5.35612516e-02f, 1.92979202e-02f, -3.90911363e-02f, 2.33092289e-02f, 4.74050120e-02f, 8.09789002e-02f, 2.15776097e-02f, 4.58054766e-02f, -8.28386024e-02f, 3.03782839e-02f,
  7.61206374e-02f, -9.22740921e-02f, 1.79702751e-02f, -2.61736084e-02f, -2.06727255e-02f, 9.52990167e-03f, 1.15208756e-02f, 1.30996808e-01f, 6.16346560e-02f, -5.45291789e-03f,
  9.39215869e-02f, -1.20183164e-02f, -1.47069828e-03f, -6.76501840e-02f, 3.74980047e-02f, -1.02835566e-01f, -4.12025861e-02f, 2.43020467e-02f, 1.15677323e-02f, 2.42434293e-02f,
  -8.20451677e-02f, -5.69734797e-02f, 4.81363423e-02f, -3.28609310e-02f, -3.94262150e-02f, -5.05572930e-02f, 9.59443972e-02f, 2.17724722e-02f, 9.05179381e-02f, -6.33036671e-03f,
  -5.85376695e-02f, -1.15700401e-01f, 1.14933057e-02f, -3.13873636e-03f, -2.65193321e-02f, -5.28199188e-02f, -1.04590565e-01f, 3.32529508e-02f, 9.57281142e-02f, 4.32940684e-02f,
  -7.33477697e-02f, 6.84736669e-02f, -1.26273304e-01f, 7.79258907e-02f, -1.84196904e-02f, -3.10561042e-02f, 4.05203439e-02f, 5.89277074e-02f, 7.19918385e-02f, 3.38703766e-02f,
  7.45445937e-02f, 5.30726537e-02f, 1.15760922e-01f, -2.26690173e-02f, -1.54438680e-02f, 9.98027846e-02f, -7.88367093e-02f, -9.43375565e-03f, 9.87630710e-02f, -3.42528187e-02f,
  -2.97025830e-01f, 2.35938326e-01f, -1.26094418e-02f, -1.10768020e-01f, 7.81766847e-02f, -2.00363085e-01f, -1.87483519e-01f, 3.96442525e-02f, 7.28702322e-02f, 8.47402662e-02f,
  2.60744523e-02f, 1.80979475e-01f, 8.28157067e-02f, 7.35441223e-03f, -2.73301303e-01f, 2.40768888e-03f, -2.75061697e-01f, -1.31386161e-01f, -2.13743635e-02f, -5.56808151e-02f,
  -1.69039667e-01f, -2.10069697e-02f, -7.84437824e-03f, 5.23973927e-02f, -8.40293691e-02f, 2.64776163e-02f, -7.76863471e-02f, 9.74806324e-02f, -4.86309509e-05f, 2.07098704e-02f,
  -2.58477122e-01f, 2.00396441e-02f, 9.18588117e-02f, -1.19892538e-01f, -1.53139949e-01f, -5.75839691e-02f, -4.44028750e-02f, 3.54592204e-02f, 6.55386178e-03f, -3.60681154e-02f,
  -2.40095370e-02f, -1.87810436e-02f, 5.63590750e-02f, 1.35792168e-02f, -5.15556224e-02f, 3.12462952e-02f, -6.45085126e-02f, -3.99304144e-02f, -4.79201600e-02f, -9.70512405e-02f,
  8.98386538e-02f, 3.90970372e-02f, -9.03091133e-02f, -4.55636233e-02f, -6.62178220e-03f, 1.99625567e-02f, -3.68299242e-03f, -2.79925615e-02f, -8.15429632e-03f, 3.66439782e-02f,
  -9.73974690e-02f, -1.03561066e-01f, -4.38491553e-02f, 6.82382956e-02f, -1.24674980e-02f, 4.37501222e-02f, -3.24508585e-02f, -1.36433486e-02f, 6.36135228e-03f, 1.87185109e-02f,
  -4.40316051e-02f, 3.21182348e-02f, -1.38264373e-02f, -1.41366899e-01f, -7.96640962e-02f, -5.25920540e-02f, 2.97933668e-02f, 8.26828368e-03f, -3.36677209e-02f, -1.01155825e-01f,
  -7.28509650e-02f, -7.89369922e-03f, 8.93132165e-02f, -6.05905522e-03f, -1.14363199e-02f, -1.32925995e-02f, 3.30842398e-02f, -7.19636604e-02f, 4.02136892e-02f, 4.77829063e-03f,
  -4.37773466e-01f, -1.59313574e-01f, -4.57436359e-03f, -2.45820396e-02f, -8.44392553e-02f, -1.40405849e-01f, -8.22063070e-03f, 2.15302426e-02f, -1.16127215e-01f, -1.36030987e-02f,
  -7.91580230e-03f, -3.62340808e-02f, -3.12932283e-02f, 1.93173229e-03f, -1.14011325e-01f, -7.61816129e-02f, -8.10619071e-02f, 2.80721914e-02f, -2.68950146e-02f, -1.11780725e-01f,
  -2.26020087e-02f, 1.23017523e-02f, 5.40370308e-02f, 1.64729841e-02f, -2.71524601e-02f, -3.89365964e-02f, -1.36323705e-01f, 4.87108827e-02f, -4.20747064e-02f, -1.31299654e-02f,
  -1.51332155e-01f, -3.27218264e-01f, 2.72179414e-02f, -1.62057474e-01f, 2.16849089e-01f, 2.55509764e-01f, 8.30659419e-02f, -1.79733828e-01f, -3.16619933e-01f, -1.37606993e-01f,
  7.97438025e-02f, -8.80704820e-03f, -3.14769447e-02f, -1.22809134e-01f, 8.41852650e-02f, -1.08719207e-01f, -1.58073261e-01f, 7.17034042e-02f, -1.83286756e-01f, -5.33903576e-03f,
  -6.36106282e-02f, 3.94937657e-02f, 4.39033285e-02f, 4.09231670e-02f, -4.88702580e-02f, 7.72713944e-02f, 2.02954695e-01f, 2.24214733e-01f, 8.28030556e-02f, 1.62073344e-01f,
  -6.88630417e-02f, -1.43616229e-01f, -2.89530866e-02f, -6.55648783e-02f, -3.33871655e-02f, 1.72937009e-02f, 6.87994957e-02f, 1.76071495e-01f, -6.27109632e-02f, 4.08362597e-02f,
  7.44569674e-02f, 2.69746985e-02f, -1.67364441e-02f, 7.67221674e-03f, 1.02909300e-02f, 2.62872912e-02f, -1.78421289e-02f, -3.28374691e-02f, -6.96814582e-02f, -1.16095785e-02f,
  1.88705735e-02f, 1.00110032e-01f, -1.13350458e-01f, 8.70516058e-03f, 8.26643109e-02f, -2.84549054e-02f, -5.42062009e-03f, 2.56486777e-02f, -1.11977961e-02f, 4.32548560e-02f,
  2.40617292e-03f, 2.68079434e-02f, 7.85898119e-02f, -7.54281059e-02f, 1.10980541e-01f, -8.12332928e-02f, -3.76043469e-02f, 1.06152095e-01f, 2.49380618e-02f, -6.05900306e-03f,
  -2.43774783e-02f, 2.94792857e-02f, -1.25367403e-01f, 6.36317059e-02f, 9.22095403e-02f, -6.91821054e-02f, 6.26727939e-02f, 3.27063426e-02f, 6.98298588e-03f, 6.64890232e-03f,
  -5.48554398e-02f, -1.41666224e-02f, 9.31046307e-02f, -5.45346327e-02f, -6.93921819e-02f, 8.44127610e-02f, -6.58498555e-02f, -1.35759749e-02f, 4.06536534e-02f, 6.72425404e-02f,
  5.42952865e-02f, -7.91963786e-02f, -7.00458661e-02f, 8.41577500e-02f, -2.07786802e-02f, -4.46667410e-02f, -5.42136542e-02f, -2.73373444e-02f, 5.37155569e-02f, -4.80599590e-02f,
  9.82570648e-02f, -2.67607197e-02f, 1.67461466e-02f, -2.92825550e-02f, 1.13283046e-01f, -5.15707657e-02f, 4.70795296e-02f, 1.36483004e-02f, -5.28736822e-02f, 3.23526934e-02f,
  7.41932392e-02f, 9.47413221e-02f, 1.99547270e-03f, 6.50566258e-03f, 1.63169075e-02f, 3.13876159e-02f, 2.93651391e-02f, 1.43719148e-02f, 1.52744036e-02f, 1.33874370e-02f,
  -3.46109085e-02f, 3.46416309e-02f, 7.30904117e-02f, -1.64334755e-02f, -2.05072194e-01f, 1.34202346e-01f, 3.08110535e-01f, -2.02805549e-01f, -5.09574413e-02f, -3.35309394e-02f,
  1.32826433e-01f, -6.43109903e-03f, 2.04799667e-01f, 8.02376941e-02f, 2.29351148e-01f, 2.33096600e-01f, 1.45960366e-02f, 1.11615688e-01f, -9.21961069e-02f, -2.04803094e-01f,
  -5.71503229e-02f, -2.30661005e-01f, 1.09018989e-01f, -2.88735509e-01f, -6.73982129e-02f, -1.86708570e-01f, -8.45618695e-02f, 9.29161459e-02f, -1.99771434e-01f, 4.82894965e-02f,
  3.17488201e-02f, -9.29622725e-02f, -5.13392314e-02f, -3.09533775e-02f, 1.96240954e-02f, -1.31466631e-02f, 1.55636657e-03f, 2.29370687e-02f, 5.38232327e-02f, -6.74025491e-02f,
  2.92343330e-02f, -1.90297551e-02f, -3.35700437e-02f, 8.26483145e-02f, -3.29856984e-02f, 1.02557354e-02f, -1.12135328e-01f, -4.80677262e-02f, -5.28366975e-02f, -4.67520133e-02f,
  -1.98416617e-02f, -2.15982329e-02f, 8.11626166e-02f, 3.10632633e-03f, -3.56284678e-02f, 3.93332504e-02f, 4.50737253e-02f, 8.35711733e-02f, -9.36233774e-02f, -1.39804617e-01f,
  -6.70481846e-02f, 5.18423133e-02f, 2.81695556e-03f, -1.06047049e-01f, 8.22676942e-02f, 6.29699156e-02f, -2.45951768e-02f, -1.43848462e-02f, -6.19999915e-02f, 2.49896757e-02f,
  -5.87839372e-02f, 9.46420990e-03f, 5.95009699e-02f, -4.28022631e-03f, -1.27362415e-01f, 2.08000503e-02f, 2.62487922e-02f, 1.63101126e-02f, 8.51211417e-03f, 3.33694480e-02f,
  -6.56865314e-02f, 9.86328535e-03f, 4.58218269e-02f, -4.84742895e-02f, -3.28778885e-02f, 3.13399769e-02f, -2.30840929e-02f, -5.87938167e-02f, -3.31048034e-02f, 7.29199499e-02f,
  -9.89677906e-02f, -9.80714560e-02f, -6.68219626e-02f, -1.59036294e-02f, -4.19217683e-02f, 2.94082966e-02f, 6.46316931e-02f, -8.20532739e-02f, 6.32476108e-03f, 9.75976791e-03f,
  1.30554335e-02f, 4.56885993e-02f, -1.30681977e-01f, -1.68582238e-02f, 4.92226630e-02f, -1.96901662e-03f, 1.88551266e-02f, -5.00683971e-02f, 4.56037559e-02f, -2.46774815e-02f,
  1.19692041e-02f, -2.75842417e-02f, -1.37823885e-02f, -5.66396415e-02f, 2.20267754e-02f, 1.11305870e-01f, -1.40002459e-01f, 1.60639901e-02f, -1.76100042e-02f, 1.29587092e-02f,
  -1.56231737e-03f, -3.07468511e-02f, -1.47107273e-01f, -1.62492935e-02f, -1.43463407e-02f, -1.82409912e-01f, -2.31516659e-01f, -2.11578831e-01f, 1.97338879e-01f, -4.17703344e-03f,
  -2.43614525e-01f, 1.85510546e-01f, -3.74497175e-02f, -1.52206421e-01f, 5.17877229e-02f, 1.16605580e-01f, -1.50779746e-02f, -2.46638544e-02f, 8.10399875e-02f, -1.73634082e-01f,
  -7.27111921e-02f, -2.65444756e-01f, -4.01825123e-02f, -2.35421985e-01f, -1.66056514e-01f, 1.88135449e-02f, 1.02293663e-01f, -7.47732371e-02f, -1.47907153e-01f, 1.20766267e-01f,
  2.78149098e-02f, 7.41178617e-02f, -4.67560329e-02f, 2.24243626e-02f, -1.36675425e-02f, 7.24207833e-02f, 8.98246616e-02f, 1.13211475e-01f, 1.10844053e-01f, -8.79552439e-02f,
  1.17894486e-01f, 5.52397035e-02f, -6.11997806e-02f, -4.58620489e-02f, 8.61343443e-02f, -4.18185629e-02f, -2.79074032e-02f, -4.18504477e-02f, 1.01020083e-01f, -3.56486812e-02f,
  -1.51616141e-01f, -4.16511223e-02f, -6.48712069e-02f, 1.37303695e-01f, 8.42155218e-02f, 2.53005940e-02f, -9.23401937e-02f, 9.62573662e-02f, -1.06713483e-02f, 1.69610962e-01f,
  1.22933881e-02f, 4.22550403e-02f, 6.13921285e-02f, -5.44022322e-02f, 4.29349653e-02f, -1.37797678e-02f, -1.30563593e-02f, -8.53907168e-02f, -2.36071609e-02f, -8.60289037e-02f,
  3.77755868e-03f, 1.02373593e-01f, 3.76967713e-02f, -1.40815610e-02f, -5.73275015e-02f, 4.31884825e-02f, 8.69089067e-02f, 8.61037523e-02f, -5.92681207e-02f, 9.47020650e-02f,
  -5.97317480e-02f, 8.38223249e-02f, 2.30250638e-02f, -4.91821244e-02f, -2.59375013e-02f, 4.32515936e-03f, -3.68976481e-02f, 2.63842680e-02f, 3.60315479e-02f, -4.55025770e-02f,
  -3.63136902e-02f, 1.44771099e-01f, -3.80952358e-02f, 3.15762237e-02f, 3.76490015e-03f, -5.66410497e-02f, 2.06374619e-02f, -1.58109386e-02f, 1.75316595e-02f, -4.26494852e-02f,
  -1.26250744e-01f, 7.28668198e-02f, 5.50993457e-02f, 1.38402000e-01f, 2.48002913e-02f, -2.57239379e-02f, 1.97148621e-02f, 3.72203737e-02f, 8.04367810e-02f, 1.31546212e-02f,
  -8.15799013e-02f, 8.08742270e-02f, 9.61612538e-03f, 1.26882210e-01f, 6.06536791e-02f, 9.93036628e-02f, -9.25971121e-02f, 1.05387740e-01f, 5.08532748e-02f, -1.46373082e-02f,
  3.74397784e-01f, 7.56058246e-02f, 1.38045922e-01f, 3.81313503e-01f, 1.12389296e-01f, 1.49000674e-01f, 1.96913838e-01f, 1.51338130e-01f, 4.67766613e-01f, -1.54750526e-01f,
  -2.56816205e-02f, 1.19081065e-01f, -1.31736815e-01f, 2.66002100e-02f, -1.00819036e-01f, -1.49761528e-01f, 5.24604768e-02f, 3.90723385e-02f, 1.42587870e-01f, 5.36739714e-02f,
  1.43368065e-01f, -2.00309172e-01f, -2.00409368e-01f, -2.35954791e-01f, -5.52617013e-03f, 3.03177666e-02f, -3.39459181e-01f, -1.09932847e-01f, -2.60212958e-01f, -1.07910030e-01f,
  2.79728416e-02f, 1.77466035e-01f, 3.28574106e-02f, -6.72876388e-02f, -2.67957449e-02f, -3.47936712e-03f, 2.59615686e-02f, -9.16426256e-02f, 6.07758723e-02f, 9.24461521e-03f,
  9.66648012e-03f, -1.89533513e-02f, 1.05223291e-01f, 2.04595905e-02f, 6.65205158e-03f, 2.71257525e-03f, -1.15503287e-02f, 2.59722117e-02f, -3.48079763e-02f, 4.30517159e-02f,
  8.07773173e-02f, 9.51272994e-02f, -2.07241904e-02f, -1.01122208e-01f, -1.13753146e-02f, 7.95544088e-02f, 1.00678667e-01f, -5.25860786e-02f, -1.55691644e-02f, 8.10214952e-02f,
  3.21647240e-04f, 1.72824394e-02f, -4.31706719e-02f, -5.68664595e-02f, -9.82892439e-02f, 4.54262085e-02f, -7.60874823e-02f, -1.82247888e-02f, 6.41829371e-02f, -4.10883948e-02f,
  -5.41018434e-02f, 1.44170672e-02f, 3.47260572e-02f, 2.79660393e-02f, 1.36703476e-01f, 7.35557228e-02f, 2.18609683e-02f, -1.00863680e-01f, 1.40119523e-01f, 2.74542253e-02f,
  6.04085363e-02f, 1.85978375e-02f, -5.47818393e-02f, -7.88369998e-02f, -4.17054109e-02f, 6.11134153e-03f, 4.45107743e-02f, -8.60998556e-02f, 7.24979192e-02f, 2.82125846e-02f,
  -1.80472508e-02f, 3.51124955e-03f, -7.14499736e-03f, -3.68293971e-02f, -7.75519237e-02f, -4.63900901e-03f, -6.09643795e-02f, -2.59948298e-02f, 3.87400109e-03f, -7.19908550e-02f,
  6.69255704e-02f, 1.19943731e-02f, -3.19477618e-02f, -7.91719258e-02f, 2.29951981e-02f, -1.58840433e-01f, 7.52742887e-02f, 1.31592248e-02f, 1.60409287e-02f, -7.75280073e-02f,
  -1.90198962e-02f, -7.47036338e-02f, -1.47553990e-02f, -1.41367214e-02f, -1.30189471e-02f, -6.64355755e-02f, 8.48671049e-03f, -4.44920883e-02f, -1.21342344e-02f, 5.33139072e-02f,
  2.15373352e-01f, -1.45296067e-01f, 1.23081610e-01f, 1.51776388e-01f, 2.03237742e-01f, 1.09239779e-01f, 2.32961580e-01f, 5.38061894e-02f, 2.15513378e-01f, -1.07583731e-01f,
  -2.41922699e-02f, -1.59897223e-01f, -7.65962452e-02f, -5.50603978e-02f, 1.03701964e-01f, -1.81387700e-02f, -3.25273946e-02f, -7.50107393e-02f, 2.00668886e-01f, 7.31385946e-02f,
  6.75159022e-02f, 5.87529577e-02f, 1.32321954e-01f, -9.23876464e-02f, 7.52476454e-02f, -4.64575738e-02f, -1.41299412e-01f, 1.43632203e-01f, -1.40686646e-01f, -1.49337519e-02f,
  -4.17110920e-02f, 4.71432954e-02f, -6.35088459e-02f, 6.77680150e-02f, 1.30342012e-02f, 5.19763380e-02f, -4.32676151e-02f, -2.89466791e-02f, 7.87313282e-02f, -1.37187410e-02f,
  -3.42529640e-02f, 1.10542566e-01f, 8.68098531e-03f, 1.30481813e-02f, 3.44634652e-02f, 7.69528002e-02f, 8.73357281e-02f, 1.00469626e-01f, -2.55653588e-03f, 4.03049886e-02f,
  -3.26449350e-02f, -4.89515066e-02f, 4.70542572e-02f, -3.23704854e-02f, -4.34065349e-02f, 1.18900843e-01f, -2.82970108e-02f, 1.85855140e-03f, 2.71900501e-02f, 6.00564368e-02f,
  -6.92199618e-02f, -6.01160973e-02f, 5.36275879e-02f, 3.10452096e-02f, 1.19203497e-02f, 5.41055314e-02f, -3.24051417e-02f, 1.00620911e-02f, -1.22571118e-01f, -8.02449510e-03f,
  4.46804576e-02f, -2.75680609e-03f, -3.00947148e-02f, -5.81608433e-03f, 4.32144143e-02f, 3.99376117e-02f, 4.68695015e-02f, -5.35969473e-02f, 1.91245284e-02f, -2.17764499e-03f,
  -8.57623965e-02f, -2.96543427e-02f, -2.62141053e-04f, 6.32096902e-02f, 4.39908728e-02f, -1.21008409e-02f, 6.85336394e-03f, 2.37111021e-02f, 4.67239954e-02f, -2.63718534e-02f,
  -1.46650940e-01f, -2.25339502e-01f, 1.02267526e-02f, 6.76540881e-02f, -7.79974982e-02f, -3.32437418e-02f, 7.33749568e-03f, -6.07587695e-02f, -4.96126711e-02f, 4.83362488e-02f,
  4.38392954e-03f, -5.41457022e-03f, -7.97239244e-02f, 5.04533835e-02f, -1.20345898e-01f, -1.04535138e-02f, -7.79789612e-02f, -1.33223608e-01f, -8.99077356e-02f, -3.13550681e-02f,
  -5.45923747e-02f, -6.96574077e-02f, 6.83234259e-02f, 5.79700321e-02f, -8.32829699e-02f, 1.78137273e-02f, -4.38607410e-02f, -2.85517219e-02f, -6.76595280e-03f, 1.62690952e-02f,
  -4.71037239e-01f, 1.25443056e-01f, 2.19915882e-01f, -3.08243454e-01f, 1.65124714e-01f, -1.47428691e-01f, -1.37437716e-01f, 1.34445116e-01f, -4.89502437e-02f, 5.08693345e-02f,
  -1.01822332e-01f, -6.87318482e-03f, 1.37009725e-01f, -1.95356101e-01f, -2.62067556e-01f, 2.51281802e-02f, -2.19880924e-01f, -1.55691206e-01f, 7.23696053e-02f, -8.97838175e-02f,
  -1.30347088e-01f, -5.41307218e-02f, 9.65155289e-03f, 1.98218480e-01f, 5.22672869e-02f, 6.26817867e-02f, -2.19320551e-01f, 2.89790332e-01f, -8.23586956e-02f, -5.32325841e-02f,
  5.94238453e-02f, 6.38744235e-02f, 8.95512328e-02f, 1.66346937e-01f, 4.99983877e-02f, -5.09252660e-02f, 1.33182071e-02f, 2.29876544e-02f, 1.01566494e-01f, -1.58966111e-03f,
  3.85863036e-02f, 4.08117510e-02f, -2.38128826e-02f, 1.56980559e-01f, 7.16972947e-02f, 3.36771272e-02f, 2.38851085e-02f, 3.10503133e-02f, 9.67260599e-02f, 9.19826999e-02f,
  2.97681186e-02f, -3.19135003e-02f, -4.60204855e-02f, -5.66834137e-02f, -2.62122564e-02f, 4.65462059e-02f, -1.80869270e-02f, 3.78104043e-03f, -1.04781680e-01f, -5.24981879e-02f,
  3.22985239e-02f, -5.24010099e-02f, 4.95621487e-02f, 5.92002086e-02f, -1.63832679e-02f, 9.49155390e-02f, 6.99165240e-02f, 2.69855130e-02f, 1.96792148e-02f, 5.48897348e-02f,
  -8.76870528e-02f, 2.80340426e-02f, 3.49078402e-02f, 1.64228457e-03f, -8.65315571e-02f, -2.49623097e-02f, -1.42365377e-02f, 1.50809223e-02f, 1.45409186e-03f, -1.88576598e-02f,
  4.23718989e-02f, 3.58085185e-02f, -1.27770454e-02f, -5.62979132e-02f, -1.98310446e-02f, 1.08789541e-01f, -3.74980383e-02f, 1.58339762e-03f, -2.72390433e-02f, -3.51435207e-02f,
  -1.36842266e-01f, -6.66410178e-02f, 1.28600881e-01f, 6.97231367e-02f, -8.67955573e-03f, -3.43162045e-02f, -4.71521914e-03f, -7.07979454e-03f, -6.69097081e-02f, -1.92035306e-02f,
  -7.19025955e-02f, -9.33729298e-03f, -1.14141844e-01f, 3.78587916e-02f, -3.87163181e-03f, -4.86638164e-03f, -8.74339119e-02f, -9.13253650e-02f, -1.41405582e-01f, -8.55419636e-02f,
  -2.36543007e-02f, -1.97096430e-02f, -3.68636586e-02f, 8.51189159e-03f, -1.91186264e-03f, -4.98462729e-02f, 1.61347375e-03f, 2.18495615e-02f, -2.08237059e-02f, -1.06221236e-01f,
  -3.95905554e-01f, 2.33154699e-01f, -1.17488138e-01f, -2.01914668e-01f, 1.46195531e-01f, -8.70615840e-02f, -2.35216931e-01f, -7.92878196e-02f, -3.75660397e-02f, 1.58303585e-02f,
  -1.06124148e-01f, -1.24177895e-02f, 1.53559953e-01f, -2.63383746e-01f, -2.43243873e-01f, -2.66365647e-01f, -3.28775853e-01f, -1.39474437e-01f, 9.39125046e-02f, -5.43314964e-03f,
  -1.02835791e-02f, -2.00274616e-01f, -1.87366113e-01f, 1.08651519e-01f, -1.06508270e-01f, 8.09876099e-02f, 3.21286097e-02f, 2.30683833e-01f, -2.64774226e-02f, -6.32073730e-02f,
  -1.44555792e-01f, 8.93546939e-02f, -3.07950918e-02f, 7.44826645e-02f, -5.82202291e-03f, -6.47682622e-02f, 2.51034722e-02f, -4.30011004e-02f, 8.06392878e-02f, -6.68296516e-02f,
  3.61347869e-02f, 9.16512907e-02f, -5.46326488e-02f, -4.45812866e-02f, -1.47922095e-02f, 6.74597993e-02f, -7.99871832e-02f, 1.64365396e-02f, 5.87501824e-02f, -2.91337166e-02f,
  3.34615968e-02f, -2.61212178e-02f, -1.67638268e-02f, 2.53663305e-02f, -1.16766118e-01f, 3.49344015e-02f, -7.61684328e-02f, 1.14818700e-01f, 1.17191002e-02f, -1.72690656e-02f,
  -1.47583159e-02f, -1.42571814e-02f, 7.23981336e-02f, -9.43724662e-02f, -1.32558281e-02f, 1.15882969e-02f, -7.88923725e-02f, 3.78680676e-02f, -2.83969473e-02f, 4.02502576e-03f,
  -1.97800435e-02f, 5.91946691e-02f, -1.32436687e-02f, -8.26789290e-02f, 1.77169070e-02f, -5.88972941e-02f, 2.25899182e-03f, -2.05439180e-02f, -3.24436091e-02f, -1.57660823e-02f,
  -3.81508023e-02f, -8.33821371e-02f, 2.41584890e-02f, 5.20696789e-02f, -6.05180999e-03f, 2.11029314e-02f, 3.30509879e-02f, 2.37524007e-02f, -4.48630266e-02f, -3.82652655e-02f,
  -2.01462761e-01f, -1.61217362e-01f, -1.00134119e-01f, 2.60669142e-02f, -3.77167910e-02f, 3.26508842e-03f, -1.28257498e-01f, -1.51236141e-02f, -1.45670613e-02f, 2.15060469e-02f,
  8.86588767e-02f, -7.32268672e-03f, -5.10385446e-02f, 1.98599827e-02f, -7.58195221e-02f, -8.26014429e-02f, 2.94423290e-02f, -5.00172004e-02f, -5.54771833e-02f, 8.89894590e-02f,
  4.08459008e-02f, -1.32010076e-02f, -6.38245046e-02f, -1.13485311e-03f, 7.43805990e-02f, 3.83677855e-02f, -5.68005703e-02f, 1.57319322e-01f, -3.94481421e-02f, 3.15689892e-02f,
  2.71880716e-01f, 2.14994654e-01f, 2.37577572e-01f, 8.70523080e-02f, 4.57278527e-02f, 4.11689356e-02f, 8.74710307e-02f, 8.65529180e-02f, 3.39970559e-01f, -3.23558263e-02f,
  -1.05829321e-01f, 2.48706877e-01f, -1.09236978e-01f, -2.07910296e-02f, -1.26298919e-01f, -1.15651242e-01f, -1.32968007e-02f, 7.09385574e-02f, 3.80907133e-02f, 6.28565922e-02f,
  -8.16449076e-02f, -2.47172490e-01f, -1.67137802e-01f, -9.77813005e-02f, -6.28554169e-03f, 1.01300314e-01f, -3.40205729e-01f, 1.62989448e-03f, -8.28747638e-04f, -3.84818874e-02f,
  4.78099883e-02f, 2.67171152e-02f, 1.02840841e-01f, 1.06168203e-01f, -2.43977197e-02f, -3.44314277e-02f, 3.42732482e-02f, -9.82371271e-02f, 8.44937563e-02f, 6.29054382e-02f,
  -1.25157228e-02f, 9.04668029e-03f, -2.08204830e-04f, -4.52396125e-02f, 1.65794000e-01f, 1.47597164e-01f, 4.61232625e-02f, 9.73343328e-02f, 3.01042274e-02f, -2.62276866e-02f,
  1.05101958e-01f, 1.54853284e-01f, 2.18736120e-02f, 2.54646805e-03f, 5.83995804e-02f, 1.10035227e-03f, 3.71868759e-02f, 2.36572213e-02f, 1.11838624e-01f, -2.21971590e-02f,
  -8.73290002e-02f, -7.27874115e-02f, 1.23146977e-02f, -3.36656999e-03f, 2.30760239e-02f, 1.39486336e-03f, -1.30546801e-02f, -1.17982179e-02f, 1.56698495e-01f, -2.61612814e-02f,
  -2.37517990e-02f, 2.23282166e-02f, 3.74937952e-02f, 1.08484641e-01f, -6.95101768e-02f, 6.10868484e-02f, 2.98312656e-03f, 9.44240615e-02f, 1.68700852e-02f, -3.86534967e-02f,
  -8.10192451e-02f, 4.16977797e-03f, 5.15159741e-02f, -5.85792996e-02f, 4.79639880e-02f, -5.26442528e-02f, 4.97212000e-02f, 1.56383827e-01f, -1.14910677e-01f, -1.47614852e-01f,
  -8.75416696e-02f, -1.60884008e-01f, -8.65747593e-03f, 5.48098050e-02f, 4.25420478e-02f, 5.02433330e-02f, 4.98419032e-02f, 2.31679641e-02f, -3.28146592e-02f, -3.16103771e-02f,
  -7.55118057e-02f, -5.52976653e-02f, -4.49335016e-02f, -4.77776341e-02f, -1.73334107e-02f, 1.86988455e-03f, -1.00445002e-01f, -6.16194569e-02f, -9.49693024e-02f, -9.12292078e-02f,
  3.75332981e-02f, -1.82392746e-02f, 2.06244066e-02f, -6.10388704e-02f, 4.48950268e-02f, 2.50378568e-02f, -1.55477682e-02f, 1.54393122e-01f, -6.19270690e-02f, -2.00634301e-02f,
  3.17003161e-01f, 3.09833288e-01f, 3.02795798e-01f, 3.77075404e-01f, -2.79633552e-01f, -1.50684297e-01f, 4.03184518e-02f, -1.08897246e-01f, 7.79003203e-02f, 8.21940005e-02f,
  -1.46533176e-01f, 1.88304946e-01f, -2.01918021e-01f, 2.05833972e-01f, -1.81793898e-01f, -2.89390199e-02f, 1.30816251e-01f, 2.69786138e-02f, -3.73296775e-02f, 1.60566926e-01f,
  -2.54870709e-02f, -2.21555546e-01f, 1.90989420e-01f, -1.67477340e-01f, 2.16347352e-01f, 1.52743369e-01f, -7.28913099e-02f, -1.04912400e-01f, 1.94814846e-01f, -1.15046017e-01f,
  -9.96520147e-02f, 5.55979572e-02f, 6.83116168e-02f, 1.39659122e-01f, 1.10420454e-02f, 4.51257415e-02f, 5.20653687e-02f, -6.16313629e-02f, -7.45233670e-02f, 6.93611940e-03f,
  1.11024030e-01f, 1.74786244e-02f, 8.09418634e-02f, -2.17441414e-02f, -5.69772497e-02f, 5.43268062e-02f, 9.66013744e-02f, 8.64640176e-02f, 8.71008784e-02f, 1.18707433e-01f,
  1.45526126e-01f, 2.21345183e-02f, 2.78483965e-02f, 6.88373595e-02f, -1.39105432e-02f, 3.10085677e-02f, 1.38079084e-03f, 8.71510208e-02f, 1.07587896e-01f, 1.35941878e-01f,
  -4.80928794e-02f, -1.77510493e-02f, 8.54440406e-02f, 7.11657032e-02f, -4.94575836e-02f, -9.86042619e-02f, 7.36743808e-02f, -6.74847886e-02f, 1.83188524e-02f, -3.11802025e-03f,
  -3.58341783e-02f, 6.51192963e-02f, 1.17624803e-02f, 3.23623344e-02f, 5.87581955e-02f, 1.60555504e-02f, -1.69108866e-03f, 9.53667089e-02f, 9.21787620e-02f, 6.07974902e-02f,
  -1.93895195e-02f, 2.08520107e-02f, -1.51146008e-02f, -4.70258817e-02f, -2.87902486e-02f, -2.30113212e-02f, 1.08333349e-01f, 5.44727817e-02f, 1.33127172e-03f, -7.17106014e-02f,
  -6.74070418e-02f, 1.03590615e-01f, -3.24576423e-02f, 5.88785224e-02f, -1.11106992e-01f, 6.53102249e-02f, 2.46951059e-02f, 2.55225729e-02f, -1.09890051e-01f, 5.01727387e-02f,
  -2.44170204e-02f, 3.22670676e-02f, -4.19204310e-02f, 6.34796023e-02f, -8.62134099e-02f, -5.43131530e-02f, 4.32327129e-02f, -3.38444114e-02f, -3.26215290e-02f, -9.91909299e-03f,
  3.61623615e-02f, -5.96079491e-02f, -6.72126412e-02f, 3.18792462e-02f, 1.19464612e-02f, -5.63639076e-03f, 7.50221089e-02f, 3.49745788e-02f, 6.90680370e-03f, -2.26451531e-02f,
  4.03299123e-01f, -3.65955830e-01f, 1.37504578e-01f, 3.64404291e-01f, 1.87485635e-01f, 1.55844009e-02f, 1.18253827e-01f, 4.29786332e-02f, 2.52422452e-01f, -1.89062342e-01f,
  -4.43046317e-02f, -5.54839969e-02f, -2.06649899e-01f, 3.39638479e-02f, 1.49148852e-01f, -1.90160096e-01f, -1.56235732e-02f, -8.28133747e-02f, -1.20309293e-02f, 4.60065203e-03f,
  1.88644513e-01f, 1.46505103e-01f, -6.04835600e-02f, -1.16969824e-01f, 7.10610896e-02f, 1.16465501e-01f, 8.25933069e-02f, -1.18093744e-01f, -3.72268818e-02f, -3.07515133e-02f,
  -8.02555978e-02f, -4.19324748e-02f, -3.79388891e-02f, -1.08568884e-01f, 1.05430121e-02f, -9.70455706e-02f, -1.01444041e-02f, 1.34232054e-02f, -2.86864154e-02f, -2.27472577e-02f,
  -2.23403275e-02f, -1.81204248e-02f, 8.84419009e-02f, 3.33280601e-02f, -5.04459776e-02f, 9.07505453e-02f, 9.76359099e-02f, 1.19531276e-02f, 2.01835223e-02f, -1.02776103e-03f,
  -5.82202189e-02f, -1.32329958e-02f, -4.07185871e-03f, 2.99908258e-02f, 4.26737741e-02f, 6.83660358e-02f, -5.87906614e-02f, 2.10621413e-02f, -4.21890132e-02f, 1.19340457e-01f,
  1.97385587e-02f, -3.42271551e-02f, -6.40208721e-02f, -1.74599013e-03f, -5.78461476e-02f, 1.02534093e-01f, -1.07603827e-02f, -2.06869394e-02f, 4.40734532e-03f, 5.40035889e-02f,
  -1.06186504e-02f, -1.87910683e-02f, -6.61579296e-02f, -5.44047058e-02f, 5.59808314e-02f, 4.96425247e-03f, 9.22038183e-02f, 2.88290028e-02f, 5.41325770e-02f, 4.29547727e-02f,
  4.84591983e-02f, -1.64436232e-02f, -3.47990990e-02f, 4.01582234e-02f, 7.90206790e-02f, 3.80280279e-02f, -7.33364047e-03f, -8.69239215e-03f, 4.12509479e-02f, -8.56071711e-02f,
  -4.52757657e-01f, -1.74697354e-01f, -8.46272185e-02f, 1.63092911e-02f, -3.41398232e-02f, 3.36079039e-02f, -2.44964063e-02f, -3.24093103e-02f, -1.50763065e-01f, 1.87018607e-02f,
  -5.03232107e-02f, -9.85004567e-03f, -3.40338387e-02f, 3.55779044e-02f, -2.61308365e-02f, -5.54659516e-02f, -1.16310669e-02f, -7.39126652e-02f, -3.40595841e-02f, -7.93896392e-02f,
  -1.19279996e-02f, -1.19955446e-04f, -9.03225690e-03f, -2.33971644e-02f, -3.91239524e-02f, -6.61384538e-02f, 5.20126857e-02f, 1.88160669e-02f, 4.68752733e-05f, -3.72517831e-03f,
  1.42523035e-01f, -8.01681913e-03f, -6.42587990e-03f, -1.62241071e-01f, -1.01988792e-01f, -1.38708815e-01f, -2.15767369e-01f, -9.79832411e-02f, -1.02436118e-01f, -2.37986892e-02f,
  -1.04477517e-01f, 7.95519575e-02f, 5.59800640e-02f, -1.17806025e-01f, 6.36828244e-02f, 4.00299467e-02f, -2.09032744e-01f, -1.12415686e-01f, -7.73626268e-02f, -1.33738503e-01f,
  -2.03405842e-02f, -2.03647077e-01f, -5.19883595e-02f, -1.78217605e-01f, -1.56750843e-01f, 3.48567439e-04f, -1.04048979e-02f, -7.12026879e-02f, -9.17656496e-02f, -6.02724999e-02f,
  3.70404907e-02f, -6.55589029e-02f, 2.32093316e-02f, 1.03631884e-01f, -9.86529514e-04f, -2.63888203e-03f, -8.31923708e-02f, 1.29158974e-01f, -1.03386575e-02f, -1.12323634e-01f,
  9.18526947e-02f, 4.58320081e-02f, -4.43752445e-02f, -1.03240665e-02f, -2.11744383e-01f, -9.82572418e-03f, 2.55602095e-02f, -2.65614297e-02f, -3.07198260e-02f, 1.13306448e-01f,
  -5.93199432e-02f, -5.28582968e-02f, -1.13234492e-02f, -2.13079937e-02f, -1.34495303e-01f, -1.01250820e-01f, 1.23281628e-01f, -3.49691068e-03f, -9.66839306e-03f, 2.94985827e-02f,
  -9.21699777e-02f, 9.06308088e-03f, -4.45196293e-02f, -7.49266893e-02f, 8.11960101e-02f, -2.14053392e-02f, -6.91728145e-02f, 7.31900260e-02f, -6.59161583e-02f, -5.91980740e-02f,
  5.56731112e-02f, -3.15783955e-02f, -5.92508912e-02f, -1.75751597e-01f, 4.15677717e-03f, 7.46508390e-02f, -6.55323267e-02f, -2.62977891e-02f, -6.15534894e-02f, 9.60958377e-02f,
  1.13638751e-01f, 4.41602767e-02f, 9.74054933e-02f, 3.58693823e-02f, -1.41062453e-01f, 8.49099085e-03f, 4.79139648e-02f, 4.44043335e-03f, 2.12508384e-02f, -3.61036249e-02f,
  -1.26977950e-01f, 7.13894330e-03f, 7.33706281e-02f, -2.19359696e-02f, -2.73969118e-02f, 1.35698719e-02f, -7.46165141e-02f, 8.91378075e-02f, -3.27128209e-02f, -7.53863826e-02f,
  -1.05887026e-01f, -2.25064438e-02f, -3.69709916e-02f, -1.26370519e-01f, -8.62696394e-02f, -1.33493111e-01f, -8.91993381e-03f, -5.07182926e-02f, 5.33174314e-02f, -3.07921413e-02f,
  -4.49868999e-02f, 9.69748124e-02f, 2.33535245e-02f, 4.36915159e-02f, -7.07905516e-02f, -1.12108983e-01f, 1.82613935e-02f, -5.77959456e-02f, -9.96468663e-02f, -2.02438124e-02f,
  1.42647371e-01f, 1.91041976e-01f, 2.36551851e-01f, 1.91392735e-01f, -9.30392742e-02f, -2.34678432e-01f, -1.72819361e-01f, 1.45071507e-01f, -7.72213787e-02f, -9.46173724e-03f,
  4.06654328e-02f, 2.00963095e-01f, -1.01280799e-02f, 1.97238207e-01f, -2.11949483e-01f, -2.19954029e-02f, -1.38529614e-01f, -1.07038744e-01f, -3.08213029e-02f, 5.93211390e-02f,
  1.50576048e-02f, 1.64268643e-01f, 2.08101928e-01f, 1.54410064e-01f, 4.44884114e-02f, 1.74412310e-01f, 7.45751858e-02f, -3.78893726e-02f, 3.60463038e-02f, -8.79856870e-02f,
  -1.75397500e-01f, 2.18275681e-01f, 2.73216348e-02f, -2.60183178e-02f, -4.55751345e-02f, 2.16604471e-02f, 2.26115119e-02f, 7.89985433e-02f, -5.67895249e-02f, 1.70587916e-02f,
  -1.05329923e-01f, -1.61185954e-03f, 9.46882069e-02f, -4.43673283e-02f, 3.59696373e-02f, -1.26291113e-02f, -1.94984619e-02f, 5.85748367e-02f, 3.35784927e-02f, -1.76617056e-02f,
  1.75145492e-01f, 5.12703471e-02f, -1.71942953e-02f, -1.58711821e-01f, 4.65291180e-02f, -4.48506512e-02f, -4.59947921e-02f, -1.16434380e-01f, 9.67991538e-03f, -9.02856365e-02f,
  -3.15896608e-02f, 7.78040811e-02f, 1.18467491e-02f, -4.96493001e-03f, 1.12938605e-01f, 7.36843154e-04f, 6.96662664e-02f, -4.89979051e-02f, -1.02840476e-01f, -9.30878967e-02f,
  -5.77566363e-02f, 9.96454805e-03f, -3.12136747e-02f, 3.74290943e-02f, -1.05402611e-01f, 1.08733624e-01f, -1.38769960e-02f, -8.13103244e-02f, -4.27057631e-02f, 7.61682615e-02f,
  -6.22603893e-02f, -1.03411078e-01f, -1.41749140e-02f, 2.98846271e-02f, -1.00760736e-01f, -1.38514256e-02f, -6.65576607e-02f, 1.82845872e-02f, 2.41338611e-02f, -2.68855393e-02f,
  -6.91426843e-02f, 1.31880462e-01f, -4.21290696e-02f, -1.06509596e-01f, 6.81477487e-02f, 4.55186330e-02f, -3.46355848e-02f, -6.10317737e-02f, 1.40690684e-01f, -2.59356815e-02f,
  -1.50777698e-01f, 1.28111513e-02f, -1.04672521e-01f, 3.32291313e-02f, 4.37914161e-04f, 1.38641121e-02f, 8.86571705e-02f, -9.51813441e-03f, -1.60297416e-02f, 2.42692158e-02f,
  1.73288450e-01f, 2.20273826e-02f, 3.73952501e-02f, -7.24926814e-02f, -6.66731298e-02f, -4.87195365e-02f, 2.63284277e-02f, -4.23535928e-02f, 7.12944567e-02f, -1.68878790e-02f,
  1.10546343e-01f, -3.20124447e-01f, -2.63912618e-01f, -2.98711006e-02f, 2.19983861e-01f, 2.09647104e-01f, -2.58169454e-02f, 3.74989468e-03f, -1.99625060e-01f, -6.47104308e-02f,
  4.52875644e-02f, -7.83187374e-02f, -1.90179139e-01f, -1.68255232e-02f, 2.22459242e-01f, -2.54007518e-01f, 1.28542632e-01f, 2.66328454e-02f, -2.34708980e-01f, -3.87922442e-03f,
  -6.23074211e-02f, 2.03887090e-01f, -1.40797466e-01f, 1.11444809e-01f, 9.92891788e-02f, -5.50288707e-02f, 1.32522658e-01f, -3.55413137e-03f, 1.64807081e-01f, 1.63025528e-01f,
  -2.18318848e-04f, -1.01984218e-01f, 3.28510590e-02f, 9.48844198e-03f, 1.05228551e-01f, 1.67626292e-01f, 1.73282340e-01f, 5.27396202e-02f, 1.36680491e-02f, -5.72613366e-02f,
  9.44804959e-03f, 1.68898907e-02f, -5.36618717e-02f, 5.96381836e-02f, -3.53238136e-02f, 4.98891957e-02f, -6.60117716e-02f, -8.79731625e-02f, -7.82893151e-02f, -7.50971437e-02f,
  -1.71844494e-02f, 6.75632581e-02f, -9.13030133e-02f, 5.51128201e-03f, -7.37840384e-02f, 2.38111196e-03f, -4.81244503e-03f, -6.53528646e-02f, -8.92900527e-02f, -2.04717554e-03f,
  1.02973267e-01f, 8.20979029e-02f, -2.07923185e-02f, -4.64219972e-02f, -1.11558646e-01f, -2.05717348e-02f, 2.16581337e-02f, -5.13820685e-02f, -6.43222034e-02f, -8.31410512e-02f,
  2.74815597e-02f, 7.69392913e-03f, -5.13573885e-02f, 3.80246602e-02f, 1.60210505e-02f, -6.69121444e-02f, 1.09020747e-01f, 3.16407755e-02f, 3.66398599e-03f, -5.64380772e-02f,
  -7.37110665e-03f, -1.51429484e-02f, 7.39405900e-02f, -6.18095556e-03f, -4.15840857e-02f, 8.90535787e-02f, -3.72316241e-02f, -5.54986447e-02f, -1.09698288e-01f, 8.11843425e-02f,
  1.99928079e-02f, -1.58635691e-01f, -4.74066846e-02f, 3.36696021e-02f, -1.18298158e-01f, 1.17575943e-01f, -6.06340133e-02f, 2.36098263e-02f, 2.61912774e-02f, -2.59171668e-02f,
  1.81825787e-01f, 1.31322622e-01f, -3.61893550e-02f, -1.87380560e-04f, 3.86473164e-02f, -4.29781303e-02f, 2.91734356e-02f, 1.09819420e-01f, 1.22358352e-02f, -4.65738922e-02f,
  -6.11902168e-03f, -5.72980419e-02f, -2.28126869e-02f, 5.88375218e-02f, -7.28319511e-02f, 3.85466740e-02f, 1.08725829e-02f, 7.47718140e-02f, 2.78465990e-02f, -8.23801011e-02f,
  -6.51166663e-02f, 2.62306839e-01f, 8.60152543e-02f, 1.33115217e-01f, -7.99461640e-03f, 3.63052785e-01f, 1.96559861e-01f, 3.75092179e-02f, 3.23106557e-01f, 1.05655961e-01f,
  -1.19590111e-01f, 3.53068076e-02f, 1.38304457e-01f, 3.20824571e-02f, 2.12325007e-01f, 1.95405036e-01f, 2.52622932e-01f, 1.45585790e-01f, 2.04029113e-01f, 6.89549930e-03f,
  4.39230613e-02f, -2.62498166e-02f, -2.30143309e-01f, -1.20950595e-01f, -1.68824643e-01f, -1.64025635e-01f, -2.39397123e-01f, -5.22559285e-02f, -7.97091350e-02f, 1.16165884e-01f,
  7.12287554e-04f, 1.45562580e-02f, -3.06962226e-02f, -1.13170017e-02f, 1.04817986e-01f, -7.71707222e-02f, 1.17285792e-02f, 4.47032154e-02f, 4.57472214e-03f, 7.88173527e-02f,
  4.74221520e-02f, -8.15647305e-04f, 1.08335152e-01f, -4.69612852e-02f, 2.31540320e-03f, -1.80334244e-02f, -1.26098935e-02f, -8.42723325e-02f, -9.52956229e-02f, -5.94836697e-02f,
  -1.03137612e-01f, 3.52605507e-02f, 4.88659891e-04f, 7.32150301e-02f, 3.55759077e-02f, 1.05311424e-01f, 3.63383740e-02f, -5.65898232e-02f, -4.86435145e-02f, 8.87099728e-02f,
  2.59844828e-02f, 1.38060153e-01f, -5.99363707e-02f, -3.78367230e-02f, 5.65101802e-02f, -8.02855566e-02f, -3.34087275e-02f, -1.01771355e-02f, -2.85645127e-02f, 2.01969258e-02f,
  -3.24683450e-02f, 1.45025216e-02f, -6.08724542e-03f, -1.10984994e-02f, 5.42399250e-02f, -6.97204247e-02f, -7.86888078e-02f, 5.65218776e-02f, -9.14465822e-03f, -7.10734800e-02f,
  -2.64700893e-02f, 8.27456191e-02f, -2.69570518e-02f, -3.48703489e-02f, 7.11344406e-02f, 2.29636095e-02f, -2.24799607e-02f, -8.81129131e-02f, -1.58856101e-02f, -5.11419885e-02f,
  7.04383999e-02f, 3.09443265e-01f, 3.27437669e-02f, 1.13639802e-01f, 5.93443662e-02f, -6.14283681e-02f, 6.65890723e-02f, 2.94827167e-02f, 5.81541285e-02f, 3.83290136e-03f,
  -4.37385440e-02f, 6.40054122e-02f, 2.01101806e-02f, -3.34083140e-02f, 1.92497764e-02f, -7.54404217e-02f, 1.32196664e-03f, 9.46986377e-02f, 9.08389762e-02f, 5.81318550e-02f,
  -5.54479212e-02f, 1.23533934e-01f, -9.95988213e-03f, -5.69200255e-02f, 1.59539375e-02f, -8.46483558e-03f, 3.08258142e-02f, 6.22367188e-02f, 4.29904535e-02f, 7.95352980e-02f,
  5.30899502e-02f, -4.08915803e-02f, 2.46410698e-01f, 2.58938950e-02f, -4.08669412e-02f, 6.33805320e-02f, -6.37454391e-02f, -1.11595467e-01f, 1.21208191e-01f, -1.05675437e-01f,
  -2.31324479e-01f, 2.37476036e-01f, 9.34355557e-02f, -6.05719388e-02f, 1.83055043e-01f, 5.37785776e-02f, -2.19520014e-02f, -3.58343124e-02f, 1.66239180e-02f, -1.87929779e-01f,
  -8.70769992e-02f, -2.30402976e-01f, -5.62176369e-02f, -2.35981002e-01f, 1.13254813e-02f, -4.67603207e-02f, -6.11071922e-02f, 2.41692718e-02f, -1.78624347e-01f, 1.46738123e-02f,
  -1.57244489e-01f, -1.13381356e-01f, -3.59157659e-02f, -5.84481023e-02f, -8.30157753e-03f, 5.49983494e-02f, 4.01708819e-02f, 1.28406025e-02f, 3.52725126e-02f, 8.61627832e-02f,
  -1.62636396e-02f, -9.67453495e-02f, -1.26777843e-01f, 1.06753469e-01f, -8.88484996e-03f, 1.39664523e-02f, -1.21285152e-02f, -1.18107021e-01f, 2.25883964e-02f, -5.29748760e-03f,
  -4.87224236e-02f, 3.73208001e-02f, -1.09041668e-02f, -8.91156495e-03f, -4.52765189e-02f, -1.11757226e-01f, 1.29266471e-01f, -3.02421506e-02f, 2.51319613e-02f, 8.81427899e-02f,
  -1.13698244e-02f, 7.04718307e-02f, -6.38660342e-02f, -3.20118293e-02f, 1.21923853e-02f, -7.39608034e-02f, -7.27586448e-02f, 1.32583566e-02f, -3.66796218e-02f, -5.48853837e-02f,
  7.86828548e-02f, 4.19287011e-02f, 1.14279613e-01f, 6.03761636e-02f, -1.82422455e-02f, -3.55095789e-02f, -1.02145366e-01f, 1.36623234e-01f, -7.90970773e-03f, -1.04383431e-01f,
  -9.40996036e-02f, -8.76816809e-02f, 4.82340604e-02f, 6.24813288e-02f, -2.57206988e-02f, -4.46624234e-02f, -1.26075849e-01f, 4.02923077e-02f, -5.94089776e-02f, 1.74563800e-04f,
  6.14860002e-03f, -8.60516727e-02f, -6.36436045e-02f, -1.42169669e-01f, 4.05426063e-02f, -1.07142396e-01f, -1.32983923e-02f, 1.21999374e-02f, 1.79679901e-03f, -8.78545791e-02f,
  -2.75085960e-02f, 1.01693392e-01f, -5.66439591e-02f, 6.68598805e-03f, -1.25834718e-01f, 2.97316890e-02f, 4.59160283e-02f, -9.54904780e-02f, -9.06149298e-02f, -7.94776678e-02f,
  -5.08617125e-02f, -5.61848842e-02f, 4.78690565e-02f, 6.34485297e-03f, 1.69860031e-02f, -5.66795915e-02f, 7.69497678e-02f, 6.88074753e-02f, 2.08568592e-02f, -4.10036072e-02f,
  2.54274141e-02f, 2.75367290e-01f, 2.54547626e-01f, 2.99560457e-01f, -1.09519310e-01f, -3.56849909e-01f, -2.86737502e-01f, -5.86256795e-02f, 3.74441408e-02f, -7.26350471e-02f,
  2.37690215e-03f, 1.67492017e-01f, 1.27820652e-02f, 1.61166608e-01f, 2.09964722e-01f, -4.29558828e-02f, -1.85383298e-02f, -9.98943150e-02f, 3.45285907e-02f, 4.96475287e-02f,
  2.50575274e-01f, 4.96660126e-03f, 2.99590021e-01f, 7.25049227e-02f, -5.68484701e-03f, 2.05439046e-01f, 1.91088036e-01f, -7.93745276e-03f, 2.45332360e-01f, 1.69155467e-02f,
  -3.16672847e-02f, 1.85039025e-02f, 3.95766012e-02f, 1.98312420e-02f, 3.72446179e-02f, -3.10154576e-02f, 3.21952775e-02f, 8.50190148e-02f, 5.70399873e-02f, 6.67353421e-02f,
  -5.39845340e-02f, 9.20995027e-02f, 7.61554344e-04f, 1.19208425e-01f, -5.42535856e-02f, -1.07114185e-02f, 6.00847602e-02f, -1.89693272e-02f, -7.78980330e-02f, -8.31856504e-02f,
  4.25306102e-03f, 6.72488613e-03f, -6.60479888e-02f, 1.58339664e-02f, 3.90550569e-02f, -1.38467010e-02f, 3.64459269e-02f, 6.32060543e-02f, 4.82375845e-02f, 4.96583804e-02f,
  -8.10070112e-02f, 1.89287234e-02f, -3.04746199e-02f, 3.54548804e-02f, 5.84041774e-02f, -2.02184427e-03f, -1.80531349e-02f, -7.08979145e-02f, 2.65566036e-02f, 1.26560986e-01f,
  2.97323018e-02f, -1.49757331e-02f, -5.26381545e-02f, -5.56246527e-02f, 6.39560893e-02f, -1.49783837e-02f, 3.58682089e-02f, 5.49963303e-02f, -2.75257174e-02f, -4.68456149e-02f,
  -4.60116528e-02f, 7.41147846e-02f, 7.88364187e-02f, -3.14165018e-02f, -8.60337764e-02f, 1.38733452e-02f, 3.01634502e-02f, -2.67659090e-02f, -5.47331832e-02f, -5.12225069e-02f,
  -3.61407474e-02f, 2.26143181e-01f, 7.35175237e-02f, -1.00375473e-01f, 1.15067903e-02f, 1.47099253e-02f, 6.38076058e-03f, -1.12383217e-02f, 1.52181447e-01f, 4.20950018e-02f,
  -1.35995923e-02f, -1.06532890e-02f, 1.65843982e-02f, 1.43617531e-02f, -3.47192734e-02f, 5.67421056e-02f, 4.47127335e-02f, 1.23929270e-01f, -4.46053371e-02f, 5.00012673e-02f,
  -2.76724566e-02f, -1.01224750e-01f, 2.31239516e-02f, 7.42839649e-03f, 2.32548211e-02f, 1.15073673e-01f, -2.92200269e-03f, 5.21249846e-02f, 1.40258484e-02f, 7.60820433e-02f,
  -4.95385706e-01f, 8.64004418e-02f, 1.21279493e-01f, -1.87965900e-01f, -2.71659255e-01f, 1.29510328e-01f, 1.96913332e-01f, -7.32999668e-02f, -1.14626929e-01f, 1.06220663e-01f,
  -6.17308579e-02f, -1.65411904e-01f, 2.84715384e-01f, -7.92865455e-03f, 1.30493745e-01f, 2.18889907e-01f, 1.11031063e-01f, 6.32189512e-02f, -6.59725890e-02f, -1.91764086e-01f,
  -6.15556575e-02f, -5.69115765e-02f, 1.85288772e-01f, -8.90325531e-02f, -2.11839348e-01f, -2.17009425e-01f, -1.65451139e-01f, -8.50412175e-02f, -6.67676106e-02f, -1.47773847e-01f,
  -1.86288804e-01f, -1.33948326e-01f, -1.36545956e-01f, 5.82158566e-02f, 3.47442254e-02f, 2.92306654e-02f, 1.83972083e-02f, -9.38335359e-02f, -1.27972752e-01f, 4.73573841e-02f,
  6.63590664e-03f, -2.09731497e-02f, -1.68282669e-02f, -1.88370198e-02f, -2.81557050e-02f, 2.06616819e-02f, -1.53559437e-02f, 1.46923631e-01f, 3.34094241e-02f, -2.67621148e-02f,
  -1.56891216e-02f, 4.35249433e-02f, -1.19484030e-01f, 5.07181063e-02f, -1.04886026e-03f, -5.11554405e-02f, 1.31588072e-01f, -6.01386987e-02f, -2.72756144e-02f, -6.15269989e-02f,
  5.22571951e-02f, 8.24581832e-02f, -1.19218484e-01f, -2.63256337e-02f, -2.08839085e-02f, 7.60919228e-03f, -4.17822897e-02f, -5.62538914e-02f, 3.11453789e-02f, -8.27868730e-02f,
  -6.70178011e-02f, 4.48243730e-02f, -4.51379307e-02f, 2.08724570e-02f, -3.48055474e-02f, 3.26994620e-02f, 5.61371958e-03f, -1.26422672e-02f, 5.96612059e-02f, 3.24312225e-02f,
  -6.99926540e-02f, -5.49456254e-02f, -2.77166371e-04f, 1.00749552e-01f, -2.00563725e-02f, -2.67613642e-02f, -4.65406440e-02f, 6.68388158e-02f, 9.16165411e-02f, 1.04894079e-01f,
  -3.21700573e-01f, -3.01775634e-01f, -3.69467884e-02f, 5.01869842e-02f, -1.15769483e-01f, -7.49831200e-02f, -1.38621954e-02f, -2.33066455e-02f, -5.64871989e-02f, 3.66585702e-02f,
  -2.55625248e-02f, 3.89857590e-02f, -1.26751766e-01f, -8.86766240e-02f, 7.34594986e-02f, 5.36275692e-02f, 1.32014742e-02f, 6.02654833e-03f, -1.23220608e-01f, 9.96538252e-03f,
  1.23881668e-01f, -6.15510345e-02f, 5.29244952e-02f, -8.98571126e-03f, 7.53693432e-02f, -6.03619926e-02f, -4.96608429e-02f, -4.27683769e-03f, -1.07274884e-02f, -3.20203532e-03f,
  -3.02168131e-01f, 2.02096686e-01f, 2.19046339e-01f, -1.69562429e-01f, 1.02934040e-01f, 2.41354123e-01f, 1.43779874e-01f, 1.45188347e-01f, -5.69212139e-02f, -2.52985150e-01f,
  -1.25392243e-01f, -9.55899581e-02f, -4.67952639e-02f, -9.19191241e-02f, 1.85405016e-01f, 4.25132662e-02f, 4.95160148e-02f, -2.02914089e-01f, 1.81808770e-01f, 3.29759680e-02f,
  4.41794619e-02f, -1.37241706e-01f, 2.55026430e-01f, 6.44835755e-02f, -9.76845808e-03f, -2.50250157e-02f, -2.00609103e-01f, 8.68673474e-02f, -1.10811934e-01f, 1.20414987e-01f,
  -6.60810694e-02f, -1.01459622e-01f, -7.94539675e-02f, -8.77822340e-02f, 4.50221635e-03f, -9.35596451e-02f, 5.02240583e-02f, 3.66463363e-02f, -3.00930608e-02f, -5.45388535e-02f,
  -1.24547623e-01f, -7.65589997e-04f, -5.13422526e-02f, 9.91608202e-02f, -3.71605605e-02f, 6.50881007e-02f, 1.48353711e-01f, 4.53684628e-02f, 7.18280897e-02f, 1.14593342e-01f,
  7.96959326e-02f, 1.04309842e-01f, 5.34690507e-02f, -3.70573476e-02f, 4.95756119e-02f, 4.81901914e-02f, -2.76934374e-02f, 3.38107310e-02f, 9.52985957e-02f, -2.94611026e-02f,
  9.41888615e-03f, -1.52984476e-02f, 4.54685278e-02f, -2.50701830e-02f, -8.63095652e-03f, -1.05790205e-01f, 5.17143980e-02f, -1.08533934e-01f, -6.53410479e-02f, 7.96551183e-02f,
  -8.35212991e-02f, -9.54030082e-02f, 5.06671239e-03f, -7.13041574e-02f, -1.13647515e-02f, -1.38281271e-01f, -1.17028214e-03f, 2.42020637e-02f, -4.34358045e-02f, 3.90431099e-02f,
  -5.11810780e-02f, 1.73103679e-02f, -2.14071181e-02f, -9.23848301e-02f, 6.35557249e-02f, 1.15679177e-02f, 2.65638232e-02f, 6.15317412e-02f, -5.35961315e-02f, 3.70960459e-02f,
  -9.51367319e-02f, -1.10144138e-01f, 5.24872579e-02f, -5.64086922e-02f, 5.33740856e-02f, 6.30953582e-03f, -1.60275418e-02f, 2.27437839e-02f, 2.53681801e-02f, -9.03968215e-02f,
  -4.33744453e-02f, -9.45871696e-02f, 6.06324896e-02f, 4.73771198e-03f, 1.79569758e-02f, -2.80703343e-02f, 2.23044213e-02f, -1.25024810e-01f, 3.09166079e-03f, -6.10759109e-03f,
  8.67898867e-04f, -4.41021957e-02f, -1.79197527e-02f, -3.91189642e-02f, -1.04016505e-01f, -9.75980610e-02f, -7.91216791e-02f, -2.22899802e-02f, 3.40506621e-02f, 6.51448742e-02f,
  2.80281276e-01f, -2.76769310e-01f, -3.41574818e-01f, -1.94123350e-02f, 1.32503465e-01f, 1.64741710e-01f, -1.63009405e-01f, -9.07478631e-02f, -7.54560232e-02f, -2.46430740e-01f,
  -6.14628941e-02f, -1.85088679e-01f, -3.14072400e-01f, 2.22749263e-01f, 3.43550026e-01f, -1.53465882e-01f, 2.56272167e-01f, 3.20975780e-02f, -8.33806843e-02f, -1.87394693e-01f,
  8.56553838e-02f, 2.24767372e-01f, -1.11648574e-01f, 9.04486850e-02f, 1.29435599e-01f, -9.18160155e-02f, 9.22891796e-02f, -2.14416131e-01f, 1.59181535e-01f, 1.24361768e-01f,
  2.78465319e-02f, -9.12823156e-02f, -1.27960652e-01f, -2.17656586e-02f, -8.20116624e-02f, 7.68419877e-02f, -4.21485379e-02f, 1.21201307e-01f, -2.27043815e-02f, -9.86128487e-03f,
  5.03763482e-02f, 1.21448942e-01f, 6.30716085e-02f, 3.96378152e-02f, 2.54962388e-02f, -2.15432467e-03f, -8.78479406e-02f, -7.81863183e-02f, 1.62252830e-03f, -2.82959454e-02f,
  -1.00806929e-01f, 2.75310073e-02f, 2.85436269e-02f, -9.96236429e-02f, -6.90624937e-02f, -3.14422511e-02f, -1.45088620e-02f, -8.66283178e-02f, 2.80096792e-02f, 4.09015454e-02f,
  -3.62810940e-02f, 1.94694996e-02f, 7.84638897e-03f, 9.73919481e-02f, 5.49450554e-02f, -4.62488867e-02f, 3.29213031e-02f, -4.78177778e-02f, -1.49594061e-02f, 2.81177927e-03f,
  -5.67070656e-02f, -3.28601263e-02f, 7.97718689e-02f, 3.08711100e-02f, 6.71409592e-02f, 5.92866763e-02f, 2.67986837e-03f, 6.55066445e-02f, -9.96217877e-02f, 2.55827866e-02f,
  1.67933516e-02f, 3.70981805e-02f, -9.52359289e-02f, 9.36720148e-02f, 3.02789230e-02f, -5.10914624e-02f, 6.87865168e-02f, 1.76952295e-02f, -6.14921600e-02f, 9.04472021e-04f,
  2.13247980e-03f, -2.08633274e-01f, -9.59727839e-02f, 6.07325472e-02f, 1.32258795e-02f, 1.96309574e-02f, -1.59088187e-02f, 2.98173111e-02f, -1.02662608e-01f, -1.50068551e-02f,
  -3.33420075e-02f, -4.51256186e-02f, 1.07209131e-01f, -7.85608664e-02f, 9.17584822e-02f, -9.81325209e-02f, -3.67553793e-02f, -5.43125346e-02f, 1.78092625e-03f, -3.39784473e-02f,
  2.26321127e-02f, 2.69530304e-02f, 3.12761180e-02f, -1.30178377e-01f, 7.45625347e-02f, -2.73840018e-02f, 3.43813822e-02f, -9.20933709e-02f, 8.10227469e-02f, -1.39588816e-02f,
  1.74583808e-01f, -1.02584556e-01f, -2.25715011e-01f, -2.03454956e-01f, -2.23131761e-01f, -2.97131449e-01f, -2.11487606e-01f, -1.49378896e-01f, 6.39640540e-02f, 8.85168463e-03f,
  -1.74790800e-01f, 1.93345606e-01f, 1.75962076e-01f, -2.26591989e-01f, 1.58765703e-01f, 3.25997472e-01f, -1.70789778e-01f, -5.03848121e-02f, -6.13596402e-02f, -2.21002307e-02f,
  2.80391388e-02f, 1.91533915e-03f, -2.42156871e-02f, -9.63601917e-02f, -3.17538261e-01f, -1.88316807e-01f, 9.40687861e-03f, -2.11429268e-01f, -2.72304952e-01f, -1.04810841e-01f,
  -7.10763782e-02f, 2.02718507e-02f, 7.26039661e-03f, 2.00031307e-02f, -8.50813650e-03f, -5.44257537e-02f, -2.17890181e-02f, -1.03295229e-01f, 3.58514935e-02f, 4.81823534e-02f,
  1.42784953e-01f, 1.19102851e-01f, 2.57129408e-02f, 1.09091622e-03f, 1.40546896e-02f, -7.13959411e-02f, 4.90239821e-02f, -1.72595344e-02f, 7.24475533e-02f, -4.71724980e-02f,
  -9.07062069e-02f, -3.90146635e-02f, -1.32014081e-01f, 1.08610988e-01f, 2.17168983e-02f, -9.49843079e-02f, 2.40187440e-02f, 3.75973098e-02f, 8.44444036e-02f, 5.75453043e-02f,
  -3.27660330e-02f, -7.69560458e-03f, -4.59449850e-02f, -7.43954554e-02f, 1.55885834e-02f, -7.36805648e-02f, 3.99362519e-02f, 1.19462581e-02f, -2.89073307e-02f, -3.05739753e-02f,
  5.54757426e-03f, -3.06207892e-02f, -4.30731587e-02f, -2.42981892e-02f, -1.62375607e-02f, 8.44918713e-02f, -7.78084795e-04f, -2.45917924e-02f, -1.32688850e-01f, -4.01278287e-02f,
  -1.65592246e-02f, -4.47828919e-02f, -3.58843096e-02f, -4.19894196e-02f, -6.51490875e-03f, 1.56622604e-02f, -1.76586453e-02f, 1.28959371e-02f, -4.74396273e-02f, -2.96170916e-03f,
  -1.02487698e-01f, -7.42760971e-02f, -4.54947799e-02f, 1.31029442e-01f, 1.41365258e-02f, -6.37088045e-02f, -5.31289987e-02f, -9.02096275e-03f, 5.15181646e-02f, 7.98497647e-02f,
  2.48861569e-03f, -1.86545365e-02f, -7.73316547e-02f, -7.33640343e-02f, 4.43149507e-02f, 3.03554982e-02f, 6.65814942e-03f, 5.76975867e-02f, -2.20411792e-02f, -2.42589843e-02f,
  8.07569027e-02f, 4.55695502e-02f, 1.06220432e-01f, 4.41621728e-02f, 3.50731388e-02f, -4.94369231e-02f, -3.24694589e-02f, -5.38673904e-03f, 4.93990183e-02f, -2.56456342e-02f,
  -2.24267498e-01f, -2.53328323e-01f, 1.22496694e-01f, 9.23749059e-03f, 2.29470059e-02f, 2.00732425e-01f, 1.18214160e-01f, -1.89755917e-01f, -2.39440188e-01f, -1.72140270e-01f,
  -7.15360641e-02f, 3.79717685e-02f, 1.94533654e-02f, 1.10573925e-01f, 2.30551064e-01f, -3.17447912e-03f, -4.76787575e-02f, -4.37149666e-02f, -5.78692742e-02f, -1.35946676e-01f,
  -2.65869908e-02f, 1.36270061e-01f, 2.67423421e-01f, 2.64039338e-02f, 6.07003160e-02f, 5.88732474e-02f, 1.55110061e-02f, 1.06910132e-01f, 1.79955084e-02f, 1.14615478e-01f,
  1.20197153e-02f, -1.40663669e-01f, 7.47915804e-02f, 4.70583402e-02f, -4.26027030e-02f, -1.12247355e-01f, 1.41048670e-01f, 1.26745135e-01f, -2.29294319e-02f, -7.78058022e-02f,
  -3.70339677e-02f, -2.64988244e-02f, 8.32145885e-02f, 6.59523951e-03f, -5.81224672e-02f, 5.23168519e-02f, 6.01027086e-02f, -6.33569658e-02f, 3.33060995e-02f, -1.69314146e-02f,
  -1.43477358e-02f, 9.71522853e-02f, -1.07002184e-01f, 4.54952642e-02f, 9.02673155e-02f, 2.44862866e-02f, 9.27485153e-02f, 1.37716785e-01f, 2.17166562e-02f, 9.53603759e-02f,
  6.03981912e-02f, 4.05004695e-02f, 8.18124190e-02f, 6.39149547e-03f, -6.27776161e-02f, -2.09575556e-02f, 3.47037458e-05f, -7.78914765e-02f, -1.10848248e-01f, -7.41120428e-02f,
  -1.89105282e-03f, 6.45674691e-02f, -1.61145087e-02f, -2.09351201e-02f, 5.00976220e-02f, -2.39365399e-02f, 3.21858227e-02f, 2.16874182e-02f, -1.72712728e-02f, 3.57109159e-02f,
  -5.48716076e-02f, 8.82797837e-02f, 3.94413173e-02f, 8.93092081e-02f, 1.10974163e-01f, 7.62311667e-02f, -5.30576035e-02f, -4.64939550e-02f, -6.53161481e-02f, 1.61496792e-02f,
  -5.72346821e-02f, -1.98044971e-01f, 4.44154143e-02f, -5.14521170e-03f, 6.39665052e-02f, -1.62645895e-02f, 1.21667683e-01f, -3.83715741e-02f, -4.62029427e-02f, -3.66991460e-02f,
  -7.91660920e-02f, 4.24050577e-02f, -6.37670904e-02f, 8.21190104e-02f, 1.20004348e-01f, 2.85692867e-02f, -3.82597297e-02f, -9.87294912e-02f, -1.44583089e-02f, -8.85611176e-02f,
  7.61533007e-02f, -2.53172256e-02f, 4.14906330e-02f, 7.34153613e-02f, 1.07640110e-01f, -7.95826390e-02f, 2.23031547e-02f, 3.90666015e-02f, 8.90173465e-02f, -1.69027653e-02f,
  -8.15167725e-02f, 6.19288869e-02f, 3.74871157e-02f, -1.16818003e-01f, -8.05486292e-02f, -2.47264922e-01f, -1.36597171e-01f, -9.82212485e-04f, -7.47548863e-02f, -1.45569950e-01f,
  -2.37211853e-01f, 1.70734718e-01f, -1.54099772e-02f, -1.96180493e-01f, -1.02298640e-01f, 4.51108180e-02f, -3.04601759e-01f, 1.46307237e-02f, 1.75790582e-02f, -1.47968531e-01f,
  -7.87879806e-03f, -2.38681495e-01f, -6.60816580e-02f, 2.44482756e-02f, -2.15833753e-01f, -6.23754300e-02f, -3.79451714e-03f, 3.65015045e-02f, -1.35594040e-01f, -1.14322171e-01f,
  -1.26956284e-01f, -1.63232014e-02f, 4.99738939e-02f, -6.40518516e-02f, -9.10535753e-02f, 7.47845322e-02f, 1.12414584e-02f, 1.03607826e-01f, 2.42100637e-02f, 6.54416531e-03f,
  9.15847067e-03f, 9.59007442e-02f, 3.87868062e-02f, 7.97478408e-02f, 5.22073507e-02f, 3.13735232e-02f, 1.08780347e-01f, 8.68723541e-02f, 4.30400558e-02f, 1.33652374e-01f,
  1.04194805e-01f, 1.01599775e-01f, 1.02035046e-01f, -9.89569947e-02f, -3.28626260e-02f, -9.28684548e-02f, -1.16005287e-01f, -3.09498087e-02f, -7.94466138e-02f, 3.25013651e-03f,
  -3.70540507e-02f, 6.85375975e-03f, -1.35421127e-01f, 8.77048597e-02f, -9.09936875e-02f, 3.53984870e-02f, -2.58376636e-02f, 3.78983915e-02f, 1.12101980e-01f, 3.96646112e-02f,
  -4.27263193e-02f, -1.88663509e-02f, -1.03494957e-01f, -3.54483835e-02f, 1.68486238e-02f, -1.39555312e-04f, -7.00016692e-02f, -2.82062981e-02f, -2.74663921e-02f, -3.90808238e-03f,
  4.35270779e-02f, 5.42634390e-02f, 7.46978819e-02f, 6.17981032e-02f, -1.99520346e-02f, -2.72508860e-02f, -9.68187954e-03f, 1.09818764e-01f, -1.00644127e-01f, 1.47931548e-02f,
  -2.50300318e-02f, -1.26059771e-01f, -3.57970893e-02f, 5.48758246e-02f, -8.77148062e-02f, -5.40165268e-02f, -8.30273107e-02f, 1.51535450e-02f, -6.96003884e-02f, -6.23916052e-02f,
  6.97664768e-02f, -1.14101805e-02f, 2.45644487e-02f, -2.64085997e-02f, 1.32204652e-01f, -4.67702448e-02f, -3.44795436e-02f, 1.15548864e-01f, 2.58577615e-02f, 5.47261946e-02f,
  9.25792679e-02f, -3.04449052e-02f, 4.71199341e-02f, -3.81402411e-02f, 4.13424633e-02f, -4.84362990e-03f, 7.92832449e-02f, -6.09203503e-02f, 7.22979242e-03f, 5.25622889e-02f,
  -1.37618572e-01f, -2.06181929e-01f, -3.77401039e-02f, -1.44874334e-01f, 1.03536524e-01f, 4.71000671e-02f, -1.35726348e-01f, -2.43591130e-01f, -1.48764938e-01f, -1.83797434e-01f,
  -1.40178934e-01f, 4.76795323e-02f, 1.37584865e-01f, -2.92775393e-01f, 1.94955438e-01f, 1.17162764e-01f, -2.04267353e-01f, -4.02515717e-02f, 1.58290237e-01f, -2.59584840e-03f,
  -1.95235703e-02f, -1.28710940e-01f, 6.19752221e-02f, 2.39084620e-04f, -9.06466097e-02f, -1.31771326e-01f, 3.90604064e-02f, 9.80808884e-02f, -1.38835117e-01f, 3.60477231e-02f,
  -3.37943155e-03f, -2.21122921e-01f, -7.69889653e-02f, -7.45012537e-02f, -7.17288181e-02f, -1.23196438e-01f, -1.26965502e-02f, 9.31023583e-02f, -2.91965815e-04f, 2.65779789e-03f,
  -4.94591855e-02f, -1.22055635e-02f, 3.20897624e-02f, -2.10460667e-02f, -9.22776982e-02f, -6.51745796e-02f, 4.23855102e-03f, 1.74042843e-02f, -8.06412399e-02f, 2.18839701e-02f,
  7.72541612e-02f, -2.13422198e-02f, 6.25871792e-02f, -2.05472521e-02f, 5.19852154e-02f, -1.51865808e-02f, 9.72078368e-02f, 6.88371435e-02f, -1.53128188e-02f, 8.09012726e-02f,
  1.94310527e-02f, -4.59243506e-02f, -1.62872169e-02f, -4.86465394e-02f, 1.61539968e-02f, -1.94827840e-02f, -4.15412486e-02f, 1.46578904e-03f, 7.65819848e-02f, 1.52856472e-03f,
  -8.02615285e-02f, -6.98793009e-02f, 9.75005608e-03f, 1.90292241e-03f, -7.29254857e-02f, -1.45089743e-03f, 6.03585765e-02f, 5.17912954e-02f, 7.97027946e-02f, 6.78043887e-02f,
  -4.34825532e-02f, 2.58126459e-03f, -5.41889332e-02f, -6.44608214e-02f, -9.39855576e-02f, 4.12639789e-02f, -1.77052524e-02f, -3.53824235e-02f, 1.13811754e-01f, 1.17217794e-01f,
  -3.17854099e-02f, -2.33798802e-01f, -7.09020440e-03f, 1.47414888e-04f, -9.46813263e-03f, -5.91036603e-02f, 8.66409391e-03f, -2.85853874e-02f, 3.09047867e-02f, -5.11249714e-02f,
  -1.98374949e-02f, -3.76674463e-03f, -8.17521065e-02f, 3.28447893e-02f, 9.14985016e-02f, -8.04114342e-02f, 1.05837071e-02f, 3.17836404e-02f, -9.36522856e-02f, -4.19514440e-03f,
  8.31804574e-02f, -3.60483043e-02f, -3.31063871e-03f, 6.31857589e-02f, -9.58590284e-02f, 8.59441049e-03f, -1.98142827e-02f, 2.15763170e-02f, 5.27194664e-02f, -2.88278256e-02f,
  2.55031556e-01f, -3.03667605e-01f, 1.33652464e-01f, 2.67181844e-01f, 1.49918824e-01f, -3.70651367e-03f, 2.02916622e-01f, -8.56554955e-02f, -3.47844437e-02f, -2.71550208e-01f,
  2.63121501e-02f, 5.35479188e-02f, -1.82687137e-02f, 3.84676158e-02f, 2.61524111e-01f, -4.79424670e-02f, 7.29057789e-02f, 6.67321160e-02f, 7.06633693e-03f, 3.60073894e-02f,
  6.49989992e-02f, -2.40310077e-02f, 1.39616787e-01f, -6.46382421e-02f, -6.63410872e-02f, -4.86216992e-02f, -5.76896928e-02f, 3.53574194e-03f, 3.53507921e-02f, 1.36934817e-01f,
  -1.14654072e-01f, 3.03495228e-02f, -3.91332321e-02f, -1.14146871e-02f, -5.43224663e-02f, -1.03689268e-01f, -1.45629710e-02f, 6.56316504e-02f, 5.58656976e-02f, 3.61595838e-03f,
  2.72272009e-04f, -7.35116191e-03f, 1.31885102e-02f, -1.97130237e-02f, -1.58053376e-02f, -9.07506347e-02f, 6.91209510e-02f, -1.37108061e-02f, -1.11092431e-02f, 8.03757682e-02f,
  6.46742387e-03f, 1.39781635e-03f, 3.70900962e-03f, -3.66494283e-02f, 3.76937762e-02f, -4.04240098e-03f, 2.91229635e-02f, -8.66433792e-03f, -6.37055114e-02f, -3.13699692e-02f,
  7.77911022e-02f, 1.52163496e-02f, -2.95177437e-02f, 7.04158619e-02f, 8.78237784e-02f, -1.71981007e-02f, 4.27164510e-02f, 5.37221655e-02f, -6.21502623e-02f, 4.07455899e-02f,
  1.82437524e-02f, -1.39701907e-02f, 5.90466633e-02f, -2.59238034e-02f, -1.79875866e-02f, -2.77256481e-02f, 2.32285634e-02f, -5.65782934e-02f, -3.49474996e-02f, 9.10030864e-03f,
  7.64883161e-02f, 2.50939224e-02f, -1.90810282e-02f, -7.91926533e-02f, -3.00030299e-02f, -4.41908352e-02f, -4.60511334e-02f, -6.83325306e-02f, -8.83158017e-03f, -2.25817710e-02f,
  -4.40367639e-01f, -2.36153871e-01f, 5.45466021e-02f, -7.00899810e-02f, 2.29574796e-02f, -1.10670187e-01f, 1.17880344e-01f, -6.32988736e-02f, -3.56621854e-02f, -3.37461680e-02f,
  -6.24942221e-02f, -3.36267836e-02f, -1.42597169e-01f, 3.65685560e-02f, -1.61401276e-02f, -2.34495532e-02f, -9.65156499e-03f, -5.47475480e-02f, -2.13329047e-02f, -2.82271998e-03f,
  -1.20682362e-02f, 2.80103665e-02f, -1.04440805e-02f, -3.42024937e-02f, -3.33886547e-03f, -3.67526188e-02f, 1.91638190e-02f, -1.97693668e-02f, -1.21912118e-02f, -5.49569912e-02f,
  -2.22975746e-01f, 1.29715919e-01f, -9.61982757e-02f, 3.65715921e-02f, 2.87797421e-01f, 9.80954245e-02f, 1.28141701e-01f, 1.61871433e-01f, 1.95555821e-01f, 2.09142774e-01f,
  2.11543813e-01f, 1.47055268e-01f, 1.30637422e-01f, 1.72942206e-01f, -7.12494254e-02f, 3.15828957e-02f, 1.63313583e-01f, 3.69183235e-02f, -5.09971194e-02f, 8.34183022e-03f,
  -1.95107862e-01f, 1.54174164e-01f, -1.10489890e-01f, 9.83663276e-03f, -2.32543088e-02f, -2.62077719e-01f, -5.70952483e-02f, -1.82200465e-02f, 2.29950179e-03f, 1.78674534e-01f,
  8.03764462e-02f, 2.32034639e-01f, -9.08302367e-02f, -3.62364604e-04f, -1.12769298e-01f, -1.55068096e-02f, -1.11511111e-01f, -1.04609355e-01f, -1.15292780e-01f, 7.74004757e-02f,
  2.07963474e-02f, -7.86695033e-02f, -2.59790048e-02f, 3.30876373e-02f, 3.48393805e-02f, 3.04182488e-02f, -2.73962114e-02f, -1.53462857e-01f, -9.04193595e-02f, -6.63687885e-02f,
  -1.28468096e-01f, -2.73467554e-03f, -5.62940836e-02f, -5.21791317e-02f, -2.41158921e-02f, 7.43940845e-02f, 7.60970730e-03f, 4.38949987e-02f, 1.87788121e-02f, 4.42373194e-02f,
  4.34245951e-02f, -8.41123238e-03f, -3.67102306e-03f, -3.64662185e-02f, -2.88706776e-02f, -9.43711847e-02f, -5.46826515e-03f, -6.43518269e-02f, -5.63975573e-02f, 1.78900100e-02f,
  -2.30985112e-03f, -1.75008718e-02f, 1.05968723e-02f, 1.26913181e-02f, 9.59955081e-02f, -3.14286794e-03f, 4.17707711e-02f, 1.16589479e-01f, -2.10141283e-04f, -3.94741856e-02f,
  3.81473526e-02f, 1.81656424e-02f, -1.56118087e-02f, 6.29061237e-02f, -5.73772043e-02f, 2.23219618e-02f, 1.22708388e-01f, -1.75615214e-02f, 2.15493105e-02f, 1.44085633e-02f,
  1.80556506e-01f, 2.92622268e-01f, 1.94754899e-02f, -1.92158148e-02f, -9.71547663e-02f, 1.15682192e-01f, 2.28357427e-02f, 7.71040246e-02f, 1.34123310e-01f, 1.36718750e-01f,
  4.03286777e-02f, -4.44717519e-02f, 3.07490006e-02f, 4.72199023e-02f, -9.44461226e-02f, 1.13630630e-01f, 1.12928741e-03f, -8.90913606e-02f, -1.35841675e-03f, -9.91421342e-02f,
  7.48562440e-03f, 4.17559221e-02f, -8.93016160e-02f, 4.85545769e-02f, -4.23099510e-02f, -3.66264805e-02f, 5.46015650e-02f, 5.72383776e-02f, 4.15646546e-02f, 3.84926833e-02f,
  -3.11331302e-02f, -7.43478909e-02f, -2.78323382e-01f, -1.65864870e-01f, -3.83722074e-02f, -2.47550681e-01f, -2.72612572e-01f, 2.94904634e-02f, 3.96537781e-02f, 7.32141063e-02f,
  -2.32225247e-02f, 5.48275635e-02f, 2.26838160e-02f, -1.61952749e-01f, -1.64346352e-01f, -3.02822273e-02f, -3.74100596e-01f, -2.06999451e-01f, 5.64653724e-02f, -1.03541113e-01f,
  -7.64780119e-02f, -1.11244239e-01f, -2.58714169e-01f, 1.32100150e-01f, -1.78269863e-01f, -3.81285809e-02f, 8.79405513e-02f, 1.65319294e-01f, -1.73438460e-01f, -6.91954745e-04f,
  -9.41120535e-02f, 1.12549290e-01f, -4.96163145e-02f, -2.89605334e-02f, -9.21033043e-03f, 1.74512919e-02f, -8.72339755e-02f, 5.77239878e-02f, 9.53430310e-03f, -7.04642683e-02f,
  -6.31171688e-02f, 1.10219352e-01f, 3.50028686e-02f, 3.95726785e-02f, 1.56693161e-02f, 3.77454795e-02f, 3.41963731e-02f, -5.97264953e-02f, -5.76998778e-02f, -4.91842255e-02f,
  -1.32127985e-01f, -1.57118261e-01f, -3.97910513e-02f, -7.93135818e-03f, -2.19210852e-02f, 8.90379678e-03f, -3.49345915e-02f, -1.93467010e-02f, -6.02811649e-02f, -4.67168204e-02f,
  1.56458840e-02f, 1.10513687e-01f, -6.08204231e-02f, -3.87335345e-02f, -9.00130998e-03f, -2.88940426e-02f, 1.06750280e-02f, -4.16634083e-02f, 2.77209040e-02f, 4.32404777e-04f,
  -4.39703418e-03f, -5.32447249e-02f, 7.49014840e-02f, -2.92529054e-02f, 3.86545099e-02f, -2.15769839e-02f, 4.62026149e-02f, 3.46238017e-02f, -1.56437695e-01f, -1.23771288e-01f,
  1.09000064e-01f, -6.43903448e-04f, 4.12452035e-02f, 4.43878584e-02f, -9.60689485e-02f, 6.23419806e-02f, 4.63345461e-02f, -3.29341665e-02f, -3.03102303e-02f, 9.31306854e-02f,
  -9.66312177e-03f, 1.48393661e-01f, 3.08709703e-02f, 6.22490048e-02f, -3.98358107e-02f, 5.62076271e-03f, -4.03757393e-02f, -1.53277189e-01f, -4.41915430e-02f, 9.90536585e-02f,
  2.80173738e-02f, -4.34629433e-02f, -9.85901654e-02f, -1.83850769e-02f, -2.11002901e-02f, -3.02422028e-02f, 9.36868638e-02f, 3.76509093e-02f, -1.17080271e-01f, -8.04779530e-02f,
  1.30736053e-01f, -1.10272374e-02f, 8.62957090e-02f, -6.21253476e-02f, -3.74100953e-02f, 1.08687341e-01f, 1.40790083e-02f, -2.73244502e-03f, -2.79964861e-02f, -6.57543242e-02f,
  -3.00290793e-01f, 6.50775582e-02f, -2.34391809e-01f, 1.03624448e-01f, -8.04395676e-02f, 1.54547349e-01f, 1.04432419e-01f, -1.87026247e-01f, -2.45006844e-01f, 1.91012338e-01f,
  2.54544348e-01f, -1.59428865e-01f, 1.35792047e-01f, 3.52403224e-01f, 6.33770227e-02f, 3.08287680e-01f, 2.40739509e-01f, 8.17138404e-02f, -7.34666809e-02f, 8.79427139e-03f,
  -5.37763052e-02f, 2.87148386e-01f, 2.11790666e-01f, 8.44287593e-03f, 1.67773575e-01f, -2.03681797e-01f, 1.15300298e-01f, -2.00489148e-01f, 9.32349712e-02f, -1.99286379e-02f,
  2.68075652e-02f, -6.89068576e-04f, -6.40890375e-02f, -1.10830233e-01f, -1.59708429e-02f, -2.62672603e-02f, -3.68290693e-02f, -1.20376192e-01f, -2.84048952e-02f, -5.21931984e-02f,
  -2.03568898e-02f, 4.01941016e-02f, 1.09080160e-02f, -6.59066737e-02f, -1.42034262e-01f, -5.71576804e-02f, -4.25537676e-02f, 6.91284165e-02f, 1.64067615e-02f, -2.44133137e-02f,
  -2.08050590e-02f, -2.54169479e-02f, 5.95606305e-02f, 7.09015802e-02f, -4.15295213e-02f, 1.54738119e-02f, 1.09428227e-01f, -1.70682818e-02f, -3.83820571e-02f, 3.79963741e-02f,
  -1.09142713e-01f, -6.39936998e-02f, -3.40282731e-02f, 1.29032403e-01f, -7.70402551e-02f, 6.17175177e-02f, -4.53329785e-03f, -3.23912464e-02f, -7.62229860e-02f, 4.19636257e-02f,
  -2.87757199e-02f, -2.89777536e-02f, -4.58311029e-02f, -1.80113688e-02f, 1.30197816e-02f, 3.39618400e-02f, -4.22845222e-02f, -2.35121399e-02f, 1.48032289e-02f, -5.12806922e-02f,
  -5.77521585e-02f, -1.23363165e-02f, -2.66175866e-02f, 1.74800039e-03f, 7.14735687e-02f, -1.47048030e-02f, -5.09554558e-02f, -1.08556533e-02f, 6.10343218e-02f, -3.21317948e-02f,
  1.43424645e-01f, -3.65930460e-02f, -1.71060357e-02f, -4.58661728e-02f, -6.56891614e-02f, 5.34656607e-02f, 2.24603154e-02f, -5.82233667e-02f, -4.98012900e-02f, -9.89623442e-02f,
  2.81705265e-03f, 6.63344637e-02f, 3.31363268e-02f, 9.60449502e-02f, 1.61263179e-02f, 1.29940244e-03f, 1.40539482e-01f, -2.22092331e-03f, 1.11735659e-02f, -2.26305034e-02f,
  5.37153296e-02f, -2.34404001e-02f, -6.10727184e-02f, -4.70252708e-02f, -4.01632637e-02f, 8.35543498e-02f, -3.28884944e-02f, 1.77337788e-02f, 8.16588700e-02f, 6.18959107e-02f,
  2.60939430e-02f, -2.02169642e-01f, 1.40722111e-01f, -5.98147847e-02f, 5.76294437e-02f, -1.10782757e-01f, 2.26046667e-01f, -2.09080800e-01f, -1.25350252e-01f, -7.19777122e-02f,
  3.15563828e-02f, -1.40480269e-02f, 2.03246877e-01f, -1.87997743e-01f, 2.67877936e-01f, 4.65135425e-02f, -7.26675913e-02f, 2.03261129e-03f, -2.06598565e-02f, -4.62642126e-02f,
  -6.58234756e-04f, -1.46356642e-01f, 3.86030115e-02f, -2.54955620e-01f, -1.41245678e-01f, -2.51087062e-02f, 6.02255426e-02f, 1.04706019e-01f, -1.10269926e-01f, 6.69603497e-02f,
  -1.14270732e-01f, 5.41441422e-03f, -9.18033496e-02f, 5.58754383e-03f, -8.64046291e-02f, 8.26976169e-03f, 2.24211589e-02f, 2.20085122e-02f, 6.13503866e-02f, 6.16792925e-02f,
  -2.80750748e-02f, -8.32503755e-03f, -1.27633974e-01f, 2.44679768e-02f, -4.89306860e-02f, -1.60387624e-02f, -9.91611630e-02f, -4.10770476e-02f, -3.37145962e-02f, 7.58569017e-02f,
  7.42387921e-02f, 1.37607865e-02f, -3.03529929e-02f, 5.37120700e-02f, -6.79064766e-02f, -3.38817723e-02f, -1.03365541e-01f, 1.48001879e-01f, 5.68836667e-02f, -2.63141003e-02f,
  -4.08413894e-02f, -1.47208599e-02f, -3.80709171e-02f, 6.98659867e-02f, -1.67680392e-03f, 5.20389155e-03f, 2.23472691e-03f, 6.65393099e-02f, 2.12073792e-03f, -4.03182171e-02f,
  -1.04520291e-01f, 3.59297618e-02f, -1.29195228e-01f, 5.38119487e-02f, 3.82742807e-02f, -3.86549942e-02f, 3.74818444e-02f, -7.13258982e-02f, -1.49186031e-04f, -8.75294283e-02f,
  8.05462673e-02f, 4.61145677e-02f, 7.36734420e-02f, 7.00293109e-02f, 2.14679986e-02f, 1.39996767e-01f, 3.48571949e-02f, 7.10380077e-02f, 4.65063415e-02f, -4.68204089e-04f,
  -1.41966879e-01f, -1.73276484e-01f, -7.55773708e-02f, -5.51605672e-02f, -4.33325544e-02f, 3.92809957e-02f, -6.02190308e-02f, -4.94619757e-02f, 8.02681595e-03f, 3.06862593e-02f,
  -7.60566220e-02f, 2.09283177e-02f, -1.38527984e-02f, 3.32271494e-02f, -4.46851365e-02f, 6.82453513e-02f, -1.06418833e-01f, -5.39048687e-02f, 8.29517692e-02f, -4.43542898e-02f,
  -1.23468647e-02f, -5.55800460e-02f, 5.39886728e-02f, -1.34364232e-01f, 5.97690186e-03f, 1.45648420e-01f, -4.99900877e-02f, 8.48289952e-02f, 1.99819803e-02f, -2.31069569e-02f,
  -9.95648429e-02f, -2.82734364e-01f, 1.76546976e-01f, -5.24436012e-02f, 1.27584442e-01f, 1.16975062e-01f, 2.17080265e-01f, 1.01175047e-01f, 1.23472512e-02f, -1.84103370e-01f,
  -8.09138566e-02f, -2.03096837e-01f, 1.30347265e-02f, -5.45434467e-03f, 1.85923204e-01f, 1.24532156e-01f, 1.08840605e-02f, -6.58480227e-02f, 5.87825999e-02f, -4.26196046e-02f,
  2.62862705e-02f, -5.87773286e-02f, 2.74131298e-01f, -1.26808211e-01f, 6.53905869e-02f, -6.10817447e-02f, -7.48277083e-02f, 4.08887118e-02f, -8.49151015e-02f, 3.04337721e-02f,
  -8.47509801e-02f, -3.07240225e-02f, 4.19668108e-02f, -5.71688600e-02f, 1.55255841e-02f, -4.96538952e-02f, -3.68903652e-02f, 3.49702537e-02f, 1.20274089e-01f, 3.03049758e-03f,
  -2.75151618e-02f, 8.00374597e-02f, -4.41951491e-02f, -3.02589871e-02f, 2.59611886e-02f, -6.81631174e-03f, 8.09391066e-02f, 5.44331316e-03f, -2.51995958e-02f, 1.09396048e-01f,
  6.24858961e-02f, -9.68949497e-02f, -4.55774143e-02f, -7.80904144e-02f, -3.54355238e-02f, -3.04112155e-02f, -1.11761555e-01f, -3.37529778e-02f, -8.96493718e-03f, 1.25595266e-02f,
  3.42724249e-02f, 7.28603005e-02f, -5.75618371e-02f, 2.57980656e-02f, 2.74577178e-02f, -4.72042449e-02f, -2.20423322e-02f, -5.01044169e-02f, -3.43302730e-03f, 6.89186007e-02f,
  6.85868831e-03f, 2.80575044e-02f, 5.74215390e-02f, -9.39646363e-03f, 2.68581063e-02f, -6.35635480e-02f, -5.11284955e-02f, 2.25307662e-02f, 9.39178169e-02f, 3.85207757e-02f,
  1.66376177e-02f, -4.73492369e-02f, 5.11235110e-02f, 1.26288412e-02f, 1.31861893e-02f, 1.43383048e-03f, -7.42929475e-03f, -6.35043010e-02f, 6.41116872e-02f, 9.22614783e-02f,
  -1.76567301e-01f, -2.76360124e-01f, -5.47852404e-02f, 2.39645084e-03f, -6.52539656e-02f, -1.03932790e-01f, 3.51181999e-03f, -7.12260380e-02f, -3.95938270e-02f, 2.96713877e-02f,
  5.12281917e-02f, -4.73650768e-02f, -2.64725965e-02f, -4.85327840e-02f, 8.74221176e-02f, 6.03984948e-03f, -8.92402306e-02f, -4.16397117e-02f, 1.76033529e-04f, -6.38847053e-02f,
  -4.71627526e-02f, 1.51955383e-02f, 3.64986062e-02f, 3.44322659e-02f, 2.09484827e-02f, -4.26326580e-02f, -3.09019145e-02f, -1.64968651e-02f, -3.24668214e-02f, -3.83714475e-02f,
  -5.23165405e-01f, -1.95956938e-02f, 3.69180441e-01f, -1.22358903e-01f, -1.00386195e-01f, 2.52902716e-01f, 1.46028295e-01f, 1.66654226e-03f, -1.85509637e-01f, 2.95926705e-02f,
  1.76780894e-01f, -6.84531853e-02f, 1.41732588e-01f, -5.42111732e-02f, 6.72853887e-02f, 1.77931935e-01f, 1.24306694e-01f, -1.01721464e-02f, -5.69055639e-02f, -2.96135191e-02f,
  -6.82756007e-02f, -1.09939910e-01f, 2.61679173e-01f, -6.08622059e-02f, 4.70563164e-03f, -6.98631033e-02f, 1.51199270e-02f, 1.40131772e-01f, 6.95445016e-02f, 9.47975218e-02f,
  4.95141651e-03f, -1.21828303e-01f, 5.63636795e-02f, 6.31159469e-02f, 9.78239551e-02f, 5.81167005e-02f, 1.12631902e-01f, 8.00145268e-02f, -3.13572399e-02f, 4.06273380e-02f,
  -7.00620636e-02f, -3.00690290e-02f, -1.27987728e-01f, -5.98773435e-02f, -1.41161442e-01f, -6.96959496e-02f, 7.26861134e-02f, 1.00975111e-01f, -2.44748183e-02f, 3.60781327e-02f,
  1.38095438e-01f, 6.54337332e-02f, 8.32035542e-02f, 5.30604348e-02f, 6.11260049e-02f, 7.71719404e-03f, 7.33711123e-02f, 1.74328834e-02f, -4.23465818e-02f, -3.85711640e-02f,
  -8.45038369e-02f, -9.37494710e-02f, -9.47565865e-03f, -1.12978026e-01f, 2.73350868e-02f, -4.60150205e-02f, 1.68786943e-02f, -7.01409280e-02f, 2.84457859e-02f, 7.22959777e-03f,
  -8.42699483e-02f, -3.28927301e-02f, -7.02352300e-02f, 2.34795474e-02f, -8.82415939e-03f, 5.28210066e-02f, -2.80089979e-03f, -2.81096380e-02f, -1.21390373e-01f, 4.53073867e-02f,
  -1.42972625e-03f, -1.04165981e-02f, -6.41890690e-02f, 2.33582524e-03f, -4.46061529e-02f, -4.41470817e-02f, -2.51945406e-02f, -3.21320780e-02f, 4.95044030e-02f, 4.76475954e-02f,
  -1.57546103e-01f, -2.14984238e-01f, -1.39289498e-02f, -1.19968288e-01f, -1.36785973e-02f, 9.80252996e-02f, -4.79299016e-02f, -8.24014693e-02f, -5.71229123e-02f, -2.78312471e-02f,
  1.68638527e-02f, -2.06420422e-02f, -1.99250169e-02f, -5.42562306e-02f, 2.49760109e-03f, 1.05439676e-02f, 8.78996253e-02f, -4.62949462e-02f, 1.64775643e-03f, -5.54639883e-02f,
  3.43681276e-02f, -5.39420508e-02f, 5.42419180e-02f, -6.33931533e-02f, 1.47737339e-02f, 7.37801427e-04f, -7.80264288e-02f, 2.44640261e-02f, 9.51525643e-02f, 8.66831094e-02f,
  -1.19731598e-01f, -1.86308450e-03f, 2.45222956e-01f, -5.18529527e-02f, 8.45128894e-02f, 2.07899749e-01f, 2.67633259e-01f, -9.69802961e-04f, 8.97729546e-02f, -2.16359217e-02f,
  -4.73427363e-02f, 3.32095921e-02f, 1.05893940e-01f, 6.65831799e-03f, 3.18788737e-01f, 2.13498026e-01f, -3.26742865e-02f, -8.01853389e-02f, 1.82426013e-02f, -1.34258524e-01f,
  5.97526506e-03f, -1.20083302e-01f, 5.55376634e-02f, -1.62410945e-01f, -3.68894152e-02f, -3.72668728e-03f, -7.56260082e-02f, 5.52601404e-02f, -1.60586402e-01f, 1.47060856e-01f,
  -1.97525807e-02f, -1.02442719e-01f, -5.66612780e-02f, -4.45883386e-02f, -5.35914339e-02f, 1.04111768e-01f, 6.51639700e-02f, 8.10088515e-02f, -1.24795232e-02f, 2.22786423e-02f,
  -6.03022687e-02f, 3.46429013e-02f, -7.24962950e-02f, -4.41545732e-02f, -5.03937602e-02f, -1.71246529e-02f, -7.68710673e-02f, -7.46208355e-02f, -8.23501125e-02f, 5.90401888e-02f,
  8.84525571e-03f, 1.68317482e-02f, -2.27852911e-02f, -9.08808261e-02f, 7.65418708e-02f, -6.99314103e-02f, 5.61540052e-02f, 8.83845165e-02f, -6.32314980e-02f, 6.00236468e-02f,
  -8.20540357e-03f, 3.05636767e-02f, 9.29337293e-02f, -6.71341270e-02f, -9.41995531e-02f, -8.66058022e-02f, -3.43983248e-02f, 3.93756889e-02f, -2.93282722e-03f, 5.68878911e-02f,
  -1.96210742e-02f, 4.88606393e-02f, -4.23770100e-02f, -1.15159107e-03f, -1.43392295e-01f, -6.61145970e-02f, -5.21271415e-02f, -1.01248041e-01f, -2.47304942e-02f, 1.83242373e-02f,
  -3.48346680e-02f, 1.07680187e-01f, -1.61914192e-02f, 4.32925709e-02f, 1.55416587e-02f, 1.05333954e-01f, 2.53206454e-02f, -6.48033693e-02f, -2.75059752e-02f, -1.67828109e-02f,
  -4.23665792e-02f, -1.23527303e-01f, -1.65731721e-02f, -7.80055001e-02f, -3.04269679e-02f, -5.07607944e-02f, 3.94415259e-02f, -1.60878710e-02f, 5.04721813e-02f, -7.04185292e-02f,
  -6.79647923e-02f, -1.01616085e-01f, -3.84467957e-03f, -6.52331933e-02f, -4.32495475e-02f, -1.00661442e-01f, 4.69437521e-03f, 4.33442071e-02f, -1.64560340e-02f, -2.81688813e-02f,
  -1.45883724e-01f, -8.83658975e-03f, 4.32006009e-02f, -6.13908954e-02f, -1.50956258e-01f, 1.14469137e-02f, -6.31299987e-02f, 5.01240604e-02f, -2.30010953e-02f, -7.88656026e-02f,
  -2.46380754e-02f, 1.42589852e-01f, 8.01555738e-02f, -3.48193645e-01f, -7.09972018e-03f, -3.52534428e-02f, -1.71606451e-01f, 1.68276858e-02f, -1.00494333e-01f, -2.77571306e-02f,
  -2.30001464e-01f, 2.72812434e-02f, -2.64346823e-02f, -2.25319937e-01f, -3.14991742e-01f, -1.49159148e-01f, -1.88733220e-01f, -1.35065109e-01f, 3.55248190e-02f, -1.90348491e-01f,
  -1.07632600e-01f, -3.52826506e-01f, -3.64779681e-02f, -1.35137159e-02f, 4.19456065e-02f, 1.15803316e-01f, -1.14621900e-01f, 3.10487319e-02f, 1.37182632e-02f, -9.13497712e-03f,
  -1.35186493e-01f, -1.67312995e-01f, -9.70630050e-02f, 2.56075934e-02f, -4.66322899e-02f, 9.93496701e-02f, 7.71823749e-02f, -7.02091977e-02f, -1.03781335e-01f, -2.86267549e-02f,
  5.03407679e-02f, 7.13668242e-02f, 4.84339427e-03f, 6.90863878e-02f, 4.75700684e-02f, 4.97057587e-02f, -4.27365750e-02f, 6.11574501e-02f, 2.46362612e-02f, -3.21563259e-02f,
  -9.48854014e-02f, 1.01321556e-01f, 2.71664932e-02f, 7.70394504e-02f, 1.18388422e-03f, 8.77147019e-02f, -2.31707022e-02f, 1.23968393e-01f, 1.32566378e-01f, 2.70210970e-02f,
  1.59101486e-02f, -4.22650315e-02f, -6.33658916e-02f, 2.04790626e-02f, 4.38525565e-02f, 4.81518768e-02f, 4.54542320e-03f, -9.33325663e-03f, -7.51882195e-02f, 1.28485963e-01f,
  -3.58822104e-03f, 1.02242954e-01f, 1.35875102e-02f, -1.17897630e-01f, 3.50673534e-02f, -1.18182890e-01f, 3.13831978e-02f, -4.08211984e-02f, 1.96471345e-02f, 9.95328464e-03f,
  3.43274586e-02f, -9.29862857e-02f, -4.85528074e-02f, 1.98417678e-02f, -5.97561598e-02f, -1.27569819e-02f, -2.86302418e-02f, -5.28894924e-02f, 1.54184373e-02f, 1.14793731e-02f,
  -1.84508666e-01f, -1.76576003e-01f, 2.23205239e-02f, 2.59183124e-02f, -9.96797606e-02f, 2.50396021e-02f, -6.53467774e-02f, 7.62988999e-03f, -1.27426296e-01f, 6.11364059e-02f,
  4.17574085e-02f, -2.24193018e-02f, 2.15843320e-02f, -5.13817333e-02f, 6.22562096e-02f, -9.30978209e-02f, -3.25683318e-02f, -5.79098165e-02f, -7.82969594e-02f, 5.94152361e-02f,
  -6.10455312e-02f, -3.34283561e-02f, 1.35481521e-01f, -7.37755820e-02f, -6.23809174e-02f, 1.71274524e-02f, 5.73584950e-03f, -7.17446655e-02f, 3.27472435e-03f, 4.81573716e-02f,
  -1.01833194e-01f, -2.02981621e-01f, -1.49054632e-01f, -1.01543665e-01f, -2.94150174e-01f, -2.17350364e-01f, -4.90799025e-02f, -2.26148412e-01f, 1.14531942e-01f, 1.24904811e-01f,
  5.38001247e-02f, 8.30254331e-02f, 1.73078611e-01f, -3.89869027e-02f, 5.58551401e-02f, 2.00742200e-01f, -9.18839276e-02f, -5.91516159e-02f, 2.32108273e-02f, -1.81546852e-01f,
  -6.21799678e-02f, -1.45604357e-01f, 2.60178316e-02f, -2.74142236e-01f, -2.76043206e-01f, -1.34497257e-02f, 1.27328366e-01f, -1.25575870e-01f, -1.40421152e-01f, -3.38881128e-02f,
  -3.13834399e-01f, -2.20188558e-01f, -9.73496512e-02f, -6.05204664e-02f, -1.84056818e-01f, 4.03601900e-02f, -1.16195776e-01f, 4.68808897e-02f, -6.80617872e-04f, -1.08250104e-01f,
  5.50610386e-02f, 1.64785646e-02f, 5.88655733e-02f, 8.89572129e-02f, -4.45944332e-02f, 3.62755079e-03f, -5.47418222e-02f, -1.10741213e-01f, 2.16182005e-02f, -4.07788418e-02f,
  -5.92672266e-02f, -7.06832185e-02f, 4.35941555e-02f, 4.81043309e-02f, 2.96532791e-02f, -5.93148582e-02f, -1.56986658e-02f, -2.64953710e-02f, -1.41181424e-01f, -1.56033099e-01f,
  1.36789858e-01f, 8.56715292e-02f, 2.26355940e-02f, 7.37670064e-02f, -5.77869825e-02f, -1.50412582e-02f, -3.41215171e-02f, 2.59635393e-02f, 5.68007268e-02f, 1.19002156e-01f,
  1.62580202e-03f, -2.99105849e-02f, -1.13776058e-01f, 6.45953342e-02f, 1.03114069e-01f, -1.68894771e-02f, 5.43353707e-02f, -4.92708199e-03f, 1.23765543e-01f, 3.64055075e-02f,
  -1.26794935e-03f, -7.69472793e-02f, 8.24143291e-02f, 5.24247661e-02f, -1.62150562e-01f, 1.43732637e-01f, -2.97370236e-02f, 4.96973284e-03f, 8.91276971e-02f, -1.49260443e-02f,
  -3.05038244e-01f, -1.20375007e-01f, 1.76148284e-02f, -1.21640876e-01f, 5.27281426e-02f, 2.72061233e-03f, 6.08204678e-02f, -6.73426464e-02f, -2.18207091e-02f, -6.86340109e-02f,
  -6.42443867e-03f, 2.56825536e-02f, 4.94520329e-02f, 7.01694116e-02f, 1.89653844e-01f, -8.87407660e-02f, 2.27833483e-02f, 1.93182807e-02f, -8.68287403e-03f, 1.39876669e-02f,
  -6.38359934e-02f, -3.80661227e-02f, 8.64474475e-02f, -4.52213064e-02f, -2.45338143e-03f, -3.62532996e-02f, -8.75569656e-02f, 3.27176824e-02f, -1.43133715e-01f, -2.06705965e-02f,
  3.91702354e-02f, 5.66004924e-02f, -9.81775969e-02f, -1.10745616e-01f, -4.45923693e-02f, 2.42850646e-01f, -1.07213028e-01f, 6.41287044e-02f, -1.48769781e-01f, 8.67364854e-02f,
  8.01438838e-02f, -8.70681778e-02f, -3.68436202e-02f, 2.96427965e-01f, -7.41415173e-02f, 1.25676095e-01f, 1.54904485e-01f, 1.41533419e-01f, -1.98936649e-02f, -1.70196139e-03f,
  -3.84461619e-02f, 1.28075585e-01f, 6.68876916e-02f, 2.61935908e-02f, 5.76610416e-02f, -3.31779756e-02f, 2.91945823e-02f, -5.45730116e-03f, 1.59655162e-03f, 5.17980829e-02f,
  1.52447507e-01f, 9.52881351e-02f, 1.28092676e-01f, 1.43160850e-01f, 7.75006860e-02f, 4.36377302e-02f, -3.06366617e-03f, 1.14927821e-01f, -2.42099562e-03f, 6.27503097e-02f,
  -9.50618759e-02f, -6.37390167e-02f, 1.42966703e-01f, 1.13318712e-02f, 5.32277487e-02f, -3.41955759e-02f, -4.42770384e-02f, 1.12590306e-02f, -1.16723321e-01f, 4.27926853e-02f,
  -6.25254363e-02f, 4.94994782e-02f, -1.23534359e-01f, -4.39780280e-02f, -2.28028614e-02f, -2.38787122e-02f, 7.10174739e-02f, 2.28312034e-02f, 1.04463317e-01f, -8.68392661e-02f,
  6.19457364e-02f, 2.42103003e-02f, 4.47971448e-02f, 9.94596183e-02f, 1.41384259e-01f, 4.03966196e-02f, -8.99302736e-02f, -1.38497604e-02f, -3.38218585e-02f, 4.22832817e-02f,
  4.56910133e-02f, 2.12627673e-03f, -5.55557981e-02f, 6.06634729e-02f, -4.30281013e-02f, 6.73602298e-02f, 9.25757363e-02f, 1.89612862e-02f, -6.59095217e-03f, 4.65322137e-02f,
  -3.55124623e-02f, -6.83703572e-02f, -2.74774898e-02f, 1.21534936e-01f, 1.17120370e-01f, -5.03704660e-02f, -1.31928837e-02f, 2.09099706e-02f, -2.54775360e-02f, -2.93109026e-02f,
  3.96914631e-02f, -1.56857446e-02f, 1.32269844e-01f, 9.47791710e-02f, 1.49597108e-01f, 1.25093848e-01f, -1.17587158e-03f, -1.90361813e-02f, 2.53245030e-02f, 8.84115696e-02f,
  6.58891201e-02f, 2.51894984e-02f, -5.09578316e-03f, -1.56462807e-02f, -1.55157238e-01f, -4.89457659e-02f, -5.93900718e-02f, -1.45700693e-01f, -9.05308276e-02f, 7.79987220e-03f,
  -1.36747852e-01f, 2.33398136e-02f, -3.18511040e-03f, -2.22890824e-02f, -4.72716242e-02f, -2.34954841e-02f, 2.84428224e-02f, 3.38291824e-02f, -1.29232686e-02f, 3.31764407e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  2.50069052e-01f, -2.75866911e-02f, 2.23058224e-01f, 1.42947182e-01f, 1.78453848e-01f, 4.61209752e-02f, 1.14321105e-01f, 1.85016140e-01f, 3.65681648e-02f, 1.63366795e-01f,
  1.26039639e-01f, 6.29320964e-02f, 2.51579583e-01f, 2.99354136e-01f, 1.86050981e-01f, 1.43923759e-01f, 3.44069861e-02f, 1.43952549e-01f, 1.64972693e-01f, 1.02553200e-02f,
  1.60473779e-01f, 1.68406889e-02f, 1.49822488e-01f, 3.64205912e-02f, 1.07189044e-01f, 1.66074429e-02f, 1.47490680e-01f, 1.39169022e-01f, 1.95639282e-01f, 2.57440582e-02f,
  1.50884241e-01f, 1.17709368e-01f, 9.46623012e-02f, 4.98864762e-02f, 1.83545902e-01f, 1.33465201e-01f, 1.71197355e-01f, 2.88556397e-01f, 1.21069051e-01f, 7.70070478e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  5.72727099e-02f, -3.22581572e-03f, 4.31148894e-02f, 9.07179117e-02f, 2.48992499e-02f, 6.91476762e-02f, -6.18869476e-02f, -9.54944715e-02f, 2.12575551e-02f, 5.00102714e-02f,
  6.95882319e-03f, -5.24140969e-02f, -1.31526902e-01f, -1.96338102e-01f, -1.38681922e-02f, 1.32180639e-02f, -1.29953474e-01f, -2.07896397e-01f, -2.77241785e-02f, -1.77139178e-01f,
  1.53965265e-01f, 4.83399928e-02f, -1.05172843e-01f, 3.27960998e-02f, 7.54233496e-03f, -2.66257316e-01f, -3.54487449e-02f, 1.24297045e-01f, 9.28081423e-02f, 1.61057655e-02f,
  8.38548988e-02f, -1.40570015e-01f, -6.32132962e-02f, -7.22073913e-02f, -1.93635568e-01f, 1.89970776e-01f, 1.55755401e-01f, -5.14229685e-02f, 1.46424979e-01f, -2.72767752e-01f,
  -1.10429130e-01f, 1.04213297e-01f, 1.34179845e-01f, -1.65650964e-01f, -1.01911798e-01f, 5.40772546e-03f, -1.98809728e-01f, -6.64761141e-02f, -1.47232741e-01f, -9.92694721e-02f,
  -1.60300776e-01f, 2.24987995e-02f, -2.67387629e-02f, -2.37934634e-01f, 1.52183741e-01f, 2.66994368e-02f, 5.63790742e-03f, -1.54501304e-01f, -1.38600722e-01f, 2.23487653e-02f,
  -2.16174945e-01f, 1.46539301e-01f, -2.27911100e-01f, 2.62440592e-02f, 8.05173665e-02f, 3.00283842e-02f, -8.63464102e-02f, -2.02922806e-01f, 6.38372004e-02f, 1.06140241e-01f,
  8.30964595e-02f, 5.74441999e-02f, -1.42813250e-01f, -1.45453647e-01f, 7.51763117e-03f, 1.22016348e-01f, 1.64449066e-01f, -2.71195285e-02f, 9.69451293e-02f, -1.55618727e-01f,
  2.18356177e-01f, 8.13776478e-02f, 2.13154089e-02f, 1.01958379e-01f, -1.36094272e-01f, -9.34415013e-02f, 1.75784305e-01f, 4.78020646e-02f, 2.36765444e-02f, 1.77801967e-01f,
  3.10530290e-02f, 1.94366798e-02f, 1.62436530e-01f, -1.03657171e-01f, 1.34366527e-01f, 2.77674407e-01f, -1.57065511e-01f, -1.93318889e-01f, 1.37047917e-01f, -2.94798147e-02f,
  -1.80922821e-01f, -6.49748296e-02f, -1.87351387e-02f, 9.35685113e-02f, -1.27142966e-01f, -1.44015476e-01f, 1.85897216e-01f, -3.64002213e-02f, -7.03893602e-02f, -1.14563979e-01f,
  1.30562663e-01f, 2.26265788e-01f, 6.23494275e-02f, -1.32237971e-01f, 1.16148084e-01f, -1.42458364e-01f, -3.23921256e-02f, 1.23719469e-01f, 1.87372621e-02f, -1.74227297e-01f,
  1.03505090e-01f, 2.61470545e-02f, 1.30335346e-01f, 2.73427874e-01f, 1.58671826e-01f, -1.00491919e-01f, -4.99914400e-03f, 1.32182389e-01f, 2.12191299e-01f, -1.30836284e-02f,
  -4.39193007e-03f, 3.11682429e-02f, -8.36105570e-02f, 3.40380855e-02f, 4.22333144e-02f, -1.35350913e-01f, 2.22429976e-01f, 1.51392445e-01f, -1.12080842e-01f, -4.80537154e-02f,
  4.62439507e-02f, 1.07308798e-01f, 1.08639635e-02f, -1.54133767e-01f, 2.15964019e-02f, 1.28356898e-02f, -1.46121547e-01f, -1.64746121e-02f, 2.55787820e-01f, 5.32788225e-02f,
  1.82020977e-01f, 2.93451585e-02f, -1.73550639e-02f, 1.17065553e-02f, 1.93492249e-01f, 1.00746661e-01f, -2.03088880e-01f, -1.76162779e-01f, -6.34677932e-02f, 5.30203879e-02f,
  2.16295555e-01f, 1.56415984e-01f, 1.40284315e-01f, -1.38297841e-01f, -1.59732550e-01f, 2.31945768e-01f, 1.93962499e-01f, 3.33763361e-02f, 4.74409647e-02f, -1.14036612e-01f,
  -3.53038386e-02f, 8.32574293e-02f, 1.96285218e-01f, -8.87449831e-02f, -6.58277273e-02f, -1.58497214e-01f, -1.55763358e-01f, 4.41618748e-02f, 1.34695815e-02f, 5.43814115e-02f,
  -1.23033985e-01f, 7.62635395e-02f, -4.03700583e-02f, -1.19041421e-01f, -1.77749887e-01f, 5.59565462e-02f, -1.33355394e-01f, -1.37278900e-01f, 9.44676399e-02f, 1.58453956e-02f,
  -7.80694261e-02f, -1.29914492e-01f, 1.23638488e-01f, -8.62498954e-02f, 1.95216745e-01f, 5.82593530e-02f, 1.66805774e-01f, -6.49275109e-02f, 2.39654481e-01f, -6.86259866e-02f,
  1.05192356e-01f, 7.89699554e-02f, 1.48654273e-02f, 1.12376340e-01f, 1.44117132e-01f, -1.77011833e-01f, -2.57834762e-01f, -1.54324025e-01f, -7.08706751e-02f, -4.05485481e-02f,
  8.92379209e-02f, 1.72900230e-01f, 7.25955516e-02f, 1.08086675e-01f, 1.62580073e-01f, -1.21688746e-01f, 2.04060465e-01f, 1.56348888e-02f, -2.04439368e-02f, 1.38459308e-02f,
  -1.24216698e-01f, 5.05680367e-02f, 7.91292191e-02f, -8.93042460e-02f, 2.25575864e-01f, 1.29785627e-01f, 1.17285244e-01f, 1.39498293e-01f, 1.93051428e-01f, 1.96950808e-01f,
  -1.15030669e-02f, 1.02465674e-01f, 1.49183884e-01f, -1.22024082e-02f, 4.75417562e-02f, -1.75739452e-01f, 9.13649127e-02f, -1.38440669e-01f, -1.76479518e-01f, 8.50134566e-02f,
  2.76807453e-02f, 6.35263324e-02f, -9.15183425e-02f, 1.09534405e-01f, 2.44368151e-01f, 1.61071137e-01f, -4.01763692e-02f, 1.59537598e-01f, -1.96230203e-01f, 1.04673356e-01f,
  6.01174794e-02f, 2.35690493e-02f, 5.11770733e-02f, 1.92495897e-01f, -8.42615068e-02f, -5.32653444e-02f, 9.52049419e-02f, 7.58340061e-02f, 2.24490557e-03f, -1.34221807e-01f,
  -1.28384143e-01f, 7.55210295e-02f, 5.55982888e-02f, 1.51924700e-01f, -7.82314762e-02f, -1.36642829e-01f, -2.42138784e-02f, 4.81638834e-02f, 6.77926689e-02f, 1.36044830e-01f,
  1.17082387e-01f, -9.20197442e-02f, 1.40720651e-01f, 1.39165163e-01f, 1.91552326e-01f, 2.20047668e-01f, -7.85377063e-03f, 5.76545745e-02f, 3.49858217e-02f, -9.73406881e-02f,
  -1.40468162e-02f, 2.24726692e-01f, 8.79597813e-02f, -1.68064550e-01f, 7.76082724e-02f, -1.55201823e-01f, 8.90671760e-02f, 2.35133648e-01f, -2.34623119e-01f, 2.58182734e-02f,
  3.74267884e-02f, -1.21754758e-01f, -1.30795792e-01f, -2.94054486e-02f, -8.01175088e-02f, 9.75754634e-02f, 4.39007906e-03f, -1.67762205e-01f, 1.03789628e-01f, -5.61624840e-02f,
  -1.05907004e-02f, -8.69781077e-02f, 2.34745055e-01f, 1.62586331e-01f, -4.84061204e-02f, -9.83439013e-02f, 1.72205865e-01f, -1.22036785e-01f, 4.33561727e-02f, 1.22598082e-01f,
  -1.48159191e-01f, -2.30894580e-01f, 4.46181037e-02f, 2.34126151e-01f, 1.96679339e-01f, 2.14387506e-01f, 1.27574518e-01f, 4.90455143e-02f, -6.02014810e-02f, 1.11156121e-01f,
  1.25503227e-01f, 5.97865991e-02f, 6.81329295e-02f, -8.19421783e-02f, 1.22022301e-01f, 8.79572518e-03f, 1.11587541e-02f, 8.51966962e-02f, -2.50097774e-02f, -5.93947992e-02f,
  4.22862023e-02f, 1.70552135e-02f, -4.23576571e-02f, 3.11562747e-01f, 2.01185733e-01f, 7.81159177e-02f, 1.38303146e-01f, 1.21092781e-01f, -1.11772254e-01f, 2.96277720e-02f,
  -1.50321871e-01f, -9.68162343e-02f, 1.82903171e-01f, 1.51617602e-01f, -5.16340360e-02f, -1.53392367e-03f, -1.60833728e-02f, 7.96102285e-02f, -4.49783430e-02f, -8.51103142e-02f,
  -3.98522653e-02f, 2.33583778e-01f, -1.83229581e-01f, 1.73941106e-02f, 1.87428460e-01f, -9.05438364e-02f, -2.64900118e-01f, -1.42182382e-02f, 3.70960571e-02f, 1.21101541e-02f,
  -1.11733481e-01f, 4.57643643e-02f, 9.98852402e-02f, 2.15525910e-01f, 1.18218824e-01f, 8.20361543e-03f, 2.69105732e-01f, 1.82891786e-01f, -4.64002639e-02f, -1.19105116e-01f,
  2.47821942e-01f, -4.77749221e-02f, -1.29520357e-01f, 5.69730550e-02f, -2.72536762e-02f, -1.04249701e-01f, 2.02630341e-01f, 5.04621863e-03f, -1.67528540e-02f, 5.31780608e-02f,
  2.37533525e-01f, -1.07543007e-01f, -6.42796159e-02f, 2.15027943e-01f, -4.25618850e-02f, 7.22067133e-02f, 1.65013462e-01f, 1.62654489e-01f, 1.93270847e-01f, -4.95272167e-02f,
  1.35123134e-01f, 5.06675290e-03f, 1.46129742e-01f, 1.49893031e-01f, 1.43413156e-01f, 3.20284143e-02f, -5.52601330e-02f, -2.07130477e-01f, -2.62905806e-01f, -6.34911060e-02f,
  -3.47867812e-04f, 8.78446028e-02f, -1.18976526e-01f, 2.80388482e-02f, 1.96134716e-01f, 2.97628157e-02f, 3.13469246e-02f, 2.63230681e-01f, 1.54463723e-01f, -1.34034961e-01f,
  2.01256752e-01f, 2.70757586e-01f, -9.49936220e-04f, -1.65455252e-01f, -1.37243494e-01f, -1.45608351e-01f, 1.73407078e-01f, 1.34454891e-01f, 1.71982974e-01f, 5.52187711e-02f,
  1.07449636e-01f, 1.06830142e-01f, 7.08637312e-02f, -7.00331479e-02f, 4.23096009e-02f, 2.60628983e-02f, 1.48814663e-01f, 3.06485258e-02f, -6.68882951e-02f, 2.00020894e-02f,
  -1.69166788e-01f, 1.83296129e-02f, 1.00936800e-01f, 6.81419671e-02f, -4.61749434e-02f, 4.88072410e-02f, 2.03897983e-01f, 2.22250726e-02f, 1.74904406e-01f, 2.45330721e-01f,
  -4.35182713e-02f, -2.01601923e-01f, -2.53711529e-02f, -2.08093539e-01f, -8.81115794e-02f, 1.36880413e-01f, -2.57762671e-01f, -5.78746758e-03f, -2.71479152e-02f, 1.36209270e-02f,
  2.23225057e-02f, -3.42918150e-02f, -1.30620286e-01f, 6.54504746e-02f, 1.57686919e-01f, -1.12042934e-01f, -1.92632347e-01f, -9.91546214e-02f, -8.18897784e-02f, 1.07662000e-01f,
  1.98418990e-01f, 5.50090261e-02f, -3.44923958e-02f, -2.10176602e-01f, 8.60077590e-02f, -6.34274259e-02f, 1.30890563e-01f, 1.46817386e-01f, 6.94228634e-02f, 4.14811932e-02f,
  -1.95207838e-02f, -1.64049268e-01f, 8.71723220e-02f, 1.87008172e-01f, -8.42587128e-02f, -5.10842428e-02f, 8.15838426e-02f, 1.15598477e-01f, -2.10612863e-02f, -5.19536622e-02f,
  1.48531184e-01f, -1.23176135e-01f, 9.45347175e-02f, 1.22292615e-01f, 7.27196932e-02f, 2.91955583e-02f, -1.83828562e-01f, 1.94954678e-01f, 3.47927362e-02f, -7.79008418e-02f,
  -3.05284746e-02f, -3.94367911e-02f, 3.86023708e-02f, -1.27909616e-01f, 1.67931125e-01f, 9.09927711e-02f, 6.76571205e-02f, 1.05431527e-01f, 8.60884413e-02f, -1.30930338e-02f,
  2.22328097e-01f, 1.50788754e-01f, -1.77741811e-01f, 6.80843815e-02f, 1.59050319e-02f, 1.40629277e-01f, 1.75615534e-01f, 6.31203055e-02f, 1.19148172e-01f, 1.31345326e-02f,
  2.42315799e-01f, -1.73190907e-02f, 3.62148620e-02f, 4.83546592e-02f, 9.86517817e-02f, 4.98568863e-02f, 4.49900441e-02f, -5.22735827e-02f, -6.22166432e-02f, 5.29945940e-02f,
  -1.25990808e-01f, -1.01430707e-01f, 9.04777925e-03f, 4.80407365e-02f, 1.48403093e-01f, -2.81387925e-01f, 1.10292688e-01f, 9.28748846e-02f, 3.20691876e-02f, -2.06473857e-01f,
  1.06665619e-01f, -1.70803964e-02f, -3.03307593e-01f, -1.09902292e-01f, -5.07725812e-02f, 4.11735922e-02f, 1.52447447e-01f, -2.20708877e-01f, -6.32400066e-02f, -2.04132423e-01f,
  7.42243603e-02f, 1.87432513e-01f, -9.75614861e-02f, -1.85430512e-01f, -2.55659163e-01f, -2.20153496e-01f, -4.45997119e-02f, 1.42339200e-01f, 1.09601244e-01f, 1.55015871e-01f,
  1.01442739e-01f, -2.27448463e-01f, 1.38826653e-01f, -1.09765701e-01f, -9.81748104e-02f, -1.62616566e-01f, 2.82178391e-02f, -1.46766260e-01f, 3.77336517e-02f, 2.30903089e-01f,
  -1.03014261e-01f, -2.40341187e-01f, -9.00689736e-02f, 7.78985396e-02f, -7.01923296e-02f, -1.78179711e-01f, 1.35844469e-01f, -8.72297063e-02f, 1.23255305e-01f, -1.86359167e-01f,
  -6.13679104e-02f, 1.65046901e-01f, -6.06986508e-02f, 1.16323004e-03f, -2.32460678e-01f, 1.89797342e-01f, 2.87394077e-02f, 1.43607721e-01f, 4.99910340e-02f, -6.70745447e-02f,
  -5.61551154e-02f, 5.31131886e-02f, 2.65002586e-02f, -4.89543471e-03f, 7.32896999e-02f, 1.71603058e-02f, 1.04685456e-01f, -1.47535697e-01f, 1.02381021e-01f, 2.12045044e-01f,
  1.56316295e-01f, 1.64051145e-01f, 1.51219174e-01f, 1.00016117e-01f, -1.15544349e-01f, 2.07520276e-03f, 3.72715071e-02f, 1.25966907e-01f, -1.91676188e-02f, 1.40206754e-01f,
  -1.11898318e-01f, -1.83939248e-01f, -4.56895679e-02f, 1.46674439e-01f, -1.77646711e-01f, -3.35511684e-01f, -8.73258561e-02f, -4.21777479e-02f, 5.94522320e-02f, 1.35814011e-01f,
  5.57839200e-02f, -3.31893712e-01f, -1.84309229e-01f, -6.73571508e-03f, 1.83660418e-01f, 3.39157842e-02f, -4.03839862e-03f, -1.61595009e-02f, -6.55734539e-02f, 2.61765212e-01f,
  7.49110654e-02f, 1.92919806e-01f, 1.45475134e-01f, -6.10519126e-02f, -6.12023100e-02f, 3.11747249e-02f, -1.01296559e-01f, -8.18582922e-02f, -2.20654637e-01f, -1.77224636e-01f,
  8.00494403e-02f, -8.78640637e-02f, 6.77981824e-02f, -8.05379972e-02f, -1.16778119e-02f, 5.43982070e-03f, 5.47005199e-02f, -3.08939129e-01f, -7.49506615e-03f, -1.27322271e-01f,
  1.21313129e-02f, -7.81106800e-02f, -1.09746374e-01f, -5.23808524e-02f, -2.00177506e-01f, 4.89197075e-02f, -2.08712459e-01f, -1.58989489e-01f, 1.61626600e-02f, 4.44197394e-02f,
  -8.95412788e-02f, -2.09180892e-01f, 6.78002536e-02f, 2.07344756e-01f, 1.81390688e-01f, 1.95208937e-01f, -4.54529375e-02f, -7.03164116e-02f, -8.08350816e-02f, -2.84365684e-01f,
  -3.27579048e-03f, 5.98098850e-03f, -6.08377010e-02f, -1.05107613e-02f, 9.38874856e-02f, -1.15378447e-01f, -1.21588990e-01f, 1.92675978e-01f, -8.08414817e-02f, 1.46718264e-01f,
  -2.95349836e-01f, 1.00089662e-01f, 1.91616446e-01f, -5.70779704e-02f, -1.13837555e-01f, 3.23023535e-02f, -5.00913262e-02f, -6.72386438e-02f, 2.01854274e-01f, -1.06753074e-01f,
  -1.16445117e-01f, 6.40317798e-02f, -2.22339556e-01f, -3.57721443e-03f, 5.22421077e-02f, 1.16322316e-01f, 1.19359821e-01f, -2.58532435e-01f, -2.33031496e-01f, 4.57416289e-02f,
  -1.00895762e-01f, 9.20979753e-02f, -5.26976734e-02f, -1.18893564e-01f, -3.35354060e-02f, 7.21587241e-02f, 1.44106373e-01f, -3.96405570e-02f, -1.79693714e-01f, 7.77615421e-03f,
  -2.22919658e-01f, 2.34530699e-02f, 2.99588799e-01f, 6.01720177e-02f, -1.22876819e-02f, -4.05694656e-02f, -4.01370935e-02f, -6.58786148e-02f, 1.11503944e-01f, -6.22884231e-03f,
  -7.97137693e-02f, 1.39626428e-01f, -1.31130680e-01f, 1.10975485e-02f, -7.00680772e-03f, 1.46366194e-01f, 4.19494547e-02f, -2.91289479e-01f, -6.97693601e-02f, 6.47603720e-02f,
  2.93755867e-02f, -1.71688884e-01f, 2.29366019e-01f, -5.06855510e-02f, -1.78237587e-01f, -1.03074439e-01f, -2.14129686e-01f, -1.59960449e-01f, 9.64914784e-02f, -1.33653328e-01f,
  -2.43397113e-02f, -2.07550600e-01f, 1.62695274e-02f, 1.97701827e-01f, 4.17986102e-02f, -1.56571269e-01f, -2.15279967e-01f, -1.81254551e-01f, -4.24505360e-02f, 2.01211467e-01f,
  1.78009853e-01f, -1.91590309e-01f, -2.21489653e-01f, -2.48641625e-01f, 8.55357125e-02f, -1.95987493e-01f, -6.63016737e-03f, -1.46048471e-01f, -1.30787134e-01f, -2.23527938e-01f,
  -3.34657952e-02f, 7.39972219e-02f, -1.01070449e-01f, -1.85284123e-01f, 5.07995039e-02f, 1.03172891e-01f, 3.72712575e-02f, -9.90800783e-02f, 1.99842393e-01f, 2.22987141e-02f,
  2.93573946e-01f, 9.69830304e-02f, -1.51594087e-01f, 1.19965203e-01f, -1.17004871e-01f, 1.20854139e-01f, 2.69457744e-03f, 4.58459444e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.54411927e-01f, -4.13023531e-02f, 3.96930575e-02f, 2.22872421e-01f, 1.10010214e-01f, 4.50965390e-02f, 1.24294721e-01f, 1.43307671e-01f, 1.19758762e-01f, 3.32093872e-02f,
  -3.19567360e-02f, 1.55307040e-01f, -4.15686332e-02f, -5.56646362e-02f, -1.49291873e-01f, -2.36360982e-01f, -2.46268958e-01f, -8.88483822e-02f, 2.02190742e-01f, -2.84987390e-02f,
  1.40638545e-01f, 3.20855491e-02f, 3.96124683e-02f, -1.77337155e-01f, -1.59992993e-01f, 1.46325469e-01f, 4.62407283e-02f, -2.10850388e-02f, 2.00109795e-01f, -1.67748496e-01f,
  3.59654963e-01f, 2.47984678e-01f, -3.64331007e-02f, -2.19638914e-01f, -5.90865798e-02f, -2.21021846e-02f, 1.87900267e-03f, 8.85803327e-02f, -1.12243064e-01f, -8.99439156e-02f,
  1.40765443e-01f, -1.38173759e-01f, 3.88081372e-01f, -2.22895488e-01f, 6.30679280e-02f, -1.68875769e-01f, 8.49227756e-02f, 1.57896206e-01f, 2.35883951e-01f, -1.65299624e-01f,
  1.48390174e-01f, 1.82844605e-02f, 2.25472823e-01f, 2.06612080e-01f, -3.12804505e-02f, 9.86525342e-02f, 9.32422057e-02f, 2.84975350e-01f, 1.89244434e-01f, 2.60183603e-01f,
  1.46082759e-01f, 2.56207079e-01f, 5.32024242e-02f, -3.47731225e-02f, 2.10533708e-01f, 1.52035907e-01f, 1.18871689e-01f, 8.79950002e-02f, -6.73032328e-02f, 2.20693171e-01f,
  1.30122393e-01f, -3.89008783e-02f, 1.78081259e-01f, 5.94652183e-02f, 3.77793461e-02f, 5.29821925e-02f, 1.63657770e-01f, 7.69568458e-02f, 3.12769115e-01f, -1.65621072e-01f,
  1.03429630e-01f, -1.23411991e-01f, -1.82391226e-01f, -3.61933522e-02f, -3.24248709e-02f, 5.31940348e-03f, 2.76534617e-01f, 5.63432574e-02f, 1.64211854e-01f, 1.85416624e-01f,
  3.17176506e-02f, -4.59025465e-02f, -7.17700496e-02f, 3.58398855e-02f, 1.01084135e-01f, 6.72989339e-02f, 5.42037264e-02f, 2.96283782e-01f, 1.73896983e-01f, -5.23333177e-02f,
  -5.36633693e-02f, 3.12160105e-01f, 1.85232326e-01f, 3.03663552e-01f, 1.52581185e-01f, 6.56069964e-02f, -7.51796290e-02f, -9.63541120e-02f, 3.49344045e-01f, -1.28061131e-01f,
  1.72721013e-01f, 2.85854727e-01f, -1.38447613e-01f, 5.97639941e-03f, 2.57662982e-01f, 1.23283960e-01f, 8.58871490e-02f, 3.62908512e-01f, -6.82035387e-02f, -3.29298466e-01f,
  -9.78259593e-02f, 2.48381376e-01f, 1.77603453e-01f, 1.59915581e-01f, 2.57317305e-01f, -9.65033483e-04f, 8.16829726e-02f, -3.15052569e-02f, 3.27043198e-02f, 2.39422232e-01f,
  2.02058256e-01f, -5.86239807e-02f, 1.12100847e-01f, 3.38492841e-02f, 1.46912187e-01f, 2.41432071e-01f, -7.96238426e-03f, 1.38917759e-01f, 5.97665086e-02f, 7.88025036e-02f,
  6.39198869e-02f, 8.06612521e-03f, 1.57766297e-01f, 2.14560047e-01f, 4.56068479e-02f, 1.16559982e-01f, 2.83805102e-01f, 1.04102626e-01f, -3.48110169e-01f, -6.13310896e-02f,
  -2.63350099e-01f, -2.11505368e-01f, 9.06868428e-02f, -1.79385975e-01f, -6.84776679e-02f, -1.46662906e-01f, -1.85260177e-02f, 2.25330785e-01f, -2.10576013e-01f, 1.47057056e-01f,
  8.41524731e-03f, -8.18375945e-02f, -8.60603228e-02f, 2.94894278e-01f, 1.78795889e-01f, 3.78903858e-02f, -4.21638973e-02f, -1.81076825e-01f, -3.47322971e-02f, 1.67394236e-01f,
  -9.38035771e-02f, -7.32228979e-02f, 6.86864788e-03f, -1.68577239e-01f, 1.18393175e-01f, -4.77981195e-02f, -2.90241502e-02f, -5.55232540e-02f, 3.89813296e-02f, -2.80998200e-02f,
  -2.29589790e-02f, -1.62813455e-01f, 2.95962006e-01f, 1.28190890e-01f, 3.50573212e-01f, -1.52230993e-01f, -8.11602771e-02f, 9.87557843e-02f, 4.18180227e-03f, -1.55888736e-01f,
  1.06483422e-01f, 1.71546593e-01f, 5.12574352e-02f, 1.17910467e-01f, 1.98734235e-02f, 8.97322968e-02f, 1.03762291e-01f, 1.44751877e-01f, 2.27942854e-01f, -7.99940377e-02f,
  6.47484511e-03f, 1.26981735e-01f, 6.41065761e-02f, 6.91615567e-02f, 1.14467284e-02f, 5.51790223e-02f, -1.99742794e-01f, -2.45765254e-01f, 1.74444076e-02f, -7.74055347e-02f,
  1.04053542e-02f, 2.86007464e-01f, 2.06559852e-01f, 2.77629882e-01f, 2.07272232e-01f, -1.41613096e-01f, 1.29667088e-01f, -8.50950703e-02f, 1.80757582e-01f, 4.65416797e-02f,
  1.05130961e-02f, -2.33793139e-01f, 2.26725206e-01f, 1.63108498e-01f, -4.19978611e-02f, -1.22854039e-02f, 2.10395291e-01f, 4.85184751e-02f, 8.13066736e-02f, 7.79402480e-02f,
  -1.85186088e-01f, 1.12464651e-02f, 1.37692943e-01f, -1.00491062e-01f, 4.89412360e-02f, 1.32427961e-01f, 4.71765064e-02f, -1.54028058e-01f, -6.77595660e-02f, 1.98226050e-01f,
  -1.53842270e-01f, -4.66279685e-02f, 7.63650611e-02f, -1.25217617e-01f, 5.18473201e-02f, -1.04330052e-02f, -1.30960196e-01f, -1.29133880e-01f, -7.23718554e-02f, 2.06240118e-01f,
  1.12696171e-01f, 6.01540878e-02f, 2.50134587e-01f, 1.22063838e-01f, 6.31222501e-02f, -4.13274951e-02f, -2.28336863e-02f, 2.16882780e-01f, 8.26570541e-02f, -1.23119652e-02f,
  1.88421384e-01f, 1.67591646e-01f, 3.41225527e-02f, 2.36923099e-01f, -5.44178486e-02f, -4.39848229e-02f, 2.12261498e-01f, 1.31238982e-01f, 1.69891953e-01f, 2.26645395e-01f,
  -7.26433098e-02f, 1.90466061e-01f, 1.65195048e-01f, 5.40545322e-02f, 2.39162281e-01f, 1.47741228e-01f, -2.31602579e-01f, -9.65939015e-02f, 1.03753529e-01f, -4.27445807e-02f,
  1.48078471e-01f, -2.40577534e-01f, 1.27177194e-01f, -6.19630292e-02f, -2.59062611e-02f, 4.33339365e-02f, -1.49193764e-01f, 2.40062833e-01f, 6.51562437e-02f, 6.14705719e-02f,
  -2.19244584e-02f, 1.34145960e-01f, 1.39985830e-01f, 3.23791094e-02f, 1.90682467e-02f, -1.20613940e-01f, 3.05386037e-01f, -2.78649628e-02f, -2.16034189e-01f, 2.63299376e-01f,
  1.22259051e-01f, -5.60099855e-02f, 3.68696690e-01f, 3.17770578e-02f, 4.33920603e-03f, 2.38489658e-01f, 9.10875127e-02f, 2.01871395e-01f, 1.02977477e-01f, -1.55316010e-01f,
  2.13644758e-01f, 1.92415901e-02f, 1.09546324e-02f, -2.97512636e-02f, 1.46372244e-01f, 1.72098190e-01f, 1.89528093e-01f, 2.79188789e-02f, 2.99782842e-01f, 7.11737424e-02f,
  -1.41057193e-01f, 7.20924288e-02f, -1.07125705e-02f, 1.17101692e-01f, 1.73363358e-01f, 1.51954800e-01f, 9.85640734e-02f, 9.90284011e-02f, 7.00257421e-02f, 2.63873171e-02f,
  1.13072611e-01f, 1.41833007e-01f, -1.95518672e-01f, 1.69980437e-01f, 1.62248552e-01f, 1.98905990e-01f, 6.12426884e-02f, 2.37984121e-01f, 2.34212309e-01f, 1.68699577e-01f,
  -2.39295900e-01f, -1.62323549e-01f, -2.77867198e-01f, 2.18255728e-01f, -1.60377219e-01f, 1.70560166e-01f, 6.60099536e-02f, 9.03968811e-02f, 1.19645141e-01f, 1.67983286e-02f,
  -4.63527478e-02f, 1.18702069e-01f, -8.31260011e-02f, 5.04336320e-02f, -9.71703529e-02f, -2.48677716e-01f, -1.17095418e-01f, -1.93287164e-01f, 1.79697163e-02f, 1.48277460e-02f,
  -1.17345110e-01f, 1.49128526e-01f, 9.35479701e-02f, 3.36211860e-01f, -1.56042278e-01f, 2.23617405e-01f, 1.43208951e-01f, -9.30899829e-02f, 3.49564254e-01f, 8.55545998e-02f,
  2.34241709e-01f, -6.39544725e-02f, -1.14652433e-01f, -2.95357164e-02f, 2.02307016e-01f, -2.25075930e-02f, 2.21332714e-01f, -2.43689284e-01f, -3.60570326e-02f, -1.19662642e-01f,
  1.93183310e-02f, -2.55852968e-01f, 1.66140914e-01f, 2.16798753e-01f, 1.74153209e-01f, 1.08686849e-01f, 9.10442546e-02f, -5.32733016e-02f, 2.82020807e-01f, 1.21184386e-01f,
  1.71115518e-01f, 2.55222887e-01f, 1.08015738e-01f, -3.59347649e-02f, 1.44435894e-02f, 5.59761226e-02f, 2.49259502e-01f, -1.77693710e-01f, 2.08918706e-01f, 2.71292001e-01f,
  4.60245870e-02f, 1.32430419e-02f, 2.57144794e-02f, 1.90536648e-01f, -3.27662587e-01f, -2.55326390e-01f, -1.33790791e-01f, -2.26883039e-01f, 2.72010863e-01f, -6.59940019e-02f,
  -8.75356719e-02f, 2.25495151e-03f, 5.04386835e-02f, 2.81752139e-01f, -1.84008121e-01f, -2.89291814e-02f, -9.46884230e-02f, 2.15129524e-01f, 8.75912234e-02f, 3.21301848e-01f,
  2.58967251e-01f, 3.32416177e-01f, 2.48612836e-01f, -3.64878797e-03f, 8.55645537e-02f, 1.71724632e-01f, -9.94017795e-02f, 2.70906910e-02f, 4.10688445e-02f, -1.93375200e-01f,
  6.36635423e-02f, 8.59059095e-02f, 6.81507140e-02f, -1.78307235e-01f, -7.77889192e-02f, 4.16559055e-02f, -9.29931924e-02f, -1.18461743e-01f, 1.44314826e-01f, 1.06788054e-02f,
  2.24316761e-01f, -2.30403543e-01f, 4.22120728e-02f, 7.36950859e-02f, 4.59480993e-02f, 2.39399076e-02f, -1.22327715e-01f, 2.57870406e-01f, -6.82829320e-02f, -4.53440696e-02f,
  -3.18562649e-02f, 2.32068405e-01f, 1.32751567e-02f, 1.61228999e-01f, 1.25488326e-01f, -2.27496158e-02f, 2.20743433e-01f, 3.41836847e-02f, 1.38878390e-01f, 5.33900075e-02f,
  4.85530719e-02f, -2.03915328e-01f, 5.97831281e-03f, -6.77414834e-02f, -1.66214257e-01f, -2.84725398e-01f, -1.75838038e-01f, -3.45391393e-01f, 2.14333311e-01f, -4.42626663e-02f,
  -2.11844698e-01f, 1.28717363e-01f, 5.47182746e-02f, -2.33154297e-02f, -1.06082454e-01f, 6.10048436e-02f, 1.37345493e-01f, 2.66209304e-01f, -1.88936070e-02f, -2.15915784e-01f,
  1.31797805e-01f, -5.74071780e-02f, -2.07090795e-01f, 1.09655902e-01f, 3.57545018e-01f, 2.17137948e-01f, 2.21170440e-01f, -2.97836997e-02f, 1.52120054e-01f, 2.37434447e-01f,
  5.94812110e-02f, -4.43926714e-02f, 1.01029329e-01f, 2.16897532e-01f, -8.25344119e-03f, -7.49258399e-02f, -7.08202198e-02f, -1.38261626e-02f, -7.07753608e-03f, 2.74088591e-01f,
  1.65810645e-01f, -3.20356488e-02f, -2.41611544e-02f, 1.31799325e-01f, -1.66188270e-01f, -8.47360045e-02f, -1.12965256e-01f, 9.08884108e-02f, -2.01335743e-01f, 3.10105026e-01f,
  1.54914662e-01f, -2.93888878e-02f, 2.83593331e-02f, 2.74242818e-01f, 1.90269016e-02f, 1.33265361e-01f, 1.59471661e-01f, 1.00067191e-01f, 4.45345677e-02f, -1.62473395e-02f,
  1.86207592e-01f, 2.33374074e-01f, 1.80203617e-01f, 4.83308099e-02f, 2.11066276e-01f, 1.57659292e-01f, 2.97218233e-01f, -4.57817763e-02f, 2.26470530e-02f, 1.75183475e-01f,
  -1.18024774e-01f, -3.87372747e-02f, -4.71016020e-02f, -2.71121264e-02f, 3.06076467e-01f, 2.02563360e-01f, 1.56201467e-01f, -5.64487278e-02f, 8.16417262e-02f, 2.47610286e-01f,
  -1.71648562e-01f, -1.38028443e-01f, -3.00733000e-01f, 1.74664795e-01f, 2.11790591e-01f, 3.24953228e-01f, 9.61355567e-02f, -5.57642244e-02f, -2.53241122e-01f, 2.50736773e-01f,
  3.48848969e-01f, 7.74303004e-02f, -7.79545575e-04f, 1.19917631e-01f, -1.79694355e-01f, 2.48459294e-01f, 1.62092000e-01f, 1.87714949e-01f, 1.67216454e-02f, 1.28741339e-01f,
  -1.99863374e-01f, 1.15104742e-01f, -1.58138290e-01f, 4.70537320e-02f, -4.13288735e-02f, 1.21041447e-01f, 3.40510043e-03f, -6.69788644e-02f, -4.72543202e-02f, -6.06046803e-03f,
  1.69355541e-01f, 1.03260383e-01f, -4.73009772e-04f, -1.23327799e-01f, 1.31954685e-01f, 1.03776313e-01f, 1.72836393e-01f, -1.19523324e-01f, 1.34836003e-01f, 2.36575425e-01f,
  7.66183138e-02f, 2.15928882e-01f, 2.33978584e-01f, -7.95204192e-02f, 2.52117276e-01f, 1.75523981e-01f, 9.32897329e-02f, 1.02853961e-01f, -1.63176700e-01f, 1.15655661e-02f,
  -2.31278881e-01f, -2.40172729e-01f, -2.18580276e-01f, -8.87996852e-02f, -1.39527142e-01f, -9.09175277e-02f, 2.92778015e-01f, 2.25681484e-01f, 5.89546096e-03f, 1.62334964e-01f,
  -2.42679000e-01f, 1.68755963e-01f, 2.04746947e-01f, 9.11451876e-02f, 2.34757766e-01f, -1.61731645e-01f, 2.42373288e-01f, 2.00340793e-01f, 6.58140285e-03f, 1.98993057e-01f,
  1.74385324e-01f, -2.20501259e-01f, 1.03490181e-01f, 8.02475307e-03f, 5.35390042e-02f, 1.92029655e-01f, -1.05857782e-01f, 3.76328975e-02f, 2.49335870e-01f, 6.19162470e-02f,
  8.09836462e-02f, 1.84564576e-01f, -4.57700454e-02f, -3.73364612e-02f, 2.32257321e-01f, -1.15217781e-02f, 8.08486119e-02f, -5.79237826e-02f, 1.18623048e-01f, 3.19128275e-01f,
  1.15027599e-01f, -5.47597185e-02f, 3.66901755e-02f, 2.19240531e-01f, 1.12794742e-01f, -1.05404360e-02f, 4.21791784e-02f, 7.40837455e-02f, -1.04952492e-01f, -3.86280008e-02f,
  2.84199901e-02f, 1.89811617e-01f, 8.92415941e-02f, 2.01384932e-01f, 1.26975551e-01f, 5.14642373e-02f, 2.52826363e-01f, 2.30697021e-02f, 1.25340134e-01f, 1.54813603e-02f,
  3.73291671e-02f, 1.57873243e-01f, 1.42067745e-01f, -3.74632962e-02f, -1.23185799e-01f, -1.73574746e-01f, -5.93116507e-02f, -5.72913364e-02f, -1.27090570e-02f, 2.39556074e-01f,
  2.34520033e-01f, 5.15869521e-02f, 1.62835777e-01f, -4.24153544e-02f, 1.49813414e-01f, 1.88957646e-01f, 2.11856708e-01f, -9.73680615e-02f, 1.79341305e-02f, -6.27659336e-02f,
  1.56762213e-01f, 1.40714869e-01f, 2.41644889e-01f, 2.13337585e-01f, 2.19506398e-01f, 6.04393892e-02f, 1.50570035e-01f, 1.83046684e-01f, 7.43918493e-02f, 1.85169384e-01f,
  1.85980216e-01f, 4.74858709e-04f, 1.53011724e-01f, 3.07830051e-02f, 2.67457992e-01f, -1.00623257e-01f, 4.49264422e-02f, 2.58171856e-01f, 2.34224603e-01f, 5.89866899e-02f,
  1.96618676e-01f, 6.04497455e-02f, 2.56293923e-01f, 1.12868354e-01f, -1.83784336e-01f, -4.65264171e-03f, -2.65925258e-01f, 7.97207579e-02f, 1.32119089e-01f, 4.32600677e-02f,
  9.12358388e-02f, 7.03739300e-02f, 5.27760796e-02f, 1.13017321e-01f, 1.71628788e-01f, -2.01699864e-02f, -3.55873927e-02f, 2.64775038e-01f, 1.87347382e-01f, -1.43795803e-01f,
  1.91735297e-01f, 1.51885062e-01f, 1.81425914e-01f, 1.75593987e-01f, 1.59049809e-01f, 7.43915439e-02f, -1.57158777e-01f, -2.74745762e-01f, -4.02481794e-01f, 5.65802753e-02f,
  -9.79849622e-02f, -6.94666579e-02f, 1.86716974e-01f, -8.63549951e-03f, 1.56366527e-01f, 8.27817246e-02f, -3.57410699e-01f, -1.33736670e-01f, 1.91043630e-01f, 1.32034048e-02f,
  6.03742786e-02f, -1.88899875e-01f, 2.20374092e-01f, 1.44705653e-01f, 1.73837140e-01f, 3.12135462e-02f, 5.30763417e-02f, -2.00638488e-01f, -3.42760086e-02f, 1.50604859e-01f,
  3.87643874e-01f, -2.34739035e-01f, -2.68570244e-01f, -1.93677232e-01f, 1.96872279e-01f, -4.43693660e-02f, 2.36367911e-01f, -8.45588222e-02f, 6.61551803e-02f, -1.23705082e-01f,
  -1.87226802e-01f, -3.97338681e-02f, 2.89548993e-01f, 1.76802576e-01f, -1.41922176e-01f, 2.52074212e-01f, 2.95443833e-01f, -1.14755720e-01f, 2.33962104e-01f, 2.07179785e-01f,
  1.92842424e-01f, 1.16220370e-01f, 1.17946183e-03f, -8.84165540e-02f, 8.53696242e-02f, 1.18037894e-01f, 1.21524654e-01f, 1.42751157e-01f, 1.01041831e-01f, 1.80252790e-02f,
  1.49729818e-01f, -3.33498605e-03f, 7.52804056e-02f, 5.32351583e-02f, 1.17358916e-01f, -3.76102813e-02f, 1.88121554e-02f, -5.24695218e-02f, 1.24080174e-01f, 1.17787600e-01f,
  1.96034908e-01f, 2.92235881e-01f, 4.36146669e-02f, -1.90789830e-02f, 2.24817857e-01f, 1.75213113e-01f, 1.58450361e-02f, 2.51758218e-01f, 4.85610450e-03f, 1.47939757e-01f,
  2.96804458e-01f, -3.43673453e-02f, 2.07175910e-01f, -1.12670146e-01f, 2.45896593e-01f, 1.32503137e-01f, 6.43535107e-02f, 1.31940609e-02f, -2.47248122e-03f, 1.19328037e-01f,
  1.71019837e-01f, 1.71310022e-01f, 6.19854107e-02f, -2.16971099e-01f, -1.40246183e-01f, 9.36883613e-02f, -9.07168761e-02f, 1.44791543e-01f, 1.29847219e-02f, -1.36296988e-01f,
  -2.16180354e-01f, 2.58267194e-01f, 2.77161807e-01f, 6.49173632e-02f, 2.74005026e-01f, 2.84990251e-01f, -2.03982711e-01f, 1.44672945e-01f, -6.15933500e-02f, 1.38116941e-01f,
  2.13677734e-01f, -3.88786271e-02f, 3.05542350e-02f, -6.90890327e-02f, -5.55685610e-02f, 1.41196132e-01f, 1.51723176e-01f, 9.09192488e-02f, 2.86498457e-01f, 6.71951920e-02f,
  2.61136740e-01f, -1.88551974e-02f, 1.38939336e-01f, -3.78804132e-02f, 5.56752272e-02f, -6.09710887e-02f, -4.89878207e-02f, 6.59921020e-02f, 1.63016647e-01f, -2.02116482e-02f,
  2.40531564e-02f, -1.44627973e-01f, -8.38512834e-03f, 7.19633326e-02f, -8.67441073e-02f, 3.51513065e-02f, 1.87913954e-01f, -1.97689086e-01f, -7.43755884e-03f, 2.12367490e-01f,
  -3.16574201e-02f, 2.21929431e-01f, 2.06906840e-01f, 2.02076256e-01f, 1.14844285e-01f, 1.41703099e-01f, 8.28187764e-02f, 2.77519494e-01f, 6.61271885e-02f, 3.08735520e-01f,
  1.83873445e-01f, 4.15600054e-02f, 1.34960234e-01f, 2.59574801e-01f, -1.80431738e-01f, 7.25251287e-02f, 1.57963827e-01f, 4.78489026e-02f, -6.96244240e-02f, -1.23263575e-01f,
  1.29612000e-03f, 3.67008328e-01f, -1.08448841e-01f, 1.24423482e-01f, 2.47966111e-01f, -2.49484912e-01f, -1.28890738e-01f, 1.84441179e-01f, 1.26726344e-01f, -4.91884314e-02f,
  1.88755572e-01f, -3.28912511e-02f, 1.42558351e-01f, -1.02992617e-01f, 3.96898650e-02f, 3.75836998e-01f, -1.06749527e-01f, -1.93129271e-01f, 6.34020716e-02f, 7.08236247e-02f,
  1.83860242e-01f, 1.56241268e-01f, -6.17901096e-03f, -6.56670257e-02f, 1.09032109e-01f, 7.81568214e-02f, -1.38395831e-01f, 1.52610093e-01f, -1.88604537e-02f, 9.83625427e-02f,
  6.54270276e-02f, 1.65103316e-01f, -1.19895339e-01f, -1.76583864e-02f, 1.34498268e-01f, -4.82612774e-02f, 5.60044497e-02f, -2.14619279e-01f, 4.38332893e-02f, -2.80332807e-02f,
  1.93565562e-01f, -8.10222253e-02f, -1.16908913e-02f, -3.01730614e-02f, -3.62185240e-01f, -3.59050572e-01f, 2.06217229e-01f, -9.92634073e-02f, 1.97336540e-01f, 1.81100085e-01f,
  -8.12225714e-02f, -1.83007624e-02f, -3.76141700e-03f, 2.75821716e-01f, 1.84522886e-02f, 4.81578223e-02f, -1.31137833e-01f, -6.56512529e-02f, 3.94077636e-02f, 6.64348304e-02f,
  -1.10126644e-01f, -4.37071137e-02f, -4.05399725e-02f, 6.24190122e-02f, 2.08425537e-01f, -1.37603000e-01f, -7.58170113e-02f, 3.48406881e-01f, -1.45927712e-01f, -1.15173765e-01f,
  2.08224878e-02f, 3.04972827e-01f, -1.16664343e-01f, 6.99805468e-03f, -1.21648565e-01f, -5.93717536e-03f, -2.90686879e-02f, 2.08041072e-01f, -1.46453053e-01f, 4.28088009e-02f,
  -1.11802824e-01f, -1.47388235e-01f, 1.06085613e-01f, -2.61570676e-03f, -1.59264192e-01f, -1.23089785e-02f, -2.06914663e-01f, 1.57029748e-01f, -9.90372077e-02f, -1.36474967e-02f,
  8.95661712e-02f, -2.19329726e-02f, 1.42917529e-01f, -6.26792312e-02f, -8.03021565e-02f, 1.08590409e-01f, 2.20249176e-01f, 1.42008781e-01f, -7.75408819e-02f, 9.20549557e-02f,
  -8.80802125e-02f, 1.99949607e-01f, -1.07434548e-01f, 1.07667953e-01f, -9.83270705e-02f, -4.07235436e-02f, -6.28596544e-03f, -2.82174051e-01f, 3.04682463e-01f, -9.58936512e-02f,
  -3.25546674e-02f, 1.12329856e-01f, -4.21546474e-02f, -6.22617081e-02f, -1.64889708e-01f, 3.24367657e-02f, 1.18323557e-01f, -1.79771438e-01f, 1.02030255e-01f, -7.75335729e-02f,
  2.81398594e-01f, 3.81617025e-02f, 7.16303214e-02f, -1.93652466e-01f, 3.74770202e-02f, 6.27116906e-03f, -5.04541695e-02f, -2.04777658e-01f, -2.20857516e-01f, -1.35520756e-01f,
  1.83110923e-01f, -7.44007677e-02f, 3.55945267e-02f, -4.80702557e-02f, -1.79056358e-02f, -5.19380160e-02f, 1.02783248e-01f, 2.04950929e-01f, -1.09789677e-01f, 4.72182408e-02f,
  2.64166564e-01f, 1.19886115e-01f, 2.43307978e-01f, 6.31365255e-02f, 9.87364128e-02f, 1.82969674e-01f, 1.57365993e-01f, 1.56481847e-01f, 1.26157850e-01f, 3.01669002e-01f,
  1.46705702e-01f, 1.78276256e-01f, 1.43021002e-01f, 1.44168437e-01f, -4.54434641e-02f, 9.75380912e-02f, -1.44438287e-02f, 2.21374184e-01f, -1.94251370e-02f, 9.42535922e-02f,
  -6.95610046e-02f, 1.06237456e-01f, 1.28074974e-01f, 1.23193927e-01f, -3.64168510e-02f, -1.81251261e-02f, -1.04935795e-01f, -3.07446569e-01f, -1.38405353e-01f, -1.97169632e-02f,
  -1.70103505e-01f, -2.67431736e-01f, -2.87018955e-01f, -3.30553591e-01f, 2.27425665e-01f, 5.04783206e-02f, -1.40285417e-01f, 5.70942685e-02f, -4.56794463e-02f, -1.58413380e-01f,
  2.62419088e-03f, 1.91356003e-01f, -5.88584738e-03f, 4.12805341e-02f, 8.74203593e-02f, -2.02901199e-01f, 1.57079011e-01f, 1.65824875e-01f, -1.87845603e-02f, 4.91223335e-02f,
  1.52185902e-01f, 4.24838848e-02f, 3.11503172e-01f, -1.02541104e-01f, 2.35717855e-02f, 2.49997139e-01f, -5.26532419e-02f, -2.13901311e-01f, 2.08600760e-02f, 2.22991779e-01f,
  -6.34956285e-02f, -2.02859178e-01f, -9.57013443e-02f, 3.07052191e-02f, -2.62108762e-02f, 2.84669220e-01f, 8.51434991e-02f, 4.65832604e-03f, -9.36739072e-02f, 1.10093631e-01f,
  -8.76332521e-02f, 1.30792946e-01f, -2.05894947e-01f, -1.74433254e-02f, -2.23340243e-01f, 2.08711550e-01f, 1.15257166e-01f, -7.15777352e-02f, -1.79519295e-03f, 9.73980781e-03f,
  -6.41871104e-03f, -2.14287080e-03f, 1.72897235e-01f, -2.13075709e-02f, -2.84330230e-02f, 1.51423058e-02f, 1.42592490e-01f, -4.09702957e-02f, 7.94331357e-02f, 1.04182720e-01f,
  -8.61762241e-02f, 3.51875246e-01f, 1.45067617e-01f, 2.54384637e-01f, -2.62996997e-04f, 7.34591708e-02f, 1.78603426e-01f, -4.32787314e-02f, 1.90700889e-02f, -4.51567248e-02f,
  -1.84962958e-01f, -1.79211721e-02f, -4.64761704e-02f, 2.91811138e-01f, 9.82300788e-02f, -1.57445427e-02f, 1.77382335e-01f, 4.75274250e-02f, 9.34441835e-02f, 1.44222558e-01f,
  2.30235353e-01f, 9.91752073e-02f, 1.62891876e-02f, -1.98983639e-01f, -1.64420933e-01f, -1.07561439e-01f, 1.53957605e-01f, 1.36399448e-01f, 9.01361406e-02f, 1.45643637e-01f,
  2.33240500e-01f, 1.33574978e-01f, 5.14162444e-02f, 2.30213776e-01f, 1.32886991e-01f, -2.28190586e-01f, 2.62331247e-01f, 3.45309019e-01f, 1.99872881e-01f, 8.73820931e-02f,
  9.62101892e-02f, 1.68064520e-01f, 1.42642483e-01f, 8.85942280e-02f, 2.43446156e-01f, 8.46643895e-02f, -1.33269712e-01f, -1.32376194e-01f, 1.15006253e-01f, -1.88494530e-02f,
  2.73403496e-01f, 1.36255184e-02f, -1.58750847e-01f, 1.57119200e-01f, 1.88536435e-01f, 4.86343056e-02f, 1.22124925e-01f, 1.69018760e-01f, -6.00038841e-03f, 3.83089297e-02f,
  5.35091944e-02f, 1.49985626e-01f, 2.39688177e-02f, -3.10637224e-02f, -2.95206398e-01f, 3.35929543e-01f, 7.10056499e-02f, 9.75959077e-02f, 3.97937298e-02f, 2.47847363e-01f,
  -1.66657656e-01f, -3.74975167e-02f, 6.01122417e-02f, -1.92064643e-01f, -1.84872895e-01f, 2.07079455e-01f, 1.00216987e-02f, 8.97308066e-02f, -2.10077949e-02f, 3.19633067e-01f,
  1.91918641e-01f, -1.50602773e-01f, -1.19301744e-01f, 2.40899488e-01f, -1.25441581e-01f, -2.01368891e-02f, -4.66644019e-02f, -2.12904170e-01f, -2.26687729e-01f, -6.55421168e-02f,
  5.86054586e-02f, 2.20438913e-01f, -9.36766528e-03f, 1.79046363e-01f, 6.44678846e-02f, 2.25103512e-01f, -1.17392823e-01f, 2.30369896e-01f, 8.25433657e-02f, -1.61301177e-02f,
  1.06521711e-01f, 1.23086475e-01f, 1.51892275e-01f, -1.42372832e-01f, -1.85290128e-01f, 1.70254081e-01f, 1.23150699e-01f, 9.21216533e-02f, 2.70818383e-01f, -1.45193577e-01f,
  -3.15561295e-02f, -5.74935488e-02f, -4.68106158e-02f, -1.74558207e-01f, 2.08953768e-01f, 1.78446285e-02f, 1.02914102e-01f, 7.02807531e-02f, 1.97395068e-02f, -1.85972705e-01f,
  -1.69812456e-01f, 2.25433260e-01f, 9.90097821e-02f, 2.47952640e-01f, -1.89573348e-01f, -4.76975143e-02f, -6.45836294e-02f, 3.84166352e-02f, 2.37602815e-01f, 2.24715024e-01f,
  2.91443706e-01f, 5.89204542e-02f, 5.59439994e-02f, -1.75230339e-01f, 2.49495655e-01f, -1.30176529e-01f, -1.30356863e-01f, 9.29385573e-02f, 1.29673123e-01f, -2.18100071e-01f,
  9.21916589e-02f, 9.07320380e-02f, 1.19000509e-01f, -2.15755135e-01f, 1.30691603e-01f, 2.83128291e-01f, 7.55141601e-02f, 2.84485787e-01f, -9.59991142e-02f, -1.87484205e-01f,
  6.96704909e-02f, -4.50842939e-02f, -2.23605032e-03f, -1.96607202e-01f, -1.35730505e-01f, -1.87557057e-01f, 8.74330699e-02f, -6.30443022e-02f, -1.54749185e-01f, -7.02064708e-02f,
  1.87847912e-01f, 1.12467661e-01f, 3.64789933e-01f, 1.01128370e-01f, -2.94798255e-01f, -4.01684269e-02f, 2.74357647e-01f, -1.83941564e-03f, 1.30711287e-01f, 3.27356271e-02f,
  -6.53375015e-02f, 4.06704620e-02f, 1.43775418e-01f, 2.38465413e-01f, 1.76500916e-01f, 4.64539021e-01f, 1.62027866e-01f, 5.79658151e-03f, 2.87550360e-01f, 1.33171409e-01f,
  1.55637607e-01f, 2.16507748e-01f, 5.08579127e-02f, -3.67940484e-05f, 1.68339297e-01f, 1.30995107e-03f, 1.64983302e-01f, -9.61008389e-03f, 8.52522030e-02f, 1.26171947e-01f,
  1.35715947e-01f, 3.58110368e-02f, 2.27766167e-02f, -2.34272391e-01f, 3.02194029e-01f, -1.59723371e-01f, -1.69519484e-01f, 1.10181332e-01f, -2.36533582e-01f, 1.14212751e-01f,
  -8.28989074e-02f, 2.97286082e-02f, 9.53627601e-02f, 2.23190069e-01f, 1.35512471e-01f, 6.88516200e-02f, -9.01064277e-02f, 2.72612065e-01f, 9.68603492e-02f, 2.19756842e-01f,
  3.62433121e-02f, -9.64098200e-02f, -1.59143478e-01f, 2.70995587e-01f, 1.45551413e-01f, 2.49729246e-01f, 2.08359942e-01f, 1.99084997e-01f, 2.77212590e-01f, 1.85032606e-01f,
  -1.47161275e-01f, 2.81466126e-01f, 7.68592209e-02f, -2.62179434e-01f, -4.11697924e-02f, -4.89211828e-03f, 1.08958371e-01f, 1.91697374e-01f, 1.50270566e-01f, -1.39009088e-01f,
  7.05570057e-02f, -8.88776593e-03f, -5.69093116e-02f, 1.21303789e-01f, -1.49045199e-01f, -2.78519124e-01f, 2.56971627e-01f, -8.70213956e-02f, 2.61710286e-01f, -7.75029697e-03f,
  1.97164025e-02f, 3.32001925e-01f, -5.78288063e-02f, 2.62009531e-01f, -4.22083065e-02f, 3.71072516e-02f, 2.65440382e-02f, 6.15544729e-02f, 1.84101928e-02f, 1.58295527e-01f,
  8.40661898e-02f, 2.36188561e-01f, 6.00368828e-02f, -3.93587956e-03f, 1.42084181e-01f, 1.16282053e-01f, -1.59644037e-01f, -2.83623308e-01f, -5.13796434e-02f, 1.80261105e-01f,
  -3.93469706e-02f, -1.34931386e-01f, 2.70679384e-01f, -2.26193219e-02f, -2.79967695e-01f, -1.91588342e-01f, -2.03875050e-01f, -3.79989818e-02f, 1.43953010e-01f, 5.16002700e-02f,
  3.01323812e-02f, 2.73619238e-02f, 3.17679048e-01f, 2.18134344e-01f, 2.52928764e-01f, -1.95657723e-02f, -2.23459408e-01f, -3.52529019e-01f, -7.10498691e-02f, 4.09671783e-01f,
  2.79353291e-01f, -1.21619672e-01f, -1.34777889e-01f, -1.05502352e-01f, -3.75556685e-02f, -1.85861569e-02f, 2.21068010e-01f, -6.46114275e-02f, -2.48018250e-01f, -9.71753374e-02f,
  1.36567250e-01f, 1.32087529e-01f, 2.80508727e-01f, -2.65265226e-01f, 7.55926743e-02f, 4.01056334e-02f, 1.28629193e-01f, -7.58114308e-02f, 2.89694220e-02f, -1.42418202e-02f,
  3.17021430e-01f, -1.25938684e-01f, 9.04549137e-02f, 1.53894812e-01f, -5.74921742e-02f, 2.08140373e-01f, 5.86636700e-02f, 2.46687740e-01f, -1.76000374e-03f, 2.16549188e-01f,
  -8.37138295e-02f, -9.20303166e-03f, 2.09975600e-01f, -8.12660437e-03f, -7.96866044e-02f, 1.16354153e-01f, -8.06468502e-02f, -5.14653660e-02f, 6.74654692e-02f, 1.48992643e-01f,
  -2.42963493e-01f, 9.22864527e-02f, 2.14662418e-01f, 1.56338781e-01f, 1.96056843e-01f, 1.08106427e-01f, 1.85289428e-01f, 2.18472984e-02f, -1.07799530e-01f, 1.22343153e-02f,
  -2.38378614e-01f, 1.37716621e-01f, -1.28218740e-01f, 3.86422290e-03f, -2.90359519e-02f, 1.82781324e-01f, 2.20920697e-01f, -8.17251429e-02f, -2.63589807e-02f, 1.15126796e-01f,
  -1.94803029e-02f, -3.74219753e-02f, -1.37693092e-01f, -2.62548774e-01f, -1.41277567e-01f, -2.18544498e-01f, 9.00223106e-02f, -1.92998528e-01f, 9.77986529e-02f, 1.81600481e-01f,
  9.51538756e-02f, 1.83573693e-01f, -1.66771114e-01f, 2.85301626e-01f, 1.32033248e-02f, -1.50873214e-01f, 1.41205758e-01f, 1.88230470e-01f, -7.03703240e-02f, -4.42277268e-02f,
  -2.71410674e-01f, 5.40365651e-02f, 1.72555760e-01f, -1.01387324e-02f, 3.81472290e-01f, 1.92084480e-02f, 4.71054576e-02f, 1.75070837e-01f, 1.00782260e-01f, -2.52235651e-01f,
  4.64788862e-02f, 1.54985368e-01f, 4.47609499e-02f, 1.42181898e-02f, 9.24939662e-03f, 1.07422769e-01f, -4.97737341e-02f, 3.59538314e-03f, 7.12980032e-02f, 1.48244612e-02f,
  6.59838915e-02f, -5.98641299e-02f, 7.61430338e-02f, -2.10420135e-03f, 9.81113613e-02f, 2.08398312e-01f, -5.54249734e-02f, -1.53730318e-01f, 7.84546137e-02f, 4.55101058e-02f,
  -2.74031349e-02f, 5.48011027e-02f, 2.44637564e-01f, 2.68251330e-01f, 1.94089472e-01f, 4.00060602e-02f, 1.65053353e-01f, 7.08725378e-02f, 2.48411492e-01f, 7.47636557e-02f,
  -1.85985237e-01f, 2.81551760e-02f, -8.23279098e-02f, 4.74197753e-02f, 2.21130624e-01f, 1.73290387e-01f, 2.51888096e-01f, -4.78980206e-02f, -4.97094877e-02f, 2.16185480e-01f,
  1.00512549e-01f, 1.50996983e-01f, 2.20731720e-01f, -1.65092543e-01f, -1.35293351e-02f, 1.03764154e-01f, 2.10075110e-01f, -8.44724551e-02f, 2.65761875e-02f, 7.79394386e-03f,
  -1.42554697e-02f, 2.34498918e-01f, 1.07613765e-01f, 4.41937186e-02f, 7.64245391e-02f, 1.18988000e-01f, -1.62618205e-01f, -3.76243964e-02f, -6.56359419e-02f, 1.62958249e-01f,
  1.71378836e-01f, -9.54308584e-02f, 1.62663117e-01f, 1.72277331e-01f, 1.55859843e-01f, 3.17645371e-02f, 9.20151845e-02f, -4.31742109e-02f, 1.24325559e-01f, 8.34379196e-02f,
  1.40716285e-01f, 1.50627226e-01f, 1.07526250e-01f, 1.40907735e-01f, -7.84538034e-03f, 5.12470156e-02f, 3.49735399e-03f, 1.15798168e-01f, 1.12262137e-01f, 4.46645655e-02f,
  -5.68654155e-03f, -8.20052065e-03f, 1.89919829e-01f, 1.36978533e-02f, -3.60767245e-02f, 2.41472870e-01f, -1.22104898e-01f, 1.71845123e-01f, 1.92440167e-01f, 1.15263974e-02f,
  2.15033904e-01f, 1.03821270e-01f, 1.25282452e-01f, 1.05221039e-02f, 6.25278503e-02f, -1.20695718e-01f, 6.23175055e-02f, 2.84548640e-01f, 1.94531769e-01f, 2.99380794e-02f,
  1.15527421e-01f, -5.31671848e-03f, -1.13646783e-01f, -2.31362646e-03f, -1.20527104e-01f, 1.59698665e-01f, 1.21361442e-01f, -1.14373788e-01f, -5.83350807e-02f, -5.18130027e-02f,
  2.44209141e-01f, -4.54133935e-02f, 2.74923474e-01f, 1.52388707e-01f, 1.45286322e-01f, 1.48918945e-02f, 1.82022005e-01f, 1.01819053e-01f, 1.05657503e-01f, 1.85484529e-01f,
  -8.99483785e-02f, -3.95270996e-02f, 9.51640531e-02f, 3.03438932e-01f, 2.46490583e-01f, 1.80290520e-01f, 3.02474946e-01f, -2.01956853e-02f, 1.90439239e-01f, 2.07315702e-02f,
  -3.13551202e-02f, 2.57763207e-01f, 2.01381698e-01f, 1.13054968e-01f, 2.98879087e-01f, 2.31314693e-02f, 2.63537675e-01f, 2.44303048e-01f, 1.70305938e-01f, 1.13624178e-01f,
  1.78672880e-01f, 9.51005071e-02f, -9.24099386e-02f, -7.77881071e-02f, -2.60610253e-01f, 2.30707839e-01f, -1.55450925e-01f, -1.60637498e-01f, 1.24815322e-01f, -7.13392273e-02f,
  -7.83535242e-02f, -3.87776308e-02f, -3.36606354e-01f, -2.18667448e-01f, 2.11106669e-02f, -2.88783666e-02f, 1.00456096e-01f, -1.35303900e-01f, 1.26106605e-01f, 1.57003909e-01f,
  1.77060023e-01f, 1.37007207e-01f, 2.67353386e-01f, -8.75881240e-02f, -1.88561246e-01f, 1.03819922e-01f, 2.58638710e-01f, 3.62659767e-02f, -3.35925184e-02f, -2.37494558e-01f,
  3.24517816e-01f, 3.14313769e-02f, 2.31138363e-01f, 2.17803925e-01f, 1.41609490e-01f, -4.80593666e-02f, 2.69085634e-02f, 1.85928375e-01f, 3.23404253e-01f, 3.11996162e-01f,
  6.41878024e-02f, 3.95597994e-01f, 1.63621232e-01f, -1.48131445e-01f, 1.93876654e-01f, 3.87793183e-01f, 2.03663662e-01f, 1.04345396e-01f, -1.47156879e-01f, -7.37973079e-02f,
  1.23324024e-03f, 1.04339488e-01f, 1.17369615e-01f, 1.06548324e-01f, 2.03184430e-02f, 1.32728472e-01f, 2.09849104e-01f, 1.39259860e-01f, 2.24781841e-01f, 9.75454897e-02f,
  -5.65189077e-03f, 2.74718761e-01f, 1.69160832e-02f, 7.90532827e-02f, 2.48059168e-01f, 9.54364389e-02f, -8.33939761e-02f, 2.04220131e-01f, 2.05433890e-01f, 3.61181825e-01f,
  2.14278266e-01f, 2.07960486e-01f, 3.43030393e-01f, 1.40097916e-01f, -1.92170709e-01f, -3.16052020e-01f, -8.18499252e-02f, -1.45761177e-01f, 9.52273887e-03f, -3.36178273e-01f,
  -1.03473499e-01f, -1.36292353e-01f, 1.84228539e-01f, -2.45612245e-02f, -2.03562621e-02f, -9.53455083e-03f, -2.59358853e-01f, -1.71303097e-02f, -3.93726528e-02f, -1.78080034e-02f,
  4.43218574e-02f, 5.57774082e-02f, 1.44820400e-02f, -2.48898804e-01f, 1.56042278e-01f, -3.95715162e-02f, 1.15146086e-01f, 1.71983302e-01f, 3.97452414e-02f, -1.91395983e-01f,
  2.35203385e-01f, 2.94032782e-01f, -4.15088423e-02f, 7.34251365e-02f, 1.02968030e-01f, 5.30864671e-02f, -1.23660013e-01f, -2.83278018e-01f, 3.25712740e-01f, 4.59314138e-02f,
  3.14783633e-01f, -1.99088246e-01f, 1.18025109e-01f, 1.62184298e-01f, 1.12708323e-01f, -1.85188070e-01f, -3.47191356e-02f, 1.89383686e-01f, 1.66346684e-01f, 1.52563766e-01f,
  2.12459147e-01f, 4.28034440e-02f, 1.52528092e-01f, 6.07863255e-02f, 9.64858979e-02f, 1.41882896e-01f, 3.02755479e-02f, 6.13122247e-02f, 2.59313881e-01f, 1.62350744e-01f,
  1.18232682e-01f, 6.09980896e-02f, 1.69343293e-01f, -2.38984041e-02f, 2.09923342e-01f, 2.23788127e-01f, -2.06965894e-01f, 1.13404281e-01f, -1.93215817e-01f, -8.50053057e-02f,
  2.42851943e-01f, 2.10571781e-01f, 1.81275949e-01f, -1.54368088e-01f, 1.54028937e-01f, 2.45640025e-01f, 4.90162075e-02f, -1.96455941e-01f, -3.23609293e-01f, 4.40413766e-02f,
  -1.24727786e-02f, 3.00570875e-01f, 3.13908219e-01f, -4.97692339e-02f, -6.74314201e-02f, 2.07979023e-01f, 2.84977525e-01f, 1.78622827e-01f, -8.67142230e-02f, 1.84081540e-01f,
  -1.11373462e-01f, 1.61817119e-01f, 5.38765416e-02f, 2.51028687e-01f, 2.74612784e-01f, 2.07238615e-01f, -1.88004047e-01f, -7.02292621e-02f, -8.60312432e-02f, -1.70049280e-01f,
  -1.60744682e-01f, -8.36302713e-02f, 1.08928949e-01f, -2.22433254e-01f, 1.17350578e-01f, -1.55719936e-01f, 1.90693095e-01f, 1.20862812e-01f, 3.32601555e-02f, -1.05063431e-01f,
  5.24045639e-02f, 2.01659381e-01f, 2.87011415e-01f, 9.26813670e-03f, 7.51385605e-03f, 1.11221127e-01f, 6.60837516e-02f, 2.22934023e-01f, 2.14953333e-01f, 1.06296048e-01f,
  2.43656516e-01f, 7.41589963e-02f, 4.74734977e-03f, 1.17567711e-01f, 2.11985499e-01f, -1.15232142e-02f, -1.39132440e-01f, -8.10511783e-02f, -9.72151235e-02f, -1.01930670e-01f,
  -1.39341265e-01f, -9.59522799e-02f, 2.30607167e-01f, 2.65633106e-01f, 2.18043745e-01f, 4.01470996e-02f, 9.53539610e-02f, 8.81962199e-03f, 2.96248376e-01f, 5.30211553e-02f,
  -1.44374475e-01f, 1.45324133e-02f, 1.46436756e-02f, 5.10596633e-02f, 2.17687517e-01f, 4.08473015e-01f, 1.89704999e-01f, 5.94600216e-02f, 2.35756069e-01f, 3.19804937e-01f,
  8.13102499e-02f, 2.59193450e-01f, 1.71494722e-01f, 6.82686865e-02f, -9.15147662e-02f, 1.53864965e-01f, 3.01460177e-01f, -8.51287916e-02f, 1.05607122e-01f, 7.91831911e-02f,
  -8.30399767e-02f, 4.32397425e-02f, -1.52680576e-01f, -1.68816913e-02f, -5.77529659e-03f, 4.62310500e-02f, -1.14384964e-01f, 5.60467243e-02f, -1.95453420e-01f, 1.60209402e-01f,
  9.24028456e-02f, -8.32663327e-02f, 1.67035803e-01f, 9.30775627e-02f, 5.25282286e-02f, -2.64733564e-03f, 3.94587731e-03f, 2.57598698e-01f, 1.71095669e-01f, 2.12052286e-01f,
  5.42771742e-02f, 9.83456448e-02f, 8.46015513e-02f, 1.65033162e-01f, 2.16380239e-01f, 1.83734670e-01f, 1.27442896e-01f, 1.24889247e-01f, 5.90031594e-02f, 2.31226474e-01f,
  1.07139841e-01f, 2.34359145e-01f, 3.06444410e-02f, -1.34022519e-01f, -2.07079679e-01f, -1.65635586e-01f, -6.77536801e-02f, 3.35782133e-02f, 2.28869408e-01f, -1.18993804e-01f,
  1.64203033e-01f, -2.30150931e-02f, 1.07860621e-02f, -1.20780490e-01f, -1.54661506e-01f, 7.46410489e-02f, 2.70670075e-02f, 1.49787530e-01f, 2.01180041e-01f, 1.95678040e-01f,
  -1.36774734e-01f, -7.78374597e-02f, 6.48481771e-02f, 3.22433025e-01f, 3.06423753e-01f, -1.04221985e-01f, 2.18916237e-01f, 6.80417120e-02f, -2.47792274e-01f, 1.61431372e-01f,
  2.53783494e-01f, 1.12096854e-01f, -2.50068959e-03f, 2.51625385e-02f, -1.36811942e-01f, 3.01114798e-01f, 2.90572457e-02f, 2.42167979e-01f, 1.83371767e-01f, -2.35546082e-02f,
  -9.29822251e-02f, 1.32873118e-01f, -3.58719472e-03f, 7.85655677e-02f, -1.70220450e-01f, -8.97918791e-02f, 6.57548904e-02f, 1.59150973e-01f, 3.45194131e-01f, 8.19071680e-02f,
  1.67803466e-01f, -2.41677791e-01f, -3.24043781e-02f, -9.38969105e-02f, -2.38850132e-01f, 6.84478804e-02f, 2.00213324e-02f, -1.49334475e-01f, -2.12531164e-01f, -1.64761052e-01f,
  3.12573984e-02f, 4.04832448e-04f, 2.81579852e-01f, 1.66706175e-01f, 2.73616254e-01f, -2.71171182e-01f, -1.60160661e-01f, 5.72281294e-02f, -1.89810451e-02f, 1.50309145e-01f,
  5.90102263e-02f, 2.94629615e-02f, 7.69486055e-02f, -1.21303298e-01f, 1.04798995e-01f, -7.84664974e-02f, 1.07900217e-01f, -4.17146981e-02f, -3.42109025e-01f, 2.21448969e-02f,
  -5.64387254e-03f, -4.43776958e-02f, 1.04736239e-01f, -1.12075895e-01f, 2.83194776e-03f, -2.08085775e-03f, 7.53508136e-02f, 2.49699473e-01f, -2.68330395e-01f, -7.83743411e-02f,
  -2.21350774e-01f, -2.65780419e-01f, 7.18640909e-02f, 1.57657176e-01f, -1.05956241e-01f, 6.42849132e-02f, -1.31230876e-01f, -1.12095438e-01f, 8.30535814e-02f, 4.65808809e-02f,
  -5.58585674e-02f, -2.53433678e-02f, -9.12818089e-02f, -2.29268163e-01f, -1.95079483e-02f, -2.13377461e-01f, 1.19639531e-01f, -9.40005258e-02f, -2.21654564e-01f, 5.72367869e-02f,
  -1.80808395e-01f, 8.24660957e-02f, -1.29161105e-01f, 1.40678361e-01f, -5.91869175e-04f, 2.19113976e-01f, 1.19824089e-01f, 8.12725350e-02f, 1.27671346e-01f, 1.32667139e-01f,
  5.35505489e-02f, -6.35970086e-02f, 4.90174852e-02f, 1.87839016e-01f, 1.43821254e-01f, 9.61442068e-02f, 1.66570634e-01f, 2.05599487e-01f, 1.29145727e-01f, -2.68434435e-02f,
  5.47095947e-02f, -2.41889823e-02f, -2.45097831e-01f, 1.31053716e-01f, -1.66790023e-01f, 1.12792628e-03f, 2.06010282e-01f, 5.58726164e-03f, 1.61395669e-01f, -7.01873302e-02f,
  1.68494493e-01f, 7.15039447e-02f, -2.02890322e-01f, -7.03390464e-02f, -5.30733839e-02f, -7.17767747e-03f, 2.15007573e-01f, 3.48178148e-01f, 2.58092195e-01f, 2.53470004e-01f,
  -3.19261216e-02f, 2.56009579e-01f, 2.20401883e-01f, 1.78904876e-01f, 2.26634204e-01f, -4.29421738e-02f, -1.58408493e-01f, 7.85763264e-02f, 2.96837747e-01f, -3.41572687e-02f,
  1.55922368e-01f, 2.39223227e-01f, 2.53440030e-02f, 1.28661081e-01f, 5.86312301e-02f, -4.92376387e-02f, 1.20183744e-01f, 1.34689450e-01f, -4.38823439e-02f, -1.90422311e-01f,
  -1.91703975e-01f, 7.83295780e-02f, 6.67150691e-02f, 4.50555086e-02f, 2.08950758e-01f, 1.11269407e-01f, 6.68555945e-02f, 1.63236991e-01f, 4.38871905e-02f, 1.01743922e-01f,
  2.02824846e-01f, 2.82525092e-01f, 1.64249659e-01f, 8.88128057e-02f, 1.98877767e-01f, -3.99796739e-02f, 2.58636713e-01f, 1.03042945e-01f, 1.39260843e-01f, 9.72910039e-03f,
  -1.96120486e-01f, -8.32878053e-02f, 1.83442652e-01f, -1.33151397e-01f, -6.26331493e-02f, 3.16242307e-01f, -2.32128918e-01f, 1.97857857e-01f, -5.34870289e-02f, -2.44337201e-01f,
  -4.69745770e-02f, 2.38654494e-01f, 6.85204715e-02f, 2.10414514e-01f, 1.31900504e-01f, 2.44271293e-01f, 2.30860129e-01f, 8.79339650e-02f, 1.05117045e-01f, -6.00597635e-02f,
  -4.50606309e-02f, 2.00254411e-01f, 3.07227403e-01f, 5.01834825e-02f, 3.97271477e-02f, 3.14339459e-01f, 3.20144594e-01f, 1.96473256e-01f, -4.90758866e-02f, 2.16991633e-01f,
  1.88229516e-01f, 1.91638783e-01f, -4.47593629e-03f, 8.23278353e-02f, -7.56710097e-02f, 1.24452561e-01f, 3.83106202e-01f, -7.30776191e-02f, 1.11417070e-01f, -1.21847212e-01f,
  -1.64737348e-02f, 7.05599636e-02f, 1.22124784e-01f, -4.63811755e-02f, -6.09438159e-02f, -6.93027005e-02f, 2.06070691e-01f, -1.35404140e-01f, -5.07739112e-02f, 2.02198550e-01f,
  -2.66114920e-01f, 1.41540155e-01f, 1.70886755e-01f, 8.96185338e-02f, 1.05903886e-01f, 2.77232021e-01f, 1.36765599e-01f, 1.59630433e-01f, 1.05798125e-01f, 1.59946829e-01f,
  3.57499602e-03f, 6.85147792e-02f, 2.21426308e-01f, 2.01828495e-01f, 1.50195792e-01f, 1.29146660e-02f, -1.53455259e-02f, 3.04228961e-01f, 1.14905484e-01f, -1.34205535e-01f,
  -1.93909220e-02f, -1.70921534e-02f, -4.85367440e-02f, -1.58781499e-01f, -2.36112371e-01f, -1.96152776e-01f, 3.47155035e-01f, -2.31590882e-01f, 1.76662728e-01f, 2.26705032e-03f,
  6.13203347e-02f, 2.85567194e-01f, -3.62102538e-02f, 8.32486078e-02f, 8.74901861e-02f, 9.60548669e-02f, -1.79976165e-01f, 1.58300519e-01f, 1.67933047e-01f, 2.12093785e-01f,
  2.21801147e-01f, -2.14585677e-01f, 2.52043575e-01f, 1.04008757e-01f, -2.13381931e-01f, 1.25982776e-01f, 1.20328799e-01f, 1.44957155e-01f, 1.61888167e-01f, 7.74969235e-02f,
  -2.89498549e-02f, 2.75994152e-01f, -3.06384135e-02f, 2.71111995e-01f, 1.50737256e-01f, -2.74836838e-01f, 3.16447020e-01f, 3.43532890e-01f, 9.22377631e-02f, -2.32290793e-02f,
  -6.44530803e-02f, -1.00919612e-01f, 3.10770236e-02f, 2.44096413e-01f, 2.36169130e-01f, 1.69317737e-01f, 1.41549092e-02f, 3.38899642e-02f, -4.11194339e-02f, 1.32573321e-01f,
  -5.73381819e-02f, 2.68113101e-03f, 1.74346074e-01f, 6.69298321e-02f, 2.71766067e-01f, 1.87386632e-01f, 1.06324963e-01f, 7.29985069e-03f, -3.54003966e-01f, -7.01159313e-02f,
  -3.14364463e-01f, -1.99285567e-01f, -1.65939033e-01f, 2.42467467e-02f, -4.63915095e-02f, -6.32504001e-02f, 2.75017440e-01f, 1.81346163e-01f, -4.36591990e-02f, 2.48598903e-01f,
  -2.50180542e-01f, 3.47685814e-01f, 2.88482606e-02f, 2.01232210e-01f, 3.01546544e-01f, -1.51046485e-01f, 3.45163912e-01f, 6.60441741e-02f, -2.92528458e-02f, -1.69020370e-01f,
  -1.62267424e-02f, -1.89955235e-01f, 5.92411533e-02f, -2.57757604e-01f, -5.60254380e-02f, 2.23022029e-01f, -2.07475796e-02f, 1.04084782e-01f, 3.47692043e-01f, -7.39122108e-02f,
  1.36287222e-02f, 1.95384532e-01f, -3.44848968e-02f, -3.81574892e-02f, 3.44013155e-01f, 3.03317010e-02f, 2.50705272e-01f, 7.24135414e-02f, 1.31841868e-01f, 1.73029318e-01f,
  4.57690358e-02f, 7.11023360e-02f, 1.50638193e-01f, 9.48732346e-02f, 1.99335203e-01f, 9.88501683e-03f, 1.39797807e-01f, 7.45666996e-02f, -8.76973271e-02f, -1.36072701e-03f,
  1.21740796e-01f, 1.12060823e-01f, -8.93228501e-02f, -6.84649050e-02f, 1.39598221e-01f, 4.41696458e-02f, 8.23701620e-02f, 1.51143536e-01f, 1.51823848e-01f, 8.99713188e-02f,
  1.71831891e-01f, 1.76346779e-01f, -7.45396391e-02f, 2.68619001e-01f, -3.71004343e-02f, 9.71079692e-02f, 2.41127133e-01f, 2.86878943e-01f, 2.13697702e-01f, 1.90067932e-01f,
  -1.03826798e-01f, -1.03123756e-02f, -1.20691568e-01f, -1.28668491e-02f, -9.66557860e-02f, 9.67051089e-02f, 1.83878615e-02f, 1.78216353e-01f, 8.32564160e-02f, -1.03778169e-01f,
  -1.00938223e-01f, 2.69098103e-01f, -7.48381913e-02f, 2.36172274e-01f, 1.35509953e-01f, -1.99529290e-01f, -3.22811097e-01f, -2.66749095e-02f, 8.48734602e-02f, 2.56551623e-01f,
  7.91308358e-02f, -5.86770335e-03f, 1.48803666e-01f, 1.51889145e-01f, 8.02598223e-02f, 4.27165888e-02f, 1.09594809e-02f, -1.36385098e-01f, 2.19822660e-01f, 1.87822670e-01f,
  -1.82730466e-01f, -2.33577564e-01f, -1.97566882e-01f, -1.00938382e-03f, 3.48917603e-01f, -5.70608377e-02f, 2.25460857e-01f, 5.92514277e-02f, 6.92443252e-02f, -1.34128883e-01f,
  1.25170145e-02f, -3.45688134e-01f, 2.01022789e-01f, -7.12541342e-02f, 4.34291549e-04f, 1.70665696e-01f, -1.90849565e-02f, 1.48539260e-01f, 1.18709311e-01f, 2.46122003e-01f,
  -5.99174462e-02f, 1.01622470e-01f, 1.90203652e-01f, 1.92920357e-01f, 1.01341046e-01f, -1.27580995e-02f, -4.13850807e-02f, 9.77232158e-02f, 2.95202047e-01f, 1.02329135e-01f,
  -4.50126268e-02f, 2.45485678e-01f, -3.12804282e-01f, -2.31907383e-01f, -6.60609603e-02f, -9.71921533e-02f, 1.62803531e-01f, 8.94458219e-02f, -1.32952422e-01f, -2.39900962e-01f,
  3.92405875e-02f, 2.82640100e-01f, -1.10060118e-01f, -2.44570732e-01f, -1.71253979e-02f, -1.68036111e-02f, 5.69762886e-02f, 2.42812961e-01f, -1.22218765e-02f, -9.98057574e-02f,
  -2.83915877e-01f, 8.82638171e-02f, 3.09193909e-01f, 5.30244373e-02f, 1.21521533e-01f, 2.65400052e-01f, -1.23973809e-01f, 3.49428833e-01f, 1.46304861e-01f, 3.28418463e-01f,
  1.23576231e-01f, -7.41452351e-02f, -2.14589879e-01f, 1.80628002e-01f, -1.30278125e-01f, 2.78868172e-02f, -2.11778000e-01f, -1.22471109e-01f, 1.81946054e-01f, -1.29256412e-01f,
  1.41677409e-01f, -6.22566678e-02f, -6.19064346e-02f, -2.32655499e-02f, 9.09931958e-02f, -1.01006487e-02f, -1.87690020e-01f, -1.44766476e-02f, 2.32434832e-02f, 3.32452029e-01f,
  2.49021679e-01f, 3.69559340e-02f, 7.94062763e-02f, 1.69290423e-01f, 1.65430456e-01f, 2.17675686e-01f, 4.19311374e-02f, 9.11004767e-02f, 2.20271841e-01f, 1.89741105e-01f,
  6.49789199e-02f, -2.33590435e-02f, 3.16065885e-02f, 7.76457861e-02f, -1.06494419e-01f, 3.27983242e-03f, 2.95064468e-02f, -2.68267632e-01f, -3.63817513e-01f, -2.84842938e-01f,
  -1.39475549e-02f, -1.93829790e-01f, 2.16683209e-01f, -2.79155344e-01f, -6.55035898e-02f, 1.43389434e-01f, 1.17336102e-02f, 1.94912553e-01f, -1.85119167e-01f, 4.91293846e-03f,
  1.69821262e-01f, 3.24277021e-02f, -2.37980396e-01f, 3.96426678e-01f, 3.45608294e-01f, -3.82785243e-03f, 2.42110699e-01f, -3.08274001e-01f, 1.78978845e-01f, 2.86921293e-01f,
  -2.39580557e-01f, 6.78188279e-02f, 5.31169139e-02f, 1.11099631e-01f, 3.50392163e-01f, 1.86845273e-01f, -1.58158869e-01f, 1.96136117e-01f, 1.01198852e-01f, 1.93810344e-01f,
  1.57593563e-02f, -1.27208188e-01f, 2.40477264e-01f, 1.68672517e-01f, 2.25082129e-01f, -1.02953628e-01f, 4.11765166e-02f, 9.64270607e-02f, -6.38875738e-02f, 1.38624206e-01f,
  1.24641202e-01f, 1.75482765e-01f, 1.11687124e-01f, -1.01249501e-01f, 1.62959814e-01f, 3.59122045e-02f, 9.93628725e-02f, 2.11527437e-01f, 5.71013838e-02f, 4.04998800e-03f,
  -7.61351213e-02f, 5.61133251e-02f, -1.44412890e-01f, 1.41944557e-01f, 1.35239121e-02f, 1.23550102e-01f, -7.95911923e-02f, -1.78490981e-01f, -4.75490373e-03f, -1.90424547e-01f,
  2.64315873e-01f, 1.79862678e-02f, 1.46227628e-01f, 5.63529283e-02f, 1.06937855e-01f, -2.91243434e-01f, -1.60853975e-02f, 1.99009068e-02f, 1.02827042e-01f, -2.23054796e-01f,
  8.93033147e-02f, 1.43524602e-01f, 1.79132268e-01f, 2.36734733e-01f, 1.40348867e-01f, -2.10012019e-01f, -7.77943656e-02f, -5.56058586e-02f, 2.00916808e-02f, -1.13724470e-01f,
  -2.91094244e-01f, -1.30199507e-01f, 1.49707913e-01f, -1.01612955e-01f, -2.47504581e-02f, -2.40473107e-01f, 7.99204037e-02f, -4.08779718e-02f, 1.57665268e-01f, 2.06152976e-01f,
  -2.36011922e-01f, 9.48050246e-02f, 2.34666184e-01f, 1.86399564e-01f, 3.01495850e-01f, 1.88728973e-01f, -7.23816361e-03f, 3.50084645e-03f, 4.07705009e-02f, 2.78679132e-01f,
  1.72485799e-01f, 1.62470877e-01f, 9.53987241e-02f, 4.31990959e-02f, 8.90078247e-02f, -2.28454005e-02f, -2.42073601e-03f, 5.63151203e-02f, 1.80135369e-01f, -6.88819811e-02f,
  -1.85865201e-02f, 2.86689073e-01f, -1.71888061e-02f, 4.52828854e-02f, -1.47833135e-02f, 5.44055626e-02f, -3.02740671e-02f, 1.87814698e-01f, 2.40288675e-01f, 1.74233884e-01f,
  1.05673775e-01f, -5.70808984e-02f, 2.26442054e-01f, 3.10558797e-04f, 1.60666376e-01f, 6.06830604e-02f, -3.28074791e-03f, 5.59045672e-02f, 2.43749008e-01f, -1.57882914e-01f,
  1.11396417e-01f, -8.15393329e-02f, 2.38954023e-01f, -1.43432423e-01f, 9.66033936e-02f, -8.01012516e-02f, 7.06189275e-02f, 2.50936031e-01f, 1.60842910e-01f, -4.37235534e-02f,
  -7.22405836e-02f, -1.85314491e-01f, -4.10454487e-03f, 6.10028468e-02f, 1.57537535e-01f, -1.58250749e-01f, 2.47684687e-01f, -1.36017010e-01f, -2.09796026e-01f, -3.88745740e-02f,
  2.78244853e-01f, 1.35362074e-01f, 1.75628603e-01f, 9.78195593e-02f, -2.84503549e-01f, 2.34854996e-01f, 2.12943062e-01f, 2.13484332e-01f, 3.29173803e-02f, 6.03111163e-02f,
  -7.74000883e-02f, -9.08955708e-02f, 1.62107512e-01f, 1.88860774e-01f, 1.40414640e-01f, 2.14933470e-01f, 8.04055110e-02f, -7.67837167e-02f, 2.63418108e-01f, -7.23480582e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.76232308e-01f, 1.13157988e-01f, 1.74003243e-01f, 1.27134949e-01f, 1.42404974e-01f, 1.86486959e-01f, 1.68955326e-01f, 2.04274178e-01f, 2.29610786e-01f, 1.02376558e-01f,
  6.87422156e-02f, 2.14397654e-01f, 1.34167835e-01f, -1.06172441e-02f, 6.70951530e-02f, 1.68804049e-01f, 1.73157156e-01f, 1.41492426e-01f, 3.27152275e-02f, -9.38049238e-03f,
  1.38980895e-01f, 2.33307213e-01f, 1.71805874e-01f, 1.42146453e-01f, 4.51968536e-02f, 1.35704711e-01f, 5.80038205e-02f, 2.25316897e-01f, 1.02782361e-01f, 6.09498695e-02f,
  -8.69012158e-03f, 8.31000730e-02f, 1.17660061e-01f, 3.93084697e-02f, 1.42893791e-01f, 1.92655370e-01f, 5.77196525e-03f, 1.88797742e-01f, 4.45122272e-02f, 1.19161986e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.48529515e-01f, -1.51121110e-01f, 9.37602893e-02f, -4.75530289e-02f, -6.98419586e-02f, 1.13750435e-01f, 2.69700699e-02f, -7.14561492e-02f, 1.46734286e-02f, 2.86544468e-02f,
  -6.68443888e-02f, -1.36874272e-02f, -4.96628433e-02f, 3.92133184e-02f, 6.10649399e-02f, 6.65124580e-02f, 1.27023727e-01f, 4.94827777e-02f, -1.93490356e-01f, 2.88725756e-02f,
  1.19392619e-01f, 6.78785751e-03f, 8.09817240e-02f, 1.32711679e-01f, -7.93776661e-02f, 1.15662761e-01f, 1.39264569e-01f, 4.15754728e-02f, -2.74327621e-02f, -1.12455204e-01f,
  -3.93808559e-02f, -2.87107248e-02f, -2.22569983e-02f, -1.93544790e-01f, 4.90601212e-02f, 7.35636577e-02f, -4.78767939e-02f, -2.37974208e-02f, 3.05534452e-02f, 1.01408444e-01f,
  -1.73161566e-01f, -1.10302448e-01f, -5.74709196e-03f, 2.50801712e-01f, 9.04870704e-02f, 8.91461968e-02f, 1.14488728e-01f, -9.57510620e-02f, 3.04731317e-02f, 2.19307262e-02f,
  -2.22496148e-02f, -5.93327843e-02f, -1.37521833e-01f, 6.08080700e-02f, -3.74296755e-02f, 1.01928338e-01f, -1.21194385e-01f, 1.65079415e-01f, -4.35203426e-02f, 1.07536884e-02f,
  7.50197917e-02f, 5.13617434e-02f, 1.90111902e-02f, 1.72745928e-01f, -6.23790920e-02f, 8.86644125e-02f, 1.03705496e-01f, -8.33627060e-02f, -4.52771969e-02f, -5.60778938e-02f,
  2.56172009e-02f, 6.87237009e-02f, -1.24943815e-01f, 6.07875995e-02f, -1.48932278e-01f, 8.14667568e-02f, -1.57710925e-01f, 1.76311374e-01f, -1.09738357e-01f, 4.21798155e-02f,
  1.41667023e-01f, 8.99743959e-02f, 2.08680794e-01f, 1.87050387e-01f, -1.67587757e-01f, 5.57088852e-02f, -2.02723276e-02f, -1.77189603e-01f, -7.13862060e-03f, -1.79086048e-02f,
  -1.78935841e-01f, -2.44432073e-02f, 2.57190540e-02f, -2.92851627e-02f, -1.65329844e-01f, -1.91144407e-01f, -5.28036132e-02f, 3.00471745e-02f, 2.31661573e-01f, -7.83899948e-02f,
  1.70110688e-01f, -5.66518418e-02f, -1.94772840e-01f, 9.93526429e-02f, -2.41864830e-01f, 1.23261996e-02f, 2.69441269e-02f, -9.08008292e-02f, -8.77709314e-02f, -1.09425493e-01f,
  -7.23001957e-02f, 8.99346918e-03f, 1.94524154e-01f, 1.39831603e-01f, -5.39872311e-02f, -5.91139961e-03f, -5.02120256e-02f, 2.56579369e-02f, -1.31750360e-01f, 7.64228925e-02f,
  1.92776799e-01f, 1.33281313e-02f, 8.21333155e-02f, 4.56674118e-03f, -9.35807601e-02f, -3.49206999e-02f, 3.60298231e-02f, 8.96013249e-03f, 1.25319332e-01f, 2.30468865e-02f,
  9.14561097e-03f, -1.22441009e-01f, -1.46694094e-01f, -7.20449314e-02f, -5.45331500e-02f, 1.13490806e-03f, -1.66793257e-01f, 7.21325204e-02f, -1.49462432e-01f, -1.59491211e-01f,
  -1.29943758e-01f, 2.09435180e-01f, -1.90327972e-01f, 1.76011324e-01f, 2.15823993e-01f, 7.82493576e-02f, 5.80130070e-02f, 1.48473963e-01f, -3.55188884e-02f, -8.23893547e-02f,
  -2.18383640e-01f, -2.84009203e-02f, -1.86877936e-01f, -1.38228804e-01f, 1.88711077e-01f, 1.44153610e-01f, 5.76803759e-02f, 4.09568883e-02f, 1.60620272e-01f, -7.73133636e-02f,
  -1.21624008e-01f, -9.79223549e-02f, 1.21655494e-01f, 1.65834323e-01f, -2.28890348e-02f, 1.54460609e-01f, -5.88405505e-02f, -1.26876235e-01f, -1.22649558e-01f, -1.82081461e-01f,
  2.65445095e-02f, -5.89923337e-02f, 1.07490435e-01f, -7.40919113e-02f, -8.57088640e-02f, 1.33085400e-01f, 1.11173056e-01f, 5.08069247e-02f, -1.00499935e-01f, -1.09040692e-01f,
  -8.98351744e-02f, -1.68909132e-01f, 5.28451167e-02f, -2.40804162e-02f, 1.13051191e-01f, 5.32299094e-02f, -2.27138437e-02f, 1.70049205e-01f, -3.88222374e-02f, -3.41015897e-04f,
  -5.41600287e-02f, -1.63619787e-01f, 4.04440910e-02f, 3.49682942e-02f, -1.03635721e-01f, -8.15353915e-02f, -1.11103430e-01f, -6.86814040e-02f, 9.87411216e-02f, 5.83611503e-02f,
  -1.67462677e-01f, 1.59676578e-02f, -9.91117284e-02f, -7.74741322e-02f, -4.07368764e-02f, 2.30056629e-01f, -2.31363431e-01f, -1.75192177e-01f, 3.72923315e-02f, -5.12646744e-03f,
  -1.21887855e-01f, 1.70397639e-01f, 9.21249837e-02f, 5.84224192e-03f, -1.23535603e-01f, 1.25282645e-01f, -7.56976381e-02f, 1.14956442e-02f, 1.79232821e-01f, -6.48674965e-02f,
  8.37291554e-02f, 1.32758364e-01f, 2.05350399e-01f, 8.17049816e-02f, -1.93065092e-01f, -2.17032745e-01f, 1.89009756e-02f, 8.29530656e-02f, -8.18252712e-02f, 8.28415304e-02f,
  -8.10328349e-02f, 2.58506443e-02f, -1.80590287e-01f, 1.02980018e-01f, -8.72606114e-02f, -1.23278789e-01f, -1.06859699e-01f, 2.17655271e-01f, -1.77768301e-02f, -1.46101177e-01f,
  -4.89534512e-02f, 7.68563338e-03f, 1.47264764e-01f, -4.67739068e-03f, -1.51261866e-01f, 3.23795527e-02f, 9.58700404e-02f, 1.08174667e-01f, 1.10770024e-01f, -9.54279453e-02f,
  4.85370792e-02f, 4.74990681e-02f, -1.77107811e-01f, -3.20050567e-02f, -1.49847776e-01f, 1.36177626e-03f, -2.90372483e-02f, 3.16348039e-02f, -3.56189013e-02f, 6.01779781e-02f,
  -6.67487010e-02f, -6.13776594e-02f, -2.21135467e-02f, -6.62446097e-02f, -7.90985972e-02f, -5.38808256e-02f, 3.38426162e-03f, 3.60354036e-02f, 6.16914518e-02f, 1.13764316e-01f,
  -2.45451361e-01f, -2.65972465e-01f, -6.64902898e-03f, 1.13483936e-01f, -1.39122009e-01f, -1.20991558e-01f, 3.79118472e-02f, -1.14104897e-01f, -9.11060274e-02f, -7.27957338e-02f,
  3.68248858e-02f, -1.31819472e-01f, 2.08506361e-01f, -9.10662934e-02f, -2.67431494e-02f, 5.45213819e-02f, 1.01695269e-01f, -1.15344720e-03f, -7.59233832e-02f, -1.65497333e-01f,
  1.69008002e-02f, 2.46919617e-02f, -2.10187480e-01f, 1.32198006e-01f, 4.08839770e-02f, -1.40383735e-01f, -1.32552674e-02f, 1.28010705e-01f, 1.72920778e-01f, 1.72871843e-01f,
  -1.04750246e-01f, 2.06552789e-01f, 5.42117544e-02f, -3.84121239e-02f, -1.54334366e-01f, 5.58844395e-02f, 1.75621770e-02f, 3.66454460e-02f, -1.76200092e-01f, -1.81225762e-01f,
  -3.84354480e-02f, -4.71272282e-02f, 4.37869690e-02f, -5.36179096e-02f, 7.85186589e-02f, 6.37957156e-02f, 4.09288406e-02f, 5.03998511e-02f, 1.04468010e-01f, -9.45335850e-02f,
  1.11726820e-01f, 9.70041081e-02f, -8.93821418e-02f, 1.07038811e-01f, 7.21872970e-02f, -1.77940266e-04f, 1.33105457e-01f, 1.53811395e-01f, 2.43102778e-02f, 1.32549211e-01f,
  1.02382191e-01f, 1.09075033e-03f, -1.44306853e-01f, 7.12446198e-02f, 1.75052971e-01f, -1.62927881e-02f, 3.28224413e-02f, 6.08602390e-02f, -1.06746398e-01f, -4.44613993e-02f,
  -1.79713473e-01f, 1.39114484e-01f, 2.85754353e-02f, -1.97345793e-01f, -1.30468728e-02f, -5.86809255e-02f, 1.56844914e-01f, -3.91718782e-02f, 1.57958195e-01f, -8.35142285e-02f,
  -4.80805971e-02f, -1.16901986e-01f, 6.33982942e-02f, -1.22704491e-01f, 9.26609635e-02f, -9.47585609e-03f, -1.27146870e-01f, -1.01090074e-02f, -1.08657159e-01f, 9.86775160e-02f,
  -1.08391471e-01f, 1.95437089e-01f, 4.42181677e-02f, 1.42205745e-01f, -6.26250654e-02f, -2.03384921e-01f, 1.45149618e-01f, 1.22112706e-01f, 2.20154971e-02f, 5.29907010e-02f,
  1.07222952e-01f, -1.58009991e-01f, 5.62227517e-02f, 9.02740359e-02f, -3.55649479e-02f, -9.80601013e-02f, -5.33946529e-02f, 7.55730569e-02f, -1.30418062e-01f, 1.77886352e-01f,
  1.04794346e-01f, 4.48583700e-02f, -3.74453627e-02f, 4.32889769e-03f, 1.11933507e-01f, 2.85398401e-02f, 1.30615920e-01f, -1.37111440e-01f, -9.63985547e-02f, -2.90567800e-02f,
  -6.99136183e-02f, -9.87376794e-02f, -7.84982517e-02f, -4.43410762e-02f, 9.06969830e-02f, -8.49374756e-02f, -1.34042516e-01f, 7.57564977e-02f, 4.79090363e-02f, -7.16938302e-02f,
  8.84090662e-02f, 1.48268417e-01f, -1.64648354e-01f, 1.00275308e-01f, -1.21564724e-01f, -7.63109997e-02f, -3.15411687e-02f, 5.54247350e-02f, 4.88256328e-02f, 4.11713170e-03f,
  -5.44888936e-02f, 3.84006836e-02f, 7.99639896e-02f, -9.94719267e-02f, -5.03699183e-02f, -2.14883968e-01f, -3.26054879e-02f, -3.95895615e-02f, -1.95375942e-02f, -6.43674284e-03f,
  1.76791966e-01f, -4.27339412e-02f, -1.80321276e-01f, 1.38281524e-01f, -1.72528476e-01f, -2.64384393e-02f, 3.59509811e-02f, 9.07381848e-02f, -1.23696342e-01f, -1.17240630e-01f,
  1.54727936e-01f, 1.71277970e-01f, 9.73560363e-02f, -1.50128469e-01f, -1.92584451e-02f, 1.11798503e-01f, 8.79585668e-02f, 3.95552889e-02f, 1.25423342e-01f, -5.91909997e-02f,
  -6.44183084e-02f, -4.83527593e-03f, -2.56502442e-03f, 3.87870818e-02f, 7.36937746e-02f, 3.38747352e-02f, 2.54089311e-02f, 1.84890166e-01f, -3.13972472e-03f, -7.77189359e-02f,
  -1.02217771e-01f, -1.92594230e-02f, -2.12055370e-02f, -3.13078649e-02f, -1.44200837e-02f, 3.52348760e-02f, 1.74220249e-01f, -1.33455887e-01f, -7.49260560e-02f, 1.47799971e-02f,
  3.34574841e-02f, 1.30805010e-02f, 6.16857298e-02f, 1.10600583e-01f, 1.84090137e-01f, 8.35505575e-02f, 1.30446583e-01f, 3.98306809e-02f, -1.08034322e-02f, -2.38409583e-02f,
  -1.46586642e-01f, -1.01074837e-01f, -8.79132748e-02f, -4.53084223e-02f, -6.98094815e-02f, 1.04995973e-01f, 4.99144644e-02f, 8.94447118e-02f, 2.45798528e-01f, 4.30847891e-02f,
  1.22261472e-01f, -1.71229333e-01f, 1.78202212e-01f, 5.34345396e-02f, 4.34867516e-02f, -9.91668701e-02f, -1.93307310e-01f, -1.60893872e-01f, -6.28845617e-02f, -1.35425061e-01f,
  -1.75463691e-01f, -9.55391154e-02f, 6.80262372e-02f, 1.06569111e-01f, -9.51584801e-02f, 1.11938439e-01f, -6.18598126e-02f, -7.80237019e-02f, 2.25454167e-01f, 1.06746927e-01f,
  7.48606995e-02f, -3.86683308e-02f, -1.69726044e-01f, 1.22708388e-01f, 2.95799002e-02f, 3.79737187e-03f, -2.16723368e-01f, -6.53357729e-02f, 4.23388444e-02f, -1.19533889e-01f,
  -2.74390846e-01f, -3.62048969e-02f, -1.01378426e-01f, 3.57004404e-02f, -1.23208858e-01f, 9.35257450e-02f, -3.34974285e-03f, -2.32407525e-02f, -5.19049726e-02f, -7.31900334e-02f,
  -1.29353628e-02f, -1.57736212e-01f, -8.33361149e-02f, -7.77994394e-02f, -7.04921633e-02f, -2.20074564e-01f, 1.85345024e-01f, 5.35661392e-02f, -5.03365882e-02f, -1.70594841e-01f,
  -7.53451511e-02f, -7.74832964e-02f, -1.89352170e-01f, 2.79102176e-01f, 2.31979579e-01f, -2.13880435e-01f, -2.32836589e-01f, -4.21384014e-02f, 6.22149706e-02f, 1.00569064e-02f,
  3.93395685e-02f, -1.27987579e-01f, 2.79763751e-02f, 1.22562431e-01f, -9.54260025e-03f, -5.30518033e-03f, -3.68225686e-02f, -2.46833973e-02f, 8.86918604e-02f, -1.14239283e-01f,
  1.02388650e-01f, -1.62593856e-01f, 1.13094889e-01f, 1.80624314e-02f, 1.71051353e-01f, -1.41042009e-01f, 5.30530326e-02f, -2.50767022e-01f, -1.02614246e-01f, -2.59630065e-02f,
  -6.80205971e-02f, 1.68215297e-02f, -6.88196123e-02f, 6.96355030e-02f, 1.00875787e-01f, -1.67774148e-02f, 8.83772150e-02f, 8.61977562e-02f, 4.22256142e-02f, 1.30495191e-01f,
  -1.09631464e-01f, 1.11403070e-01f, 6.57150894e-02f, 9.00727808e-02f, -6.39352128e-02f, -8.12539831e-02f, -9.13274649e-04f, 1.29856011e-02f, -1.21144988e-01f, -1.39591888e-01f,
  -3.95613462e-02f, 1.18089721e-01f, 9.66414064e-02f, 5.05128726e-02f, -1.70897305e-01f, 9.46804583e-02f, 4.87367660e-02f, -1.03131592e-01f, -5.29842563e-02f, 9.11985487e-02f,
  1.41839772e-01f, 1.51781783e-01f, -3.89365107e-03f, -1.15497068e-01f, -1.26708180e-01f, 1.43311158e-01f, -1.31081477e-01f, -1.64545804e-01f, 6.81984052e-03f, 8.75923317e-03f,
  -1.00798681e-02f, 1.14068866e-01f, -1.37621790e-01f, 1.81193296e-02f, -1.36827588e-01f, -1.65249541e-01f, 1.18363217e-01f, 4.40984443e-02f, -9.00554061e-02f, 8.25942531e-02f,
  9.31864604e-02f, -1.00214370e-01f, -8.86771455e-02f, 1.65058807e-01f, 1.28601557e-02f, 2.44004768e-03f, -2.82658935e-02f, 1.35737523e-01f, -3.10196057e-02f, -4.11767960e-02f,
  1.37477294e-01f, -1.16418138e-01f, -1.46608785e-01f, 7.24799111e-02f, -1.49143875e-01f, -6.03092164e-02f, -5.18024564e-02f, 2.88877375e-02f, 9.35692489e-02f, 1.00512058e-01f,
  1.15479358e-01f, -4.87784669e-02f, 9.90646258e-02f, -1.66533396e-01f, 9.27316546e-02f, -1.50416940e-01f, -1.54481933e-01f, -1.13180853e-01f, 7.51465484e-02f, 6.96584722e-03f,
  -2.83676852e-02f, -4.86805104e-02f, -3.43665816e-02f, -1.50556386e-01f, -6.98429793e-02f, -8.44888613e-02f, -2.81777903e-02f, -1.23929381e-01f, -1.49258092e-01f, 1.29371151e-01f,
  -4.67284471e-02f, 4.90686893e-02f, 4.29095738e-02f, 1.12386212e-01f, -1.59804419e-01f, 1.10367477e-01f, 1.01729214e-01f, 1.50789008e-01f, -9.17350277e-02f, 1.21389419e-01f,
  2.37980466e-02f, -4.86098006e-02f, 1.19379587e-01f, -1.52332112e-01f, 5.79506792e-02f, -1.92904659e-02f, -2.16467023e-01f, 1.68665662e-01f, 1.03368831e-03f, -1.82663441e-01f,
  -1.31225139e-01f, -3.43611538e-02f, 2.08973531e-02f, 5.40433861e-02f, -5.81550933e-02f, -4.90100607e-02f, -4.47136303e-03f, 1.72754854e-01f, 8.45540389e-02f, 4.10055667e-02f,
  -9.82189924e-02f, 8.83214234e-04f, 1.86159387e-01f, 1.74985737e-01f, 1.22791350e-01f, 2.09053420e-02f, -5.07596061e-02f, 1.18796237e-01f, 4.30539809e-02f, -2.01072037e-01f,
  -1.82704896e-01f, 3.66308726e-02f, -2.88810898e-02f, -8.37131366e-02f, 1.94514170e-01f, -1.01074137e-01f, 6.67604208e-02f, -2.65871864e-02f, 1.77511528e-01f, -5.06363343e-03f,
  -4.54429723e-02f, 4.51491736e-02f, 2.30324745e-01f, -1.73387676e-02f, 7.30557963e-02f, 2.61739660e-02f, 1.20000929e-01f, 5.92045374e-02f, 6.33604452e-02f, -5.46971001e-02f,
  2.56657079e-02f, -1.23413038e-02f, -1.40623208e-02f, 1.17795378e-01f, 7.83556551e-02f, -1.09175608e-01f, 1.74510598e-01f, -1.38987035e-01f, 1.62349150e-01f, 7.61337299e-03f,
  -1.72218829e-01f, -4.51632850e-02f, 1.47529081e-01f, -1.77342832e-01f, -4.82812300e-02f, 7.34534338e-02f, -8.43081400e-02f, 6.29665628e-02f, 1.53980270e-01f, 7.18109310e-02f,
  -1.69689044e-01f, -9.62057039e-02f, 7.92577192e-02f, -1.01214401e-01f, -6.68617105e-03f, 7.68285021e-02f, 1.36819169e-01f, 1.16431803e-01f, -1.10338166e-01f, -1.70023106e-02f,
  -1.38599277e-01f, 1.50887398e-02f, -3.15394835e-03f, -1.25542834e-01f, 2.10332066e-01f, 1.91506464e-02f, -2.20678616e-02f, -1.88094154e-01f, 1.48937374e-01f, 1.43580973e-01f,
  -9.49371085e-02f, -3.10580097e-02f, -1.14504449e-01f, 1.39050456e-02f, -1.60359859e-01f, -1.77011322e-02f, -5.72685264e-02f, -7.13249519e-02f, -2.92796828e-02f, -8.67260769e-02f,
  9.36122239e-02f, -4.35118424e-03f, 1.48029014e-01f, -7.21491501e-02f, 1.70171019e-02f, 4.75424342e-03f, -3.85591835e-02f, -1.77379310e-01f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  8.45015049e-02f, 2.24269286e-01f, 3.51416431e-02f, 1.48159444e-01f, 1.74199224e-01f, -4.00081463e-02f, 7.53611252e-02f, 1.09639816e-01f, 3.49338129e-02f, 9.75572839e-02f,
  -3.51088271e-02f, -1.20675698e-01f, -1.51844155e-02f, 5.57935946e-02f, 3.21568459e-01f, 5.00075370e-02f, -3.70307080e-02f, 2.85451800e-01f, 2.76196122e-01f, -1.28163382e-01f,
  -1.16540521e-01f, 2.30724588e-01f, -1.21256590e-01f, -2.65531093e-01f, -2.63271272e-01f, 9.00015905e-02f, -1.70445308e-01f, 1.60959959e-02f, -4.77562025e-02f, 9.30126756e-02f,
  3.81065533e-02f, 1.15769118e-01f, 3.82667124e-01f, -1.35477716e-02f, 2.89655775e-02f, -3.31393510e-01f, 4.10334356e-02f, -3.06033585e-02f, 3.77622277e-01f, -3.37881893e-01f,
  2.70663261e-01f, 5.37742600e-02f, 3.41072828e-01f, -3.20283502e-01f, 1.41323522e-01f, -2.08309710e-01f, 2.51909122e-02f, 3.77892703e-02f, -1.33019462e-01f, -9.33370367e-02f,
  7.60963485e-02f, 2.79281020e-01f, 1.49288207e-01f, 2.38737583e-01f, 5.01415208e-02f, 1.83480114e-01f, 2.09994227e-01f, 8.92736167e-02f, -4.95093092e-02f, 1.96776256e-01f,
  3.39777410e-01f, 1.00993045e-01f, -3.74974877e-01f, -1.04894467e-01f, -2.33525895e-02f, -2.79606164e-01f, -3.08424570e-02f, -2.24071711e-01f, -2.12191448e-01f, -6.15736283e-03f,
  4.77514490e-02f, -6.74496591e-02f, -1.82531327e-01f, -3.06697898e-02f, -3.95464990e-03f, 1.42979389e-02f, 1.99825034e-01f, -3.02493066e-01f, -1.22614928e-01f, -9.06067118e-02f,
  -2.56358057e-01f, -2.29156509e-01f, -1.47389054e-01f, -8.87472853e-02f, -1.26690432e-01f, -1.49519891e-01f, 1.36100635e-01f, 1.17827244e-01f, 2.58525908e-01f, -3.96860503e-02f,
  1.29998356e-01f, 4.39826176e-02f, 5.48571534e-02f, -8.89610425e-02f, -2.04837695e-01f, 1.48632014e-02f, -4.95354878e-03f, -2.48105917e-02f, 1.65607929e-01f, 3.31126273e-01f,
  6.04323745e-02f, 1.20245274e-02f, -1.48689240e-01f, 2.31375679e-01f, 2.27944061e-01f, 1.90675750e-01f, 2.11908966e-02f, 1.67983085e-01f, -8.82378370e-02f, 6.73285648e-02f,
  8.47022459e-02f, 1.93476513e-01f, 1.68504670e-01f, 1.97146922e-01f, -2.28035584e-01f, -2.13363722e-01f, -7.57577969e-03f, 4.17508818e-02f, 5.19235581e-02f, -4.66030911e-02f,
  -2.93107003e-01f, 1.62738338e-01f, 1.69461757e-01f, 1.28405735e-01f, -3.03777754e-01f, 1.06206536e-01f, 2.00897515e-01f, 1.04192078e-01f, -5.17469347e-02f, -2.13376392e-04f,
  1.22098878e-01f, 4.02786024e-03f, 4.26686890e-02f, 7.58250877e-02f, 1.08403914e-01f, 7.38983462e-03f, -1.01428404e-01f, -1.86358057e-02f, -1.41461432e-01f, 5.79918586e-02f,
  -3.10765684e-01f, -5.35275862e-02f, -8.95636529e-03f, 1.92558676e-01f, 1.12800911e-01f, 9.59336460e-02f, -2.31940150e-02f, 1.74568996e-01f, -3.78381997e-01f, 3.62270810e-02f,
  -1.95743948e-01f, -3.31508517e-01f, 1.39973342e-01f, 6.48327470e-02f, -1.57828420e-01f, 1.90094203e-01f, 2.44517535e-01f, 2.61178136e-01f, -3.09690326e-01f, -1.50830671e-01f,
  -2.55282260e-02f, 3.03077012e-01f, 3.61493707e-01f, 8.54298100e-02f, 3.00096720e-01f, 2.67474502e-01f, -3.28642339e-01f, 1.44976214e-01f, -7.60956705e-02f, 3.27786267e-01f,
  1.24038465e-01f, -2.26198919e-02f, -9.97621119e-02f, -1.95272237e-01f, 4.66815419e-02f, 1.95503578e-01f, 2.81139582e-01f, 8.92913267e-02f, -1.08795501e-01f, -9.87900943e-02f,
  2.57398076e-02f, 8.27825218e-02f, 1.25155181e-01f, 2.17843294e-01f, 8.06134716e-02f, -5.09170182e-02f, 1.91031516e-01f, 6.01732209e-02f, -2.19011739e-01f, -2.20337838e-01f,
  1.76293403e-01f, 2.49607265e-01f, -1.07816711e-01f, 8.16914067e-02f, -5.35235815e-02f, 6.06912374e-03f, -8.68192166e-02f, 1.73072424e-02f, -1.44572044e-03f, -8.76064226e-02f,
  3.15937735e-02f, -7.06744418e-02f, -1.39702126e-01f, 3.53588276e-02f, 2.10771766e-02f, 3.34133729e-02f, -7.17036054e-02f, -6.84643462e-02f, 5.47694601e-02f, -1.28196657e-01f,
  -4.60950956e-02f, 9.78659391e-02f, -3.54131646e-02f, -9.16660130e-02f, 1.39206499e-01f, 7.55480528e-02f, 1.58836357e-02f, 9.56466608e-03f, -9.60025042e-02f, 1.79782957e-02f,
  3.46389115e-02f, 3.41353118e-02f, -1.20758682e-01f, -1.12768732e-01f, 9.92233083e-02f, 1.09439231e-02f, 9.36732590e-02f, -5.66203967e-02f, -1.43539712e-01f, -8.76619145e-02f,
  6.76944479e-02f, -3.02039389e-03f, -1.00305550e-01f, -1.20800003e-01f, 3.28563638e-02f, 1.85433570e-02f, -1.34167284e-01f, 9.28769857e-02f, -1.30728064e-02f, -1.02505563e-02f,
  -5.66022983e-03f, 2.74879648e-03f, -4.45902124e-02f, -3.66448499e-02f, 6.22368418e-02f, 8.04035440e-02f, -2.67909169e-02f, 5.47525287e-03f, -1.24115109e-01f, -4.80693989e-02f,
  -1.32029848e-02f, 2.83280890e-02f, -1.21251233e-01f, 3.72317918e-02f, -8.39189347e-03f, -1.02186583e-01f, 2.35244349e-01f, -3.46360579e-02f, 7.49695972e-02f, -1.36203989e-01f,
  1.61992550e-01f, 1.57318756e-01f, 1.33548994e-02f, -2.48723682e-02f, 1.22287653e-01f, 1.59036115e-01f, 1.23261422e-01f, 1.38551444e-01f, -2.60178167e-02f, -1.43884838e-01f,
  -6.88376203e-02f, 2.60696948e-01f, 1.36655182e-01f, -1.65269762e-01f, 2.87102550e-01f, 1.61436751e-01f, 3.62090617e-01f, -2.57960886e-01f, -8.51214752e-02f, 3.07691962e-01f,
  -6.06152276e-03f, 1.01765111e-01f, 2.26030841e-01f, 4.81249541e-02f, 1.63869590e-01f, -1.26079962e-01f, 3.70117605e-01f, 2.05066651e-01f, -1.77063979e-02f, -1.64080814e-01f,
  1.75638929e-01f, 2.16742694e-01f, 1.50470793e-01f, -1.26165941e-01f, -9.05329287e-02f, -1.12982459e-01f, 7.20062852e-03f, -1.23416558e-01f, -2.18302503e-01f, -2.40058854e-01f,
  2.87143320e-01f, 2.26845145e-01f, -2.34714404e-01f, 1.00516722e-01f, 1.32813722e-01f, 2.19102085e-01f, 4.46383171e-02f, 4.30288911e-02f, 2.51419991e-01f, 1.07968599e-01f,
  -1.58681571e-01f, 3.58614773e-02f, 1.02598362e-01f, 2.98284113e-01f, -1.89397350e-01f, -1.41009435e-01f, 5.25283103e-04f, 1.93138316e-01f, -4.03091386e-02f, -1.05047666e-01f,
  5.01091965e-02f, 8.81922320e-02f, 1.09172605e-01f, 1.09776616e-01f, -5.86629994e-02f, 8.98844153e-02f, 4.15224060e-02f, 9.05833393e-02f, 7.07145259e-02f, -2.18977742e-02f,
  1.58265099e-01f, 1.05195776e-01f, 8.58338401e-02f, -3.46782476e-01f, -2.18644500e-01f, 1.90337241e-01f, -3.73779804e-01f, -7.68472031e-02f, 2.46349484e-01f, -7.33748302e-02f,
  3.02456897e-02f, -1.89555392e-01f, -5.41186854e-02f, -7.30753615e-02f, 1.18457358e-02f, 9.22559481e-03f, 5.88151207e-03f, -1.85423240e-01f, -6.09475374e-02f, 8.76409039e-02f,
  1.26524717e-01f, 3.64112049e-01f, 6.40949681e-02f, 1.74295902e-01f, 1.10696368e-02f, 3.25681537e-01f, -1.63486287e-01f, -1.92681164e-01f, 3.48976195e-01f, -2.15462726e-02f,
  2.41584554e-01f, 1.11817971e-01f, 2.16196179e-01f, -2.36465991e-01f, -7.16774072e-03f, 6.99412599e-02f, -3.76164988e-02f, -1.12678930e-01f, -1.24527708e-01f, 3.81915927e-01f,
  -1.12782486e-01f, -7.88371414e-02f, 7.47060627e-02f, 1.49308443e-01f, -1.61646739e-01f, -1.05360039e-02f, 2.03191474e-01f, 2.09733263e-01f, 2.13398919e-01f, -1.47112623e-01f,
  1.93749130e-01f, 2.15786308e-01f, 1.74777452e-02f, -1.02241404e-01f, 5.68060875e-02f, 1.12365961e-01f, 1.75178334e-01f, 1.79731339e-01f, 1.85351327e-01f, 6.05246536e-02f,
  2.03415528e-02f, 1.14385858e-01f, 2.14767605e-01f, 3.16658206e-02f, 4.32833582e-02f, 1.41231358e-01f, 2.50077784e-01f, -2.96016280e-02f, -2.08738118e-01f, 2.17914104e-01f,
  -8.84701014e-02f, -2.61466384e-01f, 3.46148849e-01f, 1.17756478e-01f, 4.56498489e-02f, -9.75129008e-02f, -2.38940582e-01f, 1.11458056e-01f, 2.39013329e-01f, -2.66608506e-01f,
  2.10114822e-01f, -2.39476580e-02f, -1.34754017e-01f, 2.79954851e-01f, 1.17010780e-01f, 1.26067922e-01f, -3.37991983e-01f, 1.50429443e-01f, 9.05706435e-02f, 3.96515697e-01f,
  -3.62758368e-01f, -4.93183092e-04f, -2.88057745e-01f, 1.48851648e-01f, 9.90699828e-02f, 2.02496111e-01f, 9.66836065e-02f, -2.95430779e-01f, 7.37549216e-02f, 3.66425425e-01f,
  1.37211010e-01f, -2.07862213e-01f, -1.46958709e-01f, 2.09299922e-01f, 2.71492619e-02f, -2.09396377e-01f, -1.80540867e-02f, -1.06985919e-01f, -1.25942454e-01f, -2.26117536e-01f,
  3.28220665e-01f, 9.09629315e-02f, 2.73802847e-01f, 4.32369299e-02f, -2.64098048e-01f, 1.11737810e-01f, -1.22390859e-01f, -3.85649323e-01f, 6.15653917e-02f, 1.06672361e-01f,
  8.45217630e-02f, -1.84137195e-01f, -1.97823718e-02f, 5.08451387e-02f, 4.57345732e-02f, -1.27544254e-01f, 4.06661667e-02f, 3.42402495e-02f, -6.98015168e-02f, 1.05138399e-01f,
  -1.50517508e-01f, -4.31986190e-02f, 2.67436922e-01f, 2.02423051e-01f, 2.00218484e-01f, -4.49444614e-02f, 2.02526465e-01f, 1.29076391e-01f, -1.50539860e-01f, -2.80054033e-01f,
  -2.11367413e-01f, 8.39329064e-02f, 2.83544511e-01f, 3.26052696e-01f, -2.79863775e-01f, 1.93686917e-01f, -6.05379976e-02f, -1.37212500e-01f, -1.32866159e-01f, 6.32164553e-02f,
  1.03402704e-01f, 3.13653558e-01f, 3.33167702e-01f, 4.57721949e-02f, 1.87703460e-01f, 1.34133577e-01f, 8.39721933e-02f, 2.27538213e-01f, 9.35732499e-02f, -3.17101106e-02f,
  -2.58391589e-01f, 1.66057512e-01f, 7.05752298e-02f, -1.43438742e-01f, -2.63179094e-01f, 3.83216500e-01f, 2.27154300e-01f, 7.71591812e-02f, -8.20111856e-02f, -5.73789142e-03f,
  3.21666330e-01f, 7.97690973e-02f, 2.64082849e-01f, 1.87469214e-01f, -2.07294989e-02f, 3.53049524e-02f, 3.17078441e-01f, -1.42258614e-01f, 4.14569750e-02f, -8.79661590e-02f,
  2.43191198e-01f, 2.06495807e-01f, 1.49017319e-01f, -3.26544754e-02f, 4.24570628e-02f, 9.86297429e-02f, 3.77019122e-02f, 6.76248744e-02f, 6.41198158e-02f, -1.08376117e-02f,
  1.97674319e-01f, 2.32039258e-01f, -1.23247355e-01f, 3.36569011e-01f, -3.53684574e-02f, 1.52659073e-01f, -3.26347977e-01f, 7.95313194e-02f, 2.40571782e-01f, -2.52397219e-03f,
  -5.38103469e-02f, -3.59018371e-02f, 1.66039556e-01f, -4.96243596e-01f, -2.56558150e-01f, 1.83849260e-01f, 3.94122839e-01f, -3.53915021e-02f, 1.07560098e-01f, 2.41197739e-02f,
  -6.08313195e-02f, 2.43089736e-01f, -4.89297882e-02f, -7.52897486e-02f, -1.98182628e-01f, 1.40303999e-01f, 1.32808566e-01f, 1.60394996e-01f, -1.46045879e-01f, 1.03789754e-01f,
  -2.64756292e-01f, 2.52398878e-01f, -1.88971043e-01f, 6.41584247e-02f, 1.21002216e-02f, 4.53393348e-02f, 1.22957952e-01f, 4.03452128e-01f, 2.61229545e-01f, -6.34778989e-03f,
  1.81104675e-01f, 1.83381468e-01f, 2.81198740e-01f, -5.30045480e-02f, -2.29456142e-01f, -1.61112145e-01f, -1.53027087e-01f, 3.16812820e-03f, 4.73241322e-02f, -3.59579548e-02f,
  3.10544968e-01f, 4.77564558e-02f, -2.05775067e-01f, -7.09126666e-02f, 1.17632516e-01f, 2.50130836e-02f, -3.03931385e-02f, -1.44930184e-01f, -1.38254091e-01f, -1.26756588e-03f,
  7.92099442e-03f, 4.31564450e-02f, 9.82293785e-02f, 2.57255845e-02f, 5.51851839e-02f, -1.38058737e-01f, -4.60780598e-02f, -7.31176063e-02f, 4.16421965e-02f, 2.85658836e-02f,
  1.08865343e-01f, -6.25296906e-02f, 1.68658197e-02f, -4.60021123e-02f, 6.55640149e-03f, -1.02569878e-01f, -2.18536276e-02f, -7.49145970e-02f, -9.29251686e-03f, -3.88426036e-02f,
  -3.52867767e-02f, -8.68369117e-02f, 2.81764884e-02f, -1.06487915e-01f, -4.91530374e-02f, -1.29811779e-01f, 9.08618197e-02f, -1.09231204e-01f, -1.13580832e-02f, 8.58629774e-03f,
  -6.35877773e-02f, -9.70645994e-02f, 3.40514816e-02f, 1.09076656e-01f, 1.71699338e-02f, 8.04040879e-02f, -3.11013144e-02f, 1.10395467e-02f, -2.04884745e-02f, 7.05776140e-02f,
  -1.03770345e-01f, -5.73421409e-03f, -6.61186799e-02f, -5.38855121e-02f, 5.34901768e-02f, 9.14474018e-03f, -7.08747432e-02f, -1.19499445e-01f, -1.21048428e-01f, 7.59978965e-02f,
  -5.90633601e-02f, -1.05074070e-01f, -5.71713261e-02f, 1.04778863e-01f, -1.04256033e-03f, 2.70164311e-02f, -1.06752820e-01f, 4.72868793e-02f, -1.03758551e-01f, -8.10266212e-02f,
  2.29651347e-01f, 1.98254287e-01f, 1.04862280e-01f, 8.65978654e-04f, 1.84768774e-02f, 1.27505898e-01f, -1.03640251e-01f, 9.98659655e-02f, 2.61184812e-01f, 7.21338093e-02f,
  1.02354571e-01f, 5.51046245e-02f, 3.30060840e-01f, -1.40799701e-01f, 1.09611914e-01f, 1.38733359e-02f, -3.17065507e-01f, -6.47369772e-02f, 3.68632853e-01f, -2.49350727e-01f,
  -1.34064957e-01f, 1.12581842e-01f, -3.11819855e-02f, 2.67077591e-02f, 6.29370734e-02f, -1.89352229e-01f, 1.86056659e-01f, -4.67691198e-02f, -5.73508926e-02f, -8.92436802e-02f,
  6.87885880e-02f, 1.46801546e-01f, 6.32018521e-02f, 2.12898284e-01f, -4.20157127e-02f, 9.42009389e-02f, 2.49162316e-03f, -1.00407712e-01f, 1.90759704e-01f, -1.03850245e-01f,
  2.80544758e-01f, -3.84403504e-02f, 1.53012782e-01f, -3.07784468e-01f, 1.45516410e-01f, 3.50618586e-02f, 2.40976065e-01f, 7.75281489e-02f, -2.25201592e-01f, 1.65724695e-01f,
  1.68175161e-01f, 1.10279709e-01f, 2.25710630e-01f, 1.92245141e-01f, -1.98095113e-01f, 6.22252077e-02f, 5.60705028e-02f, 1.90885603e-01f, -6.77879155e-02f, 1.08444855e-01f,
  1.85689256e-01f, 2.00084597e-01f, -1.22625835e-01f, -2.43795916e-01f, 1.20967533e-02f, 1.48942336e-01f, 1.10390209e-01f, 1.16472356e-01f, 1.17706306e-01f, -1.23367146e-01f,
  -3.30553227e-03f, 1.40142977e-01f, 1.90861091e-01f, 1.60713807e-01f, -3.19121778e-02f, 6.04783818e-02f, -1.32349983e-01f, 2.55337954e-01f, -1.68410882e-01f, -3.16329271e-01f,
  1.25038162e-01f, 1.08078748e-01f, -5.94595149e-02f, -2.61262834e-01f, -2.09394217e-01f, 2.59263128e-01f, -4.84823510e-02f, -4.18161005e-02f, 2.17020176e-02f, -2.28933871e-01f,
  2.27119118e-01f, -2.10700527e-01f, 4.54982035e-02f, 3.45095098e-01f, 1.85138270e-01f, -5.11135869e-02f, 7.64343441e-02f, -1.26939759e-01f, -2.09376782e-01f, 5.38655557e-02f,
  -6.39181435e-02f, -6.77340999e-02f, -1.93101898e-01f, 1.07664630e-01f, -3.40265110e-02f, 2.94823796e-01f, 2.35880122e-01f, 1.78681308e-04f, -5.37024159e-03f, 1.14903308e-01f,
  4.77297932e-01f, -7.01756626e-02f, -6.00312725e-02f, 2.12075293e-01f, 3.01867247e-01f, 1.22403905e-01f, -8.83044451e-02f, -1.21723283e-02f, -6.94008023e-02f, -1.20063901e-01f,
  -3.06728128e-02f, -2.95477454e-02f, 4.80505228e-02f, 3.79986882e-01f, 2.00186968e-01f, 4.19720821e-03f, -1.63674399e-01f, 5.10457419e-02f, 1.62427798e-01f, 1.97074398e-01f,
  -5.20991385e-02f, 1.25238925e-01f, 2.49290198e-01f, -1.21833637e-01f, -6.84018880e-02f, 1.20534860e-01f, 1.53104439e-01f, -6.02931641e-02f, 1.38773099e-01f, 5.68273850e-02f,
  -1.17205337e-01f, 1.14239529e-02f, 2.98107177e-01f, 1.65515900e-01f, 1.96710750e-01f, 2.46805206e-01f, 2.72398442e-01f, -6.54437095e-02f, -3.22177947e-01f, 3.62631202e-01f,
  -1.84574589e-01f, -3.16803604e-01f, -5.69788106e-02f, 2.20656637e-02f, -8.41847956e-02f, -9.40871388e-02f, 1.35171577e-01f, 1.17427461e-01f, -2.61291601e-02f, -1.69361323e-01f,
  1.95154697e-01f, 1.45249680e-01f, 9.23475903e-03f, 4.74910140e-02f, -3.79091650e-02f, 1.38770984e-02f, 1.37385121e-02f, -2.13505685e-01f, -1.26025900e-01f, 1.73719406e-01f,
  5.14582694e-02f, -3.18288565e-01f, -3.15407179e-02f, -2.30212972e-01f, 1.38081044e-01f, 1.49755821e-01f, -8.11916962e-02f, 2.15475142e-01f, 2.23075107e-01f, 1.43127009e-01f,
  1.69712424e-01f, 2.41009399e-01f, -2.25831911e-01f, 1.76362365e-01f, 1.43231049e-01f, 1.38622612e-01f, -7.83471912e-02f, 3.51816475e-01f, 3.03438812e-01f, -6.84710518e-02f,
  -3.70143861e-01f, -7.15375170e-02f, 1.39764056e-03f, 4.67976779e-02f, 1.97722182e-01f, 1.85847804e-01f, 1.06345586e-01f, -5.77050410e-02f, 7.00425059e-02f, 1.07885510e-01f,
  8.10608268e-02f, 5.87135442e-02f, -2.43688282e-03f, 2.01361805e-01f, 1.17985487e-01f, 1.85591146e-01f, -3.29243422e-01f, -6.35912791e-02f, 1.72097585e-03f, -1.44118980e-01f,
  5.93396723e-02f, 3.61059569e-02f, -1.79397345e-01f, -3.64721924e-01f, -2.08193451e-01f, 1.35136276e-01f, 3.92211586e-01f, -3.34760174e-02f, -3.67212333e-02f, 1.14760548e-03f,
  -1.63779587e-01f, 2.48527631e-01f, -1.83958545e-01f, 1.81251362e-01f, -2.61572033e-01f, 3.37020338e-01f, -7.58966953e-02f, 9.74935889e-02f, 1.91478357e-02f, 2.31642157e-01f,
  2.07442775e-01f, 2.26583391e-01f, 8.91518071e-02f, 2.11317599e-01f, 3.32685262e-01f, 2.58993030e-01f, 7.30073676e-02f, 3.79853427e-01f, 3.11240345e-01f, -2.25460052e-01f,
  9.35638249e-02f, 1.27114341e-01f, 1.87300265e-01f, -7.85969719e-02f, -1.63769349e-01f, -6.67974204e-02f, 9.97741297e-02f, -1.75281078e-01f, 7.21595660e-02f, -1.61834762e-01f,
  3.38852942e-01f, 1.22534715e-01f, -1.76208373e-02f, 1.53018292e-02f, 1.84351981e-01f, -7.90586248e-02f, 1.08053125e-01f, -7.02518001e-02f, -7.50444829e-02f, -1.66346934e-02f,
  -1.14652716e-01f, -1.26069620e-01f, 2.79471930e-02f, 1.03998505e-01f, 7.02559128e-02f, 7.66983256e-02f, -1.16491795e-01f, 8.40490405e-03f, 6.67246431e-03f, 1.04446419e-01f,
  -7.20380396e-02f, 5.66873215e-02f, 8.20580986e-04f, -3.05338902e-03f, 7.20969168e-03f, -1.28582373e-01f, 1.26274154e-01f, -6.48765266e-02f, 1.19542502e-01f, -9.12897140e-02f,
  -7.77755156e-02f, -4.20205761e-03f, -1.04713559e-01f, -4.44503967e-03f, -1.57537106e-02f, -6.84732273e-02f, -5.79194203e-02f, -9.62927714e-02f, -1.07558005e-01f, -8.04403275e-02f,
  -1.37635261e-01f, 4.58386290e-04f, 2.79676616e-02f, 4.42844220e-02f, 6.17701039e-02f, 5.14847488e-05f, 2.03543045e-02f, 9.14283693e-02f, -2.90371478e-02f, -5.05160801e-02f,
  -1.00354470e-01f, 5.83037511e-02f, -7.49050677e-02f, -4.23223078e-02f, 1.03742771e-01f, -1.37528460e-02f, -1.26915351e-02f, -6.82240799e-02f, 1.92968752e-02f, -3.15320417e-02f,
  1.08411387e-01f, -1.12922646e-01f, 6.68618679e-02f, -7.52001023e-03f, 5.93054481e-02f, 6.72299862e-02f, -1.06730558e-01f, 1.17649185e-02f, -9.51374546e-02f, -4.06027175e-02f,
  -2.94756889e-02f, -2.05360204e-02f, -6.64417818e-02f, -7.37712979e-02f, -7.15799555e-02f, 2.87947841e-02f, -1.39763594e-01f, 7.39161074e-02f, -1.39736786e-01f, -7.73933232e-02f,
  -1.10326968e-01f, -7.22819865e-02f, 1.34058949e-02f, 1.02304809e-01f, 6.22390732e-02f, 2.08598804e-02f, -6.39592782e-02f, 4.83483523e-02f, 3.87765504e-02f, -1.08022675e-01f,
  -9.78289917e-02f, -1.32499710e-01f, 6.80009648e-02f, 8.19024891e-02f, 2.38822773e-02f, 9.12357401e-03f, -5.76604623e-03f, 2.67093796e-02f, -1.40102729e-01f, -1.13944665e-01f,
  -7.83573836e-02f, -6.21739216e-02f, -1.10177502e-01f, -1.01831712e-01f, 5.28469533e-02f, -2.36823340e-03f, 9.80757996e-02f, -7.64535740e-02f, 7.95380473e-02f, -1.08805023e-01f,
  9.14943684e-03f, 3.56578687e-03f, -1.17294118e-01f, 2.25256719e-02f, -1.17189966e-01f, -8.08388889e-02f, -9.57501903e-02f, -2.73110159e-02f, -3.72240990e-02f, 9.03773829e-02f,
  -3.63745205e-02f, 2.49274112e-02f, 8.54449496e-02f, -1.15147702e-01f, -6.24716282e-03f, 3.00621353e-02f, -2.15850282e-03f, 5.44147603e-02f, 6.36521056e-02f, 7.26000294e-02f,
  -1.12590499e-01f, -1.11842573e-01f, 8.27947259e-02f, -1.30747154e-01f, -7.34208822e-02f, 9.92219672e-02f, 1.26312003e-01f, -7.49972742e-03f, -1.68010324e-01f, -4.35076095e-02f,
  6.01892211e-02f, -8.75068456e-02f, -1.44639075e-01f, 5.26728220e-02f, -1.92041248e-02f, -7.82775208e-02f, -2.73786038e-01f, 2.93575108e-01f, -7.39906207e-02f, 7.91811422e-02f,
  1.88011348e-01f, 2.14170188e-01f, -2.79923733e-02f, 2.47394055e-01f, 2.19876006e-01f, 2.74766237e-02f, 3.95567641e-02f, 7.07717910e-02f, -1.22610561e-03f, 1.69805110e-01f,
  -6.87742308e-02f, 2.16149941e-01f, 1.32753968e-01f, -1.19254559e-01f, 9.78418663e-02f, -1.20937333e-01f, 2.00941116e-01f, 5.90670900e-03f, 1.32085964e-01f, -1.11753590e-01f,
  2.81746596e-01f, 2.26381972e-01f, -2.05867767e-01f, 4.01608348e-02f, -1.27407745e-01f, -2.48001933e-01f, -6.29231753e-03f, 2.45103002e-01f, 1.80134416e-01f, 9.45013091e-02f,
  -9.51439738e-02f, 1.65403903e-01f, 2.37909555e-01f, -9.56310034e-02f, 1.49168015e-01f, 2.04809725e-01f, -7.07847672e-03f, 3.26662175e-02f, 1.31445244e-01f, 2.14955479e-01f,
  -3.35544050e-02f, 4.04113941e-02f, -5.72392680e-02f, -7.70876035e-02f, -7.74544030e-02f, 2.22874492e-01f, 2.14398354e-02f, 1.52573675e-01f, 1.34106219e-01f, -7.02723712e-02f,
  6.88614463e-03f, -1.66381493e-01f, -3.69299687e-02f, 2.61852872e-02f, 1.68744624e-01f, 3.63381766e-02f, 6.29552007e-02f, -4.25930731e-02f, 1.36560515e-01f, 7.91228116e-02f,
  1.41623050e-01f, -2.41686299e-01f, -8.92701671e-02f, -4.57210205e-02f, -1.89339265e-01f, -6.34989217e-02f, -1.49171473e-02f, 1.86180055e-01f, 3.63349587e-01f, -4.06137824e-01f,
  5.22327125e-02f, 2.17728987e-01f, 8.73443112e-02f, 1.50799796e-01f, 3.00681502e-01f, 5.10121584e-02f, 3.74770612e-02f, -1.39443412e-01f, 2.50057340e-01f, 1.06253415e-01f,
  4.99316258e-03f, -2.46408805e-02f, 8.63031968e-02f, 2.25479126e-01f, -9.41832662e-02f, -1.54064059e-01f, 7.45001361e-02f, 1.99148715e-01f, 2.42665172e-01f, -1.30747885e-01f,
  -3.15618157e-01f, 3.13812882e-01f, 1.93058074e-01f, 3.69172156e-01f, -1.58052295e-01f, -1.28323108e-01f, 8.20157006e-02f, 1.64854124e-01f, 1.33819401e-01f, -1.37535498e-01f,
  1.34696990e-01f, 1.10916525e-01f, 6.78566322e-02f, 1.35865780e-02f, 6.70580789e-02f, 1.97641283e-01f, -1.76289350e-01f, -5.89921698e-02f, 3.20031983e-03f, 2.88898438e-01f,
  3.85458946e-01f, 1.17804103e-01f, 3.24302554e-01f, 5.30484365e-03f, -1.60816848e-01f, -1.66863203e-01f, -4.34991298e-03f, 9.85985175e-02f, 2.02409700e-02f, -1.86455622e-01f,
  3.42789441e-02f, 6.70811683e-02f, -1.49457911e-02f, -2.62034349e-02f, 2.02936560e-01f, -2.79929519e-01f, -3.03265721e-01f, -1.16417654e-01f, -2.18662411e-01f, 9.17464718e-02f,
  -1.82149038e-01f, -1.04484409e-01f, 5.22483706e-01f, -2.20582396e-01f, 2.65889645e-01f, 1.66916132e-01f, 1.61855906e-01f, 1.88811406e-01f, 2.09415004e-01f, -1.23024784e-01f,
  1.92630246e-01f, -9.78025794e-02f, 9.15350094e-02f, 1.63874358e-01f, 8.86118561e-02f, -2.12789312e-01f, 2.05361918e-02f, 3.80544886e-02f, -1.13173760e-01f, 8.66888687e-02f,
  4.48122323e-01f, 1.71266034e-01f, 2.15554029e-01f, -1.07758343e-02f, -1.76829919e-01f, 2.57245690e-01f, 2.17347145e-01f, 1.74357250e-01f, 1.32445142e-01f, 3.52346003e-02f,
  8.32482427e-02f, 1.41238108e-01f, -5.72650768e-02f, -6.69762343e-02f, -8.57878774e-02f, 1.89596117e-01f, 9.48081464e-02f, 1.98883832e-01f, 6.56150207e-02f, 9.02687833e-02f,
  -1.49116844e-01f, -3.02534252e-01f, 1.24491761e-02f, 3.19561929e-01f, 3.12939703e-01f, 9.23001692e-02f, -1.43564595e-02f, 9.10288170e-02f, -1.81370080e-02f, 1.69555649e-01f,
  1.56280681e-01f, -8.07740912e-02f, 4.12997454e-02f, 2.02930570e-01f, -6.96469620e-02f, -5.17445207e-02f, 2.42722556e-01f, -4.42304015e-02f, 9.58306938e-02f, 1.95957012e-02f,
  8.47408548e-02f, 5.00481054e-02f, -1.23142123e-01f, 9.50079225e-03f, 8.86900257e-03f, 1.89805985e-03f, -3.51212412e-01f, 2.54129708e-01f, 6.33978024e-02f, -3.32338065e-01f,
  -2.43650638e-02f, 9.02716257e-03f, -2.55366594e-01f, -2.74996571e-02f, -1.34342834e-01f, 2.32163757e-01f, -4.89975289e-02f, 1.19759835e-01f, 2.12547421e-01f, 2.55673259e-01f,
  1.39741734e-01f, -5.09543195e-02f, 5.34461699e-02f, 1.21915385e-01f, 1.46188885e-01f, -2.28692830e-01f, 2.29584634e-01f, 2.45822281e-01f, 3.52022409e-01f, -2.02948600e-01f,
  1.23784222e-01f, -5.89166656e-02f, 1.73100293e-01f, 4.03970480e-04f, 4.16355319e-02f, 1.96741223e-02f, -7.52294660e-02f, 1.04252741e-01f, 6.40791794e-03f, -7.27845207e-02f,
  3.00052941e-01f, 4.53762412e-02f, 2.47523218e-01f, 5.93473315e-02f, 1.69680923e-01f, 1.98533740e-02f, 3.47878367e-01f, 6.20458350e-02f, -1.33825958e-01f, 3.54366447e-03f,
  3.81847396e-02f, 2.40071435e-02f, 4.09128852e-02f, 1.24587744e-01f, 1.08871490e-01f, -7.97398239e-02f, -7.94688240e-02f, 5.62356040e-02f, 1.46586522e-01f, 1.01468444e-01f,
  -2.82772034e-02f, 1.37657270e-01f, -1.80760890e-01f, 1.48141459e-01f, -4.26151901e-02f, -1.82945237e-01f, 2.06144556e-01f, 2.87719131e-01f, -6.75303396e-03f, -1.21987969e-01f,
  -2.84536541e-01f, 2.32170582e-01f, -1.70504123e-01f, -7.28686005e-02f, -1.26294017e-01f, -1.79439232e-01f, 6.99852705e-02f, -1.13977529e-01f, -4.91143987e-02f, 3.50926906e-01f,
  -3.01705729e-02f, -6.60290010e-03f, 1.80435732e-01f, -9.40029602e-03f, -1.59067318e-01f, 1.01358071e-01f, -4.04476337e-02f, 1.02395110e-01f, 1.52739778e-01f, -5.03326990e-02f,
  -1.50857419e-01f, 1.77756757e-01f, 3.56929332e-01f, -2.00204641e-01f, 1.57848582e-01f, 1.94505006e-02f, 3.46787512e-01f, -8.81119668e-02f, 6.67679682e-03f, 6.50379211e-02f,
  3.25699031e-01f, 2.27608010e-01f, -1.04811983e-02f, -8.24407563e-02f, -1.73639774e-01f, 3.55317220e-02f, 2.47712180e-01f, -2.58026477e-02f, 2.32459962e-01f, 2.69520462e-01f,
  1.04043253e-01f, 1.19552672e-01f, -3.25670272e-01f, -1.57400712e-01f, -2.11961847e-02f, 6.08315840e-02f, 3.42065841e-02f, -1.08932115e-01f, 1.38645872e-01f, -1.09807916e-01f,
  -5.31933419e-02f, 6.33405149e-02f, 1.34751471e-02f, -6.39616996e-02f, 1.64681301e-01f, 8.28705877e-02f, -2.38991845e-02f, -3.10300916e-01f, 3.29958826e-01f, 1.75310329e-01f,
  -1.47503480e-01f, -9.37792584e-02f, 1.16960905e-01f, 1.01422422e-01f, -2.55670786e-01f, 2.40918294e-01f, -6.70916215e-02f, -2.83652455e-01f, 7.35595897e-02f, 2.00475618e-01f,
  -1.24908268e-01f, 1.62955548e-03f, -2.81883217e-02f, -1.07496291e-01f, 6.96549490e-02f, 1.53449550e-01f, 7.03372881e-02f, 2.68036902e-01f, 9.93746519e-02f, 1.79802835e-01f,
  9.29223001e-02f, -1.66129485e-01f, -6.98194355e-02f, -4.24163118e-02f, 2.03975990e-01f, 1.08040012e-02f, -2.02085435e-01f, -5.69769181e-02f, -8.04219469e-02f, -2.89858401e-01f,
  -2.18395308e-01f, 3.28616828e-01f, 2.55383067e-02f, 1.12442143e-01f, -1.38291508e-01f, 1.00154720e-01f, 1.17760383e-01f, 2.94607311e-01f, -1.45428568e-01f, 1.95487499e-01f,
  -9.06310380e-02f, 2.07209021e-01f, -3.91280353e-02f, 1.44104332e-01f, 1.55261144e-01f, 5.29825613e-02f, 3.10554430e-02f, 3.48440632e-02f, 4.67077009e-02f, -1.26623228e-01f,
  2.84895431e-02f, 8.89065210e-03f, -4.72011194e-02f, -1.10751688e-01f, 1.22441985e-01f, 8.92490372e-02f, 3.19197364e-02f, -2.82920692e-02f, -2.55170241e-02f, -2.10413300e-02f,
  -2.11221337e-01f, 5.98332137e-02f, -2.62842864e-01f, -1.09400161e-01f, 5.56274094e-02f, -6.46340996e-02f, -1.89747974e-01f, 2.47581407e-01f, -1.67299449e-01f, 6.55531958e-02f,
  6.36130869e-02f, -1.38452843e-01f, 1.99658331e-02f, -7.53004700e-02f, 1.73633024e-01f, -1.79137960e-01f, 2.60723323e-01f, 2.22019836e-01f, 1.08290099e-01f, -6.50282428e-02f,
  6.88954517e-02f, -2.15262473e-01f, -1.04199387e-01f, 9.46580619e-03f, 4.76823524e-02f, 1.61577612e-01f, -1.72422886e-01f, 3.37610729e-02f, -3.98147702e-02f, 2.03678384e-01f,
  4.89453599e-02f, 2.77017385e-01f, -1.86925679e-02f, 4.63494137e-02f, 2.63662711e-02f, 2.99769621e-02f, 1.54779315e-01f, 1.12554505e-01f, 1.42056301e-01f, -1.24080554e-01f,
  4.05320153e-02f, 9.50206071e-02f, 1.27091765e-01f, -9.38453525e-03f, -1.41280472e-01f, 1.55634537e-01f, -9.81334448e-02f, 2.37322882e-01f, -1.65236130e-01f, 1.69003263e-01f,
  7.86824152e-02f, 1.21399492e-01f, 1.37293577e-01f, 4.96402346e-02f, 4.06051241e-02f, 1.41299099e-01f, 7.81798810e-02f, 1.10539936e-01f, 1.88702703e-01f, -2.49458309e-02f,
  1.60016865e-01f, 1.06666218e-02f, -5.90424286e-04f, 1.13626979e-01f, -1.41030401e-01f, 3.80812660e-02f, -3.37831765e-01f, -6.46622479e-03f, -5.11221879e-05f, 3.59061621e-02f,
  6.08972870e-02f, -3.87170799e-02f, 8.58791173e-02f, 2.95373470e-01f, 3.15810703e-02f, 4.19032462e-02f, -1.65438861e-01f, -1.62187770e-01f, 3.43107939e-01f, -7.45877028e-02f,
  2.74462074e-01f, 2.88010091e-01f, 2.76133090e-01f, -9.63830873e-02f, 9.11973789e-02f, -3.30526531e-01f, -5.52192293e-02f, 2.39089668e-01f, 1.15547366e-01f, -1.95753694e-01f,
  -2.63707638e-01f, 1.61765486e-01f, -2.04907954e-01f, 2.28660181e-01f, 1.66714653e-01f, 1.01012938e-01f, -1.66870058e-01f, 8.47763121e-02f, 1.71698272e-01f, -8.29351228e-03f,
  1.04095086e-01f, 1.87058851e-01f, 4.15096223e-01f, 1.12281613e-01f, -3.30529138e-02f, 5.91088235e-02f, -2.31453523e-01f, 3.42802033e-02f, -7.37262368e-02f, 2.92633265e-01f,
  -2.19312519e-01f, 2.85362393e-01f, -4.12986390e-02f, 1.68708786e-01f, -2.06816763e-01f, 1.84130725e-02f, -1.31114453e-01f, 1.41736165e-01f, 3.00531480e-02f, 5.28450906e-02f,
  -1.13892063e-01f, -7.66821057e-02f, 1.38598278e-01f, -5.80492802e-02f, -1.14644051e-01f, 1.21374661e-02f, 7.50101805e-02f, -1.03166066e-01f, 2.66382229e-02f, -2.16289312e-01f,
  3.72884423e-01f, 2.89217860e-01f, -6.15805164e-02f, -9.32870507e-02f, 4.84538414e-02f, -3.21030174e-03f, -2.66405791e-01f, 1.16157457e-01f, -8.22501704e-02f, -4.16672565e-02f,
  1.68383315e-01f, 2.29077175e-01f, -9.37876701e-02f, 2.41281912e-01f, 7.51548633e-02f, -1.78092286e-01f, -1.38111830e-01f, 1.84439033e-01f, 2.35026732e-01f, 8.62394348e-02f,
  2.14582011e-01f, 7.98499733e-02f, 2.90375769e-01f, -1.18147179e-01f, -2.55285949e-01f, 1.03000654e-02f, -1.00689612e-01f, 1.35922655e-01f, -2.20043808e-01f, 6.78732172e-02f,
  -1.41759083e-01f, -2.49972120e-01f, -2.40658164e-01f, 1.02729402e-01f, 2.39294738e-01f, 5.54953702e-02f, -1.88813642e-01f, 1.97820291e-02f, 3.08257461e-01f, 2.89044172e-01f,
  -4.74659242e-02f, 9.01089162e-02f, 3.17602344e-02f, 2.09476665e-01f, 1.04664564e-02f, 1.20112337e-01f, -6.01753332e-02f, 8.04845244e-02f, 3.15993071e-01f, 2.16933474e-01f,
  3.02724354e-02f, 1.17940925e-01f, 1.18623406e-01f, -5.44336028e-02f, -6.67164177e-02f, 1.51159659e-01f, 3.65080275e-02f, 2.00422201e-02f, 1.26496211e-01f, 6.75116628e-02f,
  -5.90541512e-02f, 1.80973649e-01f, 3.48901972e-02f, -1.65759698e-01f, 4.94198836e-02f, 2.53013849e-01f, -2.93035269e-01f, -1.87850475e-01f, 1.37926236e-01f, -2.09052786e-01f,
  1.48685828e-01f, -1.99477434e-01f, -5.23173884e-02f, 1.98115304e-01f, 2.74904460e-01f, -1.57444868e-02f, -6.29031658e-02f, 9.12986323e-02f, 8.86940956e-02f, -2.33350601e-02f,
  4.59558815e-02f, 2.38697603e-01f, -1.65256429e-02f, -1.12094786e-02f, 1.55914545e-01f, 1.89555094e-01f, 5.86520247e-02f, -1.60216078e-01f, 2.66982794e-01f, 2.85606265e-01f,
  2.70952076e-01f, -3.58653516e-02f, -5.90535328e-02f, 8.15327317e-02f, -1.37126639e-01f, 8.00216347e-02f, -1.24857381e-01f, 5.48565127e-02f, -6.66600913e-02f, 3.10370564e-01f,
  9.69709605e-02f, -1.17410846e-01f, 1.57791108e-01f, 2.30629325e-01f, -3.04204047e-01f, 1.68469131e-01f, -1.51813835e-01f, 2.91409642e-01f, 1.84926614e-01f, -2.33603418e-01f,
  -3.07960454e-02f, 3.10579300e-01f, 2.88072795e-01f, 1.58565089e-01f, 9.51884910e-02f, 1.02840140e-02f, -1.54293716e-01f, -5.80940247e-02f, -1.52493149e-01f, -1.14954919e-01f,
  1.59246959e-02f, -9.58738402e-02f, -5.30189127e-02f, -2.84447670e-02f, 1.95243165e-01f, -3.68315876e-02f, 2.27491498e-01f, -1.93358183e-01f, 1.27186358e-01f, -2.21140414e-01f,
  -2.76436657e-01f, -1.56378075e-01f, -7.50861987e-02f, -1.29633248e-01f, -2.18330458e-01f, 3.06744576e-01f, 2.61570543e-01f, -2.62918562e-01f, -1.17280044e-01f, 6.98804706e-02f,
  1.19440131e-01f, -2.33137101e-01f, 6.83659241e-02f, 1.22554325e-01f, -9.57596749e-02f, 2.37807184e-01f, 1.80807471e-01f, 7.36190155e-02f, -4.58551496e-02f, -1.15195706e-01f,
  -8.19677860e-02f, -5.82881756e-02f, 2.79093564e-01f, -2.85899863e-02f, 2.35573128e-01f, 2.97978759e-01f, 2.87192255e-01f, 5.65240756e-02f, -2.86798067e-02f, -1.48420617e-01f,
  2.24330619e-01f, 6.56731129e-02f, -1.85768232e-02f, -5.97145362e-03f, -1.65984362e-01f, -2.39095800e-02f, 2.39283163e-02f, 3.12466294e-01f, 3.50802508e-03f, -5.71381077e-02f,
  -1.20251747e-02f, 1.33635759e-01f, 1.25748478e-02f, -1.13415532e-01f, 2.45272160e-01f, 2.35426992e-01f, 1.46227837e-01f, 2.31644168e-01f, 2.68543959e-01f, 1.56215727e-01f,
  3.90117727e-02f, 1.40472203e-01f, -1.37664583e-02f, 1.36920840e-01f, 1.18059954e-02f, -2.35181674e-02f, 1.69555262e-01f, 3.49234007e-02f, 2.16549113e-02f, 6.21435754e-02f,
  -6.17069844e-03f, -6.29365221e-02f, -1.90663815e-01f, -9.28288698e-02f, -1.55420741e-02f, 2.09754467e-01f, 6.08510785e-02f, -1.46893673e-02f, 2.86314666e-01f, 5.96499369e-02f,
  2.10501440e-02f, 4.39530574e-02f, -1.15620755e-01f, 1.07138075e-01f, 2.50343323e-01f, -1.52875707e-01f, 1.11931421e-01f, 1.84630468e-01f, 4.01347846e-01f, 1.68028921e-01f,
  2.00530887e-01f, -1.77195773e-01f, -3.98645103e-02f, -4.82936502e-02f, -1.16732776e-01f, -5.14428206e-02f, 2.02212900e-01f, -2.54612863e-01f, -3.34334709e-02f, -6.85981242e-03f,
  6.27901256e-02f, 5.03742471e-02f, 3.17292720e-01f, 9.38335359e-02f, 1.46438867e-01f, -1.05032444e-01f, 7.10867941e-02f, 1.59874614e-02f, 1.59864008e-01f, 1.92951724e-01f,
  -1.09388664e-01f, 1.30272269e-01f, -1.60274487e-02f, 1.99580163e-01f, 2.32187226e-01f, 2.54740983e-01f, -2.10014120e-01f, 5.51637076e-02f, 8.29713270e-02f, 3.30537111e-01f,
  -1.87793404e-01f, 1.06224678e-02f, 1.03576556e-01f, -1.81072466e-02f, 9.00213644e-02f, -9.24663246e-02f, 8.77752081e-02f, 4.82352376e-02f, 2.88740061e-02f, 1.62013233e-01f,
  -1.37576717e-03f, 7.15016946e-02f, 6.98463060e-04f, 8.73107985e-02f, -1.60886496e-01f, 2.92746395e-01f, 1.98973447e-01f, 2.08437040e-01f, 2.79282689e-01f, 1.96884677e-01f,
  1.37085408e-01f, 2.03563869e-01f, -1.63970530e-01f, -2.68562436e-01f, -8.71858373e-02f, -2.04230528e-02f, 2.03932792e-01f, 1.94870025e-01f, -2.48466834e-01f, 5.46406321e-02f,
  -1.59205407e-01f, -5.17630801e-02f, 1.18259080e-01f, 2.38204934e-03f, 1.54526070e-01f, 2.23293498e-01f, 3.35811049e-01f, 5.64077422e-02f, -3.81109454e-02f, 2.11565360e-01f,
  -1.26152948e-01f, -3.27304751e-02f, 2.90637333e-02f, 2.35580057e-01f, 1.30282462e-01f, -1.57356858e-01f, 3.07091087e-01f, 6.32413253e-02f, -1.72474608e-01f, 3.53706598e-01f,
  8.87432620e-02f, -9.11532417e-02f, -3.07572812e-01f, 1.50670454e-01f, 2.68122852e-01f, 5.48173375e-02f, 1.99519739e-01f, 1.87502936e-01f, 2.30874911e-01f, -1.43042654e-01f,
  2.64879048e-01f, 7.42583647e-02f, -1.84738770e-01f, -1.28455117e-01f, 1.66618749e-01f, 5.57867102e-02f, -3.04061919e-02f, 1.52171642e-01f, 1.55143559e-01f, 3.43074761e-02f,
  4.96070981e-02f, 1.30694553e-01f, 7.10643604e-02f, -7.77203441e-02f, 2.46487036e-02f, 1.59832072e-02f, 4.56478968e-02f, 1.60795480e-01f, 1.35260597e-01f, 1.83701247e-01f,
  1.07049912e-01f, 1.86668485e-01f, -1.18176959e-01f, -8.90209675e-02f, 2.02231228e-01f, -1.13032304e-01f, -9.38334763e-02f, -4.72251326e-02f, -1.73446521e-01f, 6.28292114e-02f,
  2.83436328e-01f, -5.54851517e-02f, -1.03909178e-02f, 3.23489189e-01f, 5.25282659e-02f, -1.14455178e-01f, -1.46242782e-01f, -9.84473825e-02f, 1.51686698e-01f, 3.68207693e-01f,
  1.34644091e-01f, 2.59102970e-01f, 1.42455891e-01f, 2.82977819e-01f, 3.35288122e-02f, 2.69343346e-01f, 1.19317984e-02f, -8.12634006e-02f, 7.96453431e-02f, -9.90355983e-02f,
  5.77689819e-02f, -8.76389220e-02f, 9.83235464e-02f, 1.18435629e-01f, 1.76125448e-02f, -2.12709904e-02f, -7.80791491e-02f, 7.93941841e-02f, 2.14032993e-01f, -1.04501136e-01f,
  -1.18897833e-01f, -6.86768964e-02f, 4.71202768e-02f, -5.85380979e-02f, 3.64347488e-01f, 1.05223253e-01f, -8.71311501e-02f, -8.94487500e-02f, 1.85906678e-01f, -1.93872619e-02f,
  9.67606232e-02f, -2.27044225e-01f, -2.32339591e-01f, -1.24652289e-01f, -2.01494962e-01f, -8.51554871e-02f, -1.65050447e-01f, -1.40935883e-01f, -1.11498661e-01f, -3.15040238e-02f,
  2.67760187e-01f, -2.88374517e-02f, -1.65149402e-02f, -1.02887146e-01f, -1.30239740e-01f, -2.04120159e-01f, -8.12803919e-04f, -2.52119333e-01f, -3.17103505e-01f, 6.33974746e-02f,
  -6.27896711e-02f, 2.99795363e-02f, 3.26089740e-01f, 9.98722240e-02f, -1.60966128e-01f, -1.05545014e-01f, 2.02917099e-01f, -1.57116666e-01f, 9.21332464e-02f, 3.44715863e-02f,
  6.33847713e-02f, 2.06894502e-01f, -9.45790261e-02f, -3.59272271e-01f, -2.03321218e-01f, 7.56338388e-02f, 1.11073956e-01f, 1.19207362e-02f, -2.18249317e-02f, 3.94542962e-02f,
  9.07855704e-02f, 1.80201814e-01f, 5.19236885e-02f, 2.69270331e-01f, 7.56714027e-03f, 1.26400843e-01f, 1.95180535e-01f, 6.99282140e-02f, 7.71587044e-02f, 1.19509265e-01f,
  7.30814934e-02f, -3.29390578e-02f, -4.42679785e-02f, 2.18225390e-01f, 7.54475743e-02f, -1.13923088e-01f, -3.44975322e-01f, 9.79604423e-02f, -3.69551748e-01f, 6.35430589e-02f,
  -1.76489085e-01f, 9.15248320e-02f, 1.91464826e-01f, 1.40797675e-01f, -7.60797635e-02f, 2.07353354e-01f, -3.54635566e-02f, -3.79071496e-02f, -2.33380292e-02f, -1.33212596e-01f,
  -2.47891098e-02f, 2.04183199e-02f, 5.51881455e-02f, -1.33633032e-01f, 2.15339005e-01f, -2.23835453e-01f, 1.43156452e-02f, 1.83788285e-01f, -8.01189765e-02f, 4.28660326e-02f,
  1.14312418e-01f, 1.03762090e-01f, -3.59235741e-02f, 3.52374256e-01f, 6.99460208e-02f, 1.02727555e-01f, 3.68617252e-02f, 1.34895682e-01f, -1.04406647e-01f, 7.33772367e-02f,
  2.10791245e-01f, -6.45354167e-02f, 1.03237247e-02f, -3.06535028e-02f, 2.83875912e-01f, -7.52037764e-02f, 2.14142993e-01f, 7.82162622e-02f, 1.82094257e-02f, -1.38784021e-01f,
  9.81448293e-02f, 7.85955340e-02f, -2.40057036e-02f, -1.34131491e-01f, -9.15226154e-03f, -1.91610247e-01f, 3.89445499e-02f, 1.55425534e-01f, 1.78259179e-01f, 6.30725101e-02f,
  -4.79302332e-02f, 1.35069583e-02f, -7.74341524e-02f, -4.31652851e-02f, 9.76262465e-02f, 2.63195157e-01f, 1.68316633e-01f, -1.18961073e-01f, 1.66999564e-01f, 1.57529742e-01f,
  -7.13243335e-02f, 1.67028889e-01f, 6.18452439e-04f, 6.08651750e-02f, 2.72217572e-01f, 2.70990789e-01f, -2.39114285e-01f, -1.11031830e-02f, 9.90793575e-03f, -1.95000932e-01f,
  -4.89587113e-02f, 7.43777826e-02f, -3.10894012e-01f, -8.22308883e-02f, -1.73436537e-01f, -2.58082330e-01f, -3.16628605e-01f, -2.66026594e-02f, 1.75979167e-01f, -1.53103411e-01f,
  4.74581718e-02f, -2.59112045e-02f, -6.61606640e-02f, -4.60103452e-01f, -2.04593092e-01f, -1.87859774e-01f, -3.13317418e-01f, 7.14547187e-02f, -6.18103007e-03f, 5.10016046e-02f,
  4.75856632e-01f, -1.34494662e-01f, -5.13744354e-02f, -7.06913099e-02f, 5.52505860e-03f, -3.46976101e-01f, -1.63792390e-02f, 1.95295274e-01f, -2.37374052e-01f, 7.06750229e-02f,
  1.12818561e-01f, 1.32985860e-01f, -1.29455641e-01f, 2.41132397e-02f, -7.96875858e-04f, 2.15048999e-01f, 2.38083512e-01f, 6.82519451e-02f, 1.18360400e-01f, 1.83415502e-01f,
  3.46222073e-01f, 4.63326514e-01f, 7.24202814e-03f, 6.93514422e-02f, 2.97811031e-01f, 1.79490577e-02f, 4.38434556e-02f, 7.60693401e-02f, 4.50836355e-03f, 6.18146583e-02f,
  -1.83936179e-01f, -6.46569729e-02f, 1.85899258e-01f, -1.15861274e-01f, -1.76493526e-02f, 1.53594017e-01f, 2.28373364e-01f, -6.88802358e-03f, 8.40660557e-03f, 8.08165222e-02f,
  3.29661697e-01f, 5.12322299e-02f, -1.21979117e-01f, -1.02038875e-01f, 9.67630222e-02f, 3.73811461e-02f, -5.07471934e-02f, 8.31500068e-03f, -1.25088394e-01f, 1.60043724e-02f,
  -1.07400127e-01f, -1.27631232e-01f, -1.00335024e-01f, -4.02489118e-02f, 9.30458605e-02f, -6.59440309e-02f, -4.40922007e-02f, -3.76584120e-02f, -2.30934005e-02f, 6.80604205e-02f,
  2.81768180e-02f, 2.57869903e-02f, -9.67177600e-02f, 3.20320576e-03f, 5.92551120e-02f, -8.96336362e-02f, -3.70528996e-02f, 1.08222164e-01f, 6.18932582e-02f, 1.83673967e-02f,
  -6.42377362e-02f, 3.20627391e-02f, -6.96534663e-02f, -3.30723189e-02f, 6.17080703e-02f, -1.22955874e-01f, -1.57072227e-02f, -2.92266905e-02f, -4.84801009e-02f, 4.29023430e-02f,
  4.68021780e-02f, -2.21201591e-02f, -3.39254364e-02f, -7.50257401e-03f, 5.20412624e-03f, -8.04536566e-02f, 1.91380060e-03f, -1.05858028e-01f, 3.43456641e-02f, 9.87228379e-03f,
  -1.71839297e-02f, -6.11798503e-02f, -1.37993665e-02f, -9.09684151e-02f, 1.61813609e-02f, 2.70950031e-02f, 1.18891060e-01f, -2.80997213e-02f, -6.18745089e-02f, 1.06641926e-01f,
  -9.02257413e-02f, -1.26611307e-01f, 1.79123729e-02f, -1.09305106e-01f, -1.08116448e-01f, 4.87628207e-02f, -1.80016920e-01f, -1.42870054e-01f, -8.85280818e-02f, -1.50360882e-01f,
  -2.37264320e-01f, 2.58347541e-01f, -5.46048582e-02f, 4.28676307e-02f, -3.41799885e-01f, 2.30854109e-01f, -8.74951035e-02f, -3.37379396e-01f, 1.08517036e-01f, 1.91901982e-01f,
  8.10773447e-02f, 6.68663383e-02f, 3.41974944e-02f, -4.88882475e-02f, 1.38145164e-01f, 2.44099885e-01f, -2.94065207e-01f, -7.77869299e-02f, 6.48026466e-02f, -2.02023834e-01f,
  1.01640634e-01f, 2.04435647e-01f, -3.92743051e-01f, -4.04697321e-02f, -1.71606585e-01f, -1.75405573e-02f, -4.50072810e-02f, 8.82659927e-02f, 1.24890901e-01f, 1.38941571e-01f,
  2.38599405e-01f, -1.16792746e-01f, 1.81242637e-02f, 4.06359732e-01f, 3.46313924e-01f, -1.87891901e-01f, 3.70770961e-01f, 8.68481472e-02f, 1.59959748e-01f, -3.97474058e-02f,
  2.95977056e-01f, -1.26975164e-01f, -1.47991523e-01f, 1.43593192e-01f, 1.62717670e-01f, -9.75874215e-02f, -4.26201969e-01f, 1.11686409e-01f, 2.20414162e-01f, 7.81495066e-04f,
  3.44243288e-01f, 8.41750503e-02f, 2.73394614e-01f, -2.32376114e-01f, 2.80219376e-01f, 1.34901270e-01f, -9.02930796e-02f, -2.91987449e-01f, -1.41134590e-01f, -1.40094608e-01f,
  8.94457474e-02f, 7.84836113e-02f, 1.16069712e-01f, 1.26401871e-01f, -3.68303247e-02f, -4.34985869e-02f, 1.55454382e-01f, 1.59869122e-03f, -1.38895931e-02f, 1.02645896e-01f,
  -1.01719595e-01f, 2.02963755e-01f, -3.13246280e-01f, 3.16165894e-01f, -5.46010677e-03f, 2.04361573e-01f, 2.47063473e-01f, 3.38472247e-01f, -2.62628973e-01f, 2.33796015e-01f,
  1.91930264e-01f, 8.52684304e-02f, -1.42980948e-01f, -3.72950584e-02f, 1.48030326e-01f, 3.04933369e-01f, 1.74526766e-01f, 9.37865898e-02f, 2.73439497e-01f, -3.39584090e-02f,
  2.90282667e-01f, -1.56769380e-01f, 7.57596493e-02f, -1.51372477e-01f, 1.57186180e-01f, -2.11766988e-01f, 2.84594208e-01f, -7.08796978e-02f, -8.21256265e-02f, 2.54403383e-01f,
  -2.43651584e-01f, 8.82166773e-02f, -1.12154763e-02f, 2.98346847e-01f, 1.22869298e-01f, 8.94467011e-02f, -1.01226516e-01f, 6.84693009e-02f, 2.16150045e-01f, 8.19623284e-03f,
  3.68096948e-01f, 2.61952430e-01f, 1.85609490e-01f, 1.36352584e-01f, -1.60856858e-01f, 1.92591608e-01f, 9.36097875e-02f, 9.02149305e-02f, -2.39797235e-01f, -2.62316316e-02f,
  -2.85220109e-02f, 1.71743020e-01f, 3.53154927e-01f, 3.07295203e-01f, 4.19934541e-02f, 1.30336046e-01f, -1.26422951e-02f, 7.90361464e-02f, 1.71345890e-01f, 7.67948925e-02f,
  5.05101532e-02f, 1.93641245e-01f, 6.58044126e-03f, 1.99789718e-01f, -6.78561851e-02f, 1.38224766e-01f, -1.79706365e-01f, 2.71594346e-01f, 6.35294244e-03f, -4.89156879e-02f,
  3.26165646e-01f, 1.36709630e-01f, -2.52146851e-02f, 8.57159346e-02f, -2.24133804e-01f, 2.55672395e-01f, -3.24516073e-02f, -1.97451383e-01f, -1.49709322e-02f, 3.07253391e-01f,
  1.04355611e-01f, 1.06809074e-02f, 3.67580242e-02f, 3.66922975e-01f, 1.35857031e-01f, -1.84261963e-01f, 3.46265316e-01f, 2.71097273e-01f, -1.20899845e-02f, -2.65800953e-01f,
  2.13025495e-01f, 3.51851434e-01f, 1.20634563e-01f, -4.88422289e-02f, -1.13883331e-01f, 2.14106634e-01f, 1.41926229e-01f, 3.31773341e-01f, 2.79608816e-01f, -9.81999338e-02f,
  3.83858413e-01f, 2.14006230e-02f, 2.08384171e-01f, -8.64170939e-02f, 1.10569470e-01f, 3.36152226e-01f, 4.55354601e-02f, 2.12096740e-02f, 2.23012149e-01f, 1.00159444e-01f,
  3.37675363e-01f, -1.30352765e-01f, 6.69190437e-02f, 1.85879931e-01f, 2.05869958e-01f, 7.40318894e-02f, -7.38536492e-02f, 1.11573197e-01f, 8.62912983e-02f, -3.39937173e-02f,
  -7.12603033e-02f, -1.20353729e-01f, 7.57230818e-02f, 3.24145146e-02f, -9.72050428e-02f, 7.08930194e-02f, -3.87925655e-02f, 1.91327988e-03f, -1.35963736e-02f, -7.51394182e-02f,
  3.86360697e-02f, -1.78495958e-03f, 4.40869778e-02f, -8.04487243e-02f, 2.48673614e-02f, -8.74854326e-02f, 8.58916268e-02f, 3.19761410e-02f, -5.85724898e-02f, 6.63218051e-02f,
  6.43728599e-02f, 6.49766997e-02f, 7.71330148e-02f, -1.14356345e-02f, -1.90606955e-02f, -4.07501422e-02f, 9.67363566e-02f, 1.20967869e-02f, -3.71707194e-02f, -8.60566422e-02f,
  -1.14842378e-01f, -6.92414939e-02f, 6.22850657e-02f, -4.46259603e-03f, -5.45556694e-02f, -1.34429142e-01f, 3.03275883e-03f, 1.02699198e-01f, 8.59638304e-02f, 6.65013269e-02f,
  5.66128753e-02f, -6.58020303e-02f, -5.17392457e-02f, -6.02091029e-02f, 1.12061135e-01f, -5.42621501e-02f, -4.28785011e-02f, -7.21931234e-02f, -1.05606534e-01f, -1.71799399e-02f,
  -7.79584497e-02f, -1.18802667e-01f, -1.32991448e-01f, 6.76682070e-02f, -5.66481128e-02f, -1.36628211e-01f, -7.26532042e-02f, 1.11531332e-01f, 7.61182979e-02f, -2.14188695e-02f,
  1.12569831e-01f, -1.02475762e-01f, -4.04460654e-02f, -6.98275119e-02f, 1.39958272e-02f, 1.78417265e-01f, -4.27849218e-02f, -9.04696956e-02f, 7.40191294e-03f, 4.75328229e-02f,
  -2.54253093e-02f, -6.51293397e-02f, 1.51633888e-01f, -4.37032897e-03f, -8.50821361e-02f, -5.22740185e-02f, 7.41659030e-02f, -1.85431093e-01f, 7.16326535e-02f, -8.82357452e-03f,
  -2.18765833e-03f, -1.56457856e-01f, -3.42707157e-01f, 2.72021711e-01f, 7.84442723e-02f, -1.52783260e-01f, -6.69755563e-02f, -2.18466688e-02f, 6.80676252e-02f, 1.23905040e-01f,
  2.65737534e-01f, 2.32295752e-01f, -1.06084377e-01f, -1.74954250e-01f, 9.45211621e-04f, 8.12556446e-02f, 1.08337544e-01f, 1.32552311e-01f, 2.25974008e-01f, -2.38401502e-01f,
  -2.09098652e-01f, 9.80825946e-02f, -1.43367007e-01f, 2.28142008e-01f, 1.72418565e-01f, 2.02490360e-01f, -3.32937807e-01f, -2.02540010e-01f, 1.86114639e-01f, 3.93500887e-02f,
  6.15811497e-02f, 1.89744011e-01f, 3.59940410e-01f, 3.58790979e-02f, -2.19698809e-02f, 2.13627174e-01f, -1.48912802e-01f, -9.80963837e-03f, -1.14853457e-01f, 1.52993843e-01f,
  -4.26742770e-02f, 1.52735129e-01f, 2.35626817e-01f, 4.32891622e-02f, 2.19232023e-01f, 1.88816056e-01f, 1.56104520e-01f, -4.68847379e-02f, 6.31050766e-02f, 7.42638931e-02f,
  9.53883119e-03f, 1.09725252e-01f, -5.66257611e-02f, -1.08843453e-01f, -3.70899066e-02f, -8.20637494e-02f, 5.66079207e-02f, 1.54566377e-01f, -1.13546371e-01f, 1.23067059e-01f,
  5.68234734e-02f, 6.13265671e-03f, 2.01893687e-01f, 6.07283749e-02f, -2.29151949e-01f, 1.63495213e-01f, 2.39605427e-01f, 8.73604566e-02f, 1.75174758e-01f, 4.44666371e-02f,
  -1.16509341e-01f, 3.90944118e-03f, 8.16841237e-03f, -1.94782000e-02f, 2.06770331e-01f, -7.04597831e-02f, 1.26188412e-01f, 1.69675201e-02f, 1.02864459e-01f, -2.70605534e-01f,
  1.57175049e-01f, -2.75977477e-02f, 1.95949167e-01f, -1.66050836e-01f, 2.46780664e-02f, 1.30298674e-01f, -1.05161980e-01f, -1.28770560e-01f, -4.22482379e-03f, 3.01948845e-01f,
  9.99145061e-02f, 7.33643249e-02f, 4.90574725e-02f, 1.33898452e-01f, -1.61354467e-02f, -6.28399625e-02f, 8.97846445e-02f, 9.46020186e-02f, 1.69855431e-01f, 2.17503712e-01f,
  1.06111713e-01f, 1.22718094e-02f, -1.27986729e-01f, 2.01752022e-01f, -2.77202845e-01f, -2.11511850e-01f, 1.75959572e-01f, 1.93539336e-01f, 1.14700481e-01f, 2.47819036e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  6.47963285e-02f, -3.14347795e-03f, -4.68969792e-02f, -8.42794254e-02f, 8.25914890e-02f, 8.65437612e-02f, 9.14803669e-02f, 5.13680018e-02f, 1.02068409e-01f, 1.01724751e-01f,
  1.86677039e-01f, 1.90625995e-01f, 4.02976610e-02f, 4.71614860e-02f, -4.89664190e-02f, 2.36553978e-02f, 8.89494121e-02f, 4.99541089e-02f, 2.10945122e-02f, 1.46723846e-02f,
  1.17934674e-01f, -2.35718023e-02f, 1.50392344e-02f, 1.25380512e-02f, 1.17361680e-01f, 1.48305744e-01f, 9.92152691e-02f, -4.71726619e-02f, 1.34952232e-01f, 1.74430966e-01f,
  3.98482149e-03f, -3.28437835e-02f, -3.05012278e-02f, -6.26445562e-02f, -1.15390271e-02f, 3.08175217e-02f, 1.48643404e-01f, -9.51155573e-02f, -4.95350659e-02f, -8.65912363e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -2.02915490e-01f, 6.54884130e-02f, -2.19014026e-02f, -5.86952418e-02f, -1.29620478e-01f, -1.74161479e-01f, -1.07599147e-01f, 1.07343458e-01f, -5.13009541e-03f, -1.22756839e-01f,
  1.11684434e-01f, -1.59399241e-01f, 2.11992040e-01f, -2.55851418e-01f, -1.49292141e-01f, 1.57361150e-01f, 1.28168598e-01f, -2.20111501e-03f, 2.23692387e-01f, -1.97848529e-01f,
  -1.22733146e-01f, -1.07948091e-02f, -7.04664141e-02f, -7.68805668e-02f, -2.86612391e-01f, 6.60843924e-02f, -1.86495051e-01f, 2.78333817e-02f, -1.62573352e-01f, -2.93499857e-01f,
  -3.08557779e-01f, -3.69677246e-01f, 4.83428165e-02f, -6.61577359e-02f, -2.32365936e-01f, 1.88191280e-01f, -2.49713793e-01f, 6.64284602e-02f, 2.24219635e-02f, 1.60669889e-02f,
  7.88949355e-02f, 8.24199766e-02f, 6.19212426e-02f, -1.38764635e-01f, 5.88867776e-02f, -3.39877307e-01f, 2.10905552e-01f, 1.81409836e-01f, -2.95234531e-01f, -2.14552909e-01f,
  8.00707862e-02f, 7.62938336e-02f, -4.17626798e-01f, -3.55704516e-01f, 4.09304082e-01f, 1.31844401e-01f, 2.68362135e-01f, 1.07229352e-01f, -1.08773440e-01f, 1.29899457e-01f,
  1.36158913e-01f, 4.79503199e-02f, 8.63616094e-02f, 1.08519003e-01f, 1.50339246e-01f, -2.11927611e-02f, 5.07489331e-02f, 1.15282975e-01f, -1.15783975e-01f, -1.02664493e-01f,
  9.37469974e-02f, 7.55628273e-02f, 3.90099660e-02f, -1.11393176e-01f, 8.78965035e-02f, 2.28604138e-01f, 6.85356781e-02f, 1.48264006e-01f, 1.39268339e-01f, 2.65375018e-01f,
  2.45619535e-01f, 1.92837179e-01f, -1.23656549e-01f, 6.16868772e-03f, -1.87069908e-01f, -1.68940157e-01f, -1.53076157e-01f, -1.32089555e-01f, -7.16994405e-02f, -9.45455134e-02f,
  -7.39119202e-02f, 4.99709090e-03f, 5.75686097e-02f, 6.27400652e-02f, 2.44800597e-01f, -2.85560340e-01f, 2.42693871e-01f, -4.46092486e-02f, 1.87902644e-01f, 2.94425935e-01f,
  1.58437088e-01f, 7.63720348e-02f, 3.21910791e-02f, -3.87152861e-04f, -2.19860524e-01f, -2.12742090e-01f, -2.46476978e-01f, -5.79666644e-02f, 2.86307633e-01f, -3.02801967e-01f,
  -1.68412384e-02f, 2.11562067e-01f, -3.67451310e-01f, 1.73550136e-02f, -1.90298304e-01f, 1.05322912e-01f, -1.25799716e-01f, 5.25386781e-02f, -3.36155593e-01f, -2.14280948e-01f,
  -1.50881693e-01f, -3.01686302e-02f, -5.43687582e-01f, -8.56592357e-02f, 5.57451472e-02f, -7.20960721e-02f, 6.38945550e-02f, -3.81821781e-01f, 3.56774926e-02f, -8.36500823e-02f,
  -6.66790232e-02f, 3.79917808e-02f, -1.29357213e-02f, 1.42792031e-01f, 2.04443373e-02f, -6.63979053e-02f, -4.95938174e-02f, 6.44840077e-02f, -8.37083906e-02f, 6.76315054e-02f,
  -2.97916174e-01f, 2.10820213e-01f, 2.62465198e-02f, 2.80012161e-01f, 2.45327055e-01f, -5.67830913e-02f, -8.10017139e-02f, 6.24060519e-02f, -1.78821340e-01f, 3.32477003e-01f,
  1.50920346e-01f, 9.68902558e-02f, -5.09378165e-02f, -1.57629892e-01f, 2.01520726e-01f, -4.67161462e-03f, -3.54250908e-01f, 1.07505873e-01f, 2.25340053e-01f, -5.37019260e-02f,
  2.52774984e-01f, -1.14364468e-01f, -4.18297619e-01f, -5.17436750e-02f, -1.94438502e-01f, 2.64382869e-01f, -4.45081927e-02f, -1.25850807e-03f, -1.41473711e-01f, -5.66741407e-01f,
  -6.00638449e-01f, 1.94545776e-01f, 8.81086290e-02f, -4.80333030e-01f, 1.42939007e-02f, -3.53656143e-01f, -3.44512194e-01f, -2.29056805e-01f, -9.49853510e-02f, -1.59592971e-01f,
  2.78365433e-01f, -1.36310443e-01f, -7.94953555e-02f, -4.30008113e-01f, 1.82624072e-01f, -1.93112083e-02f, 3.01685274e-01f, -1.24160722e-01f, 7.94744417e-02f, -8.06974620e-02f,
  -2.37846464e-01f, -3.56816500e-01f, -1.71153918e-01f, -9.06828046e-02f, 8.66149142e-02f, -1.82629526e-02f, 1.00185625e-01f, 1.87149987e-01f, 2.29444616e-02f, -4.44910005e-02f,
  -2.75320709e-02f, 9.48585290e-03f, -1.20337673e-01f, 1.90879360e-01f, 1.95691928e-01f, -1.64661035e-01f, 2.76624084e-01f, 3.05487007e-01f, 1.04647629e-01f, 1.14664011e-01f,
  -2.71576285e-01f, 9.19202194e-02f, 2.75483787e-01f, -1.42463163e-01f, 5.22435270e-03f, -2.31203600e-03f, -1.86557129e-01f, 1.23183250e-01f, -3.25115323e-01f, 1.81579832e-02f,
  2.13749111e-01f, 1.70174554e-01f, 1.32733524e-01f, -3.09598416e-01f, -3.10823917e-01f, -5.78132086e-02f, 1.03334911e-01f, -1.43538013e-01f, -3.19862992e-01f, -2.78755605e-01f,
  -1.27147555e-01f, 6.99946135e-02f, -1.27673194e-01f, 2.06601381e-01f, 1.99124619e-01f, -2.96023637e-01f, -2.02248827e-01f, -2.91351601e-02f, 1.38126731e-01f, 1.94915995e-01f,
  -3.11861280e-02f, 1.52953431e-01f, 6.44528717e-02f, 2.20903248e-01f, -5.56793332e-01f, -3.02946091e-01f, 3.04424822e-01f, 9.34073254e-02f, 7.89751112e-02f, -2.15890980e-03f,
  -2.66329765e-01f, -8.35431814e-02f, -3.67438406e-01f, 4.82988432e-02f, -1.30444035e-01f, -9.03451294e-02f, -2.02615112e-01f, 1.39302820e-01f, 9.91072133e-02f, 9.62685645e-02f,
  -2.78815883e-03f, 1.24435797e-01f, 1.43401280e-01f, -2.19928622e-02f, -1.24019757e-01f, 1.32879093e-01f, 7.78989941e-02f, 1.27217807e-02f, 1.67306900e-01f, 2.51846164e-01f,
  1.30717516e-01f, 4.97709922e-02f, -1.20817386e-01f, -2.08715089e-02f, 2.43587181e-01f, 2.24039435e-01f, -2.14093983e-01f, -2.29144216e-01f, 2.32487634e-01f, -1.23631909e-01f,
  -1.25341654e-01f, -2.19605967e-01f, -6.15062565e-02f, -5.73094115e-02f, 2.31214687e-01f, -3.76939811e-02f, -2.40050286e-01f, 8.67772475e-02f, 2.31993794e-01f, -1.14832269e-02f,
  -1.71058133e-01f, -2.87339002e-01f, -3.17683607e-01f, -7.66040981e-02f, -4.94971126e-02f, 2.21032370e-02f, 2.27900758e-01f, 1.70893073e-01f, 2.19628632e-01f, -3.80756706e-01f,
  -1.80252478e-01f, -1.72440127e-01f, -6.10335730e-02f, 5.11709088e-03f, -8.11991096e-02f, 1.53239921e-01f, -4.66316581e-01f, 3.83629724e-02f, -9.94429644e-03f, -1.17421262e-02f,
  -2.61813104e-01f, 6.96219429e-02f, -2.73626357e-01f, 2.01562047e-02f, -3.22739035e-01f, 2.50705898e-01f, 2.57719941e-02f, 1.07147627e-01f, -1.27783388e-01f, 2.06974074e-01f,
  2.45105624e-02f, 1.85979940e-02f, 9.20130014e-02f, 2.21261904e-01f, 1.36186257e-01f, -2.29110509e-01f, 3.43827344e-02f, -1.17833056e-01f, -1.36179909e-01f, -3.06589473e-02f,
  9.75729376e-02f, 5.56669272e-02f, 2.99536847e-02f, 3.15731972e-01f, -6.13308214e-02f, -1.75135419e-01f, -3.29501003e-01f, -2.32600681e-02f, 1.43624634e-01f, 1.09734327e-01f,
  3.21014613e-01f, -2.23799959e-01f, -1.83815345e-01f, -4.10721153e-02f, 2.23561302e-01f, -3.46125007e-01f, 6.85985237e-02f, -5.49694486e-02f, -1.04485013e-01f, -6.26691664e-03f,
  -3.42849404e-01f, -1.25629604e-01f, -4.14967597e-01f, 6.43223664e-03f, -3.26467901e-02f, 1.28823025e-02f, 2.02530846e-01f, -3.10805231e-01f, -1.95557326e-02f, -3.40465792e-02f,
  4.15346166e-03f, -2.76562363e-01f, -4.32887435e-01f, 1.11959465e-01f, 6.94292635e-02f, 1.77372992e-01f, 6.47397414e-02f, 2.08575696e-01f, 9.61562172e-02f, -3.36456932e-02f,
  1.47854201e-02f, 3.88820283e-03f, -1.60385177e-01f, -1.25015944e-01f, -1.98935270e-01f, 1.01678409e-01f, -2.15165317e-01f, 9.24070925e-02f, -4.81173962e-01f, 1.72759324e-01f,
  1.28036156e-01f, 7.48973386e-03f, 3.10064703e-01f, 5.50519191e-02f, -1.43207088e-02f, -6.91432599e-03f, -1.68324020e-02f, 7.42502138e-02f, -9.26218089e-03f, -8.39763787e-03f,
  -6.59839064e-02f, 3.45977172e-02f, 2.06347182e-01f, 8.95744339e-02f, -5.35104759e-02f, 1.36799976e-01f, -1.53108448e-01f, 1.24320492e-01f, 2.39951715e-01f, -2.62108296e-01f,
  -2.01530516e-01f, -4.67879660e-02f, 2.08602235e-01f, 3.11839998e-01f, 1.04032151e-01f, 2.98223764e-01f, 2.95795768e-01f, 1.37230549e-02f, 1.37245536e-01f, -2.90614963e-01f,
  7.52362758e-02f, -5.48668392e-02f, 8.08745250e-02f, -2.85589665e-01f, -2.23906457e-01f, 6.72978461e-02f, -2.97964543e-01f, -2.88187210e-02f, -6.21019490e-02f, -4.43820953e-01f,
  8.41227248e-02f, -2.62525052e-01f, 9.79942381e-02f, 1.02639217e-02f, 1.41559675e-01f, -3.87243062e-01f, -5.15639305e-01f, 1.27328917e-01f, 4.81858440e-02f, 2.95481235e-02f,
  -1.10011525e-01f, -2.23072112e-01f, 1.20771686e-02f, -3.68684351e-01f, -2.80582815e-01f, -8.80244747e-02f, 3.09381694e-01f, 1.43092528e-01f, -1.28761705e-04f, 1.59881383e-01f,
  -3.35880756e-01f, 2.80836672e-02f, 2.80303329e-01f, -4.82285246e-02f, 1.84309468e-01f, 4.68594804e-02f, -2.57858217e-01f, -1.64716229e-01f, -1.45673692e-01f, 3.02944658e-03f,
  4.57692668e-02f, -5.10746473e-03f, -1.92885414e-01f, -1.55448601e-01f, -9.69100446e-02f, -9.78923067e-02f, 3.90282348e-02f, -1.32496087e-02f, 1.09073959e-01f, -7.31144771e-02f,
  -1.90672372e-02f, 1.87496141e-01f, -1.68121040e-01f, -2.00114593e-01f, -7.76784718e-02f, -1.09176449e-01f, 6.60931244e-02f, 5.37915248e-03f, 2.18842551e-01f, -1.18441414e-02f,
  -9.71424673e-03f, -1.72301922e-02f, -2.82460570e-01f, 2.56493688e-01f, 2.20448792e-01f, -8.05672780e-02f, 1.23636238e-01f, 8.39444548e-02f, -2.79694289e-01f, 1.15799107e-01f,
  -2.99362808e-01f, -2.82860678e-02f, -1.08950138e-01f, -1.07925378e-01f, -7.07252622e-02f, -3.01759660e-01f, -5.22873290e-02f, -9.84762907e-02f, -9.50155184e-02f, -1.01456478e-01f,
  2.07040291e-02f, -1.46905720e-01f, -1.90280586e-01f, 2.13220239e-01f, 5.39994128e-02f, 6.32862970e-02f, 1.56364441e-01f, 1.80604607e-01f, 1.38325140e-01f, -2.56813437e-01f,
  -9.45174247e-02f, -6.56057894e-02f, 2.04857707e-01f, -5.31037748e-01f, 1.87508956e-01f, -1.67428944e-02f, -1.87362388e-01f, -1.73346952e-01f, -3.25113088e-01f, 4.41251658e-02f,
  1.93210900e-01f, 8.28066841e-02f, 4.27496471e-02f, 1.79606415e-02f, -1.19062411e-02f, -7.48760477e-02f, 1.50226429e-01f, 1.75363019e-01f, -9.71911103e-02f, -1.54028520e-01f,
  6.94631506e-03f, 4.63931635e-02f, 6.38164580e-02f, -8.61073062e-02f, -1.92678019e-01f, -7.05331266e-02f, -2.28396937e-01f, -2.40397915e-01f, 2.15669721e-01f, -9.48909372e-02f,
  5.01243360e-02f, -8.33690092e-02f, 2.08438426e-01f, -8.42551813e-02f, 2.36079991e-01f, 8.48666281e-02f, 2.26742148e-01f, -2.41948590e-01f, -2.80473530e-01f, -2.88937576e-02f,
  -3.33577335e-01f, 2.07412243e-01f, -1.61819696e-01f, -1.91403896e-01f, -2.61556774e-01f, -4.12751809e-02f, 1.77610919e-01f, 7.96306692e-03f, -1.12772658e-01f, 8.91412124e-02f,
  -7.71722496e-02f, -1.54309012e-02f, -7.59076178e-02f, -3.74303877e-01f, 1.05609866e-02f, 2.39400744e-01f, 2.23992184e-01f, -2.15525597e-01f, -2.19068125e-01f, -2.63866246e-01f,
  -2.81625599e-01f, 5.34212552e-02f, 2.58406460e-01f, 5.55014238e-03f, -1.87080294e-01f, 8.22263062e-02f, -3.03052515e-01f, 7.17252195e-02f, 4.16055560e-01f, 8.48242268e-02f,
  9.92037952e-02f, -3.56203675e-01f, 1.23335078e-01f, 5.63587248e-02f, -7.10542127e-02f, -3.00769001e-01f, -4.79851961e-02f, -5.86278737e-02f, 5.49162254e-02f, -9.43433866e-02f,
  3.29623222e-02f, -1.65839121e-01f, -1.94457799e-01f, -9.09916242e-04f, -1.81205243e-01f, 9.30756927e-02f, -8.20697770e-02f, -6.17486890e-03f, 9.78019834e-02f, -8.73372797e-03f,
  2.83577889e-02f, -1.61020815e-01f, -1.42580554e-01f, 1.23729318e-01f, 1.03318207e-01f, -1.04343839e-01f, -2.82585293e-01f, 3.13259810e-01f, 9.55713391e-02f, -2.22688630e-01f,
  -3.51967663e-01f, 2.02669755e-01f, 1.88760325e-01f, -7.66223893e-02f, -2.85023302e-01f, -2.19820842e-01f, -3.05247933e-01f, 1.81970373e-01f, 4.45277467e-02f, -1.23712353e-01f,
  -2.33830646e-01f, -1.89881772e-01f, -2.07865581e-01f, 3.08811702e-02f, -1.01969294e-01f, -1.41303554e-01f, 2.19945349e-02f, -1.28729045e-01f, -1.06127106e-01f, -1.81064755e-01f,
  -3.76577079e-01f, 1.50408084e-02f, 1.24676723e-03f, -3.94403487e-01f, 1.96885109e-01f, 1.15516603e-01f, -8.72998908e-02f, -4.65133190e-01f, 1.40870616e-01f, 2.03842118e-01f,
  -3.38083148e-01f, -2.49092415e-01f, 4.29358929e-02f, -5.63974567e-02f, 3.94611917e-02f, 1.32124424e-01f, 9.10602584e-02f, -2.39933329e-03f, 1.09799601e-01f, -2.60652602e-01f,
  1.60659462e-01f, 1.02745570e-01f, 2.51021702e-02f, 1.79941580e-01f, 1.39362603e-01f, 5.18420115e-02f, 2.52417475e-03f, 1.40051425e-01f, -1.34299714e-02f, 1.20225377e-01f,
  8.55814889e-02f, -9.28627551e-02f, -1.36884615e-01f, -2.34523386e-01f, -1.72796220e-01f, -1.89344063e-01f, -1.51926398e-01f, -2.45357320e-01f, -2.73487508e-01f, -1.98874310e-01f,
  -1.31419107e-01f, -1.12131052e-01f, -1.92147076e-01f, 2.76798874e-01f, -3.09304178e-01f, 9.70775858e-02f, -2.61032820e-01f, -3.02574597e-03f, 1.15187369e-01f, 2.13551372e-01f,
  2.78762668e-01f, 1.50967687e-01f, 2.04514891e-01f, 9.34510585e-03f, 1.40224233e-01f, -3.32938433e-01f, -3.16680193e-01f, 2.52530634e-01f, 9.87243578e-02f, -9.34168473e-02f,
  -2.77084738e-01f, 1.46618605e-01f, -6.62244782e-02f, 2.50062104e-02f, -2.59963393e-01f, 1.80342108e-01f, -2.84025371e-01f, -2.44221076e-01f, 4.87116873e-02f, 2.33250841e-01f,
  -1.14753649e-01f, -2.04358280e-01f, 2.54703499e-02f, 2.78440207e-01f, -4.12960380e-01f, -1.00331776e-01f, -3.22767913e-01f, -1.36411980e-01f, -3.47207040e-01f, -3.60080302e-01f,
  -3.70131552e-01f, 4.85897921e-02f, -2.40874663e-01f, -3.14547658e-01f, -2.50959471e-02f, 1.73839722e-02f, -1.11906879e-01f, -1.63316876e-01f, -4.43974324e-03f, -2.91193463e-03f,
  8.66590068e-03f, 1.11898147e-01f, 7.43238255e-03f, 6.54838011e-02f, 7.10280910e-02f, -4.40599285e-02f, 9.15720537e-02f, -1.60109311e-01f, -2.11257532e-01f, -6.77641258e-02f,
  -4.20892872e-02f, 1.28542036e-01f, -2.84192741e-01f, 2.27646574e-01f, 1.63025260e-01f, 2.11167276e-01f, -1.37940452e-01f, 3.06105673e-01f, 2.41512015e-01f, -3.05045903e-01f,
  -3.45097840e-01f, 7.27412403e-02f, 1.46880850e-01f, 1.06565051e-01f, -2.71616340e-01f, 2.35364400e-02f, -2.41639137e-01f, 6.38881652e-03f, 9.21164379e-02f, -4.30461198e-01f,
  4.34065908e-02f, -3.46473694e-01f, 1.01970904e-01f, -4.54807244e-02f, -1.37817845e-01f, 1.11322038e-01f, 2.50366867e-01f, 9.53280460e-03f, -2.08676785e-01f, 1.67358488e-01f,
  -3.00387889e-01f, -3.02394956e-01f, -2.38003004e-02f, 1.16184235e-01f, 2.15383545e-01f, 1.88844070e-01f, 1.02370277e-01f, -1.96085617e-01f, -3.41103464e-01f, -7.29027838e-02f,
  -3.57791424e-01f, 9.38546192e-03f, 3.22713591e-02f, -2.34886333e-02f, -1.10514099e-02f, 6.45108148e-02f, -2.58302867e-01f, 4.92301211e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -7.40341246e-02f, -1.32241063e-02f, 7.84375817e-02f, -1.20772347e-01f, -3.21231969e-02f, -1.11651763e-01f, -4.80598733e-02f, -1.13951847e-01f, -7.64919519e-02f, -7.36330524e-02f,
  4.98835333e-02f, 1.99357662e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    