/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.98355544e-01f, -1.59114897e-01f, -8.46083015e-02f, 3.80989075e-01f, 1.00455433e-01f, 1.26335949e-01f, -1.05946407e-01f, 5.81572242e-02f, 2.95662403e-01f, 5.39503694e-02f,
  1.31155655e-01f, -4.81537208e-02f, -9.39749256e-02f, -1.13489985e-01f, 3.95281762e-02f, -1.63931355e-01f, -2.43712038e-01f, -1.36661753e-01f, -6.70796260e-02f, -6.81972727e-02f,
  -2.17407554e-01f, 2.75236219e-02f, 7.10418150e-02f, -1.39996654e-03f, -4.83999215e-02f, -5.64154834e-02f, -7.41553381e-02f, 1.04854025e-01f, -1.93817675e-01f, -3.23873669e-01f,
  -2.59570777e-02f, 3.13109845e-01f, -3.01253032e-02f, -7.30294585e-02f, -8.57813805e-02f, 4.91148904e-02f, -2.74559278e-02f, 6.33839443e-02f, -1.77258626e-02f, 1.39029864e-02f,
  -2.38156505e-03f, -4.58628610e-02f, 4.98713963e-02f, -8.18789378e-02f, 5.98133653e-02f, 2.05186140e-02f, -2.72960006e-03f, 1.55052505e-02f, 4.32119109e-02f, 5.30010611e-02f,
  -2.41593346e-01f, 5.20363711e-02f, 1.28251314e-01f, -2.72009708e-02f, 5.55159263e-02f, -1.09419771e-01f, -3.51636373e-02f, 9.17829797e-02f, 1.67897865e-01f, 1.14629939e-01f,
  -3.53739299e-02f, 4.75565903e-03f, 2.39510485e-03f, 4.32145260e-02f, -5.03987931e-02f, 2.83347573e-02f, -8.23260285e-03f, -3.97407683e-03f, 2.54592206e-02f, 1.14179056e-04f,
  1.21065509e-02f, 1.32603319e-02f, -1.97110381e-02f, 6.56045526e-02f, -4.30870615e-02f, 1.39134331e-03f, -2.92949323e-02f, -4.86558750e-02f, -5.31973206e-02f, 1.42986961e-02f,
  -3.43702361e-02f, 4.45294604e-02f, 3.10492925e-02f, -6.52552396e-02f, -3.90358130e-03f, -5.47973849e-02f, -2.32912600e-02f, -4.30392660e-02f, 1.70699842e-02f, 1.24208105e-03f,
  2.71804303e-01f, -6.71798661e-02f, 3.46445143e-02f, 7.82049447e-02f, 8.28452855e-02f, -7.02948570e-02f, -4.18687016e-02f, -3.29353078e-03f, 4.47005406e-02f, -6.06870949e-02f,
  -4.15240489e-02f, -8.50842800e-03f, -2.59697642e-02f, -6.61291853e-02f, 3.48230861e-02f, 2.08512880e-02f, 5.80442585e-02f, 4.87741902e-02f, -2.28660367e-02f, -3.16535356e-03f,
  -1.31764531e-01f, 8.55297148e-02f, 1.79195717e-01f, -8.44996050e-03f, 6.25713542e-02f, 1.09126076e-01f, -3.58738191e-02f, 3.53831314e-02f, 5.22027500e-02f, 2.06403490e-02f,
  -3.48893434e-01f, 8.29138383e-02f, -1.87713578e-01f, 1.83226466e-01f, -1.81958869e-01f, -4.69073772e-01f, -2.59457737e-01f, -8.45391024e-03f, 1.31713629e-01f, -4.53572385e-02f,
  -6.85317069e-02f, 1.59212947e-01f, 1.82206258e-01f, 1.42299876e-01f, -1.33958548e-01f, -6.87726289e-02f, 9.83511731e-02f, -6.96409345e-02f, -2.34813318e-01f, -2.91265786e-01f,
  8.87334943e-02f, 1.76473632e-01f, 1.92309879e-02f, 1.81219559e-02f, 2.20261514e-01f, 1.51883945e-01f, 1.02503531e-01f, 6.06696717e-02f, -5.52564859e-02f, 2.77275681e-01f,
  -4.87819016e-02f, -3.26937214e-02f, -9.60132778e-02f, 3.66810970e-02f, 7.59007037e-02f, -4.21951972e-02f, -9.12249014e-02f, 3.75294685e-02f, -4.15460393e-02f, -7.53110126e-02f,
  -7.66382366e-02f, -2.47034784e-02f, -7.79639231e-03f, 1.58108681e-01f, -6.87453672e-02f, -6.92729428e-02f, 4.94206138e-02f, 3.71241681e-02f, -2.30098944e-02f, -6.83125705e-02f,
  7.67975375e-02f, -1.66712850e-01f, -2.32836887e-01f, -3.25711742e-02f, -6.19347952e-02f, -1.11632086e-01f, -6.40269816e-02f, 5.36232181e-02f, -1.40502498e-01f, 1.94145784e-01f,
  -7.40979686e-02f, -1.46284513e-02f, 6.92560431e-03f, 1.22971758e-02f, 1.29812704e-02f, 2.07858980e-02f, 9.89759155e-03f, 3.30222175e-02f, -1.32228062e-02f, 5.22944741e-02f,
  3.73944044e-02f, -9.92072374e-02f, 2.45436449e-02f, -2.28284467e-02f, 6.35619760e-02f, -2.41914205e-03f, -7.19237188e-03f, 1.96318273e-02f, -3.05102207e-02f, -4.76600826e-02f,
  1.05323754e-02f, -2.45777108e-02f, 6.69362247e-02f, 1.19228192e-01f, -2.38007866e-02f, 9.31370910e-03f, -5.42870909e-02f, -3.35588865e-02f, -2.24495083e-02f, -9.70278233e-02f,
  2.45309830e-01f, -2.86260188e-01f, 3.83736752e-02f, 3.61827165e-02f, -2.05448992e-03f, 9.96986106e-02f, 7.23471344e-02f, -6.52011931e-02f, -3.96166407e-02f, 2.43468117e-02f,
  -7.80022368e-02f, -6.80506676e-02f, 7.27903545e-02f, 7.14542940e-02f, -6.80999681e-02f, -2.71870028e-02f, 4.15360183e-02f, 7.64817297e-02f, -5.75885475e-02f, -4.07675579e-02f,
  8.42338800e-02f, -8.94673541e-02f, -1.13616072e-01f, -2.45425329e-02f, -1.83951724e-02f, -1.52116060e-01f, -5.79758063e-02f, -3.59644592e-02f, -1.76260561e-01f, -4.28624898e-02f,
  1.04016170e-01f, -1.21195883e-01f, -1.70525864e-01f, 7.52975643e-02f, -1.88377693e-01f, -8.02653432e-02f, 2.26139445e-02f, 2.58449018e-01f, 5.08802310e-02f, -1.07582115e-01f,
  -4.58465427e-01f, -1.96030587e-01f, -6.06085099e-02f, 1.01860248e-01f, 2.66025215e-01f, 2.16844529e-01f, 2.23507479e-01f, 3.51066440e-01f, 2.79677778e-01f, 1.17642500e-01f,
  7.84317851e-02f, 1.68944225e-01f, 2.60840744e-01f, 1.19159736e-01f, -5.86368926e-02f, -2.44573951e-02f, -9.20496583e-02f, -1.99882552e-01f, -2.13101804e-01f, -2.99198385e-02f,
  -4.13525969e-01f, -3.29460591e-01f, 1.33599684e-01f, 2.49440745e-02f, -1.63216054e-01f, 1.28020510e-01f, -4.39398624e-02f, 4.29354683e-02f, 2.76115653e-03f, 8.75296891e-02f,
  -1.83363155e-01f, -6.78612143e-02f, -2.03058757e-02f, -3.88787501e-02f, -2.28671869e-03f, 5.58491349e-02f, 7.55635574e-02f, 3.66525128e-02f, -7.88807869e-03f, -7.64682144e-02f,
  -1.51065260e-01f, -2.23812431e-01f, -1.96453303e-01f, 6.25583297e-03f, -6.25435635e-02f, -5.19085228e-02f, -4.35959585e-02f, -1.39226958e-01f, -9.00998786e-02f, 8.60753059e-02f,
  8.46120939e-02f, -1.93064939e-02f, -2.56873406e-02f, 4.39269915e-02f, -1.91178024e-02f, -7.33019933e-02f, -1.26061169e-02f, 3.20501998e-02f, 5.20010293e-02f, 3.95872407e-02f,
  2.76239240e-03f, -4.98463102e-02f, 4.25972305e-02f, 5.70041463e-02f, -3.73967662e-02f, -1.57989617e-02f, 1.37300761e-02f, 3.88069712e-02f, -6.40979186e-02f, -8.11491511e-04f,
  7.65547331e-04f, -3.81692722e-02f, -3.74878459e-02f, 2.88830940e-02f, -2.24644449e-02f, 3.68544683e-02f, -3.30788642e-02f, 1.71443615e-02f, 1.46653578e-02f, -7.76596144e-02f,
  1.24592915e-01f, -5.48100248e-02f, 3.11557017e-03f, 1.29330605e-02f, -2.53707357e-02f, 1.94275621e-02f, -1.06208444e-01f, 2.11019535e-02f, -8.11997801e-02f, 2.75337454e-02f,
  -2.48390343e-02f, 1.13502018e-01f, -1.51704932e-02f, 9.91924778e-02f, 1.10889889e-01f, 1.17161712e-02f, 5.21738529e-02f, -3.10508050e-02f, -2.69576702e-02f, -1.41100019e-01f,
  7.06217363e-02f, 1.30821377e-01f, 3.46598625e-02f, 3.10437065e-02f, -4.74570272e-03f, -1.01988362e-02f, 1.58873815e-02f, 2.64630560e-02f, 1.14530437e-01f, 3.28624636e-01f,
  3.03171307e-01f, 2.96059132e-01f, -7.80460089e-02f, -5.63946599e-03f, -1.87999189e-01f, 4.17716540e-02f, 9.44655761e-02f, 1.44810051e-01f, 6.42543882e-02f, 8.70585591e-02f,
  -3.20626467e-01f, -4.36143607e-01f, -3.85662884e-01f, -2.36295760e-01f, 4.47324440e-02f, 1.27364859e-01f, 3.27521972e-02f, -5.15946858e-02f, -1.26229391e-01f, 1.51910141e-01f,
  7.93753341e-02f, 1.45662129e-01f, 1.21647373e-01f, 1.00496359e-01f, 6.02502227e-02f, -1.84217811e-01f, 1.58624053e-02f, 9.11644697e-02f, 2.34369729e-02f, 1.10404938e-01f,
  -9.72185805e-02f, 1.99680805e-01f, -1.21291138e-01f, -1.32426485e-01f, -1.32777631e-01f, 7.12876767e-02f, 3.10527571e-02f, -8.52848869e-03f, -5.34359589e-02f, 3.63820195e-02f,
  -1.03621863e-01f, 6.34255027e-03f, -1.79617092e-01f, 1.53484941e-02f, -3.19201709e-03f, 1.89523716e-02f, 1.42703786e-01f, 1.03182852e-01f, 5.34733525e-03f, 1.72978844e-02f,
  -7.06357360e-02f, -1.19662425e-02f, -2.90320581e-03f, 2.80944593e-02f, 6.77128509e-02f, -1.29062295e-01f, -1.73108559e-02f, 8.67802277e-02f, 2.34637689e-02f, 2.92368621e-01f,
  1.37507906e-02f, -2.15281434e-02f, -1.65700056e-02f, -7.34427804e-03f, 2.82169413e-02f, -8.03564936e-02f, -4.12557647e-02f, -3.47621925e-02f, 5.15942983e-02f, 2.75222622e-02f,
  -3.67978849e-02f, 1.50872488e-02f, -4.62159514e-02f, 6.93043619e-02f, -2.04415433e-02f, 1.34973535e-02f, -3.58912311e-02f, 6.67957664e-02f, 1.65160187e-02f, 2.93507744e-02f,
  1.70815364e-02f, -5.14743589e-02f, 2.56188195e-02f, -9.16317757e-03f, 2.51026023e-02f, -1.30888633e-02f, 3.87984738e-02f, -3.27898338e-02f, 4.62156758e-02f, -3.52782942e-02f,
  -9.90504585e-03f, -3.69357526e-01f, 7.31863305e-02f, 1.13412872e-01f, 4.48035561e-02f, 2.46047415e-02f, -9.99708325e-02f, 5.45545109e-02f, -1.03329711e-01f, 4.71623503e-02f,
  -4.00960445e-02f, 4.76218611e-02f, -3.46547328e-02f, 6.19413629e-02f, 9.91069619e-03f, 3.44941393e-02f, 9.55833793e-02f, -1.12509623e-01f, -8.18644688e-02f, 5.07462136e-02f,
  1.00268252e-01f, 1.94996316e-02f, -4.30725627e-02f, -1.02582492e-01f, -9.92044583e-02f, -2.15871125e-01f, -7.37262964e-02f, -4.20815200e-02f, -1.69331089e-01f, 1.81268200e-01f,
  -7.28468373e-02f, 2.67376065e-01f, 5.65687001e-01f, -2.19055358e-03f, 1.05030909e-01f, 2.61350363e-01f, 4.02446866e-01f, 1.71773825e-02f, -1.38728723e-01f, 1.42671317e-01f,
  -2.18979672e-01f, -3.54650795e-01f, -1.84069455e-01f, -1.84871629e-01f, 3.73775400e-02f, 4.08757627e-01f, 4.19926733e-01f, 1.59905866e-01f, -9.42979008e-02f, -2.50027329e-01f,
  -1.29410028e-01f, -1.31493332e-02f, -8.42198059e-02f, -2.27849912e-02f, -6.70955852e-02f, -9.11115706e-02f, 1.81130052e-01f, 1.07233018e-01f, -1.94847900e-02f, 1.04744203e-01f,
  9.12350118e-02f, 3.64342220e-02f, -5.11019565e-02f, -1.48566544e-01f, 3.11495755e-02f, -3.27389240e-02f, 1.31911747e-02f, -1.85167287e-02f, -5.40830642e-02f, 7.23365694e-02f,
  -5.18954322e-02f, -9.00332406e-02f, 2.17368919e-02f, -3.91425826e-02f, 1.04020961e-01f, -2.46694852e-02f, 4.23143618e-02f, 6.30884916e-02f, 1.81424171e-02f, -8.71640444e-03f,
  -1.10617628e-04f, 1.63228795e-01f, 1.55189171e-01f, 1.27893433e-01f, 8.09225440e-03f, -6.01442009e-02f, 2.83433888e-02f, -9.36218649e-02f, -1.17869690e-01f, 8.57836679e-02f,
  -4.89378981e-02f, 5.59667721e-02f, 3.53541821e-02f, -2.58687064e-02f, -4.27177325e-02f, 7.21718147e-02f, 4.52773087e-02f, -4.79301857e-03f, -1.75217409e-02f, 3.20993885e-02f,
  -5.95915094e-02f, 3.73691656e-02f, 1.83465891e-03f, 1.90503057e-02f, -3.22474688e-02f, 7.59443864e-02f, 7.66043812e-02f, 2.90971100e-02f, -6.95486814e-02f, -2.00454630e-02f,
  -5.40591478e-02f, 3.41303945e-02f, 1.58786811e-02f, -9.73089878e-03f, -1.17449863e-02f, 1.50363445e-02f, 2.87128519e-02f, -5.71274385e-02f, -6.92291260e-02f, 5.80341890e-02f,
  -9.76638496e-02f, -4.90910374e-02f, 4.88519631e-02f, -8.67808685e-02f, 5.16722016e-02f, -7.35906959e-02f, -3.20772082e-02f, -5.12484051e-02f, -1.16172500e-01f, -4.49098125e-02f,
  -6.15514293e-02f, -5.11259120e-03f, 6.81108460e-02f, -8.68141744e-03f, -1.05428405e-01f, -5.68947531e-02f, 2.94031538e-02f, -2.79324930e-02f, -6.27199709e-02f, -2.80187018e-02f,
  -4.02945764e-02f, 1.66877329e-01f, 8.01473111e-02f, -1.21581592e-02f, 1.24594895e-03f, 1.03504187e-03f, 1.37117594e-01f, 3.49222533e-02f, 7.79663324e-02f, 2.06454754e-01f,
  -7.14433551e-01f, -4.04747963e-01f, 2.19134316e-01f, -3.34829003e-01f, 8.48809555e-02f, 3.17706853e-01f, 1.42567158e-01f, 8.95869210e-02f, -3.64535078e-02f, -1.22040689e-01f,
  -2.66487569e-01f, -2.37483859e-01f, -1.31049097e-01f, -3.59328017e-02f, 3.53611596e-02f, -6.96681580e-03f, 1.73836872e-01f, 1.95435911e-01f, 1.36610702e-01f, 1.10136941e-01f,
  -1.43755391e-01f, -1.62187979e-01f, -1.74436107e-01f, -1.81636997e-02f, 4.08404283e-02f, 4.12133783e-02f, -2.98069064e-02f, -9.16747097e-03f, 9.30517316e-02f, -1.21360473e-01f,
  -1.61773980e-01f, -1.03238814e-01f, 1.65956736e-01f, -1.53607115e-01f, 1.15119678e-03f, 6.47030072e-03f, -5.65769076e-02f, 2.83925086e-02f, -7.02303499e-02f, -1.04369096e-01f,
  -1.52433395e-01f, -6.48721308e-02f, -3.35233174e-02f, 2.66921194e-03f, -2.46260967e-02f, -3.04071978e-02f, 3.95032912e-02f, -1.45440135e-04f, 9.93287712e-02f, 5.71158119e-02f,
  -1.16702728e-01f, -9.60212871e-02f, -4.59426232e-02f, 1.06905535e-01f, 1.67586312e-01f, 4.89828289e-02f, -2.59257182e-02f, -1.15052760e-02f, 1.63074583e-01f, -1.87131897e-01f,
  -7.68006071e-02f, 2.18437146e-02f, 7.00310469e-02f, -1.27340769e-02f, -9.35680270e-02f, -3.92134709e-04f, 7.30642676e-02f, -7.21057355e-02f, 3.18839513e-02f, -3.37259215e-03f,
  4.55945916e-02f, 1.73089504e-02f, -7.95106143e-02f, 1.43961096e-02f, -2.81695044e-03f, 4.85003963e-02f, 4.31259871e-02f, 3.46565023e-02f, 3.75642069e-03f, 6.76369369e-02f,
  -1.97780691e-02f, 6.66754544e-02f, 1.61490496e-02f, 2.67069470e-02f, 4.23345156e-02f, 6.86218068e-02f, -6.22791983e-03f, -2.21212488e-02f, -4.97433804e-02f, -1.27494317e-02f,
  -3.13323259e-01f, 2.09443256e-01f, -2.25443840e-01f, -3.10528949e-02f, 2.66331863e-02f, 6.46233112e-02f, -1.64604113e-02f, 2.88718380e-02f, -4.28176820e-02f, 1.97628941e-02f,
  4.48311195e-02f, -4.69252840e-02f, -9.38996226e-02f, 1.00141257e-01f, 3.53162996e-02f, -3.13709006e-02f, -1.00710243e-01f, -2.30670832e-02f, 1.83572937e-02f, 9.61939804e-03f,
  -1.19184613e-01f, -5.43242581e-02f, -1.32822245e-01f, -5.36653586e-02f, -7.49734715e-02f, -1.25504017e-01f, -7.34127760e-02f, -5.06529845e-02f, 1.02949450e-02f, -3.17398518e-01f,
  2.99132943e-01f, -4.38753903e-01f, -3.02979350e-01f, 1.27521921e-02f, -1.46811396e-01f, -2.13354230e-01f, -5.21258414e-01f, 6.59274980e-02f, 2.55787104e-01f, -3.09464753e-01f,
  -1.38914108e-01f, 2.16069907e-01f, 1.11838616e-01f, 1.41992003e-01f, 5.81847169e-02f, -3.61492187e-01f, -1.60863847e-01f, 6.70240028e-03f, 9.73792225e-02f, -1.35918200e-01f,
  -1.09749772e-01f, 2.78054010e-02f, 2.32161731e-01f, 2.02026963e-01f, -1.55615479e-01f, 7.97171593e-02f, 5.05532846e-02f, 5.27221337e-02f, -2.37380981e-01f, -3.47494692e-01f,
  -4.58979577e-01f, -1.94833785e-01f, 8.14912990e-02f, 2.47537792e-02f, -5.03538698e-02f, 1.05460912e-01f, -1.73418503e-03f, 1.33725807e-01f, 3.88825610e-02f, 5.49001992e-02f,
  -1.39423236e-02f, 1.22415097e-02f, 5.41889369e-02f, -2.45118067e-02f, -6.15570135e-02f, -1.24254320e-02f, 5.66246472e-02f, 5.71595877e-03f, -3.90263386e-02f, -1.16427712e-01f,
  -2.01386020e-01f, -1.51619405e-01f, -4.05897796e-02f, 4.57810611e-03f, 2.43086112e-03f, 7.93838203e-02f, 2.35257111e-03f, -6.85850531e-02f, 9.78289545e-02f, 6.54485375e-02f,
  -2.18777042e-02f, 6.34282902e-02f, -1.86442100e-02f, 3.67866340e-03f, 2.59474907e-02f, 2.48887446e-02f, 3.31179351e-02f, -7.26223961e-02f, 1.49209527e-02f, 3.23809162e-02f,
  1.27073182e-02f, -1.16330549e-01f, -9.58075654e-03f, -1.56545397e-02f, -4.58237715e-02f, -4.59681125e-03f, -1.01176575e-02f, -6.99186176e-02f, 3.22690010e-02f, 4.12584320e-02f,
  -4.16052826e-02f, 8.11325014e-02f, 2.30792351e-02f, -1.33128203e-02f, -5.53473569e-02f, -6.86628222e-02f, 1.12876156e-02f, 3.69747542e-02f, 5.74395359e-02f, 6.49315566e-02f,
  3.34689289e-01f, 1.49785623e-01f, -5.51424511e-02f, 6.79914579e-02f, -3.33635062e-02f, -8.64056405e-03f, -4.81512323e-02f, -1.72358118e-02f, 4.37276345e-03f, -5.28787449e-02f,
  1.53753990e-02f, 2.69821361e-02f, 3.52925068e-04f, 2.98971105e-02f, 2.90589612e-02f, -8.07512365e-03f, -6.51407689e-02f, -2.10318025e-02f, 9.13858041e-03f, -7.01415837e-02f,
  -1.87970158e-02f, 5.11671007e-02f, 1.41461432e-01f, 2.70406939e-02f, 1.84129309e-02f, 8.71572196e-02f, -7.44701102e-02f, 1.59934796e-02f, 1.33861750e-01f, 1.30932564e-02f,
  2.39204094e-01f, -5.30595124e-01f, -1.54896826e-01f, 7.16896504e-02f, 2.00460672e-01f, 7.68273324e-02f, -1.07879125e-01f, -1.80991553e-02f, -6.68104589e-02f, -2.23358348e-01f,
  -2.35040318e-02f, 2.02008247e-01f, 4.93882857e-02f, 1.22214973e-01f, 8.04211721e-02f, -2.02246368e-01f, 6.17153645e-02f, 1.67120248e-01f, 4.46489155e-01f, 2.96022773e-01f,
  6.63061440e-02f, -3.09994128e-02f, 6.06929511e-03f, 4.02470082e-02f, -1.74396038e-01f, 5.23340255e-02f, -3.60122949e-01f, -1.16357878e-01f, -7.71497190e-02f, -1.34748165e-02f,
  -1.08847655e-01f, -3.30414250e-02f, 2.43589506e-01f, 8.16824734e-02f, -6.99686557e-02f, -1.32740382e-02f, 9.38943624e-02f, -2.45675109e-02f, 1.65072903e-02f, -1.25245646e-01f,
  4.19514850e-02f, 2.71002781e-02f, 1.31391987e-01f, -1.42428085e-01f, -8.94252211e-02f, 4.99076024e-02f, -1.06643930e-01f, 5.13277166e-02f, -7.24294484e-02f, -1.00134887e-01f,
  3.73644866e-02f, 1.67354196e-01f, 9.81654674e-02f, -1.68736484e-02f, 9.36064944e-02f, 1.98336452e-01f, -8.26561153e-02f, 6.40779734e-02f, -1.76410936e-02f, -1.46088764e-01f,
  1.26108918e-02f, -3.86411585e-02f, 8.92899111e-02f, -9.40586999e-03f, 1.67203285e-02f, -4.26120348e-02f, -1.32256430e-02f, -5.80975413e-02f, -1.65521316e-02f, -6.08260706e-02f,
  7.56890625e-02f, -2.95182727e-02f, -2.18990594e-02f, -2.10499819e-02f, -2.19591483e-02f, 2.67273970e-02f, 5.81290983e-02f, -1.91335678e-02f, -6.79736864e-03f, -5.40102720e-02f,
  2.62915771e-02f, -9.44099110e-03f, -6.05816543e-02f, -2.51093861e-02f, 5.57833798e-02f, 5.74379452e-02f, 1.40065681e-02f, 5.42124175e-02f, -2.40353346e-02f, -2.23792847e-02f,
  -2.12613374e-01f, 2.91471124e-01f, -6.61269501e-02f, 6.53640032e-02f, -6.06877841e-02f, -4.68435027e-02f, -5.51736318e-02f, 3.81144136e-02f, -2.27090493e-02f, 2.01830696e-02f,
  2.55049858e-03f, 1.52412858e-02f, -1.43404081e-01f, 1.84851605e-03f, 3.61579359e-02f, 1.33721875e-02f, -6.12324178e-02f, 7.24782348e-02f, 1.19711543e-02f, -1.15717120e-01f,
  -1.38179392e-01f, 9.30645689e-03f, 4.02871296e-02f, -2.62547061e-02f, 8.03677179e-03f, 2.50443190e-01f, -9.95721072e-02f, 2.01777965e-02f, 1.13698237e-01f, -3.23323488e-01f,
  1.53585717e-01f, 1.08088560e-01f, 2.95074344e-01f, 4.49246988e-02f, -9.01182815e-02f, -3.42633158e-01f, -2.45206162e-01f, -2.36428946e-01f, -8.56698155e-02f, 2.81059127e-02f,
  7.17738569e-02f, -4.27251682e-02f, 7.94754326e-02f, 5.30212335e-02f, -1.44978464e-01f, 2.63393987e-02f, 3.62340100e-02f, 1.20692581e-01f, -8.13555643e-02f, -1.01034313e-01f,
  -4.12704237e-02f, 1.09630391e-01f, 1.30574271e-01f, 2.87892688e-02f, 1.41674474e-01f, 1.49630263e-01f, 1.09815262e-01f, 2.16315523e-01f, 2.24031862e-02f, 2.09609106e-01f,
  6.73069417e-01f, 2.25158259e-01f, -1.03320457e-01f, -4.08696197e-02f, 5.57829179e-02f, -1.52346995e-02f, 5.46143577e-02f, 1.05611511e-01f, -5.95509894e-02f, 9.94872823e-02f,
  4.85301614e-02f, -6.73619239e-03f, 5.44030108e-02f, 3.41409072e-03f, 3.14547308e-02f, 3.46080288e-02f, -3.41383507e-03f, 9.15699974e-02f, -4.20776606e-02f, 8.31165463e-02f,
  -1.27339959e-01f, -2.12396942e-02f, 9.23899189e-02f, -1.24628447e-01f, -6.08160682e-02f, -1.82821050e-01f, -5.76090347e-03f, 1.23141773e-01f, -2.03797184e-02f, 2.41230786e-01f,
  -6.38540462e-02f, 1.73104703e-02f, 2.15214640e-02f, -1.88579096e-03f, -7.06868013e-03f, -8.68703984e-03f, 7.44144842e-02f, 3.27684805e-02f, 3.56663810e-03f, 7.52702802e-02f,
  -1.84661604e-03f, -8.22025016e-02f, 1.75189953e-02f, 3.65509652e-02f, 6.16302639e-02f, 2.79972460e-02f, -7.41885463e-03f, -6.33557439e-02f, 3.57570983e-02f, -4.07985179e-03f,
  2.46649906e-02f, 3.30634043e-02f, 1.63231860e-03f, 1.21810555e-01f, -5.50226644e-02f, 1.81025006e-02f, -2.90429741e-02f, 2.16728635e-02f, -1.08362921e-02f, -5.56137413e-02f,
  1.05978347e-01f, -3.28087658e-01f, 1.23855062e-01f, 5.50330915e-02f, -2.80972105e-02f, -1.03750993e-02f, 3.50922607e-02f, 3.59710827e-02f, 6.45713694e-03f, -2.38833055e-02f,
  1.96252000e-02f, 1.36009939e-02f, 2.28989664e-02f, 2.65287757e-02f, 1.17619973e-04f, -2.28879526e-02f, -1.03808373e-01f, 1.96895953e-02f, -3.70613560e-02f, -3.50007229e-02f,
  -4.70734350e-02f, -1.10364608e-01f, -1.94830596e-02f, 2.45771911e-02f, 2.16340888e-02f, -7.57815689e-02f, 1.45772755e-01f, -2.62160674e-02f, -8.11366364e-02f, -5.84418699e-02f,
  3.93590033e-01f, -5.30385673e-01f, 4.73414004e-01f, 4.24299948e-02f, -8.84422660e-02f, -6.68168440e-02f, -4.27109927e-01f, -3.07617098e-01f, -6.19927905e-02f, -6.79664314e-02f,
  -2.93759078e-01f, -6.32580221e-02f, 8.43583196e-02f, 5.87358549e-02f, -3.76624204e-02f, 6.36445684e-03f, 2.87683666e-01f, 4.82822329e-01f, 4.06614631e-01f, -8.30736980e-02f,
  -1.74754396e-01f, -7.67694879e-03f, 2.34920800e-01f, 1.17540918e-01f, -1.18067406e-01f, 6.15329109e-02f, 8.54073763e-02f, 1.25625478e-02f, 1.17058177e-02f, 1.83424816e-01f,
  3.74005705e-01f, -3.16692740e-01f, 1.07071131e-01f, -8.84579793e-02f, -3.41233276e-02f, 1.10168532e-01f, 5.91582470e-02f, 5.33113852e-02f, 1.29379034e-02f, 1.95733756e-02f,
  -2.14830339e-02f, -2.99784336e-02f, -1.16712064e-01f, -3.96306179e-02f, -9.89297852e-02f, 7.74636399e-03f, -3.94083448e-02f, 6.79906160e-02f, 1.09306023e-01f, 7.73899863e-03f,
  -1.86992928e-01f, -5.61475903e-02f, 3.67601477e-02f, -1.03567541e-01f, -1.12715043e-01f, 8.71812180e-02f, -1.72916859e-01f, -8.09277445e-02f, 5.28593399e-02f, 1.31857082e-01f,
  3.28202546e-02f, 5.51218092e-02f, -2.38168705e-02f, -2.91906986e-02f, -2.48258468e-03f, 1.00990711e-02f, 9.16810147e-03f, -1.07561648e-02f, -1.76271405e-02f, -8.97656102e-03f,
  2.86560152e-02f, -1.16542773e-02f, 3.54156233e-02f, 4.33859900e-02f, 1.18724210e-02f, 6.05462715e-02f, -1.27512729e-03f, -1.14503494e-02f, -3.28236297e-02f, 3.51730809e-02f,
  2.97241714e-02f, -1.21039050e-02f, -6.04284788e-03f, -1.26945064e-03f, -2.62083858e-02f, -3.67698930e-02f, 6.05426356e-02f, -9.21222791e-02f, -2.06071679e-02f, 1.42592173e-02f,
  2.82457601e-02f, 3.34347188e-02f, 1.14853188e-01f, -2.48313062e-02f, 1.15538031e-01f, -5.58107644e-02f, -2.92080399e-02f, -3.67712379e-02f, 2.34269463e-02f, 2.04873402e-02f,
  -1.12914070e-01f, -4.43294784e-03f, 4.77854861e-03f, 1.20515190e-02f, 1.03961028e-01f, -3.23105268e-02f, -1.37322843e-01f, 1.52421042e-01f, -3.83163132e-02f, -1.67589150e-02f,
  -1.18399628e-01f, 6.14879094e-02f, 1.81099370e-01f, 6.20743409e-02f, -9.44365114e-02f, 1.72449991e-01f, 6.82507232e-02f, -2.94773304e-03f, 1.38031542e-01f, 8.74548331e-02f,
  3.07691783e-01f, -4.72355187e-01f, -1.66078657e-01f, 4.91462164e-02f, -1.93292499e-01f, 6.08129613e-02f, -6.26830533e-02f, 8.90254751e-02f, 4.72864918e-02f, -1.36982441e-01f,
  -2.79651970e-01f, 2.08282411e-01f, 6.96958154e-02f, 1.30449638e-01f, 1.40842468e-01f, -1.67958409e-01f, -3.66550349e-02f, 2.26252556e-01f, 4.37770605e-01f, 2.59302050e-01f,
  1.71786100e-01f, 1.49537608e-01f, 1.23204425e-01f, 8.82487595e-02f, -1.54915780e-01f, -1.39608039e-02f, -2.69283414e-01f, -1.53574437e-01f, -1.61726862e-01f, -2.08223149e-01f,
  -8.51417109e-02f, -2.78740227e-01f, 2.05165938e-01f, -2.81734783e-02f, -1.25132576e-01f, 2.19806749e-02f, -1.52090676e-02f, -6.78551272e-02f, -7.61608407e-02f, -2.17237622e-02f,
  -5.07879369e-02f, 3.02035846e-02f, -4.14201384e-03f, 7.44052604e-02f, 1.40356170e-02f, 9.29344520e-02f, 3.89809683e-02f, 8.17028284e-02f, 1.28556207e-01f, -4.31368053e-02f,
  -9.30104405e-02f, -8.09816420e-02f, 1.02180764e-01f, 6.59243623e-03f, 3.72739532e-03f, 2.11183969e-02f, -1.23547249e-01f, -1.83917768e-02f, 3.24823968e-02f, -5.37116863e-02f,
  5.69365211e-02f, -1.68211777e-02f, -1.36643099e-02f, -3.13340388e-02f, -1.52442632e-02f, 1.60147306e-02f, -3.57663222e-02f, 4.18134555e-02f, 3.31797861e-02f, 1.49715319e-02f,
  -3.45190726e-02f, -8.58159289e-02f, 3.25810388e-02f, -5.10196723e-02f, 2.90472806e-02f, -1.89800952e-02f, 9.44059435e-03f, 2.77739391e-02f, -7.72317592e-03f, -4.61006127e-02f,
  1.40790604e-02f, 1.32329119e-02f, 2.66048638e-03f, 5.44575639e-02f, -4.61519212e-02f, -5.41563444e-02f, 4.33171317e-02f, -5.52026778e-02f, 7.80203268e-02f, -3.99519019e-02f,
  2.41546795e-01f, -5.96197397e-02f, 1.88642778e-02f, 1.62712142e-01f, -4.51138578e-02f, -4.01086127e-03f, -5.03821708e-02f, -1.60222705e-02f, -1.11498132e-01f, 3.89383547e-02f,
  1.37303332e-02f, 3.39750648e-02f, -9.71036106e-02f, -2.64226925e-02f, 2.00509112e-02f, 5.35011142e-02f, -2.20977664e-02f, 5.31156175e-02f, 1.01338081e-01f, 1.02552893e-02f,
  -2.84061171e-02f, 2.90180981e-01f, 2.68529117e-01f, 1.79248035e-01f, 4.45770426e-03f, 2.49887124e-01f, 9.47214738e-02f, 3.44394036e-02f, 2.24064186e-01f, 1.79789752e-01f,
  1.62103266e-01f, 1.76252984e-02f, -3.06130759e-02f, -1.54996753e-01f, 3.30988802e-02f, -3.22821327e-02f, 6.43475652e-02f, 7.57083669e-02f, 2.37176176e-02f, 2.83527970e-02f,
  1.38500646e-01f, 1.10066561e-02f, -6.69915602e-02f, -1.45492062e-01f, -1.52857348e-01f, -2.09262833e-01f, -2.19297454e-01f, -2.12246805e-01f, -8.21557865e-02f, -6.43926486e-02f,
  -9.30767432e-02f, -8.24142620e-02f, -8.66650566e-02f, -1.86523691e-01f, -2.04216018e-01f, -6.45214468e-02f, -9.47878808e-02f, -7.06102028e-02f, -1.03585161e-01f, -3.36242110e-01f,
  8.01667199e-02f, -6.08201772e-02f, 4.35861461e-02f, 6.65098354e-02f, 4.12051789e-02f, 3.15601602e-02f, 4.74521331e-02f, 2.92257071e-02f, 5.96263856e-02f, 7.21120369e-03f,
  -5.83424978e-02f, 3.50490701e-03f, 3.34387347e-02f, -3.81353498e-02f, 1.96740627e-02f, 1.75339878e-02f, 9.96255968e-03f, -8.91062096e-02f, 4.19248939e-02f, -7.03908578e-02f,
  -5.27134463e-02f, -2.54636984e-02f, 2.16112323e-02f, -1.03043457e-02f, -5.73852621e-02f, -6.07672706e-02f, -4.02461030e-02f, 4.40349467e-02f, 3.66637297e-02f, 1.46763310e-01f,
  4.55837417e-03f, -3.64119560e-02f, 1.59455575e-02f, 4.16831411e-02f, -2.03049779e-02f, 2.42722686e-02f, -1.02784559e-01f, 4.49276119e-02f, 1.77040359e-03f, 1.92389218e-03f,
  8.08387250e-02f, -6.11515120e-02f, -4.41672504e-02f, -6.62585571e-02f, -1.04741052e-01f, -2.56053153e-02f, -9.00915824e-03f, -7.04696476e-02f, -1.00251585e-01f, -2.98308972e-02f,
  1.11664571e-01f, 9.52538475e-03f, -5.25829345e-02f, 1.95924304e-02f, -4.33720946e-02f, 2.69931294e-02f, -8.40492621e-02f, 4.15111817e-02f, 1.62429679e-02f, -6.23442754e-02f,
  3.37155372e-01f, 7.23227635e-02f, -9.10266116e-02f, 7.14731868e-03f, 1.87070258e-02f, 5.91434352e-02f, 3.38599496e-02f, 6.17590956e-02f, -6.69795200e-02f, 3.90181281e-02f,
  1.17944926e-01f, -5.11312075e-02f, -4.95110452e-02f, 2.68851668e-02f, 7.51579851e-02f, 6.99840710e-02f, -4.15979102e-02f, 5.83785912e-03f, -8.11041221e-02f, 6.25868961e-02f,
  9.75610241e-02f, 8.93303230e-02f, 1.12117611e-01f, 1.75454706e-01f, 1.04071058e-01f, 6.60967678e-02f, 6.07123189e-02f, 1.25444114e-01f, 1.11952387e-01f, 2.60434568e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.08390936e-01f, 8.82534534e-02f, -3.92267823e-01f, 1.65973846e-02f, -1.76177844e-01f, -1.66799590e-01f, -4.17582355e-02f, -9.92432609e-02f, 1.03986384e-02f, -6.90181777e-02f,
  -6.43812492e-02f, 1.36721963e-02f, 4.47365344e-02f, 1.91368181e-02f, -1.08369719e-02f, -6.51230058e-03f, -9.22880620e-02f, -1.30060226e-01f, -2.16698349e-01f, -3.34874727e-02f,
  6.62923232e-02f, 5.33171780e-02f, 4.26157154e-02f, -1.25584733e-02f, -5.01055978e-02f, -5.32964841e-02f, -3.72886918e-02f, -7.48593137e-02f, -1.16384134e-01f, -6.52696937e-02f,
  -2.18868703e-01f, -1.98007897e-01f, -3.27172652e-02f, 8.95888433e-02f, -8.77341852e-02f, -1.71275865e-02f, 3.86516489e-02f, 2.74421424e-02f, 2.27054060e-02f, 3.07683498e-02f,
  -3.68492454e-02f, 6.94011897e-02f, -3.26896906e-02f, -4.10325751e-02f, 6.97783567e-03f, -5.74215837e-02f, 6.67474195e-02f, -1.37734711e-01f, 5.52533986e-03f, -1.17221922e-01f,
  8.63500834e-02f, -7.04661235e-02f, -6.07326925e-02f, -2.73823068e-02f, -1.80951357e-01f, -9.93961617e-02f, -4.78609428e-02f, -5.80499917e-02f, -4.44794772e-03f, -2.60464158e-02f,
  -4.02037762e-02f, 1.54401949e-02f, 1.88886723e-03f, 4.86282334e-02f, -4.32011448e-02f, 8.02228153e-02f, -6.22185431e-02f, 7.27219731e-02f, 6.54322328e-03f, 6.99131414e-02f,
  -1.94691941e-02f, -7.95669928e-02f, 8.32707342e-03f, 6.48738742e-02f, -1.43161369e-02f, 3.10125258e-02f, 7.42855817e-02f, -2.19204631e-02f, 5.50237820e-02f, 1.40918866e-02f,
  3.82440165e-02f, -8.57259184e-02f, -5.60837090e-02f, -6.87668175e-02f, -4.67668734e-02f, -9.21627413e-03f, 3.62175666e-02f, 2.27148086e-02f, 8.08156729e-02f, 8.08374882e-02f,
  5.28233536e-02f, -7.19636381e-02f, 8.32992885e-03f, 1.06733970e-01f, -4.90884185e-02f, -3.89780104e-02f, -4.83443774e-02f, 3.30819562e-02f, -6.10375479e-02f, -9.35337171e-02f,
  -1.13965452e-01f, -8.22751373e-02f, 6.84581921e-02f, -8.45283121e-02f, 2.33352929e-02f, -7.56961033e-02f, 6.49747401e-02f, -4.89833131e-02f, -1.63886268e-02f, 2.93093808e-02f,
  1.44359291e-01f, 2.14523524e-02f, 1.56532571e-01f, 3.90856387e-03f, -1.34480326e-03f, 1.14292167e-01f, -6.41180202e-02f, -1.18663937e-01f, 6.36721402e-02f, 1.66457415e-01f,
  1.25059988e-02f, 1.07114039e-01f, -1.64947018e-01f, 2.83431351e-01f, 4.02353942e-01f, 1.43332422e-01f, -1.26483753e-01f, -2.04895973e-01f, 6.16263300e-02f, 1.77688509e-01f,
  2.89645642e-01f, 1.20145060e-01f, -5.45174479e-02f, -1.00258395e-01f, -3.42181951e-01f, -2.39687666e-01f, -1.75227821e-01f, -3.06082696e-01f, -2.49449790e-01f, -8.65192339e-03f,
  1.62267745e-01f, 9.49378833e-02f, -1.30780175e-01f, -2.16393713e-02f, 1.14436582e-01f, 8.98418427e-02f, 1.01303451e-01f, 1.25451475e-01f, -2.64401492e-02f, 9.28555876e-02f,
  5.53287379e-02f, -1.13222441e-02f, -9.50134471e-02f, 1.25555649e-01f, 1.26378655e-01f, -1.02602296e-01f, -7.71432072e-02f, -1.30674511e-01f, 2.54730624e-03f, -1.71678998e-02f,
  1.85579702e-01f, 9.20247138e-02f, -9.03720222e-03f, 3.05431765e-02f, 1.49473350e-03f, -1.41296178e-01f, -1.53322861e-01f, -2.81612158e-01f, -1.97419345e-01f, 1.79157928e-02f,
  9.81696472e-02f, 2.24441573e-01f, -9.63846445e-02f, -1.57246575e-01f, -1.85175240e-01f, 5.28094806e-02f, -5.77237606e-02f, -5.07562421e-02f, -2.81454146e-01f, -1.85256690e-01f,
  -9.40610189e-04f, 5.22091016e-02f, 1.66971758e-02f, 3.16762626e-02f, -4.84491847e-02f, -1.10584339e-02f, 2.29897890e-02f, 1.11768670e-01f, 4.18116571e-03f, -2.33501140e-02f,
  -1.03865847e-01f, 1.13902204e-02f, -4.45674211e-02f, -9.28451028e-03f, 2.47017667e-02f, 5.08230627e-02f, 1.22030906e-03f, -2.44926699e-02f, -6.37527108e-02f, 2.52673496e-02f,
  -4.22652960e-02f, 1.07635325e-02f, -4.88696015e-03f, -3.35419811e-02f, -6.52019382e-02f, -8.37731883e-02f, -3.14229876e-02f, 5.97165264e-02f, -1.41770719e-02f, 4.50397795e-03f,
  2.24504247e-02f, -1.84512481e-01f, -2.61437520e-02f, -1.37278989e-01f, 5.01624383e-02f, -5.44566922e-02f, 1.98313490e-01f, -4.95287217e-02f, 9.09326747e-02f, -9.80229899e-02f,
  2.63209231e-02f, -6.36198744e-02f, -2.00104304e-02f, 3.71159613e-03f, -3.72435004e-02f, 1.35039613e-02f, 8.03846121e-02f, -9.71768871e-02f, -1.54751584e-01f, 7.42354151e-03f,
  -1.83146447e-02f, -1.35046139e-01f, -1.43598452e-01f, -1.83338180e-01f, -1.16741948e-01f, -5.13532385e-02f, -1.05674349e-01f, -9.58957970e-02f, -3.01873952e-01f, -2.25248680e-01f,
  -5.37037253e-01f, -3.81029814e-01f, -4.21968669e-01f, -3.00281614e-01f, -2.58615345e-01f, -1.40777454e-02f, -1.22342400e-01f, -8.74467343e-02f, -1.44440413e-01f, -1.67541787e-01f,
  -1.67400584e-01f, -1.40857592e-01f, -1.20052248e-01f, -8.22566226e-02f, -2.65383899e-01f, -2.30039567e-01f, -4.17582840e-01f, -3.66500378e-01f, -3.12690079e-01f, -1.42618850e-01f,
  -2.01202586e-01f, -4.85142082e-01f, -3.74699920e-01f, -1.80304095e-01f, -2.75600493e-01f, -2.79811442e-01f, -2.84606278e-01f, -3.86327624e-01f, -1.57779291e-01f, -4.76640850e-01f,
  -1.06922805e-01f, 3.68297137e-02f, 5.86208776e-02f, -1.13496654e-01f, -4.21387255e-02f, 6.33154809e-02f, -5.49986027e-02f, 6.27200976e-02f, -7.34368265e-02f, 8.45190044e-03f,
  -2.24007596e-03f, -2.52380352e-02f, -1.22603163e-01f, 2.52395496e-02f, -1.43938631e-01f, -4.63716835e-02f, -1.17749020e-01f, -8.24736953e-02f, 8.55159014e-03f, 1.19319253e-01f,
  1.10889887e-02f, -2.00263754e-01f, -7.03771934e-02f, 3.71983573e-02f, -9.33305174e-03f, -1.02293357e-01f, 5.20650297e-02f, 1.17250688e-01f, -8.90167207e-02f, -9.31202695e-02f,
  -2.38144808e-02f, -1.73066985e-02f, 7.89686814e-02f, -4.33598720e-02f, 3.94864270e-04f, 6.07284270e-02f, 2.24332865e-02f, -2.09264867e-02f, 4.60004136e-02f, -1.26479551e-01f,
  -1.99688412e-03f, 7.77349919e-02f, 6.59909844e-03f, -8.49719048e-02f, -4.28694952e-03f, -1.49577977e-02f, -1.09428754e-02f, -7.37116560e-02f, 6.48565739e-02f, -4.61068712e-02f,
  -5.50960451e-02f, -3.56141813e-02f, 2.01586112e-02f, 8.91477838e-02f, -4.54397611e-02f, -1.60816032e-02f, -1.25604374e-02f, 1.24115914e-01f, 5.53122312e-02f, 5.69884442e-02f,
  -1.29103228e-01f, 1.21430010e-02f, 8.07203352e-02f, 2.69808657e-02f, -7.70339742e-02f, -7.97126666e-02f, -1.00461468e-01f, -8.07735324e-02f, 1.02535542e-02f, -6.41460344e-02f,
  1.19986221e-01f, -4.87529486e-02f, -3.54372934e-02f, 5.53488657e-02f, -9.46832225e-02f, 8.48389193e-02f, -1.23503305e-01f, -1.35579288e-01f, 3.17202955e-02f, 4.49897274e-02f,
  -1.31662190e-01f, -2.86362655e-02f, -1.17810778e-01f, -4.48274016e-02f, 3.71727953e-03f, -1.70325004e-02f, -2.61654379e-03f, 4.32322435e-02f, -8.55311900e-02f, -2.28751495e-01f,
  -7.46624351e-01f, 6.03766963e-02f, 2.39592716e-01f, -3.70529294e-01f, -2.03661010e-01f, 1.25389904e-01f, 2.05631405e-01f, -7.80415460e-02f, -2.57285058e-01f, -2.03332640e-02f,
  8.63272697e-02f, 1.67765785e-02f, 6.04445487e-02f, 1.20570108e-01f, 8.01211745e-02f, 1.00581631e-01f, -6.55251294e-02f, 4.97346818e-02f, 1.10258982e-02f, 4.71406132e-02f,
  -1.48098201e-01f, -2.75235802e-01f, -3.48823071e-01f, -1.32849231e-01f, -7.82681182e-02f, -1.01811206e-02f, -4.10822593e-02f, -8.69317874e-02f, 6.81474581e-02f, -4.07549962e-02f,
  6.10927761e-01f, -2.13213161e-01f, -3.72886732e-02f, -1.41989648e-01f, -3.77800614e-02f, -4.04378548e-02f, -4.98077311e-02f, -7.25397915e-02f, -7.59395361e-02f, -4.56313081e-02f,
  -8.61348957e-02f, -8.63422602e-02f, -1.17481925e-01f, 8.61026943e-02f, -1.15360461e-01f, -5.80540746e-02f, -1.47839189e-01f, -1.14542820e-01f, -1.25063047e-01f, 7.43051320e-02f,
  1.47129586e-02f, -1.18375309e-02f, -9.21246558e-02f, 7.16725290e-02f, 2.07342934e-02f, 3.19105536e-02f, 1.13042988e-01f, -4.26390534e-03f, 6.25286549e-02f, 8.34362023e-03f,
  9.29639617e-04f, 6.38397336e-02f, 2.14029532e-02f, -1.76641606e-02f, -8.73215310e-03f, 1.59341600e-02f, -4.71705422e-02f, 9.54868123e-02f, -4.05014120e-02f, -6.59873933e-02f,
  1.24106202e-02f, 2.34567113e-02f, 1.93506218e-02f, -1.41543867e-02f, 2.25641159e-03f, -4.16437462e-02f, 2.72732880e-03f, 3.03412043e-03f, 1.63439661e-02f, -5.58221266e-02f,
  -4.47769798e-02f, -4.97055613e-02f, 2.67914347e-02f, 6.37964606e-02f, 2.70218751e-03f, -4.15626094e-02f, -1.58006251e-02f, 3.08218729e-02f, -5.49878404e-02f, -9.43242088e-02f,
  1.94169059e-01f, -1.11605726e-01f, 7.37746209e-02f, -1.18514948e-01f, -2.56820321e-02f, 4.39221913e-05f, -6.77623078e-02f, -1.14311405e-01f, -1.00634016e-01f, 8.79759863e-02f,
  4.95985188e-02f, 4.30800319e-02f, -1.43185984e-02f, 3.62310782e-02f, 1.68188140e-02f, -1.28217265e-02f, -5.49564585e-02f, -6.13847226e-02f, 2.82185562e-02f, 5.62784933e-02f,
  -7.95349032e-02f, 5.85351214e-02f, 1.32698819e-01f, 1.20917827e-01f, -1.89666953e-02f, 1.84061229e-02f, 3.28255683e-01f, 1.67003006e-01f, 2.90885326e-02f, 4.43904772e-02f,
  -4.57390025e-03f, -1.83754668e-01f, -1.21840999e-01f, 1.67789698e-01f, 1.73545659e-01f, 1.48006886e-01f, -6.91064633e-03f, -5.60738668e-02f, 1.18225120e-01f, 9.73423645e-02f,
  1.12106338e-01f, 3.17575753e-01f, 2.28531942e-01f, 1.67494982e-01f, 1.16113378e-02f, -8.13281536e-02f, 8.37799087e-02f, 1.81945376e-02f, 3.40634771e-02f, 1.69720158e-01f,
  1.99938580e-01f, 1.58173069e-01f, 4.93824389e-03f, -3.54132093e-02f, 5.19236699e-02f, 2.06382468e-01f, 6.97189346e-02f, 9.92731079e-02f, 3.35863791e-02f, 2.13897809e-01f,
  6.89034685e-02f, -2.16005355e-01f, 1.57452703e-01f, 1.14594832e-01f, 4.15120572e-02f, -1.05628364e-01f, -1.06769539e-01f, -1.03705347e-01f, -1.59461066e-01f, -1.03973985e-01f,
  4.11291867e-02f, -4.49183173e-02f, -4.21184003e-02f, -8.95572454e-02f, -4.65197070e-03f, -5.97669780e-02f, -5.15829101e-02f, -9.07673836e-02f, -1.60767421e-01f, -4.60637137e-02f,
  4.46089394e-02f, 5.48162535e-02f, -4.73713577e-02f, -8.22405443e-02f, -1.11703753e-01f, 1.54048622e-01f, -1.37846991e-01f, -7.89568871e-02f, -4.83722538e-02f, -9.38601494e-02f,
  8.37288424e-02f, -4.43052761e-02f, 8.54813531e-02f, -6.67168573e-02f, 2.05155853e-02f, 1.13840578e-02f, 1.83274932e-02f, 3.04069202e-02f, 1.60543937e-02f, 3.76673378e-02f,
  1.75305009e-02f, 5.79807647e-02f, -8.10393132e-03f, 5.15013635e-02f, 4.28958572e-02f, -8.51418227e-02f, 3.17567140e-02f, 1.93871260e-02f, -7.59926215e-02f, 6.51521087e-02f,
  2.20533647e-02f, -3.03808916e-02f, -3.58182117e-02f, 3.06248595e-03f, 5.95321469e-02f, -2.70997956e-02f, 4.12565954e-02f, -2.69569848e-02f, 9.18632001e-02f, -5.12172617e-02f,
  1.21628068e-01f, -2.75137387e-02f, 6.63902536e-02f, -2.05152277e-02f, -1.79641563e-02f, -3.27561013e-02f, -1.78574920e-02f, -1.46394774e-01f, -3.57504711e-02f, -3.55302952e-02f,
  3.54107395e-02f, 1.02920840e-02f, 6.44670874e-02f, -6.62475750e-02f, 4.62631099e-02f, 4.72311042e-02f, 5.99550344e-02f, -5.94813004e-02f, 5.74191734e-02f, -9.66657326e-02f,
  -6.94446191e-02f, 1.19858822e-02f, 1.09472923e-01f, 1.31692320e-01f, 9.58853029e-03f, 2.25901857e-01f, 7.91502371e-02f, -1.68752186e-02f, -5.42373070e-03f, 1.18800603e-01f,
  -5.40738404e-01f, -7.20947459e-02f, 2.14470685e-01f, 1.09308176e-01f, 7.54296482e-02f, -1.42464668e-01f, -2.32082695e-01f, -1.78261057e-01f, -7.33785480e-02f, -9.81964320e-02f,
  -6.37329519e-02f, -9.24693886e-03f, 1.31086946e-01f, 3.51661332e-02f, 4.78507113e-03f, 7.75278434e-02f, 3.53964776e-01f, 2.63943642e-01f, 5.25916405e-02f, -1.46795169e-01f,
  1.22932486e-01f, 3.20960097e-02f, -7.87852034e-02f, 1.21146172e-01f, -1.89248491e-02f, 1.44806355e-01f, 1.54724956e-01f, 9.19656307e-02f, 3.82356904e-02f, 2.46759236e-01f,
  -2.87748814e-01f, -3.13816190e-01f, 2.45568808e-02f, 6.75053298e-02f, 2.46609934e-02f, -1.19861908e-01f, -1.50180623e-01f, 1.98884048e-02f, -4.87862527e-02f, -3.54190171e-02f,
  -1.32277142e-02f, -1.04733072e-01f, 2.53902320e-02f, -9.20169577e-02f, -1.43417701e-01f, -1.88808009e-01f, -8.92388746e-02f, 1.23065179e-02f, 9.35593527e-03f, -1.42019704e-01f,
  1.13630667e-01f, 3.45144458e-02f, -1.81443676e-01f, -1.10877395e-01f, -1.20324627e-01f, 6.07656687e-02f, -1.82041049e-01f, -1.79659694e-01f, -7.00392500e-02f, -2.40160152e-01f,
  7.67979249e-02f, -4.52162176e-02f, 4.09995252e-03f, -9.30476654e-03f, 3.73807289e-02f, 5.55994175e-02f, -2.87379920e-02f, -4.18075845e-02f, 1.14916310e-01f, 8.31993669e-03f,
  3.47739947e-03f, -5.61308078e-02f, 2.37513352e-02f, -2.97494791e-02f, 2.08012015e-02f, -2.63830870e-02f, -5.25701419e-02f, -6.23737909e-02f, 4.73354980e-02f, 2.63807271e-02f,
  4.53116111e-02f, -6.64403439e-02f, 4.52571213e-02f, 5.75038567e-02f, 5.06792329e-02f, 3.79319489e-02f, -1.05635092e-01f, -4.67199534e-02f, 4.79291603e-02f, -1.05213150e-01f,
  -4.58373427e-02f, 2.16607481e-01f, -1.21259667e-01f, -1.19680412e-01f, 3.80096547e-02f, -4.11295472e-03f, -3.58759500e-02f, -1.67152677e-02f, -8.43329635e-03f, -7.36417696e-02f,
  -1.48977354e-01f, -1.31737173e-01f, -5.33860102e-02f, 3.15430807e-03f, -8.79566148e-02f, -1.79039553e-01f, 3.46614607e-02f, 1.28553314e-02f, -7.21321478e-02f, -1.79956272e-01f,
  2.50783917e-02f, -1.34741262e-01f, -2.48383179e-01f, -1.83905512e-01f, -8.29528496e-02f, -1.45315170e-01f, -1.60505235e-01f, -1.80758014e-01f, -2.28215203e-01f, -3.54758292e-01f,
  4.26080167e-01f, 4.75918829e-01f, 1.10358775e-01f, 2.14490503e-01f, 1.10467099e-01f, 3.26346308e-01f, 5.22875190e-01f, 4.32673454e-01f, 1.10702388e-01f, 1.91549659e-01f,
  4.75499406e-02f, -1.82480644e-02f, 1.85313359e-01f, 9.25980657e-02f, 3.34721178e-01f, 1.89763933e-01f, 2.08755493e-01f, 1.02512501e-01f, 6.59583649e-03f, 1.46628588e-01f,
  1.30485669e-01f, 1.12154491e-01f, 1.28314331e-01f, 1.15703665e-01f, -5.81412343e-03f, 3.93219441e-02f, 8.86985064e-02f, -1.94951112e-03f, -4.70701081e-04f, 7.80974850e-02f,
  -2.04786077e-01f, 2.51687288e-01f, -9.84114483e-02f, -9.72602591e-02f, -1.30189374e-01f, -3.74116674e-02f, -1.58259384e-02f, -3.48106697e-02f, -7.94500932e-02f, 2.84367725e-02f,
  -9.60953608e-02f, -1.23505116e-01f, -8.71559680e-02f, -1.05154403e-01f, 3.20829422e-04f, -1.15031056e-01f, 3.33761536e-02f, 1.19892359e-01f, 4.29316983e-03f, 5.03673851e-02f,
  -5.59933372e-02f, -1.75200909e-01f, 4.05811891e-02f, -4.27072048e-02f, 1.65062591e-01f, -6.75776973e-02f, 6.21244311e-02f, 2.62679625e-02f, 2.00190749e-02f, -3.29122022e-02f,
  -8.95668343e-02f, -2.42939695e-05f, 6.72820956e-02f, -1.53584406e-02f, 6.87822104e-02f, 2.91084149e-03f, -1.51454834e-02f, -6.27686158e-02f, 1.02809951e-01f, 2.99346577e-02f,
  -1.62699707e-02f, -1.11226477e-02f, 4.78802361e-02f, 5.30319624e-02f, -1.00771651e-01f, -4.02969196e-02f, -1.81390606e-02f, -3.58083881e-02f, -7.53726736e-02f, 3.13212685e-02f,
  9.63638052e-02f, -2.55452171e-02f, -9.22674388e-02f, 9.82723664e-03f, 3.31461290e-03f, -4.62801605e-02f, -2.70670913e-02f, -4.38919775e-02f, -2.90325787e-02f, -4.86443751e-02f,
  -1.16702609e-01f, 8.14631358e-02f, -7.99437687e-02f, 6.37983307e-02f, -7.95857906e-02f, -5.94029911e-02f, 2.95497198e-02f, -1.01441570e-01f, -6.67178109e-02f, 4.80140336e-02f,
  -3.71143036e-02f, 6.09327406e-02f, 2.53924020e-02f, -8.30892548e-02f, -1.38242975e-01f, -2.04601679e-02f, -4.31198552e-02f, -2.78742481e-02f, -2.48766392e-02f, -1.21082552e-01f,
  -9.67529044e-03f, -7.70708397e-02f, -1.07154019e-01f, -9.43470299e-02f, 4.19302769e-02f, -1.40650570e-01f, -6.26594126e-02f, -6.09836243e-02f, 8.96125007e-03f, -1.12655625e-01f,
  5.46961904e-01f, 1.91206679e-01f, -6.86008632e-02f, 2.03413591e-01f, -1.04037613e-01f, -2.92766571e-01f, -5.10050058e-01f, -2.13330716e-01f, 5.41915419e-03f, 7.18713254e-02f,
  1.55856386e-02f, -9.86188650e-03f, -1.09753031e-02f, -7.00409636e-02f, -3.14988673e-01f, -1.16374433e-01f, -1.20357364e-01f, -4.92899492e-02f, -2.55550444e-01f, -1.59570768e-01f,
  -5.85291088e-02f, 2.00270206e-01f, 2.74071515e-01f, -6.24935934e-03f, 1.97699830e-01f, 5.94867161e-03f, 1.77684620e-01f, 2.97541440e-01f, 1.22217447e-01f, 3.24467570e-01f,
  2.83987015e-01f, 3.49956870e-01f, -1.53818458e-01f, 4.28938083e-02f, 8.27221423e-02f, 7.50740916e-02f, -4.01806869e-02f, 1.32824898e-01f, 1.68317708e-03f, 1.02244960e-02f,
  3.32779214e-02f, -7.14778062e-03f, 5.31628095e-02f, 3.42880711e-02f, 2.56487690e-02f, -5.85973039e-02f, 5.58008589e-02f, -8.53028223e-02f, -1.47750348e-01f, -1.54346684e-02f,
  -2.07380205e-02f, 1.44736588e-01f, -8.45738649e-02f, -2.02400997e-01f, -8.48342627e-02f, -5.19673824e-02f, 3.99849638e-02f, 1.66704645e-03f, 8.32884666e-03f, 1.08681165e-01f,
  -6.78711608e-02f, -3.94501574e-02f, 4.46124896e-02f, -3.82718854e-02f, -3.16741392e-02f, -2.45567597e-02f, -1.03503112e-02f, -1.10951521e-01f, -3.63564193e-02f, -6.73065260e-02f,
  -1.13292076e-02f, 9.44319647e-03f, -6.16912469e-02f, 4.70900349e-02f, 2.18543150e-02f, -4.39905599e-02f, -3.88572714e-03f, -2.38190293e-02f, -2.95303930e-02f, -1.56236878e-02f,
  -1.09614087e-02f, 3.17014232e-02f, 1.06295384e-01f, -5.43672703e-02f, 8.36952701e-02f, 3.91925424e-02f, -4.71951906e-03f, -3.68751697e-02f, 5.37797203e-03f, 1.37828648e-01f,
  -1.32573947e-01f, -4.03299391e-01f, -1.39922509e-02f, -3.00593898e-02f, 1.21009082e-01f, 8.66548270e-02f, 2.40225233e-02f, 1.36291273e-02f, 2.41206363e-02f, -3.10816243e-02f,
  -1.25418073e-02f, -1.04101039e-02f, -4.44143265e-02f, -1.23864964e-01f, -1.66130319e-01f, -4.03585397e-02f, -6.88095540e-02f, -1.04684189e-01f, -9.04069990e-02f, -2.14627497e-02f,
  -1.09569602e-01f, -2.69915879e-01f, -2.37278759e-01f, -2.88602978e-01f, 2.69427691e-02f, -1.52182654e-01f, -1.04186736e-01f, -9.40473005e-02f, -2.56117433e-01f, -1.90235808e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.63983285e-01f, 1.39741272e-01f, 2.59811521e-01f, 2.00854182e-01f, 2.42174119e-01f, 2.62484461e-01f, 2.00692326e-01f, 4.41443920e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -2.11218134e-01f, 1.08186737e-01f, 1.49799839e-01f, 4.96571586e-02f, -1.15618265e+00f, -3.42371851e-01f, -6.25369310e-01f, -1.56819031e-01f, -2.62206346e-01f, -2.53894180e-01f,
  3.50891113e-01f, -2.06316620e-01f, 1.54070258e-01f, 1.56581119e-01f, 1.17778145e-01f, 1.81960672e-01f, 1.51335120e-01f, 3.57705355e-01f, 3.28359872e-01f, 4.82819676e-01f,
  -2.41966799e-01f, -5.87345481e-01f, 4.96250033e-01f, -1.68395206e-01f, 1.09380193e-01f, 1.59164459e-01f, 8.94916773e-01f, -2.89293706e-01f, -2.97055282e-02f, -3.70199502e-01f,
  -1.23673186e-01f, -1.06105760e-01f, -1.86149478e-01f, 2.34630048e-01f, 3.70362371e-01f, -9.71767232e-02f, 2.85775363e-01f, 2.88776726e-01f, -7.38242626e-01f, -2.85481244e-01f,
  6.27530441e-02f, 4.12109077e-01f, -3.48912448e-01f, 4.32996303e-02f, 7.00446844e-01f, -5.77468216e-01f, 8.65516588e-02f, -8.42134297e-01f, -9.15377319e-01f, -5.63740790e-01f,
  -7.07053989e-02f, 7.59116590e-01f, -3.58025312e-01f, 6.50095880e-01f, 6.69967592e-01f, 1.61990479e-01f, 3.27509522e-01f, -2.55389780e-01f, 4.44265336e-01f, -2.76165277e-01f,
  2.42817894e-01f, -3.65235627e-01f, 5.29913247e-01f, -2.83576280e-01f, 3.73962745e-02f, 1.29668728e-01f, 2.14050159e-01f, 1.00690812e-01f, 3.53027791e-01f, 1.29944077e-02f,
  2.17136294e-01f, 1.95311174e-01f, 4.78474945e-01f, -7.26080760e-02f, 4.69911486e-01f, 3.94883811e-01f, -6.70903027e-01f, 3.88891995e-01f, 3.84317666e-01f, -1.91543579e-01f,
  -3.77773911e-01f, 8.50804389e-01f, 7.50409365e-01f, 1.52529731e-01f, -1.82726234e-02f, 6.07786715e-01f, -1.12001374e-01f, -5.99311054e-01f, -5.45296993e-04f, -3.33114296e-01f,
  -4.32579875e-01f, -1.50601998e-01f, -1.28726199e-01f, 8.37265193e-01f, -6.15403891e-01f, -3.54034416e-02f, -2.25605831e-01f, 1.59692049e-01f, -1.61352959e-02f, 1.32044956e-01f,
  2.56231606e-01f, -8.70936632e-01f, 5.62366903e-01f, 2.59620488e-01f, -2.24666759e-01f, -2.56501764e-01f, -3.45392853e-01f, 7.88585097e-02f, -8.68778169e-01f, -4.49603260e-01f,
  -1.50424287e-01f, 5.79903275e-02f, -2.19614178e-01f, 4.32869911e-01f, -6.00451171e-01f, -2.40621462e-01f, -8.08831871e-01f, -4.88023758e-01f, -5.43706656e-01f, -2.08379820e-01f,
  -4.92841750e-02f, -7.18106478e-02f, 6.01454377e-01f, 5.39770901e-01f, -2.48240530e-01f, 2.36907043e-02f, -1.34478077e-01f, -6.17553592e-01f, 2.20127568e-01f, -3.62977684e-01f,
  -4.57828552e-01f, 1.49419820e-02f, 1.44625828e-01f, 2.15827569e-01f, 1.11128569e-01f, -5.06433487e-01f, 1.60916254e-01f, 9.04557258e-02f, -4.88594294e-01f, 3.29975456e-01f,
  2.44460940e-01f, 3.80161583e-01f, -6.23047352e-01f, -4.47567254e-02f, -5.93760729e-01f, 4.44851816e-01f, 5.87279141e-01f, -6.62328184e-01f, 2.49144688e-01f, -1.68083102e-01f,
  -6.99962258e-01f, 3.97106588e-01f, -3.69618982e-02f, 2.80005515e-01f, 5.67706764e-01f, 1.59055404e-02f, 3.12377084e-02f, -4.65060174e-02f, 9.87729952e-02f, 5.46687901e-01f,
  2.17416808e-01f, 3.70892465e-01f, 1.30665660e-01f, -3.67474556e-02f, 5.04261255e-01f, -1.86339021e-01f, 1.05009899e-01f, 1.94119215e-01f, 1.79487005e-01f, 4.45216119e-01f,
  6.55412436e-01f, -7.00065717e-02f, 5.46498716e-01f, 2.98938751e-01f, 6.81599736e-01f, 5.10857463e-01f, -1.99339747e-01f, -6.93921030e-01f, 9.06186581e-01f, -9.20148671e-01f,
  -4.77385342e-01f, -4.35984641e-01f, 6.58913970e-01f, 6.22844815e-01f, 6.37828708e-01f, 1.09024756e-02f, 8.18727612e-02f, -2.62116164e-01f, 8.41175318e-02f, -2.53672183e-01f,
  1.83325514e-01f, -7.59856626e-02f, 1.95826367e-01f, 3.03199351e-01f, 3.51280481e-01f, -5.44296622e-01f, 2.03752041e-01f, 9.29525271e-02f, 6.22303337e-02f, 2.85558730e-01f,
  -4.09035325e-01f, 1.57208771e-01f, 1.12546250e-01f, -3.53557020e-01f, -3.24401446e-02f, 5.01810491e-01f, 4.16706473e-01f, 7.40432620e-01f, 3.82205516e-01f, -1.37718320e-01f,
  -6.53477967e-01f, -2.17668399e-01f, 7.35728145e-01f, 5.32631576e-01f, -1.67813286e-01f, -5.71855843e-01f, -9.73189548e-02f, -4.67731744e-01f, -4.70952451e-01f, -2.17606768e-01f,
  -5.41226566e-01f, -9.67393368e-02f, 3.39903504e-01f, 7.77563035e-01f, -5.94255328e-01f, -5.10830045e-01f, -1.27375111e-01f, -7.12580234e-02f, -1.11799769e-01f, -8.37485492e-03f,
  -3.97193879e-01f, 4.39043948e-03f, 1.23050749e-01f, -1.52903095e-01f, -5.84318787e-02f, -4.98390585e-01f, -5.10447025e-01f, 6.20831490e-01f, 2.89850861e-01f, -1.41178831e-01f,
  3.45640689e-01f, 1.88465536e-01f, -2.51671940e-01f, 2.49978945e-01f, -5.48813045e-01f, -6.54720724e-01f, -1.04498349e-01f, -1.52064115e-01f, 7.60516748e-02f, 2.29223534e-01f,
  -3.02961737e-01f, -1.35363653e-01f, 1.75519019e-01f, 7.72914588e-01f, 3.67179215e-01f, -3.66039425e-01f, -1.77867591e-01f, -5.39872706e-01f, 1.59311995e-01f, 4.13824499e-01f,
  -4.29647326e-01f, 5.49028516e-01f, 6.79957807e-01f, 2.73136437e-01f, 3.91705602e-01f, -4.39086199e-01f, -4.22094554e-01f, 1.83731720e-01f, 4.32427615e-01f, -7.17030406e-01f,
  6.67721987e-01f, 1.30412370e-01f, 9.05403376e-01f, 2.92224530e-02f, 1.37126237e-01f, 6.01702750e-01f, -3.81548107e-01f, 7.40302503e-01f, 6.09727621e-01f, 3.90355438e-01f,
  -1.86347261e-01f, -1.98735699e-01f, -5.54795623e-01f, 3.19285654e-02f, 2.37223446e-01f, -5.08170128e-02f, 7.15234354e-02f, -3.57047498e-01f, 6.57523498e-02f, -1.23672269e-01f,
  -7.04485625e-02f, 3.16843152e-01f, 4.63595651e-02f, 3.75079587e-02f, -1.14820048e-01f, 2.56442368e-01f, -8.79134238e-02f, 3.21396559e-01f, -4.29995283e-02f, 1.31439000e-01f,
  -4.29462314e-01f, 4.43230927e-01f, -6.79459453e-01f, -1.48768067e-01f, -4.18568939e-01f, -4.58379298e-01f, -4.66735274e-01f, 2.06890181e-01f, 4.36379939e-01f, 1.23849899e-01f,
  -3.47699791e-01f, -1.62124380e-01f, 1.48744375e-01f, 9.98058975e-01f, -4.98605639e-01f, -1.83688387e-01f, 4.48480278e-01f, 3.97711694e-01f, -5.98805904e-01f, 7.31247544e-01f,
  -8.41575563e-02f, 3.36721182e-01f, 7.32668266e-02f, -6.90478310e-02f, 3.23961407e-01f, 1.17601573e-01f, 2.59146869e-01f, -1.50706038e-01f, -6.02488965e-02f, 4.59706560e-02f,
  5.36776893e-02f, -1.19016208e-01f, -4.69099432e-01f, 1.84521392e-01f, -1.29579917e-01f, -4.85944480e-01f, 3.68769653e-02f, -2.92676389e-01f, -1.03604153e-01f, -6.45018578e-01f,
  6.19355619e-01f, 4.07580853e-01f, 5.76186836e-01f, 4.21414375e-01f, -2.43027285e-01f, -1.53270885e-01f, 1.80762925e-03f, 1.13754392e+00f, 1.06289864e-01f, -3.61441523e-01f,
  -2.74051756e-01f, -4.45793003e-01f, -4.46728878e-02f, 8.31190944e-02f, 5.73530421e-02f, 9.08870846e-02f, -4.43656415e-01f, 2.76632041e-01f, -2.65204817e-01f, 2.72858888e-01f,
  4.56084907e-01f, 1.92555681e-01f, -2.96237260e-01f, 3.27418178e-01f, 6.87722623e-01f, -9.31739926e-01f, -6.70989096e-01f, 2.23215207e-01f, 6.09006703e-01f, -1.78132758e-01f,
  -4.37852502e-01f, -2.35926673e-01f, 9.73052680e-02f, -8.39212775e-01f, -6.21148944e-01f, -1.46581307e-01f, -1.92490324e-01f, 3.69332016e-01f, -3.41836691e-01f, -2.84503400e-01f,
  -4.36149925e-01f, -2.32700780e-01f, 5.43213487e-01f, 2.94316828e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.50505006e-01f, 3.10208723e-02f, 1.96497828e-01f, -1.13159500e-01f, -1.19763799e-01f, 2.92695016e-01f, 3.78913507e-02f, -6.36962652e-02f, 3.62996906e-01f, -2.34344959e-01f,
  -2.71628201e-02f, 7.14905187e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    