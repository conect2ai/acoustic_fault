/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.20776215e-01f, -4.21826184e-01f, -4.05595526e-02f, -1.04067810e-01f, -4.54892069e-02f, 1.59303397e-01f, 2.12476179e-01f, -1.51483357e-01f, -8.23163148e-03f, -2.38262236e-01f,
  2.77181412e-03f, -4.04995233e-02f, -1.26828123e-02f, -6.16873279e-02f, 4.41867143e-01f, 1.52404383e-01f, -3.98890637e-02f, -4.91970517e-02f, 9.92213935e-03f, -1.86931416e-01f,
  6.08111359e-02f, -1.65203705e-01f, 1.51910916e-01f, -1.48612842e-01f, -9.64270309e-02f, -1.47869438e-01f, -7.79264495e-02f, 1.43804373e-02f, -1.42661810e-01f, 4.70456481e-02f,
  2.60821134e-01f, -5.74101172e-02f, -5.87099977e-02f, -4.51947637e-02f, -2.50213016e-02f, 3.28667797e-02f, -4.41029854e-03f, 1.01590581e-01f, 7.96995386e-02f, -2.09445152e-02f,
  -1.52404588e-02f, -2.54537817e-02f, -3.39730904e-02f, 1.87273789e-02f, -6.52292296e-02f, -2.87695732e-02f, 1.24701867e-02f, 2.01968644e-02f, -4.43809777e-02f, 4.68648411e-02f,
  1.86262727e-02f, 2.61446200e-02f, -1.92939825e-02f, -3.38787660e-02f, 2.38138344e-02f, -2.75802016e-02f, 4.75498624e-02f, 1.83742624e-02f, -3.70090529e-02f, 1.88929308e-03f,
  -4.97156084e-02f, -1.83734838e-02f, 6.13403507e-03f, 3.28037329e-03f, -2.59912154e-03f, 1.09634874e-02f, -1.11214165e-02f, -7.08014099e-03f, -1.38248561e-03f, 1.34101021e-03f,
  -3.21159698e-03f, -3.11772004e-02f, -9.36908554e-03f, 1.85197778e-02f, -2.10606796e-03f, -1.20613091e-02f, 2.21841931e-02f, -2.69282199e-02f, -1.28303664e-02f, 3.44880559e-02f,
  -4.81172494e-04f, 7.96877965e-03f, -1.55637246e-02f, -1.00508621e-02f, 3.04191783e-02f, 1.27295908e-02f, -6.29349574e-02f, -2.09138989e-02f, 7.07985135e-03f, 5.94385900e-02f,
  -9.13843289e-02f, -2.95755953e-01f, 1.47386864e-02f, 7.81311101e-05f, 1.10480599e-02f, -2.55099535e-02f, -5.25238458e-03f, -4.90896702e-02f, -5.57791442e-02f, 6.83142804e-03f,
  4.58170800e-03f, 4.49210545e-03f, 2.80896518e-02f, -1.91938840e-02f, 3.57049368e-02f, -4.23511304e-03f, -8.21071304e-03f, -4.75876033e-02f, 1.50709469e-02f, -4.77210917e-02f,
  -4.70276587e-02f, -1.79257113e-02f, 5.75794987e-02f, 3.81232724e-02f, -1.92633178e-02f, 3.56139094e-02f, -2.06356496e-02f, 2.67196763e-02f, 9.82657354e-03f, -1.86389256e-02f,
  7.15247750e-01f, 6.18061610e-02f, 1.63885474e-01f, 3.80498439e-01f, 3.39196801e-01f, -6.93865642e-02f, -1.67077199e-01f, 2.31987387e-01f, 1.23676769e-01f, -2.17139170e-01f,
  1.95978228e-02f, 4.80272323e-02f, -3.03203195e-01f, 1.89052761e-01f, 2.86233932e-01f, -2.53620595e-01f, 1.28782138e-01f, 6.85617328e-03f, 6.83281049e-02f, 1.18890591e-01f,
  2.41760224e-01f, 2.15686020e-03f, 1.55080676e-01f, 4.86848056e-02f, 2.13012084e-01f, 9.09662768e-02f, 5.41072041e-02f, -4.07886617e-02f, 6.72866255e-02f, -3.01221181e-02f,
  -2.21204683e-02f, 4.97901905e-03f, 7.42212310e-02f, -1.29384726e-01f, 5.06009385e-02f, 3.20344046e-02f, -2.92288009e-02f, -7.59865642e-02f, 1.00515321e-01f, 6.04400644e-03f,
  -2.33328287e-02f, 5.76424003e-02f, 7.24467542e-03f, 1.72200594e-02f, 7.01124147e-02f, 7.15441108e-02f, 6.29637390e-02f, 5.00047654e-02f, -9.16804187e-03f, 2.65101045e-02f,
  2.40003802e-02f, 4.50396240e-02f, 4.34172377e-02f, -7.64570087e-02f, 3.70266549e-02f, 1.48926247e-02f, -1.50118936e-02f, -1.98988579e-02f, 2.59452946e-02f, 3.85454819e-02f,
  -3.17872763e-02f, -5.47361840e-03f, -7.66566861e-03f, -4.92948759e-03f, 4.95475605e-02f, 2.15221988e-03f, 1.30623579e-03f, -1.04565499e-02f, 2.96900049e-02f, -6.80297147e-03f,
  8.86060949e-03f, 5.70918359e-02f, 1.38831828e-02f, 1.55479303e-02f, 1.77906100e-02f, -1.14700021e-02f, -8.32290016e-03f, -3.83421779e-02f, -6.28144480e-03f, 6.49000928e-02f,
  -3.34442183e-02f, 1.00494372e-02f, -6.24113856e-03f, -3.03636380e-02f, -1.78989321e-02f, 1.16411457e-02f, 4.41571651e-03f, 7.69217033e-03f, 1.96647309e-02f, 9.59744491e-03f,
  -1.03554450e-01f, -1.50482148e-01f, -7.64849856e-02f, 3.19226161e-02f, -5.96649125e-02f, 3.09508052e-02f, 9.21523478e-03f, 6.41125217e-02f, -8.19697976e-02f, -1.05309421e-02f,
  -1.06319822e-02f, -9.22438409e-03f, -2.18658173e-03f, 3.41474973e-02f, -1.03280763e-03f, -3.08522843e-02f, -4.81414124e-02f, -1.17096081e-02f, -1.27555709e-03f, 3.41866352e-02f,
  6.46122405e-03f, -5.46848774e-02f, 1.42239220e-02f, 4.25095186e-02f, -8.28111731e-03f, -2.27171481e-02f, 4.83303331e-02f, -2.36362591e-02f, -2.32090577e-02f, -3.39423046e-02f,
  3.29312027e-01f, 4.60293531e-01f, 9.68857557e-02f, 1.98311299e-01f, -7.32452720e-02f, 3.11661921e-02f, 2.27305993e-01f, 3.36397886e-02f, 3.35292101e-01f, 3.15151185e-01f,
  -1.46101311e-01f, 2.06647620e-01f, 6.83208182e-02f, 1.48600683e-01f, -2.68287301e-01f, 1.41639277e-01f, -5.23954257e-02f, -4.51688245e-02f, -1.85481145e-03f, -1.68879375e-01f,
  -1.12820439e-01f, -2.16350064e-01f, -2.14947373e-01f, -2.29812831e-01f, -1.17362484e-01f, 1.36858504e-02f, -2.62158036e-01f, -1.07410550e-01f, -1.33859336e-01f, -2.74737403e-02f,
  1.49187297e-01f, 1.81274638e-01f, 3.66294235e-02f, 2.58569922e-02f, -1.33125857e-01f, -1.86121352e-02f, -8.80330428e-02f, -2.27060392e-02f, -7.51744136e-02f, 2.39906777e-02f,
  -1.88884661e-02f, -2.25436948e-02f, -1.69593133e-02f, -2.95554684e-03f, 2.86927503e-02f, 5.96281737e-02f, -2.28452906e-02f, 3.73673029e-02f, 8.55843443e-03f, 3.41966655e-03f,
  2.73539852e-02f, -3.22070904e-02f, -5.26499189e-02f, -5.25403395e-03f, -2.24818420e-02f, 3.36641185e-02f, 2.06683371e-02f, -4.17184494e-02f, 1.17616557e-01f, 9.39853713e-02f,
  -5.65199144e-02f, -6.03470504e-02f, -4.84984145e-02f, 3.77205871e-02f, -2.51001660e-02f, -2.18632817e-02f, -2.53045801e-02f, -2.47983076e-02f, 3.45148034e-02f, -4.32766527e-02f,
  4.42401357e-02f, 9.41906311e-03f, 1.56725701e-02f, -2.91696703e-03f, -6.05025981e-03f, 2.47416459e-02f, -3.40004563e-02f, -1.86578277e-02f, 1.75294206e-02f, 2.13226024e-03f,
  1.49176065e-02f, -2.27713957e-02f, -1.39494250e-02f, 1.16213728e-02f, -1.84009355e-02f, -1.74225625e-02f, 1.34223457e-02f, 4.74294312e-02f, -6.41465038e-02f, -2.96174828e-02f,
  -1.85702264e-01f, -1.29639804e-01f, 4.00588065e-02f, -1.19956071e-02f, 5.31893671e-02f, 5.08926529e-03f, 3.04628089e-02f, 1.33342631e-02f, -2.05617063e-02f, -5.26489094e-02f,
  -1.02073707e-01f, 9.92300361e-03f, 1.87818538e-02f, -3.46796736e-02f, -4.05349396e-02f, -2.62425262e-02f, -3.85197289e-02f, -3.12461983e-02f, -4.68283445e-02f, -4.49961647e-02f,
  -3.64184380e-02f, -2.93926969e-02f, 4.50649634e-02f, -6.09983169e-02f, -3.02152261e-02f, -4.71137539e-02f, 1.68494396e-02f, 5.44252843e-02f, -6.81065023e-02f, -1.16234478e-02f,
  -6.31270409e-02f, 5.03631115e-01f, 2.43879199e-01f, 1.57785282e-01f, -1.71890631e-01f, 5.10155201e-01f, 3.38206351e-01f, -5.83283342e-02f, 5.69304340e-02f, 1.80038720e-01f,
  -8.76788720e-02f, 2.87164807e-01f, 5.44745103e-02f, 2.97236294e-01f, 6.36032969e-02f, 3.32355678e-01f, 1.83957994e-01f, 2.26492047e-01f, -6.22578226e-02f, 2.75133327e-02f,
  -4.45251120e-03f, 7.61144161e-02f, 1.06840283e-01f, -1.41994968e-01f, 3.46467458e-02f, -9.27523375e-02f, -2.95013487e-01f, -9.37422812e-02f, -4.89620790e-02f, -3.88393700e-02f,
  4.09672819e-02f, 7.53569528e-02f, 2.90145241e-02f, 4.76719067e-02f, 4.67303172e-02f, 1.55635681e-02f, 2.33688648e-03f, -2.12902054e-02f, -5.84677607e-03f, 2.68463772e-02f,
  3.55552472e-02f, -3.51149142e-02f, 1.39072137e-02f, -1.35121876e-02f, 2.38783080e-02f, 1.48540605e-02f, -8.71011522e-03f, 5.27231656e-02f, 4.04784046e-02f, 1.04808040e-01f,
  7.56177083e-02f, -3.44251376e-03f, 3.39995623e-02f, 5.21554835e-02f, -2.07145549e-02f, 3.51804942e-02f, 7.43395835e-02f, 1.93369966e-02f, 7.38113886e-03f, -3.31942886e-02f,
  -2.80004237e-02f, -1.26298312e-02f, 2.17134189e-02f, -3.95928062e-02f, 1.67319328e-02f, -4.15108800e-02f, -1.51913641e-02f, -1.61404088e-02f, -2.51719337e-02f, 5.03441272e-03f,
  -1.68796461e-02f, -1.46610411e-02f, -1.57736298e-02f, 1.37009369e-02f, 2.09551007e-02f, -7.70344632e-03f, -7.77650485e-03f, -2.13136487e-02f, 1.73010733e-02f, 1.25642894e-02f,
  1.60452048e-03f, 4.85876249e-03f, -1.77417323e-02f, -2.31156778e-02f, 1.26570289e-04f, 4.67001041e-03f, -4.40394599e-03f, -4.23331652e-03f, -6.39466429e-03f, -3.31015177e-02f,
  2.59013683e-01f, -5.58196455e-02f, 1.38481390e-02f, -3.58023867e-02f, 5.32246800e-03f, -1.91309862e-02f, 5.50340936e-02f, -2.56702118e-03f, 1.71444472e-02f, -3.19164782e-03f,
  -3.53725851e-02f, 5.27376160e-02f, -3.10635343e-02f, -2.30008457e-02f, -6.46242220e-03f, -1.10926507e-02f, -8.54002591e-03f, -6.69379756e-02f, -3.58103402e-02f, -3.56987603e-02f,
  -4.82510515e-02f, -2.33317609e-03f, -2.64068246e-02f, -3.05362772e-02f, -8.95556808e-03f, -5.05387671e-02f, -1.71450563e-02f, -2.13541240e-02f, -6.29163831e-02f, 4.20608222e-02f,
  6.49325848e-02f, 4.61814133e-03f, 3.18099916e-01f, -7.34420435e-04f, 1.58271879e-01f, 3.17266107e-01f, 1.12627320e-01f, -5.31202815e-02f, 8.07130709e-02f, -1.83467120e-01f,
  -1.95213422e-01f, 7.67987408e-03f, -1.80876762e-01f, -1.62177011e-01f, -1.35732099e-01f, -2.07251385e-01f, -7.95169454e-03f, -7.27763698e-02f, -9.28389654e-02f, 4.79553081e-02f,
  2.71073729e-02f, -2.55274236e-01f, -1.90368742e-02f, -3.78013626e-02f, 1.06095545e-01f, 1.67868808e-02f, -1.81591153e-01f, -9.35503393e-02f, 1.05122570e-02f, -3.22490223e-02f,
  -4.19522896e-02f, 2.55935080e-02f, 7.35386014e-02f, 5.62377367e-03f, 9.31864455e-02f, 9.73037928e-02f, 2.24241205e-02f, 2.42279395e-02f, 3.32902372e-02f, 6.59576431e-02f,
  1.74347796e-02f, 6.58398718e-02f, 2.20456496e-02f, 2.63792388e-02f, 6.08390570e-02f, 4.89412658e-02f, 1.09374404e-01f, 1.15946559e-02f, 6.51059896e-02f, 8.77937153e-02f,
  1.09902760e-02f, 1.96048133e-02f, 4.23235670e-02f, 3.37767564e-02f, 2.33647693e-02f, 5.10708317e-02f, 2.38562617e-02f, 1.24635370e-02f, -3.65247717e-04f, 5.40938117e-02f,
  -1.18969292e-04f, -2.41382886e-02f, 5.76898083e-03f, -2.74888054e-02f, 5.37296711e-03f, 1.50660658e-02f, -8.73794220e-03f, -1.32955862e-02f, -1.58301578e-03f, -2.13953871e-02f,
  -2.28643455e-02f, 3.00609390e-03f, -4.60385997e-03f, 7.45975133e-03f, -1.33035732e-02f, 4.02563959e-02f, -3.03757042e-02f, -4.32153270e-02f, 2.58269254e-02f, -8.24617445e-02f,
  -4.05648351e-02f, 1.61636062e-02f, -7.53387958e-02f, 3.32614407e-02f, -3.17227356e-02f, -3.70898172e-02f, -6.44253474e-03f, 2.29932051e-02f, 2.91296765e-02f, 1.41238719e-02f,
  -9.82564166e-02f, -2.98047721e-01f, -6.68366626e-02f, 5.02891913e-02f, -4.50491756e-02f, -4.56486270e-02f, -1.47542199e-02f, 6.21947739e-03f, -5.47137856e-02f, -3.24899629e-02f,
  3.26512158e-02f, 6.17462620e-02f, 8.53836536e-03f, -5.03782667e-02f, -4.02485058e-02f, -2.46261712e-02f, -4.09085266e-02f, -2.68106088e-02f, -4.54734266e-02f, -3.86428237e-02f,
  -1.95888020e-02f, -3.26164230e-03f, 9.98844951e-03f, -4.42684814e-03f, 3.07038017e-02f, -1.88618060e-02f, 4.32488844e-02f, -2.95327380e-02f, -1.93211194e-02f, -4.52448661e-03f,
  5.36807537e-01f, 1.92650095e-01f, -1.65824562e-01f, 1.71147645e-01f, 1.72751676e-02f, 2.02729061e-01f, 3.19040805e-01f, 2.39087525e-03f, -9.86694694e-02f, 2.73139119e-01f,
  1.98841766e-01f, -4.14615870e-02f, 8.38117003e-02f, 1.95285782e-01f, 7.69974738e-02f, -4.48463000e-02f, 2.82331795e-01f, 1.41403466e-01f, -1.20993659e-01f, 1.21482834e-01f,
  -2.02991161e-02f, 3.17113370e-01f, -5.55627942e-02f, -5.22783175e-02f, 7.33704492e-02f, -1.82787687e-01f, 9.71720591e-02f, -1.32659674e-01f, 6.02578297e-02f, 4.20628972e-02f,
  -1.51980802e-01f, -9.24855694e-02f, 1.49575658e-02f, -6.06713481e-02f, 9.41784903e-02f, 1.05203107e-01f, 1.95258902e-03f, -2.07222272e-02f, -7.56621584e-02f, 9.19589587e-03f,
  1.62823796e-02f, -3.59156914e-02f, -4.58657257e-02f, -1.09060071e-02f, -6.26913039e-04f, -7.96508938e-02f, -5.93023188e-02f, -3.74427880e-03f, -7.14407414e-02f, -1.75810140e-02f,
  -2.96879597e-02f, -2.24067811e-02f, 2.26965006e-02f, 5.18710352e-03f, -4.24492657e-02f, 6.01348700e-03f, -3.13484333e-02f, -2.79741418e-02f, -3.24818455e-02f, 2.71013081e-02f,
  8.70020464e-02f, -3.04833781e-02f, 5.31460973e-04f, -7.23998249e-02f, -4.73237969e-03f, -4.85756993e-02f, -2.56788451e-02f, -3.99443740e-03f, -2.67841462e-02f, 3.27346250e-02f,
  -2.16240901e-03f, -3.26021202e-02f, 3.05180866e-02f, -2.51193754e-02f, 5.27672879e-02f, -3.01378593e-02f, -1.11225871e-02f, -1.45066180e-04f, 2.78570000e-02f, -3.63981985e-02f,
  -2.95213833e-02f, 2.21607145e-02f, -1.82482565e-03f, 2.87520438e-02f, -5.01694307e-02f, -4.28814963e-02f, 1.10750413e-02f, -3.56608778e-02f, -4.82165702e-02f, 5.11871278e-02f,
  2.13472888e-01f, 3.34088296e-01f, -6.45686164e-02f, -4.12586331e-02f, -3.50505821e-02f, 5.12705278e-03f, -4.77416217e-02f, -2.68898252e-03f, 5.95360287e-02f, 2.61959750e-02f,
  4.50483896e-02f, 9.71375313e-03f, 7.34624565e-02f, -2.55040862e-02f, -5.16178608e-02f, 4.66856472e-02f, 7.40555078e-02f, 3.67526561e-02f, 9.18060467e-02f, 3.14703174e-02f,
  1.22386254e-02f, 1.67351728e-03f, -6.84061320e-03f, -4.97156084e-02f, 5.33631667e-02f, 2.31821965e-02f, 3.98579314e-02f, 1.08621782e-03f, 4.52046022e-02f, -1.29001336e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.85158104e-02f, 3.78526926e-01f, 1.77742213e-01f, 7.72754192e-01f, 1.63682029e-01f, -3.97504829e-02f, 2.05520838e-01f, 4.45419312e-01f, 8.75815690e-01f, -2.28174210e-01f,
  3.45952548e-02f, -3.66839796e-01f, 5.62527124e-03f, 2.68538833e-01f, 2.81476736e-01f, 2.78596789e-01f, 5.06359696e-01f, 5.58967702e-02f, 4.92322296e-01f, 2.62304842e-01f,
  4.00714487e-01f, 1.40443698e-01f, 5.43371364e-02f, 2.35737562e-02f, -1.03509530e-01f, 6.29990846e-02f, -1.11204065e-01f, -6.88957646e-02f, -2.98574269e-01f, -1.11044839e-01f,
  -1.70711577e-01f, -8.70224275e-03f, -1.41495928e-01f, -4.31367047e-02f, 5.46303131e-02f, -1.40487388e-01f, -1.81995377e-01f, -1.38055772e-01f, -1.94734111e-02f, -9.77909099e-03f,
  -1.45998165e-01f, -5.29364944e-02f, 7.11421371e-02f, 2.10548285e-02f, 8.03938806e-02f, -1.35753741e-02f, -4.84491251e-02f, -3.45378742e-03f, -8.28467682e-02f, -1.45547464e-01f,
  -7.99882784e-02f, -1.12081049e-02f, -2.56980490e-03f, 8.55868589e-03f, 4.72314395e-02f, -4.66537382e-03f, -2.30663782e-03f, -4.16851975e-02f, -3.16508710e-02f, 9.93539840e-02f,
  -1.32481651e-02f, 1.45458370e-01f, -6.63039684e-02f, -5.66824041e-02f, 4.86802794e-02f, -1.70837212e-02f, 3.78594846e-02f, -3.06354426e-02f, 6.16127774e-02f, -6.08558357e-02f,
  1.00197122e-01f, 6.33655675e-03f, 8.86162147e-02f, 2.64879968e-03f, 3.13533396e-02f, 2.62884423e-02f, -5.32009006e-02f, -1.18630705e-02f, 1.16595343e-01f, 9.71784815e-03f,
  1.64220936e-03f, -4.92181582e-03f, 5.25811280e-04f, -4.76827472e-02f, -2.49229185e-02f, -6.46632258e-03f, 2.16864236e-02f, 2.66748965e-02f, -5.09572076e-03f, -8.93931463e-02f,
  2.48068556e-01f, 6.31705999e-01f, 3.20119634e-02f, -9.48824435e-02f, -8.55569448e-03f, -9.61024314e-02f, 7.25524873e-02f, 2.79704295e-02f, 1.72406882e-01f, 4.64778505e-02f,
  2.03872062e-02f, 5.72143728e-03f, -7.63241723e-02f, -6.86712265e-02f, 1.87423620e-02f, 2.42061578e-02f, 4.34469618e-02f, 7.44778588e-02f, 9.32522789e-02f, 1.16220927e-02f,
  -1.02055676e-01f, -2.47978475e-02f, 4.78467159e-02f, 7.49779418e-02f, -8.30764789e-03f, 1.85238924e-02f, -2.94766035e-02f, -4.64346912e-03f, -5.64210908e-03f, 3.30916718e-02f,
  -5.86334951e-02f, -1.16035819e-01f, -4.60416585e-01f, -1.45089120e-01f, -1.37145042e-01f, -2.29265824e-01f, -4.89852250e-01f, -1.53260067e-01f, 8.17135870e-02f, 2.23996371e-01f,
  -2.87230641e-01f, 1.58547834e-01f, -1.80188715e-02f, -5.68304420e-01f, 2.31546104e-01f, 1.77008450e-01f, -1.60334140e-01f, 3.57669927e-02f, -4.61831503e-02f, -2.72324264e-01f,
  1.49575910e-02f, -3.47437590e-01f, -2.61513561e-01f, -2.09090427e-01f, -5.12858689e-01f, -2.85469107e-02f, 1.79780900e-01f, -3.38838041e-01f, -1.57618329e-01f, -2.49952987e-01f,
  -1.35152593e-01f, -1.97089389e-01f, -2.53579080e-01f, 1.34635214e-02f, 4.33850475e-03f, 8.19125846e-02f, -5.60076386e-02f, -9.37411636e-02f, 3.98465141e-04f, -4.33471687e-02f,
  1.22099794e-01f, 5.41535839e-02f, -6.53367117e-02f, -9.30887237e-02f, -5.64198717e-02f, -4.47475016e-02f, 4.68656011e-02f, 1.62380729e-02f, -7.38176238e-03f, -2.80357767e-02f,
  -1.28482193e-01f, 1.34385107e-02f, -3.72319520e-02f, 1.45872578e-01f, -7.43775666e-02f, -7.19450936e-02f, 1.04686134e-01f, -7.68735334e-02f, 5.31699955e-02f, 7.87740499e-02f,
  -4.87524346e-02f, 1.58196121e-01f, -1.91894248e-02f, -8.93134177e-02f, -2.25178152e-02f, -6.63603619e-02f, 5.60610963e-04f, 2.12324280e-02f, 2.64102276e-02f, 1.80749502e-02f,
  -3.63443494e-02f, -6.25028834e-02f, 1.24336896e-03f, 2.12843306e-02f, 1.68309547e-02f, -1.86147615e-02f, -3.05258688e-02f, 4.32395935e-02f, 3.05132591e-03f, 4.37995568e-02f,
  -4.31134887e-02f, -1.78542081e-02f, -4.68312651e-02f, 2.62155179e-02f, -6.67531341e-02f, -4.05450277e-02f, 4.54145856e-02f, 5.45435809e-02f, -1.98822487e-02f, 4.44411635e-02f,
  3.56058851e-02f, 1.24426290e-01f, -5.63379638e-02f, -8.80322754e-02f, 1.14770057e-02f, 1.32484026e-02f, -2.89071016e-02f, -6.18403293e-02f, 1.15289316e-02f, -5.57970256e-03f,
  1.10712983e-01f, 8.90276954e-02f, 6.88429922e-02f, 3.39230038e-02f, 2.38531195e-02f, -5.05361855e-02f, 1.87176764e-02f, 9.07307267e-02f, 7.60391951e-02f, 1.01277843e-01f,
  -6.09684410e-03f, 1.20866962e-01f, 4.06524502e-02f, 2.91416179e-02f, 6.23378567e-02f, 1.67493091e-03f, 1.08943924e-01f, 2.27035843e-02f, -2.62035336e-02f, 6.13817349e-02f,
  -4.61834490e-01f, -9.94699299e-02f, -6.04683578e-01f, 1.83498368e-01f, 1.46106482e-01f, 5.52215278e-01f, 1.09335907e-01f, 9.59833562e-02f, -3.84415053e-02f, 2.67870456e-01f,
  2.16761008e-01f, -1.55721679e-01f, -4.75809991e-01f, 7.85948098e-01f, 1.81066394e-01f, 9.81895924e-02f, 6.54654503e-01f, 3.37069154e-01f, 8.53257254e-03f, -1.80861652e-01f,
  7.00141862e-02f, 7.15984523e-01f, 1.27838831e-02f, 2.78441370e-01f, 1.49919957e-01f, -2.12323919e-01f, -1.58645343e-02f, -3.74654382e-01f, 3.97406816e-01f, 2.99419194e-01f,
  1.28046051e-01f, -3.35429281e-01f, -1.19236857e-01f, -8.78700763e-02f, -1.05520740e-01f, -1.30465612e-01f, -8.57568905e-02f, -5.29838679e-03f, -4.95423637e-02f, -7.79513046e-02f,
  -1.45184368e-01f, 1.98800601e-02f, 1.50117308e-01f, -5.35370335e-02f, 6.36713877e-02f, 2.94994768e-02f, 5.26413657e-02f, -4.17598151e-02f, -6.35931864e-02f, -1.01110213e-01f,
  -1.33453310e-01f, 5.10273948e-02f, -4.69605513e-02f, 3.97662483e-02f, 7.28641637e-04f, 3.26462090e-02f, 2.80997269e-02f, -1.05360031e-01f, 1.11354783e-01f, 1.21292599e-01f,
  -8.58343840e-02f, -1.62522998e-02f, -1.10018468e-02f, 9.55703706e-02f, -7.25945691e-03f, 8.06014240e-02f, 8.77291635e-02f, 3.90081182e-02f, -2.36461740e-02f, 1.02832802e-02f,
  -7.63665594e-04f, 4.87856008e-02f, 9.53179691e-03f, 3.33766155e-02f, 8.04835558e-02f, 5.54282330e-02f, -5.40727824e-02f, 4.08273935e-02f, 6.35676226e-03f, 7.39785507e-02f,
  -3.81907970e-02f, 1.07676266e-02f, -3.24598365e-02f, 4.08204161e-02f, 1.32798888e-02f, -9.66999084e-02f, 3.59891392e-02f, -1.57897808e-02f, -2.44374033e-02f, -8.07590783e-02f,
  -7.01999292e-02f, -5.08724570e-01f, 1.14593655e-02f, 3.59921083e-02f, 3.05373911e-02f, 6.74296692e-02f, 2.37377882e-02f, 2.56643463e-02f, 1.60025246e-02f, -1.20013282e-02f,
  -2.05444470e-02f, -1.16819153e-02f, -4.34084758e-02f, 3.18421759e-02f, -3.46343592e-02f, 1.80782955e-02f, -5.15412502e-02f, 2.13769022e-02f, 8.15829448e-03f, 1.10430513e-02f,
  -8.91085193e-02f, 1.15293008e-03f, 1.22670075e-02f, 2.92832423e-02f, 1.11122675e-01f, 3.67646106e-03f, -3.66666839e-02f, -6.73181191e-02f, -1.92892533e-02f, -3.57682491e-03f,
  -1.07978952e+00f, 6.52207911e-01f, -2.23675847e-01f, -4.31086361e-01f, -1.14230305e-01f, -2.77404279e-01f, -2.42928147e-01f, 7.07782730e-02f, -1.12096295e-01f, 2.35319912e-01f,
  4.44872752e-02f, -3.06158006e-01f, 3.78106654e-01f, 1.21109284e-01f, -3.76173437e-01f, 5.65771043e-01f, -1.21213354e-01f, -1.11968160e-01f, 1.98020428e-01f, -3.23116243e-01f,
  -1.27783343e-01f, 1.00852616e-01f, 1.83766916e-01f, 2.79925197e-01f, -2.95909762e-01f, -1.64607510e-01f, -9.94824395e-02f, 4.20623831e-02f, -1.74990103e-01f, 4.74600345e-02f,
  -3.45170200e-01f, -2.98311442e-01f, -2.28844911e-01f, -1.32160708e-01f, -1.94503218e-01f, -1.29254535e-01f, -1.41822696e-01f, -7.95888603e-02f, -1.07202783e-01f, -4.87964973e-02f,
  -3.47008631e-02f, 3.12351109e-03f, -3.29715535e-02f, 3.97025347e-02f, -7.64285102e-02f, -5.32544442e-02f, 1.48412094e-01f, 1.51031734e-02f, 1.38657242e-02f, 5.57801947e-02f,
  8.99096578e-02f, -3.46312709e-02f, -5.73806800e-02f, 9.48083177e-02f, 1.51670976e-02f, 6.48770295e-03f, -1.14299748e-02f, -6.66693747e-02f, -1.20671585e-01f, -5.97712286e-02f,
  -3.10444143e-02f, -4.74347919e-02f, 5.71604222e-02f, -3.30235213e-02f, 6.04716921e-03f, -5.65294875e-03f, -2.41336767e-02f, 3.96565907e-02f, -2.11263262e-02f, -1.66371763e-02f,
  -7.31736049e-02f, -3.26125473e-02f, 1.72312465e-02f, -7.78339477e-03f, -1.75103787e-02f, 1.39546636e-02f, 3.32549843e-03f, -4.06935886e-02f, 3.97939123e-02f, 7.49694603e-03f,
  -2.33956962e-03f, -2.61211265e-02f, 2.34733969e-02f, 1.16492165e-02f, -5.71755767e-02f, 9.09323432e-03f, 1.87678523e-02f, 3.17056216e-02f, -5.33353686e-02f, -5.55575974e-02f,
  -6.21227384e-01f, -4.65960413e-01f, -4.67535220e-02f, -1.05114132e-01f, -3.51653956e-02f, 1.60584189e-02f, -2.87414948e-03f, -5.14556617e-02f, -4.23791632e-02f, -2.98402626e-02f,
  -8.07076767e-02f, -1.47222141e-02f, -1.01526693e-01f, -2.62579061e-02f, -2.18864512e-02f, 2.40126047e-02f, -4.26769555e-02f, -4.54908349e-02f, -1.53706208e-01f, -2.24597957e-02f,
  -4.06593978e-02f, -1.83648914e-02f, 3.43539231e-02f, -7.78490724e-03f, -2.24722624e-02f, -9.62514430e-02f, -6.31185696e-02f, 7.55998353e-03f, 8.28285515e-03f, 6.85888007e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  6.59305513e-01f, 1.42245829e-01f, 1.48237810e-01f, 3.62914026e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  6.23891875e-03f, -7.24537730e-01f, 3.33109766e-01f, -7.18116641e-01f, -5.85163057e-01f, -4.23419513e-02f, 1.51032329e-01f, -8.15333247e-01f, 1.25408962e-01f, 7.05824018e-01f,
  -4.96462166e-01f, 7.77949572e-01f, -2.40261421e-01f, -1.10122673e-01f, 7.72763491e-01f, 8.71058643e-01f, 5.53690434e-01f, 8.57238293e-01f, 3.29465270e-01f, -2.97465086e-01f,
  -5.92031658e-01f, -1.54339731e+00f, -4.34994936e-01f, 4.97981936e-01f, -4.58566397e-01f, 6.90611660e-01f, -6.22153401e-01f, 8.10836136e-01f, -1.61658436e-01f, 2.53644735e-01f,
  9.86096084e-01f, -5.29590309e-01f, 1.18394554e-01f, -7.86423624e-01f, -6.82032347e-01f, -2.11471766e-01f, -5.85352778e-02f, 3.48149508e-01f, 3.35604519e-01f, 6.06544197e-01f,
  -2.93743342e-01f, -7.75289893e-01f, 1.59639958e-02f, 5.53859584e-02f, -6.43598020e-01f, -1.52180195e-01f, 1.33368266e+00f, -3.66483927e-01f, -3.07388276e-01f, -6.89798295e-01f,
  2.55958080e-01f, 1.62547946e-01f, 2.91585982e-01f, -2.60633975e-01f, -8.96941543e-01f, -7.66847491e-01f, 7.32575595e-01f, -9.83520210e-01f, -1.68333352e-01f, -7.38344371e-01f,
  -3.78188461e-01f, -3.66375744e-01f, -7.20662951e-01f, 1.19699001e+00f, 5.89759707e-01f, 4.80662197e-01f, -3.23297143e-01f, 6.45856857e-01f, -2.31188864e-01f, -6.90939724e-02f,
  1.23068833e+00f, -7.80212879e-01f, -1.44220963e-02f, 5.96809149e-01f, 4.08029079e-01f, -1.20908225e+00f, -1.16237603e-01f, -3.18041503e-01f, -1.65856495e-01f, 1.05477774e+00f,
  5.62117994e-01f, 5.42234898e-01f, -1.82850659e-01f, -7.76704252e-01f, 6.82683527e-01f, 6.80312365e-02f, -1.21217400e-01f, -6.93703532e-01f, 6.80885553e-01f, 7.36066341e-01f,
  1.86684757e-01f, 7.36326873e-01f, 1.07653987e+00f, 5.28681278e-01f, -2.11190879e-01f, -2.68884748e-01f, 3.80597860e-01f, -1.00292814e+00f, 7.32641637e-01f, 1.60420865e-01f,
  -3.45846593e-01f, 4.04773831e-01f, 1.04184628e+00f, 9.70915616e-01f, 5.66864371e-01f, -1.68514684e-01f, 8.09263408e-01f, -1.48961976e-01f, 8.94251704e-01f, -2.43290991e-01f,
  -2.42932886e-01f, -5.61852753e-01f, -1.59252107e-01f, -1.62197724e-01f, -3.69943455e-02f, -4.14466679e-01f, -2.14332938e-01f, -6.97048962e-01f, 4.59842920e-01f, -1.68609992e-01f,
  1.92721337e-01f, -3.83608192e-01f, -4.43486392e-01f, -4.69868630e-01f, -3.58393013e-01f, 1.29318345e+00f, -3.75556797e-01f, 3.93684894e-01f, -5.87682128e-01f, -3.56968313e-01f,
  -4.04686928e-01f, 2.56513327e-01f, -3.40135038e-01f, -2.25325041e-02f, -1.01071656e+00f, 1.08099687e+00f, -7.37118483e-01f, -8.62739563e-01f, -1.12123787e+00f, 6.08562946e-01f,
  9.38612223e-01f, -3.07119370e-01f, -4.55942243e-01f, -9.27275345e-02f, -1.28663588e+00f, 9.33563054e-01f, 6.71703458e-01f, 5.73921621e-01f, 5.90142548e-01f, 1.01614928e+00f,
  1.55180955e+00f, -2.75742654e-02f, -5.62757730e-01f, 6.36374056e-01f, 7.12382317e-01f, -3.76884460e-01f, -4.96156931e-01f, -1.28209263e-01f, -1.71439230e-01f, -5.44868529e-01f,
  4.66320425e-01f, 5.57883739e-01f, -7.29938969e-02f, -1.79983750e-01f, 1.15781009e+00f, 7.92643845e-01f, -1.08834422e+00f, -6.56666279e-01f, -9.98185098e-01f, -1.31506312e+00f,
  1.11324996e-01f, 3.34008217e-01f, -6.87633514e-01f, 4.19570506e-01f, -5.37114322e-01f, -2.74923146e-01f, -2.37476766e-01f, 5.34722090e-01f, -8.47683430e-01f, 3.63584369e-01f,
  -1.00919120e-01f, 5.86571515e-01f, -1.53793490e+00f, 8.63878250e-01f, 1.36719000e+00f, 1.02884150e+00f, 7.40018487e-01f, -8.36566150e-01f, -3.21950465e-01f, 2.12798893e-01f,
  -2.18830258e-01f, -3.46248358e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.98766065e-01f, 2.69629598e-01f, -1.66251853e-01f, -1.16099700e-01f, 2.99911108e-02f, -4.17798311e-01f, -1.18430167e-01f, -4.86298889e-01f, -1.87992223e-03f, 4.81602460e-01f,
  1.62744179e-01f, 5.63421130e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    