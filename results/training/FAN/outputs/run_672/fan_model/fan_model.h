/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.86589673e-01f, 4.58730102e-01f, 6.34491444e-02f, 2.67948564e-02f, 1.69856280e-01f, 1.25562638e-01f, 3.12692285e-01f, 1.60789654e-01f, -8.57549608e-02f, 1.50910944e-01f,
  1.37595236e-01f, -1.32926077e-01f, -2.47716531e-01f, -1.47495061e-01f, -1.82157069e-01f, 1.23042166e-02f, 9.88646075e-02f, -3.42027247e-01f, -2.93955922e-01f, -1.92069218e-01f,
  -4.24135774e-02f, -1.28549322e-01f, -9.38939154e-02f, -8.99474397e-02f, 1.46646708e-01f, -6.21732399e-02f, 2.43621737e-01f, 1.29489243e-01f, 1.34602070e-01f, -1.56601314e-02f,
  -2.00575516e-02f, 2.18291640e-01f, -2.34533235e-01f, -6.75812364e-02f, 1.45720363e-01f, 8.15506838e-03f, 5.41615933e-02f, -1.28083332e-02f, -1.52476868e-02f, 1.48453591e-02f,
  5.14721796e-02f, -3.38339582e-02f, -1.90730710e-02f, -2.98747700e-02f, 3.74687575e-02f, -5.32160625e-02f, 3.07196658e-02f, -7.84824044e-02f, 1.56764593e-02f, 1.41767398e-01f,
  7.75263160e-02f, 7.53711686e-02f, 2.37867851e-02f, 1.37396500e-01f, 7.27154687e-02f, -1.36903226e-01f, 4.46263179e-02f, 2.74829455e-02f, 6.50395527e-02f, 1.23924352e-01f,
  -5.46472967e-02f, 4.30712551e-02f, 3.40951458e-02f, 2.15706090e-03f, -1.74881201e-02f, 7.67161623e-02f, 7.08758738e-03f, 5.41363545e-02f, -7.01394156e-02f, -2.63339520e-04f,
  9.01235268e-02f, -5.38818017e-02f, 6.83528259e-02f, -1.78406537e-02f, -5.05249016e-02f, 6.11996725e-02f, 9.93603747e-03f, 1.92921273e-02f, -5.54756895e-02f, 7.23719150e-02f,
  7.13835331e-03f, -2.75882315e-02f, 3.92697453e-02f, 6.59168139e-02f, 2.52437517e-02f, -5.65297753e-02f, -2.89808051e-03f, -2.94131283e-02f, 5.37030399e-03f, 8.44717845e-02f,
  -5.23898117e-02f, -7.24448711e-02f, -5.86882904e-02f, -1.50120109e-01f, 8.55331048e-02f, 1.64121184e-02f, -1.96852125e-02f, 3.92172039e-02f, 6.40612692e-02f, -1.78436674e-02f,
  1.18403891e-02f, -2.07912214e-02f, 1.09162748e-01f, 3.64494249e-02f, -6.30050078e-02f, -2.32461933e-02f, 5.09691704e-03f, -7.17394352e-02f, 2.95300428e-02f, 5.41204475e-02f,
  1.45915234e-02f, 2.53604371e-02f, -1.54701307e-01f, -4.25350331e-02f, -3.04991286e-02f, -1.76090881e-01f, 8.59923139e-02f, -6.44341260e-02f, -2.40019104e-03f, -7.01370835e-02f,
  -4.61255722e-02f, 1.27109796e-01f, -6.03654757e-02f, 3.35277021e-01f, 3.42357755e-01f, 3.09882253e-01f, 4.05636489e-01f, 3.24624568e-01f, 2.82456785e-01f, 2.12261230e-01f,
  1.79181933e-01f, 3.38483661e-01f, 2.64448911e-01f, 3.27568084e-01f, 1.78625226e-01f, 2.82596797e-01f, 1.78201094e-01f, 1.62623167e-01f, 1.54438525e-01f, 4.29252446e-01f,
  5.05592287e-01f, 2.70990461e-01f, 2.04333961e-02f, 1.78293809e-01f, 2.44787827e-01f, 2.97876179e-01f, 1.53659150e-01f, 1.40989423e-01f, 1.94656119e-01f, 6.56307638e-02f,
  -7.85773527e-03f, -1.57990038e-01f, 2.40172625e-01f, 1.85030296e-01f, 8.58954713e-02f, 1.81652606e-01f, 1.76554531e-01f, 8.81718397e-02f, 1.70026541e-01f, 1.69883683e-01f,
  8.83651897e-02f, 1.13167703e-01f, 1.53154150e-01f, 1.23914152e-01f, 8.82519707e-02f, 7.97895566e-02f, 1.03000090e-01f, 1.03108950e-01f, 1.62058637e-01f, 4.53162231e-02f,
  2.61958331e-01f, 1.90888718e-01f, 1.83157414e-01f, 2.99457431e-01f, 4.52106185e-02f, 1.08992845e-01f, 5.24388291e-02f, 1.31971374e-01f, -8.13899271e-04f, 1.31856501e-01f,
  -1.18587213e-02f, -1.45290643e-01f, -8.07230473e-02f, -1.00972682e-01f, -7.56032616e-02f, -4.29411381e-02f, -1.10975772e-01f, -5.93231954e-02f, -7.81833380e-02f, -9.08670947e-02f,
  -1.43277124e-01f, -7.44031742e-02f, -1.09731704e-01f, -9.35969055e-02f, -8.64699557e-02f, -6.17070757e-02f, -9.75084081e-02f, -9.07188430e-02f, -1.41026929e-01f, -1.44144028e-01f,
  -1.28701702e-01f, -1.57597914e-01f, -1.30351037e-01f, -1.69967130e-01f, -1.82054192e-01f, -1.09321304e-01f, -1.49071336e-01f, -1.12212300e-01f, -1.71846420e-01f, -6.81649819e-02f,
  4.78814453e-01f, 3.33876051e-02f, 1.43098757e-01f, 7.92347491e-02f, 8.85463953e-02f, 2.94359773e-02f, 1.30660012e-01f, 1.08164176e-01f, 1.72560066e-01f, 1.95156872e-01f,
  6.69726953e-02f, 1.03388362e-01f, 1.69094741e-01f, 1.50985152e-01f, 2.14141682e-01f, 1.58008739e-01f, 2.48625159e-01f, 1.63098410e-01f, 2.25183323e-01f, 1.74184069e-01f,
  2.34367460e-01f, 3.27364385e-01f, 3.34145755e-01f, 3.97422493e-01f, 2.69095272e-01f, 3.57691854e-01f, 3.48788857e-01f, 2.39742517e-01f, 2.04281166e-01f, 4.30971116e-01f,
  2.54935026e-02f, 6.00496307e-02f, 5.73679917e-02f, 2.13864446e-01f, 9.20723826e-02f, 1.51888549e-01f, 1.68038800e-01f, 5.63647635e-02f, -5.95874339e-03f, 3.55866901e-03f,
  -1.08187251e-01f, -2.34986603e-01f, -1.12810500e-01f, -1.03324309e-01f, -9.38774571e-02f, 2.45771497e-01f, 2.76526839e-01f, 1.61253721e-01f, -9.68953827e-04f, 1.35994226e-01f,
  8.26449245e-02f, 1.16827644e-01f, 5.48779964e-02f, 4.98042740e-02f, 1.31275645e-02f, -5.37699237e-02f, 6.27226457e-02f, -1.19060026e-02f, -5.30924927e-03f, 1.22299917e-01f,
  -1.32976249e-01f, -9.22570825e-02f, -1.26037793e-03f, -5.14820553e-02f, -1.32108582e-02f, -8.12705234e-02f, 1.03171933e-02f, 7.22421259e-02f, -3.46695520e-02f, 1.63483135e-02f,
  -4.43567298e-02f, 4.30855751e-02f, -8.99714008e-02f, 2.23212708e-02f, 4.25075106e-02f, -8.99990350e-02f, 9.47510824e-02f, -3.72453220e-02f, -7.66313225e-02f, 2.53640749e-02f,
  7.70080164e-02f, 1.03630669e-01f, 5.89236505e-02f, -4.69124392e-02f, -9.96744446e-03f, 4.04021628e-02f, 6.15264624e-02f, -4.91704717e-02f, -1.27404720e-01f, 2.58772075e-02f,
  1.21525429e-01f, -6.34590611e-02f, 7.12463865e-03f, -1.66946799e-02f, -4.69858246e-03f, 2.49887500e-02f, -5.31039713e-03f, 4.10924964e-02f, 3.80440876e-02f, 5.02865389e-02f,
  -6.31437227e-02f, -7.63417408e-02f, -2.34989095e-02f, -4.64263409e-02f, 1.88081302e-02f, 1.72752991e-01f, -3.53006809e-03f, -1.36513747e-02f, 8.96305889e-02f, -2.86870170e-02f,
  -1.28341152e-03f, 4.16156761e-02f, 4.81572635e-02f, 3.34889330e-02f, -7.18429014e-02f, -5.02910540e-02f, 8.66499245e-02f, -1.05896808e-01f, 8.21945667e-02f, 3.89491394e-02f,
  -1.42192706e-01f, -2.23789006e-01f, 7.57444724e-02f, -1.70696285e-02f, 1.64456323e-01f, 3.24147902e-02f, -4.25460227e-02f, 7.14599192e-02f, 3.44389714e-02f, 3.42668444e-02f,
  -6.15279563e-02f, 7.44087994e-02f, -4.48061153e-02f, -1.18020982e-01f, 9.85374302e-03f, 4.41348292e-02f, 3.04809902e-02f, 3.32031511e-02f, -5.03871255e-02f, 7.78042246e-03f,
  1.27218410e-01f, 3.91927324e-02f, 7.02016056e-02f, 1.62573867e-02f, 2.28778813e-02f, 6.76811188e-02f, -3.72242332e-02f, 4.10565920e-02f, -3.50749381e-02f, 8.18041712e-02f,
  -6.19247973e-01f, -6.25622366e-03f, 3.23807716e-01f, -1.84443638e-01f, -5.12926951e-02f, 5.52222086e-03f, -5.05968230e-03f, -2.44756136e-03f, -3.36637534e-02f, 8.49882588e-02f,
  -2.97535770e-02f, -1.29795760e-01f, 8.08659121e-02f, -1.32260825e-02f, 5.20234033e-02f, 2.96119392e-01f, 2.71103978e-01f, 1.42641231e-01f, -2.56845839e-02f, 2.92690806e-02f,
  1.63348898e-01f, -1.16357483e-01f, -1.31342962e-01f, 2.07633600e-02f, 8.33230317e-02f, 1.18825389e-02f, 2.34234750e-01f, -1.62133516e-03f, 1.98353618e-01f, 2.24321365e-01f,
  1.25818148e-01f, -2.23181114e-01f, 2.58761775e-02f, -7.63253942e-02f, -7.53320754e-02f, -2.32986640e-02f, -1.88445821e-02f, 7.37098977e-02f, -1.02915645e-01f, -5.02953269e-02f,
  -4.82449643e-02f, 2.27408577e-02f, -7.28413137e-03f, 6.34026006e-02f, -2.37779152e-02f, -6.11918233e-02f, -6.78511560e-02f, 2.03256924e-02f, 9.05834213e-02f, 8.78579244e-02f,
  1.62176415e-01f, -1.26843434e-02f, 1.80918518e-02f, -5.82365207e-02f, 4.86524813e-02f, 6.91716149e-02f, 6.90730638e-04f, 1.62947997e-02f, 9.22627449e-02f, -4.02040444e-02f,
  -1.68478563e-02f, -4.19306522e-03f, 4.64858823e-02f, -6.06261892e-03f, -9.17665735e-02f, -3.54955019e-03f, -2.61282474e-02f, 9.00945961e-02f, -9.84565988e-02f, -8.01527221e-03f,
  2.26179976e-02f, -3.32661718e-02f, -3.22361216e-02f, 5.47410548e-02f, 9.51697007e-02f, -3.03503312e-02f, 2.47305185e-02f, 9.10868421e-02f, 3.45678851e-02f, 5.78613244e-02f,
  -9.96699091e-03f, 4.37278859e-02f, -1.06096119e-02f, 1.16019629e-01f, 5.20535670e-02f, 1.05145253e-01f, -3.53398025e-02f, 2.96562072e-02f, -6.21956475e-02f, -2.33183000e-02f,
  -1.47111773e-01f, -7.33068436e-02f, 6.45394772e-02f, 1.01935819e-01f, 8.61699358e-02f, 6.01400807e-02f, -1.84552697e-03f, 2.29372289e-02f, 1.19485378e-01f, 5.14979996e-02f,
  7.56324232e-02f, 5.28368019e-02f, -3.82448100e-02f, 2.95490231e-02f, -1.92528721e-02f, 6.73723221e-02f, 9.19015184e-02f, 9.10015628e-02f, 1.56515524e-01f, -6.90041156e-03f,
  6.95497021e-02f, 6.35768985e-03f, 7.26665556e-02f, 1.03512101e-01f, -5.62121123e-02f, 5.51164113e-02f, 1.44016249e-02f, 4.60789017e-02f, -1.78504083e-02f, 7.51787871e-02f,
  5.76715730e-02f, -3.70647192e-01f, 1.75405651e-01f, 4.66131233e-02f, -1.43124582e-02f, 1.76688984e-01f, 2.14495108e-01f, 1.26792327e-01f, -1.01680927e-01f, 2.34204177e-02f,
  -2.19641656e-01f, -2.32148364e-01f, -9.04655382e-02f, 9.99318785e-04f, 1.90596372e-01f, 1.54919788e-01f, 1.93433106e-01f, 3.12714815e-01f, 2.16743529e-01f, 1.26765501e-02f,
  -1.10586070e-01f, -9.65170860e-02f, 1.71587318e-02f, 3.82370241e-02f, -1.38738498e-01f, 6.75881281e-03f, 4.67957072e-02f, -4.20728624e-02f, -2.00412516e-02f, -5.78661673e-02f,
  3.07765622e-02f, -2.39910811e-01f, 2.73127202e-02f, -1.10148631e-01f, -7.99446627e-02f, 3.76638462e-04f, -2.14469316e-03f, -3.70068215e-02f, -2.57619959e-03f, -1.02626577e-01f,
  -4.41806316e-02f, -7.30022043e-03f, 1.54182464e-02f, -1.15245111e-01f, -8.41713175e-02f, -1.08993864e-02f, -4.28861678e-02f, -3.34195644e-02f, -1.88524462e-02f, -1.05964378e-01f,
  -1.21203758e-01f, -1.52529091e-01f, -3.99798453e-02f, -5.87993190e-02f, -2.21188609e-02f, 2.74523441e-02f, -1.72906574e-02f, 2.72948444e-02f, 9.44781005e-02f, 1.59537345e-02f,
  1.72678396e-01f, -7.03249723e-02f, 2.58734152e-02f, 2.36375891e-02f, -4.03994396e-02f, -5.08989114e-03f, -1.06837578e-01f, -1.70424022e-02f, 3.18494365e-02f, 3.73696834e-02f,
  -1.39094731e-02f, 1.36408759e-02f, -4.22782153e-02f, -6.42876104e-02f, -5.64471819e-02f, -1.03106033e-02f, -6.88567013e-02f, 1.17233512e-03f, -7.79396594e-02f, -2.51847319e-02f,
  -3.70419398e-02f, 2.22913865e-02f, -7.25255385e-02f, 1.02495365e-02f, -7.40910619e-02f, -6.62525147e-02f, -6.25257706e-03f, -7.88336769e-02f, -2.33519580e-02f, -1.53210387e-01f,
  3.28761642e-04f, 1.45386249e-01f, 7.00856224e-02f, -1.39422165e-02f, -4.24525179e-02f, -2.84649301e-02f, -7.85742477e-02f, -1.20040253e-01f, -1.49629503e-01f, -2.43228540e-04f,
  -6.47145659e-02f, -3.40811536e-02f, 4.40804772e-02f, -9.80662927e-02f, 5.58244288e-02f, -5.34231476e-02f, -1.04155533e-01f, -6.60294946e-03f, -7.06581548e-02f, -1.25572264e-01f,
  -2.61957590e-02f, 7.14897215e-02f, 1.17489904e-01f, 1.03749052e-01f, -6.90678731e-02f, 3.50305326e-02f, 5.53495586e-02f, 1.68930534e-02f, 2.01156363e-01f, 1.49705067e-01f,
  -9.33499858e-02f, -2.28377385e-03f, -3.26248407e-01f, -1.09550450e-02f, 4.05764282e-02f, 1.50470182e-01f, 1.77493781e-01f, 1.94045931e-01f, 2.32589364e-01f, 7.51207918e-02f,
  1.17028214e-03f, -5.11183441e-02f, -4.76325862e-02f, 5.60403764e-02f, 5.01543283e-02f, 8.26476663e-02f, -8.28269571e-02f, -9.62904990e-02f, -2.45989263e-02f, 1.75490528e-01f,
  1.42908260e-01f, 9.19121653e-02f, -7.69103467e-02f, 5.58168963e-02f, -3.05101778e-02f, 3.81945297e-02f, -1.22625321e-01f, -6.66346699e-02f, -6.96876496e-02f, -6.68125600e-02f,
  -3.53290409e-01f, -6.20886162e-02f, 1.01240084e-01f, 1.31868124e-01f, 5.05272411e-02f, 1.27596021e-01f, 6.92462847e-02f, -5.37914261e-02f, 2.72333771e-02f, -9.74456780e-03f,
  4.60531153e-02f, 1.05694711e-01f, -1.21581857e-03f, 1.60532743e-01f, 8.59939456e-02f, 4.48344387e-02f, 1.37360841e-01f, -4.10431027e-02f, 1.16775967e-01f, 1.49652764e-01f,
  1.81855977e-01f, 6.96509238e-03f, -5.24086058e-02f, 1.23538800e-01f, 1.61205649e-01f, -3.95701081e-02f, -4.06025313e-02f, -1.46479327e-02f, 1.10743105e-01f, 1.00362934e-02f,
  -6.67503029e-02f, -1.71019554e-01f, -1.06279671e-01f, -9.85935479e-02f, -1.28918827e-01f, -5.68965524e-02f, -1.11038744e-01f, -5.88506684e-02f, -1.68320492e-01f, -9.57612097e-02f,
  -1.69322044e-01f, -1.09471031e-01f, -7.94715621e-03f, -1.16951697e-01f, -9.97053385e-02f, -9.72582102e-02f, -4.36667651e-02f, -6.02072552e-02f, -8.46035033e-02f, -1.26142517e-01f,
  -1.60310924e-01f, -1.24274813e-01f, -1.69935256e-01f, -7.30250822e-03f, -1.56699717e-02f, -8.78221542e-02f, -6.93610981e-02f, -1.12481788e-01f, -4.30387966e-02f, -7.40603283e-02f,
  1.53343186e-01f, 1.13277756e-01f, 7.62651563e-02f, 1.49073884e-01f, 5.21299168e-02f, 1.52379945e-01f, 1.61702171e-01f, 1.61927089e-01f, 2.11406890e-02f, 1.75878763e-01f,
  3.74023207e-02f, 1.05746001e-01f, 9.57172588e-02f, 5.67960069e-02f, 4.94674817e-02f, 5.96132539e-02f, 2.38171652e-01f, 6.71090931e-02f, 9.74066183e-02f, 1.29956976e-01f,
  2.21634284e-01f, 1.57641947e-01f, 1.01977214e-01f, 1.19345784e-01f, 1.90036565e-01f, 3.25605609e-02f, 1.49860129e-01f, 8.04512501e-02f, 3.84954214e-02f, 2.21666425e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.68194759e-01f, -3.77971202e-01f, -3.75086874e-01f, -2.10372284e-01f, -3.57490361e-01f, -2.29591638e-01f, -4.02397633e-01f, -1.36813954e-01f, -2.92689577e-02f, -3.35529566e-01f,
  -4.11513634e-02f, 3.30430239e-01f, 1.60345241e-01f, 1.09581344e-01f, 1.69318408e-01f, -5.14019847e-01f, -5.01498938e-01f, -7.55883083e-02f, 1.63148746e-01f, -3.85627002e-02f,
  -1.53522074e-01f, -2.52119154e-01f, 8.13744217e-02f, -6.48562461e-02f, -4.04957503e-01f, -1.71220571e-01f, -4.43019539e-01f, -3.78503054e-01f, -2.30095804e-01f, -5.22329509e-01f,
  -4.12783116e-01f, -6.30332157e-02f, 1.04825139e-01f, 1.21699460e-01f, -1.58047229e-01f, 9.86154154e-02f, 2.20250897e-02f, 6.28864542e-02f, 8.62172619e-02f, -1.01221576e-01f,
  7.47639239e-02f, 2.60066092e-01f, 2.13820323e-01f, -6.44174069e-02f, -4.54066284e-02f, 2.64822915e-02f, -7.10618943e-02f, 7.48802796e-02f, -2.74838656e-02f, -1.34314388e-01f,
  1.02221137e-02f, 7.06680194e-02f, 8.94344673e-02f, -1.79683808e-02f, 9.21917036e-02f, 1.44935772e-01f, -2.37552226e-01f, -2.71934923e-02f, 9.57043394e-02f, -3.63025308e-01f,
  8.23502466e-02f, -1.12856366e-01f, -2.51236446e-02f, 5.09481952e-02f, 5.40802479e-02f, 1.35794347e-02f, -1.80811454e-02f, -2.36833524e-02f, 8.01164657e-02f, -2.44782716e-02f,
  6.75651357e-02f, -4.15837020e-02f, 1.19023778e-01f, -3.82367410e-02f, -1.66184023e-01f, 1.04208276e-01f, 5.74280992e-02f, -2.27727536e-02f, -6.73298687e-02f, 4.49037086e-03f,
  9.27258506e-02f, -4.31741104e-02f, 2.85810954e-03f, 1.54498937e-02f, -5.84224146e-03f, -5.34497388e-02f, 8.84039700e-02f, 8.20934400e-02f, 9.43501666e-02f, 1.07803352e-01f,
  -1.36587754e-01f, 1.30052030e-01f, -1.79561898e-01f, 1.50221556e-01f, -1.26857668e-01f, -2.40614042e-02f, -2.77987663e-02f, -7.22408444e-02f, 7.40776509e-02f, -9.71787348e-02f,
  4.01826389e-03f, 1.85941681e-01f, 5.89449629e-02f, -3.00461780e-02f, 6.35004193e-02f, 1.03596024e-01f, -2.35305578e-02f, -1.74946450e-02f, -4.84004542e-02f, -3.37130427e-02f,
  -1.70006648e-01f, 7.91843282e-04f, 1.33919105e-01f, -3.93802859e-02f, 7.71629903e-03f, 2.37715885e-01f, -2.46287227e-01f, -1.97633803e-01f, 1.06728122e-01f, -4.17839646e-01f,
  1.21815413e-01f, 5.76873660e-01f, 4.52086896e-01f, -2.93823361e-01f, 7.30962213e-03f, 1.60852179e-01f, 3.71759653e-01f, 1.05885252e-01f, -2.01205552e-01f, 1.49486169e-01f,
  -1.23786785e-01f, -3.91884714e-01f, -8.79239663e-02f, -1.45414934e-01f, 9.73267332e-02f, 2.10804164e-01f, 2.04387620e-01f, 7.85932466e-02f, -2.02560320e-01f, -3.46854895e-01f,
  -2.83805966e-01f, -9.32955667e-02f, -2.39148387e-03f, -5.94861060e-03f, -5.00453562e-02f, -1.50418013e-01f, 2.18115926e-01f, 9.01271403e-02f, 1.54835925e-01f, 1.62706614e-01f,
  -6.13697655e-02f, 5.28189421e-01f, -4.01065707e-01f, -2.64409810e-01f, 1.69474542e-01f, 4.29774076e-02f, 5.86435981e-02f, 1.22856997e-01f, -6.65646465e-03f, 6.84724897e-02f,
  -3.76823917e-02f, -2.13834289e-02f, 8.70893151e-02f, -1.26230763e-02f, 1.26161560e-01f, -6.26502037e-02f, 1.28999174e-01f, 7.20703462e-03f, -1.96384758e-01f, 4.70481291e-02f,
  -1.19898096e-01f, -1.00455016e-01f, 1.17808700e-01f, -1.12825774e-01f, 3.87249812e-02f, -3.92402947e-01f, 1.07796863e-01f, 3.42118926e-02f, 8.98360386e-02f, 4.61860225e-02f,
  -1.38069645e-01f, 9.34282094e-02f, 1.83899090e-01f, 5.24625890e-02f, -6.34227172e-02f, 6.33415207e-02f, 1.69686098e-02f, 3.51148397e-02f, -1.12037361e-01f, 4.47503962e-02f,
  2.77840835e-03f, -6.88047111e-02f, 8.42501819e-02f, 9.32362899e-02f, -9.01756808e-02f, 4.04224619e-02f, -2.32474394e-02f, 5.76535352e-02f, -4.31908295e-02f, 4.76510264e-02f,
  -1.27562493e-01f, 2.88598109e-02f, -4.89212945e-02f, -7.04174070e-03f, 2.19385531e-02f, 1.10270672e-01f, -7.52692148e-02f, -7.06557324e-03f, -7.59145319e-02f, 1.61589384e-01f,
  -4.25494254e-01f, 1.26169652e-01f, -2.57587194e-01f, 1.86739385e-01f, 2.75061160e-01f, 3.41263115e-02f, 6.45015165e-02f, 1.02888554e-01f, 3.86116505e-02f, 1.90731492e-02f,
  2.79605351e-02f, 1.21245138e-01f, 2.28755042e-01f, 1.26628177e-02f, -2.25035712e-01f, -1.27185896e-01f, -1.09122895e-01f, -1.07679807e-01f, -2.53097147e-01f, 6.61015213e-02f,
  -7.61537328e-02f, -2.96155125e-01f, -5.38279116e-01f, -2.77472645e-01f, -2.49794722e-01f, -5.01913607e-01f, -1.48259670e-01f, -2.10561380e-01f, -3.21321577e-01f, -3.28135312e-01f,
  8.69849980e-01f, -3.76285940e-01f, 2.75745988e-01f, 1.78944051e-01f, 1.14342272e-01f, 1.18039317e-01f, -9.18826163e-02f, 1.98999122e-01f, 1.69860706e-01f, 2.51352470e-02f,
  -1.62263885e-01f, 2.42806263e-02f, 5.25138825e-02f, 1.02501035e-01f, -3.11052892e-02f, -8.73237327e-02f, 3.43865119e-02f, 2.55375654e-01f, 3.30225587e-01f, 1.66228980e-01f,
  -1.40483230e-01f, -5.85822389e-03f, 1.17294550e-01f, 9.02710184e-02f, -1.03802875e-01f, 9.71641168e-02f, -3.54538560e-02f, -1.31303474e-01f, -1.36374384e-01f, -1.92060426e-01f,
  -2.43726298e-01f, -7.15337992e-02f, 1.48019955e-01f, -6.78762570e-02f, -1.74320474e-01f, 5.11102192e-02f, 1.09879039e-01f, -5.30538447e-02f, -1.67688861e-01f, -1.33719146e-01f,
  -1.02659583e-01f, -8.78222659e-02f, -5.81155978e-02f, 6.33326685e-03f, -7.27056265e-02f, 1.08358366e-02f, -9.83503312e-02f, 1.43143917e-02f, -1.41380548e-01f, -1.20565914e-01f,
  -1.41390294e-01f, -8.81044120e-02f, -3.61645082e-03f, -8.43218863e-02f, 3.51608694e-02f, 9.35118571e-02f, -1.08227611e-01f, -3.38390074e-03f, 4.08175364e-02f, 9.39870402e-02f,
  1.02233402e-02f, 1.41164556e-01f, 1.40359879e-01f, 1.01188950e-01f, 2.00697511e-01f, 2.04643935e-01f, 3.12851258e-02f, -1.45147881e-02f, 1.04773544e-01f, -1.27858669e-02f,
  -2.15375330e-02f, 7.65942633e-02f, 1.57665282e-01f, 7.66051039e-02f, 4.12715189e-02f, -7.65089765e-02f, -3.18175144e-02f, 4.86292988e-02f, -8.63954499e-02f, 1.36840893e-02f,
  1.42691284e-02f, -6.65898174e-02f, -2.00657323e-01f, -5.04066236e-02f, -1.12713046e-01f, 5.64430356e-02f, -3.56826819e-02f, -8.94125700e-02f, -7.33688399e-02f, -1.78431407e-01f,
  -3.04726005e-01f, 1.19880944e-01f, 1.90032080e-01f, 6.03417084e-02f, 3.85471946e-03f, -1.37889475e-01f, 1.96292028e-01f, -7.09875748e-02f, -2.05837950e-01f, -6.59801066e-02f,
  -5.42217679e-02f, -3.12509611e-02f, -9.61085930e-02f, -1.04172097e-03f, 7.17914402e-02f, 5.32906801e-02f, -8.11368972e-02f, 1.21401660e-01f, -2.75500473e-02f, -5.95495775e-02f,
  -4.53131944e-02f, 1.29076988e-01f, 1.82230353e-01f, 2.14713484e-01f, 1.82972655e-01f, 1.95916757e-01f, -3.17691849e-03f, 3.30481529e-02f, 3.62090506e-02f, 2.66269416e-01f,
  -1.31773660e-02f, -2.78225809e-01f, -6.21214807e-01f, 2.31912404e-01f, 3.01347435e-01f, -2.46114358e-01f, -3.57096463e-01f, -4.10582542e-01f, -6.56337440e-02f, -1.18761688e-01f,
  9.80550647e-02f, 1.95093319e-01f, 1.10535599e-01f, 1.01547256e-01f, -1.75903797e-01f, -2.29827747e-01f, 1.10634930e-01f, 5.53647988e-02f, 1.77958347e-02f, 1.70922741e-01f,
  2.38796800e-01f, 2.14092493e-01f, 6.80096671e-02f, 1.79036483e-02f, 2.38428250e-01f, 3.16366524e-01f, -1.75258502e-01f, 1.37040153e-01f, 4.90705930e-02f, 2.50677019e-01f,
  -3.10550958e-01f, -3.40223044e-01f, -8.52979496e-02f, 1.78761512e-01f, 9.71187353e-02f, -2.36175746e-01f, -2.22444370e-01f, -1.28847480e-01f, -2.70027239e-02f, -1.00417390e-01f,
  1.33988693e-01f, -4.67062853e-02f, 1.69664156e-02f, 4.34677452e-02f, -1.13476053e-01f, -2.42108166e-01f, -5.64741120e-02f, -2.51896232e-01f, -2.05943614e-01f, -1.17183872e-01f,
  4.31953579e-01f, 2.40375221e-01f, -2.72296160e-01f, -2.18794942e-01f, -3.72998387e-01f, 9.55760181e-02f, -1.92309901e-01f, -2.00865537e-01f, -3.74919474e-01f, -1.59583628e-01f,
  -2.85807420e-02f, 1.43533200e-02f, 4.30503078e-02f, -6.10819608e-02f, 1.94339663e-01f, -4.07898100e-03f, -2.52250973e-02f, 1.54224858e-01f, 1.11859262e-01f, -4.67695761e-03f,
  -5.58672398e-02f, -2.32750885e-02f, -1.17447264e-01f, -1.81557462e-01f, -1.94877591e-02f, -9.44057778e-02f, 7.25167394e-02f, 4.66186507e-03f, 4.60096672e-02f, -1.76576361e-01f,
  -1.37337446e-01f, -1.39961541e-01f, -4.43238355e-02f, -1.73540935e-02f, -1.10086061e-01f, -2.19827086e-01f, 5.87061606e-02f, 3.30621116e-02f, 4.13960554e-02f, -7.90740773e-02f,
  -1.70397058e-01f, -2.22418875e-01f, -7.23691806e-02f, 5.05687669e-03f, 4.06749435e-02f, 2.15590335e-05f, 1.61545891e-02f, -4.20387872e-02f, -1.53296357e-02f, 2.63072252e-02f,
  -8.76374170e-02f, -1.21454723e-01f, -1.29392609e-01f, -6.57159165e-02f, -2.25389436e-01f, -2.15838060e-01f, 7.93451518e-02f, 9.30119678e-02f, -9.44634452e-02f, -7.26711601e-02f,
  1.09532826e-01f, 3.14307422e-03f, -1.10513560e-01f, -2.15669990e-01f, -1.16760843e-01f, 9.34967250e-02f, -1.64468423e-01f, -2.40645930e-01f, -2.89485931e-01f, -2.50825167e-01f,
  8.30320716e-01f, -1.91368133e-01f, -8.42892468e-01f, 3.06604147e-01f, -3.31010222e-01f, -4.52709198e-01f, -4.82854366e-01f, 3.71963270e-02f, 2.43581951e-01f, -3.12389821e-01f,
  -3.65799040e-01f, -3.10695749e-02f, -4.90850816e-03f, -1.09431431e-01f, -1.16379797e-01f, -4.95934576e-01f, -5.49988627e-01f, -2.07631856e-01f, -2.07288399e-01f, -2.31793001e-01f,
  -7.70434812e-02f, 6.57430887e-02f, 2.58096009e-01f, 7.14610517e-02f, -6.37242869e-02f, -1.00366928e-01f, -3.49646717e-01f, -2.09220767e-01f, -3.24476779e-01f, -3.06662768e-01f,
  -3.95186126e-01f, 4.94626770e-03f, -2.95075804e-01f, 9.60835889e-02f, -2.39005849e-01f, 1.29179537e-01f, -3.33118550e-02f, 3.95047888e-02f, 1.15322791e-01f, -4.34375629e-02f,
  -2.09855705e-01f, -9.20466632e-02f, 1.31351724e-01f, -2.31545746e-01f, -5.03628366e-02f, -3.80242616e-02f, -3.73393074e-02f, -7.00971261e-02f, -1.37071833e-01f, -2.14870244e-01f,
  -1.63143516e-01f, -2.27894217e-01f, -9.84392613e-02f, -1.21007770e-01f, -1.23521984e-01f, -4.07876633e-03f, -2.28347272e-01f, -4.26551700e-02f, -6.76180199e-02f, 9.41477045e-02f,
  -1.87037326e-02f, 3.03734671e-02f, -6.72137290e-02f, 9.92040858e-02f, 6.56644776e-02f, -8.03557113e-02f, 6.00469438e-03f, -2.58477982e-02f, -6.19125962e-02f, -1.96807664e-02f,
  -1.56038210e-01f, -4.64315750e-02f, -1.09935729e-02f, 2.81064808e-02f, -8.62477645e-02f, 1.15793562e-02f, -4.63005006e-02f, -7.13184401e-02f, -5.46392575e-02f, 7.02555403e-02f,
  1.08719978e-03f, -4.13107825e-03f, 8.58325213e-02f, 4.54591960e-02f, -9.30020213e-02f, -8.56882855e-02f, 1.08510833e-02f, 2.14098301e-02f, 6.70443252e-02f, -4.16345298e-02f,
  3.14606160e-01f, -2.54845858e-01f, 1.19365424e-01f, 3.26762386e-02f, -1.17015667e-01f, -1.38678387e-01f, -1.18877470e-01f, 2.81916913e-02f, 1.11267865e-01f, 7.15844054e-03f,
  -1.72267556e-01f, 5.11346050e-02f, 3.75291123e-03f, 2.82387827e-02f, -1.30225286e-01f, -9.95676592e-02f, 1.85458583e-03f, -1.02767661e-01f, -1.30642354e-01f, -8.97362605e-02f,
  -3.41906324e-02f, 3.92434821e-02f, 2.02570722e-01f, 1.04626954e-01f, 5.91098368e-02f, 9.90601778e-02f, -8.76401365e-02f, -1.22605383e-01f, 5.02661504e-02f, 1.58574507e-01f,
  -4.74407941e-01f, -4.23995346e-01f, -1.30063206e-01f, -3.58655483e-01f, -2.38473967e-01f, -1.30819336e-01f, -3.56329262e-01f, -6.52479082e-02f, -4.58665602e-02f, -3.93653065e-01f,
  -1.91983506e-01f, -6.64271638e-02f, -1.84831083e-01f, -9.06894431e-02f, -1.38099477e-01f, -3.72370392e-01f, -2.71854311e-01f, -1.43559068e-01f, -1.17058819e-02f, -1.04385294e-01f,
  -2.89520323e-01f, -2.36675948e-01f, -8.12423006e-02f, 7.75550306e-02f, -1.09384038e-01f, 6.02598581e-03f, 2.32896977e-03f, -1.30241469e-01f, 1.72648374e-02f, -2.08834291e-01f,
  -3.54006588e-01f, -9.58831981e-02f, 1.12707727e-01f, 1.37332622e-02f, -9.21586622e-03f, -1.06077911e-02f, -1.74063772e-01f, 2.97214929e-02f, -3.41659971e-02f, -9.51413065e-02f,
  -1.24127559e-01f, -4.47882451e-02f, 3.89891081e-02f, -1.12101018e-01f, -1.03155762e-01f, -8.10890347e-02f, -3.10770273e-02f, 1.46362251e-02f, 1.11199087e-02f, 9.41900834e-02f,
  -5.78064285e-02f, -1.63866095e-02f, -2.26381421e-02f, 1.82696164e-01f, 1.91120759e-01f, -4.41658348e-02f, 1.14150397e-01f, 1.60787553e-01f, 2.40802318e-01f, -1.11778572e-01f,
  5.91952614e-02f, -4.49783914e-02f, -1.30306268e-02f, 4.22106124e-02f, 1.78944392e-04f, 6.79195896e-02f, 2.74463501e-02f, -1.05318405e-01f, 5.18261567e-02f, -4.71702665e-02f,
  -8.76770355e-03f, 6.32715374e-02f, -7.11034387e-02f, -4.66257520e-02f, -6.13286011e-02f, -4.85539660e-02f, -5.28066643e-02f, 1.47343697e-02f, 9.05487388e-02f, 1.63875185e-02f,
  -7.55212530e-02f, 5.16431853e-02f, 2.67522931e-02f, 4.29339185e-02f, 1.83894206e-02f, -1.34565113e-02f, -3.62585261e-02f, 4.73980196e-02f, 7.57222623e-02f, -5.79153076e-02f,
  -2.67659634e-01f, 2.75450408e-01f, -3.68411124e-01f, -2.33205110e-02f, -6.19384423e-02f, 1.11372188e-01f, -9.78809297e-02f, 4.46929634e-02f, -9.69173461e-02f, -2.44349808e-01f,
  -5.27347252e-02f, -1.08450271e-01f, -7.72752389e-02f, 6.95457216e-03f, -5.42528257e-02f, -3.14716715e-04f, -3.65656056e-02f, -1.99262708e-01f, 4.60676998e-02f, 1.27544805e-01f,
  5.20879030e-02f, -1.16325863e-01f, -3.10294330e-01f, -4.90818061e-02f, 6.57004789e-02f, -1.48296863e-01f, -1.30341619e-01f, -1.31420288e-02f, -2.46469937e-02f, -3.14507365e-01f,
  7.24795878e-01f, -7.55697712e-02f, -3.22984904e-02f, 6.98116496e-02f, -1.54627651e-01f, -3.43560904e-01f, -4.39483821e-01f, -9.77676436e-02f, 4.05354537e-02f, 1.45165548e-02f,
  6.63195699e-02f, 1.79954574e-01f, 2.22055405e-01f, 1.25350982e-01f, 1.25913650e-01f, -1.13509938e-01f, 2.68348102e-02f, 2.09937245e-01f, 2.29625747e-01f, 7.91679770e-02f,
  1.62693366e-01f, 2.88442761e-01f, 3.39115590e-01f, 1.70151353e-01f, 3.50602977e-02f, 8.74979272e-02f, -3.12063936e-03f, -3.10435630e-02f, 6.17497005e-02f, -2.97917542e-03f,
  -2.81454436e-02f, 1.31921589e-01f, -4.83447220e-03f, 1.53304383e-01f, 4.55550961e-02f, 1.16865605e-01f, 1.27341762e-01f, -5.99162206e-02f, -5.76757118e-02f, -1.70486793e-02f,
  -3.47814411e-02f, 8.67246836e-02f, 1.55663148e-01f, -7.06126317e-02f, 6.46633953e-02f, 5.10023860e-03f, 7.70700574e-02f, 1.12077899e-01f, -2.53645722e-02f, 8.34935904e-02f,
  -4.83765490e-02f, -9.41858515e-02f, -2.08751559e-01f, -1.41328126e-01f, 7.15530887e-02f, 1.30945191e-01f, -9.76781994e-02f, -5.70894405e-03f, 6.27717674e-02f, 1.49168342e-01f,
  7.80684277e-02f, 2.64494419e-01f, 2.02288896e-01f, 5.27249910e-02f, 1.18098944e-01f, 1.12536214e-01f, -3.05454619e-02f, -1.11200184e-01f, 1.64138466e-01f, 2.15924382e-01f,
  -9.84757170e-02f, 3.63136865e-02f, -2.87710428e-02f, 1.65492166e-02f, 1.51913241e-01f, 1.50360569e-01f, -1.50516465e-01f, -1.30703375e-01f, 8.66020024e-02f, 3.76146846e-02f,
  1.40479982e-01f, -7.46780783e-02f, 5.57263233e-02f, 4.71411981e-02f, -7.78486282e-02f, 6.79562427e-03f, 1.16658695e-01f, 1.56796664e-01f, 1.65193394e-01f, 7.73312245e-03f,
  -1.85686320e-01f, 2.54853964e-01f, 1.23653308e-01f, 5.77099882e-02f, -2.01088563e-02f, 7.41562098e-02f, 1.76217914e-01f, -4.54057977e-02f, -6.43828884e-02f, -1.14417508e-01f,
  -1.00716956e-01f, -1.78420432e-02f, -1.82227492e-02f, 4.11748625e-02f, 1.06265604e-01f, -1.15436293e-01f, 1.32625878e-01f, -6.52904361e-02f, -1.77166104e-01f, -1.39570579e-01f,
  -3.55650671e-02f, -7.64746591e-02f, -9.96345505e-02f, -2.36632660e-01f, -1.82860672e-01f, -2.87805516e-02f, 1.79630273e-03f, -1.10813625e-01f, -1.13229141e-01f, 1.00188278e-01f,
  5.69405109e-02f, 6.47209108e-01f, -3.69753808e-01f, 7.38842636e-02f, -1.03307262e-01f, -7.71916956e-02f, 5.53255856e-01f, 2.74015486e-01f, 1.39358565e-01f, 3.81184429e-01f,
  5.56642488e-02f, -4.69706565e-01f, -3.87239814e-01f, -2.85554826e-01f, -1.08490430e-01f, 6.12279534e-01f, 3.72597486e-01f, -4.64559376e-01f, -6.85982883e-01f, -1.33409381e-01f,
  1.58772379e-01f, 8.59808624e-02f, -4.30303328e-02f, -9.56554338e-02f, 5.50879687e-02f, -2.76372612e-01f, 1.23405248e-01f, -2.86697913e-02f, -1.29198715e-01f, -2.72858553e-02f,
  -3.98365229e-01f, -1.60403885e-02f, -3.72501165e-01f, -1.91130504e-01f, -1.06495880e-01f, -5.36530279e-02f, -6.15629181e-02f, -1.51846528e-01f, -1.35494694e-01f, 1.20552734e-01f,
  -2.89607137e-01f, -2.29629632e-02f, -1.46084234e-01f, -2.04031572e-01f, -2.12449864e-01f, -8.77936482e-02f, 4.02458794e-02f, -9.80447456e-02f, -1.87048689e-01f, 6.05652407e-02f,
  1.32620305e-01f, -1.84413955e-01f, -2.02459544e-01f, 1.96157515e-01f, -5.18129319e-02f, -3.63826245e-01f, -9.61192176e-02f, -2.39781767e-01f, -3.79293680e-01f, 2.83910841e-01f,
  2.57304132e-01f, 7.90986344e-02f, -6.83683082e-02f, 5.06986380e-02f, 1.50299951e-01f, -4.84044962e-02f, -1.57072383e-03f, -2.23646080e-03f, -4.68152277e-02f, 4.30292031e-03f,
  3.73872705e-02f, 8.66473317e-02f, -7.44594708e-02f, 8.72096270e-02f, 4.70750183e-02f, -1.04292065e-01f, 7.48036522e-03f, 2.03284115e-01f, 9.25113261e-03f, 5.01427101e-03f,
  -1.56839371e-01f, -1.64094213e-02f, -1.39870226e-01f, -5.20971231e-02f, 6.36808155e-03f, -1.21496832e-02f, -8.20929855e-02f, 8.78855679e-03f, -2.58060619e-02f, -1.34697380e-02f,
  -5.12621664e-02f, -2.60265201e-01f, 1.41769588e-01f, 5.04804403e-03f, 3.84351760e-02f, -2.87957583e-02f, -2.40338985e-02f, 1.01777218e-01f, 1.59714855e-02f, 9.33139101e-02f,
  -2.71012262e-02f, 6.14548922e-02f, -9.74476710e-02f, 8.79831612e-02f, -1.49828076e-01f, 1.23735918e-02f, 4.02397692e-01f, -6.76851347e-02f, 5.41834272e-02f, 5.64825870e-02f,
  3.58006597e-01f, 1.91382587e-01f, 7.38043934e-02f, 9.97914895e-02f, 1.19328581e-01f, -1.66400060e-01f, -5.41187115e-02f, -2.28292700e-02f, -1.08549878e-01f, 6.18254721e-01f,
  1.43691748e-01f, 2.48680592e-01f, 2.35760242e-01f, 4.71714549e-02f, 4.83928651e-01f, 5.91340140e-02f, -9.32059512e-02f, -3.62463027e-01f, -1.81573629e-02f, 9.46090296e-02f,
  4.15997833e-01f, 4.32950445e-02f, -1.65090725e-01f, -3.94778788e-01f, -7.86322713e-01f, -5.65823674e-01f, -4.39343542e-01f, -5.19407451e-01f, -5.31857073e-01f, -2.47846544e-01f,
  1.47905084e-03f, -8.69823694e-02f, -3.02855194e-01f, -3.77606064e-01f, 2.75725245e-01f, 4.07607518e-02f, 1.65259808e-01f, 1.80671975e-01f, 8.71782750e-02f, 1.50505990e-01f,
  9.37411785e-02f, 2.21366927e-01f, -1.00036904e-01f, -4.14963514e-02f, 1.40579596e-01f, -1.79424450e-01f, -1.46041796e-01f, 1.27009396e-02f, 4.86217206e-03f, 2.37587765e-02f,
  2.03706950e-01f, -2.32182024e-03f, -2.97273919e-02f, -4.93550003e-02f, -4.25762273e-02f, -1.10897951e-01f, -2.07667276e-01f, -3.32386851e-01f, -2.92702526e-01f, 1.23480214e-02f,
  1.78684205e-01f, 3.27141047e-01f, 2.26277597e-02f, -1.90456256e-01f, -2.36696303e-01f, 7.30001628e-02f, 4.95959595e-02f, -3.41975689e-02f, -2.42070243e-01f, -6.13191463e-02f,
  -1.72026202e-01f, -8.03064089e-03f, -4.67083193e-02f, 7.71649554e-02f, -9.79995206e-02f, 1.37709618e-01f, 3.92736169e-03f, -1.34855479e-01f, -1.60824824e-02f, 2.25751698e-02f,
  -4.32534106e-02f, 2.13891231e-02f, -2.79734060e-02f, -1.04962014e-01f, -8.32422525e-02f, 2.53398810e-02f, -3.42571735e-02f, -1.44683838e-01f, -6.36658296e-02f, 7.56161064e-02f,
  -8.87534767e-03f, -2.39903517e-02f, 1.54087514e-01f, -5.39209880e-02f, -3.14114988e-02f, 2.25765929e-02f, -1.72952353e-03f, -8.31562374e-03f, -9.84842405e-02f, 5.83993569e-02f,
  2.64281016e-02f, -4.21421118e-02f, 4.01196405e-02f, -2.80109406e-01f, -4.05378863e-02f, 3.26927602e-02f, 1.73654661e-01f, -6.81562945e-02f, 1.57008559e-01f, -7.21553937e-02f,
  2.12193131e-02f, 1.79652572e-02f, 8.44295025e-02f, -9.19047445e-02f, -6.43156990e-02f, 7.22176880e-02f, -2.14662641e-01f, 1.13638222e-01f, -1.58337206e-01f, 1.08621448e-01f,
  -1.15688913e-01f, -2.30271876e-01f, -2.40041822e-01f, -2.10746199e-01f, -1.46392971e-01f, -2.43429199e-01f, -1.03881985e-01f, -3.32193822e-03f, -3.11718196e-01f, -4.02124763e-01f,
  -2.13601187e-01f, -4.49869394e-01f, 2.17018157e-01f, -4.57040340e-01f, -3.19448382e-01f, -6.79293126e-02f, -4.61021036e-01f, -2.11271137e-01f, -2.00304076e-01f, -4.03034627e-01f,
  -1.52784631e-01f, 2.63480157e-01f, 2.59207904e-01f, 4.26303715e-01f, 4.17721152e-01f, -3.66639495e-01f, -1.53671756e-01f, 4.30858791e-01f, 5.85383892e-01f, 6.58579618e-02f,
  -3.20397079e-01f, -2.53003210e-01f, 1.74142122e-01f, 1.03168555e-01f, -5.37389457e-01f, -9.79744643e-02f, -2.21421137e-01f, -2.66937435e-01f, -5.60539635e-03f, -4.22728688e-01f,
  -3.01603470e-02f, 1.00417569e-01f, 1.40849262e-01f, 1.55207306e-01f, -1.90943450e-01f, 2.18256906e-01f, 5.49874194e-02f, 1.29848961e-02f, 1.08176917e-02f, 1.99497622e-02f,
  -1.57509267e-01f, 1.15096934e-01f, -7.28239194e-02f, -1.16321526e-01f, -2.30134159e-01f, 4.88647707e-02f, -2.00170837e-02f, 1.63049534e-01f, 7.01235607e-02f, 2.72142552e-02f,
  -2.13140860e-01f, -1.07012168e-01f, 1.08165905e-01f, 6.72369450e-02f, 1.52802706e-01f, 1.83136821e-01f, -7.42670074e-02f, 8.03342760e-02f, 8.85642022e-02f, -4.41208124e-01f,
  -2.12382346e-01f, -3.93541045e-02f, -3.15514505e-02f, -2.43421458e-02f, -6.12338930e-02f, 2.19714269e-02f, 1.89008582e-02f, -1.02530144e-01f, 6.23174459e-02f, -4.39147316e-02f,
  6.43456504e-02f, -4.22867276e-02f, 3.37576382e-02f, 2.37037018e-02f, 3.08195222e-02f, -8.23696256e-02f, 3.53535526e-02f, 6.34841695e-02f, -4.30558026e-02f, -2.69909836e-02f,
  9.36605036e-02f, 6.95852935e-02f, -5.81449606e-02f, 1.10319918e-02f, 1.16909944e-01f, 4.33572717e-02f, 2.20954767e-03f, 9.95966047e-02f, -7.45388493e-02f, -5.65669965e-03f,
  -1.36207804e-01f, 3.06102872e-01f, -3.16562712e-01f, 5.58802448e-02f, -2.41469830e-01f, 1.19277157e-01f, -5.98717062e-03f, 6.21066354e-02f, 5.78746758e-02f, 1.23107351e-01f,
  2.22778141e-01f, -4.05303109e-03f, -9.81493220e-02f, -6.40561506e-02f, -1.17984012e-01f, -1.14386894e-01f, -1.89930573e-01f, -6.64682612e-02f, 3.80424373e-02f, -1.29331365e-01f,
  -1.68260500e-01f, -4.01298925e-02f, -8.23778734e-02f, -1.34807229e-01f, -1.73896149e-01f, 1.47937134e-01f, -6.79135025e-02f, -1.71943307e-01f, 6.79750293e-02f, -4.54505235e-01f,
  -7.38040984e-01f, -1.38977915e-01f, -6.33274764e-02f, -5.06986976e-01f, -5.18169343e-01f, -3.48784059e-01f, -2.61207014e-01f, -3.55322689e-01f, -2.40121305e-01f, -1.56196728e-01f,
  5.88012375e-02f, 2.02099815e-01f, 1.77602306e-01f, -7.72986710e-02f, -1.39459223e-01f, -9.89940464e-02f, -1.24044664e-01f, -3.70123774e-01f, -3.79116744e-01f, -3.57705474e-01f,
  -4.38635468e-01f, -4.90698159e-01f, -4.51900393e-01f, -3.52305025e-01f, -1.47115409e-01f, -1.64626226e-01f, -1.00734107e-01f, -2.77525544e-01f, -1.83989108e-01f, -2.52308607e-01f,
  2.22183555e-01f, -2.39420652e-01f, -1.14028767e-01f, -1.83802485e-01f, -4.91190664e-02f, -1.22920349e-01f, -1.22487098e-01f, -1.03047276e-02f, 6.66659847e-02f, -8.40466172e-02f,
  -9.61370170e-02f, -6.32678866e-02f, -7.57541060e-02f, 2.59677488e-02f, -1.22447135e-02f, -1.21677928e-02f, -1.12359440e-02f, -4.25222963e-02f, -5.96725643e-02f, 1.77818313e-01f,
  6.17909431e-02f, -2.48052999e-02f, 6.75199404e-02f, 4.51725791e-04f, -2.79350486e-02f, -1.00028319e-02f, -3.57416123e-02f, 5.64797549e-04f, 7.44994432e-02f, 1.53717086e-01f,
  9.59238561e-04f, 2.13956594e-01f, 1.47927880e-01f, 4.65915427e-02f, 8.04034173e-02f, 1.95425421e-01f, 8.18382800e-02f, 6.20547608e-02f, 3.34799066e-02f, -4.62868391e-03f,
  3.19272839e-02f, -4.23455164e-02f, -2.34841872e-02f, -7.34486878e-02f, 1.18825532e-01f, 1.66641418e-02f, 7.33684152e-02f, 5.99287264e-02f, -1.58839244e-02f, 2.17587557e-02f,
  -4.92898636e-02f, 3.39647867e-02f, 5.03740646e-02f, 2.36270260e-02f, -8.45417082e-02f, -8.69024768e-02f, 3.23485211e-02f, 3.21795717e-02f, -4.42358553e-02f, -1.18400738e-01f,
  1.48404256e-01f, -2.14429721e-01f, -5.22720106e-02f, -2.92738695e-02f, 8.33886936e-02f, 4.91911471e-02f, 6.49887621e-02f, -7.56985173e-02f, -4.88763452e-02f, -6.51661381e-02f,
  -1.06877619e-02f, 6.40373006e-02f, -4.38130945e-02f, 8.72796774e-02f, -2.29441840e-02f, 8.86064023e-02f, 6.09724969e-02f, 3.64461318e-02f, 1.09308593e-01f, 7.71312639e-02f,
  1.63337529e-01f, 6.99503049e-02f, 9.49300155e-02f, 2.17444420e-01f, 2.14317236e-02f, 1.10475533e-01f, 1.57610461e-01f, 4.85389009e-02f, 4.01944518e-02f, 2.10760836e-03f,
  -4.59956110e-01f, 9.28337798e-02f, 4.95363981e-01f, -2.71148473e-01f, -1.70653343e-01f, -2.18017012e-01f, -5.19880712e-01f, -3.00665826e-01f, -5.38420118e-02f, 1.14909252e-02f,
  -9.88673698e-03f, -1.11819908e-01f, 1.91102982e-01f, 1.26589667e-02f, -1.73890114e-01f, -2.11987155e-03f, 2.14445472e-01f, 2.56072730e-01f, -1.38758913e-01f, -4.04592216e-01f,
  -1.95016056e-01f, -1.70125067e-01f, -3.89017188e-03f, 8.70316178e-02f, 2.11534336e-01f, 6.84054792e-02f, 4.05720145e-01f, 1.40474409e-01f, 1.70191720e-01f, 5.25903285e-01f,
  2.46795058e-01f, -4.60771918e-02f, -5.87359108e-02f, 3.20500247e-02f, 5.21483980e-02f, -2.30750795e-02f, -1.52642518e-01f, 1.12285666e-01f, -2.45443042e-02f, 4.33772020e-02f,
  2.69821292e-04f, 5.12547120e-02f, -1.42325517e-02f, -3.54917720e-02f, -1.30860209e-01f, -1.55135676e-01f, -3.98563175e-03f, -3.40533778e-02f, -6.37360290e-02f, -4.29659225e-02f,
  -1.19650304e-01f, -2.14489594e-01f, -4.20369692e-02f, -7.98470005e-02f, 1.08346529e-02f, 4.55909483e-02f, -1.01295095e-02f, -1.18874088e-02f, 2.03878842e-02f, 2.38735899e-02f,
  2.66546533e-02f, 8.39207992e-02f, 3.74073833e-02f, 4.40458916e-02f, -1.41422480e-01f, 1.13289461e-01f, 4.04711030e-02f, 2.70173028e-02f, 1.31137297e-01f, -4.33120085e-03f,
  3.27348849e-03f, -5.22704469e-03f, 1.32887457e-02f, 2.02343259e-02f, 8.53952244e-02f, -4.87933978e-02f, -9.65608954e-02f, 6.03249222e-02f, 4.33324724e-02f, -4.35571596e-02f,
  -2.42319889e-02f, -6.85939938e-03f, 1.51936352e-01f, 1.93389188e-02f, 1.27780020e-01f, 2.55103670e-02f, 2.90436689e-02f, 2.06863265e-02f, 7.26018175e-02f, 4.65204455e-02f,
  -3.09543461e-01f, 1.17679685e-02f, -1.46422446e-01f, -3.27655710e-02f, -5.30218147e-02f, 1.56656474e-01f, 1.22064896e-01f, -2.82692220e-02f, 3.54354754e-02f, -2.90149432e-02f,
  -4.47542742e-02f, 6.90871431e-03f, 5.28953262e-02f, -2.75224987e-02f, -2.11530179e-01f, -1.12447247e-01f, -1.04914099e-01f, -1.74193412e-01f, -9.74968225e-02f, -1.19496219e-01f,
  -1.24295339e-01f, -3.73286337e-01f, -3.45244676e-01f, -2.77716339e-01f, -1.99295461e-01f, -3.26579213e-01f, -9.96280983e-02f, -6.46728724e-02f, -2.98269659e-01f, -3.89321089e-01f,
  -6.83217525e-01f, -1.62148595e-01f, 5.35692811e-01f, -3.01798433e-01f, 2.19903529e-01f, 4.49687600e-01f, 3.36712629e-01f, 1.13935307e-01f, 2.80230865e-02f, 1.05319224e-01f,
  -3.37964445e-01f, -5.69733918e-01f, -3.38616401e-01f, -2.13476300e-01f, -6.97790533e-02f, 5.79399288e-01f, 5.44004917e-01f, 7.76709020e-02f, 2.19345163e-03f, -1.05355419e-02f,
  -1.91037625e-01f, -2.56747544e-01f, -3.81222874e-01f, -1.68264061e-01f, -2.73636039e-02f, -7.39291832e-02f, 1.98377401e-01f, -9.37481150e-02f, 1.64112613e-01f, 2.42768124e-01f,
  2.99868941e-01f, 3.97035480e-02f, -7.75670484e-02f, -2.18797982e-01f, -1.09367475e-01f, -2.41829917e-01f, -4.97541092e-02f, -1.02584042e-01f, -1.43240556e-01f, 8.20069462e-02f,
  -1.26534954e-01f, -1.19512193e-01f, -8.15284178e-02f, 3.05007696e-02f, -3.32483687e-02f, 2.24378612e-02f, 6.38827085e-02f, 1.30755797e-01f, 1.34243742e-01f, 1.82486370e-01f,
  -2.88686939e-02f, 1.25334293e-01f, 1.08682021e-01f, 1.38553336e-01f, 2.14701548e-01f, -1.65215936e-02f, -5.32305017e-02f, 7.68701062e-02f, 1.78888902e-01f, -2.01899791e-03f,
  -6.45270422e-02f, -2.54619569e-02f, -5.09547628e-02f, -7.86497220e-02f, -3.40661965e-02f, -7.04220012e-02f, 1.58917271e-02f, -8.78715888e-02f, -1.54257296e-02f, -7.81530142e-02f,
  -1.71746016e-01f, -2.60801837e-02f, -2.68426863e-03f, -1.31943628e-01f, -2.62121987e-02f, 8.25343877e-02f, -5.49394935e-02f, -1.62188902e-01f, 4.31637429e-02f, 7.00651035e-02f,
  -1.15699068e-01f, 5.18987887e-02f, -1.60381105e-02f, -5.35528921e-02f, 9.43013877e-02f, -8.72149318e-03f, -2.11447868e-02f, -2.36616097e-02f, -5.43861799e-02f, 7.81978145e-02f,
  -1.14639841e-01f, -9.63122472e-02f, 5.16852364e-02f, 1.18206359e-01f, 6.47811964e-02f, -4.73896079e-02f, -1.63231209e-01f, -6.82260692e-02f, -9.77447927e-02f, -3.73927993e-04f,
  1.34156691e-02f, -1.49738938e-01f, -9.52494983e-03f, 4.92830351e-02f, -1.51509911e-01f, -7.61720687e-02f, -2.03580379e-01f, -1.55057788e-01f, 1.27440810e-01f, 4.59079333e-02f,
  1.02994993e-01f, 8.98745060e-02f, -1.35188654e-01f, -4.44855988e-02f, -1.85097549e-02f, -6.82851151e-02f, 2.81531387e-03f, 1.20033566e-02f, 4.53861095e-02f, -1.89166844e-01f,
  5.82768500e-01f, 4.15919155e-01f, -1.94529980e-01f, 4.57776159e-01f, -2.50290543e-01f, -5.01502335e-01f, -9.48462710e-02f, -5.62379360e-02f, 1.01824366e-01f, 2.28757814e-01f,
  3.19397710e-02f, -1.80776700e-01f, -9.29615423e-02f, -2.33592138e-01f, -2.14346200e-01f, 1.96378212e-02f, -8.46975893e-02f, -2.23372802e-01f, -5.68598330e-01f, -3.98986608e-01f,
  6.36323763e-04f, 2.85562724e-01f, 2.43334234e-01f, -2.60207690e-02f, 1.70373023e-01f, -2.46576265e-01f, 1.87704831e-01f, 1.43447042e-01f, -1.82485893e-01f, 1.53561085e-01f,
  6.33578748e-02f, 2.75593549e-01f, -4.54745442e-01f, -2.12303959e-02f, -2.28906125e-02f, 9.79256183e-02f, 1.01334117e-01f, 1.31818533e-01f, 2.33445928e-01f, 2.64124393e-01f,
  2.89032944e-02f, 1.13207310e-01f, 5.89544624e-02f, 1.12531453e-01f, 2.13238552e-01f, -4.78390604e-03f, 1.24751039e-01f, -3.55899967e-02f, -1.84346344e-02f, 5.60214855e-02f,
  3.73797864e-02f, -8.09569191e-03f, -7.39775319e-03f, -6.46001473e-02f, -1.32224217e-01f, -2.56366760e-01f, -2.00754821e-01f, -2.01097593e-01f, -2.18128070e-01f, 3.18147480e-01f,
  -5.06715029e-02f, -2.58044503e-03f, -1.63000729e-03f, 1.04823895e-01f, 2.62249470e-01f, 8.91817957e-02f, 1.09803244e-01f, 8.69478472e-03f, 5.47431521e-02f, 1.17761917e-01f,
  -1.21677825e-02f, 1.55175021e-02f, 1.09087937e-01f, 1.32706344e-01f, -3.98707353e-02f, 2.58979164e-02f, 2.74305493e-02f, 1.41404837e-01f, 1.28150597e-01f, 1.81527868e-01f,
  3.43022905e-02f, -1.78732015e-02f, -1.32280830e-02f, 3.72296385e-02f, -1.25023335e-01f, -1.51553201e-02f, 6.49974570e-02f, -5.61026447e-02f, 5.85402101e-02f, 1.86033249e-02f,
  2.79005349e-01f, -3.42827111e-01f, 1.47586033e-01f, -5.02463430e-02f, 1.02305096e-02f, 2.32708361e-02f, 7.38924816e-02f, -1.75786242e-02f, 1.31743506e-01f, 1.13361001e-01f,
  -1.32349536e-01f, 4.45573218e-02f, 2.23295718e-01f, 6.75094780e-03f, -5.56673435e-03f, -3.64889950e-02f, 1.92922130e-01f, -5.01387529e-02f, -3.36704589e-02f, 8.88073221e-02f,
  4.93865721e-02f, -7.90918618e-03f, -5.84989116e-02f, -1.31130546e-01f, -1.02020726e-01f, -2.52479851e-01f, -1.26532376e-01f, -1.50505170e-01f, -3.56252253e-01f, 2.83810437e-01f,
  -2.29541793e-01f, -2.90378090e-02f, 2.03172967e-01f, 5.21088205e-02f, 3.25077683e-01f, 3.01035583e-01f, 3.11670274e-01f, 1.80340500e-03f, -3.72714326e-02f, -8.60154703e-02f,
  -2.20664203e-01f, -2.53197730e-01f, -1.45621195e-01f, -1.72031060e-01f, 1.35252380e-03f, 1.18531272e-01f, 2.02317476e-01f, 8.17349032e-02f, -4.22978178e-02f, -7.87639543e-02f,
  3.07652578e-02f, 3.19538414e-02f, 2.37450209e-02f, 4.28498648e-02f, -6.51024431e-02f, -6.53884560e-02f, 1.38483375e-01f, 1.27925515e-01f, 1.10537693e-01f, -7.11282268e-02f,
  -2.34398574e-01f, -1.16099484e-01f, -5.29244728e-02f, -1.21093288e-01f, 2.54010297e-02f, -5.30301966e-02f, 1.06365960e-02f, -2.92630419e-02f, -9.86735225e-02f, -1.11418389e-01f,
  -1.05954371e-01f, -1.67668760e-01f, -3.17543074e-02f, -6.97161704e-02f, -4.66245562e-02f, -7.76952580e-02f, -9.39264223e-02f, -7.43034855e-02f, -8.19505379e-02f, -1.14080220e-01f,
  -5.60684577e-02f, 1.25393299e-02f, -1.09889386e-02f, 1.50254427e-03f, -7.52609521e-02f, -4.59477305e-02f, -9.75239277e-02f, -1.49021506e-01f, -9.83003452e-02f, -8.99120495e-02f,
  9.06409696e-02f, 1.14940032e-01f, 9.78092328e-02f, -1.19106054e-01f, -1.70871854e-01f, -2.08789762e-03f, 5.30249774e-02f, 9.97012388e-03f, 1.09658964e-01f, 1.49612933e-01f,
  1.55422077e-01f, 1.35013700e-01f, 1.32758960e-01f, 7.50774965e-02f, 6.49502352e-02f, 1.14421397e-01f, 6.84391558e-02f, 7.02246204e-02f, 1.04859583e-01f, -1.45812761e-02f,
  -4.16459963e-02f, 1.41271129e-01f, 2.64816117e-02f, 1.03001662e-01f, 4.00282592e-02f, 1.13893628e-01f, 5.07743955e-02f, -1.32341951e-01f, 1.16888382e-01f, 1.61051169e-01f,
  4.09661569e-02f, 1.85721695e-01f, -1.36055082e-01f, -1.03214197e-01f, 8.75795186e-02f, 6.22232556e-02f, 4.13744301e-02f, 7.37009197e-02f, 1.47529125e-01f, 5.52287139e-02f,
  4.30268832e-02f, -9.22667310e-02f, 5.65118492e-02f, 2.43292712e-02f, 1.28870249e-01f, 4.75887619e-02f, 3.52042839e-02f, 1.15686774e-01f, -6.45636544e-02f, -3.49305458e-02f,
  -3.07457764e-02f, -3.45402248e-02f, -4.40898947e-02f, 7.64804259e-02f, -5.43960631e-02f, -6.83407784e-02f, 2.97741424e-02f, -6.95980564e-02f, 5.63548692e-02f, -2.61579622e-02f,
  -2.05897987e-01f, -2.85502017e-01f, -6.30151272e-01f, 3.96422073e-02f, 3.81749213e-01f, -1.19943760e-01f, -4.25518841e-01f, -2.34882638e-01f, 4.58305441e-02f, -1.43271431e-01f,
  2.28033513e-01f, 4.31640744e-01f, -1.09389834e-01f, -1.41931204e-02f, -2.36582205e-01f, -4.26738918e-01f, -3.57049495e-01f, -2.05967337e-01f, 2.36533403e-01f, 6.02487922e-01f,
  5.35124183e-01f, 2.96142280e-01f, 3.02716903e-02f, 7.98231736e-02f, 2.44987547e-01f, 1.38193101e-01f, -2.08933145e-01f, 1.72064707e-01f, -5.35332179e-03f, -3.94592471e-02f,
  -7.68366382e-02f, -3.04959387e-01f, -7.11327419e-02f, 2.26765215e-01f, 1.64766788e-01f, -1.13048978e-01f, -3.36632468e-02f, -1.37621120e-01f, -8.17547962e-02f, -1.53834268e-01f,
  1.66349128e-01f, -1.93893106e-03f, 5.18450029e-02f, -2.55444786e-03f, 3.54341716e-02f, -1.31251186e-01f, -1.09599002e-01f, -2.90377855e-01f, -3.45836014e-01f, -4.19486091e-02f,
  3.12976837e-01f, 2.40327045e-01f, -1.86166391e-01f, -1.92385405e-01f, -1.85174659e-01f, 1.72981359e-02f, -1.45508453e-01f, -4.44193259e-02f, -3.80035937e-01f, -1.17394313e-01f,
  4.22401130e-02f, 5.59010170e-02f, 8.32802579e-02f, -6.58215806e-02f, 1.04639940e-01f, -4.05384041e-02f, -6.85001612e-02f, 1.15865562e-02f, -3.00222255e-05f, -5.42590208e-02f,
  -4.11363915e-02f, 1.38833625e-02f, 7.88108557e-02f, -4.48811911e-02f, 4.90686484e-02f, 3.55032645e-02f, 9.01850406e-03f, -8.17217231e-02f, 4.01035696e-02f, -4.58865985e-02f,
  5.26211299e-02f, -4.50215340e-02f, 9.08263996e-02f, -7.29746595e-02f, -8.37505311e-02f, -1.64783940e-01f, -5.41226305e-02f, 6.37437478e-02f, 9.87062901e-02f, 3.30851562e-02f,
  2.69555878e-02f, -2.96153605e-01f, -3.27986442e-02f, 1.06196348e-02f, 6.05980568e-02f, 1.37996539e-01f, 1.04933530e-01f, 5.00555336e-02f, -1.38867021e-01f, -6.23534024e-02f,
  -6.63479641e-02f, -8.71295109e-02f, -2.07315147e-01f, 3.79657075e-02f, 5.60077652e-03f, -2.40120701e-02f, 8.58286917e-02f, -3.08361137e-03f, -1.62578106e-01f, 1.71175465e-01f,
  -1.25633255e-01f, -3.94633301e-02f, -1.20701142e-01f, -2.42341653e-01f, 3.97980921e-02f, 2.08482258e-02f, -1.82185590e-01f, -2.72141397e-02f, -2.91420966e-01f, -3.63232404e-01f,
  -5.29856123e-02f, -8.40303123e-01f, 2.83463329e-01f, 4.03050959e-01f, 1.47596806e-01f, -7.75759816e-02f, -3.91940325e-01f, -1.27355352e-01f, 2.88690805e-01f, -1.21482499e-01f,
  -2.35302746e-01f, -1.28312241e-02f, 4.94347028e-02f, -6.77579939e-02f, -2.25859597e-01f, -3.86050320e-03f, 2.81890094e-01f, 4.23943639e-01f, 2.99793512e-01f, -5.11201695e-02f,
  -2.48999912e-02f, -2.86703054e-02f, 6.39600158e-02f, 8.45154226e-02f, -4.69469279e-02f, 2.15784311e-01f, -8.00130423e-03f, -1.27077594e-01f, -2.44174153e-01f, 1.25823423e-01f,
  -1.82850212e-02f, -1.56498298e-01f, 3.81047606e-01f, -6.19921945e-02f, -2.28846781e-02f, 5.24083972e-02f, 1.15765698e-01f, -7.59526808e-03f, -2.25822166e-01f, 6.11310340e-02f,
  3.47719304e-02f, 5.05853328e-04f, 1.63959369e-01f, -7.81965628e-02f, -1.39040360e-02f, 8.09786543e-02f, -7.34996200e-02f, -1.55177116e-01f, -3.72205116e-02f, 2.49087568e-02f,
  -1.21172257e-01f, 1.20487884e-02f, -1.11586982e-02f, -1.07274704e-01f, -5.09493388e-02f, 1.12687238e-01f, -8.63820389e-02f, -8.18606690e-02f, 6.15213476e-02f, 4.93427590e-02f,
  4.21237312e-02f, -1.31052062e-01f, 1.30948976e-01f, 1.12603068e-01f, 1.29801273e-01f, -3.70945483e-02f, -3.05343396e-03f, -1.31508723e-01f, 8.85823667e-02f, -2.85041407e-02f,
  1.57066993e-02f, 6.50642067e-02f, 2.31229421e-03f, 1.18837036e-01f, 1.39037505e-01f, 8.62508044e-02f, -1.65127128e-01f, 6.83428869e-02f, 1.91264436e-01f, 1.19390711e-01f,
  8.05280134e-02f, -9.84896049e-02f, -5.45137636e-02f, -1.36155397e-01f, -7.55687878e-02f, 7.91818351e-02f, 4.97909896e-02f, -4.11345623e-02f, -5.01514238e-04f, -9.93066654e-02f,
  -1.42010942e-01f, 5.43517947e-01f, 3.02642852e-01f, -2.37139165e-02f, 1.89889167e-02f, -3.86520363e-02f, 1.56203032e-01f, 2.05239318e-02f, 6.50006207e-03f, 6.88869357e-02f,
  5.91898151e-02f, 2.36376762e-01f, -1.52232796e-02f, 3.82811055e-02f, 2.98760772e-01f, 2.52721399e-01f, -9.16453078e-02f, -1.33726686e-01f, -9.21294466e-02f, -3.87871601e-02f,
  -1.04504742e-01f, 1.23264216e-01f, 5.60532250e-02f, 1.71484783e-01f, 8.51409603e-03f, 2.32373223e-01f, 8.95704329e-02f, 1.32569715e-01f, 2.26837307e-01f, 6.21895343e-02f,
  9.13534105e-01f, -2.35133916e-01f, 3.91857266e-01f, 1.35493234e-01f, 3.07688028e-01f, 5.00637293e-01f, 4.95110095e-01f, 2.15295568e-01f, 1.05967619e-01f, -3.98986451e-02f,
  -6.12375215e-02f, -3.09309244e-01f, -1.48917571e-01f, -1.45157352e-01f, -5.58034368e-02f, -2.09297203e-02f, 9.98528898e-02f, 2.32256889e-01f, 3.11261535e-01f, 5.54622822e-02f,
  -1.38582379e-01f, 3.36790867e-02f, 2.33471930e-01f, -2.61321217e-02f, -3.47139925e-01f, -1.34742454e-01f, 4.04259488e-02f, 1.53724514e-02f, -1.84189945e-01f, -3.77901912e-01f,
  -3.67396116e-01f, 2.36905977e-01f, -1.80095315e-01f, -2.68414170e-01f, 1.69059560e-02f, -1.01281747e-01f, -9.66457501e-02f, -1.89176396e-01f, 3.10340449e-02f, -5.86542413e-02f,
  2.67272163e-03f, -7.00315535e-02f, -2.11977004e-03f, -8.07177201e-02f, 1.51879653e-01f, 4.91751917e-02f, -8.45966786e-02f, 7.48627994e-04f, -2.18669459e-01f, -1.08162209e-01f,
  -3.43057007e-01f, 1.37530407e-02f, 5.00019602e-02f, 2.62034480e-02f, 1.11352250e-01f, -1.79466791e-02f, 8.15868750e-03f, -2.62481794e-02f, 1.07003361e-01f, -5.61687127e-02f,
  -4.54477221e-01f, -1.08849801e-01f, -9.77125242e-02f, -1.10811666e-02f, 7.77294040e-02f, 6.20807335e-02f, -2.97919791e-02f, -9.67358947e-02f, 2.50414573e-02f, -9.03108716e-02f,
  -1.51869491e-01f, -1.07089572e-01f, -4.17025536e-02f, -1.00450873e-01f, -3.34327817e-01f, -1.21303827e-01f, 7.69458059e-03f, -1.60687387e-01f, -7.53333941e-02f, -2.16202568e-02f,
  -5.34528270e-02f, -1.31535858e-01f, -6.95372373e-02f, -2.59293854e-01f, -3.41021240e-01f, -1.01783931e-01f, -7.18266517e-02f, -1.63371488e-01f, -3.26417270e-03f, -2.81745233e-02f,
  -5.82696557e-01f, 1.97737411e-01f, -1.40873834e-01f, -1.32202968e-01f, -8.34005536e-04f, -6.49977401e-02f, -7.04168007e-02f, -2.00009197e-02f, -1.65130254e-02f, 4.48112516e-03f,
  3.60144936e-02f, 6.99137375e-02f, -5.02297431e-02f, -8.37265477e-02f, 1.40489087e-01f, -3.78036872e-02f, -8.27845857e-02f, -1.82692766e-01f, -2.12117195e-01f, -2.28658289e-01f,
  -2.84128308e-01f, -3.99591252e-02f, 4.22410890e-02f, 5.98822571e-02f, 4.35249880e-02f, 2.25356575e-02f, 1.22752544e-02f, 8.28751400e-02f, 1.51951313e-01f, 1.04989573e-01f,
  -4.05154318e-01f, 1.86456591e-01f, -6.44658685e-01f, -8.80982876e-02f, 6.59070313e-02f, 1.22340403e-01f, 3.71560544e-01f, 3.56331646e-01f, 1.54790044e-01f, 7.17791989e-02f,
  -1.35947438e-02f, -8.99874121e-02f, -1.97594613e-01f, -2.81424820e-02f, -4.06447686e-02f, 1.90720320e-01f, 6.66423142e-02f, -3.81852597e-01f, -2.23905742e-01f, 3.27500552e-01f,
  4.07022744e-01f, 1.20725252e-01f, -1.30091608e-01f, -6.41614348e-02f, 2.44527590e-02f, -3.10438983e-02f, -1.42524675e-01f, -1.78987220e-01f, -1.06869139e-01f, -2.79182941e-01f,
  -5.19001067e-01f, -2.39285648e-01f, 6.00428805e-02f, -1.38435453e-01f, -1.54371172e-01f, -5.34775332e-02f, 1.00600116e-01f, -2.82759130e-01f, -9.94079188e-02f, -5.01270182e-02f,
  -1.93824530e-01f, -1.44056484e-01f, -2.22743988e-01f, -9.69274640e-02f, 1.22601734e-02f, 1.03633189e-04f, -1.30806565e-01f, -2.48195380e-01f, -3.00669402e-01f, -2.15268224e-01f,
  9.29739326e-02f, -1.56071931e-01f, -5.46039224e-01f, -9.02906209e-02f, -3.52946557e-02f, -2.50474781e-01f, -2.16915965e-01f, -1.59347683e-01f, -2.51526803e-01f, -2.68438727e-01f,
  -7.83916155e-04f, -1.45644799e-01f, 5.09748459e-02f, -2.38998085e-02f, 1.63752705e-01f, -2.99293045e-02f, 2.10266504e-02f, -3.05771809e-02f, -1.55913413e-01f, -4.01137322e-02f,
  -6.22305237e-02f, -1.20501645e-01f, -3.57731283e-02f, 6.67703599e-02f, -2.62383949e-02f, 3.09434012e-02f, 5.73568568e-02f, 1.54259026e-01f, -4.17742021e-02f, 5.51503077e-02f,
  5.45626730e-02f, -1.61158387e-02f, 1.72676846e-01f, 9.17895511e-03f, -1.62942987e-02f, -7.60978833e-02f, 2.08178520e-01f, -1.40402289e-02f, -1.48921395e-02f, 4.36553471e-02f,
  1.74677029e-01f, 1.74932823e-01f, -9.40714031e-02f, 1.12338006e-01f, -1.58771798e-01f, 2.54102591e-02f, 5.55953123e-02f, -3.12668458e-02f, -1.93479046e-01f, -9.91142094e-02f,
  -6.75544143e-02f, -1.21010922e-01f, 6.38250709e-02f, -1.01624981e-01f, -7.80081525e-02f, -9.48238745e-02f, 3.17406580e-02f, -2.63517827e-01f, -6.16841763e-02f, -1.08442292e-01f,
  1.45236805e-01f, 1.05824716e-01f, -2.12955534e-01f, -1.53800249e-01f, 5.91505244e-02f, -1.22975670e-01f, -2.11953029e-01f, -7.22397119e-02f, -9.79754776e-02f, 5.94195686e-02f,
  3.11023265e-01f, 1.67382002e-01f, 5.42344525e-02f, -2.15228964e-02f, 2.33036473e-01f, 3.34825844e-01f, 4.58647668e-01f, 3.41265462e-03f, -1.57454699e-01f, 1.87659845e-01f,
  2.51558870e-01f, -1.65935844e-01f, -1.36268064e-01f, -1.65002257e-01f, 1.17323801e-01f, 1.22527577e-01f, -4.90645058e-02f, 6.69754371e-02f, -1.38682378e-02f, 8.13622549e-02f,
  3.09030116e-02f, 4.48744297e-02f, -2.63716225e-02f, -1.79173589e-01f, -1.91045180e-01f, -1.16409115e-01f, 5.25068790e-02f, 1.27959505e-01f, 1.01871088e-01f, -1.91897690e-01f,
  -1.18701473e-01f, 8.45163465e-02f, -8.38165283e-02f, -1.27327368e-01f, -5.33596203e-02f, -1.06364109e-01f, 9.53809693e-02f, -1.61544934e-01f, 2.48000752e-02f, -7.12464377e-02f,
  -1.22385003e-01f, -1.06647171e-01f, 1.30407671e-02f, -1.01028182e-01f, -4.96167177e-03f, -1.20723091e-01f, -1.97210476e-01f, -6.37143701e-02f, -1.15274712e-01f, 4.13178280e-02f,
  -7.77350888e-02f, 1.65865272e-01f, 1.39075160e-01f, -3.16378921e-02f, 2.73860227e-02f, 5.61306551e-02f, 4.74042855e-02f, 4.22959682e-03f, 1.16662661e-04f, -1.06773220e-01f,
  1.81625396e-01f, 2.09448457e-01f, -2.06987392e-02f, 1.29663542e-01f, 5.15358746e-02f, -1.23380842e-02f, -4.37053200e-03f, 2.31473699e-01f, 1.01306647e-01f, 7.62498751e-03f,
  1.43621400e-01f, 1.75773546e-01f, 1.50517985e-01f, 1.87276885e-01f, -1.61537540e-03f, 2.81522602e-01f, 4.49920803e-01f, 2.53258437e-01f, 1.17274947e-01f, 1.95586920e-01f,
  1.49928436e-01f, 2.56628692e-01f, 2.34272912e-01f, 2.70753019e-02f, 3.16333354e-01f, 2.09959492e-01f, 3.00877362e-01f, 4.30853486e-01f, 9.60297585e-02f, 3.42172712e-01f,
  -1.57901511e-01f, 3.80688578e-01f, -1.09375022e-01f, -3.18049610e-01f, -8.50347504e-02f, -1.03608795e-01f, -4.38166820e-02f, -2.07712516e-01f, -8.15707550e-04f, -6.46315143e-02f,
  -6.17821626e-02f, -1.45786434e-01f, 2.08282813e-01f, -3.63110118e-02f, -5.98566141e-03f, 2.37149522e-02f, -3.84043083e-02f, -1.57538503e-02f, -9.73152965e-02f, 4.34343331e-02f,
  -3.14518586e-02f, 1.23569310e-01f, 2.76771672e-02f, -1.99333322e-03f, 7.81894773e-02f, 1.61208138e-01f, 2.62815934e-02f, -2.43106410e-02f, 1.59098223e-01f, -6.54767267e-03f,
  -7.52662569e-02f, 4.51081187e-01f, 1.36446178e-01f, -4.89562720e-01f, -4.32520002e-01f, 3.63580585e-02f, 4.54789966e-01f, 3.66259851e-02f, -5.27443647e-01f, 1.83600694e-01f,
  -8.20519626e-02f, -3.88309538e-01f, -3.08038563e-01f, 9.36218724e-02f, 4.13064480e-01f, 3.76643211e-01f, 1.84614196e-01f, 1.68894649e-01f, 1.04537986e-01f, 1.08952343e-01f,
  2.46737339e-02f, -5.11735752e-02f, -1.08451501e-01f, 7.13305101e-02f, -9.25529450e-02f, -3.14926207e-01f, -1.81040987e-01f, -7.60551170e-02f, 3.93850207e-01f, 2.03155115e-01f,
  2.20288083e-01f, 1.91085443e-01f, -1.90667436e-01f, -3.74112129e-02f, -2.55472928e-01f, 1.49614960e-01f, 2.16720313e-01f, -1.37558997e-01f, -1.12323472e-02f, 1.68288648e-01f,
  -8.08025971e-02f, 9.95526388e-02f, -1.46789819e-01f, -3.92826498e-02f, -1.13140926e-01f, 9.37422812e-02f, -4.24435809e-02f, 1.57426178e-01f, 9.10410285e-02f, 9.54778492e-02f,
  -1.87079087e-02f, -6.09944128e-02f, -1.77031204e-01f, -9.96711999e-02f, 9.06055048e-03f, -2.90943921e-01f, 2.59693023e-02f, 1.41742736e-01f, 7.68419206e-02f, 1.03113912e-01f,
  -1.17947288e-01f, -4.93418239e-03f, -1.55544030e-02f, 1.95521489e-01f, 2.74171811e-02f, -2.72964444e-02f, 8.07193294e-02f, 1.46578968e-01f, 3.22129391e-02f, 4.99322861e-02f,
  -1.29126022e-02f, 3.51278037e-02f, -3.14438082e-02f, -8.07090849e-02f, -1.26059204e-01f, -6.36883229e-02f, 3.27582099e-02f, 3.07447650e-02f, -1.04670689e-01f, -2.40377802e-02f,
  2.75654681e-02f, -4.44372650e-03f, -1.83301285e-01f, 8.83948207e-02f, 2.58445414e-03f, -6.36183023e-02f, -1.65633895e-02f, -1.19617358e-01f, -1.02795690e-01f, -9.23456997e-02f,
  -3.88386130e-01f, 2.22477876e-02f, 4.14407961e-02f, 1.45585343e-01f, -4.68995469e-03f, -1.46469299e-03f, -1.35302573e-01f, 1.46142626e-03f, -1.57413170e-01f, 1.02011077e-01f,
  1.81051627e-01f, -3.00145242e-02f, -1.45469949e-01f, -6.22602291e-02f, -2.20753014e-01f, -6.04858287e-02f, 1.02842413e-02f, -1.44473895e-01f, 9.80230328e-03f, -1.65551394e-01f,
  -7.67953917e-02f, -1.78567410e-01f, -3.41476291e-01f, -3.34246248e-01f, -2.50163287e-01f, -4.24391508e-01f, -1.87713176e-01f, -1.73858136e-01f, -1.32379711e-01f, -4.86839786e-02f,
  -2.13776469e-01f, -2.75788546e-01f, 3.01493496e-01f, 2.69867390e-01f, 4.40726638e-01f, 2.96342820e-01f, 2.73276716e-01f, 1.86468959e-01f, 8.71552676e-02f, 2.93677840e-02f,
  -1.91857591e-01f, -3.68642300e-01f, -3.19456667e-01f, -2.39537418e-01f, -1.71855628e-01f, 7.26547912e-02f, 2.11924016e-01f, 1.27469331e-01f, 1.94075450e-01f, 1.58233941e-01f,
  4.63254638e-02f, 1.14034697e-01f, -1.17278742e-02f, -1.11595150e-02f, 4.24115919e-02f, -1.51208639e-02f, 8.73046294e-02f, 1.17492601e-01f, -3.44700292e-02f, 3.90743390e-02f,
  -6.14134269e-03f, -2.58978993e-01f, -1.19272798e-01f, -1.66058183e-01f, -1.53151795e-01f, -1.57543495e-01f, 1.05899766e-01f, -6.20623119e-02f, -9.55875143e-02f, -2.84606181e-02f,
  -1.20460860e-01f, -3.10692322e-02f, -7.03397021e-02f, -4.79297563e-02f, 7.56180137e-02f, 7.86735713e-02f, -1.61830083e-01f, -1.90851748e-01f, -2.25256741e-01f, -1.52595758e-01f,
  -2.39965141e-01f, -3.79221551e-02f, 1.58945508e-02f, -3.10583096e-02f, -8.66042003e-02f, -3.12592871e-02f, -1.29464373e-01f, -1.29445106e-01f, -6.40164688e-03f, 1.33291353e-03f,
  -8.22432935e-02f, -3.23971659e-02f, -7.96535462e-02f, 8.98989674e-04f, -1.45500759e-02f, 1.00985624e-01f, 1.83599770e-01f, 2.10799232e-01f, 2.17342451e-01f, 2.13402122e-01f,
  1.42583489e-01f, 2.42183148e-03f, 5.54037355e-02f, 3.00606750e-02f, 5.36731482e-02f, 5.05017005e-02f, 1.12370916e-01f, -6.40992969e-02f, 1.06360026e-01f, -3.07696126e-02f,
  3.14971879e-02f, 1.11316498e-02f, -3.37353423e-02f, -1.18891438e-02f, 1.87139232e-02f, 3.19347419e-02f, -3.70746218e-02f, -1.63417645e-02f, 8.03395286e-02f, 8.40294436e-02f,
  3.32073539e-01f, -4.57150899e-02f, -6.54200166e-02f, 2.40002340e-03f, 9.56073850e-02f, 7.67695978e-02f, 8.04271549e-02f, -3.56806908e-03f, 1.69507399e-01f, 5.44123575e-02f,
  7.43329749e-02f, -7.00496584e-02f, 8.65629017e-02f, -1.45634601e-03f, 1.92697585e-01f, 1.05333135e-01f, 1.99515559e-02f, 8.65908638e-02f, -7.19457269e-02f, -2.26056017e-03f,
  -1.39627839e-02f, 1.06641926e-01f, 1.55982390e-01f, 1.19939260e-01f, 9.02445689e-02f, 1.58446565e-01f, 1.31822079e-01f, 1.54466271e-01f, 1.41597956e-01f, 2.65394330e-01f,
  -3.94940525e-01f, 2.52483875e-01f, -8.69762674e-02f, -2.50490427e-01f, -2.30845332e-01f, -3.88514310e-01f, -2.15700299e-01f, -2.44494796e-01f, -3.43270190e-02f, 2.56617516e-01f,
  2.04903215e-01f, 1.03964321e-02f, 1.91537917e-01f, -1.07894868e-01f, -1.74708918e-01f, 1.63620293e-01f, -5.40990308e-02f, -4.63376164e-01f, -6.51304543e-01f, -5.88958263e-01f,
  -3.62155646e-01f, -6.18115008e-01f, -4.61365283e-01f, -3.56856287e-01f, -6.53311759e-02f, -2.15190336e-01f, -1.16999196e-02f, -2.76452601e-01f, -1.92156389e-01f, 1.39059722e-02f,
  -3.35652269e-02f, -1.69384509e-01f, -1.99771672e-01f, -1.23399876e-01f, -7.09272176e-02f, 2.05707606e-02f, -1.26795530e-01f, 1.96190719e-02f, 1.40261367e-01f, 3.34000476e-02f,
  7.50921592e-02f, 7.96251595e-02f, -6.55278936e-02f, 3.61899659e-02f, -8.10476094e-02f, -1.24211766e-01f, 6.47189543e-02f, -7.23502040e-02f, 7.39139915e-02f, 1.63977161e-01f,
  1.74042925e-01f, -2.44546458e-02f, 9.69139561e-02f, 3.12653854e-02f, -2.47753412e-02f, -1.10336281e-01f, 1.09434858e-01f, -4.05809171e-02f, -1.19070128e-01f, 1.00695610e-01f,
  -2.60707319e-01f, 2.23178685e-01f, 5.08486629e-02f, -6.40496314e-02f, 9.59390774e-02f, 6.09509088e-02f, 6.36162013e-02f, 1.39883593e-01f, -2.38576941e-02f, 6.54780567e-02f,
  6.27667680e-02f, 6.16638884e-02f, -1.71351526e-02f, -1.42002538e-01f, -6.50820807e-02f, 8.82287025e-02f, 1.59461517e-02f, 1.24838063e-02f, 7.67731965e-02f, 1.33476391e-01f,
  1.37276221e-02f, 8.09860826e-02f, -2.16399669e-03f, -7.84332976e-02f, 4.87216115e-02f, 1.19387880e-01f, -6.33930415e-03f, 3.50907557e-02f, 1.04715466e-01f, 3.19097973e-02f,
  -2.22125337e-01f, -3.10453296e-01f, 1.31533340e-01f, 2.84283925e-02f, 5.95915094e-02f, 1.29433319e-01f, 1.07472591e-01f, -1.24251008e-01f, -4.92114760e-02f, -8.45941156e-02f,
  -2.78472695e-02f, -8.31001848e-02f, 1.34430140e-01f, 1.29072860e-01f, -1.47203699e-01f, -1.06771156e-01f, 8.97685736e-02f, 5.66395596e-02f, 2.87564881e-02f, 2.46091545e-01f,
  2.62452126e-01f, 1.48536474e-01f, 1.93294585e-01f, 2.34375760e-01f, 1.53079242e-01f, 5.79050649e-03f, 1.10796578e-01f, 4.34847064e-02f, 5.15933894e-02f, 1.98612541e-01f,
  -1.75848350e-01f, -2.22813070e-01f, 2.89920866e-01f, -5.60516678e-03f, 7.89056532e-03f, -1.40886784e-01f, -1.41442522e-01f, -2.00726122e-01f, -2.17031196e-01f, -7.81728048e-03f,
  1.80637896e-01f, 2.96967238e-01f, 2.87577152e-01f, 2.19132379e-01f, 1.69303462e-01f, -1.46780550e-01f, -6.38833195e-02f, 2.81004965e-01f, 4.33933616e-01f, 1.45494089e-01f,
  1.19092576e-02f, -5.36531806e-02f, 1.44060746e-01f, -4.46168426e-03f, -1.25999272e-01f, 2.18613103e-01f, -1.95952915e-02f, -5.31597156e-03f, -5.65964021e-02f, -1.14036120e-01f,
  5.10635555e-01f, -4.10693407e-01f, 7.73931742e-02f, -6.39580861e-02f, 4.69195545e-02f, -2.36032218e-01f, -1.80663779e-01f, -1.94608718e-01f, -2.67583162e-01f, -1.77525923e-01f,
  4.11393382e-02f, -6.62815869e-02f, 2.29478069e-02f, 1.74563136e-02f, 2.50150096e-02f, 2.56358329e-02f, 5.37045579e-03f, -1.66901931e-01f, -2.08325759e-01f, -8.93108267e-03f,
  2.27298103e-02f, -4.30057235e-02f, 4.68250588e-02f, -8.12791511e-02f, 6.26320466e-02f, 1.49928018e-01f, -2.89070699e-02f, 1.70507040e-02f, 6.90238550e-03f, -1.94255725e-01f,
  -5.05208410e-02f, 2.08504692e-01f, 1.27694070e-01f, 7.19801560e-02f, 6.77064061e-02f, -1.65843859e-01f, 2.02721022e-02f, -2.01741606e-02f, -1.02494746e-01f, 1.67046547e-01f,
  9.36349854e-03f, 3.08172368e-02f, 1.70212181e-03f, -9.54286754e-02f, -5.39018027e-02f, -9.59248394e-02f, 1.87570676e-02f, 1.07690338e-02f, 2.00433992e-02f, -1.52604394e-02f,
  7.38744959e-02f, -9.06489193e-02f, -1.68954954e-02f, -5.01386933e-02f, -9.16582793e-02f, 1.43220887e-01f, -9.51840058e-02f, 1.53863290e-02f, 1.57798171e-01f, -1.10622875e-01f,
  2.49898851e-01f, 1.82155818e-02f, 1.08432844e-01f, -1.00427337e-01f, -4.99781445e-02f, -1.81219921e-01f, -2.06350163e-02f, -7.68510103e-02f, -1.57090023e-01f, -8.91717896e-02f,
  2.16536094e-02f, 1.12386517e-01f, 1.17435008e-01f, 6.07771277e-02f, 2.91334778e-01f, 4.32684086e-02f, -3.06697544e-02f, -3.55454348e-02f, -2.03182712e-01f, -9.89277810e-02f,
  -1.59127161e-01f, -7.30422735e-02f, 2.38044843e-01f, 8.96524191e-02f, 6.82061613e-02f, 1.01311505e-01f, 3.09987277e-01f, 4.01308872e-02f, 1.85109586e-01f, 1.55942515e-01f,
  -4.86666739e-01f, 9.76540744e-02f, -5.88414408e-02f, -3.03121030e-01f, 3.00927758e-01f, 2.00970352e-01f, 3.05359513e-01f, -3.89594920e-02f, -1.91222563e-01f, 2.48654168e-02f,
  4.20107663e-01f, 1.31788999e-01f, -4.99406494e-02f, 1.50985137e-01f, 1.45996988e-01f, 1.24450289e-01f, -2.88296607e-03f, -1.39386684e-01f, 5.59053645e-02f, 2.24065468e-01f,
  2.42786795e-01f, -8.05458575e-02f, -2.88514495e-01f, -1.65774435e-01f, -2.07012847e-01f, 2.59436644e-03f, -1.51384503e-01f, -5.13405818e-03f, 1.26070127e-01f, -5.15976027e-02f,
  -1.88366562e-01f, -1.69738218e-01f, 1.42338291e-01f, 1.56570077e-01f, 1.33346856e-01f, -3.22468817e-01f, -1.58000350e-01f, -1.93467438e-01f, 2.60569137e-02f, -9.29375738e-02f,
  2.92700324e-02f, 5.33095710e-02f, 1.38797730e-01f, -2.23925449e-02f, -1.29304960e-01f, 2.81971623e-03f, -1.13794148e-01f, -1.76484734e-01f, -2.04828978e-01f, 3.75015251e-02f,
  2.44195804e-01f, 2.41046801e-01f, -3.64783965e-02f, -3.94676346e-03f, -2.12657988e-01f, -1.16315983e-01f, -7.19306320e-02f, -1.97201326e-01f, -3.05485338e-01f, -4.22518909e-01f,
  4.83126491e-02f, 1.14063196e-01f, 6.54130355e-02f, -2.04104632e-02f, -8.13250430e-03f, 6.00077175e-02f, -2.22833473e-02f, 1.50077701e-01f, -1.64840762e-02f, -2.43249442e-02f,
  1.24064386e-01f, 7.26924464e-02f, 3.73646989e-02f, 2.14871466e-02f, 4.74389121e-02f, -1.44927017e-02f, -1.87892728e-02f, -5.62722050e-02f, 3.58519554e-02f, -3.09005547e-02f,
  -5.86434081e-02f, -7.16401115e-02f, -1.29526481e-01f, -1.00825526e-01f, 1.19936722e-03f, 1.41100049e-01f, -1.08945981e-01f, -3.66914039e-03f, 6.21100934e-03f, -5.05048484e-02f,
  -4.26371276e-01f, 2.01145500e-01f, -2.40811065e-01f, -6.80931434e-02f, 5.60687780e-02f, 1.89490244e-03f, -2.25925110e-02f, 2.26319768e-02f, -4.11397703e-02f, -1.58161521e-01f,
  -8.51702318e-02f, -9.52953324e-02f, -7.51548186e-02f, 4.26967293e-02f, -2.92891022e-02f, -1.08293593e-01f, 3.80397658e-03f, -1.54294306e-03f, -4.32908982e-02f, -1.37648210e-01f,
  -1.62123486e-01f, -1.30008861e-01f, -2.38196507e-01f, -1.92856595e-01f, -2.27917716e-01f, -2.07364619e-01f, -2.88132995e-01f, -2.75561750e-01f, -3.15429568e-01f, -4.62264955e-01f,
  5.78773141e-01f, 5.12364030e-01f, 3.34574044e-01f, 2.77969778e-01f, 1.06812656e-01f, 2.60831863e-01f, 2.78629035e-01f, 8.40590447e-02f, 1.26774414e-02f, 2.03007445e-01f,
  2.01030448e-01f, 1.61312923e-01f, 1.83844328e-01f, 1.22190423e-01f, 2.19896287e-01f, 1.88308105e-01f, 2.42440235e-02f, 8.96340609e-02f, -3.19633409e-02f, 1.09012119e-01f,
  -2.00208481e-02f, 3.94895747e-02f, 6.45181611e-02f, 3.49593419e-03f, 8.37239474e-02f, 3.31374295e-02f, 3.80473323e-02f, 1.30951464e-01f, 1.07200444e-01f, 5.42294271e-02f,
  -1.52738005e-01f, 1.67014658e-01f, -3.22464108e-01f, -1.43240049e-01f, -9.02855843e-02f, -1.14530168e-01f, -3.02549880e-02f, -1.90612704e-01f, -1.12213269e-01f, -8.10328051e-02f,
  -7.85647407e-02f, -1.75320983e-01f, -1.21068403e-01f, -8.82203728e-02f, -9.80895087e-02f, -1.05874002e-01f, -2.25735474e-02f, 8.86164680e-02f, 9.57890823e-02f, -3.69402543e-02f,
  -1.11032641e-02f, -1.29565522e-01f, 1.70173179e-02f, 2.56670993e-02f, 1.72191322e-01f, -2.14351267e-02f, 9.47589613e-03f, -1.76726449e-02f, -1.06758051e-01f, 7.90917501e-02f,
  -9.98518988e-02f, 8.63213986e-02f, 1.84922129e-01f, 1.01467252e-01f, 1.25203222e-01f, 5.56143858e-02f, -4.35490422e-02f, 2.11688760e-03f, 3.18289585e-02f, -6.65900810e-03f,
  -1.18203737e-01f, 7.40100890e-02f, 1.46030918e-01f, -4.47076783e-02f, 5.85614517e-02f, 2.35219654e-02f, -4.71044406e-02f, -9.46376398e-02f, 5.76966349e-03f, -4.52858806e-02f,
  1.25518590e-01f, -1.14833817e-01f, -6.11416586e-02f, 7.06015900e-02f, -1.00440897e-01f, -4.61854637e-02f, -8.16868097e-02f, -1.05930723e-01f, -1.48642257e-01f, -1.66601107e-01f,
  -4.32114184e-01f, -1.19714051e-01f, -2.21163586e-01f, -1.33033931e-01f, -3.83418687e-02f, -6.16403483e-02f, 9.29703340e-02f, 5.81308093e-04f, 3.12345400e-02f, -1.32133320e-01f,
  -3.48333940e-02f, -2.33117789e-02f, -9.66801494e-02f, -6.55642599e-02f, -1.64122999e-01f, -2.25477502e-01f, -1.06184512e-01f, -6.80214986e-02f, -8.57312791e-03f, -6.12210371e-02f,
  -1.01370938e-01f, -2.33090758e-01f, -2.38371342e-01f, -4.12992686e-02f, 2.80736643e-03f, -2.64643461e-01f, -1.32536858e-01f, -1.76697418e-01f, -2.00898841e-01f, -1.77696228e-01f,
  -4.64868583e-02f, 6.18291693e-03f, -4.30126071e-01f, 9.18588787e-02f, 1.45013019e-01f, -2.29122534e-01f, -4.22597617e-01f, -2.67857403e-01f, 2.31456116e-01f, 2.41965130e-01f,
  2.72083730e-01f, 1.06112555e-01f, -7.99775794e-02f, -1.78902179e-01f, -4.28961635e-01f, -1.63672715e-01f, -1.53130159e-01f, -4.47178423e-01f, -4.72926885e-01f, -2.22052619e-01f,
  1.00289524e-01f, 4.04568203e-03f, -1.69671908e-01f, -1.70633152e-01f, 4.08085585e-01f, 2.54898101e-01f, 2.38555580e-01f, 2.06853971e-01f, 7.97602311e-02f, 2.35059068e-01f,
  5.50914370e-02f, -1.81897208e-02f, -8.62013474e-02f, 5.07416241e-02f, 1.54847383e-01f, -1.38534894e-02f, -1.24509223e-01f, -1.29509777e-01f, -2.95249969e-02f, -4.34330963e-02f,
  7.52781704e-02f, 7.67679438e-02f, -1.20117389e-01f, -1.55355074e-02f, -3.49235460e-02f, -1.62536040e-01f, -2.45765388e-01f, -3.66911232e-01f, -2.93973148e-01f, -6.64812997e-02f,
  -8.10199603e-03f, -9.00998991e-03f, -3.06939065e-01f, -2.26354957e-01f, -1.66520983e-01f, -7.44050592e-02f, -1.24577343e-01f, 5.46567105e-02f, -1.75290629e-01f, 1.59121424e-01f,
  7.85913765e-02f, -5.31306230e-02f, -2.52403542e-02f, 1.05969317e-01f, 7.09920749e-02f, 1.22404493e-01f, 2.41304282e-02f, 4.64995503e-02f, 1.10954801e-02f, -1.23533860e-01f,
  -2.09295645e-01f, -8.35260004e-02f, -1.61547482e-01f, -9.15680230e-02f, -1.09470319e-02f, 7.29119405e-02f, -8.05389229e-03f, -3.94524112e-02f, -1.42437935e-01f, -1.79911610e-02f,
  -8.29199776e-02f, -9.02750045e-02f, 8.46362561e-02f, -2.78520659e-02f, 1.22757524e-01f, -5.15707657e-02f, 1.60636440e-01f, 1.02937268e-02f, -7.59393349e-02f, 1.82947636e-01f,
  2.34029710e-01f, -6.97985068e-02f, 2.24384442e-01f, -9.78953764e-02f, 3.97109166e-02f, 1.20807700e-01f, 1.71682626e-01f, 4.70712371e-02f, -3.58492546e-02f, -9.73713323e-02f,
  -1.14007518e-01f, -1.58149675e-01f, 3.40432450e-02f, -4.97789606e-02f, -9.20771062e-02f, -2.49675252e-02f, -9.74245220e-02f, -1.25715658e-01f, -2.87478477e-01f, 7.99451768e-02f,
  -5.08693419e-02f, -1.08528659e-01f, -1.37209639e-01f, -2.17812255e-01f, -2.53222529e-02f, -1.32077545e-01f, -7.11266845e-02f, 4.22241092e-02f, -1.75088808e-01f, -7.73181170e-02f,
  6.21530354e-01f, 4.95606177e-02f, -2.47849859e-02f, 4.49707061e-02f, 1.15688644e-01f, 1.83650583e-01f, 2.52850890e-01f, 5.69472909e-02f, 1.17073961e-01f, 8.20425004e-02f,
  2.84961402e-01f, 1.06469378e-01f, 2.05530331e-01f, 5.72792254e-02f, 1.09790117e-01f, -8.70559812e-02f, -2.16939852e-01f, -6.66025653e-02f, 9.56318155e-02f, -9.20358449e-02f,
  -1.42198086e-01f, -1.63012758e-01f, -4.11260575e-02f, -8.43119770e-02f, -3.86706501e-01f, -2.20988557e-01f, -1.17251962e-01f, -8.15570876e-02f, -1.94892943e-01f, -5.65416157e-01f,
  -5.74649870e-01f, 1.33520707e-01f, -8.02938789e-02f, 3.19879502e-02f, 1.90968309e-02f, 8.74870270e-02f, 1.28481224e-01f, -8.02177787e-02f, 4.31716852e-02f, -1.63757846e-01f,
  -1.03915244e-01f, 1.40022940e-03f, 8.45871270e-02f, -2.14627311e-02f, -4.28724848e-02f, -4.39288355e-02f, 2.15214983e-01f, -2.61014123e-02f, -7.42585063e-02f, 7.01262951e-02f,
  9.54876170e-02f, 2.26420060e-01f, 1.73118427e-01f, 1.67696059e-01f, 2.30506912e-01f, 1.32876232e-01f, 8.38443935e-02f, 1.82158872e-01f, 1.87852949e-01f, 2.18832895e-01f,
  2.13308424e-01f, 7.33088106e-02f, 8.15212075e-03f, 1.76283702e-01f, 2.41080508e-01f, 3.17626670e-02f, -9.90982279e-02f, 1.73105933e-02f, 2.03561634e-01f, 1.18093900e-01f,
  -1.51699245e-01f, 4.87498231e-02f, 1.48216695e-01f, -1.80704802e-01f, -8.45949203e-02f, -1.09291129e-01f, -4.76672314e-02f, -9.67998654e-02f, -4.12710849e-03f, -4.03363891e-02f,
  3.97741534e-02f, -5.79553097e-02f, -1.49253130e-01f, -2.21133694e-01f, -1.01565003e-01f, 6.24430366e-02f, 2.84710154e-02f, 8.55690911e-02f, 1.12823129e-01f, -8.54550526e-02f,
  -4.45800781e-01f, 3.47715259e-01f, -9.23836455e-02f, 5.75494468e-02f, -2.96116453e-02f, -7.87589699e-02f, 1.61147684e-01f, -2.12791428e-01f, -1.96843848e-01f, -1.71638370e-01f,
  -6.29218742e-02f, -1.34392038e-01f, 8.90472159e-03f, 9.80259478e-03f, -3.56593430e-02f, 8.16148594e-02f, 1.83591738e-01f, 1.03412261e-02f, -2.99657751e-02f, -6.33201078e-02f,
  -3.26997600e-02f, 1.95218399e-01f, 1.38520420e-01f, 4.94543910e-02f, 2.00554699e-01f, 7.72174224e-02f, 9.63996816e-03f, -9.99095589e-02f, 3.99300270e-02f, -3.90376942e-03f,
  -3.23827952e-01f, -3.07557344e-01f, -7.38399848e-02f, 3.09945464e-01f, 3.01753357e-02f, -3.99580330e-01f, -5.04311740e-01f, -1.25791609e-01f, 1.47451580e-01f, -2.40187600e-01f,
  -3.20591271e-01f, -3.84811386e-02f, 8.06699097e-02f, -7.92954415e-02f, -2.49365479e-01f, -8.49816576e-02f, 3.25821757e-01f, 1.54253289e-01f, -7.47094899e-02f, -1.22467026e-01f,
  8.79328921e-02f, 1.50881901e-01f, 7.30382577e-02f, 1.15704358e-01f, 3.70199323e-01f, 1.23450518e-01f, 1.62042856e-01f, 1.69915780e-01f, -2.51993746e-01f, 3.49531382e-01f,
  -2.90590316e-01f, -1.39253333e-01f, 7.25168064e-02f, 6.97076395e-02f, 6.33500293e-02f, -1.00992531e-01f, -1.24973394e-01f, 1.20872132e-01f, 3.49469371e-02f, 5.07936925e-02f,
  4.17866632e-02f, -1.01629563e-01f, 1.56732425e-02f, 9.75353345e-02f, 4.70492616e-02f, -9.90161374e-02f, 2.05417991e-01f, 8.03643614e-02f, -4.94930111e-02f, -1.04776904e-01f,
  2.97256690e-02f, -1.57290476e-03f, -1.42619193e-01f, -1.32275939e-01f, 1.37877604e-02f, -4.73574270e-03f, -2.15367571e-01f, -7.54675642e-02f, -2.67231345e-01f, -1.32725686e-01f,
  -2.12150663e-02f, 4.16124240e-02f, 6.29038736e-03f, -3.30064930e-02f, -2.62399088e-03f, 9.09185037e-02f, 1.41006410e-01f, -2.35542599e-02f, 2.47526281e-02f, 1.15869753e-01f,
  1.22345891e-02f, 4.26445948e-03f, 4.98294383e-02f, -2.76483912e-02f, 5.60704470e-02f, 1.57972835e-02f, -4.52752953e-04f, -3.62877622e-02f, 8.50696713e-02f, -3.23070399e-02f,
  -8.77903178e-02f, -3.80691886e-02f, 2.02940464e-01f, 1.08132705e-01f, -9.20314863e-02f, 1.70317199e-02f, 3.64616215e-02f, -1.03486329e-01f, 2.09445469e-02f, -1.91800833e-01f,
  -3.94464135e-02f, -1.98319063e-01f, -6.58588111e-02f, -1.60688662e-03f, 7.34140575e-02f, -2.58818007e-04f, -7.71996826e-02f, -9.86646116e-02f, -5.79193272e-02f, -4.23967605e-03f,
  -1.36968553e-01f, -1.69207364e-01f, -1.12301938e-01f, 2.83639189e-02f, -1.08854190e-01f, -2.06552856e-02f, 8.84779021e-02f, -5.43130189e-02f, -4.38538380e-02f, 9.80332270e-02f,
  1.39070705e-01f, -1.95734158e-01f, -3.00011456e-01f, -3.04309547e-01f, 1.87271293e-02f, -2.32129276e-01f, -2.85909444e-01f, -1.99986219e-01f, -3.92977864e-01f, -5.41839302e-01f,
  5.16882718e-01f, 2.43053734e-01f, -2.94910550e-01f, 2.64798403e-01f, -2.32642204e-01f, -3.00763220e-01f, -2.22881183e-01f, -1.04408167e-01f, 1.10345550e-01f, 2.48889610e-01f,
  2.15254482e-02f, -1.29986390e-01f, 3.81917395e-02f, -3.28190804e-01f, -2.64336169e-01f, -5.65425046e-02f, 3.84752750e-02f, -3.18497777e-01f, -7.00608313e-01f, -6.26387775e-01f,
  -2.86032140e-01f, -1.36612415e-01f, -1.50061414e-01f, -1.64320141e-01f, 8.37665144e-03f, -3.24799269e-02f, 1.27457514e-01f, -9.75145027e-02f, -9.14173126e-02f, 6.57497346e-02f,
  -3.17091763e-01f, -2.66614668e-02f, -2.24516928e-01f, 6.97424561e-02f, 6.98502213e-02f, -2.23782361e-02f, -6.30362034e-02f, 1.61443315e-02f, 1.47262976e-01f, -6.50999323e-02f,
  -4.34565172e-02f, -1.56310439e-01f, -2.22297926e-02f, -1.81650117e-01f, -1.54855043e-01f, -1.62436068e-01f, -4.79790084e-02f, -1.28722861e-01f, 1.42399240e-02f, -3.40305939e-02f,
  -1.06134571e-01f, -1.04724877e-01f, -9.66989025e-02f, -1.04258046e-01f, -1.97109327e-01f, -7.81381875e-02f, -1.82834774e-01f, -2.45036513e-01f, -1.38523147e-01f, 2.58172035e-01f,
  4.67000855e-03f, 4.14809622e-02f, 8.32598656e-03f, -6.68945163e-02f, 6.53549805e-02f, 3.16027626e-02f, 5.48997074e-02f, -7.93536473e-03f, -7.26985335e-02f, -8.85876454e-03f,
  1.34716127e-02f, 1.10685155e-01f, -3.82836498e-02f, 2.68188417e-02f, -7.29147950e-03f, -3.99077535e-02f, 6.86392337e-02f, 3.35268266e-02f, -8.22723508e-02f, -9.16022714e-03f,
  -1.07904859e-01f, -1.80721898e-02f, -2.42185369e-02f, 1.72942702e-03f, -2.52601877e-02f, -3.09841987e-02f, -1.25951180e-02f, -1.55370086e-01f, -3.77878062e-02f, -4.85058911e-02f,
  2.10824743e-01f, -7.30758682e-02f, 1.50232613e-01f, -7.84962699e-02f, 6.29253834e-02f, -7.42267668e-02f, 1.26546189e-01f, 4.06028591e-02f, 7.54849315e-02f, -9.42698494e-02f,
  -1.12535939e-01f, 4.67875935e-02f, -1.29879527e-02f, -4.98294719e-02f, -1.63189799e-01f, -1.17484368e-01f, 1.31928220e-01f, -2.04339214e-02f, -8.34351704e-02f, 7.31339753e-02f,
  1.04683921e-01f, 4.74028252e-02f, 1.18073337e-01f, 1.26884490e-01f, -2.41878908e-02f, 1.07211806e-01f, -2.62105726e-02f, 7.44955498e-04f, 9.78197083e-02f, 2.97278643e-01f,
  -3.00913513e-01f, -2.55571425e-01f, 1.57153517e-01f, -1.00508511e-01f, -1.56980559e-01f, -2.35342875e-01f, -2.01551437e-01f, -4.14789915e-02f, -1.59121871e-01f, -3.74106646e-01f,
  -3.92570525e-01f, -8.45274478e-02f, 2.30276566e-02f, 3.25001366e-02f, 1.72006398e-01f, 6.85887337e-02f, 1.88421562e-01f, 3.86131763e-01f, 3.18838447e-01f, -1.95364859e-02f,
  -3.21588442e-02f, 1.53180301e-01f, 1.41829565e-01f, 2.66863793e-01f, 9.93184000e-02f, 6.87904954e-02f, 1.11340538e-01f, 1.32505642e-02f, -1.51984245e-01f, 6.86971098e-02f,
  -4.67855364e-01f, -1.78215504e-01f, 1.10467792e-01f, -1.03093654e-01f, -5.95844761e-02f, -3.26117538e-02f, -5.19204959e-02f, 5.50347641e-02f, -5.85103445e-02f, 2.84540057e-02f,
  -1.47254065e-01f, 3.34186247e-03f, -1.25144469e-02f, 1.12360250e-02f, -5.64370789e-02f, -4.87765856e-03f, 2.09834516e-01f, 2.46569738e-01f, 7.83417746e-02f, -1.59253627e-01f,
  -1.17664620e-01f, -1.66197687e-01f, -2.10211173e-01f, 5.50365821e-03f, 4.53583449e-02f, 2.26098783e-02f, -8.33274350e-02f, 1.83254704e-02f, -6.79875463e-02f, -1.49933279e-01f,
  6.61582872e-02f, -2.31485404e-02f, 4.23929468e-02f, 1.13530286e-01f, -5.05028367e-02f, -7.72029608e-02f, 6.99932501e-02f, -8.78972746e-03f, 4.09829170e-02f, 8.98478702e-02f,
  8.85113776e-02f, -8.80316366e-03f, 1.39373720e-01f, 8.06499179e-03f, -7.47927874e-02f, -8.24872851e-02f, -5.70463426e-02f, -5.17307147e-02f, -1.72468182e-02f, -7.33812675e-02f,
  -7.02681988e-02f, 6.52448311e-02f, 7.63976574e-02f, 1.33898243e-01f, -1.22566484e-01f, 5.35652265e-02f, -1.03317231e-01f, -8.49482343e-02f, -1.02841318e-01f, -2.47940317e-01f,
  -4.16225940e-01f, 1.04579791e-01f, -1.74742803e-01f, -3.42753716e-02f, -1.90923885e-01f, -6.11579008e-02f, -1.61902472e-01f, -8.35726932e-02f, -7.03438818e-02f, -1.68891754e-02f,
  -1.79329589e-01f, 9.96147050e-04f, -9.08389762e-02f, 1.06825374e-01f, -5.54887541e-02f, -1.64508343e-01f, -1.54064849e-01f, -6.92483131e-03f, -2.96778493e-02f, -8.10592026e-02f,
  -4.43050750e-02f, -1.79275483e-01f, -3.32517803e-01f, -2.37554640e-01f, -1.53794497e-01f, -1.77944466e-01f, -5.44689707e-02f, -1.11155309e-01f, -2.17442036e-01f, -3.59507293e-01f,
  7.11197376e-01f, -1.92635804e-02f, -6.33375883e-01f, 2.36204907e-01f, -6.27080072e-03f, -1.42668262e-01f, 6.61281645e-02f, 2.44843587e-01f, 2.44943425e-01f, 6.53614849e-03f,
  -2.01364055e-01f, -3.79065201e-02f, -1.26813710e-01f, -1.66495651e-01f, 4.28386889e-02f, -4.59539518e-03f, -1.55118123e-01f, -1.72167808e-01f, -1.50909163e-02f, 2.31431589e-01f,
  2.00579077e-01f, 3.09245676e-01f, 2.21975029e-01f, -2.95650791e-02f, -9.21486020e-02f, -1.87318832e-01f, -3.55694175e-01f, -2.47262388e-01f, -4.02705908e-01f, -3.35715741e-01f,
  -4.60762322e-01f, -3.50852728e-01f, 1.76831141e-01f, 3.44315879e-02f, 3.18253934e-02f, 1.22325301e-01f, 1.27955824e-01f, 1.22340195e-01f, 2.39308864e-01f, 1.16054773e-01f,
  -1.06610924e-01f, 1.18163386e-02f, -7.55216703e-02f, -1.34639107e-02f, 5.66011630e-02f, 5.94092980e-02f, -4.02145125e-02f, 6.83383048e-02f, -1.33013660e-02f, -1.26376018e-01f,
  -2.03146562e-01f, -9.98703912e-02f, -6.05872832e-02f, 3.37524712e-02f, -4.94728349e-02f, -1.24914022e-02f, -1.09181926e-01f, -1.36347383e-01f, -1.66792512e-01f, 2.27560222e-01f,
  -3.25336829e-02f, 1.39410838e-01f, -1.52084053e-01f, -1.15533568e-01f, 2.02084165e-02f, 1.69960052e-01f, 1.55450672e-01f, 2.25586761e-02f, -5.02544641e-02f, 3.62690762e-02f,
  1.40568301e-01f, -1.82465240e-01f, -6.28946126e-02f, 1.35693014e-01f, -9.09266472e-02f, -8.16373676e-02f, -4.34726998e-02f, -1.29023224e-01f, -1.32931739e-01f, -2.48118918e-02f,
  -6.96569309e-02f, -2.05083247e-02f, 4.32324735e-03f, -1.96111649e-02f, -1.70106605e-01f, 1.28770936e-02f, -6.94283545e-02f, -9.65828449e-02f, 8.24403688e-02f, 1.50212243e-01f,
  2.28112087e-01f, -5.61371982e-01f, 1.58174440e-01f, -2.95759924e-02f, -1.38351426e-01f, 4.40560691e-02f, -2.69193411e-01f, -5.96099012e-02f, -1.15499669e-03f, 2.11692527e-02f,
  -1.40703365e-01f, -7.23598674e-02f, -1.49677426e-01f, 1.25407159e-01f, 1.20843038e-01f, -9.27847400e-02f, -2.13734079e-02f, 2.35460363e-02f, -6.32163584e-02f, -3.06163151e-02f,
  6.47104532e-02f, 1.75885767e-01f, 1.62155762e-01f, 2.07277194e-01f, 9.57452431e-02f, 4.05578949e-02f, 1.05160214e-01f, 1.39352798e-01f, 6.84786364e-02f, 3.85745615e-01f,
  -9.44663882e-02f, -3.34295034e-01f, 3.83927941e-01f, -2.75520474e-01f, -3.10490485e-02f, 7.21537843e-02f, -1.25055611e-01f, -1.68893397e-01f, -3.87598760e-02f, -1.03253983e-02f,
  7.51953945e-02f, 2.33566225e-01f, 3.16931784e-01f, 1.57886505e-01f, 1.56254098e-01f, 1.58333592e-02f, 1.10259771e-01f, 1.91681787e-01f, 1.30522341e-01f, -7.57510290e-02f,
  -2.77799636e-01f, -2.25500479e-01f, -2.46086493e-01f, -1.08350955e-01f, -1.44939318e-01f, 5.07705361e-02f, -2.95892674e-02f, -5.97983338e-02f, 1.33208768e-03f, -1.15273977e-02f,
  3.01695645e-01f, -1.69260815e-01f, 8.28563347e-02f, -6.36771768e-02f, -1.72882631e-01f, -2.29772087e-02f, 6.00903705e-02f, 2.77205482e-02f, 2.13784073e-02f, -7.21666738e-02f,
  -5.22329286e-02f, -1.14697099e-01f, 3.04832961e-02f, -9.76895615e-02f, -2.40824163e-01f, -1.15140632e-01f, -1.60267010e-01f, -8.46229196e-02f, -6.43922240e-02f, -1.16423249e-01f,
  -7.52453506e-02f, -1.23172857e-01f, -5.28339855e-02f, -3.65650542e-02f, -9.15320367e-02f, 1.45469010e-01f, -9.90540311e-02f, -6.66011572e-02f, -1.13444336e-01f, -2.46362120e-01f,
  -7.42058828e-02f, -1.65986791e-02f, -2.40399148e-02f, -1.41435713e-02f, 1.00467987e-01f, 1.61436513e-01f, 1.57124680e-02f, -1.21140555e-02f, -3.33552323e-02f, -1.21602781e-01f,
  -1.47823110e-01f, -7.59370327e-02f, 3.85794230e-02f, 2.05111168e-02f, 7.36127645e-02f, 1.95731949e-02f, -5.32787144e-02f, -8.40218291e-02f, 1.05691150e-01f, -1.85862761e-02f,
  5.47894612e-02f, -4.63781431e-02f, 1.13560662e-01f, -4.07649763e-02f, 5.79028204e-02f, -6.08541770e-03f, 1.29216775e-01f, 7.85338804e-02f, 7.82493502e-02f, -2.67134123e-02f,
  -2.07729384e-01f, 2.91549057e-01f, 1.97886810e-01f, -1.59863532e-02f, -1.86978951e-02f, -5.62915802e-02f, 5.53732067e-02f, -2.94520683e-03f, 1.01806149e-01f, 8.03589225e-02f,
  -7.28219897e-02f, -8.21315348e-02f, -3.17555293e-02f, -7.89920092e-02f, 3.35492417e-02f, -3.86623517e-02f, -1.56823136e-02f, 5.40347584e-02f, 2.22361600e-03f, -4.03073914e-02f,
  -2.06573799e-01f, -4.47312482e-02f, 1.60171062e-01f, 1.53986290e-01f, 2.38827262e-02f, 2.49222204e-01f, 1.21151946e-01f, 1.00533389e-01f, 6.41337633e-02f, -1.10184804e-01f,
  4.13369477e-01f, -1.17807597e-01f, 9.24248621e-02f, 1.47957042e-01f, -2.76564807e-01f, -3.41609120e-01f, -4.96820301e-01f, -2.38517925e-01f, -4.69171330e-02f, -1.31515235e-01f,
  -1.92312285e-01f, -5.41612618e-02f, -3.39336656e-02f, -1.10609181e-01f, -1.84188217e-01f, -1.28002986e-01f, -8.21916685e-02f, 1.44914135e-01f, 1.40249347e-02f, -1.51703298e-01f,
  -8.32429454e-02f, 2.46496305e-01f, 4.87944961e-01f, 1.78249002e-01f, 2.10317984e-01f, 4.94667850e-02f, 2.18204409e-01f, 2.42008120e-01f, 5.45548946e-02f, 2.45037377e-01f,
  3.58148068e-01f, 3.26490819e-01f, -2.42708042e-01f, 1.13190956e-01f, 1.00399539e-01f, -4.14285138e-02f, -3.22447158e-02f, 3.16550314e-01f, -1.48025766e-01f, -1.81594435e-02f,
  -7.92414993e-02f, 7.05112293e-02f, -9.97676700e-02f, -6.35182709e-02f, 1.49773723e-02f, -8.92026126e-02f, 1.77440181e-01f, 8.25111493e-02f, 6.23835064e-02f, 2.91676093e-02f,
  -3.17987114e-01f, -5.38486708e-03f, -5.92851005e-02f, -1.81519032e-01f, -2.28183549e-02f, -9.32864994e-02f, -3.77010629e-02f, 3.90243679e-02f, 9.56951454e-02f, 2.66027093e-01f,
  -6.45967424e-02f, 7.74595365e-02f, -2.11139731e-02f, 3.95474993e-02f, -2.08869755e-01f, -1.45745248e-01f, 2.47669723e-02f, -7.13246092e-02f, 1.59905832e-02f, -1.34675533e-01f,
  -2.30365351e-01f, 5.40762544e-02f, 4.35664617e-02f, 3.06823831e-02f, -1.18207037e-01f, 9.33914632e-02f, -8.88156518e-02f, 8.62661675e-02f, 1.88621059e-02f, 3.48111056e-02f,
  1.90097149e-02f, -3.98134813e-03f, 1.04109876e-01f, -2.04972643e-02f, 6.94637001e-03f, 8.35788772e-02f, 9.39755291e-02f, -2.00802945e-02f, 4.43541147e-02f, 7.57323131e-02f,
  3.28872800e-02f, -3.05382431e-01f, -4.68344465e-02f, 1.13914073e-01f, 8.32130834e-02f, -5.32658063e-02f, -1.17096618e-01f, -1.23738088e-01f, -2.58784667e-02f, -1.39965966e-01f,
  -1.88670874e-01f, -1.42513767e-01f, -1.93939339e-02f, -1.53039455e-01f, -1.80580139e-01f, -3.40604857e-02f, -1.29503965e-01f, -2.48492554e-01f, -1.33773774e-01f, 1.48777440e-02f,
  -2.89545864e-01f, -2.60078847e-01f, -2.95782119e-01f, -3.21073413e-01f, -8.22150409e-02f, -3.00791860e-01f, -2.24474445e-01f, -2.67375052e-01f, -3.13359916e-01f, -3.98809075e-01f,
  -6.16006255e-01f, -2.42801771e-01f, 1.37550443e-01f, -4.86260056e-01f, 6.88746870e-02f, 3.06901515e-01f, 5.33646703e-01f, 4.33200076e-02f, -2.68248111e-01f, 1.21205606e-01f,
  -9.96188000e-02f, -4.32452917e-01f, -3.51413995e-01f, -1.20358467e-01f, 9.03709419e-03f, 6.23393714e-01f, 4.56074566e-01f, 3.43295150e-02f, 7.15260506e-02f, 2.12601036e-01f,
  6.18561506e-02f, -1.78592682e-01f, -2.58195013e-01f, -2.06650585e-01f, -2.67906219e-01f, -1.03634201e-01f, -1.42036319e-01f, -2.27930680e-01f, 9.09566283e-02f, -4.72623147e-02f,
  4.18206125e-01f, -3.97285491e-01f, 1.04505666e-01f, -2.10589752e-01f, -7.31518194e-02f, -2.00153649e-01f, -9.41407494e-03f, -2.55611658e-01f, -1.39160633e-01f, 3.82691100e-02f,
  -2.33228132e-01f, -1.57473505e-01f, -5.60448244e-02f, -9.38243046e-02f, -8.62358045e-03f, -6.78713694e-02f, -1.36069089e-01f, -1.87768459e-01f, -1.65656820e-01f, -8.49668775e-03f,
  -9.72021073e-02f, -8.21110383e-02f, 9.32439119e-02f, 6.47586212e-02f, -2.21599922e-01f, -4.01813537e-02f, -4.00607400e-02f, -2.05519021e-01f, -1.09070772e-02f, 1.34491056e-01f,
  1.78307146e-01f, 1.32327899e-01f, -1.28921598e-01f, -1.19413771e-01f, -5.26184076e-03f, 9.88569856e-02f, -5.05932346e-02f, -3.41055319e-02f, 9.26259626e-03f, -4.99610268e-02f,
  1.27988784e-02f, 6.17830530e-02f, 1.15225734e-02f, -2.99874358e-02f, -1.45915464e-01f, -1.44570202e-01f, 8.52320045e-02f, -1.05310351e-01f, -8.02185163e-02f, -1.26509249e-01f,
  -8.83074850e-02f, -9.80407093e-03f, -8.07042941e-02f, -3.56188193e-02f, 1.14979139e-02f, -1.04610279e-01f, -1.39239728e-01f, -1.12387791e-01f, -1.37491688e-01f, -1.15964942e-01f,
  1.00646034e-01f, -1.09692879e-01f, 8.56471732e-02f, -1.88373595e-01f, -1.00268506e-01f, -9.79792252e-02f, -2.10549548e-01f, -2.52677593e-02f, -9.37349498e-02f, 7.55665940e-04f,
  -1.52022526e-01f, -1.09031178e-01f, -7.44602829e-02f, 4.22933698e-02f, 2.08357632e-01f, 9.56835002e-02f, 3.04688457e-02f, 2.45167478e-03f, -1.81918833e-02f, 6.50722235e-02f,
  9.07201245e-02f, 2.44775757e-01f, 3.20647359e-01f, 2.95151353e-01f, 9.47149321e-02f, 2.03127742e-01f, 2.86780864e-01f, 9.44632664e-02f, 3.01211894e-01f, 4.03569043e-01f,
  -6.14959300e-01f, -1.66527331e-02f, -2.58951813e-01f, -4.00309861e-01f, -1.09247006e-01f, -1.66288577e-03f, 1.80417627e-01f, 3.07760239e-01f, -4.52815704e-02f, 5.86986095e-02f,
  1.50361776e-01f, -1.11394711e-01f, -2.51151353e-01f, -7.18491673e-02f, -1.87502623e-01f, -1.21838517e-01f, -3.64214540e-01f, -3.52841198e-01f, -1.54922396e-01f, 2.26188019e-01f,
  -1.07932452e-03f, -2.62178928e-01f, -3.14061731e-01f, -8.70493278e-02f, -4.54942323e-02f, -9.43023115e-02f, -1.82040289e-01f, -2.56681651e-01f, -1.35080621e-01f, -2.83767134e-01f,
  2.60342836e-01f, -1.47171050e-01f, -5.85267786e-03f, -1.00567438e-01f, -3.83581184e-02f, 8.52689147e-02f, -2.22546272e-02f, -5.62885553e-02f, -6.90762773e-02f, 6.21101819e-02f,
  -1.20904684e-01f, 8.96184668e-02f, 1.18488790e-02f, 1.97590798e-01f, 1.34400334e-02f, 8.21731538e-02f, -3.58935967e-02f, -1.29484177e-01f, -1.91995949e-01f, 2.36864120e-01f,
  4.72937850e-03f, -3.60170573e-01f, -2.68997014e-01f, -8.58838670e-04f, 1.57302439e-01f, -2.83248156e-01f, 2.44662285e-01f, 1.92841560e-01f, 5.17791025e-02f, 2.13609233e-01f,
  1.10450618e-01f, 1.62757095e-02f, 4.82099727e-02f, 5.27587421e-02f, 1.43492013e-01f, 3.03774513e-02f, -3.37097459e-02f, 2.47378182e-02f, 8.03656504e-02f, 6.26085550e-02f,
  7.60656297e-02f, 9.05724168e-02f, 1.08301692e-01f, -2.85999514e-02f, -5.26499376e-03f, -5.99090904e-02f, -6.36653081e-02f, 4.73556202e-03f, 9.49039031e-03f, -4.46551517e-02f,
  -1.22300396e-02f, 3.62013057e-02f, -5.65800741e-02f, 1.03022844e-01f, 5.46533689e-02f, 3.68243195e-02f, 9.16765332e-02f, 6.63700178e-02f, 8.48049447e-02f, 5.28250225e-02f,
  2.48011515e-01f, -2.87160128e-01f, 1.34073440e-02f, -5.44899032e-02f, -8.30089748e-02f, 3.00207008e-02f, -5.28918467e-02f, 1.10293610e-03f, -6.46218285e-02f, 9.66171920e-02f,
  6.80072382e-02f, 1.45724162e-01f, 1.15410134e-01f, 1.61076799e-01f, 7.40306228e-02f, 1.62641898e-01f, 3.01452000e-02f, -1.52122483e-01f, -1.22838780e-01f, 1.29074186e-01f,
  8.66970234e-03f, -8.31811428e-02f, -9.56809670e-02f, -8.33396614e-03f, 1.93341859e-02f, -2.15098709e-01f, 1.62244976e-01f, 1.55526996e-01f, -1.28033563e-01f, 2.15462148e-01f,
  3.00084919e-01f, 6.52413130e-01f, 2.83731166e-02f, 3.57887484e-02f, -1.89065352e-01f, -3.62662166e-01f, -2.86112547e-01f, -8.32104906e-02f, 6.03091568e-02f, 1.01227991e-01f,
  2.32024133e-01f, 2.46300399e-01f, 2.19342634e-01f, 2.20638543e-01f, 2.03010708e-01f, 1.93132952e-01f, 7.84072876e-02f, 2.43212968e-01f, 9.72688012e-03f, -4.40393761e-02f,
  2.18309700e-01f, 2.84967095e-01f, 4.63976890e-01f, 2.57471293e-01f, 2.26030171e-01f, 1.58861116e-01f, 1.31885737e-01f, 5.83298504e-02f, 2.04205751e-01f, 4.90256876e-01f,
  2.34556496e-01f, -3.42771530e-01f, 2.60929912e-02f, 1.42107308e-01f, 9.51441452e-02f, 1.36785626e-01f, 3.07776090e-02f, 3.15490514e-02f, -6.92358688e-02f, 3.46483337e-03f,
  7.65763745e-02f, 5.83867207e-02f, -4.82284836e-02f, 1.97313223e-02f, -1.58710077e-01f, -1.11875668e-01f, -1.78465977e-01f, -1.15664631e-01f, -3.65179479e-02f, -2.39861328e-02f,
  -5.96674643e-02f, -2.31459141e-01f, -2.25987196e-01f, -1.22343622e-01f, -1.72952473e-01f, -1.04555555e-01f, -1.00186497e-01f, -1.70246556e-01f, -2.54011452e-01f, -7.59108216e-02f,
  -2.44305909e-01f, -9.94755402e-02f, -2.91800976e-01f, -2.67866164e-01f, -2.77795821e-01f, -1.66436613e-01f, -1.13386475e-01f, -5.48326783e-02f, -2.98480857e-02f, -2.20299400e-02f,
  -1.24039061e-01f, -2.90262312e-01f, -2.39118055e-01f, 3.74739356e-02f, 1.69345379e-01f, -1.57396063e-01f, -4.33294512e-02f, -2.26007894e-01f, -2.49266073e-01f, -2.31655851e-01f,
  -1.57370195e-01f, -3.15241776e-02f, 1.63682535e-01f, -5.82899759e-03f, -2.14881450e-02f, -1.84037164e-01f, -1.38781536e-02f, 5.88047728e-02f, 2.93931719e-02f, 2.03286707e-01f,
  2.39223912e-01f, -3.65589470e-01f, 6.98272362e-02f, 1.42326757e-01f, -2.29735882e-03f, 6.21639527e-02f, -1.03350468e-01f, 2.45639142e-02f, 9.35812518e-02f, -1.14962794e-01f,
  1.41666951e-02f, 1.25445455e-01f, 1.21606104e-01f, 9.28009227e-02f, 2.10431386e-02f, -1.26222208e-01f, -5.23063205e-02f, 5.80898933e-02f, 2.26706248e-02f, 3.79783697e-02f,
  1.48682475e-01f, 1.19446823e-02f, -2.38526128e-02f, -6.70934282e-03f, -1.03203051e-01f, 1.22144058e-01f, 9.52951163e-02f, -4.81698737e-02f, -4.01428640e-02f, 1.67675361e-01f,
  1.62284654e-02f, -2.25710765e-01f, 6.10231869e-02f, -1.45629704e-01f, 2.72303611e-01f, 4.05688375e-01f, 4.19267625e-01f, 3.70984226e-02f, -3.69900912e-01f, -1.24174386e-01f,
  -2.18888104e-01f, -5.34026086e-01f, -5.80461025e-01f, -3.74932379e-01f, -2.62318879e-01f, -2.41770864e-01f, -4.00937229e-01f, -2.20132202e-01f, 1.41130105e-01f, 3.59511048e-01f,
  1.73936170e-02f, 3.95428948e-02f, -1.86169803e-01f, -1.53396964e-01f, -2.22966343e-01f, -4.24498588e-01f, -3.29014868e-01f, -8.18857625e-02f, -9.56751704e-02f, -5.07789552e-01f,
  3.93957645e-02f, 2.04132527e-01f, -2.67782398e-02f, -5.59664741e-02f, 1.36032894e-01f, -7.23369867e-02f, -8.73245522e-02f, 3.60394642e-02f, 4.60387170e-02f, 4.72668819e-02f,
  -9.00429115e-02f, -2.11217850e-02f, -1.00418422e-02f, 1.91122115e-01f, 2.60914385e-01f, 1.31225631e-01f, 1.08616494e-01f, 1.49943054e-01f, 2.18759701e-02f, 1.03609283e-02f,
  -6.67729825e-02f, 2.90639490e-01f, 2.64324248e-01f, 2.35798471e-02f, 5.33620827e-02f, 4.55370289e-04f, 1.16193265e-01f, 1.07328124e-01f, 1.17753647e-01f, 1.09118707e-02f,
  -1.01960436e-01f, -9.29645523e-02f, 2.36779526e-01f, 1.43025920e-01f, 6.91135451e-02f, 1.58515528e-01f, 8.18177387e-02f, 5.04200496e-02f, -4.96837050e-02f, 3.72917652e-02f,
  -4.40334389e-03f, 6.01441786e-02f, 6.94495589e-02f, 3.35851707e-03f, -1.08447269e-01f, -1.22281991e-01f, -1.25041429e-03f, 8.05726573e-02f, 1.70915332e-02f, 3.61540914e-03f,
  8.64478797e-02f, -7.81818479e-02f, -7.10154846e-02f, 1.48928270e-01f, 1.80199191e-01f, 1.34025561e-02f, -8.76898989e-02f, -2.13507060e-02f, -1.18907332e-01f, -2.35207483e-01f,
  1.11754015e-01f, 3.05713177e-01f, -2.51262605e-01f, -1.93710476e-01f, 1.29071278e-02f, -7.01945946e-02f, -3.02319825e-02f, 3.50230634e-02f, 7.67702311e-02f, 1.71569556e-01f,
  1.09966025e-01f, -1.05343282e-01f, 9.52662155e-03f, 7.08064362e-02f, 1.27089247e-01f, 1.50012478e-01f, 1.78862616e-01f, 2.53088363e-02f, -2.05248408e-02f, 2.92805079e-02f,
  -7.50960186e-02f, 8.04451481e-03f, -6.91738054e-02f, 5.39949648e-02f, -1.05615772e-01f, -9.21651572e-02f, 4.61495891e-02f, 2.36455694e-01f, 1.32157385e-01f, 9.63065252e-02f,
  6.03404522e-01f, -2.26298720e-01f, -5.75417638e-01f, -6.56370819e-02f, -3.01132679e-01f, -2.21558452e-01f, -8.86292532e-02f, 1.86860740e-01f, 7.59499297e-02f, -1.51172593e-01f,
  -1.89573318e-02f, 2.25568622e-01f, -1.10034727e-01f, 9.98655260e-02f, 2.75235116e-01f, -3.37886035e-01f, -3.73477340e-01f, -1.39681146e-01f, 2.90079206e-01f, 3.71585131e-01f,
  1.99910864e-01f, 9.16767716e-02f, 1.36751667e-01f, -1.52364522e-02f, -3.05903107e-01f, -1.02048278e-01f, -4.80106562e-01f, -1.99198946e-01f, -1.56586364e-01f, -4.71192807e-01f,
  -4.66077924e-01f, -2.75758862e-01f, 3.16490680e-02f, 1.11874536e-01f, -1.33769676e-01f, 5.22972271e-02f, -1.58383641e-02f, -1.09295256e-01f, 3.41207045e-03f, -1.01333357e-01f,
  -1.72271147e-01f, 8.30225274e-02f, 3.07682753e-02f, -1.37625530e-01f, -5.43075614e-02f, 3.69806588e-02f, -2.00036988e-01f, -3.66723537e-02f, -9.50772017e-02f, -1.51080430e-01f,
  -1.10922664e-01f, -1.70161426e-01f, -2.11393058e-01f, -1.20008208e-01f, -1.63481951e-01f, -1.73628610e-02f, -1.65297627e-01f, -6.87267557e-02f, -1.62276492e-01f, -5.10449521e-02f,
  -1.91291012e-02f, 3.08500323e-02f, 1.13886580e-01f, 1.36936173e-01f, 1.94866389e-01f, 1.16598301e-01f, 8.23977888e-02f, 1.39726564e-01f, 1.09289736e-01f, 1.88502774e-01f,
  1.15006499e-01f, -7.48995915e-02f, 6.83408082e-02f, 1.16507178e-02f, -1.52574396e-02f, -8.35654810e-02f, -2.96256114e-02f, -1.42428363e-02f, -2.21966188e-02f, 1.21593736e-01f,
  1.86768860e-01f, 1.95285352e-03f, -1.69268101e-02f, 7.50781745e-02f, -6.42031059e-02f, -5.79700060e-02f, -7.06242770e-02f, 1.66855320e-01f, 1.15902700e-01f, -4.40443717e-02f,
  3.78181458e-01f, 4.34458032e-02f, 6.91484138e-02f, 1.06997326e-01f, -1.28738552e-01f, -5.52781299e-03f, 1.34745920e-02f, -3.28211747e-02f, -2.05262586e-01f, 3.80146205e-02f,
  2.55800076e-02f, 2.04139516e-01f, 3.68756354e-02f, 9.42565873e-02f, 1.61638573e-01f, 6.25644578e-03f, 2.00768426e-01f, -7.13357255e-02f, 9.69437063e-02f, -5.61428554e-02f,
  -2.11113989e-02f, 2.63176620e-01f, 3.12988281e-01f, 1.53686941e-01f, 7.70530924e-02f, 1.70219719e-01f, 6.42211735e-02f, 1.05067961e-01f, 1.73458040e-01f, 3.54384392e-01f,
  -5.41643918e-01f, -4.20474373e-02f, -2.42528006e-01f, 5.02495803e-02f, -1.57566085e-01f, -4.21949737e-02f, 1.89354599e-01f, 1.93240196e-01f, 1.57660201e-01f, 4.64126468e-02f,
  -2.18460009e-01f, -1.59578919e-01f, 8.47035050e-02f, 1.10560164e-01f, 1.02103554e-01f, 2.40761802e-01f, 4.31132168e-01f, 1.06847025e-01f, -2.45630488e-01f, -3.26237172e-01f,
  1.09151103e-01f, 2.07529902e-01f, 4.75579798e-02f, 1.05301902e-01f, 2.82723014e-03f, 1.46860868e-01f, 2.26232812e-01f, -1.19839378e-01f, -6.65133819e-02f, -1.19040921e-01f,
  -4.72967505e-01f, -3.97085786e-01f, -1.38935409e-02f, -2.22923324e-01f, -1.99311137e-01f, -6.27943054e-02f, -3.70180421e-02f, -1.16293758e-01f, -1.58121556e-01f, -1.18103057e-01f,
  -2.15859681e-01f, -2.83670217e-01f, -2.10660443e-01f, 3.90829779e-02f, -1.72839575e-02f, -6.24028370e-02f, 1.28889158e-01f, 3.77031341e-02f, 6.42587915e-02f, -2.88327128e-01f,
  -2.05378514e-03f, -5.06159246e-01f, -5.24798214e-01f, 2.92235110e-02f, -9.36325490e-02f, -1.91413239e-02f, -1.63970083e-01f, -3.51359755e-01f, 9.29971319e-03f, -2.48114675e-01f,
  -1.18402898e-01f, -8.69719461e-02f, 2.18724273e-02f, 9.55711082e-02f, 1.30789995e-01f, 8.13987032e-02f, 4.95411940e-02f, 7.88372532e-02f, -1.26678780e-01f, -9.95859280e-02f,
  -5.34984916e-02f, -1.01517037e-01f, -2.14288756e-02f, -1.27109811e-01f, -6.26525655e-02f, -4.43709120e-02f, -8.82532541e-03f, 1.67651162e-01f, 2.29258351e-02f, 4.25261259e-02f,
  2.56580058e-02f, -2.65257191e-02f, 2.30758525e-02f, 1.02274470e-01f, 6.22431859e-02f, 9.49554741e-02f, 2.76605058e-02f, -5.90871349e-02f, -9.45742521e-03f, 5.66366613e-02f,
  3.60471427e-01f, 3.26846480e-01f, -1.32216528e-01f, 5.25223985e-02f, -1.01208694e-01f, 4.17365469e-02f, 5.48468642e-02f, -4.07226346e-02f, -8.97649005e-02f, -1.25652909e-01f,
  -1.73968256e-01f, -1.79833174e-01f, 7.03827217e-02f, 1.01494163e-01f, -1.21945553e-01f, -7.94012323e-02f, 3.08198053e-02f, -1.86475873e-01f, 3.65487416e-03f, -1.19414173e-01f,
  2.52932191e-01f, -1.44748256e-01f, -2.35548377e-01f, 5.70193492e-02f, -1.35601804e-01f, -5.63085526e-02f, -1.14067458e-01f, -1.19953975e-01f, 8.20142031e-02f, 1.49932563e-01f,
  7.16548443e-01f, 4.86289680e-01f, 3.45606685e-01f, 3.14145982e-01f, -2.93299276e-02f, 3.40539627e-02f, 2.64425576e-01f, 2.27997869e-01f, 4.94831093e-02f, 3.05329889e-01f,
  1.85395241e-01f, 8.00709501e-02f, -1.81300137e-02f, -2.59790607e-02f, 2.35092863e-01f, 1.56364515e-01f, 9.45384242e-03f, 1.21556267e-01f, 1.13180652e-01f, 1.86381802e-01f,
  1.04407601e-01f, 1.46839663e-01f, 1.28803670e-01f, 1.39253125e-01f, 1.65448964e-01f, 1.33136660e-02f, 1.36391982e-01f, 2.57809341e-01f, 1.81609720e-01f, 2.09713176e-01f,
  1.72508746e-01f, 4.39209342e-01f, -2.21157104e-01f, -9.10597742e-02f, -1.45239998e-02f, -3.30478186e-04f, -6.47042505e-03f, -3.26754116e-02f, -1.07409678e-01f, -1.38391525e-01f,
  -1.06003106e-01f, 1.87031217e-02f, -4.19110954e-02f, -6.35053813e-02f, -3.58543359e-02f, -4.28223796e-02f, 4.17991914e-02f, 5.37293926e-02f, -9.68574956e-02f, 8.19998235e-02f,
  -3.76443788e-02f, -4.33678925e-02f, 1.80209763e-02f, -1.16255701e-01f, 1.87047765e-01f, -1.60708055e-01f, 1.11756593e-01f, 1.01882786e-01f, 2.53257807e-02f, 1.24528445e-01f,
  -1.71985686e-01f, 2.74948806e-01f, 2.17670649e-01f, 2.03285277e-01f, 1.32310450e-01f, 3.50160785e-02f, 7.10599422e-02f, 7.65278190e-02f, 3.27907763e-02f, 1.13923497e-01f,
  9.50387046e-02f, 1.51880667e-01f, 1.36756282e-02f, 1.21764183e-01f, 4.95533720e-02f, 2.04630457e-02f, 5.81618585e-02f, 6.99801072e-02f, -1.21622009e-03f, -6.29011989e-02f,
  6.17908426e-02f, -3.36502604e-02f, -6.40001073e-02f, 1.12580433e-01f, -2.41155103e-02f, 9.93555859e-02f, -1.90208964e-02f, 2.78121978e-02f, 8.22154954e-02f, -5.58159575e-02f,
  -6.36271238e-01f, -2.08771497e-01f, -4.51505110e-02f, -9.88291651e-02f, 1.00286864e-01f, -6.66278228e-02f, 9.05563012e-02f, -1.45769045e-01f, -1.30243689e-01f, -4.68112193e-02f,
  -6.59648255e-02f, 3.79391462e-02f, -1.14501482e-02f, -7.77085423e-02f, -1.11678302e-01f, -1.37813732e-01f, -9.36841369e-02f, -1.64073348e-01f, -2.16839284e-01f, -1.19790003e-01f,
  -1.83250025e-01f, -1.22301735e-01f, -1.84867218e-01f, -1.80006281e-01f, -1.09750398e-01f, -2.64678061e-01f, -2.22213104e-01f, -1.02302290e-01f, -1.30045131e-01f, -5.34405038e-02f,
  -3.42309326e-01f, -1.17691949e-01f, -5.26945055e-01f, -4.20603186e-01f, -5.73279969e-02f, 1.28696218e-01f, 4.01128352e-01f, 3.50006446e-02f, -2.84756064e-01f, -9.97736678e-03f,
  1.09568432e-01f, 3.33007146e-03f, -2.10425839e-01f, 8.47251043e-02f, 2.52865195e-01f, 1.27144694e-01f, 1.44554712e-02f, -4.61426415e-02f, 1.40354887e-01f, 5.05443871e-01f,
  3.17015111e-01f, -6.17223978e-02f, -2.31194571e-01f, -2.18683407e-02f, -1.02398835e-01f, 1.19929551e-03f, -3.60859215e-01f, -1.26416311e-01f, 1.58713952e-01f, 7.36540854e-02f,
  -1.83478951e-01f, -2.02313155e-01f, 1.02061018e-01f, 2.10269429e-02f, 1.90607924e-02f, 1.16954021e-01f, 1.15142949e-01f, -2.02903852e-01f, 1.07332103e-01f, 9.36462637e-03f,
  -4.31327568e-03f, 5.69490567e-02f, -1.25821307e-01f, 7.70652592e-02f, -1.41904637e-01f, 7.63702095e-02f, -1.76844269e-01f, -3.25192884e-02f, -1.00213788e-01f, 2.68788394e-02f,
  3.18849951e-01f, 3.34601216e-02f, -3.75644088e-01f, -1.44359395e-02f, -2.72375043e-03f, -2.44634643e-01f, -1.35205075e-01f, 6.40361682e-02f, -1.23100109e-01f, -1.37729526e-01f,
  -1.94384642e-02f, -8.92831907e-02f, -1.18742265e-01f, -8.96264687e-02f, 1.31217629e-01f, -3.90351713e-02f, -8.89995471e-02f, 1.49285287e-01f, 1.33175135e-01f, -2.50724796e-02f,
  -9.98441949e-02f, 8.59376916e-04f, 4.01390530e-02f, -1.51674375e-02f, 2.42746696e-02f, -1.77461188e-02f, 1.20145768e-01f, 1.10488296e-01f, 3.34956869e-02f, 4.27214466e-02f,
  -2.52117105e-02f, 6.65892800e-03f, -2.16991916e-01f, 1.14398949e-01f, 2.36954335e-02f, -1.20846918e-02f, 3.34320217e-02f, 7.19799399e-02f, -1.14032216e-01f, 6.42857924e-02f,
  -4.19800997e-01f, 2.94149108e-02f, -1.28272176e-01f, -7.51537300e-05f, 7.11702276e-03f, -9.38999802e-02f, 1.10801108e-01f, 4.01040427e-02f, -2.07351968e-01f, 7.22165555e-02f,
  8.64160284e-02f, 1.52139338e-02f, -2.17687830e-01f, 1.09335490e-01f, 1.18694670e-01f, -6.56861514e-02f, 1.50165349e-01f, 5.01977094e-02f, -4.07536700e-02f, -1.56931937e-01f,
  -1.60929501e-01f, 1.31488040e-01f, -2.40430519e-01f, -4.20470536e-02f, -1.54002393e-02f, -1.81107864e-01f, -2.91021138e-01f, -4.39663380e-02f, -4.15258110e-02f, -6.75787702e-02f,
  6.75623834e-01f, -1.94528103e-01f, 1.73011988e-01f, 2.31150359e-01f, -2.09735632e-01f, -3.08359861e-02f, 2.53736041e-03f, 2.17033625e-01f, 2.46950641e-01f, 1.35996580e-01f,
  -3.97601306e-01f, -2.62448400e-01f, -2.05361098e-01f, -4.55918461e-02f, 9.31799710e-02f, 1.48403287e-01f, 2.96573639e-01f, 3.72317463e-01f, 3.03363144e-01f, 1.28017649e-01f,
  2.26190649e-02f, 2.92224675e-01f, 3.96516532e-01f, 2.20771506e-01f, -1.35528622e-02f, -8.21034536e-02f, 1.57458466e-02f, -5.07719703e-02f, -1.12481184e-01f, 6.30364046e-02f,
  3.37474830e-02f, 1.68445691e-01f, -1.43221885e-01f, -2.89252967e-01f, -2.20947757e-01f, 1.29373625e-01f, 4.85403277e-02f, 1.54851869e-01f, -8.20436478e-02f, 1.38105378e-01f,
  -2.99047679e-01f, -2.89961286e-02f, -2.41018265e-01f, -8.77189040e-02f, -1.14767678e-01f, 5.41478284e-02f, -2.55514793e-02f, 7.38230720e-02f, -1.72079913e-02f, -6.28498644e-02f,
  -2.91348487e-01f, 1.77548476e-03f, -9.83264446e-02f, -3.47095504e-02f, -4.12290692e-02f, -1.58721671e-01f, -1.27162293e-01f, 2.26674080e-02f, -3.35427709e-02f, 1.82602629e-01f,
  1.89869136e-01f, -2.49301139e-02f, -6.90985546e-02f, 3.58345173e-02f, 4.76821586e-02f, -1.30871218e-02f, -8.15984011e-02f, -1.20594837e-01f, -4.87124585e-02f, 1.00262076e-01f,
  2.50042006e-02f, 9.72651020e-02f, 2.90371124e-02f, 9.46073011e-02f, -1.18384048e-01f, -3.09798736e-02f, 2.03461889e-02f, -1.47205023e-02f, -8.18245187e-02f, 4.61703651e-02f,
  -1.90401860e-02f, 3.01882867e-02f, -1.01648644e-01f, -1.95757635e-02f, 9.92062837e-02f, 7.56691322e-02f, 1.19940870e-01f, 4.14659828e-02f, 5.41311353e-02f, 1.73300296e-01f,
  1.20701650e-02f, -3.19883496e-01f, 8.33512619e-02f, -7.49108568e-02f, -1.01415008e-01f, -2.32318550e-01f, -1.98493972e-01f, -6.77764788e-02f, -1.38728067e-01f, -5.83902858e-02f,
  -2.10719243e-01f, -1.38813302e-01f, -1.63507327e-01f, -1.63071137e-02f, 1.47328183e-01f, 4.20386344e-02f, -2.00718522e-01f, -3.77216525e-02f, -1.08324476e-01f, -2.45858114e-02f,
  -1.22523025e-01f, 1.90642908e-01f, 2.43941948e-01f, -5.27239731e-03f, -1.40981972e-01f, 6.26981482e-02f, 4.49901596e-02f, 5.14893159e-02f, 4.29734103e-02f, 2.66661942e-01f,
  -5.08933127e-01f, 1.21423297e-01f, 2.90697396e-01f, 1.33277640e-01f, 3.74876440e-01f, 4.25708927e-02f, -2.24505514e-01f, -2.45106757e-01f, 4.87441346e-02f, 1.29797280e-01f,
  1.81443729e-02f, 1.28037585e-02f, 1.91517979e-01f, -5.31228855e-02f, -2.51616865e-01f, 1.32256404e-01f, 2.89742708e-01f, -2.80780997e-02f, -3.62936437e-01f, -3.17264855e-01f,
  6.87826797e-02f, -1.00483261e-01f, -3.05752546e-01f, -1.63806766e-01f, 2.78300881e-01f, 1.02874823e-01f, 2.32832193e-01f, 1.89572290e-01f, 7.58368745e-02f, 4.39475954e-01f,
  6.54000491e-02f, -1.97305441e-01f, -1.11598395e-01f, -1.64094977e-02f, 2.06867874e-01f, -2.34409988e-01f, -1.47898316e-01f, 7.31609836e-02f, 8.56182724e-02f, -5.08638434e-02f,
  1.12164952e-01f, 4.78841476e-02f, 2.19393179e-01f, 3.56262736e-03f, -8.82666185e-02f, -2.54442275e-01f, -1.56020343e-01f, -2.81497091e-01f, -1.55363187e-01f, -1.57319292e-01f,
  1.95434079e-01f, 2.91141085e-02f, -4.22065221e-02f, -1.22820988e-01f, -1.30065978e-01f, -1.35183737e-01f, -2.40213051e-01f, -2.67780900e-01f, -3.76891196e-01f, -2.02433690e-01f,
  -4.64837141e-02f, -1.61731578e-02f, 7.62251318e-02f, -2.21066177e-02f, -7.21683055e-02f, 9.45102945e-02f, 1.46940887e-01f, -5.27233183e-02f, 3.41638178e-02f, 2.67164409e-02f,
  5.32072186e-02f, -4.41615656e-02f, -6.05888255e-02f, 9.93944611e-03f, -9.06063467e-02f, -9.50825438e-02f, -2.50628684e-02f, -5.75399324e-02f, 3.41484100e-02f, -1.05575413e-01f,
  -1.66849233e-02f, -1.06660910e-02f, 5.26495464e-02f, -7.25044906e-02f, 9.53792557e-02f, 9.75244865e-03f, -2.40613315e-02f, -1.64507315e-01f, -1.17145464e-01f, -7.00520277e-02f,
  -1.43704131e-01f, -6.76484704e-02f, 3.11025847e-02f, -1.84314013e-01f, 2.92865466e-02f, -2.77324393e-02f, -1.68152135e-02f, -7.73228779e-02f, 1.30761027e-01f, -1.06026061e-01f,
  -1.48276404e-01f, -1.43829420e-01f, 1.94191411e-01f, -7.27388039e-02f, -6.17508404e-02f, -7.73005141e-03f, 8.22183117e-02f, -2.02004053e-02f, -8.80477428e-02f, -1.29389567e-02f,
  1.81244150e-01f, -2.45508090e-01f, -2.04129025e-01f, -1.81795638e-02f, -1.12510119e-02f, -2.81327695e-01f, -2.03756630e-01f, -2.38141567e-01f, -3.46244663e-01f, -4.09639269e-01f,
  -5.99838793e-01f, 2.00512752e-01f, -6.01463169e-02f, 1.78213164e-01f, 3.38477910e-01f, 2.98112482e-01f, 3.99748176e-01f, 3.52220774e-01f, 3.05118769e-01f, 1.92004025e-01f,
  3.58810574e-01f, 3.92599136e-01f, 4.12324995e-01f, 2.95990258e-01f, 2.92510122e-01f, 2.34716758e-01f, 3.05168360e-01f, -5.17584197e-02f, 1.98315904e-02f, 1.98432490e-01f,
  3.41956258e-01f, 5.89388832e-02f, -2.01598406e-01f, -5.03758378e-02f, 1.77971765e-01f, 3.67504269e-01f, 3.44253659e-01f, 2.70168900e-01f, 3.04174453e-01f, 2.44292617e-01f,
  2.96794504e-01f, -1.03977874e-01f, -1.08270317e-01f, -3.91012169e-02f, -1.82042599e-01f, -3.21176797e-01f, -1.46315172e-01f, -1.27901718e-01f, -3.16474102e-02f, -2.45608669e-02f,
  -1.66224554e-01f, -1.33175954e-01f, -8.41504931e-02f, -7.80505985e-02f, -8.91882703e-02f, -1.23786449e-01f, -2.08137646e-01f, 1.60904527e-01f, 1.04606755e-01f, -1.90242007e-03f,
  7.02731907e-02f, 3.60679068e-02f, 6.78315759e-02f, 1.43893227e-01f, 1.31478382e-05f, 2.14924756e-02f, -5.46476543e-02f, -4.57606837e-02f, -2.33794451e-02f, 6.04448132e-02f,
  1.26715198e-01f, -1.39560148e-01f, -1.34038366e-03f, 7.60907531e-02f, -2.75624227e-02f, -1.30352080e-01f, 4.71444502e-02f, 8.45308900e-02f, 5.48304692e-02f, -1.67618901e-01f,
  1.39719188e-01f, 1.71862081e-01f, 4.75127697e-02f, 1.53111115e-01f, -1.98254883e-01f, -1.54591307e-01f, -4.55605015e-02f, 3.01832496e-03f, -1.08733945e-01f, -1.41245171e-01f,
  -4.96604927e-02f, -4.70584854e-02f, -2.24207878e-01f, -9.26602259e-02f, 6.60089701e-02f, 9.66818705e-02f, -3.95101942e-02f, 6.26228824e-02f, -9.64182988e-03f, -5.67571707e-02f,
  5.19927979e-01f, 9.57494974e-02f, -7.25300610e-02f, -1.19040102e-01f, -1.14260532e-01f, -2.50433177e-01f, 1.44784618e-02f, 1.34045482e-02f, -1.41887814e-01f, 5.92996813e-02f,
  -7.80186206e-02f, -2.63922215e-01f, -1.09076478e-01f, -2.20462456e-02f, -2.11599588e-01f, -1.64452180e-01f, -1.09970562e-01f, 2.12560162e-01f, 1.71768218e-01f, 4.74099070e-02f,
  -1.50283109e-02f, 1.43182352e-01f, 4.18245159e-02f, 2.56328937e-02f, 1.59499049e-02f, -5.78340925e-02f, 6.80977944e-04f, 3.77562977e-02f, 6.97919726e-02f, -7.45567679e-03f,
  -4.13873911e-01f, -3.20365310e-01f, 2.24120066e-01f, -3.42081040e-01f, -1.18942469e-01f, -1.18088126e-01f, -2.99521625e-01f, -1.15728892e-01f, -1.22691495e-02f, -2.28909940e-01f,
  -2.88210288e-02f, -1.28611363e-02f, -7.88854510e-02f, -4.53281701e-02f, -1.34472385e-01f, -2.39012972e-01f, -9.80448574e-02f, 3.70697398e-03f, 3.82178128e-02f, -1.34728462e-01f,
  -1.69422075e-01f, -5.89944273e-02f, -2.90409066e-02f, -7.68411625e-03f, -2.67095447e-01f, -1.02968574e-01f, -8.52018595e-03f, -1.96136802e-01f, -1.21992029e-01f, -3.37384522e-01f,
  -2.17711508e-01f, -1.56451881e-01f, 2.54294842e-01f, 1.15471473e-02f, 7.19390213e-02f, 9.34676267e-03f, -3.69517095e-02f, 9.47106332e-02f, 3.10931094e-02f, -3.98351252e-02f,
  -8.86948407e-02f, 1.13343718e-02f, -1.17710233e-02f, -1.66154578e-02f, -7.22223148e-02f, -5.03075905e-02f, 1.46409675e-01f, 8.28878805e-02f, 2.64886636e-02f, 4.85912487e-02f,
  -1.38479307e-01f, -1.59388497e-01f, -1.38424218e-01f, 6.14993758e-02f, 4.44965390e-03f, 2.63577159e-02f, -2.10376773e-02f, -6.58831149e-02f, -1.18915476e-02f, -3.23150814e-01f,
  2.52384394e-02f, 5.21145836e-02f, 3.17699537e-02f, 8.35900102e-03f, -5.88677824e-02f, 1.66191496e-02f, -9.75730494e-02f, -1.26682054e-02f, 4.95929122e-02f, -9.84879583e-02f,
  2.95775454e-03f, 4.75896709e-02f, 6.39927834e-02f, -8.58688653e-02f, -1.24650687e-01f, -4.77122478e-02f, -7.95033276e-02f, -3.60622294e-02f, -4.23733778e-02f, -4.91303802e-02f,
  -3.43349688e-02f, -2.72613857e-02f, 3.35825095e-03f, -2.38869432e-02f, 1.03991479e-02f, 2.75352355e-02f, 4.41722125e-02f, 3.78880985e-02f, 2.30850503e-02f, -1.02119455e-02f,
  -1.90214857e-01f, 3.19899529e-01f, -2.93702692e-01f, -6.84201941e-02f, -3.45592201e-02f, 8.65850300e-02f, -5.81656285e-02f, 8.57024565e-02f, 4.28087041e-02f, -2.35152319e-02f,
  -1.99278835e-02f, -9.30445120e-02f, -1.25887111e-01f, 5.57576306e-02f, 4.94269766e-02f, -4.32498492e-02f, -7.40276575e-02f, -9.75394845e-02f, -3.92920487e-02f, -2.54671294e-02f,
  -1.01688825e-01f, -2.63709366e-01f, -3.62187773e-01f, -2.07396850e-01f, -2.29403779e-01f, -1.47616953e-01f, -1.99933544e-01f, -1.07831597e-01f, -1.31312802e-01f, -4.02711928e-01f,
  5.22339582e-01f, -5.90094328e-01f, -1.75121367e-01f, 1.08705215e-01f, -1.08405493e-01f, -2.63912767e-01f, -5.88975072e-01f, -2.01389521e-01f, 2.68355757e-01f, -2.53869712e-01f,
  1.48348764e-01f, 6.79635286e-01f, 4.84735131e-01f, 3.85053307e-01f, 2.22861841e-01f, -5.41087389e-01f, -3.33847582e-01f, 1.30195335e-01f, 3.38190436e-01f, 4.22528349e-02f,
  -8.96447673e-02f, 7.75566772e-02f, 2.43222788e-01f, 2.07550135e-02f, -3.19046855e-01f, 1.16658337e-01f, -3.28894109e-01f, -2.10753798e-01f, -2.89769858e-01f, -4.32681710e-01f,
  -5.96865825e-02f, -2.00711578e-01f, 1.41723171e-01f, 2.02746674e-01f, 7.01769590e-02f, -7.79664293e-02f, -1.55725315e-01f, -8.01567957e-02f, -6.31310195e-02f, -1.66175619e-01f,
  9.86527577e-02f, 7.44173825e-02f, 6.96045607e-02f, -1.50222138e-01f, -1.59632415e-01f, -8.59477669e-02f, -1.38952136e-01f, -7.55619258e-02f, -9.31744203e-02f, -7.98304603e-02f,
  -5.53363785e-02f, 4.75392006e-02f, -1.23672754e-01f, -2.28172943e-01f, -1.83498606e-01f, 1.48935929e-01f, -3.96955043e-01f, -1.75112888e-01f, -7.94680268e-02f, -4.84267652e-01f,
  1.64702296e-01f, 4.73593660e-02f, 1.48078119e-02f, -1.49594724e-01f, 7.47713447e-03f, 3.31194364e-02f, -8.97703320e-03f, -6.99870512e-02f, -2.82877986e-03f, -1.20925851e-01f,
  5.59408404e-03f, 8.91664997e-02f, 2.49430072e-02f, -1.12426184e-01f, 3.86072733e-02f, -6.37550876e-02f, -4.13599722e-02f, -4.69885096e-02f, 4.43662256e-02f, 9.75462084e-04f,
  1.04250170e-01f, 5.62135093e-02f, 4.64987522e-03f, -6.48858547e-02f, 1.14859529e-02f, 1.23225704e-01f, 8.65607783e-02f, 3.89501750e-02f, 2.92322040e-02f, -1.49101904e-02f,
  2.26911947e-01f, 3.61357123e-01f, -7.51612261e-02f, 1.54858246e-01f, -6.76636025e-02f, 4.18807380e-02f, -1.14122942e-01f, 1.29057616e-02f, 3.88270654e-02f, -3.20915505e-03f,
  -6.08917065e-02f, 1.82923134e-02f, -4.82589677e-02f, 6.00476807e-04f, -8.69715586e-02f, -2.65109893e-02f, -2.07893010e-02f, 1.17365785e-01f, 1.97412558e-02f, -1.83291793e-01f,
  -1.33855835e-01f, -9.09818113e-02f, 5.69400601e-02f, -1.09360680e-01f, -1.08824842e-01f, 1.79543525e-01f, -2.46189773e-01f, -1.71594054e-01f, 1.58375591e-01f, -4.06149775e-01f,
  9.45496857e-02f, 3.64661478e-02f, 5.17398529e-02f, 2.57449806e-01f, 1.69709809e-02f, -2.47773543e-01f, -6.24807358e-01f, -2.27959335e-01f, 3.25100541e-01f, 2.29564812e-02f,
  -6.43652231e-02f, 2.50118095e-02f, 7.44314566e-02f, -8.38136747e-02f, -5.21170795e-01f, -2.67685205e-01f, 2.71533858e-02f, -2.74764061e-01f, -3.81418020e-01f, -5.30604720e-01f,
  -1.35851815e-01f, -4.83881608e-02f, -8.76802281e-02f, -3.79827283e-02f, 5.05586565e-01f, 1.66685149e-01f, 2.74492741e-01f, 1.62902117e-01f, -5.60132712e-02f, 4.85402077e-01f,
  1.12335615e-01f, 2.38054484e-01f, -2.11720571e-01f, 1.13771960e-01f, 1.76202700e-01f, 4.06183787e-02f, -5.69917075e-02f, 7.29343593e-02f, -1.82800461e-02f, 1.94552653e-02f,
  3.53988893e-02f, 3.55975106e-02f, -4.50164340e-02f, 9.56361145e-02f, -2.99228765e-02f, -9.52770412e-02f, 1.92012824e-02f, -1.18408978e-01f, -2.70280149e-02f, 2.79217623e-02f,
  -1.04182340e-01f, -1.97762042e-01f, -1.56309441e-01f, -6.70123920e-02f, -1.43990647e-02f, 7.90803879e-02f, -4.91615757e-02f, 1.61001205e-01f, 5.68945035e-02f, 2.84571379e-01f,
  1.52085414e-02f, 7.58410245e-02f, 2.87802536e-02f, 8.23344216e-02f, -1.09736316e-01f, 4.31052558e-02f, 6.56787585e-03f, 4.83375303e-02f, 3.23126861e-03f, 4.55696061e-02f,
  5.60627654e-02f, 2.55782753e-02f, 5.14760241e-03f, 7.58842304e-02f, 6.50058538e-02f, 6.60828650e-02f, 1.22552902e-01f, -1.29626030e-02f, -2.04760693e-02f, 5.54933511e-02f,
  -1.58220679e-02f, -9.98020358e-03f, 9.62988511e-02f, -1.51094543e-02f, 5.90020604e-02f, 6.61422834e-02f, 9.45438631e-03f, 6.78419769e-02f, 1.14253819e-01f, 5.74559569e-02f,
  5.59952967e-02f, -4.19705033e-01f, 7.63420537e-02f, -3.95684019e-02f, 1.60140768e-01f, 1.49859712e-01f, 2.30556443e-01f, -1.84333418e-02f, 2.60664880e-01f, 1.08511798e-01f,
  -5.15779853e-02f, -1.24780722e-02f, 2.17501987e-02f, -9.37720612e-02f, -1.70610294e-01f, 1.00308008e-01f, -1.21438980e-01f, -8.24592914e-03f, -1.56333879e-01f, 8.30223784e-02f,
  -9.55224261e-02f, -2.89603561e-01f, -4.76868242e-01f, -8.76218155e-02f, -5.13200797e-02f, -2.94301987e-01f, -1.53662607e-01f, -1.02176934e-01f, -3.07898909e-01f, -3.40523213e-01f,
  -5.04484534e-01f, 3.66824776e-01f, -1.46886557e-01f, -3.06336522e-01f, 1.95736662e-01f, 4.25636828e-01f, 6.02625906e-01f, 3.81213605e-01f, -1.36508450e-01f, 1.19910531e-01f,
  2.74826139e-01f, -3.65911759e-02f, -3.42583477e-01f, -6.66388273e-02f, -7.06839040e-02f, 2.30149589e-02f, -3.46070915e-01f, -4.45514232e-01f, -1.36555642e-01f, 3.05337906e-01f,
  6.05979562e-02f, -1.92723170e-01f, -3.01577419e-01f, -1.17739879e-01f, -3.70632745e-02f, -3.50885391e-01f, -3.32634151e-01f, -1.68387756e-01f, -1.62417844e-01f, -5.11661649e-01f,
  -3.72037143e-01f, 2.63748229e-01f, -3.69199924e-02f, -1.38218299e-01f, -1.50482774e-01f, -9.39992219e-02f, 6.33383021e-02f, -4.43395823e-02f, 9.66318101e-02f, -4.33904305e-02f,
  1.20856822e-01f, 6.37392476e-02f, 6.95758611e-02f, 8.49524364e-02f, 1.70529410e-01f, 1.46508172e-01f, 8.24672580e-02f, -4.55034636e-02f, -1.20166011e-01f, 1.05403334e-01f,
  8.16852301e-02f, 6.22375086e-02f, 1.34997532e-01f, 1.11425668e-01f, 1.13220707e-01f, -2.27492690e-01f, 1.41679659e-01f, 5.89050576e-02f, -1.60254389e-01f, -4.48965043e-01f,
  -1.29310071e-01f, 5.65161221e-02f, 9.20438543e-02f, 9.46297050e-02f, -4.78591844e-02f, 8.90043452e-02f, -1.24460675e-01f, -6.46805018e-02f, -3.66322249e-02f, -1.66020927e-03f,
  1.16438344e-01f, -1.34253465e-02f, 7.39400983e-02f, -4.44073491e-02f, -1.20955847e-01f, -5.29761128e-02f, -9.18811113e-02f, -1.67583242e-01f, -9.56417993e-02f, 6.12225085e-02f,
  -1.38514757e-01f, -1.01251736e-01f, -4.78227213e-02f, -3.68294232e-02f, 8.35127607e-02f, -8.43973309e-02f, -2.80928835e-02f, 1.47618875e-01f, 1.92725033e-01f, 1.75861537e-01f,
  -3.32945108e-01f, 1.36760369e-01f, -2.61289001e-01f, 1.28337756e-01f, 3.88575494e-02f, -6.41858205e-03f, -3.03165782e-02f, 3.65737528e-02f, 9.13933590e-02f, 8.08768347e-02f,
  2.65907466e-01f, -1.33406203e-02f, 6.85046464e-02f, 9.75613445e-02f, 9.02745128e-02f, 3.18742916e-02f, 3.82331461e-02f, -2.25075826e-01f, 1.48813399e-02f, 1.02738172e-01f,
  -3.36890593e-02f, -1.49753451e-01f, -1.89517006e-01f, -6.14037924e-02f, -4.29036058e-02f, -2.21954182e-01f, -1.95379704e-01f, -9.56326649e-02f, -3.48318428e-01f, -4.57243174e-01f,
  -5.04550099e-01f, -1.44820273e-01f, -4.27819103e-01f, -4.58374977e-01f, -4.40389067e-01f, -2.48085603e-01f, -7.09759668e-02f, -3.70421633e-02f, -2.44858533e-01f, -2.00425372e-01f,
  -5.08181844e-03f, 1.57491624e-01f, 3.40239257e-02f, 5.20564355e-02f, 3.03655360e-02f, -1.85777172e-01f, -4.51032460e-01f, -3.10394853e-01f, -8.69054198e-02f, -1.76905077e-02f,
  -2.47300528e-02f, -2.43894026e-01f, -1.73785031e-01f, -9.54301506e-02f, -8.08352679e-02f, 1.91030018e-02f, -2.33489200e-01f, -2.03371942e-01f, -1.33655190e-01f, -3.00474524e-01f,
  3.28933120e-01f, -1.01447619e-01f, 4.83694673e-03f, -7.45591521e-02f, -7.93176740e-02f, -3.46097425e-02f, -4.55956295e-04f, -1.18444391e-01f, -6.60817325e-02f, -1.29542530e-01f,
  -1.29712105e-01f, -8.85337591e-02f, 7.18031675e-02f, 1.29709601e-01f, -4.77110036e-02f, 1.55888898e-02f, -2.91840290e-03f, -1.81456715e-01f, -8.14323127e-02f, 3.02142985e-02f,
  -7.86630958e-02f, -1.53555825e-01f, 1.36592314e-01f, 6.48747534e-02f, 9.15442128e-03f, -1.47153094e-01f, 5.74819595e-02f, 1.95340943e-02f, -5.39876334e-02f, 2.64154356e-02f,
  -2.29300205e-02f, 1.08163834e-01f, -4.90982197e-02f, -3.05582751e-02f, 1.05362184e-01f, 1.14385590e-01f, 3.16891782e-02f, 2.88107507e-02f, -4.04498819e-03f, 1.28068745e-01f,
  -3.14710848e-02f, -7.90290534e-02f, 2.89371349e-02f, -1.67266056e-02f, -2.31218543e-02f, -1.70076080e-02f, 4.76714373e-02f, 1.28764853e-01f, 2.30138972e-02f, -4.14065346e-02f,
  -5.87172210e-02f, 5.54944128e-02f, -4.97684740e-02f, 1.23950616e-01f, -1.36363328e-01f, -2.87963524e-02f, -8.59713852e-02f, 9.00571197e-02f, 1.04409054e-01f, -1.06284641e-01f,
  4.16048706e-01f, -9.50133055e-02f, 9.94646177e-02f, -3.81437019e-02f, -2.03423187e-01f, -2.14980282e-02f, 1.38927959e-02f, -7.92217180e-02f, 6.43662410e-03f, 1.51701635e-02f,
  -5.50313815e-02f, -2.70026419e-02f, 6.34097084e-02f, 7.06428383e-03f, -5.69901951e-02f, 4.72557917e-02f, -4.34380062e-02f, -7.25572631e-02f, -7.95835257e-02f, -4.53635082e-02f,
  -5.55717349e-02f, -4.53168862e-02f, 2.02584967e-01f, 8.62304345e-02f, 5.50247468e-02f, 3.70927788e-02f, 1.17918722e-01f, 1.77947342e-01f, 3.13904025e-02f, 1.75050333e-01f,
  -4.35045511e-01f, 1.41299307e-01f, 3.51650685e-01f, -2.69278497e-01f, -2.47530863e-01f, -9.29979756e-02f, -1.50957033e-01f, -1.36111408e-01f, -6.46072552e-02f, 1.72705263e-01f,
  9.73754376e-02f, 1.16255209e-01f, 3.41947079e-01f, 1.76997855e-01f, -9.16586965e-02f, 1.68388873e-01f, -1.59400385e-02f, -2.98791975e-02f, -2.60630190e-01f, -3.68623972e-01f,
  -1.87130138e-01f, -2.42881835e-01f, -3.46385241e-01f, -1.66128829e-01f, 1.52104408e-01f, 5.02270833e-02f, 1.51072681e-01f, -1.04466930e-01f, 2.87626833e-02f, 1.55263588e-01f,
  3.90366226e-01f, 4.59662676e-02f, -5.43551482e-02f, -1.06450990e-01f, 7.00353831e-02f, 1.17246583e-02f, 1.79965471e-04f, -8.21539667e-04f, -1.40760228e-01f, 2.24562101e-02f,
  -5.65804131e-02f, -1.24146767e-01f, -7.54347593e-02f, 2.43988857e-02f, -1.48482248e-01f, -1.11988150e-01f, -1.27183676e-01f, -1.03536613e-01f, 3.25440951e-02f, -4.67464216e-02f,
  -8.96471068e-02f, -1.31940320e-01f, 9.51537490e-02f, 2.55375961e-03f, -1.61781404e-02f, -4.60345373e-02f, 5.64549603e-02f, -7.39158317e-02f, -2.42506228e-02f, 1.00966342e-01f,
  -2.98988470e-03f, 3.42868604e-02f, -8.62723887e-02f, -1.67035311e-02f, 6.06632605e-03f, -1.34378383e-02f, 9.13451836e-02f, -2.49297116e-02f, -1.85751561e-02f, -5.04685231e-02f,
  -3.84768937e-03f, 2.53738109e-02f, -3.87411043e-02f, 1.02735274e-01f, 9.24919173e-02f, -5.38943522e-02f, -2.24973876e-02f, 4.59637120e-02f, 7.53851980e-03f, -6.48108348e-02f,
  -7.80664980e-02f, -1.11691408e-01f, -6.77495673e-02f, -2.62033455e-02f, -5.13016917e-02f, -9.24788862e-02f, -1.22484416e-01f, -7.16784298e-02f, -8.89930278e-02f, -1.48151785e-01f,
  3.40375066e-01f, -2.44406521e-01f, 2.03094184e-01f, 4.48437259e-02f, -6.06987737e-02f, 4.38160487e-02f, 1.15131428e-02f, -1.45440847e-01f, 9.78660360e-02f, 1.13393277e-01f,
  -1.02588885e-01f, 4.27914448e-02f, 5.71937822e-02f, -9.86563787e-02f, -1.34651706e-01f, -6.34802505e-02f, -1.34548649e-01f, 5.62252551e-02f, -1.51334494e-01f, -1.92210793e-01f,
  -1.73550233e-01f, -2.21103832e-01f, 7.90259242e-02f, 1.03244774e-01f, -7.56139159e-02f, -6.70110881e-02f, 2.01475516e-01f, 9.73507613e-02f, 5.21483347e-02f, 8.09226930e-02f,
  2.74042964e-01f, -6.66499808e-02f, -5.19005209e-02f, 2.19739556e-01f, 5.39726876e-02f, 4.31488454e-02f, 3.67403924e-02f, 1.20949611e-01f, 3.24038088e-01f, 2.41945937e-01f,
  1.82316691e-01f, 2.52411604e-01f, 3.30241859e-01f, 1.67067990e-01f, 1.71196252e-01f, 1.93595007e-01f, 1.14906169e-01f, 2.10184246e-01f, 2.16508672e-01f, 1.30086973e-01f,
  2.02087462e-01f, 2.24545702e-01f, 1.84068400e-02f, 1.95164382e-01f, 2.59754777e-01f, 2.46596247e-01f, 1.47617340e-01f, -4.64591235e-02f, 1.78557828e-01f, 2.33243242e-01f,
  6.01853766e-02f, -1.14463270e-01f, 6.18693121e-02f, -6.17413446e-02f, -2.17012778e-01f, 5.53291151e-03f, -8.51085931e-02f, -1.44534081e-01f, -1.59232561e-02f, 5.25628999e-02f,
  -1.34815872e-01f, -7.66834542e-02f, 3.40233594e-02f, -3.39043327e-02f, -3.82583700e-02f, -3.83933634e-02f, -5.63229583e-02f, 4.94133458e-02f, 5.42876311e-02f, 4.64752316e-02f,
  4.95753065e-02f, -1.70240641e-01f, -3.30908120e-01f, -7.22246384e-03f, 5.65014891e-02f, 1.05187446e-01f, -1.47657543e-01f, -3.26409265e-02f, -1.29834294e-01f, -3.71398702e-02f,
  6.10114411e-02f, -4.76136766e-02f, 7.87611157e-02f, 9.66346860e-02f, 2.29308620e-01f, 1.02638230e-01f, 7.26072341e-02f, -8.06631171e-04f, 1.07737839e-01f, -7.26551786e-02f,
  1.90585200e-02f, 6.12873584e-02f, 1.56593621e-02f, -3.38103287e-02f, 2.30322182e-01f, -8.89994577e-03f, -1.12993836e-01f, -1.41207650e-01f, 5.49228229e-02f, 6.49526417e-02f,
  1.32338598e-01f, -1.15831822e-01f, 7.46443346e-02f, -2.71004811e-02f, 4.61262912e-02f, 6.79205954e-02f, 1.35838628e-01f, -1.30896531e-02f, 2.02523954e-02f, 9.18551609e-02f,
  -3.11300665e-01f, -5.55969700e-02f, 1.40350834e-01f, -1.31224111e-01f, -9.45020989e-02f, -5.90315126e-02f, 5.43719307e-02f, -8.17050189e-02f, -5.10215126e-02f, 7.16873407e-02f,
  -1.59209073e-01f, -8.06262642e-02f, -1.90246478e-02f, -1.00694150e-01f, 1.83630865e-02f, -4.46078703e-02f, -7.94396996e-02f, -8.87211412e-02f, -1.40509168e-02f, -2.45664358e-01f,
  -1.65061176e-01f, -1.93251669e-01f, -2.43990079e-01f, -5.89889660e-02f, 2.01332779e-03f, 6.16538711e-02f, -1.33525848e-01f, -2.05041364e-01f, -2.04786643e-01f, -1.26684293e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.30063012e-01f, 5.13192415e-01f, 4.66103405e-01f, 2.51669735e-01f, 1.98252037e-01f, 3.45830500e-01f, 7.94670045e-01f, 5.50090075e-01f, 2.51346588e-01f, 5.91129541e-01f,
  3.54139447e-01f, 4.81032729e-01f, 1.12383723e+00f, 8.18958879e-01f, 3.14490914e-01f, 2.44380292e-02f, 5.76946318e-01f, 6.80897653e-01f, 3.22244048e-01f, 5.18833339e-01f,
  2.20703557e-01f, 2.89696276e-01f, 5.57744503e-01f, 5.80088317e-01f, 1.93820164e-01f, 3.94723594e-01f, 3.13170224e-01f, 3.49017769e-01f, 6.14320874e-01f, 4.69405383e-01f,
  4.25828964e-01f, 6.40872300e-01f, 6.79327607e-01f, 4.92631108e-01f, 4.94305640e-01f, 2.87642598e-01f, 5.01225352e-01f, 4.09616530e-01f, 2.93139249e-01f, 6.74611866e-01f,
  3.81349921e-01f, 1.40194520e-01f, 6.02008998e-01f, 3.37448537e-01f, 1.86051279e-01f, 3.20415437e-01f, 5.30517519e-01f, 2.44146958e-01f, 5.63084602e-01f, 3.72174561e-01f,
  3.73293728e-01f, 2.87421525e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -9.45441425e-02f, 3.13214138e-02f, -1.92504361e-01f, -3.16546112e-01f, -1.94531515e-01f, -1.28112212e-01f, -2.16006085e-01f, -3.59730795e-02f, -2.23159920e-02f, -2.40799502e-01f,
  -9.76643115e-02f, 1.85992643e-01f, 3.76371771e-01f, -7.33906746e-01f, -2.69460022e-01f, 1.25778913e-01f, 3.35227221e-01f, 3.43804836e-01f, -6.50874615e-01f, -2.81967044e-01f,
  -1.73186921e-02f, 2.85941660e-01f, -1.38305545e-01f, -5.57910681e-01f, -5.78041911e-01f, -6.73299551e-01f, -2.04538763e-01f, 7.71031320e-01f, 3.45834866e-02f, -3.79539549e-01f,
  3.65619004e-01f, -4.89049941e-01f, -3.13732564e-01f, -2.01194331e-01f, -2.94863790e-01f, -1.52836472e-01f, 2.09066600e-01f, -1.56696215e-01f, -1.00286424e-01f, 1.52477294e-01f,
  5.66769615e-02f, -4.51206326e-01f, 1.74949080e-01f, 2.40004770e-02f, -5.51858127e-01f, -2.31949519e-02f, -4.77562666e-01f, 2.78066337e-01f, -3.83002073e-01f, 4.95936126e-01f,
  4.15713847e-01f, -1.35255828e-01f, -9.73050371e-02f, 3.81579816e-01f, -1.98884845e-01f, -8.20564806e-01f, -4.50024158e-01f, 2.17459619e-01f, 3.06058645e-01f, -2.04899728e-01f,
  2.22330466e-01f, 2.15507969e-01f, -6.67723536e-01f, -3.86961773e-02f, -1.11744836e-01f, 2.82949153e-02f, 1.20864749e-01f, -5.97696193e-03f, -6.36343434e-02f, -2.78321058e-02f,
  -3.32496583e-01f, 8.74923915e-02f, -8.26574638e-02f, -2.39011601e-01f, 7.09900334e-02f, -6.43668547e-02f, 6.99026167e-01f, -6.24418139e-01f, 2.58890599e-01f, 8.92580487e-03f,
  4.58414137e-01f, 1.88187569e-01f, 1.94852754e-01f, -1.06489038e+00f, -5.67416131e-01f, 6.80092812e-01f, 3.26217595e-03f, -7.03602374e-01f, -5.59853554e-01f, -5.27614474e-01f,
  -4.40860763e-02f, -3.80339086e-01f, 6.17736802e-02f, 2.05439135e-01f, -8.94389033e-01f, 7.53576756e-02f, -1.81905478e-01f, -2.65685052e-01f, -2.09339604e-01f, 1.19805016e-01f,
  -8.61124769e-02f, 3.46622795e-01f, -8.51405919e-01f, 3.27368855e-01f, -6.61261618e-01f, 1.17126957e-01f, -5.01037061e-01f, 1.27887771e-01f, 3.78087968e-01f, -6.04617953e-01f,
  -3.13063353e-01f, -5.20297110e-01f, -1.05874524e-01f, -1.82927087e-01f, 3.36799085e-01f, -3.18841428e-01f, 3.28132212e-01f, 8.38825554e-02f, -1.49410024e-01f, -3.60982895e-01f,
  -9.11509395e-02f, -1.39705926e-01f, 9.39335585e-01f, -6.10740900e-01f, -6.68715596e-01f, 1.45167455e-01f, 5.35619184e-02f, 4.27320361e-01f, -1.01388812e-01f, 9.64749306e-02f,
  9.17230323e-02f, 3.85464914e-02f, 2.70466983e-01f, 6.72274604e-02f, -1.12688541e-01f, -2.00597078e-01f, -1.91966519e-01f, 1.05061769e-01f, 2.24329494e-02f, -3.04282755e-01f,
  1.95386503e-02f, 4.14810926e-02f, 1.07311882e-01f, 1.26738071e-01f, -4.23791349e-01f, 3.52609754e-01f, 3.33685547e-01f, -2.52032399e-01f, -5.46383262e-01f, 7.25397706e-01f,
  -2.28664294e-01f, 4.80292827e-01f, -1.16974339e-01f, -4.50497925e-01f, 2.64510721e-01f, -2.96810895e-01f, 2.71558523e-01f, -1.48893759e-01f, -4.99489605e-01f, -1.02637798e-01f,
  -2.66281813e-01f, -1.08239569e-01f, -3.96255404e-01f, 2.79400438e-01f, -1.68085229e-02f, -3.69716793e-01f, -4.31452125e-01f, 2.61800494e-02f, 3.75425220e-01f, -4.37129676e-01f,
  7.13570774e-01f, -2.84745455e-01f, 1.72651291e-01f, 2.39207938e-01f, -1.71614498e-01f, -4.38144267e-01f, 4.49353606e-02f, -5.77002801e-02f, -2.42554531e-01f, 5.41847050e-01f,
  -6.59333944e-01f, -3.28096867e-01f, -7.62536451e-02f, 4.04356495e-02f, -9.53043401e-01f, 5.06023467e-01f, 4.56084073e-01f, -6.33851737e-02f, -5.00734925e-01f, -4.91972297e-01f,
  -1.50862500e-01f, -2.16002464e-01f, -1.22013561e-01f, -1.39539778e-01f, 4.87528406e-02f, 3.68320271e-02f, 1.59050059e-02f, -2.57907152e-01f, 3.00373465e-01f, -9.26296227e-03f,
  1.78346690e-02f, 4.73847300e-01f, -6.44672960e-02f, 1.44997463e-01f, -9.32965651e-02f, 3.42027992e-01f, -1.15490369e-01f, -4.44948524e-01f, -9.15262878e-01f, 2.72623986e-01f,
  -3.60401213e-01f, 3.20449889e-01f, -8.13243240e-02f, 3.28414679e-01f, 1.69116259e-01f, 2.42130294e-01f, 6.96954608e-01f, -8.96574855e-01f, -9.62426588e-02f, -4.22610670e-01f,
  -5.01581073e-01f, -5.31586826e-01f, 2.86481529e-01f, 2.53367752e-01f, 6.86908722e-01f, -2.30900645e-01f, 2.49035195e-01f, -9.54101264e-01f, 5.39502501e-01f, -4.25009876e-01f,
  -9.53648537e-02f, 1.03436112e-01f, -7.06008792e-01f, -2.56870031e-01f, -5.87621816e-02f, -6.99652076e-01f, 1.83731258e-01f, -5.13749957e-01f, 5.07018983e-01f, 2.20793650e-01f,
  -6.75214529e-01f, 9.03090164e-02f, -2.66523898e-01f, 1.69003636e-01f, -4.56345230e-01f, 6.82560027e-01f, -6.82614520e-02f, -6.56397967e-03f, -2.62435585e-01f, 2.93932170e-01f,
  -4.41624254e-01f, -4.33912635e-01f, 3.79960775e-01f, -1.20416377e-02f, -1.90481041e-02f, -1.93638042e-01f, -2.62514859e-01f, -2.18800202e-01f, -2.07452372e-01f, -1.99712530e-01f,
  -1.68636382e-01f, -2.19043180e-01f, 1.08584598e-01f, -3.22909683e-01f, -2.12421909e-01f, 2.71314289e-02f, -9.66895893e-02f, 3.84121761e-02f, -2.63703912e-01f, 2.40742460e-01f,
  -4.33358829e-03f, -8.23029339e-01f, -3.56746800e-02f, 1.39098242e-01f, -2.88739353e-01f, -4.19680774e-02f, 4.55548108e-01f, -1.36331916e-01f, 2.66630292e-01f, 4.72624749e-01f,
  -5.67557625e-02f, 3.03462863e-01f, -2.20449135e-01f, -3.11797857e-01f, -2.38049477e-02f, -2.40005866e-01f, -1.15396798e-01f, -3.77866566e-01f, -6.19895637e-01f, -4.11660820e-01f,
  5.75011253e-01f, -3.29056591e-01f, -2.34383702e-01f, -1.61315069e-01f, 3.62203002e-01f, 1.82125315e-01f, 2.81883448e-01f, 3.06225151e-01f, -1.72655925e-01f, -3.10872197e-01f,
  -1.08183183e-01f, 2.95789838e-01f, -5.84758401e-01f, 4.88218144e-02f, -2.51115323e-03f, -3.48615468e-01f, -6.02594554e-01f, 6.35980219e-02f, -9.19320136e-02f, -9.63139534e-01f,
  -5.25543451e-01f, 4.22889054e-01f, 2.53228903e-01f, 1.64902285e-01f, -7.19945803e-02f, 6.31455362e-01f, 1.06122710e-01f, -5.17796315e-02f, 3.28300148e-01f, -5.53732038e-01f,
  2.49029562e-01f, 1.34668842e-01f, 2.98305482e-01f, 1.16925193e-02f, 2.25950554e-01f, 7.22355992e-02f, -4.24925014e-02f, 2.69684970e-01f, 9.16210376e-03f, -2.11294875e-01f,
  -1.21583883e-02f, 1.49223059e-01f, -2.27326840e-01f, -8.44637930e-01f, 1.74075607e-02f, 1.31893709e-01f, 4.31863338e-01f, -1.97103709e-01f, 2.44709360e-03f, 8.48686337e-01f,
  -3.38988870e-01f, -9.78421986e-01f, -1.31792724e-01f, -7.03699350e-01f, -6.86390042e-01f, 7.01171458e-01f, -1.57832086e-01f, -7.92516321e-02f, -1.62639990e-01f, -9.11688898e-03f,
  5.06467819e-01f, -1.04131125e-01f, -3.56090188e-01f, -2.02304870e-01f, 1.08452827e-01f, -1.92994624e-01f, -6.98409855e-01f, -3.88391495e-01f, 2.84896433e-01f, -8.17286596e-02f,
  -1.15869060e-01f, 6.48345709e-01f, -5.46092987e-01f, 6.05551541e-01f, -5.40174901e-01f, 1.01601690e-01f, -4.39364426e-02f, 2.85002571e-02f, 2.10876912e-01f, -3.25709850e-01f,
  3.99330020e-01f, 7.10441351e-01f, -2.49019846e-01f, -1.93955898e-01f, 2.94567734e-01f, -4.23668206e-01f, -8.23896565e-03f, -2.86350906e-01f, -1.79695189e-01f, -3.34162027e-01f,
  -1.37996361e-01f, 6.70941770e-02f, -1.12008832e-01f, 1.07398607e-01f, 1.60724372e-01f, -1.63478151e-01f, 1.84335917e-01f, -4.30608355e-02f, 1.03468113e-01f, -1.05837896e-01f,
  -1.47816718e-01f, -3.17025006e-01f, 1.01446338e-01f, -5.49690351e-02f, -1.65222645e-01f, -1.87593982e-01f, -3.48201573e-01f, 4.02162373e-01f, 1.50409499e-02f, -2.42210805e-01f,
  -1.34168282e-01f, -5.14047205e-01f, 1.68849841e-01f, -8.01151022e-02f, -6.74387932e-01f, 4.67811748e-02f, -3.07919264e-01f, 2.86542982e-01f, 7.73000717e-02f, 5.73600411e-01f,
  -4.01738763e-01f, -8.66356969e-01f, -6.40322939e-02f, -3.49002898e-01f, -3.57239932e-01f, -4.17392582e-01f, 5.27175725e-01f, -5.98050535e-01f, -3.09513986e-01f, -5.23782611e-01f,
  -7.82031536e-01f, 1.00293592e-01f, -2.64597058e-01f, -3.18565220e-01f, 1.53833464e-01f, -4.18239743e-01f, 2.63723701e-01f, 2.23978966e-01f, -3.09770107e-01f, 6.25680149e-01f,
  -3.24909329e-01f, -1.80431575e-01f, 5.06234288e-01f, -9.64935720e-01f, -2.32955202e-01f, -3.45369250e-01f, 3.31979364e-01f, 4.28746939e-02f, 6.75993562e-01f, -2.11320639e-01f,
  -5.93841791e-01f, -6.12251937e-01f, -8.50658894e-01f, 1.53974667e-01f, -6.66451395e-01f, -1.72062322e-01f, 1.94182158e-01f, 5.21593653e-02f, -7.25498796e-02f, -1.66032866e-01f,
  -2.71329433e-01f, 6.43880665e-02f, -2.18607351e-01f, -8.27313215e-02f, 9.76798907e-02f, 3.27170968e-01f, -3.90880927e-03f, 5.19726016e-02f, 5.56388572e-02f, 2.37264872e-01f,
  -1.42825380e-01f, 1.33747935e-01f, -2.32618660e-01f, 2.24856317e-01f, -1.38018534e-01f, -3.49168688e-01f, -5.14145613e-01f, 5.84933698e-01f, -1.34564802e-01f, -3.18837255e-01f,
  -2.90147036e-01f, -1.19789287e-01f, 4.09674704e-01f, -9.92512926e-02f, 1.26103893e-01f, -3.76312174e-02f, 3.58831771e-02f, -7.91056275e-01f, 5.63423038e-01f, -5.28072953e-01f,
  4.23912803e-04f, 1.71834588e-01f, -2.16184586e-01f, -1.74442500e-01f, 3.63576382e-01f, 4.30531800e-02f, -1.49700180e-01f, -7.25030601e-02f, 2.84859985e-01f, -1.69115588e-01f,
  2.48118103e-01f, -3.61250132e-01f, -6.14826493e-02f, -7.65476108e-01f, 7.47047588e-02f, -3.53099585e-01f, -1.09248169e-01f, -3.54177177e-01f, -1.68948576e-01f, 5.92293084e-01f,
  -3.13363761e-01f, 2.92269945e-01f, -4.35752153e-01f, 4.74435657e-01f, 4.22771364e-01f, -3.63096505e-01f, -8.66696417e-01f, 4.12429385e-02f, 1.74841478e-01f, -3.44616562e-01f,
  -1.08274072e-01f, 8.34234208e-02f, 2.22540364e-01f, 7.66475350e-02f, -1.73073083e-01f, 2.85061061e-01f, -3.01926851e-01f, 9.45535600e-02f, -3.70647430e-01f, 3.13960791e-01f,
  3.82334113e-01f, 6.22030459e-02f, 3.81274015e-01f, 5.25962077e-02f, -3.05451065e-01f, -3.45718473e-01f, 3.75762314e-01f, 1.80829912e-02f, -2.27466390e-01f, -2.12205112e-01f,
  -1.21516772e-01f, 2.70675141e-02f, -2.49995902e-01f, -2.80957818e-01f, -1.63578629e-01f, -2.00787067e-01f, 5.34066200e-01f, -3.95021409e-01f, 3.75893503e-01f, -1.87333629e-01f,
  1.35913268e-01f, 6.62882566e-01f, -1.92484841e-01f, 1.81133777e-01f, -2.76893407e-01f, 6.02977157e-01f, -7.42547214e-01f, 1.66632444e-01f, -1.34815365e-01f, -3.02055985e-01f,
  -2.25228444e-01f, -2.92972267e-01f, 1.03584960e-01f, -2.59170562e-01f, 9.16935578e-02f, 2.74006218e-01f, 2.30229661e-01f, -2.81791568e-01f, 4.44079250e-01f, -3.63566071e-01f,
  -4.46099550e-01f, 2.46612430e-02f, 2.14746278e-02f, -4.12080973e-01f, -2.32869759e-01f, 6.80102557e-02f, 7.45506048e-01f, 8.80365744e-02f, -4.11764055e-01f, -1.36328399e-01f,
  -6.37655437e-01f, -1.83833659e-01f, -4.32860970e-01f, -6.48586154e-01f, -4.14174199e-01f, -1.27592579e-01f, 2.58447323e-02f, 9.74521413e-02f, -6.68469220e-02f, 5.82976325e-04f,
  -1.97585866e-01f, -3.05646490e-02f, -7.43515119e-02f, -2.41493791e-01f, -1.59342080e-01f, -3.07929572e-02f, -2.44766042e-01f, -1.49682343e-01f, -1.87146097e-01f, -3.30202490e-01f,
  -3.26886833e-01f, 6.32661700e-01f, 4.66004163e-02f, -5.17431378e-01f, 1.17210157e-01f, -5.32046318e-01f, 8.99544001e-01f, -7.06500471e-01f, -4.97863710e-01f, 2.97288537e-01f,
  -5.22334278e-01f, 2.58618832e-01f, -8.87638777e-02f, 9.08236265e-01f, 1.17840737e-01f, -4.29784328e-01f, -5.89213073e-01f, 2.21411631e-01f, -3.96717817e-01f, -2.27215543e-01f,
  -8.97199754e-03f, 1.60482466e-01f, 2.63157398e-01f, -1.79273173e-01f, 5.50104439e-01f, -8.53917122e-01f, 3.30304265e-01f, 2.10241213e-01f, -2.25504994e-01f, -4.46368456e-01f,
  4.55456041e-02f, 2.64406174e-01f, -3.01932603e-01f, -5.04803598e-01f, 2.16424376e-01f, 1.08715422e-01f, -2.94081241e-01f, -7.37559140e-01f, -9.19833705e-02f, 1.87080055e-01f,
  -4.41844791e-01f, 5.59710503e-01f, -1.62753448e-01f, -2.63266146e-01f, 1.31160051e-01f, 5.05063474e-01f, -7.11134076e-01f, -5.40327728e-01f, -3.54687721e-01f, -2.98112258e-02f,
  8.72525051e-02f, 4.01205942e-02f, 6.80577382e-02f, -1.86807942e-02f, 1.32329851e-01f, 1.22703321e-01f, -1.41903952e-01f, 2.35783383e-01f, -1.90616608e-01f, 2.28253484e-01f,
  4.82743569e-02f, -9.99492630e-02f, -5.03122032e-01f, -9.74497348e-02f, -2.19509453e-01f, -1.56530201e-01f, -5.93691587e-01f, -6.66915178e-01f, -2.84077346e-01f, -3.63502979e-01f,
  -1.71917424e-01f, 1.56794161e-01f, 4.21407759e-01f, 2.41523311e-02f, -7.83533752e-02f, -2.25347564e-01f, -1.59359768e-01f, -1.14509054e-01f, -6.85456216e-01f, -3.81197125e-01f,
  -1.29354477e-01f, -1.32705510e-01f, -4.28911904e-03f, 4.69181575e-02f, 2.05293044e-01f, 8.57171714e-01f, -2.96732128e-01f, -2.29703724e-01f, -3.50933999e-01f, -6.58946276e-01f,
  -3.05894881e-01f, -2.97441870e-01f, -1.58615813e-01f, -1.29563019e-01f, 4.69792157e-01f, -2.96799302e-01f, 4.26509947e-01f, 5.15495956e-01f, 2.96288244e-02f, -2.33421654e-01f,
  1.02318011e-01f, 1.07332513e-01f, -1.63500577e-01f, -1.31291941e-01f, -3.75147641e-01f, -3.26129764e-01f, 1.11566983e-01f, -5.23478627e-01f, -2.84909666e-01f, -2.76411563e-01f,
  -1.84557721e-01f, 5.98098099e-01f, 7.66760826e-01f, -1.83628619e-01f, -3.04483652e-01f, 8.98004174e-02f, 1.03523783e-01f, -2.13689450e-02f, 1.58196658e-01f, 3.68737094e-02f,
  4.25073624e-01f, -2.23052591e-01f, 1.74010813e-01f, -3.28835964e-01f, -1.36757754e-02f, -1.37322888e-01f, -2.73534000e-01f, 7.62275815e-01f, -6.22099757e-01f, -3.64499390e-01f,
  -3.91223520e-01f, -3.20819497e-01f, -1.16242774e-01f, 2.31212340e-02f, 5.48003316e-01f, -2.48740911e-01f, -5.64059377e-01f, -3.58393967e-01f, 3.83267462e-01f, 2.30894670e-01f,
  2.70227820e-01f, -8.41305628e-02f, -8.56784105e-01f, 6.76936328e-01f, -3.31921279e-01f, 4.24226195e-01f, 1.80634841e-01f, 1.54021764e-02f, -2.08022475e-01f, -2.03886237e-02f,
  2.38522053e-01f, 3.74414533e-01f, -3.38742435e-01f, 1.62669584e-01f, -6.57618761e-01f, -8.06779638e-02f, -5.49922585e-01f, -6.46375358e-01f, -3.05197001e-01f, -2.18333099e-02f,
  -4.53438699e-01f, -2.14731008e-01f, -2.01370478e-01f, 5.44269800e-01f, -4.06422883e-01f, -5.68314314e-01f, 4.25261915e-01f, -2.32728675e-01f, -2.61857837e-01f, -1.03495501e-01f,
  -1.43045653e-02f, -2.32811317e-01f, -2.40498304e-01f, -6.43769443e-01f, 4.07842249e-01f, -1.05952367e-01f, -1.94930732e-01f, -4.63517070e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.63905615e-01f, 1.02137378e-03f, 1.51456937e-01f, -2.00853795e-01f, -9.52486619e-02f, -8.93907100e-02f, 2.09335804e-01f, -1.73509628e-01f, 4.38956963e-03f, 1.68476537e-01f,
  1.52240293e-02f, 1.29982322e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    