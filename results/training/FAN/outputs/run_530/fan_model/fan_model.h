/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.51476113e-02f, 1.61359459e-01f, -1.71352416e-01f, 2.09935512e-02f, 1.12008892e-01f, -2.06886262e-01f, -1.35492802e-01f, 1.33409083e-01f, 3.38056743e-01f, 1.84770018e-01f,
  9.00019854e-02f, -7.53181502e-02f, 1.77694514e-01f, -1.23264052e-01f, -3.86188537e-01f, 2.39620116e-02f, -1.14143319e-01f, -5.43773659e-02f, 9.38901603e-02f, 1.44763067e-02f,
  -3.91437002e-02f, -1.14552736e-01f, -1.69816241e-01f, 5.43465130e-02f, -1.20090105e-01f, 1.21599764e-01f, -1.84578627e-01f, 1.30437026e-02f, -1.23737551e-01f, -1.45137057e-01f,
  -7.20241368e-02f, 2.16959491e-01f, -1.63005069e-02f, -1.11274622e-01f, 2.21733321e-02f, 5.67467250e-02f, -1.14415877e-01f, -5.60320020e-02f, 6.95095211e-02f, 5.27063198e-03f,
  -6.48071617e-02f, 4.05122936e-02f, -2.03266218e-02f, 4.53758128e-02f, 7.35065416e-02f, -8.99884943e-03f, 3.60242762e-02f, -1.01990722e-01f, 5.51157668e-02f, -3.45019326e-02f,
  -2.05801558e-02f, -1.09591350e-01f, -8.81930441e-02f, -8.22110847e-02f, 2.51319073e-02f, 4.35180329e-02f, -1.22584693e-01f, -7.75952563e-02f, -8.70583579e-02f, 5.56088537e-02f,
  9.97528154e-03f, 2.36188415e-02f, -2.44722478e-02f, 3.99784110e-02f, 5.94574399e-02f, 8.95009376e-03f, 5.83137497e-02f, -5.93986027e-02f, 9.67835858e-02f, -1.24285258e-02f,
  -3.70427780e-02f, 5.78098893e-02f, 4.14704084e-02f, 6.89516589e-02f, -2.76142135e-02f, -1.64143890e-02f, -1.33991733e-01f, 4.59586345e-02f, -3.41148414e-02f, -6.09258041e-02f,
  5.71028329e-02f, -6.17949776e-02f, 3.16229314e-02f, 5.48918685e-03f, -3.04134022e-02f, -6.51135249e-03f, 4.66927551e-02f, -9.05212108e-03f, 3.60489637e-02f, -1.47788189e-02f,
  -8.97715464e-02f, 4.18818928e-02f, 8.30129236e-02f, 5.02245240e-02f, 6.72210427e-03f, -1.33939497e-02f, -2.52065919e-02f, 9.66249220e-03f, 2.97517478e-02f, -4.90101613e-02f,
  -9.69951972e-02f, 1.03089875e-02f, -7.61003122e-02f, -7.77280331e-02f, -7.18399286e-02f, 1.89391226e-02f, -1.74946096e-02f, 3.01761134e-03f, -4.89283577e-02f, 7.50596896e-02f,
  3.94133627e-02f, 2.48218719e-02f, 4.28994410e-02f, 1.42314350e-02f, 9.59295556e-02f, 3.47841568e-02f, -1.10544940e-03f, 3.67819257e-02f, -3.66086960e-02f, -1.75381918e-02f,
  1.25055492e-01f, -3.88689250e-01f, -3.62500250e-01f, -9.47481692e-02f, 1.74964279e-01f, 3.32167000e-01f, 9.58497077e-02f, 2.83353552e-02f, 3.63091119e-02f, -1.20798595e-01f,
  1.21453544e-02f, -2.70865887e-01f, -1.43588826e-01f, -1.31195962e-01f, 2.29990765e-01f, -5.48830293e-02f, 1.51484713e-01f, -2.79147550e-02f, -1.23796940e-01f, 6.77563399e-02f,
  8.70737359e-02f, 2.23066911e-01f, -2.20480904e-01f, 1.34297669e-01f, -5.95173724e-02f, -1.37567833e-01f, 8.91364962e-02f, -6.76846281e-02f, 5.01173101e-02f, 3.69570293e-02f,
  -3.34587656e-02f, -1.43747181e-01f, -8.31807032e-02f, 5.39361313e-03f, 1.12762488e-01f, 6.50004223e-02f, -8.64090100e-02f, -2.96871960e-02f, -2.07920969e-02f, 8.02895352e-02f,
  -2.88727768e-02f, 3.14392969e-02f, 2.93074064e-02f, 1.36069721e-02f, -3.31140240e-03f, -5.64239994e-02f, -9.41539034e-02f, -8.43919888e-02f, -9.77393240e-02f, -1.30319670e-01f,
  -8.84814486e-02f, -3.17116119e-02f, -2.81394366e-02f, -1.80114747e-03f, 1.66394468e-02f, -5.61399944e-02f, -2.35955175e-02f, 1.96480490e-02f, 6.34212121e-02f, 5.73321693e-02f,
  -1.52836656e-02f, 7.87829980e-02f, -5.24488725e-02f, -1.01028243e-02f, 4.67653573e-03f, -2.65297219e-02f, 1.89750586e-02f, -6.11346923e-02f, -1.30710155e-01f, 3.86800654e-02f,
  1.75284315e-02f, -5.36067374e-02f, 3.45459171e-02f, 6.33085817e-02f, 3.31748836e-02f, 6.72191009e-02f, -1.05094984e-01f, 2.76669022e-02f, 4.74209934e-02f, -2.60902420e-02f,
  -6.16435371e-02f, 4.78769839e-02f, -2.28537712e-02f, 2.57313941e-02f, 6.71878830e-02f, 2.08049845e-02f, 5.06973341e-02f, -4.66846563e-02f, -1.33672757e-02f, 1.18110403e-01f,
  1.06106102e-01f, 1.84190139e-01f, 2.82219052e-02f, 1.36544826e-02f, -7.01077357e-02f, 3.07783615e-02f, -1.07690869e-02f, -5.68995960e-02f, 6.16909526e-02f, 1.41113177e-01f,
  6.65680319e-02f, -1.01048313e-02f, 1.24623910e-01f, 3.09101548e-02f, 4.40426581e-02f, 8.85048583e-02f, 7.57928714e-02f, 1.02568902e-01f, 9.62831900e-02f, 2.05941405e-03f,
  2.96047479e-02f, 5.76948598e-02f, -1.17347194e-02f, 1.40589979e-02f, 6.89373910e-02f, 4.97037694e-02f, 5.53214438e-02f, -7.95593709e-02f, 2.08865833e-02f, -1.30306743e-02f,
  2.11802363e-01f, 1.35778904e-01f, -1.88362703e-01f, 2.07172200e-01f, -7.09498078e-02f, 1.13890037e-01f, 4.38946247e-01f, -4.78932038e-02f, 6.55201301e-02f, 2.61697441e-01f,
  1.20255753e-01f, 9.16373804e-02f, 8.21362287e-02f, 1.52724519e-01f, 2.05321573e-02f, -1.72331810e-01f, 2.40202576e-01f, 1.86576545e-01f, -4.65422347e-02f, 1.71576962e-01f,
  -8.44518617e-02f, 7.42964968e-02f, 3.52593139e-02f, -1.20395467e-01f, 1.34620130e-01f, -1.25719339e-01f, 1.52354883e-02f, -7.26309940e-02f, -2.33237799e-02f, -8.10330659e-02f,
  1.26438588e-01f, 8.17533955e-02f, 4.59912308e-02f, -5.09886304e-03f, 1.03917971e-01f, -1.47752585e-02f, 5.86136803e-02f, -2.82228496e-02f, -8.23949352e-02f, -5.80512099e-02f,
  2.13447269e-02f, -6.14578649e-02f, -3.97275959e-04f, -1.29209377e-03f, 7.30366036e-02f, -4.21142019e-02f, -1.20858327e-01f, -1.81695931e-02f, -4.95571978e-02f, -2.27945931e-02f,
  -1.59762483e-02f, -5.47894314e-02f, -4.68770266e-02f, -1.04972124e-02f, -6.60666227e-02f, 5.00644594e-02f, -6.19290657e-02f, 1.41883902e-02f, -3.43945697e-02f, -3.06139514e-02f,
  -3.72377932e-02f, 6.75701126e-02f, -1.99939646e-02f, -3.53662372e-02f, -5.42074963e-02f, -7.39419833e-02f, 7.95963556e-02f, -5.43260127e-02f, 8.21323879e-03f, 3.59276272e-02f,
  -2.53343210e-03f, -4.10493650e-03f, -3.75713743e-02f, 5.64186163e-02f, 5.48864044e-02f, 6.38743937e-02f, -9.40573215e-03f, -3.34911458e-02f, -2.18808372e-02f, -1.33095652e-01f,
  6.41409457e-02f, 5.13709616e-03f, 3.16476189e-02f, 6.53706193e-02f, -1.02269696e-02f, 1.88326335e-03f, -6.18580282e-02f, -9.27564129e-02f, -6.43285504e-03f, 1.19514354e-02f,
  2.35001341e-01f, 2.78338909e-01f, 2.16226242e-02f, 3.83964404e-02f, 7.49281719e-02f, -3.16309300e-03f, -2.68267523e-02f, -9.16522667e-02f, 1.23227857e-01f, 5.60786314e-02f,
  -2.67053284e-02f, 5.15985526e-02f, -2.56875362e-02f, 8.23301971e-02f, 4.88133356e-02f, -4.80504185e-02f, 1.03373736e-01f, 4.03261296e-02f, 8.37484896e-02f, 5.15131801e-02f,
  3.86158004e-02f, 8.42166878e-03f, 3.67094316e-02f, 5.28054349e-02f, -2.83058379e-02f, 5.91409542e-02f, -2.32389793e-02f, -4.34983782e-02f, -7.05730543e-02f, 4.26808372e-03f,
  1.23920783e-01f, -2.04763293e-01f, 1.12892151e-01f, -2.47067586e-01f, -1.21566251e-01f, -1.62258461e-01f, -2.29135349e-01f, -2.04911157e-01f, -1.10228024e-01f, -1.56959414e-01f,
  -2.96474516e-01f, 2.01302975e-01f, -1.81337848e-01f, -2.53539324e-01f, -1.83971986e-01f, -2.10746020e-01f, -2.65282452e-01f, -1.02608934e-01f, 6.27330989e-02f, -1.79316133e-01f,
  -3.26118246e-02f, -3.04833829e-01f, -2.13629127e-01f, -1.34981563e-02f, -2.09430799e-01f, 2.19788119e-01f, -1.03729889e-01f, 1.59282684e-01f, -1.15259014e-01f, 7.42522031e-02f,
  -3.73301981e-03f, -2.75833979e-02f, 3.37103121e-02f, 8.49164352e-02f, -1.36553720e-01f, 1.24826349e-01f, 1.06114686e-01f, 2.70860381e-02f, 3.94127555e-02f, 2.85053030e-02f,
  7.33816922e-02f, 4.72968677e-03f, 2.51828954e-02f, 1.05138175e-01f, 7.94208143e-03f, 9.00460184e-02f, -3.41370367e-02f, -3.98132764e-02f, -4.42328081e-02f, -2.17844602e-02f,
  -8.16735625e-03f, -1.35682523e-02f, -1.06265023e-01f, 3.96303944e-02f, 2.28096116e-02f, -3.88102084e-02f, -1.82773964e-03f, 9.77776572e-02f, -3.00971121e-02f, 3.71254012e-02f,
  1.13855973e-01f, 2.69680354e-03f, -1.23838363e-02f, 4.97866236e-02f, -1.21900156e-01f, 1.07408538e-02f, -2.29198467e-02f, -2.78079212e-02f, 4.73080724e-02f, -1.02956042e-01f,
  -2.30556112e-02f, 5.16749686e-03f, 3.48184071e-02f, 3.72997904e-03f, 2.36201156e-02f, 7.02780262e-02f, 5.66199142e-03f, 3.78593989e-02f, 1.55984180e-03f, 1.61542762e-02f,
  3.95410992e-02f, -4.41173464e-02f, -2.75857677e-03f, 7.16152042e-02f, -3.87815274e-02f, 7.52359163e-03f, -8.51752644e-04f, 2.05210112e-02f, -1.01760164e-01f, -1.61149297e-02f,
  -1.51484445e-01f, -1.76075801e-01f, -8.23930465e-03f, 1.91221330e-02f, -1.10162720e-02f, -1.73581745e-02f, -2.13207514e-03f, 4.78821248e-02f, 4.10103202e-02f, -6.06617285e-03f,
  7.68084750e-02f, 3.41362767e-02f, 2.19255164e-02f, -2.19283607e-02f, -2.06293222e-02f, -7.41758645e-02f, 2.35686954e-02f, 5.61308675e-02f, -6.15355186e-02f, 8.63063056e-03f,
  -4.46927622e-02f, 1.49047468e-02f, 9.13251266e-02f, -7.94899017e-02f, 2.54474264e-02f, 3.36524397e-02f, -1.45653570e-02f, 2.20822059e-02f, 8.24817419e-02f, -4.53062914e-03f,
  -5.65232858e-02f, -7.65628666e-02f, 3.68380398e-01f, 1.39055729e-01f, -3.05227280e-01f, 5.95511459e-02f, 1.08697042e-01f, -1.59070924e-01f, -2.15762302e-01f, -7.73017332e-02f,
  1.09618455e-01f, -1.02630883e-01f, 1.21430047e-01f, 1.73289955e-01f, 4.51711975e-02f, 1.54619426e-01f, 1.55366987e-01f, 1.39114708e-01f, -3.25807594e-02f, -1.06303804e-01f,
  2.53868196e-02f, -2.90728092e-01f, 2.42720798e-01f, -3.88711810e-01f, 2.50517670e-02f, -1.28130212e-01f, 4.99649309e-02f, -6.11075349e-02f, 1.11663297e-01f, -1.62259154e-02f,
  -8.58988613e-02f, -2.16304455e-02f, 1.64406188e-03f, 1.79371573e-02f, 4.11662124e-02f, 6.13788366e-02f, 3.51085179e-02f, 2.76224352e-02f, 1.93943921e-02f, 3.98982726e-02f,
  -2.49866005e-02f, -1.52356224e-02f, -6.76002875e-02f, 2.12698076e-02f, -6.97595924e-02f, -3.50887515e-03f, 1.20583981e-01f, 1.64566278e-01f, -1.60238501e-02f, 9.92980823e-02f,
  1.05819292e-01f, 2.02685088e-01f, 1.11345418e-01f, 1.66070554e-02f, 1.19661793e-01f, 3.70501168e-02f, 8.02759007e-02f, 5.82248382e-02f, -7.10798427e-02f, -1.01943120e-01f,
  2.39934288e-02f, -8.94566476e-02f, -6.40082965e-03f, -3.97686884e-02f, -3.73660177e-02f, 2.78791953e-02f, 4.95251128e-03f, 2.70476490e-02f, -1.04201185e-02f, 5.01392735e-03f,
  -1.48651088e-02f, 9.89150349e-03f, -3.24097835e-02f, -3.93724814e-02f, 7.29646459e-02f, 7.77127668e-02f, 4.40053046e-02f, -7.01915845e-02f, -4.17171093e-03f, 2.08311230e-02f,
  7.10679637e-03f, -2.50241868e-02f, -2.44064629e-02f, -2.24140100e-02f, -5.76752983e-02f, 6.92957416e-02f, 7.35663846e-02f, 1.00521110e-01f, -2.00211275e-02f, 2.36525815e-02f,
  -1.72622636e-01f, -1.60526857e-01f, -1.78048357e-01f, -8.29786733e-02f, -8.95198435e-02f, -4.50445488e-02f, 8.52405280e-02f, -4.42397483e-02f, -6.19277060e-02f, -1.14523828e-01f,
  -3.23219001e-02f, 7.05480874e-02f, -3.60072739e-02f, -4.03251462e-02f, -2.73032952e-02f, -5.25312275e-02f, -1.27113815e-02f, -7.43189547e-03f, -1.12006135e-01f, 5.32354927e-03f,
  -2.56382264e-02f, -8.73040110e-02f, -8.02428424e-02f, -1.28325433e-01f, -5.06800450e-02f, -4.17219661e-02f, -1.37090236e-01f, -3.19893546e-02f, 7.77831376e-02f, 1.31474547e-02f,
  3.86508517e-02f, 1.37358457e-01f, -1.70391500e-01f, -1.04774438e-01f, 2.16765910e-01f, -1.15935706e-01f, -5.37533164e-02f, 5.88771179e-02f, 3.37844379e-02f, 2.53729641e-01f,
  -4.16743718e-02f, -1.28769111e-02f, -6.67813867e-02f, 8.50626901e-02f, -4.75162953e-01f, -2.79901385e-01f, -1.21020503e-01f, 2.92595178e-02f, 4.18542624e-02f, -3.71594056e-02f,
  -9.46192890e-02f, 7.15153143e-02f, -1.93054825e-01f, 1.67108476e-01f, 2.68155396e-01f, 1.26582935e-01f, -1.62252024e-01f, 2.70659421e-02f, 8.52265358e-02f, -1.64837465e-02f,
  1.01408876e-01f, -8.54716673e-02f, 1.00286603e-02f, -1.85298175e-02f, -3.81693081e-03f, 1.01890817e-01f, -8.24355613e-03f, -3.48755717e-02f, -6.73630973e-03f, 1.60769653e-02f,
  -2.03762278e-02f, 1.39275286e-02f, -3.62324994e-03f, 2.82336008e-02f, 7.79707134e-02f, 6.18794784e-02f, 7.55135566e-02f, 4.39171866e-02f, -1.49305933e-03f, -7.68227503e-02f,
  8.92101303e-02f, 2.93054655e-02f, -7.60855228e-02f, -8.81822109e-02f, -1.09108940e-01f, 5.42461164e-02f, -1.04554102e-01f, -1.03809662e-01f, -5.32347187e-02f, 2.09082346e-02f,
  3.71313170e-02f, -4.07388285e-02f, -6.15490302e-02f, 7.67369270e-02f, 6.90759271e-02f, 8.18794593e-02f, 5.13375700e-02f, 3.23938802e-02f, 4.20330316e-02f, -1.24158412e-02f,
  -1.06637388e-01f, -2.84572616e-02f, 3.94339561e-02f, 2.76440550e-02f, -7.69178346e-02f, -1.40855899e-02f, -3.27888057e-02f, -8.24712068e-02f, 1.65789183e-02f, -5.69799989e-02f,
  6.73707901e-03f, -4.48849844e-03f, 6.70456812e-02f, -4.37597632e-02f, -1.43911675e-01f, -4.62960564e-02f, 1.14418097e-01f, -1.23398472e-02f, 8.43659490e-02f, -8.29278827e-02f,
  -4.77101207e-02f, -2.04870000e-01f, -3.81255932e-02f, 8.78346059e-03f, -1.21147791e-02f, 2.41274610e-02f, 3.58815491e-03f, -1.85935032e-02f, -2.63753925e-02f, 9.36566386e-03f,
  7.66733810e-02f, 8.33217427e-03f, 2.69877892e-02f, 1.25663176e-01f, -1.06721766e-01f, -1.01761758e-01f, -4.67528142e-02f, 7.44691268e-02f, -8.19596425e-02f, 4.20509651e-02f,
  4.90805786e-03f, 1.65476147e-02f, -8.63257647e-02f, -2.83045229e-02f, -6.92671686e-02f, -8.61861035e-02f, -8.56280401e-02f, 2.70572212e-02f, -9.23704058e-02f, -3.17668542e-02f,
  -2.39096358e-01f, -1.13491556e-02f, 1.06901117e-01f, -4.70270291e-02f, -1.23813286e-01f, -1.66072890e-01f, -1.73592925e-01f, -1.65174335e-01f, -3.99132147e-02f, 7.04967007e-02f,
  9.73410457e-02f, -1.37283355e-02f, 2.20278755e-01f, 1.01869017e-01f, -2.08917707e-01f, 3.51282328e-01f, -1.77321248e-02f, 4.44106534e-02f, 3.29825394e-02f, -1.83182314e-01f,
  -7.11243749e-02f, -1.10195823e-01f, -4.13113181e-03f, -2.69379318e-01f, -1.98927015e-01f, -2.63804272e-02f, -4.49482761e-02f, 2.43203044e-02f, -9.03882459e-02f, 4.35245149e-02f,
  -6.97448179e-02f, 3.97949032e-02f, 5.06740473e-02f, -3.63836400e-02f, -1.02746412e-01f, 3.11396010e-02f, 1.15652911e-01f, 7.48466104e-02f, 1.29453251e-02f, 2.96969078e-02f,
  -2.78234854e-02f, 1.85993209e-03f, 5.23877479e-02f, 5.62298596e-02f, -6.31025434e-02f, 3.89930382e-02f, 6.82809800e-02f, -3.88896577e-02f, 5.95795140e-02f, 7.45760500e-02f,
  2.99791470e-02f, 8.87396932e-02f, 1.13987895e-02f, 4.25482765e-02f, 7.81299733e-03f, -4.46347520e-02f, 1.18127826e-03f, -4.81734574e-02f, -6.22466132e-02f, -3.98341753e-02f,
  3.46648060e-02f, -7.55188763e-02f, 3.70121524e-02f, -2.50810906e-02f, -7.03535527e-02f, 5.56067862e-02f, 3.83276902e-02f, 3.10639441e-02f, 3.32291201e-02f, -3.16707715e-02f,
  -7.43597969e-02f, -2.27851234e-02f, -1.19691370e-02f, 1.00849560e-02f, 1.84816755e-02f, -7.14582801e-02f, 3.58460806e-02f, 7.32394978e-02f, -4.65518683e-02f, 3.60170230e-02f,
  4.88460362e-02f, -5.47848046e-02f, 1.03082759e-02f, 9.89843067e-03f, 7.12209791e-02f, 2.88311932e-02f, -2.02026088e-02f, 5.94329685e-02f, -8.44712555e-03f, -9.35665369e-02f,
  -2.64510125e-01f, -2.33010724e-01f, -5.43126836e-03f, -2.90397685e-02f, 1.10673048e-01f, -8.35012365e-03f, 7.18055218e-02f, 3.55292261e-02f, -3.11404951e-02f, -1.17242597e-02f,
  -1.63185671e-02f, -2.74625737e-02f, -5.87265529e-02f, 2.45241504e-02f, -3.84527445e-02f, -1.27806291e-02f, 3.01007740e-02f, 1.52787548e-02f, -1.88438579e-01f, -5.40895313e-02f,
  -1.85827315e-02f, -5.53919226e-02f, 6.51407391e-02f, -9.06577706e-02f, 8.01460538e-03f, -4.90173958e-02f, -8.98010880e-02f, 1.06921956e-01f, 5.67921735e-02f, 5.72991557e-02f,
  -3.75072777e-01f, 1.37270153e-01f, 5.48507795e-02f, -3.13210458e-01f, 1.90481201e-01f, -1.29955038e-02f, -8.96456242e-02f, 1.43919989e-01f, -1.72550216e-01f, 9.44303423e-02f,
  -2.68641979e-01f, -9.74040851e-02f, -5.94548695e-03f, -3.10126662e-01f, -2.99236000e-01f, -2.41602764e-01f, -2.96583056e-01f, -2.94367135e-01f, 3.57470177e-02f, -1.23107374e-01f,
  -7.78043270e-02f, 1.43473437e-02f, 8.47997293e-02f, 3.28349441e-01f, 1.83883533e-01f, 1.28178194e-01f, 7.03453943e-02f, 3.00490469e-01f, 3.55461203e-02f, 1.11555137e-01f,
  -2.80064046e-02f, -1.13950416e-01f, 1.11234076e-01f, 1.00142263e-01f, 1.74460467e-02f, 1.24117751e-02f, -8.76334906e-02f, 1.31219476e-01f, -7.68545130e-03f, 8.65442976e-02f,
  3.54851671e-02f, 1.68099143e-02f, 2.49399934e-02f, 9.08172280e-02f, 4.40474674e-02f, 2.71694791e-02f, 2.58737765e-02f, 1.51221035e-02f, 5.73629290e-02f, -1.70680303e-02f,
  -4.16349955e-02f, -4.20401469e-02f, -8.83441195e-02f, -2.17914078e-02f, -1.93284545e-02f, -4.89145853e-02f, 2.61507686e-02f, 6.51742611e-03f, 1.24768829e-02f, 2.89822277e-02f,
  1.59893259e-02f, -2.97981184e-02f, 2.10779309e-02f, 7.80191319e-03f, -1.80483479e-02f, -2.81799100e-02f, 5.38071580e-02f, 1.15546118e-02f, 2.63200458e-02f, -3.37958150e-02f,
  1.54318316e-02f, 7.48955598e-03f, -3.64593253e-03f, 6.19428381e-02f, 1.44093612e-03f, 1.49858417e-02f, 3.03079914e-02f, -1.40402932e-02f, -3.87909263e-02f, -1.96046140e-02f,
  4.68365327e-02f, -7.47926235e-02f, 2.98309382e-02f, 8.75288397e-02f, 1.62877552e-02f, 8.74836966e-02f, -3.98374870e-02f, -4.17213738e-02f, -5.59548512e-02f, 3.01127769e-02f,
  -2.46658653e-01f, -2.00247899e-01f, -2.75534838e-02f, 4.17018905e-02f, -7.63040408e-03f, -6.00768700e-02f, -2.78492607e-02f, -2.20612343e-02f, 1.14769459e-01f, -3.61346006e-02f,
  -4.43355218e-02f, 1.33237345e-02f, -1.25502481e-03f, -2.76623424e-02f, -7.43529899e-03f, 5.08319261e-03f, -1.74268022e-01f, -3.51252146e-02f, 3.39951031e-02f, -4.12872387e-03f,
  4.70378064e-02f, 3.95969488e-02f, 7.15402961e-02f, 1.05189085e-01f, -2.61425152e-02f, -1.37982396e-02f, -1.07788764e-01f, 6.27641231e-02f, 1.38338571e-02f, -3.31627531e-03f,
  -9.54813585e-02f, -2.43111759e-01f, -1.22648545e-01f, -2.74819374e-01f, 3.45127612e-01f, 2.73875982e-01f, -2.37345427e-01f, 1.04559176e-01f, -2.76440382e-01f, -7.66633600e-02f,
  1.15879953e-01f, -2.18115151e-01f, -3.09909713e-02f, -1.56387135e-01f, 1.17218010e-01f, -2.17853874e-01f, 1.12545051e-01f, -7.37366751e-02f, -5.70222214e-02f, 9.97778177e-02f,
  2.25616936e-02f, 2.89193273e-01f, 6.67140558e-02f, 2.89715648e-01f, 1.68412507e-01f, 2.96320990e-02f, 1.72931463e-01f, 3.26521099e-02f, 9.44748446e-02f, 2.89390590e-02f,
  6.67367280e-02f, -7.76770264e-02f, -1.26308218e-01f, -5.42325564e-02f, 1.27508521e-01f, -1.07417433e-02f, 2.48239338e-02f, -1.26361772e-02f, -1.15779396e-02f, 7.16588050e-02f,
  -3.55913639e-02f, 1.08988740e-01f, -6.77984357e-02f, -1.91182308e-02f, -8.64988491e-02f, -4.72842716e-02f, 2.98380684e-02f, -2.46351883e-02f, -5.69109023e-02f, 1.31705264e-02f,
  -1.07033178e-02f, 2.48518045e-04f, 4.84238984e-03f, 1.52266370e-02f, -3.91222090e-02f, -7.00440705e-02f, -5.26554175e-02f, -1.64995976e-02f, 3.22891213e-02f, -1.42718786e-02f,
  -1.38108199e-02f, -3.98376212e-02f, 1.09254401e-02f, 6.27732603e-03f, -2.72616092e-02f, -1.69830248e-02f, -1.38432032e-03f, 7.52160475e-02f, -1.29444443e-03f, 3.04223411e-02f,
  7.95914307e-02f, -3.57951894e-02f, -5.55448309e-02f, 5.54779358e-02f, 1.12154661e-02f, -9.36759859e-02f, 1.11600454e-03f, 7.26144835e-02f, -3.91670838e-02f, 4.53891605e-03f,
  -7.96698183e-02f, 3.54817063e-02f, -2.11670883e-02f, 2.04993896e-02f, 1.03591112e-02f, 3.34630013e-02f, -5.50177209e-02f, -6.52061924e-02f, 3.13067483e-03f, 8.28740671e-02f,
  2.16658458e-01f, 7.50543997e-02f, 1.74759254e-02f, 7.35922605e-02f, 1.93386003e-02f, 6.23791292e-02f, -1.00318767e-01f, 7.85509881e-04f, 1.09176105e-02f, -3.15778814e-02f,
  1.39642715e-01f, 2.37004012e-02f, 1.01742655e-01f, -3.15190032e-02f, 8.51674676e-02f, 3.29562835e-02f, 6.50863023e-03f, 6.12803772e-02f, 1.30140275e-01f, 2.43282150e-02f,
  4.61597228e-04f, 9.24187079e-02f, -4.68850732e-02f, 7.58031979e-02f, 5.50334938e-02f, 8.37701410e-02f, 1.67837199e-02f, -7.69619690e-03f, 1.85773939e-01f, 9.66098718e-03f,
  3.58125329e-01f, -1.36106014e-01f, -2.01016337e-01f, 2.16050699e-01f, 8.34561791e-03f, 2.76051670e-01f, 1.07229955e-01f, 2.84730997e-02f, 2.83937514e-01f, -3.66173424e-02f,
  -1.58424661e-01f, 8.71573947e-03f, -2.49228805e-01f, 1.96912959e-01f, 2.07351595e-01f, 6.54755458e-02f, 2.63657659e-01f, 1.56253144e-01f, -2.76050549e-02f, -8.71727392e-02f,
  1.30706444e-01f, 1.45189151e-01f, -8.36135373e-02f, -1.05656460e-01f, 8.09727609e-03f, -1.37594864e-01f, -2.41905689e-01f, -1.63641706e-01f, 1.40116319e-01f, -1.15851220e-02f,
  8.04819241e-02f, 6.61650524e-02f, -1.49894254e-02f, 1.09605670e-01f, 4.55321715e-04f, 6.30673319e-02f, -1.26262251e-02f, 1.49319926e-02f, 1.71357226e-02f, -1.14758778e-02f,
  1.85280498e-02f, 6.95694610e-02f, 6.64165150e-03f, 3.59809585e-03f, 9.85900983e-02f, 4.65482250e-02f, 6.52284697e-02f, -1.77816860e-02f, 1.19670657e-02f, 3.70742418e-02f,
  -2.89023258e-02f, 1.08857498e-01f, 6.58018934e-03f, -1.08702481e-02f, -5.62356040e-02f, -9.33228899e-03f, 4.91667539e-03f, -5.24004363e-03f, -7.41884485e-03f, 3.88589426e-04f,
  -6.45678788e-02f, 3.93703803e-02f, -2.80896630e-02f, 5.22559248e-02f, 1.00902282e-02f, 1.19654713e-02f, 1.34763662e-02f, 3.59804295e-02f, 1.26888407e-02f, -1.31102558e-02f,
  3.00963968e-02f, -4.79334332e-02f, -8.92022252e-03f, -3.43488865e-02f, -1.56762637e-02f, 4.40334752e-02f, -5.83113469e-02f, -3.61568965e-02f, -2.49677524e-02f, 1.87244844e-02f,
  -9.19267256e-03f, 5.52092269e-02f, -2.24728175e-02f, -3.65340523e-02f, 5.08936681e-02f, -2.57610232e-02f, -1.04658134e-01f, 6.52886778e-02f, -7.70489573e-02f, -6.27506152e-02f,
  -1.39648408e-01f, -1.42973706e-01f, -2.69423947e-02f, 1.09469844e-02f, -4.07483056e-03f, -4.00958881e-02f, 6.51852265e-02f, -2.66658086e-02f, -1.17432689e-02f, 6.70483336e-02f,
  -3.15173231e-02f, 5.18439487e-02f, -9.00302269e-03f, 9.42570120e-02f, 7.00355228e-03f, -7.82387778e-02f, -1.06270887e-01f, -6.78813085e-02f, -8.28997046e-02f, -3.33432555e-02f,
  -7.46347457e-02f, -3.64396982e-02f, 3.24340002e-03f, 8.45981762e-02f, -7.04125781e-03f, -1.11104315e-02f, -2.20058616e-02f, 7.26749003e-02f, -1.16677405e-02f, 5.59666287e-03f,
  -1.87210262e-01f, 1.67307884e-01f, -2.11864915e-02f, -2.24307328e-01f, -2.65724123e-01f, 1.59662947e-01f, -1.12182237e-01f, -1.20568462e-03f, -1.98993653e-01f, 1.52818754e-01f,
  7.60623366e-02f, -1.92873269e-01f, 3.08557868e-01f, 7.24212825e-02f, 2.99449116e-01f, 3.60576242e-01f, 4.11935113e-02f, -2.93989126e-02f, -4.25924882e-02f, -1.11734927e-01f,
  8.35135463e-04f, 5.05756252e-02f, 1.47168769e-03f, 4.46227565e-02f, -1.96850866e-01f, -1.96193859e-01f, 1.71362951e-01f, -2.08309710e-01f, 1.90660972e-02f, 2.90145017e-02f,
  8.44103396e-02f, -2.01810658e-01f, -6.42622858e-02f, 1.55417966e-02f, 4.18673977e-02f, -7.28741139e-02f, 4.22142856e-02f, 1.63981803e-02f, -5.63578121e-03f, -2.40978524e-02f,
  -7.55423009e-02f, -6.26247609e-03f, -6.75793737e-02f, -3.08562443e-02f, -1.38121337e-01f, -6.13647792e-03f, 1.18735647e-02f, -2.34175548e-02f, -1.45152882e-01f, 9.02531610e-04f,
  -6.32793009e-02f, 9.25949588e-02f, -1.87802315e-02f, 1.16159558e-01f, 8.30097124e-03f, -2.81195007e-02f, -5.60839437e-02f, 2.27498282e-02f, 7.12720305e-02f, -1.13720037e-01f,
  -2.27547623e-02f, 3.48446965e-02f, -2.32314300e-02f, -9.67418961e-03f, -1.89630631e-02f, -8.96517262e-02f, 5.48644178e-03f, 3.56197618e-02f, 4.43574898e-02f, 5.90676703e-02f,
  -6.67618215e-02f, -1.43206613e-02f, -1.03388965e-01f, -3.76088805e-02f, -4.04274426e-02f, -9.34902430e-02f, 3.17579880e-02f, 8.58092681e-02f, -3.14743035e-02f, 1.97607931e-02f,
  -5.76236062e-02f, -7.24363141e-03f, 1.22991120e-02f, 7.47445133e-03f, 5.16584814e-02f, 7.18960539e-02f, -4.81756367e-02f, 2.59906761e-02f, -6.07161820e-02f, -8.90314765e-03f,
  2.88666010e-01f, 1.53151989e-01f, -1.62380990e-02f, 3.57988998e-02f, -8.88337195e-03f, 7.75056109e-02f, 5.32775000e-02f, -9.31424741e-03f, 5.55912331e-02f, 1.94830988e-02f,
  8.46216902e-02f, -5.79383597e-02f, 7.34853521e-02f, 2.31390968e-02f, 1.13092447e-02f, 9.98656228e-02f, 2.29760315e-02f, 3.76560949e-02f, -2.73694973e-02f, 2.94280481e-02f,
  1.55543694e-02f, -1.94103867e-02f, -1.02077365e-01f, -8.71709809e-02f, 5.47335483e-03f, -7.38271773e-02f, 9.21140425e-03f, -2.04832405e-02f, -5.42873703e-03f, 3.13101076e-02f,
  1.71437159e-01f, 2.89286673e-01f, -1.75076276e-01f, 6.93244115e-02f, 1.76075742e-01f, -1.29016891e-01f, -1.28536195e-01f, 2.30694339e-01f, -1.45807788e-01f, 8.07616636e-02f,
  2.04846621e-01f, -3.75591218e-02f, -1.18562400e-01f, 1.48590490e-01f, -3.12404871e-01f, -1.39198422e-01f, -6.57475591e-02f, 5.43152168e-02f, -1.56277299e-01f, 6.92174509e-02f,
  -5.46332076e-02f, 1.99342623e-01f, 5.57111129e-02f, 1.27683148e-01f, 2.11454049e-01f, 9.68520716e-02f, 8.54568034e-02f, -6.50221203e-03f, 1.60765931e-01f, -6.00233711e-02f,
  1.15962461e-01f, 3.49422321e-02f, 7.87314251e-02f, -3.25694755e-02f, 7.45004639e-02f, 4.31041270e-02f, -5.11144008e-03f, -1.31618515e-01f, -1.29833460e-01f, -5.02885692e-02f,
  -4.22262140e-02f, 1.16390496e-01f, -4.93966043e-03f, -5.15594073e-02f, 1.80767458e-02f, 3.09117008e-02f, 3.70968543e-02f, 2.69399080e-02f, 3.37074734e-02f, -4.58439700e-02f,
  -3.42206396e-02f, 2.07567662e-02f, -6.02095872e-02f, -1.00486696e-01f, -1.05691530e-01f, -1.00400947e-01f, -6.94167241e-02f, 3.10615748e-02f, 9.15639028e-02f, -2.51480024e-02f,
  -5.53411394e-02f, -6.21830039e-02f, -4.72194515e-02f, 2.04091072e-02f, 4.34619561e-02f, 6.98336065e-02f, -3.18014883e-02f, -2.13679653e-02f, -2.44376361e-02f, -1.42429555e-02f,
  9.83466953e-02f, -1.88275129e-02f, 3.91460098e-02f, -2.69464552e-02f, 2.32970919e-02f, -1.37593318e-02f, -1.14221498e-02f, 1.07807711e-01f, -2.26238798e-02f, 1.76239256e-02f,
  -3.02607846e-02f, -4.25506495e-02f, 4.70015332e-02f, -5.18150348e-03f, -6.90671504e-02f, 3.33458185e-02f, 8.38388577e-02f, 6.83829114e-02f, -8.57058540e-02f, 8.39434043e-02f,
  1.23688526e-01f, 1.97587341e-01f, -2.72922572e-02f, 6.19501760e-03f, 1.47361336e-02f, 3.59375402e-02f, -1.20866023e-01f, -1.02577820e-01f, 1.65733490e-02f, 2.27443092e-02f,
  -6.61575869e-02f, 7.13029057e-02f, -1.81957725e-02f, 4.04418400e-03f, 2.32805852e-02f, -1.35496184e-02f, 1.26719549e-02f, 1.70695875e-02f, 8.46085995e-02f, 2.07997393e-02f,
  8.17261338e-02f, -1.21842781e-02f, -2.73369104e-02f, 2.44912002e-02f, 2.79334951e-02f, 3.08890678e-02f, -1.88343320e-02f, -1.26804695e-01f, 1.27549460e-02f, -6.41742796e-02f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.23243022e-01f, 3.97350788e-01f, -2.18358752e-03f, 1.39655948e-01f, -1.65449917e-01f, 2.87382841e-01f, 1.99472547e-01f, -2.15213839e-02f, 2.05390051e-01f, 2.76063412e-01f,
  -1.04909569e-01f, 3.94126058e-01f, -1.05113447e-01f, 2.11889163e-01f, -2.35273745e-02f, -1.60505161e-01f, 2.85450786e-01f, 2.29260832e-01f, 2.28232685e-02f, 2.87337393e-01f,
  -1.33988149e-02f, 3.27661410e-02f, -3.34483087e-01f, 7.06155598e-02f, 1.97623312e-01f, 1.20086418e-02f, -3.04327399e-01f, -2.31316969e-01f, 2.72919685e-02f, -5.65464459e-02f,
  7.56049380e-02f, 1.37347296e-01f, 5.75100146e-02f, 5.03456555e-02f, -2.51347404e-02f, 1.23624178e-02f, -9.06374007e-02f, -1.07708387e-01f, -1.69637144e-01f, 4.15912718e-02f,
  1.86146438e-01f, 1.94033068e-02f, 1.19493119e-01f, 2.26456579e-02f, 1.40852854e-01f, 8.76577497e-02f, -6.37936816e-02f, 9.90491081e-03f, 1.32190129e-02f, 4.68548648e-02f,
  1.02168232e-01f, 7.77789652e-02f, 1.51856365e-02f, -1.41536310e-01f, -1.10215977e-01f, -5.94175830e-02f, 2.89143883e-02f, -4.80553834e-03f, 1.12476535e-02f, 1.01651564e-01f,
  8.27966630e-02f, 1.88045204e-02f, -1.34538105e-02f, -5.37780784e-02f, 4.83136028e-02f, -6.93427324e-02f, 1.38506265e-02f, -1.31787315e-01f, -4.25645486e-02f, -2.54963082e-03f,
  -1.34202512e-02f, 5.08554243e-02f, 1.93130763e-04f, 4.97079007e-02f, 1.77816246e-02f, 1.40385851e-01f, -4.38210554e-02f, 8.37271810e-02f, 5.00856079e-02f, 9.65749845e-02f,
  -8.91939029e-02f, 3.37020792e-02f, 5.90107515e-02f, 1.50772603e-02f, -5.02165258e-02f, 2.77619846e-02f, 1.39567047e-01f, 7.29345530e-02f, -1.17408834e-01f, -8.05075467e-02f,
  -2.16186373e-03f, 2.90913701e-01f, 7.64759704e-02f, 2.84478217e-02f, -6.13986924e-02f, 6.72092522e-03f, 4.09996472e-02f, 1.37808323e-01f, -4.11171280e-02f, 1.15548417e-01f,
  1.50143623e-01f, 1.75069831e-02f, 2.24911217e-02f, -9.28803533e-02f, -1.26783215e-02f, 3.93489413e-02f, 4.00441512e-02f, -4.34499718e-02f, -1.15125820e-01f, -2.78813224e-02f,
  1.12113088e-01f, 1.77527681e-01f, 3.96170691e-02f, -2.23943684e-02f, 9.93624777e-02f, -2.04294715e-02f, 1.01231329e-01f, -6.53696358e-02f, -1.48967216e-02f, -1.39638245e-01f,
  -2.65815824e-01f, 2.49647781e-01f, 3.36557299e-01f, 2.40882486e-01f, -1.41473383e-01f, 5.62291313e-03f, 2.02625334e-01f, 1.00904763e-01f, 2.09710240e-01f, 6.74935058e-02f,
  1.49082631e-01f, -1.37455389e-01f, 2.07580365e-02f, 3.21382523e-01f, -4.72626567e-01f, 1.57589957e-01f, 2.02453062e-01f, -1.54616293e-02f, -4.13126908e-02f, 3.63468453e-02f,
  -3.45213674e-02f, -3.57841581e-01f, 1.32252336e-01f, -1.25932276e-01f, 2.09727421e-01f, 6.71391468e-03f, -2.52465457e-01f, -1.34649649e-01f, -4.47334088e-02f, -1.13224454e-01f,
  -2.60290056e-01f, 1.54791623e-01f, -1.36011783e-02f, -5.03382944e-02f, -2.91627273e-02f, -1.12801686e-01f, -1.56217003e-02f, -1.63235098e-01f, -1.98307782e-01f, 3.91006880e-02f,
  1.21568017e-01f, -7.77102485e-02f, -1.05050363e-01f, -4.32952866e-02f, 9.58577320e-02f, -1.52032422e-02f, 1.40429512e-01f, 2.51317173e-01f, 4.45200764e-02f, 1.12055250e-01f,
  1.46116570e-01f, 9.27741751e-02f, 8.45719799e-02f, 4.95591797e-02f, -3.47458534e-02f, 1.24975346e-01f, 2.03504413e-02f, 5.49943857e-02f, 3.77228409e-02f, 4.97139432e-02f,
  1.05203010e-01f, -5.04118577e-02f, -5.53426053e-03f, -2.36296952e-02f, 5.91404252e-02f, 1.87326163e-01f, -5.14038689e-02f, -2.30123773e-02f, -3.88817862e-02f, 8.23361203e-02f,
  -5.39362803e-02f, 3.54063548e-02f, 5.94811551e-02f, -5.38896304e-03f, -2.98056565e-02f, -2.50107069e-02f, -1.02202289e-01f, 1.00884140e-02f, 4.82662469e-02f, 9.84416995e-03f,
  -7.10300654e-02f, -3.05465404e-02f, 5.50276376e-02f, -3.53561230e-02f, -1.66994765e-01f, -3.63796428e-02f, 7.88481385e-02f, 2.10150614e-01f, -4.16340679e-02f, -2.11012498e-01f,
  -6.31960988e-01f, -5.35488665e-01f, -2.06157967e-01f, -1.47081405e-01f, -1.14283316e-01f, -2.44848859e-02f, 3.46748754e-02f, 1.13341063e-02f, -1.03210837e-01f, -3.24988961e-02f,
  -6.65256307e-02f, 1.31526574e-01f, -1.45799369e-01f, -5.01964763e-02f, -1.64587244e-01f, -2.11722348e-02f, -4.48032357e-02f, -6.29487634e-02f, -2.56309509e-01f, -4.12433185e-02f,
  -5.72309941e-02f, -4.26225476e-02f, -1.67733766e-02f, -7.60136321e-02f, 7.89718926e-02f, -1.14453509e-01f, -1.37950823e-01f, -2.85258703e-02f, -1.37378395e-01f, -3.88683490e-02f,
  -6.70526743e-01f, 4.75245714e-01f, 1.47134036e-01f, -6.62941858e-02f, -1.72903210e-01f, -2.43369460e-01f, 8.40494186e-02f, 3.06831226e-02f, 1.71488911e-01f, 3.57579380e-01f,
  5.66759519e-02f, 2.06218481e-01f, 1.86272457e-01f, 2.26337314e-01f, -5.34086704e-01f, -2.13122573e-02f, -4.68005463e-02f, 3.65821980e-02f, -6.30645007e-02f, -2.68345345e-02f,
  -1.69921309e-01f, -1.10147469e-01f, -6.65215030e-02f, 1.61069989e-01f, 8.40258747e-02f, 3.54901850e-02f, -2.07729518e-01f, -1.72078784e-03f, 4.80945520e-02f, -1.01841629e-01f,
  -3.62290442e-01f, -4.77720313e-02f, 1.34864628e-01f, -9.10247266e-02f, -1.73840061e-01f, 3.04930136e-02f, -1.00101225e-01f, -4.58298512e-02f, -5.14045879e-02f, -2.13226825e-02f,
  -1.26819499e-03f, 2.37883092e-03f, -7.39034042e-02f, 3.36455368e-02f, 5.21088131e-02f, 3.74828316e-02f, 1.33778155e-01f, 2.83417143e-02f, 1.50445187e-02f, -8.05615485e-02f,
  1.98336869e-01f, 9.86198038e-02f, -1.08757420e-02f, 8.45801234e-02f, -2.47937068e-02f, -5.04903644e-02f, -2.12788545e-02f, -1.37796365e-02f, 7.50293732e-02f, -6.43241266e-03f,
  7.03144958e-03f, -3.03591136e-02f, 3.46581265e-02f, -2.05900110e-02f, 5.53475367e-03f, 1.21868506e-01f, 3.43926027e-02f, -5.65021634e-02f, -2.66509820e-02f, -3.26376967e-02f,
  -4.25309539e-02f, 3.99887487e-02f, -1.41943833e-02f, -1.00790143e-01f, -5.56545937e-03f, 1.03699660e-03f, -6.24975376e-03f, -6.18576491e-03f, -3.34987305e-02f, -1.62497144e-02f,
  -5.61611615e-02f, -2.92913374e-02f, 2.22496577e-02f, -5.34770414e-02f, -4.10546139e-02f, -5.67489229e-02f, 2.35199686e-02f, 6.60364106e-02f, -8.89903978e-02f, -1.96930230e-01f,
  -4.94313449e-01f, -4.46575791e-01f, -1.23460129e-01f, -1.18344791e-01f, 4.59426129e-03f, -1.54002458e-01f, -4.24778275e-02f, 9.10298247e-03f, -2.10192427e-01f, -2.83737984e-02f,
  -9.46565568e-02f, 5.79884388e-02f, -9.03140455e-02f, -9.95768607e-02f, -8.09428170e-02f, -1.21815130e-01f, -1.18542172e-01f, -4.75835577e-02f, -9.11305770e-02f, -1.01563141e-01f,
  1.00917660e-01f, 1.69788431e-02f, 2.76887752e-02f, -4.37640995e-02f, -1.32369427e-02f, -1.05562411e-01f, -5.69211617e-02f, 5.96994087e-02f, -1.03675641e-01f, 1.36502311e-01f,
  -3.13068509e-01f, 3.44532698e-01f, 2.51869857e-01f, 1.20685294e-01f, -1.24449506e-01f, -4.14476037e-01f, -3.37197334e-01f, 3.01258087e-01f, -5.38684875e-02f, 1.97970852e-01f,
  1.49177210e-02f, 1.26646444e-01f, 2.10728750e-01f, -1.92675933e-01f, -4.88022596e-01f, -2.79103637e-01f, -1.76649019e-01f, -2.20650136e-01f, 4.61976193e-02f, 3.02411169e-01f,
  -4.71890718e-02f, -1.62349463e-01f, 1.18736401e-01f, 1.90869540e-01f, 1.82166219e-01f, 2.52325624e-01f, 2.81556845e-01f, 2.77133197e-01f, 4.32033017e-02f, -1.42854854e-01f,
  -3.50310542e-02f, 2.40144566e-01f, 1.04208797e-01f, 1.19691752e-02f, -1.48027577e-02f, 5.58795333e-02f, -4.69667949e-02f, 1.25118589e-03f, -1.32486865e-01f, 3.74709368e-02f,
  6.67701811e-02f, -7.74656981e-03f, 5.08682244e-02f, -1.39151573e-01f, -4.16009575e-02f, 4.66144197e-02f, -5.31638116e-02f, -1.37032866e-01f, 6.29977137e-02f, 2.63513774e-02f,
  2.73683071e-02f, -1.42180603e-02f, 1.11792982e-02f, 8.90321657e-02f, 1.18359871e-01f, -6.34769872e-02f, -1.30427241e-01f, 6.22927397e-02f, 8.74903500e-02f, 7.80732706e-02f,
  8.20654705e-02f, 1.85622945e-02f, -1.49129573e-02f, 2.90331576e-04f, -4.22419654e-03f, 1.07825994e-01f, 1.04097456e-01f, -2.30022203e-02f, 1.23555562e-03f, 1.40369320e-02f,
  -4.59390581e-02f, 1.04901142e-01f, -3.85447107e-02f, -1.40178397e-01f, 1.27570191e-02f, -1.41709633e-02f, -2.58291829e-02f, 1.17617212e-02f, -2.92386226e-02f, -9.03577730e-03f,
  5.82736097e-02f, -4.05479856e-02f, 7.59457471e-03f, 9.74663720e-02f, -9.93183255e-02f, 3.86961037e-03f, 9.05406922e-02f, 6.19841702e-02f, -8.60773586e-03f, 9.79449041e-03f,
  1.34740323e-01f, 3.22201222e-01f, 1.28908634e-01f, -8.99131447e-02f, 3.55350561e-02f, 6.92191422e-02f, -1.02677785e-01f, -3.41173038e-02f, 6.91387206e-02f, -3.80842425e-02f,
  4.75354567e-02f, -9.18966532e-02f, 5.90840504e-02f, -4.10658196e-02f, -7.74236768e-02f, -2.17409176e-03f, 4.55391966e-02f, 1.87479183e-02f, 3.01783010e-02f, 1.25492185e-01f,
  1.70440376e-01f, -2.95018014e-02f, 7.18875080e-02f, -8.55450854e-02f, 4.08813059e-02f, 7.41754323e-02f, -8.06238968e-03f, -5.39248921e-02f, 9.42696258e-02f, -3.64505574e-02f,
  -1.37780815e-01f, -1.73915148e-01f, -2.73964345e-01f, -3.33322376e-01f, 9.16563198e-02f, 2.06008554e-02f, -3.23585629e-01f, -7.10398778e-02f, -3.47623438e-01f, -2.71874275e-02f,
  -1.03144549e-01f, -2.71382213e-01f, -2.08726957e-01f, -3.72975141e-01f, -2.48771772e-01f, -1.29604757e-01f, -2.01692656e-01f, -2.24545598e-01f, -1.64727122e-01f, -2.29899451e-01f,
  -1.37916014e-01f, -1.91849738e-01f, -2.61944592e-01f, 8.03172812e-02f, -1.65050179e-01f, 3.34817469e-02f, 3.41230243e-01f, -3.85380238e-02f, -2.87005510e-02f, 6.46649078e-02f,
  -1.07071184e-01f, -2.55158484e-01f, -1.78809077e-01f, -1.89408625e-03f, 5.98275661e-02f, 1.02587700e-01f, 6.45013452e-02f, -1.34900972e-01f, -1.70594513e-01f, -1.02411225e-01f,
  4.76643220e-02f, -5.92639931e-02f, -4.63519953e-02f, -1.48761168e-01f, 4.00340781e-02f, -7.12225735e-02f, 7.08601028e-02f, -2.21250597e-02f, -9.14110392e-02f, -8.69904459e-02f,
  -1.78797171e-01f, 1.30707473e-01f, 1.24528252e-01f, -8.01027343e-02f, -5.48920818e-02f, 2.47064442e-03f, -6.24504220e-03f, 1.27246687e-02f, 7.24062622e-02f, 9.22539085e-02f,
  -1.61090288e-02f, 1.14538729e-01f, 3.27826887e-02f, -3.52503285e-02f, -1.14082722e-02f, -4.84759137e-02f, -3.33924703e-02f, 4.54357453e-03f, 1.89780146e-02f, 5.69098741e-02f,
  1.61244795e-02f, -1.49978235e-01f, -9.95867625e-02f, 7.96225891e-02f, 9.57583934e-02f, 1.21387184e-01f, -1.96031630e-02f, 6.86193630e-02f, -5.27304932e-02f, 2.81852819e-02f,
  -1.68479104e-02f, -2.31945422e-02f, -9.30573493e-02f, 2.40857359e-02f, -9.71597712e-03f, -9.21554491e-02f, 3.65413241e-02f, 1.33786350e-01f, 3.28609683e-02f, -5.88301197e-03f,
  9.89125073e-02f, 4.78021018e-02f, -1.33109376e-01f, 1.05732502e-02f, -5.75102419e-02f, 1.11976996e-01f, 3.22000906e-02f, -3.68127152e-02f, 4.05227095e-02f, -1.36202991e-01f,
  4.26917858e-02f, -1.31256469e-02f, 1.09123744e-01f, -1.53288782e-01f, 1.12376802e-01f, 1.25800520e-02f, -3.39809395e-02f, 8.38982388e-02f, 1.60723805e-01f, 5.50410673e-02f,
  1.11241519e-01f, 1.39990345e-01f, -4.29950608e-03f, -5.51296733e-02f, -2.51455810e-02f, 1.74641740e-02f, -2.80484464e-02f, -7.49259889e-02f, 3.97330672e-02f, 8.77239481e-02f,
  -3.88286203e-01f, 1.13130979e-01f, 3.55654836e-01f, -4.96990353e-01f, 1.53715447e-01f, 4.99486804e-01f, -2.04442427e-01f, 1.70934036e-01f, -2.86451697e-01f, -2.43515715e-01f,
  -3.69950086e-02f, -3.48502487e-01f, 1.27329394e-01f, -2.67126292e-01f, 4.33217078e-01f, 1.68581739e-01f, -1.37325794e-01f, -3.48255098e-01f, -4.71275970e-02f, -2.73664862e-01f,
  -5.24222106e-02f, -3.13272983e-01f, 2.21825823e-01f, 6.54270500e-02f, -2.22621664e-01f, -1.56343043e-01f, -3.48108441e-01f, 2.18679145e-01f, -1.95945725e-01f, 5.86947612e-02f,
  6.28726184e-02f, -6.96294233e-02f, 1.53349936e-01f, 7.84100071e-02f, 1.93033442e-02f, -6.38808236e-02f, -5.92858978e-02f, 1.16379030e-01f, -1.11849181e-01f, -8.15681368e-02f,
  -1.28136054e-01f, 6.41906783e-02f, -1.20160259e-01f, 7.71306604e-02f, -1.27737001e-01f, 1.22593646e-03f, -7.11795222e-03f, 3.72393690e-02f, 7.53413960e-02f, 2.12319903e-02f,
  1.57659709e-01f, 1.33118348e-03f, -1.95721462e-02f, -1.19926527e-01f, -6.93192109e-02f, 2.20996309e-02f, 2.55913958e-02f, -3.86152305e-02f, -9.48899016e-02f, -5.23229055e-02f,
  6.97746873e-03f, 4.27614897e-02f, 3.02293152e-02f, 6.79171011e-02f, 2.14684084e-02f, 3.42449918e-02f, -9.54315439e-02f, -1.75147727e-02f, 1.12378811e-02f, 7.34909996e-03f,
  5.00417426e-02f, -6.37792870e-02f, -9.87129509e-02f, -1.22617662e-01f, 2.03429479e-02f, -9.59864333e-02f, -6.96853623e-02f, -2.36379858e-02f, -6.58040792e-02f, 9.29068848e-02f,
  -1.31369665e-01f, -1.37935707e-03f, 1.10271238e-02f, -7.19124675e-02f, 9.55917761e-02f, -2.43992023e-02f, -9.12207067e-02f, 3.95069607e-02f, 1.62609909e-02f, 5.64239454e-04f,
  6.76068589e-02f, -9.93150920e-02f, 1.19807564e-01f, -2.27299985e-02f, 4.22090106e-03f, 1.40343577e-01f, 2.30201408e-02f, 6.41087145e-02f, 5.40153310e-02f, 1.48672154e-02f,
  -8.53243619e-02f, -7.21589699e-02f, 2.17400603e-02f, -7.78653240e-03f, 3.07179126e-03f, 2.50670537e-02f, -1.45919889e-01f, -5.68012819e-02f, -7.42085055e-02f, -1.03169680e-02f,
  -1.03577137e-01f, -1.18202873e-01f, -8.04609135e-02f, -1.58976763e-01f, -6.21527098e-02f, -6.83903173e-02f, -8.98548141e-02f, -1.50580592e-02f, -9.90675390e-02f, 2.88667833e-03f,
  3.32213879e-01f, -1.62946239e-01f, -3.93442959e-01f, -6.49195388e-02f, 3.06740999e-01f, 3.71113449e-01f, 2.68733054e-01f, 6.90835938e-02f, -7.50502124e-02f, 1.49533078e-01f,
  3.25705111e-01f, -3.24802905e-01f, -1.29972920e-01f, 7.10794106e-02f, 2.62833573e-02f, -1.52949020e-01f, 6.81401938e-02f, -2.39762496e-02f, -1.53661847e-01f, 2.71102101e-01f,
  1.03124529e-02f, 1.97182238e-01f, -2.85949081e-01f, -1.56591088e-02f, 2.72084266e-01f, -9.20422841e-03f, 2.63589948e-01f, -1.65575296e-01f, 4.56608534e-02f, -5.76015972e-02f,
  7.83544034e-02f, -1.97303817e-02f, -1.92532018e-02f, -1.27777115e-01f, 1.44820496e-01f, 1.66503757e-01f, -4.52933945e-02f, -4.64967228e-02f, -5.62139414e-02f, -7.25379363e-02f,
  9.83189344e-02f, -1.55639291e-01f, -1.03825904e-01f, -4.54381630e-02f, 9.40103605e-02f, -9.47207958e-02f, -1.16234839e-01f, 6.88575059e-02f, -6.30788431e-02f, -9.43215843e-03f,
  -5.13303019e-02f, -3.25284302e-02f, 1.44621491e-01f, -5.55764623e-02f, 4.26525921e-02f, -3.90673727e-02f, -1.61093742e-01f, -1.93788838e-02f, 2.99841072e-02f, 6.40230328e-02f,
  1.37457252e-01f, 7.47289415e-03f, 5.16831828e-03f, -7.13546947e-02f, -7.69805014e-02f, 4.99628596e-02f, 3.79503295e-02f, 7.80441798e-03f, -8.68159682e-02f, 3.53896730e-02f,
  -6.73497766e-02f, 2.21763793e-02f, -3.50344405e-02f, 1.44570069e-02f, 1.50325894e-01f, -8.07445794e-02f, -1.11160344e-02f, 1.63726304e-02f, -5.37696294e-03f, -1.51690645e-02f,
  -7.98076615e-02f, -2.31074933e-02f, -7.55541176e-02f, 3.68277580e-02f, -3.52714062e-02f, -6.61601424e-02f, 7.36346319e-02f, 5.22697084e-02f, -7.41529390e-02f, -7.54924342e-02f,
  4.33190539e-02f, 6.21269457e-02f, -6.08152784e-02f, 8.18163343e-03f, -7.55842626e-02f, 1.24709733e-01f, 1.50065525e-02f, -8.97486359e-02f, -1.34164849e-02f, 8.31703916e-02f,
  1.06327020e-01f, 7.28171170e-02f, 3.91717330e-02f, 4.16541025e-02f, -4.34179530e-02f, 2.17031300e-01f, 7.79840350e-02f, -8.88290629e-02f, 1.32550493e-01f, 3.09560876e-02f,
  1.22678988e-01f, 1.00210547e-01f, 3.91982822e-03f, -1.09905722e-02f, -5.17554171e-02f, 1.08286634e-01f, 1.01402998e-01f, -6.10419698e-02f, 1.51002824e-01f, -5.92419989e-02f,
  1.77889261e-02f, -4.68311459e-01f, -3.21742117e-01f, -1.42503530e-01f, 1.91682968e-02f, 3.43000770e-01f, 4.31551456e-01f, -3.14106911e-01f, -4.45560575e-01f, -2.43745819e-02f,
  3.45728278e-01f, -1.51311941e-02f, 1.21704318e-01f, 2.22016335e-01f, 4.32798028e-01f, 1.38516888e-01f, 2.15207860e-01f, 1.68014854e-01f, -2.02172175e-01f, -1.17254883e-01f,
  -6.67839870e-02f, 2.42085442e-01f, 2.00055495e-01f, -2.25589290e-01f, 8.77649784e-02f, -2.10012704e-01f, 7.70173967e-02f, 8.18646979e-03f, 1.75675109e-01f, 2.42756844e-01f,
  5.93275810e-03f, -2.60479629e-01f, -6.46198541e-02f, 5.00126788e-03f, 1.31694794e-01f, 4.59176302e-02f, 1.77539289e-01f, 2.82635897e-01f, 1.42348617e-01f, -3.13825011e-02f,
  1.59401059e-01f, -2.56586988e-02f, -7.04706013e-02f, 8.70349109e-02f, -7.17428401e-02f, -9.99413952e-02f, -5.32239676e-02f, -8.21439698e-02f, -5.29131899e-03f, -9.29590091e-02f,
  -1.22543678e-01f, -1.10149786e-01f, -4.76794913e-02f, -2.41384711e-02f, -4.75215875e-02f, -5.97535297e-02f, -3.94346155e-02f, 1.47972301e-01f, -1.47665724e-01f, -1.80493161e-01f,
  7.29459152e-02f, 3.63697708e-02f, -9.70655233e-02f, 4.27010749e-03f, 2.94793993e-02f, 4.56280075e-02f, -3.98521982e-02f, 1.54586717e-01f, 2.98827607e-02f, 6.63536489e-02f,
  -3.84030193e-02f, -2.27012243e-02f, -7.67641440e-02f, 1.11999055e-02f, -9.47112888e-02f, -8.61100703e-02f, 1.83405742e-01f, 3.08152363e-02f, -2.39914400e-03f, 1.09336279e-01f,
  6.98071998e-03f, 5.31712957e-02f, 1.23167314e-01f, 9.47261974e-02f, 1.44826826e-02f, 1.70354113e-01f, 3.81164178e-02f, -1.11001477e-01f, -1.36614129e-01f, 3.56672183e-02f,
  -1.56912692e-02f, -2.42032394e-01f, -6.55868053e-02f, -4.84060608e-02f, 9.10129026e-02f, 8.22687596e-02f, -3.88330929e-02f, -1.45730123e-01f, -1.75759774e-02f, 3.48555557e-02f,
  6.52035847e-02f, 5.88025525e-03f, -1.51526973e-01f, 8.91472474e-02f, -4.86304760e-02f, -1.13878414e-01f, 1.47293106e-01f, 7.09257871e-02f, 1.40293077e-01f, 4.03961726e-02f,
  -1.77613683e-02f, -3.32036875e-02f, 8.46734196e-02f, -3.87939848e-02f, -1.01179749e-01f, 4.13780957e-02f, -7.38617629e-02f, -8.13716277e-03f, -2.48289369e-02f, -8.90923813e-02f,
  -2.61185020e-02f, -1.45396903e-01f, 7.09447116e-02f, -1.41569629e-01f, 1.96115881e-01f, 1.13696426e-01f, 2.55389273e-01f, -9.50796083e-02f, 1.42937945e-02f, -2.50112265e-01f,
  -5.22495881e-02f, 1.89916253e-01f, 2.53292680e-01f, -2.34122410e-01f, 1.71964318e-01f, 3.18720229e-02f, -1.46746382e-01f, 9.63083282e-02f, -2.37555094e-02f, -2.54788972e-03f,
  -1.75810337e-01f, -2.15717882e-01f, -1.07612468e-01f, -2.39254817e-01f, -2.19796579e-02f, -5.78566976e-02f, -1.16289213e-01f, 3.35177302e-01f, -1.54454336e-01f, 1.10116228e-01f,
  -4.80965339e-02f, -1.28468135e-02f, -4.01105732e-02f, -5.31577468e-02f, -3.37443650e-02f, -1.85134392e-02f, 1.14672795e-01f, 1.19596876e-01f, 1.00806020e-01f, -1.40974909e-01f,
  9.67379361e-02f, 1.43419905e-02f, -8.58150646e-02f, 6.61343932e-02f, -4.39061448e-02f, -1.45854488e-01f, 2.65160277e-02f, 5.93434311e-02f, -7.74575546e-02f, -4.79376465e-02f,
  -9.86088738e-02f, 4.59250771e-02f, 1.34080071e-02f, -1.78708006e-02f, 3.86794768e-02f, -5.48165143e-02f, -5.90369180e-02f, 1.84297971e-02f, -9.49928015e-02f, -9.08904523e-02f,
  6.04351424e-02f, 1.91131700e-02f, -8.26062914e-03f, 7.07416832e-02f, -1.13236764e-02f, -5.15735224e-02f, 5.21585234e-02f, -8.85841325e-02f, -1.17896032e-02f, 6.42045289e-02f,
  5.54628894e-02f, 2.52682660e-02f, 8.62955004e-02f, -7.42368549e-02f, 3.18353102e-02f, 1.08039677e-01f, 9.24228579e-02f, 5.46150729e-02f, 8.62080455e-02f, 1.58052463e-02f,
  -6.85689226e-02f, -1.21866219e-01f, -4.92028184e-02f, -1.41723186e-01f, -6.31239731e-03f, 2.34706514e-03f, -1.36097878e-01f, -1.36167213e-01f, -6.45865276e-02f, 8.63649771e-02f,
  8.88074338e-02f, 7.73406178e-02f, -1.65977236e-02f, -1.63305506e-01f, 1.09517172e-01f, -9.11901072e-02f, 9.68354791e-02f, -1.16578318e-01f, -2.34903675e-02f, -1.49747683e-02f,
  1.48314424e-02f, 3.33161615e-02f, 9.81618538e-02f, -7.97613263e-02f, 4.72077690e-02f, -4.76306565e-02f, -2.62379665e-02f, -5.94220404e-03f, -9.77772474e-02f, -7.34901503e-02f,
  -1.20689146e-01f, 1.81444809e-01f, 2.03632638e-02f, 3.01032385e-04f, -5.06642386e-02f, 8.28245953e-02f, -4.00118195e-02f, -9.59085152e-02f, 8.86868238e-02f, -1.12011015e-01f,
  7.98024833e-02f, 8.50309730e-02f, -3.33287984e-01f, -2.40396529e-01f, -4.53052623e-03f, 5.55889048e-02f, 1.17895997e-03f, -1.70983449e-02f, -8.09368640e-02f, 3.67447644e-01f,
  3.98170382e-01f, 8.99520051e-03f, 1.47724524e-01f, 3.81040096e-01f, -3.37229520e-02f, 2.24927425e-01f, 2.06020519e-01f, 2.24495336e-01f, -6.57400340e-02f, 6.66602224e-04f,
  -2.40368806e-02f, 3.65309775e-01f, 4.58229333e-03f, 9.92074236e-02f, 2.61424780e-01f, -2.12411970e-01f, -3.90190780e-02f, -3.07851508e-02f, 2.12599367e-01f, 1.85015783e-01f,
  1.77828655e-01f, 1.10980019e-01f, 8.66818577e-02f, 1.81193147e-02f, 2.04085801e-02f, -3.35230306e-02f, -1.03445709e-01f, -7.77529180e-02f, -1.46522999e-01f, -7.50252753e-02f,
  -1.50710538e-01f, -6.39697464e-05f, -9.68803316e-02f, 1.91443898e-02f, 7.04299659e-02f, -2.16134861e-02f, 3.30158286e-02f, -1.92563012e-02f, -1.60103709e-01f, 2.25473195e-02f,
  3.85463275e-02f, -9.83315855e-02f, -1.02199003e-01f, -7.24994019e-02f, -2.95891799e-02f, -1.08862452e-01f, -1.51617333e-01f, 1.92835629e-02f, -7.27262348e-02f, -9.38324928e-02f,
  -5.09832799e-02f, 2.87673064e-02f, -5.06025553e-02f, 8.27511698e-02f, -9.65376385e-03f, 2.93388367e-02f, -7.10725086e-03f, 1.07555926e-01f, -1.49575725e-01f, 3.36154029e-02f,
  4.96362410e-02f, -1.70364380e-02f, 5.06940335e-02f, -1.87778361e-02f, -4.73515019e-02f, -8.03392977e-02f, 1.22262668e-02f, 6.90574721e-02f, 3.15905064e-02f, -3.08122039e-02f,
  2.70897597e-02f, -7.30744377e-02f, 6.40568659e-02f, 8.18328485e-02f, 8.87686461e-02f, 5.48194759e-02f, 9.10365880e-02f, 1.02548979e-01f, 7.16979206e-02f, -3.65081355e-02f,
  -3.02286241e-02f, -1.32407427e-01f, 2.97570229e-02f, -7.01442212e-02f, 8.12740065e-03f, 1.53391436e-01f, 4.64950595e-03f, 3.55809070e-02f, -7.99290370e-03f, -1.03719868e-01f,
  -4.03874069e-02f, -1.26857758e-01f, 9.32033546e-03f, 1.14945054e-01f, -1.78410590e-01f, 4.20175632e-03f, 2.86423857e-03f, -2.98220431e-03f, -7.96309263e-02f, -2.06350423e-02f,
  -1.13043129e-01f, -6.08614199e-02f, -1.50177702e-01f, -4.77779359e-02f, -6.84575364e-02f, 3.14727910e-02f, -7.50307217e-02f, 9.94405746e-02f, -4.47783992e-02f, -3.07260826e-02f,
  4.83098160e-03f, -1.70259103e-01f, 1.46521673e-01f, 1.39900804e-01f, 6.85610026e-02f, -7.04179564e-03f, 1.83806762e-01f, -4.81509306e-02f, -3.50953430e-01f, -3.34836147e-03f,
  9.70806032e-02f, -1.23007625e-01f, 4.27063648e-03f, -4.58050340e-01f, -3.32677931e-01f, -4.07977134e-01f, -1.28281444e-01f, 7.86776654e-03f, -1.88375175e-01f, 2.58572161e-01f,
  7.99398720e-02f, -2.01810285e-01f, 4.46525514e-02f, 3.46700586e-02f, 1.98877364e-01f, 3.22673440e-01f, 3.37545365e-01f, 2.96901911e-01f, 1.72199622e-01f, -8.81813988e-02f,
  3.92030813e-02f, -3.03688366e-02f, 1.01752533e-02f, -1.35377571e-01f, 1.32855162e-01f, 1.92409858e-01f, 8.75866339e-02f, 1.97276939e-03f, 1.21243205e-02f, -1.74687132e-02f,
  7.59558827e-02f, -2.70451535e-03f, -7.77461305e-02f, -1.13694184e-01f, 8.90824571e-02f, 9.30734053e-02f, -1.20323673e-01f, 5.49657419e-02f, 9.75734182e-03f, -4.61288095e-02f,
  3.80791612e-02f, 4.24422175e-02f, 2.62832437e-02f, 1.61648188e-02f, 3.89220077e-04f, 5.19449599e-02f, -1.33452890e-02f, 1.47700354e-01f, -8.91918018e-02f, -6.74296729e-03f,
  -1.09134847e-02f, 2.41852850e-02f, 5.09988554e-02f, -9.51062515e-02f, -8.65152180e-02f, -1.12050110e-02f, -1.61733165e-01f, -2.62345746e-02f, 5.37323207e-02f, -1.49542717e-02f,
  5.28422482e-02f, 7.66472099e-03f, -1.89951256e-01f, 7.61268809e-02f, 1.53928995e-01f, -1.27361387e-01f, 1.45189613e-01f, 1.52928745e-02f, 2.51555800e-01f, 1.02783954e-02f,
  -1.63618222e-01f, -1.63212568e-02f, 1.00710712e-01f, -1.52625330e-02f, -1.08794674e-01f, 5.19530103e-02f, -2.21942663e-02f, -7.57732615e-02f, 4.97581996e-02f, 1.16720848e-01f,
  1.89258307e-01f, 7.62291346e-03f, -5.55995367e-02f, -3.64028523e-03f, 3.95068824e-02f, -4.32306528e-02f, -2.66720265e-01f, -5.21341525e-02f, 2.87860259e-02f, -2.17490450e-01f,
  1.28394499e-01f, 1.28909856e-01f, 8.44208300e-02f, 4.49333116e-02f, 4.97490168e-03f, 9.87791941e-02f, 4.30777557e-02f, 9.22288448e-02f, 1.60619020e-02f, 9.49157402e-02f,
  8.81709680e-02f, 8.54322389e-02f, -3.49042378e-02f, -1.22891832e-02f, 1.15509719e-01f, 1.28583238e-01f, 1.41889930e-01f, 2.84414571e-02f, 4.95442748e-02f, -6.04067333e-02f,
  -3.90431941e-01f, 2.94946015e-01f, 3.69096249e-01f, -6.70242906e-02f, 7.62821361e-02f, 2.23216593e-01f, 1.34851187e-01f, 8.87430012e-02f, 3.99098471e-02f, -3.99849713e-01f,
  -2.29069322e-01f, -1.54662207e-01f, 2.13055924e-01f, -1.78792402e-01f, 3.87426108e-01f, 3.03744555e-01f, 1.71835646e-01f, 2.54264344e-02f, 3.65232468e-01f, 2.80005187e-01f,
  3.97750914e-01f, -6.34955391e-02f, 2.95408338e-01f, 6.61551729e-02f, 1.06164046e-01f, 5.42685129e-02f, -1.57547399e-01f, 3.62264484e-01f, -1.73059031e-01f, 1.43769950e-01f,
  -8.82212222e-02f, -1.08759515e-01f, -7.83730745e-02f, 2.05028709e-02f, -2.49612480e-02f, -1.03010930e-01f, 1.92351475e-01f, 5.62178791e-02f, 5.44724502e-02f, 2.14570388e-02f,
  -1.76825255e-01f, 1.76777169e-02f, -9.89329442e-02f, 4.69406620e-02f, 5.82633652e-02f, -5.03414758e-02f, 1.13879979e-01f, 1.02954261e-01f, -7.33114555e-02f, -3.05307074e-03f,
  2.70155311e-01f, 5.95397092e-02f, 6.76295087e-02f, 1.17909193e-01f, 2.92259067e-01f, -4.42918241e-02f, 7.19344709e-03f, 5.83776943e-02f, 1.18256830e-01f, -6.72858581e-02f,
  -6.52422197e-03f, 9.12023932e-02f, -1.32406875e-01f, -1.27254859e-01f, 1.36197694e-02f, 2.50039119e-02f, -6.80593550e-02f, -1.57466710e-01f, 1.28528193e-01f, -7.43388906e-02f,
  -1.45833135e-01f, 1.26516521e-02f, 1.10506266e-01f, 1.92272442e-03f, -1.28324628e-01f, -2.28660747e-01f, 8.70014206e-02f, -5.72077818e-02f, 2.13247035e-02f, -1.63619861e-01f,
  1.22595159e-02f, 6.28016293e-02f, -7.13525191e-02f, -5.12115285e-02f, -4.80586663e-02f, 7.60868117e-02f, 4.54536825e-03f, 7.45088048e-03f, -2.41054688e-02f, 2.48769671e-01f,
  8.53656009e-02f, 3.31584334e-01f, -5.98817207e-02f, -8.13534036e-02f, -9.26881358e-02f, -1.11940941e-02f, 1.09738104e-01f, -1.98341478e-02f, 1.76073566e-01f, 1.22502245e-01f,
  -5.34503721e-02f, -5.28401174e-02f, -1.12956114e-01f, 9.66774486e-03f, 1.11365251e-01f, 5.07616438e-02f, 4.94488217e-02f, 6.56529665e-02f, -3.29172648e-02f, 8.90678093e-02f,
  1.06748648e-01f, -2.65943538e-02f, 1.99771691e-02f, -4.44461815e-02f, -1.76265329e-01f, -1.46572158e-01f, -2.44393256e-02f, -1.84562616e-02f, 2.08345458e-01f, 5.64980246e-02f,
  7.47180656e-02f, -8.04710761e-02f, 2.03887448e-01f, 2.15170398e-01f, 1.45341754e-02f, -7.15269148e-02f, -4.74270619e-02f, -1.29353166e-01f, 2.67383270e-02f, -1.01162389e-01f,
  -2.39910796e-01f, 5.65151758e-02f, -3.01081240e-01f, 2.55202740e-01f, 2.73094863e-01f, -2.86375850e-01f, 1.33432224e-01f, 1.36845082e-01f, 5.55274859e-02f, 7.94807225e-02f,
  8.87181088e-02f, 2.47373626e-01f, 3.97419743e-02f, 2.38717854e-01f, 1.59104332e-01f, 2.48341247e-01f, 3.58488292e-01f, 1.68770880e-01f, 3.15110952e-01f, 1.80624679e-01f,
  -1.49239078e-01f, -5.36606014e-02f, -9.86858457e-02f, -5.39668538e-02f, 2.01357007e-02f, -3.70821096e-02f, -1.12858415e-01f, -4.85361703e-02f, 7.31933713e-02f, -7.65446424e-02f,
  -1.50485754e-01f, 6.45855814e-02f, 8.86489972e-02f, 1.53966676e-02f, -2.59290487e-02f, 2.21734699e-02f, 4.40418422e-02f, -1.38718292e-01f, -1.17805801e-01f, -9.50994939e-02f,
  -2.23627314e-02f, 1.70496162e-02f, 3.92713882e-02f, -3.28505374e-02f, -3.97661366e-02f, 4.78891209e-02f, 2.36305639e-01f, 1.21915096e-03f, 7.58631006e-02f, 1.80325031e-01f,
  -6.31597266e-02f, 1.03796341e-01f, -3.64492945e-02f, 8.87881592e-02f, 1.64630953e-02f, 3.53840627e-02f, 5.45871891e-02f, 6.27072975e-02f, -1.17627233e-01f, 9.61673781e-02f,
  2.02505272e-02f, 2.92824879e-02f, 4.27745245e-02f, 1.50120169e-01f, 3.10094263e-02f, -1.38536811e-01f, -2.51803212e-02f, 1.17974192e-01f, -9.07483101e-02f, 1.81210544e-02f,
  -3.40529643e-02f, 5.89293540e-02f, 7.74001181e-02f, 5.26772924e-02f, -3.57975475e-02f, 3.05784661e-02f, -7.55338222e-02f, -2.44659409e-02f, -1.90156084e-02f, -1.22588640e-03f,
  2.57592034e-02f, 2.32383698e-01f, -2.46323533e-02f, -1.93585783e-01f, 3.96383479e-02f, 4.83882759e-04f, -6.01918362e-02f, -5.60452929e-03f, 1.78472608e-01f, -7.17456490e-02f,
  -1.23164922e-01f, -7.30785802e-02f, -5.44384047e-02f, 3.39888618e-03f, -4.39013094e-02f, -4.22748365e-02f, 6.12765551e-02f, -2.82846931e-02f, 1.57590896e-01f, 1.04285441e-01f,
  -1.03873126e-01f, -1.83098037e-02f, -3.92955393e-02f, -8.67551863e-02f, -1.16432300e-02f, 2.27630697e-02f, -9.41943377e-03f, 1.23039722e-01f, 2.79993378e-02f, 7.20880553e-02f,
  -9.19664726e-02f, -2.71653771e-01f, 2.00592265e-01f, 1.79559439e-01f, -5.33495471e-02f, -2.74558485e-01f, -1.12653449e-01f, -2.40389779e-01f, -1.77205294e-01f, -4.00978118e-01f,
  -1.67138755e-01f, 2.20928654e-01f, -3.00843656e-01f, 5.71394674e-02f, 3.36076736e-01f, -1.64165527e-01f, 3.49137150e-02f, -4.15199548e-02f, -4.05656882e-02f, -3.26579553e-04f,
  4.56399322e-02f, 1.87331196e-02f, 2.81978011e-01f, -3.33685018e-02f, 7.10515082e-02f, 2.54494101e-01f, 3.89282376e-01f, 9.42996889e-02f, 4.28024471e-01f, 2.42383420e-01f,
  -1.35489270e-01f, -2.95633692e-02f, 1.92296766e-02f, -5.96938320e-02f, -6.11575320e-02f, -4.17066216e-02f, 1.15456574e-01f, 1.65040135e-01f, 1.60398275e-01f, -4.28915955e-02f,
  -5.03236502e-02f, 4.64817137e-02f, -7.52608329e-02f, -8.08444619e-03f, 2.09551994e-02f, 9.86008272e-02f, -4.30173799e-02f, -8.47098604e-02f, 5.40151037e-02f, -2.99427542e-03f,
  -2.22437717e-02f, -6.31844103e-02f, -7.20023438e-02f, 1.17616840e-01f, 1.44922808e-01f, -9.19329748e-02f, 1.06760517e-01f, 8.48266780e-02f, 1.21842343e-02f, 2.31928378e-02f,
  4.06189449e-02f, 4.38973568e-02f, -1.60195641e-02f, -1.04401805e-01f, -9.21440683e-03f, 6.78202808e-02f, 3.62628549e-02f, -4.81602326e-02f, 1.57422811e-01f, -1.13430724e-01f,
  -6.08648695e-02f, -4.49216366e-02f, -6.51122928e-02f, -6.39379248e-02f, -4.07137461e-02f, -1.45511076e-01f, 6.67114779e-02f, 1.05929486e-02f, -2.50460487e-02f, -7.42845014e-02f,
  5.80664575e-02f, 6.27344614e-03f, 2.19473126e-03f, 5.51475957e-02f, -2.57085174e-01f, 9.94225964e-02f, 6.27148747e-02f, 3.27447914e-02f, -3.31773572e-02f, 4.97042909e-02f,
  5.68160750e-02f, 1.26271218e-01f, -1.86903414e-03f, 2.03430243e-02f, -7.97358751e-02f, -8.38781595e-02f, 3.12051177e-02f, 1.80679467e-02f, 9.12859440e-02f, -6.81448728e-02f,
  4.05353308e-02f, 2.76473854e-02f, 6.52339682e-02f, 1.04296409e-01f, 8.83865058e-02f, -7.15591805e-03f, 6.20073825e-02f, 4.56731580e-02f, -2.35938299e-02f, 1.38406172e-01f,
  9.44343582e-02f, -1.31717056e-01f, 4.08536894e-03f, -3.88159715e-02f, 1.20474631e-02f, 2.82589942e-02f, -2.98047680e-02f, -1.27321333e-01f, 4.19356301e-02f, 5.40211350e-02f,
  -2.22043827e-01f, 1.66188851e-01f, 1.98360994e-01f, 1.58986107e-01f, -1.41556412e-01f, -2.03965783e-01f, -3.47767860e-01f, 8.47783163e-02f, -1.66654348e-01f, -2.58051306e-01f,
  -2.76637942e-01f, 6.93444237e-02f, -3.66395384e-01f, 2.16030180e-01f, 1.67084187e-01f, -2.06279323e-01f, 2.10643396e-01f, -6.24877121e-03f, 4.44518775e-02f, 2.20887482e-01f,
  1.86100021e-01f, -1.48929298e-01f, 3.56589377e-01f, 2.48753235e-01f, 7.41974413e-02f, 2.80435920e-01f, 1.19676687e-01f, 9.58923995e-02f, 2.99135059e-01f, 1.10917374e-01f,
  8.96394104e-02f, -3.05889845e-02f, 1.24294661e-01f, 1.78903025e-02f, 2.90188864e-02f, -1.93622977e-01f, 1.14630103e-01f, -2.13782415e-02f, -6.29927367e-02f, -2.97191814e-02f,
  -5.96899763e-02f, 5.57392240e-02f, 1.07943624e-01f, 4.81221452e-03f, -1.90989107e-01f, 5.81384897e-02f, -4.34640562e-03f, 6.15376234e-02f, 6.41272515e-02f, -5.69189973e-02f,
  4.11508642e-02f, -2.03252621e-02f, -1.45624205e-01f, 4.06935997e-02f, 5.55269830e-02f, -2.07460634e-02f, -1.46597838e-02f, 4.17966358e-02f, 6.21841522e-03f, -2.50238031e-02f,
  9.00407322e-03f, -1.92669496e-01f, -1.53403670e-01f, 3.14294510e-02f, 6.21670205e-03f, -8.21459442e-02f, -1.38898775e-01f, -4.16111201e-02f, -2.45881290e-03f, 4.76827957e-02f,
  8.66559297e-02f, 3.89525332e-02f, -1.56641781e-01f, -7.59065559e-04f, -1.75651640e-01f, -5.74011076e-03f, 1.13440126e-01f, -1.53174242e-02f, 1.32970661e-01f, 1.05042234e-01f,
  -5.92458881e-02f, -3.26758176e-02f, -2.43325345e-03f, 4.91118021e-02f, -7.27288499e-02f, -1.51885092e-01f, -1.18515473e-02f, -4.09103334e-02f, 1.76512711e-02f, 1.30262375e-01f,
  9.81416404e-02f, 5.01070246e-02f, 1.64005607e-01f, 5.04512228e-02f, 1.03992783e-01f, -4.23237868e-03f, 5.86830564e-02f, 1.20910980e-01f, 1.04430482e-01f, -8.38452578e-02f,
  -1.98652223e-02f, 1.64376292e-02f, 1.10659460e-02f, -5.08064479e-02f, 1.74700797e-01f, -4.63705137e-02f, 5.91875464e-02f, -6.34798035e-02f, 1.55531585e-01f, 1.06274278e-03f,
  -1.32537102e-02f, -1.50488794e-01f, -3.31027173e-02f, 4.93329689e-02f, -6.42467439e-02f, -1.01203732e-01f, -7.08444091e-03f, 5.23799146e-03f, 7.36681074e-02f, 3.00306175e-02f,
  4.16884899e-01f, -8.85952637e-02f, -1.32080585e-01f, 1.60158128e-01f, 6.03838824e-02f, 3.69388998e-01f, 2.22172990e-01f, -2.00620458e-01f, -3.42285872e-01f, 1.20904833e-01f,
  1.48121357e-01f, 2.39707217e-01f, -2.05902010e-01f, 4.11912322e-01f, -6.72828108e-02f, -2.48071596e-01f, 2.26975352e-01f, 2.86791503e-01f, -2.68908769e-01f, -1.41638547e-01f,
  -1.22151554e-01f, 1.28596708e-01f, -1.45648628e-01f, -1.01019077e-01f, 3.14015508e-01f, 1.66088656e-01f, 5.16299419e-02f, -9.89101920e-03f, 2.63239294e-01f, 2.62373269e-01f,
  2.70639718e-01f, -1.13700911e-01f, -8.69930238e-02f, 1.47399381e-01f, -6.21764436e-02f, 2.04453871e-01f, 1.78320199e-01f, 7.02143386e-02f, 8.38720426e-02f, -9.94637087e-02f,
  7.61185363e-02f, 7.83675760e-02f, 9.08780321e-02f, -4.36173007e-02f, 1.20810613e-01f, 7.79255405e-02f, 8.29026774e-02f, 4.28475998e-02f, -3.40077914e-02f, 2.94141136e-02f,
  -2.64294147e-02f, 4.46252711e-02f, 1.34078175e-01f, -5.25899120e-02f, -1.67927220e-01f, -8.30158219e-02f, 9.65372920e-02f, 3.72885279e-02f, 1.61520578e-02f, -7.43773058e-02f,
  -5.38495444e-02f, -2.56105345e-02f, -1.27070874e-01f, 3.85591574e-02f, -8.52658674e-02f, 2.06187163e-02f, -4.66191284e-02f, 5.83580844e-02f, -2.96157207e-02f, -1.22228183e-01f,
  3.00432649e-02f, -3.73073816e-02f, 6.86154589e-02f, 5.25042042e-03f, -4.48787324e-02f, 5.32019585e-02f, 6.23049289e-02f, -1.19204982e-03f, -1.28607213e-01f, -7.92578701e-03f,
  4.46425080e-02f, 1.45781152e-02f, 5.09786420e-02f, 7.72347823e-02f, 4.00430337e-02f, -1.23266429e-01f, 5.73777296e-02f, 3.02806334e-03f, -1.97722707e-02f, 6.79454505e-02f,
  -7.93075487e-02f, -3.38567674e-01f, -6.41507208e-02f, 4.26060036e-02f, -3.15232538e-02f, -4.90762517e-02f, -1.03622340e-02f, -2.42086686e-02f, -2.42388193e-02f, -1.43279955e-01f,
  2.26816237e-02f, 6.23617545e-02f, 1.80061758e-02f, -2.48222169e-03f, -8.52550380e-03f, -7.25483894e-02f, 2.47382503e-02f, 7.25359991e-02f, -1.73213780e-02f, 1.53901815e-01f,
  -2.15166877e-03f, -5.49113611e-03f, 5.50456233e-02f, -5.26955053e-02f, 7.37898201e-02f, -1.23858571e-01f, 4.26093070e-03f, -4.65400778e-02f, 1.58392206e-01f, 2.93924753e-02f,
  1.88037325e-02f, 3.09279084e-01f, 1.71103999e-01f, 9.26655307e-02f, -2.84628123e-01f, -1.43346846e-01f, -2.43409321e-01f, 9.09903422e-02f, 2.46055618e-01f, 1.16735645e-01f,
  -3.32019269e-01f, 4.81127709e-01f, -1.46713346e-01f, -3.75757851e-02f, 5.51105402e-02f, 1.45533770e-01f, 6.88443482e-02f, -1.49167627e-02f, -3.34370844e-02f, 9.61082503e-02f,
  1.88175470e-01f, -3.83937061e-01f, -8.73440728e-02f, -9.85753462e-02f, -1.83740512e-01f, 1.40715986e-01f, -3.13454241e-01f, -1.04214117e-01f, 3.72918211e-02f, -1.09394334e-01f,
  -1.92497242e-02f, 9.04430151e-02f, 6.87656254e-02f, 2.06015959e-01f, 1.15212373e-01f, -4.74282950e-02f, -1.88758429e-02f, 4.53470871e-02f, -1.06201135e-01f, 7.04607069e-02f,
  1.74051583e-01f, 1.17770374e-01f, 1.83334854e-02f, -9.78706107e-02f, 3.97669598e-02f, 1.27354339e-01f, 8.82694721e-02f, -7.33299330e-02f, 1.47431135e-01f, -7.67635852e-02f,
  9.19247568e-02f, 1.04818374e-01f, 1.22242548e-01f, 1.08106308e-01f, 3.33017185e-02f, -1.04135089e-01f, 7.96843171e-02f, 5.42846741e-03f, 1.22619860e-01f, 5.39084077e-02f,
  -5.66557758e-02f, -1.17318027e-01f, 4.86299861e-03f, -1.30651861e-01f, -5.91525622e-02f, 1.97622068e-02f, 1.16963997e-01f, -6.24060072e-02f, -2.21811645e-02f, 2.70142462e-02f,
  7.01223239e-02f, -5.42640798e-02f, -2.99178977e-02f, 4.02794741e-02f, -1.45913363e-01f, 8.09860155e-02f, -1.32233992e-01f, 1.00599043e-01f, 1.10850915e-01f, 2.81312428e-02f,
  1.23676276e-02f, -1.37509517e-02f, 1.99670773e-02f, -2.54659820e-02f, -1.40358508e-02f, -3.29834521e-02f, -9.05885100e-02f, 6.84710592e-02f, 1.77966934e-02f, -1.34263426e-01f,
  6.83778152e-02f, 2.00710535e-01f, 7.02476054e-02f, 1.89664111e-01f, 1.02788880e-01f, -7.25087002e-02f, 5.68220243e-02f, 2.52497137e-01f, -3.43501568e-02f, 3.44795622e-02f,
  4.76666912e-02f, 8.79154578e-02f, -4.53902967e-02f, -8.48516226e-02f, 9.80183557e-02f, 6.08955063e-02f, -7.37427324e-02f, 1.03537776e-02f, 8.61062668e-03f, -1.19630702e-01f,
  8.41231365e-03f, -6.55459091e-02f, 3.99652310e-02f, 8.67723525e-02f, -5.04443347e-02f, -8.57203174e-03f, -5.43808490e-02f, 1.29341021e-01f, -1.38614535e-01f, 2.94839293e-02f,
  -7.05017567e-01f, 3.37167650e-01f, 8.35963190e-02f, -3.10094208e-01f, 2.52584293e-02f, 1.03149384e-01f, 9.24129561e-02f, 1.15344353e-01f, 1.29014641e-01f, 2.83729732e-01f,
  2.27152020e-01f, -2.58511096e-01f, 4.18125629e-01f, 2.83548981e-01f, -4.32001859e-01f, 2.99773335e-01f, 1.50351420e-01f, -8.91312584e-02f, 1.62638023e-01f, -3.48568819e-02f,
  -1.63444072e-01f, 3.85735184e-02f, 5.40386289e-02f, 1.57649845e-01f, -2.00749055e-01f, -1.53753713e-01f, -2.51149267e-01f, 7.16896728e-02f, -1.72227338e-01f, -6.02270924e-02f,
  -4.37213540e-01f, -2.07378820e-01f, -2.72184014e-01f, -1.04162179e-01f, -7.76669234e-02f, -1.51585340e-01f, -1.52159438e-01f, 2.91962028e-02f, 1.22734969e-02f, 7.59669170e-02f,
  3.52967456e-02f, -3.32849585e-02f, 1.07105903e-01f, 6.48416504e-02f, -4.76473421e-02f, -2.22352450e-03f, 3.59112658e-02f, -1.94378139e-03f, 4.24762256e-02f, -3.65299266e-03f,
  1.33992270e-01f, 5.32832108e-02f, -3.09721492e-02f, 1.74467117e-02f, -4.87663597e-02f, 1.57801714e-02f, 3.12635191e-02f, -1.12915531e-01f, -1.87791422e-01f, -9.10721198e-02f,
  -5.85895181e-02f, -5.58423325e-02f, -5.40578403e-02f, 8.61012414e-02f, 5.61731402e-03f, 7.77828321e-02f, -7.93492829e-04f, -1.01146653e-01f, -5.81172481e-03f, 1.01366341e-01f,
  -2.71497648e-02f, -1.07440934e-01f, -1.09509312e-01f, -1.87048409e-02f, 5.13725402e-03f, -3.72028463e-02f, -5.79954609e-02f, 1.20259076e-02f, 4.57056984e-02f, -4.54303846e-02f,
  1.52466847e-02f, -3.32231671e-02f, -6.50071502e-02f, 5.13149844e-03f, -2.79899384e-03f, -2.92398576e-02f, 4.42471877e-02f, -1.91215314e-02f, -3.95500250e-02f, 2.27371845e-02f,
  -6.12581551e-01f, -4.94635195e-01f, -1.00687020e-01f, -2.28398725e-01f, -1.13943368e-01f, 2.81643160e-02f, -3.08064204e-02f, -1.54583171e-01f, -1.78853124e-01f, 8.47966410e-03f,
  4.05010544e-02f, -6.68520574e-03f, -1.29378006e-01f, -1.77331585e-02f, 7.14511722e-02f, 2.13340037e-02f, -7.59101659e-02f, 8.33741203e-03f, -1.79436475e-01f, -6.49577454e-02f,
  -3.71085927e-02f, -2.62445919e-02f, 2.62338370e-02f, 3.80278425e-03f, -1.12674676e-01f, -1.17596656e-01f, -9.90090147e-02f, -2.30824482e-02f, -1.78006187e-01f, 8.02053064e-02f,
  -4.99364704e-01f, 3.08415830e-01f, -2.70355731e-01f, -2.02399194e-01f, -7.12160319e-02f, 2.07320452e-01f, 2.03198195e-01f, 1.78120539e-01f, 1.74810469e-01f, 3.21878523e-01f,
  1.83393791e-01f, -1.44210324e-01f, 2.29113102e-01f, 1.24553911e-01f, -2.88001776e-01f, 9.63508487e-02f, 5.26846983e-02f, 1.13934420e-01f, 1.06657229e-01f, 7.24598467e-02f,
  -5.10242544e-02f, 2.22160891e-01f, -1.96426049e-01f, 3.23838025e-01f, -1.58675820e-01f, -7.59640858e-02f, -1.29521847e-01f, 1.31682485e-01f, -1.53057147e-02f, 4.28542402e-03f,
  -3.08215376e-02f, -3.45816836e-03f, -1.60609141e-01f, -8.48762169e-02f, -1.03715338e-01f, -6.42858818e-03f, -6.14376776e-02f, -6.20194376e-02f, -9.42490548e-02f, -8.60375166e-02f,
  -7.57677481e-02f, 7.81771764e-02f, 9.89920497e-02f, 6.43764660e-02f, -4.44260538e-02f, -1.02885842e-01f, 3.21202762e-02f, -1.17518686e-01f, 1.60521612e-01f, -1.28068343e-01f,
  -9.87392589e-02f, -1.16013169e-01f, 2.03735828e-02f, -2.47239880e-02f, -4.53711450e-02f, 1.32244453e-01f, 6.22272789e-02f, -6.24102093e-02f, -3.04195322e-02f, -2.26886608e-02f,
  -1.15722626e-01f, 2.03783199e-01f, 5.25109544e-02f, 1.07883893e-01f, -1.49960322e-02f, 4.43947082e-03f, -1.13430610e-02f, -3.55475140e-03f, -5.23986779e-02f, 2.86392448e-03f,
  5.15514053e-02f, 3.10537815e-02f, 1.01599894e-01f, 6.58563897e-02f, -8.24065134e-03f, 1.17472354e-02f, -3.84311415e-02f, -2.46032123e-02f, -7.53644556e-02f, -1.38470739e-01f,
  2.85784993e-02f, -5.43169752e-02f, -1.71527956e-02f, -8.40864703e-02f, -2.63270419e-02f, -8.86071101e-02f, -7.00388511e-04f, -2.92176474e-02f, -4.03606854e-02f, 2.74932161e-02f,
  2.22902864e-01f, 3.51438195e-01f, 1.35272473e-01f, 7.69181401e-02f, 5.71469683e-03f, -6.99296817e-02f, 3.96293588e-02f, -9.41150039e-02f, -3.37710194e-02f, -1.21750273e-02f,
  3.57297212e-02f, 3.05806175e-02f, -8.08808878e-02f, -6.54340610e-02f, -1.35673627e-01f, 1.89839618e-03f, 9.95105281e-02f, 8.46346617e-02f, 3.19832563e-02f, -7.43717849e-02f,
  7.30194151e-02f, 6.41623214e-02f, -1.79425254e-02f, 4.10711654e-02f, 5.95589615e-02f, 6.36464655e-02f, 2.28845351e-03f, -1.00502022e-01f, -2.45304387e-02f, -1.57769900e-02f,
  -3.29752058e-01f, 3.44057590e-01f, -1.35938346e-01f, 4.45615023e-01f, -3.05698931e-01f, 1.34692006e-02f, 2.19557554e-01f, -2.07187366e-02f, 2.74410307e-01f, 3.06289345e-01f,
  1.68671429e-01f, 5.23488484e-02f, 2.02401578e-01f, 2.96807826e-01f, 1.12435795e-01f, 4.16809529e-01f, 4.90651399e-01f, 2.16152087e-01f, 8.54980871e-02f, 1.58170730e-01f,
  1.93686470e-01f, 1.40697896e-01f, 8.87901857e-02f, -1.34433821e-01f, -9.82576162e-02f, -9.81832892e-02f, 2.21483856e-02f, -2.53711879e-01f, 1.35184258e-01f, -1.75018653e-01f,
  -4.51395400e-02f, 9.83305871e-02f, -2.11544931e-02f, -1.59711540e-02f, 4.14837673e-02f, -1.75882250e-01f, -8.14462975e-02f, -8.79233629e-02f, -1.07890777e-01f, 7.88116083e-02f,
  -6.35638880e-03f, -5.75527810e-02f, 4.19625901e-02f, -1.31470682e-02f, -1.71904430e-01f, -6.92534223e-02f, -5.55436686e-02f, -7.79202953e-02f, -4.07745577e-02f, -1.12287663e-01f,
  -3.37064415e-02f, 6.66623190e-02f, -1.77916028e-02f, 5.57754897e-02f, -3.80112492e-02f, 2.75865402e-02f, 1.08580053e-01f, -1.14106797e-01f, 8.30447972e-02f, -2.72768550e-02f,
  -3.28182913e-02f, 5.00740521e-02f, -2.79209800e-02f, -2.21915413e-02f, -2.99449041e-02f, -8.16330966e-03f, 5.39509505e-02f, 2.79346555e-02f, 1.15286205e-02f, 4.42465693e-02f,
  -4.91259061e-02f, 1.60163287e-02f, 2.70410478e-02f, 5.97540475e-02f, 1.04084462e-01f, -4.43884693e-02f, -7.26227537e-02f, -6.30599633e-02f, 3.02717946e-02f, 1.17305061e-02f,
  -2.50125080e-02f, 8.49613398e-02f, 7.21837953e-02f, -4.85069565e-02f, 7.97730684e-02f, 1.06327487e-02f, 9.78413820e-02f, -8.86080936e-02f, -3.15527059e-02f, -6.42674044e-02f,
  2.59146452e-01f, 3.68879914e-01f, 1.05999254e-01f, -1.14714175e-01f, 1.29951209e-01f, -5.03428392e-02f, -5.66021055e-02f, 3.23758163e-02f, 9.89765748e-02f, 3.05093210e-02f,
  3.99928279e-02f, 1.02027886e-01f, -3.98194641e-02f, -9.48390886e-02f, 9.02952775e-02f, 2.12641135e-01f, 1.43532529e-01f, 7.06673320e-03f, 8.65313709e-02f, 2.54447293e-02f,
  1.43801235e-02f, 6.94069415e-02f, -2.00154446e-02f, -9.28604901e-02f, 9.50601790e-03f, 8.72817859e-02f, -8.72277014e-05f, 4.01825644e-03f, -1.46999545e-02f, 1.58280268e-01f,
  3.33203226e-02f, -3.54393482e-01f, -1.74057290e-01f, -3.95584971e-01f, 1.49883896e-01f, -1.79510057e-01f, -2.18590647e-02f, -1.72733501e-01f, -3.11213881e-01f, -2.68593013e-01f,
  -7.14529231e-02f, 2.29241222e-01f, 1.58425361e-01f, -2.52513558e-01f, 5.45606375e-01f, 1.86957031e-01f, -3.77910823e-01f, 3.07039935e-02f, -9.83054098e-03f, -2.85392642e-01f,
  -4.42080759e-02f, -2.22081482e-01f, 1.16858967e-01f, -1.55856863e-01f, -9.24591795e-02f, -2.06603393e-01f, 1.80358529e-01f, 3.08511853e-01f, -1.42420143e-01f, 3.74791086e-01f,
  -3.62802178e-01f, -3.35046649e-01f, -2.59724706e-01f, -8.76496583e-02f, -1.79532841e-01f, -5.13936169e-02f, 8.22464600e-02f, 1.19925700e-01f, -8.42517763e-02f, 1.40901087e-02f,
  1.33872971e-01f, -1.82675812e-02f, -6.22933544e-02f, 1.82267696e-01f, -1.29481807e-01f, -2.07814962e-01f, 4.75475788e-02f, -7.89049640e-02f, -7.15693384e-02f, 2.89780404e-02f,
  -4.15040068e-02f, -1.03533179e-01f, -6.44675493e-02f, 1.06774025e-01f, 1.83043435e-01f, 2.63674185e-02f, -7.11898133e-02f, 1.67469889e-01f, -4.29195613e-02f, -1.93993643e-01f,
  8.84072706e-02f, 9.10538509e-02f, 7.68587142e-02f, 9.17882659e-03f, -8.71787816e-02f, 4.65700477e-02f, 1.45197464e-02f, 1.45819053e-01f, 1.00239292e-01f, -5.03372625e-02f,
  -6.97400942e-02f, -2.89685093e-02f, -1.45325452e-01f, -9.62015688e-02f, 8.41372460e-02f, -5.40137924e-02f, -5.86095862e-02f, -7.42323175e-02f, -5.44669330e-02f, 9.11399201e-02f,
  -3.26661430e-02f, -8.77259746e-02f, -1.18296244e-03f, -3.19575071e-02f, 3.83340605e-02f, 4.73073274e-02f, -4.41477001e-02f, -4.35910933e-03f, 2.10312363e-02f, 9.35453102e-02f,
  -3.42158616e-01f, -5.39635181e-01f, 4.48082127e-02f, -3.46847549e-02f, 5.86834960e-02f, 6.54156879e-02f, -3.91796045e-02f, -5.62412031e-02f, -1.32493628e-02f, -1.68745592e-01f,
  -1.80578336e-01f, -2.19893120e-02f, -1.36294842e-01f, 6.56028464e-02f, 1.00235306e-01f, -9.03813466e-02f, -9.10144672e-03f, -8.23452920e-02f, -5.23875132e-02f, 1.75172184e-02f,
  -3.98574769e-02f, -1.00621209e-01f, 1.45020872e-01f, -7.71783143e-02f, 6.96846321e-02f, 3.28173414e-02f, -5.66800646e-02f, 7.98691064e-02f, 6.56271055e-02f, -1.07466191e-01f,
  1.88187093e-01f, -6.75743967e-02f, 3.20224404e-01f, -6.76396713e-02f, 2.03209758e-01f, 4.05813932e-01f, 2.82908112e-01f, 6.73999563e-02f, 2.52128392e-01f, -2.56107390e-01f,
  -2.21539423e-01f, 8.13476071e-02f, 1.15670972e-01f, -1.26030549e-01f, 3.91369045e-01f, 2.55589515e-01f, 1.06846534e-01f, 1.58439025e-01f, 1.88307017e-01f, 6.69562966e-02f,
  3.06770150e-02f, -1.57041773e-01f, -6.58201724e-02f, -1.14056475e-01f, -4.18167859e-02f, -1.72961041e-01f, -3.45001489e-01f, 9.90650281e-02f, -3.58066887e-01f, 9.93069559e-02f,
  -3.98371816e-02f, -5.43822460e-02f, 7.23017827e-02f, 7.29385251e-03f, -1.18757643e-01f, 5.38875125e-02f, 4.72557507e-02f, 1.52033597e-01f, 1.48518786e-01f, -5.70859574e-02f,
  1.52303353e-02f, 3.62570919e-02f, -3.00370548e-02f, -3.37552950e-02f, 7.29229078e-02f, -1.04911678e-01f, 7.47574046e-02f, -4.29003723e-02f, -1.49964755e-02f, 1.03907203e-02f,
  1.64268449e-01f, 2.41384655e-02f, 5.81852235e-02f, -1.35315627e-01f, 1.16566606e-01f, 3.84497046e-02f, 3.20210797e-03f, -7.51962513e-03f, 3.73314172e-02f, 7.37504214e-02f,
  1.43423721e-01f, 5.11545502e-02f, -3.92976329e-02f, 1.09794959e-02f, 5.47864363e-02f, -1.72869921e-01f, -1.03115387e-01f, -1.50090113e-01f, 4.01071534e-02f, -6.30114675e-02f,
  -4.02399674e-02f, -2.08999943e-02f, 7.45617449e-02f, 2.32308893e-03f, -3.28807607e-02f, -9.81894284e-02f, 5.53283654e-02f, -1.03257038e-01f, -2.58394070e-02f, -6.12178445e-03f,
  -9.86541584e-02f, 8.73883814e-02f, 5.43627255e-02f, -8.63630995e-02f, 7.50098154e-02f, 8.73068497e-02f, -1.04786493e-01f, 3.75710125e-03f, -1.98218338e-02f, -9.89572890e-03f,
  1.42578492e-02f, -9.08468813e-02f, 4.33336534e-02f, -3.66679244e-02f, 3.43609005e-02f, -3.86792570e-02f, 4.12900075e-02f, -6.83408603e-02f, -2.91483309e-02f, -7.03747151e-03f,
  -1.34987503e-01f, -6.66491240e-02f, 7.84931034e-02f, -6.54053828e-03f, 6.72597513e-02f, -5.57081923e-02f, -5.46130352e-03f, 4.20296676e-02f, 7.99368769e-02f, 2.93429513e-02f,
  8.49115476e-03f, 5.11774607e-02f, 1.54370368e-02f, -8.47975761e-02f, -1.16522081e-01f, -9.41388831e-02f, -9.42720845e-02f, 1.23258591e-01f, -2.43942402e-02f, -4.16006148e-03f,
  8.42487440e-02f, -9.88939330e-02f, 4.55899030e-01f, 6.23679571e-02f, 2.58861005e-01f, 3.93169671e-01f, 2.21147805e-01f, 3.44374388e-01f, 4.89942074e-01f, -1.52894959e-01f,
  -2.38490149e-01f, -1.86772034e-01f, 5.36845624e-02f, -2.23172396e-01f, 2.57205755e-01f, 1.65454268e-01f, 1.42226499e-02f, -1.13841571e-01f, 5.67859299e-02f, -3.00464742e-02f,
  2.77874582e-02f, -3.13406944e-01f, -2.90120649e-03f, -3.11668724e-01f, -5.62807471e-02f, -8.02919120e-02f, -3.44181687e-01f, 1.02559820e-01f, -2.11778969e-01f, 1.45187872e-02f,
  4.16050293e-02f, -1.51066929e-01f, -1.19944245e-01f, -3.05081122e-02f, 6.01136349e-02f, -2.36467505e-03f, 2.86636204e-02f, -2.77710892e-03f, 1.23052970e-01f, 5.25292233e-02f,
  -4.40791063e-02f, -1.96426306e-02f, -1.28202721e-01f, 9.70017239e-02f, 7.87059590e-02f, 2.38032285e-02f, 9.98687521e-02f, 2.85462551e-02f, 5.22635989e-02f, 2.28333339e-01f,
  1.87966779e-01f, 9.93559286e-02f, 2.95486231e-03f, 4.96442616e-02f, -2.12688539e-02f, 4.03251611e-02f, 3.60092102e-03f, 1.01931086e-02f, 1.05725721e-01f, 6.26120046e-02f,
  -1.64227411e-01f, -2.24778458e-04f, -4.56046723e-02f, 2.32737958e-02f, -8.56465250e-02f, 4.11028676e-02f, 5.11060643e-04f, -6.22504056e-02f, 9.45961103e-02f, -9.08925608e-02f,
  -4.67525721e-02f, 4.03610915e-02f, 8.22331533e-02f, 2.09905595e-01f, -6.46902248e-02f, 1.35685187e-02f, 3.32462080e-02f, -2.69904383e-03f, 1.92738902e-02f, -3.58862355e-02f,
  -6.85411245e-02f, -3.57673578e-02f, -4.23228554e-02f, 7.21223652e-02f, 1.48895130e-01f, 3.56475264e-02f, 2.54464112e-02f, 3.87080275e-02f, -5.89459427e-02f, -1.40852734e-01f,
  4.63915244e-02f, -2.06815481e-01f, -2.31061503e-01f, -5.37203103e-02f, -7.52641559e-02f, -5.06024733e-02f, 1.46542881e-02f, 1.75541379e-02f, -1.36279231e-02f, -7.66471624e-02f,
  5.71769837e-04f, -1.00230820e-01f, -3.17462645e-02f, 9.62298885e-02f, -4.67588194e-02f, 8.88024494e-02f, 5.34993671e-02f, -1.44160748e-01f, -2.19397265e-02f, -6.50625154e-02f,
  -9.69311371e-02f, -1.07668012e-01f, -1.30715882e-02f, -1.80642754e-02f, -8.87836739e-02f, 8.35492928e-03f, -1.18236719e-02f, -7.76776969e-02f, 6.96492195e-02f, 6.65193610e-03f,
  -3.80939722e-01f, -1.08893566e-01f, 3.18219900e-01f, 2.28209883e-01f, -1.35948136e-01f, -1.53826535e-01f, -5.65426014e-02f, -2.38175318e-01f, -2.04313859e-01f, -3.30393702e-01f,
  -4.57574539e-02f, 6.30049706e-02f, -1.00845406e-02f, 2.57590353e-01f, 4.13769841e-01f, 1.73062384e-01f, 8.64662528e-02f, 1.15119025e-01f, 8.38846192e-02f, -8.84400588e-03f,
  1.13087624e-01f, 1.32779613e-01f, 3.84212732e-01f, 4.24348526e-02f, 5.97307831e-02f, 1.77594930e-01f, 2.69251376e-01f, 1.62492737e-01f, 2.65861571e-01f, 2.75811315e-01f,
  1.16773777e-01f, 1.92305520e-02f, 9.51279700e-02f, 1.59462485e-02f, 4.04280722e-02f, -6.99233413e-02f, 3.67537253e-02f, 1.29755855e-01f, 1.06137015e-01f, 3.36807072e-02f,
  -1.44636482e-01f, 1.29721358e-01f, 1.80152114e-02f, 7.87312090e-02f, -1.98757231e-01f, -6.19232170e-02f, -8.88639167e-02f, -1.06532961e-01f, 1.69354733e-02f, -9.83363166e-02f,
  -4.78720553e-02f, -1.07595231e-02f, -8.10876340e-02f, 1.85139388e-01f, 8.54643434e-02f, -2.97808181e-03f, 5.05152307e-02f, -1.19937137e-01f, 4.97875512e-02f, 7.73816044e-03f,
  2.08769739e-02f, 3.57964039e-02f, -8.05932879e-02f, 2.32814439e-02f, -4.04064693e-02f, 1.20816775e-01f, 6.23758067e-04f, 5.58278672e-02f, 4.63544950e-02f, 4.32450557e-03f,
  4.60698344e-02f, -9.75959226e-02f, -4.33337055e-02f, -1.86842069e-01f, -1.01782329e-01f, -1.85773164e-01f, 2.41050813e-02f, 5.57585023e-02f, -8.90924409e-03f, -1.35200974e-02f,
  7.43693262e-02f, 1.29832298e-01f, 5.20881712e-02f, 9.01412889e-02f, -6.17079586e-02f, -1.74141034e-01f, -1.71498116e-02f, -2.53702290e-02f, 3.03484984e-02f, 7.58600980e-02f,
  2.17280313e-01f, 1.65719777e-01f, 1.12234555e-01f, 5.02483174e-02f, 9.10732299e-02f, -1.22826338e-01f, 1.64975122e-01f, -3.27152456e-03f, 1.12028241e-01f, -5.78433797e-02f,
  -9.51024592e-02f, 5.37362322e-02f, -1.36179015e-01f, -5.12820259e-02f, 6.35894910e-02f, -9.53229144e-03f, 9.23234895e-02f, 3.21661751e-03f, 1.81826986e-02f, 1.12132773e-01f,
  1.03174448e-01f, -4.39696722e-02f, 2.32173763e-02f, 3.05069261e-03f, 2.05658264e-02f, -7.48188719e-02f, -6.27199039e-02f, -5.38651571e-02f, 1.15929469e-01f, 1.36549354e-01f,
  -2.37191841e-01f, 3.14302534e-01f, 3.82430136e-01f, -3.17154378e-02f, -3.80369008e-01f, 2.98729181e-01f, 4.73997653e-01f, -3.04434806e-01f, -3.98665160e-01f, 7.91554302e-02f,
  -3.76807824e-02f, -9.90222320e-02f, 3.23677272e-01f, 1.97280854e-01f, 1.80402845e-01f, 4.22372997e-01f, 2.71569967e-01f, 2.03525811e-01f, -1.01108281e-02f, 1.29128441e-01f,
  2.11724564e-02f, 1.64540917e-01f, 3.52652341e-01f, -7.68666267e-02f, 5.71678057e-02f, -1.79950878e-01f, 2.84447148e-02f, -3.21040191e-02f, -1.58447236e-01f, -5.37861846e-02f,
  1.76850885e-01f, -9.91077647e-02f, 7.83807337e-02f, 2.36951932e-02f, 4.67415079e-02f, -3.64154279e-02f, 1.79762989e-01f, -4.15811203e-02f, -2.96345651e-01f, 1.00821860e-01f,
  -9.42496359e-02f, -5.54360785e-02f, -3.24592330e-02f, 2.20591873e-02f, -2.89259106e-01f, -1.71491146e-01f, -7.93818086e-02f, -2.99262125e-02f, -1.45418511e-03f, 8.24773535e-02f,
  8.37362483e-02f, -2.01155804e-02f, -4.37475033e-02f, 1.10283837e-01f, -9.09290314e-02f, -6.60342574e-02f, 1.83313072e-01f, 1.86820433e-01f, 7.17421696e-02f, -1.17236488e-01f,
  -1.36103392e-01f, 1.72581077e-01f, 5.68773039e-02f, 3.22929136e-02f, -1.80022307e-02f, 1.26431659e-02f, -1.73018910e-02f, -6.39132634e-02f, -1.45731136e-01f, 8.87965113e-02f,
  -1.65300779e-02f, 1.98361799e-02f, -6.47217557e-02f, 6.48531877e-03f, -1.18174255e-01f, 1.63053066e-01f, 1.42192602e-01f, -9.26198512e-02f, -4.68395129e-02f, -4.04627714e-03f,
  -8.38121772e-02f, -4.00225446e-02f, 2.29597837e-02f, -4.14120480e-02f, 9.09384266e-02f, 9.50321853e-02f, -1.38470545e-01f, 4.31023985e-02f, 7.20755979e-02f, 1.05495468e-01f,
  1.01068720e-01f, 1.53256685e-01f, -1.73716638e-02f, 4.81316634e-02f, 1.75802350e-01f, 9.10664126e-02f, 1.82488672e-02f, -7.76744410e-02f, -3.74726914e-02f, 1.01154752e-01f,
  -5.89442812e-02f, 8.84389039e-03f, -1.39392510e-01f, 2.04364955e-02f, -9.44654793e-02f, 1.41673803e-01f, 1.47162154e-02f, -1.23937158e-02f, 1.11164134e-02f, -6.55291229e-02f,
  -1.55437665e-05f, -5.80644757e-02f, -3.72033603e-02f, -7.59018660e-02f, -8.87553617e-02f, -8.12982023e-02f, -2.03933511e-02f, -1.44863769e-01f, -8.23980570e-02f, -8.73454753e-03f,
  3.87783587e-01f, 2.73802757e-01f, 2.91388214e-01f, 3.23664635e-01f, 1.26301900e-01f, -2.98283786e-01f, -5.93701042e-02f, 2.19122246e-01f, 3.60116810e-01f, -1.27994388e-01f,
  -2.70743489e-01f, 3.75715643e-01f, -2.86782235e-01f, 5.35996147e-02f, -3.59952748e-01f, -3.23992729e-01f, -4.03128192e-02f, -8.59301314e-02f, 1.99183345e-01f, 1.26585551e-02f,
  8.12254921e-02f, -3.79411012e-01f, -7.37287402e-02f, -2.35087156e-01f, 8.49202126e-02f, 3.36119175e-01f, -2.77030110e-01f, -1.47111475e-01f, -2.04251185e-02f, -5.77218048e-02f,
  4.15464304e-02f, 2.68562764e-01f, 1.85431361e-01f, -4.05848585e-02f, -5.91838807e-02f, 1.96723770e-02f, -5.49603961e-02f, -7.77057037e-02f, -5.52361794e-02f, 2.77891885e-02f,
  2.55695432e-02f, 2.19658613e-02f, -1.53293880e-02f, -1.45842684e-02f, 1.44216880e-01f, 3.66566665e-02f, 1.74678355e-01f, 1.05925843e-01f, 5.23735434e-02f, 2.39523314e-03f,
  6.30850419e-02f, 4.55960892e-02f, 7.67000914e-02f, -4.18714732e-02f, 1.38330936e-01f, 9.69164521e-02f, -1.51197729e-03f, -9.55583081e-02f, 3.91541012e-02f, 1.86156750e-01f,
  -1.65623100e-03f, -2.59608123e-02f, -6.43007010e-02f, 4.22896594e-02f, -1.79423708e-02f, -4.85744737e-02f, 8.08383003e-02f, -6.80759735e-03f, 9.26929414e-02f, -5.32457530e-02f,
  -8.59586149e-02f, 6.33554235e-02f, 7.94916749e-02f, 3.36345211e-02f, 8.91651809e-02f, 6.96097985e-02f, -4.92940694e-02f, -1.73964038e-01f, 2.36839373e-02f, -6.05277531e-02f,
  -1.15251347e-01f, 5.49895093e-02f, 2.29227543e-03f, -4.69808728e-02f, -8.10719207e-02f, 1.13609560e-01f, -2.84605823e-03f, 1.68052036e-02f, 2.86491849e-02f, -1.66361243e-01f,
  -1.80504620e-01f, -2.26710990e-01f, -4.13699299e-02f, 2.82274373e-03f, -3.65938284e-02f, -8.61258656e-02f, -7.92554244e-02f, -1.22766299e-02f, -2.36224532e-02f, -5.61577901e-02f,
  4.61911038e-02f, 3.36914584e-02f, 2.70806998e-02f, -5.58397733e-02f, -8.24572891e-02f, -1.17493227e-01f, -7.48414099e-02f, -3.91975716e-02f, -6.11549895e-03f, -4.81509194e-02f,
  1.34599311e-02f, -5.73752709e-02f, -2.26826910e-02f, 4.03761566e-02f, -8.62248614e-02f, 4.78988253e-02f, 2.91623687e-03f, 8.76702443e-02f, -4.54350039e-02f, -7.63829425e-02f,
  -6.91983044e-01f, 1.25985712e-01f, -1.25747323e-01f, -1.53379515e-01f, -4.17361498e-01f, -5.76017350e-02f, 1.12841792e-01f, -2.70918041e-01f, -4.76252101e-02f, 2.22244203e-01f,
  -6.67162165e-02f, -1.30790129e-01f, 3.61723453e-01f, -1.02819182e-01f, -1.10721245e-01f, 4.00744289e-01f, -6.41142875e-02f, 1.30212635e-01f, 2.53865477e-02f, -2.67111033e-01f,
  -1.59203857e-01f, -6.24971278e-02f, 8.93185809e-02f, -2.23546952e-01f, -4.19922471e-01f, -2.69874364e-01f, -1.14761896e-01f, -2.36045286e-01f, -2.01078683e-01f, -1.15808561e-01f,
  -3.32604766e-01f, -3.35983634e-01f, 5.59694283e-02f, -7.46911094e-02f, -1.26717314e-01f, -2.61007547e-02f, -1.04765162e-01f, 5.25963008e-02f, -1.19846456e-01f, 2.27472614e-02f,
  1.87005643e-02f, -3.18528898e-02f, -1.38378650e-01f, 1.02327272e-01f, -8.79449770e-02f, -1.27714321e-01f, -8.89700577e-02f, -1.15324751e-01f, -7.45530948e-02f, -2.55476381e-03f,
  1.30133569e-01f, 3.45655456e-02f, 1.24851717e-02f, 4.78739850e-03f, -1.00000277e-02f, -2.92076729e-02f, 5.56601537e-03f, 7.59228552e-03f, -5.82661480e-02f, -8.43441188e-02f,
  -3.99092361e-02f, 9.75839272e-02f, 1.39016330e-01f, 8.35629739e-03f, -4.37147431e-02f, 8.62390175e-02f, 2.49231029e-02f, 5.85081726e-02f, 1.15391470e-01f, 8.31685364e-02f,
  -7.19723059e-03f, 3.30465063e-02f, -7.40569457e-02f, 3.62396613e-02f, 5.55440597e-02f, 4.00744602e-02f, 6.31306469e-02f, -8.61063600e-02f, 8.10401440e-02f, -5.27773313e-02f,
  3.19521315e-02f, -7.92423338e-02f, -6.75553409e-03f, 1.40281782e-01f, 1.06276460e-01f, 2.78271623e-02f, -1.13386028e-01f, 1.29072279e-01f, -5.23402393e-02f, -1.19071770e-02f,
  -4.44830596e-01f, -3.74588937e-01f, 7.43768588e-02f, 5.19166281e-03f, 5.12438640e-02f, -2.90749352e-02f, 3.07772737e-02f, -1.02789134e-01f, -8.50177929e-02f, 2.73326971e-02f,
  5.88092282e-02f, 7.92875290e-02f, -7.54857212e-02f, 1.02699529e-02f, 8.42000693e-02f, -2.91032773e-02f, -1.07502453e-01f, -8.00872147e-02f, -9.21941921e-02f, -9.50105339e-02f,
  1.08234711e-01f, 1.74020641e-02f, 1.48629963e-01f, 7.66945183e-02f, 6.89495429e-02f, -4.65498911e-03f, -2.36234784e-01f, 1.46422580e-01f, -8.56352895e-02f, 6.08525872e-02f,
  3.48839253e-01f, -4.86357331e-01f, 1.88697323e-01f, 3.11410487e-01f, 3.17124933e-01f, 9.48111638e-02f, 1.08489618e-01f, 7.95265064e-02f, 9.05655697e-02f, -3.84939522e-01f,
  -2.13436745e-02f, -2.58842081e-01f, -3.41859907e-01f, -1.71936512e-01f, 2.78830856e-01f, -3.10179412e-01f, 2.56064348e-02f, -6.43933266e-02f, 9.93578956e-02f, 1.09324187e-01f,
  2.34201580e-01f, -6.24193717e-03f, 6.69659749e-02f, -1.48919135e-01f, 5.45718968e-02f, 1.92131475e-02f, -1.50305882e-01f, 4.38872501e-02f, 8.48939344e-02f, 3.14252302e-02f,
  5.89315929e-02f, 1.36062363e-02f, -7.57203996e-02f, -4.90371957e-02f, 1.01234756e-01f, -1.59739330e-02f, 1.46215700e-03f, -8.10253397e-02f, 2.50799596e-01f, 1.67998135e-01f,
  -3.90750207e-02f, -1.18796306e-03f, 6.12440594e-02f, -9.25425906e-04f, 1.40111372e-01f, 9.59782451e-02f, 9.46977437e-02f, 8.93457979e-02f, 1.41444886e-02f, -1.62881501e-02f,
  9.76628885e-02f, -5.41540757e-02f, 1.24524228e-01f, -2.71289852e-02f, -8.17190483e-03f, 8.29258412e-02f, 4.15428504e-02f, 4.21086652e-03f, -2.16405094e-02f, -4.23286855e-02f,
  -2.13378504e-01f, -3.26044001e-02f, 5.48412725e-02f, 4.39793766e-02f, 1.17215849e-01f, 8.02285876e-03f, 1.12484939e-01f, 4.65506129e-02f, 6.23457283e-02f, -5.85545041e-02f,
  1.21769287e-01f, -6.08851872e-02f, 9.64697674e-02f, 1.59737822e-02f, -7.49667138e-02f, -1.55384345e-02f, 1.77647583e-02f, -3.43054160e-02f, 2.04601977e-02f, 6.81441948e-02f,
  3.48220021e-02f, 8.38275477e-02f, 1.40963932e-02f, 1.18840620e-01f, -8.01186115e-02f, -4.41899411e-02f, -1.35296201e-02f, 9.39271525e-02f, 8.47039595e-02f, 5.15561178e-02f,
  -1.34084925e-01f, -4.69112515e-01f, -2.41752043e-02f, 7.23476261e-02f, -1.11063972e-01f, -4.76030782e-02f, -1.10215425e-01f, -4.40943502e-02f, -9.19179022e-02f, -6.67070076e-02f,
  5.95151335e-02f, 1.23902269e-01f, 2.49945675e-04f, 3.44625637e-02f, -2.44686697e-02f, -5.57384603e-02f, -3.90744954e-03f, -3.37467492e-02f, -2.03560609e-02f, -4.52641957e-02f,
  1.44501515e-02f, 3.88882384e-02f, -5.72809502e-02f, -3.35638132e-03f, 1.60660371e-02f, 1.73430685e-02f, -3.06960102e-03f, -4.36151996e-02f, 5.96671700e-02f, 3.37609230e-03f,
  -2.89276130e-02f, -2.96631783e-01f, -3.93125951e-01f, -7.56678283e-02f, 3.02992612e-01f, 3.81568938e-01f, 1.15133682e-02f, -8.15532953e-02f, -2.67478645e-01f, 2.06385002e-01f,
  5.59297465e-02f, -2.90303648e-01f, -4.62379545e-01f, -1.41843427e-02f, -1.92731053e-01f, -4.57665682e-01f, 2.19673738e-01f, 1.28069744e-01f, -2.67374635e-01f, 1.55265540e-01f,
  -1.96365505e-01f, 2.31619328e-01f, -2.60367244e-01f, 4.04479057e-01f, 2.27726176e-01f, 6.82202503e-02f, 3.95841658e-01f, -5.36026508e-02f, 2.84623474e-01f, 9.50152725e-02f,
  -1.83246247e-02f, -1.17100000e-01f, -3.91218588e-02f, -1.10985739e-02f, 1.39133319e-01f, 1.05279401e-01f, 1.57280415e-01f, -1.77396432e-01f, -9.31790546e-02f, -1.36214182e-01f,
  1.72552112e-02f, -3.26437354e-02f, 2.23828070e-02f, -6.79462478e-02f, 1.14803322e-01f, 3.45540233e-02f, -1.18020870e-01f, -4.41686437e-02f, -1.31648019e-01f, -6.45322800e-02f,
  -1.78289801e-01f, -7.88694248e-02f, 2.52442192e-02f, 2.55445782e-02f, -8.60895365e-02f, -2.83894017e-02f, 1.06067464e-01f, 1.13345727e-01f, 6.86093718e-02f, 8.03378895e-02f,
  1.43117951e-02f, 6.68664798e-02f, -3.46814916e-02f, -1.66672543e-01f, -6.54643700e-02f, 4.04503085e-02f, 4.36158292e-02f, -4.30324636e-02f, -1.59003120e-02f, 1.19643353e-01f,
  5.14312238e-02f, 6.94917664e-02f, 6.60362989e-02f, -1.72822420e-02f, 4.45976704e-02f, 6.00896366e-02f, -1.70780495e-02f, 9.26905721e-02f, 9.21397954e-02f, -1.53857470e-01f,
  -6.05554730e-02f, 1.31746486e-01f, 9.25773457e-02f, -1.16631389e-02f, 4.24253866e-02f, 3.98345143e-02f, 4.83722351e-02f, -4.05719727e-02f, -2.00149938e-02f, 7.84826800e-02f,
  9.84870568e-02f, 1.58094853e-01f, -3.47115425e-03f, -3.87578122e-02f, -3.46017703e-02f, 8.47753063e-02f, 4.53407243e-02f, 2.91656684e-02f, 4.96202102e-03f, 8.12614858e-02f,
  2.23449260e-01f, -4.38155793e-02f, 2.36718953e-01f, -9.63908732e-02f, -8.34501162e-03f, 1.67627156e-01f, 4.52658832e-02f, 4.14544269e-02f, 1.46210209e-01f, 1.26221210e-01f,
  6.21813051e-02f, 1.11758821e-01f, 4.54168990e-02f, 7.87615702e-02f, 8.64065439e-02f, 7.07944334e-02f, 1.03059836e-01f, -7.22303241e-02f, -4.14836518e-02f, -4.96498533e-02f,
  2.02025399e-01f, -4.88288105e-02f, 3.13929617e-01f, 1.41983926e-01f, -1.77698001e-01f, 1.42162979e-01f, 1.57568514e-01f, 1.65110976e-01f, 4.97943431e-01f, -2.66973615e-01f,
  -3.04499805e-01f, 2.23231837e-02f, 3.66939269e-02f, -3.18363994e-01f, 3.99253994e-01f, 3.81902903e-01f, 1.19246291e-02f, -5.20486943e-02f, 2.75546640e-01f, -1.48573712e-01f,
  1.73291147e-01f, -2.04603493e-01f, -7.38928244e-02f, -2.74127990e-01f, -2.35296354e-01f, -8.63789767e-02f, -1.71809211e-01f, -2.17852574e-02f, -3.07073355e-01f, 2.96673886e-02f,
  -2.27990627e-01f, -7.28229657e-02f, -2.81701893e-01f, -8.58907551e-02f, -1.82146490e-01f, -8.81146863e-02f, -1.16346721e-02f, 2.98449229e-02f, 3.80870402e-02f, -6.15718216e-02f,
  1.12474430e-02f, -3.05316411e-02f, -5.79197295e-02f, 1.53370067e-01f, 1.65319480e-02f, -7.51443803e-02f, -6.60919398e-02f, -2.55301476e-01f, -7.51779452e-02f, 7.43523389e-02f,
  -6.10510223e-02f, -8.09362754e-02f, -5.47314994e-02f, -2.76397411e-02f, -1.85622405e-02f, -4.95539792e-02f, 5.19322790e-02f, 5.51579408e-02f, -1.29909709e-01f, -5.38445637e-03f,
  7.59950802e-02f, 9.17263702e-02f, -1.11528903e-01f, -3.22942883e-02f, 2.38825064e-02f, -7.89612532e-02f, 6.59625679e-02f, -1.05951689e-01f, 9.70495045e-02f, -1.40365049e-01f,
  -1.21795677e-01f, -1.32945135e-01f, 1.10058695e-01f, -7.18660653e-02f, 5.80995437e-03f, 9.26204696e-02f, 3.27287242e-02f, 3.16414749e-03f, -1.93510037e-02f, -1.53181046e-01f,
  1.15305133e-01f, 1.43623412e-01f, -1.15610212e-01f, 2.20358707e-02f, 5.34299798e-02f, 2.78727636e-02f, 2.31989995e-02f, -9.97591205e-03f, 6.00166013e-03f, -1.12821735e-01f,
  -1.70870144e-02f, 2.69944608e-01f, -1.13638520e-01f, -2.74221331e-01f, 1.06339730e-01f, 1.72499176e-02f, 1.06357746e-01f, -6.28479645e-02f, 9.94567946e-02f, -7.67360674e-03f,
  -2.03746799e-02f, -1.48403689e-01f, -2.56531257e-02f, 2.91084461e-02f, -1.66004784e-02f, 9.99294221e-02f, -3.02292369e-02f, -4.26035039e-02f, 5.03825350e-03f, -1.30821303e-01f,
  -2.42572680e-01f, 7.11110607e-02f, 7.39853606e-02f, 8.73732753e-03f, -1.13362223e-01f, -1.30184665e-01f, 4.21420299e-02f, -8.61766487e-02f, -1.09543607e-01f, 7.01197982e-02f,
  -4.61947739e-01f, 2.51213938e-01f, 3.24237525e-01f, -9.83446240e-02f, -8.24005231e-02f, 3.63380343e-01f, 4.00594503e-01f, -2.57539283e-02f, -1.24909729e-01f, 2.29114294e-01f,
  8.64367262e-02f, 3.25506218e-02f, 3.35128695e-01f, 1.61552459e-01f, 4.41544741e-01f, 3.36162090e-01f, -1.05260848e-03f, -9.93993226e-03f, -9.71349627e-02f, -1.97280049e-01f,
  -8.36435258e-02f, -4.00329195e-02f, 2.52533525e-01f, -8.56712982e-02f, -1.68522477e-01f, -1.26247615e-01f, -8.66099820e-02f, 3.11888933e-01f, -1.49706015e-02f, 3.03190500e-01f,
  -2.44743466e-01f, -4.30869669e-01f, -2.91188210e-01f, -9.59435999e-02f, -1.45708248e-01f, -4.44586240e-02f, 1.10747048e-03f, 5.95284477e-02f, -9.31175873e-02f, -9.25222859e-02f,
  -2.43092496e-02f, 7.43503496e-02f, -5.70428409e-02f, 8.58062580e-02f, -1.47137448e-01f, 3.04439720e-02f, 1.38303488e-01f, 8.11130852e-02f, 3.71793732e-02f, 4.35548574e-02f,
  9.46306661e-02f, -6.23872392e-02f, 8.19886383e-03f, 9.92350932e-03f, 1.19673058e-01f, 1.18816299e-02f, 6.20070137e-02f, 1.06080314e-02f, -1.62397385e-01f, 6.98655322e-02f,
  -4.89724129e-02f, -1.17678389e-01f, -1.81629062e-02f, -5.37116751e-02f, -3.30798812e-02f, 2.18430199e-02f, -1.64620914e-02f, 1.08804204e-01f, 3.95184271e-02f, -6.43565059e-02f,
  -4.86612543e-02f, -6.05823919e-02f, -1.35185197e-01f, -1.21920995e-01f, -2.31573991e-02f, -8.10782611e-03f, -3.12681571e-02f, 8.64392426e-03f, 6.26320317e-02f, 7.33306035e-02f,
  -2.23547854e-02f, 1.43203987e-02f, -2.63450556e-02f, -7.78188780e-02f, -5.53638339e-02f, -1.90056500e-03f, -3.44558805e-02f, 8.90415311e-02f, 5.56812249e-02f, 1.24100745e-01f,
  -2.00208604e-01f, -1.37947351e-01f, -5.80078177e-02f, -9.51122642e-02f, -4.91207615e-02f, -7.91554302e-02f, -6.46518692e-02f, -6.67535216e-02f, 3.03293206e-02f, 2.84440420e-03f,
  -1.45535246e-01f, 1.94968525e-02f, 1.37536731e-02f, 1.96465924e-02f, 1.82308018e-01f, 1.44563941e-02f, 4.59476896e-02f, -1.33539334e-01f, -1.08316839e-01f, 4.92142290e-02f,
  -1.36236073e-02f, -2.35267682e-03f, 1.92731664e-01f, -5.29307276e-02f, -5.55741824e-02f, 1.39718447e-02f, -1.98436722e-01f, 4.94909585e-02f, 2.41039973e-03f, 4.46731821e-02f,
  3.29924911e-01f, 1.30738974e-01f, -1.74290597e-01f, -2.88924247e-01f, -2.20224440e-01f, 1.03314169e-01f, -1.23777166e-01f, -1.23687379e-01f, 7.96704665e-02f, 1.96350425e-01f,
  -1.43486887e-01f, 5.52862138e-02f, -1.43584926e-02f, -1.91321462e-01f, 1.79152846e-01f, 2.84721315e-01f, 9.08328369e-02f, -1.73999125e-03f, 1.18945884e-02f, 7.10838959e-02f,
  -9.14618522e-02f, -7.50302002e-02f, -2.66283244e-01f, 1.79034714e-02f, -1.61863759e-01f, -1.74346253e-01f, -1.23834759e-01f, -2.20728263e-01f, -7.70806596e-02f, 1.45705687e-02f,
  5.33346310e-02f, -6.26755953e-02f, 2.29639392e-02f, -3.44585553e-02f, 1.37168625e-02f, -3.73771368e-03f, -6.13105185e-02f, -1.04607753e-02f, -1.32241070e-01f, -5.08410074e-02f,
  5.73588461e-02f, 6.29819781e-02f, 7.92317688e-02f, 5.37793152e-02f, -2.58649513e-03f, -7.74166360e-02f, 1.22960228e-02f, -1.19217642e-01f, -1.41146228e-01f, -5.49364723e-02f,
  -1.09010786e-01f, -6.13628402e-02f, -6.85697049e-02f, 1.93571951e-02f, -2.64491625e-02f, 1.27921999e-03f, 1.77260917e-02f, -7.50747547e-02f, 8.35930556e-02f, 4.27434966e-02f,
  1.39738783e-01f, 4.33771648e-02f, -9.10460856e-03f, -9.48007181e-02f, -1.16886429e-01f, -1.02231644e-01f, -4.66876943e-03f, -1.07475787e-01f, -1.23986816e-02f, 8.61604512e-02f,
  -1.18039086e-01f, 5.97012695e-03f, -8.28498155e-02f, 2.64623016e-03f, 2.53529772e-02f, 1.29768446e-01f, 4.15987261e-02f, -1.49577088e-03f, -9.08313543e-02f, -7.43451864e-02f,
  -8.77245590e-02f, 1.26636356e-01f, -1.08297698e-01f, 1.07092559e-02f, -4.09155563e-02f, 1.31784929e-02f, 8.86240825e-02f, -5.42332679e-02f, -1.36514410e-01f, 6.82983845e-02f,
  7.28431791e-02f, 2.65338153e-01f, -1.78885031e-02f, 8.93429369e-02f, 2.51074228e-02f, 6.09417930e-02f, -5.49105443e-02f, -8.16268474e-02f, -3.94677781e-02f, 1.40363157e-01f,
  2.69482695e-02f, -2.46042181e-02f, 3.68097425e-02f, -1.05250627e-01f, -9.91936848e-02f, 2.85940338e-03f, 8.97200406e-02f, -1.47668883e-01f, -1.41955158e-02f, 5.63561469e-02f,
  -7.12090582e-02f, -5.31639233e-02f, 8.30801278e-02f, -9.79644526e-03f, 5.00442740e-03f, -4.75296453e-02f, 1.42781541e-01f, 3.26598845e-02f, 5.56786768e-02f, -5.75875081e-02f,
  -2.76811898e-01f, 3.05240542e-01f, -2.92748749e-01f, -1.93868786e-01f, 4.64327820e-03f, 4.06636953e-01f, 8.13246146e-02f, -7.92291313e-02f, -5.12921393e-01f, 1.89280659e-01f,
  3.23358834e-01f, -3.68529826e-01f, 2.78019190e-01f, 3.33775133e-01f, -2.39172518e-01f, 2.87791133e-01f, 1.10713817e-01f, 1.82720304e-01f, -1.05356790e-01f, 1.63751543e-02f,
  -1.75981954e-01f, 3.13908607e-01f, 1.25589147e-01f, 1.03004292e-01f, 2.14121103e-01f, -1.76629275e-01f, 6.01794794e-02f, -7.36838672e-03f, 1.09546244e-01f, -6.06023856e-02f,
  1.52187198e-01f, -1.23775654e-01f, 2.06742659e-02f, -7.45222047e-02f, -1.39361946e-02f, 1.25029340e-01f, 5.14764898e-02f, -1.17601529e-01f, -2.19022259e-01f, -1.08789012e-01f,
  -4.35622521e-02f, -1.03761733e-01f, -1.58628702e-01f, -1.27737060e-01f, -1.38374314e-01f, -6.35341182e-02f, -5.57985418e-02f, 8.87653884e-03f, -1.09673701e-01f, -5.80081344e-02f,
  -4.17028591e-02f, -6.07497282e-02f, 2.57350076e-02f, 4.08296511e-02f, -1.68293789e-01f, -7.72732496e-02f, -6.27586246e-02f, -1.79041233e-02f, -2.61802152e-02f, -4.23975363e-02f,
  -1.13498330e-01f, 8.77794996e-02f, 1.54475212e-01f, 2.20340304e-02f, -1.10473847e-02f, 7.94030726e-02f, 1.04473174e-01f, -6.39294181e-03f, -1.73386738e-01f, 3.25315818e-02f,
  -1.57345474e-01f, -1.17246360e-01f, -3.85784032e-03f, -8.97555219e-05f, -4.80577834e-02f, 1.59316622e-02f, -7.41891786e-02f, 1.25395626e-01f, -1.71651810e-01f, 1.02197774e-01f,
  3.65701057e-02f, 1.33323492e-02f, -3.26900138e-03f, 1.28982022e-01f, 6.23819716e-02f, -1.18073635e-01f, -4.59006764e-02f, 1.11584589e-01f, 4.74211164e-02f, -3.55365649e-02f,
  1.69894248e-01f, -9.67288669e-03f, 8.24731067e-02f, -2.08644066e-02f, 1.17917694e-02f, 9.04438570e-02f, 8.23859572e-02f, -9.84748453e-02f, 5.17949462e-02f, -5.46621419e-02f,
  1.81819648e-02f, 5.68286180e-02f, 8.39001909e-02f, -1.50229320e-01f, -6.89615086e-02f, 1.91716794e-02f, -2.49277651e-02f, -9.26955193e-02f, -1.23277806e-01f, -4.14778441e-02f,
  -8.35329443e-02f, 3.50595266e-02f, -8.51488635e-02f, 3.89472507e-02f, -6.95840567e-02f, 7.06067011e-02f, -1.06686361e-01f, -6.02710098e-02f, -2.64286995e-02f, 8.00934210e-02f,
  2.43792549e-01f, 4.28559929e-01f, -1.41730458e-01f, 4.08176512e-01f, -3.24132256e-02f, 4.33604717e-01f, 3.91289353e-01f, 1.19179056e-03f, 3.31488758e-01f, 3.49855304e-01f,
  4.25537452e-02f, 1.39327466e-01f, -1.69721931e-01f, 3.91168624e-01f, 1.25231698e-01f, 3.86611409e-02f, 5.15986502e-01f, 3.04259032e-01f, -1.59539785e-02f, 2.27779955e-01f,
  2.78580617e-02f, 3.61097842e-01f, -2.73184627e-01f, -1.47790566e-01f, 3.97851840e-02f, -2.80558437e-01f, -3.00240993e-01f, -4.25770134e-01f, 1.26863271e-02f, -1.09410167e-01f,
  2.33854093e-02f, 3.08386981e-02f, -6.72002882e-02f, -6.21848106e-02f, 3.37706908e-04f, 1.72522530e-01f, 7.00466111e-02f, -1.18340857e-01f, -1.29635409e-01f, -6.05219342e-02f,
  2.06257090e-01f, -5.09895980e-02f, 6.81209490e-02f, -9.88244638e-02f, 5.87173961e-02f, -6.31779134e-02f, -4.72250991e-02f, -8.65688249e-02f, 2.51028333e-02f, -5.99179529e-02f,
  2.59415228e-02f, -1.72077660e-02f, 8.44269618e-02f, 3.10724322e-02f, -1.06835112e-01f, 5.66031458e-03f, 3.58407907e-02f, -8.39731768e-02f, 1.06442012e-01f, 2.90452987e-02f,
  1.07849590e-01f, 1.33762553e-01f, 5.54126576e-02f, 1.73872840e-02f, 1.61142573e-02f, -3.53945792e-02f, 8.26456118e-03f, 1.11690164e-02f, -8.08651149e-02f, 4.18357290e-02f,
  -6.13512136e-02f, -2.05181185e-02f, 1.10026645e-02f, -9.82300472e-03f, 2.86063384e-02f, 2.49495469e-02f, -4.76672910e-02f, 1.01791769e-02f, 5.99314831e-02f, 2.99157724e-02f,
  -8.99430886e-02f, 7.52477124e-02f, -1.10358261e-01f, -8.39033648e-02f, -7.05898879e-03f, -1.59357652e-01f, -4.37460520e-04f, -1.44238889e-01f, -4.29793783e-02f, 6.61191717e-02f,
  1.56027794e-01f, 3.10495675e-01f, -5.27699776e-02f, 5.66440895e-02f, 9.11966488e-02f, 1.21287517e-01f, 2.13993207e-01f, 9.91441533e-02f, 2.59731971e-02f, 3.47365439e-02f,
  1.68213099e-02f, 1.24770083e-01f, 1.16894722e-01f, -1.85104145e-04f, -4.04737964e-02f, 6.06568577e-03f, 9.54297185e-02f, -5.92047609e-02f, 1.30711928e-01f, 1.72400102e-02f,
  1.38677716e-01f, 1.15336753e-01f, 9.69845355e-02f, 8.49574208e-02f, 8.27217773e-02f, -9.23638046e-02f, 1.68517768e-01f, -2.52814651e-01f, 5.13571203e-02f, -1.00390963e-01f,
  -5.13277233e-01f, -4.33754884e-02f, -3.82334411e-01f, 1.81949869e-01f, 2.01536566e-01f, 1.71591222e-01f, 8.44035000e-02f, -1.02516159e-01f, -1.23742327e-01f, 1.65391177e-01f,
  1.62421852e-01f, 4.76325117e-03f, -1.57886177e-01f, 3.34143549e-01f, -2.36005321e-01f, -2.24915490e-01f, 3.12295228e-01f, 5.29778749e-02f, -9.40914080e-02f, -1.02869987e-01f,
  -1.39018387e-01f, 3.18440437e-01f, -3.20480019e-01f, 8.77991021e-02f, 1.78893879e-02f, 1.38708308e-01f, 2.97284305e-01f, 3.61696966e-02f, 2.90275276e-01f, 1.67810813e-01f,
  1.33623322e-02f, -1.19946785e-01f, -7.20750615e-02f, -5.38178124e-02f, 3.89465950e-02f, -6.63949223e-03f, 1.41334370e-01f, 1.22706212e-01f, -1.74153447e-02f, -5.52086383e-02f,
  3.73089314e-02f, 3.64818387e-02f, 1.08615115e-01f, -6.71335459e-02f, -4.07440364e-02f, 4.51113321e-02f, -1.47813618e-01f, -5.41658700e-03f, -5.78779308e-03f, -1.97753266e-01f,
  -1.79819986e-01f, -1.45377174e-01f, -4.60830703e-02f, 2.44501699e-02f, -2.78760027e-03f, -7.61062503e-02f, -1.28494069e-01f, -1.34148197e-02f, 4.39206064e-02f, 7.70844221e-02f,
  -1.76725332e-02f, 7.37014785e-02f, -4.53842469e-02f, -3.42509449e-02f, 6.91056028e-02f, -8.67235567e-03f, 7.62038231e-02f, 1.12223126e-01f, -7.64185116e-02f, -2.84532625e-02f,
  6.71216398e-02f, -1.44685591e-02f, 1.14310198e-01f, 3.53499949e-02f, -1.05747685e-01f, 9.70917847e-03f, -2.52929293e-02f, 1.14793494e-01f, -3.57909426e-02f, -9.43009276e-04f,
  6.00205585e-02f, 7.57476836e-02f, -1.25953704e-02f, 1.82653591e-02f, 2.19518878e-02f, -2.30782274e-02f, 1.06785879e-01f, -1.57773308e-02f, 6.53289333e-02f, 5.24143800e-02f,
  1.48624569e-01f, 2.59007692e-01f, -4.63930964e-02f, 1.51701272e-01f, -2.11144928e-02f, 7.14913234e-02f, 4.72389758e-02f, -8.18947777e-02f, 3.97267304e-02f, 2.35831272e-02f,
  4.68541496e-03f, -6.32282123e-02f, 1.03005171e-01f, 6.35984465e-02f, 9.83811766e-02f, -1.01201862e-01f, 6.20891340e-02f, 9.78850126e-02f, 6.64618164e-02f, -2.25890465e-02f,
  -9.65930708e-03f, 9.84045714e-02f, -5.08250482e-02f, 5.00955321e-02f, -8.93210992e-03f, 6.23950511e-02f, -3.36128809e-02f, -8.17308854e-03f, -2.52883304e-02f, 7.56801143e-02f,
  3.23043376e-01f, -5.54357469e-01f, 2.26787895e-01f, 2.13596091e-01f, 3.07297379e-01f, -7.81640410e-02f, 4.43162099e-02f, 4.24773544e-02f, 1.89878330e-01f, -4.73982126e-01f,
  -1.12469874e-01f, -1.63990632e-01f, -1.07721267e-02f, -2.64568090e-01f, 3.72383058e-01f, 1.79002583e-01f, -1.52406722e-01f, -1.95336521e-01f, 2.05265611e-01f, -6.45681471e-02f,
  1.69337481e-01f, -2.72387773e-01f, 2.20774516e-01f, -3.48556161e-01f, -4.70918603e-02f, 3.11768632e-02f, 3.36559378e-02f, 5.10555459e-03f, -3.04551899e-01f, 2.27670092e-02f,
  -2.94467062e-01f, 8.07987247e-03f, -8.96841586e-02f, 3.10456064e-02f, -2.24943832e-02f, -5.61002381e-02f, 6.31072521e-02f, 2.10136637e-01f, 1.54183432e-01f, 1.19593598e-01f,
  -1.42138183e-01f, -6.27305079e-03f, -1.44991904e-01f, 4.06606011e-02f, -4.78948653e-02f, 2.19593756e-02f, -1.08748004e-02f, -5.09157740e-02f, 5.65966666e-02f, 1.19497135e-01f,
  -1.00704422e-02f, -3.58953811e-02f, -1.99951394e-03f, -3.49993035e-02f, 1.55770764e-01f, 7.84076303e-02f, 1.18768968e-01f, 2.17812825e-02f, -6.47265390e-02f, 5.13006896e-02f,
  1.83937959e-02f, 2.84615532e-03f, -2.93090269e-02f, -2.93737091e-02f, -7.59724453e-02f, 9.09283385e-02f, -2.42740791e-02f, -3.34666930e-02f, -2.79752947e-02f, -6.45518303e-03f,
  -3.85821201e-02f, 8.82269442e-03f, 9.35590416e-02f, -2.63897441e-02f, 4.20245118e-02f, 8.18370730e-02f, 7.21126888e-03f, 1.60340220e-02f, -1.32520869e-02f, 4.13432494e-02f,
  -5.63298017e-02f, 2.16703117e-03f, 4.81237657e-02f, 7.63176531e-02f, -4.59931940e-02f, -1.94562152e-02f, -6.96417093e-02f, 5.87285124e-02f, 4.30426560e-02f, 3.47775817e-02f,
  -6.10730052e-01f, -4.89621520e-01f, -6.41540736e-02f, -1.19215809e-01f, -1.96935043e-01f, -1.30241988e-02f, -2.90538687e-02f, -1.86955798e-02f, -1.78116202e-01f, 6.13710620e-02f,
  -3.77814546e-02f, 6.61330521e-02f, 2.83166915e-02f, -4.37311828e-03f, -2.06613138e-01f, 1.02959022e-01f, -4.56922874e-02f, -8.30068365e-02f, -1.64197356e-01f, -1.37210205e-01f,
  -9.42571834e-03f, -7.91596100e-02f, 8.17421153e-02f, 1.30891219e-01f, 3.99803780e-02f, -6.28076717e-02f, 3.22956853e-02f, -9.49038789e-02f, 8.58221725e-02f, -4.07064520e-02f,
  6.64504766e-01f, 1.89269662e-01f, 6.34313896e-02f, 3.47594917e-01f, 2.60116253e-02f, -3.21222395e-02f, 3.83735821e-02f, 2.25957423e-01f, 4.07321334e-01f, -1.34734288e-01f,
  -1.20007426e-01f, 4.19805318e-01f, -2.70898610e-01f, 3.99391741e-01f, 1.47337168e-01f, -3.47248226e-01f, 4.45648909e-01f, 2.03746855e-01f, 8.83557126e-02f, 3.17352355e-01f,
  1.40241951e-01f, 2.14945003e-01f, 4.09856765e-03f, -3.44689190e-02f, 2.65709698e-01f, 1.09044932e-01f, -2.08870351e-01f, -3.50750744e-01f, 2.34016195e-01f, -1.45401418e-01f,
  4.81862314e-02f, 2.27475241e-01f, 6.52616769e-02f, -3.38216536e-02f, -2.84012146e-02f, 1.12494126e-01f, -1.91502813e-02f, -9.70702544e-02f, 1.30016394e-02f, 4.42169346e-02f,
  5.28780594e-02f, -1.38130167e-03f, 2.24248562e-02f, -7.79606104e-02f, 1.00477852e-01f, 7.82847628e-02f, 1.30199119e-01f, 5.10568954e-02f, 5.05800173e-02f, 1.39899954e-01f,
  6.13977499e-02f, -5.50869107e-03f, 8.07534158e-02f, 2.14079171e-02f, 5.99103644e-02f, 1.37980625e-01f, 2.40657059e-03f, -9.35075060e-02f, 5.02966307e-02f, 2.46936977e-01f,
  5.73862679e-02f, -1.23147048e-01f, 1.96131933e-02f, 7.36222928e-03f, -9.11298208e-03f, 6.48372248e-02f, 1.29091674e-02f, -1.09530911e-01f, 8.53255112e-03f, -1.07886814e-01f,
  -7.06237787e-03f, 2.15142388e-02f, 4.58865315e-02f, 6.18166029e-02f, 1.34618744e-01f, 1.63114160e-01f, 2.75920108e-02f, -2.09986381e-02f, 6.59919828e-02f, 3.80280353e-02f,
  -1.49547225e-02f, -3.01829707e-02f, 2.69543827e-02f, -1.07367381e-01f, -1.57808196e-02f, -1.20158032e-01f, -1.32025573e-02f, 1.40267402e-01f, -1.31674573e-01f, -2.24289037e-02f,
  -1.18134804e-02f, 4.95877713e-02f, -1.07808337e-02f, -5.42729273e-02f, -8.83603469e-02f, 1.50673047e-01f, 1.13822050e-01f, 8.54834914e-02f, 1.22589171e-01f, -1.66534260e-02f,
  -3.06007620e-02f, 3.58030014e-02f, -1.73739403e-01f, -3.83435749e-02f, -7.07708374e-02f, 1.19259126e-01f, -1.26930058e-01f, 3.01394612e-02f, -1.09593971e-02f, 7.09473863e-02f,
  -3.53575498e-02f, -2.25565452e-02f, -3.01972087e-02f, 1.26173897e-02f, -8.57549603e-04f, 1.81798935e-02f, 3.93134579e-02f, 3.36926542e-02f, -4.45205495e-02f, 2.56246272e-02f,
  3.49180967e-01f, -2.04119429e-01f, 3.67477089e-01f, 1.31420538e-01f, 1.86761782e-01f, 2.00514942e-01f, 2.63931125e-01f, -1.88005447e-01f, -1.14918604e-01f, -2.26890743e-01f,
  -2.28451312e-01f, 3.32378328e-01f, 1.30414695e-01f, -2.34741718e-01f, 1.76808983e-01f, -8.51692408e-02f, -2.38289446e-01f, -1.39596626e-01f, 2.40228083e-02f, -9.97808948e-02f,
  3.46960762e-04f, -3.22701365e-01f, 1.38252378e-01f, -3.20687085e-01f, 1.30606830e-01f, -6.72016814e-02f, -3.28414112e-01f, 5.93276732e-02f, -2.19757959e-01f, 1.32806629e-01f,
  2.47918069e-03f, -1.40875041e-01f, 1.56160802e-01f, 2.29633576e-03f, -1.35518491e-01f, 5.92771471e-02f, 7.91676044e-02f, 1.75193503e-01f, 1.72341000e-02f, -3.19073871e-02f,
  2.49333400e-02f, 6.44217804e-03f, 5.18059544e-02f, 6.73239231e-02f, 4.82729003e-02f, 6.69326782e-02f, -1.99867296e-03f, 7.76120201e-02f, 9.31753591e-02f, 2.48756528e-01f,
  1.09039836e-01f, 1.88406557e-01f, 9.74110812e-02f, -3.00476942e-02f, 1.55850396e-01f, 8.37821364e-02f, 9.77521911e-02f, 2.14646131e-01f, 5.22686951e-02f, 9.79715511e-02f,
  -7.40624443e-02f, -7.79793262e-02f, -1.16051212e-02f, 3.30252387e-02f, -1.33395717e-02f, 1.17063016e-01f, -2.77389493e-02f, -3.21779251e-02f, 1.22185778e-02f, -3.81601900e-02f,
  2.70855166e-02f, 1.06433183e-02f, 7.87438601e-02f, -1.21550441e-01f, 4.15066592e-02f, -8.06134120e-02f, 2.19357789e-01f, -1.77141130e-02f, -1.37363933e-02f, 1.15801848e-01f,
  2.33980268e-02f, -6.39470518e-02f, 2.45715026e-03f, -6.12877905e-02f, -3.64280702e-03f, -8.71663075e-03f, -1.02883920e-01f, 4.50444929e-02f, -6.08675517e-02f, -1.48714967e-02f,
  -2.31125474e-01f, -4.81847465e-01f, -1.44287959e-01f, -1.30492763e-03f, -5.98631687e-02f, -9.74467918e-02f, -2.43944079e-02f, -6.87650219e-02f, -1.67313859e-01f, -8.98528751e-03f,
  -4.65263892e-03f, -1.23998830e-02f, -3.09767928e-02f, -6.10329732e-02f, -1.38381913e-01f, -1.06868871e-01f, -2.99874265e-02f, 4.60038483e-02f, 2.11398378e-02f, -1.72913410e-02f,
  7.21337125e-02f, 1.49967168e-02f, 5.28910458e-02f, -7.46482611e-02f, -1.72772080e-01f, 1.99829862e-02f, -6.14104830e-02f, 2.42108968e-03f, -6.26693219e-02f, -4.39434201e-02f,
  7.25205019e-02f, 4.05498773e-01f, 4.00506049e-01f, 2.91817933e-01f, -2.68655568e-01f, -2.86167204e-01f, -3.21645826e-01f, 1.96133144e-02f, 9.18526389e-03f, -1.66865021e-01f,
  -1.68111876e-01f, 4.66613501e-01f, 1.70459896e-01f, -6.50213137e-02f, 2.17667311e-01f, -8.10794011e-02f, 1.46687943e-02f, 5.04815876e-02f, 1.96946204e-01f, 2.75158226e-01f,
  2.13315800e-01f, -3.01226914e-01f, 2.99547374e-01f, -4.04687151e-02f, 1.06189653e-01f, 2.71262586e-01f, 3.50714535e-01f, 1.24001905e-01f, -4.39134017e-02f, -1.77478895e-01f,
  -1.18272506e-01f, 6.27526045e-02f, 3.07167396e-02f, -1.97765589e-01f, 5.48886918e-02f, -1.02897912e-01f, -2.70927381e-02f, -1.21844849e-02f, 2.35330407e-02f, -2.50194184e-02f,
  3.22563425e-02f, -7.75092542e-02f, -1.02418356e-01f, -1.11485220e-01f, -1.59479201e-01f, 1.38725743e-01f, -3.98803689e-02f, 9.58679616e-02f, -8.87755752e-02f, 7.46053532e-02f,
  -4.76036733e-03f, -4.39921208e-02f, 2.89652832e-02f, -2.50846576e-02f, 5.25032543e-02f, -8.30188915e-02f, -1.86672211e-02f, 1.49645656e-01f, 8.24120939e-02f, 5.11789112e-04f,
  -1.51816323e-01f, -3.52204666e-02f, -3.90146151e-02f, 8.58511478e-02f, -2.15781294e-02f, -5.75057939e-02f, -6.34317920e-02f, -7.91107938e-02f, 3.85446623e-02f, -5.55580929e-02f,
  8.09505582e-02f, 5.60790114e-02f, -1.40176564e-01f, -2.29673479e-02f, 5.85817657e-02f, -9.37237963e-03f, 2.40666140e-02f, -1.48426052e-02f, 1.35166869e-02f, 2.61463579e-02f,
  5.56569435e-02f, -1.79945007e-01f, 1.26537383e-01f, 3.60020138e-02f, -2.38044351e-01f, -1.71552505e-02f, 3.26904915e-02f, 3.96004468e-02f, 1.15745433e-01f, 1.58270299e-01f,
  -3.85267437e-02f, 2.91007876e-01f, 1.13837384e-01f, -9.31885466e-02f, -3.53019089e-02f, 1.15959100e-01f, -3.52852084e-02f, -2.17958889e-03f, 1.68511942e-01f, -4.01499458e-02f,
  -6.67129084e-02f, -4.36499082e-02f, 4.81806956e-02f, -9.58723798e-02f, -3.49111087e-03f, 1.42681673e-02f, 1.71440877e-02f, 6.10814504e-02f, 1.13477044e-01f, 1.31911412e-01f,
  6.44646436e-02f, -5.79132028e-02f, -6.27383962e-03f, -1.72645096e-02f, -5.83394393e-02f, -3.86967547e-02f, 1.48545444e-01f, 1.71115305e-02f, -6.99749291e-02f, 8.89034420e-02f,
  -9.40381587e-02f, 1.52356297e-01f, -2.45716363e-01f, -8.29765797e-02f, -2.45809063e-01f, -2.97707379e-01f, -2.45322421e-01f, -2.11777296e-02f, 2.70085454e-01f, 1.31898612e-01f,
  -1.05006933e-01f, 7.47831240e-02f, 2.47594088e-01f, -1.97555110e-01f, -2.27645691e-02f, 1.86934561e-01f, -1.82665780e-01f, -1.51985407e-01f, 6.64091930e-02f, -9.18949842e-02f,
  -3.96869704e-02f, 2.84837699e-03f, -1.59158245e-01f, 9.29744169e-02f, -2.93728054e-01f, 4.06065695e-02f, -4.92502712e-02f, -1.31258890e-01f, -2.24168763e-01f, -8.58249739e-02f,
  -1.17014505e-01f, 2.15515435e-01f, -1.08507067e-01f, 4.49197181e-02f, -1.20034575e-01f, -2.66152690e-03f, -8.53681564e-02f, 1.61351394e-02f, 2.59629134e-02f, 1.13983631e-01f,
  9.21198577e-02f, 1.24550715e-01f, 8.78400356e-02f, 4.72991690e-02f, -8.31063837e-02f, 7.09620342e-02f, 3.61904427e-02f, -6.13307171e-02f, -2.46771108e-02f, -1.64269105e-01f,
  -5.51205222e-03f, -2.97602192e-02f, -1.17740426e-02f, 1.06192768e-01f, 5.79370707e-02f, 8.10346007e-02f, -7.58295208e-02f, 5.27320057e-02f, 4.07180078e-02f, 3.28492299e-02f,
  1.90319791e-02f, 7.55648315e-02f, 3.30484286e-02f, -4.75034565e-02f, 4.15687896e-02f, -5.60612790e-02f, 5.74534908e-02f, -1.92297325e-02f, 1.28949687e-01f, -8.53814259e-02f,
  8.51854905e-02f, 8.63820389e-02f, 2.40714904e-02f, 2.41032280e-02f, -9.93141979e-02f, -2.27639524e-04f, 3.97252403e-02f, 1.52354464e-01f, -5.92734665e-02f, -1.77595206e-03f,
  9.29079652e-02f, -1.55012980e-02f, 4.48356234e-02f, -1.90875083e-01f, -1.69423074e-01f, 1.15477033e-01f, 5.26678897e-02f, -1.09703846e-01f, 1.76677632e-03f, -2.14074459e-02f,
  -9.53897089e-03f, 2.27075025e-01f, 6.42843097e-02f, 1.30703598e-01f, 1.74121989e-03f, -3.50575149e-02f, 1.34663433e-02f, -7.05165789e-02f, 5.84221408e-02f, 3.37678101e-03f,
  2.31874958e-02f, 2.01212354e-02f, 2.68275924e-02f, -2.85949875e-02f, -1.80735253e-02f, -1.33656487e-01f, 1.03808165e-01f, 1.39529362e-01f, 4.42420691e-02f, -5.08415774e-02f,
  -4.88614012e-03f, -3.46559882e-02f, 1.01664074e-01f, 2.59578675e-02f, 9.23446752e-03f, 8.18024110e-03f, 7.46905524e-03f, -1.10335313e-02f, 2.53256690e-02f, 1.17866829e-01f,
  -7.42138982e-01f, 7.16021657e-02f, -2.51198441e-01f, 5.17486744e-02f, 1.03661232e-01f, 5.17718568e-02f, -1.71403840e-01f, 6.06990457e-02f, -3.11633468e-01f, 1.26247019e-01f,
  3.64666373e-01f, -3.53623897e-01f, -1.67323560e-01f, 4.57540333e-01f, 3.09359044e-01f, 2.91223139e-01f, 4.98949707e-01f, 1.52555898e-01f, 1.61537513e-01f, 4.12711389e-02f,
  2.11735070e-01f, 4.56438720e-01f, 1.79581061e-01f, 3.18757802e-01f, 1.52430609e-01f, -1.04942778e-02f, 2.48496726e-01f, -1.76773593e-01f, 3.22483450e-01f, 1.78351570e-02f,
  -2.93777764e-01f, -2.57780045e-01f, -1.62102878e-01f, -2.80033350e-01f, 2.64292303e-02f, -1.23405211e-01f, -1.35238007e-01f, -2.54855566e-02f, -1.15126923e-01f, -4.81612310e-02f,
  -1.82962596e-01f, 7.06243068e-02f, 1.79218054e-01f, -9.52014104e-02f, -7.90927336e-02f, -2.73061506e-02f, 7.44658187e-02f, -1.93072800e-02f, 1.18902763e-02f, 1.02169871e-01f,
  -3.31661776e-02f, 2.36834407e-01f, 1.24484181e-01f, 2.37516522e-01f, 3.55602987e-02f, 2.24238150e-02f, -8.98069527e-04f, -1.33334160e-01f, 2.31270373e-01f, 4.49342206e-02f,
  6.26114905e-02f, 5.94575070e-02f, 3.35321133e-03f, -1.02248322e-02f, -7.84569457e-02f, 1.05251074e-02f, 2.57856250e-02f, -3.01596001e-02f, -7.23498091e-02f, 5.66517152e-02f,
  5.60103469e-02f, 6.35629892e-02f, -2.90382206e-02f, -2.65237652e-02f, 5.79148456e-02f, 5.88697083e-02f, -2.86660213e-02f, -8.21627080e-02f, 6.58649355e-02f, 4.43317145e-02f,
  -3.72070037e-02f, -9.76898596e-02f, 6.69574514e-02f, 8.31659660e-02f, 6.83772862e-02f, -7.69992992e-02f, -1.53297903e-02f, -8.20579678e-02f, -3.58869098e-02f, 2.64210757e-02f,
  -4.32140142e-01f, -1.95868358e-01f, -5.67400083e-02f, -6.63960651e-02f, -1.68102995e-01f, -5.66929504e-02f, -1.11382335e-01f, 2.14437962e-01f, -7.00165853e-02f, -5.81738502e-02f,
  -7.25672320e-02f, -1.97978280e-02f, -1.23434411e-02f, -1.08071104e-01f, 4.89890017e-02f, -6.10893872e-03f, -1.82346314e-01f, -1.52999878e-01f, -4.04045656e-02f, 5.66548258e-02f,
  5.43550141e-02f, 5.64476401e-02f, 1.38511389e-01f, 9.42353085e-02f, 1.61056191e-01f, -6.71673194e-02f, -1.84819251e-02f, -2.12103501e-03f, 1.96966797e-01f, 6.78433105e-02f,
  6.25541449e-01f, -3.98433924e-01f, -1.66511044e-01f, 2.36503407e-01f, 2.01312229e-01f, 4.16424870e-01f, 5.06168246e-01f, -2.70537054e-03f, 3.09502274e-01f, -3.02206576e-01f,
  2.60736956e-03f, 7.05863163e-02f, 1.05001740e-01f, 1.75667137e-01f, 4.49244738e-01f, 4.71371263e-02f, 3.45061630e-01f, 2.67289102e-01f, 3.42071354e-02f, 1.17381990e-01f,
  1.44827783e-01f, 2.47262970e-01f, -2.31049865e-01f, -3.09154361e-01f, 1.77541092e-01f, -2.38736033e-01f, -2.37547532e-01f, -4.81627509e-02f, -3.40831906e-01f, 2.19298020e-01f,
  2.60880832e-02f, 1.67074949e-02f, 3.73063274e-02f, -4.81612794e-02f, -1.18994460e-01f, -7.64558762e-02f, -9.52940155e-03f, 8.61309469e-02f, 7.74046108e-02f, 1.29767153e-02f,
  7.67858326e-02f, -4.41763736e-02f, -9.09512937e-02f, 1.18729733e-02f, 3.04607432e-02f, -5.47599643e-02f, -8.90656263e-02f, -1.48359269e-01f, -2.51437742e-02f, -4.55885679e-02f,
  4.48445752e-02f, -1.25143602e-01f, 9.56361592e-02f, -9.06903967e-02f, -7.78689981e-02f, -2.78384387e-02f, -2.80946810e-02f, -4.99748923e-02f, -1.20278262e-01f, 8.13144967e-02f,
  -1.65501628e-02f, 6.88640177e-02f, 8.93599354e-03f, -6.83274344e-02f, -1.85065027e-02f, -2.87047960e-02f, 6.05691262e-02f, -8.65397155e-02f, 2.38247551e-02f, 4.93988879e-02f,
  7.50818104e-02f, 7.41134286e-02f, -2.10696436e-03f, 8.99470299e-02f, -3.10602561e-02f, 5.23780705e-03f, 1.58895180e-02f, 3.42880301e-02f, -3.01589742e-02f, 6.01439131e-03f,
  4.33357991e-02f, 4.42666672e-02f, 9.86735374e-02f, -1.45485833e-01f, -4.52176742e-02f, 8.33225772e-02f, -3.33529450e-02f, 9.19137448e-02f, -5.79919033e-02f, 1.47271812e-01f,
  8.28829408e-03f, -5.18832095e-02f, 1.31889815e-02f, -3.85817774e-02f, -2.02794179e-01f, -2.04106010e-02f, 2.17824336e-02f, 8.16476643e-02f, 1.11846268e-01f, -1.56292785e-02f,
  -4.66242991e-02f, 3.10185011e-02f, -6.03262968e-02f, -4.58544716e-02f, -2.36774571e-02f, 2.88036792e-03f, -2.79402193e-02f, 4.15434353e-02f, 1.23891216e-02f, -1.26541242e-01f,
  2.02381574e-02f, 1.19308501e-01f, 2.10163482e-02f, -4.57417630e-02f, -6.17660098e-02f, -6.93507642e-02f, 2.99821552e-02f, 1.43187046e-02f, -7.39050284e-02f, 6.05065562e-02f,
  5.14478326e-01f, -9.25167203e-02f, 2.38265581e-02f, 2.45763153e-01f, 3.02983254e-01f, -1.42317280e-01f, 6.90639466e-02f, 1.75403818e-01f, 3.91257852e-01f, -1.82843015e-01f,
  -8.03102739e-03f, -8.86734873e-02f, -3.19855958e-01f, 3.53512377e-01f, 3.10934305e-01f, -2.97031045e-01f, 2.79465973e-01f, -2.24294886e-02f, 8.12075138e-02f, 2.31548145e-01f,
  2.14908689e-01f, 4.18426603e-01f, 7.67474920e-02f, 5.88913113e-02f, 2.25008309e-01f, 1.74308807e-01f, 7.27257831e-03f, -1.76697403e-01f, -4.16359901e-02f, 6.93707019e-02f,
  5.78685775e-02f, 2.96616614e-01f, -3.14673856e-02f, -7.08891153e-02f, 9.68214348e-02f, 3.89567902e-03f, -1.80592909e-01f, -1.72082648e-01f, -2.49682907e-02f, -1.05949074e-01f,
  -2.32549515e-02f, 9.64913070e-02f, 2.08845660e-02f, 5.42038567e-02f, 1.87130734e-01f, 4.70801406e-02f, -6.30684793e-02f, -7.04871714e-02f, 5.48079945e-02f, -1.07069723e-01f,
  7.19431713e-02f, -1.17849126e-01f, 6.39083013e-02f, 2.86863148e-02f, 3.00710239e-02f, 1.49002135e-01f, -2.02810131e-02f, -6.19848445e-02f, -1.08807273e-01f, 1.70113936e-01f,
  -1.56049775e-02f, -7.41751045e-02f, 2.92705745e-03f, 7.00561181e-02f, 2.93037817e-02f, -4.01919372e-02f, 5.98400608e-02f, -2.00190376e-02f, 1.49639949e-01f, -6.21771142e-02f,
  -3.76125611e-02f, 8.85677338e-02f, 8.38143900e-02f, -1.04920179e-01f, 1.22876585e-01f, 1.42294899e-01f, -1.12349786e-01f, -1.88501284e-01f, -3.20021771e-02f, -6.00551665e-02f,
  1.54215887e-01f, 7.10071414e-04f, -1.07580781e-01f, -1.03973635e-01f, 5.81947230e-02f, -4.97330613e-02f, -5.05372435e-02f, -5.73682599e-02f, -3.02051064e-02f, 9.15225828e-04f,
  -5.46944514e-02f, -1.06132282e-02f, -7.11756125e-02f, 1.63020752e-02f, -9.21548158e-02f, 1.22985151e-03f, 4.34550121e-02f, -2.31131427e-02f, 7.71679431e-02f, -8.94712657e-03f,
  -5.35131209e-02f, -9.80195627e-02f, -5.45196719e-02f, -5.93909994e-02f, -7.24926367e-02f, 7.49629140e-02f, -1.45305529e-01f, 1.79231446e-02f, -6.07363414e-03f, -9.03631225e-02f,
  -1.04773752e-02f, -6.36922270e-02f, 1.23540573e-01f, 1.03782520e-01f, -8.14245865e-02f, -7.08707720e-02f, 9.04214531e-02f, 2.28520408e-02f, -6.13275245e-02f, -1.26280978e-01f,
  -4.33129996e-01f, -5.33424675e-01f, 1.18103586e-01f, -3.03901762e-01f, 3.18332374e-01f, 2.16727465e-01f, 6.47867769e-02f, -1.84676349e-01f, -3.27877402e-01f, -4.73613441e-01f,
  -1.01212382e-01f, -6.81107640e-02f, -2.01132461e-01f, -2.71492213e-01f, 4.34227347e-01f, 2.24352479e-02f, 1.58601180e-01f, 1.23965368e-01f, 1.93832512e-03f, -4.12842110e-02f,
  2.00180739e-01f, 7.60234939e-03f, 2.66331136e-01f, -3.23110167e-03f, -4.67431061e-02f, -8.72300640e-02f, 4.49700132e-02f, 2.53878772e-01f, 1.02667831e-01f, 3.35824005e-02f,
  -7.33387545e-02f, -2.59154648e-01f, -3.63423377e-02f, 1.51122078e-01f, 2.99381744e-02f, 6.83908463e-02f, 8.27198327e-02f, 1.88002318e-01f, 1.61734194e-01f, 1.39968321e-01f,
  1.34282410e-01f, 2.04358667e-01f, -1.53419241e-01f, 9.33524296e-02f, 8.07859004e-02f, 9.43501741e-02f, 1.72741637e-01f, 6.19265065e-02f, -8.48694518e-02f, -4.65550199e-02f,
  -5.55014517e-03f, -4.61701974e-02f, -7.51401931e-02f, -2.49283295e-02f, -4.47207084e-03f, 5.12334239e-03f, 8.59297961e-02f, 2.97665130e-02f, -7.57332593e-02f, -3.26053202e-02f,
  -2.44929967e-03f, 9.09387842e-02f, 4.85754609e-02f, 6.45264015e-02f, -8.44511911e-02f, -3.98961268e-02f, 1.54013038e-01f, -3.47243696e-02f, -3.20200226e-03f, -1.43610954e-01f,
  -3.80484685e-02f, 2.34358851e-02f, 5.19956499e-02f, 4.76330929e-02f, -1.15379021e-01f, -8.29399377e-02f, 1.69734299e-01f, -4.04151268e-02f, -1.22130342e-01f, -2.80601047e-02f,
  -2.50525195e-02f, 3.45384181e-02f, 5.58722541e-02f, 8.57306737e-03f, -6.45198859e-04f, 3.28173488e-02f, -3.65107395e-02f, -9.13895220e-02f, -6.66718110e-02f, 1.10155374e-01f,
  -7.28283748e-02f, -2.65708059e-01f, 1.97364064e-03f, 3.55022177e-02f, 2.31415052e-02f, -4.18927753e-03f, 5.39993830e-02f, -2.33084261e-02f, -2.91256774e-02f, 5.04544079e-02f,
  9.86418948e-02f, 5.25111780e-02f, -1.23054959e-01f, 1.24741293e-01f, 1.84727646e-02f, -1.02358967e-01f, 1.08719170e-01f, 9.04295594e-02f, 9.09257382e-02f, -2.00873055e-02f,
  -1.42193809e-01f, 3.71671468e-02f, -1.29325077e-01f, -1.63468406e-01f, 7.05206320e-02f, -1.92898028e-02f, 1.28349019e-02f, -5.44281118e-02f, 1.51260287e-01f, -1.63161337e-01f,
  2.90995955e-01f, 1.74913451e-01f, 1.46666318e-01f, 5.69344401e-01f, -3.89803872e-02f, -1.78613737e-01f, 3.95012289e-01f, 5.47609739e-02f, 5.14638841e-01f, -6.88035563e-02f,
  -2.01508448e-01f, 1.06412403e-01f, -1.64584383e-01f, 1.32895783e-01f, -3.91560555e-01f, -1.01091437e-01f, 3.27945739e-01f, 9.27847624e-02f, 3.13073218e-01f, 1.61143951e-02f,
  2.68469930e-01f, -3.02859426e-01f, -6.01286553e-02f, -3.91085654e-01f, 2.48102993e-02f, 3.00749481e-01f, -3.67612123e-01f, -6.89787641e-02f, -1.26250714e-01f, -7.33305886e-02f,
  1.19093403e-01f, 1.44973159e-01f, 1.86087694e-02f, 1.65028557e-01f, 1.12593949e-01f, -5.15924431e-02f, -1.29358247e-02f, -9.03391466e-02f, 1.49228171e-01f, 2.85288244e-02f,
  -7.18059717e-03f, -1.34400472e-01f, 1.03570361e-04f, -1.43210307e-01f, 2.01065317e-01f, -1.70665868e-02f, 2.89710797e-02f, 4.67140600e-02f, 1.18461624e-01f, -7.07356781e-02f,
  9.36963037e-02f, 7.54613951e-02f, 1.23199053e-01f, 7.74173588e-02f, 3.01070996e-02f, 1.72748432e-01f, -3.28075849e-02f, -5.88862039e-02f, 1.89650860e-02f, 1.18223086e-01f,
  -8.21254924e-02f, 1.71366110e-02f, 2.17750911e-02f, -2.05542967e-02f, -6.92661330e-02f, 8.60452503e-02f, 2.85561234e-02f, -2.49614734e-02f, 4.37954813e-02f, -5.16015999e-02f,
  -8.42266250e-03f, 1.02937698e-01f, 6.58629239e-02f, -6.28050715e-02f, 9.24245641e-02f, 1.14586607e-01f, -2.10133512e-02f, -2.50067143e-03f, 1.76562622e-01f, 9.40824952e-03f,
  -2.82244142e-02f, -7.00948089e-02f, -7.06383437e-02f, -2.05750391e-02f, -2.70234402e-02f, -1.10847736e-02f, -6.04783073e-02f, -4.49340530e-02f, 1.04457431e-01f, -1.41109884e-01f,
  1.13529928e-01f, -2.93142665e-02f, 1.22648448e-01f, 7.74600059e-02f, 8.26787949e-02f, -1.30999818e-01f, -2.24322286e-02f, 1.63015909e-02f, 4.56297882e-02f, 2.60755252e-02f,
  -2.58389432e-02f, 8.96968842e-02f, 1.32988840e-02f, -7.52944723e-02f, 7.54024982e-02f, -1.74354345e-01f, 1.24992616e-01f, 1.13320254e-01f, 6.29914850e-02f, -4.94889021e-02f,
  -1.65046891e-03f, 1.62294060e-02f, -7.83242099e-03f, 1.90517247e-01f, 1.32736117e-01f, 4.27666726e-03f, -1.42523199e-01f, 9.22049433e-02f, -5.87036721e-02f, 1.65136252e-02f,
  -7.59254918e-02f, -2.07163781e-01f, -6.22330839e-03f, 2.21161768e-01f, -1.27759933e-01f, -2.26730421e-01f, -2.62847066e-01f, 1.35213524e-01f, 6.00883365e-02f, -5.07245772e-02f,
  -1.35027722e-01f, -1.18838832e-01f, -1.48126751e-01f, -2.75551379e-01f, 1.43499851e-01f, -1.72862664e-01f, 1.70390099e-01f, -2.84697622e-01f, 1.03457585e-01f, 5.43467514e-02f,
  2.18028978e-01f, 5.53240739e-02f, 1.71494663e-01f, 1.16667338e-01f, 1.56326238e-02f, 2.94262856e-01f, 3.68053347e-01f, 5.24634831e-02f, 1.47233814e-01f, -1.03938237e-01f,
  -1.24001175e-01f, 3.67373489e-02f, 5.55889979e-02f, -1.40031781e-02f, 1.81340978e-01f, 5.10619991e-02f, -6.06334321e-02f, -8.44814777e-02f, 3.26324417e-03f, 8.26363452e-03f,
  4.44682203e-02f, 5.37711047e-02f, 2.87895370e-02f, -8.77713487e-02f, -7.39194825e-02f, -5.07370718e-02f, 9.85470116e-02f, 4.46584076e-02f, -3.81247811e-02f, -8.64808187e-02f,
  -2.82163220e-03f, -4.75597866e-02f, 5.33612370e-02f, 9.85680744e-02f, 9.98009555e-03f, -6.51235878e-02f, 8.06372166e-02f, 2.08352483e-03f, 3.24482098e-02f, 9.91792530e-02f,
  2.70916242e-02f, 2.68964600e-02f, -8.66377428e-02f, -7.69117698e-02f, 3.94922867e-02f, 7.97979981e-02f, -1.27244676e-02f, -1.23977764e-02f, -5.75330220e-02f, -6.71539688e-03f,
  6.99074417e-02f, -6.92516426e-03f, -7.30421953e-03f, 9.18720011e-03f, -6.81379735e-02f, 1.91640463e-02f, 6.18037358e-02f, -6.11981563e-02f, 5.59005588e-02f, 8.76642950e-03f,
  -6.60611913e-02f, -1.29328370e-01f, -4.31997217e-02f, -1.76988635e-02f, -5.44008985e-02f, 3.94598208e-02f, 4.09771018e-02f, -6.63065016e-02f, 3.73212397e-02f, 1.04543708e-01f,
  1.25336319e-01f, 2.76590466e-01f, -2.76123676e-02f, -1.00214005e-01f, 6.77865818e-02f, -3.76151837e-02f, -4.65112850e-02f, -2.06787069e-03f, 2.44942419e-02f, -6.37942404e-02f,
  1.53503641e-01f, 7.00755343e-02f, 6.32755160e-02f, -5.75665347e-02f, 1.54242562e-02f, 1.72385857e-01f, 7.92605653e-02f, 1.88028499e-01f, 2.49523208e-01f, 2.03281537e-01f,
  9.79584977e-02f, -4.33402099e-02f, 1.11475527e-01f, 1.42659932e-01f, -2.20311712e-02f, 1.31995320e-01f, -6.85555190e-02f, 4.10975702e-02f, 8.18141401e-02f, 7.01760501e-02f,
  -2.12223083e-01f, 9.41522494e-02f, -3.50653738e-01f, 2.35102519e-01f, -3.80039699e-02f, 2.61113673e-01f, 1.01434268e-01f, 4.10601962e-03f, -1.49097249e-01f, 3.04739922e-01f,
  1.82082489e-01f, -1.40559629e-01f, -1.05913170e-01f, 4.25630957e-01f, 1.91364259e-01f, 1.05563805e-01f, 4.82372165e-01f, 2.44017825e-01f, -1.63211629e-01f, 7.18507990e-02f,
  1.84480213e-02f, 3.57367903e-01f, -2.72149518e-02f, 1.09074309e-01f, 1.28758729e-01f, -2.47587010e-01f, 2.90379673e-01f, -2.04571798e-01f, 4.33515251e-01f, 1.58166066e-01f,
  1.83450773e-01f, -5.35053201e-02f, -6.58336282e-02f, -6.32129684e-02f, 3.25462595e-02f, 1.43266609e-02f, -7.26191029e-02f, 1.76326577e-02f, -1.39093801e-01f, -3.97061296e-02f,
  -9.47102830e-02f, -4.68754862e-03f, 1.51911125e-01f, -2.12465767e-02f, -2.17677131e-02f, -2.47561224e-02f, 1.71451992e-03f, -8.49220380e-02f, 2.40563713e-02f, -8.95019472e-02f,
  -1.83165208e-01f, 2.77756080e-02f, 3.57549544e-03f, 6.08487017e-02f, -1.25458017e-02f, -4.77798097e-02f, 6.85623288e-02f, -9.51429978e-02f, 4.79923189e-02f, 6.50200173e-02f,
  7.51936138e-02f, -7.96947852e-02f, -2.60197837e-02f, 6.52242452e-02f, 8.91894102e-02f, 1.06703639e-01f, 9.63432863e-02f, 1.14710107e-01f, -3.49587575e-02f, 9.89493132e-02f,
  -4.34896257e-03f, -3.04020885e-02f, 8.89804512e-02f, -6.47931546e-02f, 6.03801571e-03f, -4.34734002e-02f, -1.14706151e-01f, -1.31957466e-02f, -6.13013841e-02f, 1.86381377e-02f,
  -4.15960848e-02f, -9.38137341e-03f, 1.47552490e-02f, -1.92255639e-02f, 5.89482449e-02f, -1.08815931e-01f, 3.41475569e-02f, -1.19368561e-01f, -2.06286088e-02f, -2.83402745e-02f,
  5.41092046e-02f, 1.49861693e-01f, -6.20364994e-02f, 4.71136235e-02f, 1.16134025e-01f, 8.78210589e-02f, 8.64751488e-02f, -7.64095038e-02f, -3.84138525e-02f, 4.33923677e-02f,
  -5.32999784e-02f, -8.24131742e-02f, 4.93378378e-03f, 5.26495315e-02f, 1.49801448e-01f, 4.37611109e-03f, 1.41731218e-01f, -1.75760202e-02f, 7.63588622e-02f, 2.65024807e-02f,
  -5.27989417e-02f, -6.07390665e-02f, 9.76895168e-02f, -1.00924887e-01f, 1.29830986e-01f, 6.29479364e-02f, -1.65663306e-02f, -3.63808461e-02f, 1.27772301e-01f, 3.79003845e-02f,
  2.77922899e-01f, -3.09771955e-01f, -2.28984118e-01f, -2.72063464e-01f, 3.07109863e-01f, 3.63875687e-01f, -1.18234262e-01f, -1.79576844e-01f, -3.03541243e-01f, -3.71581495e-01f,
  -1.51697220e-02f, -1.81829527e-01f, -4.02250469e-01f, 1.97766602e-01f, 4.62794542e-01f, -1.40038341e-01f, 2.45108694e-01f, 5.36451340e-02f, 1.56515867e-01f, 5.28735900e-03f,
  1.95649326e-01f, 4.57977682e-01f, -5.52220047e-02f, 1.71809793e-01f, 1.31043106e-01f, -1.32392615e-01f, -1.96131039e-02f, -1.75014198e-01f, 1.83478668e-01f, 1.69248194e-01f,
  1.00701652e-01f, -1.02567300e-01f, 2.81970445e-02f, -9.63761285e-02f, -2.17555873e-02f, 8.06933120e-02f, -6.77289739e-02f, 2.89184172e-02f, 3.03390771e-02f, -3.52335721e-02f,
  -7.75822401e-02f, 7.02675581e-02f, -2.85845920e-02f, 1.22593969e-01f, 4.24023122e-02f, 1.64652355e-02f, -3.91434133e-02f, -9.15495455e-02f, -1.52216986e-01f, -4.86634634e-02f,
  -8.66058767e-02f, -1.14221938e-01f, 2.14379299e-02f, -1.03597984e-01f, -1.06379941e-01f, -3.55620943e-02f, -2.64746342e-02f, -1.37530610e-01f, -6.45229360e-03f, -1.17800914e-01f,
  -5.29495366e-02f, 4.93008308e-02f, 1.82818919e-02f, -2.53462885e-02f, 1.04575558e-02f, 4.23180219e-03f, 1.49671674e-01f, 5.85148931e-02f, -8.10087547e-02f, -5.44995330e-02f,
  -9.10218135e-02f, 6.42924532e-02f, -2.20118742e-02f, 9.58107337e-02f, 7.44585395e-02f, 8.98047611e-02f, 1.63613364e-01f, 3.80254798e-02f, -9.09860283e-02f, 1.55056100e-02f,
  -8.00564606e-03f, 1.02685645e-01f, -5.36815934e-02f, -4.55085508e-04f, -1.17652174e-02f, -1.07045695e-01f, 5.07693179e-02f, 3.53714381e-03f, -1.81332938e-02f, 2.81938948e-02f,
  4.88882773e-02f, -2.57614583e-01f, -9.33725536e-02f, 3.46509852e-02f, 2.49234382e-02f, 5.98994121e-02f, 6.44087866e-02f, 1.69977397e-02f, -6.00753389e-02f, 1.12389006e-01f,
  -1.58674065e-02f, -3.19865998e-03f, -4.50152457e-02f, 3.31317261e-02f, 1.36171535e-01f, -7.11616427e-02f, 8.57228972e-03f, -1.23041414e-01f, -7.48908073e-02f, 5.84545135e-02f,
  -5.26671782e-02f, 9.24012884e-02f, -1.07711926e-01f, 2.58008987e-02f, -2.40243860e-02f, 3.39607075e-02f, 1.08565748e-01f, -1.26795501e-01f, 4.02794033e-02f, -8.05407837e-02f,
  2.61708707e-01f, -3.32018510e-02f, 3.16669554e-01f, 3.63006115e-01f, 6.40641227e-02f, -4.77201521e-01f, -7.64544755e-02f, -1.41884878e-01f, 7.90804997e-02f, -2.17151031e-01f,
  -2.25942492e-01f, 4.05120313e-01f, -3.89065683e-01f, 2.77481884e-01f, 1.20935045e-01f, -4.54155087e-01f, 1.39264688e-01f, 1.49743155e-01f, 4.37519401e-02f, 7.46095404e-02f,
  9.98143777e-02f, -1.01507582e-01f, 2.39621475e-01f, -1.62621722e-01f, 1.43065959e-01f, 2.94656515e-01f, 1.30434349e-01f, -5.04284799e-02f, 2.86242962e-01f, 1.08906977e-01f,
  1.87460575e-02f, 5.50496355e-02f, 1.81221336e-01f, -4.46671769e-02f, -2.89015956e-02f, -6.45622760e-02f, 6.14044629e-02f, -3.60381790e-02f, 1.13738172e-01f, -2.22537182e-02f,
  9.53624025e-03f, 1.14104129e-01f, 8.83107930e-02f, 1.88825373e-02f, 1.47727758e-01f, 1.21779576e-01f, 5.68906032e-02f, 3.84238325e-02f, 9.10633728e-02f, -4.39776387e-03f,
  -5.04608871e-03f, 1.13340907e-01f, -1.20399790e-02f, 1.34647042e-01f, 1.08558178e-01f, 3.39088365e-02f, 3.22801992e-02f, 1.74839303e-01f, -1.61720160e-02f, 1.52672216e-01f,
  4.10585180e-02f, -8.19375888e-02f, -1.35211706e-01f, 3.23212445e-02f, -1.35464236e-01f, 7.51064345e-02f, -4.22192104e-02f, -5.94330486e-03f, -7.28508756e-02f, -4.43415716e-02f,
  -4.37222235e-02f, 1.68336153e-01f, -6.99685961e-02f, 1.30661996e-02f, 1.41263446e-02f, 1.79145113e-02f, 9.76568535e-02f, 4.14263085e-02f, -3.12371738e-02f, -2.33120061e-02f,
  -8.61881077e-02f, -3.70332152e-02f, -2.13759243e-02f, -4.30420600e-02f, -7.22718015e-02f, -3.61738205e-02f, -8.38374346e-03f, 5.38932644e-02f, -1.10782050e-01f, -9.24186036e-02f,
  -1.07855335e-01f, -1.29303381e-01f, -7.22979978e-02f, 8.39738473e-02f, -7.59355798e-02f, -1.60591416e-02f, 9.68678072e-02f, 1.15316898e-01f, -1.29660979e-01f, -1.56149477e-01f,
  1.39913246e-01f, -1.72595121e-02f, 4.62470464e-02f, 4.68714684e-02f, -2.75497250e-02f, 1.02869701e-03f, -2.62533277e-02f, 2.76900474e-02f, 1.09756015e-01f, -2.37985272e-02f,
  -8.38385150e-02f, -1.21914446e-01f, 8.93071368e-02f, 1.16539188e-01f, -1.51540581e-02f, 7.73558021e-02f, 2.16327924e-02f, -5.58137782e-02f, -3.24793048e-02f, -6.77632615e-02f,
  2.60288566e-01f, -3.56083930e-01f, 2.57898837e-01f, 3.67600232e-01f, 2.33196057e-02f, 1.94838852e-01f, 4.75453109e-01f, -1.29118949e-01f, 3.89069647e-01f, -1.35900542e-01f,
  -2.30290696e-01f, 1.90078169e-01f, 1.28596157e-01f, -2.23279178e-01f, 2.51604170e-01f, 1.64750934e-01f, -7.93521255e-02f, 6.34635612e-02f, 6.92798793e-02f, 1.47425726e-01f,
  2.20090136e-01f, -1.14959799e-01f, -1.81798011e-01f, -2.06960261e-01f, -2.31082365e-01f, -4.54653660e-03f, -2.42574885e-01f, -4.20161746e-02f, -3.13947558e-01f, -1.93728521e-01f,
  -7.01400489e-02f, -7.67382383e-02f, -3.27169262e-02f, -2.55186595e-02f, -9.73019674e-02f, -8.07089582e-02f, 8.58249143e-03f, 3.65450382e-02f, -6.98436424e-02f, 3.72046307e-02f,
  7.32629448e-02f, 5.14989197e-02f, 2.88118720e-02f, -2.09533907e-02f, 5.90051990e-03f, -5.49987704e-02f, 7.91607238e-03f, -1.17360735e-02f, 3.88906412e-02f, -8.62890780e-02f,
  4.16894518e-02f, -8.63846466e-02f, -5.49766310e-02f, -1.24930523e-01f, 7.80762509e-02f, -5.30074313e-02f, 7.55089298e-02f, -4.68341522e-02f, 1.06958345e-01f, 1.79893933e-02f,
  2.44175699e-02f, 1.53521523e-01f, -9.18703750e-02f, 3.62714827e-02f, 3.46812122e-02f, -7.31847137e-02f, -3.17369848e-02f, -6.83029070e-02f, 6.13206141e-02f, 9.80364308e-02f,
  6.10293932e-02f, -1.78495109e-01f, -1.47966012e-01f, -4.34748754e-02f, 5.88787161e-02f, 4.38402519e-02f, -7.14821517e-02f, -1.21088363e-01f, -3.35574523e-02f, 2.02844664e-02f,
  1.27453327e-01f, 1.24349706e-01f, -7.13713542e-02f, -1.07427433e-01f, -2.45239735e-02f, -1.14341810e-01f, -8.70233923e-02f, -1.06805621e-03f, 5.60940169e-02f, -2.98088919e-02f,
  1.14301927e-01f, 5.92591353e-02f, 9.61657148e-03f, 2.19019279e-02f, -4.80416864e-02f, -1.12052217e-01f, -5.34072220e-02f, 3.34041826e-02f, -7.06839859e-02f, 4.87646051e-02f,
  5.43741323e-02f, -6.99333251e-02f, 1.19501427e-01f, -2.03631856e-02f, -1.06267340e-01f, -1.47968307e-01f, 1.89716980e-01f, 7.90970400e-02f, 3.71736400e-02f, -8.50037336e-02f,
  -3.02751809e-02f, 1.28347009e-01f, 1.01962211e-02f, -2.33812723e-02f, -2.71623563e-02f, -1.85349006e-02f, 8.18103328e-02f, -9.89160091e-02f, 9.44526680e-03f, 5.03748320e-02f,
  -3.31235915e-01f, 2.89743654e-02f, 1.66122895e-02f, 1.76459834e-01f, -1.67235844e-02f, 2.46592104e-01f, 4.03325528e-01f, 2.08916161e-02f, 2.93535322e-01f, 2.06037909e-01f,
  -4.08613235e-02f, -1.73359096e-01f, 2.27642015e-01f, 1.25120282e-01f, -2.05677941e-01f, 1.28563210e-01f, 8.38875473e-02f, 2.65141129e-01f, 3.51029456e-01f, -1.67412579e-01f,
  -2.00461015e-01f, 1.51837608e-02f, -1.11241512e-01f, -1.55334603e-02f, -1.90171331e-01f, -8.69247913e-02f, -1.86329126e-01f, 2.31084913e-01f, -1.89270228e-01f, 5.02499081e-02f,
  1.38391227e-01f, 9.89758968e-02f, -2.26995125e-01f, -4.87373210e-02f, -1.37751386e-01f, -5.64791597e-02f, 2.48781722e-02f, 4.75992523e-02f, 9.68549922e-02f, 3.28208730e-02f,
  -1.04119249e-01f, 3.03001925e-02f, 7.57442042e-02f, 6.22621104e-02f, -5.11064827e-02f, -1.30890459e-01f, -9.03066620e-02f, -8.33745897e-02f, -2.38210578e-02f, -2.52240542e-02f,
  -1.66934878e-01f, -1.33806050e-01f, -1.14491247e-01f, 1.59984484e-01f, -5.39113209e-02f, 1.15613170e-01f, 5.50798774e-02f, -2.95980144e-02f, -8.18658024e-02f, 5.79155399e-04f,
  -1.46746084e-01f, 1.39742896e-01f, 4.29365151e-02f, 6.23747241e-03f, -5.14194220e-02f, -5.34596294e-02f, -1.41292676e-01f, -2.75596212e-05f, -1.36590600e-01f, -8.73540267e-02f,
  -3.32001559e-02f, -2.33725589e-02f, -5.83039783e-02f, -4.79150377e-02f, 7.51217306e-02f, -1.15212731e-01f, 4.49874699e-02f, 6.67172372e-02f, -5.97099811e-02f, -1.58268526e-01f,
  2.38779187e-02f, -9.03030299e-03f, -2.12700069e-02f, 1.65546000e-01f, 2.72859260e-03f, -5.98145686e-02f, -6.10210598e-02f, -7.93092847e-02f, 2.41586324e-02f, -5.38986512e-02f,
  2.04606339e-01f, 3.36807251e-01f, 1.38697669e-01f, -7.93984905e-02f, 1.15542248e-01f, -4.77477014e-02f, 1.73136115e-01f, -5.87739013e-02f, 8.92125741e-02f, 1.14650354e-02f,
  -1.13534413e-01f, 7.84280300e-02f, -1.10027283e-01f, -4.72394712e-02f, 3.79361138e-02f, 4.31945696e-02f, 1.18348062e-01f, 6.55472800e-02f, 2.93126311e-02f, 1.13862008e-02f,
  -1.70537025e-01f, 2.01552715e-02f, 4.89193946e-02f, -2.78504677e-02f, -3.03398110e-02f, -1.73421111e-03f, -3.31829302e-02f, 8.58882517e-02f, 1.32898586e-02f, 1.37596875e-01f,
  -4.92808133e-01f, -1.44842058e-01f, -2.04507187e-01f, 3.06857526e-01f, 6.58305511e-02f, 4.73815724e-02f, -1.10846423e-01f, -6.67979494e-02f, 2.03547031e-01f, -2.20367461e-01f,
  -1.43090785e-01f, 2.51504630e-02f, -3.43666315e-01f, 3.75090212e-01f, -8.34992826e-02f, 2.45663803e-02f, 3.33361328e-01f, 2.58561641e-01f, 1.45347282e-01f, -1.58112980e-02f,
  1.37943968e-01f, 2.55327225e-01f, -2.19272465e-01f, 3.05973858e-01f, -1.99748933e-01f, 3.85622866e-02f, -1.50063932e-01f, -1.38199344e-01f, 3.29470754e-01f, 1.98763907e-01f,
  -1.20716207e-01f, -1.82768866e-01f, -2.55047828e-01f, -1.07365184e-01f, -8.24440867e-02f, 4.13315967e-02f, -2.23513301e-02f, -5.10876216e-02f, 5.81004769e-02f, -4.47283685e-02f,
  -1.53852805e-01f, -2.30887253e-02f, 1.10404991e-01f, -1.51021767e-03f, -1.05292667e-02f, 6.48305863e-02f, 1.41618978e-02f, -4.40910570e-02f, 4.06171754e-02f, -7.23271593e-02f,
  -2.66626310e-02f, 1.07524708e-01f, -5.42998053e-02f, 9.13761929e-02f, -4.86113578e-02f, 6.77248389e-02f, 1.87884986e-01f, -4.30710204e-02f, -6.06691279e-02f, 9.41491127e-02f,
  4.64973487e-02f, -8.48195776e-02f, -1.02028385e-01f, 6.54184595e-02f, -1.44816432e-02f, 2.33457461e-02f, -4.48852703e-02f, -4.53326777e-02f, 1.55779242e-03f, -4.27694432e-02f,
  1.90280274e-01f, 3.62275951e-02f, -9.30778310e-03f, 4.59056608e-02f, 1.03076115e-01f, 1.53226033e-01f, 1.97207555e-02f, -7.92474672e-02f, -1.86094902e-02f, 6.81516007e-02f,
  -8.81779864e-02f, 3.00178919e-02f, -1.38985559e-01f, -9.59415585e-02f, 3.36802751e-03f, -7.35996217e-02f, 7.88296089e-02f, -5.25594987e-02f, 3.01907826e-02f, -8.54246914e-02f,
  -4.95501906e-01f, -3.58933121e-01f, -2.16125920e-01f, -5.26086502e-02f, 1.58294156e-01f, -1.03149928e-01f, 9.54163522e-02f, -3.54592800e-02f, -4.06761356e-02f, -7.14786425e-02f,
  -1.13936320e-01f, 8.62367898e-02f, -5.45133138e-03f, 1.09645195e-01f, 1.34757891e-01f, -7.95429870e-02f, -1.44117866e-02f, -2.69485707e-03f, -1.11437224e-01f, 8.38088468e-02f,
  -7.07858056e-02f, 2.51228958e-02f, -2.24063362e-04f, -1.00277908e-01f, 2.62882318e-02f, -3.90847586e-02f, -1.49632143e-02f, 7.71680847e-02f, 1.93253048e-02f, 1.37155876e-01f,
  2.46828690e-01f, -2.96101063e-01f, -1.89687043e-01f, 8.29142407e-02f, 2.62620240e-01f, 3.74982148e-01f, -1.59418404e-01f, 3.05050671e-01f, 1.07302144e-01f, -3.17326486e-01f,
  -1.05904313e-02f, -4.70888615e-01f, -4.52957541e-01f, 1.74557224e-01f, 1.18354745e-01f, 7.55214617e-02f, 2.20552817e-01f, -5.53138442e-02f, 3.48890662e-01f, 6.31097853e-02f,
  2.17399254e-01f, 3.59987885e-01f, 8.07611197e-02f, 2.58776039e-01f, 3.83846402e-01f, 4.77302670e-02f, -1.88854247e-01f, -2.10547540e-02f, 7.22791478e-02f, 3.89512070e-02f,
  1.96342632e-01f, 1.15691401e-01f, 1.82888091e-01f, 7.62034059e-02f, 6.63648993e-02f, -1.24134295e-01f, -9.43054259e-02f, -8.56939405e-02f, -1.38248336e-02f, -2.16532163e-02f,
  -8.60907733e-02f, 3.32387686e-02f, 1.00067601e-01f, -9.03904531e-03f, -3.88352089e-02f, 6.77193776e-02f, 3.10304505e-03f, 7.44111836e-02f, -2.05704257e-01f, -6.32372946e-02f,
  -9.41293985e-02f, -9.89440158e-02f, -7.74617717e-02f, 5.02579361e-02f, -2.50191204e-02f, -1.96280628e-02f, -1.83082759e-01f, -1.15042083e-01f, -7.07781687e-02f, -4.59561450e-03f,
  -1.92055907e-02f, 7.79174343e-02f, 3.13986838e-02f, 5.34644499e-02f, 3.22916955e-02f, 6.72712997e-02f, -8.98615494e-02f, 1.47552704e-02f, 1.82153117e-02f, -9.34700444e-02f,
  7.23490939e-02f, 7.95448720e-02f, 1.32590964e-01f, 7.88727477e-02f, 1.15490712e-01f, 4.21873927e-02f, -1.19910300e-01f, -3.42650637e-02f, 5.38482107e-02f, 1.46629423e-01f,
  1.32339835e-01f, -6.72984915e-03f, 3.28799672e-02f, -5.08924611e-02f, -1.67438705e-02f, -9.93993729e-02f, 1.22068531e-03f, 1.23515747e-01f, 7.06378222e-02f, 3.10638938e-02f,
  7.77752101e-02f, -1.27193436e-01f, 7.33340681e-02f, 1.20640568e-01f, -2.27816310e-02f, 8.41896385e-02f, 5.34900976e-03f, 1.29719138e-01f, 2.95135435e-02f, 1.57272652e-01f,
  2.82455571e-02f, 5.11021279e-02f, -3.05643771e-02f, 1.34248450e-01f, -1.78418513e-02f, 7.86689073e-02f, -9.96984914e-02f, 4.37148474e-02f, -9.55322608e-02f, 2.46696901e-02f,
  2.85769738e-02f, 1.26778081e-01f, -1.34693697e-01f, 9.77495611e-02f, -6.01734035e-02f, -1.90026611e-01f, 6.03927933e-02f, -2.50831451e-02f, -2.55014580e-02f, -1.07018925e-01f,
  1.97386056e-01f, -3.36151093e-01f, 2.15974018e-01f, 4.34513867e-01f, 3.12498480e-01f, -5.12573719e-01f, 6.33487552e-02f, -1.69687867e-01f, 9.60038006e-02f, -3.70231658e-01f,
  4.51859236e-01f, -1.76006198e-01f, 1.26844376e-01f, 1.48255900e-01f, 2.11964890e-01f, 1.53181240e-01f, -1.30786389e-01f, -1.78221241e-01f, -5.97287081e-02f, -2.15269681e-02f,
  1.65223762e-01f, 1.31523520e-01f, 2.27349699e-01f, -2.71111220e-01f, 2.24988423e-02f, -1.38937294e-01f, 6.20924355e-03f, 5.63725010e-02f, -2.52882719e-01f, 1.09772095e-02f,
  -1.66203707e-01f, 2.62067765e-01f, 1.40152112e-01f, -1.85095653e-01f, -1.30623996e-01f, 1.10561261e-02f, 8.50601196e-02f, 1.46719828e-01f, 1.09022632e-01f, -1.37483582e-01f,
  -8.67568403e-02f, 3.34944874e-02f, -8.21074620e-02f, -3.51483794e-03f, 4.35325988e-02f, 2.30199017e-04f, -1.21737286e-01f, -5.84094189e-02f, 9.45916995e-02f, -2.10706126e-02f,
  1.83262944e-01f, -7.75740892e-02f, 1.35170251e-01f, -1.25731066e-01f, 3.04193255e-02f, 9.89479125e-02f, -5.07296063e-02f, -8.23644549e-03f, -8.27047974e-02f, 6.17071404e-04f,
  1.35785744e-01f, 1.04028806e-01f, 2.80486308e-02f, 8.73460472e-02f, 2.43726019e-02f, 1.53412417e-01f, -2.03845333e-02f, -1.15197301e-01f, -6.19898103e-02f, -1.49946064e-02f,
  -7.95065705e-03f, 1.33558884e-01f, 2.81354189e-02f, -3.57476585e-02f, -6.00461029e-02f, 2.08694628e-03f, 6.53456151e-02f, -1.26451686e-01f, 2.19403990e-02f, 1.83014236e-02f,
  1.41294077e-01f, 4.12432896e-03f, -4.50684130e-03f, 3.04594003e-02f, -9.42663178e-02f, 6.37551993e-02f, -6.80421516e-02f, -8.07200968e-02f, 6.78497404e-02f, 4.12947871e-02f,
  -5.09394348e-01f, -2.28987888e-01f, 3.46104205e-02f, -1.01000495e-01f, 1.42949668e-03f, -1.99456438e-02f, 2.89112385e-02f, -1.65635645e-01f, -1.17896818e-01f, -2.70168185e-02f,
  -2.39417359e-01f, -6.74471557e-02f, -6.89135119e-02f, -1.16561703e-01f, -6.67362586e-02f, 1.25461757e-01f, 4.53678332e-02f, -1.18377902e-01f, 9.75612551e-02f, -1.73673391e-01f,
  3.46199051e-02f, 5.44174314e-02f, -2.25006025e-02f, 3.40676978e-02f, -8.92185569e-02f, -1.84348896e-02f, -6.06249906e-02f, 2.98131686e-02f, -1.05517335e-01f, -1.64197814e-02f,
  -1.46393344e-01f, -3.44881862e-01f, -3.47642094e-01f, -2.21722070e-02f, 2.99261600e-01f, -2.45262951e-01f, -3.33824068e-01f, -9.65924654e-03f, 1.28322184e-01f, -1.26508370e-01f,
  -1.19611628e-01f, -1.81548387e-01f, -3.12160909e-01f, -2.05324590e-01f, -9.59693417e-02f, -3.47424716e-01f, -1.84741974e-01f, -1.41443655e-01f, -2.70479321e-02f, -1.49704173e-01f,
  -7.17647821e-02f, 1.21830001e-01f, -1.70562670e-01f, 3.05671185e-01f, -1.83901280e-01f, 2.36778587e-01f, 2.36740485e-01f, 1.06475815e-01f, 2.91538667e-02f, 2.73889638e-02f,
  -2.09556427e-02f, -2.44528621e-01f, -1.29593268e-01f, -7.36482162e-03f, 4.15269732e-02f, -8.01582634e-03f, 9.83860418e-02f, -6.03179485e-02f, -5.06539270e-02f, -8.92424956e-02f,
  8.46187249e-02f, 9.37386453e-02f, 8.26422349e-02f, 5.54764718e-02f, -9.48081631e-03f, 1.84382987e-03f, 3.79149765e-02f, 5.45661012e-03f, -8.20500106e-02f, -1.97633654e-01f,
  -6.34285286e-02f, -1.30011290e-01f, 4.63078544e-02f, -2.76990272e-02f, -5.63599803e-02f, 6.40177876e-02f, -2.95183640e-02f, -1.33453384e-01f, 1.59807220e-01f, 7.87734389e-02f,
  5.45914173e-02f, 2.32473481e-02f, -1.05975747e-01f, -4.91326936e-02f, -2.69116350e-02f, 9.97835696e-02f, 1.08258277e-01f, -2.55053863e-02f, 1.51568919e-01f, 9.82593093e-03f,
  9.14199650e-02f, 5.66041283e-02f, 1.17655143e-01f, -3.85498442e-02f, -1.33629844e-01f, -2.61060242e-02f, -9.14152786e-02f, 3.17795575e-02f, 6.95675835e-02f, 1.34126488e-02f,
  -4.47489545e-02f, -5.51956967e-02f, -5.16505502e-02f, 1.06747702e-01f, 5.72664030e-02f, 6.54729381e-02f, -2.56021675e-02f, -1.67675108e-01f, 1.24018379e-01f, -8.51629749e-02f,
  4.11301851e-02f, -1.53451309e-01f, -6.96205348e-02f, 1.30846515e-01f, 3.37056741e-02f, -7.06250742e-02f, -2.22601164e-02f, -7.80703872e-03f, -5.24356738e-02f, -9.78228822e-02f,
  1.32612377e-01f, 9.08890590e-02f, 8.52719024e-02f, 5.95772564e-02f, 5.95506281e-02f, -1.68453142e-01f, 1.40335664e-01f, 5.60373366e-02f, 6.81506395e-02f, 7.36866146e-02f,
  1.01847917e-01f, -2.61033326e-03f, 2.85401847e-02f, 7.02249408e-02f, -2.38127131e-02f, 8.78901035e-03f, 4.65984195e-02f, -1.02797493e-01f, 8.63970444e-02f, -2.22777985e-02f,
  3.36737931e-01f, -7.13273063e-02f, -7.20588714e-02f, 1.93881959e-01f, -2.12601095e-01f, -2.10972920e-01f, -2.45072901e-01f, -5.85465282e-02f, -3.07609767e-01f, -2.31874079e-01f,
  -7.07079396e-02f, 1.45209223e-01f, -8.95377249e-02f, 2.58090049e-01f, 3.70961308e-01f, 9.71195176e-02f, 2.44711593e-01f, 6.04095384e-02f, -4.21330817e-02f, 1.84504420e-01f,
  1.52089983e-01f, 3.40241700e-01f, 2.62982726e-01f, 1.63849816e-01f, 1.56194434e-01f, 1.60184264e-01f, 2.79896468e-01f, 3.73007841e-02f, 1.38637096e-01f, 1.14739031e-01f,
  -2.08458155e-02f, 3.52435969e-02f, -2.09522154e-03f, 1.64023899e-02f, 5.00807613e-02f, -7.43603930e-02f, -1.03684105e-01f, 1.79600179e-01f, -4.65226173e-03f, -4.02077287e-03f,
  1.14749178e-01f, 1.00849032e-01f, 8.61715153e-02f, 6.09151125e-02f, -8.66521336e-03f, -2.85772271e-02f, -9.19402316e-02f, -1.33134782e-01f, -7.76026100e-02f, -1.21185472e-02f,
  8.81705526e-03f, -1.98799185e-02f, 4.30272147e-02f, 3.14377993e-02f, -4.83865337e-03f, -3.73952053e-02f, -2.87591061e-03f, -1.77335460e-02f, -4.55719046e-02f, 4.25946489e-02f,
  2.35825330e-02f, -7.02358261e-02f, 5.30284159e-02f, -1.35599151e-01f, 3.69719369e-03f, -1.65862478e-02f, 3.49668525e-02f, -3.98886157e-03f, -7.34791532e-02f, -1.19650941e-02f,
  3.78154814e-02f, 2.42250636e-02f, -3.39730047e-02f, -1.51862979e-01f, 6.66404888e-02f, 8.25871155e-03f, -5.37397265e-02f, 7.13912845e-02f, -1.05896823e-01f, -1.02450818e-01f,
  -2.56170090e-02f, 8.89903903e-02f, -7.05776736e-02f, -6.45779446e-02f, -1.21457808e-01f, -4.34115604e-02f, 1.00987370e-03f, 4.18050028e-02f, 2.14239638e-02f, 2.64955554e-02f,
  -1.44000659e-02f, 2.16644824e-01f, -3.73325869e-02f, -5.44581562e-02f, -3.13297100e-02f, 1.57431252e-02f, 4.15246338e-02f, -4.44685780e-02f, 1.09128967e-01f, 8.68322328e-02f,
  9.62755382e-02f, 1.83523558e-02f, 7.91382790e-03f, 1.09626576e-02f, -3.60781215e-02f, -8.26721862e-02f, 6.03169538e-02f, 4.93754670e-02f, 8.48367587e-02f, 9.43323895e-02f,
  2.78402884e-02f, -3.82582308e-03f, 1.53269321e-01f, -1.06530160e-01f, 2.88811326e-02f, 4.41174675e-03f, 6.46647811e-02f, -1.37575909e-01f, 1.13868773e-01f, -7.40373060e-02f,
  5.05725406e-02f, -3.62217985e-02f, -2.00017840e-01f, -7.72925913e-02f, -2.33793482e-01f, -1.93430722e-01f, -1.21966057e-01f, -2.02962026e-01f, -1.51849519e-02f, 2.32912570e-01f,
  1.59223840e-01f, 1.57152325e-01f, -1.83822755e-02f, 3.60887170e-01f, -2.97441870e-01f, 2.71286160e-01f, 4.21037152e-02f, 3.20183456e-01f, 6.46680295e-02f, -1.85904220e-01f,
  -9.31391343e-02f, 5.69713823e-02f, 2.07911044e-01f, -1.27977833e-01f, -4.43115756e-02f, 5.90505898e-02f, 1.56251699e-01f, -6.44361079e-02f, 2.11604267e-01f, 3.33415531e-02f,
  1.04983248e-01f, 5.63852564e-02f, -1.32909209e-01f, 6.07306808e-02f, -8.89781937e-02f, -1.68457045e-03f, 3.31377275e-02f, 2.00800579e-02f, -8.08648020e-02f, -1.60393901e-02f,
  1.78386513e-02f, -8.33401531e-02f, -5.42795137e-02f, -1.03556655e-01f, 1.41372764e-02f, 1.92953274e-02f, -5.70956469e-02f, 1.49694666e-01f, -4.71472405e-02f, 1.46106362e-01f,
  -4.87123318e-02f, 1.67075574e-01f, 7.88602903e-02f, 8.09396384e-04f, -1.10058114e-01f, -7.97834322e-02f, 9.77761522e-02f, 3.81374732e-02f, 7.56492838e-02f, -1.21490054e-01f,
  -7.95589387e-02f, 1.30735133e-02f, -6.62718564e-02f, 8.01134184e-02f, -7.68321529e-02f, -5.81415519e-02f, -5.33310510e-02f, 1.53013870e-01f, -8.86460990e-02f, 2.45796647e-02f,
  -1.84340812e-02f, -5.74407242e-02f, -1.88098662e-02f, 5.79558611e-02f, 7.53744785e-03f, 9.68059525e-02f, -7.11245015e-02f, -2.82283071e-02f, -1.17534986e-02f, 3.48956175e-02f,
  4.78240028e-02f, -2.35052276e-02f, -7.02111050e-02f, 1.23023696e-01f, 1.54842675e-01f, -5.37072495e-02f, 8.21012557e-02f, -2.80702468e-02f, -7.59183317e-02f, -6.47833422e-02f,
  1.63708422e-02f, -1.00683495e-01f, -3.10150273e-02f, 6.74347505e-02f, 4.52340581e-02f, -2.47580465e-02f, 7.22832158e-02f, -2.89454423e-02f, 1.00589276e-03f, -9.69421491e-02f,
  1.71270575e-02f, 3.17921750e-02f, 6.89785974e-03f, 4.12163995e-02f, -4.08682972e-02f, -1.92698166e-02f, 9.23872963e-02f, 1.36894748e-01f, 6.48596361e-02f, 3.95609438e-02f,
  4.55732271e-02f, -8.77683237e-02f, 7.26390108e-02f, -1.03522114e-01f, 1.00705579e-01f, -3.05921473e-02f, -9.46224183e-02f, -2.75630001e-02f, -3.84549536e-02f, 6.99803159e-02f,
  -1.46437943e-01f, -3.52989733e-02f, 8.83547664e-02f, 2.63128817e-01f, -2.38642886e-01f, -1.36217043e-01f, -8.97546113e-02f, -1.23956494e-01f, -2.37760827e-01f, -7.97010958e-02f,
  2.56452728e-02f, 3.74305733e-02f, -3.21785152e-01f, 2.81334251e-01f, 3.54310721e-01f, -9.00013000e-02f, 2.60316730e-01f, 8.73449519e-02f, -4.33027446e-02f, 1.12817168e-01f,
  9.84032676e-02f, 2.31186077e-01f, 1.09798603e-01f, 2.32276350e-01f, 6.52311370e-02f, 2.31355652e-01f, 1.95033908e-01f, 8.53793770e-02f, 3.98703307e-01f, 1.52151912e-01f,
  -6.52525621e-03f, 3.72072607e-02f, -8.23902264e-02f, -8.58682692e-02f, 7.89661407e-02f, 5.87269617e-03f, -2.65534613e-02f, 6.19740561e-02f, -4.15258035e-02f, 1.34627223e-01f,
  2.11254451e-02f, -2.64666928e-03f, 1.97422370e-01f, -4.59917821e-02f, -6.42249137e-02f, 4.47136164e-02f, -3.29382308e-02f, -8.73999149e-02f, -2.41348147e-03f, -1.13479294e-01f,
  -8.25014636e-02f, -9.69911665e-02f, 8.31301212e-02f, 4.76120301e-02f, 5.44240661e-02f, 2.26130337e-02f, 4.33895588e-02f, -2.04124711e-02f, 1.01031139e-01f, 6.79244846e-02f,
  4.79323715e-02f, -6.06537238e-02f, -3.52566014e-03f, -1.77393423e-03f, -1.93775129e-02f, 1.13273159e-01f, -5.22508547e-02f, 2.55612470e-02f, -4.48727794e-02f, 1.25702666e-02f,
  2.90573370e-02f, 8.38917401e-03f, 2.32028514e-02f, 3.71374004e-02f, 4.27525118e-02f, 3.26121561e-02f, -5.52781411e-02f, 1.35658488e-01f, 3.60175259e-02f, -3.79374661e-02f,
  -1.26724437e-01f, -3.35226618e-02f, -2.80417297e-02f, -1.02156639e-01f, -7.78386071e-02f, -6.80500641e-02f, 1.19257078e-01f, 3.43826339e-02f, 3.73033397e-02f, 4.10100855e-02f,
  6.39599189e-02f, 2.40758777e-01f, 3.63708138e-02f, 1.80737022e-02f, 5.18380068e-02f, 5.12609631e-02f, 5.18179163e-02f, 1.23795226e-01f, 1.47155106e-01f, 9.83794779e-02f,
  7.19397292e-02f, -1.58461034e-02f, -3.86247858e-02f, 4.44024093e-02f, 1.28243878e-01f, 4.81327213e-02f, -1.06690535e-02f, -8.36476982e-02f, 1.09745361e-01f, 1.35528952e-01f,
  6.41793907e-02f, -3.77954468e-02f, 1.40896514e-01f, -1.21918619e-01f, -3.10894214e-02f, 5.66554517e-02f, -1.02390777e-02f, 1.74725447e-02f, 6.48290515e-02f, 8.73738304e-02f,
  -5.30321300e-01f, 8.06439295e-02f, -2.35128954e-01f, -2.55021423e-01f, -1.29641578e-01f, -1.89920396e-01f, 2.13474005e-01f, -9.70176831e-02f, 9.92105622e-03f, 3.29391390e-01f,
  1.73417360e-01f, -2.48661377e-02f, 4.31715578e-01f, -2.56015897e-01f, -3.29445869e-01f, 2.49666139e-01f, -2.10270956e-01f, 5.40936328e-02f, 3.06930486e-02f, 1.15271844e-01f,
  -2.23987177e-01f, 5.77744246e-02f, -2.26133227e-01f, 9.49735381e-03f, -3.84132206e-01f, -2.07679436e-01f, 1.34621775e-02f, 8.24091658e-02f, -2.81627715e-01f, -3.50312322e-01f,
  -3.34529012e-01f, -9.93428379e-02f, 4.45491262e-02f, -1.58803388e-01f, -1.07531667e-01f, 3.28210518e-02f, -9.79639664e-02f, 1.34380057e-01f, -2.58307867e-02f, -3.63176577e-02f,
  4.80525903e-02f, -1.35931060e-01f, -1.58497810e-01f, 1.83412582e-02f, -6.84849322e-02f, -1.61512122e-01f, -1.74080357e-01f, -2.21463874e-01f, -2.42450181e-02f, -1.66300923e-01f,
  -3.74836139e-02f, -2.95356363e-02f, -1.73156232e-01f, 9.73497331e-03f, -1.83588043e-01f, -1.15405180e-01f, 1.15290880e-02f, -3.92393321e-02f, -2.12798923e-01f, -2.09052622e-01f,
  2.75359638e-02f, 1.89677075e-01f, 2.24619750e-02f, 1.77418794e-02f, 2.91423872e-03f, -1.51039913e-01f, 1.24255635e-01f, 1.44111156e-01f, -1.71688050e-01f, -2.19316501e-02f,
  -7.77542517e-02f, -2.20748670e-02f, -1.82908438e-02f, 8.74323159e-05f, -1.61151811e-02f, 1.29365370e-01f, 5.37948497e-03f, -5.06039411e-02f, -8.14328343e-02f, -1.72829106e-01f,
  5.57515174e-02f, -1.06950425e-01f, -3.60568613e-02f, -1.42740496e-02f, 8.05470198e-02f, -5.41241802e-02f, 7.72233978e-02f, 2.99117696e-02f, -5.30507118e-02f, -8.78875852e-02f,
  -3.62260848e-01f, -1.68635041e-01f, 4.86834235e-02f, -1.89937845e-01f, 9.42945629e-02f, 8.08502641e-03f, 1.52462244e-01f, -2.82901321e-02f, -1.66895509e-01f, 1.35644078e-01f,
  -2.96364035e-02f, -9.43071172e-02f, -8.44875649e-02f, 1.04010306e-01f, 1.08048931e-01f, -1.41571593e-02f, 1.42409608e-01f, 9.45414137e-03f, 1.04061097e-01f, 5.53593934e-02f,
  -1.47467414e-02f, 1.22398891e-01f, 2.46501416e-02f, 9.25344601e-02f, -4.66756038e-02f, -1.19059987e-01f, -4.10542004e-02f, -4.86170687e-02f, -1.63185999e-01f, -9.42306742e-02f,
  -7.84962177e-01f, 4.90690976e-01f, 3.49804252e-01f, -6.06161840e-02f, 3.09043471e-02f, -2.82434702e-01f, 1.97844971e-02f, 2.59475470e-01f, 4.61442381e-01f, 2.80254632e-01f,
  1.67592511e-01f, 5.50252944e-02f, 3.29197586e-01f, 2.59048015e-01f, -4.87877309e-01f, 3.27709287e-01f, -1.17900468e-01f, 8.77884589e-03f, 1.75456986e-01f, -1.55167906e-02f,
  -1.30711962e-02f, -4.30864356e-02f, 4.82474975e-02f, 2.40908653e-01f, 3.13505270e-02f, -5.29188700e-02f, -3.58831614e-01f, 3.40886474e-01f, -2.20850050e-01f, 1.01985158e-02f,
  -4.03058380e-01f, 1.78826824e-01f, -8.83688331e-02f, 1.75333899e-02f, -2.16585293e-01f, -1.56333461e-01f, -7.42098019e-02f, -4.19126041e-02f, 1.43076673e-01f, 3.92393060e-02f,
  -6.72920123e-02f, -2.87020318e-02f, 2.51650121e-02f, 1.47904724e-01f, 1.05558984e-01f, 1.80413499e-02f, 1.20868258e-01f, -1.10174611e-01f, 1.38797149e-01f, 7.75844418e-03f,
  6.53603971e-02f, 1.73025448e-02f, 5.59510514e-02f, -1.26498472e-02f, -6.58326373e-02f, 1.78594485e-01f, -9.02210400e-02f, -9.26633105e-02f, -6.05970509e-02f, -2.10506935e-02f,
  6.26382604e-02f, -3.43879722e-02f, 1.38868332e-01f, -3.67105268e-02f, -9.64344200e-03f, -6.69681048e-03f, 1.07622340e-01f, -1.14087239e-01f, 9.42707732e-02f, 3.46394582e-03f,
  -1.64349020e-01f, 3.29041341e-03f, -5.08074947e-02f, -7.65284523e-02f, 2.12499453e-03f, -6.23158971e-03f, -8.06115940e-02f, 2.47208271e-02f, -1.82235137e-01f, -5.21491356e-02f,
  7.54623935e-02f, 1.03740273e-02f, 5.72770573e-02f, -1.73092470e-01f, 5.45562245e-02f, 3.80908102e-02f, 6.65130746e-03f, 9.73995328e-02f, -8.14409554e-02f, -1.49846628e-01f,
  -4.64058697e-01f, 1.99360564e-01f, 1.07752658e-01f, 7.57449940e-02f, 1.27279945e-02f, 2.63622701e-02f, -2.74014454e-02f, -1.95259646e-01f, 1.09570153e-01f, -3.64729278e-02f,
  -4.56810631e-02f, -8.20864961e-02f, -2.13515982e-01f, -3.44289723e-03f, -1.15780775e-02f, -8.64121318e-02f, -9.29963887e-02f, 8.97529870e-02f, -1.71267927e-01f, -1.32713944e-01f,
  -6.21288456e-02f, -2.80777607e-02f, -5.90734743e-02f, 7.51391426e-03f, -1.29484579e-01f, -5.80439083e-02f, -1.70457084e-02f, -9.43040662e-03f, -5.35550416e-02f, 7.46782050e-02f,
  2.24691883e-01f, -2.89788455e-01f, 2.21795946e-01f, 2.87283748e-01f, 3.16499500e-03f, 3.04983348e-01f, 3.42015177e-01f, -2.11403713e-01f, 2.42970022e-03f, -2.48433053e-01f,
  -2.91535437e-01f, 4.06339645e-01f, -2.18440607e-01f, 9.32907034e-03f, 3.74747485e-01f, -1.42549589e-01f, 1.69040233e-01f, 2.08976716e-01f, 4.49583940e-02f, 8.17041621e-02f,
  -9.97969508e-02f, -2.62488425e-01f, 3.29035409e-02f, -2.17030436e-01f, 4.19508144e-02f, 3.19796950e-02f, -2.53940105e-01f, 1.30942911e-01f, 4.09583747e-02f, 1.79631919e-01f,
  -8.35426375e-02f, -1.56654716e-01f, -1.25779390e-01f, -5.25973029e-02f, -1.72765985e-01f, 6.44655451e-02f, 1.05315030e-01f, 5.53237759e-02f, 1.98066290e-02f, 1.09860953e-03f,
  -6.95943981e-02f, 3.21166194e-03f, -1.26758162e-02f, 8.66759382e-03f, 7.71038607e-02f, 5.76362386e-02f, 2.22614710e-03f, -8.48989263e-02f, 8.37825909e-02f, 3.78353149e-02f,
  -1.21478982e-01f, -1.22607589e-01f, -2.05262713e-02f, -1.95601415e-02f, -4.85220365e-02f, 9.53413639e-03f, 6.45236149e-02f, 4.08966020e-02f, 1.38008296e-01f, 5.86555339e-02f,
  5.21325432e-02f, -1.09182961e-01f, -2.41754893e-02f, 1.00366093e-01f, 1.26918823e-01f, -4.62504849e-02f, 5.30811399e-02f, -1.49147153e-01f, 1.75417792e-02f, -1.08076669e-01f,
  7.78102875e-02f, 3.92437633e-03f, -1.09356686e-01f, -3.45367715e-02f, -5.20237908e-02f, 6.03058897e-02f, 7.69610107e-02f, -6.76205056e-03f, -9.97126326e-02f, -6.81875423e-02f,
  -6.84529766e-02f, -1.17077306e-02f, -1.53624266e-01f, 2.74282079e-02f, 5.05302548e-02f, -3.38853933e-02f, -1.66448623e-01f, 3.79956365e-02f, -6.92465752e-02f, -6.22979216e-02f,
  -2.85658866e-01f, -7.09183142e-02f, -5.41600548e-02f, -9.72044319e-02f, -2.65664272e-02f, -9.07317102e-02f, -1.57521721e-02f, -1.21933140e-01f, 6.29260093e-02f, 8.48487169e-02f,
  -2.28698156e-03f, -2.29999311e-02f, 1.78467529e-03f, 6.46218210e-02f, 1.73734874e-02f, -7.18623623e-02f, -6.66296035e-02f, -1.69711113e-01f, -9.37744081e-02f, -3.30308378e-02f,
  -7.21061453e-02f, -1.00628939e-02f, 5.60299307e-02f, -1.17072836e-01f, -1.32025912e-01f, -1.19290590e-01f, 5.73940612e-02f, 1.12721071e-01f, 1.47422682e-02f, 9.30879079e-03f,
  5.15753984e-01f, -3.23495924e-01f, -2.48770397e-02f, 3.01961064e-01f, 2.44911581e-01f, 1.92413762e-01f, 2.81325161e-01f, 2.97958888e-02f, 3.56863551e-02f, -3.77923995e-01f,
  8.98800343e-02f, -1.09112024e-01f, 9.84617621e-02f, 2.32265368e-01f, 2.90954411e-01f, 3.75839472e-02f, 1.20025493e-01f, -1.78094618e-02f, 1.44584300e-02f, 1.57204688e-01f,
  2.15381593e-01f, 1.19947009e-01f, 1.56659976e-01f, -2.58602262e-01f, 1.98393866e-01f, -1.91524580e-01f, -5.73395565e-02f, -4.45348732e-02f, -3.04926038e-01f, 7.03079477e-02f,
  6.25686496e-02f, 1.36901408e-01f, 1.10153705e-01f, -1.48972973e-01f, 1.35203660e-01f, 2.05163378e-02f, -9.57778543e-02f, 1.06363267e-01f, 1.19636461e-01f, 6.98402822e-02f,
  -1.43313063e-02f, -5.98949194e-03f, -1.91969369e-02f, 8.69576484e-02f, 1.14001781e-01f, 1.20415306e-02f, -3.79282124e-02f, -1.28035136e-02f, -7.03660026e-02f, 7.27937073e-02f,
  2.29560155e-02f, -8.83484632e-02f, 7.82502908e-03f, -1.41998559e-01f, 4.90953587e-02f, -3.35706770e-02f, -9.65699833e-03f, 9.87457763e-03f, -1.21695012e-01f, -2.49615833e-02f,
  1.36293462e-02f, -7.33448043e-02f, 8.57209861e-02f, -5.29010557e-02f, 1.71390116e-01f, -2.26819981e-02f, -5.83266839e-02f, 8.05041045e-02f, 4.33973186e-02f, 8.90471786e-02f,
  5.99847026e-02f, 2.11272780e-02f, -4.65634055e-02f, 4.60040756e-02f, -2.01586448e-02f, 9.71241668e-03f, -1.03148362e-02f, -4.72751819e-02f, 1.95282069e-03f, 9.22491029e-02f,
  -8.69949088e-02f, 5.87778986e-02f, -4.77903709e-02f, 3.96795273e-02f, 1.17846346e-02f, 1.17377609e-01f, -7.03782886e-02f, -1.01132980e-02f, -1.95756536e-02f, 9.48128349e-04f,
  -1.06498614e-01f, -2.64161438e-01f, -6.47278577e-02f, -2.38842182e-02f, -3.60177197e-02f, 9.60918814e-02f, -6.38590083e-02f, 5.19252270e-02f, -4.48393561e-02f, 1.11866683e-01f,
  -3.78296189e-02f, -1.18256636e-01f, -1.22608766e-01f, -4.02058214e-02f, -1.92897514e-01f, 4.72408570e-02f, -1.13540880e-01f, -7.83992857e-02f, 4.95471545e-02f, -3.17074470e-02f,
  -4.88296561e-02f, 7.22972676e-02f, 5.15651947e-04f, 9.04595852e-02f, -8.42844993e-02f, -2.17243005e-03f, -5.65198399e-02f, -1.47327960e-01f, -9.03013349e-03f, -1.17622629e-01f,
  -3.88059407e-01f, 1.69958845e-01f, 3.29366446e-01f, -5.77650443e-02f, -5.94290309e-02f, 5.22332072e-01f, 3.90296131e-01f, -2.54068434e-01f, -7.23244995e-02f, 8.04820377e-03f,
  -7.02087432e-02f, 2.29752451e-01f, -6.61418363e-02f, 7.17193559e-02f, 4.51434016e-01f, 1.15896493e-01f, 1.69177085e-01f, 1.60129353e-01f, -1.61047019e-02f, -2.58707047e-01f,
  -2.89843470e-01f, 9.65079665e-02f, 2.65660044e-02f, -1.62434965e-01f, 1.92045331e-01f, -2.00393274e-02f, -4.25675325e-02f, 1.50587305e-01f, 2.38962770e-01f, 2.76703686e-01f,
  2.32615485e-03f, -1.71812937e-01f, -4.76076826e-02f, 9.98632535e-02f, -7.80418068e-02f, 4.70387638e-02f, 2.34716028e-01f, 2.73133844e-01f, -2.68082544e-02f, 5.74121475e-02f,
  -1.90805960e-02f, -2.87490548e-03f, 5.58946515e-03f, 3.21321301e-02f, -1.50948018e-01f, -2.49663480e-02f, -1.43913459e-02f, 3.04891802e-02f, 2.38929372e-02f, -2.21393462e-02f,
  -7.33694481e-03f, -1.84634868e-02f, -8.91429782e-02f, 2.11188927e-01f, 2.88437232e-02f, 6.45950362e-02f, 1.71434097e-02f, -3.45371524e-03f, 6.98160306e-02f, 1.16745278e-01f,
  -6.06168360e-02f, 8.83483663e-02f, -1.80712596e-01f, -1.08490132e-01f, 2.62080990e-02f, 2.71694758e-03f, -3.34058814e-02f, -1.63789168e-01f, 6.16686195e-02f, 1.00157626e-01f,
  -1.27474412e-01f, -8.97152945e-02f, -3.71211842e-02f, -8.78621649e-04f, -9.79967713e-02f, -1.65446520e-01f, -9.13908258e-02f, 9.97211784e-02f, -7.71051925e-03f, 5.02565084e-03f,
  7.83490203e-03f, 7.28052631e-02f, -1.89529303e-02f, -3.30776498e-02f, -3.14090103e-02f, -1.05171129e-01f, -3.02030388e-02f, 6.54752180e-02f, -1.59656584e-01f, 7.76397288e-02f,
  2.30586365e-01f, 2.44531229e-01f, -8.48385766e-02f, -5.81356771e-02f, -1.84322089e-05f, 8.58128145e-02f, 1.41243008e-03f, -4.14701886e-02f, -1.95440161e-03f, -1.05117701e-01f,
  -1.01263501e-01f, -1.33645292e-02f, -4.39464813e-03f, -1.03718974e-02f, -6.49682200e-03f, -8.51383880e-02f, -2.41132863e-02f, 4.48675193e-02f, 1.22040296e-02f, -1.29794300e-01f,
  1.34547487e-01f, -4.09437381e-02f, 4.78067212e-02f, 4.33407575e-02f, -1.11258760e-01f, 1.65880740e-01f, -6.24530166e-02f, -7.14068189e-02f, 4.72094975e-02f, 1.66456029e-01f,
  3.82680684e-01f, -2.04902977e-01f, -2.12603912e-01f, 2.27769896e-01f, 2.19783217e-01f, -7.96315148e-02f, -3.82070690e-01f, 1.54114872e-01f, -1.61121517e-01f, -2.52497822e-01f,
  -5.32335974e-02f, -6.33777678e-02f, -2.61701375e-01f, 2.91316569e-01f, 4.33187932e-01f, -6.95512220e-02f, 4.61002529e-01f, 7.48458207e-02f, 2.92554405e-02f, 1.67464033e-01f,
  3.78635466e-01f, 3.44081670e-01f, 3.35735500e-01f, 3.59385908e-01f, 2.77873755e-01f, 1.04098350e-01f, 1.60541207e-01f, -1.47329301e-01f, 1.89535707e-01f, 2.25931123e-01f,
  -1.23670362e-02f, 8.46418068e-02f, 5.72591573e-02f, 2.17841789e-02f, 6.98713511e-02f, -2.44176406e-02f, -5.00714630e-02f, 4.02016453e-02f, -4.16185744e-02f, -1.39146045e-01f,
  -5.78026287e-02f, 1.86859697e-01f, 6.10236563e-02f, 3.25803272e-03f, 9.36743617e-03f, -6.26721606e-02f, 5.12914248e-02f, -1.03458986e-01f, -6.48803785e-02f, 4.12487537e-02f,
  -7.83943906e-02f, -5.48887178e-02f, -4.48475964e-02f, -3.59895565e-02f, -9.71687287e-02f, -1.02317696e-02f, -1.03741817e-01f, -5.32544926e-02f, -3.32868099e-02f, 8.48321542e-02f,
  7.30793700e-02f, -2.60032564e-02f, -8.02888442e-03f, -4.24417481e-02f, -1.03645511e-01f, 1.49644250e-02f, -8.42766687e-02f, -1.27565175e-01f, -5.03618680e-02f, 4.16950732e-02f,
  -8.67021680e-02f, 2.05660760e-02f, -8.20905641e-02f, -3.74838151e-02f, 3.92378010e-02f, 9.27980915e-02f, -5.76563887e-02f, -1.67694055e-02f, -8.83546472e-02f, -2.54746396e-02f,
  -4.30616736e-03f, -3.65184285e-02f, -6.13952763e-02f, 8.42679963e-02f, 2.52880640e-02f, -2.24748664e-02f, -5.93222454e-02f, -2.16204161e-03f, 3.35942097e-02f, 3.49348299e-02f,
  -3.22877020e-02f, 1.06326766e-01f, -5.60550764e-02f, -4.18814309e-02f, -1.19096406e-01f, 6.15831688e-02f, 1.84322707e-02f, 5.71025610e-02f, 2.97309877e-03f, 9.66408998e-02f,
  1.02399565e-01f, 4.05778252e-02f, 2.00279988e-02f, 4.95298579e-02f, 8.73777196e-02f, -4.12825420e-02f, -2.58152224e-02f, 4.08695592e-03f, 7.09366798e-02f, -6.54488686e-05f,
  -1.95220131e-02f, -8.48370567e-02f, 4.57950383e-02f, 1.96367223e-02f, 1.01595707e-02f, -3.79175879e-02f, 2.93490198e-03f, 2.29423326e-02f, 2.08687782e-03f, -8.63125101e-02f,
  2.17082784e-01f, -6.53017908e-02f, -4.02426839e-01f, -2.71299452e-01f, 1.15363903e-01f, 1.71662226e-01f, -3.15367468e-02f, 5.61395884e-02f, -2.95101285e-01f, 1.99869826e-01f,
  1.78581506e-01f, -1.28357783e-01f, -7.76378661e-02f, -3.72619331e-02f, 1.18220940e-01f, -2.44379133e-01f, 1.98765546e-01f, 2.88063921e-02f, -2.76002556e-01f, 3.61155868e-01f,
  4.76851016e-02f, 3.24936241e-01f, -2.75390089e-01f, 1.90230012e-01f, 2.95111895e-01f, -2.72086938e-03f, 3.65362644e-01f, -8.40196088e-02f, 2.19787806e-01f, 1.10406600e-01f,
  -2.70096920e-02f, -2.52176579e-02f, -5.36015481e-02f, -4.89714108e-02f, 7.12842271e-02f, 1.43270940e-02f, 6.29720613e-02f, 4.27485295e-02f, -5.80422655e-02f, -1.02766626e-01f,
  1.46677718e-01f, -5.56756631e-02f, 9.26200897e-02f, -8.80761445e-02f, 8.58725421e-03f, -5.68893850e-02f, -1.16119638e-01f, 2.12030206e-03f, -2.08954990e-01f, -1.98534224e-02f,
  -8.06378424e-02f, 3.45226675e-02f, 3.14926878e-02f, -3.77519196e-03f, -1.76682193e-02f, 3.67604047e-02f, -5.92658520e-02f, -5.88042894e-03f, 2.81495024e-02f, -7.29025342e-03f,
  1.75446466e-01f, 1.00008346e-01f, 6.06812797e-02f, -5.46263009e-02f, -1.49474576e-01f, -7.38611519e-02f, -1.76381879e-02f, -7.45193064e-02f, -6.57550693e-02f, 3.80024780e-03f,
  8.33799597e-03f, 4.01326269e-02f, -6.49644136e-02f, 7.56807551e-02f, 7.54903257e-02f, 1.46934483e-02f, 7.43887872e-02f, 9.26264748e-02f, -1.10293657e-01f, -1.35241970e-01f,
  -1.12176403e-01f, -7.60701075e-02f, -2.18165759e-02f, 6.04344951e-03f, 2.30833516e-02f, -2.33747344e-02f, 1.60789758e-01f, -5.94943650e-02f, -3.80738080e-02f, 1.38586074e-01f,
  1.41489759e-01f, 2.79841095e-01f, -1.27526730e-01f, 5.19946171e-03f, -1.02884501e-01f, 1.26366854e-01f, -3.91276181e-02f, 5.08719087e-02f, 1.91918295e-02f, 1.34894073e-01f,
  2.02207446e-01f, -1.23990020e-02f, 1.59757853e-01f, -6.69588223e-02f, -6.84861317e-02f, 1.72297359e-01f, 9.73586291e-02f, -1.27870172e-01f, 2.51215398e-02f, 7.83630237e-02f,
  8.99714977e-02f, 4.86568138e-02f, 7.46199265e-02f, 3.39690084e-03f, -7.27593200e-03f, 1.09036006e-01f, 6.98316172e-02f, -7.25661684e-03f, 7.25937337e-02f, -1.23556349e-02f,
  1.66683912e-01f, 2.38926858e-01f, 2.56507128e-01f, -2.26135794e-02f, 1.73140898e-01f, 3.81125003e-01f, 1.90726206e-01f, 7.04821385e-03f, 3.01484287e-01f, -3.10329497e-01f,
  -4.37744439e-01f, 1.00818641e-01f, 4.94684167e-02f, -1.63515389e-01f, 1.33648604e-01f, 1.00636855e-01f, -1.03329413e-01f, -1.00026555e-01f, 1.00022249e-01f, -2.89895654e-01f,
  -1.24310464e-01f, -2.70303816e-01f, -4.64443080e-02f, -2.69504428e-01f, -2.74457544e-01f, -4.58210371e-02f, -3.57532650e-01f, -4.84847203e-02f, -2.15320915e-01f, 3.28436308e-02f,
  2.04009652e-01f, 1.16303481e-01f, 1.60648972e-01f, 4.36780900e-02f, 1.40978158e-01f, 2.10129693e-02f, -1.82731271e-01f, 7.15889111e-02f, 1.15880258e-01f, 2.02499796e-02f,
  -4.20075692e-02f, 4.72855680e-02f, 6.23055436e-02f, 3.28719653e-02f, -4.21238877e-02f, 3.21913883e-02f, 1.92986464e-03f, 2.66864616e-03f, 2.99911574e-02f, 5.89119382e-02f,
  -6.63442956e-03f, 1.24044679e-01f, 5.91708943e-02f, -1.60042465e-01f, -9.62196812e-02f, 9.76807252e-02f, 8.10805038e-02f, 5.22529613e-03f, -5.16457222e-02f, 1.27613768e-01f,
  -6.12462871e-04f, 1.01161130e-01f, 7.48589039e-02f, 1.10541604e-01f, -7.80351013e-02f, -1.29925504e-01f, -4.45119180e-02f, -3.09080258e-02f, 6.19720258e-02f, -6.36296049e-02f,
  8.48054364e-02f, 1.34460866e-01f, 2.32444946e-02f, -5.37306853e-02f, -9.86620113e-02f, 5.48634902e-02f, -1.19713154e-02f, -1.31046802e-01f, -8.34603757e-02f, -1.67972092e-02f,
  -3.14945392e-02f, -1.15919210e-01f, 5.54115735e-02f, -1.64519966e-01f, 4.98306304e-02f, 1.00101642e-01f, -4.49915752e-02f, -8.29817541e-03f, 4.24141809e-02f, -5.14674187e-02f,
  5.59769943e-02f, -4.21552435e-02f, 1.08827092e-01f, -1.42917186e-01f, 5.61220478e-03f, 9.56451073e-02f, -3.76585387e-02f, -1.64315760e-01f, 1.12439059e-01f, -1.28842086e-01f,
  -2.05917180e-01f, -7.48543367e-02f, -9.27162990e-02f, 4.83987443e-02f, -9.33017731e-02f, -8.54180530e-02f, -1.26989573e-01f, -9.22918618e-02f, -9.79224890e-02f, -1.51184097e-01f,
  -1.90525472e-01f, -1.06727973e-01f, 1.55279227e-02f, -6.07720427e-02f, -2.26787999e-01f, -2.55343301e-04f, -7.38942102e-02f, 5.62597141e-02f, -5.47069721e-02f, 4.07628305e-02f,
  2.01419443e-01f, 1.01362713e-01f, -1.00225117e-02f, 2.30149366e-02f, -1.11891255e-01f, -3.14732015e-01f, -2.95600325e-01f, -3.29181738e-03f, -4.28994633e-02f, -4.91876304e-02f,
  -5.45871146e-02f, 2.78885141e-02f, 7.72866011e-02f, -1.37947023e-01f, 4.04656045e-02f, -1.85927629e-01f, -1.48671299e-01f, -1.97544664e-01f, 3.76746501e-03f, 5.65850660e-02f,
  7.48654604e-02f, -7.43523464e-02f, 2.20937222e-01f, 1.74215641e-02f, -2.09722761e-02f, 2.38934606e-01f, 3.38024855e-01f, -3.86023149e-02f, -9.47640240e-02f, -1.87616184e-01f,
  -7.42346644e-02f, 1.35902643e-01f, -8.52955505e-02f, -4.76149879e-02f, 6.99965060e-02f, -8.72360244e-02f, -7.34998509e-02f, 6.80450723e-02f, 8.94583687e-02f, -9.08516496e-02f,
  6.00913242e-02f, 1.59878749e-02f, -1.15573764e-01f, 1.61037520e-02f, -4.41322736e-02f, 3.99332494e-03f, 1.30091384e-01f, 9.65878963e-02f, -7.63998553e-03f, 6.37656599e-02f,
  5.32505736e-02f, 1.39479652e-01f, 5.42596430e-02f, -3.51654999e-02f, 1.43453240e-01f, -1.34945035e-01f, 2.71870308e-02f, 7.77872726e-02f, 1.80971492e-02f, -8.78978579e-04f,
  3.63534465e-02f, 1.15120364e-02f, -7.50708580e-02f, -1.19736843e-01f, -4.71072420e-02f, -4.28302661e-02f, 5.97915985e-02f, 7.17273504e-02f, -3.50832306e-02f, -1.14071146e-01f,
  -4.29161787e-02f, 2.05189269e-02f, -1.12915680e-01f, -6.40918761e-02f, -3.53486091e-02f, 1.81110278e-01f, -1.10780135e-01f, -3.29181179e-02f, 3.73822227e-02f, -1.16061550e-02f,
  -4.38175118e-03f, -2.77241580e-02f, -5.88358045e-02f, 7.21821934e-02f, -8.63025635e-02f, 8.97061899e-02f, 9.25184041e-02f, -8.09969753e-02f, 6.63026869e-02f, 4.38320003e-02f,
  1.36448990e-03f, 1.00237116e-01f, -3.57645415e-02f, -5.09058386e-02f, -1.29639381e-03f, -9.19029638e-02f, 4.25592717e-03f, -5.55683412e-02f, 1.05075948e-01f, -5.61963357e-02f,
  -5.07426634e-02f, -4.62269932e-02f, -1.51358873e-01f, 1.14380203e-01f, -6.62439167e-02f, -2.57767346e-02f, 2.19803695e-02f, 5.16291298e-02f, 3.31335254e-02f, 1.66632816e-01f,
  3.21464688e-02f, 9.37090218e-02f, -1.62256118e-02f, -2.35369429e-02f, 1.05027944e-01f, 4.94987555e-02f, -3.41628641e-02f, 4.80777808e-02f, 1.26446679e-01f, 6.29024357e-02f,
  -6.39254227e-02f, 1.53101012e-01f, -3.02845627e-01f, -2.16984019e-01f, 3.68367732e-02f, -2.75706798e-01f, -2.58868903e-01f, 5.58445975e-02f, 1.34918779e-01f, 1.54001817e-01f,
  -2.36315858e-02f, 2.34687924e-01f, 3.42006654e-01f, -2.98871517e-01f, -4.38441157e-01f, 2.81305946e-02f, -3.83834094e-01f, -2.17378870e-01f, 1.51905477e-01f, -2.11432278e-01f,
  -1.95232213e-01f, -1.94244444e-01f, -2.77082086e-01f, 1.69172674e-01f, -2.94194132e-01f, -9.22620371e-02f, -2.43392643e-02f, 2.09776744e-01f, -4.14439678e-01f, 2.79793497e-02f,
  -1.38256073e-01f, 2.37387851e-01f, -2.85360683e-02f, -2.00113971e-02f, -1.85072422e-01f, -1.34853065e-01f, -1.34744078e-01f, 8.71182531e-02f, 6.85582906e-02f, 1.40590239e-02f,
  1.34313479e-03f, 6.33314401e-02f, 8.72525647e-02f, 8.90357122e-02f, -2.23385580e-02f, 2.09348146e-02f, 5.58730736e-02f, -4.63213176e-02f, 3.39909755e-02f, -2.98694931e-02f,
  6.42473157e-03f, -1.51253030e-01f, -1.56627983e-01f, 7.49161141e-03f, 7.25289211e-02f, -3.42367624e-04f, -4.79254536e-02f, -8.06763694e-02f, -1.06497042e-01f, -5.59622534e-02f,
  -6.43958747e-02f, 3.06612998e-03f, -2.92372666e-02f, -6.64004460e-02f, 8.96917582e-02f, 8.56675580e-02f, 3.39415073e-02f, 6.62170649e-02f, 2.98584644e-02f, 2.41124257e-02f,
  -6.39898032e-02f, 8.98193419e-02f, -1.28014768e-02f, -1.18208408e-01f, -5.37939183e-02f, 1.79753900e-02f, -7.79829919e-02f, 1.24681421e-01f, -1.78783178e-01f, -1.79030865e-01f,
  6.47746399e-02f, -1.23444714e-01f, 1.67866752e-01f, -4.17492464e-02f, -1.31464526e-01f, 8.27936381e-02f, -3.27991247e-02f, -1.25636645e-02f, -4.71802056e-02f, -4.42444570e-02f,
  -2.63055693e-02f, 1.37229741e-01f, 7.97499865e-02f, 5.37409335e-02f, -2.53137983e-02f, 2.10571177e-02f, -1.79886166e-02f, -1.21462338e-01f, -4.48687933e-02f, 7.38933906e-02f,
  -7.99331143e-02f, 6.18733242e-02f, -1.56877488e-01f, 1.89919528e-02f, 7.94957951e-03f, -1.38541266e-01f, 5.57222739e-02f, 1.19277634e-01f, -7.07185939e-02f, 1.82244298e-03f,
  2.71303300e-02f, 7.39915296e-02f, 5.05552813e-02f, 4.19820137e-02f, -7.33344406e-02f, -6.20519593e-02f, -1.11543043e-02f, 4.21723211e-03f, 1.34032536e-02f, 3.81415635e-02f,
  -5.64486682e-01f, 4.04465556e-01f, -1.91557765e-01f, -2.59603113e-01f, -2.07950562e-01f, -6.54456392e-02f, -8.77048150e-02f, 3.58710177e-02f, 1.59882322e-01f, 3.01036477e-01f,
  -1.41254097e-01f, 1.92484334e-01f, 3.32362264e-01f, -2.35582888e-01f, -2.36922458e-01f, 3.47078711e-01f, -2.84774423e-01f, -7.97867849e-02f, 1.09185606e-01f, -1.16038509e-01f,
  -7.75760561e-02f, -1.25011966e-01f, -2.65638143e-01f, 8.26390162e-02f, -3.50071192e-01f, -2.91793644e-01f, -2.82084942e-01f, 1.03824668e-01f, -3.49637955e-01f, -4.07634042e-02f,
  -2.60542780e-01f, -1.20266587e-01f, -2.38042518e-01f, -1.69423178e-01f, -1.57671735e-01f, -1.24453761e-01f, -2.67289251e-01f, 5.33726532e-03f, 2.58395169e-02f, 1.25995781e-02f,
  1.06790729e-01f, 1.00738876e-01f, -2.44492069e-02f, 1.12488478e-01f, -1.93433091e-03f, 4.36309278e-02f, -3.69977467e-02f, -1.95924312e-01f, 3.71605568e-02f, 3.90966535e-02f,
  1.04125388e-01f, -7.45984539e-02f, -2.15380505e-01f, -1.62603915e-01f, -1.54111326e-01f, -8.13434273e-02f, -9.87924784e-02f, -8.53076875e-02f, -7.58069232e-02f, 1.09629054e-02f,
  2.56663710e-02f, -4.85044979e-02f, -3.50734890e-02f, 2.44669747e-02f, 6.73090369e-02f, 1.80142764e-02f, 2.24053953e-02f, -2.09274869e-02f, -1.34084389e-01f, -7.89838061e-02f,
  -9.31386724e-02f, -7.55814239e-02f, -1.07995309e-01f, -8.86386335e-02f, 7.16554746e-02f, 4.53543589e-02f, -4.48752195e-02f, -4.21512946e-02f, 6.80794716e-02f, -3.58966254e-02f,
  5.04610501e-02f, -1.04076803e-01f, -5.33772111e-02f, -3.91686149e-02f, -5.85408732e-02f, 1.52452486e-02f, -7.47698098e-02f, -5.70618510e-02f, 9.41635892e-02f, 5.15994616e-02f,
  -3.38426322e-01f, -2.90712237e-01f, -4.93258983e-02f, -7.26993978e-02f, -8.46819952e-03f, -9.12147388e-03f, 7.06270989e-03f, -3.18085290e-02f, -1.20293811e-01f, 1.09442323e-01f,
  1.03665315e-01f, -1.08631685e-01f, -5.88906780e-02f, 1.12518214e-01f, 4.22253348e-02f, -1.12431139e-01f, -1.58078969e-01f, 1.78447589e-02f, -1.81106031e-01f, -1.28139229e-03f,
  -7.20954686e-02f, 5.59934266e-02f, 1.53104961e-01f, -5.90756126e-02f, -1.38399601e-01f, -1.27375182e-02f, -1.16191953e-01f, 3.04294936e-02f, -8.27301294e-02f, -3.11072245e-02f,
  4.66771722e-01f, -3.16485018e-01f, 8.42734203e-02f, 4.36980158e-01f, 1.85316533e-01f, 3.40976417e-02f, 3.43559623e-01f, -5.24769351e-02f, 1.90759659e-01f, -3.21987599e-01f,
  5.31083606e-02f, -2.00838387e-01f, 1.73486508e-02f, 1.72227204e-01f, 4.93024230e-01f, 3.86961512e-02f, 3.36509377e-01f, -4.69664782e-02f, -6.76484928e-02f, 1.68983489e-01f,
  1.23651333e-01f, 3.27800721e-01f, 2.09088504e-01f, -2.16381863e-01f, 2.08314821e-01f, -2.39972606e-01f, 1.20528601e-01f, -2.32897669e-01f, -1.60566077e-01f, 5.96972741e-02f,
  -3.30253541e-02f, 6.24173880e-02f, 8.42171684e-02f, -7.84423724e-02f, 3.34335603e-02f, 3.74578908e-02f, -8.06424469e-02f, -2.12747864e-02f, 2.06010509e-02f, -3.89311393e-03f,
  -1.51714599e-02f, 4.98585999e-02f, 2.74658035e-02f, -6.22199066e-02f, 9.18706954e-02f, 3.84854386e-03f, -8.40710569e-03f, -1.75073400e-01f, -7.33044744e-02f, -1.20657021e-02f,
  3.07996143e-02f, -8.66747648e-02f, 2.84557026e-02f, -1.26492336e-01f, -7.50294253e-02f, 1.40327234e-02f, -9.79552940e-02f, -9.54707786e-02f, -1.00472435e-01f, 8.58070776e-02f,
  -8.84130970e-02f, 3.60058807e-02f, -7.93165043e-02f, 7.54317967e-03f, 1.38173029e-01f, 1.75031964e-02f, -5.26202610e-03f, -8.60845074e-02f, 3.92636694e-02f, 4.42891493e-02f,
  9.73596200e-02f, 8.21782798e-02f, 5.65732047e-02f, 6.33561909e-02f, 1.04220603e-02f, 1.31785618e-02f, 2.78182495e-02f, -4.56974916e-02f, 5.73965907e-02f, 8.11632723e-04f,
  -6.83195442e-02f, -6.85319025e-03f, -4.83251065e-02f, -1.47197500e-01f, 1.09104542e-02f, 2.14491170e-02f, 3.02636139e-02f, 4.35582437e-02f, -1.98099110e-02f, 8.94941837e-02f,
  -6.72807023e-02f, 5.22401705e-02f, -1.32340323e-02f, -8.63331631e-02f, -4.68817018e-02f, 3.66179831e-02f, 6.88505918e-02f, -4.45393147e-03f, 7.96417519e-02f, 7.60742947e-02f,
  -2.04818305e-02f, 4.13535237e-02f, -5.92047907e-02f, -1.83509625e-02f, 1.19428402e-02f, 1.12947233e-01f, 4.82830312e-03f, -7.48967379e-02f, 3.84307019e-02f, -2.56363000e-03f,
  -3.00659742e-02f, 8.82881880e-02f, 9.99849215e-02f, -7.11450428e-02f, -1.41031057e-01f, 2.61055883e-02f, -1.13047019e-01f, 3.31323482e-02f, -7.24636242e-02f, -9.58940759e-02f,
  1.51202157e-01f, -3.64452600e-02f, -2.04964057e-01f, -2.09035620e-01f, -9.81097445e-02f, 2.10320696e-01f, -9.79227796e-02f, 9.14541930e-02f, 1.79273844e-01f, 1.75809354e-01f,
  -1.11193158e-01f, -2.26266589e-02f, 2.85125170e-02f, -2.89777368e-01f, 1.58545047e-01f, -3.78573034e-03f, -6.52243793e-02f, -1.20677687e-01f, -4.20142561e-02f, -6.22102357e-02f,
  -1.48392603e-01f, -9.26181376e-02f, -2.85188079e-01f, 1.72906555e-02f, -1.95022807e-01f, -1.13890342e-01f, -1.60288125e-01f, -1.99194774e-01f, -3.06741238e-01f, -2.09668934e-01f,
  -1.60980433e-01f, -6.76921685e-04f, -1.95230797e-01f, -6.37765974e-02f, -7.29650557e-02f, -1.68087967e-02f, 3.86053473e-02f, -1.84945315e-02f, -4.59787529e-03f, -3.31027061e-02f,
  1.13966065e-02f, 1.74158752e-01f, 7.69188628e-04f, -1.03512295e-01f, 4.81365882e-02f, -1.16526326e-02f, 3.26183289e-02f, -2.05352902e-02f, -7.34771937e-02f, -3.28713544e-02f,
  -2.20652089e-01f, 3.87956835e-02f, 8.37997571e-02f, 1.48206502e-01f, -1.09640859e-01f, -9.24226865e-02f, -1.66555177e-02f, -1.24766007e-01f, 2.92231329e-03f, 7.23774806e-02f,
  -3.50908861e-02f, 1.65489212e-01f, -4.12985347e-02f, 5.87613322e-02f, 4.77549098e-02f, 3.84331420e-02f, -3.00497729e-02f, 1.57691725e-02f, 9.28147808e-02f, -9.40033607e-03f,
  6.82239532e-02f, -4.56961915e-02f, -1.11584567e-01f, 1.08917832e-01f, -4.63968143e-02f, 1.60361737e-01f, -6.25052080e-02f, 2.55752052e-03f, 2.11760495e-02f, 1.40236899e-01f,
  -5.81638962e-02f, 9.80954841e-02f, -9.35943648e-02f, -5.22345416e-02f, -6.36310736e-03f, 1.33219315e-02f, 1.01298466e-02f, -7.82891214e-02f, -1.09558001e-01f, 8.19436014e-02f,
  1.99414082e-02f, 2.45153427e-01f, -1.61419194e-02f, 2.17638649e-02f, 3.39449160e-02f, 9.04102698e-02f, 2.64939815e-02f, 7.07656443e-02f, 3.31772119e-02f, 1.49417400e-01f,
  -5.67838550e-02f, -5.42107746e-02f, 3.13655615e-01f, 2.98475269e-02f, 1.33472728e-02f, -1.18177421e-02f, 1.27319604e-01f, 7.15290606e-02f, 8.83282050e-02f, 5.33181913e-02f,
  -9.18812230e-02f, 2.05910340e-01f, 1.46189064e-01f, 4.42077294e-02f, 1.42615631e-01f, -5.06725609e-02f, 2.20352203e-01f, -1.89465061e-01f, 8.93421173e-02f, 3.20894793e-02f,
  -3.05045128e-01f, -2.06460774e-01f, 3.95262927e-01f, -4.26619440e-01f, 2.64542371e-01f, 2.14946195e-01f, 1.50388982e-02f, -1.22504987e-01f, -1.60375699e-01f, -3.76536787e-01f,
  -1.31978497e-01f, -1.16976030e-01f, 3.47779334e-01f, -3.47191185e-01f, 5.88642120e-01f, 3.05276811e-01f, -2.23147333e-01f, -3.15027267e-01f, 3.12875137e-02f, -1.72902614e-01f,
  -3.62561531e-02f, -3.43851626e-01f, 1.16208464e-01f, -2.40348175e-01f, -1.82483658e-01f, -1.96982011e-01f, -1.94793135e-01f, 1.71799213e-01f, -3.03253174e-01f, 1.38336748e-01f,
  -6.80588782e-02f, -2.59483248e-01f, -9.66770127e-02f, 1.76359173e-02f, -1.28234476e-02f, -5.15186004e-02f, -6.71398127e-03f, 1.26052395e-01f, 5.12998225e-03f, -5.23031466e-02f,
  -3.72651890e-02f, 1.30395055e-01f, -1.04746018e-02f, -8.89039878e-03f, -3.95059176e-02f, -2.04190966e-02f, 1.92741230e-02f, -4.68690172e-02f, 7.89329559e-02f, 1.05112113e-01f,
  1.29577383e-01f, 6.58760518e-02f, 8.34733248e-03f, -7.36166164e-02f, 7.81786367e-02f, -6.98178634e-02f, 1.88883264e-02f, 1.44142404e-01f, -3.40737142e-02f, -5.29257208e-02f,
  1.00107519e-02f, -5.21727055e-02f, 5.66287674e-02f, -3.15207578e-02f, -5.82429022e-02f, 4.12234329e-02f, -3.12735024e-03f, 6.03196397e-02f, -2.52602845e-02f, 1.10275291e-01f,
  5.01010455e-02f, 1.22278342e-02f, 9.03602503e-03f, 2.39474252e-02f, -1.18577421e-01f, -6.81692585e-02f, 7.47350231e-02f, -4.08910476e-02f, -4.81696166e-02f, 4.91412245e-02f,
  -8.22471082e-02f, 8.96598101e-02f, 7.04857260e-02f, -6.48033395e-02f, 3.83000151e-04f, 5.48097789e-02f, -1.02436341e-01f, 4.79011387e-02f, -2.38245688e-02f, 5.81324175e-02f,
  -3.14532638e-01f, -3.89030576e-01f, -7.52308890e-02f, -6.98571876e-02f, -5.02934773e-03f, -8.91930237e-02f, -9.10391212e-02f, -5.33870161e-02f, -1.37027493e-02f, -6.99709207e-02f,
  -8.06216523e-02f, -1.09439418e-01f, -5.65422662e-02f, -7.43917078e-02f, -6.30553365e-02f, -1.99494716e-02f, -1.42695501e-01f, -5.20724393e-02f, -1.11691214e-01f, -5.92648461e-02f,
  -1.07583255e-01f, -7.13852197e-02f, -1.44546339e-03f, -4.98618409e-02f, -1.02405190e-01f, -5.20451553e-02f, -8.97993371e-02f, 3.63390036e-02f, 8.63017216e-02f, 2.76022051e-02f,
  -5.97922266e-01f, 2.26913095e-01f, 1.03863358e-01f, -5.44235051e-01f, 2.97869444e-01f, 2.33985320e-01f, -1.80276066e-01f, 3.31878901e-01f, -1.59945130e-01f, 3.21260870e-01f,
  -2.19240278e-01f, -2.12496787e-01f, 2.20220208e-01f, -4.43956017e-01f, -4.19252068e-01f, -2.71957755e-01f, -2.96379179e-01f, -2.83003390e-01f, -3.50900255e-02f, -8.09951648e-02f,
  -8.26660693e-02f, -2.08806202e-01f, -1.48741439e-01f, 2.98987657e-01f, 6.61341995e-02f, 3.34509075e-01f, -6.02106862e-02f, 3.01995456e-01f, -1.48901418e-02f, -4.86847609e-02f,
  5.45849726e-02f, 1.38596846e-02f, 2.22602308e-01f, 2.19435915e-01f, 7.94327781e-02f, 2.69076228e-02f, 1.76429488e-02f, 5.05591445e-02f, 2.52453741e-02f, -1.17782623e-01f,
  -5.24868853e-02f, 3.38155665e-02f, -1.71027988e-01f, -1.58702508e-01f, 1.67500079e-01f, 6.01406209e-02f, -2.64092926e-02f, 4.23753373e-02f, 9.90646854e-02f, -1.94096103e-01f,
  -1.01950489e-01f, 3.69930156e-02f, -1.00249395e-01f, -1.46155670e-01f, -1.70868207e-02f, 7.06141889e-02f, -1.29462210e-02f, 6.66960478e-02f, -2.99460590e-02f, -1.08815990e-01f,
  2.71101650e-02f, 2.77656056e-02f, 1.20438017e-01f, -7.86642209e-02f, -8.46948102e-02f, -2.79689208e-02f, -5.34394346e-02f, -7.30080903e-02f, -9.07255337e-03f, 6.32944982e-03f,
  7.02975616e-02f, 8.75073895e-02f, -1.63524244e-02f, -2.83904653e-02f, -1.80035666e-01f, 7.05759856e-04f, 1.37125235e-02f, -4.72886711e-02f, -2.94546615e-02f, 8.55640024e-02f,
  -4.22359668e-02f, 2.15106793e-02f, -4.76527587e-02f, 6.36269450e-02f, -5.34328371e-02f, -6.29941523e-02f, 4.69961278e-02f, -3.07654217e-02f, -2.89618280e-02f, -4.58718352e-02f,
  1.18956611e-01f, -6.82265460e-02f, 1.36635736e-01f, 7.15325996e-02f, -1.71989470e-03f, -3.51581210e-03f, -3.07275821e-03f, 3.44224684e-02f, -4.22061794e-02f, -3.14184353e-02f,
  3.61942053e-02f, 7.28959441e-02f, 8.69270861e-02f, -4.86776195e-02f, -3.53397541e-02f, -8.14265106e-03f, -7.17737153e-03f, -1.86237594e-06f, 1.41202956e-01f, 9.30582806e-02f,
  1.00694016e-01f, 2.32515065e-03f, -3.88988331e-02f, 9.58114862e-03f, 1.51981995e-01f, -1.99752301e-03f, 3.91847417e-02f, 8.72462317e-02f, -9.85940769e-02f, 8.55210051e-02f,
  -4.26706731e-01f, 3.83800060e-01f, 1.32812127e-01f, -5.20709865e-02f, 2.74292707e-01f, 3.22714776e-01f, 2.70095140e-01f, 3.76142979e-01f, 2.48618498e-01f, 1.58764452e-01f,
  -8.07249993e-02f, 1.42360879e-02f, 1.24038965e-01f, 4.29559499e-03f, -2.23636672e-01f, 1.61554664e-01f, 8.05425718e-02f, -5.66692837e-02f, 2.49332011e-01f, 4.77078110e-02f,
  4.62350361e-02f, -7.35866725e-02f, -1.97055683e-01f, 1.01220123e-02f, 2.20385008e-02f, -8.75390545e-02f, -2.40183562e-01f, 4.74613607e-02f, -1.07207865e-01f, 1.15389727e-01f,
  -5.62399998e-02f, 1.39115661e-01f, -3.06052174e-02f, 7.38519356e-02f, -3.58694345e-02f, -1.98251724e-01f, -4.55970727e-02f, 6.96680322e-02f, 6.80140033e-02f, 2.05613494e-01f,
  -3.38913724e-02f, 1.38186440e-01f, 9.03292224e-02f, 5.48472553e-02f, 1.63512930e-01f, 7.23196119e-02f, 1.47295948e-02f, 4.10272889e-02f, 1.20531887e-01f, 5.75477891e-02f,
  -4.13387418e-02f, 4.95186709e-02f, -7.67636523e-02f, 5.59718832e-02f, 7.41554052e-02f, 1.52004465e-01f, 3.61546725e-02f, -1.74914807e-01f, -2.41199024e-02f, 5.38786240e-02f,
  8.08089077e-02f, 4.75906841e-02f, -9.35431793e-02f, 4.64077806e-03f, 1.01127483e-01f, 9.08165500e-02f, 4.72115688e-02f, 3.07046231e-02f, 5.78707382e-02f, -9.55769271e-02f,
  -9.03675258e-02f, 9.57698282e-03f, 1.51485518e-01f, 8.49202275e-02f, 3.21703851e-02f, 8.86730198e-03f, -1.17281877e-01f, -3.51858586e-02f, -5.49987666e-02f, -7.64384419e-02f,
  7.33620822e-02f, -3.57630290e-02f, 1.17467362e-02f, 6.93393201e-02f, 9.56959277e-02f, 6.86153993e-02f, -2.73056515e-02f, -8.41062963e-02f, 2.39450205e-03f, -1.35505706e-01f,
  9.86522660e-02f, 1.41559588e-03f, 1.40990436e-01f, 1.72708750e-01f, -1.12122282e-01f, -5.75653426e-02f, 4.14096974e-02f, 3.06007899e-02f, 6.53562322e-02f, 1.44630015e-01f,
  2.07897723e-02f, 1.55106485e-01f, -1.00318365e-01f, -4.03760225e-02f, -6.34644702e-02f, 1.06004089e-01f, -2.39549261e-02f, -2.13507097e-02f, 2.02778615e-02f, 3.12537923e-02f,
  -2.74966192e-02f, -1.12803094e-01f, -1.76055267e-01f, 3.77421342e-02f, -7.52151608e-02f, -9.23788175e-02f, -4.29338738e-02f, 7.16332570e-02f, -7.31011629e-02f, -4.70550992e-02f,
  -8.41516778e-02f, 5.93531609e-01f, 2.45770529e-01f, -3.33367467e-01f, 2.21143275e-01f, 5.40069580e-01f, -6.29937947e-02f, 7.62291923e-02f, -3.76459986e-01f, -1.83261618e-01f,
  -1.29390761e-01f, 2.56287277e-01f, 1.35953367e-01f, 1.20605446e-01f, 3.96927819e-02f, 9.13844556e-02f, 5.05461497e-03f, -5.60679249e-02f, 1.23447247e-01f, 1.04267947e-01f,
  -4.71477881e-02f, 1.11279553e-02f, 1.02742769e-01f, 1.34486586e-01f, 1.91508114e-01f, -1.46798044e-01f, -4.18098390e-01f, 3.49230319e-02f, -5.23733767e-03f, 2.46353205e-02f,
  2.73198225e-02f, -3.49270135e-01f, -7.08966702e-02f, -5.64146563e-02f, 6.37538582e-02f, -1.02707535e-01f, -9.82705653e-02f, -2.12423094e-02f, -8.38966519e-02f, 8.33529085e-02f,
  4.44220752e-02f, 6.31120428e-02f, -3.43039036e-02f, -1.31264269e-01f, 5.43077029e-02f, 1.09239273e-01f, 2.27779835e-01f, 2.41216249e-03f, 1.94416553e-01f, 1.52788028e-01f,
  1.45719856e-01f, 8.36112723e-02f, 5.22040352e-02f, 6.13791961e-03f, 5.85676767e-02f, -1.14941873e-01f, -7.47848302e-02f, 1.58969283e-01f, 1.77347139e-01f, 4.55578789e-02f,
  -4.52873968e-02f, -4.65133451e-02f, 1.27076253e-01f, 1.06477790e-01f, 3.53034362e-02f, -7.05761984e-02f, 1.19460054e-01f, 1.17496900e-01f, -2.85648443e-02f, 2.28116754e-02f,
  -1.30977809e-01f, 5.59468791e-02f, -1.11355729e-01f, -8.92303661e-02f, -1.07048891e-01f, -1.58170924e-01f, -7.81014515e-03f, -5.10115884e-02f, 8.03934038e-02f, -1.37377113e-01f,
  -1.09750092e-01f, -5.01144603e-02f, -2.49222368e-02f, -1.34779746e-02f, 1.74137671e-02f, 3.42874937e-02f, -4.82265875e-02f, 8.89513176e-03f, 1.51152434e-02f, 6.09570928e-02f,
  1.48340583e-01f, -2.62681633e-01f, -9.21687484e-02f, -1.41586453e-01f, -2.82377303e-02f, 8.09959844e-02f, -5.52833080e-02f, 1.30585909e-01f, -1.08793512e-01f, -8.19863975e-02f,
  3.29371355e-03f, -2.14576989e-01f, -1.14772178e-01f, 4.73434925e-02f, 1.00658648e-02f, 9.11924914e-02f, -5.56613766e-02f, -9.58822593e-02f, -5.72898574e-02f, 7.10482746e-02f,
  -7.32573792e-02f, -1.57147527e-01f, -7.51999617e-02f, -4.96236607e-02f, -4.60680276e-02f, -3.77560258e-02f, -5.34109361e-02f, -5.11766598e-02f, 1.11800112e-01f, -1.36305362e-01f,
  -2.27824345e-01f, 1.98913738e-01f, -1.18289299e-01f, 3.94467339e-02f, 9.07790437e-02f, -2.26480529e-01f, -3.04927170e-01f, 1.45028487e-01f, -2.22572923e-01f, 1.60593227e-01f,
  -1.44111095e-02f, -1.09588526e-01f, -5.96653633e-02f, -2.26412565e-01f, -6.08855069e-01f, -3.69240254e-01f, -3.39190036e-01f, -2.64114767e-01f, -1.64293811e-01f, 1.15716465e-01f,
  -1.01558924e-01f, 1.77847054e-02f, -1.06305420e-01f, 2.39418134e-01f, 2.47149438e-01f, 1.87762797e-01f, 2.92147607e-01f, 2.40524903e-01f, 1.77515194e-01f, 2.57397611e-02f,
  -9.27334651e-02f, -6.05498217e-02f, -3.95088515e-04f, -1.87617168e-02f, -1.24654174e-03f, 1.15279511e-01f, 4.98710386e-02f, -4.96931411e-02f, -3.46064679e-02f, -4.23528515e-02f,
  5.01418859e-02f, -5.61792143e-02f, 1.59362797e-02f, 6.51072105e-03f, 2.83671506e-02f, 3.60495225e-02f, -5.10676727e-02f, 3.03446595e-02f, -6.33132681e-02f, -1.10027403e-01f,
  -6.33990485e-03f, -1.70736985e-05f, -1.13617545e-02f, 3.34230512e-02f, -3.29599828e-02f, -9.65259895e-02f, -8.36637542e-02f, 2.49047652e-02f, 1.29856467e-01f, 1.41148418e-02f,
  8.12648311e-02f, 4.71502505e-02f, 6.73029870e-02f, -1.10432088e-01f, 3.75286639e-02f, -1.76513214e-02f, 1.81898940e-02f, 4.26091887e-02f, 1.18951775e-01f, 2.96995733e-02f,
  -2.76771802e-02f, -1.75347216e-02f, -2.98239589e-02f, -4.37210575e-02f, 4.49532233e-02f, -1.08592033e-01f, 5.24619706e-02f, 1.01137191e-01f, -1.61084328e-02f, 6.22084849e-02f,
  1.38810426e-02f, 5.27260303e-02f, -5.75256459e-02f, 5.67808039e-02f, -1.61198676e-01f, 7.04060569e-02f, 1.38300523e-01f, -5.64691760e-02f, -9.42951447e-05f, -2.60672852e-04f,
  -3.74326371e-02f, 2.54850477e-01f, -3.24649946e-03f, -8.04329216e-02f, 1.02138884e-01f, 2.61320788e-02f, -2.62524337e-02f, -5.43804243e-02f, -1.15075596e-02f, 5.80550963e-03f,
  5.16301058e-02f, 1.24587946e-01f, 1.57195777e-01f, -1.86461806e-02f, 1.02494672e-01f, -7.42838010e-02f, 1.50122831e-03f, 1.57602072e-01f, 1.04806833e-01f, 1.29029706e-01f,
  1.84267655e-01f, 3.69427796e-03f, 5.07239923e-02f, 7.97513276e-02f, 7.92762935e-02f, 1.09943204e-01f, 9.64627489e-02f, 6.40745908e-02f, 6.66083470e-02f, 8.03457797e-02f,
  -5.70282698e-01f, 8.80621672e-02f, 4.27005589e-01f, -1.96434110e-01f, -4.39925104e-01f, 4.36163574e-01f, 3.25786978e-01f, -1.74384847e-01f, -1.00842804e-01f, 2.17605397e-01f,
  -2.75249928e-01f, -1.34616524e-01f, 3.11514139e-01f, -9.64874867e-03f, 2.66436279e-01f, 4.26031291e-01f, 2.07886592e-01f, 1.80578530e-01f, -2.04092026e-01f, -3.22960287e-01f,
  -2.07175106e-01f, -1.91996843e-01f, 1.68573454e-01f, -3.00271362e-01f, -2.01902330e-01f, -2.20197871e-01f, -1.99271709e-01f, -8.95277709e-02f, -1.67185917e-01f, -1.03540614e-01f,
  -1.99843556e-01f, -3.40215325e-01f, -2.01671973e-01f, 1.18249595e-01f, -2.34920084e-02f, 9.97602791e-02f, 1.14093520e-01f, 5.53772636e-02f, -3.63590494e-02f, -5.69167770e-02f,
  3.22208889e-02f, -7.53340274e-02f, -1.90952450e-01f, -2.56175036e-03f, -1.35079965e-01f, -1.62881166e-01f, -1.84242055e-02f, 1.07091635e-01f, -5.36809601e-02f, 3.81481163e-02f,
  1.09297238e-01f, 3.61788720e-02f, 6.66670352e-02f, 1.42794270e-02f, -3.77144627e-02f, -6.75434992e-02f, 1.67965099e-01f, -2.74611730e-02f, 2.13598050e-02f, -1.25795426e-02f,
  7.25449622e-02f, -1.75500140e-02f, -3.80942747e-02f, -1.21599525e-01f, 1.54493609e-02f, -9.66757312e-02f, 1.16639063e-01f, -7.56142102e-03f, 6.00740798e-02f, -1.08126439e-01f,
  -1.31574199e-01f, -3.01292893e-02f, -1.01182379e-01f, 1.51375771e-01f, -9.69918147e-02f, 6.72867149e-02f, -1.87838404e-03f, -1.29745260e-01f, 9.55840424e-02f, 8.42916444e-02f,
  1.20353177e-02f, 4.18216400e-02f, -3.08875125e-02f, -2.41439398e-02f, 2.97104921e-02f, 8.92239213e-02f, 1.08753052e-02f, 6.49267212e-02f, 5.25603332e-02f, 4.48934622e-02f,
  -2.79865026e-01f, -2.10037470e-01f, -2.11007401e-01f, -9.88738537e-02f, 1.26385063e-01f, -1.22513771e-02f, 3.81797506e-03f, -9.65424925e-02f, 4.42791618e-02f, -1.31632863e-02f,
  5.18538989e-02f, 4.44057062e-02f, 4.80497777e-02f, -4.07229438e-02f, -1.72607955e-02f, -2.05312725e-02f, -7.17145056e-02f, -3.55161577e-02f, 5.98443709e-02f, -7.79958293e-02f,
  -3.92462313e-02f, -2.92904247e-02f, 9.69408602e-02f, -4.27190438e-02f, -2.59978045e-03f, 2.23840289e-02f, -7.20084310e-02f, -9.13028568e-02f, -5.71048893e-02f, 1.11662544e-01f,
  4.93324608e-01f, -1.19838975e-01f, 3.73244584e-01f, 4.82153267e-01f, 1.85882837e-01f, -3.10369909e-01f, 1.24187127e-01f, 2.30099827e-01f, 2.51816660e-01f, -2.75309086e-01f,
  -8.82657096e-02f, 8.36819708e-02f, -2.77610093e-01f, 1.06918409e-01f, 5.25699183e-03f, -1.57011867e-01f, 6.11825101e-02f, -1.20053500e-01f, 1.57586336e-01f, 1.68290332e-01f,
  2.75380164e-01f, -1.64445385e-01f, 1.69890985e-01f, 3.50592099e-02f, 2.13966683e-01f, 2.45812625e-01f, -2.23785296e-01f, -3.84306796e-02f, -4.34061773e-02f, -1.37309775e-01f,
  5.08793741e-02f, 1.39408603e-01f, 2.57331505e-03f, -4.11180109e-02f, -7.08109466e-03f, -1.63372055e-01f, -8.80730227e-02f, -5.04026562e-02f, 3.72105017e-02f, 6.09109960e-02f,
  -1.88895408e-02f, 5.62985130e-02f, 4.48806211e-02f, -1.36903217e-02f, 4.25791405e-02f, 2.01345131e-01f, 9.88272056e-02f, 1.41940461e-02f, 8.27012882e-02f, 2.12257758e-01f,
  1.11997001e-01f, -3.23314667e-02f, 1.50765195e-01f, -6.31214380e-02f, 6.51408955e-02f, -5.87512888e-02f, -4.47618887e-02f, -1.32546037e-01f, -9.07084346e-02f, 2.64593568e-02f,
  -1.08333260e-01f, -6.76681176e-02f, 5.14637381e-02f, 1.26867786e-01f, 7.27249011e-02f, 6.28800094e-02f, 6.40164986e-02f, -2.68879440e-03f, -1.51973125e-02f, -3.25054601e-02f,
  4.53502946e-02f, 1.06054582e-01f, 5.41039445e-02f, 9.73615330e-03f, -5.28341420e-02f, 6.10083044e-02f, -3.62291336e-02f, 1.72658768e-02f, -3.40532474e-02f, 1.59392133e-02f,
  9.63200852e-02f, -2.08503362e-02f, 3.89556028e-02f, 1.10760659e-01f, -2.47716606e-02f, 1.60414372e-02f, -2.19208491e-03f, 1.39439553e-01f, -6.09974973e-02f, 3.32189500e-02f,
  -2.17836380e-01f, -3.28305155e-01f, -1.50905520e-01f, -3.65780629e-02f, -1.01697475e-01f, -1.36175036e-01f, 4.85946089e-02f, 1.18738413e-01f, -1.72675103e-01f, 6.55463040e-02f,
  -1.51781440e-01f, -2.74987612e-02f, -6.74584657e-02f, 3.22071165e-02f, -1.41318440e-01f, -1.07966457e-02f, -4.84233014e-02f, -7.95794278e-02f, -7.92966560e-02f, -3.72946225e-02f,
  5.04798405e-02f, -2.46254839e-02f, -1.23548964e-02f, 2.17178799e-02f, 8.30708258e-03f, 9.93872527e-03f, 2.87478808e-02f, 7.20310584e-02f, 3.49883623e-02f, -4.32062373e-02f,
  2.92194307e-01f, -2.07054675e-01f, -2.50124246e-01f, 4.01391387e-01f, 1.47860184e-01f, 3.68359983e-01f, 3.38688612e-01f, 1.68050021e-01f, 3.00616026e-01f, 1.04079612e-01f,
  4.70700473e-01f, -3.44006538e-01f, -8.26856270e-02f, 4.98831093e-01f, 1.45030871e-01f, 1.55947685e-01f, 3.38025868e-01f, 3.12941045e-01f, -5.50483763e-02f, 9.23948511e-02f,
  1.02977216e-01f, 2.34361991e-01f, -8.58608857e-02f, -1.00106366e-01f, 7.57570341e-02f, -1.89537406e-01f, -6.31572306e-02f, -3.12028855e-01f, 7.84000307e-02f, -5.30811921e-02f,
  2.36852631e-01f, 1.48885086e-01f, 2.27845516e-02f, -1.17272563e-01f, 1.30906347e-02f, -1.12134226e-01f, -1.64714858e-01f, -6.30146861e-02f, -8.39923471e-02f, 4.39624749e-02f,
  -5.57118580e-02f, 2.45484076e-02f, 1.15705967e-01f, -5.97455949e-02f, -5.34881204e-02f, -2.36466415e-02f, 9.95378047e-02f, 1.07288003e-01f, -8.27669650e-02f, -2.00322773e-02f,
  3.32694240e-02f, 1.25114545e-01f, 9.46236700e-02f, -6.22529350e-02f, 6.89203143e-02f, -1.83276297e-03f, -4.07330915e-02f, -3.41852643e-02f, -7.12324828e-02f, -2.55253948e-02f,
  -7.37220496e-02f, -5.71082681e-02f, 6.31834567e-02f, 1.50490068e-02f, 6.58830581e-03f, 4.31804024e-02f, 8.89559239e-02f, -3.37128304e-02f, -5.60779460e-02f, 5.57248630e-02f,
  -1.60537437e-02f, -1.35190114e-02f, 7.84007162e-02f, -2.97178961e-02f, 8.65609795e-02f, 3.27248536e-02f, -3.84730101e-02f, -1.86314043e-02f, 1.47969291e-01f, 6.00419305e-02f,
  -8.20852667e-02f, -1.28920395e-02f, 7.96262696e-02f, 2.46801469e-02f, 2.40764786e-02f, -3.33138295e-02f, 1.33083463e-01f, 3.25314365e-02f, 9.63760391e-02f, -6.50522625e-03f,
  3.01654916e-02f, -1.26493737e-01f, -3.00616422e-03f, -7.10716099e-03f, -1.59021601e-01f, -6.44339668e-03f, 8.28756206e-03f, 2.32656263e-02f, -7.51841068e-02f, 9.77753997e-02f,
  -5.51333651e-02f, -8.52800831e-02f, 9.51536894e-02f, 1.82589907e-02f, -9.89827290e-02f, 8.92602876e-02f, 3.80270593e-02f, -1.39139488e-01f, 5.66218281e-03f, -3.09370402e-02f,
  -1.05809644e-01f, -6.04918636e-02f, -4.67675216e-02f, 7.59251369e-03f, 1.11720763e-01f, -5.42016653e-03f, -1.30295800e-02f, -8.38437453e-02f, 2.73045637e-02f, 7.24064512e-03f,
  -1.17270105e-01f, -3.37939560e-01f, 8.41095019e-03f, 1.89708680e-01f, 2.60726571e-01f, 1.95653528e-01f, -3.05302322e-01f, 2.34529749e-01f, 2.50397120e-02f, -3.80210251e-01f,
  -1.15126275e-01f, -3.63907605e-01f, -3.61270428e-01f, 9.87782851e-02f, 2.86806114e-02f, -1.24274760e-01f, 2.84477115e-01f, -8.58947113e-02f, 3.34383398e-01f, 2.51702756e-01f,
  2.43383557e-01f, 2.10770383e-01f, 2.23882779e-01f, 2.40356311e-01f, 3.34424585e-01f, 1.50517792e-01f, -3.50785442e-02f, 4.01172377e-02f, 1.02918722e-01f, -1.36502922e-01f,
  -8.00070390e-02f, 7.67915472e-02f, 5.47818318e-02f, 6.73026778e-03f, 9.27384570e-02f, -2.24913973e-02f, -7.77398422e-02f, -9.16149169e-02f, 1.12126157e-01f, 3.39629874e-02f,
  -2.02324595e-02f, 1.50042996e-01f, 6.99390247e-02f, -7.01468065e-02f, -1.05067110e-02f, 1.66417554e-01f, 1.76525787e-01f, 1.99119776e-01f, -5.99164777e-02f, 1.23879567e-01f,
  3.67752509e-03f, 4.79856804e-02f, 8.61065388e-02f, 5.27128652e-02f, 1.26043111e-01f, 5.82754798e-02f, -2.86996458e-02f, -5.57022467e-02f, 1.37980832e-02f, -3.28102410e-02f,
  1.06908269e-01f, 7.60326684e-02f, -1.06291190e-01f, 5.95138185e-02f, -1.33485064e-01f, 1.33526161e-01f, -1.07534140e-01f, 9.72514674e-02f, 3.52840056e-03f, -1.07128739e-01f,
  5.28683029e-02f, -3.48860472e-02f, 4.40157615e-02f, 1.02538005e-01f, -4.14215513e-02f, 4.72324807e-03f, -1.33756712e-01f, 9.76495892e-02f, 8.93557593e-02f, 2.84882616e-02f,
  -9.72545147e-02f, 1.89496782e-02f, -9.46720317e-02f, 1.09187998e-01f, -6.34000897e-02f, 2.16411962e-03f, 7.55003244e-02f, -1.19152024e-01f, 7.31880665e-02f, -9.38455239e-02f,
  -3.34861785e-01f, -1.64092973e-01f, 9.27470531e-03f, -1.51765011e-02f, -6.07445240e-02f, -1.81811247e-02f, 4.23118807e-02f, 4.70722578e-02f, -1.29528463e-01f, -2.93605756e-02f,
  1.79544404e-01f, 6.79372698e-02f, -1.50144249e-01f, 4.36472557e-02f, -7.86052346e-02f, -3.67125147e-03f, -1.20960020e-01f, -8.00049230e-02f, -1.00806043e-01f, 5.85728958e-02f,
  -6.24963567e-02f, 2.18570456e-02f, 1.10302642e-01f, 9.47710797e-02f, 2.91899331e-02f, -1.18749924e-01f, -1.72170550e-01f, -3.06092948e-02f, -3.32042226e-03f, 2.50307843e-02f,
  4.06754524e-01f, -4.33982402e-01f, 5.67534827e-02f, 4.43778008e-01f, 1.26117602e-01f, -1.07605597e-02f, 3.77394408e-01f, -1.21762514e-01f, 3.31850857e-01f, -2.84844398e-01f,
  -9.11174621e-03f, -1.21201113e-01f, -1.56040234e-03f, -3.78530979e-01f, 2.39488974e-01f, -1.77663520e-01f, -8.31050724e-02f, 1.29031554e-01f, 1.97858941e-02f, 3.85362096e-03f,
  6.88083917e-02f, -2.73911476e-01f, -1.01045661e-01f, -4.12590384e-01f, -3.88212539e-02f, 7.06478879e-02f, -2.54510343e-01f, -1.27168726e-02f, -2.00683847e-01f, -1.91170439e-01f,
  -9.40086618e-02f, -6.80830330e-02f, 1.63423717e-02f, -1.12316623e-01f, 8.92561153e-02f, 7.50531927e-02f, 1.38070986e-01f, 1.82359535e-02f, 6.10677078e-02f, -6.87802359e-02f,
  3.64479609e-02f, -1.44472821e-02f, -9.48392898e-02f, 2.44483855e-02f, 8.15513954e-02f, -5.88771477e-02f, 8.33746511e-04f, 3.00744697e-02f, -3.61473449e-02f, 1.10492907e-01f,
  8.43853354e-02f, 1.28848150e-01f, -5.38185835e-02f, 5.04693389e-02f, 1.49658218e-01f, 6.84808269e-02f, -2.14209016e-02f, 1.08817443e-01f, -9.86255780e-02f, -3.07036098e-02f,
  -4.58506197e-02f, 5.70117403e-03f, 2.83777993e-02f, -8.47042874e-02f, -2.59967428e-02f, -4.31969911e-02f, 2.62079500e-02f, -1.09140292e-01f, 1.37881517e-01f, -7.15933591e-02f,
  -3.75688523e-02f, 3.10234986e-02f, -1.69207782e-01f, 4.85164374e-02f, 1.05869755e-01f, -3.42457071e-02f, 3.26611176e-02f, 1.88607693e-01f, 9.35565382e-02f, 3.60640464e-03f,
  1.07419491e-02f, -8.98278281e-02f, -1.07217662e-01f, 7.65523016e-02f, -1.14665374e-01f, 2.43274681e-03f, -7.76906013e-02f, 1.17268570e-01f, 1.05928152e-03f, -8.32634419e-03f,
  -1.75984129e-01f, -3.58464092e-01f, -1.06126547e-01f, -1.15279205e-01f, -5.98349273e-02f, -2.90663168e-02f, -1.36031076e-01f, -7.15456679e-02f, -1.13015488e-01f, 1.31608709e-03f,
  -1.49457145e-03f, 1.48560181e-01f, -5.86691254e-04f, 3.97235528e-02f, -1.23547629e-01f, -6.66032210e-02f, 1.15494365e-02f, -6.65233750e-03f, -1.50714457e-01f, -5.83667569e-02f,
  3.14759314e-02f, 2.00485781e-01f, -1.19927265e-01f, 1.75851718e-01f, 1.55438976e-02f, 1.26914427e-01f, 3.52416225e-02f, -6.63558766e-02f, 1.08630337e-01f, -8.26545507e-02f,
  -4.02218282e-01f, 5.72507977e-01f, 2.66174853e-01f, -1.75711215e-01f, 4.89486828e-02f, -1.36012509e-02f, -1.32678673e-01f, 1.23333804e-01f, -8.45704526e-02f, 1.49964377e-01f,
  -2.52837241e-01f, 3.31832230e-01f, -5.07487021e-02f, -1.85071379e-01f, -4.51372027e-01f, -3.33047330e-01f, -3.84683609e-01f, -1.40234977e-01f, -1.35834306e-01f, -1.26345485e-01f,
  -2.24801704e-01f, -3.74801189e-01f, -2.43479669e-01f, 1.84857622e-01f, 2.67671227e-01f, 2.92042881e-01f, -2.43411124e-01f, 1.69843778e-01f, 1.93880200e-01f, 6.16894662e-02f,
  -2.07019001e-01f, 6.54004887e-02f, 6.57643601e-02f, 1.53557166e-01f, -6.35244027e-02f, -1.92330894e-03f, 2.47213524e-02f, 4.99471910e-02f, -7.87351578e-02f, 7.27576166e-02f,
  6.73692375e-02f, 5.39810918e-02f, 2.81989202e-02f, -1.06050894e-02f, 1.57278597e-01f, 1.02293454e-01f, 3.02616358e-02f, 4.57441919e-02f, 7.78143257e-02f, 1.40369475e-01f,
  3.38065363e-02f, 6.88586086e-02f, 5.76456860e-02f, -5.57651632e-02f, -4.41988744e-02f, 8.24064985e-02f, -1.21250272e-01f, 6.12087175e-02f, 9.37989820e-03f, -8.14087465e-02f,
  -6.25260919e-02f, -1.25811368e-01f, -1.92653630e-02f, -1.90877486e-02f, -6.68080896e-02f, 8.60844087e-03f, -3.56944948e-02f, -3.52886729e-02f, 1.11846752e-01f, 6.22094460e-02f,
  -6.03096224e-02f, 1.22882746e-01f, 4.93622497e-02f, -1.07525066e-01f, -4.72653732e-02f, 1.25911618e-02f, -5.60039021e-02f, 2.98639480e-02f, -1.09818622e-01f, 1.20885605e-02f,
  7.65080601e-02f, -8.76718611e-02f, 4.62748334e-02f, 1.30462358e-02f, 1.47594204e-02f, 1.06296679e-02f, 4.33562556e-03f, 1.26291867e-02f, -1.10789768e-01f, 9.21504758e-03f,
  -4.70272064e-01f, -2.35925391e-01f, -9.31824595e-02f, 9.17087719e-02f, 1.58451907e-02f, -6.20478718e-03f, 3.55408713e-02f, 7.90947303e-02f, -5.01054376e-02f, -9.86597762e-02f,
  7.68819302e-02f, 2.64930055e-02f, -5.71644790e-02f, -3.73169258e-02f, -2.83973832e-02f, -4.41077575e-02f, -4.81135808e-02f, -7.25440532e-02f, -1.05606906e-01f, 1.54958993e-01f,
  5.38532250e-02f, 8.32607225e-02f, -4.80168611e-02f, 4.15554876e-03f, 1.53757185e-02f, 5.83182871e-02f, 2.58429348e-03f, 9.79037881e-02f, 8.20320286e-03f, 1.12177558e-01f,
  2.67587155e-01f, 2.87969202e-01f, 2.68722117e-01f, 2.51642466e-01f, -2.59109944e-01f, 1.32560968e-01f, 3.94533873e-02f, -2.54860133e-01f, 2.04218552e-01f, 1.07172772e-01f,
  -2.96745896e-01f, 4.71531928e-01f, -2.23884821e-01f, -1.90273061e-01f, -1.58152297e-01f, -1.53081685e-01f, 6.51660040e-02f, 2.28494048e-01f, -1.15022480e-01f, 6.76245391e-02f,
  -8.64847824e-02f, -2.06773058e-01f, -2.71241784e-01f, -1.96067825e-01f, 1.91335455e-01f, 3.36751878e-01f, -1.89283237e-01f, -3.92229296e-02f, 2.28160873e-01f, -1.16121329e-01f,
  -1.06726363e-01f, -2.64024567e-02f, 9.66143757e-02f, 1.42470047e-01f, 5.83445318e-02f, -1.14422310e-02f, 5.62004596e-02f, -1.06118038e-01f, 3.59812081e-02f, 1.32336281e-02f,
  1.79438218e-01f, 3.27881277e-02f, 7.35151097e-02f, -6.96510002e-02f, -2.15129014e-02f, -5.18535916e-03f, 1.17758967e-01f, 4.03973870e-02f, 1.68195218e-02f, 1.67087521e-02f,
  2.18316272e-01f, 2.31101681e-02f, 9.64743868e-02f, 5.98986112e-02f, 9.58952680e-02f, 5.53220883e-02f, 8.12381506e-02f, 5.22354394e-02f, 7.13954642e-02f, 1.29388839e-01f,
  -1.37680069e-01f, 1.89098194e-02f, 4.40435335e-02f, -9.94343311e-02f, -4.26970609e-02f, -5.77247236e-03f, 5.39670140e-02f, -4.94196229e-02f, 5.31966612e-02f, -2.94345082e-03f,
  4.24216464e-02f, 5.68405213e-03f, -1.21884286e-01f, -1.36502075e-03f, -1.84666589e-02f, 1.04328722e-01f, -8.20503384e-02f, 1.38123810e-01f, 6.81804791e-02f, 5.24096144e-03f,
  -1.45600542e-01f, -2.24994402e-02f, -1.30328806e-02f, -1.86908450e-02f, -5.89996204e-02f, 6.36064261e-02f, -6.59845769e-02f, 1.44531652e-01f, -7.66178593e-02f, -5.89028634e-02f,
  7.54478667e-03f, -6.47545308e-02f, 4.00866754e-03f, 2.05817875e-02f, 2.51456983e-02f, -3.14275809e-02f, -2.07742378e-02f, -1.52219376e-02f, 5.88539466e-02f, 1.50018884e-02f,
  5.76389395e-02f, 9.07720104e-02f, 1.50554091e-01f, -1.15076125e-01f, -1.15042411e-01f, -8.14248249e-02f, -6.44837469e-02f, 7.42205530e-02f, -2.10504998e-02f, -1.30617708e-01f,
  9.36346650e-02f, 6.58589005e-02f, 9.55202151e-03f, 4.47782464e-02f, 1.32223517e-01f, -8.21223333e-02f, 1.30260870e-01f, -1.03308298e-02f, 1.04965959e-02f, 8.31743702e-02f,
  -2.93577343e-01f, 2.88948298e-01f, 4.64356244e-01f, 1.04278632e-01f, 3.64647746e-01f, 4.81089532e-01f, 1.78840145e-01f, 4.27875668e-01f, 5.32238781e-01f, -1.39552012e-01f,
  -1.36706159e-01f, -1.32884160e-01f, -2.13217452e-01f, 1.14924096e-01f, 1.78319439e-01f, 9.06573907e-02f, 2.37216949e-01f, -4.33790847e-04f, 1.08838543e-01f, -2.06238508e-01f,
  2.04290096e-02f, -2.27264240e-01f, 9.48949310e-04f, -2.24001408e-01f, -4.27073725e-02f, -4.12937105e-02f, -3.98863345e-01f, -6.23595268e-02f, -1.04429305e-01f, 1.27408952e-01f,
  -2.45815311e-02f, -1.43273547e-01f, -2.33206615e-01f, 1.22657180e-01f, -1.55045884e-02f, -6.94915950e-02f, -1.00796595e-01f, -4.60445555e-03f, -3.34752202e-02f, -3.72470021e-02f,
  -1.68735459e-01f, -6.74751326e-02f, -1.51874097e-02f, -2.43120827e-03f, 1.64310783e-01f, 4.92207035e-02f, 2.16030851e-01f, 1.76328402e-02f, 9.25291553e-02f, 1.41951337e-01f,
  7.38649964e-02f, 1.66869074e-01f, 2.00837441e-02f, 9.75344405e-02f, 9.73047223e-04f, 8.42904523e-02f, 8.01745802e-02f, 9.77193043e-02f, 8.72313902e-02f, 9.15612280e-02f,
  8.38772729e-02f, 1.14025488e-01f, -9.29586664e-02f, -1.17893115e-01f, -2.04247274e-02f, 1.10064335e-01f, 1.98499463e-03f, -9.85815898e-02f, 5.78220449e-02f, -9.64862779e-02f,
  4.91197892e-02f, -5.02038039e-02f, 1.55544385e-01f, 7.72237182e-02f, -1.45897016e-01f, -1.22362748e-02f, -2.69433353e-02f, 2.10961774e-02f, -2.43655480e-02f, 1.06865540e-02f,
  -2.92403344e-02f, -2.23098025e-02f, -4.12732512e-02f, -1.65203698e-02f, -6.56143809e-03f, -2.00667828e-02f, -6.95726275e-02f, 5.01106381e-02f, -6.52348623e-02f, -1.34304509e-01f,
  2.45217279e-01f, 1.88050456e-02f, -1.18592948e-01f, -1.54355587e-02f, 4.00483562e-03f, -4.71215285e-02f, -5.41933626e-02f, 1.03939027e-01f, 7.21922219e-02f, -6.52042404e-02f,
  -5.32034338e-02f, -1.26709595e-01f, -7.23503679e-02f, -6.56702137e-03f, -2.03773007e-02f, -6.48345845e-03f, -1.65366992e-01f, -4.48153960e-03f, 4.95152548e-02f, -1.02215707e-01f,
  -1.89472124e-01f, -1.51538655e-01f, 5.11765853e-02f, -2.32687849e-03f, -4.41207848e-02f, -6.76544085e-02f, -3.14367600e-02f, 5.59490845e-02f, 2.13332064e-02f, 6.13844842e-02f,
  3.59719336e-01f, -5.75246401e-02f, -1.33634672e-01f, 5.56918569e-02f, -7.22006634e-02f, -1.68891236e-01f, -7.57134557e-02f, 7.58856954e-03f, 8.46969709e-02f, -1.68709084e-01f,
  -2.16015697e-01f, -2.28609830e-01f, -1.92158908e-01f, -1.95944726e-01f, -9.64733660e-02f, 6.63532764e-02f, -1.00736700e-01f, -2.85654038e-01f, 1.97632521e-01f, -1.25798300e-01f,
  1.40684828e-01f, -2.18101129e-01f, -1.09378375e-01f, -1.11891083e-01f, 7.98018053e-02f, 1.17564611e-01f, -9.34338421e-02f, -8.69501606e-02f, -2.52680868e-01f, -6.13912791e-02f,
  -2.12067515e-02f, 3.49438563e-02f, 1.10250548e-01f, 5.38705736e-02f, 2.00838611e-01f, 1.75781950e-01f, -6.15592347e-03f, -9.63791534e-02f, -8.11106414e-02f, -1.83570590e-02f,
  -1.51039004e-01f, -2.75273733e-02f, -4.23611887e-02f, 2.70192809e-02f, 1.07829072e-01f, -6.09155465e-03f, 4.47197519e-02f, 2.06757486e-01f, -4.66096140e-02f, 1.16332449e-01f,
  5.53404316e-02f, -8.68873820e-02f, 5.79500897e-03f, -1.21353760e-01f, 3.08388565e-02f, -9.63489860e-02f, 3.04651260e-02f, -1.94580883e-01f, -8.23462456e-02f, 1.09537035e-01f,
  6.08246140e-02f, 1.50406495e-01f, 1.62152834e-02f, 7.40558058e-02f, 8.15939680e-02f, 5.21213301e-02f, -4.64541242e-02f, 1.45282131e-02f, 1.72891647e-01f, 6.15752954e-03f,
  -4.96671274e-02f, 3.25547606e-02f, -3.35282553e-03f, -8.70033950e-02f, -1.02634476e-02f, 2.91524157e-02f, -6.12565503e-02f, -1.39207453e-01f, -5.18788360e-02f, -2.62385923e-02f,
  6.96864724e-03f, 2.33720858e-02f, 3.25010642e-02f, -1.26023456e-01f, -9.91436988e-02f, 1.07966904e-02f, 9.66013521e-02f, 5.59349954e-02f, 1.48534492e-01f, -1.79056562e-02f,
  9.64976568e-03f, -3.95205207e-02f, -7.69304112e-02f, -7.55546018e-02f, -2.84470860e-02f, 9.35262218e-02f, 1.31386831e-01f, -3.78649868e-02f, -3.18693221e-02f, -6.29290566e-02f,
  -5.29391244e-02f, -7.40164295e-02f, 7.22594261e-02f, -4.21387404e-02f, -1.55414194e-01f, 1.59962922e-02f, -2.06141338e-01f, 2.88338736e-02f, -1.18602797e-01f, -5.59731722e-02f,
  -5.33102080e-02f, -1.44517168e-01f, 7.41232336e-02f, 5.80825359e-02f, -1.18970461e-01f, -1.26092821e-01f, 7.80240372e-02f, 2.08321661e-02f, 7.25538507e-02f, -1.36216924e-01f,
  2.27510761e-02f, 3.06739330e-01f, -3.21176142e-01f, -2.51322120e-01f, 4.26081792e-02f, -3.84034008e-01f, -3.88045728e-01f, 5.77170700e-02f, -2.84038521e-02f, 4.75316904e-02f,
  1.95231259e-01f, -1.23855874e-01f, 2.31175527e-01f, 1.20076008e-01f, -1.74390316e-01f, 2.19595686e-01f, -1.41649008e-01f, -1.37902275e-01f, 9.79769453e-02f, -3.94734228e-03f,
  -7.43965358e-02f, 4.40887809e-01f, -8.47376359e-04f, 2.03180909e-01f, 1.61869615e-01f, -9.97603405e-03f, 1.81717962e-01f, 2.39385292e-02f, -1.49978399e-02f, 3.44321528e-03f,
  6.77599832e-02f, 2.76881784e-01f, -1.93216875e-01f, -6.81209788e-02f, -2.57769018e-01f, -1.99513093e-01f, -2.15980425e-01f, 1.75737422e-02f, 2.54336987e-02f, -2.26404797e-02f,
  1.09428400e-02f, 1.14535742e-01f, 1.02039158e-01f, 1.78446144e-01f, -5.85490838e-02f, 1.27510885e-02f, -3.03510781e-02f, -1.57027468e-01f, 7.50429109e-02f, 5.97476773e-02f,
  -7.79354386e-03f, 7.49022365e-02f, -2.67072842e-02f, -3.53842229e-02f, -6.07965961e-02f, 5.65760992e-02f, -1.06764317e-01f, -2.31340211e-02f, 5.98831289e-02f, -6.03119209e-02f,
  1.79919213e-01f, -4.91925403e-02f, 1.00742832e-01f, 9.49016660e-02f, -9.41460729e-02f, 2.94131469e-02f, -6.58609569e-02f, -1.94692856e-03f, -6.27856478e-02f, -7.20932782e-02f,
  -1.12073958e-01f, -5.77937439e-02f, 1.65470198e-01f, 1.36868106e-02f, -2.94215456e-02f, 2.83583403e-02f, 1.21676903e-02f, 7.47008100e-02f, -9.91256759e-02f, 2.55715959e-02f,
  -9.90123604e-04f, -1.43509973e-02f, 5.76846942e-05f, -4.92821299e-02f, 2.73020696e-02f, -4.69244197e-02f, 1.40334815e-02f, 1.24140441e-01f, -9.00307670e-02f, 1.11618629e-02f,
  4.17946354e-02f, 1.28499508e-01f, -5.07030189e-02f, 9.08010602e-02f, -1.12914070e-01f, -2.29779765e-01f, -2.47607138e-02f, 7.14868754e-02f, 5.47732040e-02f, 2.26280233e-03f,
  -2.85634082e-02f, -4.46522497e-02f, 6.81570917e-02f, 7.70982429e-02f, -1.35252148e-01f, 2.01908257e-02f, 4.67013568e-02f, -1.30773380e-01f, -1.21251643e-01f, -7.04199402e-03f,
  1.43214520e-02f, 8.95718485e-02f, -1.74341321e-01f, -1.64823294e-01f, -7.23497719e-02f, -4.89019714e-02f, 8.52395594e-02f, -4.77002608e-03f, 1.22932501e-01f, -8.09364393e-03f,
  1.18536979e-01f, -2.12455615e-01f, 1.93103269e-01f, 1.91089332e-01f, 3.58720958e-01f, 2.41030231e-01f, 3.30441952e-01f, 3.23603153e-01f, 4.66358274e-01f, -3.89786333e-01f,
  -1.74432084e-01f, -3.56935561e-01f, -2.59509832e-01f, 4.49929684e-02f, 3.15428913e-01f, 5.99311776e-02f, 3.28413904e-01f, 1.34316050e-02f, 3.07327479e-01f, -2.79271394e-01f,
  7.40518495e-02f, -1.06577516e-01f, -1.32264361e-01f, -1.73651859e-01f, -9.86421704e-02f, -8.93173516e-02f, -2.39405498e-01f, -2.58668121e-02f, -2.72007555e-01f, 1.18674301e-01f,
  1.70660749e-01f, 1.84110701e-02f, -5.87563813e-02f, 6.92682201e-03f, 6.39060810e-02f, -7.38416836e-02f, 4.13198993e-02f, 6.41892850e-02f, 4.94827218e-02f, 3.12186964e-02f,
  -1.88132524e-01f, -7.97120333e-02f, -1.18117752e-02f, -2.95373884e-05f, 5.16309179e-02f, -7.17839152e-02f, -6.48102164e-02f, 6.32733852e-02f, -8.22717249e-02f, -7.14875683e-02f,
  -1.26852274e-01f, 8.08358341e-02f, 3.62547636e-02f, -2.30042264e-02f, -5.29272705e-02f, -8.50576325e-05f, -1.60655975e-02f, 1.31072970e-02f, 3.45711969e-02f, 2.42028367e-02f,
  -1.09874941e-01f, 4.01156805e-02f, -3.65779959e-02f, -7.01093897e-02f, 7.05713034e-02f, 2.05626502e-03f, 7.76896030e-02f, -1.89817026e-02f, 9.24374089e-02f, -7.54362345e-02f,
  1.47903711e-01f, -1.90109890e-02f, 9.46022570e-02f, -1.60021372e-02f, 3.94456349e-02f, 3.79064493e-02f, 1.73523594e-02f, 4.70493622e-02f, 5.22625409e-02f, 3.37895565e-02f,
  1.03845835e-01f, 1.16983205e-01f, -9.64766517e-02f, -7.99647868e-02f, -4.34375592e-02f, -2.03375779e-02f, -2.83380933e-02f, 4.67310958e-02f, -1.37216091e-01f, -3.93900573e-02f,
  1.76522993e-02f, 3.44497636e-02f, -1.20891957e-02f, -1.02899164e-01f, -5.89019991e-02f, -5.31506799e-02f, 7.35993087e-02f, -1.61979534e-02f, 7.58951239e-04f, -5.82116432e-02f,
  -4.97186631e-02f, -5.11323251e-02f, -4.38816585e-02f, -7.17015639e-02f, -1.58453226e-01f, 7.12429881e-02f, -5.38005158e-02f, 7.50524644e-03f, 4.21206355e-02f, -2.72493865e-02f,
  -2.43526727e-01f, -6.88458979e-02f, 3.12424544e-03f, 2.94688269e-02f, 4.75016534e-02f, -1.83810994e-01f, -8.41846317e-02f, -1.23003125e-02f, -2.80725602e-02f, -1.10707562e-02f,
  -1.35311186e-01f, -4.35415298e-01f, -3.96769851e-01f, -8.16500559e-03f, -1.03316970e-01f, 1.02782488e-01f, 4.50021505e-01f, -2.01907098e-01f, -1.74023405e-01f, 2.28239372e-01f,
  3.53476614e-01f, -5.81098348e-02f, 6.46869391e-02f, 2.98298061e-01f, 1.96226195e-01f, 3.17435712e-01f, 2.04121679e-01f, 3.08646917e-01f, -2.18092918e-01f, -8.37756544e-02f,
  -1.34249732e-01f, 2.43153751e-01f, 7.13909864e-02f, -3.08277518e-01f, -1.26146711e-02f, -3.37846547e-01f, 1.33379102e-01f, -1.38581291e-01f, 1.32781267e-01f, 1.97112948e-01f,
  1.26992494e-01f, -2.13823438e-01f, 8.23035240e-02f, 4.65226807e-02f, 8.07967857e-02f, 2.43384093e-02f, 9.36490074e-02f, 1.60299450e-01f, 3.10257040e-02f, -6.57078102e-02f,
  4.54470403e-02f, -9.10818279e-02f, -1.01894885e-01f, 4.89929728e-02f, -1.57220870e-01f, -1.93074837e-01f, -1.90398365e-01f, -5.51770143e-02f, -9.10896584e-02f, -6.87092170e-02f,
  -3.67230326e-02f, -6.85390905e-02f, 5.78498282e-02f, 2.11541150e-02f, -2.33017616e-02f, -1.87470876e-02f, 1.85219552e-02f, 1.06219193e-02f, 4.59232777e-02f, -2.31665179e-01f,
  5.76580614e-02f, 3.04807629e-02f, 6.26691803e-02f, -1.68210710e-03f, -5.55176884e-02f, -3.52299027e-02f, 1.45569637e-01f, -1.28832832e-02f, 2.68146601e-02f, -4.71896827e-02f,
  -1.35814622e-01f, 2.21003033e-02f, -2.99259871e-02f, 6.99299872e-02f, 1.13112614e-01f, 4.50377353e-02f, 5.11442369e-04f, 4.63502994e-03f, -1.84733510e-01f, -3.21995094e-02f,
  -7.23171309e-02f, -1.25522822e-01f, -2.14505922e-02f, 1.45393342e-01f, 4.03074101e-02f, 3.05890106e-02f, -4.44881655e-02f, -1.72346264e-01f, -1.89261138e-02f, 1.70297876e-01f,
  -1.48094818e-01f, -3.23892295e-01f, -7.35338777e-02f, 1.65366400e-02f, 9.70260054e-02f, -2.76108719e-02f, -1.36353001e-02f, -1.96470067e-01f, 7.74641186e-02f, -1.66067198e-01f,
  -3.37453485e-02f, 9.57800522e-02f, -1.64252043e-01f, 5.80110028e-03f, 1.17011026e-01f, -3.76727432e-02f, 2.09369019e-01f, 5.51336780e-02f, 1.25304759e-01f, -1.06662981e-01f,
  -6.52534813e-02f, -1.18533611e-01f, 9.80711952e-02f, -7.30416328e-02f, 1.61424503e-01f, 4.38828990e-02f, -3.85696031e-02f, -1.16138430e-02f, 5.68535514e-02f, -9.33109820e-02f,
  -1.58194900e-02f, 4.52419370e-01f, -4.91139330e-02f, 2.46157008e-03f, 3.03921431e-01f, 5.68200350e-01f, 2.60029644e-01f, 1.93150014e-01f, 2.91375220e-01f, 4.04767655e-02f,
  1.62601043e-02f, 9.75928754e-02f, -9.17960256e-02f, 1.86334565e-01f, 2.49973267e-01f, 1.27752364e-01f, 2.40381926e-01f, 1.95671543e-01f, 3.48567277e-01f, -9.92422253e-02f,
  1.22083835e-01f, -2.56368481e-02f, -2.96585232e-01f, 1.13464650e-02f, -1.21501133e-01f, -7.43313581e-02f, -3.89824182e-01f, -1.41450856e-02f, -2.57833302e-01f, 2.86434472e-01f,
  -6.11670949e-02f, 9.74083170e-02f, 3.39465216e-02f, 5.51906675e-02f, 4.86535095e-02f, -8.08068961e-02f, -2.24521309e-02f, -3.02578378e-02f, -6.69025332e-02f, 2.11481526e-02f,
  -8.24173614e-02f, -1.85424358e-01f, 1.33946821e-01f, 1.01003945e-01f, 1.03675559e-01f, -1.92985125e-02f, -8.42449591e-02f, -4.01010597e-03f, 3.93160433e-02f, 7.40350559e-02f,
  2.79567912e-02f, -7.26973861e-02f, -1.31994933e-01f, 7.55036250e-02f, 1.53175309e-01f, 8.23635682e-02f, 2.96727531e-02f, 2.83150673e-02f, 8.82654190e-02f, 7.37827132e-03f,
  6.33519590e-02f, 5.22649847e-02f, 9.33891628e-03f, -5.03819026e-02f, 1.09476760e-01f, 1.21815354e-01f, 4.14314009e-02f, 2.26796363e-02f, 1.36433944e-01f, 4.67472635e-02f,
  6.33570030e-02f, 8.28687847e-02f, 1.19716927e-01f, -2.29733717e-02f, 5.67172207e-02f, -4.47963038e-03f, -6.41391203e-02f, 7.09903613e-02f, 2.85456143e-02f, -1.01067744e-01f,
  1.61400456e-02f, 7.26609975e-02f, -2.87472382e-02f, -5.28137721e-02f, 8.57349485e-02f, 3.02794017e-02f, 1.33929089e-01f, -1.81887429e-02f, -4.33004759e-02f, 9.70440283e-02f,
  1.89644784e-01f, 3.90910804e-01f, 2.87216878e-03f, 1.90185290e-02f, -3.36247943e-02f, -8.55148211e-02f, -8.54013197e-04f, 2.93414723e-02f, 1.06718585e-01f, 9.37385708e-02f,
  5.80157340e-02f, -8.80729035e-02f, -4.74539958e-02f, -1.35533035e-01f, 9.27507319e-03f, 1.75232947e-01f, -6.40795529e-02f, 1.29740760e-01f, 4.76326533e-02f, 1.10941410e-01f,
  -7.59866263e-04f, 7.30754342e-03f, -1.28569141e-01f, 1.32990226e-01f, 1.72422767e-01f, -7.46362209e-02f, 9.33099017e-02f, -6.86957613e-02f, 4.42407615e-02f, 1.16655808e-02f,
  -9.22851264e-03f, 3.82110536e-01f, 2.12629989e-01f, -2.30051771e-01f, -5.69638945e-02f, -3.95506293e-01f, -2.90938228e-01f, 1.26605496e-01f, 9.77754965e-02f, 2.44014442e-01f,
  -1.43066332e-01f, 3.73815417e-01f, 1.88019782e-01f, -2.12510332e-01f, -3.71126950e-01f, -1.39315650e-01f, -4.73198175e-01f, -1.34479031e-01f, 9.38259810e-03f, -2.51489431e-01f,
  -2.30351672e-01f, -4.76201326e-01f, -1.98622644e-01f, -2.43162066e-01f, -1.01544634e-01f, 1.21878363e-01f, -2.52857357e-01f, 8.57229084e-02f, -7.33489543e-02f, 5.25596179e-02f,
  1.66371495e-01f, 1.85046166e-01f, 1.92294165e-01f, 3.31977531e-02f, -6.91673458e-02f, -3.98062840e-02f, 9.85154230e-03f, -5.79960179e-03f, 4.48299386e-02f, 9.80872363e-02f,
  2.87591610e-02f, 1.24666207e-02f, -1.12365186e-01f, 4.35734130e-02f, -6.89582294e-03f, 8.94274041e-02f, 5.93967400e-02f, 7.20857829e-02f, 9.27251428e-02f, -4.57448401e-02f,
  9.82911326e-03f, 1.08019352e-01f, -9.23297778e-02f, -2.12218687e-02f, 9.13182870e-02f, 3.90559845e-02f, -5.41995466e-02f, 9.41261798e-02f, -8.76381323e-02f, -1.61025785e-02f,
  -1.69874921e-01f, -9.37669501e-02f, -7.28580728e-02f, 6.49645776e-02f, -4.23327610e-02f, 5.30940630e-02f, -2.52994839e-02f, 1.14310443e-01f, -3.78745683e-02f, 1.71273835e-02f,
  -9.92886275e-02f, 3.38462554e-02f, -4.89742123e-02f, -1.18329972e-01f, -1.82390913e-01f, 1.22332864e-01f, -9.89130065e-02f, 3.48302699e-03f, -1.65402964e-02f, 1.12655740e-02f,
  -5.09115532e-02f, -1.06895521e-01f, -1.78806446e-02f, -4.48361188e-02f, 2.54569929e-02f, -3.25242579e-02f, -9.66016483e-03f, 3.35847251e-02f, 9.99001637e-02f, -2.17137694e-01f,
  -8.37127771e-03f, -1.61326304e-01f, 9.90948528e-02f, 1.62936583e-01f, 6.42429069e-02f, -2.94838324e-02f, -9.61641874e-03f, 1.04686106e-02f, -1.10741490e-02f, -1.83192849e-01f,
  -8.50144923e-02f, 2.30762437e-02f, -1.13103669e-02f, -5.47816046e-03f, -8.00167322e-02f, -6.50700927e-02f, -6.39491230e-02f, -6.00356422e-02f, -1.23026311e-01f, 1.17502213e-02f,
  -7.07921013e-02f, -4.47507165e-02f, 2.43588667e-02f, -2.00879807e-03f, -1.21928446e-01f, 2.65091918e-02f, 5.76940812e-02f, 1.06921494e-01f, -1.02856077e-01f, -4.00931463e-02f,
  -1.55212700e-01f, -2.06272542e-01f, 1.43705308e-01f, -8.87842998e-02f, -2.13054046e-02f, 2.46125251e-01f, 1.52707651e-01f, 4.78153713e-02f, 5.18352203e-02f, 4.48126085e-02f,
  3.56555022e-02f, -3.12325954e-01f, -1.93571690e-02f, -3.83085907e-01f, -2.76702106e-01f, -1.58720866e-01f, 3.33539657e-02f, -1.89276934e-02f, -1.44168615e-01f, 2.45805129e-01f,
  9.37345251e-02f, -3.00915122e-01f, 1.40087381e-01f, -4.65818979e-02f, -9.95161850e-03f, 1.77535206e-01f, 2.48050511e-01f, 7.45842159e-02f, 1.83244705e-01f, -1.05794840e-01f,
  1.10512815e-01f, -1.67953417e-01f, -2.76026502e-02f, -8.20535570e-02f, 2.87360519e-01f, 8.69091228e-02f, 1.09495379e-01f, -1.24811970e-01f, -5.06039560e-02f, 1.37561291e-01f,
  4.35954593e-02f, 5.99334482e-03f, -1.54598206e-01f, 2.33717039e-02f, 6.44455999e-02f, -3.16533335e-02f, 8.76152366e-02f, 9.62540656e-02f, -1.21547252e-01f, -1.64346963e-01f,
  -1.69049855e-02f, 3.12519842e-03f, 1.41598821e-01f, -1.24521501e-01f, -1.47818014e-01f, 3.59835103e-02f, 4.97155711e-02f, 1.18008278e-01f, 9.32431892e-02f, 5.58129959e-02f,
  -1.32952571e-01f, -5.33949621e-02f, 6.44737016e-03f, 8.01346600e-02f, -3.21570300e-02f, 1.61010876e-01f, 7.41934180e-02f, -7.89669249e-03f, -2.13103797e-02f, 9.27816257e-02f,
  5.03929332e-02f, 1.68629512e-02f, 1.29786596e-01f, 1.70114681e-01f, -1.44081876e-01f, -9.81406122e-02f, -3.21134739e-02f, -8.43890160e-02f, 1.18909918e-01f, 6.73019439e-02f,
  -1.04695499e-01f, 4.62193275e-03f, -5.70290014e-02f, 1.04399018e-01f, -3.60030159e-02f, 8.60581398e-02f, -9.36126523e-03f, -1.53936520e-02f, 1.03175901e-01f, 1.53620377e-01f,
  2.55792588e-01f, 7.20938966e-02f, -3.98898721e-02f, -5.27983569e-02f, 2.53164000e-03f, -6.14071004e-02f, -1.13951884e-01f, -1.15297176e-01f, 1.38657346e-01f, -4.28699777e-02f,
  6.85911477e-02f, 1.88978672e-01f, 1.75781310e-01f, -1.05674639e-02f, -5.28362319e-02f, 6.32655546e-02f, 3.11341919e-02f, -6.85673356e-02f, 9.81328562e-02f, -1.13289930e-01f,
  -1.42811611e-01f, 7.35120997e-02f, 3.16230170e-02f, -7.65588600e-03f, -1.40749186e-01f, 6.24981336e-02f, -5.73842525e-02f, -1.02429658e-01f, 4.19242233e-02f, 1.11777067e-01f,
  -4.82121520e-02f, 2.07824692e-01f, 2.40811780e-01f, 1.23431152e-02f, -1.90120578e-01f, -1.47859752e-01f, -1.83589116e-01f, 2.54475862e-01f, -2.94089824e-01f, 9.17151272e-02f,
  1.31322995e-01f, -4.51569520e-02f, 3.41575146e-02f, -1.14495605e-02f, -6.33813515e-02f, -2.57917643e-01f, 1.34055063e-01f, -2.63506789e-02f, -1.21553555e-01f, 1.93909615e-01f,
  1.55306444e-01f, 3.40580866e-02f, 2.22919598e-01f, 1.95647210e-01f, 2.05182090e-01f, 2.98920214e-01f, 3.56875271e-01f, 4.42670062e-02f, 3.09693903e-01f, -1.34726986e-01f,
  -1.20839532e-02f, 1.92389544e-02f, 1.05878733e-01f, 2.78300215e-02f, 2.96325505e-01f, 6.40169755e-02f, 1.28418222e-01f, -1.36943832e-01f, -5.20983785e-02f, -1.80042498e-02f,
  5.35116456e-02f, -5.29431365e-02f, -6.57719895e-02f, -1.89281181e-01f, -6.08232468e-02f, -4.55629565e-02f, 2.71871723e-02f, -4.17848527e-02f, -7.30327517e-03f, 1.23810910e-01f,
  8.99562761e-02f, 4.55641150e-02f, -4.34438325e-02f, -4.14761268e-02f, 7.21411631e-02f, -5.54840825e-03f, 6.74747899e-02f, 2.69517750e-01f, -1.71655476e-01f, 9.39752012e-02f,
  -8.95016082e-03f, -6.85891658e-02f, -1.72778219e-02f, 3.62169333e-02f, -4.71747620e-03f, 5.03802709e-02f, -1.39731213e-01f, 2.75720702e-03f, -2.78200302e-02f, -2.32673287e-02f,
  7.56205618e-03f, 1.05471581e-01f, -9.05191153e-02f, -2.37336271e-02f, 7.37453550e-02f, -6.36553690e-02f, -4.06519659e-02f, -3.70286293e-02f, 3.27198431e-02f, 4.99154953e-03f,
  -1.54958174e-01f, -9.47371051e-02f, 4.29649353e-02f, -5.61990179e-02f, -8.37157220e-02f, 6.47138953e-02f, 4.19120342e-02f, 7.06470991e-03f, 2.81858817e-02f, -1.28933132e-01f,
  2.26705000e-01f, 1.35464728e-01f, 9.40274447e-02f, -1.84815273e-01f, -1.52771955e-03f, 2.95664947e-02f, 1.72949377e-02f, -2.45674346e-02f, 1.20981283e-01f, 1.32212147e-01f,
  2.76265681e-01f, 3.17844306e-03f, 3.91299725e-02f, 9.58846509e-03f, 3.71000431e-02f, 1.15146473e-01f, 9.55953747e-02f, 5.07861562e-02f, 1.39137581e-01f, 2.54784763e-01f,
  4.60874811e-02f, 9.38772708e-02f, 5.81594035e-02f, -9.35345516e-02f, 5.31433485e-02f, 4.19485867e-02f, -3.74586843e-02f, 1.01032868e-01f, -5.02861403e-02f, -6.04158416e-02f,
  -2.77162701e-01f, 4.59286094e-01f, -3.30763161e-01f, 5.18157929e-02f, -1.50252223e-01f, 4.88681823e-01f, 3.94924760e-01f, 9.42033753e-02f, 9.52153280e-02f, 3.73795480e-01f,
  1.28063127e-01f, -1.47275552e-01f, 2.18477800e-01f, 2.90021658e-01f, -4.32105139e-02f, 2.90105581e-01f, 4.14830089e-01f, 3.08589965e-01f, -9.50034410e-02f, 1.19391695e-01f,
  -1.84506252e-01f, 3.41343611e-01f, -1.07368231e-01f, 6.45134225e-02f, -7.85695240e-02f, -2.71849543e-01f, -5.22590280e-02f, -3.13978791e-01f, 3.81303020e-02f, 5.92391044e-02f,
  -2.23920085e-02f, -3.99954244e-02f, -8.95783156e-02f, -2.00496707e-02f, -3.28996852e-02f, -2.55224314e-02f, -9.86388102e-02f, -1.04941420e-01f, -1.33927107e-01f, -3.74761969e-02f,
  4.24678363e-02f, -4.72233593e-02f, 1.59725428e-01f, -7.84955472e-02f, 1.08148055e-02f, -2.16002334e-02f, 3.95341814e-02f, 1.07159764e-01f, 6.49414361e-02f, 5.26165329e-02f,
  -4.48737890e-02f, -7.85459429e-02f, -3.64586152e-02f, 6.77352846e-02f, -6.58531263e-02f, 3.16826440e-02f, 2.12263931e-02f, -2.13878322e-02f, 1.69219729e-02f, 4.54804637e-02f,
  -4.07495489e-03f, -6.48324788e-02f, 1.13916837e-01f, 3.27726901e-02f, 2.15505064e-02f, -2.87264530e-02f, 8.90489370e-02f, -2.90264916e-02f, 5.91602828e-03f, 5.16136065e-02f,
  3.11521273e-02f, -4.39653732e-02f, 6.91865385e-02f, -5.54141104e-02f, 3.55124176e-02f, 9.70485061e-02f, -7.99451917e-02f, -2.37776022e-02f, 4.03415188e-02f, -5.45377545e-02f,
  3.50369997e-02f, -3.28189246e-02f, 1.65274799e-01f, -5.71269775e-03f, 1.11462586e-01f, -1.10607177e-01f, -1.34320175e-02f, -4.89230007e-02f, 3.76823954e-02f, -7.90089220e-02f,
  2.89166033e-01f, 3.13266367e-01f, 7.15492070e-02f, -6.58238493e-03f, -1.18220158e-01f, 3.23852785e-02f, 2.01745089e-02f, -5.09972312e-02f, 8.47544223e-02f, 3.23794112e-02f,
  7.15817437e-02f, 1.30346745e-01f, -5.33218728e-03f, -5.33912927e-02f, -7.56036118e-02f, 2.44192198e-01f, 6.07701987e-02f, -5.44827878e-02f, -5.26979147e-03f, -7.93049932e-02f,
  -9.38647464e-02f, 6.31206110e-02f, -1.05129547e-01f, 6.63745776e-02f, 8.64670351e-02f, 9.54939574e-02f, 9.02331620e-02f, -2.94006206e-02f, 2.18552388e-02f, 1.57257803e-02f,
  5.02361031e-03f, -4.18917388e-02f, -1.55111551e-01f, -3.23995709e-01f, -7.62967840e-02f, -3.14452916e-01f, -2.56992966e-01f, -1.33891866e-01f, 9.96172130e-02f, 1.58356339e-01f,
  -1.38615072e-01f, -1.26675237e-02f, 9.89926886e-03f, -3.44425589e-01f, -4.59493160e-01f, 6.20980412e-02f, -3.67662191e-01f, -1.75898194e-01f, 1.59922019e-01f, -1.09103270e-01f,
  -1.76934198e-01f, -6.31023571e-02f, -1.84695601e-01f, 1.67588770e-01f, -1.20232411e-01f, 8.28467533e-02f, 2.43021935e-01f, 4.76643536e-03f, -1.83522657e-01f, 5.11581227e-02f,
  -3.84079181e-02f, -6.11661524e-02f, -9.55838785e-02f, 7.67705292e-02f, -1.71542525e-01f, -1.26137631e-02f, -6.99329078e-02f, 4.52279188e-02f, 1.24464799e-02f, -5.10607772e-02f,
  -3.43536697e-02f, 3.71477120e-02f, 7.96976760e-02f, 1.84665382e-01f, 6.12457246e-02f, 8.24874863e-02f, -1.35054737e-01f, 1.38112511e-02f, 5.65860234e-03f, 3.84938009e-02f,
  -1.74438179e-01f, -9.57037359e-02f, -1.00163981e-01f, -6.21491559e-02f, -1.32716030e-01f, -1.17560007e-01f, -9.66361612e-02f, 5.10777906e-03f, -3.97396795e-02f, -6.05902709e-02f,
  5.34026325e-02f, 8.34133774e-02f, 2.84317825e-02f, 7.82161858e-03f, 2.11185422e-02f, 1.73752836e-03f, -2.42430195e-02f, 8.12823772e-02f, -1.07169794e-02f, -5.17669171e-02f,
  1.00333199e-01f, -7.40618557e-02f, 1.36872485e-01f, -2.25359667e-02f, -9.67909116e-03f, -4.76411618e-02f, -3.74155305e-02f, 5.38785756e-02f, -5.49944565e-02f, -1.23947799e-01f,
  2.93211488e-04f, -9.85095650e-02f, 6.26483336e-02f, 3.80618498e-02f, -8.11535195e-02f, 2.23753676e-02f, 1.59204692e-01f, -1.09276704e-01f, -4.88079675e-02f, 4.45841476e-02f,
  -4.51711491e-02f, -1.29946889e-02f, -9.30044502e-02f, 4.07814123e-02f, -7.21135661e-02f, -7.84152001e-02f, -4.61463742e-02f, 3.12313531e-02f, 8.47568386e-04f, 8.24491959e-03f,
  -2.56671961e-02f, -8.06548633e-03f, 7.48915747e-02f, 9.26746149e-03f, -2.36733314e-02f, -9.28630382e-02f, -4.26711962e-02f, 1.34304464e-01f, -4.60167378e-02f, -4.04157117e-02f,
  5.57491370e-02f, 1.21111929e-01f, -2.24245079e-02f, -8.83799698e-03f, 6.72832504e-02f, 5.31057902e-02f, 5.74846268e-02f, 3.37174833e-02f, 7.69859999e-02f, 6.63319901e-02f,
  2.55996317e-01f, -2.04981938e-01f, -3.86357188e-01f, 1.71744391e-01f, 4.10393685e-01f, 3.05165559e-01f, 4.86903638e-03f, 1.27098754e-01f, 1.21075749e-01f, -2.18793467e-01f,
  2.38378137e-01f, -1.10303707e-01f, -3.50661755e-01f, 2.87223190e-01f, 3.36154789e-01f, -2.91673154e-01f, 3.32362711e-01f, 2.52582341e-01f, 3.67351510e-02f, 2.08291430e-02f,
  1.91383183e-01f, 3.96041363e-01f, -1.27446085e-01f, 1.72608018e-01f, 2.22622201e-01f, -8.29575509e-02f, 4.22893129e-02f, -3.51348162e-01f, 1.39012113e-01f, 1.79610431e-01f,
  1.52676180e-01f, 4.75586057e-02f, -9.73301212e-05f, -1.05209224e-01f, -3.49090323e-02f, 6.61238935e-03f, -7.05944300e-02f, -8.38372409e-02f, 6.27776980e-02f, -6.24150131e-03f,
  -1.59108967e-01f, 5.08419797e-02f, 5.94057292e-02f, -2.76536644e-02f, 7.65735656e-02f, 1.18568912e-01f, 3.89247686e-02f, 8.20530392e-03f, 4.31068838e-02f, -1.41128168e-01f,
  -9.29586738e-02f, -4.58470779e-03f, 1.07519999e-01f, -5.18998690e-02f, -1.38324564e-02f, 3.27247456e-02f, 5.26703745e-02f, -4.38260436e-02f, 9.40866917e-02f, 8.33262354e-02f,
  -6.37973323e-02f, -1.17946997e-01f, -3.01206000e-02f, -6.74533397e-02f, -2.45679729e-03f, 3.76640670e-02f, -2.33322605e-02f, 9.56357867e-02f, -6.49886206e-02f, 2.90882103e-02f,
  5.27031440e-03f, 3.91116217e-02f, 6.33971347e-03f, -7.83681422e-02f, 5.08080050e-02f, -9.93171614e-03f, 3.12217548e-02f, -2.72209290e-02f, 3.40314284e-02f, 4.92957719e-02f,
  -9.53083336e-02f, 7.95158669e-02f, -1.33739635e-02f, 1.87514108e-02f, 5.90847572e-03f, -1.00292284e-02f, -1.00095578e-01f, -3.43733653e-02f, -7.02520041e-03f, -3.25768366e-02f,
  -6.43281788e-02f, -2.30070531e-01f, -6.35187849e-02f, 4.30732816e-02f, 3.59024704e-02f, 8.09068978e-02f, 3.17746922e-02f, 1.14625856e-01f, -1.03739418e-01f, 3.60157564e-02f,
  5.24115264e-02f, -9.82609764e-02f, 6.28035888e-02f, 3.45809050e-02f, 1.55118570e-01f, -3.84892151e-02f, -1.39323190e-01f, 5.90829886e-02f, 5.15191853e-02f, -1.87063292e-02f,
  -1.39630204e-02f, -7.46052638e-02f, 9.25261080e-02f, 1.37036636e-01f, 5.62668294e-02f, 5.67445531e-02f, 4.56021912e-02f, -4.86225113e-02f, -9.58940610e-02f, 3.09843738e-02f,
  3.54283333e-01f, 4.37460065e-01f, 4.30449158e-01f, 5.87418675e-01f, -4.56669331e-01f, -2.53624082e-01f, -2.34737650e-01f, 8.16345587e-02f, 3.35402310e-01f, -1.88712820e-01f,
  -2.87827820e-01f, 3.69042665e-01f, -3.80721360e-01f, 1.28358275e-01f, -3.33286636e-02f, 3.65816392e-02f, 2.84526914e-01f, 8.40639547e-02f, 2.91375488e-01f, -2.94148289e-02f,
  2.24172965e-01f, -3.44916165e-01f, 1.59859255e-01f, -2.00264663e-01f, 1.85766637e-01f, 2.17190668e-01f, -1.28009766e-01f, -1.46189094e-01f, 1.20033190e-01f, -2.00014725e-01f,
  -1.66297391e-01f, 1.38001785e-01f, 1.34191051e-01f, -4.10358384e-02f, -1.65946838e-02f, 5.69983795e-02f, -6.28024638e-02f, -1.35144770e-01f, -3.59009504e-02f, 2.16044765e-02f,
  -9.26704258e-02f, -4.58652079e-02f, 1.43881261e-01f, 4.57249768e-03f, -4.09709550e-02f, 2.10298017e-01f, 6.12021051e-02f, 7.42249042e-02f, 3.51002924e-02f, 8.95092860e-02f,
  5.01086190e-02f, 1.04883976e-01f, 2.54586693e-02f, 7.62575888e-04f, 2.55301148e-02f, 6.22547530e-02f, 9.51730087e-03f, 1.94254704e-02f, 1.97279677e-01f, 1.29234483e-02f,
  -1.24923564e-01f, 1.40354037e-01f, 1.68455634e-02f, 3.54441330e-02f, -1.17420152e-01f, -1.04542777e-01f, -3.31227966e-02f, -9.04224440e-03f, 8.54768008e-02f, -2.55768728e-02f,
  -6.93327859e-02f, 1.63023710e-01f, 1.74156553e-03f, 9.19356868e-02f, -3.85229811e-02f, -1.88735570e-03f, -1.16151415e-01f, 6.36256188e-02f, 5.46010882e-02f, -1.90924406e-02f,
  -5.05241454e-02f, -6.43886551e-02f, 8.85356516e-02f, -8.39646757e-02f, -4.84568998e-02f, 1.17732184e-02f, 1.77702099e-01f, 1.27297610e-01f, -1.50469970e-02f, 1.56549569e-02f,
  -2.06813559e-01f, 2.25776419e-01f, -7.53428340e-02f, -2.52434313e-01f, -2.10984331e-02f, 4.01535928e-02f, 1.17201097e-01f, 9.45563242e-02f, 1.27487391e-01f, -1.60248831e-01f,
  6.89727953e-03f, -5.89433201e-02f, -1.63372606e-01f, 3.18850130e-02f, -1.12512894e-01f, 7.48236701e-02f, -2.28269324e-02f, 4.30467352e-03f, -9.65974778e-02f, 1.33553401e-01f,
  -1.33260250e-01f, -4.82531227e-02f, -3.14771496e-02f, -3.02807800e-02f, 1.03856072e-01f, 4.37058359e-02f, 4.20905277e-02f, 9.82175171e-02f, -9.00532976e-02f, 9.34711620e-02f,
  2.87137032e-01f, 4.77259874e-01f, -2.07740739e-01f, 6.90484792e-02f, 3.35237868e-02f, 4.18202788e-01f, 1.88749328e-01f, 1.84115961e-01f, 2.71543264e-01f, 1.82749316e-01f,
  1.42364739e-03f, 3.54979694e-01f, -7.17245936e-02f, 2.43697718e-01f, 2.13152289e-01f, 9.15641040e-02f, 3.73231113e-01f, 2.21857697e-01f, 9.12932530e-02f, 3.11301917e-01f,
  3.98314409e-02f, 1.69037715e-01f, -3.22413146e-01f, -2.77740024e-02f, 1.26775905e-01f, -9.51829180e-02f, -2.96983302e-01f, -2.32854679e-01f, 5.23001561e-03f, 1.29744753e-01f,
  -4.47925329e-02f, 9.19516683e-02f, -4.92602438e-02f, -9.33122113e-02f, -1.76253188e-02f, -1.23864003e-01f, -1.05074033e-01f, -1.11477770e-01f, -2.86470503e-02f, 8.38823803e-03f,
  1.23170339e-01f, 1.05311871e-01f, -1.98289771e-02f, -4.46141213e-02f, 3.87269780e-02f, -2.89666485e-02f, -7.69718289e-02f, -1.03900559e-01f, 3.10292356e-02f, 2.72311028e-02f,
  -7.84586072e-02f, -1.12164570e-02f, -4.55401279e-02f, 4.35423926e-02f, 4.40708920e-02f, 7.12223575e-02f, 8.88715461e-02f, -3.19854841e-02f, 6.24894500e-02f, 1.46642983e-01f,
  -7.26572052e-03f, 1.09605409e-01f, 4.15769927e-02f, -1.64442286e-02f, 9.47177224e-03f, -1.29341632e-01f, -8.44094977e-02f, -1.07835401e-02f, -4.64040712e-02f, 7.04089999e-02f,
  -3.49300355e-02f, -8.95981938e-02f, 5.51856533e-02f, 3.00545786e-02f, 1.25250146e-01f, 1.75114255e-02f, -5.47006838e-02f, -3.25960852e-02f, 7.83612430e-02f, -2.61763036e-02f,
  -1.83756929e-02f, 1.13702960e-01f, 3.84983420e-02f, -5.54953963e-02f, 4.86797355e-02f, -9.50047225e-02f, -7.58701041e-02f, 1.92131959e-02f, -1.32016027e-02f, 2.63316687e-02f,
  1.41802490e-01f, 2.42755264e-01f, -6.78950846e-02f, 5.82748577e-02f, -8.03809166e-02f, 4.90473472e-02f, 3.41871269e-02f, 9.65496376e-02f, 1.10343769e-01f, 1.15239948e-01f,
  -3.27604683e-03f, 3.90180908e-02f, -7.33236596e-02f, 3.79994884e-02f, 2.40295436e-02f, 7.28910565e-02f, -2.76459083e-02f, 9.97417327e-03f, 3.65970917e-02f, 9.23978612e-02f,
  -6.14553057e-02f, 4.42330129e-02f, 4.38503511e-02f, -1.15991635e-02f, 1.05445229e-01f, 5.99078415e-03f, 1.02581777e-01f, -5.96521869e-02f, -3.00293993e-02f, -2.31756996e-02f,
  1.03750631e-01f, 2.54506797e-01f, 3.08876991e-01f, -1.42139152e-01f, 1.05566261e-02f, 3.41635972e-01f, -1.33101821e-01f, 4.48661745e-02f, -1.18229434e-01f, 2.56114990e-01f,
  -1.84128016e-01f, 2.53457248e-01f, -2.18623608e-01f, -1.05536111e-01f, -1.25395223e-01f, -2.51591831e-01f, -5.94542474e-02f, -1.39509887e-02f, -2.11023331e-01f, 1.36967689e-01f,
  -1.23020209e-01f, -2.75391132e-01f, -2.22244501e-01f, -1.95571631e-01f, 6.94205761e-02f, 1.49141029e-01f, -2.78334618e-01f, -1.57365859e-01f, 1.09476559e-01f, -1.80328503e-01f,
  -7.07308799e-02f, -2.99429130e-02f, 7.64579028e-02f, 6.47472665e-02f, 4.61125113e-02f, 2.27112770e-01f, 1.64772362e-01f, 1.19469976e-02f, -8.79586712e-02f, 7.14613646e-02f,
  5.96735738e-02f, -4.70458763e-03f, 1.45987436e-01f, -1.24772169e-01f, -4.03789543e-02f, 6.96718618e-02f, -3.18450592e-02f, 2.23874584e-01f, 1.45963177e-01f, 6.30362406e-02f,
  8.50578025e-02f, 1.41199946e-01f, 2.46033557e-02f, 3.54244597e-02f, -2.62880269e-02f, -1.34413429e-02f, 5.63929379e-02f, 1.42617047e-01f, 1.29228635e-02f, -1.39117790e-02f,
  5.56006990e-02f, 9.72278416e-02f, 2.65352316e-02f, -2.06234455e-02f, -5.65017648e-02f, -6.90564513e-02f, -5.63575141e-02f, -9.22503769e-02f, -1.68858040e-02f, 5.98830506e-02f,
  -1.86632555e-02f, 4.38765762e-03f, -1.87873840e-01f, 9.87336934e-02f, -3.43831070e-02f, 1.27100432e-02f, 6.28931671e-02f, 4.03294377e-02f, -3.65098976e-02f, 5.57076074e-02f,
  -1.38767347e-01f, -9.40005481e-03f, -6.50268495e-02f, -1.24580212e-01f, 4.88588884e-02f, -5.48081994e-02f, 6.44527748e-03f, 8.68247524e-02f, -1.13605961e-01f, -5.43234730e-03f,
  1.19039960e-01f, 9.85604376e-02f, 1.32760238e-02f, -8.12424533e-03f, 2.80106850e-02f, 2.02878594e-01f, -6.78727636e-04f, 8.48692730e-02f, -1.88460853e-02f, 5.81754521e-02f,
  7.31728524e-02f, 6.59536151e-03f, 2.94855982e-01f, -1.30522251e-01f, -5.78765608e-02f, 1.06830694e-01f, 4.88633029e-02f, 1.05314873e-01f, -1.10294868e-03f, 8.90980810e-02f,
  1.02110207e-01f, 8.13018158e-02f, -1.42410332e-02f, -3.78128514e-02f, 2.78302282e-02f, -2.89573763e-02f, 1.55790642e-01f, -5.14378995e-02f, -4.79302518e-02f, -2.85157212e-03f,
  2.36223727e-01f, -2.41998807e-01f, 5.97236194e-02f, 2.75939196e-01f, -1.56970769e-01f, -2.47305006e-01f, 8.80873725e-02f, -1.77246764e-01f, 1.71721950e-01f, -2.86340266e-01f,
  -1.60005763e-01f, 2.58089453e-01f, 2.24532243e-02f, -2.57170349e-01f, 2.61525184e-01f, 2.91856647e-01f, -2.00724024e-02f, 2.22606286e-01f, 1.09931484e-01f, -1.33623064e-01f,
  4.53660265e-02f, -3.13275695e-01f, -1.10952370e-01f, -3.80939782e-01f, -3.40817124e-01f, -1.51937649e-01f, -7.72206336e-02f, -1.04515262e-01f, -3.39724004e-01f, -5.58347106e-02f,
  -6.15895279e-02f, -6.45778030e-02f, 1.87075939e-02f, 2.95159109e-02f, -1.44238053e-02f, -9.87373963e-02f, 6.45239055e-02f, -9.33640730e-03f, -2.52837464e-02f, 8.06984156e-02f,
  1.85246468e-01f, -8.18773881e-02f, 6.65722117e-02f, 7.65921399e-02f, -6.09527938e-02f, -7.90711939e-02f, 3.39410268e-02f, -4.60211970e-02f, -8.74679014e-02f, 9.89285931e-02f,
  2.70706769e-02f, -2.27514990e-02f, 1.95664614e-02f, 5.17475046e-02f, 1.94507822e-01f, -5.93564957e-02f, 4.95793484e-02f, 2.53860563e-01f, 8.19341540e-02f, 9.54141170e-02f,
  -9.98547859e-03f, 3.10109928e-02f, -1.01577923e-01f, -1.16001412e-01f, -3.89847066e-03f, -9.48094949e-02f, -6.63025528e-02f, -3.11775841e-02f, -3.44987176e-02f, -6.11057170e-02f,
  -4.89251390e-02f, -6.30511492e-02f, 7.44886398e-02f, -3.58944163e-02f, -2.85042655e-02f, 4.43827771e-02f, 2.56358776e-02f, 4.10915539e-02f, 3.98609787e-02f, -4.03472669e-02f,
  -1.58249468e-01f, 1.10578053e-02f, 5.67072863e-03f, -9.44471136e-02f, 3.92292142e-02f, -5.64336367e-02f, -1.06470846e-01f, -7.40913227e-02f, 3.78164090e-02f, 2.41233408e-02f,
  -1.54482201e-01f, -1.54117733e-01f, 6.26910105e-02f, 4.57405560e-02f, -9.13566872e-02f, -1.80447903e-02f, 9.88225639e-02f, -6.65752962e-02f, -5.51513247e-02f, -6.44976944e-02f,
  -9.19314250e-02f, 6.47808313e-02f, -6.14508465e-02f, 2.87408568e-02f, 2.97787925e-03f, -1.51965991e-01f, 1.82039402e-02f, 3.77527922e-02f, 3.55139114e-02f, 9.83586684e-02f,
  -1.36400294e-02f, -3.59192677e-02f, 2.35730261e-02f, -4.09570150e-02f, 7.08393240e-03f, -1.78607237e-02f, 1.27307162e-01f, 3.94651592e-02f, 9.38941464e-02f, 5.41612506e-02f,
  1.52551278e-01f, -2.60037959e-01f, -1.63085565e-01f, 1.10252015e-01f, -1.01749025e-01f, 8.04486796e-02f, 4.54770058e-01f, -1.16835341e-01f, -2.65197217e-01f, 1.50458202e-01f,
  3.94251734e-01f, 2.42302306e-02f, 3.69418919e-01f, 4.39386904e-01f, 2.03263924e-01f, 1.95163593e-01f, 3.65525037e-01f, 2.74586856e-01f, -2.01668993e-01f, 2.91149295e-03f,
  -3.28505225e-02f, 3.27162713e-01f, 3.16680878e-01f, -3.36842775e-01f, 2.44811937e-01f, -3.19477528e-01f, 9.74492580e-02f, -1.77949831e-01f, 1.96906090e-01f, 1.72556251e-01f,
  1.47826776e-01f, -2.11098064e-02f, 5.89106418e-02f, -1.01869136e-01f, -8.18151012e-02f, 3.93613130e-02f, -5.53402156e-02f, 1.30617633e-01f, 3.56156416e-02f, -7.48359086e-03f,
  -5.46803102e-02f, -9.35897231e-02f, -6.52222857e-02f, -1.16349749e-01f, -1.35161102e-01f, -2.91893464e-02f, -1.24276012e-01f, 6.05124906e-02f, -7.90125728e-02f, 1.27330512e-01f,
  5.05499579e-02f, 1.00038797e-02f, -9.03052092e-03f, 9.17543843e-02f, -4.16689366e-02f, -5.43896146e-02f, 1.79122319e-03f, -3.20242830e-02f, 5.41862994e-02f, -1.27363894e-02f,
  5.68162091e-02f, -1.14633404e-01f, -3.35559808e-03f, 5.97272441e-02f, -3.50141991e-03f, 4.05728370e-02f, 6.41436502e-02f, 1.13715522e-01f, 2.19179504e-02f, 3.69058549e-03f,
  6.31880611e-02f, -3.86910804e-04f, -2.26961337e-02f, 8.01786035e-02f, -1.81209929e-02f, -1.24112088e-02f, 1.86440405e-02f, 1.40001951e-02f, -1.21051654e-01f, 3.44665907e-02f,
  6.46864995e-02f, -1.15603253e-01f, -2.22381707e-02f, 5.56544811e-02f, -1.52084995e-02f, 4.40964699e-02f, -3.17749344e-02f, 1.35250641e-02f, -1.34340338e-02f, -2.53637061e-02f,
  5.63996425e-03f, -1.98343962e-01f, -2.61676568e-03f, -3.84397246e-02f, 3.49154579e-04f, -8.72689560e-02f, 4.51424345e-02f, -8.35844800e-02f, 8.96679051e-03f, -3.34610753e-02f,
  -3.79084945e-02f, -2.61769281e-03f, -5.82360849e-02f, -2.68142801e-02f, 2.15097610e-02f, -2.78257485e-02f, -1.14003932e-02f, -8.68195891e-02f, 5.27564101e-02f, 8.90243519e-03f,
  2.46248841e-02f, 6.87657343e-03f, -8.61580595e-02f, -3.01559772e-02f, -7.47440532e-02f, 9.99812856e-02f, -9.53995436e-02f, -1.30472749e-01f, -7.32047260e-02f, 3.74077484e-02f,
  -2.52642035e-02f, 1.72046363e-01f, -1.64901242e-01f, -4.37531658e-02f, -4.73915040e-01f, -7.46697411e-02f, -1.02265254e-01f, -5.65865822e-02f, 1.00410134e-01f, 3.26801956e-01f,
  -6.59936965e-02f, 8.10988322e-02f, 2.50040621e-01f, 3.20212240e-03f, 1.82650372e-01f, 4.17475283e-01f, 2.82685190e-01f, 2.70128846e-01f, -7.11856112e-02f, -8.71310979e-02f,
  -5.89298978e-02f, -1.80535585e-01f, -6.16135113e-02f, -2.61935532e-01f, -3.61611515e-01f, -2.00439438e-01f, -1.59087226e-01f, -1.80376768e-01f, -1.47166282e-01f, -2.56990969e-01f,
  -2.24299240e-03f, -3.19105340e-03f, 1.91569477e-02f, 9.10947993e-02f, -4.89197997e-03f, -7.51019344e-02f, -8.54649395e-02f, -1.03844918e-01f, -1.15753241e-01f, 2.95691006e-02f,
  1.03400096e-01f, 6.49614632e-02f, -3.03276465e-03f, -1.11959279e-01f, -2.45802570e-02f, 1.78320764e-03f, 7.70406192e-03f, 8.36029351e-02f, 3.26241851e-02f, -1.00836828e-01f,
  6.19008988e-02f, -3.14762513e-03f, -4.05608416e-02f, 1.29363656e-01f, -8.92775506e-02f, 4.28036340e-02f, 1.28632888e-01f, -2.02486925e-02f, 1.25781982e-03f, -1.09260390e-02f,
  -1.30225569e-02f, -3.16305310e-02f, 1.19613796e-01f, -5.49661070e-02f, -3.23382802e-02f, -2.38606241e-02f, 5.30940704e-02f, -8.83529857e-02f, 2.28908863e-02f, -5.05579710e-02f,
  5.50963450e-03f, 5.16053615e-03f, -2.81667169e-02f, 1.44413128e-01f, 5.86564764e-02f, 1.49178684e-01f, 6.95514232e-02f, -2.33779904e-02f, 9.35317948e-02f, 6.11646893e-03f,
  -2.29981598e-02f, 4.56973687e-02f, -3.19659971e-02f, -1.83148328e-02f, 6.55991733e-02f, -5.09395190e-02f, -5.83435819e-02f, 2.85305956e-04f, 6.03308622e-03f, -1.10170327e-01f,
  -1.27996206e-02f, -4.59245592e-02f, 1.92500465e-02f, 8.44369531e-02f, 6.95473254e-02f, -4.54339981e-02f, -4.67482023e-02f, -2.13615801e-02f, 6.33760840e-02f, -4.07926328e-02f,
  -1.03523741e-02f, 4.26801778e-02f, 6.25141934e-02f, -1.45815030e-01f, 4.50736098e-02f, 5.51160797e-02f, 5.93326986e-02f, 1.36598244e-01f, -1.19043060e-01f, 5.61115099e-03f,
  -5.17489612e-02f, 4.05757949e-02f, 4.09930907e-02f, 7.74734318e-02f, 1.00092597e-01f, 1.75205916e-02f, 7.53034488e-04f, -1.13822920e-02f, -1.44209266e-01f, 3.54150347e-02f,
  -4.54789549e-01f, 3.27320471e-02f, -4.78284568e-01f, -3.20127368e-01f, -5.97077906e-02f, -3.47343683e-01f, -2.48004690e-01f, -1.98932037e-01f, -9.91448462e-02f, 3.38136405e-01f,
  1.03175029e-01f, -2.80163825e-01f, 2.21805096e-01f, -2.54476398e-01f, -5.42859495e-01f, 9.57458690e-02f, -3.03829908e-01f, -1.75771683e-01f, -1.41376957e-01f, -2.63065606e-01f,
  -2.91899711e-01f, -1.30286679e-01f, -2.58013040e-01f, 6.38574734e-02f, -1.55553371e-01f, -5.81928864e-02f, 3.45715463e-01f, 3.49022970e-02f, -3.57038192e-02f, -1.03053458e-01f,
  -2.31778905e-01f, 6.88313544e-02f, 2.58781109e-02f, -5.38586639e-02f, -7.02543333e-02f, 1.40625343e-01f, -3.49057280e-02f, -1.28006854e-03f, 8.75369236e-02f, -1.51066348e-01f,
  -5.54614291e-02f, 4.39768322e-02f, -2.47059122e-01f, 1.84325501e-02f, 8.54331348e-03f, -3.85495760e-02f, -1.31753713e-01f, -1.50347641e-02f, -2.70796078e-03f, -1.82311893e-01f,
  -9.08629075e-02f, -8.02913979e-02f, -3.61607037e-02f, 8.40616748e-02f, -9.87962075e-03f, -5.98729961e-02f, -7.17347041e-02f, 5.12104742e-02f, -3.23231407e-02f, -8.75419229e-02f,
  5.12445457e-02f, 5.98750524e-02f, 1.14054028e-02f, 8.96866340e-03f, -6.05351571e-03f, 9.32692885e-02f, 6.70636594e-02f, 1.11059383e-01f, 1.91637594e-02f, 9.98472571e-02f,
  -2.37236395e-02f, -1.37686376e-02f, 6.12294115e-02f, 5.07378913e-02f, -8.22573453e-02f, -1.73700545e-02f, 5.75736456e-04f, -9.96571556e-02f, -1.30902799e-02f, -7.81865567e-02f,
  1.01181522e-01f, -1.07795909e-01f, 1.25685126e-01f, 8.59401450e-02f, -1.15463942e-01f, 1.23842694e-01f, 7.71693215e-02f, -4.76515181e-02f, 1.17618009e-03f, 5.11381850e-02f,
  -2.85742562e-02f, -4.32291068e-02f, 3.94233279e-02f, -8.30723271e-02f, -4.13910560e-02f, 1.58230215e-02f, 1.70952324e-02f, -1.07283041e-01f, -2.77201366e-02f, -5.81973717e-02f,
  1.26650985e-02f, 5.91102056e-02f, 5.07825948e-02f, -2.10921783e-02f, -1.81550812e-02f, 5.44482246e-02f, 1.16791893e-02f, -1.77497249e-02f, 5.86715639e-02f, 5.53061400e-05f,
  4.20851409e-02f, -8.22615102e-02f, -1.76906493e-02f, 1.14903681e-01f, 1.28258795e-01f, 9.12455320e-02f, -4.16833051e-02f, 7.19048232e-02f, 5.39945737e-02f, 3.40765389e-03f,
  -2.84410805e-01f, 2.06665710e-01f, -1.19356327e-01f, -4.26331282e-01f, 1.51260749e-01f, 5.48961759e-03f, -2.00499609e-01f, 1.23272367e-01f, -2.08780766e-01f, 3.93954702e-02f,
  2.55503636e-02f, -1.46892369e-01f, 1.48938298e-01f, -2.58836091e-01f, -2.02421814e-01f, -1.59274966e-01f, -3.80073279e-01f, -2.64428288e-01f, -3.80610036e-05f, -1.87112004e-01f,
  -1.84821531e-01f, -2.05598474e-01f, -1.78292081e-01f, 2.80636698e-01f, -2.07221106e-01f, -1.09301768e-01f, -1.97121710e-01f, 2.75234342e-01f, -1.25834003e-01f, 1.04539022e-01f,
  -5.71135059e-02f, 3.26137580e-02f, 5.33445105e-02f, -2.65434831e-02f, 5.34201637e-02f, 8.42181519e-02f, -1.03844535e-02f, -1.07947841e-01f, -1.00856990e-01f, 9.79025476e-03f,
  3.76011804e-02f, 6.66224584e-02f, -9.70243812e-02f, 1.30386785e-01f, -2.18552221e-02f, -9.67134535e-03f, 1.10628419e-01f, -1.07402749e-01f, -8.73213783e-02f, -5.08405715e-02f,
  -3.52612808e-02f, -1.19260522e-02f, -4.33320925e-02f, -2.29997877e-02f, 2.12583113e-02f, -7.08991960e-02f, -7.97052458e-02f, -1.24688268e-01f, -1.26084790e-01f, -4.51356620e-02f,
  -4.13340256e-02f, 1.67115368e-02f, -4.84384373e-02f, -4.88856516e-04f, 2.55415756e-02f, -6.71576560e-02f, -1.15181163e-01f, -6.62031844e-02f, -1.69030093e-02f, 1.36789829e-01f,
  -2.93465517e-02f, -6.07873984e-02f, -3.41242552e-02f, -6.19247407e-02f, -6.47723004e-02f, 1.35702221e-02f, 2.09174156e-02f, 1.14724711e-01f, -1.07442573e-01f, -7.89964274e-02f,
  1.04711354e-01f, 1.05034690e-02f, -4.44256105e-02f, -4.75648493e-02f, -3.59111242e-02f, -1.20368535e-02f, 6.64708531e-03f, -1.23122767e-01f, 6.86806291e-02f, -1.35220028e-02f,
  -1.65470992e-03f, 2.47005727e-02f, 8.96457806e-02f, -3.80565412e-03f, 8.12903717e-02f, -1.00005893e-02f, 3.24206091e-02f, -4.32118997e-02f, -4.49528731e-02f, 1.25239670e-01f,
  -5.40604815e-02f, 3.28628521e-04f, -3.69780864e-05f, -4.84308563e-02f, -6.89541176e-02f, 9.75756049e-02f, -1.97924953e-02f, -5.26028126e-02f, -4.07419801e-02f, 3.81939970e-02f,
  9.48028043e-02f, -8.82644132e-02f, -6.68296963e-02f, -6.93785176e-02f, -8.01017955e-02f, -1.05711289e-01f, 4.33161631e-02f, -8.76399651e-02f, -4.94155213e-02f, 4.98355553e-02f,
  2.16950104e-01f, -2.47557610e-01f, -2.08060160e-01f, -2.10540891e-01f, -2.80394018e-01f, -2.06101179e-01f, -7.67307058e-02f, -3.53874058e-01f, -1.36269823e-01f, -9.81787518e-02f,
  -3.64450127e-01f, 1.94409430e-01f, 3.67108494e-01f, -2.14688867e-01f, 4.71217394e-01f, 2.76111215e-01f, -1.17965028e-01f, 7.57242739e-02f, -6.01350330e-02f, -5.01385443e-02f,
  -6.29114285e-02f, -1.33858949e-01f, -2.80130841e-02f, -2.93954164e-01f, -2.77268469e-01f, -2.79467523e-01f, -1.05533525e-01f, -1.13372408e-01f, -3.33559185e-01f, -2.15452895e-01f,
  4.87727560e-02f, 1.24123134e-02f, -4.96964604e-02f, 1.99159700e-02f, 4.35632095e-02f, 9.08275694e-02f, 6.98839724e-02f, 8.92892703e-02f, -1.72820268e-03f, 8.70002955e-02f,
  1.51873738e-01f, 1.60729513e-01f, -1.52681053e-01f, 8.16329345e-02f, -1.07425740e-02f, -2.03021586e-01f, -8.92282575e-02f, 3.64722125e-02f, -3.64109874e-03f, 6.33068755e-02f,
  3.71343107e-03f, 1.47758415e-02f, -1.92988724e-01f, 1.50902346e-01f, -1.57840267e-01f, -1.46101534e-01f, 3.97534892e-02f, 9.05102044e-02f, -4.61425707e-02f, 6.45288453e-02f,
  -1.26879737e-01f, 2.00632419e-02f, 1.00215271e-01f, 5.07261790e-02f, 4.14476283e-02f, -2.33769380e-02f, -1.84952933e-02f, -4.79603261e-02f, -2.76450347e-02f, 6.46296423e-03f,
  -1.00875847e-01f, 1.89261250e-02f, -3.04974671e-02f, -2.17377879e-02f, -1.38457194e-02f, 1.54531807e-01f, 3.16098742e-02f, -7.17579871e-02f, 1.69017557e-02f, 2.76518092e-02f,
  -7.95413628e-02f, -3.95610295e-02f, -5.87695800e-02f, 3.19337174e-02f, -7.60691762e-02f, 9.18182172e-03f, -6.63166270e-02f, 5.13569415e-02f, -1.73108175e-01f, 1.59750320e-02f,
  -1.98091548e-02f, -1.23055838e-01f, -8.64498466e-02f, -6.93714544e-02f, 5.95692396e-02f, -1.89528856e-02f, 1.52274864e-02f, -3.94256078e-02f, -8.39948803e-02f, 8.01799595e-02f,
  -1.32392555e-01f, 8.12820196e-02f, -6.74851611e-02f, -2.04307772e-02f, -2.74107177e-02f, -2.59640384e-02f, 7.00546131e-02f, 3.01228520e-02f, -1.01160713e-01f, -6.73568770e-02f,
  -1.68542974e-02f, 1.05014138e-01f, 1.15575433e-01f, -6.99532554e-02f, -1.66228428e-01f, -3.55947278e-02f, 6.90141842e-02f, 2.30189748e-02f, 2.43088137e-02f, -2.26694942e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  3.39663416e-01f, 3.86374086e-01f, 3.08980525e-01f, 4.03433889e-01f, 3.08567047e-01f, 3.23597729e-01f, 3.90057504e-01f, 3.17445725e-01f, 2.19381198e-01f, 1.73626080e-01f,
  3.11194509e-01f, 4.16056246e-01f, 2.49108449e-01f, 3.37471724e-01f, 2.16690734e-01f, 3.95377666e-01f, 3.47512990e-01f, 1.79799661e-01f, 5.20128787e-01f, 2.66380817e-01f,
  3.00230056e-01f, 4.05135483e-01f, 3.88905913e-01f, 2.45052084e-01f, 5.13221025e-01f, 3.57438028e-01f, 4.04788643e-01f, 3.08741421e-01f, 3.85686994e-01f, 5.46712220e-01f,
  3.22005957e-01f, 3.12469602e-01f, 3.48338366e-01f, 3.67741019e-01f, 3.84369880e-01f, 3.13670427e-01f, 4.71596003e-01f, 2.79848218e-01f, 4.00414258e-01f, 2.80538827e-01f,
  2.38636211e-01f, 4.00692999e-01f, 3.48650575e-01f, 3.31844836e-01f, 2.82491714e-01f, 2.65315086e-01f, 2.60548770e-01f, 2.46355549e-01f, 3.28288406e-01f, 3.75349313e-01f,
  3.19270313e-01f, 2.81068265e-01f, 2.28472829e-01f, 3.19383860e-01f, 4.21250314e-01f, 2.77486563e-01f, 1.41344056e-01f, 1.76528096e-01f, 2.52555817e-01f, 4.35792267e-01f,
  4.27592874e-01f, 3.41652155e-01f, 3.91298711e-01f, 2.39165142e-01f, 3.24745536e-01f, 4.57518309e-01f, 1.75002739e-01f, 1.11311428e-01f, 3.21130216e-01f, 4.46974367e-01f,
  2.76367575e-01f, 4.32307571e-01f, 6.00878596e-01f, 3.80265951e-01f, 4.59924698e-01f, 3.84938896e-01f, 4.28481311e-01f, 3.70051324e-01f, 1.57189578e-01f, 3.52234244e-01f,
  2.97677815e-01f, 4.15632874e-01f, 2.88111061e-01f, 3.88203442e-01f, 2.72117317e-01f, 2.20402315e-01f, 3.79115134e-01f, 2.08024606e-01f, 1.95907310e-01f, 2.92360634e-01f,
  2.97569841e-01f, 2.66340613e-01f, 3.93025547e-01f, 1.68893710e-01f, 1.02914274e-01f, 5.12817025e-01f, 3.73525023e-01f, 3.89396846e-01f, 2.46758342e-01f, 1.80607378e-01f,
  2.08349422e-01f, 4.14996564e-01f, 3.66353601e-01f, 2.05611691e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  4.54716422e-02f, -1.02406427e-01f, -4.31985371e-02f, -1.46827593e-01f, -2.18401477e-01f, -1.55073285e-01f, -1.68972254e-01f, 2.54931897e-02f, -1.41852334e-01f, 9.91692469e-02f,
  -1.63596794e-01f, 3.52173969e-02f, -9.75978677e-04f, -1.41122580e-01f, 8.11389089e-02f, -2.22843975e-01f, 2.25463897e-01f, 7.36332089e-02f, 3.29524130e-01f, -1.29456863e-01f,
  -2.66784459e-01f, 6.07690364e-02f, 1.30068302e-01f, -1.94456875e-01f, -1.81686342e-01f, 3.40921044e-01f, 3.20303172e-01f, -7.92981014e-02f, -1.57506257e-01f, -3.10770601e-01f,
  -1.09146498e-01f, 2.07514122e-01f, -2.66586989e-01f, 2.87166625e-01f, -1.46156158e-02f, -3.55196059e-01f, -3.38437974e-01f, -1.98455662e-01f, -1.38546020e-01f, 9.26566347e-02f,
  -1.44288480e-01f, 3.26732427e-01f, 2.00652972e-01f, 3.53202403e-01f, -3.04791301e-01f, -3.86000365e-01f, -3.16162050e-01f, 1.40374735e-01f, 3.09124351e-01f, -1.84131265e-01f,
  3.97383034e-01f, -1.62782773e-01f, -5.32382503e-02f, -3.23963344e-01f, 2.22401336e-01f, -2.32149959e-01f, 3.32366049e-01f, 5.03867082e-02f, 1.35701343e-01f, -2.78937012e-01f,
  -4.32801932e-01f, -3.08823258e-01f, -3.22132051e-01f, -1.52576476e-01f, 3.23929161e-01f, -3.86444777e-01f, -4.57730114e-01f, -1.15068033e-01f, 1.30286545e-01f, -1.06734388e-01f,
  2.88976669e-01f, -2.77963728e-01f, -3.11497539e-01f, -2.01507285e-01f, 2.38500834e-01f, 1.78779438e-01f, -1.31162331e-02f, 5.14220097e-04f, -2.92563051e-01f, -2.80823827e-01f,
  3.31410199e-01f, -1.10050859e-02f, 2.78715700e-01f, 1.94841847e-01f, -2.70751208e-01f, -2.12587625e-01f, 3.60108986e-02f, -4.61484104e-01f, -2.14173689e-01f, -2.38773942e-01f,
  -2.71195889e-01f, -2.99508214e-01f, -4.59438972e-02f, -1.44196957e-01f, -3.14504474e-01f, -3.36977571e-01f, -2.23231524e-01f, 1.71933614e-03f, -3.11162770e-01f, -2.69749761e-01f,
  3.55825335e-01f, -2.92013735e-01f, 2.10329130e-01f, -2.07743451e-01f, -7.21073002e-02f, -2.58484244e-01f, -1.96232527e-01f, -1.73162848e-01f, -1.79819718e-01f, -2.99046990e-02f,
  -1.58143029e-01f, 3.56195122e-01f, -2.25269392e-01f, -8.70874301e-02f, 9.47208181e-02f, 4.08062637e-02f, 3.53555292e-01f, -7.28371516e-02f, -2.13452145e-01f, -6.35834858e-02f,
  -1.72253430e-01f, -2.41904661e-01f, -1.02727629e-01f, 3.30523521e-01f, 3.12885106e-01f, 1.90635830e-01f, -2.46656269e-01f, 2.38921959e-03f, 2.20284127e-02f, -8.49043205e-02f,
  -2.02236012e-01f, -2.78488636e-01f, 6.80867443e-03f, 1.35146722e-01f, 1.20824300e-01f, 4.37600054e-02f, 5.47211096e-02f, 7.38234539e-03f, 1.88267585e-02f, -4.96016964e-02f,
  -1.36785105e-01f, 1.67921796e-01f, 2.04763487e-01f, -1.92958832e-01f, -2.52044648e-01f, 5.50191924e-02f, -3.69739056e-01f, -2.85315216e-01f, 3.51009071e-01f, 2.17488959e-01f,
  2.90629655e-01f, 3.73174518e-01f, 2.28634998e-01f, -3.62531751e-01f, -4.07562912e-01f, -2.23861024e-01f, 4.01699729e-03f, -1.90558776e-01f, 3.87910068e-01f, 2.74612814e-01f,
  -1.60454735e-01f, 3.69384080e-01f, -1.75611094e-01f, -2.06286028e-01f, -1.13057613e-01f, -5.14935613e-01f, -4.09549832e-01f, 1.92318112e-01f, -3.44445795e-01f, -3.69706661e-01f,
  8.21061879e-02f, 6.98828697e-02f, -1.58979762e-02f, -1.09085016e-01f, -2.80052960e-01f, -2.58063942e-01f, 8.24266225e-02f, -3.59909594e-01f, -5.02094030e-01f, -3.86541456e-01f,
  2.60415852e-01f, -5.62844157e-01f, -8.97585899e-02f, 1.56686693e-01f, 1.73985571e-01f, 3.22624892e-01f, 9.09090415e-02f, -4.04662371e-01f, 1.93177328e-01f, -1.21971890e-01f,
  -3.65947694e-01f, -2.81832516e-01f, 1.68870732e-01f, 2.99518645e-01f, 1.17618963e-01f, -3.71726036e-01f, -4.93729323e-01f, -2.31546909e-01f, 2.98528314e-01f, 1.83046564e-01f,
  -3.75704110e-01f, -3.65521520e-01f, -8.82680863e-02f, -1.98811620e-01f, 1.22170895e-01f, -3.55663270e-01f, -2.48237565e-01f, 1.14732474e-01f, 9.25087780e-02f, 3.24585773e-02f,
  -5.41357100e-01f, -2.99236238e-01f, -3.04111242e-01f, 2.59050190e-01f, 1.73850432e-01f, 1.76876828e-01f, 3.43901008e-01f, -1.27928495e-01f, -1.24774752e-02f, -1.54453993e-01f,
  -4.75705802e-01f, 1.33127093e-01f, -2.06074808e-02f, -2.53117234e-01f, -4.53961998e-01f, 9.14402753e-02f, 4.02387857e-01f, -1.94557101e-01f, -4.99848098e-01f, -2.54486412e-01f,
  3.52929711e-01f, -2.06043005e-01f, -2.91310370e-01f, -2.45038673e-01f, -2.91389406e-01f, 6.80126697e-02f, 1.37070626e-01f, 2.92605489e-01f, -4.80400817e-03f, 1.58756971e-01f,
  2.51843125e-01f, -2.62810230e-01f, -3.86974007e-01f, 9.77917667e-03f, 3.64387810e-01f, 6.86064288e-02f, 2.76198030e-01f, -4.47705597e-01f, 3.56712639e-01f, 7.55558023e-03f,
  -2.88533509e-01f, 2.85671175e-01f, -1.12402223e-01f, -2.18701079e-01f, -1.50494787e-04f, 8.66164342e-02f, -2.08793655e-01f, -1.48739278e-01f, -3.59708034e-02f, 1.15734793e-01f,
  -1.50439609e-02f, -1.09771676e-01f, -1.35686500e-02f, -1.02802314e-01f, -5.13904355e-02f, -1.31911188e-01f, -1.28563747e-01f, -5.46035692e-02f, -1.65835902e-01f, 2.32840762e-01f,
  -1.70248106e-01f, 1.41948342e-01f, -5.70365377e-02f, 4.86888550e-02f, -7.36011937e-02f, 1.56989962e-01f, 1.51952580e-01f, 2.57801294e-01f, -2.17795268e-01f, 1.01811085e-02f,
  -2.80101866e-01f, -2.25867793e-01f, -1.03722647e-01f, -3.28392506e-01f, 1.02709070e-01f, -1.42116934e-01f, -1.65857345e-01f, 2.00325131e-01f, -2.07240582e-01f, -1.19866684e-01f,
  -1.02916330e-01f, -2.79718697e-01f, 2.45552793e-01f, 1.99179575e-01f, 1.85752809e-01f, 2.79211253e-01f, -1.37691721e-01f, -2.17677981e-01f, -3.49223644e-01f, -3.61210108e-01f,
  1.07215822e-01f, -2.32550263e-01f, -4.10315394e-01f, 1.60176530e-01f, -3.32159311e-01f, -1.41460449e-01f, -1.59695491e-01f, 1.87531754e-01f, 1.96444258e-01f, -2.69616485e-01f,
  -8.16360041e-02f, -2.70292401e-01f, -3.66350204e-01f, -7.35064670e-02f, 2.77913570e-01f, -5.14495187e-02f, 1.09449908e-01f, -1.89640775e-01f, -4.41358507e-01f, -2.41564885e-01f,
  3.43156993e-01f, -9.50302184e-03f, 1.79988787e-01f, 3.77165556e-01f, -1.84586301e-01f, 2.64336495e-03f, 2.36152813e-01f, 3.44376057e-01f, 2.72324532e-01f, -2.62894094e-01f,
  -1.54535234e-01f, 4.34434056e-01f, 1.94473296e-01f, -7.75860921e-02f, 3.42170209e-01f, 1.03453048e-01f, -2.80300733e-02f, 2.55246937e-01f, -1.49984702e-01f, -1.84516147e-01f,
  1.90106660e-01f, -4.94483970e-02f, 1.17435113e-01f, 3.04275632e-01f, -8.99814367e-02f, -2.74785846e-01f, -2.67164648e-01f, -8.57579336e-02f, -1.27395108e-01f, 3.75980884e-02f,
  -2.16822475e-01f, -2.45113671e-01f, -1.16629757e-01f, -3.23129267e-01f, -3.32430810e-01f, 1.07730351e-01f, -2.22403809e-01f, -2.78270841e-02f, 7.90752321e-02f, 3.52856517e-01f,
  -3.10066372e-01f, 6.88736811e-02f, -7.49589354e-02f, -1.16597190e-01f, -2.81816930e-01f, -1.27681583e-01f, 5.12708649e-02f, 1.44510686e-01f, -1.98843569e-01f, -1.01751596e-01f,
  -2.48861879e-01f, -1.30711332e-01f, -4.50596631e-01f, -1.07958531e-02f, 3.47733319e-01f, -1.21492058e-01f, -2.04593733e-01f, -2.48439431e-01f, -2.25328933e-02f, 1.02464529e-02f,
  -6.41828254e-02f, -2.71710008e-01f, -1.98028326e-01f, -1.84376344e-01f, -3.28912437e-01f, 1.13398945e-02f, -8.08876157e-02f, 3.85865569e-02f, -1.17741458e-01f, -2.64165699e-01f,
  -5.76936640e-02f, -2.01990545e-01f, 1.02840304e-01f, -1.29998371e-01f, 6.95121959e-02f, -2.80191414e-02f, 1.59256920e-01f, -2.66058743e-01f, -8.84355381e-02f, 2.17520863e-01f,
  -3.11403006e-01f, 9.82678980e-02f, 1.58277899e-01f, 9.27566364e-02f, -1.70247406e-01f, -1.62994102e-01f, -2.29527593e-01f, 9.63412002e-02f, -7.33502805e-02f, -6.95649069e-03f,
  3.37843388e-01f, 3.17738861e-01f, -1.06759079e-01f, -9.07321498e-02f, -4.04973924e-01f, -1.56294882e-01f, 7.58996829e-02f, 1.21456966e-01f, -2.68391669e-01f, -2.05133602e-01f,
  -1.87769458e-01f, -2.06113517e-01f, -1.74662620e-01f, -2.86957830e-01f, -1.23639787e-02f, 3.19495350e-01f, 3.08919489e-01f, -2.03627199e-01f, 1.61712244e-02f, -3.21770877e-01f,
  -4.30770904e-01f, -1.07601218e-01f, -3.53442281e-01f, 3.42329666e-02f, 1.56166330e-01f, -2.93467611e-01f, -4.37160552e-01f, -2.88620979e-01f, -1.65551528e-01f, -2.35032380e-01f,
  1.21297864e-02f, -4.59339499e-01f, 2.36142315e-02f, -2.44691998e-01f, -1.88479811e-01f, -1.86754122e-01f, -1.40891209e-01f, 2.44940817e-01f, -7.20464960e-02f, -9.02195945e-02f,
  5.99964559e-02f, -3.42692196e-01f, -7.04049468e-02f, -2.58324683e-01f, -2.63046086e-01f, -1.85060307e-01f, -2.16002867e-01f, -2.26292223e-01f, 1.85242668e-01f, 9.63980481e-02f,
  -9.80449989e-02f, 2.86793709e-01f, 3.44578885e-02f, -2.17270866e-01f, -5.90661392e-02f, -1.58046275e-01f, 3.77567053e-01f, 5.00970840e-01f, -2.71602064e-01f, -9.52255949e-02f,
  -3.56125116e-01f, -9.77539644e-02f, -4.12606746e-01f, -8.49373564e-02f, -6.09057136e-02f, 4.41310674e-01f, 3.07606697e-01f, -1.76793933e-01f, -1.21089309e-01f, -1.01951167e-01f,
  2.63207734e-01f, 2.18549430e-01f, 6.70549423e-02f, 1.85545370e-01f, -4.45111811e-01f, -1.11145772e-01f, -2.52255291e-01f, -2.59888262e-01f, -3.62681150e-01f, 3.64648700e-01f,
  -2.62150347e-01f, -4.65086937e-01f, -1.60806313e-01f, 4.42748666e-01f, -3.03050160e-01f, 9.35904682e-03f, -5.93167283e-02f, 3.08288157e-01f, -3.34770292e-01f, -3.61126661e-01f,
  -5.86757697e-02f, 2.66763926e-01f, -1.84507251e-01f, -2.15140805e-01f, -1.48206919e-01f, -2.64906138e-01f, -3.39543223e-01f, -2.39145458e-01f, -3.15696746e-01f, 2.75710523e-01f,
  3.02481711e-01f, -3.04295719e-01f, 2.28858024e-01f, 4.82995249e-02f, 1.10160805e-01f, 1.96795121e-01f, 1.80308595e-01f, 2.25096107e-01f, 1.20040558e-01f, 1.02389708e-01f,
  -5.13145179e-02f, 1.94055945e-01f, 2.79614683e-02f, 1.18322857e-02f, -1.11785628e-01f, -9.69459265e-02f, -4.18209970e-01f, -3.38890590e-02f, 3.17189097e-01f, -4.45169695e-02f,
  9.50861201e-02f, 4.36391264e-01f, 1.52783915e-01f, -2.06305370e-01f, 2.11794108e-01f, -2.59496272e-01f, -1.98246077e-01f, 1.68404505e-01f, 1.05372161e-01f, -1.40031144e-01f,
  2.67192051e-02f, 5.05132496e-01f, -2.19778061e-01f, -1.62349388e-01f, 2.79605854e-02f, 4.47074063e-02f, -2.26066187e-01f, 4.01237726e-01f, -1.79461047e-01f, -9.83729735e-02f,
  2.46505484e-01f, -3.45341116e-01f, 6.25411496e-02f, 3.03303242e-01f, 1.19105391e-02f, -4.15081441e-01f, 2.70892791e-02f, 1.43792629e-01f, 3.15714121e-01f, 1.59116820e-01f,
  1.89113036e-01f, -8.60932618e-02f, 1.61134183e-01f, -8.18972364e-02f, -2.60669142e-01f, 7.79143199e-02f, 4.19533283e-01f, -8.41546506e-02f, 1.89422354e-01f, -5.56054831e-01f,
  -3.26685369e-01f, 1.01219835e-02f, -3.98270220e-01f, 8.93692598e-02f, 4.64850031e-02f, -2.76835054e-01f, 3.86145592e-01f, -5.86985946e-01f, -3.10962081e-01f, 3.48585814e-01f,
  -4.86388475e-01f, -1.33074790e-01f, -2.23811433e-01f, 1.39824003e-01f, -3.23484123e-01f, -3.08686823e-01f, -2.92399060e-02f, 8.87846015e-03f, 1.86055630e-01f, -2.29510710e-01f,
  -2.64009565e-01f, -5.22728451e-02f, -2.41449192e-01f, -1.35978773e-01f, -1.49460599e-01f, 2.15750232e-01f, -1.09070837e-01f, -1.33582234e-01f, 1.57265052e-01f, 9.58888903e-02f,
  -1.98514521e-01f, 2.53409594e-01f, -2.68126786e-01f, -1.64378107e-01f, 1.40382707e-01f, -3.50161225e-01f, -6.13569058e-02f, 3.58247191e-01f, 2.30977982e-01f, 1.84920996e-01f,
  4.90381479e-01f, -4.12139922e-01f, 3.55022699e-01f, -8.52364674e-02f, -4.42444921e-01f, 3.37572128e-01f, -4.82145339e-01f, 8.09013024e-02f, -9.79383066e-02f, 3.85364056e-01f,
  3.50736417e-02f, -7.30209351e-02f, 4.29059155e-02f, -4.40571159e-01f, 9.12995338e-02f, 1.55528739e-01f, 8.10941756e-02f, 8.55302736e-02f, -5.98909967e-02f, -3.57958615e-01f,
  -2.07517579e-01f, 1.24391541e-02f, -1.95249304e-01f, 1.61676586e-01f, -4.02666926e-01f, -3.48716378e-01f, -1.14106730e-01f, -1.79779261e-01f, 1.66984200e-01f, -9.73423943e-02f,
  5.00376783e-02f, 1.67643607e-01f, 6.17154054e-02f, 2.32643098e-01f, 1.97367743e-01f, 1.95503496e-02f, 1.61703691e-01f, 3.54470359e-03f, 3.54687311e-02f, -4.64793807e-03f,
  9.49501246e-03f, 1.29479423e-01f, 1.33398056e-01f, 2.49588326e-01f, 3.60880524e-01f, -2.06860468e-01f, -2.37190962e-01f, -2.32154191e-01f, -2.35810161e-01f, -3.65874916e-01f,
  -2.50460237e-01f, 1.62838876e-01f, 3.85348462e-02f, -3.14705312e-01f, 2.78122514e-01f, -2.34527633e-01f, -2.17741132e-01f, -2.08348319e-01f, -3.55543882e-01f, -1.86411306e-01f,
  -1.78353876e-01f, -2.47651085e-01f, 1.43338934e-01f, -3.75937492e-01f, -2.25255340e-01f, 2.87926227e-01f, 2.08496138e-01f, 2.38899048e-02f, -2.29582563e-02f, -1.85610741e-01f,
  2.92239070e-01f, 4.43762634e-03f, 1.83402166e-01f, 2.47448564e-01f, -3.75054181e-01f, 2.79509664e-01f, 1.89767793e-01f, 1.71453014e-01f, 9.58240107e-02f, -1.80599391e-01f,
  -3.50537105e-03f, -4.05445486e-01f, -5.34558818e-02f, 4.44133967e-01f, 3.70551869e-02f, 2.33996794e-01f, -3.28213185e-01f, 2.40525797e-01f, -5.49784005e-02f, -5.31508446e-01f,
  1.03547975e-01f, -3.55253607e-01f, -5.18037938e-04f, 2.10049108e-01f, -6.60997868e-01f, 1.67745635e-01f, 2.03653844e-03f, -1.94943935e-01f, 3.34262222e-01f, 1.19755734e-02f,
  -1.47380978e-01f, -3.33533973e-01f, -6.88072518e-02f, 2.98227906e-01f, 3.48553419e-01f, 5.94332293e-02f, -1.22238390e-01f, -4.66769665e-01f, -5.52452467e-02f, 7.02347700e-03f,
  -1.66285470e-01f, 4.53833789e-02f, 1.85717270e-01f, 1.77931160e-01f, 2.25516066e-01f, -2.24761337e-01f, 2.78496265e-01f, -3.17764938e-01f, -1.22707427e-01f, 1.68717667e-01f,
  -2.20380262e-01f, -7.67684355e-02f, 1.02004983e-01f, -8.33116993e-02f, 2.44014308e-01f, -3.44913423e-01f, -2.62487113e-01f, 2.22534582e-01f, -7.10334852e-02f, -3.87616992e-01f,
  1.51301771e-01f, -2.53856629e-01f, -1.22207500e-01f, -3.30937266e-01f, -8.99796113e-02f, -5.65687060e-01f, 2.56634474e-01f, 3.05896252e-01f, -1.17031693e-01f, -3.84361327e-01f,
  2.54982799e-01f, -2.43350938e-01f, 3.90200227e-01f, -3.40386927e-01f, 1.62971038e-02f, -1.17429964e-01f, 1.94742963e-01f, -2.00436592e-01f, -2.64093429e-01f, 2.52046853e-01f,
  2.73474187e-01f, 1.04905322e-01f, 6.34090677e-02f, -3.14895570e-01f, 3.36617589e-01f, -3.34338427e-01f, -1.97800547e-01f, 1.64279982e-01f, 1.75014481e-01f, 1.01431131e-01f,
  -1.67680066e-02f, -2.05914155e-02f, -1.21167481e-01f, 1.19361147e-01f, -7.23918527e-02f, -2.33941942e-01f, -4.40712757e-02f, -1.01327531e-01f, -2.16098309e-01f, -6.56332672e-02f,
  1.58780426e-01f, 1.78391501e-01f, -4.42581736e-02f, -1.46686867e-01f, -1.68162093e-01f, 1.29589766e-01f, -1.33778393e-01f, 7.23107457e-02f, -1.50048167e-01f, 2.01705068e-01f,
  -2.49387950e-01f, 3.20149399e-02f, -1.59735799e-01f, 2.99436212e-01f, -3.12222451e-01f, -2.31170192e-01f, -2.15192273e-01f, -2.02983961e-01f, 2.25520536e-01f, -4.12402838e-01f,
  -7.19772326e-03f, -1.32791042e-01f, 7.51081631e-02f, -1.02127887e-01f, -1.00813538e-01f, -2.73972154e-01f, -1.65063739e-01f, -1.72248751e-01f, -9.79910642e-02f, -1.48431346e-01f,
  -3.29727799e-01f, -1.61442012e-01f, -4.52469289e-01f, 1.49274930e-01f, 2.36605749e-01f, -4.00098681e-01f, -3.35072070e-01f, 2.50634283e-01f, -3.97875607e-01f, 3.58667672e-01f,
  -2.08282888e-01f, 1.66541994e-01f, -4.43850666e-01f, -3.00684690e-01f, -2.00924173e-01f, 8.13916419e-03f, -5.07602036e-01f, 3.44560772e-01f, 2.46290997e-01f, 1.47965327e-01f,
  -1.20479576e-01f, -1.82103053e-01f, -2.06418648e-01f, 3.14760000e-01f, 4.03659403e-01f, -1.45926729e-01f, 3.89851838e-01f, 8.21361691e-02f, -3.62310261e-01f, -2.82201339e-02f,
  1.90118149e-01f, 2.44538382e-01f, -7.47102201e-02f, 1.64030381e-02f, 2.83967644e-01f, 3.51510823e-01f, 9.29361358e-02f, -2.52515167e-01f, -2.00718701e-01f, -4.39116806e-01f,
  -3.73844594e-01f, -2.65247732e-01f, 6.32476807e-02f, 3.80847514e-01f, -6.29731119e-01f, 9.59874541e-02f, -3.45029771e-01f, 1.37277022e-01f, 2.93547823e-03f, -2.62109518e-01f,
  -4.20724124e-01f, 2.45036185e-01f, -3.09992563e-02f, -1.09005004e-01f, 7.98961055e-03f, 1.90139432e-02f, -4.35966015e-01f, -2.11409301e-01f, -3.83381724e-01f, 2.80023366e-01f,
  3.78629982e-01f, 3.95267129e-01f, 3.89639676e-01f, -2.75929838e-01f, -7.09091648e-02f, 1.38126045e-01f, 2.85708219e-01f, -1.03948221e-01f, 3.31959933e-01f, -3.20147216e-01f,
  -5.00205569e-02f, -1.99425295e-01f, 1.04298279e-01f, -8.92858505e-02f, -4.01331782e-01f, -1.05306521e-01f, 2.35921234e-01f, 1.07265659e-01f, -5.23447879e-02f, -3.24121207e-01f,
  1.54633522e-01f, -1.33688062e-01f, -1.23752080e-01f, -7.80067444e-02f, -2.70415992e-01f, -1.35574698e-01f, -1.71669751e-01f, -9.18844119e-02f, -1.47037864e-01f, -2.78072774e-01f,
  -8.39957148e-02f, 3.82277369e-02f, -1.32467464e-01f, 8.30345154e-02f, -1.23154074e-01f, -1.91914141e-02f, -1.50755718e-01f, -7.54131824e-02f, 5.60223572e-02f, -6.33019060e-02f,
  -1.87714741e-01f, 1.48284078e-01f, 9.52304900e-03f, -1.77164719e-01f, 2.13982388e-01f, -9.89301056e-02f, -1.49831429e-01f, -2.96439175e-02f, 1.96238503e-01f, -1.86206326e-01f,
  -1.81483507e-01f, -2.64343858e-01f, -2.82067746e-01f, -1.32377073e-01f, 2.65156686e-01f, 9.87413898e-02f, -1.56632647e-01f, -1.92335010e-01f, 3.17790583e-02f, -1.69596985e-01f,
  -2.43104726e-01f, -1.60115823e-01f, -9.05129462e-02f, 1.70168146e-01f, -7.84339681e-02f, -1.91580802e-01f, 1.67201325e-01f, -1.30441725e-01f, -3.71956557e-01f, -7.48956725e-02f,
  3.05797577e-01f, -1.04258381e-01f, 4.42015426e-03f, -3.67010236e-02f, -2.51707137e-01f, -1.29870288e-02f, 2.78684139e-01f, -2.35375091e-01f, -2.34637171e-01f, 2.55582392e-01f,
  -1.38958767e-01f, 1.83491156e-01f, -3.06323886e-01f, -1.87194943e-01f, -1.81388214e-01f, 2.95007557e-01f, -8.70431289e-02f, 4.62663993e-02f, 2.28380397e-01f, 3.53721738e-01f,
  -9.55799371e-02f, -2.22763523e-01f, -8.02731439e-02f, 1.61760766e-02f, -1.54183760e-01f, 1.26157507e-01f, -1.45271569e-01f, -7.03176335e-02f, 1.52893826e-01f, 8.03861246e-02f,
  -1.80588499e-01f, -8.84631202e-02f, -5.52442782e-02f, -5.72387129e-03f, 2.06780061e-01f, 1.52403777e-02f, 2.01700121e-01f, -1.39764681e-01f, 1.42274454e-01f, -2.31071278e-01f,
  -1.90767527e-01f, -2.04513639e-01f, -2.31007800e-01f, -1.63918417e-02f, -1.40636608e-01f, 1.72825351e-01f, 1.96367756e-01f, 3.00701886e-01f, 2.00651795e-01f, -2.98087180e-01f,
  2.17802212e-01f, 2.20602244e-01f, -1.91246748e-01f, -2.64943749e-01f, -2.26648331e-01f, -1.50949880e-01f, 6.71550259e-02f, -1.70415834e-01f, -1.45237818e-01f, -1.01561643e-01f,
  1.38610870e-01f, -3.02208126e-01f, -7.47259781e-02f, -2.66960651e-01f, 1.51274204e-01f, 1.22353658e-01f, -9.71829593e-02f, -4.65029478e-02f, -1.83606267e-01f, 2.13259324e-01f,
  -1.08849786e-01f, -2.01592267e-01f, -2.83793330e-01f, 2.78922498e-01f, -1.50416102e-02f, 1.88221321e-01f, -7.75730759e-02f, -1.34879336e-01f, 2.46925488e-01f, -1.77322194e-01f,
  2.42761374e-01f, 2.15546697e-01f, 1.25683665e-01f, 3.34048867e-01f, -6.62795305e-02f, -6.03150874e-02f, 1.35454237e-02f, -9.45738554e-02f, -2.46677529e-02f, -2.08237201e-01f,
  -6.22219816e-02f, 4.41072695e-02f, 3.50280292e-02f, -1.54449448e-01f, -2.27325540e-02f, -1.35038346e-01f, -1.27948388e-01f, -1.20103806e-01f, 9.30420905e-02f, -2.11706877e-01f,
  1.60597116e-01f, -1.51329249e-01f, -2.21798401e-02f, -7.89398849e-02f, 2.83208154e-02f, -2.69986808e-01f, 8.26472640e-02f, 1.89968973e-01f, -2.62885187e-02f, 7.85634294e-03f,
  -1.89279258e-01f, 3.44284713e-01f, -2.71840900e-01f, -1.03880152e-01f, -1.15082778e-01f, -3.47807020e-01f, -1.98744267e-01f, -1.99550360e-01f, 1.20334066e-01f, 2.11923301e-01f,
  2.10282281e-01f, 2.29266480e-01f, 3.26374650e-01f, -3.66756618e-01f, 1.28643915e-01f, -1.56992614e-01f, -3.59224416e-02f, 2.70051390e-01f, -2.64245421e-01f, -2.22562328e-01f,
  -1.73906431e-01f, 3.18498224e-01f, 8.70196670e-02f, -7.48772174e-02f, -2.23718837e-01f, -2.01091364e-01f, -9.45617631e-02f, 2.54028756e-02f, -1.26380315e-02f, -1.30307838e-01f,
  -3.27259570e-01f, 5.96670434e-02f, 1.85421612e-02f, -1.84570942e-02f, 2.07255319e-01f, -2.54233837e-01f, 4.10332829e-01f, 1.06913857e-01f, 1.90793067e-01f, -2.96606213e-01f,
  1.69765934e-01f, -2.44491801e-01f, -5.87017555e-03f, 2.97552526e-01f, 1.16478801e-01f, -3.22684526e-01f, 2.04286829e-01f, -9.27246064e-02f, -2.61978269e-01f, -3.05148929e-01f,
  -1.02147833e-01f, 1.92064404e-01f, -1.98769346e-01f, 2.57098734e-01f, -2.39728112e-02f, 3.31901371e-01f, -9.56472978e-02f, 1.43198550e-01f, -1.67161673e-01f, -9.29307379e-03f,
  -1.23460464e-01f, 2.50494957e-01f, 1.06326610e-01f, -2.52601087e-01f, 2.72511095e-01f, -2.01311946e-01f, -2.21198007e-01f, 1.85543433e-01f, -2.14109510e-01f, -1.69178069e-01f,
  -2.63308167e-01f, -1.97706595e-01f, -3.41458619e-01f, 1.99916422e-01f, -2.05774561e-01f, 1.43384859e-01f, -1.42407686e-01f, 1.07282706e-01f, -1.24685779e-01f, -3.54337513e-01f,
  -1.94036454e-01f, -2.51989424e-01f, -9.41184387e-02f, 8.84706676e-02f, -2.56750435e-01f, -3.59113842e-01f, -1.26803204e-01f, -3.07774544e-01f, -9.65917036e-02f, 3.27904195e-01f,
  -1.07937761e-01f, -1.22621149e-01f, -2.25189313e-01f, 3.39848280e-01f, -6.09729327e-02f, -1.70348734e-01f, -7.37209618e-02f, 3.17130387e-02f, -1.12006366e-01f, -2.18344510e-01f,
  -2.05021530e-01f, -2.32679799e-01f, -1.22439101e-01f, -8.19545537e-02f, 6.80318177e-02f, 2.79330579e-03f, -1.13659278e-01f, -1.37630045e-01f, 1.15049414e-01f, 2.15684369e-01f,
  9.83063281e-02f, 1.26625687e-01f, 1.58897519e-01f, -2.63325665e-02f, -3.06908548e-01f, 5.26109748e-02f, 5.75183667e-02f, 1.75085947e-01f, 2.47052446e-01f, -2.33348131e-01f,
  1.16239563e-02f, -1.36097863e-01f, -3.90365832e-02f, -1.16921430e-02f, -1.59515947e-01f, -2.53968328e-01f, -3.73870224e-01f, -2.73557723e-01f, -3.01393181e-01f, -2.28442580e-01f,
  -1.70452118e-01f, 5.99701665e-02f, -2.86990814e-02f, 4.11633551e-01f, 3.82407337e-01f, -1.49019986e-01f, 1.58142641e-01f, 1.39364928e-01f, -1.06920943e-01f, 2.06514075e-01f,
  -2.62715697e-01f, 1.75656930e-01f, -4.07237798e-01f, -3.08547497e-01f, -3.67793828e-01f, -3.59917432e-01f, 3.95530492e-01f, 2.96197355e-01f, 1.44035503e-01f, 1.48522377e-01f,
  2.40132317e-01f, -4.61926073e-01f, 7.56325871e-02f, 1.46289319e-01f, -2.37525716e-01f, 1.14548601e-01f, 2.62276739e-01f, -2.09258005e-01f, -1.94460809e-01f, -3.79668534e-01f,
  -1.45301819e-01f, 2.63521910e-01f, -3.50831807e-01f, 4.17541087e-01f, 3.20658460e-02f, -2.32758597e-01f, -4.44601417e-01f, 3.14706564e-01f, -3.36267680e-01f, 3.59496623e-01f,
  -4.02488053e-01f, -1.66498259e-01f, -2.55701303e-01f, 1.00008599e-01f, 7.51571357e-03f, 2.84074008e-01f, -3.85717675e-02f, -3.96865875e-01f, -3.19629878e-01f, 3.00571740e-01f,
  -2.39700228e-01f, 5.02277575e-02f, -7.97314495e-02f, -1.67295247e-01f, 3.86212058e-02f, -2.79796511e-01f, 3.06148976e-01f, 2.72413611e-01f, 2.96470046e-01f, -1.49779484e-01f,
  -9.62923169e-02f, 1.20441116e-01f, -1.46372318e-02f, -1.70045033e-01f, -2.90767491e-01f, 1.18515886e-01f, -1.81359932e-01f, 2.56464243e-01f, -3.74350429e-01f, -3.12564611e-01f,
  1.39264914e-03f, -9.93519947e-02f, 2.34168440e-01f, -9.04452801e-02f, -2.02087328e-01f, -4.43880320e-01f, 2.63098955e-01f, -1.18288547e-01f, -3.86187322e-02f, -1.89578488e-01f,
  -2.69034863e-01f, -2.79036403e-01f, 4.03727517e-02f, 3.07055980e-01f, -2.79445201e-01f, -1.70728385e-01f, 2.08806265e-02f, -1.62017450e-01f, -2.83355445e-01f, -2.53791213e-01f,
  -3.53388220e-01f, -3.75908256e-01f, -3.88185740e-01f, -1.59921512e-01f, 2.86528409e-01f, 2.99892217e-01f, -1.87054455e-01f, -8.86794850e-02f, -2.97091722e-01f, 2.71494508e-01f,
  2.66484529e-01f, 9.48915556e-02f, 1.35176182e-01f, 1.66332155e-01f, 7.52004981e-02f, 1.04058623e-01f, 1.09999232e-01f, 1.27318621e-01f, -8.71153027e-02f, -7.68100321e-02f,
  1.88337252e-01f, 1.10824145e-01f, 2.66039222e-01f, 3.85484755e-01f, 7.94279352e-02f, 2.18122199e-01f, -2.53209770e-01f, 1.75596982e-01f, -3.30665439e-01f, 2.22291097e-01f,
  3.46011281e-01f, -2.87297189e-01f, 1.89870340e-03f, 2.95057178e-01f, -7.52819479e-02f, -4.44318920e-01f, -2.03966230e-01f, 2.25451112e-01f, 4.30041909e-01f, -1.34854987e-01f,
  3.39081377e-01f, 6.15614243e-02f, 1.19628847e-01f, -2.21890241e-01f, 4.38328296e-01f, -3.83883379e-02f, -6.84840009e-02f, 4.44274694e-02f, -7.45366439e-02f, -4.49881554e-02f,
  -2.35960945e-01f, -5.08958697e-01f, 1.82055458e-01f, -8.37518051e-02f, -1.52816281e-01f, -2.45319590e-01f, -9.86353606e-02f, -3.20514143e-01f, -2.59992242e-01f, -2.13390008e-01f,
  -2.02264294e-01f, -2.28851903e-02f, 4.90592092e-01f, -2.69977272e-01f, -3.60398531e-01f, -3.70418429e-02f, 1.31271988e-01f, -1.94393750e-02f, 2.02498391e-01f, -2.48305693e-01f,
  -2.79841781e-01f, -2.24446878e-01f, -9.97987390e-03f, -1.08732559e-01f, -1.87487349e-01f, -1.86610281e-01f, -3.65161359e-01f, 1.01960912e-01f, -2.38860101e-01f, 1.52191371e-01f,
  4.12843190e-02f, -1.38703406e-01f, -2.13723093e-01f, 1.73370335e-02f, -5.42764775e-02f, -3.40611219e-01f, -1.67038888e-01f, -3.81783843e-01f, 3.15931946e-01f, -3.09391409e-01f,
  -3.38508114e-02f, -6.47046939e-02f, 6.61718622e-02f, -4.97187495e-01f, -2.94286132e-01f, -2.33275458e-01f, -3.56352516e-02f, -3.02533835e-01f, 3.09538871e-01f, -3.88808042e-01f,
  7.27559850e-02f, -8.39568228e-02f, -3.42481464e-01f, -3.34817380e-01f, 2.26538137e-01f, -2.97172785e-01f, 3.77608359e-01f, -2.29611114e-01f, -3.48181367e-01f, 3.89596730e-01f,
  -5.25629297e-02f, -3.61528456e-01f, -1.56284779e-01f, 2.57489812e-02f, 1.13572583e-01f, 9.72673222e-02f, 4.97499704e-02f, -1.80782169e-01f, -5.73637802e-03f, -1.54843897e-01f,
  -1.33661732e-01f, 6.24926984e-02f, -1.37503043e-01f, -1.48759246e-01f, 4.32468534e-01f, 2.60146290e-01f, -9.02984198e-03f, 1.71982765e-01f, -1.53135017e-01f, -3.25426549e-01f,
  -2.05892861e-01f, 2.30896637e-01f, -3.07898313e-01f, -3.16526800e-01f, -2.23463789e-01f, 3.13806891e-01f, 1.82730496e-01f, -3.20500135e-01f, 6.53705746e-02f, -2.53407151e-01f,
  9.74136405e-03f, -2.86369994e-02f, 1.33424222e-01f, -7.09074214e-02f, 1.33172840e-01f, 1.80459201e-01f, -1.20583083e-02f, 6.03843406e-02f, -1.16379887e-01f, 4.24173698e-02f,
  5.96354902e-02f, -3.06626618e-01f, 7.41225258e-02f, 2.80730844e-01f, 2.08453625e-01f, 2.73161054e-01f, -1.01050297e-02f, 8.76329541e-02f, -3.55215490e-01f, 1.83708835e-02f,
  -1.86489120e-01f, 2.00788468e-01f, 2.37367555e-01f, 3.53083074e-01f, 3.09837818e-01f, 1.96410745e-01f, -2.12455437e-01f, -4.22750145e-01f, -2.04409674e-01f, -2.54791856e-01f,
  -2.05067061e-02f, 1.66707728e-02f, 1.35848090e-01f, -1.80091441e-01f, -7.87896588e-02f, -5.81817180e-02f, 1.67377770e-01f, 2.61936992e-01f, 2.94848710e-01f, -2.52713978e-01f,
  -3.31820905e-01f, -2.65950799e-01f, -2.69731253e-01f, -7.92346895e-02f, 4.21746336e-02f, -2.75601059e-01f, -3.05201244e-02f, 3.83931130e-01f, -9.30181965e-02f, -2.42995694e-02f,
  -1.40873998e-01f, -2.74338067e-01f, -3.75939935e-01f, -5.85239604e-02f, -1.44040987e-01f, 7.33775645e-02f, -2.55524576e-01f, -2.15941474e-01f, 3.04090381e-01f, 3.06905627e-01f,
  2.55218357e-01f, -1.84475303e-01f, -1.61348253e-01f, -2.64846057e-01f, -5.13125621e-02f, -2.65006065e-01f, 4.38756466e-01f, -3.00138861e-01f, -1.95925802e-01f, -2.71959722e-01f,
  3.75834852e-01f, -3.56189497e-02f, -3.35319489e-01f, -5.65304644e-02f, -3.23543727e-01f, -1.83511183e-01f, -1.99234515e-01f, -3.15301180e-01f, 1.66694015e-01f, -1.36553571e-01f,
  -2.88484812e-01f, 1.67633072e-01f, 2.32424378e-01f, -1.00308746e-01f, -2.00256072e-02f, -3.61721247e-01f, -2.81535864e-01f, 1.44933298e-01f, 8.08675885e-02f, -9.72476825e-02f,
  -1.85275570e-01f, -3.81402344e-01f, -1.97978035e-01f, -3.30801636e-01f, 8.59761983e-02f, -4.77102585e-03f, 2.83741057e-01f, 6.67472854e-02f, -4.78837974e-02f, 2.15781614e-01f,
  -2.59236783e-01f, -1.53100058e-01f, 1.25433609e-01f, 3.33373964e-01f, 4.59178895e-01f, 4.67198566e-02f, 6.84162378e-02f, -2.63465881e-01f, -3.38187993e-01f, -1.79915383e-01f,
  -1.88198149e-01f, 3.76095772e-01f, -8.74571037e-03f, 1.23383835e-01f, -3.20865661e-01f, -7.72340670e-02f, -2.39291251e-01f, 4.42026049e-01f, 7.07620829e-02f, 3.10949266e-01f,
  1.28880277e-01f, -5.38746044e-02f, 2.33503226e-02f, -2.46592462e-01f, -1.51885808e-01f, -1.03952944e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.93899456e-02f, -1.13290884e-02f, -1.26648188e-01f, -9.12934716e-04f, -1.01659028e-02f, -4.45965044e-02f, 6.78212345e-02f, -8.39543343e-02f, -1.50953591e-01f, 4.37461063e-02f,
  1.12904832e-01f, -1.22156776e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    