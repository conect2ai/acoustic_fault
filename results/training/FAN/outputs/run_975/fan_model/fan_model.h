/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.30362168e-01f, -4.88499880e-01f, -5.30447550e-02f, -4.58972931e-01f, -2.44781181e-01f, -1.19749747e-01f, -2.88315535e-01f, 8.39912519e-02f, 1.22290976e-01f, -3.29590738e-01f,
  -7.92357251e-02f, 2.05317304e-01f, 1.17438532e-01f, 9.88266692e-02f, 8.65990967e-02f, -4.56807345e-01f, -4.27846402e-01f, 9.57797840e-02f, 3.46890897e-01f, 1.00116367e-02f,
  -1.78173438e-01f, -2.41104677e-01f, 4.71491553e-02f, 3.48113738e-02f, -1.20986737e-01f, 1.55279860e-01f, -1.85828164e-01f, -5.34329265e-02f, -1.89261302e-01f, -4.55583543e-01f,
  -4.08762515e-01f, -5.18722162e-02f, 2.43837699e-01f, -9.13759228e-04f, 2.46007238e-02f, 1.05813250e-01f, -6.72736987e-02f, 1.04677558e-01f, 1.45438492e-01f, 5.57799311e-03f,
  -5.33226505e-02f, 8.09973329e-02f, -3.71523522e-04f, 1.70017704e-02f, -4.63392809e-02f, 3.35173588e-03f, 2.12638471e-02f, 7.54270852e-02f, 2.81883553e-02f, -5.07239178e-02f,
  -8.13712254e-02f, -8.36176798e-02f, 7.42842676e-03f, 8.36650431e-02f, 2.00340599e-01f, 1.53595805e-01f, 4.47554477e-02f, 1.61120936e-01f, 1.43643975e-01f, -7.56002814e-02f,
  6.13972992e-02f, -5.68199232e-02f, 1.00727707e-01f, 1.36947846e-02f, 2.57998728e-03f, 7.27970898e-02f, -1.32555529e-01f, 1.61304418e-02f, 5.32653332e-02f, 2.53101755e-02f,
  2.80092210e-02f, -1.28053352e-01f, -1.36400415e-02f, -4.25934903e-02f, -3.49338986e-02f, -8.16445705e-03f, -7.34024495e-02f, -1.23111233e-02f, 4.32849601e-02f, -4.14309576e-02f,
  3.46482955e-02f, 3.81508954e-02f, 1.95822958e-02f, 2.60162968e-02f, -1.38708979e-01f, -8.08517560e-02f, 4.68451343e-03f, -2.23131943e-02f, 5.64515330e-02f, -3.73527557e-02f,
  8.21447372e-02f, 2.12756783e-01f, -9.14981738e-02f, 9.08073485e-02f, 2.26929560e-02f, 9.95778516e-02f, 6.28217459e-02f, -3.72694386e-03f, -4.63897130e-03f, 3.68834995e-02f,
  1.47445560e-01f, 2.32449863e-02f, 7.99423158e-02f, 3.89303677e-02f, 1.10245161e-01f, 1.51365250e-01f, -9.46741179e-03f, -3.14920284e-02f, 1.24468565e-01f, 2.89246277e-03f,
  1.58919431e-02f, 1.99150611e-02f, 1.88453913e-01f, 1.50753841e-01f, 1.63881987e-01f, 1.94439292e-01f, 2.70256490e-01f, 7.97775984e-02f, 2.31542110e-01f, -4.57366034e-02f,
  9.22418654e-01f, -3.02731454e-01f, -3.34564686e-01f, 2.96136916e-01f, -4.51802313e-01f, -3.64942849e-01f, -5.57915747e-01f, 4.99781482e-02f, 2.51542181e-01f, -2.03285366e-02f,
  -6.34047836e-02f, 3.47125024e-01f, 2.28971705e-01f, 1.98411882e-01f, 1.23784587e-01f, -4.46102232e-01f, -3.74601126e-01f, 1.29126802e-01f, 1.14111468e-01f, 2.07816064e-01f,
  4.47419100e-02f, 1.94677234e-01f, 4.11118746e-01f, 1.58010468e-01f, -7.23259002e-02f, 3.82313579e-02f, -2.96814650e-01f, -6.73947930e-02f, -2.59001225e-01f, 7.14234412e-02f,
  5.46677271e-03f, -4.67883470e-03f, -5.71924308e-03f, 7.07700774e-02f, -1.02205299e-01f, 5.64603917e-02f, 8.59830342e-03f, 5.07251825e-03f, -3.84432673e-02f, 4.20349231e-03f,
  -4.37282287e-02f, 1.12621319e-02f, 6.31452575e-02f, -1.69281606e-02f, -1.51052345e-02f, 1.07989004e-02f, -5.28665744e-02f, 6.41915947e-02f, 2.52064485e-02f, -3.92014310e-02f,
  -2.16361415e-02f, -8.90136883e-02f, -1.06257327e-01f, -1.42674953e-01f, -1.49224298e-02f, 5.76373227e-02f, -8.64960253e-02f, 8.11353326e-02f, -3.24596912e-02f, 9.42000374e-02f,
  4.99766611e-04f, -1.20478179e-02f, -4.32844125e-02f, 1.70116238e-02f, 4.00075614e-02f, -1.15861759e-01f, 3.08551751e-02f, -3.14253457e-02f, 1.08955875e-01f, 2.62597110e-02f,
  -8.78907517e-02f, -2.69114482e-03f, 2.00586747e-02f, -3.97024378e-02f, 4.39599715e-02f, -7.93601722e-02f, -4.25001085e-02f, 1.08494954e-02f, 8.05149078e-02f, 4.37557101e-02f,
  9.15873423e-02f, -6.85566012e-03f, -1.70771759e-02f, 5.76610267e-02f, -9.09727365e-02f, -2.10969783e-02f, 4.50426973e-02f, -1.88026354e-02f, 2.97243390e-02f, 8.11870210e-03f,
  1.31869629e-01f, -8.64844844e-02f, 1.15484193e-01f, 1.54315457e-01f, -2.12779194e-02f, -9.10019316e-03f, 4.38160673e-02f, -2.25917855e-03f, 4.29514088e-02f, -6.69029579e-02f,
  7.96621013e-03f, 2.17975304e-02f, -9.21846181e-02f, 1.07866302e-02f, 4.51641716e-02f, 1.93461105e-02f, -2.68771909e-02f, 6.34630099e-02f, 4.58684564e-02f, 7.30741248e-02f,
  -3.82778724e-03f, -1.32547300e-02f, 4.79811467e-02f, 3.04961577e-02f, 3.29882987e-02f, 1.28502131e-01f, -2.00327616e-02f, -9.61244851e-02f, -8.76054317e-02f, -1.47470921e-01f,
  -7.64258862e-01f, 4.60850477e-01f, -5.60067177e-01f, -1.54404178e-01f, 1.12530738e-01f, 1.50922267e-02f, 1.57966033e-01f, -4.83769476e-02f, 5.06533273e-02f, 8.20486322e-02f,
  3.40546906e-01f, 2.29424149e-01f, -2.75511928e-02f, 1.49944708e-01f, -1.41120270e-01f, -3.05397436e-02f, -1.65092617e-01f, -5.09828091e-01f, -2.53850788e-01f, 1.87315583e-01f,
  5.35582066e-01f, 1.59872212e-02f, -2.98082143e-01f, -9.16904882e-02f, 1.34736583e-01f, 2.12953836e-02f, -2.46717501e-02f, -5.79832005e-04f, 1.56508610e-01f, 1.30921230e-01f,
  -6.54149726e-02f, -1.47070587e-01f, -7.94652849e-02f, 2.11204737e-02f, 7.50923380e-02f, -6.95794150e-02f, 9.88830719e-03f, -1.64444730e-01f, 5.06778024e-02f, -3.15474235e-02f,
  -8.32350552e-02f, 5.60741276e-02f, -5.55045046e-02f, 7.10715130e-02f, -5.83660156e-02f, -1.01593733e-01f, -6.70259073e-02f, -2.43871734e-01f, -7.00659603e-02f, 4.24606837e-02f,
  2.50493407e-01f, 3.09145004e-02f, -1.16308130e-01f, 6.81360113e-03f, -2.02385932e-02f, -3.05942148e-02f, 6.86330795e-02f, -4.25032936e-02f, -1.38494268e-01f, -7.64177963e-02f,
  2.83090882e-02f, 4.73958962e-02f, 1.22993402e-01f, 5.32571189e-02f, 1.14816882e-01f, 1.77913476e-02f, -8.59389007e-02f, 7.35309571e-02f, 5.19471467e-02f, -1.74637523e-03f,
  1.01529527e-02f, 4.76315692e-02f, 7.26086423e-02f, -6.74280375e-02f, 8.67624432e-02f, 6.51744679e-02f, 1.61133800e-02f, 5.77061065e-02f, 5.03932424e-02f, 2.96408851e-02f,
  4.61252965e-02f, -8.17661658e-02f, -1.54313846e-02f, -9.20214318e-03f, 1.66021392e-03f, -3.21092941e-02f, 7.95714837e-03f, 8.80813897e-02f, 5.71476705e-02f, 2.13207863e-02f,
  1.58612952e-02f, -1.53337911e-01f, -4.14608754e-02f, -7.24897236e-02f, -7.27988109e-02f, -1.77563615e-02f, 3.13341022e-02f, -1.99083816e-02f, 1.42543949e-02f, -6.05223961e-02f,
  9.00930632e-03f, -7.18638897e-02f, -4.98687588e-02f, -5.04457206e-02f, -8.54687244e-02f, 2.91609131e-02f, 1.32621020e-01f, -2.56877709e-02f, 5.19822799e-02f, -2.02651694e-03f,
  -6.96259900e-04f, -6.77888189e-03f, -9.02272537e-02f, -1.04091451e-01f, 1.67838447e-02f, -8.44513625e-02f, 2.20593382e-02f, 1.71968713e-02f, -1.61296710e-01f, 3.03367767e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.17114842e+00f, 3.06964099e-01f, 3.74195486e-01f, 1.72342077e-01f, 4.73175615e-01f, 4.56310034e-01f, 6.61284208e-01f, 2.65535384e-01f, -3.49159841e-03f, 2.80885130e-01f,
  2.72868186e-01f, -9.27835554e-02f, -9.58802924e-02f, -1.69063553e-01f, 1.67841539e-01f, -1.56190507e-02f, -1.76171601e-01f, -1.66060627e-02f, 1.31661549e-01f, 1.31739140e-01f,
  -1.61143050e-01f, -1.06740169e-01f, 1.91437766e-01f, 1.15458503e-01f, -2.29211207e-02f, -2.62338549e-01f, -8.20694417e-02f, 5.08044250e-02f, -1.30420420e-02f, -3.94249469e-01f,
  1.58424556e-01f, 5.47664225e-01f, -3.58350217e-01f, -1.16395522e-02f, 3.34801562e-02f, -1.94751769e-01f, -6.85163885e-02f, -1.89997360e-01f, 7.44507881e-03f, -2.28022076e-02f,
  -8.50837156e-02f, -1.90966558e-02f, 9.81011167e-02f, -3.19048949e-02f, 5.42959608e-02f, -1.21753514e-01f, -5.23437038e-02f, -5.96648864e-02f, 4.85211378e-03f, 2.71772668e-02f,
  -3.05668879e-02f, 1.29317164e-01f, 3.09820354e-01f, 9.80100483e-02f, 3.23745281e-01f, -1.01510264e-01f, 1.26380250e-01f, 1.38124049e-01f, 1.51941508e-01f, 4.00981531e-02f,
  7.08770379e-02f, 3.91643852e-01f, 2.30258733e-01f, -1.88726047e-03f, 1.28043905e-01f, -1.66806743e-01f, -8.16250145e-02f, 2.66209394e-02f, 4.97194156e-02f, 7.30540454e-02f,
  -1.96133241e-01f, -1.83316809e-03f, -7.95848444e-02f, -3.07773389e-02f, 7.55833760e-02f, 7.15921670e-02f, -1.33184880e-01f, 2.54577696e-02f, 8.77559856e-02f, -8.26673731e-02f,
  9.21665207e-02f, -3.02451476e-02f, -4.55276445e-02f, 4.03312035e-02f, -4.78452928e-02f, 8.33916515e-02f, 7.37037733e-02f, -4.47434410e-02f, 1.10547036e-01f, 1.00403987e-01f,
  -5.17475247e-01f, 2.50945270e-01f, -3.41339946e-01f, -1.06614314e-01f, 1.41985834e-01f, -1.02279931e-01f, 7.08562955e-02f, -1.57026753e-01f, -6.68834150e-02f, -1.05479605e-01f,
  1.43037783e-02f, -5.18033691e-02f, 7.09346384e-02f, -6.09812364e-02f, -7.66677186e-02f, -1.67276725e-01f, -6.17877534e-03f, -1.48366615e-01f, -2.25755647e-01f, -1.41394839e-01f,
  -1.28246188e-01f, -2.00873390e-01f, -9.34625119e-02f, -8.94669220e-02f, -1.20319821e-01f, -3.13741803e-01f, -1.01936832e-01f, -1.22979172e-01f, 2.86054965e-02f, -2.02438861e-01f,
  -1.11151290e+00f, -2.65592903e-01f, -3.47599447e-01f, 3.76644492e-01f, 3.89244467e-01f, -9.95520875e-02f, -7.68244267e-01f, -5.24790764e-01f, 1.30500421e-01f, -5.65325953e-02f,
  3.42732333e-02f, 3.10109168e-01f, 9.57752541e-02f, 1.97275013e-01f, -5.03070414e-01f, -7.25050876e-03f, 6.79200590e-01f, -3.42851505e-02f, -2.84505904e-01f, -2.87915468e-01f,
  3.48805189e-01f, 2.04320177e-02f, -3.14369023e-01f, -1.22696050e-01f, 3.10240299e-01f, 3.59826982e-01f, 2.26048052e-01f, 2.07810894e-01f, 3.36399287e-01f, 5.91519833e-01f,
  -2.32590452e-01f, -6.05892956e-01f, -2.16352418e-02f, 1.38978839e-01f, 5.17313443e-02f, -1.58890203e-01f, 1.86918732e-02f, 6.42890260e-02f, 1.16203733e-01f, 2.84042433e-02f,
  1.37716994e-01f, -1.81735754e-01f, -1.05922008e-02f, 1.19509540e-01f, -1.13195725e-01f, -3.71301472e-01f, -1.31303027e-01f, -6.29664838e-01f, -5.25204182e-01f, -7.43638217e-01f,
  3.68437707e-01f, 1.90363109e-01f, -3.88465047e-01f, -2.01983035e-01f, -3.92075628e-01f, 4.02375519e-01f, -3.95098418e-01f, -2.47246727e-01f, -1.77423030e-01f, -6.39820933e-01f,
  2.75323447e-02f, 6.51401281e-02f, 7.00048208e-02f, -1.24858290e-01f, -1.15912691e-01f, 1.61938056e-01f, 2.09680200e-01f, -1.52097285e-01f, 1.53990269e-01f, -2.52806038e-01f,
  3.15579735e-02f, -1.75803691e-01f, -1.43808171e-01f, -2.50715792e-01f, 7.79700726e-02f, 2.63450295e-01f, 1.39084272e-02f, -1.13759771e-01f, -5.73578849e-02f, -9.60543528e-02f,
  -6.96121678e-02f, -5.11118770e-02f, 3.68752509e-01f, -9.27695855e-02f, -7.82458037e-02f, 1.17121212e-01f, 8.50487500e-02f, 2.48208940e-02f, -1.15530370e-02f, 2.97614895e-02f,
  -7.29334801e-02f, 1.71384975e-01f, 2.63239350e-02f, -6.94234520e-02f, 5.95204420e-02f, 9.68843997e-02f, -2.47645508e-02f, 2.02832833e-01f, -6.97325245e-02f, -4.93416578e-01f,
  -2.93837547e-01f, -1.57164618e-01f, 1.47711840e-02f, -6.13509864e-02f, -2.55688310e-01f, 6.29999936e-02f, -9.38904211e-02f, 5.51514104e-02f, -7.11496100e-02f, 4.09738235e-02f,
  2.75093075e-02f, -5.67394376e-01f, -4.46846992e-01f, -4.18930471e-01f, 3.12710777e-02f, -2.69113809e-01f, -3.46204966e-01f, -2.38614485e-01f, -4.62180018e-01f, -8.01642895e-01f,
  1.06354976e+00f, 1.38405278e-01f, -1.41507196e+00f, 6.68611109e-01f, -1.21474102e-01f, -5.16618550e-01f, -4.46787834e-01f, 1.61342949e-01f, 5.61605215e-01f, -6.62839264e-02f,
  6.15820987e-03f, 1.30852371e-01f, 6.82027787e-02f, -1.91083342e-01f, -5.47501862e-01f, -7.76440382e-01f, -8.33596945e-01f, -7.27228463e-01f, -8.09807539e-01f, -4.14320737e-01f,
  -4.74584475e-02f, 1.33518845e-01f, 9.36112273e-03f, -1.30072564e-01f, 1.19185850e-01f, 8.92955959e-02f, -3.95599931e-01f, -2.18037903e-01f, -4.39979374e-01f, -2.22643435e-01f,
  -6.39451683e-01f, -5.05011491e-02f, -2.24489309e-02f, 2.50381947e-01f, 8.66499320e-02f, 1.48798645e-01f, -6.93022013e-02f, 1.55862316e-01f, 2.49619961e-01f, 6.43775091e-02f,
  6.08211337e-03f, 9.32024494e-02f, 2.97550838e-02f, -5.32567911e-02f, 3.65756974e-02f, -7.31766969e-02f, 7.75430128e-02f, -1.22130431e-01f, 2.55157389e-02f, -7.94192776e-02f,
  7.56970793e-02f, -1.74356997e-01f, -2.84701645e-01f, -4.55574971e-03f, -1.11088969e-01f, -6.09972477e-02f, 5.92838787e-02f, -9.11005065e-02f, -2.22255796e-01f, 4.36935425e-01f,
  1.35993464e-02f, 2.14805260e-01f, -6.87421560e-02f, -3.89331765e-02f, 5.82428128e-02f, 1.38356104e-01f, 1.00090027e-01f, -6.64329529e-03f, -4.55265418e-02f, 7.78376162e-02f,
  1.54226467e-01f, -1.20537788e-01f, 3.12309489e-02f, 7.44160414e-02f, -1.23524018e-01f, -4.40537743e-03f, -2.43275221e-02f, -3.94579247e-02f, -4.47449125e-02f, 1.53903171e-01f,
  5.65602444e-03f, -2.17074305e-02f, -6.36233389e-02f, -3.85021046e-02f, -2.26689488e-01f, -8.98226798e-02f, -1.40141668e-02f, 5.62382005e-02f, 1.32915601e-01f, 4.79482301e-02f,
  5.05913198e-01f, -3.36688876e-01f, 1.45627871e-01f, -2.48364154e-02f, -6.74913004e-02f, 7.73472711e-02f, -2.16647293e-02f, -3.60291265e-02f, 9.55155194e-02f, -7.45877856e-03f,
  -1.48991853e-01f, -5.82801104e-02f, 1.81597359e-02f, 9.87307504e-02f, -5.17959744e-02f, -2.04789817e-01f, 4.04597558e-02f, -1.23474002e-02f, -1.06397651e-01f, 1.01582803e-01f,
  1.14844896e-01f, -8.76052827e-02f, 1.38391271e-01f, 1.22106798e-01f, 1.01884902e-01f, -2.16018587e-01f, -1.59601435e-01f, 2.93017644e-02f, -1.84654176e-01f, 3.26805502e-01f,
  2.58975595e-01f, -9.17587280e-01f, -8.08521271e-01f, -2.37511039e-01f, -1.90586001e-02f, 3.71251613e-01f, 2.29482412e-01f, 2.32200086e-01f, 2.86969125e-01f, -4.37099755e-01f,
  -5.44350863e-01f, -1.32196024e-01f, -6.61722302e-01f, -8.81346613e-02f, 2.28033632e-01f, -1.13102971e-02f, -2.51190156e-01f, 3.45788635e-02f, 5.83977997e-01f, 7.86462247e-01f,
  4.54438657e-01f, -1.76634088e-01f, -1.48566244e-02f, 4.71534990e-02f, -1.16301067e-01f, -2.15575412e-01f, -1.02406502e+00f, -4.33023959e-01f, -1.16337962e-01f, -9.02614355e-01f,
  -4.63146418e-01f, -4.68636870e-01f, 2.45864108e-01f, -8.87344778e-02f, -3.90932590e-01f, 2.20699282e-03f, -1.02256341e-02f, -2.43693694e-01f, 5.14476635e-02f, -1.33539870e-01f,
  -1.81902662e-01f, 1.25924990e-01f, -8.77825692e-02f, -9.70809683e-02f, 2.70423032e-02f, 3.42240408e-02f, -6.78362027e-02f, -1.01230994e-01f, -2.01048866e-01f, -1.17137350e-01f,
  -1.99082106e-01f, -2.66564842e-02f, 6.08022846e-02f, 6.53958246e-02f, -1.86664835e-02f, 1.81849804e-02f, -1.56367764e-01f, 7.06406161e-02f, -1.49603888e-01f, -5.82887568e-02f,
  8.76323972e-03f, -6.43352270e-02f, 7.09305704e-02f, 8.27923566e-02f, 1.09095871e-01f, 8.52745473e-02f, 1.25939563e-01f, 6.70583174e-02f, 7.76255280e-02f, -9.38537866e-02f,
  1.04665972e-01f, -3.10717486e-02f, -1.33327525e-02f, -7.60720372e-02f, -1.75194889e-01f, -2.60358565e-02f, 8.75229165e-02f, -7.00158849e-02f, -1.83048218e-01f, 4.67575109e-03f,
  3.94062474e-02f, 1.02193683e-01f, -3.62884812e-02f, 2.28431355e-02f, -9.75666866e-02f, -4.50487249e-02f, -1.60971042e-02f, -1.43124145e-02f, 2.93081859e-04f, 7.16219172e-02f,
  -4.83790897e-02f, 5.79540431e-02f, -1.86111685e-02f, 1.31688574e-02f, -4.78006676e-02f, -2.16035634e-01f, -3.07884336e-01f, 8.17165989e-03f, -7.11702649e-03f, 7.48328567e-02f,
  -7.00755119e-02f, -2.72714254e-02f, -6.71557486e-02f, -6.59863204e-02f, 1.61376312e-01f, -1.79288909e-02f, -1.17211558e-01f, 1.11577347e-01f, 5.34596406e-02f, -3.02382167e-02f,
  -2.71052867e-02f, 2.56800562e-01f, 2.80005872e-01f, 1.13074064e-01f, 7.76480138e-02f, 3.39090228e-01f, 1.35548403e-02f, 1.38339043e-01f, 2.62330264e-01f, 3.52478296e-01f,
  1.26452953e-01f, -9.32581663e-01f, 4.95444804e-01f, -5.84136188e-01f, -4.86943722e-01f, -4.63122278e-01f, -8.62063646e-01f, -4.14048851e-01f, -3.60615164e-01f, -4.00358230e-01f,
  -5.90795018e-02f, 4.02201921e-01f, 8.06091487e-01f, 3.22724730e-01f, 3.01147193e-01f, -1.53414935e-01f, 1.88812390e-01f, 6.69329047e-01f, 2.57314086e-01f, -7.74339616e-01f,
  -7.74344921e-01f, -2.58296788e-01f, 3.04900166e-02f, -5.41686937e-02f, -7.70109534e-01f, 1.49510503e-01f, 3.19793850e-01f, -2.21344903e-01f, -5.58197439e-01f, -3.12931925e-01f,
  1.47307366e-01f, -4.05301899e-01f, 1.11995630e-01f, 4.73637134e-03f, -5.63940443e-02f, 3.44276987e-02f, -1.00712031e-01f, 1.03490189e-01f, -1.30031146e-02f, -7.05448315e-02f,
  -2.47582071e-03f, -1.25752702e-01f, 7.55499974e-02f, -1.36328749e-02f, -3.88246439e-02f, -8.97078812e-02f, -6.55065253e-02f, -6.12423569e-02f, 8.66703615e-02f, -5.33784851e-02f,
  -4.31751966e-01f, -1.72761977e-01f, 1.38755694e-01f, -8.28608572e-02f, -2.63614088e-01f, 3.94324809e-01f, -4.84200716e-02f, -3.56650949e-01f, 1.49976820e-01f, -2.97501713e-01f,
  -1.81891456e-01f, 9.01509523e-02f, 6.63311174e-03f, -8.33142921e-02f, -2.18987279e-02f, 1.77224904e-01f, 1.56836472e-02f, -4.26753424e-02f, 1.05394684e-01f, 1.86487045e-02f,
  -5.38026616e-02f, 1.35428712e-01f, 6.54399544e-02f, -7.55538791e-03f, 3.50366645e-02f, 5.48637509e-02f, 5.84757105e-02f, 1.14136245e-02f, -4.74717841e-02f, 3.75618227e-02f,
  7.23214149e-02f, -1.14784248e-01f, 1.35568008e-01f, -1.46089002e-01f, -2.11244524e-01f, 8.75402242e-02f, 1.68936495e-02f, 1.01872580e-02f, 8.41862410e-02f, 3.23963016e-02f,
  4.88662124e-01f, 2.18420312e-01f, 1.72572270e-01f, -5.31085879e-02f, -9.32567641e-02f, 3.98340262e-02f, 6.91492343e-03f, -7.75376409e-02f, 1.33309767e-01f, -8.51379335e-02f,
  -2.35629901e-01f, 1.19798087e-01f, -6.47294298e-02f, -5.37014380e-02f, -1.81499884e-01f, -4.40637507e-02f, -1.42469093e-01f, 7.04221353e-02f, -2.26661772e-01f, -9.71063972e-02f,
  -2.11338684e-01f, 1.33605916e-02f, 2.29367927e-01f, 1.04063511e-01f, -2.36431807e-01f, 4.96041268e-01f, 3.84877086e-01f, 1.90670073e-01f, 4.34457123e-01f, 5.43641821e-02f,
  5.49925089e-01f, -3.87269199e-01f, -1.42499939e-01f, 4.22626704e-01f, 2.98856556e-01f, 4.70068157e-02f, 3.12765807e-01f, 1.11520447e-01f, 1.33804545e-01f, 3.10831964e-01f,
  -1.43152744e-01f, -4.21796411e-01f, -2.85363436e-01f, -2.64841050e-01f, -1.11290045e-01f, 2.30827749e-01f, 1.52561069e-01f, -1.27713114e-01f, 1.50354251e-01f, 2.52543658e-01f,
  1.08226538e-01f, 4.16250646e-01f, 3.01100135e-01f, 3.23796049e-02f, -2.30395067e-02f, 1.86356351e-01f, -1.28839966e-02f, -1.73688918e-01f, -3.15286160e-01f, -6.68367803e-01f,
  4.05496508e-02f, -3.96407008e-01f, -5.53469732e-02f, -1.37677535e-01f, -1.97628886e-01f, -2.88294870e-02f, 1.23725690e-01f, -1.63178027e-01f, -2.88197584e-02f, 3.68356258e-02f,
  -5.35428599e-02f, -3.61896813e-01f, -4.26237553e-01f, -2.62986813e-02f, -1.19056456e-01f, -3.23660970e-02f, -7.85342902e-02f, -3.39217573e-01f, -2.76819944e-01f, -2.61182129e-01f,
  -3.58962625e-01f, -3.45794350e-01f, -5.45165479e-01f, -1.07018405e-03f, -2.61670440e-01f, -1.53432965e-01f, -2.52000898e-01f, -5.46662331e-01f, -3.62084657e-01f, -2.48408705e-01f,
  1.27623677e-01f, -1.02772206e-01f, -2.24343129e-02f, 6.89164996e-02f, 1.02840252e-02f, 2.56238680e-04f, -2.81233311e-01f, -1.14640072e-01f, -5.59243746e-02f, 8.21681842e-02f,
  -2.39667267e-01f, -9.39906947e-03f, -2.41435263e-02f, -7.11931065e-02f, -3.64481509e-02f, -1.58955112e-01f, -1.36755958e-01f, -1.45601749e-01f, -1.83837377e-02f, 1.35278821e-01f,
  9.66282785e-02f, -1.94609210e-01f, 7.42125064e-02f, -3.62824947e-02f, -8.59833062e-02f, -1.28796995e-01f, 1.07576840e-01f, -1.17325909e-01f, -2.20811483e-03f, 1.29570827e-01f,
  3.09527785e-01f, -2.72740215e-01f, 1.47863597e-01f, 9.72809196e-02f, 6.92475066e-02f, 2.63692349e-01f, 9.73023027e-02f, -2.69630123e-02f, 3.41923354e-04f, -2.39124484e-02f,
  -3.18932608e-02f, 2.12172076e-01f, -4.76808362e-02f, 7.44951218e-02f, 2.52042145e-01f, 1.69751674e-01f, 1.34113938e-01f, 1.06773764e-01f, -6.89778179e-02f, 1.65728763e-01f,
  8.16428661e-02f, 3.74439180e-01f, 2.86476195e-01f, -1.43615343e-02f, -1.88315753e-02f, 2.18193918e-01f, 2.84357280e-01f, 2.09080487e-01f, 1.57710671e-01f, 9.10353899e-01f,
  -1.31564069e+00f, 2.12635368e-01f, -1.95552126e-01f, -1.23790815e-01f, 1.41422302e-01f, 8.52452368e-02f, 4.33378220e-01f, 2.86558032e-01f, 1.25325516e-01f, 1.52161181e-01f,
  2.43925359e-02f, 1.61818415e-01f, 2.87950784e-01f, 2.40913108e-01f, 1.32952914e-01f, 3.63011062e-01f, 3.58389139e-01f, -4.48119119e-02f, -1.54000551e-01f, 1.08771123e-01f,
  3.50918591e-01f, 7.09443390e-02f, -3.57480884e-01f, -3.39493854e-04f, 9.41074118e-02f, 1.06811784e-01f, 1.82702571e-01f, -4.64645438e-02f, 6.33890405e-02f, 5.52605838e-02f,
  2.83372581e-01f, -6.25979185e-01f, -8.46299976e-02f, -2.08906770e-01f, -3.74271780e-01f, -1.58974692e-01f, 2.82101221e-02f, -3.57511848e-01f, -1.49281472e-01f, -2.30859369e-02f,
  -1.34095758e-01f, -5.75522743e-02f, -1.55962080e-01f, 1.01128966e-02f, -7.32416585e-02f, -6.71427026e-02f, -1.01379462e-01f, -8.23457688e-02f, 1.63227633e-01f, 1.00302942e-01f,
  2.57118315e-01f, -1.52921379e-01f, -6.42088428e-02f, 2.01718509e-01f, -1.16888829e-01f, 1.48364073e-02f, -9.32429265e-03f, -1.27239987e-01f, -5.25756851e-02f, -6.44417331e-02f,
  1.44788057e-01f, -3.43051478e-02f, -2.16088165e-02f, 9.06613171e-02f, 3.14898714e-02f, 8.66899639e-02f, -3.50327417e-02f, -4.02953215e-02f, 1.84271485e-01f, 6.77774148e-03f,
  -1.41321599e-01f, 1.19191855e-01f, 1.68448016e-02f, -2.84037814e-02f, 1.19689368e-01f, -1.40462279e-01f, -9.34966207e-02f, 6.60976991e-02f, -1.18179232e-01f, 1.86338893e-03f,
  -9.56370160e-02f, -3.05797649e-03f, -1.28685519e-01f, -5.02664745e-02f, -2.51986757e-02f, -1.63360804e-01f, -1.43643782e-01f, -3.25978324e-02f, 1.00076184e-01f, 1.08479679e-01f,
  7.17460632e-01f, -1.83156341e-01f, 7.00033382e-02f, 1.60505667e-01f, -2.10828200e-01f, -1.92954719e-01f, -2.45222561e-02f, -2.46377468e-01f, -1.68870911e-01f, 8.26030131e-03f,
  -2.04814449e-01f, -1.05919205e-01f, 7.69607648e-02f, 2.56875642e-02f, -8.33890513e-02f, -1.42716914e-01f, 6.42277002e-02f, 3.16550918e-02f, 2.03929972e-02f, -2.13649757e-02f,
  1.52677283e-01f, 7.53799174e-03f, 1.47523671e-01f, 1.49556383e-01f, 1.68360099e-01f, 7.84057528e-02f, 7.07295015e-02f, 2.78284922e-02f, 8.80898461e-02f, 3.09577942e-01f,
  8.31631780e-01f, 6.72940850e-01f, 2.21388161e-01f, 5.60207516e-02f, -4.20660764e-01f, -3.68828744e-01f, -3.35772425e-01f, -1.21515922e-01f, -7.76358647e-05f, 2.98418794e-02f,
  1.38570415e-02f, -1.39886707e-01f, -1.24170467e-01f, -1.75066307e-01f, -9.23463777e-02f, 4.25683670e-02f, 1.02082230e-01f, 3.17458719e-01f, -4.51218635e-02f, -4.80360687e-02f,
  6.03212565e-02f, 2.10313112e-01f, 3.70476156e-01f, 1.15658015e-01f, 3.29396516e-01f, -1.12196550e-01f, -5.13736829e-02f, 4.51149829e-02f, -1.53925717e-02f, 7.49921143e-01f,
  4.80073690e-01f, 3.16106737e-01f, -3.76874804e-01f, -4.47805785e-02f, -7.48329833e-02f, 1.39122441e-01f, -9.90340579e-03f, 7.33284876e-02f, 1.08454712e-02f, -5.31158149e-02f,
  -9.01127607e-02f, 1.48496151e-01f, -4.06450666e-02f, -6.12709895e-02f, -1.24156877e-01f, 3.38176428e-03f, -6.74162284e-02f, 7.84946233e-02f, -1.25097096e-01f, 1.60680354e-01f,
  7.93431327e-02f, -7.17362463e-02f, -2.25465924e-01f, -2.98063576e-01f, -3.19067389e-02f, -2.20369548e-01f, -7.82258436e-02f, -3.59483659e-02f, -2.01671168e-01f, 1.16365120e-01f,
  -2.49779560e-02f, 5.70651814e-02f, 6.35297224e-03f, -4.38075140e-02f, -4.72752973e-02f, -4.15884741e-02f, 2.52127629e-02f, -2.06569821e-01f, -1.14849471e-01f, 1.80536918e-02f,
  -1.88311324e-01f, 2.29977374e-03f, -1.00240543e-01f, 4.76406403e-02f, -7.85517022e-02f, 8.24861303e-02f, -6.36365414e-02f, 7.44352937e-02f, -5.86923622e-02f, 8.96821767e-02f,
  -5.92599846e-02f, -2.80434955e-02f, 2.25317422e-02f, -7.20392913e-02f, 1.75611209e-03f, 8.35718028e-03f, -8.29823241e-02f, -1.16120897e-01f, -5.25755063e-03f, 1.21266909e-01f,
  -2.44593054e-01f, -6.60109818e-01f, 2.44771838e-01f, 2.00462878e-01f, 1.32482678e-01f, 9.15182084e-02f, 2.05077589e-01f, 1.94363594e-01f, 1.88659236e-01f, 1.34014234e-01f,
  8.04739073e-02f, 1.46406993e-01f, 6.16695397e-02f, -7.86784850e-03f, -2.28932053e-01f, -7.80461282e-02f, -3.72360572e-02f, 1.42243013e-01f, 1.31678537e-01f, 1.85688615e-01f,
  3.24432850e-02f, -2.54400998e-01f, -3.01211894e-01f, -1.40462697e-01f, -1.41093180e-01f, -2.68993676e-01f, -1.98943123e-01f, -8.72601196e-03f, -2.74372101e-01f, -2.76761234e-01f,
  6.17818177e-01f, -8.32060337e-01f, 7.69744208e-03f, 4.28137720e-01f, 2.96499014e-01f, 2.95977443e-01f, 9.96901318e-02f, 2.90959835e-01f, 3.62288952e-01f, 9.10212100e-02f,
  -4.32189330e-02f, 2.37979054e-01f, 2.25253895e-01f, 1.24426976e-01f, 1.45979658e-01f, 2.16455832e-01f, 3.59084994e-01f, 2.72695184e-01f, 3.52610707e-01f, 4.00009751e-01f,
  1.67123273e-01f, -1.30006105e-01f, -3.00372183e-01f, 1.31362766e-01f, -2.25842856e-02f, 3.01413774e-01f, -5.22899330e-02f, -3.49744499e-01f, -2.33100191e-01f, -3.61434966e-02f,
  -2.66717613e-01f, -1.75471738e-01f, 4.23151642e-01f, -1.03011178e-02f, -9.09513831e-02f, 1.10524856e-01f, 1.48203298e-01f, -7.33547881e-02f, 5.65198325e-02f, 8.26367885e-02f,
  -1.41117722e-01f, -1.14648260e-01f, -8.23100135e-02f, -1.67198136e-01f, -1.75788496e-02f, -6.28543794e-02f, 3.18555608e-02f, 2.15807874e-02f, 5.17494678e-02f, -1.58254377e-04f,
  -3.34381424e-02f, -1.47950370e-02f, -5.59898373e-03f, -4.11715619e-02f, 1.28989033e-02f, 1.47189170e-01f, -2.28525624e-01f, -6.96979612e-02f, 1.06342128e-02f, 1.01684399e-01f,
  3.85961294e-01f, 1.21647902e-02f, -9.10467356e-02f, 2.28493903e-02f, -3.01966816e-02f, 9.80791543e-03f, 2.36467913e-01f, 1.16766924e-02f, -8.66596997e-02f, -1.65363073e-01f,
  -1.38681367e-01f, 8.11117366e-02f, 9.22308043e-02f, 8.91440660e-02f, 1.87203344e-02f, -2.50518396e-02f, 1.08909428e-01f, -3.07587758e-02f, -2.83364087e-01f, -1.58138126e-01f,
  -1.20833889e-01f, 6.70131966e-02f, -1.88917026e-01f, -1.02725603e-01f, -3.74196917e-02f, 6.47899732e-02f, -1.20909996e-02f, -7.13089481e-02f, -1.07782066e-01f, 8.62997398e-02f,
  -1.76449791e-01f, 3.54569927e-02f, 1.99390844e-01f, 1.08224884e-01f, 1.97665170e-02f, -3.19761693e-01f, -6.77388534e-02f, -5.06853610e-02f, -1.17030531e-01f, 4.11213562e-02f,
  -1.19109660e-01f, -7.99941048e-02f, -1.90744251e-01f, -1.54463172e-01f, -5.10190055e-03f, 8.73258803e-04f, -1.06636673e-01f, 1.31080374e-01f, 2.53348406e-02f, -2.12365493e-01f,
  -1.94787577e-01f, 2.20292732e-01f, 5.53649887e-02f, 1.58806682e-01f, 1.64689630e-01f, 2.56591171e-01f, -6.53245524e-02f, 3.43539822e-03f, 4.94558476e-02f, 1.18199527e-01f,
  -1.46154046e+00f, -2.85578042e-01f, -4.65079844e-01f, -1.13916910e+00f, -2.26352677e-01f, 1.25027046e-01f, 2.27081731e-01f, 2.78913379e-01f, 8.62425938e-03f, -2.62710392e-01f,
  2.04945162e-01f, -1.10255629e-01f, -5.25303185e-01f, -2.79303044e-01f, -2.75588214e-01f, -4.60994542e-01f, -8.24997187e-01f, -8.63993108e-01f, -3.53088468e-01f, 2.74101555e-01f,
  1.37132118e-02f, -8.53537560e-01f, -9.00816262e-01f, -2.37646818e-01f, -1.65005207e-01f, -7.69389793e-02f, -5.64236403e-01f, -6.45584166e-01f, 5.83382286e-02f, -6.43016577e-01f,
  5.23028933e-02f, 4.28208947e-01f, 7.35089034e-02f, -1.61781117e-01f, -3.82413380e-02f, -2.61246786e-02f, 1.02406844e-01f, -2.63651043e-01f, 1.35897771e-01f, -8.33862349e-02f,
  -1.90384999e-01f, 2.23437086e-01f, -2.50435174e-01f, 9.48549882e-02f, -2.72398502e-01f, 1.20686814e-01f, -2.02687353e-01f, -2.04627499e-01f, -1.24717675e-01f, 3.94323111e-01f,
  1.03525594e-01f, -3.58478054e-02f, -5.17983660e-02f, 2.06965819e-01f, 2.59176880e-01f, 1.54832713e-02f, 2.88607299e-01f, 3.55854809e-01f, 2.72039592e-01f, 8.06412753e-03f,
  5.98128070e-04f, 8.92410502e-02f, 5.78199513e-02f, -1.82609305e-01f, -7.24392384e-02f, -5.51262079e-03f, -1.41286582e-01f, -1.34789884e-01f, 8.41359198e-02f, -1.83140025e-01f,
  1.31642267e-01f, 4.38168235e-02f, 4.16262075e-03f, 2.95105856e-02f, 4.29703714e-03f, -5.22353388e-02f, -3.15718725e-02f, -1.31186187e-01f, -4.96250391e-02f, -1.66991472e-01f,
  -7.85747543e-02f, 7.84211904e-02f, -1.81447610e-01f, 3.23749222e-02f, 6.69715479e-02f, 4.49055247e-03f, 1.34252906e-01f, 1.96387321e-01f, -6.47449642e-02f, 5.05894944e-02f,
  -3.23728353e-01f, 7.39416704e-02f, -9.34642032e-02f, 1.95510358e-01f, 4.91670817e-02f, 3.69922258e-02f, -1.26972452e-01f, 2.76089460e-02f, -1.02781147e-01f, 1.07357338e-01f,
  2.76225477e-01f, -1.12805104e-07f, -2.02543482e-01f, 1.24548502e-01f, -1.07101135e-01f, 6.42189085e-02f, -1.76464170e-01f, -3.05147916e-01f, 1.69049323e-01f, 3.08430605e-02f,
  -1.35870233e-01f, -1.66794091e-01f, -3.02641422e-01f, -1.85434505e-01f, 1.47886008e-01f, -2.09391415e-02f, -4.64100316e-02f, 6.74488693e-02f, 5.37512675e-02f, -4.94116575e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  7.79813588e-01f, 8.60739112e-01f, 6.07501388e-01f, 5.54484189e-01f, 1.16375935e+00f, 6.53533041e-01f, 7.51554966e-01f, 3.06027412e-01f, 2.90759087e-01f, 3.94069403e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -9.04382616e-02f, 3.06843389e-02f, 1.83053121e-01f, -1.22146584e-01f, 6.12347603e-01f, 2.04971477e-01f, -2.74317831e-01f, 3.32543701e-02f, 4.39930648e-01f, -1.51936784e-01f,
  -3.77931476e-01f, 1.36813924e-01f, 2.45068178e-01f, 2.23555133e-01f, -2.64946580e-01f, 2.34015714e-02f, 3.01891774e-01f, 2.78922349e-01f, -3.95055413e-02f, 1.02022596e-01f,
  -3.69915545e-01f, -5.09910239e-03f, -2.47569494e-02f, 1.40178755e-01f, 3.06448638e-01f, 5.24731934e-01f, -4.94677395e-01f, 5.16856134e-01f, -6.80790842e-02f, -6.20140731e-01f,
  4.78197075e-02f, 1.24684833e-01f, -1.56213671e-01f, -1.40933394e-01f, -1.32399760e-02f, -1.42321259e-01f, -1.49569988e-01f, 2.05910638e-01f, -2.83963382e-01f, 1.69125959e-01f,
  3.15610856e-01f, 3.18631798e-01f, -1.20383382e-01f, 1.71331957e-01f, 3.40358764e-01f, -2.66373724e-01f, -1.64077237e-01f, 9.29764882e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.52901345e-01f, 7.20197618e-01f, 6.04074955e-01f, 3.00750047e-01f, -9.08347130e-01f, -6.29401088e-01f, 5.14491200e-01f, 4.95829761e-01f, 3.02519858e-01f, -9.53804374e-01f,
  1.16123199e-01f, -3.35234404e-01f, -4.79381979e-01f, 8.08796942e-01f, -7.39200890e-01f, -2.95605939e-02f, -3.32713872e-01f, -3.67909163e-01f, 1.45231932e-01f, -3.90071422e-01f,
  -3.65607738e-01f, 7.07284510e-01f, 6.46144271e-01f, 7.39988744e-01f, 2.36536071e-01f, -2.92040348e-01f, -1.29674566e+00f, -6.05727196e-01f, 7.22552478e-01f, 6.34052396e-01f,
  -1.10890433e-01f, -8.34559083e-01f, 7.85683513e-01f, 1.37404835e+00f, 7.34207690e-01f, 6.18233263e-01f, 2.47486487e-01f, 7.75230885e-01f, -3.68510693e-01f, 1.80320024e-01f,
  6.69441700e-01f, -6.13261938e-01f, 1.25878021e-01f, 4.41986144e-01f, 7.44940937e-01f, 7.63419038e-03f, -6.27926230e-01f, -3.23988169e-01f, 1.78283855e-01f, 3.28874677e-01f,
  -2.33008146e-01f, 3.61764431e-01f, -1.52721620e+00f, 5.49903750e-01f, -2.39246245e-02f, 1.87043846e-01f, -7.40776956e-01f, 6.94049239e-01f, 2.26771962e-02f, 7.08781600e-01f,
  8.08863997e-01f, -4.11164582e-01f, -3.12994331e-01f, 7.04114318e-01f, 3.10615629e-01f, 4.15803432e-01f, 4.29516077e-01f, 1.47983506e-01f, 1.29549003e+00f, -5.73840797e-01f,
  -3.37300688e-01f, 1.20720768e+00f, -1.17803358e-01f, -2.20789924e-01f, 1.25599003e+00f, -6.57470286e-01f, 4.72296178e-01f, 6.34997368e-01f, 5.83240017e-02f, -1.12396038e+00f,
  8.86442978e-03f, 1.45424768e-01f, 1.68508381e-01f, 2.78420061e-01f, 2.14043796e-01f, -3.65163833e-01f, 1.04120553e+00f, -3.78370672e-01f, 7.04086959e-01f, 1.07967651e+00f,
  1.17576873e+00f, 1.46789360e+00f, 4.21471089e-01f, -1.11472651e-01f, 4.11523014e-01f, -5.18920839e-01f, 1.63897201e-01f, 9.03042257e-02f, 1.01791911e-01f, 1.45875551e-02f,
  -8.52812350e-01f, -4.15699124e-01f, 8.84435534e-01f, -3.55962992e-01f, -5.70994057e-03f, -7.38609254e-01f, 1.16754007e+00f, -3.99953246e-01f, 3.94669831e-01f, 1.76122800e-01f,
  -4.72651571e-01f, 4.25627261e-01f, -8.61238688e-02f, -8.34365096e-03f, 1.60125479e-01f, 1.98731929e-01f, -6.55656815e-01f, 2.96945035e-01f, -1.78155258e-01f, 1.14623499e+00f,
  8.31290931e-02f, -2.31613457e-01f, -2.92254537e-01f, -9.01232064e-01f, 8.20654035e-01f, -4.94482398e-01f, 2.84412622e-01f, 1.11681652e+00f, -3.17172498e-01f, -7.02284217e-01f,
  3.89442772e-01f, -5.01864731e-01f, 1.49129462e+00f, 4.74085629e-01f, 6.67543709e-01f, -8.43111947e-02f, 5.72460294e-01f, 2.79279560e-01f, 2.64052629e-01f, -2.98381746e-01f,
  4.42908928e-02f, 9.16272402e-01f, -3.69767509e-02f, 6.40530467e-01f, 1.13906935e-01f, 9.18572247e-01f, 8.97158802e-01f, 3.09721172e-01f, 1.12721956e+00f, 1.23612094e+00f,
  -2.24622339e-01f, 6.58633471e-01f, 1.09510756e+00f, 9.95191261e-02f, -2.67056450e-02f, 3.70282590e-01f, -1.62407517e-01f, -4.43371087e-01f, -4.57455009e-01f, 1.06138505e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  1.10378861e+00f, 2.25785345e-01f, 4.38527644e-01f, 6.63244128e-02f, 5.32775998e-01f, 1.58620387e-01f, 7.04790533e-01f, 2.34900117e-01f, 1.59058705e-01f, 5.25133312e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -4.55814749e-01f, 3.57465409e-02f, 4.99941230e-01f, 3.33266184e-02f, 3.58687431e-01f, -5.21321774e-01f, -1.54108536e+00f, -5.63522100e-01f, -7.51843691e-01f, -1.09733373e-01f,
  -1.38348997e-01f, -3.14896792e-01f, -8.71044517e-01f, 1.83663324e-01f, 6.20086908e-01f, 5.76114476e-01f, 4.35777575e-01f, 9.32868004e-01f, -3.88871226e-03f, -2.64630198e-01f,
  6.89863265e-01f, 5.46528995e-02f, -1.29312897e+00f, -3.84230018e-02f, -7.09577978e-01f, -1.34827495e+00f, -2.73981929e-01f, 6.27217233e-01f, 2.46917501e-01f, -5.95238030e-01f,
  5.08551657e-01f, -2.45972946e-01f, 4.90645587e-01f, 3.93181980e-01f, 8.19375932e-01f, -4.23066229e-01f, -3.32234293e-01f, -7.30741501e-01f, 3.86482120e-01f, -8.81479144e-01f,
  4.45707351e-01f, -1.05104959e+00f, 9.12925541e-01f, -2.93887943e-01f, -2.23748833e-01f, -2.77356893e-01f, -7.10591137e-01f, 3.24129730e-01f, 4.23430771e-01f, -9.52111781e-01f,
  -1.02333355e+00f, -2.17496872e-01f, 1.60889581e-01f, -7.85006285e-02f, -6.72606111e-01f, -3.34682941e-01f, -1.02871454e+00f, 1.10298407e+00f, -1.11267579e+00f, -1.19405198e+00f,
  -2.01782987e-01f, 6.15694761e-01f, -5.38523421e-02f, -2.71626472e-01f, 1.84334353e-01f, 5.36427617e-01f, -4.28805679e-01f, 1.01570380e+00f, 3.54823232e-01f, 2.46995911e-01f,
  7.52286494e-01f, -6.75758064e-01f, 6.75777853e-01f, -4.84143078e-01f, -3.48427773e-01f, -3.85867447e-01f, 1.98440194e-01f, 4.65885878e-01f, -1.38589799e-01f, 2.34337851e-01f,
  -2.33598292e-01f, -7.45084882e-01f, -6.14254773e-01f, 7.00485110e-01f, 2.84512714e-02f, 1.00247115e-01f, -7.06582665e-01f, -6.58696294e-02f, 1.24609077e+00f, -8.01327527e-01f,
  -4.60307539e-01f, 3.88740331e-01f, -9.76458728e-01f, -3.12212497e-01f, -1.11241072e-01f, 5.71460903e-01f, -2.93869138e-01f, -1.16285980e+00f, -9.04576421e-01f, 1.02896476e+00f,
  -2.46886015e-01f, -7.42136478e-01f, 5.14103055e-01f, 2.66280711e-01f, -1.18476272e+00f, -4.07074720e-01f, 5.21596730e-01f, -2.78033108e-01f, -4.55361843e-01f, -9.26112711e-01f,
  7.16785967e-01f, -1.52498269e+00f, -1.85301915e-01f, -5.89428991e-02f, -5.63989170e-02f, -1.45624250e-01f, -1.60707653e-01f, 1.80074871e-01f, -2.87697256e-01f, 5.34543455e-01f,
  -1.15873873e-01f, 3.86633635e-01f, 3.30424935e-01f, -3.43752801e-01f, -7.14043081e-01f, 5.22678316e-01f, -5.70975840e-01f, -1.22345018e+00f, -9.16576922e-01f, -6.51779115e-01f,
  6.14061415e-01f, -7.07509220e-01f, -1.30166441e-01f, 6.20137334e-01f, -2.05277428e-01f, -2.31458232e-01f, -9.44305062e-01f, 5.12553334e-01f, -5.13575673e-01f, 6.74825013e-01f,
  -5.13701916e-01f, -7.83520937e-01f, -8.96070242e-01f, -7.61370897e-01f, 8.82317126e-02f, 5.64459980e-01f, 9.64748323e-01f, 1.23276331e-01f, -9.60292280e-01f, 1.39339119e-01f,
  5.44022210e-02f, 6.28005803e-01f, 3.04183483e-01f, -1.34287143e+00f, 4.06877518e-01f, -7.67927587e-01f, -1.12356174e+00f, -3.17713976e-01f, 4.30855095e-01f, 5.18835723e-01f,
  4.65640686e-02f, 2.65865065e-02f, -5.20429790e-01f, -2.05135778e-01f, -9.82775211e-01f, 4.72061396e-01f, -1.21457243e+00f, -7.44577467e-01f, 7.61565149e-01f, 9.23828840e-01f,
  -4.81347263e-01f, -2.13240266e-01f, 9.78315115e-01f, -2.71937728e-01f, -7.33366132e-01f, -4.94700074e-01f, 7.83911720e-02f, 5.30747056e-01f, -1.20215394e-01f, -1.15004110e+00f,
  -6.46591306e-01f, -4.86926556e-01f, 7.82935321e-01f, 6.08357906e-01f, -3.80584866e-01f, -2.54635625e-02f, -1.46686959e+00f, -7.81105161e-02f, 8.21372867e-01f, -9.08367753e-01f,
  -9.22030136e-02f, -3.41710418e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  2.62989402e-01f, -2.43444785e-01f, 6.82269484e-02f, 2.07024440e-02f, -3.82533073e-02f, 4.03876766e-04f, 3.35225344e-01f, -5.83465576e-01f, 2.30441555e-01f, 1.33189321e-01f,
  -4.20006543e-01f, -1.67747997e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    