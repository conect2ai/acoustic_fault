/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.36932701e-02f, 1.36275298e-03f, 2.28603154e-01f, 1.90506846e-01f, 1.44955620e-01f, 2.76801258e-01f, 1.12098955e-01f, 1.07817858e-01f, 4.14422080e-02f, 3.24243382e-02f,
  1.18735759e-02f, -1.95055604e-02f, -1.02218315e-02f, -5.27923591e-02f, -1.50531098e-01f, 8.44141692e-02f, 1.53723210e-01f, 3.43666635e-02f, -8.04192945e-02f, -1.23846486e-01f,
  -1.32492125e-01f, -1.26773849e-01f, -1.61011159e-01f, -1.36000186e-01f, -6.96290284e-02f, -5.55508770e-02f, 6.32913709e-02f, -8.68662596e-02f, -1.48522392e-01f, -1.46904424e-01f,
  9.55486391e-03f, 1.78898945e-01f, 8.01888332e-02f, -4.09687273e-02f, 5.01701422e-02f, -6.80215284e-02f, -2.16832329e-02f, 9.23650190e-02f, 8.97448212e-02f, 8.04427043e-02f,
  8.92352238e-02f, -2.45444886e-02f, 3.36670503e-02f, -5.23565486e-02f, 9.74681824e-02f, 1.42583568e-02f, 6.76581413e-02f, 2.09253021e-02f, 9.50576290e-02f, 9.59864482e-02f,
  7.95600116e-02f, 3.62849422e-02f, 1.30562289e-02f, 1.27701595e-01f, 2.79767420e-02f, 8.69778693e-02f, -6.59937039e-02f, -6.28580600e-02f, -4.24576178e-02f, -1.93991005e-01f,
  1.25787362e-01f, 2.37885211e-02f, 6.65043592e-02f, -8.04323778e-02f, -1.36322200e-01f, -4.48114704e-03f, 6.45553544e-02f, -9.71423611e-02f, -7.07082674e-02f, 2.40668692e-02f,
  -7.94727206e-02f, 4.95555587e-02f, -2.03902870e-02f, -1.30301312e-01f, -3.49635421e-03f, 1.12391943e-02f, -1.56622902e-01f, -1.95255339e-01f, 1.30625945e-02f, 5.98512031e-03f,
  3.26633565e-02f, -1.15431368e-01f, -8.05115178e-02f, -6.38038367e-02f, -1.04300439e-01f, -5.34156486e-02f, 5.60836541e-03f, 8.38172995e-03f, -8.23049843e-02f, -1.30284755e-02f,
  -4.93074115e-03f, 2.26051301e-01f, -1.10230496e-04f, 6.18018508e-02f, 1.68622490e-02f, 1.10377029e-01f, 7.98977464e-02f, 2.95490352e-03f, 1.30451649e-01f, -3.37201208e-02f,
  2.88777631e-02f, 6.35130778e-02f, 1.00854814e-01f, 7.39658698e-02f, 1.83495674e-02f, 1.78910226e-01f, 8.53438750e-02f, 7.81923085e-02f, 1.60536368e-03f, -3.89702730e-02f,
  2.63602063e-02f, 2.06602514e-02f, -2.92159747e-02f, 3.53752673e-02f, -6.35789856e-02f, -5.82802184e-02f, -4.78915498e-02f, -9.49768052e-02f, 1.34868678e-02f, -1.96122825e-01f,
  3.30914557e-01f, 2.51861699e-02f, 2.23491251e-01f, 1.75841555e-01f, -1.08031377e-01f, 5.06506748e-02f, -5.54692447e-02f, 6.45570084e-02f, 1.39281660e-01f, 8.01518261e-02f,
  1.89120956e-02f, -1.16995592e-02f, -1.04110301e-01f, -1.53740421e-01f, -3.03818975e-02f, 6.43038377e-02f, -8.79057944e-02f, 8.80156755e-02f, -3.66352275e-02f, -3.97095531e-02f,
  -2.04407573e-01f, -1.81403607e-02f, 1.17325284e-01f, 2.54735313e-02f, -1.45481139e-01f, -1.02668591e-01f, -4.84843776e-02f, 2.07055788e-02f, -1.45653367e-01f, -1.35558337e-01f,
  -6.12185635e-02f, 2.27834135e-01f, 7.37494677e-02f, -5.19094206e-02f, 1.24166217e-02f, 9.81976613e-02f, -1.49879120e-02f, 9.75288227e-02f, 1.07166596e-01f, 3.53635773e-02f,
  2.26367656e-02f, -1.43149321e-03f, -1.88761111e-02f, -2.36940361e-03f, 1.06200099e-01f, 5.63860033e-03f, 1.00171328e-01f, 1.31722406e-01f, 5.63429445e-02f, -6.41709641e-02f,
  -1.24736473e-01f, -1.37693705e-02f, 5.56472316e-02f, 1.27621561e-01f, -2.02804425e-04f, 2.54178792e-02f, -1.06575703e-02f, 6.99888840e-02f, 1.11897878e-01f, 4.16021980e-02f,
  -3.92063037e-02f, -6.14929050e-02f, 4.12147380e-02f, -2.27167550e-02f, 2.70019285e-03f, -1.12580275e-02f, -1.22184724e-01f, -1.11055538e-01f, -5.92000000e-02f, -1.01448916e-01f,
  -8.94776136e-02f, 3.97001989e-02f, -4.85460879e-03f, -3.47387306e-02f, -7.53900558e-02f, 5.41234426e-02f, -1.31646529e-01f, -6.86441436e-02f, -9.49116871e-02f, -7.21037239e-02f,
  -9.20786411e-02f, -6.51480863e-03f, 2.12768726e-02f, -1.57319047e-02f, 5.06014936e-02f, 3.20642963e-02f, -4.49932292e-02f, -1.21118128e-01f, -4.78412583e-02f, -9.94567126e-02f,
  1.80132240e-01f, 1.63467124e-01f, -7.32952654e-02f, -7.61924088e-02f, -1.76603831e-02f, -4.72104698e-02f, 8.25554803e-02f, -4.58004698e-03f, 7.13144094e-02f, -8.41552299e-03f,
  -9.75405946e-02f, 2.72340216e-02f, 4.79237288e-02f, -7.40968343e-03f, -9.90339741e-03f, 5.99864945e-02f, 6.47993535e-02f, 4.25894037e-02f, 3.55997565e-03f, 2.42691990e-02f,
  -3.97366891e-03f, -8.10043886e-03f, 1.22917473e-01f, -1.66316498e-02f, 2.84817312e-02f, 4.53855842e-02f, -3.46534289e-02f, 1.27108824e-02f, 1.26609027e-01f, -1.34137943e-02f,
  -2.63468266e-01f, -3.72881174e-01f, -1.18649185e-01f, -5.34067675e-02f, -6.81132674e-02f, -4.24857736e-02f, -1.88911378e-01f, -1.46164313e-01f, 1.05493953e-02f, -1.47338971e-01f,
  -1.63038120e-01f, 9.80598256e-02f, 1.93119854e-01f, 8.08508545e-02f, -6.34401059e-03f, -2.09043667e-01f, -1.45070339e-02f, 1.57346234e-01f, 2.77854294e-01f, 1.21274203e-01f,
  3.85365300e-02f, 1.00934103e-01f, 4.58141640e-02f, -2.04819422e-02f, -6.34626448e-02f, 1.09831139e-03f, -9.41914618e-02f, -9.69402120e-02f, -4.61189784e-02f, -3.10428571e-02f,
  -7.33854249e-02f, -2.77308583e-01f, -1.02265403e-02f, 4.87990826e-02f, -6.48305491e-02f, -8.36014748e-02f, -1.02723025e-01f, -3.14067975e-02f, -1.25297099e-01f, -1.97472125e-01f,
  3.65916640e-03f, 7.30327796e-03f, 1.35695906e-02f, -1.36721238e-01f, -1.17464438e-01f, -1.00559637e-01f, -1.36915252e-01f, -3.21784578e-02f, -1.34144396e-01f, -2.04119846e-01f,
  -1.06567159e-01f, -1.51645228e-01f, -9.41035002e-02f, -5.22514209e-02f, -1.43843785e-01f, -5.47896400e-02f, -1.41545564e-01f, -1.11672014e-01f, -2.20757961e-01f, -2.27270097e-01f,
  -9.99715552e-03f, 2.64525004e-02f, 7.92022347e-02f, -1.94112882e-02f, 1.02672316e-01f, -2.80209281e-03f, 2.26750690e-02f, 6.24699295e-02f, 1.27922148e-01f, 5.62323146e-02f,
  -1.60384048e-02f, -2.34528314e-02f, 7.38807172e-02f, -1.81938277e-03f, 1.07404284e-01f, -6.78190291e-02f, -4.03352594e-03f, 1.77143142e-02f, -4.54932787e-02f, 3.55900861e-02f,
  8.13739970e-02f, -1.27455406e-02f, 8.58693346e-02f, 6.37792191e-03f, 2.03303583e-02f, -8.76350403e-02f, -1.17114261e-02f, 5.64496629e-02f, -1.62592642e-02f, -9.10322145e-02f,
  -9.56435576e-02f, 1.36774257e-02f, -5.91456294e-02f, -7.55824074e-02f, -1.47330076e-01f, -1.20552704e-01f, -1.30186424e-01f, -5.94271086e-02f, -1.30402416e-01f, -1.47934020e-01f,
  2.53627868e-03f, -1.06815465e-01f, -1.96971465e-02f, -7.66943172e-02f, -9.78117287e-02f, -1.29071414e-01f, -8.50928724e-02f, -3.91999222e-02f, -6.94877803e-02f, -2.14913890e-01f,
  -1.54930845e-01f, -1.12688571e-01f, -1.92028154e-02f, -1.91818457e-02f, -3.39911580e-02f, -7.11746663e-02f, -4.86370623e-02f, -8.90168920e-02f, -4.28876318e-02f, -2.92983115e-01f,
  4.59139012e-02f, -1.19007289e-01f, 9.62124094e-02f, 1.53353009e-02f, 1.46013588e-01f, 2.07972769e-02f, 7.13785887e-02f, -5.56530394e-02f, -9.94865522e-02f, -9.94516090e-02f,
  -1.74341276e-01f, -1.62971124e-01f, -8.83083865e-02f, -1.90865517e-01f, -5.63777909e-02f, 1.49743883e-02f, 1.80580512e-01f, 2.21501421e-02f, 9.30801928e-02f, -1.50928656e-02f,
  3.39329503e-02f, -8.31942540e-03f, 1.32026568e-01f, 2.30525620e-02f, 1.61400735e-02f, 1.54343620e-02f, 8.13928526e-03f, 1.41573131e-01f, -6.87591406e-03f, -5.15486374e-02f,
  -1.94067255e-01f, -6.30365461e-02f, -7.18482807e-02f, -1.11777633e-01f, 1.44638196e-02f, -5.48123531e-02f, -1.62265196e-01f, -3.21725868e-02f, -1.43835053e-01f, -7.38824755e-02f,
  -3.62401344e-02f, -4.71672378e-02f, -4.57116663e-02f, -1.24189027e-01f, 1.35741150e-02f, -1.06252819e-01f, -1.24310739e-01f, -8.45595971e-02f, -5.34632802e-03f, -6.90194145e-02f,
  -1.16136454e-01f, -6.25714846e-03f, -1.01599030e-01f, -1.50684223e-01f, -1.14833936e-01f, -7.20990971e-02f, -2.12819204e-02f, -1.11733608e-01f, -6.48254016e-03f, -1.67095587e-01f,
  1.84463874e-01f, 2.98090167e-02f, -6.55614436e-02f, -7.58667588e-02f, -6.12894585e-03f, -9.39133577e-03f, -4.27983962e-02f, 9.17799920e-02f, 7.09354207e-02f, -8.40612724e-02f,
  8.50467291e-03f, -1.69766247e-02f, -2.58540884e-02f, 7.25877611e-03f, -7.98361897e-02f, -5.38474880e-02f, 5.39010093e-02f, -3.89698036e-02f, -1.23605296e-01f, -1.16979163e-02f,
  -9.71587077e-02f, -2.67438237e-02f, 2.16453988e-02f, 6.43238202e-02f, -9.53771472e-02f, 8.94689262e-02f, -3.02008446e-02f, -7.08189681e-02f, -2.66211219e-02f, 6.72087297e-02f,
  -1.74833626e-01f, -5.10151610e-02f, -1.67942181e-01f, -1.43284187e-01f, 1.85329486e-02f, -1.28908232e-01f, -1.61543593e-01f, -9.02777836e-02f, -1.58825800e-01f, -8.31582323e-02f,
  -1.27300963e-01f, -1.54491574e-01f, -4.88613062e-02f, -5.60102835e-02f, -1.42702579e-01f, -1.50617376e-01f, -1.18298493e-01f, -5.13776951e-02f, -2.42720786e-02f, -2.77236998e-02f,
  -1.32227123e-01f, -2.56162253e-03f, -1.79670885e-01f, -8.16588178e-02f, -7.26781264e-02f, -7.46081695e-02f, -7.14999139e-02f, -1.17621370e-01f, -1.32089570e-01f, -2.19166666e-01f,
  4.36187446e-01f, -2.23133191e-01f, -2.20565587e-01f, 1.39058650e-01f, 2.45006874e-01f, 9.54837129e-02f, 5.62423430e-02f, 8.58070627e-02f, 4.87120412e-02f, -4.34255786e-02f,
  -1.26082778e-01f, -8.07549879e-02f, -1.41358584e-01f, -2.16651917e-01f, -1.50146365e-01f, -1.57693386e-01f, -1.33543804e-01f, 4.27074581e-02f, 1.08847044e-01f, 1.34048671e-01f,
  7.91542754e-02f, 1.49983779e-01f, 8.29534531e-02f, -1.42297968e-02f, 2.79229265e-02f, 4.27062623e-02f, -1.86106920e-01f, 4.65834774e-02f, -1.78689629e-01f, -1.09415948e-01f,
  -2.65961528e-01f, 5.17913438e-02f, 6.22103065e-02f, 5.69373891e-02f, -1.06702391e-02f, -1.25961499e-02f, -4.10904586e-02f, -1.13995217e-01f, 6.33230507e-02f, -9.64977741e-02f,
  -1.83999408e-02f, 5.33956662e-03f, 4.84270304e-02f, 5.53195253e-02f, 4.18547802e-02f, 7.97556415e-02f, -2.25755665e-02f, -7.34068677e-02f, -1.08055510e-01f, -9.82744023e-02f,
  6.12246208e-02f, 8.59561488e-02f, 7.06813782e-02f, -1.26321465e-01f, -6.50002062e-02f, 7.48057440e-02f, -1.86254829e-02f, -7.89999589e-02f, -1.11369289e-01f, 6.09443784e-02f,
  3.55823338e-02f, -6.39837086e-02f, -3.09909247e-02f, -2.10155640e-02f, -4.51150090e-02f, -2.08903365e-02f, 1.85284987e-02f, -1.17239701e-02f, 6.51918864e-03f, -4.40205596e-02f,
  7.59925693e-03f, -2.06050128e-02f, 3.77482325e-02f, -6.26532063e-02f, -1.41110212e-01f, 2.81440634e-02f, -7.22721070e-02f, -8.52100626e-02f, -1.43192643e-02f, -6.83806092e-02f,
  -1.18471272e-02f, -1.67360529e-02f, -1.02040373e-01f, -3.93301733e-02f, -3.69220078e-02f, -2.68458184e-02f, -1.05743922e-01f, -3.39282416e-02f, -6.59763291e-02f, 2.85391361e-02f,
  -1.55366510e-01f, -4.74169180e-02f, -8.65010917e-02f, 8.77656043e-02f, 8.14059004e-02f, -7.61285052e-02f, -2.79767606e-02f, -8.60435814e-02f, -5.84828481e-02f, -9.20024291e-02f,
  -1.04685329e-01f, -8.10390525e-03f, -9.53339562e-02f, -8.30323249e-02f, 3.87014076e-02f, -1.45756267e-02f, -4.78905998e-02f, 2.23530438e-02f, -5.52579798e-02f, -5.24252541e-02f,
  2.56126355e-02f, -5.41508533e-02f, -3.36629106e-03f, -1.37710676e-01f, -5.60527407e-02f, 6.63239732e-02f, -1.42626017e-01f, -4.67385352e-02f, -1.10010013e-01f, -1.22099660e-01f,
  2.39975929e-01f, 1.64931431e-01f, -4.43317965e-02f, 1.35391161e-01f, -2.29816079e-01f, -3.23366523e-01f, -7.56895542e-02f, -7.66203105e-02f, -1.12679213e-01f, 4.14603762e-02f,
  -4.27036919e-02f, -1.64864287e-01f, -6.10732026e-02f, -6.23229221e-02f, 1.12153469e-02f, 1.57565221e-01f, 2.70749927e-02f, 8.67493078e-02f, -1.35503724e-01f, -1.84941307e-01f,
  5.05427830e-02f, 5.39590530e-02f, 2.02453919e-02f, 1.17422573e-01f, 1.20534882e-01f, 5.65574458e-03f, 7.65497237e-02f, -5.31202406e-02f, 6.10333942e-02f, 9.18253958e-02f,
  -1.79377601e-01f, -1.59214754e-02f, -5.90258315e-02f, -9.18771923e-02f, -2.37210300e-02f, -1.03427526e-02f, -1.16944551e-01f, 4.80644451e-03f, -8.66176784e-02f, -4.02254462e-02f,
  -1.68758985e-02f, -1.09801739e-01f, 8.43618531e-04f, 3.27449366e-02f, -6.53182268e-02f, 2.26373188e-02f, 1.52494851e-02f, 3.39287743e-02f, -1.47095015e-02f, -1.03952149e-02f,
  4.14402150e-02f, -1.46359857e-03f, -8.35086405e-02f, -1.24432959e-01f, -3.19959410e-02f, -6.98632002e-02f, -1.07155398e-01f, 1.98383406e-02f, -2.14949604e-02f, 6.55250400e-02f,
  3.14462110e-02f, 7.84454774e-03f, -1.22138916e-03f, 8.25102255e-02f, 2.68189400e-03f, 8.68699327e-02f, -5.16705075e-03f, 5.07707708e-02f, 4.57371511e-02f, 1.05799124e-01f,
  1.92866419e-02f, 7.57627040e-02f, 5.56602031e-02f, 1.19698038e-02f, -1.05224326e-02f, 1.55588463e-02f, -5.10312570e-03f, 6.49305582e-02f, 2.31033061e-02f, 2.86757462e-02f,
  9.23378319e-02f, 8.09308887e-03f, 3.29959616e-02f, 1.24902472e-01f, -4.85139992e-03f, 1.17831841e-01f, 8.94650444e-02f, -2.28498224e-02f, 6.62323013e-02f, -5.14969714e-02f,
  -2.25117832e-01f, -2.34785706e-01f, -1.07401036e-01f, -6.16583861e-02f, -8.03376511e-02f, -1.19400591e-01f, -1.58953890e-02f, -6.51009977e-02f, -4.43986543e-02f, -8.80972594e-02f,
  -3.99968103e-02f, -5.30883297e-02f, -2.16062702e-02f, 1.18138110e-02f, -1.10855289e-01f, -6.67089075e-02f, -2.49488130e-02f, -7.48508871e-02f, -6.46670759e-02f, -1.01532033e-02f,
  4.60382929e-04f, -8.97917375e-02f, -1.65897369e-01f, -1.93658456e-01f, -1.45062894e-01f, -8.68444964e-02f, -1.10071361e-01f, -2.04868749e-01f, -1.40380248e-01f, -4.78399210e-02f,
  1.64185867e-01f, -1.83538675e-01f, 4.04534876e-01f, 3.06775540e-01f, 8.07200447e-02f, -8.06450285e-03f, 6.80166334e-02f, 1.56048566e-01f, 1.83876425e-01f, -1.07498094e-03f,
  -2.85145491e-01f, -1.59211233e-01f, 4.05618660e-02f, 4.29829136e-02f, 7.82797635e-02f, 1.54452592e-01f, 2.10227802e-01f, 2.71074474e-01f, 7.21931905e-02f, -1.01141453e-01f,
  -8.43984857e-02f, 1.54359445e-01f, 1.22624539e-01f, 3.57281007e-02f, 9.98307988e-02f, -7.47607276e-02f, 2.06546754e-01f, 1.36471689e-01f, -6.93593845e-02f, 1.44080278e-02f,
  -9.46135968e-02f, -8.27924237e-02f, -1.89589411e-02f, -3.19793746e-02f, 4.54936922e-02f, -1.64478179e-02f, -1.08053789e-01f, 1.03821032e-01f, -9.80711803e-02f, -4.35602255e-02f,
  -7.17063472e-02f, -3.78001928e-02f, -5.65231815e-02f, -8.80153477e-02f, 1.08037228e-02f, -3.88965420e-02f, 1.22111373e-01f, 1.27405688e-01f, -4.27676439e-02f, -1.37124270e-01f,
  -1.68945268e-01f, -1.19511820e-02f, 5.26186377e-02f, 3.69202681e-02f, -5.53064831e-02f, -9.20885131e-02f, -1.37601510e-01f, 3.30335721e-02f, -3.26095670e-02f, -8.26131739e-03f,
  -9.47670713e-02f, -1.29220383e-02f, -1.09222651e-01f, -3.52219045e-02f, -5.46110272e-02f, -1.32372469e-01f, -1.46737890e-02f, -1.35891259e-01f, -8.66788030e-02f, -1.10986002e-01f,
  -2.56745014e-02f, 2.88358200e-02f, -6.37548789e-02f, 4.99593057e-02f, 8.27573054e-03f, -3.75141464e-02f, -8.27983841e-02f, 7.19305500e-03f, -1.98224038e-02f, 4.77680564e-03f,
  -3.87820192e-02f, -2.48361304e-02f, -6.50066659e-02f, 9.75102000e-03f, -1.62582323e-01f, -3.63697335e-02f, -5.04459888e-02f, -1.75759122e-01f, -3.68514024e-02f, -1.17780663e-01f,
  -9.20893773e-02f, 1.23179346e-01f, -1.17542624e-01f, -2.32440587e-02f, 6.80420399e-02f, -8.59126151e-02f, -1.00783538e-02f, 5.93716167e-02f, 4.70219664e-02f, -5.38966469e-02f,
  -1.87882837e-02f, -7.75508359e-02f, -2.90551428e-02f, -2.18947455e-02f, 1.30715519e-02f, 4.50445637e-02f, -8.75907317e-02f, 2.78593842e-02f, 8.37217867e-02f, -3.87791060e-02f,
  4.57906350e-02f, -7.19596297e-02f, -6.54737949e-02f, 5.26937321e-02f, 7.30874613e-02f, 3.28259207e-02f, -8.65949094e-02f, -4.74130511e-02f, 2.48201052e-03f, 7.04668984e-02f,
  -1.60218850e-01f, 2.96611432e-02f, 1.85892209e-01f, 4.35156412e-02f, 8.12627673e-02f, 2.51035213e-01f, 2.25808606e-01f, 3.37341689e-02f, 5.14692403e-02f, 1.41645983e-01f,
  -6.03660801e-03f, -6.54254705e-02f, -5.99410795e-02f, 4.68853526e-02f, 1.98467776e-01f, 1.82065383e-01f, 3.07760537e-01f, 2.17208937e-01f, 1.26707688e-01f, -3.55835110e-02f,
  2.43635997e-02f, 7.14101046e-02f, 9.44584161e-02f, -7.28092492e-02f, 3.52428923e-03f, -7.67638758e-02f, 1.19030392e-02f, 8.90489370e-02f, 8.56943503e-02f, 8.02258626e-02f,
  -2.27592271e-02f, -1.11939557e-01f, -1.78325877e-01f, -2.16965511e-01f, 1.04079982e-02f, -1.85711533e-01f, -1.41335949e-01f, -1.13370910e-01f, -1.90896243e-01f, -1.32020965e-01f,
  -9.28848162e-02f, -8.55007619e-02f, -1.33677214e-01f, -1.28255293e-01f, -7.47439936e-02f, -8.86351690e-02f, -8.82979203e-03f, -6.98927417e-02f, 3.65098864e-02f, 1.85232628e-02f,
  2.80513670e-02f, -1.38148472e-01f, -1.03777088e-01f, -9.97798443e-02f, -1.17670959e-02f, -8.12136382e-02f, -1.62656963e-01f, -8.02566111e-02f, -1.37001267e-02f, -1.80221558e-01f,
  1.01911724e-01f, 2.24208143e-02f, -6.60783611e-04f, 1.69827342e-02f, -5.30836098e-02f, 5.31676672e-02f, -3.23749818e-02f, 9.07067060e-02f, -1.46034099e-02f, 3.99166457e-02f,
  4.69974801e-02f, 5.10589555e-02f, 9.80351940e-02f, -3.55442464e-02f, -1.48426648e-02f, 2.37836149e-02f, 6.02009669e-02f, 4.94075343e-02f, 3.92444283e-02f, 5.64469583e-02f,
  6.62846491e-03f, -4.98880483e-02f, -8.68106633e-02f, -8.87731672e-04f, 9.75371152e-02f, 3.49331275e-02f, -5.76277822e-02f, 5.85444085e-02f, 7.16633350e-02f, -2.81104650e-02f,
  -3.30892384e-01f, -2.84096133e-02f, -2.56988943e-01f, -2.34180644e-01f, -1.48360372e-01f, -1.86780751e-01f, -1.02680892e-01f, -1.49291962e-01f, -1.65910095e-01f, -6.94171116e-02f,
  -1.80937350e-01f, -1.90187857e-01f, -8.05529580e-02f, -3.32233272e-02f, -1.39806435e-01f, -1.21573932e-01f, -9.83703360e-02f, -1.04727492e-01f, -9.89577398e-02f, -1.80450585e-02f,
  -1.00180738e-01f, -9.68783870e-02f, -1.13373540e-01f, -2.04929799e-01f, -1.10373363e-01f, -1.29996181e-01f, -8.39077607e-02f, -2.34902382e-01f, -1.93917111e-01f, -1.65861741e-01f,
  -3.55957925e-01f, -2.25913778e-01f, -3.16087335e-01f, -2.16500148e-01f, 2.80703977e-02f, -7.84363449e-02f, -3.31097990e-01f, -8.63169059e-02f, -1.09925285e-01f, -1.19767971e-01f,
  3.64394076e-02f, 2.84042388e-01f, 1.29977211e-01f, 6.69391155e-02f, -8.65614191e-02f, -2.73229152e-01f, -2.78643578e-01f, -2.17598155e-02f, 1.30427569e-01f, 1.43394932e-01f,
  -1.31914848e-02f, -1.46610104e-02f, -8.12991112e-02f, 4.90134768e-02f, -9.44902748e-02f, 1.32758439e-01f, -2.18317077e-01f, -1.68098975e-02f, 5.01173995e-02f, -1.37781158e-01f,
  -1.10197090e-01f, -2.32653841e-02f, 1.01701386e-01f, 1.33376449e-01f, 1.71084702e-02f, -3.52200270e-02f, -1.95070598e-02f, -2.09197029e-03f, 5.38374186e-02f, 4.87977918e-03f,
  1.09696619e-01f, 1.09664209e-01f, -4.39862460e-02f, 3.01048812e-02f, -9.77712721e-02f, -2.68756673e-02f, -4.33596596e-02f, -1.01420835e-01f, 8.85935575e-02f, 4.13017124e-02f,
  1.09777920e-01f, -8.93035438e-03f, -2.41823960e-02f, 1.41681992e-02f, 2.13602129e-02f, 1.40950695e-01f, -9.61413309e-02f, 9.13429633e-02f, -4.31621671e-02f, -2.04150140e-01f,
  6.89552873e-02f, 1.64928436e-02f, -1.16729783e-02f, 5.56175373e-02f, 3.45454179e-03f, -8.15921128e-02f, -6.16197325e-02f, -4.77921441e-02f, -1.11409435e-02f, -1.35480110e-02f,
  -3.57071939e-03f, 5.01473285e-02f, -4.86240797e-02f, -3.14698219e-02f, 2.04028599e-02f, -6.24793209e-02f, -4.17710654e-02f, 3.96220721e-02f, 8.74125659e-02f, -3.73251215e-02f,
  6.61923215e-02f, -1.98502019e-02f, 5.96822500e-02f, 7.34368861e-02f, 7.93972984e-02f, -1.98030677e-02f, -3.57753597e-02f, 8.10180455e-02f, 5.11550950e-03f, -3.41051593e-02f,
  -1.83124140e-01f, 1.94541097e-01f, -8.60401466e-02f, 7.85673410e-02f, 4.53618355e-02f, 3.51045455e-04f, 5.62365316e-02f, 2.32084226e-02f, 5.30588999e-03f, -1.75235905e-02f,
  6.20670952e-02f, 1.82387419e-02f, -1.09541481e-02f, 7.71958679e-02f, 1.61527619e-02f, 1.00484826e-02f, 9.01838858e-03f, -3.32248136e-02f, 5.04110679e-02f, 1.15510710e-02f,
  5.28837368e-02f, -8.75895545e-02f, -1.51039600e-01f, -7.33267516e-02f, -6.22010715e-02f, 1.30874221e-03f, 7.31073320e-03f, 1.21632731e-02f, -8.03537890e-02f, -1.30562365e-01f,
  -3.37080389e-01f, 7.43089244e-02f, -5.23694344e-02f, 3.57284322e-02f, 1.44381776e-01f, 1.13401331e-01f, 6.19699955e-02f, 2.69917790e-02f, -1.67944264e-02f, 1.34518556e-02f,
  1.09138049e-01f, 1.04539255e-02f, -2.71414500e-02f, -6.29738495e-02f, -1.78070515e-01f, -7.23475590e-02f, -7.15461969e-02f, -2.01197430e-01f, -9.26708579e-02f, -3.65985297e-02f,
  -3.84413674e-02f, 3.41405012e-02f, -1.47310033e-01f, -1.33763216e-02f, 1.10074721e-01f, 6.96773753e-02f, 1.00717217e-01f, -1.72394607e-02f, 5.07314876e-02f, 8.07034150e-02f,
  8.67655128e-02f, 8.22406262e-02f, -4.14701737e-02f, -6.18528463e-02f, 1.11230098e-01f, -5.69677427e-02f, 6.64457753e-02f, -7.74984136e-02f, -8.00144076e-02f, -2.91798767e-02f,
  5.25460765e-02f, -5.35792038e-02f, 3.95977171e-03f, -3.75591516e-02f, -8.17147866e-02f, -9.94460285e-02f, -1.15552917e-01f, -1.16049632e-01f, -1.14086926e-01f, 1.14145756e-01f,
  7.38576651e-02f, -3.28931375e-03f, -1.27718411e-02f, -2.42581386e-02f, 1.54911885e-02f, -1.02282122e-01f, 4.31327112e-02f, -8.04660022e-02f, -6.28177226e-02f, 3.19085494e-02f,
  -1.12312697e-01f, -7.80283511e-02f, -2.28948276e-02f, -8.46528038e-02f, -1.00541845e-01f, 1.69542730e-02f, 5.10641262e-02f, -9.58863720e-02f, 5.50576262e-02f, -1.33729622e-01f,
  4.21419851e-02f, 3.90833337e-03f, 8.41018483e-02f, 7.41781592e-02f, 4.44871262e-02f, -3.81023102e-02f, 2.86827870e-02f, 7.88347945e-02f, 9.19730291e-02f, -3.12964059e-02f,
  4.55771340e-03f, 4.64187935e-02f, -3.68150473e-02f, -3.53640541e-02f, 7.96172619e-02f, 4.01213728e-02f, -1.17104361e-03f, 2.23010983e-02f, -4.03092382e-03f, -5.62890843e-02f,
  -1.84600890e-01f, -2.08760072e-02f, 1.46648493e-02f, -9.40809473e-02f, -5.76634854e-02f, 5.54404221e-02f, 6.07769340e-02f, 1.01824682e-02f, 7.40233436e-02f, 5.67629449e-02f,
  4.39754240e-02f, -6.22679964e-02f, 7.51128048e-02f, -5.68804555e-02f, -3.95737812e-02f, -1.39134321e-02f, -2.72005564e-03f, -6.20459579e-02f, 3.31723765e-02f, -1.63596980e-02f,
  -5.73703162e-02f, -1.29373878e-01f, -8.39597285e-02f, -1.59566905e-02f, 1.32437885e-01f, -6.41675219e-02f, -5.12703434e-02f, 4.31691334e-02f, -1.46076828e-01f, -1.50465354e-01f,
  4.48687077e-01f, -2.99411684e-01f, -1.83417480e-02f, 1.20397292e-01f, 2.24077981e-02f, 9.24131274e-03f, 3.03537976e-02f, 6.72222897e-02f, 1.11524999e-01f, -2.89439596e-02f,
  -2.28692014e-02f, 1.71680138e-01f, 1.83718309e-01f, 1.17302395e-01f, 2.71126360e-01f, -1.47723421e-01f, -1.17395915e-01f, 1.25230283e-01f, 3.51843745e-01f, 8.24443623e-02f,
  9.16263759e-02f, 4.90573496e-02f, 1.54234886e-01f, -7.01626018e-03f, -2.07721382e-01f, 1.64125357e-02f, 1.39054609e-03f, -1.23881288e-01f, -7.72423819e-02f, -2.83587754e-01f,
  3.86094078e-02f, 5.71410358e-03f, 2.57416993e-01f, 2.03345399e-02f, 5.05690388e-02f, 2.30264887e-02f, 2.02939026e-02f, 3.98758724e-02f, 4.35539074e-02f, 8.81899893e-02f,
  -5.77033386e-02f, 6.87315911e-02f, 7.15761483e-02f, -5.45053594e-02f, 2.69460473e-02f, 4.12398800e-02f, 1.98159199e-02f, 7.23602325e-02f, -8.06009863e-03f, 6.40172465e-03f,
  -6.58362955e-02f, -1.57034621e-02f, 9.21181217e-02f, 9.18246359e-02f, 1.85475834e-02f, 5.69564700e-02f, 7.26852566e-02f, -4.26425375e-02f, 8.08955953e-02f, 2.14664321e-02f,
  -1.11343404e-02f, -6.19096309e-02f, -1.16955481e-01f, -2.58351397e-02f, -5.87516017e-02f, -6.29362315e-02f, -1.11161157e-01f, -3.69794257e-02f, 7.78640788e-06f, -4.94729951e-02f,
  -9.61205438e-02f, -3.71698178e-02f, 6.89880643e-03f, -6.34257644e-02f, -7.39091486e-02f, -8.94166157e-02f, 1.14525855e-03f, -7.68363625e-02f, -4.93957847e-02f, -7.23040923e-02f,
  -1.43284157e-01f, -1.17799137e-02f, -5.82417324e-02f, -3.07403393e-02f, -7.41850510e-02f, -2.67936774e-02f, -1.11090213e-01f, -6.82693124e-02f, -2.58016177e-02f, -4.88815457e-02f,
  3.15710694e-01f, 1.55722201e-01f, 1.54373527e-01f, 1.44599885e-01f, 1.08759233e-03f, 9.20314565e-02f, 7.99891651e-02f, 8.95458162e-02f, 1.28613651e-01f, 6.33393377e-02f,
  1.44181341e-01f, 1.67996064e-01f, 5.54911532e-02f, 3.59456353e-02f, 9.38889533e-02f, 1.31451175e-01f, 3.32797808e-03f, 1.51705503e-01f, 5.92693537e-02f, -3.25510539e-02f,
  4.24576811e-02f, 7.73891658e-02f, 1.91099524e-01f, 9.51533318e-02f, 2.05212921e-01f, 2.46178299e-01f, 1.12859324e-01f, 1.42242894e-01f, 2.63307780e-01f, 1.51600227e-01f,
  3.27744484e-01f, 3.02826315e-01f, 2.26522133e-01f, 1.89524591e-01f, 1.30135790e-01f, 2.70130426e-01f, 3.92044336e-01f, 2.76310444e-01f, 1.14589520e-01f, 1.09555177e-01f,
  -1.08580934e-02f, -4.81817760e-02f, -5.62696718e-02f, 1.11099146e-02f, 2.27030531e-01f, 2.36363873e-01f, 3.12346876e-01f, 2.39294350e-01f, 8.13091323e-02f, -3.59326154e-02f,
  -5.12679741e-02f, 9.31267515e-02f, 4.69860882e-02f, 1.32472053e-01f, -4.90556145e-03f, -2.36193556e-02f, 1.46358699e-01f, 1.52797148e-01f, 1.70749158e-01f, 3.09746303e-02f,
  -9.37236547e-02f, 1.41926751e-01f, 4.25841846e-02f, -8.66649859e-03f, -1.15090031e-02f, 3.57422978e-04f, 1.12936027e-01f, 3.59710446e-03f, 1.02891386e-01f, 5.86309768e-02f,
  9.18867514e-02f, -4.69485857e-02f, 3.04080416e-02f, -3.70853469e-02f, 9.33660343e-02f, 7.48840347e-02f, 7.21912906e-02f, 1.77129194e-01f, 1.51945218e-01f, 5.66938240e-03f,
  1.15957018e-02f, 1.54031828e-01f, 2.95988381e-01f, 1.64530158e-01f, 5.00393733e-02f, 3.63831371e-02f, 2.05533400e-01f, 3.97557840e-02f, 2.58345842e-01f, 1.58878610e-01f,
  -1.10234752e-01f, -2.99701225e-02f, 5.62303551e-02f, -7.18957186e-02f, -1.18976878e-02f, -1.41694561e-01f, 2.19958667e-02f, -7.74999931e-02f, 1.88002121e-02f, 3.78799215e-02f,
  -1.11310473e-02f, -8.56799558e-02f, -1.48881990e-02f, -6.78090286e-03f, -5.58626987e-02f, 4.01438884e-02f, 6.69486523e-02f, 4.90209507e-03f, 1.08919973e-02f, 8.07972476e-02f,
  -4.83943857e-02f, -1.78932957e-02f, -4.78711762e-02f, -2.31984705e-02f, 6.57564476e-02f, -2.78119519e-02f, 4.55125757e-02f, 1.98309142e-02f, -7.95163494e-03f, 5.30266985e-02f,
  -2.07817137e-01f, 1.29077703e-01f, 1.34628974e-02f, 7.08932942e-03f, 1.18121922e-01f, 1.60984192e-02f, 4.25872058e-02f, 3.89500931e-02f, 1.16977744e-01f, 5.62190078e-02f,
  5.25650382e-02f, 1.01549685e-01f, -4.82165627e-03f, 1.26322091e-01f, 6.13055117e-02f, 1.45165607e-01f, 2.64764801e-02f, 1.44865394e-01f, 5.50335608e-02f, 1.27021909e-01f,
  2.43254509e-02f, 2.60096312e-01f, 2.41070107e-01f, 1.87509209e-01f, 1.76270545e-01f, 6.40828088e-02f, 1.87828526e-01f, 1.39535159e-01f, 2.19321281e-01f, 2.07769856e-01f,
  1.67677715e-01f, 9.62021500e-02f, 1.89235687e-01f, 1.87669829e-01f, 6.35370165e-02f, 1.62595391e-01f, 1.25602975e-01f, 4.12523560e-02f, 5.14386892e-02f, 4.94333431e-02f,
  -5.46493568e-03f, -1.64820403e-02f, 3.88166793e-02f, -3.33556272e-02f, -2.70500910e-02f, 8.21443424e-02f, 2.98830628e-01f, 2.47259095e-01f, 9.00216922e-02f, 6.11916482e-02f,
  1.79660488e-02f, 1.76913038e-01f, 1.90611452e-01f, 1.63411051e-01f, 1.06665865e-01f, 1.38624936e-01f, 1.26410097e-01f, 1.28405049e-01f, 2.20850125e-01f, 3.07632118e-01f,
  2.61647791e-01f, 1.03393175e-01f, -7.89617747e-02f, -2.95529179e-02f, -5.94656244e-02f, -1.14804655e-01f, -2.83596944e-03f, -4.50937599e-02f, 6.01751544e-03f, 3.14961374e-02f,
  4.55104094e-03f, -5.21376692e-02f, -3.42453122e-02f, -3.02337278e-02f, 8.71963352e-02f, 6.82885349e-02f, 3.05755492e-02f, 3.18497606e-02f, -3.07341218e-02f, -8.49340931e-02f,
  -4.90976423e-02f, 1.50051236e-01f, 1.62657648e-01f, -2.69564074e-02f, 3.64285931e-02f, 5.21617383e-02f, 1.25635237e-01f, 4.92524877e-02f, 1.10060856e-01f, 9.81786847e-02f,
  -1.89373828e-02f, 1.45539762e-02f, 7.63862729e-02f, 9.56238508e-02f, 2.03603506e-02f, 1.63125414e-02f, 7.96900541e-02f, 7.74015188e-02f, 1.15916386e-01f, -4.74883392e-02f,
  8.87359083e-02f, 3.94671448e-02f, 7.11285248e-02f, 1.46712437e-01f, 9.13043469e-02f, 9.90032703e-02f, 3.20947096e-02f, 1.48682194e-02f, 8.87401178e-02f, 6.83205351e-02f,
  2.00257357e-02f, 1.17141351e-01f, 2.52879821e-02f, 6.61192238e-02f, 4.05084491e-02f, 6.98169619e-02f, 6.39334172e-02f, 3.87939997e-02f, -6.15029261e-02f, -4.76579890e-02f,
  -4.80056601e-03f, -3.73749211e-02f, -1.12752527e-01f, -5.79624027e-02f, 1.91366971e-02f, -6.52668625e-02f, 2.76681705e-04f, -1.87525782e-03f, -9.09925252e-02f, -1.22236619e-02f,
  -6.53523654e-02f, -8.08055401e-02f, 3.77025455e-02f, -2.81023961e-02f, -3.62200029e-02f, -4.15562652e-02f, -7.70030776e-03f, 1.97760668e-02f, -5.81552368e-03f, -1.28927119e-02f,
  -3.91627960e-02f, 3.63155156e-02f, -1.01272138e-02f, -9.74963903e-02f, -1.11008935e-01f, -1.35134816e-01f, 1.71597134e-02f, 4.18228330e-04f, -1.00483950e-02f, -2.22863909e-02f,
  -2.00979188e-01f, 1.11464389e-01f, 2.25280195e-01f, 2.22904552e-02f, 1.03322037e-01f, 1.39051646e-01f, 2.72540331e-01f, 7.33158961e-02f, 3.97323631e-03f, 1.79283023e-02f,
  -1.09520815e-01f, -1.00435935e-01f, -6.30692840e-02f, -2.54554860e-02f, 5.66234253e-02f, 1.72986969e-01f, 2.38320798e-01f, 2.22515628e-01f, 6.63447976e-02f, 6.96773976e-02f,
  -2.42261738e-02f, 3.73075120e-02f, 4.21441980e-02f, 6.97241724e-02f, 2.06182465e-01f, 1.45302743e-01f, 2.09364325e-01f, 1.24146119e-01f, 2.27216512e-01f, 1.26735419e-01f,
  6.96219653e-02f, -2.12166756e-02f, 5.89113496e-02f, -5.61238714e-02f, 9.35596451e-02f, 6.87251836e-02f, 6.10554926e-02f, 8.24784189e-02f, 8.05371553e-02f, 9.23276991e-02f,
  4.33259234e-02f, 5.27681895e-02f, 1.13718003e-01f, 1.20178699e-01f, -1.66890770e-03f, 1.04178622e-01f, 1.32373095e-01f, 2.69430242e-02f, 3.34514007e-02f, 3.05538252e-02f,
  2.13314462e-02f, 1.79484621e-01f, 1.26787260e-01f, 1.41844124e-01f, 1.17780007e-01f, 5.22444919e-02f, 2.20849738e-01f, 1.15845561e-01f, 2.04335153e-01f, 2.57324934e-01f,
  -1.70786411e-01f, -7.40897879e-02f, 1.35397827e-02f, 3.78255956e-02f, -4.34018895e-02f, -3.01409699e-02f, 5.81609048e-02f, -2.07782537e-02f, -9.85965971e-03f, 1.12242848e-01f,
  -8.87362882e-02f, 4.24502306e-02f, 2.21314263e-02f, 5.04532866e-02f, 4.46321107e-02f, 1.85015406e-02f, 5.89130670e-02f, -6.40993789e-02f, 1.23365358e-01f, -1.35130519e-02f,
  4.47184108e-02f, 2.38178615e-02f, 3.33893783e-02f, -7.84887373e-03f, 3.69727127e-02f, 9.20906547e-04f, 3.13568069e-03f, 2.24348120e-02f, -1.33626107e-02f, -5.47935776e-02f,
  -1.36307612e-01f, 2.52404790e-02f, 1.19061545e-01f, 8.63950402e-02f, 1.51199773e-01f, 1.15684308e-01f, 1.02819160e-01f, 7.95245692e-02f, 8.36328119e-02f, 1.98107697e-02f,
  5.12547456e-02f, -7.37809390e-03f, 1.36198074e-01f, 5.07100075e-02f, 1.22414909e-01f, 1.01581879e-01f, 8.93253982e-02f, 1.21562079e-01f, 1.24256447e-01f, 8.14994872e-02f,
  1.38652772e-01f, 1.03343271e-01f, 1.17557108e-01f, 1.08885869e-01f, 2.21815065e-01f, 1.08005069e-01f, 2.31030583e-01f, 1.64955705e-01f, 6.56802878e-02f, 1.78251415e-01f,
  1.64171532e-01f, -2.10097164e-01f, 1.55121073e-01f, -1.25693679e-01f, 2.47367635e-01f, 2.94677764e-01f, 2.28351027e-01f, 7.45270550e-02f, 4.60844953e-03f, -6.79199323e-02f,
  8.00230503e-02f, 1.54520627e-02f, -6.49645478e-02f, 2.25749109e-02f, 3.06013841e-02f, -1.37461692e-01f, -6.05133697e-02f, 2.06549503e-02f, 3.37317467e-01f, 3.06856215e-01f,
  1.70420855e-02f, -8.94531831e-02f, -2.66374666e-02f, 8.23173970e-02f, -5.71548827e-02f, -6.91278353e-02f, -1.33148119e-01f, 1.01501107e-01f, -3.59996147e-02f, -3.28024566e-01f,
  3.51527184e-02f, 2.11187035e-01f, 1.09446757e-01f, 8.17518495e-03f, 6.38857633e-02f, 4.32204902e-02f, 9.83021483e-02f, 3.61480527e-02f, 8.72665048e-02f, -1.25201400e-02f,
  9.04016644e-02f, 1.45655312e-02f, -1.61639098e-02f, -5.38134575e-02f, -1.59531888e-02f, 6.90695569e-02f, -5.42425737e-02f, -1.51098035e-02f, 4.60429676e-03f, 1.35963544e-01f,
  -1.09861735e-02f, 1.00487106e-01f, 1.74715698e-01f, -1.87055599e-02f, 5.02321944e-02f, 1.53771505e-01f, 6.16228171e-02f, 1.39372453e-01f, 4.75301631e-02f, -2.33440325e-01f,
  4.12427075e-02f, -1.47635378e-02f, 5.69274463e-02f, -1.11705519e-01f, -2.09142547e-02f, -9.41216648e-02f, -7.49569805e-03f, -1.13390587e-01f, 5.46959266e-02f, -1.01693571e-01f,
  1.06188757e-02f, -1.34882834e-02f, -4.01852019e-02f, -2.29633711e-02f, -6.75868765e-02f, -9.05409642e-03f, 7.27208145e-03f, -1.56336293e-01f, 2.85991021e-02f, -2.44108643e-02f,
  -1.05151214e-01f, 4.95198853e-02f, -5.09842448e-02f, -1.43443689e-01f, 1.04660932e-02f, -7.53710270e-02f, -5.35068400e-02f, 3.45283598e-02f, 4.20045666e-02f, -3.79523039e-02f,
  -2.28444695e-01f, 2.33020857e-01f, -9.90217105e-02f, 5.24955764e-02f, -9.02484823e-03f, 1.16230570e-01f, -4.58706804e-02f, 4.38263379e-02f, 1.10891936e-02f, 5.00692092e-02f,
  4.12727818e-02f, 6.73281327e-02f, -4.31936830e-02f, 3.95263396e-02f, 1.34206817e-01f, 2.02622935e-02f, -1.10125072e-01f, 4.01023403e-03f, 2.22415682e-02f, 1.09728158e-01f,
  -4.42848653e-02f, 4.39004824e-02f, 3.52618210e-02f, -1.25304349e-02f, 1.19533047e-01f, 2.44652219e-02f, 1.43055217e-02f, -6.33978145e-03f, 1.58145830e-01f, -2.11061597e-01f,
  -3.55086118e-01f, -4.38667268e-01f, -1.21972814e-01f, -2.99000442e-01f, 4.18332070e-02f, 7.39769265e-02f, 6.30037040e-02f, 3.46279219e-02f, -4.44103256e-02f, -2.65925169e-01f,
  -2.74795264e-01f, -2.04611063e-01f, -2.72975206e-01f, -1.03859611e-01f, 5.44747245e-03f, -1.30079180e-01f, -1.93267182e-01f, -1.12778880e-01f, 1.64847746e-01f, -2.96698371e-03f,
  -9.00791436e-02f, -8.97556320e-02f, -9.77681354e-02f, -4.51805331e-02f, -1.81587055e-01f, -1.29366726e-01f, -8.05568248e-02f, -1.33210599e-01f, -4.21043113e-03f, -3.16597223e-01f,
  -3.60128403e-01f, -6.99997693e-02f, -3.98497805e-02f, -1.05447397e-01f, -1.02026276e-01f, -1.65139854e-01f, -1.58867389e-01f, -1.75254881e-01f, -1.63799956e-01f, -2.14965597e-01f,
  -1.10700570e-01f, -8.55081603e-02f, -1.34873241e-01f, -1.39526963e-01f, -2.57006269e-02f, -1.68426737e-01f, -1.84485927e-01f, -6.82888776e-02f, -8.44965950e-02f, -1.95683032e-01f,
  -9.54695940e-02f, -1.31690353e-01f, -8.81557614e-02f, -5.69558144e-02f, -1.16697267e-01f, -8.99495631e-02f, -1.47753328e-01f, -3.14218141e-02f, -4.05807830e-02f, -2.32750922e-01f,
  2.16270667e-02f, -1.66249964e-02f, 1.63078696e-01f, 1.07022598e-01f, 6.84572160e-02f, 1.32829770e-01f, 1.20190442e-01f, 2.50561778e-02f, 2.03070939e-01f, 1.49275482e-01f,
  1.62223339e-01f, 1.09571062e-01f, 9.67178941e-02f, 1.07880481e-01f, 1.39200330e-01f, 1.30595133e-01f, 1.08877234e-01f, 4.69428934e-02f, 3.73367257e-02f, 1.72565505e-01f,
  3.50677632e-02f, 1.97277829e-01f, 1.07041016e-01f, 1.87365144e-01f, 1.28160700e-01f, 1.18524343e-01f, 1.70554444e-01f, 5.43664023e-02f, 1.21193536e-01f, 8.45467076e-02f,
  -1.65773481e-01f, 1.39315978e-01f, -2.92207330e-01f, -6.66705221e-02f, -3.47457454e-02f, -7.29970494e-03f, -1.03065208e-01f, -6.82695657e-02f, -1.02310650e-01f, -1.05126306e-01f,
  -1.07807238e-02f, -1.60461351e-01f, -1.50942743e-01f, -6.43232390e-02f, 1.23473499e-02f, 8.25299358e-05f, -5.78091778e-02f, -1.12731189e-01f, -1.25215948e-01f, -2.57649589e-02f,
  -1.83169097e-01f, -8.47800672e-02f, -1.41327858e-01f, -1.18949734e-01f, 2.16276031e-02f, -1.07586496e-01f, -1.23493224e-01f, -9.45150405e-02f, -2.50888430e-02f, -1.69714764e-01f,
  3.07013690e-01f, 5.64310014e-01f, -3.04135811e-02f, 1.81704238e-01f, -1.22105964e-01f, -5.64942807e-02f, -3.41592194e-03f, 5.69041036e-02f, -7.74706947e-03f, 2.05740944e-01f,
  1.89045385e-01f, 2.29071692e-01f, 1.45355269e-01f, 6.32492527e-02f, 7.46921003e-02f, 3.09885405e-02f, 5.72718214e-03f, -1.19836755e-01f, -1.66083544e-01f, 4.98030968e-02f,
  -1.14018871e-02f, 1.05853260e-01f, 2.26629749e-01f, 1.31009459e-01f, 8.73133019e-02f, 4.83323708e-02f, 4.52625640e-02f, 8.36535618e-02f, 2.96835275e-03f, 7.26236030e-02f,
  -1.23644501e-01f, 3.04922312e-01f, -9.31361783e-03f, 2.09910855e-01f, 6.27874434e-02f, 6.63431585e-02f, -7.26687780e-04f, 8.31950754e-02f, 1.17319584e-01f, 7.28047043e-02f,
  7.41142705e-02f, 1.91130817e-01f, 1.33585304e-01f, -2.43924800e-02f, 5.14807627e-02f, 9.67429504e-02f, 1.22829281e-01f, 1.10181108e-01f, 1.13223597e-01f, -2.83780880e-03f,
  9.56631824e-02f, 4.20456454e-02f, 4.28910702e-02f, -4.19808589e-02f, 5.50032072e-02f, 3.95971024e-03f, 1.71152242e-02f, 4.01048437e-02f, -2.52981801e-02f, -1.23410225e-02f,
  1.21610403e-01f, -7.91997090e-02f, -5.50727844e-02f, 7.86254124e-04f, -2.44239401e-02f, -8.87948796e-02f, -9.47488993e-02f, -1.24135591e-01f, -1.12984672e-01f, -1.27851099e-01f,
  -7.98276886e-02f, -6.65904135e-02f, -8.86868089e-02f, -6.28468022e-02f, -1.15547054e-01f, -3.93902957e-02f, -1.39239043e-01f, -9.50317159e-02f, -1.36356160e-01f, -2.95734406e-02f,
  -7.58361891e-02f, -1.72860786e-01f, -1.21166483e-01f, -1.85051486e-01f, -1.15007766e-01f, -1.33241102e-01f, -2.16334060e-01f, -6.96467701e-03f, -1.70716017e-01f, -5.95578402e-02f,
  2.02896506e-01f, 1.80790409e-01f, -1.09253731e-02f, 6.05143867e-02f, -1.66989248e-02f, 1.07835166e-01f, 7.56202415e-02f, 8.47060606e-02f, 1.23633951e-01f, 6.22127987e-02f,
  3.97255793e-02f, 1.34317860e-01f, 9.09990296e-02f, 5.21960929e-02f, -4.85909125e-03f, -2.56457254e-02f, 3.58021446e-02f, 2.68866438e-02f, -5.21632135e-02f, 3.82322893e-02f,
  4.52837944e-02f, 1.95153467e-02f, 3.76194599e-03f, -4.98954616e-02f, 5.31321838e-02f, -6.08670935e-02f, 4.75680754e-02f, -1.00612678e-01f, -2.83295778e-03f, 1.20034944e-02f,
  3.33114415e-01f, -3.04383487e-01f, 2.21744832e-02f, 1.69970319e-01f, 6.32087812e-02f, -1.26201272e-01f, -2.61422873e-01f, 5.09133488e-02f, 2.04976514e-01f, -6.34530783e-02f,
  -1.04571320e-01f, 1.63412556e-01f, 1.67086706e-01f, 2.16016263e-01f, 1.41401619e-01f, -4.53794748e-02f, 1.18191786e-01f, 3.46160561e-01f, 3.79097372e-01f, 1.91357121e-01f,
  4.44063582e-02f, 1.04586810e-01f, 3.08728933e-01f, 2.09918961e-01f, 9.66728702e-02f, 1.43834054e-01f, -5.18417023e-02f, 3.92938405e-02f, -7.77351186e-02f, 7.63337174e-03f,
  6.12020725e-03f, 1.04148328e-01f, 1.08531974e-01f, 6.83948910e-03f, 6.56151306e-03f, 2.36612726e-02f, -2.49853935e-02f, 8.90034065e-02f, -9.32776369e-03f, 1.67315044e-02f,
  1.46089613e-01f, 1.39666244e-01f, 2.55700033e-02f, 3.24973720e-03f, 1.58449069e-01f, 1.43054262e-01f, 5.87192103e-02f, 1.59221694e-01f, -6.90154824e-03f, -4.23998153e-03f,
  -5.64678311e-02f, 4.29963879e-02f, 1.26293465e-01f, 2.45946087e-02f, 1.78561229e-02f, 7.43287206e-02f, 2.40876488e-02f, 1.38701588e-01f, 1.30685553e-01f, -2.25917138e-02f,
  -5.95192388e-02f, 5.34061305e-02f, -8.15904140e-03f, 7.42567191e-03f, -1.39055988e-02f, -5.12561910e-02f, 6.46090731e-02f, -2.96141021e-02f, 3.33776549e-02f, 2.39812694e-02f,
  7.73647055e-03f, -3.80834341e-02f, -6.91774338e-02f, -8.22720528e-02f, -1.11031374e-02f, -5.68673685e-02f, -5.32800099e-03f, -6.18550107e-02f, -2.32846010e-03f, -1.72419716e-02f,
  2.44217142e-02f, 4.87434082e-02f, -1.13686308e-01f, -3.62668261e-02f, -1.24481700e-01f, -2.94940248e-02f, 2.93030255e-02f, 3.84791405e-03f, -7.90379494e-02f, 2.31327867e-04f,
  -1.11954864e-02f, 1.60436019e-01f, 6.85955212e-02f, 2.45845184e-01f, 2.22587846e-02f, -9.35261510e-03f, 4.67848144e-02f, 7.95397013e-02f, 6.69742450e-02f, 1.21289022e-01f,
  -6.96710340e-05f, 5.89718409e-02f, 3.95855382e-02f, 4.97603379e-02f, 5.73891625e-02f, 5.07971868e-02f, 2.70956885e-02f, 1.52551338e-01f, 1.16818566e-02f, 4.66923080e-02f,
  -2.79338509e-02f, 9.66079384e-02f, 9.70294401e-02f, 5.75392433e-02f, 8.07284489e-02f, 1.07914627e-01f, -3.48336734e-02f, 4.94769402e-02f, 3.57653238e-02f, -1.25024527e-01f,
  2.80194402e-01f, 1.70733422e-01f, -1.89395174e-01f, 6.88431561e-02f, -6.25732094e-02f, -6.25108629e-02f, 7.52499094e-03f, 1.30175665e-01f, 9.35853869e-02f, -1.18912660e-01f,
  -6.70573264e-02f, -6.63387701e-02f, -8.79916102e-02f, -1.70746312e-01f, -1.12537719e-01f, -1.32262394e-01f, -1.98907286e-01f, -2.44069442e-01f, -9.35609341e-02f, -6.88771233e-02f,
  -2.15915903e-01f, -7.58445337e-02f, -7.40294382e-02f, -1.47404820e-01f, -2.20638365e-01f, -1.85659304e-01f, -2.16555998e-01f, -2.05122054e-01f, -2.22703144e-01f, -1.15421250e-01f,
  -2.66607791e-01f, 1.92459762e-01f, -5.63934334e-02f, -3.72261787e-03f, 1.52870743e-02f, 1.78894661e-02f, 6.82135150e-02f, -1.54380258e-02f, -2.02714540e-02f, -6.88111922e-03f,
  -3.35542187e-02f, -1.57539006e-02f, -4.96248938e-02f, -3.98719385e-02f, 7.78367138e-03f, -7.25686252e-02f, 3.49961407e-03f, -5.18832393e-02f, -5.58272749e-02f, -6.01164103e-02f,
  -8.89900550e-02f, -1.20646320e-01f, 8.97583887e-02f, 1.11050986e-01f, 1.09299887e-02f, 4.94285971e-02f, 1.87677741e-02f, 5.20536751e-02f, 4.86231409e-02f, -5.23856468e-02f,
  -7.41031095e-02f, 5.89667819e-02f, 7.06708208e-02f, 9.07229260e-04f, 1.06241442e-01f, 3.57964896e-02f, -4.79851067e-02f, 6.03534915e-02f, 3.18922698e-02f, 3.65675092e-02f,
  2.23544240e-02f, -1.35236122e-02f, -3.45827639e-02f, -5.45179211e-02f, -1.31371886e-01f, 3.78427207e-02f, -3.71656008e-02f, 5.11153042e-02f, -7.44380280e-02f, 5.31042134e-03f,
  1.23104770e-02f, 4.11541834e-02f, 2.89065745e-02f, -1.20057594e-02f, -4.96989861e-02f, 2.22592894e-02f, 5.87604158e-02f, 2.76471619e-02f, -1.85290650e-02f, 1.31000411e-02f,
  -1.66893296e-03f, 6.37955293e-02f, 2.64829397e-02f, 1.65562406e-02f, -1.57731548e-01f, -9.24632102e-02f, -5.74037656e-02f, -7.36389216e-03f, -2.13894416e-02f, -2.59634089e-02f,
  -5.45468554e-02f, -2.41863206e-02f, -1.06839709e-01f, -4.71928604e-02f, -9.19432193e-02f, -6.75193742e-02f, 1.60779096e-02f, -1.21238522e-01f, 5.52236289e-03f, 1.94157921e-02f,
  6.74093440e-02f, 3.27589698e-02f, 4.29579727e-02f, -1.45423822e-02f, 3.74343842e-02f, 4.10882384e-03f, -1.09209223e-02f, -5.34306616e-02f, -2.16410160e-02f, -1.99723896e-03f,
  -2.42129743e-01f, -2.19673976e-01f, -1.73654899e-01f, -8.01521316e-02f, -1.58432983e-02f, -2.57738656e-03f, -1.83789074e-01f, -2.34703660e-01f, 5.00647090e-02f, -5.64151742e-02f,
  9.54208374e-02f, 1.40557319e-01f, 5.49912676e-02f, 4.82382663e-02f, 3.34994402e-04f, -7.86979198e-02f, -6.28952682e-02f, 1.39214657e-02f, 1.14173315e-01f, 6.44499436e-02f,
  1.41321510e-01f, 1.15030095e-01f, -2.38558240e-02f, -7.89927915e-02f, -2.06840262e-02f, 2.07016151e-02f, -8.77154544e-02f, 1.44069884e-02f, 4.63672020e-02f, -1.75605025e-02f,
  1.10654414e-01f, -1.49091437e-01f, -5.53138927e-02f, -7.22695962e-02f, -1.72507897e-01f, -7.98292011e-02f, -1.24367706e-01f, -1.96114004e-01f, -5.71326725e-02f, -1.45641908e-01f,
  -7.20022619e-02f, -7.78555572e-02f, -7.03043938e-02f, -3.22406250e-03f, -1.40513435e-01f, -7.17199743e-02f, -1.76015049e-01f, -1.89950511e-01f, -2.02547431e-01f, -1.51599169e-01f,
  -9.53145325e-02f, -8.86434987e-02f, -1.48540542e-01f, -1.20298021e-01f, -1.52307212e-01f, -1.77732967e-02f, -2.07529292e-01f, -1.68478832e-01f, -7.49673322e-02f, -2.70307362e-01f,
  1.45042568e-01f, -1.79716200e-02f, 5.24502695e-02f, 1.21816397e-01f, 1.49105832e-01f, -3.02592455e-03f, 4.01582383e-02f, 5.67793213e-02f, 7.92107452e-03f, 5.89271486e-02f,
  1.94117203e-02f, 1.26466276e-02f, 1.34025529e-01f, 4.59071212e-02f, 2.20267046e-02f, -3.23285386e-02f, 3.07284445e-02f, 9.31207910e-02f, 7.26006329e-02f, 8.21489468e-02f,
  1.09837353e-01f, 7.89970458e-02f, -2.10160622e-03f, -3.80406901e-03f, 7.05290884e-02f, 3.45850326e-02f, 8.64921510e-02f, 2.06220206e-02f, 1.52929336e-01f, -8.01595394e-03f,
  -4.13962863e-02f, -1.60866857e-01f, -1.29964324e-02f, -1.21576026e-01f, -1.09313086e-01f, -1.56818375e-01f, -9.05479193e-02f, -8.87391418e-02f, -1.34174243e-01f, -1.00250691e-01f,
  -1.66817963e-01f, -7.68731087e-02f, -2.03817517e-01f, -2.05168262e-01f, -1.50187418e-01f, -9.75058451e-02f, -1.87913075e-01f, -1.43517181e-01f, -7.56676197e-02f, -2.73834229e-01f,
  -2.43452772e-01f, -9.49180126e-02f, -7.28354529e-02f, -1.92124978e-01f, -2.27030382e-01f, -4.47129644e-02f, -1.18186891e-01f, -2.10119799e-01f, -8.95671621e-02f, -2.22710967e-01f,
  3.79840374e-01f, -1.28048971e-01f, 1.56681523e-01f, -5.80843762e-02f, -1.41664118e-01f, -7.06519117e-04f, 5.87787144e-02f, 1.19896851e-01f, -5.55044338e-02f, -7.30055496e-02f,
  -2.56026626e-01f, -1.77268982e-01f, -4.23980206e-02f, 6.43371418e-02f, 1.95424601e-01f, 3.51467170e-02f, 6.25283718e-02f, 3.01416010e-01f, 3.16688240e-01f, 1.79440826e-01f,
  8.54452029e-02f, 9.54795852e-02f, 2.10793972e-01f, 1.93121403e-01f, 7.04276860e-02f, -2.74057798e-02f, -1.14915207e-01f, 2.31779814e-02f, -6.93553984e-02f, 6.12224750e-02f,
  1.87207282e-01f, 5.51019050e-02f, 1.74988359e-01f, -4.49398011e-02f, -1.54700503e-01f, 1.92227125e-01f, 7.32556963e-03f, 1.50653988e-01f, 5.33865243e-02f, 1.06631212e-01f,
  -6.18655868e-02f, 9.99238864e-02f, -8.95798113e-03f, 3.86268683e-02f, 1.22200876e-01f, 8.87222737e-02f, 1.20825231e-01f, 1.12375364e-01f, 7.63880089e-02f, 1.29571542e-01f,
  -1.02047883e-01f, -6.55682012e-02f, -5.76839456e-03f, 1.41800806e-01f, 1.49487272e-01f, 1.19807586e-01f, 9.34575573e-02f, 1.98652428e-02f, 1.11101501e-01f, 6.56939298e-02f,
  1.43642572e-03f, -4.80274530e-03f, -9.67497230e-02f, -1.31855369e-01f, -6.54776618e-02f, -8.87569636e-02f, -1.38906911e-02f, -1.36715293e-01f, -1.92833040e-02f, -1.29839614e-01f,
  -7.65266046e-02f, -8.41300264e-02f, 2.97609828e-02f, -1.04386263e-01f, -2.25740783e-02f, -5.42591289e-02f, 1.15551183e-03f, -4.04646322e-02f, -1.19626615e-02f, -6.26557097e-02f,
  1.60595812e-02f, -6.08991049e-02f, -4.49851044e-02f, -2.24206354e-02f, -3.71207707e-02f, -1.47949889e-01f, -5.16165905e-02f, -2.66708080e-02f, -9.80271548e-02f, -7.74487555e-02f,
  -2.24839464e-01f, 4.15128060e-02f, 1.84733063e-01f, 1.75921157e-01f, 1.71887074e-02f, 8.21590573e-02f, 6.30063489e-02f, 9.54905897e-02f, -2.70169042e-02f, 9.36020836e-02f,
  4.92813438e-02f, 1.77485272e-01f, 8.40257108e-02f, 8.16016644e-02f, 1.26690522e-01f, 7.18026087e-02f, -6.41083717e-02f, 1.01507589e-01f, 1.35977268e-01f, 1.45570293e-01f,
  -1.94411948e-02f, 1.14091806e-01f, 6.10764809e-02f, -2.06445958e-02f, 6.39834106e-02f, 1.25393748e-01f, 7.58733153e-02f, 2.68243290e-02f, 5.74411973e-02f, 1.77539557e-01f,
  -1.53006077e-01f, 3.64608973e-01f, 3.37320864e-01f, -5.19756489e-02f, 3.51283140e-02f, 2.97666509e-02f, -5.44669069e-02f, -2.54874695e-02f, -3.01890429e-02f, 1.32490307e-01f,
  1.57278389e-01f, 2.15216409e-02f, 3.51098180e-02f, 1.66278318e-01f, 9.55126435e-03f, -6.25221338e-03f, -2.66911071e-02f, 7.98663241e-04f, 6.83068335e-02f, 4.00346816e-02f,
  1.69572040e-01f, 2.23364875e-01f, 1.74456879e-01f, 1.45940915e-01f, 1.84313044e-01f, -1.07223948e-03f, 1.10832006e-01f, 1.27433792e-01f, 1.36023149e-01f, 1.58758789e-01f,
  3.41620624e-01f, 2.91853487e-01f, 4.62807119e-02f, 9.66624841e-02f, 2.33211920e-01f, 1.76283136e-01f, 8.92621726e-02f, 2.18640208e-01f, 1.30982503e-01f, 5.91875426e-02f,
  1.04665786e-01f, 1.72894686e-01f, 8.27531815e-02f, 1.40333936e-01f, 9.71543863e-02f, 1.03851110e-01f, 1.73144832e-01f, 1.77475423e-01f, 7.10438490e-02f, 9.57050771e-02f,
  1.50136754e-01f, 1.16432086e-01f, 1.29274562e-01f, 1.34765789e-01f, 3.64696532e-02f, 4.93949000e-03f, 7.05368966e-02f, 1.14129797e-01f, 1.00647226e-01f, 7.66576827e-02f,
  -7.80015364e-02f, -8.09884518e-02f, -2.63608024e-02f, -1.04624778e-02f, -8.81257653e-02f, -8.24854225e-02f, 4.94756643e-03f, -6.42869994e-02f, -5.54518886e-02f, 3.23909260e-02f,
  -6.15267754e-02f, -6.14998415e-02f, 3.70989479e-02f, -6.97031766e-02f, -4.56441417e-02f, 9.27879103e-03f, -9.68117826e-03f, -7.60181248e-02f, 6.76410198e-02f, -5.42840399e-02f,
  -1.29062936e-01f, 1.97371114e-02f, -3.69879976e-02f, -4.73809093e-02f, 4.59239557e-02f, -1.13971338e-01f, -1.33516133e-01f, 3.98369692e-03f, -4.46623899e-02f, -4.85219881e-02f,
  -5.83077446e-02f, 4.86479439e-02f, 1.44545259e-02f, 2.93690450e-02f, 1.00123644e-01f, 8.94822404e-02f, 8.35855678e-02f, 1.77780867e-01f, 1.41516447e-01f, 1.17844760e-01f,
  1.15233973e-01f, 8.97953287e-02f, 1.83814555e-01f, 3.33849788e-02f, 9.47041884e-02f, 9.94793475e-02f, 9.49637294e-02f, 3.17329913e-02f, 1.14345603e-01f, 1.84928015e-01f,
  2.52756495e-02f, -4.97705042e-02f, -3.68152298e-02f, -8.96039307e-02f, 5.46929576e-02f, -1.19747743e-01f, 2.45608576e-02f, -7.23455623e-02f, -2.72458959e-02f, -1.70531794e-01f,
  3.84212255e-01f, 3.20700556e-01f, -5.03609180e-01f, 1.54191658e-01f, -5.19246608e-02f, -1.51798114e-01f, -9.96405184e-02f, 6.40689507e-02f, 6.13030903e-02f, 8.27718377e-02f,
  1.65437255e-02f, 4.43876199e-02f, -1.80658326e-01f, -2.11386636e-01f, -6.68072626e-02f, -1.56561613e-01f, -1.90206066e-01f, -2.41705596e-01f, -1.36013269e-01f, 1.82862937e-01f,
  1.72023639e-01f, 2.97423542e-01f, 1.97695956e-01f, -2.74910126e-02f, 9.82159600e-02f, -1.28196061e-01f, -2.66418457e-01f, 6.25834018e-02f, -9.38335061e-02f, 5.61311841e-02f,
  -1.71995178e-01f, 1.72345191e-01f, -1.67989790e-01f, 1.04649745e-01f, -7.59849548e-02f, -1.46210752e-02f, -7.16108549e-03f, -1.64305028e-02f, -5.92117980e-02f, -3.21169337e-03f,
  7.38055259e-02f, -6.50240621e-03f, 5.73156290e-02f, 3.95604074e-02f, 5.22151515e-02f, 1.54079664e-02f, -9.18872431e-02f, -1.14509150e-01f, -1.22221336e-01f, 3.70015353e-02f,
  8.62756595e-02f, 9.78743285e-02f, -1.80537030e-01f, -1.45135880e-01f, -1.47241056e-01f, -7.96448737e-02f, -4.43209782e-02f, -1.59025732e-02f, -1.03867143e-01f, 1.06643774e-01f,
  -2.48767348e-04f, -4.01547998e-02f, -2.65114643e-02f, 3.83199081e-02f, 5.19484207e-02f, -1.03316031e-01f, 4.03626189e-02f, -8.79746452e-02f, 4.14451174e-02f, 5.00130616e-02f,
  3.61150056e-02f, -1.12979251e-04f, -2.95945797e-02f, 2.14585714e-04f, -2.70978790e-02f, 4.23735864e-02f, -5.01575954e-02f, -4.85858247e-02f, 2.62370110e-02f, 1.21688031e-01f,
  1.99996848e-02f, -4.76649888e-02f, -4.13448736e-02f, 5.55801392e-02f, 3.40741016e-02f, 2.00626836e-03f, 5.26910275e-02f, -1.94367487e-02f, 4.62147966e-02f, 5.17247841e-02f,
  -2.08445285e-02f, -2.19625980e-01f, 9.30085182e-02f, 4.79247645e-02f, 1.21069318e-02f, 1.46006430e-02f, 9.90898255e-03f, 4.80253762e-03f, -1.85453855e-02f, -2.34181397e-02f,
  -7.89514706e-02f, -8.03451091e-02f, -5.28813386e-03f, -1.31855216e-02f, -4.62999530e-02f, 6.12066537e-02f, 4.42199074e-02f, -8.96883139e-04f, -7.47210681e-02f, 3.03060003e-02f,
  6.35102019e-02f, -9.41504240e-02f, -1.33988678e-01f, -1.53462127e-01f, -1.10078327e-01f, -9.91701484e-02f, -6.26471266e-02f, -1.24183252e-01f, -2.65030146e-01f, 1.44741097e-02f,
  -1.69859961e-01f, -1.52284965e-01f, 5.57575449e-02f, -9.14054811e-02f, -1.18979298e-01f, 4.18067351e-02f, -3.82126612e-03f, 7.03227222e-02f, 4.34171520e-02f, -9.87576842e-02f,
  -4.18547869e-01f, -3.45730364e-01f, -2.20261544e-01f, -1.68300226e-01f, -1.49672732e-01f, 1.84553519e-01f, 1.94721714e-01f, 1.54128879e-01f, -2.82022897e-02f, 2.72867754e-02f,
  -8.49843025e-02f, -1.99192856e-02f, -1.79886650e-02f, 6.48487136e-02f, -1.38426021e-01f, -1.08664848e-01f, 1.40421353e-02f, -1.84850588e-01f, -8.32911804e-02f, -5.70080131e-02f,
  -3.09541851e-01f, -2.49914885e-01f, -3.70235033e-02f, -1.69968992e-01f, -1.05090931e-01f, -1.29009172e-01f, -7.40500838e-02f, -5.27073927e-02f, -1.98098138e-01f, -5.25802784e-02f,
  -1.99796498e-01f, -1.60178602e-01f, -1.92384154e-01f, -9.58421454e-02f, -6.05496690e-02f, -2.68562455e-02f, -1.28802070e-02f, -3.39092389e-02f, -6.63972553e-03f, -8.64075944e-02f,
  -6.88802078e-02f, -1.30341202e-01f, -6.55285418e-02f, -2.18428653e-02f, -1.47371173e-01f, -1.58789113e-01f, -1.84693813e-01f, -1.70214131e-01f, -7.37544894e-02f, 1.07611548e-02f,
  2.14453507e-02f, 3.30996998e-02f, 4.72949259e-02f, 6.03731163e-02f, -3.70150129e-03f, 1.07943200e-01f, 3.70765142e-02f, 1.88617278e-02f, 1.32724643e-01f, 1.26266345e-01f,
  3.19489129e-02f, 3.52674089e-02f, 1.87211663e-01f, 4.21298668e-02f, 9.00373310e-02f, 4.23625670e-02f, 8.63383859e-02f, 1.14186160e-01f, 1.15619652e-01f, 1.05842099e-01f,
  1.61178447e-02f, 1.43805504e-01f, -2.60523148e-03f, 8.38061795e-02f, 1.52879938e-01f, 1.40365094e-01f, 4.97470796e-02f, 1.37605280e-01f, 2.78328806e-02f, -2.29347521e-03f,
  -7.76579157e-02f, -1.28228128e-01f, -1.97025742e-02f, -5.74558228e-02f, -1.98803674e-02f, -2.27533765e-02f, -1.36511058e-01f, -7.37345368e-02f, -8.75507444e-02f, -8.41782317e-02f,
  -1.39632091e-01f, -1.00792252e-01f, -9.40975994e-02f, -7.93351457e-02f, -8.81849825e-02f, -8.91829748e-03f, 1.90113652e-02f, -1.01628684e-01f, 3.19701023e-02f, -1.83586940e-01f,
  3.38290818e-02f, 3.36546302e-02f, -3.77400070e-02f, -4.74094599e-02f, -1.16942205e-01f, -4.84995358e-02f, -4.44307998e-02f, -1.93739980e-02f, -2.14737747e-02f, 4.28560227e-02f,
  5.68995997e-02f, 7.57642016e-02f, -1.83674067e-01f, 4.88648787e-02f, -1.73898906e-01f, -2.57618159e-01f, -1.89716101e-01f, 6.02167323e-02f, 6.36538267e-02f, 2.93859728e-02f,
  1.31985560e-01f, 6.35655075e-02f, 5.65330088e-02f, 1.77224219e-01f, 1.37369752e-01f, -2.28486415e-02f, -1.54773593e-01f, -1.18528724e-01f, 1.76941529e-02f, 4.48440574e-02f,
  -1.87510473e-03f, -9.79804620e-03f, 5.04260212e-02f, 7.99385980e-02f, 3.52752842e-02f, -2.30506361e-02f, -3.25774550e-02f, -8.21347311e-02f, 6.72104359e-02f, 9.31820199e-02f,
  1.80946484e-01f, 9.27173160e-03f, -1.84505302e-02f, 1.55956924e-01f, 1.26595706e-01f, 1.42401204e-01f, -1.35442419e-02f, 3.79831530e-02f, 8.53238404e-02f, 5.47171272e-02f,
  2.66038184e-03f, 1.77557021e-01f, 1.15210973e-01f, 1.23650625e-01f, 1.91516392e-02f, -8.64613615e-03f, -3.57831977e-02f, 5.48408516e-02f, 1.11601129e-01f, 4.53931168e-02f,
  -4.67557786e-03f, -1.01562925e-01f, 1.26348445e-02f, 6.42917231e-02f, 6.42866343e-02f, 8.23830292e-02f, 4.51294519e-02f, 8.25325549e-02f, 1.70215387e-02f, -2.43261307e-02f,
  -3.40412706e-02f, 1.82643011e-02f, 3.43946368e-02f, -4.40704674e-02f, -2.91784760e-03f, 2.39523891e-02f, -2.43594125e-02f, 4.82829567e-03f, -1.48288961e-02f, 7.19400421e-02f,
  -3.82379182e-02f, -2.34679459e-03f, -3.27269360e-02f, -2.07371600e-02f, 4.25408445e-02f, -1.27756014e-01f, -4.46770228e-02f, 9.24740434e-02f, 6.81990907e-02f, -5.33888163e-03f,
  2.80104391e-02f, 3.61996740e-02f, 5.83663583e-03f, 3.76123302e-02f, 2.17155926e-02f, 3.96930352e-02f, -5.71793839e-02f, -3.54225351e-03f, -9.72654894e-02f, -1.25285834e-01f,
  6.94505647e-02f, -1.58478916e-01f, 2.37286448e-01f, 1.27120644e-01f, -5.29472195e-02f, 1.44056454e-01f, 3.29036042e-02f, -4.33437638e-02f, 5.56397215e-02f, 1.17014579e-01f,
  2.76670754e-02f, 1.51644677e-01f, 4.61234385e-03f, 9.66107994e-02f, 9.03770560e-04f, 6.50316998e-02f, -1.69301573e-02f, -1.25494450e-01f, -1.86457206e-02f, 1.62315622e-01f,
  -3.17222327e-02f, -1.50461197e-01f, -2.48055700e-02f, -6.96822181e-02f, -1.48451319e-02f, -6.43990636e-02f, -4.88343053e-02f, 1.44658219e-02f, 4.71208841e-02f, -1.19169578e-01f,
  -2.60393977e-01f, -9.06951278e-02f, -8.68221596e-02f, 2.41031926e-02f, 7.33254626e-02f, -7.66851157e-02f, -2.62740604e-03f, 4.50595096e-02f, 6.97137788e-02f, 6.45783916e-02f,
  -1.12852164e-01f, 1.10268660e-01f, -4.53385189e-02f, -5.40278293e-02f, -5.64432750e-03f, 6.45374581e-02f, 9.64326933e-02f, 6.68528229e-02f, 7.80600011e-02f, 2.75017649e-01f,
  2.34426677e-01f, 2.25365490e-01f, 1.57298967e-02f, 6.99693933e-02f, 4.07582581e-01f, 1.89544573e-01f, 4.63278592e-02f, 1.21427074e-01f, 1.33736938e-01f, 3.59849334e-01f,
  2.53550977e-01f, -1.24598205e-01f, 1.83287352e-01f, 1.61091477e-01f, 6.04638159e-02f, 1.09950796e-01f, 1.70554191e-01f, 7.63778463e-02f, 5.88542409e-02f, 1.93052262e-01f,
  9.70019475e-02f, 4.88067307e-02f, 1.68628111e-01f, 9.92851555e-02f, 8.79337117e-02f, 1.41941877e-02f, 1.02368124e-01f, 7.78985471e-02f, -4.41977903e-02f, 1.02040812e-01f,
  5.94744757e-02f, 1.03899397e-01f, -4.25438248e-02f, -3.64848264e-02f, 2.69152224e-02f, 1.00448780e-01f, 1.03034280e-01f, 1.62711799e-01f, -7.59074744e-03f, 3.51393372e-01f,
  -1.31262794e-01f, -1.12722646e-02f, -1.29043311e-02f, -1.09252945e-01f, -3.48428227e-02f, -1.36570603e-01f, -8.49182010e-02f, -4.73297164e-02f, -4.24107760e-02f, -4.39382121e-02f,
  -1.23473085e-01f, -5.88038042e-02f, -9.58465412e-02f, -7.71610662e-02f, -4.89844419e-02f, -6.88878447e-02f, -7.25782569e-03f, -4.46517989e-02f, -8.81446451e-02f, -4.49116454e-02f,
  -1.07211776e-01f, -6.97880387e-02f, -3.31724286e-02f, -6.41299319e-03f, -6.00416921e-02f, -7.99624845e-02f, -2.47849734e-03f, -7.76625276e-02f, -7.87471682e-02f, -5.80856539e-02f,
  1.93148106e-01f, -1.83379740e-01f, 7.11622760e-02f, 1.44154295e-01f, 8.86647776e-02f, 5.17968647e-02f, 9.29147378e-02f, 1.49575502e-01f, 3.05932071e-02f, 1.28789037e-01f,
  5.77367358e-02f, 1.34984359e-01f, -1.23469941e-02f, 1.43667132e-01f, 1.46400183e-01f, 1.61220595e-01f, 1.12196125e-01f, 1.03255466e-01f, 2.18744343e-03f, 5.56388348e-02f,
  1.29752487e-01f, 3.33672203e-02f, 1.10783085e-01f, 8.20078850e-02f, 1.54052395e-02f, 2.33442783e-02f, 9.35714096e-02f, 1.49098754e-01f, 2.55314335e-02f, 2.87520915e-01f,
  3.18263829e-01f, -3.12533140e-01f, -2.47405022e-01f, -1.37878710e-03f, -1.40653178e-01f, -7.95636177e-02f, -3.02363694e-01f, -8.06462765e-02f, 1.87698752e-02f, -2.58802883e-02f,
  -2.09130093e-01f, 9.30126607e-02f, -5.96494228e-02f, -2.37764628e-03f, -3.75222862e-02f, -1.73267111e-01f, -2.18451358e-02f, 1.22062460e-01f, 2.29760513e-01f, 2.54545867e-01f,
  5.77202998e-02f, 2.11151496e-01f, 2.43441075e-01f, 1.84353441e-02f, -1.88823551e-01f, 2.89670452e-02f, -1.83887824e-01f, -1.30980030e-01f, -1.52973115e-01f, -9.23261046e-02f,
  -1.98359877e-01f, -1.57329351e-01f, 3.03142834e-02f, 1.22740157e-01f, -5.81290722e-02f, -3.55472453e-02f, -7.17968196e-02f, -6.57021850e-02f, -3.08290385e-02f, -5.34016080e-02f,
  -1.06217032e-02f, 4.12367322e-02f, -1.14741968e-03f, 1.44869620e-02f, 7.73893222e-02f, -2.32818560e-03f, 8.73341858e-02f, -5.88404061e-03f, 7.43317977e-02f, 5.64356684e-04f,
  -1.97338662e-03f, -3.15469168e-02f, 4.00077365e-03f, -2.73376331e-02f, -1.38710946e-01f, 6.06133894e-04f, -3.05658747e-02f, -9.95816961e-02f, -6.76263124e-02f, 2.64433175e-02f,
  5.21847717e-02f, -4.87087928e-02f, -5.95473200e-02f, -1.93515364e-02f, 1.72325298e-02f, 2.45199054e-02f, -5.48982657e-02f, 5.84109128e-02f, 2.00109687e-02f, 1.11515559e-02f,
  3.28603461e-02f, -2.07016636e-02f, 8.60769674e-02f, -1.69171523e-02f, 3.47595662e-02f, -4.42052148e-02f, 1.84245557e-02f, -3.13558057e-02f, 4.41451333e-02f, 8.75177756e-02f,
  -1.11458460e-02f, 6.02223128e-02f, -3.47888060e-02f, -3.45546715e-02f, 6.19146675e-02f, 6.43003434e-02f, 1.56319067e-01f, 2.20770445e-02f, -3.18932831e-02f, 4.39506657e-02f,
  1.29621074e-01f, 1.55928820e-01f, 1.17597161e-02f, 8.22773799e-02f, 5.22999391e-02f, 7.64033273e-02f, -7.87656978e-02f, 1.16448097e-01f, -9.24215838e-02f, 2.10345034e-02f,
  -2.53985096e-02f, -3.47250178e-02f, -1.36543647e-03f, -7.53483595e-03f, 6.48096576e-02f, 5.84333651e-02f, 9.76388529e-02f, 7.39724934e-02f, 7.56924693e-03f, -3.11695300e-02f,
  -1.84366982e-02f, 1.21206813e-01f, 1.13664173e-01f, -2.72710230e-02f, 1.10869065e-01f, 1.41762301e-01f, 2.58060377e-02f, 3.64664160e-02f, 1.26248881e-01f, 2.12308556e-01f,
  -4.68805730e-02f, 1.27568200e-01f, 3.04291606e-01f, -1.15192816e-01f, -8.57127756e-02f, 2.69869417e-02f, -9.73151252e-03f, -7.14711398e-02f, -1.54007450e-01f, -3.89210284e-02f,
  2.04005331e-01f, 9.52710658e-02f, 1.37718782e-01f, 2.30059978e-02f, 1.08451381e-01f, 2.30919868e-02f, 1.04090087e-02f, 6.18170127e-02f, 1.42522454e-02f, -1.25911817e-01f,
  -1.13417372e-01f, -3.05545256e-02f, 3.82688083e-02f, -7.37281665e-02f, -9.02898088e-02f, -2.91813239e-02f, 5.57986498e-02f, 7.91473687e-03f, 8.30121115e-02f, 1.48990294e-02f,
  2.77953833e-01f, 5.52566089e-02f, -2.50565540e-02f, -3.38744745e-02f, 3.92319933e-02f, -1.54394373e-01f, -9.62810293e-02f, -1.04563735e-01f, -4.65741269e-02f, -4.02878523e-02f,
  1.73743106e-02f, -4.35496606e-02f, -1.48671836e-01f, -4.24665548e-02f, -7.37835467e-02f, -1.46568015e-01f, -5.63195162e-02f, -2.54644584e-02f, -7.36776367e-02f, 1.89480521e-02f,
  -6.67419434e-02f, 3.38529944e-02f, -9.48209502e-03f, -9.27284732e-02f, 2.15895530e-02f, 5.03228866e-02f, -1.90633070e-02f, -2.85116583e-02f, -5.11699766e-02f, -4.34409454e-02f,
  -5.26957139e-02f, 1.47803321e-01f, 1.96544919e-02f, 9.50469747e-02f, 4.54399176e-02f, 3.61229219e-02f, 9.59358886e-02f, 7.56555423e-02f, 5.04946969e-02f, 7.75746033e-02f,
  1.24683809e-02f, 8.85854959e-02f, 1.98178329e-02f, 6.60487115e-02f, 1.55211359e-01f, 1.04294591e-01f, 2.06081197e-01f, 7.12912679e-02f, 1.25682801e-01f, -1.79591530e-03f,
  6.33186474e-02f, 1.58374593e-01f, 1.47275284e-01f, 1.11975297e-01f, 1.87429711e-01f, 1.98538229e-01f, 1.12552129e-01f, 4.75207791e-02f, -3.09295859e-02f, 8.38399772e-03f,
  -2.14691922e-01f, 1.25418633e-01f, -1.54669985e-01f, -1.43411309e-01f, -8.71368274e-02f, -3.49746319e-03f, 4.32755202e-02f, -8.66187811e-02f, 3.99143770e-02f, -1.25953123e-01f,
  -7.65716732e-02f, -8.06320161e-02f, 4.28239219e-02f, -1.04080811e-01f, -1.27920017e-01f, -9.41834822e-02f, -9.10058841e-02f, -3.27954106e-02f, -3.93239111e-02f, 1.95998494e-02f,
  -9.76806507e-02f, -7.08418339e-02f, 2.06880029e-02f, -9.75847617e-02f, -8.66464898e-02f, 3.24335769e-02f, -8.58936831e-03f, -4.23441119e-02f, 2.81186514e-02f, -1.43049166e-01f,
  -2.17054435e-03f, 3.52027446e-01f, 2.63013721e-01f, -1.08331159e-01f, 1.05042495e-01f, 6.67645410e-02f, 2.59820014e-01f, -2.04942420e-01f, -1.98885992e-01f, 1.72423571e-01f,
  1.66798890e-01f, -4.40591462e-02f, 1.42645733e-02f, 1.54889435e-01f, 9.65790898e-02f, 2.81848282e-01f, 1.46035850e-01f, 1.60109058e-01f, -7.04146624e-02f, -5.93676157e-02f,
  -2.50799023e-02f, 4.76591215e-02f, 8.14466253e-02f, -5.50009757e-02f, 1.12224333e-01f, -4.42789830e-02f, 1.44147068e-01f, 2.67670035e-01f, 3.13769311e-01f, 2.98516363e-01f,
  1.24294393e-01f, 2.06158906e-01f, -6.31931722e-02f, 7.01796636e-02f, 1.38545766e-01f, 5.37516475e-02f, 8.00848380e-02f, -1.12399245e-02f, 1.70515738e-02f, 2.61617675e-02f,
  1.02326185e-01f, 3.86824086e-02f, 1.61128610e-01f, 7.90725201e-02f, 1.36981219e-01f, 3.76343876e-02f, 1.11156665e-01f, 9.73885953e-02f, 2.32581180e-02f, 1.00565016e-01f,
  1.02536470e-01f, 2.76472598e-01f, 1.38402253e-01f, 5.64025417e-02f, 1.07101470e-01f, 9.84902829e-02f, 9.45266485e-02f, -6.22873148e-03f, 1.28329784e-01f, 4.31649573e-02f,
  -1.34875566e-01f, -1.22444198e-01f, 4.00374494e-02f, -4.84171808e-02f, 4.22931323e-03f, -3.14743668e-02f, -4.87322845e-02f, -9.13668573e-02f, -1.16488688e-01f, 1.33788073e-02f,
  -5.55374334e-03f, 4.50561233e-02f, -9.27191041e-03f, -1.33854255e-01f, -7.86284357e-02f, 4.32630479e-02f, -3.75990793e-02f, 4.31032106e-02f, -7.30915964e-02f, -1.09932378e-01f,
  -6.02563061e-02f, -5.31297512e-02f, -1.06490880e-01f, 9.87004489e-03f, -2.25457642e-02f, 9.12301242e-03f, -2.07426399e-02f, -1.42480396e-02f, -4.67184931e-02f, -1.28639460e-01f,
  -1.58664852e-01f, 2.51827240e-01f, -6.99701533e-02f, -4.45532203e-02f, 1.79991182e-02f, -4.21704091e-02f, 5.34548499e-02f, 1.35603603e-02f, 1.85480341e-02f, -2.75637209e-02f,
  1.00524187e-01f, -3.99359874e-02f, 1.66483223e-01f, 3.80225433e-03f, 2.59496123e-02f, -4.51609045e-02f, 8.58510807e-02f, 4.11463790e-02f, 7.87503943e-02f, 1.17442876e-01f,
  3.80146652e-02f, 7.18765855e-02f, -2.43521608e-05f, -1.81032028e-02f, -4.85959314e-02f, -4.28820513e-02f, 5.02295792e-02f, -8.55662003e-02f, -4.24918085e-02f, -7.28693381e-02f,
  4.02546436e-01f, 1.71401247e-01f, 6.23844750e-02f, 5.39131686e-02f, 1.24712847e-01f, 1.42066538e-01f, 3.03877741e-01f, 2.14181289e-01f, -3.08946869e-03f, 6.43759668e-02f,
  2.05199167e-01f, 1.09815359e-01f, 5.58068231e-02f, -7.96368159e-03f, -2.66086180e-02f, -4.09545898e-02f, -1.70019105e-01f, 1.90943517e-02f, -3.53425625e-03f, 1.17538027e-01f,
  -3.85427214e-02f, 5.28494306e-02f, 6.65990310e-03f, -6.73416853e-02f, -1.05987884e-01f, -6.26307651e-02f, -7.54593983e-02f, 1.02878943e-01f, -4.62433137e-02f, -1.35717154e-01f,
  1.53284043e-01f, 1.94760174e-01f, 9.40293893e-02f, 1.19054206e-01f, 4.60510999e-02f, 1.14932612e-01f, 1.13010734e-01f, 8.43349621e-02f, 1.25628531e-01f, 2.16863826e-02f,
  1.16294749e-01f, 7.93445706e-02f, 2.37254091e-02f, 1.16503850e-01f, 1.00824445e-01f, 1.01059400e-01f, 3.43435220e-02f, 4.85130176e-02f, 6.99049011e-02f, 1.74274072e-01f,
  1.37633204e-01f, 1.97417572e-01f, 2.16429353e-01f, 1.58126503e-01f, 8.80390257e-02f, 7.64720421e-03f, 1.63097426e-01f, 1.12783782e-01f, 7.72859454e-02f, 5.64464144e-02f,
  -2.77732089e-02f, -5.61332852e-02f, -4.71306220e-02f, -7.82722011e-02f, -1.55055868e-02f, -1.39589384e-01f, -1.00599095e-01f, -6.26710877e-02f, -7.58575350e-02f, -7.60555044e-02f,
  -3.80438380e-02f, -4.05986123e-02f, -3.30777243e-02f, -1.04767278e-01f, -3.15833129e-02f, -1.35873437e-01f, -3.75430658e-02f, -5.20130359e-02f, -1.01473652e-01f, -8.61756727e-02f,
  -5.55732064e-02f, -1.32344782e-01f, -6.60931319e-02f, -4.21237051e-02f, -1.11620143e-01f, -3.92686352e-02f, -1.41259715e-01f, -4.47806269e-02f, -4.22973223e-02f, -1.35285020e-01f,
  1.78941667e-01f, 2.52081096e-01f, 1.05131023e-01f, 4.20120992e-02f, 1.05297759e-01f, 1.08794004e-01f, 1.34521917e-01f, 5.78336120e-02f, 1.24846771e-01f, 6.69253021e-02f,
  5.48474751e-02f, 1.18095651e-01f, 1.35155827e-01f, 9.24077183e-02f, 1.55358836e-01f, 3.93205285e-02f, 1.41165376e-01f, 1.66719913e-01f, 2.28708293e-02f, 1.39575198e-01f,
  1.73993200e-01f, 1.84175193e-01f, 2.01451018e-01f, 9.85949188e-02f, 2.09095985e-01f, 2.07996950e-01f, 1.14788286e-01f, 2.31264099e-01f, 1.34566739e-01f, 2.38147974e-01f,
  -1.60364076e-01f, -2.74119496e-01f, 2.32559905e-04f, 1.09312087e-02f, -3.20931850e-03f, -7.23146833e-03f, -1.91686168e-01f, -1.68783024e-01f, 6.24269582e-02f, -1.15246229e-01f,
  -1.33943051e-01f, 7.26549104e-02f, -4.75832038e-02f, 1.00469068e-01f, 3.08456365e-02f, -4.59669083e-02f, 2.03221604e-01f, 1.56403348e-01f, 1.68344185e-01f, 8.31899270e-02f,
  2.52563447e-01f, 1.00069903e-01f, 5.76549992e-02f, 5.27314097e-02f, 3.14433388e-02f, 9.31152999e-02f, -6.85398281e-02f, 6.66686893e-02f, 9.05659888e-03f, 1.11412734e-01f,
  -1.20678894e-01f, -2.99100667e-01f, 4.08465043e-02f, 6.63156286e-02f, 3.46650090e-03f, -1.34026241e-02f, 1.77137193e-03f, 3.54350246e-02f, 3.77735216e-03f, 1.91682428e-02f,
  -1.07725695e-01f, -3.87101993e-02f, -1.48681894e-01f, 3.24586034e-02f, -1.52668739e-02f, -6.57269508e-02f, 1.04529727e-02f, -4.19637747e-02f, 5.05274571e-02f, -7.51373619e-02f,
  6.45360127e-02f, -1.44966364e-01f, -1.49865896e-01f, -9.15417448e-02f, -1.48858443e-01f, 4.14832570e-02f, -1.86721355e-01f, -8.86563677e-03f, -1.44052893e-01f, 2.82357931e-02f,
  6.83501437e-02f, 1.11578509e-01f, -2.10747737e-02f, -1.16681449e-01f, -9.64862108e-02f, 1.79970395e-02f, 1.62983164e-02f, 4.70404467e-03f, -4.59714308e-02f, -5.57302758e-02f,
  -1.07780077e-01f, -6.06095567e-02f, -1.00633606e-01f, -2.33631507e-02f, 8.42114538e-02f, -8.03183541e-02f, -2.48212200e-02f, 8.94665718e-02f, -5.80410212e-02f, 5.63843059e-04f,
  -5.75807355e-02f, 1.77014209e-02f, -1.77290924e-02f, -4.74521965e-02f, -2.66113151e-02f, -6.38912395e-02f, 9.69016850e-02f, -6.83036000e-02f, 1.62711018e-03f, -2.23689359e-02f,
  6.27295226e-02f, -1.39050337e-03f, 1.25327464e-02f, -5.70640042e-02f, -1.01021923e-01f, -2.45208759e-03f, -2.80417465e-02f, -2.51399297e-02f, -4.65499796e-02f, -5.93400337e-02f,
  -7.87682682e-02f, -6.76156655e-02f, -9.93431881e-02f, -7.70998327e-03f, 3.45412605e-02f, -8.04210231e-02f, 4.23909239e-02f, 4.35252227e-02f, 6.05079643e-02f, 3.05566248e-02f,
  8.52641314e-02f, 5.33805415e-02f, 1.12573085e-02f, 4.87931725e-03f, -5.72473146e-02f, 1.06183060e-01f, -5.11820130e-02f, -7.49958530e-02f, 7.72648826e-02f, -8.68684985e-03f,
  -2.24525809e-01f, 1.78953618e-01f, -1.22381493e-01f, 1.48173630e-01f, 7.58849680e-02f, 6.47467002e-02f, 1.20740011e-01f, -2.42740079e-03f, -1.20069860e-02f, -7.07107559e-02f,
  -2.18373656e-01f, -2.76491702e-01f, -1.39104262e-01f, -2.60261863e-01f, -1.45160779e-01f, 5.03516346e-02f, 2.36558676e-01f, -9.12280455e-02f, -2.92987794e-01f, -1.20155662e-01f,
  -4.19036783e-02f, 4.29494083e-02f, -1.35873184e-01f, -4.79518585e-02f, 1.51782492e-02f, -2.82769348e-03f, 3.40236239e-02f, 5.42367063e-02f, -1.12410106e-01f, 1.50828868e-01f,
  -3.22856694e-01f, -1.76294416e-01f, -4.87952009e-02f, -1.07231371e-01f, -9.18214023e-02f, -1.34965271e-01f, -5.62469065e-02f, -6.07778691e-02f, -7.78878992e-03f, 2.78318319e-02f,
  -1.61346659e-01f, -9.08837765e-02f, -5.07515743e-02f, -1.60996243e-01f, -2.46498715e-02f, -1.32113054e-01f, 2.66891010e-02f, -1.21173091e-01f, -1.04364961e-01f, -1.42921180e-01f,
  -6.83222758e-03f, -2.09997389e-02f, -2.27564424e-02f, -1.26569137e-01f, -1.67614251e-01f, -2.34187663e-01f, -1.43929794e-01f, -1.84407711e-01f, -1.74174204e-01f, 4.52704616e-02f,
  7.31911436e-02f, 6.24759756e-02f, 7.83682242e-02f, 1.18340246e-01f, 1.89735115e-01f, 1.10595159e-01f, 1.23084143e-01f, 6.14531897e-02f, 1.11091740e-01f, 5.79866730e-02f,
  3.64892324e-03f, 9.81329829e-02f, 1.14690745e-02f, 5.23613431e-02f, 1.26977384e-01f, 6.37513101e-02f, 1.33795962e-01f, 1.27329454e-01f, 1.63938049e-02f, 6.28862381e-02f,
  4.44490574e-02f, 2.07185391e-02f, 6.27634227e-02f, 2.41438150e-02f, 1.10264704e-01f, 9.66856033e-02f, 1.36512801e-01f, 7.85559714e-02f, 7.09227175e-02f, 8.29446167e-02f,
  -1.25608802e-01f, -1.22994862e-01f, -7.26270899e-02f, -1.53624848e-01f, -1.03601955e-01f, -7.31243100e-03f, -1.58677280e-01f, -6.39901608e-02f, -4.90791444e-03f, -1.80033430e-01f,
  -7.88955018e-02f, -1.11129902e-01f, -4.52646725e-02f, -7.30495080e-02f, -7.16018975e-02f, -1.18500978e-01f, -2.15103123e-02f, -8.35034922e-02f, -5.91280572e-02f, -3.85763831e-02f,
  -2.05995589e-02f, 1.48081686e-03f, -3.01418379e-02f, -9.19500962e-02f, -1.49974793e-01f, -1.84324548e-01f, -1.11991614e-01f, 2.06130780e-02f, -2.71720011e-02f, 1.12624884e-01f,
  -2.95977503e-01f, -2.22389638e-01f, -2.52432674e-01f, -6.68278337e-02f, -1.02356501e-01f, -1.16645560e-01f, -1.15904190e-01f, 6.80920929e-02f, 1.86809506e-02f, -9.94732678e-02f,
  -8.84346291e-02f, 1.41858608e-01f, 1.26504079e-01f, 2.42789891e-02f, 2.23523695e-02f, -1.64860524e-02f, -1.49089798e-01f, -1.41920924e-01f, -8.25773925e-02f, -2.31221125e-01f,
  -2.34647438e-01f, -2.16224447e-01f, -1.65987283e-01f, -2.55796969e-01f, -1.69000223e-01f, -1.54474005e-01f, -2.04414696e-01f, -3.44520867e-01f, -2.83881426e-01f, -3.60885590e-01f,
  -5.59179038e-02f, -2.65291899e-01f, 5.96676432e-02f, -1.52325630e-01f, -7.80978948e-02f, -6.50513619e-02f, -4.28710617e-02f, -1.75907314e-01f, -1.90544561e-01f, -2.19059139e-01f,
  -1.41588107e-01f, -7.14037195e-02f, -3.32828090e-02f, -1.67225078e-01f, -2.00119004e-01f, -1.43326327e-01f, -1.66005433e-01f, -1.20211020e-01f, -8.28556791e-02f, -2.76889838e-02f,
  -8.28940049e-02f, -1.97159499e-01f, -1.29791453e-01f, -1.78201303e-01f, -1.17669009e-01f, -1.85049027e-01f, -1.28143206e-01f, -2.13223740e-01f, -1.36755645e-01f, -2.63287425e-01f,
  -5.92486002e-03f, -4.65041818e-03f, 6.47445247e-02f, 1.15916051e-01f, 4.59829383e-02f, 1.51717737e-01f, 1.03047363e-01f, -1.33539177e-02f, 1.38779104e-01f, 7.89931417e-02f,
  1.55542761e-01f, 8.36391151e-02f, 1.44271567e-01f, 9.57952812e-02f, 1.71866030e-01f, 7.04493746e-02f, 1.20821536e-01f, 1.98676035e-01f, 9.88248810e-02f, 2.01525882e-01f,
  1.67170241e-01f, 3.87501493e-02f, 7.56761357e-02f, 6.40425384e-02f, 1.11861683e-01f, 6.90019056e-02f, 1.62413210e-01f, 2.06294894e-01f, 2.39004597e-01f, 2.13816836e-02f,
  1.17226020e-01f, -3.33666280e-02f, -6.35664538e-02f, -1.28523380e-01f, -1.63994297e-01f, -9.35627297e-02f, -1.46423131e-01f, -1.55939475e-01f, -2.85897627e-02f, -5.55589907e-02f,
  -1.47486463e-01f, -4.53073494e-02f, -5.15850857e-02f, -1.19494766e-01f, -7.50920027e-02f, -5.51885255e-02f, -1.27979964e-01f, -4.52091657e-02f, -1.13154076e-01f, -1.07893862e-01f,
  -8.53982791e-02f, -1.87744290e-01f, -6.06251359e-02f, -7.13423640e-02f, -1.59969345e-01f, -2.46495809e-02f, -8.50889310e-02f, -5.62069751e-02f, 2.24719569e-02f, -1.78624570e-01f,
  5.37832081e-01f, -2.04175711e-02f, -2.68985391e-01f, 7.67221078e-02f, 8.91741663e-02f, -1.91382747e-02f, 1.81876287e-01f, 2.02573121e-01f, 1.96447149e-01f, 5.76028740e-03f,
  8.19158107e-02f, 1.05577894e-01f, 1.61300957e-01f, 5.83759733e-02f, 1.35592610e-01f, -4.04951572e-02f, -1.54976919e-01f, 7.74992034e-02f, 3.76717672e-02f, 2.43046600e-02f,
  1.15450799e-01f, 8.86184275e-02f, 1.66474998e-01f, -9.36545432e-03f, 9.32133384e-03f, 7.89447315e-03f, -1.68391541e-01f, -1.03675842e-01f, -1.51231438e-01f, -1.92105427e-01f,
  -1.66471228e-01f, 9.23199877e-02f, -3.49602604e-04f, 4.32552882e-02f, -1.54250115e-01f, 4.47041988e-02f, 8.13556314e-02f, -3.40600945e-02f, -8.85923859e-03f, 4.55008820e-02f,
  -4.27840613e-02f, -1.13232974e-02f, -1.43250031e-02f, -5.62999211e-02f, -4.06793901e-04f, 4.13682833e-02f, -7.69431889e-02f, 3.11190113e-02f, 6.00284860e-02f, 1.11856004e-02f,
  -1.10990912e-01f, -7.05510005e-02f, 1.14573225e-01f, 3.03295497e-02f, 1.03204744e-02f, -3.10566593e-02f, -4.52058353e-02f, 5.04973419e-02f, -6.26275912e-02f, 1.22043386e-01f,
  2.82625426e-02f, -9.56848934e-02f, 4.98962514e-02f, -1.87941659e-02f, 5.57299256e-02f, 6.20558709e-02f, -7.75085166e-02f, -3.64295319e-02f, 6.29475266e-02f, 8.16505328e-02f,
  5.34795187e-02f, -7.73073733e-02f, 2.49798167e-02f, 4.62197773e-02f, 2.72346810e-02f, -3.87836732e-02f, -7.78254196e-02f, -2.50676870e-02f, -8.23050663e-02f, -7.17359111e-02f,
  -1.09694479e-02f, -2.72847917e-02f, -6.08591773e-02f, 1.24674747e-02f, -9.21431333e-02f, -3.33121009e-02f, -5.02423570e-02f, -4.49320264e-02f, 3.47888423e-03f, -3.03151980e-02f,
  1.82640746e-01f, 1.09986767e-01f, 2.51027104e-02f, 1.10884808e-01f, -6.28683530e-03f, -8.96259025e-02f, 2.97078583e-02f, -5.22877350e-02f, -2.43637469e-02f, 8.52956921e-02f,
  4.82179597e-02f, 4.14866880e-02f, 8.91026706e-02f, -5.79054542e-02f, 2.33807676e-02f, 1.31623656e-01f, 6.19159602e-02f, 6.72011524e-02f, -6.16450086e-02f, -7.74667263e-02f,
  5.06463721e-02f, 1.42769486e-01f, 1.38807252e-01f, 1.51249897e-02f, 4.70679812e-02f, 2.33129084e-01f, 5.26475683e-02f, 1.69691294e-01f, 1.68455511e-01f, 2.58386999e-01f,
  9.47648510e-02f, 7.95469508e-02f, 1.40215158e-01f, -4.67863716e-02f, 7.21584037e-02f, 1.93400249e-01f, 3.95974129e-01f, 2.08879650e-01f, 6.65968433e-02f, 1.21619534e-02f,
  -2.04487041e-01f, -2.07342982e-01f, -1.98847860e-01f, -1.52608687e-02f, 6.08996525e-02f, 3.24399561e-01f, 2.67675936e-01f, 1.86994746e-01f, 1.89053237e-01f, 1.08666033e-01f,
  7.74369687e-02f, -4.95338887e-02f, -2.29185596e-02f, -5.14144748e-02f, -7.78711215e-02f, -3.72904427e-02f, -2.09915470e-02f, 1.11259669e-01f, 1.07674383e-01f, 1.72329485e-01f,
  -3.07104271e-02f, 2.93581814e-01f, -2.06262991e-03f, -3.58919874e-02f, 2.37650350e-02f, 3.60104777e-02f, 1.54357806e-01f, 4.37989049e-02f, 3.79933305e-02f, -8.79841018e-03f,
  -2.94946432e-02f, 8.23832899e-02f, 2.26170868e-02f, 1.29400611e-01f, 1.59996301e-01f, 1.57503247e-01f, 6.19737208e-02f, 1.41784877e-01f, 1.09618932e-01f, 1.10826746e-01f,
  1.09357186e-01f, 1.65276021e-01f, 1.37640715e-01f, 1.51764542e-01f, 9.70120579e-02f, 4.37501930e-02f, 1.12526141e-01f, 1.53463259e-01f, 8.29929039e-02f, 1.00447156e-01f,
  -5.80721684e-02f, -7.06095174e-02f, -3.44245397e-02f, -2.55160108e-02f, -5.27388006e-02f, -4.52669337e-02f, -5.97837977e-02f, -6.21359572e-02f, 6.04184205e-03f, -1.21602617e-01f,
  -5.63048944e-02f, -2.06157640e-02f, -5.61126024e-02f, 8.73496477e-03f, -1.12295076e-01f, -2.90113147e-02f, 2.02649646e-02f, -1.06196560e-01f, -4.06078342e-03f, 1.28200734e-02f,
  -6.92687056e-04f, 7.63103291e-02f, -1.80351231e-02f, -9.77196246e-02f, 5.52157834e-02f, 2.10264921e-02f, 1.61900595e-02f, -3.51190418e-02f, -7.17747062e-02f, -2.00273786e-02f,
  -2.48329148e-01f, 4.41712216e-02f, -3.00546009e-02f, 1.09386943e-01f, 9.14060026e-02f, 6.55069426e-02f, -1.16061248e-01f, 2.46093012e-02f, 2.39634477e-02f, 1.08700834e-01f,
  1.15123160e-01f, 9.68172494e-03f, 3.51222903e-02f, 5.69829307e-02f, 1.08692691e-01f, 9.67926383e-02f, 8.16827044e-02f, 8.50799531e-02f, 1.05955005e-02f, 9.42948926e-03f,
  7.91813340e-03f, 8.28784853e-02f, -7.68290320e-03f, 8.37374032e-02f, 1.29316524e-01f, 9.71444547e-02f, 9.85742267e-03f, 2.09024660e-02f, 1.68794215e-01f, -1.27054406e-02f,
  -3.24991554e-01f, -3.08263630e-01f, 2.71379929e-02f, -1.87082574e-01f, -3.03434521e-01f, -1.39701769e-01f, -3.48633140e-01f, -1.51397169e-01f, -1.47980556e-01f, -1.50358811e-01f,
  -4.66464497e-02f, 1.57603189e-01f, 2.46510610e-01f, 2.59323627e-01f, 2.13312224e-01f, -2.18807310e-01f, -5.35331480e-02f, 1.57775775e-01f, 1.26274884e-01f, -9.25458148e-02f,
  -1.50249168e-01f, -1.59276500e-01f, -4.60158009e-03f, -3.06090098e-02f, -1.67743772e-01f, -6.45227581e-02f, -1.22637466e-01f, -1.83280498e-01f, -9.34005752e-02f, -2.40920380e-01f,
  5.79735450e-02f, -1.11344084e-01f, 1.45775080e-01f, 1.91021934e-02f, -9.41046253e-02f, 5.46320006e-02f, -1.07678756e-01f, -3.00709866e-02f, 3.65239903e-02f, -1.09307282e-01f,
  -2.45596841e-02f, -7.07058758e-02f, -3.61671038e-02f, 5.73263364e-03f, 1.26029430e-02f, -8.99877474e-02f, 4.93947126e-04f, 5.20484373e-02f, 4.22300883e-02f, -1.75334513e-02f,
  -3.16284336e-02f, -1.70492113e-01f, -9.24710631e-02f, -5.57013936e-02f, 1.13016538e-01f, 6.13191053e-02f, 1.09352656e-02f, 2.33083870e-02f, -1.74193792e-02f, -9.20652002e-02f,
  2.35206746e-02f, 2.19438635e-02f, 5.18174507e-02f, 2.35826839e-02f, -4.93488312e-02f, -4.48727980e-03f, 1.70330442e-02f, -5.89716509e-02f, -1.31935636e-02f, -8.46070424e-03f,
  8.12318102e-02f, 3.21074352e-02f, 9.11484584e-02f, 1.49859190e-02f, -8.01265799e-03f, -1.31206764e-02f, -2.49002036e-02f, -1.51856076e-02f, 1.58232395e-02f, 2.06987374e-02f,
  8.89522359e-02f, 1.02986908e-03f, 3.47430333e-02f, 1.78380497e-02f, 2.75482796e-02f, -1.83163676e-02f, 1.29775479e-02f, 6.04004115e-02f, 6.78726519e-03f, 5.56016527e-03f,
  1.21693663e-01f, 9.52466205e-02f, -5.89306140e-03f, -5.27033233e-04f, -2.57407576e-02f, -1.01427115e-01f, -7.11211516e-03f, -7.91851676e-07f, -1.10435575e-01f, -1.06416056e-02f,
  -1.18348952e-02f, 5.77835413e-03f, -7.90380090e-02f, -4.03521489e-03f, -5.51015511e-02f, -8.96500573e-02f, -8.50537419e-02f, -2.22461559e-02f, -1.93283912e-02f, -6.35599345e-02f,
  -1.84728384e-01f, -2.22087741e-01f, -1.14830807e-01f, -1.21245757e-01f, -1.45157441e-01f, -1.07628681e-01f, -8.46614093e-02f, -6.90002292e-02f, -1.41251653e-01f, -2.74431825e-01f,
  6.88809007e-02f, 5.98102622e-02f, -1.59607917e-01f, -2.57227153e-01f, -1.55418485e-01f, -8.48928913e-02f, -9.25423577e-02f, -6.35370389e-02f, -5.72907105e-02f, -4.00675125e-02f,
  -6.37856266e-03f, -5.48259430e-02f, 1.71452574e-02f, 3.35488804e-02f, -1.43799083e-02f, 1.57401729e-02f, -5.69385700e-02f, 7.97544643e-02f, -6.51678517e-02f, -1.95800122e-02f,
  -1.29014865e-01f, 1.22411018e-02f, 6.82327002e-02f, 3.43034230e-02f, -1.17798753e-01f, -7.54329041e-02f, -4.95392531e-02f, -1.44036040e-02f, -1.65759660e-02f, -5.37961163e-02f,
  -2.18453556e-01f, 2.45866463e-01f, -5.50364926e-02f, 2.03260276e-02f, -4.65232991e-02f, 8.88613909e-02f, 1.73195601e-02f, 7.91230649e-02f, 8.35482106e-02f, -4.99512926e-02f,
  -3.00376266e-02f, -5.55943921e-02f, -6.22989535e-02f, -5.58472387e-02f, -9.02655348e-02f, 5.75794652e-02f, -1.83666758e-02f, 7.24329203e-02f, 5.56869097e-02f, 8.49047899e-02f,
  9.25407559e-03f, -9.54945460e-02f, 6.42960519e-02f, 9.09355003e-03f, 8.99827182e-02f, -9.50324759e-02f, 1.16018698e-01f, -9.56712943e-03f, 1.33672962e-02f, -9.75169521e-03f,
  -3.79619710e-02f, 4.64841053e-02f, -7.53332451e-02f, 1.16800312e-02f, -4.25940976e-02f, -3.10528297e-02f, -1.18171185e-01f, 3.03902812e-02f, -7.13855177e-02f, 4.10857536e-02f,
  2.62300242e-02f, -6.01074956e-02f, -2.45966036e-02f, -7.65948966e-02f, -3.17286402e-02f, -1.44571349e-01f, -1.36505291e-01f, -8.78522024e-02f, -3.24655883e-02f, -2.89964098e-02f,
  -1.18240498e-01f, -1.06003797e-02f, -1.70412034e-01f, -5.72847389e-02f, 2.84645762e-02f, -1.02250636e-01f, 1.76116508e-02f, -4.44215126e-02f, -9.13162902e-02f, -7.44481385e-02f,
  -2.16035172e-01f, 1.44818619e-01f, -3.30820866e-02f, 2.16428023e-02f, -1.66622713e-01f, 9.52730514e-03f, -8.14745873e-02f, -6.09278418e-02f, -4.94984947e-02f, -5.58321029e-02f,
  1.79426856e-02f, -9.87150054e-03f, -6.22074259e-03f, -4.83939424e-02f, -1.18093090e-02f, -8.16493332e-02f, -6.26582727e-02f, -1.27849102e-01f, -3.86120342e-02f, -6.93205371e-02f,
  -9.61844325e-02f, -1.18756101e-01f, -1.54145539e-01f, -7.24236369e-02f, 1.06931813e-02f, -4.31826375e-02f, -1.25158830e-02f, -3.90292555e-02f, -1.00830598e-02f, -9.21375081e-02f,
  4.56981301e-01f, 8.75202045e-02f, -1.77365169e-01f, 1.34200454e-01f, -3.12850386e-01f, -3.74713063e-01f, -3.55033368e-01f, -5.13923988e-02f, 6.63123801e-02f, 1.33344624e-02f,
  8.65576938e-02f, 1.65189117e-01f, 2.63643324e-01f, 1.78282633e-01f, 1.24530263e-01f, -2.26100713e-01f, -2.26490930e-01f, 5.18361777e-02f, -4.45303805e-02f, -9.58389193e-02f,
  -1.56145934e-02f, 1.09072827e-01f, 1.69467732e-01f, 1.20148174e-01f, -3.20257582e-02f, 1.10313222e-01f, 3.72081287e-02f, -7.69462669e-03f, -6.85225427e-02f, -1.98144093e-02f,
  5.48304096e-02f, -1.53643951e-01f, -4.59465533e-02f, 4.38711122e-02f, -1.83348805e-02f, -6.27519935e-03f, -4.82717045e-02f, -2.27873866e-02f, 2.54947897e-02f, 1.03729162e-02f,
  6.84165284e-02f, 7.17227161e-03f, -3.11209857e-02f, -8.17499012e-02f, -9.95015353e-02f, -9.89688262e-02f, 7.65355825e-02f, 2.89980602e-02f, 9.14841592e-02f, 2.72399522e-02f,
  -6.20037410e-03f, -1.20906956e-01f, -5.63119352e-02f, -5.85118383e-02f, 4.34164479e-02f, 9.26853064e-03f, -5.90571463e-02f, -3.70743610e-02f, -7.08306208e-02f, 9.65960771e-02f,
  9.53276735e-03f, 4.82243523e-02f, 2.59422045e-02f, 7.09288046e-02f, 1.06447048e-01f, 1.35405883e-02f, 5.91550283e-02f, -3.12612839e-02f, -1.18540963e-02f, 8.23155865e-02f,
  -5.85488323e-03f, 1.63772632e-03f, 5.71624525e-02f, 1.15637988e-01f, 6.06984422e-02f, 1.27326949e-02f, 7.96766281e-02f, 8.13692063e-02f, 5.70255623e-04f, 1.12027027e-01f,
  -1.45591227e-02f, 2.52228137e-02f, 1.06484950e-01f, 7.28825331e-02f, 1.35832960e-02f, 1.24240331e-01f, 5.27279079e-03f, 5.73993661e-02f, 7.79382065e-02f, -6.87964028e-03f,
  2.71214336e-01f, -6.73507079e-02f, 5.39109185e-02f, 1.21464804e-01f, -6.24594614e-02f, 3.82372998e-02f, -9.08050872e-03f, 4.79379706e-02f, 3.84151726e-03f, -8.39883983e-02f,
  -9.06809121e-02f, 6.27264678e-02f, 2.92248442e-03f, -4.77400012e-02f, -5.88585548e-02f, -4.14801985e-02f, -4.54102084e-02f, 8.00293684e-03f, 3.64082232e-02f, -2.29614712e-02f,
  4.70155012e-03f, -1.47295177e-01f, -1.45611225e-03f, -3.94117758e-02f, 1.36139365e-02f, -6.05928451e-02f, -2.85671875e-02f, -5.93664460e-02f, 6.36426806e-02f, 1.46057010e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.54983115e-01f, -8.58902454e-01f, 6.24412000e-01f, 3.82248424e-02f, -1.30990371e-01f, 1.25809107e-02f, -3.36702675e-01f, 2.99249403e-02f, 4.15012091e-02f, -2.85556763e-01f,
  -6.72037542e-01f, -5.45731544e-01f, -4.73878741e-01f, -1.36878654e-01f, -9.50355381e-02f, 1.56880200e-01f, 4.49995518e-01f, 6.03327692e-01f, 5.70266902e-01f, 1.81049407e-01f,
  -2.35771388e-01f, 1.97942361e-01f, 3.47896993e-01f, 2.17579737e-01f, -6.55718297e-02f, -2.64333747e-02f, 7.11394250e-02f, -9.06483456e-02f, -2.06174254e-01f, 9.19167697e-02f,
  -2.65799537e-02f, -2.25686967e-01f, 1.70895606e-01f, -2.63160408e-01f, -1.83855698e-01f, 2.22347584e-02f, -1.43482713e-02f, 4.17068042e-02f, -1.34590879e-01f, 6.76065311e-02f,
  -1.40379280e-01f, -3.21132578e-02f, -4.63726632e-02f, -8.51771981e-02f, 6.36696070e-02f, 1.41213788e-02f, -3.41255106e-02f, 2.45673209e-03f, -7.24328160e-02f, -9.10440907e-02f,
  -2.02361152e-01f, -3.83899584e-02f, 3.49216498e-02f, -1.39923498e-01f, -1.20208852e-01f, -7.34035000e-02f, -1.06447868e-01f, -1.31549593e-02f, 1.93457883e-02f, 3.35679762e-02f,
  1.77159563e-01f, -2.35299729e-02f, -9.20915902e-02f, 7.92018231e-03f, -9.71158519e-02f, -2.72206441e-02f, -1.07059501e-01f, -1.30476892e-01f, -2.85339653e-02f, 8.97055585e-03f,
  -7.34905899e-02f, -5.00150844e-02f, -3.91016714e-02f, -5.76813146e-02f, 9.06434283e-03f, -9.98617485e-02f, -4.54816185e-02f, -5.86618558e-02f, -1.23678837e-02f, -7.86210373e-02f,
  -5.57050817e-02f, -4.34590243e-02f, -1.02861486e-02f, 5.78561574e-02f, -4.40988243e-02f, 4.82510068e-02f, -5.05050272e-02f, -1.36362061e-01f, -2.86395736e-02f, -1.46921486e-01f,
  -3.74787092e-01f, -8.04996118e-02f, 2.91056745e-02f, -9.57718212e-03f, -3.92086208e-02f, -5.54485247e-02f, -2.26990916e-02f, -6.97676912e-02f, -8.86526033e-02f, 1.22495145e-01f,
  -6.98891133e-02f, 3.08407210e-02f, -1.57505851e-02f, 4.06734552e-03f, 9.83354002e-02f, 2.01383196e-02f, -1.80100694e-01f, -1.15186833e-02f, -6.83068186e-02f, 6.33710027e-02f,
  6.93952804e-03f, 1.02291688e-01f, 1.57336995e-01f, 2.49115136e-02f, -5.23524098e-02f, 2.24394962e-01f, 1.62856683e-01f, 1.36301696e-01f, 1.52097210e-01f, 1.54099792e-01f,
  1.15633583e+00f, 6.64790943e-02f, -1.01135135e+00f, 2.44071245e-01f, -6.96729183e-01f, -5.61479509e-01f, -2.66432315e-01f, 3.21048021e-01f, 8.98323581e-02f, -2.92154431e-01f,
  -3.92132550e-01f, -1.41505301e-01f, -2.97706455e-01f, 2.51531657e-02f, 3.17197055e-01f, -2.47073382e-01f, -3.41962516e-01f, -1.66488275e-01f, 9.86367688e-02f, 3.59397173e-01f,
  1.95799544e-01f, 4.54183877e-01f, 5.54472923e-01f, 2.29787931e-01f, 4.57856385e-03f, -1.00029051e-01f, -4.63420093e-01f, -1.31312117e-01f, -2.05158398e-01f, -3.08134586e-01f,
  -4.30473626e-01f, 2.10024953e-01f, -2.60434777e-01f, 7.61756450e-02f, -2.89135247e-01f, 1.65971488e-01f, 8.76538157e-02f, 2.39327997e-02f, 2.05085780e-02f, -9.49860513e-02f,
  -2.76470095e-01f, -1.23272024e-01f, -1.63185120e-01f, -1.80144206e-01f, 1.62620038e-01f, 5.82906380e-02f, 5.13593145e-02f, 2.48927951e-01f, 4.43832688e-02f, -2.92847678e-02f,
  -1.08470075e-01f, -2.93420166e-01f, -3.65391225e-01f, -2.04039499e-01f, 8.57267603e-02f, -2.42299154e-01f, -1.79859221e-01f, 8.53104964e-02f, -1.31342262e-01f, 2.42909595e-01f,
  9.42220504e-04f, -9.24685746e-02f, -1.22735113e-01f, 6.96596801e-02f, 1.62482798e-01f, -1.72681972e-01f, 4.61324081e-02f, 4.87580970e-02f, -3.78464833e-02f, 3.56059596e-02f,
  6.30685836e-02f, -3.97706330e-02f, -9.50152241e-03f, -3.21522541e-02f, -7.30358064e-02f, -9.92494822e-02f, -2.33262125e-02f, 3.15092839e-02f, 2.56677400e-02f, 6.17365167e-02f,
  8.38882700e-02f, -5.63657209e-02f, -4.78213727e-02f, 9.48359966e-02f, -6.93917722e-02f, -1.34491269e-02f, -7.54569396e-02f, 1.69410743e-02f, 1.19649291e-01f, -6.62950650e-02f,
  1.46764979e-01f, -4.51931566e-01f, 3.73715535e-02f, 1.10615052e-01f, -1.24231048e-01f, -1.54285342e-01f, -1.36952877e-01f, -2.39172410e-02f, -4.21359856e-03f, -3.40473577e-02f,
  -1.44256987e-02f, 8.18805173e-02f, -1.14670977e-01f, -1.55670121e-02f, 4.94089462e-02f, -9.41500813e-02f, 1.48801252e-01f, -6.91390261e-02f, 3.51951160e-02f, -7.31329396e-02f,
  2.75881030e-02f, 5.23901582e-02f, 2.11161539e-01f, -9.83728096e-02f, 8.27128068e-02f, -5.23410328e-02f, -1.83516487e-01f, -1.33414254e-01f, -1.03538014e-01f, 2.66292572e-01f,
  -3.62420604e-02f, 2.40277365e-01f, 2.24280268e-01f, -1.23198619e-02f, -1.79222062e-01f, -3.05918902e-01f, -2.66389757e-01f, -1.44841179e-01f, -1.68494672e-01f, 4.10789512e-02f,
  -8.59020918e-04f, -9.17102024e-02f, -2.98059266e-02f, 4.93934453e-02f, 7.57731274e-02f, 4.34332388e-03f, 1.61310136e-02f, 3.60787392e-01f, 1.19930372e-01f, 5.78383431e-02f,
  -3.70725058e-02f, 1.64123073e-01f, 3.37677807e-01f, 2.00636059e-01f, 1.51407912e-01f, -4.02906351e-02f, 2.07220554e-01f, 3.45092304e-02f, 9.61398110e-02f, 8.14079121e-02f,
  1.58771574e-01f, -7.67346695e-02f, 1.35814399e-01f, 1.91843346e-01f, 1.85741514e-01f, 2.18855113e-01f, 1.09424673e-01f, 1.68424487e-01f, -6.08554203e-03f, 7.37406835e-02f,
  1.12884983e-01f, 1.01389900e-01f, 4.93240170e-02f, 2.51709670e-02f, 1.14906266e-01f, 1.72625557e-01f, 1.26059383e-01f, -1.05570994e-01f, 5.27102873e-02f, 3.60943526e-02f,
  8.08508471e-02f, -5.27138710e-02f, -1.53323323e-01f, -1.36459693e-01f, -7.58091658e-02f, 1.90813951e-02f, -5.94847053e-02f, -1.14170127e-01f, 1.73978284e-02f, -1.92371368e-01f,
  3.25338095e-02f, -2.86618508e-02f, 1.53673552e-02f, -1.49565518e-01f, -1.41318351e-01f, -1.24974422e-01f, -1.00902684e-01f, -6.62916228e-02f, -1.82580978e-01f, 1.96542293e-02f,
  -1.26962751e-01f, -3.99098508e-02f, -1.50001079e-01f, -5.01029082e-02f, 1.61105439e-01f, -3.42737511e-02f, -7.65043274e-02f, 1.43676788e-01f, -1.72250741e-03f, 6.27212971e-02f,
  -7.49409571e-02f, -2.60037612e-02f, 2.14698881e-01f, 4.99234982e-02f, 7.00262412e-02f, 6.94189593e-03f, -2.88156457e-02f, 9.92631391e-02f, 2.14916077e-02f, -1.36242220e-02f,
  -5.54264116e-04f, 9.80487093e-02f, -1.57289445e-01f, -4.46232930e-02f, -3.71892601e-02f, 1.98274300e-01f, -1.21437840e-01f, 1.31678790e-01f, 1.32391974e-01f, -3.10388301e-03f,
  8.69080499e-02f, 1.63992748e-01f, 3.95417027e-02f, 1.00348786e-01f, -7.46989436e-03f, -2.45065223e-02f, 4.91646584e-03f, -7.13675395e-02f, 7.70926401e-02f, 1.95757672e-01f,
  1.96398705e-01f, -1.36472419e-01f, -1.01132609e-01f, -1.41672805e-01f, -5.16002029e-02f, -6.72374293e-02f, 2.85948236e-02f, -5.77375516e-02f, 6.89907232e-03f, -7.95049518e-02f,
  3.40824127e-01f, 4.09350961e-01f, 3.64435256e-01f, 1.80134038e-03f, -3.30797851e-01f, -2.05434546e-01f, 1.42211303e-01f, 4.99439090e-02f, -2.33084530e-01f, 1.16812237e-01f,
  -1.50106430e-01f, -2.93296605e-01f, -2.32502893e-01f, -2.11697549e-01f, 8.32094923e-02f, 8.70548859e-02f, 1.00786448e-01f, 1.85567826e-01f, 8.42805728e-02f, 3.81257822e-04f,
  -6.69520870e-02f, 4.53422554e-02f, 2.84532130e-01f, 8.63298401e-02f, 7.92764276e-02f, -1.80437520e-01f, 8.00912008e-02f, 8.36643502e-02f, 4.47113663e-02f, 3.30385476e-01f,
  1.87565506e-01f, 3.48752379e-01f, -2.90341824e-01f, -9.21713039e-02f, 1.02910720e-01f, 2.20501889e-02f, -2.56883986e-02f, -4.80670575e-03f, -4.57802601e-02f, 4.13999520e-02f,
  -3.44556868e-02f, 7.75904767e-03f, 2.90679336e-02f, 6.93260832e-03f, -2.61456929e-02f, -1.02165677e-01f, 4.64853980e-02f, 1.10615075e-01f, 3.95061001e-02f, 1.24065243e-01f,
  -2.17269808e-01f, -7.23011121e-02f, 1.20194748e-01f, -1.11381009e-01f, -6.21175691e-02f, -3.16904873e-01f, 2.63860580e-02f, 1.29927378e-02f, -9.54191908e-02f, 8.92115459e-02f,
  -2.96253532e-01f, -4.23601568e-02f, 5.50500527e-02f, -6.46605194e-02f, -7.06042424e-02f, -1.59735292e-01f, -1.42448828e-01f, -1.52328406e-02f, -1.91421993e-03f, -3.63269038e-02f,
  -1.24486193e-01f, -7.58740902e-02f, -5.54853752e-02f, -1.17533699e-01f, -1.01614684e-01f, 4.45111506e-02f, 2.61322577e-02f, 3.49255130e-02f, -7.77675807e-02f, 5.98939955e-02f,
  -7.61094540e-02f, 6.37566000e-02f, -3.95368561e-02f, -2.87582614e-02f, -8.18755254e-02f, -1.02939092e-01f, -1.83838129e-01f, -1.05444983e-01f, -8.89469907e-02f, -2.95448918e-02f,
  -2.40215272e-01f, -1.19081534e-01f, -5.21827564e-02f, 2.40987450e-01f, 1.80697903e-01f, 9.36673209e-02f, 9.86225754e-02f, 1.12939835e-01f, 8.14458132e-02f, 7.73550645e-02f,
  1.50625780e-01f, 2.57097751e-01f, 1.44881174e-01f, 6.85388818e-02f, -1.79457486e-01f, -2.05543801e-01f, -5.61432242e-02f, -4.81699035e-02f, 1.92706827e-02f, 1.02474377e-01f,
  5.53943999e-02f, -1.88364938e-01f, -2.76721507e-01f, -2.31898814e-01f, -2.88019776e-01f, -4.61182505e-01f, -1.66834310e-01f, -1.84982330e-01f, -2.79090911e-01f, -3.71432245e-01f,
  6.75152779e-01f, -3.76895070e-01f, 6.80786669e-02f, 2.38574490e-01f, 5.44273108e-02f, -1.35994136e-01f, -2.73696393e-01f, -7.18823913e-03f, 1.64021626e-01f, 2.77541466e-02f,
  -1.43937021e-01f, -6.10031523e-02f, -4.48526628e-02f, -1.12417981e-01f, -1.19980484e-01f, -2.50780284e-01f, -9.47067142e-02f, 5.12745976e-02f, 1.78623274e-01f, 1.32628763e-02f,
  2.84751579e-02f, 5.39085567e-02f, 1.75288305e-01f, 5.01698330e-02f, -1.11301355e-01f, 1.21336035e-01f, -1.65007070e-01f, -4.13961671e-02f, -2.14140743e-01f, -2.76664682e-02f,
  -2.89637238e-01f, -7.33263493e-02f, 1.81752697e-01f, 1.35847833e-02f, -1.01173498e-01f, 1.07370235e-01f, 7.77216908e-03f, -5.40753379e-02f, -1.41723260e-01f, -1.19143680e-01f,
  -1.59971654e-01f, 4.94527183e-02f, -8.71352255e-02f, 1.07794395e-02f, 2.93714684e-02f, 7.68412021e-04f, 2.75748316e-02f, -1.09224096e-01f, -7.12538734e-02f, -5.03346883e-02f,
  -2.49046460e-02f, -8.86382256e-03f, -5.50555326e-02f, 1.28006386e-02f, -5.51869608e-02f, 6.05561435e-02f, 4.10036445e-02f, 9.37779546e-02f, 7.93126673e-02f, 1.65482789e-01f,
  2.22542230e-03f, -9.69656110e-02f, -3.66984457e-02f, -2.30611768e-04f, 1.03283394e-02f, 1.95591580e-02f, 1.55148342e-01f, -1.44360527e-01f, 7.32016638e-02f, 1.00950770e-01f,
  -3.25116590e-02f, -2.02949289e-02f, 2.13105530e-02f, 1.54078141e-01f, 4.35683765e-02f, -1.83282085e-02f, -1.38041340e-02f, -1.73322797e-01f, -1.36967763e-01f, -6.59526438e-02f,
  7.45405182e-02f, -4.02228087e-02f, 2.94835400e-03f, -1.60544172e-01f, -7.52867013e-02f, 5.19660823e-02f, 3.93002667e-03f, -6.00563549e-02f, -1.13965813e-02f, 1.15516044e-01f,
  -3.49099487e-01f, 2.73102503e-02f, 1.19746186e-01f, -3.97606902e-02f, 3.16641037e-03f, 5.36431633e-02f, -1.61771774e-02f, -2.72362195e-02f, -6.70991614e-02f, -2.78451536e-02f,
  -3.63215916e-02f, 5.00903726e-02f, -1.72374025e-02f, 2.33825166e-02f, 1.60407394e-01f, 1.60234407e-01f, 2.91994046e-02f, -1.77014656e-02f, -2.32972682e-01f, -9.34876353e-02f,
  4.99527417e-02f, 1.60143360e-01f, 1.55878559e-01f, 7.88558722e-02f, 1.49790302e-01f, 2.83454508e-01f, 4.57215942e-02f, 1.38800621e-01f, 1.07904859e-01f, 2.76302189e-01f,
  -5.00455201e-01f, 1.19861394e-01f, 4.77420650e-02f, -2.94887334e-01f, -9.16353241e-02f, 1.20874748e-01f, 1.23198412e-01f, 1.03351749e-01f, -3.85489985e-02f, 1.31286070e-01f,
  1.83561951e-01f, -2.90619582e-01f, -1.68154180e-01f, -3.57799321e-01f, -2.01455191e-01f, 1.90725744e-01f, 3.07854805e-02f, -4.72490072e-01f, -6.50470853e-01f, -3.01514238e-01f,
  -4.02604520e-01f, -4.71507609e-01f, -5.96211135e-01f, -3.73525083e-01f, -2.52563775e-01f, -5.98991632e-01f, -2.43056044e-01f, -3.72897893e-01f, -3.44030499e-01f, -3.35200101e-01f,
  -9.29013342e-02f, 3.85176875e-02f, -8.91358182e-02f, -6.57054484e-02f, 4.57783304e-02f, 6.34950846e-02f, 5.75655177e-02f, 9.56595838e-02f, 1.80469319e-01f, 1.84253678e-01f,
  7.83550441e-02f, 9.23678502e-02f, 1.53120812e-02f, -9.29754153e-02f, -9.25602484e-03f, 3.66930012e-03f, 2.33406320e-01f, 2.40289769e-03f, 2.12030932e-01f, 2.47123092e-01f,
  3.00949514e-01f, 9.07913372e-02f, 1.64688900e-01f, 2.63740033e-01f, 2.30858594e-01f, -5.96419349e-02f, -2.22523343e-02f, -6.34553432e-02f, -6.53215051e-02f, -1.59794047e-01f,
  -6.31010607e-02f, 6.52689114e-02f, 5.72191589e-02f, -1.27210349e-01f, 1.11486882e-01f, 5.51843531e-02f, -1.21646458e-02f, -4.86464165e-02f, -7.29703978e-02f, -5.05231507e-02f,
  1.09425023e-01f, 8.86650011e-03f, 3.81292240e-03f, -1.75265282e-01f, -1.30254641e-01f, 3.64495404e-02f, 5.72768487e-02f, 6.28409034e-04f, 1.08641468e-01f, 3.02651115e-02f,
  8.11635628e-02f, 1.44271389e-01f, -1.19746821e-02f, 1.30169112e-02f, 2.54839957e-01f, 1.70795709e-01f, 4.51909266e-02f, 1.03981994e-01f, 8.64193514e-02f, 2.10115224e-01f,
  -1.91231698e-01f, 1.27964929e-01f, -6.81075230e-02f, 7.57490471e-03f, 1.31244212e-01f, 8.47800747e-02f, 1.43360883e-01f, 1.04635715e-01f, -3.55436467e-02f, -3.52012850e-02f,
  1.17650934e-01f, -1.16967708e-01f, 9.47094709e-02f, 4.85423617e-02f, -1.72076508e-01f, -7.77360424e-02f, 2.07250401e-01f, -6.55859709e-02f, 1.00066774e-01f, 2.73695141e-01f,
  2.64358282e-01f, 1.28896475e-01f, -5.52993901e-02f, -6.11555413e-04f, 9.52157825e-02f, -1.34799182e-01f, -1.72885880e-01f, 2.07854919e-02f, -1.31205231e-01f, -2.79878527e-01f,
  8.44127774e-01f, 4.17994648e-01f, 1.90115899e-01f, 2.36084297e-01f, 1.73886091e-01f, 1.70581192e-01f, 2.45560527e-01f, -2.82196212e-04f, 7.26773739e-02f, 1.05974674e-01f,
  2.13699982e-01f, 2.00888991e-01f, 8.99538472e-02f, -4.01611887e-02f, 9.00465548e-02f, -3.10553126e-02f, -1.40224591e-01f, 5.23537770e-02f, 1.46984709e-02f, 1.74911067e-01f,
  1.00772247e-01f, 4.75457869e-02f, 1.68052018e-01f, -5.13096061e-03f, 1.70946553e-01f, 9.20496210e-02f, 7.12526813e-02f, 1.99800760e-01f, 2.31542215e-01f, 1.65048257e-01f,
  1.67309150e-01f, 2.58107543e-01f, -3.00940961e-01f, -1.44835979e-01f, -3.23039591e-02f, -1.11228012e-01f, 1.67542621e-02f, -4.00224067e-02f, 6.86391592e-02f, -6.58609867e-02f,
  -2.98777279e-02f, -5.16091809e-02f, -3.90483737e-02f, 5.38857421e-03f, -1.29104555e-01f, -9.57847908e-02f, -4.52326424e-02f, -8.59480500e-02f, -4.57196347e-02f, 7.40849152e-02f,
  5.95245659e-02f, 3.70633118e-02f, 6.82526752e-02f, -1.20133787e-01f, 1.70483768e-01f, -2.17462447e-03f, -1.64616276e-02f, 5.24335029e-03f, -6.02890812e-02f, 5.03024412e-03f,
  1.19460961e-02f, 1.42028660e-01f, 1.87519446e-01f, 3.68013978e-02f, 7.30676800e-02f, -6.72108447e-03f, -1.39181316e-01f, -6.61330745e-02f, -5.88079281e-02f, 1.57268438e-02f,
  -1.26499146e-01f, -4.96610031e-02f, 2.91637750e-03f, 1.97039563e-02f, 9.78308171e-02f, 9.53379832e-03f, -7.69364908e-02f, -5.55929765e-02f, -2.66822148e-02f, -1.15271039e-01f,
  4.83210459e-02f, -1.95059344e-01f, -6.21082447e-02f, -9.23306197e-02f, -2.10755840e-01f, 2.69978978e-02f, 5.39415404e-02f, -2.90029570e-02f, -5.14344871e-03f, -2.60111690e-02f,
  -5.40974259e-01f, 3.75647694e-02f, -7.21223950e-02f, -2.19191611e-01f, 8.04243758e-02f, 1.19783254e-02f, 1.36177316e-01f, -3.83663587e-02f, 1.13655096e-02f, -1.16077326e-01f,
  -3.22349854e-02f, -3.64531623e-03f, -1.57969035e-02f, -2.35624500e-02f, -1.28703997e-01f, -3.62325497e-02f, -1.73848700e-02f, -8.64898339e-02f, -7.87203908e-02f, -1.33518547e-01f,
  -1.26279011e-01f, -1.48889765e-01f, -2.37535343e-01f, -1.77765787e-01f, -5.38590103e-02f, -1.84494331e-01f, -6.55781999e-02f, -4.09592204e-02f, -1.01361670e-01f, -7.58806691e-02f,
  1.76973313e-01f, 2.46854439e-01f, 6.37486428e-02f, 2.77945340e-01f, 3.78834456e-01f, 3.45241070e-01f, 3.95008713e-01f, 9.82966796e-02f, 1.64741799e-01f, 1.18530467e-01f,
  2.02095553e-01f, 2.08825782e-01f, 9.11077112e-02f, 7.32665062e-02f, 7.39152450e-03f, 3.54610197e-02f, -2.63962466e-02f, -9.15648341e-02f, 5.12506673e-03f, 1.19735427e-01f,
  2.36375213e-01f, 1.44223690e-01f, -2.17666794e-02f, 4.65760529e-02f, -1.56102236e-02f, 1.79549545e-01f, 1.31690264e-01f, 2.11401612e-01f, 1.80314317e-01f, -4.27111052e-02f,
  -1.39854342e-01f, 1.69120565e-01f, -8.17848295e-02f, -1.41097322e-01f, -1.37482017e-01f, -2.42833927e-01f, -1.44298807e-01f, -2.20628619e-01f, -9.90210921e-02f, -2.76331920e-02f,
  -1.11006886e-01f, -6.92065582e-02f, -1.80205237e-02f, -1.10697120e-01f, -2.35513952e-02f, -1.79831907e-01f, -2.07209200e-01f, -1.27061144e-01f, -6.92980960e-02f, -7.71261305e-02f,
  -7.27405548e-02f, 5.14993444e-02f, -4.09272127e-02f, -8.90278369e-02f, 1.81458343e-03f, -6.92646652e-02f, -1.25714272e-01f, -1.11815020e-01f, -8.76073018e-02f, -4.29455675e-02f,
  -3.44217539e-01f, -2.65944898e-01f, -9.61328968e-02f, -5.89415664e-03f, -8.37718137e-03f, -3.27855982e-02f, -2.81466153e-02f, 6.01248965e-02f, -4.84065041e-02f, -1.09304488e-01f,
  -7.53298551e-02f, 1.82005353e-02f, 9.91394743e-03f, 2.90615018e-02f, -7.04158098e-02f, -1.64062589e-01f, -5.14313169e-02f, -1.66923776e-01f, -2.24885307e-02f, 2.67872214e-02f,
  9.51541066e-02f, -1.85379535e-01f, -1.64422587e-01f, -5.25311902e-02f, -1.60644531e-01f, -1.70045540e-01f, -1.75433248e-01f, -6.85169473e-02f, -1.16577279e-02f, -1.58937156e-01f,
  -1.67991921e-01f, 2.73584127e-01f, -8.37733448e-02f, -6.76545724e-02f, -4.27128375e-02f, -9.53183323e-02f, -1.17636230e-02f, -7.02766888e-03f, 4.23122803e-03f, -6.84048682e-02f,
  -2.24426463e-02f, -4.97430265e-02f, 4.51960862e-02f, 4.21560518e-02f, 5.44904284e-02f, 2.03203969e-02f, -1.15488535e-02f, -7.60976821e-02f, -9.64162964e-03f, -3.57913710e-02f,
  -1.89317223e-02f, -5.45234270e-02f, -1.25444941e-02f, -9.60169826e-03f, 1.01280687e-02f, 4.05396195e-03f, -1.12139910e-01f, -6.33772612e-02f, -1.23970784e-01f, 1.56853739e-02f,
  7.04377770e-01f, -2.25833923e-01f, 7.83755705e-02f, 3.84449326e-02f, -3.12932163e-01f, -3.06802183e-01f, -3.46823484e-01f, -2.87919909e-01f, -5.39723672e-02f, -1.45797515e-02f,
  -6.97454289e-02f, 1.31732941e-01f, 1.92927957e-01f, 1.33615747e-01f, 2.87135113e-02f, -1.95844367e-01f, -1.07061006e-01f, 2.38003701e-01f, 1.29096553e-01f, 5.81362983e-03f,
  -5.87972403e-02f, 2.74135508e-02f, 3.18950325e-01f, 8.28425288e-02f, 6.09632023e-02f, 4.00610790e-02f, -4.31285687e-02f, 2.73709409e-02f, 3.80531661e-02f, 1.68062583e-01f,
  1.73871264e-01f, 2.99335927e-01f, 1.23027340e-01f, 1.06255144e-01f, 2.19614897e-02f, 9.12594423e-02f, -5.77925239e-03f, -7.70157054e-02f, -1.04295775e-01f, -8.69148523e-02f,
  -4.52454723e-02f, 1.06202997e-01f, 1.27979085e-01f, -1.12510026e-01f, -1.56270549e-01f, -3.53938080e-02f, 6.11924380e-02f, 7.85281435e-02f, 3.45084742e-02f, 6.73684701e-02f,
  -7.49315694e-02f, -1.05632573e-01f, -2.31093884e-01f, -2.04731822e-01f, 6.91188127e-02f, 1.11063078e-01f, 6.44665509e-02f, 1.15525462e-01f, -7.71556050e-02f, -3.04422136e-02f,
  8.18243772e-02f, -9.96122807e-02f, 7.47488886e-02f, 5.36961742e-02f, 1.18395098e-01f, -3.89604419e-02f, -1.74387405e-03f, -6.41604289e-02f, 2.63060015e-02f, 8.40994045e-02f,
  -1.27242848e-01f, 8.13887194e-02f, -7.02881888e-02f, 7.74629712e-02f, 8.85902122e-02f, -1.49394770e-03f, -1.13214314e-01f, -9.30319447e-03f, 5.82455285e-02f, 1.76514313e-02f,
  7.03479052e-02f, -5.10553597e-03f, -4.29620817e-02f, 6.99497536e-02f, -1.10584244e-01f, -1.00127026e-01f, -1.25008849e-02f, -1.05112590e-01f, -8.08928311e-02f, 3.12735103e-02f,
  -4.33687568e-01f, 4.19439584e-01f, 2.55105406e-01f, 1.53581798e-01f, 5.36612161e-02f, 1.18018262e-01f, 1.65283456e-01f, -5.32748289e-02f, -9.32241082e-02f, -6.52280822e-02f,
  -1.01623490e-01f, 7.72430003e-02f, 3.03622597e-04f, 7.29575381e-02f, 2.54383814e-02f, 8.33347365e-02f, 9.30684954e-02f, 7.86534101e-02f, -6.80323467e-02f, 3.16211842e-02f,
  1.60354022e-02f, -2.01842561e-01f, -2.01765791e-01f, -1.23916246e-01f, 6.96891034e-03f, -5.06606214e-02f, -3.45356353e-02f, -4.87443712e-03f, -9.91057009e-02f, -1.01691760e-01f,
  -3.97053480e-01f, 1.42201995e-02f, -4.99182165e-01f, 7.09220171e-02f, 4.98030521e-02f, 1.35807283e-02f, 2.80956924e-01f, 1.86728448e-01f, 1.28476158e-01f, -6.47162348e-02f,
  -7.17326775e-02f, -2.29182467e-02f, 5.42331673e-02f, -8.87467936e-02f, 4.66123074e-02f, 1.39104068e-01f, 5.25761545e-02f, -1.40307337e-01f, -1.38509095e-01f, 7.75192082e-02f,
  3.23197335e-01f, 1.79786026e-01f, -3.58466692e-02f, 3.27523351e-02f, 1.51410699e-01f, 6.79235607e-02f, 2.01589316e-02f, 9.41720381e-02f, -5.55891693e-02f, 8.55362490e-02f,
  -4.68190700e-01f, -2.74472415e-01f, 1.11091226e-01f, -8.37127045e-02f, -2.09462941e-01f, -2.10738465e-01f, -8.12220201e-02f, -2.62031108e-01f, -2.78217010e-02f, 8.59476849e-02f,
  9.26195830e-03f, -1.81617245e-01f, 3.72422449e-02f, 1.53887987e-01f, 4.78788279e-02f, -1.14730150e-01f, -1.38226105e-02f, -2.11756751e-01f, -1.99582413e-01f, -2.57308930e-01f,
  2.45428964e-01f, -2.21868366e-01f, -3.12868148e-01f, -1.03842825e-01f, -1.02854744e-01f, -6.33940622e-02f, -1.53942928e-01f, -1.91243470e-01f, -2.21807346e-01f, -1.50604635e-01f,
  -4.07000147e-02f, -5.14250584e-02f, -6.30532252e-03f, -1.45755871e-03f, 1.15219347e-01f, 1.70289561e-01f, 1.20835774e-01f, 3.38749262e-03f, 3.58119980e-02f, -3.15520950e-02f,
  1.34701682e-02f, -1.68714792e-01f, -1.83839481e-02f, -6.68579042e-02f, 5.34958951e-02f, -9.85705703e-02f, -5.62562980e-02f, 7.99742118e-02f, -1.44247502e-01f, -1.08560532e-01f,
  1.74220128e-03f, 6.45570755e-02f, 7.45039582e-02f, -1.16281984e-02f, -1.04154877e-01f, -1.02363266e-01f, -6.74270689e-02f, -7.16998056e-02f, -2.76519451e-02f, -6.88096881e-02f,
  3.13308597e-01f, -1.91359341e-01f, -4.10522632e-02f, 4.77760211e-02f, 2.41413955e-02f, 1.98599435e-02f, 6.50679320e-02f, -8.63480717e-02f, -1.10864062e-02f, -1.41284123e-01f,
  3.47939916e-02f, -1.41661717e-02f, 1.32539839e-01f, 1.41368404e-01f, -7.88668171e-02f, 2.32538059e-02f, 1.16931364e-01f, 2.33661886e-02f, 8.03471208e-02f, -1.80770662e-02f,
  2.61612743e-01f, 1.95935845e-01f, -4.63542528e-02f, 1.16092533e-01f, 1.69763818e-01f, 9.53378156e-03f, 1.11023404e-01f, 8.61610025e-02f, -1.42930835e-01f, 3.79180610e-01f,
  2.80266702e-01f, -2.42902897e-02f, -5.79476237e-01f, 3.75368595e-01f, -7.05361739e-02f, -4.94620591e-01f, -3.03858191e-01f, -7.81126469e-02f, 3.66609007e-01f, 8.50585997e-02f,
  7.80880153e-02f, -3.04206815e-02f, -2.16915399e-01f, -3.84219259e-01f, -5.21200776e-01f, -3.41366470e-01f, -4.35354859e-01f, -6.51952684e-01f, -5.77254236e-01f, -3.53708714e-01f,
  -1.36829913e-01f, -1.77187458e-01f, -1.60489678e-01f, -1.97843537e-01f, 2.89406151e-01f, -1.41641915e-01f, -2.49370143e-01f, -1.47076696e-01f, -4.57583845e-01f, -8.33509490e-02f,
  -3.91246378e-01f, -9.11551863e-02f, -7.10312128e-02f, 7.31808022e-02f, 4.78915647e-02f, 3.04503310e-02f, -8.80406201e-02f, 1.45572737e-01f, 2.13252932e-01f, 8.58664364e-02f,
  6.14619628e-02f, 8.52736458e-02f, -3.54365706e-02f, 6.28873259e-02f, 1.20039858e-01f, -3.46212499e-02f, 1.38419077e-01f, 4.10841815e-02f, -8.19591060e-02f, 5.27866632e-02f,
  1.21546857e-01f, -7.24262297e-02f, -3.55225690e-02f, 3.32185291e-02f, -2.35710386e-02f, -7.10790977e-02f, 2.84980964e-02f, 9.32287648e-02f, -1.00249417e-01f, 1.92922667e-01f,
  -5.23008294e-02f, 4.15366776e-02f, -2.14474760e-02f, 1.60520598e-02f, 1.23925529e-01f, 3.00023220e-02f, 9.89913493e-02f, 7.93213993e-02f, 2.20834743e-02f, 1.30471274e-01f,
  5.89900129e-02f, -2.32751165e-02f, -1.82633363e-02f, -2.02268343e-02f, -3.50474752e-02f, -4.79185916e-02f, 1.63274314e-02f, 1.92052610e-02f, -6.89406842e-02f, 1.54691800e-01f,
  -3.45321582e-03f, 6.97947070e-02f, 6.89093992e-02f, 4.46454696e-02f, -1.26147151e-01f, -2.38672737e-02f, -3.80743816e-02f, 7.83197209e-03f, 3.08568100e-03f, 1.18319735e-01f,
  1.91320002e-01f, -2.94110388e-01f, 9.29759070e-02f, 1.46205455e-01f, -1.58004072e-02f, 1.58846229e-01f, 2.94805691e-03f, -2.13102475e-02f, 8.86098668e-02f, 1.45635037e-02f,
  -1.26838669e-01f, -1.95785668e-02f, -7.62287304e-02f, 5.10402173e-02f, -1.66131351e-02f, -8.40704888e-02f, 1.24432750e-01f, -4.83392365e-02f, -3.64878476e-02f, 2.63246030e-01f,
  1.06027149e-01f, 1.18430704e-02f, 5.95839471e-02f, 5.41849434e-02f, 9.42600667e-02f, -2.08919451e-01f, -3.74928489e-02f, -1.88320316e-02f, -2.56870359e-01f, 2.25495711e-01f,
  -8.89791250e-01f, -4.92220312e-01f, 6.65675998e-01f, -2.64535844e-01f, -4.84789051e-02f, 4.32297296e-04f, -5.73540866e-01f, -1.42111048e-01f, 5.36242053e-02f, -4.91449296e-01f,
  -3.40888500e-01f, -1.16417721e-01f, 3.75684723e-02f, 5.22870496e-02f, -1.31662071e-01f, -5.70796072e-01f, -7.23689422e-02f, 3.95684868e-01f, 3.65671366e-01f, -1.04662046e-01f,
  -4.70275909e-01f, -1.22392580e-01f, 1.77954584e-01f, 4.11281874e-03f, -5.83926797e-01f, -1.29838392e-01f, 1.80125967e-01f, -1.92516744e-01f, -2.68736959e-01f, -5.14853358e-01f,
  -2.90543705e-01f, 1.15541525e-01f, 4.70265359e-01f, 8.90842602e-02f, 1.51354283e-01f, 1.99268330e-02f, -7.65332254e-03f, 2.45238677e-01f, -5.04158251e-03f, 9.95073020e-02f,
  -6.53715879e-02f, -1.08891865e-02f, -5.85171990e-02f, 1.17168151e-01f, -1.99330729e-02f, -9.73251909e-02f, 3.58071417e-01f, 4.16763157e-01f, 1.08446367e-01f, -7.37091526e-02f,
  -3.84935409e-01f, -4.91010398e-01f, 1.29481629e-02f, 2.56193280e-01f, 1.65956408e-01f, 2.93708324e-01f, 1.71972275e-01f, 3.36181968e-02f, 1.78036198e-01f, -7.26705611e-01f,
  -6.35844171e-02f, 1.56260625e-01f, 1.62766367e-01f, 7.55182207e-02f, -2.23656483e-02f, 5.96916713e-02f, 2.17414517e-02f, -1.21882588e-01f, 1.09707311e-01f, -1.31212398e-01f,
  1.38689235e-01f, -1.06687784e-01f, -1.01306319e-01f, -1.13545813e-01f, -1.79737527e-02f, -4.98367362e-02f, -2.29040369e-01f, -5.12024909e-02f, 2.79072626e-03f, -1.33014366e-01f,
  3.87030020e-02f, 6.95678815e-02f, 7.11391568e-02f, -4.45911326e-02f, -2.71959510e-02f, 1.49081290e-01f, -3.45257111e-02f, 2.61297345e-01f, 3.27854343e-02f, -1.34229371e-02f,
  -1.01783268e-01f, 5.39897442e-01f, -5.54793954e-01f, -1.13991231e-01f, -8.45345259e-02f, 5.06163165e-02f, -1.28729403e-01f, 2.05779716e-01f, -3.69932391e-02f, -1.08242892e-01f,
  2.63662655e-02f, -1.66816011e-01f, -6.84304675e-03f, 8.37031975e-02f, -8.50457177e-02f, 2.69036219e-02f, -2.73376703e-01f, -1.22040428e-01f, 1.23508908e-01f, -1.25861466e-01f,
  -4.94041517e-02f, -4.55275148e-01f, -5.95144033e-01f, -3.11346799e-01f, -4.14214283e-01f, -8.78632367e-02f, -2.48424541e-02f, -1.98141634e-01f, -3.47451657e-01f, -7.73882329e-01f,
  -3.42001587e-01f, -3.65505189e-01f, 1.82864293e-02f, 1.98151723e-01f, 2.18651459e-01f, 1.00071803e-01f, -5.30529814e-03f, 1.26623273e-01f, 1.59862027e-01f, 9.72427055e-02f,
  3.90893891e-02f, 2.33592600e-01f, 2.96258211e-01f, 2.55993247e-01f, 1.13273248e-01f, 2.49443904e-01f, 3.79189759e-01f, 1.60638645e-01f, 2.65348423e-02f, 1.16203494e-01f,
  1.79688692e-01f, -7.78461397e-02f, -1.17564358e-01f, 6.71725422e-02f, 9.75804999e-02f, 2.54219532e-01f, 1.09933883e-01f, -1.05660886e-03f, 3.92544158e-02f, 2.63667583e-01f,
  8.63711312e-02f, -1.51391134e-01f, 1.82042211e-01f, 3.31422663e-03f, -1.84049442e-01f, -8.00631046e-02f, 4.78024483e-02f, -8.48377347e-02f, -8.78756121e-02f, 6.75397217e-02f,
  -1.02837952e-02f, -1.68764800e-01f, 4.36668992e-02f, -3.93367782e-02f, -1.16474340e-02f, -1.71020135e-01f, -1.27895594e-01f, -1.87318083e-02f, 1.57552615e-01f, -5.21798944e-03f,
  4.56108861e-02f, -3.90559761e-03f, -4.09642309e-02f, 5.77001087e-02f, 1.77607108e-02f, 1.31374165e-01f, -4.66086268e-02f, 9.06988629e-04f, 4.16142074e-03f, 7.97080696e-02f,
  1.78070873e-01f, 1.77854717e-01f, 5.80833144e-02f, 2.70456284e-01f, 5.27356155e-02f, 1.58230647e-01f, 1.34080827e-01f, 1.22797132e-01f, 9.62162912e-02f, 4.18046974e-02f,
  1.00056380e-01f, 2.52073973e-01f, -1.91565545e-03f, 5.23668565e-02f, -3.83533575e-02f, -1.00585274e-01f, 1.63367540e-02f, 6.11700378e-02f, -4.46746461e-02f, -3.72159388e-03f,
  3.30776311e-02f, 5.98455295e-02f, -2.33659446e-01f, -1.89530123e-02f, -2.44774334e-02f, 1.99652668e-02f, 1.11599572e-01f, 1.28155630e-02f, -2.23834105e-02f, 2.77453866e-02f,
  7.62918070e-02f, 5.35748005e-02f, 2.61428833e-01f, 1.21056214e-01f, -1.48503393e-01f, -1.54459119e-01f, 3.70409079e-02f, 6.04162998e-02f, -1.90984309e-01f, 2.99577750e-02f,
  -1.71104986e-02f, -4.38517751e-03f, -3.17744315e-02f, 9.46288742e-03f, -4.80505452e-03f, -3.88458278e-03f, -6.48771599e-02f, 1.28117323e-01f, 1.63827524e-01f, 1.56805906e-02f,
  -1.08544506e-01f, 1.33268878e-01f, 1.41405582e-01f, 6.43239394e-02f, 1.45541027e-01f, 3.65990959e-02f, -3.06042321e-02f, -4.68792804e-02f, 4.73323688e-02f, -6.34987727e-02f,
  -4.31859404e-01f, -2.85324097e-01f, 2.78610110e-01f, -4.41331305e-02f, -8.17466434e-03f, -7.67235756e-02f, -2.48542950e-01f, -4.06078994e-01f, -2.03733876e-01f, 1.65957622e-02f,
  1.04794390e-01f, 2.01590076e-01f, 1.68316424e-01f, 2.28026584e-01f, -6.00231811e-02f, -1.46344956e-02f, 4.06815037e-02f, 1.40084982e-01f, -2.80361511e-02f, -1.27062008e-01f,
  4.58493680e-02f, -1.70476586e-01f, -2.44193338e-02f, -6.83907270e-02f, 1.89207066e-02f, 1.72560900e-01f, -7.39605166e-03f, -2.32730247e-02f, 3.65084857e-02f, 2.14013055e-01f,
  4.11449522e-01f, -2.86584854e-01f, -9.30861384e-03f, 7.75913894e-02f, 5.44405729e-03f, -8.06545243e-02f, 4.36661243e-02f, -7.38136172e-02f, -1.07563704e-01f, -6.15083911e-02f,
  1.29763186e-01f, 4.82317768e-02f, -9.17801782e-02f, 5.98811470e-02f, 2.64203344e-02f, 1.43146694e-01f, -1.24015789e-02f, -1.18266568e-01f, -9.32433307e-02f, 1.96289625e-02f,
  -8.82177334e-03f, 9.92437452e-02f, 1.12544209e-01f, 4.14505415e-02f, -3.34004872e-03f, 5.46040833e-02f, 4.97903824e-02f, -4.76052170e-04f, 3.05162929e-02f, -8.91363546e-02f,
  4.32212465e-02f, 2.40802109e-01f, 2.27898940e-01f, 1.20341949e-01f, 9.15376022e-02f, 1.92647964e-01f, 1.40344277e-01f, 1.70424506e-01f, 2.08564103e-02f, 2.01403484e-01f,
  2.26333037e-01f, -2.52948422e-02f, -1.86367407e-01f, -5.01308739e-02f, 2.58590609e-01f, 1.24233365e-01f, 2.75893033e-01f, 2.25563258e-01f, 2.35452667e-01f, 1.15548871e-01f,
  1.75148681e-01f, 7.41886199e-02f, 1.26107216e-01f, -1.01597328e-02f, 2.53047407e-01f, 1.39437139e-01f, 3.08816165e-01f, 2.58449465e-01f, 1.01157598e-01f, 2.92866677e-01f,
  6.25795126e-02f, -6.85714036e-02f, 1.70501880e-02f, 4.30391990e-02f, -1.34888932e-01f, 8.91459063e-02f, 5.43490611e-02f, -1.07020564e-01f, -4.69832644e-02f, 3.68035622e-02f,
  1.82501972e-02f, -4.62987497e-02f, -7.53461793e-02f, -2.92472951e-02f, -8.69014487e-02f, 1.45005405e-01f, -4.59424518e-02f, -7.08200037e-02f, -1.44865766e-01f, 1.37906700e-01f,
  1.28300516e-02f, -1.34789109e-01f, 1.25735611e-01f, -5.22906110e-02f, 4.50730622e-02f, 1.89994097e-01f, 1.23394571e-01f, -2.37125289e-02f, 1.23637065e-01f, -1.15467291e-02f,
  -5.90190947e-01f, 7.58299977e-02f, -6.88735485e-01f, -2.84843892e-01f, -7.65825957e-02f, 7.91792665e-03f, 4.86899376e-01f, 4.13769126e-01f, 1.05095193e-01f, -7.84289986e-02f,
  -1.82710767e-01f, -1.93548039e-01f, -1.70607015e-01f, -1.49258390e-01f, 1.29002467e-01f, 4.24948484e-01f, 2.66399831e-01f, -2.53842413e-01f, -2.75712281e-01f, 2.54300117e-01f,
  3.33512604e-01f, 5.40171899e-02f, -2.06141815e-01f, 7.48524219e-02f, 7.72102997e-02f, -8.42295960e-02f, -7.55212754e-02f, -2.96471834e-01f, -1.24031752e-01f, -3.29177171e-01f,
  -6.56962752e-01f, -3.36954415e-01f, 2.19630405e-01f, -2.49526218e-01f, -1.02658466e-01f, -1.04329638e-01f, 1.82320878e-01f, -1.96910203e-01f, -2.58967429e-01f, 7.56910956e-03f,
  -3.60601485e-01f, -1.35833800e-01f, -2.99533218e-01f, -8.09640661e-02f, -4.43229452e-02f, -4.58324142e-02f, -1.25725314e-01f, -1.55214310e-01f, -2.86971718e-01f, -2.94599622e-01f,
  2.36537278e-01f, -4.74790663e-01f, -8.39040637e-01f, -1.49081822e-03f, -7.22091570e-02f, -1.88100412e-01f, -3.45202655e-01f, -3.38517845e-01f, -2.41905257e-01f, -4.50710237e-01f,
  -4.94203642e-02f, -2.41719022e-01f, -2.60835104e-02f, 8.60797167e-02f, 2.81938583e-01f, 6.50816485e-02f, 1.21355347e-01f, -2.83195004e-02f, -1.65072292e-01f, -7.93197602e-02f,
  -1.67841092e-02f, -1.52229026e-01f, 1.37742870e-02f, 7.54780928e-03f, -5.14341816e-02f, 3.51819694e-02f, 3.46545838e-02f, 1.53125823e-01f, -9.10733826e-03f, 8.91757011e-02f,
  -4.55988348e-02f, -8.62969607e-02f, 1.56932086e-01f, 5.46276160e-02f, 4.69998159e-02f, 7.52136931e-02f, 1.02457605e-01f, 8.35120901e-02f, 4.65651341e-02f, 6.87055364e-02f,
  2.60271758e-01f, 3.06767613e-01f, -9.36169550e-02f, 8.69702622e-02f, -6.79135397e-02f, 1.21799059e-01f, -5.09087145e-02f, -4.91231633e-03f, -2.32390866e-01f, -1.84529126e-01f,
  -1.41645372e-01f, -1.03401355e-01f, 3.91190760e-02f, -1.27147362e-01f, -1.36920646e-01f, -1.18317835e-01f, 2.92340722e-02f, -2.10743651e-01f, -6.39616922e-02f, -1.17157735e-01f,
  3.07658613e-01f, 9.08122510e-02f, -4.50808614e-01f, -2.52668142e-01f, 1.18831955e-02f, -1.32128209e-01f, -3.15767229e-01f, -8.77858102e-02f, -5.43038547e-02f, 1.28844574e-01f,
  -8.15626383e-01f, -3.30547094e-01f, -4.87124652e-01f, -8.56915057e-01f, -5.22591352e-01f, -1.67640910e-01f, 3.38057667e-01f, -1.56312555e-01f, -5.97892582e-01f, -3.13125849e-01f,
  -5.04848845e-02f, 9.73790288e-02f, -3.16632718e-01f, 1.01118200e-01f, 2.60728687e-01f, -7.61293024e-02f, -5.04307687e-01f, -2.48910874e-01f, 1.59319043e-01f, 5.66169381e-01f,
  1.95419326e-01f, -3.34997833e-01f, -2.58203954e-01f, -1.12943873e-01f, -2.00015217e-01f, -1.78986818e-01f, -4.84149665e-01f, -3.66875380e-01f, -9.35251713e-02f, -5.96670866e-01f,
  3.51835907e-01f, -5.10841310e-01f, 1.65024534e-01f, -1.86795905e-01f, -4.31050807e-02f, 4.24347073e-02f, 5.91405593e-02f, -1.81610689e-01f, -8.41089040e-02f, -1.56952664e-01f,
  -2.45563567e-01f, 1.81542560e-02f, -4.26672101e-02f, 2.57412978e-02f, -8.10888782e-02f, -4.05731238e-02f, -1.87898487e-01f, -9.08010304e-02f, -1.62272513e-01f, 1.18950069e-01f,
  8.00259933e-02f, -1.66978002e-01f, -9.32311788e-02f, 6.67767897e-02f, 6.18975274e-02f, -1.67923927e-01f, 1.36294812e-01f, -6.80881441e-02f, -1.33027837e-01f, -1.64794087e-01f,
  -2.69368663e-02f, 7.52637684e-02f, 4.70859446e-02f, 9.13606733e-02f, 3.76174636e-02f, 5.82022928e-02f, -1.23408750e-01f, -2.65619196e-02f, 6.43307492e-02f, 1.08287506e-01f,
  1.94185805e-02f, -4.81514493e-03f, -9.14383493e-03f, -7.41391852e-02f, -7.65012652e-02f, -1.43132091e-01f, 3.28469723e-02f, 1.79913834e-01f, -1.90613940e-02f, -4.22334485e-03f,
  -9.57035944e-02f, -1.18476696e-01f, -1.10479429e-01f, 9.57665741e-02f, 5.87986857e-02f, -2.11318493e-01f, -7.58165168e-03f, 8.29707906e-02f, 2.78402399e-02f, -5.43546975e-02f,
  2.52164841e-01f, -1.38771817e-01f, -7.61821046e-02f, -6.91163838e-02f, -7.50859007e-02f, -8.56443197e-02f, -1.63462088e-01f, 2.39310488e-02f, -1.18889295e-01f, 3.62970531e-02f,
  3.66376643e-03f, -1.22351982e-02f, -8.06224793e-02f, 1.39987692e-01f, 3.07018147e-03f, 9.62726250e-02f, -2.43502930e-02f, -2.50470750e-02f, -5.18378578e-02f, 9.20343772e-02f,
  -3.39972302e-02f, 1.26909539e-02f, 2.92458743e-01f, 8.60231593e-02f, 1.21034188e-02f, 1.27897888e-01f, 2.82570601e-01f, 2.32070923e-01f, 1.15053013e-01f, 2.57549286e-01f,
  -6.05081439e-01f, 1.64540019e-02f, -7.88925309e-03f, -5.66047728e-01f, -8.52507427e-02f, 3.38546962e-01f, 3.88413370e-01f, 6.66432455e-02f, -3.37572396e-01f, -1.35530189e-01f,
  3.23656052e-02f, -2.95866400e-01f, -3.63931209e-01f, -1.92734003e-02f, 1.61691502e-01f, -1.92581192e-02f, -2.01924115e-01f, -4.20917682e-02f, 6.81604445e-02f, 2.06265748e-01f,
  9.07212645e-02f, -2.49670669e-01f, -3.32330495e-01f, -2.61564344e-01f, -3.84231687e-01f, -2.95914441e-01f, -2.94135511e-01f, -1.99994728e-01f, 2.73827300e-03f, -3.44616890e-01f,
  2.62531251e-01f, 1.51739167e-02f, -7.44915530e-02f, -6.00516722e-02f, 6.30556196e-02f, -4.88507859e-02f, 1.20374173e-01f, -1.07873604e-01f, -2.79929619e-02f, 1.74049020e-01f,
  -3.76598053e-02f, -7.83229172e-02f, 1.66079197e-02f, 8.06925371e-02f, 1.29588068e-01f, 1.17083877e-01f, 1.93774149e-01f, 2.53030639e-02f, 1.78743750e-01f, 1.91372529e-01f,
  1.43372327e-01f, 2.40082055e-01f, 2.80124784e-01f, 3.30784589e-01f, 3.66103023e-01f, 4.24429215e-02f, 2.54573345e-01f, 1.68930426e-01f, 2.16235012e-01f, 5.98877482e-02f,
  1.21345475e-01f, -5.23610041e-02f, 1.08314402e-01f, 3.37774493e-02f, 1.68408453e-01f, 4.01460268e-02f, -8.94983411e-02f, 1.35615394e-01f, 9.50471237e-02f, -2.06162464e-02f,
  -3.59286442e-02f, 1.70388311e-01f, 1.42227009e-01f, -8.37887675e-02f, -1.24605246e-01f, -9.98043418e-02f, 1.41059384e-01f, 9.10806060e-02f, 4.54796990e-03f, -7.41894990e-02f,
  3.32069583e-02f, -3.60197611e-02f, -9.76106077e-02f, 6.73244968e-02f, 7.34763145e-02f, 5.30019328e-02f, 1.06224567e-01f, 8.66845772e-02f, -1.02543004e-01f, -2.07393497e-01f,
  -1.24252040e-03f, 1.84042141e-01f, -1.38989493e-01f, -2.20353931e-01f, -1.03354625e-01f, -1.75944835e-01f, -1.59017444e-01f, -1.62758306e-02f, -1.22906715e-01f, 6.03505075e-02f,
  1.77576661e-01f, -1.77279972e-02f, -3.12047452e-03f, 3.81348917e-04f, -3.53989378e-02f, 1.01266898e-01f, -1.08035505e-02f, -1.84780627e-01f, -7.00492188e-02f, 3.63518298e-02f,
  1.35550752e-01f, -5.33648320e-02f, 2.77306549e-02f, -6.19188324e-02f, 1.02737509e-01f, -1.05902240e-01f, 1.14223197e-01f, 7.73425400e-02f, 8.79840702e-02f, -3.36268824e-03f,
  1.03877962e+00f, 6.78243101e-01f, -2.46022031e-01f, 2.20648646e-01f, -2.29301155e-01f, -1.42152146e-01f, 7.40981698e-02f, 2.33708680e-01f, 1.63027838e-01f, 1.23452023e-01f,
  1.48188308e-01f, 1.34102717e-01f, 1.51022881e-01f, 3.44677120e-02f, 1.08393528e-01f, -5.31702451e-02f, -1.92661494e-01f, -1.77076787e-01f, -1.86677709e-01f, -8.49208310e-02f,
  -5.29442839e-02f, 1.00117348e-01f, 2.85303891e-01f, -5.61834313e-03f, 4.08489220e-02f, -1.34635642e-01f, -1.14481688e-01f, -2.59103179e-02f, -2.50848681e-02f, -5.42843491e-02f,
  -4.77188498e-01f, 9.81380939e-02f, -3.55298445e-02f, 1.62779801e-02f, 6.28339127e-02f, 1.85175583e-01f, 1.55367646e-02f, 1.56336259e-02f, 1.51062042e-01f, -9.52215716e-02f,
  5.46437316e-03f, 7.48480088e-04f, -2.55191084e-02f, -8.08060020e-02f, 1.74280964e-02f, -1.18848205e-01f, 4.46527302e-02f, 1.29073471e-01f, -4.96866331e-02f, -1.10177256e-01f,
  3.98695730e-02f, -9.39780623e-02f, -1.41324937e-01f, -5.47279008e-02f, -5.62136136e-02f, 3.65721323e-02f, 1.32216653e-02f, 4.25682999e-02f, -8.10025856e-02f, 8.68944004e-02f,
  9.50956792e-02f, 2.68832237e-01f, -1.85097530e-02f, -1.06010295e-01f, 3.33046503e-02f, -3.39985229e-02f, 2.23263563e-03f, 5.02670147e-02f, 2.09479071e-02f, 1.02573700e-01f,
  -7.61936307e-02f, -2.01421946e-01f, 6.29415549e-03f, -7.85912052e-02f, -5.97169548e-02f, 4.66465838e-02f, -5.96974418e-03f, -1.36296704e-01f, -2.39109695e-01f, -4.58715409e-02f,
  6.42000651e-03f, -5.80426417e-02f, 2.32908763e-02f, -9.34537053e-02f, -6.22184351e-02f, -1.45871684e-01f, -7.64815509e-02f, 3.81223746e-02f, 5.17375097e-02f, 1.53044775e-01f,
  -1.25495479e-01f, -3.96229446e-01f, -1.10827781e-01f, 7.47373179e-02f, 4.42686081e-02f, 1.48123443e-01f, -1.57819316e-01f, -4.91757542e-02f, -3.07519622e-02f, -7.26401582e-02f,
  -1.14865631e-01f, 5.41433655e-02f, -7.38553405e-02f, 8.59652087e-02f, -6.38884380e-02f, -8.74430239e-02f, 1.84869528e-01f, 1.06056042e-01f, -5.50798047e-03f, -5.85318469e-02f,
  1.62078112e-01f, 1.55350640e-01f, 4.03144248e-02f, 6.38549477e-02f, 5.94548509e-02f, -7.64873549e-02f, -4.17779274e-02f, -1.96010210e-02f, -3.87457642e-03f, 2.35881001e-01f,
  4.87485118e-02f, 4.33700196e-02f, 4.10157174e-01f, 1.25051126e-01f, -2.25493595e-01f, -5.71698070e-01f, -8.18608761e-01f, -2.82372802e-01f, 1.75539590e-02f, -8.59935880e-02f,
  -1.66646510e-01f, -7.41877630e-02f, 1.77337125e-01f, 3.85359116e-02f, -1.82212859e-01f, -1.44810975e-01f, 2.38477930e-01f, 2.40625262e-01f, -2.59784192e-01f, -4.98109907e-01f,
  -2.92089492e-01f, 1.26715973e-02f, 2.58929461e-01f, 1.32563442e-01f, 3.08800548e-01f, 1.18502200e-01f, 4.28373426e-01f, 2.75134712e-01f, 2.30955984e-02f, 5.63974917e-01f,
  2.93419182e-01f, 1.52069017e-01f, -1.43965185e-01f, 1.76846340e-01f, 2.68180609e-01f, 5.67944311e-02f, -3.82195599e-02f, 4.26736742e-01f, 2.83179269e-03f, 1.11320131e-01f,
  9.47018340e-02f, -5.37577551e-03f, -1.01885609e-01f, -8.67735036e-03f, -6.15068711e-03f, -2.96018541e-01f, 1.97209120e-01f, 1.51014417e-01f, 1.93795010e-01f, -1.86785422e-02f,
  -2.22240523e-01f, -8.57122615e-02f, -1.92981772e-02f, -1.71305388e-01f, -7.59853348e-02f, -8.40797648e-02f, -7.24835843e-02f, 8.95579904e-02f, -5.22064306e-02f, 3.01544428e-01f,
  -2.21125539e-02f, -1.09156668e-02f, 8.42753723e-02f, 7.66156688e-02f, -8.40976909e-02f, 1.04850799e-01f, 1.31860867e-01f, -1.01130925e-01f, 1.80194043e-02f, 8.88046809e-04f,
  5.08298427e-02f, 7.27607831e-02f, 1.41724711e-02f, 1.15596481e-01f, 4.20024134e-02f, 1.11617800e-02f, -4.16649841e-02f, -3.74710672e-02f, 1.80662493e-03f, 4.00514975e-02f,
  -5.35306968e-02f, 3.46397832e-02f, 9.42436382e-02f, 9.63593498e-02f, -1.85605474e-02f, 1.26537681e-01f, 1.57865304e-02f, -2.08131876e-03f, 4.88118716e-02f, 2.61986554e-02f,
  -1.79058060e-01f, -2.96644449e-01f, 3.81476097e-02f, 3.08323205e-02f, 2.28656176e-02f, 1.01024866e-01f, 8.22327882e-02f, -7.62965679e-02f, 1.36979774e-01f, -7.02057779e-02f,
  -2.10478976e-01f, -8.06042627e-02f, 1.42213225e-01f, -1.32137731e-01f, -2.10694447e-01f, 2.25866549e-02f, -1.88440289e-02f, -1.37000144e-01f, -1.27998665e-01f, -2.83964202e-02f,
  1.02122379e-02f, -5.66287875e-01f, -6.07551634e-01f, -3.50704163e-01f, -1.55477434e-01f, -4.45923358e-01f, -2.72825509e-01f, -3.44779342e-01f, -3.66915137e-01f, -6.39700770e-01f,
  -5.88736415e-01f, 4.02967870e-01f, -7.28993583e-03f, -3.98332030e-02f, 5.60670793e-01f, 2.19226956e-01f, 2.10679583e-02f, -4.67898071e-01f, -6.79449216e-02f, 2.13673800e-01f,
  3.80175054e-01f, 1.21150926e-01f, 2.44241096e-02f, -1.35222226e-01f, -4.19075459e-01f, 1.35127217e-01f, 1.43138319e-01f, -3.73975873e-01f, -4.63555008e-01f, -7.07103238e-02f,
  3.02684218e-01f, -7.91109204e-02f, -5.41564286e-01f, -3.58719230e-01f, 1.06697947e-01f, 1.70059979e-01f, 1.18898258e-01f, 1.79291070e-01f, 2.59620547e-01f, 4.03608531e-01f,
  -5.31148016e-02f, -3.37923765e-01f, -1.23107672e-01f, 1.63396791e-01f, 3.17018390e-01f, -3.85957062e-01f, -2.06900015e-01f, -2.05619499e-01f, 1.26913726e-01f, -1.95204049e-01f,
  3.47118855e-01f, -5.59408292e-02f, 3.69121015e-01f, -7.63702542e-02f, -1.47469908e-01f, -4.10384983e-01f, -3.49987000e-01f, -5.23757517e-01f, -4.70769346e-01f, -3.74865979e-01f,
  6.07366204e-01f, 5.60252905e-01f, -1.03055857e-01f, -1.87675118e-01f, -3.76580894e-01f, -8.94770101e-02f, -2.35014543e-01f, -4.65330571e-01f, -5.11105120e-01f, -4.66622502e-01f,
  -1.58773772e-02f, 1.12163611e-01f, 1.11217432e-01f, -1.89572740e-02f, -4.92402539e-02f, 1.68056581e-02f, 2.38875449e-02f, 9.43143666e-02f, 6.08013086e-02f, -6.14113882e-02f,
  4.08093780e-02f, -3.24299671e-02f, -2.41880536e-01f, -1.43833041e-01f, -2.37267115e-03f, 1.13288604e-01f, 3.01195239e-03f, -1.18051261e-01f, -4.98785265e-02f, -2.43442357e-02f,
  2.70024426e-02f, -8.90409648e-02f, 4.97213267e-02f, -9.73933861e-02f, 3.84019203e-02f, 4.36269566e-02f, -6.66932389e-02f, -2.19947975e-02f, -1.46671340e-01f, 7.46572018e-02f,
  -3.02426845e-01f, -4.03362364e-02f, -6.51772395e-02f, -8.58022869e-02f, 7.97278509e-02f, 6.60364851e-02f, 1.42323524e-01f, 6.45478070e-02f, 1.15649521e-01f, -1.15238369e-01f,
  -4.61474098e-02f, -1.43628329e-01f, 1.17199153e-01f, -3.20107974e-02f, -5.92071228e-02f, 4.34762239e-02f, 2.98463106e-01f, 2.03422934e-01f, -7.29410052e-02f, 7.88068026e-02f,
  7.26735741e-02f, -9.43738595e-02f, -1.34935737e-01f, -1.73236847e-01f, 4.16408218e-02f, -8.68614092e-02f, -2.43823454e-01f, -2.84836411e-01f, -3.93428236e-01f, -3.69801372e-01f,
  -8.13643277e-01f, -1.21891620e-02f, 4.99498509e-02f, -2.74824619e-01f, 2.12462549e-03f, 1.43071041e-01f, 2.50551701e-01f, 6.81660175e-02f, -1.22302525e-01f, -5.44625781e-02f,
  -6.75133839e-02f, -2.35286914e-02f, 3.28306966e-02f, 1.33739427e-01f, 1.91931650e-01f, 3.31900835e-01f, 1.86995521e-01f, 8.00860971e-02f, 1.00636423e-01f, 1.25636876e-01f,
  1.50822520e-01f, -1.57570601e-01f, -3.01920682e-01f, -1.51030272e-01f, -1.85394082e-02f, 1.25416681e-01f, 4.32371236e-02f, 4.45511639e-02f, 1.53359458e-01f, -1.44956699e-02f,
  3.07283103e-01f, -5.40596247e-01f, -8.65749083e-03f, -1.24509446e-01f, -1.25755146e-01f, -2.13776559e-01f, -1.08121537e-01f, -2.34529510e-01f, -1.70898572e-01f, -2.12359633e-02f,
  -9.15244147e-02f, -1.73507556e-01f, -1.14306808e-01f, 1.09928185e-02f, -6.09006733e-02f, -6.74117878e-02f, -8.92240331e-02f, -2.81447265e-02f, 1.40090510e-01f, -1.95649937e-02f,
  1.37509182e-02f, -9.72986445e-02f, -4.46784794e-02f, 1.34241492e-01f, 5.43654785e-02f, 4.16151956e-02f, -1.10463835e-01f, -1.15914509e-01f, 7.67707592e-03f, -3.57652307e-02f,
  2.56884813e-01f, 1.04125015e-01f, -2.80518532e-01f, -6.55924976e-02f, -8.64724815e-02f, 8.86885857e-04f, 8.05983245e-02f, -2.25327983e-02f, 1.19310081e-01f, 3.38995680e-02f,
  -5.04988842e-02f, 1.00084998e-01f, -5.78065123e-03f, -1.11970425e-01f, -1.27828345e-01f, -1.31991208e-01f, -8.31956603e-03f, -5.61936274e-02f, -7.03652278e-02f, -1.68649957e-01f,
  -3.07526458e-02f, 5.86373406e-03f, -1.73881084e-01f, 7.93573484e-02f, 6.69067353e-03f, -9.42404941e-02f, 1.09184459e-02f, -1.07759060e-02f, 1.74241066e-02f, -5.74634820e-02f,
  3.28326136e-01f, -2.13556513e-01f, 2.38490254e-02f, -1.63526367e-02f, 3.04954816e-02f, -2.01770097e-01f, -1.41973481e-01f, -1.01050273e-01f, 2.50522625e-02f, 9.52091813e-02f,
  -9.48075876e-02f, -8.74596909e-02f, 8.02028179e-02f, 4.67324778e-02f, 7.71574453e-02f, -5.80119714e-03f, -5.46313599e-02f, 1.80624817e-02f, 2.01257676e-01f, 1.42122284e-01f,
  1.12895712e-01f, -6.11519720e-03f, 1.10459208e-01f, 2.59220749e-01f, 6.91998526e-02f, 1.66926816e-01f, 1.92170456e-01f, 3.54965702e-02f, 1.87756523e-01f, 1.39758766e-01f,
  1.86536625e-01f, -6.32306710e-02f, -2.36772791e-01f, 5.96169531e-01f, -4.55745049e-02f, -5.82589924e-01f, -5.26411235e-01f, -3.10590744e-01f, 4.11286682e-01f, 3.08697410e-02f,
  -1.27345428e-01f, 2.53972501e-01f, 4.58424002e-01f, 4.47171070e-02f, -2.66040176e-01f, -1.38211213e-02f, 3.45434695e-01f, 9.35751572e-02f, -4.44845289e-01f, -6.19176030e-01f,
  7.01395944e-02f, 1.17291130e-01f, 1.29660703e-02f, -1.95933700e-01f, 1.94214091e-01f, 2.12055653e-01f, 3.03334594e-01f, 1.79279640e-01f, -6.76409751e-02f, 3.74460220e-01f,
  -1.26837283e-01f, -3.31301749e-01f, -3.33033860e-01f, -1.94639694e-02f, 3.15579735e-02f, 1.93454437e-02f, -2.44420171e-01f, -8.49020109e-02f, -6.01537433e-03f, -1.08221091e-01f,
  3.95387113e-02f, -3.06251720e-02f, 2.32704327e-01f, 6.52117133e-02f, -7.32103139e-02f, -4.83252466e-01f, 9.14072171e-02f, -2.97240525e-01f, 4.10928167e-02f, -4.39756960e-01f,
  1.03440799e-01f, -2.44663030e-01f, -3.32581729e-01f, -3.46926630e-01f, -1.88884869e-01f, 1.15140148e-01f, -4.97062445e-01f, -2.41753295e-01f, -4.66811717e-01f, -5.96168116e-02f,
  1.00648686e-01f, 1.65681317e-02f, 1.07868321e-01f, 7.05977753e-02f, 6.71852008e-02f, 7.74362758e-02f, 1.95783190e-02f, 3.16166282e-02f, -4.83248383e-03f, -1.05003752e-01f,
  -8.31525102e-02f, -9.12624896e-02f, -8.01285505e-02f, -1.88676924e-01f, -9.22992453e-02f, -1.14356965e-01f, -8.72064009e-02f, -3.49597521e-02f, -3.78916524e-02f, -6.76271990e-02f,
  3.89206372e-02f, -1.27749313e-02f, 1.03180587e-01f, -4.90974002e-02f, -2.78469119e-02f, 1.47132128e-02f, 7.40448339e-03f, -1.80090934e-01f, 4.95723113e-02f, -1.91887513e-01f,
  4.13246542e-01f, -5.30190207e-02f, 7.44513189e-03f, 2.49047950e-02f, 7.53592923e-02f, -6.20105900e-02f, 1.19653963e-01f, -1.04369111e-01f, 1.75699472e-01f, -5.70962727e-02f,
  -3.80114019e-01f, -2.20588490e-01f, 9.76924077e-02f, -5.37867881e-02f, -1.62367254e-01f, -1.71835765e-01f, 1.27329335e-01f, -1.64556745e-02f, -1.27695814e-01f, -6.01593554e-02f,
  2.87294179e-01f, -2.41808623e-01f, -8.03194940e-02f, 1.56414229e-02f, -1.45543460e-03f, 7.10469112e-02f, -2.04476118e-01f, -2.53528178e-01f, -1.64973304e-01f, -1.82528682e-02f,
  -6.56076372e-01f, -2.77896255e-01f, -9.01432559e-02f, -1.72838010e-02f, 3.72841954e-01f, -4.43656258e-02f, -6.21669888e-01f, -3.16898078e-01f, 8.34140461e-03f, -2.15948701e-01f,
  3.27477723e-01f, 3.83146226e-01f, 5.45498878e-02f, -5.04271984e-02f, -6.07447028e-01f, -5.60056031e-01f, -3.17804307e-01f, -2.00824171e-01f, -1.00936458e-01f, 1.15215898e-01f,
  2.77397186e-01f, -9.74003449e-02f, -2.65433788e-01f, -6.62017390e-02f, 3.24444801e-01f, 1.76189557e-01f, 5.70914447e-02f, 3.70103456e-02f, 5.50847501e-02f, 1.82301894e-01f,
  -2.05978885e-01f, 2.25368869e-02f, 1.48385003e-01f, 2.91324914e-01f, 3.40871692e-01f, -2.31486231e-01f, -1.74330786e-01f, -8.41961876e-02f, 1.40800819e-01f, -1.62951320e-01f,
  1.94255441e-01f, 2.38433182e-01f, 1.05074465e-01f, -4.55041453e-02f, 1.81327462e-02f, -1.33836001e-01f, -1.95605323e-01f, -1.79487377e-01f, -2.93663621e-01f, -3.38244401e-02f,
  4.54855025e-01f, 2.87253231e-01f, -2.40831956e-01f, -1.97686300e-01f, -4.18256849e-01f, -1.08117335e-01f, -1.37166813e-01f, -6.29833899e-03f, -7.13886023e-01f, -5.12057066e-01f,
  5.83161563e-02f, 3.61861736e-02f, -1.19500430e-02f, -1.27126023e-01f, -5.90759292e-02f, -5.33873076e-03f, -3.57082896e-02f, -1.87000446e-02f, 6.57870397e-02f, 2.03373469e-02f,
  9.61767212e-02f, 8.22927654e-02f, 1.18625320e-01f, -5.12347110e-02f, 6.05387315e-02f, -5.18739596e-02f, 2.64963973e-02f, -9.58722010e-02f, -7.91217089e-02f, -6.97865784e-02f,
  6.80523887e-02f, -3.62164043e-02f, 1.73732087e-01f, 1.52263204e-02f, -7.21039250e-02f, -2.36699447e-01f, -1.35182627e-02f, -2.05927677e-02f, -2.55632661e-02f, -1.84643060e-01f,
  -1.73758149e-01f, 9.13013816e-02f, -8.05875212e-02f, 9.69520677e-03f, 1.29869863e-01f, 1.74364641e-01f, 7.74068013e-02f, -6.06715493e-02f, 1.18745625e-01f, -6.44324794e-02f,
  6.77453578e-02f, -1.52291819e-01f, -1.79276690e-01f, 1.15391333e-02f, -4.90826331e-02f, 9.20788795e-02f, -2.07600176e-01f, 6.15252778e-02f, -5.45887388e-02f, 2.41900235e-01f,
  -1.53996497e-01f, -2.68650025e-01f, -5.56922197e-01f, -3.92425954e-01f, -3.11488155e-02f, -2.56812423e-01f, -3.93993825e-01f, -1.26339853e-01f, -5.39085209e-01f, -8.35144937e-01f,
  -7.58729517e-01f, 5.58343567e-02f, -6.96633533e-02f, -4.31088239e-01f, -1.05472378e-01f, 8.62233862e-02f, 1.70529425e-01f, 1.63290486e-01f, 1.64800271e-01f, 1.79579213e-01f,
  2.08209887e-01f, -2.19521567e-01f, -3.24442357e-01f, -3.80090117e-01f, -4.04515952e-01f, -2.58445054e-01f, -4.99452233e-01f, -4.82763946e-01f, -3.20873737e-01f, 9.51832999e-03f,
  -1.87731743e-01f, -2.32294813e-01f, -4.37100381e-01f, -1.74765185e-01f, 8.46644640e-02f, -7.48292282e-02f, -4.76307273e-02f, -1.30478621e-01f, -1.09822802e-01f, -2.76056916e-01f,
  1.39539361e-01f, 2.58864522e-01f, 4.51604538e-02f, -2.83699542e-01f, 7.70481005e-02f, 3.88718164e-03f, 6.49740472e-02f, 8.60370919e-02f, -3.66314165e-02f, -7.45214755e-03f,
  -4.51565906e-02f, 5.54072820e-02f, 1.23629369e-01f, 2.16059372e-01f, 2.72826254e-01f, 9.15826112e-02f, -5.65598272e-02f, -2.18277335e-01f, -1.85033217e-01f, 2.61877894e-01f,
  -2.12453663e-01f, -2.98530549e-01f, -2.25327820e-01f, 1.02081805e-01f, 2.53510356e-01f, -2.42561281e-01f, 3.04553598e-01f, 1.52612612e-01f, 1.58316031e-01f, 2.46105745e-01f,
  7.61159286e-02f, 2.68536266e-02f, -6.63764849e-02f, 1.95900667e-02f, 1.50478587e-01f, 8.30648690e-02f, -5.13694771e-02f, 2.07547694e-01f, 6.80705085e-02f, 1.41561776e-01f,
  1.49491951e-01f, 2.21080437e-01f, 1.19509764e-01f, 1.62020121e-02f, -1.27203651e-02f, -5.13764396e-02f, -5.35813347e-02f, 1.29361317e-01f, 7.42970873e-03f, -9.16710198e-02f,
  -3.46038640e-02f, 1.02074966e-01f, -3.61848786e-03f, 1.49038479e-01f, 3.55780916e-03f, 2.70862747e-02f, 4.00615111e-02f, 4.27060351e-02f, 4.66206297e-02f, -4.00354378e-02f,
  2.76971906e-01f, -3.05966921e-02f, -1.59319520e-01f, -3.65481935e-02f, -3.77496108e-02f, -5.26317842e-02f, -6.92226142e-02f, -7.55003542e-02f, -7.09151179e-02f, 1.55532807e-01f,
  6.37713224e-02f, 5.68677299e-02f, 2.22417057e-01f, 5.56412078e-02f, 4.12469544e-02f, 3.77070531e-02f, -2.59629697e-01f, -2.33448118e-01f, -2.80334204e-01f, 1.57563955e-01f,
  -1.32770240e-01f, -2.66193599e-01f, -4.39881384e-01f, -7.64798149e-02f, 8.54764208e-02f, -3.41316879e-01f, 2.80155186e-02f, 1.55308545e-01f, -1.07794173e-01f, 3.07641849e-02f,
  -2.99732655e-01f, -2.08355635e-01f, 3.35993711e-03f, 2.20331237e-01f, 3.86756539e-01f, 4.35764194e-01f, 4.04516637e-01f, 2.85616308e-01f, 1.37036592e-01f, 3.84155847e-02f,
  1.02419937e-02f, -1.14448398e-01f, -9.09272358e-02f, 1.56792179e-02f, -4.30618972e-02f, 1.60601422e-01f, 2.98400253e-01f, -1.10825144e-01f, -1.76342614e-02f, 2.04519592e-02f,
  1.34826843e-02f, -2.98371017e-02f, -8.82278010e-02f, 1.04708131e-02f, 4.68842536e-02f, -6.68215230e-02f, 6.26820773e-02f, 2.55636454e-01f, 4.64930572e-02f, 8.09721872e-02f,
  -1.40012756e-01f, 6.26844168e-02f, -8.32021013e-02f, -5.11202179e-02f, -2.66030300e-02f, -1.05008855e-01f, 4.23986167e-02f, 6.37118751e-03f, 1.00018177e-02f, 1.01875789e-01f,
  7.23737776e-02f, -1.18033566e-01f, 7.27612302e-02f, -1.58650093e-02f, 1.45049006e-01f, 3.69962491e-02f, 3.95283569e-03f, 4.61057350e-02f, 1.48500368e-01f, 6.84142765e-03f,
  7.43596628e-02f, 7.75730461e-02f, 2.93726742e-01f, 1.00613743e-01f, 8.56472030e-02f, 2.60763653e-02f, 7.95943365e-02f, 1.22112103e-01f, 1.51095361e-01f, -1.50403213e-02f,
  1.29693270e-01f, 3.03087644e-02f, -5.33257164e-02f, 3.88434902e-02f, 8.34916234e-02f, 7.78287053e-02f, 2.37666622e-01f, 1.28825665e-01f, 3.13993208e-02f, -5.00211753e-02f,
  8.70390087e-02f, 1.96268380e-01f, 7.92947710e-02f, -9.40108225e-02f, -2.19522521e-01f, 7.24502467e-03f, 5.50644472e-02f, 3.45554613e-02f, 1.38147116e-01f, 1.96527809e-01f,
  -1.46357864e-02f, 1.47536442e-01f, 3.37109268e-02f, 3.61328721e-02f, 6.60322756e-02f, 1.87716886e-01f, 1.27157003e-01f, 2.95949411e-02f, -6.85227886e-02f, -2.26253998e-02f,
  2.65777022e-01f, -3.47321555e-02f, -1.25802621e-01f, 3.05620693e-02f, 2.97843292e-02f, -7.81700090e-02f, -1.01871155e-01f, -4.81911143e-03f, 7.22697154e-02f, 1.18185893e-01f,
  5.12791658e-03f, -1.17387772e-01f, 4.12134454e-02f, -9.23116282e-02f, -1.57060862e-01f, 2.95207649e-02f, -9.05467272e-02f, 1.05230734e-01f, 3.80362347e-02f, -3.16205285e-02f,
  2.22319327e-02f, 2.68269982e-02f, 5.44695593e-02f, 3.12799998e-02f, -5.00554554e-02f, -4.61353746e-04f, -1.11424245e-01f, 6.72932044e-02f, 3.47015597e-02f, 3.28322500e-02f,
  3.92671436e-01f, -3.36236596e-01f, -3.61676328e-03f, -3.77308726e-02f, -1.96497113e-01f, -1.10163040e-01f, -1.62629128e-01f, -1.73672572e-01f, -1.11494564e-01f, -4.67912480e-02f,
  3.03525105e-02f, 2.23922536e-01f, 1.16903268e-01f, 2.55124774e-02f, 7.84374252e-02f, -9.69846249e-02f, -1.56063154e-01f, 2.22956035e-02f, 5.16556203e-02f, -3.72729972e-02f,
  -9.31962132e-02f, -1.52535945e-01f, -9.84086394e-02f, -4.48262878e-02f, -2.80386180e-01f, 2.30963863e-02f, -8.51956308e-02f, -2.34706715e-01f, -1.99954525e-01f, -2.97500372e-01f,
  4.75618541e-02f, -1.28437310e-01f, -3.26097757e-02f, -8.59083161e-02f, 2.26250086e-02f, 3.54772480e-03f, 8.43287036e-02f, -7.24214241e-02f, -1.72671396e-03f, -1.62727416e-01f,
  -1.77176818e-02f, -2.59551909e-02f, 1.95698645e-02f, 3.35877202e-02f, -1.24907345e-01f, -6.54662326e-02f, -4.57669012e-02f, -4.82135750e-02f, -2.32834667e-02f, -8.62022804e-04f,
  -1.15757920e-01f, -9.69904568e-03f, 3.59698460e-02f, 1.08621739e-01f, 5.77631369e-02f, 1.16703063e-01f, -7.59323454e-03f, -3.45833972e-02f, 8.86770934e-02f, 1.13385275e-01f,
  -2.17647910e-01f, 1.19247958e-01f, 8.04475918e-02f, 2.20568612e-01f, 1.07559122e-01f, 2.10466031e-02f, -2.46999599e-02f, -6.12240881e-02f, 1.21432044e-01f, 1.08909875e-01f,
  -7.71095082e-02f, 1.00446373e-01f, 3.88717316e-02f, 7.96453729e-02f, 6.05664067e-02f, -1.48245946e-01f, -2.32934430e-02f, -8.50183442e-02f, -5.56193991e-03f, 2.55573411e-02f,
  5.64537868e-02f, -1.81237787e-01f, -1.80122122e-01f, -1.30334288e-01f, -2.12706670e-01f, -7.00154826e-02f, -9.35837254e-02f, 2.86309049e-02f, -5.73723279e-02f, -1.41005233e-01f,
  9.43547413e-02f, 2.14660585e-01f, 1.99747771e-01f, 1.78649742e-02f, 3.41057107e-02f, -1.15042478e-01f, 2.73567796e-01f, -9.85862985e-02f, -1.27611175e-01f, -1.12008989e-01f,
  2.46417299e-02f, 7.51974508e-02f, -3.77258658e-02f, -3.36516090e-02f, 1.94941893e-01f, 1.33853152e-01f, 1.54755861e-01f, -4.48794849e-03f, -5.27209938e-02f, -1.56431928e-01f,
  -5.21409698e-02f, 1.11410663e-01f, 1.67784825e-01f, 2.09843934e-01f, 2.10500821e-01f, 1.86135754e-01f, 1.22847892e-01f, -4.63740379e-02f, 9.86498445e-02f, 2.34554753e-01f,
  -4.43360299e-01f, 2.37985015e-01f, -7.83627093e-01f, 5.48422076e-02f, 7.19591901e-02f, 2.52144128e-01f, 4.33800727e-01f, 3.97374183e-01f, 1.23969406e-01f, 3.04203224e-03f,
  2.63637733e-02f, 2.37921044e-01f, 1.31502286e-01f, -8.57116207e-02f, 5.70907742e-02f, 7.42779225e-02f, 6.06361125e-03f, -3.47520798e-01f, -9.21279714e-02f, 2.72660583e-01f,
  3.29648882e-01f, 2.08694607e-01f, -5.61483055e-02f, 1.37072995e-01f, -3.49144228e-02f, -6.64332474e-04f, -1.34787455e-01f, -3.23267758e-01f, -1.43853828e-01f, -6.18497908e-01f,
  -7.69550145e-01f, -3.09950143e-01f, 1.03774220e-01f, 7.07332566e-02f, -1.45359874e-01f, 5.31982817e-02f, 1.35014087e-01f, -6.13538846e-02f, 2.97671765e-01f, -8.82347152e-02f,
  2.96012554e-02f, 7.18507171e-03f, 2.16920659e-01f, 1.09812155e-01f, 1.63909093e-01f, 2.90628802e-02f, 3.06259841e-03f, -2.03092277e-01f, -2.43686169e-01f, -1.27356231e-01f,
  2.19362423e-01f, -7.36076459e-02f, -3.26198965e-01f, 2.24196658e-01f, -6.08379729e-02f, -1.07087167e-02f, -1.18633807e-01f, -2.61856019e-01f, -2.15613320e-01f, -4.31690246e-01f,
  8.30487758e-02f, -5.57529218e-02f, -5.40737770e-02f, 1.56960776e-03f, 8.72030016e-03f, -1.16381861e-01f, -6.40261266e-03f, -2.03151092e-01f, -6.91283718e-02f, 2.57166270e-02f,
  1.65186618e-02f, -1.57849211e-02f, -6.39651343e-02f, 5.40585630e-02f, 6.77926838e-02f, 4.93805297e-02f, -1.30594119e-01f, -1.09181561e-01f, -2.07200289e-01f, 4.20080461e-02f,
  -2.92632394e-02f, -1.98851928e-01f, -3.13910134e-02f, 9.98662412e-02f, -8.33512843e-02f, -1.21725008e-01f, 4.49973457e-02f, 8.73074457e-02f, 1.29048124e-01f, 1.94943324e-01f,
  5.75772524e-02f, 3.00884485e-01f, -3.15614522e-01f, 2.00876817e-01f, -3.20891589e-01f, -6.12454042e-02f, 6.51827231e-02f, -1.01023413e-01f, -6.35645958e-03f, 6.75854683e-02f,
  9.00969431e-02f, -1.58613235e-01f, 2.05115438e-01f, -4.43722941e-02f, 4.58339266e-02f, -2.71433033e-02f, -6.86918199e-02f, -3.13186198e-01f, 3.47721693e-03f, -9.38635319e-02f,
  -7.25534260e-02f, -1.18567355e-01f, -2.80756325e-01f, -1.38834938e-01f, -3.52908261e-02f, -1.11228392e-01f, -1.89170003e-01f, -2.34575048e-01f, -1.89209685e-01f, -2.20296830e-01f,
  6.26552582e-01f, 5.37386656e-01f, -2.48083159e-01f, 1.73976287e-01f, 3.93056311e-02f, -1.35128483e-01f, 4.17517900e-01f, 6.44136444e-02f, 5.16713746e-02f, 4.50421989e-01f,
  1.19798541e-01f, -5.45158923e-01f, -2.74378806e-01f, -4.70438719e-01f, -3.72322828e-01f, 3.08257252e-01f, 5.52604236e-02f, -3.49506438e-01f, -7.01338112e-01f, -3.54797214e-01f,
  -4.85549644e-02f, 1.22195587e-01f, 2.71596238e-02f, -1.05543457e-01f, 1.83605134e-01f, -2.14497685e-01f, 2.56151229e-01f, 3.25778127e-01f, 2.57791113e-02f, 1.34812921e-01f,
  -1.00688912e-01f, 4.03977603e-01f, -7.13346958e-01f, -1.91494256e-01f, 1.30194560e-01f, -1.32348642e-01f, -2.02819049e-01f, -8.33665878e-02f, -2.11290363e-02f, 2.39665750e-02f,
  -3.88171405e-01f, -2.11022004e-01f, -1.00207515e-01f, -1.61599517e-01f, -6.49192259e-02f, -1.35698467e-01f, 4.93928306e-02f, -3.33648592e-01f, -1.86869711e-01f, -4.37790565e-02f,
  -1.50261316e-02f, -2.97414418e-02f, 1.68425336e-01f, -5.68044698e-03f, -1.82736233e-01f, -2.15423509e-01f, 1.28427073e-01f, -2.65065283e-01f, -1.17676720e-01f, 5.15381992e-01f,
  1.61796346e-01f, 4.81741838e-02f, -6.40031546e-02f, 4.24271412e-02f, 4.87111658e-02f, -1.51345775e-01f, 1.07129678e-01f, 1.39338404e-01f, -1.12216085e-01f, 2.21452024e-02f,
  -5.82606308e-02f, 2.53991425e-01f, -5.08769527e-02f, 1.30199745e-01f, -1.22068472e-01f, 2.76760478e-02f, 5.21938913e-02f, 2.77863413e-01f, 3.85850407e-02f, -5.14188483e-02f,
  -1.81523830e-01f, 5.15672043e-02f, -1.32103860e-01f, -9.92365181e-02f, -6.86101196e-03f, -9.37773660e-02f, 4.64529246e-02f, -4.97748032e-02f, 1.48517951e-01f, -1.99771691e-02f,
  -2.46166259e-01f, -2.84966588e-01f, 1.12289734e-01f, -1.21311843e-01f, 1.02301553e-01f, -2.66673446e-01f, 7.96837881e-02f, 1.87661111e-01f, 1.62433490e-01f, 9.28493068e-02f,
  -2.63180286e-02f, -6.80024400e-02f, 1.02079965e-01f, -1.56416036e-02f, -3.17386121e-01f, -5.76593839e-02f, 2.18927622e-01f, 7.36059668e-03f, -2.19273254e-01f, 1.76912159e-01f,
  2.83747554e-01f, 6.06422499e-02f, 5.17647937e-02f, 6.22485206e-02f, 1.04881898e-01f, -1.19036369e-01f, 6.17081858e-02f, -9.46837664e-02f, -8.96084905e-02f, 6.29139960e-01f,
  -2.21587028e-02f, 1.00544199e-01f, -4.43204820e-01f, 1.35972556e-02f, 1.39518932e-01f, -1.94335178e-01f, -1.28493592e-01f, -2.29264393e-01f, 3.72010887e-01f, 1.99648678e-01f,
  1.17514089e-01f, -1.49202868e-01f, -1.71907619e-01f, -3.84829670e-01f, -5.25261045e-01f, -1.37076035e-01f, -1.86563700e-01f, -5.30431271e-01f, -7.26678133e-01f, -2.65129119e-01f,
  -4.58674692e-02f, -2.08667070e-01f, -4.30273533e-01f, -2.65805542e-01f, 1.72854587e-01f, -2.43093342e-01f, 7.95069709e-02f, -6.91361725e-02f, -1.60741061e-01f, 9.13704410e-02f,
  4.65173051e-02f, 1.72924269e-02f, -1.57904074e-01f, -2.21395180e-01f, 1.32333115e-01f, -1.16449366e-04f, 1.24958223e-02f, 3.24472114e-02f, 6.91385418e-02f, -2.94804368e-02f,
  -1.37628037e-02f, 1.71576273e-02f, 1.35640474e-02f, -3.68955657e-02f, -1.25686288e-01f, -2.07182825e-01f, -1.06184795e-01f, -3.50552708e-01f, -2.54346281e-02f, 8.00915882e-02f,
  1.59695223e-01f, -3.72029543e-02f, -4.41279322e-01f, -1.42425910e-01f, 3.88714708e-02f, -1.24208607e-01f, -2.06467658e-01f, -2.94234417e-02f, -1.85892850e-01f, 1.50251374e-01f,
  1.09699652e-01f, 1.61699727e-01f, 8.43590349e-02f, 2.54440643e-02f, 2.92455405e-02f, 1.50851831e-01f, -1.04334533e-01f, -1.39312923e-01f, -4.80823964e-02f, 1.00671925e-01f,
  9.83990729e-02f, 5.14046662e-02f, -7.21929083e-03f, 1.05597347e-01f, -1.16999149e-01f, -1.90243050e-01f, -1.44944862e-01f, -3.44583020e-02f, -1.27331838e-01f, -7.82728121e-02f,
  -1.89049363e-01f, -2.68493742e-01f, 1.71348765e-01f, -1.78646728e-01f, -2.33554952e-02f, 5.60519472e-02f, 1.00510672e-01f, -3.68741453e-01f, 4.61124666e-02f, -8.00019279e-02f,
  -2.74064112e-02f, -2.99771667e-01f, 1.09616607e-01f, -3.83242875e-01f, 4.55871448e-02f, 2.42386758e-01f, 1.39754996e-01f, -8.92463550e-02f, 6.91355988e-02f, -1.77988157e-01f,
  -2.48544976e-01f, 6.25782236e-02f, 2.05815762e-01f, -8.58087689e-02f, -2.02314436e-01f, 6.58009201e-02f, 7.81208351e-02f, -2.02195019e-01f, -1.74713522e-01f, 2.64578164e-01f,
  1.02254689e-01f, -1.15578897e-01f, -3.66513759e-01f, -9.59411636e-02f, 1.08741954e-01f, -3.87574643e-01f, -4.46837306e-01f, -2.29063272e-01f, -3.98518622e-01f, 4.15291861e-02f,
  6.47027731e-01f, -7.25420237e-01f, -2.65715808e-01f, 1.73021927e-01f, 8.27286951e-03f, 3.52599174e-02f, -1.92336753e-01f, 1.26821017e-02f, 2.15384766e-01f, -3.04137290e-01f,
  -2.71712363e-01f, 2.72065448e-03f, 9.67754647e-02f, -7.32212961e-02f, -1.36774465e-01f, -2.33923808e-01f, -2.16466859e-01f, -8.80550444e-02f, 3.26166570e-01f, 4.21438180e-03f,
  -2.28907287e-01f, 1.88289806e-01f, 8.77917707e-02f, 3.45870219e-02f, -1.05248079e-01f, -3.08858585e-02f, -1.13125913e-01f, -1.53380007e-01f, -3.70478511e-01f, -4.26113933e-01f,
  9.03207660e-02f, -2.36695603e-01f, 1.08689750e-02f, -6.69270754e-02f, -1.93307921e-02f, -5.54707088e-02f, 9.25712585e-02f, 2.97077391e-02f, 1.03009984e-01f, 1.02619797e-01f,
  -6.68954402e-02f, -1.13704698e-02f, 7.81052858e-02f, 3.72724049e-02f, 1.08161762e-01f, -9.41169262e-03f, 7.39019504e-03f, -1.23435162e-01f, 3.02463421e-03f, -1.96388409e-01f,
  -3.18364710e-01f, -6.18192814e-02f, 1.87192917e-01f, 1.19260207e-01f, 2.94074733e-02f, 8.66422430e-02f, -8.47691074e-02f, 5.59150279e-02f, 1.01599559e-01f, 3.74575481e-02f,
  -1.60689071e-01f, 1.18266203e-01f, 6.53265864e-02f, 6.86096549e-02f, 1.67843848e-01f, 1.20016992e-01f, 6.49669990e-02f, 1.52482037e-02f, 9.98251811e-02f, 3.09855975e-02f,
  6.45426214e-02f, -1.52857214e-01f, 2.84774993e-02f, -3.23515385e-02f, -9.77450162e-02f, 6.65572286e-02f, -1.57059617e-02f, -8.31773430e-02f, -1.40982702e-01f, -4.04270366e-02f,
  -2.09907871e-02f, 1.60343461e-02f, 4.62987414e-03f, -6.94486052e-02f, -2.75254518e-01f, -8.33057612e-03f, -1.11449368e-01f, -1.52669027e-01f, 4.89098132e-02f, -2.94206254e-02f,
  3.25597316e-01f, -1.70020729e-01f, 3.99048068e-02f, -1.10181145e-01f, 3.90717993e-03f, -1.57187521e-01f, -1.33408651e-01f, -5.56220673e-02f, 4.07205150e-02f, -3.30702029e-02f,
  -9.82798561e-02f, 9.94410515e-02f, -4.16988693e-02f, -3.27716470e-02f, 2.47614279e-01f, 4.58796807e-02f, -2.33755380e-01f, -5.41891940e-02f, -8.18725303e-02f, -6.89232126e-02f,
  -1.42952174e-01f, 1.93765126e-02f, 3.00230861e-01f, 2.33544961e-01f, 1.71181276e-01f, 2.45165586e-01f, 2.29988590e-01f, 1.37135029e-01f, 8.87350067e-02f, 2.61210710e-01f,
  -7.24438190e-01f, -1.57528177e-01f, -4.48547572e-01f, -8.68067816e-02f, 4.43290174e-01f, 8.93349200e-02f, -8.80548954e-02f, -3.32131714e-01f, -8.09681192e-02f, -1.20002694e-01f,
  1.18293956e-01f, 1.85810253e-01f, 1.56495169e-01f, 2.27080077e-01f, -3.98561507e-02f, 7.94654265e-02f, 2.23707333e-01f, -3.03318724e-02f, -7.44386017e-02f, 1.94109961e-01f,
  3.44378382e-01f, -3.02969851e-02f, -3.88850003e-01f, -6.42563254e-02f, 2.15467438e-01f, 2.43494272e-01f, -1.12367831e-01f, 1.55968428e-01f, 2.98941344e-01f, 5.02202809e-01f,
  -1.89593792e-01f, -4.08227712e-01f, 2.61054635e-02f, 1.54166341e-01f, 1.13301851e-01f, -1.58598587e-01f, -2.14334384e-01f, -1.60108969e-01f, 1.06394164e-01f, -6.21013157e-02f,
  1.32848606e-01f, 5.33899479e-02f, 1.73830345e-01f, 4.32712026e-03f, -1.25787526e-01f, -2.41158143e-01f, -2.45941401e-01f, -2.94076711e-01f, -3.07978272e-01f, -8.27158168e-02f,
  8.11553121e-01f, 3.05089921e-01f, -3.48742455e-01f, -1.87135622e-01f, -3.89920145e-01f, 1.55228615e-01f, -5.31014688e-02f, -2.43107416e-02f, -5.43513119e-01f, -1.63412452e-01f,
  -7.51151412e-04f, -1.92135759e-02f, -6.80083409e-02f, -1.28591061e-01f, 1.66415423e-01f, 8.26538540e-04f, -1.07915606e-02f, 2.20218986e-01f, 9.02275518e-02f, -8.22484344e-02f,
  8.30253400e-03f, -1.56913385e-01f, -1.17152156e-02f, -2.17838094e-01f, 1.44983649e-01f, -1.27775013e-01f, 6.76541701e-02f, -8.25131014e-02f, -9.70551453e-04f, -3.59219350e-02f,
  -5.69257066e-02f, -9.68858227e-03f, -1.36475444e-01f, -6.23598788e-03f, -5.76097227e-04f, -1.53530389e-01f, -1.31240457e-01f, 2.16840580e-02f, -9.75667760e-02f, -8.55193734e-02f,
  -4.97449726e-01f, -3.65680978e-02f, -7.03711882e-02f, 1.51303947e-01f, 1.00336991e-01f, 7.53236860e-02f, 2.02917144e-01f, 1.87507287e-01f, -5.58061898e-02f, -1.76095054e-01f,
  -2.48427004e-01f, -1.03024669e-01f, -1.20667696e-01f, 2.27423012e-03f, -7.10409209e-02f, 5.21798432e-02f, 1.35045290e-01f, 1.01386338e-01f, -7.92701617e-02f, 2.55504921e-02f,
  1.59898639e-01f, -1.64587930e-01f, -3.71015787e-01f, -2.36856163e-01f, -2.53463835e-01f, -4.65850383e-02f, -1.72035128e-01f, -2.26988271e-01f, -4.34333175e-01f, -3.97437543e-01f,
  3.17441486e-02f, 7.41918802e-01f, 2.90936768e-01f, -2.10371241e-01f, -1.84574109e-02f, 2.14407872e-02f, 1.09144069e-01f, 1.68604285e-01f, 8.53599235e-02f, 1.39438808e-01f,
  -6.69514835e-02f, -3.28231275e-01f, -9.93288010e-02f, -1.24623664e-02f, 6.44355714e-02f, 3.07961941e-01f, 2.56899029e-01f, -6.70737997e-02f, -4.57776308e-01f, -3.18150997e-01f,
  -2.95820624e-01f, -3.11957270e-01f, -3.71046424e-01f, -1.15226381e-01f, 5.08286297e-01f, -2.21198171e-01f, 3.19109052e-01f, 2.30881691e-01f, 2.69832879e-01f, 6.90910876e-01f,
  1.58382669e-01f, 5.57915151e-01f, -4.94235307e-01f, -1.53699353e-01f, -3.76313142e-02f, 1.42433971e-01f, 3.95667255e-02f, 2.40180477e-01f, 9.45885703e-02f, 2.06403822e-01f,
  5.72334528e-02f, 2.18446225e-01f, 6.24965616e-02f, 2.24160358e-01f, 2.32423581e-02f, -5.94248809e-02f, 2.99431384e-01f, 1.71436697e-01f, 9.91079677e-03f, 1.69006079e-01f,
  -6.30769208e-02f, -2.87792146e-01f, -8.12469870e-02f, 9.89313945e-02f, 2.12191239e-01f, -5.15380502e-01f, -2.08769385e-02f, 5.30355982e-02f, -2.07940772e-01f, 1.93275273e-01f,
  -6.13444969e-02f, 9.25269201e-02f, 4.08022031e-02f, 1.53401360e-01f, 1.95580767e-03f, 1.75525934e-01f, 1.72103763e-01f, -5.29597625e-02f, -1.54898255e-04f, 7.10063577e-02f,
  7.24662170e-02f, -1.23231359e-01f, 1.78046525e-01f, 1.23373955e-01f, -1.82979420e-01f, 2.19166689e-02f, -2.52444483e-02f, -8.26670080e-02f, -1.34351760e-01f, -1.36093260e-03f,
  -1.67751327e-01f, 1.31170088e-02f, -1.00992329e-01f, 5.86982034e-02f, 4.13123108e-02f, 6.98354989e-02f, -5.27034253e-02f, -2.87356693e-02f, -1.15975020e-02f, 8.47449452e-02f,
  -2.95625269e-01f, -3.47281426e-01f, -4.27653790e-02f, 1.32807836e-01f, 1.31592914e-01f, -1.00800820e-01f, -9.19093043e-02f, -8.22916031e-02f, 3.17826085e-02f, -1.95348933e-01f,
  -2.65184157e-02f, -8.49441905e-03f, 6.61824420e-02f, 4.43173107e-03f, -2.81687409e-01f, 1.69193011e-03f, -3.80264148e-02f, -4.01242040e-02f, -1.17985412e-01f, 1.72060311e-01f,
  -1.00545347e-01f, -4.66768742e-01f, -6.47933364e-01f, -2.22896606e-01f, -2.62269557e-01f, -7.91454375e-01f, -3.55348468e-01f, -3.29497010e-01f, -5.27692020e-01f, -3.32393795e-01f,
  -1.70720473e-01f, -5.32778800e-01f, -1.52912021e-01f, -6.09608889e-01f, -3.37818235e-01f, -3.25500309e-01f, -6.49808764e-01f, -4.57220227e-01f, -1.85077980e-01f, -6.77100122e-01f,
  -2.34333202e-01f, 3.28510702e-01f, 3.39344025e-01f, 6.87527210e-02f, -1.86662972e-01f, -7.70079732e-01f, -4.17875707e-01f, 1.56893671e-01f, 4.06355746e-02f, -5.54133654e-01f,
  -6.23081744e-01f, -4.32655513e-01f, 1.38174757e-01f, 1.45972986e-02f, -2.90761679e-01f, 1.77492440e-01f, -5.22691421e-02f, -1.24999784e-01f, -1.15603106e-02f, -6.32463023e-02f,
  -3.51257890e-01f, -2.70313863e-02f, 2.75236040e-01f, 1.95154145e-01f, -2.24076986e-01f, 1.47661626e-01f, -1.45362064e-01f, 1.58640087e-01f, 1.38455257e-01f, -8.83769840e-02f,
  3.46641243e-02f, -6.37281127e-03f, 2.28397846e-01f, -4.28510234e-02f, -2.20904052e-01f, -8.87382925e-02f, -1.42549425e-01f, -4.68748473e-02f, 2.30308950e-01f, -3.02857995e-01f,
  -2.41390541e-01f, -6.77544624e-02f, 1.46227866e-01f, 7.72338733e-02f, 2.94220652e-02f, 2.22884402e-01f, -9.68454592e-03f, 1.98469937e-01f, 2.48547286e-01f, -1.18812680e-01f,
  -1.86071396e-01f, 8.76765251e-02f, -7.74352625e-02f, -9.47049260e-02f, 6.30611405e-02f, -6.94926828e-02f, 1.27928881e-02f, -3.51020135e-02f, 3.90748493e-02f, -8.35859105e-02f,
  -1.64912909e-01f, -4.57171872e-02f, -2.17518769e-02f, 6.79272339e-02f, -1.77924931e-02f, -1.25949964e-01f, -6.06991574e-02f, -8.19692463e-02f, -3.05985864e-02f, 1.18608035e-01f,
  4.75172289e-02f, -2.43841838e-02f, 4.21197563e-02f, -9.69864428e-02f, 1.43061662e-02f, 9.99384560e-03f, 5.50310314e-02f, -1.85685251e-02f, 2.13426072e-02f, -3.73964780e-03f,
  -1.80544361e-01f, 4.03165609e-01f, -2.01465294e-01f, 5.58363311e-02f, -8.50073621e-02f, 9.37408432e-02f, 1.20020412e-01f, 2.63100024e-02f, 1.67479470e-01f, -2.58028001e-01f,
  -3.92568856e-02f, -3.75210226e-01f, 3.35247032e-02f, 8.50906223e-02f, -2.55806483e-02f, 2.84925643e-02f, -3.27923745e-01f, -1.97076723e-01f, 7.74529576e-02f, -3.59152436e-01f,
  -2.46948272e-01f, -1.30686432e-01f, -1.77992046e-01f, 2.58010277e-03f, 5.64631373e-02f, 3.73042673e-02f, -6.09779134e-02f, -1.17172897e-01f, 1.17828377e-01f, -3.69404554e-01f,
  5.46423733e-01f, 1.10568888e-01f, -3.42499435e-01f, -1.01284741e-03f, -4.84250300e-02f, -2.41550282e-02f, 1.49354786e-01f, 7.11333901e-02f, 1.52913872e-02f, 6.06450737e-02f,
  2.19654039e-01f, 1.14768073e-01f, -2.28589848e-02f, -4.43078764e-02f, 1.02126755e-01f, 7.62077421e-03f, -1.26027763e-01f, -1.30609095e-01f, -4.20503356e-02f, 1.59908563e-01f,
  1.49635583e-01f, 7.79410899e-02f, 7.61392638e-02f, -9.65260267e-02f, -1.35036215e-01f, -6.74037822e-03f, -1.45006821e-01f, 2.36887932e-02f, 5.93265705e-03f, -2.91361451e-01f,
  -1.52907610e-01f, 1.63149923e-01f, 7.82868490e-02f, 6.42851815e-02f, 1.40704244e-01f, 1.09260634e-01f, -2.18192320e-02f, -7.98324030e-03f, 8.76234025e-02f, -2.28252877e-02f,
  -1.49337888e-01f, 6.35235012e-02f, 2.00686409e-04f, 8.78955424e-03f, 6.37151077e-02f, -4.94793691e-02f, 1.17464475e-02f, -9.16143060e-02f, 7.20036179e-02f, 1.24848187e-01f,
  1.28350899e-01f, 1.20209135e-01f, 9.85184833e-02f, 9.34803113e-02f, -6.60153746e-04f, -5.57429343e-02f, -3.23326625e-02f, 1.11847818e-01f, 7.45308911e-03f, 1.14948824e-02f,
  2.76981324e-01f, 2.91305006e-01f, 1.61162674e-01f, 1.89845875e-01f, 2.04387665e-01f, 3.65237333e-02f, -6.51244298e-02f, 1.33578151e-01f, 1.17363650e-02f, 4.11432572e-02f,
  -8.42120275e-02f, 8.38336498e-02f, 8.61338377e-02f, 2.03766692e-02f, -1.26850277e-01f, 7.24762008e-02f, 2.63662729e-02f, 1.58892900e-01f, 1.36575744e-01f, 9.65365767e-02f,
  5.33809774e-02f, 3.35829481e-02f, -9.19528678e-02f, 3.22090387e-02f, 1.39006171e-02f, -9.86284763e-03f, 1.13179468e-01f, 2.70377874e-01f, 1.07981816e-01f, -9.26717930e-03f,
  -5.58605157e-02f, 2.24662378e-01f, 6.95355907e-02f, -1.24670692e-01f, -1.34843335e-01f, -9.05678123e-02f, -9.42987204e-02f, 1.88371129e-02f, -1.75601557e-01f, -2.42901266e-01f,
  -7.42047578e-02f, -1.32957891e-01f, -7.51880854e-02f, -1.15037076e-01f, -1.01294443e-01f, -3.38930786e-02f, 5.78857809e-02f, -8.20755139e-02f, 2.84806173e-02f, -9.26354900e-02f,
  -7.19076917e-02f, 2.30626259e-02f, 5.58701605e-02f, -2.37709563e-02f, 7.05151707e-02f, 8.87581483e-02f, -2.30006054e-02f, -7.53914341e-02f, -2.24465691e-03f, 1.05948687e-01f,
  -6.38311863e-01f, 3.35878223e-01f, 5.85961461e-01f, -2.92751461e-01f, -1.03286751e-01f, -1.06230967e-01f, -2.06752181e-01f, -3.89246106e-01f, -3.19508970e-01f, 1.67139739e-01f,
  3.34334403e-01f, -7.73132592e-02f, 2.58566380e-01f, -9.16545019e-02f, -3.69095773e-01f, -1.05186421e-02f, -2.14873608e-02f, -3.50560874e-01f, -7.04160869e-01f, -6.06672406e-01f,
  -4.10718501e-01f, -2.92571485e-01f, -3.56219560e-01f, -2.46260107e-01f, 2.66844183e-01f, 1.09454365e-02f, 4.51831162e-01f, 1.65545754e-03f, 2.71843770e-03f, 3.07663709e-01f,
  4.93025005e-01f, 2.78241225e-02f, -2.18684256e-01f, -3.33644480e-01f, 9.07737315e-02f, -1.71298414e-01f, -1.20008692e-01f, 5.64571843e-02f, -6.10561743e-02f, 3.29071991e-02f,
  1.08615160e-01f, -1.46209151e-01f, -1.32608071e-01f, 9.41095408e-03f, -1.90264761e-01f, -3.28633219e-01f, -2.35754550e-01f, -3.45417023e-01f, -1.86370507e-01f, 1.04269639e-01f,
  -3.93080376e-02f, 5.69494115e-03f, 3.27001035e-01f, 7.03442246e-02f, 1.52161447e-02f, -5.32162786e-02f, 2.88827270e-01f, 2.45465841e-02f, 4.65662079e-03f, 2.20835418e-01f,
  -1.60492316e-01f, 6.01011142e-03f, -1.62762925e-01f, 7.38499239e-02f, -1.40698269e-01f, 1.09172473e-02f, 6.35292754e-03f, -6.97384253e-02f, -1.01601891e-01f, 5.01184613e-02f,
  4.07613143e-02f, 5.76794557e-02f, 1.67715084e-02f, 4.71966304e-02f, 1.56181946e-01f, -6.60508499e-02f, -6.37247115e-02f, -3.77141573e-02f, -5.65235876e-02f, 1.96449738e-02f,
  -1.99017897e-01f, -5.84733337e-02f, 4.21850458e-02f, -9.74124484e-03f, -7.37999799e-03f, -1.03561275e-01f, -3.84978466e-02f, -8.45915303e-02f, -3.55582722e-02f, -6.02046102e-02f,
  2.89666355e-01f, -1.59100756e-01f, 2.16603413e-01f, -3.21267307e-01f, 6.03084378e-02f, 1.14585005e-01f, 1.60472065e-01f, -1.88890412e-01f, 2.15345025e-01f, -2.83263680e-02f,
  -6.07265458e-02f, -1.55011192e-02f, 1.71514928e-01f, 3.47876102e-02f, -3.55482519e-01f, 2.49599237e-02f, -2.55302280e-01f, 8.64098072e-02f, -2.00014099e-01f, -4.76358533e-02f,
  -1.47728562e-01f, -2.27465406e-01f, -7.99917206e-02f, 1.13707744e-01f, -6.06280006e-03f, -8.80111903e-02f, 3.36230844e-01f, 7.92638063e-02f, -7.09959567e-02f, 8.93646106e-02f,
  -5.99689543e-01f, -6.58977509e-01f, -5.37345409e-01f, -9.33260560e-01f, -6.37798429e-01f, -3.61906201e-01f, -3.56677681e-01f, -1.81259170e-01f, -2.40641505e-01f, -4.24458593e-01f,
  -1.33996010e-01f, -1.97271451e-01f, -1.65522531e-01f, 8.03124830e-02f, 4.90716279e-01f, -1.41763121e-01f, 1.02048097e-02f, 1.59384653e-01f, 1.30446836e-01f, -1.12777054e-01f,
  -2.20976517e-01f, -4.52401817e-01f, -9.49500501e-02f, -1.79764945e-02f, -7.47414589e-01f, -4.50465679e-01f, -4.33689713e-01f, -3.99126500e-01f, 4.02305275e-02f, -5.78227699e-01f,
  -5.48805654e-01f, -3.05944026e-01f, 7.13606030e-02f, 2.38199979e-02f, -3.60397756e-01f, -5.99780865e-02f, -2.01422751e-01f, -4.38960493e-02f, 8.70974362e-02f, -1.61962271e-01f,
  -2.52945691e-01f, 5.84991947e-02f, -6.95367754e-02f, -2.99207084e-02f, -4.25822228e-01f, -8.30448344e-02f, 3.18730362e-02f, 8.12326521e-02f, 2.11505577e-01f, 5.93151823e-02f,
  1.17965497e-01f, 6.58800304e-02f, 3.19635160e-02f, 1.81327730e-01f, 3.04034740e-01f, 3.25909317e-01f, 6.55730546e-04f, 1.47873849e-01f, 4.51020122e-01f, -3.23296100e-01f,
  8.79656971e-02f, -1.27135187e-01f, -5.86807206e-02f, -2.52495278e-02f, 2.29040504e-01f, 1.04342967e-01f, -7.68086761e-02f, -9.93935168e-02f, 1.92504346e-01f, -1.16660640e-01f,
  -1.80834103e-02f, 1.34007081e-01f, 6.02118410e-02f, 1.09489625e-02f, -1.08437099e-01f, -3.52240689e-02f, 1.30875051e-01f, -4.14427146e-02f, 8.57926160e-02f, 8.34185705e-02f,
  -1.20196529e-02f, -4.13328782e-02f, -1.17934473e-01f, -1.71438083e-02f, 7.01680183e-02f, 2.92490348e-02f, 7.85097852e-02f, 2.29076147e-02f, -1.61837012e-01f, -2.37570591e-02f,
  -6.50379598e-01f, 6.21716440e-01f, -5.35236359e-01f, 4.06825691e-02f, -1.32615715e-01f, 8.90361443e-02f, -2.33693704e-01f, 7.04246536e-02f, -1.83278024e-01f, -1.02794290e-01f,
  5.48042990e-02f, -3.17157544e-02f, -1.05561845e-01f, -4.80530187e-02f, -6.23152852e-02f, -1.07982662e-02f, 1.36642903e-01f, -2.61416823e-01f, 1.34158537e-01f, 2.19128397e-03f,
  2.44396716e-01f, 1.76558942e-02f, -2.29369164e-01f, -6.62296414e-02f, 4.56033386e-02f, 1.20514140e-01f, -1.63284242e-01f, -4.00735624e-03f, 1.76986337e-01f, -1.80466846e-01f,
  6.57574475e-01f, 3.62411290e-02f, 2.90305197e-01f, 1.07863672e-01f, 2.91560084e-01f, 3.23693752e-01f, 2.44087815e-01f, 1.09538145e-01f, 7.26345107e-02f, 8.23940560e-02f,
  -1.97616667e-02f, -1.11721298e-02f, 1.21489968e-02f, -5.26565015e-02f, -2.50080880e-02f, 1.54847009e-02f, -8.22737440e-02f, 2.10509285e-01f, 1.49253651e-01f, 1.26021355e-01f,
  -5.86423837e-02f, -1.26495194e-02f, 2.40452871e-01f, -1.41082145e-02f, 2.09143870e-02f, -1.66590557e-01f, 9.93916020e-02f, 9.17353258e-02f, 6.96958527e-02f, -2.70508587e-01f,
  -6.53426051e-02f, 4.06612307e-01f, -6.56372011e-02f, -1.87336251e-01f, 5.75160496e-02f, 2.90271137e-02f, 1.07687153e-01f, -8.01768377e-02f, -1.12699926e-01f, -1.82916254e-01f,
  -4.12442908e-03f, 3.76867056e-02f, 1.85242549e-01f, 2.41815653e-02f, 1.73369691e-01f, 1.42490938e-01f, 5.51833287e-02f, 1.30410552e-01f, 3.78373489e-02f, -1.05761006e-01f,
  -3.29506584e-02f, 1.35473967e-01f, 2.13921219e-02f, 8.35839137e-02f, -1.00722176e-03f, 2.55631600e-02f, 1.43417001e-01f, 3.02635599e-02f, 4.55689766e-02f, -2.67185252e-02f,
  2.28016287e-01f, 1.15943566e-01f, 2.33618438e-01f, 7.83133805e-02f, 1.36371508e-01f, 6.02050349e-02f, 4.24199104e-02f, -9.66885090e-02f, 1.20888434e-01f, 2.56106287e-01f,
  1.55383825e-01f, 1.29216388e-01f, 2.83092648e-01f, 2.14240581e-01f, 1.66532457e-01f, 1.00669555e-01f, 5.35617508e-02f, 9.14238468e-02f, 2.58813709e-01f, 1.64763242e-01f,
  5.77466898e-02f, 1.11227885e-01f, 2.77704090e-01f, 2.22770587e-01f, 7.03752637e-02f, 2.15257093e-01f, 7.98530355e-02f, 6.53289929e-02f, 2.40219295e-01f, 2.08463967e-01f,
  -2.89714634e-01f, 2.87323624e-01f, -4.76959832e-02f, -1.31322309e-01f, 4.52418923e-02f, 2.54501589e-02f, 9.93097275e-02f, -1.36526242e-01f, -1.83447197e-01f, -1.24413237e-01f,
  -1.74521446e-01f, 2.54757535e-02f, 1.49252653e-01f, 2.22568214e-01f, 1.13356121e-01f, 5.52386716e-02f, -6.90211803e-02f, -7.09867477e-02f, -1.05403699e-01f, -1.14932485e-01f,
  -1.69156566e-01f, 1.83590315e-02f, 2.07271185e-02f, -5.55958264e-02f, -5.06519228e-02f, 9.68213752e-02f, -7.65259424e-03f, 1.34347323e-02f, 1.37740999e-01f, 1.92846321e-02f,
  3.96141618e-01f, 2.99351752e-01f, 1.90187141e-01f, 1.94410190e-01f, -6.88763484e-02f, -2.89159119e-01f, -5.32708228e-01f, -3.22672874e-01f, 3.37435991e-01f, 1.37342095e-01f,
  5.80450892e-02f, -5.48682362e-02f, 7.74272755e-02f, -2.41187647e-01f, -4.31980848e-01f, -5.39498627e-02f, 1.57586355e-02f, -3.12047422e-01f, -5.54129303e-01f, -6.39695883e-01f,
  -2.24406943e-01f, 7.15759248e-02f, -8.13966617e-02f, -1.07294314e-01f, 5.38477600e-01f, 1.27501085e-01f, 3.24152440e-01f, 3.25281531e-01f, 5.92381544e-02f, 4.92405474e-01f,
  3.88861477e-01f, 4.87130225e-01f, -2.90240943e-01f, 1.80180129e-02f, -7.93718845e-02f, -9.10513476e-02f, -1.00576065e-01f, 1.68015853e-01f, -9.86729376e-03f, 1.04497358e-01f,
  2.75484696e-02f, -1.30117878e-01f, 2.07504526e-01f, -1.21799842e-01f, 1.28451278e-02f, -1.64649427e-01f, 4.21787575e-02f, -1.84306800e-01f, -5.00020459e-02f, -8.15634206e-02f,
  -2.41448030e-01f, 2.47958452e-02f, 1.19110227e-01f, -2.11911246e-01f, 2.88192742e-02f, -3.96108776e-02f, -2.88419574e-02f, 7.23139271e-02f, -2.67580040e-02f, 3.17973673e-01f,
  2.90279258e-02f, 4.29680720e-02f, -1.55444697e-01f, 6.93211257e-02f, -1.11215420e-01f, 1.19461574e-01f, 1.58027142e-01f, 1.03044873e-02f, 2.27498151e-02f, -1.03438944e-01f,
  -1.05597563e-01f, -7.25894794e-02f, -4.39493023e-02f, 1.19590990e-01f, -3.14937579e-03f, 1.49680749e-01f, -1.31193742e-01f, -1.08292535e-01f, 1.29547372e-01f, 2.96051372e-02f,
  -2.34629842e-03f, 5.91065101e-02f, 1.36791319e-01f, -1.06664091e-01f, 7.57345781e-02f, 2.38865092e-02f, -2.24740840e-02f, -7.43244290e-02f, 4.08459604e-02f, 1.60068572e-01f,
  6.09777085e-02f, -3.85597408e-01f, 2.64329225e-01f, -1.39918208e-01f, 4.52016629e-02f, 7.92762637e-03f, 1.07333452e-01f, -1.86755404e-01f, 7.52255544e-02f, -8.47766846e-02f,
  -1.42284244e-01f, 1.01170773e-02f, 2.38998756e-01f, -1.08105548e-01f, -2.15312228e-01f, -1.56341791e-02f, -2.10407600e-01f, -1.55258924e-01f, -1.41821980e-01f, 9.09195691e-02f,
  1.05395578e-02f, -2.43069395e-01f, -1.95463568e-01f, -2.08069474e-01f, 8.73544514e-02f, -2.93195665e-01f, -1.28047571e-01f, -1.38328001e-01f, -3.23594600e-01f, -2.37747863e-01f,
  -5.64568281e-01f, 1.05234075e+00f, 1.10267773e-01f, -3.78268182e-01f, 1.27970383e-01f, 6.27134979e-01f, 9.33958471e-01f, 3.26054424e-01f, -3.89205694e-01f, -2.64208880e-03f,
  1.15745708e-01f, -4.58636612e-01f, -2.38640860e-01f, -1.11522943e-01f, 2.32366383e-01f, 4.96507436e-01f, 1.32550821e-01f, -2.85534173e-01f, -2.67491728e-01f, 1.99549332e-01f,
  1.13250241e-01f, -3.21073085e-01f, -3.54881823e-01f, -1.27744302e-01f, -3.41437519e-01f, -3.26338321e-01f, -1.39452413e-01f, -7.60187209e-02f, 2.30007187e-01f, -2.60340422e-01f,
  -4.15846050e-01f, 3.78566235e-01f, -2.65694708e-01f, -1.31624237e-01f, -8.40117931e-02f, -1.74401235e-02f, 7.78429094e-04f, -2.41200790e-01f, -4.81947400e-02f, -1.20896742e-01f,
  3.79850343e-02f, 1.05835840e-01f, -7.26047978e-02f, 2.43432969e-02f, 6.47516251e-02f, 2.46141568e-01f, -7.14370981e-02f, 3.05209626e-02f, -8.77921581e-02f, 1.70105591e-01f,
  1.53698787e-01f, 3.38001573e-03f, 1.37444422e-01f, 3.52613747e-01f, 1.70035258e-01f, -3.81002754e-01f, 1.52921304e-01f, -7.54673406e-02f, 1.39795482e-01f, -5.58628976e-01f,
  3.91101725e-02f, -2.14021914e-02f, 7.95670822e-02f, 7.06751645e-02f, 4.60779332e-02f, 4.86300178e-02f, -1.44631099e-02f, 1.23139575e-01f, -6.73233941e-02f, 5.06718419e-02f,
  1.19888604e-01f, -2.57146452e-02f, 4.55349386e-02f, 1.05201721e-01f, -4.86327447e-02f, -1.01523921e-01f, -1.03483135e-02f, -6.91029206e-02f, -2.38511376e-02f, 1.00678965e-01f,
  9.51070711e-03f, 7.34947845e-02f, 2.55450215e-02f, 2.25414354e-02f, -9.62730423e-02f, -1.53109031e-02f, -1.65461779e-01f, -1.68380305e-01f, -1.33186370e-01f, 1.28928319e-01f,
  -3.54694158e-01f, 2.90535659e-01f, -4.45418417e-01f, 5.40019087e-02f, -1.34916315e-02f, -4.13983501e-02f, 1.07650138e-01f, -3.26651074e-02f, 1.30552128e-01f, 7.80648086e-03f,
  1.75915852e-01f, -3.87933254e-02f, 7.18461648e-02f, 1.03187479e-01f, 3.15574966e-02f, -6.37995154e-02f, 2.25159116e-02f, -1.18103370e-01f, 5.48124313e-02f, -5.28263301e-02f,
  -1.39430374e-01f, -1.59628645e-01f, -5.24132073e-01f, -1.30253345e-01f, -1.59634985e-02f, -4.52344775e-01f, -3.54700923e-01f, -1.89163566e-01f, -1.04127347e-01f, -4.90127176e-01f,
  7.44824648e-01f, -4.40386504e-01f, 1.85078382e-01f, 1.38831481e-01f, -2.15599220e-02f, 1.64291099e-01f, -2.19166605e-03f, 1.10032536e-01f, 2.50127465e-01f, 1.49416178e-01f,
  -1.20259702e-01f, 1.82127625e-01f, 1.90433577e-01f, 1.89157188e-01f, 1.13002859e-01f, 1.08999178e-01f, 2.02401280e-01f, 4.42907006e-01f, 3.19564342e-01f, 7.80913234e-02f,
  -4.14498784e-02f, -4.62386804e-03f, 6.66358918e-02f, 1.74466193e-01f, -7.89298341e-02f, 7.64906630e-02f, 5.85350953e-02f, -1.02669857e-01f, -1.53284028e-01f, 1.20084248e-01f,
  -1.12451971e-01f, -1.40558749e-01f, 3.53104100e-02f, -8.46172720e-02f, -1.21695369e-01f, -2.23531877e-03f, 5.80986543e-03f, -1.38264084e-02f, -3.83391194e-02f, 8.91811494e-03f,
  -1.67865828e-01f, -1.68207586e-01f, 4.30719182e-03f, -1.49420351e-01f, -1.33991363e-02f, -1.22651264e-01f, -1.63609926e-02f, 2.46201293e-03f, 1.11508928e-01f, -1.59452245e-01f,
  -1.06787011e-01f, -2.12882403e-02f, -7.87617117e-02f, -4.40717414e-02f, 1.23906814e-01f, 1.00725845e-01f, -1.14190884e-01f, 6.64006025e-02f, 4.37352993e-02f, -1.16189162e-03f,
  1.80502329e-02f, -4.01082449e-02f, 8.29439312e-02f, 2.40060031e-01f, 3.22127998e-01f, 2.08253592e-01f, 6.62123933e-02f, -2.01314371e-02f, 1.36910021e-01f, 2.76361443e-02f,
  1.84517205e-02f, 1.11295760e-01f, 6.89268112e-02f, -1.24060310e-01f, 6.27267212e-02f, -1.25321597e-01f, -7.69750923e-02f, -2.10340336e-01f, 7.30881840e-02f, 1.05586030e-01f,
  1.54651254e-01f, -2.87920367e-02f, -2.83014029e-03f, -2.37639667e-03f, -1.10216804e-01f, -8.39901268e-02f, 1.09009042e-01f, -1.54316351e-01f, -1.89378746e-02f, -6.02672547e-02f,
  -4.24591273e-01f, -1.93407312e-02f, 3.23115349e-01f, -6.46003848e-03f, -1.75070047e-01f, -1.39865786e-01f, 5.27754985e-02f, -2.70604752e-02f, -2.09862843e-01f, 2.62389183e-02f,
  -1.83531836e-01f, -5.25539042e-03f, -9.60506871e-02f, -1.81417633e-02f, 6.76568523e-02f, -8.69101100e-03f, -3.45421471e-02f, -1.48302326e-02f, -7.30858222e-02f, -2.12160915e-01f,
  -1.64832428e-01f, 5.67598641e-02f, 1.19043244e-02f, 8.81801024e-02f, 7.51550570e-02f, 6.46071136e-02f, -1.55113498e-02f, 1.92368563e-04f, 7.59749711e-02f, 9.26923975e-02f,
  3.31178814e-01f, 5.82713604e-01f, 4.28195238e-01f, -1.17395267e-01f, 7.74153695e-02f, 1.45282120e-01f, 2.74738491e-01f, 5.02690375e-02f, -1.37789398e-01f, -1.00333961e-02f,
  2.77117211e-02f, -2.99357802e-01f, -1.32172242e-01f, -1.62356392e-01f, 7.47900158e-02f, -7.88122322e-03f, -4.43869345e-02f, 3.58631387e-02f, -7.12682307e-02f, -2.30171889e-01f,
  -3.53099704e-01f, -1.18451677e-01f, -6.44760728e-02f, -1.58859827e-02f, 2.32609864e-02f, -2.01920837e-01f, 2.23767802e-01f, 2.10207403e-01f, 1.90006346e-01f, -8.23807642e-02f,
  3.91445421e-02f, 4.39875513e-01f, -3.53354514e-01f, -3.32296267e-02f, -4.27045897e-02f, -4.98904623e-02f, -9.96048823e-02f, 6.59731254e-02f, -3.60308401e-02f, -7.69145191e-02f,
  -1.32520935e-02f, -5.99800535e-02f, 8.16077180e-03f, 3.15140001e-02f, -4.89414558e-02f, 1.51883374e-04f, 6.42414093e-02f, 7.72060305e-02f, 3.17067541e-02f, 2.40568649e-02f,
  -1.93762183e-01f, -9.26676989e-02f, 2.15392113e-01f, 8.20366889e-02f, 4.45613042e-02f, -4.07140441e-02f, 4.40661423e-02f, 1.21181952e-02f, 1.86140597e-01f, 6.11707494e-02f,
  -2.03245476e-01f, 1.46288246e-01f, 8.86947736e-02f, -1.21437587e-01f, -4.98653091e-02f, -8.90945196e-02f, -9.18158814e-02f, -3.82139236e-02f, 8.88523981e-02f, 3.09982672e-02f,
  -3.97032462e-02f, -7.36226216e-02f, -2.19623577e-02f, -1.21862022e-03f, -9.54854786e-02f, 2.45484039e-02f, -3.88246179e-02f, -4.74965349e-02f, 6.08313363e-03f, 1.12960755e-03f,
  3.33273783e-02f, -3.60086486e-02f, -3.96020561e-02f, 1.01872407e-01f, -4.74683754e-02f, -1.37579203e-01f, -1.57130271e-01f, 2.65632737e-02f, -5.95196970e-02f, -1.60283029e-01f,
  -2.79026479e-01f, 8.51809904e-02f, -3.05142075e-01f, 8.87328833e-02f, 1.03148334e-01f, 2.66169030e-02f, 4.81622592e-02f, 9.34172496e-02f, 5.01838252e-02f, 8.31494760e-03f,
  1.09608658e-01f, -1.41641185e-01f, 1.96628850e-02f, -1.18257008e-01f, -1.03950635e-01f, -1.89264938e-02f, -2.65485793e-01f, -1.22947536e-01f, -8.84136856e-02f, -2.18928009e-02f,
  -4.07607555e-02f, -2.10024118e-01f, -2.37251356e-01f, -1.37810528e-01f, -1.36672705e-01f, -2.93043077e-01f, -6.43200725e-02f, -3.89984325e-02f, 1.09578576e-02f, -2.17597753e-01f,
  7.28894249e-02f, 1.28197268e-01f, -4.06709611e-01f, 3.13272513e-02f, -1.43297261e-03f, 5.54158911e-02f, 2.68724918e-01f, 1.63596839e-01f, 5.86440274e-03f, 1.05910949e-01f,
  -1.60361648e-01f, -1.56922638e-01f, -1.93536997e-01f, -1.35499880e-01f, 4.38083075e-02f, 1.59377888e-01f, -1.36900291e-01f, -2.85222352e-01f, -1.49500683e-01f, 1.48440465e-01f,
  1.22059256e-01f, 2.25719914e-01f, 1.72388673e-01f, -9.65848938e-02f, 1.30427526e-02f, -9.13554281e-02f, 1.86481513e-02f, -6.72814474e-02f, -2.35009402e-01f, -1.58865869e-01f,
  1.74325407e-01f, -3.69091481e-01f, -1.81036144e-01f, -1.83348402e-01f, -8.12929124e-02f, 6.61762990e-03f, 6.54579327e-03f, -1.60433426e-01f, -2.24875193e-02f, 1.19678900e-01f,
  -4.24488373e-02f, -5.25472574e-02f, -1.45269349e-01f, 5.45797460e-02f, 1.23773776e-01f, 2.53606420e-02f, -1.11134760e-01f, -5.71076311e-02f, -2.25615829e-01f, -1.55467674e-01f,
  -4.52067181e-02f, -1.29274100e-01f, -1.67165443e-01f, -1.69134930e-01f, -2.69261271e-01f, -1.55474126e-01f, -7.38403127e-02f, -1.41543001e-01f, -2.20651671e-01f, 1.15070164e-01f,
  7.09513202e-02f, 1.47479296e-01f, 2.29967888e-02f, 6.40991330e-02f, 3.14613245e-02f, -1.33751646e-01f, -1.32559791e-01f, -4.38153669e-02f, 8.02027211e-02f, 1.01098053e-01f,
  -8.40056986e-02f, -7.04915673e-02f, 6.40262738e-02f, 4.31372114e-02f, 9.60552320e-02f, -3.34382616e-02f, -4.98731881e-02f, 1.03566736e-01f, -7.65120909e-02f, 4.29576151e-02f,
  -4.38764431e-02f, -4.02469859e-02f, 7.57651683e-03f, 4.28408384e-02f, -1.18800215e-01f, -1.15735114e-01f, 5.05100153e-02f, 6.11693263e-02f, -7.06255212e-02f, -5.40328920e-02f,
  4.90661234e-01f, -2.54665554e-01f, 9.20767337e-02f, -3.21236737e-02f, 2.57253908e-02f, -1.09624647e-01f, 5.53378500e-02f, -1.65325388e-01f, -7.69062713e-02f, 1.60890728e-01f,
  -4.50468883e-02f, 1.01242974e-01f, 4.92857443e-03f, 7.00346753e-02f, 1.70629159e-01f, 9.76939797e-02f, 1.38292596e-01f, -1.48529466e-03f, 5.02273105e-02f, 9.27272961e-02f,
  2.81787291e-02f, 2.16529474e-01f, 1.03927977e-01f, 8.46449286e-02f, -4.90923300e-02f, 3.74526493e-02f, 2.21162274e-01f, 5.11540659e-03f, 9.53014493e-02f, 5.20280182e-01f,
  -5.87421954e-01f, -5.72299540e-01f, -3.01294267e-01f, 3.66248675e-02f, 2.15267271e-01f, -1.52914360e-01f, -6.62193954e-01f, -4.45098758e-01f, 8.90012607e-02f, -1.65192649e-01f,
  1.08973399e-01f, 3.44749749e-01f, 5.85964881e-02f, 8.17450974e-03f, -4.35781330e-01f, -5.70521116e-01f, -2.59508759e-01f, -1.29363447e-01f, 1.67896077e-01f, 5.15136540e-01f,
  4.18252349e-01f, 3.76573175e-01f, 1.66649774e-01f, 1.13930456e-01f, 3.11733931e-01f, 3.18714947e-01f, 3.97542641e-02f, 1.80251032e-01f, -1.70331094e-02f, -9.47538093e-02f,
  1.57273889e-01f, -2.78985023e-01f, 1.30444318e-01f, 9.71952751e-02f, 2.26568177e-01f, -2.09509715e-01f, -9.76730511e-02f, -1.82888806e-02f, -7.70589941e-06f, -1.66570604e-01f,
  2.13158205e-01f, 1.88883841e-02f, 1.71345592e-01f, 2.28574768e-01f, 8.35549086e-02f, 9.59773213e-02f, 5.54306209e-02f, -1.34031579e-01f, -1.09090351e-01f, 1.03404023e-01f,
  1.62320226e-01f, 1.17221847e-01f, -1.81129873e-02f, -9.06076953e-02f, -1.63699854e-02f, 1.17119662e-01f, 5.00305742e-02f, 3.59628983e-02f, -9.91990790e-02f, -2.20710739e-01f,
  1.64817423e-02f, 1.00397833e-01f, 7.56730065e-02f, 3.68381068e-02f, -9.75388214e-02f, 2.12438405e-02f, -8.70834664e-03f, -1.20746195e-02f, 1.36890700e-02f, -4.66788150e-02f,
  -8.56119469e-02f, -1.17297709e-01f, 9.80154239e-03f, -1.56279385e-01f, -1.33272149e-02f, 1.41347647e-02f, -1.19068228e-01f, -1.18619047e-01f, 1.22835629e-01f, -8.31289450e-04f,
  -7.36308694e-02f, -1.67294759e-02f, 5.61174825e-02f, -1.03628546e-01f, -1.96086869e-01f, -1.06212907e-01f, -2.42868382e-02f, 6.53212517e-02f, 1.74449980e-01f, 3.79656404e-02f,
  2.01486796e-01f, -5.64221293e-02f, -1.67530909e-01f, 1.26497475e-02f, -7.95652568e-02f, 3.83041762e-02f, -9.77431796e-03f, -1.99130490e-01f, -1.47971943e-01f, -7.79331997e-02f,
  -6.16711825e-02f, -1.45678267e-01f, 4.52703163e-02f, 1.44350350e-01f, 1.02547638e-01f, -1.32393688e-02f, -2.98499838e-02f, -5.17090969e-02f, -2.19896495e-01f, 1.67437658e-01f,
  -6.52887374e-02f, -3.01381320e-01f, -1.57810777e-01f, -3.22902709e-01f, -5.55579457e-03f, -1.38393581e-01f, 5.22845648e-02f, 5.51041886e-02f, -2.61905730e-01f, -2.37312645e-01f,
  7.51239955e-01f, -5.91817737e-01f, -4.45806473e-01f, 4.75316197e-01f, 2.49411240e-02f, -4.49231833e-01f, -9.76068854e-01f, -2.16488108e-01f, 9.10376459e-02f, -6.27746820e-01f,
  1.11979209e-02f, 6.73264384e-01f, 2.14159533e-01f, 1.33298606e-01f, -7.26763010e-02f, -8.96019101e-01f, -6.37371421e-01f, 1.90168992e-01f, 4.50886488e-01f, 2.42686898e-01f,
  1.45211875e-01f, 1.61066845e-01f, 3.29600006e-01f, 1.52176529e-01f, -2.27881566e-01f, 2.66058683e-01f, -5.11555195e-01f, 4.02996764e-02f, -3.86347055e-01f, -3.34250748e-01f,
  -3.08164001e-01f, 6.81453645e-02f, -5.27516566e-02f, 1.57268226e-01f, 9.88607928e-02f, -1.04054995e-02f, -3.78096327e-02f, -1.75437719e-01f, -1.32826548e-02f, -1.81436881e-01f,
  1.70741931e-01f, -3.12951617e-02f, 2.43400425e-01f, -1.89687114e-03f, -8.81566107e-02f, 4.21120450e-02f, 3.25271785e-02f, -1.07623860e-01f, -2.46422753e-01f, -2.87834718e-03f,
  9.46793985e-03f, 1.52218997e-01f, 3.21901180e-02f, -1.22169249e-01f, 7.05494881e-02f, 4.81308252e-01f, 4.02285643e-02f, 2.83205539e-01f, 4.89188582e-02f, -3.77829105e-01f,
  6.30810410e-02f, 8.60242397e-02f, 2.93131266e-02f, 2.82726996e-02f, -9.16578248e-02f, -8.18278193e-02f, 4.58583497e-02f, -1.21402629e-01f, 5.48922643e-02f, 2.55922880e-02f,
  3.47493449e-03f, -7.40323514e-02f, 4.26866449e-02f, -1.91317961e-01f, 1.15044350e-02f, 8.90516341e-02f, -7.65702222e-03f, -9.55437049e-02f, -4.34699245e-02f, -1.12425372e-01f,
  1.38198972e-01f, -2.28374023e-02f, 7.45062158e-02f, 2.30311044e-02f, -1.04605906e-01f, 5.91365062e-02f, 1.11853465e-01f, 2.65703559e-01f, 1.75307482e-01f, -1.30916849e-01f,
  1.79254517e-01f, 1.56830270e-02f, -4.34397250e-01f, -4.27536331e-02f, -5.62948547e-02f, -1.61930829e-01f, -8.32128376e-02f, 1.48409784e-01f, 1.27955422e-01f, 1.12257935e-01f,
  8.31828862e-02f, 2.90829279e-02f, -1.52368948e-01f, -3.37898284e-02f, -1.06092736e-01f, -2.07784384e-01f, -2.57530063e-01f, -6.40722811e-02f, -1.90887421e-01f, 6.30099177e-02f,
  -1.42336309e-01f, -2.31976569e-01f, 1.03568528e-02f, -2.42601633e-01f, 1.27467215e-01f, 3.52013588e-01f, -2.70840079e-01f, -2.42037073e-01f, -1.24904372e-01f, -6.77649558e-01f,
  -1.26378745e-01f, 1.98682323e-01f, 1.52116893e-02f, 3.19473743e-01f, 4.54160124e-01f, 3.76519322e-01f, 2.95527905e-01f, 1.41904742e-01f, 2.82438487e-01f, 3.06472659e-01f,
  2.92118996e-01f, 3.63776237e-01f, 3.70059580e-01f, 1.82015747e-01f, 1.29387096e-01f, 1.31163210e-01f, 1.89836383e-01f, -1.32668063e-01f, 9.36057139e-03f, 2.00753376e-01f,
  4.26383793e-01f, 1.44571647e-01f, -2.59622629e-03f, -5.17799221e-02f, 2.01358601e-01f, 2.85903573e-01f, 1.86926916e-01f, 2.98548907e-01f, 3.13476682e-01f, 2.17022613e-01f,
  1.38413385e-01f, -5.38532808e-02f, 5.80873154e-02f, 4.09303326e-03f, -4.22633477e-02f, -1.40182555e-01f, -1.07464127e-01f, -1.77702993e-01f, -1.61211312e-01f, -9.18767080e-02f,
  -4.58186753e-02f, -1.74413681e-01f, -2.61622332e-02f, -5.15698753e-02f, -1.45552754e-01f, -5.03282808e-02f, -1.50148213e-01f, 2.42092386e-02f, -3.68020870e-02f, 4.76964600e-02f,
  -9.62135755e-03f, 1.43222600e-01f, 5.38405078e-03f, 4.65428270e-03f, 4.11229432e-02f, 9.19312388e-02f, -6.06740974e-02f, -8.38689599e-03f, -8.34149197e-02f, -3.19911987e-02f,
  3.03803712e-01f, 1.35237455e-01f, 1.60447702e-01f, 2.07065925e-01f, 1.43902838e-01f, 7.46760070e-02f, -1.71920303e-02f, 1.13186851e-01f, 1.54973149e-01f, -6.02570064e-02f,
  -1.06591344e-01f, 1.21570311e-01f, 1.91524085e-02f, 7.12691545e-02f, 7.54575729e-02f, 5.71782142e-02f, 1.00324504e-01f, 8.36340636e-02f, -6.87498897e-02f, -4.58008274e-02f,
  2.55349521e-02f, -7.00597093e-02f, -1.36534914e-01f, -1.83864102e-01f, -4.07308228e-02f, 5.10351099e-02f, -2.46404745e-02f, 4.80199046e-02f, 9.60633680e-02f, -2.16705408e-02f,
  2.94822812e-01f, 5.19394595e-03f, -1.35955298e-02f, -4.96458262e-03f, -2.45861821e-02f, -1.61295608e-01f, 3.53544839e-02f, -3.70596796e-02f, -8.43559429e-02f, -4.88636196e-02f,
  -5.83751947e-02f, -3.50046828e-02f, -1.42131560e-03f, -9.77916121e-02f, -7.16429427e-02f, -1.42762348e-01f, 5.73668778e-02f, 8.53549689e-02f, 7.98165947e-02f, 9.44312215e-02f,
  -7.23594278e-02f, -6.06171712e-02f, -5.59407473e-02f, 7.02294987e-03f, 4.05778252e-02f, 5.49799129e-02f, -5.03711700e-02f, 5.19300811e-02f, 3.82598229e-02f, -6.76394254e-02f,
  4.27450925e-01f, 3.72253805e-01f, 2.73573577e-01f, 1.06605083e-01f, -1.23744242e-01f, 1.07517764e-01f, 6.73775747e-02f, 1.42651767e-01f, 3.33285108e-02f, 2.06537455e-01f,
  8.86916965e-02f, 1.82556525e-01f, 2.76940405e-01f, 3.28817785e-01f, 2.49528065e-01f, 1.88243002e-01f, 1.47928879e-01f, 2.34117985e-01f, 1.58344567e-01f, -8.51245876e-03f,
  1.60547961e-02f, 8.46960396e-02f, 1.43986002e-01f, 1.24219604e-01f, 2.14099083e-02f, 1.61319729e-02f, 1.01010837e-01f, 6.43901585e-04f, 5.84619818e-03f, 6.52913973e-02f,
  -1.03811726e-01f, 2.36965612e-01f, 1.16469637e-02f, 9.41584036e-02f, 5.19846156e-02f, 5.21552376e-02f, 1.15937345e-01f, -1.20598681e-01f, -1.20309688e-01f, -1.43523768e-01f,
  1.05576543e-02f, 7.57605657e-02f, -2.97928043e-02f, -5.65962270e-02f, -1.21228784e-01f, -9.47689563e-02f, 4.34260629e-03f, 3.27087864e-02f, 2.85605732e-02f, 7.21617043e-02f,
  1.01799347e-01f, -1.46974981e-01f, -3.56496475e-03f, 4.18732278e-02f, 1.74195737e-01f, -5.62302433e-02f, 1.07479528e-01f, 2.76398826e-02f, 1.08341917e-01f, 4.73598167e-02f,
  2.17537969e-01f, 1.17457397e-01f, 2.17410102e-01f, -2.33067013e-03f, 4.68763383e-03f, -1.80780262e-01f, -1.64052039e-01f, 6.38454966e-03f, 8.77731144e-02f, 9.97313391e-03f,
  -2.14273795e-01f, -8.71551689e-04f, 3.68670523e-02f, -7.41907656e-02f, -4.67291176e-02f, 4.27822731e-02f, -1.10242844e-01f, -4.64021973e-02f, 4.90158834e-02f, 9.77208540e-02f,
  -1.47850690e-02f, -1.46781653e-01f, -1.20095961e-01f, -9.98665094e-02f, -7.55237937e-02f, -3.55437621e-02f, 1.87058165e-03f, 6.10472225e-02f, -5.87619692e-02f, -9.65123903e-03f,
  -1.46595880e-01f, 2.11062253e-01f, 8.89363419e-03f, 1.87613502e-01f, -7.64412284e-02f, -2.91542187e-02f, 9.32906494e-02f, -6.36414811e-02f, -2.34713435e-01f, -1.26545131e-01f,
  -1.49981797e-01f, 1.94490254e-02f, 2.47645974e-02f, -1.14763945e-01f, -1.50538027e-01f, -1.76960498e-01f, 3.97427045e-02f, -5.20649701e-02f, 9.71567333e-02f, 5.64598702e-02f,
  6.88978881e-02f, -1.08026557e-01f, -1.30682915e-01f, 3.98484617e-03f, -2.96567678e-02f, -7.73023665e-02f, -1.79937586e-01f, -1.04583465e-01f, -8.33942816e-02f, -1.74857691e-01f,
  5.28900325e-01f, -5.40196240e-01f, -5.04484951e-01f, -5.03275275e-01f, -2.95279175e-01f, 1.17203176e-01f, -8.06280598e-02f, 9.10421312e-02f, -1.61276579e-01f, -2.42612720e-01f,
  3.50932032e-01f, 8.05199265e-01f, 2.06519932e-01f, 4.09289002e-01f, 4.27149594e-01f, -5.52147985e-01f, -5.80574811e-01f, 1.66922346e-01f, 6.29913986e-01f, 6.01027012e-01f,
  1.10110819e-01f, -1.24477580e-01f, 1.10854000e-01f, 2.36836001e-02f, -5.81647635e-01f, 2.96408348e-02f, -5.75748920e-01f, -4.28435326e-01f, -1.75142169e-01f, -6.27323806e-01f,
  -1.75776873e-02f, 4.11214530e-02f, 1.96187720e-01f, 2.92862356e-01f, -1.28782585e-01f, 2.89762169e-02f, 2.76646540e-02f, -3.01615715e-01f, 9.92872864e-02f, -2.01358065e-01f,
  -1.25294812e-02f, 1.35582194e-01f, 1.18249603e-01f, -8.30520876e-03f, -1.77194178e-01f, -2.27683820e-02f, -2.99223840e-01f, -6.49093883e-03f, -1.49189293e-01f, 4.10559885e-02f,
  -2.54273385e-01f, 9.92187560e-02f, -3.45519036e-02f, -2.88462639e-01f, -1.13043249e-01f, -6.83060428e-03f, -3.79325390e-01f, -6.74689189e-02f, 6.86526820e-02f, -7.41849601e-01f,
  6.84806425e-03f, -1.49196297e-01f, -1.29669592e-01f, -9.96799394e-02f, 4.57618060e-03f, 3.26296836e-02f, 4.80717272e-02f, 1.18108869e-01f, 1.00828810e-02f, -1.40706748e-01f,
  6.89431876e-02f, 4.61210199e-02f, 1.77865878e-01f, -3.80948335e-02f, -1.07665606e-01f, -1.29297718e-01f, 1.21790893e-01f, -1.04942366e-01f, 1.80937901e-01f, 1.93846133e-02f,
  1.30998641e-01f, 9.13809240e-03f, -1.73556983e-01f, 2.03196958e-01f, 5.97311594e-02f, 3.17421667e-02f, -3.35758887e-02f, 9.78516415e-02f, 7.27736056e-02f, 5.11626340e-02f,
  -2.77358722e-02f, 3.04515958e-01f, 1.04565453e-02f, 1.10255845e-01f, -9.28666666e-02f, -6.72308058e-02f, -3.19163539e-02f, -1.02537973e-02f, 1.03959613e-01f, 7.66989961e-02f,
  1.41101003e-01f, 5.71747795e-02f, -1.31232604e-01f, -9.94475409e-02f, 2.39856597e-02f, 7.51751736e-02f, 5.68763837e-02f, 2.83553183e-01f, 2.02773064e-02f, -2.65415579e-01f,
  -4.74019200e-01f, 1.29843801e-01f, 2.22328126e-01f, -7.25521296e-02f, -1.79754689e-01f, 1.95234820e-01f, -3.82629484e-01f, -1.49610654e-01f, 2.67317891e-01f, -3.91714931e-01f,
  5.21171749e-01f, -5.14225028e-02f, -2.04514280e-01f, 3.13763410e-01f, 3.24559718e-01f, 1.86096340e-01f, 1.75835252e-01f, 2.98475832e-01f, 3.77035022e-01f, 1.16630077e-01f,
  2.80329417e-02f, 1.76950768e-01f, 1.59649566e-01f, -4.17802706e-02f, 4.39489745e-02f, 1.12171277e-01f, 2.07060035e-02f, -7.84090832e-02f, 6.87997118e-02f, 1.89525798e-01f,
  2.39253953e-01f, 2.70276666e-01f, 1.04165331e-01f, 1.25821397e-01f, 3.18251401e-02f, 2.21390843e-01f, 1.41218632e-01f, 8.31161365e-02f, -1.11537641e-02f, 8.94321781e-03f,
  -5.36321580e-01f, -2.51529887e-02f, -4.65025790e-02f, -3.06403171e-02f, -2.01074287e-01f, 4.29720059e-02f, -3.54894511e-02f, -2.94184797e-02f, 9.08204447e-03f, -1.64625961e-02f,
  -3.91186439e-02f, 2.97818072e-02f, -1.71643645e-01f, -3.58598381e-02f, -7.77369514e-02f, -1.25706181e-01f, -9.04701129e-02f, 4.06273268e-03f, -2.99585592e-02f, -1.68329865e-01f,
  -1.10858567e-01f, -1.48370750e-02f, -7.58273378e-02f, -8.27371180e-02f, -5.40744029e-02f, -1.84511002e-02f, -6.58260584e-02f, 7.25222677e-02f, 2.98643727e-02f, 1.26289368e-01f,
  -3.07392746e-01f, -1.01350933e-01f, -1.97174072e-01f, 6.08060956e-02f, -1.79703478e-02f, 1.33746341e-01f, 9.95764881e-02f, -3.42264809e-02f, -1.63065419e-02f, 1.01881549e-01f,
  2.01746169e-02f, -5.13823442e-02f, -1.90437108e-01f, -1.59443018e-03f, -1.10300735e-01f, -2.49828026e-02f, -9.35117900e-02f, -2.24780351e-01f, -3.42548698e-01f, -1.09829955e-01f,
  3.23181180e-03f, -5.94687276e-02f, -4.21867520e-02f, -2.40175322e-01f, 2.89972704e-02f, -3.76837924e-02f, -6.25341833e-02f, -1.21264063e-01f, 3.95212285e-02f, 4.07357961e-02f,
  -8.56184587e-03f, -2.40202680e-01f, -4.62101474e-02f, -7.95001909e-02f, 1.64156910e-02f, -1.96359642e-02f, -7.20071793e-02f, -5.26779257e-02f, -7.41938427e-02f, -5.73276542e-02f,
  -1.24722995e-01f, -9.99986008e-02f, -2.18429461e-01f, 3.83133143e-02f, 9.08990726e-02f, -4.62593958e-02f, 3.58826667e-02f, 1.36179984e-01f, -7.31671520e-04f, -1.53465092e-01f,
  -6.50918186e-02f, 1.00691997e-01f, 1.20632775e-01f, 1.19904466e-01f, 1.44717738e-01f, 1.89814553e-01f, 3.70442793e-02f, -6.54400289e-02f, 4.65408154e-02f, 2.99117684e-01f,
  2.75319844e-01f, -5.17099500e-02f, -3.72547686e-01f, 1.80412158e-01f, -5.29490292e-01f, -5.88427007e-01f, -6.30008340e-01f, -9.84837487e-02f, 3.55153710e-01f, -1.45033136e-01f,
  -2.03231007e-01f, 3.15444320e-02f, -2.56944865e-01f, -1.15861163e-01f, -1.98344901e-01f, -2.08108172e-01f, -2.53186896e-02f, -7.50494152e-02f, -8.04313272e-02f, 1.91785306e-01f,
  4.02628541e-01f, 3.84924263e-01f, 4.26787972e-01f, 3.52311373e-01f, 6.80628240e-01f, 4.07279462e-01f, 1.84281558e-01f, 3.60658556e-01f, 8.63968730e-02f, 5.06232202e-01f,
  -2.42312610e-01f, 1.02320172e-01f, -2.07947046e-01f, 2.08887145e-01f, -3.55690398e-04f, 1.33812368e-01f, 8.28933269e-02f, 2.09756210e-01f, -8.89538527e-02f, 2.43813872e-01f,
  -2.74805017e-02f, 6.66652471e-02f, -1.74438551e-01f, 1.88711494e-01f, 9.28205550e-02f, -4.88621853e-02f, 1.79662123e-01f, -2.52894089e-02f, -4.43235934e-02f, 3.96556174e-03f,
  2.14416254e-03f, -2.07579628e-01f, -4.83296812e-01f, -2.40573168e-01f, -1.32724717e-01f, -1.75046504e-01f, -1.66273177e-01f, 2.36172542e-01f, -1.35933816e-01f, 3.17220628e-01f,
  7.07517192e-02f, -1.62364379e-01f, -5.50420471e-02f, -8.31630453e-03f, 5.76246455e-02f, -1.25198156e-01f, 1.14816520e-02f, 8.49141777e-02f, 1.03510343e-01f, -3.33910324e-02f,
  -2.10717797e-01f, -9.63849798e-02f, 8.71865824e-02f, -3.69346105e-02f, 1.13219239e-01f, 4.72589247e-02f, 6.70757815e-02f, 5.14628105e-02f, -1.18225813e-01f, 1.04024224e-01f,
  -7.44610205e-02f, -2.44329255e-02f, 9.35332254e-02f, 2.02260286e-01f, 1.01364486e-01f, 1.68698519e-01f, 2.29200915e-01f, 1.19063705e-01f, 8.89448002e-02f, 1.38597965e-01f,
  2.03251854e-01f, -2.14465559e-01f, 1.56364560e-01f, 1.59990609e-01f, -4.91112582e-02f, 9.48840678e-02f, 1.37129929e-02f, 2.35724240e-03f, -8.70199353e-02f, 1.74547255e-01f,
  2.02104039e-02f, -3.66611034e-02f, -6.91630468e-02f, -1.44272102e-02f, 5.44390343e-02f, -7.23309144e-02f, 1.74047574e-02f, -1.94040045e-01f, -7.26047456e-02f, 8.14025551e-02f,
  -1.71602011e-01f, -1.88076094e-01f, -4.33514923e-01f, -5.04209995e-01f, -6.72679022e-02f, -2.63811469e-01f, -2.01874644e-01f, 4.50960174e-02f, -3.36984575e-01f, -3.58595550e-01f,
  -7.54406452e-01f, -6.27321228e-02f, 4.11961079e-01f, -3.33860666e-01f, 4.09351021e-01f, 6.32576525e-01f, 6.41510665e-01f, 1.71474636e-01f, -3.08330327e-01f, -1.69926845e-02f,
  -6.11771010e-02f, -4.51273143e-01f, -4.32379425e-01f, -1.18056759e-01f, 1.07185371e-01f, 4.32245046e-01f, 4.17440534e-01f, 1.57967314e-01f, 2.46616945e-01f, 3.62090975e-01f,
  1.71288490e-01f, -1.84778720e-01f, -2.61882991e-01f, 9.19979811e-03f, -1.66570112e-01f, -2.56641179e-01f, -1.48293003e-01f, -1.35258898e-01f, 1.14393711e-01f, -8.49294960e-02f,
  -6.19767904e-01f, -3.02614123e-01f, 3.47195208e-01f, -2.52121687e-01f, -7.61655569e-02f, -1.03140630e-01f, 2.00253725e-02f, -2.41622031e-02f, 1.43444940e-01f, -6.68512583e-02f,
  -9.43389833e-02f, -2.89687105e-02f, -2.15446681e-01f, 7.66878948e-02f, -1.29138589e-01f, -1.30982131e-01f, -4.82170545e-02f, -2.59794910e-02f, -2.51038760e-01f, -8.35386217e-02f,
  3.44989486e-02f, -1.81186311e-02f, -9.73959938e-02f, 2.08482504e-01f, 3.06911860e-02f, -2.30721802e-01f, 3.96863967e-02f, 4.88038696e-02f, -1.55161172e-02f, -3.85387748e-01f,
  -3.12451739e-02f, 6.93228990e-02f, 1.66010097e-01f, 1.10942982e-01f, 2.73282789e-02f, 3.86856459e-02f, 2.33327486e-02f, 9.77632999e-02f, 1.24617025e-01f, -1.16717713e-02f,
  -1.43228732e-02f, -5.46293110e-02f, 4.89240512e-02f, -4.65831645e-02f, -1.30732551e-01f, 1.26395477e-02f, 1.98081478e-01f, 3.43782082e-02f, 1.11530825e-01f, 9.39028114e-02f,
  -2.14228839e-01f, 1.25273755e-02f, -1.39708593e-01f, -8.08997899e-02f, 7.98928291e-02f, 1.16234928e-01f, -1.51974142e-01f, -7.97227100e-02f, -1.04472205e-01f, -2.97660194e-02f,
  -6.44954085e-01f, 7.38883913e-01f, -3.18562835e-01f, -7.89393261e-02f, -7.43337721e-02f, 6.33134544e-02f, -1.99540660e-01f, 6.13736957e-02f, -6.03113585e-05f, 4.35723513e-02f,
  1.66229606e-01f, 5.73322475e-02f, -2.84862876e-01f, 2.17648536e-01f, -4.12752293e-02f, -1.45127431e-01f, 7.31450915e-02f, 9.45060141e-03f, 9.26387385e-02f, -1.87027622e-02f,
  -9.05149207e-02f, 3.00513327e-01f, -3.15906316e-01f, 1.11812830e-01f, 9.33944434e-03f, -4.21262145e-01f, -1.30091950e-01f, 2.20078882e-02f, 1.62860140e-01f, -5.71996644e-02f,
  8.70216370e-01f, -1.23611890e-01f, -9.59512711e-01f, 6.04893386e-01f, -1.36232302e-01f, -6.79436982e-01f, -5.23700237e-01f, -1.65745124e-01f, 4.22970444e-01f, 1.41458714e-03f,
  1.11890793e-01f, 2.34782144e-01f, -6.72405884e-02f, -3.61418962e-01f, -6.31796837e-01f, -5.91739535e-01f, -6.44950092e-01f, -6.15041316e-01f, -4.62332308e-01f, -1.80220455e-01f,
  2.12521642e-01f, 2.91687816e-01f, 2.53697842e-01f, 1.07774129e-02f, 1.44297644e-01f, -3.21705192e-02f, -2.89691895e-01f, -1.55634925e-01f, -4.64024931e-01f, -1.95167065e-01f,
  -4.83387470e-01f, -2.93377042e-01f, -7.10783899e-02f, 2.58439422e-01f, 5.89109659e-02f, 1.02461822e-01f, 6.53244704e-02f, 2.00424477e-01f, 2.75151730e-01f, 1.85867444e-01f,
  5.50455675e-02f, 1.60794601e-01f, 5.61042055e-02f, 3.68398055e-02f, 7.69627467e-02f, 1.62891615e-02f, -5.74360229e-02f, -6.84997216e-02f, -1.61220245e-02f, -7.19677703e-03f,
  5.98144764e-03f, -1.29952744e-01f, -2.44769961e-01f, -6.23495989e-02f, -3.27577174e-01f, -1.48035303e-01f, -2.94685453e-01f, -2.33203590e-01f, -4.59422678e-01f, 2.76714470e-02f,
  -3.36432122e-02f, 1.34536559e-02f, 6.75225034e-02f, 4.79116142e-02f, 2.13159576e-01f, 1.68597743e-01f, 8.28672498e-02f, -1.38982679e-04f, -1.35626104e-02f, 4.99624386e-02f,
  -8.51005130e-03f, -1.84569433e-02f, 1.20042861e-02f, 1.60700008e-01f, 7.80853331e-02f, 3.92819941e-02f, -1.27675636e-02f, -2.30240040e-02f, 4.07789014e-02f, 1.31008729e-01f,
  6.69438839e-02f, 6.00100756e-02f, 1.47707835e-01f, 2.93269437e-02f, -3.55181172e-02f, -1.14234537e-01f, -1.95437342e-01f, 3.32764238e-02f, 6.83930796e-03f, -4.28690240e-02f,
  3.92553002e-01f, -3.40615034e-01f, 1.32380873e-01f, -1.73853263e-01f, -1.86628234e-02f, 1.85996443e-02f, 3.77038755e-02f, 1.64611846e-01f, 2.16212645e-01f, 1.48884356e-01f,
  -3.99897359e-02f, 2.11604804e-01f, -2.31851712e-02f, 2.10259669e-02f, 6.87847957e-02f, 4.46066335e-02f, 1.73830807e-01f, 5.55877050e-04f, -1.02615401e-01f, 1.03039779e-01f,
  1.16867699e-01f, 9.48399827e-02f, 1.32757127e-01f, 7.94810280e-02f, -1.88482273e-02f, -1.07754506e-01f, -1.69440821e-01f, -1.53916985e-01f, -3.07255119e-01f, 3.36766839e-01f,
  6.82187319e-01f, 1.72658429e-01f, 5.50874248e-02f, 2.05257535e-01f, 7.73035339e-04f, 8.87646675e-02f, 6.85986057e-02f, 4.59367223e-02f, 1.44360840e-01f, 1.92438602e-01f,
  2.23644659e-01f, 1.53313890e-01f, 1.92368142e-02f, 4.38534804e-02f, 6.42118752e-02f, 2.56064907e-02f, 1.35353375e-02f, 1.19083449e-01f, 1.75521269e-01f, 1.98059201e-01f,
  1.55935973e-01f, 1.23801596e-01f, 2.51531541e-01f, 1.44566610e-01f, 1.43827096e-01f, 7.15674981e-02f, 9.07818079e-02f, 1.17299750e-01f, 2.02632099e-01f, 1.94826797e-01f,
  2.38950998e-01f, 1.61047056e-01f, 1.75586157e-02f, 7.57448077e-02f, 1.57889277e-02f, 5.89137338e-02f, 1.04572944e-01f, -3.37177701e-02f, 9.04576574e-03f, -4.26343195e-02f,
  5.09611936e-03f, 8.80676806e-02f, -6.34986982e-02f, 2.60126814e-02f, -5.54885976e-02f, 6.09453470e-02f, -2.42928192e-02f, -3.18211801e-02f, -2.46972162e-02f, 3.29374871e-03f,
  5.41106462e-02f, -7.62251951e-03f, -1.01697348e-01f, -1.18193299e-01f, 2.81491634e-02f, -7.25737438e-02f, -1.94454137e-02f, 4.10130341e-03f, -7.75221810e-02f, 9.32982564e-02f,
  4.31996062e-02f, 1.04761414e-01f, 2.73120910e-01f, 1.19112372e-01f, 2.24613562e-01f, 1.07861884e-01f, 5.13118058e-02f, 2.13100277e-02f, 9.39440578e-02f, 1.49970263e-01f,
  1.86335314e-02f, 7.75771365e-02f, -8.68702158e-02f, 1.06153101e-01f, 1.91173196e-01f, 1.64816216e-01f, -3.38138677e-02f, 1.11021735e-01f, -8.70511308e-03f, -3.11797466e-02f,
  7.98983425e-02f, -3.79687198e-03f, -1.08857356e-01f, -2.17615172e-01f, -1.87487295e-03f, 5.49268946e-02f, 1.42972425e-01f, 2.07919687e-01f, 8.17623630e-04f, 1.59650102e-01f,
  -2.91488379e-01f, 1.70141365e-02f, 8.97236913e-02f, -6.51696883e-03f, 2.50870758e-03f, -7.31848031e-02f, -5.86204007e-02f, -1.82932913e-01f, -1.55474231e-01f, 4.16025743e-02f,
  -1.27099305e-01f, -5.32356352e-02f, -3.82570848e-02f, -7.75966495e-02f, -4.98405211e-02f, -1.67567849e-01f, -1.49978444e-01f, -1.75795868e-01f, -2.08746701e-01f, -7.07987547e-02f,
  -9.66277346e-02f, -4.80349436e-02f, -6.79928884e-02f, -2.45770261e-01f, -1.38669029e-01f, -1.21817671e-01f, -7.37257972e-02f, 5.80032589e-03f, -1.58650905e-01f, -2.15847380e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  6.90951049e-01f, 5.46046495e-01f, 2.22816288e-01f, 4.14728701e-01f, 4.29649472e-01f, 3.91432971e-01f, 4.13739592e-01f, 3.35266918e-01f, 5.89428484e-01f, 3.52477789e-01f,
  4.99052316e-01f, 4.73889500e-01f, 3.55953068e-01f, 2.17645019e-01f, 4.11878258e-01f, 4.08549130e-01f, 3.15491110e-01f, 5.03023505e-01f, 5.33077776e-01f, 3.14762145e-01f,
  5.89049220e-01f, 7.66924500e-01f, 1.68507382e-01f, 4.45608437e-01f, 3.16560149e-01f, 4.28189307e-01f, 4.18027937e-01f, 7.27727115e-01f, 2.59166181e-01f, 6.09360218e-01f,
  2.08488330e-01f, 6.02654874e-01f, 2.81531870e-01f, 5.53498745e-01f, 3.40307444e-01f, 4.12547112e-01f, 3.91370475e-01f, 2.46612355e-01f, 4.92876440e-01f, 8.01056623e-01f,
  5.96124470e-01f, 6.15239382e-01f, 4.23540831e-01f, 7.16136336e-01f, 2.40608811e-01f, 1.48381487e-01f, 2.47690305e-01f, 3.57598335e-01f, 7.13753521e-01f, 7.55257130e-01f,
  5.40326536e-01f, 4.65630859e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  7.47001683e-03f, -9.93301421e-02f, -2.97393084e-01f, -6.31220117e-02f, 3.74625511e-02f, -1.35101393e-01f, -1.54120341e-01f, -1.27950042e-01f, -3.67418885e-01f, -2.84914370e-03f,
  -8.09842125e-02f, -5.23499250e-02f, -4.99715097e-02f, -1.59029067e-01f, -2.25325614e-01f, -3.10771406e-01f, 2.18911543e-02f, -9.91362482e-02f, -1.85011759e-01f, -1.77057475e-01f,
  -3.60092521e-02f, -3.92643660e-02f, -2.20033810e-01f, -9.35950130e-02f, -2.98087820e-02f, -6.08888529e-02f, 1.74063072e-01f, -1.66103348e-01f, -1.54085949e-01f, -4.80973423e-02f,
  -5.08433096e-02f, -3.93783152e-02f, -4.84498702e-02f, 1.43981725e-01f, -4.83171381e-02f, -1.10416412e-01f, -1.70882434e-01f, 1.18333586e-02f, -4.92663234e-02f, -1.69576585e-01f,
  1.49712726e-01f, 6.95346519e-02f, 2.57870495e-01f, -4.25358117e-02f, -5.33386543e-02f, -2.07893878e-01f, 4.35749628e-02f, 8.08760002e-02f, 1.56605378e-01f, -1.82535470e-01f,
  1.85447559e-01f, 4.74583842e-02f, 2.67500639e-01f, -2.38738004e-02f, -1.66150331e-02f, 1.69663027e-01f, -2.33473852e-01f, 7.12667126e-03f, 1.25818830e-02f, 1.19217560e-01f,
  3.74169439e-01f, 4.83403988e-02f, 1.06110640e-01f, 1.59838721e-01f, 7.98078850e-02f, -1.66569799e-01f, -1.59822047e-01f, -5.31887002e-02f, 6.25608638e-02f, -2.79344320e-01f,
  -2.36266386e-03f, 1.07065253e-01f, -4.46282960e-02f, 6.36048019e-02f, 1.96415130e-02f, 3.04710548e-02f, -2.65772998e-01f, 4.44930702e-01f, 1.06068552e-02f, -3.84139866e-01f,
  7.46257901e-02f, -4.89646718e-02f, -2.12738261e-01f, -2.15554252e-01f, -8.54219273e-02f, 1.41844302e-01f, -7.93849118e-03f, 1.08136155e-01f, -6.23136424e-02f, -7.03893304e-01f,
  1.57315522e-01f, 2.36133292e-01f, 2.27933064e-01f, -8.29366818e-02f, -6.06497824e-01f, -4.09450233e-01f, -6.06047750e-01f, -6.80880666e-01f, 2.38017440e-01f, 1.10701554e-01f,
  1.57137290e-01f, 8.76951683e-03f, 2.76375085e-01f, -8.01683784e-01f, -5.37816994e-02f, 4.31903005e-02f, 2.96051037e-02f, -4.32271987e-01f, 3.36269736e-02f, -7.15302899e-02f,
  -8.01915705e-01f, 8.52328688e-02f, -4.07871842e-01f, -6.75836980e-01f, 1.34339826e-02f, -1.33102015e-01f, -2.21356571e-01f, -9.18482393e-02f, 3.87325615e-01f, 5.47659636e-01f,
  -5.78652561e-01f, -6.73472285e-02f, 4.48102802e-01f, -2.56049961e-01f, 2.97178686e-01f, -1.08799227e-02f, 1.38190925e-01f, -1.94655150e-01f, -7.91612826e-03f, -7.60929706e-03f,
  1.94083840e-01f, -6.25793859e-02f, -4.21368051e-03f, 6.80794753e-03f, -5.69852665e-02f, -3.50389853e-02f, -3.09494021e-03f, 5.75229228e-02f, -1.59821346e-01f, 3.43105458e-02f,
  6.67740498e-03f, -4.97318394e-02f, 7.39590526e-02f, -6.80370033e-02f, 9.56739113e-02f, 7.25571364e-02f, -1.86569333e-01f, 5.22364154e-02f, 7.82963336e-02f, -4.70540337e-02f,
  1.82653621e-01f, 1.21709734e-01f, -4.96804044e-02f, 1.95442140e-02f, -4.73698899e-02f, 7.58005530e-02f, 1.54585123e-01f, 4.97105084e-02f, 1.39055252e-01f, 9.35267657e-03f,
  -1.28933815e-02f, -3.34598012e-02f, 1.03317864e-01f, 9.86131877e-02f, -2.38803066e-02f, -7.12207481e-02f, 1.56952962e-01f, 1.03074022e-01f, -1.42528694e-02f, -1.38897598e-01f,
  6.01951554e-02f, -3.75399999e-02f, -3.95312272e-02f, 1.45746605e-03f, 1.94800004e-01f, -3.05305094e-01f, 1.57867938e-01f, 4.79991212e-02f, -2.08434626e-01f, -3.01254511e-01f,
  6.58206195e-02f, -8.82543996e-02f, -5.28044216e-02f, 3.90064180e-01f, 2.29444988e-02f, -3.03110126e-02f, -5.93390455e-03f, -2.88926661e-01f, -1.29397541e-01f, -2.74554193e-01f,
  1.20213598e-01f, -2.06679583e-01f, 2.95187943e-02f, 1.24268472e-01f, 7.22092539e-02f, 2.08302319e-01f, 1.06764473e-02f, -4.02150422e-01f, 3.17793816e-01f, 2.71377981e-01f,
  -9.96070951e-02f, 1.07815221e-01f, 2.02299487e-02f, 2.93380201e-01f, -2.51291692e-01f, 2.31211111e-01f, -1.61580905e-01f, -1.11751877e-01f, 1.12288795e-01f, -2.55592138e-01f,
  4.14334506e-01f, 1.32413045e-01f, 2.41646260e-01f, -2.69583285e-01f, -5.30950949e-02f, -1.48375854e-01f, 3.30959596e-02f, -1.50689436e-02f, -7.54074097e-01f, 2.99775191e-02f,
  -1.20035022e-01f, 9.33072641e-02f, -9.09785628e-01f, -3.61359030e-01f, -1.60352856e-01f, 1.09838516e-01f, -7.22755432e-01f, -8.87918591e-01f, -7.68785328e-02f, 2.19098777e-01f,
  -4.15842205e-01f, -1.08274662e+00f, -8.66970479e-01f, 1.42125010e-01f, -9.49920863e-02f, -7.40551054e-01f, 6.50937080e-01f, 1.71817869e-01f, -4.34749484e-01f, 5.14988363e-01f,
  1.05809987e-01f, -4.54221755e-01f, -6.99348629e-01f, 4.47656482e-01f, 5.41368723e-02f, -3.47361714e-01f, -6.33956432e-01f, 6.09563589e-01f, 2.94916015e-02f, 8.01660344e-02f,
  1.24083269e+00f, 7.74647593e-02f, -8.89004827e-01f, -6.78104520e-01f, 1.53959230e-01f, 2.61015534e-01f, 3.10056526e-02f, 1.18010156e-01f, -1.15911476e-01f, 1.05572164e-01f,
  1.13953836e-01f, 1.34911537e-01f, -2.29450837e-02f, 7.54371807e-02f, -3.54522578e-02f, 1.62835389e-01f, 2.30364427e-01f, 3.69033292e-02f, 3.84201445e-02f, 8.80226195e-02f,
  1.34541228e-01f, 1.43462121e-01f, 1.20920770e-01f, 8.78993701e-03f, 1.92353308e-01f, 1.25059232e-01f, 7.65422285e-02f, 1.70019612e-01f, 3.18449773e-02f, -1.04174600e-03f,
  3.88529301e-02f, -6.60928711e-02f, 4.61022742e-02f, -1.22923523e-01f, 1.05164886e-01f, -6.44482821e-02f, -8.71747583e-02f, 5.40298261e-02f, 1.33301437e-01f, 8.79193470e-02f,
  3.93712483e-02f, -1.29746690e-01f, 5.95939122e-02f, 1.62079275e-01f, 1.51498184e-01f, 1.19762078e-01f, 2.33856648e-01f, 1.57642350e-01f, 3.82685363e-02f, 2.33582810e-01f,
  3.07945400e-01f, 3.29127073e-01f, 2.31926724e-01f, -1.28138125e-01f, 1.40493840e-01f, -9.30623040e-02f, 2.26259723e-01f, -7.80766681e-02f, 9.73943323e-02f, 2.46611163e-01f,
  1.17565237e-01f, 2.80685425e-01f, -1.31999537e-01f, 1.14882484e-01f, 7.41418228e-02f, 2.28301018e-01f, -3.80149096e-01f, 2.22332478e-01f, -9.23258513e-02f, -1.16192900e-01f,
  2.32223332e-01f, 8.25024098e-02f, -1.02041088e-01f, -3.03628922e-01f, 2.36646920e-01f, -2.85149389e-03f, 1.15904268e-02f, -1.12940706e-01f, -1.59965545e-01f, 4.70027655e-01f,
  2.16038987e-01f, 3.23507130e-01f, 3.71996224e-01f, -3.51785421e-01f, 2.26364419e-01f, -1.32632747e-01f, 5.06756194e-02f, -4.62664872e-01f, -6.59870744e-01f, -3.59371662e-01f,
  1.61948830e-01f, -1.87512577e-01f, -4.26649332e-01f, 7.62307823e-01f, -8.76047835e-02f, 2.04296499e-01f, -1.48221776e-01f, -7.67452717e-01f, -6.50861040e-02f, -2.57079214e-01f,
  5.27380228e-01f, -3.34250510e-01f, -1.66951492e-01f, 3.35576773e-01f, 1.09555557e-01f, -2.58359075e-01f, -5.13555780e-02f, -6.55290708e-02f, -1.70026511e-01f, -6.24466419e-01f,
  -4.67143029e-01f, 3.93983908e-02f, 1.59084663e-01f, -3.57187480e-01f, 3.55395168e-01f, -2.06936106e-01f, -3.21345001e-01f, 3.01959664e-01f, 1.42395675e-01f, -3.62407178e-01f,
  -3.36386800e-01f, 1.92146227e-01f, 6.58294857e-02f, -4.64931399e-01f, 2.04871774e-01f, 4.64714676e-01f, -4.53740805e-01f, -2.96221324e-03f, -1.01752616e-01f, -3.27124655e-01f,
  3.84790972e-02f, 3.01324666e-01f, -6.91478431e-01f, -2.77047157e-01f, -2.08006620e-01f, 1.56226335e-02f, 6.18067309e-02f, 9.13573951e-02f, 1.51249440e-03f, 1.24423020e-02f,
  -4.77101244e-02f, 6.85720146e-02f, -1.39219910e-01f, -8.87992829e-02f, 5.74120991e-02f, 5.30617982e-02f, -2.36654356e-02f, 2.21784282e-02f, -9.07290205e-02f, -7.99727738e-02f,
  -1.18063390e-02f, -2.36070648e-01f, 1.59282461e-01f, -1.04212523e-01f, -5.54435439e-02f, -5.81571162e-02f, 1.26589015e-01f, 4.44091633e-02f, 5.52859232e-02f, 5.73070794e-02f,
  -5.46111092e-02f, 2.25977544e-02f, 3.58108841e-02f, 4.25720513e-02f, 4.89776097e-02f, 1.47672715e-02f, 6.22622222e-02f, -2.05024660e-01f, 9.24762115e-02f, -7.34924972e-02f,
  -1.05457835e-01f, -2.65569806e-01f, -5.21401726e-02f, -1.44833341e-01f, 7.60430023e-02f, -1.15953572e-01f, -3.93736839e-01f, -1.34433612e-01f, -2.33327538e-01f, 1.25576377e-01f,
  2.03131154e-01f, 1.33674264e-01f, -2.48687699e-01f, -2.78982855e-02f, -1.65920705e-01f, -6.37489781e-02f, 2.99456388e-01f, 1.15392776e-02f, -2.82553248e-02f, -2.83083618e-01f,
  1.61489025e-01f, -4.64892611e-02f, 7.04430416e-02f, 1.05001509e-01f, -2.92104334e-01f, 9.02126357e-02f, 2.32104827e-02f, -6.02253079e-02f, -2.15296090e-01f, 2.01526806e-01f,
  2.78880179e-01f, -4.97224217e-04f, -3.51023972e-02f, -1.68929193e-02f, 9.47254524e-02f, -1.70524195e-01f, 3.14066976e-01f, 2.15810463e-02f, 7.12077096e-02f, -4.12018597e-01f,
  -1.40101343e-01f, -1.05328608e+00f, -5.00295520e-01f, -1.24707974e-01f, 1.60221875e-01f, 3.02891880e-01f, -1.68180600e-01f, -3.97857726e-01f, -4.42409337e-01f, -2.41708964e-01f,
  -3.03733647e-01f, 1.68828577e-01f, -4.03561771e-01f, -7.94848576e-02f, 2.91609794e-01f, 2.88697749e-01f, 4.59999233e-01f, -6.72877491e-01f, -4.81887311e-01f, 2.53685027e-01f,
  3.47208232e-01f, -8.25739026e-01f, 6.62829436e-04f, 1.09265633e-01f, -2.15807587e-01f, -4.40762818e-01f, 1.64170176e-01f, -3.26120332e-02f, 1.12464949e-01f, -8.84459674e-01f,
  2.32465535e-01f, 2.26457998e-01f, 8.56551901e-03f, 5.17860204e-02f, 3.04558575e-02f, 4.73983943e-01f, -4.43498969e-01f, -6.07075810e-01f, 5.63330531e-01f, -1.60837412e-01f,
  2.41350040e-01f, -2.95827955e-01f, -2.95983881e-01f, -1.42023480e+00f, -3.60628426e-01f, -3.31570923e-01f, 1.17869705e-01f, -8.04926157e-02f, -3.42127889e-01f, 6.22594357e-01f,
  -4.71761674e-01f, 2.92057581e-02f, -5.52850291e-02f, -4.80339490e-02f, -8.85686744e-03f, 4.95048575e-02f, 5.91111630e-02f, 1.80963755e-01f, 7.36020282e-02f, -7.66891018e-02f,
  1.46901771e-01f, -1.75468281e-01f, -1.69694927e-02f, -5.88008091e-02f, -1.55858368e-01f, -1.80836156e-01f, 7.51363486e-02f, 1.42028064e-01f, -1.05504416e-01f, -1.59133092e-01f,
  -1.55229256e-01f, 2.52059400e-02f, -2.10063323e-01f, -8.83860961e-02f, 1.87334344e-02f, -2.08594978e-01f, -2.67974418e-02f, -9.76128057e-02f, -3.53871845e-02f, 1.54035985e-01f,
  -5.14602587e-02f, 9.28017404e-03f, -1.50593193e-02f, 1.54756941e-02f, -2.02852786e-02f, -1.13862595e-02f, -9.67120603e-02f, -8.91812667e-02f, -1.26561880e-01f, 7.28618577e-02f,
  1.94961697e-01f, 1.77180275e-01f, -1.67181551e-01f, -9.49085802e-02f, -6.01474494e-02f, -2.94476524e-02f, -3.52282785e-02f, -1.33909225e-01f, 6.93188682e-02f, 1.44984007e-01f,
  -5.44365458e-02f, -6.38907999e-02f, -1.87135562e-01f, 2.24534087e-02f, -1.73512295e-01f, 1.37337446e-01f, 6.09978773e-02f, -2.31753066e-01f, 2.16878682e-01f, -4.30145077e-02f,
  -2.21456841e-01f, -5.31212986e-03f, -1.01737335e-01f, -1.34782210e-01f, 1.46076649e-01f, -6.26254007e-02f, -3.55150044e-01f, -8.95493701e-02f, -1.39601842e-01f, -5.51219247e-02f,
  -1.72011957e-01f, 4.96887490e-02f, 4.18959074e-02f, -2.26504102e-01f, -8.87189992e-04f, 2.30993405e-02f, 2.67132133e-01f, 8.72093514e-02f, -4.95172262e-01f, -6.03658497e-01f,
  -2.82441825e-02f, -4.59933728e-02f, -4.23452519e-02f, 3.59922677e-01f, -4.15079594e-01f, -3.44479121e-02f, -2.97743917e-01f, -2.04653740e-01f, 3.78191203e-01f, 1.71739563e-01f,
  1.14009883e-02f, 2.44525596e-02f, -1.01735875e-01f, -3.89160246e-01f, -2.31436357e-01f, 1.42689392e-01f, 4.66519415e-01f, -9.69421398e-03f, -3.87417316e-01f, 1.48603573e-01f,
  2.00262934e-01f, 2.22837478e-01f, 9.86689851e-02f, -1.85517207e-01f, -2.14319840e-01f, 2.07802474e-01f, 3.36903602e-01f, -1.85894132e-01f, -4.42991316e-01f, 3.18356156e-01f,
  1.68081447e-01f, -2.39560589e-01f, 5.72411358e-01f, -2.31746078e-01f, -8.19177702e-02f, 6.20942354e-01f, -1.59846291e-01f, -2.22118065e-01f, 7.99535364e-02f, -3.21617186e-01f,
  8.89622793e-02f, -4.60253209e-01f, 1.29994810e-01f, 1.46581039e-01f, -6.19180322e-01f, 1.31497979e-01f, 7.11196065e-02f, -8.49111974e-01f, 5.42722046e-02f, -5.70260406e-01f,
  7.63857812e-02f, 7.07855076e-02f, 2.29863480e-01f, 4.57270741e-02f, 8.85691047e-02f, 1.88960969e-01f, 3.46931517e-02f, -2.17359401e-02f, 2.26832628e-01f, 1.98522016e-01f,
  1.87619656e-01f, 1.24274589e-01f, 5.52098900e-02f, 2.06860930e-01f, -2.63736788e-02f, 5.47774024e-02f, 1.99397460e-01f, 8.48633349e-02f, -1.03788786e-01f, -6.95452541e-02f,
  9.48150456e-02f, 2.48608664e-02f, 1.36669055e-01f, 4.14804667e-02f, -4.57214341e-02f, 1.35925442e-01f, 6.24557920e-02f, 5.39332023e-03f, 4.85620238e-02f, 5.46594448e-02f,
  -1.95537079e-02f, 5.81945516e-02f, -3.24024260e-02f, -5.58169112e-02f, 5.79012670e-02f, 1.10197492e-01f, 1.77538976e-01f, 6.77403435e-02f, -1.24101415e-01f, 1.00456581e-01f,
  -1.67784229e-01f, -1.08665496e-01f, 1.73981600e-02f, 7.79840127e-02f, 7.53674656e-02f, -1.80905625e-01f, -1.41558230e-01f, -1.36033922e-01f, 1.28358543e-01f, 8.61042067e-02f,
  -9.81913432e-02f, -2.54231393e-01f, -3.51518959e-01f, -1.36252893e-02f, 2.85304546e-01f, -3.27007383e-01f, 3.16590101e-01f, -9.13293958e-02f, -1.80457398e-01f, -9.19041261e-02f,
  4.56771970e-01f, 1.22651875e-01f, 5.84392920e-02f, 8.50815549e-02f, 3.20805967e-01f, -3.13859761e-01f, -2.03479335e-01f, -4.75336332e-03f, 5.81975244e-02f, 2.10046634e-01f,
  7.61259794e-02f, 1.51793003e-01f, -2.07914874e-01f, -2.52946854e-01f, 1.97097454e-02f, 2.79805511e-01f, -2.30965927e-01f, 7.33504593e-01f, -1.93541090e-03f, -3.48131210e-01f,
  8.35385546e-02f, -5.54793552e-02f, -2.29657710e-01f, 2.66233515e-02f, -3.85139346e-01f, 2.72664547e-01f, 3.53159785e-01f, -8.06547225e-01f, -9.12688151e-02f, -3.52371514e-01f,
  4.53334659e-01f, -1.61401723e-02f, -2.55780697e-01f, 3.57819527e-01f, -4.65876102e-01f, -2.58645564e-01f, -9.62573141e-02f, 3.73895407e-01f, -9.39113140e-01f, -8.76419321e-02f,
  -4.37820889e-02f, -1.49162829e-01f, 5.31688452e-01f, 7.63186395e-01f, 2.96157598e-01f, 1.09081484e-01f, -4.66661543e-01f, -7.41441309e-01f, -4.00345713e-01f, 2.89707839e-01f,
  -3.42466027e-01f, -1.10863119e-01f, -2.68070549e-01f, -9.36894417e-02f, -4.82662797e-01f, -3.81864756e-01f, -6.47606432e-01f, 5.38112581e-01f, -1.60027862e-01f, -4.63162780e-01f,
  -1.53550133e-01f, -6.67092204e-02f, -5.73000789e-01f, 2.59232849e-01f, 2.82675982e-01f, -5.45782089e-01f, 6.91910744e-01f, 2.79595107e-01f, 5.87054482e-03f, 5.47202080e-02f,
  -9.61757600e-02f, 8.39417800e-02f, 6.85232282e-02f, -3.65099400e-01f, 2.13329848e-02f, 2.93379407e-02f, -1.57254934e-01f, 2.71766987e-02f, -5.10866791e-02f, 2.02799678e-01f,
  -2.51045078e-01f, 1.00915860e-02f, 1.98239624e-03f, -1.85954981e-02f, -5.75662125e-03f, 3.98432836e-02f, -8.91569033e-02f, 1.65343016e-01f, -6.06377497e-02f, -8.80702864e-03f,
  3.29857841e-02f, 2.40122452e-02f, 8.38721842e-02f, 3.81362103e-02f, 5.53751253e-02f, -1.09153874e-02f, -7.09093139e-02f, -7.13680312e-02f, 2.80936956e-02f, 4.88594957e-02f,
  -4.68243733e-02f, 2.54067108e-02f, 2.73933373e-02f, 6.46465793e-02f, 1.07854508e-01f, -2.62876861e-02f, -2.59808302e-01f, 2.25332640e-02f, -1.45484701e-01f, 1.23209618e-01f,
  -2.59984890e-03f, 2.06206188e-01f, 1.19880520e-01f, 1.40448540e-01f, -2.84347117e-01f, -1.75098494e-01f, -6.49071410e-02f, 3.90749832e-04f, 2.13274121e-01f, 1.20518394e-01f,
  -1.97607115e-01f, -2.00375289e-01f, 2.24736780e-02f, 2.17314959e-01f, -1.00032941e-01f, 9.92734358e-02f, 4.14615452e-01f, 1.07671514e-01f, 1.31297380e-01f, 9.38142240e-02f,
  1.04950927e-01f, 8.03259388e-02f, -4.06686999e-02f, 4.48012166e-02f, -6.54075015e-03f, -1.78452104e-01f, 2.37951074e-02f, -2.16581859e-02f, -2.48675168e-01f, -1.03781395e-01f,
  7.47601241e-02f, -4.36458550e-02f, 3.47488701e-01f, 2.76271671e-01f, 2.25931302e-01f, 5.65665483e-01f, 1.25396192e-01f, 4.27570462e-01f, 5.70920296e-02f, -3.94619077e-01f,
  -1.77414715e-02f, -3.21979940e-01f, 3.22815061e-01f, -3.37722719e-01f, -4.14088070e-01f, -4.85082418e-01f, -1.20646164e-01f, -3.46843392e-01f, -3.42575938e-01f, -1.94657296e-01f,
  -7.17032731e-01f, 2.76803464e-01f, 5.30451119e-01f, -8.37107420e-01f, -4.40839797e-01f, -4.90345173e-02f, -4.64263827e-01f, -4.36289698e-01f, -1.96054995e-01f, -1.23277992e-01f,
  -6.71460867e-01f, 1.74362466e-01f, -4.59984660e-01f, -3.01842600e-01f, -4.05965686e-01f, 7.31683731e-01f, -5.81597805e-01f, -2.67741591e-01f, -1.64759651e-01f, -3.52064669e-01f,
  -2.72365570e-01f, 3.23255241e-01f, -4.62159336e-01f, 6.00739121e-02f, 1.07422464e-01f, -2.09366202e-01f, -8.41994584e-01f, -1.42784938e-01f, -2.73161829e-01f, 1.53481469e-01f,
  -5.01287341e-01f, -6.52004704e-02f, 4.99344736e-01f, -4.23861235e-01f, -5.93911707e-01f, 2.93535352e-01f, -5.38978390e-02f, -1.44987702e-01f, -8.04993063e-02f, -2.43441872e-02f,
  -1.44404382e-01f, -2.93304026e-01f, 8.88502784e-03f, -1.23234876e-01f, -6.15733564e-02f, -2.43032277e-01f, -2.48044148e-01f, -6.35975450e-02f, 1.44386128e-01f, -7.49144629e-02f,
  -1.86647281e-01f, 6.69075027e-02f, -6.96936296e-03f, -1.05770901e-02f, -1.68639928e-01f, 4.52620201e-02f, -2.38842577e-01f, -6.99699447e-02f, -3.29306982e-02f, -1.00196615e-01f,
  -5.53645156e-02f, 1.96084473e-02f, -1.84719577e-01f, -8.34738463e-02f, 7.95372855e-03f, -6.68545291e-02f, -6.69465661e-02f, -2.93391407e-01f, 6.95352703e-02f, -1.30894795e-01f,
  -1.55371219e-01f, -1.01289347e-01f, -1.18131123e-01f, -1.29725695e-01f, 5.89317195e-02f, -1.94767058e-01f, 2.31516421e-01f, 1.42984852e-01f, 4.64828089e-02f, -3.34665412e-03f,
  1.16147883e-01f, -1.45565961e-02f, 1.47535414e-01f, 7.16118738e-02f, -1.81382477e-01f, -3.92409787e-02f, 1.38647363e-01f, 1.53135806e-01f, -1.77469745e-01f, -5.98670274e-04f,
  -2.87072198e-03f, 2.92891748e-02f, -4.91510853e-02f, 1.06735127e-02f, -1.59679756e-01f, -9.05897766e-02f, -1.66615054e-01f, 2.22948357e-01f, -2.28701998e-02f, 1.09897219e-01f,
  -7.11410493e-02f, -3.97758745e-02f, 1.82859063e-01f, -1.25298187e-01f, 5.17560728e-02f, 2.26125538e-01f, 2.31793597e-02f, 5.09598441e-02f, -5.31397127e-02f, -4.51535210e-02f,
  -1.98678210e-01f, -1.41899228e-01f, -5.66502690e-01f, -3.88386808e-02f, -1.38892174e-01f, -2.60355860e-01f, -1.46468461e-01f, -2.66810298e-01f, -2.19955221e-01f, 3.44711654e-02f,
  -3.01463515e-01f, 3.37270230e-01f, -2.03439325e-01f, -8.54583383e-02f, 2.05126762e-01f, -7.21304864e-02f, 4.23799872e-01f, -5.28741479e-01f, -7.48253390e-02f, -2.96641797e-01f,
  -3.60707432e-01f, 4.95417178e-01f, 4.59266216e-01f, 1.63861856e-01f, 2.21111700e-01f, -3.91481400e-01f, 2.27289945e-01f, -2.18853667e-01f, 2.70770609e-01f, 1.01857908e-01f,
  -2.23960891e-01f, -1.40380874e-01f, 5.26757360e-01f, 2.57484376e-01f, -2.42984563e-01f, -3.91754389e-01f, -3.53003889e-01f, -5.31872749e-01f, -2.45464176e-01f, -7.00979531e-02f,
  4.11424637e-01f, -1.97426260e-01f, -2.04029515e-01f, -1.11839235e-01f, -5.28729856e-01f, -9.14283246e-02f, 1.96628347e-01f, 6.88569471e-02f, -8.51757228e-01f, 1.09454868e-02f,
  -2.64872402e-01f, 3.33813012e-01f, -4.82405573e-01f, -2.54122317e-01f, 1.48932710e-01f, 1.67325333e-01f, -1.04204983e-01f, 9.67727005e-02f, 1.71068370e-01f, 3.66872251e-02f,
  1.24747157e-02f, 1.98987406e-02f, -1.93279132e-01f, -4.41425294e-02f, 8.27917829e-03f, -1.54677451e-01f, 1.27262920e-01f, -1.69394851e-01f, 1.96469367e-01f, 8.93939361e-02f,
  2.52190549e-02f, 1.17477559e-01f, 2.54096180e-01f, -2.97088306e-02f, -7.54002184e-02f, 2.95238337e-03f, 2.83827409e-02f, -2.06140266e-03f, -3.69766019e-02f, 1.50362641e-01f,
  -4.67292741e-02f, 2.05556005e-01f, 4.63070795e-02f, 7.26134926e-02f, 2.12040931e-01f, 5.82848191e-02f, 9.48129594e-03f, 8.30425099e-02f, -4.13083248e-02f, -1.92407072e-01f,
  -1.98993310e-01f, 7.40248561e-02f, 1.37973756e-01f, 8.66236240e-02f, -1.80736020e-01f, 1.43066287e-01f, 3.30642283e-01f, -3.17401022e-01f, 2.86866993e-01f, -1.17365187e-02f,
  -3.40289026e-01f, -2.71898925e-01f, 2.42285505e-01f, 1.25116244e-01f, 2.82608628e-01f, 4.23841268e-01f, 4.21158135e-01f, -5.88982366e-02f, -2.94739813e-01f, 2.71436840e-01f,
  -2.64571160e-01f, -2.19033971e-01f, 3.75402153e-01f, -2.94315577e-01f, -5.35772920e-01f, 2.99373150e-01f, -3.39663506e-01f, 1.85687020e-01f, 3.41406435e-01f, -1.51486650e-01f,
  -3.18009347e-01f, 9.23248529e-02f, 4.88734022e-02f, 2.55738020e-01f, -2.46473014e-01f, 1.70866728e-01f, 3.97293389e-01f, -2.43960902e-01f, -4.23612028e-01f, -5.15195429e-01f,
  9.62365806e-01f, -3.97444814e-01f, -3.16636711e-01f, -1.15048721e-01f, 2.02746496e-01f, -4.78893667e-01f, -4.12642062e-01f, 8.42446387e-02f, -4.19476151e-01f, 5.24008870e-02f,
  -3.76027316e-01f, -2.59583235e-01f, 2.44779754e-02f, 1.22445203e-01f, -1.47800952e-01f, -2.13097855e-01f, -2.24467561e-01f, -4.57138509e-01f, -1.20104291e-01f, 7.58655043e-03f,
  -7.61130126e-03f, -4.82353091e-01f, -1.01566724e-02f, -4.08375710e-01f, 1.36848584e-01f, -1.37008578e-02f, -4.42823648e-01f, -9.68488574e-04f, -2.09618688e-01f, 6.82935059e-01f,
  -2.95833468e-01f, -3.61408204e-01f, -4.47817355e-01f, -1.30287290e-01f, -8.83427978e-01f, -5.27618408e-01f, 2.38878489e-01f, -3.17155600e-01f, -5.17135262e-01f, 3.89660835e-01f,
  -2.60022789e-01f, 3.29518884e-01f, -3.17470163e-01f, -3.66888702e-01f, -9.02298912e-02f, -4.58298415e-01f, -5.43586373e-01f, 2.18180403e-01f, -1.75668329e-01f, 6.34952009e-01f,
  -6.29278004e-01f, -1.02258632e-02f, 5.92674948e-02f, -1.85626268e-01f, -6.12666160e-02f, -4.13741171e-02f, -1.20252416e-01f, 1.13976888e-01f, 2.53101904e-02f, 1.53491691e-01f,
  1.20362803e-01f, -5.22589944e-02f, -6.57369243e-03f, -2.52744794e-01f, 7.38361701e-02f, -1.56990830e-02f, 5.12820203e-03f, -9.21261013e-02f, -2.62622982e-02f, -9.04309750e-02f,
  -1.34465843e-01f, -2.01525271e-01f, -4.50728089e-03f, -1.63827658e-01f, -1.14462599e-01f, -6.88136071e-02f, 1.74685307e-02f, -4.10026982e-02f, -5.42962849e-02f, -7.15435296e-02f,
  2.50304528e-02f, -1.35993451e-01f, -4.33052257e-02f, -5.92335267e-03f, 8.43940303e-03f, 1.81732997e-02f, 3.05469278e-02f, 2.75959581e-01f, -1.63909882e-01f, 6.30889088e-02f,
  -1.42001539e-01f, -1.93519577e-01f, 2.86727518e-01f, 3.40264067e-02f, 2.74904937e-01f, 2.62978226e-01f, -3.09768617e-01f, -2.54235994e-02f, 1.76905930e-01f, 2.58378476e-01f,
  -2.08346650e-01f, -4.24815863e-01f, 1.62173307e-03f, -9.28857327e-02f, -1.66652754e-01f, -2.65093327e-01f, 1.64567307e-01f, -8.12223628e-02f, 9.24932770e-04f, 1.20260015e-01f,
  -3.12725037e-01f, 2.34007180e-01f, 3.05943102e-01f, -3.14617097e-01f, 8.34276974e-02f, 2.99159288e-01f, 2.09808469e-01f, 8.48785415e-02f, 2.38110647e-01f, -1.14238247e-01f,
  2.86872178e-01f, -4.18923609e-02f, -2.37890601e-01f, -2.34432250e-01f, -3.50427300e-01f, -1.29987840e-02f, -2.69535542e-01f, 5.97952157e-02f, -3.82242590e-01f, -4.13426459e-01f,
  1.40644833e-01f, -7.17555685e-03f, 2.06640050e-01f, -5.87482810e-01f, 4.64090258e-02f, 1.00397341e-01f, 3.37476134e-01f, -1.20827414e-01f, 8.52219015e-02f, -8.85648787e-01f,
  -1.04659133e-01f, 4.64302003e-01f, -8.36522937e-01f, -7.73007870e-01f, -6.13239348e-01f, -3.28510135e-01f, 2.49725610e-01f, 6.18540525e-01f, -3.89502794e-01f, 3.74205798e-01f,
  6.50185943e-01f, -4.95542288e-01f, -2.64277488e-01f, 8.79428312e-02f, -4.87827450e-01f, -1.44528523e-02f, 3.82569879e-01f, -2.15505630e-01f, 5.17677009e-01f, -1.34025931e-01f,
  -3.14068526e-01f, 1.06337339e-01f, 3.09215456e-01f, -8.98092806e-01f, -1.61844477e-01f, 3.26532751e-01f, -9.28284407e-01f, -4.24337119e-01f, -3.54912907e-01f, -2.65393496e-01f,
  6.24243081e-01f, 3.56414258e-01f, 5.60831949e-02f, -3.98196191e-01f, -4.27863300e-01f, 1.36918575e-01f, 2.65266508e-01f, -3.45297486e-01f, 4.85506594e-01f, 9.64439958e-02f,
  9.75329243e-03f, 1.52511094e-02f, 3.90978716e-02f, -6.51255846e-02f, -2.14392677e-01f, -1.30341038e-01f, -3.05836536e-02f, -2.42890660e-02f, 1.56724274e-01f, 1.24743134e-01f,
  5.40940128e-02f, -1.61687173e-02f, 9.41368714e-02f, 1.80088356e-01f, 3.49881873e-02f, 8.35312754e-02f, 1.10118642e-01f, 7.94942081e-02f, 1.60876736e-01f, 6.33133352e-02f,
  -4.87422533e-02f, 9.51481834e-02f, -1.25748262e-01f, 8.35523307e-02f, 1.23334117e-01f, -1.11606181e-01f, 1.82141751e-01f, 3.94073762e-02f, 6.60632625e-02f, -2.48445198e-04f,
  1.49596721e-01f, 1.18971299e-02f, -8.41658935e-02f, 1.38011694e-01f, -2.77653113e-02f, 1.36751235e-01f, 9.15682986e-02f, 1.64077595e-01f, -2.03225955e-01f, -1.30138084e-01f,
  -6.53623939e-02f, -2.13736162e-01f, -2.60285348e-01f, -2.35825717e-01f, -1.99619725e-01f, -4.42272052e-02f, -2.19220184e-02f, -2.62174066e-02f, 1.56809032e-01f, -1.70824453e-01f,
  -1.81965888e-01f, 1.63144186e-01f, -3.65405560e-01f, -1.04211062e-01f, -1.73985779e-01f, -3.79259437e-01f, -2.92527467e-01f, 4.70857844e-02f, -1.09477207e-01f, 1.39559150e-01f,
  -3.24392915e-01f, -1.81715921e-01f, 1.41321108e-01f, 2.66720951e-01f, -1.20414332e-01f, 4.26265374e-02f, -1.30500361e-01f, 8.26525465e-02f, 8.67318828e-04f, -1.47627473e-01f,
  3.23942661e-01f, -4.42852825e-02f, -3.27522188e-01f, 3.12741190e-01f, -3.67240965e-01f, 1.74408227e-01f, -3.14392120e-01f, -5.73851585e-01f, -7.18495771e-02f, -2.17572466e-01f,
  -5.72695673e-01f, -2.99756318e-01f, -2.22593680e-01f, -1.89102665e-01f, -2.53468901e-01f, 2.77714849e-01f, -4.43137586e-01f, -4.06397641e-01f, -5.08056544e-02f, 4.02176857e-01f,
  -2.58545559e-02f, 6.59406364e-01f, 2.35169962e-01f, -4.99070853e-01f, -2.70375580e-01f, -2.64976650e-01f, 6.44937277e-01f, -3.64472032e-01f, -4.86759216e-01f, 3.42326701e-01f,
  -5.70334196e-01f, 3.63478392e-01f, -2.99361348e-01f, -4.66601878e-01f, -4.92367536e-01f, 2.84643441e-01f, -2.92246372e-01f, -2.12512642e-01f, -3.03615898e-01f, -5.67002520e-02f,
  6.87530935e-01f, -5.97425699e-01f, -3.97017866e-01f, -3.27642322e-01f, -5.38099706e-01f, -2.24608004e-01f, -1.56492159e-01f, 5.39260209e-01f, 3.09644103e-01f, -2.00432062e-01f,
  -1.66081950e-01f, -1.79314286e-01f, 6.84618726e-02f, -5.73006392e-01f, -2.94959992e-01f, -4.84728843e-01f, -6.23232186e-01f, -2.51549155e-01f, 6.57283068e-02f, -1.50480252e-02f,
  -2.40484446e-01f, -7.45782033e-02f, 1.85608808e-02f, 1.44883767e-01f, 5.28804734e-02f, 9.81434509e-02f, -8.53879005e-02f, 2.07185410e-02f, 6.13435581e-02f, -2.17541102e-02f,
  -3.51224169e-02f, -6.06031269e-02f, 4.60021533e-02f, 1.45004600e-01f, 7.17881471e-02f, 7.03680217e-02f, 6.12209812e-02f, -8.67562518e-02f, 7.28540942e-02f, -2.79095341e-02f,
  1.65106803e-01f, 2.00629625e-02f, 1.92717373e-01f, -1.46298021e-01f, -1.24147106e-02f, 7.13181496e-02f, -1.60943881e-01f, -3.16006839e-02f, -2.66010016e-01f, 7.89112374e-02f,
  -7.19198138e-02f, 6.25466229e-03f, 3.00225001e-02f, -1.24435052e-01f, 6.34230748e-02f, 1.96313635e-01f, 2.18376040e-01f, 9.51098725e-02f, -1.61922276e-01f, 9.97425094e-02f,
  2.01179713e-01f, 7.99272582e-02f, 5.37000336e-02f, 2.30274238e-02f, -2.40283176e-01f, 6.80389628e-02f, -8.13679919e-02f, 2.27781460e-01f, 3.19646895e-01f, 9.49015692e-02f,
  4.41411495e-01f, 8.01851600e-03f, 1.51797757e-01f, -2.34211862e-01f, 6.62814602e-02f, -1.86383188e-01f, -1.74651176e-01f, 2.60609865e-01f, 5.40555790e-02f, -1.93371013e-01f,
  -3.21118444e-01f, -3.81965727e-01f, -2.76954621e-01f, 3.44262391e-01f, 2.16224343e-01f, 2.20287085e-01f, -3.80875081e-01f, -4.90495637e-02f, -4.55541424e-02f, 9.11917388e-02f,
  2.15022922e-01f, -1.73623472e-01f, 7.03124851e-02f, -3.28162044e-01f, -5.67524195e-01f, -4.08274233e-01f, -2.56932586e-01f, 4.78481978e-01f, -5.02685368e-01f, 1.26170084e-01f,
  3.81824911e-01f, 3.04490864e-01f, -2.68908471e-01f, -3.04968655e-01f, -3.53116304e-01f, -1.08804293e-02f, -5.33701181e-01f, -1.30198836e-01f, -5.24345696e-01f, -3.45060885e-01f,
  1.82608157e-01f, 5.95356487e-02f, -3.35662067e-01f, 6.01262935e-02f, -4.71387297e-01f, -4.97100770e-01f, -1.55928984e-01f, 2.44028717e-01f, 1.03216380e-01f, -5.19197226e-01f,
  -7.20626041e-02f, 7.43900180e-01f, -2.77118117e-01f, -2.04020381e-01f, -6.04007304e-01f, 3.19263339e-01f, -3.31166536e-01f, 2.10655898e-01f, 1.91466674e-01f, -5.57172775e-01f,
  3.48849714e-01f, 1.48533896e-01f, 7.56650448e-01f, -4.10908252e-01f, 7.55639553e-01f, -7.88265914e-02f, -1.29601285e-01f, -1.76518932e-01f, -1.12358898e-01f, -3.75898369e-02f,
  -1.07813261e-01f, -1.18334047e-01f, -8.33389044e-01f, 1.94505915e-01f, -5.87744534e-01f, -1.81702934e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.23260134e-01f, 1.74028665e-01f, -3.05184461e-02f, -2.52995174e-02f, -1.66428521e-01f, -4.16538827e-02f, -9.77427289e-02f, -3.03179864e-02f, 1.17731988e-01f, -1.20342954e-03f,
  7.67709687e-02f, -3.24932002e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    