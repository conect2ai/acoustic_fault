/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.79696918e-01f, -6.87721968e-02f, -3.14622790e-01f, -1.05759360e-01f, -1.46123126e-01f, -1.01334684e-01f, 8.04719105e-02f, -7.35781863e-02f, -1.18338004e-01f, 3.80508363e-01f,
  1.50481939e-01f, -1.03942052e-01f, 3.17994267e-01f, 3.03940605e-02f, -1.70079991e-01f, 1.51563972e-01f, -3.95690352e-02f, 2.96298508e-02f, -1.02102466e-01f, -1.12269493e-02f,
  -1.00077569e-01f, 1.66402966e-01f, -1.54202253e-01f, 4.62347940e-02f, -1.66397303e-01f, -1.38295978e-01f, 1.71357304e-01f, 6.20875508e-02f, 2.75616627e-02f, -3.31040658e-02f,
  -2.10413545e-01f, -2.11925786e-02f, -9.52517539e-02f, 3.28266993e-02f, -1.02970423e-02f, 3.22876163e-02f, -3.08387056e-02f, 6.83186250e-03f, -9.15951505e-02f, -1.49959633e-02f,
  5.65606430e-02f, -2.30449773e-02f, -5.97572699e-03f, 7.12752994e-03f, -1.98065676e-02f, -4.62897755e-02f, -7.36980364e-02f, -3.90103683e-02f, 2.78498419e-03f, -6.38893023e-02f,
  -6.17070831e-02f, -8.47645625e-02f, 1.81336291e-04f, 5.43224812e-02f, -5.32410704e-02f, -2.39804331e-02f, 7.38312816e-03f, -3.10089272e-02f, -1.75995231e-02f, -3.40187065e-02f,
  3.59484442e-02f, 6.12608343e-02f, 1.44109232e-02f, -3.38191763e-02f, 2.34429073e-02f, 2.15337388e-02f, 1.80451181e-02f, 4.16009203e-02f, -6.29339516e-02f, 5.08330204e-02f,
  -3.28018256e-02f, -3.67015302e-02f, -1.17808217e-04f, -5.85507462e-03f, 3.31556238e-02f, -4.60406998e-03f, 3.12928751e-04f, 4.99220565e-02f, -2.54084915e-02f, -5.57232201e-02f,
  4.91183437e-02f, 6.96630776e-03f, 1.89674590e-02f, 2.07529925e-02f, 3.79347093e-02f, -2.35976633e-02f, 4.69312072e-02f, -1.27390129e-02f, -3.77918547e-03f, 3.93186733e-02f,
  2.95155317e-01f, 4.19363976e-01f, 5.21739163e-02f, -3.87879834e-02f, 1.67610999e-02f, -8.35302919e-02f, 2.13618260e-02f, -3.52808684e-02f, 7.89758265e-02f, 3.04232035e-02f,
  -8.83994438e-03f, 8.51292722e-03f, 1.26412371e-02f, -5.31849153e-02f, -1.55225396e-02f, 2.52376013e-02f, 1.33655742e-01f, 1.43757351e-02f, 2.62915343e-02f, 1.92328747e-02f,
  4.88882661e-02f, 7.66307637e-02f, -3.81255336e-02f, -2.98373587e-02f, 1.65771414e-02f, 4.62903492e-02f, -3.52611169e-02f, 3.24497670e-02f, 2.28209905e-02f, 8.93286616e-03f,
  2.35352337e-01f, 3.29153806e-01f, 1.57528430e-01f, -2.45687455e-01f, -4.59045311e-03f, 4.65387285e-01f, 2.05968991e-01f, 1.03172943e-01f, 2.82558471e-01f, 5.39342128e-02f,
  -1.03006754e-02f, -1.81598380e-01f, 1.63008079e-01f, -1.00986920e-01f, -3.61907780e-02f, 2.07948998e-01f, 9.59544107e-02f, 1.66971907e-02f, 2.17930809e-01f, 4.18918617e-02f,
  -3.24183404e-02f, -1.02262884e-01f, -1.57542035e-01f, 2.29367875e-02f, -9.07305703e-02f, -8.52471963e-02f, -3.16171825e-01f, 8.42041057e-03f, -1.41413778e-01f, -1.66479312e-02f,
  1.02810264e-02f, 8.85858983e-02f, -1.01858340e-01f, 4.45382483e-02f, -6.67093671e-04f, -6.00734428e-02f, -5.19964434e-02f, -3.50261517e-02f, -1.33860651e-02f, 3.73075493e-02f,
  -2.57471316e-02f, -1.03925690e-01f, -6.14208309e-03f, -3.17479223e-02f, 1.19602762e-01f, -8.35685059e-03f, -4.49557900e-02f, 1.55054815e-02f, -2.59710290e-03f, -2.32835915e-02f,
  6.81698769e-02f, 9.88334185e-04f, -2.67995428e-02f, 2.50680484e-02f, 2.00289534e-03f, 4.21140864e-02f, -2.82518398e-02f, 3.49908834e-04f, -2.56678164e-02f, 3.23389061e-02f,
  5.46843298e-02f, 3.82761955e-02f, -8.23434070e-03f, -1.53352469e-02f, 3.14634107e-02f, -3.36385034e-02f, 1.08841863e-02f, -3.41265909e-02f, -7.86685757e-03f, -2.44679227e-02f,
  3.85461235e-03f, 2.30643898e-02f, -5.99250337e-03f, 3.34997587e-02f, -4.56068702e-02f, -1.77026093e-02f, -1.10925147e-02f, -3.81958112e-02f, 3.02063189e-02f, -8.51954296e-02f,
  1.92570593e-02f, 5.52838892e-02f, -8.17006547e-03f, -2.25338973e-02f, 7.32849017e-02f, 3.40240672e-02f, 1.80844590e-02f, 4.66671437e-02f, -2.90284753e-02f, -3.46830375e-02f,
  2.47146070e-01f, 2.38953397e-01f, 6.85595348e-02f, -4.06321995e-02f, 1.36242444e-02f, -5.24179526e-02f, 6.65041283e-02f, -3.00914291e-02f, 1.16673455e-01f, 1.29348384e-02f,
  -1.27984257e-02f, 1.19785499e-02f, 2.74450239e-02f, 3.05370558e-02f, -3.37617137e-02f, 2.94622350e-02f, 6.06031977e-02f, -1.48784891e-02f, 5.25631616e-03f, -3.13414484e-02f,
  -8.94166306e-02f, 2.13320740e-02f, -3.66266668e-02f, -7.40866438e-02f, -8.86890516e-02f, -2.09867060e-02f, -1.70284882e-02f, 8.30262899e-03f, -1.65485106e-02f, 2.21191086e-02f,
  -4.58626449e-01f, -3.25080246e-01f, -3.77660878e-02f, -1.32643595e-01f, 1.45469815e-01f, -2.15074509e-01f, -3.59155625e-01f, -7.26864859e-02f, 1.98320180e-01f, -3.41807574e-01f,
  -9.74761322e-02f, -7.95769691e-02f, -3.62936757e-03f, -3.57438803e-01f, 2.38858864e-01f, 1.85039043e-02f, -3.60504925e-01f, -2.73330450e-01f, 1.26178026e-01f, -1.42245203e-01f,
  2.70764586e-02f, -1.47357494e-01f, -5.48172891e-02f, 1.65613934e-01f, -1.89936787e-01f, 4.25203070e-02f, -4.00267877e-02f, 1.26637250e-01f, -1.36873856e-01f, 8.06053206e-02f,
  5.08758985e-02f, 1.27371371e-01f, -5.15497252e-02f, 4.45503034e-02f, -7.60391504e-02f, -1.01821780e-01f, -7.20983744e-02f, 4.70946394e-02f, 8.40676576e-02f, -1.74875781e-02f,
  -3.12564597e-02f, 5.18279485e-02f, 2.01730002e-02f, 2.42919382e-02f, 2.05451483e-03f, 5.72337359e-02f, 6.52048886e-02f, -4.07981081e-03f, 4.00074571e-02f, -3.63597721e-02f,
  1.92060729e-03f, -5.16377054e-02f, -3.09735555e-02f, -2.68781763e-02f, 6.37181625e-02f, 5.16589172e-02f, 1.69288907e-02f, -6.94245612e-03f, -1.10521563e-03f, 1.55500099e-02f,
  -4.10554409e-02f, 2.43464927e-03f, -1.90255959e-02f, 1.32279377e-02f, 6.48103803e-02f, 7.57588632e-03f, 5.38264513e-02f, -1.04614431e-02f, 2.07755361e-02f, 2.25334149e-02f,
  8.80298112e-03f, -2.62996070e-02f, 8.01245216e-03f, -1.84716135e-02f, -3.02702710e-02f, -1.13592548e-02f, 1.90568753e-02f, -1.66299375e-04f, -5.65537959e-02f, -2.70931772e-03f,
  2.26261653e-02f, 1.71251670e-02f, -1.53241297e-02f, -5.43594062e-02f, -1.21665346e-02f, 2.44647879e-02f, -6.12683073e-02f, 3.19732539e-03f, 9.60638467e-03f, -1.28619559e-02f,
  -1.18694656e-01f, -1.94926456e-01f, 1.38716977e-02f, 5.67675456e-02f, 2.02189256e-02f, -1.27556147e-02f, 2.81725395e-02f, -5.70323877e-03f, 1.00390650e-02f, 1.05875707e-03f,
  -5.11958562e-02f, -2.32289620e-02f, -2.76997741e-02f, -3.35972309e-02f, 6.90612718e-02f, -7.96755105e-02f, -6.41904473e-02f, 9.08651948e-03f, -8.15245733e-02f, 2.09396263e-03f,
  -4.46022414e-02f, 3.59161831e-02f, 6.14285246e-02f, 4.33652066e-02f, -4.85689715e-02f, -4.83902879e-02f, 7.25281483e-04f, 1.26577076e-02f, -1.93932336e-02f, 1.44127142e-02f,
  6.82079569e-02f, 1.33134365e-01f, 3.19951624e-01f, 2.82044291e-01f, -4.31987584e-01f, -2.25703120e-01f, 2.04172447e-01f, -1.55041352e-01f, 6.73892125e-02f, -1.36489928e-01f,
  -1.90270945e-01f, 3.17858964e-01f, 1.54167205e-01f, -9.05748010e-02f, 3.99052233e-01f, 2.46536851e-01f, -5.78915440e-02f, -2.05860101e-02f, -2.23666057e-02f, -6.66704327e-02f,
  5.61870672e-02f, -2.20905527e-01f, 1.87772080e-01f, -2.79341400e-01f, -1.96597084e-01f, 5.94306923e-03f, -4.32229899e-02f, 5.00025861e-02f, -1.05420962e-01f, 7.67400339e-02f,
  -2.23584473e-01f, -1.81277260e-01f, 1.02596082e-01f, 4.38157432e-02f, -6.71702549e-02f, -6.14481093e-03f, 6.06947392e-02f, 6.02571219e-02f, 5.75602576e-02f, 4.22990695e-03f,
  3.05460338e-02f, -3.08535788e-02f, -3.27544622e-02f, 2.29006000e-02f, -9.16036069e-02f, 2.44017616e-02f, -3.30799930e-02f, -3.98843139e-02f, -6.65104203e-03f, 1.26834214e-02f,
  5.92424348e-03f, -3.47402953e-02f, -2.63566356e-02f, 4.68419166e-03f, 4.26161429e-03f, -2.49833483e-02f, 5.51298745e-02f, 7.60004222e-02f, -4.19865213e-02f, -5.89740723e-02f,
  -1.41873965e-02f, 4.22082804e-02f, 1.94753241e-02f, -1.15168793e-02f, 1.39255617e-02f, -5.45552075e-02f, 4.22301516e-02f, -5.83600486e-03f, 1.04375660e-01f, -8.71714379e-04f,
  -1.49569707e-02f, 5.03833964e-02f, 1.27202040e-02f, 3.47945094e-02f, 1.84279233e-02f, -4.19201655e-03f, 3.72582451e-02f, 1.34859439e-02f, -4.09210883e-02f, 1.69861615e-02f,
  2.56425925e-02f, -3.92256491e-03f, -1.44008407e-02f, -4.26808111e-02f, 2.99103395e-03f, 6.97319880e-02f, -6.94604889e-02f, 9.00555309e-03f, 4.06498797e-02f, 1.04292817e-02f,
  -3.04458309e-02f, 1.40268371e-01f, 1.01215461e-04f, -3.96938846e-02f, 2.57382896e-02f, 1.75526030e-02f, 3.89377177e-02f, -2.92991498e-03f, 1.56388097e-02f, -3.05693019e-02f,
  -1.00622751e-01f, -2.14223135e-02f, -2.96287192e-03f, -1.23574520e-02f, 7.48002008e-02f, -5.09820282e-02f, 5.05693182e-02f, 2.60959901e-02f, 1.69772487e-02f, -8.35694931e-03f,
  -8.37631989e-03f, -2.87630642e-03f, 2.32252609e-02f, -5.46703823e-02f, 1.08904000e-02f, -5.01777865e-02f, 1.58032533e-02f, 3.35923769e-02f, 3.05020791e-02f, 2.15983782e-02f,
  6.11964226e-01f, 1.93066731e-01f, -2.80870106e-02f, 4.01674807e-01f, 2.49526482e-02f, -3.03927571e-01f, -1.12002835e-01f, 1.68013163e-02f, 5.78302562e-01f, -9.58978161e-02f,
  -1.05490454e-01f, 1.18973531e-01f, 1.33165875e-02f, -1.73052013e-01f, 1.35854959e-01f, 4.51231822e-02f, 2.85483114e-02f, 3.78234289e-03f, 8.98120478e-02f, 5.66791557e-02f,
  9.58168954e-02f, -7.52175525e-02f, -1.53785929e-01f, -1.36967003e-01f, 2.19265465e-02f, 3.14348377e-02f, -5.31655215e-02f, -1.94059819e-01f, -1.15479879e-01f, -6.61980063e-02f,
  -3.69595975e-01f, 7.46342167e-02f, -1.09887635e-02f, 4.89966199e-02f, 2.72937603e-02f, -4.45453189e-02f, -8.88188630e-02f, -1.29980713e-01f, -7.03591900e-03f, 3.78846675e-02f,
  1.96390208e-02f, 2.09038649e-02f, 2.49480084e-02f, 2.28092074e-02f, 3.50062698e-02f, 2.42309961e-02f, 4.31861691e-02f, 3.32088210e-02f, -2.62050647e-02f, -3.86826601e-03f,
  2.24078689e-02f, -4.07789350e-02f, 6.06956109e-02f, -4.18610126e-03f, 1.85363200e-02f, 3.68457027e-02f, -2.75670346e-02f, -3.80960479e-02f, 1.09358421e-02f, 9.77278128e-02f,
  6.43533980e-03f, -2.22845329e-03f, -8.73407931e-04f, -3.23687792e-02f, -1.84306987e-02f, -2.48224214e-02f, -6.71293878e-04f, -4.07922007e-02f, 2.00642031e-02f, -1.42576238e-02f,
  3.92024852e-02f, -1.66286808e-02f, 2.91881301e-02f, -1.04696779e-02f, 4.70574237e-02f, 1.98583538e-03f, -2.10922919e-02f, -2.20083855e-02f, 2.98772324e-02f, 7.01635657e-03f,
  5.01946686e-03f, 8.71007983e-03f, 6.10322272e-03f, -1.27194384e-02f, -1.10842818e-02f, 5.89993922e-03f, 8.93180259e-03f, -5.37648378e-03f, 1.08941214e-03f, -3.08313686e-02f,
  1.50118381e-01f, 3.21577579e-01f, -2.37112194e-02f, -3.60549875e-02f, 2.02621724e-02f, 1.02210781e-02f, 3.46648321e-02f, 4.23550829e-02f, 5.10611990e-03f, -1.11146681e-02f,
  -2.84069348e-02f, -6.41188025e-03f, 4.54606721e-03f, -4.02295925e-02f, 8.39404110e-03f, -2.40948913e-03f, -2.10923124e-02f, 1.49157597e-02f, 2.19305623e-02f, 9.18498542e-03f,
  -2.56255805e-03f, 4.65025790e-02f, -4.64351336e-03f, 1.25529608e-02f, 5.57598425e-03f, 4.11914382e-03f, 4.40260991e-02f, 3.47043462e-02f, -4.59270068e-02f, 2.45070271e-03f,
  -7.07804561e-01f, 1.05027027e-01f, 9.85184088e-02f, -1.90481022e-01f, -2.01899916e-01f, -4.94267046e-01f, -3.99818301e-01f, 4.20622528e-02f, -1.27276838e-01f, 4.57946258e-03f,
  -9.18139070e-02f, -8.27490687e-02f, 7.03449324e-02f, -3.41013640e-01f, -2.78337479e-01f, -3.44307860e-03f, -2.56285548e-01f, -1.00606330e-01f, -7.83239231e-02f, -8.52543022e-03f,
  -8.43766779e-02f, -2.84020960e-01f, -2.76754200e-02f, 7.39585012e-02f, -1.61527336e-01f, 1.04204945e-01f, 7.24785179e-02f, 1.30750835e-01f, 1.62633788e-02f, -3.99840996e-02f,
  -5.18735349e-02f, 4.49001007e-02f, 8.42882320e-02f, -1.23418793e-02f, -3.01522184e-02f, 1.87198035e-02f, 3.42631936e-02f, -7.30665028e-03f, 2.94723106e-03f, 1.56358536e-02f,
  8.93826317e-03f, -1.83371846e-02f, -5.27374521e-02f, -2.06173696e-02f, -7.47769773e-02f, 3.08882669e-02f, 3.48973759e-02f, -1.12476537e-03f, 1.46895023e-02f, -1.83300339e-02f,
  3.96842733e-02f, -1.01686753e-02f, -2.12687925e-02f, -3.62682268e-02f, 2.32139230e-02f, -1.54575780e-02f, -3.30874436e-02f, 2.55555082e-02f, 3.37610878e-02f, -4.27207947e-02f,
  -2.35184692e-02f, -4.55516055e-02f, -1.70923863e-02f, -6.44958811e-03f, -3.42473276e-02f, 2.39893980e-02f, -3.61039266e-02f, -1.28499568e-02f, -3.18751729e-04f, -4.69045117e-02f,
  -1.97946206e-02f, -2.64147632e-02f, -3.43507230e-02f, -3.83398030e-03f, -3.71136479e-02f, -2.12528966e-02f, -4.13587987e-02f, -3.75337689e-03f, -4.04876657e-02f, -9.73571930e-03f,
  3.38182002e-02f, -3.31259370e-02f, 6.16923440e-03f, 1.34010762e-02f, -1.13374908e-02f, 8.33562948e-03f, -3.21860164e-02f, 1.87913887e-02f, 2.98763625e-03f, -1.02554467e-02f,
  3.06408517e-02f, 7.42321461e-02f, 2.83418857e-02f, -8.23649298e-03f, 3.86860967e-02f, -9.19154845e-03f, -2.57288702e-02f, 5.31778391e-03f, 2.55875904e-02f, -4.36896868e-02f,
  1.68033526e-03f, 5.15853148e-03f, 7.38276960e-03f, -3.26826125e-02f, 1.93780269e-02f, -1.28781423e-02f, -3.08985612e-03f, 2.55520139e-02f, -1.68048404e-03f, 7.44888652e-03f,
  2.07773335e-02f, -2.33117193e-02f, -1.18170278e-02f, 5.06779104e-02f, -3.05433180e-02f, -7.69815734e-03f, 6.03822118e-04f, 1.95188969e-02f, 2.02673953e-02f, 9.07198433e-03f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.74685311e-01f, 3.95699620e-01f, -2.50490308e-01f, -3.76107037e-01f, -5.34794033e-01f, -1.62325218e-01f, -3.39318186e-01f, -9.70501453e-02f, -5.70042059e-02f, 3.15375686e-01f,
  -1.73963264e-01f, -1.44581750e-01f, 4.22950685e-01f, 7.29788393e-02f, -1.22876786e-01f, 7.81171739e-01f, -4.05975357e-02f, -3.36503088e-02f, 1.94357410e-01f, -4.40578014e-01f,
  -1.39105961e-01f, -2.00864673e-01f, 1.53180405e-01f, -5.66491019e-03f, -6.11069560e-01f, -2.16956511e-01f, -1.92190006e-01f, -8.79921019e-02f, -3.43142182e-01f, -3.76480371e-02f,
  -2.72466272e-01f, -3.13772410e-01f, -3.00080389e-01f, 3.14487051e-03f, -2.03773290e-01f, -1.81667805e-01f, -7.44104460e-02f, -3.47554795e-02f, -7.35570341e-02f, -6.02039248e-02f,
  -1.00514226e-01f, 9.52258985e-03f, 2.68592569e-03f, 1.11316107e-01f, -1.23993509e-01f, -5.15034907e-02f, 6.01040199e-02f, -3.38422805e-02f, -5.23822233e-02f, -1.73208099e-02f,
  4.73155193e-02f, 3.89824025e-02f, -7.46356994e-02f, 1.65932290e-02f, -5.24159074e-02f, -3.21630239e-02f, 3.04154046e-02f, -1.18039668e-01f, -1.38476506e-01f, -5.32428129e-03f,
  -8.60300586e-02f, -9.67617426e-03f, -1.51635520e-02f, 1.09643424e-02f, -3.68990637e-02f, -2.38105934e-03f, -4.51640488e-04f, 9.41654295e-03f, 1.52936652e-02f, -3.41901369e-02f,
  -9.58398953e-02f, -3.74773778e-02f, -1.09024448e-02f, 9.75995604e-03f, 4.91619343e-03f, 3.19364434e-03f, -2.70193405e-02f, -1.06623225e-01f, 9.96849388e-02f, 7.52441138e-02f,
  -1.26488339e-02f, -1.46322772e-02f, 2.10916158e-02f, 1.89888235e-02f, -7.41925032e-04f, 4.00252640e-02f, 2.14132965e-02f, 8.88027810e-03f, -5.85764006e-04f, -1.25873789e-01f,
  -3.19223195e-01f, -4.28310573e-01f, -8.08372200e-02f, -1.70094088e-01f, -2.69553997e-02f, -3.52427289e-02f, 5.44730723e-02f, -7.03826323e-02f, -1.38882101e-01f, -7.55091980e-02f,
  -1.12164378e-01f, -2.84662787e-02f, -1.74901024e-01f, -2.10623369e-02f, 2.60811821e-02f, 1.24198366e-02f, 3.48220929e-03f, -5.71186580e-02f, -1.40337884e-01f, 1.54021699e-02f,
  -1.20515108e-01f, -5.98217472e-02f, 6.59325644e-02f, 1.49446633e-02f, -5.27084731e-02f, -5.24103940e-02f, -1.25222236e-01f, -1.52615206e-02f, -3.47548090e-02f, 5.75123206e-02f,
  6.98472932e-02f, -1.64613858e-01f, 2.86552489e-01f, 7.42715597e-01f, 2.20969710e-02f, -4.83493149e-01f, -1.51723385e-01f, 3.35090041e-01f, 1.79911837e-01f, -3.82029355e-01f,
  7.45835081e-02f, -3.16573918e-01f, -3.36332649e-01f, 1.68472007e-01f, 1.76144004e-01f, -2.60728091e-01f, 2.44031549e-01f, -1.17450088e-01f, 1.32615000e-01f, 4.46728706e-01f,
  5.33636510e-01f, 2.41776451e-01f, 3.39529216e-01f, 2.20615342e-01f, 2.37659663e-01f, 5.37302673e-01f, 4.79689837e-01f, 5.24864793e-02f, 3.25576782e-01f, -1.56267554e-01f,
  -1.37150243e-01f, 6.74117133e-02f, 6.06370270e-02f, -1.10220909e-01f, 8.03281516e-02f, -3.67065445e-02f, -1.06335558e-01f, -5.78666404e-02f, 9.87685770e-02f, 2.94095208e-03f,
  -9.09505114e-02f, -2.45073643e-02f, 2.71307714e-02f, -5.28847659e-03f, 6.15994222e-02f, 1.20646462e-01f, 1.38694160e-02f, -4.94675571e-03f, 1.73829533e-02f, 3.13902413e-03f,
  5.97078167e-02f, -5.20564169e-02f, 1.36119381e-01f, -7.48812184e-02f, 6.51989952e-02f, 6.45791814e-02f, -4.11929563e-02f, -3.47959846e-02f, 3.57919745e-03f, 1.33740809e-03f,
  -3.86729501e-02f, 3.53676379e-02f, -5.50235547e-02f, 7.79342726e-02f, 1.98738407e-02f, 6.36133328e-02f, 8.90637096e-03f, -1.28175393e-02f, 6.16084263e-02f, 1.83260646e-02f,
  1.48594991e-04f, 9.01374072e-02f, 4.84840907e-02f, -1.00519406e-02f, -1.65169388e-02f, -4.98259179e-02f, 3.96869320e-04f, -9.77652892e-03f, 1.19614810e-01f, -1.45692602e-02f,
  1.75049261e-03f, 4.49010730e-02f, 1.96040552e-02f, -1.19502461e-02f, -6.63046241e-02f, 2.83334777e-02f, 7.54471570e-02f, 5.68570336e-03f, 4.82025631e-02f, 7.02299103e-02f,
  -5.38225025e-02f, 3.03015292e-01f, 8.51919428e-02f, -6.37383536e-02f, -7.66997337e-02f, -5.01391701e-02f, -4.43732776e-02f, -1.82781890e-02f, -2.25434098e-02f, 3.43460627e-02f,
  7.46788830e-02f, 6.03453219e-02f, -6.74005598e-02f, 7.50964507e-02f, 3.59984152e-02f, -4.00560237e-02f, 1.28988832e-01f, 7.67263100e-02f, 1.40369251e-01f, 1.05745390e-01f,
  4.41593304e-02f, -4.11233082e-02f, -1.71876065e-02f, 1.31256534e-02f, -3.30064595e-02f, -7.50376135e-02f, -2.25291569e-02f, 2.92189568e-02f, -4.63224798e-02f, -2.45557632e-02f,
  1.60814017e-01f, 6.91618800e-01f, 1.86054304e-01f, -8.53775740e-02f, -1.58491969e-01f, -7.31032312e-01f, -4.68639821e-01f, 3.09238071e-03f, 2.69613892e-01f, 9.99585688e-02f,
  -2.20594883e-01f, 4.35618311e-01f, 1.74035490e-01f, -3.43855590e-01f, -9.24329937e-01f, -2.39229783e-01f, -7.28969276e-01f, -3.23016435e-01f, 9.20396019e-03f, -1.55565113e-01f,
  -3.18975598e-01f, -4.20507282e-01f, -2.79238433e-01f, 6.78437352e-02f, 6.14917539e-02f, 2.66611397e-01f, -2.30894789e-01f, 1.54274076e-01f, -1.32741854e-02f, -6.35625347e-02f,
  -7.13740364e-02f, 3.11993659e-01f, 1.22084267e-01f, -2.51935353e-03f, -3.01402330e-01f, -1.21231042e-01f, -2.99659539e-02f, -4.39334847e-02f, -3.29156383e-03f, -2.19100621e-02f,
  1.22232348e-01f, 4.18574661e-02f, 2.81082522e-02f, 9.62055922e-02f, 5.47181815e-02f, 1.68493837e-01f, 1.27452791e-01f, 8.18075389e-02f, 1.06559932e-01f, 8.25071931e-02f,
  1.37265652e-01f, -6.77803822e-04f, -6.90950779e-03f, -5.07009551e-02f, 1.00594470e-02f, 3.96498106e-02f, -1.07851662e-01f, 1.13965496e-02f, -4.40703519e-02f, -4.89636101e-02f,
  1.08091319e-02f, -3.92027348e-02f, -4.13629338e-02f, 1.27255812e-01f, -2.47811042e-02f, 5.30571258e-03f, 2.87909480e-03f, -4.89909500e-02f, 2.56694015e-02f, -4.41771336e-02f,
  -3.62235866e-02f, 7.95347802e-03f, 1.05017290e-01f, -1.14687346e-01f, -5.14226779e-02f, 2.32689362e-02f, 5.07101864e-02f, 5.68217374e-02f, -1.25024645e-02f, -7.53117278e-02f,
  5.90478368e-02f, -1.27155378e-01f, 1.39575571e-01f, 1.08483701e-03f, -6.51306435e-02f, 2.44268440e-02f, 3.90874259e-02f, 1.16339572e-01f, -3.74105312e-02f, -1.23898655e-01f,
  -3.54900777e-01f, -3.88837963e-01f, 1.06874127e-02f, 1.19387917e-02f, 2.01930441e-02f, -1.03176966e-01f, -9.85605270e-02f, -1.16938008e-02f, -1.59388065e-01f, -5.41689619e-02f,
  -1.04683176e-01f, -4.69735032e-03f, -1.15109012e-01f, 4.69954833e-02f, -4.18848023e-02f, -1.52241588e-01f, -1.09867670e-01f, -7.82345459e-02f, -2.03777567e-01f, -7.08174035e-02f,
  1.23207361e-01f, -2.39541344e-02f, -5.26757091e-02f, -7.56673366e-02f, -9.05288309e-02f, -1.07465595e-01f, -1.47499982e-02f, 3.23238224e-02f, -1.25733931e-02f, -3.42260189e-02f,
  3.00597042e-01f, -2.86768705e-01f, 7.06114233e-01f, 2.47124434e-01f, 3.77449453e-01f, 4.59989250e-01f, 7.56758273e-01f, -1.89628582e-02f, 1.40847206e-01f, -5.38639307e-01f,
  -2.11164325e-01f, 9.81684625e-02f, 3.52369845e-01f, -1.38697281e-01f, 1.84715539e-01f, 1.69745520e-01f, -9.52125862e-02f, -3.40506472e-02f, 1.31901175e-01f, -3.99856269e-02f,
  5.45882843e-02f, -1.49837956e-01f, 3.68678719e-01f, -4.76971984e-01f, 1.29542515e-01f, -1.74247220e-01f, -3.92155141e-01f, 2.56283432e-01f, -5.24157524e-01f, -5.50532490e-02f,
  3.65025029e-02f, -4.46219631e-02f, -3.67687386e-03f, -1.14922486e-01f, 2.64046527e-02f, -7.08077624e-02f, 7.28725344e-02f, 8.29890445e-02f, 6.20869845e-02f, -2.35943813e-02f,
  6.21763617e-02f, 2.28323732e-02f, -1.35021791e-01f, 9.62006822e-02f, -2.88676582e-02f, -5.04118949e-02f, 7.30571970e-02f, 5.98019660e-02f, 1.14875354e-01f, 1.20389238e-01f,
  1.51259556e-01f, -1.30284000e-02f, 5.63815646e-02f, -1.69487178e-01f, 4.53029983e-02f, 1.24318283e-02f, 8.03110152e-02f, 7.57768750e-02f, -4.53474559e-02f, -6.06384911e-02f,
  -1.04443967e-01f, -7.76697248e-02f, 1.00123696e-02f, -6.81138486e-02f, 1.90625507e-02f, -7.06978748e-03f, -4.45237570e-02f, -3.35823670e-02f, 3.73019315e-02f, 3.54011245e-02f,
  -1.68306772e-02f, -5.83427176e-02f, -1.90054737e-02f, 4.14227769e-02f, -4.55473773e-02f, 3.51024512e-03f, 1.49128279e-02f, -3.43421772e-02f, 3.63951363e-03f, -5.33712991e-02f,
  5.63369179e-03f, 1.61017524e-03f, -5.05120195e-02f, -1.40153188e-02f, -5.30253574e-02f, 8.33353698e-02f, 3.11678462e-02f, 9.52431634e-02f, 1.17232744e-02f, 2.51958184e-02f,
  -3.16269785e-01f, -5.17795265e-01f, -1.06280759e-01f, -6.71367198e-02f, -1.49017349e-01f, -1.33217782e-01f, -1.03195846e-01f, -6.27170801e-02f, -1.00431889e-01f, -3.03773093e-03f,
  -6.82619736e-02f, 1.28280073e-02f, -5.84886223e-02f, -5.07808588e-02f, -2.57691033e-02f, -5.28557636e-02f, 2.28844397e-02f, -1.41457632e-01f, -1.18227683e-01f, -3.12984213e-02f,
  4.24541591e-04f, -1.67760458e-02f, 1.02304081e-02f, -2.76656169e-02f, -1.81904003e-01f, -5.68761155e-02f, -1.31483108e-01f, -6.11651056e-02f, -4.88838181e-02f, -3.70910484e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  5.56220293e-01f, 4.10875171e-01f, 4.54113215e-01f, 7.15104163e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -7.37747788e-01f, 1.17664665e-01f, -7.15843618e-01f, -1.67933125e-02f, -1.62110001e-01f, 4.26256388e-01f, 6.33096278e-01f, 4.20542181e-01f, -8.05032074e-01f, 1.32130563e-01f,
  -9.16287601e-01f, -1.14624798e-01f, 1.17319047e+00f, -4.01638210e-01f, -6.57947540e-01f, -1.59773007e-01f, 2.91667908e-01f, 9.17072594e-01f, -5.35203934e-01f, -5.20919524e-02f,
  8.77595007e-01f, -9.11231339e-01f, 6.10541165e-01f, 5.04657567e-01f, -1.26209819e+00f, -1.30371177e+00f, -8.88039470e-02f, -1.27679503e+00f, -4.06844795e-01f, -1.64174139e-01f,
  -3.83125037e-01f, -4.68423635e-01f, 1.67300820e-01f, -8.54467928e-01f, 2.70654559e-01f, -5.35782948e-02f, 2.52790809e-01f, -2.14467838e-01f, -8.52373481e-01f, -9.84884262e-01f,
  5.29474318e-01f, -6.96013987e-01f, -7.77542174e-01f, -1.07304370e+00f, -3.06807965e-01f, 7.43622720e-01f, -4.57221419e-01f, -4.47685093e-01f, -3.48836452e-01f, -2.99273692e-02f,
  -2.62274176e-01f, 1.61212057e-01f, 1.10494688e-01f, -2.74715245e-01f, 5.41748464e-01f, 3.62762548e-02f, 7.26191998e-01f, -8.76074910e-01f, -6.79326355e-01f, 2.20870331e-01f,
  3.69361788e-01f, -5.74956954e-01f, 1.20779324e+00f, -4.34690446e-01f, 6.74017906e-01f, -2.25016847e-01f, 3.93696487e-01f, 5.13189137e-01f, -1.26289934e-01f, 7.57058144e-01f,
  -6.24768734e-01f, 8.57525706e-01f, 1.00330305e+00f, -1.12042286e-01f, -1.09525716e+00f, 9.65526402e-01f, 7.23407805e-01f, -2.26021215e-01f, -5.57648428e-02f, 5.82807541e-01f,
  9.02742207e-01f, -7.20905483e-01f, 5.73180676e-01f, 4.40911561e-01f, -3.14739794e-02f, 5.13710439e-01f, 5.86169958e-01f, 7.06728578e-01f, -7.15761900e-01f, 1.00258696e+00f,
  1.53952134e+00f, -7.17370093e-01f, 4.48536009e-01f, -2.02747673e-01f, -6.55123770e-01f, 3.39900553e-01f, -7.88290322e-01f, 4.28547651e-01f, -8.79079476e-02f, 4.20431525e-01f,
  -1.51511699e-01f, -8.57222155e-02f, -7.48200595e-01f, 7.82232806e-02f, 4.07961726e-01f, -4.92688835e-01f, 1.27097297e+00f, -4.07965004e-01f, -5.39416075e-01f, 3.90775889e-01f,
  -4.44963872e-01f, 1.07607758e+00f, 2.76075959e-01f, -6.07089996e-01f, -6.07333183e-01f, -4.23826694e-01f, -8.75238836e-01f, -3.56689036e-01f, 3.52729291e-01f, -2.89200083e-03f,
  7.00232923e-01f, 9.81084108e-01f, 1.01969731e+00f, 1.76925674e-01f, 8.94349098e-01f, -4.18029636e-01f, 6.30628824e-01f, -2.98857003e-01f, 3.10388446e-01f, -4.08877373e-01f,
  -3.58129919e-01f, -1.81882083e-01f, -1.83783352e-01f, 4.07699913e-01f, 3.03029597e-01f, -6.23822093e-01f, 3.23712379e-02f, 7.54228830e-01f, 6.49469852e-01f, 7.21073329e-01f,
  -1.04380012e-01f, 1.19999206e+00f, -2.04339594e-01f, -3.20548236e-01f, 1.31572574e-01f, 1.48323447e-01f, 1.40349492e-01f, -6.06575429e-01f, 5.58923185e-01f, 2.61321336e-01f,
  -4.03998256e-01f, -2.52875209e-01f, 1.56554446e-01f, 1.00292635e+00f, -8.45872104e-01f, -5.72242618e-01f, -3.65757763e-01f, -7.08975017e-01f, -5.31726062e-01f, 1.25799727e+00f,
  -3.23352776e-02f, 7.38872766e-01f, 9.96537507e-01f, -5.87547839e-01f, 1.03207901e-01f, 1.04128599e-01f, 1.18608797e+00f, -6.14620090e-01f, -2.59444922e-01f, -1.06731343e+00f,
  -7.74285376e-01f, 1.46200907e+00f, -5.85254848e-01f, 7.48195648e-02f, 3.15940470e-01f, -5.95746279e-01f, -3.85968447e-01f, 3.26947570e-01f, -2.12748125e-01f, 1.55595526e-01f,
  2.62842000e-01f, 9.67211202e-02f, -1.01174510e+00f, -1.60250947e-01f, -4.67859715e-01f, 7.04854488e-01f, 1.96445420e-01f, 7.24912286e-01f, -7.59968281e-01f, -2.56135911e-01f,
  1.24387395e+00f, 2.33381823e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -5.75583018e-02f, 5.67509651e-01f, 1.72531977e-01f, -4.68134999e-01f, -1.34108707e-01f, 4.17716771e-01f, -3.10081095e-01f, -1.08941123e-01f, -3.99410218e-01f, -1.37493923e-01f,
  3.52745712e-01f, 3.87411490e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    