/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.50081336e-01f, 2.28527859e-01f, -4.22243595e-01f, -9.87896249e-02f, -1.33782387e-01f, 3.71897280e-01f, 2.50034302e-01f, 1.11916706e-01f, -1.15684226e-01f, 4.98365223e-01f,
  2.81264275e-01f, -1.13480121e-01f, 2.98355758e-01f, 4.10300463e-01f, -1.68159693e-01f, 3.48075181e-01f, 1.15659744e-01f, 7.20600411e-02f, 2.25353474e-03f, 1.57486334e-01f,
  -9.30621028e-02f, 4.34434593e-01f, -2.09410787e-02f, 2.37589777e-01f, -2.03646757e-02f, -1.73376665e-01f, 6.42058775e-02f, -1.51501773e-02f, 8.16273764e-02f, 3.46921496e-02f,
  2.09941193e-02f, -4.03106539e-03f, -1.44131079e-01f, -6.64085075e-02f, -6.09206259e-02f, -3.65559310e-02f, -6.06064796e-02f, -3.44943777e-02f, -3.22963558e-02f, -2.33563296e-02f,
  -8.32997859e-02f, 3.80051360e-02f, 9.01928917e-02f, -1.58625524e-02f, -1.27770072e-02f, -1.29676357e-01f, -3.10662109e-02f, -2.71268301e-02f, 9.49494764e-02f, -4.74461280e-02f,
  -6.18930236e-02f, -3.83074246e-02f, -1.03230059e-01f, 6.17183261e-02f, -9.05566439e-02f, -4.89355549e-02f, 4.35806066e-02f, -8.78430605e-02f, 4.25923616e-02f, -1.59300566e-02f,
  1.70949083e-02f, 2.99038030e-02f, 2.38803010e-02f, -1.05353473e-02f, 7.20232213e-03f, -2.88029034e-02f, 7.48554617e-02f, 2.18258686e-02f, -9.21046585e-02f, 4.95129302e-02f,
  -4.33052778e-02f, -9.13619697e-02f, 8.31893608e-02f, -3.55636291e-02f, 3.23956534e-02f, -1.41913090e-02f, -4.88260575e-02f, 8.50897357e-02f, -1.47497486e-02f, -2.94144824e-02f,
  -6.87564583e-03f, 2.40094436e-04f, 7.34475255e-02f, 1.27163110e-02f, 8.26588571e-02f, -9.57395136e-02f, 5.07356636e-02f, -4.10732515e-02f, 2.67690234e-02f, -1.71994716e-02f,
  2.61840284e-01f, 3.29538792e-01f, 1.12113565e-01f, 4.00531963e-02f, -4.56745457e-03f, -4.25163284e-02f, -4.96552838e-03f, -1.90692712e-02f, 2.61489339e-02f, 1.77235827e-02f,
  -5.00731282e-02f, -1.39052998e-02f, -1.05983624e-02f, -1.77052245e-02f, 8.52359552e-03f, 6.79000318e-02f, 5.91589957e-02f, -3.76343690e-02f, 4.06874791e-02f, 5.33322841e-02f,
  -2.72176949e-05f, 5.10770418e-02f, -2.21677311e-02f, 4.51298617e-02f, 4.40145917e-02f, 3.26171555e-02f, -5.45354001e-02f, -3.13965976e-02f, -8.96949619e-02f, 4.59685028e-02f,
  -4.53800142e-01f, 3.02607298e-01f, 6.16974980e-02f, -1.87524594e-02f, -1.60026878e-01f, 3.91088635e-01f, 1.08198136e-01f, 1.14449196e-01f, 1.64459005e-01f, 2.45820045e-01f,
  1.80256456e-01f, -1.00457102e-01f, 3.53507966e-01f, 2.85644054e-01f, -1.44710273e-01f, 5.20249307e-01f, 1.21520407e-01f, 3.98668535e-02f, 1.76382631e-01f, -2.86224727e-02f,
  -3.17046903e-02f, -6.35955483e-02f, -3.14152054e-02f, 9.15968791e-02f, -1.48889050e-02f, 3.38106491e-02f, -2.02179432e-01f, -1.55891672e-01f, -1.26585150e-02f, -1.36696249e-01f,
  -1.03443963e-02f, -1.81673676e-01f, 4.32284847e-02f, 2.69044340e-02f, -4.28157905e-03f, -9.90579352e-02f, -5.77636547e-02f, -6.24123551e-02f, -3.45547684e-02f, 2.07930114e-02f,
  4.70288135e-02f, -7.49579296e-02f, -1.70121286e-02f, 2.88112145e-02f, 2.95731332e-02f, 3.20341066e-02f, 8.77920762e-02f, 1.02068201e-01f, 6.51508272e-02f, 2.54093204e-02f,
  1.21668540e-01f, 5.41012250e-02f, 1.20790467e-01f, -4.88574337e-03f, -2.67772023e-02f, 7.27227256e-02f, -3.25036645e-02f, -5.65583296e-02f, -1.29509373e-02f, 3.22086401e-02f,
  -2.59841164e-03f, -7.04975473e-03f, 4.96020578e-02f, -3.30594666e-02f, 7.48677626e-02f, -1.46176666e-01f, 6.77355900e-02f, -6.27584383e-02f, -4.38347757e-02f, 7.77022913e-03f,
  -2.62016822e-02f, -1.67381652e-02f, -7.28969276e-02f, 5.10081835e-02f, -6.57787099e-02f, 8.83898046e-03f, -6.46878183e-02f, 2.06244458e-02f, -1.36668235e-02f, -3.61092435e-03f,
  -5.81722558e-02f, 9.26504135e-02f, 4.36962862e-03f, -2.44461205e-02f, 9.51254070e-02f, 7.90440850e-03f, 3.62346061e-02f, 8.40516984e-02f, 2.05538310e-02f, -1.35787725e-01f,
  1.73578784e-02f, -1.71700329e-01f, 9.71716791e-02f, -4.66781892e-02f, -5.05977981e-02f, 6.03903905e-02f, 5.41982204e-02f, -4.36683409e-02f, 9.43814069e-02f, -6.18441142e-02f,
  -2.34213322e-02f, -4.61474247e-03f, -1.37770444e-01f, 9.25947633e-03f, -5.27907610e-02f, 1.02548063e-01f, -2.79994719e-02f, -1.05302416e-01f, -1.45423606e-01f, -4.97105997e-04f,
  -9.31032449e-02f, -1.01495683e-01f, -1.23232149e-01f, -1.35875689e-02f, -1.09723456e-01f, -4.69988771e-02f, -9.68092605e-02f, 2.34273449e-02f, -7.46106878e-02f, -5.03549390e-02f,
  -4.78514314e-01f, 3.46248507e-01f, 4.70348626e-01f, -9.52266976e-02f, -4.56076056e-01f, 2.47269720e-01f, 2.85073787e-01f, -2.94565707e-01f, 1.58348396e-01f, 1.70177251e-01f,
  7.50270579e-03f, -1.38178170e-02f, 3.47715259e-01f, 2.04938933e-01f, -2.67064925e-02f, 5.71157873e-01f, 1.00751305e-02f, 2.82029565e-02f, 1.47683918e-01f, -2.47092992e-01f,
  -1.28652779e-02f, -1.51385263e-01f, 7.19207376e-02f, -1.27935395e-01f, -1.23316295e-01f, -1.69927344e-01f, -2.74858296e-01f, 9.42251682e-02f, -1.97372198e-01f, 4.53350544e-02f,
  1.94158573e-02f, 1.19577246e-02f, 4.35605943e-02f, 1.29591584e-01f, -1.73419774e-01f, 3.54635231e-02f, -1.58290863e-02f, 4.63397838e-02f, 5.93397766e-03f, 4.97531742e-02f,
  1.53412998e-01f, -1.28819272e-01f, -1.80393122e-02f, 9.67852622e-02f, -4.10888679e-02f, 8.68094563e-02f, 5.35526685e-02f, 1.21736318e-01f, 3.62873892e-03f, 8.97884443e-02f,
  1.18174389e-01f, 2.43947897e-02f, 2.05860212e-02f, 5.36297671e-02f, 2.96111195e-03f, 3.24106403e-02f, 8.94943178e-02f, -7.54076988e-02f, 1.04776062e-01f, -1.19996652e-01f,
  3.85227725e-02f, -1.82857625e-02f, 9.75976884e-02f, 6.44581318e-02f, 9.18517858e-02f, -2.02556252e-02f, 9.93718654e-02f, -1.90389026e-02f, 6.17643679e-03f, 8.50399490e-03f,
  -1.78836450e-01f, -1.62847880e-02f, -2.12890506e-02f, 7.96731934e-03f, -5.56785576e-02f, 8.25126544e-02f, 3.19227315e-02f, -8.48287940e-02f, -1.27369255e-01f, -1.67552270e-02f,
  3.63472551e-02f, -5.78188710e-03f, -8.71131122e-02f, 8.19087587e-03f, 7.58108199e-02f, -7.37378821e-02f, -5.19071966e-02f, 3.65794003e-02f, 5.39459800e-03f, 8.24124180e-03f,
  -1.21909834e-01f, -8.76917243e-02f, -6.16959631e-02f, -6.70655742e-02f, 1.18951827e-01f, 1.00367712e-02f, 1.77252501e-01f, -3.15342546e-02f, 4.09638844e-02f, 2.14283206e-02f,
  -3.43608633e-02f, -4.36492264e-02f, -7.08124042e-02f, -8.53430182e-02f, 6.16034791e-02f, -1.73746329e-02f, -1.77882686e-02f, -5.43074198e-02f, -5.34981303e-02f, -7.00668022e-02f,
  -8.66040513e-02f, -1.17990352e-01f, 8.54275599e-02f, -1.44707739e-01f, -4.93865758e-02f, -7.73039088e-03f, -1.45476416e-01f, 2.42428444e-02f, 4.61552292e-02f, 9.67893749e-02f,
  -6.37871206e-01f, -1.49445742e-01f, -1.23020120e-01f, -4.42585975e-01f, 1.90200806e-01f, -2.13639677e-01f, -4.74482536e-01f, 3.07687987e-02f, -1.82881922e-01f, 1.99153312e-02f,
  -2.14000225e-01f, -1.84296221e-01f, -6.47972375e-02f, -3.57410192e-01f, -1.49418950e-01f, -1.52269855e-01f, -3.09115618e-01f, -2.91920662e-01f, 1.09765902e-01f, -1.49237186e-01f,
  -9.20174122e-02f, 7.34545849e-03f, -2.12764576e-01f, 4.02225018e-01f, -1.70955136e-01f, 1.69239372e-01f, 2.11139113e-01f, 1.63902283e-01f, -5.99778146e-02f, 1.38410151e-01f,
  -8.29911008e-02f, -1.77904263e-01f, 5.94527908e-02f, 3.83605771e-02f, -1.51384935e-01f, 2.15646648e-03f, -8.50786418e-02f, 9.82009992e-02f, 3.05848029e-02f, 5.75465150e-02f,
  -4.80718836e-02f, 3.25099938e-02f, 1.05250865e-01f, 9.13739726e-02f, -2.29100473e-02f, 5.24433404e-02f, 3.14628705e-02f, -8.50278232e-03f, 2.65026800e-02f, -1.02302469e-01f,
  -3.12120691e-02f, -6.90874681e-02f, -7.47251660e-02f, 3.15198326e-03f, 1.32926237e-02f, -6.20385520e-02f, 7.10615441e-02f, 2.70396229e-02f, 1.28018325e-02f, -2.92532854e-02f,
  -1.27864750e-02f, 8.12959298e-02f, 9.60359629e-03f, 4.67820689e-02f, -4.94882911e-02f, 8.56088400e-02f, -6.72715828e-02f, 5.72001152e-02f, 5.81731014e-02f, -1.38398230e-01f,
  2.52661053e-02f, -1.01201005e-01f, -6.17082813e-04f, -9.16333869e-02f, -3.24363299e-02f, -2.25815326e-02f, 5.73290000e-03f, 9.75666509e-04f, 3.33005078e-02f, 3.94066572e-02f,
  -1.31708849e-02f, -4.43775430e-02f, -4.05007340e-02f, 5.53839840e-03f, 3.27022921e-04f, -7.81118078e-03f, -6.30149571e-03f, -8.07506442e-02f, 4.84422408e-02f, -3.46510597e-02f,
  -2.76343405e-01f, -3.60408753e-01f, 3.45647661e-03f, 4.85188812e-02f, 9.25316960e-02f, 3.54189686e-02f, 5.28902449e-02f, 8.76351893e-02f, 1.36680966e-02f, -5.59448600e-02f,
  1.04094602e-01f, 5.48666045e-02f, -5.26987426e-02f, -1.91246551e-02f, -2.27109678e-02f, -4.01495248e-02f, -1.43492565e-01f, 5.97288720e-02f, -1.23854205e-02f, 8.71193931e-02f,
  -6.62465021e-02f, -4.15572226e-02f, 1.44729272e-01f, 5.92455044e-02f, 3.47681902e-02f, 2.71447022e-02f, -1.06759652e-01f, 6.10800460e-03f, 9.54855978e-03f, 3.95625979e-02f,
  -2.58271247e-01f, 3.90731871e-01f, 2.33629927e-01f, 5.53545095e-02f, -4.04886931e-01f, -3.48215669e-01f, -4.08459514e-01f, 2.31545568e-02f, 1.58198908e-01f, 1.40839696e-01f,
  -4.75441426e-01f, 4.97190654e-01f, -2.10496977e-01f, 2.81859130e-01f, -3.27116668e-01f, 2.10740060e-01f, 1.06190622e-01f, 1.42634019e-01f, 1.94201306e-01f, 1.74542218e-01f,
  4.42718863e-02f, -1.34075716e-01f, 8.46879631e-02f, 1.78966239e-01f, -2.51419783e-01f, 1.79284215e-01f, -1.52309969e-01f, 8.07745457e-02f, 1.32290283e-02f, -2.73595415e-02f,
  -1.08008392e-01f, 1.53436556e-01f, -3.22854891e-02f, 1.55746222e-01f, -1.37086183e-01f, -9.50725898e-02f, -1.31256580e-02f, -9.03373510e-02f, 7.70116150e-02f, -7.27727264e-03f,
  -4.10470292e-02f, -4.63730609e-03f, -5.85318618e-02f, 7.93816075e-02f, 3.11715691e-03f, 4.23979573e-02f, 1.62992477e-02f, -1.45207733e-01f, 6.88703358e-02f, -3.91957425e-02f,
  1.86161026e-02f, -2.70931851e-02f, -1.24522947e-01f, 5.69652878e-02f, -1.94852632e-02f, 5.40730841e-02f, 8.35600644e-02f, -7.93074965e-02f, -8.80872011e-02f, 1.22114541e-02f,
  -9.17797536e-03f, 6.38580276e-03f, 2.37515140e-02f, -1.78018026e-02f, -5.20356698e-04f, -3.77476141e-02f, 5.52955829e-02f, -4.52406593e-02f, 8.52389857e-02f, -6.45330250e-02f,
  -4.78337007e-03f, -6.13595098e-02f, 1.50643690e-02f, -6.71605766e-02f, 6.95401523e-03f, 2.84397136e-02f, -1.37018869e-02f, 1.49402861e-02f, -8.92720595e-02f, -1.02120720e-01f,
  -1.41284615e-02f, 6.91953599e-02f, -3.88586707e-02f, 1.02526518e-02f, -4.39915471e-02f, -1.85124073e-02f, 8.67209435e-02f, 1.74874496e-02f, 3.19186375e-02f, -1.54514551e-01f,
  2.26454809e-01f, 2.92564273e-01f, 2.50005685e-02f, 1.06865121e-02f, 8.02751631e-02f, -1.17886648e-01f, -6.04720553e-03f, 2.92826276e-02f, 7.99155608e-02f, -4.04530503e-02f,
  2.31248774e-02f, 2.30099279e-02f, -6.88024536e-02f, -4.34549898e-03f, 3.41026634e-02f, -1.25631869e-01f, 1.53232431e-02f, 7.16996118e-02f, -4.05704342e-02f, -4.54246514e-02f,
  -8.65708739e-02f, -1.87303163e-02f, 3.71657126e-02f, -9.59354863e-02f, -6.30798563e-02f, -9.39351171e-02f, 5.96444719e-02f, 5.20735942e-02f, -3.68523486e-02f, 4.36005965e-02f,
  -6.40056431e-01f, 1.32687554e-01f, -2.63038184e-02f, 1.21699981e-01f, -3.87796700e-01f, -5.23109198e-01f, -1.15806058e-01f, -2.40940094e-01f, 6.62000477e-02f, 3.93299669e-01f,
  -9.89541560e-02f, -1.38159409e-01f, 1.47969991e-01f, -1.81372792e-01f, -5.84636152e-01f, 2.28465602e-01f, 1.45468861e-02f, 5.09721488e-02f, 6.74367649e-04f, -5.02484068e-02f,
  -5.60031049e-02f, -7.17624724e-02f, -3.45846526e-02f, -4.04689610e-02f, -3.28581840e-01f, 7.25965574e-02f, 2.30615631e-01f, -3.11610842e-04f, -5.23845898e-03f, -2.07574248e-01f,
  -2.02932417e-01f, 9.30612758e-02f, -3.50771919e-02f, -4.65509249e-04f, -4.18018028e-02f, 3.46139781e-02f, -3.64202410e-02f, -2.14989185e-02f, 4.29058000e-02f, 8.12509209e-02f,
  4.81933281e-02f, -9.45964232e-02f, -1.94809008e-02f, 7.54487747e-03f, -9.68639553e-02f, -5.91848418e-02f, -1.38326123e-01f, -1.12309113e-01f, -5.47031499e-02f, -9.11605880e-02f,
  -6.09314814e-02f, -8.99169967e-02f, -4.50643152e-02f, 8.94629285e-02f, 8.36613495e-03f, 4.11970280e-02f, 6.05390370e-02f, 6.02383865e-03f, 2.43817642e-02f, -4.40039001e-02f,
  -2.18049027e-02f, 7.31076747e-02f, -6.84821904e-02f, -7.77104823e-03f, -9.97269079e-02f, 1.43801877e-02f, -1.82660278e-02f, -4.54062000e-02f, -3.87973189e-02f, -4.61282395e-02f,
  3.16350423e-02f, -2.14689169e-02f, -2.63080746e-02f, -5.56763858e-02f, 2.62248348e-02f, 2.39511281e-02f, 7.57607911e-03f, 1.86191779e-03f, 6.16877638e-02f, -8.12430084e-02f,
  1.52160004e-02f, -3.67107317e-02f, -1.89606112e-03f, 4.67120521e-02f, 2.77390089e-02f, -4.32975665e-02f, 7.29160234e-02f, -6.94966316e-02f, 7.61608034e-02f, -4.41455022e-02f,
  1.07091576e-01f, 3.28451425e-01f, 1.49485618e-01f, 5.97235002e-03f, 6.76362589e-02f, -7.76302516e-02f, 3.25225270e-03f, -6.17310740e-02f, -1.61525067e-02f, -3.40072811e-02f,
  -3.43043096e-02f, 3.94714773e-02f, -2.27441452e-02f, 8.20507854e-03f, 2.17447802e-02f, 3.11298277e-02f, 1.18001074e-01f, 7.45687336e-02f, 2.74152402e-02f, 5.51990233e-03f,
  2.01252997e-02f, -5.29834721e-03f, 2.86641885e-02f, -8.91505275e-03f, 2.01517381e-02f, 7.78484298e-03f, -8.10617432e-02f, -3.56506021e-03f, -4.13604230e-02f, 8.04107711e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.20537543e-01f, -3.97448927e-01f, 5.95680416e-01f, 5.34895897e-01f, 2.69775420e-01f, -1.56563789e-01f, -1.92104667e-01f, 4.69004780e-01f, 2.80322194e-01f, -4.68700528e-01f,
  -8.29883292e-02f, -3.88172306e-02f, -6.42103255e-01f, 2.59339958e-01f, -2.22642541e-01f, -3.08139861e-01f, 3.51804793e-01f, 4.84631921e-04f, 3.12850296e-01f, 3.90775800e-01f,
  3.74773622e-01f, -2.67954677e-01f, 2.11000919e-01f, 9.72108915e-02f, 3.78141165e-01f, 3.27458441e-01f, -4.23926145e-01f, -9.36345533e-02f, 1.58253998e-01f, -1.79922625e-01f,
  1.44530937e-01f, 1.82598114e-01f, 7.84165487e-02f, 4.36958298e-02f, 8.47428963e-02f, -1.23468406e-01f, -9.14238542e-02f, -1.70011684e-01f, 1.12771980e-01f, 7.90119320e-02f,
  -5.84368892e-02f, 6.12585507e-02f, 1.12583190e-01f, -6.19572923e-02f, 6.87968209e-02f, 1.89466923e-01f, 2.15655506e-01f, 2.80360490e-01f, 1.68320686e-01f, 2.32419610e-01f,
  2.41912812e-01f, 1.32338986e-01f, 1.84123904e-01f, -9.32761992e-04f, 1.46219835e-01f, 5.60642518e-02f, -5.18900808e-03f, -4.64131348e-02f, -9.84013081e-03f, 6.52749604e-03f,
  5.34681454e-02f, -5.28118759e-02f, -2.56919600e-02f, 1.16839921e-02f, 7.31279561e-03f, 7.68291727e-02f, 1.50098400e-02f, -1.21970102e-01f, -3.38244648e-03f, -3.65686743e-03f,
  8.17604363e-02f, 7.10599348e-02f, 5.32403216e-02f, 4.12342064e-02f, 3.12414188e-02f, 1.87231787e-02f, -1.90355163e-02f, 3.88196222e-02f, -7.46170571e-03f, 1.66238159e-01f,
  -1.48638442e-01f, 3.68346795e-02f, -1.13441430e-01f, 8.58435705e-02f, -1.11235872e-01f, -8.21810886e-02f, 3.72988507e-02f, 6.83510154e-02f, 1.07222751e-01f, -2.16487572e-02f,
  -1.02601111e+00f, -7.36933172e-01f, -1.73238024e-01f, -1.54023454e-01f, -1.20832510e-01f, -6.24326840e-02f, -3.78378741e-02f, 1.30425856e-01f, -3.27917486e-01f, 8.12309515e-03f,
  -4.54071835e-02f, 5.32161370e-02f, -1.71323761e-01f, 1.54999346e-01f, -1.58379897e-01f, 1.89819466e-02f, -1.26719266e-01f, -3.80878925e-01f, -3.54677409e-01f, -4.01128307e-02f,
  -3.78505252e-02f, -1.38286784e-01f, 7.40895653e-03f, 1.89170316e-01f, -1.24731492e-02f, -8.82084817e-02f, 5.61015755e-02f, -3.17526236e-02f, 2.82127354e-02f, -8.57035220e-02f,
  -1.36920202e+00f, 4.75723863e-01f, 4.38801706e-01f, -5.23474216e-01f, 1.07698761e-01f, 1.05753386e+00f, 1.07116029e-01f, 3.29564750e-01f, -2.99973249e-01f, 2.26292357e-01f,
  -2.05318965e-02f, -3.80431712e-01f, 6.83874339e-02f, 4.69097227e-01f, 5.30364215e-01f, 4.44839776e-01f, 5.00471294e-01f, 1.44462436e-01f, -5.27928919e-02f, -2.07186192e-01f,
  2.19360809e-03f, 9.03161019e-02f, 3.17721426e-01f, 2.98113048e-01f, -1.40048146e-01f, -4.27346557e-01f, -2.43896380e-01f, -1.35220245e-01f, 3.40305954e-01f, 2.11369857e-01f,
  -3.95112783e-01f, -5.22257566e-01f, -1.39789253e-01f, 1.22333534e-01f, 6.48521408e-02f, -1.27014026e-01f, -7.16106594e-02f, -1.13177918e-01f, -2.10339129e-01f, 8.99520889e-02f,
  -1.71096966e-01f, 5.80593869e-02f, -5.12795113e-02f, -1.17911957e-01f, -5.61107993e-02f, 9.77542177e-02f, 2.46926233e-01f, 1.39281526e-01f, 4.96914871e-02f, 1.64093569e-01f,
  2.01040238e-01f, 2.58410484e-01f, 6.13383316e-02f, 1.09193459e-01f, 8.62394199e-02f, 5.86896911e-02f, 7.16918558e-02f, 1.41648185e-02f, 1.78455889e-01f, 3.27051580e-02f,
  9.81005132e-02f, -8.73191357e-02f, -1.25497682e-02f, -5.60164601e-02f, -4.17041518e-02f, 2.45021507e-02f, -6.24367781e-02f, 2.84548085e-02f, -1.42060459e-01f, 2.19358634e-02f,
  -3.98993045e-02f, -1.75771993e-02f, -8.34203139e-02f, 2.27543805e-02f, -1.10853881e-01f, -1.20932437e-01f, -1.31801575e-01f, -1.09626584e-01f, 9.88590196e-02f, 7.05591366e-02f,
  -8.69149342e-02f, 3.94821130e-02f, -1.83391552e-02f, -9.16955322e-02f, 7.50810653e-02f, -5.93417964e-04f, -3.78677323e-02f, 9.31595266e-02f, -9.37114283e-03f, -8.61678459e-03f,
  -2.98562527e-01f, -3.67685527e-01f, -2.45560229e-01f, -7.25462614e-03f, -4.34656702e-02f, 1.77250043e-01f, -9.45995599e-02f, 1.18542187e-01f, 4.35153283e-02f, 3.88751365e-02f,
  5.74516021e-02f, -2.01962367e-02f, -1.03133738e-01f, -8.57150853e-02f, 1.56498980e-02f, 8.47177580e-02f, -1.44354522e-01f, -2.18695343e-01f, -6.35979399e-02f, -2.73249745e-02f,
  -1.50762424e-01f, -9.96713638e-02f, -1.25216795e-02f, -8.28573108e-02f, -2.40549240e-02f, -1.20184347e-01f, -1.06797166e-01f, -9.55536813e-02f, 1.54267880e-03f, 1.38215810e-01f,
  5.09732604e-01f, -6.53218806e-01f, -4.38186020e-01f, -5.21590412e-01f, 1.13576680e-01f, 1.23170830e-01f, 2.01923758e-01f, -4.61406350e-01f, -7.60888934e-01f, -1.79301754e-01f,
  -3.13850455e-02f, 1.49222612e-01f, 1.46085575e-01f, -5.43073356e-01f, 8.32130849e-01f, -1.22163765e-01f, -2.42313758e-01f, 1.82575330e-01f, -4.52984393e-01f, 1.10123731e-01f,
  -1.80032969e-01f, 6.29170015e-02f, -1.40675530e-01f, -1.67553499e-01f, -7.43420124e-02f, -1.13563858e-01f, 3.75106603e-01f, 5.48808649e-02f, -1.60412025e-02f, 3.00429821e-01f,
  -8.26017112e-02f, -2.78779805e-01f, -1.81734040e-01f, 4.88139838e-02f, -2.49203965e-02f, 8.32541883e-02f, 1.46676838e-01f, 2.73804903e-01f, -4.62345742e-02f, -7.14500248e-02f,
  1.84615463e-01f, 8.46420527e-02f, -1.79900050e-01f, 1.30804703e-01f, -3.95346573e-03f, -1.12333320e-01f, -2.20080361e-01f, -1.45837784e-01f, -1.62369817e-01f, 1.22768864e-01f,
  -1.65681645e-01f, -6.44554868e-02f, -1.86970040e-01f, 2.12668013e-02f, -1.27134383e-01f, -7.36664161e-02f, 9.25172716e-02f, 1.79174408e-01f, -2.35853661e-02f, 3.09759304e-02f,
  1.51608795e-01f, 4.02593873e-02f, 7.88275599e-02f, -3.06260623e-02f, -4.85120900e-02f, -1.09717362e-01f, -4.56593931e-02f, 4.73243594e-02f, -5.17217405e-02f, 2.23099943e-02f,
  -1.52029201e-01f, -6.75176829e-02f, -3.03096920e-01f, -1.47135392e-01f, 7.26701915e-02f, -1.08388856e-01f, 2.20618472e-01f, 4.86584641e-02f, -2.13912427e-01f, -1.29354447e-01f,
  -6.90600276e-02f, 3.08642746e-03f, -1.58166625e-02f, -3.47974896e-02f, -1.08463146e-01f, 1.04921922e-01f, -4.37224768e-02f, -1.39596667e-02f, -2.61971056e-01f, 1.61672920e-01f,
  2.50981804e-02f, 9.49661657e-02f, -8.40450227e-02f, 6.51868582e-02f, -5.02605326e-02f, -2.56611109e-02f, -1.32293776e-01f, -1.44315749e-01f, 1.03111625e-01f, -7.04714283e-02f,
  7.24966228e-02f, 6.84287846e-02f, -2.02789195e-02f, -4.47922060e-03f, -6.62971213e-02f, -9.98106692e-03f, 2.20940292e-01f, 3.20248678e-02f, 7.55169690e-02f, 7.19979499e-03f,
  8.23470429e-02f, 3.17545645e-02f, 1.54739544e-01f, -1.71465695e-01f, 9.85973421e-03f, 2.29159847e-01f, 1.73009876e-02f, 9.17027984e-03f, 1.97722733e-01f, -1.53774604e-01f,
  -2.30495092e-02f, 6.22979045e-01f, 6.99237227e-01f, -1.95205286e-02f, -6.21984720e-01f, -2.03119636e-01f, -2.91269124e-01f, 2.71307170e-01f, 3.95106047e-01f, 2.51437306e-01f,
  -5.92791080e-01f, 3.93514663e-01f, -1.13791712e-02f, -7.42018148e-02f, 1.98074996e-01f, 6.36102483e-02f, 1.15175359e-01f, -7.79751688e-02f, -1.67377010e-01f, 9.24219787e-02f,
  -7.38994554e-02f, -7.25688040e-01f, 1.07087471e-01f, -2.59093851e-01f, -2.00941071e-01f, 2.67495185e-01f, -2.98885405e-01f, -2.01699480e-01f, 7.31000006e-02f, -2.02772126e-01f,
  -1.32640349e-02f, 2.76929396e-03f, 2.05089971e-01f, 2.99502522e-01f, 1.47632748e-01f, -9.01136920e-02f, 3.15500312e-02f, -7.42338449e-02f, -3.84831950e-02f, 4.08964641e-02f,
  4.31098826e-02f, 7.88273569e-03f, 1.81984350e-01f, -1.25263289e-01f, -1.19240768e-01f, 2.74123531e-03f, 1.04335606e-01f, 1.70120746e-01f, 1.48205251e-01f, -7.13938698e-02f,
  2.04426404e-02f, 1.82982296e-01f, 1.56658161e-02f, 1.26704127e-01f, 1.09893821e-01f, 6.49664700e-02f, 5.74222915e-02f, -5.55434413e-02f, 9.93273929e-02f, 7.55371898e-02f,
  -1.22768395e-01f, -9.92553830e-02f, -6.66858256e-02f, 5.55201322e-02f, -1.85726091e-01f, -6.35071918e-02f, -1.09173380e-01f, -1.76412374e-01f, 3.18182409e-02f, -8.73882473e-02f,
  5.47054857e-02f, -9.22103971e-02f, -1.15312070e-01f, 7.92542323e-02f, -2.58726895e-01f, 1.17054274e-02f, 4.46855649e-02f, 1.17543735e-01f, 1.65722445e-01f, 1.98626548e-01f,
  -8.25517252e-02f, 1.09351156e-02f, -1.57549173e-01f, -1.08522080e-01f, -1.07544459e-01f, -7.77462451e-03f, 9.86519977e-02f, -7.90062919e-02f, -8.85160267e-02f, -1.27254486e-01f,
  2.98197448e-01f, 4.85333323e-01f, 2.74969190e-01f, 1.80646881e-01f, 1.95141286e-01f, -1.09021068e-02f, -7.32322857e-02f, 1.43499896e-01f, 2.22852692e-01f, -1.32287648e-02f,
  -1.42646223e-01f, 1.46741033e-01f, 1.64952278e-01f, -1.61924526e-01f, 1.18437730e-01f, 1.20183118e-01f, 2.89313018e-01f, 2.36155912e-01f, 1.92271620e-01f, -3.81679609e-02f,
  -8.85472745e-02f, -1.97257847e-01f, 1.04272977e-01f, 2.28424333e-02f, -4.19829302e-02f, 1.41006351e-01f, -1.22441113e-01f, 2.76329160e-01f, -1.98094025e-02f, 1.72173575e-01f,
  -7.50088692e-01f, -2.63091445e-01f, 1.37430117e-01f, -4.91641641e-01f, -5.22744417e-01f, 4.35099751e-02f, 4.58784938e-01f, -4.65384781e-01f, -4.46805537e-01f, 1.51291639e-01f,
  -2.59630401e-02f, -5.14255986e-02f, 7.74408162e-01f, -1.16862521e-01f, 4.89447147e-01f, 5.75249493e-01f, -1.96370870e-01f, 1.68342680e-01f, -1.83494493e-01f, -5.39397120e-01f,
  -2.70887643e-01f, -4.71439928e-01f, 5.24546742e-01f, -6.73396647e-01f, -4.67809319e-01f, -3.80244225e-01f, 7.60888727e-03f, 1.07929096e-01f, -3.82430971e-01f, -1.79743692e-02f,
  -3.38955015e-01f, -6.89884841e-01f, -2.06487298e-01f, -4.03012298e-02f, -2.47236416e-01f, 5.88441417e-02f, 7.77969584e-02f, 2.88292855e-01f, -5.02443239e-02f, -5.82373701e-02f,
  1.04588322e-01f, -5.36739221e-03f, -1.51589006e-01f, 1.23428687e-01f, -2.42859647e-01f, -2.36776173e-01f, 4.60216962e-03f, 6.08236715e-02f, -1.91553697e-01f, -1.91171728e-02f,
  -6.97493330e-02f, -1.08132817e-01f, -9.35931057e-02f, 8.76616016e-02f, -7.92794824e-02f, -1.85573384e-01f, 1.50501445e-01f, 1.30086526e-01f, -2.04203606e-01f, -1.82167545e-01f,
  -1.44551352e-01f, 7.60793090e-02f, -1.28490448e-01f, -1.87824573e-02f, -7.50061348e-02f, -2.84343027e-02f, -4.79218177e-02f, 7.14389086e-02f, -2.22840831e-02f, -6.69986829e-02f,
  9.21513364e-02f, 2.25579720e-02f, -1.30628228e-01f, 6.88049421e-02f, -1.49274051e-01f, -5.85452002e-03f, 8.05867836e-02f, -9.19612870e-02f, 2.59011369e-02f, 1.86936744e-03f,
  2.45667621e-02f, 7.55405147e-03f, 3.81276235e-02f, 1.52996242e-01f, -2.55772136e-02f, 1.38579775e-02f, -1.39023319e-01f, 1.70402415e-02f, -3.76961082e-02f, 7.66072124e-02f,
  -3.39557499e-01f, -7.04542339e-01f, -1.02296650e-01f, -1.87379628e-01f, 1.89618468e-02f, -9.44674015e-02f, -1.03135426e-02f, -1.64795414e-01f, -1.83041751e-01f, -5.53078167e-02f,
  -1.43363386e-01f, -1.30737657e-02f, -4.82010841e-02f, 7.99414739e-02f, 8.05729255e-02f, -3.91244851e-02f, -2.26036776e-02f, 7.48446118e-03f, -1.23067781e-01f, -1.92747205e-01f,
  1.18712883e-03f, 2.88750362e-02f, 9.86088216e-02f, -7.11444467e-02f, 5.78471087e-02f, 2.36810491e-04f, -1.46734223e-01f, -7.19785551e-03f, -5.93799911e-02f, 1.57271847e-01f,
  5.31050384e-01f, -2.50349969e-01f, -2.53656238e-01f, 7.33997226e-01f, -3.65907490e-01f, 5.61042130e-01f, 1.08292997e+00f, -2.58124322e-01f, 7.11994350e-01f, 2.96160698e-01f,
  2.12078616e-01f, 1.52495056e-01f, 2.98666388e-01f, 6.57699823e-01f, 3.28675538e-01f, 5.15625119e-01f, 6.66849375e-01f, 5.30678689e-01f, 3.76654826e-02f, 3.76534760e-01f,
  1.55553758e-01f, 4.50421304e-01f, -7.04945922e-02f, -5.07421136e-01f, 3.86045128e-02f, -4.21956390e-01f, -4.13272053e-01f, -4.27805394e-01f, -3.21874022e-01f, -2.01746330e-01f,
  1.70906618e-01f, 1.30162954e-01f, -1.01049490e-01f, 1.78415272e-02f, 5.55495620e-02f, 1.49282189e-02f, -4.93730046e-03f, -1.23968072e-01f, 4.51885425e-02f, 1.67379916e-01f,
  1.34815276e-01f, -7.52087831e-02f, 1.13692209e-01f, -9.32557210e-02f, 5.49498871e-02f, -1.10434100e-01f, -5.59482425e-02f, -1.23527730e-02f, -3.52788866e-02f, -1.14542712e-02f,
  9.89584252e-02f, -6.35601282e-02f, 1.14050590e-01f, -2.82800160e-02f, -1.02676861e-01f, 1.11311778e-01f, 2.24392395e-02f, -7.95199946e-02f, -7.52868801e-02f, 3.12632099e-02f,
  -5.90625703e-02f, 8.14989656e-02f, 7.25514162e-03f, -9.20129661e-03f, -1.38497278e-02f, -6.65825903e-02f, 1.00496963e-01f, -1.16542116e-01f, 6.57774433e-02f, 4.85283285e-02f,
  2.44347323e-02f, 5.18241152e-02f, 7.69482329e-02f, 4.00886089e-02f, 2.19189793e-01f, 5.20307347e-02f, -5.24300188e-02f, -4.77372296e-02f, 1.89134672e-01f, -5.51491193e-02f,
  2.22514421e-02f, 1.03386231e-01f, -2.22264230e-03f, -1.32207453e-01f, 7.26511180e-02f, -8.52079540e-02f, 2.69531216e-02f, -2.07718574e-02f, 1.59607250e-02f, -5.40118553e-02f,
  1.26407713e-01f, -6.50591031e-02f, 8.09309781e-02f, -1.23083359e-02f, -6.32501692e-02f, -8.06716830e-02f, 3.42607126e-03f, -3.01741306e-02f, -4.96697500e-02f, -7.08394349e-02f,
  -5.23486622e-02f, 1.20761305e-01f, -1.76131040e-01f, -5.97322807e-02f, -6.69475794e-02f, -5.23380525e-02f, 1.60638019e-01f, -8.43768418e-02f, 3.65875699e-02f, -1.88639820e-01f,
  -6.41877875e-02f, 1.16114177e-01f, 6.85013235e-02f, 8.10324922e-02f, 3.27772349e-02f, -7.09763989e-02f, -1.00243166e-01f, -1.93158641e-01f, -1.99301124e-01f, 3.19130672e-03f,
  -8.79932761e-01f, 6.25439048e-01f, 5.53053133e-02f, -2.57414192e-01f, 8.18170086e-02f, -2.74935961e-01f, 8.17389861e-02f, -3.65262926e-02f, -5.04118316e-02f, 5.70616484e-01f,
  3.53070050e-02f, 3.16921502e-01f, 4.62495200e-02f, -4.52088676e-02f, -8.70320380e-01f, -3.54837269e-01f, -4.40501779e-01f, -7.94257894e-02f, -2.79815912e-01f, -5.52077107e-02f,
  -4.25224692e-01f, -2.76603639e-01f, -4.00458664e-01f, 3.05763006e-01f, 2.72661537e-01f, 3.29274744e-01f, -2.01153710e-01f, 3.19757581e-01f, 4.51736189e-02f, -5.27165681e-02f,
  -1.07963465e-01f, 1.93429694e-01f, 1.91865653e-01f, 5.67533821e-02f, -1.44404531e-01f, 2.01501567e-02f, 6.10599220e-02f, -6.06448837e-02f, -6.12495169e-02f, -1.35778695e-01f,
  1.09213516e-01f, -7.39991590e-02f, -3.40427011e-02f, 1.35060903e-02f, 1.99805975e-01f, 1.07553661e-01f, 5.97752966e-02f, 1.78739280e-02f, 8.53614584e-02f, 1.02567054e-01f,
  9.41672176e-02f, 1.02937691e-01f, 6.83523715e-02f, 8.22288692e-02f, -1.72733203e-01f, -5.05042858e-02f, -1.40811890e-01f, 7.02442676e-02f, 3.76616679e-02f, -7.04316571e-02f,
  -2.14833003e-02f, 4.16221656e-02f, 2.22355902e-01f, 1.64769534e-02f, 1.26948908e-01f, 1.46903575e-03f, 1.49933882e-02f, -1.00133575e-01f, 4.94257025e-02f, 7.53587186e-02f,
  -8.68267789e-02f, 2.64989976e-02f, 7.30836987e-02f, -6.42226338e-02f, 9.92722362e-02f, 6.90235198e-02f, -2.86045130e-02f, 1.10300213e-01f, -1.31681994e-01f, -5.43719716e-02f,
  -4.01417911e-02f, -8.46697763e-02f, 2.17251591e-02f, 5.35853542e-02f, -2.46792659e-02f, 1.90559402e-02f, 2.38512270e-02f, 6.50005192e-02f, -1.56379566e-01f, -4.42890115e-02f,
  -3.37177277e-01f, -1.47377312e-01f, -1.58402789e-02f, 1.31024048e-01f, 5.87875303e-03f, -3.41478772e-02f, -1.18334077e-01f, 8.51028338e-02f, -1.74085572e-01f, -8.42562243e-02f,
  3.18974592e-02f, 6.64738566e-02f, -4.97591011e-02f, 2.53549274e-02f, -1.50740176e-01f, -1.95610449e-01f, 6.39281701e-04f, -1.41348597e-02f, -8.01818892e-02f, 2.10544523e-02f,
  1.44177943e-01f, 7.01339692e-02f, -2.05949377e-02f, -4.03330885e-02f, 1.31286448e-02f, 9.47250724e-02f, -2.42597181e-02f, 8.51140916e-03f, 2.24533938e-02f, 6.99728429e-02f,
  -3.80591780e-01f, 6.45305991e-01f, -2.24659994e-01f, -4.68900442e-01f, -1.91614732e-01f, -5.31108797e-01f, -4.47250932e-01f, 2.74559170e-01f, 5.48828959e-01f, 2.70348787e-01f,
  -9.60660726e-02f, 5.19952297e-01f, 6.74307764e-01f, -4.08044994e-01f, -3.29261780e-01f, 3.82785678e-01f, -6.50162399e-01f, -1.61998749e-01f, 2.89099216e-01f, -2.00618282e-01f,
  -2.59005964e-01f, -2.65740484e-01f, -3.92317176e-01f, 2.37387806e-01f, -4.77055013e-01f, -2.27506727e-01f, -5.71020782e-01f, 2.44594440e-01f, -7.34769464e-01f, -1.49389401e-01f,
  -6.00682437e-01f, 1.62593424e-01f, -2.24177495e-01f, -4.85577341e-03f, -4.09529001e-01f, -2.08311737e-01f, -3.47052455e-01f, -1.56488605e-02f, 4.65224199e-02f, 8.88694301e-02f,
  1.46061212e-01f, 2.33611897e-01f, -1.43492017e-02f, 2.77400851e-01f, 1.07484974e-01f, -2.17079539e-02f, -4.74622287e-02f, -3.49602610e-01f, 1.05443738e-01f, -4.47601229e-02f,
  5.61002754e-02f, -1.69478729e-01f, -2.07851648e-01f, -8.09146538e-02f, -8.35549533e-02f, -8.96645337e-02f, -2.70611435e-01f, -8.17200243e-02f, -1.55466452e-01f, -6.57257587e-02f,
  1.29096821e-01f, -9.68676209e-02f, 2.18174979e-03f, -1.78974178e-02f, 4.66522351e-02f, -1.28285810e-01f, -5.44806644e-02f, -3.30055668e-03f, 2.96568684e-02f, -1.11206427e-01f,
  -1.54757529e-01f, -3.01210880e-02f, 4.89320010e-02f, -2.31711656e-01f, -5.42544276e-02f, -3.09384149e-02f, -7.68630505e-02f, 9.43904072e-02f, -5.74431233e-02f, -6.78525865e-02f,
  1.97812885e-01f, -1.74838118e-02f, 5.93274198e-02f, -1.63277522e-01f, -3.83402184e-02f, 3.80942635e-02f, -7.60724917e-02f, 3.54202911e-02f, -1.43810526e-01f, 2.49661803e-02f,
  -4.86097872e-01f, 6.27230853e-02f, 1.25019267e-01f, 6.38253838e-02f, 6.07974082e-02f, -5.31164417e-03f, 7.04349354e-02f, -1.17775090e-01f, -5.60125448e-02f, -3.09971850e-02f,
  -6.32415786e-02f, -6.17729966e-03f, -2.55554914e-01f, -2.22061388e-02f, 5.81948496e-02f, -1.85062513e-01f, -4.76697758e-02f, -1.45319134e-01f, -2.49944806e-01f, -8.96663964e-02f,
  -1.71570387e-02f, 6.47063553e-02f, 5.09873889e-02f, 6.44274196e-03f, -3.25887986e-02f, -8.69867504e-02f, 7.65209645e-02f, 6.32900894e-02f, -7.25549981e-02f, -8.27114359e-02f,
  6.18931115e-01f, -1.82103857e-01f, 9.59149778e-01f, 3.87135237e-01f, 4.85057235e-01f, 5.15763164e-01f, 7.42915154e-01f, 5.49691357e-02f, 7.27844834e-01f, -5.56619465e-01f,
  -5.65370023e-01f, 9.36810300e-02f, 7.51878098e-02f, -4.20282662e-01f, 7.03902602e-01f, 3.35408509e-01f, 1.07995994e-01f, -1.50317829e-02f, 5.82592934e-02f, -1.77537248e-01f,
  5.64456247e-02f, -7.24475443e-01f, -8.18829089e-02f, -7.03294873e-01f, -2.83911407e-01f, -1.62030339e-01f, -6.82362914e-01f, 2.14770734e-01f, -6.63319886e-01f, 1.70121387e-01f,
  -4.40151244e-01f, -2.01754998e-02f, -1.06136620e-01f, 2.47102901e-02f, -8.69151503e-02f, 5.61563745e-02f, 1.82069793e-01f, 1.55321553e-01f, 1.55540630e-01f, -5.29041886e-02f,
  -1.35914264e-02f, -1.01572573e-01f, -1.94917962e-01f, 2.55735703e-02f, 1.47127613e-01f, 2.49451194e-02f, 5.68099767e-02f, -1.45865455e-01f, 4.41341028e-02f, 2.18735605e-01f,
  2.39292905e-01f, 6.67765886e-02f, 7.41381943e-03f, -5.76021336e-03f, 1.52830064e-01f, -3.98824699e-02f, 1.32819593e-01f, 1.98542044e-01f, 9.32093635e-02f, 8.77075195e-02f,
  -5.56576587e-02f, 1.20375872e-01f, -3.01770750e-03f, -3.75601985e-02f, 2.66307294e-02f, -5.87371327e-02f, -6.83956593e-02f, -1.08595617e-01f, 8.91560614e-02f, -1.17960706e-01f,
  -1.14933945e-01f, -5.86647950e-02f, 1.11910403e-01f, 2.32627615e-02f, -1.41433060e-01f, 1.97698884e-02f, 2.02013105e-02f, 3.51591595e-02f, 2.10597471e-04f, -1.38005421e-01f,
  1.07414424e-02f, 3.57002877e-02f, -1.16225518e-01f, 1.26821056e-01f, 1.40258983e-01f, 5.37948273e-02f, -3.05433482e-01f, 1.88632503e-01f, -6.99549019e-02f, -7.53252208e-02f,
  -5.18547058e-01f, -2.27078095e-01f, -1.84989989e-01f, -2.22351775e-01f, -5.70073687e-02f, -1.87051266e-01f, 4.95694615e-02f, -8.22981149e-02f, -5.94545738e-04f, -5.77619225e-02f,
  -1.38197988e-01f, -7.04072341e-02f, -8.19536373e-02f, 2.10671052e-02f, -1.61196858e-01f, -1.46300986e-01f, 6.95231035e-02f, -1.27333745e-01f, -7.37930760e-02f, -2.06987038e-01f,
  -1.06437385e-01f, -3.73626836e-02f, -5.01926728e-02f, -2.70343512e-01f, -2.23701581e-01f, -6.20883368e-02f, -1.19597748e-01f, 2.02905815e-02f, -1.43753707e-01f, -1.42342579e-02f,
  -1.19914159e-01f, -7.95609117e-01f, 5.81565797e-01f, 3.88444752e-01f, 5.01830801e-02f, -2.48021990e-01f, 1.75692007e-01f, -3.26904625e-01f, -5.01258075e-01f, -7.80942440e-01f,
  -1.03388028e-02f, 8.63547996e-02f, -3.33567820e-02f, 7.84752294e-02f, 7.37762034e-01f, 1.16284549e-01f, 9.90543291e-02f, 1.95579994e-02f, 3.15460682e-01f, 2.52890229e-01f,
  4.40373778e-01f, 2.25632712e-01f, 7.82745659e-01f, 1.19727254e-01f, 1.29630938e-01f, 2.89782912e-01f, 4.20206338e-01f, 5.23347080e-01f, 2.35931039e-01f, 3.93879384e-01f,
  -4.48096424e-01f, 7.19842836e-02f, 8.76753870e-03f, -4.26064096e-02f, -9.34210867e-02f, -1.20742299e-01f, 9.42769200e-02f, 3.26169044e-01f, 1.86732262e-01f, 4.75352742e-02f,
  -9.19185802e-02f, 7.18905404e-02f, -2.67408900e-02f, 8.36351290e-02f, -1.25080094e-01f, 7.68403197e-03f, -1.44891337e-01f, -1.66805953e-01f, 7.37770051e-02f, -7.37560540e-02f,
  1.73847983e-03f, -1.37754843e-01f, -5.93754500e-02f, 8.45124479e-03f, 2.69141227e-01f, -2.21846059e-01f, 1.29009098e-01f, 2.04699218e-01f, -1.51071981e-01f, -4.76221070e-02f,
  3.50003541e-02f, 7.10715577e-02f, -2.81801214e-03f, 5.25169075e-02f, 1.24152815e-02f, 1.50415115e-02f, 6.23736717e-02f, 6.11378551e-02f, 5.71996383e-02f, -2.76634283e-02f,
  -1.86370928e-02f, 3.58265974e-02f, -9.69077554e-03f, -1.78587690e-01f, 4.99927178e-02f, -1.04062401e-01f, 1.08431578e-01f, 5.29412143e-02f, -5.34707075e-03f, 6.44178912e-02f,
  -1.40795335e-02f, -3.79681922e-02f, 4.76408079e-02f, 4.89220992e-02f, -1.38708472e-01f, 9.30553153e-02f, -8.77325013e-02f, -1.62264183e-01f, 1.09333225e-01f, 3.37499797e-01f,
  -6.61941946e-01f, 1.94129683e-02f, 8.20066407e-03f, -1.88842446e-01f, 3.38257290e-02f, -7.57155567e-02f, 1.72218516e-01f, -1.28894985e-01f, 7.81134889e-02f, -4.53503756e-03f,
  -8.06035567e-03f, 2.03825533e-02f, -2.23322421e-01f, -3.88481952e-02f, 1.47591829e-01f, -1.24006987e-01f, 5.69082871e-02f, -1.70525983e-02f, 7.51868263e-02f, 2.27162745e-02f,
  -7.51474202e-02f, -2.15369742e-02f, 8.03840756e-02f, 1.61600247e-01f, -9.41377133e-03f, 1.91995073e-02f, 6.32897159e-03f, -6.53100684e-02f, 8.78650993e-02f, 4.24365364e-02f,
  1.17281094e-01f, 1.10570535e-01f, 1.83906779e-02f, -2.72326879e-02f, 6.36993766e-01f, 6.38784468e-01f, 5.17819464e-01f, 7.77307212e-01f, 9.17593241e-01f, -8.65062699e-02f,
  -1.54815644e-01f, -2.67861962e-01f, -8.81986544e-02f, -1.96539447e-01f, -2.53975019e-02f, -7.27830827e-02f, 1.04746699e-01f, -1.07228954e-03f, 4.74350303e-01f, 2.66247354e-02f,
  8.22695624e-03f, -1.98821276e-01f, -7.56426930e-01f, -5.44516779e-02f, -1.03566743e-01f, -1.08327977e-01f, -5.05923569e-01f, 9.37859043e-02f, -3.62623692e-01f, 1.78102702e-01f,
  -1.99584868e-02f, 3.03066432e-01f, -1.86611533e-01f, -9.05250292e-03f, -2.89904103e-02f, -1.19091935e-01f, -2.08937660e-01f, -5.62556903e-04f, 8.50676820e-02f, 9.86323282e-02f,
  -1.72032505e-01f, -1.33354723e-01f, 9.17570740e-02f, -3.09481658e-03f, 2.65141666e-01f, -1.63225997e-02f, -1.56718507e-01f, -8.10058713e-02f, 9.10703093e-02f, -8.43339190e-02f,
  -3.44229788e-01f, -6.03054017e-02f, 5.21254800e-02f, 3.30405869e-02f, -5.66010512e-02f, 1.34449646e-01f, 4.34360802e-02f, -4.39375117e-02f, -1.30995233e-02f, 1.11625291e-01f,
  8.29529837e-02f, 2.22477302e-01f, 4.61374745e-02f, 2.85990164e-02f, 6.72954172e-02f, 5.70255816e-02f, -1.52569264e-01f, -1.23868383e-01f, 7.12430291e-03f, -4.86058295e-02f,
  9.17854533e-02f, 1.09451130e-01f, 1.98058352e-01f, 8.49471390e-02f, -4.94494624e-02f, -5.53205842e-03f, -1.26038000e-01f, 2.43501477e-02f, -3.26159112e-02f, 6.79661185e-02f,
  -1.93432458e-02f, 2.16173902e-02f, -3.74663398e-02f, -5.71755506e-02f, -1.23141944e-01f, 5.08560725e-02f, 1.15517236e-01f, -5.64799719e-02f, -8.23850557e-02f, 6.86711224e-04f,
  2.56441355e-01f, 4.87550616e-01f, 1.45915478e-01f, -7.28704482e-02f, -8.30625296e-02f, 2.66141389e-02f, 8.00759569e-02f, 1.66960225e-01f, 2.00059354e-01f, 1.61467850e-01f,
  -4.78917733e-02f, -6.74861223e-02f, -7.02443421e-02f, 1.16885789e-02f, -1.76901549e-01f, 1.91917509e-01f, -1.50027066e-01f, 1.18486822e-01f, 6.15837760e-02f, -4.14803401e-02f,
  -1.69394761e-01f, 1.55730486e-01f, 1.03180511e-02f, 7.45497420e-02f, -6.58474490e-03f, -1.27437785e-01f, 1.95349574e-01f, -4.40079905e-02f, -1.56004414e-01f, 7.10683912e-02f,
  -8.10017347e-01f, 5.40654182e-01f, -5.93876839e-01f, 2.62801498e-01f, 2.87947297e-01f, -5.63054264e-01f, -3.28023016e-01f, 4.61114049e-01f, -3.80896410e-04f, 5.94766200e-01f,
  6.97823584e-01f, -1.37420222e-01f, 3.04992050e-01f, 7.35743821e-01f, -2.09352717e-01f, 1.54584451e-02f, 2.11297959e-01f, -1.76105335e-01f, -1.74356893e-01f, 2.36629799e-01f,
  -2.75592417e-01f, 6.89140141e-01f, 1.16067164e-01f, 3.56233507e-01f, 7.01236501e-02f, -2.16653749e-01f, 5.42236030e-01f, -1.39830727e-02f, 4.41493094e-01f, 1.22864179e-01f,
  -2.18439959e-02f, 4.14708525e-01f, -1.52526632e-01f, -1.90740004e-01f, -1.36269197e-01f, -1.95790991e-01f, -2.24833563e-01f, -4.78064679e-02f, 2.52146763e-03f, 2.94531826e-02f,
  -1.05506152e-01f, -6.97257230e-03f, 8.42883438e-03f, 2.32682936e-02f, -1.43377811e-01f, 5.84641173e-02f, 1.30718444e-02f, -4.53140624e-02f, 6.45308569e-03f, -8.60378444e-02f,
  -6.59579560e-02f, -1.01998113e-01f, 9.91179049e-02f, -2.62636109e-03f, 1.09597789e-02f, 6.91276267e-02f, -1.06871963e-01f, -1.09639384e-01f, -1.08312584e-01f, -3.42899859e-02f,
  -2.27021053e-02f, -1.07200608e-01f, -1.36673851e-02f, 5.43767996e-02f, 1.93298310e-02f, -3.02358903e-03f, -1.66997779e-03f, 2.77571077e-03f, -6.87928423e-02f, 9.52360630e-02f,
  1.31632641e-01f, 1.31797679e-02f, 1.13419637e-01f, 2.43626311e-02f, 1.01635996e-02f, -4.81354222e-02f, -9.63099301e-02f, 1.17748834e-01f, -1.06314719e-01f, 2.34635212e-02f,
  1.71666488e-01f, -7.63133913e-02f, 2.62252986e-02f, -7.40359053e-02f, -2.28847805e-02f, 1.11403160e-01f, 1.79200873e-01f, -2.91252080e-02f, -1.21936481e-02f, -8.34990814e-02f,
  6.32999092e-02f, 3.09490621e-01f, 1.43708140e-01f, -6.72311857e-02f, 9.05973315e-02f, 3.16991359e-02f, -8.07906613e-02f, 9.70021938e-04f, 8.05490837e-02f, 2.97965314e-02f,
  -3.46714258e-02f, -7.45300278e-02f, -6.59829900e-02f, 7.23824725e-02f, -3.93264219e-02f, 2.02184305e-01f, 1.92486390e-01f, -2.48411088e-03f, 7.59624690e-02f, -1.20980609e-02f,
  2.58328110e-01f, 1.32066637e-01f, -4.06484678e-02f, -7.14448020e-02f, -2.53948406e-03f, 1.60366669e-01f, -1.90870520e-02f, 4.99879755e-02f, 1.28837347e-01f, 6.95999637e-02f,
  4.81043220e-01f, -1.54557481e-01f, -3.56088907e-01f, 1.84146836e-01f, -1.00180402e-01f, -3.45497578e-01f, -3.53549778e-01f, -2.43478194e-02f, 7.27044046e-01f, -3.81490998e-02f,
  -2.13943467e-01f, -9.54891667e-02f, -1.26236483e-01f, -4.78169978e-01f, 3.80982786e-01f, 1.86505869e-01f, -3.23998705e-02f, -2.03702882e-01f, 1.57036424e-01f, -1.25667438e-01f,
  3.04625511e-01f, -1.94755882e-01f, -4.01809722e-01f, -2.08254531e-01f, -2.71888554e-01f, 3.40455994e-02f, 1.53866857e-01f, -4.21776086e-01f, -4.66877162e-01f, -2.13426709e-01f,
  -3.12252700e-01f, 4.00487892e-02f, -2.41876096e-01f, -5.52829802e-02f, 1.16052926e-02f, 9.70443785e-02f, -5.00898287e-02f, -3.06520522e-01f, -2.64855653e-01f, -7.93772265e-02f,
  2.03794807e-01f, -9.91404895e-03f, 1.20340772e-01f, -1.18721187e-01f, -1.31600052e-01f, 1.36433586e-01f, 1.75715521e-01f, 1.75533816e-01f, -1.90422252e-01f, -2.02420607e-01f,
  6.17487356e-02f, 5.32848947e-02f, 4.95193861e-02f, 7.04837814e-02f, -6.97907200e-03f, -9.29044858e-02f, -1.34605199e-01f, -1.50783256e-01f, 1.56623721e-01f, 1.60641689e-02f,
  2.09598839e-02f, 1.75837532e-01f, -9.02679488e-02f, -1.23099633e-01f, -6.76274076e-02f, 3.81968319e-02f, 2.61565670e-02f, 5.48308156e-02f, 4.63482328e-02f, 5.77148721e-02f,
  1.46918103e-01f, -1.07534140e-01f, 3.10238749e-02f, -6.70842305e-02f, 6.39270544e-02f, 5.54107651e-02f, -6.88916370e-02f, 5.54334335e-02f, 2.21906796e-01f, 1.11998245e-01f,
  -3.89147997e-02f, 4.44702916e-02f, -1.16218992e-01f, 4.42335717e-02f, -5.81987575e-02f, -4.13069651e-02f, 2.21283082e-02f, -5.32052964e-02f, 1.80929437e-01f, 1.47808805e-01f,
  1.13710962e-01f, 3.76888037e-01f, -5.22161685e-02f, -2.08662927e-01f, 2.67062522e-02f, 1.78104024e-02f, -3.72834690e-02f, -5.23367450e-02f, 7.81734362e-02f, 9.39926058e-02f,
  1.16049670e-01f, -1.12365559e-02f, 1.95413753e-01f, -2.30653025e-02f, 5.92187457e-02f, 4.92771193e-02f, 1.31346717e-01f, 2.12854877e-01f, 1.44628510e-01f, 8.75034407e-02f,
  8.37853029e-02f, 3.33398759e-01f, 3.94268297e-02f, 1.70472756e-01f, 1.12343661e-01f, 1.56504996e-02f, 2.21233457e-01f, -1.57331198e-01f, 8.81939456e-02f, 7.15353489e-02f,
  3.55886579e-01f, 6.14251614e-01f, 2.48678356e-01f, 1.48738846e-01f, -1.04749911e-01f, 2.77483642e-01f, -8.28067958e-02f, -2.12133214e-01f, -2.75743961e-01f, 4.60646212e-01f,
  -1.07180603e-01f, 3.83225292e-01f, -4.83139485e-01f, -9.46423486e-02f, -4.02636915e-01f, -4.35950220e-01f, 3.61324370e-01f, 2.25254059e-01f, -1.58054233e-01f, 6.17195904e-01f,
  -6.90066069e-02f, -1.16243929e-01f, -2.48696029e-01f, -5.21826372e-02f, 4.25920159e-01f, 4.88471597e-01f, 2.62316108e-01f, 3.08582410e-02f, 6.39980137e-01f, -1.30679503e-01f,
  -9.22806710e-02f, -1.25551641e-01f, 1.13842227e-01f, -5.06924279e-02f, 2.28449121e-01f, 2.39873454e-01f, 1.91208199e-01f, -7.52376989e-02f, -1.56950772e-01f, -1.22244842e-03f,
  1.36541784e-01f, -6.44101724e-02f, 1.47863701e-02f, -1.49052620e-01f, -2.28354186e-02f, 7.35604391e-02f, 8.18648189e-02f, 8.04714207e-03f, -8.83754864e-02f, 5.73578365e-02f,
  1.30674183e-01f, 2.19386257e-02f, 2.12578505e-01f, 8.64984766e-02f, 1.28271088e-01f, -1.72304194e-02f, 1.36476338e-01f, 2.25869372e-01f, 1.96501747e-01f, 1.01977028e-01f,
  1.85432971e-01f, 1.26396418e-01f, -1.27976820e-01f, -9.69237834e-02f, -1.67857315e-02f, -1.29482344e-01f, 7.73271220e-03f, -1.92584455e-01f, -4.60120700e-02f, 4.26073372e-02f,
  -1.30124073e-02f, 1.24358892e-01f, -9.35465395e-02f, 1.48952171e-01f, -2.97905039e-02f, 5.58466539e-02f, -1.35354266e-01f, 8.55996758e-02f, 9.48683545e-02f, -1.47935838e-01f,
  -1.87148198e-01f, -1.95112676e-04f, 8.34857076e-02f, -1.71623826e-02f, -1.40301004e-01f, 3.81286331e-02f, 6.07697107e-02f, 7.34630600e-02f, -1.83118805e-02f, 7.89015442e-02f,
  2.00206071e-01f, 6.72523201e-01f, -4.16315459e-02f, -1.64228529e-01f, -1.25571579e-01f, 2.36055091e-01f, -1.12315796e-01f, 1.43491805e-01f, 2.15514451e-01f, 1.43558621e-01f,
  2.44964853e-01f, 5.78837469e-02f, 1.37173399e-01f, 4.30239812e-02f, 2.12181173e-02f, 2.39394009e-01f, -1.82883367e-02f, 2.09558189e-01f, 1.02400720e-01f, 1.55537933e-01f,
  1.31549135e-01f, 1.15369253e-01f, -4.20790091e-02f, 3.42795886e-02f, 1.45221531e-01f, 1.04879551e-02f, 2.16422766e-01f, 4.62837927e-02f, 2.53147837e-02f, 2.43294910e-02f,
  -4.55510467e-01f, -1.03981562e-01f, -7.15514064e-01f, -4.33382809e-01f, 3.49404007e-01f, 3.11982661e-01f, 2.83810616e-01f, 2.37016276e-01f, -3.78876597e-01f, 5.37299871e-01f,
  4.46244955e-01f, -8.20319951e-01f, 5.26332781e-02f, -3.42396080e-01f, -7.32783377e-01f, -4.97209489e-01f, -2.59343624e-01f, -1.95822358e-01f, -3.41861993e-01f, -7.47915544e-03f,
  -2.90987939e-01f, 3.71790886e-01f, -3.74591380e-01f, 6.42109036e-01f, 2.36871585e-01f, -1.77540500e-02f, 5.18581271e-01f, 2.68096656e-01f, 1.96511537e-01f, -1.87624767e-01f,
  7.74879232e-02f, -1.30933717e-01f, -3.29686888e-02f, -8.63779336e-02f, 2.14128032e-01f, 3.97908777e-01f, 1.44321501e-01f, -2.18860731e-01f, -6.18343949e-02f, -1.54921055e-01f,
  2.06096265e-02f, -1.44653887e-01f, -2.67702937e-01f, -1.93063337e-02f, 2.15927675e-01f, 6.94259033e-02f, -1.09316722e-01f, -1.02081344e-01f, -7.88186211e-03f, -2.86238223e-01f,
  -1.67447478e-01f, -1.84834614e-01f, 6.65194495e-03f, -2.43789792e-01f, -5.19665442e-02f, 1.38459196e-02f, -6.19571805e-02f, -4.91636619e-02f, -6.59477189e-02f, -2.47854903e-01f,
  5.82882315e-02f, 1.57245591e-01f, 6.44011125e-02f, 7.64712617e-02f, -2.68667247e-02f, 1.62520215e-01f, 1.57150015e-01f, 2.61980370e-02f, 1.94459036e-02f, 4.84655760e-02f,
  -2.22871639e-02f, -1.68839842e-02f, -3.63156423e-02f, 1.69708177e-01f, -9.73042548e-02f, -2.21581548e-01f, 5.35823517e-02f, 6.63267495e-03f, 1.97968502e-02f, 7.27909580e-02f,
  3.11706960e-02f, -3.89288366e-02f, 1.91487353e-02f, 1.72501355e-01f, -8.12288672e-02f, -1.46816656e-01f, 7.06015229e-02f, -8.46289620e-02f, 9.63716507e-02f, 7.13940635e-02f,
  1.68822750e-01f, -6.84380457e-02f, 7.43441358e-02f, -7.35137165e-02f, -3.41318324e-02f, 9.66835022e-02f, -1.40160974e-02f, -1.70365497e-01f, 8.48732591e-02f, 2.83870418e-02f,
  1.92587078e-01f, 3.04905325e-01f, 1.64792970e-01f, -1.09014034e-01f, -5.01412302e-02f, 8.33111852e-02f, 9.78545919e-02f, -8.85331705e-02f, 1.09371938e-01f, 5.52257597e-02f,
  1.12001985e-01f, 4.70194034e-02f, -1.37222111e-01f, 1.38615265e-01f, 6.64218441e-02f, 1.03784755e-01f, -1.39666721e-02f, 1.26851685e-02f, -6.15759417e-02f, -1.91661626e-01f,
  5.29004037e-01f, 5.59466243e-01f, 3.48894894e-01f, 2.93162704e-01f, -1.06074609e-01f, -6.63023293e-01f, -2.30924979e-01f, -1.28547859e-03f, 2.48716533e-01f, 8.10862780e-02f,
  -4.01627868e-01f, 5.00773668e-01f, 3.57715935e-02f, -1.27140522e-01f, -8.60305607e-01f, -3.86344075e-01f, -5.99600196e-01f, 3.14595401e-02f, 8.98243263e-02f, -2.41809160e-01f,
  -1.73381656e-01f, -7.15253353e-01f, -2.16012031e-01f, -4.07010168e-01f, 9.64226723e-02f, 3.46416980e-01f, -4.48535353e-01f, -4.44072485e-02f, -1.41880468e-01f, 4.53119390e-02f,
  -7.38120228e-02f, 2.69548297e-01f, 2.38302141e-01f, 4.25757058e-02f, -2.73175895e-01f, -3.34515423e-02f, 3.42933089e-02f, 3.07636168e-02f, -9.22400579e-02f, 7.42508173e-02f,
  4.11072038e-02f, -4.86470275e-02f, -5.56793511e-02f, 5.73417954e-02f, 7.60164782e-02f, 1.82260424e-01f, 2.03864798e-01f, 1.06948234e-01f, 1.74316943e-01f, 1.88538060e-01f,
  1.29081920e-01f, 1.80897444e-01f, -1.91716626e-02f, 3.52125801e-02f, 1.11733347e-01f, 1.13874242e-01f, -6.51166141e-02f, 4.82669733e-02f, 3.45289186e-02f, 1.99532703e-01f,
  6.81865513e-02f, -2.43662953e-01f, -1.84474215e-01f, 1.77607268e-01f, -9.69905257e-02f, 6.29843473e-02f, -2.71054339e-02f, -3.37418355e-02f, 5.23752868e-02f, -1.65822357e-01f,
  -6.82199299e-02f, 1.47761554e-01f, -2.03346033e-02f, -1.11591406e-01f, -3.00395489e-02f, 1.13773890e-01f, -1.47486199e-02f, -5.54269040e-03f, -7.91773349e-02f, -6.30488396e-02f,
  -6.57800958e-02f, -2.21106410e-01f, 1.45071462e-01f, 8.20019171e-02f, -1.76273391e-01f, 3.03534642e-02f, 6.69095889e-02f, 6.67203218e-02f, -1.21557415e-02f, -3.06007326e-01f,
  -8.91814649e-01f, -7.64777124e-01f, -7.30961412e-02f, 6.53456431e-03f, -4.28630747e-02f, -1.54691353e-01f, -1.10171355e-01f, 7.11175576e-02f, -1.44044548e-01f, -6.62994683e-02f,
  -1.30776223e-02f, 3.56114842e-02f, -1.33969009e-01f, 5.81494346e-02f, -1.45709470e-01f, -5.63846938e-02f, -1.58766121e-01f, -5.12011461e-02f, -2.02250943e-01f, -1.08078599e-01f,
  6.66278275e-03f, -2.32528355e-02f, -8.64791796e-02f, -5.45220226e-02f, -3.90905663e-02f, -5.79400780e-03f, 2.93376669e-02f, 7.00426623e-02f, -1.33223683e-01f, -1.29398510e-01f,
  3.20229620e-01f, 7.20347762e-01f, -2.03906357e-01f, -1.45547017e-01f, -3.42636704e-01f, -3.38348985e-01f, -5.72118104e-01f, 3.59667726e-02f, -5.56828916e-01f, 4.23918627e-02f,
  4.80472576e-03f, -2.57000417e-01f, 3.43315423e-01f, 2.28199705e-01f, 1.37356922e-01f, 7.15562880e-01f, 2.45152816e-01f, 1.99365437e-01f, 3.51912260e-01f, 4.69102651e-01f,
  4.00897294e-01f, 3.05835187e-01f, 7.66191244e-01f, 3.84036183e-01f, 3.18856299e-01f, 2.34588236e-01f, 3.66724968e-01f, -5.12034493e-03f, 1.29799535e-02f, -2.29507685e-01f,
  1.19121231e-01f, 3.33417147e-01f, -6.02790192e-02f, -6.56913295e-02f, 1.23514555e-01f, -1.38274997e-01f, -1.53571274e-02f, -1.71173006e-01f, -2.08895192e-01f, -1.71790961e-02f,
  -7.29605332e-02f, 3.63391489e-02f, -1.07890368e-01f, -1.48311689e-01f, -2.46005699e-01f, -2.23788336e-01f, 1.86926559e-01f, 1.97801564e-04f, -1.31199971e-01f, 3.77699584e-01f,
  -5.73430676e-03f, -3.09887771e-02f, 1.28585577e-03f, 7.30510950e-02f, -1.19459778e-01f, -2.21165359e-01f, -1.18402667e-01f, -3.80444117e-02f, -1.48671987e-02f, -5.18444516e-02f,
  1.17679030e-01f, -3.14477575e-03f, 1.42042309e-01f, -2.24057119e-02f, 2.75806338e-03f, -3.41592394e-02f, 4.69297692e-02f, 1.03716608e-02f, -7.50033036e-02f, 1.11347280e-01f,
  -2.29809642e-01f, 8.81805457e-03f, -4.88160998e-02f, -2.05095969e-02f, 1.24114491e-01f, 5.10939173e-02f, 4.88835126e-02f, 6.78925067e-02f, -1.74068838e-01f, -3.06839459e-02f,
  -8.38523656e-02f, -1.43226400e-01f, -1.39764890e-01f, 1.56132087e-01f, -5.53228781e-02f, 1.43275550e-02f, 5.93798980e-02f, 9.49939564e-02f, 1.71162024e-01f, 2.94186343e-02f,
  1.19123332e-01f, 4.87471849e-01f, -6.74328879e-02f, -3.04391593e-01f, 9.09181014e-02f, -2.48055886e-02f, 2.02111363e-01f, 1.45270556e-01f, 2.95789894e-02f, -2.28569340e-02f,
  -7.87680298e-02f, -1.20380975e-01f, -1.13767693e-02f, -9.57169682e-02f, -1.41936168e-01f, 3.50533426e-02f, -6.66037723e-02f, -2.04624385e-01f, -2.23616198e-01f, 2.14018911e-01f,
  -1.86891649e-02f, 6.42346544e-03f, -3.63262445e-02f, -1.19278006e-01f, -2.70566512e-02f, -1.76655471e-01f, -1.91201389e-01f, -7.70764202e-02f, 1.08791925e-01f, -1.05606787e-01f,
  7.11517185e-02f, -1.95087522e-01f, -6.56227767e-01f, 1.83884382e-01f, -9.99693945e-02f, 8.52509677e-01f, 3.46972764e-01f, -1.90717131e-01f, -1.15483426e-01f, 5.63785315e-01f,
  1.76564917e-01f, 8.72702822e-02f, -5.92769563e-01f, 8.90661359e-01f, 4.04552400e-01f, 1.25029609e-01f, 7.88541794e-01f, 5.66242278e-01f, -9.25751477e-02f, -2.05216557e-01f,
  -6.73000813e-02f, 8.72165024e-01f, -3.43311876e-01f, 2.01231554e-01f, 4.04038243e-02f, -4.30384725e-01f, 9.85594839e-02f, -5.03585160e-01f, 7.94280529e-01f, 4.22904998e-01f,
  1.82218492e-01f, -9.38680321e-02f, -1.00049384e-01f, 2.04086024e-02f, -1.75156251e-01f, -3.70479934e-02f, 2.64238194e-02f, -1.80247112e-03f, -6.75899386e-02f, -8.21724236e-02f,
  -5.08315936e-02f, 7.06181899e-02f, 3.14789116e-01f, -1.88875366e-02f, -1.69407763e-02f, 9.68058594e-04f, -1.55846193e-01f, -8.30194429e-02f, -1.25133350e-01f, -1.86668649e-01f,
  -2.65955657e-01f, -8.73764083e-02f, 3.00082564e-02f, 1.95836481e-02f, -4.19401452e-02f, -5.48961461e-02f, 1.67676389e-01f, -1.86207503e-01f, 1.37904912e-01f, 1.12902433e-01f,
  -1.91260744e-02f, 1.86614394e-02f, -1.82571914e-02f, 5.41609786e-02f, -4.51065972e-02f, 2.94464119e-02f, 1.04469448e-01f, 9.06691924e-02f, -2.06140041e-01f, 9.88891535e-03f,
  8.82824417e-03f, -6.25301003e-02f, 7.89539516e-02f, 1.01583570e-01f, 5.44910841e-02f, 4.58278321e-02f, -6.12337887e-02f, 1.27602801e-01f, -1.32450268e-01f, -3.00817601e-02f,
  -1.73196882e-01f, 4.02189465e-03f, -4.36767153e-02f, 7.35628381e-02f, 1.56620592e-01f, -1.83091074e-01f, 1.49879053e-01f, -9.19035356e-03f, -1.09868653e-01f, -8.54582787e-02f,
  1.78269818e-01f, -1.05907813e-01f, 1.69752873e-02f, 1.89747751e-01f, -4.43012267e-02f, 7.70735368e-02f, 1.75749153e-01f, 3.42645757e-02f, 6.62737191e-02f, -3.27241753e-04f,
  -2.69304160e-02f, -4.35775109e-02f, 8.83633047e-02f, 1.15024917e-01f, 9.85554531e-02f, -5.73574230e-02f, -3.53107452e-02f, -1.25683949e-03f, 5.84575608e-02f, -3.99859957e-02f,
  -1.06946744e-01f, 3.14216800e-02f, -4.48722094e-02f, 2.61951368e-02f, 1.16503388e-01f, 6.80922791e-02f, 9.13919359e-02f, 3.20918746e-02f, -2.79388707e-02f, -1.36732757e-02f,
  9.27999616e-01f, -2.88518429e-01f, -4.10780013e-02f, 7.22196221e-01f, 2.33470842e-01f, -2.30943397e-01f, -3.75847340e-01f, 4.34334576e-01f, 2.18947887e-01f, -4.28507686e-01f,
  1.02515139e-01f, -4.33384091e-01f, -6.35149121e-01f, 5.34636676e-01f, 5.65168023e-01f, -4.65838283e-01f, 6.57881081e-01f, 1.64480299e-01f, -2.20712498e-02f, 1.50705472e-01f,
  5.22752345e-01f, 6.71718478e-01f, 9.93395522e-02f, 3.05260152e-01f, 3.61178696e-01f, 3.27632993e-01f, 3.31191421e-01f, -4.37601238e-01f, 3.52676392e-01f, 1.50611013e-01f,
  9.56214294e-02f, 7.83805698e-02f, 1.37715280e-01f, 3.41980755e-02f, -1.33076338e-02f, 6.04509450e-02f, -1.20321296e-01f, -1.46428570e-01f, 9.70728789e-03f, -1.84105217e-01f,
  -1.38534844e-01f, 1.14254370e-01f, 1.30353570e-01f, -6.11528121e-02f, 2.11839661e-01f, 1.36035979e-01f, 3.58293913e-02f, -3.86546701e-02f, -6.88342080e-02f, -8.38686004e-02f,
  -1.85778849e-02f, -1.05173187e-02f, 7.64548853e-02f, 1.52738720e-01f, 4.21928056e-02f, 1.56023681e-01f, -2.60476302e-02f, -6.10474423e-02f, -3.40804234e-02f, 1.66194081e-01f,
  7.10933506e-02f, -1.05348855e-01f, -5.34780063e-02f, -3.77085581e-02f, -3.88022251e-02f, -5.48823085e-03f, -6.35064021e-02f, -1.41524330e-01f, 1.21816332e-02f, -6.34749904e-02f,
  7.71169960e-02f, 2.02824131e-01f, 5.72279766e-02f, 9.76608787e-03f, 2.85821855e-02f, 1.33831680e-01f, -1.30360976e-01f, 5.10209054e-02f, 1.29813805e-01f, 2.09298506e-02f,
  6.12656698e-02f, 1.71997786e-01f, -2.13244841e-01f, 3.39036761e-03f, 3.27939242e-02f, -1.99065834e-01f, 9.99536291e-02f, 4.43239175e-02f, -1.27493411e-01f, -1.73795801e-02f,
  -1.06868111e-01f, 9.36342776e-02f, -1.33596629e-01f, 7.15370998e-02f, -1.32080957e-01f, 1.52560666e-01f, -3.40044498e-02f, 2.05822289e-01f, 3.84367518e-02f, 1.40184443e-02f,
  1.42371640e-01f, -5.28601110e-02f, -1.49629772e-01f, -1.51966829e-02f, 4.95307148e-02f, 1.79913845e-02f, 6.48673400e-02f, 9.04986858e-02f, 1.63492158e-01f, 6.58948570e-02f,
  2.83467956e-02f, -2.86024392e-01f, 6.77230358e-02f, 4.24379483e-02f, 7.81652033e-02f, -1.24900497e-01f, -4.36301976e-02f, 1.50871305e-02f, 2.84088459e-02f, 4.67399647e-03f,
  3.37067544e-01f, -5.23505390e-01f, -1.00284116e-02f, -4.10445601e-01f, 4.77309853e-01f, -1.45315275e-01f, -3.56871307e-01f, -2.77643353e-01f, 3.03347725e-02f, -6.84140265e-01f,
  -3.31037283e-01f, -4.29537028e-01f, -6.32462874e-02f, -3.66922557e-01f, 4.42101508e-01f, 3.28324586e-01f, -3.43676239e-01f, -4.68489289e-01f, 1.38359800e-01f, -1.18256703e-01f,
  1.92986466e-02f, -9.03748870e-02f, 1.42416626e-01f, -2.35129669e-01f, -1.06903337e-01f, -2.78616220e-01f, -2.07395747e-01f, 1.30698889e-01f, -4.97842371e-01f, 2.85576750e-02f,
  1.63453475e-01f, 2.21815139e-01f, 1.09255783e-01f, 4.57778014e-02f, -2.62018312e-02f, 1.02862477e-01f, -1.98743463e-01f, 1.30501941e-01f, 2.26756349e-01f, 2.10127160e-02f,
  -1.65965632e-01f, -4.60673980e-02f, -1.59535781e-01f, 1.50049135e-01f, 9.05875936e-02f, -2.33995412e-02f, 1.43560022e-01f, -4.72312123e-02f, -3.97666544e-02f, 1.42054548e-02f,
  1.14448674e-01f, 2.75206752e-02f, 1.35235384e-01f, -2.95349211e-01f, -5.74638397e-02f, -2.56207548e-02f, -9.99144185e-03f, -9.30010900e-02f, -1.04853965e-01f, -6.67484924e-02f,
  -1.58056002e-02f, -7.00699389e-02f, 1.10190347e-01f, 8.26523602e-02f, 7.49936029e-02f, 1.84065849e-02f, 8.02518129e-02f, -7.12626129e-02f, -5.26343323e-02f, -1.43220574e-01f,
  -5.97657487e-02f, -1.40402466e-01f, 1.87023029e-01f, -1.03393994e-01f, -3.48772071e-02f, 6.61783814e-02f, 6.54285599e-04f, -7.95744658e-02f, -1.02058657e-01f, -6.90586194e-02f,
  2.99227312e-02f, -7.55779520e-02f, 9.73092318e-02f, -1.64173380e-01f, 1.40262008e-01f, 4.74398471e-02f, -1.25395060e-01f, 5.01084216e-02f, 2.28375625e-02f, 5.40287755e-02f,
  -2.37056509e-01f, -3.62961650e-01f, 5.27558587e-02f, -3.54512073e-02f, -1.47993848e-01f, 2.11263388e-01f, -8.24321881e-02f, -1.78198397e-01f, -2.20287502e-01f, 6.09200262e-02f,
  -1.60081729e-01f, -2.52197403e-02f, 2.60905419e-02f, 3.42897959e-02f, -7.64868185e-02f, 3.36688645e-02f, -2.87156075e-01f, 4.55418117e-02f, -2.82171756e-01f, -3.66505712e-01f,
  -1.29099131e-01f, -1.20427437e-01f, -1.58566851e-02f, -2.42513185e-03f, -1.52860150e-01f, -2.10350722e-01f, 6.26657158e-02f, 2.69418731e-02f, -1.21673018e-01f, 1.79533183e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  7.01607823e-01f, 6.72983110e-01f, 9.04505849e-01f, 7.64483154e-01f, 6.59289718e-01f, 8.19342434e-01f, 8.49556148e-01f, 5.26518524e-01f, 8.97635520e-01f, 4.56342191e-01f,
  5.34058094e-01f, 5.68288863e-01f, 5.65756261e-01f, 9.35041428e-01f, 8.54588985e-01f, 5.28070450e-01f, 2.94345170e-01f, 5.16868830e-01f, 3.87192786e-01f, 6.66417480e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -7.23694444e-01f, -6.41261220e-01f, -8.87200236e-01f, 1.76768690e-01f, -5.75259104e-02f, -2.60795265e-01f, 1.02540106e-02f, 1.18860729e-01f, 3.72002453e-01f, -4.86333489e-01f,
  -2.20758356e-02f, 8.66857231e-01f, -6.05572045e-01f, 4.20840323e-01f, -7.43885577e-01f, -2.38375485e-01f, 7.40198255e-01f, 5.45104146e-01f, 5.35377450e-02f, -5.81880331e-01f,
  -6.74448252e-01f, -5.22678792e-01f, -1.05732453e+00f, 4.39998567e-01f, -5.46271741e-01f, -4.74294156e-01f, 2.38697335e-01f, -2.88885117e-01f, 2.90122300e-01f, 4.91944313e-01f,
  -1.10969651e+00f, -7.87861884e-01f, -9.15186524e-01f, 2.38169909e-01f, 6.58985734e-01f, -5.59742332e-01f, 9.57126468e-02f, -2.47288607e-02f, 6.12460256e-01f, 5.54957271e-01f,
  -4.93848056e-01f, -6.05326235e-01f, -9.42308664e-01f, -1.13841677e+00f, -7.85214603e-01f, 2.07572147e-01f, 4.54952002e-01f, -1.28553569e+00f, -9.62473810e-01f, 3.49018782e-01f,
  -9.07716095e-01f, -6.89978600e-01f, -1.04601908e+00f, -1.22427690e+00f, 1.23018876e-01f, 4.21571046e-01f, -1.22134529e-01f, 2.10971102e-01f, -1.87098831e-02f, -5.11781275e-01f,
  4.24646109e-01f, 7.62411237e-01f, 1.16127715e-01f, 2.69208342e-01f, 3.23142737e-01f, -6.01409197e-01f, -3.81923795e-01f, -2.33900130e-01f, 2.51146615e-01f, -4.51658756e-01f,
  -2.67156929e-01f, -3.82216096e-01f, -9.52031761e-02f, 6.14787281e-01f, -1.07424974e-01f, -5.20932257e-01f, 4.04728740e-01f, -1.43861279e-01f, 1.94178581e-01f, -4.25456077e-01f,
  -5.51526248e-01f, -3.06931287e-01f, -2.41412222e-01f, -4.80257601e-01f, -7.07890928e-01f, 5.52401721e-01f, -9.44072008e-01f, -1.20660961e-01f, -3.90285283e-01f, -4.59585637e-01f,
  -1.15885390e-02f, -5.77236772e-01f, -9.69559073e-01f, 7.73268580e-01f, 7.75438726e-01f, -7.84265399e-02f, 7.34242797e-03f, 2.08429322e-01f, 5.36290705e-01f, -5.53266108e-01f,
  5.71276583e-02f, -3.23737532e-01f, 4.55965847e-01f, 2.57477432e-01f, 3.49735647e-01f, 1.27567559e-01f, 3.03488940e-01f, 2.79315978e-01f, -4.67253149e-01f, -6.22845769e-01f,
  -1.05237377e+00f, -3.39521945e-01f, -1.00057662e-01f, -7.82438576e-01f, 6.61559582e-01f, 9.26744223e-01f, -1.13420558e+00f, -4.49879736e-01f, 2.08821401e-01f, 5.81515372e-01f,
  -7.61205316e-01f, -7.41264403e-01f, 2.38151088e-01f, 5.19127786e-01f, -2.76009321e-01f, -4.51304555e-01f, -2.71441489e-01f, 3.38036537e-01f, 4.80413318e-01f, -3.27590972e-01f,
  -3.17397803e-01f, 4.25692588e-01f, 3.96052361e-01f, 6.86738431e-01f, 3.27697814e-01f, 6.67311430e-01f, 5.86809814e-01f, 9.10849810e-01f, 1.09395973e-01f, -4.71848965e-01f,
  7.89782628e-02f, 1.09785509e+00f, -5.08835018e-01f, 4.08456713e-01f, 3.58105272e-01f, -1.41124403e+00f, -8.15390870e-02f, 5.97246774e-02f, 2.02999055e-01f, 1.28292799e-01f,
  1.41332179e-01f, -3.70440215e-01f, -9.01753187e-01f, -4.10326123e-01f, -1.53416738e-01f, -1.94308251e-01f, 4.89740759e-01f, -8.45703661e-01f, -8.23493361e-01f, 4.44913059e-01f,
  5.02159834e-01f, 1.09552927e-01f, 1.13954842e-01f, -2.08965912e-01f, 3.39519322e-01f, 5.44082701e-01f, 7.58172154e-01f, 4.18914378e-01f, 5.22541285e-01f, -7.46256769e-01f,
  1.11094856e+00f, 4.18371409e-01f, -6.84997082e-01f, -2.33205780e-01f, -4.68486920e-02f, 5.00617146e-01f, -1.45311415e-01f, 5.54298639e-01f, -5.36301374e-01f, 3.25176954e-01f,
  4.14858401e-01f, -4.93247390e-01f, 7.42655516e-01f, -6.98777318e-01f, 4.18703914e-01f, 3.88558626e-01f, -9.03030992e-01f, -1.18019128e+00f, -3.77845824e-01f, 2.41191629e-02f,
  -2.85615325e-01f, -7.95114160e-01f, -3.12337130e-01f, 1.09672494e-01f, 1.68340549e-01f, -2.13400036e-01f, -1.92529231e-01f, -3.39508265e-01f, -6.68571055e-01f, -1.02979392e-01f,
  -7.04005420e-01f, 1.82024445e-02f, -5.03916681e-01f, -3.82818162e-01f, 7.34953165e-01f, -9.46889162e-01f, -1.00877464e+00f, -5.34450352e-01f, -9.51213300e-01f, 5.98451555e-01f,
  -7.31472969e-01f, -8.56287241e-01f, 4.42368478e-01f, -1.92445517e-01f, 5.07697761e-01f, -7.43181109e-01f, 4.28796440e-01f, -9.37145889e-01f, 1.91663042e-01f, 1.88432842e-01f,
  -3.93582195e-01f, -6.20747745e-01f, 4.57953930e-01f, 4.62220043e-01f, -5.02605915e-01f, -2.51524448e-01f, -9.65681206e-03f, -2.12811500e-01f, -4.61341262e-01f, -1.22552916e-01f,
  -2.30458543e-01f, -4.08655882e-01f, -3.50206405e-01f, 5.04736722e-01f, 7.88120329e-02f, 4.50157791e-01f, -6.42780662e-01f, -6.85066283e-01f, 2.41256282e-01f, 1.46421254e-01f,
  4.66365427e-01f, -6.62899613e-01f, -6.92824423e-01f, 5.77910781e-01f, -1.10904858e-01f, -2.63527244e-01f, -6.98506460e-02f, -6.06990397e-01f, 6.79820478e-01f, -5.79068482e-01f,
  -7.81999409e-01f, 2.79165894e-01f, 1.49357945e-01f, -3.66233647e-01f, -5.60972571e-01f, 4.47700799e-01f, 1.71575397e-01f, 1.58470757e-02f, 4.39730138e-02f, 4.56306338e-02f,
  -2.37609133e-01f, 7.45025501e-02f, 3.67395371e-01f, -3.91811788e-01f, -3.14976990e-01f, -3.89397681e-01f, 5.57352722e-01f, 5.98513782e-01f, 1.05410390e-01f, -7.00227618e-01f,
  -2.75229186e-01f, 3.40958327e-01f, -4.32799727e-01f, -5.31638920e-01f, -6.76414192e-01f, -1.92870557e-01f, -6.27635479e-01f, 5.15107751e-01f, -6.16106868e-01f, 6.75561726e-01f,
  6.69744685e-02f, 2.70841897e-01f, -7.02796221e-01f, -3.88394386e-01f, 4.74517167e-01f, -6.77944124e-01f, 4.34324682e-01f, -8.07165742e-01f, 1.28534675e-01f, 1.54791594e-01f,
  -6.68830425e-02f, 4.11534935e-01f, -2.95958251e-01f, -1.01191849e-01f, -6.47325039e-01f, -6.09312356e-01f, 3.75919461e-01f, -6.91166580e-01f, -6.74696207e-01f, -4.62344736e-01f,
  -3.23043346e-01f, -5.42379797e-01f, 8.08818161e-01f, -4.61292535e-01f, 7.90138960e-01f, 1.97432443e-01f, -2.77289033e-01f, -8.00655425e-01f, 6.21255279e-01f, 7.24864602e-01f,
  -7.31541634e-01f, -2.61568695e-01f, -5.21064699e-01f, -3.07963043e-01f, -6.20473444e-01f, -5.75186670e-01f, -7.28872836e-01f, -5.84666252e-01f, -1.04733837e+00f, 4.32412773e-01f,
  4.66357738e-01f, 3.65914375e-01f, -4.81213272e-01f, -3.69643494e-02f, 3.64598870e-01f, 1.13504857e-01f, 3.33647162e-01f, -7.02160478e-01f, -7.17845380e-01f, 6.18573248e-01f,
  -5.60159266e-01f, 3.82999241e-01f, -6.25256717e-01f, -4.80840296e-01f, 4.80395168e-01f, -1.62291244e-01f, -6.33729815e-01f, -8.49477112e-01f, 3.50801915e-01f, -7.24229634e-01f,
  -6.25675559e-01f, -4.18252677e-01f, 2.68733362e-03f, -1.04009034e-02f, 4.91497606e-01f, 5.12286782e-01f, 1.02723002e+00f, -6.02624118e-01f, -3.52091312e-01f, -3.03632647e-01f,
  -6.74023688e-01f, -7.70281434e-01f, -4.20842439e-01f, 2.57662416e-01f, 3.85744214e-01f, 1.12619728e-01f, -1.12872370e-01f, 2.95629978e-01f, -6.29278243e-01f, -2.59897619e-01f,
  -2.62973160e-01f, -3.93214673e-01f, 4.11201358e-01f, -4.19192016e-01f, 5.73826551e-01f, -3.96056384e-01f, -3.32682550e-01f, 5.81746995e-01f, -6.73900962e-01f, -3.43428403e-01f,
  5.44966578e-01f, -5.35733737e-02f, 4.54393923e-02f, -7.60856152e-01f, -7.48363018e-01f, -7.98500121e-01f, -5.37886679e-01f, 6.02746606e-01f, -8.01913977e-01f, 9.40092385e-01f,
  -4.67610732e-02f, -5.24710000e-01f, -4.19561297e-01f, -7.18739331e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.61381841e-01f, -9.30283889e-02f, -4.38914113e-02f, -2.09169790e-01f, 2.47481421e-01f, -9.76881385e-02f, 5.87207824e-02f, -1.10247798e-01f, -6.99467286e-02f, 5.19331917e-03f,
  1.86969906e-01f, -3.18037085e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    