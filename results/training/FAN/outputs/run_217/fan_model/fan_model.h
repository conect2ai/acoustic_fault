/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.39053029e-01f, -2.05109984e-01f, -2.40728974e-01f, -1.13760300e-01f, 2.76282609e-01f, -1.25749409e-01f, -3.29699904e-01f, 2.51417905e-01f, 3.14707696e-01f, -4.85066026e-02f,
  1.19955219e-01f, -1.74152762e-01f, -1.74885079e-01f, -2.24403273e-02f, 5.34209758e-02f, -2.12375417e-01f, 1.60872728e-01f, -1.35458142e-01f, 3.10176518e-02f, -6.01606735e-04f,
  8.04897547e-02f, 8.86109695e-02f, -2.62387216e-01f, 4.47860323e-02f, 4.95808311e-02f, -6.56570718e-02f, -4.82463092e-02f, -1.88670531e-01f, -5.65011613e-02f, -4.71243672e-02f,
  2.68005244e-02f, 3.88027057e-02f, -3.58594805e-02f, -4.54233587e-02f, -2.38448828e-02f, -2.25222781e-02f, -1.06378354e-01f, -1.20490640e-01f, 7.36437663e-02f, -2.37640310e-02f,
  -9.00388360e-02f, 3.43250446e-02f, 1.44724576e-02f, -1.96301015e-04f, 9.10428092e-02f, 6.92123026e-02f, 1.10013127e-01f, 6.11465648e-02f, 1.44195249e-02f, 3.25011909e-02f,
  4.64100167e-02f, 9.14875790e-02f, 5.07796519e-02f, -1.01479851e-01f, 7.27295578e-02f, -7.90412724e-03f, -8.45625848e-02f, -9.43397507e-02f, 3.82034518e-02f, 6.48250356e-02f,
  8.21339190e-02f, -4.20375988e-02f, -3.64117622e-02f, 3.35998349e-02f, -3.88070457e-02f, 6.96818903e-02f, -1.66294780e-02f, -2.93335803e-02f, -2.29009781e-02f, 9.44198575e-04f,
  1.57322250e-02f, -2.00747643e-02f, 2.59011593e-02f, 5.08305430e-02f, -2.12216210e-02f, 7.89968967e-02f, -3.65706757e-02f, -1.57619007e-02f, 5.47652282e-02f, 3.54086347e-02f,
  -9.78047587e-03f, 7.06936326e-03f, -6.93849288e-04f, 1.83394719e-02f, 1.69192795e-02f, -5.16906418e-02f, 3.24601866e-02f, -5.11259586e-02f, -1.49082160e-02f, -5.22125065e-02f,
  -1.10721298e-01f, -1.27485186e-01f, 3.18104110e-04f, 7.95826092e-02f, -5.27999550e-02f, 7.54607245e-02f, -1.08816093e-02f, 5.88997900e-02f, -5.93365282e-02f, 8.24034028e-03f,
  6.12725019e-02f, -5.98900169e-02f, -2.85882261e-02f, -6.14049612e-03f, -7.21701458e-02f, -7.03999214e-03f, -1.04920998e-01f, 3.29270102e-02f, 1.94471180e-02f, 7.63103366e-02f,
  1.02858832e-02f, 3.02278977e-02f, -7.54775032e-02f, 1.03282221e-01f, -3.89882475e-02f, 2.83300728e-02f, 1.42264413e-02f, -2.81763021e-02f, 1.15379086e-02f, -8.12131390e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.28047466e-01f, -2.49280408e-01f, -2.36536190e-01f, 1.86115559e-02f, 1.17147848e-01f, -4.72569525e-01f, -7.12013543e-01f, 5.09394258e-02f, -5.71452200e-01f, -5.27549386e-02f,
  4.35272716e-02f, -5.95089458e-02f, -2.52080947e-01f, -1.56770602e-01f, 1.01311445e-01f, -4.45530832e-01f, 2.85567194e-02f, 2.46954467e-02f, 1.68781728e-02f, 1.64340928e-01f,
  3.29395175e-01f, 3.81339341e-01f, 1.96218506e-01f, 4.02504444e-01f, -3.77938226e-02f, 4.17611480e-01f, 8.30656350e-01f, -7.27375597e-03f, 4.14907068e-01f, 1.29369095e-01f,
  -2.27615550e-01f, -1.78270951e-01f, -3.81416380e-02f, -7.28747398e-02f, 1.77497745e-01f, 3.26887891e-02f, 7.89680555e-02f, -1.19665444e-01f, 1.70208979e-02f, -3.64294723e-02f,
  3.29870991e-02f, 9.65452343e-02f, -7.96475541e-03f, 6.97507635e-02f, -5.77297285e-02f, -3.21348533e-02f, -6.26414642e-02f, -6.11115210e-02f, -1.57109007e-01f, -2.56722569e-02f,
  -5.50304959e-03f, -2.70538423e-02f, -1.40185244e-02f, 4.90706377e-02f, -8.66072997e-02f, 2.89093051e-02f, 5.03425195e-04f, -6.32465333e-02f, 6.30997047e-02f, 5.68688922e-02f,
  1.27903953e-01f, 7.52995396e-03f, 3.78389172e-02f, 3.88690196e-02f, 6.52856007e-02f, -7.34781325e-02f, -4.86047268e-02f, -4.13487777e-02f, 5.98223805e-02f, 5.17904945e-02f,
  3.21535133e-02f, 5.64224198e-02f, 2.48524621e-02f, -1.58505179e-02f, 6.71725050e-02f, -8.09531251e-04f, 1.29827708e-02f, 6.48998376e-03f, 4.18353938e-02f, -3.67109776e-02f,
  -3.66393775e-02f, 8.44967142e-02f, -4.65427414e-02f, -5.67776226e-02f, -5.34431636e-02f, 8.90012772e-04f, 6.40582591e-02f, 1.38222538e-02f, 1.33348163e-02f, 7.12142438e-02f,
  9.52470005e-02f, 3.56783628e-01f, -1.43706769e-01f, -1.36670219e-02f, 1.47563601e-02f, -5.45896292e-02f, 4.83303145e-02f, 1.34314984e-01f, 8.69346559e-02f, -2.12568063e-02f,
  1.17325604e-01f, -3.00616417e-02f, 1.23842858e-01f, -5.45511954e-02f, 1.31672844e-01f, 1.00245468e-01f, 8.62614363e-02f, 1.16495132e-01f, 1.64013669e-01f, 1.76034212e-01f,
  8.22307840e-02f, -3.65355760e-02f, 2.00996678e-02f, -1.38584584e-01f, 9.70822573e-02f, 2.01423690e-02f, 5.47828190e-02f, 3.51558141e-02f, 1.25403926e-01f, -3.90295126e-02f,
  4.99002665e-01f, -5.38066216e-02f, -1.24382623e-01f, -1.87575638e-01f, 1.27154142e-01f, 2.28988618e-01f, 3.63506451e-02f, -4.44379821e-02f, -3.80058348e-01f, -4.86921556e-02f,
  -9.09490436e-02f, -1.39482617e-01f, -1.18106946e-01f, -1.17821597e-01f, -1.05010904e-01f, -1.61326513e-01f, 1.15500938e-03f, -8.33556652e-02f, -7.11667985e-02f, 1.57724053e-01f,
  -8.25532377e-02f, 6.95892200e-02f, -2.11649925e-01f, 8.49842355e-02f, 1.26535207e-01f, -1.39207393e-02f, -9.66343936e-03f, -4.27648379e-03f, -3.57178859e-02f, 1.61181053e-03f,
  4.16099876e-02f, -3.58313397e-02f, 3.41789201e-02f, 1.62826888e-02f, -4.94363979e-02f, 1.31306171e-01f, 8.85536075e-02f, 2.78032962e-02f, -1.28867611e-01f, -1.10045359e-01f,
  3.82258743e-02f, -1.51275322e-02f, 6.92762136e-02f, -1.14462279e-01f, 7.14531988e-02f, 1.39349196e-02f, -1.55400801e-02f, -2.22089048e-02f, -5.98140471e-02f, 8.75513162e-03f,
  -5.26198745e-02f, 4.25855257e-02f, -3.95090915e-02f, 3.99741791e-02f, -6.42742813e-02f, -1.25457853e-01f, -5.46995290e-02f, 5.66603020e-02f, 4.18101288e-02f, -4.78615835e-02f,
  1.60573244e-01f, 8.58518556e-02f, 1.29198566e-01f, -5.95766865e-02f, -4.23664749e-02f, -1.11806020e-01f, 2.83847656e-02f, -6.69140294e-02f, -6.88351807e-04f, -5.66969290e-02f,
  2.19154768e-02f, -8.47688243e-02f, 2.76950444e-03f, 2.29113307e-02f, 3.38999406e-02f, -4.55975868e-02f, -1.70988627e-02f, 2.50360556e-02f, -1.98987275e-02f, -7.06615821e-02f,
  -7.70243555e-02f, -1.23182870e-01f, 2.83128885e-03f, 6.42487705e-02f, 6.89460486e-02f, 2.88706776e-02f, -2.14004871e-02f, -5.13575561e-02f, -7.79551864e-02f, 2.37115920e-02f,
  2.35739388e-02f, 9.07874107e-02f, -1.22068701e-02f, 2.35045999e-02f, 4.07094210e-02f, 2.26480141e-02f, -5.62468953e-02f, 1.05309099e-01f, -4.87730131e-02f, 7.89868236e-02f,
  1.21239536e-01f, 2.37359218e-02f, 1.55351475e-01f, -5.71556650e-02f, -2.34958958e-02f, 1.91141926e-02f, 8.57182816e-02f, 5.17327040e-02f, -4.06420976e-02f, 5.27218394e-02f,
  -2.23646928e-02f, 8.49010050e-02f, 4.47465526e-03f, 6.14455678e-02f, -6.83431746e-03f, 1.14910409e-01f, 5.20626232e-02f, 1.21351026e-01f, 1.37225285e-01f, -4.73746546e-02f,
  -3.21580470e-01f, 2.64318466e-01f, -5.36588967e-01f, 1.99479327e-01f, -6.06910475e-02f, 3.49100947e-01f, 2.85738289e-01f, 1.36154905e-01f, 1.54615398e-02f, 4.20381963e-01f,
  3.14411551e-01f, -1.96171343e-01f, -3.58134434e-02f, 6.30152643e-01f, -3.33758220e-02f, 2.81946838e-01f, 6.66366339e-01f, 3.73187423e-01f, 2.38926336e-02f, 9.87753719e-02f,
  9.40173864e-03f, 5.42391658e-01f, 2.11605564e-01f, 3.22359592e-01f, 9.14644226e-02f, -2.55152375e-01f, 1.73526704e-01f, -1.76852688e-01f, 2.39158809e-01f, 2.15442151e-01f,
  1.39311418e-01f, -1.23717599e-01f, -1.77675545e-01f, -7.33151510e-02f, 4.70522493e-02f, -8.43642652e-02f, -1.01450205e-01f, -8.24253783e-02f, -1.32734865e-01f, 6.39987364e-03f,
  -1.20888315e-01f, -1.12320833e-01f, 4.30458598e-02f, -9.05595627e-03f, 1.71962380e-03f, -1.87826484e-01f, -9.00786370e-02f, -1.25534814e-02f, -4.67199422e-02f, -3.82382646e-02f,
  -1.23550996e-01f, 3.81308631e-03f, -4.92928214e-02f, 1.28918933e-02f, -1.34053215e-01f, 1.24652134e-02f, 6.03779554e-02f, -8.95946547e-02f, 2.17004330e-03f, 3.17913145e-02f,
  3.83758917e-02f, -2.61550397e-02f, -2.29149088e-02f, 5.29960915e-02f, -1.16696255e-02f, 2.75290720e-02f, 6.73368797e-02f, 4.11174744e-02f, -5.03482260e-02f, -1.48124285e-02f,
  6.19760416e-02f, -3.71459238e-02f, 3.05865481e-02f, -5.21672405e-02f, -3.45700560e-03f, 8.58674347e-02f, -3.69296744e-02f, -4.59866710e-02f, -4.23321538e-02f, -1.45290215e-02f,
  4.08174843e-02f, -1.57264713e-02f, 6.97455406e-02f, 9.18764025e-02f, 4.84345257e-02f, -4.76887822e-02f, 9.16419551e-02f, 8.29667598e-03f, -3.66104729e-02f, -4.18256074e-02f,
  2.47055396e-01f, 2.90239491e-02f, 7.03518167e-02f, -1.98162589e-02f, 5.45176491e-02f, 5.06955981e-02f, 7.55669177e-02f, 3.41302566e-02f, -3.18781510e-02f, 1.59026682e-02f,
  -1.06242448e-02f, 3.80563922e-02f, -5.92546351e-02f, -3.09793521e-02f, 1.99771132e-02f, 1.49090320e-01f, 2.93885265e-02f, -3.05911973e-02f, 2.78800745e-02f, -1.88965481e-02f,
  1.41816474e-02f, -8.36046711e-02f, -3.99277508e-02f, 5.16543770e-03f, 3.26837488e-02f, -6.30115643e-02f, -1.58212990e-01f, -7.61646628e-02f, -5.73853441e-02f, 4.91781160e-02f,
  -4.34795886e-01f, 8.82357508e-02f, -3.79321128e-02f, 3.99998650e-02f, -3.61768878e-03f, 4.22854185e-01f, 4.54509228e-01f, 2.35461872e-02f, 3.32267225e-01f, 1.63688943e-01f,
  -4.61586490e-02f, 2.74598598e-02f, 9.60648805e-02f, 7.92394057e-02f, 2.63357520e-01f, 2.95633644e-01f, 2.28535995e-01f, 6.55331761e-02f, 2.09548436e-02f, -2.31957324e-02f,
  -1.04598522e-01f, 2.73519494e-02f, -9.09868926e-02f, -2.77744263e-01f, -2.01031208e-01f, -3.19195300e-01f, -2.09066480e-01f, -2.85162739e-02f, -1.63556442e-01f, 4.18893248e-02f,
  -1.46000972e-02f, -1.67409122e-01f, -5.01116551e-02f, 8.27855766e-02f, -1.98700652e-02f, -6.18232638e-02f, -2.21918686e-04f, -1.64436121e-02f, 6.17799424e-02f, 3.47453989e-02f,
  8.95131603e-02f, -7.41157606e-02f, 8.17474164e-03f, 4.86478135e-02f, 4.14503925e-02f, -3.78517583e-02f, -4.00221534e-02f, 2.18671211e-03f, 5.09255901e-02f, 2.12070323e-03f,
  5.15203588e-02f, 1.87456626e-02f, -2.59232670e-02f, -1.37035623e-02f, -4.07413282e-02f, 2.12032292e-02f, 7.34495819e-02f, -3.61016486e-03f, -1.24580776e-02f, 1.24999939e-03f,
  -1.55991530e-02f, -1.03035020e-02f, 2.48123631e-02f, 1.31232839e-03f, 5.19073522e-03f, -1.03559792e-01f, -1.29248770e-02f, -2.21791659e-02f, 1.61601566e-02f, 2.98035648e-02f,
  -3.96851887e-04f, 1.42086437e-02f, 7.32735023e-02f, 6.80234879e-02f, 1.04095258e-01f, -3.19852121e-02f, -1.19932964e-02f, -7.47486129e-02f, 7.21372291e-02f, 4.29630950e-02f,
  1.08960900e-03f, 2.61970516e-02f, -3.80358323e-02f, -9.49396659e-03f, -3.34804170e-02f, -2.57313102e-02f, -5.43661602e-02f, -6.04756139e-02f, -6.78308262e-03f, -2.47467626e-02f,
  8.08640569e-02f, 1.25070304e-01f, -2.48958971e-02f, -3.74409333e-02f, 1.70192085e-02f, -1.34337007e-03f, -5.93975931e-02f, -4.51839119e-02f, 5.03789037e-02f, 1.51399039e-02f,
  2.79922015e-03f, -7.06806928e-02f, 1.49203008e-02f, -1.02347411e-01f, -2.58773956e-02f, 1.11268193e-01f, 2.82008592e-02f, 6.37498721e-02f, 8.66357237e-02f, -9.34871659e-02f,
  -5.89723401e-02f, 3.70861478e-02f, -1.61382779e-02f, -7.64826983e-02f, -2.60924734e-02f, -1.41732069e-02f, -2.23586895e-02f, -1.38678448e-03f, -1.72512699e-02f, -1.34742474e-02f,
  -7.22083390e-01f, 3.45818251e-01f, -7.41116032e-02f, -6.71974778e-01f, 1.74238503e-01f, -2.35342264e-01f, -4.34688479e-01f, 2.38560438e-02f, -1.19590253e-01f, -1.53895602e-01f,
  -2.65388697e-01f, -1.27153620e-01f, 1.47104695e-01f, -2.36714467e-01f, -1.15793101e-01f, 3.42491008e-02f, -2.08859921e-01f, -3.18561584e-01f, 4.19246554e-01f, -1.97053537e-01f,
  -8.48189890e-02f, -6.36454150e-02f, 3.48092876e-02f, 4.60211754e-01f, -1.98869720e-01f, -5.05141318e-02f, -6.80315569e-02f, 2.20727772e-01f, -2.65974700e-01f, 2.72870213e-01f,
  4.61893417e-02f, -1.08187251e-01f, -1.17120631e-01f, 1.10047860e-02f, -5.44734821e-02f, -1.17360204e-01f, -6.76651224e-02f, -6.24748580e-02f, -9.10019875e-02f, 5.38609773e-02f,
  6.29981756e-02f, 3.59126702e-02f, 1.70563497e-02f, 8.42651129e-02f, -2.09467839e-02f, 4.10063826e-02f, 9.04552490e-02f, -3.69090540e-03f, -1.09131855e-03f, 8.08717087e-02f,
  5.77605926e-02f, -4.59343307e-02f, -1.97236031e-01f, -8.72934461e-02f, -3.77392620e-02f, 4.52192202e-02f, -7.34462067e-02f, 5.19901095e-03f, -1.47798453e-02f, -2.15971824e-02f,
  2.21576598e-02f, -1.50088472e-02f, 2.13088281e-02f, 8.88953432e-02f, -4.23894674e-02f, 2.50479449e-02f, -7.32712895e-02f, -4.07179445e-02f, -2.11960413e-02f, -1.24535285e-01f,
  -1.59693081e-02f, -9.71629471e-03f, 4.26820554e-02f, -6.44002110e-02f, -2.34306343e-02f, -3.63602042e-02f, -5.94832562e-02f, -3.12086605e-02f, 7.86587074e-02f, 6.64575696e-02f,
  -5.92721514e-02f, -2.41470616e-02f, 1.96977686e-02f, -4.19018976e-03f, -6.99098632e-02f, 1.59255471e-02f, 8.32320899e-02f, -3.79292108e-02f, 2.76317764e-02f, 3.71036306e-02f,
  -1.47293031e-01f, -3.47821176e-01f, 2.57157832e-02f, 1.09130833e-02f, 3.67420446e-03f, -6.41242862e-02f, 4.47612964e-02f, 5.27032278e-02f, -1.38009876e-01f, -3.79561745e-02f,
  -4.89193723e-02f, -1.15028292e-01f, 3.99098324e-04f, -1.01443216e-01f, 1.46880493e-01f, -2.05458552e-02f, -1.09197289e-01f, -7.14395270e-02f, -7.97456652e-02f, 1.80540197e-02f,
  8.23559519e-03f, 9.81607754e-03f, 3.38073857e-02f, -9.42487363e-03f, -7.46115223e-02f, -1.47712484e-01f, -4.65140752e-02f, 4.90391068e-02f, 5.33096045e-02f, -2.09794976e-02f,
  -9.33469534e-02f, 3.12579155e-01f, 1.72331750e-01f, 2.26982106e-02f, 7.08939731e-02f, -1.51092187e-01f, -5.89259118e-02f, 1.57165397e-02f, -6.45141080e-02f, 1.59753248e-01f,
  -6.55979440e-02f, 2.67546803e-01f, -1.32948890e-01f, -5.73179387e-02f, -5.52557111e-01f, -3.68714124e-01f, -1.25528332e-02f, 3.76102291e-02f, -7.62164444e-02f, 4.07456569e-02f,
  -1.43744186e-01f, -3.27954292e-02f, -2.08873674e-01f, -3.78197171e-02f, 1.69161856e-01f, 1.91313267e-01f, -5.46611249e-02f, 1.90518480e-02f, 4.18903604e-02f, 3.95679735e-02f,
  -6.16322793e-02f, -1.39143229e-01f, 1.00945950e-01f, -1.98234450e-02f, -4.90342341e-02f, 7.69964606e-02f, 1.59320518e-01f, -6.91925362e-02f, -2.11416185e-03f, -3.37086432e-02f,
  1.62120774e-01f, -3.72555703e-02f, 8.05069059e-02f, 3.48631432e-03f, -8.04007112e-04f, 4.25854027e-02f, 1.41601190e-01f, 1.04610600e-01f, 7.28395954e-02f, 1.27552018e-01f,
  9.54781398e-02f, 1.09629162e-01f, 7.60567710e-02f, -4.49562743e-02f, -5.49730025e-02f, 1.10075012e-01f, 4.24512550e-02f, 1.14420533e-01f, 5.66029139e-02f, 4.50520497e-03f,
  5.05511370e-03f, -9.10554454e-02f, 3.50143723e-02f, 6.17168397e-02f, 3.24353054e-02f, -5.67157567e-02f, 7.41417408e-02f, -1.02453902e-01f, -3.08338590e-02f, 9.51804686e-03f,
  -4.05527689e-02f, -7.19969869e-02f, 2.83739995e-02f, -1.04864491e-02f, -2.25841943e-02f, 1.22732259e-01f, 3.79994623e-02f, 3.00920121e-02f, 1.02675870e-01f, -1.02872394e-01f,
  -2.58872192e-02f, 3.95148955e-02f, -5.01929820e-02f, 2.30795033e-02f, -3.33873834e-03f, -9.79859605e-02f, -3.41876745e-02f, -2.32684854e-02f, -1.90235972e-02f, 4.86456677e-02f,
  1.78875610e-01f, -1.57394819e-02f, -6.31219372e-02f, 3.50818224e-02f, -8.18385184e-02f, 2.18894854e-02f, 4.82565239e-02f, -3.35617922e-02f, 2.02971250e-02f, -9.15839896e-03f,
  1.17606893e-01f, -7.46042281e-02f, 1.16496533e-02f, 1.10159256e-01f, -4.08490039e-02f, 6.45836219e-02f, -8.69882666e-03f, -3.60153578e-02f, 1.12128444e-02f, 4.76821736e-02f,
  5.40971346e-02f, 1.46624679e-02f, -4.81745526e-02f, -2.67389063e-02f, -3.90908681e-02f, 8.58905166e-02f, -1.59222295e-03f, 5.96547909e-02f, 2.18360648e-02f, 3.96608114e-02f,
  2.66943902e-01f, -3.46449047e-01f, 6.05002083e-02f, 1.93136498e-01f, 3.11611474e-01f, 2.58327276e-01f, 2.67447978e-01f, 4.54253405e-02f, 2.41371915e-01f, -1.70662627e-01f,
  -5.40773012e-03f, -8.51335451e-02f, -2.96535999e-01f, 1.49305835e-01f, 1.47577330e-01f, -1.51986212e-01f, 1.43779173e-01f, 1.20767139e-01f, -5.20889498e-02f, 4.33414467e-02f,
  1.34230837e-01f, 1.63067952e-01f, -8.65791142e-02f, -7.19614178e-02f, 1.21586792e-01f, -1.69517949e-01f, -3.30401883e-02f, -1.00760847e-01f, 6.19253777e-02f, -2.12078020e-02f,
  7.85340220e-02f, 1.27735034e-01f, 1.08545050e-01f, 6.16214760e-02f, 2.16178764e-02f, -9.14773792e-02f, -8.18792209e-02f, 4.52161394e-02f, 6.21138625e-02f, 3.70275532e-03f,
  -6.47651330e-02f, -5.50796576e-02f, -1.35076966e-03f, 5.92457969e-03f, 4.98837084e-02f, -7.86494240e-02f, 6.11865474e-03f, -1.16780540e-02f, -1.68659743e-02f, -9.08516124e-02f,
  -4.08340320e-02f, -2.39380170e-02f, 2.86440831e-02f, -4.86874878e-02f, -5.77437431e-02f, 8.28576833e-02f, -1.88459456e-02f, -3.61835957e-02f, -1.22268274e-01f, 5.13119921e-02f,
  -2.73904838e-02f, -1.46096330e-02f, -1.00408001e-02f, 2.90773995e-02f, -2.01017242e-02f, -1.35417422e-02f, 3.03294379e-02f, -9.30197015e-02f, -2.00176844e-03f, -2.45504901e-02f,
  -1.60083733e-02f, -3.85805592e-03f, 6.79858774e-02f, 3.76537442e-02f, 7.20335683e-03f, 2.48938613e-02f, 1.16514014e-02f, -2.07858328e-02f, 1.34875055e-03f, -4.43893224e-02f,
  4.49773893e-02f, 6.80960864e-02f, -4.21972200e-02f, -5.16617186e-02f, -2.76640225e-02f, -5.68935350e-02f, 1.94283947e-02f, -1.61566976e-02f, -3.07793152e-02f, -7.78453946e-02f,
  1.14793226e-01f, -3.76084372e-02f, 4.99396846e-02f, -9.76474769e-03f, 1.42690670e-02f, 1.09039843e-01f, 1.11584701e-02f, -2.07836907e-02f, -5.47009483e-02f, -2.20475942e-02f,
  -7.44852843e-03f, 5.77131882e-02f, 9.65357292e-04f, 3.94915976e-02f, -9.49809924e-02f, 1.71455555e-02f, -7.50929415e-02f, 5.89197576e-02f, 3.87633666e-02f, -9.21930969e-02f,
  -1.20000198e-01f, -1.05621062e-01f, -1.78777985e-02f, -1.19322017e-02f, -4.66739424e-02f, -5.52295633e-02f, -1.54738771e-02f, 4.15407680e-02f, -9.36357901e-02f, -2.41214037e-02f,
  1.00959308e-01f, -4.35745060e-01f, 1.34027198e-01f, 8.00611731e-03f, 5.96968651e-01f, 3.14568549e-01f, 2.48677567e-01f, 1.01769082e-01f, 1.38548374e-01f, -3.86589497e-01f,
  -7.86506161e-02f, -2.11206123e-01f, -2.51117885e-01f, 2.10152622e-02f, 3.27769250e-01f, -1.43188769e-02f, 2.76422888e-01f, 9.85869691e-02f, 4.53433730e-02f, 1.51294261e-01f,
  8.07452127e-02f, 1.53756201e-01f, 1.04040764e-01f, 3.94741781e-02f, 1.68865219e-01f, -6.33374602e-02f, -1.87368263e-02f, 4.85503674e-02f, 7.14765396e-03f, 1.75385609e-01f,
  -2.38248277e-02f, -4.48698029e-02f, -1.25275776e-01f, -1.41146839e-01f, 1.48585299e-02f, -5.34924455e-02f, 1.05648162e-02f, 3.55322212e-02f, 3.47027965e-02f, -7.72813410e-02f,
  -2.41154265e-02f, -7.72617897e-03f, 1.36144876e-01f, 2.86487583e-02f, 2.85129044e-02f, -1.43812094e-02f, -1.38680926e-02f, -3.09814736e-02f, 7.38067254e-02f, 1.04698099e-01f,
  -5.07787876e-02f, -8.81540217e-03f, 1.94640104e-02f, 2.41482090e-02f, -3.80181968e-02f, -1.45338308e-02f, 8.26828852e-02f, 1.08184211e-01f, 4.29250337e-02f, 5.51623851e-03f,
  1.66548882e-02f, -3.46984342e-03f, 2.62741316e-02f, -7.63668120e-02f, 3.78042683e-02f, 2.36792192e-02f, -8.53194669e-02f, 4.35564555e-02f, -3.51299569e-02f, -1.96544062e-02f,
  7.38008544e-02f, 1.34705836e-02f, -2.09138095e-02f, -1.59309134e-02f, -7.48827904e-02f, -3.34674157e-02f, 3.50734405e-02f, -6.76673129e-02f, -1.03600852e-01f, 9.66836233e-03f,
  -9.68939066e-02f, 6.77657127e-03f, 2.77353711e-02f, 5.48210777e-02f, 2.05042921e-02f, 2.56604161e-02f, -7.27616474e-02f, 2.38267500e-02f, 2.91839056e-02f, 2.26275474e-02f,
  -2.23707587e-01f, -2.42080346e-01f, -2.62036771e-02f, -2.79267691e-02f, -4.80911247e-02f, -6.52501956e-02f, 2.80540399e-02f, 4.87277806e-02f, -2.57575908e-03f, 1.25493050e-01f,
  3.68965305e-02f, -7.38261193e-02f, -3.56266182e-03f, -2.09634695e-02f, -6.19338453e-02f, 3.31969224e-02f, 6.21481463e-02f, -2.82492917e-02f, -5.43461218e-02f, -1.09231234e-01f,
  7.11438013e-03f, 1.23161469e-02f, -1.13550592e-02f, 2.96120234e-02f, -4.59251143e-02f, 1.04970649e-01f, 3.49915735e-02f, -3.16057429e-02f, 6.63954243e-02f, -3.00018350e-03f,
  -1.16531529e-01f, -1.10368162e-01f, 2.62443721e-01f, -1.27155751e-01f, 1.93955705e-01f, 1.24996573e-01f, -1.11298840e-02f, -8.14060792e-02f, -2.38255933e-02f, -3.98955606e-02f,
  1.82642147e-01f, -4.41505462e-02f, 1.53010651e-01f, -2.04757657e-02f, 1.23597518e-01f, 1.73714254e-02f, -6.22270331e-02f, 2.53976379e-02f, -3.41504961e-02f, 5.79836033e-02f,
  3.92306447e-02f, -1.84498318e-02f, 1.79384410e-01f, -6.84931129e-02f, 2.03944668e-01f, -1.14083901e-01f, -4.48012799e-02f, 9.71725062e-02f, -8.75860676e-02f, 6.16559051e-02f,
  -4.38832641e-02f, 6.11326955e-02f, 1.26888663e-01f, 1.16373874e-01f, 1.56290513e-02f, 4.15185317e-02f, 1.02470897e-01f, 5.04170880e-02f, 6.21620230e-02f, -1.11463450e-01f,
  2.62118522e-02f, 9.56685320e-02f, -1.20170064e-01f, 6.98843449e-02f, 4.64519532e-03f, -8.40867832e-02f, -1.57349501e-02f, -7.01525733e-02f, -2.92539373e-02f, 6.13969639e-02f,
  9.96282548e-02f, 3.50472406e-02f, 3.77138108e-02f, -4.81338352e-02f, 7.25940093e-02f, -9.16255862e-02f, -6.48935977e-03f, -4.57241992e-03f, -3.81999649e-03f, 2.82129124e-02f,
  6.33961707e-02f, 7.19809979e-02f, 5.93222305e-02f, 3.92623283e-02f, -1.11946121e-01f, -1.50153483e-03f, 7.88984150e-02f, -6.49756119e-02f, 2.25690077e-03f, -8.79458524e-03f,
  -9.36726630e-02f, -4.78865989e-02f, 1.11473091e-01f, -2.35126484e-02f, 7.09718168e-02f, 1.71478000e-02f, -8.85520205e-02f, -3.48827504e-02f, 3.63387391e-02f, -2.24888660e-02f,
  3.77392210e-02f, 8.91245380e-02f, 1.09378416e-02f, 1.07040785e-01f, 1.07699357e-01f, -1.70416497e-02f, -8.47269148e-02f, -2.60973312e-02f, 3.09865586e-02f, -5.90057336e-02f,
  -8.59115720e-02f, -2.16554925e-01f, -1.06732640e-03f, -2.84349993e-02f, 1.33904353e-01f, 6.23578541e-02f, -1.30496128e-02f, -4.96678874e-02f, -9.47424248e-02f, -2.49369722e-03f,
  8.11580867e-02f, 3.64076197e-02f, 1.53581407e-02f, 1.83143951e-02f, 7.21599981e-02f, -1.41377440e-02f, 2.88741048e-02f, -3.65677252e-02f, 4.81483266e-02f, -6.59472123e-03f,
  -1.10820651e-01f, 8.32883827e-03f, -3.43465502e-03f, -3.22910957e-02f, -2.89861672e-02f, -2.95300875e-02f, -1.31221980e-01f, -7.21271485e-02f, -2.79385597e-02f, -7.54202008e-02f,
  -1.34542778e-01f, 7.06945136e-02f, 3.78525369e-02f, -1.86485171e-01f, -2.72517446e-02f, -4.01599668e-02f, -1.28853649e-01f, -1.43716056e-02f, -1.15544029e-01f, -1.13299996e-01f,
  -8.80532786e-02f, -1.18185855e-01f, 4.86344062e-02f, -2.92031527e-01f, 8.55626166e-02f, 2.12637916e-01f, -2.10912079e-01f, -2.43676156e-01f, -3.79713811e-02f, -2.10960776e-01f,
  -9.97916982e-02f, -1.97387412e-01f, -4.52706181e-02f, -6.63080737e-02f, -2.79716790e-01f, -1.76376402e-01f, -8.24595913e-02f, -6.01167371e-03f, -5.55611998e-02f, -4.99939248e-02f,
  -3.81431691e-02f, -2.20434397e-01f, -1.17966436e-01f, 6.18606322e-02f, -8.66861790e-02f, 1.00810923e-01f, -9.20389295e-02f, -8.60015601e-02f, -4.89941202e-02f, -3.14962119e-02f,
  5.36841992e-03f, -6.98443130e-02f, -4.64342680e-04f, -3.88234295e-02f, -7.42036775e-02f, -5.78551404e-02f, -2.52537802e-02f, -4.60337801e-03f, -5.89611717e-02f, -2.54632086e-02f,
  -5.75416088e-02f, 5.52433841e-02f, -5.70282862e-02f, -8.50967467e-02f, -7.16946572e-02f, -1.92457568e-02f, 7.24951774e-02f, -1.43863298e-02f, -6.74998313e-02f, -1.99001376e-02f,
  2.93582957e-03f, 1.36112481e-01f, 5.48707545e-02f, 6.56868741e-02f, -1.21181300e-02f, 5.77816069e-02f, 4.11331914e-02f, 2.88082026e-02f, 2.79127266e-02f, 7.24400952e-02f,
  -6.05816580e-02f, -7.66993240e-02f, 2.98965294e-02f, 2.76056994e-02f, -5.60137555e-02f, 1.23239592e-01f, -8.63491669e-02f, 5.86764738e-02f, 2.96312086e-02f, -3.08997761e-02f,
  1.32370004e-02f, -8.34530592e-02f, -7.98744615e-03f, -1.68392956e-02f, 2.41064001e-02f, -1.02177477e-02f, -5.84964361e-03f, 2.09149979e-02f, -3.24003282e-03f, -3.00739277e-02f,
  -1.32541165e-01f, -7.43202940e-02f, -1.14269778e-02f, -8.03859159e-02f, 5.77060208e-02f, 6.53669760e-02f, 1.68324821e-03f, 8.48669559e-02f, 5.78027889e-02f, -3.20166983e-02f,
  -3.71252187e-02f, -2.07190678e-04f, 9.48843583e-02f, 2.95282658e-02f, -9.15290788e-02f, -2.87426766e-02f, -8.21035877e-02f, -2.29213182e-02f, -6.02399446e-02f, -2.68573444e-02f,
  -7.64621347e-02f, 1.55426813e-02f, 4.85405652e-03f, -8.83006863e-03f, 7.43581429e-02f, -4.69126552e-02f, 8.67579691e-03f, 6.81241881e-03f, 1.41482186e-02f, 7.69423395e-02f,
  3.28696109e-02f, -5.58196045e-02f, -9.49192792e-02f, -2.00166836e-01f, -7.60099888e-02f, 1.05601452e-01f, -9.56714451e-02f, -4.23926078e-02f, 6.63122907e-02f, -4.32999097e-02f,
  -6.49264678e-02f, -1.24389224e-01f, 1.55266762e-01f, -2.20882922e-01f, 1.15363054e-01f, 8.41054618e-02f, -1.00275092e-01f, -1.42182186e-01f, -1.37122825e-01f, -1.55263707e-01f,
  -1.58595666e-01f, -2.49743760e-01f, -1.27687991e-01f, -9.26680490e-02f, -2.17434704e-01f, -1.61175996e-01f, -1.00189835e-01f, -1.65392980e-01f, -1.73420668e-01f, -1.93945423e-01f,
  -8.87920484e-02f, 4.67329798e-03f, -6.79020286e-02f, -8.73425603e-03f, 5.51454313e-02f, -5.08205295e-02f, 5.70621043e-02f, 9.90203582e-03f, -3.40941711e-03f, 8.00085068e-03f,
  4.82493863e-02f, 4.17516977e-02f, -5.55013865e-02f, 1.67728029e-02f, -4.52274345e-02f, -7.53417462e-02f, -8.00465718e-02f, -4.14661765e-02f, 6.47323281e-02f, -2.24583372e-02f,
  -1.04798563e-02f, 7.69581180e-03f, -5.65257780e-02f, 1.01039708e-01f, -8.69704261e-02f, -6.98127598e-02f, -5.40255345e-02f, -1.91448797e-02f, 2.08497997e-02f, 2.14178767e-02f,
  5.47557231e-03f, 1.31755427e-01f, 8.69010687e-02f, -7.36292303e-02f, 5.92371263e-02f, -3.86230648e-02f, 3.37770842e-02f, -2.96219569e-02f, -3.03481482e-02f, -2.23682206e-02f,
  7.31460303e-02f, 7.15250075e-02f, -1.32132769e-01f, 1.53095992e-02f, -3.44610289e-02f, -6.00064956e-02f, 4.01578434e-02f, -1.01115443e-01f, 4.81326617e-02f, 1.03412308e-02f,
  -2.40189768e-02f, 1.78400539e-02f, -3.09613869e-02f, 1.85085386e-02f, -2.81624869e-02f, -2.42405701e-02f, 5.14251478e-02f, 5.85146360e-02f, -4.56414139e-03f, -5.03412411e-02f,
  5.14752716e-02f, 3.19817029e-02f, -6.51883408e-02f, -7.92334601e-02f, -2.30857469e-02f, 2.57305782e-02f, -9.22990090e-04f, 2.81412639e-02f, 8.30266401e-02f, 1.57747027e-02f,
  -9.57110375e-02f, 8.09626803e-02f, 8.37161299e-03f, 5.15610613e-02f, -8.39371458e-02f, 3.94517370e-02f, 4.46262546e-02f, -3.97350676e-02f, 2.20784917e-02f, -6.54776171e-02f,
  4.81809042e-02f, -2.89014578e-02f, 5.37389442e-02f, 6.05660826e-02f, -2.51547508e-02f, 3.91458757e-02f, 1.04043625e-01f, -4.83683385e-02f, -6.22467101e-02f, -3.52716558e-02f,
  -6.00088418e-01f, 7.37370327e-02f, -2.15650171e-01f, -3.82636607e-01f, 1.22849241e-01f, -2.20454186e-01f, -2.13504672e-01f, 4.41369601e-02f, -1.82024330e-01f, 2.74493009e-01f,
  1.07026882e-01f, -2.71677762e-01f, 1.38082188e-02f, -4.30126101e-01f, -8.21578920e-01f, -2.91452140e-01f, -4.84283596e-01f, -1.00722700e-01f, -2.49559626e-01f, -4.14266028e-02f,
  -2.71658301e-01f, -1.84306771e-01f, -4.43630040e-01f, 1.33390442e-01f, -1.70886684e-02f, 9.90772322e-02f, 1.37255475e-01f, 1.14048921e-01f, 1.06531560e-01f, -1.57743320e-01f,
  -3.32838073e-02f, 2.16145962e-01f, 1.39926434e-01f, -2.90707238e-02f, -3.41959074e-02f, 6.19677491e-02f, -5.20766228e-02f, -3.07946058e-04f, -4.90394458e-02f, -4.17851135e-02f,
  -5.25868759e-02f, -3.96782532e-03f, -8.05193260e-02f, 3.78739610e-02f, -1.01217404e-02f, 2.68524345e-02f, -8.44850242e-02f, -4.46282327e-02f, 5.76779917e-02f, -7.18676075e-02f,
  -1.16089962e-01f, 3.96793373e-02f, 1.20845586e-02f, 1.25652626e-02f, -8.99500027e-02f, 2.06357986e-02f, -6.06873147e-02f, 6.82599563e-03f, 3.19118332e-03f, -7.93580338e-02f,
  2.28580739e-02f, 2.86553026e-04f, -1.03926241e-01f, -3.94523069e-02f, -4.48685400e-02f, 1.86470104e-03f, -3.75125408e-02f, 4.14703004e-02f, 1.54749174e-02f, 4.34027463e-02f,
  5.89288026e-03f, 2.90198009e-02f, -9.84286238e-03f, -2.08046753e-02f, -8.52306038e-02f, -1.10963605e-01f, -1.18012947e-03f, 2.97703538e-02f, -7.70250931e-02f, -3.06864199e-03f,
  -7.49077601e-03f, -8.99541250e-04f, 2.13093292e-02f, 3.07249557e-02f, 5.26235700e-02f, -1.58924498e-02f, 2.00920627e-02f, -5.00926049e-04f, -1.92801468e-02f, -3.35410833e-02f,
  4.44290042e-02f, 7.50885606e-02f, 4.40182947e-02f, 9.83267352e-02f, -3.75950738e-04f, -7.08886907e-02f, -8.48075598e-02f, -3.10880411e-02f, 9.97411683e-02f, -2.58068871e-02f,
  8.85721445e-02f, 2.96013476e-03f, 7.14416504e-02f, 2.20977422e-02f, -4.24904637e-02f, -1.60867050e-02f, 6.02958091e-02f, 1.35863066e-01f, 2.99729258e-02f, -1.80095751e-02f,
  1.06763519e-01f, -9.96314082e-03f, -2.15483550e-02f, 3.33523862e-02f, -1.14157330e-02f, 5.83246090e-02f, 5.55808805e-02f, -2.14346237e-02f, -9.11294948e-03f, -5.86648360e-02f,
  -4.26448435e-01f, 3.75073642e-01f, 2.13948011e-01f, -2.03439504e-01f, -3.07565928e-02f, 7.09026456e-02f, 4.59093414e-02f, 5.80428466e-02f, 2.64757592e-02f, 1.79650575e-01f,
  8.70666467e-03f, 5.26646525e-02f, 1.57975983e-02f, 4.40318324e-03f, -3.54103863e-01f, 1.46093154e-02f, 2.71745324e-02f, -1.75987941e-03f, 9.87124294e-02f, 9.27188620e-02f,
  -2.38180589e-02f, 3.11634913e-02f, -9.31811612e-03f, 1.81979269e-01f, -1.72459111e-02f, 2.32894793e-02f, -1.53345689e-01f, 8.17317795e-03f, 4.65526842e-02f, -3.10667548e-02f,
  -7.43649229e-02f, -1.04326703e-01f, -8.43764246e-02f, 3.45483832e-02f, -7.04843830e-03f, -2.60006767e-02f, -6.36587963e-02f, -4.01734300e-02f, -3.60819511e-02f, 9.61264744e-02f,
  -5.97893037e-02f, 5.04567996e-02f, -1.14207650e-02f, -4.43587191e-02f, 6.09508231e-02f, -5.49478196e-02f, -1.22021530e-02f, 3.68726067e-02f, -6.93556145e-02f, 3.29043455e-02f,
  2.38389876e-02f, 3.13451514e-02f, -9.48375016e-02f, -2.82546822e-02f, -8.29648972e-02f, 1.02490753e-01f, -3.27037387e-02f, -8.48501548e-02f, 9.45427418e-02f, 4.51192968e-02f,
  4.54697832e-02f, 6.13927580e-02f, 6.25078827e-02f, 1.07752820e-02f, -7.33375922e-02f, -5.73545403e-04f, -1.80744976e-02f, -8.03670958e-02f, -1.16954008e-02f, -1.01878420e-02f,
  -2.53164154e-02f, -2.71739773e-02f, -7.03682452e-02f, 8.28311965e-03f, 6.98399125e-03f, 4.38682735e-02f, 3.76419052e-02f, -2.72636544e-02f, 2.90753618e-02f, 5.84623255e-02f,
  -6.66189846e-03f, -4.86284215e-03f, 8.19321126e-02f, -8.91249999e-02f, 2.98191234e-02f, -3.55703495e-02f, 9.27565321e-02f, -2.07109097e-02f, -8.34972970e-03f, -1.07116848e-01f,
  -1.59748718e-01f, -2.00773939e-01f, -1.39496773e-01f, -4.48950231e-02f, 5.56991026e-02f, -3.12909968e-02f, 5.82875647e-02f, -7.10780248e-02f, -1.72011349e-02f, -5.57861626e-02f,
  -4.48828936e-02f, 1.27603747e-02f, 7.44950667e-04f, -1.25834197e-02f, -7.86292776e-02f, -7.17482120e-02f, -4.26250845e-02f, 7.22469166e-02f, -2.64274776e-02f, -1.71067286e-02f,
  -6.58189654e-02f, 5.46931922e-02f, -9.14200023e-02f, -6.20125234e-02f, 3.20485234e-02f, 4.03644703e-02f, -7.19576329e-02f, -8.87862593e-02f, -7.60922059e-02f, -1.93009656e-02f,
  -1.60338372e-01f, 3.89963835e-01f, 2.93718845e-01f, 3.10656965e-01f, -5.08616641e-02f, -2.98921555e-01f, -2.08109632e-01f, 1.77260414e-01f, -4.08827141e-02f, 7.56833777e-02f,
  -8.52403045e-02f, 8.41907971e-03f, -5.66539094e-02f, 8.13149586e-02f, -2.77903795e-01f, 4.52953838e-02f, -2.31122654e-02f, 1.10632218e-01f, -1.75198037e-02f, 2.21476644e-01f,
  2.93534789e-02f, -6.32404312e-02f, 1.90316409e-01f, -2.32777814e-03f, 9.78789702e-02f, 2.14526966e-01f, 1.31621078e-01f, -3.26346382e-02f, 1.72384813e-01f, -2.15101942e-01f,
  -7.75763914e-02f, -2.33707111e-02f, 1.28520206e-02f, -1.49827143e-02f, -4.22545224e-02f, 4.28043380e-02f, 5.38955368e-02f, -6.71687769e-03f, 5.80836684e-02f, -5.98416105e-02f,
  7.90916756e-02f, -8.57040361e-02f, -1.81743801e-02f, -8.79366398e-02f, -2.30477192e-03f, -2.19897814e-02f, 1.06295921e-01f, 1.04440100e-01f, 1.84754282e-01f, -5.61493635e-02f,
  1.98659729e-02f, 7.83941969e-02f, 1.12447016e-01f, 3.71854156e-02f, 3.87675986e-02f, -1.26679659e-01f, -4.69595715e-02f, -6.96918741e-02f, 7.10860044e-02f, -7.44841173e-02f,
  -3.76347527e-02f, 2.10680645e-02f, 8.67956057e-02f, 1.94544659e-03f, -1.00471653e-01f, 1.01275213e-01f, -6.88082501e-02f, 8.79927576e-02f, -1.20975245e-02f, -6.27490431e-02f,
  1.83029496e-03f, 3.85270305e-02f, -6.90437108e-02f, 4.48251404e-02f, -6.42493963e-02f, -7.44830146e-02f, -1.85493827e-02f, -7.40919113e-02f, -2.57302038e-02f, 1.16481762e-02f,
  -4.84271646e-02f, -6.01357035e-02f, 1.12695254e-01f, -7.41632609e-03f, -3.43222246e-02f, -1.92534775e-02f, 4.80148308e-02f, -2.07364745e-02f, 1.18123397e-01f, -1.80880398e-01f,
  1.00546069e-01f, 1.63723379e-01f, 1.20714717e-02f, -8.29762146e-02f, 4.48999703e-02f, -3.13668922e-02f, -7.96421915e-02f, 9.45935622e-02f, -3.72617156e-04f, -9.38869268e-02f,
  2.89626922e-02f, -2.95110960e-02f, -5.11939405e-03f, -1.54109225e-01f, -1.69663578e-02f, -5.69115654e-02f, -1.33857573e-03f, -5.93849532e-02f, 3.56509686e-02f, 8.88784304e-02f,
  1.59319386e-01f, -8.88524652e-02f, -2.36124657e-02f, 9.06318706e-03f, -8.08634702e-03f, 1.25072068e-02f, -2.38984525e-02f, 4.13514972e-02f, 5.58812469e-02f, 2.50864644e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.66327107e-01f, 1.02286123e-01f, 5.88652678e-02f, 2.14705005e-01f, 2.15515774e-02f, 1.65468112e-01f, 8.53184760e-02f, 3.44060987e-01f, 6.08568126e-03f, 9.11958963e-02f,
  -1.84304379e-02f, 4.99190509e-01f, 2.27986112e-01f, 2.52328902e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.21272348e-01f, -4.69888926e-01f, -4.40721422e-01f, 4.64775026e-01f, 3.30564737e-01f, -8.98910835e-02f, 1.34046018e-01f, 3.06692064e-01f, -4.55652356e-01f, -4.39735968e-03f,
  4.43857573e-02f, 2.92218328e-01f, 2.98365027e-01f, 3.75038117e-01f, 1.74088478e-01f, -3.20633382e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -1.72340900e-01f, 1.29352972e-01f, 6.93921149e-02f, 2.08515808e-01f, 1.04202842e-02f, -2.17459902e-01f, -2.23949030e-01f, -1.88442647e-01f, -6.01990670e-02f, -1.31482199e-01f,
  2.07405820e-01f, 6.60144910e-02f, 4.11102548e-02f, -2.67621521e-02f, -2.24517569e-01f, -1.74094871e-01f, -1.15671260e-02f, -3.40261698e-01f, -1.13489032e-01f, 1.51611209e-01f,
  -1.34494513e-01f, 1.52298659e-01f, -8.61026198e-02f, -2.21450970e-01f, 2.31745154e-01f, 7.14925081e-02f, -1.62754864e-01f, 1.99310124e-01f, 1.35210529e-01f, -1.84002206e-01f,
  -2.13614181e-01f, 1.15436353e-01f, 6.37097731e-02f, -2.06491411e-01f, -1.25860900e-01f, -8.86974186e-02f, -1.77941218e-01f, -4.47445214e-02f, -1.48051217e-01f, 1.83848292e-01f,
  1.54451327e-02f, 8.38458538e-02f, 2.50920832e-01f, -1.79214582e-01f, 2.32191637e-01f, 4.50277925e-02f, -8.42033252e-02f, 8.07822421e-02f, 2.39464305e-02f, 4.40219007e-02f,
  7.42561147e-02f, -1.18435748e-01f, -2.26546362e-01f, -2.21854910e-01f, 1.40219450e-01f, -6.50248900e-02f, -7.45717958e-02f, -1.49237573e-01f, 1.81674883e-01f, -8.61924700e-03f,
  -8.75313208e-02f, -7.64009953e-02f, -2.51036525e-01f, 9.78654698e-02f, 2.57604390e-01f, 5.40217519e-01f, 1.49623871e-01f, -7.42230713e-02f, -9.86523703e-02f, 3.71679626e-02f,
  8.59412849e-01f, -3.57940257e-01f, 2.94250399e-01f, 6.77981079e-01f, 1.71447977e-01f, 4.55374837e-01f, 5.56729555e-01f, 2.62607306e-01f, -5.84882274e-02f, -2.47705221e-01f,
  4.06205565e-01f, -2.85766333e-01f, 4.55675244e-01f, 7.37178504e-01f, 1.10589445e+00f, 9.04066622e-01f, -4.97081876e-01f, 4.56502438e-01f, 2.56266713e-01f, 3.10209543e-01f,
  -9.99424979e-02f, 5.88112026e-02f, 1.08455904e-02f, -1.35668650e-01f, 3.31631273e-01f, 1.19342245e-01f, 3.25955659e-01f, -4.57420051e-02f, 3.88299465e-01f, -4.81420457e-02f,
  1.12804037e-03f, -3.32819402e-01f, 4.77104455e-01f, 6.27686203e-01f, -1.54121116e-01f, -3.22094351e-01f, 8.37493688e-02f, -6.07836470e-02f, -3.56022358e-01f, 1.02146161e+00f,
  4.45568472e-01f, 7.15713084e-01f, 5.41970909e-01f, 5.68684340e-02f, 1.19182207e-01f, -3.24283063e-01f, -4.48112875e-01f, -2.19242219e-02f, 1.15410709e+00f, 5.74996322e-02f,
  3.17961574e-01f, 7.82039165e-01f, 6.25864923e-01f, 3.85354400e-01f, -9.69735533e-03f, 8.16284835e-01f, 3.76610875e-01f, -2.04454690e-01f, 2.23874784e-04f, 8.36570024e-01f,
  1.00525022e+00f, 1.89553753e-01f, 2.89442748e-01f, -1.62920043e-01f, -1.63890809e-01f, -2.01747134e-01f, 4.72752035e-01f, 2.62386948e-01f, 8.40727389e-02f, -2.62520105e-01f,
  -3.33955199e-01f, -2.67807305e-01f, -9.97179523e-02f, 8.67213532e-02f, 1.61432311e-01f, -4.33033407e-02f, 4.82795089e-01f, -2.07789123e-01f, 3.92589122e-01f, -3.07399839e-01f,
  -1.20607890e-01f, 3.82512122e-01f, -1.46560803e-01f, -2.39464834e-01f, -2.22572237e-01f, 2.63361841e-01f, 1.46584198e-01f, 5.06396890e-01f, -4.11949232e-02f, 5.20482421e-01f,
  1.56805620e-01f, -1.87633038e-01f, 2.25005634e-02f, 1.32464737e-01f, -1.56414285e-01f, -1.38558000e-01f, 9.18186083e-02f, 2.15611219e-01f, -5.20815216e-02f, -9.70746651e-02f,
  -5.54875880e-02f, -1.02068491e-01f, 4.24748510e-02f, -1.84841856e-01f, -1.94005102e-01f, 1.78437486e-01f, 3.31623144e-02f, -2.50969604e-02f, 6.15217164e-03f, -1.34398252e-01f,
  5.60922265e-01f, 2.91516721e-01f, -1.75020188e-01f, 9.90822446e-03f, -2.97033817e-01f, -6.98102713e-02f, 6.97279908e-03f, 1.70809940e-01f, 1.89200327e-01f, -2.41219223e-01f,
  3.34004551e-01f, 3.52362156e-01f, 1.14874668e-01f, -3.37633602e-02f, 4.63771462e-01f, 1.40492395e-01f, 6.68385804e-01f, 4.65820909e-01f, 3.74626547e-01f, 1.67419568e-01f,
  -2.38150254e-01f, -4.07594919e-01f, -3.33965808e-01f, -5.52804358e-02f, 2.87665814e-01f, 6.44434392e-01f, 2.39279807e-01f, 2.25970328e-01f, 2.42673084e-02f, 8.71834636e-01f,
  1.23164523e+00f, -5.57660013e-02f, 6.58087850e-01f, -2.37396047e-01f, 6.40766397e-02f, -2.94064939e-01f, 2.36100048e-01f, 1.57701254e-01f, -2.73499250e-01f, 4.36219662e-01f,
  1.52336240e-01f, 4.05783117e-01f, -4.93126571e-01f, -6.50785938e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  9.48359594e-02f, 1.67572528e-01f, -1.60484985e-01f, 5.38807176e-02f, 4.36066538e-01f, 7.96273768e-01f, 3.19359481e-01f, 6.60250485e-01f, 5.38659655e-02f, 2.57690907e-01f,
  -2.17053697e-01f, 2.62026619e-02f, 4.65388775e-01f, 2.90106416e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.18882406e-01f, 1.31474137e-01f, 2.61341006e-01f, 5.62698022e-02f, -4.57507605e-03f, -1.13705501e-01f, 2.88931847e-01f, 1.98686197e-01f, -2.56071389e-01f, 3.24492306e-02f,
  2.95807272e-01f, -1.54280767e-01f, 4.83301245e-02f, -3.21909279e-01f, -2.26001069e-01f, -1.90965861e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -3.86039764e-01f, -2.42987677e-01f, -3.07699293e-02f, -2.63952971e-01f, 1.31154746e-01f, 2.13429585e-01f, -4.40274805e-01f, 2.21060276e-01f, 1.44428670e-01f, -4.14551377e-01f,
  5.62776327e-01f, 2.59777337e-01f, -1.40931457e-01f, 4.80768159e-02f, 3.02852601e-01f, 7.32993782e-01f, -7.52894282e-01f, -1.03653431e+00f, -8.32467601e-02f, -2.53301293e-01f,
  -2.62228936e-01f, 1.31765366e-01f, 1.17863750e+00f, -5.87959647e-01f, -7.17860162e-02f, 6.68583214e-01f, 1.03343129e+00f, 2.18904227e-01f, 6.13128506e-02f, 1.84450485e-02f,
  3.17957491e-01f, 1.52059793e+00f, -2.67197371e-01f, 7.76885450e-02f, 9.33222771e-02f, -2.50960231e-01f, 1.00749336e-01f, -7.65282065e-02f, 8.16370249e-02f, 1.34761736e-01f,
  -8.65941346e-02f, -2.43116826e-01f, -2.22707912e-03f, -2.15915307e-01f, -2.22564921e-01f, -4.81189378e-02f, 2.33152017e-01f, 2.11611316e-02f, 4.18855757e-01f, 8.62540424e-01f,
  -1.04640543e-01f, 2.87086427e-01f, 9.93639305e-02f, 1.84750542e-01f, 6.20165884e-01f, -2.50725031e-01f, 1.07503974e+00f, 1.61397314e+00f, -4.60000038e-01f, 1.48982272e-01f,
  -2.02026382e-01f, 5.86616397e-02f, 4.75948304e-01f, -5.91574430e-01f, 5.30413762e-02f, -1.36492774e-01f, 1.60722345e-01f, -1.89174950e-01f, -5.43933874e-03f, -1.26156792e-01f,
  -1.10748485e-01f, -2.36609906e-01f, 1.88154832e-01f, -1.87908292e-01f, -7.86520690e-02f, -1.11462928e-01f, 1.16958261e-01f, 1.89664468e-01f, 1.72420546e-01f, 1.43096074e-01f,
  -1.62281856e-01f, 2.47054338e-01f, 1.08153239e-01f, -2.35160291e-01f, 1.01745099e-01f, 2.31279507e-02f, -2.44569052e-02f, -1.65461570e-01f, -1.07115127e-01f, -1.57604888e-01f,
  7.38963559e-02f, -1.37261763e-01f, 3.06448173e-02f, 1.22077344e-03f, 1.33921772e-01f, 7.29794502e-02f, 2.96406168e-02f, 1.23466402e-01f, -2.06931457e-01f, -1.55813977e-01f,
  9.58361402e-02f, -2.58748084e-01f, 2.01289445e-01f, 2.66885430e-01f, -1.30541651e-02f, -8.50559920e-02f, 3.85007948e-01f, -6.28066212e-02f, 5.28789274e-02f, -2.15773016e-01f,
  -3.62328976e-01f, 1.70115724e-01f, 2.23952428e-01f, 1.29315302e-01f, 1.22176595e-01f, 2.68047124e-01f, 8.12496152e-03f, -3.92820686e-02f, 2.74241678e-02f, 5.57162941e-01f,
  -2.82875299e-01f, -3.80347073e-01f, 4.16042477e-01f, -2.73730010e-01f, -1.85408607e-01f, -8.43384266e-02f, 3.14798027e-01f, 1.60509720e-01f, -3.75072747e-01f, -5.77440634e-02f,
  -3.58122066e-02f, -1.93707719e-01f, -4.64457273e-02f, -4.65025753e-02f, -4.48985472e-02f, 2.98523635e-01f, -3.87191065e-02f, -1.60229489e-01f, -2.26953298e-01f, 1.22093581e-01f,
  -6.18231110e-02f, 3.73117954e-01f, 3.59382987e-01f, -8.95403996e-02f, -1.10417753e-01f, -2.77476698e-01f, -7.58567527e-02f, -1.11757509e-01f, -2.47231349e-01f, -1.27198488e-01f,
  -6.59108460e-02f, 6.43586814e-02f, -1.35755017e-01f, 1.86135516e-01f, 9.07757282e-02f, 1.66052982e-01f, 3.77011560e-02f, -7.16458559e-02f, -5.55619560e-02f, 2.31789108e-02f,
  -3.08870554e-01f, 2.21945941e-01f, 1.03089817e-01f, -3.20347875e-01f, -2.67877593e-03f, -1.75621912e-01f, -4.81167763e-01f, 1.14035177e+00f, 8.53894293e-01f, -7.17191458e-01f,
  6.79563880e-02f, 8.40103030e-01f, 1.60518005e-01f, 6.69878185e-01f, 1.09135020e+00f, 3.96077067e-01f, 7.18221128e-01f, 2.49299556e-01f, 1.87513586e-02f, -9.34509095e-03f,
  1.03321403e-01f, -5.83246239e-02f, 4.50627565e-01f, 1.43545890e+00f, -7.90787160e-01f, 5.35567105e-01f, 3.98179442e-01f, -5.25855601e-01f, -1.23763599e-01f, 1.82187200e-01f,
  -4.57125083e-02f, 3.05371702e-01f, -1.76188841e-01f, -1.90302178e-01f, 1.98674351e-01f, -2.52353013e-01f, 1.17318131e-01f, 2.10232660e-01f, -3.95819962e-01f, -3.06644797e-01f,
  4.32438463e-01f, 2.40480721e-01f, -2.32507750e-01f, 1.36614799e-01f, 9.12247505e-03f, -7.62591735e-02f, 1.57165542e-01f, 1.69464946e-01f, -1.45760790e-01f, 6.94974735e-02f,
  5.53835183e-02f, -2.22061291e-01f, 4.42206673e-02f, -1.90507531e-01f, 1.67167380e-01f, -1.21928729e-01f, -2.00671777e-01f, 1.43666789e-01f, 3.83730382e-01f, -2.26951003e-01f,
  2.90666632e-02f, -7.72384629e-02f, -3.41298938e-01f, 1.88756540e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -5.01289308e-01f, -1.11614890e-01f, -1.72655657e-02f, 7.33732462e-01f, -1.90625623e-01f, -1.51759654e-01f, 2.53434569e-01f, -1.21258339e-02f, -3.75385582e-01f, -1.73476174e-01f,
  2.39165530e-01f, 6.16667449e-01f, -2.26446047e-01f, -4.21483479e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -4.47222553e-02f, -4.44934934e-01f, 1.85918123e-01f, -1.03598344e+00f, 2.81022489e-01f, -5.87437093e-01f, -1.27539068e-01f, -9.33649763e-02f, -4.04755324e-01f, 1.29764289e-01f,
  6.11243069e-01f, -5.98645210e-02f, 1.02877259e+00f, 1.35564029e-01f, 1.89722124e-02f, -1.37571931e-01f, -6.75013363e-02f, 1.78095713e-01f, 4.74510044e-01f, -2.06546649e-01f,
  2.27370143e-01f, -1.08995140e+00f, -7.32824653e-02f, 2.89987475e-02f, 1.49161026e-01f, 6.02246106e-01f, -1.48907945e-01f, -7.50850094e-03f, 4.81206268e-01f, 6.04331195e-01f,
  -5.05078286e-02f, 2.95083802e-02f, 6.59911111e-02f, 8.31523538e-02f, 3.19124579e-01f, 9.03364718e-01f, -5.30659109e-02f, -9.89127934e-01f, 2.01277196e-01f, 2.45483905e-01f,
  2.66735345e-01f, 1.20463453e-01f, -2.43737251e-01f, 1.64379016e-01f, -2.08843783e-01f, 3.51067960e-01f, 3.82399894e-02f, 1.94119722e-01f, -7.83509970e-01f, -4.66029465e-01f,
  -1.00103363e-01f, 2.14245155e-01f, 9.20592174e-02f, 1.08697414e+00f, 1.36194795e-01f, 2.69411709e-02f, -4.17813696e-02f, -7.04248473e-02f, -1.67240039e-01f, -1.46077527e-02f,
  -5.37267864e-01f, -1.03198612e+00f, 3.56396616e-01f, -3.42423946e-01f, 3.81649017e-01f, 2.99707931e-02f, -2.26444557e-01f, 1.37415994e-02f, -4.03245129e-02f, 1.06543648e+00f,
  2.03859076e-01f, -1.31760746e-01f, -2.31280610e-01f, -3.54574591e-01f, 1.93182707e-01f, -1.22417420e-01f, -3.50444555e-01f, 1.32906824e-01f, -5.42006135e-01f, 1.66084573e-01f,
  5.42368531e-01f, 3.44209641e-01f, -7.36318946e-01f, -7.70616889e-01f, -8.61508548e-02f, -1.88102238e-02f, 1.18642680e-01f, -2.19407514e-01f, -1.00547418e-01f, 5.63775599e-01f,
  3.42571735e-03f, 5.26456274e-02f, 3.23052257e-01f, 8.85797322e-01f, 1.53921515e-01f, -2.86557347e-01f, -1.06290234e-02f, 9.29601729e-01f, -3.48874599e-01f, 9.39882755e-01f,
  2.30512515e-01f, -2.11205497e-01f, 1.41169637e-01f, 1.13945439e-01f, 1.47000223e-01f, 2.13076230e-02f, -3.54042575e-02f, 1.09195784e-01f, -1.02273440e+00f, 4.55797523e-01f,
  1.57957822e-01f, 2.93885112e-01f, 5.80916882e-01f, -6.56128466e-01f, 1.00016698e-01f, 1.32176125e+00f, 2.63954490e-01f, 1.48472995e-01f, -2.24357963e-01f, 1.18221879e-01f,
  -2.53763139e-01f, -2.57808361e-02f, -1.44511566e-01f, -7.82192573e-02f, -5.38181901e-01f, -5.05943835e-01f, -3.42091382e-01f, -3.85986745e-01f, -7.37569928e-01f, -8.23668480e-01f,
  7.93236315e-01f, 5.51294744e-01f, -5.83638735e-02f, -7.83169210e-01f, 3.62488790e-03f, -2.26161987e-01f, 8.68085548e-02f, -1.58624053e-02f, 1.79811567e-01f, -1.27466694e-02f,
  5.36350608e-01f, -4.30265874e-01f, -1.75939038e-01f, -2.41877809e-01f, 4.21415091e-01f, 7.86469936e-01f, -1.88846402e-02f, -6.76045537e-01f, -1.33799180e-01f, 6.24536872e-01f,
  -1.93507209e-01f, 2.39134766e-02f, 2.68929034e-01f, -1.04772277e-01f, 3.08300052e-02f, -1.75387084e-01f, -1.13602054e+00f, 1.07693851e+00f, -2.56527334e-01f, -1.76896155e-01f,
  -4.19479609e-01f, -6.11267149e-01f, 5.98115660e-02f, 4.51170653e-01f, 1.60470828e-01f, 3.07950467e-01f, 1.47767682e-02f, 1.16189443e-01f, -2.74545774e-02f, -1.27921522e-01f,
  -2.75389925e-02f, 3.88884582e-02f, 4.08907980e-01f, -5.36125004e-01f, 2.94432014e-01f, 6.51633143e-02f, 3.15445065e-01f, -5.82572401e-01f, -3.58442098e-01f, -1.12812829e+00f,
  -2.09168895e-04f, 7.51294792e-01f, -2.23253518e-02f, -5.08633330e-02f, 1.67209491e-01f, -1.69183344e-01f, -2.95590281e-01f, 5.94331585e-02f, 7.50843108e-01f, -4.66032475e-01f,
  -8.08901489e-02f, 3.05165388e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.16312280e-01f, -3.17399343e-03f, -2.58137316e-01f, -5.75654805e-01f, -5.62804677e-02f, 7.21617699e-01f, 4.58489716e-01f, -2.57816166e-02f, -6.03963077e-01f, 7.65365183e-01f,
  -3.64742100e-01f, 4.18935478e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    