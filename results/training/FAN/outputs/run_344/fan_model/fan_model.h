/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.13661857e-02f, 1.77166373e-01f, 6.33289889e-02f, 1.37446746e-01f, -2.09557354e-01f, -3.48445550e-02f, -1.56419557e-02f, -9.99024659e-02f, -7.60689378e-02f, -7.04947300e-03f,
  -2.50281207e-02f, 1.09522820e-01f, 6.41373098e-02f, 1.49901852e-01f, 1.92108676e-01f, 1.35987833e-01f, 1.76969543e-01f, 8.05203542e-02f, 1.87615976e-02f, -2.26388481e-02f,
  1.22412033e-01f, 2.25807384e-01f, 1.73816219e-01f, 1.12657726e-01f, 1.13438465e-01f, 4.28833365e-02f, 4.55049686e-02f, -1.09081544e-01f, 1.64092824e-01f, 1.05894141e-01f,
  -5.48079461e-02f, 3.49449553e-02f, 1.91214867e-02f, 3.52869072e-04f, 2.10389509e-04f, -5.92655391e-02f, 4.53271717e-02f, 8.75949487e-03f, 1.43760638e-02f, -1.19424192e-02f,
  3.63281518e-02f, -3.35824257e-03f, 4.01655957e-02f, -2.06405912e-02f, -6.94069192e-02f, -3.76278609e-02f, 1.16614634e-02f, 3.24706770e-02f, -7.75379911e-02f, 3.04863472e-02f,
  -5.73910847e-02f, -1.61800757e-02f, -1.15600014e-02f, 1.03355162e-01f, -4.17771004e-02f, -4.27460857e-02f, 5.61781004e-02f, 1.55911446e-02f, -5.92286848e-02f, 2.75459830e-02f,
  5.57712987e-02f, 1.22895623e-02f, -5.84503561e-02f, 3.12496796e-02f, 1.94288362e-02f, 3.76493707e-02f, 2.86256447e-02f, 5.32189757e-02f, -7.89032690e-03f, 5.91022670e-02f,
  6.87526688e-02f, 5.20615205e-02f, -1.62868723e-02f, -5.74233048e-02f, 6.69461787e-02f, -6.78790435e-02f, 1.66848134e-02f, 7.80845284e-02f, 1.62165277e-02f, 5.33106253e-02f,
  -1.84801687e-02f, -3.57326418e-02f, -1.40483035e-02f, 4.64480445e-02f, -3.49715464e-02f, -6.17289392e-04f, -1.22613953e-02f, -5.66940196e-02f, 1.60472710e-02f, -3.01250033e-02f,
  2.85924021e-02f, 1.21567763e-01f, -7.73265958e-02f, 4.53399029e-03f, 4.11448814e-02f, -6.68403730e-02f, 2.13539973e-02f, 4.17317562e-02f, -1.61408540e-02f, -4.07074727e-02f,
  -8.02579150e-03f, -4.10969146e-02f, -7.06059067e-03f, 3.42959608e-03f, -5.20720109e-02f, 6.94557130e-02f, 5.33685684e-02f, -5.59597276e-02f, 7.62563571e-02f, 1.91371683e-02f,
  6.58744276e-02f, -2.22669169e-02f, 1.88390035e-02f, -1.02341637e-01f, 3.19016655e-03f, -5.57145802e-03f, 4.31797020e-02f, 3.24649131e-03f, 8.08856264e-02f, 4.75684963e-02f,
  -3.33690464e-01f, -9.62275639e-02f, 7.41217434e-02f, 6.20793272e-03f, -1.29271537e-01f, -4.88155745e-02f, -1.59841031e-02f, -8.81095454e-02f, -1.08789094e-01f, 9.72931758e-02f,
  1.33881643e-01f, -1.09480478e-01f, 9.20270532e-02f, 3.99430878e-02f, -1.09899327e-01f, -8.29567984e-02f, -5.98844364e-02f, -6.74764141e-02f, -1.08992256e-01f, 1.23555340e-01f,
  -3.66237238e-02f, 7.99576342e-02f, 1.27532616e-01f, 6.98179305e-02f, 5.47132790e-02f, 1.11060664e-01f, 1.26178876e-01f, 2.28306994e-01f, 1.30691782e-01f, -7.45211691e-02f,
  -8.81623328e-02f, -1.11196218e-02f, 1.53153727e-03f, 5.57727255e-02f, 4.13848087e-02f, 6.86429143e-02f, 1.03384584e-01f, -9.60854534e-03f, -3.00967414e-02f, 1.31598990e-02f,
  3.88239063e-02f, -4.41702120e-02f, 1.66857149e-02f, -3.35069522e-02f, -5.84754720e-02f, 3.47639807e-02f, -7.05906153e-02f, -5.94842620e-02f, -2.19782591e-02f, -1.13293909e-01f,
  -8.79486278e-02f, -6.27924725e-02f, 1.06285801e-02f, 1.38438372e-02f, 4.70548868e-03f, 5.27889319e-02f, 4.03548777e-02f, 4.53693159e-02f, -9.98635739e-02f, -6.51410222e-02f,
  7.59580359e-02f, 2.08215360e-02f, -1.16766728e-02f, -3.49248797e-02f, -3.56526859e-02f, 1.41578233e-02f, -2.82848108e-04f, -1.59280561e-02f, 4.73350696e-02f, 3.12041817e-03f,
  6.23144694e-02f, -5.30677810e-02f, 4.75748330e-02f, -5.53855821e-02f, -5.38263097e-02f, -3.45533970e-03f, 6.31567910e-02f, 5.11657409e-02f, -4.14909720e-02f, -5.81762865e-02f,
  5.13690971e-02f, -4.12477665e-02f, 5.69872186e-02f, 1.04901055e-02f, 5.74318739e-03f, 8.62318743e-03f, 5.62597401e-02f, 1.71533301e-02f, 3.33739668e-02f, 6.87286481e-02f,
  -1.94343291e-02f, 1.25639752e-01f, 9.63841900e-02f, -2.16738731e-02f, 8.96144286e-02f, -7.85853192e-02f, 1.35142459e-02f, 4.83300956e-03f, 2.43188255e-02f, -4.95123900e-02f,
  7.56799653e-02f, -4.61576879e-03f, 4.51204507e-03f, 8.52447450e-02f, 6.49907961e-02f, -1.92430150e-02f, 5.65459244e-02f, 6.11722320e-02f, 1.09025590e-01f, 2.77185682e-02f,
  4.13221046e-02f, 6.81437552e-02f, -2.86902301e-02f, -7.02070594e-02f, -4.11923118e-02f, -2.13322733e-02f, -7.05451593e-02f, -5.36617152e-02f, 6.91597834e-02f, 2.46224180e-03f,
  9.23686661e-03f, 6.95436224e-02f, 2.86247581e-01f, 1.29568517e-01f, 1.16045967e-01f, -3.81692778e-03f, -4.80422378e-02f, 2.17541263e-01f, 1.14650629e-01f, -1.15630291e-01f,
  -1.72116324e-01f, 9.43173096e-02f, -5.15616275e-02f, -2.04928368e-02f, -8.31999928e-02f, -7.50348344e-02f, -2.87017711e-02f, -2.23738998e-02f, 1.27857819e-01f, 1.14229791e-01f,
  1.03553481e-01f, -1.08048245e-01f, 1.34455875e-01f, 4.72708680e-02f, 1.37891527e-02f, 3.74666862e-02f, -2.74587393e-01f, 1.06049590e-01f, -1.01403832e-01f, -1.80812776e-02f,
  -5.76665476e-02f, 9.95832533e-02f, -1.30389472e-02f, 1.09832756e-01f, -5.27502410e-02f, 9.58004408e-03f, -5.62832803e-02f, -3.47491540e-02f, -1.41898133e-02f, 8.68986640e-03f,
  -8.78184859e-04f, 5.04277162e-02f, 7.37480447e-02f, -4.91281338e-02f, 9.35286507e-02f, 1.02894425e-01f, 7.73873031e-02f, 2.71207877e-02f, 2.23226249e-02f, 6.13442659e-02f,
  1.16122790e-01f, 1.06292039e-01f, 3.44547629e-02f, -3.34967598e-02f, -5.43918498e-02f, 4.59539369e-02f, 2.99012866e-02f, -6.73083290e-02f, -2.57786047e-02f, 4.80017476e-02f,
  5.72277457e-02f, -7.51798088e-03f, 4.79784794e-02f, -4.51840609e-02f, -7.17041641e-02f, -4.54523899e-02f, -4.98364791e-02f, -7.53765702e-02f, -3.65081169e-02f, 5.15999459e-02f,
  -6.32673129e-02f, -5.10950275e-02f, 4.70842943e-02f, 1.18354140e-02f, 2.46589910e-02f, -4.77039181e-02f, -6.98713884e-02f, -2.45745350e-02f, 1.27151818e-03f, 3.63106988e-02f,
  6.68126792e-02f, 4.13697548e-02f, 3.47682759e-02f, -2.01663356e-02f, 6.84737116e-02f, 7.52789341e-03f, -5.82183637e-02f, 4.83249761e-02f, -2.63447128e-02f, -1.85591716e-03f,
  -1.39584199e-01f, 4.05457392e-02f, -5.25046214e-02f, -7.33671635e-02f, 4.28156257e-02f, -8.28094631e-02f, -4.91331704e-02f, -3.60360965e-02f, 5.39366156e-02f, 6.13548979e-02f,
  -6.97729215e-02f, -6.84996173e-02f, -9.36495662e-02f, -1.39458766e-02f, -3.20859253e-02f, 2.14488301e-02f, -1.04059130e-01f, -4.94298637e-02f, 1.18452171e-02f, 6.68471977e-02f,
  -7.35710859e-02f, -9.68245864e-02f, -1.75550226e-02f, 6.11921400e-02f, -3.11027002e-02f, -8.35851207e-02f, -8.67110565e-02f, 1.77921876e-02f, 4.38743979e-02f, 2.32643262e-02f,
  -1.54761121e-01f, 1.42156720e-01f, 3.21389616e-01f, 1.89905111e-02f, -2.41350144e-01f, -8.95410478e-02f, -4.28176560e-02f, -1.43874353e-02f, -1.59967750e-01f, 9.44342371e-03f,
  -1.58070460e-01f, 7.03041926e-02f, 3.66078541e-02f, 9.57818255e-02f, 1.49010614e-01f, 4.64965105e-02f, 1.00522906e-01f, 6.71014041e-02f, 1.98168159e-02f, 5.09144478e-02f,
  9.86405388e-02f, -7.42823035e-02f, 2.31462032e-01f, -5.16029969e-02f, 3.72567624e-02f, 6.19460046e-02f, 3.97110768e-02f, 1.38472170e-02f, 7.85606652e-02f, 1.62947644e-02f,
  -6.94496855e-02f, -1.09153189e-01f, -3.84752192e-02f, 2.28919908e-02f, 4.07469943e-02f, -1.29003972e-02f, 1.29067814e-02f, 1.00366985e-02f, -1.26251793e-02f, 2.12797169e-02f,
  4.82881889e-02f, 9.59232543e-03f, -3.16851214e-02f, -5.40638342e-03f, -8.20423216e-02f, 1.71288289e-02f, 4.87134196e-02f, -4.64790650e-02f, 8.14874247e-02f, 3.95829007e-02f,
  1.06359338e-02f, -8.02796916e-04f, 4.21924219e-02f, 1.70256253e-02f, 3.37217785e-02f, 2.02578306e-02f, 9.23795030e-02f, -2.94608921e-02f, -1.56580340e-02f, 6.53298944e-03f,
  -1.82452321e-03f, 1.89528707e-02f, 4.63764071e-02f, -4.00061719e-02f, 4.53391150e-02f, -3.75167467e-02f, 7.01202452e-02f, -6.60446957e-02f, 5.32405712e-02f, 2.49253735e-02f,
  -4.43515852e-02f, 5.90109378e-02f, -8.34638178e-02f, 7.33127519e-02f, -6.25710711e-02f, -3.82598452e-02f, -1.14163756e-02f, -3.02845649e-02f, 7.16950893e-02f, -7.07790703e-02f,
  1.93359554e-02f, 4.60277731e-03f, 3.70766036e-02f, 5.01157455e-02f, 7.17313886e-02f, -1.56095652e-02f, 6.74835220e-02f, 6.54643327e-02f, 4.54430431e-02f, -1.63989794e-02f,
  2.41925009e-03f, 7.17808977e-02f, -2.30628066e-02f, -5.48645854e-02f, 3.22445966e-02f, 1.84348021e-02f, -1.21842371e-02f, -5.70505336e-02f, 8.35009962e-02f, 8.56186089e-04f,
  -3.75274085e-02f, 3.28610651e-02f, 4.77938130e-02f, 2.66523790e-02f, 3.25303972e-02f, 2.09605061e-02f, 4.08971943e-02f, 6.35372922e-02f, 2.31563337e-02f, 8.95724669e-02f,
  4.68506441e-02f, 3.74873653e-02f, 5.89404106e-02f, -5.85595556e-02f, 1.62382480e-02f, 2.59414911e-02f, -9.89012048e-02f, -3.16350311e-02f, -4.87561431e-03f, 2.45903507e-02f,
  2.11622208e-01f, -3.35634112e-01f, -1.75631970e-01f, 3.12033087e-01f, 1.02539524e-01f, 1.48037568e-01f, 2.16710418e-01f, -6.35891706e-02f, -1.50592066e-02f, -2.35414859e-02f,
  7.79077485e-02f, -1.19459093e-01f, -2.00397342e-01f, 1.37913868e-01f, 3.06210101e-01f, -1.08426146e-01f, 2.26750940e-01f, 1.37953743e-01f, -9.14382339e-02f, 6.21739291e-02f,
  9.15745571e-02f, 2.54707098e-01f, -2.68553272e-02f, -2.22474653e-02f, 1.49487302e-01f, -8.07063952e-02f, 2.44681031e-01f, -1.93762705e-01f, 1.51909202e-01f, -2.65920386e-02f,
  -3.82067710e-02f, -1.15263812e-01f, -1.53091224e-02f, -8.29927847e-02f, 1.13257542e-01f, 4.87473682e-02f, 5.71939312e-02f, 4.87477258e-02f, 5.56511693e-02f, 2.01202072e-02f,
  -2.30347160e-02f, 2.83892769e-02f, 1.42122395e-02f, -6.68385327e-02f, 1.57402456e-02f, -3.72397266e-02f, -5.31010441e-02f, 3.19324695e-02f, -5.26194610e-02f, -1.41983330e-02f,
  -1.38218915e-02f, 2.53838506e-02f, 3.68881673e-02f, -2.06127353e-02f, 3.07421833e-02f, 1.36225000e-02f, 5.58826700e-02f, -1.57235865e-03f, -4.65873629e-03f, 1.14038354e-02f,
  -2.43076887e-02f, 1.42321894e-02f, -4.88904454e-02f, 6.28971402e-03f, -4.22763117e-02f, 9.45871463e-04f, 9.20713786e-03f, 2.40955465e-02f, -6.83424175e-02f, 1.34831481e-02f,
  3.48944142e-02f, 6.29018061e-03f, 5.40323444e-02f, 4.75458205e-02f, 8.93814936e-02f, -2.18435675e-02f, 8.50011557e-02f, -6.84268251e-02f, 3.67242135e-02f, 3.26969549e-02f,
  2.65453365e-02f, 5.23050502e-02f, 2.00596936e-02f, 3.26049626e-02f, 4.68350016e-02f, 4.01261747e-02f, -3.18453126e-02f, -6.76316768e-03f, -6.24383148e-03f, 5.24309948e-02f,
  6.33261949e-02f, 6.40621483e-02f, -1.20123774e-02f, -6.95791319e-02f, -5.15953749e-02f, 3.90686169e-02f, -2.99648512e-02f, -7.06504360e-02f, -4.59922105e-02f, -2.38926392e-02f,
  4.86896746e-02f, -7.14146625e-03f, 1.92515533e-02f, 1.89373754e-02f, -2.48226163e-04f, 1.93775911e-02f, 8.64104703e-02f, 7.44875595e-02f, 8.94246399e-02f, 1.25474129e-02f,
  -9.56713688e-04f, -1.26638217e-02f, 3.26861851e-02f, 1.94750950e-02f, 4.95389923e-02f, 4.10996452e-02f, -3.33976336e-02f, -4.61567082e-02f, -6.02574600e-03f, -2.07737945e-02f,
  -3.53879780e-01f, 5.21388948e-01f, 6.38853759e-02f, -6.04863949e-02f, -1.20873697e-01f, 1.11964911e-01f, -5.01520485e-02f, 4.03831191e-02f, 6.54905010e-03f, 1.82711884e-01f,
  -6.64923117e-02f, 1.71355963e-01f, 1.86212957e-02f, 2.70532012e-01f, -1.38916716e-01f, 1.57923758e-01f, 3.12683880e-02f, 3.16931866e-02f, 4.27515469e-02f, -8.59079733e-02f,
  -5.73032983e-02f, 3.88456173e-02f, 9.58586559e-02f, 1.64858714e-01f, 1.70587823e-02f, -9.65144634e-02f, -1.23060577e-01f, -6.01031370e-02f, 1.06714837e-01f, 9.83718559e-02f,
  -1.08941093e-01f, -1.17703602e-01f, 4.53946292e-02f, 2.03599613e-02f, -1.47102684e-01f, -1.08213648e-01f, -5.63497581e-02f, -1.39668724e-02f, 1.00528896e-02f, -1.94224920e-02f,
  -3.05238105e-02f, -2.78970320e-02f, 5.91167174e-02f, 1.82080991e-03f, 4.32051495e-02f, 5.91335371e-02f, 5.36936186e-02f, 8.40832144e-02f, 6.71193376e-02f, -2.08038334e-02f,
  7.65937567e-02f, -6.13449886e-03f, 1.19234277e-02f, -3.07646114e-02f, -6.24366291e-02f, -9.16541461e-03f, 8.66622315e-04f, -5.26873618e-02f, 4.97510843e-02f, -3.68454829e-02f,
  -2.83432454e-02f, -8.11458752e-02f, 4.51582223e-02f, 4.52253483e-02f, 5.70449494e-02f, -1.41499387e-02f, 5.65408804e-02f, -4.88777906e-02f, -7.79460073e-02f, -2.58621834e-02f,
  -5.40876426e-02f, 1.89750567e-02f, 1.45393349e-02f, -3.42446938e-02f, -6.86210394e-02f, 5.89085452e-04f, -1.78198349e-02f, -4.03719656e-02f, -8.27550981e-03f, -1.27230473e-02f,
  3.29569243e-02f, -4.02150676e-03f, -3.22738215e-02f, -2.44456567e-02f, 6.97742924e-02f, -4.63042185e-02f, 7.33168283e-03f, 4.06890176e-02f, 8.45476612e-03f, -2.37402716e-03f,
  -2.99773607e-02f, -1.29814565e-01f, -2.69048363e-02f, -2.39961147e-02f, 1.16629951e-01f, 1.85504407e-02f, 7.43649602e-02f, 7.01474398e-02f, -2.04783020e-04f, -7.38672614e-02f,
  -2.17897575e-02f, -2.39091311e-02f, -4.90840711e-02f, -5.30745694e-03f, -3.88540216e-02f, -3.04787816e-03f, -3.28483842e-02f, 1.47124873e-02f, -3.29985768e-02f, 2.93077119e-02f,
  -3.41610145e-03f, -4.63526249e-02f, -2.53491905e-02f, -4.38902453e-02f, -8.34342651e-03f, -7.28335306e-02f, -4.97807823e-02f, 2.48808041e-02f, 2.58287089e-03f, 4.32783850e-02f,
  -3.10670882e-01f, 2.46818408e-01f, 1.85203016e-01f, -3.17628197e-02f, -2.23337755e-01f, -6.14232346e-02f, -8.58060792e-02f, 2.21078694e-02f, -1.15776502e-01f, 1.00600801e-01f,
  -8.50265771e-02f, -1.00506730e-01f, 2.07843110e-01f, 6.49492431e-04f, -4.46616635e-02f, 1.45416275e-01f, 2.27593463e-02f, 2.83979736e-02f, 7.92108104e-02f, 3.50433365e-02f,
  2.21835356e-02f, -1.08726673e-01f, 1.54861987e-01f, 9.54497419e-03f, -9.66648906e-02f, -1.95561759e-02f, -8.65899995e-02f, 7.25073293e-02f, -7.69933313e-02f, 1.75641030e-02f,
  4.31017652e-02f, -1.33081451e-02f, -7.54684536e-03f, 9.14211869e-02f, 5.48157133e-02f, 5.33360988e-02f, -3.89252938e-02f, -5.92806451e-02f, 3.65486331e-02f, -5.64257950e-02f,
  -1.61780864e-02f, -1.15663948e-04f, -9.81853455e-02f, -3.74736786e-02f, -2.90181655e-02f, -5.33498749e-02f, -9.06647369e-03f, -8.62263609e-03f, 4.04081866e-02f, 4.09351289e-02f,
  9.26722437e-02f, 3.38459536e-02f, -3.30778733e-02f, 6.78625554e-02f, 2.82214042e-02f, 2.21130047e-02f, 2.07813107e-03f, 9.15286019e-02f, -3.92560251e-02f, -7.24383770e-03f,
  5.30069806e-02f, 1.40547417e-02f, 2.65360158e-02f, -7.93869421e-03f, -4.64033931e-02f, -3.13388854e-02f, -2.86495476e-03f, 6.56002853e-03f, 3.28699239e-02f, 2.69045886e-02f,
  1.69492830e-02f, -4.20087948e-02f, 4.76094671e-02f, -1.89573467e-02f, -3.72134410e-02f, 4.64954004e-02f, -4.38519567e-02f, 5.41275442e-02f, 1.19762076e-02f, 4.94160131e-02f,
  1.13128277e-03f, -2.45974343e-02f, 5.63799515e-02f, 3.61464126e-03f, 4.09112945e-02f, 6.97694197e-02f, 3.49877104e-02f, 4.77849506e-02f, 5.74951544e-02f, 4.80010733e-03f,
  3.51283886e-02f, 1.94290113e-02f, 1.03665218e-01f, -2.71958597e-02f, 2.22704876e-02f, -6.28211498e-02f, 1.29556805e-02f, 4.95838597e-02f, -5.71437962e-02f, 5.10024987e-02f,
  -2.94923577e-02f, -4.11332548e-02f, 7.60055780e-02f, -1.73543990e-02f, -4.85820584e-02f, 2.19109021e-02f, -1.56406518e-02f, 1.25739826e-02f, -1.80707239e-02f, 6.93272576e-02f,
  -2.05649920e-02f, 3.73754092e-02f, -6.29128963e-02f, -7.15307891e-02f, -1.10417018e-02f, 1.87768172e-02f, -5.49107743e-03f, 6.10171556e-02f, -5.14115430e-02f, 3.76545303e-02f,
  2.45119408e-01f, 1.18680196e-02f, -1.90106854e-01f, 1.05085194e-01f, 7.14015886e-02f, 9.43347588e-02f, 6.22668527e-02f, 1.16946481e-01f, -4.26057167e-02f, 1.48433492e-01f,
  -7.28448387e-03f, 5.58640733e-02f, -1.85166791e-01f, 1.48634717e-01f, 3.67616373e-03f, -1.73831224e-01f, 1.27700314e-01f, 1.40383199e-01f, -1.44777030e-01f, 2.16843724e-01f,
  2.46515423e-02f, 2.28768885e-01f, -7.64157549e-02f, -7.18322303e-03f, 1.01977505e-01f, -8.37348849e-02f, 8.70076269e-02f, -1.53615922e-01f, 1.72329962e-01f, 2.97826286e-02f,
  1.11533649e-01f, 8.93222541e-02f, -5.29103652e-02f, 1.76798943e-02f, 7.66794756e-03f, 4.21535447e-02f, -1.26612894e-02f, -1.04547985e-01f, -5.44595122e-02f, -3.43695171e-02f,
  -9.85965598e-05f, -6.76443428e-03f, -7.93697610e-02f, -6.13419265e-02f, -3.98901990e-03f, -9.55238864e-02f, -6.36657625e-02f, 1.57991126e-02f, -7.24726170e-02f, 2.70999502e-02f,
  -9.78601128e-02f, 1.05483672e-02f, 6.12587444e-02f, 4.31925282e-02f, -2.81989444e-02f, -1.24152899e-02f, 3.51056680e-02f, -2.10887752e-02f, 4.47358238e-03f, 7.35551566e-02f,
  -7.96897709e-02f, 1.17742931e-02f, 3.56175634e-03f, -1.54067837e-02f, 5.33363037e-02f, 1.62986328e-03f, -3.35827284e-03f, 1.72818061e-02f, 5.07880636e-02f, 2.27984190e-02f,
  1.88479647e-02f, 4.13847230e-02f, -2.18492057e-02f, 1.05522415e-02f, -2.08729710e-02f, 4.28281203e-02f, -8.09804816e-03f, 6.73417896e-02f, 4.03485708e-02f, -4.64249142e-02f,
  2.47888453e-02f, -2.86358949e-02f, 4.47808690e-02f, -2.76526678e-02f, -2.43330877e-02f, -4.89116721e-02f, 5.67435585e-02f, 7.10282177e-02f, 2.39185449e-02f, 1.68013144e-02f,
  2.64219999e-01f, 2.73295283e-01f, -3.11132781e-02f, -7.50091672e-03f, -2.38507409e-02f, 7.14683831e-02f, -5.16425073e-02f, 7.32516050e-02f, -1.19506586e-02f, -4.29691933e-03f,
  2.74752043e-02f, -1.82445440e-02f, 5.37301227e-02f, 2.21477505e-02f, 4.59419675e-02f, 6.02731183e-02f, 5.74162416e-02f, 2.33162530e-02f, 1.08193099e-01f, 7.61733055e-02f,
  3.88912782e-02f, 3.84994075e-02f, -6.68989047e-02f, -2.95586442e-03f, 4.06162217e-02f, -2.04077233e-02f, 8.26572850e-02f, 1.26224039e-02f, 7.39823431e-02f, 3.05696074e-02f,
  1.35109708e-01f, -1.13378331e-01f, -1.30045280e-01f, 1.89224616e-01f, 1.17898121e-01f, -4.66066934e-02f, 1.11481518e-01f, -7.90910721e-02f, -1.21527277e-01f, 5.23686316e-03f,
  1.05411366e-01f, 1.32971434e-02f, -1.84966177e-01f, 2.25539375e-02f, -2.34738402e-02f, -1.16288573e-01f, 8.57934803e-02f, -2.04613544e-02f, -6.14739656e-02f, 1.69988573e-01f,
  -2.34770942e-02f, 1.08011097e-01f, -1.21223241e-01f, -4.12750803e-02f, 8.27893913e-02f, 2.63673458e-02f, 7.12544546e-02f, 6.40729815e-02f, 1.55274406e-01f, 2.32565720e-02f,
  1.03045456e-01f, -7.05708861e-02f, 3.84199992e-02f, -8.07342008e-02f, 3.85624431e-02f, -3.71388160e-02f, 4.39697541e-02f, -3.12637500e-02f, -5.06660752e-02f, 4.08000089e-02f,
  8.95450711e-02f, -1.48985237e-02f, 5.09500057e-02f, -5.39369658e-02f, 9.07852724e-02f, 1.64716411e-02f, -1.71204712e-02f, 1.14577347e-02f, 4.65656444e-02f, -1.16078399e-01f,
  -1.63508300e-02f, -2.69319396e-03f, 6.33952543e-02f, -3.35538983e-02f, 1.95338000e-02f, -2.29986832e-02f, 4.57376288e-03f, 7.26987273e-02f, 4.88837808e-02f, 1.84587464e-02f,
  8.05783831e-03f, -1.31262206e-02f, 4.81903814e-02f, 5.35553321e-02f, 6.42278865e-02f, -3.02201156e-02f, -5.43937348e-02f, -7.33649731e-02f, -2.03820784e-02f, 3.31239626e-02f,
  2.31386013e-02f, -3.57756987e-02f, 5.74796610e-02f, -2.36130450e-02f, -5.37904054e-02f, -5.72658777e-02f, -4.77619953e-02f, 2.05481481e-02f, 9.75927636e-02f, -6.58237264e-02f,
  6.29800335e-02f, 1.45048294e-02f, 3.22051793e-02f, 5.09409755e-02f, 4.16977610e-03f, -1.74976364e-02f, -4.81149964e-02f, -5.39011396e-02f, -3.08054276e-02f, 5.33297099e-02f,
  9.78237838e-02f, 9.22838897e-02f, 5.04267476e-02f, 4.49690484e-02f, 7.24462122e-02f, 7.41779730e-02f, -1.15829613e-02f, -5.03487140e-02f, 1.00190431e-01f, -2.60612667e-02f,
  2.99633946e-02f, 5.25712483e-02f, 3.61504592e-02f, -5.26726469e-02f, 6.74422830e-02f, -2.08240817e-03f, -1.33528933e-02f, 2.88484972e-02f, 1.66561976e-02f, 5.69881201e-02f,
  4.71508019e-02f, 5.41229956e-02f, 1.69381257e-02f, -3.16361822e-02f, -5.92613108e-02f, 1.40435132e-03f, 8.93750116e-02f, -5.48687652e-02f, -4.97213788e-02f, -5.96774407e-02f,
  -2.09751040e-01f, 3.17832790e-02f, -1.54289886e-01f, -2.03571290e-01f, 8.20295289e-02f, -7.24415779e-02f, 4.57025971e-03f, -4.52499017e-02f, -2.59496748e-01f, -1.07917683e-02f,
  9.43765640e-02f, 7.32419714e-02f, 1.47407621e-01f, 4.69782725e-02f, 2.05282539e-01f, 1.07908845e-01f, -3.39686498e-02f, -1.98097378e-02f, -1.20772839e-01f, -5.82925901e-02f,
  -5.77824153e-02f, 2.72390395e-01f, 2.75963042e-02f, 1.63245454e-01f, -5.39712533e-02f, -6.42579868e-02f, 1.06150135e-01f, 1.51514217e-01f, 8.21103677e-02f, 2.04792008e-01f,
  6.57028332e-02f, 6.85484381e-03f, -2.68792249e-02f, 3.36153656e-02f, -4.47007902e-02f, -1.73447058e-02f, 2.65093073e-02f, 1.07860751e-01f, -5.92610128e-02f, -6.68922588e-02f,
  -4.14251313e-02f, 4.67600636e-02f, -2.94010248e-02f, 9.56945941e-02f, -7.51226023e-02f, 2.80378684e-02f, -1.16763916e-02f, -1.25822186e-01f, -4.84188087e-02f, 5.56849949e-02f,
  -2.56675389e-02f, -2.51186229e-02f, -1.27387568e-01f, -6.30674660e-02f, 9.05229151e-03f, -3.98785062e-02f, -4.10518907e-02f, 2.09975317e-02f, -5.08221798e-02f, 1.22174341e-02f,
  -1.82636231e-02f, -8.67446586e-02f, -2.01823693e-02f, 2.92340666e-02f, 6.22877432e-03f, -3.62890735e-02f, -3.06401644e-02f, 2.75206137e-02f, -4.17117402e-02f, 6.14709333e-02f,
  -2.92590037e-02f, -8.17740802e-03f, -3.84830683e-02f, 1.22508220e-02f, 1.47465887e-02f, -1.88644063e-02f, 4.38100472e-03f, -2.09556948e-02f, -8.06738511e-02f, -1.36935730e-02f,
  5.22102639e-02f, 6.02434129e-02f, 6.53306907e-03f, 1.77250318e-02f, 3.23047563e-02f, 4.56542708e-03f, 2.04959903e-02f, -1.29632680e-02f, 3.18281795e-03f, 1.82059519e-02f,
  -2.04684242e-04f, -2.97024194e-02f, -4.70834300e-02f, 7.17555881e-02f, -4.93086241e-02f, 6.28945231e-02f, 3.63457203e-02f, -1.93391629e-02f, 7.59150321e-03f, 3.64068747e-02f,
  -3.09088808e-02f, 3.08180433e-02f, -1.76976398e-02f, 4.43063378e-02f, 3.64824496e-02f, -5.04473783e-02f, 5.37941158e-02f, -7.16739744e-02f, -4.98447604e-02f, -4.46544141e-02f,
  3.69209284e-03f, -6.24984391e-02f, -3.42783146e-02f, -4.58109677e-02f, -5.50589431e-03f, 9.49119276e-05f, -4.36230637e-02f, -9.46204923e-03f, 3.88845615e-02f, -5.28883114e-02f,
  -6.79217950e-02f, 1.14507027e-01f, -1.23730838e-01f, 1.10851116e-01f, 1.53966337e-01f, -2.91767828e-02f, -7.55380467e-02f, 2.58651450e-02f, 3.62768859e-01f, 2.67455038e-02f,
  -4.60728966e-02f, -9.53106135e-02f, -8.28896463e-02f, -5.29426932e-02f, -3.31010073e-01f, -3.34305502e-02f, -3.68654393e-02f, -5.87217212e-02f, 1.15703575e-01f, -9.54616144e-02f,
  3.24241035e-02f, -6.10474497e-02f, -2.29174048e-01f, -5.15671149e-02f, 3.83624993e-02f, 1.00886218e-01f, -1.44224897e-01f, -5.43986857e-02f, -1.66805923e-01f, 4.43519764e-02f,
  1.12069026e-01f, 5.49751148e-03f, -5.43677099e-02f, -6.40666783e-02f, -2.54777446e-02f, -9.44831222e-03f, -6.78679571e-02f, -7.38046318e-02f, 6.54761866e-02f, 4.65014949e-02f,
  -4.65864129e-02f, -6.66993186e-02f, 5.67523725e-02f, -5.31880036e-02f, 4.42895442e-02f, -5.27662737e-03f, 1.20927989e-02f, 2.21802946e-02f, -3.66542749e-02f, -4.06195037e-02f,
  1.86066292e-02f, 2.03575604e-02f, -2.23877896e-02f, -3.41088362e-02f, -4.04083431e-02f, 8.42852890e-03f, -5.48292324e-02f, -7.97071457e-02f, -6.34179488e-02f, 7.57143199e-02f,
  -6.39949962e-02f, 1.40626691e-02f, -1.18859066e-02f, -9.98210255e-03f, -1.91234685e-02f, 1.72281824e-02f, -7.40906522e-02f, 2.60848086e-03f, 7.09348917e-02f, -1.46352658e-02f,
  -3.68818790e-02f, 7.22368211e-02f, 2.69528981e-02f, -1.79268159e-02f, -8.68168995e-02f, 1.02836471e-02f, -6.05692565e-02f, -1.16860848e-02f, 8.16020146e-02f, -3.60920131e-02f,
  3.99290398e-03f, 3.27354334e-02f, 1.04853474e-02f, -3.06560863e-02f, 3.65996696e-02f, 8.81781522e-03f, 6.98466375e-02f, 7.69859329e-02f, 8.46996624e-03f, -1.11212926e-02f,
  -4.49669994e-02f, -3.50485668e-02f, -6.61444850e-03f, 7.22978562e-02f, 5.64193800e-02f, -6.43049777e-02f, 7.95260966e-02f, 3.19391638e-02f, -8.79959688e-02f, -4.25424688e-02f,
  -4.89874594e-02f, 6.87528104e-02f, -6.78583905e-02f, 3.86472717e-02f, -3.08153089e-02f, -9.19593126e-02f, -7.24273548e-02f, -2.66518891e-02f, -2.94828266e-02f, -8.36093724e-02f,
  -5.82425781e-02f, -1.60550661e-02f, -4.57908660e-02f, 1.61985494e-02f, -5.99452145e-02f, 7.05433413e-02f, -2.25283206e-02f, -4.86835539e-02f, 1.89975314e-02f, -6.33699447e-02f,
  1.33849040e-01f, -3.20434868e-01f, 7.63808042e-02f, 7.61537626e-02f, -7.49018742e-03f, 8.46615285e-02f, 4.33130562e-02f, -1.19604982e-01f, 1.33212367e-02f, -2.92214453e-01f,
  -1.36665657e-01f, -1.16642863e-02f, -2.00405583e-01f, -3.94143425e-02f, 4.33313012e-01f, 4.67008613e-02f, 4.43678834e-02f, 3.82639877e-02f, 2.37592552e-02f, -1.56948641e-01f,
  3.52681614e-02f, -1.02086842e-01f, -3.54146259e-03f, -1.27640426e-01f, -7.11253360e-02f, -1.03936970e-01f, 1.59636252e-02f, -9.34141353e-02f, 3.37021798e-03f, 1.56675026e-01f,
  6.49408251e-02f, -1.12946503e-01f, 1.42587461e-02f, 7.33655412e-03f, -5.21842092e-02f, 2.24902704e-02f, 6.03968240e-02f, 2.48087454e-04f, 3.18065323e-02f, -3.15421671e-02f,
  -1.03468969e-02f, 5.92815243e-02f, 7.33551309e-02f, 7.97547922e-02f, 3.07904463e-02f, -4.29330431e-02f, 5.45172878e-02f, -4.52470640e-03f, -9.64670256e-02f, -2.67937104e-03f,
  -3.66758630e-02f, -2.34558694e-02f, -5.93397133e-02f, 2.82693021e-02f, 1.17140256e-01f, 4.99695987e-02f, 3.58128846e-02f, 6.87449658e-03f, -3.80868651e-02f, 2.99124047e-02f,
  1.43285664e-02f, -3.01886238e-02f, 1.01821804e-02f, -4.45825793e-02f, 4.22887430e-02f, -5.20403497e-02f, -3.45729850e-02f, -3.13197300e-02f, 2.29396876e-02f, 1.20315375e-03f,
  6.96171001e-02f, -2.46024784e-03f, 4.87617590e-02f, -2.71423906e-02f, 1.09010432e-02f, 9.88308433e-03f, -3.81964594e-02f, -4.41671051e-02f, 1.91543717e-02f, 3.53382714e-02f,
  -5.38783334e-02f, 5.58417141e-02f, -7.70238116e-02f, 3.66971381e-02f, -4.42545265e-02f, 2.70325299e-02f, -8.19554031e-02f, 2.93168314e-02f, -2.57515494e-04f, 2.88830083e-02f,
  4.99534362e-04f, -1.87257797e-01f, -3.85796614e-02f, 3.79227921e-02f, 3.80081832e-02f, -2.85431892e-02f, -3.53878699e-02f, 3.99033539e-02f, 3.76417302e-03f, -4.25994433e-02f,
  -3.49426530e-02f, -6.20397963e-02f, -4.30401936e-02f, 8.48807301e-03f, 6.47729114e-02f, -6.80217743e-02f, -3.09842266e-03f, -1.38470195e-02f, 7.10443184e-02f, -3.90308686e-02f,
  -5.59097640e-02f, -1.79391820e-03f, 1.93149205e-02f, -4.40132655e-02f, -3.97731811e-02f, -2.10926831e-02f, -2.56959815e-02f, 2.49564499e-02f, 4.43154350e-02f, 8.72252043e-03f,
  -2.92363673e-01f, 1.35763913e-01f, -2.22060025e-01f, -4.26248133e-01f, 1.08146928e-01f, 2.98357725e-01f, -4.08321247e-02f, 1.21990785e-01f, -3.28103602e-01f, 2.03042790e-01f,
  1.33680642e-01f, -2.49799743e-01f, 1.11941723e-02f, 9.78664029e-03f, -1.34636268e-01f, 2.80259614e-04f, 1.05009347e-01f, 3.75196859e-02f, -8.97354558e-02f, 2.88508926e-02f,
  -1.52587935e-01f, 1.15396462e-01f, -7.57406652e-02f, 2.65055031e-01f, 2.32777209e-03f, -6.48099706e-02f, 1.31920874e-01f, -9.91904456e-03f, 1.40209749e-01f, 1.43610854e-02f,
  1.93771690e-01f, -1.09829828e-01f, -3.36157158e-02f, 2.69796886e-03f, 3.57601754e-02f, 5.20369448e-02f, 1.03546726e-02f, -7.04997331e-02f, -3.52344587e-02f, -1.53062176e-02f,
  -2.27035377e-02f, 4.57764119e-02f, 2.59889830e-02f, -6.19509406e-02f, -2.98690889e-02f, -8.54449905e-03f, 2.49834657e-02f, 1.09377550e-02f, -4.71854210e-02f, -2.45617162e-02f,
  -6.52451441e-02f, 1.44837238e-03f, -1.21282786e-02f, -1.44591592e-02f, -9.34002921e-02f, 2.61988193e-02f, -6.15740642e-02f, -1.12126749e-02f, 1.50852799e-02f, 5.03728837e-02f,
  -6.43662065e-02f, 4.22618240e-02f, -7.69311097e-03f, -7.13308109e-03f, -2.50416156e-03f, 3.59824523e-02f, 3.66544956e-03f, 1.08794440e-02f, -2.30382755e-02f, 4.20948267e-02f,
  3.03071942e-02f, -4.56027798e-02f, 2.70461831e-02f, -2.64001954e-02f, 3.27631049e-02f, -2.84781195e-02f, -2.05071848e-02f, 2.26357020e-02f, -5.55232749e-04f, 3.99308093e-02f,
  -2.39750426e-02f, 5.60249276e-02f, 4.98989634e-02f, -3.48674745e-04f, -1.46614723e-02f, -5.78712672e-02f, 2.57735197e-02f, -2.66127326e-02f, -6.32819384e-02f, -3.15381810e-02f,
  3.58727723e-01f, 1.14635043e-01f, 2.61712112e-02f, 1.15410332e-02f, 5.84770106e-02f, 6.24882542e-02f, -5.98342866e-02f, -2.34725457e-02f, 3.27883027e-02f, -1.92953032e-02f,
  7.95159638e-02f, -4.94536161e-02f, 6.14365824e-02f, -3.19386385e-02f, 5.21276221e-02f, 4.28302921e-02f, -6.32044747e-02f, 4.30929065e-02f, 7.93445408e-02f, 7.85375535e-02f,
  6.26742989e-02f, 1.54012404e-02f, 3.83805064e-03f, 2.04689428e-02f, 5.04432842e-02f, -1.56214135e-02f, -2.54526045e-02f, -5.65188415e-02f, 8.48543644e-02f, -4.25753295e-02f,
  1.97685421e-01f, -1.79752082e-01f, -2.37949237e-01f, -2.25778017e-02f, 1.27952993e-02f, -4.12997693e-01f, -2.03776672e-01f, 5.99765964e-02f, 5.98757192e-02f, 5.95568754e-02f,
  1.01853400e-01f, -8.58840719e-02f, -5.53919822e-02f, -1.22317560e-01f, -3.43228161e-01f, -1.97456345e-01f, -2.23791614e-01f, -1.55916721e-01f, 5.61294053e-03f, -7.17928354e-03f,
  1.41972676e-02f, -8.03921651e-03f, -6.20008856e-02f, 1.55445293e-01f, -5.41585945e-02f, 1.39221504e-01f, 2.04353496e-01f, 6.17629029e-02f, -6.06446899e-02f, -7.92430714e-02f,
  -2.89590079e-02f, 1.29790917e-01f, 1.09472247e-02f, -1.17538553e-02f, 1.26188062e-02f, 3.87331359e-02f, -5.12112230e-02f, -5.85343726e-02f, 5.88207431e-02f, -2.59765163e-02f,
  -7.27614909e-02f, -5.59675470e-02f, 2.19942220e-02f, -2.04350445e-02f, -2.24499647e-02f, -1.06457341e-02f, -4.13143188e-02f, 3.52673121e-02f, 5.59799327e-03f, -1.16858616e-01f,
  -8.41474831e-02f, -1.03451006e-01f, -5.51243052e-02f, -5.50410673e-02f, 8.55692104e-03f, -8.14473927e-02f, -1.20549444e-02f, -9.25721228e-02f, -7.62272552e-02f, -8.14647824e-02f,
  3.31724621e-03f, 5.22200763e-02f, 6.55431375e-02f, 1.96029283e-02f, -2.62754858e-02f, 1.09760903e-01f, -5.83138056e-02f, 3.42680514e-02f, 1.66598614e-02f, 2.34697349e-02f,
  3.93043347e-02f, 3.02392151e-02f, -2.79480349e-02f, -2.43409984e-02f, 4.56222370e-02f, -4.31926884e-02f, 2.86689103e-02f, -1.36200972e-02f, 2.64229868e-02f, -1.72592830e-02f,
  3.98284905e-02f, -4.32366680e-04f, 3.04322392e-02f, -1.01301689e-02f, -8.26258771e-03f, -2.05251630e-02f, 6.77259117e-02f, -3.25642414e-02f, 1.70150064e-02f, -5.30898385e-02f,
  -3.91584449e-02f, 1.15708195e-01f, 8.07100534e-03f, 5.89711778e-02f, -4.34798039e-02f, -3.18351164e-02f, -5.99043295e-02f, -1.33220730e-02f, 1.66633539e-02f, 6.23387061e-02f,
  -2.72722710e-02f, 6.18110690e-03f, -2.39556041e-02f, -5.80844563e-03f, -1.66743454e-02f, 3.76597866e-02f, 6.37828782e-02f, -1.86212976e-02f, -5.57716824e-02f, -2.88813394e-02f,
  1.41246142e-02f, 4.99528497e-02f, 4.19674851e-02f, 2.22038180e-02f, -3.96669321e-02f, 7.21081644e-02f, -4.64699678e-02f, -3.56531553e-02f, -4.28914092e-02f, -5.79705276e-03f,
  -1.72923326e-01f, 2.07663208e-01f, -2.61653394e-01f, -1.21131480e-01f, -6.14431836e-02f, -1.83408901e-01f, -2.40998045e-01f, 3.82528529e-02f, 4.31489609e-02f, 2.22877204e-01f,
  1.67319804e-01f, -1.20868258e-01f, 1.22309841e-01f, -2.61866674e-02f, -2.79705912e-01f, 1.26835361e-01f, 1.70502104e-02f, 1.23757648e-03f, -4.62408699e-02f, -1.31837232e-02f,
  -7.88195059e-03f, 1.30130783e-01f, -6.84480220e-02f, 1.41424939e-01f, -1.69130012e-01f, 2.08042935e-02f, 1.69711336e-01f, -7.52248541e-02f, -1.05339952e-01f, -1.18984915e-01f,
  1.21074453e-01f, 1.32216364e-01f, -4.45284769e-02f, 4.46392111e-02f, 4.40651961e-02f, 5.69099328e-03f, -3.82118337e-02f, -4.40953411e-02f, -3.57449614e-02f, -5.26782535e-02f,
  4.76732962e-02f, 3.05763818e-02f, -2.24323533e-02f, 3.96171249e-02f, -3.14632282e-02f, -3.44709493e-02f, -3.16130109e-02f, -2.51595955e-02f, -5.08980602e-02f, -1.14248767e-01f,
  -8.05059820e-02f, -1.09250091e-01f, -5.29918727e-03f, 4.45968211e-02f, -2.55098995e-02f, 2.91760527e-02f, -3.46707627e-02f, -1.23540595e-01f, 3.23942788e-02f, -4.33670683e-03f,
  1.44003928e-02f, -1.60896871e-02f, 5.67733347e-02f, 1.80395264e-02f, -1.77126366e-03f, -3.00847646e-03f, 4.34037186e-02f, 3.72380354e-02f, -3.02681420e-02f, -2.59942412e-02f,
  -2.71900464e-02f, 3.33382711e-02f, 1.87430363e-02f, -3.33999060e-02f, 8.99025891e-03f, 2.27744989e-02f, 1.74869632e-03f, 5.05287386e-02f, 4.24236096e-02f, 1.40014710e-02f,
  4.90941256e-02f, -5.37853613e-02f, -2.82038152e-02f, 6.31303862e-02f, 4.49771546e-02f, -1.51915513e-02f, 9.38864425e-02f, 2.29771975e-02f, 3.89051437e-02f, 1.61562115e-03f,
  2.05360815e-01f, 2.04937860e-01f, 3.78449932e-02f, 4.20062477e-03f, 3.19213700e-03f, -2.51176246e-02f, -1.94500256e-02f, 1.84760559e-02f, 6.85187429e-02f, 4.85843979e-02f,
  -3.06756906e-02f, 2.29647420e-02f, -1.48650669e-02f, -1.48435459e-02f, -4.71574999e-02f, 1.06501624e-01f, 9.08012763e-02f, 5.48612550e-02f, 1.58101898e-02f, 2.33316813e-02f,
  2.57876259e-03f, 6.30461723e-02f, -5.13364002e-02f, -4.81208004e-02f, -2.97797956e-02f, -5.14097959e-02f, -2.52808537e-02f, -7.35870376e-02f, -5.73276170e-02f, -4.88901176e-02f,
  -1.93554565e-01f, -1.78732440e-01f, 2.85798684e-02f, -1.57579705e-01f, -4.46169414e-02f, 1.63362935e-01f, 7.97337294e-02f, -6.34141192e-02f, 1.96161404e-01f, -1.92775831e-01f,
  -2.56329417e-01f, -1.77809764e-02f, 1.57082882e-02f, -2.71114230e-01f, 1.48745432e-01f, 1.40431643e-01f, -6.73661605e-02f, -7.64387324e-02f, 7.25166276e-02f, -7.23697105e-03f,
  8.73157233e-02f, -2.23795131e-01f, -2.84995064e-02f, -1.36375293e-01f, -2.29656458e-01f, -6.18829504e-02f, -1.05602182e-01f, 4.02380675e-02f, -1.79823726e-01f, 2.40317415e-02f,
  -2.25796737e-02f, -9.75239798e-02f, -9.97417327e-03f, 2.23026592e-02f, 5.79337291e-02f, -2.93221902e-02f, -9.73703619e-03f, 5.16971946e-03f, 7.27289245e-02f, 5.54948207e-03f,
  -9.43309255e-03f, -4.62098196e-02f, -4.27018665e-03f, -1.67191960e-02f, -5.90938665e-02f, -3.01176328e-02f, -2.19060369e-02f, -3.05137374e-02f, -4.34791259e-02f, 3.18485079e-03f,
  -1.86736733e-02f, -1.99264996e-02f, 2.92869546e-02f, 2.84929909e-02f, 7.97632262e-02f, -5.65395914e-02f, 8.98763910e-02f, -6.71394868e-03f, 4.15220596e-02f, 4.94169816e-02f,
  -2.98512597e-02f, 1.01311482e-01f, 1.19085545e-02f, -4.14192863e-02f, -1.45818265e-02f, -2.56910305e-02f, 4.59343009e-02f, 3.91039328e-04f, -4.31402540e-03f, -7.59963319e-03f,
  6.93150461e-02f, -2.50852406e-02f, 1.87796669e-03f, -2.23356131e-02f, -4.37335530e-03f, 1.35679543e-02f, 2.27974653e-02f, -1.35223437e-02f, 5.92995062e-02f, -3.79205262e-03f,
  -1.08503867e-02f, 2.55317949e-02f, 1.19108418e-02f, 1.37118585e-02f, 4.72043343e-02f, -1.47566097e-02f, -1.46365538e-02f, -5.49382232e-02f, 1.35995848e-02f, -1.03160450e-02f,
  4.20645401e-02f, 5.10126278e-02f, 4.74705659e-02f, -1.69850886e-02f, -1.04538742e-02f, -3.85687836e-02f, 6.42564595e-02f, 1.19865844e-02f, -7.67523143e-03f, 5.20089380e-02f,
  4.07611430e-02f, 8.39810520e-02f, 1.92285310e-02f, -3.05345356e-02f, 9.85119678e-03f, -6.51354566e-02f, 3.47496904e-02f, 4.83741574e-02f, 6.13834849e-03f, -5.73585741e-02f,
  -2.27522161e-02f, 6.92956001e-02f, -1.74958340e-03f, -1.76490750e-02f, -4.83950675e-02f, 6.67708814e-02f, -1.04519315e-02f, 6.89446703e-02f, 6.39649108e-03f, 2.73968969e-02f,
  -8.09424371e-03f, 3.39637809e-02f, 1.52334109e-01f, -2.71096565e-02f, 4.65779826e-02f, 2.05883190e-01f, 3.14125977e-02f, -7.22307488e-02f, -9.82401967e-02f, -4.24892493e-02f,
  -4.71169651e-02f, -2.97067370e-02f, -1.68788880e-01f, -1.22455172e-01f, 1.17873223e-02f, -2.41861343e-01f, -2.29430534e-02f, -6.17137514e-02f, -8.30409527e-02f, 1.22843809e-01f,
  2.47596856e-02f, -1.70355442e-03f, 7.68572316e-02f, -8.94140918e-03f, 9.54160392e-02f, 5.00504784e-02f, 3.20803635e-02f, 1.48934245e-01f, 1.94428355e-01f, -1.11926887e-02f,
  -1.45227052e-02f, -9.28697512e-02f, 2.64837109e-02f, -1.78236645e-02f, -3.38055976e-02f, 7.00192600e-02f, 1.24564148e-01f, 3.69129851e-02f, 4.64406498e-02f, -2.61241011e-02f,
  -8.77042860e-03f, 3.10489908e-02f, -6.22104555e-02f, 1.14220874e-02f, 6.74844980e-02f, -3.33712809e-02f, 3.43241282e-02f, 7.56965280e-02f, -3.25476453e-02f, -5.05093746e-02f,
  6.19096160e-02f, -3.01060509e-02f, -5.02038449e-02f, 6.23182505e-02f, 6.41938224e-02f, -7.67111555e-02f, 9.66000631e-02f, -2.00997991e-03f, -4.06287983e-02f, -5.06998338e-02f,
  -1.66229997e-02f, 8.68761316e-02f, 5.42137325e-02f, -8.56796205e-02f, -7.47558847e-02f, 3.39213759e-02f, -9.92735755e-03f, 5.34578711e-02f, -2.14384794e-02f, -2.94182003e-02f,
  -2.65075080e-02f, -3.87548469e-02f, -4.26312536e-02f, 3.36309597e-02f, 2.76913997e-02f, -3.93643454e-02f, -4.67667691e-02f, 3.28517854e-02f, 7.84408227e-02f, 1.56656206e-02f,
  7.45298415e-02f, 1.42505309e-02f, -6.28562346e-02f, -7.14164227e-02f, -7.98042789e-02f, 1.73560400e-02f, 3.83781977e-02f, -2.48981845e-02f, -8.54913220e-02f, 7.47080892e-02f,
  4.60409820e-02f, 1.59130380e-01f, -8.05526599e-02f, 7.21543133e-02f, 5.56656048e-02f, 1.92511007e-02f, 5.08960113e-02f, 3.18895206e-02f, 6.90738261e-02f, -6.93707764e-02f,
  8.56066346e-02f, 1.49185788e-02f, -2.17869114e-02f, -6.80170730e-02f, -6.07085712e-02f, 1.86397918e-02f, 6.13773875e-02f, 4.96814959e-02f, -4.94800583e-02f, 9.10093728e-03f,
  -6.62672392e-05f, -4.90392074e-02f, -7.05385804e-02f, -6.56590909e-02f, 2.09111013e-02f, 6.80811107e-02f, -1.61131117e-02f, 2.47592945e-02f, -7.80585501e-03f, -6.43632337e-02f,
  4.59995985e-01f, -3.71198058e-01f, 1.03192262e-01f, 1.57330379e-01f, -1.61378998e-02f, -1.03254430e-01f, -8.49807113e-02f, -1.78007502e-02f, -1.12631679e-01f, -4.00827169e-01f,
  -1.42557949e-01f, 1.00349344e-01f, -2.61577845e-01f, -1.68153197e-01f, 1.57428592e-01f, -1.73458740e-01f, -3.03321760e-02f, -1.10580675e-01f, -1.26332110e-02f, -8.17965120e-02f,
  7.68715590e-02f, -1.83383420e-01f, 3.53380069e-02f, -1.04105450e-01f, -9.46133491e-03f, 1.85146451e-01f, 4.74097468e-02f, 7.09958225e-02f, 1.86745115e-02f, 2.06952207e-02f,
  8.71132780e-03f, -3.51637229e-03f, 2.60866527e-03f, 2.95187589e-02f, -2.78406218e-02f, 4.81940247e-02f, 5.21808900e-02f, 3.50004770e-02f, 3.91054600e-02f, 2.00332627e-02f,
  4.83141327e-03f, 3.94728743e-02f, 7.86378700e-03f, -2.30123904e-02f, 1.02095166e-02f, -2.62331944e-02f, -1.58457942e-02f, 8.48848522e-02f, -6.55051973e-03f, 6.26994222e-02f,
  -4.20848839e-03f, 3.77455465e-02f, 5.52219301e-02f, -5.93393855e-02f, 2.64189467e-02f, -2.29978058e-02f, 3.74702141e-02f, 6.51990697e-02f, 7.75184948e-03f, 5.65571599e-02f,
  1.05972053e-03f, -7.41795897e-02f, 3.82785909e-02f, 9.13323741e-03f, -2.16031559e-02f, -1.02336165e-02f, -3.98765132e-02f, -3.18200402e-02f, 4.75112461e-02f, -6.85457960e-02f,
  8.28694273e-03f, -6.94246637e-03f, 2.08587460e-02f, -3.01458538e-02f, -2.41154861e-02f, -2.43646302e-03f, 5.30030243e-02f, -8.27822685e-02f, 3.25242691e-02f, 1.42753245e-02f,
  -5.24692610e-02f, -6.02279827e-02f, -7.05809752e-03f, 1.76652241e-02f, -7.17020631e-02f, 4.44676243e-02f, -5.57891428e-02f, 4.38299291e-02f, 2.60004476e-02f, 1.69934351e-02f,
  -1.80352122e-01f, -2.38311708e-01f, -4.39678095e-02f, -2.71730181e-02f, -4.38347757e-02f, 1.01997480e-02f, -6.06038282e-03f, 4.38609682e-02f, 2.23554615e-02f, -6.90415576e-02f,
  -5.95046813e-03f, -1.68052725e-02f, -9.23096295e-03f, 6.19709753e-02f, 8.17192066e-03f, -3.96037940e-03f, -5.31204492e-02f, -1.17730694e-02f, 5.82193211e-02f, -2.38068495e-02f,
  1.21819158e-03f, -8.29288960e-02f, 5.34187630e-03f, -1.04906950e-02f, 1.85137941e-03f, 1.31162029e-04f, -2.95866728e-02f, -4.30177674e-02f, 2.30531655e-02f, -8.96283612e-02f,
  -2.51599491e-01f, -3.43007185e-02f, 1.03135586e-01f, -2.49172859e-02f, 8.35177824e-02f, -1.49206072e-01f, -9.64714885e-02f, 2.08563283e-02f, -2.97904313e-01f, -1.70525070e-02f,
  2.88573392e-02f, -7.74381384e-02f, 2.14971490e-02f, -1.15398586e-01f, -1.73008353e-01f, -1.27657726e-01f, -2.08894521e-01f, -8.20011720e-02f, -5.70819192e-02f, -1.61221959e-02f,
  -7.39502907e-03f, -8.61673504e-02f, 1.62345752e-01f, 1.62406415e-01f, 5.10021225e-02f, 1.39013797e-01f, 1.86959147e-01f, 1.77419081e-01f, 9.93763730e-02f, 4.63849306e-02f,
  -3.56367603e-02f, -8.87910277e-02f, 4.49472331e-02f, 5.05420230e-02f, -4.64860685e-02f, 2.12371890e-02f, 1.12256370e-01f, 8.30157846e-02f, 1.13010444e-02f, -6.50097206e-02f,
  2.16688830e-02f, 6.43602535e-02f, -2.57763583e-02f, -2.78247171e-04f, -4.13051695e-02f, 4.43436466e-02f, 1.90252438e-02f, 5.28039411e-02f, 8.90534222e-02f, -2.13084891e-02f,
  -9.30081028e-03f, 9.74777434e-03f, 4.50485386e-02f, 2.94411033e-02f, 1.16398055e-02f, 2.26351023e-02f, -3.05105243e-02f, 8.07495639e-02f, 3.44729796e-03f, -1.35051817e-01f,
  -1.18685961e-01f, -4.11038250e-02f, -6.21338282e-03f, 7.28257522e-02f, -4.91294935e-02f, 4.41877469e-02f, 1.61311980e-02f, -3.97015596e-03f, -1.51221389e-02f, -4.37394949e-03f,
  2.36612167e-02f, 4.90622669e-02f, 3.41298133e-02f, -4.74849939e-02f, 1.16655752e-02f, -9.46872588e-03f, 6.57388121e-02f, 1.61263756e-02f, -4.97837067e-02f, 2.24396456e-02f,
  -2.07049344e-02f, 1.76608842e-03f, 4.39728901e-04f, 5.07378839e-02f, -3.60953510e-02f, 1.44338096e-02f, 6.65648794e-03f, 5.11611290e-02f, -1.00761009e-02f, 4.93138507e-02f,
  -9.21762586e-02f, -1.58395857e-01f, -1.83073245e-02f, -2.63758823e-02f, 9.22976155e-03f, -7.23575205e-02f, -7.15095317e-03f, -5.77780046e-02f, -2.52212361e-02f, -4.29721624e-02f,
  2.25124154e-02f, -2.19297316e-02f, -5.12420721e-02f, 3.16901132e-02f, 8.96423459e-02f, -8.07869211e-02f, 3.91764008e-02f, -4.04474791e-03f, 6.08775467e-02f, 4.20338996e-02f,
  2.15621125e-02f, 1.77530607e-03f, -1.55824202e-03f, -2.38287216e-03f, -1.88664068e-02f, 2.59022992e-02f, -1.89747885e-02f, -5.69670200e-02f, 5.91096841e-02f, 4.11923118e-02f,
  2.44753286e-02f, 2.59954095e-01f, -1.06412368e-02f, 2.46417180e-01f, -4.18994911e-02f, 5.44789284e-02f, 1.76204089e-02f, 2.04191998e-01f, 1.65235296e-01f, 1.81376696e-01f,
  -5.06527387e-02f, 1.40924349e-01f, -1.22540325e-01f, 4.11709957e-02f, -1.00934424e-01f, -1.50877580e-01f, 2.06603885e-01f, 1.37403473e-01f, -8.93479306e-03f, 1.88083544e-01f,
  9.15378109e-02f, -5.60007095e-02f, -4.77030799e-02f, 3.12244911e-02f, 7.93324485e-02f, 2.15469465e-01f, -7.47730210e-02f, -1.70847967e-01f, 1.10856779e-01f, -1.39108390e-01f,
  -1.77834313e-02f, 1.42576277e-01f, -4.06908849e-03f, -1.13495777e-03f, 4.13463712e-02f, 1.44943837e-02f, 2.17759609e-02f, -9.64257717e-02f, -6.19128048e-02f, 2.39617974e-02f,
  2.34684013e-02f, -6.33589178e-02f, 4.82675396e-02f, -2.86085848e-02f, 6.05749786e-02f, 9.40740779e-02f, -2.14305278e-02f, 1.73468590e-02f, 3.67999636e-02f, 2.86266506e-02f,
  -3.04348320e-02f, 8.75891373e-02f, 2.95232031e-02f, 3.22587714e-02f, 6.84332028e-02f, 5.42469025e-02f, 9.13361728e-04f, 1.78012997e-02f, 8.37352872e-02f, 3.13633755e-02f,
  1.21566337e-02f, 7.26972474e-03f, -2.14757789e-02f, -5.27453385e-02f, -7.28045180e-02f, -5.00042103e-02f, -2.39267498e-02f, -3.18984576e-02f, -3.10199391e-02f, 5.94238155e-02f,
  5.83525039e-02f, 2.87119225e-02f, -2.21014395e-02f, 6.30408823e-02f, 5.41433506e-02f, 4.46142666e-02f, -3.38147171e-02f, 2.08759401e-02f, 9.51214507e-03f, -1.00319472e-03f,
  -1.49360262e-02f, 4.18566540e-03f, -3.24270874e-02f, -4.11099475e-03f, -4.15169112e-02f, -6.81757405e-02f, -1.28277410e-02f, -1.77039336e-02f, -5.01095168e-02f, -4.83334735e-02f,
  9.63600427e-02f, 2.82773405e-01f, -6.04603067e-02f, 2.16448326e-02f, -4.33837473e-02f, 4.74431142e-02f, 3.11122201e-02f, 9.74435583e-02f, 7.20191523e-02f, -2.15935558e-02f,
  9.13142487e-02f, 3.32338624e-02f, 2.34117918e-02f, 1.16107222e-02f, 4.50779870e-02f, 2.87387334e-02f, 1.43240681e-02f, 2.17650924e-02f, 2.01715007e-02f, 3.35509479e-02f,
  3.43514513e-03f, -3.40432711e-02f, 1.02059413e-02f, 6.57196669e-03f, 5.36433011e-02f, 4.50021997e-02f, 1.23990335e-01f, 1.59430169e-02f, 3.05300001e-02f, 3.12860683e-02f,
  6.00706786e-02f, 2.43788436e-01f, -3.75213213e-02f, -4.99818288e-02f, 8.23621526e-02f, 2.09275022e-01f, 1.47269085e-01f, 9.93102491e-02f, 2.48169631e-01f, 2.20791265e-01f,
  -6.75456424e-04f, 1.25508860e-01f, 3.31264921e-02f, 1.01649553e-01f, -2.90975034e-01f, -1.31154105e-01f, -1.93892885e-02f, 1.67721249e-02f, -1.23114986e-02f, 1.43964775e-02f,
  -1.81536496e-01f, -1.03767939e-01f, -1.62514165e-01f, 4.30250773e-03f, 9.13231671e-02f, -3.36436331e-02f, -2.14040488e-01f, -1.44507838e-02f, -5.40395863e-02f, -2.96090823e-02f,
  1.56291172e-01f, 6.84615746e-02f, -2.43687350e-02f, 1.27331868e-01f, -9.74252149e-02f, 4.51405719e-03f, -1.55640254e-02f, -3.57517004e-02f, -5.83445467e-02f, -2.13886444e-02f,
  4.80289869e-02f, -6.22777008e-02f, -1.27345743e-02f, 1.50836287e-02f, 1.26347661e-01f, 2.81778518e-02f, -1.67640019e-02f, 7.37308105e-03f, 6.37467206e-02f, -5.38606420e-02f,
  5.85418493e-02f, -5.24852499e-02f, 5.82262240e-02f, -3.69626954e-02f, 2.04701833e-02f, 8.68064985e-02f, -2.55588396e-03f, 4.58849687e-03f, -1.45549700e-02f, 6.06221445e-02f,
  -6.19507954e-02f, -4.55225073e-02f, 7.82356337e-02f, -4.93645156e-03f, 7.62166530e-02f, 2.39682868e-02f, -1.38488719e-02f, 9.11151932e-04f, -3.48514244e-02f, -5.27461572e-03f,
  -1.86548755e-02f, 8.69099423e-03f, -1.75101869e-02f, -4.70118672e-02f, 2.72752680e-02f, -1.11524686e-02f, 4.39334108e-04f, 2.61471011e-02f, 2.57531535e-02f, -3.03033423e-02f,
  4.16527204e-02f, 5.00594452e-02f, 2.06548739e-02f, 9.53132752e-03f, 1.67903211e-02f, 3.19053456e-02f, 9.64164827e-03f, 8.47313926e-02f, 5.39287217e-02f, -4.11974043e-02f,
  -2.63277106e-02f, -7.00012073e-02f, 4.43626381e-02f, 9.16812718e-02f, 3.95018831e-02f, 6.80317283e-02f, 2.59701442e-02f, 3.22339833e-02f, -2.25231331e-02f, 3.46266069e-02f,
  3.56697221e-03f, 2.18649791e-03f, 2.67349929e-02f, 1.62456520e-02f, -7.42894039e-02f, 1.21720340e-02f, -1.60163548e-02f, 2.03243960e-02f, 1.91906095e-02f, 3.54439616e-02f,
  4.26151091e-03f, 4.08249758e-02f, -4.82539088e-02f, -5.47589064e-02f, -3.53998765e-02f, 3.40755470e-02f, 2.23320574e-02f, 3.11302636e-02f, -7.11805746e-02f, -1.98209807e-02f,
  3.28715533e-01f, -4.14646789e-02f, 3.65536600e-01f, 8.13143179e-02f, 5.68073355e-02f, -5.68967126e-02f, -5.04190102e-02f, 1.20526413e-02f, -7.70604610e-02f, -2.20563352e-01f,
  -7.14240521e-02f, 1.63313717e-01f, 4.98582311e-02f, -2.36284301e-01f, 1.34436801e-01f, -8.20663497e-02f, -1.80375397e-01f, -9.64419357e-03f, -3.51074822e-02f, 4.57883887e-02f,
  2.16436759e-02f, -3.07926595e-01f, 1.32288918e-01f, -1.26835093e-01f, 9.53620896e-02f, 2.43754499e-02f, 6.25919625e-02f, -2.34126579e-02f, -9.93889943e-02f, -1.90316234e-02f,
  7.35285878e-02f, 8.56893882e-02f, 6.79399818e-02f, 1.56149790e-01f, 3.79642732e-02f, 7.50804096e-02f, 7.68671408e-02f, -3.32235023e-02f, 2.67230300e-03f, -2.55962950e-03f,
  1.07606955e-01f, -3.59207764e-02f, -4.45265099e-02f, -3.27631123e-02f, 5.68184769e-03f, 5.73736802e-02f, 3.18223238e-02f, -2.71825567e-02f, 4.41393666e-02f, 9.25278589e-02f,
  2.13566087e-02f, -1.99188795e-02f, -4.52643121e-03f, -2.04852950e-02f, 8.81618261e-02f, 3.38638313e-02f, -1.73996463e-02f, 5.93465893e-03f, 4.04411070e-02f, 5.15609011e-02f,
  -1.07606120e-01f, -3.00908741e-02f, -4.93695913e-03f, -6.77723158e-03f, -3.17713083e-03f, -8.14567041e-03f, -5.30248880e-02f, 2.99667176e-02f, -2.07845550e-02f, 4.29716008e-03f,
  -2.08727047e-02f, 6.25950620e-02f, 2.25511409e-04f, 2.06908733e-02f, -4.47726957e-02f, 9.60730109e-03f, -1.15190195e-02f, 9.11552832e-03f, -5.02505526e-02f, 6.84914663e-02f,
  3.38484086e-02f, 1.70181561e-02f, -8.07555169e-02f, -5.35246357e-02f, -2.74850950e-02f, -3.68071091e-03f, 3.62785137e-03f, 1.01189638e-04f, -4.59531099e-02f, 6.21744283e-02f,
  1.44446120e-01f, 9.90175456e-02f, -4.93746065e-02f, 3.12373298e-03f, 7.84365647e-03f, 1.84312910e-02f, -4.55531068e-02f, -2.37849224e-02f, -1.98892131e-02f, 1.60542019e-02f,
  -1.25069208e-02f, -3.27406488e-02f, 3.39575141e-04f, 2.08710041e-02f, -3.13242413e-02f, 1.10544162e-02f, -3.41263115e-02f, 2.25589033e-02f, 4.65797668e-04f, 2.85653193e-02f,
  -5.02017513e-03f, 8.89736041e-03f, 5.94682014e-03f, 4.76632304e-02f, -7.15178624e-02f, -6.17985092e-02f, 4.19664830e-02f, 3.77475992e-02f, 4.33372660e-03f, -6.45617321e-02f,
  -3.65003109e-01f, 5.67156337e-02f, -2.65039861e-01f, -3.75728339e-01f, 1.20284855e-01f, 4.26602475e-02f, -1.50906533e-01f, 2.19046101e-02f, -1.70072839e-01f, 9.10378546e-02f,
  -2.29701120e-02f, -6.90225288e-02f, 4.49790107e-03f, -2.11548030e-01f, -2.31236741e-01f, -5.77411316e-02f, -2.31120408e-01f, -3.63903046e-02f, 1.23105245e-02f, -1.77352667e-01f,
  -8.52820873e-02f, 1.43933687e-02f, -1.83088273e-01f, 2.06327617e-01f, -1.81558747e-02f, 1.30388457e-02f, 1.99284423e-02f, 8.29560682e-02f, 4.12664637e-02f, 1.21746644e-01f,
  -1.29804283e-01f, -1.73606828e-01f, 2.96668205e-02f, -1.74567178e-02f, -5.45184724e-02f, 3.35633643e-02f, -6.98667169e-02f, -9.59769171e-03f, -2.51213200e-02f, -6.40010685e-02f,
  -1.87919562e-04f, 6.04102425e-02f, 1.85422655e-02f, -7.42370822e-03f, 9.47586447e-03f, -1.70964077e-02f, -4.83168568e-03f, -9.21062939e-03f, -4.18000884e-04f, 5.98373264e-02f,
  -5.44708073e-02f, 2.47264579e-02f, -6.54009730e-02f, -1.81421246e-02f, 3.34739350e-02f, 4.37145047e-02f, 1.91332269e-02f, 1.82331912e-02f, 1.71677989e-03f, 3.96025032e-02f,
  4.49745096e-02f, -5.37579805e-02f, 5.41122258e-02f, -4.49789427e-02f, -1.69622786e-02f, -2.10389253e-02f, 5.92344999e-02f, -9.74155497e-03f, 4.94229347e-02f, -4.54913899e-02f,
  2.42067371e-02f, -7.33684329e-03f, 2.89760735e-02f, 5.45863248e-02f, -5.94967417e-02f, 9.11196787e-03f, -5.96771464e-02f, -2.29717954e-03f, -5.25319278e-02f, -3.82244438e-02f,
  3.90954614e-02f, -6.14438318e-02f, -2.35187337e-02f, 2.33372040e-02f, 3.42601500e-02f, -2.01783460e-02f, -3.99366356e-02f, 1.14299627e-02f, -4.45058979e-02f, 1.39005128e-02f,
  -9.56953093e-02f, -1.34521693e-01f, -4.94398847e-02f, 5.36764301e-02f, -7.59217422e-03f, 2.33262442e-02f, 4.33701277e-02f, 5.47409393e-02f, 2.07533725e-02f, 4.21808511e-02f,
  2.24173050e-02f, -3.57817337e-02f, -3.70185934e-02f, 6.34642169e-02f, 3.20221595e-02f, -3.04528289e-02f, -5.29480763e-02f, 9.15639009e-03f, -4.34745774e-02f, -3.38796689e-03f,
  1.73922777e-02f, -2.08476316e-02f, 1.13377161e-02f, 5.09042516e-02f, -1.60065349e-02f, 1.99658703e-02f, 2.73811352e-02f, 6.70503452e-02f, 5.31351231e-02f, -3.97473946e-02f,
  -8.11668038e-02f, 3.98309439e-01f, 9.85460430e-02f, 9.29754153e-02f, -2.04791591e-01f, 6.39204979e-02f, 9.01206359e-02f, 2.59430241e-03f, 1.33929029e-01f, 2.61608064e-01f,
  -1.34281471e-01f, 2.15468481e-01f, 7.10892379e-02f, 1.68360263e-01f, -1.45338595e-01f, 1.06943347e-01f, 5.12679145e-02f, 1.46564633e-01f, 4.06418964e-02f, -2.33160215e-03f,
  2.62053777e-02f, -1.29210532e-01f, -4.47841473e-02f, -1.34403452e-01f, 7.00449897e-03f, 5.22831455e-02f, -1.83131263e-01f, -1.75662026e-01f, -3.60519327e-02f, -8.37654695e-02f,
  6.96951300e-02f, 1.15308166e-01f, -7.07267895e-02f, -5.71848359e-03f, -7.04875067e-02f, -7.06507415e-02f, -2.04558875e-02f, -7.37452358e-02f, -1.44921541e-02f, 2.12831013e-02f,
  1.48851788e-02f, -7.76711777e-02f, 9.83306393e-02f, 4.10580868e-03f, 2.75945533e-02f, -1.73169449e-02f, 2.34071855e-02f, -3.19518559e-02f, 6.73251301e-02f, -2.51355357e-02f,
  3.92519943e-02f, -3.81769948e-02f, -7.53357857e-02f, -6.40387274e-03f, -2.91993208e-02f, 1.80118177e-02f, 7.07579479e-02f, -1.49641819e-02f, 4.35454287e-02f, -2.45294292e-02f,
  -6.75865114e-02f, -5.62206209e-02f, 5.37939444e-02f, -7.20391646e-02f, -4.23769243e-02f, -4.62770015e-02f, -4.69590984e-02f, 1.55210448e-03f, -3.29641216e-02f, -1.37118334e-02f,
  -3.31117325e-02f, 2.36199964e-02f, -1.15832603e-02f, 3.77041735e-02f, 4.61960398e-02f, 3.17356773e-02f, -3.64075601e-03f, -3.19189243e-02f, 3.65069844e-02f, 2.06011087e-02f,
  -3.77690867e-02f, 2.80679911e-02f, 6.75034225e-02f, -1.14396885e-02f, -4.30465713e-02f, -2.34713219e-03f, 2.09716726e-02f, -3.16521190e-02f, 4.25244356e-03f, -9.69735906e-03f,
  8.06286931e-03f, 1.10280640e-01f, 6.99528828e-02f, 2.31328662e-02f, 2.72618607e-02f, -1.89243704e-02f, 7.24495621e-03f, 8.17010738e-03f, 4.61633019e-02f, 1.20384628e-02f,
  -5.63459331e-03f, -4.85699922e-02f, -4.78796624e-02f, -8.25308915e-03f, -5.42787276e-02f, 5.18855713e-02f, 4.80452031e-02f, -2.79120486e-02f, -3.51401828e-02f, 1.40686380e-02f,
  -1.80473477e-02f, 4.87043783e-02f, 4.27489392e-02f, 5.39706461e-02f, -5.60451560e-02f, -3.28936242e-02f, 1.56502854e-02f, -3.58192958e-02f, 4.52821236e-03f, 7.07067773e-02f,
  7.25515857e-02f, -3.17112952e-01f, -1.64955407e-01f, -1.15104161e-01f, 1.61368296e-01f, 3.84108365e-01f, 1.10595763e-01f, -6.75289109e-02f, -2.67325360e-02f, -1.24694973e-01f,
  1.24745369e-01f, -2.79063582e-01f, -4.73265797e-02f, 7.02163577e-02f, 1.65899411e-01f, -8.77743065e-02f, 1.97239757e-01f, 1.31459400e-01f, -5.10196090e-02f, 3.96204144e-02f,
  6.78332672e-02f, 2.11348876e-01f, -6.08037673e-02f, -4.40153368e-02f, 1.61370918e-01f, -7.36461952e-02f, -2.30169538e-02f, -1.47191674e-01f, -4.96922918e-02f, 4.45183739e-02f,
  1.32818893e-01f, 2.45175753e-02f, 1.74777340e-02f, -6.82601035e-02f, 1.28492728e-01f, 7.75280744e-02f, -1.81913972e-02f, -5.37692457e-02f, -1.64985452e-02f, -4.97523025e-02f,
  -5.82280457e-02f, -1.29687386e-02f, -2.48057880e-02f, -3.74572761e-02f, -1.82951391e-02f, -6.78898692e-02f, 6.15286157e-02f, 4.70957235e-02f, -5.36237247e-02f, 3.26685347e-02f,
  -2.54689269e-02f, -4.11350615e-02f, 7.35704303e-02f, -5.19060716e-02f, -3.48944105e-02f, -2.10421029e-02f, 7.49769583e-02f, -3.29967998e-02f, -3.19968052e-02f, -1.85232759e-02f,
  5.38999923e-02f, -5.31869195e-02f, 3.31583843e-02f, -4.13774140e-02f, -3.45247425e-02f, -1.37573145e-02f, -1.16514340e-02f, 2.08959021e-02f, -3.89927700e-02f, 3.09136771e-02f,
  -5.86647317e-02f, -4.20874804e-02f, 4.33130227e-02f, -2.97972746e-02f, 3.40193585e-02f, -2.63508968e-03f, -4.96235415e-02f, -4.48536091e-02f, 6.20376831e-03f, -1.11526446e-02f,
  -5.16268797e-02f, 5.27435094e-02f, -5.49075380e-02f, 3.84588391e-02f, -2.29404625e-02f, -3.01440153e-02f, 5.85468858e-03f, -6.32654801e-02f, 3.91517840e-02f, -8.09057895e-03f,
  2.75176000e-02f, -1.65975317e-01f, -1.28391366e-02f, -4.24514636e-02f, -5.06195836e-02f, -1.76660027e-02f, 6.76778378e-03f, 5.12485541e-02f, -2.32457053e-02f, 9.94267836e-02f,
  7.04330206e-02f, 6.97999122e-03f, 1.64653473e-02f, -1.35694183e-02f, -9.07164416e-04f, 8.36823061e-02f, -7.53943622e-02f, -1.22278035e-02f, -1.12774121e-02f, -3.69795747e-02f,
  -3.43219079e-02f, 4.68873940e-02f, -6.13256264e-03f, 6.84788972e-02f, 1.24763427e-02f, -1.60316098e-02f, -3.28981951e-02f, -2.29727048e-02f, -4.35947441e-03f, -4.36177775e-02f,
  -1.00986995e-01f, -1.68027475e-01f, 1.78739965e-01f, -1.50713980e-01f, -8.16254541e-02f, -2.02547804e-01f, -2.41050929e-01f, -8.77497494e-02f, -4.14002612e-02f, -1.13466457e-01f,
  -2.86629871e-02f, -1.72734205e-02f, 3.22642811e-02f, -1.98630661e-01f, -2.35429630e-01f, -9.32383817e-03f, -2.35373348e-01f, -1.61245733e-01f, 3.24094109e-02f, -1.80031791e-01f,
  8.70165881e-03f, -2.42434219e-01f, 7.90349022e-02f, -1.07189409e-01f, -1.08828239e-01f, 1.22474566e-01f, -1.85815785e-02f, 1.62394390e-01f, -9.90909338e-02f, -1.92142259e-02f,
  -1.65752679e-01f, -4.93001640e-02f, -1.08191562e-04f, 1.05428034e-02f, -1.54316993e-02f, -1.16745364e-02f, 2.67464742e-02f, 1.81089845e-02f, 1.18879443e-02f, -6.78294003e-02f,
  -1.30132362e-02f, -3.77116352e-02f, -1.69680100e-02f, 1.32355150e-02f, -5.48428707e-02f, 7.38046989e-02f, 6.24962188e-02f, 9.76021984e-04f, -3.68939638e-02f, 4.33414690e-02f,
  2.32074689e-02f, 5.31520993e-02f, 1.82138141e-02f, 3.26425917e-02f, 7.23446831e-02f, 4.18179817e-02f, 2.38861088e-02f, 8.78548250e-02f, -7.26327254e-03f, -1.74265672e-02f,
  -7.38492794e-03f, -4.52092960e-02f, -3.71008776e-02f, -3.69969942e-02f, -8.41739029e-02f, 4.93329875e-02f, 4.57927352e-03f, -2.37486586e-02f, 2.62509426e-03f, -2.82255094e-02f,
  -4.00017090e-02f, -2.65806019e-02f, 4.77413535e-02f, -5.65050021e-02f, -2.84837447e-02f, 1.62567664e-02f, 3.99211794e-02f, -4.87532653e-02f, 6.90595619e-03f, 8.22468475e-02f,
  2.50166450e-02f, -1.93983950e-02f, 1.99744515e-02f, 6.30188510e-02f, -2.28518024e-02f, 4.38571796e-02f, 1.50274234e-02f, 6.42548688e-03f, 1.47951050e-02f, -3.35991494e-02f,
  -3.60839963e-01f, -2.32219279e-01f, 1.00752050e-02f, -4.66890261e-02f, -8.14615712e-02f, -2.84575988e-02f, -2.19719969e-02f, -4.83397394e-02f, -1.02130078e-01f, -5.95386066e-02f,
  3.37930471e-02f, 5.69897071e-02f, -2.28575729e-02f, -5.61199524e-02f, -3.78804393e-02f, -6.93311021e-02f, -1.43141981e-04f, 7.17004854e-03f, -8.73990655e-02f, -4.61565331e-02f,
  -3.93029600e-02f, -2.40711886e-02f, 2.76896115e-02f, -2.56551169e-02f, -1.19229052e-02f, -2.22090408e-02f, -9.03849304e-03f, 4.47440557e-02f, 3.70793194e-02f, -1.16197336e-02f,
  2.39002526e-01f, 4.57841083e-02f, 1.04159778e-02f, 1.62832573e-01f, 2.77488194e-02f, 1.37388617e-01f, -3.61448876e-03f, 2.38967434e-01f, 4.05037463e-01f, 4.17067707e-02f,
  -8.94782096e-02f, -8.20256472e-02f, -1.91358551e-01f, 1.29151955e-01f, 2.44434997e-01f, 1.39814004e-01f, 2.90265620e-01f, -1.42897218e-02f, 1.64685115e-01f, 7.15780035e-02f,
  1.58798352e-01f, 1.39362365e-01f, -5.78083247e-02f, 8.76427367e-02f, -3.24518941e-02f, -7.81068504e-02f, -1.16003789e-01f, -1.56845927e-01f, -3.59237120e-02f, -5.94206154e-02f,
  -2.21800469e-02f, 1.27147272e-01f, -2.58338135e-02f, 6.60473034e-02f, 2.31244322e-03f, -4.34762388e-02f, -1.10648289e-01f, -5.60548343e-02f, -4.56651347e-03f, 8.11872482e-02f,
  -2.15575639e-02f, 4.03642245e-02f, 1.03162952e-01f, -2.84267198e-02f, 1.85403842e-02f, 8.19179788e-02f, 1.43872015e-02f, -4.80195805e-02f, -7.82914385e-02f, 3.18859145e-02f,
  3.29140648e-02f, 1.99046754e-03f, -2.54128762e-02f, -4.95430566e-02f, 3.29716541e-02f, -8.86810478e-03f, 4.16441560e-02f, -7.01596886e-02f, 3.06219198e-02f, 1.12042978e-01f,
  6.19560666e-02f, 7.79850548e-03f, -3.92509103e-02f, 2.79810671e-02f, 1.33407908e-02f, -8.63617137e-02f, -2.14718245e-02f, -1.02693789e-01f, -2.14777216e-02f, -1.86681990e-02f,
  -1.64230820e-02f, 5.17861396e-02f, 5.67738675e-02f, 6.92825466e-02f, -5.27898967e-02f, 7.25520253e-02f, -9.02744010e-02f, 3.14870523e-03f, 7.03813806e-02f, 1.42317275e-02f,
  -6.41645566e-02f, 7.94428214e-02f, -2.57322621e-02f, -3.26672867e-02f, 2.41215955e-02f, -4.75848429e-02f, 3.78410593e-02f, 3.42686251e-02f, 2.82819737e-02f, -4.74334694e-02f,
  7.78954104e-02f, 2.32840717e-01f, 8.15428570e-02f, -3.59548815e-02f, -5.00809960e-02f, 1.45681966e-02f, 5.89530468e-02f, 3.37643884e-02f, 9.92999598e-02f, 5.75587153e-02f,
  -4.78178151e-02f, -9.87573061e-03f, -9.64362361e-03f, -1.13286842e-02f, 5.34311198e-02f, 7.04634935e-03f, -4.64457041e-03f, -1.34603735e-02f, 2.59511583e-02f, -9.32469312e-03f,
  -7.97849596e-02f, 3.06548327e-02f, 5.81748672e-02f, 4.72251922e-02f, -1.56289432e-02f, -2.49676500e-02f, -2.26476118e-02f, 6.74246298e-03f, -1.85298994e-02f, 4.34785299e-02f,
  -8.26201066e-02f, -1.84233095e-02f, 3.07294101e-01f, -1.73812762e-01f, -5.37675396e-02f, 1.60850689e-01f, 2.56191939e-01f, -5.92102669e-02f, 1.74475759e-02f, -1.86326310e-01f,
  -7.28665218e-02f, -3.14825960e-02f, 2.91016638e-01f, -9.94148999e-02f, 3.07437092e-01f, 3.84526581e-01f, -1.40050977e-01f, -1.06142275e-01f, 1.09982073e-01f, -1.81405246e-01f,
  -5.35625126e-03f, -1.92370489e-01f, 1.96592018e-01f, -1.81864470e-01f, -1.20318025e-01f, -1.15871027e-01f, -2.22512826e-01f, 1.61278695e-01f, -1.85864568e-01f, 3.17199416e-02f,
  6.19243458e-02f, -1.02556512e-01f, 3.08108274e-02f, -4.22162898e-02f, -1.28060458e-02f, -1.22906603e-02f, -5.06226793e-02f, 1.28036350e-01f, 4.68988717e-02f, -3.41751277e-02f,
  -4.49369550e-02f, -4.04493660e-02f, -1.04549386e-01f, 5.64765856e-02f, -3.10402975e-04f, -1.19108493e-02f, -3.13907973e-02f, 3.78847457e-02f, -3.63144279e-02f, 8.28998908e-02f,
  -6.57062279e-03f, -3.86241823e-02f, -1.86395962e-02f, -7.89352879e-02f, -1.22423805e-02f, 1.94574390e-02f, -4.84253801e-02f, 5.54045849e-02f, -1.00465037e-01f, -4.24066046e-03f,
  3.31911966e-02f, 4.27622870e-02f, 1.36167789e-02f, 2.87450850e-02f, 8.05708487e-03f, -9.42809284e-02f, -3.50174698e-04f, -1.30392332e-02f, -1.17778853e-02f, 2.30250582e-02f,
  -3.73668075e-02f, -2.21416764e-02f, -7.65983686e-02f, 2.17394647e-03f, 2.80763805e-02f, -6.20672703e-02f, 3.37463282e-02f, -2.97524780e-02f, 1.30925803e-02f, -8.48487765e-03f,
  4.56811488e-02f, -9.98324249e-04f, -6.84088562e-03f, -2.06185672e-02f, 2.21132673e-02f, 3.36017739e-03f, -5.38956299e-02f, 4.28894013e-02f, 2.71807634e-03f, 4.69912961e-03f,
  -5.45169041e-02f, -5.30227572e-02f, -3.72294150e-02f, 4.36683325e-03f, -2.14001276e-02f, 1.87970791e-02f, 1.85900722e-02f, -7.33594149e-02f, 4.36229035e-02f, 2.26700269e-02f,
  -6.14889599e-02f, -6.16398267e-02f, -6.68086996e-03f, -1.02548599e-02f, -1.18412105e-02f, 4.37749326e-02f, 5.86748961e-03f, -8.05353895e-02f, -3.75372171e-02f, -5.02653308e-02f,
  -2.91423090e-02f, 5.53628546e-04f, -1.70746781e-02f, -3.89334634e-02f, -5.65414689e-02f, -5.78589626e-02f, 2.20104828e-02f, 3.76787633e-02f, 2.89223362e-02f, 3.11727840e-02f,
  -2.51358628e-01f, 1.67028736e-02f, 1.22907743e-01f, -5.10830097e-02f, -7.80525580e-02f, 3.48828509e-02f, 5.15171289e-02f, -7.85866603e-02f, 1.87028930e-01f, 1.09131843e-01f,
  -3.68181728e-02f, -1.19157836e-01f, 9.87975225e-02f, -1.57980531e-01f, -1.32592097e-01f, 4.76695038e-02f, -8.14699978e-02f, -9.35951322e-02f, 2.96599139e-02f, -1.04005970e-01f,
  -1.45014390e-01f, -2.19954103e-01f, -1.49777740e-01f, -7.61942416e-02f, -1.07382007e-01f, -7.61665404e-02f, -1.76989511e-01f, -2.20635738e-02f, -2.25902870e-01f, -9.28086042e-03f,
  -2.99399197e-02f, 5.66167869e-02f, 8.81693438e-02f, 1.16494834e-01f, 2.13631000e-02f, -6.37295619e-02f, 1.57121979e-02f, -5.35278246e-02f, 3.18756551e-02f, 6.88585732e-03f,
  -4.25529405e-02f, 3.16996612e-02f, -5.13776802e-02f, 9.02201608e-02f, 6.02965839e-02f, -3.39267068e-02f, 8.17121565e-03f, 4.94878646e-03f, 3.05128470e-02f, -5.79428673e-02f,
  3.77434939e-02f, -5.83126396e-02f, 2.80658286e-02f, -3.47983651e-02f, 7.38507544e-04f, 5.94848730e-02f, -3.80395427e-02f, -4.27837819e-02f, 5.65032437e-02f, 2.84710880e-02f,
  4.43294346e-02f, 5.32449931e-02f, 6.17280863e-02f, -1.02379424e-02f, 4.23726216e-02f, -2.95784161e-03f, -3.15472186e-02f, -2.78370082e-03f, -2.00058660e-03f, 5.30605018e-02f,
  5.08603752e-02f, -2.62882486e-02f, 3.87700647e-02f, 6.28865138e-02f, 5.93873337e-02f, 8.35914016e-02f, 2.84732170e-02f, 2.34216657e-02f, 7.19854832e-02f, -8.47827643e-02f,
  7.85664320e-02f, -5.49271293e-02f, -3.84303927e-02f, -5.37156174e-03f, 5.01953363e-02f, 4.23274077e-02f, -1.77903622e-02f, -3.30304839e-02f, 3.83069776e-02f, -3.28164026e-02f,
  -1.08102493e-01f, -7.62848854e-02f, 3.30463727e-03f, 9.14567560e-02f, 2.95348633e-02f, -9.00304914e-02f, -5.33222035e-02f, -3.54191177e-02f, 4.52472121e-02f, -5.38660511e-02f,
  -1.14867017e-02f, -5.64484149e-02f, 4.64645177e-02f, -6.81903884e-02f, -9.59259644e-03f, -6.22971961e-03f, 3.54724266e-02f, -5.29307500e-02f, 2.54553929e-02f, -5.68884984e-02f,
  -2.15330441e-02f, 1.27969971e-02f, -1.96419451e-02f, -8.11659992e-02f, -3.28758582e-02f, -5.05726896e-02f, 2.32529151e-03f, 2.26290021e-02f, -7.62046352e-02f, 6.75004050e-02f,
  5.55790141e-02f, -1.05897235e-02f, 1.13974385e-01f, 1.62007868e-01f, 1.23769157e-01f, -2.67332017e-01f, -3.45742524e-01f, 4.58500497e-02f, 1.07178293e-01f, -2.73394436e-01f,
  -4.60652523e-02f, 8.56815651e-02f, -3.78577858e-01f, 1.19080812e-01f, -1.89480893e-02f, -1.91436157e-01f, 9.91593748e-02f, 1.14989160e-02f, 1.61494866e-01f, 9.36074704e-02f,
  1.76583648e-01f, 8.04876015e-02f, 1.01559021e-01f, 8.43555704e-02f, 1.51399061e-01f, 2.35129997e-01f, 1.08709566e-01f, -3.54975350e-02f, 1.99958518e-01f, 7.75680020e-02f,
  1.22725405e-01f, 1.08343020e-01f, 8.92732516e-02f, -2.87015624e-02f, 4.85661514e-02f, -6.52627498e-02f, -2.75346189e-04f, -1.02510870e-01f, 2.97029186e-02f, -4.64151017e-02f,
  -6.85858205e-02f, -1.42621575e-02f, 6.72467127e-02f, 2.10633501e-02f, 3.65172289e-02f, 1.05126679e-01f, 9.43683013e-02f, 1.60867535e-02f, 9.67089906e-02f, 2.00784998e-03f,
  -3.85137983e-02f, 5.31972051e-02f, 2.92137992e-02f, 5.10914586e-02f, 7.50572234e-02f, 1.93541571e-02f, -1.50942905e-02f, -8.55340734e-02f, 7.67255723e-02f, 5.51722907e-02f,
  -6.86004534e-02f, -4.43774723e-02f, -7.67127201e-02f, 4.19833371e-03f, -3.01934555e-02f, 7.78571740e-02f, -4.30267006e-02f, 2.86127739e-02f, -4.13062163e-02f, -1.92563720e-02f,
  1.45903742e-02f, 2.82412730e-02f, 7.22184777e-02f, -4.34055626e-02f, 1.55882379e-02f, -5.79645857e-02f, -3.28359380e-02f, -1.96995819e-03f, 2.84603853e-02f, 2.32705437e-02f,
  3.01004257e-02f, -1.14864828e-02f, 2.29646880e-02f, -1.62276290e-02f, -3.78747918e-02f, -2.54817009e-02f, 3.29544209e-02f, -1.33566996e-02f, 5.43585271e-02f, -6.77655712e-02f,
  -3.70329767e-02f, 3.31889652e-02f, 7.60137364e-02f, 3.35464291e-02f, -4.18375842e-02f, 2.08718665e-02f, -1.45496230e-03f, 1.69416200e-02f, 1.05759883e-02f, 2.24119499e-02f,
  2.61451546e-02f, -1.15631288e-02f, 2.51869503e-02f, -5.66642992e-02f, -2.40957998e-02f, -8.84683989e-03f, -1.21144420e-02f, 6.97495490e-02f, -1.61566958e-02f, 2.92980131e-02f,
  5.51660024e-02f, -3.41233425e-03f, -4.05124500e-02f, 9.47368797e-03f, -4.03075404e-02f, 2.67887139e-03f, -2.15700455e-02f, 7.12393597e-02f, -3.39345410e-02f, 4.23425343e-03f,
  7.19204778e-03f, -5.12684807e-02f, -9.77706611e-02f, -8.49660784e-02f, 2.27789342e-01f, -1.52842492e-01f, -3.06705266e-01f, 1.02855913e-01f, 1.94998503e-01f, -5.84159903e-02f,
  -2.00154945e-01f, -2.03742888e-02f, -1.67715326e-01f, -2.47603938e-01f, -2.66723722e-01f, -2.51163751e-01f, -2.55488366e-01f, -1.60323977e-01f, 7.82599449e-02f, 9.03662574e-03f,
  -3.29367183e-02f, -1.38918161e-01f, -1.79466054e-01f, 1.71752706e-01f, 5.98741062e-02f, 1.95305765e-01f, 5.64010292e-02f, 8.17806926e-03f, 7.75522366e-02f, -2.58060042e-02f,
  -3.98679301e-02f, -3.80697735e-02f, -1.07238637e-02f, 3.60382744e-03f, 2.09132507e-02f, -4.00889292e-02f, -3.67626473e-02f, -8.16460624e-02f, 4.65544835e-02f, -1.59115084e-02f,
  2.24178936e-02f, 7.65771046e-02f, 8.65102634e-02f, 5.78662194e-03f, 1.24826036e-01f, -1.81191731e-02f, 4.08535823e-02f, 2.66629774e-02f, 1.64458714e-02f, -4.30767909e-02f,
  2.84423381e-02f, -6.62629977e-02f, 1.70944128e-02f, -5.41322306e-03f, -3.36854309e-02f, -4.68217768e-04f, 2.57193036e-02f, 1.94554031e-02f, 4.12440673e-02f, 4.49766032e-02f,
  4.66516800e-02f, -2.53151972e-02f, -3.62285273e-03f, 4.32779081e-02f, 2.32548732e-03f, -1.41792176e-02f, -2.67923772e-02f, 5.09985257e-03f, -2.63127759e-02f, -8.74381792e-03f,
  4.56668101e-02f, -4.76142595e-04f, -1.48431407e-02f, -4.34174500e-02f, 8.51094350e-03f, -1.38909407e-02f, -4.42387797e-02f, 3.84794660e-02f, 3.95282246e-02f, 3.57520059e-02f,
  1.11979409e-03f, 1.84239133e-03f, -7.83456303e-03f, 2.67358050e-02f, -6.08059801e-02f, 2.01317091e-02f, 9.93231777e-03f, 1.42574238e-04f, 1.71737559e-02f, -8.50737095e-04f,
  -7.92499408e-02f, 3.67870219e-02f, 5.22041023e-02f, 6.89249579e-03f, -2.52599735e-02f, 4.81630228e-02f, -5.60616255e-02f, 5.57865016e-02f, -5.65608852e-02f, -1.32432655e-02f,
  2.49761548e-02f, 1.01606781e-02f, -2.74438169e-02f, -3.62352766e-02f, -7.19133466e-02f, 9.54059232e-03f, -3.63356508e-02f, -3.57814953e-02f, -4.68877591e-02f, 2.79299300e-02f,
  2.64302064e-02f, 7.28401914e-03f, -8.63502733e-03f, 2.66800039e-02f, 7.60395452e-02f, -3.89485480e-03f, -2.70829536e-04f, 6.13682065e-03f, 2.14193258e-02f, -5.07908389e-02f,
  1.89889073e-01f, -1.98074952e-01f, 4.95653115e-02f, 9.57770422e-02f, 3.10054600e-01f, 1.42992258e-01f, 2.87708398e-02f, 7.30733424e-02f, -6.45815358e-02f, -1.35239869e-01f,
  6.83754757e-02f, -6.36053011e-02f, -2.32710570e-01f, 3.12924683e-02f, -3.44444104e-02f, -3.61299217e-01f, -2.92740054e-02f, -5.97012565e-02f, -4.65175584e-02f, 5.04759587e-02f,
  1.29232526e-01f, 8.04244876e-02f, 3.59834395e-02f, 9.73725766e-02f, 1.80192962e-01f, 1.53256759e-01f, 6.99742734e-02f, 3.24903354e-02f, 1.67996243e-01f, -4.80690179e-03f,
  6.87147379e-02f, 3.06342840e-02f, 2.51127928e-02f, -4.06708941e-02f, 7.66263753e-02f, 5.17325886e-02f, -2.99842842e-02f, -1.97176002e-02f, 5.21272272e-02f, 3.26127075e-02f,
  -5.81683107e-02f, 7.76707977e-02f, -5.11284918e-02f, -3.85199524e-02f, 9.45550203e-02f, -8.51697475e-03f, -3.18911001e-02f, -7.89179280e-03f, 4.65605780e-02f, -1.93312652e-02f,
  4.15328704e-02f, 1.23177078e-02f, 5.23417182e-02f, -7.37958178e-02f, -3.48237790e-02f, 9.92675647e-02f, -3.05787083e-02f, 5.92919299e-04f, 3.29767279e-02f, 4.21206839e-02f,
  7.99872205e-02f, -1.90240741e-02f, 2.29870062e-02f, -5.72912544e-02f, 3.40576731e-02f, 6.11395501e-02f, -3.38184312e-02f, -2.53250804e-02f, 7.97598902e-03f, -1.76489782e-02f,
  -1.80561636e-02f, 5.20953462e-02f, -4.95424233e-02f, -8.74687918e-03f, 4.41110805e-02f, 3.35045867e-02f, 5.70697617e-03f, 3.58395502e-02f, 8.66094679e-02f, 2.76187551e-03f,
  -6.23879805e-02f, 3.21476236e-02f, -4.90770116e-02f, 5.11428937e-02f, -8.45609233e-03f, -5.44492118e-02f, 5.07637933e-02f, -4.87915613e-02f, -2.59199012e-02f, -5.24659269e-03f,
  -1.66057870e-01f, -1.88399315e-01f, 1.02580320e-02f, -2.66132317e-02f, -6.51244372e-02f, -2.60704383e-02f, -1.11978195e-04f, -3.87013145e-02f, -3.87136154e-02f, -6.36749789e-02f,
  3.18513289e-02f, 2.57060044e-02f, -1.74194761e-02f, 2.25152113e-02f, -3.67261693e-02f, 1.03615737e-02f, 2.95155961e-02f, -5.63891605e-02f, 3.04957796e-02f, 7.95294791e-02f,
  1.09476661e-02f, 1.16336960e-02f, 2.63892487e-02f, 9.42041725e-02f, 1.14814244e-01f, -2.74408832e-02f, 1.01459026e-01f, 3.79617065e-02f, -2.87216771e-02f, -4.39388640e-02f,
  -1.00113396e-02f, 2.82579660e-01f, 7.96968713e-02f, -1.20715208e-01f, -8.02290887e-02f, -3.29274565e-01f, -2.70549804e-01f, 2.76459996e-02f, -9.12934020e-02f, 3.64234000e-02f,
  -5.21500222e-02f, 2.38237604e-02f, 2.81593483e-02f, -2.03378871e-01f, -3.10565889e-01f, -1.74245581e-01f, -2.26708159e-01f, -1.80362687e-01f, 6.73636142e-03f, 2.78954487e-02f,
  6.38828473e-03f, -8.53663087e-02f, 5.58763882e-03f, 1.70274496e-01f, 1.59494055e-03f, 2.28150308e-01f, 1.15173385e-01f, 6.18378296e-02f, 7.50311359e-04f, -4.09054793e-02f,
  -9.63580683e-02f, -2.91079450e-02f, 1.68163236e-03f, 1.07781552e-02f, -1.20170722e-02f, -2.17611752e-02f, -2.18409337e-02f, -1.71019975e-02f, -2.41703484e-02f, 1.87983476e-02f,
  -3.12000420e-02f, 1.54507225e-02f, 2.56555043e-02f, 1.12322960e-02f, 8.11212435e-02f, 2.26688925e-02f, 5.15386462e-02f, 4.07635607e-03f, -2.04260536e-02f, 1.06906019e-01f,
  7.00087398e-02f, 6.31671771e-02f, -4.70835231e-02f, -3.28195728e-02f, -5.50324842e-03f, -1.92616470e-02f, -2.53607184e-02f, -4.21355553e-02f, 1.50176585e-02f, -6.92671835e-02f,
  8.75550322e-03f, -3.06013282e-02f, 4.35431972e-02f, -3.98891605e-02f, 2.46492531e-02f, 1.38320550e-02f, -3.02051995e-02f, -5.47018312e-02f, 4.00223322e-02f, -9.68302879e-03f,
  -5.12467846e-02f, -1.39565710e-02f, -6.70233462e-03f, -2.80627646e-02f, 2.84309033e-03f, -5.24378242e-03f, -2.69572623e-02f, -3.48649956e-02f, -4.42026518e-02f, -5.73582016e-02f,
  -4.84898612e-02f, -2.07437715e-03f, 3.45097929e-02f, -1.34136453e-02f, 1.28275873e-02f, -4.22064923e-02f, 3.57260071e-02f, 2.55437586e-02f, 4.06869389e-02f, -3.84071879e-02f,
  -2.82371622e-02f, 1.91439912e-01f, -1.16682071e-02f, -9.42587014e-03f, -2.78837513e-02f, 6.10072538e-02f, -5.42965233e-02f, -5.92968427e-02f, -3.57185639e-02f, 1.80358421e-02f,
  3.35889682e-02f, 2.59686001e-02f, 3.78733464e-02f, 4.69186008e-02f, -7.67627507e-02f, -6.17364869e-02f, -2.36643292e-02f, 5.48865553e-03f, 2.32099853e-02f, 2.44845673e-02f,
  4.68739793e-02f, 4.17848229e-02f, 3.96663435e-02f, 4.04609852e-02f, 6.30906969e-02f, -5.51621504e-02f, -5.60466908e-02f, 4.71045449e-03f, -1.45083731e-02f, 1.32674510e-02f,
  1.12122275e-01f, -5.57287261e-02f, 1.09751515e-01f, 1.24777541e-01f, 8.43850672e-02f, 2.58592665e-02f, 2.22342834e-01f, -3.11606452e-02f, 5.36628552e-02f, -6.68458268e-02f,
  -5.54817636e-03f, 1.49703085e-01f, -9.08190632e-05f, 6.97256625e-02f, -7.05545545e-02f, -1.49862692e-01f, 1.24837346e-01f, -1.60421804e-02f, -3.57605554e-02f, 1.86826304e-01f,
  -2.59186141e-02f, 1.23551473e-01f, 1.26313969e-01f, -7.70350769e-02f, 1.81074634e-01f, 1.55065665e-02f, -3.95931024e-03f, -1.77194662e-02f, -3.79627757e-02f, 1.20880216e-01f,
  2.39217952e-02f, 1.14699900e-01f, -6.68038130e-02f, 4.03045937e-02f, -5.35971336e-02f, -1.89001951e-02f, -3.75765339e-02f, 2.72718910e-02f, 6.58486038e-02f, -3.93594950e-02f,
  2.74904463e-02f, -3.45267020e-02f, 6.88676164e-02f, -6.78602904e-02f, 3.16699445e-02f, -4.34064642e-02f, -5.75246885e-02f, 1.09516997e-02f, -1.68940015e-02f, 6.26429096e-02f,
  2.53457520e-02f, -6.57142997e-02f, 4.20151539e-02f, -6.20562024e-03f, 4.27852524e-03f, -2.92652268e-02f, 3.00588571e-02f, -7.00279176e-02f, -1.24904579e-02f, -8.62532854e-02f,
  -1.48526328e-02f, 5.05785942e-02f, 8.60344470e-02f, 5.71365729e-02f, 2.57085506e-02f, 3.06097902e-02f, 3.85109149e-02f, -3.56755480e-02f, -3.33712064e-02f, -5.83273061e-02f,
  5.82803860e-02f, 5.24125360e-02f, 1.85494758e-02f, -7.81677067e-02f, -8.88970774e-03f, 6.30398691e-02f, 9.51835886e-03f, 2.82157045e-02f, -1.65944882e-02f, 5.70129678e-02f,
  5.83798364e-02f, 7.13961199e-02f, -6.70477515e-03f, 5.00224270e-02f, 3.73709053e-02f, -6.16746629e-03f, -7.22253276e-03f, 6.72428729e-03f, -3.81691679e-02f, 2.65651643e-02f,
  1.85182188e-02f, -7.61622712e-02f, -6.26600347e-03f, 1.87985301e-02f, 4.53280620e-02f, -2.36449596e-02f, 1.86463799e-02f, 4.13344800e-02f, -3.82415913e-02f, 6.37014285e-02f,
  -4.69824672e-02f, -6.38202624e-03f, -9.44576114e-02f, -7.35218897e-02f, 6.56562448e-02f, 9.63759981e-03f, 8.26932676e-03f, 6.36583492e-02f, 4.16007452e-02f, -9.87110585e-02f,
  -5.25804758e-02f, 3.77242174e-03f, -6.05556816e-02f, 7.13856309e-04f, -6.52573630e-02f, 7.84966052e-02f, -6.08253591e-02f, -2.35743336e-02f, -5.15408181e-02f, 6.28233105e-02f,
  3.51126075e-01f, -1.58948287e-01f, 2.01879546e-01f, -1.42296672e-01f, 4.42075022e-02f, -2.71448374e-01f, -5.30468114e-02f, -6.33565634e-02f, 1.28358588e-01f, -1.68899640e-01f,
  -2.36144736e-01f, 2.19736069e-01f, -5.43135293e-02f, -2.50291497e-01f, -2.15855509e-01f, -1.86760500e-01f, -2.81003356e-01f, -8.95949453e-02f, 1.18036747e-01f, -7.29016662e-02f,
  1.74210481e-02f, -4.17945623e-01f, -1.00618042e-01f, -1.91914201e-01f, -2.04004608e-02f, 1.26749486e-01f, -1.81837633e-01f, 1.04650915e-01f, -1.05002239e-01f, -8.66210908e-02f,
  8.82569142e-03f, 4.59850021e-02f, 1.11554697e-01f, 3.16346586e-02f, -7.04828724e-02f, 2.94866599e-02f, -2.68526562e-03f, 2.85015833e-02f, 3.84401157e-02f, 6.71139732e-02f,
  -1.27342334e-02f, -3.85684834e-04f, -4.85429540e-02f, -6.37380108e-02f, 1.50006516e-02f, 2.28931010e-02f, 5.29532023e-02f, 2.37978362e-02f, 5.33947125e-02f, 6.83179200e-02f,
  5.31676337e-02f, 1.81197077e-02f, 2.68845782e-02f, -3.91312167e-02f, -1.21980580e-02f, -3.07384133e-02f, -1.12554675e-03f, 5.63978925e-02f, -4.62941378e-02f, 2.60798894e-02f,
  -2.91229840e-02f, -1.90125089e-02f, -1.51337544e-02f, 4.28244658e-02f, -1.64704416e-02f, 5.89197548e-03f, -7.28970347e-03f, -3.02200299e-02f, 1.93596594e-02f, -2.99565420e-02f,
  3.81027907e-02f, 3.78921777e-02f, 3.47625688e-02f, 3.57569270e-02f, -5.06068766e-02f, 5.24247698e-02f, -3.13214101e-02f, 2.05512382e-02f, 2.00534575e-02f, 2.41850428e-02f,
  -3.92137188e-03f, -2.69309264e-02f, -2.83548571e-02f, 9.32758395e-03f, -5.09855226e-02f, -2.40306277e-02f, -1.32435858e-02f, 4.89035398e-02f, -7.47422129e-03f, -1.59982983e-02f,
  -2.48422176e-01f, -2.25262627e-01f, 5.30902967e-02f, 1.65271759e-02f, -6.50362112e-03f, -4.61056875e-03f, -3.15698758e-02f, -5.39570674e-02f, -4.81623448e-02f, -8.02467018e-02f,
  3.66802737e-02f, 2.10266635e-02f, 2.42575128e-02f, 4.28030342e-02f, -1.25212567e-02f, -1.19170668e-02f, -5.64512089e-02f, 2.69115400e-02f, -8.45132619e-02f, -8.78571346e-02f,
  -5.97545281e-02f, -6.48059696e-02f, 1.24607831e-02f, -1.64468158e-02f, -1.61157213e-02f, 2.87690535e-02f, 1.53176133e-02f, 2.88176606e-03f, -2.47442462e-02f, -5.04792072e-02f,
  1.91977084e-01f, -5.24541400e-02f, -2.09801659e-01f, -4.31054272e-02f, 6.04887977e-02f, 8.31227675e-02f, 7.82681853e-02f, 9.51091200e-02f, 1.09868594e-01f, -1.67900488e-01f,
  -5.22493161e-02f, -7.36150816e-02f, -9.62187797e-02f, -1.23456866e-01f, 2.61699080e-01f, -1.30212963e-01f, 9.66096371e-02f, -4.55086045e-02f, 7.24157989e-02f, 2.96118576e-02f,
  1.61156043e-01f, 4.89457026e-02f, -7.28465691e-02f, 5.30330911e-02f, 2.58267485e-02f, 4.38913517e-02f, 7.91086853e-02f, -1.79455206e-02f, 1.60604604e-02f, 6.86714202e-02f,
  1.13468990e-01f, -2.84345504e-02f, -6.61854595e-02f, -7.25689679e-02f, 6.38317093e-02f, -8.18937959e-04f, 2.87804212e-02f, -6.90360740e-02f, 1.03490809e-02f, -3.94600630e-02f,
  2.87759919e-02f, 7.42769465e-02f, -1.14440648e-02f, -5.49905235e-03f, 9.44792014e-03f, -8.87966007e-02f, -7.13126808e-02f, -4.49048579e-02f, -6.11379445e-02f, -6.92768171e-02f,
  -1.17529705e-01f, -5.38611189e-02f, -4.61477116e-02f, 3.07379785e-04f, -2.60603484e-02f, 6.45936504e-02f, 2.40810285e-03f, -3.62662897e-02f, 4.67871688e-03f, -3.41573805e-02f,
  6.29946887e-02f, -1.28481106e-03f, 1.26267755e-02f, -6.75572306e-02f, -3.82927470e-02f, -6.16907421e-03f, -5.98461404e-02f, -2.31469981e-02f, 7.51631148e-03f, 3.58589776e-02f,
  2.92704441e-02f, -6.27929941e-02f, 2.91133896e-02f, 3.73916589e-02f, 2.93229315e-02f, 4.34843116e-02f, 1.08856261e-02f, -1.39093101e-02f, 3.07594948e-02f, 3.07395440e-02f,
  -6.29580617e-02f, 4.16271128e-02f, 7.77037023e-03f, 1.03445975e-02f, 4.61260155e-02f, 7.01170368e-03f, -4.20176871e-02f, -1.81070473e-02f, -2.53873542e-02f, 2.18541250e-02f,
  2.76206970e-01f, 1.58483535e-01f, -1.02637354e-02f, -2.66636796e-02f, 6.43397048e-02f, -3.55402939e-02f, -6.37797499e-03f, 2.05432903e-02f, 3.82618345e-02f, 6.56659007e-02f,
  6.19773231e-02f, -5.32224327e-02f, 1.21641554e-01f, 7.73371756e-03f, -4.96991863e-03f, 3.61854285e-02f, 3.98258045e-02f, 4.89149950e-02f, 1.17005251e-01f, 1.47970458e-02f,
  2.58810688e-02f, 7.19938651e-02f, -4.39983159e-02f, 1.30971486e-03f, 3.77687067e-03f, 8.18918571e-02f, 8.54265988e-02f, -4.55039106e-02f, -3.97790447e-02f, 5.24369366e-02f,
  1.46689847e-01f, 2.05442727e-01f, 6.06579147e-02f, 9.99159664e-02f, -1.61474228e-01f, 8.58341902e-02f, 2.82120854e-01f, -1.84281349e-01f, -1.99609995e-02f, 3.74446600e-03f,
  -3.19194458e-02f, 2.94016778e-01f, 2.05689207e-01f, -9.69537944e-02f, 2.97589955e-04f, 8.74373913e-02f, -6.97882101e-02f, 1.59907058e-01f, -3.28086838e-02f, 6.33845851e-02f,
  -9.66397226e-02f, -1.05887108e-01f, -2.42995168e-03f, -2.01457232e-01f, -7.32881725e-02f, -3.13040763e-02f, -1.23026729e-01f, 4.53131157e-04f, -7.19884411e-02f, -1.98698491e-02f,
  2.46122032e-02f, -7.42003322e-02f, 4.96298820e-02f, 9.14858934e-03f, -6.86681196e-02f, -1.72442924e-02f, -1.16938204e-02f, 4.06627171e-02f, -8.69362950e-02f, -1.11146905e-02f,
  1.03166968e-01f, 2.17499658e-02f, 7.67867221e-03f, -6.27310425e-02f, -3.75928618e-02f, -3.02362107e-02f, -7.55608529e-02f, 1.37517862e-02f, 5.98673262e-02f, 4.30037864e-02f,
  7.26637840e-02f, 3.03033758e-02f, -8.53821337e-02f, 4.05292772e-02f, -2.71700043e-02f, -4.74713854e-02f, 1.59750972e-02f, 1.28007263e-01f, -1.66883357e-02f, 2.39156689e-02f,
  4.94491048e-02f, 4.53225002e-02f, 3.44686098e-02f, 5.84851112e-03f, -6.19702647e-03f, 1.50542650e-02f, -5.40672392e-02f, -1.31287919e-02f, -7.45361671e-03f, -4.00628112e-02f,
  -9.19012874e-02f, -5.09061590e-02f, -8.57558381e-03f, 3.16342339e-02f, 2.92779170e-02f, 3.38554494e-02f, -1.98229030e-02f, -3.86570720e-03f, 3.51575091e-02f, -1.40320202e-02f,
  2.43775994e-02f, 8.86750966e-03f, -4.63247038e-02f, -1.18661309e-02f, -3.09988633e-02f, -6.47261813e-02f, 1.94908772e-02f, -4.53111827e-02f, -3.45720835e-02f, 2.24185251e-02f,
  -1.03646740e-02f, 1.25986755e-01f, -9.48675501e-04f, -3.88780534e-02f, 7.35739395e-02f, 2.96912473e-02f, 4.87764888e-02f, -4.05123159e-02f, 7.96399489e-02f, -2.76560690e-02f,
  3.84374000e-02f, 5.37042692e-02f, -1.86398104e-02f, -1.21802436e-02f, 3.27229640e-03f, -8.09856281e-02f, 4.12766673e-02f, 8.89331684e-04f, -3.42099555e-02f, -2.55540479e-02f,
  5.37820049e-02f, -2.14356128e-02f, 6.56564459e-02f, 7.88388588e-03f, 2.33892277e-02f, 4.43905033e-02f, -4.26808931e-02f, 3.97195145e-02f, 3.17653641e-02f, 5.64515032e-03f,
  2.39751562e-01f, -8.35530460e-02f, -1.05433151e-01f, 1.47564098e-01f, 2.63897121e-01f, 6.26697540e-02f, -7.04455748e-02f, 2.20986269e-02f, -9.54014212e-02f, -3.38207781e-01f,
  -5.00496030e-02f, -1.22839838e-01f, -2.55311906e-01f, 4.42902371e-02f, 2.17625678e-01f, -5.93510792e-02f, 5.66912070e-02f, -4.72448580e-02f, 8.89357701e-02f, 8.51923004e-02f,
  1.36902422e-01f, -3.22073675e-03f, 1.00558162e-01f, 1.52445987e-01f, 1.39323071e-01f, 8.14736262e-02f, -7.21201003e-02f, -4.87871235e-03f, -3.10515240e-02f, 4.06965613e-02f,
  1.22313634e-01f, -8.45275149e-02f, -4.30763029e-02f, -1.98325515e-02f, -9.51485056e-03f, -4.57107276e-02f, -9.91402939e-02f, 4.27493118e-02f, 1.81734692e-02f, -3.84396091e-02f,
  2.06039194e-02f, -2.29414571e-02f, 4.20422070e-02f, 6.66520791e-03f, -3.63125373e-03f, -1.61683485e-02f, 6.70849681e-02f, 4.01479043e-02f, 1.45669924e-02f, 8.77272189e-02f,
  -4.68851998e-02f, 5.09657152e-02f, -2.05642935e-02f, -5.89614399e-02f, -1.05817607e-02f, 4.82746325e-02f, -7.09134936e-02f, -6.90178946e-02f, -3.95950954e-03f, 3.72599624e-02f,
  -1.37396632e-02f, 4.34144698e-02f, -2.72060167e-02f, 4.76762652e-02f, -3.13382741e-04f, -1.96198225e-02f, 7.82776326e-02f, -2.90453266e-02f, -3.26590762e-02f, 3.56760211e-02f,
  6.18463557e-04f, 5.69219328e-02f, -4.95891832e-02f, -4.13709395e-02f, -3.67332413e-03f, 3.62130292e-02f, -2.71145869e-02f, 2.81782132e-02f, 3.42515297e-02f, 7.63372565e-03f,
  -8.36021081e-03f, -4.24723774e-02f, -8.01822767e-02f, -2.01470237e-02f, -3.79814096e-02f, 2.07250030e-03f, 1.54684519e-03f, -7.05686435e-02f, -3.13139111e-02f, 6.96324930e-02f,
  -5.38476892e-02f, -1.89886868e-01f, -4.52488400e-02f, 1.91346426e-02f, -4.05312292e-02f, 1.86115690e-02f, 1.08342357e-02f, 1.04234107e-02f, -8.16482902e-02f, 2.63302587e-02f,
  -2.20019892e-02f, -3.67071405e-02f, -1.93874929e-02f, 4.37227823e-02f, 2.66196337e-02f, 7.66924676e-03f, -2.20903996e-02f, -3.30938864e-03f, -6.39494956e-02f, 9.26897489e-03f,
  -1.08973561e-02f, -9.89135914e-03f, -7.54649118e-02f, -7.42429448e-03f, -2.61189025e-02f, -2.29053777e-02f, 2.14530453e-02f, -6.79403096e-02f, 1.90191083e-02f, -2.23509856e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.54842883e-01f, 8.86638686e-02f, 3.46966237e-02f, 1.32124722e-01f, -8.44362378e-02f, -2.96077669e-01f, -1.28067136e-01f, 2.31129415e-02f, 1.28029743e-02f, -6.68282881e-02f,
  -3.87874171e-02f, -1.10462718e-01f, 7.32468516e-02f, -1.12871610e-01f, -1.59660820e-02f, 5.35876043e-02f, 3.18163224e-02f, -1.42626494e-01f, 2.24067550e-03f, 1.62448674e-01f,
  1.63185939e-01f, -4.25004102e-02f, 1.62488028e-01f, 1.70485809e-01f, 1.06893573e-02f, 1.44898981e-01f, 2.32221246e-01f, 1.39495254e-01f, 3.78509127e-02f, 9.17819608e-03f,
  2.43508164e-03f, 9.31199715e-02f, 7.61134773e-02f, -6.15875870e-02f, 5.59660979e-02f, -7.70902038e-02f, -2.30933260e-03f, 1.56123145e-02f, -7.72877485e-02f, 9.18216910e-03f,
  4.96529937e-02f, 1.24481022e-02f, 2.52183317e-03f, -4.48504314e-02f, 5.37662022e-02f, -2.86363699e-02f, 4.04929258e-02f, 3.50504033e-02f, 1.07968636e-02f, 5.26678190e-02f,
  -2.78052390e-02f, -2.36336272e-02f, -1.36979381e-02f, -3.00727393e-02f, 8.12663585e-02f, 9.64900292e-03f, -3.64940800e-02f, 5.41923493e-02f, -5.19946814e-02f, -1.00304866e-02f,
  -3.64977680e-02f, 5.25954217e-02f, -2.79230415e-03f, 1.59259401e-02f, -4.77671949e-03f, 4.94685732e-02f, -3.77608724e-02f, 4.10044156e-02f, -2.04866938e-03f, -6.18067831e-02f,
  -1.05402134e-02f, -4.75786701e-02f, 6.05133474e-02f, -8.19763318e-02f, -2.72329394e-02f, 5.69710024e-02f, -5.29648662e-02f, 1.93295777e-02f, 5.03068082e-02f, 1.87431052e-02f,
  1.18057607e-02f, -6.64622933e-02f, -3.91671285e-02f, -8.17735642e-02f, 2.77625974e-02f, 6.77014515e-02f, 6.02135696e-02f, -8.70418251e-02f, 2.85682436e-02f, 1.45432064e-02f,
  9.57092643e-02f, 2.85494953e-01f, 9.99267921e-02f, 3.39474715e-02f, 5.63285351e-02f, 6.24715816e-03f, 1.05805863e-02f, 2.07979043e-04f, 9.40237567e-02f, -4.10437323e-02f,
  -3.84337455e-02f, 6.42455891e-02f, -5.54001816e-02f, 8.56255274e-03f, 2.29560025e-02f, -3.64465900e-02f, 4.71119992e-02f, -6.83048815e-02f, -1.70847252e-02f, 3.93464677e-02f,
  1.01812124e-01f, -7.29175359e-02f, -5.77565730e-02f, 6.86724782e-02f, -4.04151827e-02f, -3.82891335e-02f, -9.51077640e-02f, 2.78695989e-02f, 5.19223772e-02f, 3.79403643e-02f,
  -1.08396463e-01f, 8.42384771e-02f, -8.10959190e-03f, -1.18467256e-01f, 7.70814903e-03f, -1.62781045e-01f, -1.58075064e-01f, 2.89380886e-02f, -4.82719839e-02f, -6.66257218e-02f,
  -1.35241687e-01f, -6.13641329e-02f, 1.72008246e-01f, -1.85695663e-01f, -8.62483867e-03f, 7.30642676e-02f, -2.17033461e-01f, -8.96082371e-02f, 8.91140848e-02f, -1.81641012e-01f,
  3.75204757e-02f, -1.35586366e-01f, -1.13707571e-03f, 1.02696009e-02f, -2.33788490e-01f, -5.84631376e-02f, 1.13786599e-02f, -2.64076311e-02f, -1.71014786e-01f, -1.35187590e-02f,
  -2.99944002e-02f, -7.19024390e-02f, 6.85716644e-02f, -7.19030723e-02f, -6.60019666e-02f, -6.66757077e-02f, -7.86409713e-03f, -6.38165250e-02f, -8.47786069e-02f, -5.88658303e-02f,
  2.68605519e-02f, -7.00876936e-02f, 2.17065755e-02f, 1.00541525e-01f, 5.46260178e-02f, 8.13532993e-02f, 1.71448868e-02f, 5.01984060e-02f, 6.48919195e-02f, 1.33949146e-02f,
  -7.22385570e-02f, -6.59158379e-02f, -3.99697833e-02f, 2.02945434e-02f, -1.22506479e-02f, -2.42551155e-02f, -5.38963415e-02f, 3.73514853e-02f, -7.00961724e-02f, -2.19537411e-02f,
  -1.79765485e-02f, 2.62874514e-02f, 6.50785714e-02f, -4.83485311e-02f, 6.85544033e-03f, -3.18472050e-02f, 6.24448573e-03f, -8.65387395e-02f, -7.14491159e-02f, 1.76468287e-02f,
  -6.84466735e-02f, 2.28433870e-02f, 7.68773258e-04f, -1.51035385e-02f, -5.71830459e-02f, -7.92672336e-02f, 5.69748282e-02f, -8.51792544e-02f, -1.11363577e-02f, -5.81843294e-02f,
  5.78236878e-02f, 3.44203115e-02f, -6.47939369e-02f, -2.24458948e-02f, -3.33802626e-02f, 5.03522083e-02f, -4.58296910e-02f, 4.78519797e-02f, -2.15145629e-02f, -5.83033357e-03f,
  -1.14013024e-01f, -1.03204764e-01f, 2.35648640e-02f, -9.13989246e-02f, 1.90404821e-02f, 7.01471744e-03f, -7.24293515e-02f, 8.20394531e-02f, -5.23175038e-02f, 3.44595611e-02f,
  -3.89641039e-02f, 4.11749147e-02f, 1.70514046e-03f, 6.24081865e-02f, 7.69040510e-02f, -4.68723625e-02f, 4.29922268e-02f, 6.53423667e-02f, -4.40982431e-02f, 4.63053491e-03f,
  -6.22189902e-02f, 6.78652301e-02f, -4.41728570e-02f, 2.74586659e-02f, 2.06384119e-02f, -9.38735306e-02f, -7.17560053e-02f, 2.33909190e-02f, -3.36270444e-02f, 7.23638684e-02f,
  -4.72215489e-02f, 1.27007812e-01f, -5.96115217e-02f, -1.41007185e-01f, -1.26358628e-01f, -3.56697887e-01f, -3.56250763e-01f, -8.69516060e-02f, -9.06661060e-03f, 7.17150718e-02f,
  -8.02176073e-02f, 5.96598424e-02f, 3.38546612e-04f, -1.93085134e-01f, -2.10271493e-01f, -1.99660063e-02f, -2.12176964e-01f, -1.32613093e-01f, -5.95241087e-03f, 6.08850010e-02f,
  -2.54519489e-02f, 1.18836528e-02f, 2.92925630e-02f, 4.24833558e-02f, -1.03695787e-01f, 1.16111338e-01f, 1.98108941e-01f, 6.09107539e-02f, -1.30618200e-01f, 1.15578696e-02f,
  -1.10039152e-01f, 3.84391397e-02f, 2.26967055e-02f, -7.13533685e-02f, -1.08381450e-01f, 2.73942649e-02f, -8.95200744e-02f, 2.35320069e-02f, 3.09544280e-02f, -7.76087269e-02f,
  1.11376807e-01f, -7.74350297e-03f, -5.50354980e-02f, -4.58520874e-02f, -1.28295757e-02f, 5.06983846e-02f, -2.27806661e-02f, 7.16472939e-02f, -5.22641800e-02f, 4.68787737e-02f,
  4.57778806e-03f, 2.25570407e-02f, -3.12618762e-02f, -1.96073167e-02f, -3.27736582e-03f, -3.54333036e-02f, -4.28787060e-02f, -3.92239839e-02f, -3.36995278e-03f, 8.33869800e-02f,
  -1.30686127e-02f, -7.66297355e-02f, -5.26390858e-02f, -1.03578806e-01f, -7.97443837e-02f, -6.62418455e-02f, 8.25434476e-02f, 1.78109482e-02f, 4.89091724e-02f, -4.09146808e-02f,
  -3.22570801e-02f, 6.84628636e-02f, -3.95481624e-02f, 7.13465810e-02f, 8.92390124e-03f, -5.17828427e-02f, -8.42921287e-02f, -4.64515500e-02f, -9.20194909e-02f, 4.15988564e-02f,
  1.12876423e-01f, -1.87932774e-02f, 6.64848015e-02f, -8.44784975e-02f, 3.87583449e-02f, -3.10116895e-02f, -4.58544493e-02f, -8.63179415e-02f, -1.86916795e-02f, -6.76070200e-03f,
  -1.57282054e-02f, 1.97196573e-01f, -1.77292824e-02f, -4.56603914e-02f, -9.26224166e-04f, -3.16839591e-02f, 2.59729195e-02f, -7.99604505e-02f, 5.92828616e-02f, -8.46707672e-02f,
  -6.97309226e-02f, -4.42027226e-02f, 2.63835234e-03f, 6.04729168e-02f, 5.66723421e-02f, -1.52385924e-02f, -8.90034717e-03f, 1.52495345e-02f, 1.67814287e-04f, 1.17535293e-01f,
  1.25871887e-02f, 6.84092417e-02f, 4.01830934e-02f, -4.12435606e-02f, 5.14141284e-03f, 5.58369756e-02f, 4.75956611e-02f, 1.12628117e-01f, 2.02127751e-02f, 1.17753120e-02f,
  -1.34913743e-01f, 1.01474561e-01f, 8.31993073e-02f, 3.51146907e-02f, -6.36519045e-02f, -1.24010984e-02f, -9.89913940e-02f, 1.01616010e-01f, 4.40770537e-02f, -1.72108218e-01f,
  -1.21801868e-01f, -9.98764671e-03f, -5.97209781e-02f, 5.32654412e-02f, 2.39591096e-02f, -4.46917899e-02f, 9.71280560e-02f, -3.27466661e-03f, 1.32765502e-01f, 4.27410938e-02f,
  -1.26551231e-02f, -4.79755066e-02f, 4.98968642e-03f, 6.13338947e-02f, 1.14564272e-02f, 2.71286853e-02f, -9.20228437e-02f, 2.28526555e-02f, 1.56393629e-02f, 7.61014596e-02f,
  2.83423681e-02f, -9.32397321e-02f, -7.31051117e-02f, -5.46509661e-02f, 6.00755103e-02f, -2.36796420e-02f, -7.82321095e-02f, 5.07396199e-02f, -2.86725517e-02f, 5.24384715e-02f,
  -3.86242084e-02f, -3.25224511e-02f, 7.77163059e-02f, -6.74604401e-02f, 1.96077190e-02f, -3.15119959e-02f, 6.27035573e-02f, 1.04210556e-01f, 9.79244038e-02f, 5.74964583e-02f,
  1.31064296e-01f, 8.28800257e-03f, -2.55474746e-02f, 9.67663825e-02f, 9.53996554e-02f, 7.91943073e-02f, 4.59535494e-02f, -5.43822534e-02f, 2.55917255e-02f, -1.15986494e-02f,
  -3.22397314e-02f, 2.98763867e-02f, 5.51460460e-02f, 6.91775680e-02f, 3.80512588e-02f, 2.74328943e-02f, -1.27277244e-02f, -3.16442586e-02f, 2.63222065e-02f, -6.77816942e-02f,
  -5.83478734e-02f, -6.41844645e-02f, 8.83323548e-04f, 6.26729876e-02f, -5.93452081e-02f, -6.71579465e-02f, 4.54659387e-02f, -4.92987165e-04f, 6.17533140e-02f, -2.17477549e-02f,
  -6.54921904e-02f, 2.46370528e-02f, 3.49170296e-03f, -1.44182295e-02f, 1.02142198e-02f, 5.32167181e-02f, 3.14025208e-02f, 1.02949210e-01f, -1.13242427e-02f, 5.71875833e-02f,
  -1.50675297e-01f, -9.29653496e-02f, -1.11421458e-01f, -8.42358992e-02f, 4.50904593e-02f, -8.48390236e-02f, 5.49697727e-02f, 5.25416732e-02f, 4.63082315e-03f, 2.56369039e-02f,
  1.94729604e-02f, 5.86360656e-02f, -8.89134705e-02f, -6.62860498e-02f, 4.29778099e-02f, -9.48803127e-03f, -5.74980080e-02f, -2.24564951e-02f, -6.63172081e-02f, 6.60085976e-02f,
  -7.99741074e-02f, -7.09335431e-02f, 5.57247959e-02f, 3.34025100e-02f, 1.20363468e-02f, -6.59161210e-02f, -9.15300027e-02f, -6.32093623e-02f, -7.34223574e-02f, 4.39017452e-02f,
  -2.85357863e-01f, 1.52799740e-01f, 7.17657730e-02f, -9.67295542e-02f, -5.45038283e-02f, -8.17289650e-02f, -1.92606021e-02f, 1.22036777e-01f, 5.00044189e-02f, 2.04073116e-01f,
  8.85458663e-02f, -4.67150211e-02f, 1.77354321e-01f, -4.50514629e-02f, -3.32740545e-01f, 4.01233323e-02f, -1.96922302e-01f, -1.28863171e-01f, 7.78984055e-02f, -3.81904319e-02f,
  -1.57145619e-01f, 3.29774171e-02f, -4.96374816e-02f, 1.71971798e-01f, -7.44237527e-02f, 4.28185724e-02f, -4.99837212e-02f, 8.10875818e-02f, -7.24737123e-02f, -3.87573354e-02f,
  -1.35519813e-05f, 1.92820773e-01f, -3.54181938e-02f, 2.88441479e-02f, -9.00342464e-02f, -1.08076565e-01f, -7.07684308e-02f, 2.31649894e-02f, 9.80644114e-03f, -3.60222273e-02f,
  -6.83239400e-02f, -4.85615805e-03f, 1.52982753e-02f, 5.98948076e-02f, -3.63286920e-02f, 1.39960647e-02f, -7.92069733e-02f, -2.19295006e-02f, -6.00377992e-02f, -1.82594340e-02f,
  3.97134088e-02f, -8.86052102e-02f, -3.84604260e-02f, -2.49813963e-02f, -4.71191444e-02f, 1.08506799e-01f, -1.20322155e-02f, -9.66600329e-02f, -7.02067316e-02f, 1.81291364e-02f,
  -7.80107826e-02f, -6.63572997e-02f, -2.25905273e-02f, 9.98504385e-02f, 4.05445918e-02f, 7.88975209e-02f, -8.05377439e-02f, -2.89067831e-02f, 1.98663492e-02f, 6.09172694e-02f,
  2.07846742e-02f, -5.05374633e-02f, 8.53252318e-03f, -6.46172911e-02f, -7.91756436e-02f, 6.21345709e-04f, -6.29522428e-02f, 3.36763933e-02f, 2.96233539e-02f, -3.96114588e-02f,
  6.33835793e-02f, -4.62070890e-02f, 4.82045040e-02f, -9.10163522e-02f, -6.99497312e-02f, -6.78003281e-02f, 4.03907858e-02f, -3.10968179e-02f, 5.80351204e-02f, -7.64555857e-02f,
  -6.77424157e-03f, 6.65928870e-02f, 1.24837212e-01f, 8.74483213e-03f, 8.73818770e-02f, -3.74906287e-02f, -6.35166541e-02f, 1.18667623e-02f, -1.75920557e-02f, 3.98085862e-02f,
  -6.92795515e-02f, -1.60644855e-02f, -1.90707762e-02f, 2.29374692e-02f, -3.15651596e-02f, 2.06665527e-02f, 2.16457378e-02f, -6.77416250e-02f, 1.50702540e-02f, 5.25477529e-02f,
  -2.22308859e-02f, 9.15513113e-02f, -8.19913223e-02f, -7.19743371e-02f, 7.90237542e-03f, 4.36794274e-02f, 4.11973000e-02f, -4.90186773e-02f, 7.22342283e-02f, 4.50970605e-02f,
  2.65328065e-02f, -1.99555442e-01f, 1.14196151e-01f, 3.67702767e-02f, 1.96390957e-01f, 1.73526138e-01f, 1.50298133e-01f, -9.35220346e-02f, 2.21329499e-02f, -2.47236252e-01f,
  -5.23255905e-04f, 9.33393985e-02f, 1.01869985e-01f, 3.08073703e-02f, 2.26506606e-01f, 9.75503996e-02f, 8.03721398e-02f, 7.97335729e-02f, 1.01650447e-01f, -1.12287542e-02f,
  -1.57953054e-02f, -1.02930613e-01f, -5.36349006e-02f, -9.51843485e-02f, 7.45147914e-02f, -1.48474261e-01f, -1.33146092e-01f, 1.00427151e-01f, -1.59315079e-01f, 8.68659392e-02f,
  5.72801195e-02f, -9.87416282e-02f, 6.00834116e-02f, -1.63286608e-02f, 4.73681167e-02f, 6.09107614e-02f, -6.04221039e-02f, 3.36717367e-02f, 8.61553997e-02f, 2.25317222e-03f,
  1.25046885e-02f, 4.63011153e-02f, -8.46998468e-02f, 2.12453064e-02f, 7.94986486e-02f, -9.72058922e-02f, 2.47307885e-02f, 4.53146361e-02f, -1.59947958e-03f, 5.50844055e-03f,
  5.24367653e-02f, -1.07325530e-02f, 2.94984318e-02f, 3.44536523e-03f, -8.29860941e-02f, 2.01212075e-02f, 7.56534040e-02f, 4.61780885e-03f, 4.42024954e-02f, -1.39427138e-02f,
  -7.32683539e-02f, -6.86600804e-02f, 1.82558093e-02f, 2.52321102e-02f, -6.73974827e-02f, 4.66411412e-02f, -1.66984946e-02f, -3.47528271e-02f, -6.21755794e-02f, -6.06255680e-02f,
  8.16328973e-02f, 7.98718184e-02f, -1.93042811e-02f, 4.60016448e-03f, -2.91487277e-02f, -2.20022928e-02f, 3.90959904e-02f, 3.76580209e-02f, -3.28313857e-02f, -2.18672259e-03f,
  7.96677247e-02f, 1.57787967e-02f, 2.35728472e-02f, -4.29902412e-03f, 1.04485117e-01f, 7.95503929e-02f, -1.67330708e-02f, -2.17081290e-02f, -7.49878166e-03f, -2.85359789e-02f,
  6.79985285e-02f, -2.88072508e-03f, 2.57870238e-02f, -9.87950489e-02f, -9.72540677e-02f, -2.15647556e-02f, 8.14371184e-02f, -1.99724101e-02f, -2.40300447e-02f, 3.42971534e-02f,
  -8.73486698e-02f, -1.59653313e-02f, 2.74582282e-02f, 7.93617964e-02f, 3.96534652e-02f, -5.72350947e-03f, -7.19958320e-02f, -4.54762094e-02f, -1.76939054e-03f, -2.16388423e-02f,
  -5.63577451e-02f, 3.05183455e-02f, 4.96728495e-02f, -1.66494157e-02f, -9.21564759e-04f, -9.30171311e-02f, -7.85802677e-02f, 7.50474855e-02f, 7.48196989e-02f, -3.46535891e-02f,
  -3.69952768e-01f, 1.15529492e-01f, -2.53381766e-02f, -1.63616866e-01f, -3.50683206e-03f, -3.32438760e-02f, 8.71118754e-02f, 2.43096519e-02f, 3.36208455e-02f, 3.92015055e-02f,
  4.05210070e-02f, -1.10210001e-01f, 1.51217684e-01f, 1.27416730e-01f, -2.02449039e-01f, 1.09000042e-01f, 3.37666757e-02f, -2.97860429e-02f, -5.33738509e-02f, -8.31232741e-02f,
  -1.26007393e-01f, 1.98815361e-01f, 2.41158661e-02f, 1.72921762e-01f, -2.80998163e-02f, -2.86580157e-02f, 6.44929707e-02f, 1.05675347e-02f, 7.62996674e-02f, 4.04086895e-02f,
  -7.02291876e-02f, -2.25886121e-01f, -1.27032220e-01f, -8.79635066e-02f, -1.17734596e-01f, -1.09130569e-01f, -6.18793778e-02f, -5.17783202e-02f, -5.69790490e-02f, 2.38055438e-02f,
  -7.99110979e-02f, -4.05811369e-02f, 2.21344028e-02f, 6.39351010e-02f, -3.14369351e-02f, 1.05621889e-02f, -6.21497780e-02f, 6.30418286e-02f, -6.10636957e-02f, -2.30444074e-02f,
  -3.35969515e-02f, 1.29436543e-02f, -1.65104847e-02f, -2.75243111e-02f, 6.71216398e-02f, 6.22621700e-02f, 6.87902048e-02f, 3.13671455e-02f, -5.97464070e-02f, 1.79256650e-03f,
  2.14688275e-02f, -5.47875185e-03f, -2.70893592e-02f, -5.23694195e-02f, 3.15719619e-02f, 1.01641994e-02f, -6.80487156e-02f, 4.25292440e-02f, -6.30531227e-03f, 1.16593565e-03f,
  4.19720560e-02f, -3.74315642e-02f, -8.60606134e-03f, -2.23441515e-03f, -3.70588386e-03f, -5.49446233e-02f, -5.06262854e-02f, -5.69924247e-03f, 8.30145404e-02f, -7.49609945e-03f,
  4.72168066e-03f, -2.11338867e-02f, -4.16986980e-02f, -2.48151124e-02f, -7.80346766e-02f, -2.93019358e-02f, -1.08198973e-03f, 3.24440747e-02f, -3.07485592e-02f, -3.13656740e-02f,
  -2.20675826e-01f, -1.89140692e-01f, -7.61123747e-02f, -4.97667007e-02f, 2.29306496e-03f, -2.02499405e-02f, -8.09333399e-02f, -3.61449905e-02f, 2.44553257e-02f, -1.82198342e-02f,
  -4.96428460e-02f, 5.64242452e-02f, -1.15238987e-02f, -7.95665532e-02f, -3.92142609e-02f, -5.06881205e-03f, 5.08121625e-02f, 3.29928845e-02f, 1.75730884e-02f, 7.48465508e-02f,
  -6.16044626e-02f, 3.96778025e-02f, 2.80567817e-02f, 1.43957390e-02f, 3.92013974e-02f, -7.96507206e-03f, -9.49926376e-02f, 1.47009389e-02f, -5.05580567e-02f, -4.43253778e-02f,
  1.86917558e-01f, 7.53620220e-03f, -1.92703828e-01f, -3.84236053e-02f, -1.55512020e-02f, -8.78358781e-02f, -3.37829404e-02f, -7.14819208e-02f, -5.49404472e-02f, 4.26055305e-02f,
  -3.82076949e-02f, 1.30792469e-01f, -3.45159788e-03f, 9.19753313e-02f, 9.14718136e-02f, 8.95203948e-02f, 1.20271137e-02f, -5.34648262e-02f, 2.25409586e-02f, 8.09308514e-02f,
  5.65508865e-02f, 4.16914448e-02f, 6.39194697e-02f, 3.32938358e-02f, 6.31360188e-02f, 1.35733504e-02f, 2.90880073e-02f, -1.24422550e-01f, 8.84203091e-02f, 8.42079371e-02f,
  2.07366552e-02f, 1.04151011e-01f, -6.47355318e-02f, 1.48808379e-02f, 5.43500204e-03f, 4.17446122e-02f, 5.04200719e-02f, -2.40247753e-02f, 5.01080765e-04f, -5.84761985e-02f,
  -6.13710470e-02f, -3.43069285e-02f, 6.92745447e-02f, 6.92300685e-03f, -6.37468472e-02f, -8.40668902e-02f, 4.82409373e-02f, 3.32055390e-02f, -1.81014743e-02f, 6.88434243e-02f,
  -4.39469256e-02f, -1.67894289e-02f, -8.21831673e-02f, 9.83414128e-02f, -6.48877174e-02f, -2.73119044e-02f, 5.36475284e-03f, 5.40351197e-02f, 4.30688001e-02f, 8.46005529e-02f,
  -1.58829913e-02f, 4.60221283e-02f, 1.69122126e-02f, 1.00227706e-02f, -1.71167534e-02f, 6.38296530e-02f, -1.51630351e-03f, 5.50679527e-02f, 1.37254391e-02f, 4.14323881e-02f,
  -1.01246536e-01f, -1.13635845e-01f, 3.72637482e-03f, -5.25254160e-02f, -3.76180559e-02f, -5.60111180e-02f, 4.77521829e-02f, 3.54156531e-02f, -1.04735821e-01f, -1.12096243e-01f,
  -2.46947482e-02f, 8.21072161e-02f, -3.53475288e-02f, -8.91830027e-02f, 5.32422923e-02f, -5.45568019e-02f, -4.90697846e-02f, 8.66011307e-02f, -7.81662110e-03f, -1.85177643e-02f,
  1.24819316e-02f, 1.77126214e-01f, -3.87994945e-02f, 7.72900134e-02f, -5.09842969e-02f, 6.19065426e-02f, 7.09753856e-02f, -5.08687459e-02f, -4.56863865e-02f, -4.55409177e-02f,
  -5.63908927e-02f, 6.54610768e-02f, 9.37412530e-02f, 9.11571458e-02f, 8.08352232e-02f, -8.06869101e-03f, 5.91393653e-03f, 8.11670944e-02f, 8.24968796e-03f, 7.39543214e-02f,
  -7.67526180e-02f, -6.92839324e-02f, -4.89362935e-03f, -1.96499154e-02f, -6.25527576e-02f, 4.79450263e-03f, -5.77278528e-03f, 3.67808342e-02f, 5.62036969e-02f, -2.06789840e-02f,
  -2.89329886e-02f, 4.34322655e-03f, 4.57369946e-02f, -1.51028410e-01f, -3.26804072e-02f, 4.35390733e-02f, -4.64167558e-02f, 9.16657373e-02f, -6.54420406e-02f, 8.27624608e-05f,
  -8.39749798e-02f, -4.16455371e-03f, -1.84119102e-02f, -1.48228835e-02f, 1.66949555e-02f, -3.62141393e-02f, -2.12308448e-02f, -5.55300936e-02f, -2.07444909e-03f, -4.70699044e-03f,
  2.42529698e-02f, -1.61823928e-01f, -1.54938605e-02f, 1.06143937e-01f, 4.86241169e-02f, -5.55813313e-02f, -8.71814117e-02f, 4.02755197e-03f, 2.00488959e-02f, -3.89996581e-02f,
  8.45519230e-02f, -8.91135335e-02f, 6.68856353e-02f, 8.68778676e-02f, 4.97587547e-02f, 8.92842934e-02f, 6.35419115e-02f, 7.14480830e-03f, 4.52955849e-02f, 3.72097306e-02f,
  -5.19917086e-02f, 9.10587534e-02f, 1.20023009e-03f, 7.94363543e-02f, 9.61037725e-02f, 8.27848390e-02f, -1.88948493e-02f, 3.98222655e-02f, 6.45651147e-02f, 2.75250934e-02f,
  5.00873476e-02f, -3.21375839e-02f, 3.43018435e-02f, -3.30255926e-02f, 5.94571978e-02f, 4.36708555e-02f, 1.62608325e-02f, -8.51199701e-02f, 8.89098272e-02f, -7.09302202e-02f,
  3.59222777e-02f, -9.85525455e-03f, -4.99073938e-02f, 1.03845119e-01f, 4.63035814e-02f, 3.91041487e-02f, -5.16869016e-02f, 1.95007436e-02f, -2.42486428e-02f, 5.43836057e-02f,
  -6.73104152e-02f, 5.68891950e-02f, -7.91969821e-02f, 8.79883170e-02f, -6.46693930e-02f, 2.29159594e-02f, -5.36256023e-02f, 2.31132749e-02f, 9.39466432e-03f, -1.51503319e-02f,
  -7.63696507e-02f, -1.65348817e-02f, -4.82871346e-02f, 3.97115275e-02f, 8.33065808e-02f, -6.91258907e-02f, -5.71150966e-02f, 8.27636346e-02f, -5.64633831e-02f, -8.42902064e-02f,
  -3.61497933e-03f, -8.14746693e-02f, 6.21554963e-02f, 7.59054497e-02f, 1.11796521e-02f, -3.29859816e-02f, 1.04606964e-01f, 1.16968872e-02f, -1.57818273e-02f, 5.84557243e-02f,
  1.17645726e-01f, 2.28124056e-02f, 3.80496830e-02f, 7.27318041e-03f, 3.65245268e-02f, 5.61393285e-03f, -6.65037259e-02f, 1.71208717e-02f, 6.78069144e-02f, 6.29888847e-02f,
  4.30688076e-02f, 4.46271971e-02f, 1.95445702e-03f, -1.06654547e-01f, 4.45284061e-02f, 6.91754967e-02f, 2.32272875e-02f, 5.82110882e-02f, -6.79359287e-02f, -1.14412224e-02f,
  -1.23927474e-01f, 2.36422822e-01f, 1.41047567e-01f, 7.30021894e-02f, 6.68908283e-03f, -1.30335033e-01f, -2.77508758e-02f, 1.72427446e-02f, 5.26322536e-02f, 1.06942609e-01f,
  -8.92975181e-02f, 1.36760384e-01f, -4.61567976e-02f, 1.06103063e-01f, 6.23060344e-03f, -1.03856735e-01f, -6.28650635e-02f, -6.69763461e-02f, 5.72174489e-02f, 9.08619314e-02f,
  -6.43027648e-02f, 4.74274755e-02f, 7.74341524e-02f, -3.21352519e-02f, 9.77540761e-02f, 1.15403682e-01f, 1.70776807e-02f, 1.18987180e-01f, 5.67403026e-02f, 5.74998185e-02f,
  5.36319392e-04f, 1.13992319e-01f, 1.80494208e-02f, 2.76418310e-02f, -6.81119412e-02f, -6.57422766e-02f, -7.79195651e-02f, 6.04051240e-02f, 7.57523105e-02f, -8.34443048e-02f,
  -1.17140515e-02f, -3.90254743e-02f, 2.01118626e-02f, 5.56200482e-02f, -7.12142978e-03f, 2.15442292e-02f, -7.66402483e-02f, -6.14857301e-03f, -6.05669282e-02f, 8.35820958e-02f,
  -6.42025173e-02f, 2.11577024e-02f, -2.89626438e-02f, 8.66745263e-02f, 2.06272826e-02f, 5.00900708e-02f, 8.56773481e-02f, 6.53282627e-02f, 2.23959587e-03f, 2.94974614e-02f,
  8.12839493e-02f, -1.00603521e-01f, -5.48268445e-02f, -8.65567848e-02f, 4.22424078e-02f, 7.99617916e-02f, -2.96178143e-02f, -3.77163440e-02f, -2.18472444e-02f, 2.73566712e-02f,
  -2.58959290e-02f, -3.87438573e-02f, 1.90286408e-03f, -4.97108363e-02f, -1.45545406e-02f, 6.51562437e-02f, -3.01774312e-02f, -5.71019091e-02f, 9.69933253e-03f, -2.42710561e-02f,
  7.86768049e-02f, -8.00172389e-02f, -2.70698722e-02f, 3.04869860e-02f, 7.16183186e-02f, 6.89372942e-02f, -3.51251103e-02f, -4.15995903e-02f, -7.09752962e-02f, 4.99809235e-02f,
  9.76490229e-03f, 1.88268974e-01f, 9.35379788e-02f, 9.33290347e-02f, 9.00509506e-02f, -4.94937301e-02f, -1.15787057e-04f, 7.73718283e-02f, 1.24041028e-02f, 9.47845802e-02f,
  -4.94451374e-02f, -4.63259928e-02f, -1.92703307e-02f, 6.91324547e-02f, -4.77045476e-02f, 1.33369549e-03f, 5.20471409e-02f, -8.08079913e-02f, -7.18212337e-04f, -1.20692309e-02f,
  -3.10687423e-02f, -1.36174203e-03f, -6.42758310e-02f, 6.76019192e-02f, -1.83752533e-02f, -1.32333608e-02f, 1.56898405e-02f, 6.75940663e-02f, 6.65366724e-02f, -4.05244417e-02f,
  1.68019440e-03f, 6.46648258e-02f, 2.50874944e-02f, -5.91245964e-02f, 3.43586206e-02f, 1.24718631e-02f, -1.06846645e-01f, 4.01396081e-02f, -8.16733837e-02f, 7.15278238e-02f,
  -5.21403216e-02f, -1.28701389e-01f, 1.13159247e-01f, -1.84971336e-02f, 6.16494119e-02f, 1.16392091e-01f, -2.12176293e-02f, -6.62951991e-02f, -1.06249694e-02f, 3.78388725e-02f,
  -6.45021200e-02f, -1.45459339e-01f, -7.67224282e-03f, 3.09249852e-02f, -2.63278913e-02f, -1.07821815e-01f, -7.00186938e-02f, 1.56528391e-02f, 4.73320708e-02f, 2.07036361e-02f,
  -1.04195438e-01f, -3.52642536e-02f, -5.01242504e-02f, -3.86664718e-02f, -2.13129669e-02f, -9.05286819e-02f, 6.32535815e-02f, -2.07114569e-03f, -1.69927925e-02f, -2.21269671e-02f,
  7.77455568e-02f, -8.14478099e-02f, 1.16859302e-02f, 3.41439359e-02f, -6.36542542e-03f, -1.01715988e-02f, 1.42133348e-02f, -2.37855402e-05f, 5.11696935e-03f, -2.42841113e-02f,
  1.00485273e-02f, 5.36184609e-02f, 7.97568560e-02f, 2.99514793e-02f, -8.22787881e-02f, 5.90267070e-02f, -1.12697072e-02f, -6.30705506e-02f, 3.40017788e-02f, -2.22652964e-03f,
  1.12577341e-02f, 5.06938063e-02f, 8.73840824e-02f, -5.92960492e-02f, 7.45842308e-02f, -8.07814896e-02f, 4.87285629e-02f, -1.00908257e-01f, -5.49465679e-02f, -3.94227952e-02f,
  -5.26430979e-02f, -8.58624745e-03f, -7.71867558e-02f, 1.50625855e-02f, -6.12861328e-02f, -8.38627517e-02f, 3.12905125e-02f, -9.41489264e-02f, 5.97391687e-02f, 3.44283246e-02f,
  -8.40798616e-02f, 5.86639531e-02f, 1.70204286e-02f, -1.18943183e-02f, -8.55982825e-02f, 5.88647388e-02f, 6.02876395e-02f, 3.02691069e-02f, 5.31175397e-02f, 9.40196142e-02f,
  -6.19351938e-02f, 3.43730673e-02f, -7.21427128e-02f, -2.43931822e-02f, 5.62857538e-02f, 4.04107980e-02f, 4.02826108e-02f, 4.94319461e-02f, 1.98301971e-02f, 2.62804725e-03f,
  5.69593124e-02f, -6.06970936e-02f, 5.69863319e-02f, 7.06105977e-02f, -2.98966491e-03f, 1.09507544e-02f, 6.28054366e-02f, 3.78110632e-02f, -6.16557971e-02f, -2.44812332e-02f,
  -8.91192630e-02f, -5.91723137e-02f, 6.78201988e-02f, -1.03768278e-02f, 6.54777810e-02f, -6.98463097e-02f, 6.39808699e-02f, 3.32040787e-02f, -5.14292605e-02f, -1.83313910e-03f,
  1.17328793e-01f, -3.53660993e-02f, 9.79207158e-02f, 1.65304422e-01f, 8.61178860e-02f, 1.27959102e-01f, 8.33561420e-02f, 1.00683980e-01f, 1.92539036e-01f, -5.40589653e-02f,
  -1.03841998e-01f, -4.79235547e-03f, -1.24763131e-01f, -1.02300934e-01f, 6.84022787e-04f, 4.04580086e-02f, -1.53968502e-02f, 4.03329320e-02f, 4.25031967e-02f, -5.70994914e-02f,
  -2.41150875e-02f, -1.53152242e-01f, -1.47752136e-01f, -8.61507133e-02f, -7.70537555e-02f, -7.73090646e-02f, -4.45744395e-02f, -6.63935021e-02f, -5.78129068e-02f, -5.73024154e-02f,
  2.27216585e-03f, -3.45414840e-02f, 1.66583024e-02f, -3.84352617e-02f, 9.23059210e-02f, 2.39249542e-02f, 3.48043777e-02f, 2.17955746e-02f, 9.20907259e-02f, -4.91975844e-02f,
  -8.10812339e-02f, 1.71312620e-03f, -4.65507358e-02f, -6.92575723e-02f, 9.95866731e-02f, 7.35527724e-02f, -5.94217191e-03f, -3.77135016e-02f, -4.49836440e-02f, -5.24964035e-02f,
  -8.23294297e-02f, 8.38750824e-02f, 8.60096440e-02f, 2.58281939e-02f, -5.02371378e-02f, 1.39439283e-02f, -6.53510541e-02f, -4.91388664e-02f, -5.97168580e-02f, 1.93391014e-02f,
  1.57930460e-02f, -2.44557559e-02f, -9.56351534e-02f, -1.69964768e-02f, -6.64051026e-02f, 6.99228724e-04f, -1.53367519e-02f, -1.38256298e-02f, 6.51980191e-02f, 5.06477691e-02f,
  8.43215957e-02f, -6.21135645e-02f, 1.09645307e-01f, -2.30806954e-02f, -1.77315809e-02f, -4.79160175e-02f, 4.47669998e-02f, -3.92979849e-03f, 8.16228986e-03f, 7.41692334e-02f,
  4.36193384e-02f, 7.74572641e-02f, 1.65411178e-03f, 5.39471656e-02f, 1.94772352e-02f, -3.92869338e-02f, -1.02294512e-01f, 2.70611271e-02f, -5.46401851e-02f, 1.92451235e-02f,
  1.78118329e-02f, 8.77515152e-02f, 3.22023779e-02f, -1.03043161e-01f, 1.23274839e-02f, -6.88675940e-02f, 6.04061335e-02f, -4.28759642e-02f, 1.03412233e-01f, -2.68380791e-02f,
  -7.04926625e-02f, 6.88513815e-02f, 8.07396993e-02f, 7.65383542e-02f, -8.57162289e-03f, 5.65828243e-03f, 1.24789597e-02f, -1.41624557e-02f, 8.80839899e-02f, -3.19838189e-02f,
  1.28807826e-02f, 8.96346942e-03f, 5.50852343e-02f, 2.79333033e-02f, 3.60258631e-02f, 7.39647483e-04f, -4.67270613e-02f, -6.56532720e-02f, -6.86581060e-02f, 1.00931287e-01f,
  8.92392322e-02f, 1.58504937e-02f, -1.46474093e-02f, -8.23525265e-02f, -5.68197146e-02f, -5.11943251e-02f, -1.48274302e-01f, 5.53843332e-03f, 1.75983347e-02f, 2.33285297e-02f,
  -1.18184276e-01f, -7.88392033e-03f, 9.15296096e-03f, 2.77170888e-03f, 1.95714161e-01f, 2.51829177e-02f, -2.10968871e-03f, -1.06029540e-01f, -1.34465145e-03f, -1.48149401e-01f,
  -1.42117580e-02f, -1.99435085e-01f, 2.08109785e-02f, -1.41240835e-01f, -2.33553797e-01f, -1.03262164e-01f, -1.04609579e-01f, -1.60885558e-01f, -1.45240590e-01f, -9.01501030e-02f,
  4.24661413e-02f, 6.14595376e-02f, -1.52296536e-02f, 1.30074188e-01f, -6.61175400e-02f, 4.27871421e-02f, 2.12268606e-02f, 8.12587366e-02f, -3.71919498e-02f, 4.51734243e-03f,
  2.63379626e-02f, 6.67686239e-02f, -8.09535310e-02f, 8.50978345e-02f, -1.64562482e-02f, -8.95968899e-02f, -9.19875726e-02f, 7.46725127e-02f, -4.25111391e-02f, 5.08464910e-02f,
  -4.26975414e-02f, -4.63479310e-02f, 5.44259138e-02f, -7.53827617e-02f, -7.84224346e-02f, 3.78185394e-03f, -2.11393554e-03f, 6.17993250e-02f, -3.03686336e-02f, 9.34830010e-02f,
  -1.44647524e-01f, 3.39835659e-02f, 5.64955175e-02f, 2.70290989e-02f, -3.63093577e-02f, 6.58938438e-02f, -8.72471705e-02f, 8.40702560e-03f, 6.82390481e-02f, -5.65739274e-02f,
  -7.63747841e-02f, -6.75052106e-02f, -1.75998453e-02f, -4.64255735e-02f, 3.19981128e-02f, 8.95440727e-02f, 6.73511773e-02f, 3.40272710e-02f, 2.00682860e-02f, -7.01427758e-02f,
  7.88628161e-02f, 5.65343797e-02f, 7.94446766e-02f, -7.14633316e-02f, 5.22255562e-02f, 5.52098155e-02f, 6.39590994e-02f, 1.80123113e-02f, -3.36547606e-02f, -2.07849070e-02f,
  9.75908525e-03f, -3.42032835e-02f, 1.19194668e-02f, 9.41630006e-02f, 3.68363336e-02f, -2.54881643e-02f, -8.01938772e-02f, 5.32830395e-02f, 5.54997362e-02f, -6.02103248e-02f,
  -7.08270743e-02f, -9.11178216e-02f, -6.30634949e-02f, -4.72837985e-02f, -5.50523661e-02f, -3.73482145e-02f, -4.23369072e-02f, -9.16740764e-03f, -8.60665590e-02f, 5.29787056e-02f,
  -6.54107779e-02f, -5.65271489e-02f, 6.64162263e-02f, 6.97051436e-02f, -9.06964019e-03f, -1.09517135e-01f, 9.83823091e-02f, 5.01289358e-03f, -3.89038846e-02f, 8.00815895e-02f,
  6.57274574e-02f, -1.13255933e-01f, -1.05061986e-01f, -6.49971515e-02f, 8.96086246e-02f, 1.30690513e-02f, 9.82008949e-02f, 1.25387413e-02f, 2.31057014e-02f, -8.14838856e-02f,
  -8.50684103e-03f, -3.78625803e-02f, -8.18223581e-02f, 7.35243186e-02f, 1.09396197e-01f, -2.03875341e-02f, 5.63203767e-02f, -7.07463548e-02f, -5.08928448e-02f, -3.79314832e-02f,
  -7.23459795e-02f, -9.40133445e-03f, 3.38465124e-02f, 6.59904927e-02f, 2.26129945e-02f, -7.92355612e-02f, 3.27242427e-02f, 9.73982811e-02f, 2.33118664e-02f, 2.74472516e-02f,
  3.63650993e-02f, -3.86034101e-02f, -5.09117693e-02f, 2.99967043e-02f, 2.68634539e-02f, -5.42863645e-02f, 1.12857204e-03f, 8.50421339e-02f, -8.51635337e-02f, -6.90099364e-03f,
  -5.74767664e-02f, -7.07032681e-02f, 6.90922961e-02f, -7.14926571e-02f, -5.88639565e-02f, -4.76126000e-02f, -5.29456884e-02f, -9.48218480e-02f, 8.37313756e-02f, 5.55382930e-02f,
  -7.58015662e-02f, -5.39847603e-03f, 2.91250236e-02f, -4.88057323e-02f, 7.69783035e-02f, 9.97484103e-02f, -1.04451180e-02f, 2.76447535e-02f, -7.50081912e-02f, -1.79054085e-02f,
  -5.03948778e-02f, 1.25554232e-02f, -2.42944602e-02f, -3.70565020e-02f, 3.26056546e-03f, 5.01376297e-03f, -6.13653474e-02f, 1.14178704e-02f, 6.26437552e-03f, 5.40861599e-02f,
  2.94455569e-02f, 6.61384128e-03f, -1.93670131e-02f, 3.17674838e-02f, -3.15013453e-02f, 4.10890393e-02f, 4.78233248e-02f, 9.88968685e-02f, 4.76170768e-04f, 7.77622983e-02f,
  5.72122149e-02f, -7.15226009e-02f, -4.45523188e-02f, 7.99010620e-02f, -3.26424204e-02f, -2.17813291e-02f, 9.44400057e-02f, -8.62900242e-02f, 5.76252714e-02f, 8.74931514e-02f,
  1.11058410e-02f, 7.20200241e-02f, 5.93161443e-03f, -5.56384064e-02f, 2.49122269e-02f, -6.27013817e-02f, -6.25807643e-02f, 7.73167238e-02f, -7.79850781e-02f, 9.05764997e-02f,
  5.91264591e-02f, 1.00530684e-01f, -2.12568277e-03f, 1.47773810e-02f, -4.00018543e-02f, -1.54079320e-02f, -6.03473671e-02f, 7.96822608e-02f, 6.44315034e-02f, -7.75108486e-02f,
  -7.54457191e-02f, 7.63371587e-02f, -5.07253688e-03f, -2.71519907e-02f, 1.33055774e-02f, 5.92003278e-02f, 2.77069267e-02f, 5.86760938e-02f, -5.66477329e-02f, -8.69451612e-02f,
  8.69680345e-02f, -1.25378430e-01f, 2.50751346e-01f, -2.89892573e-02f, 1.39681220e-01f, 9.80088413e-02f, 1.26822308e-01f, -9.52736568e-03f, 4.81755212e-02f, -2.61885881e-01f,
  -1.01051770e-01f, 1.70268472e-02f, -2.68481113e-02f, 5.36467917e-02f, 1.24926269e-01f, 7.04812035e-02f, -8.07136372e-02f, -8.67816284e-02f, 7.36695435e-03f, -6.49828762e-02f,
  1.01916045e-01f, -1.14423677e-01f, 1.44751057e-01f, -4.78003770e-02f, 6.31303117e-02f, 1.26404185e-02f, -1.70753032e-01f, -3.56411412e-02f, -9.05523822e-02f, -4.66696627e-04f,
  6.06863759e-02f, 4.02978761e-03f, 4.14679386e-03f, 4.03663516e-03f, 3.91645841e-02f, -7.38285780e-02f, -5.35272732e-02f, 4.91527691e-02f, 7.52600357e-02f, 6.43080398e-02f,
  2.61948034e-02f, -5.32155335e-02f, 4.28546630e-02f, 5.72381690e-02f, -5.75305186e-02f, 9.40100402e-02f, 6.34643510e-02f, 6.95392489e-02f, -8.09599310e-02f, 8.17423090e-02f,
  7.27611482e-02f, -5.48145697e-02f, -6.82585537e-02f, -5.87393939e-02f, 1.00195661e-01f, 4.67366576e-02f, -4.36833650e-02f, 8.03064331e-02f, -3.49867977e-02f, 3.51400003e-02f,
  -1.22586973e-02f, -5.18863788e-03f, -7.87981451e-02f, -2.59808637e-02f, 2.00724741e-03f, 3.46554480e-02f, -4.48429175e-02f, 1.01993136e-01f, 4.91905995e-02f, 6.41136058e-03f,
  2.88953464e-02f, 7.33211860e-02f, -5.19418269e-02f, -5.99252582e-02f, -8.13181251e-02f, 1.74708981e-02f, 2.86063384e-02f, 3.05697042e-02f, 5.97564019e-02f, 8.66857469e-02f,
  -6.73522353e-02f, -1.61747709e-02f, -8.25104862e-03f, -3.61187905e-02f, -6.38168305e-02f, 1.62249915e-02f, -5.08728921e-02f, 5.35480073e-03f, -3.44540328e-02f, -4.76380438e-02f,
  -1.03339478e-02f, -1.53775811e-01f, 2.36436613e-02f, -1.62655693e-02f, -9.51096714e-02f, 7.53636211e-02f, 7.62475803e-02f, 4.84386869e-02f, 3.53536680e-02f, -7.92017877e-02f,
  8.23545828e-03f, -2.53303014e-02f, -4.77036275e-02f, -1.46112079e-02f, -1.88075863e-02f, -3.34690139e-02f, -8.03644024e-03f, -7.45388493e-02f, -7.99909830e-02f, -2.33739987e-02f,
  -4.51242290e-02f, 6.84759915e-02f, 5.16948402e-02f, 3.78686301e-02f, -2.97959521e-02f, -7.86364600e-02f, 1.81858465e-02f, -2.92737540e-02f, 5.79585135e-02f, -7.68033117e-02f,
  3.82842086e-02f, -4.40702848e-02f, -1.74273625e-01f, -8.00632015e-02f, 1.39340060e-02f, 7.48785734e-02f, 8.59173089e-02f, -6.81892261e-02f, -3.76131646e-02f, 3.99428904e-02f,
  1.66215062e-01f, 4.92249951e-02f, 4.63466607e-02f, 1.34603739e-01f, 1.58660412e-01f, 1.70066371e-03f, 1.69115290e-01f, -5.43883210e-03f, -2.19748057e-02f, 1.01747617e-01f,
  1.13848813e-01f, 2.08867893e-01f, 4.44190167e-02f, 3.35594602e-02f, 1.25493884e-01f, 4.33449261e-03f, 8.13844353e-02f, 1.80465654e-02f, 9.27596167e-02f, 2.48035043e-02f,
  -3.43675204e-02f, 1.04558550e-01f, 6.08041920e-02f, -3.00837159e-02f, 6.08609766e-02f, 5.17438389e-02f, -4.50113788e-02f, -2.52113361e-02f, 5.90968952e-02f, -1.16150733e-02f,
  -9.12068412e-02f, 8.55776295e-03f, 1.29783282e-03f, -2.02322938e-02f, -7.77648166e-02f, -8.29556659e-02f, -7.37594739e-02f, 4.32607643e-02f, -8.65478143e-02f, 4.26406786e-02f,
  -6.52747303e-02f, -1.79242920e-02f, 1.47304032e-03f, -5.21331243e-02f, -4.86465953e-02f, 8.29032622e-03f, -4.21917699e-02f, 1.14553440e-02f, 8.28314424e-02f, -6.89692274e-02f,
  -1.06095951e-02f, -7.58808702e-02f, 1.73024274e-03f, -4.13396470e-02f, -4.55941297e-02f, -7.21765384e-02f, -7.45119527e-02f, -6.01810887e-02f, -7.24732950e-02f, 1.00414447e-01f,
  3.16382386e-02f, 5.08593172e-02f, -4.80541866e-03f, -4.69293632e-02f, 2.31901687e-02f, -2.66407523e-02f, -3.30030881e-02f, 3.38895023e-02f, -9.07611102e-02f, 3.59092951e-02f,
  -9.02358722e-03f, -7.21201375e-02f, 6.60324693e-02f, 3.24514918e-02f, -7.27014095e-02f, -6.54096305e-02f, 1.09095924e-01f, 4.29223329e-02f, -1.22243520e-02f, 2.65977662e-02f,
  5.88874146e-02f, 1.00041136e-01f, 1.16013512e-02f, -5.81938475e-02f, -7.35753551e-02f, -3.46096754e-02f, 8.82125050e-02f, -7.70300906e-03f, 3.49878781e-02f, 3.31512094e-02f,
  1.03102490e-01f, -7.70686939e-02f, -5.15414514e-02f, -2.91884728e-02f, 2.05170922e-02f, 9.82790813e-02f, 1.23998933e-02f, 2.16383226e-02f, 3.30390297e-02f, -3.02233547e-03f,
  -8.12543780e-02f, -1.44893927e-02f, 3.01161390e-02f, 1.86581984e-02f, 9.86618735e-03f, -4.08682302e-02f, -4.14275890e-03f, -4.37115654e-02f, -3.75997536e-02f, 3.32074836e-02f,
  1.74215496e-01f, 7.91129023e-02f, 5.36757745e-02f, 9.07657221e-02f, -4.17705141e-02f, -1.47532031e-01f, -1.58196867e-01f, -9.33216605e-03f, 1.84818938e-01f, 3.02877789e-03f,
  -1.50432423e-01f, 2.96402246e-01f, -1.72738526e-02f, 7.71161243e-02f, -1.19058371e-01f, -1.62602529e-01f, 8.70143697e-02f, 6.51951581e-02f, 8.54303911e-02f, -7.38945827e-02f,
  7.12699294e-02f, 4.95912135e-03f, -7.81261101e-02f, -5.27316369e-02f, 8.55770484e-02f, 6.81184530e-02f, -1.01481155e-01f, -5.07081114e-02f, -6.33626198e-03f, -2.06087585e-04f,
  -4.29531075e-02f, 7.45399157e-03f, 5.98862432e-02f, 7.35789612e-02f, 1.04445452e-02f, -2.37943977e-02f, -8.10446069e-02f, -1.14083990e-01f, -8.48970488e-02f, 8.11406001e-02f,
  -1.73406936e-02f, 6.74804151e-02f, 1.05482601e-01f, -6.21531680e-02f, -3.79954316e-02f, 1.85533520e-02f, 9.76651013e-02f, -5.86367659e-02f, 5.93378954e-02f, -1.52461426e-02f,
  -5.02928607e-02f, 6.38762489e-02f, -2.79492941e-02f, -5.90690672e-02f, -7.56862611e-02f, -3.82855684e-02f, -2.74869744e-02f, 5.94258681e-02f, -1.51777985e-02f, -2.83444598e-02f,
  -2.10445914e-02f, -5.79432547e-02f, -6.22599833e-02f, -6.02545403e-03f, 6.32179379e-02f, -7.62615129e-02f, -2.62801368e-02f, 5.37748300e-02f, 4.77958433e-02f, -3.18890102e-02f,
  -6.16390957e-03f, 1.50864115e-02f, 6.92602843e-02f, -3.49837542e-03f, 4.11762111e-02f, -5.98770678e-02f, 9.07020122e-02f, 2.17739809e-02f, -3.35837081e-02f, -7.04164132e-02f,
  2.76654437e-02f, 5.25196046e-02f, -3.01195644e-02f, -8.53880197e-02f, 7.12967589e-02f, -5.18331565e-02f, -1.01315258e-02f, -4.76874933e-02f, -8.53392854e-02f, -2.67993975e-02f,
  -5.89410774e-02f, 5.38156964e-02f, -4.64461297e-02f, 1.92072541e-02f, 7.83333778e-02f, -8.09378326e-02f, -7.85901770e-02f, 1.33964708e-02f, 4.67158966e-02f, -6.87618181e-03f,
  9.20262709e-02f, 4.67338711e-02f, 1.22721903e-02f, -2.53540720e-03f, 5.53852879e-02f, -9.14139524e-02f, 3.16539488e-04f, 4.32348438e-02f, 2.10768427e-03f, 6.51847050e-02f,
  -2.35479381e-02f, -4.26084362e-02f, 3.17990407e-02f, 5.83216548e-02f, 1.89542118e-02f, 1.17804706e-02f, 9.87340882e-02f, -9.32802185e-02f, -1.37497270e-02f, 1.00187138e-01f,
  1.06197983e-01f, -5.47368340e-02f, 5.89173548e-02f, 2.32386291e-01f, 7.89305195e-02f, -1.06214009e-01f, 8.23521018e-02f, 5.73207512e-02f, 8.97450745e-03f, 3.30475494e-02f,
  -2.04169955e-02f, 1.04575977e-01f, -3.82699184e-02f, 7.45586231e-02f, 9.30893421e-02f, -3.40136923e-02f, 8.79648104e-02f, 4.78021018e-02f, 6.67613819e-02f, 1.66796520e-01f,
  4.73516583e-02f, 1.32128716e-01f, 1.36459842e-02f, 4.68944013e-02f, 4.18789163e-02f, 6.04459457e-02f, 1.77457407e-01f, 9.19226408e-02f, 1.29019871e-01f, 6.65900260e-02f,
  -2.44963374e-02f, -7.82535039e-03f, -3.19707505e-02f, -8.99957269e-02f, 3.14211361e-02f, -5.07467501e-02f, 2.35434994e-02f, 7.71225467e-02f, 7.56416544e-02f, 7.26977289e-02f,
  4.77396809e-02f, -5.80611452e-02f, -7.63996542e-02f, -7.71008208e-02f, 1.51693206e-02f, 4.62856293e-02f, 8.00791085e-02f, 8.43641255e-03f, 1.26119645e-03f, -8.81157890e-02f,
  6.26746938e-02f, 7.12166131e-02f, 9.89061594e-02f, -3.51233147e-02f, 9.90948156e-02f, -1.55372862e-02f, -3.38990837e-02f, 4.04732563e-02f, -6.47965819e-02f, -3.34828757e-02f,
  -7.65933990e-02f, -8.45885351e-02f, 6.63687512e-02f, -5.67579828e-02f, 3.68646197e-02f, 6.46936074e-02f, 8.71807616e-03f, -3.49716879e-02f, 1.33457258e-02f, 6.47915974e-02f,
  -6.40798956e-02f, 8.44374076e-02f, -6.08784407e-02f, -9.60870683e-02f, 5.31167053e-02f, 1.27683226e-02f, -3.70069332e-02f, 8.30656737e-02f, -5.24309501e-02f, 2.43544076e-02f,
  -9.31220967e-03f, 5.50584905e-02f, -1.99738722e-02f, 1.05044348e-02f, -3.97883691e-02f, 4.21248190e-02f, 5.74268103e-02f, 5.51054329e-02f, 5.90965338e-02f, -1.98599622e-02f,
  -1.21304439e-02f, 1.89875454e-01f, -1.39156729e-02f, -6.17324607e-03f, -3.14896517e-02f, -3.43116783e-02f, 1.84167512e-02f, 3.05476505e-02f, 8.66013989e-02f, -1.40766986e-03f,
  7.22090900e-02f, 7.11107999e-02f, -4.82245088e-02f, 1.54376822e-02f, 3.01585011e-02f, -2.86356620e-02f, 9.68868658e-02f, -1.06188720e-02f, -1.51274642e-02f, 8.27440545e-02f,
  4.92932200e-02f, -6.49003312e-02f, -5.34960069e-04f, -5.55665642e-02f, -3.63447331e-02f, -2.15495732e-02f, 4.60698865e-02f, -1.99599396e-02f, 5.92411533e-02f, 8.32075626e-02f,
  -3.21848802e-02f, 1.25569433e-01f, 4.03955439e-03f, -1.29407458e-02f, 1.66161239e-01f, 2.48636324e-02f, -1.01813063e-01f, 1.38339177e-01f, 1.24059534e-02f, -1.61238853e-02f,
  -1.22752078e-01f, -8.02553371e-02f, -3.35816946e-03f, -1.36369646e-01f, -2.23682836e-01f, -1.46644950e-01f, -1.33770123e-01f, -1.80201441e-01f, 1.20051958e-01f, 3.42814848e-02f,
  5.60703911e-02f, -3.23926657e-02f, 1.40757365e-02f, 1.07500374e-01f, 1.07643284e-01f, 8.25732648e-02f, -1.28493130e-01f, 9.19689685e-02f, 1.44987684e-02f, -1.54577084e-02f,
  -5.39701134e-02f, 4.56184447e-02f, 1.34921953e-01f, -6.75164834e-02f, 8.98283347e-02f, 5.93068674e-02f, -9.15002748e-02f, -4.16723313e-03f, 6.74895709e-03f, -6.31473958e-02f,
  -6.00702167e-02f, -3.89331914e-02f, -3.01410686e-02f, -3.53077389e-02f, 5.15624806e-02f, -6.82413280e-02f, -1.49665773e-02f, 6.50579408e-02f, 1.08615153e-01f, -3.55795473e-02f,
  9.03974324e-02f, 1.01194084e-01f, -8.19645450e-02f, -6.92320168e-02f, -4.74315323e-02f, 3.68506908e-02f, -7.60849416e-02f, 3.52734253e-02f, -7.75647983e-02f, 7.19940364e-02f,
  -2.34485697e-02f, -2.04048716e-02f, -5.11518456e-02f, -7.64878169e-02f, 2.49781087e-02f, -7.80149326e-02f, -4.01967242e-02f, -6.31075799e-02f, 9.18834433e-02f, -5.28810322e-02f,
  5.34573123e-02f, 1.59909148e-02f, -5.72094209e-02f, 7.57060945e-02f, 7.75407627e-02f, 1.99075993e-02f, 5.41091971e-02f, 3.52737829e-02f, -5.11800200e-02f, 7.08502205e-03f,
  -6.61283508e-02f, -3.96646746e-02f, 2.47952957e-02f, -3.52277793e-02f, -6.68058470e-02f, -3.16867717e-02f, 6.32424727e-02f, -7.76128694e-02f, -3.25023904e-02f, -4.23806421e-02f,
  -4.41946350e-02f, -8.04821029e-02f, 3.59732145e-03f, 2.07001921e-02f, 2.74956226e-02f, 5.45816198e-02f, -8.11902955e-02f, 5.16255051e-02f, 3.86640206e-02f, 2.07366291e-02f,
  2.98636574e-02f, -2.37902645e-02f, -4.06304561e-02f, -1.59669779e-02f, 3.53413611e-03f, -5.68319708e-02f, -1.31222568e-02f, 1.47701977e-02f, 7.18677118e-02f, -8.36066529e-03f,
  9.44138095e-02f, 1.33097135e-02f, -4.49459702e-02f, -5.28692547e-03f, -4.85524721e-02f, -8.04316849e-02f, -9.38910767e-02f, 5.71858361e-02f, 4.76671532e-02f, -5.73469438e-02f,
  9.88056213e-02f, -7.39692003e-02f, -4.02601138e-02f, 6.55890489e-03f, -1.84195474e-01f, -1.69161499e-01f, -2.56559178e-02f, -8.26421082e-02f, 1.39208928e-01f, 3.44514451e-03f,
  -6.25873879e-02f, -4.47709337e-02f, 8.16317182e-03f, -3.68317449e-03f, 6.59749731e-02f, 1.72264084e-01f, -5.02347723e-02f, 5.09059131e-02f, 7.74490312e-02f, -1.43567219e-01f,
  -5.99878561e-03f, 1.74847525e-02f, 3.29397172e-02f, -1.93923667e-01f, -1.95672140e-01f, 6.32982794e-03f, -7.61821195e-02f, -1.81625351e-01f, -9.44285318e-02f, 3.24955732e-02f,
  -7.31661320e-02f, -1.42101035e-03f, -6.94387630e-02f, -4.13337862e-03f, -1.18123084e-01f, -3.32944095e-02f, -5.59177212e-02f, -1.78125389e-02f, 6.58713505e-02f, -4.83354852e-02f,
  -8.03221315e-02f, 1.26840267e-02f, 1.97589416e-02f, 6.37707636e-02f, 3.76000181e-02f, -8.90685245e-03f, -3.11742332e-02f, 5.04167601e-02f, -4.13814485e-02f, -4.29322422e-02f,
  -8.35622698e-02f, 4.54531051e-02f, -8.85514244e-02f, -1.85065996e-02f, -4.19835374e-02f, 2.37279739e-02f, 3.87437567e-02f, -3.18875313e-02f, 2.00405214e-02f, -7.01341592e-03f,
  2.40810905e-02f, 4.44057547e-02f, 8.31873566e-02f, -4.07772139e-02f, -7.95415789e-02f, -4.74407747e-02f, 5.79096042e-02f, -4.05690484e-02f, 4.98877168e-02f, -8.87908861e-02f,
  -8.12631696e-02f, 8.11354071e-03f, 3.12062111e-02f, 5.14969863e-02f, 3.33599222e-04f, -1.62364244e-02f, 3.56347710e-02f, 4.89894822e-02f, -3.91891152e-02f, 6.14672452e-02f,
  7.64523745e-02f, 4.32019196e-02f, -6.69395775e-02f, -1.16275875e-02f, -5.63339069e-02f, -3.87104861e-02f, -5.95159233e-02f, -3.05836760e-02f, -2.05711257e-02f, 2.21005641e-02f,
  -1.47853598e-01f, -2.39940230e-02f, 5.57961315e-02f, 2.15752702e-02f, -6.10604137e-02f, -3.26177552e-02f, 1.98339149e-02f, 3.36991204e-03f, -8.22621733e-02f, -2.80006919e-02f,
  6.93149343e-02f, -5.01396917e-02f, 3.86985615e-02f, 4.55994532e-02f, -8.15344751e-02f, -6.69241026e-02f, 3.06255687e-02f, 2.23327875e-02f, 5.47611825e-02f, -9.03892219e-02f,
  1.72577873e-02f, -8.29003453e-02f, -7.34799877e-02f, -3.30376811e-02f, 4.23044153e-02f, 9.85105988e-03f, -6.50046319e-02f, -4.60253581e-02f, -9.09835696e-02f, -5.82271740e-02f,
  4.77538072e-02f, -1.17273986e-01f, -1.77609921e-01f, 7.85855693e-04f, -1.30794605e-03f, -9.53533202e-02f, -1.75831735e-01f, -6.77634254e-02f, 2.00164709e-02f, 8.13899934e-03f,
  3.20642777e-02f, -4.00270037e-02f, 9.15587619e-02f, -3.25691439e-02f, -5.78262359e-02f, 2.93643400e-02f, -1.42404452e-01f, -1.02841660e-01f, -3.62743288e-02f, 1.04414001e-02f,
  -9.37203690e-02f, -1.16513014e-01f, -9.99855176e-02f, -7.13810772e-02f, -7.25744367e-02f, -6.59485161e-02f, -1.73817631e-02f, 2.10301634e-02f, -1.39316350e-01f, -5.08293584e-02f,
  3.06099858e-02f, 8.33358392e-02f, -7.76649415e-02f, 6.07071863e-03f, 1.07276998e-02f, -1.65344700e-02f, -7.29391398e-03f, 6.63087666e-02f, 5.44583285e-03f, -5.85549884e-02f,
  4.41129617e-02f, -4.03128564e-02f, 5.76604456e-02f, 3.93838882e-02f, -9.58227292e-02f, 2.71287635e-02f, -4.27968800e-02f, -9.03284699e-02f, 6.27925172e-02f, -9.17871293e-05f,
  1.13860229e-02f, -6.99125081e-02f, -8.28709155e-02f, 7.06011653e-02f, -7.82794729e-02f, 6.68161884e-02f, 8.24247226e-02f, 4.84525412e-03f, -1.91204734e-02f, 7.70580098e-02f,
  4.63954397e-02f, 7.65923411e-02f, -5.02292300e-03f, 4.29480374e-02f, -3.62613425e-02f, -2.64227781e-02f, -7.31824562e-02f, 8.68640095e-02f, 7.16215149e-02f, 5.88804558e-02f,
  -4.60985638e-02f, -2.45427229e-02f, 8.30030441e-02f, 5.36734834e-02f, -4.88664992e-02f, 9.32594854e-03f, -3.58652174e-02f, -3.20439152e-02f, -3.03128958e-02f, -9.24447402e-02f,
  -1.74781438e-02f, 7.93123767e-02f, 5.63433617e-02f, -3.65026072e-02f, -9.25182030e-02f, -6.38125231e-03f, -5.25353709e-03f, 6.68732002e-02f, 7.33408928e-02f, -8.24693814e-02f,
  -9.43570957e-03f, -3.95100042e-02f, -9.97478813e-02f, 5.95341735e-02f, 7.33255818e-02f, 3.12657505e-02f, -4.56658192e-02f, 1.54625927e-03f, -4.26722839e-02f, -2.44664829e-02f,
  -4.43884544e-02f, -5.83615154e-02f, 5.58363497e-02f, 1.87825169e-02f, 6.93297386e-02f, 2.17841640e-02f, -7.95257315e-02f, -1.45985885e-02f, -6.11774474e-02f, 5.87982200e-02f,
  4.02909182e-02f, 9.60466638e-02f, 2.35614693e-03f, 9.21754986e-02f, 1.02386093e-02f, 2.54318528e-02f, 6.98294565e-02f, -1.78979977e-03f, -4.88224514e-02f, -4.06339066e-03f,
  1.34306746e-02f, 3.67454439e-02f, -1.43723100e-01f, -1.54467789e-03f, 1.33609781e-02f, -1.06019862e-01f, -5.22215404e-02f, -8.20201933e-02f, -1.13988765e-01f, -6.56548217e-02f,
  -9.64432061e-02f, 4.62194867e-02f, -1.49008840e-01f, -5.77261634e-02f, 9.15340260e-02f, 1.16222966e-02f, -3.56231183e-02f, -1.42981885e-02f, -2.48826714e-03f, -2.27697343e-02f,
  5.22738248e-02f, 3.96880088e-03f, 3.94308120e-02f, 5.11840954e-02f, 3.43363173e-02f, 5.03295511e-02f, 4.50537093e-02f, -8.64241049e-02f, 4.26319204e-02f, 1.30383596e-01f,
  7.32179731e-02f, -1.02401651e-01f, 4.51393239e-02f, -1.16155529e-02f, 5.05816601e-02f, 9.04264674e-02f, -3.62760723e-02f, -2.52896175e-02f, -2.66617723e-02f, -4.37255800e-02f,
  9.19444859e-02f, 2.16821935e-02f, -2.26951181e-03f, 9.29275714e-03f, 2.77421344e-02f, -5.45763969e-02f, -2.80206203e-02f, -5.91903366e-02f, -8.71213675e-02f, 1.16812866e-02f,
  -7.36647844e-02f, -4.04084800e-03f, -4.83243056e-02f, 2.95865946e-02f, 3.61759067e-02f, 4.06685583e-02f, -7.17073306e-02f, 1.23189494e-03f, 4.26775515e-02f, 5.48942611e-02f,
  1.26510048e-02f, -1.53598776e-02f, -5.60963750e-02f, 7.11284205e-02f, 4.18368652e-02f, -2.74313390e-02f, 5.99778295e-02f, 9.67834443e-02f, -1.02386594e-01f, 3.89222428e-02f,
  -5.28998226e-02f, 5.24228401e-02f, -3.51357646e-02f, 5.05886041e-02f, -8.97659883e-02f, -8.01260322e-02f, 6.99753389e-02f, 9.73911062e-02f, 3.78242396e-02f, 5.78645207e-02f,
  -6.45301938e-02f, 2.06464324e-02f, -4.98125888e-02f, 9.26321186e-03f, -7.49293808e-03f, -4.71724235e-02f, -3.33123431e-02f, 5.67839779e-02f, -5.08062579e-02f, -1.58036016e-02f,
  -1.30264059e-01f, -1.22111455e-01f, 3.39206830e-02f, -1.40930293e-02f, 2.48738267e-02f, 4.60488237e-02f, -4.03586682e-03f, -3.72959785e-02f, -2.66753184e-03f, -1.11384295e-01f,
  -7.28914365e-02f, 5.52395806e-02f, -4.10424173e-02f, 1.77937988e-02f, -7.92789385e-02f, 2.21130960e-02f, -8.18673074e-02f, -1.81321595e-02f, -1.02072814e-02f, -6.21135347e-03f,
  4.72122915e-02f, 1.41097279e-02f, -6.05016015e-02f, -4.55633327e-02f, -6.48842081e-02f, -3.58956680e-02f, 3.57105397e-02f, 9.43200141e-02f, 3.93425412e-02f, -5.10561354e-02f,
  1.07856207e-01f, 1.84284180e-01f, 1.33890584e-01f, 7.18913898e-02f, -9.70640481e-02f, -1.37681514e-01f, -5.00298589e-02f, 3.93372141e-02f, 3.28126997e-02f, -5.37071936e-02f,
  -5.95540367e-02f, 1.46142498e-01f, -5.17393323e-03f, -2.40676831e-02f, -8.91366899e-02f, 6.27720878e-02f, 5.25715481e-03f, -9.76620764e-02f, -3.76610830e-02f, 4.22717258e-02f,
  -3.84925008e-02f, -5.23904338e-02f, -5.93486764e-02f, 3.66049558e-02f, 3.32236588e-02f, 1.24653041e-01f, -3.78587767e-02f, -8.99296477e-02f, -9.01461542e-02f, -1.06017604e-01f,
  -7.15898797e-02f, 4.64373343e-02f, 1.05009899e-01f, 9.68286991e-02f, 1.02990894e-02f, -5.13182543e-02f, -5.84759787e-02f, -2.73319352e-02f, -5.28937541e-02f, 2.69884355e-02f,
  6.08616397e-02f, 6.38399720e-02f, -3.72986719e-02f, 2.25024601e-03f, -4.75727729e-02f, -1.97214149e-02f, 1.13712698e-02f, 6.61329553e-02f, -3.06001734e-02f, 9.99131706e-03f,
  -9.05703753e-04f, 2.89741773e-02f, -6.33038729e-02f, -7.13719353e-02f, 3.18911336e-02f, 8.13295320e-02f, 2.00428832e-02f, 5.11435457e-02f, 7.23600090e-02f, -2.50665825e-02f,
  8.69109295e-03f, 1.01516591e-02f, -6.12881919e-03f, 4.62665521e-02f, -7.09798699e-03f, 2.19283886e-02f, -6.34841025e-02f, 5.83974048e-02f, 1.56975593e-02f, -8.17437395e-02f,
  -4.41060066e-02f, -3.36555466e-02f, -7.94762596e-02f, -1.74581800e-02f, 9.33981594e-03f, 6.12860247e-02f, -6.97744563e-02f, 5.08043095e-02f, 8.31155851e-03f, 4.34055142e-02f,
  -6.18284643e-02f, 1.43333953e-02f, 2.01923251e-02f, 5.77277951e-02f, -8.35241601e-02f, 5.75126149e-02f, 4.96853851e-02f, -1.73024330e-02f, -2.94398665e-02f, -6.44191355e-02f,
  -6.21868931e-02f, -5.38644567e-02f, -5.53310327e-02f, 5.59239015e-02f, -5.09044491e-02f, -3.49777266e-02f, 3.53914239e-02f, -2.34202370e-02f, -7.53599033e-02f, -6.59701303e-02f,
  9.36342627e-02f, 3.81859690e-02f, -5.27273398e-04f, -6.18041679e-02f, -1.00496218e-01f, 8.78598243e-02f, -1.65575091e-02f, -7.59099871e-02f, 1.21028405e-02f, 3.09907161e-02f,
  -6.61586747e-02f, -4.73988429e-02f, 2.36925725e-02f, -3.27279754e-02f, 4.11306359e-02f, 6.07439950e-02f, 7.82104507e-02f, 3.91530097e-02f, 2.51273178e-02f, -8.13443214e-02f,
  1.55814245e-01f, 1.38045505e-01f, 1.44537896e-01f, 8.26423466e-02f, -7.85079747e-02f, 8.62194225e-03f, 1.16562378e-02f, -2.91801132e-02f, 1.38279825e-01f, 5.38849235e-02f,
  -1.52534097e-01f, 1.92468688e-01f, -3.50243486e-02f, 1.57006215e-02f, 1.85706448e-02f, -2.85449647e-03f, 6.19640388e-02f, -1.01303816e-01f, 4.54741977e-02f, 7.80488849e-02f,
  -1.14206988e-02f, -1.21044070e-01f, -5.46640642e-02f, -9.86403599e-03f, -3.75693329e-02f, 9.37293842e-02f, -1.50804460e-01f, -9.60099846e-02f, 3.03543210e-02f, -1.33511260e-01f,
  -4.23865244e-02f, 8.47726911e-02f, -4.63262796e-02f, -2.58212890e-02f, 6.28003031e-02f, 6.68277293e-02f, -3.40731591e-02f, -9.48514938e-02f, -2.45921146e-02f, 9.72948875e-03f,
  6.40222505e-02f, -7.45589435e-02f, 1.19646993e-02f, -5.37024587e-02f, 6.48202300e-02f, 1.00385249e-02f, 8.05066675e-02f, 7.63246417e-03f, 2.24351138e-02f, -5.57505991e-03f,
  2.22954657e-02f, -1.64493155e-02f, -4.42169495e-02f, -4.65743430e-02f, 8.46251026e-02f, 8.65453780e-02f, -4.73850407e-03f, -3.86415236e-02f, 3.81526463e-02f, 1.02204092e-01f,
  6.66325837e-02f, -7.72402808e-02f, -2.85770427e-02f, -2.76372097e-02f, 4.41620909e-02f, 4.20555398e-02f, 1.68363173e-02f, 4.60669138e-02f, 4.33234088e-02f, 5.15424758e-02f,
  -7.86213130e-02f, 9.52178240e-02f, -4.75674979e-02f, -3.47475260e-02f, 8.03041905e-02f, 1.23187611e-02f, 4.22341749e-02f, -9.92891416e-02f, 2.40375809e-02f, 2.88328882e-02f,
  3.08986958e-02f, 7.46280402e-02f, -5.07613271e-02f, -2.88074985e-02f, -6.71110451e-02f, -3.51555049e-02f, 4.53882217e-02f, 8.17083567e-02f, -1.04078231e-02f, -5.80242239e-02f,
  9.24866870e-02f, 7.48415440e-02f, 4.56331447e-02f, 4.53725792e-02f, 5.10001965e-02f, 6.75386144e-03f, 4.12503295e-02f, 3.75865190e-03f, -6.69511259e-02f, 9.95040312e-03f,
  -6.55760765e-02f, -4.34414595e-02f, -5.18977717e-02f, 2.69998070e-02f, -6.88505545e-02f, 6.63792938e-02f, 1.17551079e-02f, -6.91499515e-03f, -6.19909987e-02f, -7.92145655e-02f,
  -4.19680122e-03f, 6.07067049e-02f, 7.16720894e-02f, -1.24176852e-02f, 1.33176204e-02f, 4.44357134e-02f, 3.98583971e-02f, 1.39845966e-03f, 2.81404182e-02f, -5.90995252e-02f,
  7.61604980e-02f, -7.66266212e-02f, 1.70951989e-02f, 1.78850099e-01f, -1.33231640e-01f, -7.18534738e-02f, 5.31467907e-02f, -3.77953500e-02f, 7.44959479e-03f, -1.30414903e-01f,
  -6.65716380e-02f, -3.24276611e-02f, 1.99460667e-02f, 1.27551273e-01f, 1.86016947e-01f, 8.33534449e-03f, 9.38966647e-02f, 9.99916121e-02f, 8.92313644e-02f, -3.03863641e-02f,
  5.19184675e-03f, 4.63116262e-03f, 1.17486000e-01f, -1.38334587e-01f, -5.07974764e-03f, -6.25348687e-02f, -4.47993539e-02f, -7.93493912e-02f, 3.45750153e-02f, 4.96385694e-02f,
  -1.09783508e-01f, -5.22099510e-02f, -9.95960832e-03f, -7.30284378e-02f, -5.11573888e-02f, -2.68903431e-02f, 5.92753328e-02f, 1.09657601e-01f, 8.23624730e-02f, 2.84189649e-04f,
  3.71107832e-02f, 3.47329564e-02f, 2.91458834e-02f, 9.00370330e-02f, -3.44520025e-02f, -8.17414671e-02f, 8.66831541e-02f, -6.39812555e-03f, 4.50691069e-03f, -1.04464456e-01f,
  6.93260357e-02f, 1.33062247e-02f, 6.76007345e-02f, -7.03372210e-02f, 9.18459818e-02f, -5.56129776e-02f, 3.50128189e-02f, 7.00861514e-02f, 1.11378478e-02f, 6.59985542e-02f,
  1.47245626e-03f, 7.81536028e-02f, -1.49212955e-02f, 7.66539276e-02f, 6.62814081e-02f, -5.66570722e-02f, -8.20382498e-03f, -6.38556853e-02f, 3.32440250e-02f, 5.65141998e-02f,
  1.17160268e-02f, 3.59330922e-02f, 3.94508094e-02f, 4.34466936e-02f, -1.73042510e-02f, 9.84303802e-02f, -4.55055051e-02f, 1.34044057e-02f, -3.73405628e-02f, 4.16937023e-02f,
  -5.08382544e-03f, -4.62129153e-02f, 4.79236990e-02f, -1.02242734e-03f, -6.18697405e-02f, -7.76775032e-02f, 2.82058604e-02f, -5.37921526e-02f, 9.75093395e-02f, 8.72894153e-02f,
  -7.37488046e-02f, -1.53838107e-02f, 4.03558277e-02f, 4.87187356e-02f, -2.69181896e-02f, -7.94666559e-02f, -6.78199902e-02f, -7.64620528e-02f, 3.99659388e-02f, -8.81342366e-02f,
  2.60864813e-02f, -3.65553759e-02f, -6.33054078e-02f, -3.66186909e-02f, -4.81612459e-02f, -8.27088878e-02f, 1.97788943e-02f, 5.26009500e-02f, -3.17884311e-02f, -1.89285390e-02f,
  8.01266581e-02f, -5.21046631e-02f, 6.99640065e-02f, -7.14109540e-02f, 1.17856199e-02f, 7.24718273e-02f, 3.64782140e-02f, -9.54900030e-03f, -2.94535607e-02f, -6.56075329e-02f,
  2.15929478e-01f, 1.85941383e-01f, -1.87835708e-01f, 9.30821465e-04f, -7.19434246e-02f, 2.45457515e-02f, 1.95852034e-02f, 6.91739544e-02f, -1.03752343e-02f, 2.29494035e-01f,
  1.86614081e-01f, 2.19520144e-02f, -4.85678427e-02f, 2.17860848e-01f, 1.44771598e-02f, 6.62712529e-02f, 1.95570081e-01f, 1.29723296e-01f, -6.21877313e-02f, 1.50971621e-01f,
  4.43018712e-02f, 8.12129453e-02f, -7.18194246e-02f, -3.88858654e-02f, 9.73106623e-02f, -1.08820656e-02f, 5.56101128e-02f, -1.14637911e-01f, 1.31172821e-01f, 7.56191090e-02f,
  1.20034754e-01f, 5.91190234e-02f, 8.42732787e-02f, -7.46547505e-02f, 4.15552892e-02f, 2.17542192e-03f, 2.16986202e-02f, 2.15510726e-02f, -3.92547213e-02f, -3.47390622e-02f,
  7.31898844e-02f, -5.80082349e-02f, -6.04316667e-02f, -7.55705032e-03f, -6.03874680e-03f, -8.42662230e-02f, 5.60368262e-02f, -3.21769007e-02f, -5.44805154e-02f, 6.21423759e-02f,
  4.46842201e-02f, 8.61651301e-02f, -2.29377933e-02f, 1.19522889e-03f, -5.55054173e-02f, -5.49292564e-02f, -6.51290938e-02f, -1.74409021e-02f, -4.64628302e-02f, 8.65460411e-02f,
  -3.82918655e-03f, -5.21188416e-02f, 1.81506574e-02f, 1.22719649e-02f, -9.73153338e-02f, -4.44258424e-03f, -7.46293589e-02f, -2.63293758e-02f, -9.62156504e-02f, 7.49173537e-02f,
  1.51246386e-02f, 2.32708431e-03f, -4.06693993e-03f, 2.61954460e-02f, 1.85345355e-02f, 9.80095863e-02f, -8.91050920e-02f, 8.16665068e-02f, 6.06134497e-02f, 5.91280796e-02f,
  9.54149943e-03f, 2.93094590e-02f, 8.86724517e-02f, 2.56752893e-02f, -6.04352094e-02f, -5.59004471e-02f, -3.68026420e-02f, 1.39999026e-02f, -6.75750896e-02f, -3.73470969e-02f,
  9.29405317e-02f, -4.84467000e-02f, 7.32896551e-02f, 3.91058885e-02f, 1.79519393e-02f, 1.25793219e-01f, 5.69014326e-02f, -2.18894556e-02f, 5.99632226e-02f, -4.08436321e-02f,
  -7.60510517e-03f, -8.89008120e-02f, 6.80608377e-02f, 2.88149398e-02f, -1.31752416e-01f, 6.27346337e-02f, -9.48639528e-04f, -1.30785793e-01f, -3.55202705e-02f, 9.21644941e-02f,
  6.22905232e-03f, 6.53016418e-02f, -3.24218199e-02f, -1.16627604e-01f, -2.29931101e-02f, 6.47945777e-02f, -6.43111542e-02f, -5.47465980e-02f, 1.02380544e-01f, -8.84590372e-02f,
  9.53821465e-03f, 6.36113286e-02f, -1.97650287e-02f, 3.14373150e-02f, 5.70862591e-02f, -1.69930719e-02f, 9.26290974e-02f, -9.24171507e-02f, 9.63480305e-03f, 1.53816640e-01f,
  5.82666770e-02f, 1.01358883e-01f, -9.86038707e-03f, -1.41820952e-01f, -1.40423730e-01f, -6.27317727e-02f, -2.43512392e-02f, 5.03686629e-02f, -7.13328272e-02f, -1.51854148e-02f,
  4.07847017e-02f, -2.33646501e-02f, -1.11659706e-01f, 4.76443321e-02f, -5.08231856e-02f, -1.37228929e-02f, 6.50590211e-02f, 3.64761017e-02f, -4.75659184e-02f, 1.10516539e-02f,
  -8.36519599e-02f, 1.09342933e-01f, 5.55891879e-02f, 1.36342915e-02f, 9.71276255e-04f, -4.90062274e-02f, 8.67282599e-03f, -7.41632134e-02f, -1.31861353e-02f, -8.75879377e-02f,
  3.00125945e-02f, 3.11438013e-02f, -3.86628397e-02f, 4.43857238e-02f, 2.08916198e-02f, 7.46037737e-02f, 2.90170461e-02f, -7.59879127e-02f, -6.47785142e-02f, -8.52695480e-03f,
  -6.09816834e-02f, -1.75543223e-02f, -5.98935038e-02f, 2.50752531e-02f, 3.60094756e-02f, -7.19762743e-02f, -1.36805763e-02f, 8.12619105e-02f, -2.73757178e-04f, -9.26414803e-02f,
  2.42203139e-02f, 1.12593316e-01f, -4.56701368e-02f, 5.24153486e-02f, -8.48663896e-02f, 2.39984505e-03f, 2.74647512e-02f, -7.21257254e-02f, -5.21816686e-02f, -4.74623926e-02f,
  6.58163279e-02f, -6.17970861e-02f, -8.35160390e-02f, -5.60323037e-02f, 3.32636982e-02f, -5.36205247e-02f, 2.67262217e-02f, -6.37095720e-02f, 5.97208031e-02f, -5.88123798e-02f,
  -5.85589595e-02f, -7.95822814e-02f, -3.49769928e-02f, -8.69949907e-03f, -4.12317105e-02f, 5.72340526e-02f, 4.34853807e-02f, 5.81872240e-02f, 7.79581293e-02f, 5.85441589e-02f,
  2.26392467e-02f, 7.59036243e-02f, -8.94321781e-03f, -4.15234603e-02f, -1.04101431e-02f, 8.34606141e-02f, -3.12414933e-02f, -7.62622654e-02f, -2.66750827e-02f, 6.14159629e-02f,
  -5.15666157e-02f, 4.13827598e-02f, -6.69949576e-02f, -1.48934470e-02f, 5.27632907e-02f, 3.38383205e-02f, 5.22664674e-02f, -2.89317537e-02f, -4.54256311e-03f, 2.47791521e-02f,
  2.18058433e-02f, 1.07621916e-01f, 6.77810386e-02f, -1.64425001e-02f, -4.97276634e-02f, 8.06507766e-02f, -3.17648798e-02f, -3.95581014e-02f, 6.91624954e-02f, 3.19363140e-02f,
  -6.24557398e-02f, -9.60144699e-02f, -1.87799051e-01f, -1.02357134e-01f, -1.03972226e-01f, -6.93397373e-02f, 9.67909954e-03f, -1.70691073e-01f, 6.07469678e-02f, -3.26160545e-04f,
  8.85071605e-02f, -5.28016128e-02f, 6.10134080e-02f, 9.86035615e-02f, 9.74701419e-02f, 1.86449438e-01f, -1.36714065e-02f, 7.75756389e-02f, 1.04735404e-01f, -4.70550396e-02f,
  4.28793468e-02f, 5.26620187e-02f, -2.10665837e-02f, -1.29743338e-01f, -5.80997160e-03f, -5.66760786e-02f, 4.87515470e-03f, -1.74334377e-01f, 4.97491956e-02f, -1.02026239e-01f,
  3.90023924e-02f, -7.08582401e-02f, -2.24473123e-02f, -4.77431789e-02f, -1.02720059e-01f, -3.44839320e-02f, -2.25274004e-02f, 1.14057101e-02f, 2.20750482e-03f, -1.26523338e-02f,
  -3.07245906e-02f, -3.16734463e-02f, 2.56815273e-02f, -9.23050568e-02f, 1.31961238e-02f, 1.27212824e-02f, 1.51316216e-02f, -6.47745654e-02f, 1.23060150e-02f, -1.58391763e-02f,
  -1.97963230e-02f, -5.45698404e-02f, 8.89588818e-02f, -4.13230946e-03f, 6.56588078e-02f, -8.48200992e-02f, -2.91068181e-02f, -1.41990390e-02f, -6.15603849e-02f, -5.64655028e-02f,
  -9.61527303e-02f, -4.53234389e-02f, -2.24525221e-02f, 5.97135052e-02f, -3.25752422e-02f, 6.44013509e-02f, -4.83221970e-02f, 2.43454706e-02f, -5.19107059e-02f, 7.16703013e-02f,
  -3.76936235e-03f, -3.12470063e-03f, -1.12334769e-02f, 1.38274645e-02f, -3.57941501e-02f, 2.97051538e-02f, -3.87391099e-03f, 3.04958895e-02f, 1.85103947e-03f, 9.36531946e-02f,
  7.09036663e-02f, 6.10137284e-02f, 1.62964016e-02f, 9.13831666e-02f, -1.02412254e-02f, -1.49909975e-02f, -3.62373404e-02f, -2.71301903e-02f, 2.97625195e-02f, 1.33260200e-02f,
  -2.67135026e-03f, -1.01063818e-01f, 2.29347777e-02f, 1.61397215e-02f, 5.38973622e-02f, 8.39133002e-03f, 7.96092749e-02f, -5.55696599e-02f, -1.18902132e-01f, -9.13230553e-02f,
  -7.06268009e-03f, 5.16928509e-02f, -3.21865715e-02f, 1.54670738e-02f, -4.08865474e-02f, 5.89343533e-03f, -2.19264664e-02f, -5.98909743e-02f, -7.27513358e-02f, 2.10514441e-02f,
  -5.97170182e-02f, -6.89811110e-02f, 5.37429526e-02f, 8.56455117e-02f, 9.80594307e-02f, -3.85451689e-02f, 4.19876277e-02f, -5.36315106e-02f, -1.42712509e-02f, -1.27417287e-02f,
  6.31719977e-02f, 1.43922213e-02f, 1.15729205e-01f, 1.68207139e-01f, 2.26131883e-02f, -1.24121666e-01f, -3.70779410e-02f, 7.31555000e-02f, 2.04678655e-01f, -4.84624952e-02f,
  1.06680458e-02f, -1.03433980e-02f, 3.29497606e-02f, 5.05389385e-02f, -3.81739275e-03f, -3.73463333e-02f, 5.38867265e-02f, -4.53766361e-02f, 1.27084628e-01f, 3.98323536e-02f,
  1.34839997e-01f, -2.98701879e-02f, 5.83679304e-02f, -7.67393559e-02f, 1.15237795e-01f, 4.72487733e-02f, -3.38582732e-02f, -8.07067826e-02f, -7.07683191e-02f, -1.10892415e-01f,
  -2.77026314e-02f, 1.02714524e-01f, 3.23952585e-02f, -5.88065274e-02f, 1.99326854e-02f, 7.55164474e-02f, 7.51262084e-02f, -7.37653375e-02f, 1.04677647e-01f, 2.50179786e-02f,
  6.81151450e-03f, 6.71204850e-02f, -2.92561017e-02f, -7.86366407e-03f, -6.37528673e-02f, -3.90812941e-02f, -4.75780852e-02f, -1.17486743e-02f, -1.72233004e-02f, 9.92877558e-02f,
  8.31074417e-02f, 6.32858053e-02f, 1.02186084e-01f, -3.14535722e-02f, -4.51280130e-03f, 2.66157743e-02f, 4.89022918e-02f, -4.86638844e-02f, -1.20747034e-02f, 1.25082517e-02f,
  -6.44586161e-02f, 5.02684489e-02f, -5.79176061e-02f, 7.87206553e-03f, 7.41678253e-02f, -7.59432763e-02f, -2.39394940e-02f, -5.10451209e-04f, -5.68445288e-02f, -1.12544373e-02f,
  2.28245538e-02f, 9.05000269e-02f, -3.71348225e-02f, -2.65500695e-02f, -7.48582780e-02f, -2.08874494e-02f, -1.02714486e-01f, 4.65894444e-03f, -4.30415268e-04f, 7.64494110e-03f,
  7.51281008e-02f, -7.57919997e-02f, -1.25601543e-02f, -1.91886500e-02f, -7.00239018e-02f, 2.03875126e-03f, -5.92933223e-03f, 4.53660935e-02f, -9.65200178e-03f, -8.14902484e-02f,
  -1.67757571e-02f, 3.71803008e-02f, -3.38913947e-02f, -8.42661932e-02f, 7.82997087e-02f, -2.78933365e-02f, -3.16872410e-02f, -7.22831441e-03f, -2.72191074e-02f, 4.37806286e-02f,
  -7.78977796e-02f, -2.60660541e-03f, 8.68086293e-02f, -2.75907107e-02f, 1.30128376e-02f, -3.34971510e-02f, -8.01541358e-02f, 4.14913222e-02f, 6.55657649e-02f, 9.91048366e-02f,
  8.42221454e-02f, -6.24897005e-03f, -1.43995439e-03f, 6.60958439e-02f, -6.95724189e-02f, -2.13579908e-02f, -6.57587033e-03f, 3.78050171e-02f, 6.50417060e-03f, -1.89355314e-02f,
  -9.38147604e-02f, 1.28298938e-01f, 2.31992230e-01f, -1.53908087e-02f, 1.34849519e-01f, 7.77099878e-02f, 2.84849219e-02f, -1.62371397e-02f, -7.75507092e-02f, 4.70619202e-02f,
  6.50833771e-02f, -5.10426350e-02f, 6.44897372e-02f, -1.49082590e-03f, -5.21404073e-02f, -5.00870049e-02f, -7.41986781e-02f, -1.44888416e-01f, 2.62406841e-03f, -1.17744550e-01f,
  -8.68747607e-02f, -1.76288381e-01f, 9.06735957e-02f, -1.71587355e-02f, 4.97826301e-02f, -9.37734395e-02f, -1.37277156e-01f, 5.52520491e-02f, 5.58462441e-02f, -9.68279466e-02f,
  -1.12079822e-01f, -1.31517828e-01f, -1.60629507e-02f, 4.18590382e-02f, -2.18932573e-02f, 5.67817353e-02f, -8.75740871e-02f, 6.28870502e-02f, -6.41356483e-02f, 5.68726957e-02f,
  -5.30387610e-02f, -6.07568882e-02f, -1.09191507e-01f, 2.21039057e-02f, 3.05196107e-03f, 4.60190326e-02f, 1.05876319e-01f, 2.61286441e-02f, 8.50042105e-02f, 1.42409325e-01f,
  5.98586984e-02f, -2.74725929e-02f, -7.93004688e-03f, -1.95436999e-02f, -1.12377787e-02f, 4.73431405e-03f, 4.50812429e-02f, -8.59593675e-02f, -6.21879997e-04f, 1.32190306e-02f,
  -5.36066201e-03f, -5.48718348e-02f, 5.70883527e-02f, 3.49572226e-02f, -4.60322648e-02f, -5.17669171e-02f, 7.53410626e-03f, 5.14531545e-02f, 3.19908671e-02f, -6.20009601e-02f,
  -5.98633103e-02f, 2.89833359e-02f, 7.93743059e-02f, -2.03569029e-02f, -5.14087416e-02f, -4.23992388e-02f, 7.86035359e-02f, 2.08318643e-02f, -8.74910504e-03f, 4.83516380e-02f,
  1.38973705e-02f, -2.24354006e-02f, 1.34445736e-02f, -4.38014716e-02f, 5.22719361e-02f, 5.75648285e-02f, -4.56059389e-02f, -2.24347152e-02f, -5.88324629e-02f, 4.64002974e-02f,
  -1.33662343e-01f, -1.99956432e-01f, 6.08471707e-02f, -3.43599766e-02f, 1.98400542e-02f, 7.74656562e-03f, -9.93414521e-02f, 4.15287800e-02f, -5.59443198e-02f, -9.25628876e-04f,
  6.02374785e-02f, 3.23362201e-02f, -9.27077904e-02f, -5.75035363e-02f, -5.36097512e-02f, -7.13981763e-02f, 1.92827024e-02f, -4.65702601e-02f, -1.21120578e-02f, -5.58634959e-02f,
  3.79057862e-02f, -4.64802496e-02f, -4.22110260e-02f, -3.15722898e-02f, -1.06276721e-01f, -2.83720717e-02f, -4.47211750e-02f, -3.27352388e-03f, -9.11885425e-02f, -4.25758073e-03f,
  4.32915287e-03f, 4.97085825e-02f, -9.27885342e-03f, -8.48717839e-02f, -2.26461627e-02f, -9.05108303e-02f, -1.44568188e-02f, 1.81690902e-02f, 5.96616790e-02f, -1.43326074e-03f,
  -4.09119092e-02f, 8.43445286e-02f, -7.43947551e-02f, 2.79323058e-03f, -1.75665304e-01f, -5.93207628e-02f, 6.57040998e-02f, 7.88859501e-02f, -3.59249599e-02f, -1.27800507e-02f,
  -1.12240970e-01f, -1.59955248e-02f, -1.34731740e-01f, -1.26999751e-01f, 3.13438103e-02f, -1.62324570e-02f, -1.63009703e-01f, 2.96661034e-02f, 3.83150466e-02f, 2.22645868e-02f,
  5.67313805e-02f, 1.12064734e-01f, 1.81460958e-02f, -1.87853817e-02f, 3.22434865e-02f, 3.79575901e-02f, 3.40178162e-02f, -3.77248041e-02f, -9.98433679e-02f, 8.30581412e-02f,
  -4.85626459e-02f, -1.01020769e-03f, 9.81836244e-02f, 6.23744614e-02f, 3.94012108e-02f, -7.81608671e-02f, 1.63070969e-02f, 4.53064106e-02f, -7.08073080e-02f, 4.82309237e-02f,
  -6.17301948e-02f, -4.62521426e-02f, 7.07206279e-02f, 2.55822353e-02f, 1.17161721e-02f, 2.63546035e-02f, -5.71633242e-02f, -1.01417638e-01f, 7.54242390e-02f, -4.48108800e-02f,
  6.33550808e-02f, 7.25980550e-02f, -2.78165266e-02f, -7.16394559e-02f, -6.06805682e-02f, 4.53298874e-02f, 3.11671868e-02f, 6.33853152e-02f, 7.92169571e-02f, -3.91620696e-02f,
  -4.13514413e-02f, 7.15832859e-02f, -6.24043569e-02f, -6.05919249e-02f, -6.38716742e-02f, 3.98862995e-02f, 1.63158216e-02f, 4.81172986e-02f, -6.15590438e-02f, -8.22549835e-02f,
  5.73684126e-02f, -4.22105119e-02f, -3.73264365e-02f, 5.29071279e-02f, -6.62589818e-02f, 9.15649161e-02f, -4.28321101e-02f, 1.45572573e-02f, -8.76253769e-02f, -6.76069632e-02f,
  9.82294697e-03f, 1.10059001e-01f, 1.19452532e-02f, -2.66385563e-02f, -7.62577355e-02f, -9.08569992e-03f, 4.28933911e-02f, 5.15400618e-02f, -1.91716533e-02f, 3.29800248e-02f,
  5.68108559e-02f, 5.67980111e-02f, -2.33494770e-02f, -1.84445065e-02f, 1.61951184e-02f, -4.44704145e-02f, 8.78149197e-02f, -4.57110442e-03f, 4.07028422e-02f, -8.65381286e-02f,
  8.75357911e-02f, -4.04489115e-02f, 2.20735352e-02f, 7.65062422e-02f, -2.01039817e-02f, 3.73010933e-02f, 2.17607170e-02f, 2.22764909e-02f, 6.15110993e-02f, 7.03367144e-02f,
  1.76747769e-01f, -3.19390856e-02f, -1.60871834e-01f, -5.61611131e-02f, -4.95820083e-02f, 6.73288479e-02f, -4.93507795e-02f, 9.45253018e-03f, -8.13437179e-02f, 1.31898969e-01f,
  4.38339412e-02f, -9.78075154e-03f, 1.04778357e-01f, -1.13817938e-01f, 1.09076902e-01f, 3.93652394e-02f, 8.52289423e-02f, -2.23997049e-02f, 5.29449172e-02f, 5.20879775e-03f,
  6.90699518e-02f, -8.04014597e-03f, 6.97918562e-03f, -1.22515567e-01f, -3.14830244e-02f, -1.47546396e-01f, -1.87597126e-02f, -5.97151257e-02f, -1.31218173e-02f, -8.69643986e-02f,
  -2.84352954e-02f, 3.51367630e-02f, 3.18147466e-02f, 5.57273626e-02f, 6.02318160e-02f, 2.02269796e-02f, -8.63209739e-02f, -1.10177703e-01f, -6.93069175e-02f, 2.73395330e-03f,
  -5.44517301e-02f, -2.18193419e-03f, -8.45685676e-02f, 1.95425935e-02f, 4.41063046e-02f, -1.00604571e-01f, -8.72951522e-02f, 5.35874367e-02f, 6.14569290e-03f, -5.06547317e-02f,
  -1.05403841e-01f, -9.95091945e-02f, -2.46872660e-02f, -5.92242507e-03f, -1.07548729e-01f, 2.92521212e-02f, 3.96221913e-02f, -3.31994258e-02f, 5.15372790e-02f, -8.69847685e-02f,
  1.29053136e-02f, -3.34296115e-02f, -7.12679625e-02f, 2.54814811e-02f, 1.36994477e-02f, 2.71345135e-02f, 7.81496614e-03f, 4.40972187e-02f, 1.14935422e-02f, 8.39659944e-02f,
  1.59303192e-02f, 6.20439202e-02f, -3.33975442e-02f, -6.31550327e-02f, -1.62302759e-02f, -2.83434801e-03f, -1.25839515e-02f, 1.77478418e-02f, 6.75044656e-02f, -7.82380998e-02f,
  -2.21127570e-02f, -7.33655021e-02f, -3.46584921e-03f, 3.65201347e-02f, 2.82028783e-02f, -2.30050664e-02f, 6.76918626e-02f, -3.32499780e-02f, -3.25029157e-02f, 5.34622744e-02f,
  5.84433749e-02f, 1.42625928e-01f, 1.39486985e-02f, -9.52457488e-02f, -4.04295921e-02f, 5.57801872e-02f, -3.25588998e-03f, -7.53052756e-02f, -6.28807172e-02f, 2.50723097e-03f,
  1.70035306e-02f, -2.36216746e-02f, -1.36168730e-02f, 5.62640354e-02f, 5.65067120e-02f, -5.97693911e-03f, 6.14005625e-02f, 6.51647523e-02f, 8.33276566e-03f, 5.68359159e-02f,
  2.93929894e-02f, -4.17304933e-02f, 6.57820404e-02f, 6.61202595e-02f, 1.30325304e-02f, 4.72576683e-03f, -5.67759536e-02f, -5.14583550e-02f, 1.00701466e-01f, -7.46519715e-02f,
  9.63435918e-02f, -2.67289937e-01f, 6.34878278e-02f, 2.39660412e-01f, 2.58874625e-01f, 1.80797968e-02f, 1.41842976e-01f, 1.23484559e-01f, 2.10829481e-01f, -2.14269027e-01f,
  3.57656204e-03f, -1.40984237e-01f, -1.49692863e-01f, 5.38816787e-02f, 1.32043332e-01f, -5.12224808e-02f, 3.46244350e-02f, -1.14665210e-01f, 9.31767449e-02f, 7.81862512e-02f,
  1.14024267e-01f, 1.20330356e-01f, 8.53821561e-02f, 1.52755007e-02f, 1.72587588e-01f, 6.71188310e-02f, -4.61345352e-02f, -1.08211279e-01f, 1.74666606e-02f, -4.04302143e-02f,
  -8.20332319e-02f, 9.44097713e-02f, 6.70304149e-02f, 3.80899757e-02f, -1.70794837e-02f, 2.73000672e-02f, -7.34745488e-02f, -9.36854724e-03f, -1.80120040e-02f, -2.11029407e-02f,
  -1.34028718e-01f, 9.22747031e-02f, 1.06769279e-01f, 4.61435281e-02f, 2.96712071e-02f, 1.21044025e-01f, 4.29221503e-02f, 7.77115822e-02f, 7.22116604e-02f, 8.67672414e-02f,
  5.25451116e-02f, -6.78746551e-02f, 1.94803867e-02f, -3.65506373e-02f, -4.25653607e-02f, 3.65632959e-02f, -9.27318037e-02f, 8.22865032e-03f, -3.85848209e-02f, 3.37626785e-02f,
  6.21423572e-02f, -3.58073413e-02f, -4.46926020e-02f, 8.89342278e-02f, -8.64127725e-02f, 1.23061933e-01f, -4.55730110e-02f, -1.94125883e-02f, -4.22934964e-02f, 2.25555263e-02f,
  6.79181293e-02f, -5.73097952e-02f, 7.16232210e-02f, 2.70008780e-02f, 3.71528380e-02f, 3.43795344e-02f, -7.39548355e-02f, -3.15053314e-02f, -5.12749422e-03f, -8.31698719e-03f,
  5.66671714e-02f, 2.19305977e-03f, -5.33517934e-02f, 5.18997237e-02f, -6.33631274e-02f, -5.01690358e-02f, 3.04735824e-02f, 3.40933464e-02f, 7.03798532e-02f, 5.80003485e-03f,
  -1.82186559e-01f, -1.45393506e-01f, 9.43432841e-03f, 5.88627830e-02f, -8.72566029e-02f, -9.59063470e-02f, 1.91802774e-02f, 5.69867827e-02f, -5.53746754e-03f, 5.13382293e-02f,
  -3.49145643e-02f, 1.71559043e-02f, -8.21323246e-02f, 2.30447575e-03f, -6.39490560e-02f, 5.18138595e-02f, -1.00092925e-01f, -7.40047172e-02f, -3.86114954e-03f, -9.94428769e-02f,
  2.13663629e-03f, -3.34238298e-02f, 6.12046048e-02f, 5.20455018e-02f, -3.20993252e-02f, -8.48802552e-02f, -5.58557846e-02f, -8.26764107e-02f, -6.75229728e-03f, -8.07225630e-02f,
  2.37605721e-02f, 1.59559354e-01f, 9.28410366e-02f, -8.05629697e-03f, -5.01297936e-02f, -1.79410428e-01f, 1.39396749e-02f, -1.22265443e-02f, 1.76917642e-01f, -3.31829749e-02f,
  -9.86668393e-02f, 4.98302877e-02f, 4.08464335e-02f, 7.95770809e-02f, -1.89909518e-01f, -2.43436955e-02f, -3.82145979e-02f, 4.10853140e-02f, -9.89695918e-03f, 7.70784244e-02f,
  -1.28219068e-01f, -4.65261703e-03f, -1.16800457e-01f, 3.56846303e-02f, 7.10854903e-02f, -1.10146655e-02f, -3.56634706e-02f, 7.45394602e-02f, 1.17043993e-02f, -6.51986003e-02f,
  -2.47247797e-02f, 2.78690010e-02f, 8.14211592e-02f, 5.68686835e-02f, -6.40836582e-02f, -6.83624065e-03f, 3.89029793e-02f, -4.54796255e-02f, 7.92702958e-02f, 1.03463225e-01f,
  3.76181081e-02f, 7.34324306e-02f, 6.42808899e-02f, 4.39389646e-02f, 3.92638221e-02f, 1.51458476e-02f, 8.78690779e-02f, 5.15249521e-02f, 8.90626460e-02f, 9.95851979e-02f,
  3.20040854e-04f, 2.01347265e-02f, 6.35235831e-02f, -2.20459029e-02f, -7.51647353e-02f, -5.38694151e-02f, -6.67069331e-02f, 5.38993739e-02f, 4.64195535e-02f, 4.13991231e-03f,
  9.17997397e-03f, -5.71885817e-02f, -4.46835048e-02f, 7.94121698e-02f, -8.78530815e-02f, 6.44577369e-02f, -6.67881519e-02f, -1.82875041e-02f, 2.89851762e-02f, -4.13204804e-02f,
  8.85282159e-02f, -4.30641845e-02f, 7.45732486e-02f, -7.94689506e-02f, 6.84473515e-02f, 2.51755621e-02f, 3.52675654e-02f, 2.22148784e-02f, -2.98218764e-02f, 6.58358186e-02f,
  3.20204683e-02f, -9.85392481e-02f, 9.77912247e-02f, 1.64991245e-02f, 2.71378849e-02f, -7.70113543e-02f, 3.56998034e-02f, 4.53599874e-04f, 2.07433235e-02f, -4.24036942e-02f,
  -8.55199173e-02f, -6.32509887e-02f, 5.41962124e-02f, -3.59818041e-02f, 6.29465282e-02f, 3.02430186e-02f, 3.38473432e-02f, -4.32063006e-02f, -7.79253766e-02f, -2.07753368e-02f,
  -4.38991152e-02f, 5.81717491e-02f, -2.93658231e-03f, 6.90268129e-02f, 8.97108577e-03f, 3.38490270e-02f, -4.69665602e-02f, 7.90420845e-02f, 2.22470164e-02f, -9.53710638e-03f,
  1.91139989e-02f, -3.47095244e-02f, 6.88551292e-02f, 6.83643445e-02f, -5.45759127e-03f, -5.62178902e-03f, -8.30727071e-03f, 4.90126275e-02f, -8.87768865e-02f, -3.66506912e-02f,
  -3.74559201e-02f, -1.97075889e-01f, -1.88479692e-01f, 1.46499882e-02f, 3.46269198e-02f, 6.09642826e-02f, -6.35493845e-02f, 1.75120458e-02f, -8.98797810e-02f, 1.43116917e-02f,
  8.13401416e-02f, -4.45929654e-02f, -2.59670794e-01f, 4.00198326e-02f, -4.91116680e-02f, -1.66650131e-01f, 1.23752937e-01f, 5.16469069e-02f, 2.03550812e-02f, -3.56045440e-02f,
  -3.44019085e-02f, 1.12512596e-01f, 3.88419256e-02f, 1.82730794e-01f, -1.22429011e-02f, 1.17177986e-01f, 1.11316256e-01f, -9.49660540e-02f, 1.37442291e-01f, 1.56783894e-01f,
  -1.19528249e-02f, -1.26453474e-01f, -4.26307954e-02f, 6.47363514e-02f, -3.52756828e-02f, 8.31446424e-02f, 4.99536656e-02f, -5.64601682e-02f, -7.46197030e-02f, 6.23212419e-02f,
  -4.83965054e-02f, -6.60227612e-02f, 8.59331563e-02f, 6.35485798e-02f, 3.18522975e-02f, 5.57812192e-02f, 1.03585713e-03f, -7.44332895e-02f, 7.74643337e-03f, 4.00812998e-02f,
  -8.85227248e-02f, 5.45380674e-02f, -9.49504972e-02f, 7.68490657e-02f, -7.98521936e-02f, -4.06134548e-03f, -5.41932248e-02f, -5.33349179e-02f, 6.33914545e-02f, 1.01626836e-01f,
  4.51149531e-02f, 8.08267295e-02f, -3.24493498e-02f, -4.53908183e-02f, 5.79752289e-02f, -4.62137125e-02f, -3.00374185e-03f, -3.07130534e-03f, 1.56822484e-02f, -6.88447952e-02f,
  -5.29761380e-03f, -5.07566929e-02f, 3.66969854e-02f, 1.81644093e-02f, 7.59718493e-02f, 8.16330779e-03f, 5.66054769e-02f, -2.68045813e-02f, -6.57191128e-02f, 7.58651178e-03f,
  -9.32316408e-02f, -4.69319858e-02f, -5.31159416e-02f, -5.40206321e-02f, 8.35359022e-02f, -7.91118890e-02f, 8.38329047e-02f, -4.71909493e-02f, -7.46995211e-02f, 1.85754094e-02f,
  4.26812880e-02f, -1.44042432e-01f, -2.09185388e-02f, 9.65558216e-02f, -7.15312436e-02f, 7.77974084e-04f, 2.59256642e-02f, 1.82439107e-02f, 1.78484507e-02f, -7.21766725e-02f,
  -7.26924613e-02f, -1.24408063e-02f, 8.08179900e-02f, 3.54757421e-02f, 3.49283181e-02f, 5.94334230e-02f, 3.56033407e-02f, -8.13217759e-02f, 1.54404407e-02f, -1.06775528e-02f,
  -8.25437009e-02f, 2.88898665e-02f, -5.14665805e-02f, 5.74490707e-03f, -5.21565005e-02f, 4.80069518e-02f, 1.96446721e-02f, 5.28396331e-02f, 6.95171878e-02f, 5.40281422e-02f,
  -1.78081840e-01f, 5.18676713e-02f, -1.39093906e-01f, 1.06834825e-02f, -1.74648073e-02f, 2.45255101e-02f, -5.66047765e-02f, -3.74041349e-02f, -1.38554484e-01f, -1.24793023e-01f,
  -2.13941988e-02f, -1.05659343e-01f, -1.29460305e-01f, 7.15909228e-02f, 1.38578430e-01f, 8.08915123e-02f, 1.35333315e-01f, 1.36063516e-01f, 2.26700827e-02f, -1.97106767e-02f,
  7.92798176e-02f, 8.08268785e-02f, 2.45667443e-01f, 1.19705528e-01f, 1.09634735e-01f, -5.10808490e-02f, 1.05939984e-01f, 5.20568825e-02f, 1.36104867e-01f, 1.24442287e-01f,
  1.29729673e-01f, -9.46549699e-02f, -7.46053979e-02f, 3.51495370e-02f, -3.53338644e-02f, -1.22228764e-01f, -2.75288746e-02f, 1.58834513e-02f, -5.80760092e-02f, 6.95657358e-02f,
  -7.01098517e-02f, 2.45827828e-02f, 5.19596450e-02f, -3.58051322e-02f, -4.34181392e-02f, 5.28432019e-02f, 8.14698786e-02f, 7.32624605e-02f, -1.04554379e-02f, 2.69419793e-02f,
  -6.77394196e-02f, 1.94773804e-02f, 6.33567870e-02f, 3.52626629e-02f, -4.59535792e-02f, 6.11228980e-02f, 7.85698667e-02f, 4.86896783e-02f, 2.46125124e-02f, 1.48258926e-02f,
  -2.78339684e-02f, 8.21262524e-02f, -6.16302826e-02f, 4.68166247e-02f, -6.40068203e-02f, 7.00310320e-02f, 7.26359487e-02f, 4.98845987e-02f, -1.40661758e-03f, -5.33823781e-02f,
  8.94338712e-02f, -6.50053248e-02f, 8.44521597e-02f, -2.50232592e-02f, 2.41302289e-02f, -9.75553226e-03f, 7.01774508e-02f, -3.32680270e-02f, -2.01583318e-02f, -5.21996431e-02f,
  6.36352822e-02f, 6.51839748e-02f, 3.93992849e-03f, -7.71335363e-02f, -2.72182897e-02f, -3.49840298e-02f, 8.37270170e-02f, 1.61302332e-02f, -5.72882481e-02f, -7.55949765e-02f,
  -1.89401433e-02f, 6.14271360e-03f, 5.20200469e-03f, 4.65227626e-02f, 3.71622220e-02f, -1.00036729e-02f, -4.75494303e-02f, -2.89316326e-02f, -3.43944505e-02f, -9.31420848e-02f,
  -6.42504692e-02f, 1.55741433e-02f, -8.88282731e-02f, 5.08704707e-02f, 4.71018888e-02f, -4.31846343e-02f, -3.10275182e-02f, 5.60809858e-02f, 1.27520896e-02f, -6.19037449e-02f,
  -2.56320070e-02f, -8.63529593e-02f, 1.93966050e-02f, 2.92428993e-02f, 5.62266968e-02f, -3.73599902e-02f, 2.98943985e-02f, -1.44240186e-02f, 1.75303053e-02f, 6.99979812e-02f,
  2.61043347e-02f, -5.23089319e-02f, 5.38255274e-02f, 6.61614537e-02f, -4.34094816e-02f, -9.62574184e-02f, -1.46357849e-01f, 5.86512387e-02f, -1.40076000e-02f, -1.38483986e-01f,
  -1.26142455e-02f, -4.56341282e-02f, -4.96336445e-02f, 1.35863617e-01f, 1.67407200e-01f, -3.36344610e-03f, 6.17946796e-02f, -7.02512115e-02f, 4.72273640e-02f, 1.31671920e-01f,
  5.23711592e-02f, 2.10581556e-01f, 1.55497238e-01f, 1.26920655e-01f, 5.89208342e-02f, 9.96480361e-02f, 1.42552316e-01f, 3.72759514e-02f, 1.80757806e-01f, 7.95507431e-02f,
  -5.27892970e-02f, 7.57916123e-02f, 5.34494333e-02f, -1.40433386e-02f, -1.98669303e-02f, -9.48442519e-02f, -1.00807576e-02f, 7.16890991e-02f, 7.00070336e-02f, 4.17247377e-02f,
  -3.65502238e-02f, -2.79869400e-02f, 1.01506762e-01f, 1.53930364e-02f, 7.32070729e-02f, 8.28296766e-02f, -7.25553408e-02f, -8.45096856e-02f, -8.70930851e-02f, -2.78696441e-03f,
  6.67056963e-02f, -4.65988461e-03f, -6.31010346e-03f, -7.85261244e-02f, -2.82413065e-02f, -2.11878568e-02f, -4.06594686e-02f, -1.88262332e-02f, 6.66362643e-02f, 3.95681523e-02f,
  2.46255053e-03f, 1.80344954e-02f, 6.45480677e-03f, 2.22793315e-02f, 7.92557299e-02f, -6.73773186e-03f, 4.35727611e-02f, -2.21217070e-02f, 1.67106874e-02f, -9.19702500e-02f,
  -3.91497724e-02f, 1.32381003e-02f, -2.54612090e-03f, 5.19894715e-03f, 6.83514550e-02f, 2.37392243e-02f, -2.33671553e-02f, -2.37738853e-03f, 5.88272735e-02f, -1.66603811e-02f,
  -4.26304974e-02f, 7.91398585e-02f, 4.26917709e-02f, 5.38850622e-03f, 1.29790800e-02f, 6.38471823e-03f, 7.66759664e-02f, -6.80357888e-02f, 8.54332224e-02f, -9.27752815e-03f,
  -9.78382304e-03f, 1.47183752e-03f, 6.85335323e-02f, -1.00940904e-02f, 5.07959239e-02f, 7.22086355e-02f, -7.46457204e-02f, 9.40131769e-02f, 8.25259611e-02f, 6.71584830e-02f,
  -1.15237106e-02f, 1.04995621e-02f, 1.76575724e-02f, 2.36428324e-02f, 9.81441364e-02f, 5.00796735e-02f, -4.35825139e-02f, 1.35338726e-02f, 2.51933914e-02f, 6.08056076e-02f,
  3.55069898e-02f, 2.51056068e-03f, 5.84150665e-02f, -5.16257808e-02f, -3.23786922e-02f, -1.01066120e-02f, -6.59362525e-02f, 1.99074886e-04f, -1.29929325e-02f, 4.66754623e-02f,
  6.66807815e-02f, 1.46893542e-02f, -4.23192456e-02f, 1.15827844e-01f, -9.89050865e-02f, -2.01713309e-01f, -1.43657878e-01f, -1.75529588e-02f, 1.13463558e-01f, 6.83439989e-03f,
  -8.65356550e-02f, 1.74032003e-01f, -6.33205846e-02f, 8.80226195e-02f, 1.86990947e-01f, 1.62884489e-01f, 1.79924015e-02f, 1.43063307e-01f, 6.54401407e-02f, 8.02763849e-02f,
  7.08739236e-02f, -5.88138551e-02f, 7.22087771e-02f, 5.29549026e-04f, -1.29075825e-01f, -7.23841041e-02f, 7.75862932e-02f, -9.58221629e-02f, 4.05779146e-02f, -4.01049890e-02f,
  -5.41011766e-02f, -1.30476691e-02f, 5.83344549e-02f, 1.24977482e-02f, 5.82145713e-02f, -4.90282923e-02f, 7.46120214e-02f, 8.98894668e-02f, 5.02735600e-02f, -1.44027900e-02f,
  3.05534694e-02f, -1.36209130e-02f, 1.68949869e-02f, 7.71521106e-02f, -8.22864175e-02f, 3.31221484e-02f, 6.04134686e-02f, -4.89725433e-02f, 6.85664499e-03f, -9.24783275e-02f,
  5.61263459e-03f, 3.51246190e-03f, 7.20404983e-02f, 9.13669914e-02f, -1.24834925e-02f, 3.47615816e-02f, -6.25573322e-02f, 7.40917996e-02f, 7.57771730e-02f, 1.51631748e-02f,
  -5.76345623e-02f, -6.30672202e-02f, 5.88443950e-02f, 3.97220962e-02f, -1.94723308e-02f, 1.44927511e-02f, 1.92316342e-02f, 1.84379965e-02f, -4.82594781e-02f, 5.49578704e-02f,
  -8.31954554e-02f, -7.23161772e-02f, -1.26161948e-02f, 6.01685271e-02f, 8.20142478e-02f, -3.17929573e-02f, -7.10054338e-02f, 3.52032371e-02f, 8.06899890e-02f, 1.48500837e-02f,
  7.05890581e-02f, -3.59723866e-02f, -3.47144809e-03f, 1.52949141e-02f, -5.76235764e-02f, -5.61398678e-02f, -3.51378880e-02f, -4.98731583e-02f, -5.14385030e-02f, -1.98778640e-02f,
  7.09511638e-02f, -7.38788350e-03f, -1.33625139e-02f, -3.12030856e-02f, 1.31130619e-02f, 6.47677407e-02f, 3.89203839e-02f, 2.95671262e-02f, 1.13206454e-01f, 1.51425721e-02f,
  8.12243894e-02f, -4.00900207e-02f, 6.46105930e-02f, 2.25304775e-02f, -6.12583384e-02f, 2.84977332e-02f, 4.55006137e-02f, 9.13200974e-02f, 7.90172219e-02f, -5.40094413e-02f,
  5.82794510e-02f, 2.89524198e-02f, 3.98316532e-02f, 3.66436839e-02f, 7.69258142e-02f, 7.90083334e-02f, 7.74690742e-03f, 7.08942711e-02f, 1.82241574e-02f, 4.66375947e-02f,
  -2.78039817e-02f, -3.48994099e-02f, -1.66359186e-01f, -1.20099541e-03f, -3.14328000e-02f, 6.81619272e-02f, -5.58838174e-02f, 5.39814401e-03f, -1.10620916e-01f, 1.42754242e-01f,
  1.35351092e-01f, -4.90393154e-02f, 5.20256944e-02f, 9.41911116e-02f, 1.68188363e-02f, 2.22482625e-02f, 1.46825150e-01f, 9.37377661e-02f, -9.12231728e-02f, 3.11563071e-02f,
  -2.28842590e-02f, 1.60973623e-01f, 2.83336658e-02f, -2.10972391e-02f, 4.87722456e-02f, -3.20215225e-02f, 3.02975415e-04f, 5.79296518e-03f, 6.88697249e-02f, 2.16876883e-02f,
  1.28809378e-01f, -8.67384672e-02f, -8.75011235e-02f, 8.05424079e-02f, 8.56320485e-02f, 4.73472513e-02f, -9.91381094e-05f, -7.49476254e-02f, -8.71520936e-02f, -5.27333990e-02f,
  8.29905272e-02f, -5.94112091e-03f, 7.57605806e-02f, 8.57481286e-02f, -7.33477026e-02f, -1.17350638e-01f, -8.09593499e-02f, -5.34613952e-02f, 9.70130879e-03f, -9.54247117e-02f,
  -1.01266116e-01f, -6.03120103e-02f, 1.89164616e-02f, 6.50175214e-02f, -6.53796718e-02f, 6.92996830e-02f, -3.15912850e-02f, 6.13804758e-02f, -9.24404189e-02f, -8.88313130e-02f,
  1.32851349e-02f, -4.11390550e-02f, 3.50205526e-02f, 1.44764371e-02f, -1.02614546e-02f, -4.60393652e-02f, -2.97555588e-02f, 9.91805345e-02f, 3.33581641e-02f, -4.40365029e-03f,
  8.24913606e-02f, -2.35358067e-02f, 9.06704590e-02f, 1.02048598e-01f, -8.96163192e-03f, 4.25713276e-03f, 3.74254957e-02f, -8.57341513e-02f, -2.25776322e-02f, -2.75949612e-02f,
  9.24517140e-02f, 5.63054793e-02f, -5.29701523e-02f, -7.61031918e-03f, -9.33131054e-02f, -8.14128295e-03f, -4.21470106e-02f, 3.90611328e-02f, -4.11695316e-02f, 5.05182520e-02f,
  1.16421897e-02f, -1.12916067e-01f, -5.15297465e-02f, -1.29472725e-02f, -3.34887132e-02f, 5.80225550e-02f, 2.16246117e-02f, -1.03613578e-01f, 3.04293707e-02f, -4.60978858e-02f,
  6.62624761e-02f, 7.61455595e-02f, -1.20752668e-02f, -2.72118431e-02f, 5.60088493e-02f, -7.92220384e-02f, 9.63336527e-02f, -3.56756635e-02f, 5.87345101e-02f, 2.71300972e-02f,
  -6.68127462e-02f, -2.38474272e-02f, -3.57719585e-02f, -1.61121367e-03f, 4.77777421e-02f, 8.13273862e-02f, -4.29229289e-02f, -1.04732430e-02f, 4.40993393e-03f, -8.65283459e-02f,
  2.37403452e-01f, -1.49286881e-01f, 7.40058273e-02f, 1.59513891e-01f, 4.89144176e-02f, 7.99396709e-02f, 6.79343566e-02f, -1.03224985e-01f, -6.08190335e-02f, -2.17312932e-01f,
  -8.93062353e-03f, 1.09337784e-01f, 4.94487491e-03f, 2.57479362e-02f, 7.74305835e-02f, -1.25512287e-01f, 1.09656796e-01f, 8.69767815e-02f, -1.00474894e-01f, 6.36517704e-02f,
  7.07449168e-02f, 5.63578941e-02f, 8.30796212e-02f, -1.27056107e-01f, 1.92763120e-01f, 3.64466310e-02f, -4.71512899e-02f, -5.70227206e-02f, 1.49128705e-01f, 3.92570756e-02f,
  1.70997437e-02f, 4.74398211e-02f, 3.79998237e-02f, 2.29200609e-02f, -4.36988510e-02f, -4.64360565e-02f, -6.84460774e-02f, 3.44880931e-02f, -1.02776578e-02f, -1.48825254e-02f,
  -2.44247280e-02f, 2.13691518e-02f, 5.37616313e-02f, -6.06680587e-02f, -5.73327485e-03f, -5.12329154e-02f, -3.21121812e-02f, -8.52640122e-02f, -5.07465824e-02f, 3.63236591e-02f,
  -8.13377947e-02f, -9.46412235e-02f, 9.47968289e-03f, -9.49050635e-02f, 6.36131912e-02f, 3.95386331e-02f, 6.40868098e-02f, -3.90369049e-03f, -7.32492283e-02f, 6.68895543e-02f,
  1.01710573e-01f, -5.34325689e-02f, 5.91271743e-02f, 6.84683397e-02f, 3.71236615e-02f, 3.90617549e-02f, -1.14154089e-02f, -6.60292208e-02f, 1.55763291e-02f, 4.17518541e-02f,
  -6.19475022e-02f, 2.44930200e-02f, -3.07788905e-02f, -4.47471952e-03f, 7.13396668e-02f, 7.26045445e-02f, 7.02672452e-02f, -5.22150323e-02f, 2.86891647e-02f, -5.09919710e-02f,
  -3.85626704e-02f, 6.72554001e-02f, 7.25138411e-02f, 1.83063522e-02f, -2.72972751e-02f, 2.18285080e-02f, 9.25583467e-02f, 6.18094951e-02f, -1.36918295e-02f, 6.28770590e-02f,
  3.64339389e-02f, -1.24635972e-01f, -3.82789485e-02f, 2.11769398e-02f, -1.04233362e-01f, -8.43294710e-02f, -7.29786977e-02f, 8.56643394e-02f, -8.10824931e-02f, 4.62365635e-02f,
  -3.92542146e-02f, 3.28162387e-02f, 1.93055551e-02f, -9.63214878e-03f, -7.98320174e-02f, -9.40796137e-02f, -7.77877197e-02f, -5.53910509e-02f, 6.62200823e-02f, -4.18273918e-02f,
  4.62113507e-02f, 2.19199192e-02f, 4.04610820e-02f, -3.44677940e-02f, -5.15723228e-03f, -6.09941147e-02f, 8.43810439e-02f, -8.31979290e-02f, -6.03171922e-02f, -6.92019761e-02f,
  -3.29586774e-01f, 1.97826475e-01f, -8.52187276e-02f, 7.77547881e-02f, -7.91688561e-02f, 1.59566239e-01f, 1.39787704e-01f, 2.14830749e-02f, -7.67830834e-02f, 2.39454359e-01f,
  1.17142752e-01f, -7.75979236e-02f, -3.58614675e-03f, 2.94216722e-01f, -6.24894723e-02f, 2.22422838e-01f, 1.95460334e-01f, 6.15677908e-02f, 4.36292030e-03f, -1.01451047e-01f,
  -5.58554269e-02f, 9.15294960e-02f, 1.16749175e-01f, 5.49783446e-02f, -8.51651058e-02f, -1.36137769e-01f, 2.17548236e-02f, -1.42834798e-01f, 1.73236489e-01f, 3.52461971e-02f,
  -1.40467867e-01f, -1.41382352e-01f, -9.77420136e-02f, -2.71310974e-02f, -1.28034294e-01f, 2.52104327e-02f, -4.99641858e-02f, -1.00500889e-01f, -7.77946860e-02f, -1.08482748e-01f,
  -8.76608565e-02f, -4.29967046e-02f, -2.48157680e-02f, -2.04023384e-02f, -9.53408331e-02f, 6.27468154e-02f, -3.82974260e-02f, -3.01104337e-02f, 3.36042941e-02f, -2.43914463e-02f,
  -3.98490345e-03f, 7.24212080e-02f, 8.60707536e-02f, 1.25247583e-01f, -6.29550964e-02f, 7.97546506e-02f, 3.62710953e-02f, 2.98623350e-02f, 4.68229391e-02f, 8.28336403e-02f,
  -4.77905422e-02f, 1.97201613e-02f, 7.40425885e-02f, -5.77187948e-02f, -6.83733374e-02f, 3.76645522e-03f, 1.86510058e-03f, -7.15002492e-02f, 5.22499233e-02f, 6.73900545e-02f,
  -4.32806090e-02f, 2.21447008e-05f, -7.16563761e-02f, -1.74949151e-02f, 9.81888827e-03f, -4.41403203e-02f, 7.43906945e-03f, -4.11191583e-02f, -1.94923151e-02f, 5.04260696e-02f,
  2.79622339e-02f, 1.02314996e-02f, -5.13028838e-02f, -2.69725230e-02f, -2.36769702e-04f, 7.41776638e-03f, -1.16175367e-02f, 5.86775504e-02f, -5.18058576e-02f, -1.82490032e-02f,
  -1.62742540e-01f, -2.30416074e-01f, -2.03169603e-02f, -1.05183423e-01f, -8.76128450e-02f, 6.86978176e-02f, -4.31553721e-02f, 6.53276518e-02f, -1.11392505e-01f, 1.32641504e-02f,
  -5.39942496e-02f, 3.22512002e-03f, -9.73817855e-02f, 2.85722353e-02f, 1.03398137e-01f, 7.79714063e-02f, -8.76422822e-02f, -2.32558772e-02f, -8.88420567e-02f, -2.38199141e-02f,
  -1.63498912e-02f, -5.85605251e-03f, -7.94941792e-04f, 5.62798120e-02f, -1.24276262e-02f, -7.51261488e-02f, -8.13828036e-02f, -7.83186331e-02f, -3.26812342e-02f, -3.48888934e-02f,
  -1.26977772e-01f, -4.44951653e-02f, 1.17873661e-01f, -1.18103728e-01f, -8.57862309e-02f, -1.35842590e-02f, -7.61352554e-02f, 3.15318294e-02f, -3.48160379e-02f, -3.32243107e-02f,
  5.47752567e-02f, 2.10730117e-02f, 4.29959185e-02f, -1.85184609e-02f, -5.38515747e-02f, 1.73330791e-02f, -1.81204248e-02f, 9.02911574e-02f, -6.04166985e-02f, -2.03315634e-02f,
  -2.24155048e-03f, 3.04831415e-02f, 8.23808610e-02f, -4.85335151e-03f, 6.88528270e-02f, 4.68989462e-02f, -3.10976878e-02f, -8.22054669e-02f, 8.75558555e-02f, 6.33179173e-02f,
  -7.88530558e-02f, -9.57448557e-02f, 8.81445408e-02f, -2.92060096e-02f, 9.50826108e-02f, 6.83329776e-02f, 1.86413396e-02f, 6.52066618e-02f, 4.06127758e-02f, 6.33042008e-02f,
  -7.62296692e-02f, -5.36885522e-02f, -7.50582144e-02f, -8.76763090e-02f, -9.46047306e-02f, -8.48533958e-02f, 1.53448209e-02f, -3.44789922e-02f, -4.75607850e-02f, 6.32181540e-02f,
  8.88234675e-02f, 8.82189348e-02f, 6.92633539e-02f, 5.64129874e-02f, -8.16910192e-02f, -4.19603437e-02f, -6.79201037e-02f, 1.14461154e-01f, 5.12495590e-03f, 4.16987389e-02f,
  3.35014332e-03f, 7.20772371e-02f, -8.33838284e-02f, 5.15815876e-02f, -2.66946089e-02f, -3.09125967e-02f, -8.48100781e-02f, 1.95055809e-02f, 1.48626219e-03f, 3.79974805e-02f,
  -3.45240310e-02f, -3.49813737e-02f, 7.23999292e-02f, 2.40480304e-02f, -1.16722984e-02f, 3.61654982e-02f, 7.05330819e-02f, 9.42963287e-02f, 4.73234467e-02f, 1.73212290e-02f,
  1.30850095e-02f, -1.35286665e-02f, 5.93031049e-02f, -4.86257337e-02f, 4.42151390e-02f, 1.54828923e-02f, 4.45942441e-03f, 8.48331079e-02f, 8.83352309e-02f, -2.54894830e-02f,
  -4.87320721e-02f, -2.07222514e-02f, 5.80951646e-02f, 2.32912563e-02f, -2.52037439e-02f, -6.55334666e-02f, 7.49292895e-02f, 9.40309651e-03f, -1.66332256e-02f, -2.63416022e-02f,
  -2.10411637e-03f, 1.11113014e-02f, 2.40296335e-03f, 3.70857632e-03f, 5.89328818e-02f, 4.94461618e-02f, -9.78925973e-02f, 3.06895599e-02f, 3.05349343e-02f, 4.55796234e-02f,
  -7.35366568e-02f, -8.17320645e-02f, 8.46849382e-02f, 8.75611007e-02f, -5.22517366e-03f, 3.97945121e-02f, -2.12488417e-02f, 5.34143895e-02f, 5.03248535e-02f, 2.79723052e-02f,
  5.50289750e-02f, 3.94704416e-02f, -9.01788846e-03f, -2.51231819e-01f, -5.70092946e-02f, -2.11374238e-01f, -1.27237245e-01f, -1.51014701e-02f, -7.17701688e-02f, -1.43830612e-01f,
  -9.10910890e-02f, -3.96049358e-02f, 4.77754474e-02f, -1.97804555e-01f, 6.69885725e-02f, 1.21423952e-01f, -2.46357590e-01f, -7.63036236e-02f, -9.56466014e-04f, -1.18232757e-01f,
  1.72034148e-02f, -4.70676199e-02f, -2.65504494e-02f, -3.95383351e-02f, -5.56088462e-02f, -8.27882588e-02f, 2.70575583e-02f, 7.90308323e-03f, -1.22979619e-01f, -9.52291489e-02f,
  -5.08922487e-02f, 8.87960866e-02f, 2.51939171e-04f, -6.64833337e-02f, -2.47343536e-02f, -4.72906157e-02f, -7.98857808e-02f, 3.68983671e-02f, -8.87531638e-02f, -7.51503035e-02f,
  -3.17245312e-02f, 3.29635069e-02f, 3.93309724e-03f, -2.06029527e-02f, -9.36007220e-03f, -1.09190106e-01f, -5.91465719e-02f, -5.58696352e-02f, -5.35707979e-04f, -1.62670184e-02f,
  4.64499667e-02f, 4.93603349e-02f, -9.04929861e-02f, -1.84292160e-02f, -7.90213495e-02f, -9.97158140e-02f, 6.14718124e-02f, -5.09375669e-02f, -1.04526505e-01f, -4.10825722e-02f,
  1.49006322e-02f, 2.50047632e-03f, -6.16703294e-02f, 9.13289115e-02f, 8.33778735e-03f, -2.13743607e-03f, -6.36833087e-02f, -2.07960838e-03f, 7.89154992e-02f, -7.47031793e-02f,
  2.50288285e-02f, 5.92847057e-02f, -8.55212286e-02f, -8.72963965e-02f, -4.84632626e-02f, -2.54121851e-02f, -1.77052990e-02f, 3.04028727e-02f, 1.75859910e-02f, -1.93740427e-02f,
  -8.36295635e-02f, 3.81037313e-03f, 7.11085126e-02f, 3.99585105e-02f, -4.05011252e-02f, -2.01965738e-02f, 6.05908297e-02f, 7.84362182e-02f, -1.53336264e-02f, 4.49072346e-02f,
  -2.24974565e-02f, -4.82829772e-02f, 2.77521014e-02f, 4.65450026e-02f, 4.86947447e-02f, 3.81477699e-02f, 2.15953998e-02f, -4.93510589e-02f, -1.65768750e-02f, 2.11260468e-02f,
  -8.33442733e-02f, -7.94756636e-02f, 3.28719765e-02f, 1.97533816e-02f, -8.85360241e-02f, -7.11623579e-02f, -7.13814124e-02f, 3.25788818e-02f, -7.40031675e-02f, 7.64728338e-02f,
  -3.38391438e-02f, 3.07642408e-02f, 2.59549376e-02f, -1.01728179e-01f, 5.44663984e-03f, -4.12755832e-03f, 4.48428169e-02f, 3.69148701e-02f, -5.60407788e-02f, -6.62065223e-02f,
  -1.58719286e-01f, -5.27418852e-02f, 1.11760788e-01f, -1.04512490e-01f, 8.58393982e-02f, 7.64629915e-02f, 6.55266270e-02f, -1.13464087e-01f, -1.08275600e-01f, -8.01900253e-02f,
  6.62846491e-02f, -1.50986686e-01f, 1.57185242e-01f, 4.54569533e-02f, 2.41114814e-02f, 2.02592507e-01f, 1.23994172e-01f, 1.18585385e-01f, 3.69427004e-03f, -8.91449973e-02f,
  6.32257462e-02f, -1.42607195e-02f, 1.16269529e-01f, 8.02688599e-02f, 5.17844558e-02f, -1.49542550e-02f, -5.15445806e-02f, 1.57633230e-01f, -3.93137671e-02f, -3.54689639e-03f,
  3.23925959e-03f, -1.82724833e-01f, -7.82817304e-02f, -1.21907726e-01f, -8.99837241e-02f, 2.59710476e-03f, -1.25463065e-02f, -3.07775699e-02f, 6.74054176e-02f, 4.53195274e-02f,
  5.25087453e-02f, -5.63569777e-02f, 2.41018943e-02f, -6.66582137e-02f, -2.26810239e-02f, -8.16310570e-02f, -6.22196682e-02f, -1.71124004e-02f, 6.81234524e-04f, -1.70928258e-02f,
  9.16764513e-02f, -3.36021446e-02f, 4.85501923e-02f, -4.47531193e-02f, -5.75504936e-02f, 2.74294103e-03f, 8.26802328e-02f, -3.67507264e-02f, 1.41782104e-03f, -6.75783083e-02f,
  -6.17443621e-02f, -1.27405673e-02f, 6.52714744e-02f, 9.92546696e-03f, 3.01653221e-02f, 2.72869039e-02f, -8.01963508e-02f, -3.19044963e-02f, 5.26182204e-02f, -2.63044536e-02f,
  -1.64187606e-02f, 2.36294437e-02f, -7.03149065e-02f, 1.21518709e-02f, 7.97925293e-02f, -2.42649913e-02f, 9.57610980e-02f, -6.10605872e-04f, 2.01483686e-02f, 7.29501396e-02f,
  -7.18782330e-03f, 5.58834895e-02f, 1.66546889e-02f, -1.08890757e-02f, -9.61488336e-02f, -6.49250150e-02f, -7.80573264e-02f, 4.00702283e-02f, 4.45139967e-03f, -3.66756767e-02f,
  -9.92875844e-02f, -1.69003576e-01f, 4.08571400e-02f, -9.55525190e-02f, -5.83774224e-02f, -4.61689159e-02f, -3.95314023e-03f, 7.65115116e-03f, -5.04425876e-02f, -1.12389512e-01f,
  -5.69772758e-02f, -6.40019774e-02f, -1.71940513e-02f, 2.41405312e-02f, 3.54636684e-02f, -6.20042756e-02f, 4.03191112e-02f, -8.70552007e-03f, -4.90796082e-02f, -1.00418441e-01f,
  -5.67435659e-02f, 1.00075556e-02f, 6.54421747e-02f, 4.85696122e-02f, 1.74281895e-02f, 1.65595394e-03f, -9.13986936e-03f, -8.20218697e-02f, -8.56951028e-02f, 8.19181949e-02f,
  -5.26274182e-02f, -3.31078246e-02f, -1.22769408e-01f, -5.91285713e-02f, 1.37212992e-01f, 4.32370640e-02f, 5.84026799e-03f, 6.14244817e-03f, -1.32349938e-01f, 1.26528621e-01f,
  8.43899325e-02f, -1.85177967e-01f, 7.70371035e-02f, -8.35615247e-02f, -1.49961546e-01f, -1.24156661e-01f, -4.39354517e-02f, -1.16030656e-01f, -1.41505435e-01f, -6.00730218e-02f,
  -1.37707517e-01f, -3.94595489e-02f, -1.10629432e-01f, 9.73819047e-02f, 3.75804901e-02f, -1.36291469e-02f, -2.27892566e-02f, 2.60293316e-02f, -2.28009764e-02f, 4.93418910e-02f,
  -4.05764244e-02f, 2.10772455e-02f, -6.60002232e-02f, -4.83136177e-02f, 4.27751467e-02f, 9.23742652e-02f, -1.25100156e-02f, -5.33663258e-02f, 4.95272838e-02f, 6.97288960e-02f,
  -2.95736622e-02f, 3.81161389e-03f, -4.31843549e-02f, 2.98183318e-02f, 1.50502119e-02f, 3.08611896e-02f, 5.15190549e-02f, 5.60878180e-02f, -6.77180663e-02f, 7.32433423e-02f,
  -9.06488597e-02f, -1.63764041e-02f, -6.82254962e-04f, 4.18690704e-02f, 1.90247744e-02f, 3.57460119e-02f, -6.75956756e-02f, -4.23307791e-02f, -7.08693191e-02f, 2.70196851e-02f,
  3.01500261e-02f, -8.29756353e-03f, -3.66219431e-02f, 4.24195863e-02f, 2.15691850e-02f, 2.43495647e-02f, -4.46100682e-02f, -3.14986371e-02f, 1.95393432e-02f, 1.05912678e-01f,
  -2.72139534e-02f, 5.87736368e-02f, -3.35588604e-02f, 5.11924475e-02f, -5.78937791e-02f, 3.96669246e-02f, 7.05815032e-02f, 5.44198863e-02f, -6.03188947e-02f, -2.58015450e-02f,
  -2.55359039e-02f, 7.41108805e-02f, -3.65255959e-02f, -5.73652200e-02f, -3.12911868e-02f, -2.77662668e-02f, 9.15260706e-03f, -8.14008415e-02f, -5.40767908e-02f, -2.54406054e-02f,
  1.25365272e-01f, 1.38276190e-01f, -6.43596500e-02f, 3.36895324e-02f, 6.96755722e-02f, 1.07921802e-01f, -8.37639049e-02f, -2.75120977e-02f, 5.75007834e-02f, 5.31798303e-02f,
  1.00084513e-01f, 6.17186539e-02f, 5.27731255e-02f, -1.30629130e-02f, -1.32385651e-02f, 1.60635880e-03f, 4.53474745e-02f, -6.19604364e-02f, 9.63150337e-02f, 1.49532622e-02f,
  9.73764658e-02f, -2.05605626e-02f, 2.93724816e-02f, -2.32606716e-02f, -8.24012160e-02f, -1.01266736e-02f, 3.00452244e-02f, -2.00196225e-02f, -6.05694428e-02f, 7.23027810e-02f,
  1.16466984e-01f, -2.04016820e-01f, 6.52283356e-02f, 1.45489693e-01f, 1.53748810e-01f, 7.28806332e-02f, -2.89470330e-02f, 1.00409977e-01f, 1.80083364e-01f, -7.66765028e-02f,
  -5.19346297e-02f, -1.48557812e-01f, 4.46952786e-03f, -3.35965790e-02f, 1.39960378e-01f, 4.48074937e-02f, -3.05596702e-02f, -6.04026802e-02f, 7.75974244e-02f, 1.35020837e-01f,
  1.67972922e-01f, 6.33718222e-02f, -6.86906874e-02f, 1.45617705e-02f, -5.58971763e-02f, 3.41674499e-02f, -5.16622402e-02f, 2.83761676e-02f, -1.14126056e-01f, -4.87285368e-02f,
  -1.75950211e-02f, 1.33311316e-01f, -2.35787164e-02f, -2.81508248e-02f, -4.52769175e-02f, -6.93896189e-02f, -3.83326374e-02f, 2.65778266e-02f, -3.04448940e-02f, 3.78300296e-03f,
  1.21325711e-02f, -5.11407256e-02f, -9.09893960e-02f, -5.00362851e-02f, -5.63191399e-02f, -4.30785120e-02f, -7.84598663e-02f, -3.61934602e-02f, -3.22462693e-02f, 5.61934002e-02f,
  3.88892777e-02f, -5.61153516e-02f, 5.51854894e-02f, 9.88914352e-03f, 6.74771816e-02f, 5.89179881e-02f, -5.84756061e-02f, 5.85759841e-02f, -2.78258114e-03f, 1.03259251e-01f,
  -6.24926873e-02f, -3.54677252e-02f, -3.47889103e-02f, 8.43885317e-02f, 7.43014514e-02f, 5.52739576e-02f, -3.93141955e-02f, -7.97546431e-02f, -6.28195554e-02f, 4.14106809e-03f,
  -2.31855903e-02f, -6.94865957e-02f, -7.82931894e-02f, 6.56738728e-02f, 5.35172746e-02f, -5.94740994e-02f, 3.31850834e-02f, -1.95389520e-02f, -4.58465368e-02f, 3.95997688e-02f,
  -3.17584649e-02f, 7.78860524e-02f, 6.37657866e-02f, -6.94104144e-03f, -2.75952071e-02f, 5.91982827e-02f, -7.82446936e-02f, 3.83505300e-02f, -5.97645855e-03f, 8.84955674e-02f,
  -4.91856076e-02f, 4.98972740e-03f, -2.92772260e-02f, -5.20179123e-02f, -7.45008327e-03f, 3.97131853e-02f, -5.30054346e-02f, -6.54895082e-02f, -4.39090729e-02f, 4.00374737e-03f,
  4.32799198e-02f, 1.02817088e-01f, 2.85374634e-02f, 6.46608993e-02f, 2.12787557e-02f, 4.60099317e-02f, 5.14724553e-02f, -1.26118185e-02f, -4.84482795e-02f, 6.48830533e-02f,
  8.45568925e-02f, 1.92188937e-02f, -3.70815247e-02f, -6.20710775e-02f, 1.58206224e-02f, -4.05203886e-02f, 3.72624435e-02f, 7.29815736e-02f, -3.86856943e-02f, -4.49984558e-02f,
  5.40879462e-03f, -1.23097844e-01f, -9.60536003e-02f, -6.06739596e-02f, -2.37335544e-02f, 1.13866534e-02f, 5.10170758e-02f, -6.84592873e-02f, -6.72358274e-02f, -5.72604910e-02f,
  6.55545443e-02f, -1.32523596e-01f, -3.18728085e-03f, 1.75443918e-01f, 7.50907585e-02f, 5.16107790e-02f, 3.44508477e-02f, 4.38534468e-02f, -1.99710820e-02f, 7.40758032e-02f,
  3.53724882e-02f, 3.93464714e-02f, 6.64255396e-02f, 5.50710261e-02f, 7.59840291e-03f, -2.63124835e-02f, 2.73277368e-02f, -2.14245804e-02f, 6.60469681e-02f, -4.67441827e-02f,
  1.77177880e-02f, 6.23852536e-02f, -1.89855602e-02f, 7.23042041e-02f, -6.91119507e-02f, 9.91115049e-02f, -9.14222151e-02f, 7.48665631e-02f, 8.09880067e-03f, 4.27531041e-02f,
  -1.01320580e-01f, 6.95011094e-02f, 6.43732175e-02f, -1.38720870e-02f, 1.44216872e-03f, -8.68530497e-02f, -3.90378907e-02f, -8.05345029e-02f, -7.19591901e-02f, -8.48643854e-02f,
  9.39370785e-03f, 3.04164458e-02f, 4.93582711e-02f, -6.47734627e-02f, 4.46124412e-02f, 7.84736648e-02f, -8.08287635e-02f, 5.09278961e-02f, 5.25805540e-02f, 3.42147835e-02f,
  5.81340343e-02f, 2.13796762e-03f, 6.65556043e-02f, 2.59420788e-03f, 4.69263084e-02f, 1.36617282e-02f, 4.82592098e-02f, -5.82015589e-02f, -1.00653572e-02f, -1.49202291e-02f,
  -2.49691643e-02f, 6.37578368e-02f, -1.46284681e-02f, 2.96949726e-02f, 3.68133411e-02f, 7.58118415e-03f, -3.31039503e-02f, -3.86105739e-02f, 7.74955228e-02f, 6.42723441e-02f,
  -6.48027137e-02f, -1.40378708e-02f, 1.14515964e-02f, 4.42902073e-02f, 3.25740613e-02f, 3.96911949e-02f, -1.03335185e-02f, 8.01228061e-02f, -2.14671101e-02f, 1.54846674e-02f,
  -6.30258992e-02f, -1.30260289e-01f, 1.88868530e-02f, -7.09786862e-02f, 9.06179100e-02f, 1.04373157e-01f, 1.42330751e-02f, 9.50767547e-02f, 1.57369580e-02f, 5.92819089e-03f,
  -2.59323288e-02f, -5.72362617e-02f, 8.11318234e-02f, 6.82775155e-02f, 5.54875657e-02f, 4.07686792e-02f, 6.36072084e-02f, -6.15942292e-02f, 7.41039366e-02f, 2.59666871e-02f,
  -5.16223945e-02f, 6.03187531e-02f, -1.57848708e-02f, 4.91221249e-02f, -4.43936251e-02f, 3.73261906e-02f, 4.80866153e-03f, -1.06893502e-01f, 7.08693713e-02f, 6.02156762e-03f,
  1.81916296e-01f, 1.46060228e-01f, 2.24126264e-01f, 1.23539567e-01f, -1.11696355e-01f, -8.02027285e-02f, 6.81764539e-03f, -1.46794528e-01f, -3.80817130e-02f, 1.30555794e-01f,
  -8.34957063e-02f, 1.88474759e-01f, -5.22700846e-02f, -4.71784621e-02f, -2.08363473e-01f, -2.51728356e-01f, -1.02431928e-04f, 7.32987598e-02f, 2.45995838e-02f, -3.61760966e-02f,
  -1.11161821e-01f, -1.43607840e-01f, -8.25984553e-02f, 8.43719579e-03f, 1.58940926e-01f, 1.50302902e-01f, -1.25904605e-01f, 2.17054710e-02f, 4.50192764e-02f, -7.67154917e-02f,
  -4.14015166e-02f, -7.88804665e-02f, 1.54219255e-01f, 2.16211565e-02f, -5.29732145e-02f, 3.03588994e-02f, 1.54829904e-01f, 2.90684216e-02f, 1.69618893e-02f, -3.36260907e-02f,
  7.52117038e-02f, 5.63168935e-02f, -6.71172813e-02f, -9.25938562e-02f, 6.48139045e-02f, 2.34040916e-02f, 3.38636599e-02f, 1.04013190e-01f, -4.06737328e-02f, -1.15172099e-02f,
  8.89816806e-02f, 1.16804197e-01f, 1.11644462e-01f, -2.94623282e-02f, -2.41471864e-02f, 4.06286828e-02f, 8.92111659e-02f, 8.26499760e-02f, 1.08745052e-02f, 8.52882266e-02f,
  -5.91724478e-02f, 4.64631207e-02f, -7.28579685e-02f, -2.12892555e-02f, -6.82547912e-02f, -6.90249354e-02f, -4.29254919e-02f, -1.01520807e-01f, 3.39937583e-02f, -1.94526203e-02f,
  6.40689582e-02f, -2.19668355e-02f, 1.11582326e-02f, -5.44128828e-02f, -2.54945159e-02f, -5.88400699e-02f, 1.09651141e-01f, -2.23713890e-02f, 5.45596443e-02f, 7.84392133e-02f,
  -5.38697690e-02f, 5.30408416e-03f, -4.02175114e-02f, -1.08616995e-02f, -8.24220926e-02f, -5.22132479e-02f, 2.15459000e-02f, 4.08865698e-02f, -6.56797141e-02f, 2.06713900e-02f,
  -2.60057393e-02f, -1.07191920e-01f, 7.57136717e-02f, 2.57534236e-02f, 2.60568615e-02f, 5.24328798e-02f, -9.64241475e-02f, 9.14847851e-02f, -1.89978983e-02f, -4.50174846e-02f,
  9.75730121e-02f, -1.65401269e-02f, 9.44433138e-02f, 8.81429389e-02f, -5.59117384e-02f, -3.39209698e-02f, 3.77540924e-02f, -4.01826575e-02f, 8.34640488e-03f, -5.48655130e-02f,
  7.38260970e-02f, 9.01279449e-02f, -6.71616718e-02f, 7.52630010e-02f, 8.58270563e-03f, -2.15537380e-02f, -3.46506238e-02f, 1.19933784e-01f, 1.02519937e-01f, 7.63339698e-02f,
  -4.47172746e-02f, -2.55405176e-02f, 3.24448459e-02f, 1.44649763e-03f, 9.88284871e-03f, -4.22115400e-02f, 1.36483133e-01f, 3.53871100e-02f, -3.04254815e-02f, -8.13175291e-02f,
  5.46880178e-02f, -4.56232727e-02f, -6.99475035e-02f, -5.89809157e-02f, 1.12860940e-01f, -1.08512610e-01f, 4.31689247e-02f, -5.11946082e-02f, 1.10827245e-01f, -9.20341462e-02f,
  -2.00842079e-02f, -3.50097083e-02f, -4.93129306e-02f, -9.13714990e-02f, 7.53852576e-02f, 7.24773929e-02f, -9.22440588e-02f, -1.67109706e-02f, 4.81731035e-02f, 1.06664099e-01f,
  7.08973184e-02f, 2.29997560e-02f, 8.62696320e-02f, -3.56774926e-02f, 4.51244265e-02f, 2.99862977e-02f, 7.43536502e-02f, -4.40775119e-02f, -2.37117312e-03f, -7.61393411e-03f,
  -9.66053158e-02f, 7.72404745e-02f, 1.51192378e-02f, 1.81789901e-02f, -6.01691045e-02f, 3.03168334e-02f, 2.61413306e-02f, -6.95973858e-02f, 5.44489659e-02f, -4.68043536e-02f,
  1.17306854e-03f, 4.76371348e-02f, -8.04616734e-02f, -1.89624801e-02f, 5.69324493e-02f, 5.65494448e-02f, 7.02920556e-02f, 9.11573879e-03f, -5.88308647e-03f, -7.17187524e-02f,
  2.97377873e-02f, -8.08265507e-02f, 5.95597252e-02f, 8.80875066e-02f, -5.25889210e-02f, -4.11258973e-02f, 3.18555608e-02f, -6.41627386e-02f, -2.10177973e-02f, -4.23267595e-02f,
  -3.60946693e-02f, -3.01907567e-04f, 2.34616175e-02f, -1.25158066e-02f, 7.45714828e-02f, -4.26835157e-02f, -3.70995589e-02f, 1.13552501e-02f, 9.61335823e-02f, -8.07322413e-02f,
  2.57433020e-02f, -2.60625612e-02f, 4.02023420e-02f, -6.18464164e-02f, -1.21840062e-02f, -8.75881985e-02f, -9.25815180e-02f, -1.84991155e-02f, -3.35845798e-02f, -3.48889269e-02f,
  3.84283029e-02f, -1.52714513e-02f, 7.52425939e-02f, 3.52166109e-02f, -7.84284715e-03f, 8.19566175e-02f, -3.53055857e-02f, -5.23466840e-02f, 6.16435334e-02f, 6.77672178e-02f,
  -6.45071492e-02f, -6.85183629e-02f, -1.21818595e-02f, -1.90593433e-02f, 6.83884323e-02f, -7.31864274e-02f, -3.56428847e-02f, -2.10207626e-02f, -3.28793675e-02f, -2.97807660e-02f,
  -9.60290208e-02f, -9.82214883e-03f, 8.50841403e-02f, 1.95525102e-02f, -7.85114318e-02f, 1.53438933e-02f, 1.21642705e-02f, 6.20439127e-02f, 8.51946548e-02f, 3.75398318e-03f,
  -4.86541055e-02f, 7.31640607e-02f, -4.72118333e-02f, 5.59609570e-02f, 1.76848933e-01f, -1.64008420e-02f, 3.09369173e-02f, 1.70073226e-01f, 1.86041221e-01f, 7.51943737e-02f,
  9.36561152e-02f, -3.25696170e-02f, 5.97021393e-02f, -8.73036087e-02f, -8.51353705e-02f, -4.65450957e-02f, -1.06419496e-01f, -4.73310389e-02f, 1.54310107e-01f, -4.63512447e-03f,
  -7.01561943e-02f, 9.92150679e-02f, -7.52284452e-02f, -6.37927745e-03f, 2.49128584e-02f, 9.60720237e-03f, -1.38101369e-01f, 1.47679493e-01f, -1.50324777e-01f, 8.08188110e-04f,
  1.64996535e-02f, -1.55360624e-02f, 4.41501848e-03f, -8.52267370e-02f, 1.03265001e-02f, 8.85505602e-03f, 5.90021536e-02f, 3.09458096e-02f, 1.84427164e-02f, 5.95607162e-02f,
  5.96944131e-02f, 2.52235625e-02f, -4.81896996e-02f, 5.00256307e-02f, 1.00276403e-01f, -6.88982829e-02f, 2.23194044e-02f, 3.35704233e-03f, 5.61127514e-02f, 2.61755753e-02f,
  -1.10617779e-01f, -2.12607477e-02f, -1.18012056e-02f, 5.96215129e-02f, -6.30017519e-02f, -2.14852318e-02f, 1.92879408e-03f, -1.27188578e-01f, -7.41497353e-02f, 8.05640295e-02f,
  3.56200337e-02f, 8.93094465e-02f, -4.08772007e-02f, 6.86353520e-02f, 5.08348979e-02f, -8.68101045e-02f, -2.14919238e-03f, -5.62308133e-02f, -6.15487574e-03f, -4.54420112e-02f,
  -4.61427085e-02f, 2.51996145e-03f, 4.88786958e-02f, 3.26718353e-02f, -3.53784934e-02f, -4.47438210e-02f, -4.56541106e-02f, 1.82573944e-02f, 5.07583693e-02f, -4.84118089e-02f,
  -5.15941456e-02f, 7.79130831e-02f, -3.98260914e-02f, -2.25483999e-02f, -8.09657052e-02f, -7.05285668e-02f, -3.33077041e-03f, -3.35830450e-02f, 2.00494323e-02f, 6.25044981e-04f,
  -7.53654093e-02f, -4.17779647e-02f, -5.23045696e-02f, -1.08765736e-02f, -5.69046177e-02f, -1.60020031e-02f, 3.97134349e-02f, -2.37374343e-02f, 4.64518033e-02f, -2.52904021e-03f,
  -6.66311681e-02f, 6.23667203e-02f, -4.98248264e-02f, -3.47598083e-03f, 8.69420590e-04f, -1.16870152e-02f, -1.27584618e-02f, -6.57752678e-02f, -9.05296579e-02f, -7.96845034e-02f,
  -4.98406105e-02f, 2.06481218e-02f, -2.00142851e-03f, -1.76432598e-02f, -5.73062077e-02f, -4.82766517e-02f, 7.61098936e-02f, -3.36727910e-02f, -3.58062387e-02f, -5.90182617e-02f,
  -7.58573785e-02f, 7.97835886e-02f, -9.63513777e-02f, 3.82262841e-02f, -1.78521369e-02f, -5.53382896e-02f, 7.69881681e-02f, 2.32952144e-02f, -1.17239267e-01f, 2.05947518e-01f,
  1.23123052e-02f, -5.93397170e-02f, -3.20117511e-02f, 7.33911023e-02f, -7.25919679e-02f, 8.46655890e-02f, 2.90145464e-02f, 1.36490196e-01f, -2.90840492e-03f, 2.70161703e-02f,
  6.47601709e-02f, 6.65163621e-02f, 8.60920772e-02f, 6.89171851e-02f, 5.74015304e-02f, -1.14160962e-02f, 2.51520295e-02f, -9.23606940e-03f, 1.36263847e-01f, -7.97180608e-02f,
  -8.87424313e-03f, -1.69912893e-02f, -5.52838109e-02f, 1.73431367e-03f, 1.18543305e-01f, 7.47765675e-02f, 5.18390350e-02f, 1.06167141e-03f, 3.99447978e-02f, 8.11263472e-02f,
  3.54024060e-02f, 2.74470393e-02f, -5.71858883e-02f, -4.93893810e-02f, -1.79497420e-03f, -6.76604807e-02f, -1.97328199e-02f, 1.04163013e-01f, -4.90821041e-02f, -7.44895190e-02f,
  5.20937480e-02f, 1.15274578e-01f, 2.24547219e-02f, 7.00351149e-02f, 3.17562446e-02f, -6.71312138e-02f, 5.35512343e-02f, -6.53077289e-02f, 2.02196790e-03f, -4.35046405e-02f,
  -7.61826262e-02f, 9.30941254e-02f, 9.87362042e-02f, 6.40478358e-02f, 4.41201311e-03f, 3.23523656e-02f, 4.61525321e-02f, 3.61220799e-02f, -9.48311239e-02f, -5.80973923e-03f,
  -3.28910165e-02f, -5.83314896e-02f, -9.59123299e-02f, 6.82274774e-02f, 9.97704174e-03f, -3.99928279e-02f, 8.33902508e-02f, -3.57877724e-02f, 9.93760899e-02f, 6.22387864e-02f,
  -5.99244386e-02f, -4.07827906e-02f, -1.34611903e-02f, 3.25675262e-03f, -1.08119240e-02f, 5.68275303e-02f, -2.35023331e-02f, -5.86783588e-02f, 7.37521052e-02f, 7.43603781e-02f,
  9.51919630e-02f, 9.58838016e-02f, 3.45531292e-02f, -6.15725406e-02f, 1.67887677e-02f, 6.90283552e-02f, -8.44549835e-02f, 1.68371946e-02f, -4.67741042e-02f, -3.75144631e-02f,
  2.58252304e-03f, 7.62085915e-02f, 7.13825822e-02f, -4.24902746e-03f, -6.05139183e-03f, -2.93976441e-02f, 5.80865741e-02f, 8.53815079e-02f, -4.33266535e-02f, 8.06713924e-02f,
  3.25003490e-02f, 1.02266274e-01f, -6.04649493e-03f, 8.35997388e-02f, -2.33172104e-02f, 8.28311443e-02f, 4.96186353e-02f, 9.09981206e-02f, -3.64980660e-02f, 5.79388700e-02f,
  -6.33812472e-02f, 9.26911458e-02f, 1.17802203e-01f, 1.10194482e-01f, -2.40155514e-02f, 2.53195735e-03f, 9.61201116e-02f, 2.13792361e-02f, -1.36834942e-02f, -2.84006670e-02f,
  3.70023884e-02f, 5.32402880e-02f, -1.26066925e-02f, -1.62680522e-02f, -2.43327906e-03f, 6.97703436e-02f, 1.07172713e-01f, -5.32035455e-02f, 4.50113416e-02f, -5.02848104e-02f,
  -6.43597394e-02f, -8.33111703e-02f, 1.84346084e-02f, 3.87413129e-02f, 5.96887944e-03f, -2.83833742e-02f, -5.59548847e-02f, 4.76298258e-02f, -4.09483239e-02f, -3.52395996e-02f,
  -2.29987558e-02f, 8.11063424e-02f, 9.24715959e-03f, -3.09285522e-02f, 8.77941176e-02f, 2.34374925e-02f, -3.98835316e-02f, 3.46025899e-02f, -1.11345341e-02f, -7.42549300e-02f,
  4.30794507e-02f, 6.04490144e-03f, -2.92168371e-02f, 2.78463811e-02f, 8.87203291e-02f, 1.74506288e-02f, 8.30114856e-02f, 3.48133519e-02f, -4.92762886e-02f, 8.40419345e-03f,
  5.69386631e-02f, -8.10643360e-02f, 3.40207331e-02f, -6.69447258e-02f, -2.77819596e-02f, -1.94940146e-03f, 7.94340372e-02f, 3.28816958e-02f, 5.41575961e-02f, 7.90690407e-02f,
  4.41022404e-03f, -5.87196136e-03f, 5.07947356e-02f, -9.20024291e-02f, 7.71618932e-02f, -2.55855899e-02f, 1.89270999e-04f, 2.23542452e-02f, 3.32175270e-02f, -5.56353331e-02f,
  7.64313936e-02f, 3.21572386e-02f, 2.96477675e-02f, -4.66969498e-02f, 1.01296827e-02f, 4.21213619e-02f, 3.44727524e-02f, -3.64345103e-03f, -2.85985079e-02f, -7.79517964e-02f,
  -3.33514102e-02f, 2.05343100e-03f, 3.00125349e-02f, -6.72159269e-02f, 1.98507542e-03f, -7.97177553e-02f, -4.88095544e-02f, -1.06115034e-02f, 1.74147915e-02f, -3.37934792e-02f,
  4.06793095e-02f, 1.33727938e-01f, -4.04035114e-03f, 1.33365309e-02f, 6.85213506e-02f, -4.19181213e-02f, -1.07770320e-02f, 1.80994067e-02f, -3.01226284e-02f, -1.62878595e-02f,
  4.24273536e-02f, -1.75939631e-02f, 1.54489811e-04f, 5.97193651e-02f, -3.04163285e-02f, -2.95965225e-02f, 2.85686273e-02f, 1.01155519e-01f, -9.01784934e-03f, -3.79968211e-02f,
  -1.80078484e-02f, 4.79622781e-02f, 6.36590496e-02f, 1.61000043e-02f, 7.88947940e-02f, -4.40390036e-02f, 2.69849282e-02f, 5.96423522e-02f, -4.42010425e-02f, 7.37976506e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  2.57876161e-02f, 1.69693068e-01f, 1.64272830e-01f, 1.26425847e-01f, 5.58550507e-02f, 8.15378651e-02f, 4.39413898e-02f, 3.19742784e-02f, -4.54445332e-02f, 3.87397036e-02f,
  -3.47487442e-02f, 1.13365754e-01f, 1.17693342e-01f, -2.07160860e-02f, 1.66743144e-01f, 8.17366224e-03f, 1.55089691e-01f, 1.37240976e-01f, 4.18792218e-02f, 4.06512134e-02f,
  5.01670204e-02f, 1.05266728e-01f, 7.35217780e-02f, 1.35145456e-01f, 4.57309233e-03f, 3.16104740e-02f, -4.05182391e-02f, 6.12150021e-02f, -2.43661478e-02f, 9.99731123e-02f,
  1.01449706e-01f, -1.68228857e-02f, 1.23939432e-01f, -3.38727385e-02f, -4.33191378e-03f, 1.10553145e-01f, -8.89418647e-03f, 7.66824419e-03f, 4.45594788e-02f, 7.06334785e-02f,
  6.26629218e-02f, 1.14949215e-02f, 1.56606674e-01f, 3.99775915e-02f, 2.31230855e-02f, 1.12825133e-01f, -1.51230721e-02f, 1.61547982e-03f, -4.83937450e-02f, -3.99454543e-03f,
  7.39336684e-02f, -5.37239276e-02f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  4.83630039e-02f, 5.55333868e-02f, -4.29929756e-02f, -1.15368515e-02f, 1.89346299e-01f, -2.62816310e-01f, -1.38011472e-02f, 9.40385982e-02f, -5.75763546e-02f, -4.63347547e-02f,
  5.26018701e-02f, 7.07676122e-03f, -4.36476357e-02f, -5.46061695e-02f, 4.89809131e-03f, 1.49808705e-01f, -8.50375183e-03f, -4.22592998e-01f, 1.23511478e-01f, 1.29509881e-01f,
  -5.77745549e-02f, -3.87806773e-01f, -2.02333909e-02f, -9.94820818e-02f, 7.77797177e-02f, 7.53980130e-02f, 2.00746983e-01f, 1.59696519e-01f, 4.79718558e-02f, -1.72852486e-01f,
  -3.73596787e-01f, -1.50985792e-01f, -1.34803290e-02f, -6.33769780e-02f, -2.66499132e-01f, -1.53309450e-01f, 1.79387312e-02f, -1.14122771e-01f, 2.07679540e-01f, 1.31761834e-01f,
  -3.06387961e-01f, 1.38713449e-01f, 6.91759735e-02f, 2.04808027e-01f, 2.93667287e-01f, -1.10477604e-01f, -1.01857178e-01f, 5.40295504e-02f, -4.23203707e-02f, -1.78590506e-01f,
  1.21978104e-01f, -1.37837783e-01f, 2.93724954e-01f, -1.16426982e-01f, -1.73099369e-01f, -3.07828337e-01f, -1.37885347e-01f, -5.57216704e-02f, 4.63666096e-02f, -3.69262338e-01f,
  2.38372944e-02f, 2.41726875e-01f, 2.15013757e-01f, -1.08236767e-01f, -1.22812696e-01f, 1.29726008e-01f, 1.74512833e-01f, -2.94847637e-01f, -3.54851246e-01f, -2.92789042e-01f,
  -2.62263030e-01f, -9.90915298e-03f, -4.31942016e-01f, -3.21522117e-01f, 4.28477190e-02f, -3.54460061e-01f, -3.73734161e-02f, -1.02570429e-01f, -1.53748557e-01f, -2.07267851e-02f,
  7.92385116e-02f, -1.03041843e-01f, 3.36332798e-01f, -4.97563146e-02f, -9.58032459e-02f, -4.29518409e-02f, 3.38902250e-02f, -1.77143320e-01f, 7.13382801e-03f, -1.26799509e-01f,
  -1.81145594e-01f, 7.72665367e-02f, -2.06093252e-01f, -1.36845052e-01f, -2.58107454e-01f, 1.50241077e-01f, -6.12946488e-02f, -1.00568749e-01f, -4.46846634e-02f, -1.46029100e-01f,
  1.22817680e-01f, 2.20460027e-01f, 1.29053295e-02f, 3.02295476e-01f, 3.33322142e-03f, 1.10598505e-01f, -5.82288243e-02f, 8.57312754e-02f, -1.57435358e-01f, -3.34520191e-02f,
  -4.77668159e-02f, 1.14081413e-01f, -1.56737491e-01f, 6.97665811e-02f, 2.82116413e-01f, -1.43370777e-01f, 6.09342456e-01f, 1.03003070e-01f, -1.58664241e-01f, 2.52220541e-01f,
  -2.14467403e-02f, -1.66018128e-01f, 1.17556825e-01f, -8.54451805e-02f, -1.06220627e-02f, -8.75076354e-02f, 2.64719903e-01f, -5.60611896e-02f, 4.89267856e-02f, -6.14045709e-02f,
  -6.90789195e-03f, -3.55456397e-02f, -1.48038343e-01f, 2.24562772e-02f, 9.46349278e-02f, -3.61330360e-01f, 5.47164790e-02f, 4.84158844e-03f, 8.76673386e-02f, 2.27894738e-01f,
  -1.61947712e-01f, -7.74122626e-02f, -6.12513274e-02f, -1.27693221e-01f, 2.72673164e-02f, -3.94302383e-02f, -1.48139879e-01f, -1.81793235e-02f, 1.54714361e-01f, 6.81682006e-02f,
  1.48949385e-01f, 6.40506372e-02f, -2.06600890e-01f, -5.00401855e-01f, -7.12914467e-02f, 1.58854470e-01f, -7.05412626e-02f, 3.52145553e-01f, -4.75675426e-02f, 2.84212440e-01f,
  -8.59844983e-02f, 8.29534009e-02f, -3.80676478e-01f, -9.97066572e-02f, 7.35349879e-02f, 1.30548418e-01f, 1.55566067e-01f, -2.51163661e-01f, -2.22758964e-01f, -1.68900922e-01f,
  2.11681828e-01f, 8.77472237e-02f, -2.23848000e-01f, 4.59550977e-01f, 1.75418422e-01f, 2.39116341e-01f, -2.11139038e-01f, -5.74216396e-02f, 5.46254337e-01f, -2.24865124e-01f,
  1.61212265e-01f, -3.63411039e-01f, -6.51178062e-02f, -3.63561958e-01f, -3.83095592e-01f, 8.40793028e-02f, 1.59382626e-01f, -2.78743356e-01f, -7.96393678e-02f, -2.64651608e-03f,
  3.95383805e-01f, -2.99988061e-01f, 2.20644414e-01f, -4.07665968e-01f, -3.45318437e-01f, -1.49059057e-01f, -2.49271721e-01f, 3.89981903e-02f, -8.21698010e-02f, 8.30153227e-02f,
  -2.86305636e-01f, 2.71081209e-01f, -1.94133203e-02f, 1.74261972e-01f, -2.45878503e-01f, -2.11632296e-01f, -1.26138389e-01f, -1.35229528e-01f, -1.74194366e-01f, 3.66878770e-02f,
  -2.06395239e-02f, 2.56986797e-01f, -3.95525172e-02f, -5.69880381e-02f, -4.85970154e-02f, -1.40087530e-01f, 3.35640386e-02f, 9.42415297e-02f, -1.21330105e-01f, 3.49440664e-01f,
  -1.60345696e-02f, 5.01524061e-02f, -1.54584333e-01f, -9.32483450e-02f, 5.09116761e-02f, 4.03387807e-02f, -2.10789274e-02f, -1.89214870e-02f, -1.65318772e-01f, 4.08401668e-01f,
  -5.84382042e-02f, 1.93091054e-02f, -1.26522899e-01f, -1.33889407e-01f, 6.72819018e-02f, 2.15903208e-01f, -6.91081211e-02f, -2.89315134e-02f, 9.54786539e-02f, 3.00412793e-02f,
  5.95419994e-03f, -7.53904656e-02f, 1.53363109e-01f, 1.34889498e-01f, 1.25337526e-01f, -8.72687623e-02f, 2.99358927e-02f, -1.41503766e-01f, 4.71310839e-02f, -5.16214557e-02f,
  1.63207605e-01f, -7.56355822e-02f, -2.64094286e-02f, 5.32249268e-03f, -3.36514506e-03f, -7.88564160e-02f, 1.18375861e-03f, 7.76769295e-02f, -8.29555746e-03f, 6.33713156e-02f,
  -3.88359010e-01f, 3.39306258e-02f, -1.40481621e-01f, -5.18626953e-03f, -1.22039370e-01f, -5.04676104e-02f, 1.17734028e-03f, -2.25532874e-01f, 1.89778835e-01f, -1.10133539e-03f,
  -5.73735721e-02f, -3.49368043e-02f, -1.27869561e-01f, -9.63605344e-02f, 3.92276011e-02f, 6.94442317e-02f, -1.09589033e-01f, -4.44042832e-02f, 2.17589661e-02f, -1.09021120e-01f,
  -4.96876687e-02f, 3.13905552e-02f, 8.69689956e-02f, -1.38463035e-01f, -5.75775765e-02f, -2.97045976e-01f, -1.81989130e-02f, -2.71716624e-01f, -3.58230211e-02f, 3.32045443e-02f,
  5.55172861e-02f, -5.93975186e-03f, -1.99655503e-01f, -1.68110803e-01f, 1.78374827e-01f, 2.90682446e-02f, -9.30418000e-02f, 2.72062630e-03f, 2.00987101e-01f, -7.88618922e-02f,
  -2.59477884e-01f, 1.45996124e-01f, 1.23486407e-01f, 2.38931865e-01f, -6.47120774e-02f, 3.57531488e-01f, -1.69891492e-02f, -4.73094955e-02f, -3.00009459e-01f, -1.78077981e-01f,
  6.61137924e-02f, 4.64123368e-01f, 2.30557173e-01f, -9.28869843e-02f, -2.64283240e-01f, -2.02709422e-01f, 1.30512431e-01f, -3.72563422e-01f, 2.35197410e-01f, -1.24552831e-01f,
  5.28821014e-02f, -4.24374133e-01f, -3.25897723e-01f, 4.45075333e-01f, 9.86599773e-02f, 2.71751434e-01f, -2.68266767e-01f, 1.01410612e-01f, -3.38868499e-01f, 1.32266462e-01f,
  -2.93848336e-01f, 4.27838326e-01f, -1.73503041e-01f, -1.55690059e-01f, -2.09946603e-01f, 1.06314503e-01f, -2.03104034e-01f, 4.49108891e-02f, 8.36057588e-02f, 7.06411153e-02f,
  1.80018563e-02f, 1.37886731e-02f, -1.25394881e-01f, -1.94552951e-02f, 1.43010337e-02f, 9.25692543e-02f, -2.07644026e-03f, 3.22392248e-02f, 2.34078206e-02f, 1.10977717e-01f,
  -7.10945576e-02f, 2.25823410e-02f, -3.85981463e-02f, 2.15149239e-01f, -1.84414357e-01f, -1.96437463e-01f, 1.33808196e-01f, -6.55193180e-02f, -1.43581048e-01f, 6.88077360e-02f,
  -1.12134725e-01f, -1.54204458e-01f, -9.34848115e-02f, -1.43799990e-01f, 2.24115968e-01f, -1.34997824e-02f, 4.12551343e-01f, 3.09998721e-01f, 2.65662104e-01f, 1.10515036e-01f,
  1.36783436e-01f, 2.25942671e-01f, 1.10078484e-01f, 7.68563594e-04f, -1.85002223e-01f, 1.02531333e-02f, -8.07502344e-02f, -4.87212613e-02f, 1.47255734e-01f, -2.61732191e-02f,
  6.79135546e-02f, -8.66488367e-02f, -5.78782195e-03f, -1.35924429e-01f, -2.02850886e-02f, 5.58143109e-02f, 1.37362760e-02f, -8.49899650e-02f, -3.92742336e-01f, -1.14219394e-02f,
  -1.12453559e-02f, -1.24003589e-01f, 8.73745605e-02f, 3.14691886e-02f, -1.60768613e-01f, -2.53185660e-01f, 1.25625938e-01f, -1.90917373e-01f, -1.79888427e-01f, 8.67213123e-03f,
  9.19802859e-02f, -3.62163372e-02f, 4.78294715e-02f, -1.40349850e-01f, -1.59091562e-01f, -1.29139781e-01f, -3.43656272e-01f, 9.54471678e-02f, -1.60710782e-01f, -1.09792084e-01f,
  -1.32588923e-01f, 1.56316668e-01f, -3.67193781e-02f, 1.61693752e-01f, -5.60522862e-02f, 1.91619888e-01f, -1.32749781e-01f, 5.89627288e-02f, -1.46875978e-02f, -1.10355914e-01f,
  1.22786127e-01f, -9.39173251e-02f, -1.97287261e-01f, 2.16529340e-01f, 8.55271742e-02f, -2.76539981e-01f, -3.08409423e-01f, 3.26995671e-01f, 1.27698630e-02f, -2.95551419e-01f,
  -2.06361130e-01f, 2.73562968e-01f, 2.33511850e-01f, -3.01648438e-01f, 8.83613452e-02f, 4.54615623e-01f, 2.65299886e-01f, -1.72101200e-01f, -1.66279256e-01f, -3.64902914e-01f,
  2.71007746e-01f, -2.40923241e-01f, 2.02896476e-01f, -2.67324060e-01f, 2.38777608e-01f, 1.82373710e-02f, -2.89185494e-01f, 2.79540896e-01f, -2.33726636e-01f, -7.19147474e-02f,
  2.88032860e-01f, -1.62722886e-01f, 3.29604656e-01f, -1.68805376e-01f, 2.96130955e-01f, 2.89925244e-02f, 1.72557980e-01f, -2.62470514e-01f, -1.37210935e-01f, -1.20684460e-01f,
  6.66873083e-02f, 1.63064942e-01f, 2.64136314e-01f, -3.24393697e-02f, 5.58014035e-01f, -1.85470358e-01f, 3.10828000e-01f, -3.36963944e-02f, -3.96187417e-02f, 2.01759607e-01f,
  -1.18985148e-02f, -1.25109181e-01f, -1.56424344e-01f, -2.02428848e-02f, -2.01871514e-01f, -1.06190570e-01f, 1.26398839e-02f, -4.01197113e-02f, 2.23702654e-01f, -6.60959482e-02f,
  1.23662561e-01f, -3.10104825e-02f, 2.72126328e-02f, -3.41137797e-02f, -1.39940351e-01f, -9.49120447e-02f, 1.14200719e-01f, -4.50282134e-02f, -9.84095037e-02f, 9.09562707e-02f,
  8.76944959e-02f, -9.16582644e-02f, -2.09565135e-03f, 2.34534606e-01f, -1.69657208e-02f, -1.37855932e-01f, 1.83066633e-02f, -1.73188448e-01f, -2.23315787e-02f, -1.23970725e-01f,
  -3.80076282e-02f, -1.05721042e-01f, 1.31578133e-01f, 8.22031349e-02f, 1.29948229e-01f, -8.84822384e-02f, -8.62679034e-02f, -1.15485527e-01f, -3.66864377e-03f, 3.00886005e-01f,
  -1.67085126e-01f, -4.66609113e-02f, 2.65813824e-02f, -2.49459315e-03f, -1.44293934e-01f, -1.43738119e-02f, -7.90958032e-02f, -5.59931993e-02f, -9.90795344e-02f, -9.05418098e-02f,
  -9.24789533e-02f, 1.15806423e-02f, -5.70713058e-02f, 2.40166202e-01f, 1.79410711e-01f, 4.19672653e-02f, 2.30325326e-01f, 7.13265017e-02f, 6.26042113e-02f, 2.93414801e-01f,
  1.74794927e-01f, 1.49458379e-01f, -1.21347219e-01f, 4.62204106e-02f, 1.76455099e-02f, 8.61738473e-02f, 2.80155409e-02f, 3.34790945e-02f, 3.28815252e-01f, -2.14243352e-01f,
  -9.70213115e-02f, 6.47694170e-02f, 2.87625194e-01f, 1.23676181e-01f, 3.82398874e-01f, 1.29999608e-01f, 2.35596299e-01f, -5.56291565e-02f, 1.89585045e-01f, -1.17797650e-01f,
  -6.27404526e-02f, -1.07089952e-01f, 3.19277883e-01f, 1.69140086e-01f, -5.37501335e-01f, 4.27702159e-01f, 3.41981947e-01f, -4.73178416e-01f, -3.33098471e-01f, 1.51983604e-01f,
  -7.14336336e-02f, 5.48109878e-03f, 3.11220348e-01f, -4.78388906e-01f, -2.65820652e-01f, 3.20959598e-01f, 1.34802625e-01f, -2.14296773e-01f, 1.24699898e-01f, -3.01838726e-01f,
  -1.67326797e-02f, -1.49624152e-02f, 3.49716276e-01f, -7.43689984e-02f, 6.26279861e-02f, 2.54276186e-01f, -3.46071832e-02f, 5.83322942e-01f, 4.47385013e-02f, -1.35039002e-01f,
  -3.63175422e-02f, -7.93187693e-02f, 4.14390229e-02f, -1.91470414e-01f, 4.23336700e-02f, -1.80486172e-01f, -1.91650540e-01f, 1.48694709e-01f, 6.35828003e-02f, 1.23821288e-01f,
  -2.04458982e-01f, 2.85672218e-01f, 1.21707544e-01f, 8.37154984e-02f, 2.12555945e-01f, -1.13948524e-01f, 2.73431987e-01f, -4.52523008e-02f, 1.34947807e-01f, -6.38605515e-03f,
  1.74111634e-01f, -2.92971618e-02f, 2.06807345e-01f, -4.48722579e-02f, -2.16678277e-01f, -2.10142732e-01f, 1.46896198e-01f, -2.00086355e-01f, -7.94620961e-02f, 6.10854700e-02f,
  -4.31004772e-03f, -3.68441828e-02f, -1.22014701e-01f, -7.13944361e-02f, -1.58161223e-01f, -8.34716484e-02f, -6.22479804e-02f, 3.32916409e-01f, -1.25162795e-01f, -6.32490069e-02f,
  5.34960628e-02f, -5.58972135e-02f, -6.09030537e-02f, 1.60147145e-01f, 3.46763358e-02f, -2.11530983e-01f, -1.11459851e-01f, -2.20510259e-01f, 2.23240212e-01f, 1.63042754e-01f,
  1.16435409e-01f, 2.68042892e-01f, 8.47892761e-02f, -4.49722894e-02f, 8.32999405e-03f, -1.27149880e-01f, 7.47687966e-02f, 1.22185713e-02f, -3.37799676e-02f, 3.14854132e-03f,
  4.44519222e-02f, 1.51772369e-02f, 3.09994370e-02f, 1.02076732e-01f, 2.64172584e-01f, 1.97468340e-01f, 1.20007910e-01f, 1.93224892e-01f, 1.09660570e-04f, 6.66803643e-02f,
  -5.34691801e-03f, 8.93304199e-02f, 2.31080040e-01f, -7.80439451e-02f, 1.09452605e-01f, -1.28076179e-02f, -2.85286382e-02f, 1.00027584e-01f, -3.01883101e-01f, 9.89524201e-02f,
  9.66002196e-02f, 2.46898785e-01f, 1.06677383e-01f, -1.89002812e-01f, 2.83014029e-01f, -2.84029841e-02f, -2.40798265e-01f, 4.42295149e-02f, 1.05248235e-01f, -1.55476674e-01f,
  1.91643775e-01f, -1.25036100e-02f, 8.06978568e-02f, 8.51743743e-02f, 3.63689154e-01f, 7.71637335e-02f, -1.90517935e-03f, 6.76776767e-02f, 5.77039346e-02f, -1.88656941e-01f,
  1.42914608e-01f, 8.86993110e-02f, -9.51365903e-02f, 1.38554022e-01f, 3.51246297e-02f, 1.42665282e-01f, -9.91469808e-03f, -2.37194821e-01f, 1.57891735e-01f, 8.75839517e-02f,
  -2.16930062e-01f, -2.99572498e-01f, 3.97877209e-03f, 4.14557874e-01f, 6.17618673e-02f, -3.60206902e-01f, -4.96933818e-01f, 4.00919467e-01f, 2.80367643e-01f, -1.32933706e-01f,
  -2.70409793e-01f, 3.46423149e-01f, -4.03104350e-02f, -5.77082813e-01f, 5.28843760e-01f, 2.88298577e-01f, 2.29758263e-01f, -1.78159282e-01f, -2.20391691e-01f, -4.05628622e-01f,
  -2.69758731e-01f, 7.29903281e-02f, -2.87014425e-01f, 2.67631948e-01f, 3.25367361e-01f, -1.88149214e-01f, -1.15056917e-01f, -9.52648297e-02f, -2.04262346e-01f, 3.11094876e-02f,
  -5.46934307e-02f, 1.36969060e-01f, -2.35799387e-01f, 7.05733150e-02f, -5.24987979e-03f, 1.12448961e-01f, -1.32739022e-02f, 2.88242131e-01f, 1.14617102e-01f, 2.89582964e-02f,
  -7.67381787e-02f, -6.91514537e-02f, 1.28476992e-01f, 1.72418244e-02f, -1.32243887e-01f, 8.94041583e-02f, -3.75210494e-02f, -1.78775266e-01f, -2.61323154e-02f, 1.77376568e-01f,
  6.43943250e-03f, -1.19126514e-01f, 8.21172297e-02f, -1.41076460e-01f, 3.36711928e-02f, -2.19359964e-01f, 1.16126902e-01f, 1.09866649e-01f, -1.67417735e-01f, -1.85583979e-02f,
  -1.09843746e-01f, -1.08670473e-01f, -7.50485882e-02f, 1.50788113e-01f, -5.04528694e-02f, -1.34724811e-01f, -9.17663053e-02f, -7.65554830e-02f, -1.45992547e-01f, -1.09548397e-01f,
  -8.48530829e-02f, -2.92621702e-02f, -1.17311798e-01f, -4.94969599e-02f, 8.46588239e-02f, 1.89393565e-01f, -3.40538062e-02f, 1.23918831e-01f, -1.06668398e-02f, -7.26408511e-02f,
  -8.81286263e-02f, -1.21027958e-02f, 9.80630443e-02f, -1.39226437e-01f, -4.58010063e-02f, 7.19073787e-02f, -2.46030428e-02f, -1.70142099e-01f, 1.02122217e-01f, -3.54221240e-02f,
  -2.75974482e-01f, 7.53373206e-02f, -1.08592801e-01f, 6.34617060e-02f, -7.47809261e-02f, -3.61677222e-02f, -7.21206814e-02f, 2.18135655e-01f, 1.65798455e-01f, 9.27978382e-02f,
  -2.02006131e-01f, 1.35529459e-01f, -9.96455252e-02f, 2.03544557e-01f, -1.09496772e-01f, 2.54857153e-01f, 2.02091202e-01f, 2.28229791e-01f, 2.45093629e-02f, -1.05443850e-01f,
  -3.79362628e-02f, 6.36939844e-03f, 1.53168842e-01f, -5.55040427e-02f, -1.25137428e-02f, -1.10638075e-01f, -2.59615541e-01f, -3.10345024e-01f, 2.88324088e-01f, -2.92265743e-01f,
  3.31579834e-01f, -3.84591371e-01f, -2.36208811e-01f, -2.72375271e-02f, -2.62248032e-02f, -4.81818050e-01f, 3.65177840e-01f, 1.79352283e-01f, -3.08224171e-01f, 1.53885975e-01f,
  -1.62333727e-01f, 1.16532817e-01f, -1.00317679e-01f, 2.82161176e-01f, -2.44353667e-01f, 5.24896681e-02f, 1.45063356e-01f, 1.36442572e-01f, -2.05090284e-01f, -1.59154952e-01f,
  3.66659045e-01f, -2.77511626e-02f, 5.02429307e-01f, 1.91820100e-01f, 7.84761459e-02f, 2.70104557e-01f, 1.93837643e-01f, 3.76974910e-01f, -1.84090674e-01f, 1.86694548e-01f,
  4.25563693e-01f, 1.03315510e-01f, -2.64768541e-01f, 3.94453377e-01f, -8.38248245e-03f, -9.89003256e-02f, -2.33076140e-01f, 6.77041784e-02f, -1.44106328e-01f, 1.99892879e-01f,
  -1.20108925e-01f, -1.72512189e-01f, -5.25514074e-02f, -1.75723970e-01f, -1.05325267e-01f, 2.26149425e-01f, 4.55419309e-02f, -2.49197911e-02f, 2.71880627e-01f, -4.10290137e-02f,
  -5.24803391e-03f, 4.74441200e-02f, 1.48246348e-01f, 1.26201823e-01f, -1.01835444e-03f, -1.36270329e-01f, 3.66041549e-02f, 8.43946114e-02f, 1.31243199e-01f, -9.96668264e-02f,
  -7.44813383e-02f, 7.86500946e-02f, 1.98992193e-01f, 5.16022146e-02f, -8.92503560e-02f, 2.49926187e-03f, 5.92827260e-01f, 4.75910567e-02f, -3.62060741e-02f, -1.51447311e-01f,
  -7.63507234e-03f, -5.00217713e-02f, -1.09238945e-01f, 1.32570684e-01f, -1.55437469e-01f, -1.21641845e-01f, -1.47003099e-01f, -3.70764136e-02f, -5.64157739e-02f, 3.26650053e-01f,
  3.42249051e-02f, -1.00637153e-01f, 1.16839275e-01f, 1.79861337e-01f, -6.52653277e-02f, -7.01004360e-03f, -1.49407014e-01f, -1.20055929e-01f, 5.32774590e-02f, -3.65708023e-02f,
  -9.89260003e-02f, 3.69223356e-02f, 7.89580718e-02f, -1.28283903e-01f, -5.34125417e-02f, 1.90334544e-02f, 1.06099648e-02f, -2.44302321e-02f, -1.25444531e-01f, -1.80304202e-03f,
  -1.28362384e-02f, -1.06995970e-01f, -1.59145266e-01f, 2.13141944e-02f, 5.00877537e-02f, 1.62109286e-02f, 9.94696841e-03f, 7.97857419e-02f, -4.11577635e-02f, -1.72429010e-02f,
  -4.21728306e-02f, -3.10641557e-01f, 3.91395651e-02f, -3.69937904e-02f, -4.92565781e-02f, -2.89277226e-01f, 5.95760830e-02f, -2.40609899e-01f, 1.75908674e-02f, -2.18718469e-01f,
  -1.99327260e-01f, 2.76132599e-02f, 2.14994475e-02f, 4.75175002e-05f, -3.23830685e-03f, -2.72870660e-01f, -1.94695279e-01f, -1.15303835e-02f, -1.41004756e-01f, -1.81208819e-01f,
  2.35645771e-02f, -7.16682449e-02f, -2.96629012e-01f, -2.76276339e-02f, 1.04599993e-03f, 2.31554985e-01f, -3.14389914e-01f, 3.01076561e-01f, 2.23304689e-01f, 2.07074538e-01f,
  -2.33484611e-01f, 1.42739981e-01f, -1.30521104e-01f, -1.90302774e-01f, -2.53547519e-01f, 1.49283603e-01f, 1.96477070e-01f, -2.04453077e-02f, -1.51316226e-01f, 2.99020797e-01f,
  -4.75555286e-02f, 9.11311582e-02f, -4.94562415e-03f, 1.24059275e-01f, 2.21427023e-01f, -3.03519219e-01f, 1.44966856e-01f, -2.14380458e-01f, 2.53089279e-01f, 2.17417423e-02f,
  -2.95861252e-02f, -1.05230600e-01f, 5.97838648e-02f, 3.98602247e-01f, 3.75622183e-01f, -2.73836055e-03f, -8.51870105e-02f, -1.28899693e-01f, -1.05672292e-01f, 1.38116479e-01f,
  -2.17990880e-03f, -1.83367550e-01f, 1.08222269e-01f, 3.79735306e-02f, 3.77581269e-01f, -9.74614471e-02f, -5.73530747e-03f, -6.85876906e-02f, 1.38998792e-01f, -1.36625126e-01f,
  -8.84996429e-02f, 3.49752694e-01f, 3.06494683e-01f, 1.62564784e-01f, 1.30875438e-01f, 3.30050662e-02f, 8.54752511e-02f, -1.47378922e-01f, -5.88598251e-02f, 2.18585595e-01f,
  3.24919424e-03f, 1.95037983e-02f, 3.81259480e-03f, 1.31351143e-01f, -1.65432617e-01f, -1.47995092e-02f, -5.29080965e-02f, -3.95888947e-02f, -1.10093452e-01f, 2.34132245e-01f,
  -1.63010247e-02f, -1.60925701e-01f, -9.13975164e-02f, 2.68007107e-02f, 3.76892000e-01f, -1.27330422e-01f, -4.48321812e-02f, 3.87789751e-03f, -5.70551977e-02f, -7.39853755e-02f,
  -8.85743946e-02f, -4.23829444e-02f, -6.40575886e-02f, -1.27716839e-01f, -2.59047568e-01f, -5.80858551e-02f, 5.65166585e-02f, -2.39898816e-01f, -6.27718344e-02f, 1.35427564e-01f,
  8.22522640e-02f, -4.38033417e-02f, -7.52844736e-02f, -3.77899297e-02f, -1.75824836e-01f, 4.80782986e-02f, 1.30515933e-01f, 7.34112859e-02f, 5.91686107e-02f, -1.30087569e-01f,
  -4.30492461e-02f, -3.98861652e-04f, -2.58950870e-02f, -7.08967522e-02f, -2.34206811e-01f, -1.78806204e-02f, -2.29525670e-01f, 6.49443045e-02f, 1.57174859e-02f, -4.92790490e-02f,
  -3.19554806e-02f, -2.03391118e-03f, -1.37521252e-01f, -3.86795491e-01f, 2.28737318e-03f, 7.46739432e-02f, -6.04310259e-02f, -7.68469870e-02f, -1.01140223e-01f, 1.13481522e-01f,
  7.35149980e-02f, -3.11080227e-03f, 3.18940729e-01f, 2.85280883e-01f, 9.77040082e-02f, 4.01989609e-01f, 1.60479322e-01f, -7.18344674e-02f, 2.05195084e-01f, 1.52914211e-01f,
  -1.85730290e-02f, 1.12621590e-01f, -2.02670678e-01f, -2.22257674e-01f, -1.73731923e-01f, 1.96806073e-01f, 2.95842260e-01f, -2.70064831e-01f, 8.61590058e-02f, 1.18913494e-01f,
  2.22493425e-01f, 2.52336800e-01f, -4.06475574e-01f, 1.86103761e-01f, -2.96415538e-01f, -4.61173318e-02f, -3.86607379e-01f, -1.71938449e-01f, 9.35548767e-02f, -1.54316247e-01f,
  -2.48624563e-01f, 3.27778131e-01f, -1.07316591e-01f, 4.58718538e-02f, 2.90074915e-01f, 6.28335699e-02f, -2.84002811e-01f, 1.05517581e-01f, -9.73472819e-02f, -2.31546233e-03f,
  4.56666678e-01f, -1.03988335e-01f, 2.74396002e-01f, 7.21548963e-03f, 3.81433778e-02f, -1.43033117e-01f, -7.76787251e-02f, 1.31817132e-01f, -1.31971613e-01f, 2.55023479e-01f,
  -9.72189568e-03f, -1.02931716e-01f, -1.39809445e-01f, -7.38212541e-02f, 9.82813258e-03f, 2.00543627e-01f, 6.66038468e-02f, 3.66508991e-01f, 4.54288581e-03f, -5.90151809e-02f,
  -1.60727426e-01f, -4.78312857e-02f, 8.76882151e-02f, 6.95689023e-02f, 9.41926688e-02f, 5.04490137e-02f, 5.10736275e-03f, -1.16362453e-01f, 1.74237266e-01f, -1.20470330e-01f,
  -1.07530057e-01f, -5.98083809e-03f, 2.24870327e-03f, 2.28107683e-02f, -1.63013160e-01f, 1.23992898e-01f, 3.42670381e-01f, 1.68650627e-01f, -8.53817388e-02f, 7.31631815e-02f,
  -1.29276022e-01f, 4.02265675e-02f, -1.78827457e-02f, -2.68180929e-02f, -1.30400538e-01f, 9.38907713e-02f, -1.35615738e-02f, -5.03726117e-02f, -3.59510072e-02f, -8.06530938e-02f,
  1.05337396e-01f, 6.68301508e-02f, 8.39326605e-02f, 1.19959384e-01f, 9.62041318e-02f, -2.81378347e-02f, 1.85652748e-01f, -3.63496579e-02f, -1.47200248e-03f, 3.17623504e-02f,
  1.16637386e-02f, 9.07606259e-02f, 4.73647341e-02f, -1.57757029e-01f, -2.90348269e-02f, -7.51489922e-02f, -2.89433330e-01f, 1.11070666e-02f, 1.43888313e-02f, -3.02900244e-02f,
  1.94564581e-01f, -1.40572220e-01f, 1.09019741e-01f, 2.32297629e-02f, 6.85628429e-02f, 9.44477320e-02f, 1.65575519e-02f, 1.18972018e-01f, 1.27253175e-01f, -4.02168185e-01f,
  3.84889357e-02f, 6.33758828e-02f, -1.53577983e-01f, 1.44650444e-01f, -3.45273688e-02f, -6.00948790e-03f, 1.50783926e-01f, 9.23280567e-02f, -7.12640658e-02f, 1.81031764e-01f,
  -5.12379333e-02f, 3.02864630e-02f, -1.13512754e-01f, 6.88261539e-02f, 2.37167075e-01f, -3.96520883e-01f, -6.80335760e-02f, -2.18290269e-01f, -3.59462015e-02f, 2.24922702e-01f,
  -3.64624828e-01f, 2.47930959e-01f, -4.31533068e-01f, -2.77989835e-01f, -2.83242166e-01f, 2.15913072e-01f, 1.36033028e-01f, 3.75632137e-01f, 1.13637321e-01f, -5.06905079e-01f,
  -2.98261315e-01f, 3.19017440e-01f, -1.92957103e-01f, -3.32703501e-01f, 1.42383114e-01f, 1.33904323e-01f, -4.00164485e-01f, 5.09796560e-01f, 2.68320907e-02f, -5.46589494e-01f,
  -3.93543512e-01f, 7.07702115e-02f, -3.88961703e-01f, 1.56678274e-01f, 2.19949484e-01f, -2.39528865e-02f, 3.32275540e-01f, 1.37880713e-01f, -1.96419537e-01f, -2.30586715e-02f,
  -1.51592925e-01f, -1.20259136e-01f, -1.37295455e-01f, 3.97819281e-01f, -1.28612146e-01f, -5.75180873e-02f, -1.40197501e-01f, -8.18205252e-02f, -4.12447974e-02f, 1.74804870e-02f,
  6.90487847e-02f, 1.08330466e-01f, 2.58270293e-01f, 2.63261124e-02f, -1.97883219e-01f, 5.25064953e-02f, -1.87093511e-01f, 1.44299315e-02f, 4.88917604e-02f, 8.03936087e-03f,
  -9.98516083e-02f, -1.59957647e-01f, 1.74746990e-01f, -2.01196626e-01f, 1.83000341e-02f, -2.40044985e-02f, -1.25831500e-01f, 4.54367436e-02f, -1.32460654e-01f, 7.89280608e-03f,
  -1.61329992e-02f, -6.04752153e-02f, -1.99210808e-01f, -1.28095463e-01f, -4.88708019e-02f, -2.32004151e-02f, -2.43221167e-02f, 2.44832724e-01f, -1.98485523e-01f, 4.71851416e-02f,
  6.13633730e-02f, 2.04843223e-01f, -8.83134380e-02f, 3.45807113e-02f, 4.11044359e-02f, 8.07114765e-02f, 7.37446025e-02f, -3.64173763e-02f, -1.38428405e-01f, 1.28035462e-02f,
  1.04349390e-01f, -1.11899242e-01f, 8.46231729e-02f, 2.97808205e-03f, 2.48203292e-01f, -5.92306629e-02f, 3.80066223e-02f, 1.18883513e-01f, 4.59273439e-03f, -3.77987474e-02f,
  4.23393436e-02f, -5.68055958e-02f, -2.28582010e-01f, -4.00289185e-02f, 2.08154861e-02f, 1.63424477e-01f, -8.29536468e-02f, 2.36468151e-01f, -3.04172076e-02f, -6.57994417e-04f,
  9.94027480e-02f, 9.05667990e-02f, -3.00309006e-02f, 6.04722090e-02f, 2.13599518e-01f, 2.18320072e-01f, -1.64372563e-01f, -1.30989194e-01f, 1.90421641e-01f, 1.06167816e-01f,
  -4.53821085e-02f, 2.79240292e-02f, -3.11073139e-02f, 6.48321360e-02f, 2.06207365e-01f, 1.08755328e-01f, 3.85474646e-03f, 2.16989651e-01f, -3.38524520e-01f, 2.21436590e-01f,
  -2.88270295e-01f, -1.30298883e-01f, 7.83202946e-02f, -3.86576146e-01f, -1.12940639e-01f, 2.47646987e-01f, 1.66689441e-01f, -1.06064230e-01f, -1.23805339e-02f, -2.57607222e-01f,
  6.14104807e-01f, 4.04380947e-01f, 2.90791094e-01f, 4.05571945e-02f, 2.49199718e-01f, -1.13423444e-01f, 3.02384973e-01f, 1.46504551e-01f, 6.38914555e-02f, 4.84818267e-03f,
  4.11772579e-01f, -2.94870436e-01f, 9.52072367e-02f, 1.00605637e-01f, -3.58543754e-01f, -3.48521918e-01f, 1.81415845e-02f, -1.54820550e-02f, 4.20871556e-01f, 2.71506160e-01f,
  2.46593639e-01f, -1.23805016e-01f, 2.59382520e-02f, 2.05497056e-01f, -1.09535463e-01f, -1.94128826e-01f, 5.03316559e-02f, -1.16719484e-01f, 1.26446247e-01f, -1.64893374e-01f,
  1.15757510e-02f, -1.74190477e-01f, -9.54915658e-02f, -6.71522990e-02f, 5.07793017e-02f, -1.35508582e-01f, 2.93738749e-02f, 4.95531298e-02f, -2.06184328e-01f, 6.29992634e-02f,
  -2.52581239e-01f, -3.82331312e-02f, -1.31794930e-01f, -2.05876734e-02f, 1.44100517e-01f, -1.84553653e-01f, 5.33463992e-02f, -2.34731212e-02f, -5.36161847e-02f, -1.17426075e-01f,
  -2.22500205e-01f, -1.25115216e-01f, 1.75830662e-01f, -1.59796014e-01f, -8.60595629e-02f, -9.07284319e-02f, 1.84693262e-02f, 3.79074104e-02f, -2.32494131e-01f, -1.30756453e-01f,
  1.33463711e-01f, -1.56017333e-01f, -1.14575855e-01f, -1.77504510e-01f, 1.00189395e-01f, -1.32814676e-01f, -1.76453918e-01f, 7.72450045e-02f, -1.07523002e-01f, -1.27492368e-01f,
  3.24002117e-01f, 1.36171756e-02f, -6.77795559e-02f, 1.47442758e-01f, -3.92243761e-04f, -3.73441204e-02f, 1.90998673e-01f, 2.83812336e-03f, 9.44166407e-02f, 6.17617369e-02f,
  -1.36204198e-01f, -2.47417148e-02f, 3.24332938e-02f, 3.23461532e-03f, 1.44702727e-02f, 9.09236893e-02f, 5.45043349e-02f, -9.78792533e-02f, 7.09341764e-02f, 7.86466748e-02f,
  2.45266575e-02f, 1.28688797e-01f, 1.15817875e-01f, 7.92297348e-02f, 2.22126748e-02f, 4.48815152e-02f, 5.88853545e-02f, -8.89585540e-02f, -3.80564667e-02f, -9.76599827e-02f,
  1.22264385e-01f, -8.10509548e-02f, -1.10190749e-01f, 9.23980251e-02f, -1.89843979e-02f, 1.26405150e-01f, 6.37425929e-02f, 1.63892195e-01f, 9.64830816e-02f, 1.09289780e-01f,
  -2.80100703e-02f, -2.33670808e-02f, -3.12797487e-01f, -3.13391797e-02f, 1.74872726e-02f, -2.21862737e-02f, -3.07644419e-02f, -1.69245169e-01f, 1.89180583e-01f, 1.72495037e-01f,
  -3.18848252e-01f, 2.25426599e-01f, 2.04020254e-02f, 2.35900618e-02f, -3.40700261e-02f, -2.97454685e-01f, 6.92573711e-02f, -1.80874899e-01f, -2.78827161e-01f, -3.50520276e-02f,
  -2.55489111e-01f, -2.86927760e-01f, 1.05132110e-01f, 1.75826594e-01f, 1.24175765e-01f, 3.41763049e-01f, 2.98226535e-01f, 2.97863543e-01f, -1.62496597e-01f, 3.49508196e-01f,
  -2.31545553e-01f, 1.78926304e-01f, -2.29780033e-01f, -2.23407537e-01f, 4.81351139e-03f, 2.82999575e-01f, 2.41880193e-01f, 1.28956169e-01f, 2.73376971e-01f, 1.37588680e-01f,
  5.04879415e-01f, -3.18762451e-01f, 3.01264942e-01f, -3.78430379e-03f, -1.77412614e-01f, -1.09693319e-01f, 8.58310051e-03f, 1.27115279e-01f, -6.85755834e-02f, -1.26194119e-01f,
  -2.04294890e-01f, -5.51944524e-02f, 1.30397290e-01f, 1.67994663e-01f, -8.55037645e-02f, 3.26774940e-02f, -1.41572058e-02f, -1.64235055e-01f, 3.29379663e-02f, -1.50619954e-01f,
  3.25297832e-01f, -3.77986697e-03f, 1.35566458e-01f, -7.21931979e-02f, -6.34284765e-02f, 8.13525990e-02f, 2.68721074e-01f, 2.45970741e-01f, 1.53319715e-02f, 1.65205315e-01f,
  3.81577536e-02f, -1.46663681e-01f, 1.50678515e-01f, 1.17051899e-01f, 1.70342162e-01f, -1.98515370e-01f, -8.07325244e-02f, 2.91040450e-01f, -6.86118007e-02f, -1.88046694e-01f,
  -8.63008723e-02f, 6.68037981e-02f, -1.19917654e-01f, 1.44342646e-01f, -2.41493508e-02f, 5.89838959e-02f, -7.62735382e-02f, -1.87712878e-01f, -2.03847036e-01f, -2.43754059e-01f,
  -1.12892650e-01f, 5.60602427e-01f, -7.30067864e-03f, -8.81758332e-02f, 2.06330214e-02f, 2.95565408e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -5.46701513e-02f, 1.26558850e-02f, 6.90376163e-02f, -7.76914805e-02f, 5.88789210e-02f, -1.94986761e-02f, -5.55805415e-02f, -8.64907876e-02f, -3.52588706e-02f, -5.60493059e-02f,
  1.10922568e-03f, 2.95357853e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    