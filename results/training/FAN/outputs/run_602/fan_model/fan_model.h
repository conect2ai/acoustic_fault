/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.86025226e-01f, -3.49956214e-01f, 2.79947910e-02f, -6.32884428e-02f, 3.45357478e-01f, 5.61056361e-02f, -2.39875033e-01f, -1.23808697e-01f, -1.79040600e-02f, 6.69424795e-03f,
  4.33494039e-02f, 2.60719389e-01f, 1.91700608e-01f, 2.58194089e-01f, -7.92654976e-02f, -7.92322084e-02f, 4.23938408e-03f, 1.04767559e-02f, 1.93092778e-01f, 7.21156597e-02f,
  2.20841721e-01f, -5.35074212e-02f, -1.96650147e-01f, 2.49161981e-02f, 1.22087494e-01f, 2.01246023e-01f, 2.11181566e-02f, -8.96174312e-02f, -2.14295182e-03f, 2.07820252e-01f,
  -1.95579196e-04f, -2.30269089e-01f, 2.70626962e-01f, 1.64129928e-01f, 6.35108352e-02f, -1.60581190e-02f, 2.51198933e-02f, 2.48015374e-02f, 1.95950028e-02f, 4.71676365e-02f,
  8.90561268e-02f, 5.04334234e-02f, -2.82920245e-03f, 1.04512364e-01f, -5.29113486e-02f, -4.49568443e-02f, -3.63823175e-02f, -6.59000203e-02f, -7.86426812e-02f, 8.53021257e-03f,
  1.45166487e-01f, -1.69030251e-03f, -7.99368024e-02f, -6.31799106e-04f, 4.21371907e-02f, 1.70436025e-01f, -2.30897218e-03f, 1.30491788e-02f, 1.87654346e-02f, -4.19597961e-02f,
  -6.24017976e-02f, 6.21781684e-02f, -3.25095579e-02f, -9.12302956e-02f, -7.26330280e-03f, 7.30786799e-03f, -1.87797453e-02f, 4.57113646e-02f, -1.47681693e-02f, 7.22821977e-04f,
  8.01670924e-02f, -6.35411888e-02f, -1.69986282e-02f, -1.16926037e-01f, 1.86001416e-02f, -2.69918144e-02f, -3.52681279e-02f, -3.24156247e-02f, 4.68242690e-02f, -3.68979499e-02f,
  -5.92229444e-05f, 3.03300992e-02f, -5.99903129e-02f, -2.39183549e-02f, -7.63141587e-02f, 1.70532074e-02f, 6.53105527e-02f, 5.75901605e-02f, 6.57629371e-02f, 5.84450690e-03f,
  -1.21627159e-01f, -2.00971700e-02f, 1.07059702e-02f, 5.62649146e-02f, 3.31756659e-02f, 8.11529160e-02f, 5.05573861e-02f, 2.86052264e-02f, 9.71746966e-02f, -5.75814508e-02f,
  6.77059442e-02f, -1.52873509e-02f, 4.41035666e-02f, 3.66942361e-02f, 4.75281663e-03f, 4.93066683e-02f, 2.57223416e-02f, 1.00813478e-01f, 1.65594555e-02f, 8.22370723e-02f,
  -7.22798146e-03f, -4.30511385e-02f, -5.87013504e-03f, 7.57782832e-02f, 8.29772875e-02f, 7.59212822e-02f, 7.31577575e-02f, 1.11937530e-01f, -5.04705869e-02f, -7.04831332e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.74268162e-01f, -3.03076319e-02f, 3.57422739e-01f, 1.57409713e-01f, 1.57124072e-01f, -2.64931142e-01f, -5.77209651e-01f, -5.20490587e-01f, -2.44537562e-01f, -3.21681798e-02f,
  -1.10686466e-01f, -8.23498666e-02f, 1.60695091e-01f, 2.44290829e-01f, -1.22642413e-01f, 2.13307649e-01f, 4.70440865e-01f, 3.54844838e-01f, -8.02537948e-02f, -3.30889076e-01f,
  1.18239895e-01f, -2.96628680e-02f, 4.33185808e-02f, 7.41987154e-02f, 1.49913147e-01f, 1.76196054e-01f, 2.88914174e-01f, 1.46777153e-01f, 2.47447729e-01f, 7.06804574e-01f,
  3.07282507e-01f, -1.13766789e-01f, 2.61779547e-01f, 7.54881874e-02f, 1.56597897e-01f, -1.76713988e-01f, 4.51231301e-02f, 4.08695489e-02f, 1.45991206e-01f, 2.97628958e-02f,
  1.27997115e-01f, -4.44460325e-02f, 3.21688615e-02f, -3.96201275e-02f, -7.39073083e-02f, -6.55363202e-02f, -3.94848734e-02f, 7.33385682e-02f, -3.71537283e-02f, 5.07280044e-02f,
  3.50296170e-01f, 4.78117615e-02f, -1.69223219e-01f, -1.67209446e-01f, -1.37248352e-01f, 7.55461156e-02f, -3.08682974e-02f, -7.95912668e-02f, -3.34833175e-01f, -1.45790353e-01f,
  8.73683691e-02f, 2.09032297e-02f, 2.85644699e-02f, 2.36348867e-01f, -9.40889493e-02f, 4.78283651e-02f, 7.32806027e-02f, 7.99450651e-02f, 9.69540179e-02f, 1.14529006e-01f,
  1.81955382e-01f, -3.81318145e-02f, 4.79834080e-02f, 8.86288583e-02f, 5.85970692e-02f, -1.74088757e-02f, 8.60971212e-02f, 1.14832930e-01f, 1.42052054e-01f, 7.31149539e-02f,
  -1.87187362e-02f, -1.00314040e-02f, 1.42776787e-01f, 1.11994639e-01f, 9.95906144e-02f, -2.48001963e-02f, -8.20152555e-03f, -3.96707393e-02f, -1.31084761e-02f, 7.54714757e-02f,
  -3.76730353e-01f, 3.00108761e-01f, 8.82046148e-02f, -2.02314928e-02f, 5.01702875e-02f, 9.31671634e-02f, 1.46021873e-01f, -1.04659982e-01f, 4.67948206e-02f, -7.25136623e-02f,
  -2.39607260e-01f, -1.10338233e-01f, -3.61021720e-02f, 3.02411765e-02f, -5.91659825e-03f, -9.95803699e-02f, 7.13977516e-02f, 3.37583162e-02f, -4.11509424e-02f, 4.95316349e-02f,
  2.45426387e-01f, -3.29900742e-01f, -4.63244021e-01f, -2.48557687e-01f, -1.99696615e-01f, -2.51510859e-01f, -1.72164127e-01f, -3.08928043e-01f, -3.85329962e-01f, -5.42197168e-01f,
  5.68063438e-01f, -4.65851247e-01f, -7.84324646e-01f, 4.20125842e-01f, -4.88209128e-01f, -3.30941886e-01f, -4.36971962e-01f, 2.33364016e-01f, 3.93118292e-01f, -2.76346922e-01f,
  -3.78213018e-01f, -1.06855467e-01f, -4.21099514e-02f, -1.92903697e-01f, -2.22867250e-01f, -4.14451629e-01f, -4.03320402e-01f, -2.70812929e-01f, -3.55034202e-01f, -3.07425708e-01f,
  -1.58241063e-01f, 9.66644380e-03f, -2.74922140e-02f, -9.43352059e-02f, -1.16716556e-01f, -2.77358830e-01f, -4.78926957e-01f, -3.40780914e-01f, -4.63697463e-01f, -6.45617068e-01f,
  -6.48093104e-01f, -2.14432091e-01f, 2.36267410e-02f, 1.15111947e-01f, -2.34920695e-01f, 1.77949622e-01f, -1.84954986e-01f, -2.17842862e-01f, -4.99881506e-02f, -8.24825615e-02f,
  -1.22472525e-01f, -1.37586311e-01f, 7.66870156e-02f, -1.50946304e-01f, -1.58559427e-01f, 4.76252800e-03f, 2.13807642e-01f, -9.79682207e-02f, 1.80996563e-02f, -2.74109840e-01f,
  -1.60669565e-01f, -4.69197243e-01f, -4.64724749e-01f, -2.20562756e-01f, -1.67984471e-01f, -1.47225425e-01f, -4.85761195e-01f, -4.63292867e-01f, -5.29990435e-01f, -1.73013762e-01f,
  -1.66518301e-01f, -3.24518830e-02f, -4.92343940e-02f, 1.16850704e-01f, 1.55388996e-01f, 9.84909683e-02f, -1.41816940e-02f, 9.21608806e-02f, -4.39625122e-02f, -2.21727416e-02f,
  1.02654397e-01f, 1.51748657e-02f, 3.45012136e-02f, 1.03543162e-01f, -1.45897165e-01f, -1.34284258e-01f, -4.44511212e-02f, -9.30945948e-02f, -4.36722599e-02f, -7.11869299e-02f,
  -2.04688191e-01f, -1.35149553e-01f, -1.57185923e-02f, -2.18240097e-02f, -3.58763963e-01f, -2.08936498e-01f, -6.98961541e-02f, -1.45688519e-01f, 1.66577667e-01f, -8.87760743e-02f,
  3.62824112e-01f, -1.08477995e-01f, 5.21900430e-02f, 9.96916518e-02f, 6.10047355e-02f, -9.63058025e-02f, -1.03339553e-01f, 6.47101132e-03f, 1.87023729e-01f, -8.62799957e-02f,
  -8.70853141e-02f, -7.13197663e-02f, 5.14456891e-02f, -4.83530164e-02f, 6.73472062e-02f, -3.73699591e-02f, 1.74644724e-01f, 2.84678116e-03f, 7.52434954e-02f, 7.23653063e-02f,
  1.98490128e-01f, 2.61807382e-01f, 3.24587494e-01f, 2.07686484e-01f, 3.84164937e-02f, 1.15342341e-01f, -1.22397989e-01f, -8.41130223e-03f, -2.58336626e-02f, 4.01118308e-01f,
  -6.17818415e-01f, -9.55467746e-02f, -5.67726135e-01f, -4.69567925e-01f, 1.84801310e-01f, 1.75798219e-02f, -3.75614792e-01f, -3.59095298e-02f, -1.13123596e-01f, -3.07409525e-01f,
  2.23649204e-01f, 2.48995841e-01f, -2.99015284e-01f, -1.49922505e-01f, -6.24879003e-01f, -6.34514213e-01f, -7.12503731e-01f, -6.04276657e-01f, -2.47499883e-01f, 3.69256645e-01f,
  2.60189921e-01f, -2.76233137e-01f, -3.95391226e-01f, -7.22768977e-02f, 3.28460932e-01f, 3.11418921e-01f, -1.31169125e-01f, -1.31489947e-01f, 2.09063649e-01f, 3.62003557e-02f,
  4.27927636e-02f, 4.04526442e-01f, 1.21440582e-01f, -9.87600884e-04f, 2.41774663e-01f, 5.34656644e-02f, 6.91828281e-02f, -1.10837799e-02f, 2.02930287e-01f, -1.81436792e-01f,
  1.00761667e-01f, 2.82651424e-01f, 2.46780384e-02f, 7.14225471e-02f, -9.82558578e-02f, -1.23163559e-01f, -1.19888842e-01f, -3.10425818e-01f, -3.77313912e-01f, -1.14174590e-01f,
  -1.05652828e-02f, -3.21472436e-02f, -3.54632527e-01f, 3.96757713e-03f, 8.47912580e-02f, -1.29387885e-01f, 1.14486232e-01f, 4.49267149e-01f, 9.05451104e-02f, 3.40289474e-02f,
  -7.95167056e-04f, -7.56354406e-02f, 9.59948376e-02f, -3.08288299e-02f, -9.47779790e-02f, 7.19539523e-02f, 3.60105224e-02f, -4.76489663e-02f, -2.18129959e-02f, -5.44020422e-02f,
  -2.77514402e-02f, 1.26866981e-01f, 2.41088104e-02f, 2.37536840e-02f, 1.11854710e-01f, -1.37260742e-03f, -1.31207239e-03f, -1.40916392e-01f, -6.88506737e-02f, 1.06010340e-01f,
  -1.57938763e-01f, 1.46267712e-01f, 1.02297571e-02f, 1.56937495e-01f, -1.40377745e-01f, -1.31846473e-01f, 1.70325845e-01f, -3.19178738e-02f, 3.70090082e-02f, -3.18926983e-02f,
  -1.86067179e-01f, -9.29488242e-02f, -1.13283880e-01f, 3.17432024e-02f, -1.58994226e-03f, 2.92455312e-02f, 5.15987352e-02f, -8.19265991e-02f, 1.41859408e-02f, -1.02798387e-01f,
  1.54915869e-01f, -5.10743633e-02f, -1.99462175e-01f, -6.50345832e-02f, 1.34961819e-02f, -8.30658749e-02f, -3.22524369e-01f, -2.59028018e-01f, 2.70455424e-02f, -4.55798507e-02f,
  -3.60226065e-01f, -4.30060834e-01f, -5.86436570e-01f, -4.39185649e-01f, -4.95110489e-02f, -2.81179070e-01f, -6.30240664e-02f, -2.10749470e-02f, -2.52833128e-01f, -4.96940672e-01f,
  7.73802221e-01f, 4.08806622e-01f, 3.55809450e-01f, 3.40162963e-01f, -2.52627254e-01f, -5.04999936e-01f, -6.89147890e-01f, -5.69803298e-01f, -6.45737723e-02f, 2.16366053e-01f,
  4.55246344e-02f, -1.26234323e-01f, -5.54064997e-02f, -2.19884247e-01f, -3.29170465e-01f, 7.41185620e-02f, 7.64687508e-02f, -3.61247435e-02f, -5.60203075e-01f, -4.23195630e-01f,
  -5.91556355e-02f, 2.04294119e-02f, 4.98213321e-02f, -9.25750211e-02f, 4.81632978e-01f, -6.68548122e-02f, 2.12016836e-01f, 1.98226109e-01f, 1.45130858e-01f, 8.35113406e-01f,
  7.91162312e-01f, 3.48239005e-01f, -4.02205974e-01f, -7.93489516e-02f, 2.56043047e-01f, 2.32643962e-01f, -6.02157833e-03f, 2.37146109e-01f, 2.75963116e-02f, 1.60225868e-01f,
  2.37453386e-01f, 1.08588688e-01f, 4.81392629e-03f, -8.91256263e-04f, 4.98294048e-02f, -1.22887202e-01f, -1.42122149e-01f, -6.34763911e-02f, -3.37061100e-02f, 7.47348517e-02f,
  -2.09093885e-03f, -1.03382058e-01f, -1.15038961e-01f, -4.81842756e-01f, 2.85166930e-02f, 1.73513312e-02f, -1.14880912e-01f, 1.22985840e-01f, -1.64549977e-01f, 3.59951317e-01f,
  -1.74289629e-01f, 1.35388792e-01f, -2.07824856e-02f, -4.60359175e-03f, -7.04899803e-02f, 6.01103753e-02f, 7.06467479e-02f, -1.27019331e-01f, -8.84053186e-02f, -2.89445557e-02f,
  -1.78597584e-01f, 3.89029011e-02f, 1.61458529e-03f, -6.44051703e-03f, 1.25262737e-02f, -4.78366800e-02f, 1.21375680e-01f, -2.64431033e-02f, 5.56661375e-03f, -3.20655815e-02f,
  -1.89304668e-02f, 5.12396209e-02f, 4.36491445e-02f, -1.46606088e-01f, -2.67200582e-02f, 4.83357385e-02f, 9.63781774e-02f, 1.96921127e-03f, -6.96060658e-02f, 2.64266804e-02f,
  7.13203698e-02f, -6.63013995e-01f, 2.33638823e-01f, -1.81180120e-01f, 1.53207809e-01f, -5.85115142e-02f, 2.00314701e-01f, -9.69844088e-02f, 1.61051303e-01f, -4.99802455e-03f,
  -6.21412285e-02f, 3.68376002e-02f, 3.28478031e-02f, 3.47115919e-02f, -2.45297059e-01f, -5.99506907e-02f, -1.90045163e-01f, -2.93531060e-01f, -2.71995544e-01f, 3.71626057e-02f,
  -7.11281821e-02f, -3.92819971e-01f, -3.32876176e-01f, -2.25963458e-01f, 4.37800623e-02f, -2.62488097e-01f, -1.77771702e-01f, 4.31597829e-02f, -4.09441054e-01f, -2.17634052e-01f,
  1.20760655e+00f, -4.63022232e-01f, 1.25641003e-01f, 1.59600809e-01f, -1.99582353e-01f, -1.09898143e-01f, -3.36727291e-01f, -1.57862738e-01f, -9.10957158e-03f, 8.41351300e-02f,
  1.22778617e-01f, 2.28441343e-01f, 1.69875547e-01f, 2.10340247e-01f, 1.20126210e-01f, -1.31683007e-01f, -5.07913530e-02f, 3.03284109e-01f, 3.31754208e-01f, 3.22290547e-02f,
  -8.18621293e-02f, -4.33462150e-02f, 2.27439031e-01f, 2.44866009e-03f, -2.70929128e-01f, 1.35737419e-01f, -4.96223345e-02f, -4.21915762e-02f, -1.10895865e-01f, -7.27882087e-02f,
  5.51324561e-02f, 1.60536364e-01f, 1.17618002e-01f, 4.08577807e-02f, 6.80450648e-02f, 1.84920892e-01f, 1.82610556e-01f, -6.02448080e-03f, 2.17685271e-02f, -1.27799988e-01f,
  -1.94605701e-02f, 1.38675511e-01f, 5.54537922e-02f, 1.78630855e-02f, 2.95871999e-02f, 8.85336101e-02f, -1.23766891e-03f, 1.85502827e-01f, -4.88743670e-02f, -5.22314794e-02f,
  -4.67965305e-02f, 8.64261091e-02f, -5.17263561e-02f, -9.05391052e-02f, 7.19977543e-02f, 1.22815162e-01f, -5.14980592e-02f, -4.15578932e-02f, 1.72955379e-01f, 4.51759361e-02f,
  6.02231734e-02f, -1.10627577e-01f, 5.60390092e-02f, 9.69976261e-02f, -1.15652516e-01f, -1.34579822e-01f, -6.55577704e-02f, -5.81760667e-02f, 1.73760280e-01f, 1.38819650e-01f,
  -1.75476804e-01f, 9.71546546e-02f, -5.31977788e-02f, 1.26033634e-01f, 2.69895196e-01f, 1.29451444e-02f, 1.95313301e-02f, -1.84935644e-01f, -1.77308195e-03f, -1.43546000e-01f,
  1.12465575e-01f, 1.13348581e-01f, 1.23523762e-02f, 3.74942981e-02f, -2.47444883e-02f, 2.56587425e-03f, 1.13205448e-01f, -5.65448478e-02f, -3.44200619e-02f, -1.86854914e-01f,
  -5.14641523e-01f, 2.43838489e-01f, 1.37263477e-01f, 5.84808923e-02f, -1.53312441e-02f, -1.07879415e-02f, 4.77367193e-02f, -1.46653607e-01f, -1.42632857e-01f, -3.37906837e-01f,
  -1.22723594e-01f, 9.50511768e-02f, -2.02727616e-01f, 6.59745038e-02f, 1.28009379e-01f, 1.64102346e-01f, -3.39689702e-02f, 6.46890178e-02f, -1.35398999e-01f, -1.60288230e-01f,
  -2.02832565e-01f, 7.87452608e-02f, 5.03331758e-02f, 6.61900640e-02f, 1.01449795e-01f, 1.31970212e-01f, 3.46129648e-02f, -1.20788492e-01f, 2.23335356e-01f, 2.96841208e-02f,
  3.19248259e-01f, -4.19174314e-01f, -3.34885344e-02f, -1.29346475e-02f, 2.08755121e-01f, 1.45287633e-01f, -1.06991313e-01f, -2.46710345e-01f, 2.00321209e-02f, 4.32747416e-03f,
  -3.15515041e-01f, -1.26275584e-01f, -3.19829971e-01f, -1.42833248e-01f, -3.35483670e-01f, -1.80978075e-01f, -9.62836742e-02f, 1.65754005e-01f, 4.65618163e-01f, 4.85638529e-01f,
  3.58809799e-01f, 3.59265715e-01f, 1.36959299e-01f, 3.05995904e-03f, 8.67036432e-02f, 2.13394225e-01f, -1.56728759e-01f, -1.90511793e-01f, -1.78424641e-01f, -1.20204739e-01f,
  4.45251554e-01f, -5.77986598e-01f, -1.70350879e-01f, -2.43882671e-01f, -1.30558908e-01f, -2.39443034e-02f, 7.57444426e-02f, -5.46125360e-02f, -2.02573970e-01f, -6.31147027e-02f,
  -9.18409601e-02f, -4.59985919e-02f, -1.00302160e-01f, 4.73185144e-02f, 1.88541710e-01f, 7.44854510e-02f, -8.17719921e-02f, -3.46667618e-01f, -2.79070735e-01f, -6.33145794e-02f,
  1.46754645e-02f, -4.47478704e-02f, -6.43367767e-02f, -1.63777396e-01f, -3.23227495e-01f, -1.88760296e-01f, -2.02508897e-01f, -2.16139704e-01f, -3.22566003e-01f, 1.20823607e-01f,
  2.74154916e-02f, 2.12481003e-02f, 4.86602373e-02f, 3.80680971e-02f, 2.22271234e-02f, 3.33332606e-02f, -3.97313945e-02f, 1.66099101e-01f, 8.18122104e-02f, -1.08796813e-01f,
  2.51365490e-02f, -1.59409493e-02f, -3.14046629e-02f, 8.63081217e-02f, -4.82064523e-02f, -1.56930745e-01f, 7.41333738e-02f, 1.24340408e-01f, -1.17566101e-01f, -4.44764458e-02f,
  -1.31580429e-02f, -1.55854791e-01f, 1.19973114e-02f, 7.41171315e-02f, -9.32067931e-02f, -1.26716256e-01f, 4.90568914e-02f, -2.75591705e-02f, 4.23465259e-02f, 3.24136461e-03f,
  6.42532170e-01f, -4.43334252e-01f, 9.81338173e-02f, -5.91018349e-02f, 3.36079113e-02f, -1.20616414e-01f, -4.77691814e-02f, 5.65622896e-02f, -2.02227622e-01f, 4.60456498e-02f,
  -1.62864327e-01f, -5.88486269e-02f, -9.57202092e-02f, -2.31615584e-02f, 1.60324976e-01f, 9.25482288e-02f, -1.04488604e-01f, 2.12273467e-03f, -1.69706032e-01f, -5.77034429e-02f,
  -1.96411996e-03f, 1.94024011e-01f, 2.72423834e-01f, 8.05728212e-02f, -3.86543432e-03f, 1.45784810e-01f, 3.03431422e-01f, 4.90898974e-02f, 9.08490494e-02f, 4.80649173e-01f,
  -4.60693002e-01f, 7.57402122e-01f, 3.91629249e-01f, 1.08430371e-01f, 5.17354369e-01f, 4.32813019e-01f, 9.77669120e-01f, 2.62368798e-01f, -2.67893493e-01f, 1.19418673e-01f,
  7.46457353e-02f, -5.10886610e-01f, -2.75045305e-01f, -1.96511865e-01f, -7.32264156e-03f, 1.86409652e-01f, 3.75888765e-01f, -2.31723204e-01f, -4.93605763e-01f, -2.79070705e-01f,
  -1.64369687e-01f, -1.07290268e-01f, -3.31995666e-01f, -2.49416128e-01f, 4.87902761e-02f, -4.02995437e-01f, 2.82345474e-01f, 1.11911394e-01f, -9.76421754e-04f, 6.59410805e-02f,
  -1.41201958e-01f, 4.29755867e-01f, -3.92920643e-01f, -2.65575290e-01f, 8.96088332e-02f, -2.11211443e-01f, 8.54714662e-02f, -5.62226623e-02f, -2.22055495e-01f, -1.10345051e-01f,
  8.32951292e-02f, -1.57682598e-01f, 1.61611989e-01f, 9.24399570e-02f, 2.14983195e-01f, 1.58675894e-01f, -6.96793795e-02f, -7.04753250e-02f, -1.08223021e-01f, 2.59107471e-01f,
  2.18695045e-01f, -4.35474887e-02f, 1.78523749e-01f, 2.20170766e-01f, 8.44361410e-02f, -1.77553490e-01f, 3.65320265e-01f, -5.17090186e-02f, -2.97359526e-02f, -2.49011010e-01f,
  -2.35248193e-01f, 7.85982460e-02f, 1.20347194e-01f, 1.20440116e-02f, 2.33515799e-02f, 7.17184413e-03f, 3.85397673e-02f, -4.40424718e-02f, 8.45250413e-02f, 1.40931727e-02f,
  -8.02385062e-02f, -1.35574397e-02f, 1.08369760e-01f, 1.22912109e-01f, -1.39151230e-01f, 2.61624139e-02f, 8.01720694e-02f, -1.53350020e-02f, 1.48776220e-02f, -3.60359922e-02f,
  -2.06029534e-01f, 1.25931382e-01f, 1.67632312e-01f, 1.05983227e-01f, -1.62668992e-02f, -1.01762228e-01f, -9.04062539e-02f, 5.47630154e-03f, -7.83102470e-04f, 4.63538663e-03f,
  -2.81059533e-01f, 4.91652675e-02f, -2.77838290e-01f, -1.32538006e-01f, 1.35883614e-01f, -1.60167664e-02f, 2.75784805e-02f, -4.81128842e-02f, 5.21614887e-02f, -3.61162759e-02f,
  1.96727246e-01f, -1.85237974e-01f, 1.59595490e-01f, 2.73885280e-02f, -1.40694454e-01f, -5.80393150e-02f, -1.37876779e-01f, 4.29373980e-02f, -1.13214143e-01f, -4.39465232e-02f,
  7.17079490e-02f, -2.36816213e-01f, -3.38762552e-01f, -1.38213098e-01f, -6.97990283e-02f, -4.60120946e-01f, -1.37542620e-01f, -3.90264876e-02f, -1.53464213e-01f, -3.32331330e-01f,
  -5.35377145e-01f, -5.32283902e-01f, 6.47406816e-01f, -7.29478061e-01f, -3.68140578e-01f, -3.44675660e-01f, -6.65141106e-01f, -5.51864803e-01f, -3.26609790e-01f, -4.02473301e-01f,
  -7.16850907e-02f, 5.57125509e-01f, 6.74817204e-01f, 5.25601566e-01f, 3.99956733e-01f, -4.84379798e-01f, -3.33242267e-01f, 6.53007030e-01f, 5.73489726e-01f, -3.29618812e-01f,
  -4.19934154e-01f, -2.67260253e-01f, 2.00705841e-01f, -5.46695255e-02f, -6.19601905e-01f, 1.84252169e-02f, 3.57654281e-02f, -1.90223038e-01f, -1.26460478e-01f, -3.85976166e-01f,
  3.72417986e-01f, -5.66381097e-01f, 8.62976089e-02f, -1.94883551e-02f, 2.73068808e-03f, 3.68573740e-02f, -3.80970612e-02f, 9.64363664e-02f, 1.14029145e-03f, -1.04310587e-01f,
  -7.34649524e-02f, 5.29708166e-04f, 3.43436562e-02f, 1.22540869e-01f, -1.91629425e-01f, -4.59669083e-02f, -1.73017792e-02f, 4.92307544e-02f, 2.51994450e-02f, -1.19918309e-01f,
  -3.13214928e-01f, -1.34653419e-01f, 1.69210732e-01f, -6.77158125e-03f, -1.04752760e-02f, 3.48521382e-01f, -1.35276705e-01f, -2.73038268e-01f, 2.18467996e-01f, -3.59365553e-01f,
  -8.48891139e-02f, 1.08584076e-01f, -6.39160052e-02f, -1.29371628e-01f, 3.89311686e-02f, 1.82642899e-02f, -4.09793407e-02f, 1.75037037e-03f, -1.00770488e-01f, -4.76656556e-02f,
  1.12574790e-02f, -1.15906922e-02f, 2.90400591e-02f, -3.40635180e-02f, -3.65244523e-02f, 3.14422511e-02f, 2.15092096e-02f, -1.23253264e-01f, -8.18259921e-03f, -5.90914898e-02f,
  8.21846724e-02f, -6.27174508e-03f, -6.63416758e-02f, 2.60185990e-02f, -1.51907623e-01f, 3.83002684e-02f, -7.83002228e-02f, 3.20809744e-02f, 5.73690832e-02f, -6.92929281e-03f,
  2.53929913e-01f, 3.53543490e-01f, -8.33181962e-02f, 9.06703323e-02f, -2.23549142e-01f, 1.95923615e-02f, -1.44656852e-01f, -8.06388408e-02f, -1.22344485e-02f, 1.25084035e-02f,
  -5.01102023e-02f, 1.25865534e-01f, -5.19986674e-02f, -1.55556798e-02f, 4.24197465e-02f, -8.46500024e-02f, -9.31065381e-02f, 5.75487502e-02f, -1.97113365e-01f, -7.60617405e-02f,
  -2.59794563e-01f, -1.47257462e-01f, 1.11655198e-01f, 1.55941099e-01f, -1.68543682e-01f, 2.46963024e-01f, 1.91787422e-01f, -4.11193930e-02f, 2.46319532e-01f, 8.91347416e-03f,
  -7.99512327e-01f, 3.46168131e-02f, 6.16156101e-01f, -1.57253534e-01f, 3.96837145e-01f, 4.10779357e-01f, 4.06253725e-01f, -1.22239374e-01f, -2.44195297e-01f, 1.33950487e-01f,
  4.15751860e-02f, -2.09075481e-01f, -1.73973575e-01f, -2.58475155e-01f, -1.60284892e-01f, 2.47591004e-01f, 1.37598693e-01f, -4.39736582e-02f, -2.49323118e-02f, 6.80128634e-02f,
  -9.20800492e-02f, -3.79669107e-02f, -1.99365318e-01f, -2.42672041e-02f, 7.19381198e-02f, 7.70331100e-02f, 3.16888779e-01f, 2.43634164e-01f, 3.97877008e-01f, 3.56414616e-02f,
  7.93085933e-01f, -2.12955084e-02f, -1.15860000e-01f, -2.94137001e-01f, 1.04841702e-02f, -1.39178500e-01f, -1.20447921e-02f, -8.57103840e-02f, -6.20636903e-02f, 3.52833122e-02f,
  5.21026505e-03f, -1.78683206e-01f, -1.21025249e-01f, -1.87704545e-02f, 4.11255248e-02f, 4.86814678e-02f, -2.04237103e-02f, -5.91999963e-02f, 6.15421832e-02f, 8.34141299e-03f,
  7.81073282e-03f, 4.52457666e-01f, 5.84513068e-01f, 2.27492183e-01f, 4.89761941e-02f, -1.41562743e-03f, 1.59651235e-01f, -4.24629040e-02f, 1.67280897e-01f, 2.44936064e-01f,
  2.23293349e-01f, -2.99468059e-02f, 2.05315739e-01f, 1.08534254e-01f, 7.14709144e-03f, 7.36257657e-02f, 2.04335600e-02f, 1.14670403e-01f, 1.10257138e-02f, 6.40090629e-02f,
  3.46234404e-02f, 1.39371783e-01f, -1.02897108e-01f, 2.83297580e-02f, 1.46049261e-01f, 1.50455207e-01f, 9.95940808e-03f, 4.03826833e-02f, 2.61830515e-03f, -1.15989499e-01f,
  -2.97843441e-02f, 7.88297281e-02f, -9.62005928e-02f, -5.38960733e-02f, 8.33488628e-02f, -2.43527368e-02f, 7.26006776e-02f, 3.14731002e-02f, 8.34914949e-03f, -1.30963922e-01f,
  5.63968658e-01f, 8.34602583e-03f, -1.50416806e-01f, -2.16969207e-01f, -3.49057987e-02f, -2.10327402e-01f, -3.98718454e-02f, 3.99256032e-03f, -1.74563378e-01f, 7.16730133e-02f,
  9.46030580e-03f, -1.29994869e-01f, -2.28799991e-02f, -1.56193361e-01f, -1.38236836e-01f, -3.16440016e-02f, -5.78809232e-02f, 6.23632409e-02f, 1.41850710e-01f, 2.31046587e-01f,
  9.28021222e-02f, 3.64779532e-01f, 4.85377192e-01f, 1.39759287e-01f, 7.66855851e-02f, 5.33100441e-02f, 2.56878942e-01f, 2.20291361e-01f, 3.49083453e-01f, 2.11502492e-01f,
  5.15769899e-01f, -1.62549928e-01f, -6.02679193e-01f, 2.93445081e-01f, -5.91947556e-01f, -3.47099543e-01f, -5.14900446e-01f, 2.30028778e-02f, 3.67658794e-01f, -7.95103833e-02f,
  -3.98652144e-02f, 2.77934581e-01f, 5.75873375e-01f, 5.25742844e-02f, -9.75519642e-02f, -2.68933862e-01f, -2.76040256e-01f, -3.20455998e-01f, -5.44087887e-01f, -7.35309482e-01f,
  -4.26343888e-01f, -1.52720004e-01f, 1.24706319e-02f, -5.01275137e-02f, -1.85531378e-01f, -6.91191992e-03f, -1.18424490e-01f, -2.16283306e-01f, -1.92949846e-01f, -3.32173884e-01f,
  -9.53843072e-03f, -4.44247276e-01f, -1.16873525e-01f, -5.32978103e-02f, -1.07451938e-01f, 6.09842166e-02f, -1.40230820e-01f, -3.18440109e-01f, 5.64144505e-03f, 9.17432532e-02f,
  -1.20121762e-01f, -2.70996004e-01f, -1.66826285e-02f, -1.30144998e-01f, -2.25815460e-01f, -2.26510063e-01f, -1.71703175e-01f, -4.01095271e-01f, -5.22616915e-02f, -1.77954420e-01f,
  -4.30686355e-01f, -6.66093051e-01f, -2.02597469e-01f, -1.38470501e-01f, -1.91141948e-01f, -4.19496372e-02f, -1.22292958e-01f, -1.90920100e-01f, -2.08105162e-01f, 9.49154869e-02f,
  1.48710012e-01f, 2.44315997e-01f, -6.09188490e-02f, -8.18339065e-02f, 3.36210951e-02f, 2.06868932e-01f, 9.56475511e-02f, -1.10796075e-02f, -1.25365689e-01f, 9.28778276e-02f,
  1.67364374e-01f, 1.70210768e-02f, -1.04035199e-01f, 1.41796306e-01f, 1.10262193e-01f, -4.76120226e-02f, 2.92589683e-02f, 8.30587521e-02f, 1.02917619e-01f, 1.61933638e-02f,
  -9.78570357e-02f, -3.57626714e-02f, 1.43522382e-01f, 6.13808408e-02f, -1.66330576e-01f, -1.67709906e-02f, -1.01259944e-03f, 2.37427279e-01f, 2.81713009e-01f, 3.34996097e-02f,
  8.63587141e-01f, -1.11606114e-01f, 3.55547100e-01f, -2.61578053e-01f, -3.26940045e-02f, 5.24393879e-02f, 1.61901698e-01f, -2.12385505e-01f, 1.37607023e-01f, 4.14673202e-02f,
  -6.55895099e-02f, 2.11210310e-01f, 1.81211039e-01f, -5.36874346e-02f, -3.88804018e-01f, -1.24121204e-01f, 8.18454176e-02f, -8.24115053e-02f, -1.43157870e-01f, -3.73261869e-02f,
  1.45757377e-01f, -3.39177661e-02f, 4.84701127e-01f, 3.25249106e-01f, 1.30656362e-01f, 3.49405378e-01f, 3.18403929e-01f, 2.93150544e-01f, 4.35303688e-01f, 6.59270287e-01f,
  8.95275295e-01f, -7.89713979e-01f, 1.65235937e-01f, 2.50532806e-01f, 1.15480654e-01f, 1.86988562e-01f, 1.99081190e-02f, 7.19053745e-02f, 1.60085723e-01f, -4.31691520e-02f,
  1.03199957e-02f, 1.66798100e-01f, 8.10413584e-02f, 9.70016494e-02f, 6.16298690e-02f, -2.28017382e-02f, 2.57755276e-02f, 3.81220788e-01f, 4.66289043e-01f, 4.43047062e-02f,
  -6.00011945e-02f, -6.77300170e-02f, 3.02693024e-02f, -5.19322231e-02f, -2.64636546e-01f, 1.02284603e-01f, -1.76720783e-01f, -2.47396827e-01f, -3.20224971e-01f, -3.94516200e-01f,
  -6.95925355e-02f, -2.24753514e-01f, 3.16774666e-01f, -1.19940624e-01f, 6.22196775e-03f, 4.12859814e-03f, -1.82073265e-02f, -1.77264929e-01f, -6.81221783e-02f, 6.81000995e-03f,
  -5.89850098e-02f, -2.24336926e-02f, 6.21265732e-02f, -1.12100653e-01f, -1.14997774e-01f, 6.97042840e-03f, -1.74082473e-01f, -7.20226765e-02f, -3.33440141e-03f, -9.41903740e-02f,
  -1.62539124e-01f, 1.35296565e-02f, 4.89375219e-02f, -3.66821215e-02f, -7.57908623e-04f, 7.42355883e-02f, -2.32382476e-01f, -7.42574260e-02f, 3.74777019e-02f, -5.67573830e-02f,
  9.77760106e-02f, 1.55323535e-01f, 1.96829751e-01f, 9.34064090e-02f, 2.26001695e-01f, 1.87757969e-01f, 7.51709640e-02f, 1.02977883e-02f, 1.04561687e-01f, 1.92048270e-02f,
  -4.90742177e-02f, 2.25044787e-01f, 5.33722863e-02f, 3.04018259e-02f, 2.92746611e-02f, 1.62222236e-02f, -7.59783387e-02f, -8.67915899e-02f, -2.53658127e-02f, -6.04794212e-02f,
  1.10005602e-01f, -5.14033437e-02f, -1.39552996e-01f, -1.92167133e-01f, -1.33655056e-01f, -4.13528681e-02f, -1.32574528e-01f, -2.14393670e-03f, -6.80908412e-02f, -5.88401034e-02f,
  -3.21718365e-01f, 2.79836357e-01f, 2.03543276e-01f, -1.19333550e-01f, -2.03279760e-02f, -8.12778771e-02f, 7.86276162e-02f, -9.69586819e-02f, -2.91380584e-01f, -1.27135485e-01f,
  -3.36084850e-02f, 9.09062922e-02f, -1.04278192e-01f, -1.24147929e-01f, 1.98145032e-01f, 1.71890169e-01f, -1.05002612e-01f, 7.97612965e-02f, 4.29949770e-03f, -1.82613298e-01f,
  -1.44255146e-01f, 2.71071315e-01f, 3.20784628e-01f, 2.82276541e-01f, 1.53669342e-01f, 3.40219438e-01f, 5.72612733e-02f, 1.80941105e-01f, 2.81035513e-01f, 2.41485596e-01f,
  -8.06518495e-01f, 3.62810999e-01f, 4.54673059e-02f, 8.65043700e-02f, 4.66533452e-01f, 9.78991836e-02f, -5.61570860e-02f, -2.58658558e-01f, -9.39677993e-05f, 1.57221094e-01f,
  3.65131974e-01f, 1.72167599e-01f, 1.11781791e-01f, 1.14862863e-02f, -3.11517149e-01f, 3.73354524e-01f, 5.64175665e-01f, -1.95534587e-01f, -5.36526978e-01f, -4.05999660e-01f,
  1.15874954e-01f, -2.74903119e-01f, -4.14372116e-01f, -2.77671456e-01f, 2.44865075e-01f, 2.90887970e-02f, 1.53335884e-01f, -2.36486946e-03f, 2.22963721e-01f, 6.88325226e-01f,
  6.07828051e-02f, -2.10175768e-01f, -2.38069847e-01f, 1.05733678e-01f, 1.53693836e-02f, -1.91543519e-01f, -1.52949885e-01f, -5.53421751e-02f, -1.38025999e-01f, -9.89932790e-02f,
  6.23316430e-02f, -1.89024016e-01f, 2.23180845e-01f, -1.50457779e-02f, -1.15876207e-02f, -1.60182357e-01f, -2.19273046e-02f, -3.51609707e-01f, -2.95547456e-01f, -8.83338153e-02f,
  3.50421041e-01f, 1.07118569e-01f, -3.68446290e-01f, -5.70550710e-02f, -1.49704769e-01f, -1.96061775e-01f, -1.30145654e-01f, -3.41672540e-01f, -4.83865887e-01f, -2.66158640e-01f,
  -4.50938800e-03f, 1.19312495e-01f, 4.46573384e-02f, -3.29092033e-02f, -1.04432320e-02f, 1.74585089e-01f, 1.24636687e-01f, 7.65620321e-02f, -7.16604963e-02f, -2.62416899e-01f,
  2.22292393e-02f, 3.92523408e-02f, -1.00142971e-01f, -2.92060841e-02f, -7.13884234e-02f, -8.72242078e-03f, 7.76542798e-02f, -2.23553121e-01f, -1.51560575e-01f, -1.52182713e-01f,
  -2.34212782e-02f, -4.38049957e-02f, -5.43980636e-02f, -1.05087291e-02f, 4.15598117e-02f, -8.80906656e-02f, -1.21042088e-01f, -6.50111819e-03f, -2.30176091e-01f, -7.25886747e-02f,
  -7.85542652e-02f, -6.50299639e-02f, -1.17546968e-01f, 2.97651929e-03f, 7.97536038e-03f, -5.99465594e-02f, 1.17312908e-01f, -3.57190520e-02f, 7.97720477e-02f, -7.26997852e-02f,
  -1.65747985e-01f, -1.36661291e-01f, -2.20710095e-02f, -1.11906156e-02f, -1.85119390e-01f, 5.66480197e-02f, -2.33736783e-02f, 1.19887516e-01f, -8.90690088e-02f, -1.02359332e-01f,
  7.68855587e-02f, -2.12200746e-01f, -2.30628446e-01f, 1.10992722e-01f, 9.36176479e-02f, -1.65169448e-01f, -2.77825385e-01f, -3.67562711e-01f, -3.72520536e-01f, -4.45841104e-01f,
  5.58410466e-01f, 6.53376520e-01f, 3.00577760e-01f, 2.47315750e-01f, 3.21150869e-01f, 3.35318506e-01f, 5.14689803e-01f, 3.75720203e-01f, 8.39193836e-02f, 3.42323452e-01f,
  3.48195285e-01f, 6.38752952e-02f, 9.75205898e-02f, 3.02453935e-02f, 3.05093169e-01f, 2.16153249e-01f, 1.69857666e-01f, 4.53962423e-02f, 8.94918442e-02f, 1.36728033e-01f,
  1.28787577e-01f, 7.58643746e-02f, 2.03500554e-01f, 8.92387331e-02f, 8.40844437e-02f, -7.44810775e-02f, 1.22786790e-01f, 2.58628607e-01f, 6.65013045e-02f, 1.37445778e-01f,
  4.42725010e-02f, 6.45047665e-01f, -1.77254274e-01f, -7.81009346e-02f, -4.29732129e-02f, -9.91370454e-02f, -1.39823379e-02f, 2.28240173e-02f, -7.01753199e-02f, 3.58275347e-03f,
  -2.62647327e-02f, 1.78520028e-02f, 1.02117844e-01f, -4.04444523e-02f, 2.26651784e-02f, -1.14670396e-02f, -7.70460144e-02f, 2.61675566e-01f, 4.79090437e-02f, -1.92870889e-02f,
  3.33800055e-02f, 1.99161857e-01f, 2.27797758e-02f, 1.93424337e-02f, 2.10261986e-01f, -1.18523967e-02f, 1.64732963e-01f, 7.97210168e-03f, 2.04832256e-02f, 1.98257312e-01f,
  1.67147279e-01f, 1.72479376e-01f, -5.72598018e-02f, 1.40453637e-01f, 1.04500562e-01f, -8.24539363e-02f, -5.29170521e-02f, -6.32907972e-02f, -4.98064496e-02f, -6.26672953e-02f,
  -1.46129681e-02f, 1.46840438e-01f, 5.16865626e-02f, -3.01485732e-02f, -5.37663400e-02f, -1.16054513e-01f, -7.35758469e-02f, -8.50975066e-02f, -2.75638383e-02f, 1.52518768e-02f,
  3.82853337e-02f, -1.87659472e-01f, -1.84220850e-01f, 2.09660828e-02f, 4.68101837e-02f, 9.33434516e-02f, 6.06883243e-02f, -6.25266787e-03f, -4.60704491e-02f, 8.66220593e-02f,
  -3.41395408e-01f, -5.37310019e-02f, -6.48932680e-02f, 2.64770426e-02f, -2.96843816e-02f, -2.03341872e-01f, 6.96500540e-02f, -1.63807124e-01f, -8.66226852e-02f, 1.02475425e-02f,
  -3.23956609e-02f, -7.42173940e-02f, 2.23276131e-02f, -1.61289617e-01f, -2.19142646e-01f, -1.73849449e-01f, -1.35845706e-01f, -4.91640046e-02f, -1.59325898e-01f, -1.85645044e-01f,
  -1.83263347e-01f, -2.48204976e-01f, -4.57269549e-01f, -2.52200902e-01f, -5.60352206e-02f, -2.58588046e-01f, -2.73923516e-01f, -1.77322090e-01f, -2.71609277e-01f, -2.60191083e-01f,
  -7.55734026e-01f, 1.35414138e-01f, 3.79026793e-02f, -8.40053320e-01f, 1.90919079e-02f, 4.39517885e-01f, 4.94298667e-01f, 2.72909403e-01f, 8.14366415e-02f, 1.15982093e-01f,
  -1.42534852e-01f, -4.57597852e-01f, -6.24814570e-01f, -7.25942627e-02f, 1.62489861e-02f, 3.85924906e-01f, -2.71009862e-01f, -2.57229686e-01f, 7.31345639e-02f, 3.29187304e-01f,
  1.46420851e-01f, -4.30020064e-01f, -5.91294944e-01f, -3.68064076e-01f, -2.78503686e-01f, -4.06755239e-01f, -5.34298241e-01f, -3.62902969e-01f, -4.07132171e-02f, -4.49363291e-01f,
  1.97064672e-02f, -4.20408398e-01f, 2.17902720e-01f, -2.36352623e-01f, 1.80648472e-02f, 1.46497600e-02f, 4.73597609e-02f, -1.06976897e-01f, -8.50336812e-03f, 7.78477490e-02f,
  -3.22635055e-01f, 9.69558358e-02f, -2.81330049e-01f, 1.20865710e-01f, -1.79260880e-01f, -1.20658793e-01f, -8.87014065e-03f, -6.15124218e-03f, 3.24299075e-02f, -8.70607886e-03f,
  -7.59909227e-02f, -2.55475879e-01f, -1.91717833e-01f, 3.02929461e-01f, 1.96195319e-01f, -1.85372397e-01f, -2.69658957e-02f, 4.15338613e-02f, 3.83552462e-02f, 2.44932428e-01f,
  -2.75873691e-02f, 9.62051377e-02f, 7.32610449e-02f, 9.68682021e-02f, 5.00862077e-02f, 1.57073975e-01f, -1.39144242e-01f, -1.21531606e-01f, 6.84771240e-02f, 1.43032551e-01f,
  1.48539543e-01f, 9.84680653e-02f, -7.41148740e-02f, -8.14448744e-02f, -5.53560629e-03f, -5.03384396e-02f, -4.06789407e-02f, 4.06925529e-02f, -9.67735499e-02f, -8.38113800e-02f,
  5.64104458e-03f, -4.37883213e-02f, -1.87322661e-01f, -1.18844785e-01f, 9.61943865e-02f, 1.41818188e-02f, -4.19017784e-02f, 2.37102062e-01f, 3.86580825e-02f, 5.57311252e-02f,
  2.82399021e-02f, -7.28183687e-02f, -6.73337206e-02f, -2.23277912e-01f, -1.82506114e-01f, -6.81905821e-02f, -2.69122690e-01f, 1.86293237e-02f, -2.00537637e-01f, -1.02249600e-01f,
  -6.05622306e-02f, -2.69313548e-02f, -5.91535382e-02f, 1.28828198e-01f, 1.76878404e-02f, 3.04128900e-02f, 5.89462407e-02f, -1.17276445e-01f, -8.40272754e-02f, 2.11951360e-02f,
  1.37126371e-01f, 1.96881264e-01f, 1.56075433e-01f, 1.03307433e-01f, 7.40848575e-03f, -5.09927869e-02f, 1.03275165e-01f, 1.22601472e-01f, 6.73687384e-02f, 4.30560857e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.90635979e-01f, 5.93545258e-01f, 2.04985067e-01f, 4.08560246e-01f, 4.55056280e-01f, 1.08998382e+00f, 4.27992731e-01f, 7.44835615e-01f, 2.97424614e-01f, 8.23267400e-01f,
  6.12219274e-01f, 2.77907372e-01f, 5.17211258e-01f, 4.04297918e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.77407037e-02f, -1.24121763e-01f, 2.97188878e-01f, -1.70223773e-01f, 3.53567690e-01f, -1.63028002e-01f, -1.85731068e-01f, 2.42917672e-01f, -3.53177130e-01f, -5.85400045e-01f,
  -1.25014693e-01f, -2.34837532e-02f, 2.47863829e-01f, -2.17049211e-01f, -2.52603978e-01f, 5.35002470e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -2.49765992e-01f, 2.21243218e-01f, -5.09323478e-01f, 3.30559343e-01f, 5.33843160e-01f, -8.07610571e-01f, -4.09123152e-02f, 1.45322219e-01f, -6.93301201e-01f, -2.08190307e-01f,
  1.89762950e-01f, -7.98869357e-02f, -3.56416106e-01f, -1.95603743e-01f, -1.21713087e-01f, -7.01173618e-02f, 4.18027431e-01f, 1.11578710e-01f, 5.58016241e-01f, -3.88032556e-01f,
  5.86006284e-01f, 7.37417564e-02f, 7.87320137e-02f, 4.72621202e-01f, -3.52013052e-01f, 4.87556726e-01f, 2.67804533e-01f, 1.07595019e-01f, -2.92195022e-01f, 6.65302515e-01f,
  5.31711504e-02f, 7.91470766e-01f, 2.86415279e-01f, -3.35788280e-01f, -1.45044953e-01f, 2.25561127e-01f, -2.41729409e-01f, -3.32945108e-01f, 3.48242849e-01f, 3.52878183e-01f,
  -5.01221716e-01f, -4.73218232e-01f, 2.37482801e-01f, -1.43512994e-01f, 5.92525840e-01f, 2.01871723e-01f, -6.57479465e-02f, 1.83543041e-01f, 9.58199576e-02f, -2.27916300e-01f,
  -5.94529450e-01f, 6.96938276e-01f, 1.54561773e-01f, -7.69573689e-01f, -8.05346966e-02f, 1.31100547e+00f, -6.49680436e-01f, -3.39840055e-01f, 1.29434139e-01f, 4.75114107e-01f,
  4.19733196e-01f, -1.94820642e-01f, 4.24155667e-02f, 3.31926614e-01f, 5.29313862e-01f, 3.10018480e-01f, 6.13223314e-01f, -2.13982031e-01f, 1.80131420e-01f, 2.98532844e-01f,
  -3.21106911e-01f, -4.79974240e-01f, 6.32224619e-01f, -2.69346416e-01f, 3.10144722e-02f, -1.11198828e-01f, -6.48202747e-02f, 1.08051610e+00f, -1.16239391e-01f, 7.37667501e-01f,
  6.51520073e-01f, -4.75548208e-01f, 3.69570032e-02f, 5.06224334e-01f, 2.91853547e-01f, 1.27593863e+00f, 4.95967031e-01f, 3.16760205e-02f, -6.05177879e-01f, -8.38762105e-01f,
  -5.78867376e-01f, 7.08942235e-01f, -1.96126133e-01f, 2.09164202e-01f, 3.84201676e-01f, -3.01821530e-01f, 4.55710649e-01f, -4.64115709e-01f, 1.00214824e-01f, 4.00126427e-01f,
  -7.00177431e-01f, 1.33015737e-01f, 2.87556171e-01f, 3.12536210e-01f, 3.16053219e-02f, 9.05884579e-02f, -3.70371789e-01f, 6.20534182e-01f, 4.45181936e-01f, -3.40036929e-01f,
  5.43984354e-01f, -2.80530542e-01f, 3.64355028e-01f, 1.21079579e-01f, 1.58712953e-01f, 7.39013970e-01f, 8.28156471e-01f, -4.97771353e-01f, -6.17505133e-01f, -4.64939773e-01f,
  3.81733388e-01f, 3.37343782e-01f, 1.95807904e-01f, 3.48702759e-01f, -4.33892123e-02f, 7.85131872e-01f, 3.40164900e-01f, 5.05860567e-01f, -1.02263473e-01f, -1.36871085e-01f,
  2.82706350e-01f, -6.94607124e-02f, -6.82824627e-02f, 8.86469126e-01f, -7.16945007e-02f, 6.33912206e-01f, -5.85462712e-02f, -9.52435613e-01f, -7.37443686e-01f, -3.36123347e-01f,
  -9.34335113e-01f, 1.50712341e-01f, 3.60443383e-01f, -2.25423336e-01f, 1.86019558e-02f, -4.05465424e-01f, 1.15171000e-01f, -5.76967537e-01f, -5.15436769e-01f, 2.24650130e-01f,
  -1.66158766e-01f, -8.86666179e-02f, 9.38471794e-01f, -3.69797319e-01f, 7.87914824e-03f, -3.69813561e-01f, -4.93354917e-01f, -2.01050401e-01f, 4.64624166e-02f, -4.48237300e-01f,
  3.50231290e-01f, 1.27010062e-01f, 1.04815531e+00f, 5.12832217e-02f, -4.11403865e-01f, 6.69701695e-01f, 6.19323969e-01f, 3.57880816e-02f, 1.13214910e-01f, 4.04806048e-01f,
  -8.39624643e-01f, 2.99910694e-01f, 1.13319993e-01f, 4.45659101e-01f, -1.23212487e-01f, -5.19805849e-01f, 3.26409519e-01f, 4.49992150e-01f, 8.00265968e-01f, -8.05524662e-02f,
  -2.41186898e-02f, -3.34015191e-01f, 2.54693449e-01f, 3.67044389e-01f, -1.04831658e-01f, 1.45592511e+00f, -7.21249580e-02f, 1.65785477e-01f, 4.80951250e-01f, 2.58623987e-01f,
  1.16166212e-01f, 1.37235209e-01f, -1.87018692e-01f, -5.73913157e-01f, 4.63096984e-02f, -1.18642080e+00f, -3.38668376e-01f, 2.20028218e-02f, -1.96585491e-01f, -3.07885110e-01f,
  1.12584567e+00f, -1.80306673e-01f, 1.10402413e-01f, -8.39478791e-01f, 1.46472201e-01f, 3.08427721e-01f, 4.54748064e-01f, -9.44918096e-01f, 7.83988610e-02f, 2.29212493e-01f,
  7.55001828e-02f, 2.19744533e-01f, -3.28862846e-01f, 6.83345139e-01f, 2.54953027e-01f, -6.03838444e-01f, 6.40054643e-01f, 4.54078168e-01f, 2.38971427e-01f, 2.93124557e-01f,
  2.86606252e-01f, 2.37798691e-01f, 6.60965502e-01f, -8.39859486e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  4.08845425e-01f, 5.27732521e-02f, 8.69336501e-02f, 7.14406133e-01f, 6.01977170e-01f, 7.13563740e-01f, 7.06452429e-01f, 6.56927228e-01f, 2.93796182e-01f, 4.08607811e-01f,
  1.65105700e-01f, -1.15736149e-01f, 6.22617364e-01f, 2.02994153e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.23585649e-01f, 1.03031464e-01f, 5.04415333e-01f, 2.73130219e-02f, 4.42211121e-01f, 2.60494858e-01f, -3.79644032e-03f, 1.65929034e-01f, 2.46021319e-02f, -1.17678255e-01f,
  -2.42712468e-01f, -2.76014745e-01f, -1.73659295e-01f, -2.80387551e-02f, -9.83169228e-02f, 9.45394784e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  7.41414726e-01f, 7.97772229e-01f, -2.25029066e-02f, 3.92072916e-01f, -1.45324960e-01f, 3.62012118e-01f, 1.33228511e-01f, 6.55422091e-01f, 8.42365474e-02f, 7.04366267e-02f,
  -1.82141189e-03f, -3.85967046e-01f, -5.78036904e-01f, 4.02899832e-02f, -3.23371768e-01f, 9.69631895e-02f, 8.27578664e-01f, -2.29438350e-01f, -4.96167272e-01f, 1.83689788e-01f,
  1.02237523e-01f, 3.63316268e-01f, 6.74662367e-02f, 2.55139861e-02f, 1.05095017e+00f, -2.86565661e-01f, -3.37120771e-01f, -4.53678578e-01f, 8.25622439e-01f, 6.93508089e-01f,
  -2.05391213e-01f, 6.25985339e-02f, 7.93514311e-01f, 6.30533099e-01f, 3.17610890e-01f, 4.82794613e-01f, -5.75828612e-01f, 2.40209207e-01f, 5.37345946e-01f, 6.81167603e-01f,
  -2.56692730e-02f, 7.36886978e-01f, -7.98013091e-01f, -1.39912292e-01f, -5.49921751e-01f, -7.89072692e-01f, -6.24242425e-02f, -6.66687787e-01f, 9.88434732e-01f, -2.43217051e-01f,
  7.98115432e-01f, -1.82299227e-01f, -7.94198811e-01f, 3.04247648e-01f, -4.82023299e-01f, 6.00160480e-01f, 2.25029916e-01f, 5.15765250e-01f, 5.26905775e-01f, -2.44194105e-01f,
  3.52169454e-01f, 6.05125539e-02f, -5.15618205e-01f, -1.77429855e-01f, 4.61511880e-01f, -6.77205682e-01f, -1.18539937e-01f, -2.12759241e-01f, 3.43535870e-01f, 3.21349978e-01f,
  3.11122000e-01f, 7.04426765e-01f, 4.06348765e-01f, 1.75743237e-01f, 7.21837461e-01f, 1.09923430e-01f, 5.31030715e-01f, -5.59978306e-01f, 5.92266858e-01f, 3.33080471e-01f,
  -3.29737663e-01f, 1.77592695e-01f, 2.23304927e-01f, 5.78266919e-01f, -3.08563858e-01f, 6.34767860e-02f, 5.72654188e-01f, -2.91579366e-01f, -7.24126041e-01f, 5.17010987e-01f,
  4.12538767e-01f, -4.48415101e-01f, 1.97843686e-01f, 6.71222627e-01f, -7.02419207e-02f, -1.07455023e-01f, -2.79298604e-01f, -3.58852774e-01f, -7.28796303e-01f, -8.66529226e-01f,
  -2.18766391e-01f, -2.66743600e-01f, -2.80823708e-01f, 5.38648143e-02f, 6.59260809e-01f, -4.70996529e-01f, 1.72190323e-01f, 7.04195976e-01f, 1.35519370e-01f, -7.13869706e-02f,
  7.13983774e-01f, 4.46142256e-01f, 1.68844461e-02f, 7.97296345e-01f, 5.05303204e-01f, 3.34150761e-01f, -6.07119165e-02f, 5.23994267e-01f, -5.16315222e-01f, -3.01547199e-01f,
  -2.45344445e-01f, -4.22923602e-02f, -1.93868518e-01f, -6.09765232e-01f, -1.00052881e+00f, 5.01791060e-01f, -1.90167129e-01f, -1.55627802e-01f, -7.69381523e-01f, 4.25991684e-01f,
  3.45314205e-01f, -3.67760301e-01f, 4.00215993e-03f, 4.45535004e-01f, -6.91541076e-01f, 4.42392379e-01f, 7.55691111e-01f, 3.88237834e-01f, -7.47647509e-02f, 1.29146755e-01f,
  -2.42295280e-01f, 5.58498735e-03f, 3.93101901e-01f, 3.20469081e-01f, 3.12613100e-01f, 1.41354740e-01f, 5.16371548e-01f, 5.79642281e-02f, -4.08198923e-01f, -4.88175713e-02f,
  1.15932453e+00f, 2.97663599e-01f, -3.89831215e-01f, 5.82486451e-01f, 8.20215464e-01f, 8.04409385e-01f, 3.73456359e-01f, -4.12218928e-01f, 6.20770276e-01f, 3.62481028e-01f,
  5.09023786e-01f, 1.22025406e+00f, 2.05056891e-01f, -1.62114867e-03f, 4.06901479e-01f, 6.03917122e-01f, 4.70844150e-01f, -3.62776488e-01f, 3.09111267e-01f, 2.59460747e-01f,
  -1.76202655e-01f, -9.07930136e-01f, -7.12320030e-01f, -7.46965334e-02f, -5.18055737e-01f, -4.95169282e-01f, -2.61217505e-01f, -1.20115697e+00f, 9.64806229e-02f, 2.12206304e-01f,
  1.53086975e-01f, 3.23545597e-02f, 4.04804386e-02f, 6.94330990e-01f, 5.86212218e-01f, -7.60144591e-01f, 7.97846615e-01f, -3.26772809e-01f, 4.81161714e-01f, -4.71265256e-01f,
  -2.17283294e-01f, 1.11158192e-01f, -2.51298606e-01f, 7.01790333e-01f, -3.60374302e-01f, -3.43577042e-02f, 1.24437481e-01f, 2.46869937e-01f, 3.58595967e-01f, -3.17010939e-01f,
  6.17399096e-01f, 8.97545099e-01f, -6.00022674e-01f, -2.69793481e-01f, 2.51280278e-01f, 5.18749475e-01f, 4.69907880e-01f, 2.12363675e-01f, 4.69340682e-01f, -5.38238227e-01f,
  -4.63492155e-01f, 4.48872358e-01f, 1.23037636e-01f, -3.28111887e-01f, 5.47953248e-01f, 2.99912512e-01f, -1.44788370e-01f, 1.89326972e-01f, -1.05106629e-01f, -2.47381926e-01f,
  5.59823394e-01f, 7.58983433e-01f, -3.03214103e-01f, 4.83230144e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  5.98973669e-02f, 6.15989864e-01f, 6.70152485e-01f, 4.61253524e-01f, 7.00223088e-01f, -2.12642118e-01f, 3.67892653e-01f, 2.17931308e-02f, 1.03601530e-01f, 4.16931152e-01f,
  3.31298262e-01f, 2.62334496e-01f, -2.63026714e-01f, -6.75679073e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  5.02164125e-01f, -2.92731762e-01f, 4.04810756e-02f, -7.29183555e-01f, 1.94758937e-01f, 5.69943249e-01f, -2.60092109e-01f, 2.47137129e-01f, -1.92932397e-01f, 6.68304920e-01f,
  2.46743456e-01f, -4.04582508e-02f, 1.59433708e-01f, 3.82475644e-01f, -4.88524213e-02f, -3.67621690e-01f, -5.53856015e-01f, 5.85126936e-01f, -5.66672534e-02f, 3.57914835e-01f,
  -9.21936154e-01f, -4.18871082e-03f, 1.62706093e-03f, -4.84004259e-01f, 2.43498281e-01f, -4.75914955e-01f, 3.80650729e-01f, -1.04509485e+00f, -4.23070103e-01f, -9.34943780e-02f,
  4.70658153e-01f, 1.11927234e-01f, 1.20414414e-01f, -1.54544485e+00f, -9.64908898e-01f, 3.81753206e-01f, -6.61006272e-01f, 1.36611491e-01f, 4.46968488e-02f, 5.01808003e-02f,
  -9.35787320e-01f, -2.19311416e-01f, -3.96561921e-01f, -7.72375047e-01f, -3.65288496e-01f, -3.58205289e-01f, 2.38331854e-01f, 4.78663862e-01f, 1.49382234e-01f, -6.06729202e-02f,
  -3.00687738e-02f, -7.31838703e-01f, 3.81033391e-01f, -2.77563512e-01f, -6.14640951e-01f, 6.13132298e-01f, 2.61883527e-01f, -6.66440800e-02f, -9.33672369e-01f, 6.03017695e-02f,
  4.40511078e-01f, -3.75896484e-01f, 2.14722410e-01f, -5.53946197e-02f, 5.86157441e-01f, 1.14084148e+00f, 3.30826163e-01f, -1.55844614e-01f, 4.24362779e-01f, 1.16489299e-01f,
  2.13619351e-01f, -2.48527333e-01f, -4.69954431e-01f, -3.30605060e-01f, -1.10506050e-01f, 2.19381720e-01f, -6.41321838e-01f, -9.01689410e-01f, 4.60304022e-02f, 1.92544773e-01f,
  3.72200668e-01f, 5.96883535e-01f, 3.48924428e-01f, -2.57057715e-02f, 1.79501951e-01f, 2.43596241e-01f, 3.47728461e-01f, -3.87238890e-01f, -1.03413530e-01f, -1.01900019e-01f,
  4.15285796e-01f, -4.06182468e-01f, 1.47171885e-01f, 3.68161261e-01f, -8.54750723e-02f, -5.82553267e-01f, -2.55693316e-01f, -2.70871460e-01f, -6.06262326e-01f, -8.27529654e-02f,
  -7.08165646e-01f, 2.27289394e-01f, 3.33588451e-01f, -9.79246080e-01f, 3.12843025e-01f, -4.08894196e-02f, -2.64704108e-01f, -1.13376953e-01f, -2.16147095e-01f, 5.95563233e-01f,
  -9.57906544e-01f, 1.65563837e-01f, -1.05374467e+00f, -1.06026232e-02f, -6.37574971e-01f, -5.58399975e-01f, -1.99961022e-01f, -9.57198977e-01f, 2.38371432e-01f, 3.97669077e-01f,
  -6.32496238e-01f, -3.35589975e-01f, -1.12363122e-01f, 3.14475983e-01f, -2.07130924e-01f, -5.67025721e-01f, 3.87775570e-01f, 1.31009789e-02f, -2.67301083e-01f, -1.55643106e-01f,
  1.34731472e-01f, 6.27627969e-01f, -7.66482890e-01f, -1.65432894e+00f, -8.96722451e-02f, -4.92059439e-01f, 3.69401604e-01f, 4.11689430e-01f, -1.14921838e-01f, 6.46305904e-02f,
  1.08913612e+00f, -4.84720051e-01f, 2.83873826e-01f, -5.04271448e-01f, 9.67565253e-02f, 2.31779844e-01f, 2.24647626e-01f, -1.91876307e-01f, -6.12249494e-01f, 2.01393053e-01f,
  1.62883401e-01f, -8.64639431e-02f, -9.93029237e-01f, -6.52521312e-01f, -8.62974167e-01f, 1.90270290e-01f, -3.95167559e-01f, 4.21631128e-01f, -6.00245118e-01f, 3.86359841e-01f,
  -1.91479661e-02f, 5.66106439e-01f, 4.02078241e-01f, 2.70476043e-01f, -5.39212003e-02f, -4.36491624e-04f, -1.28187013e+00f, 7.53390133e-01f, -7.02332556e-02f, 6.88223124e-01f,
  -2.58505553e-01f, -1.14812481e+00f, -5.35458215e-02f, -6.33130848e-01f, 9.57785174e-02f, -1.55388609e-01f, -6.20293140e-01f, -8.20464492e-01f, -6.91894352e-01f, -1.23387480e+00f,
  -8.42375100e-01f, -9.96622741e-01f, 2.34701142e-01f, -2.81737179e-01f, 5.93562543e-01f, -2.32638106e-01f, 3.16659331e-01f, 3.59794617e-01f, -6.59599900e-01f, -6.63930848e-02f,
  -6.40808418e-02f, -4.35033262e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -5.18910252e-02f, -2.77875334e-01f, 6.22339308e-01f, -2.51471102e-01f, 1.14165924e-01f, 3.61169487e-01f, 8.16597193e-02f, -5.19167840e-01f, 7.65984207e-02f, 1.98171720e-01f,
  -1.87472686e-01f, 2.65850514e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    