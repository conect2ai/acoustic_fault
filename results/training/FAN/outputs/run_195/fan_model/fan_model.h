/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.95843005e-01f, 3.40600878e-01f, 1.64419383e-01f, -7.68421590e-02f, -2.75258482e-01f, -2.34257892e-01f, -3.74998689e-01f, 6.68926835e-02f, -1.74343079e-01f, 1.72292903e-01f,
  -1.29502699e-01f, -7.76892304e-02f, 2.31200885e-02f, 1.27736315e-01f, -4.62617755e-01f, 2.72614639e-02f, -3.96423489e-02f, -7.03138039e-02f, -1.19155152e-02f, 8.88498221e-03f,
  -1.24948569e-01f, -8.66738707e-02f, 6.58339635e-02f, 1.23173237e-01f, -1.58426732e-01f, 4.02456000e-02f, 1.02760166e-01f, 3.61974426e-02f, 1.24173976e-01f, -6.40700683e-02f,
  7.74190426e-02f, 1.27886847e-01f, 4.57789302e-02f, 9.29266065e-02f, 3.02776112e-03f, 2.33659633e-02f, -4.34912890e-02f, -3.12196258e-02f, -2.89586578e-02f, -2.27352623e-02f,
  6.31165039e-03f, -1.82597544e-02f, 1.42877111e-02f, -4.31158915e-02f, 9.17997895e-05f, 9.50584039e-02f, -8.48914776e-03f, -3.78099196e-02f, 4.60864156e-02f, -2.40584090e-02f,
  -1.52189378e-03f, 9.76204965e-03f, -1.04789492e-02f, 1.86918043e-02f, -1.81283522e-02f, 1.49551295e-02f, -1.88729260e-02f, -3.96590456e-02f, -4.16152962e-02f, -5.15522175e-02f,
  2.64942506e-03f, -4.91247736e-02f, -2.78265048e-02f, 2.31687035e-02f, -5.50802834e-02f, 3.89960743e-02f, -4.18187864e-02f, 5.28591163e-02f, -5.43601587e-02f, -1.76627294e-03f,
  -4.59466614e-02f, -3.75884399e-02f, -3.88360233e-03f, -3.68021019e-02f, -3.15842740e-02f, 5.38761020e-02f, -4.46320511e-02f, 3.98072265e-02f, -1.07878940e-02f, 1.25325788e-02f,
  -1.31111601e-02f, -1.93569567e-02f, -1.31714940e-02f, 3.82771678e-02f, 1.40745463e-02f, -6.25452027e-02f, 1.73881985e-02f, 1.52916014e-02f, -3.35198129e-03f, -7.39224553e-02f,
  7.22707734e-02f, 1.18343979e-01f, -4.07753810e-02f, -1.27327787e-02f, 4.71159853e-02f, 2.16596248e-03f, 3.64338458e-02f, 1.94126796e-02f, 5.29530905e-02f, -1.31397266e-02f,
  8.54487182e-04f, -1.80961303e-02f, -2.99453456e-02f, -7.69968145e-03f, 6.56743534e-03f, -3.95603925e-02f, 1.20400293e-02f, -1.07787633e-02f, -4.53847796e-02f, 7.88907632e-02f,
  2.81129386e-02f, -6.66873232e-02f, -8.64860043e-02f, -2.52072401e-02f, -7.50192162e-03f, -5.10723852e-02f, 1.30519960e-02f, 7.27488520e-03f, -1.14334607e-03f, 4.69106771e-02f,
  6.12095147e-02f, 9.31486860e-02f, 6.06133223e-01f, 1.45788163e-01f, -3.80487084e-01f, -9.57658663e-02f, 4.71905917e-01f, -9.99742299e-02f, 7.83929601e-02f, 1.23700425e-01f,
  -8.04356784e-02f, 1.43101081e-01f, 3.81425053e-01f, -1.43954828e-01f, 1.22591078e-01f, 1.20165713e-01f, 5.05261160e-02f, 1.22871332e-01f, -1.12300083e-01f, 7.43259639e-02f,
  -3.16400975e-02f, -2.35701531e-01f, 2.35465094e-01f, -3.29507142e-01f, 9.54002962e-02f, 5.84408008e-02f, 3.81495059e-02f, 6.68470636e-02f, -1.54470995e-01f, -5.30423224e-02f,
  -2.45556504e-01f, 8.36949572e-02f, 7.03780055e-02f, 7.01927617e-02f, 5.15576303e-02f, 7.60897156e-03f, 7.86876157e-02f, 6.12867065e-02f, -2.31501833e-02f, 3.09710596e-02f,
  7.11782426e-02f, -1.25334457e-01f, -5.53262345e-02f, -4.21276651e-02f, -2.27408186e-02f, -2.78302766e-02f, -8.01706687e-02f, -2.73418799e-02f, 5.36500290e-03f, -6.39361038e-04f,
  8.24048668e-02f, -1.66779868e-02f, 1.45607460e-02f, 7.54054710e-02f, 8.25727060e-02f, -1.07286070e-02f, 1.53309479e-02f, 7.16285035e-02f, 2.53115520e-02f, -7.40927225e-03f,
  -3.55770737e-02f, -4.67051240e-03f, -2.87171975e-02f, -3.08796093e-02f, -5.01789637e-02f, 3.02648824e-02f, -4.51098196e-03f, -8.97766277e-02f, 2.62960931e-03f, -4.33101878e-02f,
  -2.87968330e-02f, 3.06941732e-03f, -6.67468533e-02f, 5.44672534e-02f, -1.04026258e-01f, 3.65689471e-02f, -1.64495129e-02f, 1.07559317e-03f, -3.93614545e-02f, -6.64973482e-02f,
  5.28756389e-03f, 5.62647264e-03f, 1.72543768e-02f, 1.34905251e-02f, -2.40455996e-02f, -2.17579529e-02f, 1.47328526e-02f, 7.01206410e-03f, 8.73398259e-02f, 6.93571866e-02f,
  1.21536165e-01f, 4.23454374e-01f, 5.61772957e-02f, 3.43645411e-03f, 1.91949811e-02f, -7.94105232e-02f, -3.02122962e-02f, -5.80807999e-02f, 5.40440083e-02f, 1.77149829e-02f,
  -1.37337698e-02f, 9.20010656e-02f, 3.08386888e-02f, -6.01876639e-02f, -1.06114978e-02f, 1.46767106e-02f, 6.24380484e-02f, 2.68304199e-02f, 8.07976872e-02f, -3.42327356e-02f,
  1.47125330e-02f, 3.56181487e-02f, 1.23528250e-01f, -6.70560915e-03f, -3.14084403e-02f, 6.07730970e-02f, -2.79215816e-02f, 3.37393628e-03f, 2.05555162e-03f, 6.10831194e-02f,
  -5.08665573e-03f, 8.25203419e-01f, 6.94065541e-02f, 2.34519511e-01f, -7.87594467e-02f, 1.90392822e-01f, 1.13002196e-01f, 1.46359116e-01f, -3.99390468e-03f, 3.95423830e-01f,
  9.04584825e-02f, 2.33535767e-01f, 1.70968562e-01f, 3.43095481e-01f, -2.32942969e-01f, 1.55316979e-01f, 2.44338915e-01f, 1.98190764e-01f, -5.36227822e-02f, 1.89957291e-01f,
  -2.04928294e-02f, 1.52892113e-01f, 2.63651535e-02f, 7.64873400e-02f, 1.37709424e-01f, 7.25012794e-02f, -8.34081322e-02f, -7.68473074e-02f, 1.82124346e-01f, -5.36420755e-02f,
  -7.59962713e-03f, 9.87065658e-02f, 5.29126376e-02f, 3.73895131e-02f, 2.86879875e-02f, 5.80434017e-02f, -7.40507105e-03f, -6.55361339e-02f, -8.84491578e-02f, 1.06855743e-02f,
  -1.63847096e-02f, -1.13647161e-02f, 4.28915862e-03f, -1.70430001e-02f, 2.53757201e-02f, 5.96697954e-03f, -9.59460717e-03f, 5.33403493e-02f, 3.91755179e-02f, 6.15043566e-02f,
  3.74145545e-02f, 9.18593630e-03f, -5.31805679e-03f, 6.14807047e-02f, -4.19791713e-02f, 1.14702787e-02f, 4.50607128e-02f, 1.63700823e-02f, 1.18545759e-02f, 7.56424963e-02f,
  2.37247199e-02f, 7.26337824e-03f, 3.36248018e-02f, -6.07083365e-02f, 4.10470665e-02f, -8.39176252e-02f, 1.20133394e-03f, -2.45651770e-02f, -3.85187455e-02f, 1.42058367e-02f,
  -4.07003947e-02f, -9.58346110e-03f, -9.74405743e-03f, -2.81684697e-02f, 1.20546110e-03f, 4.12462205e-02f, -2.50916798e-02f, 4.21027280e-02f, -2.53236406e-02f, -2.42348760e-02f,
  -1.39851486e-02f, -5.97265139e-02f, 1.18830763e-02f, -1.02657676e-02f, 1.75177213e-02f, -5.56503721e-02f, 3.93183902e-02f, 3.66146527e-02f, -2.72376202e-02f, -5.03547117e-02f,
  2.34222814e-01f, 2.18581557e-01f, -1.15545532e-02f, -2.91875824e-02f, 3.36327255e-02f, 1.63389789e-03f, 1.11863352e-02f, 3.71454135e-02f, -1.35488110e-02f, 6.00825902e-03f,
  1.46142244e-02f, 1.47435116e-03f, 2.29165759e-02f, -1.49236657e-02f, -7.00320154e-02f, 9.96865798e-03f, 4.28961776e-02f, -3.66073437e-02f, -2.09773239e-02f, 4.18243855e-02f,
  2.10582484e-02f, 3.30117904e-02f, -4.31480557e-02f, -3.79330367e-02f, 1.67315416e-02f, 2.12162435e-02f, -1.97848249e-02f, -1.84121588e-03f, -1.51615320e-02f, 4.30386467e-03f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.81663498e-01f, -1.03005335e-01f, -3.18936855e-01f, -6.84463903e-02f, 2.24828541e-01f, -2.27961801e-02f, -2.36796886e-01f, 8.63646120e-02f, -4.59277332e-01f, 2.86861628e-01f,
  2.76578307e-01f, -2.79737413e-01f, -1.86454415e-01f, -2.78698921e-01f, -3.03557575e-01f, -5.41813493e-01f, 1.04183992e-02f, -2.05797274e-02f, -2.67059684e-01f, 2.79761553e-01f,
  -8.32169428e-02f, 1.57220960e-01f, -2.05518141e-01f, 2.89070040e-01f, 1.38728827e-01f, 3.05960715e-01f, 7.58708298e-01f, 4.07907255e-02f, 3.51369411e-01f, 9.27749462e-03f,
  -3.15961003e-01f, -2.10878834e-01f, -7.86975175e-02f, -1.10382318e-01f, 1.87053859e-01f, 1.99823424e-01f, 1.30202159e-01f, -1.11743556e-02f, -6.34097457e-02f, -9.25660208e-02f,
  1.19343996e-02f, 5.05049364e-04f, 2.24577542e-02f, -7.83929229e-02f, -2.63944268e-02f, 1.49542894e-02f, -8.18174109e-02f, 2.50866935e-02f, -4.44184951e-02f, -1.46289602e-01f,
  -1.18759975e-01f, 3.81534211e-02f, 1.29092932e-01f, -9.83936805e-03f, -4.16173898e-02f, 1.60958096e-02f, 1.03804665e-02f, 4.53512631e-02f, 1.02317698e-01f, -4.45637619e-03f,
  8.13373178e-02f, 1.31146163e-01f, -3.14015113e-02f, -1.67729631e-01f, -3.44204679e-02f, -1.68445762e-02f, 1.15884021e-02f, 1.56344213e-02f, -9.63661149e-02f, 6.97407871e-02f,
  7.65611371e-03f, 3.21725747e-05f, -2.09738258e-02f, 2.30526067e-02f, 2.75802668e-02f, -8.33240058e-03f, -8.06051865e-03f, -1.04585653e-02f, 1.13327615e-02f, -3.42692584e-02f,
  -5.90462834e-02f, -1.34461699e-02f, 1.30609237e-02f, 1.19064316e-01f, -4.16321978e-02f, 4.29004095e-02f, 1.19134195e-01f, -4.98493016e-02f, -4.32598181e-02f, 4.88175862e-02f,
  1.94148481e-01f, 4.35885757e-01f, -1.83309577e-02f, -7.61044323e-02f, -5.10590747e-02f, 7.60592297e-02f, -2.47777663e-02f, -3.97000946e-02f, 7.50796571e-02f, 1.19842533e-02f,
  2.55672932e-01f, 2.48469468e-02f, 1.63090557e-01f, 3.98738356e-03f, 9.74775478e-03f, 9.69763324e-02f, 1.64507598e-01f, 7.92511702e-02f, 1.37640208e-01f, 1.80404797e-01f,
  1.85510367e-01f, 6.88707605e-02f, -1.99390221e-02f, 4.18835804e-02f, 7.96282291e-02f, 1.13682568e-01f, 1.05892360e-01f, 6.48277439e-03f, 5.60888760e-02f, -1.60649791e-02f,
  -4.94217277e-01f, 1.97693944e-01f, 1.09303731e-03f, 4.06810135e-01f, -2.80836910e-01f, -2.92611122e-01f, -1.59729302e-01f, 1.15065746e-01f, -2.69507974e-01f, 2.38651130e-02f,
  2.08016574e-01f, -1.66528136e-01f, 5.39211817e-02f, 5.12042165e-01f, 2.26855487e-01f, 2.03651220e-01f, 3.88651460e-01f, 1.56055331e-01f, 1.35206893e-01f, 1.99812859e-01f,
  3.40056717e-01f, 3.63033026e-01f, 5.75823784e-01f, 3.77817631e-01f, 1.88094407e-01f, 2.12344587e-01f, 3.92704219e-01f, 5.35540767e-02f, 3.92749131e-01f, 1.13790695e-04f,
  -2.29559839e-01f, -4.47875969e-02f, -5.04205562e-02f, -2.36230880e-01f, 4.72570164e-03f, -6.20030910e-02f, -5.60011379e-02f, -5.92804477e-02f, -1.36701418e-02f, 1.13545032e-02f,
  -1.59239799e-01f, 3.84601913e-02f, 4.24315743e-02f, -2.62137391e-02f, -1.47176221e-01f, 2.21876483e-02f, 4.90770303e-02f, -1.06827151e-02f, 1.00234356e-02f, 2.37332424e-03f,
  1.24089215e-02f, 5.64907305e-02f, 5.08944988e-02f, 4.54740077e-02f, 1.42780002e-02f, -1.41079398e-02f, 2.94406284e-02f, -5.52540645e-02f, -2.21061558e-02f, -2.76358128e-02f,
  -4.16657254e-02f, -1.12808810e-03f, 5.22092283e-02f, 4.49064896e-02f, 2.18281150e-02f, 4.03099172e-02f, 4.89467755e-02f, 2.02746056e-02f, -2.21657064e-02f, 4.75477055e-03f,
  9.74641647e-03f, 6.70617968e-02f, -5.85139655e-02f, 2.03810949e-02f, 4.35580388e-02f, -1.01532526e-01f, 3.87629718e-02f, -6.63375482e-03f, 1.30707491e-03f, 1.04038715e-01f,
  -2.77416762e-02f, -5.98166808e-02f, 1.54725239e-02f, -3.87459323e-02f, -5.41945882e-02f, 1.25515889e-02f, 4.02755141e-02f, 1.05147688e-02f, 4.33898382e-02f, 4.13978547e-02f,
  -9.75889713e-02f, 2.66391039e-01f, 6.77899197e-02f, -9.96664837e-02f, 1.51320528e-02f, -6.19076714e-02f, 2.47471072e-02f, 4.48804200e-02f, 1.28274113e-02f, 4.76294756e-03f,
  -8.97407904e-03f, 8.92455038e-03f, -5.29358871e-02f, -2.97173541e-02f, 9.12496671e-02f, -1.57339741e-02f, 5.19311316e-02f, 1.24989776e-02f, -1.33666201e-02f, 1.06653668e-01f,
  -1.97199974e-02f, -1.62579138e-02f, 3.64718176e-02f, -3.12161185e-02f, 2.92968657e-02f, -4.18083593e-02f, -1.49586305e-01f, 4.15607430e-02f, 1.12546355e-01f, 6.00515977e-02f,
  -4.86933172e-01f, -1.20817192e-01f, 5.35043478e-01f, -5.39822876e-01f, 6.88171014e-02f, 5.19129395e-01f, 3.93702984e-01f, -2.03301758e-01f, -5.72854638e-01f, -1.96016312e-01f,
  3.12793106e-02f, -1.47919044e-01f, 5.32518089e-01f, 3.57884914e-02f, 5.03146827e-01f, 4.62527186e-01f, 5.11550196e-02f, -3.15405913e-02f, -5.92904426e-02f, -2.60289013e-01f,
  -1.13413535e-01f, -1.87646240e-01f, 4.61506695e-01f, -2.83923656e-01f, -3.76210921e-02f, -3.15926194e-01f, -1.61452308e-01f, 2.71921039e-01f, -1.50265098e-01f, 1.51766837e-01f,
  -2.36803405e-02f, -3.92688572e-01f, 4.50466350e-02f, 4.84900922e-02f, -3.27960104e-02f, -2.80916300e-02f, 8.24256688e-02f, 2.42992163e-01f, 3.86276916e-02f, -2.83632856e-02f,
  -4.34622727e-02f, 6.79297522e-02f, -1.71316370e-01f, 3.74072627e-03f, -1.38006717e-01f, -5.83677888e-02f, 9.05526280e-02f, 5.02534993e-02f, -1.45316739e-02f, 2.39898175e-01f,
  1.15243383e-01f, 9.08956230e-02f, 9.80382599e-03f, -3.42803150e-02f, 7.49156326e-02f, -2.13754177e-02f, 4.94154431e-02f, 1.07918575e-01f, -8.71601477e-02f, -9.20737386e-02f,
  2.06790138e-02f, -3.86311114e-02f, 7.37462416e-02f, -5.02374209e-02f, -6.51018880e-03f, -5.02950400e-02f, -2.75324900e-02f, 3.21228430e-02f, -5.55463471e-02f, 3.63553762e-02f,
  -4.43901904e-02f, -1.17206894e-01f, -6.40358590e-03f, -3.66246365e-02f, -2.44787987e-02f, -6.80682138e-02f, 5.84373474e-02f, -1.89106036e-02f, -6.15760460e-02f, 2.38453085e-03f,
  1.27642546e-02f, -7.74909602e-03f, -1.81275420e-02f, 4.91995923e-02f, 5.87468371e-02f, 8.93489867e-02f, -5.53229898e-02f, 8.46179500e-02f, -2.81633735e-02f, 5.68415932e-02f,
  -1.69816181e-01f, -6.20259762e-01f, -9.71182510e-02f, -1.38439372e-01f, -2.41453983e-02f, 6.03225408e-03f, -5.91744520e-02f, -3.58966775e-02f, -1.46702128e-02f, -7.40221143e-02f,
  -3.85430716e-02f, -9.12225544e-02f, -8.47903788e-02f, -3.20730507e-02f, -8.06108769e-03f, -4.07746807e-02f, -7.37045556e-02f, -9.25882608e-02f, -7.13588074e-02f, -1.14048630e-01f,
  -7.89288506e-02f, -7.24643171e-02f, 1.23111894e-02f, -1.62062407e-01f, -1.20838284e-01f, -4.63521667e-02f, -1.11398369e-01f, -1.34531856e-02f, 3.27898003e-02f, -3.54014784e-02f,
  2.77173430e-01f, -1.05153546e-01f, -2.86923021e-01f, -3.42332870e-01f, -3.77349034e-02f, -1.26222804e-01f, -4.30642664e-01f, -2.27299049e-01f, -2.34807923e-01f, -3.21226567e-02f,
  -1.98487774e-01f, -3.30347903e-02f, -6.00024872e-03f, -3.54017258e-01f, 1.08200051e-01f, 1.51780322e-01f, -3.07783335e-01f, -2.12635890e-01f, -2.11507268e-02f, -3.26677978e-01f,
  -8.07999000e-02f, -4.24640238e-01f, -1.41171336e-01f, -1.51646048e-01f, -3.47838938e-01f, -1.06090717e-01f, 1.57388836e-01f, -1.44567817e-01f, -1.92549318e-01f, -9.48734507e-02f,
  -1.18135691e-01f, -1.15403429e-01f, -1.54323012e-01f, -7.86221102e-02f, 1.99221652e-02f, 3.63126956e-03f, 1.55282561e-02f, -1.16444621e-02f, -1.83885619e-02f, -1.32533228e-02f,
  -1.53163141e-02f, 1.07921898e-01f, -1.08119741e-01f, 3.89247127e-02f, -3.04377712e-02f, -1.38545744e-02f, -3.50870416e-02f, 1.38122530e-03f, -6.51242137e-02f, -6.49913121e-03f,
  -1.32506080e-02f, 1.67553406e-02f, 6.16052113e-02f, 6.88221157e-02f, 2.74831051e-04f, 1.35932292e-04f, 6.74770474e-02f, 6.91749975e-02f, -2.74819620e-02f, 3.75620909e-02f,
  -4.45685759e-02f, 1.13177367e-01f, -2.98320334e-02f, -1.79166775e-02f, -1.34905856e-02f, 1.04207834e-02f, -8.66644364e-03f, -3.51485237e-02f, -2.86562610e-02f, 3.02534215e-02f,
  -4.23134826e-02f, -4.91205864e-02f, -6.33706450e-02f, 1.14066824e-02f, 3.27109662e-03f, 4.25812528e-02f, -8.43940396e-03f, 6.50357306e-02f, -1.04748011e-01f, 7.26991668e-02f,
  2.07376592e-02f, 5.78495935e-02f, -3.50589082e-02f, 4.40325812e-02f, -6.83590844e-02f, -3.37992162e-02f, -5.27386032e-02f, 8.66034776e-02f, 5.42734303e-02f, 1.47337103e-02f,
  -7.76524693e-02f, -8.48205239e-02f, -2.65727732e-02f, -7.46988282e-02f, -4.91639674e-02f, 4.32410873e-02f, -8.11308771e-02f, -1.45414583e-02f, -5.78106306e-02f, -3.22540998e-02f,
  4.84690778e-02f, 1.99921969e-02f, 9.16368738e-02f, 2.77596023e-02f, -1.09241299e-01f, -1.08628914e-01f, -4.81130891e-02f, 5.82882576e-02f, -2.08538584e-02f, 6.68959096e-02f,
  -1.21256351e-01f, 8.27730000e-02f, -2.56370753e-02f, -3.04042604e-02f, -2.14839522e-02f, 7.10258856e-02f, 8.96356627e-02f, 1.66060273e-02f, 6.82109967e-02f, 5.69134811e-03f,
  -4.95003849e-01f, 1.26406848e-01f, -6.62501812e-01f, -2.04733253e-01f, -3.59284699e-01f, -5.72621644e-01f, -1.39452830e-01f, -2.64272183e-01f, 1.11128502e-01f, 5.60464859e-01f,
  2.70214766e-01f, -2.37920769e-02f, 5.46199501e-01f, 9.43754613e-03f, -4.48472440e-01f, 4.34740841e-01f, -1.80240631e-01f, 4.43063006e-02f, -3.25440541e-02f, -2.59627461e-01f,
  -3.12967390e-01f, 8.10082853e-02f, -1.34989560e-01f, -5.98854311e-02f, -3.57013285e-01f, -2.39200369e-01f, 1.18819535e-01f, -6.99318200e-02f, -2.04798877e-01f, -1.12698443e-01f,
  -1.94930285e-01f, 1.04785554e-01f, -9.93642807e-02f, -5.56693301e-02f, -2.11020723e-01f, -1.44392431e-01f, -9.50614959e-02f, 5.67295309e-03f, -5.63998185e-02f, -4.55268146e-03f,
  2.37218682e-02f, 1.60524286e-02f, -9.30708181e-03f, 8.88894871e-02f, 8.33286252e-03f, -7.98177421e-02f, -3.92519236e-02f, -9.66483802e-02f, -1.94057766e-02f, -5.48339933e-02f,
  -5.94563782e-02f, -8.93488303e-02f, -7.50229806e-02f, 5.14299497e-02f, -5.38917445e-02f, -3.48542333e-02f, -4.09090221e-02f, -7.94081166e-02f, -5.26570529e-02f, -1.19762331e-01f,
  5.40640131e-02f, 5.40059134e-02f, 1.12167880e-01f, 4.57205204e-03f, -4.11643013e-02f, -1.17823118e-02f, 8.00014064e-02f, -2.68267915e-02f, 3.74079384e-02f, -2.77843755e-02f,
  -8.41872767e-02f, -1.20032728e-02f, 2.42998563e-02f, -7.09489882e-02f, -2.93526538e-02f, 8.95136446e-02f, -1.95879061e-02f, 4.49381582e-03f, -1.01962514e-01f, -5.40125556e-02f,
  6.25076070e-02f, -2.09739059e-02f, 1.33589193e-01f, 4.12435681e-02f, -1.58742182e-02f, 9.37170684e-02f, -1.22459084e-02f, -9.44662001e-03f, 8.83825682e-03f, -6.10464960e-02f,
  -2.69538254e-01f, -2.17603028e-01f, 4.43536788e-02f, -2.15794761e-02f, 5.23480289e-02f, 4.62867767e-02f, -3.30247246e-02f, -1.28439903e-01f, -1.03414126e-01f, -3.21243070e-02f,
  -5.12134843e-02f, 3.31323519e-02f, -1.22346722e-01f, -1.81474686e-02f, -4.08011824e-02f, 4.58352938e-02f, 4.15499210e-02f, 4.92961071e-02f, -1.07601158e-01f, -7.67842531e-02f,
  -8.62492807e-03f, 5.80700338e-02f, 2.35414598e-02f, -5.40902019e-02f, 3.63816693e-02f, 6.62701204e-02f, -3.06126550e-02f, 5.44821806e-02f, -6.19600713e-02f, -3.79091986e-02f,
  -3.97440940e-01f, 4.66406018e-01f, -9.62815881e-02f, -2.03007892e-01f, -1.87883630e-01f, 5.93213379e-01f, 4.03350860e-01f, 1.47566363e-01f, 3.46826106e-01f, 4.34655666e-01f,
  1.10798702e-02f, 6.83790520e-02f, 2.79815435e-01f, 1.74939767e-01f, 2.37344161e-01f, 4.69884574e-01f, 3.86334658e-01f, 2.42187530e-01f, 1.23009153e-01f, -2.96338554e-02f,
  -1.36046946e-01f, 4.28253189e-02f, -2.77467340e-01f, -7.94471502e-02f, -2.84184724e-01f, -3.22955787e-01f, -2.71230310e-01f, -2.28095621e-01f, -1.12114549e-01f, 9.33373645e-02f,
  -4.79671098e-02f, -5.13076708e-02f, -2.14349568e-01f, 3.79229896e-02f, -8.54277387e-02f, -1.17806241e-01f, -6.23652935e-02f, -2.37183850e-02f, -1.47788003e-01f, -4.68416475e-02f,
  3.22756656e-02f, 1.67764630e-02f, 7.26533234e-02f, -4.53730486e-02f, -7.33513013e-02f, -1.60569716e-02f, -1.13627709e-01f, -9.59686264e-02f, -3.14739123e-02f, -8.51413086e-02f,
  -4.59469669e-02f, -1.77110080e-03f, -1.04446016e-01f, 6.56557381e-02f, -8.95493105e-02f, 4.63698898e-03f, 9.23964530e-02f, -1.66364643e-03f, -2.57054176e-02f, 1.20623246e-01f,
  -1.86489255e-03f, 7.42230639e-02f, 6.51438087e-02f, -5.06524071e-02f, -1.28456550e-02f, -6.32532910e-02f, 4.31149267e-02f, 5.84262721e-02f, -7.80721307e-02f, 1.53190987e-02f,
  -2.80119497e-02f, -6.13533258e-02f, 1.33533133e-02f, 3.38341631e-02f, 5.23568727e-02f, -1.23577612e-03f, -3.08386628e-02f, 2.74576284e-02f, 1.18659474e-02f, -3.49281705e-03f,
  1.23076653e-02f, 8.18278566e-02f, -2.24265689e-03f, -2.25242339e-02f, 6.78537935e-02f, 8.98233335e-03f, 8.81494433e-02f, -1.05367985e-03f, -7.78068006e-02f, -6.35826588e-02f,
  2.81467766e-01f, 4.76601422e-01f, 3.33780907e-02f, -1.16758950e-01f, 6.01156242e-02f, 1.32557855e-03f, 8.68568867e-02f, 4.85679805e-02f, 2.03345358e-01f, 8.07762891e-02f,
  -4.03069742e-02f, -3.37103121e-02f, 2.64452416e-02f, -4.84915003e-02f, 7.15271533e-02f, 1.23232044e-01f, 1.02119774e-01f, 4.87341844e-02f, 8.98220167e-02f, -5.45083694e-02f,
  -1.76213145e-01f, 2.39441320e-02f, 1.89987477e-02f, -5.29273562e-02f, -5.35840020e-02f, 1.20960353e-02f, 5.40335523e-03f, -8.53634924e-02f, 7.53795281e-02f, 1.01756521e-01f,
  -7.33451009e-01f, 6.16349638e-01f, 2.35264108e-01f, -6.02695644e-01f, 1.36721089e-01f, 4.95576970e-02f, -2.71967441e-01f, 1.00475140e-01f, -2.48472258e-01f, 2.59404689e-01f,
  -9.99278016e-03f, 5.23933209e-02f, 1.75153539e-01f, -1.88302413e-01f, -8.87290835e-01f, -2.85755366e-01f, -4.13704246e-01f, -2.15173781e-01f, -3.44091952e-02f, -4.48674858e-02f,
  -3.67455781e-01f, -2.08778158e-01f, -6.72742948e-02f, 3.05271417e-01f, 9.21386480e-02f, 1.61002412e-01f, -1.49649903e-01f, 4.39139366e-01f, 3.89273539e-02f, -1.18529182e-02f,
  -9.17235687e-02f, -7.60602653e-02f, 7.24150911e-02f, 4.74577956e-02f, -7.58303329e-02f, -7.73045197e-02f, 3.95864993e-02f, 2.24977154e-02f, -5.28356694e-02f, -5.83699420e-02f,
  1.65415220e-02f, 5.56266606e-02f, -2.60276701e-02f, -3.36497985e-02f, 5.46435006e-02f, 8.79622698e-02f, 9.10717994e-02f, 1.09744884e-01f, 8.59599560e-02f, 1.05988175e-01f,
  8.58908296e-02f, 1.24576733e-01f, 2.88853957e-03f, -2.44641472e-02f, -4.24084105e-02f, 6.40674680e-02f, -3.59085687e-02f, 3.99782322e-02f, -7.13580661e-03f, -3.73161174e-02f,
  -8.16503689e-02f, -7.25178272e-02f, -1.79679040e-02f, 1.59263927e-02f, -5.93805499e-03f, 3.99760939e-02f, -1.51419295e-02f, -4.19040173e-02f, -1.65551919e-02f, -1.06783900e-02f,
  -6.05453514e-02f, 3.28256213e-03f, -7.55330315e-03f, -3.43838222e-02f, -1.27678961e-01f, -6.61169961e-02f, 2.95726936e-02f, -7.26978807e-03f, -6.40951917e-02f, 2.69607101e-02f,
  1.06020816e-04f, -7.52117783e-02f, 4.79073972e-02f, -2.12935638e-02f, -2.13619117e-02f, -9.88139492e-03f, 5.43249696e-02f, 7.66713694e-02f, -8.46242532e-03f, -5.46688288e-02f,
  -2.49864399e-01f, -2.39875257e-01f, 1.08443173e-02f, 5.34064621e-02f, 1.03183482e-02f, 5.73309474e-02f, -6.88590109e-02f, 3.40409651e-02f, -6.78082705e-02f, -2.05700453e-02f,
  4.16263118e-02f, -3.60727981e-02f, -4.71179150e-02f, -4.10708226e-03f, -8.78148302e-02f, -1.11578349e-02f, -5.11718877e-02f, -9.40451249e-02f, -8.26902315e-02f, 5.27885277e-03f,
  2.35383362e-02f, 5.00893034e-03f, -5.04009686e-02f, 1.02792690e-02f, -5.69240749e-02f, -2.86701899e-02f, -7.85358101e-02f, 9.00105163e-02f, 7.50675518e-03f, 2.16038022e-02f,
  5.54001033e-01f, 2.77617604e-01f, 6.21469378e-01f, 5.31513512e-01f, 3.73497233e-02f, 8.91739056e-02f, 6.87903613e-02f, 1.38136551e-01f, 7.18570590e-01f, -1.13195673e-01f,
  -3.31838310e-01f, 4.70711261e-01f, -3.29688817e-01f, 1.94918349e-01f, -3.71374220e-01f, -3.34938824e-01f, 8.38691089e-03f, 5.20582087e-02f, 2.32775345e-01f, 1.52423456e-01f,
  8.53384510e-02f, -5.66113412e-01f, -8.26696903e-02f, -3.65967780e-01f, 2.27121100e-01f, 2.15871692e-01f, -5.67906201e-01f, -2.38223583e-01f, -8.78962055e-02f, -1.99258193e-01f,
  -8.35489929e-02f, 9.88132134e-02f, 1.36577666e-01f, 1.12798184e-01f, 3.63475904e-02f, 5.06871566e-02f, 1.59709547e-02f, -8.32116604e-02f, 5.48946261e-02f, 5.19918799e-02f,
  2.94614136e-02f, 5.66549320e-03f, 1.06720380e-01f, -2.50622202e-02f, 1.23410903e-01f, 1.54467300e-01f, 1.25296727e-01f, 1.54656515e-01f, 1.37634039e-01f, 1.60968408e-01f,
  2.26769418e-01f, 1.80487603e-01f, 1.02349065e-01f, -7.04307249e-03f, -2.25581117e-02f, 5.27245291e-02f, 1.03323236e-01f, -5.74938208e-02f, 9.77514386e-02f, 1.46631747e-01f,
  -4.36276123e-02f, -5.45212589e-02f, -7.95312598e-03f, 2.76564062e-02f, 2.87564402e-03f, -1.24030337e-02f, -4.10344079e-02f, -5.46539426e-02f, 4.72731106e-02f, 3.49640206e-04f,
  2.00916268e-02f, 3.01312264e-02f, 2.71993671e-02f, 9.23362449e-02f, 2.45776419e-02f, 1.01516910e-01f, -1.86228137e-02f, 1.77821610e-02f, 3.15509178e-02f, 5.49292713e-02f,
  -9.58716720e-02f, -5.27324677e-02f, -7.02758580e-02f, -1.78725552e-02f, 3.12789008e-02f, -1.13781290e-02f, 5.41705377e-02f, 1.63135707e-01f, -1.41901588e-02f, -1.86945781e-01f,
  -2.00448215e-01f, -2.25753576e-01f, -5.20225726e-02f, -3.62488814e-02f, -6.06932007e-02f, 1.01509308e-02f, -6.85373917e-02f, 9.00435001e-02f, -4.79246750e-02f, 1.09640816e-02f,
  -4.67434973e-02f, -7.55074155e-03f, -6.64240718e-02f, -4.94755283e-02f, -9.48158652e-02f, -1.94949266e-02f, -9.35550556e-02f, -1.05128698e-01f, -1.25502124e-01f, -1.22112192e-01f,
  -3.45371142e-02f, -1.07132398e-01f, 1.94401164e-02f, -4.41640019e-02f, 4.15875278e-02f, -7.82482773e-02f, 2.18282491e-02f, 5.39417379e-02f, -6.96028173e-02f, -3.16597670e-02f,
  6.01337969e-01f, -1.61429957e-01f, -2.44971916e-01f, -4.61098403e-02f, 2.71676511e-01f, 2.57778436e-01f, 1.68781444e-01f, 5.88589981e-02f, -3.40912879e-01f, -7.86742270e-02f,
  3.35561633e-01f, -3.20206359e-02f, -1.68065771e-01f, 3.62540215e-01f, 4.84402776e-01f, -1.16174750e-01f, 3.70585889e-01f, 1.83298767e-01f, -1.09198675e-01f, 1.58147141e-01f,
  6.22738414e-02f, 6.14363313e-01f, -6.75684959e-02f, 1.11387298e-01f, 3.64863008e-01f, -1.83712438e-01f, 1.11961991e-01f, -9.93336812e-02f, 2.49463856e-01f, 1.80459648e-01f,
  8.11465457e-02f, -6.21000454e-02f, 5.54475933e-02f, -1.01745941e-01f, -1.79536399e-02f, 6.09907135e-02f, -7.07391230e-03f, 3.76415327e-02f, -8.65673646e-02f, -1.22777587e-02f,
  3.18977400e-03f, 1.11633874e-02f, 6.98122382e-02f, -3.20540555e-02f, 7.25887939e-02f, -7.65912607e-02f, -6.36339113e-02f, -5.61452135e-02f, -1.14040710e-01f, 1.25794113e-01f,
  -6.58341423e-02f, -1.95184927e-02f, 5.26717454e-02f, -1.35232732e-01f, -7.21132606e-02f, 2.42780093e-02f, -1.02371357e-01f, 2.11160984e-02f, 1.80028602e-02f, 1.62638873e-02f,
  1.11268803e-01f, 1.51916351e-02f, 4.56071384e-02f, 4.14081067e-02f, 9.17050838e-02f, -6.60427958e-02f, 6.31464720e-02f, -3.35409231e-02f, -4.58892025e-02f, 1.47651266e-02f,
  -6.87438399e-02f, -2.28816904e-02f, -6.05142675e-03f, 2.96896882e-02f, 7.71106854e-02f, -1.26194051e-02f, 3.02191405e-03f, 4.16087620e-02f, -8.33003968e-02f, -6.52432367e-02f,
  -7.60735273e-02f, 8.14396366e-02f, -1.57685112e-02f, -9.99152660e-03f, 1.53442137e-02f, -1.12023135e-03f, 3.35263051e-02f, 7.79698640e-02f, -1.19378828e-01f, -4.92471159e-02f,
  -8.95744860e-02f, 8.05666596e-02f, -1.43379703e-01f, -2.82908902e-02f, -3.11013088e-02f, 1.79292768e-01f, -2.93572694e-02f, 1.05118349e-01f, 3.55546921e-02f, 6.39737844e-02f,
  2.69650724e-02f, -2.36104392e-02f, -3.65310200e-02f, 4.25436571e-02f, -7.99056962e-02f, 1.51258737e-01f, -2.92212944e-02f, -3.11230291e-02f, 1.12192556e-02f, 2.29649879e-02f,
  -3.23182866e-02f, 2.48287921e-03f, -4.00846936e-02f, -8.04926232e-02f, 4.29763831e-02f, -4.87562036e-03f, 3.70634608e-02f, -9.75709781e-02f, 4.33595069e-02f, -7.15937465e-02f,
  -1.03402242e-01f, -5.00249982e-01f, -7.98040405e-02f, 3.52002293e-01f, 1.90326255e-02f, 2.05984011e-01f, 4.32666153e-01f, -2.83524960e-01f, -3.03078830e-01f, -4.06149440e-02f,
  2.83294082e-01f, 2.06116511e-05f, -2.10421890e-01f, 5.69177032e-01f, 2.52552271e-01f, -9.23923105e-02f, 3.74194026e-01f, 3.16199899e-01f, -2.48829991e-01f, -2.51351535e-01f,
  -1.39522851e-01f, 3.15181583e-01f, 1.38066545e-01f, -9.52576622e-02f, 1.44821316e-01f, -1.52112678e-01f, 6.95449561e-02f, -1.93179667e-01f, 3.89071256e-01f, 3.01788956e-01f,
  -3.85265760e-02f, -1.58454344e-01f, -2.61690561e-03f, 1.93017200e-02f, -5.05431704e-02f, 5.57290278e-02f, 7.80464336e-02f, 2.28237286e-01f, 8.62752087e-03f, -1.48848414e-01f,
  -2.01691296e-02f, -7.34195439e-03f, 3.78298536e-02f, 1.37736415e-02f, -6.70796558e-02f, -5.97907007e-02f, -8.55878666e-02f, 1.23607079e-02f, -8.44796970e-02f, -9.98273566e-02f,
  -7.54529238e-02f, 6.02112822e-02f, -3.39565575e-02f, 9.12488401e-02f, 3.63738053e-02f, 5.54700419e-02f, 7.06304163e-02f, 2.41544992e-02f, -7.97626153e-02f, 1.60515949e-03f,
  -7.86089003e-02f, 1.60032883e-02f, -7.09955171e-02f, 3.87192145e-02f, -8.96628108e-03f, 9.13504511e-02f, 3.59388627e-02f, 8.27305168e-02f, -3.35704014e-02f, -2.89040338e-03f,
  2.75390595e-03f, 1.58970635e-02f, 3.84403840e-02f, 5.94729520e-02f, 5.69801927e-02f, 5.74771129e-02f, 4.18308452e-02f, 1.76668949e-02f, 4.44447808e-03f, 3.69890258e-02f,
  -6.45870809e-03f, -2.56612562e-02f, -2.58527324e-02f, 6.66346997e-02f, 3.59281972e-02f, -4.15384546e-02f, 4.15639989e-02f, -6.24929704e-02f, 2.18814258e-02f, 3.13147902e-02f,
  -2.30180487e-01f, -4.37399626e-01f, -3.97907756e-02f, 3.97240231e-03f, 6.56516990e-03f, -3.52863371e-02f, -2.43166611e-02f, -1.08264878e-01f, -1.54260084e-01f, 1.26628894e-02f,
  -2.36798469e-02f, 3.56006261e-04f, -2.30028164e-02f, 3.55687737e-02f, 7.34279901e-02f, -1.12155542e-01f, 7.63516277e-02f, 5.22852689e-02f, 2.87412181e-02f, -9.16698202e-03f,
  -2.56425198e-02f, -3.57903019e-02f, 6.36652410e-02f, -4.14985418e-02f, 4.86348011e-02f, -5.31279743e-02f, -7.57404491e-02f, -4.36435416e-02f, 9.01217610e-02f, 1.56507380e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  4.81172144e-01f, 3.16282302e-01f, 6.04434311e-01f, 2.12165475e-01f, 2.89426625e-01f, 7.36646891e-01f, 7.88487673e-01f, 7.49371767e-01f, 2.89160341e-01f, 3.82030368e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -7.46911094e-02f, 6.75882697e-02f, -1.76633030e-01f, 5.86191714e-01f, 3.07267934e-01f, 2.99440444e-01f, -5.04462779e-01f, 4.50004011e-01f, 3.19231927e-01f, -4.74856228e-01f,
  9.17735577e-01f, 5.89615226e-01f, -1.75512999e-01f, -6.21598721e-01f, -3.57156664e-01f, 6.47797644e-01f, -9.66100916e-02f, 6.12948418e-01f, -3.64924103e-01f, -5.84133089e-01f,
  -6.54504478e-01f, 1.02623725e+00f, 1.25549659e-01f, 8.20358321e-02f, -3.55490237e-01f, 1.40762225e-01f, -2.16025338e-01f, 6.23701811e-01f, -5.01378059e-01f, -6.35718644e-01f,
  1.21106052e+00f, 1.15303054e-01f, 1.31412342e-01f, -6.90485656e-01f, 1.96049675e-01f, -2.59204477e-01f, -6.08767033e-01f, -8.64785314e-01f, 2.12563053e-01f, 4.42277580e-01f,
  -4.18937653e-01f, -4.63258207e-01f, -3.61257464e-01f, -6.30351961e-01f, -1.56708315e-01f, -4.78201985e-01f, 6.21568143e-01f, 1.09464288e+00f, -4.90705848e-01f, -4.63490754e-01f,
  3.21382076e-01f, 3.75347376e-01f, -4.67429757e-01f, 3.36514488e-02f, -2.44887009e-01f, -5.69556177e-01f, -5.41619599e-01f, -2.24766597e-01f, 8.75250876e-01f, -3.43622565e-02f,
  1.19715679e+00f, -2.43946433e-01f, -2.56910145e-01f, -6.79192021e-02f, 4.95907664e-01f, 5.70676774e-02f, 4.17013317e-01f, 6.95432186e-01f, -3.81375432e-01f, -1.59913644e-01f,
  -6.55162275e-01f, 3.31837654e-01f, 1.10666990e+00f, 1.41377822e-01f, -5.70306003e-01f, 3.51659328e-01f, 7.20664978e-01f, -7.84750469e-03f, -1.85753673e-01f, -6.30298316e-01f,
  5.68054855e-01f, -1.25879407e-01f, 5.05504131e-01f, -5.34608364e-01f, 7.92177141e-01f, 8.30858111e-01f, -4.85850722e-01f, -3.62517744e-01f, -3.55585426e-01f, -1.27641425e-01f,
  -3.83706428e-02f, 1.31184685e+00f, -7.10153162e-01f, 4.19990063e-01f, -2.27325514e-01f, -3.10884356e-01f, -4.34056878e-01f, 9.20403421e-01f, 4.14757848e-01f, -1.16397941e+00f,
  -7.79328942e-02f, -1.07453740e+00f, -3.53993952e-01f, -4.64500725e-01f, -2.56111771e-01f, -2.60492444e-01f, -4.70074862e-01f, -2.55379766e-01f, -6.19804144e-01f, 1.13294554e+00f,
  7.65052363e-02f, 5.00179641e-02f, 1.05533600e-01f, -2.09751904e-01f, -5.83971798e-01f, -2.57215083e-01f, -1.75563931e-01f, -2.63006777e-01f, -2.34214455e-01f, -3.46777529e-01f,
  -1.40007257e-01f, 1.05920982e+00f, 8.03533852e-01f, 2.14961141e-01f, -3.15361708e-01f, -1.49566934e-01f, -4.40437376e-01f, -4.07825500e-01f, -1.46188334e-01f, -7.28424415e-02f,
  -9.08019468e-02f, 4.92058337e-01f, 7.58200824e-01f, 4.36131328e-01f, 5.61534941e-01f, 1.28910565e+00f, -4.48531032e-01f, -2.67529219e-01f, -4.70241845e-01f, -1.24899633e-01f,
  -5.23291945e-01f, -3.04465592e-01f, 1.37467265e-01f, -3.28463107e-01f, -4.85242546e-01f, -4.44544852e-01f, -1.34800613e-01f, -7.88752079e-01f, 7.77846515e-01f, -5.49024880e-01f,
  -3.80746961e-01f, -3.40872705e-01f, 1.35075331e+00f, 1.29597113e-01f, -4.36070174e-01f, -2.08105102e-01f, -3.00752372e-01f, -2.52914280e-01f, 1.46163240e-01f, 5.25724769e-01f,
  1.18320554e-01f, 1.85744733e-01f, 1.93675719e-02f, 1.91468999e-01f, -2.29028717e-01f, -2.87383676e-01f, 1.37010014e+00f, -2.11459979e-01f, -4.22411054e-01f, 1.68533400e-01f,
  -3.61503184e-01f, -2.20689356e-01f, 6.02626860e-01f, -4.63768691e-01f, -3.15383762e-01f, -4.67251539e-01f, 3.65227818e-01f, -1.87150866e-03f, -2.08869666e-01f, 1.75864995e-01f,
  2.62730330e-01f, 6.39563799e-01f, -2.38737196e-01f, -2.04534158e-01f, -4.60866243e-01f, -1.01293542e-03f, -4.02305752e-01f, -7.10842788e-01f, 6.36239171e-01f, 1.21751070e+00f,
  -2.79792279e-01f, -1.79461077e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.92909145e-01f, 4.19853330e-02f, -2.96182603e-01f, -3.28007996e-01f, 1.10852130e-01f, 3.08030844e-01f, 6.39740169e-01f, -1.31501079e-01f, -4.22282368e-01f, -9.79465321e-02f,
  -1.73933789e-01f, -1.13770694e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    