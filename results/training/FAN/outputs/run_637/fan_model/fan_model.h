/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.52804846e-01f, -2.96580017e-01f, 3.39188010e-01f, 7.66996071e-02f, -1.16074048e-01f, -1.78331416e-02f, -7.29786232e-02f, -4.94237803e-02f, 8.72869918e-04f, -1.19871609e-01f,
  -3.36505234e-01f, -1.58105478e-01f, -5.20094074e-02f, 8.53356794e-02f, 8.48573893e-02f, 1.70120940e-01f, 2.36985967e-01f, 3.22498769e-01f, 1.72334015e-01f, -1.47608101e-01f,
  -2.10248798e-01f, -1.75663888e-01f, 5.87588437e-02f, -2.06865016e-02f, -4.26750667e-02f, -6.49859086e-02f, 9.35171992e-02f, -5.63978665e-02f, -1.33750394e-01f, 3.54150236e-02f,
  1.40401736e-01f, -2.07496449e-01f, 6.98119123e-03f, -1.44514009e-01f, -6.88689649e-02f, -2.33185086e-02f, -7.33595714e-02f, 5.20697460e-02f, -8.00882280e-02f, 2.53287442e-02f,
  -1.66297242e-01f, -1.32774010e-01f, -6.51382729e-02f, -1.47703841e-01f, -5.41666970e-02f, -2.47447435e-02f, -3.62941846e-02f, 2.27812119e-02f, 4.88906503e-02f, 2.87366416e-02f,
  -2.36360669e-01f, -1.19127370e-01f, 3.81615274e-02f, -6.57384098e-02f, -5.36706001e-02f, -1.51878387e-01f, -1.10558189e-01f, -2.24184114e-02f, -1.03651181e-01f, 1.25806089e-02f,
  -2.49216985e-02f, 2.98818201e-02f, 6.87108636e-02f, -4.76557016e-02f, 4.60427329e-02f, 5.66363148e-02f, 6.21457212e-02f, 1.82694886e-02f, 1.07035032e-02f, 1.35557577e-01f,
  4.55248877e-02f, 4.88950461e-02f, 4.15895917e-02f, 3.30359489e-02f, 1.01550363e-01f, 5.01688756e-02f, 1.11026525e-01f, 1.42695671e-02f, -2.84511056e-02f, 8.61484408e-02f,
  -4.52263951e-02f, 6.09827153e-02f, 5.62086664e-02f, 6.81632236e-02f, 4.94614653e-02f, 1.05186664e-01f, 5.56364916e-02f, -1.29405549e-02f, 8.48042145e-02f, 1.08122695e-02f,
  -5.43557992e-03f, -2.02651113e-01f, -2.96261515e-02f, -6.14473447e-02f, -1.78517010e-02f, 2.33169962e-02f, -1.02923952e-01f, -9.35280472e-02f, -1.30309882e-02f, -1.19661435e-01f,
  -4.69179116e-02f, 5.16825728e-02f, -8.80916193e-02f, -7.63905747e-03f, -1.54416943e-02f, -6.60344362e-02f, -1.02489181e-01f, 6.24553263e-02f, -6.14013113e-02f, -4.43376973e-02f,
  8.17560405e-03f, 1.04655951e-01f, 1.78772375e-01f, 1.32018372e-01f, -2.54858118e-02f, 8.56630206e-02f, -2.13870732e-03f, 1.71289407e-02f, 1.12216577e-01f, 1.11304559e-01f,
  3.28973919e-01f, -4.22352940e-01f, -1.09249331e-01f, 1.67488962e-01f, -7.84744844e-02f, -3.70001912e-01f, -4.87350971e-01f, -2.45944217e-01f, 7.47828931e-02f, -1.41691282e-01f,
  -2.67271429e-01f, -4.76376526e-02f, -7.76908621e-02f, -2.34721869e-01f, -1.56784907e-01f, -1.98871687e-01f, 8.72832388e-02f, 2.24520243e-03f, -1.50907084e-01f, -2.16292828e-01f,
  -1.89082205e-01f, 1.26491293e-01f, 1.96378291e-01f, -1.76745579e-02f, 1.03374082e-03f, 1.86521020e-02f, -3.00030373e-02f, -2.39284970e-02f, -2.53784567e-01f, 7.52896518e-02f,
  -1.66700959e-01f, -1.19715802e-01f, -8.03028941e-02f, 8.49283673e-03f, 8.56670514e-02f, -4.55423705e-02f, 1.17418868e-02f, 2.15440448e-02f, -1.03516905e-02f, -1.48031469e-02f,
  4.83040139e-02f, -4.28321213e-02f, 8.90313163e-02f, 4.41296622e-02f, -6.99507147e-02f, -2.63759643e-02f, 2.58627962e-02f, 5.60484231e-02f, -7.40201026e-02f, -1.18944518e-01f,
  -2.46236715e-02f, -2.60266643e-02f, 1.29659856e-02f, -6.91718236e-02f, -1.34057775e-01f, 9.19257943e-03f, -8.35186616e-02f, -5.25564402e-02f, -5.92761338e-02f, -5.54676801e-02f,
  -4.48349304e-03f, 2.37336326e-02f, 3.50228809e-02f, -4.30979319e-02f, -6.98270202e-02f, 1.88464634e-02f, 2.05086302e-02f, -2.89202444e-02f, 1.75059438e-02f, -1.20912232e-02f,
  -1.67888388e-01f, -4.83195148e-02f, 1.94030218e-02f, 1.41880140e-02f, -6.58688485e-04f, -6.66561052e-02f, -4.37673368e-02f, -3.13718282e-02f, 5.07726818e-02f, 1.22473482e-02f,
  -4.38965634e-02f, -6.23853840e-02f, -1.42027112e-02f, -3.29652838e-02f, -3.01039238e-02f, -2.58181505e-02f, 3.31371985e-02f, -3.31145823e-02f, -1.91100687e-03f, -2.88854539e-02f,
  7.27768540e-02f, -4.27364707e-02f, -6.31118845e-03f, -7.03018755e-02f, 9.79691073e-02f, 9.91454720e-02f, 1.37962280e-02f, -1.32504310e-02f, 9.32284817e-02f, -3.27681862e-02f,
  -1.87108722e-02f, 6.60664355e-03f, -3.07816304e-02f, 6.91525489e-02f, 3.15008461e-02f, 5.97272813e-02f, 6.02370873e-02f, -1.48160703e-04f, -3.48352119e-02f, 1.45305786e-02f,
  5.89672662e-02f, 7.96410367e-02f, 5.17832953e-03f, -9.50479954e-02f, -1.37024438e-02f, 5.37341908e-02f, -3.92673872e-02f, -6.58743680e-02f, 2.88256425e-02f, -3.45077664e-02f,
  -2.52018929e-01f, 2.97158808e-01f, 8.33854973e-02f, -2.58782990e-02f, 1.91900179e-01f, 2.07010344e-01f, 5.25061190e-01f, 2.04081833e-01f, -3.70196961e-02f, 9.86799672e-02f,
  -9.92120728e-02f, -3.71859014e-01f, -2.88766623e-01f, -2.58601815e-01f, -2.04894729e-02f, 3.14379513e-01f, 2.77923673e-01f, -1.23152630e-02f, -2.48285636e-01f, -4.11144942e-02f,
  4.89890501e-02f, 1.43626735e-01f, -9.94388089e-02f, -2.82106604e-02f, -8.79282728e-02f, -1.47275567e-01f, 1.73404664e-01f, 7.53985643e-02f, 2.15492863e-02f, 9.94001776e-02f,
  -2.16305614e-01f, 6.03924431e-02f, -5.87816983e-02f, -4.30507995e-02f, 4.63177860e-02f, -2.80240085e-02f, 1.48771973e-02f, 1.69708226e-02f, 2.44732816e-02f, 8.60492736e-02f,
  -6.19678712e-03f, 7.17752962e-04f, -1.05488878e-02f, -2.67442148e-02f, 3.98087278e-02f, -3.19619812e-02f, 5.95504940e-02f, -1.72781069e-02f, 6.82670921e-02f, 2.41457503e-02f,
  3.11454125e-02f, 1.16922446e-01f, 1.40608788e-01f, 8.45753849e-02f, 6.09435849e-02f, -2.50812545e-02f, 2.46923752e-02f, -6.17345497e-02f, 7.69119859e-02f, -3.73843946e-02f,
  -3.12836026e-03f, 2.63676196e-02f, 2.23136432e-02f, -6.20030705e-03f, -7.47849373e-03f, 4.50468477e-04f, 9.62129910e-04f, 3.77571918e-02f, -5.16870059e-02f, -3.33758518e-02f,
  -8.72473270e-02f, -2.28503663e-02f, 1.15199876e-03f, 7.59754851e-02f, -6.91908300e-02f, 6.34162053e-02f, -3.60014625e-02f, -1.43713439e-02f, -7.42637366e-02f, 4.90065180e-02f,
  -8.52387697e-02f, 4.13349085e-03f, -1.75145492e-02f, -6.24089278e-02f, 2.31155241e-03f, -5.07411510e-02f, -9.99751966e-03f, -5.56383394e-02f, -4.13022675e-02f, -1.00776441e-02f,
  -2.74305884e-02f, 8.79835859e-02f, -5.46712577e-02f, -4.44116183e-02f, 6.55351323e-04f, -5.87142259e-02f, -7.47385398e-02f, -5.74530214e-02f, 4.50911038e-02f, -4.32200693e-02f,
  -1.47316922e-02f, -2.13461043e-03f, 2.79512070e-02f, 1.15657095e-02f, -3.22819725e-02f, -4.24955301e-02f, -1.23397270e-02f, -6.91453293e-02f, 8.63207951e-02f, 4.14402671e-02f,
  1.03004470e-01f, -3.94547172e-03f, -2.16139257e-02f, -2.00669114e-02f, 9.93014500e-03f, -4.62585464e-02f, 5.06370282e-03f, 2.97373794e-02f, -4.45990711e-02f, 1.34927288e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.76593292e-01f, -1.57155007e-01f, 1.12937381e-02f, 1.42562166e-01f, -1.92951933e-01f, -9.49111879e-02f, 3.07630271e-01f, 1.01140969e-01f, -3.63078490e-02f, 1.93409458e-01f,
  -2.44112015e-01f, -5.99620879e-01f, -3.24157059e-01f, -2.54730195e-01f, -1.37658864e-01f, 5.12090385e-01f, 3.43388110e-01f, 3.66878174e-02f, -1.85558259e-01f, -1.15086578e-01f,
  -2.07443032e-02f, 1.66170299e-01f, -8.67641065e-03f, -1.00576967e-01f, 2.70002894e-02f, -1.94763809e-01f, 1.01192154e-01f, -1.77462548e-01f, -2.40421191e-01f, 6.03938252e-02f,
  2.08569169e-01f, -1.46805018e-01f, -5.41022532e-02f, -1.79431260e-01f, -4.03228812e-02f, 8.24958365e-03f, 1.63643435e-03f, 2.86575016e-02f, -7.90680945e-02f, 3.61350477e-02f,
  -1.67179018e-01f, -2.52712131e-01f, -2.76010215e-01f, -4.24194848e-03f, -2.17416398e-02f, -1.34532740e-02f, 1.44552246e-01f, -1.20114796e-01f, -1.09552868e-01f, -1.38211772e-01f,
  -2.49204949e-01f, -1.52196750e-01f, -9.99227017e-02f, -1.61497667e-01f, -1.85706005e-01f, -2.88006723e-01f, -2.03852132e-01f, -2.92822510e-01f, -2.20031381e-01f, 3.01264793e-01f,
  -6.51182011e-02f, 2.89121382e-02f, -1.63749885e-02f, 5.72606958e-02f, 1.18763886e-01f, -1.71582494e-02f, -5.53918444e-02f, -1.19843014e-01f, -6.13724173e-04f, 1.72475606e-01f,
  -7.93525130e-02f, 1.22680686e-01f, -2.77948901e-02f, 1.04617029e-01f, -3.38875465e-02f, 5.86492904e-02f, 2.67816540e-02f, 9.24117640e-02f, -1.72091033e-02f, 5.33950552e-02f,
  -1.35938913e-01f, 2.17432249e-02f, -6.94865510e-02f, 1.02681018e-01f, -1.59724485e-02f, -7.61133283e-02f, 9.59938094e-02f, -3.61153334e-02f, -8.22031498e-03f, 7.35155866e-02f,
  3.28240216e-01f, -2.55845100e-01f, 2.94681221e-01f, 2.39623599e-02f, -6.27194345e-03f, -1.46752402e-01f, 4.47551683e-02f, -5.01890667e-02f, -1.05745502e-01f, -3.69734801e-02f,
  -1.87564969e-01f, -1.62178472e-01f, -3.14010493e-02f, 5.89432614e-03f, 3.90973017e-02f, 7.74585530e-02f, 7.06837550e-02f, -5.28223775e-02f, -3.29748429e-02f, 1.94285527e-01f,
  1.82727784e-01f, 2.37932056e-01f, 2.86798745e-01f, 1.49573654e-01f, 3.89620960e-02f, 1.40900895e-01f, 9.93382037e-02f, 5.32521643e-02f, 7.39685670e-02f, 6.31266057e-01f,
  2.84006238e-01f, 3.35523427e-01f, -8.82018566e-01f, 9.16649625e-02f, -3.22468430e-01f, -3.22488397e-01f, 4.64304723e-02f, 2.90594459e-01f, 1.61498010e-01f, 1.71400756e-01f,
  -5.94948828e-02f, -2.17807576e-01f, -3.99083823e-01f, -3.62144738e-01f, -2.70951390e-01f, -3.20439577e-01f, -4.94670749e-01f, -6.66699946e-01f, -6.65608585e-01f, 6.29329085e-02f,
  2.06126973e-01f, 8.13849270e-02f, -1.47263473e-02f, -1.25360802e-01f, -7.55060650e-03f, -2.92636007e-01f, -2.75140196e-01f, -2.15565249e-01f, -2.76446104e-01f, -4.22173619e-01f,
  -5.00194430e-01f, 7.60168629e-03f, -2.66237289e-01f, -6.27875840e-03f, -1.28591180e-01f, -1.06437162e-01f, -2.28899550e-02f, -8.98391530e-02f, 5.03262691e-02f, -3.04421559e-02f,
  -2.76243031e-01f, 9.46944486e-03f, -2.43096367e-01f, -2.13100627e-01f, -9.15204212e-02f, -1.43129155e-01f, -6.60323352e-02f, -1.74670532e-01f, -1.25357255e-01f, -8.08300227e-02f,
  -4.66915071e-02f, -3.53876680e-01f, -2.70745486e-01f, 2.72585396e-02f, -1.86173782e-01f, -3.74609381e-01f, -1.39547437e-01f, -2.67682582e-01f, -2.67868668e-01f, 3.14798474e-01f,
  3.93625647e-02f, -3.65043841e-02f, -7.00427443e-02f, 1.54024184e-01f, 2.53534228e-01f, -4.86817770e-02f, 1.69443432e-02f, 5.39647881e-03f, -1.40109127e-02f, 1.46105394e-01f,
  3.88062671e-02f, -6.17223494e-02f, 3.59898545e-02f, 2.88027432e-02f, -1.44621044e-01f, -1.75804973e-01f, -1.00669846e-01f, 1.78107042e-02f, 3.01195271e-02f, -6.45323545e-02f,
  -3.49198282e-02f, -5.86744323e-02f, -6.13743253e-02f, 1.35743646e-02f, -1.81775451e-01f, -9.37408656e-02f, -4.45749238e-02f, 7.25006759e-02f, 1.80465523e-02f, -3.14989835e-02f,
  3.30987066e-01f, -1.69020861e-01f, 1.19621912e-03f, -1.16258167e-01f, -1.01308778e-01f, -8.71878937e-02f, 2.89116912e-02f, 4.81244549e-02f, -4.23702337e-02f, -2.94636358e-02f,
  -9.14420933e-02f, 1.48428723e-01f, -6.75235465e-02f, -1.34013277e-02f, -1.36136916e-02f, 2.83191390e-02f, 6.85612950e-03f, -1.86091498e-01f, 1.05148191e-02f, 1.84101149e-01f,
  1.97955713e-01f, 7.88013637e-02f, 1.16520829e-01f, 6.07650094e-02f, -2.14600544e-02f, -1.63855180e-01f, -2.70254053e-02f, 6.49723262e-02f, -1.35651767e-01f, 5.74460566e-01f,
  -1.09351806e-01f, 1.20703772e-01f, 1.09902710e-01f, 3.79256785e-01f, 2.17170138e-02f, -1.54916197e-02f, 1.20333351e-01f, 2.33456582e-01f, 1.85434550e-01f, 4.52176705e-02f,
  -2.52591908e-01f, 2.00072434e-02f, 2.80429721e-01f, 3.31449628e-01f, 2.79701829e-01f, 1.35275915e-01f, 3.55554730e-01f, 2.80820578e-01f, 1.21736780e-01f, 1.19977511e-01f,
  1.20302036e-01f, 1.02424659e-01f, -1.82356834e-02f, 2.87007213e-01f, 1.07822150e-01f, 2.55507797e-01f, 8.29541832e-02f, -1.01101249e-01f, 1.01129934e-01f, 3.49626392e-01f,
  -1.33846581e-01f, -2.54640013e-01f, 1.23552978e-02f, -2.69404471e-01f, -2.75378913e-01f, 8.50480720e-02f, -1.05594300e-01f, -1.23952337e-01f, 5.46408072e-02f, 8.52859765e-02f,
  -1.96605995e-01f, -1.59314007e-01f, -9.66654271e-02f, 3.47341783e-02f, -1.44616038e-01f, -3.05303276e-01f, -1.35591738e-02f, 1.86110824e-01f, 1.26532733e-01f, -2.38595441e-01f,
  7.15683848e-02f, -5.79631150e-01f, -5.93663990e-01f, -4.01319824e-02f, -2.51561459e-02f, -4.36724648e-02f, -2.45427474e-01f, -2.24009186e-01f, -3.95948812e-02f, -2.09046230e-01f,
  5.29264100e-02f, -1.46062464e-01f, -1.07732773e-01f, 9.17590335e-02f, 1.40507147e-01f, 9.64569822e-02f, 2.34888077e-01f, 1.14872411e-01f, 6.37723804e-02f, -1.60618186e-01f,
  1.62450343e-01f, -5.63865602e-02f, -2.81001185e-03f, -4.00827490e-02f, 3.30382064e-02f, -1.49925426e-01f, 2.85764411e-03f, 8.26510936e-02f, -8.03565606e-02f, -2.79572979e-02f,
  -4.68549915e-02f, 1.51283517e-02f, -5.08226790e-02f, 7.36668110e-02f, 3.35060693e-02f, 4.06484082e-02f, 2.04405207e-02f, -4.49817181e-02f, -1.09545037e-01f, -1.66052163e-01f,
  -1.05338365e-01f, -8.77013709e-03f, -9.55134407e-02f, 7.43331164e-02f, -4.09263819e-02f, 9.79933292e-02f, 1.25033379e-01f, 1.30402893e-01f, 8.59962627e-02f, 2.36552283e-01f,
  -2.32928902e-01f, 1.78280219e-01f, 3.49436440e-02f, 1.78867429e-02f, 2.17334833e-02f, -1.46230072e-01f, 3.75714898e-02f, 1.89243495e-01f, 1.32989854e-01f, -2.66024739e-01f,
  3.33766006e-02f, -2.38649353e-01f, -3.69893014e-01f, 1.42394402e-03f, -2.96239518e-02f, 6.40128702e-02f, -2.35928342e-01f, -2.10606247e-01f, -1.83367968e-01f, -3.40896875e-01f,
  -5.56344748e-01f, 1.77921221e-01f, -8.66013944e-01f, 1.37113094e-01f, 2.97046393e-01f, 8.77975374e-02f, -6.33502677e-02f, -1.76572770e-01f, 8.38903934e-02f, 9.13484171e-02f,
  1.70663863e-01f, 1.81313738e-01f, 2.44361628e-02f, -9.21613127e-02f, -1.41247451e-01f, -1.19584734e-02f, 5.50333411e-02f, -3.28856349e-01f, -1.26290217e-01f, 2.12028891e-01f,
  5.22539675e-01f, 2.59264946e-01f, -2.33125523e-01f, -7.22701177e-02f, 1.98151320e-01f, 2.33389571e-01f, -1.10644825e-01f, 6.17343225e-02f, 1.63366079e-01f, 2.42063239e-01f,
  -3.04540783e-01f, -3.75534624e-01f, -1.36380881e-01f, 1.98898509e-01f, -1.21843830e-01f, -2.67687023e-01f, -1.14518419e-01f, -1.76211834e-01f, 9.46935937e-02f, -5.78544550e-02f,
  9.67935398e-02f, 1.19397687e-02f, 1.59656450e-01f, 8.25451985e-02f, 1.42407268e-01f, -6.48621768e-02f, -3.49821746e-01f, -4.58201289e-01f, -4.31825250e-01f, -3.04593712e-01f,
  5.15993714e-01f, 2.21138045e-01f, -5.01504302e-01f, -2.93490469e-01f, -3.15644324e-01f, 1.56178661e-02f, -2.95824260e-01f, -2.51938641e-01f, -5.56064725e-01f, -2.90500402e-01f,
  -9.20508057e-02f, -3.41140293e-02f, 7.43943499e-03f, -7.38310218e-02f, 3.58772017e-02f, 4.48461287e-02f, 1.23168103e-01f, 1.31080315e-01f, 1.02810040e-01f, -1.20538257e-01f,
  -7.52703175e-02f, -9.00703147e-02f, -5.42325061e-03f, 1.81300938e-02f, 2.04463780e-01f, 1.68298427e-02f, -1.79077964e-02f, 2.08882987e-02f, -1.14471922e-02f, -4.78582680e-02f,
  3.64631377e-02f, -1.65713802e-01f, 2.20725372e-01f, 7.99744576e-02f, 4.05069143e-02f, -1.19461894e-01f, 6.56434745e-02f, -4.93486375e-02f, -2.37979125e-02f, -2.87501980e-03f,
  6.65373281e-02f, 4.65843687e-03f, -2.07346100e-02f, -9.62243900e-02f, 3.50417681e-02f, 8.46801698e-02f, 1.63873181e-01f, 2.70810090e-02f, 5.75802773e-02f, -2.25175083e-01f,
  -3.99580039e-02f, -8.20458680e-02f, 6.04887865e-02f, 2.74684075e-02f, 5.24065457e-02f, -1.09766394e-01f, 3.05736661e-01f, 1.01895429e-01f, -3.27356383e-02f, 6.79383352e-02f,
  -7.71726072e-02f, -7.14033656e-03f, -2.57355005e-01f, -1.89622208e-01f, 1.38440984e-03f, 5.36038913e-02f, -1.25199303e-01f, -1.32848620e-01f, -2.92787760e-01f, -1.36319891e-01f,
  7.79483020e-01f, -5.47155499e-01f, -1.56180069e-01f, 2.83709288e-01f, 2.61682179e-02f, 9.90382954e-02f, -1.73163004e-02f, 1.07265934e-02f, 1.52846932e-01f, -1.00829706e-01f,
  -2.87642747e-01f, -1.68536663e-01f, -1.66494280e-01f, -2.68174887e-01f, -1.31950900e-01f, -5.95141500e-02f, 1.12162098e-01f, 1.94800004e-01f, 2.24261582e-01f, -6.59052283e-02f,
  -8.83661732e-02f, 1.60420194e-01f, 1.97458372e-01f, -2.70862971e-03f, -2.54002720e-01f, 4.28915396e-02f, -5.84355555e-02f, -1.80827036e-01f, -2.68754363e-01f, -2.02504680e-01f,
  -3.76777112e-01f, -1.15784645e-01f, 1.44420415e-01f, -1.04849756e-01f, -1.82449847e-01f, 2.52354909e-02f, -7.70192780e-03f, -3.04161385e-02f, 3.81805338e-02f, -3.73698585e-02f,
  -7.01259524e-02f, 2.09580772e-02f, -7.00855106e-02f, -1.99321523e-01f, -5.50336912e-02f, 5.31420000e-02f, -4.56907861e-02f, -1.83198676e-01f, -1.73337117e-01f, -2.43357211e-01f,
  -2.97509611e-01f, -8.34418312e-02f, 1.35792186e-02f, -9.31543261e-02f, -1.92639336e-01f, 7.78554603e-02f, -6.47248551e-02f, -5.59425168e-02f, -2.78631523e-02f, -1.32261422e-02f,
  8.62887246e-04f, -8.71756673e-02f, -1.29541680e-01f, -3.96936946e-02f, -1.54970698e-02f, -2.83843111e-02f, 8.85444507e-02f, -2.15492491e-02f, -1.14467345e-01f, -6.23446777e-02f,
  -4.73062918e-02f, -1.25036806e-01f, -2.88341463e-01f, 4.97318581e-02f, -9.99758244e-02f, -1.61374599e-01f, -3.00205834e-02f, -2.03888521e-01f, -1.77342698e-01f, -1.08909011e-01f,
  -5.00898808e-02f, -7.56337419e-02f, 7.04747438e-02f, -1.14939429e-01f, -7.18716308e-02f, -8.37302878e-02f, -9.37518999e-02f, -1.77872211e-01f, -3.19054164e-03f, 1.33344859e-01f,
  -3.12823445e-01f, 5.03977239e-02f, 2.01481208e-01f, 7.43775293e-02f, 6.42169192e-02f, 3.41865905e-02f, -3.68785076e-02f, 4.35698293e-02f, 3.68673131e-02f, -4.92578484e-02f,
  -1.36409223e-01f, 6.88803792e-02f, -6.59714192e-02f, -2.09520608e-01f, 1.55036926e-01f, 8.62716585e-02f, -2.15967931e-02f, 9.69967023e-02f, -7.76418075e-02f, -1.64852247e-01f,
  -3.72905247e-02f, 2.46792331e-01f, 2.88206547e-01f, 1.82166889e-01f, 7.19750896e-02f, 2.82924771e-01f, 1.41424164e-01f, 1.77365825e-01f, 1.14243351e-01f, 3.47939700e-01f,
  1.85922131e-01f, -2.02655662e-02f, 3.26219082e-01f, 2.05521602e-02f, 2.15839222e-02f, -1.30947351e-01f, -2.86867887e-01f, -2.67840505e-01f, -1.23250755e-02f, -6.16532676e-02f,
  -3.40765864e-01f, -4.36625063e-01f, -1.99204028e-01f, -3.35749030e-01f, -3.83714080e-01f, 3.92946564e-02f, 2.47356385e-01f, 1.21627949e-01f, -2.03799471e-01f, -4.56509352e-01f,
  -4.41648036e-01f, -9.84089524e-02f, -1.07698649e-01f, -6.27973378e-02f, 2.77022570e-01f, 7.09857652e-03f, 1.69704601e-01f, 1.27024844e-01f, 4.14296500e-02f, 3.19822341e-01f,
  9.72345993e-02f, 1.68637723e-01f, -2.81955302e-01f, -2.01372817e-01f, -1.68927699e-01f, -5.35957664e-02f, -2.20123962e-01f, 1.95222406e-03f, -8.08136985e-02f, 1.66086736e-03f,
  -9.45621729e-03f, -3.77012119e-02f, -8.35516527e-02f, -5.00378311e-02f, -4.22046073e-02f, -6.47031292e-02f, 1.39430568e-01f, -2.09264383e-02f, -2.55044587e-02f, -6.79502077e-03f,
  -2.24399388e-01f, -2.13402280e-04f, 8.22068378e-02f, -8.40536207e-02f, -6.14525229e-02f, -7.94496238e-02f, 3.38919461e-02f, 9.48663279e-02f, 1.39473796e-01f, 6.34059981e-02f,
  -3.34244996e-01f, -3.92050743e-02f, 4.96650720e-03f, -1.12819783e-01f, -6.65037706e-02f, -1.19757332e-01f, -2.42134184e-02f, -8.53033960e-02f, -2.21920282e-01f, -1.68070480e-01f,
  -2.55554259e-01f, -2.64323384e-01f, -1.12087227e-01f, -7.00062588e-02f, 2.12820824e-02f, -8.49284530e-02f, -5.79981469e-02f, -7.29861185e-02f, -1.30943194e-01f, -1.35585248e-01f,
  -1.43479660e-01f, -2.55812705e-02f, 1.05704293e-01f, -6.53018579e-02f, -1.76562164e-02f, -4.59849499e-02f, 7.00008590e-03f, -1.80539593e-01f, -5.97378355e-04f, 6.47187009e-02f,
  -1.64206922e-01f, -1.76180333e-01f, -5.97193837e-02f, 1.19404443e-01f, 8.04689750e-02f, 6.27002716e-02f, 1.89304017e-02f, -4.95623387e-02f, 8.27013329e-02f, 3.89722968e-03f,
  -2.58343946e-02f, -1.43829454e-02f, 1.12012222e-01f, -3.57434899e-02f, -5.16786836e-02f, -1.00475453e-01f, -1.88968658e-01f, 9.97070894e-02f, 4.28372808e-02f, -6.80515990e-02f,
  -2.66771596e-02f, 1.19945407e-03f, -6.76776394e-02f, 7.28991702e-02f, -7.98717141e-03f, 6.82801148e-03f, 3.50022204e-02f, 1.59548238e-01f, 1.39417529e-01f, -8.97509977e-03f,
  -3.31892133e-01f, -2.16161028e-01f, -2.80284900e-02f, 5.22484303e-01f, 5.08782446e-01f, 2.81820446e-01f, 1.44438013e-01f, 1.28331348e-01f, 3.03085923e-01f, 2.35871077e-01f,
  1.24574073e-01f, 2.78305560e-01f, 9.71149281e-02f, 1.72836930e-01f, -4.85383580e-03f, 2.07173347e-01f, 3.30225527e-01f, -4.24146373e-03f, 1.17205061e-01f, 1.48902029e-01f,
  3.84430647e-01f, 1.50693461e-01f, 3.37965898e-02f, 1.50465548e-01f, 2.96169341e-01f, 4.08124119e-01f, 1.62559494e-01f, 2.53311783e-01f, 1.68942630e-01f, 2.76519865e-01f,
  -1.95370913e-01f, -1.30483314e-01f, 2.26410255e-01f, 1.47626638e-01f, -8.03986266e-02f, -2.34137401e-01f, 6.90469891e-02f, -1.32346064e-01f, 6.43858388e-02f, 8.02394561e-03f,
  -3.03931125e-02f, -1.39892742e-01f, -2.09091939e-02f, 2.81993244e-02f, -1.42933056e-01f, -1.91429064e-01f, -8.48402008e-02f, -1.12318993e-01f, -3.02243102e-02f, -1.60946324e-01f,
  1.16602205e-01f, 1.28582135e-01f, 3.01555917e-02f, 5.94663573e-03f, -8.16316456e-02f, 7.33096749e-02f, -2.02402025e-01f, -1.16896167e-01f, -8.75022635e-02f, -2.63456050e-02f,
  4.11456794e-01f, 1.22550830e-01f, 1.11065339e-02f, 8.64013433e-02f, 5.92687055e-02f, -7.47216046e-02f, 7.82274827e-02f, 3.24767157e-02f, 1.65418714e-01f, -4.67004031e-02f,
  3.48477997e-02f, 1.87703416e-01f, -8.84155259e-02f, 8.71500373e-02f, 1.74573436e-01f, 1.98249936e-01f, -3.59120183e-02f, -4.94877063e-02f, -3.74858715e-02f, 6.22534985e-03f,
  -1.23860566e-02f, 9.37047135e-03f, -1.47870541e-01f, -2.60872602e-01f, 6.50103902e-03f, 1.49743453e-01f, 1.66572735e-01f, 1.27840757e-01f, 5.77487089e-02f, 1.04224816e-01f,
  4.86475110e-01f, 2.70719051e-01f, -9.05880518e-03f, -1.61356166e-01f, -6.66391477e-02f, -2.10639551e-01f, 7.99069647e-03f, 4.47437949e-02f, -6.17944971e-02f, 6.11635596e-02f,
  -2.54133474e-02f, -2.40765482e-01f, -1.38097093e-01f, -7.53983408e-02f, 6.98804099e-04f, -2.07288959e-03f, -1.08377293e-01f, 1.36285827e-01f, -5.18405773e-02f, -7.75164068e-02f,
  7.15013519e-02f, 7.46086985e-02f, 1.28259182e-01f, 4.54699919e-02f, 1.21904343e-01f, 9.22721773e-02f, -1.40911518e-02f, 4.12740819e-02f, -3.68452743e-02f, -5.67660527e-03f,
  -3.48319829e-01f, 3.28324258e-01f, 2.03873873e-01f, 2.03930698e-02f, 2.20802682e-03f, 4.52523232e-02f, 2.94386335e-02f, -8.54542404e-02f, -5.91370165e-02f, -2.80624665e-02f,
  -1.48849152e-02f, 2.09931307e-03f, -3.52773368e-02f, 8.15973878e-02f, 7.02770939e-03f, 1.24055520e-01f, -4.20943163e-02f, 5.44954464e-02f, -8.48161429e-02f, -1.65424034e-01f,
  -1.76893681e-01f, -1.17624380e-01f, 6.28719255e-02f, -1.76674000e-03f, 1.13938414e-01f, 5.71480133e-02f, 6.42897785e-02f, 1.74710840e-01f, 1.26277894e-01f, 7.60650337e-02f,
  5.01784444e-01f, 3.06678683e-01f, -4.11219858e-02f, 4.89211529e-02f, -3.43307443e-02f, -1.29139289e-01f, 1.11058382e-02f, 2.06965823e-02f, -5.89822568e-02f, 5.69638833e-02f,
  1.14656538e-01f, -1.80394985e-02f, -2.18373109e-02f, 3.16082016e-02f, -8.61505140e-03f, -6.58051595e-02f, -3.36728320e-02f, 1.86677370e-02f, 6.09016456e-02f, 1.78465303e-02f,
  -7.10632280e-02f, 1.87147013e-03f, 2.15483859e-01f, 5.24724051e-02f, 5.95835671e-02f, 6.27778396e-02f, 2.33070161e-02f, 5.58151193e-02f, 1.37737378e-01f, 4.12421525e-02f,
  -3.64773758e-02f, -2.86041886e-01f, 4.09625359e-02f, -1.03013255e-01f, -2.03706369e-01f, -6.43797666e-02f, -6.94069453e-03f, -2.77554691e-02f, -1.32178769e-01f, -2.70929709e-02f,
  -1.07700199e-01f, 5.15541732e-02f, -7.59419277e-02f, -9.48276445e-02f, 3.10206925e-03f, 8.53071362e-02f, -2.43523438e-02f, 1.53191566e-01f, 9.91190076e-02f, 1.18649937e-02f,
  -6.11929037e-02f, 4.69327383e-02f, 6.45107850e-02f, 1.18817270e-01f, 8.60153884e-02f, 3.87046114e-02f, -1.85656045e-02f, -1.10511206e-01f, -1.03627607e-01f, -1.16133749e-01f,
  3.16904783e-01f, 2.94496983e-01f, -1.60731021e-02f, 3.55812870e-02f, 3.07465773e-02f, 2.96668112e-02f, 4.15002517e-02f, 1.85387246e-02f, 1.37249544e-01f, 1.68220580e-01f,
  1.53099865e-01f, -1.47450985e-02f, 4.02864181e-02f, -8.28710645e-02f, -5.94852455e-02f, 5.90408631e-02f, 1.00883171e-02f, 3.87747735e-02f, 1.68052658e-01f, 2.64603555e-01f,
  5.09952083e-02f, -3.04406770e-02f, 1.42579094e-01f, -6.79478096e-03f, -5.57707734e-02f, -3.43485288e-02f, 9.45773721e-02f, 1.72492504e-01f, 1.89801335e-01f, -2.01675698e-01f,
  1.04035452e-01f, -7.03727603e-01f, 3.36153299e-01f, 9.53666270e-02f, 1.34893611e-01f, 2.46214017e-01f, 8.63445178e-02f, 7.33620524e-02f, 8.13410655e-02f, -1.60692126e-01f,
  -2.25883469e-01f, 6.71329116e-03f, -1.36050908e-02f, -8.08710307e-02f, 8.50237608e-02f, 1.09003603e-01f, 1.76517189e-01f, 2.77022392e-01f, 3.80354732e-01f, 1.59752250e-01f,
  -6.87584653e-02f, -1.72646835e-01f, -1.27379477e-01f, -5.83747551e-02f, -1.37525812e-01f, 4.76422124e-02f, -1.33192137e-01f, -2.10540652e-01f, -4.88480739e-02f, -4.16976288e-02f,
  2.74925500e-01f, -1.38534710e-01f, 1.90676093e-01f, -1.19580775e-01f, -2.39298671e-01f, -1.65718302e-01f, 6.66992739e-02f, -1.53076664e-01f, -1.43112436e-01f, -5.91519177e-02f,
  -7.26279616e-02f, -7.30302632e-02f, -5.68592325e-02f, -1.34399906e-01f, 2.73609236e-02f, -7.03349933e-02f, -1.11838661e-01f, -8.26039165e-02f, -3.52042168e-02f, -1.13070354e-01f,
  -8.95715877e-02f, 6.04408570e-02f, 5.91893494e-02f, 7.70887434e-02f, -1.18793614e-01f, 2.27237158e-02f, -9.24313515e-02f, -5.50400931e-03f, -6.58148304e-02f, -8.90285820e-02f,
  -1.03106618e-01f, -1.09137863e-01f, 1.16507538e-01f, 3.17730904e-02f, 7.95759112e-02f, 2.03178912e-01f, 1.07550308e-01f, 2.64763013e-02f, 8.86233598e-02f, 9.44626331e-02f,
  1.08502701e-01f, 2.69611955e-01f, 6.01162352e-02f, -3.43248919e-02f, -4.48153652e-02f, 6.75024763e-02f, -4.72447947e-02f, -1.34636194e-01f, 1.96525399e-02f, 1.11821651e-01f,
  1.84076786e-01f, 5.26743531e-02f, -7.27241561e-02f, 2.47935094e-02f, -5.15076630e-02f, -7.47426972e-02f, -3.03623173e-02f, -1.53488711e-01f, -6.42278716e-02f, -1.75846834e-02f,
  9.59080756e-02f, 2.58276612e-01f, 3.06105196e-01f, 1.74106732e-01f, 4.88507114e-02f, -6.69665486e-02f, 1.16908379e-01f, 3.71391769e-03f, -9.42895561e-02f, 3.72719578e-02f,
  -3.35975294e-03f, 2.57546715e-02f, 2.70233061e-02f, 2.94676833e-02f, 2.26540238e-01f, 1.39984325e-01f, -1.57987058e-01f, 7.48983175e-02f, 3.45713310e-02f, -6.78050593e-02f,
  -6.91098720e-02f, 1.19884297e-01f, 2.09551960e-01f, 2.23564878e-01f, 1.03451975e-01f, 3.06601286e-01f, 6.72271177e-02f, 2.83316318e-02f, 2.16688782e-01f, -6.90368786e-02f,
  -4.53070998e-01f, 1.52483970e-01f, 4.62735742e-01f, -1.43296242e-01f, 1.06002100e-01f, -2.40169317e-01f, -4.28096324e-01f, -4.08134401e-01f, -2.36366000e-02f, 1.29603505e-01f,
  3.73679310e-01f, -2.13848371e-02f, 2.89801112e-03f, -1.90614998e-01f, -5.82131445e-01f, -1.79502711e-01f, -7.52046481e-02f, -3.31212968e-01f, -5.51106155e-01f, -5.77397108e-01f,
  -2.73182541e-01f, -3.56681168e-01f, -4.26609755e-01f, -2.14835733e-01f, 1.13608629e-01f, -3.68055366e-02f, 3.84211510e-01f, 4.17697802e-02f, 5.05775884e-02f, 1.17397413e-01f,
  4.68115240e-01f, 6.30521476e-02f, -1.61859021e-01f, -1.15760550e-01f, 2.72853553e-01f, -2.76097432e-02f, -6.02218173e-02f, 5.85738420e-02f, 4.90144603e-02f, 2.33509075e-02f,
  -2.92529128e-02f, -4.58680093e-02f, 1.13449395e-02f, -7.87415355e-02f, -2.18793541e-01f, -2.14181975e-01f, -3.15409973e-02f, -2.38352388e-01f, -1.89352214e-01f, -3.66143472e-02f,
  -1.33769080e-01f, -1.03677586e-01f, 3.35427672e-02f, -3.19053046e-02f, -7.21668452e-03f, -1.51944384e-01f, 3.50478925e-02f, -9.80565920e-02f, -6.10362031e-02f, -1.72759697e-01f,
  -1.27702141e-02f, 4.30077389e-02f, 1.68653399e-01f, 1.87075394e-03f, -5.01229763e-02f, 2.53787398e-01f, 7.50419572e-02f, 4.18066829e-02f, 3.86678874e-02f, -9.08811316e-02f,
  1.34846449e-01f, 5.80142289e-02f, 9.81230214e-02f, 6.93471879e-02f, 8.07436556e-02f, -1.02594234e-01f, -3.92606482e-02f, -1.16260052e-01f, -8.83907825e-03f, -8.15127641e-02f,
  -7.18451142e-02f, -6.42177761e-02f, 2.04614177e-01f, -4.18412611e-02f, 1.14744775e-01f, -4.17489447e-02f, 1.21414319e-01f, -4.20652181e-02f, -1.40688950e-02f, 8.72093067e-02f,
  7.79545158e-02f, 6.25678077e-02f, -2.91105658e-02f, -2.01387554e-01f, 3.18374038e-02f, 1.86365023e-01f, 1.67524338e-01f, -6.57603443e-02f, 9.28848460e-02f, -2.21030489e-01f,
  -2.63895869e-01f, -1.17729284e-01f, 5.62590025e-02f, -3.16664539e-02f, -1.19955197e-01f, -4.68002781e-02f, -1.22825742e-01f, 1.11689031e-01f, -2.67715424e-01f, 6.78868219e-02f,
  -1.70080185e-01f, -5.90218723e-01f, -4.82186288e-01f, -9.12118554e-02f, -1.50614485e-01f, -2.30528891e-01f, -1.27953574e-01f, -2.06921056e-01f, -1.61516249e-01f, -4.15989965e-01f,
  7.99241662e-01f, -1.65057406e-01f, 2.87549645e-01f, 2.23220065e-01f, 2.24575415e-01f, 2.25084454e-01f, 1.92681789e-01f, 2.08697885e-01f, 4.46219966e-02f, 4.66231965e-02f,
  -1.05758253e-02f, 4.91672643e-02f, 1.01050310e-01f, 6.89802244e-02f, 5.21542951e-02f, 9.77437198e-02f, 1.13317989e-01f, 1.54648319e-01f, 3.24774772e-01f, 4.25333269e-02f,
  -1.02953158e-01f, 1.74189415e-02f, 7.07351416e-02f, 1.15352646e-01f, -2.16093212e-01f, 3.79726337e-03f, 6.62179813e-02f, -1.42212128e-02f, -1.34202421e-01f, -1.39517918e-01f,
  -3.59861642e-01f, 1.46593019e-01f, -3.58183198e-02f, -8.74467120e-02f, -1.51125476e-01f, -1.22093596e-01f, -2.25351448e-03f, -7.43120462e-02f, -1.56601205e-01f, -5.90118878e-02f,
  -3.55463102e-02f, -1.28649205e-01f, -9.88198668e-02f, -6.42955899e-02f, 3.88273783e-02f, 2.38682777e-02f, -9.17289183e-02f, -9.51167103e-03f, 7.82920327e-03f, -3.26640829e-02f,
  -2.12383389e-01f, -1.10355839e-01f, 4.69063362e-03f, -6.83846790e-03f, 1.21322863e-01f, 4.07941639e-02f, -2.49815471e-02f, -6.75924867e-02f, 6.21045530e-02f, 3.67251970e-02f,
  3.58541869e-03f, 6.95706680e-02f, 1.93301123e-02f, -1.01856031e-01f, -1.09329239e-01f, -5.51145039e-02f, -8.89308453e-02f, -1.83584169e-02f, 1.94264859e-01f, -1.81515105e-02f,
  8.41171965e-02f, 6.30570725e-02f, 2.07936540e-01f, -1.84910819e-02f, -3.29927281e-02f, -3.86425704e-02f, 6.67383000e-02f, 4.38288227e-02f, 2.11219534e-01f, 7.99569581e-03f,
  1.59328297e-01f, 1.00550447e-02f, 2.58742813e-02f, 4.10359539e-02f, 6.54906109e-02f, 7.36668780e-02f, 4.73851301e-02f, -1.17391646e-01f, 6.41990453e-02f, -6.42588362e-02f,
  -3.13156962e-01f, 3.34036320e-01f, -1.04615085e-01f, -1.21337883e-01f, -2.81616077e-02f, -1.11302540e-01f, 1.43623129e-01f, -1.00111239e-01f, -1.93608955e-01f, -1.60242215e-01f,
  -4.05517705e-02f, 1.53543837e-02f, 1.23658530e-01f, 1.30318357e-02f, 2.22108047e-02f, -1.20118514e-01f, -1.19043238e-01f, 3.01221255e-02f, -2.11598873e-02f, -5.56055419e-02f,
  -3.69330272e-02f, 2.24719960e-02f, 2.22891569e-01f, 1.95488736e-01f, 2.79521826e-03f, 1.25498310e-01f, -6.00491352e-02f, -1.01185203e-01f, 1.21515162e-01f, 4.78815436e-02f,
  1.03763127e+00f, 1.87086254e-01f, -2.10903615e-01f, 2.17114285e-01f, -2.46561933e-02f, -8.03675503e-03f, 6.75404742e-02f, 1.83534637e-01f, 3.05868834e-01f, 1.75784349e-01f,
  2.15741932e-01f, 2.45680317e-01f, 2.71395326e-01f, 9.23296288e-02f, 2.33385973e-02f, -1.80333927e-01f, -3.49667221e-01f, -4.65513319e-02f, 1.04365334e-01f, 5.36108166e-02f,
  -1.22558236e-01f, 8.20462778e-02f, 1.05517000e-01f, 5.70422597e-03f, -2.69619852e-01f, -8.84220079e-02f, -1.18853442e-01f, -1.40866444e-01f, -2.81986445e-01f, -3.94972861e-01f,
  -6.11868620e-01f, 4.82920818e-02f, -6.86107262e-04f, 2.30642576e-02f, -6.06939010e-02f, 1.78706869e-01f, 2.52981670e-02f, -4.45445441e-02f, -1.75215025e-02f, -8.28197747e-02f,
  -8.24808106e-02f, 1.97561793e-02f, 1.58021518e-03f, -5.27388230e-02f, -8.26972425e-02f, -1.16633691e-01f, 4.41823602e-02f, -3.94889303e-02f, -1.19623005e-01f, -7.72433057e-02f,
  -1.39481038e-01f, 1.75281409e-02f, -3.40935849e-02f, 6.61254153e-02f, 5.38188629e-02f, 3.23859490e-02f, -2.77208518e-02f, -1.40899137e-01f, 3.79128642e-02f, 9.39719155e-02f,
  2.19188351e-02f, 7.39383325e-02f, 2.76635047e-02f, 1.21131249e-01f, 2.39789188e-01f, 2.18969181e-01f, 3.79444882e-02f, 1.12033777e-01f, 2.24008515e-01f, 9.80197787e-02f,
  -9.26184729e-02f, -1.37575924e-01f, -1.78151000e-02f, -1.89647842e-02f, -1.10309944e-01f, -5.00809923e-02f, -1.07991584e-01f, -4.16285619e-02f, -1.80473939e-01f, -5.20862974e-02f,
  -3.12790573e-02f, -1.18320785e-01f, -1.89233080e-01f, -2.52192467e-01f, -1.72115073e-01f, -2.45402381e-03f, -1.09395333e-01f, -6.04734086e-02f, 4.24686186e-02f, 3.06827724e-02f,
  -1.52535915e-01f, 7.30988234e-02f, -6.76764324e-02f, -7.92584270e-02f, 3.98399681e-02f, 6.16890974e-02f, 1.10587776e-02f, -1.16821781e-01f, -7.59610161e-02f, -5.93370125e-02f,
  -3.20054293e-02f, 8.46718028e-02f, -9.19356421e-02f, -9.96877849e-02f, 9.53672156e-02f, 1.04177803e-01f, 1.41011417e-01f, 2.20679969e-01f, -1.50575429e-01f, -1.17811628e-01f,
  3.78338583e-02f, 2.40861267e-01f, 1.99800953e-01f, 8.62844288e-02f, 8.32719058e-02f, 1.22665547e-01f, 1.31363161e-02f, -1.55155230e-02f, 1.51079372e-01f, 1.88473955e-01f,
  -6.62750244e-01f, -5.05622057e-03f, 4.90817755e-01f, -2.65215784e-01f, 6.48026839e-02f, 1.33096561e-01f, 2.69613415e-01f, -1.00035705e-01f, -3.40038627e-01f, -1.13488823e-01f,
  -1.75023779e-01f, -3.70871395e-01f, -7.92399123e-02f, 4.65988135e-03f, 1.93911433e-01f, 2.90482908e-01f, 5.24160504e-01f, 4.26352024e-01f, 1.43129215e-01f, -2.01726243e-01f,
  -1.84030667e-01f, 6.01271763e-02f, 3.44334217e-03f, 1.12702563e-01f, 3.09440140e-02f, 1.22012729e-02f, 1.83604926e-01f, 7.28497840e-03f, 9.68118459e-02f, -2.74980143e-02f,
  -2.37671122e-01f, -1.82914764e-01f, 1.10056758e-01f, -8.30884650e-02f, -2.98356544e-02f, -1.48368523e-01f, -7.16415420e-02f, -4.10948088e-03f, -1.21160559e-02f, -5.40498495e-02f,
  -3.76670831e-03f, -7.37573132e-02f, -2.73402371e-02f, 6.20940775e-02f, -1.05812788e-01f, -1.66428268e-01f, 1.26168013e-01f, 1.01210326e-01f, 2.58553820e-03f, -2.69848794e-01f,
  -1.47693276e-01f, -2.11366534e-01f, 4.07680795e-02f, 7.61516094e-02f, -1.01025905e-02f, 1.06790915e-01f, 6.59707114e-02f, -1.52255878e-01f, 7.76915695e-04f, -3.59813541e-01f,
  2.26410776e-02f, 2.48758565e-03f, 8.57663527e-02f, 8.32105502e-02f, 3.55840400e-02f, -3.90561633e-02f, 1.49068847e-01f, -1.36376601e-02f, 5.16614728e-02f, 1.44966394e-02f,
  -5.65590598e-02f, -1.14471436e-01f, -7.00621307e-02f, -8.97796638e-03f, -1.04137622e-01f, -5.02217263e-02f, -8.74611214e-02f, 4.54131374e-03f, 1.44342974e-01f, -2.10922807e-02f,
  7.28791580e-03f, 4.57603252e-03f, -3.38020474e-02f, 8.48726332e-02f, -8.62995861e-04f, 2.02455088e-01f, -1.72607899e-01f, -3.82505171e-02f, -8.44637156e-02f, -1.41252697e-01f,
  -3.78402591e-01f, 5.76311946e-01f, -3.69221956e-01f, 1.36866286e-01f, -5.46269044e-02f, 5.98959699e-02f, 4.78021888e-04f, 6.32031113e-02f, -7.97633678e-02f, -1.62258055e-02f,
  -4.99593578e-02f, -2.18337346e-02f, -9.94040370e-02f, 1.42125949e-01f, -7.96013847e-02f, -5.20527884e-02f, 3.97873372e-02f, -3.88766266e-02f, -3.39013673e-02f, -2.21953318e-01f,
  8.25809538e-02f, -2.73728669e-02f, -2.99817801e-01f, -8.74456391e-02f, -2.61949897e-01f, -2.58523792e-01f, -4.93341126e-02f, -1.82321787e-01f, -5.45262359e-02f, -3.81672412e-01f,
  -7.51234591e-02f, -4.06224489e-01f, -3.94310802e-01f, 5.58061637e-02f, 5.11930734e-02f, -1.77706853e-01f, -4.20895576e-01f, -1.71410009e-01f, 2.48822972e-01f, -2.71161854e-01f,
  5.27051724e-02f, 4.39149588e-01f, 5.46385460e-02f, -1.58427492e-01f, -4.78646368e-01f, -5.35439551e-01f, -2.97720551e-01f, -1.09356351e-01f, 7.24823326e-02f, 2.12539107e-01f,
  2.58614421e-01f, 1.71023339e-01f, -1.94818422e-03f, 8.52623396e-03f, 7.76264891e-02f, 1.63477510e-01f, -1.20790310e-01f, -7.77524486e-02f, -1.10346660e-01f, -2.13498920e-01f,
  -2.26438269e-01f, -1.97526857e-01f, 6.69792742e-02f, 9.48537812e-02f, 2.42486879e-01f, -3.53594348e-02f, -4.90618609e-02f, -1.69896707e-02f, 2.10559238e-02f, -2.60277033e-01f,
  1.07321329e-01f, 6.32985234e-02f, 1.57204688e-01f, 3.73090804e-02f, 1.03551373e-02f, -9.25408900e-02f, -8.56157243e-02f, -7.62195885e-02f, -2.41932467e-01f, 1.90713387e-02f,
  8.10475498e-02f, -9.37858224e-02f, -1.09739535e-01f, -1.68418765e-01f, -1.42582536e-01f, 9.40965787e-02f, 4.55058701e-02f, 4.04193513e-02f, -3.85919601e-01f, -2.87834048e-01f,
  -1.08025283e-01f, 4.41456512e-02f, 6.60609454e-02f, 1.04027413e-01f, 8.85558948e-02f, 7.05773085e-02f, 7.21544102e-02f, -2.92719733e-02f, 9.90600213e-02f, 6.71112090e-02f,
  1.64879486e-02f, 2.28479505e-02f, 1.01423897e-01f, -1.57093614e-01f, -3.54983993e-02f, -1.20472036e-01f, -5.79511374e-02f, -1.12087786e-01f, -7.96190649e-02f, -2.84610409e-02f,
  7.93870315e-02f, 2.22471058e-02f, 4.82929535e-02f, -2.36473270e-02f, -1.56052753e-01f, -2.45004952e-01f, 6.84269285e-03f, -2.63272189e-02f, -7.57127404e-02f, -1.18974872e-01f,
  -8.53121728e-02f, -2.53854752e-01f, -1.94982052e-01f, -1.11668475e-01f, 5.26815765e-02f, 6.30654097e-02f, -1.06915705e-01f, -1.35647401e-01f, -3.47524509e-02f, -6.30269498e-02f,
  -1.18136242e-01f, -1.38117522e-01f, -1.26287296e-01f, 2.31645346e-01f, 4.69418764e-02f, 6.86230808e-02f, -4.43448797e-02f, -3.90438437e-02f, -1.41696379e-01f, 2.01423392e-01f,
  -2.04814062e-01f, -2.92455703e-01f, -2.29052514e-01f, -2.44656891e-01f, 6.11785986e-03f, -5.41047938e-02f, -1.50860220e-01f, -2.58862972e-01f, -3.09846461e-01f, -5.34407020e-01f,
  -5.77353537e-01f, -4.68737483e-01f, -2.34646603e-01f, -5.09395182e-01f, -3.18803102e-01f, -1.23571135e-01f, -2.56836623e-01f, -1.46387648e-02f, -2.38602951e-01f, -4.80439574e-01f,
  -2.85227358e-01f, -1.69199899e-01f, -2.34661967e-01f, -7.31529295e-02f, 8.50618631e-02f, -3.20258379e-01f, -2.24193230e-01f, -4.66214232e-02f, 8.41203034e-02f, 8.69909897e-02f,
  -3.07119940e-03f, -1.14747971e-01f, 1.49202451e-01f, 1.78308383e-01f, -3.45959991e-01f, -1.94658801e-01f, -2.10266322e-01f, -2.21825436e-01f, -1.15087248e-01f, -5.11846662e-01f,
  -3.39161128e-01f, -2.30814084e-01f, 7.77892172e-02f, -6.15821481e-02f, -1.11692101e-01f, -4.04040031e-02f, -8.25500637e-02f, 2.13587582e-02f, 5.52617684e-02f, -1.40217289e-01f,
  -2.19582394e-01f, 6.51672333e-02f, -1.75165877e-01f, -4.62304950e-02f, -3.10247438e-03f, -7.67212063e-02f, 5.38885184e-02f, 5.18831424e-02f, 9.46177263e-03f, -1.26184952e-02f,
  -6.48780987e-02f, -2.45086193e-01f, -1.56431228e-01f, 5.54110184e-02f, 8.12624618e-02f, 9.77986157e-02f, 1.15723282e-01f, 1.10213727e-01f, 1.99179962e-01f, -1.76368922e-01f,
  3.92107852e-02f, -8.26936811e-02f, -9.99512300e-02f, 1.61666404e-02f, -1.58647802e-02f, -4.23849747e-02f, -2.79442798e-02f, -8.92700925e-02f, 1.13514259e-01f, -1.25131518e-01f,
  -2.29111705e-02f, -2.41819732e-02f, 9.37079638e-02f, -1.62547484e-01f, -5.50340526e-02f, -1.14698522e-01f, -3.98135483e-02f, -1.54079953e-02f, 3.39110522e-03f, -7.19988793e-02f,
  -1.38209745e-01f, -7.18882009e-02f, -3.17453481e-02f, 5.16424403e-02f, 1.77648407e-03f, 1.52726925e-03f, 6.89134449e-02f, 9.84286964e-02f, -1.20826345e-02f, 1.17188096e-01f,
  -3.93027216e-01f, 2.25147158e-01f, -2.39334553e-01f, -7.94212073e-02f, -7.45998845e-02f, 5.74791618e-02f, -2.77539581e-01f, 1.04155159e-02f, -1.38064936e-01f, -4.90042567e-02f,
  -4.87495363e-02f, -1.69589788e-01f, -1.43111110e-01f, 1.04318606e-02f, 7.00913146e-02f, -5.08651845e-02f, -2.26185676e-02f, -2.55589187e-01f, 4.20935676e-02f, 1.04230903e-01f,
  6.55526295e-02f, -2.16164887e-01f, -2.56459683e-01f, -1.47603169e-01f, -2.35887133e-02f, -9.45536494e-02f, -6.93383766e-03f, -8.20591860e-03f, 1.12775177e-01f, -1.19271182e-01f,
  3.38868886e-01f, -5.27140021e-01f, -2.68204987e-01f, -2.23298639e-01f, -3.60281706e-01f, -3.54862303e-01f, -6.40128732e-01f, -1.43829748e-01f, -1.19362876e-01f, -5.93946993e-01f,
  -3.66125554e-01f, 2.17312396e-01f, 6.68760836e-02f, 6.97955266e-02f, 1.95996299e-01f, -5.35983682e-01f, -4.41517472e-01f, 1.96878254e-01f, 5.47719896e-01f, -5.85489953e-03f,
  -1.76442191e-01f, -3.86212990e-02f, 3.35586190e-01f, 4.46115434e-02f, -4.57096726e-01f, -1.35988608e-01f, -4.21276867e-01f, -1.55728698e-01f, -3.34843546e-01f, -4.70100313e-01f,
  -4.08288926e-01f, -2.20859237e-02f, 1.19116820e-01f, 2.06778914e-01f, -1.67566195e-01f, 7.20530972e-02f, -7.69721493e-02f, 1.37029216e-01f, 8.03025160e-03f, -1.24563254e-01f,
  1.11127580e-02f, 3.04752891e-03f, 1.12655558e-01f, 4.68913466e-02f, -9.35752541e-02f, 5.04944846e-02f, 6.82923198e-02f, 2.73040980e-01f, -5.63527551e-03f, -2.23751456e-01f,
  -1.92457408e-01f, 9.60846916e-02f, 1.53894022e-01f, 7.18087777e-02f, 4.36133854e-02f, 1.50889352e-01f, -1.72608733e-01f, -7.80648962e-02f, 9.56725180e-02f, -3.84046555e-01f,
  -1.71417400e-01f, -1.00354746e-01f, -5.90938479e-02f, -1.31482836e-02f, 2.50614211e-02f, -5.55015057e-02f, 6.18855022e-02f, -5.02135940e-02f, 7.42996708e-02f, -4.28470150e-02f,
  -2.40469966e-02f, -5.96645288e-02f, 5.51517271e-02f, 2.67999358e-02f, -2.21345411e-03f, 1.21452212e-01f, 3.36908922e-02f, -1.10055499e-01f, -4.56827208e-02f, 7.00233225e-03f,
  6.04035472e-03f, 2.76530217e-02f, -4.26053703e-02f, 2.54586674e-02f, -3.72654758e-02f, 2.07405053e-02f, 6.43196702e-02f, 6.83987886e-02f, 8.68585706e-03f, 6.35627583e-02f,
  3.21197347e-03f, 2.90448040e-01f, -4.17214006e-01f, 1.93878546e-01f, -1.14441223e-01f, -1.61925271e-01f, -1.50239989e-01f, 3.34160440e-02f, 1.84013486e-01f, -9.17423442e-02f,
  -2.87884697e-02f, -1.07531793e-01f, -1.55388936e-01f, -1.21494103e-02f, -1.79069620e-02f, 1.55532993e-02f, -7.95586631e-02f, 6.00274503e-02f, 1.42075032e-01f, -2.23930068e-02f,
  -1.11060768e-01f, 5.42944260e-02f, 4.20421772e-02f, -5.23335747e-02f, -9.44036990e-02f, 1.32348031e-01f, -1.25560492e-01f, -2.58189231e-01f, 1.72905236e-01f, -3.80818099e-01f,
  -4.97294962e-01f, -2.20558252e-02f, -1.18902206e-01f, -6.33917689e-01f, -3.49870294e-01f, -1.34567291e-01f, 4.49086651e-02f, -3.08754563e-01f, -5.31921744e-01f, -9.15877670e-02f,
  2.78859325e-02f, 2.76076823e-01f, -2.25436781e-02f, 1.79091141e-01f, 2.76420861e-01f, 6.80730119e-02f, -2.39901155e-01f, 4.85493476e-03f, 3.58907104e-01f, 1.63496956e-01f,
  -3.08265463e-02f, -1.35834724e-01f, -1.98747545e-01f, -2.36955598e-01f, -2.38313615e-01f, 1.10019349e-01f, -1.81856170e-01f, -3.27458948e-01f, 5.73678687e-02f, -2.20194638e-01f,
  4.87347037e-01f, -3.96681935e-01f, -4.48424369e-02f, -1.68102011e-01f, -4.55712192e-02f, -1.25294819e-01f, -9.39753279e-02f, -2.24080324e-01f, -1.09219857e-01f, -2.53015757e-01f,
  -1.18430935e-01f, -3.82577851e-02f, -3.52018289e-02f, -8.12509358e-02f, -1.12253046e-02f, 2.66236216e-02f, -8.10066536e-02f, -2.95895375e-02f, -2.54250653e-02f, -4.70899837e-03f,
  1.09083951e-01f, 3.36128077e-03f, 1.29994780e-01f, 1.21296756e-01f, -1.08131319e-01f, -2.08825413e-02f, 6.91111088e-02f, -6.04625195e-02f, -3.79054695e-02f, 7.39127118e-03f,
  1.17116878e-02f, 1.22606449e-01f, 7.28942379e-02f, 1.29395798e-02f, 1.25336528e-01f, 3.06533910e-02f, 6.10939525e-02f, 8.86861905e-02f, -5.65106347e-02f, 2.28754189e-02f,
  -9.18552652e-03f, -1.44223142e-02f, 1.27945855e-01f, -1.07418075e-01f, 2.26510055e-02f, -1.95419285e-02f, 1.20156974e-01f, 6.54494166e-02f, -1.25515535e-01f, -2.98233777e-02f,
  -8.98713842e-02f, -1.57668367e-01f, -1.39224872e-01f, 2.70846840e-02f, -1.13023430e-01f, -3.21720652e-02f, -8.08678046e-02f, 2.40972657e-02f, -3.33996266e-02f, -7.53132552e-02f,
  3.92617941e-01f, -6.73714057e-02f, -2.75632013e-02f, -2.78205033e-02f, -1.45110801e-01f, -1.37462869e-01f, -6.74914494e-02f, -1.44366682e-01f, -1.80385098e-01f, -5.00681959e-02f,
  -8.60244110e-02f, -4.38599214e-02f, 1.35431401e-02f, -7.93590471e-02f, 8.91427845e-02f, 4.05694777e-03f, -2.71753501e-03f, 1.01282306e-01f, 4.90752906e-02f, 2.77180970e-02f,
  -8.35114866e-02f, 1.31193787e-01f, 3.22022825e-01f, 2.39725634e-01f, -8.92883316e-02f, 2.23890126e-01f, 2.47177020e-01f, 8.04152861e-02f, 2.50077397e-01f, 2.54376471e-01f,
  4.78429675e-01f, 1.20518811e-01f, 1.64364934e-01f, 3.11375171e-01f, -4.91956234e-01f, -6.83247209e-01f, -5.46028256e-01f, -3.17988515e-01f, -1.90953553e-01f, 3.39550758e-03f,
  -3.36009294e-01f, -2.72300839e-01f, -5.57263903e-02f, 4.60214773e-03f, -9.02435370e-03f, 1.13970771e-01f, 3.43658894e-01f, 2.68059939e-01f, -2.11376190e-01f, -2.39325166e-01f,
  -1.35101168e-03f, 3.43198419e-01f, 4.48942602e-01f, 1.38967186e-01f, 1.57137528e-01f, -6.94795251e-02f, 1.74412787e-01f, 1.62658855e-01f, 4.15929370e-02f, 4.21390146e-01f,
  1.61173835e-01f, 6.12741001e-02f, -1.19254969e-01f, -2.09989361e-02f, -1.66259930e-02f, -4.42973189e-02f, -8.55829790e-02f, 2.66641855e-01f, -1.35775834e-01f, 1.05623923e-01f,
  -6.19054623e-02f, -5.11416756e-02f, -2.29912609e-01f, -1.08391434e-01f, -4.48538773e-02f, -1.78288341e-01f, 1.66844413e-01f, 2.55032510e-01f, 1.65978819e-01f, -1.09407581e-01f,
  -1.74035307e-03f, -1.43568754e-01f, -1.72420874e-01f, -1.13439046e-01f, 3.81153524e-02f, 2.84134652e-02f, -7.65580535e-02f, -1.29757807e-01f, -1.19708396e-01f, 1.96214899e-01f,
  7.74366781e-03f, -3.07027549e-02f, -7.10087493e-02f, 3.39299180e-02f, -6.06202520e-02f, -8.05364326e-02f, 6.81184977e-03f, 6.31795526e-02f, -4.30256017e-02f, -1.30405361e-02f,
  -2.15822440e-02f, 9.09338593e-02f, -3.26408148e-02f, 2.38554049e-02f, -3.43123265e-02f, 5.70852458e-02f, -4.56725731e-02f, 1.90854073e-01f, 8.40916783e-02f, -1.06406786e-01f,
  5.65610006e-02f, -1.91545449e-02f, 5.05151786e-02f, -3.51090468e-02f, -7.26989470e-03f, 5.09730652e-02f, 1.58991851e-02f, 2.78011803e-03f, 3.69605944e-02f, 1.08781308e-01f,
  1.11105338e-01f, -1.72176674e-01f, 3.63018513e-02f, 4.96840812e-02f, -4.47096117e-02f, -6.03052117e-02f, -2.33667511e-02f, -4.53604348e-02f, -5.20782024e-02f, -8.72748271e-02f,
  -3.10508043e-01f, -1.22989692e-01f, 6.97437972e-02f, 5.51656149e-02f, -1.99395567e-01f, -2.92042736e-02f, 5.07804863e-02f, -9.41117629e-02f, -1.05344124e-01f, -1.01727605e-01f,
  -2.60086525e-02f, -1.46651089e-01f, -9.29701328e-02f, -7.56122246e-02f, -1.15715779e-01f, -2.59535015e-01f, -2.29938373e-01f, -3.05500180e-01f, -3.15163106e-01f, -9.12032928e-03f,
  -7.05124378e-01f, -1.55569255e-01f, -3.31706226e-01f, -3.68255228e-01f, -1.20141260e-01f, 1.97885353e-02f, 3.59732024e-02f, 1.98983052e-03f, -1.10933922e-01f, -7.27483928e-02f,
  8.96258727e-02f, -1.39519855e-01f, -1.83772758e-01f, -2.91044623e-01f, -3.52325410e-01f, -2.98649997e-01f, -3.66708934e-01f, -6.06719971e-01f, -3.97134244e-01f, -1.81112066e-01f,
  -3.23678017e-01f, -5.30189812e-01f, -5.45658767e-01f, -3.28561842e-01f, -1.84030071e-01f, -1.44641295e-01f, -1.31208330e-01f, -2.04259664e-01f, -6.02617487e-02f, -3.12627912e-01f,
  -8.11207220e-02f, 4.86387797e-02f, -2.99871024e-02f, -6.89689666e-02f, -1.81154191e-01f, 3.42459022e-03f, -1.83699951e-02f, 3.75585705e-02f, -3.79858315e-02f, 6.69278651e-02f,
  -1.48477023e-02f, -1.18353955e-01f, -1.46528646e-01f, 6.07370287e-02f, -1.28100961e-01f, 1.88258383e-02f, 1.65612876e-01f, 2.07460187e-02f, 3.38527299e-02f, 2.42615819e-01f,
  2.09701672e-01f, 2.20643818e-01f, 1.71824425e-01f, 4.12045538e-01f, 1.89473048e-01f, 4.10695858e-02f, 1.51299313e-01f, 2.42322952e-01f, 1.70587569e-01f, 2.78263390e-01f,
  -3.39390375e-02f, -2.45802607e-02f, 8.76364186e-02f, -1.30079442e-03f, 1.04412800e-02f, 3.35012726e-03f, 1.72311738e-02f, -6.05047904e-02f, -6.70569018e-02f, -4.10926826e-02f,
  -6.83779716e-02f, 7.74183450e-03f, -7.12673888e-02f, -8.68410096e-02f, -8.66332501e-02f, 6.77896887e-02f, 2.91315038e-02f, 1.13326192e-01f, 8.57657418e-02f, 8.12071040e-02f,
  1.03586562e-01f, 1.19896181e-01f, -7.83626065e-02f, -3.25935632e-02f, 5.69939278e-02f, 2.44652666e-02f, 5.39397039e-02f, 5.05106263e-02f, -3.28328684e-02f, 2.63946149e-02f,
  -2.06402391e-01f, 2.57267002e-02f, -2.17669122e-02f, 1.40614346e-01f, 9.17597786e-02f, -4.14700136e-02f, 1.30546512e-02f, 1.18442783e-02f, -8.32619444e-02f, 1.55845433e-02f,
  4.25044075e-02f, -1.28933161e-01f, 1.70303416e-02f, 1.43262997e-01f, -7.97367543e-02f, 1.14391699e-01f, 1.44348726e-01f, 2.83066891e-02f, 9.52338353e-02f, 4.03097793e-02f,
  8.42169672e-02f, 2.17528552e-01f, 1.03743084e-01f, 2.30628386e-01f, 1.35927752e-01f, 1.28507353e-02f, -8.89186864e-04f, 1.40786216e-01f, 8.19965673e-04f, -8.33050013e-02f,
  7.36908138e-01f, 3.60479951e-01f, 4.41152483e-01f, 9.59375054e-02f, -5.29668331e-02f, 1.70672923e-01f, 4.40709978e-01f, 2.79008001e-01f, 9.13544670e-02f, 1.56503424e-01f,
  1.09259196e-01f, -1.04310028e-01f, -1.93424776e-01f, -2.05103047e-02f, 1.66539073e-01f, 1.51005477e-01f, 7.94057995e-02f, 1.72564581e-01f, 1.53454766e-01f, 9.01454911e-02f,
  -8.78909230e-02f, 1.49383262e-01f, 3.09826553e-01f, 4.35109325e-02f, 3.59986983e-02f, -2.35306457e-01f, 5.83331063e-02f, 2.62262262e-02f, -7.70255178e-03f, -3.59164663e-02f,
  1.93225175e-01f, 4.14943874e-01f, -2.85649568e-01f, -2.58710086e-01f, -1.86396355e-03f, 1.00262366e-01f, -1.22035041e-01f, 2.00351812e-02f, -5.44620641e-02f, -3.83038856e-02f,
  -5.82388900e-02f, -1.82426739e-02f, -4.79728449e-03f, 1.85257960e-02f, 1.20872475e-01f, 6.23285025e-02f, 1.61434948e-01f, 1.58423439e-01f, 4.05935384e-03f, -6.34936765e-02f,
  -1.51466519e-01f, 7.60347173e-02f, 1.11390226e-01f, -3.07156537e-02f, 4.83370349e-02f, -2.07260147e-01f, 8.06137398e-02f, 5.15062883e-02f, 7.76503012e-02f, 1.16106980e-01f,
  -2.15944141e-01f, -6.81312010e-02f, -4.79707122e-02f, 6.54903147e-03f, 2.50244606e-02f, 8.13852996e-02f, 3.33902016e-02f, 3.39111611e-02f, 8.44401345e-02f, 1.06681146e-01f,
  -2.52312645e-02f, 1.16949631e-02f, 1.15628026e-01f, 8.15169886e-02f, -3.21598239e-02f, 4.53846529e-02f, 1.60591483e-01f, 7.48993456e-02f, 4.64386530e-02f, -4.80300859e-02f,
  1.09003201e-01f, 1.76009983e-01f, 1.72298357e-01f, 1.08428814e-01f, 8.59729275e-02f, 6.48353770e-02f, 9.03667286e-02f, 1.11862592e-01f, 6.31833449e-02f, 3.18988264e-02f,
  -3.43967497e-01f, -9.96803567e-02f, -1.82523891e-01f, -8.59692544e-02f, -5.90438582e-02f, 2.29276102e-02f, -1.31967843e-01f, -5.97923696e-02f, -2.05987647e-01f, -2.66281627e-02f,
  -1.27124846e-01f, 7.18582720e-02f, 1.01800807e-01f, 7.79540762e-02f, 2.68823896e-02f, -3.67892496e-02f, -6.48416951e-02f, 5.12912273e-02f, -1.83158204e-01f, -1.08089261e-01f,
  -3.37457843e-02f, 5.83842061e-02f, 5.02368212e-02f, -1.54962838e-01f, -1.43426582e-01f, -2.14585319e-01f, -2.66803019e-02f, -2.11896021e-02f, -5.22119664e-02f, 9.77455229e-02f,
  5.50507784e-01f, -1.45488858e-01f, -6.40482549e-03f, -5.65064233e-03f, -1.70161590e-01f, -6.80188835e-02f, -1.17801689e-01f, -1.09387627e-02f, 1.41209453e-01f, 5.05258515e-02f,
  2.32349247e-01f, 3.22498769e-01f, 2.85686791e-01f, 2.99459934e-01f, 2.25541040e-01f, -3.60974036e-02f, -1.42216340e-01f, 3.03622223e-02f, 4.24740314e-02f, -5.92103787e-02f,
  4.69092950e-02f, -1.39362738e-01f, -5.57113513e-02f, 6.94299415e-02f, -1.23463742e-01f, 5.93298636e-02f, 4.33424339e-02f, -3.45700793e-02f, 4.67933677e-02f, -8.28939825e-02f,
  -1.78861678e-01f, 2.11173207e-01f, 1.55126527e-01f, 7.16332272e-02f, -5.40665239e-02f, -9.68225226e-02f, 5.53442203e-02f, 6.11961447e-03f, -8.00616741e-02f, -9.98971313e-02f,
  -6.79833665e-02f, -8.04779455e-02f, -7.35472292e-02f, -5.67464344e-02f, -1.01249024e-01f, -6.52457103e-02f, 5.11294752e-02f, 7.02346638e-02f, 1.05593078e-01f, 8.82621109e-03f,
  1.96364094e-02f, 6.25451654e-03f, -8.27275030e-03f, 1.41608670e-01f, 1.90585747e-01f, 1.68183055e-02f, 1.09727951e-02f, 1.04889221e-01f, 1.79743886e-01f, 2.20285013e-01f,
  7.57121146e-02f, 1.88158691e-01f, 1.57309532e-01f, 3.77760567e-02f, 1.15433082e-01f, 1.36822537e-01f, -3.33363712e-02f, -1.14238076e-02f, 8.51346403e-02f, 2.14126948e-02f,
  -6.35946617e-02f, 9.56042632e-02f, 5.62173203e-02f, 5.73368685e-04f, 9.69338045e-02f, -2.53564417e-02f, -1.43777266e-01f, 1.43054165e-02f, 1.28536373e-01f, -2.23904178e-02f,
  7.49620944e-02f, -2.77155191e-02f, -5.03796674e-02f, -4.91869897e-02f, -6.89608008e-02f, 3.23222093e-02f, -9.11229253e-02f, 3.36050279e-02f, -1.19798973e-01f, -1.78804979e-01f,
  -2.20569387e-01f, 3.79256636e-01f, 7.75880143e-02f, -8.86923261e-03f, -1.64216965e-01f, -1.42883465e-01f, 2.74607539e-02f, -5.50278686e-02f, -3.09104770e-01f, -6.11353740e-02f,
  -1.45732284e-01f, -5.13161998e-03f, -9.14748479e-03f, -1.17929105e-03f, -7.62231797e-02f, -6.67800903e-02f, 5.04705496e-02f, -2.90973447e-02f, -2.95585371e-03f, -2.13356867e-01f,
  -4.49562110e-02f, -3.10930870e-02f, 9.10169110e-02f, 1.36477977e-01f, 5.96066862e-02f, 1.42673254e-01f, -6.90213740e-02f, -1.42128006e-01f, 4.72533591e-02f, 6.27846420e-02f,
  6.64672256e-01f, 6.20325506e-01f, 3.34121972e-01f, 2.28938550e-01f, 5.39450627e-03f, -1.58621654e-01f, -3.82476263e-02f, -1.62242323e-01f, -1.19526140e-01f, 2.30618715e-01f,
  1.88947946e-01f, -6.87501654e-02f, -1.97769180e-01f, -2.26133123e-01f, -8.38753581e-02f, -4.76692319e-02f, 8.72932598e-02f, 8.49271938e-02f, -2.27829397e-01f, -5.00594005e-02f,
  -8.97067189e-02f, 1.93591446e-01f, 1.07883796e-01f, -5.70362769e-02f, 1.60147741e-01f, -1.63989708e-01f, -3.36066447e-02f, 2.95879006e-01f, 1.42547622e-01f, 3.83638799e-01f,
  3.18099827e-01f, 3.31217051e-01f, -6.01524949e-01f, 2.75569037e-02f, 1.25343487e-01f, -9.92463827e-02f, -4.99420613e-02f, 1.03115074e-01f, 7.89812356e-02f, -6.74373843e-03f,
  1.44319475e-01f, 2.08979920e-01f, 2.05392525e-01f, 7.18195513e-02f, 3.79994698e-02f, -1.95433855e-01f, 5.41466940e-03f, 2.62175687e-02f, -1.95016250e-01f, 1.56114697e-01f,
  2.90962905e-02f, 3.24434727e-01f, 1.41407594e-01f, -3.12190771e-01f, -9.27757919e-02f, -1.85183093e-01f, -1.98274665e-02f, 7.54361972e-02f, -2.32721314e-01f, -1.81478029e-03f,
  -1.72599927e-01f, 6.45728037e-02f, 1.29579663e-01f, 8.53319094e-02f, -5.36121652e-02f, 2.34335959e-02f, 1.09287776e-01f, 8.47248212e-02f, -1.09945713e-02f, 1.17087938e-01f,
  -1.13697849e-01f, -1.26562461e-01f, -4.78098616e-02f, -8.06254372e-02f, -1.64954409e-01f, 1.23418786e-01f, -5.10629229e-02f, -9.63784605e-02f, 2.07430199e-02f, -1.60348732e-02f,
  7.29369447e-02f, -1.05912670e-01f, -3.52114886e-02f, -5.33658918e-03f, -9.51742306e-02f, -8.54373723e-02f, -5.14048263e-02f, -1.42649904e-01f, -7.53000900e-02f, -9.10397246e-02f,
  -3.37886214e-01f, -3.74782681e-01f, -7.52831548e-02f, -5.28953336e-02f, 2.95765907e-01f, -7.11289719e-02f, -1.39509976e-01f, 9.39270109e-03f, 1.12719968e-01f, -1.73904803e-02f,
  1.80059969e-01f, -5.21307439e-02f, -2.20686551e-02f, -1.32617041e-01f, -4.91951443e-02f, -1.69990927e-01f, 4.52037416e-02f, -4.08975035e-02f, -8.58563408e-02f, 2.02313393e-01f,
  -3.75348963e-02f, -2.72200733e-01f, -2.63446391e-01f, -4.28793311e-01f, -2.40271106e-01f, -6.30547762e-01f, -3.56869072e-01f, -2.19396114e-01f, -4.50855672e-01f, -4.57965076e-01f,
  8.12033772e-01f, -6.65772557e-02f, 2.62237012e-01f, 3.83452140e-02f, -4.70165789e-01f, -1.90989032e-01f, -1.21988401e-01f, 7.48863909e-03f, 2.55407393e-02f, -1.10927075e-01f,
  -1.84436247e-01f, -1.78181771e-02f, 3.57711948e-02f, 1.44208729e-01f, 2.23374844e-01f, 3.01193297e-02f, 5.44929504e-02f, 3.35937977e-01f, 2.63788581e-01f, -1.85851485e-01f,
  -8.52881595e-02f, 1.08856574e-01f, 2.31705308e-01f, 1.04613319e-01f, -1.73561677e-01f, 4.22401354e-02f, 2.01612711e-02f, -5.12177777e-03f, -7.48328418e-02f, 1.06938984e-02f,
  -1.84480771e-02f, 2.86474138e-01f, 1.19789265e-01f, 1.24263637e-01f, 7.08153099e-02f, 7.64426962e-02f, 8.47806856e-02f, -2.92529017e-02f, -2.55823284e-01f, -1.47387072e-01f,
  1.36490157e-02f, 3.45482342e-02f, 6.31633177e-02f, -8.38488564e-02f, -1.75690174e-01f, 3.72209139e-02f, 8.16317126e-02f, 3.86118330e-02f, -2.74214186e-02f, -2.98909354e-03f,
  -1.29040465e-01f, -1.15748942e-01f, -2.36706913e-01f, -2.78710611e-02f, 1.40639871e-01f, 3.30921672e-02f, -4.31849770e-02f, 6.20629527e-02f, 6.22005202e-03f, -4.40140069e-02f,
  9.73391086e-02f, 1.42632157e-01f, -7.30447564e-03f, 2.78826468e-02f, 6.07891046e-02f, -1.89732686e-02f, -1.07009150e-02f, -5.60312122e-02f, 1.30184367e-01f, 2.42428929e-02f,
  -2.58384556e-01f, 7.21809268e-03f, 7.58357719e-02f, -1.81120690e-02f, 1.51443779e-01f, -6.21332899e-02f, -3.28971855e-02f, 5.08700497e-02f, 4.96753082e-02f, -5.19519020e-03f,
  1.94997434e-02f, -4.13702540e-02f, -1.20066017e-01f, 6.15290739e-03f, -1.43824413e-01f, 2.70194467e-02f, -3.37791778e-02f, -1.59307905e-02f, -4.23595309e-02f, -2.36238446e-02f,
  -2.94411868e-01f, 3.83788913e-01f, 1.63221762e-01f, 2.38516003e-01f, 1.21832900e-01f, 6.07881658e-02f, 2.67587692e-01f, -4.81436551e-02f, -8.83127078e-02f, -6.02305355e-03f,
  4.39055264e-02f, 2.56276011e-01f, 1.00661129e-01f, -8.10783505e-02f, -7.44806752e-02f, -1.75098088e-02f, 8.46144259e-02f, 4.66005616e-02f, -9.60960798e-03f, -1.30840644e-01f,
  9.06111579e-03f, -1.57200247e-01f, -8.17446262e-02f, -4.88821082e-02f, 1.11432321e-01f, 2.71261837e-02f, -1.18423186e-01f, -1.09564908e-01f, -6.60879835e-02f, -1.80147037e-01f,
  -4.78390038e-01f, 2.08322823e-01f, -1.63440350e-02f, -1.52970225e-01f, 3.36271197e-01f, 2.86930859e-01f, 5.10071397e-01f, 2.08685055e-01f, 5.79608940e-02f, 5.59912659e-02f,
  -2.31601700e-01f, -2.79023796e-01f, -2.90527701e-01f, -1.51480108e-01f, 3.86820585e-02f, 2.15004429e-01f, 1.74872816e-01f, -5.23027889e-02f, -1.73268810e-01f, 9.08075869e-02f,
  1.68895692e-01f, -1.15913741e-01f, -4.08123314e-01f, -8.04352015e-02f, -6.84775226e-03f, -9.40316468e-02f, -1.17806323e-01f, -2.00733691e-02f, 5.46269529e-02f, -1.82830952e-02f,
  -3.65347266e-01f, -2.00947180e-01f, 5.66804316e-03f, -2.87187368e-01f, -2.42142260e-01f, -1.24688737e-01f, -9.70094129e-02f, -2.29337931e-01f, -1.61917940e-01f, -8.61740187e-02f,
  -4.76044938e-02f, -6.55995756e-02f, 3.45734581e-02f, 1.12869769e-01f, 1.04118280e-01f, -1.59854181e-02f, 9.28191170e-02f, -1.92118496e-01f, -7.55727515e-02f, -9.50942487e-02f,
  1.64591700e-01f, 5.63553683e-02f, 7.32414424e-02f, 2.48832136e-01f, 1.22327387e-01f, 4.58760373e-02f, 5.70972674e-02f, 5.65438811e-03f, -6.33004233e-02f, -2.16736048e-01f,
  1.94896571e-02f, 3.60571668e-02f, -6.33652583e-02f, 4.38700765e-02f, 3.52993645e-02f, 5.16682230e-02f, 9.29342583e-02f, -4.02195156e-02f, 8.70077536e-02f, 1.31322499e-02f,
  -4.27983701e-03f, -1.09301731e-01f, -1.07436679e-01f, -1.96357623e-01f, -1.13542683e-01f, -1.26202768e-02f, -1.36886844e-02f, -1.01108260e-01f, -1.07043117e-01f, -1.16443187e-01f,
  1.17224501e-02f, 1.66526526e-01f, -1.59271181e-01f, 5.79510629e-02f, -7.03286305e-02f, -1.15860254e-01f, -1.98586117e-02f, -1.32158130e-01f, -8.98895971e-03f, -7.39966407e-02f,
  -2.30374068e-01f, -2.49233186e-01f, -2.95651443e-02f, 1.47394374e-01f, -2.05071680e-02f, -1.21972233e-01f, -2.48520896e-01f, -2.01645136e-01f, -2.20379271e-02f, -5.00796735e-03f,
  -4.09489609e-02f, -8.24641958e-02f, -2.42683049e-02f, 1.95146371e-02f, -8.93506501e-03f, 9.39124674e-02f, 9.61661432e-03f, 9.71165299e-02f, 2.09413078e-02f, -8.67435113e-02f,
  7.99019188e-02f, 1.88188359e-01f, 4.29327041e-02f, 1.37618989e-01f, 2.08855048e-01f, 2.15297602e-02f, 3.30582559e-02f, -3.14891189e-02f, 8.79149064e-02f, 1.49159014e-01f,
  -1.83710799e-01f, -4.25904349e-04f, -3.43952447e-01f, -4.21499640e-01f, -1.64682820e-01f, -4.74617928e-02f, -4.59872298e-02f, 5.50869927e-02f, -2.06595868e-01f, -1.80306807e-01f,
  -7.21027283e-03f, 4.16372329e-01f, 5.91295632e-03f, 2.93888301e-01f, 3.03008914e-01f, -1.39484555e-01f, -4.20363486e-01f, -1.02593862e-01f, 4.64727491e-01f, 4.64401573e-01f,
  8.57372656e-02f, -2.11366534e-01f, -1.21248066e-01f, -8.38600844e-02f, -2.13927865e-01f, 8.47408101e-02f, -3.65563869e-01f, -3.13332468e-01f, -1.02572471e-01f, -5.46789825e-01f,
  3.59359622e-01f, -2.43930966e-01f, 1.15659554e-02f, -1.19026318e-01f, -7.03390390e-02f, 1.52171068e-02f, 1.17870905e-01f, -1.22649394e-01f, -8.84609222e-02f, -1.14279084e-01f,
  -2.06580982e-01f, -2.20378535e-03f, -1.36155784e-01f, 1.46687612e-01f, -2.29153875e-02f, -4.19516154e-02f, -1.23138852e-01f, -1.13712482e-01f, -1.92962170e-01f, 1.23940501e-02f,
  -1.22584939e-01f, -1.96343109e-01f, -5.83257973e-02f, -1.09194897e-01f, 1.23364162e-02f, -1.43266678e-01f, -5.37505001e-02f, -1.75529689e-01f, -1.11001112e-01f, -4.08357590e-01f,
  -3.45876962e-02f, -1.21867526e-02f, -7.35758990e-02f, -2.95827538e-02f, -5.36703765e-02f, -9.91511941e-02f, -1.48211837e-01f, 1.03827780e-02f, -9.07550305e-02f, 8.92771035e-02f,
  -8.79140049e-02f, -4.79832254e-02f, -5.76710850e-02f, -1.35671034e-01f, -1.37526065e-01f, -1.12169363e-01f, -1.46491621e-02f, 5.57303913e-02f, -1.68817807e-02f, -6.60127029e-02f,
  3.93313775e-03f, -6.19441532e-02f, -1.22833073e-01f, 2.05253035e-01f, -2.21811011e-02f, -6.25563711e-02f, -2.32652389e-02f, 7.84972459e-02f, 1.36195135e-03f, -6.49343207e-02f,
  2.41251022e-01f, -2.05300823e-02f, 2.67109908e-02f, -3.42446268e-02f, -3.70592549e-02f, 3.90365757e-02f, -9.38584507e-02f, 6.92476779e-02f, -6.37478158e-02f, 1.66619465e-01f,
  1.07192487e-01f, 6.14434630e-02f, -1.41470199e-02f, 2.10555792e-02f, -1.03915118e-01f, -3.39948274e-02f, 2.26990446e-01f, -2.36446187e-02f, -8.10214281e-02f, -7.82780126e-02f,
  -1.37802482e-01f, -4.58268374e-02f, 2.99057961e-01f, 9.59427729e-02f, -2.10166071e-02f, 5.67506365e-02f, 2.16993883e-01f, 1.62101671e-01f, 1.71077132e-01f, 6.55077398e-02f,
  -5.61623096e-01f, 5.93368649e-01f, 1.92413688e-01f, -4.62061584e-01f, 4.11069512e-01f, 4.42755103e-01f, 8.20373356e-01f, 1.04886383e-01f, -1.62848935e-01f, 1.98776990e-01f,
  2.03721657e-01f, -2.60658830e-01f, -1.04668058e-01f, -7.98469037e-02f, 3.37383486e-02f, 4.42348450e-01f, 1.59440100e-01f, -1.56652659e-01f, -2.25272730e-01f, 5.10550626e-02f,
  -2.07388662e-02f, -2.73962021e-01f, -3.54239166e-01f, -1.71037793e-01f, -1.69307470e-01f, -3.41265559e-01f, 3.10475957e-02f, -3.55202034e-02f, 2.49028251e-01f, -3.31674278e-01f,
  -9.61239040e-02f, 8.01601782e-02f, 2.74808574e-02f, -1.95961118e-01f, 4.58510108e-02f, -1.30714372e-01f, -5.18745221e-02f, -1.86775282e-01f, 4.95114326e-02f, -9.07390863e-02f,
  -5.27829155e-02f, 5.92002459e-02f, 1.39472103e-02f, 5.00424532e-03f, -2.69268043e-02f, -3.68511747e-03f, -6.24561422e-02f, -4.29067351e-02f, -3.10254749e-02f, 8.43719840e-02f,
  8.03210139e-02f, 5.19596003e-02f, 5.24203628e-02f, 1.76665112e-01f, 8.60876888e-02f, -1.91852316e-01f, 1.20013788e-01f, -7.30608627e-02f, 9.64872260e-03f, -3.45338702e-01f,
  -1.56590015e-01f, -2.04890165e-02f, 9.13183242e-02f, -1.12750165e-01f, -4.72938232e-02f, 1.42535074e-02f, -6.24603219e-02f, 5.29035814e-02f, 5.58387041e-02f, -5.80807962e-02f,
  1.02350563e-01f, 4.04303148e-02f, 2.20130626e-02f, 4.79751639e-02f, -2.33442709e-02f, -1.03553422e-02f, 1.25395447e-01f, 5.18779457e-02f, 1.39877662e-01f, 9.80765466e-03f,
  -9.71193612e-03f, 5.28245829e-02f, -4.37171943e-02f, -4.29226868e-02f, 5.95553480e-02f, -1.11987591e-01f, -8.83157626e-02f, 7.14505836e-03f, -7.04550222e-02f, 8.68919268e-02f,
  -3.89013559e-01f, 4.57047880e-01f, -2.35170886e-01f, 1.03792073e-02f, 3.66188549e-02f, -2.47888975e-02f, 8.58873650e-02f, 4.61476520e-02f, 8.25911686e-02f, -1.46381229e-01f,
  1.15574077e-01f, -6.58768928e-04f, -2.42646574e-03f, 4.66254354e-02f, 6.43095374e-03f, -1.51121870e-01f, 3.94730493e-02f, -1.43503219e-01f, 4.31299806e-02f, 3.24225277e-02f,
  2.44198348e-02f, 5.17089926e-02f, -2.20489874e-01f, -1.71259627e-01f, -5.77420034e-02f, -2.31290713e-01f, -7.86485225e-02f, -2.47164294e-01f, 3.72072533e-02f, -3.47489893e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  5.86081445e-01f, 7.64846325e-01f, 3.06331903e-01f, 3.50468904e-01f, 3.75425100e-01f, 5.88084698e-01f, 4.33401108e-01f, -2.59823471e-01f, 3.52073222e-01f, 2.94029742e-01f,
  5.90248764e-01f, 4.39743280e-01f, 6.42068028e-01f, 3.50032061e-01f, 5.82394063e-01f, 1.89277917e-01f, 4.22956109e-01f, 6.43295527e-01f, 1.71244606e-01f, 2.00190470e-01f,
  2.20812097e-01f, 4.53396440e-01f, 1.36018187e-01f, 4.96374488e-01f, 3.06471616e-01f, 4.23625797e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  3.39829065e-02f, 2.32313797e-01f, 1.26890868e-01f, -2.52541840e-01f, 1.20225340e-01f, -1.24510668e-01f, -1.96301997e-01f, 1.40130967e-01f, 9.62791312e-03f, 3.23385388e-01f,
  -1.18399240e-01f, -2.05996893e-02f, 1.37203321e-01f, -1.74591541e-01f, -2.01865554e-01f, 1.38669489e-02f, -1.11313671e-01f, -3.43700573e-02f, -1.17622398e-01f, 2.14181751e-01f,
  1.64863706e-01f, -1.57437325e-01f, -1.18404143e-01f, -6.85250610e-02f, 3.91245008e-01f, -2.91924953e-01f, 1.55917108e-01f, -4.62210476e-02f, -2.12527826e-01f, -1.68136761e-01f,
  -9.96455178e-02f, 1.48240790e-01f, -2.69828141e-02f, -3.78486626e-02f, 8.07734430e-02f, 4.73881736e-02f, 1.21077403e-01f, 3.12528402e-01f, 4.20665860e-01f, 2.19138116e-02f,
  -7.98429921e-02f, 2.22007960e-01f, -3.01024728e-02f, 1.14636272e-01f, 2.22349074e-03f, -1.73786610e-01f, -7.43328333e-02f, 1.88491449e-01f, -7.68086463e-02f, -1.67086974e-01f,
  3.88130873e-01f, -2.02083960e-01f, -1.39130026e-01f, -3.95548105e-01f, -1.19795285e-01f, 3.19415778e-01f, 2.09344551e-01f, 5.94034046e-02f, 4.58400846e-02f, -7.26295188e-02f,
  -1.04556255e-01f, 3.55384499e-01f, -3.80030364e-01f, 9.18585733e-02f, 4.50342894e-02f, 5.31166084e-02f, 5.06962575e-02f, 6.61520734e-02f, 9.20388401e-02f, -2.30463117e-01f,
  -3.82710874e-01f, 9.20479465e-03f, -2.03189086e-02f, -1.19041637e-01f, -1.34770811e-01f, -1.40609786e-01f, 1.35706618e-01f, 1.33341947e-03f, 2.28878424e-01f, 1.43643990e-01f,
  5.10254838e-02f, 5.49122654e-02f, -1.58209145e-01f, 1.26378655e-01f, 2.49500945e-02f, 1.68957710e-01f, 8.96349847e-02f, -1.83633491e-01f, 2.63178229e-01f, -1.32650703e-01f,
  2.45465219e-01f, -1.05765104e-01f, -1.07679956e-01f, -3.73122782e-01f, 3.21948975e-01f, -1.91317890e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -2.09310483e-02f, 3.22198629e-01f, 1.48723617e-01f, 9.45359021e-02f, -1.62683293e-01f, 2.29066864e-01f, 1.96737926e-02f, 4.14261103e-01f, -1.56065542e-02f, -3.47445905e-01f,
  -2.23455742e-01f, -1.83137972e-02f, -1.07324466e-01f, 5.72329313e-02f, -2.09479436e-01f, 5.52038968e-01f, 2.29698047e-01f, 1.31485403e-01f, 5.00467896e-01f, -9.64600816e-02f,
  5.70783794e-01f, 3.67734551e-01f, 1.15811206e-01f, -5.81423491e-02f, 4.23938036e-01f, -1.30824685e-01f, 2.20928609e-01f, -2.02775180e-01f, -8.54461715e-02f, -1.86040848e-01f,
  2.32422590e-01f, 6.73794627e-01f, 4.29881476e-02f, -1.23154193e-01f, -1.85585152e-02f, -4.07112539e-01f, -1.20779179e-01f, 4.33954507e-01f, -8.51970091e-02f, -4.02095206e-02f,
  5.46247251e-02f, 1.56949610e-01f, -3.31809402e-01f, 2.75967926e-01f, 3.38082284e-01f, -7.02530444e-02f, -1.23708688e-01f, 6.38381302e-01f, 2.68088341e-01f, 1.52609631e-01f,
  -1.73369706e-01f, -1.59190983e-01f, 7.12055638e-02f, -4.21914160e-01f, -3.17303151e-01f, -2.15975210e-01f, 2.63976455e-01f, 3.43447894e-01f, 3.09065431e-01f, 7.56502211e-01f,
  1.13326311e-01f, 3.00150961e-01f, -1.31694824e-01f, 7.04285264e-01f, 1.90067571e-02f, -1.14963239e-03f, 5.56276068e-02f, 1.92288309e-01f, 3.68000895e-01f, 2.65219599e-01f,
  3.91770154e-01f, 5.34063578e-01f, 5.43356091e-02f, -2.21196726e-01f, 6.38082027e-02f, 6.36115968e-02f, -2.72024442e-02f, -4.77944501e-03f, -2.42914066e-01f, 9.31036249e-02f,
  1.24932341e-01f, 4.61067319e-01f, -1.46071583e-01f, -5.90617880e-02f, -2.91975541e-03f, 2.15157624e-02f, -2.86716551e-01f, 3.05935740e-01f, -7.26141259e-02f, -4.49471623e-02f,
  2.45250612e-01f, -1.80441849e-02f, -1.18369140e-01f, -2.18698189e-01f, -1.54507309e-01f, -3.61265987e-01f, 2.10906595e-01f, 1.12468280e-01f, 1.27870679e-01f, -3.26421797e-01f,
  3.44430566e-01f, -3.78775626e-01f, 2.57930607e-01f, 7.94508338e-01f, -9.66714174e-02f, 6.11016810e-01f, 3.41162533e-02f, 7.78621957e-02f, 3.66757751e-01f, -1.46465108e-01f,
  -4.60540473e-01f, 5.29414296e-01f, -2.97574282e-01f, 4.96018380e-02f, -6.31176233e-01f, 2.71714240e-01f, -3.11500072e-01f, -4.15817887e-01f, -3.54991406e-01f, 4.97277141e-01f,
  3.72813642e-01f, -3.43084484e-02f, -3.13505858e-01f, 1.31673619e-01f, -3.76559556e-01f, -2.69379705e-01f, -3.61819446e-01f, -4.30808306e-01f, 3.99614930e-01f, 1.16516054e-01f,
  3.10223192e-01f, -2.60300577e-01f, -1.79398179e-01f, -1.25770733e-01f, -2.06937954e-01f, 7.62133896e-02f, 1.00312484e-02f, 1.56215459e-01f, -5.32186031e-01f, 6.36307836e-01f,
  -8.39282423e-02f, 1.26364371e-02f, 2.53228039e-01f, 6.77584469e-01f, -3.01346421e-01f, -6.50944233e-01f, 2.26480216e-01f, 4.04771596e-01f, 3.73001583e-02f, -1.68870881e-01f,
  1.03021257e-01f, 4.29735541e-01f, 5.09876430e-01f, 8.27082545e-02f, 1.24555230e-01f, 4.46065307e-01f, -4.79817204e-02f, 1.31421715e-01f, 1.35919645e-01f, 1.62945464e-01f,
  1.54353514e-01f, 2.63512760e-01f, 4.90342341e-02f, -9.50292274e-02f, 2.06583962e-01f, 1.89986199e-01f, -3.38790625e-01f, -1.69216841e-01f, -1.72007725e-01f, 1.22577555e-01f,
  -4.86855328e-01f, 1.44373834e-01f, 1.06359713e-01f, 1.08666144e-01f, 2.16977552e-01f, 3.91099721e-01f, 2.89334077e-02f, -3.48957598e-01f, 8.69101048e-01f, 4.83931512e-01f,
  3.97872627e-01f, 2.21864343e-01f, -1.62823364e-01f, 1.18112057e-01f, -1.08544663e-01f, -8.17765594e-02f, -7.92772993e-02f, 4.18551415e-01f, 2.38210289e-03f, 3.62896502e-01f,
  -4.23414982e-04f, 7.65559554e-01f, -9.67633054e-02f, 5.12343571e-02f, -9.04631242e-02f, -2.13483185e-01f, -4.71316166e-02f, 1.41564474e-01f, -5.47040284e-01f, 2.49589041e-01f,
  -3.02253842e-01f, 8.35358799e-01f, -8.18113238e-02f, -2.90371832e-02f, 4.09959197e-01f, 1.56997979e-01f, 1.88929871e-01f, 3.63129914e-01f, -2.03242555e-01f, -1.66010827e-01f,
  2.67226696e-01f, 5.76341391e-01f, 2.77153909e-01f, 1.46397024e-01f, -2.28506312e-01f, -3.28669697e-01f, 3.88258547e-01f, 2.35863551e-02f, -1.19505703e-01f, 3.26433599e-01f,
  -2.75206327e-01f, 5.54130614e-01f, 4.94391061e-02f, 9.48070824e-01f, 6.80660158e-02f, 1.68038785e-01f, 1.98387831e-01f, 7.38552883e-02f, -2.22089171e-01f, -2.25351483e-01f,
  4.14975196e-01f, 1.78703159e-01f, 3.16930830e-01f, 1.95781052e-01f, -3.65642756e-02f, 2.40180731e-01f, -1.94563642e-02f, -1.66058704e-01f, 1.05187774e-01f, 1.62026197e-01f,
  5.32968789e-02f, 7.16175810e-02f, -4.35797200e-02f, -2.72577778e-02f, 3.88884932e-01f, 9.40043554e-02f, 7.09484100e-01f, -3.60091060e-01f, 2.80693233e-01f, -2.06919223e-01f,
  3.59062068e-02f, -3.24931383e-01f, -2.08309501e-01f, 2.37383321e-01f, 5.85040212e-01f, 2.89554954e-01f, 8.36783797e-02f, 1.21870540e-01f, 1.30241007e-01f, -2.46882695e-03f,
  -2.53344685e-01f, -2.37121895e-01f, 5.42691529e-01f, 6.36821836e-02f, 1.06103353e-01f, 6.61031902e-01f, 3.39298040e-01f, 4.20432687e-02f, 3.72886360e-01f, 2.81279515e-02f,
  4.16517913e-01f, -1.06299572e-01f, -8.10969039e-04f, -3.79301339e-01f, 1.96980760e-01f, 9.54301283e-02f, -2.73339480e-01f, -8.56995136e-02f, 6.98599100e-01f, -1.36818737e-01f,
  -2.01381996e-01f, -3.84318322e-01f, -1.39436826e-01f, -1.83701906e-02f, -2.69993365e-01f, 5.22143900e-01f, 5.16310692e-01f, 1.10666521e-01f, 2.01578051e-01f, 5.64653128e-02f,
  1.83318734e-01f, -3.93910319e-01f, 1.83081716e-01f, -8.49730492e-01f, -2.67082781e-01f, 4.89657104e-01f, 3.78478438e-01f, 4.15457375e-02f, 1.68092683e-01f, -1.28645539e-01f,
  2.24232405e-01f, -2.85095960e-01f, -1.42079860e-01f, -3.62945557e-01f, 2.10225925e-01f, 1.15537494e-01f, -7.08396673e-01f, 2.10615516e-01f, 2.04497620e-01f, 6.02949739e-01f,
  -8.53102878e-02f, 3.69445682e-01f, 6.80456832e-02f, 9.60911512e-02f, 2.87723422e-01f, 3.59884977e-01f, 3.73671085e-01f, -6.35275900e-01f, 2.91929126e-01f, -6.81571066e-01f,
  7.81237110e-02f, 3.75294276e-02f, 2.81749237e-02f, -3.23585540e-01f, -2.21837801e-03f, 8.88601318e-03f, -4.12783265e-01f, 4.57789302e-01f, -2.31437564e-01f, 1.68882668e-01f,
  -1.01983860e-01f, 2.30706975e-01f, -8.83894414e-02f, -1.06300846e-01f, 5.07923700e-02f, 1.55578092e-01f, -1.75263286e-01f, -2.67176032e-01f, -4.29674685e-01f, 4.99259323e-01f,
  4.60457653e-01f, 3.81570041e-01f, -1.51810691e-01f, -1.99305803e-01f, 3.87387127e-01f, -1.72806308e-01f, 1.11727603e-03f, 4.14657816e-02f, -2.97139585e-01f, 1.49868175e-01f,
  1.89297944e-01f, 1.47663072e-01f, -2.58250665e-02f, 2.49022275e-01f, 3.32854837e-01f, 2.07362548e-01f, -1.03411630e-01f, 4.29436751e-02f, 6.57611489e-01f, 3.52706313e-01f,
  3.67558748e-02f, 3.15487295e-01f, 1.80970430e-01f, 1.50435446e-02f, 3.72891068e-01f, -2.09261477e-01f, 3.16791564e-01f, 2.61870753e-02f, 2.58170545e-01f, 1.60410553e-01f,
  -2.86737710e-01f, 1.59932837e-01f, 2.96337098e-01f, -1.45262018e-01f, 4.11865056e-01f, -2.97220618e-01f, 1.63905963e-01f, -1.99604407e-01f, -6.42105937e-02f, -4.97515678e-01f,
  -3.34470689e-01f, 5.03708482e-01f, 4.48372573e-01f, -7.28580207e-02f, 9.72617790e-02f, 7.29064345e-02f, 2.55394638e-01f, 1.74974635e-01f, 3.44364941e-01f, -1.88839689e-01f,
  -3.71026457e-03f, -4.26730424e-01f, 6.46515369e-01f, -3.28405589e-01f, 7.79556334e-02f, 2.33470604e-01f, 1.57304600e-01f, -9.83854830e-02f, 3.73769581e-01f, 2.35404875e-02f,
  3.20014298e-01f, 1.92482784e-01f, 1.58833399e-01f, 1.39339924e-01f, 1.03077367e-01f, 7.97656775e-01f, -1.21892683e-01f, 2.45970264e-01f, 1.37512788e-01f, 3.63201015e-02f,
  2.95568764e-01f, -9.38807949e-02f, 2.26397663e-01f, -1.45363778e-01f, 1.65421084e-01f, -4.77214515e-01f, 2.67339379e-01f, 1.99976489e-01f, 2.81442523e-01f, -2.09614821e-02f,
  3.06129128e-01f, -5.13055742e-01f, -2.41836786e-01f, 1.47912100e-01f, 3.83110285e-01f, 5.99014126e-02f, 1.12720579e-01f, 2.92730898e-01f, -2.40454584e-01f, 3.17382902e-01f,
  1.17100798e-01f, -1.77851960e-01f, -4.03783768e-02f, 1.19333550e-01f, -2.67989457e-01f, 4.71334457e-01f, 1.20643325e-01f, 6.24792814e-01f, -3.24000627e-01f, 5.56288958e-01f,
  2.17038050e-01f, -5.28528057e-02f, 5.39244036e-04f, 1.28313780e-01f, 5.54235041e-01f, -6.08158231e-01f, 4.01286520e-02f, -6.44609153e-01f, 7.85427317e-02f, 9.52727720e-02f,
  1.29127309e-01f, -1.02230646e-01f, -3.70501518e-01f, 5.25924206e-01f, 1.32635877e-01f, 2.40951642e-01f, 3.83938965e-03f, -2.58536428e-01f, -3.51888746e-01f, 3.74105334e-01f,
  -5.55538237e-01f, 3.73058976e-03f, -2.83479333e-01f, 4.86122556e-02f, -8.37516859e-02f, 1.88425809e-01f, 2.95322388e-01f, -3.84070445e-03f, 3.18056732e-01f, -2.36667365e-01f,
  -2.92814076e-01f, 2.80819573e-02f, 3.66213590e-01f, 4.62041080e-01f, 1.55447721e-01f, 5.56469917e-01f, -9.26742330e-02f, 2.71596521e-01f, 2.36838639e-01f, 7.49253690e-01f,
  -3.37130502e-02f, 7.91678950e-02f, 2.21430436e-01f, -4.59008291e-02f, 3.85002434e-01f, -1.30312800e-01f, 4.64429826e-01f, 1.55199036e-01f, -3.76794130e-01f, 1.16944142e-01f,
  4.55058455e-01f, 7.15564311e-01f, 4.61440682e-01f, -1.38013009e-02f, 1.35150880e-01f, 4.00494218e-01f, 2.55116910e-01f, 3.29187363e-01f, -4.62444097e-01f, 1.34816527e-01f,
  -3.42499465e-01f, -2.34665096e-01f, -1.37284100e-01f, 2.70866066e-01f, -6.41976669e-02f, 5.65451920e-01f, -1.91185638e-01f, 5.44108689e-01f, -8.79434720e-02f, -1.29033729e-01f,
  -3.72073442e-01f, -2.64764696e-01f, 1.96446568e-01f, 1.53712988e-01f, 1.18929863e-01f, -1.33329824e-01f, -4.28937115e-02f, -4.48780298e-01f, -3.18366528e-01f, 3.56367320e-01f,
  1.55333877e-01f, 3.28853250e-01f, -2.58520804e-03f, -1.47413313e-01f, 2.26157337e-01f, 5.00161760e-02f, 5.87643050e-02f, 3.04964364e-01f, -8.92970636e-02f, 6.15408197e-02f,
  1.11828335e-02f, 6.54637992e-01f, 5.27582645e-01f, 6.02376759e-01f, 2.72064358e-01f, 1.12744585e-01f, 4.80631560e-01f, -1.69570953e-01f, 3.24060261e-01f, -1.52589858e-01f,
  1.91333115e-01f, -4.83613372e-01f, 6.99486196e-01f, -3.77615035e-01f, 1.06598720e-01f, 4.12117004e-01f, 4.11577910e-01f, 2.01220334e-01f, 1.63744763e-01f, 3.55020195e-01f,
  8.10585856e-01f, -9.01308432e-02f, -1.58019572e-01f, -6.51553869e-01f, 3.62310618e-01f, 6.72998548e-01f, 4.30174591e-03f, 5.61466739e-02f, -2.83075292e-02f, 1.39770791e-01f,
  2.49134034e-01f, -7.71575421e-02f, 5.73689818e-01f, 7.73698241e-02f, 1.45046994e-01f, 1.05037525e-01f, -1.62998885e-01f, 7.51542091e-01f, -2.77875394e-01f, 2.64013916e-01f,
  -3.57647240e-01f, 5.25040448e-01f, 1.47804603e-01f, -1.04392938e-01f, -3.38220924e-01f, -1.78082138e-01f, -2.47010529e-01f, 2.08470017e-01f, 4.02060039e-02f, 1.04496799e-01f,
  4.28508908e-01f, 3.22548807e-01f, 3.52062881e-01f, -3.08496594e-01f, 9.19897556e-02f, 3.01989429e-02f, 6.34743631e-01f, 1.70013666e-01f, 2.10725084e-01f, -2.32598349e-01f,
  4.79579270e-01f, -2.55438268e-01f, 4.04579431e-01f, 2.32885838e-01f, 6.62137806e-01f, -2.01471463e-01f, 2.11570442e-01f, 6.42148197e-01f, 1.53662890e-01f, -1.57310620e-01f,
  1.63942933e-01f, 4.94350493e-02f, -8.00253972e-02f, 2.28107899e-01f, 1.10731922e-01f, 4.22541022e-01f, -1.67401582e-01f, 6.51202857e-01f, -7.01097250e-02f, 1.18685797e-01f,
  -2.22030412e-02f, -1.49658993e-01f, 2.98681498e-01f, 2.13880748e-01f, -1.05401456e-01f, 3.06409985e-01f, 3.66916180e-01f, 6.83432281e-01f, 1.62540123e-01f, -5.21016061e-01f,
  3.49367738e-01f, 7.39020780e-02f, 1.48303835e-02f, -2.20845252e-01f, 1.81075230e-01f, 1.86363772e-01f, 1.32301152e-01f, 1.77509621e-01f, 3.62775683e-01f, 4.68112051e-01f,
  -1.60191402e-01f, -5.45120500e-02f, 2.69897521e-01f, -2.55136579e-01f, 3.02558988e-01f, -2.59857744e-01f, -9.53404531e-02f, 8.74904171e-02f, 3.50634195e-02f, 3.54745269e-01f,
  2.55907357e-01f, -3.38600436e-03f, 2.31740251e-02f, 2.88278490e-01f, 8.34960341e-02f, -2.83984877e-02f, 1.30203754e-01f, -1.06831491e-01f, 3.70271802e-01f, 1.10522881e-01f,
  -4.70512480e-01f, 4.42000240e-01f, 3.71178418e-01f, 1.73756793e-01f, -4.88152355e-02f, 4.62031484e-01f, -7.31010884e-02f, -3.96578223e-01f, 4.84405637e-01f, 2.82238573e-01f,
  1.10036217e-01f, -5.05647138e-02f, -1.42007664e-01f, 5.55346251e-01f, -2.80377388e-01f, -3.70436698e-01f, 2.32826546e-01f, 3.16568837e-02f, 7.18326820e-03f, 2.34102041e-01f,
  -3.66958261e-01f, -1.56091638e-02f, 1.00215927e-01f, 2.15499699e-02f, 1.96518674e-01f, -2.02731207e-01f, 3.76219213e-01f, 1.57898381e-01f, 4.01495069e-01f, 4.17505175e-01f,
  2.60981381e-01f, 7.41451502e-01f, 2.36544177e-01f, -1.99187443e-01f, 5.72124183e-01f, -2.72504508e-01f, -6.66763425e-01f, -4.35994178e-01f, -3.58303219e-01f, 1.59664862e-02f,
  -1.08105056e-01f, 2.83414632e-01f, -6.29830062e-02f, -1.82692483e-01f, -1.61969826e-01f, 6.22136950e-01f, 8.13031793e-02f, -1.58504769e-01f, -1.98144272e-01f, 2.16051027e-01f,
  -1.39050171e-01f, 2.24170193e-01f, -1.43262073e-01f, -3.92539829e-01f, 1.38470545e-01f, 1.33052245e-01f, 2.73138255e-01f, -2.14678332e-01f, -2.71866471e-01f, 3.60156655e-01f,
  5.68385839e-01f, 3.89781147e-01f, 2.12032005e-01f, 2.56647915e-01f, -2.22513944e-01f, -2.38761589e-01f, -7.56105855e-02f, -1.26455635e-01f, -5.60202956e-01f, 2.25462578e-02f,
  -2.26075247e-01f, 1.63342729e-01f, 4.92004722e-01f, -3.21551204e-01f, -9.40049216e-02f, -4.41049248e-01f, 3.30877960e-01f, 6.30098701e-01f, 2.54295588e-01f, 2.25288406e-01f,
  -2.67031938e-01f, 3.80214512e-01f, -3.37523632e-02f, 3.44710469e-01f, -1.13727279e-01f, 3.54441822e-01f, -8.23788643e-02f, 1.53619871e-01f, 2.18334973e-01f, 2.40448520e-01f,
  -1.28697306e-01f, 3.07880826e-02f, 1.96618035e-01f, 1.48700342e-01f, 3.41327101e-01f, 1.71810091e-01f, 5.23955047e-01f, 2.70292182e-02f, 2.97235310e-01f, -3.47145617e-01f,
  1.57313541e-01f, -3.20159733e-01f, 3.77742499e-01f, 8.98636132e-02f, 1.35140240e-01f, 2.75113415e-02f, 3.50913733e-01f, 3.80332410e-01f, 2.27021441e-01f, -2.53214002e-01f,
  6.04057722e-02f, 9.16579142e-02f, 2.91857928e-01f, -4.71462995e-01f, -1.98463708e-01f, 1.83530226e-01f, 4.01341856e-01f, 2.90335655e-01f, 2.67791420e-01f, 2.05812261e-01f,
  2.25291714e-01f, 6.28977362e-03f, -1.76247805e-01f, 1.87147126e-01f, 4.30720150e-01f, 1.17418289e-01f, 2.32834652e-01f, -6.53349578e-01f, -2.00133309e-01f, 6.44178167e-02f,
  -7.56171942e-02f, 5.61227910e-02f, 2.50175055e-02f, -3.50188643e-01f, 3.32581729e-01f, 2.53006935e-01f, -4.12591159e-01f, -2.99959332e-01f, -1.70031503e-01f, 1.95352271e-01f,
  4.03922796e-01f, 2.35838741e-01f, 4.61902805e-02f, 5.81778705e-01f, 1.88308001e-01f, 4.10425842e-01f, 3.21601301e-01f, -6.97970316e-02f, 6.00684047e-01f, -2.01085523e-01f,
  2.91924458e-02f, 1.35602459e-01f, 1.51121542e-01f, -8.89847502e-02f, 8.47801268e-02f, 3.63283455e-01f, 9.01349559e-02f, 4.81784761e-01f, 5.92890680e-02f, 5.46767533e-01f,
  -1.98598243e-02f, -7.65776575e-01f, 2.51727641e-01f, 1.32069483e-01f, -2.08128020e-01f, -2.54578054e-01f, -7.72082955e-02f, 2.19841912e-01f, -1.50674120e-01f, 3.24322790e-01f,
  2.19448015e-01f, 5.30735254e-02f, -2.30355859e-01f, -2.18297809e-01f, 2.69026179e-02f, -3.17063004e-01f, -2.69391350e-02f, -3.07730705e-01f, 4.08791676e-02f, 3.87528032e-01f,
  1.56286374e-01f, 2.95183044e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.92347780e-01f, 2.04283074e-01f, 3.59586626e-01f, 3.12918216e-01f, 3.63226712e-01f, 3.26325715e-01f, 1.08498037e-01f, 1.48284048e-01f, 2.20124379e-01f, 2.88128018e-01f,
  -9.48503911e-02f, 8.93040970e-02f, -7.50545263e-02f, 1.74831823e-01f, 1.10232644e-01f, 4.87659633e-01f, 5.36483042e-02f, 3.59903187e-01f, -4.24492434e-02f, 6.60128668e-02f,
  1.49845958e-01f, 4.33694959e-01f, 4.22801137e-01f, 1.68615475e-01f, 1.63530469e-01f, -1.47157326e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  6.34141043e-02f, -5.88178337e-01f, -3.19806904e-01f, -2.88913529e-02f, -3.06423992e-01f, -2.04617396e-01f, -2.76324525e-02f, -3.21888596e-01f, -2.13571936e-01f, -2.09890530e-01f,
  -8.03821087e-02f, -6.24214821e-02f, 2.67406195e-01f, -1.39801562e-01f, -2.59007096e-01f, 2.92835593e-01f, 2.86607832e-01f, 2.11634301e-02f, -6.98781312e-02f, 1.23655774e-01f,
  9.84083191e-02f, -8.05632532e-01f, 1.06398016e-01f, -6.71181858e-01f, -3.91551018e-01f, 1.90476596e-01f, -7.56739616e-01f, 1.69103935e-01f, -7.86172688e-01f, -1.87278371e-02f,
  -2.69472953e-02f, 3.45606029e-01f, 2.24100828e-01f, -4.74976838e-01f, -4.08289164e-01f, -8.19094032e-02f, -5.85844040e-01f, 3.13232303e-01f, -1.08160544e-02f, 1.67992815e-01f,
  4.53938060e-02f, -6.51518762e-01f, -7.54069567e-01f, -4.76283252e-01f, -2.98246533e-01f, 1.11247256e-01f, -1.66478127e-01f, 5.36084354e-01f, -2.14362498e-02f, -7.18218237e-02f,
  4.41971123e-01f, 4.14903760e-02f, -4.87256438e-01f, -2.86249425e-02f, 1.49979949e-01f, -3.49242985e-01f, 9.46740359e-02f, 1.74756899e-01f, -4.23113555e-01f, -3.61210108e-01f,
  -6.82583272e-01f, 2.66462058e-01f, 1.95811883e-01f, -1.14271507e-01f, -3.29898596e-02f, -8.21154192e-02f, 3.80133510e-01f, 1.78649053e-01f, 1.53644562e-01f, 3.36420350e-02f,
  3.24266821e-01f, -6.70737982e-01f, 3.78696923e-03f, -3.70661706e-01f, -3.25486436e-02f, 6.20754957e-01f, -2.65978962e-01f, -5.36882818e-01f, -4.66022760e-01f, -8.45219418e-02f,
  -7.11134553e-01f, -5.10762691e-01f, 3.40720832e-01f, 1.43578514e-01f, -3.36728662e-01f, -4.67369109e-01f, 2.11373165e-01f, 3.67432594e-01f, 2.59986103e-01f, 1.77080836e-02f,
  4.80993360e-01f, -1.33821800e-01f, -1.20852299e-01f, 7.59240612e-03f, -2.75481492e-01f, -2.82012492e-01f, -1.31371632e-01f, -1.39556810e-01f, -4.81992997e-02f, 1.36338025e-01f,
  2.43567571e-01f, -2.81818528e-02f, 3.06835562e-01f, 2.17540219e-01f, -6.08507037e-01f, -4.93300408e-01f, 1.43779188e-01f, 5.93464449e-02f, 1.39626667e-01f, 3.32194328e-01f,
  -2.38366708e-01f, -8.48359942e-01f, 1.01566263e-01f, -9.25324950e-03f, -5.22404552e-01f, -1.06457067e+00f, 3.48078907e-01f, -8.05002868e-01f, -9.33336020e-02f, -5.67547321e-01f,
  -1.09241223e-02f, 7.68404379e-02f, -2.61743069e-01f, -7.28376627e-01f, 2.04807997e-01f, 2.09935784e-01f, -5.39701402e-01f, -1.02084711e-01f, -6.26690686e-01f, 6.46497726e-01f,
  -4.19362485e-01f, 4.64673311e-01f, 3.63242149e-01f, 2.83605039e-01f, 1.25514328e-01f, 2.63181835e-01f, 2.65303701e-01f, 2.37713635e-01f, 4.58697915e-01f, -5.73656745e-02f,
  1.27897272e-02f, -1.40547715e-02f, -6.17846191e-01f, -3.63850832e-01f, 3.14011216e-01f, -9.05214474e-02f, 4.82914001e-02f, -1.69443309e-01f, -8.46198499e-02f, 2.69327760e-01f,
  -3.00159529e-02f, -7.42670521e-02f, -5.00006318e-01f, -1.72851995e-01f, 3.03642690e-01f, -7.23072648e-01f, -2.57588118e-01f, -4.44992632e-01f, -1.14012003e-01f, -4.03511934e-02f,
  2.83116043e-01f, 7.76241720e-01f, 4.71136928e-01f, 7.19331801e-01f, 2.62200564e-01f, 1.15116663e-01f, 9.90044028e-02f, -3.71813506e-01f, 5.34650505e-01f, 4.10668701e-01f,
  -5.68724573e-01f, -7.16068208e-01f, -3.56663585e-01f, -4.89357905e-03f, -7.21964240e-02f, 1.27433658e-01f, -2.82696873e-01f, 1.49654314e-01f, -3.88984025e-01f, -1.50546446e-01f,
  -3.09426188e-02f, 8.08754042e-02f, -9.88612697e-02f, -1.09783690e-02f, -1.43443003e-01f, 2.20083967e-01f, -4.51654017e-01f, 6.45261765e-01f, 4.97553438e-01f, 1.47227257e-01f,
  -8.59367475e-03f, 2.88711816e-01f, -3.56279612e-02f, 3.13682817e-02f, -4.75039259e-02f, -5.66689670e-01f, 2.11515337e-01f, -4.62104887e-01f, -8.33170295e-01f, -1.55267537e-01f,
  -3.82115133e-02f, -1.88123092e-01f, 1.41189337e-01f, -1.37372330e-01f, -1.11966324e+00f, -3.89502615e-01f, -7.09833682e-01f, 2.92044699e-01f, -2.57162452e-01f, -5.71044743e-01f,
  2.07136452e-01f, 1.88054368e-01f, 2.00693905e-01f, 5.38145863e-02f, -3.94321740e-01f, 5.26327372e-01f, -1.65732980e-01f, -5.14511645e-01f, 3.60151120e-02f, 3.22120786e-01f,
  5.30526757e-01f, -6.50810659e-01f, 4.63480860e-01f, -3.25358808e-02f, 1.34703159e-01f, -5.08578777e-01f, -2.86254257e-01f, -2.72310227e-01f, -4.20669988e-02f, -1.68843597e-01f,
  -4.61215794e-01f, -3.52403969e-02f, -3.98396283e-01f, -3.89711082e-01f, -2.70613939e-01f, 2.60986686e-01f, 3.00801098e-01f, -2.43616834e-01f, 3.66992205e-01f, -6.95749879e-01f,
  -2.86794603e-01f, -2.07453296e-01f, -9.62149650e-02f, -1.30704433e-01f, -3.55988055e-01f, -3.46633971e-01f, -2.43003517e-01f, -4.88945693e-01f, 9.66775045e-02f, 2.86553353e-01f,
  4.73909646e-01f, 1.73692226e-01f, 2.48222306e-01f, -1.49821073e-01f, -2.70459741e-01f, 2.44421467e-01f, -2.75906503e-01f, -2.55315542e-01f, 3.27234536e-01f, -3.61523300e-01f,
  6.57078803e-01f, -5.45297342e-04f, -6.32927477e-01f, -2.43128672e-01f, -2.49624446e-01f, -6.64732814e-01f, -4.61172134e-01f, 2.96227485e-02f, -1.60726383e-01f, 1.14961810e-01f,
  2.43212536e-01f, -7.05727339e-01f, -2.03382164e-01f, 2.83481866e-01f, 5.12642041e-02f, -4.96695727e-01f, -5.05432904e-01f, 4.10417289e-01f, -6.74945593e-01f, 4.31480736e-01f,
  4.86245334e-01f, -2.06479251e-01f, -1.85529977e-01f, -1.61362514e-01f, -3.38486820e-01f, 3.34050089e-01f, -6.77188067e-03f, -4.19785649e-01f, 1.67108446e-01f, 1.13961995e-01f,
  5.89050472e-01f, 3.77208620e-01f, -2.41791040e-01f, -2.17023551e-01f, -7.32893109e-01f, -7.32022896e-02f, -6.28760159e-01f, 6.40082419e-01f, 3.15512180e-01f, 5.91042340e-02f,
  1.98825717e-01f, -9.95193005e-01f, 9.58454534e-02f, 3.90399337e-01f, -2.64340878e-01f, -8.25913906e-01f, -3.44464034e-01f, 1.84757128e-01f, -4.90187168e-01f, 4.48816866e-01f,
  1.75574601e-01f, 4.34601083e-02f, -2.81107724e-01f, -2.44118616e-01f, 1.15406357e-01f, 3.29878688e-01f, 1.07580468e-01f, -4.00860220e-01f, -4.61661130e-01f, -7.56820202e-01f,
  3.04358631e-01f, 2.80670494e-01f, 1.71364710e-01f, -1.29913747e-01f, -1.89684376e-01f, 2.86575764e-01f, 4.05028882e-03f, -6.01234794e-01f, -4.51916516e-01f, -4.44302619e-01f,
  1.84630200e-01f, -1.56933352e-01f, -3.94805640e-01f, 6.14303887e-01f, 6.32983863e-01f, -4.82151061e-01f, -4.74682122e-01f, 3.93973142e-01f, -4.27347541e-01f, -5.48634768e-01f,
  -3.65236819e-01f, -5.30932844e-01f, 1.53181419e-01f, -4.00416136e-01f, -4.18894947e-01f, -6.98228300e-01f, -1.04177415e-01f, -3.83979023e-01f, 2.58016765e-01f, 4.82747108e-02f,
  4.03099507e-01f, -2.35714480e-01f, 3.25879633e-01f, -2.19966490e-02f, 8.62658545e-02f, -5.46416342e-01f, -6.49528054e-04f, -2.29650408e-01f, 1.22277066e-01f, 4.32747424e-01f,
  -4.59065065e-02f, -3.49979311e-01f, 2.29297820e-02f, 4.13530856e-01f, 3.32611889e-01f, -5.49276769e-01f, -4.56781447e-01f, -4.13951218e-01f, -4.39645708e-01f, -6.25300109e-01f,
  -5.56946874e-01f, -4.11334544e-01f, 4.75026071e-01f, 2.42423505e-01f, -7.03730762e-01f, 2.72109360e-01f, 1.61487624e-01f, -2.86859959e-01f, -6.46466911e-01f, -3.29694629e-01f,
  1.86458454e-01f, -3.09757739e-01f, 2.69751012e-01f, -4.56115395e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.64534801e-01f, -4.13251072e-02f, 1.03032373e-01f, -8.50086957e-02f, -7.68379048e-02f, -6.84266016e-02f, 8.70760903e-02f, 4.37775031e-02f, -9.45959333e-03f, 1.89672917e-01f,
  1.48258992e-02f, 2.72079352e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    