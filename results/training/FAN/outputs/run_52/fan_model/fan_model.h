/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.00001547e-02f, -1.24566570e-01f, 2.86073625e-01f, 2.21249331e-02f, -1.42111123e-01f, 1.72323450e-01f, 1.31994532e-02f, -8.68269708e-03f, 8.19794834e-02f, -3.02140713e-02f,
  -2.68962961e-02f, -6.32193312e-02f, -1.05678186e-01f, 1.92136183e-01f, -2.32677311e-01f, 4.00720462e-02f, -4.45738509e-02f, 8.43694285e-02f, -5.80197461e-02f, -1.65474772e-01f,
  3.68986987e-02f, -3.48223895e-01f, 1.91632479e-01f, -2.60360330e-01f, 4.92003150e-02f, 7.46116862e-02f, -2.65888512e-01f, -1.61317140e-01f, 9.63328555e-02f, -2.58114208e-02f,
  1.21453084e-01f, 6.72827587e-02f, 4.58071493e-02f, 5.05764037e-02f, 6.71492144e-02f, -5.75415008e-02f, -4.44580428e-02f, -1.70525641e-03f, 3.79017219e-02f, 4.88506556e-02f,
  -1.13677634e-02f, 3.61633277e-03f, -9.62911360e-03f, -4.12709489e-02f, 5.59542030e-02f, 1.93845648e-02f, 1.63951069e-01f, 2.01928079e-01f, 6.86607510e-02f, 1.74084812e-01f,
  6.04689717e-02f, 1.38664186e-01f, 1.33458883e-01f, 4.27119695e-02f, 3.17280963e-02f, 8.12346265e-02f, 1.90080151e-01f, 4.03043255e-02f, -2.79503129e-02f, 7.03970641e-02f,
  -1.75018199e-02f, -1.68391138e-01f, -9.43771657e-03f, 9.51826014e-03f, -5.37209027e-02f, 1.18071392e-01f, -9.83294025e-02f, -1.37609662e-04f, -2.21777838e-02f, -3.51843759e-02f,
  -1.87604502e-02f, 4.57305536e-02f, -6.35813922e-02f, -1.82799939e-02f, 5.86200617e-02f, 2.62130890e-02f, -3.52840461e-02f, -5.29341102e-02f, 1.71248522e-02f, 1.07222535e-02f,
  -4.90591675e-03f, 5.47710899e-03f, -1.21949658e-01f, 6.66018501e-02f, 5.75211421e-02f, -7.71875530e-02f, 2.83979345e-02f, 1.25770986e-01f, 6.31482154e-02f, -2.69524865e-02f,
  -3.61640364e-01f, -5.43673098e-01f, -7.23567083e-02f, 8.31473544e-02f, -1.45371603e-02f, 2.37297472e-02f, 2.48473044e-02f, 3.64716426e-02f, -1.60341486e-01f, 3.40156257e-03f,
  -6.85544387e-02f, 3.65526862e-02f, -9.24864933e-02f, 3.38073671e-02f, -7.73448497e-02f, 4.52234261e-02f, -8.91141966e-02f, -6.74079955e-02f, -2.08011061e-01f, -1.25623137e-01f,
  -6.31140098e-02f, -8.53425860e-02f, -5.80463149e-02f, -4.34870890e-04f, 2.91385893e-02f, -5.51461987e-02f, -2.82686930e-02f, 6.57288060e-02f, 1.52662825e-02f, -4.98206615e-02f,
  -8.02665725e-02f, 3.91816497e-01f, -3.48308831e-01f, -5.69965914e-02f, 1.59873441e-02f, 4.91624549e-02f, -9.64105651e-02f, 1.26962960e-01f, 9.70014855e-02f, 3.51687640e-01f,
  1.37628391e-01f, -1.70284554e-01f, 6.14557564e-02f, 3.61013085e-01f, -2.95254111e-01f, 1.86926275e-01f, 2.75026143e-01f, 4.52319309e-02f, -2.68286448e-02f, 9.84353498e-02f,
  -1.20155998e-01f, 3.96254003e-01f, -2.01333880e-01f, 2.26344705e-01f, -8.31083022e-03f, -2.91723728e-01f, 1.17722213e-01f, -1.35327786e-01f, 1.12136804e-01f, -3.40112927e-03f,
  1.04135528e-01f, 7.26584196e-02f, 4.71343799e-03f, -4.36194763e-02f, -3.76082957e-02f, 1.68789607e-02f, -8.16192701e-02f, -4.75465171e-02f, -1.74165785e-01f, -1.34443715e-02f,
  -2.02165470e-02f, 2.17984430e-02f, -6.63848445e-02f, -8.07607081e-03f, 9.56233498e-03f, 2.84623820e-02f, -1.13541512e-02f, -9.03921798e-02f, 5.06034829e-02f, -1.19359851e-01f,
  -8.41514096e-02f, -1.52242377e-01f, -2.66972017e-02f, -7.71717206e-02f, -1.09247878e-01f, 1.08571118e-02f, -3.76159279e-03f, -1.18138947e-01f, -2.75701308e-03f, 2.28973478e-02f,
  -7.32631283e-03f, 1.57561079e-02f, 4.95394052e-04f, 5.29651120e-02f, 3.28797251e-02f, -2.24224292e-02f, 8.59257877e-02f, 1.90579239e-02f, -9.87578183e-02f, 9.83011127e-02f,
  -3.86748463e-02f, 2.78265830e-02f, 6.69039860e-02f, 1.56668108e-02f, 6.47492930e-02f, -1.30122360e-02f, -6.52475953e-02f, 5.19781560e-03f, -3.02481712e-05f, -3.35743986e-02f,
  4.72379662e-02f, 6.53537214e-02f, 9.15040355e-03f, 7.07203001e-02f, 4.00919281e-02f, -7.44123980e-02f, 7.35542774e-02f, -2.03228202e-02f, 5.92004247e-02f, -3.46205458e-02f,
  4.07549053e-01f, 2.87255347e-01f, 5.63326217e-02f, -4.85801362e-02f, 8.33136961e-02f, -9.83206369e-03f, 5.26786596e-02f, -1.07729388e-02f, 1.00393809e-01f, 5.29457740e-02f,
  -3.13599929e-02f, -4.55244258e-03f, -5.05874865e-02f, -1.40723810e-02f, -1.27102835e-02f, -5.29045239e-02f, 1.37385689e-02f, 7.07822517e-02f, 3.46809998e-02f, 1.64522678e-02f,
  2.84170806e-02f, 2.60598045e-02f, -3.48913334e-02f, 1.46622956e-03f, 2.26310361e-02f, -3.93996164e-02f, 6.00090511e-02f, -5.99102192e-02f, 2.94204056e-02f, 4.20567803e-02f,
  8.51192698e-02f, -2.34630182e-01f, -2.09060103e-01f, -6.65849149e-02f, 3.41069341e-01f, 2.02643931e-01f, -2.22381391e-02f, 9.73910540e-02f, -3.38024437e-01f, -1.08542889e-01f,
  1.87525451e-01f, -1.01822406e-01f, -6.08060062e-02f, -5.41758426e-02f, 3.46875966e-01f, -3.12358379e-01f, 1.54924840e-01f, 9.52594802e-02f, -1.16231479e-01f, 2.83643484e-01f,
  -2.55097430e-02f, 2.98609197e-01f, 3.76640819e-02f, 1.56677917e-01f, 1.33133560e-01f, 6.60199076e-02f, 2.79295683e-01f, -2.01122947e-02f, 2.31703490e-01f, -3.47944424e-02f,
  5.43769971e-02f, -2.56116271e-01f, -1.12329513e-01f, -7.95779377e-02f, 2.18269005e-01f, 4.37218100e-02f, 2.71506943e-02f, 3.91261131e-02f, 4.26729955e-02f, 1.04587600e-02f,
  -3.11719850e-02f, 1.71891544e-02f, 2.43069082e-02f, -7.84063041e-02f, -6.30285591e-02f, -9.83973667e-02f, -1.29230320e-02f, -6.25023916e-02f, -1.61543503e-01f, -6.80739582e-02f,
  -1.19950138e-01f, -6.25460669e-02f, -3.92458849e-02f, -8.91872495e-03f, 2.00314578e-02f, -3.93743590e-02f, 1.10625681e-02f, 1.04879119e-01f, -6.25690669e-02f, 7.32422806e-03f,
  2.86135301e-02f, 6.15543537e-02f, 5.69059215e-02f, -9.76509601e-02f, 1.11289509e-01f, -7.58782029e-02f, -9.30819809e-02f, 6.12236299e-02f, 4.23255973e-02f, -1.32122058e-02f,
  1.35497436e-01f, 3.14295217e-02f, -8.25682655e-02f, 1.37440420e-05f, 1.01679720e-01f, -4.06242050e-02f, 1.30895805e-03f, 7.84983560e-02f, 4.68698591e-02f, 3.60836908e-02f,
  -7.18337744e-02f, 4.00986969e-02f, 1.54504970e-01f, -4.46586544e-03f, -7.96295106e-02f, 3.92950885e-02f, -7.18081519e-02f, -9.66985226e-02f, 1.70281660e-02f, 9.72800180e-02f,
  3.25214624e-01f, 2.80299038e-01f, 5.47603741e-02f, 3.77082080e-02f, -8.49240869e-02f, 5.28840907e-02f, -1.08216472e-01f, -3.27550843e-02f, 9.14197192e-02f, 1.14154220e-02f,
  8.66366625e-02f, 7.06558675e-02f, 6.95317471e-03f, 8.17394778e-02f, 6.55641109e-02f, 5.85282333e-02f, 3.47083360e-02f, 4.11298573e-02f, 1.28673121e-01f, 1.00739613e-01f,
  8.40172023e-02f, 1.93920940e-01f, -3.90896536e-02f, 7.27994367e-02f, 3.97119932e-02f, 2.58192271e-02f, 8.03715065e-02f, -7.07423612e-02f, 5.34257591e-02f, -2.21145395e-02f,
  -6.24630153e-01f, 1.48722708e-01f, 2.67153472e-01f, -1.34556636e-01f, -6.01720624e-02f, 4.99546260e-01f, 2.03801647e-01f, 9.28338245e-03f, -1.91861376e-01f, 1.91560060e-01f,
  4.18765917e-02f, -2.52033565e-02f, 1.14546165e-01f, 1.68679625e-01f, 4.11252946e-01f, 1.18073754e-01f, 2.66859621e-01f, 1.77713126e-01f, -1.78422242e-01f, 5.44569865e-02f,
  3.93071733e-02f, 7.00643584e-02f, 1.94140583e-01f, -1.99216262e-01f, -2.91266851e-02f, -1.65966377e-01f, 1.52490139e-02f, -6.25480860e-02f, 1.36257514e-01f, 5.92822023e-02f,
  -1.14876144e-01f, -2.80465484e-01f, -5.04238391e-03f, 9.71025079e-02f, -9.67251956e-02f, -1.27724841e-01f, 1.04892381e-01f, 1.23408483e-02f, -1.27163809e-02f, 8.81024897e-02f,
  5.00747003e-02f, -1.64734535e-02f, -6.95256665e-02f, 1.96086559e-02f, -3.18088867e-02f, -3.01190764e-02f, -5.53614635e-04f, 9.36024860e-02f, -6.80969656e-02f, 3.37671838e-03f,
  -3.22999060e-02f, 1.35192931e-01f, 1.74207389e-01f, 1.98155064e-02f, 1.85617153e-02f, 3.16187255e-02f, 5.82450479e-02f, -5.81189767e-02f, 8.51567239e-02f, -9.07575563e-02f,
  -1.08947530e-02f, 1.01320585e-02f, -1.21802213e-02f, 4.26383466e-02f, -7.16775134e-02f, -2.21095055e-01f, 2.41902862e-02f, -8.37082490e-02f, -1.07091337e-01f, -9.36539546e-02f,
  -4.90260199e-02f, 2.81122164e-03f, -5.69376945e-02f, 4.57618944e-02f, 2.73501202e-02f, 2.08945926e-02f, 9.27588567e-02f, -8.12019333e-02f, 3.12971249e-02f, 5.97366355e-02f,
  -2.13473290e-02f, 7.77212009e-02f, 7.01719299e-02f, 5.26292846e-02f, 1.00890800e-01f, 1.98580064e-02f, -9.39819738e-02f, 3.30200163e-03f, -1.72091108e-02f, 1.21486351e-01f,
  2.14213476e-01f, 1.44674540e-01f, -4.53149714e-03f, -3.88061516e-02f, -1.79250855e-02f, 1.40261784e-01f, 8.70303512e-02f, -6.26159012e-02f, 5.10188453e-02f, -2.71763224e-02f,
  1.48082264e-02f, -2.06454564e-02f, 1.38772413e-01f, -3.35289910e-02f, 1.28818573e-02f, 1.28715545e-01f, 3.63789275e-02f, -5.19885793e-02f, 1.17556274e-01f, 1.66004542e-02f,
  1.99191254e-02f, -2.91812271e-02f, -6.31088018e-02f, -1.44097432e-01f, -3.38614658e-02f, -6.01763092e-02f, 1.05059676e-01f, 5.55358268e-03f, 2.99581848e-02f, -6.68688118e-03f,
  -4.30236667e-01f, 3.12913060e-01f, 2.03246161e-01f, -2.58321822e-01f, -1.36086330e-01f, -1.54192328e-01f, -3.24321419e-01f, -4.34029959e-02f, -9.60554928e-02f, -2.47283746e-02f,
  -3.79116833e-01f, 2.67734200e-01f, -5.99872991e-02f, -4.32384342e-01f, -3.68818104e-01f, -6.84646592e-02f, -3.81114841e-01f, -4.67098989e-02f, 5.06176502e-02f, -8.10422674e-02f,
  -9.65041865e-04f, -4.35336351e-01f, -8.79978016e-02f, 7.92036280e-02f, -1.49773464e-01f, 2.36776888e-01f, -3.07579368e-01f, 3.01105738e-01f, -9.52360556e-02f, 1.87080391e-02f,
  -1.21981539e-01f, 1.34708295e-02f, 2.24271845e-02f, 1.16493449e-01f, -9.16531309e-02f, -2.39220317e-02f, 3.45410816e-02f, 1.32739156e-01f, -3.69751677e-02f, 2.28199381e-02f,
  8.04735497e-02f, 9.58344527e-03f, 3.51671241e-02f, 8.51037055e-02f, 6.69214055e-02f, 1.01848297e-01f, 1.96657460e-02f, 1.17315091e-02f, 3.04347416e-03f, -3.44618298e-02f,
  6.39419165e-03f, -2.69844593e-03f, -7.78587237e-02f, -5.59473336e-02f, 3.48098427e-02f, -1.01471931e-01f, 1.53885800e-02f, 7.63945803e-02f, 2.87962947e-02f, -1.99523475e-02f,
  -5.95084056e-02f, -8.12517107e-02f, -7.23024039e-03f, 3.86978290e-03f, 6.53930381e-02f, -4.44576377e-03f, -9.90021452e-02f, -3.31725068e-02f, 6.28561387e-03f, -2.52392795e-02f,
  -5.42783514e-02f, 1.26509026e-01f, -1.11259334e-01f, -2.71957871e-02f, -6.77668378e-02f, 1.38666956e-02f, -5.49422726e-02f, 3.50242071e-02f, -5.07888431e-03f, 6.00333586e-02f,
  3.82729508e-02f, -1.26233567e-02f, 7.00954869e-02f, -7.22005963e-02f, 6.78226398e-03f, 3.62665728e-02f, -1.81416925e-02f, 1.26779871e-02f, -4.10251915e-02f, -1.10142846e-02f,
  4.08028290e-02f, 7.52909705e-02f, -9.93811898e-03f, 2.03833301e-02f, 8.95224810e-02f, 3.88124883e-02f, -4.31061387e-02f, 2.03762259e-02f, 4.88330312e-02f, 7.74420192e-03f,
  -6.13174587e-02f, -8.79868865e-02f, -1.03074629e-02f, -1.08115159e-01f, -1.53097538e-02f, -7.00668320e-02f, -5.93138905e-03f, 2.56736460e-03f, -9.58744362e-02f, 4.04208526e-02f,
  5.68736382e-02f, -8.75793174e-02f, 8.13480392e-02f, 6.13017473e-03f, 4.20678669e-04f, -5.22674024e-02f, -5.31792548e-03f, 5.54840453e-02f, -8.67450163e-02f, -1.85667500e-02f,
  3.57198596e-01f, -3.02663613e-02f, -5.85717373e-02f, 5.84446013e-01f, -2.06196651e-01f, -1.07585810e-01f, 2.31840029e-01f, 1.54729977e-01f, 2.86973447e-01f, 2.01085493e-01f,
  8.51397589e-02f, -1.47360563e-01f, -2.17784002e-01f, 2.93963730e-01f, -4.30579424e-01f, -1.56760290e-01f, 3.12125742e-01f, 1.31503612e-01f, -8.97746086e-02f, 1.95956558e-01f,
  6.88575581e-02f, 2.11898029e-01f, -1.25923660e-02f, -1.11901075e-01f, 5.65370806e-02f, 1.74043357e-01f, -8.08810443e-02f, -9.87609848e-02f, 1.31824195e-01f, -1.08364634e-01f,
  -1.21253729e-01f, 2.58118600e-01f, 2.85705850e-02f, -1.86339300e-02f, 1.81065485e-01f, -1.03527438e-02f, 3.10211219e-02f, -1.18438855e-01f, -4.89403643e-02f, -9.39036533e-03f,
  -5.30792028e-02f, -3.24282795e-02f, 1.18653374e-02f, -1.00262709e-01f, 1.57894626e-01f, 6.80338517e-02f, 9.73065943e-02f, 3.70129980e-02f, 6.68593869e-02f, -1.71064474e-02f,
  3.24166119e-02f, 8.13686699e-02f, 1.95065916e-01f, 1.42241418e-01f, -9.34405811e-03f, 1.78626984e-01f, -5.53255994e-03f, -9.25801769e-02f, 6.07599467e-02f, 1.75222874e-01f,
  4.38314155e-02f, 4.84486148e-02f, 1.56620089e-02f, -1.79268122e-02f, 6.81100488e-02f, -9.74896085e-03f, 7.87106827e-02f, 1.52954916e-02f, 5.89699671e-02f, 9.27444026e-02f,
  1.23935714e-02f, 2.97285691e-02f, 8.49741399e-02f, 8.46581981e-02f, 9.22227576e-02f, 2.46964786e-02f, -5.20672053e-02f, -3.49751227e-02f, 7.02709556e-02f, -2.04532314e-02f,
  -1.97205562e-02f, -2.62947418e-02f, -2.30756886e-02f, -4.00643200e-02f, -2.12176163e-02f, -2.18262356e-02f, 1.99658535e-02f, 8.23884681e-02f, -1.00400455e-01f, -9.85595584e-02f,
  2.63155624e-02f, 3.51572007e-01f, -4.58593778e-02f, -2.58890204e-02f, -3.90237160e-02f, -4.97878343e-02f, -4.58325520e-02f, -2.65174136e-02f, 4.88319471e-02f, -5.57952002e-03f,
  9.71492454e-02f, 5.58593385e-02f, 2.99849510e-02f, 1.27520692e-02f, -1.43250749e-01f, -3.95463705e-02f, -1.49673857e-02f, -3.59262042e-02f, 2.53991894e-02f, -1.70863289e-02f,
  -5.13333548e-03f, -2.35650484e-02f, -1.41716022e-02f, 6.01234585e-02f, -3.16508338e-02f, -3.75656039e-02f, 5.55661554e-03f, 1.10712476e-01f, -3.49889882e-02f, -6.18829317e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.21114945e-01f, -2.54414052e-01f, -6.24177516e-01f, -1.86439604e-01f, 2.65786082e-01f, 4.70934957e-01f, -1.15417972e-01f, 1.08907437e-02f, -4.69015479e-01f, 2.27547079e-01f,
  2.10114464e-01f, 5.50063774e-02f, -6.37885809e-01f, 2.70398080e-01f, 3.47063392e-01f, -5.45670509e-01f, 3.60924006e-01f, 3.16616565e-01f, -3.78425062e-01f, 3.12046975e-01f,
  -5.96841052e-03f, 6.95693314e-01f, -3.44143748e-01f, 5.58231533e-01f, 4.56509352e-01f, -7.31733143e-02f, 1.92657962e-01f, -1.70048997e-01f, 4.59352076e-01f, 2.59427994e-01f,
  -1.23385983e-02f, -2.12476477e-01f, -1.16375841e-01f, -6.83421567e-02f, 3.67280282e-02f, 1.09700628e-01f, 9.53909531e-02f, 2.72343457e-02f, -2.10251704e-01f, -1.21636622e-01f,
  7.64962584e-02f, 9.75851864e-02f, 9.10694078e-02f, -1.43857211e-01f, 1.87121347e-01f, 1.22715525e-01f, -1.38628617e-01f, -5.66149354e-02f, -2.13395000e-01f, 8.65573883e-02f,
  -1.24696478e-01f, -1.65346175e-01f, 2.10402999e-02f, -7.03827739e-02f, -1.60276946e-02f, 4.86877300e-02f, -6.80442005e-02f, -5.88489696e-02f, 4.38062940e-04f, 1.85231537e-01f,
  1.31469846e-01f, 1.00878224e-01f, 9.77340117e-02f, -3.41352448e-03f, 9.87653732e-02f, -1.56496719e-01f, -3.10027245e-02f, -3.96288931e-02f, -3.69746843e-03f, 1.10169917e-01f,
  1.67379789e-02f, -5.72457016e-02f, -2.58090789e-03f, 1.48594320e-01f, 8.33644271e-02f, -9.15223062e-02f, -2.78606713e-02f, 5.70355840e-02f, -8.24615583e-02f, -1.09791569e-01f,
  -9.64413509e-02f, 7.59581923e-02f, -6.31048083e-02f, -1.17078960e-01f, -3.80859114e-02f, 4.13509384e-02f, 2.38007143e-01f, -5.28868288e-04f, -1.53659239e-01f, -8.66747834e-03f,
  7.67284073e-03f, -1.01356916e-02f, -1.41672447e-01f, 6.44258708e-02f, 1.41701512e-02f, 2.31144026e-01f, 3.48280147e-02f, 5.96622005e-02f, 9.18217078e-02f, 1.05145834e-02f,
  1.96928561e-01f, -7.93168768e-02f, 8.25650543e-02f, 3.76940407e-02f, -5.18229716e-02f, 1.00626431e-01f, 2.00082045e-02f, -5.46088628e-02f, -7.52990460e-03f, 8.07998404e-02f,
  1.57070860e-01f, 1.03988461e-01f, 4.44301218e-02f, 1.63400788e-02f, 4.76393513e-02f, 2.07636915e-02f, 9.22013149e-02f, 5.05485758e-02f, -1.35382876e-01f, -1.58134103e-01f,
  -6.88418329e-01f, 5.75911462e-01f, 3.18264902e-01f, 4.56945777e-01f, -5.04192173e-01f, -2.15693653e-01f, 5.01773059e-02f, 1.56707257e-01f, 9.84810591e-02f, 2.47915417e-01f,
  1.58049483e-02f, -1.47076055e-01f, 2.89069623e-01f, 4.25814569e-01f, 1.43026516e-01f, 4.87676650e-01f, 4.28477257e-01f, 2.19671745e-02f, 1.63104787e-01f, 1.49621233e-01f,
  3.15954506e-01f, 1.67453021e-01f, 5.33052087e-01f, 5.60101904e-02f, 2.79776603e-02f, 1.11364372e-01f, 2.60929048e-01f, 5.12136444e-02f, 2.18161404e-01f, -1.97866485e-01f,
  -3.81802559e-01f, 2.22329348e-02f, -3.62759531e-02f, -2.51791567e-01f, 1.03888981e-01f, -2.13961348e-01f, -1.92689132e-02f, -1.45645186e-01f, -2.12707035e-02f, 4.32912894e-02f,
  -1.99504256e-01f, -9.14082006e-02f, -1.83564238e-02f, -1.89459361e-02f, -1.30244240e-01f, 5.52865118e-02f, -6.53164685e-02f, 1.41584873e-02f, -4.07889150e-02f, 2.36203559e-02f,
  1.03114046e-01f, 1.20576367e-01f, 1.41560093e-01f, 8.22770596e-02f, 5.69719896e-02f, 1.85455307e-02f, 3.57456654e-02f, -7.36140311e-02f, -2.09526494e-02f, 4.21385393e-02f,
  3.63912135e-02f, 1.33600220e-01f, 1.16314374e-01f, -6.38944060e-02f, 1.44725069e-01f, 8.65828618e-02f, -1.55256800e-02f, -7.02537000e-02f, -4.10817638e-02f, 1.28447175e-01f,
  -1.25268400e-01f, -2.56516337e-02f, -2.30487343e-02f, -3.51153128e-02f, 5.29928319e-02f, 3.20241973e-02f, -8.34824368e-02f, -1.90423727e-01f, -7.09737241e-02f, -5.08923680e-02f,
  6.58941343e-02f, 2.15699393e-02f, 8.73838440e-02f, -1.14538282e-01f, -8.30640793e-02f, 7.43802339e-02f, 1.28271312e-01f, 1.16733372e-01f, -1.01240803e-04f, -5.68603091e-02f,
  -4.20843586e-02f, 3.69714916e-01f, -6.65327441e-03f, -2.87884682e-01f, 1.75441224e-02f, 1.91160478e-02f, 1.19670205e-01f, -3.65268253e-02f, 1.59914434e-01f, 2.78554652e-02f,
  -1.62438944e-01f, -5.61385229e-02f, 7.25141615e-02f, -1.02541283e-01f, 5.14290482e-02f, 1.33401334e-01f, -2.87255738e-02f, -2.01769508e-02f, -7.25196535e-03f, 7.71984532e-02f,
  1.59816071e-01f, -3.35206091e-02f, 8.34897906e-02f, 6.43914789e-02f, -3.77579965e-02f, -3.83285582e-02f, -1.29505947e-01f, -1.17220730e-01f, -4.08543535e-02f, 1.46838993e-01f,
  -3.77960324e-01f, -1.22327164e-01f, -4.81896013e-01f, -3.52602005e-01f, -1.42820448e-01f, -2.39636093e-01f, -2.23986015e-01f, -1.75223842e-01f, -1.36221349e-01f, 5.40602982e-01f,
  -2.10503459e-01f, -2.04458162e-02f, 6.12222888e-02f, -6.86718285e-01f, -7.64045477e-01f, -2.91915327e-01f, -3.18411350e-01f, 1.13410026e-01f, -1.58047661e-01f, 2.57816583e-01f,
  -2.15063795e-01f, -2.79997140e-01f, -4.62662578e-01f, 1.89184900e-02f, -2.26023585e-01f, 2.11931661e-01f, 4.15610522e-01f, -1.05155423e-01f, 1.74379900e-01f, -3.16558063e-01f,
  -2.42055431e-01f, -1.78317338e-01f, 2.68965941e-02f, -3.79167385e-02f, 2.75401026e-01f, 2.07212061e-01f, 4.93214503e-02f, -1.29835218e-01f, 3.61818410e-02f, 9.77150723e-02f,
  1.89117178e-01f, 9.43434164e-02f, -1.07022196e-01f, -8.12202320e-02f, -5.77338412e-02f, 1.83723830e-02f, -4.29116637e-02f, 1.48171872e-01f, -3.43698524e-02f, -1.86605096e-01f,
  -1.97397266e-02f, -1.54442489e-02f, 9.48808640e-02f, 1.47005871e-01f, 7.97953531e-02f, -5.51657155e-02f, 4.24894281e-02f, 1.11320481e-01f, 8.38800594e-02f, -7.20058680e-02f,
  -6.23312145e-02f, 1.92431137e-01f, -1.52473867e-01f, -1.07444197e-01f, -1.50898322e-01f, -1.28758207e-01f, 1.33239049e-02f, 4.33143526e-02f, 3.54353152e-02f, 1.10609904e-01f,
  1.24124967e-01f, -5.57700433e-02f, -1.59486495e-02f, 1.38926014e-01f, -1.67961174e-03f, -2.40257219e-03f, 1.47790287e-03f, 1.12638183e-01f, 1.49755120e-01f, -2.66348291e-02f,
  6.88648643e-03f, -4.23301980e-02f, 1.15622193e-01f, 3.99145782e-02f, -1.32813111e-01f, 9.11989585e-02f, 8.16804543e-02f, -4.66049500e-02f, -8.42768699e-03f, 1.86070353e-01f,
  8.85862336e-02f, 1.19292341e-01f, 1.33610964e-02f, 4.13626172e-02f, 1.03173822e-01f, 6.89164400e-02f, -1.85491323e-01f, 4.01191087e-03f, 4.32820097e-02f, 2.52614506e-02f,
  1.99011981e-01f, 1.25045314e-01f, 3.05429071e-01f, -2.13454328e-02f, 3.69042531e-02f, -1.01231091e-01f, 2.09607944e-01f, 2.48216853e-01f, 2.07171723e-01f, 1.46833107e-01f,
  1.73699453e-01f, 2.23775983e-01f, 1.34267807e-01f, 2.76444137e-01f, 9.10089165e-02f, 1.64894968e-01f, 1.32620201e-01f, -5.59223741e-02f, 1.84645221e-01f, 9.73266587e-02f,
  -5.10010660e-01f, -1.65892571e-01f, -4.32903171e-01f, -5.71355760e-01f, 7.59909302e-02f, -3.39155197e-01f, -3.62877995e-01f, 5.82379382e-03f, -1.81245953e-01f, 3.28443170e-01f,
  6.86031431e-02f, -3.47115964e-01f, 2.32983455e-01f, -5.91436625e-01f, -6.00889981e-01f, -2.75508553e-01f, -6.75231516e-01f, -4.64957863e-01f, -8.40155184e-02f, -1.10082440e-01f,
  -1.70943186e-01f, -2.62210786e-01f, -4.33016181e-01f, 2.53800184e-01f, -3.67037654e-01f, 8.67074952e-02f, 4.14966792e-01f, 1.87395439e-01f, -2.71051973e-01f, -1.64198503e-01f,
  -1.72943383e-01f, 1.60819054e-01f, -5.03063276e-02f, -1.34383529e-01f, -1.86826400e-02f, 1.62172019e-01f, 2.63460949e-02f, -7.85218030e-02f, 2.64149830e-02f, -6.12264238e-02f,
  6.33881427e-03f, 1.08201213e-01f, -1.54736117e-01f, 1.38133064e-01f, 1.38286687e-02f, -2.39665881e-02f, -1.33238837e-01f, -8.91379640e-02f, -1.64352134e-01f, -8.88818726e-02f,
  -2.75083780e-01f, -7.08426163e-02f, -4.96792682e-02f, -2.22885814e-02f, -7.70101920e-02f, -3.85790206e-02f, -5.16119190e-02f, 4.58616130e-02f, -7.76301548e-02f, 1.04296720e-02f,
  5.18130213e-02f, 1.00228526e-01f, -4.43553142e-02f, -1.20773967e-02f, 2.39479952e-02f, 7.67089948e-02f, 1.20362276e-02f, -7.37570524e-02f, 2.38202903e-02f, -6.48966059e-03f,
  -3.06070894e-02f, -4.92473058e-02f, 1.83080826e-02f, -3.32262553e-02f, -3.36385099e-04f, -1.00976201e-02f, -7.09320828e-02f, -6.57427637e-03f, -1.74797073e-01f, -3.52672040e-02f,
  1.33689761e-01f, -1.03534751e-01f, 5.21303806e-03f, 8.27862769e-02f, -7.56978691e-02f, 5.11794724e-02f, -3.50491703e-02f, -3.05910669e-02f, 6.88781030e-03f, 2.99773794e-02f,
  9.37722102e-02f, 3.53094667e-01f, -6.87632710e-03f, -6.30275086e-02f, -4.57893759e-02f, -1.32269580e-02f, -9.74288955e-02f, -1.37160212e-01f, 1.42776864e-02f, 6.86650574e-02f,
  4.30449471e-02f, -2.27118097e-02f, 1.23417772e-01f, 1.81474723e-02f, -1.12794545e-02f, 4.88656983e-02f, 1.51562179e-02f, -1.91049166e-02f, 7.59933516e-02f, 6.67180717e-02f,
  6.31959811e-02f, 4.00616527e-02f, 2.07474157e-02f, -1.56828407e-02f, 2.84133628e-02f, 1.48766920e-01f, 2.03132018e-01f, 1.28478119e-02f, 5.77713102e-02f, 3.11051253e-02f,
  3.25492978e-01f, -9.21989024e-01f, 4.03276026e-01f, 5.80750763e-01f, 3.64406854e-01f, 5.44768162e-02f, 2.92182237e-01f, -3.04871529e-01f, 1.03720516e-01f, -7.40881562e-01f,
  -4.09836441e-01f, 2.40380839e-02f, -3.92966658e-01f, 9.71015543e-02f, 6.40899122e-01f, -3.83633852e-01f, 7.13635013e-02f, -7.08526596e-02f, 2.58740666e-03f, -4.27528657e-02f,
  3.11535001e-01f, -2.31623277e-02f, 2.93377846e-01f, -2.07981691e-01f, 4.03276719e-02f, 1.11992441e-01f, 2.84357299e-03f, 2.12769821e-01f, 1.75845429e-01f, 2.40391105e-01f,
  -5.76344272e-03f, -8.90828893e-02f, -1.09372027e-02f, 8.61045066e-03f, -1.57818854e-01f, 3.63995247e-02f, 1.42125502e-01f, 1.47801936e-01f, 3.05462331e-01f, -2.23595125e-04f,
  -1.62141934e-01f, 1.91573530e-01f, 1.43590748e-01f, 7.67635331e-02f, 4.77064215e-02f, 1.21365808e-01f, 5.53170778e-02f, 2.47483868e-02f, -1.29962107e-02f, 2.10735891e-02f,
  1.17900036e-01f, -5.54112494e-02f, 1.28259482e-02f, -1.11413456e-01f, 6.71739727e-02f, 8.03514197e-02f, 1.54374525e-01f, 4.39183749e-02f, 6.45453483e-02f, 1.51299521e-01f,
  -1.80631071e-01f, 6.16344512e-02f, -3.22928540e-02f, 9.71379131e-02f, 1.00433445e-02f, 9.54097360e-02f, 7.43160024e-02f, 2.06940547e-02f, 4.29909118e-02f, -1.16944596e-01f,
  9.64907743e-03f, 1.04133628e-01f, -2.81942505e-02f, 1.04001917e-01f, -4.13567852e-03f, -6.56463355e-02f, 1.07684061e-01f, -2.32929941e-02f, -1.20660499e-01f, 1.13949776e-01f,
  -6.88383877e-02f, 6.90074489e-02f, -3.71568799e-02f, 1.45607874e-01f, -6.93821982e-02f, 3.53252329e-02f, -6.74886554e-02f, 3.51209901e-02f, -6.70320168e-02f, -3.20997760e-02f,
  -5.43667972e-01f, -6.31772280e-01f, -1.68005690e-01f, -7.86466748e-02f, -2.80621406e-02f, -2.16859236e-01f, 1.50228962e-02f, -1.02174081e-01f, -1.01240672e-01f, -7.03731179e-02f,
  -1.58506691e-01f, 1.10069633e-01f, -1.04270972e-01f, 1.18933119e-01f, -4.05092798e-02f, -1.84037805e-01f, 8.44199285e-02f, -1.30869463e-01f, -3.40295918e-02f, -4.77166660e-02f,
  -4.89568012e-03f, -1.89399645e-02f, 8.87013823e-02f, 1.27273006e-02f, -8.75553861e-03f, -1.49954468e-01f, -2.89091226e-02f, -3.67786102e-02f, 7.31869414e-02f, 1.29700871e-02f,
  -1.02460051e+00f, 6.59873962e-01f, 1.88262761e-01f, -4.19929981e-01f, 2.13577710e-02f, 4.88567166e-02f, 9.95404199e-02f, 3.98003608e-02f, -2.11068898e-01f, 3.25178176e-01f,
  7.24356398e-02f, 9.57586542e-02f, 2.27298319e-01f, 1.29406769e-02f, -7.66525269e-01f, -2.23601371e-01f, -3.21357131e-01f, -1.04396500e-01f, -1.08702160e-01f, -1.85195968e-01f,
  -3.08217496e-01f, -4.31224778e-02f, -9.11488310e-02f, 3.38249952e-01f, 1.67883202e-01f, 1.34026006e-01f, -6.31434619e-02f, 3.90131354e-01f, 1.50293693e-01f, 9.86010581e-02f,
  -2.60734797e-01f, -6.46671504e-02f, -3.40901017e-02f, 5.68721034e-02f, -1.02408253e-01f, 2.48085409e-02f, -2.13706065e-02f, 3.67013067e-02f, -1.21025436e-01f, -1.21308669e-01f,
  5.38879633e-02f, 1.69630572e-02f, -8.22392851e-02f, -1.51634775e-02f, -4.39357124e-02f, 6.54600859e-02f, 8.96630436e-02f, -3.57111148e-03f, 5.02579436e-02f, -2.08942010e-03f,
  1.38706550e-01f, 2.18230579e-02f, -7.20090643e-02f, -3.24852169e-02f, -4.77884859e-02f, 1.29411981e-01f, -6.53572604e-02f, -2.89132237e-03f, -4.16722894e-02f, -3.30485664e-02f,
  -3.65755856e-02f, -1.42399073e-01f, 1.07413568e-01f, -8.60633254e-02f, 2.12126542e-02f, 1.29275873e-01f, 2.77749598e-02f, -8.38507488e-02f, 9.38168615e-02f, -1.22724576e-02f,
  -6.33690655e-02f, -4.75933813e-02f, -3.81739764e-03f, -5.56859635e-02f, 2.65509309e-03f, -8.61642212e-02f, -5.80349416e-02f, 1.14044582e-03f, -6.51402920e-02f, -7.03769550e-02f,
  -2.82854736e-02f, 5.04593067e-02f, 3.36326542e-03f, -4.98467721e-02f, -8.42436552e-02f, -5.37069589e-02f, 3.43678780e-02f, 6.46373332e-02f, -5.87902330e-02f, -2.27969605e-02f,
  -4.86551017e-01f, -3.14781249e-01f, -1.20528735e-01f, 5.83027750e-02f, -6.68247789e-02f, -5.54678515e-02f, -4.75821346e-02f, -6.58898875e-02f, -1.27936289e-01f, -6.65735230e-02f,
  3.76425614e-03f, 4.81841974e-02f, -1.77710019e-02f, -6.88566417e-02f, -7.23448843e-02f, -3.07531748e-02f, -3.01595423e-02f, -1.95096601e-02f, -1.75074741e-01f, -2.37637199e-02f,
  1.07178085e-01f, 3.13408463e-03f, 6.35920689e-02f, -1.31121352e-01f, -9.21449661e-02f, 3.71184759e-02f, -6.83341771e-02f, 3.53844687e-02f, 3.91598120e-02f, 3.83591689e-02f,
  7.89419174e-01f, -4.22583312e-01f, -5.10576546e-01f, 2.49172226e-01f, 4.28071707e-01f, 4.42464411e-01f, 3.95130128e-01f, 2.28899419e-01f, 4.80590463e-01f, -2.04553559e-01f,
  1.96593493e-01f, -4.26862121e-01f, -5.82212687e-01f, 4.94437039e-01f, 4.02254790e-01f, -1.67798147e-01f, 5.31691611e-01f, 2.12495297e-01f, 1.83352649e-01f, 1.23189703e-01f,
  2.84153670e-01f, 4.31341529e-01f, -4.30578262e-01f, -5.47650717e-02f, 3.11018586e-01f, -1.85658500e-01f, -2.63275564e-01f, -5.81020534e-01f, -1.20267635e-02f, 1.03319243e-01f,
  2.40488257e-02f, 1.20665111e-01f, 1.89055745e-02f, -5.72383218e-02f, -3.54200043e-02f, 7.18909577e-02f, -1.79583177e-01f, -1.53459638e-01f, 7.42921904e-02f, -2.91067008e-02f,
  -7.58155584e-02f, 6.36893734e-02f, 1.82373345e-01f, -8.81902967e-03f, 1.96894601e-01f, 6.93695396e-02f, 2.04914100e-02f, 1.20658271e-01f, -1.17531031e-01f, -3.29601616e-02f,
  3.63513082e-02f, 5.30203944e-03f, 5.48186377e-02f, -3.26580065e-03f, -4.23187129e-02f, 2.02440470e-01f, -2.75649205e-02f, -2.17677251e-01f, -1.02163767e-02f, 9.82262492e-02f,
  -3.18598822e-02f, 3.47645045e-03f, -2.77562607e-02f, -3.37998830e-02f, 9.81701314e-02f, 4.40970138e-02f, 3.52653638e-02f, -1.60339639e-01f, -1.03575855e-01f, -1.27938136e-01f,
  3.32857966e-02f, 1.00006536e-01f, 5.18158302e-02f, 9.90588218e-02f, 1.27809033e-01f, 1.70182228e-01f, -9.03855935e-02f, -2.97242198e-02f, 4.56991941e-02f, 3.73953469e-02f,
  -7.01267123e-02f, 1.46138430e-01f, -1.09583177e-01f, -2.32360885e-02f, 8.34546313e-02f, -1.02097288e-01f, 3.01589705e-02f, 9.43113235e-04f, 5.92140891e-02f, -8.17709118e-02f,
  -3.53904478e-02f, -2.52825201e-01f, -1.66334629e-01f, -1.35242520e-02f, -1.62339643e-01f, 5.14172800e-02f, 1.14851464e-02f, 1.51105255e-01f, -5.20240366e-02f, 1.99027315e-01f,
  -1.42633785e-02f, -1.80956014e-02f, 7.98074678e-02f, 5.23769297e-02f, -9.42094103e-02f, 8.98625404e-02f, -5.09521142e-02f, 4.56023738e-02f, 4.30377433e-03f, -2.95132603e-02f,
  -4.37103137e-02f, 4.17520963e-02f, -5.76902255e-02f, 1.34348109e-01f, 1.60740428e-02f, -1.88638046e-01f, 6.14584424e-02f, -1.21841833e-01f, -1.24852642e-01f, -9.88715366e-02f,
  6.99418664e-01f, 8.93396318e-01f, 5.67824721e-01f, 4.46285665e-01f, -3.07951510e-01f, -2.67157316e-01f, -2.23801211e-01f, 3.81946713e-02f, -1.70191705e-01f, 3.75466436e-01f,
  -1.90186143e-01f, 7.55489111e-01f, -2.13246688e-01f, 3.64085674e-01f, -5.15333891e-01f, -4.98714149e-01f, 2.63290852e-01f, 2.94015020e-01f, -1.87455550e-01f, 3.31025928e-01f,
  -5.04383221e-02f, -3.50009292e-01f, 1.37260899e-01f, -2.45086819e-01f, 5.57195544e-01f, 4.76358324e-01f, -1.24295615e-01f, -2.18949646e-01f, 4.87977684e-01f, -1.11138232e-01f,
  2.68864762e-02f, 1.53937981e-01f, 3.15119505e-01f, 5.72180115e-02f, 1.06103465e-01f, 7.86100104e-02f, 8.93586800e-02f, -1.09741062e-01f, -1.65870234e-01f, 1.95606425e-02f,
  1.31955579e-01f, -5.67342713e-02f, 7.20741823e-02f, -1.10683933e-01f, 1.14282474e-01f, 1.06569804e-01f, 9.09082294e-02f, 1.69386849e-01f, 1.06832094e-01f, 2.01771885e-01f,
  2.19632566e-01f, 2.31346339e-01f, 1.11608520e-01f, 1.05819784e-01f, 1.05040245e-01f, -2.75056101e-02f, 1.14120528e-01f, 2.27009013e-01f, 1.86893985e-01f, 6.79180101e-02f,
  1.49406016e-01f, -1.28786430e-01f, 1.73893627e-02f, 2.39363126e-02f, 1.52383586e-02f, -6.99629560e-02f, 7.00855628e-02f, -8.13783035e-02f, -7.95915648e-02f, 1.16122914e-02f,
  -1.31868497e-01f, 1.69265136e-01f, -1.25427887e-01f, 6.32534698e-02f, 6.80322200e-02f, 1.28864482e-01f, -4.64716814e-02f, 3.75056379e-02f, 1.90974362e-02f, 4.54136357e-02f,
  -1.84999257e-01f, -1.35410011e-01f, 4.01139632e-02f, 3.11852694e-02f, -1.27595007e-01f, -4.09226418e-02f, 4.67797145e-02f, 1.79184407e-01f, -9.30196345e-02f, -3.04603891e-04f,
  -3.77115794e-03f, 1.61492139e-01f, -2.07505087e-04f, -1.45096630e-02f, -1.57977492e-01f, 9.97367203e-02f, -9.77608487e-02f, 2.11447135e-01f, 1.08225003e-01f, -1.18474223e-01f,
  1.71911851e-01f, 2.77251750e-02f, 2.59944722e-02f, -3.42151783e-02f, -1.07093997e-01f, 2.76680919e-03f, -6.55774474e-02f, -8.88857916e-02f, 5.19007891e-02f, 1.61688045e-01f,
  7.90263936e-02f, -7.63716027e-02f, -2.75159278e-03f, -1.42661810e-01f, 8.13458338e-02f, 1.94669608e-02f, 1.33202821e-01f, 3.19331661e-02f, 1.24062307e-01f, -7.09921345e-02f,
  7.27975965e-01f, -5.61334312e-01f, 3.77234161e-01f, 2.41571933e-01f, 4.09656137e-01f, 2.06304386e-01f, 5.46251059e-01f, -2.13942781e-01f, -6.27211481e-02f, -6.21109962e-01f,
  1.77420884e-01f, -2.77480423e-01f, 3.19917411e-01f, -2.99750954e-01f, 4.66469884e-01f, 1.09030716e-01f, -7.16899931e-02f, -1.56585872e-01f, 9.34850425e-02f, 2.28022188e-01f,
  1.45813808e-01f, -1.22979991e-01f, 2.99133390e-01f, -3.64151210e-01f, 2.40953207e-01f, -1.69461966e-01f, 1.58216469e-02f, 1.63119450e-01f, -5.11958778e-01f, -6.10155426e-02f,
  1.22739442e-01f, 5.24192154e-02f, 2.07928345e-01f, -1.06901042e-01f, 2.44682878e-01f, 1.01090841e-01f, -8.36965628e-03f, 1.43468350e-01f, 3.76594476e-02f, -8.12838152e-02f,
  1.24917664e-02f, -2.17453614e-01f, -1.89228892e-01f, 6.24938197e-02f, 3.58768217e-02f, -1.98714241e-01f, -9.20889825e-02f, -1.52683221e-02f, -1.74721822e-01f, 1.31806269e-01f,
  1.16402909e-01f, -1.49037004e-01f, 1.32911205e-01f, -2.82992065e-01f, 5.99577501e-02f, -1.14314102e-01f, -3.12722474e-02f, 1.25152439e-01f, -1.45149231e-01f, -8.52869153e-02f,
  -8.16024691e-02f, 2.25583743e-02f, 4.86597568e-02f, -1.17408901e-01f, 1.29593536e-01f, -5.54804988e-02f, -6.69907257e-02f, -8.60140398e-02f, 2.72724442e-02f, 1.15465656e-01f,
  2.77448213e-03f, 1.21662831e-02f, 1.37489997e-02f, 1.20148748e-01f, -8.36261362e-03f, 8.07075948e-03f, 7.04864115e-02f, 9.02503205e-04f, 6.36760890e-02f, 7.14976639e-02f,
  4.40579541e-02f, -4.39433679e-02f, 4.04380485e-02f, -1.06059968e-01f, -1.17053285e-01f, 9.70567316e-02f, -1.71767976e-02f, 3.92909162e-02f, 4.91533428e-02f, 9.69858989e-02f,
  -1.68342948e-01f, -4.11720932e-01f, 7.38161057e-02f, -1.59484744e-01f, -1.06286399e-01f, 6.48969635e-02f, 8.88471901e-02f, -9.15991142e-02f, -9.66484100e-02f, 1.13184847e-01f,
  -5.54393455e-02f, 2.23240908e-02f, -6.59502074e-02f, -1.83635168e-02f, -1.55661508e-01f, 2.36517880e-02f, -1.17017314e-01f, -1.01158604e-01f, 2.62372810e-02f, -1.04369812e-01f,
  -8.40884149e-02f, -1.06198281e-01f, -4.29941192e-02f, -2.06168592e-02f, -5.82351424e-02f, 3.80890146e-02f, -1.40634021e-02f, -3.82020362e-02f, -1.19195454e-01f, -1.76171616e-01f,
  2.19040722e-01f, 4.33832496e-01f, -4.52058852e-01f, -3.02502751e-01f, -1.84520647e-01f, 5.61410546e-01f, 4.00849372e-01f, 1.79501504e-01f, 2.67103285e-01f, 8.13084066e-01f,
  4.34090614e-01f, 1.31075114e-01f, 4.53253061e-01f, 3.86869162e-01f, 9.14009884e-02f, 5.91431737e-01f, 2.53398985e-01f, 2.93964028e-01f, 8.85709599e-02f, 3.49952653e-02f,
  -1.06080770e-01f, 4.88483638e-01f, -2.94947892e-01f, 2.00494155e-01f, 2.42789164e-02f, -2.46914789e-01f, -3.08607519e-01f, -1.76192507e-01f, -4.08823639e-02f, 1.72879264e-01f,
  1.25188202e-01f, 3.28231663e-01f, -8.76959264e-02f, 1.82593428e-03f, -9.61916670e-02f, -5.92302568e-02f, -1.68284282e-01f, -7.87536278e-02f, -2.30490506e-01f, 1.83875971e-02f,
  -2.12783087e-02f, 4.87543382e-02f, 1.20781071e-01f, 2.08072048e-02f, -5.12968339e-02f, -1.10869177e-01f, -1.89051460e-02f, -1.98165700e-01f, -4.34735268e-02f, 2.41042078e-02f,
  3.14916484e-02f, -4.63216454e-02f, -1.31506249e-01f, 2.75161825e-02f, -1.32382467e-01f, 9.27827880e-02f, 4.12250608e-02f, -7.21813068e-02f, 2.19603375e-01f, 8.50269422e-02f,
  4.16774713e-02f, -5.66972420e-03f, 2.20902681e-01f, 1.52943447e-01f, 3.81428078e-02f, 7.71624222e-03f, 6.05958328e-02f, -6.08690903e-02f, -2.70504057e-02f, 7.02647045e-02f,
  7.52444053e-03f, 6.09732652e-03f, 4.92097624e-02f, 4.37399708e-02f, 3.56880240e-02f, 3.68787460e-02f, -1.10607184e-01f, 1.63902506e-01f, -3.99348587e-02f, -5.68737881e-03f,
  3.62582691e-02f, -1.32958600e-02f, 2.02190205e-01f, -2.81954613e-02f, 1.48058742e-01f, -5.86713031e-02f, 5.71832955e-02f, 1.20325021e-01f, -2.82855053e-03f, -3.67081240e-02f,
  1.59258738e-01f, 5.35497546e-01f, 2.02742159e-01f, 1.28496647e-01f, -1.70769151e-02f, 1.45632356e-01f, -3.08360271e-02f, -5.73720085e-04f, 5.35745099e-02f, 2.46842787e-01f,
  -9.32533294e-02f, 6.24756888e-03f, -1.27995968e-01f, -4.54423651e-02f, -1.40624061e-01f, 2.00965375e-01f, 3.40759940e-02f, -9.93072912e-02f, -8.81129652e-02f, -6.21607006e-02f,
  -7.89328516e-02f, 1.03039555e-01f, -6.50261417e-02f, -5.92798665e-02f, -5.46081550e-03f, -3.13906409e-02f, 4.27847095e-02f, -3.26291937e-03f, -3.34409736e-02f, 1.04513196e-02f,
  -3.80167723e-01f, 9.05428827e-02f, -1.47499099e-01f, -1.75145403e-01f, -7.74176121e-01f, 1.01922385e-01f, 5.31532951e-02f, -3.44306946e-01f, 9.85874329e-03f, 4.64829206e-01f,
  -2.08779573e-01f, 3.91368149e-03f, 3.50658059e-01f, -1.56813651e-01f, 2.29457334e-01f, 6.67499423e-01f, 2.49633923e-01f, 2.55226642e-01f, -1.47394136e-01f, -2.81410992e-01f,
  -2.70627499e-01f, -3.88986915e-01f, 1.28189251e-01f, -2.39458784e-01f, -5.37691772e-01f, -3.51951689e-01f, -1.30086467e-01f, -4.88559127e-01f, -3.57537210e-01f, -4.09325838e-01f,
  -4.08065677e-01f, -3.64679784e-01f, -8.05522725e-02f, 2.13938072e-01f, -8.86511281e-02f, 2.75020041e-02f, -6.97193369e-02f, -1.28159523e-01f, -2.08383545e-01f, -8.15588683e-02f,
  1.55261949e-01f, -6.35690764e-02f, 2.91203354e-02f, 7.47095421e-02f, -1.97070718e-01f, -7.68943354e-02f, -6.86903894e-02f, -5.07951155e-02f, -1.92717925e-01f, -8.98059458e-02f,
  1.24396138e-01f, -3.84485628e-03f, -1.50482446e-01f, 8.70957971e-02f, -1.97062805e-01f, -1.09258711e-01f, 1.74753219e-01f, -8.28678012e-02f, -6.57920018e-02f, -1.20901912e-01f,
  -5.33795990e-02f, 4.25768010e-02f, 8.11050013e-02f, -3.39663997e-02f, 9.91694704e-02f, -8.25924501e-02f, 1.03865378e-01f, -1.06300086e-01f, -2.67391535e-03f, -3.55451996e-03f,
  -1.12172157e-01f, -5.64095937e-02f, -1.25809669e-01f, 1.72985375e-01f, -4.04894687e-02f, 6.92041889e-02f, 6.19212538e-02f, -1.00194395e-01f, 1.86702833e-02f, 4.07858789e-02f,
  -7.88792893e-02f, 8.59462544e-02f, -6.26731291e-02f, 4.26365510e-02f, -5.90931345e-03f, -2.35975627e-02f, -4.68217321e-02f, 1.30979612e-01f, 5.07870726e-02f, -1.79378182e-01f,
  -2.71146804e-01f, -2.80345231e-01f, 3.27414311e-02f, 9.18312650e-03f, 6.88178614e-02f, -2.78558470e-02f, 3.89694236e-02f, 5.44401025e-03f, -1.92066595e-01f, 7.23943338e-02f,
  1.28587708e-01f, 2.48406515e-01f, 2.93766037e-02f, -9.71125960e-02f, 1.16821319e-01f, -4.58041988e-02f, 2.69269850e-02f, 5.62274493e-02f, -4.53147069e-02f, -1.03529386e-01f,
  5.49113713e-02f, 8.59448537e-02f, 1.87196895e-01f, 4.00004238e-02f, 1.34798765e-01f, 2.07889080e-02f, -1.27872884e-01f, 6.27200380e-02f, -2.26699963e-01f, 3.86834331e-02f,
  6.40691876e-01f, -1.31910415e-02f, 5.06276906e-01f, 6.92053854e-01f, 2.05639258e-01f, 2.89950848e-01f, 6.22994661e-01f, 7.81013966e-02f, 9.61393476e-01f, -2.16534480e-01f,
  -3.62845182e-01f, 4.27215695e-01f, -2.58182343e-02f, -8.01456496e-02f, 8.82442594e-02f, -5.23624308e-02f, 3.41925055e-01f, 1.57007515e-01f, 4.04381722e-01f, 2.61020541e-01f,
  2.94265926e-01f, -2.53523707e-01f, -2.63766617e-01f, -4.18270499e-01f, 1.72108769e-01f, -3.68703306e-02f, -7.82833338e-01f, 1.07611313e-01f, -5.34632981e-01f, -6.26574233e-02f,
  -2.13971883e-02f, 5.01845405e-02f, -5.81580922e-02f, -8.75178073e-03f, 7.32773989e-02f, 6.85235369e-04f, -7.57700726e-02f, -1.79466698e-03f, 1.50577098e-01f, 6.99332878e-02f,
  2.84549296e-02f, 1.23167075e-02f, -5.80685772e-02f, -7.22120553e-02f, 1.19121745e-01f, -8.54674727e-02f, 1.82446986e-02f, -6.29293770e-02f, 6.56897277e-02f, 6.07415251e-02f,
  1.02593437e-01f, 6.73720008e-03f, 8.48392844e-02f, -7.26160109e-02f, 4.03839871e-02f, 6.23889305e-02f, 1.02789409e-01f, 1.90311410e-02f, -1.09002739e-01f, 1.97902456e-01f,
  7.41828838e-03f, 4.47154157e-02f, -8.40866566e-02f, -7.68692195e-02f, 1.06520735e-01f, -2.69856192e-02f, -1.51759889e-02f, -2.00226083e-02f, 1.47663817e-01f, 2.63802726e-02f,
  3.96985859e-02f, -8.55927356e-03f, 2.71819886e-02f, 2.98596267e-02f, 1.20360374e-01f, 1.77956317e-02f, -4.63948287e-02f, 2.65134219e-03f, -1.56223560e-02f, 4.00359258e-02f,
  2.25076359e-03f, -5.70097305e-02f, -5.26900310e-03f, -1.88502930e-02f, -1.06502444e-01f, 9.22128651e-03f, -8.97654593e-02f, 1.09444864e-01f, -4.80448380e-02f, 1.00093283e-01f,
  7.53814951e-02f, 2.68659860e-01f, 2.96082925e-02f, -5.87177556e-03f, 4.99867871e-02f, -3.85866687e-02f, 9.00829062e-02f, 9.25863162e-02f, 1.52763233e-01f, 5.85298352e-02f,
  -5.09327948e-02f, 1.55537814e-01f, -6.99251071e-02f, -8.02704319e-02f, -5.76875061e-02f, -5.11757098e-03f, -1.26763359e-02f, 7.51807615e-02f, 5.32166064e-02f, -1.01803482e-01f,
  -7.24640042e-02f, 1.09549589e-01f, 5.36345765e-02f, 3.62609401e-02f, -3.49658774e-03f, -7.47417882e-02f, -2.26734895e-02f, -6.95999265e-02f, -4.01817448e-02f, 8.19532797e-02f,
  5.24296761e-01f, -2.12049291e-01f, -9.08267796e-02f, -7.24516869e-01f, -3.01950812e-01f, 1.19356155e-01f, -1.06919125e-01f, -4.49886441e-01f, -5.85633457e-01f, -4.03283089e-01f,
  -4.51761991e-01f, 1.20415553e-01f, 5.15105426e-01f, -5.28841555e-01f, 9.64221776e-01f, 4.44101095e-01f, -4.34159696e-01f, -2.24266738e-01f, -3.57043296e-02f, -2.48802319e-01f,
  4.89250431e-03f, -3.63617241e-01f, 2.12172344e-01f, -2.36806393e-01f, -1.99945569e-01f, -3.17649603e-01f, -1.13634966e-01f, 3.73631790e-02f, -4.37548757e-01f, 4.33839969e-02f,
  -5.54246269e-02f, -1.64402992e-01f, -6.32320717e-02f, 2.09916092e-04f, -2.22136080e-02f, -1.04626687e-02f, 3.28219905e-02f, 2.32759759e-01f, -2.02651285e-02f, -4.84479554e-02f,
  1.39609560e-01f, 2.24981412e-01f, -1.82503045e-01f, 2.26551816e-01f, -1.73445612e-01f, -1.33335650e-01f, 5.05067967e-02f, -4.07443680e-02f, 1.07574530e-01f, 1.89401701e-01f,
  1.03952982e-01f, 5.83280548e-02f, -1.24086834e-01f, 6.09050579e-02f, -4.26629791e-03f, -7.85694346e-02f, 2.40786850e-01f, 9.87501144e-02f, -3.76326218e-02f, -9.18200519e-03f,
  -1.90380942e-02f, 9.90997106e-02f, 1.46514401e-02f, -1.23029836e-01f, -4.66458984e-02f, -1.38681782e-02f, -9.58504900e-02f, 4.77478094e-02f, 1.42350137e-01f, 1.19530320e-01f,
  -9.22304466e-02f, -1.05569400e-01f, -3.54362056e-02f, -8.41464382e-03f, -4.98129688e-02f, -2.02359837e-02f, 1.57217056e-01f, 1.00446744e-02f, -1.79116383e-01f, 8.61714687e-03f,
  -6.55297786e-02f, 6.75292388e-02f, -4.78207804e-02f, 2.12579574e-02f, -5.42012639e-02f, 3.95966172e-02f, -1.69925183e-01f, 1.65627748e-01f, -1.30232647e-01f, 1.40025377e-01f,
  -1.62554085e-01f, -2.15402529e-01f, -1.34171173e-01f, 3.77672836e-02f, -6.80100620e-02f, -3.30966599e-02f, -1.82035774e-01f, -2.18125790e-01f, 8.59593973e-03f, 3.37845385e-02f,
  -1.78656340e-01f, 4.09577154e-02f, -1.07247844e-01f, -7.43028149e-02f, -5.47900349e-02f, -1.35184363e-01f, 3.44600007e-02f, -1.80035219e-01f, 1.12161012e-02f, -9.28365886e-02f,
  -3.66535299e-02f, 7.02615902e-02f, 1.51915789e-01f, 6.18300820e-03f, -9.86689702e-02f, 6.24725521e-02f, -9.79900267e-03f, -3.93949188e-02f, 1.44331530e-01f, -1.88451082e-01f,
  -9.53780711e-01f, 3.50529671e-01f, 2.68615186e-01f, -5.69548905e-01f, 2.77450353e-01f, 5.21503747e-01f, 1.82409659e-01f, 8.59514475e-02f, -5.61964154e-01f, 2.58631796e-01f,
  3.63806993e-01f, -3.55488896e-01f, 3.68797004e-01f, 3.30807239e-01f, -7.50844851e-02f, 2.89367557e-01f, 1.22067168e-01f, 1.94659427e-01f, 7.42331205e-04f, -1.79338306e-01f,
  -2.22579807e-01f, 2.59909302e-01f, 2.63985753e-01f, 5.24415858e-02f, 1.82962745e-01f, -4.36677724e-01f, 6.04848191e-02f, -5.29945791e-02f, 9.54523832e-02f, -8.39815661e-03f,
  3.46137024e-02f, -4.34953779e-01f, -2.04411112e-02f, -1.82650983e-01f, 3.32858413e-02f, -5.55978529e-03f, -7.03610331e-02f, -1.80775579e-02f, -1.25680029e-01f, -5.59922494e-03f,
  -1.36134714e-01f, -4.65913415e-02f, -1.27640635e-01f, -8.81328061e-02f, -1.26912117e-01f, 3.46420407e-02f, 2.55239367e-01f, 1.26826093e-01f, 4.02969234e-02f, 1.69500381e-01f,
  1.98370248e-01f, 3.07471268e-02f, 9.58557650e-02f, 1.49583034e-02f, 1.93433389e-01f, -2.61387769e-02f, -7.80319273e-02f, 6.98412210e-02f, -1.45595847e-02f, 2.36726999e-02f,
  -9.19708982e-02f, -1.27456263e-01f, 8.06435868e-02f, 4.30543236e-02f, 1.00632019e-01f, -1.16609212e-04f, -2.09904145e-02f, 1.97084546e-01f, -7.40883201e-02f, 1.66389659e-01f,
  -5.18654659e-02f, -9.66774523e-02f, -5.68095632e-02f, -7.72337839e-02f, -4.96715195e-02f, -2.82172769e-01f, 1.97098665e-02f, 8.52366984e-02f, -2.04937328e-02f, 4.73047979e-02f,
  -1.36993885e-01f, -6.39594765e-03f, 6.86051175e-02f, 2.51545291e-02f, -4.74147908e-02f, 1.11432776e-01f, 9.44608764e-04f, 1.10816851e-01f, 9.28212181e-02f, 3.23466845e-02f,
  -1.43721268e-01f, -4.88663405e-01f, -7.87090212e-02f, 1.66236013e-02f, 7.91927986e-03f, 1.06144480e-01f, -8.42035189e-02f, 9.30718407e-02f, -1.72365606e-02f, 5.84691055e-02f,
  -2.59173606e-02f, -4.45108190e-02f, -3.93068492e-02f, -3.75898741e-02f, -7.96585456e-02f, 1.63278252e-01f, -1.11471556e-01f, -1.38597876e-01f, -2.01724172e-02f, -5.66607602e-02f,
  -1.51467556e-02f, -1.52675584e-01f, -1.12782978e-02f, -1.51803363e-02f, -6.64488673e-02f, 7.31667057e-02f, -2.15463981e-01f, -1.06715135e-01f, 5.12295403e-02f, 9.83083248e-02f,
  -8.00398052e-01f, 5.23451447e-01f, 8.12047303e-01f, -2.67207414e-01f, 2.61663273e-02f, 6.64100111e-01f, 4.75855291e-01f, 2.38019586e-01f, 4.05390710e-01f, -2.44883150e-01f,
  -4.05668288e-01f, -2.08697785e-02f, 1.81789532e-01f, -1.40504196e-01f, 4.66013461e-01f, 4.53715533e-01f, 1.27302483e-01f, 2.51325071e-02f, 2.41181508e-01f, -1.35831699e-01f,
  -3.52814458e-02f, -3.72218937e-01f, -1.46162540e-01f, -2.35089257e-01f, -3.98669988e-01f, -1.58294976e-01f, -4.92188662e-01f, 3.94756705e-01f, -3.36814791e-01f, 2.57917643e-01f,
  -2.50285923e-01f, -2.99464434e-01f, -3.43190581e-01f, 8.89461339e-02f, -1.05692372e-02f, 2.97437292e-02f, 1.77698404e-01f, 1.21033400e-01f, 6.61484897e-02f, -1.34508582e-02f,
  -5.24298660e-02f, -4.60342839e-02f, -1.30659491e-01f, 7.01747276e-03f, 3.71942781e-02f, -6.29179031e-02f, 3.21575589e-02f, 2.06241235e-02f, -2.71121301e-02f, 1.26271024e-01f,
  1.01820640e-02f, -2.87146606e-02f, -1.10891767e-01f, 1.67373106e-01f, 2.93423305e-03f, 1.14889748e-01f, 5.17017730e-02f, 1.15837887e-01f, -1.07019633e-01f, 8.48840848e-02f,
  1.39334112e-01f, 3.08400273e-01f, 5.06450906e-02f, -8.41773599e-02f, 2.60971859e-02f, -1.24960527e-01f, -2.84348931e-02f, -1.48685917e-01f, 4.42636013e-02f, -1.15688436e-01f,
  -4.70663756e-02f, -2.06950866e-02f, -1.62127893e-02f, -9.60001070e-03f, -9.82184336e-02f, -5.44033898e-03f, 1.33904722e-02f, -3.56369168e-02f, -3.06704128e-03f, -5.59133552e-02f,
  2.56600846e-02f, 8.69957581e-02f, -1.62376747e-01f, -1.51392147e-01f, 1.24975018e-01f, 1.20165544e-02f, -4.54730503e-02f, -5.67994118e-02f, -2.45876722e-02f, -5.68798706e-02f,
  3.20624828e-01f, 3.88896018e-01f, -1.42626494e-01f, -2.20262215e-01f, 7.64587447e-02f, -6.73306286e-02f, 1.03191487e-01f, -7.34725073e-02f, 2.80345142e-01f, -4.08109426e-02f,
  -3.16248871e-02f, -1.30430460e-01f, -2.44956426e-02f, 9.37003046e-02f, 1.19847693e-01f, 3.34327086e-03f, 5.24086282e-02f, 4.75118645e-02f, 2.92379297e-02f, -1.55164311e-02f,
  -2.35696912e-01f, -6.05291240e-02f, -6.66980539e-03f, -1.83925375e-01f, -1.68164328e-01f, -1.28049850e-01f, -5.67319281e-02f, 1.02013409e-01f, 2.19837874e-02f, 1.08358949e-01f,
  -3.59289318e-01f, -2.73540527e-01f, -4.65862304e-02f, 3.91605437e-01f, -2.59035021e-01f, -2.54870832e-01f, -3.81262809e-01f, -1.62910938e-01f, -3.71418387e-01f, -7.55043551e-02f,
  2.30197042e-01f, -1.33194476e-01f, -4.52247292e-01f, 5.23034394e-01f, 3.78302068e-01f, -2.70931184e-01f, 5.94134331e-01f, 1.86943263e-01f, 6.38326034e-02f, 3.03423762e-01f,
  2.97153443e-01f, 4.77857947e-01f, 2.87661701e-01f, 3.92309815e-01f, 1.01813987e-01f, 2.92015433e-01f, 6.96412563e-01f, 1.02965059e-02f, 8.18710208e-01f, 3.32027733e-01f,
  2.04645336e-01f, -4.83184569e-02f, -5.95740341e-02f, 7.69817606e-02f, 1.36359662e-01f, 8.43973160e-02f, 1.79527272e-02f, 6.66828081e-02f, -2.67130751e-02f, 7.44987503e-02f,
  -7.75444880e-02f, 7.09218681e-02f, 2.39877790e-01f, -4.83767726e-02f, -5.72457165e-02f, -1.07056715e-01f, -1.52355790e-01f, -1.72131181e-01f, -1.06152542e-01f, -2.26341262e-01f,
  -2.34083369e-01f, -1.69958606e-01f, -5.77567145e-02f, 8.22786242e-02f, 5.23125716e-02f, 1.36795640e-02f, 9.62267444e-02f, -6.62558153e-02f, -8.70604906e-03f, -1.60074085e-02f,
  7.01502040e-02f, -1.06004477e-01f, -2.21923783e-01f, -7.11655244e-02f, -4.64148931e-02f, 1.47370428e-01f, -1.05317049e-04f, 1.09441511e-01f, -7.73586631e-02f, 1.10266365e-01f,
  7.35845864e-02f, -4.61515300e-02f, 5.29140569e-02f, -5.78014702e-02f, 6.08938001e-02f, -4.62923758e-02f, -9.44820717e-02f, 8.40996355e-02f, 5.62968850e-02f, 3.33907939e-02f,
  -3.00505031e-02f, -5.42425644e-03f, -2.15486716e-02f, 9.63475183e-02f, -6.49095252e-02f, -5.81907742e-02f, 7.24916309e-02f, -5.68953305e-02f, 7.89001659e-02f, 1.37202758e-02f,
  2.95936584e-01f, 3.26847970e-01f, 1.37576703e-02f, 4.62140888e-02f, 5.26101254e-02f, -7.20031559e-02f, 8.72464925e-02f, 1.82717472e-01f, 1.54524073e-01f, -5.33327423e-02f,
  7.75353611e-02f, 7.41167888e-02f, -9.12750885e-02f, 8.67505446e-02f, 2.29053900e-01f, -1.49796950e-02f, 1.07664205e-01f, 2.18418557e-02f, 1.35575339e-01f, 1.09768942e-01f,
  -5.45361079e-02f, -8.08443502e-02f, 4.68190163e-02f, -1.99485764e-01f, 6.30473271e-02f, 2.17284746e-02f, 2.05535232e-03f, 2.14967448e-02f, 4.53894176e-02f, 1.34769604e-01f,
  -3.94601256e-01f, 3.76863092e-01f, -2.73850858e-01f, -1.08771764e-01f, -1.62212297e-01f, -1.00405812e+00f, -1.36170939e-01f, -1.06983691e-01f, 3.25839430e-01f, 2.58544385e-01f,
  9.80054364e-02f, 4.32388395e-01f, 5.80277741e-01f, 1.48917809e-01f, -6.19764984e-01f, 4.54357654e-01f, -4.43949997e-01f, 1.17949713e-02f, 2.17731565e-01f, -2.81514943e-01f,
  -2.29778528e-01f, -3.09758801e-02f, -1.02847546e-01f, -6.08678423e-02f, -2.18425840e-01f, -5.40101230e-02f, -1.07869208e-01f, 2.47818112e-01f, -3.93087804e-01f, -7.77651668e-02f,
  -4.07268018e-01f, 8.68582577e-02f, 1.69820249e-01f, -1.79706499e-01f, -2.87436634e-01f, -7.33759925e-02f, -1.04330607e-01f, 1.55461326e-01f, 1.79487705e-01f, 7.97645375e-02f,
  1.30290776e-01f, 3.97738479e-02f, -6.92043127e-03f, 1.53329402e-01f, 3.49340662e-02f, 6.75273016e-02f, -1.27220646e-01f, -1.41155884e-01f, 1.36863053e-01f, 2.96244230e-02f,
  2.65541207e-02f, -9.77515131e-02f, -2.32641846e-01f, 1.15644395e-01f, -1.22136161e-01f, -1.97990593e-02f, -1.52922317e-01f, -1.02025449e-01f, -3.63812566e-01f, -2.37042680e-01f,
  -1.12184221e-02f, 8.98180082e-02f, 1.97014422e-03f, 2.20366511e-02f, 1.10275276e-01f, -1.29804298e-01f, -1.25512481e-02f, 7.88474083e-02f, 5.02407402e-02f, 1.19355246e-02f,
  -3.38098630e-02f, -7.24506825e-02f, 6.99249059e-02f, -1.06992580e-01f, -7.81539455e-02f, 1.61036536e-01f, 9.40483809e-03f, -6.18612953e-03f, -1.16695628e-01f, -1.16646014e-01f,
  1.72468722e-01f, -1.59317896e-01f, 1.22300871e-02f, -9.62523296e-02f, -4.53724563e-02f, 4.70474735e-02f, 1.58945993e-02f, -1.41147450e-01f, 8.25840086e-02f, -1.10125847e-01f,
  -8.95197749e-01f, -6.48809314e-01f, 2.06441343e-01f, 3.89234871e-02f, 2.66734008e-02f, -1.22174397e-01f, 7.25447610e-02f, -1.00411456e-02f, -9.10618082e-02f, -1.29770949e-01f,
  -2.26410687e-01f, -1.87034216e-02f, -3.22943270e-01f, 1.06671184e-01f, 1.23355821e-01f, -8.58891606e-02f, 2.89862771e-02f, 1.50553241e-01f, -1.71777621e-01f, -9.49860737e-02f,
  -7.28680566e-03f, 7.02093914e-02f, 5.79766883e-03f, 4.80758809e-02f, 7.17661679e-02f, -3.34026292e-02f, -1.37321323e-01f, 1.88230470e-01f, -1.68375984e-01f, -3.84398848e-02f,
  -1.05658188e-01f, 3.36122990e-01f, 2.13608041e-01f, 2.65028387e-01f, -1.77081290e-03f, -5.28740406e-01f, -7.54670084e-01f, 2.44207695e-01f, 1.66152534e-03f, -4.40073967e-01f,
  -3.90005112e-01f, 9.71845724e-03f, -1.53625220e-01f, 5.39395884e-02f, 3.95186663e-01f, 2.56113887e-01f, 1.74177989e-01f, -5.59092350e-02f, 5.61161399e-01f, 2.69020736e-01f,
  5.62964916e-01f, 1.20774440e-01f, 6.22761786e-01f, 3.29323620e-01f, 1.97790504e-01f, 3.30911100e-01f, 3.09094459e-01f, 8.07924941e-02f, -5.64750396e-02f, -1.53280780e-01f,
  -1.10986494e-01f, 5.18034175e-02f, 1.59962475e-02f, -1.37739703e-01f, 1.43629432e-01f, -2.52359629e-01f, -3.12109534e-02f, -1.15962148e-01f, -6.71874732e-02f, 5.68042451e-04f,
  -5.68008935e-03f, 2.38511235e-01f, -3.71752530e-02f, -6.48288131e-02f, -3.84719782e-02f, 8.54935423e-02f, 3.63014072e-01f, 3.08648460e-02f, 1.66075557e-01f, 1.53797567e-01f,
  1.21667877e-01f, 1.27495304e-01f, -8.11950117e-02f, 7.54366890e-02f, 5.31095974e-02f, -4.27160934e-02f, -4.66263928e-02f, -1.09303176e-01f, -3.00429892e-02f, -7.76817137e-03f,
  -9.57069546e-02f, -2.57754233e-02f, -2.70866174e-02f, 6.26454689e-03f, -1.74929485e-01f, 1.65282227e-02f, -4.84746881e-02f, -6.41041473e-02f, 2.76258588e-02f, -5.58423661e-02f,
  2.56812125e-02f, 7.80222788e-02f, 1.72535498e-02f, -1.20476343e-01f, 2.51373556e-02f, -1.11188672e-01f, 5.14597036e-02f, -1.63683351e-02f, 6.49047345e-02f, 1.17588222e-01f,
  -1.09152220e-01f, -9.03031603e-03f, 9.58633199e-02f, 6.91663772e-02f, -1.81629419e-01f, 1.35169998e-01f, 2.19953582e-02f, -9.60634723e-02f, 9.25500840e-02f, 2.13036478e-01f,
  -1.03733130e-01f, 7.95643106e-02f, -1.55829648e-02f, -1.28506988e-01f, -1.14694685e-01f, 6.28010035e-02f, -2.26316918e-02f, 1.03869095e-01f, -6.57988340e-02f, -2.00000405e-02f,
  -3.69645432e-02f, -6.25164583e-02f, -1.02334060e-02f, 3.34183723e-02f, 5.26230820e-02f, -4.86723408e-02f, -1.59406990e-01f, -1.01594023e-01f, -6.21560514e-02f, 2.08132505e-01f,
  -8.13348517e-02f, -4.13934775e-02f, -1.25618786e-01f, 1.14102423e-01f, -3.68925347e-03f, 4.13927771e-02f, -1.27138421e-01f, 8.76476709e-03f, -3.39705944e-02f, 3.27611975e-02f,
  -5.32907903e-01f, -6.70892775e-01f, -2.81140655e-01f, -1.49286434e-01f, -9.03044790e-02f, 4.56027150e-01f, 8.75182092e-01f, -5.08051515e-01f, -6.45752788e-01f, 1.91446111e-01f,
  4.85683203e-01f, -1.77151278e-01f, 5.24600089e-01f, 2.60077626e-01f, 5.70411205e-01f, 3.40430528e-01f, 3.44318241e-01f, 3.76809955e-01f, -3.65849763e-01f, -1.44954681e-01f,
  -1.07088216e-01f, 3.88877630e-01f, 4.34274733e-01f, -3.00585240e-01f, 1.11659728e-01f, -3.96953762e-01f, 3.16936225e-01f, 1.29479572e-01f, 3.22875917e-01f, 4.50679541e-01f,
  6.74541155e-03f, -5.51159024e-01f, -8.00140202e-02f, -7.19778761e-02f, 3.48178111e-02f, 1.05573356e-01f, 2.19378456e-01f, 3.56883824e-01f, -9.32883471e-03f, -1.08259574e-01f,
  4.62141894e-02f, -1.18239209e-01f, -1.78821132e-01f, 8.07515066e-03f, -1.21649869e-01f, -3.24307889e-01f, -1.37232587e-01f, 4.07882147e-02f, -2.33574286e-01f, 4.31360193e-02f,
  -5.77337407e-02f, -2.16045901e-02f, -6.37286156e-02f, 1.13613233e-01f, -1.16027139e-01f, -1.03112124e-01f, 8.10517371e-02f, 1.57567009e-01f, -5.35081215e-02f, -1.02052592e-01f,
  3.57870162e-02f, 9.46197286e-02f, 2.91236602e-02f, 1.46021266e-02f, -5.06931692e-02f, 1.32125197e-02f, 5.11642322e-02f, 4.75721732e-02f, -3.84308621e-02f, -2.12737322e-02f,
  -7.21820220e-02f, -1.94033086e-02f, -5.28917201e-02f, 4.70392853e-02f, 4.46566939e-02f, -4.80325222e-02f, 1.28283009e-01f, -4.48841229e-02f, -1.06597006e-01f, -3.61654758e-02f,
  5.38677014e-02f, -6.56002387e-02f, 4.33043167e-02f, 1.21878393e-01f, 5.24882860e-02f, 2.69920509e-02f, -1.02348305e-01f, -1.41924813e-01f, -3.91012616e-02f, 2.42771387e-01f,
  -1.47804946e-01f, -4.54898894e-01f, -8.28238428e-02f, -5.28619997e-02f, 5.40211760e-02f, 2.96498984e-02f, 2.02954491e-03f, -1.70905754e-01f, 1.98685061e-02f, -9.61913988e-02f,
  1.26914736e-02f, 6.04273416e-02f, -6.43806681e-02f, 1.84129458e-02f, -2.90440805e-02f, -3.85875814e-02f, 1.49193615e-01f, -6.04552254e-02f, 8.06694925e-02f, -9.78244022e-02f,
  -3.79395708e-02f, -4.90165269e-03f, 2.75132637e-02f, -1.69665501e-01f, 2.35569831e-02f, 7.31223673e-02f, -2.07105324e-01f, -7.04515055e-02f, 8.69768858e-02f, -1.97488908e-02f,
  -8.10387611e-01f, 9.67006385e-02f, 1.45930544e-01f, -5.40675879e-01f, 4.72540855e-01f, 6.15555108e-01f, -4.10061896e-01f, 5.37409663e-01f, -1.88765094e-01f, -1.57503173e-01f,
  -2.91769236e-01f, -6.11031175e-01f, -1.58059895e-01f, -3.34177673e-01f, -2.81548917e-01f, -2.38159463e-01f, -2.36864328e-01f, -5.69311798e-01f, 4.39718924e-02f, -1.37820825e-01f,
  -7.74407238e-02f, -1.72840983e-01f, 2.76745200e-01f, 6.02829993e-01f, 2.67557621e-01f, 2.19555855e-01f, -6.36320338e-02f, 4.32972789e-01f, 1.17597096e-01f, 3.49964686e-02f,
  -4.59214821e-02f, -2.17544734e-01f, 1.63379237e-01f, 1.51367068e-01f, 1.48759127e-01f, 5.77828176e-02f, -9.83130932e-02f, 1.94200838e-03f, -5.08079790e-02f, 4.22705226e-02f,
  -7.05264583e-02f, 6.95233643e-02f, -1.03633389e-01f, 1.06678553e-01f, 1.09958328e-01f, 9.98764262e-02f, 5.17734326e-02f, 1.15944698e-01f, 8.39477703e-02f, 2.04953011e-02f,
  -9.47887227e-02f, 1.69737458e-01f, 2.17508152e-02f, -1.08240522e-01f, 4.12662253e-02f, -2.80860774e-02f, 2.52996515e-02f, 3.51287285e-03f, -1.98170133e-02f, 2.40345486e-02f,
  -5.07094944e-03f, 8.05461258e-02f, -5.78993447e-02f, -3.60429706e-03f, -6.32803142e-02f, -7.56329820e-02f, -1.14979319e-01f, -3.24724205e-02f, -5.50013175e-03f, 2.69473735e-02f,
  5.86318895e-02f, -3.16506773e-02f, 2.98069417e-03f, 4.42958064e-02f, -4.86333333e-02f, 1.48122078e-02f, -1.55104781e-02f, -1.03476867e-01f, 4.96297553e-02f, 8.70647579e-02f,
  -8.57585389e-03f, -8.83362908e-03f, 8.09485279e-03f, 2.92371921e-02f, 3.37621123e-02f, 1.32212397e-02f, 1.17423534e-01f, 3.08747031e-02f, 1.04626969e-01f, -2.55451147e-02f,
  -3.36268879e-02f, -3.92985553e-01f, 1.22340970e-01f, 3.60690467e-02f, -5.89257963e-02f, -6.38871863e-02f, 6.38449714e-02f, 9.04632285e-02f, 3.51355635e-02f, -4.55110259e-02f,
  1.90564916e-01f, 3.71676544e-03f, -1.31596401e-02f, -2.94439979e-02f, 6.03753747e-03f, -5.25895394e-02f, -2.82196641e-01f, 4.01991094e-03f, 5.63680418e-02f, 4.24353778e-02f,
  -1.30910110e-02f, -6.48544207e-02f, 4.90228236e-02f, 2.33746946e-01f, 1.87687259e-02f, -1.31049499e-01f, -6.31872937e-02f, 5.15911840e-02f, -7.42169768e-02f, -8.08621347e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  4.78784919e-01f, 3.50185513e-01f, 5.46762049e-01f, 4.86279517e-01f, 6.50710583e-01f, 6.73352897e-01f, 6.45326495e-01f, 5.69368243e-01f, 3.04594308e-01f, 7.16695070e-01f,
  2.47858971e-01f, 6.73450768e-01f, 5.74990034e-01f, 5.00283957e-01f, 3.99104059e-01f, 5.02752364e-01f, 3.09469163e-01f, 4.39579666e-01f, 4.54750389e-01f, 7.22508967e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -2.52034664e-01f, -1.57659292e-01f, 1.94571555e-01f, -3.67248535e-01f, -3.82441394e-02f, 1.42976135e-01f, 6.66194022e-01f, 4.24606651e-01f, -5.46352148e-01f, -3.07236612e-01f,
  -7.40342975e-01f, 4.30913419e-01f, -9.01599765e-01f, 5.42488575e-01f, -1.75028369e-02f, -4.49598998e-01f, -5.39892733e-01f, 1.65158659e-01f, -4.55719411e-01f, -5.41752696e-01f,
  -2.41199255e-01f, 4.66588736e-01f, 6.55372918e-01f, -1.00918424e+00f, -8.18978727e-01f, 6.36711061e-01f, -4.53585148e-01f, 3.27900410e-01f, 3.50364685e-01f, -6.68964922e-01f,
  7.21238434e-01f, -8.48763227e-01f, 1.82690948e-01f, -6.03364170e-01f, -3.97098154e-01f, -2.13926330e-01f, -5.77785134e-01f, 3.49721968e-01f, -8.53871822e-01f, 6.52392268e-01f,
  7.68346369e-01f, 1.47390828e-01f, -3.72061551e-01f, 4.20799553e-01f, 9.42302346e-01f, -2.67881364e-01f, -7.25351810e-01f, -4.94934320e-01f, -1.22646213e+00f, -5.97046733e-01f,
  6.73584521e-01f, 1.04418375e-01f, 9.70756188e-02f, 5.80353498e-01f, -8.47606957e-01f, -2.87078619e-01f, 3.52869600e-01f, 3.96381408e-01f, -7.06807792e-01f, -1.84066921e-01f,
  -6.52787268e-01f, -3.72403711e-01f, 2.85541803e-01f, -5.13331354e-01f, 2.24130929e-01f, 1.48219429e-02f, -3.89711201e-01f, 1.40279010e-01f, -1.91008016e-01f, -5.70623502e-02f,
  9.93531868e-02f, -4.29778546e-01f, 2.66000688e-01f, 1.12943225e-01f, -1.88518718e-01f, -1.19280718e-01f, 5.91149449e-01f, -6.74742401e-01f, -5.45809925e-01f, -5.54316819e-01f,
  6.98645055e-01f, -4.95631397e-02f, 4.19876844e-01f, -6.14890277e-01f, -6.89118683e-01f, -8.40141952e-01f, -4.00058359e-01f, -7.73891866e-01f, -3.98633659e-01f, -5.19051492e-01f,
  -5.49923062e-01f, 6.57651603e-01f, -2.51394957e-01f, -6.97984025e-02f, 1.81847915e-01f, 2.89836466e-01f, 3.28522712e-01f, 8.26800466e-02f, 7.54981712e-02f, -3.22049379e-01f,
  -3.84546757e-01f, -5.41508615e-01f, -4.80354071e-01f, 6.11082673e-01f, -9.19739962e-01f, -6.96301937e-01f, 7.34561607e-02f, -3.36071163e-01f, -7.12234557e-01f, -4.87188101e-01f,
  1.96809042e-02f, 5.29935539e-01f, -4.06548530e-01f, 6.89042926e-01f, -4.62765992e-01f, -4.96228844e-01f, -3.79185736e-01f, 3.59618038e-01f, -7.02294171e-01f, -6.15946949e-01f,
  -6.06749237e-01f, 2.49603555e-01f, -6.10542417e-01f, -8.05929303e-01f, 1.12285435e+00f, -2.89344907e-01f, -6.03390276e-01f, 1.76693097e-01f, -1.96734548e-01f, 5.43501139e-01f,
  -1.44314513e-01f, 9.95764285e-02f, 1.61845878e-01f, -2.04051927e-01f, 7.34128177e-01f, -4.24759209e-01f, -1.71021372e-01f, 1.02217770e+00f, 1.03096604e+00f, -7.99114645e-01f,
  -3.89187008e-01f, 5.02874367e-02f, -8.21195304e-01f, -1.51197121e-01f, -2.42033973e-01f, 3.39735717e-01f, -7.89650321e-01f, -5.79680026e-01f, 1.04207993e-01f, 2.14614004e-01f,
  -7.36436322e-02f, -6.32718623e-01f, 2.92132527e-01f, 7.54759014e-01f, 6.76862240e-01f, -1.10058367e-01f, -4.74867940e-01f, 5.17208457e-01f, -3.72324914e-01f, 8.13468575e-01f,
  4.60038215e-01f, 5.52638471e-01f, 5.61791360e-01f, 5.86365648e-02f, 1.00324547e+00f, 3.67216975e-03f, -3.85606229e-01f, 7.10347831e-01f, -1.58390492e-01f, 5.62950253e-01f,
  -3.37032318e-01f, 2.01403812e-01f, -1.42401233e-01f, 7.61463046e-02f, 1.92433909e-01f, -6.17065191e-01f, -1.78301126e-01f, -7.83846855e-01f, -1.72985718e-02f, -6.43074736e-02f,
  -8.02838922e-01f, 4.06244308e-01f, 7.33170807e-01f, 7.02863157e-01f, -4.17857096e-02f, -8.34496915e-01f, 9.94056404e-01f, -2.44782105e-01f, -2.20057204e-01f, -6.57895207e-01f,
  -5.69933057e-01f, -7.86666036e-01f, -4.76467520e-01f, 2.21064035e-02f, 1.39071420e-01f, 1.26081958e-01f, -1.03568219e-01f, 4.81710061e-02f, 4.69976068e-01f, -4.39926565e-01f,
  -2.55156726e-01f, -8.18367362e-01f, -6.51663661e-01f, 8.02923858e-01f, -3.09613854e-01f, -6.46777153e-01f, -3.94318193e-01f, -2.67447352e-01f, 5.65441251e-01f, -6.68912649e-01f,
  8.99889410e-01f, -5.70169508e-01f, 6.94917858e-01f, -3.60752046e-01f, -5.48374295e-01f, 6.56826615e-01f, -5.89882016e-01f, -4.89577144e-01f, -5.63433886e-01f, -9.29026127e-01f,
  -3.65596354e-01f, 3.48140657e-01f, -8.74374866e-01f, 3.12216401e-01f, -2.97430698e-02f, -1.71566874e-01f, -8.61071274e-02f, -3.43622327e-01f, -1.16140209e-01f, -6.21658981e-01f,
  5.49990870e-02f, -4.42668915e-01f, -1.58821315e-01f, -3.67435396e-01f, 2.14316681e-01f, -1.38406292e-01f, -6.16006851e-01f, -3.77270192e-01f, 3.13750476e-01f, 3.40613753e-01f,
  -2.11060137e-01f, -7.86617517e-01f, -2.35313386e-01f, -6.52939022e-01f, -4.76842254e-01f, -1.02519512e-01f, 5.11158943e-01f, -3.22071820e-01f, 6.81464612e-01f, -5.30742645e-01f,
  7.55154639e-02f, -3.79192114e-01f, 5.44135153e-01f, 6.46147907e-01f, -4.60055202e-01f, -5.58652341e-01f, -3.70240837e-01f, 4.55776957e-04f, -1.31148443e-01f, 2.28765309e-01f,
  2.62567073e-01f, -3.58282417e-01f, -3.07891220e-01f, 2.44030893e-01f, 3.26676399e-01f, 1.18977621e-01f, -2.55721003e-01f, 1.89631507e-01f, -2.25312352e-01f, 8.13436210e-01f,
  -2.86065519e-01f, -1.82925805e-01f, -2.59727538e-01f, -5.36479473e-01f, -7.52177536e-01f, 4.18232024e-01f, -2.99116492e-01f, -3.26590806e-01f, -2.79903769e-01f, -3.24456841e-01f,
  -3.82026553e-01f, -5.14655590e-01f, -4.63253587e-01f, 6.07534707e-01f, -1.92845270e-01f, 7.64828920e-01f, -5.77641964e-01f, -2.18481943e-01f, 2.21782476e-01f, -6.60798967e-01f,
  1.40835628e-01f, 3.87489088e-02f, 4.33235586e-01f, 2.63657290e-02f, 2.46060997e-01f, -4.11427230e-01f, 2.77729273e-01f, 4.63941753e-01f, -9.18683186e-02f, -9.00544584e-01f,
  -4.69199061e-01f, -5.66484213e-01f, -4.04302567e-01f, -7.07923412e-01f, 5.41642487e-01f, -1.45425498e-01f, -4.47195530e-01f, -4.79790866e-01f, 6.74248159e-01f, -9.08344924e-01f,
  -1.36641100e-01f, 6.15018755e-02f, 7.00810611e-01f, 5.89919798e-02f, 7.28738084e-02f, -4.69925821e-01f, 1.04799777e-01f, -7.50110626e-01f, 8.88765395e-01f, -9.62092519e-01f,
  8.58727768e-02f, 1.19817428e-01f, -1.85874224e-01f, 3.66976082e-01f, 4.23023939e-01f, 5.44010401e-01f, -6.01263404e-01f, -2.49913316e-02f, 1.06152284e+00f, -8.84978026e-02f,
  5.01739323e-01f, 2.12710023e-01f, 3.79281044e-01f, -3.40528667e-01f, 9.41464543e-01f, 7.06181049e-01f, -4.86396164e-01f, 2.49908194e-01f, -3.13872486e-01f, -3.23893219e-01f,
  -4.16328102e-01f, -6.88179255e-01f, -4.47858334e-01f, -4.40589726e-01f, -7.01274335e-01f, -1.38090700e-01f, -5.76352119e-01f, 1.19214524e-02f, -1.11645114e+00f, -3.27375531e-01f,
  -5.26666874e-03f, 5.16654730e-01f, -3.48821491e-01f, -1.72008835e-02f, -1.01215713e-01f, 3.89888704e-01f, -3.92543107e-01f, 2.25050256e-01f, 6.79763496e-01f, -5.35042048e-01f,
  -5.76217294e-01f, -2.45825797e-01f, 6.51667118e-01f, 5.16567349e-01f, -1.40514001e-01f, -1.62472710e-01f, 2.00718492e-01f, -6.06020927e-01f, 8.50974992e-02f, 2.41059214e-01f,
  -4.51694578e-01f, 1.22552156e+00f, -5.38393676e-01f, -6.09478354e-01f, -7.43551031e-02f, 4.40849125e-01f, -4.03924286e-01f, -3.68168414e-01f, -3.40771168e-01f, -6.09506905e-01f,
  3.41813922e-01f, -6.38310686e-02f, -4.90526468e-01f, -2.78583795e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -9.05386955e-02f, 4.98753265e-02f, -1.45708591e-01f, 2.80118175e-03f, 1.96308270e-01f, 5.11392653e-02f, 1.77819893e-01f, -1.47372067e-01f, 8.68627578e-02f, -7.49759376e-02f,
  -2.13897061e-02f, 2.65307069e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    