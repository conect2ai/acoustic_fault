/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.87527895e-01f, 9.48128626e-02f, 3.44766498e-01f, -1.41050920e-01f, 1.01741940e-01f, -7.96992611e-03f, 1.83938593e-01f, -8.79784077e-02f, 3.40554446e-01f, -2.74426639e-01f,
  -1.62655726e-01f, 2.38393486e-01f, 5.01810685e-02f, -2.06994265e-01f, 1.67507112e-01f, -7.23270327e-02f, -1.08513437e-01f, 3.24124284e-03f, 1.22100577e-01f, -9.97953117e-02f,
  3.02713607e-02f, -2.91278720e-01f, -5.29375672e-02f, -2.91458756e-01f, 7.04861805e-03f, 7.90023208e-02f, -2.44713590e-01f, -2.26284061e-02f, -2.89732188e-01f, -7.12502655e-03f,
  -1.27251402e-01f, 6.42877668e-02f, -3.89345968e-03f, 1.66629395e-03f, 5.74930087e-02f, 1.49664218e-02f, -7.08862767e-03f, 1.46938125e-02f, -6.52119610e-03f, 4.05465327e-02f,
  4.50564250e-02f, 9.47882794e-03f, 4.60838452e-02f, -1.03761218e-02f, 2.68803854e-02f, 6.38940325e-03f, 6.15068860e-02f, 9.06120113e-05f, 1.18793778e-01f, 4.20236886e-02f,
  4.04464751e-02f, -8.15896876e-03f, 2.19044834e-02f, -2.96554957e-02f, 6.04162067e-02f, 3.27330641e-02f, 1.38543416e-02f, 5.72503284e-02f, 5.42190932e-02f, 6.98173791e-02f,
  -4.73408811e-02f, 2.05222405e-02f, 2.25831587e-02f, -2.47733272e-03f, 1.72092132e-02f, -3.69799174e-02f, -3.48860361e-02f, 4.64003824e-04f, 6.21974692e-02f, -4.86857519e-02f,
  -5.28850183e-02f, 1.64639521e-02f, -3.03367786e-02f, 5.54673970e-02f, -9.92172398e-03f, 4.02222807e-03f, 2.43221950e-02f, -1.41845653e-02f, -8.44284659e-04f, 8.21600261e-04f,
  -5.45141113e-04f, 2.27963249e-03f, -1.67070050e-02f, -5.58111630e-03f, -3.88727412e-02f, 1.11774161e-01f, -5.64473979e-02f, 6.34198040e-02f, 2.05413327e-02f, 2.74150223e-02f,
  -1.46284685e-01f, -1.91524979e-02f, 3.12167145e-02f, 3.40004638e-02f, -8.06443840e-02f, -3.50258090e-02f, 2.54114103e-02f, 2.42878944e-02f, 3.39830592e-02f, -3.55167054e-02f,
  -4.90911417e-02f, 5.43175405e-03f, -1.40866796e-02f, -5.33525869e-02f, -8.40758011e-02f, -1.59699824e-02f, -7.18978718e-02f, -1.61550771e-02f, -1.08941436e-01f, -1.62777882e-02f,
  6.92801364e-03f, 6.37575239e-02f, -6.49712002e-03f, 3.61297168e-02f, -7.65501931e-02f, -2.79291440e-02f, 2.09501218e-02f, 3.14384475e-02f, -8.57104361e-02f, -8.18234012e-02f,
  1.02751411e-01f, 1.13078490e-01f, 2.22984806e-01f, 4.11127545e-02f, 2.23970011e-01f, 7.61832148e-02f, -1.27874613e-01f, 2.23158956e-01f, 1.60019487e-01f, -1.46172613e-01f,
  4.33494989e-03f, 3.55746448e-02f, -1.41468465e-01f, 1.10466070e-01f, -3.30605358e-01f, -9.53154638e-02f, -1.29696161e-01f, -9.67070684e-02f, 1.65618762e-01f, -1.05701126e-01f,
  1.20544896e-01f, 1.68127250e-02f, 1.32269431e-02f, 3.31795156e-01f, 2.37333104e-02f, 8.32950026e-02f, -2.73588777e-01f, 1.44175962e-01f, 5.51416278e-02f, 3.81254964e-02f,
  1.43606052e-01f, 1.89680710e-01f, 1.14671215e-01f, 1.19746467e-02f, -8.59543756e-02f, -1.52961072e-02f, -6.16213307e-02f, 3.44238095e-02f, 4.31557894e-02f, 1.19858393e-02f,
  -5.42503819e-02f, -3.11726751e-03f, 3.00099067e-02f, 3.42865810e-02f, 2.21702661e-02f, 8.57223645e-02f, 5.36962561e-02f, 9.47303548e-02f, 7.56807625e-02f, 6.64266050e-02f,
  2.16976069e-02f, 1.27104580e-01f, -3.02761346e-02f, -3.31088379e-02f, 3.92600335e-02f, -8.84957891e-03f, 9.25725102e-02f, -6.02656826e-02f, -1.32797016e-02f, 9.35713053e-02f,
  4.53216359e-02f, -1.44419484e-02f, -3.20063834e-03f, 2.92309467e-02f, 2.04208214e-02f, 6.08217083e-02f, -1.52172353e-02f, -1.55574922e-02f, -2.71318518e-02f, 4.56618331e-02f,
  -2.94719171e-02f, 3.13904323e-02f, 5.10411114e-02f, 4.11466807e-02f, 2.25860272e-02f, 6.77498523e-03f, -7.15724975e-02f, -1.76632572e-02f, -3.33423959e-03f, 3.62201710e-03f,
  2.70414799e-02f, -6.13093376e-04f, 1.04979118e-02f, -3.79994209e-03f, 1.62270591e-02f, -4.06245440e-02f, 8.49927776e-04f, 4.47572917e-02f, -4.58437130e-02f, -5.30213527e-02f,
  -2.96395928e-01f, -3.62448633e-01f, 8.81078746e-03f, 1.06676809e-01f, 8.08230974e-03f, -4.51651923e-02f, 6.86226040e-02f, -1.30455093e-02f, -9.20802057e-02f, 2.70000361e-02f,
  -2.70180795e-02f, -4.35806587e-02f, -9.82136801e-02f, 3.19480188e-02f, 3.78031060e-02f, -9.52088311e-02f, -1.30272254e-01f, -9.48101208e-02f, -8.61514732e-02f, 6.08488638e-03f,
  -3.75314876e-02f, -1.18461914e-01f, 3.20009142e-02f, 3.06766387e-02f, 2.41022203e-02f, -2.80848425e-02f, -6.61351681e-02f, 7.34465495e-02f, -4.79405634e-02f, -4.34139967e-02f,
  1.15464538e-01f, 4.11601186e-01f, 1.03555024e-01f, 1.12600327e-01f, -2.53481925e-01f, 2.03960791e-01f, 2.69526005e-01f, -1.80462390e-01f, 1.58128098e-01f, 1.28384888e-01f,
  2.62767226e-01f, -8.31105188e-02f, 2.32648790e-01f, 3.11349332e-01f, -1.59974366e-01f, 4.18641537e-01f, -4.71658260e-03f, 2.66040444e-01f, -6.79373182e-03f, 1.29504381e-02f,
  -4.37757894e-02f, -6.13143630e-02f, -1.78855006e-02f, -4.27914597e-02f, -1.06567405e-01f, -1.65664300e-01f, -2.19093978e-01f, -8.90413858e-03f, 2.60600485e-02f, -1.20563498e-02f,
  3.43247503e-02f, 8.77436623e-02f, -6.57535717e-02f, 3.43445316e-02f, -1.29590914e-01f, -3.85256074e-02f, -1.11414291e-01f, 2.54701581e-02f, 1.37596466e-02f, 6.38013035e-02f,
  3.94372977e-02f, -7.64023736e-02f, 5.19462712e-02f, 7.68991262e-02f, 3.70961940e-03f, -4.72971471e-04f, 5.03456183e-02f, 6.31096810e-02f, -2.45506894e-02f, 6.30849972e-02f,
  1.33997053e-02f, 1.41072005e-03f, 1.99258793e-02f, 3.00961576e-04f, -4.27374132e-02f, -1.33504206e-02f, -4.23006080e-02f, -1.12154007e-01f, -1.42613322e-01f, -9.24643427e-02f,
  -5.50382659e-02f, -8.10266957e-02f, -1.45105319e-03f, 3.31102163e-02f, 3.98852080e-02f, -2.06467584e-02f, 8.28743353e-02f, 1.33081255e-02f, -6.52993992e-02f, 6.69140890e-02f,
  -2.28669196e-02f, -5.25119482e-04f, 2.62403488e-02f, 1.15992397e-03f, 4.71634679e-02f, -3.81701924e-02f, -1.15781585e-02f, 2.75847893e-02f, -7.25791615e-04f, -3.76081094e-02f,
  8.75162706e-03f, -1.73415970e-02f, 7.96093047e-02f, -3.94537598e-02f, 2.73802057e-02f, -5.58256581e-02f, 2.25094482e-02f, 2.00379025e-02f, -5.27137853e-02f, -1.39873708e-02f,
  -2.57569421e-02f, 1.33471945e-02f, 8.01285729e-02f, -4.18085866e-02f, 1.07880637e-01f, 8.07221532e-02f, 5.65055907e-02f, -3.28836814e-02f, -7.35805333e-02f, -2.52493825e-02f,
  -1.14874847e-01f, -1.02095753e-02f, -1.31003752e-01f, 2.82728076e-02f, -2.93535814e-02f, -1.92813650e-02f, 3.44384718e-03f, -1.18498296e-01f, -1.63657784e-01f, -3.25964950e-02f,
  -6.99283853e-02f, 4.96361330e-02f, -1.07329085e-01f, -3.66642065e-02f, -5.81484437e-02f, -5.36597334e-03f, -4.57381792e-02f, 5.66236116e-02f, 7.46227279e-02f, 5.65704107e-02f,
  -2.42361233e-01f, -1.38512284e-01f, -1.82062685e-01f, -2.07562461e-01f, 4.65131104e-02f, -3.09918582e-01f, -1.52226031e-01f, -6.25717118e-02f, -5.23477681e-02f, 2.65705772e-02f,
  -7.08485860e-03f, -9.16186050e-02f, 2.93112770e-02f, -2.97045618e-01f, -2.80543417e-01f, -8.64984095e-02f, -3.75661105e-01f, -4.56651412e-02f, 2.54293648e-03f, -1.98173374e-02f,
  -5.78235276e-02f, -6.39689788e-02f, -2.88942665e-01f, 4.99774329e-02f, -7.09912553e-02f, 5.26499115e-02f, 1.90979078e-01f, 6.47263527e-02f, -4.77094427e-02f, 1.03730522e-03f,
  -3.31156179e-02f, 9.51952189e-02f, -2.91804057e-02f, -2.92913299e-02f, -6.79578334e-02f, -4.00328711e-02f, 5.03678294e-03f, 1.37783978e-02f, -2.58646626e-03f, -2.42991894e-02f,
  2.00995021e-02f, -1.11468919e-02f, -3.31130065e-02f, -1.88058671e-02f, 3.02777477e-02f, -2.35841423e-02f, 1.37848007e-02f, -2.00475752e-02f, -3.86887230e-02f, -3.54040526e-02f,
  -6.25904351e-02f, -6.43479750e-02f, -3.89949530e-02f, -1.29125854e-02f, -1.15891767e-03f, 2.18387078e-02f, -7.79732838e-02f, 1.78317260e-02f, 2.77444138e-03f, -6.40734583e-02f,
  2.72895005e-02f, 1.11037064e-02f, -3.49278119e-03f, 9.87936370e-03f, -2.37037521e-02f, 4.49834801e-02f, -1.15898848e-02f, 3.22736017e-02f, -2.08835187e-03f, 4.11220342e-02f,
  -1.73190869e-02f, -2.58913916e-02f, 3.49881053e-02f, -1.45357586e-02f, -1.55482339e-02f, -3.69420298e-03f, 1.07098082e-02f, 7.41273686e-02f, -3.97366509e-02f, -1.18036466e-02f,
  -2.19775159e-02f, 1.62247904e-02f, -3.65623320e-03f, 3.28615978e-02f, -2.66543552e-02f, 6.69705495e-03f, 2.51759291e-02f, -2.90965885e-02f, -2.56904913e-03f, 3.69767845e-03f,
  -5.34972399e-02f, -2.91182268e-02f, -3.03289201e-02f, 2.57261526e-02f, 5.64095154e-02f, -1.08506558e-02f, -6.42054304e-02f, 2.65045557e-02f, -8.63739476e-03f, 1.02707557e-02f,
  3.18495892e-02f, 9.05637443e-03f, 3.87755968e-02f, 2.80789211e-02f, -2.83447597e-02f, -3.10673136e-02f, -2.02844925e-02f, 5.18072397e-02f, 1.08850617e-02f, -1.18056254e-03f,
  7.26148710e-02f, 8.70873258e-02f, -1.71096381e-02f, 4.61603701e-03f, -2.82005519e-02f, 9.77583602e-03f, 3.42965312e-02f, -3.86894085e-02f, -2.39717847e-04f, -9.38252266e-03f,
  -4.17831481e-01f, 3.25924993e-01f, 2.10432857e-01f, -1.93049401e-01f, -8.08473025e-03f, -3.69195551e-01f, -2.15638220e-01f, 2.35240355e-01f, -3.30413699e-01f, 1.94223627e-01f,
  -6.80394769e-02f, -1.55572221e-01f, 2.72585958e-01f, -1.61254227e-01f, -2.34289974e-01f, 6.71071932e-02f, -2.19743192e-01f, -1.65149912e-01f, -2.20633037e-02f, -9.20312628e-02f,
  -5.64610399e-02f, -1.58063501e-01f, 2.77592599e-01f, 1.14039429e-01f, 6.39309064e-02f, 7.75815621e-02f, 1.42495200e-01f, 1.16886660e-01f, 7.90612847e-02f, 3.21518965e-02f,
  5.99541934e-04f, 7.37837851e-02f, 1.18181519e-01f, 6.26312394e-04f, -1.20199425e-02f, 2.13135276e-02f, -1.07463092e-01f, -1.17725572e-02f, 3.46997869e-04f, 1.91050600e-02f,
  -1.48103340e-02f, -6.51377141e-02f, -1.16354618e-02f, 1.50518464e-02f, -6.39163405e-02f, -3.03445626e-02f, -2.67631486e-02f, -2.74172947e-02f, 3.06306090e-02f, -3.83669436e-02f,
  -2.40792576e-02f, 3.39517482e-02f, -8.68738219e-02f, -6.87854737e-02f, 1.87715311e-02f, -2.03051288e-02f, -2.29490120e-02f, 2.77380887e-02f, -5.64515255e-02f, -7.29257613e-02f,
  -7.00226352e-02f, 3.53993773e-02f, 2.14836709e-02f, 1.91805530e-02f, -3.57973464e-02f, -8.36332329e-03f, -4.19916995e-02f, -6.49724761e-03f, -2.58255415e-02f, -6.77230358e-02f,
  -1.75731331e-02f, -1.92602407e-02f, -8.33637118e-02f, -2.07550246e-02f, -4.16220278e-02f, 4.84522693e-02f, -4.15006168e-02f, 4.71436009e-02f, -4.64170519e-03f, -8.13344587e-03f,
  7.15228021e-02f, -5.23772016e-02f, 8.98403674e-02f, -9.25662834e-03f, 5.41329645e-02f, 4.42476235e-02f, 3.59587604e-03f, 2.31243912e-02f, 5.29761650e-02f, 4.48054001e-02f,
  -1.20489128e-01f, 3.81289818e-03f, -1.69884022e-02f, -4.95432355e-02f, -2.93135010e-02f, -2.10215747e-02f, 5.59568964e-02f, 2.15389486e-02f, 7.16516655e-03f, 5.42294547e-05f,
  -5.04371040e-02f, 2.72058714e-02f, -4.04138565e-02f, -2.15049274e-02f, 1.60812456e-02f, 6.77523762e-02f, 1.90779418e-02f, -1.18874833e-02f, -4.46521938e-02f, -8.14556703e-03f,
  5.00392262e-03f, -1.28418431e-01f, 2.32891571e-02f, 3.93921658e-02f, -7.45247900e-02f, 1.90253220e-02f, -7.90854543e-02f, -7.50864856e-03f, 6.63511397e-04f, 2.06452515e-02f,
  2.76753545e-01f, 1.24914497e-01f, 1.99303359e-01f, 1.31886676e-01f, 3.15930210e-02f, -3.71237785e-01f, -7.65340254e-02f, -2.01229677e-02f, 3.13706696e-01f, -3.39207537e-02f,
  1.02543846e-01f, 5.76095767e-02f, 1.98730215e-01f, -1.69437081e-01f, 3.71587396e-01f, 2.23652378e-01f, -9.35740843e-02f, -7.79543668e-02f, 1.69969603e-01f, 3.05293277e-02f,
  7.51368701e-02f, -8.86947755e-03f, 5.36538940e-03f, -7.02002719e-02f, -1.70144275e-01f, 2.68619563e-02f, 2.23296951e-03f, 3.23128439e-02f, -1.49465784e-01f, -5.34613281e-02f,
  4.42093834e-02f, 7.26561174e-02f, -4.43978049e-02f, 2.71579437e-03f, -8.77600759e-02f, -1.18719921e-01f, -4.96285595e-03f, -3.09223123e-03f, 5.43235019e-02f, 2.38905512e-02f,
  8.00259337e-02f, 7.65356049e-02f, -4.89770621e-02f, 1.09100593e-02f, -6.58721998e-02f, 4.85494100e-02f, -6.93250149e-02f, -1.21253356e-01f, 4.79447562e-03f, -6.61600456e-02f,
  2.70217247e-02f, -1.05516911e-01f, -1.81443617e-02f, 1.06446957e-02f, 4.61285077e-02f, 7.18333647e-02f, -5.83246462e-02f, -9.92834494e-02f, 5.48626296e-02f, -8.48272294e-02f,
  7.41066784e-02f, 5.78258708e-02f, -3.11684366e-02f, -2.52099410e-02f, -9.44533944e-03f, -7.12073222e-02f, 4.99347113e-02f, 6.03912026e-03f, 9.03233886e-03f, 1.78115983e-02f,
  -1.64156239e-02f, 3.78035381e-02f, 2.76949927e-02f, -3.22388373e-02f, -2.96036098e-02f, 1.82599723e-02f, 4.77242433e-02f, -4.23285253e-02f, 5.65645173e-02f, -1.09901279e-02f,
  7.02909157e-02f, 9.90292616e-03f, 4.14992869e-02f, -6.54616728e-02f, 1.24946088e-02f, 4.91251275e-02f, -8.40881653e-03f, -3.02573945e-02f, 1.53256701e-02f, -2.76873223e-02f,
  -1.19098589e-01f, 3.53301391e-02f, -4.05078530e-02f, -1.96777880e-02f, 6.42073229e-02f, 4.73161563e-02f, 2.18988210e-02f, 1.79214720e-02f, 5.04473075e-02f, -1.11009106e-02f,
  -6.17403872e-02f, -9.81398597e-02f, -5.73134199e-02f, 3.29018524e-03f, 1.09562077e-01f, -1.78769045e-02f, 8.40787813e-02f, 8.28884244e-02f, -8.50753486e-02f, -7.71049410e-02f,
  -3.82245667e-02f, 2.45368313e-02f, 4.49903533e-02f, -2.17746329e-02f, -4.68405113e-02f, -8.02048445e-02f, 1.19094048e-02f, 5.58821931e-02f, -9.73246247e-02f, 4.02078405e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.64174056e-01f, -1.76715806e-01f, 1.73817888e-01f, -4.44762468e-01f, 2.97919344e-02f, 4.98818159e-02f, 1.98972300e-01f, -4.06461388e-01f, -4.98025626e-01f, -3.57165188e-01f,
  5.90593219e-02f, 6.64169267e-02f, 2.15282798e-01f, -3.64201099e-01f, 5.15979826e-01f, 1.98635623e-01f, -1.77971140e-01f, -4.10737470e-02f, 1.98077243e-02f, -1.56408966e-01f,
  3.11020855e-02f, -2.79008925e-01f, 3.16087633e-01f, -2.38227487e-01f, -5.16086118e-03f, -2.70537525e-01f, -3.98218930e-02f, 2.62222260e-01f, -1.54433265e-01f, 7.82533810e-02f,
  1.02598183e-01f, -1.02454141e-01f, -1.02298837e-02f, 3.99652906e-02f, -1.98157448e-02f, 5.12956828e-02f, 3.76301296e-02f, 2.54666746e-01f, 4.02890630e-02f, 1.81019362e-02f,
  8.04296583e-02f, 1.16146728e-02f, -3.57375033e-02f, 6.83755279e-02f, -4.02071066e-02f, -5.98817468e-02f, -2.32495088e-02f, 1.76190038e-03f, -2.97433231e-02f, 1.53030053e-01f,
  3.26602831e-02f, 1.30296350e-02f, -7.73967132e-02f, -8.04376379e-02f, -5.18471887e-03f, -1.17781959e-01f, 4.08482477e-02f, 1.86647639e-01f, -6.47782385e-02f, -1.38295025e-01f,
  6.51229694e-02f, -2.37732101e-02f, 7.61078075e-02f, -2.49996912e-02f, -5.76197468e-02f, -6.59533963e-02f, 6.33287430e-03f, -4.88807410e-02f, 6.73977211e-02f, -8.73672292e-02f,
  -8.69415253e-02f, -4.77282666e-02f, -8.66311565e-02f, -2.07582042e-02f, 1.51418746e-02f, -6.04562648e-02f, 1.12694472e-01f, -2.24476345e-02f, -4.92478311e-02f, -4.26246524e-02f,
  -8.32612291e-02f, 3.66663211e-03f, -2.87873275e-03f, 2.21607331e-02f, -1.12119898e-01f, 6.84444383e-02f, -1.75179690e-02f, 4.62689623e-03f, 3.64395715e-02f, 6.25140965e-02f,
  -1.70204386e-01f, -3.10382545e-01f, -9.68059599e-02f, -3.76179256e-02f, -8.78362283e-02f, 6.76543042e-02f, 1.20531516e-02f, -1.21486217e-01f, -7.43010491e-02f, -1.83301903e-02f,
  -1.01142362e-01f, 6.91204099e-04f, -3.39522436e-02f, -6.08389005e-02f, -2.90999338e-02f, -4.11364995e-02f, 3.42099816e-02f, -7.63478950e-02f, -3.63935530e-02f, -5.72847575e-02f,
  3.83956614e-03f, 8.51851553e-02f, 9.22964048e-03f, -3.53793614e-02f, -1.07818849e-01f, 1.07863821e-01f, -5.54672107e-02f, -9.93789211e-02f, 8.18365067e-02f, 8.84611532e-02f,
  6.45914376e-01f, 1.40159220e-01f, -1.03461832e-01f, 5.07947803e-01f, 3.46111000e-01f, -2.28858031e-02f, -2.65980750e-01f, 2.88443416e-01f, 3.23080271e-02f, -2.38553077e-01f,
  3.78260165e-01f, -1.42838553e-01f, -3.11999451e-02f, 3.89639705e-01f, 5.51475763e-01f, -1.66237324e-01f, 3.14843148e-01f, 6.83619268e-03f, -4.39367816e-03f, 1.91589236e-01f,
  2.71766603e-01f, 4.33680505e-01f, 1.88340247e-01f, 2.63253093e-01f, 1.58296496e-01f, 1.18302926e-01f, 2.68168151e-01f, -1.34441152e-01f, 2.12318614e-01f, 5.25273122e-02f,
  -8.35973471e-02f, 1.29332393e-01f, 3.49905230e-02f, -1.38450682e-01f, 5.51967602e-03f, 7.99597520e-03f, -1.88759565e-01f, -8.92131403e-02f, -3.29953693e-02f, -4.84955497e-02f,
  -7.27396905e-02f, 3.50853130e-02f, -9.18447040e-04f, 2.27258801e-02f, 4.21849973e-02f, 6.59745559e-02f, -6.11245818e-03f, -4.39947359e-02f, -8.02512001e-03f, 7.91853964e-02f,
  -5.38371429e-02f, -2.35699359e-02f, 3.90173160e-02f, -1.05520621e-01f, -1.28035592e-02f, 2.67050415e-02f, -1.38591379e-01f, -4.66122814e-02f, -2.69428026e-02f, -6.53238967e-02f,
  4.59651165e-02f, -9.59042683e-02f, -7.17524160e-03f, -2.28480883e-02f, 4.13464792e-02f, -6.66843611e-04f, 7.36676306e-02f, -3.87479104e-02f, -7.18163252e-02f, 4.01793011e-02f,
  6.84767636e-03f, 1.02789104e-01f, -3.91947962e-02f, -2.19414383e-02f, 3.66569124e-02f, 1.21016661e-02f, -8.78813565e-02f, 2.62270179e-02f, -8.90077427e-02f, -2.04086266e-02f,
  -6.52268901e-03f, 6.23296946e-02f, -3.63529436e-02f, -6.06431104e-02f, -1.10495063e-02f, 3.96571867e-02f, 8.40238184e-02f, -1.71651021e-02f, -1.02768682e-01f, 7.46022314e-02f,
  1.54685741e-02f, 2.76615560e-01f, -9.87828895e-02f, 3.48921865e-02f, -1.75489280e-02f, 6.08863980e-02f, 7.78683182e-03f, 4.01464328e-02f, -9.64173861e-03f, 1.31378308e-01f,
  -4.89523970e-02f, 4.24436154e-03f, -6.86883926e-02f, 1.67381279e-02f, -2.13590562e-02f, 9.98115540e-02f, -7.53982812e-02f, -4.89891171e-02f, -9.46096890e-03f, 6.06031995e-03f,
  -2.27698795e-02f, -3.63183357e-02f, -9.00088698e-02f, 6.34566769e-02f, 2.60705538e-02f, -4.72506508e-02f, 6.52890205e-02f, -6.71114922e-02f, 1.62960850e-02f, -1.28990030e-02f,
  4.08690274e-01f, -8.57356310e-01f, 1.07018523e-01f, 6.16995156e-01f, 2.38926694e-01f, -4.05972511e-01f, 2.32629523e-01f, -2.69142687e-01f, 4.22857851e-01f, -5.21680892e-01f,
  5.14411069e-02f, -4.44442153e-01f, -2.66524017e-01f, -1.34724632e-01f, 3.05423915e-01f, -2.45022357e-01f, 7.90250599e-02f, 3.92306549e-03f, -9.43226926e-03f, -9.40813273e-02f,
  1.62723154e-01f, -1.97782144e-01f, -3.04424390e-03f, -3.41191709e-01f, 1.24267280e-01f, 2.38049198e-02f, 2.70788848e-01f, -7.55237192e-02f, 1.33944094e-01f, -1.82722993e-02f,
  -2.00012803e-01f, 1.30337477e-01f, -8.11194815e-03f, -1.08115666e-01f, -9.12836194e-02f, -9.52436328e-02f, -1.13050692e-01f, -3.94471474e-02f, 1.14054330e-01f, 1.83354672e-02f,
  -5.12951910e-02f, -4.25660387e-02f, 1.03366122e-01f, -3.34463827e-02f, -5.65544656e-03f, 2.08941158e-02f, 1.82387933e-01f, 8.52956846e-02f, 1.28883515e-02f, -2.94917151e-02f,
  -3.10917199e-02f, -7.20364302e-02f, 4.25891541e-02f, -7.08537325e-02f, 3.68772820e-02f, 5.43628223e-02f, 4.04345393e-02f, -9.55418646e-02f, -4.64556515e-02f, 3.00385095e-02f,
  -4.76190960e-03f, -1.26599923e-01f, -3.12956832e-02f, 2.02853847e-02f, -1.08277332e-02f, 1.90592676e-01f, -1.04159527e-02f, -2.33766623e-02f, -1.03509620e-01f, 9.21389088e-03f,
  1.77992042e-02f, 4.03043851e-02f, 3.58047523e-02f, 2.01095976e-02f, 2.14758776e-02f, -2.43367609e-02f, 1.18206535e-02f, -1.17056426e-02f, -2.51832162e-03f, 1.07388616e-01f,
  -8.69983993e-03f, 3.28611694e-02f, -1.51359603e-01f, 8.71995315e-02f, 4.04873304e-02f, 3.25410478e-02f, -4.20760683e-04f, -5.68971708e-02f, 3.54294330e-02f, 6.03569485e-02f,
  -9.03343141e-01f, -5.64290702e-01f, -8.17597434e-02f, -8.91250297e-02f, 8.20109695e-02f, -1.87259112e-02f, 9.59902182e-02f, -1.15079403e-01f, -1.74184367e-01f, -1.95408594e-02f,
  -9.54690948e-02f, 9.66766849e-03f, -1.50893852e-01f, 9.82628316e-02f, -3.41451764e-02f, -1.04168030e-02f, -1.42097250e-01f, -1.80455834e-01f, -7.09114596e-02f, -2.91319415e-02f,
  2.05748174e-02f, -1.58916377e-02f, -3.14379372e-02f, 5.93227334e-03f, 2.64228452e-02f, 1.00664953e-02f, -3.32047939e-02f, 1.77866556e-02f, 4.81838137e-02f, -8.84454548e-02f,
  9.53119457e-01f, 6.26245081e-01f, 7.42777646e-01f, 4.81378645e-01f, -2.66002238e-01f, -5.09830177e-01f, -1.35493577e-01f, 1.74375311e-01f, -1.60515487e-01f, 5.03373370e-02f,
  -1.57433808e-01f, 2.24767938e-01f, -1.72748603e-02f, 2.74794906e-01f, -4.24202859e-01f, -2.00543731e-01f, 3.12061638e-01f, 2.30551586e-02f, -4.98989038e-03f, 3.00126106e-01f,
  5.60078993e-02f, -2.37974107e-01f, 3.15540612e-01f, -2.20420390e-01f, 2.88577288e-01f, 3.71121049e-01f, 1.21614849e-02f, 1.02586977e-01f, 3.38677615e-01f, -2.33726203e-01f,
  -8.40395764e-02f, 9.03378129e-02f, 2.32032403e-01f, 8.87560248e-02f, -3.78708020e-02f, 1.47193298e-02f, 1.01167277e-01f, -3.05857006e-02f, -1.11473925e-01f, 1.06952921e-01f,
  7.60499667e-03f, 2.88343318e-02f, -3.85222211e-02f, -9.20495689e-02f, 5.62085100e-02f, 9.90671664e-02f, 1.69487782e-02f, 8.15963522e-02f, -3.32764313e-02f, 2.15073273e-01f,
  5.59499604e-04f, 1.44343838e-01f, 6.03556186e-02f, 8.43112767e-02f, 6.47006035e-02f, -4.37007053e-03f, -2.57625040e-02f, 1.18551580e-02f, -9.15504817e-04f, -1.17894541e-02f,
  5.75595982e-02f, -2.73967301e-03f, -5.03704399e-02f, 1.69310302e-01f, -4.52813767e-02f, 7.37621123e-03f, -5.57104126e-03f, -1.40606733e-02f, -6.83856457e-02f, -5.68349063e-02f,
  -6.37814635e-03f, 2.01660767e-02f, -2.80286465e-02f, -2.25332435e-02f, 3.30319032e-02f, 3.02373972e-02f, -1.48293851e-02f, 1.95699632e-02f, 3.28245312e-02f, 2.16010362e-02f,
  -2.78240498e-02f, -6.41694525e-03f, -3.16087566e-02f, 1.10631650e-02f, -4.80782539e-02f, 1.72256436e-02f, 4.55068499e-02f, 1.25238433e-01f, 1.07995588e-02f, -2.96243876e-02f,
  -1.84605569e-01f, 5.80944382e-02f, -3.52586396e-02f, -4.40049917e-02f, -4.18286957e-02f, 1.88809764e-02f, -8.47747102e-02f, -6.47637323e-02f, 1.40452273e-02f, -1.24334857e-01f,
  9.41445827e-02f, -1.96666662e-02f, -3.60349528e-02f, 4.59583774e-02f, -4.41871472e-02f, -7.37583116e-02f, 1.07267469e-01f, -7.82062933e-02f, 1.43446606e-02f, -4.12671193e-02f,
  1.02194445e-02f, -1.12767369e-01f, -7.19714239e-02f, -1.00326419e-01f, -4.83473130e-02f, -6.78717298e-03f, -1.36812463e-01f, 8.36238265e-02f, 1.13725970e-02f, -3.49036977e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  2.12944411e-02f, 1.55704468e-01f, 3.20925206e-01f, -2.59011388e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.59645790e-01f, 1.12999164e-01f, -1.25298247e-01f, -6.68349087e-01f, 2.51346320e-01f, 4.84870136e-01f, -2.03136727e-01f, -3.00146252e-01f, 2.90373206e-01f, 5.21275878e-01f,
  -1.95388913e-01f, -3.07846040e-01f, -4.33649391e-01f, -4.24277633e-01f, -1.98577821e-01f, 1.29584894e-01f, 1.78095639e-01f, -2.13103518e-01f, 3.49832207e-01f, 4.93540734e-01f,
  -4.92474250e-02f, 2.73749560e-01f, 5.75805962e-01f, 8.37581933e-01f, 4.07746851e-01f, -3.68219852e-01f, 1.56458467e-01f, 3.04017335e-01f, 3.49925786e-01f, -3.77146274e-01f,
  7.23247081e-02f, -4.60591704e-01f, -1.60175666e-01f, -2.70732939e-01f, -6.07964247e-02f, 7.93410659e-01f, -1.01458363e-01f, 5.05041718e-01f, 3.59477878e-01f, 5.12044191e-01f,
  3.13430548e-01f, -9.09207404e-01f, 4.46522206e-01f, 2.98683614e-01f, -1.82336271e-01f, -2.00327337e-01f, 2.37182349e-01f, 7.33021349e-02f, 1.48876429e-01f, 1.76764593e-01f,
  4.61251020e-01f, 2.13626072e-01f, 3.45749289e-01f, -1.83109432e-01f, 8.06986809e-01f, 6.83658123e-02f, -4.75236952e-01f, 2.35022038e-01f, 2.16828421e-01f, -7.35537112e-02f,
  5.19854009e-01f, -2.87630230e-01f, 1.03314668e-01f, 3.73294473e-01f, -1.60712019e-01f, 5.39304614e-02f, -2.77490020e-01f, 6.26999497e-01f, 6.66809142e-01f, 1.93210889e-03f,
  5.43202698e-01f, -7.66849995e-01f, 1.59542173e-01f, -7.72729814e-01f, -1.40368626e-01f, 2.62840211e-01f, 2.74851650e-01f, -5.13811111e-01f, 1.71807200e-01f, -5.48985481e-01f,
  4.59484011e-01f, -6.64778054e-02f, 5.11795282e-01f, -4.97405767e-01f, 7.87710175e-02f, -7.93023258e-02f, 7.42826223e-01f, 2.60808796e-01f, 2.25687280e-01f, 6.50107086e-01f,
  -1.57041818e-01f, 3.68798018e-01f, 4.95394975e-01f, -2.26491883e-01f, -2.42130712e-01f, 2.16194451e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -9.93058272e-03f, 2.26426408e-01f, 9.50704098e-01f, 2.95328408e-01f, 3.62548381e-01f, 6.80902481e-01f, -8.99101973e-01f, -2.63299290e-02f, 1.66939706e-01f, 4.03749138e-01f,
  6.28792226e-01f, -1.18647194e+00f, 2.15219513e-01f, 7.24469781e-01f, -1.57608628e+00f, 1.92656982e+00f, 1.08332396e+00f, 4.69237775e-01f, 1.32837868e+00f, -2.86544748e-02f,
  -5.89463472e-01f, 1.03494740e+00f, 1.14719048e-01f, 8.42866719e-01f, 1.27647877e+00f, -6.43098831e-01f, 8.27073492e-03f, 3.93822998e-01f, -5.22169173e-01f, 1.77153170e-01f,
  -1.45758140e+00f, -1.05303156e+00f, 2.42113039e-01f, 3.69975477e-01f, 8.19301903e-01f, 1.57557392e+00f, 4.03113961e-01f, 1.18124855e+00f, -1.21214919e-01f, -9.19096589e-01f,
  1.07641292e+00f, -1.24648070e+00f, -1.35546327e+00f, -6.97488010e-01f, 8.02868783e-01f, -4.39822018e-01f, -7.40323722e-01f, -3.45158368e-01f, -2.43862554e-01f, 3.36022317e-01f,
  3.41264993e-01f, 5.52265346e-01f, 7.82927394e-01f, 1.08482003e+00f, -1.38821089e+00f, 4.40456808e-01f, 5.69708765e-01f, 6.14212215e-01f, 2.02123952e+00f, -1.41763902e+00f,
  2.46016942e-02f, -1.44317722e+00f, -2.52809525e-01f, -4.09326732e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  3.82137984e-01f, 8.99739802e-01f, 4.61808026e-01f, 1.23406184e+00f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  2.10862398e-01f, 4.87167895e-01f, -1.88208506e-01f, 1.80795435e-02f, -4.69848454e-01f, -1.30389345e+00f, 1.81182325e+00f, -1.08190143e+00f, 1.07868707e+00f, -1.82917416e+00f,
  1.32982922e+00f, -1.56082368e+00f, -6.46121502e-01f, -3.56460303e-01f, 2.66796082e-01f, 8.88711810e-01f, 1.17173694e-01f, 1.33535564e-01f, 1.66296989e-01f, -9.13537264e-01f,
  8.14145625e-01f, -3.83274913e-01f, 3.44648421e-01f, -7.31478095e-01f, -1.76268172e+00f, -1.11911869e+00f, -4.20243382e-01f, -1.16621554e+00f, 6.22979105e-01f, 4.60572332e-01f,
  6.87395871e-01f, -1.92173290e+00f, -1.38109076e+00f, 8.19303632e-01f, 1.49769723e+00f, 1.48362458e+00f, 1.16332495e+00f, -1.48553061e+00f, -1.38618767e+00f, -2.20758486e+00f,
  3.67308646e-01f, -1.71441507e+00f, -1.57417715e+00f, -5.81032455e-01f, -1.18491435e+00f, -1.21441650e+00f, -2.27152124e-01f, -8.24274838e-01f, 4.60613996e-01f, 6.98627830e-01f,
  1.12860882e+00f, 6.91108048e-01f, -1.54480028e+00f, -6.14374816e-01f, 1.22475457e+00f, 8.65246177e-01f, -5.21047294e-01f, -2.68115997e-01f, -1.21775651e+00f, 1.24847007e+00f,
  -1.29279971e-01f, 1.42353296e+00f, -2.18887043e+00f, 4.65679437e-01f, 8.59880522e-02f, -1.51604390e+00f, -2.45538726e-01f, -4.57810849e-01f, 8.33162248e-01f, 1.57326013e-01f,
  -1.05166864e+00f, 8.51146817e-01f, 9.13366616e-01f, 8.35177958e-01f, 3.71690929e-01f, 5.96041501e-01f, -2.18712151e-01f, 5.75417399e-01f, -2.42941543e-01f, 9.58913863e-01f,
  9.63116825e-01f, 4.12397712e-01f, 1.85497150e-01f, 1.44970667e+00f, -4.55371410e-01f, 9.94175315e-01f, 9.42892075e-01f, 8.92255425e-01f, 6.03559196e-01f, -3.86269480e-01f,
  7.73313165e-01f, 1.02762377e+00f, -1.19064426e+00f, 1.25319958e+00f, 5.28136015e-01f, -1.88541615e+00f, -1.45631456e+00f, 2.28551134e-01f, -2.00009537e+00f, 1.07422709e+00f,
  1.33490646e+00f, 1.58914852e+00f, -1.34647310e+00f, 1.81765878e+00f, 1.40513384e+00f, 1.35310757e+00f, 1.51983094e+00f, -1.78785038e+00f, -7.80383885e-01f, -4.49851573e-01f,
  -7.34523237e-01f, -1.30533361e+00f, 1.03378427e+00f, 1.47285771e+00f, 6.69824958e-01f, -1.50026572e+00f, -2.84725875e-01f, -1.36304009e+00f, -1.62765789e+00f, 8.95056665e-01f,
  -2.24914980e+00f, 1.03854847e+00f, 1.76415527e+00f, 1.48101258e+00f, -5.58061659e-01f, -1.00393569e+00f, -6.40676618e-01f, -2.57761210e-01f, -1.02608049e+00f, -1.16860950e+00f,
  6.33769333e-01f, 1.16910672e+00f, -7.90108323e-01f, 6.49330199e-01f, -6.74214482e-01f, -5.46184003e-01f, 1.36220336e-01f, 4.99792874e-01f, -2.35332340e-01f, -8.80449712e-01f,
  1.14421678e+00f, -2.79695004e-01f, -1.60234535e+00f, -1.31401193e+00f, -1.06622851e+00f, -1.26802266e+00f, 4.10000384e-01f, -1.07224810e+00f, -1.20037699e+00f, 2.67979860e-01f,
  -8.53236914e-02f, 5.62918603e-01f, 1.17527413e+00f, 4.18300748e-01f, -1.10167526e-01f, 1.13377011e+00f, -7.18882799e-01f, -1.97652817e+00f, 1.22476208e+00f, -1.06269205e+00f,
  4.40615207e-01f, -7.17512429e-01f, -1.25997710e+00f, 2.69872487e-01f, 7.27535665e-01f, 5.53527355e-01f, 1.61432123e+00f, -1.87064970e+00f, -1.86942220e+00f, 9.06914234e-01f,
  -6.66481495e-01f, -5.23262084e-01f, 1.51463360e-01f, -8.79483223e-01f, -7.28580415e-01f, 9.61493492e-01f, 1.63782024e+00f, 7.63977170e-01f, -1.42424548e+00f, -1.67617536e+00f,
  3.43950480e-01f, 1.88394070e-01f, 8.41441631e-01f, -1.73580468e-01f, 1.50349379e+00f, -5.67191048e-03f, -1.17292774e+00f, 1.47555459e+00f, 9.38225567e-01f, -1.29092085e+00f,
  -5.51017940e-01f, -3.24566633e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -7.33356178e-01f, -6.25062764e-01f, 1.18737864e+00f, -2.22069263e-01f, -8.97982657e-01f, -4.06270146e-01f, 1.04320717e+00f, 1.35755074e+00f, -4.24962491e-01f, -1.88123807e-01f,
  -2.08465412e-01f, -2.69366354e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    