/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.50696000e-02f, -4.34016110e-03f, -1.22225285e-02f, 2.55058259e-01f, 8.23815838e-02f, -2.28207439e-01f, -1.34565026e-01f, 1.28986225e-01f, 3.82513665e-02f, -6.30115196e-02f,
  1.55174658e-01f, -1.58195734e-01f, 4.55434360e-02f, 5.67973405e-02f, -2.11249605e-01f, -6.48678988e-02f, -1.12385824e-02f, 2.77194493e-02f, -5.37434071e-02f, 1.12453863e-01f,
  2.06743833e-02f, 6.88881427e-02f, 9.80593264e-03f, 1.22908978e-02f, 8.25006107e-04f, 4.75296527e-02f, 1.64896846e-01f, -1.65290553e-02f, 7.75937736e-02f, -9.78622213e-02f,
  -6.62813485e-02f, 2.55032349e-02f, 6.56414479e-02f, 2.03888007e-02f, 1.91656277e-02f, -2.01070812e-02f, -1.87619347e-02f, -4.75189723e-02f, 4.08164896e-02f, 3.32752988e-03f,
  -5.49864210e-02f, -4.90428135e-02f, -3.78623381e-02f, 1.72580015e-02f, 7.90136456e-02f, -8.08728859e-04f, -1.53392712e-02f, -3.37859131e-02f, 6.22025616e-02f, -6.72388896e-02f,
  -3.72191221e-02f, 1.98805169e-03f, -2.65959334e-02f, -6.96177594e-03f, -4.02958170e-02f, -6.14707991e-02f, -4.74170744e-02f, -1.42880514e-01f, -2.69418675e-02f, -3.65836658e-02f,
  -4.91426438e-02f, -2.52677426e-02f, 6.72636852e-02f, 1.23259900e-02f, -4.15144302e-03f, 8.25446025e-02f, 1.47861452e-03f, 1.09130824e-02f, 3.74181978e-02f, -2.63709389e-02f,
  8.60198736e-02f, 2.59292126e-03f, -2.61446014e-02f, 1.06706306e-01f, -7.18452483e-02f, 2.27638837e-02f, 3.27003971e-02f, -1.16651878e-02f, 7.08990544e-02f, 4.10294496e-02f,
  1.15799578e-02f, 3.75686996e-02f, 1.27848973e-02f, -2.04082504e-02f, -2.21542418e-02f, 8.15709978e-02f, -3.71006108e-03f, 3.26746283e-03f, -3.16930376e-02f, 6.37917817e-02f,
  -6.40129969e-02f, -3.89315337e-02f, -2.54728310e-02f, -1.73158832e-02f, -9.17769372e-02f, 1.82887763e-02f, -1.66277401e-02f, -3.68594527e-02f, 4.53499071e-02f, 4.18339437e-03f,
  -7.15231225e-02f, 7.52383173e-02f, -2.43768692e-02f, 4.16395627e-02f, 2.38944534e-02f, -2.30170344e-03f, 3.10221817e-02f, 2.09154319e-02f, -6.56932965e-02f, 1.79032031e-02f,
  -6.56367885e-03f, -2.33354084e-02f, -5.45778759e-02f, -1.56794209e-02f, 4.47104573e-02f, -1.80372931e-02f, -5.00688739e-02f, 4.32555489e-02f, -6.43719137e-02f, 4.95443493e-02f,
  -8.39302167e-02f, 2.40643501e-01f, -1.36330258e-02f, 4.98617254e-02f, 1.35933040e-02f, -2.55039155e-01f, -1.80817217e-01f, 7.12846816e-02f, 5.77146597e-02f, 1.90740675e-02f,
  -1.34220049e-01f, 5.78098521e-02f, 1.59727887e-03f, -2.41836518e-01f, -2.53496081e-01f, -1.11977987e-01f, -2.64168113e-01f, -1.29790297e-02f, -2.03555040e-02f, 1.54702470e-01f,
  2.59999279e-02f, -6.33968785e-02f, -2.48964727e-01f, 8.72680545e-02f, 2.67578978e-02f, 1.25491217e-01f, 7.50355199e-02f, 5.33111840e-02f, -5.94719313e-02f, -6.51558340e-02f,
  -3.73482071e-02f, 6.39781682e-03f, 3.12575162e-03f, 3.33397724e-02f, -3.21807601e-02f, 5.61932065e-02f, 4.79584187e-02f, -5.52310199e-02f, -6.66384306e-03f, -5.18438891e-02f,
  4.33828123e-02f, -9.75194201e-03f, 1.93817019e-02f, 3.37176882e-02f, 6.71812566e-03f, 5.66640543e-03f, -2.65910942e-02f, -1.14055187e-01f, -2.02983152e-02f, -9.99237597e-02f,
  -8.12911764e-02f, -7.15703964e-02f, -1.60653703e-02f, -9.44278613e-02f, -4.30341549e-02f, -4.57645133e-02f, -4.58827466e-02f, -3.69676910e-02f, -1.01927528e-03f, -3.56203355e-02f,
  -5.24577079e-03f, 7.32560679e-02f, 6.27740994e-02f, 3.07657924e-02f, -1.37586342e-02f, -5.12985066e-02f, 1.45719908e-02f, -6.72843531e-02f, 2.90451273e-02f, -9.99188982e-03f,
  -1.98270045e-02f, -4.36170101e-02f, -7.16065709e-03f, 1.08628133e-02f, -4.16841879e-02f, -2.14796625e-02f, 1.79273989e-02f, 3.13974544e-02f, -1.65326856e-02f, -6.27017468e-02f,
  -2.01936811e-02f, -1.28552811e-02f, -8.57003685e-03f, 2.46769935e-02f, 3.34266922e-03f, -2.27121338e-02f, -2.37020440e-02f, -5.94125725e-02f, 1.30686322e-02f, 1.39013184e-02f,
  1.27871603e-01f, 2.72361428e-01f, -4.40485179e-02f, -3.93040385e-03f, -1.66702718e-02f, 3.80583364e-03f, 1.66845266e-02f, 3.74150798e-02f, 8.53180960e-02f, 3.55573483e-02f,
  6.46410957e-02f, -4.14804649e-03f, 7.62133598e-02f, 2.88850199e-02f, -4.11458760e-02f, 5.84001467e-03f, 2.37449259e-02f, 4.03995551e-02f, -4.20172587e-02f, -1.58604868e-02f,
  5.17948791e-02f, 3.64322923e-02f, -6.41492084e-02f, 1.38898743e-02f, -3.09612174e-02f, 7.00991461e-03f, 5.44053726e-02f, 3.22016515e-02f, -5.60097061e-02f, -2.08157972e-02f,
  -3.48958701e-01f, -1.51568890e-01f, 1.62137058e-02f, -2.00727031e-01f, 1.59709081e-01f, -9.78290364e-02f, -6.27013668e-02f, 8.77501676e-04f, -1.98414296e-01f, -7.75668696e-02f,
  -1.18258193e-01f, 8.91926065e-02f, -1.19086675e-01f, 7.32979700e-02f, -2.73555517e-01f, -2.08442777e-01f, -1.65186916e-02f, 8.79823416e-03f, -1.19881490e-02f, 9.40922240e-04f,
  -1.40224854e-02f, 1.58443898e-01f, 1.54743074e-02f, 1.06215075e-01f, 1.64566204e-01f, 9.72604658e-03f, 3.30537781e-02f, 4.81576510e-02f, 9.27414224e-02f, 1.50963172e-01f,
  -1.74680963e-01f, -5.76967821e-02f, 7.33496919e-02f, 6.42538145e-02f, -1.07418373e-01f, 1.42620103e-02f, -1.02170184e-02f, 3.29122916e-02f, 1.17172133e-02f, 4.55229823e-03f,
  2.28990819e-02f, -8.36725533e-03f, 5.36402836e-02f, -6.79839309e-03f, -2.48391386e-02f, 1.06812827e-02f, 8.05886369e-03f, -5.24910465e-02f, 4.08503376e-02f, 5.22802211e-02f,
  2.10584626e-02f, 3.74580547e-02f, 1.10551395e-01f, 1.63731482e-02f, 6.07505515e-02f, -5.28481090e-03f, 5.29639348e-02f, 1.80088915e-02f, 1.32226814e-02f, -3.30442749e-02f,
  3.33351037e-03f, 5.93700521e-02f, 5.85508794e-02f, 1.36084342e-02f, 2.39970852e-02f, 2.64609903e-02f, 5.24888858e-02f, 2.56926063e-02f, 2.73154899e-02f, -8.27345811e-03f,
  -9.25960913e-02f, 4.92505506e-02f, 2.28314754e-03f, -8.35985318e-03f, 4.84366864e-02f, 1.12749273e-02f, 4.87979837e-02f, 8.92012790e-02f, -5.18632084e-02f, 7.25491345e-03f,
  1.38229430e-02f, 1.59938186e-02f, 4.28319685e-02f, -2.05188710e-03f, -7.37214610e-02f, -1.25964936e-02f, 7.38844126e-02f, 3.16555277e-02f, -6.94949459e-03f, -2.86867358e-02f,
  -4.78024408e-02f, 2.09047720e-02f, 3.10853645e-02f, -2.59206388e-02f, -4.26763669e-02f, -1.78725719e-02f, -2.98960172e-02f, 3.28035876e-02f, -6.74087182e-02f, 2.36951653e-02f,
  -1.22438269e-02f, 3.28571871e-02f, -5.33326492e-02f, -2.54407013e-03f, 2.79003829e-02f, -1.73935276e-02f, -6.17600456e-02f, -2.57268418e-02f, 3.03851869e-02f, 1.70331802e-02f,
  5.82684577e-02f, -2.55971476e-02f, 1.56023419e-02f, 3.55376489e-02f, 6.23247363e-02f, 3.15775201e-02f, 1.27254538e-02f, -4.03804518e-02f, 1.89944413e-02f, -1.26037095e-02f,
  -3.42941016e-01f, -7.30950907e-02f, -1.27167016e-01f, -7.57151917e-02f, -8.25436935e-02f, -1.62749052e-01f, -2.32987508e-01f, -6.88964650e-02f, -2.75695294e-01f, 3.77581939e-02f,
  -2.46604737e-02f, -4.06389544e-03f, -7.26576969e-02f, 8.94718990e-02f, 1.80725753e-01f, -3.85449976e-02f, 1.48496106e-01f, -7.90361017e-02f, 1.75403878e-02f, 3.66980918e-02f,
  5.31957634e-02f, 2.64888793e-01f, 2.07813516e-01f, 7.96822309e-02f, -1.48250628e-02f, -9.55291316e-02f, 3.47283155e-01f, 9.14850924e-03f, 1.12844571e-01f, 1.05432682e-01f,
  -5.38892336e-02f, -2.80924607e-02f, -4.70837541e-02f, -2.77966447e-02f, 2.22236216e-02f, -6.24397360e-02f, -1.84613708e-02f, 1.45760952e-02f, -4.97415215e-02f, -2.88263485e-02f,
  -1.16562247e-02f, 8.07576999e-02f, 1.43766990e-02f, 1.08611993e-02f, -7.20812380e-02f, -2.68035661e-02f, -4.24403884e-02f, -6.21898100e-02f, 8.89465399e-03f, 3.41314524e-02f,
  -1.63658112e-02f, -2.26197951e-02f, -2.65614204e-02f, 2.24135239e-02f, 2.74912938e-02f, -2.43901145e-02f, -5.72352931e-02f, 4.44715209e-02f, 6.02262188e-03f, -2.73789652e-02f,
  -2.14171745e-02f, -4.45653237e-02f, -4.10273531e-03f, -4.40719584e-03f, -3.13506089e-02f, 3.44815291e-02f, 3.16924453e-02f, 6.26364350e-02f, -5.31749576e-02f, -3.04996758e-03f,
  1.12803569e-02f, -8.73716176e-02f, -3.87848541e-02f, -7.57469833e-02f, 2.23311801e-02f, -1.42811434e-02f, 1.72143560e-02f, 4.89051752e-02f, -4.23917584e-02f, -1.08502656e-02f,
  1.84843186e-02f, 1.90060381e-02f, -1.77663879e-03f, -4.78171892e-02f, -8.37727450e-03f, -4.77728844e-02f, -8.58611520e-03f, -1.29273608e-02f, 4.17176336e-02f, 2.53873318e-02f,
  6.66294768e-02f, 1.55134052e-01f, -2.86832433e-02f, -4.48828703e-03f, 8.30427743e-03f, 4.26870249e-02f, 2.44001411e-02f, 5.65430382e-03f, 3.77700813e-02f, 3.09289452e-02f,
  5.55591658e-02f, -4.41328771e-02f, 5.23006497e-03f, 3.66455801e-02f, -1.98075268e-02f, -1.61751863e-02f, 2.95027811e-02f, 1.51601143e-03f, 5.34512214e-02f, 1.48720238e-02f,
  1.00979470e-02f, -4.08292338e-02f, 3.35620493e-02f, -4.57350053e-02f, -2.11979896e-02f, -1.71745883e-03f, -1.11909844e-02f, -5.25789186e-02f, 4.08739112e-02f, 8.22053477e-03f,
  2.76792556e-01f, 5.31115895e-03f, -1.26223922e-01f, 1.84412956e-01f, 5.87774590e-02f, -4.60883155e-02f, -1.13734618e-01f, 1.18190750e-01f, 8.65720140e-05f, 2.74546780e-02f,
  1.63312048e-01f, -1.96500584e-01f, -9.54686701e-02f, 7.35720247e-02f, -4.41333689e-02f, -6.93828613e-02f, 5.00200987e-02f, -7.70954117e-02f, -5.15526310e-02f, 8.20377469e-02f,
  8.64863768e-02f, 1.51230618e-01f, -5.71492389e-02f, 1.10797673e-01f, 1.48872463e-02f, 6.66880142e-03f, 1.06034935e-01f, -5.30024767e-02f, 1.14842340e-01f, -5.08799069e-02f,
  3.60086560e-02f, 8.95266607e-02f, -8.26687515e-02f, -7.84732681e-03f, 1.21527500e-02f, -1.94452945e-02f, -2.60686297e-02f, -1.13344662e-01f, -7.60833099e-02f, -5.09523302e-02f,
  -4.38364372e-02f, 2.77187070e-03f, 7.28680789e-02f, -8.06900114e-02f, -4.58546504e-02f, -8.61578733e-02f, -6.46288693e-02f, -5.29688038e-02f, -1.15940943e-02f, -3.57719176e-02f,
  -3.93016264e-02f, -3.96900903e-03f, -9.81135014e-03f, -3.58423069e-02f, -7.25427410e-03f, -2.52855178e-02f, -6.57765195e-02f, -4.96190265e-02f, 1.98951084e-02f, 2.74817515e-02f,
  1.09608173e-02f, -9.05994046e-03f, 1.57148752e-03f, 5.69508970e-02f, 4.34858389e-02f, 6.39149770e-02f, 6.88130362e-03f, 1.73916202e-02f, -4.18678783e-02f, 4.95674908e-02f,
  7.62816817e-02f, 7.84831047e-02f, 5.21189068e-04f, -2.28473488e-02f, 6.85571358e-02f, 3.68977562e-02f, -3.12900171e-02f, 2.25857273e-02f, -1.46368137e-02f, 3.91602628e-02f,
  -1.52122816e-02f, 3.15636992e-02f, 1.21525880e-02f, 4.16061394e-02f, 1.24089541e-02f, 7.39058759e-03f, -2.85213888e-02f, -1.12840697e-01f, 1.28941778e-02f, -9.66445450e-03f,
  1.26500607e-01f, 3.19512188e-01f, 2.68495572e-03f, 8.06780457e-02f, 3.89775746e-02f, -3.68605256e-02f, -8.38898495e-02f, -4.67922613e-02f, -1.20990817e-02f, 9.39216539e-02f,
  -3.28210406e-02f, 1.69030651e-02f, 5.55849671e-02f, 4.14513312e-02f, 1.83607321e-02f, -9.22495220e-03f, 6.91276267e-02f, -1.21059716e-02f, 5.97910099e-02f, 5.42795137e-02f,
  7.15828165e-02f, 2.91510746e-02f, -8.01943764e-02f, 9.86013934e-02f, 4.50522490e-02f, -1.59969286e-03f, 5.02432287e-02f, -8.77621491e-03f, -3.93081270e-03f, -8.28667805e-02f,
  -3.61648083e-01f, -2.13576838e-01f, -9.38103795e-02f, -2.42561132e-01f, -1.69945404e-01f, -4.28281948e-02f, -3.52770612e-02f, -1.24241747e-01f, -3.31312805e-01f, -9.48912501e-02f,
  8.25163573e-02f, -2.38910839e-01f, 3.30337882e-01f, -2.29682103e-01f, 3.04997619e-02f, 1.99907452e-01f, -3.02192390e-01f, -1.35428309e-01f, -2.03783978e-02f, -1.59491807e-01f,
  -3.44005115e-02f, -1.54427648e-01f, 5.34991808e-02f, -7.95649663e-02f, -1.93557754e-01f, -4.53932174e-02f, 6.68501630e-02f, 1.01558283e-01f, -5.83179146e-02f, -1.62243675e-02f,
  2.86358222e-02f, -4.65062745e-02f, -2.53284052e-02f, -1.75718032e-02f, -5.33276871e-02f, 1.20762317e-02f, 9.31814164e-02f, 1.15593478e-01f, -5.58138825e-02f, -9.27079283e-03f,
  -1.48292352e-02f, -5.00981510e-02f, -3.83775271e-02f, -3.62237953e-02f, -1.38779238e-01f, -2.99881361e-02f, 2.54933387e-02f, -4.54857126e-02f, -6.93275928e-02f, -1.24421325e-02f,
  2.13762745e-02f, 4.57031280e-03f, -8.24440867e-02f, -8.35844129e-03f, 1.13984896e-02f, -3.55644636e-02f, -2.98570339e-02f, 5.51790334e-02f, 1.02191996e-02f, -1.21339977e-01f,
  -3.04986127e-02f, 2.70564295e-02f, 1.99142024e-02f, 2.91619580e-02f, 8.65859503e-04f, 2.49138325e-02f, 1.56538915e-02f, 6.12846650e-02f, -2.40125563e-02f, -2.35650148e-02f,
  -2.83592548e-02f, -2.61709858e-02f, -5.23139872e-02f, 8.78931023e-03f, -1.11346943e-02f, -6.40357584e-02f, 5.20611480e-02f, 4.13620286e-02f, -5.44869341e-02f, 9.73577611e-03f,
  2.25229021e-02f, -2.52422038e-02f, 5.64336255e-02f, 7.39346221e-02f, 2.20413934e-02f, 7.29465559e-02f, 3.42512019e-02f, -6.50589764e-02f, 8.27214792e-02f, 1.77130997e-02f,
  -2.29269173e-02f, -2.37828612e-01f, -2.65468247e-02f, -1.08139170e-02f, 1.68978926e-02f, -1.34395342e-02f, -9.15413797e-02f, -6.09026067e-02f, 1.66836139e-02f, 7.13935180e-04f,
  -2.61533204e-02f, -4.28529866e-02f, -8.48845840e-02f, 6.53979741e-03f, -2.24078051e-03f, -3.93866412e-02f, 2.55211219e-02f, -2.35233121e-02f, -1.80690382e-02f, 2.88117751e-02f,
  1.30677931e-02f, -3.36561538e-02f, -2.29906123e-02f, -3.64753716e-02f, -4.99344319e-02f, 2.47889739e-02f, -1.09639317e-01f, -4.65687737e-02f, 5.58904782e-02f, -4.76800986e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.22909081e-01f, -2.95009106e-01f, 1.08975478e-01f, 4.39127684e-01f, 2.47508347e-01f, -1.10043183e-01f, 1.36467531e-01f, 1.25770256e-01f, 3.54194880e-01f, -2.05277249e-01f,
  -3.92800346e-02f, -1.91671818e-01f, -1.19793609e-01f, 4.73531224e-02f, 8.19050819e-02f, -9.52859521e-02f, 1.12257212e-01f, -4.10548076e-02f, 1.61722779e-01f, 2.03686152e-02f,
  1.24827959e-01f, 2.16800980e-02f, -4.62939180e-02f, -1.17514201e-01f, 6.07268326e-02f, -5.27146570e-02f, -9.42289010e-02f, -1.78308785e-01f, -1.58380166e-01f, -1.12888798e-01f,
  8.21027905e-02f, 7.54110068e-02f, -2.50884276e-02f, -9.18664336e-02f, -3.29535268e-02f, -7.28442967e-02f, -1.01175988e-02f, -1.00453921e-01f, 4.67460304e-02f, -4.24059741e-02f,
  -7.28820562e-02f, 4.03624661e-02f, 2.52238214e-02f, 4.60412614e-02f, 1.20707825e-01f, 1.21235371e-01f, 4.58613150e-02f, 1.00551760e-02f, -3.02363764e-02f, 1.93494037e-02f,
  3.30977291e-02f, 2.24258052e-03f, 8.95252228e-02f, -2.53297202e-02f, -4.03444991e-02f, -5.37786819e-03f, -5.06189428e-02f, -1.32279903e-01f, -3.25920545e-02f, 2.05027014e-02f,
  -9.80911925e-02f, 2.20460333e-02f, 1.05032790e-02f, 5.97125180e-02f, 5.81978373e-02f, 9.78180990e-02f, 1.31290495e-01f, 4.48380038e-02f, -4.64778058e-02f, 5.26437089e-02f,
  9.32915881e-02f, -3.68713541e-03f, 6.19742274e-02f, 5.61089255e-02f, -1.55397896e-02f, 1.27810121e-01f, 4.63616196e-03f, 2.61716568e-03f, -8.40277597e-02f, 9.29168612e-03f,
  1.02441311e-01f, 7.86533754e-04f, -6.91541880e-02f, 9.69679877e-02f, 1.33342594e-02f, -1.11068927e-01f, -1.11097051e-02f, -4.60429490e-02f, 6.05415367e-02f, -7.39774108e-02f,
  -5.22624403e-02f, -3.50423336e-01f, -1.30408064e-01f, -6.02678396e-02f, -5.08325025e-02f, -9.13451016e-02f, 1.10859815e-02f, 5.61686046e-02f, -1.11921288e-01f, 3.50655504e-02f,
  -2.39984877e-02f, -3.07567511e-02f, -3.36951464e-02f, 3.22595313e-02f, -7.52178580e-02f, -2.77161542e-02f, -3.88219319e-02f, -1.60992265e-01f, -3.29656713e-02f, -1.04683772e-01f,
  8.37962981e-03f, 3.35731846e-03f, 8.14909115e-03f, 3.31703536e-02f, 7.86014833e-03f, -3.90845649e-02f, 2.78249327e-02f, 1.03752241e-02f, 5.13642207e-02f, -8.13589320e-02f,
  1.61728278e-01f, 6.16483204e-02f, 1.70362066e-03f, 1.29599497e-01f, -6.98423609e-02f, -1.85222745e-01f, -3.15759897e-01f, 6.80861622e-02f, -1.17858693e-01f, -4.79019806e-02f,
  8.66804421e-02f, 5.30626029e-02f, -3.60664092e-02f, 2.05963224e-01f, 2.69982129e-01f, -4.14646193e-02f, 1.74497977e-01f, 1.39921736e-02f, 3.44219222e-03f, 2.25988030e-01f,
  1.88011006e-01f, 2.59899080e-01f, 1.48851603e-01f, 2.39314407e-01f, 1.98293507e-01f, 5.24278954e-02f, 1.76299840e-01f, -6.84838295e-02f, 1.77438438e-01f, 1.50609226e-03f,
  8.34118482e-03f, 5.82828559e-02f, -3.41637582e-02f, -9.98103246e-02f, -4.12056632e-02f, 3.75088081e-02f, -3.58512290e-02f, -4.67577167e-02f, 1.27649903e-02f, -4.78005297e-02f,
  -9.02767256e-02f, 7.95113295e-02f, -1.11523092e-01f, 1.26396166e-02f, 6.79562986e-02f, -8.02864879e-03f, 1.66029446e-02f, -5.19316271e-02f, -7.60115907e-02f, 5.04211187e-02f,
  -1.19930886e-01f, -3.46739851e-02f, 2.94742752e-02f, -2.60031950e-02f, -4.40950431e-02f, 2.71364283e-02f, -1.07634231e-01f, -3.15528810e-02f, -1.15394332e-01f, 3.63302901e-02f,
  7.23025724e-02f, 3.42110777e-03f, 3.02688219e-02f, -6.87290505e-02f, 4.79978658e-02f, -9.86899249e-03f, -1.57013182e-02f, -1.05906893e-02f, -6.92121033e-03f, 6.95624724e-02f,
  4.57509980e-02f, 5.33342771e-02f, 2.88140569e-02f, 2.12701056e-02f, -3.04072872e-02f, -3.83707210e-02f, -5.98870255e-02f, -1.44263851e-02f, -6.02874300e-03f, -1.66483056e-02f,
  -1.96127780e-03f, 2.50908043e-02f, 1.16491225e-02f, -6.52182326e-02f, -2.88341020e-04f, 2.67011691e-02f, 9.99516845e-02f, 4.98130126e-03f, -1.39674008e-01f, 2.81291027e-02f,
  2.72489386e-03f, 1.74450010e-01f, -1.13670202e-02f, 3.34839080e-03f, -8.60633478e-02f, 1.30603582e-01f, -2.08226107e-02f, 6.11249506e-02f, 1.21085487e-01f, 4.10136916e-02f,
  -3.56611870e-02f, -1.23891920e-01f, -2.83727851e-02f, 2.24097054e-02f, -6.61629438e-02f, 1.05714604e-01f, -8.99155904e-03f, -3.63706760e-02f, 1.35857323e-02f, 1.27114549e-01f,
  4.24727947e-02f, -1.24766491e-01f, -2.39912942e-02f, -4.07119356e-02f, -4.50262874e-02f, -1.59237850e-02f, -6.93219826e-02f, -7.84022501e-04f, 6.22232221e-02f, -2.37749480e-02f,
  -4.76607114e-01f, 1.66814819e-01f, -1.11403786e-01f, -1.44678384e-01f, -1.20956831e-01f, -1.02023669e-01f, -1.41570136e-01f, -8.50676559e-03f, -1.40307158e-01f, 1.94450840e-02f,
  -1.35647342e-01f, 3.22980024e-02f, 8.63172188e-02f, -1.10153832e-01f, -1.23685502e-01f, 1.76977038e-01f, -2.01760024e-01f, -4.53473143e-02f, 2.06656326e-02f, 7.00368080e-04f,
  -2.19994038e-02f, -3.38537507e-02f, -4.08337414e-02f, 1.22538380e-01f, -1.53194368e-01f, -7.00400025e-02f, -1.74164340e-01f, -8.47657546e-02f, -2.08873793e-01f, -8.87256041e-02f,
  -3.65138859e-01f, -2.68890113e-01f, -1.88851520e-01f, -7.93138891e-02f, -1.79108977e-01f, -8.49369988e-02f, -1.22467346e-01f, -5.34642152e-02f, -4.82882001e-02f, -4.50094864e-02f,
  3.25603597e-02f, 9.66791362e-02f, 2.87965368e-02f, 3.94313456e-03f, -3.97792459e-02f, -7.89641291e-02f, 2.60172188e-02f, -7.21131116e-02f, 3.48532274e-02f, 3.01919524e-02f,
  9.44821388e-02f, -4.91504408e-02f, -1.29750118e-01f, -3.05451639e-02f, -4.54471968e-02f, -1.75351903e-01f, -4.33324389e-02f, -1.00068234e-01f, -5.54980040e-02f, -8.11498761e-02f,
  1.09966174e-01f, 6.02842942e-02f, -4.61671054e-02f, -3.83191667e-02f, -5.54354582e-03f, -1.83768328e-02f, 3.26067246e-02f, 1.41840829e-02f, 7.87408277e-03f, -5.20556048e-03f,
  -8.05754587e-02f, -5.95459435e-03f, -8.43718648e-02f, -3.87129150e-02f, 2.39014924e-02f, 2.16182880e-02f, -4.05180752e-02f, -9.75381881e-02f, 9.16623846e-02f, -1.37857599e-02f,
  -2.56928615e-02f, 3.11130146e-03f, 9.75652132e-03f, -7.20302993e-03f, -1.46604981e-02f, 3.42933065e-03f, -2.72629559e-02f, -3.39909382e-02f, -5.66176623e-02f, -7.75996298e-02f,
  -3.92269105e-01f, -4.64539200e-01f, -4.75040413e-02f, -1.39295161e-01f, -1.62301585e-02f, -2.76995897e-02f, 4.00941772e-03f, 7.18557322e-03f, -9.77951363e-02f, 2.99918447e-02f,
  -6.06796145e-02f, -3.13588157e-02f, 5.66135254e-03f, -6.90928847e-02f, 1.34382304e-02f, -4.64351065e-02f, -6.12438247e-02f, -7.41776526e-02f, -4.69626449e-02f, -7.17973337e-02f,
  1.51461316e-02f, 8.89043510e-02f, 5.13693020e-02f, 5.81460856e-02f, -6.14268035e-02f, -1.11355796e-01f, 3.10836863e-02f, -3.37293074e-02f, -6.60591722e-02f, 4.40166965e-02f,
  1.46219030e-01f, 1.01572186e-01f, -2.30862096e-01f, -7.59409443e-02f, -5.66743091e-02f, 3.76155913e-01f, 2.87557721e-01f, 2.78143752e-02f, 2.78011281e-02f, 2.76729196e-01f,
  1.10424228e-01f, -1.02045164e-02f, 6.81989565e-02f, 3.03422272e-01f, 4.09341492e-02f, 1.12350069e-01f, 2.40574151e-01f, 1.89138696e-01f, -1.87440682e-02f, 1.74106061e-01f,
  -5.50086945e-02f, 2.48989195e-01f, -1.43801451e-01f, -6.93615526e-02f, 3.52376401e-02f, -2.60523856e-01f, -1.54654697e-01f, -1.74376711e-01f, -1.69488396e-02f, 2.29945146e-02f,
  7.01242760e-02f, -5.10543725e-03f, 1.09696276e-02f, 3.84453428e-03f, -7.71361515e-02f, -4.74114642e-02f, -2.16190498e-02f, -8.37699473e-02f, -9.11305100e-02f, 2.69058831e-02f,
  9.36897919e-02f, -7.57255182e-02f, 1.23587303e-01f, -1.05127819e-01f, -3.68112363e-02f, -4.32939157e-02f, -1.80105008e-02f, -5.57719320e-02f, -1.03429101e-01f, 4.64783087e-02f,
  7.11611584e-02f, -5.61615191e-02f, 1.91159956e-02f, -1.05896980e-01f, -4.20346111e-02f, -3.13609354e-02f, -2.81278677e-02f, -8.09104554e-03f, 7.23714307e-02f, -1.64432917e-02f,
  5.57514131e-02f, 3.90053838e-02f, 8.22164863e-02f, 5.63664036e-03f, 4.19841241e-03f, 2.48685200e-03f, -6.42655476e-04f, -1.02115676e-01f, 7.87916593e-03f, -5.75094484e-02f,
  -3.35167237e-02f, -4.95706592e-03f, 6.07351549e-02f, 5.75659685e-02f, 4.30860408e-02f, -4.48622964e-02f, 6.49306551e-02f, 9.26593170e-02f, -8.14507827e-02f, -4.34203446e-02f,
  -5.18728867e-02f, -6.03370853e-02f, -2.52937875e-03f, -2.25252230e-02f, 8.11425876e-03f, -8.85128509e-03f, 7.75786862e-02f, 2.84250453e-02f, -3.10255997e-02f, 4.94603291e-02f,
  9.70674679e-02f, 1.19417965e-01f, -2.43454650e-02f, -1.20196799e-02f, -8.26708898e-02f, 1.10122144e-01f, 4.14482094e-02f, 1.08920738e-01f, 4.43463847e-02f, 9.58250910e-02f,
  -1.72301903e-02f, 8.11349303e-02f, 7.96539262e-02f, -8.19766521e-03f, 4.09856141e-02f, 7.67654702e-02f, 5.45737147e-02f, -6.12651510e-03f, 4.55347076e-02f, -2.89944466e-04f,
  -4.11195643e-02f, 1.34451851e-01f, 4.50289845e-02f, 4.87597287e-02f, -4.53645103e-02f, 4.73459549e-02f, 2.37441063e-02f, -8.81229490e-02f, 2.78298929e-02f, -6.73618689e-02f,
  3.82239819e-01f, -2.19658241e-01f, 1.07891791e-01f, 1.22988552e-01f, 1.86910793e-01f, 2.68385142e-01f, 4.69994903e-01f, -6.28048629e-02f, 1.99997842e-01f, -1.60912275e-01f,
  6.49160333e-03f, 1.61992610e-01f, 8.52666125e-02f, 1.19404756e-02f, 3.94651622e-01f, -4.56676669e-02f, 1.49411887e-01f, 4.17672135e-02f, -2.95002125e-02f, 4.43002358e-02f,
  1.64435506e-01f, 1.77567184e-01f, -3.98331620e-02f, -2.59980589e-01f, -4.25286219e-02f, -2.60554761e-01f, -1.64568573e-01f, 8.16326775e-03f, -2.22641736e-01f, 1.81292996e-01f,
  4.02625985e-02f, -3.66730392e-02f, -1.24262199e-02f, 2.65331045e-02f, -1.71694160e-01f, -6.56509101e-02f, 6.90812990e-03f, 9.40366834e-02f, 6.64659590e-03f, -2.20076870e-02f,
  4.36147265e-02f, 1.42407930e-02f, -4.87280972e-02f, 8.97757858e-02f, 3.36761698e-02f, -5.28932735e-02f, -1.01063184e-01f, -1.23555437e-01f, -4.37521711e-02f, -8.77428502e-02f,
  -3.18199471e-02f, -9.21800435e-02f, -8.29007775e-02f, -4.34680618e-02f, -2.79813185e-02f, -6.90872371e-02f, 5.76021075e-02f, 1.08954577e-04f, -1.79131906e-02f, -3.96798216e-02f,
  -2.41274312e-02f, 1.90472398e-02f, 3.81764583e-02f, -5.27701825e-02f, 6.51608333e-02f, -5.52680939e-02f, 6.09699041e-02f, -2.87496895e-02f, 5.45254499e-02f, 5.29608727e-02f,
  -2.44203825e-02f, 8.19798410e-02f, -3.24477293e-02f, 5.02488986e-02f, 1.12911098e-01f, 6.12898842e-02f, -6.49516508e-02f, -5.27565554e-02f, -3.11128385e-02f, 3.68363783e-02f,
  1.87460780e-02f, 3.84760946e-02f, 5.06927818e-02f, -9.45951715e-02f, -2.74497420e-02f, 8.63595679e-02f, 9.19590704e-03f, 8.38287082e-03f, -4.23764959e-02f, 4.63822670e-02f,
  1.56503562e-02f, -1.07107703e-02f, 1.13776870e-01f, 3.93408490e-03f, -5.11743575e-02f, -5.43125272e-02f, 2.35903100e-03f, 3.09031233e-02f, 6.21016975e-03f, 1.36033650e-02f,
  -1.78978629e-02f, 2.92151924e-02f, -1.08039202e-02f, -3.64828967e-02f, -7.01312535e-03f, 1.93311982e-02f, -1.34409023e-02f, 1.87404603e-02f, -4.59805727e-02f, -6.79451600e-02f,
  -7.65884146e-02f, 2.52189282e-02f, 1.03993416e-01f, -9.12862644e-03f, -4.81166542e-02f, -8.03040415e-02f, -4.27531376e-02f, 2.99664028e-02f, -1.10131294e-01f, 3.68717462e-02f,
  1.18393287e-01f, 2.05326885e-01f, 1.33672163e-01f, 1.58558100e-01f, -1.88665614e-01f, -4.12158996e-01f, -3.23219568e-01f, 4.11937460e-02f, 5.79837263e-02f, 5.98665141e-03f,
  -7.27913976e-02f, 3.03728998e-01f, -3.55389081e-02f, 9.61547941e-02f, -1.75866351e-01f, -1.26666069e-01f, -5.45346402e-02f, -9.41939056e-02f, 4.29800786e-02f, 1.12146124e-01f,
  8.41315556e-03f, -1.05282500e-01f, 5.14931530e-02f, -1.11859776e-01f, 2.93143764e-02f, 2.38651931e-01f, 1.67371079e-01f, -6.33267313e-02f, 9.66811460e-03f, 5.55943847e-02f,
  -8.66068229e-02f, 1.80457979e-01f, 7.49302655e-02f, 1.43996840e-02f, 4.82842028e-02f, -9.59867015e-02f, -1.11725159e-01f, -2.17906330e-02f, -3.26981619e-02f, 4.99906316e-02f,
  2.86415275e-02f, 5.52561227e-03f, 2.93964129e-02f, -5.67515567e-03f, -3.29529829e-02f, 2.15007588e-02f, 5.04362285e-02f, 7.05149099e-02f, 1.05759151e-01f, -2.00801566e-02f,
  4.20812108e-02f, 3.57298665e-02f, 7.78546855e-02f, 6.86735436e-02f, 6.52955398e-02f, 2.43691932e-02f, -7.78932497e-02f, 1.46236802e-02f, 5.16568832e-02f, 5.47866970e-02f,
  -2.56770235e-02f, -1.13144986e-01f, -3.40672471e-02f, 6.57189339e-02f, 6.12130091e-02f, -3.96190621e-02f, 2.27809343e-02f, 7.60225160e-03f, 1.44965816e-02f, -1.92938987e-02f,
  -6.35904372e-02f, 1.06877543e-01f, -1.11144833e-01f, -4.84114029e-02f, -6.60175607e-02f, 8.53258818e-02f, -1.03512863e-02f, -4.49455194e-02f, 7.21466914e-03f, 8.11730232e-03f,
  4.83210385e-02f, -6.93896785e-02f, 1.27926394e-01f, -8.43138546e-02f, -1.07331239e-01f, 7.75463507e-02f, 5.53687699e-02f, -3.05905193e-03f, 4.64376993e-02f, -8.12171921e-02f,
  2.23216601e-02f, 1.98071599e-01f, 2.70196255e-02f, 7.11238086e-02f, -3.98122519e-02f, -6.96753487e-02f, -1.15458176e-01f, 9.04693455e-02f, 1.56186614e-02f, -7.86990672e-02f,
  -1.94739189e-03f, 1.39068523e-02f, 2.62850970e-02f, -5.71014658e-02f, -8.65144469e-03f, -5.09097194e-03f, 9.49283689e-02f, 5.80551587e-02f, 1.39270589e-01f, 3.74031067e-02f,
  5.00506014e-02f, -4.84237075e-02f, 1.60381582e-03f, 2.32075825e-02f, -1.08883291e-01f, -1.62790045e-02f, 2.25292724e-02f, 8.38893950e-02f, 1.34485951e-02f, -6.91827163e-02f,
  7.03695863e-02f, -2.03970507e-01f, 2.70214647e-01f, 1.93074018e-01f, -1.30440921e-01f, -1.36337653e-01f, 2.48587076e-02f, -2.51105636e-01f, -1.84004813e-01f, -2.24554747e-01f,
  -7.46294037e-02f, 2.67259210e-01f, -2.80719101e-01f, 1.45021290e-01f, 2.95318365e-01f, -1.30520895e-01f, 7.82052502e-02f, 1.59765780e-01f, -1.42505303e-01f, 6.62652776e-03f,
  -3.02386731e-02f, -5.02002724e-02f, 1.27856717e-01f, -1.43573424e-02f, 6.14346154e-02f, 2.18736649e-01f, 1.29237190e-01f, 6.87400624e-02f, 3.40240538e-01f, 2.00972810e-01f,
  -1.86608151e-01f, -4.84343246e-02f, -2.29215268e-02f, 3.09337601e-02f, -8.61700028e-02f, 6.30521029e-02f, 1.24092847e-01f, 1.17019065e-01f, 1.52093628e-02f, 1.90607198e-02f,
  -1.83331165e-02f, 1.01154894e-01f, 3.59294116e-02f, -9.43544600e-03f, -9.05139819e-02f, 9.21409577e-02f, 6.30425988e-03f, -8.51421133e-02f, 2.26732381e-02f, -2.24308819e-02f,
  -5.53853437e-02f, -3.59055996e-02f, -3.75855938e-02f, 8.16168636e-02f, 1.03371982e-02f, -3.33117247e-02f, 7.42526650e-02f, 1.46090373e-01f, 5.22883646e-02f, 6.95359781e-02f,
  2.65353359e-02f, -8.67489651e-02f, -2.71506347e-02f, -2.18967050e-02f, 8.17359611e-02f, -2.10390426e-02f, 3.20136617e-03f, -4.42159139e-02f, 1.81050077e-02f, -1.08340718e-01f,
  -6.50028810e-02f, -1.98230464e-02f, 2.05271207e-02f, -8.16454366e-02f, -3.52665260e-02f, -4.20169719e-02f, 1.19508348e-01f, 1.49161052e-02f, 1.77764706e-03f, -7.13031273e-03f,
  -1.14585347e-01f, 1.67180020e-02f, 5.42630181e-02f, 3.39364149e-02f, 2.92776264e-02f, -2.19740253e-02f, -3.83793898e-02f, 1.28022628e-02f, -3.70526016e-02f, -7.77391791e-02f,
  -3.14340442e-01f, -2.93378755e-02f, -1.41382674e-02f, -2.68479879e-03f, 2.57539283e-02f, -2.52767727e-02f, -1.74932610e-02f, -5.22460267e-02f, -2.15482339e-02f, 1.53510878e-02f,
  -7.45042711e-02f, 9.00866687e-02f, -9.20722820e-03f, 6.58193752e-02f, -3.23392749e-02f, -6.11582398e-02f, 1.22842286e-02f, -8.29998702e-02f, 1.31734228e-02f, -3.13954391e-02f,
  -1.30380318e-02f, -4.59742211e-02f, 3.29574011e-02f, 6.11608811e-02f, -4.57942709e-02f, -1.97025016e-03f, 2.90388416e-05f, 5.43454997e-02f, 3.41034792e-02f, 1.53055880e-02f,
  -4.54332493e-02f, 2.05420420e-01f, -5.62399365e-02f, 2.84226201e-02f, 2.73930598e-02f, -1.92333177e-01f, -1.03996117e-02f, 4.34761234e-02f, 4.45913114e-02f, 2.64204323e-01f,
  -9.41053331e-02f, 6.37289360e-02f, -4.58367653e-02f, -2.16135353e-01f, -4.88813907e-01f, -2.92361796e-01f, -2.28775680e-01f, -1.48069024e-01f, -1.20044410e-01f, 5.70436530e-02f,
  -1.07836790e-01f, -1.00545853e-01f, -5.98708838e-02f, 7.98230246e-02f, 2.21213266e-01f, 2.26156652e-01f, 1.43467426e-01f, 3.27228270e-02f, 1.05083540e-01f, -1.18648469e-01f,
  -9.20952708e-02f, 3.42536792e-02f, 1.14022702e-01f, -8.84646922e-02f, 6.82206899e-02f, 1.30331591e-01f, 4.39225975e-03f, -4.88569178e-02f, -2.92998701e-02f, -7.22951293e-02f,
  1.49892587e-02f, -2.00834349e-02f, -2.83969399e-02f, -1.10479183e-01f, 3.87593172e-02f, -8.65872577e-02f, -3.47755998e-02f, 4.18627821e-02f, -3.20393927e-02f, -1.25794485e-02f,
  2.71856971e-02f, 7.66814649e-02f, 3.21895406e-02f, -1.81621704e-02f, -3.47226416e-03f, 3.13111171e-02f, 5.84647525e-03f, -3.04522607e-02f, 3.68616693e-02f, -1.48485787e-02f,
  1.18830264e-01f, -8.57073162e-03f, -1.16462089e-01f, -4.02852483e-02f, -6.36537969e-02f, 2.57096626e-02f, -8.29376504e-02f, -2.13932246e-02f, -6.61823303e-02f, 2.05825455e-02f,
  9.96694192e-02f, -4.19680960e-02f, -2.83908229e-02f, 1.39445830e-02f, 3.33330445e-02f, -7.49299536e-03f, 3.02705038e-02f, -1.75948497e-02f, -1.40242912e-02f, -5.87004563e-03f,
  1.59088485e-02f, -8.61625001e-03f, -6.42595859e-03f, 8.05078000e-02f, -7.54792765e-02f, -1.43572045e-02f, -1.70275159e-02f, -7.09205568e-02f, -2.21986547e-02f, -2.31062621e-03f,
  -2.33149268e-02f, 1.55788660e-01f, 9.37286168e-02f, -7.38131627e-02f, 4.78027277e-02f, -1.02243964e-02f, -1.34210840e-01f, -4.03766194e-03f, -6.93151355e-02f, -2.90201269e-02f,
  7.64454454e-02f, 1.37108952e-01f, 1.04729220e-01f, -4.85887527e-02f, -1.22380033e-02f, -6.65600076e-02f, 6.62234128e-02f, 5.03870249e-02f, 1.12887353e-01f, 1.13137379e-01f,
  9.47731212e-02f, 4.92734946e-02f, 7.07343146e-02f, 1.73994917e-02f, 5.63373789e-02f, 4.37413678e-02f, 1.98723711e-02f, 7.43511915e-02f, 7.90554509e-02f, 3.98632213e-02f,
  3.85758340e-01f, 3.82392406e-01f, 3.09569865e-01f, 4.23715979e-01f, -2.04986826e-01f, -1.65402129e-01f, -7.61206672e-02f, 8.32523331e-02f, 1.98276073e-01f, 8.18710774e-02f,
  -1.46810472e-01f, 4.21576440e-01f, -1.04108945e-01f, 1.13567404e-01f, -2.12417003e-02f, -1.36691034e-01f, 2.36518428e-01f, 9.53934342e-02f, 1.48670807e-01f, 1.69079021e-01f,
  1.90289557e-01f, -9.65522677e-02f, 5.23214899e-02f, -9.40654501e-02f, 9.55668613e-02f, 1.37070090e-01f, -9.53561813e-02f, -1.49252534e-01f, 3.62753891e-03f, -1.25724852e-01f,
  -2.20330045e-01f, 1.26672670e-01f, 1.04429647e-01f, -1.90526545e-02f, 1.62468571e-02f, -8.29921141e-02f, -1.48784239e-02f, -9.34129879e-02f, -6.82122633e-02f, -5.22134081e-03f,
  3.84646207e-02f, -2.31195223e-02f, 1.25655672e-02f, -5.24837524e-02f, -3.78842205e-02f, 5.89372925e-02f, -2.34488100e-02f, 8.93144980e-02f, -8.74208193e-03f, 5.02184220e-02f,
  2.93733254e-02f, 6.49779104e-03f, 3.54151167e-02f, -9.91306826e-03f, 1.30061910e-01f, 9.12169367e-02f, 4.65307236e-02f, -3.48017365e-02f, 7.03190686e-03f, 6.65921345e-02f,
  2.64249109e-02f, 2.18471251e-02f, 1.05732242e-02f, -3.40827666e-02f, -3.65069658e-02f, 4.34835032e-02f, 1.78708751e-02f, -4.06861454e-02f, -4.05953415e-02f, -4.05948348e-02f,
  -4.58040796e-02f, 3.94935198e-02f, -2.37960145e-02f, 4.38642055e-02f, 1.11692235e-01f, -6.12657145e-03f, -1.53891668e-02f, -4.63745557e-02f, 1.03743531e-01f, 2.51031816e-02f,
  -1.46936094e-02f, -3.37795876e-02f, 6.94955140e-02f, -3.25113274e-02f, -6.51149824e-02f, -6.16196245e-02f, 3.21651772e-02f, 9.02737379e-02f, -2.16635298e-02f, 7.18521746e-03f,
  -4.98642810e-02f, 1.52823225e-01f, 1.01053625e-01f, -3.28693837e-02f, -2.77411216e-03f, -5.77075779e-03f, 6.00722320e-02f, -1.31698931e-02f, 3.04479674e-02f, 6.56317547e-02f,
  6.04384765e-02f, -4.06818092e-02f, -3.96183953e-02f, -1.20454647e-01f, -5.70073165e-03f, 7.55299907e-03f, 1.73319988e-02f, 1.05764613e-01f, 2.09477004e-02f, 4.72330675e-02f,
  5.10972552e-02f, -2.15682015e-02f, -5.40207885e-02f, -2.09715888e-02f, -2.56575793e-02f, 3.74725834e-02f, -3.48776323e-03f, 4.97941636e-02f, -4.96504568e-02f, -9.40300990e-03f,
  -6.79643095e-01f, 2.92175636e-02f, -3.46952587e-01f, 4.95166332e-02f, -1.68867484e-01f, -1.40767857e-01f, 7.23286271e-02f, -1.32516339e-01f, 2.02963389e-02f, 3.64999920e-01f,
  2.73880929e-01f, -1.16532490e-01f, 1.77048117e-01f, 2.71896064e-01f, -5.37309051e-01f, 9.07807946e-02f, 6.99839136e-03f, 8.00925046e-02f, -5.13108373e-02f, -1.18869431e-01f,
  -1.75787032e-01f, 1.83622018e-01f, -1.45806283e-01f, 3.25212628e-02f, -1.58047199e-01f, -5.21650873e-02f, 1.86802790e-01f, 1.05998032e-02f, 1.14601970e-01f, -6.36580884e-02f,
  -1.04116097e-01f, -7.22978413e-02f, 5.34048788e-02f, -3.92158739e-02f, -9.48849544e-02f, 1.33051639e-02f, 4.15796740e-03f, 1.32644614e-02f, -2.46439129e-02f, -7.47390613e-02f,
  -4.41622511e-02f, -5.34093678e-02f, 8.09263140e-02f, -5.69222122e-03f, -5.71315847e-02f, -6.08041734e-02f, -7.23363683e-02f, 5.73078170e-03f, 5.45772444e-03f, -7.15533048e-02f,
  -1.00269563e-01f, -1.08836658e-01f, 1.60307288e-02f, -8.11356585e-04f, -3.03154364e-02f, 3.50342803e-02f, 5.23319608e-03f, -8.28766171e-03f, -1.14446394e-01f, -7.25104064e-02f,
  -1.22027136e-02f, -1.04463156e-02f, 2.11044829e-02f, -1.18912756e-02f, 1.00462310e-01f, 5.19813336e-02f, 4.01691198e-02f, 4.20680456e-02f, -1.38457641e-02f, 4.68199626e-02f,
  3.06679048e-02f, -2.35850476e-02f, 5.03520519e-02f, 1.62914433e-02f, -7.39068985e-02f, 7.27330893e-02f, -1.88175533e-02f, -1.95531510e-02f, 5.68566732e-02f, 2.13114936e-02f,
  9.09862518e-02f, -4.16137278e-02f, 1.33885592e-01f, 8.95261168e-02f, -6.19931035e-02f, -7.57128792e-03f, 3.88461947e-02f, -6.31100032e-04f, 6.70080706e-02f, -5.88772334e-02f,
  -9.49572921e-02f, -1.56748936e-01f, 1.06884673e-01f, -8.70523304e-02f, 6.40996024e-02f, -1.63849927e-02f, 1.83578711e-02f, -1.33752795e-02f, 5.43605462e-02f, -9.71743912e-02f,
  -5.08658774e-02f, -1.77523419e-02f, -6.10809922e-02f, 5.27911410e-02f, -3.72310281e-02f, 7.02064484e-02f, 2.61682980e-02f, -8.05791654e-03f, -1.09133748e-02f, -1.05000563e-01f,
  -1.94710847e-02f, -6.77983239e-02f, -6.91636652e-02f, 1.00323334e-01f, 6.81978017e-02f, 8.06564838e-02f, -8.55891500e-03f, 4.77226563e-02f, -8.25087279e-02f, 6.77157789e-02f,
  2.42352560e-01f, -2.59794205e-01f, -1.04391076e-01f, 2.97492921e-01f, 3.36028710e-02f, -1.84858710e-01f, -1.48345754e-01f, 2.20359355e-01f, 2.82325242e-02f, -2.13215783e-01f,
  7.02460706e-02f, -8.27645212e-02f, -1.68524414e-01f, 1.55958474e-01f, 2.50065684e-01f, -1.57210648e-01f, 1.44657776e-01f, 1.37424236e-02f, 1.13525381e-02f, 1.09996021e-01f,
  2.58502692e-01f, 2.81067908e-01f, 2.00120896e-01f, 2.21998721e-01f, 5.51982783e-02f, 2.31612042e-01f, 1.50622413e-01f, -1.18639125e-02f, 2.39878491e-01f, 1.09941185e-01f,
  -1.83252115e-02f, -1.45558883e-02f, 1.11387476e-01f, 5.69807030e-02f, -1.61094349e-02f, -9.78335589e-02f, -9.05727446e-02f, 9.10344422e-02f, 9.37148333e-02f, 1.92172416e-02f,
  -1.05576783e-01f, 3.74911688e-02f, 1.63006544e-01f, 7.43135512e-02f, 5.89709207e-02f, 1.18610254e-02f, 4.04045098e-02f, 2.58144587e-02f, -2.45133066e-03f, -4.76283878e-02f,
  -4.10277918e-02f, -8.22943971e-02f, -2.27805730e-02f, 1.33765265e-02f, 6.18512705e-02f, 4.17698696e-02f, -6.99316859e-02f, -1.26259727e-02f, -4.11864221e-02f, 5.37944771e-03f,
  6.20907508e-02f, -1.04429841e-01f, -3.22656929e-02f, 5.96538782e-02f, 2.94232853e-02f, 1.60909165e-02f, -2.27096044e-02f, 1.76009759e-02f, 3.70166823e-02f, -2.80762427e-02f,
  -6.16720915e-02f, 6.16526268e-02f, 2.19612196e-02f, -1.31296501e-01f, 3.66190672e-02f, -8.57224613e-02f, -3.61278653e-02f, 5.01711816e-02f, -3.26191783e-02f, -2.25369986e-02f,
  -5.44160642e-02f, 4.68483977e-02f, 7.44472668e-02f, -1.11411661e-02f, 6.20840536e-03f, 3.37315574e-02f, 1.49468500e-02f, 2.94014458e-02f, -1.24060567e-02f, -3.71205658e-02f,
  -4.88204136e-02f, -6.04953319e-02f, -3.21485586e-02f, 3.55803482e-02f, -2.17554122e-02f, -2.94743907e-02f, -7.80024081e-02f, 9.50342491e-02f, -4.72325133e-03f, -2.06292905e-02f,
  4.78226691e-02f, 1.44551310e-03f, -1.30591169e-01f, 7.46025294e-02f, 8.97806734e-02f, -3.46603394e-02f, 4.51131398e-03f, 9.89845023e-02f, 5.43963611e-02f, -4.92366478e-02f,
  -5.86709753e-02f, -7.22448900e-02f, -2.62818576e-05f, 4.59165424e-02f, 5.41920848e-02f, -1.01843745e-01f, 1.60515998e-02f, -4.07369174e-02f, -6.83031930e-03f, 7.49406498e-03f,
  -7.18531013e-02f, -2.59278882e-02f, -3.17200512e-01f, -1.99132353e-01f, -5.44753559e-02f, -2.62023807e-01f, -3.59056354e-01f, -8.74533430e-02f, 1.01735257e-01f, 3.51324938e-02f,
  -1.34035408e-01f, -2.33871136e-02f, 1.39698043e-01f, -2.78198957e-01f, 1.54075339e-01f, 2.20997632e-01f, -1.25050008e-01f, -9.71194655e-02f, 1.08382486e-01f, -2.24119663e-01f,
  2.66779140e-02f, -1.86915517e-01f, -8.66322592e-02f, -1.11259945e-01f, -3.37773442e-01f, -1.16605870e-01f, 8.63841269e-03f, -1.51622787e-01f, -2.23629966e-01f, -8.53641033e-02f,
  -1.53590545e-01f, -9.80438143e-02f, -5.83480336e-02f, 2.71957442e-02f, -9.19969082e-02f, -3.09820846e-03f, -1.12020031e-01f, 1.86132044e-02f, -7.51715079e-02f, -2.46290267e-02f,
  2.51338980e-03f, 7.53363455e-03f, -2.47174446e-02f, 5.72543964e-02f, 8.23063925e-02f, -9.23065562e-03f, -2.70136297e-02f, -9.16680843e-02f, -9.16626900e-02f, 5.14675863e-02f,
  -9.33052376e-02f, 1.21004991e-02f, -8.36465731e-02f, 5.77334426e-02f, -2.56007500e-02f, -5.09431027e-03f, -1.93885043e-02f, 3.45679447e-02f, -3.47360037e-02f, -9.02107283e-02f,
  2.80357823e-02f, 2.69889878e-03f, 4.55049332e-03f, -2.39800848e-02f, -1.91365127e-02f, -5.70265353e-02f, 4.00868151e-03f, 1.05899889e-02f, -8.04494694e-02f, -4.20992114e-02f,
  5.38276881e-03f, 1.93327162e-02f, 6.70622103e-03f, 6.19886443e-02f, -5.16430996e-02f, -8.33480805e-02f, 4.49642874e-02f, 3.04323230e-02f, -2.50787158e-02f, 5.20842038e-02f,
  -6.42858818e-03f, -1.40831694e-02f, 8.78776237e-03f, -4.53128405e-02f, -5.45725180e-03f, -7.42433732e-03f, -3.55317583e-03f, 5.81010468e-02f, 2.68600807e-02f, -2.46206913e-02f,
  -2.33520307e-02f, -3.18848453e-02f, -3.63809057e-02f, -2.58287471e-02f, 6.13393486e-02f, 6.09606737e-03f, 5.86690009e-02f, 2.43494138e-02f, -1.30638489e-02f, -8.09020922e-02f,
  -4.59192842e-02f, 4.97544929e-02f, -1.04647495e-01f, -2.08958220e-02f, 4.95763160e-02f, -3.99428606e-02f, -5.09187616e-02f, 6.85047135e-02f, -6.97201267e-02f, 6.07511550e-02f,
  -4.46887910e-02f, 4.59102616e-02f, 5.16031347e-02f, -4.65805121e-02f, 8.71232450e-02f, -3.71674038e-02f, -1.59493741e-02f, 2.28003357e-02f, 2.80787293e-02f, 2.74255108e-02f,
  -4.67281163e-01f, 1.64305270e-01f, -6.94299489e-02f, 1.50438130e-01f, -2.64728159e-01f, 7.00165145e-03f, 4.77122590e-02f, 1.57548338e-02f, 3.79695654e-01f, 1.74349353e-01f,
  -1.16488896e-01f, -3.89599353e-02f, 1.01002529e-01f, 3.56610492e-02f, -9.08003841e-03f, 2.91660875e-01f, 3.60580571e-02f, 8.65604877e-02f, 6.81025684e-02f, -1.87337145e-01f,
  -4.77205627e-02f, -2.28324309e-01f, -1.79007813e-01f, -1.85342789e-01f, -3.03114086e-01f, -5.37680574e-02f, -1.48140550e-01f, -3.90525907e-03f, -1.51538193e-01f, 3.33862267e-02f,
  -1.47623077e-01f, -8.77848826e-03f, -1.71771988e-01f, 3.79732922e-02f, -1.42882079e-01f, -5.65893762e-02f, 3.28372768e-03f, 1.20323878e-02f, 4.98721525e-02f, -5.45953475e-02f,
  -5.14632575e-02f, -5.51573783e-02f, 4.43477649e-03f, 3.83740887e-02f, 6.68659359e-02f, -2.72224527e-02f, -1.59218572e-02f, -1.44554213e-01f, -2.95092501e-02f, -1.04028605e-01f,
  -9.80103910e-02f, -2.04711850e-03f, -5.31035438e-02f, 1.23727292e-01f, -1.07972389e-02f, 5.15422635e-02f, 1.03385009e-01f, -7.22036436e-02f, -5.04267514e-02f, 3.97256650e-02f,
  -4.80440371e-02f, 1.20547861e-01f, 1.02690770e-03f, -2.58994964e-03f, -1.90973356e-02f, 2.45699547e-02f, 3.00079468e-04f, -3.38153020e-02f, 8.86431560e-02f, -6.97167888e-02f,
  -2.73810774e-02f, -1.97355710e-02f, -7.30031077e-03f, -2.09394991e-02f, 2.23751459e-02f, 8.35519135e-02f, -4.75126244e-02f, 7.29146507e-03f, -7.28776604e-02f, -8.32027793e-02f,
  7.89481401e-02f, 6.07042313e-02f, -6.33896738e-02f, 2.39495840e-02f, -6.08828664e-02f, 4.56539840e-02f, -2.82183420e-02f, -3.09057590e-02f, 2.51736958e-02f, -7.22556263e-02f,
  8.52476954e-02f, 2.28436425e-01f, 1.11252908e-02f, -1.09051749e-01f, 3.02333236e-02f, -2.79977545e-02f, 4.25630212e-02f, -4.48479950e-02f, 1.08208761e-01f, 6.12799190e-02f,
  -2.58834623e-02f, 1.02316849e-01f, -6.17006160e-02f, 3.33543904e-02f, 9.33011770e-02f, 7.41798058e-02f, 6.86690360e-02f, 6.57900497e-02f, -1.43073853e-02f, -3.30821052e-02f,
  -7.77177587e-02f, 2.39032805e-02f, 5.13051189e-02f, -6.89174384e-02f, -5.08900220e-03f, -2.69768909e-02f, 1.47223705e-02f, 3.50029469e-02f, -6.52056262e-02f, 5.60964085e-03f,
  7.64141679e-02f, -2.93694913e-01f, -4.10360396e-01f, -5.85242510e-02f, 3.37278068e-01f, 2.70352930e-01f, 6.36038110e-02f, 3.34686413e-02f, -1.49419829e-01f, 5.54587953e-02f,
  -4.98298928e-02f, -1.84725732e-01f, -2.61397362e-01f, -2.31148288e-01f, -1.05106175e-01f, -2.99329400e-01f, -1.04593597e-01f, 7.73657393e-03f, -1.93611443e-01f, 4.77495007e-02f,
  -1.14903841e-02f, 1.33400157e-01f, -8.58353600e-02f, 1.35073408e-01f, 1.07026309e-01f, 8.58524814e-02f, 2.36411586e-01f, 7.75049301e-03f, 1.56463608e-01f, -2.56248433e-02f,
  -4.51226830e-02f, -1.85465798e-01f, -7.78954998e-02f, 1.35800652e-02f, 1.12847313e-01f, 1.46772474e-01f, 1.35721445e-01f, -6.52647624e-03f, -2.63804588e-02f, -5.43157719e-02f,
  5.75169101e-02f, -5.46748117e-02f, -1.16832759e-02f, -1.29510416e-02f, -2.16090661e-02f, 1.78310517e-02f, -5.48295937e-02f, -8.06045905e-02f, -8.06060880e-02f, -8.78698453e-02f,
  -7.65398517e-02f, -6.31431118e-02f, -5.28068244e-02f, 1.45518165e-02f, -4.34697904e-02f, -1.13570187e-02f, 2.10681316e-02f, 9.55865234e-02f, -5.98013662e-02f, 7.78024793e-02f,
  1.06039889e-01f, 3.06569748e-02f, 6.85429350e-02f, -2.09724531e-03f, -7.36139566e-02f, 8.66474863e-03f, -2.77871229e-02f, -7.84730017e-02f, -2.33238172e-02f, -5.63561954e-02f,
  1.16229448e-02f, 1.34089962e-03f, -9.71062556e-02f, 7.66912699e-02f, 3.62890959e-02f, -3.18189822e-02f, 4.56739180e-02f, -1.78409684e-02f, 9.04085860e-02f, -7.06734508e-02f,
  1.88352391e-02f, -4.99186441e-02f, 1.44075722e-01f, -6.40499173e-03f, -1.25600263e-01f, 1.10137075e-01f, -6.83401618e-03f, -3.49821858e-02f, -5.59169985e-03f, 4.71012592e-02f,
  -3.78122553e-03f, 4.72607501e-02f, -1.35951850e-03f, -3.56154628e-02f, -1.06606714e-01f, 3.74782719e-02f, -5.54044470e-02f, 8.58394022e-04f, 2.24747602e-02f, 1.11040445e-02f,
  1.54833227e-01f, 7.87556097e-02f, 6.53230026e-02f, 1.63311493e-02f, -6.73998520e-02f, 1.19723856e-01f, 5.27006015e-02f, 1.37875482e-01f, 8.63689557e-02f, 2.27082558e-02f,
  8.82345289e-02f, 8.31052884e-02f, -3.64870317e-02f, 8.32381472e-02f, 2.06114911e-02f, 3.73001732e-02f, 4.49523749e-03f, 1.18115701e-01f, -5.53519577e-02f, -3.26755941e-02f,
  -1.34133264e-01f, -2.78904617e-01f, -3.12078953e-01f, -3.04336455e-02f, 1.72014669e-01f, 1.09004498e-01f, -3.33605886e-01f, 1.52122770e-02f, -3.52927536e-01f, 3.67178768e-02f,
  7.74210691e-02f, -1.79308146e-01f, -2.91038573e-01f, 5.53410314e-03f, 7.20853582e-02f, -3.05008382e-01f, 1.51048869e-01f, 2.41668802e-03f, -1.45567209e-01f, 2.11922154e-02f,
  -3.10921427e-02f, 1.89560920e-01f, -1.82683364e-01f, 2.76552349e-01f, 6.97486177e-02f, 9.98476520e-02f, 4.14498299e-01f, -6.45332783e-02f, 2.72051007e-01f, 1.80693388e-01f,
  3.12044695e-02f, -1.59232751e-01f, -5.63430823e-02f, -6.31256104e-02f, 2.60894764e-02f, 5.57242110e-02f, 5.26531562e-02f, 5.85387228e-03f, -1.95245743e-02f, -3.31725106e-02f,
  -1.66897699e-02f, -2.94859409e-02f, 4.87465411e-02f, 7.95627665e-03f, 1.91581547e-02f, 4.43788432e-03f, -1.16333961e-01f, -4.36427295e-02f, -1.37946844e-01f, -5.91008551e-02f,
  -1.60722226e-01f, 6.43104091e-02f, 6.37507886e-02f, 3.08944471e-03f, 4.04996704e-03f, -6.56091375e-03f, 1.70717854e-02f, -2.08973624e-02f, 1.32414952e-01f, 1.74612440e-02f,
  4.76066023e-03f, 1.03315085e-01f, -8.57404619e-02f, -8.13204199e-02f, -2.24426463e-02f, 1.11522144e-02f, 8.37068185e-02f, 3.88347246e-02f, -1.08335279e-01f, -1.13191539e-02f,
  3.77392247e-02f, -8.46702531e-02f, 5.40816896e-02f, 2.95829494e-02f, 2.30901558e-02f, 2.01124810e-02f, 7.19668716e-02f, -5.26535977e-03f, -3.85592915e-02f, 3.04963291e-02f,
  -4.04229611e-02f, 1.10715553e-01f, -8.81870091e-02f, 8.80297124e-02f, 3.98054495e-02f, -6.37219772e-02f, 7.45608434e-02f, -3.48745845e-03f, 2.10665222e-02f, 1.35512212e-02f,
  6.34286106e-02f, 8.03292617e-02f, -9.29469690e-02f, 3.07614710e-02f, -2.62128301e-02f, 8.24212357e-02f, -3.21629420e-02f, 3.43935043e-02f, 2.90857200e-02f, 2.90819164e-02f,
  9.61041078e-02f, 6.24481440e-02f, 1.06342226e-01f, -2.90144105e-02f, 1.28683820e-01f, 5.12995198e-03f, 7.60245174e-02f, 7.35045671e-02f, 1.30238116e-01f, 3.96483131e-02f,
  7.31752589e-02f, 4.28504050e-02f, 8.21885467e-02f, -2.13068686e-02f, 8.56982917e-02f, 1.31419241e-01f, 1.54722944e-01f, -5.72210327e-02f, 8.01497027e-02f, -4.81464751e-02f,
  1.68055430e-01f, 1.21715322e-01f, -3.35602462e-01f, 6.21608160e-02f, -1.78225949e-01f, 1.52135327e-01f, 1.25051856e-01f, -6.95676878e-02f, -1.30851418e-01f, 2.88673520e-01f,
  1.95850238e-01f, -8.91675949e-02f, 1.33798778e-01f, 4.08615530e-01f, 1.46795884e-02f, 1.44327968e-01f, 2.93395579e-01f, 2.55520701e-01f, -1.11146078e-01f, 1.55507863e-01f,
  1.10013294e-03f, 4.58670437e-01f, 2.26947442e-02f, 8.53814185e-02f, 9.47629064e-02f, -1.55533552e-01f, 1.94601472e-02f, -2.88296163e-01f, 1.41533315e-01f, -4.02371474e-02f,
  8.48476440e-02f, 8.91784877e-02f, -5.34699149e-02f, 4.45181765e-02f, -3.07158530e-02f, 8.28319788e-02f, -1.20525450e-01f, -3.03147081e-02f, -1.35648921e-01f, -1.43428892e-02f,
  6.22641742e-02f, 3.51779498e-02f, 6.58178255e-02f, -4.20717038e-02f, -3.82944420e-02f, -4.64969017e-02f, -2.55420711e-02f, -6.91408291e-02f, -4.03222926e-02f, 5.75901307e-02f,
  -3.15018231e-03f, 4.13870364e-02f, -1.07578654e-02f, 2.20474396e-02f, -9.08721685e-02f, 8.86648335e-03f, 1.03333322e-02f, -1.11120567e-01f, -3.91849168e-02f, -6.83782101e-02f,
  5.31063750e-02f, -5.81395999e-03f, 6.67942539e-02f, 5.96189201e-02f, 1.96972210e-02f, -1.60169415e-02f, 1.00161150e-01f, -1.32970093e-02f, -6.12476654e-02f, 8.30064863e-02f,
  -2.27962285e-02f, -2.95955725e-02f, 3.69694121e-02f, -3.06342077e-02f, 3.30447480e-02f, 4.00718860e-02f, -3.20007210e-03f, -6.50526211e-02f, -2.11728625e-02f, -4.48671505e-02f,
  -2.32110377e-02f, -8.03726017e-02f, -1.23197250e-02f, 1.46446014e-02f, 3.72807570e-02f, -1.01308361e-01f, -1.58757214e-02f, 7.54055241e-03f, -7.87914544e-02f, 7.56202824e-03f,
  -1.70873273e-02f, -3.69347781e-02f, -1.44469766e-02f, -4.40609232e-02f, -1.87022872e-02f, 5.44756949e-02f, 2.52576843e-02f, -1.46175204e-02f, -1.50140569e-01f, -2.89125610e-02f,
  8.79767686e-02f, -1.64790712e-02f, -3.70495580e-02f, -6.28502965e-02f, -1.05139114e-01f, 6.36235625e-02f, 6.42224103e-02f, -8.46764818e-02f, -1.51134469e-02f, -2.01630630e-02f,
  5.47797084e-02f, 2.75799986e-02f, 4.78514768e-02f, 9.96537413e-03f, 1.00562856e-01f, 3.33542414e-02f, -9.92984325e-02f, 8.85923952e-03f, -2.11069379e-02f, 2.26695742e-02f,
  2.94008874e-03f, 3.79625112e-02f, -7.61377886e-02f, 9.06976908e-02f, 1.02883510e-01f, -1.16005354e-01f, 7.28189722e-02f, 8.02328959e-02f, 1.29716992e-01f, 1.47907376e-01f,
  -9.21051130e-02f, 5.88307790e-02f, -1.25307605e-01f, -1.58755079e-01f, -4.46682811e-01f, -2.18718246e-01f, -1.42537937e-01f, 2.97158528e-02f, -6.10293001e-02f, 1.21329017e-01f,
  -6.32486117e-05f, -1.89999565e-01f, -1.62055999e-01f, 1.20588169e-01f, 1.58383816e-01f, 1.36504501e-01f, -2.49012336e-02f, 1.43323224e-02f, -3.95349897e-02f, -2.57853623e-02f,
  -2.11446341e-02f, -2.24589072e-02f, -4.04279083e-02f, 6.28122762e-02f, -2.02107206e-02f, 3.13709788e-02f, 5.86476512e-02f, 3.76602411e-02f, 2.93562934e-02f, -5.61349851e-04f,
  1.63572785e-02f, -6.62349090e-02f, -8.36143084e-03f, -1.69240516e-02f, 1.20305859e-01f, 2.64773257e-02f, 4.31363843e-02f, 6.46321177e-02f, 8.61913338e-02f, 1.15863308e-02f,
  -5.62217347e-02f, 2.52614208e-02f, 5.84417656e-02f, 4.47065346e-02f, -1.02630304e-02f, -1.07800230e-01f, -3.41597497e-02f, -3.66734788e-02f, 4.20745574e-02f, -6.55497164e-02f,
  -6.10513091e-02f, -4.48289998e-02f, 3.31191942e-02f, 4.12206613e-02f, -1.23240147e-02f, -3.18158828e-02f, 1.28413020e-02f, 1.03472143e-01f, 3.58829200e-02f, -2.66854931e-03f,
  1.63304750e-02f, 6.34955764e-02f, 1.20456079e-02f, 1.14752270e-01f, 3.20625752e-02f, 9.12085772e-02f, 1.06540145e-02f, -5.11645563e-02f, 5.21713262e-03f, 7.47241639e-03f,
  4.05846760e-02f, 3.78606841e-02f, -8.06675628e-02f, 7.76175782e-02f, 5.24808653e-02f, 2.93912739e-02f, -6.37000576e-02f, 6.04134090e-02f, -1.10958936e-02f, 7.13924542e-02f,
  1.37479916e-01f, -9.25314054e-02f, -1.60663798e-02f, 6.88186660e-02f, 2.35204212e-02f, 3.14261270e-05f, -2.11675968e-02f, 2.89357826e-02f, 1.52714793e-02f, 1.80882402e-02f,
  5.53841442e-02f, 6.87079877e-02f, 8.49224925e-02f, -2.52354331e-02f, -2.99530011e-02f, 1.35375140e-03f, 1.07517913e-02f, 3.15913698e-03f, 2.51115821e-02f, -3.70114646e-03f,
  7.16272071e-02f, 1.28369806e-02f, 6.83058277e-02f, 4.37843837e-02f, -2.63826572e-03f, 2.37237569e-02f, 1.47999953e-02f, -2.54460163e-02f, 3.22827627e-03f, 2.82190759e-02f,
  -6.29657686e-01f, 1.36459440e-01f, 6.97144167e-03f, -3.76809299e-01f, 1.16740800e-01f, -3.71659584e-02f, -1.41864419e-01f, 1.76731169e-01f, -5.27974404e-02f, 1.30639225e-01f,
  1.41260207e-01f, -2.30813652e-01f, 2.09238008e-01f, -1.78755581e-01f, -3.22429299e-01f, -1.00156881e-01f, -2.90584624e-01f, -1.82856083e-01f, -7.13592172e-02f, -1.47512287e-01f,
  -1.80197105e-01f, 9.13776234e-02f, -1.94924682e-01f, 3.07284594e-01f, -9.74139944e-03f, 7.94463698e-03f, -1.15735233e-01f, 1.85783967e-01f, -8.75902548e-02f, 5.42227291e-02f,
  -3.47473323e-02f, 1.33282095e-01f, 7.86737576e-02f, 2.11219098e-02f, -7.26224408e-02f, -3.18763815e-02f, -7.99511150e-02f, 1.63968559e-02f, -2.11332850e-02f, -3.15724425e-02f,
  -1.17303738e-02f, 3.91990383e-04f, -1.27244323e-01f, 7.60194361e-02f, 6.72828406e-02f, 8.02553073e-02f, 8.09986740e-02f, -3.76112871e-02f, -2.64514983e-03f, 3.57832611e-02f,
  5.26007637e-02f, 3.42446007e-02f, -4.05221200e-03f, -5.34013547e-02f, 3.72214392e-02f, 9.69521180e-02f, -6.35680184e-02f, 4.46690917e-02f, 1.88210681e-02f, -1.47438026e-04f,
  -3.82319316e-02f, -6.81938827e-02f, 3.95189635e-02f, 3.51248346e-02f, -1.06612565e-02f, 8.20184946e-02f, -5.44005074e-02f, -1.12543501e-01f, -5.08111306e-02f, -1.20012211e-02f,
  -5.41564636e-02f, -3.25354263e-02f, 7.13611543e-02f, -6.28431439e-02f, 7.36152171e-04f, -8.79444331e-02f, -3.31857242e-02f, 3.75750698e-02f, -1.23665541e-01f, -6.58108443e-02f,
  4.75465059e-02f, -2.72616278e-02f, 3.27507742e-02f, -6.49622530e-02f, 9.95255336e-02f, 1.69243813e-02f, 6.85785199e-03f, 8.93162042e-02f, -8.94095749e-03f, 1.03425048e-02f,
  -1.37616500e-01f, 1.51603520e-02f, 5.61220385e-03f, 1.58042565e-01f, 2.25339853e-03f, -6.78071612e-03f, -8.22744425e-03f, -4.83865477e-02f, -6.55008256e-02f, 4.54543009e-02f,
  2.45247944e-03f, -9.27389693e-03f, -8.34209248e-02f, 2.38484927e-02f, 6.95808157e-02f, -4.57401611e-02f, 1.70080829e-02f, 7.12647010e-03f, -7.20302314e-02f, -1.52413147e-02f,
  8.23307317e-03f, 3.84095870e-02f, -4.79529332e-03f, 2.55684946e-02f, -4.51687612e-02f, -4.09628414e-02f, -5.84256463e-02f, -9.49484576e-03f, 6.05750922e-03f, -6.47976100e-02f,
  -4.64889675e-01f, 3.66661340e-01f, -1.66870371e-01f, 3.00229549e-01f, -9.19080600e-02f, 3.66999090e-01f, 3.37940156e-01f, -6.62867948e-02f, 1.30703703e-01f, 2.51296163e-01f,
  1.43726304e-01f, -1.02365278e-01f, 5.34967482e-02f, 3.52398008e-01f, -1.02386624e-02f, 1.50266230e-01f, 3.03679883e-01f, 2.26308063e-01f, 2.51059514e-03f, -4.54637185e-02f,
  -2.82470826e-02f, 2.22277671e-01f, 6.06174394e-03f, -5.33300340e-02f, 4.12606224e-02f, -1.41791612e-01f, 2.65342221e-02f, -1.44132242e-01f, 1.07611917e-01f, 4.37038429e-02f,
  4.68910374e-02f, -3.89161818e-02f, -1.46279201e-01f, -1.24693185e-01f, -5.57185933e-02f, -7.26277158e-02f, 8.20403695e-02f, -3.94228846e-02f, -1.39913082e-01f, 6.02905639e-02f,
  -8.80667102e-03f, -7.14022890e-02f, -2.54778210e-02f, -2.79264860e-02f, 1.97449252e-02f, 3.69766122e-03f, 7.26116728e-03f, 2.56622136e-02f, -3.03497612e-02f, -8.45642015e-02f,
  -4.57854681e-02f, -1.95152517e-02f, 4.18831259e-02f, 8.84841308e-02f, -5.76524846e-02f, 2.22466514e-02f, 1.03938691e-01f, -3.09938518e-03f, 4.24000286e-02f, -6.92872470e-03f,
  -4.39062491e-02f, -7.51324967e-02f, -1.62815526e-02f, 2.43590642e-02f, 5.26113063e-02f, -4.63053510e-02f, 3.70355994e-02f, 5.44237792e-02f, -5.99132702e-02f, 5.06342202e-02f,
  -6.72506285e-04f, 1.92752238e-02f, -8.01166221e-02f, -1.18866805e-02f, 1.45989691e-03f, 3.95289697e-02f, -4.91801761e-02f, -3.72783355e-02f, 4.85466532e-02f, 9.24112871e-02f,
  2.65065096e-02f, 2.61302236e-02f, 1.28681147e-02f, 4.50698696e-02f, 1.41396880e-01f, -5.28800674e-02f, 6.85046762e-02f, -1.31499050e-02f, -2.73874798e-03f, -6.84241802e-02f,
  2.32028306e-01f, 2.73423374e-01f, 5.33558279e-02f, 2.19812337e-02f, 1.13145962e-01f, -5.62676936e-02f, 4.52212580e-02f, -2.25302670e-02f, 4.52014655e-02f, -6.29752036e-03f,
  -5.81642464e-02f, 2.76902337e-02f, -7.27951303e-02f, -4.12575230e-02f, 4.08151234e-03f, 2.14439481e-02f, 5.34528717e-02f, 9.86390486e-02f, 1.36032864e-01f, 2.52345484e-02f,
  7.32243657e-02f, -2.70518884e-02f, -5.85988797e-02f, 3.31696495e-02f, -3.10053048e-03f, 1.92160148e-03f, -2.47459449e-02f, -5.74981421e-02f, -9.01637971e-02f, 5.47951125e-02f,
  6.07995577e-02f, -5.94223626e-02f, -1.88478842e-01f, -1.62794277e-01f, -2.56474644e-01f, -1.45189315e-01f, -1.97588444e-01f, -6.02239743e-02f, -7.59584233e-02f, 1.31864429e-01f,
  5.59570221e-03f, 5.76729774e-02f, 5.18927760e-02f, -6.16721204e-03f, -1.15080357e-01f, 1.94025844e-01f, 7.89067373e-02f, 1.23151310e-01f, 5.45561574e-02f, 6.43184185e-02f,
  9.43839476e-02f, -8.66000075e-04f, 8.16738382e-02f, -4.62141931e-02f, -5.20330369e-02f, 1.62718639e-01f, 1.76889539e-01f, -1.48270175e-01f, 4.75451499e-02f, -8.81592259e-02f,
  2.44879015e-02f, 1.68127716e-01f, 1.63042396e-02f, 1.11264355e-01f, 2.01637477e-01f, 3.82238552e-02f, -8.02061521e-03f, -1.05758458e-01f, 2.57113036e-02f, 9.98918433e-03f,
  1.14045046e-01f, 2.90274508e-02f, 6.89857677e-02f, -1.61628928e-02f, -1.33238817e-02f, -6.49994751e-03f, -2.94005871e-02f, -1.10062538e-03f, 6.92280829e-02f, 2.42812606e-03f,
  -6.05936609e-02f, 5.70536517e-02f, 1.17879380e-02f, 1.20319694e-01f, -3.53631005e-02f, -4.51265275e-03f, 2.70840246e-02f, 3.26867439e-02f, 1.39826074e-01f, 3.70940864e-02f,
  -2.24319976e-02f, -9.31203458e-03f, -1.46171972e-02f, -3.65958400e-02f, -1.11068748e-02f, -7.28827193e-02f, -7.23186508e-02f, -7.94480816e-02f, -8.23898911e-02f, 4.72648777e-02f,
  -2.14864928e-02f, -3.96921821e-02f, 4.79571633e-02f, 1.29911870e-01f, 2.04432048e-02f, 2.08749697e-02f, -9.26379338e-02f, -4.18684725e-03f, -1.64586052e-01f, -5.38031794e-02f,
  5.73468469e-02f, -1.62132233e-02f, -7.58796604e-03f, -1.70023628e-02f, 1.13584017e-02f, 5.53998500e-02f, 1.08061314e-01f, -5.54526737e-03f, -7.58610219e-02f, 9.78410151e-03f,
  1.11460947e-01f, 2.02042088e-01f, 6.58468679e-02f, -5.55435084e-02f, 1.16214037e-01f, 2.80019026e-02f, -2.01998297e-02f, 4.35701832e-02f, 2.41466872e-02f, 1.63978972e-02f,
  7.20716864e-02f, -2.47851666e-02f, 1.44486383e-01f, -6.76323473e-03f, -5.53175732e-02f, 1.10997409e-01f, -1.64483711e-02f, 1.04066126e-01f, -1.02172978e-01f, -1.03682429e-02f,
  -3.24573182e-02f, 9.28999335e-02f, 5.89979813e-02f, -8.77361298e-02f, -6.65039793e-02f, 2.05187816e-02f, 2.25982331e-02f, 5.73295727e-02f, 3.92555520e-02f, 1.33347780e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  7.39279613e-02f, 1.38584271e-01f, 3.30982119e-01f, 1.29923224e-01f, 3.50593835e-01f, 2.69769013e-01f, 3.14715028e-01f, 2.15737432e-01f, 2.81394511e-01f, 2.21779644e-01f,
  1.87178463e-01f, 2.08785478e-02f, 3.41020614e-01f, 1.03718638e-01f, 2.82832295e-01f, 1.84449926e-01f, 1.12986133e-01f, 2.66633928e-01f, 2.79764801e-01f, 4.02788639e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.28560722e-01f, -4.09534834e-02f, -2.10714657e-02f, 1.30005956e-01f, -6.59660948e-03f, 2.55864896e-02f, -5.23110554e-02f, -3.86467069e-01f, -2.93870479e-01f, -7.24501163e-02f,
  -1.15242355e-01f, -5.10555208e-02f, 2.53501922e-01f, -9.98110846e-02f, -1.00521334e-01f, 1.87956452e-01f, 2.07927465e-01f, -2.31596723e-01f, 6.26992136e-02f, -1.43254146e-01f,
  -1.68045759e-01f, 1.89621672e-01f, 1.15269810e-01f, -7.01495856e-02f, -1.54760620e-02f, -2.89124530e-02f, 2.85285227e-02f, 3.21781486e-01f, -8.86120349e-02f, -1.23586066e-01f,
  1.11898787e-01f, -7.24709406e-02f, -1.30567253e-01f, 1.53188735e-01f, 2.99209380e-03f, -2.74400681e-01f, 7.77869448e-02f, -2.45331950e-03f, -9.58027132e-03f, 5.06462790e-02f,
  -1.31426170e-01f, -1.01016745e-01f, 3.03252451e-02f, -3.16209733e-01f, 1.63960442e-01f, 1.11439086e-01f, -1.81129873e-02f, 3.30979973e-02f, 1.06427021e-01f, 2.36799926e-01f,
  1.34148851e-01f, -1.40798286e-01f, 2.77577013e-01f, -3.64736944e-01f, 1.09819204e-01f, 1.02465414e-01f, 1.06873177e-01f, -1.59363464e-01f, -4.94975187e-02f, -2.52325594e-01f,
  -1.19881481e-01f, -2.30125770e-01f, -2.43339479e-01f, -1.33494306e-02f, 6.37006462e-02f, 4.51485887e-02f, 6.37946278e-02f, 1.08855709e-01f, -4.95114215e-02f, -1.46680504e-01f,
  -8.43225792e-02f, 9.72780138e-02f, 4.83765900e-02f, 2.42006898e-01f, -2.44029462e-02f, 2.59400040e-01f, -1.13527045e-01f, -3.07249259e-02f, 2.24153951e-01f, 6.37034280e-03f,
  -1.07626811e-01f, 1.12797888e-02f, -2.18729079e-01f, -1.13526188e-01f, -2.74879187e-01f, 2.24199861e-01f, -1.92052007e-01f, 2.20403090e-01f, 2.78109908e-02f, 5.91709130e-02f,
  5.70801757e-02f, 6.21272437e-02f, -8.10933709e-02f, 1.55215785e-01f, 8.17075074e-02f, 1.32732034e-01f, -2.38776766e-02f, 1.26591831e-01f, -1.36158273e-01f, -2.78831989e-01f,
  -4.45790701e-02f, -7.18844235e-02f, 5.81489243e-02f, 7.43030608e-02f, -1.42693967e-01f, -2.87212040e-02f, 1.15906134e-01f, -3.35663319e-01f, 1.57171771e-01f, 1.28619239e-01f,
  4.15935880e-03f, -1.00232609e-01f, -1.32779613e-01f, 1.40006870e-01f, -7.78594092e-02f, -1.27247229e-01f, 2.64734626e-01f, -4.12537187e-01f, 3.22359311e-03f, 1.82078943e-01f,
  -1.61790755e-02f, -1.43310010e-01f, -9.99704078e-02f, -2.36297160e-01f, -1.23911314e-01f, -2.75032640e-01f, -7.77565986e-02f, -2.70053186e-02f, -1.48765489e-01f, -6.74795285e-02f,
  1.26290515e-01f, -7.56418481e-02f, -5.76774441e-02f, 2.20700353e-02f, 2.36346871e-01f, -1.00346915e-01f, -9.75781828e-02f, -8.13602954e-02f, 2.58237064e-01f, -1.56970933e-01f,
  1.17778718e-01f, 1.17512919e-01f, -2.21186817e-01f, 8.25366005e-02f, 4.01590131e-02f, -4.14052755e-02f, -1.71408504e-01f, -5.17853312e-02f, 1.14963546e-01f, 9.50727910e-02f,
  1.42911538e-01f, -2.75152862e-01f, 9.70412940e-02f, 1.17613710e-01f, 7.95078427e-02f, 6.13024086e-02f, 2.26068310e-02f, -1.54003292e-01f, 2.55100042e-01f, -1.47202685e-01f,
  1.52788416e-01f, 9.46230143e-02f, -9.28463265e-02f, 1.48691371e-01f, 1.55025750e-01f, 1.59678534e-02f, -1.19135976e-01f, 1.69809178e-01f, 1.60320729e-01f, -5.55832125e-02f,
  -9.29855406e-02f, 1.24191474e-02f, -1.80231929e-01f, -2.28681400e-01f, 1.75322115e-01f, 2.76109725e-02f, -2.23548934e-01f, 2.06826255e-02f, 1.27064943e-01f, -1.20621361e-02f,
  3.37949507e-02f, 1.87643021e-01f, -2.17558175e-01f, 6.27969503e-02f, 1.84002742e-01f, -2.01385781e-01f, -1.62116662e-01f, -9.87443328e-03f, 2.01002464e-01f, 6.85947090e-02f,
  1.49142340e-01f, 2.64406148e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.52616256e-01f, -3.17957345e-03f, 2.28169903e-01f, -3.64801176e-02f, 2.23807588e-01f, 8.20799321e-02f, 2.45763376e-01f, 2.56622672e-01f, 3.60736787e-01f, 1.06828034e-01f,
  -1.85532063e-01f, 2.19622329e-01f, -1.06775068e-01f, 2.34987773e-02f, 2.52982706e-01f, -1.98707819e-01f, -3.42330396e-01f, 4.04129714e-01f, 1.17886849e-01f, 3.29921722e-01f,
  2.14008823e-01f, 4.61318880e-01f, -1.03078209e-01f, 2.02755913e-01f, 1.27336755e-01f, -1.47280902e-01f, -8.98948908e-02f, 7.53827766e-02f, 1.58658385e-01f, 4.63253379e-01f,
  1.17380142e-01f, 2.76410818e-01f, 1.00487508e-01f, 1.01479352e-01f, 2.40008727e-01f, 2.71603763e-01f, 3.02937061e-01f, 1.37025952e-01f, 1.98180586e-01f, -4.95070554e-02f,
  4.03895266e-02f, -3.80175382e-01f, -2.17727050e-02f, -1.31653607e-01f, 6.04058146e-01f, -2.24448025e-01f, 5.51963970e-02f, -1.18196055e-01f, 2.08079576e-01f, 6.32179230e-02f,
  2.47775376e-01f, 4.92664754e-01f, 2.84131914e-01f, 1.93751976e-01f, 1.68483898e-01f, -2.26781100e-01f, -1.70555353e-01f, 2.17646480e-01f, 3.16569984e-01f, -9.59929451e-02f,
  4.49310422e-01f, 3.45996559e-01f, -3.26682836e-01f, -8.13057721e-02f, 4.26391602e-01f, 3.77466261e-01f, 4.49629188e-01f, 3.03683639e-01f, 2.01123208e-01f, 2.89357662e-01f,
  -3.65519404e-01f, -3.49583209e-01f, -1.05629660e-01f, -4.32800293e-01f, -4.71541822e-01f, 3.37296009e-01f, 3.43784571e-01f, -1.51812494e-01f, 6.84228241e-02f, -7.45592117e-02f,
  4.28698957e-01f, -7.94607401e-02f, 4.54029560e-01f, 1.41187817e-01f, 1.95720404e-01f, -2.74666935e-01f, 4.44612987e-02f, -1.62991822e-01f, -6.15580417e-02f, -7.13401064e-02f,
  -9.56439301e-02f, -2.53015816e-01f, 7.04789683e-02f, 7.35688359e-02f, -2.70449519e-01f, 4.35803458e-02f, 2.21838549e-01f, 3.02558124e-01f, 3.95543203e-02f, 1.42684966e-01f,
  -5.70521504e-02f, 1.44811898e-01f, -7.54767582e-02f, -2.68415183e-01f, -2.27106392e-01f, 1.46893859e-01f, -8.35663080e-02f, 2.24622712e-01f, -2.14834943e-01f, 1.40828907e-01f,
  1.52342632e-01f, 3.51206273e-01f, -9.67054740e-02f, -5.77094145e-02f, -3.91836226e-01f, -2.21043006e-01f, -8.33116323e-02f, 1.36409685e-01f, -1.63636282e-01f, 6.35219645e-03f,
  1.59237906e-01f, 7.72936568e-02f, -6.61685690e-03f, 5.26697218e-01f, -1.90709829e-01f, 1.74158886e-02f, 4.67392325e-01f, 3.13594550e-01f, 2.06461295e-01f, 1.71790943e-01f,
  1.34248599e-01f, 7.75264427e-02f, 2.30126411e-01f, 2.03671884e-02f, -1.09541388e-02f, 3.57655287e-01f, 3.69975805e-01f, -2.89976667e-03f, -2.82390535e-01f, 9.03387517e-02f,
  -1.38620123e-01f, 1.59822807e-01f, 3.25180054e-01f, -1.80451289e-01f, -3.64306509e-01f, 4.24453586e-01f, 5.84037639e-02f, 3.23491096e-01f, 2.51485527e-01f, 2.67226517e-01f,
  -2.56487548e-01f, 2.00496420e-01f, 1.44244999e-01f, -1.48280367e-01f, 2.89354976e-02f, 1.91761050e-02f, 2.04429865e-01f, 5.08627355e-01f, -1.59247834e-02f, 2.13889197e-01f,
  -1.21164270e-01f, -6.77484870e-02f, -4.56861220e-02f, -2.31455117e-01f, -1.21932141e-01f, 1.68896422e-01f, 2.35711902e-01f, -6.40669689e-02f, 1.35989666e-01f, 3.02098364e-01f,
  1.92181751e-01f, -1.65346757e-01f, 7.85636902e-02f, 4.41241235e-01f, -2.20905319e-01f, -1.86861604e-01f, -8.97478983e-02f, 1.53636768e-01f, 3.39835435e-01f, -6.50134981e-02f,
  2.13019684e-01f, -1.53773353e-01f, 4.55238789e-01f, -2.57474612e-02f, -1.59565695e-02f, -1.11821607e-01f, 3.49131614e-01f, 8.91539603e-02f, -1.51945561e-01f, -7.41071925e-02f,
  6.08802848e-02f, 1.62979513e-02f, 2.42521092e-01f, 1.93398327e-01f, 2.40067765e-01f, 2.80668378e-01f, 1.27472445e-01f, 1.83682889e-01f, -2.65093505e-01f, -2.57374227e-01f,
  -2.44759068e-01f, 1.36084929e-01f, 1.25545397e-01f, 8.82437360e-03f, 3.22085284e-02f, 1.87533259e-01f, 7.50666065e-03f, 4.03251022e-01f, 5.00513554e-01f, -1.20140165e-01f,
  2.09061846e-01f, 5.25965802e-02f, -1.00561939e-01f, 8.21110979e-02f, 1.84886053e-01f, 1.50922641e-01f, 2.60339946e-01f, 3.93925518e-01f, 3.12066883e-01f, 2.38092214e-01f,
  -6.13320619e-02f, -2.02436343e-01f, 3.55840504e-01f, 2.54140466e-01f, 4.04829025e-01f, 2.14821115e-01f, 3.14298362e-01f, 3.34380180e-01f, 1.23924285e-01f, 2.90884376e-01f,
  -3.02207202e-01f, -2.36742139e-01f, 2.09059700e-01f, 9.58843529e-02f, -2.98471630e-01f, 5.79643250e-01f, -1.73686028e-01f, -3.67014334e-02f, 2.97118068e-01f, 5.11056185e-02f,
  1.61085371e-02f, -1.15282945e-01f, 3.21285099e-01f, -1.99057367e-02f, -2.80427694e-01f, 8.07254463e-02f, 1.51875600e-01f, -4.51011099e-02f, 2.50929892e-01f, 1.51196331e-01f,
  3.73024166e-01f, -1.61296442e-01f, 1.58902016e-02f, 4.71423566e-01f, 4.57056332e-03f, 3.85948010e-02f, 1.02975346e-01f, 8.77658557e-03f, 1.50563598e-01f, 8.26802626e-02f,
  -1.75425649e-01f, 9.37203467e-02f, 1.90538019e-01f, -1.93794563e-01f, 6.48966879e-02f, 2.87306041e-01f, 3.47654849e-01f, -1.12399526e-01f, 3.08967412e-01f, 4.75088835e-01f,
  -3.52355242e-01f, 1.81573004e-01f, 3.22764926e-02f, -8.87578260e-03f, -6.52316632e-03f, 2.39693686e-01f, -1.32592350e-01f, 9.11495090e-02f, 5.43186665e-01f, -1.32224619e-01f,
  -2.78908104e-01f, 5.93830585e-01f, 6.07451558e-01f, 3.34524065e-01f, -8.69266391e-02f, -4.08937149e-02f, 2.15171292e-01f, 1.31863117e-01f, -1.26115736e-02f, -2.12165415e-01f,
  4.36922833e-02f, 1.88975379e-01f, 1.95888877e-01f, 1.12977162e-01f, 2.41039142e-01f, 1.32552534e-01f, 2.27795839e-01f, 8.87445211e-02f, 1.43304527e-01f, 2.36219242e-01f,
  -1.46121413e-01f, -2.05865815e-01f, 1.41787991e-01f, -2.70460863e-02f, -2.97090322e-01f, -7.77936652e-02f, -1.99652210e-01f, 4.11952406e-01f, -1.43642366e-01f, 5.63048303e-01f,
  -3.33226055e-01f, -1.68560550e-01f, 4.08508182e-02f, 1.88931152e-01f, 1.69166297e-01f, 1.50184542e-01f, 3.66868198e-01f, 2.84643203e-01f, 2.51828343e-01f, 1.40002295e-01f,
  1.01302773e-01f, -4.47707102e-02f, 1.23430364e-01f, 1.53168133e-02f, -3.37350182e-02f, 1.69610336e-01f, 5.52312806e-02f, -3.35033275e-02f, 2.69907564e-01f, 1.98974937e-01f,
  -2.00971320e-01f, 2.21635312e-01f, 7.25355884e-03f, 1.51085034e-01f, 3.31720561e-01f, -9.83645841e-02f, -2.43043110e-01f, 1.14359185e-01f, -6.97614774e-02f, -2.35597193e-02f,
  -9.42332298e-02f, 3.05766582e-01f, 1.19291469e-01f, 8.63022432e-02f, 1.45480290e-01f, -2.89682329e-01f, -1.72217667e-01f, 6.74072653e-02f, -1.19821951e-01f, 3.41773838e-01f,
  2.22209515e-03f, 9.67521593e-02f, 3.79414767e-01f, 2.48152539e-01f, 2.07093909e-01f, 3.39266241e-01f, 1.32937849e-01f, 1.14483334e-01f, -1.69074342e-01f, -2.55901247e-01f,
  -7.48244226e-02f, -2.16200903e-01f, -4.06858891e-01f, 2.90041536e-01f, 2.37400867e-02f, -1.68095753e-01f, 3.69429946e-01f, 1.13873214e-01f, 4.37300056e-01f, 3.70892808e-02f,
  2.88971007e-01f, -1.47702649e-01f, 8.22271928e-02f, 7.31923282e-02f, -9.07120630e-02f, 1.05012976e-01f, 3.02426934e-01f, -1.98085830e-01f, -2.34314546e-01f, -5.92990667e-02f,
  -8.89274701e-02f, 1.56611070e-01f, 1.00686662e-01f, 1.01642489e-01f, 3.31778377e-01f, 3.06296766e-01f, 1.05039075e-01f, 6.84734387e-03f, 6.41083270e-02f, 7.95837492e-02f,
  -1.31940186e-01f, 1.11191258e-01f, 1.52422152e-02f, -7.22046010e-03f, -1.38360113e-01f, -1.65360589e-02f, -2.28073493e-01f, 7.96105117e-02f, 3.91993105e-01f, 2.60006517e-01f,
  -1.74330235e-01f, 2.27752015e-01f, -7.60576800e-02f, -2.11106375e-01f, 2.17187833e-02f, 1.08064644e-01f, -3.31656858e-02f, 2.48901159e-01f, 3.98056507e-01f, -2.35558912e-01f,
  -6.49331808e-02f, 2.04019934e-01f, 5.95869757e-02f, 3.38148862e-01f, 3.40628535e-01f, 9.78470743e-02f, 6.59454390e-02f, 2.24609330e-01f, 3.44332345e-02f, 1.83263466e-01f,
  6.86125234e-02f, 7.44087398e-02f, -2.33297385e-02f, -7.94444084e-02f, -3.07046860e-01f, -1.06535576e-01f, 1.72250226e-01f, -3.12680066e-01f, 9.78566259e-02f, -3.28414030e-02f,
  -7.05772713e-02f, 5.10086596e-01f, 1.61323071e-01f, -5.69009688e-03f, -2.43213013e-01f, -1.39921188e-01f, 1.99055336e-02f, 3.07886928e-01f, -8.04820582e-02f, -1.01283364e-01f,
  3.83782357e-01f, -3.90279782e-03f, -1.51785553e-01f, 3.68212819e-01f, -7.34324893e-03f, -2.77265966e-01f, 4.57907915e-01f, 1.14262477e-02f, 1.79774523e-01f, 1.75180182e-01f,
  4.36290586e-03f, -7.40015805e-02f, 2.27050170e-01f, -2.43518874e-02f, 8.35899115e-02f, 3.87966275e-01f, 8.41237307e-02f, 8.82771239e-02f, -1.02473699e-01f, -2.15936005e-01f,
  -2.43450478e-01f, 3.38117145e-02f, 3.85953248e-01f, -1.13221176e-01f, -1.50181353e-01f, 4.29500222e-01f, 1.48518637e-01f, 1.12784714e-01f, 3.56716186e-01f, 1.40296638e-01f,
  -4.10645865e-02f, 4.45319444e-01f, 4.54286158e-01f, -3.41483116e-01f, -1.27381921e-01f, -8.60468820e-02f, 8.30021128e-03f, 1.43421263e-01f, 2.81374931e-01f, 3.52284223e-01f,
  7.73133337e-02f, 3.82880390e-01f, -2.57031322e-02f, -2.19690293e-01f, 2.79823452e-01f, -6.71751648e-02f, -7.96208158e-02f, 3.86892438e-01f, -1.91225052e-01f, -1.89408571e-01f,
  3.43674980e-02f, -5.63059926e-01f, 1.37688061e-02f, -1.10796271e-02f, 1.63141504e-01f, 6.94877431e-02f, 1.44182310e-01f, 4.42716420e-01f, 4.27064478e-01f, 1.08059971e-02f,
  5.27327895e-01f, -3.39903653e-01f, 1.80002376e-01f, 5.02505183e-01f, 4.65508074e-01f, -1.67440116e-01f, 7.86083657e-03f, 1.95902437e-02f, -1.86024215e-02f, -2.29716241e-01f,
  1.34258837e-01f, 2.75774240e-01f, -8.89748558e-02f, 3.03232908e-01f, 4.30754460e-02f, -1.25139803e-01f, 1.27368495e-01f, 1.55873373e-01f, 2.41803333e-01f, 9.67009142e-02f,
  -1.41517609e-01f, -5.08520722e-01f, 9.80898067e-02f, -4.41999614e-01f, 4.49608177e-01f, 1.34717032e-01f, -1.21186748e-01f, 4.24718298e-02f, 6.51157647e-03f, 3.40435237e-01f,
  9.67364106e-03f, 2.38639250e-01f, 5.22207201e-01f, -1.19642951e-01f, 8.14639404e-02f, -1.76427826e-01f, 1.53164357e-01f, -9.30284634e-02f, -3.13975483e-01f, 2.44349483e-02f,
  2.17984885e-01f, -2.54509628e-01f, -3.16365138e-02f, 5.86810932e-02f, 2.77571470e-01f, 2.88515985e-01f, 2.62487605e-02f, 2.09024653e-01f, 5.57621643e-02f, 1.50358319e-01f,
  -1.84221283e-01f, -8.11053663e-02f, -1.12945393e-01f, -7.86085986e-03f, -2.18127832e-01f, 1.75787687e-01f, -2.16798320e-01f, 8.13695788e-02f, 3.89470726e-01f, 1.84247300e-01f,
  2.80141067e-02f, -8.21625628e-03f, -2.07300901e-01f, -2.57690966e-01f, -5.80158606e-02f, 2.95391679e-01f, -2.36551976e-03f, 1.53457016e-01f, 2.85291493e-01f, -1.73372880e-01f,
  -1.99202269e-01f, 3.56022000e-01f, -1.84585705e-01f, 2.15080038e-01f, 3.82511109e-01f, 3.15613419e-01f, 9.91051570e-02f, 3.35100859e-01f, 1.72228411e-01f, -5.01868874e-02f,
  7.27430061e-02f, 1.63228035e-01f, 1.12527339e-02f, -4.46810722e-02f, -1.62913665e-01f, -3.63737881e-01f, 2.80219525e-01f, -4.28597242e-01f, 4.95822579e-01f, 1.76130772e-01f,
  -2.26976171e-01f, 2.46512458e-01f, 2.68094450e-01f, 4.90289629e-02f, -1.42667741e-01f, 3.24349493e-01f, 2.89963335e-01f, -1.16591580e-01f, 1.45346239e-01f, -1.22390486e-01f,
  -1.16808616e-01f, 2.05043346e-01f, 7.81268701e-02f, 1.84196725e-01f, 2.48797804e-01f, -1.71887115e-01f, -4.22858931e-02f, 8.34439415e-03f, 2.41988793e-01f, 1.03121422e-01f,
  2.06373543e-01f, 4.68518846e-02f, -1.23885153e-02f, 7.52319396e-02f, 5.81831709e-02f, 7.07377344e-02f, 1.42416313e-01f, 3.61582488e-01f, 3.45514208e-01f, -2.44545519e-01f,
  -2.34267697e-01f, 4.42791969e-01f, -9.78955552e-02f, 3.03699195e-01f, 1.26424087e-02f, 7.78117925e-02f, 1.04328677e-01f, 2.17753857e-01f, 2.70502828e-02f, 1.94753051e-01f,
  2.65532404e-01f, 1.31380618e-01f, 1.33488864e-01f, 2.29333624e-01f, 5.08508384e-01f, 2.22039998e-01f, -2.18781251e-02f, -1.44923121e-01f, 4.20001537e-01f, 2.16128334e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  7.12483898e-02f, 2.68159389e-01f, 4.52959090e-01f, 1.59687087e-01f, 2.16882169e-01f, -3.17203738e-02f, 4.02674943e-01f, 2.71151751e-01f, 1.13387115e-01f, 5.42782713e-03f,
  1.53450385e-01f, 2.61655599e-01f, 1.69305712e-01f, 9.30494964e-02f, 1.61681145e-01f, 2.66424209e-01f, 1.54404417e-01f, 2.21173048e-01f, 3.21440369e-01f, 1.51702806e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -2.92909145e-02f, 3.77149205e-03f, -4.82282750e-02f, -4.60455045e-02f, -4.42404486e-02f, -1.60414666e-01f, -1.06361240e-01f, 1.94805548e-01f, -7.00413659e-02f, 2.53857076e-01f,
  1.68781221e-01f, -8.52266029e-02f, 1.63310871e-01f, -4.81429597e-04f, -1.96639791e-01f, 5.24268746e-02f, -5.45969307e-02f, 2.51909375e-01f, -1.80177063e-01f, -1.94163293e-01f,
  -2.01743633e-01f, 1.42699601e-02f, 1.25953645e-01f, -1.09644555e-01f, 1.27313673e-01f, 1.21413752e-01f, 1.69127285e-01f, 1.62836313e-01f, 1.24750501e-02f, 4.84962128e-02f,
  -8.95577371e-02f, 9.91140455e-02f, -1.93893965e-02f, 6.84752390e-02f, -6.79266602e-02f, -4.53126132e-02f, 7.39286989e-02f, 6.22332580e-02f, -7.09230006e-02f, -2.53853817e-02f,
  1.23026691e-01f, -2.65524816e-03f, -8.08419660e-02f, 1.21400006e-01f, 2.17858911e-01f, -3.30593344e-03f, 1.32446542e-01f, -4.84118350e-02f, 1.53097942e-01f, -1.94559038e-01f,
  7.02705979e-03f, 7.87537396e-02f, -1.46579355e-01f, 1.95528775e-01f, 8.58812854e-02f, 1.27398759e-01f, 5.47281280e-02f, -1.96555287e-01f, 5.80280088e-02f, -9.39722285e-02f,
  -1.54958650e-01f, 1.04512870e-01f, -1.39557257e-01f, -7.58376196e-02f, 1.97190363e-02f, 1.35168806e-01f, 1.89243451e-01f, 1.00877143e-01f, 1.16346523e-01f, 9.79455933e-02f,
  4.40692753e-02f, -1.75677046e-01f, 1.06054284e-01f, -2.89518416e-01f, -1.42585725e-01f, -3.01080644e-02f, -9.52075571e-02f, 2.26826414e-01f, 1.51808381e-01f, -9.73983780e-02f,
  8.11234117e-02f, -9.74902362e-02f, 4.53690998e-02f, 1.35398433e-01f, 4.90323342e-02f, -4.08846997e-02f, -3.23520675e-02f, 1.79082863e-02f, 4.33437452e-02f, 2.39700526e-02f,
  -6.80093616e-02f, -8.88935030e-02f, -4.66258675e-02f, -6.07360899e-02f, 1.66668922e-01f, -9.09125507e-02f, 5.58660328e-02f, 1.29439868e-02f, 9.05250907e-02f, -3.40145156e-02f,
  8.85162875e-02f, 3.50698233e-02f, 7.88764879e-02f, -8.24690983e-03f, -5.42072877e-02f, -9.50614735e-03f, -9.38281044e-02f, -2.53964588e-02f, -1.06343366e-01f, 1.10966817e-01f,
  1.95012286e-01f, 1.14326179e-02f, 5.42059280e-02f, -1.23211525e-01f, -7.13702813e-02f, 4.78670299e-02f, -1.69532210e-01f, -7.65176490e-02f, -1.38187021e-01f, -8.18155799e-03f,
  -1.28845274e-01f, 2.02017892e-02f, -1.39253125e-01f, 2.91300770e-02f, 2.06701890e-01f, -2.20008671e-01f, 1.68571159e-01f, -7.09430352e-02f, -4.34736162e-02f, -1.33580893e-01f,
  -1.75702572e-01f, 6.59018978e-02f, -9.15612057e-02f, 1.00343592e-01f, 1.78144425e-01f, 1.04708493e-01f, -1.29081592e-01f, 2.35737175e-01f, 1.62850261e-01f, -9.05711129e-02f,
  7.24137351e-02f, -5.96077368e-02f, -2.30015904e-01f, 1.37329116e-01f, -1.22531533e-01f, 2.49138940e-02f, 7.07935542e-02f, -2.48191014e-01f, 1.46105692e-01f, -7.01302215e-02f,
  -7.36253113e-02f, 2.74417363e-02f, 1.02327764e-01f, 1.80527747e-01f, 7.37440884e-02f, 2.10592151e-01f, 2.20674768e-01f, -3.87150347e-02f, 1.12803370e-01f, 8.72762129e-03f,
  -1.63352609e-01f, -1.77112028e-01f, -1.79627985e-01f, -4.90978695e-02f, -2.24677175e-02f, -8.06965381e-02f, -1.51357725e-01f, -6.42976016e-02f, 1.50875375e-01f, 9.11996588e-02f,
  2.40490492e-02f, -4.89184225e-04f, 1.81847945e-01f, 1.86829597e-01f, -6.58375025e-02f, 1.84769958e-01f, 4.51056324e-02f, -1.57073900e-01f, -1.61121666e-01f, -8.36398602e-02f,
  1.52548421e-02f, 2.32089415e-01f, 9.45783332e-02f, -1.65122330e-01f, 1.42425997e-02f, 8.97139609e-02f, -7.67995641e-02f, -2.40352526e-01f, 6.01582564e-02f, 3.80078778e-02f,
  1.57323852e-02f, -1.71402797e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -5.87937273e-02f, -2.79670030e-01f, -8.40596259e-02f, -6.81947097e-02f, -3.03816386e-02f, -7.84703493e-02f, -3.30598801e-01f, 2.59244084e-01f, -2.20416620e-01f, 2.03435525e-01f,
  1.91568598e-01f, 2.04717100e-01f, 4.70491379e-01f, 3.46817106e-01f, -7.85140246e-02f, -1.23734683e-01f, 4.23119068e-01f, 6.15592971e-02f, -5.75714931e-02f, -2.00982302e-01f,
  -1.28521100e-01f, 5.64244151e-01f, -9.63129550e-02f, -1.79667920e-02f, -7.94935077e-02f, 2.17730448e-01f, 5.70344508e-01f, 4.11989450e-01f, 5.16881943e-01f, -1.32712126e-01f,
  1.63036153e-01f, 1.15498744e-01f, 3.59181345e-01f, 3.22953939e-01f, 8.20085630e-02f, 3.29378843e-01f, 8.22227448e-03f, 3.49041559e-02f, -5.57052419e-02f, 2.19125688e-01f,
  -8.17989409e-02f, -8.90332833e-02f, -2.29249507e-01f, 3.77001077e-01f, 1.49681747e-01f, 2.14121655e-01f, 3.14431638e-01f, -1.38140529e-01f, 2.29749411e-01f, -2.56221145e-01f,
  -3.36365253e-02f, 4.14454937e-02f, -5.45631230e-01f, -3.04736942e-01f, -4.70160916e-02f, 2.32192680e-01f, 3.47429842e-01f, -1.36213109e-01f, 3.68755311e-01f, 5.62953770e-01f,
  3.23608994e-01f, 1.54922649e-01f, 1.94995940e-01f, -8.12500119e-02f, 2.23611593e-01f, 3.83461505e-01f, 1.08333245e-01f, 2.30258927e-01f, 2.65001386e-01f, 1.79493234e-01f,
  2.48809591e-01f, 1.02630846e-01f, -1.75544500e-01f, -2.30875805e-01f, 3.58114578e-02f, 1.30647808e-01f, -2.57264555e-01f, 4.04160440e-01f, 6.22355759e-01f, -1.14151835e-01f,
  -1.32146895e-01f, -1.98133796e-01f, 2.68432289e-01f, 1.18992046e-01f, -1.00021929e-01f, -3.15900475e-01f, -2.01004446e-01f, 4.38631088e-01f, 5.86794913e-02f, 2.45368645e-01f,
  -5.73621467e-02f, 4.43791479e-01f, 3.03798050e-01f, 6.79834187e-02f, 3.94847840e-01f, -1.96658909e-01f, -2.96484772e-02f, -1.31140007e-02f, 1.07725978e-01f, -1.22241385e-01f,
  2.36052066e-01f, 1.19948924e-01f, 1.23415068e-01f, -1.28722265e-01f, -4.19121385e-02f, -1.71685249e-01f, 3.28223221e-02f, -7.27847517e-02f, 1.49579376e-01f, 5.66549301e-01f,
  4.13798124e-01f, 1.48046777e-01f, 1.54784322e-01f, -3.66534889e-01f, 1.72522530e-01f, 1.33817732e-01f, 8.65948573e-02f, 4.15531993e-01f, -4.10764180e-02f, 1.97333947e-01f,
  -1.78247504e-02f, 1.84557185e-01f, -2.28115052e-01f, -2.91624159e-01f, 2.06720844e-01f, 1.31291464e-01f, 3.04056138e-01f, -5.24212159e-02f, 1.41917005e-01f, 6.30422682e-02f,
  2.36809611e-01f, -3.43958139e-02f, 2.30392665e-01f, -5.94103932e-02f, 2.94300407e-01f, -1.51625667e-02f, 1.21479101e-01f, -2.73369730e-01f, -2.45115817e-01f, 2.25402251e-01f,
  3.07596922e-01f, -1.11411601e-01f, 2.92136878e-01f, 2.68814098e-02f, 4.40772772e-02f, -9.23431218e-02f, 1.22932233e-01f, 4.54646766e-01f, -4.39417273e-01f, 2.94584148e-02f,
  2.32224807e-01f, 5.30191720e-01f, 3.46908599e-01f, 6.36090189e-02f, 1.70316666e-01f, 6.81523560e-03f, -2.70353675e-01f, 3.05073529e-01f, -3.87357384e-01f, -2.49898627e-01f,
  1.85803682e-01f, -8.95347372e-02f, -3.85086723e-02f, 1.15469374e-01f, -7.90017769e-02f, -4.88822535e-02f, -6.08729944e-02f, 2.63537187e-02f, 1.66095406e-01f, 1.47885725e-01f,
  1.02469780e-01f, 2.07939968e-01f, 2.71566123e-01f, -3.95305544e-01f, -3.57509524e-01f, 3.25600237e-01f, 2.51245439e-01f, 1.26745448e-01f, 1.73020050e-01f, 1.49426848e-01f,
  -1.85351700e-01f, 8.95875171e-02f, 3.53068322e-01f, 1.34260297e-01f, 5.37651837e-01f, 3.64187032e-01f, 6.02832317e-01f, 4.25448388e-01f, 3.76103707e-02f, 4.14393067e-01f,
  -2.58368969e-01f, 1.42873988e-01f, 8.07245821e-03f, 2.50978678e-01f, 1.67203829e-01f, 3.57772671e-02f, -6.16583508e-03f, 2.12802574e-01f, 2.49786526e-01f, -2.72729024e-02f,
  1.30667254e-01f, -2.19575584e-01f, -2.07589209e-01f, 8.94520208e-02f, -2.74819195e-01f, -3.48659486e-01f, 9.07313377e-02f, 3.40313941e-01f, -1.87088847e-01f, 1.96240819e-03f,
  5.12454867e-01f, 3.51950943e-01f, 5.37058040e-02f, -3.24520230e-01f, -1.29758105e-01f, 3.22492361e-01f, 1.96537524e-01f, 9.41844732e-02f, 1.19902723e-01f, 2.24811703e-01f,
  -4.74254608e-01f, 3.52617860e-01f, -1.55938223e-01f, 3.02477360e-01f, 2.93357402e-01f, 9.61828455e-02f, 2.56339442e-02f, 1.16854288e-01f, 2.77892537e-02f, 8.79456550e-02f,
  -3.71397316e-01f, -3.80650423e-02f, 2.42515057e-01f, -1.19756991e-02f, -2.40052819e-01f, 1.06705137e-01f, 3.84077579e-01f, 1.30490467e-01f, 2.90010810e-01f, -1.77106023e-01f,
  6.06529117e-01f, -1.58671048e-02f, -6.41621724e-02f, 2.95432627e-01f, -9.37122256e-02f, 1.79326255e-02f, 1.37848973e-01f, 1.22012682e-02f, 1.70664117e-01f, -5.20241201e-01f,
  2.33182073e-01f, 8.87690485e-02f, 4.41669449e-02f, -9.50815305e-02f, -1.39412269e-01f, -6.88846409e-02f, 9.95396003e-02f, -3.34201455e-02f, 2.81279720e-02f, 8.87175053e-02f,
  -5.74252149e-03f, -8.78780782e-02f, -1.23389900e-01f, -7.11775050e-02f, 1.79313004e-01f, -4.16106656e-02f, -2.15960562e-01f, 2.93274343e-01f, 4.67827857e-01f, 1.07278474e-01f,
  7.79062230e-03f, 2.68084586e-01f, 5.06218433e-01f, -1.66293889e-01f, 5.26854321e-02f, 3.73302847e-01f, -1.65515468e-01f, 2.08471328e-01f, 3.07220399e-01f, 3.07790220e-01f,
  3.99552107e-01f, 6.21438771e-02f, 4.19023186e-01f, 8.39871615e-02f, -9.48256999e-02f, 4.11447972e-01f, -2.17403471e-01f, 9.78761688e-02f, -8.61777365e-02f, -2.76223049e-02f,
  1.84511635e-02f, -1.06118508e-01f, 1.31354958e-01f, 1.42040834e-01f, 5.27529344e-02f, -1.89092290e-02f, -2.43349761e-01f, -1.09478168e-01f, 1.01428963e-01f, -2.50252724e-01f,
  -1.12522086e-02f, 3.97025943e-01f, 3.31304073e-01f, -3.08085680e-01f, -2.41088197e-01f, 4.68666643e-01f, 3.56918871e-01f, 4.35205281e-01f, 4.46236491e-01f, 8.24132264e-02f,
  -2.12880880e-01f, 7.48469979e-02f, -3.56902093e-01f, -3.06326866e-01f, -1.74215868e-01f, 9.99501571e-02f, -1.61448032e-01f, -4.16111171e-01f, -3.18091139e-02f, 2.75600046e-01f,
  7.82192871e-02f, 1.60075828e-01f, 2.58919038e-02f, 1.14505701e-01f, 7.75878802e-02f, 1.15223221e-01f, -8.56158435e-02f, 2.42112484e-02f, -1.87827408e-01f, 2.59316433e-02f,
  1.83338389e-01f, -1.93934336e-01f, 5.36365807e-02f, 2.73245633e-01f, -2.61403918e-01f, -1.62386313e-01f, 4.13531959e-02f, 4.21703905e-01f, 2.76130676e-01f, 2.59394106e-02f,
  4.75911230e-01f, -2.56655931e-01f, -1.14985481e-01f, -1.83397993e-01f, -2.45170705e-02f, -1.07417062e-01f, 1.83165535e-01f, 4.97670799e-01f, 1.43484712e-01f, -1.26708448e-01f,
  3.76354277e-01f, 4.03304279e-01f, 1.63317576e-01f, 2.51083255e-01f, 2.64462411e-01f, 1.23889297e-01f, 1.37173653e-01f, 2.90929168e-01f, 2.77365297e-01f, -1.16335995e-01f,
  1.47977322e-01f, -2.59566009e-01f, -1.36922091e-01f, -1.17846154e-01f, -7.17269722e-03f, 2.81589001e-01f, 5.84158599e-01f, 2.71939546e-01f, -1.11755602e-01f, -2.85796314e-01f,
  1.22156821e-01f, 3.67526799e-01f, 4.13457230e-02f, -5.02577499e-02f, 1.60740629e-01f, 3.91080618e-01f, -8.44667405e-02f, -7.07799867e-02f, -3.21225584e-01f, -2.91056007e-01f,
  2.59248745e-02f, 1.48862734e-01f, 2.09272534e-01f, -3.14212680e-01f, 1.25618532e-01f, 1.82950243e-01f, 2.45251566e-01f, 3.32501344e-02f, 3.04206699e-01f, 1.65023863e-01f,
  1.50890648e-01f, -3.18443745e-01f, 2.55812705e-01f, -3.60801727e-01f, -1.43963009e-01f, 1.59400523e-01f, -1.78392619e-01f, -2.06400514e-01f, 5.91992922e-02f, 4.72970933e-01f,
  -2.02880844e-01f, -1.46834970e-01f, 4.27229851e-01f, 3.24667931e-01f, 3.60534757e-01f, -1.34548442e-02f, -6.82648644e-02f, 1.53315160e-02f, 2.23280907e-01f, 2.35547423e-01f,
  -2.26417944e-01f, -1.09223805e-01f, -2.99339950e-01f, 1.88723952e-01f, 2.43189782e-02f, 3.69827777e-01f, -1.08637281e-01f, 8.69963616e-02f, 4.89976220e-02f, 1.76869512e-01f,
  4.68519628e-02f, 1.52128279e-01f, 1.75851986e-01f, 1.47849411e-01f, -3.10405105e-01f, -6.98604956e-02f, 9.39726084e-02f, -2.63986230e-01f, -2.16683045e-01f, 3.17432880e-01f,
  3.90675813e-01f, 4.75652218e-02f, -2.56146967e-01f, 3.33562881e-01f, 3.08329105e-01f, -8.85452330e-02f, 3.84599447e-01f, -2.98448056e-01f, -1.66005343e-01f, 1.19102895e-01f,
  -2.49381155e-01f, 1.96384378e-02f, -1.08683385e-01f, 3.06494355e-01f, 3.74364197e-01f, -6.26924187e-02f, 4.14662808e-01f, 6.33042529e-02f, 1.34963363e-01f, -2.53674425e-02f,
  -1.22360662e-02f, -1.35483488e-01f, 1.43507451e-01f, -2.95771044e-02f, -3.27667385e-01f, -1.75302595e-01f, 1.83422774e-01f, -1.10925794e-01f, -1.51695833e-01f, -2.94375811e-02f,
  4.65562493e-01f, 2.97729760e-01f, -3.64446342e-02f, -6.47562593e-02f, 5.10569990e-01f, 4.29967433e-01f, -2.29526028e-01f, 4.90576804e-01f, 2.18411922e-01f, 4.55881655e-01f,
  4.48203951e-01f, -7.69687667e-02f, 1.75009176e-01f, -4.02842551e-01f, 2.87994266e-01f, -1.81504950e-01f, 1.26331169e-02f, 8.24469551e-02f, -1.29951805e-01f, 3.54517877e-01f,
  8.35322589e-02f, -2.67390385e-02f, 4.83273342e-02f, 2.36368433e-01f, 1.85840085e-01f, 2.55071968e-02f, -2.13818401e-02f, 1.79234162e-01f, -3.07661623e-01f, 1.16578452e-02f,
  2.03516573e-01f, 2.42816716e-01f, 1.88798577e-01f, 2.61653453e-01f, 1.28028244e-01f, -3.54736120e-01f, 1.81415871e-01f, 1.08672753e-01f, -2.16354094e-02f, -4.01670113e-02f,
  -6.36234656e-02f, 5.81091009e-02f, -2.25438893e-01f, -1.16713971e-01f, -6.81247711e-02f, 8.18042606e-02f, 2.51948267e-01f, 4.73869681e-01f, 3.75268221e-01f, -2.08578527e-01f,
  3.44740957e-01f, 2.16622159e-01f, 2.27961659e-01f, -6.79775281e-03f, 1.15329437e-01f, 1.46094054e-01f, -2.99204458e-02f, 1.81055710e-01f, -5.05624227e-02f, -1.31981879e-01f,
  3.49067330e-01f, 1.41755193e-01f, -5.31129688e-02f, 1.25389472e-01f, -5.36980703e-02f, -5.23183286e-01f, -1.94770113e-01f, 4.63252485e-01f, 5.75798973e-02f, -1.31373644e-01f,
  1.28658384e-01f, -4.52192649e-02f, 9.42256600e-02f, -2.13764146e-01f, 5.99325113e-02f, 9.97071862e-02f, 1.67427212e-01f, 2.10723713e-01f, 2.91451633e-01f, 3.79645526e-01f,
  -6.01112284e-02f, 4.16506588e-01f, 4.45928909e-02f, 2.50047445e-01f, -4.65381742e-02f, 7.90649094e-03f, -4.84630875e-02f, 8.67278427e-02f, 1.38500214e-01f, 3.22813094e-02f,
  2.01655135e-01f, 1.25439614e-01f, -1.18514828e-01f, 1.17698893e-01f, 3.79476607e-01f, -9.69685465e-02f, -2.32722938e-01f, -1.21440202e-01f, -4.42953318e-01f, 3.04657131e-01f,
  -3.62763464e-01f, 2.56223887e-01f, 3.87557119e-01f, -2.81456143e-01f, 3.00106645e-01f, -2.35665604e-01f, -1.12611264e-01f, -5.02596274e-02f, 2.65147358e-01f, 5.98551273e-01f,
  -4.71584834e-02f, 1.66015908e-01f, 4.01332736e-01f, 2.75804281e-01f, 4.91600722e-01f, 3.92066389e-01f, 8.70768726e-02f, 2.90578604e-02f, 2.09373400e-01f, 8.17775205e-02f,
  2.42611587e-01f, 1.89627409e-01f, 3.53788137e-01f, -1.86007798e-01f, -7.30855390e-02f, -3.42765629e-01f, 3.37805822e-02f, 9.33485776e-02f, -3.21993351e-01f, 2.63124228e-01f,
  2.23290801e-01f, 1.01134121e-01f, -3.15109134e-01f, -1.11075066e-01f, 4.07539546e-01f, 4.12995666e-01f, 8.81797597e-02f, 1.26639664e-01f, -1.91299006e-01f, 1.82582155e-01f,
  1.90475080e-02f, 3.35125327e-01f, -1.89894944e-01f, 1.75790042e-02f, -1.54314458e-01f, 2.11417884e-01f, 9.07884166e-02f, 1.73282221e-01f, -1.28980249e-01f, -3.55338782e-01f,
  -9.10969675e-02f, -3.70501697e-01f, 3.94188203e-02f, -5.71365654e-02f, -1.91154480e-01f, -3.23475152e-01f, 1.78483605e-01f, -1.51259631e-01f, 6.83885962e-02f, -7.55764693e-02f,
  1.49699360e-01f, 1.82821512e-01f, -5.50417781e-01f, 1.94827408e-01f, 3.08513436e-02f, 1.01423144e-01f, 3.89723837e-01f, 1.86995625e-01f, 4.75779206e-01f, 5.80056012e-01f,
  -1.84631534e-02f, -2.51216888e-01f, 8.07446614e-02f, 7.30439499e-02f, -1.30177945e-01f, -2.40959302e-01f, -3.73000532e-01f, 1.75620429e-02f, 1.44509494e-01f, 4.79798853e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  -1.80316288e-02f, 5.44239618e-02f, 8.42435360e-02f, 2.09428556e-02f, 2.12500393e-01f, 1.30625635e-01f, 1.26245603e-01f, 1.08141959e-01f, 5.84437884e-02f, 7.52489567e-02f,
  5.20414114e-02f, 2.24438161e-01f, 1.86360911e-01f, 1.19030073e-01f, 6.04184642e-02f, 9.92022380e-02f, 7.90455490e-02f, 1.36267304e-01f, 6.24360256e-02f, 2.72995140e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  6.46654367e-02f, 1.56331696e-02f, 5.48390746e-02f, -2.57081449e-01f, -1.67833850e-01f, 8.60688239e-02f, 3.57065678e-01f, 1.78068221e-01f, -3.62734944e-01f, 2.15042070e-01f,
  2.79376537e-01f, 4.49873418e-01f, 7.42319226e-02f, -3.68696839e-01f, -3.94977510e-01f, 1.06143065e-01f, 2.27869466e-01f, 2.96602607e-01f, 1.09679535e-01f, -4.86085385e-01f,
  2.14354217e-01f, -1.98099434e-01f, -5.81520021e-01f, -1.23394050e-01f, 1.07306227e-01f, -3.47315192e-01f, -1.43786922e-01f, -3.84770811e-01f, 2.13552475e-01f, -8.28380603e-03f,
  1.32410392e-01f, 3.14067334e-01f, -3.11840195e-02f, -6.50895014e-02f, -9.88677219e-02f, 9.82064288e-04f, -1.61174268e-01f, 7.44494647e-02f, -9.82098579e-02f, -2.98817158e-01f,
  7.25078210e-02f, -1.38079524e-01f, 7.84934983e-02f, -2.60615051e-01f, -5.58165014e-01f, -4.76507187e-01f, -1.54754624e-01f, 3.87530774e-02f, -6.12130046e-01f, -1.40228078e-01f,
  2.68507570e-01f, -1.78953633e-01f, -1.48661554e-01f, -2.81854272e-01f, 9.83448252e-02f, -6.55071139e-02f, 4.42813814e-01f, 8.12333748e-02f, -3.82400811e-01f, -4.20059532e-01f,
  2.72314310e-01f, 3.87702674e-01f, 1.57041818e-01f, 3.51724237e-01f, 1.55288398e-01f, -1.58571944e-01f, -6.76134974e-02f, 5.88398054e-02f, 1.74653664e-01f, -1.35538533e-01f,
  -1.67887345e-01f, -1.84154347e-01f, 7.16833696e-02f, -1.75378755e-01f, 1.41676724e-01f, 1.11408845e-01f, -3.77937704e-01f, -5.20521343e-01f, -6.25990927e-02f, -1.71622127e-01f,
  -1.79669693e-01f, -6.91037595e-01f, 9.95658934e-02f, -3.37167680e-01f, -4.02846664e-01f, 5.78019261e-01f, 3.57960194e-01f, -3.13576728e-01f, 2.40675304e-02f, 2.37810120e-01f,
  1.00029424e-01f, 1.44868881e-01f, -5.01508176e-01f, 8.36902391e-03f, 2.28250012e-01f, 1.49084896e-01f, 1.48089334e-01f, 1.85493767e-01f, -3.31369452e-02f, -2.43953422e-01f,
  -8.78413767e-02f, -5.05459048e-02f, 3.84708703e-01f, 8.41620751e-03f, 1.81191072e-01f, -1.33395940e-01f, -9.40736458e-02f, 1.75250471e-01f, 2.70044863e-01f, 3.22340019e-02f,
  -6.72199130e-01f, 7.02501088e-02f, 2.58072674e-01f, 1.14211038e-01f, -5.22172391e-01f, 1.94916546e-01f, 2.77334750e-01f, -5.64852178e-01f, -3.79118174e-01f, -1.62287399e-01f,
  -6.42352283e-01f, -1.56100780e-01f, 4.48634654e-01f, -2.25177526e-01f, -3.57193857e-01f, -8.63820910e-02f, -5.10341287e-01f, 2.42641959e-02f, 1.24256738e-01f, -2.60465264e-01f,
  -1.19329058e-01f, 1.30127162e-01f, -1.02752976e-01f, 3.25737119e-01f, -4.47538942e-01f, 2.24953994e-01f, 2.61980802e-01f, -1.36249319e-01f, -4.51863021e-01f, -7.77074173e-02f,
  -7.31658518e-01f, 1.87995791e-01f, -8.91139954e-02f, 1.79967601e-02f, 2.90785044e-01f, 7.33479038e-02f, 4.96030487e-02f, 2.70200163e-01f, 1.74144834e-01f, -3.51382971e-01f,
  -3.57214212e-01f, 4.40981776e-01f, 2.37804472e-01f, -4.58994448e-01f, 2.19534084e-01f, -3.72725636e-01f, 2.04282090e-01f, -6.98228598e-01f, 1.37642054e-02f, -4.25753415e-01f,
  7.85421804e-02f, 2.96991467e-01f, 1.45490104e-02f, 2.44972214e-01f, -8.07402804e-02f, -2.20719814e-01f, 1.56997547e-01f, -1.92405581e-02f, 7.53447413e-02f, -5.97570091e-02f,
  -1.46351624e-02f, 7.40160570e-02f, 1.92778613e-02f, 4.02671456e-01f, 2.49238610e-01f, -1.84402168e-01f, 1.23211734e-01f, 2.44973212e-01f, 1.97517291e-01f, -4.33975428e-01f,
  -1.51209338e-02f, -3.25313210e-01f, -1.45074546e-01f, -1.83233410e-01f, 1.20327219e-01f, -1.19650483e-01f, -6.97818279e-01f, 2.01332852e-01f, 1.25048637e-01f, 1.70370504e-01f,
  2.36265451e-01f, -5.47102988e-01f, 3.28934081e-02f, 4.93744537e-02f, -6.76799938e-02f, -8.39709118e-02f, -6.60389215e-02f, 2.77188659e-01f, -3.26360732e-01f, -2.58285642e-01f,
  1.89899430e-01f, 2.91367203e-01f, 2.72017568e-01f, -1.62156373e-01f, 1.12167992e-01f, -7.37902448e-02f, 2.92842209e-01f, 4.08715606e-01f, -6.08515501e-01f, -4.14679199e-01f,
  -4.81744945e-01f, -3.83841038e-01f, -7.00876355e-01f, 7.12418631e-02f, 1.12766497e-01f, 3.18364769e-01f, -5.02438784e-01f, 4.00732070e-01f, -4.20160919e-01f, 2.20471576e-01f,
  -2.56220609e-01f, 2.03530818e-01f, 1.34146526e-01f, -3.42667401e-01f, -1.71129569e-01f, -1.24714501e-01f, 1.93074256e-01f, -2.41379097e-01f, 4.82284613e-02f, 3.95327732e-02f,
  3.13451082e-01f, 1.26331523e-01f, -3.01526636e-01f, -6.81107938e-02f, 3.59579384e-01f, -1.05300665e-01f, 6.19659387e-02f, 2.56233394e-01f, -3.08496445e-01f, -6.54160261e-01f,
  1.51126385e-02f, 3.81389678e-01f, 2.40193725e-01f, 2.31005430e-01f, 2.55866379e-01f, -6.88915178e-02f, 7.04651177e-02f, -5.31055927e-01f, -3.68571579e-01f, -2.24119186e-01f,
  -6.16108626e-02f, -9.04048532e-02f, 3.51121575e-01f, -3.69301379e-01f, -3.39751393e-01f, -3.25985134e-01f, -2.18886107e-01f, -2.59041190e-01f, 4.90047187e-02f, 8.88677761e-02f,
  1.16491439e-02f, -1.07079454e-01f, 2.63769954e-01f, -2.21670747e-01f, -3.34225774e-01f, -4.08245213e-02f, -1.69451181e-02f, -1.08722039e-01f, 3.63573372e-01f, -2.78553098e-01f,
  -2.68935561e-01f, -4.34775472e-01f, -1.83541223e-01f, 1.66597515e-01f, -3.19754511e-01f, 8.25643446e-03f, -2.68789738e-01f, 2.71048278e-01f, 3.05604428e-01f, -2.62289137e-01f,
  -3.29810292e-01f, 2.34305799e-01f, 2.97397226e-01f, 1.66631624e-01f, 1.26656786e-01f, 2.59455919e-01f, -4.40373391e-01f, -1.01797141e-01f, -2.71806747e-01f, 7.69435018e-02f,
  -5.72986901e-02f, 3.48930992e-02f, 6.36070967e-02f, -2.26016268e-01f, -5.44352606e-02f, 3.12461793e-01f, 4.28284332e-02f, 2.85575360e-01f, -4.40819919e-01f, -2.91378260e-01f,
  -4.04006690e-01f, -4.15850952e-02f, 2.08318308e-01f, 2.82401115e-01f, 4.33072954e-01f, -5.90994656e-01f, 3.47165227e-01f, -1.69765770e-01f, -2.24229813e-01f, 3.62434179e-01f,
  -4.24317122e-01f, 4.34014142e-01f, 1.35643750e-01f, 2.03527957e-01f, -5.23495615e-01f, -3.72844011e-01f, -2.55525470e-01f, -5.35565615e-01f, 2.80196309e-01f, -2.82532185e-01f,
  -1.37362793e-01f, 5.59326857e-02f, -1.15845062e-01f, 8.11770335e-02f, 3.21168788e-02f, 1.24745302e-01f, -2.33336031e-01f, 3.02289784e-01f, 1.10703230e-01f, 6.36543110e-02f,
  -2.47274131e-01f, 3.63357425e-01f, 2.97074795e-01f, -3.99234414e-01f, -3.30172747e-01f, 3.31429720e-01f, -3.21822941e-01f, -2.84068733e-01f, -2.11476296e-01f, 1.69028670e-01f,
  -6.39564395e-02f, 3.46284568e-01f, 5.55718131e-02f, -5.10587804e-02f, 1.23027727e-01f, -4.78752106e-01f, 2.97291785e-01f, 1.54246688e-01f, -2.06250176e-01f, -4.04688954e-01f,
  1.72565326e-01f, 4.66288894e-01f, 1.04173347e-01f, 1.35878742e-01f, 1.55538451e-02f, -7.25035593e-02f, 1.61784217e-01f, 1.67259455e-01f, 8.88388306e-02f, 5.04064634e-02f,
  3.96566987e-02f, 2.94699281e-01f, 9.31417868e-02f, -1.43236145e-01f, 4.40393597e-01f, 4.98563737e-01f, 1.30941644e-01f, 1.03021331e-01f, -2.20840916e-01f, -3.24193358e-01f,
  -3.11833411e-01f, 2.61377782e-01f, 7.19230548e-02f, -3.40117395e-01f, -5.65626696e-02f, -2.80543804e-01f, -3.02253485e-01f, 1.09233230e-01f, -5.78798801e-02f, 3.85755301e-01f,
  -2.24615127e-01f, -4.12985593e-01f, -2.84454793e-01f, -3.12256485e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.84065968e-01f, -5.94180040e-02f, -6.98973313e-02f, 4.03263718e-02f, 1.50755316e-01f, 8.50646850e-03f, 6.99759498e-02f, 1.13689378e-01f, -8.18516612e-02f, -1.21762296e-02f,
  1.18987620e-01f, 8.73930603e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    