/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.32608390e-01f, -3.91844101e-02f, -5.05545288e-02f, -2.77189970e-01f, 6.72525242e-02f, 3.03291865e-02f, 7.70712718e-02f, 7.03386217e-02f, -1.06401548e-01f, -1.06298134e-01f,
  2.07157210e-01f, 2.58501381e-01f, 2.39511877e-01f, 2.57431418e-01f, 8.89356509e-02f, -1.71305373e-01f, -1.55554444e-01f, -1.83695674e-01f, 2.80139428e-02f, 7.68774599e-02f,
  -7.72557035e-02f, -1.78940058e-01f, -1.86492339e-01f, 3.27867009e-02f, -7.93514997e-02f, 7.12948963e-02f, 3.14667970e-02f, -5.29687554e-02f, -1.08848289e-02f, -1.80368647e-01f,
  -1.00886663e-02f, -2.00826913e-01f, 7.12421685e-02f, 6.80254474e-02f, 1.21919490e-01f, -7.57389963e-02f, -6.63241148e-02f, 4.50009853e-02f, -1.57075655e-02f, -3.52536030e-02f,
  6.60598725e-02f, 7.52306283e-02f, 2.45119426e-02f, -1.65966898e-02f, 1.21818651e-02f, -4.94128950e-02f, 6.95903152e-02f, -7.60173276e-02f, -3.47139314e-02f, -7.88314119e-02f,
  1.41899243e-01f, -9.98204052e-02f, -8.76269192e-02f, 1.45903319e-01f, -5.28589375e-02f, -3.05340160e-02f, 1.32166088e-01f, 9.44458321e-02f, 5.07286042e-02f, -6.83089346e-02f,
  -8.67779255e-02f, -2.79682167e-02f, -1.46665787e-02f, 9.21164360e-03f, 4.84369509e-02f, 4.52578217e-02f, 9.13660526e-02f, 9.38498154e-02f, -1.20616639e-02f, 6.26027808e-02f,
  6.42593354e-02f, -9.77023244e-02f, -4.03981097e-02f, -4.85951975e-02f, 1.44837812e-01f, 2.08736118e-02f, -4.66798991e-02f, 8.27980936e-02f, 1.14493549e-01f, 4.83849049e-02f,
  3.73253748e-02f, 8.55699368e-03f, -9.27206054e-02f, 9.29237828e-02f, -4.59936857e-02f, 2.75054965e-02f, -5.65342009e-02f, 3.69201861e-02f, 7.73816109e-02f, -1.14784166e-01f,
  -3.31751257e-02f, 1.35556817e-01f, -2.45175034e-01f, 1.82327479e-02f, -4.05055471e-02f, 3.87978703e-02f, -7.39004463e-02f, -1.70315877e-02f, -4.26189676e-02f, -1.38244793e-01f,
  5.58198094e-02f, -1.13763539e-02f, -8.45088903e-03f, -1.29912561e-02f, -1.03356332e-01f, 1.43350400e-02f, -6.09318018e-02f, -7.78292418e-02f, 7.33246515e-03f, -3.08470298e-02f,
  -4.09747809e-02f, -1.60937056e-01f, -5.90442866e-02f, -6.22257926e-02f, -3.79336886e-02f, -1.63821012e-01f, 3.18184420e-02f, -1.19472854e-01f, -7.50824586e-02f, -2.86487639e-01f,
  -1.12036496e-01f, -4.54288095e-01f, -4.87117946e-01f, -6.67489097e-02f, -2.34951854e-01f, -2.80859053e-01f, -5.01877069e-01f, 2.73870286e-02f, 6.23946898e-02f, -1.50021493e-01f,
  -6.45116344e-02f, -1.89189054e-02f, -7.62215406e-02f, -1.38367981e-01f, -8.80214721e-02f, -3.48009974e-01f, -3.47901344e-01f, -2.98731565e-01f, -1.71244785e-01f, -2.18182225e-02f,
  -4.46786992e-02f, -5.32232113e-02f, -7.41815008e-03f, -5.20859957e-02f, -2.10109934e-01f, -1.13365524e-01f, -2.40149155e-01f, -8.72194916e-02f, -2.84599751e-01f, -3.94979060e-01f,
  -5.38169146e-01f, -9.11715478e-02f, -6.61209896e-02f, -4.38613929e-02f, -1.91010058e-01f, -9.02066231e-02f, -1.16459802e-01f, 4.65102643e-02f, 7.26786256e-02f, -7.05456808e-02f,
  1.78344343e-02f, 3.47813144e-02f, -1.25596821e-01f, -1.16977617e-01f, -1.10118076e-01f, -8.75173286e-02f, 1.05130665e-01f, -5.59079759e-02f, -5.81907704e-02f, -7.64880925e-02f,
  -1.23483166e-01f, -8.56075138e-02f, -1.25134453e-01f, -9.06760693e-02f, 3.18966284e-02f, 1.66004095e-02f, -7.58154467e-02f, -7.07432106e-02f, -2.65780706e-02f, -2.33721986e-01f,
  2.05334071e-02f, 2.61213612e-02f, 1.11545615e-01f, 1.73752949e-01f, 1.91742897e-01f, 1.69428155e-01f, 3.97979394e-02f, 7.24104047e-02f, 1.18893079e-01f, 1.60990775e-01f,
  2.01412410e-01f, -3.08507564e-03f, 6.11027442e-02f, 1.11843469e-02f, 8.43800381e-02f, 5.98005727e-02f, 1.10178284e-01f, 3.01655866e-02f, 1.60579488e-01f, 1.65079638e-01f,
  1.13818444e-01f, 1.16562180e-01f, 1.22586817e-01f, 1.20155409e-01f, 3.10115926e-02f, 6.03223927e-02f, 9.83464867e-02f, 1.75065130e-01f, 2.01270401e-01f, 1.92062423e-01f,
  2.14141179e-02f, -9.08315927e-03f, -2.29075417e-01f, -5.74797131e-02f, -1.03680864e-01f, -3.09805702e-02f, -1.20370448e-01f, -1.73566431e-01f, -1.51740298e-01f, -1.44766197e-01f,
  -7.10187703e-02f, -5.18003553e-02f, -8.84537771e-02f, -5.72669059e-02f, -3.83060612e-02f, -1.60034280e-02f, -4.64474037e-02f, -1.44634128e-01f, 1.21791195e-02f, -2.25652400e-02f,
  -4.82989401e-02f, -4.58665118e-02f, -1.37330890e-01f, -1.38017282e-01f, -5.81983589e-02f, -7.68967941e-02f, -2.85764158e-01f, -5.04182428e-02f, -9.71357077e-02f, -2.56883442e-01f,
  -3.34700257e-01f, 5.51476419e-01f, 1.13592774e-01f, 5.92583343e-02f, 2.27470234e-01f, 1.63805917e-01f, 2.96930879e-01f, 1.99701071e-01f, 8.30609575e-02f, 5.98521456e-02f,
  -6.16618805e-02f, -9.58182588e-02f, -9.21380520e-02f, -1.38132684e-02f, 5.64154983e-02f, 1.99855998e-01f, 3.06892723e-01f, -8.22164267e-02f, -1.15551539e-01f, 1.17088243e-01f,
  2.02735707e-01f, 2.76497066e-01f, 1.43461049e-01f, 1.52895153e-01f, 2.07518056e-01f, 7.98163936e-02f, 1.81151286e-01f, 2.04450205e-01f, 2.22567722e-01f, 2.26917252e-01f,
  -2.96467036e-01f, 1.20422974e-01f, -1.21484369e-01f, -8.67176503e-02f, -4.29766765e-03f, -7.54605532e-02f, -7.55475536e-02f, 8.42754468e-02f, -3.98799255e-02f, -2.36794841e-03f,
  7.55374953e-02f, -3.72255556e-02f, -7.02895597e-02f, 1.12492546e-01f, 7.11813103e-03f, -3.71415429e-02f, 4.42782380e-02f, 1.05715901e-01f, -1.87830441e-02f, 2.74156984e-02f,
  1.04085878e-01f, 7.75684491e-02f, -5.89489937e-02f, 1.25726853e-02f, 1.37140200e-01f, -3.67551520e-02f, 4.78446521e-02f, -1.54788960e-02f, -3.86343412e-02f, 4.03749831e-02f,
  -4.93166000e-02f, 4.80908528e-02f, 7.05262199e-02f, 1.51807949e-01f, -8.35674554e-02f, -1.14708496e-02f, 9.46282223e-02f, 2.34228633e-02f, 2.35946104e-03f, -2.55771037e-02f,
  4.78425995e-02f, -7.53019601e-02f, 1.46324798e-01f, 5.58106378e-02f, 1.16573751e-01f, 7.23738223e-02f, 1.05496421e-01f, 8.26841816e-02f, -1.44245317e-02f, 4.29729484e-02f,
  -4.12814170e-02f, -6.65927231e-02f, 4.77581583e-02f, 3.74822430e-02f, 6.99230507e-02f, -1.42607465e-03f, -4.55381442e-03f, 4.08164114e-02f, 8.83722678e-02f, 2.27341894e-03f,
  -4.71363477e-02f, -1.09059885e-01f, -1.35521054e-01f, -2.22825110e-02f, -1.36514530e-02f, -3.25652882e-02f, -3.54146808e-02f, -7.30376095e-02f, 2.55177496e-03f, 9.07076616e-03f,
  -7.52084553e-02f, -7.80169144e-02f, -2.62624230e-02f, -5.93965799e-02f, -5.04314043e-02f, -8.73104036e-02f, 4.05425020e-03f, -5.32639697e-02f, 1.87040847e-02f, 3.77951562e-02f,
  -2.17875540e-02f, -1.10238045e-01f, -3.02936763e-01f, -1.66809440e-01f, 3.04406676e-02f, -3.11021715e-01f, -5.11326827e-02f, -8.31337571e-02f, -2.13152274e-01f, -1.53610572e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.84566998e-01f, 1.38458520e-01f, 3.07200048e-02f, 4.36912537e-01f, -2.87228763e-01f, -7.66539037e-01f, -8.07159364e-01f, -4.64017808e-01f, 3.19206297e-01f, 3.72396439e-01f,
  5.90596115e-03f, 1.31797090e-01f, 2.41231292e-01f, -2.99235672e-01f, -6.91972136e-01f, -1.07563727e-01f, -5.88249229e-02f, -3.68228942e-01f, -9.77748156e-01f, -8.89160991e-01f,
  -3.82422894e-01f, 2.76556574e-02f, -2.16306970e-01f, -1.32754818e-01f, 5.32557368e-01f, 1.86380774e-01f, 5.36562383e-01f, 6.42378181e-02f, -1.66731521e-01f, 6.01154864e-01f,
  6.65156722e-01f, -8.95742103e-02f, -3.17245096e-01f, -1.42528489e-01f, 1.85684502e-01f, 1.26257360e-01f, -1.46425322e-01f, 2.47392163e-01f, 1.97904214e-01f, 1.68401018e-01f,
  1.27315477e-01f, -4.75331843e-02f, -2.39027128e-01f, -2.04021148e-02f, -7.61061758e-02f, -1.27633095e-01f, -1.33860530e-02f, -2.21629605e-01f, -2.87904292e-02f, 1.67451292e-01f,
  -3.89167741e-02f, -1.96863487e-01f, 8.18790942e-02f, -9.91278291e-02f, -1.77045912e-01f, -1.53526440e-01f, 4.35449854e-02f, -8.90467912e-02f, -2.13710189e-01f, 4.21497136e-01f,
  -9.43896621e-02f, 1.82066277e-01f, -2.41759066e-02f, 4.00469676e-02f, 4.66414504e-02f, 2.65179873e-01f, 1.78174153e-01f, -5.28652333e-02f, -7.19939917e-02f, 1.36600360e-01f,
  8.18295404e-02f, 4.00640555e-02f, -3.78110372e-02f, 8.40833634e-02f, 1.23799354e-01f, 3.46155129e-02f, 7.88560957e-02f, 9.68494043e-02f, 8.15271139e-02f, 2.23825052e-01f,
  1.41538560e-01f, 1.12328805e-01f, 3.06205899e-01f, 6.29113913e-02f, -4.62758131e-02f, 9.26835388e-02f, 3.25248502e-02f, -7.84140304e-02f, -5.22232242e-02f, 8.70596170e-02f,
  5.32052875e-01f, -6.39282525e-01f, 5.63311756e-01f, -1.60417184e-01f, 2.40567893e-01f, 6.94970340e-02f, 2.76157975e-01f, -3.92111205e-02f, 3.67706776e-01f, 4.08419222e-02f,
  -2.17192590e-01f, 8.46487954e-02f, 7.68031925e-02f, -2.50567049e-02f, -2.30359003e-01f, 1.81539170e-02f, -3.32345627e-02f, 1.00764565e-01f, -1.56260297e-01f, 3.50010306e-01f,
  1.79728672e-01f, -1.52906045e-01f, 1.15205787e-01f, 2.11227328e-01f, -9.21705551e-03f, -1.60320505e-01f, 1.24882825e-01f, 5.80490977e-02f, -3.72185588e-01f, 4.12950873e-01f,
  4.87381160e-01f, -3.34817886e-01f, -1.52428851e-01f, 4.12315458e-01f, 3.13517660e-01f, 3.49446744e-01f, 2.46312484e-01f, 4.15767342e-01f, 5.04665077e-01f, 7.54136592e-02f,
  -2.35124290e-01f, 9.87258330e-02f, 1.33716777e-01f, 2.96814293e-02f, 1.41856134e-01f, 2.18246937e-01f, 3.43848348e-01f, 6.03045039e-02f, 1.41416192e-01f, 1.70996532e-01f,
  2.87955880e-01f, 2.32629240e-01f, 7.14120641e-02f, 1.46639466e-01f, 3.35270166e-02f, 2.96749115e-01f, -2.26810332e-02f, -1.00078158e-01f, -8.46330523e-02f, 7.87691306e-03f,
  -5.76061726e-01f, -1.79625168e-01f, 4.96570766e-02f, 1.14093320e-02f, -2.70968199e-01f, -1.24236301e-01f, -1.41450306e-02f, -1.28712803e-01f, -2.76583657e-02f, 9.96220671e-03f,
  -1.32254615e-01f, -7.26375729e-02f, -1.76627234e-01f, -7.87657574e-02f, -7.06397220e-02f, -4.01289910e-02f, -1.13187127e-01f, 7.14318082e-02f, 8.31776634e-02f, -1.97823405e-01f,
  -1.06861904e-01f, -1.04265511e-01f, -1.20189404e-02f, 1.14092737e-01f, -4.20939922e-02f, -2.18338910e-02f, -1.68432057e-01f, 3.66442930e-03f, -1.67067945e-02f, 1.74953669e-01f,
  6.14142418e-02f, -7.80084133e-02f, -4.59726639e-02f, 3.12897675e-02f, -1.21526420e-03f, 7.70927314e-03f, 1.39516503e-01f, 5.45022748e-02f, 1.78377062e-01f, -6.79818541e-02f,
  7.74539113e-02f, -4.59925719e-02f, 1.71209909e-02f, 1.27433136e-01f, 4.17407323e-03f, -9.93937254e-02f, -3.94393317e-02f, -1.75842211e-01f, -2.07977682e-01f, -9.36236233e-02f,
  -9.01328698e-02f, 7.68618099e-03f, -2.91032821e-01f, -1.70748472e-01f, -2.63853669e-02f, 1.01197876e-01f, 1.28320545e-01f, -9.94997397e-02f, 8.13825876e-02f, 1.35561630e-01f,
  -9.07137543e-02f, -1.20262705e-01f, 7.96819329e-02f, -2.09017806e-02f, -1.34607598e-01f, -1.72033533e-01f, -1.03309162e-01f, -1.75376341e-01f, -1.65059820e-01f, 3.59009095e-02f,
  -1.00275800e-01f, -1.78074047e-01f, -2.27263644e-01f, 5.58873042e-02f, 2.07830042e-01f, 1.16433762e-01f, -1.38561875e-01f, 1.85834587e-01f, 3.82664204e-02f, -1.02935359e-01f,
  -4.88294736e-02f, 2.90347040e-01f, 2.72897631e-01f, 2.74771720e-01f, 9.46410447e-02f, 3.00636172e-01f, 9.24921408e-02f, 3.82638052e-02f, 1.81982547e-01f, 3.07337105e-01f,
  -7.24634051e-01f, 3.48462552e-01f, -7.71410167e-01f, 5.50283253e-01f, 4.90924567e-01f, -9.31545570e-02f, -1.77005142e-01f, -1.66935921e-01f, 3.72648120e-01f, 2.84638256e-01f,
  2.08329931e-01f, 4.61748153e-01f, 4.92217511e-01f, 3.00837159e-01f, -1.08890980e-01f, -2.77877692e-02f, 1.97875321e-01f, -4.30649757e-01f, -5.07825017e-01f, -2.79463440e-01f,
  5.28466702e-01f, 2.72691131e-01f, -1.42688483e-01f, -2.13360041e-01f, 3.28478575e-01f, 2.41499737e-01f, 1.85607359e-01f, 2.06850901e-01f, 1.80276763e-02f, 2.52333969e-01f,
  -1.91802680e-01f, -8.06496799e-01f, -3.22309047e-01f, 2.13178813e-01f, -2.71451950e-01f, -3.96805853e-01f, -5.89065313e-01f, -5.58215857e-01f, -5.07361628e-02f, -3.46121430e-01f,
  1.33181751e-01f, -2.72878885e-01f, 4.19262916e-01f, 4.81151491e-02f, -5.78699037e-02f, -1.70996279e-01f, -8.92975107e-02f, -5.31465411e-01f, -3.98970962e-01f, -5.04704773e-01f,
  4.45576549e-01f, -1.10094674e-01f, -6.91798151e-01f, -2.61468023e-01f, -5.85124612e-01f, -2.51441598e-01f, -5.45555711e-01f, -5.63306093e-01f, -6.81986868e-01f, -4.42263573e-01f,
  -1.78379953e-01f, -2.53198594e-01f, 2.16638446e-01f, 1.45600319e-01f, 1.51303485e-01f, 9.28646252e-02f, 1.09371461e-01f, -2.36013420e-02f, 3.24420072e-02f, 1.12151392e-01f,
  -4.95118573e-02f, -1.46411300e-01f, -1.03184223e-01f, 1.55151763e-03f, 2.76804805e-01f, -1.84421510e-01f, -3.37283850e-01f, -1.17141098e-01f, -1.49034351e-01f, -1.92515731e-01f,
  1.23283930e-01f, -2.34085252e-03f, 1.45301104e-01f, -2.90230066e-01f, -3.55895646e-02f, -4.15444493e-01f, -4.01723571e-02f, -1.00889191e-01f, 3.05073727e-02f, -8.15564916e-02f,
  7.50643790e-01f, -1.31382108e-01f, -7.02256411e-02f, -1.52905747e-01f, -1.54937565e-01f, -6.70016035e-02f, 1.32286310e-01f, -1.31161332e-01f, 2.55809486e-01f, -3.71028066e-01f,
  -3.03723723e-01f, -2.17482850e-01f, 3.34625959e-01f, 9.48910117e-02f, -1.44888088e-01f, 7.15104714e-02f, 2.65672982e-01f, 6.74455687e-02f, 9.43061635e-02f, -2.35195920e-01f,
  4.74294126e-01f, -7.32366517e-02f, -6.06427602e-02f, 1.39676686e-02f, 1.38450876e-01f, 2.96227187e-01f, 3.09677750e-01f, -9.15115401e-02f, -1.67792350e-01f, 2.17095576e-02f,
  -3.20915192e-01f, -9.91197765e-01f, 2.89360911e-01f, -7.73047447e-01f, -3.32771987e-01f, -1.67082816e-01f, -9.30455983e-01f, -5.91385007e-01f, -2.46960431e-01f, -9.59030330e-01f,
  -2.23279282e-01f, 6.43693984e-01f, 7.23489344e-01f, 3.91375095e-01f, 3.44504863e-02f, -1.20950472e+00f, -6.10878348e-01f, 5.02250493e-01f, 6.03591204e-01f, -4.02040392e-01f,
  -5.72075129e-01f, -4.48265344e-01f, 1.80801794e-01f, -1.56135991e-01f, -7.96481907e-01f, 5.15173487e-02f, -1.38608679e-01f, -2.00945660e-01f, -2.42551491e-01f, -5.45501947e-01f,
  -2.87509024e-01f, 1.45886779e-01f, 3.77706081e-01f, 4.08431381e-01f, -2.97850907e-01f, 9.93234292e-02f, -2.05287322e-01f, 6.09408543e-02f, 1.18690915e-01f, -1.39196023e-01f,
  1.81283683e-01f, 9.32822898e-02f, 3.68371308e-01f, -1.11305535e-01f, -3.67518455e-01f, -9.35657695e-02f, -4.86525521e-02f, 1.70307785e-01f, 1.17943533e-01f, -2.64364094e-01f,
  -3.23037297e-01f, -2.09727511e-02f, 3.72198164e-01f, 5.65614253e-02f, 9.45782065e-02f, 4.53949392e-01f, -1.72276855e-01f, 1.70660183e-01f, 4.02293682e-01f, -9.82833564e-01f,
  -1.88839659e-01f, 7.30479956e-02f, -7.45656043e-02f, -1.55837148e-01f, 2.09272895e-02f, 9.60798264e-02f, 1.20567381e-01f, -1.47677183e-01f, 4.04784530e-02f, -1.38289198e-01f,
  -3.05727329e-02f, -9.17201936e-02f, 1.99519303e-02f, -6.99085444e-02f, 5.76099474e-03f, -7.16445618e-04f, 1.30999386e-02f, -9.22295377e-02f, -3.02931760e-03f, 6.93238303e-02f,
  1.07113414e-01f, 6.80568442e-02f, 1.76163688e-02f, -1.01594768e-01f, 1.71008125e-01f, 3.76629122e-02f, 1.08285688e-01f, 5.64398430e-02f, -1.13856442e-01f, 1.38237411e-02f,
  -2.00587064e-01f, 6.66125596e-01f, -2.86515266e-01f, 1.44752383e-01f, -1.21467210e-01f, 6.92400932e-02f, 6.87477589e-02f, 4.35688868e-02f, 3.65321577e-01f, -2.36778557e-01f,
  7.32274875e-02f, -1.64595529e-01f, -7.93876275e-02f, -9.89844203e-02f, -1.21972449e-01f, 6.85214400e-02f, -3.52514118e-01f, 5.10790106e-03f, 1.39416128e-01f, -2.06838578e-01f,
  -2.94015944e-01f, -1.52801588e-01f, -1.98317200e-01f, -1.22390471e-01f, -1.37259319e-01f, 2.74660945e-01f, -1.28818050e-01f, -2.75476307e-01f, 1.78843364e-01f, -1.00374150e+00f,
  6.49369895e-01f, -4.49757501e-02f, -1.35637987e+00f, -4.56319712e-02f, -8.60125124e-01f, -7.75709629e-01f, -3.57795894e-01f, 2.95437187e-01f, 3.33262980e-02f, -1.93588302e-01f,
  -2.96463668e-01f, -3.92196298e-01f, -6.14166498e-01f, -4.19814974e-01f, -4.75098550e-01f, -4.69643891e-01f, -7.43955791e-01f, -8.40370595e-01f, -7.06759810e-01f, -2.19934478e-01f,
  -6.75971732e-02f, -8.60419050e-02f, -1.30160684e-02f, -9.87366587e-02f, -2.15979725e-01f, -4.59543049e-01f, -6.39786243e-01f, -6.20313406e-01f, -5.66729963e-01f, -6.01590097e-01f,
  -8.72054577e-01f, -2.08638519e-01f, -2.52684474e-01f, 2.23238260e-01f, -2.23067984e-01f, 8.02497491e-02f, 4.90824878e-03f, -8.25276673e-02f, 6.55947998e-02f, -1.24878034e-01f,
  -1.29565850e-01f, -2.53711678e-02f, -1.45111591e-01f, -3.10029566e-01f, -5.64216860e-02f, -2.21432716e-01f, -8.59533921e-02f, -2.12810799e-01f, -1.46127790e-01f, -1.27917409e-01f,
  -4.06902209e-02f, -6.23334229e-01f, -7.62427866e-01f, -4.80354652e-02f, -2.51756638e-01f, -3.81839305e-01f, -4.96361405e-01f, -3.96713525e-01f, -5.76429427e-01f, 2.71106362e-02f,
  8.87640268e-02f, 2.30816118e-02f, -1.27407655e-01f, 5.18826135e-02f, 2.55252838e-01f, 5.01432978e-02f, -1.66283622e-02f, 1.60396606e-01f, -8.47929493e-02f, -1.51804790e-01f,
  -1.35059627e-02f, -4.19145077e-02f, -1.03830397e-01f, 9.70449299e-02f, -1.84950218e-01f, -1.46984249e-01f, 4.82463762e-02f, 1.49462566e-01f, -1.62561446e-01f, 2.61956695e-02f,
  -1.12768829e-01f, -1.49374619e-01f, -6.02474399e-02f, 1.46781355e-01f, -3.81213874e-01f, -1.50843129e-01f, -1.72285840e-03f, 1.65590301e-01f, 1.79435417e-01f, 3.37622012e-03f,
  3.56362820e-01f, -2.56042063e-01f, 1.90041542e-01f, 2.47415036e-01f, -1.38691097e-01f, -2.00616851e-01f, 1.12793230e-01f, 1.61887839e-01f, -4.04347032e-02f, -4.40761410e-02f,
  -1.83532506e-01f, -1.87917165e-02f, -2.49285340e-01f, 1.46692559e-01f, -1.07565299e-01f, -1.96993619e-01f, 2.28867114e-01f, -2.01334506e-01f, -5.83022125e-02f, 2.38117859e-01f,
  2.60150552e-01f, -5.08976355e-02f, 2.61224777e-01f, 8.07594731e-02f, 1.12670712e-01f, 3.18230726e-02f, -1.15323730e-01f, -8.25480297e-02f, -6.83648139e-02f, 6.89855397e-01f,
  -4.72450554e-01f, 3.67818952e-01f, 1.32129550e-01f, -4.63981688e-01f, 3.47126685e-02f, 3.85345012e-01f, 6.69790506e-01f, 1.13523401e-01f, -2.35949516e-01f, 4.96579148e-02f,
  -7.13828132e-02f, -4.24143493e-01f, -3.85033995e-01f, -2.77848542e-01f, -1.10364128e-02f, 3.10992658e-01f, 1.50756046e-01f, 2.83575878e-02f, 1.33229434e-01f, 2.20354065e-01f,
  2.38986194e-01f, 9.69818160e-02f, 9.71351489e-02f, -1.11138396e-01f, -2.53482550e-01f, -1.77220598e-01f, 1.23317456e-02f, -8.23215619e-02f, 1.97410047e-01f, -2.15254933e-01f,
  2.62836307e-01f, -1.29789963e-01f, -1.59492746e-01f, -2.05747709e-01f, -2.70322673e-02f, -8.16533491e-02f, -7.59467557e-02f, -2.22347796e-01f, 7.74839800e-03f, 3.43765058e-02f,
  -5.96404038e-02f, 2.73906328e-02f, -1.39083609e-01f, 1.86621130e-01f, 1.52705476e-01f, 2.73138452e-02f, -1.09037139e-01f, 1.05638150e-02f, -1.47538900e-01f, -8.94618630e-02f,
  -1.32018149e-01f, -3.60851660e-02f, 7.08734244e-02f, 8.87437239e-02f, 1.76356407e-03f, -1.41108066e-01f, 1.03297226e-01f, -3.31558138e-02f, -5.56644909e-02f, -5.04576564e-02f,
  -2.72548851e-02f, -6.90952875e-03f, -6.88615814e-02f, 1.17012024e-01f, 1.31328061e-01f, -1.86183471e-02f, -2.95534674e-02f, 8.40199441e-02f, 1.01232201e-01f, 5.60850985e-02f,
  5.02102450e-02f, 1.73604697e-01f, 1.70285642e-01f, 1.51464313e-01f, -2.43262388e-02f, 8.11100155e-02f, 1.22007057e-01f, -3.70946638e-02f, -2.94951275e-02f, -9.55722705e-02f,
  1.50319517e-01f, 7.58412927e-02f, -6.74510840e-03f, 1.43241063e-01f, 1.72443807e-01f, -5.96009642e-02f, 1.26288161e-02f, 1.99348181e-01f, -8.61119255e-02f, 1.00450367e-01f,
  3.25027049e-01f, 4.77357060e-02f, -1.98778391e-01f, -1.35778919e-01f, -9.32910889e-02f, -1.43483698e-01f, -5.63237779e-02f, -5.24486275e-03f, 9.65169165e-03f, 1.79168314e-01f,
  -4.17583548e-02f, 5.61735630e-02f, -8.15034751e-03f, 1.40830651e-01f, 1.55180812e-01f, 5.54328449e-02f, -1.47096857e-01f, -6.24046512e-02f, -9.67316180e-02f, 1.42678421e-03f,
  6.09844588e-02f, 8.02537054e-02f, 9.38067362e-02f, 4.25007381e-02f, 2.21945308e-02f, -4.91604991e-02f, 2.54929215e-01f, 3.19181457e-02f, 1.28043711e-01f, 3.84774536e-01f,
  -1.23764980e+00f, 1.95819706e-01f, 4.09679502e-01f, -6.50240242e-01f, 1.98693648e-01f, 6.62074506e-01f, 1.00263774e+00f, 5.60548827e-02f, -3.27946156e-01f, 2.48672605e-01f,
  -1.81716800e-01f, -5.30139565e-01f, -4.48326021e-01f, -9.65241492e-02f, 2.31188223e-01f, 1.04212821e+00f, 7.20556498e-01f, 7.37563372e-02f, -2.88540330e-02f, 9.87660140e-02f,
  2.79702544e-01f, -4.27335322e-01f, -6.97398007e-01f, -4.02720779e-01f, -2.42219016e-01f, -7.55808577e-02f, -5.37614971e-02f, -2.91647524e-01f, 3.37826431e-01f, 2.13578150e-01f,
  -4.07589711e-02f, -5.72314024e-01f, 3.68366510e-01f, -2.75207072e-01f, -1.47476465e-01f, -1.57706589e-01f, 2.91159637e-02f, -3.80587012e-01f, -1.62418097e-01f, -2.03962833e-01f,
  -1.89936817e-01f, -1.91939995e-01f, -2.15329319e-01f, -9.30871367e-02f, -3.62523347e-01f, -8.00721869e-02f, -2.40982965e-01f, -1.44051567e-01f, -1.99791700e-01f, 1.53004546e-02f,
  1.64455339e-01f, 9.09660533e-02f, -6.73131496e-02f, 1.81821972e-01f, 3.11010741e-02f, 1.02546262e-02f, -1.58874199e-01f, -1.00043945e-01f, -1.04662813e-01f, -3.38448077e-01f,
  9.78453606e-02f, -4.71766107e-02f, 2.83545312e-02f, -9.32433978e-02f, -3.63958664e-02f, 1.52170897e-01f, 8.46228302e-02f, 5.51781990e-02f, 1.01185381e-01f, -7.46193901e-02f,
  9.29177999e-02f, 6.18168227e-02f, -6.35707229e-02f, -7.53179379e-03f, -4.12127711e-02f, -7.58310929e-02f, 1.56790048e-01f, -3.27984802e-02f, 3.88077684e-02f, 1.43783949e-02f,
  -8.68553370e-02f, 3.00439782e-02f, -1.10436663e-01f, 1.67992711e-02f, 9.32034180e-02f, -3.04613803e-02f, -1.64771825e-01f, -1.78437427e-01f, -1.17499173e-01f, -3.21527640e-03f,
  -3.68238032e-01f, 4.56763446e-01f, 8.56615826e-02f, -1.16346158e-01f, 3.41604501e-02f, 1.56413708e-02f, -9.02225375e-02f, 6.99458122e-02f, 7.04537705e-02f, -6.67633861e-02f,
  2.94822007e-02f, -1.69395700e-01f, -3.06833796e-02f, -4.37887907e-02f, -3.04429755e-02f, 1.62752084e-02f, 1.46831751e-01f, 6.12321571e-02f, 1.29739299e-01f, 2.15950720e-02f,
  9.97035727e-02f, 2.19472349e-01f, 1.68794841e-01f, 1.77642196e-01f, 2.62407307e-02f, 1.60549834e-01f, 1.26279458e-01f, 1.91833712e-02f, 3.29010725e-01f, 2.67591596e-01f,
  -6.00499511e-01f, -5.76689720e-01f, -2.54020561e-02f, -1.13950543e-01f, -3.66002284e-02f, -4.60431725e-02f, -3.39789033e-01f, -1.73553362e-01f, -2.35751942e-02f, -4.32283767e-02f,
  1.35080978e-01f, 3.36444348e-01f, 3.30689132e-01f, 2.33691022e-01f, 1.31833255e-01f, -1.09943733e-01f, 9.98748466e-02f, 1.04561470e-01f, 1.43004373e-01f, -1.47120468e-02f,
  -1.03179336e-01f, -3.46057087e-01f, -1.90015480e-01f, -1.65954098e-01f, 9.45436060e-02f, 1.56390056e-01f, -1.26942784e-01f, 8.38125646e-02f, -6.93806261e-02f, 3.35619450e-02f,
  5.21679044e-01f, 1.17275916e-01f, 1.74742758e-01f, 6.52586073e-02f, -1.50648087e-01f, -1.41277283e-01f, -4.99938130e-02f, 2.37962278e-03f, -1.58109054e-01f, -7.87076429e-02f,
  -3.99386324e-03f, 4.31768782e-03f, 7.84813240e-02f, 2.79396016e-04f, -9.55178365e-02f, 2.99043320e-02f, 6.66645318e-02f, 9.74533185e-02f, -2.17981935e-02f, 1.51462778e-01f,
  2.26948559e-01f, 2.26436466e-01f, 2.24532560e-01f, 1.76980391e-01f, 1.32403091e-01f, 1.81082934e-01f, 1.05974814e-02f, 1.91559821e-01f, 1.55526757e-01f, 1.50690615e-01f,
  -1.43978447e-01f, -8.80985633e-02f, 9.85417515e-02f, 2.24296883e-01f, 2.21749753e-01f, -8.63381997e-02f, 6.07308745e-02f, -5.07462882e-02f, -2.66457554e-02f, -1.97788954e-01f,
  -1.60136625e-01f, 1.75873205e-01f, 8.13342929e-02f, -1.36111736e-01f, 2.99248304e-02f, -4.25328128e-02f, -1.02795877e-01f, 1.42169446e-01f, 1.36807352e-01f, 2.05842890e-02f,
  -1.09102449e-03f, -1.33142665e-01f, -2.23420992e-01f, 5.99289276e-02f, -3.45629677e-02f, 1.08584844e-01f, -5.77252507e-02f, 2.10124464e-03f, -1.01351209e-01f, -2.12726399e-01f,
  1.88993618e-01f, 4.58021313e-01f, 6.43634871e-02f, -1.74977463e-02f, 2.48008105e-03f, -7.35168159e-02f, 2.50655621e-01f, -1.51992328e-02f, -8.60501304e-02f, 5.62822334e-02f,
  1.12468645e-01f, -6.75967261e-02f, -1.12961493e-01f, -1.21491298e-01f, -4.38568406e-02f, 4.15140614e-02f, 5.28206341e-02f, 1.04427926e-01f, -1.73180178e-02f, 3.05632427e-02f,
  6.90627098e-02f, 8.24483186e-02f, 9.43352804e-02f, 2.11334415e-02f, 9.80513543e-03f, 1.58492297e-01f, 1.23013332e-01f, 1.03163309e-02f, 1.21411182e-01f, -1.20175555e-01f,
  9.54669237e-01f, 3.46395969e-01f, 1.95502996e-01f, 3.86613756e-01f, 4.21895504e-01f, 1.16472334e-01f, -6.04389980e-02f, -3.90476942e-01f, -1.48576617e-01f, 1.57658279e-01f,
  4.54770982e-01f, 3.29622984e-01f, 7.17632100e-02f, 8.28600526e-02f, -2.29878023e-01f, -2.32515574e-01f, -3.51205409e-01f, -4.25213650e-02f, 9.07065056e-04f, 2.68130660e-01f,
  1.05862804e-01f, 9.33166966e-02f, 3.53319235e-02f, -1.14739537e-01f, 2.09982708e-01f, 5.71468472e-02f, -5.13497330e-02f, 2.28759348e-01f, 2.34266073e-01f, 2.00941414e-01f,
  3.64863783e-01f, 2.24433199e-01f, -2.54588008e-01f, 1.10140890e-01f, 1.80871084e-01f, -1.14211231e-01f, 1.32179223e-02f, -1.13814950e-01f, 4.97488417e-02f, -1.66738927e-01f,
  1.60673365e-01f, 5.33369891e-02f, 7.75076300e-02f, -4.00761068e-02f, 1.27965137e-02f, -1.38392776e-01f, -1.72758609e-01f, -2.89414018e-01f, -4.33084555e-02f, 1.31583780e-01f,
  2.39131331e-01f, 3.52138758e-01f, 1.97555274e-01f, -1.10511005e-01f, -5.32017387e-02f, 1.06322892e-01f, -1.45743648e-02f, 7.57376552e-02f, -1.52778253e-01f, 4.44668569e-02f,
  3.66093755e-01f, 4.27172244e-01f, 3.00701499e-01f, 9.57247764e-02f, 7.35687613e-02f, -4.96883094e-02f, -2.44284384e-02f, 7.52052367e-02f, 2.90373415e-02f, 6.58901557e-02f,
  4.88822646e-02f, 1.97894961e-01f, -9.37236026e-02f, -2.89069060e-02f, 2.18430623e-01f, 1.96725413e-01f, 1.44764796e-01f, -3.07152439e-02f, 1.06762700e-01f, -1.72985718e-01f,
  5.30534387e-02f, -1.67033225e-01f, -9.43446811e-03f, -1.69001386e-01f, -7.97288939e-02f, 2.35137597e-01f, 8.41345340e-02f, 1.69761851e-01f, 1.54175356e-01f, 1.97134405e-01f,
  -5.29810667e-01f, -5.25074685e-03f, -4.25605662e-02f, -2.78818130e-01f, 1.30273610e-01f, -4.82023396e-02f, 1.10683590e-01f, -9.36431810e-02f, -1.73072398e-01f, -1.61171049e-01f,
  -3.15446518e-02f, 8.86708647e-02f, -1.62497174e-03f, -1.22432455e-01f, -8.68423730e-02f, -1.08350806e-01f, 2.19973153e-03f, 1.37848333e-02f, -1.82278246e-01f, 3.92329320e-02f,
  -6.01812974e-02f, -5.96276671e-02f, -5.36394715e-02f, -2.36926898e-01f, -1.03778131e-02f, 1.63217373e-02f, -1.22977935e-01f, -1.30466625e-01f, -1.12399168e-01f, -2.16160908e-01f,
  -6.70670629e-01f, -4.00932014e-01f, 1.33103848e-01f, 3.24425399e-01f, 4.63927478e-01f, 3.78848940e-01f, 2.66978711e-01f, 1.16120659e-01f, 3.53052206e-02f, -9.21607986e-02f,
  -1.62129641e-01f, -1.11283083e-02f, 5.62387332e-03f, 2.03851815e-02f, 1.12726822e-01f, 3.32952499e-01f, 4.88474846e-01f, 1.29495069e-01f, 1.33041993e-01f, 9.95806977e-02f,
  1.63520291e-01f, 2.34989915e-02f, -2.71082073e-01f, 8.72016549e-02f, 1.62794083e-01f, 1.58516705e-01f, 1.59750670e-01f, 1.89337850e-01f, 9.11493152e-02f, 3.19856435e-01f,
  -6.32687192e-03f, -4.79146183e-01f, 1.68715477e-01f, -1.16070636e-01f, -2.21451402e-01f, -2.32779086e-01f, 1.31767467e-02f, -2.07882315e-01f, -1.51423931e-01f, 9.20139849e-02f,
  -8.31099506e-03f, -1.31253436e-01f, -1.87396258e-02f, -7.18603432e-02f, 3.53774205e-02f, -1.72892779e-01f, -1.04797103e-01f, -7.25401714e-02f, -2.16920730e-02f, -7.04941452e-02f,
  -9.84684378e-02f, -1.16532877e-01f, 5.88696823e-02f, 7.00232163e-02f, 1.20048970e-02f, 1.75987389e-02f, -1.26623988e-01f, -8.22023973e-02f, -1.06645674e-01f, -7.37339184e-02f,
  1.83487743e-01f, -6.81269988e-02f, 5.95169701e-02f, -8.46283212e-02f, -2.12117285e-02f, -6.38323650e-02f, 4.93435971e-02f, 1.58879668e-01f, 1.17143512e-01f, 5.10925874e-02f,
  8.65350068e-02f, 6.63038120e-02f, 5.58365881e-02f, -1.06776180e-02f, 3.00422199e-02f, 3.60575058e-02f, 5.97962551e-02f, -7.20162466e-02f, -4.72758226e-02f, 2.64777262e-02f,
  2.54904293e-02f, 6.21337164e-03f, -7.28165433e-02f, 3.32655124e-02f, -8.34188014e-02f, -8.14237297e-02f, -6.93154484e-02f, -2.34623756e-02f, -9.03167948e-02f, -8.32824409e-02f,
  2.39870846e-01f, -7.89472982e-02f, 7.88917318e-02f, 5.41727021e-02f, 1.26070321e-01f, -2.86298990e-01f, -3.66763510e-02f, -1.09487303e-01f, -3.23577449e-02f, -1.98551118e-02f,
  -6.16774634e-02f, -2.02051271e-02f, 7.67063200e-02f, -6.82512075e-02f, 1.14338502e-01f, 3.82971950e-02f, -1.63812727e-01f, 7.69149736e-02f, -8.00750181e-02f, -1.30401775e-01f,
  -1.81450173e-01f, 1.00893810e-01f, 2.12266415e-01f, 1.73664406e-01f, 9.45973843e-02f, 1.78833231e-01f, 4.44947630e-02f, 9.36037451e-02f, 6.64520785e-02f, 4.56013680e-02f,
  8.70316923e-01f, 4.27091569e-01f, 3.49144101e-01f, 2.90518820e-01f, -3.54520947e-04f, -8.13827589e-02f, 2.16514263e-02f, -2.36455545e-01f, -2.62780547e-01f, 1.74583241e-01f,
  1.41547412e-01f, 4.83666584e-02f, -5.93626946e-02f, 1.95514830e-03f, 5.85798621e-02f, -2.08825409e-01f, -3.34565520e-01f, 6.50855973e-02f, 8.81398246e-02f, 1.68666784e-02f,
  -3.68522331e-02f, 1.52281895e-01f, 4.21427250e-01f, -9.89303924e-03f, 1.19973890e-01f, -1.49725527e-01f, -8.56952835e-03f, 1.13068789e-01f, 1.95320979e-01f, 3.11826587e-01f,
  6.47128344e-01f, 4.79306698e-01f, -3.76811057e-01f, -1.93516344e-01f, 7.60636777e-02f, -1.23293987e-02f, -5.61140254e-02f, -8.83935392e-02f, -1.47206178e-02f, -1.69233337e-01f,
  -6.44694567e-02f, -1.44042680e-02f, -5.79657182e-02f, -1.21563077e-01f, 2.44605374e-02f, -9.61643755e-02f, -1.32900015e-01f, 4.48841527e-02f, -1.38578907e-01f, -7.73019493e-02f,
  -1.29214883e-01f, 6.78461716e-02f, 3.71848010e-02f, -2.77559817e-01f, -2.60928576e-03f, -9.27812830e-02f, 6.36783913e-02f, 3.82603444e-02f, -4.38218080e-02f, 1.03941619e-01f,
  -4.47564274e-01f, -7.15067387e-02f, -7.04223290e-02f, -1.19753696e-01f, -1.01893894e-01f, -2.63054273e-03f, -8.90807156e-03f, 1.15341516e-02f, -8.77593085e-02f, -9.16746706e-02f,
  -5.93254082e-02f, 3.05325221e-02f, -1.47843291e-03f, -5.91140240e-02f, -2.09549457e-01f, -7.66192377e-02f, 9.88866575e-03f, -6.69124126e-02f, -1.25799552e-01f, 7.09348619e-02f,
  1.47495389e-01f, -4.82594334e-02f, -1.43303111e-01f, -6.97538927e-02f, -1.92962646e-01f, -1.81080148e-01f, -9.56908166e-02f, -1.29715756e-01f, -2.24529877e-01f, -4.49841544e-02f,
  -3.39776695e-01f, -9.84627474e-03f, 2.53311962e-01f, 1.56743929e-01f, 1.30227908e-01f, 6.63304776e-02f, 1.49407014e-01f, 1.51115328e-01f, 5.66536151e-02f, 8.95336866e-02f,
  1.29718065e-01f, 3.28755416e-02f, 4.07498479e-02f, -1.44657135e-01f, -6.24166690e-02f, -4.90059108e-02f, 4.10779156e-02f, 1.30713612e-01f, -1.19818039e-01f, -4.90183709e-03f,
  -2.22937450e-01f, -2.60841072e-01f, -1.56624809e-01f, -1.94848582e-01f, 5.67944348e-03f, -2.63414145e-01f, -9.51317176e-02f, -1.46170139e-01f, -2.69873887e-01f, -2.00796932e-01f,
  -2.91008174e-01f, 5.04500985e-01f, 1.46712393e-01f, -8.66304487e-02f, 3.84253979e-01f, -2.04354920e-03f, -1.40076905e-01f, -3.74085039e-01f, 1.70345739e-01f, 3.74607235e-01f,
  6.75395787e-01f, 2.39565447e-02f, -1.18027061e-01f, -5.07856309e-01f, -1.03420460e+00f, -2.94099599e-01f, -2.09016323e-01f, -7.95253932e-01f, -9.86184299e-01f, -6.13656878e-01f,
  -1.78515643e-01f, -4.00282085e-01f, -7.06992567e-01f, -5.71601748e-01f, 1.60731509e-01f, -1.88108027e-01f, 1.31239876e-01f, -1.87916439e-02f, -2.27819473e-01f, 4.56984863e-02f,
  -1.90696090e-01f, -1.30833536e-01f, -2.03582838e-01f, 9.32716206e-02f, 3.96479100e-01f, -2.73816258e-01f, -1.94449164e-02f, 2.96099167e-02f, 7.01609552e-02f, -1.34111553e-01f,
  2.42618009e-01f, 7.55442604e-02f, 2.02721983e-01f, -1.86803505e-01f, -9.40942764e-02f, -3.64488065e-01f, -2.60169148e-01f, -5.84807754e-01f, -2.93760121e-01f, 9.13648084e-02f,
  4.14999187e-01f, -5.23182657e-03f, -3.78375232e-01f, -2.98156410e-01f, -5.58227003e-01f, -1.91833541e-01f, -1.75911456e-01f, -3.26733798e-01f, -5.78914762e-01f, -5.17711282e-01f,
  -1.08449578e-01f, 9.85688046e-02f, 1.10643931e-01f, 1.06195221e-02f, -8.84465352e-02f, 2.18421966e-01f, -1.25790192e-02f, -1.32064208e-01f, -4.73215394e-02f, -4.52075936e-02f,
  -4.66872863e-02f, 1.94410980e-01f, 1.43003389e-01f, 3.57946940e-02f, -1.87685385e-01f, 2.68460698e-02f, 4.95133996e-02f, -1.44109979e-01f, -1.13295026e-01f, -3.60323563e-02f,
  -1.33336142e-01f, -1.14131942e-01f, 2.02281982e-01f, -2.57116646e-01f, 8.27034265e-02f, 5.65704927e-02f, 7.92796165e-02f, -1.94339883e-02f, -1.35405689e-01f, 7.04295561e-02f,
  -3.22774678e-01f, 1.93782561e-02f, -2.38207746e-02f, -3.05381507e-01f, 7.29423314e-02f, 2.08592251e-01f, 2.05826551e-01f, 8.01772773e-02f, 1.65849388e-01f, -1.75384596e-01f,
  -5.30084558e-02f, -7.42820203e-02f, 3.05033296e-01f, -6.57972693e-02f, -1.04975186e-01f, -4.95569073e-02f, -4.81993407e-02f, 9.25153345e-02f, -7.98256174e-02f, 3.51237565e-01f,
  -9.54748839e-02f, -5.01617312e-01f, -6.16499007e-01f, -4.22890216e-01f, -5.28134406e-01f, -5.90042651e-01f, -3.75703007e-01f, -3.52610707e-01f, -6.56500697e-01f, -9.06624198e-01f,
  8.07500243e-01f, 3.97195309e-01f, 1.22757941e-01f, 1.85722008e-01f, 4.61333364e-01f, 4.99180198e-01f, 5.87794542e-01f, 3.16269547e-01f, 5.17676696e-02f, 3.03243458e-01f,
  4.82973665e-01f, 2.34802708e-01f, 1.63399771e-01f, 1.65717050e-01f, 1.85647324e-01f, -1.66619159e-02f, -2.97310740e-01f, -9.46054533e-02f, 4.33498733e-02f, 1.10510893e-01f,
  4.56305817e-02f, 1.11317389e-01f, 1.41813934e-01f, -3.61131690e-02f, -2.47770861e-01f, -1.61452636e-01f, -3.38860266e-02f, 5.12602888e-02f, 5.25045246e-02f, -5.77416062e-01f,
  -3.07609469e-01f, 3.05554986e-01f, -1.75867617e-01f, -1.45647198e-01f, 6.71779141e-02f, -1.18717156e-01f, -7.18208179e-02f, -1.19855702e-01f, -1.60219058e-01f, -1.66430384e-01f,
  -8.63200203e-02f, -2.41013523e-02f, 5.94291128e-02f, 7.41069913e-02f, -3.29515561e-02f, 9.56205577e-02f, 1.89733648e-04f, -1.01897597e-01f, -6.34677783e-02f, -7.54363835e-02f,
  -7.60790240e-03f, 1.52720675e-01f, 1.01275675e-01f, 7.75182173e-02f, 1.49180382e-01f, 1.11705549e-01f, 1.16702333e-01f, 4.35856655e-02f, 2.53290264e-03f, -2.07501709e-01f,
  -2.23366454e-01f, -4.37463596e-02f, 7.87210092e-02f, -6.45275488e-02f, -8.92300252e-03f, -5.35624325e-02f, -4.91696522e-02f, 7.16437846e-02f, 9.14108823e-04f, 5.91171607e-02f,
  -1.30601048e-01f, -1.90574005e-02f, -2.14104056e-02f, -7.51755536e-02f, 3.49601768e-02f, 8.14063996e-02f, -5.89305684e-02f, 7.60928690e-02f, 1.11173600e-01f, -2.01328285e-03f,
  8.90511274e-02f, 1.13017270e-02f, 1.28495544e-01f, 3.56192030e-02f, 9.64999348e-02f, 1.57229707e-01f, -8.30316991e-02f, 1.40200764e-01f, 1.28426626e-01f, 2.31591016e-02f,
  -2.02172577e-01f, 4.40640986e-01f, -1.76546618e-01f, -1.84519872e-01f, -3.37601677e-02f, -1.53175835e-03f, -5.50579606e-03f, -1.60968170e-01f, -1.19014800e-01f, -3.09195220e-01f,
  -9.10332054e-03f, -1.21089965e-01f, 6.46419227e-02f, -1.02766072e-02f, -1.77071810e-01f, -1.17441118e-02f, -4.56790626e-02f, -1.17327869e-02f, -1.09010123e-01f, -2.40436718e-01f,
  2.01417692e-02f, -4.41453420e-02f, -6.14344776e-02f, -3.10956929e-02f, -1.45934850e-01f, -1.19503945e-01f, -6.33082837e-02f, -1.47069693e-01f, 1.56012448e-02f, 5.19874319e-02f,
  8.08416784e-01f, -7.08209932e-01f, 5.68211898e-02f, 2.30394572e-01f, 2.24099055e-01f, 3.44832271e-01f, 3.89905982e-02f, -3.80100086e-02f, -5.57004241e-04f, -2.66042612e-02f,
  -2.47023124e-02f, 1.28894046e-01f, 2.33509064e-01f, 1.31917298e-01f, -4.19904739e-02f, -1.58389971e-01f, -2.56232709e-01f, 2.50556856e-01f, 4.43789750e-01f, 2.13119507e-01f,
  -1.96714982e-01f, -2.75242105e-02f, -5.46128787e-02f, -1.23279288e-01f, -3.00767988e-01f, 5.40731773e-02f, -2.12664902e-01f, -3.18408251e-01f, -2.85109758e-01f, -4.82902318e-01f,
  2.16492817e-01f, -2.73639083e-01f, 1.94551110e-01f, -1.76458985e-01f, -1.29234463e-01f, -2.44759861e-02f, 6.61232844e-02f, -9.37203243e-02f, -1.00057118e-01f, -6.52766824e-02f,
  -8.42029676e-02f, -9.33372509e-03f, -4.38039638e-02f, -3.41080837e-02f, -8.20480660e-02f, 7.58634433e-02f, -2.39036992e-01f, -1.37868807e-01f, -6.37411475e-02f, -8.68726373e-02f,
  -2.31466725e-01f, -1.52005970e-01f, -3.65904649e-03f, -3.96743901e-02f, -8.06026980e-02f, 1.66737974e-01f, -1.80125907e-01f, -3.98364030e-02f, -4.21078168e-02f, -1.25498865e-02f,
  -2.91984707e-01f, 1.41132653e-01f, 1.24884890e-02f, 1.36029981e-02f, 9.05388743e-02f, 8.96816701e-02f, 5.58965690e-02f, 5.64832874e-02f, 3.68438177e-02f, -5.13920076e-02f,
  2.40123970e-03f, 1.28525302e-01f, 1.23345703e-01f, 2.26195566e-02f, 3.19036730e-02f, 4.70198225e-03f, 3.93724702e-02f, -3.40808108e-02f, -1.30060624e-04f, 7.09626963e-03f,
  -2.73462683e-02f, -1.52024791e-01f, -1.91705897e-01f, -1.12391725e-01f, -2.10250586e-01f, -5.23765571e-02f, -4.53160815e-02f, -2.39301156e-02f, 4.39190529e-02f, -1.74866319e-01f,
  9.45214927e-02f, 5.66956848e-02f, 7.96163678e-02f, -4.99230362e-02f, -1.04013048e-01f, -8.04037824e-02f, 7.37118572e-02f, -5.28578162e-02f, -1.14052378e-01f, 3.16294678e-03f,
  -2.39918046e-02f, 6.62601292e-02f, -9.67177823e-02f, -2.13285331e-02f, 2.47169182e-01f, 4.46774997e-02f, -1.39318570e-01f, 6.46350160e-02f, -1.29902735e-01f, -1.77183166e-01f,
  -1.78958967e-01f, 1.90492600e-01f, 4.38298106e-01f, 3.42639446e-01f, 1.29861668e-01f, 4.04669076e-01f, 1.23038955e-01f, 1.21724337e-01f, 2.20820159e-01f, 2.98797339e-01f,
  1.28467739e-01f, 1.11718929e+00f, 5.75874820e-02f, -3.85331601e-01f, -1.72345012e-01f, 5.55499494e-02f, 9.06150937e-01f, 4.41964060e-01f, -2.52605021e-01f, 4.54719186e-01f,
  2.02857733e-01f, -5.99271476e-01f, -3.57164778e-02f, -1.01425834e-01f, 9.26973149e-02f, 7.53125250e-01f, 4.11697060e-01f, -5.40631294e-01f, -1.05379736e+00f, -5.00056028e-01f,
  -2.44586721e-01f, -3.53263766e-01f, -3.81998062e-01f, -1.00124523e-01f, 1.27689913e-01f, -2.08435595e-01f, 4.67188090e-01f, 9.16427597e-02f, 1.34267226e-01f, -9.04598907e-02f,
  -3.21220219e-01f, 5.46471596e-01f, -5.64846635e-01f, -2.61336952e-01f, -1.33983597e-01f, -1.49999514e-01f, -1.44652007e-02f, -7.29390327e-03f, -1.66020691e-01f, 2.34212242e-02f,
  -2.80267417e-01f, -2.21831530e-01f, -1.25015518e-02f, -3.66434678e-02f, -7.66364932e-02f, -8.13240260e-02f, 1.81391090e-01f, 3.92625034e-02f, -4.15849984e-02f, 1.20888807e-01f,
  1.95947960e-02f, 1.00414641e-02f, 8.62626135e-02f, 1.52399629e-01f, 9.97325331e-02f, -2.64145851e-01f, 1.73547462e-01f, -4.89898957e-02f, 9.89678428e-02f, 1.64053872e-01f,
  -1.04677435e-02f, 5.54659739e-02f, 7.18178898e-02f, 1.70117438e-01f, 1.57600954e-01f, -2.87317578e-02f, -1.46495877e-02f, -3.83673199e-02f, -4.51056063e-02f, -1.47691611e-02f,
  -8.36093817e-03f, 9.29888897e-03f, -8.29604045e-02f, 2.02766433e-01f, -3.99944223e-02f, 1.20561458e-01f, -1.42867893e-01f, 2.17692688e-01f, 9.19819623e-02f, 1.65432662e-01f,
  -9.17065069e-02f, -1.06023803e-01f, -1.32535264e-01f, -1.61694095e-01f, 6.23060614e-02f, -2.79021226e-02f, -8.37638043e-03f, -1.54463649e-01f, -5.92184998e-02f, 2.40192220e-01f,
  -4.11631614e-01f, 5.77653870e-02f, -2.11399305e-03f, 7.01107457e-02f, 1.67336613e-01f, 1.00047193e-01f, 2.46338639e-02f, -6.67300373e-02f, -6.10658601e-02f, -1.40943736e-01f,
  4.74713184e-02f, 2.77180672e-02f, 2.73659706e-01f, -4.19461653e-02f, -2.97981501e-01f, -8.41815546e-02f, 2.10331917e-01f, -2.34778941e-01f, -1.49987161e-01f, 4.87670191e-02f,
  2.37322599e-01f, -1.44662976e-01f, -2.36161888e-01f, -1.43724801e-02f, -7.71847814e-02f, -3.59396070e-01f, -7.33868629e-02f, -2.57454902e-01f, -1.04129128e-01f, 1.67794108e-01f,
  -9.77803469e-01f, -4.07758683e-01f, -8.77295077e-01f, -1.15520620e+00f, -7.66112804e-01f, 3.81657667e-02f, 3.11461061e-01f, 7.03532025e-02f, -6.32349312e-01f, -3.11141104e-01f,
  2.09353894e-01f, 3.41243297e-01f, -2.41814062e-01f, 2.91352212e-01f, 4.52796161e-01f, -2.56744593e-01f, -8.23870838e-01f, -3.53360057e-01f, 5.70982397e-01f, 8.53335023e-01f,
  3.78021985e-01f, -2.80485272e-01f, -2.51614302e-01f, -2.89156228e-01f, -4.77537423e-01f, -1.75297946e-01f, -8.05324733e-01f, -4.31948245e-01f, -9.52401906e-02f, -7.97727704e-01f,
  4.51467693e-01f, -5.59422076e-01f, 1.28973365e-01f, -6.44443780e-02f, -2.52446562e-01f, 1.36037888e-02f, 5.82039654e-02f, -3.68549377e-01f, 1.19069256e-02f, -2.20408574e-01f,
  -3.48767787e-01f, 1.37674902e-02f, -3.66034247e-02f, 1.01041570e-02f, -1.36288837e-01f, 1.20841578e-01f, -2.15711817e-01f, -1.01642579e-01f, -2.49538362e-01f, 1.02126829e-01f,
  1.98009387e-01f, -1.23392008e-01f, -1.27038196e-01f, 1.59132883e-01f, 6.20846450e-02f, -5.99229559e-02f, 7.16771930e-02f, -2.30182726e-02f, -2.04797164e-01f, -3.05056602e-01f,
  -3.13422158e-02f, -2.61455104e-02f, -1.30000729e-02f, 1.57362744e-02f, 1.74743980e-01f, 9.24219638e-02f, -1.59805894e-01f, 1.62887096e-01f, 1.26206979e-01f, 1.80151641e-01f,
  -3.09375171e-02f, -3.74461636e-02f, 5.64950891e-02f, -1.35808121e-02f, -2.40483731e-02f, -2.76388675e-01f, 2.76921075e-02f, 4.58193645e-02f, -1.19105317e-02f, -1.14426516e-01f,
  -2.44413107e-03f, 5.20514697e-02f, -2.08706170e-01f, 1.10369012e-01f, -1.07620554e-02f, -1.94620013e-01f, -1.31947875e-01f, 2.33738139e-01f, -1.85233690e-02f, -1.16860710e-01f,
  3.36730897e-01f, 6.10110760e-02f, 1.48020498e-02f, 1.12471229e-03f, -4.05123085e-01f, -1.82278439e-01f, -2.12732598e-01f, -1.35857925e-01f, -1.88494697e-01f, 1.11057632e-01f,
  1.37542367e-01f, 8.59512761e-02f, -1.33264989e-01f, -4.50689869e-04f, 1.37007788e-01f, 5.34186400e-02f, 7.12200068e-03f, -2.16658302e-02f, -5.05283996e-02f, -9.25781354e-02f,
  -7.40655512e-02f, 1.32556215e-01f, 2.92297423e-01f, 1.37974992e-01f, 3.17485482e-02f, 8.26306567e-02f, 2.67866194e-01f, 2.56450802e-01f, 2.41543829e-01f, 2.48939484e-01f,
  2.03038335e-01f, 7.80608952e-01f, 7.09861284e-03f, 2.67944515e-01f, 1.44661099e-01f, -8.27971622e-02f, 1.10022500e-01f, 9.66812968e-02f, 1.63970187e-01f, 2.84625202e-01f,
  2.48677015e-01f, 1.84060484e-01f, 6.44490421e-02f, -2.67129354e-02f, 3.25411260e-02f, 1.36521280e-01f, 2.37773523e-01f, -1.75881460e-01f, -2.31272474e-01f, 1.14991069e-02f,
  1.97111264e-01f, 1.41111493e-01f, -6.49296865e-02f, 7.31172115e-02f, 4.07956690e-01f, 2.00503528e-01f, 2.19160855e-01f, 3.62563908e-01f, 3.27104092e-01f, 7.32300878e-01f,
  -6.26212498e-03f, 1.29294097e-01f, -2.15896651e-01f, -1.33293733e-01f, -1.31226778e-01f, -7.92141557e-02f, -1.05030097e-01f, -2.28397604e-02f, -1.05386883e-01f, -6.83362857e-02f,
  -2.09239987e-03f, -6.42728209e-02f, -1.45023108e-01f, -1.14773124e-01f, -1.51862651e-01f, -1.76920220e-01f, -1.81961119e-01f, 2.10593101e-02f, 1.33787922e-03f, 2.84084976e-02f,
  7.64639005e-02f, -9.46444459e-03f, -4.85495292e-02f, -1.39858514e-01f, -2.05091029e-01f, -1.61301970e-01f, 2.19198875e-02f, 5.74860089e-02f, -1.32528469e-01f, 1.33218199e-01f,
  -2.25087300e-01f, 2.78158356e-02f, -5.85533231e-02f, -4.64899726e-02f, -4.82355468e-02f, -1.72714993e-01f, -5.88330030e-02f, -1.81493553e-04f, -1.90863013e-01f, -2.28236496e-01f,
  -2.54779179e-02f, 1.00082057e-02f, -9.60222408e-02f, -2.43056759e-01f, -1.42042324e-01f, 7.34129027e-02f, 3.23767141e-02f, -6.32080659e-02f, -1.82447866e-01f, 5.61138801e-02f,
  -4.77781929e-02f, -5.07229492e-02f, -5.05542606e-02f, -7.31446743e-02f, 5.31202927e-02f, -2.11574152e-01f, -1.04243226e-01f, -4.10032123e-02f, -5.79270124e-02f, 7.84117430e-02f,
  5.94681501e-02f, -4.28790182e-01f, 1.95291594e-01f, 2.10895672e-01f, 1.94215938e-01f, 1.13924675e-01f, 1.15205817e-01f, 8.09343159e-02f, 1.41560853e-01f, 4.17293608e-02f,
  4.63750698e-02f, 1.12353452e-02f, -3.77237387e-02f, 4.64658998e-02f, -2.73659021e-01f, -2.36235797e-01f, 8.39481428e-02f, 1.84149742e-01f, 1.58621520e-01f, 8.36523473e-02f,
  1.01543002e-01f, 1.36788446e-03f, -6.49320856e-02f, -1.37235016e-01f, -9.62243006e-02f, -5.99857718e-02f, -2.01496676e-01f, 2.05084607e-02f, -1.60431847e-01f, -2.38296852e-01f,
  1.21552563e+00f, 5.46559870e-01f, -3.55149120e-01f, 9.79592055e-02f, -4.55123752e-01f, -1.87416002e-01f, 1.21952638e-01f, 2.89455652e-01f, 1.27442881e-01f, 1.47427067e-01f,
  7.74706975e-02f, 4.52004522e-02f, -1.70009919e-02f, 7.38944635e-02f, 1.77633032e-01f, -6.42019063e-02f, -2.87092775e-01f, -9.88990441e-02f, -6.86724260e-02f, -5.90935387e-02f,
  -2.97006965e-02f, 1.82756200e-01f, 4.93313104e-01f, 9.90343466e-02f, -1.36408985e-01f, -1.28689408e-01f, 4.77005262e-03f, -1.58881098e-01f, -1.53849214e-01f, -3.85298938e-01f,
  -5.10833502e-01f, 1.69083234e-02f, 9.34252366e-02f, 7.48359263e-02f, 1.44036710e-01f, 2.80210316e-01f, 6.89200908e-02f, 1.48722574e-01f, 1.83638707e-01f, 7.41611645e-02f,
  -3.47200930e-02f, -6.65287971e-02f, -6.24367148e-02f, -2.82389075e-02f, -1.21180005e-02f, -1.91449411e-02f, 1.20263979e-01f, -4.35664207e-02f, -9.25809368e-02f, -3.85306478e-02f,
  -1.71288565e-01f, -1.13380693e-01f, -1.04696885e-01f, -9.67621878e-02f, 2.31071115e-02f, -1.45136014e-01f, -3.49833593e-02f, -4.25813440e-03f, -3.84343192e-02f, 1.34973913e-01f,
  1.43628061e-01f, 3.13366920e-01f, -5.03686480e-02f, -2.50574559e-01f, -6.64452612e-02f, 2.14141488e-01f, 2.92808209e-02f, -2.49418877e-02f, 7.50757679e-02f, 1.55047476e-01f,
  -2.88796891e-02f, -2.15414479e-01f, -1.27801418e-01f, 1.23597115e-01f, -4.23580632e-02f, -1.81280941e-01f, -8.36396683e-03f, -6.31237701e-02f, -1.54328763e-01f, -1.00348637e-01f,
  -1.66677415e-01f, -9.37006548e-02f, 6.83097243e-02f, -8.96212757e-02f, -1.19254135e-01f, -1.04694799e-01f, -1.63028553e-01f, 3.24202813e-02f, 1.57650203e-01f, 1.13073066e-01f,
  -5.26571013e-02f, -3.71680468e-01f, -1.24807954e-01f, 6.31612912e-02f, -7.03000724e-02f, 3.32533941e-02f, -2.40244314e-01f, -5.45868762e-02f, 3.13089713e-02f, -1.19862825e-01f,
  -2.44072825e-02f, 1.21952057e-01f, 1.22528616e-02f, 9.51786265e-02f, 7.91352242e-02f, -6.89372197e-02f, 1.34389535e-01f, 8.88179243e-03f, -1.06999032e-01f, -3.14956531e-02f,
  1.25679016e-01f, -9.07583686e-04f, 1.13689892e-01f, 1.25502467e-01f, 4.49552387e-02f, 7.51634538e-02f, 5.31910919e-02f, -9.19562951e-02f, 7.17635974e-02f, 4.20491010e-01f,
  8.14014450e-02f, -3.04957896e-01f, 5.17876446e-01f, -9.84170511e-02f, 5.82928061e-01f, 5.39870143e-01f, 6.02579057e-01f, 1.39544934e-01f, -1.51927127e-02f, 5.47553040e-02f,
  -3.10764313e-01f, -7.17921913e-01f, -6.46255910e-01f, -4.33367938e-01f, -3.28847677e-01f, 2.10540101e-01f, 2.88913101e-01f, -6.19945209e-03f, 2.12152764e-01f, 2.60670960e-01f,
  4.42363042e-03f, 1.72162727e-01f, 1.00671295e-02f, -5.11934943e-02f, -7.18413442e-02f, -2.83051401e-01f, 8.18133131e-02f, 2.56397784e-01f, 1.43642798e-01f, -3.01414460e-01f,
  -1.66771501e-01f, -5.87599874e-02f, -5.61403893e-02f, -5.41169457e-02f, -4.20440845e-02f, -1.61041513e-01f, -7.36262202e-02f, -8.51036385e-02f, -1.30090326e-01f, 5.60185537e-02f,
  -7.54133314e-02f, -9.17887241e-02f, -1.39349625e-01f, -1.70469671e-01f, 9.54111442e-02f, 1.74026102e-01f, -4.11762334e-02f, -1.00820892e-01f, -2.63718992e-01f, -1.77715778e-01f,
  -1.91352755e-01f, 1.47204906e-01f, 2.17656896e-01f, -7.66693950e-02f, -1.22682326e-01f, 6.35653362e-02f, -7.14000687e-02f, -5.87460473e-02f, 2.48293243e-02f, -9.97858122e-02f,
  1.65134549e-01f, -2.33947951e-03f, -1.13084763e-01f, -4.91811521e-02f, -2.18326915e-02f, 2.57542636e-02f, 1.13213314e-02f, -1.01272874e-01f, -1.27720594e-01f, 9.10502765e-03f,
  -2.04031169e-01f, -1.67441353e-01f, -1.43971398e-01f, -3.49670909e-02f, -1.86316818e-01f, -9.36148837e-02f, -8.59710872e-02f, -1.14234984e-01f, -1.23679616e-01f, -6.69359192e-02f,
  -5.70047759e-02f, 1.03313271e-02f, 1.24219626e-01f, -7.36650229e-02f, 8.24863538e-02f, -1.00705922e-01f, 5.97648555e-03f, -1.40458271e-01f, 3.75440717e-02f, -1.76475849e-02f,
  -4.92087752e-01f, -4.03311290e-02f, -1.04124330e-01f, -2.04133153e-01f, 1.58633769e-01f, -5.64711615e-02f, -2.76020080e-01f, 4.57035638e-02f, 7.95419589e-02f, -4.83768396e-02f,
  7.34693334e-02f, -6.77675977e-02f, -3.65354419e-02f, -1.56955063e-01f, 1.13162182e-01f, 1.67093873e-01f, 1.32778203e-02f, -8.69715437e-02f, 1.59719810e-02f, -2.02468392e-02f,
  -1.45176006e-02f, 1.93433613e-01f, 9.97065306e-02f, -3.95993963e-02f, -8.73851329e-02f, 1.81998745e-01f, 1.50157943e-01f, 1.89731881e-01f, 3.19354653e-01f, 3.62837255e-01f,
  6.41418099e-01f, 5.07794440e-01f, 5.36190450e-01f, 2.56425664e-02f, -3.69471371e-01f, 1.67198628e-01f, 4.61455047e-01f, 4.13552493e-01f, -1.31295085e-01f, -9.48775634e-02f,
  -6.66015565e-01f, -6.46203756e-01f, -3.80186141e-01f, -1.61698282e-01f, 2.39534333e-01f, 2.92609304e-01f, 2.59543240e-01f, 5.12046158e-01f, 2.31460184e-01f, -1.68878317e-01f,
  -2.66733587e-01f, 1.49132982e-01f, 2.15014249e-01f, 1.61494210e-01f, -1.43141216e-02f, -3.84223253e-01f, 7.99230486e-02f, 1.52491078e-01f, -4.83298339e-02f, 6.42790273e-02f,
  -2.60366201e-01f, 3.72923821e-01f, -3.97876531e-01f, -4.60635751e-01f, -6.46369830e-02f, 1.21078670e-01f, 4.07226384e-02f, 1.25779912e-01f, -3.11633963e-02f, 1.39497980e-01f,
  -1.55831918e-01f, -2.96976212e-02f, -3.38939950e-02f, 8.64330530e-02f, 2.03436658e-01f, 4.38298918e-02f, 2.19848871e-01f, 5.87283254e-01f, 3.66671860e-01f, 7.90763497e-02f,
  -4.36845392e-01f, -1.55429870e-01f, 2.91801721e-01f, -6.91889087e-03f, 2.46486455e-01f, -3.04909199e-01f, 1.02205828e-01f, 1.08711854e-01f, 1.26219064e-01f, 1.25926659e-01f,
  -3.96803200e-01f, -2.57344782e-01f, -3.95731665e-02f, 1.38626024e-01f, 2.32663527e-02f, -1.81291383e-02f, 1.42257020e-01f, -6.98680729e-02f, -5.45861907e-02f, 1.26522720e-01f,
  7.72939399e-02f, 2.76684761e-02f, 2.68213123e-01f, 1.37012869e-01f, -2.23081663e-01f, 1.19532570e-01f, 1.71709925e-01f, 1.11379765e-01f, -2.66747270e-02f, 6.45987540e-02f,
  -1.29100438e-02f, 8.78406838e-02f, 2.32285745e-02f, 1.99014574e-01f, -5.33388592e-02f, 1.63436055e-01f, -2.56383617e-04f, -2.82473024e-02f, -5.26644103e-02f, -8.86461213e-02f,
  -1.39181867e-01f, -3.59485708e-02f, -2.14025319e-01f, -1.64799150e-02f, -7.31764957e-02f, -1.99118942e-01f, -2.00660616e-01f, -1.73028275e-01f, -2.73635071e-02f, 7.38191456e-02f,
  5.59927721e-04f, 6.40386045e-02f, 1.62630677e-01f, 1.16411768e-01f, -2.25072633e-02f, -7.52510503e-02f, -2.30518833e-01f, 8.71692151e-02f, -5.28331026e-02f, -6.13527093e-03f,
  -2.81694066e-02f, -7.40193278e-02f, -2.19193637e-01f, -2.64503270e-01f, -3.51605654e-01f, -6.39813006e-01f, -1.78587630e-01f, -1.05053119e-01f, -1.11953586e-01f, -1.62477508e-01f,
  -1.41819823e+00f, -2.03447685e-01f, 2.89630920e-01f, -5.61286688e-01f, 1.30471468e-01f, 2.40195528e-01f, -4.15791851e-03f, 4.26935405e-01f, 1.82983093e-02f, -5.32651603e-01f,
  -2.32596815e-01f, -1.33958355e-01f, -3.39108706e-01f, -9.05261748e-03f, 2.51842458e-02f, -1.34753898e-01f, -1.20541062e-02f, -5.56637011e-02f, 3.86974066e-01f, 3.37799221e-01f,
  -5.11748157e-02f, -3.86217773e-01f, -4.67414439e-01f, 4.81021963e-02f, -2.52242386e-01f, -2.31465563e-01f, -2.78408349e-01f, -3.24897736e-01f, -9.34899598e-02f, -6.29825294e-01f,
  -6.48484230e-01f, -1.90863043e-01f, 3.89133245e-01f, 5.24103008e-02f, -1.17997102e-01f, -2.91948855e-01f, -2.05697253e-01f, -9.19672102e-02f, -1.86985090e-01f, -3.38837653e-02f,
  -1.69408351e-01f, 4.28227544e-01f, -1.75523072e-01f, -2.31399219e-02f, -1.08830035e-01f, -4.22312245e-02f, 3.38195026e-01f, 1.36890322e-01f, -5.11789881e-02f, 3.93968314e-01f,
  1.56797484e-01f, -4.59405869e-01f, -3.23039085e-01f, 4.44960445e-01f, 3.50531280e-01f, -6.04740046e-02f, 1.16633147e-01f, 1.61738187e-01f, -8.48481357e-02f, -6.97790802e-01f,
  5.29711545e-02f, 6.69670552e-02f, 3.01990718e-01f, 1.68754295e-01f, -3.77315283e-02f, 1.85673777e-02f, -1.57755658e-01f, -1.64679497e-01f, 1.37524575e-01f, -1.87345132e-01f,
  2.80825883e-01f, -7.95638561e-03f, 2.29379684e-02f, -1.99353710e-01f, -1.68046635e-02f, -2.13710129e-01f, -2.51336038e-01f, -1.37440071e-01f, -2.21092239e-01f, -6.42921627e-02f,
  -5.59146479e-02f, -1.36499017e-01f, -5.26453136e-03f, -1.14427567e-01f, 4.55366820e-02f, 1.33051172e-01f, 1.11915835e-03f, 2.49195293e-01f, 2.93403029e-01f, 1.49972662e-01f,
  -3.27758342e-01f, 3.73194903e-01f, -9.13620412e-01f, -1.19620105e-02f, -2.03848779e-01f, 1.99696776e-02f, -1.08560205e-01f, 2.91026503e-01f, -6.22988008e-02f, -4.81889583e-02f,
  3.32384139e-01f, -5.07888794e-02f, -1.07044376e-01f, 3.40396613e-01f, -1.36103168e-01f, 1.87903680e-02f, -1.40939221e-01f, -2.96967894e-01f, 8.31539631e-02f, -4.94207405e-02f,
  -7.86452368e-03f, -4.50077802e-01f, -9.37937975e-01f, -5.03837943e-01f, -8.18862766e-02f, -4.90398020e-01f, -4.52260375e-01f, -2.38236919e-01f, -5.97669423e-01f, -1.18778265e+00f,
  -2.10724413e-01f, -7.30039716e-01f, -6.96799755e-01f, 8.02536309e-03f, 1.48636818e-01f, -4.86235976e-01f, -9.64437604e-01f, -6.80281460e-01f, -1.68507203e-01f, -6.10238552e-01f,
  -2.41622329e-01f, 2.14152679e-01f, -4.50338960e-01f, -1.07210867e-01f, -3.04196179e-01f, -4.48876202e-01f, -9.88132358e-02f, 2.71610439e-01f, 5.44074416e-01f, 6.48667872e-01f,
  7.55478203e-01f, 6.36430919e-01f, 6.30904675e-01f, 5.72095037e-01f, 5.50904512e-01f, 4.55063403e-01f, -5.63437305e-02f, 3.84011716e-01f, 2.92980582e-01f, 4.04299170e-01f,
  -4.24720496e-01f, -4.36964095e-01f, 3.79341729e-02f, 4.70974594e-01f, 1.16938964e-01f, 6.81801364e-02f, -1.28316909e-01f, -7.40010813e-02f, -9.80853438e-02f, -4.51276302e-02f,
  5.17258868e-02f, 5.80268987e-02f, -5.03547005e-02f, 1.38578936e-01f, 9.46978256e-02f, -1.08743049e-01f, 1.59997746e-01f, -2.60445774e-01f, -3.58392030e-01f, -4.94110659e-02f,
  4.10437495e-01f, 4.30241942e-01f, -4.95855689e-01f, -4.55413729e-01f, -5.39221048e-01f, 1.21577993e-01f, -2.47095257e-01f, 9.52919424e-02f, -6.16840899e-01f, -3.00565034e-01f,
  -6.15376867e-02f, -1.04417443e-01f, -6.12721816e-02f, -3.11048627e-02f, 1.78477213e-01f, -5.71235605e-02f, 3.35057713e-02f, 6.72996640e-02f, -1.00494064e-02f, -8.81764144e-02f,
  -1.44173890e-01f, -2.48852633e-02f, -5.16666099e-02f, -6.87422752e-02f, 1.11848973e-01f, 7.82946423e-02f, 1.00228854e-01f, 1.96561992e-01f, 1.79515734e-01f, -8.41229260e-02f,
  -7.18744192e-03f, -8.07714239e-02f, 2.19682917e-01f, 6.31414801e-02f, -2.23208487e-01f, -8.96754414e-02f, 1.47045076e-01f, 1.12690166e-01f, -6.25852495e-02f, -7.95008987e-02f,
  2.53358688e-02f, 1.73620626e-01f, -3.30447197e-01f, 1.95452385e-02f, -6.80918805e-04f, 1.71358272e-01f, -1.86680242e-01f, -1.77419442e-03f, -9.11059380e-02f, -1.62479967e-01f,
  -2.78373808e-01f, -2.82140464e-01f, -1.45648405e-01f, 1.36954635e-01f, 4.69998904e-02f, -1.17621094e-01f, 1.57457396e-01f, -1.73378915e-01f, -3.37579876e-01f, -4.64458689e-02f,
  -1.28445357e-01f, -2.53474474e-01f, -4.43523914e-01f, -6.52500927e-01f, -1.96151763e-01f, -4.34490591e-01f, -2.04890758e-01f, -2.70984262e-01f, -7.55040348e-01f, -7.20998704e-01f,
  1.12032998e+00f, -2.88539529e-01f, 2.24620685e-01f, -5.31211728e-03f, -3.83953422e-01f, -2.02312350e-01f, -3.39996159e-01f, -1.24376155e-01f, 3.36065665e-02f, -9.91274416e-03f,
  -1.18356459e-01f, 6.22587167e-02f, 2.78677285e-01f, 2.60230005e-01f, 3.60839844e-01f, -5.23387901e-02f, 5.67895286e-02f, 4.65732574e-01f, 4.27726537e-01f, -3.98887396e-02f,
  -3.01576018e-01f, -4.45745923e-02f, 3.60499173e-01f, 2.84628779e-01f, -2.25275055e-01f, 1.06584057e-01f, -1.36876544e-02f, -3.90172750e-02f, -1.63935781e-01f, 4.18470474e-03f,
  1.53371785e-02f, 2.02916071e-01f, 4.86906618e-02f, 1.56336632e-02f, -5.25120981e-02f, 1.44915015e-01f, 3.46838534e-02f, 1.87408198e-02f, -1.33593440e-01f, -1.97211266e-01f,
  -4.63134870e-02f, 7.51362741e-02f, 1.01253971e-01f, -1.11874893e-01f, -7.37715513e-02f, 9.18295421e-03f, -7.76055409e-03f, -1.45829199e-02f, -6.35596961e-02f, -3.51380259e-02f,
  -2.16755286e-01f, -5.99712357e-02f, -1.77047908e-01f, -2.40038671e-02f, 1.01012677e-01f, 1.53915048e-01f, -5.78994974e-02f, -2.40023471e-02f, 1.67041481e-01f, 3.74547727e-02f,
  1.40571699e-01f, 2.34501529e-02f, 2.74819862e-02f, 3.22209559e-02f, 1.21956855e-01f, -6.57257438e-02f, -1.01204358e-01f, -1.05649859e-01f, 2.37033620e-01f, 3.89854126e-02f,
  -2.60856748e-01f, 7.31245056e-02f, 1.09339822e-02f, -5.02301678e-02f, 1.53683424e-01f, 4.58833650e-02f, -5.92546165e-02f, -5.17903715e-02f, 1.44004542e-02f, -3.48803811e-02f,
  1.70490772e-01f, -7.99864531e-03f, 4.24518958e-02f, -9.30517316e-02f, -1.69164747e-01f, -8.05509239e-02f, 4.38216096e-03f, 3.67628634e-02f, 3.00256051e-02f, -7.32317865e-02f,
  -3.53864670e-01f, 3.01195800e-01f, 1.73872709e-01f, 1.52334094e-01f, 1.94442719e-02f, 7.32112080e-02f, 9.99895856e-02f, -1.43885881e-01f, -1.93428189e-01f, -1.62388384e-01f,
  -1.30715027e-01f, 1.48955852e-01f, 7.48755410e-03f, -1.65110212e-02f, 3.96725461e-02f, -9.94728412e-04f, -5.91359474e-02f, -3.39047424e-02f, -1.13342963e-01f, -1.36788115e-01f,
  -1.46197543e-01f, 1.70187913e-02f, 8.91317055e-02f, 7.90083110e-02f, 8.17515850e-02f, 1.64638296e-01f, -5.43499850e-02f, -4.05867212e-02f, 1.52234599e-01f, -1.31031200e-01f,
  7.60100186e-01f, -1.86867431e-01f, 4.33513552e-01f, 3.70808870e-01f, -5.28617978e-01f, -7.04873681e-01f, -6.44805729e-01f, -1.30648464e-01f, 2.11631618e-02f, -2.93692164e-02f,
  -3.82280588e-01f, 1.63619429e-01f, 3.47991377e-01f, 4.55477953e-01f, 4.62961197e-01f, 4.16914403e-01f, 4.92290258e-01f, 8.80856812e-01f, 5.82141042e-01f, 1.44927382e-01f,
  4.31503057e-02f, 2.58212000e-01f, 4.70339149e-01f, 4.92661983e-01f, 1.14494398e-01f, 2.22802103e-01f, -4.97617200e-02f, 5.23592858e-03f, 1.45524889e-02f, 7.85184145e-01f,
  1.61231160e-01f, -3.71534199e-01f, -1.80817265e-02f, -9.19764489e-02f, -1.35956660e-01f, 1.98552877e-01f, 1.09883167e-01f, -1.11030238e-02f, -4.18383218e-02f, 8.91340449e-02f,
  -1.83612123e-01f, -2.42168400e-02f, 1.30145416e-01f, -1.72365427e-01f, -2.65009999e-01f, -2.41899088e-01f, 2.24631920e-01f, 4.74294722e-01f, 2.37977281e-01f, 1.85166329e-01f,
  8.11792314e-02f, -3.86353463e-01f, -2.72940755e-01f, -2.71142691e-01f, 7.58128017e-02f, 1.74135163e-01f, -2.05832049e-01f, 2.18005609e-02f, -2.39661530e-01f, 1.12781353e-01f,
  -5.52801974e-02f, 3.68396635e-03f, -6.76440075e-02f, 8.40878021e-03f, 1.30526617e-01f, 4.91472334e-02f, 2.72835314e-01f, -9.27204918e-03f, 7.43444934e-02f, 1.50410854e-03f,
  2.79819742e-02f, -5.44706825e-03f, 1.53293639e-01f, -1.62352864e-02f, 9.47857425e-02f, 3.20708305e-02f, -6.88047782e-02f, 4.98600304e-02f, -7.99276233e-02f, -7.40376934e-02f,
  8.80519301e-02f, 1.62970006e-01f, -3.65176387e-02f, 3.41973096e-01f, 7.94762075e-02f, 1.31544217e-01f, 8.91859233e-02f, -2.52395310e-02f, -1.52091414e-01f, -9.97545496e-02f,
  -6.40246511e-01f, -3.78268242e-01f, 6.25553951e-02f, 2.56496757e-01f, -2.07895562e-01f, -2.75442094e-01f, -2.78351642e-03f, 6.37620315e-02f, -6.83053955e-02f, 9.99932513e-02f,
  -5.06495118e-01f, 3.35289612e-02f, -2.17712328e-01f, -5.48939332e-02f, -5.03748131e-04f, -2.87938952e-01f, 7.16692721e-03f, 1.75428554e-01f, -3.42468731e-02f, -4.20327000e-02f,
  2.34113857e-01f, -4.06155854e-01f, -3.12385410e-01f, -1.95898741e-01f, -2.69573241e-01f, 5.81054902e-03f, -2.32607245e-01f, -2.63381958e-01f, -4.73973960e-01f, -2.57427096e-01f,
  -1.06316185e+00f, -1.98283672e-01f, 1.15388668e+00f, -7.73860693e-01f, -4.93394524e-01f, -3.40917915e-01f, -5.72495639e-01f, -5.34346163e-01f, -5.48448741e-01f, 1.16336003e-01f,
  -8.25117379e-02f, -3.17972273e-01f, 5.17049432e-01f, 1.00394063e-01f, -2.52469063e-01f, 3.57442766e-01f, 3.43620658e-01f, 3.82650256e-01f, -5.88745438e-02f, -8.01953971e-01f,
  -4.52226251e-01f, -1.96405515e-01f, -1.76052719e-01f, 4.70588886e-04f, -6.31101802e-03f, 5.36880456e-02f, 6.61261976e-01f, -5.27638495e-02f, 7.53408223e-02f, 3.01172376e-01f,
  7.08458066e-01f, -3.19645613e-01f, 2.09088817e-01f, -3.29520762e-01f, 1.93614364e-01f, 5.66946529e-02f, -2.62535065e-02f, 2.13652566e-01f, -2.23990828e-01f, 7.55484626e-02f,
  -2.23674908e-01f, -3.70785713e-01f, -1.78703174e-01f, 9.64144692e-02f, 2.18970031e-02f, -2.85012811e-01f, 4.92260605e-02f, -1.09585673e-01f, 7.74539039e-02f, 4.85851541e-02f,
  -2.63289094e-01f, -3.41013521e-01f, 1.45841211e-01f, 2.61912435e-01f, -1.96863964e-01f, -1.65905327e-01f, 9.75930765e-02f, -3.89206320e-01f, 1.53714448e-01f, 2.88001806e-01f,
  -6.85004294e-02f, 1.85272202e-01f, -2.16000378e-01f, -4.98213843e-02f, -1.42305300e-01f, -4.97943051e-02f, 7.32721761e-02f, 1.00382656e-01f, -8.15278366e-02f, -1.53674732e-03f,
  -1.82864100e-01f, 1.46735795e-02f, 7.33307302e-02f, -1.33590743e-01f, 1.91700235e-02f, 9.81820561e-03f, 5.77578284e-02f, 1.15757570e-01f, 1.40046000e-01f, -2.21698791e-01f,
  -2.36538917e-01f, -2.23057315e-01f, 7.04499893e-03f, 4.46060747e-02f, -1.67225897e-01f, 8.38447362e-02f, -8.61826539e-02f, 4.81966510e-03f, -5.49784489e-02f, -7.19493404e-02f,
  2.73358643e-01f, 1.89476053e-03f, 9.49712023e-02f, 3.03965043e-02f, -3.75146680e-02f, 1.26652829e-02f, 2.42594350e-02f, -1.25659451e-01f, -4.71188091e-02f, -2.66754553e-02f,
  -2.21606240e-01f, -1.86717510e-01f, 4.05544639e-01f, 8.36068094e-02f, -7.37503022e-02f, -1.74412116e-01f, -1.13681689e-01f, -4.38450798e-02f, 8.61649364e-02f, -1.34744748e-01f,
  -1.82741091e-01f, -2.21604019e-01f, -5.14678136e-02f, 2.00337186e-01f, -4.75935526e-02f, -1.88654199e-01f, 3.90581101e-01f, 1.00189656e-01f, -3.13494951e-02f, 6.21966943e-02f,
  1.23062062e+00f, -2.75482357e-01f, -1.21016514e+00f, 2.27804482e-01f, -4.10557061e-01f, -2.26114422e-01f, -1.14235654e-01f, 2.65230954e-01f, 2.37714678e-01f, -7.74059594e-02f,
  -1.55341968e-01f, 2.42234811e-01f, 1.52569473e-01f, 1.13118723e-01f, 3.35357249e-01f, -2.94951558e-01f, -3.94543976e-01f, -1.72351003e-01f, 1.77617028e-01f, 3.12974781e-01f,
  2.32304484e-01f, 5.43017387e-01f, 6.04320049e-01f, 6.33836761e-02f, -3.56430680e-01f, -4.06051725e-02f, -4.54240203e-01f, -3.61192465e-01f, -2.35949308e-01f, -7.11440623e-01f,
  -5.51505864e-01f, -4.56752360e-01f, 9.26770940e-02f, 1.31337658e-01f, -9.50483754e-02f, 1.95797175e-01f, -3.44614200e-02f, -5.74900582e-02f, 2.80171689e-02f, -1.02599248e-01f,
  -2.18668237e-01f, -1.31635696e-01f, -1.13135293e-01f, -1.74413636e-01f, 1.03652179e-02f, 5.09136356e-03f, -6.22617640e-02f, 3.08292322e-02f, 5.77900670e-02f, -2.42755324e-01f,
  -1.59670621e-01f, -1.71311557e-01f, -3.04345906e-01f, -2.28074789e-01f, -1.72168240e-01f, -1.67188644e-01f, -3.55801851e-01f, -2.27546856e-01f, -1.45647794e-01f, -4.74379733e-02f,
  -2.16073934e-02f, 9.06464830e-02f, -1.44290726e-03f, 1.35777280e-01f, 1.61870822e-01f, -3.20034511e-02f, 2.82389950e-02f, 1.04682915e-01f, 2.29231850e-03f, 1.04968540e-01f,
  -9.86820310e-02f, 6.19441941e-02f, -1.13259582e-03f, -4.85089533e-02f, -7.53399059e-02f, -5.18689007e-02f, -2.94985790e-02f, 1.40556768e-01f, 7.60099515e-02f, 1.12962820e-01f,
  1.98981464e-01f, -1.29527733e-01f, 2.16818005e-02f, 2.86373757e-02f, -5.08857928e-02f, -6.54030666e-02f, -1.13862706e-02f, 1.33298775e-02f, 7.50861615e-02f, 1.91949829e-02f,
  7.57225871e-01f, 1.92906752e-01f, 1.22458264e-01f, 5.46245836e-02f, -1.18991800e-01f, 6.43636240e-03f, 6.11545984e-04f, 5.87816611e-02f, -2.38574669e-02f, 1.82691067e-02f,
  -2.08426341e-01f, 2.72719394e-02f, -2.40988471e-02f, -6.42326102e-02f, 1.68907903e-02f, 1.19537041e-02f, 1.72272980e-01f, 6.77004457e-02f, 1.77523345e-01f, -5.97145334e-02f,
  5.86914606e-02f, 2.58193731e-01f, 3.73640060e-01f, 2.12960213e-01f, 1.10897169e-01f, 1.75323412e-01f, 1.76585019e-02f, 4.70758341e-02f, 1.73408821e-01f, 6.38905644e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  7.74012744e-01f, 4.15841907e-01f, 5.30427217e-01f, 4.60528463e-01f, 6.18023872e-01f, 5.28557956e-01f, 9.35123920e-01f, 4.83360589e-01f, 4.97086644e-01f, 4.07764763e-01f,
  4.91694868e-01f, 5.76586664e-01f, 2.77353317e-01f, 9.09382820e-01f, 1.31067061e+00f, 3.80624115e-01f, 4.49676365e-01f, 5.89110017e-01f, 7.46748507e-01f, 6.39221251e-01f,
  3.12689573e-01f, 5.45044243e-01f, 7.07123578e-01f, 7.53692150e-01f, 8.68156791e-01f, 8.06622446e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -3.36275995e-01f, -3.30057144e-01f, 4.17320095e-02f, 3.99048299e-01f, -1.84349030e-01f, 2.24138424e-01f, -8.55096281e-01f, -5.91335297e-01f, -7.90506363e-01f, 1.82761475e-01f,
  4.68858629e-01f, -7.84522891e-02f, -9.44013953e-01f, 3.86037022e-01f, -4.35749084e-01f, -3.98789227e-01f, -4.31905717e-01f, -1.00183785e-01f, -1.13952719e-01f, -2.24568889e-01f,
  -8.62830698e-01f, 5.26052177e-01f, -4.81844753e-01f, -1.54962288e-02f, -4.88475114e-01f, -5.05851090e-01f, 4.92900521e-01f, 5.99883437e-01f, -4.23507899e-01f, -4.86112505e-01f,
  -1.24174833e+00f, 1.85278386e-01f, -8.19720104e-02f, -1.37100339e-01f, -2.29015395e-01f, 7.01726153e-02f, 8.66644233e-02f, -4.62003917e-01f, -3.90529186e-01f, 1.48148701e-01f,
  -2.36057229e-02f, 1.28067458e+00f, 1.01463087e-01f, -5.80247343e-01f, -5.72283030e-01f, 4.14116904e-02f, 4.27311927e-01f, -9.50206891e-02f, 2.03600228e-01f, -1.05385554e+00f,
  4.08515215e-01f, 4.91950363e-01f, -1.48056889e+00f, 2.36918569e-01f, -2.68140137e-01f, 1.79235145e-01f, -5.55008352e-01f, -7.35924989e-02f, -1.25323820e+00f, -1.21850526e+00f,
  6.68131173e-01f, 2.70021051e-01f, -6.88417494e-01f, 4.55514103e-01f, -4.88715656e-02f, -1.15177616e-01f, 2.27551505e-01f, 4.15341079e-01f, 2.70610839e-01f, 1.40924573e-01f,
  -6.22732818e-01f, -5.28531194e-01f, -4.38942909e-01f, 9.59081650e-01f, -9.74428892e-01f, -1.25098556e-01f, -4.48808670e-01f, 2.05952525e-01f, -6.87849581e-01f, -2.91770369e-01f,
  -3.58067364e-01f, -4.69942510e-01f, -4.16265875e-01f, 6.37283027e-02f, -5.80886304e-01f, -1.05057585e+00f, -6.31564081e-01f, 3.98155041e-02f, 8.18026997e-03f, -3.62731516e-02f,
  6.10870242e-01f, 5.56022823e-01f, 4.99166787e-01f, 4.95771676e-01f, 7.65249133e-01f, -1.75999943e-02f, -6.25208437e-01f, 4.42260325e-01f, 6.39394950e-03f, -1.33844679e-02f,
  1.94589883e-01f, 2.78773695e-01f, -9.60929036e-01f, -1.35270640e-01f, -1.07001531e+00f, 3.96384820e-02f, -1.65983796e-01f, 7.25166440e-01f, 1.39460087e+00f, -2.68380493e-02f,
  -3.67180258e-01f, -8.10129583e-01f, -8.60216439e-01f, 2.84085691e-01f, -2.05371156e-02f, -1.48692226e+00f, 7.79446721e-01f, 4.39845413e-01f, -6.41216516e-01f, -9.55399454e-01f,
  3.15456688e-01f, -5.31614780e-01f, 3.92705381e-01f, -3.25434059e-01f, -5.56723952e-01f, -4.20262456e-01f, 2.00415850e-01f, -1.02308655e+00f, 4.25829291e-01f, 2.75130212e-01f,
  -3.22137177e-01f, 4.74999100e-01f, 3.86654973e-01f, -1.52600899e-01f, 1.07144618e+00f, 1.04818091e-01f, 4.94505763e-02f, 1.51712313e-01f, 8.99330676e-02f, -7.46396601e-01f,
  -1.13078344e+00f, 1.69172645e-01f, -3.19930583e-01f, -2.44830430e-01f, -2.82361120e-01f, 5.23354053e-01f, 1.85456172e-01f, -6.98693812e-01f, 5.68808794e-01f, -6.73909009e-01f,
  1.81344807e-01f, 1.54136689e-02f, -4.61827904e-01f, -2.22032636e-01f, 5.41296192e-02f, -2.37276286e-01f, -2.82782704e-01f, -1.34126866e+00f, 5.08793056e-01f, -1.05960453e+00f,
  -5.86933643e-02f, 1.74577460e-01f, 4.68428433e-01f, -3.61903965e-01f, 4.83892828e-01f, -7.84246475e-02f, 5.24285138e-01f, 3.09862942e-01f, 6.63104236e-01f, -1.33214748e+00f,
  8.52254868e-01f, 2.36385673e-01f, -4.20337319e-01f, -2.79666334e-01f, -6.46651506e-01f, -3.88619781e-01f, -3.47480536e-01f, -2.50997782e-01f, 9.66139883e-02f, -1.21748030e-01f,
  1.95211053e-01f, -3.84840742e-02f, -1.66991130e-02f, 7.51212835e-01f, -2.42805183e-02f, -5.49125016e-01f, -1.02773678e+00f, 6.44914880e-02f, -4.88132983e-01f, -6.25619531e-01f,
  -5.37011027e-01f, 6.17812574e-01f, -2.15384103e-02f, 6.29481301e-02f, 1.52342737e-01f, -5.96814871e-01f, -2.03270182e-01f, 2.52294660e-01f, 1.01571642e-01f, -3.21481854e-01f,
  -8.57212007e-01f, -9.58779991e-01f, -9.20339346e-01f, -3.22377264e-01f, -6.95302963e-01f, -3.85646790e-01f, -5.85156307e-03f, -7.85191834e-01f, 5.03418803e-01f, -9.72868919e-01f,
  -8.54692757e-01f, -8.29428911e-01f, 2.53838748e-01f, -3.62557590e-01f, 4.12071556e-01f, 3.07540327e-01f, -8.84330690e-01f, 7.82726884e-01f, -3.32222402e-01f, 3.19822580e-02f,
  4.83906180e-01f, 6.86123073e-01f, 1.92411423e-01f, -3.93979847e-01f, -1.62088901e-01f, -1.62182882e-01f, -1.08190499e-01f, 3.38344693e-01f, -1.50340810e-01f, 1.81875557e-01f,
  -3.53762418e-01f, 2.14341864e-01f, 5.69123209e-01f, -6.18390739e-01f, -8.09984207e-01f, -3.12541455e-01f, 1.01578522e+00f, 2.35141680e-01f, -3.94431651e-01f, 4.00825381e-01f,
  -4.87224042e-01f, 1.98167995e-01f, -3.68475109e-01f, -5.42459249e-01f, 5.97306073e-01f, -9.13820744e-01f, 2.30189174e-01f, -4.77577150e-01f, -6.58335388e-01f, 4.77709323e-02f,
  2.51242787e-01f, -1.69026226e-01f, -5.92934608e-01f, 2.12601572e-02f, -6.49716020e-01f, -2.43103907e-01f, -5.00737011e-01f, 3.13951373e-02f, 9.58890617e-02f, -7.26606905e-01f,
  -2.83246934e-01f, -3.08027506e-01f, -9.97193605e-02f, 3.68669301e-01f, -7.71162271e-01f, -1.86142638e-01f, -6.62496567e-01f, 3.64008635e-01f, 4.05626774e-01f, -1.94623113e-01f,
  -2.45302930e-01f, 5.18016338e-01f, -2.44886458e-01f, -6.15941048e-01f, -1.75943330e-01f, 7.93576896e-01f, -4.63582456e-01f, -5.00056028e-01f, -5.83458006e-01f, -3.86579841e-01f,
  9.89748538e-01f, 2.63338208e-01f, -7.07877696e-01f, 2.16500685e-02f, 3.69785130e-02f, -1.88194156e-01f, -2.40747184e-01f, 1.94018669e-02f, -2.27987796e-01f, -3.94942984e-02f,
  1.68439195e-01f, -3.86894755e-02f, 1.16206119e-02f, 2.30549738e-01f, 6.13618970e-01f, -5.77990949e-01f, 4.60584462e-01f, -3.94945115e-01f, 5.22494167e-02f, -6.81576908e-01f,
  -1.02787137e+00f, 8.28503743e-02f, 8.17984700e-01f, -1.19399220e-01f, 5.20637572e-01f, 8.02226245e-01f, -6.62079930e-01f, -4.08205777e-01f, -1.33423638e+00f, -8.52619767e-01f,
  3.96194607e-01f, -6.76419258e-01f, -4.64652866e-01f, -8.92574847e-01f, -9.07415986e-01f, 7.84536362e-01f, -3.27196032e-01f, 6.76688105e-02f, -7.52700865e-01f, -7.90395260e-01f,
  -3.73848788e-02f, -6.16698805e-03f, -9.27462205e-02f, 4.70848829e-01f, -5.84740102e-01f, -2.34685227e-01f, 2.57849038e-01f, -7.97198176e-01f, 2.12689325e-01f, -5.86333871e-01f,
  -3.58298302e-01f, 5.73028684e-01f, 2.08274856e-01f, -1.51006192e-01f, -5.96142471e-01f, 3.23256552e-01f, -9.64322686e-02f, -8.19702566e-01f, -3.59905779e-01f, 6.18753195e-01f,
  -7.23742545e-01f, 7.31513798e-01f, -4.63750720e-01f, -7.86291301e-01f, -5.31617403e-01f, -5.82562923e-01f, -8.22585762e-01f, -7.25100040e-01f, -9.61224735e-01f, -3.05153340e-01f,
  1.09314692e+00f, -1.48956448e-01f, 9.87996385e-02f, 6.48101419e-02f, 1.29440442e-01f, 8.71714056e-02f, -1.00813538e-01f, 4.71393690e-02f, -5.93923509e-01f, -5.88244438e-01f,
  -2.18834564e-01f, 2.39728205e-03f, -5.34977019e-01f, 5.86637735e-01f, -2.32131615e-01f, -3.51498514e-01f, 3.41257602e-01f, -4.27585155e-01f, 6.09375060e-01f, 2.53458977e-01f,
  7.06749439e-01f, -7.30800807e-01f, 9.87366736e-01f, -1.84195146e-01f, 8.93379003e-02f, 5.51007967e-03f, 4.57599431e-01f, 7.51131892e-01f, -5.15902042e-01f, -1.01924264e+00f,
  -3.44067276e-01f, -7.44480193e-01f, -7.55883932e-01f, -8.34456384e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.85244644e-01f, -2.97734171e-01f, 1.98699623e-01f, -2.41443947e-01f, 3.16625953e-01f, -3.29553187e-02f, -1.36329740e-01f, -1.69369519e-01f, -2.09312990e-01f, -3.58283445e-02f,
  -4.99388836e-02f, 2.96706776e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    