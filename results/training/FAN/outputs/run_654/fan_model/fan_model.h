/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.39919680e-01f, 3.88912916e-01f, -1.45480782e-01f, -1.21655993e-01f, 1.46192312e-01f, -2.06816681e-02f, 1.84180200e-01f, 9.62745622e-02f, 1.66898835e-02f, 2.42303386e-01f,
  1.24916822e-01f, -1.76103432e-02f, -4.84716184e-02f, -3.16332802e-02f, -1.54165983e-01f, 3.73850204e-02f, -1.00749314e-01f, -4.56356645e-01f, -4.32471365e-01f, 4.21965420e-02f,
  8.96923393e-02f, 3.00097670e-02f, -1.05940185e-01f, -4.80587706e-02f, 2.34625936e-01f, -4.94990312e-02f, 1.32891342e-01f, 6.11229008e-03f, 1.97423369e-01f, 2.56528463e-02f,
  -8.64126533e-02f, 2.75591146e-02f, -5.54537587e-02f, 5.01546003e-02f, 2.61363829e-03f, -6.10858239e-02f, -3.96974897e-03f, -1.98280923e-02f, 1.22249424e-02f, 5.01349680e-02f,
  -4.17333655e-02f, -9.93159600e-03f, -4.43750285e-02f, -2.49267314e-02f, -1.51606016e-02f, -4.03401116e-03f, -5.74762933e-02f, -3.39085646e-02f, -4.87221740e-02f, 1.08596742e-01f,
  6.98307753e-02f, 3.93720753e-02f, -4.40977737e-02f, 1.43630607e-02f, -1.24540562e-02f, -4.27602977e-02f, 8.20424408e-02f, -1.04029486e-02f, -8.29951912e-02f, 1.01831131e-01f,
  1.70612168e-02f, -1.06983259e-01f, -3.23484689e-02f, 3.31415236e-02f, -8.23600683e-04f, 5.60773425e-02f, -1.71217620e-02f, -2.02411339e-02f, -1.62184611e-02f, -5.11090942e-02f,
  2.83322539e-02f, -3.73300724e-02f, -1.56824272e-02f, 6.78354278e-02f, -3.91488038e-02f, 4.74273181e-03f, -8.36752653e-02f, -2.05751862e-02f, 6.66725934e-02f, 4.25557466e-03f,
  -7.54055381e-02f, 4.75817360e-02f, 9.71128140e-03f, 6.38769940e-03f, 6.04884848e-02f, -9.08028334e-02f, -5.79133853e-02f, 5.57507910e-02f, 7.56238215e-03f, 3.53624597e-02f,
  1.75907388e-01f, -5.21317236e-02f, -1.00023113e-01f, -4.78534587e-02f, -3.67489569e-02f, 6.74114302e-02f, 4.93666790e-02f, -3.43737155e-02f, -7.00521618e-02f, -4.94583929e-03f,
  4.98013757e-02f, -1.09313101e-01f, -5.35107441e-02f, 2.49497220e-03f, -8.12028199e-02f, -3.14809219e-03f, 3.26337703e-02f, -5.58597669e-02f, -5.75290993e-02f, 8.82319435e-02f,
  1.15372650e-02f, 2.29904987e-02f, 8.46727472e-03f, 4.04476337e-02f, -1.48968324e-02f, -4.28197309e-02f, 5.59161492e-02f, 8.03823993e-02f, -5.64817376e-02f, 1.10375792e-01f,
  4.24671590e-01f, -2.68877119e-01f, 1.12967141e-01f, 2.13614479e-02f, 4.30746339e-02f, 4.10632826e-02f, 1.12893142e-01f, 4.18896973e-02f, -2.77108960e-02f, 3.71251721e-03f,
  -1.81364104e-01f, 7.16229947e-03f, -7.46292472e-02f, -1.25083447e-01f, 3.32539231e-02f, 7.47725666e-02f, -6.77615255e-02f, 8.61627683e-02f, 9.10483152e-02f, 4.73800907e-03f,
  -1.24145396e-01f, 7.40963146e-02f, -2.92756259e-02f, 5.17724361e-03f, -6.51541799e-02f, 3.09209563e-02f, 3.05106048e-03f, -1.29589692e-01f, -1.34454772e-01f, -1.85630992e-01f,
  2.49003127e-01f, 5.08981710e-03f, -5.26334085e-02f, 2.07169610e-03f, -1.58629939e-01f, 5.15828235e-03f, 3.95651534e-02f, -2.56521162e-02f, -8.71382430e-02f, -2.42543649e-02f,
  -3.06652803e-02f, -2.74923947e-02f, -4.14370447e-02f, -1.35476843e-01f, -1.39421888e-03f, -4.01199758e-02f, -2.89980378e-02f, -1.04164995e-01f, 7.85062276e-03f, 3.83731052e-02f,
  -2.52615884e-02f, -3.52007337e-02f, -4.84557915e-03f, -4.29803543e-02f, -8.93399492e-02f, -5.51293828e-02f, -2.03659274e-02f, -9.90263373e-02f, -1.15125366e-02f, -9.90619212e-02f,
  5.40698990e-02f, -3.26369703e-02f, -2.36959662e-02f, -2.98916595e-03f, -4.61194888e-02f, -2.46176925e-02f, -1.07938722e-01f, 1.85100138e-02f, 3.41002196e-02f, 1.66758522e-02f,
  -2.92332154e-02f, -2.54193880e-02f, -3.54068689e-02f, 2.67248712e-02f, -7.54096210e-02f, 6.06096350e-04f, 2.15660073e-02f, -3.16014849e-02f, -6.17035925e-02f, 3.43447812e-02f,
  -1.11080892e-02f, -5.27640395e-02f, -2.39158515e-02f, -7.65071809e-02f, 4.14460674e-02f, -4.79358472e-02f, 7.19351247e-02f, 3.66757214e-02f, -6.85225949e-02f, 5.90564422e-02f,
  1.37455046e-01f, 2.40032617e-02f, 1.41091226e-02f, 6.20464422e-02f, 5.71788922e-02f, -5.38395606e-02f, -3.17979641e-02f, 3.26308608e-02f, -6.45678714e-02f, -4.44403297e-04f,
  5.86696379e-02f, 2.07632743e-02f, -6.34508282e-02f, 3.82708833e-02f, -1.17118517e-02f, 2.23833565e-02f, 1.51541186e-02f, 1.38982134e-02f, -2.61232425e-02f, -1.94748472e-02f,
  -7.22855926e-02f, -3.52124381e-03f, 1.26963496e-01f, 7.68783540e-02f, 3.83255333e-02f, 6.52164146e-02f, 5.53477928e-02f, 1.30991623e-01f, 9.32742059e-02f, 2.02410161e-01f,
  1.75569803e-01f, -2.18094792e-02f, -3.93305957e-01f, 3.92861903e-01f, -6.95364103e-02f, -9.70997661e-02f, -3.80469024e-01f, 2.74084229e-02f, 2.79132992e-01f, -9.78227183e-02f,
  -8.32135007e-02f, 1.02118351e-01f, 1.44115537e-02f, -1.02816075e-01f, -1.81496665e-01f, -1.86135665e-01f, -7.19413534e-02f, -1.61313549e-01f, -1.94621131e-01f, 1.85701307e-02f,
  1.48414403e-01f, -4.32536639e-02f, 1.85344659e-03f, 1.44919083e-01f, 1.69542983e-01f, 6.92623779e-02f, -1.19034432e-01f, -6.05909713e-02f, 1.11921616e-02f, 1.00105613e-01f,
  -3.49635631e-01f, -1.57365173e-01f, -2.86859274e-02f, 4.13955469e-03f, -1.41689077e-01f, 4.67367657e-02f, -7.61046559e-02f, -7.92637020e-02f, -3.67133543e-02f, -8.22891667e-02f,
  -4.43356894e-02f, -5.19607663e-02f, -8.40753838e-02f, -5.94077632e-02f, -6.15385100e-02f, -1.40130445e-02f, -1.56126553e-02f, -2.64170785e-02f, -2.72356309e-02f, -9.65937451e-02f,
  3.60239903e-03f, -5.56618646e-02f, -1.58834368e-01f, -5.98040819e-02f, -9.50855836e-02f, -2.48127282e-02f, -1.50381967e-01f, -7.16512948e-02f, -4.31779251e-02f, 5.50369732e-02f,
  5.44675030e-02f, -9.45803151e-02f, -3.55243534e-02f, 7.31272576e-03f, 2.58193631e-02f, 5.66721242e-03f, 5.88643812e-02f, -1.30694196e-01f, 3.79709341e-02f, 2.67764516e-02f,
  5.12151606e-02f, -1.04506239e-01f, 6.14863671e-02f, -1.59358680e-02f, 4.40630801e-02f, -4.19539884e-02f, 1.42094179e-03f, 1.04970396e-01f, 1.95065106e-03f, -4.61660810e-02f,
  6.33177832e-02f, -1.36292698e-02f, 2.73463726e-02f, 6.15426898e-02f, 1.17396330e-02f, -6.04728051e-02f, 4.96712588e-02f, 6.08011987e-03f, -7.06427405e-03f, 4.39225845e-02f,
  -4.03098874e-02f, -1.32518858e-01f, 8.24490376e-03f, -1.25304377e-02f, -6.18710741e-02f, -4.84362021e-02f, 5.23100309e-02f, -3.11015192e-02f, -7.55586894e-03f, 2.04204489e-02f,
  1.77355967e-02f, -1.56543069e-02f, -7.12151155e-02f, -3.37241963e-02f, -1.38632908e-01f, -3.74661610e-02f, 2.45301761e-02f, -2.28515752e-02f, 2.38100090e-03f, -4.84283119e-02f,
  5.29574184e-03f, 4.85939980e-02f, 1.24504007e-02f, -2.00429205e-02f, 6.80560321e-02f, -6.97770864e-02f, -1.83842018e-01f, 2.45344900e-02f, -5.49419597e-02f, -6.84695914e-02f,
  -1.50570482e-01f, 2.57661730e-01f, 4.33549583e-01f, -2.37417802e-01f, -2.35274434e-02f, 9.81901027e-03f, 4.10693705e-01f, -3.28220762e-02f, -2.21541569e-01f, 1.08128548e-01f,
  -2.58495629e-01f, -4.56922144e-01f, -2.51303464e-01f, -1.06803343e-01f, 6.92716315e-02f, 3.41658413e-01f, 3.22401524e-01f, 9.07509923e-02f, -5.94031364e-02f, -1.87588707e-02f,
  -9.89918560e-02f, 1.13023445e-01f, -9.99540016e-02f, -1.37253225e-01f, 4.39601541e-02f, -1.54112667e-01f, 1.24119520e-01f, -1.45373661e-02f, 7.45382207e-03f, 2.04849124e-01f,
  1.81605846e-01f, 1.43149525e-01f, -1.52060268e-02f, -9.97525826e-02f, 3.90082076e-02f, 3.45388837e-02f, 3.55675109e-02f, 3.41145135e-02f, -1.96429659e-02f, 2.83588823e-02f,
  -1.24312900e-01f, -9.21324790e-02f, -1.43375788e-02f, -2.40051225e-02f, 9.39380750e-02f, 2.59926450e-02f, 3.07032261e-02f, 1.12035803e-01f, 7.29190931e-02f, 1.22372679e-01f,
  -2.84770709e-02f, 6.31713420e-02f, 5.78639396e-02f, 8.42354074e-02f, 1.25224022e-02f, -2.21443046e-02f, -6.12955168e-02f, -9.41256136e-02f, -1.25166968e-01f, 2.31485143e-02f,
  -1.75187737e-02f, -4.96916026e-02f, -3.89818177e-02f, 1.64479446e-02f, 1.02756247e-02f, -2.92047076e-02f, 3.45402472e-02f, -5.16115017e-02f, -1.79894790e-02f, 5.33928573e-02f,
  -6.03892282e-02f, 5.02269976e-02f, 3.40653174e-02f, 1.97872836e-02f, 8.51870794e-03f, 7.44959414e-02f, 8.26277658e-02f, -1.37933828e-02f, -3.77464369e-02f, -8.48455802e-02f,
  -7.43326824e-03f, 3.56066413e-03f, 3.69879194e-02f, 9.94954556e-02f, -3.30562214e-03f, 2.95737870e-02f, -1.19758304e-02f, -3.53836827e-02f, -6.89415773e-03f, -3.42482887e-02f,
  -8.14187601e-02f, -1.28766641e-01f, 4.71483357e-02f, -7.78558943e-03f, 9.98125970e-03f, -4.82409149e-02f, -1.37156332e-02f, -7.65050650e-02f, -1.50344269e-02f, 2.13581584e-02f,
  -2.86800284e-02f, 1.83629412e-02f, 8.92575681e-02f, 7.46004954e-02f, -3.42293382e-02f, -9.56442729e-02f, -9.18586925e-02f, -3.19877304e-02f, -5.21485694e-02f, -8.68969262e-02f,
  3.08555569e-02f, -1.04653602e-02f, -1.23823024e-02f, -1.37236565e-01f, -1.76371485e-02f, -8.06191564e-02f, 7.37082437e-02f, 2.59363577e-02f, 4.49356250e-02f, 1.89036071e-01f,
  -3.22989702e-01f, 5.03475852e-02f, -1.06683858e-01f, -2.28121370e-01f, -4.43564318e-02f, 1.38821406e-02f, 4.35100496e-01f, 2.45499685e-02f, -2.14896068e-01f, 4.04895172e-02f,
  -1.04399756e-01f, -2.38891944e-01f, -1.85683399e-01f, -5.83163910e-02f, 1.15835570e-01f, 2.65482336e-01f, 1.87142551e-01f, 1.06685147e-01f, -6.37508035e-02f, 6.28812835e-02f,
  3.77991386e-02f, 8.00954849e-02f, -1.76561087e-01f, -1.04200855e-01f, -9.68614817e-02f, -1.72214985e-01f, -7.37292543e-02f, -2.03694269e-01f, -1.73347399e-01f, -2.10959971e-01f,
  -5.66696841e-03f, -1.66112378e-01f, -7.79827535e-02f, -1.12967543e-01f, -7.73046613e-02f, -9.75155085e-02f, -5.25891148e-02f, -7.38959312e-02f, -1.24374181e-01f, -8.36400241e-02f,
  -1.90838054e-01f, -5.28557301e-02f, -1.61491171e-01f, -9.79819521e-02f, -2.07334124e-02f, -2.47799903e-02f, 5.95344007e-02f, -1.41532952e-02f, -8.76210779e-02f, -1.52273448e-02f,
  9.58378166e-02f, -6.90999851e-02f, 1.71332993e-02f, -5.56143038e-02f, -4.29853648e-02f, -1.07762344e-01f, -4.19875160e-02f, -1.26893535e-01f, -9.93565917e-02f, -9.57018510e-02f,
  1.21054530e-01f, -2.06371602e-02f, 2.50716954e-02f, -3.78734469e-02f, 6.68635685e-03f, -3.84275094e-02f, -5.75837977e-02f, -5.93739701e-03f, 5.44865131e-02f, 2.97616851e-02f,
  -8.70071128e-02f, -3.00425175e-03f, -7.77477920e-02f, -2.86803916e-02f, -1.32461479e-02f, -1.04391716e-01f, 3.30608636e-02f, 3.83219775e-03f, -3.70031446e-02f, -6.89758956e-02f,
  -9.98283550e-02f, -2.37390269e-02f, -1.36213705e-01f, -3.21808830e-02f, -3.86376865e-02f, -6.42763674e-02f, -2.00533979e-02f, -8.58490095e-02f, 2.59592757e-02f, 1.77493114e-02f,
  -8.93338919e-02f, -1.00412712e-01f, -4.44849394e-02f, -8.65230523e-03f, -8.99231732e-02f, -6.55416399e-02f, -1.20233163e-01f, -1.28592134e-01f, -4.11855653e-02f, -8.62652436e-02f,
  -1.61505833e-01f, -8.06157142e-02f, 1.36927590e-02f, 1.17542148e-02f, 4.08475175e-02f, -8.03771317e-02f, -1.13755588e-04f, -6.89429119e-02f, -4.50914465e-02f, -1.02918059e-01f,
  8.65094643e-03f, 1.21606819e-01f, -1.96014009e-02f, -1.46049855e-03f, 1.79000087e-02f, 1.34241441e-02f, 3.13400254e-02f, 4.87394398e-03f, 4.50420044e-02f, 2.33791173e-01f,
  3.19763035e-01f, -7.58370385e-02f, 9.46279317e-02f, -2.36514974e-02f, -1.33852571e-01f, 4.46895994e-02f, 1.67009339e-01f, 7.88529068e-02f, 7.83094689e-02f, -7.19553828e-02f,
  -1.46062970e-01f, -1.93289548e-01f, 6.74683377e-02f, -6.75258227e-03f, 1.92789316e-01f, 2.94928830e-02f, 4.24815379e-02f, 3.84977944e-02f, 1.61195934e-01f, 1.39127016e-01f,
  -1.38709500e-01f, -1.68927088e-02f, 1.07716195e-01f, 5.59128486e-02f, -8.79805312e-02f, -8.77282917e-02f, -2.28322931e-02f, -1.40499294e-01f, -1.15768850e-01f, -2.75452018e-01f,
  -1.70620576e-01f, -5.71693443e-02f, 3.56895961e-02f, -8.58159289e-02f, -6.73279911e-02f, 4.75788303e-02f, 6.02699108e-02f, 2.41262768e-03f, 2.18875594e-02f, 6.70152679e-02f,
  -8.58474076e-02f, -3.11236288e-02f, -9.29856896e-02f, -9.16525498e-02f, -4.75335754e-02f, 5.20047508e-02f, -1.81339234e-02f, 2.50937752e-02f, 1.75588205e-02f, -4.95043844e-02f,
  -1.52045548e-01f, -2.02787384e-01f, -5.55914491e-02f, -4.99265492e-02f, -9.64867324e-02f, -6.89995289e-02f, -7.17823505e-02f, -7.84734413e-02f, -1.43205503e-03f, -2.01603062e-02f,
  -4.39157225e-02f, -3.50084715e-02f, -1.05790950e-01f, -3.60937491e-02f, -4.33965623e-02f, -5.18308766e-02f, -6.38192985e-03f, -7.44419098e-02f, -6.35155886e-02f, 9.46570933e-02f,
  -6.70824274e-02f, -3.11576459e-03f, 1.18122036e-02f, 1.82042737e-02f, -8.04406330e-02f, 2.48093680e-02f, -5.21536022e-02f, -1.66685935e-02f, -1.64619684e-02f, -3.74037363e-02f,
  -8.63520801e-02f, -1.65058523e-02f, -1.25753079e-02f, -5.57396561e-02f, 6.75732568e-02f, 3.18142809e-02f, 3.07941884e-02f, -6.24645017e-02f, 3.32367495e-02f, -4.78871458e-04f,
  1.73197508e-01f, 1.34201452e-01f, 6.75254688e-02f, 8.18261579e-02f, 6.32232502e-02f, 5.19682169e-02f, 9.27802697e-02f, -1.12950001e-02f, 2.45211534e-02f, 6.82928190e-02f,
  9.06126946e-03f, 8.02561194e-02f, 6.62393346e-02f, 2.08936110e-02f, 8.20817202e-02f, 2.43861694e-03f, 5.54866455e-02f, -8.66050571e-02f, 3.53073627e-02f, -2.72501446e-03f,
  1.01162851e-01f, 3.92795913e-02f, 8.92401859e-02f, 8.37301388e-02f, 6.13529123e-02f, 1.19871654e-01f, 2.37205308e-02f, 9.45945755e-02f, 1.91381454e-01f, 2.26387247e-01f,
  4.18252379e-01f, -2.86257505e-01f, 1.29206210e-01f, -2.39641499e-02f, -2.43162028e-02f, 1.84233516e-01f, 1.48393527e-01f, -5.24473339e-02f, -1.01652749e-01f, 8.37491453e-03f,
  -2.17830956e-01f, -4.50635552e-02f, -6.89708441e-02f, 6.24110177e-03f, 2.31668666e-01f, 2.45006636e-01f, 3.03920656e-01f, 3.31954837e-01f, 3.28015536e-01f, 7.49363527e-02f,
  2.89700050e-02f, 3.85415703e-02f, -1.82688832e-02f, 8.52719098e-02f, -6.92307800e-02f, -5.71631975e-02f, 1.20089976e-02f, 6.64662570e-02f, 6.36646748e-02f, -1.21264063e-01f,
  1.06802598e-01f, 7.72123337e-02f, 2.08108835e-02f, -1.19759478e-01f, -1.53780609e-01f, -9.17816386e-02f, -4.68033776e-02f, -6.26252145e-02f, -8.01352784e-02f, -7.78947994e-02f,
  -7.78988972e-02f, -8.88946578e-02f, 4.95647416e-02f, 3.76173221e-02f, 6.60442859e-02f, -4.81500477e-02f, -4.79080379e-02f, 3.09312716e-02f, 4.32937145e-02f, 1.21845920e-02f,
  -1.22609228e-01f, -6.20654672e-02f, -8.17470253e-02f, -9.61072743e-02f, 1.09511852e-01f, -1.03157036e-01f, -7.96389282e-02f, 6.24469258e-02f, 4.87663271e-03f, -8.39912817e-02f,
  5.23702204e-02f, 1.01721417e-02f, -2.72530895e-02f, -5.09212837e-02f, 3.05899070e-03f, -7.71884769e-02f, 5.68475761e-02f, 1.04374468e-01f, 4.36062962e-02f, -2.07434446e-02f,
  -5.70073165e-02f, 6.11564843e-03f, -1.13034159e-01f, 3.07324901e-02f, -3.67000289e-02f, -1.68758109e-02f, 1.13437939e-02f, 1.50371380e-02f, -1.86466314e-02f, -3.77752781e-02f,
  2.07887590e-02f, 1.97271518e-02f, -7.62046576e-02f, 6.57976717e-02f, 1.11284316e-01f, 1.16169769e-02f, 4.55283858e-02f, 3.12961526e-02f, 5.41242994e-02f, -3.27697694e-02f,
  4.02092226e-02f, -1.12801678e-02f, 6.17916062e-02f, 5.38486429e-02f, 8.50611925e-03f, -1.15896143e-01f, -1.02805503e-01f, 1.01483138e-02f, -2.99173500e-02f, 9.27186683e-02f,
  -2.60154549e-02f, 7.94191808e-02f, -4.18603793e-02f, 5.35323843e-02f, -2.25943960e-02f, -1.46683073e-02f, -1.30457515e-02f, 3.73921357e-02f, -5.01884706e-02f, 2.06715544e-03f,
  -2.86273584e-02f, 1.25434287e-02f, 6.06164709e-02f, -2.30262689e-02f, -2.78049316e-02f, 9.62702557e-02f, -1.49143279e-01f, 1.59559827e-02f, -1.88947972e-02f, -7.52485618e-02f,
  -6.80626392e-01f, 3.87981772e-01f, 1.35837063e-01f, -3.01080346e-01f, 5.91544099e-02f, -1.28125757e-01f, -2.66902335e-02f, -8.91681463e-02f, -1.21092357e-01f, -1.43127497e-02f,
  1.12558141e-01f, 1.23385966e-01f, 1.64511874e-01f, 1.69400588e-01f, 9.23951268e-02f, -4.17034514e-03f, 9.60326418e-02f, -1.25106260e-01f, -1.42188892e-01f, -1.85797527e-01f,
  8.57623219e-02f, -4.68062423e-02f, -6.14866763e-02f, -3.57060917e-02f, 1.27339184e-01f, 2.59092599e-02f, 9.00892094e-02f, -3.08344364e-02f, 6.67042136e-02f, 3.32034677e-01f,
  3.72715831e-01f, 5.65132536e-02f, -5.18149808e-02f, -7.40115996e-03f, 8.02689642e-02f, -5.80454059e-02f, -4.07739356e-02f, -1.86462719e-02f, -8.55144858e-02f, 3.58161330e-02f,
  6.07873201e-02f, 4.76300940e-02f, -1.01937829e-02f, 8.85606483e-02f, -1.48821771e-02f, -5.05739963e-03f, 7.18886182e-02f, 6.38868883e-02f, 5.52307926e-02f, 1.02774620e-01f,
  2.06213742e-01f, 4.47307006e-02f, -3.52057070e-02f, -4.62170132e-02f, -7.34607950e-02f, 2.49540750e-02f, 1.02250785e-01f, 5.60856909e-02f, 1.07323587e-01f, -5.43583632e-02f,
  -7.71300821e-03f, 5.38107827e-02f, 2.15770910e-03f, -3.00071705e-02f, -6.79718032e-02f, -1.54784964e-02f, 1.20747194e-03f, -8.57204199e-04f, 4.39252295e-02f, 2.02473626e-02f,
  4.32766005e-02f, -3.56048271e-02f, 6.32750764e-02f, -8.37433264e-02f, 1.97653063e-02f, 5.17697558e-02f, -2.39023957e-02f, 4.38191704e-02f, -1.00630634e-02f, -3.68451141e-02f,
  -7.70578980e-02f, 1.11617101e-02f, -9.73262787e-02f, 2.71062218e-02f, 2.21525412e-02f, -6.81571811e-02f, 3.73730063e-02f, 9.39980522e-03f, 5.89041738e-03f, -4.30686772e-02f,
  6.34998381e-02f, 8.97800550e-02f, -2.01131850e-02f, 1.08116426e-01f, 4.06010710e-02f, 5.05266599e-02f, 1.12088181e-01f, 1.69385262e-02f, 1.37057165e-02f, 3.58441845e-02f,
  -2.83967075e-03f, 4.97745676e-03f, 4.02853750e-02f, 5.15231080e-02f, 9.66428313e-03f, -4.84843291e-02f, 1.16538063e-01f, 1.81401353e-02f, 6.20333217e-02f, 3.29588354e-02f,
  -6.53962744e-03f, -8.60260203e-02f, 6.71017775e-03f, 2.84865145e-02f, 1.68631710e-02f, -9.72174630e-02f, -1.80796869e-02f, 4.32564840e-02f, -3.08239721e-02f, -8.09744075e-02f,
  -6.75951615e-02f, -2.38422632e-01f, -2.55810637e-02f, 2.57519241e-02f, 1.91863514e-02f, -1.10950097e-01f, -3.44825059e-01f, -1.13714658e-01f, 1.63630340e-02f, -9.26680267e-02f,
  -3.29029597e-02f, 2.68958881e-02f, 2.31729466e-02f, 3.22387042e-03f, -1.95421159e-01f, -1.75628945e-01f, 1.87310670e-02f, 1.43631190e-01f, -1.05395482e-03f, -3.14895771e-02f,
  1.43990502e-01f, 1.00755490e-01f, 5.53957708e-02f, 7.01138601e-02f, -6.27375965e-04f, 3.68588157e-02f, 5.48876543e-03f, 6.36000633e-02f, -1.06595039e-01f, 1.38142779e-01f,
  -5.80620486e-03f, -5.03622415e-03f, 4.67015095e-02f, 2.87429728e-02f, -4.89310129e-03f, -7.91343972e-02f, -6.68698698e-02f, 3.70746776e-02f, 8.16104561e-02f, 2.50245910e-03f,
  -3.72891836e-02f, -5.66285849e-02f, 1.29279777e-01f, 6.82633966e-02f, -3.76620293e-02f, -1.98836369e-03f, -1.03227921e-01f, -4.40455899e-02f, -1.89756732e-02f, -6.53915033e-02f,
  -3.69823277e-02f, -4.11825739e-02f, -6.55003935e-02f, 3.16091515e-02f, -5.40351048e-02f, -8.77466798e-03f, 5.62232025e-02f, 1.17010444e-01f, -9.45204571e-02f, -7.64586478e-02f,
  -8.59620236e-03f, 1.19813018e-01f, 6.09736107e-02f, -3.03951874e-02f, -8.14752430e-02f, 1.04205266e-01f, 1.00994900e-01f, 7.75469393e-02f, 2.45434679e-02f, -1.50245233e-02f,
  3.24719697e-02f, 7.82753229e-02f, 8.09448510e-02f, 1.45515710e-01f, 1.32467747e-01f, 6.17921762e-02f, 1.87398195e-01f, 1.01764195e-01f, 8.06356221e-02f, 4.85585704e-02f,
  3.69452350e-02f, 5.07367030e-02f, 6.15677573e-02f, 1.75486311e-01f, 1.34671494e-01f, 8.74222890e-02f, -1.84677243e-02f, 2.84246802e-02f, -3.12455930e-04f, 1.23341391e-02f,
  -1.04238622e-01f, 6.04227446e-02f, -1.05089992e-01f, -1.43853560e-01f, -7.76695311e-02f, 2.27765851e-02f, -7.86662847e-02f, -1.72743071e-02f, 8.11442733e-02f, 1.95549261e-02f,
  -4.39777896e-02f, -1.88384354e-02f, -3.44752311e-03f, -3.53647657e-02f, -4.66060042e-02f, -1.62803940e-02f, -1.99106649e-01f, -2.17052437e-02f, -4.23104357e-05f, -9.99916866e-02f,
  -3.37777287e-02f, -5.00530638e-02f, -1.33120880e-01f, -4.28860039e-02f, 8.04467872e-03f, 1.24432314e-02f, -7.09696487e-02f, -3.96758281e-02f, -1.39153764e-01f, -2.23293602e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.06454158e-01f, -5.25876403e-01f, -3.90803479e-02f, -5.27977347e-01f, -1.64126366e-01f, 5.30424267e-02f, -4.89565104e-01f, 1.70807950e-02f, 5.82674630e-02f, -3.19078445e-01f,
  -7.02355504e-02f, 1.10521182e-01f, 7.33512803e-04f, 2.36497596e-01f, 7.57999346e-02f, -1.98107824e-01f, -1.89878345e-01f, 2.22051844e-01f, 2.67500311e-01f, 2.64496177e-01f,
  -1.78999454e-02f, -2.76155651e-01f, 9.57948044e-02f, 1.41867056e-01f, -4.76942420e-01f, -8.83996487e-02f, -2.87497193e-01f, -5.27906343e-02f, 1.62183389e-01f, -6.56466901e-01f,
  -2.10238263e-01f, -1.18805759e-01f, 1.66175514e-01f, -1.26894480e-02f, -2.60306388e-01f, 1.04880929e-02f, -1.06175415e-01f, -8.45967308e-02f, 9.29374695e-02f, 5.04284315e-02f,
  -4.79969047e-02f, 9.70405191e-02f, -8.76248106e-02f, -6.85953274e-02f, -1.73813850e-01f, 5.01933880e-03f, -8.21596943e-03f, 7.62101784e-02f, -2.05942262e-02f, -8.74060839e-02f,
  -6.43944507e-03f, 1.13106132e-01f, 1.30915537e-01f, 2.51437783e-01f, 1.11337975e-01f, 2.44766951e-01f, 3.25439088e-02f, 2.10358888e-01f, 1.95883930e-01f, -5.09810030e-01f,
  -1.21407658e-01f, -3.44543308e-02f, -5.59273697e-02f, -1.83702093e-02f, 6.02364130e-02f, -1.09109841e-02f, -7.43215606e-02f, -8.05591196e-02f, -5.95011562e-02f, -9.89445373e-02f,
  -1.77723821e-02f, -4.62079793e-02f, -4.17243829e-03f, -6.75095990e-02f, -9.61596798e-03f, -4.44638766e-02f, -2.68999860e-02f, -3.81540097e-02f, -4.53769751e-02f, -3.16313561e-03f,
  1.70255139e-01f, -3.37606855e-02f, -7.41317719e-02f, 3.05195749e-02f, 9.95010585e-02f, 3.97580378e-02f, 1.28368000e-02f, -1.53384302e-02f, -4.82323654e-02f, 1.31171614e-01f,
  -4.22899753e-01f, 3.63835394e-01f, -4.39085573e-01f, -4.05243132e-03f, -5.86041994e-02f, 3.38143557e-02f, -6.43428713e-02f, 7.23860413e-02f, 9.61008444e-02f, -1.57892004e-01f,
  1.00328751e-01f, -9.26094279e-02f, -5.16993413e-03f, 2.78216926e-03f, -2.89394353e-02f, 9.97060910e-02f, -2.84560546e-02f, -1.37834668e-01f, 1.81481630e-01f, -8.53833035e-02f,
  3.73488143e-02f, 1.39641566e-02f, -4.47318032e-02f, -1.02320258e-02f, -9.88458991e-02f, 1.62333844e-03f, -7.59072006e-02f, -8.42844024e-02f, 6.05042204e-02f, -5.38236856e-01f,
  1.52142448e-02f, -3.17192316e-01f, 3.31182420e-01f, -4.18803126e-01f, -7.33143508e-01f, -5.23419380e-01f, -5.93518436e-01f, -1.59222394e-01f, -1.01649933e-01f, -4.00855660e-01f,
  -5.06996512e-01f, -3.15149844e-01f, -1.20393254e-01f, 2.49412775e-01f, 4.66324747e-01f, -7.44997859e-02f, 1.61194742e-01f, 6.05001628e-01f, 4.54339147e-01f, 1.82267144e-01f,
  -2.32278213e-01f, 2.28077605e-01f, 4.98041302e-01f, 5.06339371e-01f, -6.09809943e-02f, 7.54494667e-02f, 1.32127613e-01f, -2.58988589e-02f, 1.61236033e-01f, 3.64467919e-01f,
  -1.31954923e-01f, -1.32609189e-01f, -1.89016126e-02f, -7.96875581e-02f, -9.23041701e-02f, -1.91692007e-03f, 6.22022338e-03f, 1.32328689e-01f, 1.61493808e-01f, 1.43010691e-01f,
  -2.30144218e-01f, 1.42794356e-01f, 7.98547044e-02f, 3.26654017e-02f, -1.03321873e-01f, 2.79580969e-02f, 1.07753038e-01f, 3.28967869e-01f, -5.09011410e-02f, -1.17510566e-02f,
  -3.32003534e-01f, -1.38118953e-01f, -1.93080455e-01f, -1.81634888e-01f, -3.33981998e-02f, 8.89716223e-02f, 1.62243396e-02f, 2.36230180e-01f, 1.71619907e-01f, 2.44640410e-01f,
  5.17980568e-03f, 2.03639008e-02f, -7.08721504e-02f, -5.56104369e-02f, 6.66385591e-02f, -1.58242583e-02f, -5.48716076e-02f, -4.14924547e-02f, 1.57257363e-01f, -8.61692205e-02f,
  1.17342137e-02f, -6.92856908e-02f, -1.44939423e-02f, -3.47492076e-03f, -5.73555641e-02f, -1.17660798e-02f, -6.66965544e-02f, 2.25567799e-02f, 3.73105309e-03f, 5.32661043e-02f,
  -5.67142777e-02f, 4.22716662e-02f, -1.88105125e-02f, 1.35656282e-01f, -1.89219326e-01f, 3.47569324e-02f, 6.84160441e-02f, -3.85016203e-02f, -2.27640476e-03f, -7.90295564e-03f,
  -2.62119740e-01f, -5.59636839e-02f, -1.14804871e-01f, 1.79812059e-01f, 3.03884386e-03f, 1.34538198e-02f, -4.22601867e-03f, 8.06562454e-02f, -9.70097780e-02f, 3.15223709e-02f,
  -1.64779827e-01f, -1.31608665e-01f, -4.90708314e-02f, 7.62540326e-02f, -7.54140168e-02f, -2.64005631e-01f, -2.46233925e-01f, -2.49744490e-01f, 2.31552906e-02f, -1.45615190e-01f,
  -7.53580555e-02f, -3.10060382e-01f, -3.68457824e-01f, -2.98601747e-01f, -2.77115732e-01f, -2.35258296e-01f, 4.10762466e-02f, -9.91673991e-02f, 6.10229932e-03f, -3.21656227e-01f,
  -4.56129938e-01f, 1.76490754e-01f, -2.32822359e-01f, -2.31981963e-01f, 2.40534708e-01f, 1.05276518e-01f, 1.55750245e-01f, -3.64327058e-02f, 3.22091915e-02f, 1.11795530e-01f,
  9.85634420e-03f, 5.35442904e-02f, 2.17244238e-01f, 1.18532501e-01f, -2.14000791e-02f, 3.14644694e-01f, 3.67268384e-01f, -3.83673963e-04f, -2.73881108e-01f, -2.06672341e-01f,
  1.42180860e-01f, -1.68562040e-01f, -3.82020384e-01f, -1.89386293e-01f, 1.06985234e-01f, -1.43803120e-01f, 1.62907675e-01f, 1.20999426e-01f, 4.59045433e-02f, 2.10647762e-01f,
  -2.35848740e-01f, -1.44315168e-01f, -1.43412948e-02f, -5.51655628e-02f, 3.49339172e-02f, -2.65755743e-01f, -2.73790490e-02f, -9.12642777e-02f, -3.37768905e-02f, -8.13495070e-02f,
  -1.06887175e-02f, -6.18101284e-02f, 2.92561743e-02f, -5.67223914e-02f, -4.66143712e-02f, -1.30376101e-01f, 3.83105315e-02f, -5.86927645e-02f, -2.89695472e-01f, -2.91860819e-01f,
  1.54242992e-01f, 6.57579675e-03f, -1.63551718e-01f, -2.91814823e-02f, -2.74614412e-02f, -3.39653790e-02f, -1.76531836e-01f, -1.48276061e-01f, -3.64891142e-01f, -2.43087888e-01f,
  -4.82538827e-02f, 4.46851831e-03f, 1.35322064e-01f, 2.05476116e-02f, -1.23089077e-02f, 2.21070200e-02f, 8.18417072e-02f, -2.90504890e-03f, 5.99475540e-02f, -5.28483316e-02f,
  -8.32168683e-02f, -1.33989602e-01f, -1.49295069e-02f, -1.47404999e-01f, 5.27762924e-04f, 4.25162306e-03f, 3.21720317e-02f, -5.23444153e-02f, -5.84371611e-02f, 6.21946268e-02f,
  -1.05490007e-01f, 7.37288385e-04f, -4.18291315e-02f, -1.76309481e-01f, -5.27580678e-02f, 6.28819615e-02f, 3.73283704e-03f, 1.39058679e-01f, -1.31073058e-01f, 9.77127478e-02f,
  -2.88809747e-01f, 1.73209459e-01f, -4.05934220e-03f, 1.66937083e-01f, 1.98021960e-02f, -1.65749695e-02f, -6.79871887e-02f, -2.77959947e-02f, -4.30032015e-02f, -2.39153743e-01f,
  -1.39450356e-01f, 1.96437351e-03f, 2.78738346e-02f, 4.74110804e-02f, -1.31433368e-01f, 3.27541381e-02f, 4.73195910e-02f, -2.60711871e-02f, 1.88482016e-01f, -7.02414438e-02f,
  3.41710858e-02f, -4.17099185e-02f, -2.52484769e-01f, 1.40886044e-03f, 1.68106467e-01f, -5.58557920e-02f, -1.43632889e-01f, -3.88934724e-02f, -1.02718033e-01f, -2.05267549e-01f,
  -5.84692657e-01f, 4.72891033e-02f, 5.13516545e-01f, -4.73617345e-01f, 9.50971469e-02f, 1.62250131e-01f, 3.39229137e-01f, -9.80776995e-02f, -2.98628211e-01f, 2.82407433e-01f,
  1.48217767e-01f, -4.94379371e-01f, -2.71171302e-01f, -1.38600931e-01f, -2.64854550e-01f, 2.29806423e-01f, 1.96129307e-01f, -2.55925413e-02f, -1.52376518e-01f, -1.03978224e-01f,
  -2.39302158e-01f, -3.15070957e-01f, -4.14402753e-01f, -2.28109211e-01f, -1.12587549e-01f, -1.62859306e-01f, 2.11218372e-01f, -1.38279498e-01f, 4.34581563e-02f, -1.09428219e-01f,
  2.96314836e-01f, -8.14919323e-02f, -1.93651989e-02f, -2.89229155e-01f, -2.74979118e-02f, -1.00121304e-01f, 3.68804373e-02f, -5.42931221e-02f, -1.52762175e-01f, -6.27736971e-02f,
  -1.08650267e-01f, 9.15903747e-02f, -1.34162247e-01f, 5.19979373e-03f, -6.07543513e-02f, -1.11512028e-01f, -5.99735789e-02f, -1.81226641e-01f, -9.99247208e-02f, 2.22585592e-02f,
  -1.21857375e-01f, 6.11807667e-02f, 3.13610956e-02f, 7.36559033e-02f, -6.30066097e-02f, -2.46572923e-02f, -5.07000787e-03f, -1.12483449e-01f, 7.20203519e-02f, 9.62678194e-02f,
  6.15787692e-02f, 5.28482161e-02f, -3.24657606e-03f, -2.23792414e-03f, 9.90715548e-02f, -7.79627264e-02f, -3.28437872e-02f, 1.38276182e-02f, -3.25016603e-02f, -9.05936807e-02f,
  -5.67576103e-03f, 5.48871644e-02f, 3.27722095e-02f, 4.42824140e-02f, -2.15945765e-02f, -1.09283194e-01f, -3.41572836e-02f, 2.29322463e-02f, 3.85044925e-02f, -4.36951593e-02f,
  -4.52558249e-02f, 2.09776964e-02f, 3.38959764e-03f, 3.02109178e-02f, -2.79163215e-02f, -5.07728234e-02f, 4.86112684e-02f, -7.07262978e-02f, -1.02448009e-01f, -9.48285908e-02f,
  -2.13535413e-01f, 1.56103377e-03f, 8.52606520e-02f, 5.60586117e-02f, 5.75399138e-02f, -4.68058065e-02f, -2.90476647e-03f, 1.19218528e-01f, 2.34474670e-02f, 1.72910991e-03f,
  -1.11448191e-01f, 1.47528425e-01f, 3.02857310e-02f, 6.69070780e-02f, -1.66074242e-02f, 9.41796880e-03f, 6.56787306e-02f, -2.34924611e-02f, 7.50443190e-02f, 8.83858204e-02f,
  4.92059253e-02f, 1.20751016e-01f, 7.48185962e-02f, 1.41038820e-01f, -4.36601080e-02f, 2.17831656e-01f, 1.65843144e-01f, 1.06195159e-01f, 1.20939367e-01f, 1.79160833e-01f,
  -1.18253797e-01f, 2.41881356e-01f, 2.52244938e-02f, 1.49255469e-01f, 3.91475648e-01f, -1.47108734e-01f, 1.50613971e-02f, -2.04382479e-01f, -1.39500678e-01f, 1.08722806e-01f,
  -9.81869549e-02f, -1.99634165e-01f, 2.16066968e-02f, -3.58232372e-02f, -1.91352114e-01f, 1.95436954e-01f, 3.40210468e-01f, 7.12080374e-02f, -4.30611670e-01f, -3.53347689e-01f,
  1.07905500e-01f, -6.14657924e-02f, -2.56357282e-01f, -1.80661589e-01f, 2.21014574e-01f, -1.68393999e-01f, 2.60820717e-01f, 2.19314605e-01f, 6.47528172e-02f, 3.85339677e-01f,
  -1.28248902e-02f, 1.26413777e-01f, -1.81171104e-01f, 3.71915512e-02f, -4.12673969e-03f, -1.74055062e-02f, -1.53194934e-01f, 1.06222034e-01f, 1.21593446e-01f, 8.16947520e-02f,
  2.14347556e-01f, -2.61658779e-03f, 2.77838677e-01f, -1.90301731e-01f, -1.08535178e-01f, -3.18801761e-01f, -2.43089825e-01f, -2.25419208e-01f, -2.66836673e-01f, -1.56127855e-01f,
  3.50651264e-01f, 9.23745632e-02f, -3.82009335e-02f, -1.08849376e-01f, -7.46331215e-02f, -3.83784771e-02f, -5.66484444e-02f, 8.93765222e-03f, -2.74881661e-01f, -2.06913147e-03f,
  -1.27139948e-02f, 3.01786736e-02f, -3.78351845e-02f, -9.24391788e-04f, 8.81112143e-02f, -2.84850467e-02f, 7.77613297e-02f, -7.94433579e-02f, 1.21962251e-02f, -4.76088412e-02f,
  -7.34931510e-03f, -2.60216426e-02f, -8.26200321e-02f, 1.16511807e-02f, -1.06356973e-02f, 1.03778346e-02f, -5.45906797e-02f, -2.65972111e-02f, 3.37608270e-02f, -1.75797679e-02f,
  7.99516588e-02f, -2.95607280e-02f, 8.99774730e-02f, -4.16748635e-02f, 1.33070171e-01f, -2.19940990e-02f, 9.35419183e-03f, 1.64886359e-02f, 9.82400924e-02f, 1.23942785e-01f,
  -2.91778266e-01f, 6.57323450e-02f, 2.05520391e-02f, -1.10009730e-01f, -3.45589370e-02f, 8.24303553e-02f, 1.46522969e-01f, 6.03136644e-02f, -5.98050654e-03f, -6.87866881e-02f,
  -9.13198590e-02f, -3.77834737e-02f, 7.64054134e-02f, -2.52169296e-02f, -2.45214194e-01f, -2.72482317e-02f, -3.39178070e-02f, -7.77413370e-03f, -1.73182800e-01f, -1.46011367e-01f,
  -1.33034904e-02f, -2.84594864e-01f, -2.99067795e-01f, -1.30675897e-01f, -2.48411223e-02f, -2.42203578e-01f, -1.52212515e-01f, -1.96092129e-01f, -2.54086524e-01f, -2.22490951e-01f,
  -4.44534540e-01f, -1.02874689e-01f, -1.16504088e-01f, -3.48080367e-01f, 1.89687591e-02f, 3.89262587e-01f, 1.50422186e-01f, 3.16255748e-01f, 1.83671519e-01f, -1.30339652e-01f,
  7.67176822e-02f, -1.02296554e-01f, -3.48397642e-01f, -1.90385804e-01f, -1.89752415e-01f, -2.48881191e-01f, -4.12968218e-01f, -2.93733060e-01f, -7.73574284e-04f, 2.43776470e-01f,
  9.00283903e-02f, -2.20478266e-01f, -3.63330930e-01f, -1.32637411e-01f, -1.47270456e-01f, -4.26687330e-01f, -6.26068830e-01f, -2.47786865e-01f, -1.01399064e-01f, -6.38030887e-01f,
  -2.31664941e-01f, 1.79603711e-01f, 1.47558078e-01f, 1.02170020e-01f, -1.16955727e-01f, -2.79679783e-02f, 5.44636557e-03f, -1.11947507e-01f, -4.23592236e-03f, 1.13913894e-01f,
  -6.58721700e-02f, 9.15646628e-02f, -1.48706719e-01f, 6.77829087e-02f, 1.99085176e-02f, 8.32573846e-02f, 1.73374340e-01f, -3.22549827e-02f, 2.82338588e-03f, 1.19005896e-01f,
  1.92278624e-01f, 7.92758167e-02f, 1.02821089e-01f, 2.22823814e-01f, 3.27813178e-01f, 6.15666546e-02f, -1.29430240e-03f, 1.81759804e-01f, 7.84867331e-02f, -9.91151556e-02f,
  4.64917459e-02f, -6.27392158e-02f, 2.62555815e-02f, 1.16100386e-01f, -2.69027846e-03f, 8.84205103e-02f, -5.59208915e-02f, -1.67332496e-02f, -1.07147135e-01f, -4.80771065e-02f,
  -4.79332209e-02f, -2.48227101e-02f, 3.94873768e-02f, -2.88655430e-01f, -1.36534482e-01f, 2.77840719e-02f, 5.38766868e-02f, -3.60719450e-02f, 1.38564250e-02f, 1.81026999e-02f,
  8.38031024e-02f, 4.08543274e-02f, -1.48999721e-01f, 1.75085794e-02f, 1.56237581e-03f, -4.44088988e-02f, -3.67058744e-03f, 2.12299712e-02f, -1.54824546e-02f, -4.57844092e-03f,
  -2.87658960e-01f, -4.71735373e-02f, -1.42476335e-01f, 1.09541215e-01f, 6.77584261e-02f, 1.14684757e-02f, -5.27625717e-02f, 7.52269328e-02f, -2.76735052e-02f, 1.79846883e-01f,
  1.80795401e-01f, 2.43317112e-02f, -1.57774448e-01f, 8.06263164e-02f, 2.24142205e-02f, 1.92459896e-01f, 3.36692929e-02f, -8.21732730e-02f, 1.47212690e-04f, 1.19579636e-01f,
  9.77424085e-02f, 1.32486559e-02f, -3.85649577e-02f, -4.48680557e-02f, 5.00385575e-02f, -1.24151640e-01f, 1.32616144e-02f, 8.34839195e-02f, -1.35997236e-01f, -2.21997663e-01f,
  9.32145119e-01f, 2.00409830e-01f, 4.06205416e-01f, 1.94285527e-01f, 1.41115993e-01f, 1.40028045e-01f, 1.06738359e-01f, -1.04076885e-01f, -5.49819209e-02f, 1.03447497e-01f,
  -5.06468900e-02f, -2.83206701e-01f, -3.18028748e-01f, -3.66155535e-01f, -2.01834142e-01f, -1.14679679e-01f, -7.98760131e-02f, 1.49352491e-01f, 6.26527742e-02f, 1.26995876e-01f,
  -3.59783322e-02f, 1.76257282e-01f, 2.42105126e-01f, -4.37725261e-02f, 6.96858093e-02f, 5.29013686e-02f, 5.44473268e-02f, 5.48758581e-02f, -4.39829845e-03f, 2.38956884e-01f,
  2.32427090e-01f, 2.58028686e-01f, -1.96001589e-01f, -1.28679499e-01f, 3.85223180e-02f, -5.63871898e-02f, -3.98930116e-03f, -1.06023036e-01f, -1.05270959e-01f, -5.78287244e-02f,
  -1.53469797e-02f, 1.66948084e-02f, -1.08086422e-01f, -1.48224074e-03f, -1.73072536e-02f, -5.41868508e-02f, -1.48417741e-01f, -5.70426509e-03f, -1.25138491e-01f, -8.21964443e-02f,
  -1.13225095e-01f, 5.74073792e-02f, -3.85821126e-02f, -1.85942426e-01f, -6.57174662e-02f, -2.66251285e-02f, -1.88796427e-02f, 5.98507263e-02f, 6.39935533e-05f, -4.84682731e-02f,
  -2.67014742e-01f, -2.22733133e-02f, -1.11744545e-01f, -1.68843880e-01f, -1.04495794e-01f, -3.05206701e-02f, -9.27247554e-02f, 2.46118698e-02f, -8.08854848e-02f, -4.33763117e-02f,
  -1.38575420e-01f, -6.78771436e-02f, -1.48333013e-01f, -5.89076243e-02f, -1.10049486e-01f, -1.39295816e-01f, 5.24781644e-03f, -1.00005575e-01f, -1.64866567e-01f, -1.07687399e-01f,
  -1.29434718e-02f, 4.51289932e-04f, -1.04765803e-01f, -7.73156062e-02f, -3.32454108e-02f, -2.98244841e-02f, -7.59147555e-02f, -1.23743787e-01f, -4.89613153e-02f, 1.35241836e-01f,
  -5.25322020e-01f, -3.43567610e-01f, 1.52401119e-01f, 8.26820061e-02f, 1.76848203e-01f, 5.04888259e-02f, 4.04338911e-02f, 5.31487539e-02f, 1.73163593e-01f, 4.28965129e-02f,
  9.87266749e-02f, 6.98768571e-02f, -1.23203225e-01f, -1.71648376e-02f, 7.85183460e-02f, -7.02546015e-02f, 4.67186533e-02f, -1.80474315e-02f, -5.96102290e-02f, -4.57680114e-02f,
  -1.57873854e-01f, 1.11958093e-03f, 7.20225275e-03f, -8.92748311e-02f, 8.17572847e-02f, -3.85128963e-03f, 6.06683455e-02f, 1.20956436e-01f, 6.16035014e-02f, -8.88323560e-02f,
  2.52502114e-01f, -3.62114102e-01f, 8.42931047e-02f, 2.81164050e-01f, 1.89477801e-01f, 1.29877388e-01f, -8.69935229e-02f, 2.13332325e-02f, 3.04630071e-01f, 1.05776377e-01f,
  1.23902567e-01f, 1.91541418e-01f, 1.17281415e-01f, 1.10512592e-01f, 1.83342233e-01f, 1.69731513e-01f, 1.64012328e-01f, 3.20341438e-01f, 3.01965415e-01f, 1.95120439e-01f,
  6.35257438e-02f, 4.81486656e-02f, 1.44089177e-01f, 1.93423212e-01f, -2.32523847e-02f, 1.19538806e-01f, 1.40031099e-01f, 4.68402952e-02f, 1.10945925e-02f, 2.55949646e-02f,
  1.25548542e-01f, -7.85039514e-02f, 3.45228016e-01f, 5.97930662e-02f, -1.73754677e-01f, -4.12659906e-02f, -2.50379387e-02f, -5.38685881e-02f, -1.78398155e-02f, 6.86156228e-02f,
  4.48956192e-02f, -3.69309224e-02f, -1.20344549e-01f, -1.55281663e-01f, 1.37859664e-03f, -7.10298866e-02f, -4.11986709e-02f, 7.79418275e-02f, 1.40717059e-01f, 4.81403209e-02f,
  -1.79708764e-01f, 1.00099362e-01f, 5.77718988e-02f, 8.11951682e-02f, 1.57139041e-02f, 1.23557881e-01f, -3.37594608e-03f, -7.91274360e-04f, 8.02946314e-02f, -8.03676993e-02f,
  7.31299371e-02f, 1.86517276e-02f, -3.39545086e-02f, 6.06770255e-02f, -1.09714434e-01f, -2.15152167e-02f, -3.63798365e-02f, -1.41386032e-01f, -4.78190221e-02f, -2.37619653e-01f,
  -5.87763414e-02f, 9.62851867e-02f, 7.23582804e-02f, 7.38942176e-02f, 5.18386811e-02f, -1.46578416e-01f, -2.12834820e-01f, 9.10524726e-02f, 4.62340452e-02f, -2.31703427e-02f,
  -7.37988204e-02f, -4.35431115e-02f, -5.17492816e-02f, -3.71526890e-02f, 4.34224978e-02f, 7.69047290e-02f, -1.03917755e-01f, -3.43932807e-02f, -1.58337489e-01f, -1.02463260e-01f,
  2.00017393e-01f, 2.77671814e-01f, 2.52654161e-02f, 1.76820420e-02f, -2.33082958e-02f, -2.00940564e-01f, 1.15698770e-01f, 4.67705689e-02f, 3.26451566e-03f, 1.15869038e-01f,
  -7.70726129e-02f, 4.78470698e-03f, -1.71188638e-01f, -6.88711703e-02f, -6.66321255e-03f, 8.34749192e-02f, -1.67684615e-01f, 1.22748666e-01f, 1.64453790e-01f, 2.12129783e-02f,
  2.55021788e-02f, 2.56476611e-01f, 3.93643647e-01f, 2.86265135e-01f, -3.74492407e-02f, 2.64586508e-01f, 1.13983033e-02f, -3.28318099e-03f, 1.47226185e-01f, -1.49700105e-01f,
  -3.71135712e-01f, -3.42950553e-01f, 9.28324088e-02f, 3.31915542e-02f, 2.15032265e-01f, 1.78135708e-01f, 2.93173492e-01f, 1.02285877e-01f, 1.51558081e-02f, -1.14559613e-01f,
  -3.28967631e-01f, -1.44608498e-01f, -1.91396594e-01f, -1.96933895e-01f, -1.54374361e-01f, 3.11352462e-01f, 1.92023873e-01f, 1.96786523e-02f, 8.93770233e-02f, 2.10984960e-01f,
  2.64492691e-01f, 2.81784713e-01f, -7.98414648e-02f, 7.31843337e-02f, 1.66005120e-02f, 1.45739138e-01f, 1.12095244e-01f, -4.90334108e-02f, -1.35336816e-01f, -3.70028727e-02f,
  -1.48316711e-01f, -4.83130813e-01f, 7.83180594e-02f, -2.11814225e-01f, -1.03861973e-01f, -1.26979977e-01f, -3.90524305e-02f, 6.07876433e-03f, 4.79147434e-02f, 8.95553008e-02f,
  -6.70199022e-02f, -5.98621443e-02f, -3.56057025e-02f, -5.84932184e-03f, 1.45819783e-01f, 2.83936132e-02f, -6.96974322e-02f, 4.34081489e-03f, -1.19919125e-02f, 5.02162438e-04f,
  -1.21034265e-01f, -3.60165574e-02f, 8.84566009e-02f, 1.54076666e-01f, -1.24080498e-02f, -9.62699726e-02f, -1.12436362e-01f, -1.05083033e-01f, -1.68457702e-01f, 5.12626134e-02f,
  -9.11570564e-02f, 1.49254575e-01f, -3.44363824e-02f, 1.80812646e-02f, 7.95073956e-02f, 1.27244562e-01f, 1.60971526e-02f, 1.58775896e-01f, 6.70138299e-02f, 6.20703623e-02f,
  1.62556060e-02f, -3.49527062e-03f, 3.41479390e-05f, 4.39550094e-02f, -8.54222663e-03f, -1.21381156e-01f, 1.20453918e-02f, 5.17126452e-03f, -2.47986279e-02f, -4.24898975e-02f,
  -8.41000378e-02f, -1.58270393e-02f, 3.20916474e-02f, -4.14639292e-03f, -8.07058662e-02f, -2.44472474e-02f, -3.70052680e-02f, -1.62383035e-01f, 6.65622354e-02f, 5.75021692e-02f,
  2.39661023e-01f, -3.26709449e-01f, 5.81337735e-02f, -3.28456387e-02f, -8.36438611e-02f, -1.83279335e-01f, -5.60517795e-02f, -1.00567751e-01f, 2.40960019e-03f, 6.46597818e-02f,
  -8.70394409e-02f, -1.08133495e-01f, -5.47074862e-02f, 9.11383890e-03f, 2.41824269e-01f, 9.95500311e-02f, -1.29724871e-02f, 4.50188182e-02f, 1.03938475e-03f, 9.01849642e-02f,
  1.63894758e-01f, 2.03193024e-01f, 2.78451502e-01f, 1.55786157e-01f, 7.33527318e-02f, 1.54748946e-01f, 1.77103311e-01f, 9.16773230e-02f, 4.01480272e-02f, 3.70448112e-01f,
  5.40737212e-01f, 3.18893522e-01f, 3.59928876e-01f, 2.41944287e-02f, -2.43803654e-02f, 1.37388363e-01f, 3.90855014e-01f, 2.11119458e-01f, -1.28382131e-01f, 4.86194082e-02f,
  9.73796770e-02f, -2.63097972e-01f, -1.83217078e-01f, -9.91353989e-02f, 8.92532244e-02f, 1.00514509e-01f, -3.03539587e-03f, 1.56872928e-01f, 1.04474694e-01f, 9.04883146e-02f,
  -1.82037115e-01f, 2.61903614e-01f, 3.17474693e-01f, 4.19571884e-02f, -2.87432075e-02f, -3.47445875e-01f, 5.20065241e-02f, 1.80239171e-01f, 1.39707744e-01f, 7.05017373e-02f,
  7.56210014e-02f, 2.89109498e-01f, -4.21455711e-01f, -1.70091882e-01f, 1.43674128e-02f, -1.17465317e-01f, -4.60964590e-02f, -2.89868880e-02f, -3.31258662e-02f, -1.24059714e-01f,
  -2.53270790e-02f, 7.65566006e-02f, 1.98223874e-01f, 1.11944735e-01f, 8.96945298e-02f, -1.31380018e-02f, 1.63684607e-01f, 2.60206848e-01f, 1.49574429e-01f, 6.78998008e-02f,
  -2.71748984e-03f, 1.11507073e-01f, 1.74563706e-01f, 3.16277822e-03f, 1.65816978e-01f, -5.78407831e-02f, 2.79238466e-02f, 5.61765470e-02f, 3.28585356e-02f, 9.34345499e-02f,
  -1.72923654e-01f, 1.73287094e-02f, 6.63593225e-03f, 9.11113434e-03f, 1.52691901e-01f, -4.24851626e-02f, 7.81771839e-02f, 8.57035592e-02f, 1.20366447e-01f, 5.96678369e-02f,
  9.33234468e-02f, 3.31005529e-02f, 4.24968675e-02f, 2.68337149e-02f, -1.82958677e-01f, 1.44823208e-01f, 6.17801026e-02f, -2.15436500e-02f, 2.37656403e-02f, -1.77880116e-02f,
  5.84112015e-03f, 1.07614174e-01f, -3.79053131e-02f, 1.29135594e-01f, -5.80138490e-02f, -3.22203487e-02f, 1.42511341e-03f, 9.53173116e-02f, -1.28060607e-02f, 2.98381131e-02f,
  -4.12953496e-01f, 2.18865499e-01f, -1.29224002e-01f, -8.02007914e-02f, 5.37914522e-02f, 4.15138714e-03f, -2.90563516e-02f, -9.12158117e-02f, -3.40967029e-02f, -1.58325776e-01f,
  6.37811571e-02f, -8.10500681e-02f, 1.15511961e-01f, 1.30833849e-01f, -7.15044737e-02f, -5.28242961e-02f, -4.37178873e-02f, 5.45687750e-02f, -5.16664870e-02f, 4.17964347e-02f,
  9.56691988e-03f, -1.00025572e-01f, -2.57952124e-01f, -2.07605854e-01f, -1.06105767e-01f, -4.28734839e-01f, -9.45983976e-02f, -1.66837722e-01f, -1.04588598e-01f, -2.23106399e-01f,
  5.47889248e-02f, 3.89494523e-02f, -9.53559130e-02f, 4.57438350e-01f, 2.44169727e-01f, -3.64053279e-01f, -5.15211582e-01f, -3.19808841e-01f, 2.47487739e-01f, 1.31637231e-01f,
  1.12682022e-01f, 2.28393808e-01f, 1.51737913e-01f, -4.25059274e-02f, -4.52410430e-01f, -3.11375130e-02f, 1.15614109e-01f, -1.79144472e-01f, -2.73719251e-01f, -1.39714986e-01f,
  2.56792843e-01f, 8.05643424e-02f, -2.08081439e-01f, -2.00878121e-02f, 4.97856379e-01f, 1.70320734e-01f, 6.41937926e-02f, 1.08608976e-01f, -4.06923257e-02f, 4.74051148e-01f,
  1.84254095e-01f, -1.08026884e-01f, -1.63062960e-01f, 3.20707038e-02f, 9.18754861e-02f, -9.83536541e-02f, 2.83491351e-02f, 8.65784660e-02f, 5.01865894e-02f, 9.02597886e-03f,
  2.28152394e-01f, 5.36023313e-03f, 1.34180889e-01f, 1.77186728e-02f, 1.25252167e-02f, -9.96993110e-02f, -6.93497360e-02f, -1.56337753e-01f, -2.03522518e-01f, -6.59338981e-02f,
  2.76955426e-01f, 2.24927098e-01f, -3.26145142e-01f, -2.85494715e-01f, -2.54625022e-01f, -2.20509134e-02f, -1.74618557e-01f, -1.68536231e-02f, -4.33295637e-01f, -3.72599699e-02f,
  -2.23001018e-01f, 6.26420453e-02f, -1.16470531e-01f, 2.65943054e-02f, 1.40554877e-02f, 5.23093715e-02f, 9.36114788e-02f, -7.76613429e-02f, -5.16303480e-02f, -6.04208037e-02f,
  -4.87299040e-02f, 5.51674888e-02f, 1.45432465e-02f, -7.39334822e-02f, 2.11279676e-03f, 1.94555558e-02f, 7.04492778e-02f, -1.62592113e-01f, -1.63051412e-01f, 3.15686651e-02f,
  -3.04544717e-03f, 1.84693243e-02f, -4.12302744e-03f, 3.34126386e-03f, -2.60484014e-02f, -7.87474513e-02f, 3.42097357e-02f, -2.54183579e-02f, -3.56103741e-02f, -1.13969920e-02f,
  1.27555087e-01f, -2.89907038e-01f, 6.32607713e-02f, -1.10016413e-01f, 4.10993546e-02f, -3.48119996e-02f, 7.76708499e-02f, -6.43304065e-02f, 9.37157050e-02f, -1.83090806e-01f,
  -1.88900381e-01f, -5.91907389e-02f, 2.41388492e-02f, 2.44473270e-03f, 1.02803633e-01f, -5.91223463e-02f, -3.80818173e-02f, 1.04432374e-01f, 4.77146022e-02f, 5.05489409e-02f,
  -7.11492077e-02f, -2.42535517e-01f, -3.16856265e-01f, -1.69834107e-01f, -3.64973173e-02f, -1.53964221e-01f, -1.61291629e-01f, -8.08074400e-02f, -3.06420147e-01f, -2.56788433e-01f,
  5.32978237e-01f, -2.93545038e-01f, -7.98822939e-01f, -1.11718578e-02f, -4.93992388e-01f, -3.20322931e-01f, -2.34070852e-01f, 1.67311609e-01f, 2.14132309e-01f, -3.16193640e-01f,
  -2.66103595e-01f, 5.12516312e-02f, -8.78581926e-02f, 1.36162601e-02f, 2.43271872e-01f, -4.96631294e-01f, -3.49507630e-01f, -1.63715884e-01f, 8.29418749e-02f, -8.60400591e-03f,
  3.91944870e-02f, 6.02620840e-02f, 2.22898990e-01f, 1.46436125e-01f, -3.11867625e-01f, -2.52493501e-01f, -4.53527510e-01f, -2.43091285e-01f, -3.54588270e-01f, -4.72424924e-01f,
  -3.29765230e-01f, -1.53578833e-01f, -1.47089660e-01f, 1.53944835e-01f, -2.27646858e-01f, 5.65568395e-02f, 7.18112849e-03f, -1.91601627e-02f, -3.72466929e-02f, -1.22072347e-01f,
  -2.64027447e-01f, 8.47958326e-02f, 2.26139531e-01f, -4.67406809e-02f, -1.34846643e-01f, -5.56311682e-02f, -1.37456432e-01f, -1.44222051e-01f, -7.72986338e-02f, -2.16055498e-01f,
  -1.34518975e-02f, -7.39499405e-02f, -1.07391946e-01f, -8.26539770e-02f, -8.57304037e-02f, -9.32791233e-02f, -2.20076665e-01f, -1.26819015e-01f, -2.58050650e-01f, 3.26866843e-02f,
  1.94455460e-02f, -3.28603052e-02f, -1.20790116e-01f, 6.09763600e-02f, 8.20393190e-02f, -7.21037164e-02f, 7.95177966e-02f, 6.31859377e-02f, 1.40847340e-01f, 7.44099542e-03f,
  -9.19671450e-03f, -1.08803295e-01f, 6.13993295e-02f, 3.92947206e-03f, -5.59026450e-02f, -4.39971127e-02f, -8.67683366e-02f, -5.49278185e-02f, -5.90156876e-02f, 2.07912512e-02f,
  6.32789824e-03f, -6.97652549e-02f, -2.69634333e-02f, 2.24331003e-02f, -1.02903508e-01f, -5.16116135e-02f, -1.22826740e-01f, 4.46031727e-02f, 3.46399695e-02f, -5.74633144e-02f,
  2.39496708e-01f, -1.26562774e-01f, -8.05654749e-03f, 1.23794429e-01f, -9.35710408e-03f, -1.81568414e-01f, -1.33662120e-01f, 7.94527829e-02f, -5.44644631e-02f, -2.09881868e-02f,
  -1.34356022e-01f, -3.90039524e-03f, -3.24530825e-02f, -4.87775207e-02f, 1.96388979e-02f, 3.78901511e-02f, -2.39811633e-02f, 2.24587461e-03f, 2.80920360e-02f, -4.74857800e-02f,
  1.21184036e-01f, 1.45476207e-01f, 2.82236636e-01f, 1.55557051e-01f, 6.53110147e-02f, 1.37689605e-01f, -3.34035866e-02f, -5.74219786e-02f, 2.83432186e-01f, 3.03494662e-01f,
  1.19926059e+00f, -1.77571401e-01f, 2.64826298e-01f, 1.34006634e-01f, -1.26426920e-01f, 3.22261043e-02f, -1.39747575e-01f, 3.54764163e-02f, 7.89646730e-02f, 3.04096211e-02f,
  -1.85862947e-02f, 1.98575273e-01f, 2.36606389e-01f, 1.66380197e-01f, 1.77072167e-01f, -2.13980898e-01f, -1.74375743e-01f, 2.63369262e-01f, 3.71161729e-01f, 1.06964163e-01f,
  -8.16514939e-02f, -1.26204461e-01f, 2.35012576e-01f, 1.04081795e-01f, -2.24095076e-01f, 7.81437531e-02f, -1.22182652e-01f, -2.88578928e-01f, -1.49429068e-01f, -4.81552929e-02f,
  1.78767309e-01f, 1.11176567e-02f, 1.21454060e-01f, -4.19437885e-02f, -1.44052893e-01f, -2.71943794e-03f, 2.45344453e-02f, -7.30304196e-02f, -1.43939257e-01f, -1.91155151e-01f,
  -4.91655283e-02f, 2.78601050e-02f, -2.86615863e-02f, -4.71731052e-02f, -1.01258196e-01f, -9.97246504e-02f, -7.23524392e-02f, 4.59172986e-02f, -1.20727852e-01f, -9.22534689e-02f,
  -3.58191133e-02f, -1.71085924e-03f, -9.54761803e-02f, 4.47002053e-02f, 5.44122308e-02f, 7.45325536e-02f, -1.45986050e-01f, 3.27860489e-02f, 6.04674220e-02f, 7.99578354e-02f,
  1.04006395e-01f, 6.48557097e-02f, 9.18642059e-02f, 1.08191386e-01f, 2.87672970e-02f, 5.54438978e-02f, 4.00887243e-02f, 6.66454434e-02f, 7.17671737e-02f, -2.11904813e-02f,
  -7.89805353e-02f, 1.27133712e-01f, 2.85638776e-02f, 3.26933265e-02f, 2.09567621e-02f, -2.72089355e-02f, 5.58977108e-03f, -7.56709799e-02f, 3.51263694e-02f, 7.87294656e-03f,
  -2.27214787e-02f, -4.08303551e-02f, -6.14339709e-02f, -1.42151415e-01f, -5.05120009e-02f, 3.33275683e-02f, 2.36300286e-02f, -1.80314872e-02f, 1.72354113e-02f, -8.36643204e-02f,
  -3.17936480e-01f, 1.56577259e-01f, 2.18259558e-01f, -3.23211104e-02f, -1.38374753e-02f, 1.41572906e-02f, 1.19802825e-01f, -9.38768238e-02f, -1.73162594e-01f, -1.58040464e-01f,
  -7.72450566e-02f, 2.31002830e-02f, -3.69481221e-02f, 5.40134236e-02f, 1.52694821e-01f, 6.24242611e-02f, 4.27027009e-02f, -1.05981147e-02f, -1.07556405e-02f, -8.82956386e-02f,
  -6.88083023e-02f, 2.10562900e-01f, 1.37036309e-01f, 2.16491982e-01f, 1.00314148e-01f, 1.18951246e-01f, 1.22949714e-02f, -1.57588720e-02f, 5.19267209e-02f, -4.91037667e-02f,
  -4.28041697e-01f, -1.05223373e-01f, -2.37887621e-01f, -2.14797869e-01f, -1.01605309e-02f, 1.39291421e-01f, -1.03009194e-02f, 2.42130026e-01f, 1.18459925e-01f, -1.66074157e-01f,
  -5.39487414e-02f, -4.65374023e-01f, -3.72706622e-01f, -2.86423922e-01f, -3.46480101e-01f, -2.70199239e-01f, -3.61990154e-01f, -4.30748940e-01f, -1.60405174e-01f, 3.42663556e-01f,
  1.45159423e-01f, -2.17378587e-01f, -2.45434657e-01f, 3.13118771e-02f, 1.17936872e-01f, -1.53420910e-01f, -5.88874072e-02f, -1.74909666e-01f, -2.00599385e-03f, -3.35925043e-01f,
  -2.58614451e-01f, 1.13501593e-01f, 4.55699787e-02f, -1.99353471e-01f, 8.50827470e-02f, 4.29060124e-02f, 9.13124755e-02f, -4.83241305e-02f, 2.48233080e-02f, 2.85234805e-02f,
  -1.95554689e-01f, 5.98592497e-02f, -1.30767524e-01f, 5.70295081e-02f, -9.04581472e-02f, 1.05783090e-01f, -1.73354894e-01f, -2.53372639e-02f, -1.73336998e-01f, 2.03363344e-01f,
  -1.60496935e-01f, -3.22769344e-01f, -3.64550561e-01f, 1.49381444e-01f, 2.01446414e-01f, -1.88388526e-01f, -9.99837276e-03f, 3.84702623e-01f, 2.90215135e-01f, 1.19164914e-01f,
  1.89801022e-01f, 1.34349570e-01f, -7.39104822e-02f, -1.73984408e-01f, -8.47307220e-02f, -8.65602959e-03f, -1.04301110e-01f, 6.59393594e-02f, 2.09397078e-02f, 3.10041849e-02f,
  9.87030417e-02f, 7.69403279e-02f, 1.04072474e-01f, 1.23899110e-01f, -9.22738314e-02f, -1.56261469e-03f, 3.86410691e-02f, -3.24134380e-02f, -5.77721037e-02f, -5.24072349e-02f,
  -1.61428526e-01f, 2.73215622e-02f, -4.83352095e-02f, 9.51607898e-02f, -8.72114673e-02f, -4.43618596e-02f, 3.17699648e-02f, -4.63963114e-02f, -7.83629995e-03f, 2.39332527e-01f,
  -2.07842872e-01f, -8.37658122e-02f, 9.69871529e-04f, -1.56603411e-01f, 2.71681361e-02f, -7.75567081e-04f, -9.71769914e-02f, 1.88896190e-02f, -4.40843813e-02f, -1.43009694e-02f,
  3.80020216e-03f, 1.97356045e-02f, -4.31741066e-02f, 1.11613482e-01f, -7.04209805e-02f, 8.67511705e-03f, -2.58560389e-01f, -1.44649431e-01f, -2.22377300e-01f, 7.37894252e-02f,
  -1.06948055e-01f, -2.29060605e-01f, -3.54364991e-01f, -1.79004371e-01f, 7.10057691e-02f, -3.40281457e-01f, -2.07518935e-01f, 1.42577261e-01f, -1.12920754e-01f, -1.26698494e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.61079007e-01f, 1.49759606e-01f, 3.74019772e-01f, 5.14112353e-01f, 3.08776140e-01f, -2.99785733e-01f, 2.81589329e-01f, 5.77372350e-02f, 4.02315408e-01f, 1.81991875e-01f,
  1.23007089e-01f, 2.79875159e-01f, 3.94750655e-01f, 2.11982187e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -8.05318877e-02f, 1.34372473e-01f, -1.19509764e-01f, -1.23278506e-01f, -6.38432354e-02f, -7.41284415e-02f, 3.03756315e-02f, -1.53792292e-01f, 1.79893244e-02f, 3.17006111e-01f,
  -1.38160295e-03f, 2.16990247e-01f, 2.98203062e-02f, 1.70113385e-01f, -1.65562350e-02f, 8.75092372e-02f, 1.21040948e-01f, -1.01100512e-01f, 8.90457164e-03f, 1.73077047e-01f,
  3.51380557e-01f, -1.82403088e-01f, -2.58181542e-01f, 1.01178795e-01f, -4.19713348e-01f, 4.86800186e-02f, 3.33166271e-01f, -4.29849148e-01f, 2.35641971e-02f, 1.04753286e-01f,
  -3.00763361e-02f, 2.59069592e-01f, -3.00710201e-02f, 3.93188186e-02f, 2.38754764e-01f, 1.70443296e-01f, 8.82927999e-02f, 3.97791760e-03f, -1.40625432e-01f, -3.25025395e-02f,
  1.51309237e-01f, -1.45633906e-01f, 2.53147274e-01f, 8.55623037e-02f, 4.14858423e-02f, -1.21398289e-02f, 1.80482969e-01f, 3.21898371e-01f, -2.22324908e-01f, 4.10866886e-02f,
  -3.22434038e-01f, -1.10799253e-01f, -1.41311735e-01f, 1.22102566e-01f, 2.12901875e-01f, -1.77956104e-01f, -8.72435868e-02f, -6.92242682e-02f, 3.15151781e-01f, -2.19068632e-01f,
  6.64879605e-02f, -2.82236159e-01f, 1.74539328e-01f, 4.80809584e-02f, -2.05474153e-01f, -9.13271382e-02f, -6.60882192e-03f, -7.97492415e-02f, -7.74592832e-02f, 1.39779104e-02f,
  -1.91833928e-01f, -7.22055510e-02f, -4.63016555e-02f, -1.39628232e-01f, -3.23274374e-01f, 5.94259277e-02f, -1.40639231e-01f, -4.00658287e-02f, -1.59644455e-01f, -2.16302991e-01f,
  2.66740978e-01f, 1.52781829e-01f, 4.34563249e-01f, 1.06662195e-02f, 5.87451994e-01f, -3.56013440e-02f, 2.01952010e-01f, 1.89699546e-01f, -2.68841267e-01f, -1.16320387e-01f,
  -4.90867272e-02f, -1.75838143e-01f, -1.28337502e-01f, -3.58019918e-01f, 9.00673568e-02f, 1.15535319e-01f, 2.22454965e-03f, 1.06398828e-01f, 1.51350141e-01f, 2.36472543e-02f,
  3.22256400e-03f, -3.10768373e-02f, -4.07859497e-02f, -1.18767373e-01f, 3.73193175e-02f, 2.79733855e-02f, 1.25172704e-01f, -1.09151296e-01f, -1.00169413e-01f, -2.46565808e-02f,
  2.42678210e-01f, 2.50807349e-02f, -4.81022924e-01f, 1.13407979e-02f, -1.99724719e-01f, -3.54346931e-01f, -1.40267581e-01f, 1.15438491e-01f, -2.21471921e-01f, 2.21277654e-01f,
  -5.99295534e-02f, -1.34392425e-01f, 7.73646832e-02f, 2.46590406e-01f, -4.47916448e-01f, 2.14270893e-02f, 1.74413934e-01f, 2.12103397e-01f, -2.13883013e-01f, -1.01400368e-01f,
  -1.26772255e-01f, 4.22655530e-02f, -1.65231124e-01f, -2.14082420e-01f, -1.58629879e-01f, -3.10695730e-02f, -8.19281563e-02f, 1.47920236e-01f, -8.55959505e-02f, 1.36316448e-01f,
  -2.05489784e-01f, -4.99565788e-02f, -3.09794456e-01f, -2.89631754e-01f, 1.33425638e-01f, -6.08629584e-02f, -3.72836262e-01f, -3.15156788e-01f, 2.50588566e-01f, -4.50423174e-02f,
  -2.44078152e-02f, 1.53629035e-01f, -1.29306972e-01f, -1.33151978e-01f, 1.58268288e-02f, 1.54332981e-01f, 4.27443832e-01f, 8.39772522e-02f, -3.14539783e-02f, 2.66738385e-01f,
  -1.62930526e-02f, -2.27456260e-02f, -7.34859183e-02f, -4.97163832e-02f, -1.20810293e-01f, -2.13143587e-01f, -5.60839064e-02f, 4.54400741e-02f, -2.60856263e-02f, 1.24808580e-01f,
  -6.33533970e-02f, 2.58158147e-01f, -4.33270425e-01f, 6.58775494e-02f, -1.07501470e-01f, -2.53789157e-01f, -8.75836890e-03f, -1.17106855e-01f, -2.88364649e-01f, -1.98508561e-01f,
  -1.63081199e-01f, -5.12178898e-01f, 6.25857040e-02f, 7.78228045e-02f, -2.74009584e-03f, 6.87956735e-02f, -1.13144591e-01f, -3.65262896e-01f, 3.39965850e-01f, 4.98937100e-01f,
  -1.14232682e-01f, 2.57079639e-02f, 8.78725871e-02f, -5.80224320e-02f, -9.92570370e-02f, 1.37188705e-02f, 1.06304377e-01f, 1.58681750e-01f, 1.74478546e-01f, 2.45270226e-02f,
  -2.35386379e-02f, -9.12223235e-02f, 8.69467705e-02f, -1.69047222e-01f, 2.04136744e-01f, 5.24737835e-02f, 6.64294735e-02f, 1.26401454e-01f, 1.40336990e-01f, 1.22653611e-01f,
  1.27692461e-01f, 3.53101455e-02f, 3.46650571e-01f, 1.45767704e-01f, 1.36119053e-01f, -7.17153773e-02f, -1.46429524e-01f, 1.77133143e-01f, 7.40368664e-02f, 2.42613077e-01f,
  -4.14339483e-01f, -2.57003248e-01f, -1.15521640e-01f, -3.97580080e-02f, 7.14996308e-02f, 4.33596931e-02f, -2.67420243e-02f, 2.05522388e-01f, 1.26044258e-01f, -2.11657025e-02f,
  -6.61599357e-03f, -7.41388202e-02f, 1.30611137e-01f, -1.44621460e-02f, -3.17206373e-03f, -5.88373914e-02f, 2.49338970e-01f, 2.06640467e-01f, -1.12535402e-01f, 1.04379326e-01f,
  -7.94690102e-02f, 2.39056144e-02f, -5.02477407e-01f, 5.88933341e-02f, 1.65621355e-01f, 6.03102595e-02f, 1.04535781e-01f, -1.04351873e-02f, 2.98891366e-01f, -1.61117047e-01f,
  2.03994513e-01f, 1.42501844e-02f, 6.79812580e-02f, -1.52705342e-01f, -2.74726778e-01f, 7.59987235e-02f, -1.34854198e-01f, 3.06532811e-02f, 9.04150084e-02f, -1.87793121e-01f,
  -4.07691374e-02f, 9.10589695e-02f, -1.79487720e-01f, -1.78675920e-01f, 3.15096490e-02f, -1.19623251e-01f, -1.86119124e-01f, -6.39072880e-02f, -1.19905077e-01f, 7.70628154e-02f,
  -9.28652436e-02f, 3.90931852e-02f, 4.26976942e-02f, 4.16088402e-02f, 5.54573119e-01f, 1.50519028e-01f, 2.63074845e-01f, 7.44857341e-02f, -1.58992499e-01f, 1.92795083e-01f,
  -2.33321652e-01f, 5.49885370e-02f, -2.24438131e-01f, -2.42484193e-02f, -1.77467600e-01f, -2.98863441e-01f, 2.03815877e-01f, 2.71283090e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.27352077e-01f, 1.10626206e-01f, 4.17136494e-03f, 5.36403656e-01f, 2.20822394e-01f, 1.37037009e-01f, 1.90886423e-01f, 1.15726143e-01f, 2.01386854e-01f, 3.65776032e-01f,
  -9.26088095e-02f, 2.27703854e-01f, 1.87393069e-01f, 2.64144123e-01f, 2.02396601e-01f, -3.35725099e-01f, 5.45246713e-02f, -1.56715617e-01f, -3.82316470e-01f, -2.19026089e-01f,
  6.79154694e-01f, 3.21342885e-01f, 5.20001769e-01f, -3.59308243e-01f, -3.32391024e-01f, 1.35437660e-02f, 4.81195241e-01f, -1.19841710e-01f, 4.64078099e-01f, 8.49792883e-02f,
  -3.18780631e-01f, 2.83405054e-02f, 2.42113873e-01f, 8.08779821e-02f, 2.40203515e-01f, 6.23392873e-02f, -8.33101850e-03f, 1.26401670e-02f, 6.73862994e-02f, 2.71270424e-01f,
  3.13785896e-02f, 2.23309398e-01f, 5.57020344e-02f, 3.75336528e-01f, -2.58788675e-01f, -1.74112454e-01f, 1.30393088e-01f, -3.68435055e-01f, 1.40888974e-01f, 1.88552186e-01f,
  -2.28461727e-01f, -1.19462289e-01f, 6.12686157e-01f, 8.08940977e-02f, 4.34780926e-01f, -7.69264922e-02f, -1.35400414e-01f, 1.42767891e-01f, 2.65182853e-01f, -3.28513831e-01f,
  4.83546525e-01f, -3.19290943e-02f, -3.96634668e-01f, 2.80064791e-01f, 2.90569246e-01f, 1.04289472e-01f, 1.73854321e-01f, 4.72008670e-03f, 1.88039348e-01f, 5.68607450e-02f,
  3.39389503e-01f, 3.05080563e-01f, 8.64196122e-02f, -4.08984780e-01f, -3.49639393e-02f, -1.77048184e-02f, 3.33316773e-01f, -1.57877967e-01f, -2.70075262e-01f, 2.65964478e-01f,
  2.40723133e-01f, 1.21153831e-01f, 5.57197094e-01f, 5.68030119e-01f, -7.91975707e-02f, -1.96376443e-01f, 2.28033558e-01f, -2.48508424e-01f, 3.28925192e-01f, 2.98973769e-02f,
  -5.76594174e-01f, 5.18396914e-01f, 3.06238323e-01f, 2.02538241e-02f, 2.33206853e-01f, -9.11277175e-01f, 2.31830612e-01f, -1.21209882e-02f, 6.94570616e-02f, -3.00165862e-02f,
  -9.20343697e-02f, -4.70717922e-02f, -1.25063956e-01f, 1.11801811e-02f, 2.10104644e-01f, -3.38695079e-01f, 2.91955546e-02f, -1.36655882e-01f, 1.79171488e-01f, -6.28944440e-03f,
  2.61326939e-01f, 2.28338256e-01f, -2.85499424e-01f, 1.28129929e-01f, 3.21640909e-01f, -7.05920517e-01f, -7.07154861e-03f, -8.68027806e-02f, 2.56568760e-01f, -2.67317832e-01f,
  -6.96088597e-02f, 3.30708802e-01f, 5.17608762e-01f, 1.12022594e-01f, 1.39447495e-01f, 1.82661802e-01f, 6.01412654e-01f, -2.03231916e-01f, 1.43648133e-01f, 2.53613770e-01f,
  4.01526660e-01f, 1.48854870e-02f, 1.37243897e-01f, 1.09342135e-01f, 1.99745730e-01f, 4.27274406e-01f, 1.83354601e-01f, -2.40347728e-01f, -2.81055309e-02f, 3.34206939e-01f,
  -2.87843674e-01f, -1.19147316e-01f, 6.38732081e-03f, 7.59256631e-02f, 4.46720654e-03f, 1.07402869e-01f, 6.20993257e-01f, 7.59737849e-01f, -4.42964472e-02f, -4.25368756e-01f,
  -2.81905264e-01f, 5.40159762e-01f, -3.60451907e-01f, 2.44481359e-02f, -2.95596331e-01f, 9.19830054e-02f, 2.83518881e-01f, 6.50620520e-01f, 3.77833217e-01f, 1.99189246e-01f,
  -1.15309902e-01f, 1.10808723e-01f, 5.63274138e-02f, 1.77902564e-01f, -9.78961959e-03f, -1.92524210e-01f, -2.53227465e-02f, 3.75093669e-01f, -1.31328255e-01f, -1.30237211e-02f,
  -8.17569047e-02f, -7.23034590e-02f, -1.72907859e-02f, -1.06217451e-01f, -5.12568057e-01f, -1.10043295e-01f, 4.12843913e-01f, 1.82936862e-01f, 1.22288533e-01f, 4.96175557e-01f,
  -5.90887032e-02f, 1.70684129e-01f, 1.97632834e-01f, 7.88945109e-02f, 4.07743305e-01f, -8.85981619e-02f, -6.34405494e-01f, -7.67314732e-02f, 4.32276249e-01f, -2.34493092e-01f,
  1.12581246e-01f, 4.15639192e-01f, 1.42809495e-01f, 2.63733774e-01f, 1.97072625e-01f, 1.22487515e-01f, 2.49408588e-01f, 2.25660339e-01f, 1.14137642e-01f, 3.24777216e-01f,
  5.93931228e-02f, 5.42379320e-01f, 2.01824121e-02f, 2.98333466e-01f, -2.47247621e-01f, -5.94759025e-02f, 1.43645778e-01f, -3.91434908e-01f, -1.69300064e-01f, -1.28921419e-01f,
  1.94963500e-01f, 6.53947413e-01f, 1.34853959e-01f, 1.48994103e-01f, -5.67980409e-01f, 4.16430473e-01f, -4.44815516e-01f, -4.37615113e-03f, 1.56861395e-02f, -4.86902893e-01f,
  -2.32341528e-01f, 4.86514688e-01f, -4.65940893e-01f, 6.19250119e-01f, 3.23655009e-02f, 5.35372505e-03f, 1.85182497e-01f, 1.73501357e-01f, -8.23163837e-02f, 1.04401903e-02f,
  1.36430506e-02f, 1.90103352e-02f, -2.88810283e-02f, -1.82948261e-01f, -1.48594519e-02f, 1.53511986e-01f, 1.81944463e-02f, -1.96345314e-01f, -1.94079235e-01f, 6.72473609e-02f,
  1.86722621e-01f, 8.72380733e-02f, 1.34900793e-01f, 3.75244975e-01f, 5.48323393e-01f, 4.22777265e-01f, 4.39295202e-01f, 6.24058992e-02f, -2.33511403e-01f, 1.67113587e-01f,
  -1.18380412e-02f, -2.30787754e-01f, 4.08919603e-01f, -2.32905194e-01f, -2.94673711e-01f, 1.99637339e-01f, 3.02249402e-01f, 5.22455156e-01f, -1.53907249e-02f, 5.32272041e-01f,
  2.41175413e-01f, 3.05617988e-01f, 2.07000419e-01f, -7.73771554e-02f, 2.45939702e-01f, 3.17227155e-01f, 2.92196393e-01f, -2.27273166e-01f, 5.08319914e-01f, 3.83565515e-01f,
  2.88405627e-01f, 7.44712655e-04f, -1.92410890e-02f, -1.24242492e-01f, -4.21472304e-02f, -3.94424289e-01f, 3.22591394e-01f, 5.22780359e-01f, 2.50527769e-01f, 8.16943217e-03f,
  3.59195061e-02f, -1.95417941e-01f, 4.26794171e-01f, 3.24427158e-01f, -3.76832426e-01f, 4.94459551e-03f, -2.56401569e-01f, -5.94228171e-02f, -2.63217509e-01f, 1.48776829e-01f,
  1.77477241e-01f, 4.11055565e-01f, 1.49846934e-02f, -9.37457681e-02f, -2.06900224e-01f, 1.97650924e-01f, -2.29625627e-02f, 2.55581319e-01f, -3.72492313e-01f, 5.59663773e-02f,
  -3.25286835e-02f, -1.24332897e-01f, 2.13733055e-02f, -3.50997210e-01f, 4.33066219e-01f, 1.29333809e-01f, 2.45817423e-01f, -1.78100690e-01f, 5.33132017e-01f, 4.40714031e-01f,
  4.84444916e-01f, 3.35013956e-01f, -1.60958797e-01f, -1.62742689e-01f, 2.60282382e-02f, -2.89819062e-01f, 4.83356476e-01f, -2.83116817e-01f, -2.07046345e-01f, 4.24439907e-01f,
  9.10541341e-02f, 2.18262851e-01f, 1.56150892e-01f, -1.07980728e-01f, 1.15704164e-01f, 1.91769660e-01f, 1.39775410e-01f, 2.03558132e-01f, 4.27855812e-02f, -2.15640783e-01f,
  -6.88982569e-03f, 1.05843298e-01f, -3.42652917e-01f, -1.84749097e-01f, -1.60838053e-01f, -1.56416982e-01f, 9.38823223e-02f, 6.76589087e-02f, -2.72043757e-02f, 5.09786427e-01f,
  -3.24664772e-01f, -4.28443879e-01f, -1.52627612e-02f, 2.62737200e-02f, -4.21028137e-02f, 2.27556124e-01f, -1.70288131e-01f, -2.55746216e-01f, 6.46259427e-01f, 5.94708800e-01f,
  3.20986003e-01f, 1.31584838e-01f, 3.46632928e-01f, 2.86166221e-01f, 2.94508100e-01f, 2.05527972e-02f, 2.75838524e-01f, 9.64874998e-02f, 2.38050982e-01f, 8.04725066e-02f,
  2.82543123e-01f, -1.94266126e-01f, 2.19859719e-01f, 2.09969714e-01f, -2.19783828e-01f, 5.66373020e-02f, 2.42967978e-01f, -6.58359379e-03f, -5.36009252e-01f, -1.40050709e-01f,
  -1.71420977e-01f, -6.36513948e-01f, -2.91426182e-01f, 7.90430680e-02f, -8.57834816e-02f, -3.48128751e-03f, 2.53647178e-01f, -1.71386693e-02f, 3.76120031e-01f, -6.65218607e-02f,
  1.78037539e-01f, 6.82395637e-01f, 2.86044538e-01f, -2.02946380e-01f, -3.72227542e-02f, 2.25319967e-01f, 1.50011614e-01f, 5.96919894e-01f, 4.55200344e-01f, 3.15451890e-01f,
  2.04887509e-01f, -1.81859266e-02f, 1.25572070e-01f, 3.71602863e-01f, -7.44399950e-02f, -6.92887425e-01f, 6.38806969e-02f, 1.48377299e-01f, -1.79173246e-01f, -2.94987679e-01f,
  7.88237810e-01f, 1.46219894e-01f, 1.52463585e-01f, 4.69800323e-01f, -4.65781055e-02f, 7.13856101e-01f, 1.01638168e-01f, -1.72437564e-01f, -6.07840300e-01f, -2.61863798e-01f,
  2.96554137e-02f, 1.14577059e-02f, -3.99150491e-01f, -1.68303281e-01f, -5.37983954e-01f, -7.30631202e-02f, 2.10418299e-01f, 6.67102039e-02f, 1.23055972e-01f, 2.56061643e-01f,
  3.94095071e-02f, 1.34268850e-01f, 2.21110120e-01f, 1.51918739e-01f, -7.67949000e-02f, 8.38176012e-02f, -3.88624877e-01f, 9.76795778e-02f, 1.95594862e-01f, 4.99310158e-02f,
  -5.66250026e-01f, -1.08871739e-02f, 3.02653193e-01f, -8.40009190e-03f, -7.88753927e-01f, -1.38036847e-01f, 1.91295445e-01f, 1.31385019e-02f, 4.95393991e-01f, -8.77554789e-02f,
  4.46925461e-01f, -3.82118374e-01f, -3.87202322e-01f, 6.54130757e-01f, 2.15750158e-01f, -4.10492271e-01f, -9.25412029e-02f, -4.50510025e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.90660053e-01f, 3.67852807e-01f, 4.50986713e-01f, 8.27752985e-03f, 2.31486782e-01f, 5.00386059e-02f, 3.05023789e-01f, 2.43376523e-01f, 1.84307754e-01f, 1.03065856e-01f,
  2.32176334e-01f, 2.97341645e-01f, 4.63265061e-01f, 2.67591298e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  8.04151818e-02f, 1.27546072e-01f, -1.67236388e-01f, -2.28791032e-02f, 9.84283090e-02f, 2.02727199e-01f, 1.55060276e-01f, 6.47423491e-02f, 1.45753687e-02f, -1.07079566e-01f,
  -2.12291945e-02f, 1.33736387e-01f, 1.38641924e-01f, 1.13905169e-01f, -5.23453914e-02f, -1.66649297e-01f, -2.04371050e-01f, -6.56391010e-02f, -4.08439755e-01f, -1.46021277e-01f,
  2.99713284e-01f, 2.71257013e-02f, 2.01123819e-01f, 1.55004248e-01f, 1.28498033e-01f, -1.76738217e-01f, -2.35724688e-01f, 1.81851581e-01f, 7.16007575e-02f, 1.32920608e-01f,
  4.24274579e-02f, 5.17472960e-02f, -1.13013633e-01f, 1.90251231e-01f, 1.38972372e-01f, -7.59779364e-02f, 1.76278532e-01f, 1.20415846e-02f, 1.00572377e-01f, 2.21720740e-01f,
  -5.56971431e-02f, -4.17541564e-01f, 1.06222011e-01f, -1.37133049e-02f, -9.14053172e-02f, -2.10714042e-02f, 1.91204637e-01f, -3.46190691e-01f, -8.92143250e-02f, -2.31508375e-03f,
  3.13413441e-02f, -1.24394760e-01f, 2.56639957e-01f, -3.56880665e-01f, 2.62370795e-01f, -4.66579273e-02f, 2.02649996e-01f, -2.26555765e-01f, -1.14383876e-01f, -1.92345709e-01f,
  -1.05921226e-02f, 6.24375120e-02f, -1.81657851e-01f, 2.37050205e-01f, -1.29213661e-01f, 2.01698661e-01f, -2.68898547e-01f, -1.13246955e-01f, 9.38868895e-02f, 4.48839217e-01f,
  -1.72634202e-03f, 2.05003068e-01f, -6.01658635e-02f, 2.23614976e-01f, -2.67933011e-01f, 3.15627083e-02f, -2.64699638e-01f, 1.60917640e-01f, 1.02437645e-01f, 2.03028079e-02f,
  1.69267505e-01f, 2.22244471e-01f, 1.81913868e-01f, 6.69813082e-02f, -1.81141704e-01f, -2.30285078e-01f, 8.50432962e-02f, 8.96537453e-02f, 6.93323240e-02f, 3.60578150e-02f,
  1.09633282e-01f, 2.11199462e-01f, -2.62894630e-01f, -2.02927724e-01f, -2.48487189e-01f, 2.78207213e-01f, -1.99001536e-01f, -1.09766915e-01f, -1.56316772e-01f, -9.55267623e-02f,
  -2.38760754e-01f, -3.14298451e-01f, 4.65713553e-02f, -3.67469668e-01f, -1.37478814e-01f, 1.51926711e-01f, 4.58379805e-01f, -4.05273885e-01f, -1.00630082e-01f, -3.99726778e-01f,
  -2.90335000e-01f, 2.21226826e-01f, 2.89350957e-01f, 5.31887682e-03f, 1.23279601e-01f, -2.17984959e-01f, -6.16654870e-04f, 4.16160300e-02f, 2.59809136e-01f, -1.79517940e-01f,
  1.38722330e-01f, 3.63849849e-02f, 1.52802780e-01f, -1.12316482e-01f, -1.93961747e-02f, -4.56891432e-02f, 2.19120383e-01f, -1.70790926e-01f, 9.59806442e-02f, 7.21572042e-02f,
  3.29051316e-02f, -1.74667642e-01f, -3.31440307e-02f, 1.84875891e-01f, -5.25403857e-01f, 7.19977543e-02f, -2.41901934e-01f, 1.91326439e-01f, -2.58177161e-01f, 3.27489078e-01f,
  -1.72848284e-01f, -1.34213567e-01f, 2.05971032e-01f, 7.27887750e-02f, -3.42519641e-01f, 2.14846328e-01f, 4.18385752e-02f, 9.50111151e-02f, -3.28769565e-01f, -9.96999890e-02f,
  -1.61908939e-02f, -1.83522888e-02f, 1.81078240e-01f, 2.64015704e-01f, -1.32094115e-01f, 2.48474419e-01f, -1.46720394e-01f, -3.56693923e-01f, -6.74662441e-02f, 1.27260700e-01f,
  2.06872404e-01f, 6.53105751e-02f, 8.16400796e-02f, 1.45292550e-01f, 1.30605400e-01f, 2.28806704e-01f, -1.74069077e-01f, -1.39880523e-01f, -9.22367871e-02f, -3.01120896e-02f,
  -8.48881304e-02f, 1.53217509e-01f, 1.94304049e-01f, 4.48984116e-01f, 4.44929600e-01f, -3.59171569e-01f, -2.22085923e-01f, 3.84298652e-01f, 2.35924330e-02f, 8.90679881e-02f,
  -4.98203896e-02f, 2.15525895e-01f, -1.70888439e-01f, -1.55223593e-01f, -1.47116080e-01f, 1.41798422e-01f, -2.19887659e-01f, 3.35645899e-02f, 1.08177681e-02f, 3.52235824e-01f,
  -2.39430338e-01f, 2.82702357e-01f, -1.04859062e-02f, -1.08132049e-01f, 5.78049608e-02f, -2.43680775e-01f, -1.48008555e-01f, 2.18753651e-01f, -2.44422674e-01f, -1.60097569e-01f,
  -1.12570874e-01f, 1.03197340e-02f, 3.36740941e-01f, 5.08074462e-01f, 6.19984977e-02f, 1.47611037e-01f, 3.90099376e-01f, -3.80802333e-01f, -1.18342787e-01f, 3.28315854e-01f,
  1.45647734e-01f, 1.42871678e-01f, -1.68956667e-01f, 2.23164812e-01f, 1.16645433e-01f, -1.24708138e-01f, -3.39285694e-02f, 2.92523503e-01f, -2.94650316e-01f, 1.52513698e-01f,
  1.21650167e-01f, 7.71783814e-02f, 1.51428785e-02f, -1.91131160e-02f, -2.37834137e-02f, 1.33169830e-01f, 3.12990129e-01f, 1.28872227e-02f, 1.39410958e-01f, -1.73419639e-02f,
  5.78194857e-02f, 1.64855227e-01f, 1.64147735e-01f, 2.05739141e-01f, -5.62857926e-01f, 4.87263918e-01f, 1.65709496e-01f, 3.46077621e-01f, 4.19017464e-01f, -3.71791661e-01f,
  -2.59431928e-01f, 4.35563356e-01f, -3.16644788e-01f, 6.54650256e-02f, -1.27948195e-01f, 2.03121558e-01f, 1.99785586e-02f, 2.26442024e-01f, -3.46310437e-02f, 4.09120992e-02f,
  -3.68608028e-01f, 1.68059424e-01f, 2.40495548e-01f, -1.29864886e-01f, 8.33068863e-02f, -4.13214229e-02f, -1.38638496e-01f, -1.67579606e-01f, 3.42658237e-02f, -2.14147434e-01f,
  1.64192364e-01f, -2.21505240e-01f, -2.62319058e-01f, 3.31056058e-01f, 9.14340392e-02f, 1.07820235e-01f, -2.39445493e-01f, -1.69662554e-02f, 2.90529490e-01f, 2.92553846e-02f,
  -2.31363118e-01f, 3.95509154e-01f, 1.16661370e-01f, -3.89893800e-01f, 2.10639715e-01f, 2.09734023e-01f, -8.78390744e-02f, -6.94820136e-02f, -2.61395633e-01f, -1.35269731e-01f,
  -1.43357292e-01f, -1.37841955e-01f, 2.89105147e-01f, -2.64301270e-01f, -7.32271969e-02f, 1.03721082e-01f, -1.52263910e-01f, 2.04275861e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.33438781e-01f, -2.38436982e-01f, 3.05053949e-01f, 2.46032089e-01f, 3.16742718e-01f, 2.48493955e-01f, 1.63282007e-01f, 2.92787641e-01f, -5.09735286e-01f, 1.21321378e-03f,
  -8.12540203e-02f, 4.78776217e-01f, -2.09576208e-02f, 5.63581347e-01f, 4.79566783e-01f, -4.05099660e-01f, -2.89102733e-01f, 1.54269770e-01f, -3.26736867e-01f, 4.54309732e-01f,
  -3.57992053e-01f, -2.42781311e-01f, 5.34601033e-01f, 4.97301936e-01f, 6.54643595e-01f, 2.24589244e-01f, -2.91907787e-02f, 4.53883052e-01f, 1.21040434e-01f, -3.08458786e-02f,
  2.71559022e-02f, -4.19983380e-02f, -1.58845350e-01f, 4.41359133e-01f, -1.62004054e-01f, 1.89687267e-01f, 1.43754944e-01f, 9.55631733e-02f, 1.09606050e-01f, 3.01801741e-01f,
  2.19582543e-02f, -1.55218169e-01f, -6.12987876e-01f, 1.53438762e-01f, -3.31134290e-01f, -2.50936836e-01f, -7.95090437e-01f, 6.95345461e-01f, -1.06349215e-02f, -2.11103499e-01f,
  1.80762827e-01f, -2.48498120e-03f, 5.42362332e-01f, -5.17404258e-01f, -1.63092222e-02f, 4.19620812e-01f, 5.22421040e-02f, 4.12410945e-01f, 5.21332264e-01f, 3.09844166e-01f,
  -1.64415136e-01f, -4.78934139e-01f, 8.33070159e-01f, 4.16612476e-01f, -1.84441675e-02f, 9.92837623e-02f, 2.34000832e-01f, -5.00672162e-01f, 2.99746305e-01f, 1.49300516e-01f,
  2.07923409e-02f, 1.62667245e-01f, 2.77640074e-01f, -3.56972814e-01f, 1.70127779e-01f, -3.45076323e-01f, 1.07433863e-01f, 2.32049208e-02f, 3.19765985e-01f, -8.69864784e-03f,
  3.25356513e-01f, -6.22162044e-01f, 5.60029745e-01f, 2.37353206e-01f, 3.69597822e-01f, 2.69191545e-02f, -1.55491203e-01f, 3.00535232e-01f, -5.22679448e-01f, 1.50713757e-01f,
  1.54776543e-01f, 2.59155989e-01f, -3.25422026e-02f, 1.89573094e-01f, -6.40348732e-01f, 7.23427951e-01f, 8.76313984e-01f, 4.20095742e-01f, 4.52064008e-01f, 2.67184079e-01f,
  2.87221819e-01f, 2.39763558e-01f, 2.45118499e-01f, 5.26596606e-01f, 4.93763626e-01f, 8.87604989e-03f, -1.34360045e-01f, 1.26143485e-01f, -1.01088375e-01f, 1.97115578e-02f,
  1.41053721e-01f, -4.85572964e-03f, 1.40292957e-01f, 1.50324658e-01f, 3.82884532e-01f, 1.68777347e-01f, -8.59563425e-02f, -9.65825468e-02f, -1.31723166e-01f, -2.30063438e-01f,
  -5.45129739e-02f, 1.33678213e-01f, 2.18589697e-02f, 3.42033096e-02f, 2.06793159e-01f, 3.32634985e-01f, 2.60297894e-01f, -6.48327544e-02f, 9.06895027e-02f, 7.70524502e-01f,
  2.37182230e-01f, 5.02101541e-01f, 8.39891851e-01f, 2.64759719e-01f, -3.06348242e-02f, 5.31224549e-01f, 1.61388040e-01f, 7.53231466e-01f, -2.32889667e-01f, -5.98770738e-01f,
  2.87506312e-01f, 3.39864986e-03f, 1.05079338e-02f, 4.79196310e-01f, 7.09086582e-02f, -3.82188410e-01f, 7.68267214e-01f, 3.74338597e-01f, -3.00970450e-02f, -2.12361589e-01f,
  -3.00201684e-01f, -4.74290550e-01f, 2.67561108e-01f, 2.20474252e-03f, 6.93919659e-01f, 8.30616280e-02f, -2.04815358e-01f, 3.40888686e-02f, 5.66653669e-01f, 4.74340260e-01f,
  -1.63922071e-01f, -1.24406487e-01f, 1.16374388e-01f, 6.06238842e-02f, 2.63914908e-03f, -5.34724165e-03f, 4.10509259e-01f, 2.87153572e-01f, 3.60537440e-01f, -3.66498053e-01f,
  -1.79972157e-01f, -7.69998431e-01f, -1.92101911e-01f, -3.02991748e-01f, -2.08743840e-01f, 1.68305282e-02f, 3.82320225e-01f, -7.64351130e-01f, -1.04791582e-01f, -1.88550636e-01f,
  4.11895901e-01f, -1.27457231e-01f, 3.60355489e-02f, 6.90960050e-01f, -5.28059185e-01f, -2.72383634e-02f, 1.18229911e-01f, -3.33972633e-01f, 1.22912265e-01f, 3.28588247e-01f,
  -3.55412662e-01f, 4.40274119e-01f, 5.27040720e-01f, 5.05845785e-01f, 3.54508817e-01f, -2.34450325e-01f, -6.97324276e-02f, 5.42787969e-01f, 1.29201353e-01f, 1.63370490e-01f,
  7.13407278e-01f, -4.64496791e-01f, -4.61569488e-01f, 5.47731638e-01f, -3.74885857e-01f, 2.58288503e-01f, 4.85606253e-01f, -1.17482521e-01f, 2.13909328e-01f, 6.49408162e-01f,
  3.89105827e-01f, 4.32537854e-01f, 4.82444614e-01f, 3.93532664e-02f, 4.39141840e-02f, 3.53554726e-01f, -2.70245224e-01f, 2.48760805e-01f, -4.15206313e-01f, 1.46903560e-01f,
  3.30775976e-01f, -4.10269275e-02f, 1.01140551e-01f, 2.53943980e-01f, 4.66080993e-01f, 7.33880103e-02f, 3.80554914e-01f, 1.72767982e-01f, 5.63018441e-01f, 1.60834461e-01f,
  5.83084047e-01f, 3.35149378e-01f, 1.11361094e-01f, 1.74892277e-01f, 4.57094252e-01f, -2.86040574e-01f, 5.67804754e-01f, -7.90968314e-02f, 1.45883754e-01f, -5.07920444e-01f,
  1.61306366e-01f, -1.80357650e-01f, 1.74371213e-01f, 1.36198312e-01f, -2.47622281e-01f, 2.53692806e-01f, 1.97704837e-01f, -3.13172400e-01f, 4.40027416e-01f, -2.74865359e-01f,
  9.74839106e-02f, -1.94963440e-01f, 8.30335543e-02f, 6.58548415e-01f, -6.88988864e-02f, -5.53221226e-01f, 2.84848928e-01f, 1.78445578e-01f, -2.45142341e-01f, 4.04156074e-02f,
  -1.52354285e-01f, 2.68791705e-01f, 4.28026207e-02f, -1.70233905e-01f, -1.17416635e-01f, 5.35043418e-01f, -1.69844419e-01f, 5.25234222e-01f, -3.32768232e-01f, 2.01837912e-01f,
  -4.44907090e-03f, -6.99307024e-02f, 1.51548356e-01f, 4.71505374e-01f, 2.12620452e-01f, 3.32575470e-01f, 9.28981006e-02f, 2.12651893e-01f, 2.96997398e-01f, 1.82230756e-01f,
  4.03813958e-01f, 4.61712986e-01f, -1.88556314e-02f, 4.93727386e-01f, 2.70618051e-01f, -2.54725963e-01f, 2.35257298e-01f, -1.64265171e-01f, -7.07093393e-03f, 2.88774133e-01f,
  5.56589663e-02f, 2.65277088e-01f, -1.41133964e-01f, -6.00514114e-02f, 1.15229130e-01f, -4.14715767e-01f, 1.35303289e-01f, -9.86999795e-02f, -5.05418442e-02f, -2.55833149e-01f,
  -4.61602986e-01f, -6.83460295e-01f, -4.37942207e-01f, 3.30115438e-01f, -5.00140131e-01f, 5.39460957e-01f, -7.41165340e-01f, -5.28417587e-01f, 5.25191605e-01f, 2.05081664e-02f,
  5.37019432e-01f, 1.02089085e-01f, 2.15082038e-02f, -4.07433897e-01f, -6.78889304e-02f, -5.80062628e-01f, -8.76036845e-03f, 1.21927056e-02f, 5.38411498e-01f, 2.84835845e-01f,
  2.69797444e-01f, 4.57207084e-01f, 1.82498276e-01f, 2.54142642e-01f, 7.10511327e-01f, 5.23687005e-01f, 3.81672323e-01f, 3.56005073e-01f, -2.10901126e-01f, 3.14617872e-01f,
  -6.25678673e-02f, -6.95257485e-02f, 1.79701611e-01f, -1.32437065e-01f, 1.96408823e-01f, -2.42788792e-01f, -6.65715709e-02f, -7.42280483e-02f, 4.93777357e-03f, 1.29780481e-02f,
  -1.78027600e-01f, -3.61709625e-01f, 4.20952469e-01f, 8.06124806e-02f, 5.94528079e-01f, 1.56952888e-01f, 4.45751734e-02f, 2.90341318e-01f, 2.73766071e-01f, -2.56900657e-02f,
  6.30995035e-01f, -3.57353270e-01f, -2.49463141e-01f, -2.61963189e-01f, 7.97576644e-03f, 4.79375690e-01f, 7.57551268e-02f, -1.74575537e-01f, 4.51168448e-01f, -3.28948051e-01f,
  2.87769169e-01f, -1.91976905e-01f, 1.63186207e-01f, -3.38272572e-01f, 3.85629237e-01f, -5.21278203e-01f, -6.55883670e-01f, 2.96071947e-01f, 2.30379835e-01f, -1.20934166e-01f,
  -1.11318521e-01f, -4.82017785e-01f, 3.50516856e-01f, 3.97535473e-01f, 5.06157875e-02f, -2.04001039e-01f, -1.82863697e-01f, -3.78884196e-01f, 5.60919583e-01f, -6.76667690e-02f,
  5.01096621e-02f, 3.73373479e-01f, -1.72845185e-01f, 3.74106437e-01f, -1.31575599e-01f, 1.26997486e-01f, 2.71937937e-01f, 2.65982985e-01f, 8.89487788e-02f, 1.59806341e-01f,
  2.43573546e-01f, -6.64130151e-02f, 1.98049322e-01f, -2.86384314e-01f, 4.34935212e-01f, -3.93229544e-01f, -2.05641776e-01f, -5.86897492e-01f, 2.26605222e-01f, -1.52266353e-01f,
  -4.49476749e-01f, 9.02430639e-02f, -3.36438656e-01f, -9.33497101e-02f, 1.84971228e-01f, 1.94047168e-01f, 7.48158336e-01f, -5.30347154e-02f, 2.64432758e-01f, 1.32544953e-02f,
  -3.98476720e-01f, -4.24352765e-01f, 4.56004262e-01f, 4.96511340e-01f, -2.07019448e-01f, -3.14265370e-01f, 5.71952283e-01f, -2.13395521e-01f, -2.24480912e-01f, 1.16930373e-01f,
  -1.15217835e-01f, 6.03980199e-02f, 1.66431546e-01f, 4.92520779e-01f, 6.25710860e-02f, 1.53904587e-01f, 1.78225905e-01f, 3.97514142e-02f, 1.02358304e-01f, -2.70373940e-01f,
  -5.87927461e-01f, 3.78316194e-01f, 3.81672740e-01f, -2.08731607e-01f, 5.77317119e-01f, 1.93908215e-01f, -1.36386439e-01f, 1.84875429e-01f, -1.27092287e-01f, 2.60347039e-01f,
  1.17154531e-02f, 2.24807993e-01f, 5.90817034e-01f, 3.29771787e-01f, -3.60680133e-01f, 3.25393319e-01f, 4.62031901e-01f, -4.45621729e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  2.25038826e-02f, 2.28349656e-01f, 2.40913272e-01f, 1.70167714e-01f, 1.04676023e-01f, 3.66082937e-01f, 1.08859204e-01f, 1.21547006e-01f, 1.48103341e-01f, 1.10897593e-01f,
  5.45775518e-02f, 1.86559781e-01f, 1.26039445e-01f, 2.52321780e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -2.36677840e-01f, -4.90532279e-01f, 2.18389388e-02f, -3.33829373e-01f, 2.81269103e-01f, 1.92200392e-03f, -1.33365974e-01f, 1.09004611e-02f, -5.67893162e-02f, -2.17999578e-01f,
  -3.67169119e-02f, 3.51804763e-01f, 2.77298152e-01f, 3.36148053e-01f, -1.31517187e-01f, -2.38927126e-01f, 1.58602104e-01f, 2.45511711e-01f, 4.36647356e-01f, -5.95889688e-01f,
  -1.96880221e-01f, -6.91567481e-01f, -5.83540857e-01f, -2.39565223e-01f, -3.69085968e-01f, 1.58397377e-01f, 1.86855108e-01f, -1.70106634e-01f, 1.79874241e-01f, -4.17773902e-01f,
  1.25924423e-01f, -6.41035140e-01f, -4.49514538e-01f, 1.54617831e-01f, -5.23256063e-01f, 1.62256643e-01f, -1.79081768e-01f, 1.20544605e-01f, 4.13785614e-02f, 4.46360186e-02f,
  -3.35571945e-01f, -2.00327143e-01f, 2.35182837e-01f, 8.00535642e-03f, 3.85712594e-01f, -2.36775056e-01f, 5.02640866e-02f, 5.05231023e-01f, 4.83123362e-01f, -4.70319122e-01f,
  -2.51919078e-03f, -8.30437303e-01f, -1.35360584e-01f, -1.14733674e-01f, -9.34987664e-01f, 6.75570741e-02f, -1.46198824e-01f, 2.94804573e-01f, -2.40711331e-01f, 6.35737360e-01f,
  -2.22042799e-01f, 2.80536801e-01f, 4.82324898e-01f, -3.82630914e-01f, 1.93798140e-01f, -5.87856948e-01f, -1.11810654e-01f, -1.39090577e-02f, 2.29919299e-01f, -5.53977489e-01f,
  -3.73028338e-01f, -5.41101545e-02f, -2.73024924e-02f, 1.31154716e-01f, 6.78939670e-02f, -5.32445669e-01f, 2.06548676e-01f, -1.14022650e-01f, 1.61951466e-03f, -1.51769236e-01f,
  5.50144911e-01f, -6.32894784e-02f, -1.35045826e-01f, 3.31698239e-01f, -6.25790834e-01f, 1.46503419e-01f, -8.71723473e-01f, -4.11671668e-01f, 2.78904468e-01f, -4.60315049e-01f,
  6.62975088e-02f, 4.07295197e-01f, -4.07529809e-02f, -3.68076801e-01f, 2.81127781e-01f, -6.05231673e-02f, -3.08631301e-01f, -1.09602459e-01f, -2.10070491e-01f, -3.68205100e-01f,
  -2.63072282e-01f, -4.59870011e-01f, 2.13398531e-01f, 7.72140741e-01f, -1.23979539e-01f, -1.75158963e-01f, -1.68588772e-01f, -9.16915247e-04f, 2.32432574e-01f, 2.24473868e-02f,
  1.48997948e-01f, 6.08087063e-01f, 1.48975670e-01f, -4.34928268e-01f, 1.13017917e-01f, 3.60065579e-01f, -5.48165679e-01f, -4.74041224e-01f, 6.33497387e-02f, -2.04736784e-01f,
  -9.96317923e-01f, -5.42969584e-01f, 1.13592297e-01f, -3.93264651e-01f, 2.28451237e-01f, -4.19563413e-01f, -5.35144210e-01f, 4.00138825e-01f, 1.40817985e-01f, 8.99238646e-01f,
  -1.85697317e-01f, 4.83316809e-01f, -4.22315598e-01f, 5.99996686e-01f, 2.65544653e-02f, -3.00280392e-01f, -2.96427757e-01f, 5.67034364e-01f, -3.06808874e-02f, 6.00759029e-01f,
  -6.58612251e-01f, 1.88864261e-01f, 4.87445444e-02f, -7.59615796e-03f, -1.26196921e-01f, 1.23482225e-02f, 2.13090017e-01f, -1.29628271e-01f, -3.45846206e-01f, 1.99317038e-01f,
  -2.98860878e-01f, -3.36339861e-01f, 1.84897706e-01f, 1.66248716e-02f, 2.60272980e-01f, -3.76639366e-01f, 6.56052902e-02f, 3.54155302e-02f, -3.94299418e-01f, 2.51824819e-02f,
  4.34890360e-01f, 2.49732599e-01f, 3.69382441e-01f, -2.85950512e-01f, 1.24034993e-02f, 9.99271274e-02f, 3.35478723e-01f, 1.56847596e-01f, 6.47028744e-01f, 6.35424137e-01f,
  5.30025125e-01f, -2.45963037e-01f, -2.81735603e-02f, -4.92165089e-01f, 2.59962201e-01f, 2.39640027e-01f, -4.63354737e-01f, -1.17557712e-01f, -2.34331023e-02f, -8.37048709e-01f,
  6.56045601e-02f, 2.31259063e-01f, 2.79716194e-01f, -2.32297316e-01f, -2.72451490e-01f, 4.97376472e-01f, -3.04452270e-01f, -5.11959732e-01f, 1.58626840e-01f, -2.89793670e-01f,
  1.99307904e-01f, -4.49266396e-02f, -7.12657347e-02f, -4.73556906e-01f, 3.67276222e-01f, -5.12421727e-02f, -3.81694645e-01f, -1.67228188e-02f, 2.16793448e-01f, 2.74168432e-01f,
  4.30237949e-01f, 1.18009397e-03f, -2.21483976e-01f, -1.00399368e-01f, -1.34268552e-01f, -1.31145194e-01f, -4.56496686e-01f, -7.77128279e-01f, -2.08148524e-01f, -2.59648860e-01f,
  -7.06738710e-01f, 2.96275228e-01f, 2.16919214e-01f, -3.01592886e-01f, -7.40048051e-01f, 4.81334746e-01f, 7.54048973e-02f, -1.64339736e-01f, -1.78191856e-01f, 2.68407017e-01f,
  -6.93607092e-01f, -1.45316839e-01f, 1.81361645e-01f, -6.48149073e-01f, -4.09678310e-01f, -2.65687078e-01f, -3.02523971e-01f, 3.75272572e-01f, 1.65500239e-01f, -1.45237148e-01f,
  -2.24564075e-01f, -1.65759340e-01f, 1.62844628e-01f, -3.78731698e-01f, -5.83061501e-02f, -2.27294937e-02f, -9.90846455e-02f, 5.84670782e-01f, 3.31966996e-01f, 1.19474806e-01f,
  -4.84997243e-01f, 4.11156595e-01f, -6.96771681e-01f, 1.14320345e-01f, 2.41310194e-01f, 5.93084879e-02f, 4.55554873e-01f, -8.68190289e-01f, 2.40111336e-01f, -1.68355241e-01f,
  1.98334098e-01f, -3.51633817e-01f, -8.33339036e-01f, -1.91871211e-01f, -1.66761652e-01f, 1.03332087e-01f, 9.90985483e-02f, -2.51594633e-01f, -3.61882418e-01f, -3.21101576e-01f,
  -1.94221556e-01f, 6.69394806e-02f, 2.87922531e-01f, -3.73767048e-01f, -1.40316799e-01f, -3.76841486e-01f, -7.41005838e-01f, -1.25891984e-01f, 3.03352505e-01f, 1.72914535e-01f,
  -2.88681220e-02f, -1.32505670e-01f, -2.36567840e-01f, 6.24711573e-01f, -2.80943662e-01f, -6.40928805e-01f, 1.53695703e-01f, 7.79359601e-03f, -2.31899545e-01f, 3.78073245e-01f,
  -3.10728669e-01f, 2.68571794e-01f, -5.93175828e-01f, -4.32782203e-01f, -1.01090908e+00f, 4.42787707e-01f, -1.39144346e-01f, 5.61401129e-01f, 1.46932468e-01f, -2.61487633e-01f,
  1.82892501e-01f, -3.87111902e-01f, 3.26312035e-01f, 2.23894820e-01f, 1.11875959e-01f, -7.42033049e-02f, 1.81212232e-01f, 4.21174824e-01f, 7.94506893e-02f, 3.39224130e-01f,
  -4.30904955e-01f, -1.94019884e-01f, 7.72519052e-01f, 4.97500449e-01f, 6.56211853e-01f, -3.02984238e-01f, 1.76035941e-01f, 9.62002110e-03f, 4.32737231e-01f, 5.68567477e-02f,
  -3.18194598e-01f, 2.18602836e-01f, 4.86143351e-01f, -5.25776923e-01f, -3.05924892e-01f, -3.95506084e-01f, -8.71447772e-02f, -4.70740885e-01f, -3.05979997e-01f, -6.53898358e-01f,
  -2.45199591e-01f, -5.42168226e-03f, 3.47614676e-01f, -1.26982376e-01f, 4.59139407e-01f, -4.89834398e-01f, -8.15217942e-02f, -1.52006298e-01f, 6.07879348e-02f, -4.28775877e-01f,
  -5.29319704e-01f, -4.15834300e-02f, 1.22024767e-01f, -4.72808570e-01f, -2.06533968e-01f, -7.99904764e-01f, -1.55202644e-02f, 3.20284486e-01f, -7.49410391e-01f, 2.20010176e-01f,
  -6.52181923e-01f, 3.28795016e-01f, 5.91490090e-01f, -3.73553902e-01f, -4.59602892e-01f, 1.06937557e-01f, -3.86304677e-01f, 5.42211346e-02f, 2.05108002e-01f, -1.90673888e-01f,
  -4.11216021e-01f, 8.51836652e-02f, 2.62226820e-01f, 2.27878824e-01f, 9.35098231e-02f, 3.17620672e-02f, -1.66636586e-01f, 2.47312188e-01f, -5.62406898e-01f, 1.96377728e-02f,
  -1.60207197e-01f, 2.78965414e-01f, 3.46165329e-01f, -1.04928128e-01f, -7.85221010e-02f, -2.36518130e-01f, 1.14198133e-01f, -2.77212054e-01f, -2.26160392e-01f, 5.69123089e-01f,
  -1.04276553e-01f, 3.59743208e-01f, 7.89135396e-02f, -1.31452858e-01f, 5.27435839e-01f, 2.41313338e-01f, -3.92005771e-01f, -3.64866972e-01f, -7.37015367e-01f, 1.51452288e-01f,
  -5.31104565e-01f, 4.37879473e-01f, -5.93290806e-01f, -3.08952481e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  2.41762456e-02f, -1.63632527e-01f, -7.11623952e-02f, -1.21040091e-01f, -5.79102263e-02f, 3.46125290e-02f, 9.15938430e-03f, -1.27672330e-01f, -1.35582909e-01f, 1.13829665e-01f,
  1.13136321e-01f, 4.95391153e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    