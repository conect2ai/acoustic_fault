/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.23582445e-01f, 1.34994954e-01f, -2.57316202e-01f, 7.61716440e-02f, -1.67301401e-01f, -1.65900990e-01f, 1.49880806e-02f, -3.19844559e-02f, -2.05334231e-01f, 7.82779604e-02f,
  3.14748771e-02f, -4.61740755e-02f, 7.15056360e-02f, 2.48078436e-01f, 1.58170551e-01f, -8.02357122e-02f, 1.26883566e-01f, -5.57490885e-02f, -1.19820803e-01f, -4.13051546e-02f,
  -4.20620926e-02f, 2.62396842e-01f, 9.67545584e-02f, -6.08867630e-02f, 6.41403720e-02f, -3.00007295e-02f, 2.61747271e-01f, -7.22149794e-04f, 1.38303727e-01f, 6.35803193e-02f,
  1.10945432e-03f, 3.70635465e-03f, 6.46002889e-02f, 3.54381441e-03f, 1.06710255e-01f, 7.76518956e-02f, -2.64901407e-02f, 1.03779523e-04f, -5.78123843e-03f, -8.72752741e-02f,
  1.16169252e-01f, -4.10286225e-02f, 3.15229408e-02f, -2.77729034e-02f, -9.24763456e-02f, -7.49758855e-02f, -7.74166286e-02f, -2.74488311e-02f, -1.11263404e-02f, -1.82304069e-01f,
  -1.53023437e-01f, -7.85491392e-02f, 2.38393694e-02f, -2.84104198e-02f, 7.73335099e-02f, -9.90467370e-02f, -9.44985151e-02f, -2.88920216e-02f, -9.06880051e-02f, -4.77263965e-02f,
  2.36183498e-02f, 1.18801787e-01f, -1.22898966e-01f, -1.49717435e-01f, -1.04882352e-01f, -2.75186114e-02f, -9.72363576e-02f, 3.75416242e-02f, -5.07163703e-02f, 6.41854072e-04f,
  2.83226054e-02f, 5.65821715e-02f, -1.82936992e-02f, -1.24526680e-01f, -2.44697519e-02f, 6.80805556e-03f, -6.03353828e-02f, -3.04901674e-02f, 7.77033269e-02f, 1.02394067e-01f,
  2.85398401e-02f, -1.07288457e-01f, 9.30593610e-02f, -5.31603992e-02f, -7.65829831e-02f, -4.97417487e-02f, -4.54495922e-02f, -1.30386636e-01f, 1.26072958e-01f, 1.53163344e-01f,
  9.14985538e-02f, 1.66506946e-01f, 1.11617714e-01f, -3.18206549e-02f, -1.68052092e-02f, 1.45787641e-01f, -3.45499627e-03f, -4.88849692e-02f, 1.19301461e-01f, -2.02385969e-02f,
  1.38582587e-01f, -4.32584472e-02f, -1.18358023e-02f, -1.68326194e-03f, 2.17331126e-02f, 6.95492700e-03f, 3.51554155e-02f, 1.34593472e-01f, 2.17467427e-01f, 7.57834464e-02f,
  8.72620195e-02f, -4.61308248e-02f, -4.94728535e-02f, -2.30711065e-02f, 2.16778426e-04f, 4.70400155e-02f, -1.03618279e-01f, -3.99384797e-02f, -2.32275538e-02f, 2.27337498e-02f,
  -4.33012754e-01f, 3.73756178e-02f, -1.25726476e-01f, -1.66347325e-01f, 3.42100002e-02f, 1.24131106e-01f, 4.27163802e-02f, 1.30131423e-01f, 2.87627988e-03f, 2.71410376e-01f,
  7.35073388e-02f, -1.74299866e-01f, 1.83144435e-01f, -6.60002679e-02f, -1.98013023e-01f, 2.17335239e-01f, -2.56669316e-02f, -1.87305193e-02f, -4.54337448e-02f, -1.02244079e-01f,
  -9.32589769e-02f, 2.15605870e-02f, -1.04461849e-01f, 1.05477490e-01f, -1.39204174e-01f, -1.17081158e-01f, -4.19371855e-03f, -7.37642422e-02f, -1.00929514e-01f, -2.61902250e-02f,
  -1.53416216e-01f, -8.13693255e-02f, -6.88236877e-02f, -5.40138744e-02f, -3.04141454e-02f, -4.03320491e-02f, -5.61088622e-02f, -7.45464265e-02f, -8.64812210e-02f, -5.34097804e-03f,
  5.40666096e-02f, -7.01570585e-02f, 4.78552021e-02f, -7.19373720e-03f, -1.12527423e-01f, -5.83983026e-02f, 4.54098918e-02f, 2.43512285e-03f, -4.15675677e-02f, 2.68247593e-02f,
  9.99210700e-02f, 4.61221263e-02f, 5.60972355e-02f, 2.75305361e-02f, -2.88873985e-02f, 5.67587838e-03f, -9.65832919e-02f, -7.19161984e-03f, 1.14108883e-02f, -6.23690560e-02f,
  1.35241106e-01f, -7.78945088e-02f, -4.32966091e-02f, -3.74542736e-02f, -1.55417500e-02f, 2.35871244e-02f, 3.08756698e-02f, 4.70001549e-02f, 1.12824964e-04f, -6.78447559e-02f,
  -5.69721907e-02f, -8.21242929e-02f, 7.23913759e-02f, 3.36876959e-02f, -5.16898483e-02f, 2.66823750e-02f, -1.60036255e-02f, 1.20315040e-02f, -8.26099962e-02f, 8.93115625e-02f,
  1.14417613e-01f, -7.32494667e-02f, -9.59215760e-02f, 7.42958784e-02f, 3.10677048e-02f, -8.27217102e-03f, 5.07869497e-02f, 2.71979962e-02f, 1.40706003e-01f, -1.64847765e-02f,
  -3.92953046e-02f, 6.45741299e-02f, -3.60333957e-02f, -1.02537818e-01f, 2.67872643e-02f, 1.03443637e-01f, -2.32116748e-02f, -2.42781285e-02f, -2.50032730e-02f, 4.51859981e-02f,
  1.06477030e-01f, -3.09088212e-02f, 4.74349260e-02f, 1.03963250e-02f, -6.49179742e-02f, 7.13986829e-02f, 9.79738832e-02f, -2.61808410e-02f, 4.34989594e-02f, 1.01408303e-01f,
  1.83191106e-01f, 3.92885841e-02f, 7.44418800e-02f, 2.19880305e-02f, 2.59167980e-02f, 2.21224073e-02f, -1.30674979e-02f, -5.67632578e-02f, 8.59014839e-02f, -6.86140507e-02f,
  4.84036803e-01f, -9.64201689e-02f, 1.30793959e-01f, 2.48340905e-01f, -2.01649398e-01f, 1.59207389e-01f, 2.72173941e-01f, -1.47555247e-01f, 3.40488970e-01f, -8.31826255e-02f,
  -1.04660049e-01f, 1.30402327e-01f, -3.39941382e-02f, 1.13208182e-01f, 1.36899084e-01f, 1.03877649e-01f, 1.30679443e-01f, 6.28189296e-02f, 2.83155199e-02f, -5.39974011e-02f,
  -1.04024941e-02f, -2.05050990e-01f, -7.19243065e-02f, -3.33551437e-01f, 1.05412811e-01f, 7.95903727e-02f, -2.23168269e-01f, -7.27155432e-02f, -4.09209579e-02f, -7.64889047e-02f,
  8.37943796e-03f, -8.92040208e-02f, 4.80996817e-03f, 1.25766331e-02f, -4.08169590e-02f, -2.75090840e-02f, 9.03173089e-02f, 5.77743761e-02f, 4.23231721e-02f, 1.67293623e-02f,
  7.77040944e-02f, 8.96661449e-03f, -3.58385555e-02f, 1.66784432e-02f, 6.19026795e-02f, 2.39309538e-02f, 5.70896268e-02f, 9.37222689e-02f, -3.01981010e-02f, -3.18297260e-02f,
  5.67936786e-02f, -1.63213257e-02f, 4.05960865e-02f, -3.05838906e-03f, 1.52983531e-01f, 1.13992587e-01f, 3.08183823e-02f, -6.60144091e-02f, 5.70630692e-02f, 1.76171977e-02f,
  -2.43948828e-02f, 5.27416691e-02f, 1.03687951e-02f, -8.24958757e-02f, -2.62570232e-02f, -1.80485416e-02f, 1.19767003e-02f, -2.26195976e-02f, 9.61479694e-02f, -4.36179750e-02f,
  3.91131900e-02f, -8.19669198e-03f, 2.41050925e-02f, 5.34464121e-02f, 1.84455849e-02f, 3.39898914e-02f, 2.83066351e-02f, -4.10019606e-03f, 3.97851840e-02f, 2.35830750e-02f,
  -7.09392056e-02f, 5.74128628e-02f, -1.01795816e-03f, -7.45330751e-02f, -1.32312343e-01f, 2.48470791e-02f, 5.22589646e-02f, -1.48505215e-02f, 2.62518395e-02f, -1.19750283e-03f,
  -6.82760924e-02f, -1.10300437e-01f, -7.65686184e-02f, -3.99759710e-02f, 9.93626099e-03f, -2.62392941e-03f, 1.12004494e-02f, 7.12119117e-02f, 2.10301057e-02f, 1.11082429e-02f,
  -5.61037622e-02f, 3.27365808e-02f, -2.45430637e-02f, -2.78179832e-02f, -4.26954925e-02f, 2.89166905e-02f, 6.08652271e-02f, 1.47571927e-02f, -8.69577378e-03f, -7.96947032e-02f,
  2.55408064e-02f, 4.33900803e-02f, 7.04362020e-02f, 6.02507442e-02f, 7.68090263e-02f, 5.79932006e-03f, 5.60308397e-02f, -1.35019217e-02f, 8.20197538e-03f, -4.26470116e-02f,
  2.71374404e-01f, 1.64453492e-01f, 1.19555511e-01f, -8.18728507e-02f, -6.98227957e-02f, 2.37611085e-01f, -2.71935295e-02f, 1.75312564e-01f, -3.37287039e-02f, -1.69137686e-01f,
  -1.53952256e-01f, -6.53955638e-02f, -1.83747128e-01f, 1.20358840e-01f, 2.52317607e-01f, -1.33284122e-01f, 2.29467332e-01f, 1.72934551e-02f, -1.06342152e-01f, 1.61059126e-01f,
  8.88414159e-02f, -2.62882896e-02f, 5.43302931e-02f, -8.69127340e-04f, 9.83093828e-02f, 1.48590699e-01f, -2.61272997e-01f, -6.46526441e-02f, 1.91376418e-01f, -6.21560030e-02f,
  1.29526883e-01f, -3.11384145e-02f, 8.90119150e-02f, 7.86667988e-02f, 1.76067889e-01f, 1.00703597e-01f, 1.47100285e-01f, -5.31303398e-02f, -2.45452747e-02f, 6.24513552e-02f,
  -6.91410527e-02f, -9.96066928e-02f, 9.81921926e-02f, -8.00089687e-02f, -5.28937019e-02f, -2.43944637e-02f, 3.05527002e-02f, 8.59250426e-02f, -1.77977830e-02f, -9.76642221e-02f,
  9.27994400e-02f, 2.72162445e-02f, 2.21962035e-02f, -1.31649926e-01f, 1.63354352e-03f, -1.04432136e-01f, -5.43635990e-03f, -8.88910294e-02f, -8.71864930e-02f, 4.85248826e-02f,
  8.66717193e-03f, 3.59955728e-02f, 4.60887253e-02f, -1.90636795e-02f, 2.18195394e-02f, -2.75917305e-03f, 6.85192943e-02f, -4.34117019e-02f, 4.11543287e-02f, -1.39772464e-02f,
  -2.18984038e-02f, -1.00868745e-02f, 6.41397908e-02f, 4.20171656e-02f, 3.91359255e-02f, 1.50585892e-02f, -1.67612627e-01f, -1.27274208e-02f, 1.66090369e-01f, 6.60499483e-02f,
  -1.45105854e-01f, -1.80268735e-02f, -4.12592329e-02f, -1.82795525e-02f, 5.28229922e-02f, -3.17038260e-02f, -6.78688213e-02f, -5.75095676e-02f, -5.06579615e-02f, -1.21861741e-01f,
  4.59675714e-02f, 4.58362438e-02f, -6.09667674e-02f, -2.27989908e-02f, -2.49531888e-03f, 1.12518698e-01f, 1.15338482e-01f, 3.19503397e-02f, 1.07347250e-01f, 9.81475115e-02f,
  5.22604808e-02f, -4.55554128e-02f, 1.21028893e-01f, -3.23826075e-02f, -3.72305997e-02f, 2.46146377e-02f, -5.26986532e-02f, 3.81887071e-02f, 4.73661255e-03f, -1.57757521e-01f,
  -1.43852606e-01f, -4.81154583e-02f, -4.50330116e-02f, 1.93493180e-02f, -7.30906799e-02f, -1.18852090e-02f, 4.02580090e-02f, -5.75607754e-02f, -9.19113904e-02f, -8.80988911e-02f,
  1.87041059e-01f, 1.98021345e-02f, 1.88379303e-01f, 8.22372660e-02f, 1.70690417e-01f, 1.41786367e-01f, 1.97503157e-02f, 1.48264140e-01f, 5.62913008e-02f, 7.27988034e-03f,
  1.15160100e-01f, 1.60605654e-01f, -5.87198660e-02f, 1.04008555e-01f, -2.20610127e-02f, -9.64623541e-02f, 6.87246323e-02f, 6.20144308e-02f, -9.97934788e-02f, -1.62365641e-02f,
  2.80198492e-02f, -3.91433723e-02f, 8.68602172e-02f, -7.79658780e-02f, 7.53942728e-02f, 6.82246462e-02f, -6.25552312e-02f, -4.84469421e-02f, 1.79684475e-01f, 2.66085286e-02f,
  -1.72367524e-02f, -2.91183498e-02f, -2.18491983e-02f, -2.86835805e-02f, 3.87264392e-03f, -9.04333312e-03f, -4.58121113e-03f, 5.62555864e-02f, -6.98257834e-02f, 9.75891501e-02f,
  -3.62855755e-02f, 2.53589302e-02f, 1.15865164e-01f, -2.14211643e-03f, 1.39471404e-02f, 1.23950794e-01f, 1.05987430e-01f, 3.23932506e-02f, 8.42722580e-02f, 8.89496729e-02f,
  6.49573281e-02f, 5.06522171e-02f, 8.35672989e-02f, 4.24073450e-02f, -9.73588973e-03f, 3.95867117e-02f, 3.79672609e-02f, 1.38238400e-01f, 1.08427010e-01f, 8.47388878e-02f,
  -9.14729834e-02f, -2.12220717e-02f, 1.08262435e-01f, 6.88165054e-02f, -4.66323458e-03f, 4.54499722e-02f, 3.24263163e-02f, 1.76064186e-02f, -5.41725866e-02f, 1.14284411e-01f,
  -2.07225140e-02f, 6.04939722e-02f, -1.73174553e-02f, 3.41875814e-02f, 6.72773570e-02f, -1.34210726e-02f, -3.54198436e-03f, 1.34258978e-02f, 2.39108745e-02f, -6.91018140e-05f,
  -3.40459533e-02f, 4.00576629e-02f, 3.62123810e-02f, 3.86911221e-02f, -1.20737813e-02f, -4.76730242e-02f, -1.04390010e-01f, 3.58874016e-02f, -4.10889499e-02f, -6.59866259e-02f,
  -1.92221865e-01f, -2.08706349e-01f, -4.20523956e-02f, 5.42401522e-02f, -3.80380414e-02f, -3.36541310e-02f, -3.08958720e-02f, -1.72080181e-03f, -1.72920883e-01f, -2.94613447e-02f,
  -7.46595562e-02f, 7.41765276e-02f, -8.21080524e-03f, 3.25966324e-03f, -6.92476928e-02f, -7.15592876e-02f, 1.71804719e-03f, -1.10755973e-01f, -5.50037995e-02f, -2.21958365e-02f,
  -1.44786444e-02f, 3.31139751e-03f, 3.96759398e-02f, -3.29557844e-02f, 3.29723372e-03f, 8.88681933e-02f, 1.10057238e-02f, 1.19738085e-02f, 8.69151391e-03f, 3.71623449e-02f,
  -1.09135155e-02f, -3.52752745e-01f, -1.10373594e-01f, -1.14018261e-01f, 2.66535670e-01f, 1.94776639e-01f, 9.81675610e-02f, 7.16481954e-02f, -7.04948306e-02f, -8.24252591e-02f,
  2.52353221e-01f, -1.26626566e-01f, -4.42575738e-02f, -8.56671017e-03f, 2.00330257e-01f, -8.64810869e-02f, 7.32421130e-02f, -4.76746820e-02f, -1.33162379e-01f, -1.22428149e-01f,
  -2.56972783e-03f, 1.05722860e-01f, 4.26371135e-02f, 2.46516839e-02f, -5.83877647e-03f, -8.73436183e-02f, 2.15695649e-01f, 4.12093615e-03f, 6.94335848e-02f, 1.33021474e-01f,
  2.87401602e-02f, -9.35192592e-03f, 5.67239113e-02f, -9.80087090e-03f, 1.23387016e-01f, 4.37703840e-02f, -5.77755971e-03f, 4.85559627e-02f, 6.12040386e-02f, 2.47583836e-02f,
  2.59206165e-02f, -3.62168923e-02f, 8.82002860e-02f, -4.30492200e-02f, -1.21710170e-02f, 2.34470349e-02f, -8.27233344e-02f, 3.90118137e-02f, 5.31222373e-02f, -6.73119947e-02f,
  5.33943623e-02f, -9.08338055e-02f, 7.54623935e-02f, -5.83693339e-03f, 4.70752977e-02f, 1.22183934e-02f, -4.28864695e-02f, 4.25023772e-02f, 1.46034257e-02f, 2.58542728e-02f,
  1.08904488e-01f, -8.82443041e-02f, -6.76071122e-02f, -3.88191529e-02f, -1.06629327e-01f, 1.09462544e-01f, -3.89146358e-02f, 1.03123918e-01f, 6.44744840e-03f, -9.24512278e-03f,
  -3.00763547e-02f, 1.18749784e-02f, 8.15168321e-02f, 2.41441280e-02f, 8.58257245e-03f, -1.45425826e-01f, -6.87454268e-02f, -2.64581107e-02f, 1.56789005e-01f, 6.46299869e-02f,
  -7.13304710e-03f, -5.52629828e-02f, 5.16745262e-04f, 6.67070597e-02f, 3.16843688e-02f, -5.81626520e-02f, -9.28599909e-02f, -4.44887243e-02f, -8.54061618e-02f, 2.88192406e-02f,
  5.61556853e-02f, -2.14364558e-01f, 9.98298265e-03f, -7.72829652e-02f, 5.47673739e-02f, -1.23662297e-02f, 3.98449483e-04f, 4.56988253e-03f, -4.37786244e-02f, 6.71200873e-03f,
  8.19168985e-02f, -2.35799290e-02f, 7.53335506e-02f, -9.39816702e-03f, 2.78481469e-02f, 5.85552976e-02f, -9.54773203e-02f, 1.06847510e-01f, 8.85745510e-02f, 2.62950384e-03f,
  -2.71763522e-02f, -8.60724971e-02f, 3.69251110e-02f, -6.65954798e-02f, 9.22969077e-03f, 7.47936368e-02f, -6.11970341e-03f, 4.15390395e-02f, -1.32863903e-02f, 5.02947159e-02f,
  9.02784765e-02f, -1.48836285e-01f, -1.01001948e-01f, -6.28137961e-02f, 3.47597227e-02f, 8.26621950e-02f, 3.14013660e-02f, -4.50515114e-02f, -1.95981100e-01f, -1.38768777e-01f,
  4.34385203e-02f, -1.81185722e-01f, -8.76141936e-02f, 1.09322421e-01f, 5.77682592e-02f, -1.54066071e-01f, -1.20987119e-02f, -6.10203855e-02f, -2.69116573e-02f, -4.24180701e-02f,
  -7.25719007e-03f, 1.49737254e-01f, -3.92716601e-02f, 7.84656629e-02f, 2.60707252e-02f, -1.09981559e-02f, -4.43983302e-02f, -5.72990254e-02f, -8.48030224e-02f, -8.70930403e-02f,
  1.74259752e-01f, -3.05936933e-02f, 4.13297378e-02f, 5.17708398e-02f, 1.10332400e-01f, 1.34744078e-01f, 2.58206595e-02f, -7.62502179e-02f, 8.50912482e-02f, -1.09663866e-01f,
  -8.18347838e-03f, -2.95744240e-02f, -1.02630658e-02f, -1.47854641e-01f, -4.92057577e-02f, -8.83737579e-02f, -1.79642066e-02f, 7.67993554e-02f, -2.88373902e-02f, 2.56910603e-02f,
  -9.16017294e-02f, 7.89771695e-03f, -4.55242693e-02f, -1.43821776e-01f, -1.20178163e-01f, -6.73676357e-02f, -5.90834692e-02f, -9.98177305e-02f, -1.23976961e-01f, -9.23454575e-03f,
  -3.38113010e-02f, 5.99404424e-02f, 1.97706185e-02f, 6.12660544e-03f, 5.28806932e-02f, -5.56296334e-02f, -3.35712358e-02f, 5.70946075e-02f, 3.13876383e-02f, 4.50409502e-02f,
  7.82740414e-02f, 9.79383290e-02f, 2.48308256e-02f, 7.07002506e-02f, -4.14800495e-02f, -1.61812436e-02f, -3.52318473e-02f, -1.22580692e-01f, 4.24616598e-02f, 1.87831059e-01f,
  3.28887440e-02f, -3.50829102e-02f, 1.10083930e-01f, 1.45206405e-02f, -4.67444584e-02f, 2.74042636e-02f, -1.82308972e-01f, 5.49947657e-03f, 5.05446317e-03f, -2.51465030e-02f,
  2.58969814e-02f, -1.73946545e-02f, 5.28927296e-02f, 7.37369508e-02f, 5.35003655e-02f, 1.50472045e-01f, 7.42519870e-02f, -9.39088967e-03f, 8.02600831e-02f, 3.25950198e-02f,
  5.22916727e-02f, -5.29912591e-04f, 7.62236640e-02f, -6.37250161e-03f, -5.66587746e-02f, -4.62942868e-02f, 2.09407862e-02f, 3.21161896e-02f, 1.11172102e-01f, 3.16229798e-02f,
  -8.07149857e-02f, 6.06394857e-02f, -1.32554799e-01f, -1.97801907e-02f, -9.39703062e-02f, -7.25825951e-02f, 3.91565040e-02f, 8.41833372e-03f, -1.29707262e-01f, -1.23865306e-02f,
  -1.82256564e-01f, -1.24249972e-01f, 1.80089459e-01f, -9.81143769e-03f, -3.33439931e-02f, -1.05076909e-01f, -7.42626190e-02f, -1.50815591e-01f, 6.91906214e-02f, -1.79655388e-01f,
  -9.15792212e-02f, 1.43378675e-01f, 6.93985894e-02f, -6.95577413e-02f, 4.90487181e-02f, 2.04739079e-01f, -1.50420934e-01f, -1.16778158e-01f, 1.59110919e-01f, -1.34822443e-01f,
  1.28166690e-01f, -1.68877572e-01f, 1.33595258e-01f, -3.96566242e-02f, -1.01197153e-01f, 8.87914002e-02f, -8.70107487e-02f, 2.27564871e-01f, -1.07720137e-01f, 7.73833990e-02f,
  -1.24077171e-01f, -1.61020029e-02f, 6.24218248e-02f, 5.69305867e-02f, -8.62735212e-02f, 2.29912587e-02f, 1.95340872e-01f, 7.88874775e-02f, 1.17830731e-01f, -2.65693176e-04f,
  4.81519289e-02f, -4.01776507e-02f, -2.29839273e-02f, 6.05017096e-02f, 2.33759936e-02f, 5.48104271e-02f, 5.09338602e-02f, -6.38390109e-02f, 1.16203196e-01f, 5.57484813e-02f,
  1.00357592e-01f, -1.46769434e-02f, 7.56295770e-02f, -3.12753692e-02f, 5.03432490e-02f, 7.47788697e-02f, 7.30766281e-02f, 6.25205487e-02f, -2.61525530e-02f, -3.46247718e-04f,
  6.74188137e-02f, 6.82208017e-02f, 5.47810085e-02f, -4.29867357e-02f, -3.34222605e-05f, 2.59320959e-02f, 1.49894625e-01f, 2.15731058e-02f, 1.21982537e-01f, -1.59845725e-02f,
  -5.41570224e-02f, 3.87255549e-02f, -2.75237896e-02f, 3.74708287e-02f, 2.35143006e-02f, -8.56993198e-02f, -4.16258350e-02f, -5.06446697e-02f, 2.18085274e-02f, -1.91769134e-02f,
  9.50740054e-02f, 3.31946276e-02f, -3.39739174e-02f, -7.53767509e-03f, 1.49236089e-02f, 8.59389007e-02f, 2.85076313e-02f, 3.42340432e-02f, -3.28207156e-04f, 4.52355295e-02f,
  -2.57025242e-01f, -1.67671129e-01f, -2.90292315e-02f, 7.68002421e-02f, 4.46506292e-02f, 3.47109996e-02f, 8.40524733e-02f, 4.53257114e-02f, 4.04014289e-02f, -1.18569313e-02f,
  -2.58357655e-02f, -2.70745400e-02f, 1.14940973e-02f, -7.73594901e-02f, -5.16744982e-03f, 2.00441983e-02f, 2.59369053e-02f, 1.31305326e-02f, -2.01396272e-02f, -1.36775941e-01f,
  -5.59223555e-02f, 7.20015215e-03f, 8.38461667e-02f, -6.08974025e-02f, -5.56113720e-02f, -5.85614480e-02f, 2.01985259e-02f, -1.27108898e-02f, 6.95224628e-02f, 3.99512872e-02f,
  -1.61648124e-01f, 2.32358605e-01f, 1.78187579e-01f, -4.21252139e-02f, -3.23053181e-01f, -3.16752791e-01f, -1.47951916e-01f, -1.71851307e-01f, 3.77740189e-02f, 3.33493575e-02f,
  -2.02327490e-01f, 1.16112433e-01f, 9.15475711e-02f, -8.51803180e-03f, -7.20208436e-02f, 9.32283401e-02f, -4.32038121e-02f, 1.20251020e-02f, -5.28380387e-02f, -1.80786744e-01f,
  -4.01946045e-02f, -2.00058371e-01f, -6.23379126e-02f, -8.28678682e-02f, -1.17087267e-01f, 1.82298254e-02f, -2.36008391e-02f, 5.84362587e-03f, -1.25491824e-02f, -3.34280096e-02f,
  7.47388378e-02f, 1.09426655e-01f, 1.15894169e-01f, 1.19980909e-01f, -3.47322598e-02f, 7.25703984e-02f, 1.59476429e-01f, -1.01590775e-01f, 1.90740917e-02f, -3.06707192e-02f,
  -8.31506103e-02f, -8.96642450e-03f, 1.99587811e-02f, 2.49908157e-02f, -6.41042441e-02f, 8.87151137e-02f, -9.35765356e-02f, 1.52519168e-02f, 4.25188988e-02f, -8.50303750e-03f,
  1.62097603e-01f, -9.19868238e-03f, 1.52459778e-02f, -2.68662274e-02f, -1.41843736e-01f, -5.40542938e-02f, -2.99585285e-03f, 2.36780290e-02f, 3.22550088e-02f, -1.79865360e-02f,
  -1.07998021e-01f, 8.28178823e-02f, -2.53636688e-02f, 7.69378170e-02f, -4.69489349e-03f, 6.98892260e-03f, 5.99941099e-03f, -1.06049582e-01f, -5.18661886e-02f, -8.45445991e-02f,
  -2.24197228e-02f, -7.75413364e-02f, 1.04395999e-02f, -2.09981538e-02f, -1.17375910e-01f, -3.98621820e-02f, -3.29147018e-02f, 1.89555511e-02f, 1.72798391e-02f, -7.73877800e-02f,
  7.18392730e-02f, -8.30120817e-02f, 4.13116850e-02f, -2.96216831e-02f, 3.91574614e-02f, -7.00358525e-02f, 5.99650778e-02f, 9.17230248e-02f, -5.66097349e-02f, 2.67022848e-02f,
  -2.77743815e-03f, 4.76468503e-02f, 7.62945637e-02f, 3.82689759e-02f, 1.99251026e-01f, -1.68903898e-02f, 6.79795146e-02f, -1.06680706e-01f, 8.93174484e-02f, -8.74808338e-03f,
  -2.93257050e-02f, 8.10748339e-02f, 6.90900311e-02f, 7.61419609e-02f, -1.21015008e-03f, 1.05462382e-02f, -4.88963388e-02f, 9.96845588e-02f, -7.33258575e-02f, -8.19213539e-02f,
  -1.06867962e-01f, -8.97910893e-02f, 8.04438516e-02f, -2.68355217e-02f, -1.39649749e-01f, -1.53586268e-01f, -6.69124275e-02f, -7.57538453e-02f, -2.68680565e-02f, -4.88887541e-03f,
  -2.19465226e-01f, -1.40180647e-01f, -2.90029615e-01f, -5.42540802e-03f, -4.01534624e-02f, -2.46949971e-01f, -1.08822197e-01f, -1.03489690e-01f, -2.39104003e-01f, 2.33769387e-01f,
  2.71429777e-01f, -2.38736540e-01f, 5.53539302e-03f, 1.01762876e-01f, -2.04769850e-01f, -2.06212457e-02f, -1.38829506e-04f, 7.64465258e-02f, -6.57608360e-03f, 1.01204053e-01f,
  2.24790368e-02f, 3.14032525e-01f, 2.73142066e-02f, 1.46354720e-01f, 2.92497408e-02f, -6.40010759e-02f, 2.33071327e-01f, 4.01317738e-02f, 7.20763281e-02f, -8.23552310e-02f,
  6.00949377e-02f, 5.39671909e-03f, -8.08525980e-02f, -1.06532976e-01f, 3.43433605e-03f, -3.29787727e-03f, 1.52822714e-02f, -7.04938732e-03f, -7.71626979e-02f, 9.99065209e-03f,
  1.32773891e-02f, 1.07604280e-01f, -6.46076351e-02f, -1.53661123e-03f, -4.90035526e-02f, -3.79581749e-02f, 4.21394333e-02f, 1.54939927e-02f, -8.23242664e-02f, -1.64225418e-02f,
  -6.39151111e-02f, -7.88033381e-02f, 1.82559099e-02f, 2.90061422e-02f, 1.81284565e-02f, -3.87514606e-02f, -5.99951707e-02f, -1.04521126e-01f, 2.12952551e-02f, -5.79520464e-02f,
  3.54282558e-02f, 5.75843900e-02f, 9.42447484e-02f, -2.73239668e-02f, 2.67134774e-02f, 5.68931662e-02f, -8.58782418e-03f, -1.12409936e-02f, -6.10560067e-02f, 7.25919753e-02f,
  -1.07517149e-02f, -5.59816509e-03f, -1.17985541e-02f, 1.43347029e-02f, 2.86343452e-02f, 3.18516418e-02f, 7.09965229e-02f, -3.19759250e-02f, -7.05565289e-02f, -3.34095061e-02f,
  3.80802341e-02f, -1.09501500e-02f, -4.83001731e-02f, 7.29659479e-03f, 2.19480637e-02f, 6.21452183e-02f, 6.24848306e-02f, -7.72586139e-03f, 1.07636258e-01f, 7.30219930e-02f,
  2.29369458e-02f, 3.88736092e-02f, -2.39919573e-02f, -6.16353713e-02f, -2.90380958e-02f, 2.21651029e-02f, -4.00974788e-02f, 2.92938929e-02f, 2.49446351e-02f, -5.01502901e-02f,
  -5.27825691e-02f, -3.22285704e-02f, -3.08688954e-02f, 5.03343195e-02f, -2.47090161e-02f, 6.93258420e-02f, 1.15708202e-01f, 4.56663705e-02f, 2.35232934e-02f, 3.89994234e-02f,
  7.51374289e-02f, 9.38220415e-03f, -8.06220900e-03f, 8.02988634e-02f, 4.32152301e-02f, -5.77010866e-03f, -6.50723875e-02f, -3.07791606e-02f, 4.85583134e-02f, 6.80458965e-03f,
  7.26082595e-03f, -6.43867701e-02f, -8.97723734e-02f, -1.36455894e-01f, -6.80532008e-02f, 3.09687912e-01f, 6.88381642e-02f, -2.55392015e-01f, 1.11953117e-01f, 4.06703241e-02f,
  1.84945390e-01f, 2.73340672e-01f, 7.19042793e-02f, 1.96691483e-01f, 3.50149006e-01f, 1.86242655e-01f, 1.56882182e-01f, 2.46777117e-01f, -2.90719867e-02f, 2.61238329e-02f,
  3.50147784e-02f, -6.12277575e-02f, -1.53568521e-01f, -2.52718091e-01f, -2.65617251e-01f, -3.42668802e-01f, -2.06111059e-01f, -3.10493093e-02f, -8.22226480e-02f, 8.29727203e-02f,
  1.46337017e-01f, 2.98933983e-02f, -1.54283956e-01f, -1.83834247e-02f, -8.33914131e-02f, 3.98111604e-02f, 2.29872148e-02f, 1.70018226e-01f, -2.14662943e-02f, 2.21961532e-02f,
  -1.32530136e-02f, 9.57402438e-02f, -2.78839543e-02f, -4.93399613e-02f, -5.12440652e-02f, 5.95135093e-02f, -6.38767630e-02f, -1.06241040e-01f, -1.06639089e-02f, 3.76125276e-02f,
  7.95202330e-02f, 2.68684849e-02f, 6.51501045e-02f, 1.24934219e-01f, 9.25000831e-02f, 4.99090813e-02f, 6.76580297e-04f, 4.29755449e-02f, -1.15861975e-01f, -6.89573884e-02f,
  2.76334328e-03f, 2.96194013e-02f, 2.68112551e-02f, -3.20453048e-02f, 7.10511282e-02f, -5.12875579e-02f, 1.70665011e-01f, -9.94073506e-03f, -4.97637838e-02f, 1.05617501e-01f,
  -2.17503030e-02f, -5.52205406e-02f, -3.41305062e-02f, -6.28810674e-02f, 6.61973506e-02f, -1.06873877e-01f, 4.78649959e-02f, 1.17581738e-02f, -1.32110298e-01f, -1.17890313e-01f,
  -5.73154986e-02f, 3.60220969e-02f, -1.71824545e-02f, -2.36622877e-02f, 4.52560522e-02f, 6.38364181e-02f, -6.22356795e-02f, -8.77398401e-02f, -6.25502467e-02f, -1.40462339e-01f,
  9.76133421e-02f, 8.59275460e-03f, -4.31519747e-02f, 3.80973257e-02f, 2.20683729e-03f, -3.25184651e-02f, -8.65936205e-02f, 5.44679463e-02f, -1.45491753e-02f, 8.84020701e-02f,
  -5.51117435e-02f, -1.00740548e-02f, 8.15027859e-03f, -4.18016613e-02f, -2.46998128e-02f, -7.13780103e-03f, 1.58546954e-01f, -6.90300986e-02f, -1.53508529e-01f, -6.96477368e-02f,
  -3.67234983e-02f, 7.18905777e-02f, 5.38363792e-02f, -3.24376225e-02f, -5.00406548e-02f, -1.68669373e-02f, 1.00701172e-02f, -5.07142134e-02f, 9.10446327e-03f, 5.31474911e-02f,
  -3.25327724e-01f, 2.44355902e-01f, -6.04035817e-02f, -4.18983260e-03f, -9.58762839e-02f, -1.41424641e-01f, -8.69357064e-02f, 1.28575608e-01f, -2.14974452e-02f, 1.70743659e-01f,
  -1.09905535e-02f, -7.41484463e-02f, 7.80040249e-02f, -5.77431805e-02f, -3.23519915e-01f, -1.45544698e-02f, -4.63650236e-03f, 3.03675234e-02f, -4.84451912e-02f, 9.56564583e-03f,
  -1.30303100e-01f, -1.12382472e-01f, -7.55665824e-02f, 1.75958142e-01f, -2.10240725e-02f, 1.29279613e-01f, 2.08407596e-01f, 7.58546963e-03f, 2.01572683e-02f, -7.39647746e-02f,
  -1.52139068e-01f, 7.16789393e-03f, -3.49551104e-02f, -7.66334906e-02f, 3.91073637e-02f, 1.17046982e-01f, -9.51792207e-03f, -3.83322053e-02f, -6.78449720e-02f, -5.97741036e-03f,
  5.28317578e-02f, -5.59800901e-02f, 6.55745529e-03f, -6.98503926e-02f, -1.08673111e-01f, -5.61872311e-02f, 7.34851360e-02f, 1.54370796e-02f, 2.39982195e-02f, -5.03719747e-02f,
  3.04885563e-02f, 3.20510194e-02f, 7.22869262e-02f, 5.47654741e-02f, -2.16921698e-02f, -2.59651318e-02f, 6.33895919e-02f, 7.41489157e-02f, -9.59056057e-03f, -2.54743434e-02f,
  9.33920741e-02f, -8.48637894e-02f, -7.33476058e-02f, -5.22323586e-02f, -6.76388294e-02f, 4.78797182e-02f, -2.58385204e-02f, 3.81910168e-02f, -4.44325879e-02f, 1.81555245e-02f,
  6.78655412e-03f, -1.32650644e-01f, 5.64547302e-03f, -2.58655250e-02f, -7.39406236e-03f, 3.32656801e-02f, 5.27668372e-02f, 6.17118627e-02f, 1.89644508e-02f, 6.68093190e-02f,
  4.58161831e-02f, -5.06811105e-02f, -2.83177458e-02f, 1.34653136e-01f, 3.86982486e-02f, -1.51941720e-02f, -6.65528327e-02f, -2.47572977e-02f, 3.28623690e-02f, -6.02610335e-02f,
  6.41685873e-02f, 2.00691342e-01f, -1.14729842e-02f, 1.84639711e-02f, 4.96404804e-02f, 1.31484106e-01f, 4.15608808e-02f, 5.95772490e-02f, 8.02570432e-02f, 6.75177053e-02f,
  5.15391082e-02f, 6.73431680e-02f, 5.37121370e-02f, -2.27186754e-02f, -4.92682569e-02f, -1.14805382e-02f, 9.06875432e-02f, 2.81607099e-02f, 7.85215050e-02f, 4.91135865e-02f,
  1.77119687e-01f, -1.54675345e-03f, -2.93149445e-02f, -2.71366648e-02f, 4.75135818e-02f, 1.81506984e-02f, -2.49094050e-03f, 3.04597821e-02f, 1.22746252e-01f, 1.82012189e-02f,
  -2.82024115e-01f, -1.89304411e-01f, 1.23174205e-01f, -2.21160308e-01f, 7.93052241e-02f, 1.25672713e-01f, -1.05805378e-02f, -1.27255067e-01f, -2.13311777e-01f, -1.64258435e-01f,
  1.14050694e-02f, -9.88026112e-02f, 5.28089590e-02f, -6.32210225e-02f, 8.74410495e-02f, 5.67962825e-02f, -1.85653605e-02f, -1.70351952e-01f, 7.59544075e-02f, -8.12626183e-02f,
  -2.34736819e-02f, 3.23696211e-02f, 2.71078229e-01f, 1.72156133e-02f, 1.10880286e-01f, 9.88133345e-03f, -3.16843800e-02f, 2.70177364e-01f, 2.17348821e-02f, 9.80109051e-02f,
  -1.07544817e-01f, -1.76195979e-01f, 9.69846323e-02f, -3.25809419e-02f, 4.29094620e-02f, 4.33731712e-02f, 9.16108862e-02f, 8.22334364e-02f, 1.27671426e-02f, 4.10331227e-02f,
  -6.24248870e-02f, -6.08107261e-02f, 2.42035948e-02f, 6.39917469e-03f, -2.21580397e-02f, 3.72024775e-02f, 1.22463115e-01f, -1.12366870e-01f, 2.80470736e-02f, 1.08169941e-02f,
  1.65237058e-02f, 1.47174729e-03f, 8.60081539e-02f, 6.24417607e-03f, 1.15581550e-01f, 2.46139802e-02f, 4.77361046e-02f, 7.67724141e-02f, 3.89704457e-03f, -6.71051815e-02f,
  -3.55915017e-02f, 7.09240660e-02f, 1.51237190e-01f, -3.64781320e-02f, -1.14540927e-01f, 7.32230023e-02f, 4.45736051e-02f, 6.60949796e-02f, 1.22949399e-01f, -1.65997315e-02f,
  -5.66990487e-02f, -1.50436424e-02f, 1.48422569e-02f, -1.08917430e-01f, 5.41726686e-02f, -9.17593762e-02f, -7.41300210e-02f, 4.44221050e-02f, -5.28164804e-02f, -3.70974056e-02f,
  -4.99423556e-02f, 5.24623133e-03f, 1.51388887e-02f, 3.32837887e-02f, -4.15887646e-02f, 4.94610565e-03f, 2.85694506e-02f, -5.13587259e-02f, 8.30679238e-02f, 2.95842905e-02f,
  -2.79975891e-01f, -2.65158325e-01f, 5.15636802e-02f, 1.21816332e-02f, -2.14776024e-02f, 8.64205137e-02f, 5.54861268e-03f, 6.45912886e-02f, -1.30377337e-01f, 9.44137480e-03f,
  -1.66718010e-02f, 3.25987376e-02f, -3.45763266e-02f, -1.05210282e-01f, 8.34460184e-02f, -2.41857357e-02f, -1.88275555e-03f, -5.87054156e-02f, 5.00108749e-02f, -7.60825947e-02f,
  -9.49842036e-02f, -9.61955190e-02f, 1.47787914e-01f, 3.97008024e-02f, 6.59773201e-02f, -9.13859811e-03f, -9.04367194e-02f, -9.20930728e-02f, 7.54943714e-02f, -1.58641804e-02f,
  -2.21494064e-01f, -2.13085413e-01f, 1.90998256e-01f, -6.58170730e-02f, 6.56592846e-02f, 1.96862042e-01f, 1.40076011e-01f, -1.46445230e-01f, 4.34233621e-02f, -1.66417509e-01f,
  -7.76888877e-02f, -1.29194945e-01f, 5.04170842e-02f, -2.45457157e-01f, 3.45717967e-01f, 3.03002834e-01f, 3.49105187e-02f, -5.92137538e-02f, 1.72469154e-01f, -1.03156529e-01f,
  4.09753731e-04f, -1.52527317e-01f, 3.09765488e-02f, -3.83028202e-02f, -1.65304363e-01f, -1.14650607e-01f, -9.72226784e-02f, 2.56408215e-01f, -1.72737375e-01f, 6.97076470e-02f,
  -1.14458568e-01f, 5.33307844e-04f, -1.89572908e-02f, -5.71581069e-03f, -1.35306254e-01f, 4.03713807e-03f, 1.91781707e-02f, 3.98220718e-02f, 5.51387444e-02f, -1.16771273e-01f,
  -8.89499336e-02f, -9.33339968e-02f, -9.17664394e-02f, 7.49152601e-02f, 3.80018763e-02f, 6.12235675e-03f, -8.49374086e-02f, -4.66663614e-02f, -9.36131701e-02f, 1.04554318e-01f,
  4.47807312e-02f, -9.28957760e-02f, -9.86834615e-02f, -1.44846201e-01f, 1.32567645e-03f, 5.98044731e-02f, 1.33852407e-01f, -1.38305994e-02f, -4.38633338e-02f, -5.62934801e-02f,
  3.37890796e-02f, 9.84353870e-02f, -9.52057540e-03f, -5.38640879e-02f, -3.60153578e-02f, -7.20547065e-02f, 9.79608595e-02f, -1.16355896e-01f, -2.86646895e-02f, -8.02803412e-02f,
  -3.33271734e-02f, -7.42423460e-02f, -3.98073718e-02f, -1.03433970e-02f, 1.24371080e-02f, -2.69477554e-02f, -8.28009918e-02f, -7.28513114e-03f, 3.06326710e-03f, -7.20759481e-02f,
  4.99046072e-02f, 7.71828219e-02f, -1.90032031e-02f, -8.50446709e-03f, 8.91791657e-02f, 3.60100791e-02f, -5.35997897e-02f, 3.00862920e-02f, -1.22607546e-03f, -1.76699460e-02f,
  -1.08372077e-01f, -2.86396444e-02f, -3.65205258e-02f, -8.65866244e-02f, -1.94415096e-02f, -8.22308585e-02f, 2.98561472e-02f, -8.51421729e-02f, 5.39826183e-03f, -1.53357461e-02f,
  -6.63204789e-02f, -8.93528014e-02f, 9.37982462e-03f, -3.13822478e-02f, 8.89729932e-02f, 1.46972211e-02f, 2.13780142e-02f, -1.01415746e-01f, -8.68302211e-02f, -4.57864031e-02f,
  -1.44550368e-01f, -1.50759667e-02f, 1.21819077e-03f, -5.58932722e-02f, -1.18774310e-01f, -3.51196229e-02f, 2.40020640e-02f, 1.57319382e-02f, 3.71996276e-02f, -2.38969009e-02f,
  1.58564419e-01f, 3.64655495e-01f, -7.99515471e-02f, 1.01865917e-01f, -2.68064588e-01f, -1.97839767e-01f, 2.38177553e-02f, -8.93304721e-02f, 7.40085170e-02f, 1.85572684e-01f,
  -8.59486237e-02f, 1.80988401e-01f, 1.29546210e-01f, 1.03534706e-01f, 6.43526614e-02f, 1.50413871e-01f, 2.36018058e-02f, 2.11926941e-02f, 1.57137420e-02f, 1.29646987e-01f,
  -4.66666594e-02f, -2.93138903e-02f, -6.28852248e-02f, -1.61361814e-01f, 1.98707376e-02f, -1.02523835e-02f, -5.99603057e-02f, -9.30892751e-02f, -1.40448749e-01f, -1.05760068e-01f,
  -4.88304906e-02f, 1.58461988e-01f, 3.56554538e-02f, 4.59198020e-02f, 6.94741532e-02f, -6.39497908e-03f, 2.45863497e-02f, 4.14676704e-02f, -4.66640517e-02f, -1.93179790e-02f,
  2.49399189e-02f, -7.09348321e-02f, 2.89458316e-03f, -1.38204349e-02f, -3.53876427e-02f, -5.24932072e-02f, -7.63505176e-02f, -1.28337994e-01f, -1.03791587e-01f, -4.66667600e-02f,
  -3.98407839e-02f, -7.05555528e-02f, -3.04239653e-02f, -5.03779575e-02f, -1.94288529e-02f, -3.69881727e-02f, 1.18722050e-02f, -5.83685823e-02f, -6.07224032e-02f, 1.49171874e-02f,
  8.04560483e-02f, 8.18020552e-02f, -1.01870541e-02f, -5.58536090e-02f, -3.22455354e-02f, -7.68868998e-02f, -1.13970973e-02f, -5.99813685e-02f, 2.22168472e-02f, 3.88202332e-02f,
  -4.75223698e-02f, 4.56450693e-02f, -2.05621459e-02f, -6.87339678e-02f, 2.51719542e-02f, 3.44327576e-02f, 4.21686051e-03f, 8.74118041e-03f, -8.92539546e-02f, -1.38406336e-01f,
  -2.78902822e-03f, -4.99799149e-03f, 3.68797071e-02f, -8.97127390e-02f, -1.79895740e-02f, 7.94981122e-02f, 2.38086865e-03f, -3.28387544e-02f, 7.58018643e-02f, -4.07588556e-02f,
  1.11955643e-01f, 3.37538272e-01f, 3.83073539e-02f, 4.52980660e-02f, 1.17913922e-02f, 1.69897713e-02f, 3.44247371e-02f, -3.77802248e-03f, 6.46370128e-02f, 2.36502700e-02f,
  -6.48943931e-02f, -6.55804947e-02f, -5.99537902e-02f, -4.79377620e-03f, 1.82983913e-02f, 4.19114195e-02f, 1.21962376e-01f, -3.20919417e-02f, 7.37954024e-03f, -5.83508089e-02f,
  1.13302600e-02f, 2.47571506e-02f, 6.90214988e-03f, -9.11919326e-02f, -8.69149417e-02f, 4.63804521e-04f, -4.50717881e-02f, 1.08577507e-02f, -9.89273414e-02f, 5.60108498e-02f,
  -3.46043766e-01f, 3.64645898e-01f, 1.39031380e-01f, 9.31293219e-02f, -2.02456757e-01f, -7.44475005e-03f, 3.05358004e-02f, 5.47667593e-02f, -3.33106518e-02f, 2.33614892e-01f,
  2.53259540e-01f, 1.20606653e-01f, 1.83267564e-01f, 2.26596162e-01f, -1.18939295e-01f, 1.35114342e-01f, -6.96666092e-02f, -4.35694307e-03f, -2.12333910e-02f, 1.76007522e-03f,
  -8.69418979e-02f, -1.69130415e-02f, 1.07474625e-01f, -9.48426127e-02f, 1.34343073e-01f, -5.10963649e-02f, -1.31485388e-01f, 1.55405939e-01f, 3.46779600e-02f, 6.24728687e-02f,
  4.36302014e-02f, 7.97821432e-02f, 9.24237892e-02f, 3.06721181e-02f, 4.27167527e-02f, -1.03319526e-01f, -5.17376103e-02f, 1.36734704e-02f, -3.08392923e-02f, 3.24911252e-02f,
  7.92190805e-02f, -1.10993432e-02f, -3.98844713e-03f, -7.91120157e-02f, -8.36168677e-02f, -7.27921911e-03f, 1.31594213e-02f, -3.12477164e-02f, -5.35270870e-02f, 2.79956497e-02f,
  3.12526599e-02f, 3.53873870e-03f, -3.50732659e-03f, -3.31635512e-02f, -2.74794027e-02f, 6.02121791e-03f, -1.13436840e-02f, -6.46988153e-02f, 2.45996378e-02f, -4.45155911e-02f,
  4.85390611e-02f, -3.80850658e-02f, -4.62924801e-02f, 7.19440694e-04f, -2.25381944e-02f, -1.92798078e-02f, -1.35836722e-02f, 5.79336397e-02f, -5.87228537e-02f, 1.88998301e-02f,
  -7.22006485e-02f, 3.72666866e-02f, 3.42142470e-02f, -3.45414691e-02f, -3.91058065e-02f, 1.64577160e-02f, -1.52418427e-02f, 2.81974692e-02f, -2.05781981e-02f, 1.99755542e-02f,
  2.10077222e-03f, -5.54626994e-02f, 4.43705879e-02f, -5.97705618e-02f, -1.21504543e-02f, -3.78717594e-02f, -3.71186547e-02f, 5.69508262e-02f, 5.59602529e-02f, -5.14224805e-02f,
  6.04506955e-02f, 5.09367622e-02f, 6.61422163e-02f, 9.65796933e-02f, 2.39501288e-03f, -6.64766803e-02f, -7.51121622e-03f, 6.21928051e-02f, 4.31390293e-02f, -7.41216019e-02f,
  -4.48817201e-02f, -4.13010158e-02f, -4.27168757e-02f, -3.25380042e-02f, -4.57289517e-02f, 1.85064804e-02f, 3.41651589e-02f, -7.76047111e-02f, -3.40958834e-02f, -1.52133433e-02f,
  1.08426875e-02f, 2.78844289e-03f, 2.32210811e-02f, -9.52695869e-03f, 1.13578578e-02f, 1.56346208e-03f, -1.55735537e-01f, 4.60820086e-02f, -8.00515637e-02f, -6.03340939e-02f,
  -4.78787899e-01f, 1.88477173e-01f, 2.67402772e-02f, -2.31143057e-01f, 2.25462187e-02f, -2.10215617e-03f, 4.48835753e-02f, 1.30836725e-01f, -1.39852643e-01f, 1.13705650e-01f,
  4.88026626e-02f, -2.25295454e-01f, 1.48557410e-01f, 1.30578587e-02f, -3.31965506e-01f, 5.67130707e-02f, -2.09599003e-01f, -6.70074448e-02f, -5.09363003e-02f, -7.80103654e-02f,
  1.01571474e-02f, 6.48388043e-02f, 1.57563478e-01f, 1.78196758e-01f, 1.11193821e-01f, 8.64708722e-02f, 6.42779246e-02f, 2.40461051e-01f, 8.31344910e-03f, 8.50760490e-02f,
  6.14027046e-02f, -1.87769309e-02f, 6.39707372e-02f, 6.77055120e-02f, 6.24769367e-02f, -2.67418195e-02f, 7.11397175e-03f, 1.45103335e-02f, -1.74048748e-02f, 7.20241666e-02f,
  -4.65126224e-02f, -6.75560459e-02f, 3.88767682e-02f, -5.35138824e-04f, -2.32539047e-02f, -8.77169296e-02f, -7.13707283e-02f, -2.95696110e-02f, -5.58537384e-03f, -9.00268629e-02f,
  9.16537084e-03f, 9.18004662e-02f, -1.68090444e-02f, -1.89202335e-02f, -1.48127489e-02f, -1.09113026e-02f, -1.00820184e-01f, -3.80062647e-02f, 9.14419144e-02f, -1.02187380e-01f,
  -1.01130016e-01f, 5.97514361e-02f, 1.42211378e-01f, 6.72279596e-02f, 1.47867016e-02f, 8.37154686e-02f, 9.77528542e-02f, 2.63222959e-02f, 6.35192767e-02f, -5.29551134e-02f,
  -2.57219970e-02f, 7.19285682e-02f, -8.67833477e-03f, 7.63203129e-02f, -3.96429300e-02f, -1.01744523e-02f, -1.54457549e-02f, 2.96657793e-02f, -4.86038029e-02f, 4.60854452e-03f,
  4.43435349e-02f, 3.04828435e-02f, 3.80281247e-02f, -1.78394525e-03f, 1.16573302e-02f, -1.42421089e-02f, 6.47310838e-02f, -8.03222805e-02f, 4.65234742e-02f, -2.55985018e-02f,
  -8.53203759e-02f, -3.36100310e-02f, 8.01094323e-02f, -2.13319268e-02f, -3.09829544e-02f, -5.72515391e-02f, -6.49858192e-02f, 2.26929933e-02f, -3.88715882e-03f, -7.54632801e-02f,
  1.38640692e-02f, -2.50585955e-02f, 1.07673441e-04f, -4.05769609e-02f, 4.56159972e-02f, 2.32679695e-02f, -4.36414480e-02f, -1.26699973e-02f, -5.97529151e-02f, -4.91137616e-02f,
  -6.79950267e-02f, 4.37277853e-02f, -6.73944578e-02f, 7.49522001e-02f, -7.65264109e-02f, 5.38276024e-02f, -9.59122330e-02f, 3.16890515e-02f, -7.78504834e-02f, -1.76378805e-02f,
  -2.13139176e-01f, -4.04935591e-02f, 2.64862150e-01f, -2.11851850e-01f, 2.33494848e-01f, 8.07569697e-02f, -2.53954142e-01f, 4.60726134e-02f, -7.51430616e-02f, -3.05646181e-01f,
  -1.42567188e-01f, -1.64373294e-01f, -3.42922937e-03f, -1.40280992e-01f, 3.74762565e-01f, 1.30179152e-01f, -5.19234017e-02f, -1.62613451e-01f, 7.93039575e-02f, -9.19611752e-02f,
  1.20967925e-01f, -6.29122332e-02f, 1.58538550e-01f, 1.17595628e-01f, -1.10177010e-01f, -6.63780943e-02f, 3.42488959e-02f, 1.06111638e-01f, 2.79840757e-03f, 6.61359355e-02f,
  5.78294620e-02f, -2.03897312e-01f, 2.69195009e-02f, 2.18260027e-02f, 5.38220368e-02f, -3.86007950e-02f, 1.69140603e-02f, 3.62510011e-02f, 7.40000904e-02f, -7.87465498e-02f,
  9.58146527e-03f, 1.72692090e-02f, 2.85793412e-02f, -6.07412271e-02f, -2.74945498e-02f, 2.45135557e-02f, 4.48380895e-02f, -1.44326722e-03f, 7.42044719e-03f, -1.65992286e-02f,
  4.22210544e-02f, 5.37467469e-03f, -8.06300864e-02f, -1.18910119e-01f, -2.73449514e-02f, 7.03853881e-03f, 6.19361885e-02f, 5.70965894e-02f, -4.52021472e-02f, -5.17363511e-02f,
  -3.87586020e-02f, -2.96978112e-02f, -3.71437185e-02f, 5.19016869e-02f, 8.97936076e-02f, 9.13748220e-02f, 1.02918698e-02f, 5.79265580e-02f, 3.14482152e-02f, 7.36152427e-03f,
  9.38342214e-02f, -2.58296914e-02f, -5.96576855e-02f, -4.32956517e-02f, -9.72078964e-02f, -1.33701146e-01f, 2.15983316e-02f, 3.28073017e-02f, 8.55168775e-02f, 7.10400864e-02f,
  6.29248098e-03f, 6.90680370e-02f, 1.03819009e-03f, -6.68106508e-03f, 3.20454203e-02f, -9.56212450e-03f, -3.15427221e-02f, -3.62365469e-02f, -7.26062134e-02f, -3.77475023e-02f,
  1.51854092e-02f, -1.22137837e-01f, 4.34128419e-02f, -5.57505339e-02f, 6.50878698e-02f, -5.12629142e-03f, 5.23846149e-02f, 6.42642677e-02f, 2.60665920e-02f, -7.32965544e-02f,
  3.35565303e-03f, -1.08043507e-01f, 7.04674423e-02f, -8.37711990e-02f, 7.62241036e-02f, 2.57735867e-02f, -6.42614216e-02f, 6.86374530e-02f, 2.63011437e-02f, 4.29941230e-02f,
  -2.26143524e-02f, 1.39536550e-02f, -7.88151193e-03f, -9.99446437e-02f, -2.73108091e-02f, 2.87492163e-02f, 2.35442612e-02f, 3.76642384e-02f, 2.45541967e-02f, 3.01810931e-02f,
  -4.72563982e-01f, 2.83339739e-01f, 7.35249519e-02f, -1.61702752e-01f, -7.15754479e-02f, 2.30668157e-01f, 9.46477279e-02f, 1.98723022e-02f, -6.92908615e-02f, 1.96255371e-01f,
  -8.19031298e-02f, 8.15893188e-02f, -7.22857891e-03f, 2.66420320e-02f, -1.78501919e-01f, 6.83870614e-02f, -1.01516731e-02f, 6.18439540e-02f, -1.74075756e-02f, -1.73926249e-01f,
  -1.55122027e-01f, -1.24683842e-01f, -1.34576455e-01f, -1.10847101e-01f, -1.40496477e-01f, -7.28897005e-02f, -4.17406447e-02f, -2.63779480e-02f, 7.94208795e-02f, 5.16020618e-02f,
  -6.27469122e-02f, -1.98776349e-01f, -1.27066742e-03f, -6.10437877e-02f, -2.60227416e-02f, 1.60606205e-02f, -4.65449877e-02f, -3.95498537e-02f, 1.19955819e-02f, -1.02539875e-01f,
  6.03304356e-02f, -1.00338101e-01f, -2.13100892e-02f, 1.34601146e-02f, 7.11411387e-02f, 7.21217096e-02f, 6.02968410e-02f, 1.06122524e-01f, 4.31696214e-02f, -9.03603248e-03f,
  2.77143475e-02f, -2.19169334e-02f, 3.23621407e-02f, -1.61152277e-02f, -7.43034557e-02f, -9.46432445e-03f, -1.92699884e-03f, 1.23946341e-02f, -6.81693573e-03f, 2.00797841e-02f,
  -2.47421954e-02f, -4.66543473e-02f, 7.06081018e-02f, 4.17317078e-02f, 4.81554754e-02f, 3.18740010e-02f, -6.12003356e-02f, 4.88309488e-02f, 7.01536313e-02f, -3.33547592e-02f,
  5.72671071e-02f, 1.08985230e-02f, -9.02896896e-02f, 7.41901174e-02f, -6.51143342e-02f, -4.15452048e-02f, 8.22004862e-03f, -8.94200429e-02f, 3.83160040e-02f, 4.44746986e-02f,
  -5.63126011e-03f, -2.56226473e-02f, 6.48519695e-02f, -5.76908104e-02f, -5.83182164e-02f, 3.25375758e-02f, -4.21207137e-02f, 1.78942289e-02f, -7.94211999e-02f, -1.35613400e-02f,
  -2.37709899e-02f, -2.14962229e-01f, -4.39177565e-02f, -4.61243354e-02f, 1.86136086e-02f, 2.86655352e-02f, -4.41341661e-02f, 6.45675585e-02f, 1.93893537e-01f, -3.77684981e-02f,
  -1.11286587e-03f, -2.80189104e-02f, -9.91422385e-02f, -3.56742255e-02f, 4.07159403e-02f, 2.39708386e-02f, -4.45960201e-02f, 1.28678575e-01f, 7.07139447e-02f, 4.73555885e-02f,
  -1.27399331e-02f, -7.57770985e-02f, -9.22498554e-02f, 1.21663674e-03f, -1.02809761e-02f, -8.99187624e-02f, -5.75417690e-02f, 1.08345695e-01f, -9.11941007e-02f, 6.41653836e-02f,
  7.32857063e-02f, -1.43923253e-01f, -1.46529689e-01f, -1.68760374e-01f, 4.85781282e-02f, -2.94090211e-01f, -3.79737645e-01f, -1.34723564e-03f, -1.30249456e-01f, -2.12498531e-01f,
  -1.26465991e-01f, -2.40512371e-01f, -7.05665872e-02f, -2.58736908e-01f, -1.31027043e-01f, -1.70643628e-01f, -1.92655191e-01f, -2.37949833e-01f, 1.10597216e-01f, -3.13787684e-02f,
  1.56987701e-02f, 4.73063551e-02f, -9.01301019e-03f, 1.52394190e-01f, -1.93237867e-02f, 2.13090956e-01f, 1.45160511e-01f, 1.75044197e-03f, -2.15918086e-02f, -2.04820856e-02f,
  5.29768318e-02f, 1.80098593e-01f, -7.61581361e-02f, -5.59573434e-02f, 6.35405406e-02f, -9.80382115e-02f, -2.62671169e-02f, 2.67558564e-02f, -1.39095529e-03f, 3.62974852e-02f,
  -1.49405390e-01f, 1.06279172e-01f, 1.68742910e-02f, 2.18244866e-02f, -8.20365325e-02f, 1.58764366e-02f, 5.79543635e-02f, -3.15715075e-02f, -4.13812958e-02f, -2.00560950e-02f,
  -5.96585013e-02f, -3.59644182e-02f, 5.43543585e-02f, 5.57583682e-02f, -3.92072760e-02f, -2.69699842e-02f, -3.35257314e-02f, -3.89499106e-02f, 1.35637773e-02f, -2.80626826e-02f,
  -3.85510586e-02f, -3.63529176e-02f, 5.71174268e-03f, 2.91721318e-02f, 4.07335050e-02f, 6.38268217e-02f, 3.57502252e-02f, 2.36075111e-02f, 5.99719360e-02f, 3.18187661e-02f,
  6.05665613e-03f, -5.85772768e-02f, -9.71668120e-03f, -4.33105268e-02f, 8.79697651e-02f, 3.56834531e-02f, -6.28742483e-03f, -1.18434941e-02f, -2.68206876e-02f, 9.28767305e-03f,
  1.58728156e-02f, 1.32137671e-01f, -1.72465900e-03f, -3.36942933e-02f, 8.86861514e-03f, -1.05599023e-01f, 1.19533598e-01f, 8.81410902e-04f, -1.79081243e-02f, -2.49162447e-02f,
  8.73604342e-02f, 1.27374619e-01f, 3.19289335e-04f, 1.89782884e-02f, 4.87094931e-02f, -4.36544232e-03f, -9.53276828e-03f, 1.95253491e-02f, -4.56007421e-02f, 2.63372865e-02f,
  -4.07677703e-02f, 1.51203927e-02f, 1.78972278e-02f, 2.82564219e-02f, -2.96724830e-02f, -9.27140657e-03f, 5.47595229e-03f, -6.17134310e-02f, -6.97133765e-02f, -2.76845470e-02f,
  5.91811091e-02f, 9.52501670e-02f, 5.65398857e-02f, 8.54790732e-02f, -4.09775088e-03f, 9.66036506e-03f, 1.69495232e-02f, -1.82157308e-02f, 7.14940429e-02f, 6.88369498e-02f,
  1.16256457e-02f, 1.20353386e-01f, -6.03108900e-03f, -5.88272214e-02f, 7.91194886e-02f, -2.29512110e-01f, -1.15342855e-01f, 1.21481672e-01f, 3.19282234e-01f, -1.91079199e-01f,
  -1.05179943e-01f, -1.43409416e-01f, 1.40269563e-01f, -2.12510586e-01f, -1.34484455e-01f, 1.57389700e-01f, -1.40916273e-01f, -1.43738568e-01f, 1.58395186e-01f, -1.67897075e-01f,
  6.51091523e-03f, -1.58307061e-01f, -1.41569808e-01f, -7.32879117e-02f, 2.63759363e-02f, 2.25554425e-02f, -2.55577505e-01f, 4.51130681e-02f, -3.39071512e-01f, 1.06111607e-02f,
  7.83140063e-02f, 1.31134927e-01f, 4.63720858e-02f, 1.50860427e-02f, 3.85206006e-02f, 5.57569191e-02f, -1.25144035e-01f, -6.21683933e-02f, 1.66153654e-01f, -6.13298081e-02f,
  -1.18822884e-02f, -6.74895793e-02f, -7.43322447e-02f, 1.30535364e-02f, 2.70124841e-02f, -8.69101286e-03f, 1.22701395e-02f, 6.02209680e-02f, -2.00316310e-02f, -5.94645813e-02f,
  -1.03493109e-01f, 8.52001384e-02f, 1.24968654e-02f, -1.71347987e-02f, -2.45124362e-02f, 7.10797608e-02f, -1.88656986e-01f, -1.26752600e-01f, 5.10044657e-02f, 5.58005683e-02f,
  9.21136420e-03f, 2.63289385e-03f, -9.87861231e-02f, 5.68617927e-03f, -5.88620566e-02f, 2.16545332e-02f, -1.01771235e-01f, -8.87101665e-02f, 8.06759149e-02f, -1.52298408e-02f,
  -4.69065234e-02f, 2.19296459e-02f, 4.26687449e-02f, -6.00463673e-02f, -1.32142931e-01f, 1.72416881e-01f, 8.33558571e-03f, 5.82323410e-02f, 3.38326506e-02f, 3.56425308e-02f,
  8.84638634e-03f, 4.81824540e-02f, 1.64828114e-02f, 1.67616569e-02f, 4.59976681e-02f, -1.60329193e-02f, -4.00291644e-02f, -3.81116197e-03f, 8.59670565e-02f, -1.41576706e-02f,
  -6.33733496e-02f, 5.89944236e-03f, 8.28588977e-02f, 2.79611647e-02f, 6.16583712e-02f, -3.27676050e-02f, 2.08149813e-02f, -6.55956268e-02f, 8.22163075e-02f, -4.47708592e-02f,
  -2.20936760e-02f, -3.12718786e-02f, 3.31223616e-03f, -7.08606839e-03f, 1.36692692e-02f, -1.14093982e-01f, 1.60721559e-02f, 3.20494883e-02f, 3.33217233e-02f, -3.72085646e-02f,
  -6.84314072e-02f, 1.36496825e-03f, -5.37920231e-03f, 4.19106632e-02f, -4.41481993e-02f, -1.38021186e-02f, -9.58645865e-02f, 5.84523305e-02f, 1.34053938e-02f, 1.44188991e-02f,
  1.11743972e-01f, 5.05862804e-03f, -1.38963267e-01f, -2.99075991e-02f, 3.81884165e-02f, 1.02114573e-01f, 2.05030143e-01f, 1.02159359e-01f, -1.41809940e-01f, 2.78076939e-02f,
  2.56423712e-01f, -1.58962548e-01f, 4.08600979e-02f, 2.19790384e-01f, 1.99275002e-01f, 7.60969445e-02f, 5.40529080e-02f, 7.85852522e-02f, 8.42584949e-03f, 1.65570050e-01f,
  2.11682275e-01f, 2.96359986e-01f, 1.17879786e-01f, 7.75563270e-02f, 1.56829759e-01f, -4.89434898e-02f, 6.28921017e-02f, 5.42566963e-02f, 8.41325801e-03f, -8.12338814e-02f,
  1.20991737e-01f, -2.98700333e-02f, 5.11639267e-02f, -1.12889186e-01f, 9.09583420e-02f, 4.27067354e-02f, -4.63472418e-02f, 1.11569025e-01f, -8.93468708e-02f, -4.36115190e-02f,
  -4.02187295e-02f, -6.71182275e-02f, -5.36410324e-02f, -8.16305354e-02f, 3.77970189e-02f, -2.82019246e-02f, -6.24051467e-02f, -5.49427457e-02f, -6.47429302e-02f, -3.19485329e-02f,
  -2.80058589e-02f, -2.65812892e-02f, 3.86003032e-02f, -6.74928427e-02f, 2.00354923e-02f, 2.86035449e-03f, -5.51093221e-02f, -6.50784373e-02f, -5.06253354e-02f, -6.11490384e-02f,
  5.29999100e-02f, 1.50472913e-02f, 6.91976473e-02f, -1.45001542e-02f, 4.48999517e-02f, -1.39017478e-02f, -2.97686514e-02f, 4.53465134e-02f, 1.11169785e-01f, 2.12134961e-02f,
  -1.03046425e-01f, 1.28266692e-01f, 3.35189067e-02f, 5.57339378e-02f, 3.19280699e-02f, 6.00945987e-02f, 4.61075753e-02f, -5.14609776e-02f, 7.74610182e-03f, 1.20872408e-01f,
  -1.14402816e-01f, -3.37577462e-02f, -8.59205984e-03f, -5.08909002e-02f, -1.05721848e-02f, -3.86754125e-02f, 2.32402980e-03f, -6.07844442e-02f, 1.67052895e-01f, -8.92198905e-02f,
  -2.67527942e-02f, -1.07715584e-01f, 1.71875339e-02f, -5.74868210e-02f, -8.54808539e-02f, 6.03354871e-02f, 2.62496565e-02f, 1.85137510e-01f, -7.03956559e-02f, -3.85271497e-02f,
  1.14560099e-02f, -6.84965029e-02f, -1.58376843e-01f, 2.24259160e-02f, 3.27931643e-02f, 6.36179820e-02f, 3.20841260e-02f, -1.32002413e-01f, -5.77088557e-02f, 3.05208797e-03f,
  6.11969978e-02f, 8.19171965e-02f, -2.09969468e-03f, 1.03583215e-02f, 4.10717763e-02f, -1.63686071e-02f, -2.30905637e-02f, -6.06292784e-02f, -8.85759294e-02f, -8.09518769e-02f,
  2.75168661e-02f, 1.63389608e-01f, 4.77945060e-02f, 3.31180692e-01f, -1.19382165e-01f, 2.20908597e-01f, 1.95167586e-01f, 2.38408297e-02f, 1.84258252e-01f, 3.01123321e-01f,
  1.06336884e-01f, -2.14922737e-04f, -1.02208368e-01f, 8.09563920e-02f, -1.12114415e-01f, -4.95581664e-02f, 3.31677228e-01f, 2.51821786e-01f, 3.20420638e-02f, 8.70262757e-02f,
  3.21662948e-02f, 5.60918003e-02f, -3.81822735e-02f, 3.96731719e-02f, 1.24491669e-01f, 1.43935397e-01f, -2.30792593e-02f, -1.63003236e-01f, 1.88263446e-01f, -7.54895210e-02f,
  5.81236444e-02f, -2.89161261e-02f, 1.24491174e-02f, 3.21503729e-02f, 3.47884446e-02f, 3.37642245e-02f, 7.37146065e-02f, -7.00400174e-02f, -7.67682195e-02f, 5.28561473e-02f,
  -5.33080176e-02f, 2.35539433e-02f, -8.44579015e-04f, 2.78368890e-02f, 8.81497189e-02f, -2.51081418e-02f, -3.81742902e-02f, -4.73401845e-02f, -2.24425290e-02f, -2.72445995e-02f,
  -4.70348746e-02f, -5.35989064e-04f, 8.16714168e-02f, -4.84170169e-02f, 1.48284078e-01f, 7.00720698e-02f, 5.87814935e-02f, -9.20435227e-03f, 4.76144414e-05f, 6.66957349e-02f,
  -4.76789065e-02f, 6.18509986e-02f, 1.92466788e-02f, 6.88962042e-02f, -3.19313966e-02f, -8.20209533e-02f, -2.07875948e-02f, -7.82621279e-02f, 3.82154509e-02f, 1.33869098e-02f,
  2.13969517e-02f, 5.69607355e-02f, 1.17815539e-01f, 4.64003235e-02f, 1.17366150e-01f, -6.11232826e-04f, -5.53454496e-02f, -7.96609595e-02f, 5.92114590e-02f, 1.78661961e-02f,
  -1.40454369e-02f, 7.51665309e-02f, -7.73969516e-02f, -4.69274260e-02f, -9.26904157e-02f, -5.76387951e-03f, -4.70940117e-03f, -3.77525352e-02f, 5.20884153e-03f, -1.72647496e-03f,
  7.15256706e-02f, 1.15450725e-01f, 3.51157156e-03f, -2.61016842e-02f, -3.21066380e-02f, -1.93390250e-02f, 5.11581600e-02f, 9.10518840e-02f, 3.56005840e-02f, -3.06023937e-02f,
  -3.78416851e-03f, 5.52089214e-02f, 1.44066485e-02f, 6.97631836e-02f, -2.45299507e-02f, 1.14766821e-01f, 2.35904679e-02f, -9.28485841e-02f, -4.57249284e-02f, -2.43800525e-02f,
  5.78298643e-02f, 8.37494712e-03f, 8.82709101e-02f, 8.85010976e-03f, 1.03881381e-01f, 8.13047215e-03f, 1.28348246e-01f, -3.81359458e-02f, -6.07523248e-02f, 1.29234446e-02f,
  -2.61120647e-01f, -1.21389896e-01f, -1.01053692e-01f, -1.87583023e-03f, -8.46415833e-02f, 1.74658105e-01f, 1.05873525e-01f, -1.72302186e-01f, -7.66403228e-02f, 1.41644806e-01f,
  1.55011773e-01f, 2.60182917e-02f, 1.03451408e-01f, 7.86330402e-02f, 2.36543804e-01f, 2.11496100e-01f, 2.00828075e-01f, 1.07255779e-01f, -1.71933755e-01f, -1.86635628e-01f,
  -1.02849618e-01f, 1.90230424e-03f, 1.12467080e-01f, -1.77203298e-01f, -2.84174792e-02f, -7.19188303e-02f, 1.72615528e-01f, -5.34040295e-02f, 1.61751017e-01f, 7.58816898e-02f,
  -5.91307096e-02f, -3.00620437e-01f, -1.48813250e-02f, -5.96177466e-02f, 5.10489717e-02f, 1.53441885e-02f, 2.27115415e-02f, 8.30593035e-02f, -1.38322609e-02f, -3.83806601e-02f,
  1.72000900e-01f, -1.75921395e-01f, -1.17826154e-02f, 9.94522497e-02f, 8.77540931e-03f, -8.25854316e-02f, 7.50548532e-03f, 1.31792175e-02f, -5.77228069e-02f, -3.48396152e-02f,
  -2.64590774e-02f, -5.08993771e-03f, 1.31812185e-01f, 2.45262329e-02f, 2.76436582e-02f, 3.43774748e-03f, 1.00074358e-01f, 6.89703003e-02f, 4.91499715e-02f, 4.28270958e-02f,
  6.86193556e-02f, -1.19211085e-01f, -1.59948349e-01f, -4.16140966e-02f, -3.59803811e-02f, 1.49927363e-01f, 1.75391529e-02f, 5.66904508e-02f, 2.43864041e-02f, -7.70449489e-02f,
  -6.77906349e-02f, -3.47448401e-02f, -5.34989908e-02f, 3.98531370e-02f, -7.22467378e-02f, -9.32857320e-02f, 1.70959830e-02f, 3.02297231e-02f, -7.51816947e-03f, 3.87481339e-02f,
  7.41227940e-02f, -7.49850124e-02f, -1.44155382e-03f, 7.18593970e-02f, -2.53699198e-02f, -3.33802551e-02f, -1.32091865e-01f, 2.93949861e-02f, -4.97411191e-02f, 3.49315852e-02f,
  3.58788483e-02f, -9.33480188e-02f, 1.60193481e-02f, -1.76996142e-02f, 8.38975161e-02f, -9.83754098e-02f, 4.33030911e-02f, 5.81252836e-02f, 1.09414488e-01f, -2.61972696e-02f,
  8.25844184e-02f, 1.68435723e-02f, 1.40167484e-02f, 6.68000281e-02f, 1.50751369e-02f, -8.18433985e-03f, -5.16594562e-04f, 2.03403141e-02f, 1.99353006e-02f, -4.37939726e-03f,
  -4.00546864e-02f, -1.45519711e-02f, 4.22149599e-02f, -9.46107060e-02f, 8.50617662e-02f, 6.00580834e-02f, 3.39174010e-02f, 4.99385782e-02f, 6.28074482e-02f, -2.15583704e-02f,
  2.46894211e-01f, -2.05414236e-01f, 2.96865523e-01f, 6.32754490e-02f, 8.16200152e-02f, -1.99452087e-01f, -8.12301040e-03f, -4.43082973e-02f, 1.09217718e-01f, -2.64358938e-01f,
  -8.00398216e-02f, 4.00840566e-02f, -1.77657127e-01f, -9.92507935e-02f, 1.14956178e-01f, -9.05308947e-02f, -9.71101373e-02f, -3.65550108e-02f, 1.02634043e-01f, -8.99427906e-02f,
  4.46704738e-02f, -1.66068748e-01f, 1.31714061e-01f, -1.41770557e-01f, 1.17955968e-01f, 2.06948459e-01f, 2.89228838e-03f, 1.57945916e-01f, -4.98419348e-03f, 1.12884521e-01f,
  -1.06185660e-01f, 8.05594921e-02f, 1.37128383e-01f, 2.91494988e-02f, -9.08250213e-02f, 4.55387793e-02f, 3.92338634e-02f, 7.25473389e-02f, 4.66545986e-04f, -3.40327173e-02f,
  -7.12364316e-02f, -1.00504950e-01f, 4.46840189e-02f, 9.91117284e-02f, 4.46576253e-02f, 7.02102035e-02f, -6.63809758e-03f, 1.73545647e-02f, 6.45193607e-02f, 1.74737144e-02f,
  4.52894196e-02f, 2.18176153e-02f, -1.38312196e-02f, 1.99322943e-02f, 5.42079695e-02f, 4.79234606e-02f, -2.80659571e-02f, 1.65421948e-01f, 3.39757018e-02f, 6.54258057e-02f,
  1.08155645e-01f, -2.40520835e-02f, 8.39037374e-02f, -5.52236997e-02f, 4.19668294e-02f, -1.54106664e-02f, -3.94826159e-02f, -3.33140343e-02f, 1.61396712e-02f, -5.52444682e-02f,
  1.84738450e-02f, 5.19818030e-02f, -3.72063741e-02f, 1.87302381e-02f, 1.72171202e-02f, -4.36421074e-02f, -4.79355380e-02f, -2.33937055e-02f, 9.11327004e-02f, -2.25787163e-02f,
  2.03336105e-02f, 2.39717048e-02f, -4.56722034e-03f, -1.01260440e-02f, -3.07478360e-03f, 2.42499430e-02f, 4.80594207e-03f, 7.48477643e-03f, -5.12075424e-02f, 3.58355604e-02f,
  -3.29212219e-01f, -2.18913451e-01f, -8.67918283e-02f, -7.36774430e-02f, 2.62154192e-02f, -7.60038272e-02f, -1.69559300e-03f, 3.92640978e-02f, -1.07607670e-01f, 1.27318576e-02f,
  -5.54408431e-02f, -6.54062629e-02f, -5.21046035e-02f, 3.73033970e-03f, 2.00973751e-04f, -3.27477194e-02f, -9.13030729e-02f, -7.72094578e-02f, -9.31785926e-02f, -1.43183827e-01f,
  -1.74752548e-01f, -9.30916667e-02f, 2.70732082e-02f, 4.93283980e-02f, -5.00382148e-02f, 8.67285132e-02f, 2.13091448e-02f, 3.51431631e-02f, 4.44290489e-02f, 2.19244533e-03f,
  4.60728884e-01f, 1.49456248e-01f, 1.43370375e-01f, 1.46312878e-01f, -1.64806042e-02f, -1.23855673e-01f, -1.12280183e-01f, 1.69258475e-01f, 1.70640454e-01f, -1.27674744e-01f,
  -6.20798320e-02f, -6.22615516e-02f, 3.20012793e-02f, 3.52903595e-03f, 1.95968971e-01f, 7.10152462e-02f, 7.86190107e-02f, -1.11978360e-01f, 9.88268107e-02f, 1.86216280e-01f,
  1.22829489e-01f, 9.78832785e-03f, 9.51961651e-02f, -4.13167216e-02f, 1.99661300e-01f, 4.13662158e-02f, -1.10712953e-01f, -3.11077200e-03f, -1.36801198e-01f, -2.18776301e-01f,
  -1.69245172e-02f, 1.25403598e-01f, 9.09551606e-02f, -1.52265234e-02f, 6.49181828e-02f, 2.26484537e-02f, -1.25387728e-01f, -8.98601636e-02f, 3.63957509e-02f, -4.48580720e-02f,
  -6.10081591e-02f, -7.65008777e-02f, -1.04365595e-01f, 5.46812685e-03f, 8.77211057e-03f, -7.27122501e-02f, -4.64463234e-03f, -1.04041826e-02f, 3.42921214e-03f, -3.67916748e-02f,
  5.52738905e-02f, -5.39545417e-02f, -3.14036049e-02f, -1.94125623e-01f, -3.17747407e-02f, 4.42201877e-03f, -1.62906379e-01f, -1.16033152e-01f, -3.57861854e-02f, -5.01716547e-02f,
  -2.59636994e-02f, 6.28263205e-02f, 7.67531693e-02f, 5.11609986e-02f, 4.40654345e-02f, -3.44678573e-02f, 4.10023965e-02f, -4.10703570e-02f, 6.40858989e-03f, -1.21782282e-02f,
  -2.07461454e-02f, 4.18572500e-02f, 6.26987368e-02f, 7.95476586e-02f, 5.38881570e-02f, 8.03059712e-02f, 4.95929606e-02f, -7.88353086e-02f, -8.62627756e-03f, 1.59560330e-02f,
  -5.75047657e-02f, 7.58440495e-02f, 6.15909956e-02f, -1.19649477e-01f, -9.06294733e-02f, -2.12716497e-03f, -1.38931221e-03f, -4.84932140e-02f, 3.84341516e-02f, 5.82118193e-03f,
  8.10454413e-03f, 1.62927553e-01f, 5.39018624e-02f, -2.09987164e-02f, -5.47516011e-02f, 6.33429289e-02f, 2.44002752e-02f, 3.75229083e-02f, -2.91647203e-02f, -3.84158380e-02f,
  -4.63215671e-02f, -1.09731115e-01f, -1.04550652e-01f, -1.13662146e-01f, 2.84395833e-02f, -2.98186224e-02f, 2.97072921e-02f, -1.13550961e-01f, -1.67692881e-02f, -8.00280571e-02f,
  -1.38507392e-02f, -3.92299965e-02f, 3.32597420e-02f, -1.37797855e-02f, -8.74163657e-02f, -5.14915287e-02f, -3.74372005e-02f, -3.78577039e-02f, -6.03301115e-02f, -1.47125885e-01f,
  -2.09542885e-01f, 5.20904036e-03f, -1.29416212e-01f, 3.39616984e-02f, -7.73894787e-02f, 1.80229977e-01f, 2.45308295e-01f, 4.29186188e-02f, 1.16181910e-01f, 2.39454657e-01f,
  1.92029089e-01f, -1.10364268e-02f, 2.23318204e-01f, 2.42602006e-01f, 3.09824079e-01f, 1.49955228e-01f, 9.62454975e-02f, 1.80881415e-02f, -1.51925817e-01f, -1.42984286e-01f,
  -3.97826470e-02f, 5.10723032e-02f, 2.86391918e-02f, -3.02194152e-02f, 1.96400769e-02f, -1.42064512e-01f, 1.15732260e-01f, 7.01944008e-02f, 1.06075823e-01f, 1.26150370e-01f,
  4.14207913e-02f, 9.96943191e-03f, -6.76138848e-02f, 5.18627986e-02f, 3.86218503e-02f, 1.29404673e-02f, -9.22133625e-02f, 3.98391336e-02f, 6.14894321e-03f, 2.10210718e-02f,
  7.49630271e-04f, -4.68693674e-02f, 3.15949656e-02f, 6.59119636e-02f, -9.92763136e-03f, 3.34758386e-02f, -9.18443054e-02f, 1.65503323e-02f, 2.73537990e-02f, -8.26950520e-02f,
  -3.95189039e-03f, 3.49953845e-02f, 1.14680767e-01f, -2.49821022e-02f, -5.03347032e-02f, 7.32880756e-02f, -5.16628772e-02f, 2.00615749e-02f, -2.17838474e-02f, 3.27427275e-02f,
  -4.76890020e-02f, -3.70177850e-02f, -3.70351560e-02f, 1.13473445e-01f, 1.05459124e-01f, 9.86637548e-02f, -4.80511375e-02f, -3.96117754e-02f, 1.03810392e-01f, 8.69473219e-02f,
  2.88604526e-03f, -2.75929626e-02f, -1.85631402e-02f, 2.18142048e-02f, -8.95014703e-02f, 1.55660864e-02f, -5.02390452e-02f, -9.28101987e-02f, 1.00986520e-02f, 3.44471820e-02f,
  -9.73006263e-02f, -9.60382745e-02f, 6.22548498e-02f, -2.33775713e-02f, -5.04346332e-04f, 1.09024413e-01f, 2.94183996e-02f, 6.37094826e-02f, 5.90220504e-02f, -3.65826674e-02f,
  3.28058526e-02f, 1.49597796e-02f, 1.02541491e-01f, 3.91238108e-02f, -3.10512800e-02f, -1.37230307e-02f, 5.95686724e-03f, 2.34405184e-03f, 1.09166950e-01f, 3.68904695e-03f,
  3.44706513e-02f, 2.62601115e-02f, 1.10646868e-02f, 8.11255872e-02f, 6.32937327e-02f, 4.02896516e-02f, -4.21962515e-02f, 1.35460705e-01f, 5.69655336e-02f, 2.60628778e-02f,
  5.03562056e-02f, 1.11604296e-02f, 4.87799123e-02f, -6.09493777e-02f, -4.78188396e-02f, 7.69727603e-02f, -7.08337650e-02f, 4.18285802e-02f, -1.03950426e-01f, 4.26942259e-02f,
  1.26944736e-01f, -1.96901873e-01f, 1.80457160e-01f, -2.58804150e-02f, 1.36728361e-01f, 1.21460050e-01f, -7.75470361e-02f, 5.03868312e-02f, -2.98445076e-02f, -1.92712188e-01f,
  -3.19502018e-02f, -6.27375022e-02f, -8.20968971e-02f, -4.16560695e-02f, 4.10319790e-02f, -1.43290833e-01f, 9.39815342e-02f, -5.22871641e-03f, -6.73948228e-03f, -7.37207150e-03f,
  3.29975635e-02f, 1.49085131e-02f, 2.01919407e-01f, 4.97238524e-02f, 3.78759690e-02f, 6.93876594e-02f, -2.39765756e-02f, -5.10068350e-02f, 1.81904122e-01f, -1.55334128e-03f,
  5.08981682e-02f, 2.24077571e-02f, 5.44790104e-02f, -6.87681511e-02f, 9.69294608e-02f, 8.00732598e-02f, 1.39420584e-01f, -2.65465435e-02f, 7.00547621e-02f, 4.01311703e-02f,
  1.64571404e-02f, 5.07162064e-02f, 3.81136797e-02f, -5.92156835e-02f, 7.63292387e-02f, 4.69412170e-02f, 6.35283887e-02f, 5.90427145e-02f, 1.28807351e-01f, 4.18366827e-02f,
  4.03770059e-02f, 3.65671217e-02f, 1.06329054e-01f, 6.57621399e-02f, 8.53605419e-02f, -3.14118690e-03f, 4.05053385e-02f, 7.43101388e-02f, 6.52192011e-02f, 7.12150112e-02f,
  1.32217214e-01f, -5.06914146e-02f, -7.15805069e-02f, -1.26891747e-01f, -1.42496243e-01f, 4.23188917e-02f, -8.48893821e-03f, -2.99393721e-02f, 1.08457245e-02f, 6.24543568e-03f,
  1.81804819e-03f, 1.45346131e-02f, 3.11946347e-02f, 2.11087801e-02f, -2.35147085e-02f, -8.81873295e-02f, -1.79974437e-02f, 4.45935270e-03f, 1.50945708e-01f, 7.41435736e-02f,
  -8.53679106e-02f, -3.24659003e-03f, -4.81112078e-02f, 6.67630583e-02f, -5.44059686e-02f, -4.31706682e-02f, 2.99418159e-02f, 2.66379602e-02f, -5.97975403e-02f, -7.42432568e-03f,
  -1.03757232e-01f, -1.65445253e-01f, 4.20204401e-02f, -3.60062681e-02f, -3.94912250e-02f, -1.05007581e-01f, -4.49658418e-03f, 1.31357685e-02f, -5.06687351e-02f, -7.10104257e-02f,
  6.34646192e-02f, 2.55464502e-02f, 1.40167875e-02f, -5.60466796e-02f, 7.20976805e-03f, -6.34617805e-02f, -2.18569972e-02f, -8.90249945e-03f, 8.49762484e-02f, 3.28808837e-02f,
  -1.60289761e-02f, -5.67451008e-02f, -9.80031211e-04f, -2.99308337e-02f, 9.44815129e-02f, 7.38184229e-02f, -4.52802591e-02f, 2.92558186e-02f, 3.75692956e-02f, 2.18134783e-02f,
  1.68840900e-01f, -7.74003044e-02f, -1.43221527e-01f, 1.56191811e-01f, 2.32741371e-01f, 1.89304888e-01f, 1.78507909e-01f, -8.54251627e-03f, -2.27633491e-02f, 1.55102968e-01f,
  -8.05371255e-02f, -1.52527615e-02f, -1.03071868e-01f, 7.99522176e-02f, -8.43305588e-02f, -2.09188089e-01f, 1.91233724e-01f, 1.35306939e-01f, -1.71856537e-01f, 6.92612454e-02f,
  -3.74347158e-02f, 8.06368515e-02f, -2.33806282e-01f, -1.44574298e-02f, 1.62964836e-01f, 2.55450830e-02f, 3.44347507e-02f, -9.05760080e-02f, 2.25291044e-01f, 6.42208159e-02f,
  -1.63482502e-02f, 1.14436736e-02f, -1.07621931e-01f, 1.28902625e-02f, 6.49536178e-02f, -4.01879102e-02f, -5.25776781e-02f, -6.81976825e-02f, 5.26465997e-02f, 1.21383987e-01f,
  9.49658677e-02f, -9.64374468e-03f, 1.47553524e-02f, -4.62003574e-02f, 4.80275415e-02f, 2.93273982e-02f, 1.07741252e-01f, 4.64850292e-02f, 2.08680741e-02f, -1.65418757e-03f,
  4.13662866e-02f, 6.78169355e-02f, 4.66638394e-02f, 1.77747622e-01f, 3.71823832e-02f, 8.34431686e-03f, 1.20472275e-02f, 2.02541240e-02f, 1.11494094e-01f, 4.83115204e-02f,
  1.23149566e-01f, -6.05488308e-02f, -1.31526306e-01f, -9.79632139e-02f, -6.07966930e-02f, -1.26618311e-01f, -9.39657837e-02f, -7.84939677e-02f, -8.46582931e-03f, -2.54798420e-02f,
  -7.92493671e-02f, -7.07417056e-02f, 7.40376562e-02f, 3.72568294e-02f, -1.14418790e-02f, -1.36336274e-02f, -3.90914716e-02f, 2.84341685e-02f, -3.90166417e-02f, 4.32313699e-03f,
  -9.77930948e-02f, -9.37071349e-03f, -5.90026553e-04f, 1.85944382e-02f, -9.40622464e-02f, -6.12164102e-02f, -1.39145106e-02f, -3.12730074e-02f, 3.59150097e-02f, 8.91579315e-02f,
  9.25985351e-02f, 5.07228300e-02f, -7.31561035e-02f, -1.82586629e-02f, -7.35099707e-03f, 8.02046387e-04f, -1.15439534e-01f, 4.55264635e-02f, 1.68638408e-01f, 1.49716288e-02f,
  1.59843430e-01f, 2.32330691e-02f, 9.61973965e-02f, 6.46065772e-02f, 2.54983027e-02f, -6.88639730e-02f, 1.11332059e-01f, -1.89365670e-02f, 1.13617197e-01f, 1.39575228e-01f,
  8.59702155e-02f, 3.19529735e-02f, 9.57178399e-02f, 1.03702962e-01f, 1.30462632e-01f, 1.52356774e-01f, -4.33917996e-03f, 1.90907717e-03f, 2.22267225e-01f, -1.30729795e-01f,
  1.08932428e-01f, -2.27855816e-01f, 1.61657870e-01f, 3.15126151e-01f, 1.10399321e-01f, -2.82068729e-01f, -2.87769809e-02f, -8.77767578e-02f, -2.04542831e-01f, -2.89088935e-01f,
  1.41978143e-02f, 2.25508496e-01f, -1.39368519e-01f, 8.87082741e-02f, -1.20896124e-03f, -1.87597334e-01f, 7.18865718e-04f, 7.05567524e-02f, 8.25719163e-02f, 1.74912766e-01f,
  1.81463927e-01f, 3.28378379e-02f, 2.83162206e-01f, 1.11907996e-01f, 1.20559447e-01f, 6.78842962e-02f, 1.74964294e-01f, 1.04421400e-01f, 1.25789031e-01f, -7.86477923e-02f,
  -1.00562707e-01f, 9.92586091e-03f, 5.43802492e-02f, -6.14112169e-02f, 8.04518722e-03f, 3.33530009e-02f, -3.91984452e-03f, -5.89563698e-02f, 7.97150061e-02f, -2.93946303e-02f,
  -7.83950314e-02f, -4.01077457e-02f, 6.42797872e-02f, -3.48642915e-02f, 5.88089041e-03f, 1.35288849e-01f, 4.51643243e-02f, 1.76755972e-02f, 2.81989053e-02f, 1.24468289e-01f,
  7.84769878e-02f, -6.01294376e-02f, 7.60477781e-02f, -1.37166576e-02f, 1.15457535e-01f, 2.78574340e-02f, 8.99668038e-02f, 9.39971358e-02f, -9.32995044e-03f, 7.41402209e-02f,
  -2.72703134e-02f, 4.41671237e-02f, 1.78237185e-02f, -2.80207396e-02f, -1.48408815e-01f, -2.14901585e-02f, -3.76541466e-02f, 1.06885731e-01f, -4.06091809e-02f, -9.26077664e-02f,
  6.14752658e-02f, 1.59808397e-01f, -6.26468100e-03f, 2.13856492e-02f, 1.30230919e-01f, -1.94526697e-03f, 1.65977571e-02f, 2.86373515e-02f, 1.17837310e-01f, 5.48403300e-02f,
  1.13931634e-01f, -1.00420646e-01f, 3.18248682e-02f, 3.40547301e-02f, -2.90213395e-02f, -6.12924322e-02f, -5.99548966e-02f, -5.01018018e-02f, 1.01683075e-02f, 1.47489369e-01f,
  -1.15658239e-01f, -1.26606777e-01f, -2.41072513e-02f, -3.63106020e-02f, 4.27646525e-02f, 2.97899097e-02f, -4.96375114e-02f, -1.50081692e-02f, -6.61226735e-02f, -3.06094252e-02f,
  -5.42793497e-02f, 1.93144660e-02f, 2.59432034e-03f, -8.15576091e-02f, -9.61528718e-02f, 7.07055628e-02f, -9.04605612e-02f, -9.05673206e-03f, -2.58465353e-02f, -1.60295833e-02f,
  -1.55352587e-02f, 2.00234866e-03f, -3.18020582e-02f, 5.21077439e-02f, 3.39857265e-02f, 4.39745113e-02f, 7.00783432e-02f, 1.02669140e-02f, 2.27558939e-03f, -1.79817118e-02f,
  8.91432241e-02f, -7.69888312e-02f, 1.78739667e-01f, 1.89839881e-02f, 1.66007504e-01f, 3.56557041e-01f, 1.90178782e-01f, -1.17743649e-01f, -7.14639574e-02f, -1.26908898e-01f,
  -2.75975000e-02f, 1.52856007e-01f, -9.33000594e-02f, -2.72464417e-02f, 1.56071350e-01f, -1.39019981e-01f, 2.32012221e-03f, 9.11808833e-02f, -1.33481622e-01f, -4.99473624e-02f,
  -9.94948968e-02f, -1.42704770e-01f, -6.45450354e-02f, -1.30186200e-01f, 1.08566411e-01f, 2.52344999e-02f, -5.22087701e-02f, 4.03601862e-02f, 1.76053420e-01f, 8.54449272e-02f,
  7.23848026e-03f, -8.04653391e-02f, -7.54532404e-03f, -5.14241457e-02f, 1.57753639e-02f, 8.32577422e-02f, 1.14612445e-01f, 2.59606782e-02f, 5.26101701e-02f, 2.35616881e-02f,
  3.55449468e-02f, -1.20474152e-01f, 9.67242196e-02f, -5.09452038e-02f, 1.47312149e-01f, 4.61121611e-02f, -3.47196758e-02f, 5.40877655e-02f, 1.22883782e-01f, 6.98610023e-02f,
  1.97113119e-02f, 7.04768002e-02f, 2.86928974e-02f, -3.13784042e-03f, 3.62344719e-02f, 1.91239174e-02f, 5.28877182e-03f, 5.67350090e-02f, 1.38802484e-01f, 8.96938592e-02f,
  4.30754274e-02f, -1.30908534e-01f, -4.06675115e-02f, -1.25389490e-02f, 1.65126491e-02f, -8.62431899e-03f, -1.91100799e-02f, -8.77753738e-03f, 1.46706581e-01f, -4.51189503e-02f,
  3.10888421e-02f, -1.83819830e-02f, -7.25535750e-02f, 5.01708910e-02f, 1.21994056e-02f, -1.30389243e-01f, -4.38848697e-02f, 6.29610848e-03f, 1.19044870e-01f, -1.61750838e-02f,
  -6.35109991e-02f, -1.78895425e-03f, 8.34989548e-02f, 6.38206378e-02f, 7.68933743e-02f, -7.48459250e-02f, -7.17290938e-02f, -3.74999410e-03f, -7.60697573e-02f, 1.16233127e-02f,
  -2.44338885e-02f, -1.31113917e-01f, -8.39339867e-02f, -4.25110720e-02f, -3.61463986e-02f, -2.21968014e-02f, -7.26608839e-03f, -2.30953767e-04f, 3.46519127e-02f, 7.10656121e-02f,
  6.50503859e-02f, -4.82349284e-02f, 1.37355909e-01f, -6.78911731e-02f, 3.35980393e-02f, 2.29015332e-02f, -2.62199175e-02f, -3.73408422e-02f, 1.37066692e-01f, 5.06044403e-02f,
  -1.50048528e-02f, -1.65375578e-03f, 1.02319312e-03f, -9.37969014e-02f, 1.72065403e-02f, 7.86131322e-02f, 3.54562588e-02f, -2.13671532e-02f, 8.90862644e-02f, -1.04314806e-02f,
  1.90294012e-01f, -8.34162682e-02f, 3.72991383e-01f, 1.50062636e-01f, -1.32415995e-01f, 2.30056350e-03f, 1.43673211e-01f, -6.51816726e-02f, 1.25821859e-01f, -2.35326320e-01f,
  -1.60013601e-01f, 2.19478309e-01f, -1.62888076e-02f, -1.78344384e-01f, 2.35163823e-01f, 1.22162275e-01f, 4.63106930e-02f, -6.47188956e-03f, 1.78208560e-01f, -1.00227762e-02f,
  -3.05240359e-02f, -2.85658777e-01f, 7.91309923e-02f, -5.75365275e-02f, -1.68442726e-01f, 5.77913709e-02f, -7.36101940e-02f, 1.34115055e-01f, -1.52605116e-01f, 4.95594926e-02f,
  -1.02344245e-01f, -4.07060124e-02f, -8.94029886e-02f, 1.28669161e-02f, -1.29720256e-01f, -7.39627853e-02f, 1.21893600e-01f, 1.38747007e-01f, 1.21704027e-01f, 1.26889683e-02f,
  -4.02970091e-02f, -2.84879189e-02f, 4.68190275e-02f, -1.21149365e-02f, -1.21826276e-01f, -2.20107235e-04f, -4.05043252e-02f, -7.81403296e-03f, 1.54108685e-02f, 1.02479756e-02f,
  1.99246462e-02f, 9.27974749e-03f, -9.97128934e-02f, 1.04272619e-01f, 6.04248084e-02f, 3.20608318e-02f, 1.20091125e-01f, 6.68465793e-02f, -5.69726191e-02f, 2.80664060e-02f,
  1.11229770e-01f, -5.00118174e-03f, 1.16794907e-01f, -1.00823268e-01f, 7.70128891e-02f, 4.65338305e-02f, 7.23039284e-02f, -1.08247325e-02f, 9.62744802e-02f, -1.00703482e-02f,
  -2.52410024e-02f, 2.36887578e-02f, -6.76902011e-02f, -5.74917309e-02f, -5.84161095e-02f, -5.35601601e-02f, 2.72546858e-02f, 6.60573542e-02f, -5.93796186e-03f, -3.27394418e-02f,
  2.71192882e-02f, -1.26855029e-02f, -8.89668614e-02f, 2.94551719e-03f, 6.67199418e-02f, 3.92124765e-02f, -3.55387293e-02f, 5.76890483e-02f, -2.77941525e-02f, 2.64498200e-02f,
  -2.17019573e-01f, -9.52970311e-02f, -2.19679344e-02f, -1.76996309e-02f, 8.00643414e-02f, -8.91624317e-02f, 4.68239337e-02f, 3.79670761e-03f, 6.26233593e-02f, 3.12249772e-02f,
  -4.36936468e-02f, -3.52924541e-02f, 4.43501472e-02f, -8.87699202e-02f, -1.92139130e-02f, 5.26541658e-02f, 2.91553810e-02f, 1.73618495e-02f, -9.01169628e-02f, -1.29523695e-01f,
  -5.21162115e-02f, 2.26577669e-02f, 2.69342796e-03f, -1.85973532e-02f, -5.14737479e-02f, -4.11435403e-03f, 8.80295932e-02f, -7.90644437e-03f, 3.49186696e-02f, -4.24327217e-02f,
  -1.61335126e-01f, 1.94991216e-01f, 2.64249206e-01f, -1.44655555e-01f, -1.97047349e-02f, -1.07912287e-01f, -1.13194317e-01f, 5.86493872e-02f, -1.76939175e-01f, -2.08191574e-01f,
  -9.65713635e-02f, 2.42742330e-01f, 1.62394032e-01f, -2.05839559e-01f, -2.78872102e-01f, 2.65265182e-02f, -2.78485864e-01f, -1.57733411e-01f, 9.14563835e-02f, -2.38315035e-02f,
  -1.42434742e-02f, -2.52393663e-01f, 2.61230558e-01f, 2.07895756e-01f, -1.22920331e-03f, 2.87964404e-01f, 4.20337655e-02f, 2.87479788e-01f, 1.58998724e-02f, 1.12937964e-01f,
  -6.67230189e-02f, -3.88697870e-02f, 1.78422984e-02f, 1.36096729e-02f, -8.33788812e-02f, -2.68037450e-02f, 1.11392349e-01f, 5.62301129e-02f, 1.92651190e-02f, 7.73427263e-02f,
  -5.96838631e-02f, 3.78982760e-02f, 3.94515917e-02f, 5.85560761e-02f, -2.96707246e-02f, 8.08267295e-02f, -8.81997570e-02f, -6.17412440e-02f, 8.98192450e-02f, 1.25226498e-01f,
  1.80285284e-03f, 2.67539900e-02f, -9.48579535e-02f, -3.22533324e-02f, -2.74761114e-03f, -4.02712934e-02f, 1.04703456e-02f, 5.91390766e-02f, 2.81901583e-02f, -1.49790104e-03f,
  -1.46286592e-01f, 5.80171980e-02f, 1.22913390e-01f, 2.03710541e-01f, 1.08045898e-01f, 7.42152333e-02f, 5.47005944e-02f, 3.05681936e-02f, 1.01706102e-01f, 3.16878259e-02f,
  4.75536659e-02f, 5.28885834e-02f, -2.25568619e-02f, 1.07611187e-01f, 9.96604841e-03f, 6.94100484e-02f, 5.21189421e-02f, 1.95976291e-02f, -5.98020665e-03f, 1.45403910e-02f,
  9.18606222e-02f, -1.93159506e-02f, 4.65668812e-02f, 2.33307071e-02f, -1.58563666e-02f, 1.57963820e-02f, -3.60120204e-03f, 1.03382617e-01f, -2.05368306e-02f, 1.28803197e-02f,
  -1.25428200e-01f, -3.99418063e-02f, -9.37747061e-02f, 3.25535126e-02f, 1.49782524e-02f, -4.77147400e-02f, 2.11339984e-02f, -5.82573675e-02f, -1.25629746e-03f, 6.56543374e-02f,
  -5.60432300e-02f, -2.78062392e-02f, 4.96743992e-02f, 6.07900172e-02f, -5.29716723e-02f, -4.70963791e-02f, -8.97179693e-02f, 6.41888082e-02f, -1.18400030e-01f, -6.08598292e-02f,
  -1.49815520e-02f, 7.38777500e-03f, -7.76916072e-02f, -4.08974290e-03f, -5.05943857e-02f, 2.00573355e-02f, 1.08795412e-01f, -4.45543006e-02f, -5.84303178e-02f, -2.90709641e-03f,
  -2.15562105e-01f, 8.94803628e-02f, -2.16326639e-02f, 2.30836645e-01f, -1.12432741e-01f, 2.52010375e-01f, 3.75001192e-01f, 1.19145162e-01f, 7.85406828e-02f, 2.46876687e-01f,
  1.45396039e-01f, 1.32536525e-02f, 2.07620822e-02f, 2.88083941e-01f, 1.85079694e-01f, 9.19812024e-02f, 3.00190002e-01f, 1.13895603e-01f, -1.55682832e-01f, 3.70568149e-02f,
  -1.18905343e-02f, 1.82685435e-01f, 1.05789982e-01f, -6.86773332e-03f, 8.21563303e-02f, -5.72683774e-02f, 9.92269143e-02f, -1.20748043e-01f, 1.82961240e-01f, 1.19727798e-01f,
  9.11424123e-03f, -5.68808652e-02f, -4.36199717e-02f, -7.15803504e-02f, 7.85699636e-02f, 3.65132280e-02f, -3.33639234e-02f, -2.10934624e-04f, 5.44879287e-02f, 1.93422046e-02f,
  -7.28347450e-02f, -7.29543269e-02f, 4.04851288e-02f, -4.44782563e-02f, -1.26225501e-01f, -8.46610442e-02f, -4.21452001e-02f, 2.06205733e-02f, 3.82751115e-02f, -6.26827553e-02f,
  3.49547039e-03f, -2.57996079e-02f, 5.39006200e-03f, 6.68909550e-02f, -1.03732599e-02f, 1.45966429e-02f, 5.62440604e-02f, -4.55108173e-02f, 1.39833046e-02f, 4.60871756e-02f,
  4.61039059e-02f, -1.17131785e-01f, 5.53033967e-03f, -2.85812262e-02f, 1.60986986e-02f, 8.79418254e-02f, -4.06142622e-02f, 2.06840392e-02f, 3.37402411e-02f, -9.14332047e-02f,
  -4.71302979e-02f, -3.08989696e-02f, 2.80186795e-02f, -3.56022306e-02f, 9.60467104e-03f, -3.32347266e-02f, 3.67186479e-02f, 6.75586611e-02f, -9.07129794e-03f, 7.55405575e-02f,
  1.08476877e-02f, -6.72814921e-02f, -7.81131089e-02f, 2.03999989e-02f, 8.83944705e-02f, 2.19174251e-02f, -2.99144853e-02f, -3.00577097e-03f, -2.69042561e-03f, 2.60254107e-02f,
  1.62618816e-01f, 1.42044902e-01f, 1.00715615e-01f, 4.07922221e-03f, 3.63131240e-02f, -3.84297408e-02f, 7.09774494e-02f, 9.27737728e-03f, 1.51999652e-01f, 6.69048680e-03f,
  -7.95273855e-02f, 1.18301786e-01f, -8.01008753e-03f, 1.56073906e-02f, 1.48019642e-02f, 5.55077679e-02f, -1.62555911e-02f, 2.76938900e-02f, 1.08236641e-01f, 4.05458659e-02f,
  4.38985527e-02f, -1.31637389e-02f, -3.16301025e-02f, 2.78531592e-02f, 3.39119583e-02f, 9.35081393e-03f, -1.40006626e-02f, -3.33552845e-02f, 1.33448904e-02f, 2.53447704e-02f,
  1.43606335e-01f, 1.48764923e-01f, 8.60873461e-02f, 2.26628706e-01f, -9.89827886e-03f, -2.10815400e-01f, -7.99133107e-02f, 2.72166610e-01f, 3.46725106e-01f, -1.63313802e-02f,
  -2.53514171e-01f, 1.11804016e-01f, -7.14698434e-02f, -8.71752203e-02f, -1.66965619e-01f, -9.56845284e-02f, -4.89585027e-02f, -3.21705006e-02f, 9.66494977e-02f, 5.39326444e-02f,
  -9.21125244e-03f, -2.85578281e-01f, -2.48588651e-01f, -4.00105678e-03f, -6.22378774e-02f, 1.69410780e-01f, -1.51547968e-01f, -8.56183246e-02f, -1.12177685e-01f, -6.76538348e-02f,
  -1.01681305e-02f, 1.26429126e-01f, 6.34150207e-02f, 7.84289390e-02f, 5.99645637e-03f, -3.87352519e-02f, -2.54362673e-02f, -1.65591627e-01f, 1.04643174e-01f, -6.23373501e-02f,
  -8.74060094e-02f, -6.54955059e-02f, 5.57737984e-02f, 2.62921248e-02f, 9.80824828e-02f, -1.14188164e-01f, 1.13551259e-01f, 4.37695011e-02f, 1.08647533e-01f, -4.64849323e-02f,
  -2.51582898e-02f, 3.14334892e-02f, 2.43350212e-02f, 3.64093520e-02f, -5.85957139e-04f, 5.94149977e-02f, -1.30113773e-02f, -5.19392677e-02f, -1.01934023e-01f, 5.46454526e-02f,
  -3.56540978e-02f, 3.80727090e-02f, -2.00119037e-02f, 4.17014398e-02f, -1.22466162e-02f, -8.96215439e-03f, 4.42556031e-02f, 6.08569644e-02f, 8.55436176e-02f, -1.30078435e-01f,
  6.07493520e-03f, 4.54103537e-02f, 6.49383739e-02f, -1.69162061e-02f, -4.97392379e-02f, 4.98433560e-02f, -7.26397783e-02f, -1.64345149e-02f, 1.29508972e-01f, 1.53238196e-02f,
  -4.46319543e-02f, 3.46290432e-02f, 1.12754377e-02f, 2.75474438e-03f, -5.16191460e-02f, -6.49840087e-02f, -1.72501430e-03f, -4.87676747e-02f, -1.45249534e-02f, -1.28045917e-01f,
  3.45921866e-03f, 8.95112455e-02f, -1.35552266e-03f, 1.06071807e-01f, -4.62406408e-03f, -5.41379154e-02f, 5.07423878e-02f, 1.61646996e-02f, 4.74424511e-02f, -6.57372549e-02f,
  4.18710858e-02f, 1.82457548e-02f, 3.60251777e-02f, -4.45238911e-02f, 2.17383113e-02f, -7.27773532e-02f, 6.68020099e-02f, 6.49227053e-02f, 3.46561112e-02f, 5.36202081e-03f,
  -6.58951029e-02f, -3.20890658e-02f, 4.02774476e-02f, -6.01838119e-02f, 3.07327975e-02f, 1.32067785e-01f, 5.02660982e-02f, 7.36443400e-02f, -7.34179094e-02f, -1.45452216e-01f,
  4.26946372e-01f, 2.17229515e-01f, 2.31501479e-02f, 1.36502177e-01f, 1.07144088e-01f, -1.82083622e-01f, -2.04547942e-01f, 1.82789788e-01f, 1.22649983e-01f, -9.37443168e-04f,
  -1.20116740e-01f, 9.04650167e-02f, -3.86494584e-02f, -4.15100493e-02f, 1.39928833e-01f, 6.24627769e-02f, 1.39826328e-01f, 3.12253889e-02f, 1.52832836e-01f, 1.81261554e-01f,
  8.89043510e-02f, 1.69056337e-02f, 4.18590270e-02f, 9.26340297e-02f, 1.27639845e-01f, 1.13422066e-01f, 4.75613773e-03f, -7.99411610e-02f, -5.79476357e-02f, -1.01211354e-01f,
  3.32811698e-02f, 6.76011220e-02f, -3.02634016e-03f, 5.52252214e-03f, 5.99743687e-02f, -9.16526765e-02f, -3.03396359e-02f, -7.87662640e-02f, -5.27120940e-02f, 3.63363884e-03f,
  2.39942013e-03f, 5.48690185e-02f, 8.74565765e-02f, -1.98909771e-02f, 5.76326400e-02f, -8.14579502e-02f, 3.94559875e-02f, -4.26876508e-02f, -1.49811022e-02f, 3.18834418e-03f,
  1.11976191e-02f, 1.23985440e-01f, 1.72593743e-02f, -1.28557766e-02f, -6.06251620e-02f, 3.67740095e-02f, -8.22907090e-02f, -5.13094291e-02f, -4.06163037e-02f, 3.71195450e-02f,
  3.12182065e-02f, -6.77637979e-02f, 1.93776228e-02f, -2.26619821e-02f, -4.94070761e-02f, -1.65601484e-02f, -6.00289479e-02f, 6.90101087e-02f, -2.70428099e-02f, -3.91426682e-02f,
  -4.17289287e-02f, -1.70787331e-02f, 8.03104788e-02f, -1.30352173e-02f, -5.47104403e-02f, 3.15978229e-02f, 9.59579125e-02f, 4.54769172e-02f, -1.28767239e-02f, -6.50775358e-02f,
  -1.34128749e-01f, 2.61066891e-02f, -4.14102264e-02f, 4.40364331e-02f, -5.59656471e-02f, -5.12322709e-02f, -1.14541709e-01f, -8.41917749e-03f, -2.80316602e-02f, -9.49461162e-02f,
  1.45345107e-01f, 2.59460956e-01f, -9.28810518e-03f, -4.85491268e-02f, 2.64765415e-02f, 5.18292841e-03f, 6.60928935e-02f, 5.52143790e-02f, -4.25678417e-02f, -4.04655114e-02f,
  6.71801716e-02f, -3.10045015e-02f, 8.04357007e-02f, -1.33373862e-04f, -4.28002998e-02f, -2.62905583e-02f, 2.79400330e-02f, -6.18883185e-02f, 2.37385873e-02f, 8.26113671e-02f,
  6.58833981e-02f, 1.68135092e-01f, -2.50604730e-02f, 2.54929941e-02f, 2.68871486e-02f, 7.69871920e-02f, 4.42096889e-02f, 2.65207402e-02f, -4.96919490e-02f, -1.08003914e-01f,
  -3.69039178e-01f, 3.54230046e-01f, 6.11721091e-02f, 4.95323837e-02f, 1.66657940e-02f, 1.98694810e-01f, 5.38782477e-02f, 1.83022290e-01f, 1.60306588e-01f, 2.27503449e-01f,
  1.01256512e-01f, -3.84771489e-02f, 1.21944681e-01f, 1.34745330e-01f, -1.87079594e-01f, 1.15425035e-01f, 1.16488017e-01f, 8.03522319e-02f, 5.19201979e-02f, 1.40026389e-02f,
  -1.07417777e-01f, 9.69931856e-02f, 1.24579202e-02f, 1.22574516e-01f, -2.02315338e-02f, -1.16906978e-01f, -9.75300595e-02f, -1.70229405e-01f, 8.40867311e-03f, 4.21247855e-02f,
  -2.77583934e-02f, 7.77518228e-02f, 6.07728912e-03f, 6.76745772e-02f, 2.64644846e-02f, 1.88190525e-03f, -1.36393785e-01f, -1.99720725e-01f, -1.42189134e-02f, -2.58070920e-02f,
  -8.73059779e-02f, -8.51971190e-03f, 5.22831529e-02f, -8.84166062e-02f, 7.26761818e-02f, 6.31864890e-02f, 5.19092083e-02f, 4.47762907e-02f, 2.12776959e-02f, 3.56153995e-02f,
  2.16294546e-02f, 1.25046968e-02f, 6.60753250e-02f, -1.47257885e-02f, -6.77779913e-02f, 1.96637977e-02f, -2.94169076e-02f, -8.02535638e-02f, -5.26003875e-02f, 4.84988391e-02f,
  -2.25399267e-02f, -8.84079956e-04f, -2.14108340e-02f, 4.93930466e-02f, 5.89211509e-02f, -2.51241890e-03f, -9.37030092e-02f, 2.22020075e-02f, 3.50109637e-02f, -2.39757709e-02f,
  4.99064699e-02f, 1.33847110e-02f, 3.68053727e-02f, -2.60243397e-02f, 5.61042083e-03f, 3.06024565e-04f, -2.35851873e-02f, -3.77039053e-02f, 3.63005064e-02f, 5.85971735e-02f,
  4.83266003e-02f, -4.05882522e-02f, 4.62073609e-02f, 8.55271742e-02f, 2.74244649e-03f, 6.17354875e-03f, -1.08681601e-02f, 3.33534591e-02f, -3.73952948e-02f, -1.14049472e-01f,
  1.50689766e-01f, 1.58593804e-01f, 6.17047921e-02f, 2.13676449e-02f, 7.65696242e-02f, -1.29717989e-02f, -3.68881151e-02f, -5.87370656e-02f, 1.33224845e-01f, 5.88413142e-02f,
  2.14629099e-02f, 7.84532353e-02f, 2.46873740e-02f, 1.87643860e-02f, -3.90655361e-02f, 2.93709151e-02f, 6.09058095e-03f, 2.12511197e-02f, 7.32268989e-02f, 3.69312912e-02f,
  4.17185277e-02f, 7.33692013e-03f, -5.39971963e-02f, 1.25648193e-02f, -2.40783617e-02f, -5.89350760e-02f, -4.22807923e-03f, -3.16915289e-02f, -1.07890420e-01f, 6.68387786e-02f,
  3.34556736e-02f, -7.28112757e-02f, -1.37010232e-01f, -7.54670277e-02f, -6.54014423e-02f, 1.10269450e-01f, 1.40869275e-01f, 5.12731001e-02f, -1.37110785e-01f, -2.69793943e-02f,
  1.15426868e-01f, -2.89401770e-01f, -1.72830448e-01f, 3.37870330e-01f, 1.65151030e-01f, 5.59899844e-02f, 1.90548182e-01f, -3.60248163e-02f, -4.59220931e-02f, 1.27418101e-01f,
  2.32015565e-01f, 3.36647272e-01f, 9.69625041e-02f, 1.06365234e-01f, 2.94343177e-02f, -5.55054955e-02f, 5.39524816e-02f, 1.46554066e-02f, 7.97805712e-02f, 3.57627012e-02f,
  1.39956981e-01f, 5.53596802e-02f, 9.37668681e-02f, 7.65082538e-02f, 4.33149487e-02f, 6.85163289e-02f, 5.98456413e-02f, 4.77638133e-02f, -4.26863432e-02f, 4.57962975e-02f,
  -9.29217860e-02f, 7.02452706e-03f, 5.78263402e-03f, -1.05990663e-01f, 1.48728201e-02f, 2.63314210e-02f, -1.38423011e-01f, -7.73442984e-02f, -3.05001754e-02f, -8.50126967e-02f,
  -6.44094348e-02f, -7.52244070e-02f, 4.41497704e-03f, -8.07933733e-02f, -1.29283428e-01f, -1.08448334e-01f, 5.48725249e-04f, -5.98140880e-02f, 1.90592352e-02f, -8.74575600e-02f,
  -5.33068515e-02f, 1.25488117e-01f, 9.86015648e-02f, 4.17185836e-02f, 1.10864118e-01f, -4.85967137e-02f, -4.36827354e-02f, -8.46329331e-02f, -4.87781763e-02f, 2.73933467e-02f,
  1.10919245e-01f, 1.43539459e-01f, 2.37453431e-02f, -4.14311923e-02f, -1.55818388e-02f, 1.44096464e-01f, 3.13037708e-02f, 1.12039903e-02f, 7.75083750e-02f, 4.54511121e-02f,
  2.12488379e-02f, 7.88728613e-03f, -1.27746060e-01f, -3.31851952e-02f, 4.47745360e-02f, -1.37718879e-02f, -1.14599600e-01f, -2.58376095e-02f, 5.95370010e-02f, -5.15489541e-02f,
  4.71766368e-02f, -4.08455217e-03f, 1.58793032e-01f, -4.33924189e-03f, -5.09872101e-03f, 1.46346509e-01f, 8.29301253e-02f, -4.00765762e-02f, -1.11948214e-01f, 8.49766433e-02f,
  -3.04192789e-02f, -1.05735129e-02f, -7.10403826e-03f, 5.30074611e-02f, 1.01571158e-02f, 1.07147954e-02f, -5.24203442e-02f, -3.01119480e-02f, 4.12547626e-02f, -1.93418469e-02f,
  -8.65487456e-02f, -6.48138672e-02f, -6.48483336e-02f, 1.08518051e-02f, -6.26438633e-02f, -1.24433100e-01f, 1.26455352e-02f, 5.69808995e-03f, -5.66742644e-02f, -1.02227636e-01f,
  -1.02558155e-02f, 3.19222480e-01f, 7.72427171e-02f, 1.17408849e-01f, 1.66317672e-01f, 1.90678641e-01f, 2.61795640e-01f, 3.15841943e-01f, 3.74878049e-01f, 3.25192586e-02f,
  -1.60683822e-02f, -1.52480714e-02f, -1.06602676e-01f, 4.04941626e-02f, -2.00163141e-01f, -1.24050416e-01f, 1.00213297e-01f, 1.53763354e-01f, 1.57480031e-01f, 4.77432162e-02f,
  -4.46598418e-02f, -1.05030946e-01f, -2.26346985e-01f, -7.36090075e-03f, -1.14894174e-02f, -1.77141652e-02f, -1.03204235e-01f, -2.92302463e-02f, 1.46875027e-04f, 6.84486553e-02f,
  9.09082964e-02f, -2.76408028e-02f, -1.19827829e-01f, 1.02689369e-02f, -2.40756106e-02f, 7.92062953e-02f, -8.58318526e-03f, -5.94842359e-02f, 4.86682504e-02f, -1.00411451e-03f,
  3.70469578e-02f, -4.36440073e-02f, 9.22064111e-02f, -2.45605297e-02f, 1.27936870e-01f, -1.02586523e-01f, 2.40593459e-02f, 1.35348305e-01f, 1.36350272e-02f, -2.22404376e-02f,
  3.58840711e-02f, 1.71797872e-02f, 2.36870293e-02f, 6.23604991e-02f, -5.54710664e-02f, 5.13142385e-02f, 4.72009294e-02f, 6.42991960e-02f, -5.27874157e-02f, 7.18007386e-02f,
  4.71383296e-02f, 5.33018447e-02f, -1.85465894e-03f, -3.53357531e-02f, -1.86826196e-02f, 4.01895726e-03f, -3.54182273e-02f, 2.68362667e-02f, 1.24087650e-02f, -1.88886747e-01f,
  -1.17553204e-01f, -2.45085917e-04f, 7.56314471e-02f, -5.04168645e-02f, -3.37170996e-02f, 7.64643168e-03f, -1.68747492e-02f, 5.56596108e-02f, 1.24971457e-01f, 1.52005237e-02f,
  -6.64155409e-02f, -1.08085319e-01f, -1.79188043e-01f, 2.68641151e-02f, 5.11471629e-02f, -4.82337624e-02f, -2.76063345e-02f, -1.09820507e-01f, -4.89828251e-02f, -1.03408396e-01f,
  5.69027886e-02f, 2.02308878e-01f, -2.37702765e-02f, -3.79787087e-02f, 2.05415133e-02f, -8.81624296e-02f, 5.97643480e-03f, 7.08729587e-03f, 1.56433016e-01f, -5.92721663e-02f,
  6.68683872e-02f, 1.99121982e-03f, 7.67731443e-02f, 3.42837460e-02f, -1.33018708e-02f, -7.07521215e-02f, -1.30381305e-02f, 1.29440740e-01f, 1.87200792e-02f, -2.40134355e-02f,
  -2.73816474e-02f, 1.92246214e-02f, 2.21443065e-02f, 4.63702343e-02f, 7.71562452e-04f, 3.08120325e-02f, 1.06031597e-01f, 3.59612666e-02f, -7.57129267e-02f, -8.25180486e-02f,
  -2.65458584e-01f, 8.74763876e-02f, 3.12108845e-02f, -3.62667926e-02f, -1.28459349e-01f, 1.05642721e-01f, 1.39492854e-01f, -1.63220003e-01f, 2.38384113e-01f, 4.76458743e-02f,
  -5.88724129e-02f, 2.88725525e-01f, 1.98132068e-01f, 8.32382292e-02f, 1.22594416e-01f, 3.12635571e-01f, 8.91383663e-02f, 1.78447843e-01f, 1.27727866e-01f, -3.32744084e-02f,
  -3.67572010e-02f, -1.78392932e-01f, -4.57183756e-02f, -2.26385623e-01f, -2.32057214e-01f, -2.51783162e-01f, -2.59955853e-01f, -1.06429756e-02f, -1.99651912e-01f, 5.69322258e-02f,
  -1.26508862e-01f, -7.95751065e-02f, -8.82537067e-02f, 4.18310519e-03f, -1.12604044e-01f, -1.24504298e-01f, 1.40619818e-02f, 9.86668169e-02f, 3.21805514e-02f, 5.79396114e-02f,
  1.04464106e-01f, -6.23567728e-03f, -2.93173697e-02f, 2.37417072e-02f, -4.44904203e-03f, 3.36576998e-02f, -1.02356076e-02f, 2.80607753e-02f, 8.88605416e-02f, 7.18235523e-02f,
  7.06781670e-02f, -2.98973825e-03f, -1.75888725e-02f, 7.84157291e-02f, 4.00670543e-02f, 5.25411740e-02f, 1.24596998e-01f, 2.27205697e-02f, 8.78697038e-02f, 2.87756994e-02f,
  -4.76832725e-02f, 4.26470954e-03f, -8.05484354e-02f, 8.75957310e-03f, 7.66126346e-03f, -3.22184302e-02f, 1.23887286e-01f, -2.67423056e-02f, -2.79776976e-02f, 2.09618546e-02f,
  2.69631594e-02f, -1.20277360e-01f, -6.87729567e-03f, -6.08091615e-02f, 8.23662132e-02f, -2.07832959e-02f, 6.33270293e-02f, -4.88347299e-02f, -1.18752517e-01f, -8.74951035e-02f,
  8.43755305e-02f, -6.09025313e-03f, -6.05008453e-02f, 3.37985605e-02f, 7.08756298e-02f, 3.51186059e-02f, 1.41372913e-02f, -1.43630309e-02f, -2.98004895e-02f, -1.87772687e-03f,
  -7.44326115e-02f, -1.06751934e-01f, -4.03116830e-03f, -5.16690165e-02f, -1.33718569e-02f, 2.68881489e-02f, -9.85127687e-03f, 5.12814932e-02f, -7.94073418e-02f, -9.37947724e-03f,
  -1.26079261e-01f, -3.01478114e-02f, -7.59822056e-02f, -1.12985969e-01f, 1.62796155e-02f, 7.13822711e-03f, 4.49719131e-02f, -9.88136604e-02f, -8.61606598e-02f, -7.13815764e-02f,
  -9.57136825e-02f, -7.81588629e-02f, 9.62216705e-02f, -4.05675285e-02f, 4.92117694e-03f, -4.82721999e-03f, -9.18427557e-02f, -8.76071453e-02f, 2.58188471e-02f, 1.52402386e-01f,
  -2.16614023e-01f, 5.39213419e-02f, -6.94906116e-02f, 4.80594859e-02f, 2.04954416e-01f, -1.68440387e-01f, -2.19554514e-01f, 2.62780130e-01f, 2.45576441e-01f, -1.37136474e-01f,
  -7.96333104e-02f, -2.62529105e-01f, 4.71507162e-02f, -1.05501577e-01f, -1.31109118e-01f, -6.41659126e-02f, -5.52555919e-02f, -6.68421090e-02f, 9.42339078e-02f, -6.65405989e-02f,
  1.28142804e-01f, -5.83407208e-02f, -4.23145667e-02f, 1.65906876e-01f, -6.61203265e-02f, 6.58948272e-02f, 9.56290532e-05f, 1.11130968e-01f, -5.85804805e-02f, 2.29372773e-02f,
  -3.67364548e-02f, 1.75731163e-02f, -1.74439289e-02f, 2.91873310e-02f, 1.98954437e-02f, 6.64072558e-02f, -8.28978512e-03f, -1.11094601e-01f, 7.69098401e-02f, 7.32063176e-03f,
  -5.05540241e-03f, -7.64982924e-02f, -3.27429697e-02f, -2.31477320e-02f, 1.16112530e-01f, -2.73252372e-02f, -2.51268800e-02f, 1.02203652e-01f, 9.74778365e-03f, -2.39964947e-02f,
  3.15043032e-02f, 3.41376923e-02f, 1.40678823e-01f, 5.75711802e-02f, -1.31202579e-01f, 6.93438128e-02f, -1.70875490e-02f, -4.19169106e-02f, 4.86896634e-02f, 1.66856479e-02f,
  4.59635966e-02f, -5.39059639e-02f, -8.73639658e-02f, 2.67602112e-02f, -4.48815860e-02f, 1.41474724e-01f, -8.91248509e-02f, -7.95178562e-02f, 6.46464806e-03f, -2.63511837e-02f,
  4.16684635e-02f, -9.09497067e-02f, 5.53490818e-02f, -5.27807102e-02f, -3.01503781e-02f, 4.28741984e-03f, -1.17058851e-01f, 1.14716493e-01f, 1.84675127e-01f, 6.38858452e-02f,
  -9.14694443e-02f, -9.27132517e-02f, -2.99677681e-02f, 6.80702552e-02f, 2.12638211e-02f, -7.14855567e-02f, -5.65398932e-02f, 2.61404738e-02f, 8.45149010e-02f, -2.03977916e-02f,
  2.30425242e-02f, -7.38233654e-03f, -7.75660155e-03f, -8.44853465e-03f, 8.82705078e-02f, -7.33982697e-02f, -4.80667986e-02f, -5.25049679e-02f, 1.36587441e-01f, -4.31003384e-02f,
  5.47421128e-02f, -6.59797490e-02f, -3.43742385e-03f, 6.83043376e-02f, 3.48206572e-02f, -6.82602525e-02f, -9.75165442e-02f, 1.57578230e-01f, 6.04331084e-02f, 1.08829411e-02f,
  -8.26132298e-02f, -3.58197689e-02f, -4.79938790e-05f, 7.19786510e-02f, -7.26810470e-02f, -1.14310179e-02f, 3.54422964e-02f, 2.29723565e-02f, 4.70627919e-02f, -2.29416490e-02f,
  -3.29143345e-01f, 2.54982829e-01f, 8.95732865e-02f, -2.51285791e-01f, 3.66684571e-02f, -1.52787045e-01f, -2.08398864e-01f, 1.69249207e-01f, -3.51879954e-01f, 9.66869965e-02f,
  -9.22567174e-02f, 9.64560658e-02f, -3.41767669e-02f, -9.90652665e-02f, -3.47885728e-01f, -1.68798685e-01f, -1.62471652e-01f, -2.26873977e-04f, -8.83402675e-02f, 2.49764528e-02f,
  -5.28143048e-02f, -1.99148618e-02f, 2.37290472e-01f, 2.18287200e-01f, 6.61360621e-02f, 1.61038831e-01f, 1.17070116e-01f, 1.55460626e-01f, 1.12756371e-01f, 6.21309020e-02f,
  -1.98219139e-02f, -4.71955463e-02f, 7.50898346e-02f, 1.99908987e-02f, -4.80509847e-02f, -1.28235221e-02f, 2.80891191e-02f, -6.48052245e-02f, -1.36082023e-01f, 4.65821438e-02f,
  4.25165407e-02f, -3.26429866e-02f, -2.51403619e-02f, 5.16199544e-02f, 2.76015187e-03f, -2.53240056e-02f, -1.68199539e-02f, -6.07220940e-02f, 3.75242531e-02f, -2.47514006e-02f,
  -1.60018820e-02f, 1.49602024e-02f, -2.32727509e-02f, 1.68207902e-02f, -5.58622032e-02f, -9.71858650e-02f, -3.34274881e-02f, 1.56885147e-01f, -6.46395748e-03f, -2.92435810e-02f,
  2.05393806e-02f, -1.49331719e-01f, 9.03679058e-03f, 5.86448163e-02f, -3.35406214e-02f, -2.16019545e-02f, -5.61774075e-02f, 1.49451531e-02f, -2.99302321e-02f, 2.92018298e-02f,
  -1.23986036e-01f, 6.07123487e-02f, -8.89776647e-02f, -2.18118764e-02f, 8.30177683e-03f, -5.03109284e-02f, -4.02328698e-03f, 6.21890612e-02f, -7.42720366e-02f, 5.90850301e-02f,
  1.85753349e-02f, -2.89227441e-02f, 7.90520459e-02f, 1.35758324e-02f, 5.63567355e-02f, -6.94203377e-02f, -3.87290455e-02f, 2.14989390e-02f, 2.14711614e-02f, 1.95161644e-02f,
  1.13648521e-02f, -9.46264248e-03f, 9.81372874e-03f, -4.28796560e-02f, -1.02760866e-02f, -1.35551589e-02f, -9.32544246e-02f, 1.18629280e-02f, -1.70051623e-02f, -4.27387469e-02f,
  9.18206498e-02f, 4.05129120e-02f, -1.70179922e-02f, 8.39836895e-02f, 5.91770629e-04f, -3.32544297e-02f, -1.25355542e-01f, 7.01689068e-03f, 7.23491833e-02f, 4.59856680e-03f,
  -4.60525416e-02f, -9.74139646e-02f, -2.86341906e-02f, -3.14839259e-02f, -1.50477529e-01f, -2.07503419e-02f, 3.16275991e-02f, -4.39428017e-02f, -1.05960350e-02f, 2.09493451e-02f,
  1.51765391e-01f, -4.21468705e-01f, 1.98183611e-01f, -1.66237831e-01f, 1.21406481e-01f, -5.69259152e-02f, -1.68261573e-01f, -5.22320680e-02f, -9.26622078e-02f, -3.67408812e-01f,
  -1.45069361e-01f, -7.18596056e-02f, -5.47369793e-02f, -3.04623157e-01f, 1.92180604e-01f, -8.96762982e-02f, -9.72336009e-02f, -7.74484798e-02f, 7.81360567e-02f, -1.19005933e-01f,
  9.46561173e-02f, -1.33502737e-01f, 1.81994617e-01f, 7.61711076e-02f, -3.57134193e-02f, 9.28941295e-02f, -6.76423460e-02f, 2.27845937e-01f, -5.76362461e-02f, 7.20011592e-02f,
  -4.72775474e-02f, 7.96635747e-02f, 9.87135246e-02f, 4.92338613e-02f, 9.18927193e-02f, 7.06833089e-04f, 7.76636377e-02f, 5.39767928e-02f, 8.85302946e-02f, -5.55524305e-02f,
  8.04764032e-02f, 8.70767748e-04f, -2.70485915e-02f, 2.02373546e-02f, 1.20585347e-02f, 1.34033905e-02f, 3.35442051e-02f, -2.01167688e-02f, 2.35630646e-02f, -6.42261739e-07f,
  6.83136582e-02f, -4.01933379e-02f, 9.14487801e-03f, -1.03558106e-02f, 1.99203175e-02f, -3.99322137e-02f, -5.60957119e-02f, 5.46945222e-02f, -6.81649745e-02f, -9.89713073e-02f,
  5.72534278e-03f, -1.23928197e-01f, -9.05538648e-02f, -3.42210308e-02f, -5.97890243e-02f, 1.07687645e-01f, -5.20770252e-02f, 5.40733524e-02f, 4.07768562e-02f, -4.49716970e-02f,
  -1.25550078e-02f, -1.54927243e-02f, 2.39463001e-02f, -8.57081413e-02f, -7.84178898e-02f, -8.63711387e-02f, -2.69458424e-02f, 2.74502859e-02f, 4.23971266e-02f, 9.56033915e-03f,
  -1.22256391e-02f, 6.67488798e-02f, -2.02840529e-02f, 1.59595273e-02f, 2.59135067e-02f, 3.78798842e-02f, -3.69086638e-02f, -4.47016694e-02f, 3.19364332e-02f, -1.79983974e-02f,
  -1.77504122e-01f, -1.98978439e-01f, 4.38020863e-02f, -2.16794293e-02f, 1.08680658e-01f, -1.10062972e-01f, -4.30069119e-02f, -7.48876110e-03f, -9.62920040e-02f, -3.98738645e-02f,
  8.48638266e-02f, -1.64869502e-02f, -4.09825053e-03f, 2.67548747e-02f, 5.88006228e-02f, -8.53293538e-02f, -5.27838916e-02f, 4.17511240e-02f, 3.52743752e-02f, 9.19696689e-03f,
  -3.48562412e-02f, -2.13384014e-02f, 1.39476061e-02f, -7.25661144e-02f, 7.05649750e-03f, 4.57787625e-02f, 2.98543517e-02f, -8.20407644e-03f, -3.74797429e-03f, -1.36243582e-01f,
  2.64685363e-01f, -2.99544543e-01f, -1.71252966e-01f, 1.11187473e-02f, 1.99162409e-01f, 2.17261061e-01f, 1.91949695e-01f, -1.00671146e-02f, -7.74791755e-04f, -1.46122172e-01f,
  1.39969513e-01f, -1.85359061e-01f, -1.45084277e-01f, 1.19696967e-01f, 2.10197195e-01f, -5.09681031e-02f, 1.34625331e-01f, 3.82386819e-02f, -7.82621130e-02f, -8.12571123e-02f,
  -8.40901956e-03f, 1.66807055e-01f, -1.28653096e-02f, 2.74535418e-02f, 6.31156191e-02f, -9.52588990e-02f, 3.44275534e-02f, -1.46163300e-01f, -2.71201432e-02f, 5.63804694e-02f,
  8.17669481e-02f, 7.70272221e-03f, 3.96569893e-02f, 1.06842434e-02f, 2.22934224e-02f, 1.83884948e-02f, -5.32533880e-03f, -5.51409237e-02f, 2.07929965e-02f, -6.85839877e-02f,
  -5.91960996e-02f, -1.76034924e-02f, -2.89067607e-02f, -7.11738169e-02f, 7.40786493e-02f, -1.15919830e-02f, -3.49539779e-02f, 6.47601634e-02f, -4.03734669e-02f, -1.73120555e-02f,
  -2.32404075e-03f, -7.89543092e-02f, -3.38456333e-02f, -8.99707526e-02f, -2.45069619e-02f, -7.01597705e-02f, -2.76620686e-02f, -2.93533709e-02f, -1.01465151e-01f, 3.94740216e-02f,
  -2.56635696e-02f, -2.81555746e-02f, 4.10973802e-02f, -8.16208646e-02f, 5.56050539e-02f, -3.62281390e-02f, -2.72087771e-02f, -2.32074987e-02f, -6.13600276e-02f, 5.77031337e-02f,
  5.29020354e-02f, 1.29171386e-01f, -3.32213268e-02f, -4.93981540e-02f, 1.20364033e-01f, -1.18776346e-02f, 1.65169649e-02f, -2.39244942e-02f, 5.46909347e-02f, 1.43355057e-01f,
  -1.17158992e-02f, 2.01107352e-03f, -7.46378005e-02f, 7.15711638e-02f, 6.70192838e-02f, -3.10964845e-02f, -1.10837795e-01f, -1.08189750e-02f, -1.12969294e-01f, -4.03983472e-03f,
  -4.19595093e-02f, -2.33998522e-01f, -3.72247696e-02f, -2.70990040e-02f, 2.29672287e-02f, 4.15317640e-02f, -6.69021755e-02f, -2.92593595e-02f, -6.23081923e-02f, 4.26325239e-02f,
  3.29380110e-03f, -5.80310859e-02f, 2.37955619e-02f, -1.12443492e-02f, -6.47734925e-02f, -8.14503729e-02f, -3.66583802e-02f, 4.45547551e-02f, 3.36310789e-02f, 3.69540341e-02f,
  -1.74136311e-02f, -3.34718339e-02f, 8.11629370e-03f, -1.58471242e-02f, 4.64693606e-02f, -3.11288312e-02f, 2.67831665e-02f, -5.63363768e-02f, -4.39904816e-02f, -8.25072378e-02f,
  2.48859629e-01f, -3.37628901e-01f, -1.49060756e-01f, -7.45834485e-02f, 2.97598690e-02f, -1.77956343e-01f, -2.51245886e-01f, -1.95680901e-01f, -1.36614874e-01f, -2.67087966e-01f,
  -2.12288633e-01f, 6.65112138e-02f, -1.96677908e-01f, -2.35808983e-01f, -9.40086767e-02f, -2.52025217e-01f, -1.45429298e-01f, -5.38864918e-02f, -4.26227897e-02f, -1.50799677e-01f,
  -1.07059844e-01f, -1.22106269e-01f, -1.02844983e-01f, -1.16132364e-01f, -1.87662557e-01f, -7.64179556e-03f, 1.66662693e-01f, -2.32484043e-01f, -2.48519098e-03f, -1.23514004e-01f,
  2.55432613e-02f, -2.76206080e-02f, 7.97378346e-02f, -3.57088111e-02f, -8.49169865e-02f, 6.61605075e-02f, 5.65959029e-02f, -3.70852426e-02f, 9.06951278e-02f, -9.08909291e-02f,
  1.17782820e-02f, 8.47859960e-03f, 7.34911766e-03f, -7.78067112e-02f, 4.08671796e-02f, 6.67231008e-02f, 1.46967871e-02f, -3.88320372e-03f, -1.01233609e-02f, 2.21107737e-03f,
  -9.48019139e-03f, -2.34360695e-02f, 6.50844872e-02f, -2.61782203e-02f, 4.78475541e-03f, 1.73012614e-02f, 8.78271181e-03f, 9.04531553e-02f, -8.08384642e-02f, 6.89244866e-02f,
  5.17539978e-02f, -4.09803763e-02f, -6.00338429e-02f, -4.53885412e-03f, -5.63658662e-02f, 5.20625152e-02f, 3.85113135e-02f, 4.36435938e-02f, -4.53770794e-02f, 1.75361652e-02f,
  1.19336337e-01f, 1.07234567e-02f, 4.74319123e-02f, 7.54358023e-02f, 5.82263544e-02f, -3.77355255e-02f, -4.01608795e-02f, -2.62658577e-02f, 7.91943222e-02f, 1.09447800e-01f,
  7.33890310e-02f, -5.94232976e-02f, -2.86731720e-02f, 2.51972061e-02f, -6.12141266e-02f, -2.28149742e-02f, 5.22169024e-02f, 3.30521800e-02f, -1.87286153e-01f, -5.12890331e-03f,
  -1.02442220e-01f, -2.37110943e-01f, -3.16557102e-02f, 3.92189883e-02f, 1.18146196e-01f, 1.91787444e-02f, 6.47577038e-03f, -9.98305529e-03f, -1.28319366e-02f, -1.16652302e-01f,
  4.54682931e-02f, -1.03820330e-02f, 1.52205182e-02f, 2.52182148e-02f, -1.13504881e-03f, 6.43413421e-03f, -2.33527906e-02f, 4.91877832e-02f, 1.80797335e-02f, 7.24070659e-03f,
  -4.60344888e-02f, -4.00982089e-02f, -1.39965222e-03f, -7.58196041e-02f, 9.16199833e-02f, 4.64828908e-02f, 1.10232174e-01f, -2.06803679e-02f, -3.09276395e-02f, 4.83821817e-02f,
  1.85652420e-01f, -1.23407684e-01f, -1.07334822e-01f, 1.18004046e-01f, -6.86884001e-02f, 2.28822157e-01f, 2.16386497e-01f, 2.95931678e-02f, 2.34349817e-01f, 5.52758276e-02f,
  1.92464903e-01f, 2.71330271e-02f, -7.15612024e-02f, 3.20398390e-01f, 3.94890100e-01f, 2.49940217e-01f, 3.58950943e-01f, 1.60420612e-01f, 1.19857684e-01f, 5.19089215e-02f,
  8.55004340e-02f, 2.29579508e-01f, -6.69914633e-02f, -1.00195501e-02f, -2.48214547e-02f, -2.38924697e-01f, -9.89756063e-02f, -1.40765101e-01f, 6.68053562e-03f, 2.41157599e-02f,
  3.14554460e-02f, 2.15442702e-02f, 1.78769901e-02f, 2.52407249e-02f, -5.58240935e-02f, -5.91061078e-02f, -1.43443644e-01f, 1.27652228e-01f, 5.84057346e-02f, 3.61038148e-02f,
  -2.14397646e-02f, 6.77839145e-02f, -2.07883287e-02f, 4.92704622e-02f, 2.63831206e-02f, 4.31676470e-02f, -4.11391184e-02f, -6.62358403e-02f, -2.71372274e-02f, 7.00075254e-02f,
  3.59849036e-02f, -1.76644903e-02f, 3.65144499e-02f, -3.04632280e-02f, 3.25681604e-02f, 9.20422084e-04f, 1.12240620e-01f, -1.32839262e-01f, 2.51447950e-02f, 1.26474336e-01f,
  6.86236005e-03f, 5.29329181e-02f, 3.95122878e-02f, 2.59161852e-02f, 9.17867348e-02f, -1.08141014e-02f, -3.18449829e-03f, -4.31634784e-02f, -4.47531752e-02f, 3.11035682e-02f,
  -2.12110467e-02f, 6.15221076e-03f, 7.86420628e-02f, -1.74055155e-02f, 5.40949404e-02f, -1.97921507e-03f, -5.43357618e-02f, -5.87934591e-02f, 1.00841802e-02f, 7.46638626e-02f,
  4.06305939e-02f, -2.41951738e-02f, -1.14780225e-01f, -3.54573689e-02f, 3.71542610e-02f, -7.55836964e-02f, -1.13260522e-01f, -3.67926583e-02f, -5.76504506e-02f, 2.92124832e-03f,
  2.84318477e-02f, 1.26973484e-02f, 3.31082307e-02f, 5.34113869e-02f, 3.77301802e-03f, 3.47104073e-02f, 9.41532031e-02f, 1.45820320e-01f, 5.29681705e-03f, 1.01367742e-01f,
  -7.31764510e-02f, -5.69485798e-02f, -2.19454784e-02f, -2.54257005e-02f, 1.40858954e-02f, 5.32172769e-02f, 3.06945164e-02f, -1.71816453e-01f, -4.48804647e-02f, -1.04885325e-01f,
  -5.68249114e-02f, -3.69358286e-02f, 8.78991187e-02f, -4.01210636e-02f, 2.68419273e-02f, -1.60728201e-01f, 9.80233923e-02f, -6.51410520e-02f, 1.34917954e-02f, 1.31752656e-03f,
  3.19075853e-01f, -2.15684459e-01f, -9.85481143e-02f, -1.12263560e-01f, 3.01535606e-01f, 2.39745185e-01f, 1.25973210e-01f, 2.00803265e-01f, 2.12376248e-02f, -2.93323427e-01f,
  1.08066034e-02f, -2.06066117e-01f, -8.10707510e-02f, 3.49964425e-02f, 3.68448257e-01f, -4.24442887e-02f, -9.43699554e-02f, -7.23362118e-02f, 1.66678894e-02f, 3.72025184e-02f,
  1.09158412e-01f, 1.28815427e-01f, 2.61158887e-02f, 2.44274875e-03f, 1.85856372e-02f, -1.82216406e-01f, -3.94340493e-02f, -6.19683936e-02f, -1.34855941e-01f, 5.90452086e-03f,
  2.18308698e-02f, -3.86168472e-02f, 4.58648019e-02f, -2.23076027e-02f, 4.45148796e-02f, -4.02496457e-02f, -3.89974192e-02f, -1.34677678e-01f, 3.90002877e-02f, -3.38514857e-02f,
  -1.07608557e-01f, -8.64477828e-02f, 2.09889244e-02f, -8.84811953e-02f, 1.20523810e-01f, 4.56354693e-02f, -9.46059376e-02f, 7.38566816e-02f, 1.90694276e-02f, 9.67304185e-02f,
  5.16334660e-02f, 6.12744093e-02f, 4.18212488e-02f, -9.56043229e-02f, -7.10555241e-02f, -1.58568799e-01f, -9.23814029e-02f, -9.89088193e-02f, -3.60843390e-02f, -6.12998893e-03f,
  5.01577370e-02f, 9.88487503e-04f, 2.35542040e-02f, -1.27478130e-02f, 3.73742133e-02f, 5.57095930e-02f, -4.33749631e-02f, -6.82199048e-03f, -4.35130037e-02f, 1.10380188e-01f,
  -8.16964135e-02f, 2.60062087e-02f, -1.40704690e-02f, 7.66578466e-02f, 4.57315855e-02f, -5.32637574e-02f, -1.10438041e-01f, -4.31311964e-05f, 1.47145493e-02f, 1.40290335e-01f,
  -1.42139951e-02f, -2.26244051e-02f, 4.27567121e-03f, -3.37268673e-02f, 5.65075725e-02f, -1.02854744e-02f, -9.31147039e-02f, 4.32501324e-02f, -6.63427636e-02f, -4.23977710e-02f,
  2.15423834e-02f, -2.28419393e-01f, -4.91769947e-02f, -9.11318958e-02f, -2.43711239e-03f, -8.80772918e-02f, -2.64640842e-02f, -7.25786835e-02f, 2.65465379e-02f, 1.74788181e-02f,
  -2.34120637e-02f, -9.63619053e-02f, 8.49604458e-02f, -7.53691643e-02f, 4.84253243e-02f, -3.20305265e-02f, -2.01487735e-01f, 1.68517921e-02f, -3.52915749e-02f, 5.22213988e-02f,
  -1.27344280e-02f, -2.44145747e-02f, -1.03735015e-01f, 1.23641165e-02f, -4.92924787e-02f, -3.14809754e-02f, 3.35659645e-02f, -9.27354395e-02f, 1.00713558e-01f, -3.75497900e-02f,
  -2.43362874e-01f, -1.49884775e-01f, 1.61016777e-01f, 8.63954350e-02f, 1.56684175e-01f, -1.26198232e-01f, 3.78149264e-02f, 6.50561824e-02f, -5.50862178e-02f, -1.76831499e-01f,
  1.38173178e-01f, -1.09431341e-01f, 9.87830088e-02f, 1.37482151e-01f, 2.15285216e-02f, -8.51180032e-03f, -3.61506268e-02f, -9.70607996e-02f, -6.37421161e-02f, 2.95989029e-02f,
  1.10340506e-01f, 1.49856791e-01f, 3.38736266e-01f, 8.43188167e-02f, 1.34390235e-01f, -5.11261960e-03f, 1.85056001e-01f, 8.02700669e-02f, 2.67092362e-02f, -7.92442784e-02f,
  -5.09914868e-02f, 8.31230208e-02f, 9.26367752e-03f, -9.09620821e-02f, 2.20221654e-02f, -8.33631121e-03f, 1.23680420e-02f, -4.73326910e-03f, 1.00505255e-01f, 1.55732594e-02f,
  -3.91404293e-02f, -2.95823719e-02f, 2.52853701e-04f, -1.47236092e-03f, -1.44632617e-02f, 2.54119392e-02f, 4.04603630e-02f, -2.14325991e-02f, 8.41818675e-02f, 5.09614386e-02f,
  2.44209796e-01f, 1.53403878e-02f, 9.87561941e-02f, -2.67192237e-02f, -4.54601608e-02f, -4.54597212e-02f, -1.11446483e-02f, 4.21899147e-02f, 8.05937201e-02f, -4.00687195e-02f,
  -1.47780487e-02f, 2.83998027e-02f, 1.19970270e-01f, 2.73348019e-03f, 5.45314997e-02f, 5.85920699e-02f, 2.24217642e-02f, -2.76081264e-02f, -3.05130947e-02f, -2.04918366e-02f,
  -1.12139173e-01f, -4.99301665e-02f, 8.15791916e-03f, 1.25492457e-02f, 3.36165912e-02f, -9.88889560e-02f, -5.95551776e-03f, 1.05556197e-01f, -8.35232809e-03f, 8.41278117e-03f,
  1.05028011e-01f, -9.55947116e-02f, -8.34102705e-02f, 4.03938815e-02f, -4.28091995e-02f, 1.66131444e-02f, 8.30813348e-02f, 3.04650515e-02f, 4.63995114e-02f, 1.02005847e-01f,
  -1.99131563e-01f, 9.30103380e-03f, -1.70669183e-02f, -1.09553836e-01f, 1.99012505e-03f, -4.62568626e-02f, 4.29079458e-02f, -1.06741168e-01f, -2.24522389e-02f, 8.82338807e-02f,
  -1.93274524e-02f, -1.68578476e-02f, -9.90048423e-02f, -1.57519104e-03f, 5.35534546e-02f, -8.74256063e-03f, -3.49453650e-02f, -3.86845618e-02f, 7.13036805e-02f, -4.07019593e-02f,
  8.85906816e-02f, -2.03812942e-02f, -3.41657400e-02f, 3.74077354e-03f, -3.76838483e-02f, -4.62811850e-02f, -7.97930136e-02f, -8.74976441e-03f, 1.27213940e-01f, -4.53943945e-02f,
  3.48396599e-01f, 9.35682505e-02f, 2.39231139e-01f, 2.34674960e-02f, 1.07147902e-01f, -6.50194436e-02f, 1.94099844e-02f, 4.85011898e-02f, 2.28911668e-01f, -1.79370478e-01f,
  -1.65771112e-01f, -4.69107628e-02f, 1.71921834e-01f, -3.18968445e-01f, -8.28196108e-02f, 1.34830132e-01f, -1.53388605e-01f, -7.66289383e-02f, 7.09166229e-02f, -2.08381917e-02f,
  -2.17306688e-02f, -3.29335362e-01f, -7.03326389e-02f, -1.92763895e-01f, 7.20772892e-03f, 1.59754127e-01f, -2.66283274e-01f, 8.74837190e-02f, -2.90505558e-01f, -8.46774206e-02f,
  -1.95322838e-03f, 6.74558952e-02f, 6.79167062e-02f, -8.80886859e-04f, 8.64236429e-02f, 6.85774907e-02f, -3.14418972e-02f, 5.04673691e-03f, 1.48351133e-01f, -2.29414366e-02f,
  1.15249313e-01f, 3.48188393e-02f, -1.16631007e-02f, -5.75051084e-02f, 4.65563908e-02f, -8.02799910e-02f, -1.49024306e-02f, -1.77977085e-02f, -7.90923238e-02f, -5.10284603e-02f,
  -1.93469133e-02f, 7.39905685e-02f, 4.12505232e-02f, 6.94724498e-03f, 3.78570147e-02f, 6.52640015e-02f, -3.13728340e-02f, -5.20601124e-03f, 5.26707545e-02f, 1.89653132e-02f,
  1.21351220e-01f, 1.04496945e-02f, 1.63048990e-02f, -3.10843792e-02f, 4.01393212e-02f, -7.52768889e-02f, -4.50816602e-02f, -6.79739490e-02f, 1.26543224e-01f, -6.84908703e-02f,
  -2.31461562e-02f, -1.25618828e-02f, 4.16052863e-02f, 4.58783954e-02f, -8.86066854e-02f, 3.05767916e-02f, 4.59806398e-02f, -6.70208111e-02f, 2.73215435e-02f, -7.23341554e-02f,
  -5.97578548e-02f, 1.85185391e-02f, 9.89856347e-02f, -2.51857825e-02f, -1.76168010e-02f, 5.33951679e-03f, -5.11306860e-02f, 2.96111945e-02f, 3.80638056e-03f, 1.42536694e-02f,
  -1.48866981e-01f, -6.04631333e-03f, -1.17940319e-04f, -4.44408320e-02f, 2.20364258e-02f, -8.94409325e-03f, 1.02930360e-01f, 4.35242653e-02f, 5.28324358e-02f, -2.65200296e-03f,
  6.76245317e-02f, 5.66944107e-03f, -3.23274992e-02f, -5.09476960e-02f, 1.64958704e-02f, -6.35129362e-02f, -1.31311864e-02f, 2.28919163e-02f, -1.61070358e-02f, -9.74031761e-02f,
  -2.43631192e-02f, 8.51347521e-02f, 1.71457678e-02f, 6.19070120e-02f, -4.26889658e-02f, 5.14369830e-02f, -2.24291235e-02f, 6.77289516e-02f, -7.90260211e-02f, -8.48897919e-03f,
  2.68022329e-01f, 1.81880563e-01f, 5.37816882e-02f, 1.71069860e-01f, 1.01140672e-02f, 2.38920301e-02f, 6.53314292e-02f, -1.09104283e-01f, 1.00350482e-02f, -5.48101962e-02f,
  -8.99913236e-02f, 1.05853796e-01f, -9.37943459e-02f, 7.20090643e-02f, 9.51838270e-02f, -1.81450725e-01f, 9.93450955e-02f, 9.82738882e-02f, 3.70038152e-02f, 1.40839249e-01f,
  7.34887794e-02f, -1.84631255e-03f, -1.54547915e-01f, -6.59357011e-02f, 1.88117549e-01f, 1.11844718e-01f, 1.35006502e-01f, 4.44742814e-02f, 1.94609120e-01f, -2.56416248e-03f,
  1.01771161e-01f, 2.23175913e-01f, -9.94901871e-04f, 1.16996989e-01f, -4.56816442e-02f, 2.34660301e-02f, -8.72091427e-02f, -3.10953874e-02f, 6.06709020e-03f, -2.55770162e-02f,
  -1.32367745e-01f, -9.49439332e-02f, -1.19169895e-02f, -2.54403669e-02f, 9.64930281e-03f, 1.62355959e-01f, 7.47895017e-02f, 1.07506812e-01f, 3.86475469e-03f, 5.34295700e-02f,
  1.98615971e-03f, 1.55905336e-02f, 6.82075508e-03f, 1.42042011e-01f, 6.07935479e-03f, 8.86856988e-02f, 1.90897286e-02f, 1.09171212e-01f, 1.46955490e-01f, 5.89088611e-02f,
  -6.70829564e-02f, -5.29262014e-02f, -8.46970603e-02f, 8.40479136e-02f, 9.47992280e-02f, -4.99248430e-02f, 4.78817441e-04f, -4.42136116e-02f, -1.24452142e-02f, 2.35357024e-02f,
  2.38308706e-03f, 1.01116590e-01f, -8.42649117e-02f, 1.66180596e-01f, -1.16989121e-01f, -8.39037076e-03f, 9.06671956e-02f, 4.94874753e-02f, -3.67412679e-02f, -4.55958880e-02f,
  -4.21274155e-02f, 1.07813692e-02f, 1.76645499e-02f, -8.00266042e-02f, -1.35825295e-02f, -8.24337080e-02f, -1.02606669e-01f, 9.81819779e-02f, 8.91207308e-02f, 1.73169777e-01f,
  2.81144738e-01f, 3.99310380e-01f, 3.34116863e-03f, 1.81005597e-01f, 2.11506593e-03f, 1.41241834e-01f, 9.41770226e-02f, -7.43020177e-02f, 1.66892782e-01f, 5.82006201e-02f,
  3.39063853e-02f, -5.18793128e-02f, 5.60396239e-02f, 2.04217080e-02f, -1.22995749e-01f, 2.73164324e-02f, 4.03254526e-03f, 1.48905009e-01f, 1.18028790e-01f, 1.47863794e-02f,
  1.22485727e-01f, 2.03075279e-02f, -1.53874785e-01f, 1.73013024e-02f, -1.37813613e-01f, 5.48604093e-02f, 4.68675382e-02f, 8.59232023e-02f, 2.20434144e-02f, -6.66203424e-02f,
  3.55566549e-03f, -1.38258636e-01f, -1.03558950e-01f, -2.93786645e-01f, 5.90534471e-02f, -2.40596049e-02f, -7.51280859e-02f, -2.83874478e-02f, -2.24672988e-01f, -4.35258262e-02f,
  7.49646202e-02f, -4.30625081e-02f, -9.05446485e-02f, -1.54421881e-01f, -2.08060831e-01f, -1.14642136e-01f, -2.50836790e-01f, 6.90626120e-03f, -1.59697384e-01f, -1.78605523e-02f,
  -2.92414188e-01f, -1.60752386e-01f, -2.23113373e-01f, 2.59264149e-02f, 8.82441923e-02f, -2.90589295e-02f, 1.42213210e-01f, 9.66385752e-02f, 7.63754845e-02f, 1.45580426e-01f,
  1.23314589e-01f, -6.80823177e-02f, -1.09602615e-01f, -2.04144535e-03f, 7.97862336e-02f, 3.86332124e-02f, 6.44614249e-02f, 4.24242280e-02f, 5.03128469e-02f, 6.44266382e-02f,
  -2.65014730e-02f, -7.48642087e-02f, -3.39280069e-02f, -6.25291467e-02f, -4.77699339e-02f, -1.61473766e-01f, 1.70678142e-02f, -6.47747964e-02f, -2.89064460e-02f, -9.86105502e-02f,
  2.12080730e-03f, 1.06219374e-01f, -2.63369400e-02f, 5.53949848e-02f, 4.03003320e-02f, 4.73200604e-02f, -5.37184626e-02f, 5.56799583e-02f, 1.12418950e-01f, -1.22066088e-01f,
  -4.95985262e-02f, -3.98931876e-02f, -3.65605354e-02f, -8.62998888e-02f, -2.73881275e-02f, 7.54110515e-02f, -4.91424464e-02f, 1.37290090e-01f, 4.87457961e-02f, -2.29411181e-02f,
  7.13087842e-02f, -1.27870739e-01f, -6.78799674e-02f, -3.62896025e-02f, -8.81118253e-02f, 2.43820921e-02f, 1.26400262e-01f, 1.75094917e-01f, -1.11293606e-01f, 1.21134534e-01f,
  -1.55342985e-02f, -4.16062661e-02f, -2.50091366e-02f, 2.12499991e-01f, 8.87795240e-02f, -1.85978934e-01f, -1.68202728e-01f, -7.91051015e-02f, 8.46326053e-02f, -1.33048426e-02f,
  2.45686874e-01f, 8.67681950e-02f, -7.23147169e-02f, 1.26631990e-01f, 3.47182490e-02f, 3.69096063e-02f, -8.51058885e-02f, 7.74983615e-02f, 4.68317457e-02f, 1.23049982e-01f,
  6.68068081e-02f, 7.88459256e-02f, 9.82272401e-02f, -7.01810047e-02f, 1.59252267e-02f, -6.45633936e-02f, 2.17598993e-02f, -5.63171133e-02f, 1.11753702e-01f, 1.13192566e-01f,
  9.10290554e-02f, 2.22634137e-01f, -5.78859560e-02f, -2.02367753e-02f, 1.06551133e-01f, 1.48286626e-01f, -2.95238923e-02f, -1.11666191e-02f, 7.51922131e-02f, -5.33446483e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.96465699e-02f, -1.81303427e-01f, 1.45861832e-02f, 1.18432812e-01f, -6.36350783e-03f, -3.26613039e-01f, -4.25745010e-01f, -9.68182683e-02f, -2.19603982e-02f, -2.11632505e-01f,
  -2.20706597e-01f, 8.49189684e-02f, -2.77286440e-01f, 9.17694196e-02f, 2.56604910e-01f, -1.19160257e-01f, 1.21164694e-01f, 1.32727753e-02f, 4.16493490e-02f, -5.02313934e-02f,
  1.51737034e-01f, 6.54219612e-02f, 1.65027633e-01f, 1.36657193e-01f, -1.70130193e-01f, 1.39234915e-01f, 2.16463089e-01f, -2.00832803e-02f, 2.62053758e-01f, 7.23797902e-02f,
  2.76236720e-02f, 8.76583681e-02f, -3.06445025e-02f, 2.46091224e-02f, -1.83461178e-02f, -3.07246801e-02f, -1.41343437e-02f, -1.59515645e-02f, 1.32273391e-01f, -6.59659505e-02f,
  -4.98096109e-04f, 8.69915262e-02f, 7.01386631e-02f, 3.61846201e-02f, -5.58539741e-02f, 9.20237526e-02f, 8.31099078e-02f, 1.23915402e-03f, 9.65208709e-02f, -3.02601419e-02f,
  -4.91229221e-02f, 1.36859985e-02f, 1.09350560e-02f, 9.10519063e-02f, -6.18447131e-03f, -5.93679324e-02f, 4.98870611e-02f, -4.65937145e-02f, -3.85098113e-03f, 4.94716838e-02f,
  5.42050079e-02f, -1.27326809e-02f, -1.29553244e-01f, -1.65161770e-02f, 5.83716668e-03f, 5.40035143e-02f, 8.57408792e-02f, -8.65897257e-03f, -3.04566473e-02f, -1.86488088e-02f,
  1.10313040e-03f, 7.46807270e-03f, -4.63047903e-03f, -1.03867762e-01f, 1.06245484e-02f, 2.98922248e-02f, 4.25864421e-02f, -1.50543433e-02f, -7.16958987e-03f, 2.02893950e-02f,
  4.17949595e-02f, -3.62821333e-02f, -1.93688981e-02f, 4.69732992e-02f, -9.28210281e-03f, -1.60309821e-02f, 1.48702348e-02f, -1.15726353e-03f, -4.65603210e-02f, -2.52923518e-02f,
  2.46466100e-02f, 2.45314855e-02f, -5.15970886e-02f, 5.01095168e-02f, 7.28327632e-02f, -2.60038320e-02f, 6.26554117e-02f, -3.98763083e-02f, 6.92638084e-02f, -7.74056539e-02f,
  4.98067848e-02f, 3.03596705e-02f, 3.11257392e-02f, 2.53059939e-02f, 1.76780093e-02f, -8.63212049e-02f, -5.54089397e-02f, 8.46436918e-02f, 1.19247906e-01f, 1.20059110e-01f,
  -2.50752624e-02f, -1.30051792e-01f, 1.27055449e-02f, -1.05657496e-01f, -2.38188840e-02f, -3.52884419e-02f, 1.06534949e-02f, -2.32864674e-02f, 9.47406963e-02f, 1.30186090e-02f,
  -4.59893197e-01f, 4.14140254e-01f, 3.54633242e-01f, -2.21580222e-01f, -2.60946825e-02f, 2.18733177e-01f, 1.48069365e-02f, 2.64416933e-01f, 6.03027120e-02f, 1.79496482e-02f,
  -1.10818006e-01f, 6.31151646e-02f, 4.00260314e-02f, 1.89140085e-02f, 8.59634299e-03f, 3.87666821e-02f, 4.17682789e-02f, -8.06728452e-02f, -4.98885568e-03f, -1.08190469e-01f,
  -1.58693045e-02f, -1.20839886e-01f, -2.20299233e-02f, -5.62579371e-03f, 5.50199673e-02f, -8.97796731e-03f, -2.26245761e-01f, 3.96185853e-02f, -5.41777676e-03f, 2.98882015e-02f,
  7.09022488e-03f, -1.22238696e-01f, 1.46354437e-01f, 1.41048163e-01f, 7.02539384e-02f, 2.69174594e-02f, -2.58173738e-02f, -9.94785596e-03f, -4.79482189e-02f, -2.87656710e-02f,
  3.29487734e-02f, 9.34970658e-03f, -3.63445505e-02f, -1.47010330e-02f, 1.23122055e-02f, 5.14041297e-02f, 1.16272226e-01f, 4.27057333e-02f, 8.73638391e-02f, 2.62506064e-02f,
  1.18110858e-01f, 1.34157866e-01f, 7.85344765e-02f, -8.32151398e-02f, 6.94357441e-04f, 6.85770288e-02f, -5.88833261e-03f, -8.54171589e-02f, 1.57436181e-03f, -5.30466298e-03f,
  1.36935815e-01f, -1.25793412e-01f, 5.43779992e-02f, 3.78957391e-02f, -4.76142857e-03f, 3.76879536e-02f, 1.18482644e-02f, -1.37950573e-02f, 1.03582464e-01f, -6.31612241e-02f,
  -3.95412557e-02f, 5.89359291e-02f, -2.06065495e-02f, 1.26190102e-02f, -5.61897978e-02f, -2.20536273e-02f, 9.87543315e-02f, 1.33748904e-01f, -5.49921691e-02f, -4.75073010e-02f,
  -6.20251596e-02f, 4.26412188e-02f, -9.81031433e-02f, -1.08437784e-01f, 8.15798864e-02f, 1.49542727e-02f, -2.01196223e-02f, 1.35850087e-02f, -7.78439119e-02f, -9.50960740e-02f,
  -1.13302551e-01f, -2.08626300e-01f, 9.71754789e-02f, 4.43818644e-02f, -1.60977654e-02f, -2.14205030e-02f, 3.12251579e-02f, 5.25967404e-02f, 7.70045519e-02f, -7.38911405e-02f,
  2.80234404e-02f, -3.14635821e-02f, -4.13501635e-02f, -1.70431156e-02f, 1.26495464e-02f, 2.33343169e-02f, -3.79770137e-02f, -1.05709322e-01f, -3.49181518e-02f, 4.69615906e-02f,
  7.89529458e-03f, -9.17972103e-02f, -2.67680995e-02f, -8.90680328e-02f, 1.23533867e-02f, 2.41290983e-02f, -1.78917423e-01f, 1.20520435e-01f, -1.21815845e-01f, -1.14430860e-01f,
  -7.59835094e-02f, 4.05875333e-02f, 1.22085422e-01f, 2.75559843e-01f, -2.28544474e-02f, -2.40218714e-01f, -2.53024846e-01f, 3.24825235e-02f, -2.64840890e-02f, -7.49731809e-02f,
  5.11184782e-02f, 3.93224088e-03f, -1.48918271e-01f, 1.73112497e-01f, 2.87826926e-01f, -1.42934486e-01f, 1.85925066e-01f, -2.68038884e-02f, 5.33009171e-02f, 1.66393399e-01f,
  2.86594957e-01f, 1.70802027e-01f, 1.87625676e-01f, 1.50511920e-01f, -9.77241993e-02f, 7.65010938e-02f, 1.72554702e-01f, 3.22181694e-02f, 2.44758889e-01f, 1.05436221e-02f,
  -1.73463956e-01f, 6.67769313e-02f, 4.47564721e-02f, -8.15150961e-02f, 4.52232324e-02f, -6.16277233e-02f, -7.27598369e-02f, 6.56928285e-04f, 8.05042963e-03f, 1.45547641e-02f,
  -4.77075167e-02f, 4.76207398e-02f, 2.44346578e-02f, 2.66283918e-02f, -1.47750974e-01f, 3.84254940e-02f, -4.62647863e-02f, -1.04352362e-01f, -1.29477736e-02f, 6.02214271e-03f,
  7.75412470e-02f, -6.38437197e-02f, 2.93817073e-02f, 4.68368689e-03f, 7.82606825e-02f, -7.67067214e-03f, 4.61725285e-03f, 2.27059312e-02f, 8.21187627e-03f, 8.99491012e-02f,
  -1.10808507e-01f, 9.97318849e-02f, 2.74027567e-02f, 4.72311378e-02f, 1.12511002e-01f, 4.80242819e-02f, 6.27949461e-02f, -3.41380085e-03f, 6.61135744e-03f, 1.77161209e-02f,
  6.94150552e-02f, 9.57107730e-03f, -4.61837240e-02f, -3.77253816e-02f, 1.16267458e-01f, 7.49472482e-03f, -1.09849460e-01f, -1.31322853e-02f, 7.06671178e-02f, -3.43593769e-02f,
  -2.66629942e-02f, -1.11330114e-02f, -2.18318980e-02f, -1.27975866e-01f, 1.22669069e-02f, -1.24144303e-02f, -1.96964499e-02f, 9.41325154e-04f, -2.85810865e-02f, 4.92878631e-02f,
  -3.63351265e-03f, 2.61336446e-01f, -2.85824854e-02f, -9.00999829e-03f, 5.21662161e-02f, 1.17947958e-01f, -1.39161935e-02f, 1.13393907e-02f, -1.10577866e-02f, 1.52304443e-02f,
  -4.36759330e-02f, -1.26516044e-01f, -5.86182158e-03f, -1.12112226e-04f, -1.91946290e-02f, 3.55483666e-02f, 1.15233206e-03f, -1.53158121e-02f, 8.64283070e-02f, 6.81293458e-02f,
  -1.32203931e-02f, -1.49120584e-01f, 6.57194406e-02f, -9.17771161e-02f, 7.91654282e-04f, -8.98629203e-02f, -3.10389628e-03f, -7.75159299e-02f, 8.01122114e-02f, 2.89778784e-02f,
  -2.69713730e-01f, 5.88463210e-02f, -2.25458905e-01f, -8.92656222e-02f, 2.21004561e-01f, -2.57373840e-01f, 4.42429562e-04f, 2.56845132e-02f, -6.61158189e-02f, 3.12901765e-01f,
  -1.42333712e-02f, -2.94254813e-02f, -1.10577820e-02f, -3.29066932e-01f, -5.31249523e-01f, -3.82529318e-01f, -2.84231812e-01f, -1.01326026e-01f, -5.35264611e-02f, -1.49974227e-02f,
  -1.36497751e-01f, 3.61592919e-02f, -2.31647193e-01f, 1.94540352e-01f, 5.13762608e-02f, 2.03982785e-01f, 2.28362381e-01f, 1.52546450e-01f, 2.30074655e-02f, -1.05569921e-02f,
  -2.02781364e-01f, -8.77730548e-02f, 5.07058576e-02f, -5.50239906e-02f, -7.11324159e-03f, 1.41856819e-02f, 7.18474984e-02f, 3.73931676e-02f, -2.14038938e-02f, -2.23593451e-02f,
  7.18130395e-02f, 8.37739334e-02f, 1.64594268e-03f, 3.45232151e-02f, 1.76284127e-02f, -2.68252324e-02f, -4.50353101e-02f, -1.29095521e-02f, -7.51020983e-02f, -7.18460754e-02f,
  -1.97783887e-01f, -2.13294011e-02f, 7.53154010e-02f, 8.91429335e-02f, 1.71776693e-02f, -2.72343438e-02f, -1.01880021e-01f, 1.11202560e-01f, -7.92068169e-02f, -3.85288559e-02f,
  1.99503135e-02f, 1.26514614e-01f, -6.78020492e-02f, -8.80651698e-02f, -2.89105196e-02f, 7.63673037e-02f, -3.17970365e-02f, -2.25961637e-02f, 5.48846945e-02f, 2.79280003e-02f,
  -3.42412554e-02f, 1.69940051e-02f, -7.25689530e-02f, -1.16838636e-02f, 2.24509295e-02f, -4.23857942e-02f, -2.16660518e-02f, -4.74068262e-02f, -1.60146262e-02f, -3.86688262e-02f,
  3.29940021e-02f, -2.39150152e-02f, 1.44820975e-03f, -9.44698304e-02f, -1.13740005e-01f, 1.06027767e-01f, 1.54825756e-02f, 7.60324448e-02f, 5.89855053e-02f, 1.13613732e-01f,
  2.27480242e-03f, 1.18895575e-01f, 3.01097631e-02f, 1.22624002e-02f, 2.50671394e-02f, 8.35406184e-02f, -2.37689540e-02f, 2.22756471e-02f, 1.10927857e-02f, 1.32213449e-02f,
  1.40663117e-01f, 7.15485960e-02f, 8.85150582e-02f, -1.38430282e-01f, 1.71748176e-03f, 9.13001224e-02f, 7.19392523e-02f, 9.29981321e-02f, 8.66781846e-02f, 1.44521026e-02f,
  4.43301210e-03f, 4.58841324e-02f, 3.70910838e-02f, 9.09680799e-02f, -8.67525674e-03f, 1.05634384e-01f, 4.61496040e-02f, -9.85198561e-03f, 8.23468938e-02f, 7.58475289e-02f,
  2.80279994e-01f, -3.34689021e-01f, 1.77986901e-02f, 2.67498881e-01f, 3.12688500e-01f, -5.40992478e-03f, 1.06699847e-01f, -6.24654442e-02f, 1.95049211e-01f, -3.90366256e-01f,
  -1.61981992e-02f, -1.78596497e-01f, -1.74614713e-01f, 5.92699759e-02f, 1.75937817e-01f, -1.03245176e-01f, 5.72200678e-02f, -7.46039450e-02f, 1.11285903e-01f, -3.49375419e-02f,
  1.54802859e-01f, 6.39486834e-02f, 1.00631639e-01f, -1.05393631e-02f, 9.82145891e-02f, -3.59920636e-02f, 4.71932143e-02f, -8.23179930e-02f, -8.42140093e-02f, 2.94278730e-02f,
  6.51643202e-02f, 3.98976579e-02f, 1.28685504e-01f, -1.03918582e-01f, -1.56142963e-02f, -3.84316593e-03f, -1.61253717e-02f, 6.66581001e-03f, 1.21866405e-01f, -5.78165613e-02f,
  3.66707146e-02f, 9.54664499e-03f, -2.35932563e-02f, 6.12159893e-02f, 7.31248781e-02f, 1.68338586e-02f, 1.62378643e-02f, 9.65848938e-02f, 2.32678205e-02f, -5.99086769e-02f,
  5.64747192e-02f, -2.90958341e-02f, 1.22682594e-01f, -1.17826998e-01f, -5.63993789e-02f, 2.59975456e-02f, -6.08055554e-02f, -6.10485487e-02f, -4.00604047e-02f, 2.48367414e-02f,
  -2.48883925e-02f, -5.41494824e-02f, -2.08088327e-02f, -1.77813079e-02f, -1.42454514e-02f, 6.41425028e-02f, 6.97166985e-03f, -5.90845197e-02f, -2.70579290e-02f, 6.91998051e-03f,
  -3.94535810e-02f, 3.64934467e-02f, 6.39966279e-02f, 5.45014106e-02f, -1.61173232e-02f, 1.27805639e-02f, 4.42621894e-02f, -9.31737050e-02f, 6.01976775e-02f, 8.84782225e-02f,
  -6.05502874e-02f, 2.59855948e-02f, -5.30753285e-02f, 2.11333707e-02f, 6.41924366e-02f, -6.65453747e-02f, -3.83186452e-02f, -3.57406661e-02f, 9.27762315e-02f, -4.18984853e-02f,
  -6.18810579e-02f, -3.79683822e-01f, -1.74742714e-02f, -4.79007810e-02f, 3.17606851e-02f, -3.02778780e-02f, 2.60269511e-02f, -1.30462706e-01f, -5.42173795e-02f, -3.07966843e-02f,
  6.68518990e-02f, 1.35134840e-02f, -6.17810078e-02f, -6.38784957e-04f, -5.15193399e-03f, 2.52598105e-03f, -1.23645864e-01f, 4.45227697e-03f, -5.88713493e-03f, -9.69935060e-02f,
  -8.01840723e-02f, -4.43984196e-02f, -5.26089594e-02f, -6.20424328e-03f, 4.50461805e-02f, -5.69137335e-02f, 7.02904910e-03f, -5.21537103e-02f, -9.68314782e-02f, -9.39741433e-02f,
  -2.08807141e-01f, -2.78206140e-01f, -5.13696996e-03f, 1.73353449e-01f, -5.62212579e-02f, -2.35716760e-01f, -2.34553903e-01f, 1.17069734e-02f, -8.00704509e-02f, -1.69376507e-01f,
  -1.52180530e-02f, -2.88643166e-02f, -1.53113395e-01f, 2.17704803e-01f, 2.27893710e-01f, -6.40284941e-02f, 1.63949758e-01f, 6.95109069e-02f, 1.74532443e-01f, 5.64956106e-02f,
  3.28881204e-01f, 2.81944305e-01f, 3.67143780e-01f, 2.52303720e-01f, 6.48037940e-02f, 1.80941343e-01f, 1.79660991e-01f, 1.42985687e-01f, 3.58773172e-01f, 1.31375760e-01f,
  -1.36252046e-01f, -4.42838557e-02f, 1.59971789e-02f, -4.66845976e-03f, -4.80526909e-02f, -3.71475853e-02f, -3.41338441e-02f, 4.06120308e-02f, -2.51758308e-03f, 2.88119726e-02f,
  -1.11647457e-01f, -2.56959032e-02f, 9.92697552e-02f, 2.54779477e-02f, -1.59505635e-01f, 6.95704371e-02f, -3.42237987e-02f, -6.05987124e-02f, 1.53237628e-02f, -4.50923964e-02f,
  2.06143572e-03f, -2.11087763e-02f, -2.43003317e-03f, 3.30441631e-02f, -1.45737338e-03f, -5.95114343e-02f, 3.41587774e-02f, -2.34119617e-03f, 3.50829028e-02f, -3.58753316e-02f,
  -1.48019567e-01f, 1.20090343e-01f, 1.44195765e-01f, 3.93039212e-02f, -1.12921773e-02f, 3.13607194e-02f, 5.34933396e-02f, 8.58712010e-03f, 7.57296383e-02f, -3.57974805e-02f,
  -7.50086550e-03f, 4.95087504e-02f, -3.35473306e-02f, -1.06181890e-01f, 1.16157733e-01f, -1.53074143e-02f, 2.88374554e-02f, 3.84596474e-02f, 4.88380976e-02f, -8.37278180e-03f,
  4.08234028e-03f, -1.55876409e-02f, -2.06297338e-02f, 3.02195828e-02f, -1.56948250e-02f, -4.72769253e-02f, 7.32971728e-02f, -9.30524841e-02f, 4.97522913e-02f, 1.74580321e-01f,
  -1.17511377e-01f, 1.80134270e-02f, 4.31337804e-02f, -1.65619422e-02f, 1.32984873e-02f, 1.15756188e-02f, -1.67049486e-02f, -1.13637745e-02f, -1.13574877e-01f, -6.67362139e-02f,
  -4.66509946e-02f, 4.78267949e-03f, -2.70905625e-02f, 6.56661903e-03f, 1.65424883e-01f, -2.98178028e-02f, -4.07722369e-02f, -4.52445820e-02f, 9.95936915e-02f, 1.10071767e-02f,
  -7.31745958e-02f, -1.12233557e-01f, 1.52711302e-01f, 2.60705110e-02f, 5.62273944e-03f, -6.66112304e-02f, 1.53928855e-02f, -1.20718956e-01f, 1.35718077e-01f, -1.05023207e-02f,
  -5.42220101e-02f, 8.49220622e-03f, -5.49311787e-02f, -4.28358801e-02f, 9.47687775e-02f, 2.20334549e-02f, -1.43234149e-01f, 6.17000461e-02f, -2.41193101e-01f, 3.80836776e-03f,
  -1.27422497e-01f, -1.55888215e-01f, -1.98591769e-01f, -1.81413606e-01f, -5.95244877e-02f, -4.60083187e-01f, 9.71887857e-02f, -1.21175706e-01f, -1.48318052e-01f, 1.07974820e-01f,
  1.72028281e-02f, 8.40450749e-02f, -3.51935811e-02f, 8.02194029e-02f, 1.77872218e-02f, 2.45389730e-01f, 3.36810023e-01f, -3.49119641e-02f, 2.91948169e-01f, 3.61172631e-02f,
  -7.08284006e-02f, -8.01128522e-02f, -3.36632840e-02f, -1.41082406e-01f, 1.30006030e-01f, 1.37789771e-01f, 6.80661500e-02f, 2.24755052e-02f, -7.95788467e-02f, -1.09405853e-02f,
  2.64869388e-02f, -7.19341114e-02f, 3.78382616e-02f, 2.35710964e-02f, 1.12642655e-02f, 2.13217083e-03f, 2.73961797e-02f, -9.96916741e-02f, -6.64807260e-02f, -8.03115871e-03f,
  -5.88790551e-02f, 3.39188427e-02f, 8.04963261e-02f, 5.70014082e-02f, 1.01336189e-01f, 6.58238959e-03f, 9.83210951e-02f, 2.06978217e-01f, 5.50206937e-02f, 6.11225292e-02f,
  7.13098347e-02f, 5.88313937e-02f, -4.68982663e-03f, -1.34346962e-01f, -2.34915782e-02f, -4.88172919e-02f, -1.45111546e-01f, 7.33553693e-02f, 4.04430106e-02f, -2.63541285e-02f,
  9.32865497e-03f, -4.33603376e-02f, -9.05582234e-02f, 2.00173594e-02f, 8.53514448e-02f, -4.52377126e-02f, 9.48241130e-02f, 6.71144724e-02f, 1.30907521e-01f, 3.65277603e-02f,
  -2.67737806e-01f, -1.12300739e-02f, -4.20782296e-03f, 2.39983555e-02f, -5.69518432e-02f, -2.10101474e-02f, -1.02673909e-02f, -2.78927502e-03f, 7.99984038e-02f, -2.57183239e-02f,
  7.22914413e-02f, 1.95834965e-01f, -9.88502428e-02f, -8.04266259e-02f, -3.55992578e-02f, 6.64446577e-02f, -1.01796113e-01f, -2.16141250e-02f, 1.95196923e-02f, 4.58974540e-02f,
  1.73545048e-01f, 7.78394798e-03f, 7.79760927e-02f, -3.16515490e-02f, 2.66062990e-02f, 1.13094807e-01f, -6.34633796e-03f, 4.00852114e-02f, 7.71770775e-02f, 1.41885638e-01f,
  9.53613818e-02f, 6.60976619e-02f, -3.35107744e-02f, 4.28456860e-03f, 8.65209624e-02f, 4.83427830e-02f, 1.01991110e-01f, 1.06457733e-01f, 1.71035692e-01f, -4.03457545e-02f,
  2.10917339e-01f, -2.96137422e-01f, -8.72997567e-02f, 1.44057140e-01f, 1.92169547e-01f, -3.09173949e-02f, -1.78240865e-01f, 1.85890883e-01f, 6.29178882e-02f, -1.82242513e-01f,
  1.57442063e-01f, -1.85625970e-01f, -2.03270420e-01f, 1.47154883e-01f, 1.39016911e-01f, -1.56173646e-01f, 1.21690825e-01f, 2.17460599e-02f, -1.55534723e-03f, 3.72337028e-02f,
  1.14155129e-01f, 2.15213194e-01f, -9.28923301e-03f, 2.01179057e-01f, 4.26479429e-02f, 1.01516739e-01f, 6.61941171e-02f, -1.92544132e-01f, 7.16387182e-02f, -2.74474686e-03f,
  3.89302187e-02f, -5.13506308e-02f, 8.09522253e-03f, -4.00505811e-02f, -1.24996148e-01f, -5.91720790e-02f, -8.79829079e-02f, -7.25586191e-02f, -9.22115073e-02f, 4.29564752e-02f,
  -9.07439440e-02f, 1.16185650e-01f, 1.07257225e-01f, -2.16120742e-02f, 1.06088653e-01f, 1.11795567e-01f, 3.11228726e-02f, 8.50199908e-02f, -4.03476581e-02f, -8.01926553e-02f,
  1.19492961e-02f, 5.68392575e-02f, 2.99474616e-02f, -7.59995878e-02f, 6.74819127e-02f, 3.21735106e-02f, -5.19533120e-02f, -7.08869621e-02f, -1.72298849e-01f, 4.75281011e-03f,
  1.44075532e-03f, -5.06443642e-02f, 1.60534307e-02f, 2.54316349e-02f, -3.01988184e-04f, -1.13653420e-02f, -4.71044108e-02f, -5.02127782e-02f, -1.42426044e-01f, 1.69511214e-02f,
  1.00915693e-01f, 1.75870899e-02f, -4.25795615e-02f, -2.27270033e-02f, 7.01003373e-02f, 1.86267290e-02f, 7.62321195e-03f, 1.77727882e-02f, 2.94866064e-03f, 8.32669437e-02f,
  -4.60135052e-03f, -3.83701809e-02f, -9.21110064e-03f, 1.53750032e-01f, 2.36257724e-02f, -2.69617978e-02f, -6.90474920e-03f, 1.00423075e-01f, -1.51683077e-01f, -6.41778409e-02f,
  1.82121266e-02f, 2.49961624e-03f, -1.00164555e-01f, 9.88416560e-03f, -6.19116575e-02f, 7.09365308e-02f, -4.48197573e-02f, 5.06738797e-02f, -5.06425761e-02f, 1.64458737e-01f,
  3.83602269e-02f, 6.13868982e-02f, 3.29098813e-02f, 5.77701218e-02f, -8.42258856e-02f, -1.26305791e-02f, -1.03232041e-01f, -1.66586414e-02f, 6.91201165e-02f, 8.93737152e-02f,
  2.71088467e-03f, 2.37971894e-03f, -1.29047260e-01f, -6.16872422e-02f, 1.42837450e-01f, -2.87313145e-02f, 1.03792489e-01f, 9.87848639e-03f, -2.97666993e-02f, -2.18066126e-02f,
  -4.66510326e-01f, 3.18111390e-01f, 1.17109016e-01f, -6.89799190e-02f, 2.34651461e-01f, -9.96787027e-02f, -1.64721206e-01f, 4.99151573e-02f, -3.97256650e-02f, -1.62664279e-01f,
  9.95014012e-02f, -8.66046846e-02f, 1.20613866e-01f, 4.81312070e-03f, -2.99150735e-01f, -4.83681336e-02f, -1.58720359e-01f, -1.05987258e-01f, 7.76654780e-02f, -7.53383711e-02f,
  -4.25410755e-02f, 5.56383468e-02f, -1.84949990e-02f, 3.21713358e-01f, 3.17678228e-03f, -1.38451625e-02f, -2.24577814e-01f, 1.05794892e-01f, -5.10264188e-03f, 9.88300666e-02f,
  -2.41538122e-01f, -1.11361451e-01f, -1.51533797e-01f, -4.54656482e-02f, -1.93729013e-01f, -1.19080842e-01f, -1.77335829e-01f, 9.88046080e-03f, 1.12554687e-03f, 2.24929303e-02f,
  -1.41575724e-01f, -2.66766101e-02f, 1.85339004e-02f, 1.52439177e-01f, 3.00193415e-03f, 6.00921740e-05f, 3.62007059e-02f, -2.91743465e-02f, 8.59115869e-02f, 7.40432143e-02f,
  1.12176500e-01f, 3.59037109e-02f, -4.22859378e-02f, -1.26733974e-01f, -4.84270640e-02f, 6.29824307e-03f, -2.10562907e-02f, -4.66101468e-02f, -5.81551455e-02f, -1.57496277e-02f,
  -2.99731102e-02f, -1.07819133e-01f, 1.12694219e-01f, 1.67162836e-01f, 1.17000274e-01f, 8.09220746e-02f, 1.81419477e-02f, -8.61234069e-02f, -8.25262815e-02f, -5.21568954e-02f,
  -3.37691419e-02f, -6.71422631e-02f, 1.12934764e-02f, -2.93550100e-02f, -5.62548824e-03f, 4.60887626e-02f, -5.44174351e-02f, 5.64471893e-02f, 1.56057373e-01f, 1.88757386e-02f,
  -5.71122020e-02f, -6.00926466e-02f, -1.45744067e-02f, -6.75373003e-02f, -2.42618509e-02f, -2.26198267e-02f, -6.40160143e-02f, -2.04857867e-02f, -4.00041416e-02f, -6.77867420e-03f,
  -4.54555482e-01f, -3.02989841e-01f, -1.92948043e-01f, -2.87017561e-02f, -3.58297117e-02f, -6.26763254e-02f, -2.62867827e-02f, -6.77102990e-03f, -1.10779971e-01f, 2.76930593e-02f,
  -3.31614390e-02f, -1.31650299e-01f, 3.01847216e-02f, 7.14693293e-02f, -4.66446858e-03f, -8.95901546e-02f, -1.34507671e-01f, -4.01985198e-02f, -1.90765366e-01f, -1.27606660e-01f,
  -1.24235518e-01f, 5.32612950e-02f, -7.88003430e-02f, -9.66869444e-02f, -7.75704533e-02f, -1.20338611e-01f, 6.23665042e-02f, -7.19602220e-03f, -2.87773330e-02f, 3.14388797e-02f,
  -4.85042155e-01f, 2.13353813e-01f, 1.03385650e-01f, -2.57414490e-01f, 1.43995374e-01f, -1.34826660e-01f, -9.77633428e-03f, 1.34351909e-01f, 2.64827795e-02f, 1.50204271e-01f,
  1.50264755e-01f, -2.17741616e-02f, 2.00964853e-01f, -1.68183465e-02f, -2.59253889e-01f, -6.38103411e-02f, -2.38770708e-01f, -9.92258191e-02f, 2.45029349e-02f, -9.31751281e-02f,
  -1.71870545e-01f, -4.22346517e-02f, -1.54560685e-01f, 1.68237105e-01f, 2.94159371e-02f, -3.40239815e-02f, -1.64212704e-01f, 9.41472128e-02f, -8.75818357e-02f, 1.11982778e-01f,
  -2.28278488e-01f, -1.56393051e-02f, 8.57181773e-02f, -5.54168522e-02f, -1.33151844e-01f, 3.60973626e-02f, -1.71310395e-01f, 2.19478048e-02f, 3.26909237e-02f, -1.33034540e-02f,
  1.00319594e-01f, -5.23803523e-03f, -4.60329354e-02f, 1.15760945e-01f, 3.93514661e-03f, 7.59622380e-02f, 8.82070661e-02f, -7.03304559e-02f, 9.19451565e-03f, 3.48596903e-03f,
  -7.92000256e-03f, 9.94204916e-03f, -2.79026851e-02f, -4.86889109e-02f, -4.76876423e-02f, 1.00482859e-01f, -6.07881434e-02f, -9.00599435e-02f, -6.08087480e-02f, -4.58586849e-02f,
  -2.70124003e-02f, -1.24161877e-02f, 5.26630543e-02f, 1.29976898e-01f, 2.36114953e-02f, 8.52730200e-02f, 6.71640113e-02f, 5.42200124e-03f, 1.57129671e-02f, 2.00729184e-02f,
  -8.16479847e-02f, 9.55557218e-04f, 4.16138805e-02f, -3.34335342e-02f, -6.94659492e-03f, -1.85396429e-02f, -6.46211505e-02f, -2.72251666e-02f, -7.42112473e-03f, -7.93406293e-02f,
  -8.19648579e-02f, -1.47293480e-02f, 1.50342975e-02f, -4.27428149e-02f, 6.42646030e-02f, -3.98816764e-02f, -3.54135968e-02f, -2.94996090e-02f, 4.05235449e-03f, -6.59305751e-02f,
  -3.93314719e-01f, -2.97365069e-01f, 8.76047276e-03f, -3.31106745e-02f, -7.00234398e-02f, -6.48645833e-02f, -3.66851278e-02f, 5.70741929e-02f, 6.71616942e-02f, -5.91121726e-02f,
  6.67185187e-02f, -1.90151688e-02f, -8.96086544e-02f, 5.94265498e-02f, -2.00673789e-02f, -9.86339822e-02f, -1.88835226e-02f, 1.23202959e-02f, -8.36979449e-02f, -1.43344263e-02f,
  -1.86138928e-01f, 7.05749616e-02f, 1.48387114e-02f, -2.15325989e-02f, -1.33446902e-02f, 1.38911735e-02f, -8.85113627e-02f, -2.22395454e-02f, -9.94444042e-02f, -8.13660584e-03f,
  2.53247887e-01f, -4.09386195e-02f, -2.67532259e-01f, -1.25566959e-01f, 3.56120579e-02f, 1.51695788e-01f, 2.13534757e-02f, -2.67801955e-02f, -2.27439061e-01f, 2.29854837e-01f,
  1.94305211e-01f, -9.92256477e-02f, -2.30177045e-01f, 3.62112582e-01f, 1.40083015e-01f, -1.06038108e-01f, 2.36660421e-01f, 1.40954420e-01f, -6.19159341e-02f, 6.42477870e-02f,
  -1.56599451e-02f, 3.65336478e-01f, -1.32122234e-01f, 2.11282820e-01f, 2.55571485e-01f, -9.87427309e-02f, 1.02638990e-01f, -1.75665125e-01f, 6.26126081e-02f, 6.38122410e-02f,
  9.68804732e-02f, -5.31255119e-02f, -9.98183787e-02f, -5.06630540e-02f, -1.52480975e-02f, 1.66129041e-02f, -4.06629518e-02f, 6.63973838e-02f, -1.37184277e-01f, -7.20648319e-02f,
  1.48667153e-02f, 5.78147061e-02f, 7.67483562e-02f, -9.00203660e-02f, 8.10933411e-02f, -1.05378985e-01f, -9.12901610e-02f, -1.29418120e-01f, -1.80134758e-01f, 3.03360708e-02f,
  -1.74123570e-01f, -1.03583019e-02f, -7.99101740e-02f, -2.92148795e-02f, -9.65493470e-02f, -7.62389898e-02f, -1.50445133e-01f, -3.16050649e-02f, 7.48737678e-02f, -4.26227674e-02f,
  1.07649595e-01f, 1.79801900e-02f, 1.16451420e-02f, -1.11635821e-02f, -4.18957397e-02f, -5.08722737e-02f, 1.02294251e-01f, 7.92963430e-02f, -1.02344938e-01f, 5.74966818e-02f,
  -7.54703432e-02f, 1.94882099e-02f, 6.99965060e-02f, 7.22606033e-02f, 1.45361125e-01f, 8.02572593e-02f, -6.37976918e-04f, -3.93055268e-02f, -2.50800818e-01f, -5.97504973e-02f,
  6.05975911e-02f, 2.67475620e-02f, -7.66121224e-02f, 2.33287388e-03f, 6.62723929e-02f, -8.37474987e-02f, 1.51583672e-01f, -9.66711435e-03f, -5.65481447e-02f, -2.31011752e-02f,
  9.04133320e-02f, -4.83659953e-02f, -1.19444340e-01f, 4.35509905e-02f, -2.32527852e-01f, 1.16227716e-01f, -2.37320326e-02f, 8.48762020e-02f, -5.92480078e-02f, 1.35854454e-04f,
  5.87886535e-02f, -3.69915627e-02f, 6.86629442e-03f, -1.05865225e-01f, -3.67421955e-02f, -3.26478644e-03f, 6.02459162e-02f, -1.12831354e-01f, -6.58707246e-02f, 7.33269975e-02f,
  -2.84527559e-02f, 1.71403885e-02f, -6.12597615e-02f, -1.22800529e-01f, 8.43450874e-02f, -4.20931205e-02f, -3.01479921e-02f, 7.79597508e-03f, 5.00990003e-02f, -3.06924935e-02f,
  -5.52453935e-01f, 1.57714039e-01f, -1.47002071e-01f, -6.24042340e-02f, -3.33182812e-01f, -3.02647473e-03f, -1.33130299e-02f, -1.18844397e-01f, -2.68317997e-01f, 5.16942032e-02f,
  -2.46614620e-01f, -2.06569359e-01f, 1.96626514e-01f, 1.33969650e-01f, -8.81645421e-04f, 2.79241413e-01f, 7.96323642e-02f, 3.78997438e-02f, 5.70901670e-03f, -8.82063061e-02f,
  9.29911211e-02f, 6.61317911e-03f, 1.55652881e-01f, -3.19226040e-03f, -1.43007487e-01f, -8.82165879e-02f, -5.02932491e-03f, -6.84465170e-02f, -6.16697446e-02f, -2.84490943e-01f,
  -2.19507724e-01f, -2.52138346e-01f, -1.29440561e-01f, -9.23612267e-02f, -4.86837700e-02f, 6.86411047e-04f, -4.01329361e-02f, -9.37906280e-02f, -7.23004937e-02f, -3.10319792e-02f,
  -4.15683538e-02f, -1.85146406e-02f, -1.53596535e-01f, 1.55430497e-03f, 1.57080572e-02f, -9.32604149e-02f, 5.65985031e-02f, 1.21388584e-01f, -4.59105102e-03f, -2.98617650e-02f,
  2.02293098e-02f, 3.87954488e-02f, 7.49900118e-02f, 1.40408561e-01f, 1.94948781e-02f, -8.38485721e-04f, 5.82961030e-02f, 2.69497372e-02f, -1.82134588e-03f, -2.02977452e-02f,
  2.76922621e-03f, -3.65850441e-02f, -1.22772262e-01f, -6.23391494e-02f, -1.91910043e-02f, -3.31054674e-03f, -3.63781266e-02f, -5.40055744e-02f, 5.29266521e-02f, 6.81682006e-02f,
  -1.32132038e-01f, -3.15566510e-02f, -2.94445008e-02f, 1.56054914e-01f, -8.95178877e-03f, 3.86874005e-02f, 5.51249832e-03f, -1.59593850e-01f, -2.56331987e-03f, 6.13856595e-03f,
  -4.96347062e-02f, -1.48924485e-01f, 4.97744791e-02f, 6.46402016e-02f, -1.30087435e-01f, 1.31541207e-01f, 5.18052131e-02f, 4.11876775e-02f, 6.84048086e-02f, 6.13559335e-02f,
  -3.06849539e-01f, -2.04275072e-01f, -7.31490329e-02f, -1.21165328e-01f, -3.44069116e-02f, 1.53710144e-02f, 5.66781983e-02f, -8.38498697e-02f, -1.48724597e-02f, -4.42125238e-02f,
  -6.97708279e-02f, 1.49551351e-02f, -7.77889937e-02f, -1.48566496e-02f, 4.27895375e-02f, 4.85510416e-02f, 8.71367287e-03f, 3.88244800e-02f, 7.70516545e-02f, -8.92962962e-02f,
  6.78562298e-02f, -2.99288146e-02f, 1.06814861e-01f, 1.42747192e-02f, 1.23447329e-01f, -6.49821386e-02f, -6.19326197e-02f, 1.79542396e-02f, -2.37467587e-02f, -5.41034862e-02f,
  3.79651874e-01f, 2.05577835e-01f, 7.67608285e-02f, 2.94276386e-01f, 1.26919493e-01f, 6.05337881e-03f, 6.52138963e-02f, 7.40644112e-02f, 4.83349770e-01f, -9.67504606e-02f,
  -1.06559597e-01f, 1.94907233e-01f, -2.06811205e-01f, 3.41638699e-02f, -1.98792577e-01f, -1.23634614e-01f, 1.75767064e-01f, 2.09624037e-01f, 2.81244636e-01f, 1.02699501e-02f,
  1.55293092e-01f, -2.54421264e-01f, -1.31691918e-01f, -5.03976196e-02f, 1.13898501e-01f, 7.76429549e-02f, -4.00473595e-01f, -8.04749429e-02f, -1.27740458e-01f, -5.86018674e-02f,
  6.13311343e-02f, 4.44480740e-02f, 1.04002103e-01f, 5.01587018e-02f, 8.90449360e-02f, 2.49780603e-02f, -7.50357360e-02f, -1.16056338e-01f, 1.19390801e-01f, 4.93080169e-02f,
  5.10432236e-02f, -5.49805835e-02f, -3.91121097e-02f, -5.49321920e-02f, 1.45867512e-01f, -1.70411859e-02f, 8.39128047e-02f, 7.95848370e-02f, -9.88221541e-03f, 4.83363196e-02f,
  1.06717564e-01f, 9.56773683e-02f, 1.34643018e-01f, -6.96280301e-02f, 9.27102715e-02f, 1.18875429e-01f, 3.52462642e-02f, -1.47515237e-01f, -3.45198624e-02f, 1.18558377e-01f,
  3.92463990e-02f, 2.22770758e-02f, -1.11784294e-01f, -7.17192367e-02f, -8.24256688e-02f, 6.02523275e-02f, 6.76424205e-02f, -7.24322796e-02f, 1.79289997e-01f, 2.31783534e-03f,
  -5.81669323e-02f, 7.58506507e-02f, 7.06492513e-02f, 2.98530795e-02f, 2.49920666e-01f, 1.18851708e-02f, -4.85812090e-02f, -1.12971086e-02f, 1.94874138e-01f, 9.38093755e-03f,
  -8.01344812e-02f, -3.84584256e-02f, 7.49809667e-02f, 2.33387556e-02f, 4.21310514e-02f, -6.68186098e-02f, -1.95158795e-01f, -9.14696231e-03f, 1.99401882e-02f, -8.88497457e-02f,
  3.25863948e-03f, -2.83533521e-02f, 2.53815539e-02f, 2.22106427e-02f, 7.52419457e-02f, -3.81339937e-02f, 6.42692344e-03f, 1.20810188e-01f, 4.04692702e-02f, -1.47706987e-02f,
  5.63696288e-02f, 7.79734999e-02f, 1.45028308e-02f, -1.25193521e-01f, 2.05114689e-02f, -1.54823974e-01f, -6.55381680e-02f, 7.70941004e-03f, 1.35987913e-02f, -1.83690935e-01f,
  4.88684606e-03f, -2.29122210e-02f, 9.24210548e-02f, 1.45106897e-01f, 1.28919512e-01f, -1.98773853e-02f, 2.69423202e-02f, 3.02497167e-02f, -3.79750356e-02f, 5.79247475e-02f,
  1.25756711e-01f, 2.06793040e-01f, 1.45621091e-01f, 1.80285901e-01f, -2.83064693e-01f, -1.74596384e-01f, -1.59038678e-01f, 2.86475960e-02f, 5.45302592e-02f, 7.07221776e-02f,
  -1.11088604e-01f, 2.72619337e-01f, 2.07217652e-02f, 9.36192051e-02f, -5.13769463e-02f, 8.81343633e-02f, 5.46709150e-02f, 3.10343783e-02f, -5.58261722e-02f, 2.12140054e-01f,
  5.97713217e-02f, -6.45144209e-02f, 3.92785855e-02f, -9.11462530e-02f, 1.23540916e-01f, 1.63984552e-01f, -4.51992564e-02f, -5.63030466e-02f, 6.80009425e-02f, -1.42534792e-01f,
  -7.15096667e-03f, 1.45033702e-01f, 3.28421742e-02f, 3.74131985e-02f, 9.75826830e-02f, -9.03363600e-02f, 4.34941500e-02f, 2.17000879e-02f, -7.51040354e-02f, 1.32074565e-01f,
  5.08673899e-02f, 6.80696592e-02f, -1.38235940e-02f, 3.01493332e-02f, -9.03568491e-02f, 3.45945545e-02f, 1.47098005e-01f, -1.78289041e-02f, 3.35842706e-02f, 9.46231857e-02f,
  1.94117911e-02f, 5.22780567e-02f, 5.83720244e-02f, 1.37286305e-01f, 1.39007956e-01f, 1.37589768e-01f, -9.39936086e-04f, 8.70809034e-02f, 1.32370085e-01f, 8.79712030e-02f,
  -9.49101429e-03f, 5.54560386e-02f, 2.39107036e-03f, -9.36962441e-02f, 3.75775644e-03f, 2.32913089e-03f, -1.02329697e-03f, -3.61558050e-02f, 4.83524241e-02f, 2.25267429e-02f,
  -8.20786282e-02f, -8.76618251e-02f, -8.93697608e-03f, -1.05140172e-02f, 5.85558377e-02f, 1.04828134e-01f, 1.21970298e-02f, -8.68293494e-02f, -5.76996468e-02f, -1.12622969e-01f,
  -4.22290564e-02f, 1.23373345e-02f, 1.09147020e-01f, -3.10852490e-02f, -1.53606325e-01f, 6.42419308e-02f, 4.59358059e-02f, 1.21001909e-02f, -4.77433987e-02f, -1.60447154e-02f,
  9.34058279e-02f, 3.01818162e-01f, -2.58967862e-03f, 2.49933777e-03f, 5.60068935e-02f, 7.28054643e-02f, 3.98516953e-02f, 1.85360551e-01f, 8.81841853e-02f, -1.21535351e-02f,
  -1.36225559e-02f, -1.63625758e-02f, 6.72516972e-02f, -4.52206731e-02f, -5.94459623e-02f, 1.35579318e-01f, 1.65927738e-01f, 1.50067667e-02f, 3.47666964e-02f, 2.43162625e-02f,
  2.08872836e-02f, 6.74654320e-02f, 1.41947508e-01f, 2.55412553e-02f, 2.15926431e-02f, 1.44096404e-01f, -2.94784512e-02f, 3.23817506e-02f, 3.87135968e-02f, 7.13879019e-02f,
  3.02998930e-01f, 7.79625550e-02f, 3.35354358e-01f, 1.97077081e-01f, -9.41203609e-02f, -5.16494811e-02f, -2.33687628e-02f, 6.95192069e-02f, 2.14416850e-02f, 2.09611095e-02f,
  2.09503137e-02f, 3.40822756e-01f, 2.24551223e-02f, 2.58528143e-02f, -1.92218557e-01f, -1.35684386e-01f, -1.18950635e-01f, 7.51511902e-02f, -2.02632286e-02f, 1.00754708e-01f,
  -1.07426811e-02f, -2.69234926e-01f, 6.28485680e-02f, -2.12205559e-01f, 1.65975332e-01f, 1.36458188e-01f, -2.02498987e-01f, -2.82326024e-02f, 6.07037246e-02f, 2.07463261e-02f,
  -3.70721221e-02f, -6.33749217e-02f, 7.81701952e-02f, -8.22588056e-02f, -9.37882960e-02f, -1.66409519e-02f, -5.69779775e-04f, 7.59410709e-02f, -5.30179963e-02f, -6.15142211e-02f,
  -7.11621493e-02f, 9.32898466e-03f, -1.16719597e-03f, 3.56883630e-02f, -6.82247579e-02f, 1.10398151e-01f, 1.29823834e-01f, -9.56860092e-03f, 9.46840867e-02f, 1.68461978e-01f,
  9.11450163e-02f, 5.02651110e-02f, -6.27481705e-03f, -7.06987754e-02f, 3.24766561e-02f, 2.13294663e-03f, 4.78521502e-03f, 1.90567374e-01f, 4.69788685e-02f, 1.99638829e-02f,
  -1.24945693e-01f, -1.45269141e-01f, -4.28454876e-02f, 5.29758818e-02f, 5.60831800e-02f, -1.33410236e-02f, -1.04819484e-01f, 5.74093871e-03f, -5.74432202e-02f, 2.80305743e-03f,
  5.51522560e-02f, -3.24776471e-02f, -7.67609477e-02f, 1.33046862e-02f, -7.89286196e-03f, 3.34218256e-02f, 1.15075208e-01f, 5.06672449e-02f, -1.00331791e-01f, 1.06656857e-01f,
  3.61479409e-02f, -2.06662621e-02f, 4.13604714e-02f, 9.57293808e-02f, 6.73606014e-03f, 1.15510421e-02f, 4.54939641e-02f, 1.70702487e-01f, -1.08918063e-01f, -4.21380065e-02f,
  -2.54825354e-01f, -3.14104170e-01f, -5.81467561e-02f, -6.23300998e-03f, 1.80825349e-02f, -3.55978427e-03f, -4.81110401e-02f, -2.73715388e-02f, -1.56822965e-01f, -1.12318890e-02f,
  -7.74082616e-02f, 4.29988094e-02f, -6.06657490e-02f, 9.82176512e-02f, -8.61555412e-02f, -5.98234273e-02f, -6.02011681e-02f, -1.18623868e-01f, -1.08288541e-01f, 2.55935127e-03f,
  5.34092560e-02f, -1.18660651e-01f, 1.19935591e-02f, -5.76326661e-02f, 6.09703735e-03f, 5.06947115e-02f, 1.74165815e-02f, 1.66003779e-01f, -7.32000619e-02f, -8.40571970e-02f,
  -1.24414586e-01f, 5.95967062e-02f, -2.56987363e-01f, -1.11672036e-01f, 1.44317031e-01f, -4.48467791e-01f, -2.64986187e-01f, -1.08727755e-03f, 1.58817582e-02f, 2.06071913e-01f,
  -3.34004983e-02f, 1.54991046e-01f, 2.17422545e-01f, -2.99257040e-01f, -4.43034768e-01f, -1.88587427e-01f, -4.27566171e-01f, -9.02153999e-02f, -4.21841443e-02f, -6.39151549e-03f,
  -1.72660559e-01f, -7.94946402e-02f, -2.52198040e-01f, -1.23035340e-02f, -1.54075533e-01f, -9.95912030e-03f, 1.05047680e-01f, 9.76228528e-03f, -1.02416798e-01f, -4.68122996e-02f,
  -7.51891211e-02f, 2.37060919e-01f, 3.66495475e-02f, -1.70339663e-02f, -8.08671862e-02f, -7.24218041e-02f, -6.94379210e-02f, 7.11516440e-02f, 1.53968204e-02f, -5.85215501e-02f,
  2.15113424e-02f, 5.75328171e-02f, -1.41052790e-02f, 6.99761808e-02f, -9.10022780e-02f, -2.70163249e-02f, 8.63067359e-02f, -5.86060472e-02f, 7.66473562e-02f, -4.21584621e-02f,
  -4.40931395e-02f, 5.45201600e-02f, -2.66826209e-02f, 6.10563084e-02f, -1.68775972e-02f, 5.01979366e-02f, -8.25743005e-02f, 7.75253866e-03f, -2.27642674e-02f, -5.96000487e-03f,
  -4.98766489e-02f, -2.88361758e-02f, -7.54272565e-02f, 5.71499020e-02f, 4.00177874e-02f, 5.68636954e-02f, -2.18218230e-02f, 6.56730905e-02f, 4.66773752e-03f, 2.23731343e-02f,
  5.80343083e-02f, 2.27236766e-02f, -8.55628029e-02f, -8.64980146e-02f, -6.92269877e-02f, 5.34702279e-02f, 1.22247050e-02f, 5.84610291e-02f, -1.61378279e-01f, -4.11185995e-02f,
  1.79668739e-01f, -9.81289521e-02f, 2.39765309e-02f, 7.11181164e-02f, -1.34985015e-01f, 3.99127137e-03f, 1.66359302e-02f, -2.57643461e-02f, -5.34544960e-02f, -2.46661473e-02f,
  1.39886728e-02f, 1.19878940e-01f, 1.11868732e-01f, 1.19144499e-01f, 7.92414844e-02f, -6.51403666e-02f, -8.23687539e-02f, -9.09197256e-02f, -3.99748012e-02f, -2.84917597e-02f,
  -8.20231717e-03f, 1.44522674e-02f, 2.71160174e-02f, 1.19672127e-01f, -5.32068219e-03f, -1.24660425e-01f, -4.30338871e-04f, 6.91792369e-02f, 1.15867155e-02f, 7.05187321e-02f,
  4.22806218e-02f, 4.27464806e-02f, -5.06038852e-02f, -1.01423524e-01f, -5.18184528e-03f, 1.78931113e-02f, -1.02575710e-02f, 1.05265407e-02f, 8.07545334e-02f, 7.66964182e-02f,
  1.99571662e-02f, -2.47473359e-01f, -1.63200930e-01f, -1.60415526e-02f, 1.84711367e-01f, 9.90497246e-02f, -1.62357643e-01f, 1.29403442e-01f, -1.31720796e-01f, -1.08582698e-01f,
  8.25204700e-02f, 3.22277956e-02f, -2.81726956e-01f, 1.58096239e-01f, 1.76643506e-01f, -2.84699172e-01f, 4.91029024e-02f, 1.01567484e-01f, -2.35625759e-01f, -9.91078615e-02f,
  4.60876338e-02f, 2.33915284e-01f, 4.20008935e-02f, 3.35799307e-01f, 3.36363241e-02f, 1.45175233e-01f, 2.01509833e-01f, -1.73182841e-02f, 3.07896435e-01f, 2.39020467e-01f,
  7.21801147e-02f, -1.18110828e-01f, 1.74513198e-02f, 5.42188846e-02f, -4.50009517e-02f, 9.15429071e-02f, 6.28084764e-02f, 1.23967580e-01f, 3.88657185e-03f, -1.78210497e-01f,
  -9.71747376e-03f, 5.55393323e-02f, 9.59450454e-02f, 3.21261995e-02f, 9.46630016e-02f, 7.07391351e-02f, -9.10739303e-02f, 9.51367319e-02f, -5.05398400e-02f, -8.19843933e-02f,
  -2.95836888e-02f, -4.57209796e-02f, -4.20000218e-03f, 8.33350942e-02f, -2.04519536e-02f, -2.62751412e-02f, -2.11725030e-02f, -1.75478943e-02f, -6.01959638e-02f, 3.73435095e-02f,
  1.36664912e-01f, 2.01184247e-02f, 4.62859906e-02f, 4.52908464e-02f, -9.39513519e-02f, -4.86875884e-02f, -1.03471233e-02f, -5.93470596e-02f, -7.90124238e-02f, -5.81108266e-03f,
  -8.15383196e-02f, -4.49897349e-03f, -5.56170847e-03f, -1.38516035e-02f, 6.38345033e-02f, -1.06968701e-01f, -5.83248846e-02f, -5.17814048e-02f, 8.94032791e-02f, 1.17916777e-03f,
  -1.86417177e-02f, -6.38336642e-03f, -6.55776635e-02f, 4.30144705e-02f, 3.49820554e-02f, 4.96127233e-02f, 4.94807623e-02f, 9.64158587e-03f, -6.91535249e-02f, 9.34672728e-02f,
  6.76597059e-02f, -1.17650583e-01f, -2.93088909e-02f, 6.93018809e-02f, -3.76462303e-02f, -1.21091129e-02f, 8.70432779e-02f, 1.07617564e-01f, 5.16628474e-02f, -7.01600909e-02f,
  1.07990198e-01f, 3.83129250e-03f, -1.33866156e-02f, 9.24361944e-02f, 1.03679135e-01f, -3.73674892e-02f, -3.79002392e-02f, 1.72416747e-01f, 9.28836130e-03f, -2.08424497e-03f,
  5.72495200e-02f, -1.48447260e-01f, 8.45326856e-02f, 4.87977341e-02f, 6.26356304e-02f, 5.87075241e-02f, 4.20113727e-02f, -1.16964729e-04f, 2.81660724e-02f, -2.19884552e-02f,
  3.29281002e-01f, 2.75810510e-01f, 2.18958750e-01f, 2.36197129e-01f, -8.33598524e-02f, -2.76989490e-01f, -2.45050341e-02f, 5.79355508e-02f, 9.37469378e-02f, 9.69939083e-02f,
  -1.16152391e-01f, 3.56892824e-01f, -1.82165354e-01f, 1.28163859e-01f, -4.48767066e-01f, -2.02780500e-01f, -8.41982663e-02f, 1.15014188e-01f, -8.61506611e-02f, 8.82339478e-02f,
  1.48086175e-02f, -1.99058399e-01f, 1.87992826e-02f, -1.19051613e-01f, 1.30907446e-01f, 2.63819337e-01f, -1.68379888e-01f, -1.45478591e-01f, 1.79801628e-01f, -2.09185034e-01f,
  1.07637653e-02f, 1.06803313e-01f, 1.33203283e-01f, -1.00762531e-01f, -5.62134944e-02f, 9.95182339e-03f, -1.24280928e-02f, -6.06806716e-04f, 6.04443299e-03f, 2.70785168e-02f,
  1.53300548e-02f, -1.23691425e-01f, 5.69130778e-02f, -2.62826737e-02f, 1.00843854e-01f, 6.43540174e-02f, 1.49613231e-01f, 1.03045478e-01f, 1.15433171e-01f, 3.39738913e-02f,
  1.23519093e-01f, -1.01028550e-02f, 9.42110196e-02f, -1.52998671e-01f, -3.18327062e-02f, 3.09867840e-02f, -2.75164060e-02f, 1.80231947e-02f, 7.60112032e-02f, 8.73404592e-02f,
  2.78302543e-02f, -8.45378116e-02f, -5.46897836e-02f, 9.94056538e-02f, -7.10117295e-02f, -3.31248716e-02f, -1.86575744e-02f, -2.21246239e-02f, -7.95823857e-02f, -1.14483573e-01f,
  -7.19488636e-02f, 1.29442900e-01f, -2.48472355e-02f, -1.48385093e-02f, 3.29867899e-02f, 7.21441954e-02f, 1.69845298e-02f, -6.22143187e-02f, -1.38872545e-02f, -3.34439836e-02f,
  4.04872447e-02f, -5.91186807e-02f, 9.43528041e-02f, -4.93786633e-02f, -6.71009645e-02f, -8.77536237e-02f, 6.24080449e-02f, 9.81397852e-02f, -3.32595706e-02f, -1.10121526e-01f,
  -2.09990397e-01f, -1.78559437e-01f, 3.73691171e-02f, 1.63187012e-02f, 8.02261680e-02f, 4.79228124e-02f, 3.23566385e-02f, -6.04343750e-02f, -1.07008994e-01f, -3.35950889e-02f,
  1.67065524e-02f, -4.45691086e-02f, -1.48313409e-02f, 3.34748067e-02f, -2.42454950e-02f, -7.04202056e-02f, -4.01922800e-02f, -1.15520321e-02f, 3.61308269e-03f, -9.80845988e-02f,
  2.26487406e-02f, -3.08429040e-02f, 7.75590390e-02f, -7.37258792e-02f, -2.42975801e-02f, -3.71736288e-02f, 3.64555717e-02f, 9.22839418e-02f, -5.97381666e-02f, -6.46974817e-02f,
  1.94231197e-01f, -4.86444205e-01f, 9.45989937e-02f, 2.53131449e-01f, 2.69586444e-01f, 8.15113112e-02f, 1.44266173e-01f, -2.05946743e-01f, -4.46981080e-02f, -3.89637947e-01f,
  -3.93814128e-03f, 7.91748334e-03f, -1.61620438e-01f, 7.15169162e-02f, 3.43950272e-01f, -1.16744012e-01f, -4.50009480e-03f, 6.07823506e-02f, -8.13293755e-02f, -4.47309278e-02f,
  1.60979375e-01f, 1.12799138e-01f, 1.42253652e-01f, -1.08856395e-01f, 1.34101296e-02f, -7.78391883e-02f, 7.69459503e-03f, 1.51711833e-02f, 3.82393226e-02f, 1.36464089e-01f,
  6.43120781e-02f, -6.16270155e-02f, 2.65894365e-02f, 6.59188442e-03f, -6.29868507e-02f, 5.63266128e-02f, 1.14568368e-01f, 1.87111184e-01f, 1.43034905e-01f, -5.63658550e-02f,
  4.41961810e-02f, 2.25245189e-02f, -2.27100216e-02f, 1.48357600e-02f, 5.97511558e-03f, 6.50038421e-02f, 1.46874664e-02f, 1.71670672e-02f, 5.18652499e-02f, -7.72444308e-02f,
  -3.97614501e-02f, 5.66087570e-03f, -1.99026596e-02f, 2.69360971e-02f, -1.55626480e-02f, -6.70353009e-04f, -5.16336337e-02f, -1.33284926e-02f, -1.72869973e-02f, -2.71167457e-02f,
  -1.08410679e-01f, -1.88438781e-02f, -6.87006041e-02f, 8.40791408e-03f, 5.71738854e-02f, 1.54909566e-01f, 8.51390958e-02f, -2.57813223e-02f, 4.28613909e-02f, 5.19513115e-02f,
  5.37647419e-02f, 6.66348496e-03f, -6.88670725e-02f, 3.24207619e-02f, -4.83495854e-02f, -8.30546692e-02f, 8.10635537e-02f, 3.16702165e-02f, -2.35314798e-02f, -1.55170681e-02f,
  8.54216367e-02f, 5.20648733e-02f, 8.82230420e-03f, 9.82458666e-02f, 7.92819485e-02f, 6.52245730e-02f, -4.81157303e-02f, -4.02766885e-03f, -1.50391525e-02f, 8.91408175e-02f,
  -1.31319046e-01f, -4.01754975e-01f, -5.40458076e-02f, 3.31812613e-02f, 7.89446086e-02f, -1.37667716e-01f, 4.80302125e-02f, -1.15484431e-01f, 1.55010598e-03f, 4.32229135e-03f,
  1.58953853e-02f, 1.35512829e-01f, 1.03051001e-02f, 2.70569362e-02f, 4.99675460e-02f, -4.55229841e-02f, 1.56378336e-02f, 9.62284580e-02f, 3.80230136e-02f, -3.26831751e-02f,
  -2.05626357e-02f, 3.99769992e-02f, -2.08040550e-02f, 6.16867421e-03f, -4.49450165e-02f, 1.66381728e-02f, -5.90737648e-02f, -8.80132169e-02f, 7.25416318e-02f, 1.71343461e-02f,
  2.64475971e-01f, -9.17184502e-02f, -2.76161462e-01f, -1.59409344e-01f, 5.48235066e-02f, 2.06786945e-01f, 5.55374436e-02f, 5.42769916e-02f, -2.24907547e-01f, 1.61439672e-01f,
  1.62255839e-01f, -6.62747175e-02f, -1.45200893e-01f, 1.34816900e-01f, 8.37634504e-03f, -8.57057646e-02f, 1.42345995e-01f, 4.66103815e-02f, -8.01940560e-02f, 9.50399339e-02f,
  -4.52078022e-02f, 2.36420646e-01f, -1.08596012e-01f, 1.44941151e-01f, 2.83829927e-01f, -6.81671947e-02f, 2.09911942e-01f, 3.08647584e-02f, 6.91964477e-02f, 1.11908264e-01f,
  -2.18190756e-02f, -6.01795726e-02f, -4.77721654e-02f, -5.13807386e-02f, 8.58346745e-03f, 4.93236259e-02f, -3.20668332e-02f, 5.98528311e-02f, -8.31630528e-02f, -8.08534250e-02f,
  2.62390133e-02f, -5.10316379e-02f, -1.23315575e-02f, 1.24867959e-02f, 2.93874014e-02f, -3.29214297e-02f, -1.00241974e-01f, -5.62960804e-02f, -1.68277100e-01f, 5.35624661e-02f,
  -1.90066934e-01f, -8.73657316e-02f, 2.73473072e-03f, -1.34152636e-01f, -7.14828521e-02f, -7.81852379e-02f, -7.62607604e-02f, 2.58853976e-02f, 2.48203753e-03f, -3.09271198e-02f,
  8.03120285e-02f, 9.91938338e-02f, -1.19601414e-02f, -5.99243417e-02f, -4.72909808e-02f, -1.34976223e-01f, 1.05164535e-01f, 1.19910026e-02f, 3.14365663e-02f, 4.02747579e-02f,
  -1.22980051e-01f, 2.42064763e-02f, 8.53938386e-02f, 1.21203393e-01f, 5.12015633e-02f, 6.09072521e-02f, 4.44878116e-02f, -9.82663501e-03f, -1.49414405e-01f, -4.28281613e-02f,
  1.98084749e-02f, -1.42278441e-03f, -7.04829618e-02f, 2.24215146e-02f, -3.49999033e-02f, -1.26455128e-01f, 7.55721182e-02f, 5.19076996e-02f, -1.13092419e-02f, -5.72347865e-02f,
  7.70596862e-02f, 4.81428690e-02f, -8.58028233e-02f, -5.46401031e-02f, -1.75229758e-01f, 7.08678961e-02f, -2.16706023e-02f, 8.43607709e-02f, -6.48739040e-02f, 4.15953510e-02f,
  3.05449520e-03f, -4.47764993e-02f, 9.64173581e-03f, -7.93043599e-02f, 2.02304572e-02f, 7.87967965e-02f, 3.86554282e-03f, -7.79667497e-02f, -5.80990501e-02f, 3.90126184e-02f,
  5.48947975e-02f, 3.96907292e-02f, -6.82734400e-02f, -1.78108230e-01f, -3.67115885e-02f, 3.22934724e-02f, 2.52943933e-02f, -1.98155157e-02f, 3.65665257e-02f, -8.67548287e-02f,
  -1.06785677e-01f, -8.31353143e-02f, 9.70046669e-02f, -9.96537507e-02f, -1.01833738e-01f, 1.16067916e-01f, 2.33907983e-01f, -2.44026616e-01f, -3.44329625e-01f, -1.48005977e-01f,
  1.08810805e-01f, -1.02814898e-01f, 2.01097444e-01f, 1.08048424e-01f, 1.77745998e-01f, 1.12793930e-01f, 2.08909232e-02f, 4.74226251e-02f, 6.51183352e-02f, 1.17463417e-01f,
  1.40927419e-01f, 1.82504937e-01f, 2.32626334e-01f, 3.74868810e-02f, 1.39471471e-01f, -5.46116717e-02f, -1.50355175e-02f, 2.01182500e-01f, -4.31998521e-02f, -1.87773351e-02f,
  1.45304665e-01f, -1.03538916e-01f, 7.92737529e-02f, -6.07303157e-03f, 5.44692837e-02f, 8.25952552e-03f, 5.92845492e-02f, 7.79999569e-02f, -1.23233125e-01f, -4.26873146e-03f,
  6.70096546e-04f, -6.59474581e-02f, -1.24085948e-01f, -3.82986404e-02f, -1.17939182e-01f, -1.55836031e-01f, -9.59937368e-03f, 3.30668353e-02f, -6.28059031e-03f, -1.47395944e-02f,
  5.02229147e-02f, 2.46473569e-02f, -9.48474109e-02f, -8.59500617e-02f, -1.49754003e-01f, -5.53765669e-02f, 2.59173643e-02f, 2.32402310e-02f, -1.30802393e-03f, -1.46829247e-01f,
  -3.64167541e-02f, 7.37770274e-02f, 3.46678570e-02f, -4.94779162e-02f, -4.18746993e-02f, -4.51617651e-02f, -3.28822359e-02f, -1.92316379e-02f, -5.78865521e-02f, 1.69852264e-02f,
  -7.19127357e-02f, -7.51347318e-02f, 5.63724265e-02f, 1.21525964e-02f, -6.08915091e-02f, 1.01113163e-01f, 1.69418275e-01f, 9.61634703e-03f, -1.12338781e-01f, 8.17983598e-02f,
  -3.19571383e-02f, -7.94493593e-04f, 3.72267631e-03f, -3.54992785e-02f, 5.15025631e-02f, 5.25289476e-02f, -2.93675940e-02f, 2.07289755e-02f, 9.96503755e-02f, 1.24872848e-01f,
  5.49076796e-02f, -1.01947829e-01f, 1.46938860e-03f, -9.37865004e-02f, -3.84040968e-03f, 5.60849383e-02f, 3.10215391e-02f, -8.42839703e-02f, -7.33177662e-02f, -2.55518202e-02f,
  -7.86566660e-02f, -2.00685896e-02f, -1.09954402e-01f, 8.57976377e-02f, -6.27298132e-02f, -3.77390832e-02f, 1.01973094e-01f, 6.77362829e-02f, 4.21213582e-02f, -7.72656687e-03f,
  -1.52800065e-02f, -4.99069020e-02f, -1.95699424e-01f, 1.70218050e-02f, -8.90266746e-02f, 1.74880289e-02f, -3.60329114e-02f, -3.78453322e-02f, -1.11649528e-01f, -8.95997360e-02f,
  -8.08091983e-02f, 9.17032138e-02f, -3.48695107e-02f, 1.47857517e-01f, 8.18758383e-02f, -1.57019645e-01f, -1.96390465e-01f, 1.22944899e-01f, -1.61791146e-01f, 1.23682499e-01f,
  1.84128866e-01f, 3.31501029e-02f, 3.80221829e-02f, 2.94381231e-01f, 2.35794306e-01f, -5.43743037e-02f, 2.71659493e-01f, -1.20623745e-02f, -8.66674725e-03f, 2.08566099e-01f,
  9.76504833e-02f, 2.92418867e-01f, 1.50170520e-01f, 1.96068034e-01f, 1.16190881e-01f, 8.65063742e-02f, 2.64913529e-01f, -1.18501885e-02f, 2.15881437e-01f, -3.74388210e-02f,
  -2.10386701e-02f, 1.26507031e-02f, -3.01189832e-02f, -1.32162496e-01f, 3.61061133e-02f, 2.48352401e-02f, -3.96148413e-02f, -4.05636951e-02f, 1.70626473e-02f, 9.62830409e-02f,
  2.29594260e-02f, 5.18148243e-02f, 1.34807631e-01f, 2.60304380e-03f, -1.97917260e-02f, -1.45287355e-02f, -3.04099154e-02f, -3.05047724e-02f, -5.63351251e-03f, 4.71115708e-02f,
  2.76866872e-02f, 7.31739029e-02f, -3.03035472e-02f, 6.30697459e-02f, 4.54582460e-03f, -5.99241368e-02f, 2.69649904e-02f, 8.38221386e-02f, 9.14625525e-02f, 7.41850468e-04f,
  1.82441413e-01f, -1.82424217e-01f, -2.23728307e-02f, -3.50352861e-02f, -3.92529480e-02f, -4.02953401e-02f, -7.08215088e-02f, 3.75011540e-03f, -4.49580774e-02f, 6.57320395e-02f,
  -9.46695805e-02f, 4.94771264e-02f, 1.64634455e-02f, -1.16325378e-01f, -3.82681452e-02f, -1.12544172e-01f, -5.05966656e-02f, 9.24142152e-02f, 1.44061660e-02f, 1.04174808e-01f,
  -4.44026291e-02f, -1.25019118e-01f, -5.65301888e-02f, 6.98138550e-02f, 8.22831504e-03f, -4.80831775e-04f, -3.09391860e-02f, 1.26214158e-02f, 2.31514629e-02f, -3.64852212e-02f,
  1.29557878e-01f, 1.38151437e-01f, -3.76528837e-02f, -6.87047914e-02f, -1.86030418e-02f, -2.77319271e-03f, 7.41997734e-02f, 2.49302257e-02f, 4.49509285e-02f, -5.30997962e-02f,
  8.21394175e-02f, -8.03251658e-03f, -4.22093682e-02f, 3.36201526e-02f, -3.25976908e-02f, -3.94817553e-02f, -8.31556916e-02f, -7.77768418e-02f, 3.04740341e-03f, 1.58927456e-01f,
  6.40478209e-02f, 1.15819022e-01f, -2.88615189e-02f, -1.03737108e-01f, 4.14978601e-02f, -4.80357674e-04f, 2.87387241e-02f, -3.21073495e-02f, 2.12610736e-01f, 2.20774952e-02f,
  2.67698407e-01f, 1.39176726e-01f, 1.45283610e-01f, 3.38499606e-01f, 1.98030859e-01f, -8.12256634e-02f, 3.46434042e-02f, 2.94817924e-01f, 4.54034567e-01f, -5.98835871e-02f,
  -5.24912290e-02f, -5.01126908e-02f, 2.68869009e-02f, 1.05115920e-02f, 1.45582661e-01f, 1.03475917e-02f, 1.60035089e-01f, -1.02698784e-02f, 1.75793275e-01f, 2.16435090e-01f,
  3.27973217e-01f, 8.74848962e-02f, -1.13852479e-01f, -4.14627828e-02f, 3.22935358e-02f, -1.54765053e-02f, -4.88773286e-02f, -1.28446549e-01f, -2.42602482e-01f, -5.80033474e-02f,
  1.77958026e-03f, 6.39348105e-02f, -5.63009493e-02f, -6.18921518e-02f, 9.46464092e-02f, -1.18966967e-01f, -9.90624055e-02f, -1.94421276e-01f, -2.82053240e-02f, -1.20760135e-01f,
  5.39231971e-02f, -1.11215964e-01f, 8.07911456e-02f, 2.43571657e-03f, 5.01718260e-02f, 1.44918710e-02f, -4.32744399e-02f, 6.58710152e-02f, -4.35086861e-02f, 6.35791495e-02f,
  9.61685628e-02f, 3.98249961e-02f, -4.65480331e-03f, -8.86712074e-02f, 1.31069934e-02f, 5.85162733e-03f, -5.55164069e-02f, 2.88126548e-03f, 1.89223804e-03f, -3.44891637e-03f,
  2.01734394e-01f, -3.52897905e-02f, -1.77711353e-01f, -1.30588979e-01f, -4.74769436e-02f, 7.11828694e-02f, -5.08229695e-02f, -7.62784630e-02f, -4.67057973e-02f, -2.70211678e-02f,
  -1.34369224e-01f, -4.65093479e-02f, 1.22933306e-01f, -6.03260621e-02f, 1.22213677e-01f, -4.43834290e-02f, 9.60944779e-03f, -9.57573503e-02f, 1.51058137e-01f, 9.76030380e-02f,
  -1.58725940e-02f, 2.66992971e-02f, -1.17590278e-01f, 2.70656925e-02f, -1.27294613e-02f, -3.97689790e-02f, 2.87245773e-02f, -1.26256875e-03f, -1.47857238e-02f, 5.54330088e-02f,
  2.06378698e-02f, 1.95983514e-01f, 2.56611835e-02f, -1.40818164e-01f, 8.43990296e-02f, -3.31643000e-02f, 5.25179394e-02f, -1.61339119e-02f, 3.53251658e-02f, -4.95646857e-02f,
  1.30889297e-01f, -8.30333084e-02f, 3.17640305e-02f, -1.34654921e-02f, 4.94866632e-02f, -4.74636778e-02f, -1.23064471e-02f, -2.11618580e-02f, 8.50846171e-02f, 1.15458511e-01f,
  -7.81244924e-03f, 2.18314826e-02f, 2.26735286e-02f, 1.41977772e-01f, -3.64125557e-02f, -2.69009508e-02f, 5.16371243e-02f, -1.63469017e-02f, 5.32617345e-02f, -2.96926256e-02f,
  9.89549905e-02f, -2.49936596e-01f, 1.40446320e-01f, -1.16091795e-01f, 2.63160150e-02f, -2.05221213e-02f, 4.65233661e-02f, -2.45785117e-01f, -1.56425804e-01f, -2.44235635e-01f,
  -5.03063463e-02f, 1.60325691e-01f, 3.37231368e-01f, -2.99530119e-01f, 5.29666245e-01f, 2.56689548e-01f, -1.66491732e-01f, 3.80658545e-02f, -2.85411235e-02f, -2.41546512e-01f,
  -1.63738400e-01f, -2.90841281e-01f, 1.37286171e-01f, -3.28791887e-01f, -2.41486818e-01f, -2.35502779e-01f, 1.49579868e-01f, 1.15665145e-01f, -2.06211105e-01f, 1.65747970e-01f,
  -2.41832435e-02f, -1.89379230e-01f, -7.33666942e-02f, -7.52678886e-02f, -1.01583518e-01f, 4.39238474e-02f, 4.31276578e-03f, 1.10907562e-01f, 4.44870852e-02f, -9.14260224e-02f,
  8.79591480e-02f, -2.80591361e-02f, -3.43371741e-02f, 5.26307262e-02f, -1.10326506e-01f, -8.42583925e-02f, -1.03699699e-01f, -2.21938603e-02f, -2.24662218e-02f, 9.55705866e-02f,
  1.61041897e-02f, -4.78095748e-02f, -4.55785543e-02f, 2.19340101e-02f, 9.69239883e-03f, -2.24209693e-03f, -4.32338053e-03f, 1.96258232e-01f, 4.54036053e-03f, -1.73147954e-02f,
  2.36923601e-02f, -5.27362637e-02f, -5.00237495e-02f, -4.69347686e-02f, -1.69720780e-02f, 5.68731651e-02f, -8.52599926e-03f, 6.08332492e-02f, 1.62017159e-02f, -3.42207327e-02f,
  -2.92221587e-02f, 5.16468883e-02f, 2.59845816e-02f, -8.45831633e-02f, -1.07632361e-01f, -1.66428119e-01f, 5.36575727e-02f, 7.78035149e-02f, 1.33627991e-03f, -2.03074571e-02f,
  -2.62566488e-02f, 3.51395644e-02f, 4.29421961e-02f, -4.01329584e-02f, 6.49109334e-02f, 4.68854234e-02f, -5.65212630e-02f, 3.72586772e-02f, -3.46910134e-02f, 6.51775077e-02f,
  -4.47235517e-02f, -1.93562523e-01f, -6.43958002e-02f, -7.20491707e-02f, 2.04138122e-02f, -1.65509477e-01f, -8.45197290e-02f, -9.07698274e-02f, 4.89527248e-02f, -6.86486140e-02f,
  1.34100709e-02f, -1.60899777e-02f, 6.21454716e-02f, -5.49208932e-02f, 2.83059161e-02f, -1.68384075e-01f, -4.57202531e-02f, 1.53344208e-02f, 6.43744916e-02f, 5.82814068e-02f,
  -4.65008728e-02f, 9.60722789e-02f, 8.90388712e-02f, -1.29228950e-01f, -1.25941038e-01f, 1.61387295e-01f, 2.14405097e-02f, -2.74170730e-02f, 1.29725128e-01f, 1.72007084e-02f,
  -2.65608042e-01f, 6.61050901e-02f, -2.06301212e-01f, 4.71927598e-02f, -2.76805192e-01f, 9.28278193e-02f, 2.74227440e-01f, -1.68484733e-01f, -2.29421094e-01f, 3.44114512e-01f,
  2.66738385e-01f, -2.27328107e-01f, 1.57037854e-01f, 4.34253961e-01f, -2.59451091e-01f, 2.55706817e-01f, 2.23077625e-01f, 1.53069183e-01f, -1.73687488e-01f, -5.80537738e-03f,
  -1.46917626e-01f, 2.86259353e-01f, 1.62550271e-01f, -6.47108555e-02f, 9.13177356e-02f, -9.97786224e-02f, 6.25636503e-02f, -9.92126390e-02f, 8.07229206e-02f, -8.83050412e-02f,
  1.81944788e-01f, -8.55571702e-02f, -1.02499951e-04f, 6.02731621e-03f, 5.51822484e-02f, 4.14159615e-04f, 4.17228322e-03f, -9.42120515e-03f, -7.86415488e-02f, -5.03938757e-02f,
  4.52293344e-02f, 9.70167294e-03f, -4.24732678e-02f, -1.04040325e-01f, -1.67048708e-01f, -6.62545264e-02f, 3.36117260e-02f, 3.65568101e-02f, 3.00803836e-02f, -5.64721189e-02f,
  -2.49840803e-02f, -3.10800783e-03f, 3.26486826e-02f, 7.18504190e-02f, -2.19930559e-02f, 6.10631630e-02f, 4.19641882e-02f, -6.77365810e-02f, -1.56480800e-02f, -9.69487280e-02f,
  -5.65433539e-02f, 1.83802117e-02f, 6.25033751e-02f, 3.07914093e-02f, 1.24309387e-03f, 1.14012405e-01f, 5.74637130e-02f, 8.97312239e-02f, -1.18249729e-01f, 9.31585431e-02f,
  6.28276840e-02f, 2.46444438e-02f, -2.52372120e-02f, -2.70161610e-02f, 4.42860601e-03f, 6.03579320e-02f, -3.46961804e-02f, -3.20840180e-02f, -2.40108860e-03f, 5.18762469e-02f,
  3.77538614e-02f, -2.11484395e-02f, 8.35960358e-02f, 5.23957238e-02f, -1.56579986e-02f, -4.20223102e-02f, -4.37952541e-02f, 4.67360094e-02f, 1.77844197e-01f, 1.29198320e-02f,
  3.97791415e-02f, -4.04461436e-02f, 3.98749895e-02f, -2.67501660e-02f, -3.97428125e-03f, -3.74133475e-02f, -8.34905505e-02f, -5.85802719e-02f, -1.59173571e-02f, -8.40516239e-02f,
  -8.76492709e-02f, 1.42703746e-02f, -2.52191648e-02f, 1.87857840e-02f, -9.61996540e-02f, 6.70543984e-02f, 1.14685722e-01f, -3.29720043e-02f, 2.15818472e-02f, -1.06826089e-02f,
  9.08496827e-02f, -1.78562489e-03f, -4.75986414e-02f, 8.76171887e-02f, -2.75561102e-02f, 5.74981906e-02f, -3.32314931e-02f, 3.45220976e-02f, -8.22665766e-02f, -1.70873590e-02f,
  -1.33409172e-01f, -1.11377090e-01f, -9.45170000e-02f, -2.16928303e-01f, -2.48984948e-01f, -1.70282610e-02f, -1.79607749e-01f, 2.36853994e-02f, 1.00818984e-01f, 7.98870698e-02f,
  -1.32736400e-01f, 3.65267391e-03f, 2.39740044e-01f, -2.05526739e-01f, 2.56726861e-01f, 3.32336217e-01f, -7.52768591e-02f, 2.55696848e-02f, -3.71950306e-02f, 2.16642935e-02f,
  -9.87944454e-02f, -2.10194960e-01f, -5.89048527e-02f, -1.08126000e-01f, -4.45059240e-01f, -2.39367589e-01f, -7.97166899e-02f, -2.28410915e-01f, -2.90093839e-01f, -2.60177642e-01f,
  -1.16187163e-01f, -2.41087660e-01f, -9.40368697e-02f, 2.62313131e-02f, -3.59842703e-02f, -1.95327047e-02f, -7.80748576e-02f, -2.13219710e-02f, -5.25103211e-02f, 6.57780096e-02f,
  5.73858358e-02f, 4.63433787e-02f, -9.76372287e-02f, 1.75034568e-01f, -3.40200141e-02f, -1.53924465e-01f, -1.25454053e-01f, -5.90907261e-02f, -1.11528113e-02f, 4.18295572e-03f,
  7.46869221e-02f, -9.45871070e-05f, -6.66144192e-02f, 9.23746899e-02f, -1.37654960e-01f, -6.17838278e-02f, 1.75916523e-01f, 6.76081181e-02f, -9.67563838e-02f, -3.51071618e-02f,
  -1.07058901e-02f, 7.65411928e-02f, 2.77454220e-03f, 6.59504309e-02f, 3.87570523e-02f, 5.82175180e-02f, 8.20479076e-03f, 2.45621987e-02f, -1.09660938e-01f, -4.20882292e-02f,
  2.47187819e-02f, -2.17433628e-02f, 1.92571525e-02f, -6.51869997e-02f, -1.34374071e-02f, 8.95911306e-02f, -1.17229559e-02f, 1.39213083e-02f, 5.51044531e-02f, -3.58545333e-02f,
  6.55363426e-02f, -1.18578121e-01f, -9.81713384e-02f, -2.41454262e-02f, -4.26347367e-02f, 6.58929646e-02f, 2.90747406e-03f, 1.31386733e-02f, -7.22296312e-02f, -6.02492318e-02f,
  -8.56797397e-02f, -1.84233472e-01f, -1.10540435e-01f, -3.36594619e-02f, 6.64468184e-02f, -6.13557436e-02f, -3.79644446e-02f, 4.36749831e-02f, -5.03864430e-04f, 1.21979648e-02f,
  -4.08242345e-02f, -1.70523301e-02f, 6.34448417e-03f, 3.48193273e-02f, 7.41683021e-02f, 4.52305470e-03f, -4.37150970e-02f, 1.11031853e-01f, -5.26151322e-02f, -9.42663327e-02f,
  7.55471438e-02f, 8.69852006e-02f, 1.48842245e-01f, -5.62842675e-02f, -1.94026753e-02f, -1.16812013e-01f, 1.50664076e-01f, -5.33205690e-03f, -1.21789008e-01f, 2.32057925e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.13752618e-01f, 1.53120294e-01f, 5.04322611e-02f, 2.02017754e-01f, 1.18525021e-01f, 9.65470895e-02f, 1.34359241e-01f, 8.52393433e-02f, 1.07656069e-01f, 6.67136386e-02f,
  5.09401932e-02f, 5.76263145e-02f, 9.12384465e-02f, 8.46521705e-02f, 1.76470816e-01f, 1.46867856e-01f, 4.94922772e-02f, 1.64188117e-01f, 8.90818611e-02f, 1.03438884e-01f,
  5.37330098e-02f, 4.85895909e-02f, 1.29451826e-01f, 1.04274414e-01f, 8.69813608e-04f, 7.30836391e-02f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  1.25720650e-01f, -8.60945787e-03f, 1.33480402e-02f, 1.04017831e-01f, 7.93293584e-03f, 2.10458990e-02f, 1.06351711e-01f, 8.78454521e-02f, 5.71100973e-03f, 3.85746956e-02f,
  -1.27821520e-01f, -4.35932018e-02f, 9.98700336e-02f, 2.55658701e-02f, 5.00030853e-02f, -1.40726836e-02f, 1.33057356e-01f, 8.28941092e-02f, 1.38865992e-01f, 4.45097201e-02f,
  3.53857763e-02f, 2.77272947e-02f, 6.23880960e-02f, 1.54002691e-02f, 1.57369971e-02f, 1.15983002e-01f, 3.06631494e-02f, -3.79441008e-02f, -4.47583906e-02f, 8.97481143e-02f,
  5.84993400e-02f, 3.60852629e-02f, -5.90954092e-04f, 8.97547230e-02f, 2.13873405e-02f, 1.10003456e-01f, 1.45586580e-01f, 7.96419606e-02f, 9.34354961e-02f, -8.17469656e-02f,
  8.47523194e-03f, -6.19629472e-02f, -1.03602961e-01f, 6.67217001e-02f, 8.57896656e-02f, -1.59982041e-01f, 3.09873689e-02f, 1.24987744e-01f, -2.85125757e-03f, 8.00820962e-02f,
  -5.50872125e-02f, 4.39998955e-02f, -2.64873803e-02f, 8.80318135e-02f, -8.98771826e-03f, 1.72709841e-02f, 2.31886338e-02f, 7.12901307e-03f, -6.85377344e-02f, -7.32086226e-02f,
  -5.32996096e-02f, 8.70828927e-02f, -2.23496687e-02f, 2.54508443e-02f, 9.62611362e-02f, -3.70629579e-02f, -5.80725446e-02f, -3.53753683e-03f, -9.50905532e-02f, 1.00485034e-01f,
  -4.60221469e-02f, -9.13867876e-02f, -4.16651443e-02f, 1.35592565e-01f, 1.24587007e-01f, -3.88675742e-02f, -1.37658596e-01f, 3.93279083e-02f, 1.16831057e-01f, 1.15952633e-01f,
  -1.15794202e-04f, 1.03260577e-01f, 1.53139783e-02f, -9.22908857e-02f, 1.02246694e-01f, -5.79880401e-02f, -1.68674782e-01f, -4.88830730e-02f, 6.62103295e-02f, 3.44051979e-02f,
  1.71508957e-02f, -8.07443112e-02f, -4.53366935e-02f, -2.51824427e-02f, 4.98166680e-02f, -1.31915165e-02f, 3.20193432e-02f, -3.33300717e-02f, -3.11729200e-02f, -1.12713344e-01f,
  1.05504267e-01f, 3.99051309e-02f, -3.40772606e-02f, -3.33916694e-02f, -3.37531529e-02f, 4.54864241e-02f, -8.02321211e-02f, -8.52316897e-03f, 1.17938675e-01f, 2.73904186e-02f,
  -1.99072421e-01f, -1.18933961e-01f, 4.38331366e-02f, 4.44122739e-02f, -4.12373282e-02f, -2.98290141e-02f, 6.10988680e-03f, -1.53788984e-01f, 1.11344114e-01f, 9.13520083e-02f,
  1.48650602e-01f, -1.12436507e-02f, -2.50769351e-02f, -8.75027776e-02f, -1.33136705e-01f, -2.53020022e-02f, 2.05560356e-01f, -3.12857516e-02f, -3.67556512e-02f, 4.24997285e-02f,
  4.10855226e-02f, 1.45748049e-01f, 3.84659413e-03f, -6.61676079e-02f, 3.41794267e-02f, 5.08763501e-03f, -1.22797079e-01f, 3.37929353e-02f, -4.73257303e-02f, -9.31074657e-03f,
  -3.92576642e-02f, -3.47190835e-02f, 7.21712690e-03f, -2.55495161e-02f, 7.92568773e-02f, -1.66192222e-02f, 2.46932283e-02f, -4.01520133e-02f, 3.33992625e-03f, 1.96529385e-02f,
  5.30407429e-02f, 6.86553167e-03f, -3.85736413e-02f, 5.40319756e-02f, 3.84989753e-02f, -7.10182998e-04f, -7.91851729e-02f, 6.10600151e-02f, 4.25730944e-02f, 1.10737467e-02f,
  7.35338852e-02f, 1.32832095e-01f, 3.29709635e-03f, 6.14245273e-02f, 7.25743994e-02f, 7.01034665e-02f, -3.38582844e-02f, -1.00961830e-02f, -5.08576855e-02f, -1.81646086e-02f,
  -4.63871919e-02f, -5.12099601e-02f, 1.01363435e-01f, -1.12895081e-02f, -4.59323190e-02f, 2.73527112e-02f, -4.98204455e-02f, 4.84117679e-02f, 5.71689382e-02f, -6.50844872e-02f,
  -4.32636589e-02f, 1.31629214e-01f, 7.10819289e-03f, 5.66902682e-02f, 7.62135461e-02f, 3.77889946e-02f, -1.64958522e-01f, -1.46306694e-01f, -1.64281905e-01f, 6.26702607e-02f,
  -1.00598298e-01f, -6.40389100e-02f, 1.20430373e-01f, -1.82658341e-02f, -1.34255081e-01f, -1.68092519e-01f, 5.23379929e-02f, -8.48777667e-02f, -6.49444610e-02f, 4.62417230e-02f,
  3.95168141e-02f, 4.29501384e-02f, -8.93340167e-03f, -2.44227387e-02f, 1.71708167e-02f, 6.37715682e-02f, 7.23862499e-02f, 1.08687982e-01f, -4.93760407e-02f, 5.94611578e-02f,
  -3.41883325e-03f, -7.19952583e-02f, 6.54169694e-02f, 6.35493454e-03f, 4.83673848e-02f, -1.08626850e-01f, 1.32794660e-02f, 1.09090353e-03f, -1.09246280e-02f, -1.33077055e-01f,
  -1.18207224e-01f, 6.82161003e-02f, 1.47092059e-01f, -1.88949574e-02f, 1.36807650e-01f, 2.42088854e-01f, -8.30837935e-02f, 8.53682458e-02f, 5.29179201e-02f, -4.59648436e-03f,
  -1.03759699e-01f, -2.21360214e-02f, -5.40533029e-02f, -1.43761963e-01f, 7.83038214e-02f, -6.14028126e-02f, -2.66446415e-02f, 9.85804945e-02f, -1.38554454e-01f, -1.43459439e-01f,
  2.91713607e-02f, -1.48787200e-01f, 2.02639475e-02f, -7.36619160e-02f, 5.57800829e-02f, -2.50528961e-01f, 1.26180142e-01f, -1.09915927e-01f, 1.96478590e-01f, 1.87779665e-02f,
  3.50239985e-02f, -1.99013501e-02f, 4.83555868e-02f, 1.11448675e-01f, -7.63988569e-02f, -3.21614258e-02f, 4.01771106e-02f, 2.17801575e-02f, -5.07362336e-02f, -4.32943627e-02f,
  -3.99715789e-02f, 1.50248269e-02f, 4.57886420e-02f, 2.81076059e-02f, -8.85493681e-03f, 9.29684471e-03f, 6.10370971e-02f, 3.45835648e-02f, -7.08601391e-03f, 1.06302567e-01f,
  -2.02793665e-02f, 2.34642327e-02f, -1.11475751e-01f, -4.94622178e-02f, -8.91873911e-02f, 5.16174100e-02f, 1.80615764e-02f, -6.25213683e-02f, -3.33402418e-02f, -1.19467666e-02f,
  -4.33025658e-02f, -7.68477246e-02f, 4.56364341e-02f, -7.94371665e-02f, 8.03773031e-02f, 8.90126394e-05f, -4.42266092e-03f, 3.45656276e-03f, -5.20917252e-02f, 1.07649490e-01f,
  -7.43607059e-02f, -1.91871561e-02f, -4.73169833e-02f, 1.16015319e-02f, 5.12467436e-02f, 9.80031863e-02f, 4.97204699e-02f, -6.59018010e-02f, 9.03520137e-02f, -5.17973267e-02f,
  4.74917963e-02f, 9.77704450e-02f, -1.04431309e-01f, -7.99829289e-02f, 1.10547826e-01f, 2.55669467e-02f, 1.64653677e-02f, -1.56306610e-01f, 3.32015008e-02f, -1.32206619e-01f,
  -9.68482494e-02f, 6.34883568e-02f, -3.09619661e-02f, -4.10363302e-02f, 2.07080469e-02f, -4.58174460e-02f, 4.76891287e-02f, -2.50357091e-01f, -2.69928318e-03f, -1.04555180e-02f,
  -1.03473820e-01f, 2.47643702e-03f, 7.51018748e-02f, 1.81668341e-01f, -5.21087162e-02f, -1.67006664e-02f, 1.11996662e-02f, 1.56265110e-01f, 5.55902384e-02f, -2.07658987e-02f,
  -1.22733116e-01f, 5.94811402e-02f, 9.16737989e-02f, -1.19168170e-01f, 3.14666405e-02f, -8.14628694e-03f, 2.94962376e-02f, -7.89784193e-02f, -6.74195141e-02f, 9.34171528e-02f,
  -1.52905032e-01f, 1.07069835e-01f, 1.24715291e-01f, -1.46343131e-02f, 1.96123160e-02f, 8.41161311e-02f, -1.51833892e-01f, 1.50063053e-01f, 1.59279525e-01f, -3.66489552e-02f,
  -1.06334630e-02f, 7.55165005e-03f, -1.00227550e-01f, -2.28477903e-02f, 1.33231925e-02f, 1.38642341e-01f, -1.62256718e-01f, -1.08423151e-01f, -1.08725630e-01f, 6.78335801e-02f,
  -1.62383035e-01f, 1.09466925e-01f, 1.58910036e-01f, -2.01577470e-01f, -3.36165614e-02f, -2.25418173e-02f, 2.44324535e-01f, 1.37912482e-01f, -1.02325775e-01f, -1.87348425e-02f,
  2.78596491e-01f, 3.79669704e-02f, 7.49936625e-02f, 1.91336066e-01f, -1.33054197e-01f, 1.45221978e-01f, -8.78280029e-02f, 2.73325574e-02f, -5.71901426e-02f, -6.93821833e-02f,
  1.57542855e-01f, -2.33195662e-01f, -4.91309799e-02f, -1.56137556e-01f, 1.12025939e-01f, -1.13941664e-02f, -1.26994208e-01f, -1.62272036e-01f, -5.46705499e-02f, 4.54988480e-02f,
  2.07514297e-02f, -3.22584473e-02f, 5.60398027e-02f, -5.68364449e-02f, 5.62674664e-02f, 8.03517550e-03f, -3.31202261e-02f, 5.51577844e-02f, 4.29237559e-02f, -1.13629717e-02f,
  -3.43377218e-02f, -3.59728448e-02f, -9.31913778e-02f, -2.84583960e-03f, 3.09430044e-02f, -6.17752001e-02f, -1.04673924e-02f, -1.79341376e-01f, -4.09497507e-02f, -1.71314168e-03f,
  -7.51382113e-02f, -6.77810386e-02f, 1.34874890e-02f, 1.39878057e-02f, -6.92053065e-02f, 3.11846416e-02f, -8.24795142e-02f, -5.98787032e-02f, -1.19928651e-01f, -5.49060926e-02f,
  -8.30326676e-02f, -1.68865267e-02f, -4.41757590e-02f, 5.66364229e-02f, -2.60729139e-04f, -3.68491858e-02f, 1.25853736e-02f, -3.60610373e-02f, -2.40746215e-02f, 7.44112357e-02f,
  -4.53425944e-02f, -8.20673164e-03f, 3.57318111e-02f, -9.72369909e-02f, 4.47138250e-02f, -3.03399134e-02f, -4.73410152e-02f, 1.18661812e-02f, -9.93124321e-02f, 3.17084976e-02f,
  -1.33744761e-01f, -5.71188405e-02f, 6.92742467e-02f, 1.18204556e-01f, 4.21590395e-02f, 1.22932217e-03f, 3.46075594e-02f, -5.98453507e-02f, -8.13127309e-02f, 8.37448239e-02f,
  1.91854924e-01f, 1.13603108e-01f, -1.47864312e-01f, 1.48345008e-01f, -7.39721507e-02f, 3.83482873e-02f, 1.41395461e-02f, 1.27054546e-02f, -1.57524552e-02f, 6.77790586e-03f,
  -3.32768969e-02f, -3.54519039e-02f, -2.77398042e-02f, -6.73156828e-02f, -1.26507580e-02f, -7.24255294e-02f, 1.86895598e-02f, -2.48957053e-02f, -3.18366885e-02f, 5.84439561e-02f,
  -5.15069366e-02f, 6.57274202e-02f, -1.14896875e-02f, 1.24433637e-02f, 5.39453290e-02f, -5.43331727e-02f, 9.98716280e-02f, -1.15419671e-01f, -4.92532887e-02f, -2.85112485e-02f,
  -3.40895429e-02f, -2.38686651e-01f, 2.73219422e-02f, 1.15561448e-02f, -3.30791026e-02f, -1.57835752e-01f, -9.98408422e-02f, 8.83576423e-02f, -1.11683950e-01f, -6.25418350e-02f,
  -7.74212256e-02f, -2.00906113e-01f, -1.59091264e-01f, -7.65599087e-02f, 1.55896842e-01f, 1.21526070e-01f, -1.18264735e-01f, 1.70652404e-01f, 9.84133184e-02f, 1.00228019e-01f,
  1.46419376e-01f, 1.02374546e-01f, -2.28492841e-01f, 2.49453351e-01f, -1.60265073e-01f, -9.90808085e-02f, 5.44908307e-02f, -6.78536445e-02f, -6.49692044e-02f, -1.48701087e-01f,
  1.55506223e-01f, -1.22045737e-03f, -1.20164029e-01f, -2.66743824e-03f, 6.53939182e-03f, 9.92245227e-02f, 6.30436465e-02f, -2.82877404e-02f, 4.07068543e-02f, -1.05396353e-01f,
  -4.66072708e-02f, -5.09655382e-03f, -4.33987640e-02f, -7.33508393e-02f, 7.36869052e-02f, -2.79936958e-02f, -4.59049046e-02f, -2.63279937e-02f, 3.80816087e-02f, -2.87807230e-02f,
  -1.95832308e-02f, 1.33161061e-02f, 1.13817174e-02f, 7.70170912e-02f, 1.68219744e-03f, 4.48950119e-02f, -6.73606666e-03f, 3.06905098e-02f, 2.08767522e-02f, 4.76757400e-02f,
  4.94869687e-02f, 7.67802969e-02f, 2.29085665e-02f, -1.24263018e-01f, -1.43236956e-02f, -3.21595632e-02f, 2.15041675e-02f, 2.22875476e-02f, 4.52103801e-02f, 2.66767461e-02f,
  6.49891347e-02f, 4.91301604e-02f, -4.41972949e-02f, 2.70073526e-02f, -2.84125265e-02f, -6.85210433e-03f, 7.09831566e-02f, -8.56165867e-03f, 1.65084321e-02f, -2.03397665e-02f,
  -6.64447621e-02f, 1.03429087e-01f, -4.45724055e-02f, 4.59081978e-02f, -5.20076044e-02f, 4.48410399e-02f, 5.96777461e-02f, 6.64707571e-02f, 1.18368141e-01f, -4.77657095e-02f,
  -1.07899159e-01f, -1.19793355e-01f, 4.70738821e-02f, -4.91201691e-02f, -2.92688534e-02f, -4.89345985e-03f, -1.17803492e-01f, 5.73442914e-02f, 4.33956459e-02f, -2.95838937e-02f,
  -9.46536139e-02f, -1.97831199e-01f, -1.64445806e-02f, -8.46320987e-02f, 1.86606467e-01f, 7.46136606e-02f, 1.43749162e-03f, 5.74300950e-03f, 1.55895621e-01f, 2.02556159e-02f,
  3.34627889e-02f, 6.30001873e-02f, 1.45057077e-02f, -2.30413694e-02f, -2.68063508e-02f, 6.43257238e-03f, 4.23114188e-03f, -9.64101255e-02f, -1.34303672e-02f, -1.05813749e-01f,
  3.55258882e-02f, -5.72531894e-02f, -1.29605934e-01f, -1.25506818e-01f, 2.60891523e-02f, 4.85891514e-02f, 7.16238990e-02f, -8.30129385e-02f, -4.04938832e-02f, 8.87343735e-02f,
  8.88590142e-02f, -4.51737531e-02f, -2.35535484e-02f, -3.74650098e-02f, -1.22469645e-02f, -1.62327975e-01f, 1.12488844e-01f, -6.66460022e-02f, 1.42254099e-01f, 1.31093949e-01f,
  6.80728331e-02f, 9.31878760e-03f, -1.84980139e-01f, -7.70044848e-02f, 1.59909353e-01f, -1.67978629e-01f, -5.65274470e-02f, -2.87839901e-02f, 3.55687514e-02f, -1.54894993e-01f,
  1.15490995e-01f, 2.34337263e-02f, 8.97864699e-02f, 1.26560017e-01f, 1.05356257e-02f, 1.41793162e-01f, 5.79159670e-02f, -1.02357455e-02f, 3.08860163e-03f, -2.12869197e-01f,
  -3.01124789e-02f, 6.36658520e-02f, -2.52610398e-03f, 2.23864280e-02f, 8.47927257e-02f, -1.19471466e-02f, -8.01922195e-03f, 8.97364318e-02f, 3.00838444e-02f, 5.94814159e-02f,
  -7.29457363e-02f, 2.44745743e-02f, -5.26169129e-02f, -7.77035654e-02f, -2.86897924e-02f, -3.86535376e-02f, -2.61597540e-02f, 3.78672616e-03f, 4.15121727e-02f, 4.90627550e-02f,
  -9.77586256e-04f, 9.99402441e-03f, -1.38574373e-03f, -1.95472334e-02f, 3.88190821e-02f, 1.65903643e-02f, 9.90047157e-02f, -4.12154989e-03f, 5.08430712e-02f, -4.22147475e-02f,
  3.94164585e-02f, 4.06193361e-02f, 1.88428298e-01f, 1.84412509e-01f, -4.18472709e-03f, 6.58243075e-02f, 4.71083038e-02f, -1.04116509e-02f, -2.24950276e-02f, -2.68405005e-02f,
  -7.19651803e-02f, 3.11750378e-02f, 5.06759882e-02f, -1.19835287e-02f, 2.03284733e-02f, 3.26664187e-02f, -7.01595545e-02f, -2.76357699e-02f, 6.17193021e-02f, 6.41577393e-02f,
  8.60555917e-02f, -8.40253010e-02f, 3.94620933e-02f, 8.65297690e-02f, -1.32495752e-02f, 5.01239486e-02f, 1.16760202e-01f, 9.22193378e-02f, 9.96403918e-02f, -1.34877384e-01f,
  -1.45781994e-01f, 9.84340310e-02f, -1.08304776e-01f, 7.76713639e-02f, 2.38359213e-01f, -7.35641122e-02f, -9.86557007e-02f, -3.48482281e-02f, 2.36462548e-01f, -7.33893961e-02f,
  -1.55519977e-01f, 1.77975655e-01f, -7.27623759e-04f, -6.41882792e-02f, 1.11351937e-01f, 1.53022587e-01f, 6.07319027e-02f, 8.21641386e-02f, 2.27494426e-02f, -9.53188352e-03f,
  6.45566955e-02f, 9.47541371e-02f, 1.61513150e-01f, -9.76232253e-03f, 5.80443330e-02f, 1.05613063e-03f, 2.55575646e-02f, -7.60987177e-02f, -5.89614473e-02f, -1.32999914e-02f,
  2.89525557e-02f, -1.28291929e-02f, -1.42330527e-01f, 1.18993349e-01f, 1.18889660e-01f, 5.56080937e-02f, 1.25120282e-01f, 1.76512524e-01f, 7.87233375e-03f, 1.50957689e-01f,
  -1.36305615e-01f, 1.48334140e-02f, -2.18416452e-02f, 4.09175642e-02f, -1.48881510e-01f, -4.65860553e-02f, 1.14594691e-01f, -1.58255547e-02f, 2.07437649e-02f, -4.12538126e-02f,
  -6.38183653e-02f, -9.30580199e-02f, -1.06879868e-01f, -5.05870804e-02f, -7.17230523e-06f, -1.43495142e-01f, -2.25862139e-03f, -2.15650201e-01f, -2.38878676e-03f, -1.76033616e-01f,
  2.10833117e-01f, -8.12692335e-04f, 6.17064498e-02f, -1.19512036e-01f, 2.38495190e-02f, 1.83203056e-01f, -1.45214945e-01f, 6.73289075e-02f, -3.19042429e-02f, -2.19173972e-02f,
  7.60209188e-02f, 1.58047341e-02f, -7.41384476e-02f, -6.96566850e-02f, -1.00306116e-01f, -1.21201091e-01f, -5.04054241e-02f, 5.84042892e-02f, -6.36122003e-02f, -6.89572245e-02f,
  2.37077055e-03f, -3.57213765e-02f, -4.13203835e-02f, -4.21845429e-02f, 4.29299101e-02f, 1.42914448e-02f, -1.13674320e-01f, -1.56447962e-01f, 6.76966086e-02f, -3.13999616e-02f,
  -7.48857632e-02f, -5.87359518e-02f, -8.99784267e-02f, -1.90713012e-03f, -1.90237701e-01f, 7.38140335e-03f, -6.27049729e-02f, -7.54817622e-03f, -6.61334917e-02f, -1.29629835e-01f,
  -5.63304424e-02f, -1.36256471e-01f, 2.39230618e-02f, -4.39846776e-02f, -8.85793120e-02f, -2.75148638e-02f, 4.87510711e-02f, -1.99666284e-02f, 3.72196659e-02f, 8.15903321e-02f,
  -6.28252253e-02f, -5.23025095e-02f, -1.43101081e-01f, 5.25360703e-02f, -6.62121107e-04f, 2.02266164e-02f, -6.37277588e-02f, 5.07765859e-02f, -9.72905383e-02f, 7.94841498e-02f,
  -5.92749491e-02f, 9.43445936e-02f, -4.76688482e-02f, -5.94927929e-02f, 1.38522238e-01f, 4.48197685e-02f, 1.18747666e-01f, -9.93984938e-02f, 8.35128948e-02f, 1.05846845e-01f,
  -2.00654507e-01f, 6.21730015e-02f, -9.08908173e-02f, 7.65366107e-02f, 9.19111446e-03f, -4.37431782e-02f, -5.02921641e-02f, -7.16541633e-02f, -5.92131987e-02f, -5.01167402e-02f,
  4.34870459e-02f, -1.07732989e-01f, 1.27945423e-01f, 9.79963467e-02f, -2.30707526e-02f, 4.64143902e-02f, 2.10704538e-03f, 9.26877111e-02f, -4.40250039e-02f, -3.24226916e-03f,
  1.52161112e-02f, -8.11591148e-02f, -4.55294177e-02f, -7.43014663e-02f, -4.16478738e-02f, -2.22571969e-01f, 6.73480146e-03f, -1.92158550e-01f, 6.92581311e-02f, -9.18564051e-02f,
  -8.44211504e-02f, 1.51695624e-01f, 7.27459267e-02f, 3.95955630e-02f, 9.40795150e-03f, 1.02494970e-01f, -2.33348906e-02f, 6.89634075e-03f, 3.33578363e-02f, -2.69786753e-02f,
  -2.12105662e-02f, -1.14601314e-01f, -1.26975238e-01f, -1.00604303e-01f, 1.10534318e-01f, 7.25669554e-03f, -1.06727136e-02f, -6.94212615e-02f, -1.97462365e-01f, -2.41218843e-02f,
  1.50223047e-01f, 1.10967420e-02f, -1.65904820e-01f, -1.24015532e-01f, -4.65855747e-02f, -6.30132705e-02f, 5.77941863e-03f, -1.21335819e-01f, 9.95048806e-02f, 1.20391011e-01f,
  1.42830908e-01f, -6.20808713e-02f, -9.49826166e-02f, 2.05542088e-01f, 1.95043638e-01f, 2.89773680e-02f, 3.13534178e-02f, 9.32238344e-03f, -1.72275992e-03f, -1.40281413e-02f,
  6.17223606e-02f, 9.88334939e-02f, 1.16555095e-01f, 5.11349253e-02f, 2.85334047e-02f, -3.89498360e-02f, 5.55987544e-02f, 7.21066669e-02f, -5.80797717e-02f, 9.46858227e-02f,
  2.64717657e-02f, 7.55380839e-03f, 1.42446179e-02f, 2.17330549e-02f, 5.37837781e-02f, -2.29461472e-02f, 1.75384693e-02f, -1.25773894e-02f, 2.41897199e-02f, -8.34773779e-02f,
  1.90353161e-03f, 1.75259579e-02f, -4.42219749e-02f, -7.23306509e-03f, -3.56070772e-02f, 1.37283236e-01f, 5.04497141e-02f, 6.87491074e-02f, 1.88398771e-02f, -3.65629196e-02f,
  2.83536557e-02f, -2.84728166e-02f, 2.08581542e-03f, 1.65212564e-02f, -7.61748850e-02f, 3.29743065e-02f, 2.03095120e-03f, -8.45985580e-03f, -7.88423885e-03f, 6.77331090e-02f,
  4.58502807e-02f, -4.16306779e-02f, 1.66134704e-02f, 5.87009974e-02f, -1.13930916e-02f, -4.20347340e-02f, -4.38649170e-02f, 1.07202835e-01f, 6.19626120e-02f, -9.05186459e-02f,
  -4.00347710e-02f, -3.13515924e-02f, -6.65854011e-03f, -8.92027840e-03f, -2.32863482e-02f, 7.36840665e-02f, 2.82223169e-02f, 7.02448934e-02f, 7.40021169e-02f, -8.02006349e-02f,
  1.14660496e-02f, 4.53589000e-02f, 3.05285640e-02f, -4.82966099e-03f, -7.95332715e-02f, 1.47902191e-01f, -4.40864041e-02f, 3.01278103e-02f, -1.66357756e-02f, 5.55262202e-03f,
  3.84322442e-02f, -2.56717891e-01f, -2.81641353e-02f, 1.04053065e-01f, 4.87791114e-02f, 8.09422955e-02f, -1.72589302e-01f, 2.94883344e-02f, -1.13097757e-01f, -1.19933411e-01f,
  3.11317760e-02f, 2.24771984e-02f, -8.27281773e-02f, 2.14059845e-01f, 6.25911802e-02f, 1.02457494e-01f, 3.55606899e-02f, 2.25427505e-02f, -2.87141688e-02f, -1.65874481e-01f,
  -4.29330431e-02f, -1.69921413e-01f, 9.54145342e-02f, -8.77306610e-02f, -9.98486206e-03f, -1.02590602e-02f, -5.48292883e-04f, 4.38130461e-02f, -8.22056159e-02f, 1.10120863e-01f,
  -2.88620591e-03f, -2.65343115e-02f, -1.05346769e-01f, -1.46411583e-01f, -5.75648136e-02f, -2.25271806e-02f, 7.10261688e-02f, 9.46142897e-02f, 2.67164484e-02f, 1.66096136e-01f,
  -9.41033214e-02f, -1.43876728e-02f, -9.06694382e-02f, -2.08788626e-02f, -6.75655901e-02f, -1.15974978e-01f, -1.60962000e-01f, 2.83622611e-02f, 3.26929502e-02f, 1.54090952e-02f,
  1.96263026e-02f, -1.01437882e-01f, 1.56519577e-01f, 3.90936434e-02f, 2.99634933e-02f, -5.06365038e-02f, -1.15977980e-01f, -1.14668950e-01f, -8.61642603e-03f, 5.04038110e-03f,
  -6.18018135e-02f, -1.64037272e-02f, 9.16311592e-02f, 7.33235676e-04f, 7.29995519e-02f, -1.90560762e-02f, -1.24895811e-01f, 1.98321622e-02f, -4.47907224e-02f, -2.38293298e-02f,
  -9.99290347e-02f, -7.33606750e-03f, 1.12239672e-02f, -7.61976093e-02f, -2.65995897e-02f, -5.22639379e-02f, -1.09759353e-01f, -2.91821640e-02f, -5.49691953e-02f, -1.03780851e-01f,
  -4.66204956e-02f, -8.76007508e-03f, -3.28610055e-02f, -6.51195273e-02f, -6.92116246e-02f, -5.82621507e-02f, 6.33460060e-02f, -8.53645205e-02f, -1.95149183e-02f, -8.23315680e-02f,
  -1.46416172e-01f, -6.92374483e-02f, -7.30526596e-02f, -4.05558944e-03f, -3.43707986e-02f, -3.37090641e-02f, 1.89057402e-02f, -4.80836444e-02f, -1.16362251e-01f, -1.06934234e-02f,
  -2.51260437e-02f, -1.75021179e-02f, -4.96407691e-03f, -1.35720417e-01f, -2.92145815e-02f, 4.88285087e-02f, 1.26303107e-01f, -1.77814797e-01f, -5.11231385e-02f, -1.35015815e-01f,
  1.96738485e-02f, 6.09892793e-02f, 7.12516233e-02f, 6.83664083e-02f, 1.03288971e-01f, -7.66360536e-02f, 1.38887808e-01f, 1.37277264e-02f, -9.45364907e-02f, -3.69212739e-02f,
  3.61098582e-03f, 8.50682482e-02f, -1.12140151e-02f, 8.86130035e-02f, 1.34035885e-01f, 8.17546546e-02f, -2.69961488e-02f, -9.66436416e-02f, -1.23881372e-02f, -1.11222208e-01f,
  -1.32745439e-02f, -3.33161466e-02f, -1.39689416e-01f, -2.07051300e-02f, -3.28149199e-02f, -8.33906382e-02f, -5.71760945e-02f, 9.69110988e-03f, -8.29735920e-02f, 1.08604170e-02f,
  3.32664177e-02f, 9.56750810e-02f, -1.11761149e-02f, -1.18976925e-02f, -5.89140765e-02f, 1.56689703e-01f, 3.04074623e-02f, -4.68601361e-02f, -2.62051430e-02f, 6.28253967e-02f,
  -1.10781817e-02f, -7.36076012e-02f, 1.35606294e-02f, 1.10112699e-02f, -5.38230874e-02f, 1.63708106e-01f, -2.62529776e-02f, 1.74196679e-02f, -1.18343689e-01f, 1.48515388e-01f,
  -1.23361461e-02f, -9.30330530e-02f, -4.18894371e-04f, -4.10528556e-02f, 1.76007092e-01f, 1.24977373e-01f, -1.55999158e-02f, 8.57712179e-02f, -3.47280428e-02f, -3.82236019e-02f,
  -1.53884634e-01f, 2.00893804e-01f, -1.36842638e-01f, -1.04793839e-01f, -1.50662079e-01f, -2.95630237e-03f, -7.55695999e-02f, -1.26151396e-02f, -4.09578122e-02f, -2.33233906e-02f,
  -1.17048867e-01f, 9.20756534e-02f, -2.44517568e-02f, 3.90861332e-02f, -3.27345207e-02f, -5.84918559e-02f, -3.27356867e-02f, 3.99958827e-02f, 9.02126729e-02f, 9.60922614e-02f,
  -1.55211855e-02f, -2.25958116e-02f, -2.90435716e-03f, 8.58207420e-02f, -2.04375461e-02f, 9.98473242e-02f, -5.63752390e-02f, -6.30310252e-02f, 5.61785419e-03f, -3.05730868e-02f,
  -8.38970467e-02f, 7.40575418e-02f, -3.42794620e-02f, -2.27773972e-02f, 8.06245282e-02f, 2.58156769e-02f, -8.91708024e-03f, -2.57608481e-03f, 7.00960681e-02f, -5.44860922e-02f,
  4.48867530e-02f, -9.58996192e-02f, 4.05214913e-03f, 8.71402398e-02f, 7.04475567e-02f, 1.30733714e-01f, -4.18737121e-02f, -3.76924574e-02f, -1.64977275e-02f, 4.98280674e-02f,
  -4.90529910e-02f, 5.24154007e-02f, 9.33929160e-03f, 3.16509814e-03f, 5.03811128e-02f, 1.86422821e-02f, 9.32219774e-02f, 1.28394172e-01f, -4.16358039e-02f, -6.57905489e-02f,
  6.60653859e-02f, -5.43318801e-02f, 2.03717470e-01f, -2.12932155e-01f, -1.24735363e-01f, 1.24639489e-01f, -8.62177238e-02f, 6.00295467e-03f, -4.86251563e-02f, -2.60691065e-02f,
  -9.02127381e-03f, 1.19942755e-01f, -1.33562580e-01f, -7.26050064e-02f, -4.38671112e-02f, -4.53274548e-02f, 2.30832975e-02f, 6.79385588e-02f, 7.76003152e-02f, -1.30258137e-02f,
  -5.54179251e-02f, -8.27326253e-02f, -5.26926704e-02f, 2.10869148e-01f, -8.23904425e-02f, 8.41402188e-02f, -1.37130111e-01f, 1.12121806e-01f, 1.17912710e-01f, -8.06123540e-02f,
  -2.91584786e-02f, -1.02410614e-01f, 2.78742928e-02f, -7.03937262e-02f, 5.26280925e-02f, 2.23841071e-02f, -7.53742084e-03f, 2.00747043e-01f, 9.73443165e-02f, 5.79880103e-02f,
  -4.16569188e-02f, 7.50145130e-03f, 2.05225330e-02f, -1.85721144e-02f, -7.75986090e-02f, 2.61156969e-02f, -2.03922689e-02f, 9.35577694e-03f, 4.81912680e-02f, -2.13548206e-02f,
  -4.13525961e-02f, 2.14974537e-01f, -1.12475574e-01f, -1.51662052e-01f, -3.27262171e-02f, 1.55476674e-01f, -9.55375507e-02f, -1.12646885e-01f, 1.03556804e-01f, -1.20380417e-01f,
  -2.02761903e-01f, 2.63346974e-02f, 1.63815781e-01f, 1.08703710e-01f, -2.20534667e-01f, -9.02085751e-02f, 2.28520676e-01f, 1.01008281e-01f, 1.44161671e-01f, 2.99444832e-02f,
  -1.08937204e-01f, 1.54176578e-01f, 1.10310316e-02f, -1.86443582e-01f, -1.11161493e-01f, -1.37512863e-01f, 8.07053819e-02f, -5.39354533e-02f, -7.66902491e-02f, 4.15510982e-02f,
  1.28492728e-01f, -3.68991718e-02f, -1.04539031e-02f, -6.91578584e-03f, 6.42607035e-03f, -2.33279075e-02f, 2.73479167e-02f, -3.57071683e-02f, -6.38602301e-02f, -6.92641512e-02f,
  1.43375829e-01f, -2.48565190e-02f, -5.57418987e-02f, 6.68858588e-02f, 3.85278873e-02f, 5.24945837e-03f, 2.10676342e-02f, -1.67419743e-02f, -9.11643282e-02f, -9.36981589e-02f,
  3.69674228e-02f, -7.02349171e-02f, -4.74986061e-02f, -1.05359726e-01f, -4.05438505e-02f, -4.04499797e-03f, -1.39425084e-01f, 3.89731629e-03f, -8.79252106e-02f, 1.56096399e-01f,
  2.57278932e-03f, -1.36348763e-02f, -9.09632146e-02f, -1.01201355e-01f, -5.82816172e-03f, 1.54851610e-02f, -8.40102881e-02f, -7.22594606e-03f, -3.82100057e-04f, 4.23333384e-02f,
  2.26564482e-02f, -3.79711565e-07f, -3.55713703e-02f, -1.17611997e-02f, 3.86627465e-02f, -9.17169824e-02f, 6.71732649e-02f, 1.30434250e-02f, -8.57123360e-02f, -6.68808771e-03f,
  -5.47809005e-02f, 1.20976664e-01f, 1.53017744e-01f, -2.00425655e-01f, -6.37430176e-02f, -4.99332510e-02f, 4.15319912e-02f, 1.08544680e-03f, -2.04496570e-02f, 1.00735007e-02f,
  1.18122108e-01f, 5.71221784e-02f, 7.12753832e-02f, 6.64019305e-03f, -7.27434307e-02f, -4.41595241e-02f, 9.95927081e-02f, 4.78764810e-02f, -2.80109011e-02f, 1.84035644e-01f,
  2.23594401e-02f, -1.37166036e-02f, 4.95872200e-02f, -3.09045892e-02f, 4.54148762e-02f, -2.63115436e-01f, -1.07442051e-01f, 6.51400983e-02f, -1.52455475e-02f, 5.62054142e-02f,
  -1.61596984e-01f, 4.34940159e-02f, -2.87284613e-01f, -8.83061215e-02f, -8.40646997e-02f, -9.93756205e-02f, -1.24961659e-01f, 1.41015664e-01f, 7.96560794e-02f, 4.68246229e-02f,
  3.67617910e-03f, 1.68439932e-02f, 5.88395707e-02f, -1.21101163e-01f, -6.94136182e-03f, -9.46364552e-02f, -3.47456113e-02f, 2.64792610e-02f, -2.69719819e-03f, -5.83103746e-02f,
  2.81939656e-02f, 1.07606366e-01f, -1.89794645e-01f, 6.33588582e-02f, -8.89031813e-02f, 6.50402531e-02f, -1.23085663e-01f, -1.37366921e-01f, -2.54555065e-02f, -2.32919976e-02f,
  1.04519174e-01f, 1.34641916e-01f, 1.37924522e-01f, 1.63816646e-01f, -2.09394082e-01f, -1.11184090e-01f, -6.82565272e-02f, 7.22882375e-02f, -3.76344733e-02f, -1.32568657e-01f,
  -1.70205861e-01f, 5.43798320e-02f, 7.48462752e-02f, 1.44716837e-02f, -1.48483872e-01f, -8.62549320e-02f, 2.26713359e-01f, -1.24253482e-01f, -7.08177909e-02f, 2.95075662e-02f,
  6.20870665e-02f, 5.06623089e-02f, -5.09200767e-02f, -5.05900867e-02f, 7.64535964e-02f, -2.57078446e-02f, -8.90945494e-02f, 2.29301583e-02f, -2.25633122e-02f, 3.72277126e-02f,
  3.44523950e-03f, -3.54356505e-02f, -1.61049962e-02f, -1.18012512e-02f, 7.08337426e-02f, -2.54242681e-02f, 1.10362738e-01f, 3.02814767e-02f, -4.81793806e-02f, 2.81107668e-02f,
  9.71336067e-02f, 6.51888400e-02f, -4.13869359e-02f, 4.59265821e-02f, 9.89638939e-02f, -5.37454672e-02f, -1.64423250e-02f, -6.30606264e-02f, -1.95665490e-02f, 6.57614842e-02f,
  -3.62272784e-02f, 3.20513174e-02f, 1.14093171e-02f, 2.22771205e-02f, 7.59744644e-02f, -4.07964224e-03f, -8.42564255e-02f, 3.80146201e-03f, -5.33221774e-02f, 1.80772282e-02f,
  -1.55360280e-02f, -2.33723205e-02f, 8.90986323e-02f, -6.14934079e-02f, 1.99372265e-02f, -5.78051396e-02f, 2.06531119e-02f, -1.61269102e-02f, -5.27447872e-02f, -5.21268584e-02f,
  -9.24269632e-02f, 1.16664998e-01f, 7.63969347e-02f, 7.33923838e-02f, -1.03754468e-01f, -2.74525676e-02f, -2.11303532e-01f, -7.34521672e-02f, -1.14955567e-01f, -5.79858646e-02f,
  -4.07907069e-02f, -1.55868918e-01f, -4.69233431e-02f, 5.43784574e-02f, -1.06087893e-01f, -1.56029105e-01f, -4.10079397e-02f, -1.16259016e-01f, 5.48336096e-02f, -3.89607698e-02f,
  3.35612893e-02f, 4.85616289e-02f, -2.25252599e-01f, 1.62555464e-03f, 1.19583592e-01f, -1.69141237e-02f, -9.04957298e-03f, 7.30909109e-02f, 5.20782955e-02f, -9.21298005e-03f,
  1.13386884e-02f, -2.67645949e-03f, 5.90611286e-02f, 8.64991546e-02f, 1.82558239e-01f, 2.75127850e-02f, 3.55428755e-02f, 8.69289860e-02f, -8.69252831e-02f, -9.91644263e-02f,
  -8.32417086e-02f, -3.91725115e-02f, 4.63028066e-02f, -2.72743683e-02f, 1.00200139e-01f, 6.69199154e-02f, -1.20361328e-01f, -2.97930441e-03f, 4.06313539e-02f, -8.52365699e-03f,
  1.62555590e-01f, -3.37745398e-02f, 1.31234318e-01f, -2.29486927e-01f, 4.66629304e-02f, 4.52558249e-02f, -1.63761713e-02f, 1.49731889e-01f, -7.80182630e-02f, -1.83717728e-01f,
  1.39286771e-01f, -1.68202102e-01f, 1.69081703e-01f, 1.51007637e-01f, 7.03478903e-02f, -1.20872252e-01f, 1.50358155e-01f, 9.26706493e-02f, 5.63692078e-02f, 3.75517346e-02f,
  -1.09592937e-01f, 2.20591463e-02f, 1.41540855e-01f, -1.33244038e-01f, -1.20660201e-01f, -6.19539469e-02f, 9.35140029e-02f, -7.47116357e-02f, 3.49465199e-02f, -6.99169040e-02f,
  7.06831962e-02f, 4.88049649e-02f, -3.49568799e-02f, -2.18324102e-02f, -1.85349658e-02f, -1.66105723e-03f, 1.86126679e-01f, 2.28184275e-02f, -5.63500300e-02f, -3.96992974e-02f,
  6.00204915e-02f, 3.02607333e-03f, -2.16477830e-02f, 5.87667758e-03f, -6.39761835e-02f, -9.09209475e-02f, 1.71154719e-02f, -3.33774649e-02f, -6.41369373e-02f, -1.12146839e-01f,
  -4.41083265e-03f, 2.14347336e-02f, -1.42848507e-01f, 9.61516798e-03f, 3.76475491e-02f, 7.22047910e-02f, 4.25503682e-03f, -4.64610319e-04f, 6.41972199e-02f, -3.97529379e-02f,
  -2.88452059e-02f, -1.25604318e-02f, -8.85042250e-02f, -3.86102661e-03f, -1.42409950e-02f, 8.59309956e-02f, 5.74816018e-02f, 5.88506199e-02f, 6.88118264e-02f, 2.26735398e-02f,
  -4.36969064e-02f, -9.75581817e-04f, 2.70301476e-02f, 7.96112865e-02f, -2.44889557e-02f, -1.64096486e-02f, -3.43915671e-02f, 8.84928256e-02f, 1.58989713e-01f, -1.17873535e-01f,
  -5.04211485e-02f, -6.14903457e-02f, 5.75157218e-02f, 2.12007444e-02f, 1.31759644e-01f, 3.11154537e-02f, 4.55917493e-02f, 1.19495004e-01f, -2.66575185e-03f, 4.81384620e-02f,
  2.93084495e-02f, 1.98985706e-03f, 5.63653670e-02f, 8.11944231e-02f, 7.71536455e-02f, 1.76686242e-01f, -1.99333802e-02f, 4.03248370e-02f, -6.85806153e-03f, -1.49852708e-01f,
  9.85532328e-02f, -1.01598501e-01f, -7.72052556e-02f, 1.31234378e-01f, -6.15931936e-02f, -6.69813231e-02f, -1.54610142e-01f, 1.46930367e-02f, -4.69409935e-02f, -3.51759931e-03f,
  -7.07574636e-02f, -8.94769430e-02f, -8.57119039e-02f, 1.15488581e-01f, 7.69897969e-03f, -3.14526223e-02f, 6.48209825e-02f, 5.56533001e-02f, -1.42131909e-03f, -6.19968213e-02f,
  1.03274570e-03f, -8.52412209e-02f, 4.54986244e-02f, 3.77441794e-02f, 4.55564223e-02f, 2.07902361e-02f, -2.53273826e-02f, 8.45849365e-02f, -1.31640494e-01f, 1.62254959e-01f,
  -1.25229910e-01f, 1.99817661e-02f, -5.12675382e-02f, -9.63683873e-02f, -8.34841728e-02f, -4.09209356e-02f, 1.59273058e-01f, 1.78108811e-01f, 1.15832118e-02f, 2.48293117e-01f,
  -1.83412999e-01f, -6.70391172e-02f, -7.02034459e-02f, 1.13436267e-01f, -1.08207010e-01f, -1.85002089e-01f, -7.62997270e-02f, 2.61323862e-02f, 1.38454944e-01f, 1.47784417e-02f,
  -1.14000797e-01f, 1.42549247e-01f, 1.59630582e-01f, 9.44437459e-02f, -1.29075320e-02f, 4.40698452e-02f, -6.54215459e-03f, -1.32777914e-01f, -4.14627790e-02f, -1.44726280e-02f,
  -4.95421924e-02f, 1.07872196e-01f, 6.58981726e-02f, -4.44622897e-02f, 1.46620264e-02f, 8.53345692e-02f, 9.62958299e-03f, -2.07098983e-02f, -4.83894385e-02f, -3.86114977e-02f,
  2.10484304e-02f, -4.39032912e-02f, -9.60124657e-02f, 1.94369256e-02f, -7.97886252e-02f, -4.38454300e-02f, -1.70728825e-02f, -1.00586852e-02f, 5.42333648e-02f, -2.77250130e-02f,
  -3.18947285e-02f, -6.73323944e-02f, 1.00191139e-01f, -1.03887983e-01f, -8.84970427e-02f, 1.15627758e-02f, 1.36264026e-01f, 4.32901196e-02f, -1.21969193e-01f, 2.67376658e-03f,
  -2.62691267e-02f, -3.57555114e-02f, -5.15451282e-02f, 3.34574990e-02f, 3.60994004e-02f, 4.08152193e-02f, 3.20746191e-02f, -1.33659057e-02f, -2.54010297e-02f, 1.55291528e-01f,
  -4.19400707e-02f, -8.76491070e-02f, 2.82349307e-02f, 7.27488659e-04f, 1.80688217e-01f, -1.04187503e-01f, -1.79200470e-02f, 4.07622717e-02f, 1.82408560e-03f, 8.90971646e-02f,
  4.22913805e-02f, -7.58414492e-02f, 1.34719163e-01f, 1.24694787e-01f, -6.87024593e-02f, 8.19220841e-02f, -8.41937587e-03f, 1.33777916e-01f, 4.40114550e-02f, -3.12010292e-02f,
  1.11087970e-01f, 2.48403642e-02f, 9.62159857e-02f, 7.01120915e-03f, -1.08029000e-01f, 1.01984382e-01f, -5.25961742e-02f, -1.60582066e-02f, 5.95211051e-02f, 2.10989371e-01f,
  5.07245362e-02f, 1.68615449e-02f, 4.90426347e-02f, -1.82104513e-01f, 1.09765962e-01f, 2.68468093e-02f, 1.13233402e-01f, 3.20263803e-02f, -1.28829964e-02f, 3.69331874e-02f,
  -5.12739271e-02f, 1.98444873e-02f, -9.38525647e-02f, -6.19411916e-02f, 1.10734247e-01f, -4.40520234e-02f, 4.72801626e-02f, 1.55332200e-02f, -6.08369745e-02f, 9.69560668e-02f,
  -3.66009623e-02f, -6.59021735e-02f, -2.39055790e-02f, 3.91287059e-02f, -1.93004534e-01f, -1.94677174e-01f, 2.68656835e-02f, 1.34059653e-01f, -7.77612478e-02f, -4.05279621e-02f,
  -6.14564819e-03f, 5.05440310e-02f, -8.69562477e-02f, -7.78833255e-02f, 1.10042728e-01f, 1.48092210e-01f, -1.53636992e-01f, 4.71584462e-02f, 1.80025809e-02f, -4.46376465e-02f,
  1.40731230e-01f, 2.23014858e-02f, -8.90985057e-02f, 1.42756075e-01f, 3.90195139e-02f, -1.36364639e-01f, 3.29656852e-03f, -1.25389799e-01f, -1.58614740e-01f, 8.67198780e-02f,
  -3.95319909e-02f, 9.25705209e-02f, -2.17366256e-02f, 5.16891778e-02f, -2.86378786e-02f, 1.06834635e-01f, 6.48772344e-02f, -1.12494649e-02f, 1.80859305e-02f, -1.13729304e-02f,
  -3.78432721e-02f, 2.95318086e-02f, 2.74598952e-02f, -3.94576462e-03f, -1.30720109e-01f, -8.64567459e-02f, 8.11891630e-02f, 4.06167004e-03f, 1.43572539e-02f, -4.49405462e-02f,
  3.94809954e-02f, 6.37725741e-02f, 9.33280364e-02f, 1.31921368e-02f, 1.10088743e-01f, 9.22294706e-03f, -4.36259210e-02f, 8.87942463e-02f, 4.85952199e-02f, 6.68149814e-02f,
  -3.58341411e-02f, 1.34352148e-01f, 1.07713223e-01f, 7.25616980e-03f, 9.96970385e-02f, 1.80490673e-01f, 7.19204023e-02f, 5.07129617e-02f, 1.14071175e-01f, 1.18111067e-01f,
  -7.52964541e-02f, 7.32456148e-02f, -8.73197168e-02f, 1.87545586e-02f, 7.78980926e-02f, -2.42603719e-02f, 1.49789840e-01f, 1.19096031e-02f, -2.93464046e-02f, -2.29215268e-02f,
  1.64235700e-02f, 1.72299687e-02f, 3.96106578e-02f, -1.31124318e-01f, -4.48295400e-02f, 8.47865939e-02f, -9.73731931e-03f, 3.01245134e-02f, -5.31164138e-03f, 7.24082962e-02f,
  -6.21064901e-02f, -1.37615338e-01f, -1.12414502e-01f, 6.33572266e-02f, -1.39805868e-01f, -6.54677451e-02f, 1.18811868e-01f, -7.40774674e-03f, -1.26607195e-01f, -1.01423360e-01f,
  8.07498693e-02f, -2.28415933e-02f, -1.10616580e-01f, 1.19827420e-01f, 4.94671017e-02f, -7.13391304e-02f, -2.63194069e-02f, 1.63737629e-02f, 1.33253746e-02f, 4.82415706e-02f,
  4.17481922e-02f, 9.96996239e-02f, -8.50835294e-02f, 2.86529269e-02f, -2.42225751e-02f, 5.19282930e-03f, -3.32565233e-02f, -2.25846227e-02f, 8.54392722e-02f, -3.95619422e-02f,
  -1.21967786e-03f, -6.17652899e-03f, -6.22585639e-02f, -1.01214707e-01f, -1.00786015e-01f, 6.34231493e-02f, 1.57585323e-01f, -4.76234481e-02f, 1.16917633e-01f, 2.37836078e-01f,
  -2.29164734e-02f, 1.56360313e-01f, -5.87016195e-02f, 5.95264919e-02f, -1.54101297e-01f, 7.88686499e-02f, -1.12887084e-01f, -1.28326654e-01f, 1.06212802e-01f, -1.63095251e-01f,
  -7.46095181e-02f, 1.91671979e-02f, 2.16822606e-02f, -3.91628295e-02f, 4.39835936e-02f, -1.18349485e-01f, -4.57665743e-03f, -7.41519406e-02f, 8.94585028e-02f, -1.62204191e-01f,
  -1.22216521e-02f, -1.98550150e-01f, 9.42682028e-02f, 7.77577981e-02f, 4.86600399e-02f, -8.04466158e-02f, 6.26629069e-02f, 1.24685086e-01f, -8.84973183e-02f, -5.92261143e-02f,
  3.57469358e-02f, 5.96887385e-03f, -7.43578970e-02f, -1.03427600e-02f, -4.60347347e-03f, 5.05231209e-02f, 1.33297205e-01f, 8.75748917e-02f, 2.69833375e-02f, -2.94076968e-02f,
  3.69376168e-02f, 1.99336335e-02f, -2.37192493e-03f, 5.60847633e-02f, 4.55672517e-02f, -5.17495442e-03f, -6.31589070e-02f, -5.20438924e-02f, 1.20022045e-02f, 1.78565815e-01f,
  1.03883753e-02f, -3.80287617e-02f, 8.56828168e-02f, -2.95751798e-03f, 9.92548559e-03f, -1.43713988e-02f, 1.30768090e-01f, -1.57270394e-02f, 9.36696455e-02f, -3.40636484e-02f,
  5.55554517e-02f, 8.20986778e-02f, -3.76699641e-02f, 1.44442409e-01f, -5.31360656e-02f, 2.69426946e-02f, 7.66013712e-02f, 6.11529835e-02f, -9.57042165e-03f, 8.02899897e-02f,
  -1.97488815e-02f, -4.67355959e-02f, 4.57154736e-02f, 1.99443959e-02f, 6.45971373e-02f, 6.44283695e-03f, -6.83837458e-02f, -3.17415260e-02f, 9.22394246e-02f, -1.18694790e-01f,
  6.94580898e-02f, -1.36689857e-01f, -2.31959801e-02f, -2.73509491e-02f, -4.23105992e-02f, 4.05389071e-02f, -1.37926251e-01f, -1.83905289e-02f, 1.81749873e-02f, 9.69685242e-02f,
  -6.18526414e-02f, -1.61193460e-01f, 1.06271856e-01f, -5.37935272e-02f, 3.69398668e-03f, -1.65042579e-02f, 5.15728518e-02f, 1.03580177e-01f, -4.80227247e-02f, 8.01621079e-02f,
  2.42742747e-02f, 1.38852552e-01f, -3.00250314e-02f, 4.47470956e-02f, -1.20017618e-01f, 1.94629431e-02f, 4.11771238e-02f, -1.22426070e-01f, -1.27567081e-02f, -2.39636637e-02f,
  4.30538692e-03f, -6.41408861e-02f, 3.00799962e-02f, 7.26905018e-02f, -5.90711348e-02f, 6.01229211e-03f, 5.14520481e-02f, 9.01001990e-02f, 4.78223010e-05f, 1.12367667e-01f,
  -1.08319342e-01f, 3.52104418e-02f, 8.76025558e-02f, -7.56045282e-02f, -4.94788326e-02f, -5.09337261e-02f, -5.96344247e-02f, -8.06547180e-02f, 5.43402471e-02f, 1.30724937e-01f,
  -5.41710630e-02f, -2.13633198e-02f, -5.25321141e-02f, 1.28772661e-01f, -6.53182119e-02f, 2.90835183e-02f, -3.65674347e-02f, -9.01479945e-02f, -1.07276581e-01f, -8.28700513e-03f,
  2.20646411e-01f, 5.44338003e-02f, -1.92288086e-01f, -1.79317780e-02f, 2.07672372e-01f, 7.22577646e-02f, 1.28188670e-01f, 8.59082490e-02f, -1.29938975e-01f, 2.23431125e-01f,
  -4.64211367e-02f, -1.40584081e-01f, -2.57337783e-02f, -7.83865899e-02f, 8.63657966e-02f, -1.33440539e-01f, -1.16822504e-01f, -8.90901163e-02f, -9.67565477e-02f, 4.15314697e-02f,
  5.35026900e-02f, 3.93917188e-02f, 9.07807518e-03f, 4.36644331e-02f, 3.30295973e-02f, 6.82251826e-02f, 2.59305234e-03f, 7.54677877e-02f, -5.56714162e-02f, 1.02339081e-01f,
  5.47598079e-02f, -6.47853836e-02f, -1.96646247e-02f, 4.30515930e-02f, -3.80219007e-03f, -4.95818779e-02f, -1.54772801e-02f, 3.37937847e-02f, -2.93693133e-02f, 8.93437564e-02f,
  -3.27840634e-02f, 1.09253742e-01f, -6.43329835e-03f, 4.16939001e-04f, 1.43070236e-01f, -3.17238620e-04f, 4.41172794e-02f, -9.87446234e-02f, 3.22938934e-02f, 3.52565460e-02f,
  1.50791332e-01f, 9.22594517e-02f, 9.30226501e-03f, -7.05364812e-03f, 5.87988570e-02f, -1.63129196e-02f, -5.02543859e-02f, 5.85091524e-02f, -3.92766446e-02f, 9.08015296e-03f,
  6.75864741e-02f, 5.28705195e-02f, -7.05782920e-02f, 3.79002541e-02f, -1.77486781e-02f, -6.56998679e-02f, 2.41471101e-02f, 7.39903748e-03f, 2.14285299e-01f, -1.86226517e-01f,
  -5.64197893e-04f, 8.16017240e-02f, -8.74354094e-02f, -8.85690600e-02f, 5.11298887e-02f, 2.57152934e-02f, 4.38525714e-02f, -7.48953670e-02f, -1.19289845e-01f, 4.92436625e-02f,
  -2.33677812e-02f, -6.36852011e-02f, 2.26406127e-01f, 1.38556091e-02f, -8.09463635e-02f, -6.69187903e-02f, 1.78868279e-01f, -1.75099939e-01f, -1.08301798e-02f, 1.85347810e-01f,
  4.09457879e-03f, 3.21303983e-03f, 2.06022393e-02f, 2.93906704e-02f, 1.78931817e-01f, 6.38463572e-02f, -5.83465695e-02f, -5.52400649e-02f, -5.50795794e-02f, -4.94016819e-02f,
  1.51691481e-01f, -6.23433925e-02f, 8.45094472e-02f, 5.59445247e-02f, 1.13829605e-01f, -2.24913321e-02f, -3.43887135e-02f, -7.24771768e-02f, -5.08853793e-02f, -1.15139605e-02f,
  -1.34387508e-01f, 2.01208070e-02f, 5.69735467e-02f, -1.05699271e-01f, 1.84651807e-01f, 1.29462719e-01f, -2.34030019e-02f, 1.41126618e-01f, -8.24138746e-02f, -3.07170916e-02f,
  -2.06189901e-02f, 3.03972512e-02f, -3.02527621e-02f, -1.33688152e-01f, 1.18461482e-01f, 3.06678601e-02f, -9.12603810e-02f, -6.30774535e-03f, -3.58361974e-02f, -3.22791412e-02f,
  -1.64338559e-01f, -8.66441950e-02f, 3.12128421e-02f, -2.46342309e-02f, -8.89324397e-02f, -8.22706744e-02f, -9.53298658e-02f, -2.52993196e-01f, 1.75994579e-02f, -6.33788109e-02f,
  2.67757662e-03f, -2.76180897e-02f, 1.85387209e-01f, 1.57697216e-01f, -2.34894782e-01f, 1.45578891e-01f, 4.48274054e-02f, -5.34293391e-02f, -5.55664152e-02f, 5.22849672e-02f,
  1.29378941e-02f, 1.01608559e-02f, 1.21649854e-01f, -3.91567759e-02f, 8.62125680e-02f, -4.87091066e-03f, 5.50299659e-02f, -1.33701162e-02f, 2.00351346e-02f, 9.04921889e-02f,
  -1.36885848e-02f, 6.07560426e-02f, -1.54537959e-02f, 8.32559094e-02f, 8.80640373e-02f, -2.82820147e-02f, 1.15245092e-03f, 9.32466462e-02f, 3.94001929e-03f, -2.61414610e-03f,
  -5.05496599e-02f, -5.62764565e-03f, 5.81912585e-02f, -1.51044447e-02f, -1.00941382e-01f, 6.93231300e-02f, -3.34368460e-02f, 1.01643859e-03f, -1.41607314e-01f, -7.07841367e-02f,
  3.92320119e-02f, -8.93490016e-03f, 4.46676910e-02f, 2.48425603e-02f, -9.23843086e-02f, 1.09796389e-03f, -2.45482586e-02f, -4.98168021e-02f, -2.73075197e-02f, 1.62184592e-02f,
  2.55100317e-02f, -8.85698050e-02f, -4.54077460e-02f, 5.94622456e-02f, -4.04804796e-02f, -7.77080134e-02f, -7.13159889e-02f, 9.36893299e-02f, 2.73152068e-02f, -1.03290968e-01f,
  -5.12620024e-02f, -8.42189938e-02f, -3.67179327e-02f, 1.28974498e-04f, -1.77373260e-01f, -2.67697535e-02f, 3.17622051e-02f, -3.38337682e-02f, 1.08589865e-01f, -1.67486712e-01f,
  -4.11922596e-02f, 6.62263036e-02f, -8.52670334e-03f, -2.85881441e-02f, -1.89034447e-01f, 3.40602323e-02f, 1.05490118e-01f, 3.58915813e-02f, -3.22360918e-02f, 4.55666408e-02f,
  -9.44954231e-02f, -2.92485833e-01f, 4.41960525e-04f, 1.92647427e-02f, -4.71887924e-02f, 1.07914530e-01f, -1.80253476e-01f, -9.45609137e-02f, -1.70447856e-01f, -1.46285802e-01f,
  6.62436010e-03f, 1.98672265e-02f, 2.57578455e-02f, 1.45862907e-01f, 7.36405998e-02f, 5.00827134e-02f, -1.07245713e-01f, 6.18557595e-02f, -9.43099186e-02f, -1.78161636e-01f,
  -3.27798817e-03f, -1.67283729e-01f, 9.13754627e-02f, -5.09596802e-02f, 1.85042098e-02f, -4.81868982e-02f, 1.30388677e-01f, 4.32236493e-02f, -7.50912949e-02f, -5.31769730e-02f,
  9.99382138e-02f, 9.28144753e-02f, -8.06423500e-02f, -1.58304393e-01f, 1.04276501e-02f, 6.17927015e-02f, 4.94677722e-02f, 4.97622974e-02f, 7.67763555e-02f, 3.34778160e-04f,
  8.09240341e-02f, 1.26960233e-01f, -1.44279093e-01f, 1.13737538e-01f, -5.34730591e-02f, -1.05816521e-01f, -1.40724182e-01f, 4.23837034e-03f, -9.97692049e-02f, 1.13320462e-01f,
  2.38954797e-01f, -1.54655442e-01f, 1.01911165e-01f, 1.73637513e-02f, -5.79587668e-02f, -4.35248651e-02f, -6.42520860e-02f, -2.72537954e-02f, -1.51542593e-02f, -4.42168899e-02f,
  -2.60222163e-02f, -7.64633715e-02f, 2.44171396e-02f, -5.75553849e-02f, 5.76714352e-02f, 1.02962991e-02f, -3.87341231e-02f, 4.96287784e-03f, -5.51286992e-03f, 8.48649442e-03f,
  -2.43480261e-02f, -6.40003569e-03f, 1.02843821e-01f, 7.75422379e-02f, -4.89373431e-02f, -7.70295113e-02f, -8.75469968e-02f, 1.18077464e-01f, -1.35641629e-02f, -4.19391021e-02f,
  5.17721660e-02f, 1.17780762e-02f, -6.22328483e-02f, -1.92339476e-02f, -1.72076300e-02f, -1.27542345e-03f, -6.77185357e-02f, -8.37610289e-02f, 1.01072108e-02f, -5.96389100e-02f,
  -2.19947230e-02f, -7.31878355e-02f, -1.84803978e-02f, 4.31660935e-02f, -2.49908064e-02f, -6.62182942e-02f, 8.56621750e-03f, -5.63758686e-02f, -4.68096435e-02f, -7.11088330e-02f,
  3.25764418e-02f, -5.03711123e-03f, -1.68161299e-02f, -1.24591000e-01f, -3.04338187e-02f, -4.00713161e-02f, -4.94608702e-03f, -1.61018610e-01f, 3.65930237e-02f, -5.71200885e-02f,
  -6.07392415e-02f, 2.66855434e-02f, -9.23830122e-02f, 1.23847008e-01f, -6.10769074e-03f, -1.84877366e-01f, 1.98745742e-01f, -8.75713006e-02f, -1.54605478e-01f, -1.53073557e-02f,
  9.16768797e-03f, 7.50689954e-03f, -5.62841408e-02f, 3.94326970e-02f, 1.26104727e-01f, -1.66593716e-02f, -5.42851090e-02f, 2.69364957e-02f, -1.29305869e-01f, -7.76376128e-02f,
  2.40366384e-02f, -1.38264805e-01f, -4.65095975e-02f, 6.91951215e-02f, 4.19990197e-02f, -1.76173989e-02f, -6.05006739e-02f, 8.97760168e-02f, -6.65002763e-02f, 9.46517214e-02f,
  7.31524006e-02f, 5.23519218e-02f, -6.73372392e-03f, 5.00218160e-02f, -1.50709227e-01f, 8.74294937e-02f, 9.06676352e-02f, -2.89362185e-02f, -8.38135630e-02f, 6.43478557e-02f,
  -7.73243457e-02f, -5.56041077e-02f, -3.55215892e-02f, -3.48201580e-02f, 1.60313427e-01f, 1.11680448e-01f, 6.75374493e-02f, -3.27185798e-03f, 1.20814160e-01f, 8.14437643e-02f,
  -1.62525728e-01f, 2.15068758e-02f, 5.30048832e-03f, 3.61207798e-02f, 9.21443254e-02f, 9.46343504e-03f, 1.63362250e-02f, -9.51985940e-02f, 9.15609598e-02f, 7.63320327e-02f,
  2.36021262e-02f, 1.27226129e-01f, 1.90407857e-02f, 1.17836647e-01f, -1.52971148e-01f, 1.37085905e-02f, -1.46200821e-01f, 4.82119024e-02f, 3.16820964e-02f, -1.19236238e-01f,
  -2.45931596e-01f, -2.51146909e-02f, -6.48039952e-02f, 6.97231740e-02f, -4.45008324e-03f, -9.31963176e-02f, -2.79238746e-02f, 3.38362940e-02f, -5.40811522e-03f, 5.06391115e-02f,
  9.78561640e-02f, -2.85482407e-02f, -7.20127225e-02f, -4.95643076e-03f, -7.71200692e-04f, 3.75881866e-02f, -6.53031990e-02f, 5.08664083e-03f, -5.43821044e-02f, -4.93640043e-02f,
  -4.56699431e-02f, -3.11070438e-02f, -1.31318033e-01f, 1.86328851e-02f, -1.21528041e-02f, -2.56054215e-02f, 6.54125959e-02f, -7.69713968e-02f, -9.63103550e-04f, -1.10755712e-01f,
  2.72607356e-02f, -1.38773724e-01f, -8.35090205e-02f, 8.08786079e-02f, 1.47029478e-03f, -1.06206611e-01f, -7.56663084e-02f, -1.17166273e-01f, -4.70769294e-02f, -1.07076587e-02f,
  -9.19273719e-02f, -6.01454787e-02f, -5.97308092e-02f, 2.22848840e-02f, -1.39364786e-02f, -3.08636390e-03f, -1.24890581e-01f, 3.51959653e-02f, 1.91975962e-02f, -3.30380797e-02f,
  -3.40926275e-02f, -8.82277787e-02f, 8.61381739e-02f, 9.53911468e-02f, -1.52811008e-02f, -8.21151808e-02f, -5.93247190e-02f, -7.16673881e-02f, -9.74754691e-02f, -5.22777103e-02f,
  1.50860667e-01f, 8.74426439e-02f, -2.98143718e-02f, 9.02832821e-02f, -5.55517105e-03f, 2.76926812e-02f, 1.91550449e-01f, 2.12718267e-02f, 6.81464886e-03f, 2.81580240e-02f,
  1.39025643e-01f, -5.51793277e-02f, 8.54530111e-02f, 5.66795841e-02f, -6.82790503e-02f, 1.31229637e-02f, 1.62747167e-02f, 6.82790801e-02f, -1.56730153e-02f, 3.35719399e-02f,
  -4.78063971e-02f, -2.37705126e-01f, 1.49482954e-02f, -1.15679801e-01f, 1.44661412e-01f, -7.09601343e-02f, 9.61898342e-02f, 6.97348118e-02f, -8.31584260e-03f, 8.64841267e-02f,
  1.98552348e-02f, -1.11608624e-01f, 7.46489242e-02f, 9.04917270e-02f, -2.05163658e-02f, -7.68840685e-02f, -6.15327507e-02f, -3.42286751e-03f, 9.94582698e-02f, -1.89518839e-01f,
  3.38634364e-02f, -1.11831531e-01f, -1.01243600e-01f, -1.20617680e-01f, 1.86693504e-01f, -4.97057252e-02f, 1.13238126e-01f, 1.28347483e-02f, -7.31051713e-02f, 2.13012755e-01f,
  -1.87467914e-02f, -8.57548497e-04f, 9.60101858e-02f, 9.17298347e-02f, -1.61893532e-01f, 1.33147046e-01f, -2.27392353e-02f, 8.43548179e-02f, -1.52958855e-01f, 1.42206922e-01f,
  -9.64850094e-03f, -1.29029781e-01f, 1.69472545e-02f, -2.15592220e-01f, 4.74151485e-02f, 8.73504430e-02f, 1.68750212e-02f, -5.75029179e-02f, 4.94047925e-02f, 2.56433785e-01f,
  1.60815089e-03f, 1.10540604e-02f, -2.92007197e-02f, -4.40714993e-02f, 8.73430911e-03f, -6.10499196e-02f, -2.55925879e-02f, -2.73955651e-02f, -6.96344450e-02f, -3.60782631e-02f,
  -4.18897606e-02f, -3.40624675e-02f, 9.89323258e-02f, 1.01470955e-01f, -8.07975009e-02f, -3.44809750e-03f, -3.76498662e-02f, 1.17149111e-02f, -4.48364988e-02f, -6.86181337e-02f,
  -1.26550287e-01f, 9.36008338e-03f, -1.16135843e-01f, 9.19310525e-02f, 4.52678837e-02f, -4.73584048e-02f, -1.32160960e-02f, -2.74460465e-02f, -5.87600702e-03f, -8.20764340e-03f,
  -2.99777966e-02f, -4.09931280e-02f, -8.84487778e-02f, -1.26875848e-01f, 1.06236748e-02f, -6.86476603e-02f, 6.07387759e-02f, -5.82203679e-02f, 2.40953546e-02f, -7.08535826e-03f,
  1.17481789e-02f, -4.23256122e-02f, -3.55460821e-03f, -3.10887024e-02f, -5.13101369e-02f, -3.69227268e-02f, 2.21893992e-02f, -6.88033700e-02f, -1.14085250e-01f, 3.93456332e-02f,
  -7.61969686e-02f, 1.05067022e-01f, 8.57740939e-02f, -9.18483138e-02f, -9.88713205e-02f, -1.27913533e-02f, 9.14639235e-02f, -7.07328245e-02f, 3.02121155e-02f, -6.98328838e-02f,
  1.77333862e-01f, -1.30709708e-01f, 5.23980102e-03f, 6.61954731e-02f, -3.71160470e-02f, -6.51588514e-02f, -8.21179673e-02f, -1.05532827e-02f, -9.92295705e-03f, -2.04353049e-01f,
  1.65494755e-01f, -4.32181545e-02f, 4.27215174e-02f, -2.79122721e-02f, -9.42833722e-02f, 6.91652372e-02f, 3.14083472e-02f, 4.92702127e-02f, -9.71989781e-02f, -1.40850827e-01f,
  3.63444835e-02f, -8.54505226e-02f, -4.59402278e-02f, -4.43153121e-02f, -7.38311186e-02f, -2.99719106e-02f, -4.52213399e-02f, -9.07474756e-02f, -2.48061772e-02f, -7.35681131e-02f,
  -2.60885898e-02f, 1.41102672e-01f, -1.79455732e-03f, 7.17801526e-02f, 5.47939818e-03f, 1.19669028e-01f, -1.15096398e-01f, 4.02715616e-02f, 4.04921398e-02f, -8.65738541e-02f,
  -1.20200299e-01f, 2.48347186e-02f, 1.10320002e-01f, -1.89953282e-01f, 1.26662284e-01f, 1.73310041e-01f, 1.32630080e-01f, 1.85717478e-01f, 6.58433214e-02f, 1.48071736e-01f,
  4.56660576e-02f, 1.43309221e-01f, 8.52409974e-02f, -1.48605425e-02f, -5.85681237e-02f, -4.53850962e-02f, -6.70053810e-02f, 1.72640234e-01f, 9.08769667e-02f, -8.22593570e-02f,
  4.59773615e-02f, -8.52792710e-03f, -1.16523489e-01f, 2.33283713e-02f, -1.40344929e-02f, -2.76804268e-02f, -5.29211126e-02f, 4.92967777e-02f, -3.05491546e-03f, 8.85077715e-02f,
  -1.47706072e-03f, -3.93884666e-02f, -2.33593807e-02f, 4.32907268e-02f, 3.41171958e-02f, 3.16595547e-02f, -8.40981212e-03f, -1.12279933e-02f, 5.20452447e-02f, 8.33361670e-02f,
  -8.60803202e-02f, 7.30243549e-02f, -3.63808461e-02f, -2.73443852e-02f, -7.91625381e-02f, -9.24100503e-02f, -6.54022768e-02f, 1.03891931e-01f, -9.14416835e-03f, -1.94010753e-02f,
  4.88249138e-02f, 3.99303064e-02f, 2.95288395e-03f, 7.48960301e-03f, 8.90866071e-02f, -1.24225793e-02f, 5.46736270e-02f, -1.12232461e-04f, 3.47934337e-03f, 2.81306282e-02f,
  1.64056122e-02f, 9.98024568e-02f, -4.64751497e-02f, -2.13293657e-02f, 5.07334732e-02f, 4.64590378e-02f, -2.89196987e-02f, 1.17224529e-01f, -6.13605464e-03f, 1.86967216e-02f,
  6.94989562e-02f, -2.19837707e-02f, 8.85652527e-02f, 9.79236290e-02f, -5.60469143e-02f, -4.78319377e-02f, 1.27003133e-01f, -6.69909790e-02f, 1.11360602e-01f, -1.63814485e-01f,
  -2.29850281e-02f, 3.27378251e-02f, 7.32857734e-03f, -7.86881987e-03f, -5.91682941e-02f, 3.65672335e-02f, -5.50955022e-03f, 2.03606021e-02f, -9.07768011e-02f, -1.80064067e-01f,
  4.96087363e-03f, -2.58254819e-02f, -1.38271553e-02f, -2.31023263e-02f, 2.43640915e-02f, 8.27450827e-02f, 2.39127409e-02f, 5.43460855e-03f, 1.13414582e-02f, 2.05070823e-01f,
  -2.74213869e-02f, 3.90244313e-02f, -1.47050738e-01f, 5.32446876e-02f, 1.03819013e-01f, -1.21627919e-01f, 2.26028319e-02f, 3.97993252e-02f, -2.46175881e-02f, -4.75299060e-02f,
  7.11909542e-03f, 3.53925787e-02f, -4.95817736e-02f, 1.75304294e-01f, 1.77131921e-01f, 9.91109461e-02f, 2.32413299e-02f, 8.68195370e-02f, -9.68410447e-02f, 1.01146743e-01f,
  4.51318398e-02f, -3.56801189e-02f, 1.72745110e-03f, -1.82492752e-02f, -1.57725383e-02f, 2.24604551e-02f, -3.03307846e-02f, 1.91306010e-01f, -9.78442207e-02f, -7.82536566e-02f,
  -2.59388108e-02f, 1.41852632e-01f, -1.49532869e-01f, -1.05838448e-01f, 1.04797840e-01f, -1.52476326e-01f, -2.02818051e-01f, 3.86354551e-02f, 2.40152717e-01f, 9.79673192e-02f,
  -9.79461670e-02f, -9.59500857e-03f, 2.21464992e-01f, 6.07930310e-02f, 2.36967970e-02f, 2.20730137e-02f, -9.79875475e-02f, 4.41407710e-02f, -1.11372598e-01f, -5.26282601e-02f,
  1.60026252e-02f, -8.36884156e-02f, 8.34600702e-02f, -1.73065528e-01f, -1.14740692e-01f, -5.39683588e-02f, -7.13756457e-02f, 9.28590223e-02f, 4.77240346e-02f, 6.85707703e-02f,
  2.48151086e-02f, -4.39633839e-02f, 3.52758653e-02f, 1.14440955e-02f, 1.69924200e-02f, 2.07266435e-02f, -8.42823833e-02f, 8.21500653e-05f, 1.83765441e-02f, -8.08200017e-02f,
  -1.18577192e-02f, 1.03887236e-02f, 8.52514582e-04f, 5.17550856e-03f, 1.31305888e-01f, 1.18269376e-01f, 4.31134738e-03f, 7.94386417e-02f, 7.04076663e-02f, 1.05696924e-01f,
  7.81888217e-02f, 4.67088446e-02f, 1.69905260e-01f, 5.90056628e-02f, 4.45394479e-02f, -2.43455414e-02f, 5.92437461e-02f, 4.50444582e-04f, 4.74505238e-02f, 9.31725129e-02f,
  6.29527569e-02f, 4.34539579e-02f, 1.37479693e-01f, 3.30813043e-02f, 2.78109754e-03f, -2.82184873e-02f, -1.41344639e-02f, -6.08815206e-03f, -1.03401411e-02f, -3.94082814e-03f,
  6.85037747e-02f, 1.26864007e-02f, -3.78458686e-02f, -1.32982703e-02f, 2.69388389e-02f, 2.61301249e-02f, 5.98207600e-02f, -7.87496939e-02f, -1.79773793e-01f, 1.88352972e-01f,
  1.10188499e-01f, 8.17084014e-02f, -2.44494416e-02f, 2.41934787e-02f, -9.39781070e-02f, -8.17045383e-03f, -1.43794626e-01f, -2.68577766e-02f, -8.71614665e-02f, -5.48841991e-02f,
  1.19647561e-02f, 2.93220095e-02f, -1.31428152e-01f, -1.26845375e-01f, 2.25495677e-02f, -1.47202760e-01f, -5.92875779e-02f, -2.91840024e-02f, -8.50081735e-04f, 7.55133107e-02f,
  -4.42529321e-02f, 1.75438479e-01f, 9.08655971e-02f, -4.39299569e-02f, 5.42608239e-02f, 2.64202300e-02f, 1.31991908e-01f, 2.56060492e-02f, 1.64840445e-01f, 5.04837781e-02f,
  7.12415203e-02f, 6.38857111e-02f, 1.29199564e-01f, -6.95785433e-02f, 1.36395358e-03f, 1.13620097e-02f, -3.29080075e-02f, -8.30972493e-02f, -4.29608375e-02f, 7.54578412e-02f,
  3.47388797e-02f, 9.39454883e-02f, 8.66110995e-02f, 4.33445685e-02f, -4.40272652e-02f, -3.62511819e-05f, -7.53884995e-03f, -3.76500711e-02f, 1.93350956e-01f, -8.79331529e-02f,
  1.33617744e-01f, -1.13185309e-01f, 7.18538836e-02f, 1.64823532e-01f, 1.80745162e-02f, 5.32396920e-02f, -1.47046134e-01f, -2.04580560e-01f, 6.47599762e-03f, -1.92590445e-01f,
  1.77810177e-01f, 3.10718790e-02f, 1.06453203e-01f, -1.37774542e-01f, 1.19974159e-01f, 1.43189728e-01f, 1.70252725e-01f, 5.47098275e-03f, -6.47486970e-02f, -2.27535889e-02f,
  9.42834467e-02f, -3.91330291e-03f, -1.96464881e-01f, -4.96432781e-02f, 4.84231487e-03f, 2.82565504e-02f, -3.02577708e-02f, -5.15138581e-02f, 4.15606163e-02f, -6.78495318e-03f,
  -1.15209501e-02f, 6.31511807e-02f, 3.71750966e-02f, 3.19166817e-02f, -9.03353654e-03f, -3.59180272e-02f, 2.02516578e-02f, 6.18087314e-02f, -5.11647761e-03f, 1.90647598e-02f,
  -6.77755252e-02f, 5.92794502e-03f, 1.25862047e-01f, 1.06792361e-01f, -4.37342674e-02f, 3.73057574e-02f, 4.11030464e-02f, 3.05970199e-02f, 2.77725607e-02f, -2.64138039e-02f,
  1.57667160e-01f, -1.94993720e-03f, 3.85869220e-02f, -3.70690934e-02f, 3.54296975e-02f, -5.12939543e-02f, 2.35536266e-02f, 1.22589879e-01f, 3.04804705e-02f, 1.08212344e-01f,
  7.80312717e-02f, -1.72103345e-02f, 7.94471949e-02f, -4.54338901e-02f, 2.23107971e-02f, -3.49207893e-02f, 8.57143775e-02f, -2.50065383e-02f, 9.27043781e-02f, 1.68245230e-02f,
  -5.76484203e-02f, -2.73662508e-02f, 9.26021039e-02f, 4.49157692e-02f, 6.49833605e-02f, -1.58470780e-01f, -1.96515266e-02f, 1.12614579e-01f, -1.18342467e-01f, 6.51481887e-03f,
  4.17460613e-02f, 2.55524796e-02f, 7.50246197e-02f, -4.01040986e-02f, -4.65559065e-02f, -4.66772467e-02f, -5.67735322e-02f, 3.78552973e-02f, 6.53233752e-02f, -4.33952399e-02f,
  -5.02141267e-02f, 3.39051224e-02f, 1.14569871e-03f, -1.39636591e-01f, 2.39915363e-02f, 1.55899659e-01f, -3.24923769e-02f, -2.64040250e-02f, -4.82223630e-02f, 1.85934097e-01f,
  -4.39302102e-02f, -1.16500914e-01f, -9.31497850e-03f, 1.19341845e-02f, 8.47337022e-02f, -9.60005727e-03f, 7.68426359e-02f, -6.62728250e-02f, -3.76950651e-02f, 7.65642375e-02f,
  -5.61863370e-03f, -1.55938774e-01f, -8.72585773e-02f, -5.11901965e-03f, 2.61714924e-02f, -1.64451394e-02f, -3.80533114e-02f, 1.26926616e-01f, 7.60955438e-02f, 1.60063848e-01f,
  -3.07923369e-02f, -7.85237364e-03f, -1.57944262e-02f, 1.07913263e-01f, -1.37584180e-01f, 3.58059891e-02f, -6.22129347e-03f, -2.27226466e-02f, -1.43593863e-01f, 2.19156936e-01f,
  1.61926359e-01f, -4.11866084e-02f, -4.99814451e-02f, 1.35634397e-03f, 4.64559123e-02f, 1.42021000e-01f, -1.44233823e-01f, -1.57777205e-01f, 1.59495160e-01f, -8.87558386e-02f,
  1.96477734e-02f, 8.35105628e-02f, 8.21263902e-03f, 9.42815319e-02f, 2.03517079e-01f, -1.05922259e-01f, -5.35619482e-02f, -1.81496948e-01f, -2.77925376e-02f, 7.31717646e-02f,
  -1.25255421e-01f, 4.64414917e-02f, -9.79989301e-03f, 2.98192110e-02f, 2.73231566e-02f, -5.55876270e-02f, -3.83930728e-02f, 2.14334745e-02f, -6.44498691e-02f, 6.40059933e-02f,
  4.48135771e-02f, 6.26116991e-02f, -3.69850472e-02f, 5.50178438e-02f, -8.14808439e-03f, 1.08873593e-02f, 3.79296727e-02f, 1.68974511e-02f, -4.09258530e-02f, -5.68197183e-02f,
  8.42421725e-02f, 6.61947876e-02f, -7.38561004e-02f, -1.15727549e-02f, 3.25618275e-02f, 8.83856639e-02f, 4.57576923e-02f, 3.33988741e-02f, 9.09896269e-02f, -6.63074031e-02f,
  1.00883655e-01f, -3.73217091e-02f, 5.07587940e-03f, -4.77637106e-04f, 1.35568455e-01f, 7.35472292e-02f, -2.20101960e-02f, 8.98341015e-02f, 9.05312598e-02f, -4.56180833e-02f,
  -6.82175253e-03f, 2.70699635e-02f, -5.00967465e-02f, 3.12913321e-02f, 6.81669042e-02f, -6.88545257e-02f, 3.22015071e-03f, 5.92537075e-02f, -1.06768809e-01f, -6.58607259e-02f,
  8.05753563e-03f, 3.20533626e-02f, 1.06781811e-01f, -1.59914657e-01f, -8.00640434e-02f, 1.41831070e-01f, 1.32031390e-03f, 6.03146739e-02f, -3.71528454e-02f, -1.18726678e-02f,
  1.08358888e-02f, -6.33916492e-03f, -1.63595393e-01f, 7.95347709e-03f, -5.96675761e-02f, -2.57228613e-02f, 6.53221086e-02f, -4.61298525e-02f, -3.41971479e-02f, -2.87088305e-02f,
  1.03885517e-01f, -8.93427059e-02f, -7.36841261e-02f, 5.02874292e-02f, -4.42893617e-02f, -3.83628681e-02f, -1.23941377e-02f, 2.42501289e-01f, 4.83909920e-02f, -1.03160746e-01f,
  3.55174653e-02f, -1.83116328e-02f, 1.33566469e-01f, 4.35762927e-02f, 1.41930521e-01f, 9.05617103e-02f, -1.52375260e-02f, 4.19054888e-02f, 1.27969816e-01f, -7.53839239e-02f,
  -8.65126774e-02f, 2.71712877e-02f, 1.64609365e-02f, -3.69946770e-02f, -4.10252437e-02f, 9.02488679e-02f, 1.18250248e-03f, 6.35650232e-02f, -1.36174019e-02f, 5.16836122e-02f,
  -2.65523139e-03f, 1.24919735e-01f, -8.03340897e-02f, -3.06449886e-02f, 5.85649274e-02f, 4.29145508e-02f, -1.02998897e-01f, -1.02667972e-01f, 8.92598480e-02f, -4.02317047e-02f,
  -9.47216377e-02f, 3.47708643e-04f, -8.12015496e-03f, -8.66428539e-02f, -9.12632421e-02f, -6.58998415e-02f, 1.95253894e-01f, 1.36199372e-03f, 1.05669826e-01f, -6.66250288e-02f,
  -1.32383863e-02f, 1.35496393e-01f, 1.23975977e-01f, -1.08583592e-01f, -3.59301977e-02f, -1.17486767e-01f, -1.02169206e-02f, 7.70873353e-02f, -1.85447991e-01f, 1.11418732e-01f,
  1.06464587e-01f, -5.21453507e-02f, -4.34302315e-02f, -1.15858898e-01f, -2.70063747e-02f, 5.97670004e-02f, -8.93398188e-03f, 7.07461908e-02f, 1.02168642e-01f, -2.31054090e-02f,
  7.72581846e-02f, 1.38239097e-02f, -9.03543234e-02f, -5.13388477e-02f, -4.55732952e-04f, -1.26067817e-03f, -7.74809867e-02f, -5.77516593e-02f, -7.77642503e-02f, -3.27001475e-02f,
  -1.61288958e-02f, -1.28135100e-01f, -1.08082101e-01f, -1.47516683e-01f, 2.80914046e-02f, -3.10668088e-02f, -1.00295313e-01f, -2.77322630e-04f, -3.16249505e-02f, -7.97258243e-02f,
  -3.94178294e-02f, 8.08400661e-02f, 8.58711898e-02f, -1.90216396e-02f, -4.76720408e-02f, -4.82892171e-02f, -6.09608628e-02f, -2.30687223e-02f, -1.20348908e-01f, 4.25465778e-02f,
  4.05985378e-02f, -2.21543089e-02f, 7.13636577e-02f, 1.74169510e-03f, -7.22624883e-02f, 3.98024777e-03f, -2.60520214e-03f, 4.00260687e-02f, 5.78458868e-02f, -7.42163733e-02f,
  5.03633879e-02f, 6.66605011e-02f, 8.74110982e-02f, -4.63650711e-02f, 8.64361785e-03f, -6.58435449e-02f, -8.67067203e-02f, 1.10481597e-01f, 1.61303341e-01f, 1.36294425e-01f,
  -1.10337837e-02f, 1.01240486e-01f, 4.08080742e-02f, 4.14835960e-02f, 8.05279985e-02f, 2.99190506e-02f, 5.33245541e-02f, 9.57907736e-02f, 9.55361053e-02f, 2.48624116e-01f,
  -7.10787326e-02f, -3.24547961e-02f, -9.89293456e-02f, -1.02161296e-01f, 1.04796827e-01f, -4.24275212e-02f, -8.08818862e-02f, 3.55676785e-02f, -2.32968275e-02f, -1.30116716e-01f,
  -3.84953804e-02f, -2.90512783e-03f, 7.86703974e-02f, 4.18011472e-02f, -4.50748354e-02f, 2.53499933e-02f, -5.79099990e-02f, 1.44343004e-01f, 1.96694601e-02f, -2.49086097e-02f,
  6.38243631e-02f, 6.61118999e-02f, 3.37490737e-02f, -6.37584329e-02f, -4.77026440e-02f, 4.11404334e-02f, 2.91982405e-02f, -9.94681641e-02f, 2.24533137e-02f, -4.21821605e-03f,
  -1.32740783e-02f, -4.35682200e-03f, -1.23112537e-02f, 1.93678364e-01f, -7.73366466e-02f, -9.06364806e-03f, -1.61241919e-01f, -3.48442867e-02f, -6.18431754e-02f, -9.47791412e-02f,
  1.39278486e-01f, 1.35159358e-01f, -1.29304200e-01f, 2.45286629e-01f, -8.65206718e-02f, 7.28299562e-03f, -1.23743182e-02f, 1.30847231e-01f, -1.61458850e-01f, 3.61529030e-02f,
  -8.26428682e-02f, -1.04133911e-01f, 8.61099511e-02f, -5.82152680e-02f, -1.10421747e-01f, 5.69094997e-03f, 9.51140597e-02f, 1.65404037e-01f, 1.92082636e-02f, 9.20737311e-02f,
  1.37971282e-01f, 1.99335217e-01f, 8.67067575e-02f, 1.82447657e-02f, 2.55096313e-02f, 4.09084223e-02f, -9.22427103e-02f, -4.04439047e-02f, -5.58589101e-02f, 3.54988202e-02f,
  8.13281536e-03f, 8.12394824e-03f, 2.91148368e-02f, -3.12600657e-02f, 1.66166313e-02f, -6.59893127e-03f, -4.94781919e-02f, 4.93697263e-03f, 1.26075577e-02f, 9.75256264e-02f,
  9.40987915e-02f, -1.20040290e-02f, 3.81518528e-02f, 6.55595288e-02f, 4.90714051e-02f, -5.07547967e-02f, -5.45887575e-02f, 7.49145001e-02f, 8.37140009e-02f, 7.76480287e-02f,
  3.33378315e-02f, 5.08409701e-02f, 3.87908518e-02f, 9.82097313e-02f, 1.16480127e-01f, 8.37759078e-02f, 6.29495829e-02f, -6.39081188e-03f, 2.03619841e-02f, 4.49625030e-02f,
  -7.50522166e-02f, 1.20171178e-02f, 1.45453557e-01f, 1.96698159e-02f, -1.30524402e-02f, 1.70291346e-02f, 4.62783827e-03f, 1.09133087e-01f, -3.80387530e-02f, 2.53595831e-03f,
  3.50742675e-02f, 3.91006283e-02f, 8.17074999e-02f, 8.95657949e-03f, 4.29046154e-02f, 5.66120213e-03f, -1.44819647e-01f, -1.57183632e-01f, -5.97511930e-03f, 4.79811952e-02f,
  -6.82059750e-02f, -6.95253387e-02f, 1.23629250e-01f, -3.55339353e-03f, 1.29503524e-02f, 1.75399929e-02f, 3.71231921e-02f, -5.83592318e-02f, -4.10311297e-02f, 1.95598342e-02f,
  5.60112409e-02f, 1.24932446e-01f, 5.30557856e-02f, -9.50333178e-02f, -3.25747654e-02f, 1.11753896e-01f, 3.53763588e-02f, 1.30703285e-01f, -1.36831164e-01f, 9.43144411e-03f,
  -7.53856152e-02f, -1.02945253e-01f, 1.26285210e-01f, -9.49967839e-03f, 4.44889441e-02f, 5.45459986e-02f, 1.38193071e-01f, 9.23702121e-02f, 1.73479319e-02f, 2.28005610e-02f,
  -6.92532137e-02f, -8.04189965e-02f, 1.10938340e-01f, -1.53212175e-01f, 1.27665684e-01f, 1.11295223e-01f, 3.45861688e-02f, -9.05445740e-02f, -1.22995647e-02f, -8.29262212e-02f,
  -4.82538380e-02f, 2.45956797e-02f, 6.36221692e-02f, -1.16682641e-01f, 3.77864614e-02f, 7.75179192e-02f, -2.94226687e-02f, 1.20748647e-01f, -8.01331177e-02f, -3.94347087e-02f,
  1.01843148e-01f, 4.95822169e-02f, 3.91653180e-02f, -2.19024234e-02f, -8.89853910e-02f, -2.06964016e-01f, 8.87641385e-02f, -1.39033198e-01f, 1.41226943e-03f, 3.94994169e-02f,
  2.55411621e-02f, 7.19889849e-02f, 1.40086249e-01f, -1.63386419e-01f, 2.17736050e-01f, -4.46595997e-02f, -5.97783439e-02f, -1.97076928e-02f, -6.72071939e-03f, 9.74873751e-02f,
  5.29235080e-02f, -3.46855223e-02f, 3.44179943e-02f, 4.49566431e-02f, 7.96609151e-04f, 7.27259219e-02f, -1.72630772e-01f, -9.37002376e-02f, 1.47348166e-01f, 2.82985885e-02f,
  -1.23603018e-02f, 1.59851927e-02f, 3.17262337e-02f, 1.39048308e-01f, 1.27611339e-01f, -1.25399902e-02f, -3.02997865e-02f, 8.73721465e-02f, 8.96321908e-02f, 7.12227523e-02f,
  3.29924040e-02f, -4.65107746e-02f, 7.58684054e-02f, 7.34651228e-03f, 1.26020180e-03f, -5.25929704e-02f, 7.39779249e-02f, -6.33549020e-02f, -7.63610527e-02f, 5.42017035e-02f,
  1.99502110e-02f, 7.55862519e-02f, 9.66990888e-02f, -8.59417580e-03f, 1.43360496e-01f, -1.72771722e-01f, -6.57437444e-02f, -8.53227526e-02f, -1.00249819e-01f, 4.19102460e-02f,
  6.52282983e-02f, -1.63054481e-01f, -2.74938699e-02f, 1.64186917e-02f, -4.46958169e-02f, 1.35853335e-01f, -5.77282608e-02f, 3.04952152e-02f, -3.30721103e-02f, 4.96571139e-02f,
  -4.01036106e-02f, -9.07606538e-03f, 1.00817561e-01f, -1.20940385e-02f, -1.30367309e-01f, -5.30274250e-02f, -1.36361988e-02f, 1.42810242e-02f, 1.21725006e-02f, -2.92314328e-02f,
  9.98442620e-02f, -2.83923857e-02f, -8.16629678e-02f, 8.09861813e-03f, -1.04750216e-01f, -1.12976901e-01f, 6.37946054e-02f, -2.84168832e-02f, 3.51714566e-02f, 9.57567915e-02f,
  -5.07724546e-02f, -4.64325026e-02f, -4.87016290e-02f, -1.02601880e-02f, 7.99542814e-02f, 1.12964466e-01f, 6.80000931e-02f, 2.64193863e-03f, -4.11024429e-02f, -1.40559509e-01f,
  1.04046404e-01f, 3.84842716e-02f, -6.42763376e-02f, -1.00586131e-01f, 2.54775025e-03f, -2.41613295e-03f, -5.15988767e-02f, -2.79193912e-02f, -1.37509450e-01f, 2.90739760e-02f,
  6.45602494e-02f, -2.50023566e-02f, 6.52104989e-02f, 3.10102087e-02f, 4.87150922e-02f, -3.19126993e-02f, 1.44415006e-01f, -3.57587002e-02f, -4.67909537e-02f, -1.33609772e-01f,
  1.19251281e-01f, 7.16194510e-02f, 1.62705313e-02f, 1.09065376e-01f, 7.22173005e-02f, 1.32113472e-01f, -2.56896615e-01f, -1.18804537e-01f, 3.64323705e-02f, -1.00095898e-01f,
  4.80073430e-02f, -3.52398045e-02f, -9.56316814e-02f, -8.70744362e-02f, 1.58077389e-01f, -3.56276743e-02f, 1.79429770e-01f, -1.35148289e-02f, -7.22202435e-02f, -7.95949548e-02f,
  7.66924322e-02f, 1.88492350e-02f, 6.97525218e-02f, 6.40143128e-03f, 6.23904057e-02f, -4.94317245e-03f, 1.14795752e-02f, -5.16145602e-02f, -2.97539979e-02f, 2.42541954e-02f,
  3.12226303e-02f, 3.25197447e-03f, 9.18770209e-03f, -6.81966767e-02f, 1.19161613e-01f, 1.01531237e-01f, -6.72579184e-02f, 2.09962074e-02f, -1.29308226e-02f, 2.35485770e-02f,
  4.34435159e-02f, -4.26710630e-03f, -7.57794781e-03f, -6.11849725e-02f, 7.04671722e-03f, -6.44055828e-02f, -8.95568132e-02f, -8.96516815e-02f, -5.34303114e-02f, 1.89024694e-02f,
  -1.50261238e-01f, -7.47923646e-03f, -2.32425872e-02f, 4.04518768e-02f, -1.03447763e-02f, 1.01954609e-01f, 6.85499534e-02f, -1.07478321e-01f, -5.34508098e-03f, -3.08076870e-02f,
  -6.55323491e-02f, -3.59540619e-02f, -1.43143952e-01f, 1.19225141e-02f, 9.67543107e-03f, 2.21340507e-02f, -2.13409383e-02f, -2.02213265e-02f, -6.81961551e-02f, 1.84709094e-02f,
  -1.02772629e-02f, 2.30051228e-03f, -2.71567702e-02f, -2.79046707e-02f, -1.54502001e-02f, 1.02567554e-01f, 7.60296881e-02f, -7.03161955e-02f, 4.39779535e-02f, -2.18628533e-02f,
  -4.19272110e-02f, 4.68585361e-03f, 5.28141968e-02f, 1.27172083e-01f, -5.79845998e-03f, 1.03082478e-01f, 4.63982858e-02f, -4.00462374e-02f, -1.91913382e-03f, 3.04335523e-02f,
  -1.48992538e-02f, -1.27286362e-02f, 3.72090936e-02f, 1.83681533e-01f, -9.36203673e-02f, -4.28965595e-03f, -6.55023381e-02f, -2.62798797e-02f, 6.14124872e-02f, -1.57405898e-01f,
  -7.08485469e-02f, 1.18457973e-01f, 1.27028823e-02f, -5.50051546e-03f, -1.47891283e-01f, 4.74411175e-02f, -5.77542521e-02f, -5.46493381e-02f, 2.31852345e-02f, 4.12262278e-03f,
  -1.27943521e-02f, 1.48081601e-01f, 3.42355557e-02f, 7.53072202e-02f, 1.15123220e-01f, 4.28539850e-02f, 1.01597756e-02f, -1.60276175e-01f, -1.17890816e-02f, -1.38352379e-01f,
  5.44424206e-02f, -7.38441870e-02f, -5.69029078e-02f, -5.43494662e-03f, -5.18765338e-02f, -1.12772752e-02f, -3.18151503e-03f, 1.56626850e-01f, -7.10237548e-02f, -1.86501965e-01f,
  -1.43185109e-01f, -1.23618007e-01f, -1.16405085e-01f, -1.64906250e-03f, 5.92947006e-02f, 7.04834983e-02f, 3.17993872e-02f, 2.85509109e-01f, -6.31306767e-02f, -8.49195011e-03f,
  -8.92144367e-02f, -7.36022666e-02f, -1.01946369e-01f, -5.73267937e-02f, -1.51066035e-01f, -9.18966532e-03f, 4.42555994e-02f, -2.38067620e-02f, -6.75657466e-02f, -3.29656117e-02f,
  1.96656615e-01f, 1.59926057e-01f, 2.08496489e-02f, 6.91084936e-02f, -1.83426067e-02f, -6.47000670e-02f, -2.52519082e-03f, 2.72219372e-03f, 5.95021024e-02f, 7.66314492e-02f,
  1.16452336e-01f, -2.71091927e-02f, 8.00658613e-02f, 4.74047475e-02f, -3.39273848e-02f, 2.63351644e-03f, -4.27777842e-02f, 8.83053541e-02f, -1.15469061e-01f, -1.65676922e-02f,
  4.86845337e-02f, 8.83798301e-02f, -3.82825024e-02f, -4.58306186e-02f, -4.85023782e-02f, 7.61343837e-02f, 1.67682767e-02f, -6.33484945e-02f, 1.38075039e-01f, -1.14516951e-02f,
  5.21489419e-03f, -5.18586487e-02f, 1.06994668e-03f, 6.49023503e-02f, 5.22419289e-02f, -3.67243066e-02f, -1.36639678e-03f, -2.70673595e-02f, 4.16317470e-02f, -1.95977874e-02f,
  1.34554924e-02f, 6.47682473e-02f, 4.07132171e-02f, -8.03026184e-03f, 8.48328099e-02f, 3.23357433e-02f, 3.61419134e-02f, -2.29061097e-02f, 5.55621758e-02f, -8.93270001e-02f,
  1.20191433e-01f, -6.54557571e-02f, 5.89496009e-02f, -5.51790670e-02f, 5.85733354e-02f, -1.51869297e-01f, 1.46832364e-02f, -8.42795074e-02f, -1.00589536e-01f, 5.41647635e-02f,
  6.18688874e-02f, 1.32349283e-01f, 5.95613644e-02f, -1.12772934e-01f, 1.67718902e-01f, 5.97790480e-02f, 1.53799430e-02f, -7.00497851e-02f, -3.99719179e-02f, 9.05731246e-02f,
  1.75999016e-01f, 4.46920358e-02f, 9.26167890e-02f, 4.97619994e-02f, -7.30740428e-02f, 5.47573576e-03f, -4.05829772e-02f, -1.48448003e-02f, -5.30055277e-02f, -4.76912819e-02f,
  -2.42389571e-02f, -7.20535964e-02f, 3.69923823e-02f, -2.52236370e-02f, 4.86169010e-02f, 1.25462040e-01f, -1.85289793e-02f, 1.33285701e-01f, -1.03692282e-02f, 1.54156506e-01f,
  1.80867147e-02f, 7.68515021e-02f, -4.59308140e-02f, 1.42237261e-01f, 1.53737500e-01f, -9.05733556e-02f, -1.17688544e-01f, 4.15489115e-02f, -7.93118030e-02f, -2.10560247e-01f,
  2.57535335e-02f, -1.73698738e-02f, -6.09529056e-02f, 7.66716525e-02f, 7.10125193e-02f, 7.49814138e-02f, 7.26290047e-02f, 1.77684724e-01f, -1.55478910e-01f, 1.04287975e-01f,
  3.49351279e-02f, 1.29941190e-02f, 1.56165496e-01f, 1.12640977e-01f, -1.22920066e-01f, 6.94780238e-03f, 5.20139150e-02f, 1.83999855e-02f, -1.30476296e-01f, 2.55287856e-01f,
  -2.02954356e-02f, 1.04083288e-02f, -1.59427956e-01f, -4.73190211e-02f, -6.31904602e-02f, 1.70976203e-02f, 4.36272880e-04f, -1.33840591e-01f, -1.55732661e-01f, 7.56682381e-02f,
  -1.10815868e-01f, 6.00043591e-03f, -2.10054615e-03f, -6.76269978e-02f, -7.70343915e-02f, 4.34091613e-02f, 3.42007279e-02f, 4.93960679e-02f, 6.08256906e-02f, 2.85164770e-02f,
  -1.16513193e-01f, 6.46387786e-02f, 5.61514348e-02f, 1.97725873e-02f, -1.20221853e-01f, -3.41944993e-02f, -4.71479781e-02f, -3.72017622e-02f, -3.20272110e-02f, 4.03753016e-03f,
  -1.10791065e-01f, 7.93371126e-02f, -1.31617272e-02f, 1.21424519e-01f, 7.19798496e-03f, -1.05838761e-01f, 1.23137362e-01f, -7.10203201e-02f, 5.23307212e-02f, -1.53020620e-01f,
  -1.36362230e-02f, 2.75309589e-02f, -1.34220468e-02f, 3.06774396e-02f, 4.52479534e-02f, -5.01790568e-02f, -3.52332485e-03f, 4.40524309e-04f, -4.76101451e-02f, -8.32080394e-02f,
  -3.76670882e-02f, -1.86341926e-02f, 1.57323331e-02f, -1.97311658e-02f, -1.84989739e-02f, 7.37976804e-02f, -9.78284776e-02f, -6.42617419e-02f, 3.55926417e-02f, -3.59264873e-02f,
  5.35973683e-02f, -1.80189461e-01f, -5.51024750e-02f, 1.19417673e-03f, -2.09004693e-02f, -7.91369602e-02f, -1.63245331e-02f, 1.94321631e-03f, -6.04486503e-02f, -3.24791558e-02f,
  -7.81727396e-03f, -8.47616494e-02f, 2.67167538e-02f, -1.20081648e-01f, 1.59668699e-01f, 3.22840624e-02f, -1.17073864e-01f, -1.38946017e-02f, 2.11955793e-02f, -2.35655174e-01f,
  1.07013665e-01f, 1.50625229e-01f, -3.52304727e-02f, 7.94794038e-02f, -1.18752494e-01f, 9.84815210e-02f, 1.36642322e-01f, -3.58124971e-02f, -5.96771091e-02f, -9.65464041e-02f,
  2.93088071e-02f, -1.56216457e-01f, 1.17324606e-01f, -6.28156662e-02f, 5.81234656e-02f, 1.09968118e-01f, 1.22863144e-01f, -2.16188915e-02f, -6.20460557e-03f, -5.18618450e-02f,
  -3.36858705e-02f, 9.66543928e-02f, -9.65449214e-02f, 5.92491822e-03f, -2.41752993e-03f, 1.26392329e-02f, 8.08855668e-02f, -1.19366134e-02f, -2.00028233e-02f, 3.24479230e-02f,
  -5.63668273e-02f, -1.64830998e-01f, 1.14593014e-01f, -1.19680487e-01f, 6.26140237e-02f, -1.78421140e-02f, 1.80166975e-01f, 9.83557478e-02f, -2.42231544e-02f, 7.60338157e-02f,
  5.98676912e-02f, -5.35983825e-03f, -1.10981725e-01f, -6.75138161e-02f, 1.75865293e-01f, 8.16701800e-02f, -1.59163103e-01f, 4.60255854e-02f, -2.03990899e-02f, -1.64853871e-01f,
  -4.47141007e-03f, -1.29084155e-01f, -1.00030944e-01f, -7.76018295e-03f, 2.32523307e-01f, -8.62691924e-02f, -1.15650021e-01f, 2.12510467e-01f, 4.37601730e-02f, -4.94040586e-02f,
  -1.47190303e-01f, -1.09804459e-01f, 4.64845635e-02f, -6.19901717e-03f, -6.55684993e-02f, 6.85640424e-03f, 7.29651898e-02f, 4.14066855e-03f, 7.32600689e-02f, -6.11384884e-02f,
  5.96904568e-02f, -3.78812365e-02f, 4.68612686e-02f, 1.73828863e-02f, -2.29418930e-02f, 2.02260241e-02f, -1.62313171e-02f, 1.48703028e-02f, 2.23794300e-02f, -3.82669680e-02f,
  5.26603870e-03f, -3.24801286e-03f, 2.25779098e-02f, -7.30663240e-02f, -3.35825235e-03f, 1.07501233e-02f, 4.77040447e-02f, -1.09036686e-02f, -5.04628988e-03f, -3.66244614e-02f,
  4.50343676e-02f, 7.27343336e-02f, -9.98495370e-02f, -4.22779880e-02f, 3.13856429e-03f, -1.80641301e-02f, 5.66600449e-02f, -3.36071774e-02f, 5.20852357e-02f, -5.33216633e-02f,
  7.62978420e-02f, -2.42092572e-02f, -1.73412003e-02f, 4.59798947e-02f, -1.92620251e-02f, -5.88928647e-02f, 3.71109731e-02f, 4.76554446e-02f, 1.11978859e-01f, -4.67043966e-02f,
  -1.78164914e-02f, 4.78918105e-03f, -1.16075248e-01f, 2.45133005e-02f, 4.06407043e-02f, -5.29829040e-02f, 1.42421469e-01f, 2.83972938e-02f, 3.34501043e-02f, 3.37797888e-02f,
  -1.41115917e-03f, 9.08285081e-02f, -7.35333487e-02f, -7.22454302e-03f, 1.14741161e-01f, 1.27851740e-01f, -9.22193751e-02f, -2.47674715e-02f, -2.32007354e-02f, 1.34706022e-02f,
  -1.35411555e-02f, -7.79233128e-02f, 7.71876648e-02f, 1.55524582e-01f, -3.58582586e-02f, -9.40179974e-02f, 3.78919207e-02f, -5.26362695e-02f, 6.13852479e-02f, -2.18771491e-02f,
  5.19342311e-02f, -6.17812611e-02f, -1.13414094e-01f, -7.25712180e-02f, -1.37091130e-01f, -1.48739934e-01f, -1.10021286e-01f, -1.14951566e-01f, 6.80584908e-02f, -5.91698997e-02f,
  1.05664425e-01f, 2.50986479e-02f, -7.08708391e-02f, 2.06808537e-01f, -9.61470976e-02f, -9.30944458e-02f, 3.46290460e-03f, 2.57860310e-02f, -1.69509187e-01f, -3.60956267e-02f,
  -1.13350689e-01f, 1.27795516e-02f, -2.08378077e-01f, 1.68632090e-01f, 6.41541854e-02f, -1.54562980e-01f, 1.29078061e-03f, -2.07677454e-01f, 3.37672830e-02f, 2.14212626e-01f,
  -1.59694225e-01f, -2.70461235e-02f, 6.68608490e-03f, -1.01874471e-01f, 1.44553706e-01f, 1.03405669e-01f, -1.45309702e-01f, 2.46002614e-01f, 6.73101693e-02f, -1.47828516e-02f,
  8.80694855e-03f, -1.35316968e-01f, -2.04212025e-01f, 1.28313661e-01f, 1.59659714e-03f, -3.43653411e-02f, 1.32541046e-01f, -1.50986500e-02f, 3.95369995e-03f, -7.65676722e-02f,
  -6.01318404e-02f, -1.44923467e-03f, 2.13135500e-02f, -8.01060498e-02f, 1.40779617e-03f, -3.77908722e-02f, 1.11483842e-01f, 3.82902399e-02f, -7.65025690e-02f, 6.32449016e-02f,
  2.19937973e-02f, 3.11817508e-03f, 2.49725021e-02f, -2.52921935e-02f, -4.83773127e-02f, -1.05341680e-01f, 1.28115611e-02f, -5.02712987e-02f, -3.47434394e-02f, -1.26587942e-01f,
  -6.74950480e-02f, 2.24312525e-02f, -1.51057824e-01f, -3.06740310e-02f, 1.65889855e-03f, 1.11307696e-01f, -9.17161852e-02f, -3.24554741e-03f, -1.16617724e-01f, -1.36046067e-01f,
  -6.63707480e-02f, -3.13259736e-02f, -1.45326346e-01f, -2.96833497e-02f, -4.87085693e-02f, 4.31287773e-02f, 7.71424398e-02f, 5.14198989e-02f, 4.19355324e-03f, 1.60698220e-02f,
  -1.71774416e-03f, -2.09077112e-02f, 1.70138478e-02f, 1.08866347e-02f, -3.66853699e-02f, -3.34480926e-02f, -1.81900281e-02f, 1.22659668e-01f, 3.19376886e-02f, -1.15236558e-01f,
  -7.19052032e-02f, -2.59472826e-03f, -7.13959038e-02f, -2.86087450e-02f, 4.20074239e-02f, 8.44683573e-02f, 6.51869327e-02f, 5.35022169e-02f, 7.33291171e-03f, -6.09281007e-03f,
  -1.36182427e-01f, 3.90021242e-02f, 1.62956595e-01f, 8.04070979e-02f, -1.22240551e-01f, 2.02571690e-01f, 5.26531693e-03f, -2.40525045e-02f, -1.12947426e-03f, -4.10124883e-02f,
  -5.02830464e-03f, -1.02522209e-01f, -1.06969051e-01f, -1.84086002e-02f, -7.34535083e-02f, -1.46897594e-02f, -7.28106722e-02f, -1.56675205e-02f, -1.52716458e-01f, -6.52832165e-02f,
  -7.06629679e-02f, -4.90690209e-02f, -7.31938034e-02f, 1.06616087e-01f, 2.74103768e-02f, 2.54856031e-02f, 9.29858238e-02f, 1.32612549e-02f, 5.73833697e-02f, -1.19974166e-01f,
  -1.98528301e-02f, -6.14753887e-02f, -4.85538505e-02f, -9.16042924e-02f, -3.73565853e-02f, -4.45732698e-02f, -1.02704833e-03f, -3.29192029e-03f, -6.87273741e-02f, 9.43317935e-02f,
  -8.05112869e-02f, -2.17254888e-02f, -1.14593789e-01f, -1.41318426e-01f, -9.37317535e-02f, -2.13613994e-02f, 1.42301649e-01f, 1.05188720e-01f, 5.26583567e-02f, 1.84715986e-01f,
  -4.46698144e-02f, 1.50988894e-02f, 1.02012418e-02f, 1.58068046e-01f, -1.15874723e-01f, 1.08642191e-01f, -1.61790490e-01f, 3.59384641e-02f, 5.37488312e-02f, 7.78963603e-03f,
  -1.38259947e-01f, -8.63376334e-02f, 2.52066731e-01f, -4.20166180e-03f, -1.56056490e-02f, -4.00338508e-03f, -6.60448968e-02f, -2.42491532e-02f, 5.88765666e-02f, -1.83832962e-02f,
  -3.13205197e-02f, 2.57558636e-02f, -4.27096300e-02f, -5.88309858e-03f, -7.99739957e-02f, -1.42707199e-01f, 2.88742837e-02f, 6.84740990e-02f, -1.24854282e-01f, -2.69879457e-02f,
  -8.96179751e-02f, -5.60594089e-02f, -1.43273458e-01f, 2.32088286e-02f, -4.93485555e-02f, 4.06127598e-04f, -4.03861925e-02f, -6.52915537e-02f, 9.13975108e-03f, -4.93880995e-02f,
  3.22086886e-02f, -4.86925729e-02f, 5.15514016e-02f, -4.24153917e-02f, 5.02933934e-03f, -4.08470258e-02f, -8.33936855e-02f, 1.48183238e-02f, -4.45839465e-02f, -6.82983249e-02f,
  9.26373899e-02f, -2.43496858e-02f, 1.21461146e-01f, -8.59437063e-02f, -2.98136789e-02f, -1.53021365e-02f, -9.75344032e-02f, -2.54515316e-02f, 8.45802203e-02f, -1.51209626e-02f,
  -8.32103100e-03f, -3.05051785e-02f, -5.52830510e-02f, 3.24859582e-02f, -6.46673143e-02f, 7.16216639e-02f, 6.00090995e-02f, -9.82778147e-02f, -3.33824307e-02f, 4.74449396e-02f,
  1.21997474e-02f, -1.41938562e-02f, 1.07172497e-01f, -7.03425184e-02f, 1.28553957e-01f, -3.61717939e-02f, -9.81794018e-03f, 1.40788376e-01f, 6.87141046e-02f, -5.22391126e-02f,
  3.46038714e-02f, 1.02352716e-01f, 4.80854772e-02f, -3.19605768e-02f, 4.04611900e-02f, -1.12821013e-02f, 1.05784923e-01f, 1.93590373e-02f, -5.83520019e-03f, 5.69083691e-02f,
  2.91642882e-02f, 1.09589584e-01f, 2.00465526e-02f, -1.01150028e-01f, 8.84513259e-02f, -6.33858815e-02f, 2.81435554e-03f, -2.15026867e-02f, 3.53321023e-02f, -6.02421723e-02f,
  -6.52279556e-02f, 8.09429958e-03f, 9.37256068e-02f, -4.92669493e-02f, 2.40585580e-02f, 3.43044288e-02f, 2.08377447e-02f, -4.66139149e-03f, -2.40918784e-03f, -1.82498172e-02f,
  -6.18314780e-02f, -8.66068080e-02f, 1.04936637e-01f, -5.80566786e-02f, -1.77694529e-01f, -6.47530034e-02f, 7.59733692e-02f, -8.86030570e-02f, 1.45945027e-01f, 1.09788388e-01f,
  1.00552149e-01f, 2.46750548e-01f, 1.03503941e-02f, 8.47927928e-02f, 6.84486106e-02f, 1.42589882e-01f, 4.93324250e-02f, 7.67562091e-02f, -1.43876955e-01f, -8.09670463e-02f,
  -1.05998315e-01f, 3.93962450e-02f, 8.55540931e-02f, -3.81814949e-02f, 1.06754392e-01f, -4.40530293e-02f, 1.38128147e-01f, 7.48096257e-02f, -1.05657585e-01f, -7.99748227e-02f,
  1.60576791e-01f, -6.36441410e-02f, -4.15151492e-02f, 6.86704293e-02f, -6.58991784e-02f, -4.67108004e-02f, -1.75875630e-02f, -3.36192399e-02f, -3.41288783e-02f, 8.41970667e-02f,
  -8.31004232e-03f, -3.29976492e-02f, -4.09050495e-04f, 1.07885255e-02f, 2.23826785e-02f, 5.06439433e-02f, -7.07079694e-02f, -3.80065478e-02f, -7.14350045e-02f, -1.31895557e-01f,
  -1.62474483e-01f, 1.12920068e-01f, -4.74518202e-02f, -2.32390240e-02f, 4.39044200e-02f, -9.68052167e-03f, 1.54657802e-02f, -4.44627702e-02f, 9.10062566e-02f, -7.42214248e-02f,
  1.32384017e-01f, -6.77924901e-02f, 3.67177743e-03f, 3.33077721e-02f, 4.96199168e-02f, 1.35250345e-01f, -7.53615052e-02f, -1.83453523e-02f, 6.04565069e-02f, 7.84447882e-03f,
  7.88900703e-02f, 7.04504373e-06f, -5.57599403e-03f, -3.24705802e-02f, 7.20016286e-02f, -2.26604640e-02f, 1.28481627e-01f, 7.96749890e-02f, -5.22481650e-02f, -1.12598754e-01f,
  1.01262610e-02f, 8.70202016e-03f, 6.01404719e-02f, -1.28954366e-01f, 9.63654742e-03f, -1.52719463e-03f, 5.23430109e-02f, 1.27224475e-01f, -5.65380082e-02f, 9.85542685e-03f,
  1.11239843e-01f, 5.85615356e-03f, -3.43569256e-02f, -1.00224949e-01f, -4.16421145e-02f, 1.27339348e-01f, 1.17768072e-01f, -1.01180553e-01f, 2.62452196e-02f, 1.13635987e-01f,
  1.32423028e-01f, -1.83867961e-02f, -9.14547592e-02f, 1.29189327e-01f, 6.55360371e-02f, 4.91924100e-02f, 3.92049327e-02f, 2.15502590e-01f, 9.20029134e-02f, 9.81772505e-03f,
  6.89948425e-02f, -6.67053983e-02f, 1.72786757e-01f, -2.47734040e-03f, 1.40455544e-01f, 9.13897306e-02f, -1.18142348e-02f, 5.96025847e-02f, 3.31753232e-02f, -2.70868372e-02f,
  4.37386939e-03f, 2.13379711e-02f, 6.95501547e-03f, 1.63128823e-02f, 1.60161987e-01f, 5.11301570e-02f, 3.40473615e-02f, 7.26950839e-02f, -8.72665644e-02f, 1.27943189e-04f,
  4.76795956e-02f, 7.56465197e-02f, -1.98653728e-01f, -1.06912680e-01f, 1.87433027e-02f, 8.07370320e-02f, -5.48963137e-02f, -8.63111168e-02f, 1.58371955e-01f, 1.14819355e-01f,
  -1.06878057e-01f, 3.80080119e-02f, 1.56462982e-01f, 5.38302287e-02f, -1.17374703e-01f, 2.00675949e-02f, 4.10113670e-02f, -1.00671686e-01f, 1.15822256e-01f, -1.32313237e-01f,
  -5.45301884e-02f, 1.22157663e-01f, 1.14803918e-01f, -1.20941482e-01f, 3.91011685e-02f, -1.06122606e-01f, -5.80785833e-02f, -1.30923763e-01f, -5.38728349e-02f, -1.24497786e-01f,
  5.02852350e-02f, 2.75812298e-02f, -8.60015079e-02f, -2.63854228e-02f, -2.11872309e-02f, -9.23692528e-03f, 2.21552588e-02f, 1.80038288e-02f, 4.97349203e-02f, 7.87893832e-02f,
  -1.03668414e-01f, 4.06412333e-02f, 4.80284393e-02f, 1.27618328e-01f, -3.18560600e-02f, 9.81144607e-03f, -7.78586492e-02f, 9.06214789e-02f, 1.13673896e-01f, 5.09638265e-02f,
  -1.39646992e-01f, 5.40118366e-02f, 1.27196917e-02f, 1.77941740e-01f, 7.36708045e-02f, -2.73644924e-02f, 1.76409557e-01f, -5.66458981e-03f, 3.08803581e-02f, -3.97619233e-02f,
  6.01060130e-02f, 3.34988758e-02f, -3.19652222e-02f, 3.51022147e-02f, 7.64632002e-02f, 9.40608531e-02f, 6.96272328e-02f, -1.81597825e-02f, 3.66997309e-02f, -1.57809258e-01f,
  1.43676614e-02f, -1.02234401e-01f, -1.28656914e-02f, -5.98414754e-03f, 5.73337860e-02f, -1.31968141e-01f, -6.94131106e-02f, 1.09445984e-02f, 4.77196136e-03f, 1.07489772e-01f,
  1.43811982e-02f, -1.51809558e-01f, 1.13829765e-02f, -4.06317078e-02f, -7.67683089e-02f, -9.22498554e-02f, 4.31200303e-02f, 2.48973388e-02f, -7.47464448e-02f, -8.51633921e-02f,
  1.44920554e-02f, -6.70913830e-02f, -1.80351697e-02f, -7.03763589e-02f, 5.08966446e-02f, -9.06194448e-02f, -1.79660171e-01f, -3.17214280e-02f, -3.12513858e-02f, -1.43411100e-01f,
  1.41936868e-01f, 1.05846450e-01f, -2.31600720e-02f, 1.11674376e-01f, -1.11515343e-01f, 4.79297452e-02f, -1.23026222e-02f, -9.49807912e-02f, -8.44957307e-02f, 1.92331523e-02f,
  6.86458126e-02f, -7.58773908e-02f, -1.13465078e-02f, -1.27855465e-01f, -5.85850142e-03f, 1.04738578e-01f, 5.62144630e-03f, -6.06828667e-02f, -3.87526155e-02f, 4.43501994e-02f,
  -5.51754758e-02f, 9.72173885e-02f, -1.09442271e-01f, 2.24087834e-02f, 7.01564997e-02f, 9.72499698e-02f, 4.84907329e-02f, 7.36597478e-02f, -1.82899624e-01f, -1.33902701e-02f,
  -7.43775517e-02f, 9.68406908e-03f, 5.04001379e-02f, -1.69077128e-01f, -2.31576841e-02f, 2.50234395e-01f, 8.98510590e-02f, -5.07652648e-02f, -6.73456769e-03f, 1.11248732e-01f,
  -3.55702974e-02f, 1.54533156e-03f, 1.12773804e-02f, -1.41716376e-01f, 2.23017946e-01f, -2.64486410e-02f, -1.29473582e-01f, 1.66824386e-01f, 1.01457015e-01f, -7.48208687e-02f,
  3.31920087e-02f, 3.02568804e-02f, -1.30486116e-01f, -1.80242255e-01f, 1.10007517e-01f, -1.32794574e-01f, -1.12906449e-01f, 1.13347307e-01f, -1.03458740e-01f, 6.35781586e-02f,
  -8.24525729e-02f, 6.22152165e-02f, -1.30098620e-02f, -6.59904629e-02f, 8.51499066e-02f, -6.45082816e-02f, -6.87235966e-02f, -8.44428723e-04f, -9.66968313e-02f, -3.44873667e-02f,
  5.92490695e-02f, 7.43860006e-02f, -7.69443214e-02f, 5.07383561e-03f, -7.61882961e-02f, -1.56186828e-02f, -2.71897893e-02f, 5.22733070e-02f, -8.43017176e-02f, 9.71277431e-02f,
  3.88770737e-02f, 1.19548023e-01f, 2.28574481e-02f, -3.94085944e-02f, 1.52107552e-01f, -2.93291193e-02f, -3.12927887e-02f, 1.27838412e-02f, 1.23335635e-02f, -6.63422495e-02f,
  -1.56861797e-01f, -1.71234389e-03f, 6.86001182e-02f, -4.56032716e-02f, 6.38293177e-02f, 1.55934703e-03f, 8.29715505e-02f, -2.48710457e-02f, -1.91866755e-02f, -3.14221978e-02f,
  -4.69889864e-02f, -4.45270948e-02f, 1.01826541e-01f, -4.45308685e-02f, 3.98591673e-03f, -8.01863149e-02f, -7.91101679e-02f, 8.55664164e-02f, -1.27200410e-01f, -4.00434732e-02f,
  -6.23159017e-03f, -1.58844113e-01f, -3.77881117e-02f, 2.70499829e-02f, 2.24421788e-02f, -5.28150722e-02f, -1.29780427e-01f, -1.45395502e-01f, 1.65109485e-01f, -2.11999089e-01f,
  6.63500875e-02f, -3.37513238e-02f, -1.28542081e-01f, -1.37411999e-02f, -5.45887016e-02f, -1.37894116e-02f, -4.63374443e-02f, -2.79119641e-01f, 1.66672558e-01f, 2.18421035e-02f,
  1.47878021e-01f, 2.02858374e-02f, -1.97573960e-01f, -3.60715836e-02f, 1.12911567e-01f, -7.23209605e-02f, 1.01951538e-02f, 5.02610728e-02f, 1.63056739e-02f, -1.68272585e-01f,
  -1.29494891e-01f, 2.38884147e-02f, -6.09635189e-02f, -3.20779122e-02f, 6.23432435e-02f, -9.68146026e-02f, 5.32211848e-02f, 8.74141045e-03f, -1.49286419e-01f, 5.61350398e-02f,
  8.48628953e-02f, 3.48153003e-02f, 3.59269567e-02f, 3.87925026e-03f, -1.07673578e-01f, 9.52792540e-02f, 5.26977703e-02f, 1.62964147e-02f, -4.69129421e-02f, 2.13085730e-02f,
  2.95708142e-02f, -1.85258761e-01f, 1.20877348e-01f, 1.47438884e-01f, 1.10780023e-01f, 1.47372335e-01f, 1.12014979e-01f, 1.14715271e-01f, 6.38745874e-02f, 2.76580378e-02f,
  9.16534215e-02f, -2.19983026e-01f, 2.57618427e-02f, -2.19107419e-02f, 4.78710339e-04f, 8.05175006e-02f, 1.05424114e-01f, -7.73865730e-02f, 6.65220214e-05f, 6.50012866e-02f,
  -1.04946263e-01f, 1.14936039e-01f, 8.12370852e-02f, -1.10314578e-01f, -1.13853045e-01f, -1.18064076e-01f, -4.81496453e-02f, 2.45745829e-03f, 1.05185263e-01f, -6.03629723e-02f,
  -8.81811082e-02f, -4.25849333e-02f, -1.01477370e-01f, -8.54229368e-03f, 3.51336636e-02f, -7.08514452e-02f, -1.57004938e-01f, 7.41448179e-02f, 2.76298374e-02f, -4.51648943e-02f,
  -9.68818292e-02f, -1.30438544e-02f, 6.52721822e-02f, 9.46520269e-03f, 9.75405946e-02f, -5.98487370e-02f, -7.65670240e-02f, 2.91125048e-02f, -4.29581590e-02f, 9.41519812e-03f,
  -2.47764140e-02f, -2.46977117e-02f, -3.86197753e-02f, -4.53263782e-02f, -3.06130778e-02f, -1.81711540e-01f, -6.05712608e-02f, 3.04736998e-02f, 3.28040943e-02f, -1.19991459e-01f,
  4.32308018e-03f, -1.75607007e-03f, -9.67124701e-02f, -6.71831816e-02f, -3.92706729e-02f, -1.36617675e-01f, 2.28750575e-02f, -3.71690956e-03f, -1.29106015e-01f, -4.52986434e-02f,
  -9.22852606e-02f, -1.66439719e-03f, 6.47791894e-03f, 2.22847778e-02f, -6.68249950e-02f, -1.50154904e-03f, -6.51082098e-02f, 1.70873925e-02f, -9.19324234e-02f, 5.29402755e-02f,
  1.61517680e-01f, 5.94094507e-02f, -2.70464015e-03f, -5.13175316e-02f, 1.81114227e-02f, 2.52726022e-02f, -1.00246988e-01f, 1.12877123e-01f, -2.98639666e-02f, -4.98333089e-02f,
  6.51194453e-02f, 8.89633875e-03f, -2.48581637e-02f, -1.28043726e-01f, 5.57344109e-02f, -6.36735139e-03f, -7.40722241e-03f, -1.34855494e-01f, -9.38261822e-02f, 9.20950919e-02f,
  4.22214232e-02f, 1.11847982e-01f, -2.44557112e-03f, 6.11482784e-02f, 5.02808355e-02f, -1.12822331e-01f, 5.11344671e-02f, 1.82563311e-03f, 1.33922458e-01f, -3.67908576e-03f,
  1.13597244e-01f, 7.13017583e-02f, 8.42012465e-02f, 2.38278066e-03f, 3.28193093e-03f, -1.77287031e-02f, 1.21046796e-01f, 5.04388995e-02f, -6.05040677e-02f, 5.43964561e-04f,
  -1.53285274e-02f, 3.96867581e-02f, 9.30790082e-02f, -7.14952052e-02f, -1.15626417e-01f, -1.76026076e-01f, 4.79946695e-02f, -1.30485550e-01f, 2.57738143e-01f, -7.43259266e-02f,
  1.16856970e-01f, -1.54970899e-01f, -7.54695088e-02f, 1.89049304e-01f, 7.51957521e-02f, 4.65905294e-02f, -1.28170043e-01f, -1.74424797e-01f, 4.28895913e-02f, 6.91698715e-02f,
  2.36293525e-02f, 9.99159366e-02f, -1.02936655e-01f, -4.90490459e-02f, 1.17796347e-01f, 1.67016797e-02f, -3.79508771e-02f, -5.89466803e-02f, -5.32059930e-02f, 4.79562022e-02f,
  -2.09900960e-02f, -3.27297039e-02f, -1.42589062e-02f, 2.17509300e-01f, 5.59450537e-02f, -6.96236864e-02f, 1.35847107e-02f, 6.23751730e-02f, 5.23399445e-04f, 1.73130333e-02f,
  2.30144653e-02f, -7.21850470e-02f, -3.95348594e-02f, -6.81346804e-02f, 1.13894902e-02f, -1.82482004e-02f, -5.07314019e-02f, -4.54134010e-02f, -1.11077996e-02f, -3.27914357e-02f,
  2.38079727e-02f, -1.17391618e-02f, -8.07273313e-02f, -1.21160269e-01f, 4.38636430e-02f, 3.96426094e-06f, 4.77746129e-03f, -1.15554750e-01f, -5.69009632e-02f, -5.69828739e-03f,
  -7.60486051e-02f, -5.47100008e-02f, -4.37416956e-02f, 2.35492662e-02f, -5.00901155e-02f, 4.55053225e-02f, -6.46550581e-02f, -6.27097785e-02f, 2.46199174e-03f, -7.73204714e-02f,
  -8.18850696e-02f, 2.16111373e-02f, -1.05213940e-01f, -4.47463542e-02f, -4.54022996e-02f, -3.30532193e-02f, -1.49276569e-01f, 3.49540077e-02f, 1.77346170e-02f, -1.36080035e-03f,
  -6.44796267e-02f, -8.50469805e-03f, -1.28476992e-01f, -6.96618333e-02f, -1.11808099e-01f, 1.95509747e-01f, 4.07364331e-02f, -2.83516683e-02f, 6.53439537e-02f, 4.75359596e-02f,
  2.21887585e-02f, -8.96122027e-03f, -1.65058300e-01f, -5.83784245e-02f, 3.84444487e-03f, 7.79240802e-02f, 1.11921486e-02f, -1.06384352e-01f, -2.57334635e-02f, 5.40358908e-02f,
  3.14974263e-02f, -1.00628123e-01f, -8.42103586e-02f, 2.77468637e-02f, -9.10655335e-02f, -8.74182209e-02f, 7.94298649e-02f, 7.72691667e-02f, 1.68509167e-02f, -2.08395734e-01f,
  6.38007745e-02f, 1.83039516e-01f, 2.11953465e-02f, 5.16644418e-02f, -1.63297236e-01f, -3.71422507e-02f, -7.57145062e-02f, -1.02646127e-01f, 1.45195454e-01f, -6.39325902e-02f,
  2.58389069e-03f, 1.79038927e-01f, 1.07970908e-01f, 4.83664833e-02f, -6.40509510e-03f, -2.52050944e-02f, -6.11341223e-02f, -2.02600002e-01f, 2.91100871e-02f, -2.04150960e-01f,
  1.41280875e-01f, -1.11531012e-03f, 5.82684651e-02f, -8.33939910e-02f, 8.21127519e-02f, -6.55169562e-02f, -4.97514606e-02f, 2.37739608e-02f, 9.83273089e-02f, -2.75193959e-01f,
  -8.91683325e-02f, 2.88748834e-02f, -6.27347082e-02f, 4.25396375e-02f, -8.01824704e-02f, -8.41072127e-02f, 5.97789437e-02f, 9.31364149e-02f, -1.21447131e-01f, 4.32269536e-02f,
  -1.18667036e-01f, -2.58740783e-01f, -1.77107528e-02f, -1.39822662e-01f, -9.37675461e-02f, -5.02127297e-02f, -1.40327793e-02f, 1.37226567e-01f, 6.77870139e-02f, -9.28711295e-02f,
  1.46271095e-01f, -4.74537909e-02f, -4.10117442e-03f, 1.34510547e-02f, 9.13632065e-02f, -1.90204978e-02f, -4.42608446e-02f, -6.45945072e-02f, -1.11941166e-01f, -3.92428376e-02f,
  -7.35989213e-02f, -5.06330980e-03f, -1.94065515e-02f, -4.76399669e-03f, -4.70247045e-02f, -2.58606132e-02f, -4.25541699e-02f, -4.98074666e-02f, -4.51238193e-02f, -3.75221893e-02f,
  -1.33703336e-01f, -5.52555621e-02f, -5.81755713e-02f, 8.72756913e-03f, -6.18231520e-02f, -3.14139575e-02f, 2.26807706e-02f, 4.54689376e-02f, -8.17996562e-02f, -2.15435941e-02f,
  -1.64224615e-03f, 1.97911542e-02f, -4.60301079e-02f, -1.42586306e-02f, 5.28145954e-03f, -3.63160633e-02f, -4.62828437e-03f, -4.62353043e-02f, -1.37600070e-02f, -8.12230445e-03f,
  1.37030631e-01f, -5.92746958e-02f, 4.77642417e-02f, 9.01962668e-02f, -7.97976926e-02f, -3.83039750e-02f, -2.93323752e-02f, 6.55412348e-03f, 5.74418157e-02f, -2.81476639e-02f,
  -6.49790540e-02f, 3.38559560e-02f, -6.79940218e-03f, 6.01249710e-02f, 6.45729154e-02f, 8.07544868e-03f, 8.60498697e-02f, 4.93945964e-02f, 7.65133798e-02f, 1.40044745e-02f,
  1.65976822e-01f, -8.71579200e-02f, 7.15240315e-02f, 1.18497029e-01f, -1.53933808e-01f, 2.26251721e-01f, 5.44063449e-02f, -7.48608708e-02f, 4.95322682e-02f, 7.22196698e-02f,
  1.87945485e-01f, 5.18674478e-02f, -8.07000697e-02f, -5.28531335e-02f, 7.32820407e-02f, -6.45878613e-02f, 1.22170947e-01f, 1.14969939e-01f, -3.37821543e-02f, 1.45061016e-01f,
  4.19446826e-02f, -8.33770856e-02f, 3.67957503e-02f, 5.87347336e-02f, 1.82863337e-03f, 5.97846359e-02f, 3.38059627e-02f, -9.00313184e-02f, -1.05277747e-01f, -2.74154339e-02f,
  7.57400841e-02f, -6.81169927e-02f, 1.08778782e-01f, -3.06192948e-03f, 5.34982374e-03f, 6.93801045e-02f, 2.86208540e-02f, 2.64366679e-02f, -3.26796845e-02f, 1.13953389e-02f,
  -1.55003404e-03f, -1.13915972e-01f, -1.33056447e-01f, -1.20739285e-02f, 8.87251869e-02f, 5.10154963e-02f, 2.63236873e-02f, -1.10589974e-01f, 1.34289330e-02f, 2.22543448e-01f,
  -7.26878345e-02f, 2.57065091e-02f, -2.55296342e-02f, 1.95124168e-02f, 1.14778019e-01f, 1.29529163e-01f, -2.60425866e-01f, -1.32508919e-01f, -9.78801996e-02f, -1.24279916e-01f,
  1.12005718e-01f, -9.79749113e-02f, 5.76696992e-02f, 4.15052325e-02f, 1.63687304e-01f, 2.81581352e-03f, -2.34436929e-01f, 2.53494531e-02f, 8.65451023e-02f, -7.34244566e-03f,
  -6.07466325e-02f, -6.27915040e-02f, 5.06809577e-02f, 1.10705338e-01f, -1.64748356e-02f, -1.18701629e-01f, -5.02608009e-02f, -1.14598513e-01f, -5.71128391e-02f, 2.68568471e-02f,
  -9.85092893e-02f, -1.00909099e-01f, 5.95185198e-02f, -9.05476138e-02f, 2.55326852e-02f, 1.73892546e-03f, 2.47075707e-02f, 1.92592933e-03f, 4.26564813e-02f, -3.71150821e-02f,
  1.28930090e-02f, -3.14340182e-02f, -7.75509560e-03f, 2.50750277e-02f, 2.66425181e-02f, -6.14164695e-02f, 1.21412221e-02f, 5.89040779e-02f, -9.02570561e-02f, -3.55169140e-02f,
  -2.42398027e-02f, -8.70143324e-02f, -7.43580535e-02f, -3.98177002e-03f, -5.58149861e-03f, 9.06686783e-02f, 3.42557058e-02f, -7.90047925e-03f, 9.64997858e-02f, -8.89381319e-02f,
  2.26833634e-02f, -2.11737677e-02f, -2.92877294e-02f, -7.91129470e-02f, -9.12809074e-02f, -4.55221310e-02f, 5.52299917e-02f, -2.82176398e-03f, -5.15547320e-02f, 1.14834540e-01f,
  -9.03339460e-02f, -6.86409324e-03f, -3.03287208e-02f, 9.38316286e-02f, -6.51992531e-03f, 3.83169316e-02f, 7.37502575e-02f, 2.56952383e-02f, -9.26967338e-02f, -1.45803273e-01f,
  2.44636927e-02f, -6.87142313e-02f, -9.98954549e-02f, 8.06974545e-02f, -8.04373771e-02f, -1.83229353e-02f, -8.60553011e-02f, -1.07201792e-01f, -1.83428545e-02f, -1.43487275e-01f,
  7.09895119e-02f, -8.45764056e-02f, 1.12442888e-01f, -2.82206610e-02f, -2.03026943e-02f, 1.79036543e-01f, 3.72684039e-02f, -8.81525204e-02f, 7.49362931e-02f, 2.44249217e-02f,
  1.11149304e-01f, 2.10533440e-02f, -1.97008438e-02f, 1.95605401e-02f, -5.17998450e-02f, -9.59471520e-03f, 4.39749137e-02f, -2.39447802e-01f, -1.15935355e-02f, -5.13411574e-02f,
  -1.20013863e-01f, -1.21791236e-01f, -8.29242356e-03f, 2.10331097e-01f, 6.95258379e-02f, 1.59738898e-01f, -1.07418783e-01f, 1.62539050e-01f, -7.19450787e-02f, -3.61074717e-03f,
  6.54590055e-02f, 3.28502730e-02f, 6.48207068e-02f, -1.50249675e-01f, -3.79923061e-02f, 9.32044089e-02f, 1.21882521e-01f, 7.09397793e-02f, 1.58955947e-01f, 5.08964583e-02f,
  -2.31562316e-01f, -1.34020329e-01f, 1.73465446e-01f, -2.58469015e-01f, 3.53187509e-02f, -5.55544682e-02f, 6.24270625e-02f, -1.06083332e-02f, 1.54783502e-01f, 7.27303326e-02f,
  1.75264671e-01f, 1.09114662e-01f, -4.34571244e-02f, 1.08573493e-02f, -5.70761273e-03f, 1.12095997e-01f, -1.07210159e-01f, -5.83632998e-02f, 3.11096455e-03f, 7.09722787e-02f,
  -7.45711848e-03f, -3.47196795e-02f, -7.79307261e-02f, 5.47310524e-03f, 1.50128559e-03f, -1.43981278e-02f, 4.96069863e-02f, 7.72809014e-02f, 2.48238631e-02f, 3.31437215e-02f,
  -5.37658744e-02f, -6.24460988e-02f, 3.72960372e-03f, -3.31944712e-02f, -4.18713503e-03f, -8.27384926e-03f, 8.42917711e-02f, -1.61537938e-02f, -6.23091636e-03f, -6.46841200e-03f,
  -4.12030751e-03f, 5.19429334e-02f, -5.14117777e-02f, 1.14962216e-02f, 5.22886887e-02f, -7.34976232e-02f, 4.93787192e-02f, 1.48943504e-02f, 3.79876979e-02f, 3.14195231e-02f,
  1.16305865e-01f, 6.06854670e-02f, -2.40870919e-02f, 2.64386423e-02f, -2.19420604e-02f, -2.96547823e-02f, -8.26398730e-02f, 5.77378981e-02f, -1.18247839e-03f, 2.12816726e-02f,
  2.79317517e-02f, -3.33158448e-02f, -3.72391269e-02f, 5.64997308e-02f, -9.28348303e-02f, 7.27116084e-03f, 6.73691109e-02f, -1.11009199e-02f, 1.40507162e-01f, -1.56367719e-01f,
  -7.41482005e-02f, 1.05799429e-01f, -1.09043278e-01f, -2.69844793e-02f, -2.72835176e-02f, 4.76990566e-02f, -8.95647425e-03f, -2.69982032e-02f, -1.66851446e-01f, 4.70792018e-02f,
  -5.92083149e-02f, -4.42345217e-02f, 1.70492027e-02f, 1.95336714e-02f, -1.34621084e-01f, -7.88000003e-02f, 4.23539802e-02f, -8.54914263e-02f, -2.86303591e-02f, 1.25111386e-01f,
  -3.25138643e-02f, -7.41990134e-02f, -3.31355631e-02f, 1.60945982e-01f, 5.41588292e-02f, -8.62700492e-02f, -4.41315174e-02f, 4.24564369e-02f, 2.80682575e-02f, 9.41215141e-04f,
  3.16580646e-02f, 2.69782040e-02f, -9.71855968e-03f, 8.30673054e-02f, 1.49079695e-01f, -7.23133311e-02f, -1.05930045e-01f, 1.19810048e-02f, 7.12258816e-02f, -4.10485528e-02f,
  -1.30661085e-01f, 1.16159663e-01f, 4.01097089e-02f, 3.63142677e-02f, 9.64011550e-02f, 1.31866038e-01f, -8.05239752e-02f, 2.00125620e-01f, -2.55378168e-02f, -8.79634824e-03f,
  -2.94252038e-02f, 2.90841628e-02f, -1.77569047e-01f, -1.68901607e-01f, 2.24590048e-01f, -1.40774861e-01f, -1.44013360e-01f, -1.15583166e-02f, -2.54348889e-02f, -7.57317841e-02f,
  -6.15179725e-02f, -7.81217888e-02f, 1.64613724e-01f, 3.18024890e-03f, 8.35602060e-02f, -4.26135361e-02f, -7.36779347e-02f, -7.48164728e-02f, 1.55286863e-01f, 2.22419482e-02f,
  -8.90755001e-03f, -1.60224482e-01f, 4.54002135e-02f, 1.69703335e-01f, -1.25837326e-01f, 1.12086892e-01f, -5.02347387e-03f, 2.19952185e-02f, -2.81087365e-02f, 7.07955658e-02f,
  8.14734921e-02f, -3.83189134e-02f, 2.98613738e-02f, -1.09701887e-01f, 2.94132304e-04f, 1.38626751e-02f, -3.24943252e-02f, -8.22984874e-02f, -3.99557315e-03f, -1.97336613e-03f,
  -4.80344631e-02f, 9.55506600e-03f, -7.16624483e-02f, 1.86851583e-02f, -2.39383671e-02f, -3.66647132e-02f, 5.11281788e-02f, 6.31886721e-02f, -2.61198282e-02f, -3.58575806e-02f,
  -7.91168436e-02f, -3.79965045e-02f, -4.46433015e-02f, 4.31546383e-02f, -9.40586552e-02f, 9.81366932e-02f, 9.62276477e-03f, -9.25651789e-02f, -1.74196452e-01f, -1.04865558e-01f,
  2.67461985e-02f, -7.87685961e-02f, -4.85759750e-02f, -5.07300384e-02f, 4.02927436e-02f, 6.52226582e-02f, 3.43674012e-02f, -9.19062048e-02f, -4.09866050e-02f, -2.88419332e-02f,
  3.26736122e-02f, -1.14637360e-01f, 3.66788693e-02f, -2.38614604e-02f, -3.44661959e-02f, 3.61614190e-02f, -2.20960736e-01f, 1.88955814e-01f, 5.55713922e-02f, -1.51269287e-01f,
  8.90840311e-03f, -9.13375616e-03f, 1.00811971e-02f, 7.09746778e-02f, -1.08576946e-01f, -1.53931305e-01f, 1.82732806e-01f, -9.75021198e-02f, 2.15120781e-02f, -2.67542414e-02f,
  -2.16804296e-01f, 3.15645672e-02f, -7.03497455e-02f, -4.03051414e-02f, -1.05579548e-01f, -3.47411148e-02f, 6.69827685e-02f, -1.72362402e-01f, 1.95757523e-01f, -3.26668210e-02f,
  -3.54737453e-02f, -1.18819319e-01f, 8.78054742e-03f, 1.61496247e-03f, -5.11556026e-03f, 1.21331528e-01f, -8.21608678e-02f, -3.70300859e-02f, -1.36309102e-01f, -2.42048549e-03f,
  -1.00247741e-01f, -5.33842519e-02f, -1.62364673e-02f, 1.84095204e-02f, 9.34701189e-02f, 6.11362373e-03f, -1.10087544e-01f, 3.28803957e-02f, 1.10632971e-01f, -1.32145099e-02f,
  5.60616255e-02f, -1.30731864e-02f, -9.34293792e-02f, 7.53844380e-02f, 1.54806018e-01f, -5.02131768e-02f, 9.92121398e-02f, 3.89723033e-02f, -7.28057250e-02f, -1.22685052e-01f,
  7.98741579e-02f, 1.55294925e-01f, 7.22865835e-02f, 3.26953433e-03f, 1.91141665e-01f, 5.77581674e-02f, -1.03252754e-02f, 1.83154829e-02f, 1.66162014e-01f, 1.70307718e-02f,
  -1.17361262e-01f, -1.52433105e-02f, -5.70904836e-02f, 8.00199732e-02f, 2.98680179e-02f, -5.67192398e-02f, -8.17542076e-02f, 2.25022942e-01f, 1.28777407e-03f, 1.36446252e-01f,
  9.61218998e-02f, -1.37593687e-01f, 7.96262622e-02f, -2.12851763e-01f, -7.89419934e-02f, -1.74245536e-02f, 7.23915696e-02f, 1.03655294e-01f, -7.07048690e-04f, -6.11093342e-02f,
  -2.58681062e-03f, -8.76810998e-02f, -7.65216872e-02f, -1.18611509e-03f, -8.13035760e-03f, 8.36844742e-03f, -3.35857533e-02f, -3.31986919e-02f, -4.51005436e-02f, -5.69524579e-02f,
  -3.19855437e-02f, 9.98286232e-02f, 4.14730608e-02f, 3.00211329e-02f, 6.79255351e-02f, 6.12253547e-02f, 4.21475582e-02f, 5.27445041e-02f, -2.74258368e-02f, -9.04891565e-02f,
  3.41611705e-03f, 9.20463260e-03f, -1.30744666e-01f, 1.12176798e-02f, -4.73163314e-02f, 5.72012179e-03f, -1.06833450e-01f, -8.11928809e-02f, 1.07084788e-01f, 5.35994209e-02f,
  -2.55332212e-03f, -2.05188263e-02f, -9.77284238e-02f, -6.98448420e-02f, 5.21613732e-02f, -1.88940787e-03f, 5.07064871e-02f, -1.39848471e-01f, 7.52504691e-02f, -8.96116272e-02f,
  2.62893783e-03f, -7.00307218e-03f, 6.59440756e-02f, -3.62016298e-02f, -1.71046212e-01f, -2.72156335e-02f, -2.06646323e-01f, 1.02757707e-01f, 9.59297866e-02f, -7.34394565e-02f,
  -2.97422241e-02f, 2.83959433e-02f, -1.69365942e-01f, -1.12260394e-01f, 1.29439220e-01f, -1.23437896e-01f, -7.68725425e-02f, -7.93986693e-02f, -1.99716121e-01f, 5.23419268e-02f,
  -1.58482566e-01f, -1.03535339e-01f, -1.12809137e-01f, -6.08759262e-02f, 6.14227168e-02f, -1.30992457e-01f, -6.89585460e-03f, 3.42573635e-02f, -7.92544335e-02f, -4.78553120e-03f,
  -8.82151723e-02f, -1.02211267e-01f, 1.16239749e-02f, 1.58677325e-01f, -2.55363360e-02f, -4.04530875e-02f, -2.62424294e-02f, -4.65855822e-02f, -5.38667478e-02f, 2.51993677e-03f,
  9.90737006e-02f, -1.03892058e-01f, 7.95687065e-02f, 2.50146016e-02f, -1.33122087e-01f, -3.65419611e-02f, 1.02366291e-01f, 1.84688028e-02f, -1.69762839e-02f, 9.62870717e-02f,
  -5.26526086e-02f, -7.37733692e-02f, -1.15623266e-01f, -2.66281385e-02f, 1.56469554e-01f, 7.01664528e-03f, 9.94614735e-02f, -9.81786922e-02f, 1.28857777e-01f, 1.12612925e-01f,
  3.23947072e-02f, 7.31801381e-03f, 1.89921424e-01f, -1.23449985e-03f, -1.37471005e-01f, -1.66892946e-01f, 1.46237090e-01f, -1.85143828e-01f, 1.59525856e-01f, 8.77013952e-02f,
  1.72917556e-04f, -3.88559559e-03f, 1.47467643e-01f, 2.68114842e-02f, -3.15498896e-02f, 1.64417237e-01f, -9.24063101e-02f, 3.28496397e-02f, 1.24117739e-01f, -1.44282192e-01f,
  -8.92673358e-02f, -1.37245089e-01f, 1.72949806e-02f, 5.46319522e-02f, 5.12119643e-02f, 8.18559751e-02f, 3.15676108e-02f, 6.87439740e-02f, 6.68411329e-02f, -2.56691184e-02f,
  8.10115710e-02f, 3.26897949e-02f, -1.14172548e-02f, 4.70825145e-03f, -5.85741811e-02f, -8.85510370e-02f, -4.60416451e-03f, -4.57474478e-02f, 3.60984467e-02f, -1.16199963e-02f,
  1.19563835e-02f, 1.12190768e-01f, 1.33381933e-01f, 3.67979780e-02f, 1.42829150e-01f, -7.85272047e-02f, 2.88364459e-02f, 5.31965308e-02f, 5.35826851e-03f, 4.80334759e-02f,
  8.80404115e-02f, 6.46475405e-02f, 9.79822651e-02f, 6.61859065e-02f, -7.58644380e-03f, 1.93842322e-01f, 8.15413073e-02f, 1.62579902e-02f, 6.80230409e-02f, 1.04958266e-01f,
  -2.74034999e-02f, 3.05856224e-02f, 1.18918605e-02f, 1.18548833e-01f, 1.99973509e-02f, 4.91316728e-02f, 8.06827173e-02f, 8.94696712e-02f, -5.97188100e-02f, 4.97048721e-02f,
  1.29443541e-01f, -1.52054150e-02f, 2.36372128e-02f, -8.23934972e-02f, -1.12826943e-01f, 7.27249309e-02f, -8.50183051e-03f, 2.93942913e-02f, -1.18967384e-01f, -2.78137848e-02f,
  -1.67117417e-02f, -2.07285816e-03f, -3.47874500e-02f, 1.00350298e-01f, -1.37842715e-01f, -9.81551707e-02f, 3.14025655e-02f, 1.02273151e-01f, -5.17046591e-03f, 1.12024732e-02f,
  -1.48324873e-02f, 9.53463167e-02f, -1.34910226e-01f, 1.13917336e-01f, 1.03623969e-02f, 2.59042233e-02f, 3.12416926e-02f, -6.03288412e-03f, 8.62818491e-03f, 9.74411727e-04f,
  2.28434820e-02f, 8.81531090e-02f, -6.66158348e-02f, -6.91953078e-02f, 3.28674577e-02f, -3.85337509e-02f, 7.95879886e-02f, 5.05523831e-02f, 8.51137117e-02f, 5.42114004e-02f,
  7.23314285e-02f, 1.31278029e-02f, 3.62122394e-02f, -3.58839743e-02f, -2.57952698e-02f, -6.49556667e-02f, 3.97607312e-02f, -1.45697758e-01f, 1.64313480e-01f, 9.47678275e-03f,
  -1.43857989e-02f, 1.62642375e-01f, -6.03330024e-02f, -1.46070048e-01f, -5.52019812e-02f, 1.61070555e-01f, -6.80049285e-02f, -1.51968822e-01f, 1.06213599e-01f, -1.10112250e-01f,
  -9.59420726e-02f, -4.12730296e-04f, 3.76580097e-02f, -2.65909247e-02f, 9.64886229e-03f, 1.02382347e-01f, 7.04879463e-02f, 1.47692889e-01f, 6.16371334e-02f, -8.62062722e-02f,
  -1.00999907e-01f, -9.57758203e-02f, 4.77797166e-02f, -2.30544321e-02f, 1.21681616e-01f, -2.97462475e-02f, 6.47253990e-02f, 1.04388902e-02f, 1.70008361e-01f, 2.33164597e-02f,
  2.70510186e-03f, 3.91059294e-02f, 1.18815794e-03f, -1.70095377e-02f, -4.51669358e-02f, 2.41648797e-02f, 3.14436369e-02f, -7.73756355e-02f, 8.58103335e-02f, -1.39127644e-02f,
  8.77179056e-02f, 3.75722311e-02f, -2.76592635e-02f, 1.58789661e-02f, 3.97157408e-02f, 5.21846265e-02f, 6.15875348e-02f, 4.97948676e-02f, 1.07789300e-01f, -4.15136144e-02f,
  -9.92212817e-03f, -3.55830230e-02f, -2.27356851e-02f, 5.73091470e-02f, -3.06605529e-02f, -1.66536553e-03f, -6.11339808e-02f, 2.58682091e-02f, 6.75038528e-03f, 4.18923050e-02f,
  -2.32683048e-02f, 1.80151605e-03f, 8.55931267e-02f, -4.70319055e-02f, -3.47559378e-02f, 1.81266386e-02f, -8.64918679e-02f, -1.17763551e-02f, -1.57054827e-01f, 4.76043187e-02f,
  3.46377529e-02f, -1.24848103e-02f, 9.64538902e-02f, 1.22601409e-02f, -9.35267806e-02f, 5.28703146e-02f, -4.20950993e-04f, 3.55896354e-02f, 4.76843789e-02f, -2.41536181e-02f,
  2.35395730e-02f, -7.10537210e-02f, -3.88501026e-02f, 1.91088617e-02f, 4.48731408e-02f, -3.89223136e-02f, -5.41823655e-02f, 3.40180509e-02f, -1.42053559e-01f, 1.27222076e-01f,
  -9.61808637e-02f, -7.11751133e-02f, 6.71288744e-02f, -1.11101769e-01f, -8.17245245e-02f, 4.83013615e-02f, -5.77008678e-03f, -5.53545430e-02f, -7.37615377e-02f, -2.70814747e-02f,
  2.19118968e-02f, -1.49704618e-02f, -7.80989453e-02f, -2.45798603e-02f, -7.13958219e-02f, -2.51331031e-02f, 3.26187201e-02f, -1.44937858e-01f, -3.00900619e-02f, 1.51242753e-02f,
  -2.38395128e-02f, 4.07030247e-02f, 7.37839937e-03f, 4.66715395e-02f, -9.85185429e-02f, 6.19832799e-02f, 7.45605677e-02f, -1.29736634e-02f, -4.51207049e-02f, 3.79074402e-02f,
  -7.59839490e-02f, -5.09251142e-03f, 1.11563737e-02f, 5.06119942e-03f, -1.57723464e-02f, 4.71916199e-02f, -5.49071021e-02f, 2.02268567e-02f, -5.66223525e-02f, 9.07365233e-02f,
  1.14552453e-01f, 8.13970268e-02f, -4.99644130e-02f, 3.54462899e-02f, -1.05834238e-01f, -6.48566708e-02f, -4.02236283e-02f, -2.13727191e-01f, 2.49178018e-02f, -1.11812823e-01f,
  5.60634322e-02f, -3.09039745e-02f, -9.33790132e-02f, -1.16485819e-01f, 1.44055203e-01f, 6.14088923e-02f, 1.29015297e-01f, 1.07610025e-01f, -1.71631664e-01f, 8.31392780e-02f,
  -1.02955759e-01f, -5.28862178e-02f, -1.32846922e-01f, -4.79931459e-02f, 8.54919851e-02f, 1.61872003e-02f, -1.62562326e-01f, 1.97781939e-02f, 7.01605752e-02f, -1.19113147e-01f,
  8.18140619e-03f, -8.82779947e-04f, 3.86264548e-02f, 1.26996376e-02f, -3.60819474e-02f, 7.38305273e-03f, 5.67425303e-02f, -1.91272404e-02f, -1.78437810e-02f, -6.47003856e-03f,
  -4.78527416e-03f, -4.46745753e-02f, 7.17732757e-02f, 4.89988253e-02f, 7.51379430e-02f, 6.55708164e-02f, 1.90193981e-01f, -1.45089194e-01f, 8.24622884e-02f, 1.77769735e-02f,
  -3.74582708e-02f, 1.05320876e-02f, 1.19355172e-02f, 6.44151717e-02f, -9.78542641e-02f, 3.17993350e-02f, -1.50724366e-01f, 1.03583626e-01f, 4.32294281e-03f, -3.96677777e-02f,
  3.39975134e-02f, -1.45115018e-01f, 6.32191673e-02f, 6.55330271e-02f, -5.30432425e-02f, -2.32866732e-03f, -9.50269103e-02f, -5.04404195e-02f, 5.31100575e-03f, -5.34273349e-02f,
  -5.38256913e-02f, 3.46431695e-02f, -9.98771638e-02f, -1.14925750e-01f, 5.18875681e-02f, 8.51374269e-02f, -3.43303829e-02f, -5.60303510e-04f, -9.08946171e-02f, 1.43701360e-01f,
  1.38930809e-02f, 2.86072399e-02f, -4.80134562e-02f, -7.01661035e-02f, 6.62603378e-02f, -8.24342109e-03f, -4.96737845e-02f, 4.29395773e-02f, 6.47533452e-03f, 1.42148867e-01f,
  8.67239535e-02f, -7.23914802e-02f, -4.15136889e-02f, 2.02366915e-02f, -1.24308310e-01f, -1.10676534e-01f, -1.01502113e-01f, 5.40652908e-02f, 5.56725450e-02f, -1.41068682e-01f,
  -1.41725868e-01f, 1.49217052e-02f, 9.00265500e-02f, -1.69673190e-01f, -1.66249514e-01f, -4.78561874e-03f, -3.97255942e-02f, 7.94303864e-02f, -9.70198438e-02f, 7.86190033e-02f,
  -5.70965633e-02f, -1.01852223e-01f, 2.76331734e-02f, -8.94408971e-02f, -9.88396555e-02f, -1.81678440e-02f, -7.40312189e-02f, -2.28762794e-02f, 5.16542494e-02f, -2.49978080e-02f,
  -1.39933705e-01f, -8.59919470e-03f, -1.32796811e-02f, 3.44528556e-02f, 1.13555059e-01f, -5.04014976e-02f, -4.02756743e-02f, -7.81783536e-02f, 2.18929559e-01f, 1.53211594e-01f,
  3.40306610e-02f, -8.41546208e-02f, -4.81049605e-02f, 2.22178344e-02f, -1.22327812e-01f, -1.11843884e-01f, 1.41065910e-01f, -6.20380566e-02f, -2.10093498e-01f, -1.38001218e-01f,
  4.21288125e-02f, 6.77354485e-02f, -1.07362069e-01f, 4.44521531e-02f, -2.67818235e-02f, -1.96513310e-02f, 4.31310050e-02f, -1.17444575e-01f, -1.25122638e-02f, 7.74792507e-02f,
  -8.27299878e-02f, -5.26346220e-03f, -1.40603498e-01f, 1.72326550e-01f, 8.25772062e-02f, 1.48901463e-01f, 8.15192889e-03f, -2.97894292e-02f, 1.09573007e-02f, -1.76554136e-02f,
  2.08017156e-02f, -4.18457296e-03f, 4.40620398e-03f, -6.06593639e-02f, 2.83637401e-02f, -4.07039411e-02f, 1.36494517e-01f, 6.91787601e-02f, -4.45565507e-02f, 2.32419837e-02f,
  2.70617995e-02f, 7.74366036e-02f, -5.25820367e-02f, 3.10546067e-02f, 7.24332258e-02f, 5.58324270e-02f, 3.96753438e-02f, -4.59983200e-02f, -6.47396222e-02f, 4.20775637e-02f,
  2.74795052e-02f, -3.13236155e-02f, -1.42762661e-02f, 7.39321634e-02f, -2.66680587e-02f, 3.23320739e-02f, 3.27617489e-02f, 1.06085986e-01f, 5.62644489e-02f, -7.09634870e-02f,
  4.30777073e-02f, 1.00731747e-02f, -2.35522818e-02f, -3.75610925e-02f, -1.57178894e-01f, 1.50432184e-01f, 4.19882499e-03f, -2.30722297e-02f, 1.03414275e-01f, -3.41686010e-02f,
  -8.41894560e-03f, -5.13333119e-02f, -1.07206851e-02f, -1.23764994e-02f, 7.28136599e-02f, -1.14333346e-01f, -2.85886079e-02f, -7.03374250e-03f, 2.25387961e-02f, -6.19734153e-02f,
  1.10676892e-01f, -4.55410033e-02f, -4.34619673e-02f, 4.11499292e-02f, -1.04616009e-01f, 7.54162073e-02f, -2.08503939e-02f, -1.37468591e-01f, 1.05293825e-01f, -8.65236446e-02f,
  -1.25817224e-01f, -2.68307701e-03f, -8.08775946e-02f, -4.60596383e-02f, 3.66039425e-02f, 8.99862275e-02f, 5.88235185e-02f, -3.36445533e-02f, -6.71717301e-02f, -5.37813036e-03f,
  -8.59720185e-02f, -6.47924840e-02f, 3.75097874e-03f, -1.37268767e-01f, -3.21482215e-03f, 5.75953387e-02f, 1.23730954e-03f, 5.34735695e-02f, 1.52853306e-03f, 1.04804479e-01f,
  -6.63662106e-02f, 7.65496492e-02f, 1.45534709e-01f, 3.80726382e-02f, -2.27776188e-02f, 5.49188741e-02f, -1.13634810e-01f, 9.47531760e-02f, 1.04218818e-01f, -4.76701111e-02f,
  -1.00187369e-01f, 5.94427362e-02f, -8.81256089e-02f, -6.01398200e-02f, -2.55234614e-02f, 3.68393883e-02f, 1.44191325e-01f, 1.11436091e-01f, 6.22638315e-03f, -1.70483068e-02f,
  6.02972172e-02f, 7.77092427e-02f, -1.34886190e-01f, -8.38782936e-02f, 8.62372592e-02f, -4.68692407e-02f, 8.74385536e-02f, -4.14655842e-02f, -1.02720842e-01f, -7.28248134e-02f,
  1.02759957e-01f, 1.02063090e-01f, 4.58263196e-02f, 1.26393124e-01f, -6.83855340e-02f, 1.13072142e-01f, -2.00511590e-01f, -2.20068893e-03f, -9.41839144e-02f, 2.86799688e-02f,
  7.03933761e-02f, -1.28301069e-01f, -2.24100173e-01f, -4.21103165e-02f, -4.77210656e-02f, -9.97803174e-03f, -3.86057422e-02f, -4.60174903e-02f, -4.95943353e-02f, -6.27933219e-02f,
  -1.14970930e-01f, -2.13769916e-02f, -6.51717186e-02f, 1.84036531e-02f, -7.96976220e-03f, -9.26048160e-02f, -5.01921549e-02f, 2.81724334e-03f, -2.29775738e-02f, -2.51903404e-02f,
  -1.41026258e-01f, -6.10032156e-02f, -2.08829865e-02f, 1.80816799e-02f, -1.41254634e-01f, -3.72078530e-02f, -9.10719484e-02f, 3.36655863e-02f, 8.87421370e-02f, -2.01060567e-02f,
  1.13222925e-02f, -5.05520105e-02f, -3.74098122e-02f, -1.07366689e-01f, -5.39937466e-02f, -1.06552899e-01f, 1.79839861e-02f, -7.44224712e-02f, -1.38506722e-02f, 1.50309559e-02f,
  -2.35182531e-02f, -1.26342118e-01f, 1.18965626e-01f, -5.01764789e-02f, -9.18851118e-04f, -1.25186965e-02f, 4.85171843e-03f, -8.29498917e-02f, -5.47293648e-02f, -2.93896813e-02f,
  6.27158433e-02f, -4.21260707e-02f, -5.41739948e-02f, -1.98905710e-02f, -1.88187379e-02f, 1.90626103e-02f, 1.19519621e-01f, -1.13124967e-01f, -2.16954723e-02f, -7.60955065e-02f,
  6.94586113e-02f, 5.06439097e-02f, 1.28089935e-01f, 5.11103570e-02f, 1.08274549e-01f, -2.91989259e-02f, 6.53214008e-03f, 2.12014601e-01f, 3.53647098e-02f, -1.39053956e-01f,
  -3.47330347e-02f, 1.10650413e-01f, 1.76721677e-01f, 8.68311431e-03f, 1.27771497e-01f, -4.89844149e-03f, -5.02194315e-02f, -6.90129697e-02f, -2.88998540e-02f, 1.24586150e-01f,
  -9.45109129e-02f, -9.76395234e-02f, -9.72889438e-02f, -1.05724968e-01f, 1.44519374e-01f, 8.48386716e-03f, 8.49336162e-02f, 1.06635138e-01f, -9.97923985e-02f, -4.17222315e-03f,
  -5.97807057e-02f, -7.42017478e-02f, -4.18175310e-02f, -7.27470294e-02f, 3.94570641e-02f, 7.61007294e-02f, 7.79723227e-02f, 1.29780665e-01f, -1.82556920e-02f, 1.98205963e-01f,
  -1.67340338e-01f, -1.77159403e-02f, -1.55644640e-02f, -9.38995332e-02f, -1.55102417e-01f, 9.24380496e-02f, 1.19746730e-01f, -4.75720093e-02f, 4.79097292e-02f, 2.27496132e-01f,
  -1.90202985e-02f, 1.55413032e-01f, 7.71673396e-02f, 5.24600642e-03f, 8.17632824e-02f, 8.91754404e-02f, 4.41010483e-03f, -3.12758982e-02f, -1.19031802e-01f, -1.26230091e-01f,
  -8.94792974e-02f, 2.24969491e-01f, 1.08198956e-01f, -2.08321288e-02f, 4.56223749e-02f, 3.40799405e-03f, -1.64055396e-02f, -1.37167601e-02f, -1.58950731e-01f, -2.93139694e-03f,
  -1.46567464e-01f, 2.67293435e-02f, 3.73143633e-03f, -1.16433449e-01f, -1.06823891e-01f, -1.32093966e-01f, -5.69991842e-02f, -6.77103351e-04f, -4.14520614e-02f, -7.69562200e-02f,
  -2.60198619e-02f, 2.00655870e-02f, 3.98532525e-02f, -1.46901101e-01f, -9.01935175e-02f, -4.05123234e-02f, -3.74077968e-02f, -3.66272517e-02f, -6.61400035e-02f, -1.46509511e-02f,
  -8.01887512e-02f, -1.39669850e-01f, 7.55913332e-02f, -4.34616804e-02f, -5.38994856e-02f, -1.32105172e-01f, -6.60553351e-02f, -5.34057245e-02f, -8.98481458e-02f, -2.43604183e-02f,
  -1.31086811e-01f, 2.09555812e-02f, -1.24559805e-01f, -9.05153006e-02f, 1.95715241e-02f, -7.80919269e-02f, 4.34996113e-02f, -1.69097334e-01f, -6.76105246e-02f, -6.32856414e-02f,
  4.79162671e-02f, -2.14935504e-02f, -7.67102465e-03f, -3.90916616e-02f, 3.63144390e-02f, -8.91646296e-02f, 6.94134925e-03f, 2.39092577e-02f, 1.68343540e-02f, -5.05122989e-02f,
  7.68608451e-02f, -6.43203482e-02f, -5.45842163e-02f, 1.44892097e-01f, -3.85874175e-02f, 1.38021797e-01f, -1.82957515e-01f, -1.18494049e-01f, -1.38820380e-01f, 4.22936790e-02f,
  1.12818919e-01f, 1.32038921e-01f, 9.25052911e-02f, -1.16635948e-01f, -1.99613650e-03f, 1.49720699e-01f, -1.30018175e-01f, 8.54525492e-02f, -2.12437436e-02f, 1.26630468e-02f,
  -9.47460905e-02f, 3.35551761e-02f, 6.18712865e-02f, -3.05317226e-03f, -1.28444480e-02f, -1.04624704e-01f, -6.48763105e-02f, 4.38176170e-02f, -2.53162766e-03f, -9.97159109e-02f,
  -4.63398546e-02f, 3.12177241e-02f, 3.59594151e-02f, -3.23669463e-02f, 1.57713536e-02f, 5.22292070e-02f, -1.24173567e-01f, 1.12015106e-01f, -6.79536909e-02f, -1.79401249e-01f,
  -3.93310562e-02f, -1.92508459e-01f, -5.44231348e-02f, -1.00192815e-01f, -9.77573823e-03f, 1.94029734e-01f, -3.46953161e-02f, 1.76639467e-01f, -9.00421366e-02f, -1.19394377e-01f,
  3.25730778e-02f, 1.59945473e-01f, -9.58923027e-02f, 1.78747490e-01f, 1.54940739e-01f, -1.07327119e-01f, -8.04108232e-02f, 1.33754775e-01f, 1.11280516e-01f, -5.22500016e-02f,
  -2.99214255e-02f, -9.37241390e-02f, 3.63411643e-02f, 1.20551035e-01f, 1.04437871e-02f, 2.52373312e-02f, -9.92516577e-02f, 4.23663929e-02f, 5.42247780e-02f, 2.50660688e-01f,
  -1.32387402e-02f, 1.07234716e-01f, 1.16148882e-01f, 1.23117298e-01f, 1.65156618e-01f, -6.73814267e-02f, -1.43399060e-01f, 1.94368720e-01f, 3.93031053e-02f, 1.92042976e-03f,
  -2.45549493e-02f, -5.04704975e-02f, -4.91603129e-02f, 3.40278111e-02f, -8.68684426e-03f, -4.58891727e-02f, 9.79889706e-02f, -4.15093116e-02f, 3.96786146e-02f, 5.13853617e-02f,
  -2.12747753e-02f, 3.86588834e-03f, -3.02828997e-02f, -5.28044999e-02f, 4.34536636e-02f, 5.00470512e-02f, -1.97783578e-02f, 2.58499272e-02f, 8.89284536e-02f, 3.94797325e-02f,
  1.27508733e-02f, 5.22934832e-02f, 2.06440613e-02f, 4.51585948e-02f, -4.92484542e-03f, -2.71907840e-02f, 1.04983963e-01f, -3.68336029e-02f, -4.89251874e-03f, 1.38173001e-02f,
  2.30565406e-02f, 4.26795008e-03f, -1.58953592e-01f, -3.57282311e-02f, 2.08978839e-02f, -1.51158264e-02f, 8.47599804e-02f, 1.46242371e-02f, -6.74051717e-02f, 9.35592502e-03f,
  -6.51111230e-02f, -7.50995502e-02f, -4.94294725e-02f, -1.16777578e-02f, 5.22020683e-02f, -8.43846276e-02f, -3.32258008e-02f, -2.33383905e-02f, 2.58748867e-02f, -8.84273872e-02f,
  -1.84347965e-02f, 2.93534603e-02f, -3.23950686e-02f, -5.65510541e-02f, -6.94731856e-03f, -3.33153643e-02f, -1.58804193e-01f, -1.23984860e-02f, -1.84008598e-01f, 1.15590449e-02f,
  -3.31728198e-02f, -7.74634406e-02f, 1.08610086e-01f, -1.57435209e-01f, -1.35762945e-01f, 1.09195970e-01f, -4.38750386e-02f, -7.52626583e-02f, -1.25387862e-01f, -1.51234306e-02f,
  1.00294866e-01f, 5.84283331e-03f, 2.48485114e-02f, 4.60699089e-02f, -1.71849638e-01f, -1.17553353e-01f, 7.53704756e-02f, -1.11331947e-01f, -5.13180606e-02f, 1.07287653e-01f,
  -3.37782316e-02f, -5.43699786e-02f, -8.66705254e-02f, 6.94211526e-03f, -2.13007163e-02f, 5.88445179e-02f, 1.35222986e-01f, 1.04286842e-01f, 2.20508296e-02f, 1.03855550e-01f,
  -1.67785168e-01f, -3.88211831e-02f, 2.51212306e-02f, -1.23248331e-01f, -5.12162335e-02f, -1.02934666e-01f, 6.72030970e-02f, 1.05698546e-03f, -2.26262435e-02f, 5.38015664e-02f,
  1.14443652e-01f, 3.96644976e-03f, -2.34285370e-03f, -1.36078447e-02f, 7.11449236e-02f, 5.23653515e-02f, -8.89884531e-02f, -1.20804839e-01f, 1.03507983e-02f, 5.57490923e-02f,
  5.41733019e-02f, -2.07225122e-02f, 4.03154381e-02f, -1.07586578e-01f, 1.42024130e-01f, 1.13601074e-01f, 8.04668441e-02f, 6.25198781e-02f, -2.42163204e-02f, 7.97365159e-02f,
  -1.21070191e-01f, 3.23385522e-02f, -1.01170160e-01f, 7.54226074e-02f, 2.80424297e-01f, -1.53297633e-01f, -1.30188927e-01f, -5.88390976e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  4.05161269e-02f, 9.61867049e-02f, 2.10141316e-02f, 1.42499492e-01f, -2.00533066e-02f, 1.79715063e-02f, 8.65910500e-02f, 2.32897475e-02f, -6.67187795e-02f, 2.53084376e-02f,
  1.40220057e-02f, 1.20565556e-01f, 1.22160859e-01f, 6.51338771e-02f, 1.05605096e-01f, 1.02812484e-01f, 7.12104365e-02f, 7.12472349e-02f, 1.55098170e-01f, 1.06378965e-01f,
  6.02550022e-02f, 2.11267378e-02f, 9.57662389e-02f, 1.10575527e-01f, 2.79703960e-02f, 8.37848634e-02f, 4.08296287e-02f, 7.10081086e-02f, 8.67368467e-03f, 1.23924993e-01f,
  1.72825113e-01f, 1.02018565e-01f, -8.55216756e-02f, 1.17974818e-01f, 6.87381774e-02f, 6.51431233e-02f, 1.63579762e-01f, 1.05215587e-01f, 5.06457165e-02f, 9.90014449e-02f,
  5.45433387e-02f, -7.94317648e-02f, -2.29528323e-02f, 3.74152362e-02f, 1.39002010e-01f, -5.08032516e-02f, 3.80106680e-02f, 5.61854728e-02f, -7.39349611e-03f, 1.32167950e-01f,
  -6.45407811e-02f, -1.10222720e-01f, -6.32639304e-02f, -3.65345441e-02f, 1.19811900e-01f, 8.67999122e-02f, -1.25930877e-02f, -2.81401817e-02f, -2.50800401e-01f, -7.97336474e-02f,
  -2.91380119e-02f, -2.10321680e-01f, 4.69582900e-02f, -9.02332813e-02f, -2.27782547e-01f, -7.31426179e-02f, -8.38262811e-02f, -8.88666287e-02f, -1.56674609e-01f, -3.86577286e-02f,
  6.67904392e-02f, -8.23515505e-02f, 1.04512885e-01f, 1.67353600e-01f, -1.51066124e-01f, -5.46501502e-02f, 3.96947153e-02f, -2.15979442e-01f, 1.22833826e-01f, 2.53871083e-01f,
  4.01749387e-02f, 1.08867534e-01f, -2.13557705e-01f, 1.79626122e-02f, -7.81788677e-02f, 7.10216612e-02f, 1.25121415e-01f, -4.04587351e-02f, -3.40244547e-02f, 1.80592895e-01f,
  -1.74940556e-01f, 5.00996644e-03f, 7.02330917e-02f, -5.16954586e-02f, 6.75418302e-02f, 2.01223530e-02f, -7.65894949e-02f, 1.27810210e-01f, -1.24985836e-01f, 4.17679287e-02f,
  1.44247264e-01f, 1.75234228e-02f, -2.26137992e-02f, 1.14866486e-02f, -1.23104500e-03f, 6.59618080e-02f, 2.45870072e-02f, -1.31673783e-01f, 1.24239363e-01f, 1.26107901e-01f,
  -1.03332296e-01f, -1.43332437e-01f, 2.13212624e-01f, -1.80780753e-01f, 2.06469551e-01f, 8.28407258e-02f, 1.38537154e-01f, -4.57832552e-02f, 1.00634731e-01f, 2.64906436e-01f,
  -7.79118240e-02f, 1.18085779e-01f, -1.13016129e-01f, 1.30267218e-02f, 1.58271521e-01f, -2.49068633e-01f, -1.15560375e-01f, -2.20202819e-01f, 7.14474842e-02f, 8.82497579e-02f,
  5.27095571e-02f, 2.49122344e-02f, 3.28839459e-02f, 1.18996955e-01f, 1.33880883e-01f, 1.00333579e-01f, 1.19314387e-01f, -3.55961733e-02f, 8.47527459e-02f, 2.32418925e-01f,
  1.11318916e-01f, 1.50853232e-01f, 6.27635196e-02f, 6.93513080e-02f, 9.12169963e-02f, 4.18513678e-02f, -1.44911725e-02f, 8.40877220e-02f, 1.14635259e-01f, 9.77081433e-02f,
  1.16921797e-01f, -1.63999163e-02f, 4.54874337e-02f, 6.96203411e-02f, 1.63814910e-02f, -1.44976033e-02f, 1.37571111e-01f, 2.07010079e-02f, 7.91721717e-02f, 2.07500741e-01f,
  4.20531146e-02f, 1.22100227e-01f, -3.52707854e-03f, 6.74633980e-02f, 4.83985581e-02f, 1.26522720e-01f, -4.92625460e-02f, -4.14217217e-03f, 9.50282961e-02f, 6.77435026e-02f,
  3.02940290e-02f, 1.18140981e-01f, 1.29718661e-01f, 1.16811104e-01f, -7.93877915e-02f, -1.27981685e-03f, 1.17955282e-01f, 2.27108132e-02f, 1.04161181e-01f, -1.27005816e-01f,
  -6.38029724e-03f, -2.02689096e-02f, 1.16973132e-01f, 2.14436054e-01f, -1.49318188e-01f, -1.08854339e-01f, -3.51310410e-02f, 4.87828515e-02f, -1.16788521e-01f, 4.12363224e-02f,
  5.95989684e-03f, -1.64174795e-01f, 7.19317570e-02f, 5.58450408e-02f, 7.79291093e-02f, 5.75052723e-02f, -4.47659045e-02f, 1.07175499e-01f, -1.89859927e-01f, 8.27538371e-02f,
  -4.44861464e-02f, 1.47125632e-01f, 4.61764410e-02f, 3.03978007e-03f, 4.00952660e-02f, 1.38799101e-01f, 1.04777440e-01f, -2.02290025e-02f, -1.27985924e-01f, 1.30045759e-02f,
  3.10500842e-02f, -7.60619417e-02f, 1.00187771e-01f, 1.11671813e-01f, 5.03321476e-02f, 2.08219945e-01f, 4.80745733e-02f, 1.94256648e-01f, 1.12563752e-01f, 1.30418226e-01f,
  7.83542991e-02f, -3.05798233e-01f, -2.47742217e-02f, -1.73419058e-01f, 1.43155694e-01f, -1.29595026e-01f, -7.20533580e-02f, 2.22009961e-02f, -1.00480773e-01f, -3.40641767e-01f,
  -2.84591485e-02f, 2.48708129e-01f, 9.63533763e-03f, -1.46397248e-01f, -4.12489995e-02f, -6.56722933e-02f, -7.62390047e-02f, 5.02565429e-02f, 2.37349167e-01f, 9.25801620e-02f,
  -6.19444288e-02f, 2.44821548e-01f, 2.72478133e-01f, 1.23604983e-01f, 7.43016973e-02f, -6.99245632e-02f, -1.29793137e-01f, 1.72626212e-01f, -1.76932961e-01f, -1.53892964e-01f,
  -1.13617573e-02f, -3.82852666e-02f, 1.39061376e-01f, -2.73959458e-01f, 2.29543626e-01f, 9.43026021e-02f, -4.11517844e-02f, 1.00651115e-01f, -5.68774678e-02f, 1.15366213e-01f,
  7.73454010e-02f, 4.16346975e-02f, 1.23170741e-01f, 1.18680060e-01f, 5.89282997e-02f, 1.20906457e-01f, -4.97647971e-02f, -3.06992866e-02f, 9.35583860e-02f, 7.26773813e-02f,
  -2.54287869e-02f, 7.07660541e-02f, -7.59491324e-02f, 8.10911600e-03f, -9.87129882e-02f, 1.99262038e-01f, -1.16517004e-02f, 6.53633773e-02f, 1.62694186e-01f, 1.50243327e-01f,
  1.10841885e-01f, -1.90140028e-02f, 2.88335025e-01f, 3.62927802e-02f, 1.54289439e-01f, -2.91576162e-02f, 1.27794430e-01f, 1.70810074e-02f, 2.67454069e-02f, 2.79861033e-01f,
  1.03396244e-01f, 5.02497442e-02f, 2.57142395e-01f, 1.04548030e-01f, 2.55898803e-01f, 2.97475923e-02f, 5.63711189e-02f, 4.48684487e-03f, 6.97795600e-02f, 4.28560264e-02f,
  2.47902736e-01f, 2.64054704e-02f, 2.09477842e-02f, -1.61358267e-02f, 7.04529807e-02f, 1.14430711e-01f, 4.37477827e-02f, -1.59268305e-01f, 7.56132007e-02f, -1.89593598e-01f,
  -1.27167320e-02f, 5.97091904e-03f, 8.66409391e-02f, 3.87435779e-02f, 6.66383356e-02f, -1.46594211e-01f, 1.01980492e-01f, -2.25350991e-01f, 1.85942110e-02f, 2.01679736e-01f,
  1.51210949e-01f, -2.18773797e-01f, -1.26109913e-01f, 1.45533398e-01f, 1.95495099e-01f, -1.44918740e-01f, 1.84170112e-01f, 1.99175522e-01f, 1.00501686e-01f, -1.66144054e-02f,
  -8.54707360e-02f, 1.54412538e-01f, 5.17393649e-02f, -5.46256602e-02f, 1.00892171e-01f, -4.40372489e-02f, 1.81982160e-01f, -5.64607754e-02f, 1.73723940e-02f, 1.00029334e-01f,
  -1.11323990e-01f, 3.70689631e-02f, -1.19314520e-02f, -1.17645547e-01f, 1.71108672e-03f, -3.50638963e-02f, -1.49176046e-01f, 1.53269440e-01f, 1.62524819e-01f, 2.19424069e-01f,
  3.67401540e-02f, 1.37882754e-01f, -1.42787054e-01f, 1.42581552e-01f, 1.13239482e-01f, 1.06903985e-01f, -1.89825192e-01f, -3.15906405e-02f, 3.29883210e-02f, -4.46823571e-04f,
  5.96330687e-02f, 3.53179038e-01f, 3.00839275e-01f, 2.45307326e-01f, 1.54153779e-01f, 1.18169390e-01f, 2.30087861e-01f, 1.83244780e-01f, -5.76461293e-02f, -1.02925420e-01f,
  -2.81896759e-02f, -1.82891741e-01f, 7.76118832e-03f, 6.49998486e-02f, 1.22280113e-01f, -1.02363944e-01f, 1.95806533e-01f, 8.75853118e-04f, 6.81424979e-03f, -5.15734637e-03f,
  1.19525164e-01f, -4.38842438e-02f, -1.49271190e-01f, -1.36718124e-01f, 9.54846386e-03f, 1.58177745e-02f, 1.24338500e-01f, -1.06577938e-02f, -8.47290009e-02f, 2.07207147e-02f,
  -4.16250862e-02f, -6.62731826e-02f, -3.37546654e-02f, -1.75279807e-02f, 2.36724406e-01f, 1.49100184e-01f, -1.07676819e-01f, -2.19876036e-01f, 9.04940516e-02f, 7.00871972e-03f,
  8.83434117e-02f, -1.05545744e-01f, 2.73996927e-02f, -4.95493375e-02f, 1.16805129e-01f, -9.74514335e-02f, -1.22476229e-02f, 1.14467219e-02f, -9.87466052e-02f, 1.30385458e-01f,
  -1.90364838e-01f, 1.23010509e-01f, 1.55786481e-02f, -6.64772512e-03f, -6.40713647e-02f, -1.15763461e-02f, 2.82037765e-01f, -9.95277893e-03f, -7.95350038e-03f, -6.32103831e-02f,
  -1.13868974e-01f, -5.11304941e-03f, -3.09814624e-02f, 2.11838409e-01f, 1.03124015e-01f, 1.19961344e-01f, 1.41574770e-01f, 5.10211959e-02f, -1.00016579e-01f, 2.21936285e-01f,
  1.14443749e-01f, 7.43641984e-03f, 5.18447384e-02f, -2.29453761e-02f, 7.26586059e-02f, -5.86018525e-02f, -3.45241949e-02f, 7.82168433e-02f, 8.56436417e-02f, -9.91620403e-03f,
  -1.36945605e-01f, -4.94058523e-03f, 1.05029874e-01f, 1.68513283e-01f, -7.44004026e-02f, 4.97299358e-02f, -3.57662626e-02f, 9.64081213e-02f, -1.58960849e-01f, 5.32332696e-02f,
  1.46914208e-02f, -9.58363116e-02f, 8.56747106e-02f, 1.11072682e-01f, -1.36346266e-01f, -7.40388110e-02f, -8.36962909e-02f, -2.56338090e-01f, 1.28564180e-03f, 7.62642249e-02f,
  -1.73005667e-02f, -7.32805282e-02f, 2.22032033e-02f, -9.24658589e-03f, 7.48818591e-02f, 1.24465846e-01f, 2.96504311e-02f, 2.99804926e-01f, -1.79166824e-01f, -1.91662498e-02f,
  3.32066119e-02f, -6.38816059e-02f, -1.56105652e-01f, -1.20637953e-01f, 8.61624479e-02f, -2.16126546e-01f, 1.36861041e-01f, 1.89161167e-01f, -1.06159240e-01f, 1.34695828e-01f,
  -1.47116914e-01f, 7.94234276e-02f, -7.78750330e-02f, 1.34333208e-01f, 1.54020684e-02f, 1.68302774e-01f, 1.59153849e-01f, 2.40913317e-01f, -1.94134712e-01f, -2.01055467e-01f,
  4.50186431e-02f, -6.85663819e-02f, 4.21370231e-02f, -2.49441519e-01f, 4.59752530e-02f, -2.49345023e-02f, 1.04121871e-01f, 1.23994902e-01f, -1.02277905e-01f, 7.26916492e-02f,
  3.48780394e-01f, 6.21402673e-02f, -8.93991962e-02f, 2.46295974e-01f, -6.66650236e-02f, 2.40087405e-01f, 1.89930379e-01f, -1.47500113e-02f, -2.37775132e-01f, 3.66775244e-01f,
  -1.98063850e-01f, 1.07214525e-01f, -1.07557944e-03f, 6.53776228e-02f, 8.38019475e-02f, -1.22364126e-02f, 3.34122358e-03f, 2.83421315e-02f, -7.58416206e-02f, 2.32353713e-02f,
  6.40428299e-03f, 6.43885359e-02f, -3.51732522e-02f, 4.93490486e-04f, -7.86817726e-03f, -1.05071537e-01f, 9.07162298e-03f, 1.49156451e-02f, -9.12753772e-03f, -3.59244235e-02f,
  7.61459814e-03f, -2.95548271e-02f, -2.89507676e-02f, 2.31576320e-02f, -1.10189952e-02f, 2.76037455e-02f, 6.22924864e-02f, 1.45846279e-02f, -3.91850993e-03f, -4.80906665e-03f,
  2.88290270e-02f, -6.39626980e-02f, -7.71097699e-03f, 1.77716967e-02f, 1.76307693e-01f, -3.42506059e-02f, 1.51173939e-04f, 4.40678932e-02f, -2.70901863e-02f, -9.88388713e-03f,
  2.81296950e-02f, -1.54469712e-02f, 1.52607001e-02f, 8.65720734e-02f, 7.17068650e-03f, 4.01716940e-02f, -5.63083999e-02f, 1.61799893e-01f, 1.00804217e-01f, 4.57762368e-02f,
  -1.88779794e-02f, 7.66346827e-02f, 1.12288505e-01f, 1.58039164e-02f, 8.95791594e-03f, 7.65452906e-02f, -5.81287183e-02f, -3.05987317e-02f, 1.20226145e-01f, 3.24605368e-02f,
  2.22416028e-01f, 1.86630916e-02f, -8.29486400e-02f, 1.51468724e-01f, -1.35751337e-01f, 2.39019975e-01f, 2.21921965e-01f, -5.45025580e-02f, -8.25927332e-02f, -2.12970600e-02f,
  2.59050518e-01f, -4.96165045e-02f, -2.04176060e-03f, 5.55731244e-02f, -9.27092955e-02f, -8.30674544e-02f, 1.54663593e-01f, 2.82643795e-01f, -9.22290012e-02f, 2.50139516e-02f,
  1.97879900e-03f, -1.01880386e-01f, 1.32689103e-01f, 9.04202238e-02f, 2.16315836e-01f, 7.11416975e-02f, 2.90939026e-02f, -2.80523337e-02f, -3.29355709e-02f, -1.17353871e-01f,
  -7.30578303e-02f, -1.36740997e-01f, 1.51330188e-01f, 6.98459381e-03f, -1.16549291e-01f, 2.41984129e-01f, 4.39833291e-02f, 1.57990664e-01f, 2.72276867e-02f, 9.70936567e-02f,
  -4.98967897e-03f, 2.54765712e-03f, -1.07216373e-01f, 4.41483855e-02f, 1.80374756e-01f, 2.84618139e-02f, -6.72079325e-02f, -8.46675597e-03f, 1.27456173e-01f, 2.18289211e-01f,
  3.00005302e-02f, 8.70896876e-03f, -1.56657100e-02f, 1.72589347e-02f, -5.43362312e-02f, 4.57466841e-02f, -1.01715162e-01f, -1.10608093e-01f, -4.62152623e-02f, 4.79910814e-04f,
  1.30258381e-01f, -1.77996486e-01f, 2.19097927e-01f, -2.89970785e-02f, 1.21511720e-01f, -6.64862022e-02f, -1.69276521e-01f, 3.23564589e-01f, -7.50421658e-02f, 2.38357171e-01f,
  -1.41259119e-01f, 1.00585163e-01f, 3.64619046e-02f, -1.13450075e-02f, -2.39346791e-02f, -3.42756696e-03f, 8.39105397e-02f, 2.87694484e-02f, 7.02629611e-02f, -8.07901621e-02f,
  9.63933840e-02f, 1.27246708e-01f, 1.75148230e-02f, -1.33347362e-01f, 4.21101488e-02f, 2.56152265e-02f, 2.95733400e-02f, -7.18568340e-02f, -9.72343460e-02f, 1.07568547e-01f,
  4.57715522e-03f, -4.04063426e-02f, -3.70206125e-02f, 1.35376886e-01f, 1.23659549e-02f, 3.57637629e-02f, 3.59945297e-02f, 6.23065718e-02f, 1.01774387e-01f, -1.30155176e-01f,
  -1.18766939e-02f, 4.80053527e-03f, 8.73664767e-02f, 1.16708772e-02f, -6.76425099e-02f, -1.44951656e-01f, -5.83075620e-02f, -9.17908270e-03f, -1.18981290e-03f, 1.91167399e-01f,
  2.20631585e-02f, 4.01281491e-02f, 4.55423445e-02f, 5.48369400e-02f, -8.50114450e-02f, 2.08548069e-01f, 4.98677120e-02f, -1.01236276e-01f, 8.78428668e-02f, -1.32716477e-01f,
  1.28620416e-01f, -9.50413942e-03f, 1.11804027e-02f, -1.64608777e-01f, 8.70287493e-02f, 4.79330868e-02f, -1.92663506e-01f, -3.27991992e-02f, 1.01266444e-01f, 2.00095534e-01f,
  -1.20840564e-01f, -9.87090692e-02f, 1.80571511e-01f, 4.42290232e-02f, -4.36571753e-03f, 1.11206129e-01f, 1.44246370e-01f, 2.59256866e-02f, 1.44166142e-01f, -5.49529009e-02f,
  -2.15299074e-02f, 1.35859055e-02f, -4.86340523e-02f, -1.04332872e-01f, -8.38805437e-02f, 2.58969404e-02f, 1.95857912e-01f, -5.51441722e-02f, 5.42282946e-02f, -2.20997527e-01f,
  1.26044348e-01f, -2.72138920e-02f, 1.67854860e-01f, 3.16868514e-01f, -9.58194062e-02f, 1.34209283e-02f, 5.22849299e-02f, 1.18731245e-01f, -5.89583553e-02f, -1.56142516e-02f,
  -2.58135535e-02f, -3.75430882e-02f, 2.55911618e-01f, 2.40251608e-02f, -2.20398620e-01f, -7.22627938e-02f, -1.66608363e-01f, -7.45159984e-02f, 1.61892414e-01f, 5.16868643e-02f,
  6.02469519e-02f, -3.98877338e-02f, 9.46275517e-02f, 2.41043240e-01f, 1.59582317e-01f, -9.58635807e-02f, -1.64665461e-01f, 1.69461042e-01f, 6.14649653e-02f, -1.11514479e-01f,
  1.80729240e-01f, 6.69598430e-02f, -1.55011043e-01f, 1.30656660e-02f, -5.78020997e-02f, 1.69688553e-01f, 2.13626742e-01f, 7.50012621e-02f, -5.27243055e-02f, 1.84354335e-01f,
  -2.14795023e-01f, -4.67536077e-02f, -3.98862660e-02f, 2.67522812e-01f, 5.54913394e-02f, 1.44915253e-01f, -2.86472529e-01f, 3.62354629e-02f, 1.49947017e-01f, -3.65513451e-02f,
  -4.51730080e-02f, 3.81084066e-03f, 7.28945341e-03f, 5.21152979e-03f, 4.34686951e-02f, -5.00399480e-03f, -6.35552704e-02f, 3.74312559e-03f, 8.24541226e-02f, -1.92839056e-02f,
  5.28570786e-02f, 9.52877179e-02f, 7.47902989e-02f, 6.85482696e-02f, 6.00952469e-02f, 6.51385635e-02f, 1.77464977e-01f, -5.99964149e-03f, 8.03673491e-02f, 4.58851345e-02f,
  7.11542219e-02f, 2.95517445e-02f, 8.54513329e-03f, 3.46282893e-03f, -2.80260406e-02f, 3.60928243e-03f, -9.02765691e-02f, 1.38640061e-01f, 2.49503646e-02f, 1.65096223e-02f,
  -1.20883510e-01f, 1.42657040e-02f, 8.58522132e-02f, 7.67985955e-02f, 1.35095492e-01f, 3.61573212e-02f, 5.92710115e-02f, 1.26884636e-02f, 3.70597467e-02f, -6.76551685e-02f,
  1.52558787e-04f, -4.24336791e-02f, 1.49727821e-01f, -1.27224520e-01f, 3.11091226e-02f, 5.83918467e-02f, -1.80441830e-02f, 8.99532810e-02f, -1.08216792e-01f, -1.36188522e-03f,
  -7.58067593e-02f, 3.55490856e-02f, 5.54687195e-02f, 6.92785010e-02f, -3.44019234e-02f, -6.95661232e-02f, -2.05268353e-01f, -1.29495310e-02f, 6.50482327e-02f, -9.04478431e-02f,
  -4.44355719e-02f, -1.14953741e-01f, -2.08341911e-01f, -5.14216498e-02f, -3.61363664e-02f, -8.88980553e-02f, -2.99991310e-01f, 4.80724536e-02f, 3.72132212e-02f, -1.13088399e-01f,
  4.33115214e-02f, 1.44086704e-01f, -1.47226766e-01f, -1.15401007e-01f, -7.74633586e-02f, -1.09776422e-01f, 3.14318947e-02f, 9.68679860e-02f, -3.02206390e-02f, 1.68631189e-02f,
  -2.16271058e-01f, -7.43373036e-02f, -8.15928653e-02f, 2.61168014e-02f, 5.87539747e-03f, -2.99979523e-02f, 3.12087629e-02f, 1.05080217e-01f, -3.18013243e-02f, -2.27117003e-03f,
  -1.52808079e-03f, -9.58558396e-02f, 8.40512738e-02f, 7.31501207e-02f, -2.54292022e-02f, -5.38688665e-03f, -1.31320059e-01f, -7.91557431e-02f, 6.22223057e-02f, -1.77722878e-03f,
  1.58300921e-02f, -1.02837928e-01f, -3.02588101e-03f, 1.60643861e-01f, 8.99041295e-02f, -1.53511375e-01f, 1.06459837e-02f, 1.50983050e-01f, 1.83375459e-02f, -1.90438405e-02f,
  2.37132475e-01f, -7.24161938e-02f, 2.23254099e-01f, 1.22024633e-01f, 8.54175985e-02f, 1.12538978e-01f, 8.38990733e-02f, 3.13438535e-01f, 2.36924738e-03f, 1.42987832e-01f,
  -8.17213953e-02f, -7.35241398e-02f, 1.94741581e-02f, -2.80179143e-01f, 8.52349326e-02f, -1.87038109e-01f, -6.93709124e-03f, 9.31550041e-02f, 3.55215855e-02f, 4.56624478e-02f,
  5.81379160e-02f, 1.05307423e-01f, 1.37946963e-01f, 1.06628403e-01f, 1.00036584e-01f, -2.76698470e-02f, 9.82267559e-02f, 1.01175107e-01f, 6.68185502e-02f, 3.38700078e-02f,
  -1.01199439e-02f, 9.65564698e-02f, -5.05593373e-03f, 1.48033844e-02f, -1.10189311e-01f, 2.44302630e-01f, 3.14300098e-02f, 4.32090787e-03f, -3.39192003e-02f, 1.01025462e-01f,
  8.57672095e-02f, -6.67412765e-03f, 1.31029233e-01f, 5.19147627e-02f, 9.79280993e-02f, 1.14179701e-02f, 1.04208864e-01f, 9.90450382e-02f, 4.63120267e-02f, 5.21841645e-02f,
  1.41772972e-02f, -1.18375614e-01f, 4.23798040e-02f, 4.24517617e-02f, 7.90847912e-02f, 1.71023771e-01f, 1.05921082e-01f, -1.95948663e-03f, 8.64123255e-02f, 7.66091123e-02f,
  5.25230803e-02f, 1.43424422e-01f, 8.76191854e-02f, -3.72145027e-02f, 1.17962509e-01f, -7.43440464e-02f, 1.07680019e-02f, -2.79841442e-02f, 1.60367891e-01f, -2.69684881e-01f,
  4.49320152e-02f, -2.70136911e-02f, -1.36555359e-01f, -1.82895660e-02f, 7.30167329e-02f, 9.63965058e-02f, 8.81102905e-02f, -2.48526230e-01f, 1.49289072e-01f, 1.04678646e-01f,
  -3.43029127e-02f, -7.59482607e-02f, 5.10468073e-02f, 1.95364147e-01f, 1.74803168e-01f, 6.92699179e-02f, 6.35636598e-02f, 7.37100169e-02f, 4.41065393e-02f, -3.28381956e-02f,
  -9.41942111e-02f, -5.15872948e-02f, 1.64040372e-01f, -1.07730657e-01f, 2.52180900e-02f, -1.73745602e-01f, 2.98309829e-02f, -1.07559592e-01f, 3.05303447e-02f, 2.49951541e-01f,
  -1.77685410e-01f, 3.33807804e-02f, 4.49468046e-02f, 9.11081508e-02f, 3.62982936e-02f, -3.97634655e-02f, -1.66604742e-01f, 1.47085279e-01f, 3.84541363e-01f, -1.61973247e-03f,
  -1.95542410e-01f, -4.20094356e-02f, -1.97261319e-01f, -1.15037777e-01f, 1.49300709e-01f, 3.85880210e-02f, -1.07731350e-01f, -1.35313869e-02f, 9.90975350e-02f, 1.49151608e-01f,
  1.84959203e-01f, 1.71683133e-01f, -9.72476304e-02f, 2.28149220e-01f, 1.69074669e-01f, 1.72664188e-02f, 2.98725337e-01f, 2.04845399e-01f, -9.73629206e-02f, 1.14705190e-01f,
  -5.60245886e-02f, 5.95680103e-02f, 7.88735524e-02f, 2.13119194e-01f, -3.09684668e-02f, 1.22552201e-01f, -2.90681869e-01f, -4.98799309e-02f, -4.40061046e-03f, 1.72484562e-01f,
  8.34997147e-02f, -9.14263278e-02f, -1.06857099e-01f, -2.84858905e-02f, -4.36948016e-02f, 9.85571668e-02f, 1.70196816e-01f, 1.86069570e-02f, 5.23519590e-02f, 1.10955641e-01f,
  9.42139104e-02f, 8.66628066e-02f, 1.55133307e-01f, -3.01971920e-02f, 1.29781827e-01f, 2.76331663e-01f, 7.59286284e-02f, -3.81285772e-02f, 8.26349482e-02f, 5.25937341e-02f,
  5.72976358e-02f, 6.82739988e-02f, -4.22372483e-02f, 4.60202321e-02f, 3.07609863e-03f, 6.66237697e-02f, -1.87434498e-02f, 5.08800223e-02f, 3.76044326e-02f, 6.82604611e-02f,
  -2.53484789e-02f, 7.58651271e-02f, 7.26103783e-02f, -9.48785618e-02f, 4.91647869e-02f, 1.76678300e-01f, 1.25987485e-01f, -1.25539482e-01f, -7.58658350e-03f, -8.67885202e-02f,
  -1.16109043e-01f, -1.10833673e-02f, -8.59510452e-02f, 8.08515027e-02f, 1.57249227e-01f, 1.04747139e-01f, -4.58962284e-02f, 9.58570689e-02f, -1.04737781e-01f, 1.79043785e-01f,
  5.43419532e-02f, 2.66549978e-02f, 2.26439275e-02f, -1.25222832e-01f, 4.52579223e-02f, 7.46916980e-02f, 1.05178244e-01f, -1.37321711e-01f, 1.49991527e-01f, -6.99993074e-02f,
  -1.08682506e-01f, 1.91633066e-03f, 4.58322326e-03f, 1.19519018e-01f, -4.95330207e-02f, 6.16052486e-02f, 1.53168425e-01f, -1.67863101e-01f, 6.19557388e-02f, 9.93116572e-02f,
  6.07200600e-02f, 4.67590466e-02f, 1.40176460e-01f, 1.51504099e-01f, -7.32893944e-02f, -4.18716967e-02f, -7.39991218e-02f, 4.46513183e-02f, 2.37974804e-02f, -1.92453712e-01f,
  1.47822365e-01f, 1.79178327e-01f, -9.96522792e-03f, -8.10346156e-02f, -1.47626057e-01f, -8.29212293e-02f, 8.01737383e-02f, 5.29183969e-02f, 8.28397274e-02f, 6.52450919e-02f,
  1.23737209e-01f, 2.82647908e-01f, 5.69540448e-02f, 6.24126680e-02f, 3.16404290e-02f, 1.60875171e-01f, 8.46062675e-02f, -2.21156970e-01f, -1.43349290e-01f, -3.16564888e-01f,
  9.35241804e-02f, -1.01354100e-01f, -7.44240638e-03f, -4.41079028e-02f, 6.01985604e-02f, -1.60891950e-01f, 1.56571314e-01f, 2.37295032e-01f, 1.85987607e-01f, -2.34424323e-01f,
  -2.31918931e-01f, 1.37742028e-01f, 1.18335158e-01f, 3.80971581e-02f, 1.19196452e-01f, -4.68306653e-02f, 3.98830883e-02f, 3.51327568e-01f, 1.97445136e-03f, 1.84944630e-01f,
  -1.08458094e-01f, -5.35019413e-02f, -5.90201691e-02f, -1.56456828e-01f, -3.10075879e-01f, 2.32314430e-02f, 5.37762828e-02f, 2.60597289e-01f, 2.01364607e-01f, -6.84490521e-03f,
  5.68890870e-02f, 3.51135284e-01f, 7.71925747e-02f, 5.80609217e-02f, 7.70475268e-02f, 8.70482102e-02f, 6.86835572e-02f, 1.33807240e-02f, 5.63278571e-02f, 1.10713765e-01f,
  1.78912224e-03f, 7.50717372e-02f, -1.19727775e-01f, -1.11426907e-02f, 8.30457583e-02f, 1.41748860e-01f, -3.99677530e-02f, 3.91610824e-02f, 2.99558230e-02f, 8.67345631e-02f,
  1.76827252e-01f, 4.70011346e-02f, 4.06817114e-03f, 8.02192912e-02f, 1.46559164e-01f, 1.58798963e-01f, 2.95221787e-02f, 1.97032560e-02f, 2.12722674e-01f, 3.46553698e-02f,
  5.05440645e-02f, 2.59087551e-02f, 1.25783518e-01f, 6.72260597e-02f, 5.70846125e-02f, 1.47641063e-01f, 5.79726361e-02f, 1.11735426e-01f, 2.11287633e-01f, 8.35560560e-02f,
  1.08440593e-01f, -1.29705191e-01f, -3.68541013e-03f, -2.14688368e-02f, 1.39904767e-02f, -2.77776197e-02f, 1.24941267e-01f, -1.56212717e-01f, -3.04976963e-02f, 5.25059626e-02f,
  1.18873054e-02f, 1.75671190e-01f, 2.10009981e-02f, -1.05227143e-01f, -5.72502203e-02f, 3.43424529e-02f, 3.71674933e-02f, 2.36179661e-02f, 1.65005475e-01f, 2.77414359e-03f,
  -1.18731640e-01f, -1.15470193e-01f, -1.07766971e-01f, -7.07771555e-02f, -8.52665603e-02f, -7.83371478e-02f, 8.59452784e-02f, -1.18201844e-01f, -2.08011240e-01f, -5.04061468e-02f,
  -1.56479969e-03f, -1.43125489e-01f, 5.21203056e-02f, 4.95255515e-02f, -2.88634025e-03f, 1.64400399e-01f, -4.58620749e-02f, 7.43869841e-02f, -3.95877659e-02f, -4.93167900e-02f,
  1.15311958e-01f, 1.83974221e-01f, 4.49336059e-02f, 1.02793694e-01f, 5.31714298e-02f, -1.10379934e-01f, 2.32790839e-02f, 1.03899904e-01f, 7.39059672e-02f, -9.43770930e-02f,
  -3.66964936e-02f, 1.23313576e-01f, -8.98005068e-02f, 6.92972615e-02f, -7.98852965e-02f, 4.72032540e-02f, 9.92418006e-02f, 1.01826049e-01f, 8.68301168e-02f, 1.01058312e-01f,
  -1.52023464e-01f, 3.76206040e-02f, 7.50917047e-02f, 1.96578577e-02f, 6.42255135e-03f, -9.75214690e-02f, -1.43609708e-02f, 1.68909401e-01f, 1.09208286e-01f, -5.29604219e-03f,
  1.05850413e-01f, 1.54652178e-01f, -2.05487609e-01f, -1.45861328e-01f, 5.03828712e-02f, -2.25220725e-01f, 2.12949976e-01f, -5.89390993e-02f, -4.08762246e-02f, -1.02153264e-01f,
  1.78796098e-01f, 2.81858463e-02f, 1.49817392e-01f, 3.71874273e-02f, -1.33954719e-01f, -1.97318822e-01f, 8.75985399e-02f, -1.13518633e-01f, -1.31700680e-01f, -6.14478737e-02f,
  5.69789819e-02f, 3.79034132e-02f, 7.15093091e-02f, 1.38024792e-01f, 3.83563675e-02f, 4.08158302e-02f, 4.20476869e-02f, -6.26403932e-03f, -1.37347028e-01f, 4.31282818e-02f,
  4.58024330e-02f, 9.78691597e-03f, -2.56162975e-02f, -6.41530380e-02f, 3.39560397e-02f, -2.73872949e-02f, 3.22452411e-02f, -4.57810536e-02f, -2.07463324e-01f, 5.03640771e-02f,
  1.02230884e-01f, 2.14525834e-02f, 3.51648331e-02f, -2.20395029e-02f, 7.12096784e-03f, 1.49037436e-01f, -6.98840916e-02f, 3.07544246e-02f, 8.78147334e-02f, 1.18213505e-01f,
  6.67703822e-02f, -1.29400687e-02f, 9.96611118e-02f, 1.21980667e-01f, 5.40010445e-02f, 2.01349240e-02f, 6.66161105e-02f, 9.42444503e-02f, 9.37871337e-02f, 1.39347807e-01f,
  3.56663465e-02f, 5.74993901e-02f, 4.69088741e-02f, -4.41563036e-03f, 1.07036933e-01f, 1.01876460e-01f, 7.27323517e-02f, 3.95215414e-02f, 9.71285719e-03f, 8.70877355e-02f,
  -1.74611360e-02f, -2.82636378e-02f, 1.77281797e-02f, 4.28032652e-02f, -1.48576070e-02f, 2.59306002e-02f, 4.75320518e-02f, 1.98190641e-02f, -6.13530539e-03f, -1.50576964e-01f,
  -2.14659795e-02f, 4.09284346e-02f, -1.00790203e-01f, 7.32612610e-02f, 4.73556444e-02f, -3.59718502e-03f, -7.10823806e-03f, 2.35717576e-02f, 1.17404610e-01f, -9.66967642e-03f,
  -1.29983500e-01f, 6.73836991e-02f, 1.50328293e-01f, -1.01204067e-01f, 5.12185358e-02f, -2.52415035e-02f, 6.01534843e-02f, 8.59793201e-02f, 3.34562808e-02f, 7.90622160e-02f,
  -6.38839304e-02f, 8.32609460e-02f, -7.73012713e-02f, 1.38363997e-02f, -6.89724647e-03f, -1.52095988e-01f, 2.33306978e-02f, -4.60665487e-02f, 7.31474534e-02f, -2.54527107e-02f,
  -1.17286770e-02f, -5.24052903e-02f, 1.07394578e-02f, 5.99331185e-02f, 6.26358092e-02f, -8.76847729e-02f, 4.56454512e-03f, 3.04362714e-01f, 3.03009208e-02f, 1.13464430e-01f,
  -9.39605236e-02f, 7.20443353e-02f, -1.34599403e-01f, 6.09589219e-02f, -1.21414579e-01f, -1.72021419e-01f, 2.18659937e-01f, -2.41054092e-02f, -7.36865103e-02f, 2.33743340e-02f,
  7.17188194e-02f, 3.26850340e-02f, 1.12890981e-01f, 5.53159267e-02f, -1.40799314e-01f, -1.46141604e-01f, 6.00380935e-02f, -1.85980737e-01f, -2.24502664e-02f, -1.55096099e-01f,
  1.08248428e-01f, 1.40897587e-01f, 2.50944346e-01f, 1.62023306e-02f, -1.66147493e-03f, 9.31842476e-02f, 6.98801130e-02f, -1.15460664e-01f, 1.25009477e-01f, 1.82345510e-02f,
  1.25856459e-01f, 1.05700672e-01f, 7.68916681e-02f, 1.05442099e-01f, 5.34331761e-02f, -1.17216995e-02f, 1.82451922e-02f, 3.71110141e-02f, 1.03434272e-01f, 2.41136253e-02f,
  -2.23344751e-03f, -6.62065670e-02f, 1.40498132e-01f, 2.47687511e-02f, 1.34771049e-01f, 5.79525381e-02f, 9.10061598e-02f, -6.55493438e-02f, 1.29118368e-01f, 4.40244116e-02f,
  1.04267918e-01f, -7.26955682e-02f, 8.02840367e-02f, 1.74118057e-01f, -1.17002830e-01f, 1.07827693e-01f, -4.03028633e-03f, 1.95492744e-01f, -4.65427572e-03f, 5.03545254e-02f,
  8.74094516e-02f, -8.09806399e-03f, 1.25519708e-02f, 7.84488022e-02f, -9.85214040e-02f, 9.85972956e-02f, -1.30389780e-01f, 1.16309524e-01f, -7.23730447e-03f, 1.20893270e-01f,
  -5.01602478e-02f, 1.09196708e-01f, -4.51768041e-02f, 5.77488355e-02f, 9.36774388e-02f, 1.55885115e-01f, -6.53144391e-03f, 5.93150705e-02f, 7.08218440e-02f, 1.84485510e-01f,
  -9.94556118e-03f, 1.48517460e-01f, -2.04954157e-03f, -1.56373344e-02f, 5.83490804e-02f, 4.29425091e-02f, -2.19170917e-02f, 2.97642574e-02f, -1.39760181e-01f, 2.97047257e-01f,
  -1.83235016e-02f, -8.95653814e-02f, 8.52955505e-02f, 1.67413026e-01f, 1.15965635e-01f, -9.19955149e-02f, -8.74737874e-02f, 1.51146010e-01f, -1.72889113e-01f, -9.50503126e-02f,
  -2.03253096e-03f, -3.53472754e-02f, 1.98058218e-01f, -1.83948219e-01f, -6.02452382e-02f, 2.51221538e-01f, -4.53904979e-02f, 5.60099855e-02f, -2.37193197e-01f, 1.05212614e-01f,
  -1.92007050e-02f, -1.77229375e-01f, 1.64443851e-01f, -2.08054826e-01f, -1.13440558e-01f, 1.32403672e-01f, 9.32005122e-02f, 3.58858448e-03f, 1.62086830e-01f, -1.82247967e-01f,
  -1.87393531e-01f, -1.71176344e-01f, 5.27763702e-02f, -2.52024829e-01f, 1.95925921e-01f, 7.64188170e-02f, -1.62924803e-03f, -4.05955985e-02f, 1.01342224e-01f, 3.94407026e-02f,
  -1.95688292e-01f, 1.10648446e-01f, -8.75762999e-02f, -2.73066491e-01f, -1.49224460e-01f, -1.91516951e-01f, -1.45502627e-01f, -6.61018863e-02f, -1.10930383e-01f, -4.20009978e-02f,
  6.28975108e-02f, 1.40838876e-01f, -1.83680490e-01f, 5.80222830e-02f, -2.13821139e-02f, -1.64627984e-01f, -3.33130024e-02f, -1.88048437e-01f, 3.73182669e-02f, 7.67724216e-02f,
  1.78319722e-01f, 6.13182597e-02f, -6.29651845e-02f, 2.35327110e-01f, 2.53822893e-01f, 7.30280057e-02f, 2.19772384e-02f, 2.77554076e-02f, -3.74772400e-02f, 4.76963073e-02f,
  1.71387137e-03f, 3.67848426e-02f, 1.27287552e-01f, 3.05022709e-02f, 8.99565127e-03f, 7.97178298e-02f, -3.37344334e-02f, 3.45866419e-02f, 2.32302435e-02f, 4.95356768e-02f,
  5.93370944e-02f, 3.07037756e-02f, 4.25767004e-02f, 7.50211626e-03f, 3.09253344e-03f, 8.12611133e-02f, 1.65639251e-01f, 4.92292196e-02f, 1.59512222e-01f, 7.98939355e-03f,
  7.53787812e-03f, 7.58986622e-02f, 7.36279488e-02f, 3.89408432e-02f, 9.50565413e-02f, 6.48286417e-02f, 7.61274621e-02f, 9.26160533e-03f, -1.23198377e-04f, 2.33584136e-01f,
  2.85656601e-02f, 1.14663735e-01f, 7.85793588e-02f, 1.33181378e-01f, 2.58593597e-02f, 9.65206549e-02f, 2.35797279e-02f, -1.73780639e-02f, 7.93949515e-02f, 2.17189882e-02f,
  1.63249090e-01f, 8.50483179e-02f, -4.28681970e-02f, 1.10136550e-02f, 2.01651737e-01f, 4.60669361e-02f, 2.05466673e-01f, -2.01517448e-01f, -2.17312172e-01f, 2.12958604e-01f,
  -9.49328914e-02f, 9.33154002e-02f, -1.06873639e-01f, -6.84838966e-02f, 4.10647839e-02f, 3.15164514e-02f, -1.61350459e-01f, -7.56978914e-02f, -6.80268481e-02f, -5.28346039e-02f,
  1.95647366e-02f, 1.00806981e-01f, 6.75322190e-02f, -2.16729492e-02f, -1.69652373e-01f, -7.53767714e-02f, -1.59050658e-01f, 1.96917504e-01f, -7.03822263e-03f, 7.77900144e-02f,
  -9.44307148e-02f, 1.79251388e-01f, 1.25873506e-01f, -6.61545396e-02f, 6.64016530e-02f, 1.67973507e-02f, 2.18429305e-02f, -4.48051207e-02f, 1.45492166e-01f, 1.14916367e-02f,
  -1.29217366e-02f, 5.53715788e-02f, 1.90951377e-02f, -1.04777157e-01f, -7.60415494e-02f, 9.86710947e-05f, -2.36491729e-02f, -1.47401854e-01f, -2.51574609e-02f, 1.08248312e-02f,
  4.49617440e-03f, -1.62297934e-02f, 5.99475168e-02f, 1.44867534e-02f, 4.43271659e-02f, 2.55552024e-01f, -8.78984258e-02f, -1.57005623e-01f, -1.74598381e-01f, 2.29629874e-02f,
  -1.65329650e-01f, -2.21716743e-02f, 1.85496196e-01f, -2.59347320e-01f, -2.51839638e-01f, -6.14203438e-02f, 1.09710246e-01f, 7.71816447e-02f, -1.89052492e-01f, -1.15812927e-01f,
  2.51785278e-01f, 1.01153903e-01f, 2.62195051e-01f, -4.89389263e-02f, -1.34853259e-01f, 2.72407323e-01f, 2.01362297e-01f, -1.20457985e-01f, -1.55101912e-02f, -1.67000785e-01f,
  9.88803431e-02f, 1.17096595e-01f, -2.77092401e-02f, -1.24010786e-01f, -7.18344096e-03f, 6.71900064e-02f, -9.31380540e-02f, -4.50288095e-02f, -1.49174985e-02f, 9.60968062e-02f,
  1.23569891e-01f, 1.11248061e-01f, 8.93003717e-02f, 9.51618776e-02f, -5.18066958e-02f, 2.48079970e-02f, 4.77255993e-02f, -4.04141471e-02f, 3.76368575e-02f, 4.03970815e-02f,
  4.88816574e-02f, 1.66470762e-02f, -1.64901242e-02f, 8.29553157e-02f, 6.13729022e-02f, 1.42225940e-02f, 4.54423428e-02f, 1.99376233e-02f, 9.82343927e-02f, 1.07469817e-03f,
  7.86820650e-02f, 5.35124168e-02f, 5.94210997e-02f, -9.91499647e-02f, -3.25859822e-02f, 8.64013210e-02f, -1.92706138e-02f, 7.17862248e-02f, -5.56537062e-02f, -4.87909988e-02f,
  -5.88263683e-02f, 4.82866503e-02f, -1.08416174e-02f, 7.42913932e-02f, -1.77163649e-02f, -1.30186956e-02f, 8.72345567e-02f, 9.97110829e-02f, -7.78774992e-02f, 1.23773515e-01f,
  -2.98536997e-02f, 2.63809822e-02f, 1.20592929e-01f, -1.65557608e-01f, 2.01818958e-01f, 8.52821022e-02f, -1.45475551e-01f, 1.14414826e-01f, -1.40307769e-01f, -4.19620238e-02f,
  -1.87864646e-01f, -3.66090834e-02f, 1.44025609e-01f, 1.92716703e-01f, -1.16595224e-01f, 4.66009378e-02f, 6.66611195e-02f, -6.13871496e-03f, 1.02948688e-01f, 1.61598176e-01f,
  1.44996285e-01f, -1.36867939e-02f, -7.50150904e-02f, -4.35322113e-02f, -2.88469512e-02f, 8.51500854e-02f, -4.15133014e-02f, 2.21347306e-02f, -1.11587485e-02f, 1.31112635e-01f,
  1.79481342e-01f, 5.96529944e-03f, -4.18572826e-03f, -2.48506933e-01f, 8.29005167e-02f, -1.10426880e-01f, 2.20288545e-01f, 6.53062016e-02f, 5.71620986e-02f, 1.75180696e-02f,
  -2.92140711e-02f, 1.66490078e-02f, -3.66972834e-02f, -5.40706031e-02f, 4.40808497e-02f, -9.61453170e-02f, -8.28947220e-03f, -1.79241672e-02f, -1.56993598e-01f, -5.09853251e-02f,
  6.30363300e-02f, -2.84657419e-01f, 1.83887661e-01f, 6.43805265e-02f, -1.38468537e-02f, -1.57212406e-01f, 4.55760732e-02f, 8.42623040e-02f, 1.30163655e-01f, -6.12056740e-02f,
  -7.45136663e-02f, 7.31350929e-02f, -1.13659449e-01f, -9.99448970e-02f, 1.16509199e-01f, 1.14191324e-01f, -2.41344392e-01f, -2.32223840e-03f, 3.01459227e-02f, 2.02117145e-01f,
  1.64746478e-01f, 1.20281190e-01f, -8.28718841e-02f, 1.98208585e-01f, 1.01325616e-01f, -1.95006922e-01f, 4.07162830e-02f, 6.83382750e-02f, 4.06074971e-02f, 1.53806329e-01f,
  1.25941886e-02f, 5.55064566e-02f, 1.36211455e-01f, -9.56007000e-03f, 1.28531642e-02f, -6.55906200e-02f, 7.08441287e-02f, 4.11357246e-02f, 3.85531932e-02f, 9.70698297e-02f,
  1.53343514e-01f, 4.95108292e-02f, 7.39573836e-02f, 1.27389193e-01f, -5.84807061e-02f, -1.51907736e-02f, 1.44156709e-01f, 9.90781859e-02f, 3.81535827e-03f, 6.31334856e-02f,
  1.94349781e-01f, 2.20524278e-02f, 4.08702493e-02f, 7.37676909e-03f, -9.66877863e-03f, 1.00236714e-01f, 4.20587733e-02f, -8.27902579e-04f, 8.63405317e-02f, -1.73394947e-04f,
  -2.16932110e-02f, -3.90457474e-02f, -1.68079715e-02f, 3.54256742e-02f, 1.72407344e-01f, 1.40785398e-02f, 5.96137270e-02f, 8.59334841e-02f, 2.19817851e-02f, 1.61335617e-02f,
  -8.40186849e-02f, 3.37836780e-02f, 5.96511103e-02f, 5.63679077e-02f, 8.04077908e-02f, 9.62297469e-02f, -6.83331266e-02f, -1.19521869e-02f, 5.16394712e-02f, 6.17514439e-02f,
  1.58941329e-01f, -4.79206294e-02f, 1.27655178e-01f, -5.04652336e-02f, 3.46280932e-02f, -5.98902465e-04f, -7.09649399e-02f, -9.66326743e-02f, -6.27076402e-02f, 3.02210040e-02f,
  5.27671725e-02f, 1.76370710e-01f, -7.34953880e-02f, 1.06619835e-01f, 1.06003411e-01f, -6.60361275e-02f, 3.06516718e-02f, 2.09288555e-03f, -9.23015252e-02f, 6.71635056e-03f,
  -2.81490404e-02f, 1.59326091e-01f, -1.84909673e-03f, -3.54961418e-02f, -2.87315756e-01f, -3.41126211e-02f, 3.43207605e-02f, 1.76077969e-02f, -2.47229442e-01f, -5.57398722e-02f,
  -6.04849495e-02f, 3.91190592e-03f, -1.03630731e-02f, 3.95058542e-02f, 1.03407443e-01f, 4.44098152e-02f, -1.95825193e-02f, -1.95977706e-02f, -1.19116038e-01f, 3.13958600e-02f,
  -1.39643624e-01f, 5.30078833e-04f, 1.36447266e-01f, 2.47805417e-02f, 2.44562998e-02f, 5.11864200e-03f, -1.18026145e-01f, 1.78348094e-01f, -1.06711406e-02f, -1.84793159e-01f,
  -1.31866619e-01f, -4.74122688e-02f, 6.18331842e-02f, 1.23594075e-01f, 3.43736373e-02f, 1.11880951e-01f, -1.20309763e-01f, 1.98647588e-01f, -1.84322461e-01f, -1.31535202e-01f,
  8.06803629e-02f, -1.08147994e-01f, 6.16097338e-02f, -3.46073671e-03f, -1.24083146e-01f, 9.61952507e-02f, 1.08412735e-01f, 6.90798610e-02f, 4.78876233e-02f, 1.88316464e-01f,
  -3.40704732e-02f, 1.80362210e-01f, -3.40603329e-02f, -4.90952544e-02f, -4.88745645e-02f, -1.20055236e-01f, -1.78404719e-01f, 1.15249924e-01f, -8.49973410e-02f, 2.51408041e-01f,
  4.62168567e-02f, 3.46137732e-02f, 1.60917774e-01f, 1.19283296e-01f, -1.05307713e-01f, -8.43597129e-02f, -4.98432927e-02f, -1.71413764e-01f, -2.02209264e-01f, 3.01459786e-02f,
  7.32438266e-02f, 2.51899268e-02f, -1.20785184e-01f, -7.44854659e-02f, 2.46510971e-02f, -3.54060642e-02f, 4.28778417e-02f, -4.47588302e-02f, -1.40967900e-02f, -6.86654299e-02f,
  1.70397311e-02f, -3.40888165e-02f, -4.48861159e-03f, -6.80254679e-03f, -2.35296898e-02f, 1.06620565e-01f, -1.46774724e-01f, 1.41090779e-02f, -7.04332143e-02f, 1.64236963e-01f,
  -1.61137059e-02f, -6.81061670e-02f, -7.54769444e-02f, -1.29162982e-01f, 1.10465497e-01f, -1.71986576e-02f, -8.12824965e-02f, -4.22528107e-03f, 2.00957917e-02f, 8.88570920e-02f,
  2.61285901e-02f, 8.35527703e-02f, -7.05665573e-02f, -7.21720457e-02f, 1.35193300e-02f, 1.41438330e-02f, 1.29432663e-01f, -4.64597426e-04f, -7.44770244e-02f, 7.93075040e-02f,
  -1.43681958e-01f, 1.08013123e-01f, -4.31039482e-02f, -4.83561233e-02f, 9.09073725e-02f, 3.57853770e-02f, 4.89996858e-02f, 7.93675482e-02f, -1.96526736e-01f, -2.16170505e-01f,
  1.44322723e-01f, -3.52232222e-04f, -1.08776093e-01f, -2.38152593e-02f, -2.65386522e-01f, 2.06406061e-02f, -6.70473278e-02f, -1.79381430e-01f, 1.05834370e-02f, -7.71135762e-02f,
  2.59424690e-02f, -1.58966228e-01f, 1.75255537e-01f, -8.76178741e-02f, -9.69240591e-02f, -1.41374066e-01f, -1.90630555e-02f, 3.74414437e-02f, -6.62508458e-02f, 2.08171487e-01f,
  -6.66086152e-02f, 3.28758098e-02f, -2.91590869e-01f, -5.31422943e-02f, -3.47501598e-02f, -9.97665748e-02f, 1.28592983e-01f, -4.45121303e-02f, 1.39457956e-01f, -2.40391567e-02f,
  -5.73142134e-02f, -6.00287989e-02f, -4.73234132e-02f, -1.49703892e-02f, 1.67046100e-01f, -1.74989235e-02f, 1.73355304e-02f, 3.34817588e-01f, -1.00705229e-01f, -1.29514083e-01f,
  1.00921981e-01f, 2.39160001e-01f, 1.59007803e-01f, -1.04206808e-01f, 5.22003621e-02f, -1.77400991e-01f, 1.31704509e-01f, 9.12316144e-02f, 3.72578837e-02f, 2.12299898e-01f,
  9.84579884e-03f, -8.20206627e-02f, 4.47811931e-01f, -1.01543009e-01f, -1.57159358e-01f, -3.04906666e-02f, -3.62921767e-02f, -6.34465413e-03f, 2.57322788e-01f, -1.31211564e-01f,
  -4.08250801e-02f, 3.25042695e-01f, 1.49172470e-01f, 2.42284834e-01f, 8.84511508e-03f, -1.58927798e-01f, -2.44117957e-02f, -2.30114758e-01f, 1.18697667e-02f, 4.55463491e-02f,
  7.06351027e-02f, 1.68097019e-01f, 1.11659452e-01f, -6.05191439e-02f, 3.86005007e-02f, 2.91466247e-02f, -2.36793831e-02f, 8.92948806e-02f, -1.07374132e-01f, -5.88851459e-02f,
  7.19026029e-02f, -5.89445084e-02f, 7.19950348e-02f, 4.28182073e-02f, 3.58886831e-02f, 6.84295595e-02f, 8.84226337e-02f, 4.71536703e-02f, 1.44246556e-02f, 3.49094276e-03f,
  6.75107539e-02f, 7.72122964e-02f, 4.66054305e-02f, 2.86598541e-02f, 1.42829210e-01f, 8.92492980e-02f, -1.62468217e-02f, -5.57345944e-03f, 1.02580644e-01f, -5.83403558e-02f,
  -2.84061693e-02f, 1.69447154e-01f, 5.98867983e-02f, 1.28083989e-01f, 1.65720031e-01f, 8.20252579e-03f, 1.80539265e-01f, -5.76196648e-02f, 1.19935190e-02f, -6.39749179e-03f,
  -1.71020832e-02f, 3.78524363e-02f, 4.82783690e-02f, -1.32696927e-01f, 6.50138184e-02f, 7.54104480e-02f, 2.21653208e-02f, 1.37478963e-01f, -8.47318992e-02f, 1.32533431e-01f,
  1.19071146e-02f, -5.66691458e-02f, 2.84665674e-02f, -9.95437130e-02f, 1.83422938e-01f, 1.05506115e-01f, -3.29238623e-02f, -1.69471160e-01f, 5.36608063e-02f, -6.93773925e-02f,
  -1.42376721e-02f, 1.74733967e-01f, 3.99233541e-03f, -1.48549631e-01f, -8.99378732e-02f, 4.27833349e-02f, 4.70555425e-02f, -6.98677897e-02f, 1.50153428e-01f, -8.57180580e-02f,
  1.02700740e-01f, 5.25932349e-02f, -4.79013147e-03f, -2.68531237e-02f, -6.21277392e-02f, -5.66869713e-02f, 1.09949231e-01f, 1.54627636e-01f, 1.24840513e-01f, 1.18090384e-01f,
  -6.83874488e-02f, -2.86849253e-02f, 6.10345900e-02f, -9.85678807e-02f, -1.11635163e-01f, -1.56961888e-01f, 1.75284334e-02f, -3.28317061e-02f, -2.17259511e-01f, -1.25434587e-03f,
  3.17606851e-02f, 2.31208161e-01f, 5.73300757e-02f, 9.62398127e-02f, -4.26941402e-02f, 1.69688389e-01f, 1.23334788e-01f, -2.84174439e-02f, 1.58921868e-01f, 2.13592336e-01f,
  2.37920750e-02f, -1.00642793e-01f, 5.01169935e-02f, 2.21429825e-01f, 9.18429438e-03f, 1.92319110e-01f, 2.51381397e-01f, 7.62372017e-02f, -2.98853338e-01f, -1.09915257e-01f,
  4.72299419e-02f, -1.54778957e-01f, -1.57054365e-01f, -1.25330776e-01f, -7.18231872e-02f, -1.12049542e-01f, 2.12364241e-01f, -9.23758373e-02f, 1.81987181e-01f, 1.03566051e-01f,
  6.71266541e-02f, 5.86263202e-02f, -8.72697681e-03f, 1.28763810e-01f, -7.73954391e-02f, -1.40064716e-01f, 2.65885349e-02f, -5.50235203e-03f, 1.62596568e-01f, -3.70669849e-02f,
  2.12203618e-02f, 6.71643317e-02f, -2.95148455e-02f, 8.79766718e-02f, 1.85749248e-01f, 6.23481795e-02f, -6.43358305e-02f, 1.02241166e-01f, 9.48362797e-02f, 4.28777486e-02f,
  4.78299987e-03f, 7.34706298e-02f, 8.02718699e-02f, 1.59577414e-01f, 1.64872617e-01f, -7.54885897e-02f, -3.92095670e-02f, 1.17734149e-01f, -6.93186224e-02f, 7.16454610e-02f,
  1.20917425e-01f, -1.51332701e-02f, 8.60005990e-03f, 1.42539507e-02f, -4.98203151e-02f, -1.59298837e-01f, -3.00389025e-02f, 1.16012201e-01f, 1.44922122e-01f, -2.02680677e-01f,
  6.41632974e-02f, 1.42121809e-02f, -8.66224617e-02f, -4.69632074e-02f, -5.31724282e-02f, -1.78929880e-01f, 9.45407897e-02f, 1.26892731e-01f, -7.44093433e-02f, 1.04009591e-01f,
  -1.73302352e-01f, 2.05996335e-02f, 1.02121539e-01f, 9.91314352e-02f, 6.09140936e-03f, -1.04901362e-02f, 1.51384398e-02f, 1.86084092e-01f, 5.32855503e-02f, 4.07989398e-02f,
  4.46788259e-02f, -1.08220361e-01f, 4.69360314e-02f, 2.47841030e-02f, 4.39166985e-02f, 9.70942229e-02f, 4.29135524e-02f, 2.21085474e-01f, 6.25896379e-02f, 3.15121450e-02f,
  1.34619564e-01f, -2.32704282e-02f, -1.04293063e-01f, -7.61114731e-02f, 5.94676994e-02f, 4.24081199e-02f, 4.47582528e-02f, -1.59897014e-01f, -2.06345469e-01f, 1.28379881e-01f,
  1.70975327e-01f, 2.30083503e-02f, -1.61435008e-01f, 1.04353622e-01f, -3.57041769e-02f, -6.01327382e-02f, -1.73113272e-02f, 1.59796476e-02f, 1.75321877e-01f, -1.24269255e-01f,
  2.16589332e-01f, 4.47453856e-02f, -6.37572557e-02f, 5.30644096e-02f, -2.20267046e-02f, -5.35247065e-02f, 1.53758630e-01f, 7.69250244e-02f, -1.55845061e-01f, 1.82232652e-02f,
  -5.20805940e-02f, 2.57545840e-02f, 1.27900571e-01f, -2.03766644e-01f, -7.66099468e-02f, -2.41325155e-01f, 9.24487934e-02f, -5.59888221e-02f, 3.88126165e-01f, -5.37916124e-02f,
  2.21431732e-01f, 3.41262808e-03f, -1.35747075e-01f, 3.43243957e-01f, 2.56831974e-01f, 1.02038890e-01f, -1.93854153e-01f, -1.23153344e-01f, 5.31218871e-02f, 2.22052410e-01f,
  -4.30247635e-02f, 1.30143553e-01f, -2.62792438e-01f, 5.40372394e-02f, 1.99764952e-01f, -1.92876801e-01f, 5.03430851e-02f, -6.25026971e-02f, -1.79346884e-03f, 1.48004711e-01f,
  -8.00068751e-02f, 1.53006762e-01f, 1.17964901e-01f, 4.32920158e-01f, -2.87294444e-02f, 7.35443681e-02f, 1.30396569e-02f, 1.38312131e-02f, 4.15001661e-02f, 1.02530859e-01f,
  7.57789984e-02f, 9.76959541e-02f, 1.46100029e-01f, 1.32651359e-01f, -9.17106271e-02f, 1.05924912e-01f, 1.38176620e-01f, 4.05749828e-02f, -1.12404022e-02f, 3.83068621e-02f,
  3.86484079e-02f, 7.86479041e-02f, 1.00341313e-01f, 4.51890891e-03f, -1.29089244e-02f, 1.99258327e-01f, 8.92731249e-02f, 2.21754625e-01f, 4.55278158e-02f, -2.49306057e-02f,
  2.01538458e-01f, -2.37807818e-03f, 1.07163988e-01f, -8.65373686e-02f, 1.89612154e-02f, 5.00159562e-02f, 8.97141695e-02f, 9.05866176e-02f, 4.05165032e-02f, 7.30666071e-02f,
  6.40679151e-02f, 5.68623357e-02f, -6.71144500e-02f, -6.57023787e-02f, -1.91292129e-02f, 2.36183386e-02f, 2.43739169e-02f, 7.45264292e-02f, -4.90058325e-02f, 8.55578408e-02f,
  -2.01022048e-02f, -2.16554571e-02f, 1.11473888e-01f, -4.54282109e-03f, 1.99802041e-01f, -9.30765271e-02f, -1.82075068e-01f, 2.03889668e-01f, -8.93982947e-02f, -7.28997067e-02f,
  -3.07501443e-02f, -4.99338247e-02f, 1.72045920e-02f, -3.99557352e-02f, -1.62361518e-01f, -3.24456617e-02f, -4.53504138e-02f, -1.45041630e-01f, 1.94480017e-01f, 1.09396294e-01f,
  -1.37132630e-01f, -1.71965942e-01f, 4.46675718e-03f, -3.63474607e-01f, 3.98765616e-02f, 1.90534130e-01f, -6.39738813e-02f, 6.20261915e-02f, -9.37651247e-02f, 2.05726728e-01f,
  2.13659570e-01f, -5.43928519e-02f, -7.09961057e-02f, -5.64668700e-02f, 6.66693449e-02f, -1.27030894e-01f, 2.73697704e-01f, -1.26410484e-01f, 1.44449189e-01f, 1.58214048e-01f,
  1.92414790e-01f, -1.19365633e-01f, -9.88606662e-02f, -5.30120619e-02f, -8.95353220e-03f, 1.77401341e-02f, -2.67253876e-01f, 9.21946466e-02f, -1.54273426e-02f, -7.15428172e-03f,
  2.01305240e-01f, 1.17068458e-02f, -1.01380190e-03f, 1.50725245e-01f, 8.92728847e-03f, -1.82663739e-01f, 1.89010888e-01f, -1.47909537e-01f, 1.14295982e-01f, -4.75546718e-02f,
  2.32913151e-01f, 1.17597848e-01f, -1.21732447e-02f, 8.28731284e-02f, -1.38259709e-01f, -7.09449574e-02f, -2.41165832e-01f, -1.56598404e-01f, 2.67604530e-01f, 1.61791310e-01f,
  -6.46980330e-02f, 6.03306219e-02f, -7.05338595e-03f, -1.68567374e-01f, 2.42182627e-01f, -1.45791948e-01f, -6.87187314e-02f, -3.59792709e-02f, 3.65345895e-01f, 1.80014715e-01f,
  -1.76610753e-01f, 2.61935472e-01f, 1.38792157e-01f, 9.88076441e-03f, 4.08744961e-02f, 1.17488816e-01f, 5.29745929e-02f, 3.17332372e-02f, 1.02412298e-01f, 4.81251925e-02f,
  2.74225883e-02f, 2.05647405e-02f, 2.67953835e-02f, 1.93709740e-04f, 6.19096830e-02f, 1.00483939e-01f, 1.30542830e-01f, 3.05742752e-02f, 1.61961675e-01f, 1.22476891e-01f,
  1.40760630e-01f, -1.05540141e-01f, 1.10700667e-01f, 4.30747606e-02f, 5.06496914e-02f, -6.03601802e-03f, -8.41969345e-03f, 1.36107832e-01f, -8.70594606e-02f, 7.02725500e-02f,
  -8.98893401e-02f, 1.84358001e-01f, 5.16901501e-02f, -1.31120253e-02f, 1.43208727e-02f, -9.80714709e-03f, 5.29326797e-02f, 8.54318365e-02f, -4.30214256e-02f, 8.47574025e-02f,
  -3.65706645e-02f, 1.00832405e-02f, 3.00341304e-02f, -3.20239714e-03f, -8.17364007e-02f, 5.91293238e-02f, 2.27874704e-03f, -6.58989549e-02f, 8.70986283e-02f, 1.30167097e-01f,
  -5.68325166e-03f, 6.95185512e-02f, -8.44336674e-02f, 1.75882190e-01f, 6.81974962e-02f, 2.57893559e-02f, -6.01528175e-02f, -4.77949679e-02f, 1.34411499e-01f, 1.84844318e-03f,
  -1.44098416e-01f, -1.14009924e-01f, 6.29764795e-02f, 1.78967252e-01f, 2.75866482e-02f, -1.91918492e-01f, -4.29516695e-02f, 7.49736428e-02f, -7.36250803e-02f, -4.29829843e-02f,
  -2.44172931e-01f, 1.09694257e-01f, -7.36197224e-03f, -1.13830201e-01f, -4.38069776e-02f, 8.09853002e-02f, 1.30886137e-01f, -3.34781170e-01f, -1.24406576e-01f, 1.43985033e-01f,
  1.32674584e-02f, 2.03587666e-01f, -2.62358725e-01f, 7.46616125e-02f, -1.68608397e-01f, -2.83912390e-01f, 5.45159988e-02f, -1.36820674e-01f, -1.12349145e-01f, 8.57657269e-02f,
  4.25460376e-02f, 3.92057709e-02f, 3.95119600e-02f, -1.69018749e-02f, -1.93305358e-01f, -1.37740478e-01f, 8.34910199e-02f, -1.38381273e-01f, 1.85069099e-01f, 3.64866504e-03f,
  -1.71709005e-02f, -6.66689426e-02f, 1.95351467e-01f, 7.36252442e-02f, -1.42223090e-01f, -9.56355557e-02f, -1.21308699e-01f, -5.07675894e-02f, -2.38600690e-02f, -2.71923125e-01f,
  5.66439703e-02f, 6.90579088e-03f, -2.69650161e-01f, -1.59796447e-01f, 1.25131533e-01f, 7.00050294e-02f, -4.06082422e-02f, 2.95338649e-02f, -1.74505204e-01f, -8.04137439e-02f,
  -9.04509947e-02f, -1.61379784e-01f, -3.91670801e-02f, 1.09419167e-01f, 2.09330227e-02f, -3.00067421e-02f, 3.78485806e-02f, 7.32907727e-02f, 2.97205210e-01f, 4.84512299e-02f,
  9.12219100e-03f, -9.25263297e-03f, 8.42647776e-02f, 1.27435118e-01f, 8.95946771e-02f, 2.74361558e-02f, 1.10124059e-01f, 2.54239328e-02f, -2.52019428e-02f, 8.31838474e-02f,
  -2.51014475e-02f, 1.15161221e-02f, 7.03621209e-02f, -2.40649618e-02f, 1.09836482e-01f, 4.49703671e-02f, 1.15103208e-01f, 1.38551459e-01f, 2.17649326e-01f, 5.99195920e-02f,
  1.02700971e-01f, 1.24576233e-01f, 1.12361670e-01f, 5.21817990e-02f, 2.50682123e-02f, 6.79628402e-02f, 7.98816308e-02f, 1.22389458e-01f, 2.37017367e-02f, 5.87827340e-02f,
  1.84033401e-02f, 7.61958957e-02f, -1.09500371e-01f, 5.32689244e-02f, 1.05738387e-01f, 1.07795425e-01f, 9.29624736e-02f, 8.65705013e-02f, 3.58072296e-03f, 2.72767693e-02f,
  9.80836991e-03f, 8.37418437e-03f, -5.37211113e-02f, 6.56471476e-02f, 5.79786636e-02f, -5.41557223e-02f, 1.01608802e-02f, 6.44706935e-02f, 4.25417908e-02f, 6.10913569e-03f,
  1.70708215e-03f, 7.04172999e-02f, -1.66682556e-01f, 1.35566846e-01f, 6.09426349e-02f, 9.10159498e-02f, -8.27759877e-02f, -4.26369309e-02f, -2.22891465e-01f, 3.48269157e-02f,
  -1.21004038e-01f, -1.46237379e-02f, -1.26546267e-02f, -2.09703729e-01f, -1.38983235e-01f, 1.34847999e-01f, -2.39122491e-02f, -1.57505289e-01f, -1.89898461e-01f, -2.17037126e-02f,
  -4.14321236e-02f, -1.19962610e-01f, 3.33997011e-02f, 8.71401429e-02f, -6.60850406e-02f, -8.78731906e-02f, 9.84015986e-02f, -2.73382422e-02f, 3.82911786e-02f, 1.65572792e-01f,
  -7.51854805e-03f, 7.07318075e-03f, -6.18719077e-03f, -8.24213624e-02f, 8.73897597e-02f, -2.15510689e-02f, 6.85403422e-02f, -1.27525702e-02f, 2.40451191e-02f, 6.42730966e-02f,
  -8.92007872e-02f, -1.81753591e-01f, -8.41177255e-02f, -1.19411655e-01f, 4.03635167e-02f, -1.29980519e-01f, 9.74554867e-02f, 1.94481108e-02f, -3.48647572e-02f, -2.53568832e-02f,
  2.35917270e-01f, -2.30793394e-02f, 6.33418486e-02f, 2.82923188e-02f, 1.64218456e-01f, -9.11447331e-02f, -7.45867118e-02f, -1.10036191e-02f, 5.79758361e-02f, 8.33131522e-02f,
  -2.05718353e-01f, -1.65921152e-01f, 1.01012483e-01f, -1.82812765e-01f, 1.71077713e-01f, 2.21320510e-01f, 1.45843118e-01f, -1.32149309e-01f, 1.12045243e-01f, 2.10729539e-01f,
  1.33716883e-02f, 1.11577325e-01f, -6.57919720e-02f, 1.66785374e-01f, 2.27440044e-01f, 1.26099233e-02f, -2.31342670e-02f, -3.91560681e-02f, 3.33372988e-02f, 6.46645203e-02f,
  3.76933329e-02f, 5.41645859e-05f, 5.73982997e-03f, -1.37377577e-02f, -3.01597845e-02f, 3.55690233e-02f, 2.24081594e-02f, 9.09900814e-02f, 5.24808429e-02f, 6.42136559e-02f,
  -1.83439385e-02f, -3.97062004e-02f, 5.93859367e-02f, 7.86491111e-02f, 2.85723861e-02f, 4.99546491e-02f, 1.28907934e-01f, 5.90809025e-02f, 1.92852598e-02f, 2.49677226e-02f,
  8.57726578e-03f, 9.10798162e-02f, 1.06783032e-01f, 4.22385372e-02f, 6.76972494e-02f, 8.80208090e-02f, 1.37166437e-02f, -2.51391046e-02f, 3.04845218e-02f, 1.98281594e-02f,
  1.29734412e-01f, 6.14420883e-02f, 2.63106953e-02f, 7.65654817e-02f, 1.08639728e-02f, -3.72133218e-02f, 5.58000915e-02f, 4.10832092e-03f, 5.78477383e-02f, 6.74748346e-02f,
  1.25984937e-01f, 5.19360118e-02f, -8.02396089e-02f, 8.54870230e-02f, 6.72256425e-02f, 4.33897898e-02f, 9.53703076e-02f, 8.80236328e-02f, 6.43471405e-02f, -3.78219485e-02f,
  -1.45077892e-02f, 5.59767224e-02f, -6.53511332e-03f, 8.76993220e-03f, 9.80902463e-02f, -1.95465256e-02f, 1.10251702e-01f, 6.13616444e-02f, -6.98236153e-02f, 2.66671702e-02f,
  -5.57639375e-02f, 1.88101679e-01f, 3.87581736e-02f, -7.98104480e-02f, -9.42937210e-02f, 1.69954486e-02f, 1.09538220e-01f, 4.27792519e-02f, 1.41925951e-02f, -6.15567230e-02f,
  -1.21866122e-01f, -3.28353718e-02f, 9.39970687e-02f, 2.83928603e-01f, -1.82168156e-01f, -1.44813567e-01f, 6.29350692e-02f, -5.05752936e-02f, 1.80343941e-01f, 1.14074379e-01f,
  1.80043682e-01f, 1.19969420e-01f, -4.92166355e-02f, -9.12932120e-03f, -6.64081797e-02f, -2.04167262e-01f, -1.42242298e-01f, -7.49742612e-02f, 7.71132633e-02f, -4.13573571e-02f,
  6.22314289e-02f, 2.55260020e-01f, -4.90560643e-02f, 3.16649765e-01f, -1.18579678e-01f, -2.09398009e-02f, -7.63361529e-02f, 1.36975814e-02f, -3.62121202e-02f, 5.90070523e-02f,
  1.11240581e-01f, 6.42542690e-02f, -1.15082629e-01f, 1.91806763e-01f, 4.13367301e-02f, 8.40170234e-02f, 1.47633806e-01f, -5.44794165e-02f, -6.24274388e-02f, -4.08243835e-02f,
  -6.43309355e-02f, -1.59449186e-02f, 6.09312057e-02f, -5.76737039e-02f, 1.38399050e-01f, 7.74570033e-02f, 1.23212308e-01f, 2.27161005e-01f, 1.88123435e-01f, -2.74371076e-02f,
  3.58329690e-03f, -1.31264731e-01f, -2.27486551e-01f, 1.84383363e-01f, -1.79204226e-01f, 9.63481516e-02f, 1.02249369e-01f, 4.83794957e-02f, -2.45237276e-02f, 5.95735162e-02f,
  3.25629339e-02f, 9.15325582e-02f, 1.29027292e-01f, 1.05289444e-01f, 1.60560273e-02f, 5.13316728e-02f, 9.39212739e-02f, 8.09071288e-02f, 1.08886883e-01f, 1.30854830e-01f,
  6.35473896e-03f, 7.02191144e-02f, 2.96807904e-02f, 2.80269701e-03f, -2.15132535e-01f, 7.45780692e-02f, 1.62108421e-01f, 3.02154552e-02f, 1.01753935e-01f, -5.27396053e-02f,
  1.58745702e-02f, 5.84325939e-02f, -3.90897542e-02f, -2.90909060e-03f, 1.56756327e-01f, 1.30781859e-01f, 9.70342755e-02f, 1.86633859e-02f, -6.24562055e-02f, 1.58449084e-01f,
  -1.94935256e-03f, 7.46481074e-03f, 1.04909204e-01f, 1.46065518e-01f, 1.01360992e-01f, 6.46325126e-02f, 7.63267130e-02f, -2.39251833e-03f, 6.09144121e-02f, 1.82965137e-02f,
  2.09736094e-01f, 4.67853881e-02f, -2.08528060e-02f, 9.31857433e-03f, 9.72837582e-02f, 6.10689372e-02f, 4.77305166e-02f, -5.89301214e-02f, 6.95211962e-02f, -6.55579567e-02f,
  -7.62744471e-02f, 9.01103914e-02f, -6.88378438e-02f, -8.84644389e-02f, 7.23827109e-02f, 7.73142604e-03f, 1.04037151e-01f, -4.95302156e-02f, -1.77060477e-02f, 1.09159887e-01f,
  5.31203905e-03f, -3.83271687e-02f, 6.95260689e-02f, 1.92201123e-01f, -6.82849362e-02f, 1.26074925e-01f, -1.08312383e-01f, 1.48934454e-01f, 7.82431960e-02f, 4.74104434e-02f,
  2.08757315e-02f, 7.52611225e-03f, -3.34420241e-02f, 1.86369959e-02f, 5.93079291e-02f, -2.84252465e-02f, -4.87859733e-02f, -6.06638826e-02f, -4.07461226e-02f, -4.21108566e-02f,
  -1.55199513e-01f, 3.05043012e-02f, -9.98346731e-02f, 5.17574027e-02f, 2.70989370e-02f, 3.77048217e-02f, 3.82465310e-02f, 9.90268290e-02f, 2.15660959e-01f, -1.23794705e-01f,
  -4.10922915e-02f, -6.09408058e-02f, -8.83101150e-02f, -1.04802065e-01f, 3.76465581e-02f, 9.54555273e-02f, -2.12868109e-01f, -1.45931691e-01f, -1.29688829e-01f, 8.73978361e-02f,
  -1.60329252e-01f, 1.69512257e-01f, 1.53102919e-01f, -1.23361073e-01f, -7.23471679e-03f, -2.30255257e-02f, 2.57060289e-01f, 2.58918434e-01f, -3.40160839e-02f, 1.81837261e-01f,
  1.05165131e-01f, -6.03860393e-02f, 8.13627914e-02f, 1.25982359e-01f, -1.52099475e-01f, 1.10940449e-01f, -6.99196979e-02f, 1.06980661e-02f, 1.04391985e-01f, -8.53020176e-02f,
  -2.12702490e-02f, -1.60236478e-01f, 2.55073875e-01f, -1.16040200e-01f, 9.06326249e-03f, 1.09671205e-01f, 4.39256467e-02f, 3.31072807e-02f, 1.00844719e-01f, 2.81593092e-02f,
  3.40429284e-02f, 8.95906687e-02f, 3.69906938e-03f, 3.81036960e-02f, 2.88632866e-02f, -1.59703568e-02f, 7.90219307e-02f, 1.15975611e-01f, -5.06019704e-02f, 1.50614670e-02f,
  -6.48643821e-02f, 8.65042023e-03f, -1.86907828e-01f, 1.08352721e-01f, 2.74933539e-02f, 2.56542340e-02f, 1.60493758e-02f, 9.97220725e-03f, 1.00419931e-01f, -1.29664959e-02f,
  6.31028190e-02f, 4.63202596e-02f, 7.12954774e-02f, -1.35564879e-02f, 7.87670687e-02f, 2.58974154e-02f, 5.25916778e-02f, 5.62242679e-02f, 4.91443388e-02f, -9.97932721e-03f,
  9.46812704e-02f, 3.07074897e-02f, 2.37090096e-01f, 5.05171437e-03f, 8.90809968e-02f, 7.43342191e-02f, -7.96012860e-03f, 5.88752516e-02f, 1.62082389e-01f, 5.18250428e-02f,
  1.13693699e-01f, 3.49582918e-02f, -2.41027176e-02f, 9.18791890e-02f, -3.53170484e-02f, 1.01774536e-01f, 2.05020502e-01f, -2.01844558e-01f, 4.39957902e-02f, 2.06478257e-02f,
  1.20776005e-01f, 5.39931543e-02f, 1.45641893e-01f, -9.34198499e-03f, 2.43025377e-01f, -4.50170785e-02f, 1.11698478e-01f, 2.67120004e-01f, 3.25529911e-02f, -2.02355236e-01f,
  1.24169476e-01f, 2.51978129e-01f, 1.90138280e-01f, 8.54813382e-02f, 5.57503738e-02f, 5.77625120e-03f, 9.65270102e-02f, 1.52889490e-02f, 8.68754014e-02f, -4.74468358e-02f,
  -1.06106669e-01f, 8.91433954e-02f, 4.14698310e-02f, -1.02640122e-01f, 5.42318076e-02f, -3.99347953e-03f, -1.10282950e-01f, 7.94575512e-02f, -3.45241129e-02f, -9.37170088e-02f,
  -1.95839062e-01f, 8.62590373e-02f, 1.05342656e-01f, -8.29101428e-02f, -2.47487333e-03f, 1.12540059e-01f, 2.29382455e-01f, 3.69745046e-02f, -2.27598213e-02f, 1.15119340e-02f,
  -1.62155971e-01f, -5.71216494e-02f, 1.60641998e-01f, -1.47452742e-01f, -1.70287177e-01f, 1.19518125e-02f, 9.13446918e-02f, 7.60008693e-02f, 1.94214121e-01f, 2.90495366e-01f,
  -2.97081731e-02f, 3.77977788e-01f, 1.17171094e-01f, 7.96053931e-02f, 2.34109908e-01f, 2.41023868e-01f, 8.46213326e-02f, 2.08069175e-01f, -2.76089698e-01f, -1.52297363e-01f,
  -8.41187909e-02f, 1.03897080e-01f, 1.61454469e-01f, -5.48263825e-03f, 2.49299388e-02f, 1.00793466e-02f, 1.71675622e-01f, 1.88783467e-01f, -1.51927963e-01f, -1.19767264e-01f,
  2.44627684e-01f, -8.70624706e-02f, 6.92626685e-02f, 3.70951109e-02f, 1.09645911e-01f, 7.16335326e-02f, 4.01078127e-02f, 4.36789542e-02f, -7.25802314e-03f, -4.99022119e-02f,
  -1.88122913e-02f, 4.73619699e-02f, 9.88102183e-02f, 4.78849048e-03f, -8.83152485e-02f, -1.79467928e-02f, 6.13984279e-02f, -3.37000228e-02f, 9.00249332e-02f, -3.83245945e-02f,
  -8.47871304e-02f, -2.85752700e-03f, 5.07546365e-02f, 2.13541626e-03f, -4.60841041e-03f, -9.86037999e-02f, 4.26485054e-02f, 1.63834646e-01f, -1.48672625e-01f, 5.88475391e-02f,
  1.01556495e-01f, 1.12103894e-01f, 4.58681993e-02f, 2.71978192e-02f, 9.81929302e-02f, 7.69681334e-02f, 1.56881213e-02f, 4.36573885e-02f, -4.12356630e-02f, 3.15693617e-02f,
  1.52792513e-01f, 6.94191828e-02f, 5.13135567e-02f, 1.35497466e-01f, 1.97616778e-02f, 4.50087115e-02f, 7.93412030e-02f, 9.23589095e-02f, 1.06644727e-01f, 7.77425095e-02f,
  -4.07518037e-02f, 5.07872701e-02f, -1.53891435e-02f, 1.27452537e-01f, 8.56091157e-02f, -2.67575178e-02f, 1.14421040e-01f, 4.68865782e-02f, 8.92505050e-02f, 8.84853974e-02f,
  8.42064694e-02f, -1.01373540e-02f, 1.38185304e-02f, 2.08527729e-01f, -1.24689452e-01f, 1.86593756e-01f, 1.00459456e-02f, -4.42239754e-02f, 1.41755402e-01f, 5.80351762e-02f,
  1.11790985e-01f, 1.92504793e-01f, -1.93445265e-01f, -6.51091188e-02f, 7.43588358e-02f, -1.47304028e-01f, 1.72103703e-01f, -4.18362767e-02f, -1.17440864e-01f, 1.74445525e-01f,
  3.87540832e-02f, -8.21667782e-05f, -1.24843381e-01f, 1.31573558e-01f, -1.07753344e-01f, 5.93977273e-02f, -2.34758910e-02f, -1.55630469e-01f, -1.25865281e-01f, 3.96459475e-02f,
  1.31898031e-01f, -8.20600390e-02f, 1.22147083e-01f, -7.32524842e-02f, 6.73633441e-02f, 4.88191955e-02f, 8.35055262e-02f, -9.13298875e-02f, 1.14472108e-02f, 1.70893401e-01f,
  1.32248392e-02f, -5.44507615e-02f, -6.49150610e-02f, 1.47032782e-01f, -1.43760098e-02f, 1.76041022e-01f, -5.59177399e-02f, -2.12900132e-01f, 1.67568901e-03f, 1.15493171e-01f,
  -8.86122435e-02f, -2.91927122e-02f, 1.15175612e-01f, 8.79411846e-02f, 2.12020040e-01f, 2.22884446e-01f, -2.67544538e-01f, -1.46211505e-01f, 2.46819593e-02f, -1.35929450e-01f,
  3.35065089e-02f, -8.21090117e-02f, 7.94855356e-02f, 1.23054095e-01f, 3.00562888e-01f, 1.27636358e-01f, -2.29316801e-01f, 1.52148426e-01f, 2.18303695e-01f, -9.45024192e-02f,
  1.11076482e-01f, 1.21220695e-02f, -3.28578390e-02f, -1.61936045e-01f, -6.62011607e-03f, 3.64572890e-02f, -6.12984004e-04f, 5.95622789e-03f, 1.63089186e-01f, 7.03316703e-02f,
  5.42176180e-02f, 5.79977669e-02f, -3.50829214e-02f, 5.57658076e-02f, 3.96928564e-02f, 5.28917946e-02f, 3.59724858e-03f, 7.00618094e-03f, 1.45521000e-01f, -5.83948269e-02f,
  -2.91440096e-02f, 1.80271361e-02f, -6.23999126e-02f, 1.95346447e-03f, 4.89037260e-02f, -2.74348762e-02f, 1.20982351e-02f, -3.99831720e-02f, -2.73795296e-02f, -8.29583630e-02f,
  -1.29599065e-01f, 3.58307660e-02f, 4.29600626e-02f, -1.57274768e-01f, -2.38009430e-02f, -8.58642068e-03f, -1.25445470e-01f, -4.43549082e-02f, -1.42079562e-01f, -2.52116416e-02f,
  2.17434336e-02f, 4.70027700e-02f, 3.35833728e-02f, 8.13517254e-03f, -1.17858090e-01f, 4.54495326e-02f, -1.02408733e-02f, 1.68999529e-03f, 8.02017450e-02f, -1.24266744e-01f,
  1.65028438e-01f, 2.33452022e-02f, -8.08628835e-03f, 1.21997297e-01f, -1.74496680e-01f, -1.10177636e-01f, -1.62296817e-01f, -3.37535664e-02f, 9.59628597e-02f, 1.65094480e-01f,
  -4.35033701e-02f, 1.85132891e-01f, -9.84657742e-03f, -1.18484356e-01f, 1.18366398e-01f, 1.32337242e-01f, -3.73026803e-02f, -9.37434807e-02f, -6.48009479e-02f, -2.31602089e-03f,
  1.14913434e-02f, 3.75311263e-02f, -2.01819584e-01f, -3.88652645e-02f, -1.74567889e-04f, 6.24842532e-02f, -9.48435217e-02f, 4.02931236e-02f, -2.31240883e-01f, -1.80878982e-01f,
  -5.82251586e-02f, -1.45156935e-01f, 1.81863934e-01f, -1.39418170e-01f, 3.33679467e-02f, 1.20918423e-01f, -5.73618971e-02f, 6.70074746e-02f, -9.83748809e-02f, -6.21001609e-02f,
  2.32481256e-01f, 3.48752216e-02f, -1.97697967e-01f, -6.83727711e-02f, -8.23221579e-02f, 7.73800611e-02f, 1.40697330e-01f, -2.51349717e-01f, -8.75744894e-02f, -3.98725122e-02f,
  -9.71999764e-02f, -7.04071000e-02f, 1.69580534e-01f, -2.32701506e-02f, -2.24482939e-02f, 9.40859169e-02f, -2.38189567e-02f, -7.16149807e-02f, -1.80361062e-01f, -3.71792242e-02f,
  1.36833012e-01f, 1.77000046e-01f, -1.19148731e-01f, 1.18108399e-01f, 1.22918554e-01f, 1.33934408e-01f, -1.19349003e-01f, 3.42421651e-01f, -8.77938345e-02f, -4.75889258e-03f,
  2.29651071e-02f, -1.24624908e-01f, -3.69669124e-02f, -9.36929658e-02f, -7.09992426e-04f, 1.32862717e-01f, 8.79019126e-02f, 3.57252747e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  4.70047481e-02f, 1.04511708e-01f, 2.45662518e-02f, 6.56014383e-02f, 5.84789887e-02f, -7.49672705e-04f, 4.10265252e-02f, 7.00468644e-02f, 7.58928582e-02f, 4.29225303e-02f,
  6.29789829e-02f, 6.57602623e-02f, 5.09655476e-02f, -1.43218727e-03f, 8.77582803e-02f, 3.23419981e-02f, 4.43887385e-03f, 1.06503852e-01f, 6.79025128e-02f, 7.11877942e-02f,
  4.44183648e-02f, 5.76314703e-02f, 4.83541079e-02f, 5.01697250e-02f, 2.37128027e-02f, 8.56160000e-02f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  -1.64533257e-01f, 1.00346014e-01f, -2.76176091e-02f, 8.72360542e-02f, 1.01584598e-01f, -5.46398805e-03f, 2.58017015e-02f, -1.82007253e-01f, 1.30210947e-02f, 8.58270228e-02f,
  -1.60118207e-01f, -8.18988234e-02f, -8.17876160e-02f, 1.67785615e-01f, 7.17986226e-02f, 4.32173647e-02f, 4.90776598e-02f, 8.63328576e-02f, -1.65660098e-01f, -1.92949951e-01f,
  6.47437945e-02f, -3.74125019e-02f, -1.14543691e-01f, -9.58674327e-02f, -1.66566014e-01f, 4.42551188e-02f, -8.36038217e-02f, 3.30702169e-03f, -1.82630152e-01f, 4.31696363e-02f,
  -5.82262017e-02f, 1.08185165e-01f, -2.11657688e-01f, -9.11506563e-02f, 6.42512143e-02f, -1.34741917e-01f, -5.39811887e-02f, -5.98282777e-02f, 1.44261576e-03f, 7.94186164e-03f,
  -2.91931015e-02f, -9.81342047e-02f, 1.15216836e-01f, 2.23383084e-02f, -3.01151276e-02f, -1.40514657e-01f, -7.35366940e-02f, -1.57648131e-01f, -8.57541934e-02f, 1.31201774e-01f,
  5.65530658e-02f, 1.40073329e-01f, -1.35142729e-01f, -1.40021920e-01f, 3.11563104e-01f, -1.18425108e-01f, -1.21215247e-01f, 1.95672259e-01f, 4.37651947e-02f, -9.63142887e-02f,
  -8.80896598e-02f, 7.58131966e-02f, -3.08665812e-01f, 1.87183395e-01f, -3.11392359e-02f, -2.55674064e-01f, -1.55027285e-01f, -2.28724435e-01f, 1.34567201e-01f, -9.41666216e-02f,
  1.25916958e-01f, -2.57818848e-02f, -1.42795175e-01f, -1.69631973e-01f, -1.79629892e-01f, -1.28736302e-01f, 2.67518073e-01f, 1.17728338e-01f, 4.38701920e-02f, 4.81285341e-03f,
  -1.22945689e-01f, -9.27667841e-02f, -1.64370641e-01f, 9.29080099e-02f, 2.48034731e-01f, -9.60782468e-02f, -2.54219711e-01f, -1.84674934e-01f, 1.39740586e-01f, 2.49273151e-01f,
  2.75590062e-01f, -1.89908400e-01f, -2.26656854e-01f, 2.27490664e-02f, -2.67201662e-01f, 1.22956567e-01f, -1.16799831e-01f, 1.35234147e-01f, -8.33749324e-02f, -1.27558634e-01f,
  3.91016761e-03f, -2.82999039e-01f, -3.76331806e-01f, 2.23261729e-01f, -5.06836474e-01f, -3.05548847e-01f, -1.00165702e-01f, -2.11365327e-01f, -1.17288828e-02f, -1.21769525e-01f,
  2.07649037e-01f, -3.13193887e-01f, 5.41300029e-02f, 2.46401116e-01f, -1.61848605e-01f, -1.86130311e-03f, -8.78942162e-02f, -2.29670793e-01f, -3.03095102e-01f, 2.40031168e-01f,
  -3.63566130e-01f, 2.47229472e-01f, -8.98039341e-02f, -3.05583030e-01f, 2.15268269e-01f, 1.94602937e-01f, 2.16981813e-01f, 3.93157601e-02f, -1.12149261e-01f, -2.43510306e-02f,
  -7.13984221e-02f, -6.04393817e-02f, -7.52541749e-03f, -3.57484538e-03f, 2.95786094e-02f, 5.17534502e-02f, -6.32831454e-02f, -5.35461791e-02f, 5.82954288e-02f, 1.46430088e-02f,
  1.72910392e-01f, -1.44813687e-01f, 5.14371283e-02f, 1.04262074e-02f, 1.47177845e-01f, 4.44923108e-03f, 9.37877521e-02f, 1.67894498e-01f, 4.98300754e-02f, -2.84280833e-02f,
  2.99452841e-01f, -1.18578471e-01f, -4.73066270e-02f, -1.17086612e-01f, -1.19165450e-01f, -6.35215221e-03f, 1.22048706e-01f, 3.73611003e-02f, -2.21161973e-02f, -4.47258390e-02f,
  2.15381220e-01f, 1.14661239e-01f, -2.08846614e-01f, 8.88050497e-02f, 6.36917129e-02f, 6.60906658e-02f, -8.41345415e-02f, 1.32887170e-01f, 3.91789638e-02f, 5.24534136e-02f,
  -4.18487191e-02f, 1.50514543e-02f, 1.28693327e-01f, -6.86693937e-02f, -3.55555080e-02f, 3.18447649e-02f, -7.63870180e-02f, -1.18157893e-01f, 4.17769961e-02f, 8.60259980e-02f,
  1.21237375e-01f, -2.17614397e-01f, -3.22614908e-01f, 2.05316156e-01f, -1.80393100e-01f, 1.62287414e-01f, 2.30928972e-01f, 9.89162736e-03f, -2.53244638e-01f, 4.37756479e-01f,
  2.90879846e-01f, 8.37101117e-02f, -2.51960388e-04f, 8.68246406e-02f, -2.06554577e-01f, -1.37719482e-01f, 1.29691839e-01f, -2.74814051e-02f, -2.34547302e-01f, 1.58592895e-01f,
  -2.06141680e-01f, 9.97123122e-02f, -3.04201603e-01f, -2.26684719e-01f, -9.76459906e-02f, -1.26660958e-01f, 8.22932869e-02f, 3.00468206e-01f, -1.74186230e-01f, -2.00442031e-01f,
  -1.30383611e-01f, 2.23687813e-01f, 3.13039385e-02f, -1.13740876e-01f, -7.28086829e-02f, 1.69243753e-01f, 1.22754365e-01f, 2.42368728e-01f, 2.16083616e-01f, 2.39360705e-01f,
  -1.25902399e-01f, 3.02277476e-01f, 3.24726939e-01f, -3.13916355e-02f, -1.06441490e-01f, 2.09293604e-01f, -1.30582184e-01f, -1.08254932e-01f, 1.25531629e-01f, 1.17979072e-01f,
  1.32079378e-01f, -5.78230247e-02f, -3.21294188e-01f, 1.83436334e-01f, -2.75057644e-01f, -2.04257160e-01f, 1.74148038e-01f, -2.11887658e-01f, 2.42954586e-02f, 1.18358375e-03f,
  1.27869666e-01f, 2.62117922e-01f, -3.75543803e-01f, -3.80043179e-01f, -2.03688323e-01f, 5.04401028e-01f, 5.25800278e-03f, -6.38062730e-02f, -3.31597805e-01f, 2.67120421e-01f,
  2.02008784e-01f, -3.63018811e-01f, -1.77043140e-01f, -8.69204849e-02f, 1.52797386e-01f, -2.51954973e-01f, -1.19891092e-01f, -1.34993196e-01f, -1.65203705e-01f, -1.38477102e-01f,
  -1.05415069e-01f, 7.44174868e-02f, 1.23617426e-03f, -2.12486058e-01f, -1.11157872e-01f, -1.49978131e-01f, 2.17490941e-02f, -1.17576472e-01f, -1.61166832e-01f, -1.07729323e-01f,
  9.90922563e-03f, -1.30383089e-01f, 1.31988646e-02f, -1.09821305e-01f, 4.88380268e-02f, -7.14191003e-03f, -1.22603469e-01f, -1.40790805e-01f, -2.23276213e-01f, 1.40517548e-01f,
  7.86758363e-02f, -2.09187642e-01f, -1.62244007e-01f, -9.52980518e-02f, -1.10620722e-01f, 1.83404852e-02f, 1.81556381e-02f, -9.78233069e-02f, -6.68575466e-02f, -2.10650101e-01f,
  1.08476304e-01f, -2.81140395e-02f, -9.56996456e-02f, -7.72971511e-02f, 1.51986117e-02f, -2.85891414e-01f, -2.42294699e-01f, 1.07243039e-01f, 1.99914984e-02f, -9.50178280e-02f,
  1.10274352e-01f, -2.22224072e-01f, 2.81835627e-02f, -9.98725668e-02f, 1.02957480e-01f, 3.67355831e-02f, 1.94245949e-02f, -2.38338560e-02f, 1.39491871e-01f, -1.27166761e-02f,
  1.69670954e-01f, 1.47757977e-02f, 2.21910223e-01f, 1.71059996e-01f, -2.86189079e-01f, 3.02559137e-02f, -2.25325331e-01f, -3.02401572e-01f, 1.40693411e-01f, -1.26999766e-01f,
  -7.74456561e-02f, -1.80031881e-02f, -1.81255326e-01f, -1.48396924e-01f, -2.83873677e-01f, -2.64419187e-02f, 2.10047606e-02f, 5.10565788e-02f, -1.10920399e-01f, 6.91315532e-02f,
  1.57379031e-01f, -2.68032774e-02f, 4.54221070e-02f, -4.98469211e-02f, -5.10789528e-02f, -1.36655688e-01f, -1.42809123e-01f, -8.35662857e-02f, -1.50318474e-01f, -1.66358933e-01f,
  1.42420933e-01f, 3.50345522e-02f, 1.24610230e-01f, 3.96443158e-02f, 1.46715716e-01f, -3.02340705e-02f, 1.32151142e-01f, -6.35262057e-02f, -1.07998915e-01f, 2.16009934e-02f,
  1.36547446e-01f, -1.52417973e-01f, 4.85220924e-02f, -3.74837890e-02f, -4.13676947e-02f, 2.67929465e-01f, -1.56297520e-01f, -4.71521467e-02f, -1.19444933e-02f, -3.38355124e-01f,
  1.63218558e-01f, -1.49729863e-01f, 2.10508853e-01f, -3.28379363e-01f, 5.89911081e-02f, -2.56592989e-01f, -4.28230643e-01f, 1.64629102e-01f, 5.75130917e-02f, -2.81726897e-01f,
  -3.17713886e-01f, -3.53313595e-01f, -3.24405730e-01f, 3.06272924e-01f, 2.37419993e-01f, 2.13277221e-01f, -6.50973395e-02f, -2.07481608e-01f, 4.22573052e-02f, 1.31959036e-01f,
  -2.84867346e-01f, 2.20444202e-01f, 9.91399512e-02f, -1.79483160e-01f, 4.52021696e-02f, -2.53068537e-01f, -2.49554187e-01f, -1.84004679e-01f, -7.31347427e-02f, -1.83945596e-01f,
  -1.29516885e-01f, 5.29586896e-03f, -2.01391414e-01f, 3.05595994e-02f, -1.98480301e-02f, -6.71841353e-02f, -1.15025401e-01f, 1.29016131e-01f, 3.72696319e-03f, -1.75982654e-01f,
  -1.13816569e-02f, -1.28341347e-01f, -1.22499503e-02f, -3.37373163e-03f, -5.99922761e-02f, 3.81622789e-03f, -1.27979830e-01f, -5.44138737e-02f, 1.82111524e-02f, -6.40577897e-02f,
  -1.49172470e-02f, -3.30518857e-02f, 2.36070566e-02f, -1.76360756e-01f, -1.69736380e-03f, -1.45110101e-01f, -2.37963021e-01f, 8.60782042e-02f, 5.08396924e-02f, 3.88737805e-02f,
  9.70968828e-02f, -1.92045867e-01f, -7.72844851e-02f, -5.27563803e-02f, -2.03660175e-01f, -3.68854664e-02f, 5.22733741e-02f, -5.82752842e-03f, 1.67314708e-01f, 1.08809009e-01f,
  6.30240366e-02f, -3.87268327e-02f, -6.98910952e-02f, 1.12148831e-02f, 8.37423000e-03f, -2.78815418e-01f, 9.50907841e-02f, -1.40487379e-03f, 2.90117055e-01f, -5.48250936e-02f,
  -9.58172306e-02f, 3.26007456e-02f, 1.26191318e-01f, 1.17071271e-01f, 3.10146689e-01f, 3.00074339e-01f, -4.81510684e-02f, 1.71210319e-01f, 4.64260802e-02f, -1.97839722e-01f,
  -6.74773678e-02f, -1.38320878e-01f, 1.93087935e-01f, 2.15143785e-01f, 2.80763954e-01f, 2.86524594e-01f, 2.17232555e-01f, -2.29283944e-01f, 1.06714785e-01f, -1.67728558e-01f,
  1.47337601e-01f, -2.83399343e-01f, -3.04143846e-01f, 5.14851734e-02f, -1.89562544e-01f, -2.92080361e-02f, 1.21255346e-01f, 1.83328211e-01f, 3.27235997e-01f, 2.27076057e-02f,
  1.94869623e-01f, 1.66735873e-01f, -1.22434579e-01f, -3.71642299e-02f, -1.26981437e-01f, -2.57224858e-01f, -1.28965035e-01f, 2.88466573e-01f, -2.50810772e-01f, -1.77969187e-01f,
  3.23563181e-02f, -2.66180813e-01f, 1.77218199e-01f, 2.42158771e-01f, 3.14341396e-01f, 1.44013748e-01f, -2.10524738e-01f, -7.44403526e-02f, 1.23724088e-01f, -2.38411933e-01f,
  -2.34075367e-01f, 1.55440778e-01f, 2.68284846e-02f, 2.66315877e-01f, -1.22464210e-01f, -4.80950415e-01f, -2.48657048e-01f, -2.81802654e-01f, -2.23232489e-02f, 1.89282179e-01f,
  1.43364131e-01f, -2.46335883e-02f, -5.05072474e-01f, -3.38709265e-01f, -2.72963941e-01f, -3.37221652e-01f, -4.68626350e-01f, -6.62575439e-02f, 2.25556239e-01f, 2.47522965e-01f,
  -1.05298512e-01f, 3.13144922e-01f, 1.67950124e-01f, 2.75416881e-01f, 4.23811302e-02f, 9.43415463e-02f, -8.72354805e-02f, 1.28732488e-01f, -9.58651751e-02f, 2.19513848e-01f,
  2.26858005e-01f, -1.14476912e-01f, 2.52050370e-01f, -3.84412264e-03f, -3.08580734e-02f, -9.19776782e-02f, 1.21821299e-01f, -5.87350018e-02f, 1.07286699e-01f, 1.40059084e-01f,
  8.54805857e-02f, 1.38195813e-01f, 8.71195570e-02f, -1.10516213e-01f, 2.34945044e-01f, 4.87970263e-02f, 1.42029047e-01f, -5.27784266e-02f, 2.14664742e-01f, -6.42881989e-02f,
  1.27130747e-01f, 2.59869602e-02f, 5.45149073e-02f, -5.13592968e-03f, 1.60927907e-01f, 9.09806415e-03f, -3.32281403e-02f, 6.73822984e-02f, -4.32519279e-02f, 1.16201505e-01f,
  1.11502171e-01f, -5.53253666e-02f, -7.03920573e-02f, 1.81425825e-01f, -9.58545879e-02f, -1.95524961e-01f, -8.39848667e-02f, -7.57538155e-02f, -1.35227730e-02f, 1.40986025e-01f,
  1.91131607e-01f, -7.89538398e-02f, 1.01870015e-01f, -6.65415078e-02f, -1.24554947e-01f, 1.58769876e-01f, 7.20832795e-02f, -1.65549830e-01f, 3.57458115e-01f, -2.15919077e-01f,
  1.39508769e-01f, -1.12125292e-01f, -5.56279421e-02f, 5.15504554e-02f, -3.10833156e-01f, 2.41296723e-01f, 5.16712777e-02f, 2.47081593e-01f, 1.35961562e-01f, 2.65396267e-01f,
  -3.71885151e-01f, -2.46671125e-01f, 1.36459872e-01f, -2.73340911e-01f, 2.72559077e-01f, -1.49555817e-01f, -7.56243318e-02f, 1.27431974e-01f, 2.56192803e-01f, 1.82757422e-01f,
  -3.11047643e-01f, 3.20562273e-01f, 2.50627279e-01f, -1.29656211e-01f, -3.11474148e-02f, 1.03789940e-01f, 8.49040076e-02f, 3.50322485e-01f, -2.90415794e-01f, -1.61387444e-01f,
  -2.00717434e-01f, -2.61634380e-01f, 2.65590042e-01f, -3.00748765e-01f, 9.84971896e-02f, -1.37178674e-01f, -1.83622673e-01f, 1.69701204e-01f, -1.35152280e-01f, -2.79744029e-01f,
  -7.44895488e-02f, 7.73506314e-02f, -2.10528031e-01f, -2.71706730e-01f, -1.64257020e-01f, 1.17519446e-01f, 1.33859724e-01f, 2.60593921e-01f, 1.13783635e-01f, 2.45394930e-01f,
  -3.43288392e-01f, 1.99978560e-01f, 1.80305526e-01f, -2.05271065e-01f, 2.31923059e-01f, -7.89234340e-02f, -4.13830392e-02f, -1.86928641e-02f, 9.61070508e-03f, 1.78616010e-02f,
  -1.36177063e-01f, -2.18270943e-01f, -2.99139112e-01f, -3.35573018e-01f, -3.68138134e-01f, 7.27054998e-02f, 1.52962863e-01f, 2.35805526e-01f, 2.60782152e-01f, -2.06828803e-01f,
  -4.64975648e-02f, -2.75051259e-02f, -1.68106481e-02f, 6.56000301e-02f, -1.95684321e-02f, 1.02743693e-01f, 2.14554789e-03f, -5.38083166e-02f, -1.18901767e-02f, 2.19862238e-02f,
  8.56471062e-02f, -4.56620194e-02f, 5.61983027e-02f, 1.24130405e-01f, -8.41160193e-02f, 3.55033614e-02f, -8.49583894e-02f, 1.10652028e-02f, 1.77425340e-01f, -5.63586354e-02f,
  -5.22307605e-02f, 4.26921472e-02f, -4.03739102e-02f, 2.26946995e-01f, 1.79905936e-01f, 9.49085057e-02f, -1.50078326e-01f, 6.94075674e-02f, 6.15864759e-03f, 1.70472756e-01f,
  7.24837482e-02f, 2.74508074e-02f, 7.86686167e-02f, -1.83259286e-02f, 8.95036682e-02f, 1.47335194e-02f, 8.67270455e-02f, 6.09609336e-02f, 1.95081070e-01f, 1.08206011e-01f,
  9.36378315e-02f, 1.51161999e-01f, -1.79739494e-04f, 1.78989261e-01f, -2.19772622e-01f, 2.06203148e-01f, -2.90902797e-02f, 2.23105013e-01f, -1.69685885e-01f, -1.80158883e-01f,
  6.50562765e-03f, 1.07884161e-01f, 2.41255909e-01f, -1.50078591e-02f, -3.17180716e-02f, -1.57845110e-01f, 2.59396911e-01f, -2.73104548e-01f, 3.02067786e-01f, -7.42824003e-02f,
  2.54159629e-01f, -1.18618190e-01f, 1.47190288e-01f, -4.33627628e-02f, -1.11702554e-01f, 2.89152324e-01f, 1.09609708e-01f, 2.75623143e-01f, 2.72236079e-01f, -1.35021970e-01f,
  2.05513567e-01f, -2.69236892e-01f, 2.15674862e-01f, 7.34064355e-02f, -5.21534048e-02f, 1.16126180e-01f, 4.54342784e-03f, 1.80966258e-01f, 1.32624701e-01f, 2.64552683e-01f,
  -2.70190854e-02f, 1.87688112e-01f, -3.14901501e-01f, -8.23135227e-02f, -2.45496407e-01f, -2.01572612e-01f, 1.40824601e-01f, -1.87262997e-01f, 1.30571991e-01f, 2.02928290e-01f,
  -3.00754905e-01f, -2.42178246e-01f, 2.73344606e-01f, -3.60878199e-01f, 7.00136274e-02f, 9.77548286e-02f, 5.92162833e-02f, 1.36106506e-01f, 1.14021152e-02f, -2.90225800e-02f,
  -4.72153537e-02f, 1.90455809e-01f, -8.98259729e-02f, 2.38344088e-01f, -4.26570326e-01f, -3.91402096e-01f, -1.05273984e-01f, -2.12973580e-01f, -3.93701065e-03f, -2.90386111e-01f,
  1.44991562e-01f, 1.68084770e-01f, -8.14681575e-02f, 1.96352348e-01f, 4.59444635e-02f, 3.53628770e-02f, 9.91749540e-02f, -4.89133954e-01f, -1.76580980e-01f, 1.52525872e-01f,
  2.70388663e-01f, 1.18767977e-01f, 1.45471245e-01f, -1.56021401e-01f, -7.80147910e-02f, -5.88256478e-01f, -2.07215935e-01f, 2.01967046e-01f, 1.30456835e-01f, -7.98299685e-02f,
  8.95508751e-02f, 1.60682425e-02f, 4.73876335e-02f, -1.36719361e-01f, 2.62171000e-01f, -7.20811635e-02f, -1.96224496e-01f, -1.52771384e-01f, -8.75259861e-02f, -8.56441930e-02f,
  -1.24946930e-01f, 5.27666844e-02f, -1.70869529e-01f, 6.31851181e-02f, -1.43037334e-01f, 5.78562059e-02f, -6.79308325e-02f, -5.09429909e-02f, 7.21562430e-02f, -7.17498455e-03f,
  -8.72821137e-02f, -1.79576367e-01f, -1.01817109e-01f, -3.13487887e-01f, -9.07123685e-02f, -5.56052588e-02f, -1.57084391e-01f, 3.60921845e-02f, 1.13016903e-01f, 9.22333226e-02f,
  -1.19667351e-01f, 1.41050428e-01f, -1.64621577e-01f, -1.43816322e-01f, 5.45206219e-02f, 5.44960871e-02f, 2.84145027e-02f, 4.65775542e-02f, -1.22934254e-02f, -1.77044213e-01f,
  1.34171262e-01f, -4.17435467e-02f, -5.50904088e-02f, 1.71342060e-01f, -1.10671081e-01f, 9.44932625e-02f, -9.15231183e-02f, -6.65842816e-02f, 2.59370990e-02f, 1.52840704e-01f,
  1.54533386e-01f, 4.09438968e-01f, -1.96529314e-01f, 2.40800753e-01f, 1.76650077e-01f, -9.73040462e-02f, -1.76643461e-01f, -7.62114748e-02f, 2.82756984e-01f, 4.83277515e-02f,
  2.75143266e-01f, -1.83397338e-01f, -1.03872932e-01f, 4.50933725e-02f, 2.44848430e-01f, 2.41906598e-01f, -8.97707343e-02f, -1.25922933e-01f, -1.78611442e-01f, 1.30525574e-01f,
  3.02534819e-01f, -3.00358031e-02f, 1.41240537e-01f, 4.78778258e-02f, -1.21096253e-01f, 1.06888160e-01f, 1.65143684e-01f, -2.64871508e-01f, -2.23230213e-01f, 3.66303653e-01f,
  -1.90455746e-02f, -1.10314563e-01f, -5.66898696e-02f, 2.34429955e-01f, 3.27490777e-01f, 4.10364240e-01f, -1.72069073e-01f, -1.89387888e-01f, -2.75756866e-01f, 1.93186730e-01f,
  1.83529302e-01f, -3.65104266e-02f, 7.84394890e-02f, 4.30418774e-02f, 1.96780786e-02f, -2.47291848e-01f, -1.91729829e-01f, -1.34666771e-01f, -1.35822445e-01f, 9.77192223e-02f,
  1.48176476e-01f, 7.36425593e-02f, 3.13882679e-01f, -3.57384145e-01f, -1.38535589e-01f, -2.92923808e-01f, 9.51426700e-02f, -1.18070118e-01f, -4.67966318e-01f, 2.47346103e-01f,
  1.21919855e-01f, -3.27966601e-01f, 2.64356166e-01f, -8.69667083e-02f, -3.68310302e-01f, -1.54655576e-01f, 1.13452254e-02f, -7.15723693e-01f, 3.29916716e-01f, -7.68123567e-02f,
  3.73729877e-02f, -1.08020633e-01f, 1.48576796e-01f, -1.83341861e-01f, -3.50198358e-01f, -2.79995084e-01f, -4.54620570e-02f, 7.52199674e-03f, 3.63102406e-02f, 1.46015286e-01f,
  -8.09310898e-02f, 8.45304430e-02f, 9.92710963e-02f, -1.02570504e-02f, 6.78443760e-02f, 9.70230103e-02f, -1.37896046e-01f, -5.27544916e-02f, 8.53567719e-02f, 1.03714742e-01f,
  -5.20006521e-03f, 1.38137281e-01f, -9.78648961e-02f, 5.28705120e-02f, 6.24843910e-02f, -1.47853196e-01f, -1.45883411e-01f, 7.72742629e-02f, 7.04834424e-03f, 8.26417729e-02f,
  5.68572059e-02f, 6.55012429e-02f, -9.42896083e-02f, 7.32989535e-02f, -4.79729138e-02f, -2.50309072e-02f, -9.68254358e-02f, 6.05635047e-02f, 9.26440805e-02f, -3.58891673e-02f,
  -2.48498768e-02f, 8.07189569e-02f, 8.35757405e-02f, -3.00753936e-02f, -2.04724252e-01f, 5.33326827e-02f, 9.16729420e-02f, -4.83759381e-02f, -2.80340444e-02f, -8.64412356e-03f,
  5.27126193e-02f, 3.92582156e-02f, -6.21933267e-02f, -2.93566771e-02f, -7.75901154e-02f, -8.73833001e-02f, -4.89399061e-02f, -1.59619138e-01f, -1.12847559e-01f, 2.79889605e-03f,
  -1.16094314e-01f, -1.72430754e-01f, 6.05777325e-03f, 1.73899069e-01f, -2.10830882e-01f, 1.72702283e-01f, 2.98624523e-02f, -1.44249663e-01f, -7.92138949e-02f, -1.04154041e-02f,
  1.93632528e-01f, -1.60616204e-01f, -1.35912225e-01f, 2.16584325e-01f, -1.55376092e-01f, 9.62920263e-02f, 1.33005515e-01f, 1.80155993e-01f, 6.83085434e-03f, 4.06294577e-02f,
  1.30665451e-01f, 1.67193711e-01f, 8.23386461e-02f, -1.90542147e-01f, -1.76843137e-01f, 5.58088943e-02f, 1.15663320e-01f, 2.88220346e-01f, 4.97989915e-02f, -6.12357818e-02f,
  -1.60559982e-01f, -1.60411030e-01f, 1.35808378e-01f, -5.44341914e-02f, 2.15215653e-01f, -1.13773532e-01f, -2.51249634e-02f, 7.42603689e-02f, 2.25711301e-01f, -1.33135304e-01f,
  2.57023182e-02f, -2.65885919e-01f, 2.49375120e-01f, 2.15279654e-01f, 9.71544981e-02f, 2.19803393e-01f, 2.23007023e-01f, -1.57509699e-01f, -2.44521052e-01f, -5.00751197e-01f,
  -2.55323321e-01f, 3.43574405e-01f, 2.74506599e-01f, 1.73805907e-01f, -1.63775951e-01f, -3.15836747e-03f, 1.81103677e-01f, -2.21447542e-01f, -3.24571133e-01f, -2.36194521e-01f,
  -3.07376981e-01f, -4.22344869e-03f, 1.70557156e-01f, -2.87760105e-02f, -2.24444598e-01f, 3.94773483e-01f, 2.76386887e-01f, -1.70101687e-01f, -3.01638603e-01f, 2.50982225e-01f,
  -4.54327047e-01f, -2.40174010e-01f, -2.67517209e-01f, 3.11593562e-01f, 1.49081901e-01f, 3.31750922e-02f, -6.76638708e-02f, -1.15062013e-01f, -1.59327775e-01f, -1.67569742e-01f,
  -1.02119021e-01f, -5.85500598e-02f, 1.70740020e-02f, 2.97900103e-02f, -1.64311454e-01f, -9.00593325e-02f, -3.07714701e-01f, -9.51807722e-02f, -6.62478507e-02f, 1.46293491e-01f,
  -1.17953802e-02f, -9.46964398e-02f, -1.46802917e-01f, 6.36965781e-03f, -6.88921884e-02f, -5.15018292e-02f, -1.89841568e-01f, -2.11800471e-01f, -1.80033132e-01f, -1.45442694e-01f,
  -3.46162803e-02f, 5.17517142e-02f, -4.63334359e-02f, -4.74719033e-02f, -5.56151122e-02f, -2.26846397e-01f, -7.39677399e-02f, -9.79389027e-02f, -8.71102437e-02f, 5.82967289e-02f,
  -2.31118768e-01f, 1.86363107e-03f, 6.18550554e-02f, 6.37748092e-02f, 2.00889390e-02f, -1.38259739e-01f, -1.30638197e-01f, -5.54851629e-02f, 2.56955880e-03f, -4.39111181e-02f,
  1.27174594e-02f, -2.34130695e-02f, 1.80616044e-02f, 7.12603182e-02f, -2.58366704e-01f, -1.33709699e-01f, -8.25719535e-02f, -1.42233238e-01f, -8.47586170e-02f, 2.66411006e-01f,
  -1.02689758e-01f, -1.56795338e-01f, 1.86099508e-03f, -2.00239629e-01f, 7.84992799e-02f, -9.79197845e-02f, 1.15153961e-01f, -8.64276364e-02f, 7.39084557e-02f, -1.26437411e-01f,
  5.65293878e-02f, 1.47432014e-01f, 3.35695967e-02f, 1.13447912e-01f, 1.57851785e-01f, 8.50788280e-02f, 4.21449468e-02f, 1.27354711e-01f, -2.11305648e-01f, -7.66736269e-02f,
  -6.47035763e-02f, 1.74053028e-01f, 1.91597492e-01f, -7.31738508e-02f, 1.87468365e-01f, 2.34914437e-01f, -9.68440995e-02f, -1.84153408e-01f, 4.72449511e-02f, -2.10635997e-02f,
  -8.14684629e-02f, 8.49480852e-02f, 2.33007908e-01f, 2.01005310e-01f, -3.17474641e-02f, 1.61840431e-02f, -1.25240833e-01f, 6.04253411e-02f, -6.23317948e-03f, -1.16593994e-01f,
  -1.96421519e-02f, -1.33289874e-01f, 1.71894044e-01f, -8.30090940e-02f, -1.55779392e-01f, 7.11096376e-02f, 2.01461799e-02f, -1.17307700e-01f, 9.42776129e-02f, -2.57597417e-01f,
  -3.06266934e-01f, 4.25555438e-01f, -1.56296536e-01f, 3.51297259e-01f, 3.54061633e-01f, -8.44810605e-02f, -1.91640183e-01f, -3.34742755e-01f, -1.52387455e-01f, 1.79361477e-01f,
  -3.87682319e-01f, -7.11437464e-02f, 5.93582466e-02f, 2.21602529e-01f, 2.21635208e-01f, -2.38925159e-01f, 2.03828588e-01f, -2.80208379e-01f, -3.25927377e-01f, 1.06430158e-01f,
  -4.12119687e-01f, -2.80609131e-01f, -4.85688932e-02f, -7.86869973e-02f, -8.08609426e-02f, -7.85713196e-02f, 6.53931946e-02f, -2.82306612e-01f, -4.32074666e-02f, -7.67850950e-02f,
  -1.53555721e-01f, 9.39878076e-02f, -2.71074544e-03f, 6.91512451e-02f, 1.52660415e-01f, 4.57683299e-03f, -1.97920606e-01f, 1.54989049e-01f, -1.77990958e-01f, -1.81470037e-01f,
  -3.04386377e-01f, -2.25079828e-03f, -4.71672975e-02f, 1.01306580e-01f, 3.75302020e-03f, -6.02131896e-02f, 3.40726152e-02f, 1.45811677e-01f, 1.13985494e-01f, 2.70059258e-02f,
  -3.33639979e-02f, -1.16616279e-01f, -1.11561023e-01f, -7.37863639e-03f, -3.64127271e-02f, 6.14483953e-02f, 9.86483991e-02f, 2.06745602e-03f, -2.43977236e-04f, 8.30588266e-02f,
  -5.07318713e-02f, 1.43353743e-02f, -4.52276915e-02f, -1.46936953e-01f, -6.27941042e-02f, -1.79252326e-01f, -3.68363857e-02f, 1.22671433e-01f, 1.35868788e-01f, -1.73876718e-01f,
  -1.32728834e-02f, 2.29837120e-01f, -6.97894096e-02f, 4.33169445e-03f, 1.60506770e-01f, -3.70178908e-01f, -1.10534295e-01f, 1.20997444e-01f, 6.74882845e-04f, 3.86140704e-01f,
  -1.13890655e-01f, -1.07742831e-01f, 3.15140411e-02f, -1.44754112e-01f, -3.51951629e-01f, 1.11704759e-01f, 5.95430024e-02f, 5.86601123e-02f, -1.47572786e-01f, 1.36687271e-02f,
  -1.36190608e-01f, 6.58054138e-03f, -7.96124190e-02f, -2.39144146e-01f, -2.51627386e-01f, 9.25853401e-02f, 2.06142068e-01f, 2.00777903e-01f, -1.03745706e-01f, -3.97546142e-02f,
  2.35664770e-01f, -2.09781647e-01f, -3.71854961e-01f, -2.61776835e-01f, 1.75323546e-01f, -2.35721737e-01f, -1.03764884e-01f, -2.59722117e-02f, -3.84554029e-01f, -3.20200056e-01f,
  -2.14320645e-01f, -9.60577354e-02f, 1.40572518e-01f, 2.33587831e-01f, 2.12285548e-01f, -1.80491969e-01f, -2.74384320e-01f, -2.15101987e-02f, -9.57202166e-02f, 1.38690770e-01f,
  -3.60869020e-02f, -9.43725556e-02f, 2.83721834e-03f, -2.64654309e-01f, -4.35011506e-01f, -3.79301220e-01f, -3.86810452e-02f, 2.73858905e-01f, 3.54767412e-01f, -1.49073200e-02f,
  -5.54278493e-01f, -5.63875794e-01f, -4.64827865e-01f, -1.19700372e-01f, 2.27650434e-01f, 3.03260863e-01f, 2.00262770e-01f, 1.98674545e-01f, -4.78720739e-02f, -2.54670113e-01f,
  1.86618924e-01f, -2.04836071e-01f, 1.46890640e-01f, -2.82002753e-03f, -1.71289220e-02f, 2.03305110e-01f, -1.54399574e-01f, -1.26800701e-01f, 2.36785740e-01f, -1.00031428e-01f,
  -5.02703823e-02f, -1.34440616e-01f, 6.71137199e-02f, 1.25719786e-01f, 1.41395688e-01f, 6.40461519e-02f, -8.84508640e-02f, 6.99209943e-02f, 1.47856027e-01f, -1.04691930e-01f,
  -1.91786550e-02f, 1.04963824e-01f, 1.04429252e-01f, -1.45558864e-01f, 8.15707967e-02f, 9.93447825e-02f, -9.44502130e-02f, -1.89181250e-02f, 5.43322563e-02f, 4.61087488e-02f,
  6.99874163e-02f, 5.00248373e-02f, 1.03307754e-01f, 2.58976948e-02f, -7.59911016e-02f, 2.11479977e-01f, 6.51735961e-02f, 4.90566045e-02f, -3.63802910e-02f, -2.38403708e-01f,
  -1.21555917e-01f, 1.24371707e-01f, 1.59290880e-01f, 1.23379685e-01f, -1.51866660e-01f, -2.10887522e-01f, 6.02192357e-02f, -1.31249502e-01f, -1.81179523e-01f, 2.59068795e-02f,
  6.63978234e-02f, -6.56357557e-02f, -1.12556085e-01f, 3.49783269e-03f, 5.12945056e-02f, 4.50971238e-02f, -8.16046521e-02f, -3.80343832e-02f, 9.09053236e-02f, 1.26722157e-01f,
  4.77501154e-02f, 2.50351787e-01f, -3.20991725e-01f, 2.05583811e-01f, -3.06473970e-01f, -1.36992723e-01f, -1.41266406e-01f, -2.11439997e-01f, 6.02257475e-02f, 2.92198420e-01f,
  -3.50335330e-01f, 2.52088577e-01f, -3.61352324e-01f, 6.37392923e-02f, -1.53180644e-01f, -1.37165308e-01f, 1.05693981e-01f, -2.10204810e-01f, 1.84450164e-01f, 1.82872400e-01f,
  -3.42265457e-01f, 1.11295186e-01f, -2.01089337e-01f, -2.62551457e-01f, 1.43899307e-01f, -9.88110527e-02f, -3.37489806e-02f, -9.28889886e-02f, 3.23533654e-01f, -1.48008719e-01f,
  1.21302478e-01f, -2.70846695e-01f, 2.30781406e-01f, 2.52151373e-03f, -1.60080031e-03f, -1.68317944e-01f, 1.98590174e-01f, 1.73374474e-01f, -2.80871928e-01f, -1.16581991e-01f,
  -1.32965997e-01f, 1.87404066e-01f, -1.62091881e-01f, 6.50585890e-02f, 2.20504329e-01f, -2.12925687e-01f, -1.02663953e-02f, 3.27460825e-01f, 1.78412616e-01f, 2.11433545e-01f,
  1.52900005e-02f, 4.23606783e-02f, 1.99979603e-01f, -3.21330130e-01f, 1.96491659e-01f, -2.57656664e-01f, -2.14822710e-01f, -2.44455665e-01f, 1.71007678e-01f, 7.96789005e-02f,
  -2.30608195e-01f, 1.73282906e-01f, -2.08585367e-01f, -1.87404171e-01f, -2.49683335e-01f, -3.47659111e-01f, 2.00637713e-01f, -3.58770967e-01f, 3.36970657e-01f, 5.14058508e-02f,
  -3.99711818e-01f, 2.46567175e-01f, -1.00899577e-01f, 1.76403984e-01f, 2.80856416e-02f, 1.88389719e-01f, -1.61727592e-01f, -2.99524546e-01f, 4.21104357e-02f, 9.23279747e-02f,
  -1.49086118e-01f, -2.59853154e-02f, 7.29547888e-02f, 8.82504135e-02f, -1.36949867e-01f, -2.02031527e-02f, -4.74212095e-02f, -1.02098458e-01f, -1.81203634e-01f, -1.16749750e-02f,
  -1.85395971e-01f, 6.77980036e-02f, 1.25146195e-01f, -1.07271686e-01f, -1.69554842e-03f, -3.77198192e-03f, -7.65030682e-02f, -1.48387030e-01f, -7.11815879e-02f, -2.47712508e-02f,
  -2.11093321e-01f, 4.32579070e-02f, -8.73248726e-02f, 1.52071327e-01f, 1.41185060e-01f, 6.46817088e-02f, -4.24123928e-02f, 1.01327136e-01f, -1.09937057e-01f, -1.22725315e-01f,
  9.82765406e-02f, -1.91494077e-01f, 3.17208506e-02f, 4.73928265e-02f, 7.04625919e-02f, 8.87887925e-02f, -5.99174686e-02f, -1.39386848e-01f, 5.91760799e-02f, 3.60021107e-02f,
  2.01327484e-02f, 7.14756027e-02f, 9.99657512e-02f, -1.47250816e-01f, 1.10255256e-02f, -1.72396407e-01f, -2.78250892e-02f, 1.12951480e-01f, -9.65493619e-02f, 3.25540788e-02f,
  -1.67897284e-01f, 1.22566417e-01f, 3.80689561e-01f, 6.09949790e-03f, -2.86160976e-01f, -7.36411512e-02f, -2.77197599e-01f, -9.07913148e-02f, 5.22053801e-02f, -1.38354436e-01f,
  1.46261632e-01f, -2.46200845e-01f, 2.17548802e-01f, -1.28568143e-01f, -1.03074312e-01f, -4.75335568e-01f, -2.13899001e-01f, 2.04875171e-01f, -2.49457642e-01f, -1.99003771e-01f,
  8.19617659e-02f, 2.02723444e-01f, 1.01560764e-01f, 2.41224840e-01f, -3.64971645e-02f, -1.49190277e-01f, -2.28352159e-01f, -1.22849509e-01f, 1.29028961e-01f, -2.16603413e-01f,
  2.51237303e-01f, 6.64812624e-02f, -1.78091452e-01f, 1.95081875e-01f, -1.34285137e-01f, -1.00215025e-01f, -4.52261455e-02f, -5.16291335e-02f, 3.21879163e-02f, 9.86529291e-02f,
  1.03373073e-01f, -2.20104188e-01f, 2.03915834e-01f, 1.23127140e-01f, 2.34983176e-01f, -1.25985801e-01f, 1.60736144e-01f, -6.59779906e-02f, -1.04449548e-01f, 7.25076720e-02f,
  3.10274273e-01f, 1.09940678e-01f, -2.64063805e-01f, 3.34361136e-01f, -3.35168213e-01f, 1.85014576e-01f, 2.77251005e-01f, 5.38342148e-02f, -2.39966348e-01f, -3.86834852e-02f,
  -1.87098578e-01f, -2.68596351e-01f, 2.58040845e-01f, 1.18865706e-01f, 1.39942572e-01f, -1.60866573e-01f, -2.07998827e-01f, -4.54638720e-01f, -1.64350823e-01f, -3.41457665e-01f,
  1.83774129e-01f, 2.51412511e-01f, 3.17152515e-02f, -4.16867882e-01f, -2.25358710e-01f, -1.72145367e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -7.25157410e-02f, 9.58150849e-02f, -8.62893835e-02f, -3.67749296e-02f, -4.99958843e-02f, 3.06656137e-02f, -2.07846668e-02f, 7.04960078e-02f, 3.69049385e-02f, 4.24671061e-02f,
  9.19922590e-02f, -6.60676062e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    