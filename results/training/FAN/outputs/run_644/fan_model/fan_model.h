/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.16625404e-01f, 3.91929567e-01f, -2.40038946e-01f, -9.83339474e-02f, 9.28010568e-02f, -7.70691857e-02f, -1.45137599e-02f, -8.72471929e-02f, 4.08948548e-02f, 1.36661053e-01f,
  3.87976468e-01f, 2.88420081e-01f, 4.13186364e-02f, 1.52403936e-01f, -9.42632407e-02f, -5.12756892e-02f, -1.57903224e-01f, -2.30317026e-01f, -3.09402645e-01f, 2.33232137e-02f,
  1.73940584e-01f, -3.84262875e-02f, -1.87497720e-01f, -7.08475709e-02f, 2.01594755e-01f, 1.44188464e-01f, 1.26202360e-01f, 1.18956886e-01f, 2.86109209e-01f, 8.24138224e-02f,
  1.53461859e-01f, -1.72735937e-02f, 1.13013843e-02f, 1.03076972e-01f, 1.02488294e-01f, -1.32800445e-01f, -3.86183932e-02f, -5.11302613e-02f, 1.10148303e-02f, 3.77583541e-02f,
  1.21254422e-01f, 1.37649059e-01f, -8.33481997e-02f, 3.97873297e-02f, -9.74801462e-03f, 1.95878148e-02f, -2.05887631e-02f, -1.47681702e-02f, -3.70881781e-02f, 1.27808958e-01f,
  1.13633849e-01f, 9.80721861e-02f, -6.67510629e-02f, 9.03598666e-02f, -1.35885144e-03f, -7.10876659e-02f, 1.78225130e-01f, -4.11603041e-02f, -8.83502439e-02f, 1.60380393e-01f,
  -7.43488921e-03f, 3.98139618e-02f, -2.08540112e-02f, -1.18334796e-02f, -1.50021669e-02f, -1.44084515e-02f, 9.12707474e-04f, 3.32204513e-02f, -3.75924222e-02f, -2.62431595e-02f,
  8.18720274e-03f, 4.82505560e-03f, -3.61858644e-02f, -9.32376534e-02f, 4.49243002e-02f, -1.96142923e-02f, 3.93568911e-03f, 1.51441218e-02f, -5.61444275e-02f, -3.78707126e-02f,
  -6.35861605e-02f, -1.38118165e-02f, -6.22966029e-02f, -2.13238373e-02f, -5.82457520e-02f, -3.29823904e-02f, -9.37383622e-02f, 2.13890113e-02f, -6.66990206e-02f, -1.58358533e-02f,
  2.27432162e-01f, -1.12350583e-01f, 7.33922869e-02f, -2.25593690e-02f, 2.06331555e-02f, 7.90417194e-02f, 8.15369561e-02f, 5.46166115e-02f, 1.63095251e-01f, 6.74184710e-02f,
  8.61825719e-02f, -3.01097147e-02f, 6.26214221e-02f, 1.67763710e-01f, 7.60874571e-03f, 9.45914537e-02f, 1.48076400e-01f, 6.97054937e-02f, 1.27537698e-01f, 1.21496968e-01f,
  3.85130383e-02f, 8.22123662e-02f, 6.64961785e-02f, 1.78039700e-01f, 1.09062120e-01f, 8.71727169e-02f, 7.14566186e-02f, 1.66144416e-01f, -6.89435303e-02f, 7.32831657e-02f,
  3.09208184e-01f, -2.46169284e-01f, -3.71141821e-01f, 1.67577252e-01f, -1.43901467e-01f, -3.67479175e-01f, -5.18349230e-01f, -1.75224066e-01f, 5.62037714e-02f, -7.76987076e-02f,
  -8.04629847e-02f, 6.19068891e-02f, -2.93229031e-03f, -4.27341349e-02f, -1.92082196e-01f, -3.18368763e-01f, -3.01334798e-01f, -7.61722177e-02f, -1.49333104e-01f, -5.78273162e-02f,
  6.53618276e-02f, 9.59925875e-02f, 1.98520795e-01f, -1.17163314e-02f, 8.33456665e-02f, 1.94157198e-01f, 7.24060908e-02f, 6.11087419e-02f, -6.42300174e-02f, 1.07846387e-01f,
  -1.00295253e-01f, -2.58517675e-02f, -1.66282639e-01f, -4.33786809e-02f, -4.46640588e-02f, -8.02151263e-02f, -1.11158989e-01f, -3.01641179e-03f, -8.82160589e-02f, -4.88128699e-02f,
  -8.05414002e-03f, -5.00370786e-02f, -7.34134018e-02f, 4.78245411e-03f, -1.18213799e-02f, -7.85585120e-02f, -4.35132794e-02f, -3.50942574e-02f, -1.79856867e-01f, -1.06974272e-02f,
  -6.65559992e-02f, -5.30814156e-02f, -1.19415410e-01f, -8.03675577e-02f, -3.69833857e-02f, -4.86117750e-02f, 5.70464460e-03f, -6.19502366e-02f, -1.28598288e-01f, 1.01497665e-01f,
  3.49122174e-02f, 9.60787907e-02f, 2.88070515e-02f, 9.70852934e-03f, 1.05119817e-01f, 3.89530808e-02f, 8.83541033e-02f, 6.23275898e-02f, 9.98188928e-02f, 1.30525917e-01f,
  4.86097522e-02f, 1.39013186e-01f, 8.76961127e-02f, 1.11545973e-01f, 1.58736944e-01f, 9.34825838e-02f, 1.44751206e-01f, 1.49687290e-01f, 4.95016016e-02f, 8.15651715e-02f,
  1.14371240e-01f, 1.76937645e-03f, 7.03905225e-02f, 1.66378066e-01f, 9.18362886e-02f, 8.50816965e-02f, 1.13073029e-01f, 2.11770460e-01f, 1.52444899e-01f, 1.17446356e-01f,
  2.28139549e-01f, -3.18782002e-01f, 7.95519575e-02f, -7.58414865e-02f, -1.01409048e-01f, -5.41553646e-02f, -8.18103645e-03f, -1.19197056e-01f, -3.66756949e-03f, -3.84393074e-02f,
  -1.17213152e-01f, 2.47221831e-02f, -9.60690752e-02f, 3.73420794e-03f, -3.20107453e-02f, -6.29991200e-03f, -4.18674685e-02f, 1.24088814e-02f, -6.42658770e-02f, -2.51737498e-02f,
  -6.06317110e-02f, -9.59745571e-02f, -5.86450249e-02f, -5.82829118e-02f, -2.51263697e-02f, -7.07920268e-02f, -5.39061874e-02f, -1.97747070e-02f, -2.05405056e-01f, 2.76138745e-02f,
  3.85820568e-01f, -7.84579664e-02f, -9.22944918e-02f, 3.10258031e-01f, -2.06715479e-01f, -2.12224334e-01f, -3.09993446e-01f, -1.57194212e-02f, 1.55034825e-01f, 1.73882753e-01f,
  -1.25260726e-01f, 1.04621299e-01f, 2.21297577e-01f, -5.53272776e-02f, -2.78653949e-02f, 7.29159340e-02f, -2.77960934e-02f, -2.43246630e-02f, -2.83814874e-02f, -1.99592784e-01f,
  -1.13229737e-01f, 2.01529920e-01f, 9.48854312e-02f, 6.36114106e-02f, 1.44414082e-02f, 1.44723386e-01f, 5.74799888e-02f, -4.87036596e-04f, -1.67632326e-01f, 3.26215811e-02f,
  1.98616296e-01f, -1.25676906e-02f, 5.66986538e-02f, -1.76160620e-03f, -5.42160496e-03f, 1.16890289e-01f, 2.82908045e-02f, 2.77219974e-02f, 4.57693003e-02f, 1.20588712e-01f,
  -7.49199465e-02f, 3.98072749e-02f, -2.89663989e-02f, -5.19907400e-02f, -1.68013405e-02f, -4.70097060e-04f, 1.59867492e-03f, 4.48214472e-04f, 1.04129136e-01f, -3.25798653e-02f,
  -6.54399907e-03f, -1.00025989e-01f, -3.15232687e-02f, -4.45294119e-02f, -2.49080472e-02f, -6.83121532e-02f, -3.55849974e-02f, -1.19582899e-01f, -6.91732913e-02f, 1.94019735e-01f,
  -1.54176829e-02f, -7.09090084e-02f, -1.05895646e-01f, -3.04308087e-02f, -6.99692294e-02f, -9.41714086e-03f, -5.88998310e-02f, -3.96726802e-02f, -6.00615367e-02f, 4.98179607e-02f,
  -9.16290656e-02f, -1.31765672e-03f, -8.06137398e-02f, 3.89471687e-02f, -2.36242302e-02f, -6.47229254e-02f, -5.39462715e-02f, 9.18927975e-03f, -6.53661117e-02f, -2.24553999e-02f,
  1.77208968e-02f, -6.93107098e-02f, 5.89891300e-02f, -4.34527881e-02f, -1.51971817e-01f, -1.03928439e-01f, -5.21067567e-02f, -1.28445134e-01f, -1.69754941e-02f, -6.18848018e-03f,
  4.97199237e-01f, -1.89134665e-02f, 1.69514179e-01f, 1.04521081e-01f, 4.49004546e-02f, -1.96603108e-02f, 4.82271537e-02f, 3.40679549e-02f, -3.43756601e-02f, 6.68987911e-03f,
  -4.29386385e-02f, -5.05295657e-02f, 7.61221424e-02f, 1.45539073e-02f, 7.24559203e-02f, 1.90250762e-02f, 8.13406985e-03f, 6.80596158e-02f, 4.60285619e-02f, 2.10629832e-02f,
  7.09448904e-02f, 5.14458939e-02f, 1.31005123e-01f, 1.44290417e-01f, 4.38507199e-02f, 5.77918626e-02f, 1.21945754e-01f, 8.25471431e-02f, 6.67675138e-02f, 3.23101819e-01f,
  4.61820439e-02f, -7.08973408e-02f, 3.59947383e-01f, 2.88221925e-01f, 6.56888112e-02f, -1.08926326e-01f, -2.52870291e-01f, -1.95038036e-01f, -1.99851394e-02f, 8.48609768e-03f,
  -9.51964036e-02f, 2.73253229e-02f, 1.56692844e-02f, 5.87994196e-02f, 1.68012790e-02f, 1.09361470e-01f, 1.25653118e-01f, 1.89313680e-01f, 1.58316135e-01f, 4.85983584e-03f,
  7.56846145e-02f, 2.93865353e-01f, 2.50337422e-01f, 8.83484185e-02f, 1.36893958e-01f, 9.20918360e-02f, 9.67617780e-02f, 1.29885733e-01f, -1.57789961e-01f, 8.12061206e-02f,
  1.69510230e-01f, 1.17929272e-01f, -1.01946015e-02f, -6.08539693e-02f, 1.43600985e-01f, -1.44858076e-03f, 1.23902209e-01f, 3.98439094e-02f, 4.34916019e-02f, 7.41749853e-02f,
  2.07432970e-01f, 1.18471436e-01f, 1.51907191e-01f, 2.72667259e-02f, 9.46881771e-02f, 1.24127574e-01f, 8.25811625e-02f, 1.38022140e-01f, 1.26138151e-01f, 6.31199628e-02f,
  4.94719110e-02f, 2.57591546e-01f, 1.96558312e-01f, -4.01459001e-02f, -4.21200469e-02f, 6.88923672e-02f, 9.45214033e-02f, -1.20073156e-02f, -3.87317198e-03f, -1.90040886e-01f,
  -4.39490452e-02f, -1.96528640e-02f, 5.51889911e-02f, 2.36586086e-03f, -4.34620902e-02f, 5.60027920e-02f, -1.58034824e-02f, 3.07989866e-02f, -3.39942612e-02f, 6.17563128e-02f,
  5.45906462e-02f, -1.82337302e-03f, 3.53246965e-02f, 4.59777415e-02f, 1.26773909e-01f, 1.38390213e-01f, -4.80799451e-02f, 7.41079524e-02f, -4.72464226e-02f, -3.68227600e-03f,
  -8.62694718e-03f, 8.86126459e-02f, 1.68517962e-01f, 1.79257281e-02f, -2.50043347e-02f, 1.28858700e-01f, 9.67717767e-02f, 3.24691422e-02f, 7.29461536e-02f, 1.37709171e-01f,
  7.48061612e-02f, 1.13035992e-01f, 2.27231551e-02f, 2.97857001e-02f, 1.70364827e-01f, 7.02302530e-02f, 6.49980605e-02f, 9.39645395e-02f, 9.96083394e-02f, -7.49996230e-02f,
  6.21959530e-02f, -2.73406189e-02f, 7.23411143e-02f, 1.12451427e-03f, 2.25912649e-02f, 7.18645230e-02f, -3.91695201e-02f, 4.15620059e-02f, 2.97757946e-02f, -2.08337568e-02f,
  2.60305852e-02f, -7.31538609e-02f, -1.02184024e-02f, -6.35339767e-02f, 3.88850495e-02f, 9.14694965e-02f, -2.31008511e-02f, -1.01451166e-01f, -7.51062930e-02f, -1.24876037e-01f,
  6.55356586e-01f, 3.86555523e-01f, 3.00248772e-01f, 1.83936566e-01f, -1.73422828e-01f, -2.26291180e-01f, 1.27089834e-02f, -8.01069662e-02f, -2.05573589e-01f, 8.50194022e-02f,
  -2.00800106e-01f, -3.04848999e-01f, -2.28472114e-01f, -9.65254307e-02f, 8.28495547e-02f, 1.30934298e-01f, 2.04777122e-01f, 1.95045978e-01f, 1.37362734e-03f, -1.73716456e-01f,
  -1.58710927e-01f, 2.01889142e-01f, 1.91630095e-01f, 9.30044986e-03f, -4.26763594e-02f, -2.65411556e-01f, 1.71783734e-02f, 3.90391350e-02f, -1.89968199e-01f, 2.15105519e-01f,
  4.22268175e-02f, 1.96379483e-01f, -5.77416010e-02f, -9.07043964e-02f, -2.82657575e-02f, 6.44080192e-02f, -4.07693610e-02f, 1.60072654e-01f, -3.94227766e-02f, -2.81491056e-02f,
  2.87426598e-02f, 1.37823969e-02f, -1.31010066e-03f, -1.94371305e-02f, 3.23146991e-02f, -2.63199639e-02f, 5.22362031e-02f, 1.11664996e-01f, 1.39265344e-01f, -2.55034063e-02f,
  -6.69917986e-02f, 1.11829706e-01f, 1.21150114e-01f, -1.22382469e-01f, -2.00623721e-02f, -2.15023123e-02f, 2.60910653e-02f, -5.54615036e-02f, 7.14458898e-02f, 1.10942997e-01f,
  -1.00268431e-01f, 1.03291303e-01f, 5.60267195e-02f, 1.19711906e-01f, -1.70695446e-02f, -5.45235090e-02f, 4.03672196e-02f, 1.10805929e-02f, 2.94425394e-02f, 6.36017432e-07f,
  1.91604663e-02f, 4.88551706e-02f, 4.99976128e-02f, 3.56754176e-02f, 4.37457673e-03f, 1.45438537e-01f, 5.70151061e-02f, 5.40711395e-02f, 1.24540076e-01f, 1.29633427e-01f,
  5.74888252e-02f, 2.78274138e-02f, 2.42385529e-02f, 8.31145514e-03f, 6.71183616e-02f, 8.10812116e-02f, 5.33122346e-02f, 4.60270867e-02f, 4.44672629e-02f, 1.22050740e-01f,
  -2.48269234e-02f, -9.40466896e-02f, -1.45947374e-02f, 3.41983326e-02f, -6.81611151e-03f, -7.96734169e-02f, -1.69549994e-02f, -5.50215431e-02f, 3.33660580e-02f, 6.11047074e-02f,
  -8.42601061e-02f, 2.79485025e-02f, -8.16143826e-02f, -6.50186315e-02f, -5.89059331e-02f, -6.90729469e-02f, -6.77951053e-02f, -2.28441842e-02f, -3.19959149e-02f, 1.27009060e-02f,
  -7.79904202e-02f, 4.95911576e-02f, -1.12605497e-01f, -1.00818627e-01f, -4.15341817e-02f, -1.33579478e-01f, -2.61276029e-02f, -7.15684742e-02f, -5.39953187e-02f, 5.71798831e-02f,
  -5.52733183e-01f, -2.90317327e-01f, 2.15732768e-01f, -3.38242590e-01f, 1.40648648e-01f, 2.76102364e-01f, 4.32121158e-01f, 1.37061849e-01f, -1.42862231e-01f, -1.41785502e-01f,
  -2.39980727e-01f, -2.78910965e-01f, -2.06347361e-01f, 4.09418754e-02f, 2.06419483e-01f, 2.35071689e-01f, 2.80971318e-01f, 1.51806369e-01f, 3.51582736e-01f, 1.35666832e-01f,
  1.44059747e-01f, -9.22004580e-02f, -1.27885967e-01f, -3.81734855e-02f, -9.32996571e-02f, 7.24861398e-02f, -8.87747332e-02f, -1.02923237e-01f, 5.34077212e-02f, -7.34984130e-02f,
  -3.06272089e-01f, -1.91087961e-01f, 1.61344349e-01f, -1.06956214e-02f, -1.07501976e-01f, -5.40543310e-02f, 2.63629518e-02f, -7.38839209e-02f, -7.91170150e-02f, -2.53950972e-02f,
  -1.21170253e-01f, -3.04085296e-02f, -1.92836765e-02f, -9.29151997e-02f, -3.74258086e-02f, -7.25546910e-04f, -8.13926086e-02f, 3.14265601e-02f, -5.76927140e-02f, -6.40480965e-02f,
  -1.06636593e-02f, -4.02566083e-02f, -8.23700503e-02f, -8.54921469e-04f, -6.58317506e-02f, 5.40459305e-02f, -1.91290304e-02f, 8.39855801e-03f, -9.65173263e-03f, -2.13630483e-01f,
  -4.42768476e-04f, -8.59393999e-02f, -1.71006415e-02f, -2.53046639e-02f, -7.05620423e-02f, -2.74051130e-02f, -3.76703478e-02f, -4.74231318e-02f, -1.31860683e-02f, -2.69641876e-02f,
  3.48917283e-02f, -6.12710379e-02f, -4.93155085e-02f, -5.24123088e-02f, -5.47116436e-02f, 4.04897593e-02f, 2.46677194e-02f, 2.87550222e-02f, -3.31633575e-02f, 2.41472069e-02f,
  -1.95508134e-02f, 7.67876534e-03f, -7.78703811e-03f, 9.94732045e-03f, 6.77509159e-02f, 2.37793028e-02f, 5.95868379e-02f, 1.75032057e-02f, -3.55747081e-02f, -5.21985255e-03f,
  -1.58664942e-01f, 1.57088339e-01f, -1.00809075e-01f, 4.96559143e-02f, 6.03874773e-02f, -8.84812046e-03f, -4.00989177e-03f, 7.10926801e-02f, 8.00013244e-02f, -2.90043503e-02f,
  2.04232913e-02f, -1.07992291e-02f, -5.88691309e-02f, 3.53343599e-02f, 3.47341150e-02f, 2.53492706e-02f, 1.33848307e-03f, 1.37929497e-02f, 2.57157832e-02f, -7.55375549e-02f,
  -1.11743612e-02f, 1.35896355e-01f, -5.28698415e-02f, 1.86118651e-02f, 8.76088440e-03f, 8.54938477e-02f, 6.93651335e-03f, 4.83807400e-02f, 1.88128814e-01f, -6.21152483e-03f,
  -2.24095672e-01f, -1.05275854e-01f, -8.82391036e-02f, 1.57190226e-02f, -2.02647746e-01f, -1.87725663e-01f, -7.58441165e-02f, -1.01966104e-02f, 1.79795586e-02f, -2.02770844e-01f,
  -3.35350573e-01f, -2.99225658e-01f, -1.88635886e-01f, -1.56205418e-02f, -7.52822086e-02f, -3.87362465e-02f, 4.15890887e-02f, -1.37876971e-02f, -1.06065258e-01f, -1.44626468e-01f,
  -1.42128980e-02f, 2.05678102e-02f, -3.99711877e-02f, 1.34383380e-01f, 1.72590822e-01f, 5.91847077e-02f, 3.83174866e-02f, -6.11094944e-02f, -3.43750231e-02f, 5.46530075e-03f,
  -4.01604384e-01f, -8.20257515e-02f, -6.91045262e-03f, -1.45429984e-01f, -4.88143563e-02f, 4.74416800e-02f, -1.47401363e-01f, -1.39208138e-02f, -2.48384830e-02f, 4.31334525e-02f,
  -9.22221914e-02f, -1.28787652e-01f, -1.16182804e-01f, -2.81659961e-02f, -9.40817297e-02f, 2.36280877e-02f, 2.96558626e-02f, 1.46596879e-02f, -1.11981064e-01f, -1.01761818e-01f,
  -8.48624781e-02f, -1.45164579e-01f, -6.04328401e-02f, 8.04575235e-02f, 2.81556770e-02f, -7.13112801e-02f, -1.28011644e-01f, -7.16896057e-02f, -8.13156590e-02f, 9.97023731e-02f,
  -2.59234048e-02f, 4.61010225e-02f, 2.52409130e-02f, 2.45356485e-02f, 7.95680732e-02f, 5.52288853e-02f, 7.24269897e-02f, 5.06465100e-02f, 8.56789574e-02f, 4.24004570e-02f,
  1.25370882e-02f, 1.73786804e-02f, -2.34801881e-02f, -2.41261199e-02f, -9.55743045e-02f, 1.55858360e-02f, -8.07953253e-02f, 5.36923334e-02f, 2.77688894e-02f, -3.04172449e-02f,
  6.49838103e-03f, 3.94818485e-02f, 1.60814505e-02f, 1.22365728e-02f, -4.57334928e-02f, 9.50493664e-02f, 3.81666906e-02f, 6.31635636e-02f, -9.72970854e-03f, -6.60884678e-02f,
  -8.50461721e-02f, -2.04883188e-01f, -1.37547478e-01f, 1.22261479e-01f, -8.75917450e-02f, -5.70943055e-04f, -6.93318769e-02f, -3.92075181e-02f, -1.13632068e-01f, -7.26063922e-02f,
  -9.65751112e-02f, -3.09842378e-02f, -6.85028434e-02f, -1.79376844e-02f, -3.48483510e-02f, -4.80113514e-02f, -5.85601432e-03f, -1.38180375e-01f, -9.35130864e-02f, -1.84254698e-03f,
  1.35590965e-02f, 4.52382630e-03f, -1.52416527e-01f, -7.18875751e-02f, -1.00960337e-01f, -1.79941565e-01f, -1.11742921e-01f, -1.51284374e-02f, -1.22715488e-01f, -4.61793467e-02f,
  4.38044250e-01f, -9.17898566e-02f, 2.44521827e-01f, 1.41851842e-01f, -2.32994724e-02f, -7.80017599e-02f, -3.44839782e-01f, -1.36406124e-01f, -1.38272075e-02f, -1.88236430e-01f,
  -3.29898745e-01f, -1.54217958e-01f, -3.27082314e-02f, 5.33864722e-02f, 2.45299637e-01f, 1.72216609e-01f, 2.22246245e-01f, 4.67907906e-01f, 3.04519385e-01f, -1.14700526e-01f,
  -1.52695343e-01f, 1.17596224e-01f, 2.35094741e-01f, 2.94984519e-01f, 1.67949378e-01f, 1.02984592e-01f, -2.27145702e-02f, 1.15926154e-01f, 2.42586248e-02f, 2.01732054e-01f,
  3.09696179e-02f, 1.28641039e-01f, -2.27285083e-02f, 8.90068486e-02f, 8.62679183e-02f, 4.89964560e-02f, -8.38722512e-02f, 4.05407045e-03f, -9.80823301e-04f, 2.81137079e-02f,
  7.80197755e-02f, -1.86710414e-02f, 2.24234611e-02f, 6.09408766e-02f, 3.17526571e-02f, 7.37512186e-02f, 6.83623701e-02f, 1.36765510e-01f, 1.17170066e-01f, -1.12687214e-03f,
  -4.00428548e-02f, 6.59871548e-02f, 1.45748973e-01f, 5.31734414e-02f, 9.37577784e-02f, 1.01235442e-01f, 1.07034683e-01f, 4.04178947e-02f, 1.67645425e-01f, 1.10557431e-03f,
  -1.05430745e-01f, 3.00528802e-04f, -7.22830594e-02f, -9.17473510e-02f, -4.28377800e-02f, -4.76799496e-02f, -4.87928949e-02f, -5.70487007e-02f, -3.24913561e-02f, -3.76545675e-02f,
  -1.83470603e-02f, -7.79226348e-02f, -2.08522612e-03f, -4.68540117e-02f, -6.46369532e-02f, 2.80187801e-02f, 4.99268062e-02f, -3.22482809e-02f, -6.75971061e-03f, 4.54467908e-02f,
  -1.16615877e-01f, -1.16280708e-02f, -9.15796012e-02f, -1.52069721e-02f, -9.02141780e-02f, 1.77808069e-02f, -3.62947546e-02f, -9.82699543e-02f, -1.18066408e-01f, -1.37707517e-02f,
  -1.77235126e-01f, 4.52387333e-02f, 8.72836411e-02f, 1.02774471e-01f, 4.17841822e-02f, 1.96864121e-02f, 3.02282441e-02f, -2.53766906e-02f, 5.05547300e-02f, -2.63747890e-02f,
  -4.79965955e-02f, 8.94297585e-02f, 6.07151054e-02f, 3.24131250e-02f, 6.49146810e-02f, -4.58619334e-02f, -8.21553450e-03f, 1.12206936e-01f, 5.96860945e-02f, 2.07324661e-02f,
  1.09607711e-01f, -2.96808071e-02f, 2.26958543e-02f, -7.80074671e-02f, -2.62795631e-02f, 4.03343178e-02f, -1.29936144e-01f, -6.65047169e-02f, -6.09032921e-02f, -2.49376521e-01f,
  -4.98813242e-01f, -2.03230530e-01f, 9.10123363e-02f, -2.31409639e-01f, -7.18429089e-02f, 3.15033086e-02f, 3.80831659e-02f, 1.15274228e-01f, -3.80215459e-02f, -4.05339152e-02f,
  -3.20399642e-01f, -2.59871244e-01f, -8.94153118e-02f, 8.00777301e-02f, 1.07246041e-01f, 2.43585721e-01f, 3.58151823e-01f, 2.70408869e-01f, 1.73643589e-01f, -4.99373674e-02f,
  -5.66644371e-02f, 3.81416529e-02f, -6.85231686e-02f, 1.25934020e-01f, 1.18673757e-01f, 1.39234543e-01f, 7.96399713e-02f, 9.04293656e-02f, 1.32269293e-01f, 3.95968854e-01f,
  -1.14628017e-01f, -3.46818447e-01f, -8.45309347e-03f, -7.67851919e-02f, -2.34893840e-02f, 6.16084784e-02f, -5.28687760e-02f, -1.41033484e-02f, -5.55241480e-02f, -1.33650769e-02f,
  -6.84947744e-02f, -6.07151911e-02f, -7.38655124e-03f, -6.58403486e-02f, 3.52056175e-02f, -5.33920415e-02f, 1.39791921e-01f, 7.78951943e-02f, 2.14091931e-02f, -4.22296450e-02f,
  -5.61478101e-02f, -7.64686689e-02f, -8.24804232e-03f, 1.46278605e-01f, 4.96037975e-02f, -1.16176317e-02f, 8.60425234e-02f, 1.42009124e-01f, 6.38596714e-02f, 1.01834334e-01f,
  -2.73773652e-02f, -6.25305483e-03f, 2.43497174e-02f, 1.73195302e-02f, 9.54685286e-02f, -2.35530585e-02f, 4.91058566e-02f, -2.88555701e-03f, 4.53341715e-02f, 1.10543966e-01f,
  -5.69277965e-02f, -2.88487785e-02f, 3.93201746e-02f, -3.74311432e-02f, 4.74801194e-03f, 3.14648845e-03f, 9.78724658e-03f, 4.50623855e-02f, -2.14519966e-02f, 2.17685383e-02f,
  -2.98453066e-02f, 8.68142992e-02f, -3.52942869e-02f, 1.22512847e-01f, 9.48034693e-03f, 6.99112490e-02f, -3.18417102e-02f, -3.50510143e-02f, 1.40690692e-02f, -1.09692449e-02f,
  -1.84443101e-01f, -2.60893106e-01f, -1.02897570e-01f, -7.27752410e-03f, -8.37747902e-02f, -3.28393211e-03f, -6.19291402e-02f, -4.01479043e-02f, -1.40976280e-01f, 4.67205197e-02f,
  -1.13101281e-01f, 4.97683249e-02f, -6.71095550e-02f, 3.62918563e-02f, -2.93886159e-02f, 2.98145087e-03f, -1.92173142e-02f, -1.09428391e-01f, 4.75378893e-02f, -1.95455924e-02f,
  3.72496364e-03f, -1.67246647e-02f, -1.13590047e-01f, -5.33787906e-02f, -4.47488613e-02f, -7.50645921e-02f, 4.90001589e-02f, -1.95288584e-02f, -8.98516271e-03f, 7.93421939e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.19924005e-03f, -1.24132290e-01f, -1.68607440e-02f, 2.87098080e-01f, 3.55569154e-01f, 2.08399028e-01f, -1.25151724e-01f, 7.44818822e-02f, 1.53594017e-01f, 1.49217859e-01f,
  1.90288305e-01f, 4.00328517e-01f, 2.84337759e-01f, 2.92080820e-01f, 4.19640988e-02f, 1.78207815e-01f, 2.81707257e-01f, 2.10165098e-01f, 1.91176310e-01f, 1.82423413e-01f,
  3.50503922e-01f, 3.56733382e-01f, 2.42685527e-01f, 2.14191124e-01f, 3.26184601e-01f, 3.53896797e-01f, 1.80087164e-01f, 2.07776174e-01f, 2.74209857e-01f, 4.17349845e-01f,
  -2.12022007e-01f, 2.76996017e-01f, 2.45278656e-01f, 3.08938861e-01f, 9.18736309e-02f, -2.42464557e-01f, 1.09362928e-03f, -1.33539617e-01f, -1.66721657e-01f, -1.92865089e-01f,
  -3.13450061e-02f, -7.23675489e-02f, 1.68387413e-01f, 4.94305603e-02f, 5.89547865e-02f, 5.48630208e-02f, 9.45053101e-02f, -1.05098657e-01f, -8.00685659e-02f, -8.49298239e-02f,
  1.11218929e-01f, -4.73499298e-02f, -2.89356321e-01f, -6.17501587e-02f, 9.18088630e-02f, 2.23305032e-01f, 1.26917213e-02f, -8.70635584e-02f, -1.40629798e-01f, -2.04884894e-02f,
  2.64867306e-01f, 2.06350982e-01f, 2.43617699e-01f, 1.80393964e-01f, 1.55558601e-01f, 1.72604457e-03f, 2.18174309e-01f, 1.04729302e-01f, 9.01818424e-02f, 1.56415969e-01f,
  1.70942973e-02f, -4.34149280e-02f, -1.77907556e-01f, -5.46997301e-02f, 1.87780112e-02f, -1.48005169e-02f, -1.76433682e-01f, -9.07034054e-02f, 3.47485393e-02f, 2.40763370e-02f,
  9.86440182e-02f, -1.29081964e-01f, -1.52812442e-02f, 1.29042175e-02f, -2.84313094e-02f, 1.50571704e-01f, 3.69522423e-02f, 5.34913689e-02f, 8.44537690e-02f, 7.59003730e-03f,
  -3.16559643e-01f, 3.87881190e-01f, 1.45240754e-01f, 5.79439178e-02f, -1.45864226e-02f, -1.44880181e-02f, 1.60149857e-01f, -1.41973659e-01f, -5.83302006e-02f, -2.67404467e-01f,
  -9.19021219e-02f, -1.69870749e-01f, -5.59663065e-02f, -1.58975013e-02f, -1.90285802e-01f, -9.50757563e-02f, -1.70682259e-02f, 2.53492277e-02f, -1.68414593e-01f, -2.75862694e-01f,
  -9.32548493e-02f, -3.80614102e-01f, -4.74520504e-01f, -2.43026748e-01f, -9.62108821e-02f, -4.20206152e-02f, -1.69578686e-01f, -3.43448400e-01f, -1.88916698e-01f, -3.30355257e-01f,
  4.93910313e-01f, 4.72118825e-01f, -4.68293518e-01f, 2.29487896e-01f, 3.74566406e-01f, 3.34889203e-01f, 7.59913683e-01f, 3.16385686e-01f, -2.57189143e-02f, 1.66198805e-01f,
  2.04817668e-01f, -3.22435528e-01f, -1.54263213e-01f, -3.34693044e-01f, -1.20042488e-02f, 3.44094448e-02f, -5.99561892e-02f, -4.33218569e-01f, -3.28326553e-01f, 3.93824466e-02f,
  3.76579970e-01f, 3.56485486e-01f, 1.14466675e-01f, -1.29658774e-01f, -5.39501458e-02f, -1.86338171e-01f, 8.70734081e-02f, 6.72929510e-02f, 6.09878972e-02f, -4.65060055e-01f,
  -6.01689339e-01f, -3.90991010e-02f, -1.45235643e-01f, 8.03391337e-02f, -1.04309484e-01f, -6.94290474e-02f, 1.46558527e-02f, -1.21186480e-01f, 1.38339764e-02f, -2.79448498e-02f,
  -3.65068167e-02f, -1.17376246e-01f, -8.33163690e-03f, -6.03528060e-02f, 8.36503878e-02f, -3.08390558e-02f, -3.25525068e-02f, -1.35632649e-01f, -2.26290450e-01f, -2.31058896e-01f,
  -9.67413113e-02f, 7.08002374e-02f, 9.68086049e-02f, 9.01381224e-02f, -3.06137986e-02f, -6.44385070e-02f, -4.60173264e-02f, -9.88970920e-02f, -8.07132721e-02f, -7.24484548e-02f,
  -1.95961669e-02f, -7.27870017e-02f, -1.59520656e-01f, -6.32815957e-02f, -1.63335409e-02f, -3.98569554e-02f, -2.17310730e-02f, 7.35138059e-02f, -1.93346804e-03f, 5.51927611e-02f,
  -3.37448418e-02f, -1.32080957e-01f, -1.04179300e-01f, -3.92351765e-03f, -2.59434916e-02f, -1.25644729e-01f, 2.67901160e-02f, -4.84840237e-02f, -7.04151616e-02f, 5.79656698e-02f,
  -3.43488082e-02f, -3.42084770e-03f, -3.22648920e-02f, -1.44512668e-01f, -9.09227356e-02f, -7.97130018e-02f, -4.76888269e-02f, -1.63658634e-01f, 7.02814162e-02f, 1.50386602e-01f,
  1.24663010e-01f, -1.43982559e-01f, -7.96380416e-02f, -1.69166058e-01f, -7.61298910e-02f, -1.20040774e-01f, -3.27469379e-01f, -8.63849893e-02f, -9.82989743e-03f, -5.21893799e-02f,
  -4.18993086e-03f, -8.63441378e-02f, 7.17019476e-03f, 7.44014308e-02f, 6.52653575e-02f, 1.58498343e-02f, 1.57616943e-01f, -2.08265260e-02f, -1.04213394e-01f, -2.15288906e-04f,
  1.44835815e-01f, 1.91057697e-01f, 1.36295989e-01f, 4.40919735e-02f, 3.35723907e-02f, -1.42009824e-03f, -4.65627871e-02f, -2.01912131e-02f, 1.43536121e-01f, 5.19557059e-01f,
  -5.75761616e-01f, -4.82571363e-01f, 6.75874501e-02f, 1.86430179e-02f, 2.06542104e-01f, -1.76809549e-01f, -6.37859344e-01f, -7.29789287e-02f, 2.51344442e-01f, -4.88877416e-01f,
  -7.69084692e-02f, 2.30601728e-01f, -4.33146991e-02f, -1.92524374e-01f, -7.28803813e-01f, -8.86145175e-01f, -5.22882640e-01f, -2.85843283e-01f, 9.37255695e-02f, 3.17651033e-02f,
  -3.39259356e-02f, -1.65788054e-01f, -9.74597558e-02f, 1.19909458e-01f, 2.51285523e-01f, 2.62297213e-01f, 1.13897361e-01f, -1.33820996e-02f, -8.32223445e-02f, -3.19020063e-01f,
  -9.95158181e-02f, 5.73070198e-02f, 3.59521389e-01f, -1.80631161e-01f, 7.14281872e-02f, -7.85923824e-02f, -5.62563539e-02f, 1.91877261e-02f, 2.96875443e-02f, -6.36912584e-02f,
  -1.94245353e-02f, 5.20951152e-02f, 1.57897025e-01f, 8.65944698e-02f, 7.64731914e-02f, -7.98456222e-02f, 8.48318711e-02f, -1.61815599e-01f, -1.30219460e-01f, -1.05883079e-02f,
  -2.19997033e-01f, -2.81314582e-01f, -2.68734246e-01f, 9.64236483e-02f, 8.76741409e-02f, 8.34169015e-02f, 2.58869290e-01f, 4.04468685e-01f, 1.23563692e-01f, -1.37765119e-02f,
  8.55463818e-02f, 2.97719259e-02f, -1.37219653e-01f, -2.04810780e-02f, -1.46511897e-01f, -5.30576333e-03f, -1.78241963e-03f, -2.33156830e-01f, 1.17761232e-01f, 5.54210099e-04f,
  4.09734882e-02f, -1.02477126e-01f, 3.64398994e-02f, -2.63052821e-01f, 8.32233764e-03f, -5.27650453e-02f, -1.05586722e-01f, -8.67820829e-02f, -1.84184790e-01f, -4.56706844e-02f,
  -1.13713965e-01f, 1.15528122e-01f, 4.14104424e-02f, 1.29589692e-01f, -2.09634885e-01f, -1.24915160e-01f, 8.67699236e-02f, 3.11423838e-02f, 8.73150397e-03f, -1.13159545e-01f,
  4.19666693e-02f, -1.21672854e-01f, -3.24564040e-01f, -1.47425861e-04f, -2.00095430e-01f, -1.67580515e-01f, -1.52040794e-01f, 1.92625448e-02f, 1.14934042e-01f, -4.31934111e-02f,
  4.42885235e-02f, -8.60264748e-02f, 4.21676114e-02f, 5.86362444e-02f, -1.91816196e-01f, 3.31862979e-02f, -4.01250452e-01f, -2.16770425e-01f, -2.36977041e-01f, 1.04673430e-02f,
  -2.63559520e-01f, -3.98280263e-01f, -3.89143109e-01f, -2.29950204e-01f, 6.88199699e-02f, -1.53790608e-01f, -9.29245278e-02f, 5.67081012e-02f, -4.16803598e-01f, -4.63466227e-01f,
  1.07926559e+00f, -2.98681736e-01f, 4.58265871e-01f, 3.91799986e-01f, -1.70381337e-01f, -1.49468035e-01f, -2.99893349e-01f, 6.18110783e-03f, 3.28605831e-01f, 1.28759742e-01f,
  -5.21292761e-02f, 1.20805487e-01f, 1.63937643e-01f, 1.56893536e-01f, 9.53565538e-02f, 1.63394734e-01f, 1.75779298e-01f, 4.22974944e-01f, 4.28690135e-01f, 1.34629801e-01f,
  -6.42620921e-02f, 3.72448117e-02f, 3.09614390e-01f, 1.86110020e-01f, -6.04057200e-02f, 1.73179835e-01f, -4.99509573e-02f, -1.64023697e-01f, -3.39572877e-02f, 2.48964638e-01f,
  7.46624172e-02f, 1.88570097e-01f, 1.38960689e-01f, -1.04668774e-01f, -2.25901440e-01f, 7.79758096e-02f, 5.87389991e-02f, -8.57431069e-02f, -5.73960878e-02f, -1.50837435e-03f,
  -6.49662465e-02f, -2.56846775e-03f, -2.13444203e-01f, -1.26760051e-01f, -9.02820230e-02f, -1.27582893e-01f, -1.23982087e-01f, 1.51718095e-01f, 5.23235030e-05f, -9.46153253e-02f,
  -1.38353616e-01f, -9.47804227e-02f, -7.71552846e-02f, -1.14769779e-01f, -1.97170794e-01f, -1.37447849e-01f, -1.68245673e-01f, 3.36215943e-02f, 1.90744875e-03f, 2.39203244e-01f,
  3.94350514e-02f, -7.78003484e-02f, -6.57969788e-02f, -6.80665895e-02f, -3.58271524e-02f, -7.71058872e-02f, -9.65745449e-02f, -1.19785242e-01f, 5.41043431e-02f, -2.08917156e-01f,
  -4.76312898e-02f, 6.63343892e-02f, -8.16129670e-02f, 4.60186787e-03f, -1.45210987e-02f, -5.28347529e-02f, 3.49039957e-02f, -1.63652465e-01f, -1.56232849e-01f, -1.80544658e-03f,
  -6.52677706e-03f, 1.07620537e-01f, -1.10300496e-01f, -1.52464673e-01f, -6.20594285e-02f, -2.79415846e-02f, -7.81926140e-02f, -1.26356289e-01f, -1.08456746e-01f, -2.05337219e-02f,
  -3.19670409e-01f, -1.08609676e-01f, 1.84215456e-01f, 1.03897400e-01f, 6.63440749e-02f, -5.92360534e-02f, 4.72633094e-02f, 1.18022665e-01f, -4.48098034e-02f, 4.42877561e-02f,
  -1.78579427e-02f, 5.91344051e-02f, -2.94825107e-01f, -1.49809435e-01f, -9.45305377e-02f, 1.77450329e-02f, -1.38832033e-01f, 1.75305367e-01f, -4.79039457e-03f, -1.01686165e-01f,
  -1.35052189e-01f, 7.99027383e-02f, 2.15568647e-01f, 1.33184600e-03f, -3.92303541e-02f, 1.37728736e-01f, -1.95984676e-01f, -4.09087278e-02f, -1.67502407e-02f, 8.71300325e-02f,
  5.41577816e-01f, -7.01420426e-01f, -8.03875104e-02f, 3.62596184e-01f, 2.74704874e-01f, 3.18536282e-01f, 9.94094461e-02f, 2.25235775e-01f, 3.15579146e-01f, 9.98205915e-02f,
  9.29880813e-02f, 2.11896062e-01f, 1.42191857e-01f, 1.55569866e-01f, 2.96198986e-02f, 5.30503653e-02f, 2.35932637e-02f, 1.42967794e-02f, 2.53416121e-01f, 1.77563176e-01f,
  9.50390659e-03f, -1.04892604e-01f, -5.97062260e-02f, -1.29121900e-01f, -3.15587610e-01f, 4.89486530e-02f, -1.07709169e-01f, -2.59127319e-01f, -1.06354937e-01f, -3.80934864e-01f,
  -2.51148820e-01f, -1.30237505e-01f, 1.61365852e-01f, -5.81853883e-03f, -1.79743275e-01f, -7.69049227e-02f, -6.11583673e-05f, 9.30241868e-03f, 1.18057402e-02f, 9.63873193e-02f,
  -1.23869568e-01f, -1.32477105e-01f, -1.27505675e-01f, -1.19237795e-01f, -5.11127990e-03f, 1.97648071e-02f, -3.46003249e-02f, 6.59246743e-02f, 1.21736988e-01f, -7.17828348e-02f,
  -8.22140723e-02f, 1.71449393e-01f, 2.38010064e-01f, 1.80195212e-01f, 6.94061220e-02f, 2.08498031e-01f, -6.83255419e-02f, 4.08717692e-02f, 2.16310561e-01f, 1.66823760e-01f,
  2.35790297e-01f, 7.36788288e-02f, -6.59234002e-02f, 4.27746773e-02f, 4.31479253e-02f, 1.23104900e-01f, 1.85425505e-02f, 7.32907876e-02f, 2.88868081e-02f, -9.81721058e-02f,
  5.13669066e-02f, 7.22156689e-02f, 4.25262339e-02f, 1.36263855e-02f, -1.11528561e-01f, -1.56491205e-01f, -7.22548887e-02f, -1.92245185e-01f, -3.06426384e-03f, -7.47661516e-02f,
  8.43230821e-03f, 8.62284470e-03f, -1.45916760e-01f, -3.10130030e-01f, -8.25020820e-02f, 1.46280184e-01f, 2.84731165e-02f, -1.50751555e-02f, -4.86880057e-02f, -1.17180660e-01f,
  1.26793347e-02f, 3.60619538e-02f, -1.71225914e-03f, -6.75613135e-02f, -7.57407248e-02f, -2.27231920e-01f, -2.99430564e-02f, -1.06782883e-01f, -6.44183978e-02f, 4.89541236e-03f,
  -7.32655898e-02f, -2.70361155e-01f, -2.35700130e-01f, -7.08213598e-02f, 2.71917358e-02f, 2.60006208e-02f, -1.50981233e-01f, 1.14247747e-01f, 5.27743287e-02f, -8.99787992e-02f,
  -1.91837430e-01f, 3.40585083e-01f, 4.89002794e-01f, 2.43454278e-01f, -1.90228894e-02f, 2.57072628e-01f, -3.44972312e-02f, 2.18983591e-02f, 7.85916522e-02f, 1.90780669e-01f,
  7.09283352e-01f, 5.25368631e-01f, 5.21872759e-01f, 2.65615463e-01f, -2.46500261e-02f, 1.83364600e-01f, 2.10197702e-01f, 6.43200800e-02f, -2.11156443e-01f, 4.94818091e-02f,
  2.02251911e-01f, -7.98993334e-02f, -7.49795660e-02f, 3.82452831e-02f, 1.15543991e-01f, 2.08958164e-02f, -1.20607205e-01f, 1.85852006e-01f, 7.74675906e-02f, 5.79922944e-02f,
  -8.73791724e-02f, 1.74685419e-01f, 2.86234081e-01f, 9.73567516e-02f, -1.29610494e-01f, -2.04043627e-01f, 6.33924678e-02f, 2.48054877e-01f, 1.69869110e-01f, 2.88661532e-02f,
  5.37374437e-01f, 5.93250394e-01f, -2.61046827e-01f, -5.16460538e-02f, 9.56847444e-02f, -2.49257013e-02f, -6.72214851e-03f, -1.90830417e-02f, 7.62201995e-02f, 4.96997349e-02f,
  -1.65992919e-02f, -2.22922638e-02f, 5.01354188e-02f, -8.63067806e-02f, 1.47349238e-01f, 4.02216427e-02f, -1.12731032e-01f, 1.55325860e-01f, 6.45237649e-03f, 7.13839829e-02f,
  -8.07919204e-02f, 1.63494200e-01f, 1.32771432e-01f, -1.17931366e-01f, 9.55170169e-02f, -1.28140911e-01f, 1.23558722e-01f, 1.61263123e-02f, 5.67671657e-02f, -4.53861337e-03f,
  8.42597485e-02f, -1.44463584e-01f, -1.15409428e-02f, -1.07376970e-01f, -1.22400075e-01f, -2.18572021e-02f, -8.65454525e-02f, -2.23448411e-01f, -1.35227665e-01f, -4.62601557e-02f,
  -8.90818685e-02f, 5.16806319e-02f, -6.51129857e-02f, 3.68243195e-02f, -2.90021556e-03f, 1.56706329e-02f, 4.97230887e-02f, -9.50738415e-03f, 5.58991060e-02f, -4.51594032e-02f,
  1.30029082e-01f, 1.46547437e-01f, 1.13967024e-01f, 2.65336633e-02f, -4.91441973e-02f, 4.78824601e-02f, -4.02070172e-02f, -7.31960237e-02f, -9.12051499e-02f, 5.32225817e-02f,
  2.15017162e-02f, 1.99593678e-01f, -1.81956232e-01f, -1.20059364e-01f, 6.45180047e-02f, 2.61452347e-02f, 6.82921410e-02f, 1.42001852e-01f, 1.13506384e-01f, 2.73068827e-02f,
  9.12025645e-02f, -1.32482182e-02f, 1.03167854e-01f, -6.68857917e-02f, -1.69263348e-01f, 8.29382837e-02f, -9.60500091e-02f, 1.28666814e-02f, 5.70768565e-02f, 2.92023588e-02f,
  -1.53171763e-01f, -4.21421565e-02f, -1.12809353e-01f, -1.13719568e-01f, -1.62791032e-02f, -1.67424068e-01f, 2.84113903e-02f, -3.23191471e-02f, -3.49599868e-02f, -2.04295322e-01f,
  2.97243416e-01f, -3.43223006e-01f, 4.63091850e-01f, 4.66077119e-01f, 3.38331401e-01f, 4.69654202e-01f, 2.20450759e-01f, 2.46214151e-01f, 3.62185895e-01f, 1.97427005e-01f,
  -2.51759112e-01f, 6.86097471e-03f, -8.50280896e-02f, -4.95676473e-02f, 7.32051507e-02f, 3.23600411e-01f, 5.06194830e-01f, 3.60694617e-01f, 4.69467700e-01f, 2.02082992e-01f,
  2.14939952e-01f, 1.27333328e-01f, 1.68020606e-01f, 1.71088189e-01f, 1.87648311e-01f, 2.02990681e-01f, 1.55016929e-02f, 2.96686590e-02f, -9.04384106e-02f, 3.26453984e-01f,
  -1.15517572e-01f, -1.67818174e-01f, 7.71240070e-02f, -2.26642311e-01f, -2.28061274e-01f, -1.46174595e-01f, 2.69980002e-02f, -7.92383105e-02f, -1.96951330e-01f, 2.64625042e-03f,
  -7.41699710e-02f, -1.18173882e-01f, -5.61817214e-02f, -4.17418629e-02f, -8.25367309e-03f, -1.89591050e-02f, -1.78126305e-01f, -2.46911440e-02f, -2.45877132e-02f, -9.70069990e-02f,
  -8.23258460e-02f, -3.86729389e-02f, 2.35261749e-02f, -1.02441475e-01f, -1.41306534e-01f, -1.34968936e-01f, -1.40943229e-01f, -1.49463087e-01f, -1.89768374e-01f, -5.21933921e-02f,
  9.86996144e-02f, -2.08204631e-02f, -1.03477769e-01f, 6.37374818e-02f, -3.75309214e-02f, 6.73485696e-02f, 1.66923478e-01f, 1.89563856e-01f, 1.48266658e-01f, -1.88850742e-02f,
  7.84395412e-02f, 1.25026122e-01f, 8.19648057e-02f, -4.65664454e-02f, -3.45343687e-02f, 6.81823939e-02f, 7.39990100e-02f, -6.54602274e-02f, -1.25398368e-01f, -6.73006848e-03f,
  -2.00068597e-02f, 4.88781594e-02f, -2.63944604e-02f, -3.25808339e-02f, -1.00003354e-01f, 5.97316138e-02f, 2.41483245e-02f, -8.96152332e-02f, -2.46795379e-02f, 3.53539102e-02f,
  -1.52781174e-01f, -2.55283386e-01f, 9.50965509e-02f, -8.45887116e-04f, 5.98384179e-02f, -1.79053530e-01f, 8.98390636e-02f, -1.60389826e-01f, 1.45245679e-02f, 2.13066101e-01f,
  6.81938455e-02f, 2.32150778e-02f, -3.05163469e-02f, 7.23658949e-02f, 2.45427713e-01f, 1.75563283e-02f, -1.02109529e-01f, 1.42800078e-01f, 2.52573453e-02f, -6.10212330e-03f,
  4.57491577e-02f, 2.60634512e-01f, 2.12105602e-01f, 8.08558315e-02f, 1.30619869e-01f, 1.30041897e-01f, -9.47745331e-03f, 2.85370834e-02f, 7.59966392e-03f, 1.85928047e-01f,
  -6.05604172e-01f, -1.23902589e-01f, -3.19735587e-01f, 2.38224730e-01f, 3.39236379e-01f, -2.08312184e-01f, -6.34967804e-01f, -5.71429849e-01f, 2.74372585e-02f, -1.27437208e-02f,
  1.39687017e-01f, 4.04390305e-01f, 9.44165364e-02f, 4.09826413e-02f, -4.17331815e-01f, 1.35413297e-02f, 4.02830482e-01f, -1.63104489e-01f, -4.49802041e-01f, -5.24970852e-02f,
  5.61677873e-01f, 1.38902426e-01f, -2.79708833e-01f, -2.92288125e-01f, 3.54091942e-01f, 2.83478200e-01f, -3.69540155e-02f, 1.82739347e-01f, 1.80777505e-01f, 5.41706443e-01f,
  2.41326302e-01f, -8.21617603e-01f, -1.09864555e-01f, 9.67898443e-02f, 1.09344199e-01f, -3.73997360e-01f, -1.43151775e-01f, -1.14237271e-01f, -2.99766590e-03f, -5.28693721e-02f,
  2.84970969e-01f, -2.61591952e-02f, 2.06229672e-01f, 1.95836602e-03f, -1.33964986e-01f, -3.71426225e-01f, -3.83647263e-01f, -3.78335863e-01f, -4.73486632e-01f, -3.59641701e-01f,
  7.14919746e-01f, 3.15163404e-01f, -3.15597087e-01f, -3.71249050e-01f, -4.80730742e-01f, 1.43460810e-01f, -4.36128974e-01f, -2.06302464e-01f, -5.58916569e-01f, -2.47503966e-01f,
  -2.96375882e-02f, -5.89675605e-02f, 8.82302895e-02f, -7.01822564e-02f, -5.68489078e-03f, -4.58385516e-03f, 2.75123883e-02f, 9.98360664e-02f, 1.87550783e-02f, -3.40331614e-01f,
  3.14697213e-02f, 3.80520113e-02f, -4.38567884e-02f, -8.10071155e-02f, 5.58512956e-02f, -6.30740821e-02f, 8.84666517e-02f, -9.09079313e-02f, -2.94356421e-02f, 1.47359800e-02f,
  1.76902220e-01f, -5.72550818e-02f, 1.30880281e-01f, -3.18661667e-02f, 4.45323177e-02f, -8.70543495e-02f, 4.83504236e-02f, -9.65250954e-02f, -1.68193683e-01f, -2.58536004e-02f,
  2.08853379e-01f, -4.19881679e-02f, 1.11121014e-01f, -1.10475190e-01f, 7.35336393e-02f, 5.19226193e-02f, 2.27044672e-01f, 7.14065433e-02f, 2.41026238e-01f, -1.19706422e-01f,
  -1.78243130e-01f, -1.35064617e-01f, 1.18860218e-03f, -1.02501370e-01f, -6.20404221e-02f, -7.58007765e-02f, -2.97843534e-02f, 1.68458804e-01f, 1.11661404e-02f, 1.53916478e-01f,
  9.00030881e-02f, -1.08450338e-01f, -1.59914330e-01f, -2.32418820e-01f, -7.35562593e-02f, 1.55646801e-02f, -4.52982783e-02f, -2.57544219e-01f, -4.50321287e-01f, -3.93141866e-01f,
  -5.02499461e-01f, 3.12144786e-01f, 5.15537523e-02f, -6.62806677e-03f, -1.44970477e-01f, -1.55080751e-01f, 5.25899082e-02f, 3.12359892e-02f, 1.69324726e-01f, 3.53185505e-01f,
  -1.07227139e-01f, -3.00018102e-01f, 1.78913474e-01f, 1.63237825e-02f, -7.23190308e-02f, 4.72346932e-01f, 5.22971451e-01f, -2.01353028e-01f, -7.35975504e-01f, -7.98108876e-01f,
  -1.81152433e-01f, -4.00658906e-01f, -6.49850309e-01f, -1.84329376e-01f, 3.47474307e-01f, 5.74897975e-03f, 3.10531765e-01f, 2.31353547e-02f, -7.72261098e-02f, 5.11355639e-01f,
  5.52043356e-02f, 7.97436312e-02f, -9.70793292e-02f, -2.67365187e-01f, -3.82088237e-02f, 1.12987440e-02f, -1.80132598e-01f, 2.85757631e-02f, -1.09996729e-01f, -9.94870737e-02f,
  -8.09156448e-02f, -2.69337408e-02f, 1.00396378e-02f, -3.88429947e-02f, -2.92397022e-01f, -1.40936598e-01f, 8.29633884e-03f, -4.67356388e-03f, 1.77692343e-02f, -9.81036723e-02f,
  1.70162395e-01f, -4.14246321e-01f, -2.73742944e-01f, 1.09494675e-03f, 2.21823558e-01f, -1.93194345e-01f, -1.39568642e-01f, -7.79795572e-02f, -1.60222337e-01f, 1.71454906e-01f,
  -6.00318201e-02f, 6.85309768e-02f, 2.84752194e-02f, 7.91684687e-02f, -2.29224395e-02f, 1.46037415e-02f, 1.55506536e-01f, 1.10468678e-02f, 4.42831554e-02f, -1.28644079e-01f,
  4.46345098e-02f, -4.21138629e-02f, 9.53005347e-03f, 5.82670793e-02f, 1.45181268e-02f, 8.11228156e-03f, -2.58473624e-02f, 4.53170389e-02f, 6.56787083e-02f, -1.51157789e-02f,
  -1.25025854e-01f, -8.56612064e-03f, 2.51916219e-02f, 7.57012814e-02f, 6.61862642e-02f, 2.50851754e-02f, 4.78311516e-02f, -4.60885130e-02f, 2.88461484e-02f, 6.34033699e-03f,
  3.13640339e-03f, -2.38699969e-02f, 2.09342390e-01f, 1.65908098e-01f, -5.10213040e-02f, -3.45494645e-03f, 1.16077207e-01f, -4.28665895e-03f, 7.17353970e-02f, -1.16428688e-01f,
  -1.92961574e-01f, -5.76867862e-03f, 2.39417478e-01f, 1.04226291e-01f, -2.96074659e-01f, -1.52739128e-02f, 5.44883795e-02f, -7.46010393e-02f, -7.34575465e-02f, -1.06033191e-01f,
  1.19675554e-01f, -1.57496765e-01f, -2.71311581e-01f, 6.68438748e-02f, 1.39771149e-01f, -2.43344605e-01f, -1.94707632e-01f, -4.58083637e-02f, -1.81180581e-01f, -4.92168264e-03f,
  -9.33631480e-01f, -8.92977774e-01f, 7.04842269e-01f, -4.74457413e-01f, 1.90820664e-01f, 3.90171677e-01f, 2.12824881e-01f, -1.58513367e-01f, -1.79087877e-01f, -8.78125653e-02f,
  -2.34556302e-01f, -1.11406989e-01f, -2.77992599e-02f, 5.57509065e-02f, -7.82033056e-02f, 1.20574452e-01f, 1.83080852e-01f, 4.16810244e-01f, 5.29543757e-01f, 2.42581993e-01f,
  -8.02402943e-02f, -3.61405432e-01f, -4.42702681e-01f, -1.57246351e-01f, -3.74531209e-01f, 7.88278133e-02f, -2.05907688e-01f, -1.78439945e-01f, -5.65200206e-03f, -2.57158160e-01f,
  6.42449558e-01f, -3.17158818e-01f, 1.06039688e-01f, -3.25228930e-01f, -1.59501791e-01f, -2.16089487e-01f, 8.63464698e-02f, -1.10191464e-01f, -1.38122857e-01f, -4.94438000e-02f,
  -2.42828518e-01f, -1.49961665e-01f, 4.73523326e-02f, -5.38581097e-03f, -6.29133731e-02f, -4.32115383e-02f, -1.55083895e-01f, -2.64926076e-01f, -1.04977764e-01f, -2.08976697e-02f,
  -2.39559766e-02f, -7.75723830e-02f, 2.10372716e-01f, 1.31316870e-01f, -6.66530952e-02f, 1.15581468e-01f, -6.89492822e-02f, -1.17242076e-01f, 6.07193746e-02f, -1.31727219e-01f,
  5.77310659e-02f, 4.36782800e-02f, 6.78892285e-02f, -9.20184478e-02f, -1.12015702e-01f, 8.71236846e-02f, 1.77551080e-02f, -2.64039282e-02f, 7.49729723e-02f, -3.90431657e-02f,
  -9.14510414e-02f, 4.38664779e-02f, 5.94128780e-02f, -1.23639375e-01f, -5.48670515e-02f, -1.12733468e-01f, 1.36590246e-02f, -4.38975953e-02f, 4.62959409e-02f, -1.41095638e-01f,
  -1.21881709e-01f, -2.39737518e-03f, -5.47874533e-02f, 3.19031030e-02f, -1.15418851e-01f, -1.25590980e-01f, -1.24181835e-02f, 8.21046308e-02f, 8.12259838e-02f, -6.30862787e-02f,
  3.35377783e-01f, 1.84851423e-01f, 1.30116969e-01f, -6.02337644e-02f, -2.56064665e-02f, -1.77865461e-01f, -1.01957418e-01f, -6.58777431e-02f, -3.13537382e-02f, 1.21769369e-01f,
  2.96034422e-02f, 6.63097799e-02f, 4.18716334e-02f, -4.15308587e-02f, 1.10297807e-01f, -6.11386150e-02f, -1.71513990e-01f, -8.28560144e-02f, -7.80607834e-02f, -2.25994270e-02f,
  -1.60264954e-01f, 2.42893696e-01f, 2.05661371e-01f, 2.78355211e-01f, 2.56313551e-02f, 4.11868781e-01f, 2.55023152e-01f, 1.73777655e-01f, 1.72377959e-01f, 2.02028945e-01f,
  8.60036910e-01f, -5.09318411e-01f, -7.40940213e-01f, 8.92744213e-02f, -3.83420497e-01f, -3.57612282e-01f, -6.40003383e-01f, 3.14686187e-02f, 1.44105151e-01f, -6.26130223e-01f,
  -1.84002481e-02f, 7.40048349e-01f, 6.39352024e-01f, 5.47992826e-01f, 5.16091883e-01f, -5.45752823e-01f, -6.10960424e-01f, 6.25219420e-02f, 5.01416028e-01f, 1.39309540e-01f,
  -1.45761088e-01f, 1.40554100e-01f, 1.85842827e-01f, 8.06787908e-02f, -2.69960165e-01f, 9.18504745e-02f, -6.42294407e-01f, -2.27785796e-01f, -3.20216924e-01f, -7.25422204e-01f,
  -5.90972230e-02f, -3.36829841e-01f, 4.91865799e-02f, 1.15940936e-01f, -2.85128266e-01f, 1.53825298e-01f, 2.15563662e-02f, -2.19897404e-01f, -8.70266557e-02f, -1.22824311e-01f,
  -4.00057063e-02f, -1.25953294e-02f, 1.34470299e-01f, 1.28973976e-01f, -1.35702506e-01f, 8.11743438e-02f, -1.77597210e-01f, -5.66340461e-02f, -3.26670408e-02f, -2.12046996e-01f,
  -1.14253864e-01f, -3.29924673e-01f, -1.62392735e-01f, -1.53178930e-01f, -6.53541982e-02f, 1.50591120e-01f, -3.92172635e-01f, -1.75938979e-01f, -1.77851722e-01f, -4.66728359e-01f,
  -5.51516563e-02f, -2.78711356e-02f, -5.27379289e-03f, -5.84918782e-02f, 7.82223605e-03f, 2.71291304e-02f, 5.77660166e-02f, 2.67715156e-02f, -1.41116818e-02f, 4.06157933e-02f,
  -1.90964378e-02f, -1.29684895e-01f, 3.64657380e-02f, -5.40210642e-02f, -3.23413536e-02f, 4.84750792e-02f, -3.87490280e-02f, 1.15137152e-01f, 2.30316799e-02f, 1.32188629e-02f,
  9.46759656e-02f, -4.93014120e-02f, 3.11718863e-02f, 1.41423866e-01f, -1.73371971e-01f, 1.05430365e-01f, 8.94120634e-02f, 3.54713090e-02f, 1.42911017e-01f, -3.34111191e-02f,
  4.33030933e-01f, 2.09138557e-01f, 1.87303409e-01f, 2.14594211e-02f, -2.53333785e-02f, -4.39704396e-02f, -2.94226147e-02f, 9.03740153e-03f, -1.24094086e-02f, -1.73395276e-02f,
  -1.64637253e-01f, 1.67982638e-01f, 1.12472542e-01f, -6.94544166e-02f, -1.45164847e-01f, -3.79757285e-02f, -6.52259514e-02f, 5.80787398e-02f, 5.82558662e-02f, -1.65610343e-01f,
  1.92772597e-02f, -7.65432641e-02f, 1.62533909e-01f, 7.96938911e-02f, 1.39945567e-01f, 3.12100232e-01f, 1.00152880e-01f, 3.94407362e-02f, 3.55549753e-01f, -2.17372421e-02f,
  -3.62753898e-01f, -4.88472223e-01f, -4.35953587e-01f, -6.87728703e-01f, -8.98866802e-02f, 3.72961700e-01f, 1.76016241e-02f, 1.84522718e-01f, -7.78235914e-03f, -3.66458178e-01f,
  5.78553975e-02f, 1.61299661e-01f, -1.37554362e-01f, 1.96428537e-01f, 3.03620487e-01f, -3.05363268e-01f, -3.74886125e-01f, -8.52717683e-02f, 3.39396387e-01f, 4.38445508e-01f,
  1.22877471e-02f, -1.94054455e-01f, 1.13683157e-02f, -5.96742891e-02f, -4.32574183e-01f, -1.65803164e-01f, -5.07139862e-01f, -3.51410151e-01f, -7.26597290e-03f, -6.14638507e-01f,
  -3.77134979e-01f, 3.33039053e-02f, 1.11404106e-01f, 8.29620659e-02f, -3.04100990e-01f, 9.78329331e-02f, -1.83250122e-02f, -1.98522821e-01f, 5.08254804e-02f, -1.09157175e-01f,
  -1.48259178e-01f, 8.50689262e-02f, 5.32902926e-02f, -1.12208545e-01f, -6.62733316e-02f, -3.75590697e-02f, -1.15587294e-01f, -1.46880262e-02f, 7.68516287e-02f, 1.51672006e-01f,
  8.06482509e-02f, 1.46859840e-01f, -4.37489003e-02f, 1.80363908e-01f, 2.36577660e-01f, 1.70972794e-01f, 7.60092810e-02f, 2.00120404e-01f, 3.38034630e-01f, -3.46244514e-01f,
  -7.53746554e-02f, -2.92644687e-02f, 5.96407950e-02f, 2.34705992e-02f, 3.24685983e-02f, 4.40382622e-02f, -8.36667940e-02f, -9.72995386e-02f, 8.33914429e-02f, -6.81431293e-02f,
  -4.66170944e-02f, -6.70445487e-02f, 5.74173182e-02f, -8.34001601e-02f, -4.35477421e-02f, -4.99502085e-02f, -8.78792908e-03f, -3.31596867e-03f, 4.62936237e-02f, 4.26970683e-02f,
  1.12964086e-01f, 2.37845108e-02f, -3.33328508e-02f, 5.24363443e-02f, 1.31889554e-02f, -1.34462595e-01f, 2.35849209e-02f, 2.46342421e-01f, 2.59774867e-02f, 1.64050385e-01f,
  -6.94525957e-01f, 3.51340890e-01f, -3.26532185e-01f, 1.32937253e-01f, -1.67714626e-01f, 5.68848616e-03f, -1.52557269e-01f, -1.11347817e-01f, -1.73756018e-01f, -5.76580763e-02f,
  1.36295632e-01f, -1.05795376e-02f, -7.48235881e-02f, 1.43110566e-02f, 4.20196690e-02f, 1.15066044e-01f, -6.56102002e-02f, -1.26437724e-01f, 3.33033442e-01f, -6.79984922e-03f,
  8.96538347e-02f, 1.73200130e-01f, -9.78516415e-02f, 1.50923589e-02f, 1.36630252e-01f, 1.78478152e-01f, 1.81259923e-02f, 2.62392107e-02f, 2.26068303e-01f, -4.60633487e-01f,
  -8.61652076e-01f, -2.43366867e-01f, 6.48538113e-01f, -7.03689933e-01f, -4.82973978e-02f, 1.50598720e-01f, -1.09919764e-01f, -1.83663696e-01f, -2.05460861e-01f, -1.58987999e-01f,
  1.68776110e-01f, 2.56693754e-02f, 1.23908825e-01f, 2.25753874e-01f, 1.95366889e-02f, 4.73717041e-02f, 8.01126212e-02f, 1.85276017e-01f, 2.36710131e-01f, 6.89041615e-03f,
  -1.64260387e-01f, -2.30154261e-01f, -1.73338782e-02f, 5.27260080e-02f, -5.85723281e-01f, -1.50700092e-01f, 2.91083772e-02f, -1.83634266e-01f, 1.16136804e-01f, -6.17364466e-01f,
  6.17354438e-02f, -4.13851917e-01f, 2.78162509e-01f, -4.46799807e-02f, 1.88398495e-01f, 1.86352525e-02f, -4.36996594e-02f, 5.92481419e-02f, 2.82648616e-02f, 5.31736352e-02f,
  -1.56229213e-01f, 8.23422298e-02f, -1.65998876e-01f, 7.62048066e-02f, -1.55577183e-01f, -1.26076669e-01f, 1.73421055e-01f, 4.44227755e-02f, 1.58573210e-01f, -1.06961851e-03f,
  -5.21748289e-02f, -1.24172136e-01f, -8.01554620e-02f, 1.29553497e-01f, 1.19519923e-02f, 1.57306984e-01f, 1.94604725e-01f, -2.24546179e-01f, 1.67566285e-01f, -7.33555138e-01f,
  7.70523120e-03f, 5.76578639e-02f, 1.43346563e-01f, 3.54054607e-02f, -2.03876644e-01f, 3.58240791e-02f, -5.12526780e-02f, -1.39225526e-02f, 7.37534761e-02f, -1.77785560e-01f,
  1.78332403e-01f, 1.64391734e-02f, 1.20852791e-01f, -1.76572368e-01f, 1.70892313e-01f, -5.64172827e-02f, -9.12709385e-02f, 1.36838838e-01f, 8.13750103e-02f, -1.32351831e-01f,
  9.09218416e-02f, 8.39211862e-04f, 3.67115214e-02f, 1.65666062e-02f, 1.00398377e-01f, 3.05856094e-02f, -7.91372731e-02f, -1.11021318e-01f, -1.07365601e-01f, 2.07405388e-02f,
  -1.86821416e-01f, 5.61451495e-01f, -3.10610890e-01f, -6.99182674e-02f, 2.00587362e-02f, 1.80484012e-01f, -2.75662933e-02f, 2.12405071e-01f, -4.59830612e-02f, -9.64101106e-02f,
  4.91463915e-02f, 1.31530892e-02f, 7.92719349e-02f, 1.50832161e-01f, -7.04009011e-02f, -6.34791628e-02f, -1.06192539e-02f, -8.12481791e-02f, -2.73303930e-02f, -6.25886247e-02f,
  4.20679972e-02f, -1.53329507e-01f, -3.93744886e-01f, -2.28774399e-01f, -2.92779416e-01f, -1.63789436e-01f, -9.98465940e-02f, -2.82514960e-01f, -1.12705439e-01f, -7.58810341e-01f,
  -3.59164059e-01f, 2.80022919e-01f, 1.65635198e-01f, 1.26872763e-01f, 3.67363214e-01f, 5.62066793e-01f, 7.74170399e-01f, 2.86397368e-01f, -1.81529000e-02f, 1.84545234e-01f,
  3.05723161e-01f, -9.96278897e-02f, 1.88983344e-02f, -8.87235329e-02f, 1.99240908e-01f, 2.38384739e-01f, 1.03425950e-01f, -1.22869775e-01f, -3.31850290e-01f, -8.22360814e-02f,
  -3.37484889e-02f, -1.45516440e-01f, -2.69133717e-01f, -1.43728197e-01f, -8.06974620e-02f, -7.16526136e-02f, 7.53429681e-02f, 1.64103523e-01f, 2.49818698e-01f, -1.08976029e-01f,
  1.00730576e-01f, 2.34151945e-01f, -1.79380164e-01f, -2.23564446e-01f, -3.64966728e-02f, -2.89077222e-01f, -1.03898562e-01f, -1.18080147e-01f, -4.19269204e-02f, 2.15717535e-02f,
  1.04469664e-01f, -1.34559274e-01f, 4.54930849e-02f, -7.01958016e-02f, 2.55388357e-02f, -8.67330804e-02f, -1.28421873e-01f, 1.44047558e-01f, 1.67568147e-01f, 9.27615538e-02f,
  6.87729716e-02f, 2.08015680e-01f, 2.29911610e-01f, 1.36191159e-01f, 1.48317739e-01f, 8.93615112e-02f, 1.09748736e-01f, -1.03752457e-01f, 1.08544260e-01f, -2.10525051e-01f,
  -1.50987998e-01f, 9.61817987e-03f, 2.85507232e-01f, -3.49977165e-02f, -6.94283321e-02f, -3.88657227e-02f, 2.92624105e-02f, 1.76567629e-01f, 1.23066247e-01f, -1.06422342e-01f,
  -1.11124188e-01f, 2.18099520e-01f, -4.42299210e-02f, -1.02954037e-01f, -1.92476153e-01f, 5.50600700e-02f, -1.24774398e-02f, -5.12948446e-02f, 1.31839558e-01f, 1.02744952e-01f,
  7.45324194e-02f, 6.41337484e-02f, -1.19399317e-01f, -2.61018369e-02f, -8.56340379e-02f, -1.09311283e-01f, -1.46556020e-01f, -6.44512102e-02f, -1.52752504e-01f, -1.50617480e-01f,
  -3.82878818e-02f, 4.07024890e-01f, -2.07058042e-01f, 1.25043485e-02f, -5.21811768e-02f, -9.84540731e-02f, 4.06339578e-02f, -4.24466655e-02f, 1.52372429e-02f, -7.07669333e-02f,
  1.12683967e-01f, -1.50301576e-01f, -5.48012666e-02f, 1.39927948e-02f, -7.02772513e-02f, -7.76580721e-02f, 1.24088190e-02f, 1.51275188e-01f, 7.54148439e-02f, 4.48011607e-02f,
  3.23178153e-03f, -3.50096375e-02f, -7.28585944e-02f, -1.10488825e-01f, 9.16140154e-03f, -1.23396538e-01f, -1.44302160e-01f, -1.49996758e-01f, -8.72335583e-02f, -4.79333043e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  8.06336164e-01f, 7.15985596e-01f, 2.53534853e-01f, 5.96692681e-01f, 8.51398706e-02f, 2.10942984e-01f, 3.98079127e-01f, 3.42933118e-01f, 6.21199608e-01f, 7.43654549e-01f,
  7.81004548e-01f, 4.21593815e-01f, 4.28567320e-01f, 4.01314974e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.08763881e-01f, 9.77966860e-02f, -1.71624869e-01f, 2.98054907e-02f, -7.30403736e-02f, 1.79011703e-01f, 6.70034438e-02f, -1.86967015e-01f, 3.02731305e-01f, -8.68043825e-02f,
  4.35618497e-02f, 1.09832942e-01f, 5.17281331e-02f, 5.90123571e-02f, 2.61890963e-02f, 9.55030024e-02f, -1.03318095e-01f, 3.37481387e-02f, -1.88081965e-01f, 1.95333660e-01f,
  -2.92888403e-01f, 1.50701672e-01f, -3.79597731e-02f, 3.20052385e-01f, -3.27899829e-02f, -3.63483995e-01f, 3.37415189e-01f, 3.72474611e-01f, 7.19957128e-02f, -3.66397351e-01f,
  -2.23896042e-01f, -1.22281805e-01f, -5.62476814e-02f, 2.40525696e-02f, -1.23728160e-02f, -3.74509059e-02f, 5.30055538e-02f, 3.08474563e-02f, -8.98964144e-03f, 8.62263143e-02f,
  -2.44282540e-02f, 2.14253440e-01f, -5.03620915e-02f, -7.95667097e-02f, -1.26550853e-01f, -9.75974426e-02f, 4.94699366e-02f, -6.77512884e-02f, 8.04238170e-02f, -1.40335277e-01f,
  1.21553481e-01f, 2.21055932e-02f, 2.68412709e-01f, -1.49363801e-01f, -1.91453174e-01f, -3.30953032e-01f, -7.76464418e-02f, 4.85864937e-01f, -4.25263733e-01f, 2.10582882e-01f,
  -9.26248878e-02f, 2.05237985e-01f, 3.44064981e-01f, -1.39170602e-01f, -4.46615517e-02f, 6.53438047e-02f, 2.13469341e-02f, 9.46334451e-02f, 1.20354146e-02f, 3.06814592e-02f,
  -5.40646724e-02f, -4.14924137e-02f, -4.53240797e-02f, 1.34074613e-01f, 9.32363644e-02f, -2.49558054e-02f, -4.03375924e-02f, -6.93656206e-02f, -9.41796452e-02f, 7.89534152e-02f,
  4.56741229e-02f, 1.15701007e-02f, 9.68404710e-02f, -7.51980916e-02f, 2.90076882e-01f, -3.40878189e-01f, -4.09143269e-02f, 1.95904166e-01f, -3.89068365e-01f, 2.26714224e-01f,
  -4.63317305e-01f, -1.94868416e-01f, -1.26270130e-01f, 3.04976493e-01f, 1.97231531e-01f, 1.08583748e-01f, 2.33895719e-01f, 7.33707696e-02f, -4.26169597e-02f, -7.45466771e-03f,
  -1.77893221e-01f, 2.13188261e-01f, -8.21228027e-02f, 7.57563114e-02f, -1.25565559e-01f, -1.26003549e-01f, -2.35671438e-02f, 1.64737061e-01f, -7.27022393e-03f, -1.77829564e-02f,
  1.12399913e-01f, -2.04599395e-01f, 4.87742200e-02f, -7.46084377e-02f, 9.83791351e-02f, 3.55316773e-02f, -5.17496467e-02f, -4.35657566e-03f, -6.64258301e-02f, -1.35359541e-01f,
  -1.43159240e-01f, -1.61099151e-01f, -5.38838863e-01f, 1.66068897e-01f, 5.96553445e-01f, 9.29093733e-02f, 5.19915484e-02f, -2.11504713e-01f, -7.67538100e-02f, 1.31431203e-02f,
  -6.10664785e-02f, 1.91184152e-02f, -1.52813360e-01f, 2.78383881e-01f, 5.79629559e-03f, -3.18930686e-01f, 2.08873644e-01f, 1.55349255e-01f, 2.12170556e-02f, 3.14163506e-01f,
  -1.89908832e-01f, -5.57246692e-02f, -2.63672203e-01f, -1.01848446e-01f, -2.50464141e-01f, 1.15419306e-01f, -8.97354260e-03f, 1.68540195e-01f, 5.52560911e-02f, -1.71127751e-01f,
  -1.06244564e-01f, -1.34008816e-02f, -1.29328340e-01f, -1.76851168e-01f, 5.90344369e-01f, -5.47225364e-02f, -3.47541243e-01f, -1.46601439e-01f, 1.04156516e-01f, -8.37310329e-02f,
  -1.84358209e-01f, 5.62398024e-02f, -8.69975239e-02f, -2.15887859e-01f, -1.89865753e-01f, -3.67793366e-02f, -6.19249828e-02f, -1.73886791e-01f, -5.34202792e-02f, 4.35673073e-02f,
  5.81694543e-02f, 2.27606580e-01f, -1.45353600e-02f, 3.91339250e-02f, 1.29340559e-01f, 1.12696573e-01f, -3.05554360e-01f, 8.13786313e-02f, -6.16683848e-02f, 3.74981880e-01f,
  -2.70900935e-01f, -1.22955613e-01f, 5.46983443e-02f, -2.56275326e-01f, 1.44007862e-01f, -7.61532709e-02f, 5.19941270e-01f, 1.70196518e-01f, -3.37025314e-03f, -3.56613308e-01f,
  -2.96245843e-01f, -1.32603735e-01f, -5.24711795e-04f, -2.28295755e-02f, -6.34818058e-03f, 3.20460759e-02f, 9.95769650e-02f, -2.97382027e-02f, 8.53885263e-02f, -6.02454022e-02f,
  1.42133264e-02f, 6.47081062e-02f, -2.13476550e-03f, -5.25254058e-03f, 6.69144094e-02f, 1.92458984e-02f, 1.22554220e-01f, 1.75407976e-01f, -9.13295448e-02f, 2.91319549e-01f,
  1.22755744e-01f, 1.51202708e-01f, -6.73255548e-02f, -1.54562101e-01f, -1.22015730e-01f, -1.14808895e-01f, -1.63003281e-01f, 1.27213642e-01f, 2.91395873e-01f, 1.36359796e-01f,
  -4.49970096e-01f, -1.02885902e-01f, 1.92077801e-01f, 8.04181471e-02f, -3.45981941e-02f, 1.00501716e-01f, 1.78149357e-01f, 9.17613730e-02f, -1.52199671e-01f, -9.22169164e-03f,
  -9.28856879e-02f, -3.24060440e-01f, 1.14997983e-01f, -2.27288395e-01f, -1.91097468e-01f, -4.86306511e-02f, 1.26098961e-01f, 1.62030786e-01f, 3.36255044e-01f, 5.42727336e-02f,
  1.33820981e-01f, 3.28665197e-01f, 1.95299834e-01f, -1.60603747e-02f, -2.36938864e-01f, 1.96048394e-01f, 7.66772553e-02f, 9.33256745e-02f, 1.56729043e-01f, -2.65718810e-02f,
  -1.02468051e-01f, -1.92434832e-01f, -2.02135012e-01f, -3.81489284e-02f, 9.45179835e-02f, 3.60404775e-02f, -9.89298373e-02f, -5.32363579e-02f, -1.41547799e-01f, -2.39830185e-03f,
  -6.73498586e-02f, -1.59321465e-02f, -2.69344542e-02f, -1.08742759e-01f, -1.62802875e-01f, 4.21571344e-01f, 9.00857989e-03f, 2.85566738e-03f, -2.40678921e-01f, 5.57780378e-02f,
  -2.03737527e-01f, -2.92268768e-02f, -2.75677592e-01f, -1.07384771e-01f, 2.09519625e-01f, 3.09890687e-01f, 2.45915875e-01f, -1.70984641e-01f, -1.21989381e-02f, -2.05823645e-01f,
  -1.85462330e-02f, 3.34127605e-01f, 4.68617141e-01f, -3.69576722e-01f, -1.33876801e-01f, -1.99653640e-01f, -1.02006197e-01f, -2.22757533e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -2.28304043e-01f, -7.83506557e-02f, 5.43285072e-01f, -1.85592026e-01f, -6.77271858e-02f, 3.49556863e-01f, 1.84222385e-02f, 1.20071076e-01f, -3.63090426e-01f, 2.94519305e-01f,
  1.31690633e-02f, 6.98211510e-03f, -2.89554179e-01f, -3.47729504e-01f, -6.67395949e-01f, 2.04112917e-01f, -3.72690856e-01f, -2.90048271e-01f, -6.85155928e-01f, -2.24246889e-01f,
  5.98055124e-01f, -4.53299224e-01f, 1.13925502e-01f, -4.46547389e-01f, -3.23808193e-01f, -2.74985045e-01f, 4.48600531e-01f, 3.43571961e-01f, 4.33133453e-01f, 5.65830350e-01f,
  2.81738430e-01f, -6.86474591e-02f, 4.28673208e-01f, 2.41901249e-01f, -3.22464108e-02f, 1.52113074e-02f, 1.21269323e-01f, 4.53996271e-01f, 3.33767503e-01f, 2.71273345e-01f,
  2.01727506e-02f, -1.85290232e-01f, -3.18011701e-01f, -2.17002407e-01f, 2.02517897e-01f, -7.20890053e-03f, 3.90549272e-01f, 4.56940867e-02f, 2.05126211e-01f, -7.13606179e-02f,
  1.39426619e-01f, 9.92429614e-01f, -2.13671371e-01f, -6.51904285e-01f, -5.36464691e-01f, 2.48430803e-01f, -1.18561417e-01f, 1.12522226e-02f, 6.94104791e-01f, 3.14563997e-02f,
  -1.41451992e-02f, 2.72555679e-01f, 7.37232327e-01f, 5.28429508e-01f, 4.40877348e-01f, 5.39950617e-02f, 1.96031630e-01f, 7.75504066e-03f, -1.25206932e-01f, -7.69629627e-02f,
  4.82170314e-01f, -1.60258427e-01f, 3.94112229e-01f, 5.11192322e-01f, 1.35069311e-01f, 1.41700387e-01f, -9.69307348e-02f, 1.41179129e-01f, -1.85434178e-01f, 5.44393480e-01f,
  -1.84811592e-01f, 1.05475768e-01f, 1.41604856e-01f, 1.76182032e-01f, -9.68005210e-02f, 2.31624126e-01f, -6.96211398e-01f, 5.19477352e-02f, 6.24946989e-02f, 1.00044966e+00f,
  7.18250275e-01f, -2.92776115e-02f, 3.22294593e-01f, -4.65116829e-01f, -9.84448373e-01f, -4.91937459e-01f, 9.27939638e-02f, 7.40396902e-02f, 2.14740291e-01f, 1.24766551e-01f,
  2.73534626e-01f, 6.30403817e-01f, 1.58015773e-01f, 4.37857956e-01f, 6.29940107e-02f, 7.99008831e-03f, 2.07620207e-02f, 4.62329626e-01f, -2.68969103e-04f, -4.16069657e-01f,
  7.31753632e-02f, -2.69145936e-01f, -1.63809359e-01f, 6.88143075e-02f, 4.44486409e-01f, 2.25165740e-01f, 6.52769059e-02f, -5.65724261e-02f, 1.23612314e-01f, -2.20769614e-01f,
  2.82417443e-02f, -7.23187402e-02f, -3.53077054e-01f, 3.18899900e-01f, 1.34380853e+00f, -7.66283050e-02f, -2.63992622e-02f, -4.91312705e-02f, 3.80784035e-01f, 3.12217642e-02f,
  4.52828735e-01f, 3.10264751e-02f, -1.66404426e-01f, 3.97045493e-01f, 1.15220286e-01f, 1.71748564e-01f, 1.11167133e-01f, -4.94093001e-01f, 2.29324594e-01f, 5.58052398e-02f,
  1.41959697e-01f, 3.54275614e-01f, -5.60050726e-01f, 1.28674909e-01f, -1.40305102e-01f, -2.60045588e-01f, 2.38750324e-01f, 3.04743499e-01f, 5.85088968e-01f, 4.56993997e-01f,
  8.54902267e-02f, 2.28782982e-01f, -1.38346717e-01f, -3.01020533e-01f, 5.08086458e-02f, -7.13802218e-01f, 7.27480888e-01f, 2.54666209e-01f, -6.34957924e-02f, 2.21225962e-01f,
  3.72255355e-01f, 1.57156631e-01f, 2.46303335e-01f, -1.03518948e-01f, 5.47846854e-01f, -4.89954725e-02f, 2.46912673e-01f, 6.61954165e-01f, 1.89850330e-01f, -3.71226072e-01f,
  1.06536388e-01f, 1.77876502e-01f, 6.43505855e-03f, 2.41605744e-01f, 1.50181400e-02f, -1.76483929e-01f, -1.34191081e-01f, -4.47182983e-01f, 4.34594959e-01f, 1.02115881e+00f,
  -1.03922248e+00f, 1.81473240e-01f, 2.45886341e-01f, -1.93411231e-01f, 4.46587324e-01f, 1.67490229e-01f, -1.95511989e-02f, -6.53024316e-02f, 5.60294569e-01f, 5.99067807e-01f,
  -6.23391092e-01f, 2.87378937e-01f, 1.60329863e-01f, -7.18546510e-02f, 1.79953892e-02f, -1.73804969e-01f, 1.93440169e-01f, 2.23535910e-01f, -2.38821711e-02f, 9.33174714e-02f,
  -1.58717949e-02f, 2.12416783e-01f, 1.09877035e-01f, 4.00566794e-02f, -6.13874346e-02f, -1.98664755e-01f, -2.19904236e-04f, 3.98481727e-01f, -9.51908752e-02f, -2.75433838e-01f,
  2.72563938e-03f, 5.04290700e-01f, 9.26933527e-01f, -1.51112929e-01f, 6.02017820e-01f, 4.67849448e-02f, -6.81816041e-02f, 6.33007467e-01f, 4.71489429e-01f, -4.70665932e-01f,
  4.32913333e-01f, 9.14583147e-01f, 6.94474041e-01f, 1.90488070e-01f, 2.85418004e-01f, 1.12967379e-01f, 2.44897917e-01f, 3.93280059e-01f, 2.29177773e-01f, 3.59143108e-01f,
  3.03007096e-01f, -1.08099282e-01f, 4.40042228e-01f, -4.71745014e-01f, 2.78468996e-01f, -2.20327139e-01f, 8.42979997e-02f, 3.96863967e-01f, -3.01875323e-01f, 3.27661425e-01f,
  6.63607121e-01f, 1.41330197e-01f, 5.50547838e-01f, -3.79278690e-01f, 4.29442078e-01f, 1.78999633e-01f, -5.98055959e-01f, 4.12992507e-01f, -1.47127673e-01f, 2.89247394e-01f,
  -1.87516287e-01f, -2.95517057e-01f, 4.26189959e-01f, -2.27669433e-01f, 3.45851749e-01f, 1.05442025e-01f, 3.43880765e-02f, 1.16162978e-01f, 3.63828510e-01f, 2.76572853e-01f,
  -1.00242645e-01f, 2.58516610e-01f, -1.25963137e-01f, -1.20910652e-01f, -1.49412274e-01f, -5.42277396e-01f, 8.75983089e-02f, 3.09291840e-01f, 7.68903345e-02f, 1.13164270e-02f,
  -7.06317872e-02f, 1.26992822e-01f, 2.84818076e-02f, 5.54477870e-01f, 3.46750408e-01f, -6.16118193e-01f, 1.12879366e-01f, 2.73864120e-01f, 1.67162791e-01f, -9.09812599e-02f,
  3.87964010e-01f, 1.10806026e-01f, 9.96539295e-02f, 9.02214050e-01f, 4.65323269e-01f, -2.17004448e-01f, -2.48472139e-01f, -3.53277884e-02f, -1.76422238e-01f, -2.37020627e-01f,
  7.14349926e-01f, 7.31539056e-02f, 1.03804931e-01f, -2.30337754e-02f, 1.46751434e-01f, 2.05350257e-02f, -1.64059967e-01f, 2.71406472e-01f, -2.22994193e-01f, -6.37638032e-01f,
  1.61559761e-01f, 2.68958598e-01f, -9.13525999e-01f, 9.20882598e-02f, 1.77334517e-01f, -1.97205558e-01f, 2.87469655e-01f, 3.86587799e-01f, 4.87672597e-01f, -4.43207502e-01f,
  -6.10280514e-01f, 8.16266611e-03f, 9.83746871e-02f, 7.71753728e-01f, 5.87694943e-01f, -3.60945582e-01f, -6.02867901e-01f, -2.35831320e-01f, -4.62560058e-01f, 4.43419278e-01f,
  -2.32280120e-01f, 1.51528418e-01f, 3.26321018e-03f, 6.11996371e-03f, 1.12267330e-01f, -6.77521378e-02f, -1.77702438e-02f, 1.83221593e-01f, -2.04182267e-01f, 5.11331320e-01f,
  -3.23415905e-01f, -1.95935532e-01f, -3.00453275e-01f, -2.45468616e-01f, -1.16934463e-01f, -2.09573731e-01f, -2.60398656e-01f, 4.87974808e-02f, 1.07030548e-01f, -3.81224662e-01f,
  8.23923945e-02f, 1.27998546e-01f, 6.66224062e-02f, -1.56802714e-01f, 1.79393947e-01f, 2.91386098e-01f, 1.22777665e+00f, 3.45033377e-01f, -6.40701830e-01f, 1.16663411e-01f,
  4.50004846e-01f, 6.42084122e-01f, 3.33821148e-01f, 6.01430871e-02f, 1.29301008e-02f, -2.15305947e-02f, 1.15808025e-01f, -7.03539746e-03f, 2.17093244e-01f, 1.10855445e-01f,
  1.46199629e-01f, 3.16441536e-01f, 3.70728113e-02f, -6.16896331e-01f, 5.92471249e-02f, -2.19367146e-01f, 3.77177119e-01f, -9.06716064e-02f, 8.95429030e-02f, -2.83930004e-01f,
  3.90652210e-01f, 2.38384947e-01f, 1.46995649e-01f, -2.86800385e-01f, 1.60316303e-01f, 8.30872953e-02f, -2.87209034e-01f, 6.89211488e-01f, -1.70826375e-01f, 3.10204059e-01f,
  4.74742591e-01f, 5.71200132e-01f, 1.10348113e-01f, 5.56457400e-01f, 3.54003400e-01f, 2.54266948e-01f, 2.41036639e-01f, 5.50731309e-02f, 7.07244098e-01f, 2.03115210e-01f,
  4.75919217e-01f, 2.77653188e-01f, 4.17697757e-01f, 6.30849123e-01f, 2.61934102e-01f, 5.99389911e-01f, -2.53678352e-01f, 5.01131304e-02f, -7.42219448e-01f, 1.87475666e-01f,
  -2.72773117e-01f, -5.54445148e-01f, 4.84781623e-01f, -1.39550790e-01f, 1.04294926e-01f, 4.37966555e-01f, -1.47909522e-01f, 2.48798467e-02f, -7.87098631e-02f, 5.39652288e-01f,
  1.88222855e-01f, -3.10770810e-01f, 5.96393645e-01f, -4.20581996e-01f, -4.21175659e-02f, -5.55970550e-01f, -1.00075416e-01f, 3.35717320e-01f, 5.39300799e-01f, -1.17913997e-02f,
  4.54375297e-01f, 2.28960976e-01f, 2.71171689e-01f, 2.42418237e-02f, 4.02389020e-01f, -4.26064610e-01f, -8.67201760e-02f, -3.05555686e-02f, 2.52946764e-01f, -1.44886309e-02f,
  7.19275773e-01f, 7.32728913e-02f, 2.90198982e-01f, 7.37499356e-01f, 1.66777149e-01f, 4.02573459e-02f, 3.97581547e-01f, 3.54848474e-01f, -3.69218662e-02f, -5.34115314e-01f,
  9.92719457e-02f, 1.62817344e-01f, 1.15512006e-01f, 1.09092057e+00f, -4.25266922e-01f, 3.08255196e-01f, 7.32894003e-01f, -3.38665932e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  8.07032287e-01f, 4.15808797e-01f, 7.10931718e-01f, 2.15452328e-01f, 2.45307848e-01f, 3.56673032e-01f, 5.29622614e-01f, 1.89352185e-01f, 2.37616390e-01f, 3.70048970e-01f,
  8.79406482e-02f, 1.51137635e-01f, 6.79609299e-01f, 4.07779574e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -3.40656132e-01f, -6.98465779e-02f, -9.52704966e-01f, -8.19524944e-01f, 1.17825128e-01f, -5.48167944e-01f, -3.83391172e-01f, -1.09020986e-01f, 2.10289523e-01f, 1.71511054e-01f,
  -3.01744789e-01f, 4.21737850e-01f, 2.23289698e-01f, -4.55223083e-01f, 6.70785829e-02f, -3.22822154e-01f, -9.28896740e-02f, 3.74987572e-01f, 3.04000169e-01f, -2.20366895e-01f,
  -2.58513033e-01f, 1.57047257e-01f, 2.47704253e-01f, -8.45163047e-01f, 3.18610370e-01f, -2.74171501e-01f, -2.32001916e-01f, -4.07603234e-01f, -7.61355102e-01f, 4.59226936e-01f,
  -5.50727546e-01f, -1.67401269e-01f, 2.66422331e-01f, 4.22336757e-01f, 1.49513304e-01f, -8.35220218e-01f, -8.71502101e-01f, 3.60735729e-02f, -1.32731545e+00f, -4.11453098e-01f,
  -4.36627835e-01f, 6.77117556e-02f, -2.53687263e-01f, -1.59714937e-01f, -3.16345602e-01f, -1.06953174e-01f, -6.11384392e-01f, 2.19391897e-01f, -2.13534281e-01f, -8.52897644e-01f,
  2.17309922e-01f, -1.00147772e+00f, -1.00408983e+00f, 4.47812527e-01f, 1.17923640e-01f, 2.84777015e-01f, -1.93635523e-02f, 1.36355441e-02f, 6.31496608e-02f, -2.37780809e-01f,
  -8.00672695e-02f, 8.22182298e-02f, 2.06339464e-01f, -8.33080351e-01f, 5.65706659e-03f, 1.76233366e-01f, 1.51167929e-01f, -2.78788861e-02f, -6.16744813e-03f, -5.02595782e-01f,
  -3.98365915e-01f, 2.74411529e-01f, -2.62812823e-01f, -5.58160663e-01f, 8.20672452e-01f, 2.51519829e-01f, 1.44632440e-02f, -5.18008471e-01f, -2.43415192e-01f, 3.07979137e-01f,
  7.07098782e-01f, -7.18738511e-02f, -1.06024754e+00f, 2.60409892e-01f, -5.26950598e-01f, 1.67191830e-02f, -8.80376920e-02f, -5.24166346e-01f, 1.76202983e-01f, 5.09955525e-01f,
  1.96809098e-01f, -7.58191168e-01f, -4.10512298e-01f, -5.81486151e-02f, -1.75600778e-02f, 6.10758245e-01f, 3.12670842e-02f, -3.91361058e-01f, 3.12698036e-02f, -2.57666826e-01f,
  8.58437177e-03f, -2.67378241e-01f, -1.37357786e-01f, -1.82395145e-01f, 1.25984058e-01f, -4.28505272e-01f, 3.08367044e-01f, 1.72586679e-01f, 2.89461434e-01f, 6.37718320e-01f,
  -1.57681853e-01f, 9.15439501e-02f, -6.87115967e-01f, 2.06351876e-01f, 2.72455961e-02f, 4.05133784e-01f, -7.98859417e-01f, -8.04213703e-01f, -9.44870770e-01f, -1.64025053e-01f,
  1.46576554e-01f, -6.54534638e-01f, -5.26703537e-01f, -8.59764636e-01f, 7.04007447e-01f, 3.76590759e-01f, -1.15070510e+00f, 6.01253927e-01f, 3.60242426e-01f, 6.03573620e-01f,
  2.82303929e-01f, 1.10729396e+00f, 1.70775235e-01f, 5.29069364e-01f, 7.32723296e-01f, 1.54684573e-01f, -1.39092654e-01f, -5.06860375e-01f, 2.38117233e-01f, 5.00001788e-01f,
  -1.78900436e-02f, 8.14347029e-01f, -2.33656447e-02f, 9.34917629e-02f, 2.06116334e-01f, 1.53682008e-01f, 4.06155407e-01f, -2.45724842e-01f, -3.53725910e-01f, -3.31873715e-01f,
  4.50280569e-02f, -2.86126494e-01f, 2.26217836e-01f, -3.08806956e-01f, 1.67369097e-02f, 2.79693305e-01f, 5.25099635e-01f, -3.16020250e-01f, 1.59814030e-01f, -2.22081050e-01f,
  2.69417226e-01f, 2.22640768e-01f, 3.80251348e-01f, 7.93495327e-02f, 6.33560300e-01f, 3.82163376e-01f, 6.32248461e-01f, 1.62982002e-01f, 3.75326872e-01f, 3.67459983e-01f,
  -7.23524988e-02f, -4.27081168e-01f, 1.00580001e+00f, 5.12509942e-01f, 8.75134408e-01f, -4.70694482e-01f, -3.73052061e-01f, 9.24354613e-01f, -1.44891711e-02f, 2.74313033e-01f,
  5.47514200e-01f, 1.35127708e-01f, 4.23266217e-02f, 3.44376981e-01f, 1.48952603e-01f, -6.67178392e-01f, -3.61376345e-01f, -6.52197123e-01f, -5.15871286e-01f, -1.45259783e-01f,
  5.24543047e-01f, -9.68042076e-01f, 3.76121312e-01f, -5.47005475e-01f, 5.69758646e-04f, 7.43761286e-02f, 3.21687728e-01f, 1.16667636e-01f, 1.56705767e-01f, -6.62653148e-01f,
  3.45153064e-01f, 6.90207720e-01f, -1.02390420e+00f, -7.43745804e-01f, -3.51086766e-01f, -1.18380681e-01f, 3.86508144e-02f, 1.64067879e-01f, 2.14770079e-01f, -2.11669654e-01f,
  -4.14817840e-01f, -5.17217875e-01f, 7.33500242e-01f, -6.22207761e-01f, 3.86125475e-01f, -3.36803377e-01f, -7.65311718e-01f, 4.57191825e-01f, 3.76209199e-01f, 1.64811552e-01f,
  -1.04423828e-01f, -1.22965193e+00f, 2.42059931e-01f, -1.88780114e-01f, -4.49253052e-01f, -3.59299749e-01f, -3.80164355e-01f, -1.98583677e-01f, -1.39651895e-01f, 2.52303511e-01f,
  -3.89196903e-01f, -2.51449198e-01f, 1.61838364e-02f, -5.15194356e-01f, 1.94277674e-01f, -2.46029660e-01f, 4.16541621e-02f, 9.82087702e-02f, 5.53252578e-01f, 2.82655746e-01f,
  2.37529993e-01f, 3.84313077e-01f, -1.21175098e+00f, 3.18676800e-01f, 2.75881171e-01f, -1.02796860e-01f, -2.30934754e-01f, 1.91391394e-01f, -8.23158771e-02f, -2.79430211e-01f,
  1.82125136e-01f, 3.44836861e-01f, 5.83439112e-01f, 1.81716874e-01f, -6.24907017e-01f, -2.20918491e-01f, -1.06782757e-01f, 1.04350969e-01f, -7.68245757e-01f, 2.55572259e-01f,
  -4.76394981e-01f, 1.76962003e-01f, 1.79307967e-01f, 3.57173890e-01f, -5.90612352e-01f, 4.76691306e-01f, -8.77203703e-01f, 1.77623585e-01f, -1.51740804e-01f, -2.39879712e-01f,
  4.61952060e-01f, -2.88046718e-01f, 1.73128054e-01f, -4.97762114e-01f, -7.64251411e-01f, -2.56246835e-01f, -2.91267246e-01f, 2.29094744e-01f, -4.32378411e-01f, 4.15402800e-01f,
  -3.84222299e-01f, -4.76041138e-01f, 2.58245945e-01f, -1.46008074e-01f, -1.39282390e-01f, -4.45588678e-01f, -5.91865420e-01f, 8.21656585e-01f, -2.01606438e-01f, 1.74561277e-01f,
  5.09900510e-01f, 2.63280660e-01f, -1.34018064e-01f, -3.96048307e-01f, 1.97171673e-01f, 4.80828702e-01f, -1.02414355e-01f, -7.92749345e-01f, 1.08736408e+00f, 4.35170770e-01f,
  -6.85001194e-01f, -4.99621332e-01f, -5.84488094e-01f, -7.12059438e-02f, -1.25052286e-02f, 5.95201969e-01f, -1.06753302e+00f, -7.32803762e-01f, 4.78213519e-01f, -4.92048919e-01f,
  -1.42180994e-01f, -1.10203490e-01f, -2.76931107e-01f, 2.47157067e-01f, -3.16516042e-01f, 5.22023737e-01f, -2.27484882e-01f, 1.49533689e-01f, 6.47854507e-01f, -4.97866750e-01f,
  -5.18617369e-02f, -2.53999650e-01f, 3.22927952e-01f, -2.09199369e-01f, 4.90066677e-01f, 3.12250983e-02f, 2.18944103e-01f, -1.04640789e-01f, 1.93394942e-03f, 5.92646897e-01f,
  7.62606800e-01f, -4.31960642e-01f, 3.36208254e-01f, 9.00265574e-02f, 6.13642335e-01f, 2.26481333e-01f, -6.17783189e-01f, -5.32017529e-01f, 5.35062253e-01f, -3.82240295e-01f,
  -5.15027083e-02f, 5.36202729e-01f, -9.56926823e-01f, -1.04549623e+00f, -1.17562497e+00f, -7.37488091e-01f, 3.82190675e-01f, -2.85890490e-01f, 4.39605325e-01f, 1.22450627e-01f,
  1.68793306e-01f, 4.95936036e-01f, -1.77263424e-01f, -3.74053955e-01f, 3.23368222e-01f, -1.53558915e-02f, 9.58920270e-02f, -3.00826639e-01f, 3.03370148e-01f, 2.38746777e-02f,
  -5.00432365e-02f, 8.53273749e-01f, -5.96900880e-01f, 1.36501044e-01f, -3.05176854e-01f, -7.92111829e-02f, -6.31135643e-01f, -2.40082934e-01f, -6.86767176e-02f, -5.14159143e-01f,
  -5.47013819e-01f, 9.97607529e-01f, -4.82786030e-01f, -2.81886280e-01f, 3.35259169e-01f, 3.39746892e-01f, -4.95831698e-01f, 3.05240452e-01f, -8.90977561e-01f, 5.31876385e-01f,
  -2.65916824e-01f, 2.14003816e-01f, -7.98142910e-01f, -9.03716922e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.57153332e-01f, 6.92060739e-02f, 3.17688227e-01f, -5.51541336e-02f, 1.98069751e-01f, 1.35679364e-01f, 4.47914340e-02f, -2.27377832e-01f, 1.48253947e-01f, 3.30871604e-02f,
  1.39332354e-01f, -6.93872124e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    