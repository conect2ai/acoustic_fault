/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.76246807e-02f, -2.70869378e-02f, 1.54803559e-01f, 1.18234925e-01f, 5.45868650e-02f, 4.45280552e-01f, 3.46214026e-01f, -1.10928982e-01f, 1.79996654e-01f, 5.74003607e-02f,
  1.27912778e-02f, 2.25324571e-01f, -2.20610231e-01f, 3.53385895e-01f, 2.40389898e-01f, -2.23832913e-02f, 2.96478212e-01f, 4.97357026e-02f, -1.04220711e-01f, -1.39180586e-01f,
  -1.98743194e-02f, 5.99620752e-02f, 6.16336465e-02f, -9.06825066e-02f, -3.16923037e-02f, -1.45814210e-01f, -2.36905083e-01f, -1.18249990e-01f, 7.07048038e-03f, 1.45408079e-01f,
  2.97933575e-02f, -1.71756327e-01f, 1.46989375e-01f, 6.42452762e-02f, 4.78463210e-02f, 2.34068912e-02f, -2.76888348e-02f, 3.43091190e-02f, -1.25598498e-02f, 8.37356150e-02f,
  2.85853748e-05f, 1.35357759e-03f, 5.99549003e-02f, 1.04546823e-01f, 6.03803694e-02f, 6.10342585e-02f, -2.02210695e-02f, 5.30848727e-02f, -5.45029677e-02f, -4.91658822e-02f,
  1.75981421e-03f, -3.26492973e-02f, -6.76374733e-02f, 3.93255390e-02f, 3.86545770e-02f, -1.04103014e-02f, -5.01654930e-02f, -3.54136573e-03f, -7.39295967e-03f, 3.95186432e-02f,
  -6.13233969e-02f, -6.86156899e-02f, -3.19385193e-02f, -2.86873896e-02f, 1.49243847e-02f, -8.52146074e-02f, -1.73799116e-02f, 5.63084055e-03f, 5.17356582e-02f, -9.42570269e-02f,
  1.15164379e-02f, 3.74694876e-02f, -4.04247493e-02f, 4.53789458e-02f, 3.96743305e-02f, -1.73340902e-01f, -6.09278232e-02f, 4.81636450e-03f, 7.78080374e-02f, -3.79102826e-02f,
  -1.22125829e-02f, 1.58251598e-02f, 7.16399252e-02f, -1.42182475e-02f, -1.03750117e-02f, 8.66055563e-02f, 4.41019200e-02f, -4.86505032e-02f, -5.24610654e-03f, 1.49923582e-02f,
  -1.26384676e-01f, -2.80954480e-01f, -8.05021450e-02f, -7.42008910e-03f, -5.32411179e-03f, 7.71978125e-02f, -8.82196520e-03f, 1.55283622e-02f, 1.82542074e-02f, -4.22235988e-02f,
  -7.90683087e-03f, -2.76175067e-02f, -1.46550462e-01f, -2.70288642e-02f, 6.14323243e-02f, 4.80062030e-02f, -4.70336527e-02f, 5.47615327e-02f, 5.64639010e-02f, -1.04584470e-01f,
  -5.54629602e-02f, -7.71386251e-02f, 7.72336498e-02f, -9.51140281e-03f, 1.41019952e-02f, -2.73168180e-02f, 4.71130237e-02f, -1.24398218e-02f, 1.28569617e-03f, -2.69927699e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.88822317e-01f, 2.81736046e-01f, -6.12503707e-01f, 8.92512947e-02f, 7.53026903e-02f, 3.12115967e-01f, 1.49625102e-02f, 1.04397886e-01f, -3.13381642e-01f, 1.34789869e-01f,
  1.85502112e-01f, -2.78754681e-01f, -1.46639735e-01f, 4.69641179e-01f, -2.10194349e-01f, 1.35117635e-01f, 7.12440535e-02f, 1.02982454e-01f, 5.53637482e-02f, -4.63258736e-02f,
  4.97763185e-03f, 6.20279551e-01f, -2.47501712e-02f, 3.29634935e-01f, -1.37039544e-02f, -1.04928978e-01f, -6.60892501e-02f, -1.62758783e-01f, 2.22384080e-01f, 2.52870824e-02f,
  7.70260021e-02f, -3.40915173e-01f, -8.77775103e-02f, -2.42422447e-01f, -1.31605729e-01f, -9.81384665e-02f, -1.32951543e-01f, -9.33120251e-02f, 3.41834649e-02f, -8.50420073e-02f,
  -1.10913433e-01f, 2.85980999e-02f, 1.94973294e-02f, 1.95722301e-02f, 6.07372224e-02f, 7.76346028e-02f, 7.06555694e-02f, 4.22387421e-02f, 6.02550842e-02f, 4.26583029e-02f,
  2.69844290e-03f, 7.62073398e-02f, -1.05820499e-01f, 4.37297784e-02f, 4.02640644e-03f, 2.87653171e-02f, 8.19003955e-03f, 1.63393619e-03f, 1.00019895e-01f, 7.18424693e-02f,
  1.11696068e-02f, -9.88322422e-02f, -8.89276490e-02f, 9.61383618e-03f, 1.58407595e-02f, 9.90237202e-03f, 3.10197715e-02f, -5.20935357e-02f, -5.48879728e-02f, 3.93293425e-02f,
  -3.34592946e-02f, 3.72372530e-02f, -5.82371354e-02f, -4.13980745e-02f, 5.71720749e-02f, -4.36846130e-02f, -6.43878058e-02f, 6.61294907e-02f, -7.44678900e-02f, 6.33392558e-02f,
  -2.27182191e-02f, -8.47536512e-03f, 2.42568851e-02f, 2.58331690e-02f, -1.88907180e-02f, -6.48951065e-03f, -6.93497211e-02f, -3.72989960e-02f, -2.99845058e-02f, -3.16744894e-02f,
  8.04512203e-02f, -3.84165943e-01f, 3.45110544e-03f, -8.53291154e-02f, 7.78380875e-03f, 4.02437001e-02f, -9.30678919e-02f, 2.00318638e-02f, -4.63033691e-02f, -1.05974376e-01f,
  1.92468818e-02f, 5.45256026e-02f, 1.87189132e-02f, 1.95118431e-02f, -2.65572127e-02f, 5.78871109e-02f, -7.79384300e-02f, -8.19074586e-02f, 2.84276605e-02f, -4.01691608e-02f,
  -2.46636830e-02f, -3.77400033e-02f, 8.24668852e-04f, 7.62704462e-02f, -6.13595620e-02f, -5.31730130e-02f, 6.68337420e-02f, -9.56753194e-02f, -4.82837036e-02f, -6.44591227e-02f,
  3.55024040e-01f, -1.15259372e-01f, -1.24635428e-01f, -5.99092059e-03f, -2.99214805e-03f, -1.71521693e-01f, -2.61563629e-01f, 8.25174451e-02f, -3.68189067e-01f, 5.18184640e-02f,
  3.91272828e-02f, 1.06514953e-02f, -2.77132280e-02f, -2.60792896e-02f, 4.68967631e-02f, -2.17220306e-01f, 3.89698632e-02f, 6.82101399e-02f, -1.33662730e-01f, 3.19959462e-01f,
  1.60724074e-01f, 2.20905930e-01f, 1.11137383e-01f, 1.68594822e-01f, 2.81773619e-02f, 2.76771337e-01f, 5.06937981e-01f, 9.77879092e-02f, 3.03656667e-01f, -4.20341156e-02f,
  -1.65176049e-01f, -1.13296613e-01f, -6.60661310e-02f, -1.28995880e-01f, 1.49944350e-01f, 2.33021434e-02f, 9.01911035e-02f, -1.72019854e-01f, -1.42130896e-01f, 4.25288733e-03f,
  5.57295373e-03f, 4.55551669e-02f, -1.21553890e-01f, 4.10013944e-02f, -6.31915554e-02f, 5.91257885e-02f, 5.16845807e-02f, -5.70562221e-02f, 3.76649946e-02f, 1.47628197e-02f,
  -3.63470465e-02f, -5.52276783e-02f, 4.70074825e-02f, 9.88915488e-02f, -2.88326405e-02f, 5.09104356e-02f, 3.38297859e-02f, 1.23625295e-02f, -5.80501817e-02f, -1.70684978e-02f,
  9.31480154e-02f, -4.58190218e-02f, -1.61060765e-02f, -1.81567624e-01f, 1.09798446e-01f, -2.92152148e-02f, -4.62928116e-02f, 1.34436423e-02f, 5.98129779e-02f, 1.38055801e-01f,
  1.03816234e-01f, 3.85051556e-02f, -2.52737086e-02f, -7.03168362e-02f, 5.81438504e-02f, -7.64632672e-02f, -2.33280901e-02f, 2.70091482e-02f, 3.94189358e-02f, -4.94090561e-03f,
  -1.36234224e-01f, 1.07653841e-01f, 9.22769755e-02f, -5.02970107e-02f, 1.52535213e-03f, 1.42458780e-02f, -1.98380724e-02f, 3.52897658e-03f, -4.46109101e-02f, -1.32039502e-01f,
  7.43644387e-02f, 2.58350909e-01f, 8.40761699e-03f, -4.98324819e-02f, 5.62412404e-02f, 3.70018966e-02f, -1.59149364e-01f, 7.49461204e-02f, 8.41658860e-02f, 1.15121953e-01f,
  1.46468490e-01f, -7.72312284e-02f, 2.63555031e-02f, 2.62051616e-02f, -3.05175725e-02f, 1.00723729e-01f, 6.61897659e-02f, 3.10031679e-02f, 1.21981233e-01f, 1.20213628e-01f,
  6.18525743e-02f, -1.31096533e-02f, 9.74615291e-02f, -7.78794214e-02f, -6.32756427e-02f, 1.03677198e-01f, 1.72722235e-01f, 1.78384244e-01f, -1.46638947e-02f, -7.55698308e-02f,
  2.02883288e-01f, -2.89681971e-01f, -2.02018827e-01f, 8.19610357e-02f, 1.39996745e-02f, -1.72389641e-01f, -1.23476669e-01f, 1.16516873e-01f, -1.91785187e-01f, -4.14472781e-02f,
  -4.50427122e-02f, -5.72258353e-01f, -1.73122227e-01f, -3.94638956e-01f, -2.94274129e-02f, -3.83538187e-01f, -9.44392085e-02f, -1.87640056e-01f, -5.04224338e-02f, -1.83397204e-01f,
  5.82622513e-02f, -1.05212212e-01f, -6.58236891e-02f, 1.81991234e-01f, 2.66621053e-01f, 2.65794098e-01f, 4.10400808e-01f, 6.91886768e-02f, 1.88500211e-01f, -9.20747779e-03f,
  -1.93333000e-01f, -1.89330950e-01f, 4.31487104e-03f, 4.43599597e-02f, 2.69588958e-02f, 1.08982623e-01f, 1.22932851e-01f, -1.43329754e-01f, -6.23627827e-02f, -5.87579645e-02f,
  -5.96442446e-02f, 6.87749833e-02f, -2.15979889e-02f, -4.07459289e-02f, -4.69987504e-02f, 2.91229784e-02f, -3.04111410e-02f, 1.26218840e-01f, -1.15089029e-01f, -1.95447743e-01f,
  -3.86194885e-02f, -6.93754405e-02f, 4.28023227e-02f, 1.74926847e-01f, 1.68094188e-01f, -6.21391693e-03f, -9.18516442e-02f, 1.21147726e-02f, 1.36367664e-01f, -5.21121137e-02f,
  2.46610194e-02f, 1.38527691e-01f, -2.77235992e-02f, 6.15328550e-03f, 3.05126179e-02f, 5.25795296e-02f, -5.18758446e-02f, 1.29492223e-01f, 1.71580329e-03f, 7.32949469e-03f,
  4.72035445e-02f, -9.12145153e-02f, -7.30500966e-02f, 1.58786643e-02f, -3.67229767e-02f, 7.48263225e-02f, -8.65556952e-03f, 7.92880431e-02f, 1.96410809e-02f, -4.09702472e-02f,
  -2.51045618e-02f, 9.10564810e-02f, -3.55060846e-02f, 4.72192690e-02f, -4.82912175e-02f, 3.32657285e-02f, 1.33599238e-02f, -6.66246414e-02f, 1.47320395e-02f, 1.31967783e-01f,
  6.72317743e-02f, 1.87935606e-01f, -1.09345913e-01f, 3.06754634e-02f, -6.52746782e-02f, 1.43440902e-01f, -2.38341823e-01f, 4.21671569e-02f, -4.56751920e-02f, 4.27632481e-02f,
  7.41409957e-02f, 4.90420721e-02f, 1.98817700e-01f, -1.03192903e-01f, 1.60796996e-02f, -5.07164863e-04f, 4.30874974e-02f, 7.63078183e-02f, 1.25690147e-01f, 7.96221197e-02f,
  1.13190942e-01f, -1.35214269e-01f, 1.37093104e-02f, 1.37787789e-01f, 1.67432889e-01f, 3.12671289e-02f, -2.51170248e-02f, 7.18185678e-02f, 2.12523583e-02f, -4.46329527e-02f,
  -2.86060750e-01f, 5.95132053e-01f, -6.18686005e-02f, 3.03513855e-01f, -2.08170369e-01f, 4.69212532e-01f, 3.25101256e-01f, 1.03241548e-01f, 3.52281779e-01f, 4.13006395e-01f,
  1.02510773e-01f, 8.86336938e-02f, 2.77602166e-01f, 4.14547533e-01f, 1.85514748e-01f, 3.26094031e-01f, 3.92962068e-01f, 2.71835357e-01f, -1.38570458e-01f, 2.58778423e-01f,
  -9.60390717e-02f, 1.80863753e-01f, -1.05614595e-01f, -3.17375451e-01f, -2.68297642e-01f, -4.58194077e-01f, -2.03789413e-01f, -3.59981269e-01f, -1.17388442e-01f, 8.13087728e-03f,
  -7.49975592e-02f, 5.95475920e-02f, -1.30886331e-01f, -8.88943449e-02f, 2.26681922e-02f, -4.77400310e-02f, -5.96478805e-02f, -1.44963905e-01f, -9.77202319e-03f, 3.94798405e-02f,
  5.97186433e-03f, -9.65850130e-02f, 5.82786165e-02f, -1.43429011e-01f, -4.01097201e-02f, -4.99081612e-02f, -6.44837096e-02f, -1.77665185e-02f, 6.44487068e-02f, -1.37970597e-01f,
  2.80375872e-02f, 1.87336504e-02f, 1.76977664e-02f, 7.38977194e-02f, -6.74320012e-02f, 4.96344119e-02f, 2.40229085e-01f, 5.82776219e-03f, -7.03245355e-03f, 1.60631046e-01f,
  -5.17366966e-03f, 1.26057640e-01f, 9.73596275e-02f, -1.34919688e-01f, -7.67119648e-03f, -1.11807942e-01f, 1.05940066e-02f, -1.34058781e-02f, -4.35280576e-02f, 1.50433436e-01f,
  1.08255021e-01f, 3.48228775e-02f, -3.53466196e-04f, -1.16197683e-01f, 9.78641808e-02f, 6.10413998e-02f, 4.44387458e-02f, -7.63249993e-02f, 4.99739237e-02f, 8.97458196e-03f,
  1.26910567e-01f, 9.06218439e-02f, -4.47995104e-02f, 4.46561798e-02f, 2.20580660e-02f, 3.10898051e-02f, -2.42410805e-02f, 1.59803070e-02f, -4.10601720e-02f, -2.44811457e-02f,
  3.41789395e-01f, 3.79820347e-01f, 1.20635666e-01f, 5.79501539e-02f, -3.19909528e-02f, -5.50227910e-02f, -3.16272466e-03f, 7.75525123e-02f, 9.89196822e-02f, 7.91162848e-02f,
  2.02505593e-03f, 3.50635499e-02f, -1.04246335e-02f, -2.00382292e-01f, -4.98877354e-02f, 1.37118235e-01f, -8.01034458e-03f, 4.34393249e-02f, 1.49706289e-01f, -8.41600671e-02f,
  5.21984845e-02f, 7.28037283e-02f, 4.94401380e-02f, -3.43257189e-02f, 1.78499460e-01f, 7.34988600e-02f, 2.27294229e-02f, -4.38369848e-02f, 2.23589446e-02f, 1.47985160e-01f,
  7.68390775e-01f, -2.60576364e-02f, 4.50680226e-01f, 6.64693177e-01f, 1.66075051e-01f, -1.75462678e-01f, 3.40206027e-01f, 1.35468528e-01f, 7.65717685e-01f, -2.32098833e-01f,
  -4.91610616e-02f, 8.33475068e-02f, -5.40593006e-02f, 7.48245791e-02f, 1.91850334e-01f, -2.36059308e-01f, 1.76515490e-01f, 1.44284680e-01f, 2.08566815e-01f, 2.37753764e-01f,
  2.88997263e-01f, -5.15555926e-02f, 1.64635724e-03f, -3.45116079e-01f, 1.86141118e-01f, 1.26409397e-01f, -1.42834350e-01f, -1.32604674e-01f, -2.99550474e-01f, -3.11387450e-01f,
  -9.22720879e-03f, 3.28592472e-02f, -1.11890242e-01f, -6.10883757e-02f, 3.15742716e-02f, -1.35739014e-01f, -2.27089822e-01f, -1.15768760e-01f, 1.37029245e-01f, -2.00800020e-02f,
  -3.31893973e-02f, 3.00664697e-02f, -7.03041488e-03f, 5.80612272e-02f, 4.96580936e-02f, 8.25103745e-02f, 8.06032717e-02f, 4.64435853e-02f, 5.76823540e-02f, 1.06322847e-01f,
  9.73426625e-02f, 2.63538882e-02f, 5.00824600e-02f, -7.56349713e-02f, -9.87075642e-02f, 1.33383670e-03f, -3.15801464e-02f, -4.79503907e-02f, -7.94736370e-02f, -6.26483113e-02f,
  -1.17696337e-01f, -7.79334828e-02f, -2.47721877e-02f, 7.34157860e-02f, 5.32086529e-02f, 1.78659096e-01f, -2.02438366e-02f, -7.01497868e-02f, -3.01302336e-02f, 4.07987610e-02f,
  7.60504082e-02f, 5.33327796e-02f, 6.05110787e-02f, 1.18731327e-01f, 1.79166161e-02f, 4.83445339e-02f, -2.08808221e-02f, -7.93934241e-02f, -3.20006697e-03f, -4.55092713e-02f,
  1.12158328e-01f, 5.66917807e-02f, 6.76122634e-03f, 6.86641410e-03f, -5.95149994e-02f, 5.48674725e-03f, -9.05293673e-02f, -3.77678461e-02f, 1.07312612e-01f, -8.18216950e-02f,
  -7.00870231e-02f, -4.95727919e-02f, -8.03721547e-02f, 1.52732795e-02f, 2.95509715e-02f, -2.41132379e-02f, 4.68671955e-02f, 1.01241268e-01f, 4.99582402e-02f, -8.75479821e-03f,
  -9.60218236e-02f, 5.51520139e-02f, -4.84493934e-02f, 8.80330354e-02f, -5.71481548e-02f, 1.67077184e-02f, -8.53994512e-04f, -6.88777715e-02f, -1.54663541e-03f, -1.07939653e-01f,
  -3.98981050e-02f, 6.98535442e-02f, -1.86453369e-02f, 1.14348456e-01f, -1.12612046e-01f, -8.03246871e-02f, -8.82716477e-03f, -1.00262798e-01f, -1.27933592e-01f, -5.96087798e-02f,
  -3.03434908e-01f, 6.52401030e-01f, 1.26987308e-01f, -1.89121440e-02f, -9.44874994e-03f, -2.35932246e-01f, -2.42672563e-01f, 1.05673999e-01f, 2.20214650e-02f, 4.12923634e-01f,
  -5.32478690e-02f, 2.60273993e-01f, -1.77611560e-01f, -1.57123029e-01f, -1.06617141e+00f, -4.73209441e-01f, -4.47722048e-01f, -2.14560047e-01f, -1.40386999e-01f, 5.54684177e-02f,
  -3.02242815e-01f, -3.09473336e-01f, -3.24846536e-01f, 1.03376597e-01f, 2.76606888e-01f, 3.68844062e-01f, -1.50064170e-01f, 1.75698236e-01f, 2.67210186e-01f, -5.32912575e-02f,
  2.68440265e-02f, 2.10670993e-01f, 1.46161556e-01f, 4.32569124e-02f, -1.70461848e-01f, 2.39843596e-02f, 5.01282811e-02f, -9.86632407e-02f, -8.68597708e-04f, 5.08680716e-02f,
  6.06215075e-02f, 1.60995889e-02f, 1.78074918e-03f, -2.39705741e-02f, 1.02165997e-01f, 6.79580942e-02f, 8.30969587e-02f, -4.55144346e-02f, 1.30183592e-01f, 8.85535255e-02f,
  2.06881762e-02f, 3.26205343e-02f, 6.56417012e-02f, 2.56147981e-02f, 9.41538485e-04f, 5.66387028e-02f, -2.14704238e-02f, 5.05408905e-02f, -8.94873496e-03f, 4.31083515e-02f,
  -5.66585176e-02f, -6.08167462e-02f, -7.57237524e-02f, 9.52686444e-02f, -2.31930818e-02f, 6.09616339e-02f, -8.81820917e-02f, 3.97604378e-03f, 2.21973551e-06f, 3.05450931e-02f,
  -7.07719401e-02f, 4.26101685e-02f, 9.81075969e-03f, -3.17461044e-02f, -4.84452583e-02f, 7.61633515e-02f, -1.26532361e-01f, 6.53826445e-02f, -5.55196106e-02f, -2.62083560e-02f,
  2.59793717e-02f, -5.36346175e-02f, 1.20330164e-02f, -5.38675003e-02f, -4.74056825e-02f, -1.80823007e-03f, 6.43221736e-02f, 1.39370009e-01f, -8.56997520e-02f, -9.41594020e-02f,
  -2.93095589e-01f, -1.24176487e-01f, 2.21079774e-02f, 1.17865607e-01f, 9.63161066e-02f, 3.01234471e-03f, -1.00571960e-01f, 2.53855400e-02f, -7.44492859e-02f, 2.06000712e-02f,
  6.62210882e-02f, -2.16388088e-02f, -7.55545944e-02f, -2.48184223e-02f, -4.90693338e-02f, -8.84514898e-02f, -6.57651275e-02f, 4.99401875e-02f, 9.27678347e-02f, -4.63288054e-02f,
  1.29934698e-01f, 5.66763505e-02f, 4.09735814e-02f, -5.68349138e-02f, -4.20304388e-03f, 1.30787203e-02f, 2.15044362e-03f, 8.68666321e-02f, -4.43264320e-02f, -7.56589025e-02f,
  -1.14467371e+00f, 6.09766006e-01f, 1.96210444e-01f, 1.67438388e-01f, -1.91998139e-01f, 5.35524666e-01f, 3.29689056e-01f, 3.97606604e-02f, 2.32321337e-01f, 3.29079181e-01f,
  -8.21494237e-02f, -3.01693827e-02f, 4.34082076e-02f, 2.41248861e-01f, 5.52532310e-03f, 3.05079728e-01f, 9.42438021e-02f, -1.96474493e-02f, 1.94837615e-01f, -1.15953155e-01f,
  -6.72041019e-03f, 5.67817762e-02f, 6.24095201e-02f, 1.08065277e-01f, -4.64627519e-02f, -7.70388031e-03f, -2.57508636e-01f, 1.80876032e-01f, 3.31088342e-02f, 5.42717502e-02f,
  -4.60779041e-01f, -2.82800406e-01f, -3.00678939e-01f, -6.19069152e-02f, -6.11231551e-02f, -1.69015139e-01f, 3.81050073e-02f, -9.34000406e-03f, -1.19916320e-01f, 5.71674556e-02f,
  7.26571714e-04f, 4.31543067e-02f, -7.12869363e-03f, 1.99702475e-02f, 5.16440682e-02f, -2.88244877e-02f, 4.63734046e-02f, -1.22691477e-02f, 2.09087357e-02f, 6.45592436e-02f,
  9.53539833e-02f, 8.54019076e-02f, 3.65518183e-02f, 2.75993198e-02f, -5.95060103e-02f, 6.21878766e-02f, 7.36507550e-02f, -3.90310064e-02f, 4.96609658e-02f, 9.86622274e-02f,
  -4.42428514e-02f, 1.20977946e-01f, -7.29512870e-02f, -1.06926505e-02f, 9.48415324e-02f, -6.21715486e-02f, 4.24411967e-02f, -5.27749248e-02f, 8.88543651e-02f, -1.25788124e-02f,
  -1.20341226e-01f, 2.69224867e-02f, -1.88547000e-01f, 6.95893541e-02f, 7.21380720e-03f, 1.70928594e-02f, -2.98665147e-02f, 4.20197323e-02f, 5.55388294e-02f, -6.03515003e-03f,
  3.45253199e-02f, 7.78841367e-03f, -7.12913498e-02f, 2.42189150e-02f, 3.01040001e-02f, -4.31177504e-02f, 1.12378167e-03f, 3.01643144e-02f, -3.41809988e-02f, -6.09348528e-02f,
  2.23949462e-01f, 2.94712484e-02f, -7.80416653e-02f, -1.29214197e-01f, -3.02134212e-02f, -5.24132997e-02f, -2.92119402e-02f, 4.08383869e-02f, 1.64661556e-01f, -5.40973730e-02f,
  -8.81555304e-02f, -4.24735025e-02f, -5.97567745e-02f, 1.01672277e-01f, 1.15222499e-01f, 3.88948470e-02f, 3.18646915e-02f, -6.85750321e-02f, -3.11471988e-02f, 4.97051068e-02f,
  -2.04653963e-02f, -2.57554930e-02f, 4.83127572e-02f, -1.24003671e-01f, -9.11920443e-02f, -7.75322095e-02f, -1.59517944e-01f, 1.55585622e-02f, -5.64184822e-02f, 3.66660841e-02f,
  3.14584933e-02f, -1.48092970e-01f, 1.83490306e-01f, -5.38990080e-01f, -3.60005856e-01f, 3.10912848e-01f, 3.70710284e-01f, -2.64008015e-01f, -6.45046115e-01f, -8.28251615e-02f,
  -4.50256616e-02f, -1.99617207e-01f, 6.48091555e-01f, 4.78943996e-02f, 4.72310930e-01f, 5.40819645e-01f, 1.49664566e-01f, 1.60025477e-01f, -4.46751080e-02f, 1.01189055e-01f,
  -1.01838566e-01f, -3.35036814e-02f, 4.49629188e-01f, -2.68582385e-02f, 8.68928432e-02f, -1.40282542e-01f, -1.09031484e-01f, 1.76297650e-01f, -1.75509408e-01f, -2.12565903e-02f,
  1.47721440e-01f, 2.23710183e-02f, 1.28986895e-01f, 9.05308276e-02f, 1.10084064e-01f, 5.69102056e-02f, 1.85901791e-01f, 1.95587561e-01f, -1.16744213e-01f, 1.96754821e-02f,
  4.00671624e-02f, -1.22702837e-01f, -3.78384963e-02f, -1.80230349e-01f, -1.95614085e-01f, -5.04201688e-02f, -2.02475235e-01f, 4.18757088e-02f, 5.26709075e-04f, 4.37145755e-02f,
  1.31961912e-01f, -8.77101272e-02f, -4.81294654e-02f, -7.33823106e-02f, -6.45311326e-02f, -1.13025986e-01f, 4.03430909e-02f, 1.59980744e-01f, 2.18679309e-02f, -2.19528466e-01f,
  4.83807214e-02f, 4.29951772e-02f, 9.02566910e-02f, -1.72483698e-02f, 2.55876761e-02f, -5.67517616e-02f, 1.23575233e-01f, 6.84761554e-02f, -1.39386818e-01f, 4.89359312e-02f,
  6.43465891e-02f, -1.06044486e-01f, -8.72842444e-04f, -6.87014014e-02f, -1.29348114e-01f, 9.33456235e-03f, 9.38165262e-02f, -4.62262109e-02f, -9.42329541e-02f, -2.73580719e-02f,
  -1.87856227e-01f, -3.71922068e-02f, 2.98325215e-02f, -3.83032560e-02f, 6.42132908e-02f, -4.20307517e-02f, -6.16475679e-02f, -4.63621244e-02f, 1.39618754e-01f, 1.44551113e-01f,
  5.56801036e-02f, -2.08387107e-01f, -7.32084876e-03f, -3.05002742e-02f, 2.47180238e-02f, 8.11316445e-02f, 2.80249920e-02f, -1.16956607e-02f, 1.38863930e-02f, 7.16111436e-02f,
  -5.36356457e-02f, -5.80434268e-03f, 1.90117769e-02f, -2.04590801e-02f, -2.39826050e-02f, -3.04233041e-02f, 1.63247526e-01f, -1.45152621e-02f, -1.12854272e-01f, -7.34764338e-02f,
  -2.51290463e-02f, 1.16763584e-01f, -2.55722739e-02f, 1.26875505e-01f, -1.63380429e-01f, 1.12587832e-01f, -8.94809440e-02f, 5.60447164e-02f, -1.65657550e-02f, -3.62820253e-02f,
  5.43971717e-01f, -4.99632627e-01f, 2.56361753e-01f, 2.93096900e-01f, 3.00812393e-01f, 3.33105534e-01f, 3.98258328e-01f, -2.39969626e-01f, -2.61571229e-01f, -4.87859935e-01f,
  -1.47143841e-01f, 2.46925250e-01f, -3.87077928e-01f, 3.41872312e-02f, 2.82227308e-01f, -1.39234602e-01f, 6.52643070e-02f, 3.71675380e-02f, -1.31948903e-01f, -5.49298078e-02f,
  1.58981699e-02f, 6.34225160e-02f, 1.67843893e-01f, -1.99668854e-01f, 1.31275162e-01f, -4.37145121e-02f, -1.42562404e-01f, 1.16359383e-01f, 1.79006681e-01f, 3.84671360e-01f,
  -1.51476786e-01f, -2.48719066e-01f, -4.31118859e-03f, -1.38322324e-01f, -1.76122636e-01f, -1.87874828e-02f, 6.64564893e-02f, 1.89361811e-01f, -3.14176083e-02f, -1.12537164e-02f,
  3.17140259e-02f, 8.69078860e-02f, 8.09539407e-02f, -7.07468856e-03f, 1.62495635e-02f, 3.27113792e-02f, 2.63734143e-02f, -4.79888879e-02f, 5.87065332e-02f, -3.47568393e-02f,
  -5.46131544e-02f, 6.87067863e-03f, -8.51452723e-02f, 8.71382728e-02f, 4.63019721e-02f, 5.03748208e-02f, 1.47685796e-01f, 2.11391374e-01f, 4.34812643e-02f, 3.79064828e-02f,
  1.80590466e-01f, 4.07476947e-02f, -7.93374609e-03f, -9.70777124e-02f, 4.10053134e-02f, -3.42838131e-02f, -2.35752985e-02f, -2.52982751e-02f, 1.02270946e-01f, 1.64881479e-02f,
  -3.83712463e-02f, 5.02272556e-03f, -2.93710083e-02f, -1.11055814e-01f, 1.55472588e-02f, 3.98160964e-02f, 9.09240991e-02f, 4.04932648e-02f, 4.52012047e-02f, 5.99718243e-02f,
  -3.41972001e-02f, 1.39319221e-03f, -2.68570650e-02f, 3.20193619e-02f, 5.21957688e-02f, -1.11897448e-02f, -1.20106861e-01f, 8.80014077e-02f, -8.54117200e-02f, -2.01648083e-02f,
  -8.58912826e-01f, -6.12374663e-01f, -1.36994511e-01f, -1.30906656e-01f, -3.85302454e-02f, -4.29814942e-02f, 2.04695109e-02f, -5.15383529e-03f, -2.27640897e-01f, -4.60747816e-03f,
  -1.87887326e-02f, 5.73072955e-02f, -4.47042566e-03f, 1.16779476e-01f, 3.23869139e-02f, -2.02883929e-01f, 9.59189702e-03f, -1.13472991e-01f, -1.02357619e-01f, -6.66191354e-02f,
  -7.05435574e-02f, -2.17856672e-02f, 7.80660212e-02f, -3.65419872e-03f, -1.14657404e-02f, 7.69624934e-02f, -3.48993428e-02f, 2.63532810e-02f, 1.91537123e-02f, 3.11460551e-02f,
  2.92795688e-01f, 3.91543597e-01f, 3.06429803e-01f, 4.16139722e-01f, -2.81386208e-02f, -4.45213437e-01f, -1.68790892e-01f, 2.90980875e-01f, -1.28014460e-01f, -2.90910136e-02f,
  2.58705695e-03f, 2.80653358e-01f, -3.92076969e-01f, 7.54049793e-02f, -1.30359113e-01f, -3.02251130e-01f, 8.31295997e-02f, -4.48924452e-02f, -8.13601837e-02f, 2.08405733e-01f,
  1.65868640e-01f, 1.46183372e-01f, 4.67249095e-01f, 2.81754822e-01f, 2.32114747e-01f, 4.87542599e-01f, 2.28385061e-01f, 1.50298262e-02f, 5.37528038e-01f, -5.57924286e-02f,
  -1.23902127e-01f, 5.34876995e-02f, 1.67745858e-01f, -1.52739316e-01f, 9.86701101e-02f, 4.14573774e-02f, 2.25749216e-03f, -1.44272596e-01f, 3.07161100e-02f, 1.94617291e-03f,
  2.70420946e-02f, -6.77472055e-02f, -6.84040075e-04f, -9.66613740e-02f, 1.24638695e-02f, 5.90499416e-02f, 2.94911228e-02f, 1.43712670e-01f, 7.16668293e-02f, 9.17545035e-02f,
  2.99985349e-01f, 3.45057882e-02f, 7.38754719e-02f, -4.10447940e-02f, 1.26647875e-01f, -4.84926142e-02f, 1.54902125e-02f, 1.05282314e-01f, 2.01634437e-01f, 1.38084531e-01f,
  2.34996498e-01f, 2.81988773e-02f, -9.17643160e-02f, 2.19810195e-02f, 4.67860214e-02f, -6.78904802e-02f, 6.42082766e-02f, 2.06345469e-02f, -2.23902408e-02f, -6.43125251e-02f,
  7.67333107e-03f, 8.61969292e-02f, -8.94873440e-02f, -1.00050665e-01f, 9.42774490e-02f, -8.58738050e-02f, -5.57075404e-02f, -1.71947151e-01f, -2.56700963e-02f, 1.04892969e-01f,
  -1.70037121e-01f, -8.47536251e-02f, 5.76290339e-02f, 3.75890583e-02f, -8.67879018e-02f, 9.57350619e-03f, 4.75208536e-02f, -8.09535664e-03f, 1.04018793e-01f, 1.46219462e-01f,
  1.71990275e-01f, 2.44036973e-01f, 8.68416354e-02f, -9.34519842e-02f, 3.41062136e-02f, -1.46121547e-01f, -4.52532284e-02f, 1.41473606e-01f, 7.27365837e-02f, -4.43961918e-02f,
  8.57863054e-02f, 3.87001820e-02f, -8.48963335e-02f, -1.03225693e-01f, 1.30675748e-01f, -3.78192924e-02f, -1.41696960e-01f, 9.00913253e-02f, 2.04712585e-01f, 2.43194550e-01f,
  2.17548579e-01f, -2.22319990e-01f, -3.03112692e-03f, 1.10523216e-01f, 1.31802455e-01f, 6.52070763e-03f, -3.24008204e-02f, 1.32074788e-01f, 3.91053669e-02f, -1.25176549e-01f,
  4.77146566e-01f, -5.63140437e-02f, -1.63805246e-01f, 6.08633220e-01f, 3.31493169e-01f, 3.94508779e-01f, 4.51399758e-02f, 4.39464658e-01f, 4.15031850e-01f, -1.41605332e-01f,
  -2.19716989e-02f, 3.97229654e-04f, -4.76595223e-01f, 4.72323745e-01f, 5.17215490e-01f, -1.24479361e-01f, 4.09035504e-01f, 1.77682430e-01f, 1.56744421e-01f, 2.06072167e-01f,
  2.56599218e-01f, 5.71847796e-01f, -2.30950505e-01f, 1.13313220e-01f, 1.43491969e-01f, -1.60243466e-01f, -1.23353504e-01f, -3.11097980e-01f, 2.34220952e-01f, 1.96544170e-01f,
  3.22994627e-02f, 3.78498733e-02f, -1.73233636e-02f, -3.38341445e-02f, -1.63239725e-02f, -1.00212082e-01f, -1.74954236e-01f, 7.02975169e-02f, -4.17012647e-02f, -5.99007756e-02f,
  -1.58818394e-01f, 1.04114145e-01f, 2.04975948e-01f, -1.48073984e-02f, 1.35910794e-01f, 1.20932110e-01f, -1.04181297e-01f, 3.10872532e-02f, -1.78786442e-02f, -9.96250287e-02f,
  -1.88352779e-01f, -7.63121024e-02f, 4.64905277e-02f, -8.21231678e-02f, 2.80003417e-02f, 1.94569435e-02f, 4.87464294e-02f, -1.14462174e-01f, 7.44409785e-02f, 2.22504735e-01f,
  1.03640124e-01f, -9.01589096e-02f, -7.96961486e-02f, -1.53468025e-03f, 2.17577275e-02f, -1.01480864e-01f, 1.40070692e-01f, -1.33792639e-01f, 3.66059579e-02f, -2.19056085e-02f,
  -7.77792558e-02f, 4.73096147e-02f, 8.07401910e-02f, -6.98433584e-03f, 7.99032375e-02f, -1.23318136e-01f, 4.04973701e-02f, 1.24593496e-01f, 9.89127308e-02f, -1.28225749e-02f,
  -2.61957068e-02f, 1.23321988e-01f, -1.85315654e-01f, -1.66739330e-01f, 4.65476252e-02f, -3.49137895e-02f, 7.85488263e-02f, 1.59698397e-01f, -1.72355562e-01f, 6.70272158e-03f,
  1.08366564e-01f, 2.20912352e-01f, 3.60336266e-02f, 3.19864452e-02f, -5.59615530e-03f, 3.02942134e-02f, 2.96465922e-02f, 2.10959673e-01f, 1.32571131e-01f, 1.12070449e-01f,
  -1.00702621e-01f, 1.76347569e-02f, 3.89541872e-02f, 4.28263918e-02f, 7.82678276e-02f, -5.54546863e-02f, 2.22914293e-02f, -7.06727267e-04f, 1.80378497e-01f, 8.82437900e-02f,
  -1.60034969e-01f, -4.01512533e-02f, -7.88941383e-02f, -4.53516357e-02f, -3.41827571e-02f, -1.53015688e-01f, 1.07187361e-01f, -3.29816155e-02f, -4.59044278e-02f, 3.62150483e-02f,
  -1.90855294e-01f, 5.79292774e-02f, -1.40576497e-01f, -5.04299223e-01f, -5.06689362e-02f, -2.64452934e-01f, -4.94509518e-01f, 4.64218855e-02f, 2.48661950e-01f, -5.69143705e-02f,
  -3.42317194e-01f, 2.63224751e-01f, 4.19127464e-01f, -5.45779347e-01f, 3.70914817e-01f, 4.11192894e-01f, -6.09483719e-01f, -3.48491132e-01f, -4.66094501e-02f, -3.50920588e-01f,
  -1.15213022e-01f, -5.37544608e-01f, -3.93344909e-02f, -1.36340484e-01f, -6.22320950e-01f, -3.40593040e-01f, -1.80267826e-01f, -3.87364179e-01f, -4.14340079e-01f, -1.24524631e-01f,
  -7.76150152e-02f, 4.34332229e-02f, -9.22452658e-02f, 1.25464574e-01f, -6.58104643e-02f, -1.98909491e-01f, -2.29957804e-01f, 6.05087541e-02f, -8.81845281e-02f, -1.06158787e-02f,
  -2.44905315e-02f, 1.31436810e-01f, -6.62195459e-02f, 5.97956888e-02f, -1.34996921e-01f, -2.29591560e-02f, -8.52856338e-02f, -1.33908510e-01f, 1.05574287e-01f, -7.96775073e-02f,
  -1.00435041e-01f, -5.51346987e-02f, -1.61188945e-01f, 2.00064126e-02f, 5.09103946e-02f, -1.49299875e-01f, 3.41630988e-02f, 5.93074746e-02f, -3.30608003e-02f, 5.73782288e-02f,
  -1.44351557e-01f, -3.32045890e-02f, 1.14467852e-01f, -8.24975818e-02f, -2.61581279e-02f, 1.93107016e-02f, -9.95164961e-02f, -2.23732572e-02f, -7.57230148e-02f, 7.60072693e-02f,
  9.14029181e-02f, -6.63597137e-02f, 3.80166918e-02f, -7.10170642e-02f, -2.73288712e-02f, 1.47934081e-02f, 1.51153579e-02f, 1.01964502e-02f, -8.18901286e-02f, 4.06882539e-02f,
  2.20407486e-01f, 4.92571257e-02f, 8.18761066e-02f, -1.14801228e-01f, -7.73858745e-03f, 7.05169737e-02f, -1.02012455e-01f, -7.59778172e-02f, -8.12659487e-02f, -4.82473224e-02f,
  1.81163494e-02f, 8.12596306e-02f, -9.44651105e-03f, -1.76067241e-02f, -1.46690924e-02f, -1.15821756e-01f, -8.76534358e-02f, 1.29623502e-01f, -1.36304125e-01f, -4.78396285e-03f,
  -1.22504294e-01f, -8.97060856e-02f, -9.30196978e-03f, -3.50980787e-03f, 1.23485722e-01f, -2.90461220e-02f, -1.58142567e-01f, -1.10439407e-02f, 2.96981093e-02f, -6.37699738e-02f,
  -4.82876599e-02f, 1.03204258e-01f, 1.84329554e-01f, -3.61422636e-03f, 5.42849787e-02f, -8.47220421e-02f, 1.84315026e-01f, 4.84602805e-03f, -7.36274645e-02f, -7.42817894e-02f,
  1.27405569e-01f, -2.98021942e-01f, -5.10578573e-01f, -3.56343508e-01f, 3.55901867e-01f, 2.66715437e-01f, -1.25133231e-01f, 1.58917814e-01f, -4.23739076e-01f, 2.37229779e-01f,
  2.09842741e-01f, -1.11966886e-01f, -4.05916244e-01f, -6.04380481e-02f, -1.46620065e-01f, -5.60484111e-01f, 1.81132570e-01f, 4.68551414e-03f, -2.03049242e-01f, 1.75486654e-01f,
  -2.86698043e-01f, 4.05932277e-01f, -4.07035142e-01f, 3.81999224e-01f, 1.78879321e-01f, -1.59238894e-02f, 4.51870233e-01f, 9.62915570e-02f, 2.48759598e-01f, 1.92522466e-01f,
  -3.68731730e-02f, -6.61882684e-02f, 5.91741642e-04f, 2.75275633e-02f, 6.68346882e-02f, 1.64832145e-01f, 5.97097129e-02f, 1.47902459e-01f, -7.87807554e-02f, -1.02342948e-01f,
  5.60773797e-02f, -2.03831512e-02f, -2.72406340e-02f, -1.22575313e-01f, 3.99545990e-02f, -1.79668050e-02f, -1.69642642e-01f, -6.81124628e-02f, -2.50389814e-01f, -6.68662339e-02f,
  -1.25856638e-01f, 4.95906770e-02f, 6.02202155e-02f, -4.08400483e-02f, -1.67743862e-01f, -5.79150319e-02f, -4.13776003e-02f, 4.61831801e-02f, -4.38137501e-02f, -9.97570828e-02f,
  2.62577701e-02f, 7.09581524e-02f, -4.22787033e-02f, -2.16060821e-02f, 1.78856049e-02f, -4.36371006e-02f, -3.83130461e-02f, -7.18220025e-02f, -1.44998208e-01f, 5.32530583e-02f,
  2.63655130e-02f, -1.03078231e-01f, 3.04803364e-02f, 1.02754302e-01f, -7.25016072e-02f, 8.72012004e-02f, 1.35484533e-02f, 1.21951535e-01f, -1.96996573e-02f, -9.49660614e-02f,
  3.27910148e-02f, 9.25120264e-02f, -2.14151293e-02f, 9.11897048e-02f, 8.28696042e-02f, -4.70740274e-02f, 1.14197329e-01f, -5.13730496e-02f, 8.08705837e-02f, 6.85980245e-02f,
  4.41851951e-02f, 1.31829768e-01f, -5.50720766e-02f, 2.10017376e-02f, 2.76986305e-02f, -5.64384088e-03f, 4.98271687e-03f, 4.88389172e-02f, 1.96319390e-02f, 7.59924576e-02f,
  -1.85419025e-03f, 8.49412568e-03f, 1.73605829e-01f, -2.76125483e-02f, -4.29383107e-02f, 4.55086157e-02f, 4.93445881e-02f, 3.68810333e-02f, 2.49356702e-02f, 4.34415042e-03f,
  1.37445107e-01f, 1.17749169e-01f, 1.81822982e-02f, -1.35269361e-02f, 6.00199290e-02f, 5.25761656e-02f, 4.75537628e-02f, 2.99134646e-02f, 4.40825932e-02f, -1.69993088e-01f,
  9.63083804e-02f, 1.94523454e-01f, -2.30152383e-01f, 3.88884574e-01f, -2.76623219e-01f, 1.69091865e-01f, 1.49686381e-01f, -2.30064780e-01f, -8.07067156e-02f, 2.51257420e-01f,
  2.01954737e-01f, -3.43469158e-02f, -2.64277309e-02f, 7.62838185e-01f, 1.06189340e-01f, 1.18441172e-01f, 4.49095756e-01f, 1.76507309e-01f, -1.46348596e-01f, 1.81039765e-01f,
  3.19846310e-02f, 5.21113873e-01f, 9.25619528e-02f, 1.66498214e-01f, 5.95063977e-02f, -4.87003922e-02f, 2.10728541e-01f, -3.22144836e-01f, 2.11500525e-01f, 6.45004883e-02f,
  2.75013763e-02f, 1.94953289e-02f, -1.35425091e-01f, -5.18762786e-03f, -1.06833048e-01f, -3.34570482e-02f, -1.17713250e-02f, 5.46683297e-02f, -1.76154763e-01f, 5.32731935e-02f,
  -1.46467034e-02f, 5.86741231e-02f, 6.10530861e-02f, -4.50776145e-02f, -1.01524815e-01f, -1.42643005e-01f, -6.87855035e-02f, -1.57520324e-01f, -4.22254391e-02f, 1.19853988e-02f,
  -1.54769763e-01f, -7.34316092e-03f, 5.65042682e-02f, 1.11699760e-01f, -1.18456677e-01f, 9.04600546e-02f, 1.12538531e-01f, -1.28989905e-01f, 5.43491505e-02f, 7.56378695e-02f,
  1.95512697e-02f, -5.09737954e-02f, 1.13061167e-01f, 7.83719048e-02f, 7.15412199e-02f, 1.42912626e-01f, -2.25839857e-03f, 4.95072789e-02f, -1.08591788e-01f, 6.19998351e-02f,
  -3.20283771e-02f, -2.33259816e-02f, 9.84472781e-02f, -7.10013062e-02f, 8.02321285e-02f, 1.69877917e-01f, -9.29519609e-02f, -9.93942022e-02f, -9.99214500e-02f, -9.95738655e-02f,
  7.34696612e-02f, -1.18963771e-01f, 2.90553216e-02f, -3.27324532e-02f, 2.24701539e-02f, -2.10107788e-01f, -2.56073810e-02f, -1.32334530e-02f, -7.33997747e-02f, -8.05735886e-02f,
  1.07824452e-01f, 1.50619015e-01f, -1.26376108e-03f, -1.01708837e-01f, 4.78883050e-02f, 9.13302302e-02f, 1.00379393e-01f, 8.24171025e-03f, -3.66996927e-03f, -1.63488612e-02f,
  8.97446088e-03f, -8.69488642e-02f, 7.33830184e-02f, -1.48258246e-02f, -1.38810854e-02f, 2.78209825e-03f, 9.77231413e-02f, -6.82243705e-02f, 3.78701687e-02f, -1.95764229e-02f,
  -3.46937776e-03f, -3.10541387e-03f, 2.04161350e-02f, -3.10913231e-02f, 2.21015904e-02f, -2.30591800e-02f, -1.25781879e-01f, -3.13108638e-02f, -6.09585121e-02f, -5.37697808e-04f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.06732786e-01f, 1.94429561e-01f, 2.59321988e-01f, 3.20551246e-01f, 6.02554977e-01f, 3.90404433e-01f, 5.91152370e-01f, 4.78983760e-01f, 5.89012921e-01f, 4.10943568e-01f,
  5.29525280e-01f, 3.71957153e-01f, 4.15728211e-01f, 2.02971220e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.68209720e-01f, 2.36318246e-01f, 1.22952469e-01f, -3.37013930e-01f, -1.96770236e-01f, -1.74061999e-01f, 2.57992893e-01f, 2.17032045e-01f, -7.90709164e-03f, -7.73599045e-03f,
  2.89536595e-01f, 3.19075808e-02f, -2.24865034e-01f, -9.39776152e-02f, -2.42469802e-01f, -5.78171372e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  6.55151308e-01f, 5.92851162e-01f, -3.78509909e-01f, -3.29809546e-01f, -3.48778218e-01f, 7.96476752e-03f, 7.34026194e-01f, 3.17644089e-01f, -4.13878262e-01f, 5.93804121e-01f,
  1.05667949e+00f, 4.43041086e-01f, 1.31254271e-01f, -2.42268905e-01f, -2.02060074e-01f, -3.37469459e-01f, 5.09595573e-01f, 7.26191998e-01f, -1.11524262e-01f, 1.99150518e-02f,
  1.28192693e-01f, 7.54966676e-01f, 6.92798138e-01f, -1.11300357e-01f, 1.81589514e-01f, 2.06596911e-01f, 6.49218976e-01f, 3.45406860e-01f, 8.11253011e-01f, -7.11292997e-02f,
  1.59231257e-02f, 4.54855204e-01f, 2.82316744e-01f, 5.54889500e-01f, -2.53115803e-01f, 3.76884751e-02f, 4.69699293e-01f, 2.54525125e-01f, 2.67726302e-01f, -5.97944021e-01f,
  4.38117497e-02f, 2.71411538e-01f, 7.86867201e-01f, -1.30746931e-01f, 6.21151686e-01f, 7.42629230e-01f, 3.55809599e-01f, -2.89699078e-01f, 1.00060232e-01f, -8.86599839e-01f,
  5.50648332e-01f, 5.01805425e-01f, 6.25259578e-01f, -3.01950604e-01f, 2.95772105e-01f, 7.73621976e-01f, -5.67683101e-01f, -2.75208652e-01f, 3.47003877e-01f, 6.00890517e-01f,
  8.03622425e-01f, 1.58592686e-02f, 8.96713853e-01f, 4.18578349e-02f, 1.04950465e-01f, -8.34959745e-01f, -1.67024598e-01f, 6.15355194e-01f, 5.63919127e-01f, 4.27613676e-01f,
  8.14822316e-01f, -1.88213497e-01f, -4.96927977e-01f, -1.91892520e-01f, -1.64196357e-01f, 7.46985435e-01f, 2.28161573e-01f, -4.45842564e-01f, 2.16370448e-01f, 2.64606148e-01f,
  -3.34631979e-01f, 2.32613549e-01f, 4.70458716e-01f, 2.05640361e-01f, -1.89765189e-02f, 4.49518442e-01f, -1.91777110e-01f, -2.63343036e-01f, 4.86131817e-01f, 4.18489724e-01f,
  -6.69032514e-01f, 3.39853525e-01f, 4.93186206e-01f, -1.16098985e-01f, 5.77166855e-01f, 4.81305867e-01f, 2.05726504e-01f, 8.92371595e-01f, 5.21019578e-01f, -1.89812928e-01f,
  -2.48174697e-01f, 5.00299573e-01f, -7.24170506e-02f, 1.74337566e-01f, 9.99341667e-01f, 7.02211559e-01f, 1.31895557e-01f, -1.97642773e-01f, -2.20003188e-01f, -1.01297401e-01f,
  -6.17665499e-02f, 3.74672741e-01f, 4.68015403e-01f, 6.14314713e-02f, 1.05524850e+00f, -1.54644802e-01f, -4.71725389e-02f, -3.30771506e-02f, -6.64282262e-01f, 4.95319039e-01f,
  9.66053247e-01f, 5.23427606e-01f, 4.37282711e-01f, -2.25200653e-01f, 1.49960309e-01f, 8.23477328e-01f, 3.95998567e-01f, 3.45773637e-01f, -5.60874224e-01f, -4.60213095e-01f,
  2.65100867e-01f, 6.03223026e-01f, 8.90441090e-02f, 5.14149845e-01f, -2.06372086e-02f, 4.08933699e-01f, 5.54001808e-01f, 2.99574673e-01f, -7.38393307e-01f, 4.23046529e-01f,
  1.57690480e-01f, 1.47461891e-01f, 3.21076572e-01f, 4.36154842e-01f, -4.27238643e-01f, 1.62285611e-01f, 6.39636695e-01f, 1.80864796e-01f, 9.99973491e-02f, 3.86277229e-01f,
  -4.92297173e-01f, -4.74445343e-01f, 2.68276811e-01f, 5.44996798e-01f, -4.86932546e-01f, -3.85836750e-01f, 1.50902078e-01f, -2.29689658e-01f, 1.97502181e-01f, 3.71499866e-01f,
  3.59409787e-02f, 3.80762577e-01f, -9.85749140e-02f, 4.04105306e-01f, -4.69741821e-02f, 6.80552840e-01f, 8.03649724e-01f, -1.09538734e-01f, 6.85070306e-02f, -1.74861118e-01f,
  1.12849750e-01f, 6.44258559e-01f, 1.03624201e+00f, -1.86164328e-03f, 3.59940901e-02f, 6.73873901e-01f, 5.16566038e-01f, 7.63362199e-02f, -5.05483329e-01f, 3.62722695e-01f,
  2.64831424e-01f, 6.09122455e-01f, 7.32001841e-01f, -8.73872042e-01f, 5.90387642e-01f, 2.65449226e-01f, -1.53608754e-01f, 5.25246561e-01f, 3.05352867e-01f, 8.08624506e-01f,
  -4.56975251e-01f, -2.31333360e-01f, -2.21562833e-01f, -4.03979234e-02f, 2.76926190e-01f, 4.87316877e-01f, 2.47299477e-01f, 5.27818620e-01f, 7.13625103e-02f, -1.03534602e-01f,
  -8.63777846e-03f, -2.69595981e-01f, 2.55338065e-02f, 2.99512058e-01f, 6.82377040e-01f, -2.77002633e-01f, 4.31254894e-01f, 4.97008055e-01f, 4.18228894e-01f, 5.49310558e-02f,
  1.84359565e-01f, -5.69326282e-01f, -6.49575770e-01f, -4.16011810e-01f, 5.87880164e-02f, 9.13862348e-01f, 2.86321491e-01f, 1.96945876e-01f, 2.20432296e-01f, 4.21950042e-01f,
  -4.05776620e-01f, 1.93226323e-01f, -3.24873149e-01f, -3.61777395e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  5.32747567e-01f, 1.94733784e-01f, 5.84425688e-01f, 4.18081760e-01f, 2.98130989e-01f, -1.67044267e-01f, 5.48590541e-01f, 7.52242148e-01f, 8.05717558e-02f, -1.06368832e-01f,
  -6.54200241e-02f, 4.87013012e-01f, -1.61799014e-01f, 1.18120365e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -7.90495649e-02f, -6.88562334e-01f, -3.69696289e-01f, -3.42197478e-01f, -3.58957574e-02f, 1.82198837e-01f, -2.88277775e-01f, -1.51430577e-01f, 8.80417153e-02f, 2.45416716e-01f,
  -7.15368316e-02f, 2.76105069e-02f, 4.63194288e-02f, -3.20727006e-02f, 2.88939655e-01f, -2.29868084e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -4.22707587e-01f, -4.91280973e-01f, -6.42978966e-01f, 3.93563896e-01f, -6.94523752e-02f, -2.55840212e-01f, -1.40403971e-01f, 5.81715763e-01f, 4.47459757e-01f, 3.10275078e-01f,
  2.25631416e-01f, 7.40308344e-01f, 6.80681467e-01f, -6.15260303e-02f, 3.57850075e-01f, -9.16652828e-02f, -3.12309086e-01f, 5.59112549e-01f, 7.61196077e-01f, 6.43189788e-01f,
  2.74710536e-01f, 7.56604314e-01f, 6.08815968e-01f, 7.96680301e-02f, -5.32008111e-01f, -4.85636860e-01f, -1.33696854e-01f, 1.21710218e-01f, 8.30738962e-01f, 3.80181260e-02f,
  3.50694597e-01f, 6.74501419e-01f, 3.95684242e-01f, -4.24264401e-01f, -4.81852472e-01f, -4.40253556e-01f, 6.89915955e-01f, 8.53834331e-01f, -7.68976882e-02f, 2.12134004e-01f,
  -4.53643888e-01f, 6.10839248e-01f, 2.19781518e-01f, -1.90522801e-02f, -3.08361441e-01f, 8.62543583e-02f, 7.16943368e-02f, 6.59801662e-01f, 4.51215088e-01f, -8.71491373e-01f,
  -3.22771251e-01f, -5.95595300e-01f, -8.24413896e-02f, 6.35921299e-01f, 3.74363780e-01f, -1.70779407e-01f, -4.20282930e-01f, 4.53325391e-01f, 3.15317482e-01f, -6.22804821e-01f,
  -2.50995636e-01f, 7.37717003e-02f, 1.63877815e-01f, -1.72711149e-01f, -2.68795937e-01f, 1.42342851e-01f, -6.82505131e-01f, 3.03086806e-02f, 2.35007435e-01f, 2.28384107e-01f,
  1.17412116e-02f, 5.55725992e-01f, 2.50379473e-01f, 5.10308862e-01f, 1.57817259e-01f, 6.29942894e-01f, 6.47943914e-02f, 1.49533972e-01f, 3.21007282e-01f, -2.50427634e-01f,
  4.92321014e-01f, 7.76410937e-01f, 1.00788140e+00f, 2.54247636e-01f, 5.12765124e-02f, 6.16278648e-01f, 1.44059062e-01f, -3.63527209e-01f, 1.42854452e-01f, 1.96706980e-01f,
  -2.70583987e-01f, -8.87007862e-02f, -2.12033261e-02f, -2.15345114e-01f, -4.23473060e-01f, 1.07154775e+00f, 2.92397231e-01f, -9.43302140e-02f, 4.14501131e-01f, 5.41710258e-01f,
  5.29135346e-01f, -5.80746710e-01f, -4.99238551e-01f, 3.31880391e-01f, 6.74738467e-01f, 6.96749240e-02f, 2.64677674e-01f, 9.07035843e-02f, 5.68785099e-03f, 5.45346081e-01f,
  -3.32367629e-01f, -7.73996890e-01f, 3.31222594e-01f, -3.46789479e-01f, 3.96153718e-01f, 5.94297111e-01f, 1.07808852e+00f, -5.91906570e-02f, -9.90769416e-02f, -3.21552396e-01f,
  -2.27755159e-01f, -4.33168933e-02f, -4.58123565e-01f, -5.22881567e-01f, 4.42624390e-01f, 5.96998215e-01f, 2.63270922e-02f, -1.00710011e+00f, -4.06034827e-01f, -7.96664298e-01f,
  -5.40259480e-01f, 4.88471717e-01f, -3.18828598e-02f, 5.93070626e-01f, 8.77622604e-01f, 4.96949077e-01f, -1.68419555e-01f, -3.52504790e-01f, 7.17642069e-01f, 4.55638729e-02f,
  6.80736303e-01f, 6.35015190e-01f, 7.65228808e-01f, -1.15543592e+00f, 3.94157588e-01f, 5.58277607e-01f, 1.07103609e-01f, -5.50404526e-02f, 6.65602162e-02f, -1.04401186e-01f,
  -5.39356828e-01f, 3.38939130e-01f, 9.30826724e-01f, 6.53629780e-01f, 4.48327392e-01f, 7.06424773e-01f, -2.05163434e-02f, -2.80989319e-01f, -1.33165047e-01f, 8.58501077e-01f,
  5.03467917e-01f, 7.05609322e-02f, 4.63603228e-01f, -7.45077133e-02f, 2.93389171e-01f, -2.91754515e-03f, -6.30207717e-01f, -3.20508242e-01f, 3.12462986e-01f, 5.73889911e-01f,
  -7.93356746e-02f, -5.22590876e-01f, 1.23190276e-01f, 5.50607264e-01f, -1.70426816e-01f, 1.23809624e+00f, 5.19806921e-01f, 1.58728391e-01f, 7.63340071e-02f, 2.32896194e-01f,
  3.02292824e-01f, -7.37547398e-01f, -6.69249892e-02f, 9.66963619e-02f, 3.97773087e-01f, 6.86770558e-01f, -6.84558004e-02f, 4.67935055e-01f, -1.68690979e-01f, 6.19854987e-01f,
  6.96787462e-02f, -4.26006347e-01f, 6.68669224e-01f, 3.17039639e-01f, 5.25753081e-01f, 5.82269609e-01f, 4.05701548e-01f, -1.45553261e-01f, 3.73907894e-01f, -2.84344733e-01f,
  5.63578129e-01f, -2.60041878e-02f, -2.89969623e-01f, -3.16727936e-01f, 1.63522717e-02f, 5.51796198e-01f, -2.81199008e-01f, -2.52844632e-01f, -1.42732516e-01f, -4.52394128e-01f,
  2.89902747e-01f, 5.05737126e-01f, 7.74823204e-02f, 5.32936215e-01f, -4.69155997e-01f, 1.32083939e-02f, 3.44214410e-01f, 5.62768817e-01f, -3.58708143e-01f, 3.52425814e-01f,
  3.88846174e-02f, -7.85284817e-01f, 3.50788176e-01f, 4.06125523e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -1.33584561e-02f, -1.71501935e-01f, 3.60175908e-01f, 4.49290991e-01f, 1.12085035e-02f, 3.27517390e-01f, 1.75299227e-01f, 2.89941221e-01f, 1.16159253e-01f, 2.58219570e-01f,
  3.71356905e-01f, 2.18705446e-01f, 2.29050219e-01f, -4.53958586e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -3.42562616e-01f, 5.44871569e-01f, 4.70585048e-01f, -8.47954333e-01f, -1.06733084e+00f, -3.64380538e-01f, 9.65077803e-02f, -7.32860863e-01f, 2.09636375e-01f, -8.06146979e-01f,
  -1.72965135e-02f, 4.12329972e-01f, -4.85431761e-01f, 3.45776677e-01f, -1.92966744e-01f, 1.73470497e-01f, 3.71678025e-01f, 1.94247305e-01f, 2.89998442e-01f, -7.71201868e-03f,
  -4.01915647e-02f, -7.34320223e-01f, 3.79451156e-01f, -6.61131084e-01f, -1.17458068e-01f, -3.63426745e-01f, 3.02247882e-01f, 2.71456748e-01f, -8.31088245e-01f, -1.93872124e-01f,
  -6.23738229e-01f, 1.27657531e-02f, 3.59210938e-01f, -4.00746465e-01f, 2.06451282e-01f, 1.84224308e-01f, 7.64284134e-02f, -2.25134909e-01f, 8.02353323e-02f, 7.21623823e-02f,
  -5.10528088e-01f, 2.57063508e-01f, -5.64199276e-02f, -5.90023100e-01f, -2.19024748e-01f, -5.52331924e-01f, -1.17876284e-01f, 7.04366148e-01f, 4.13847744e-01f, 5.60145378e-01f,
  -5.04859567e-01f, -5.47157288e-01f, 5.02949238e-01f, 4.29144770e-01f, -1.27909318e-01f, 2.50746399e-01f, -8.36288333e-01f, -1.94572449e-01f, -5.70940971e-01f, 5.76343298e-01f,
  4.39632565e-01f, -4.64904785e-01f, -9.28566873e-01f, 1.20702319e-01f, 7.06000090e-01f, -7.43169069e-01f, -2.00764582e-01f, -6.61323011e-01f, -7.84284249e-02f, -4.81276959e-01f,
  2.57755935e-01f, 2.42646992e-01f, 9.39119011e-02f, -2.39479065e-01f, -6.95354939e-01f, 3.47710073e-01f, 3.13408703e-01f, 3.92793059e-01f, 3.05940807e-01f, -1.68747574e-01f,
  1.24046028e-01f, -2.08923161e-01f, 2.69065827e-01f, -4.34130371e-01f, -7.16215372e-01f, -4.67110544e-01f, -5.03525250e-02f, -6.98113859e-01f, 3.89689237e-01f, 4.84690964e-01f,
  1.84030816e-01f, -2.43024856e-01f, 1.60968974e-01f, 9.36109126e-02f, 2.57563889e-01f, -2.00710565e-01f, -1.02133781e-01f, 1.60036776e-02f, -4.59111482e-01f, 2.77471691e-01f,
  -5.80053270e-01f, -1.39713332e-01f, -5.20384490e-01f, 3.57779473e-01f, -6.56650886e-02f, 4.59979862e-01f, 2.37576980e-02f, -9.37925160e-01f, -2.94018209e-01f, -1.96030378e-01f,
  5.31896055e-01f, -2.12891176e-01f, 2.11911350e-01f, 4.31694090e-01f, -4.48336601e-01f, -4.23594087e-01f, 6.54916584e-01f, 3.94542456e-01f, -5.71762864e-03f, -5.00452280e-01f,
  -5.07566072e-02f, 5.43349802e-01f, -1.25405535e-01f, -4.41093624e-01f, 3.31151664e-01f, 4.30311143e-01f, 1.73865873e-02f, -7.75078297e-01f, -1.08610623e-01f, -4.66857255e-01f,
  -1.36755839e-01f, 3.29845369e-01f, -4.22534078e-01f, 8.03142413e-02f, 1.67998746e-01f, -6.57490566e-02f, -4.35705215e-01f, -3.36899281e-01f, 5.79897881e-01f, -6.49713099e-01f,
  -5.17150462e-01f, -4.85216081e-01f, -9.46633071e-02f, -8.44719410e-01f, -4.26251113e-01f, 2.00917348e-02f, -8.38090777e-01f, -2.71724939e-01f, -9.62087154e-01f, -6.92321211e-02f,
  -5.14298081e-01f, 4.10217494e-01f, 3.96995515e-01f, 4.04042274e-01f, -6.25467598e-01f, 1.17216595e-01f, 1.97484508e-01f, 2.90043533e-01f, 4.41024601e-01f, 6.09693378e-02f,
  -1.72617674e-01f, 7.02042460e-01f, -4.51948375e-01f, -3.92888725e-01f, 6.03720665e-01f, 7.50159979e-01f, -8.81630033e-02f, 6.63358159e-03f, -4.19160455e-01f, -6.02616191e-01f,
  4.18095767e-01f, -4.06840593e-01f, -5.25539041e-01f, -5.04532158e-01f, -6.68532729e-01f, 2.63289124e-01f, -3.22040528e-01f, -2.03871578e-01f, -3.83293688e-01f, 5.24174988e-01f,
  -1.80627763e-01f, -2.78698385e-01f, -7.76381612e-01f, 5.99605560e-01f, -4.51351106e-01f, -3.29625368e-01f, -3.81958216e-01f, 3.05126041e-01f, 3.01535159e-01f, -7.42094517e-01f,
  -1.50446683e-01f, 3.52200866e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.04000978e-01f, -2.01778695e-01f, -2.96347320e-01f, 2.04321127e-02f, 1.77003413e-01f, 3.05943079e-02f, -1.43071160e-01f, 1.93964586e-01f, 1.38884455e-01f, -1.80870280e-01f,
  1.88130379e-01f, 1.47054061e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    