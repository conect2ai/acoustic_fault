/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.01515245e-01f, 3.26118439e-01f, -2.28102785e-02f, 1.89111486e-01f, 2.04563633e-01f, -1.45359039e-01f, -1.28564492e-01f, 2.96876639e-01f, 1.42387807e-01f, 9.53832641e-02f,
  1.80657730e-02f, 6.94771335e-02f, 5.97420037e-02f, 7.36059844e-02f, 2.06116680e-02f, -7.30158612e-02f, -4.08561155e-02f, 3.62700000e-02f, -2.66946424e-02f, 1.01961091e-01f,
  -2.18724459e-02f, 7.64868408e-02f, -9.15098190e-02f, 4.73536067e-02f, 1.34619072e-01f, -3.59689407e-02f, 1.49375936e-02f, -5.38396053e-02f, -3.83746624e-02f, -3.69696245e-02f,
  8.86065513e-03f, 7.48727024e-02f, 6.93731382e-02f, 6.67126942e-03f, 4.74658608e-02f, -1.35401219e-01f, -8.49292874e-02f, -7.59072453e-02f, 5.31883724e-02f, 4.80913557e-02f,
  -5.93214296e-02f, 1.56006500e-01f, -9.96070728e-02f, 2.90220547e-02f, 4.11592685e-02f, -1.46914870e-02f, -1.27830049e-02f, 9.63624716e-02f, 6.15108609e-02f, -1.05454093e-02f,
  4.00900766e-02f, 5.77770136e-02f, -4.66476679e-02f, 7.42767304e-02f, -9.75325983e-03f, 5.26311633e-04f, -6.52210936e-02f, -6.73293322e-02f, 1.32876989e-02f, 6.39493018e-03f,
  -6.61941841e-02f, -5.56980120e-03f, -5.18836007e-02f, 1.13609314e-01f, 3.93231120e-03f, 4.86468635e-02f, -2.56253686e-02f, -1.78212430e-02f, 6.13463037e-02f, -1.30400257e-02f,
  2.22177268e-03f, 3.89920585e-02f, 3.26375365e-02f, -6.53828457e-02f, -8.40238295e-03f, 3.92888561e-02f, -6.00442011e-03f, 9.23910812e-02f, 2.27870885e-02f, -3.89324501e-02f,
  2.22904086e-02f, -1.35863185e-01f, 1.24767773e-01f, 1.44037334e-02f, 3.56733538e-02f, 7.75160734e-04f, 6.24203309e-02f, 8.10393021e-02f, 4.17316742e-02f, -1.32655323e-01f,
  2.48233408e-01f, 7.76992515e-02f, -5.05610965e-02f, 8.03466588e-02f, 9.87459440e-03f, -2.23689172e-02f, 3.97863016e-02f, -4.40116264e-02f, -1.06251635e-01f, -2.57641785e-02f,
  -4.03686203e-02f, -2.70561446e-02f, 2.48089414e-02f, -1.92189664e-02f, -1.59751568e-02f, 6.05305843e-03f, -2.36939546e-02f, 4.04480286e-02f, 2.79585570e-02f, 3.51460911e-02f,
  2.04171427e-02f, 4.69519980e-02f, -2.06061359e-02f, 1.93440970e-02f, -8.60610530e-02f, -2.50139423e-02f, 7.07598701e-02f, -3.32108233e-03f, -5.15108481e-02f, -1.26079610e-02f,
  4.02862132e-01f, 9.62080359e-02f, -3.84798884e-01f, -1.27255574e-01f, 8.85287523e-02f, 3.24444681e-01f, 2.40842663e-02f, 1.13781594e-01f, 1.61382481e-02f, 2.63166726e-01f,
  -1.13816969e-02f, -4.78984825e-02f, 2.06118315e-01f, 2.03357972e-02f, -1.29640713e-01f, -2.38102321e-02f, 1.15990318e-01f, 1.18127696e-01f, -1.44270986e-01f, 3.41543183e-02f,
  -7.11929426e-02f, 1.45645827e-01f, -1.12373248e-01f, 9.73351896e-02f, -1.37499467e-01f, -2.08446443e-01f, -4.06967336e-03f, -8.76627564e-02f, 8.28130245e-02f, -1.95496827e-02f,
  2.23345496e-02f, -1.56161040e-01f, -1.24418303e-01f, 1.53022502e-02f, 3.38523164e-02f, 5.11262305e-02f, -2.86400341e-03f, -1.27928078e-01f, -8.61025006e-02f, 4.81943525e-02f,
  -1.81123591e-03f, -4.05343808e-03f, -1.59159210e-02f, -6.80294260e-02f, -2.27726903e-02f, -4.17291038e-02f, -6.41952381e-02f, -1.37580587e-02f, 3.31064053e-02f, -1.43586576e-01f,
  -6.58046976e-02f, -2.22059581e-02f, -6.76084533e-02f, 5.45701422e-02f, -1.79964408e-01f, 1.04123257e-01f, -1.00132011e-01f, 1.97821809e-03f, 3.70699242e-02f, 1.42543847e-02f,
  -7.06427842e-02f, 5.70546761e-02f, -3.32795009e-02f, 5.68131879e-02f, -1.62628421e-03f, 3.26093733e-02f, -9.79076624e-02f, 4.23634984e-02f, -1.02472948e-02f, 5.58442101e-02f,
  6.96178228e-02f, -5.83233424e-02f, -1.43218609e-02f, 6.39159465e-03f, -1.56679656e-02f, 1.21378212e-03f, -4.87824082e-02f, 3.56659777e-02f, 8.97987336e-02f, 2.22223643e-02f,
  2.31732279e-02f, 7.95779154e-02f, 3.50796245e-02f, 3.72926965e-02f, 3.11028250e-02f, -3.05763911e-02f, -2.26259101e-02f, -3.46072987e-02f, -5.03395051e-02f, -2.16151308e-02f,
  2.21223846e-01f, 9.64732170e-02f, 3.13991793e-02f, 1.71106681e-02f, -7.19350576e-02f, -9.55712795e-02f, -6.60011545e-02f, -3.65488580e-03f, 2.90328991e-02f, -6.27708584e-02f,
  3.75394449e-02f, -9.69149638e-03f, 3.68181132e-02f, -3.90558206e-02f, 4.37281877e-02f, 5.75472321e-03f, 8.03935993e-03f, 1.66671854e-02f, -6.02608779e-04f, 3.08131799e-02f,
  4.71633151e-02f, 2.77469587e-02f, -6.35431111e-02f, 5.87386750e-02f, 8.72818604e-02f, -3.92519981e-02f, -1.16851041e-02f, -4.57685627e-03f, -3.22428122e-02f, -4.25916016e-02f,
  -2.98515022e-01f, -3.78355920e-01f, -4.10160333e-01f, -9.39775854e-02f, 9.82529521e-02f, 4.56585735e-01f, 2.93387592e-01f, -1.52421787e-01f, 2.15092693e-02f, -1.73181202e-02f,
  1.90582335e-01f, 1.74361176e-03f, -1.40613690e-01f, 7.04537407e-02f, 1.21860966e-01f, 6.58362433e-02f, 7.73343816e-02f, 8.76006186e-02f, -1.14974156e-01f, -7.84558579e-02f,
  -4.17832434e-02f, 2.23056823e-01f, -1.33121848e-01f, -3.52669358e-02f, -6.97934851e-02f, -1.59037858e-01f, 2.95933709e-02f, 1.33331176e-02f, -3.63864265e-02f, 5.60057946e-02f,
  -1.65850390e-02f, -6.27377108e-02f, -1.33777186e-01f, -3.05795409e-02f, 5.78561276e-02f, -1.21338619e-03f, 2.69732419e-02f, -4.19043098e-03f, 4.50613583e-03f, 3.39684114e-02f,
  -5.26196277e-03f, 7.87690729e-02f, 7.36324163e-03f, 6.69478476e-02f, 5.11968471e-02f, 7.21936533e-03f, -4.20702435e-02f, -3.95377502e-02f, -5.28814718e-02f, -8.72516036e-02f,
  1.87525507e-02f, -3.39997932e-02f, 1.37486039e-02f, 4.62103486e-02f, 1.92525275e-02f, 1.32860001e-02f, 2.54553743e-02f, 3.57837677e-02f, 1.87740184e-03f, 1.99514553e-02f,
  -2.55779456e-02f, 3.93632837e-02f, 3.35528818e-03f, -2.51843352e-02f, 2.29901746e-02f, -3.67948934e-02f, 8.07443634e-03f, 1.89101100e-02f, 1.41695584e-03f, 3.75396460e-02f,
  1.39583461e-02f, -2.44387742e-02f, 1.03655644e-02f, 3.03034130e-02f, 6.53201267e-02f, -9.24338102e-02f, -7.14754174e-03f, -4.65978161e-02f, 7.71648735e-02f, -4.38164696e-02f,
  -4.50891331e-02f, 4.31120098e-02f, 8.72576796e-03f, -5.38067557e-02f, 1.14620619e-01f, -4.50821742e-02f, 2.49830820e-02f, -5.48492931e-02f, -1.74075253e-02f, 2.23999098e-03f,
  1.27294078e-01f, 3.61919357e-03f, -1.55599287e-06f, 8.19452200e-03f, 1.94448549e-02f, 4.76120040e-02f, 9.68634710e-02f, -4.09203917e-02f, 2.86887102e-02f, 6.93752989e-02f,
  4.06006426e-02f, -9.99222230e-03f, 6.52514622e-02f, -1.19168572e-02f, 1.01667121e-02f, 3.99662275e-03f, 4.71232980e-02f, 1.10810906e-01f, 4.81989458e-02f, 1.87656395e-02f,
  -6.84065297e-02f, 4.81009372e-02f, 7.36675560e-02f, 5.44395782e-02f, 3.50630693e-02f, 4.38743792e-02f, 4.03677970e-02f, -2.00836752e-02f, 1.21573836e-03f, 3.40757295e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.87893355e-01f, -6.05111361e-01f, 5.34916706e-02f, 3.79964978e-01f, 3.72492850e-01f, -8.62347409e-02f, 4.38280612e-01f, -9.02314112e-02f, 2.40436643e-01f, -4.15195435e-01f,
  -2.80109681e-02f, -3.00531179e-01f, -5.82765974e-02f, -2.49807298e-01f, 4.46304619e-01f, -1.64458081e-01f, -3.26982252e-02f, 4.37060662e-05f, -2.54915133e-02f, 3.39453146e-02f,
  1.45723328e-01f, 1.36190549e-01f, 4.20663580e-02f, -1.86558440e-01f, 1.91712484e-01f, 3.48878503e-02f, 4.12375294e-02f, 4.95482832e-02f, -1.99947432e-01f, 5.38211912e-02f,
  1.45636395e-01f, 7.07221329e-02f, 8.49375129e-02f, -6.16799966e-02f, -1.45227432e-01f, 5.82611561e-03f, -9.01375115e-02f, 7.11049810e-02f, 1.02978557e-01f, -4.74579036e-02f,
  -2.10657287e-02f, 9.78352726e-02f, 4.26365575e-03f, 7.91818723e-02f, 7.00273588e-02f, -2.90795360e-02f, 9.03606713e-02f, -6.93800449e-02f, -1.05528347e-02f, 8.44409317e-02f,
  7.09267780e-02f, -6.75003603e-02f, 6.94454461e-02f, -1.22645997e-01f, 9.78283957e-03f, -1.46745937e-03f, 2.32150201e-02f, -5.18852100e-02f, 3.49349566e-02f, -1.58966437e-03f,
  -3.96988839e-02f, 5.48362061e-02f, 3.13642807e-02f, -1.28194485e-02f, -1.67503487e-02f, 4.00582254e-02f, -4.33623791e-03f, -1.08491570e-01f, -1.82068266e-03f, -3.24019939e-02f,
  3.31980139e-02f, 1.63405724e-02f, -5.83798997e-02f, 2.56138723e-02f, 1.24985620e-01f, -5.35585545e-02f, 3.94477136e-02f, -2.66259853e-02f, 5.94418077e-03f, -7.71934241e-02f,
  -7.49994069e-02f, -2.84047071e-02f, 2.18268912e-02f, -1.18581153e-01f, 2.87617315e-02f, 8.29307511e-02f, -8.62078890e-02f, -3.05923410e-02f, 1.01184053e-03f, 2.30483320e-02f,
  -2.33305290e-01f, -4.54564929e-01f, -2.42435671e-02f, 1.10923283e-01f, -9.46398675e-02f, -1.81149811e-01f, -2.37722509e-03f, 9.00801271e-03f, -1.56244770e-01f, -1.65732782e-02f,
  -7.70145133e-02f, 4.38117683e-02f, -6.27221987e-02f, 3.05864327e-02f, 5.57158403e-02f, -7.16145039e-02f, -4.38332185e-02f, -4.71285880e-02f, -3.13750952e-02f, -1.36853397e-01f,
  -4.06340025e-02f, 6.34619743e-02f, 2.85217669e-02f, 1.15176097e-01f, 4.50301595e-04f, -2.56633051e-02f, -7.64631853e-02f, 2.05507074e-02f, -7.62198940e-02f, -3.87718305e-02f,
  -3.19551796e-01f, 4.96840626e-02f, -4.43319023e-01f, -3.63753885e-01f, 3.59662354e-01f, -3.28964382e-01f, -3.47498447e-01f, 1.22559913e-01f, -1.47190198e-01f, 3.28170925e-01f,
  1.92952663e-01f, -8.64321366e-02f, 1.43578023e-01f, -4.28642511e-01f, -7.30096281e-01f, -3.50101471e-01f, -6.49357617e-01f, -2.22093716e-01f, -3.29650193e-02f, 1.07400209e-01f,
  -2.91440547e-01f, 1.39914518e-02f, -5.29441595e-01f, 4.86830264e-01f, 5.49767651e-02f, 1.76958695e-01f, 3.79926741e-01f, 3.53674918e-01f, 1.79336127e-02f, -5.70726432e-02f,
  -7.95771852e-02f, 2.50695739e-02f, -6.38064966e-02f, -8.00255537e-02f, -1.49954721e-01f, 3.91369425e-02f, 8.09918251e-03f, -2.84453593e-02f, -2.62761414e-02f, -1.17209986e-01f,
  1.79320797e-02f, 8.50319341e-02f, -1.11287542e-01f, 3.46256532e-02f, 2.46146470e-02f, -3.78327556e-02f, -1.72189102e-01f, -1.52561173e-01f, -1.36192115e-02f, -3.62271778e-02f,
  -1.12740979e-01f, -1.51484475e-01f, -3.98185179e-02f, -1.52078643e-01f, -7.99724087e-02f, -5.53254038e-02f, -1.17819738e-02f, -2.07495932e-02f, -3.26217487e-02f, -1.54046297e-01f,
  7.47053921e-02f, -3.63723673e-02f, -3.48541178e-02f, 5.12703694e-02f, -2.65323948e-02f, 6.83830753e-02f, 2.60022306e-03f, -3.55726182e-02f, -5.39957285e-02f, 5.80831617e-03f,
  -5.29662259e-02f, -1.29118543e-02f, 1.06607310e-01f, 3.75648332e-03f, -4.36531678e-02f, -7.32606184e-03f, -2.71683950e-02f, 6.51853606e-02f, -9.44239199e-02f, 9.40964837e-03f,
  4.27907892e-02f, -2.93765124e-02f, 5.24611548e-02f, 1.55465119e-02f, 1.42690074e-02f, 5.99505976e-02f, 5.37256710e-02f, -4.58782446e-03f, 5.03212102e-02f, -1.04885409e-02f,
  -1.95167288e-02f, 9.68089923e-02f, 7.57442713e-02f, 7.52354115e-02f, 2.70419177e-02f, 5.62588088e-02f, -1.03910707e-01f, 6.06233329e-02f, -1.05618620e-02f, 7.06712306e-02f,
  5.66392988e-02f, -8.53025913e-03f, 3.20956521e-02f, 4.12414260e-02f, -2.84509584e-02f, 2.78616175e-02f, 7.28417411e-02f, 6.36774898e-02f, 6.55747578e-02f, 6.02803566e-02f,
  1.40561968e-01f, 1.06941774e-01f, -3.86512652e-02f, 6.52993247e-02f, 3.71143557e-02f, -1.81881581e-02f, 1.55000687e-02f, 2.55611017e-02f, -3.51613835e-02f, 3.71209681e-02f,
  -5.42585135e-01f, 1.84702724e-01f, 1.02729231e-01f, -7.66694129e-01f, 1.13799341e-01f, 2.49419346e-01f, -2.48208568e-01f, -1.49794593e-01f, 1.06106959e-01f, -2.63053685e-01f,
  -3.04128975e-01f, 1.90599114e-01f, 3.71559083e-01f, -5.99321365e-01f, 4.25171047e-01f, 3.37395608e-01f, -6.24535918e-01f, -2.28953019e-01f, 1.88294634e-01f, -3.98033977e-01f,
  -1.56467661e-01f, -6.48753345e-01f, -2.97181070e-01f, -2.15671465e-01f, -4.12658691e-01f, -2.61877090e-01f, -3.53846818e-01f, 2.38786459e-01f, -5.59971511e-01f, 9.78956670e-02f,
  -1.27269059e-01f, -3.26381743e-01f, -1.96290061e-01f, -8.07963014e-02f, -2.23804966e-01f, -1.05037153e-01f, -2.69937664e-02f, 8.60532150e-02f, -2.62857359e-02f, 1.17564216e-01f,
  9.19445381e-02f, 5.41945435e-02f, -5.13069890e-03f, 1.42046586e-01f, -1.37293577e-01f, -1.26107201e-01f, 3.96971330e-02f, -3.38086374e-02f, -6.65452145e-03f, 5.60113043e-02f,
  7.68303946e-02f, -7.98267275e-02f, -9.79511291e-02f, -5.04991738e-03f, 2.82874163e-02f, 3.05148400e-02f, -1.07381038e-01f, 7.38700256e-02f, 6.72258763e-03f, -4.45659421e-02f,
  -1.08310319e-01f, 1.54328093e-01f, 6.27400577e-02f, 7.63539076e-02f, 2.08915654e-03f, 5.15278475e-03f, -1.05427168e-01f, -3.12155262e-02f, 7.33822072e-03f, -3.08615621e-02f,
  2.91338023e-02f, -8.00595507e-02f, 1.49040660e-02f, -1.55572295e-02f, -9.64617357e-02f, -2.49416418e-02f, -1.16646411e-02f, 2.04825425e-03f, -7.53713027e-02f, 7.84755573e-02f,
  -1.32142613e-03f, 7.73509815e-02f, -3.23105417e-02f, -1.32704586e-01f, 4.66737300e-02f, 1.80449765e-02f, -3.70974056e-02f, 7.75181409e-03f, 7.15335608e-02f, 9.24212262e-02f,
  6.22613938e-04f, -1.64385974e-01f, 2.48903576e-02f, 4.38607633e-02f, 7.21260160e-02f, 6.14659907e-03f, -3.97009775e-02f, -5.72174564e-02f, -5.79214282e-02f, -7.37253949e-02f,
  -8.86657760e-02f, -9.01207626e-02f, -9.08556208e-02f, 2.63461918e-02f, 1.40985280e-01f, 3.73559855e-02f, -7.03182891e-02f, -3.10068694e-03f, -3.96529771e-02f, -8.11256096e-02f,
  5.91842234e-02f, -4.44915257e-02f, 1.28299192e-01f, -3.91147360e-02f, -8.05789232e-02f, 4.92574945e-02f, -6.71666116e-02f, 1.12909153e-01f, 6.04163036e-02f, 7.10165873e-02f,
  -8.60193253e-01f, -5.73472939e-02f, 1.64820343e-01f, -6.74751878e-01f, 9.88171101e-02f, 4.64061648e-02f, -9.70895588e-02f, 1.25731349e-01f, -5.92946038e-02f, 1.07881855e-02f,
  3.85640338e-02f, -1.85031965e-01f, 3.27691346e-01f, -1.11952005e-02f, -1.11347074e-02f, 3.91677171e-01f, -1.03206843e-01f, -1.23493679e-01f, 3.90416235e-02f, -2.21775010e-01f,
  -3.17932330e-02f, -4.61130962e-02f, 1.72951028e-01f, 1.26391143e-01f, -1.61299974e-01f, -2.60689408e-01f, 7.75063969e-03f, 2.52865367e-02f, -1.27542838e-01f, 2.07283750e-01f,
  -3.40479344e-01f, -3.62562627e-01f, -1.71339586e-01f, 6.75629079e-02f, -5.93542308e-02f, 8.55983123e-02f, -1.04875043e-01f, -8.04240033e-02f, -8.60093012e-02f, -6.05714321e-02f,
  -5.98913729e-02f, 3.62280868e-02f, -1.46166429e-01f, 9.98360012e-03f, -2.45465077e-02f, -9.27201193e-03f, 2.87919957e-02f, 8.85160491e-02f, 6.65861964e-02f, 1.61587708e-02f,
  2.42584217e-02f, 9.54343602e-02f, -1.99332163e-02f, 7.84018189e-02f, 9.79530904e-03f, -4.40590382e-02f, 2.83079725e-02f, 7.77975470e-02f, -2.06333306e-02f, -1.95330307e-01f,
  -2.16005240e-02f, -4.95913327e-02f, 1.42264254e-02f, 3.46484594e-05f, -6.38392242e-03f, -3.42181586e-02f, 1.54359918e-02f, 4.31875885e-02f, -1.18289769e-01f, 1.15058934e-02f,
  1.04728423e-03f, -2.12991256e-02f, -6.87612966e-02f, 1.13784865e-01f, -2.10902598e-02f, -5.72957285e-02f, 4.38387739e-03f, -4.17374559e-02f, 8.53385124e-03f, -9.05591249e-02f,
  -6.38575330e-02f, -6.31839689e-03f, 1.04214430e-01f, -3.18873264e-02f, 2.78713144e-02f, 7.08196312e-02f, -9.12817102e-03f, 4.17998843e-02f, -9.16555226e-02f, -1.41844094e-01f,
  -6.04902923e-01f, -4.92992014e-01f, -9.48436931e-03f, -1.99402973e-01f, -6.42904714e-02f, -6.57095611e-02f, 3.30770761e-02f, 2.06790213e-02f, -4.21783961e-02f, -6.10700697e-02f,
  -1.49804736e-02f, -1.56462844e-02f, 4.07754667e-02f, -3.16906832e-02f, 1.24349799e-02f, 3.86370607e-02f, -1.62711889e-02f, -1.25656575e-01f, -1.04064018e-01f, 3.36100608e-02f,
  -2.48391423e-02f, 1.89049914e-03f, -2.83891223e-02f, -1.57933813e-02f, 2.14636680e-02f, -9.00249109e-02f, -9.77017432e-02f, 3.67258266e-02f, -4.40056436e-02f, 9.62148160e-02f,
  -2.01333046e-01f, -5.09491801e-01f, -2.76376158e-01f, 2.38350824e-01f, 1.78650528e-01f, -2.58546472e-02f, -5.47690988e-01f, 2.65382230e-02f, -2.67021298e-01f, -4.52858746e-01f,
  4.80172262e-02f, -1.12303168e-01f, -5.92444122e-01f, 2.25198537e-01f, 5.01196623e-01f, -2.31805876e-01f, 2.39681721e-01f, 1.09023474e-01f, -2.86130537e-03f, 1.42781869e-01f,
  3.46734315e-01f, 3.84202689e-01f, 3.63584369e-01f, 4.26295191e-01f, 1.39646858e-01f, 1.30739585e-01f, 4.06313390e-01f, 1.14445411e-01f, 4.85507518e-01f, 3.18467289e-01f,
  -1.13879573e-02f, 4.66856398e-02f, -8.84264484e-02f, 8.24960247e-02f, -7.57021606e-02f, -3.68634574e-02f, -2.63542123e-02f, 8.00277442e-02f, 1.98542997e-02f, 6.00705706e-02f,
  2.78134681e-02f, 8.40599313e-02f, 2.09465578e-01f, 6.96963742e-02f, -7.49960989e-02f, -7.73556903e-03f, 6.00583444e-05f, -5.60308956e-02f, -5.89535721e-02f, -3.16253267e-02f,
  -8.32677782e-02f, -2.52912957e-02f, -1.32155791e-02f, -7.49405771e-02f, -8.92301053e-02f, -6.54476285e-02f, -8.84118751e-02f, 1.12368539e-03f, -2.50465493e-03f, -7.12121557e-03f,
  4.64856513e-02f, 3.64796668e-02f, -2.99474169e-02f, -4.19666842e-02f, -6.75985217e-02f, -1.05849765e-01f, 8.16566795e-02f, -7.82890320e-02f, 7.54909143e-02f, -6.59536347e-02f,
  -4.96075489e-02f, 4.07565534e-02f, 2.02797595e-02f, 1.09828096e-02f, 5.56726865e-02f, -5.51594272e-02f, 3.24697010e-02f, 6.19638711e-02f, -2.62485109e-02f, -6.28717989e-02f,
  5.36816940e-02f, 4.85865474e-02f, 5.63970115e-03f, -9.67530459e-02f, 8.77527054e-03f, -4.73570414e-02f, 6.23504408e-02f, -4.73195352e-02f, 2.57569719e-02f, 6.59831911e-02f,
  1.50794797e-02f, 2.31623545e-01f, -7.16196150e-02f, 4.35189605e-02f, -1.08333841e-01f, 1.30697325e-01f, 1.44750357e-01f, 3.11648156e-02f, 3.80742513e-02f, 4.19974001e-03f,
  5.84736131e-02f, 2.96790414e-02f, -1.85280405e-02f, 3.31853796e-03f, 2.19054356e-01f, -5.57893813e-02f, 9.85141322e-02f, 6.40650615e-02f, 5.14864735e-02f, 4.01257724e-02f,
  -4.56907507e-03f, -4.11192104e-02f, -3.91584113e-02f, 9.33350176e-02f, 3.75040583e-02f, -9.80337113e-02f, 3.11350357e-02f, -6.28664196e-02f, 2.68410873e-02f, -3.85873057e-02f,
  -7.67402589e-01f, 4.40844178e-01f, -2.98674442e-02f, 1.05501212e-01f, -5.61674178e-01f, 5.40024154e-02f, 4.17486392e-02f, 1.20666124e-01f, 1.75223574e-01f, 6.70699120e-01f,
  -3.23808230e-02f, 1.36453077e-01f, 2.42727831e-01f, 2.98641264e-01f, -7.71923423e-01f, 3.06632102e-01f, 4.67365459e-02f, 2.01949373e-01f, 1.07124798e-01f, -3.15364748e-02f,
  -2.29261398e-01f, 4.24786657e-03f, -5.80207147e-02f, 1.27208382e-01f, -2.39649326e-01f, -7.82813504e-02f, -3.12667638e-01f, -5.16163409e-02f, -3.18324059e-01f, -1.97872683e-01f,
  -3.45163494e-01f, 2.68068969e-01f, -2.68555973e-02f, -7.09456280e-02f, -1.49614632e-01f, -1.87841192e-01f, -9.71727446e-02f, -5.26891612e-02f, -1.14310399e-01f, 6.03297129e-02f,
  9.52439755e-03f, -4.01910804e-02f, 1.06756672e-01f, 9.48072076e-02f, -3.13193947e-02f, -1.08328179e-01f, 3.31534147e-02f, -2.66427714e-02f, -7.89089070e-04f, -4.72330488e-02f,
  1.25265583e-01f, -1.46754356e-02f, -1.02026135e-01f, 9.87157300e-02f, -1.73446774e-01f, 1.04514398e-01f, -1.00915790e-01f, -1.90310493e-01f, -4.38875481e-02f, -5.63516766e-02f,
  6.81960434e-02f, 4.61036786e-02f, 1.18135422e-01f, -1.03587117e-02f, 6.37769997e-02f, -9.63222515e-03f, -1.36663010e-02f, -3.13704200e-02f, 9.81708169e-02f, 1.58508439e-02f,
  2.16295384e-02f, 3.21124941e-02f, 2.46800985e-02f, 5.16424328e-03f, -2.17981916e-02f, 1.01889350e-01f, -8.51175711e-02f, 1.22593483e-02f, -8.54788870e-02f, -3.57749276e-02f,
  1.09783456e-01f, 3.24918106e-02f, 6.58261999e-02f, -1.51451275e-01f, 1.75451431e-02f, -9.69691873e-02f, 9.36276373e-03f, 1.46882072e-01f, -1.47162881e-02f, -8.04573894e-02f,
  -4.77446258e-01f, -1.53696954e-01f, 6.58479407e-02f, 7.72900656e-02f, -1.15684699e-02f, -7.44210705e-02f, -7.14851618e-02f, -1.92622483e-01f, -3.99513766e-02f, 1.88802183e-02f,
  -2.72920765e-02f, 9.76491123e-02f, -1.65539637e-01f, -3.16078067e-02f, 1.47764683e-01f, -6.64152429e-02f, -1.30223455e-02f, 1.45975217e-01f, -8.29327554e-02f, -1.86007515e-01f,
  1.89083605e-03f, -6.33501783e-02f, 1.06851123e-01f, 5.97926462e-03f, 1.37405442e-02f, -7.48047531e-02f, -8.23410824e-02f, 4.61257584e-02f, -1.36577368e-01f, 2.82130241e-02f,
  8.25066924e-01f, 2.47103591e-02f, -9.11384262e-03f, 1.42320499e-01f, 2.34344527e-01f, 4.48607922e-01f, 3.41282666e-01f, 2.53572881e-01f, 6.34914339e-01f, 2.99232397e-02f,
  1.86947919e-02f, -5.15441895e-02f, -2.88266726e-02f, 1.59499332e-01f, 2.04371572e-01f, 1.67838916e-01f, 3.88632089e-01f, 7.87130669e-02f, 2.47325614e-01f, 1.30241200e-01f,
  1.85845286e-01f, 1.52626917e-01f, -2.16299742e-01f, 2.95630414e-02f, 5.08732460e-02f, -9.56921801e-02f, -3.82351965e-01f, -1.96253970e-01f, -2.41582498e-01f, 1.23158723e-01f,
  1.62818003e-03f, 7.97617137e-02f, -1.15960412e-01f, -3.24690784e-03f, 3.53661668e-03f, -1.11243099e-01f, -6.70256317e-02f, -6.23148903e-02f, -3.14439014e-02f, 4.75291312e-02f,
  4.05321606e-02f, -6.79000244e-02f, 1.19193733e-01f, 3.61704342e-02f, 1.17048524e-01f, -2.50226352e-02f, -1.43856239e-02f, 9.98788327e-02f, -4.10613790e-02f, -2.84733158e-03f,
  -3.76398861e-03f, -7.93830231e-02f, 2.70059705e-02f, -8.86454210e-02f, 6.02427730e-03f, 6.14239015e-02f, 1.91458352e-02f, 1.41625954e-02f, -3.80959250e-02f, 5.63573018e-02f,
  8.21620971e-02f, 1.06037371e-01f, 2.86014434e-02f, -1.62656382e-02f, 6.54952750e-02f, -8.55978280e-02f, 1.38094306e-01f, -1.55791957e-02f, 8.86918604e-02f, -1.83446016e-02f,
  -3.64720784e-02f, 3.74688208e-02f, 2.78538540e-02f, 4.09739874e-02f, 6.22496717e-02f, 4.54510115e-02f, 3.51857916e-02f, -4.34047952e-02f, 1.04627432e-02f, 3.15390453e-02f,
  6.42931014e-02f, 4.01338190e-02f, -1.13107882e-01f, -1.11527080e-02f, 5.75877354e-03f, -6.41111359e-02f, 4.67030853e-02f, 3.98002788e-02f, 3.24158445e-02f, 7.40993246e-02f,
  7.27840289e-02f, 1.80226162e-01f, -4.68144305e-02f, -5.64501919e-02f, -1.13680556e-01f, 8.50804225e-02f, 1.22292094e-01f, -5.67813730e-03f, 7.88895339e-02f, 7.04459921e-02f,
  -4.35125269e-02f, -8.41423217e-03f, -3.90365254e-03f, -3.82455885e-02f, -7.80921802e-02f, 8.23552683e-02f, 3.64579186e-02f, 1.88070778e-02f, 7.24911736e-03f, -8.67992565e-02f,
  -5.58480583e-02f, 4.93328869e-02f, -6.06379285e-03f, 2.52142604e-02f, 7.20461784e-03f, -1.12063214e-01f, 8.12757015e-02f, -5.18209562e-02f, 2.86497809e-02f, 7.22972630e-03f,
  3.93406063e-01f, 6.44112408e-01f, 3.10505599e-01f, 4.09979820e-01f, -3.12737785e-02f, 3.54991734e-01f, 2.95844555e-01f, 1.21158622e-01f, 5.23423314e-01f, -4.24679443e-02f,
  -4.23139840e-01f, 5.45251787e-01f, -5.02904415e-01f, 1.69290498e-01f, -4.57525104e-01f, -1.94681361e-01f, -5.17367609e-02f, 2.98600972e-01f, 6.33432791e-02f, 1.15628138e-01f,
  -1.41724246e-02f, -2.93606758e-01f, -4.29076642e-01f, -3.17958534e-01f, 8.72920752e-02f, 1.89689726e-01f, -4.47387457e-01f, -2.34573223e-02f, 1.03314497e-01f, -3.58334444e-02f,
  7.79448450e-02f, 1.97682083e-01f, -9.87168700e-02f, 1.44066408e-01f, -1.41011313e-01f, 6.76927045e-02f, 8.23731199e-02f, -6.67992383e-02f, -1.36769518e-01f, 9.44058076e-02f,
  1.05722278e-01f, 1.12560084e-02f, 1.09136745e-01f, 3.11370157e-02f, 1.52274564e-01f, 2.76476219e-02f, 1.03890911e-01f, 1.34184301e-01f, 1.10064603e-01f, 1.86755769e-02f,
  1.14506491e-01f, 5.17181270e-02f, -6.32662550e-02f, -8.21367279e-03f, 8.98683965e-02f, 1.33392736e-02f, 1.36252403e-01f, 5.36252037e-02f, 1.38956398e-01f, 1.25492468e-01f,
  -8.06057081e-02f, 6.24154508e-02f, 2.67941356e-02f, -4.17425409e-02f, -4.60288823e-02f, -9.26127806e-02f, 8.56660157e-02f, -1.96756914e-01f, -5.57342358e-03f, -6.14422001e-02f,
  5.17357932e-03f, -5.92309162e-02f, -1.51216378e-02f, 7.61574209e-02f, 1.08277254e-01f, 2.80209277e-02f, -1.08530290e-01f, -7.44741550e-03f, 1.49312198e-01f, -1.50115239e-02f,
  -9.33473706e-02f, 3.93132269e-02f, 5.03001083e-03f, 3.74533981e-02f, -1.02155488e-02f, -9.10920650e-02f, 2.63537001e-02f, 6.95503503e-02f, 3.30000021e-03f, 8.71144310e-02f,
  1.89426765e-01f, 1.62026480e-01f, 9.70310196e-02f, 4.63456959e-02f, -1.17338160e-02f, -8.39242488e-02f, 3.58514860e-02f, 9.61939991e-02f, 1.94043726e-01f, -5.33567816e-02f,
  -1.47171197e-02f, -3.55075509e-03f, 9.48901623e-02f, -2.80913543e-02f, 6.90705655e-03f, 2.13032984e-03f, 8.73581469e-02f, -4.87199659e-03f, -2.68665925e-02f, -8.15985054e-02f,
  6.99386224e-02f, -1.85763650e-02f, 1.88578274e-02f, 7.48222768e-02f, -9.47078243e-02f, -1.78247783e-02f, 4.50816005e-02f, 5.55385463e-02f, -1.05988905e-01f, 3.74422781e-02f,
  5.93770325e-01f, 1.90583676e-01f, -2.89072003e-02f, 1.49403051e-01f, 6.50943369e-02f, 1.31806076e-01f, -3.70476812e-01f, 2.25785360e-01f, -2.54929841e-01f, 2.85563730e-02f,
  3.57437879e-01f, 1.01144306e-01f, -9.40570980e-02f, 3.46896857e-01f, 1.53829813e-01f, -3.54455709e-01f, 3.73938829e-01f, 1.50727063e-01f, -1.25349641e-01f, 3.72414052e-01f,
  2.09843993e-01f, 3.31153929e-01f, 1.82745695e-01f, 4.02286887e-01f, 3.09322983e-01f, 2.29106769e-01f, 2.43045628e-01f, -3.15269642e-02f, 4.28574294e-01f, 5.67553379e-02f,
  -1.42761365e-01f, 7.81884789e-02f, -2.82065887e-02f, -2.02147424e-01f, 1.47330957e-02f, 9.66502056e-02f, -1.19417064e-01f, 3.14154550e-02f, -6.34784475e-02f, -7.05720931e-02f,
  -3.99893634e-02f, 8.29273537e-02f, 5.64035475e-02f, -7.69114643e-02f, 1.04740262e-01f, 1.40735526e-02f, -5.08446731e-02f, -1.42972946e-01f, -2.16181651e-02f, 1.35535672e-01f,
  9.64495633e-03f, 6.14419160e-03f, 5.86892143e-02f, -1.44634351e-01f, 6.00320064e-02f, 1.00537956e-01f, -1.05281733e-01f, -2.67680064e-02f, -1.70116685e-02f, 4.19117771e-02f,
  1.02375850e-01f, -6.61632270e-02f, 7.71180540e-02f, -3.82529385e-02f, 2.05486324e-02f, 6.55059442e-02f, 9.88676175e-02f, -4.87567578e-03f, -1.14023544e-01f, -6.83705730e-04f,
  7.23156258e-02f, 4.62341122e-02f, -8.39838013e-02f, 3.14419493e-02f, 1.60433371e-02f, -1.07017845e-01f, -1.03705257e-01f, -5.45254871e-02f, -1.32807478e-01f, 1.63950659e-02f,
  -1.21392891e-01f, 7.83241466e-02f, 8.12344812e-03f, -1.61980033e-01f, 4.65152152e-02f, -2.66474392e-02f, 1.14299953e-01f, -3.55035327e-02f, -1.52272090e-01f, 7.28190085e-03f,
  4.46692780e-02f, 3.12975228e-01f, 6.35327958e-03f, -3.73663232e-02f, -5.90445288e-02f, 1.09981209e-01f, -7.92119503e-02f, 1.50688261e-01f, 6.39225692e-02f, 4.04298566e-02f,
  7.25427791e-02f, -1.51032269e-01f, -7.30998218e-02f, 8.41366276e-02f, -6.05728365e-02f, 7.26742968e-02f, -8.61820672e-03f, -1.25949800e-01f, 2.59439386e-02f, 1.06367454e-01f,
  1.60392467e-02f, -1.11587182e-01f, 7.00343475e-02f, -4.62199934e-02f, 7.18515739e-02f, -8.43215454e-03f, 1.07751321e-02f, 2.63630748e-02f, 6.98733516e-03f, -7.45029002e-02f,
  2.18383729e-01f, -2.67815202e-01f, -1.53740808e-01f, -4.58951801e-01f, -2.18555272e-01f, -5.66533387e-01f, -6.38780057e-01f, -1.72701180e-01f, -2.24011153e-01f, 1.34589925e-01f,
  -7.30395466e-02f, -1.79132223e-01f, -4.57088612e-02f, -6.13127589e-01f, -4.12992626e-01f, 1.61803560e-03f, -3.16817135e-01f, -3.06483597e-01f, 1.45255655e-01f, -1.78994209e-01f,
  -6.28250912e-02f, -2.77779222e-01f, -1.48436651e-01f, -2.73780860e-02f, -2.66239941e-01f, -2.54519116e-02f, 3.64881784e-01f, -7.55412653e-02f, -1.23015113e-01f, -2.98544884e-01f,
  -1.30828932e-01f, -1.00910231e-01f, -2.51648799e-02f, 9.65480283e-02f, -1.21914269e-02f, 1.38175026e-01f, 8.05073697e-03f, -1.26681894e-01f, -4.77521382e-02f, -1.79521650e-01f,
  -4.99649383e-02f, 4.38374840e-02f, -2.93811355e-02f, 3.84154655e-02f, 5.24169803e-02f, -2.65776296e-03f, -1.06130637e-01f, 3.70323076e-03f, -2.63385415e-01f, -8.31297264e-02f,
  -2.41640255e-01f, -1.63239956e-01f, -7.13676540e-03f, 2.09374242e-02f, -3.06985974e-02f, -2.60369945e-02f, 2.33808998e-02f, -3.25421430e-02f, 1.04923025e-01f, -3.82884145e-02f,
  1.46327749e-01f, 1.36155784e-01f, 2.01816484e-02f, -9.15256292e-02f, -8.13164786e-02f, 4.72802483e-02f, -7.88600966e-02f, 5.27813379e-03f, 8.41109306e-02f, 1.92896940e-03f,
  2.99411938e-02f, -1.06946237e-01f, 6.73327297e-02f, 6.63567381e-03f, 1.21604227e-01f, 3.80904153e-02f, 7.95571785e-03f, -4.60009798e-02f, -5.65758981e-02f, -1.10421963e-01f,
  -4.62184660e-02f, 6.99520856e-02f, -1.00548401e-01f, 9.29658934e-02f, -2.17920139e-01f, -4.91072200e-02f, 6.98952675e-02f, -3.25077325e-02f, -3.10780909e-02f, 3.42902429e-02f,
  -1.38374195e-02f, 2.02909783e-01f, -1.06422216e-01f, -1.34989813e-01f, 2.05980577e-02f, -1.02703944e-01f, -6.62308410e-02f, -7.86549076e-02f, -5.11921868e-02f, 7.81526789e-02f,
  1.38120696e-01f, 2.60406937e-02f, 4.29651737e-02f, 6.46339208e-02f, -7.20705539e-02f, -2.12242957e-02f, 1.47528365e-01f, 2.70997398e-02f, 8.85033328e-03f, 2.51980498e-02f,
  8.80653486e-02f, 1.16673961e-01f, 2.13567587e-03f, -2.33926535e-01f, 6.27230778e-02f, 7.60914758e-02f, 3.91954966e-02f, 2.10232139e-02f, -6.67667463e-02f, -1.97773194e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  1.17570765e-01f, 1.18905380e-01f, 6.58949375e-01f, 3.54498923e-01f, 2.39147589e-01f, 4.55085188e-01f, 1.77269906e-01f, 5.17845869e-01f, 4.14993584e-01f, 2.20724896e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.80692631e-03f, -6.19079828e-01f, -6.54031396e-01f, 4.41712201e-01f, 4.42470968e-01f, -4.16128784e-01f, -3.59784782e-01f, 4.96592253e-01f, -1.51295075e-02f, -2.89242357e-01f,
  -2.26026867e-02f, -1.47728339e-01f, 1.39332679e-03f, -5.16538359e-02f, 4.58963931e-01f, 4.59038317e-01f, 4.78130542e-02f, 4.84120309e-01f, 4.47916500e-02f, -2.53086627e-01f,
  3.11157852e-02f, 4.14071381e-01f, -5.86717248e-01f, 3.36495966e-01f, -4.30469155e-01f, 1.74484268e-01f, -6.45727888e-02f, 2.70311534e-01f, -2.81683385e-01f, 1.61803991e-01f,
  -2.08752006e-01f, 2.02694520e-01f, 2.14233562e-01f, 1.23228379e-01f, 2.74339676e-01f, 1.23276703e-01f, 4.45581198e-01f, 3.63953292e-01f, 4.28857267e-01f, -1.26956269e-01f,
  9.98490453e-02f, -1.67313427e-01f, 9.84630957e-02f, -3.69833499e-01f, 2.52687812e-01f, -2.66240895e-01f, 1.25376591e-02f, 2.66427815e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  9.54326838e-02f, 6.85297027e-02f, -3.51793140e-01f, 4.91094917e-01f, -3.46423805e-01f, -6.53627098e-01f, -4.49239820e-01f, -2.17981696e-01f, 6.14574999e-02f, -7.37388670e-01f,
  -1.59091756e-01f, 4.46710259e-01f, -1.27915800e-01f, 6.86424673e-01f, 4.60016340e-01f, 1.36590421e-01f, 4.29835677e-01f, 3.61169249e-01f, 1.89216003e-01f, 3.64968121e-01f,
  -8.04658532e-02f, -1.10160112e-01f, 2.71368027e-01f, 7.11576164e-01f, 7.14010715e-01f, 3.85702704e-04f, 1.02769470e+00f, -1.24039024e-01f, 8.44513699e-02f, -2.55503058e-01f,
  7.54711509e-01f, 7.78601691e-02f, 1.38765067e-01f, 6.55249178e-01f, 2.41125047e-01f, -3.64262164e-02f, -8.01976442e-01f, -3.89616191e-01f, -3.53769332e-01f, -1.11438222e-01f,
  -1.23047329e-01f, 5.20178080e-01f, 7.21197307e-01f, 5.37164390e-01f, -6.15577281e-01f, 5.74843228e-01f, 1.45126581e-01f, -5.35711288e-01f, 1.64850876e-01f, 2.22888123e-02f,
  4.75380838e-01f, -3.22131723e-01f, -4.73155737e-01f, 3.66810292e-01f, -4.45179269e-02f, 2.94804126e-01f, 1.68385699e-01f, 8.20944786e-01f, -1.71846747e-02f, 9.07740235e-01f,
  -2.72623837e-01f, -3.32982481e-01f, -5.61767995e-01f, -5.65978050e-01f, 2.60667980e-01f, 2.31649235e-01f, 5.34924805e-01f, -6.53525889e-01f, -3.99010628e-01f, 7.50699818e-01f,
  4.04654816e-02f, 3.99825990e-01f, 1.04236114e+00f, 5.25894642e-01f, 8.34297955e-01f, -3.64431292e-01f, -4.31192666e-01f, -2.38079503e-01f, -2.63152868e-01f, 5.66640854e-01f,
  4.99797672e-01f, 5.24511337e-01f, 4.75577712e-01f, -3.54667902e-01f, 5.37235379e-01f, 3.87755126e-01f, -1.10300219e+00f, 6.62444949e-01f, 8.60264361e-01f, 4.82507765e-01f,
  1.74338132e-01f, 8.10736001e-01f, 2.93308467e-01f, 6.89439118e-01f, -1.04099080e-01f, 7.43929088e-01f, -4.18897331e-01f, -8.86417776e-02f, -6.89130202e-02f, 8.27789843e-01f,
  -8.74156833e-01f, -1.08777380e+00f, -6.81980252e-01f, -2.05581874e-01f, 4.44397837e-01f, 5.50590932e-01f, 2.05437467e-01f, 1.77071278e-03f, -1.45653263e-01f, -1.01442516e-01f,
  3.63732368e-01f, 4.61324334e-01f, 3.53751153e-01f, -1.36409223e-01f, -4.25231010e-01f, 7.50832200e-01f, 6.72571421e-01f, -2.99776435e-01f, -4.25205886e-01f, -7.57856965e-01f,
  6.17472529e-01f, 3.54147255e-02f, 7.53740311e-01f, -3.13320607e-02f, 3.19169402e-01f, 3.22649986e-01f, 7.36363590e-01f, 5.44824183e-01f, 9.03416336e-01f, 3.63657147e-01f,
  4.50204551e-01f, 7.72345841e-01f, 5.56115746e-01f, 1.81564718e-01f, 4.36099976e-01f, 8.02654982e-01f, -3.37595910e-01f, -3.55475575e-01f, 4.49271016e-02f, 3.35922360e-01f,
  7.60481179e-01f, 8.15143466e-01f, 7.00218081e-01f, 2.97562838e-01f, 6.07688308e-01f, 2.51180738e-01f, 6.53968036e-01f, -5.36564052e-01f, 2.34746024e-01f, 4.42108750e-01f,
  9.03406262e-01f, -7.91495085e-01f, 1.45502090e-01f, 1.49151653e-01f, -3.97222787e-01f, 4.92065102e-01f, 8.93601656e-01f, 3.97844672e-01f, 8.06934312e-02f, -3.04446995e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  2.98128843e-01f, 1.78053156e-01f, 2.62443423e-01f, 5.57037652e-01f, 5.49175382e-01f, 5.70282698e-01f, 9.16281343e-02f, 2.65754610e-01f, 2.22224250e-01f, 5.02931058e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  5.84528185e-02f, 9.76002291e-02f, 5.69216125e-02f, 4.84489828e-01f, 1.99349284e-01f, -1.85187608e-01f, -3.80212426e-01f, 1.12694062e-01f, -5.31831622e-01f, -4.67058480e-01f,
  -3.62815619e-01f, 2.52143562e-01f, 7.97276124e-02f, 3.86999279e-01f, 6.17518276e-02f, 1.53266639e-01f, 3.49068339e-03f, -1.80965036e-01f, 1.81114763e-01f, -4.62076038e-01f,
  4.41206217e-01f, -5.62552571e-01f, 1.45356074e-01f, -1.69276893e-01f, 2.93400735e-01f, -4.02068123e-02f, 1.87558719e-04f, 3.09848249e-01f, -3.33573073e-01f, -2.10080236e-01f,
  1.01735316e-01f, -3.00983846e-01f, 2.09278002e-01f, 1.60551593e-01f, -9.14928764e-02f, -1.84884027e-01f, -2.85197139e-01f, 4.44747210e-01f, -3.76769006e-01f, 2.09711697e-02f,
  -2.67256439e-01f, -2.11727798e-01f, -5.77833876e-02f, -5.23992777e-02f, -2.76656210e-01f, 2.70732760e-01f, 9.01844427e-02f, 4.16922152e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  2.48418510e-01f, 1.03544593e+00f, -5.37724905e-02f, 8.24439883e-01f, -3.88763785e-01f, -5.82542317e-03f, 1.20413601e+00f, -2.62526143e-02f, -2.14608714e-01f, -2.63591614e-02f,
  -6.89710006e-02f, 5.25232017e-01f, 1.37679017e+00f, 1.39662766e+00f, -3.38442400e-02f, -1.54934898e-01f, 1.59081697e-01f, 4.75512356e-01f, 5.06449938e-01f, -1.07381773e+00f,
  3.11211586e-01f, 2.73624882e-02f, 9.31859687e-02f, -1.50235832e-01f, 1.23973739e+00f, 8.84978831e-01f, 9.35565293e-01f, 7.26486683e-01f, 2.09595099e-01f, -3.12007573e-02f,
  -6.33282781e-01f, 3.49693656e-01f, -5.14402911e-02f, -5.00758290e-01f, 6.20609939e-01f, -1.18431485e+00f, 6.04101419e-01f, -3.87372643e-01f, -4.52837348e-01f, 1.14212207e-01f,
  3.66092831e-01f, 9.86759961e-01f, 1.37061149e-01f, 4.21731025e-01f, 4.59577441e-02f, -8.71985853e-01f, 3.29498917e-01f, 6.19708657e-01f, 3.35647136e-01f, 7.66347721e-02f,
  -3.34572941e-01f, 6.65705919e-01f, 5.22604346e-01f, 2.42779523e-01f, -4.42310601e-01f, 7.95763314e-01f, 1.03549518e-01f, -1.47302791e-01f, 8.11575174e-01f, 6.16131663e-01f,
  8.54231566e-02f, -2.55457491e-01f, -1.86320418e-03f, -1.14000928e+00f, 4.19719309e-01f, -2.48359591e-01f, -6.14545703e-01f, 1.17603540e+00f, 5.41652329e-02f, 6.48234248e-01f,
  -6.54700458e-01f, 2.46503413e-01f, -5.75336933e-01f, -5.40714860e-01f, 6.21522129e-01f, 3.81316334e-01f, -5.25937378e-01f, 4.12512988e-01f, 2.90832520e-01f, -4.47297692e-01f,
  -9.30173919e-02f, -2.63021320e-01f, -1.13376647e-01f, 2.82070875e-01f, -6.47447228e-01f, 8.17545712e-01f, -5.59383690e-01f, 4.89236206e-01f, -9.68873024e-01f, 1.37974709e-01f,
  2.50191867e-01f, 5.75948246e-02f, -4.54382628e-01f, -1.88147366e-01f, 9.27016437e-01f, 4.99940157e-01f, 6.95399821e-01f, 2.69208133e-01f, 4.72891361e-01f, 3.74930382e-01f,
  9.90035087e-02f, -2.54923612e-01f, 9.54237640e-01f, 3.38740945e-01f, 7.06861317e-01f, -6.24153256e-01f, -4.46531147e-01f, 2.39111751e-01f, -5.40260375e-01f, 6.93227470e-01f,
  9.48276460e-01f, 3.52542132e-01f, -3.50144319e-02f, 5.76366067e-01f, 5.69350302e-01f, -5.27065217e-01f, -2.94430047e-01f, 1.09288228e+00f, -4.48689312e-01f, 1.99689925e-01f,
  -8.82058978e-01f, -5.86604238e-01f, 6.33445740e-01f, 3.18586081e-01f, -7.97321200e-01f, 1.31357431e-01f, 4.53283250e-01f, 7.81543255e-01f, 3.35619211e-01f, 1.14441074e-01f,
  3.19939584e-01f, 9.86263931e-01f, 1.04068506e+00f, -6.57048702e-01f, 5.78676522e-01f, -5.81476018e-02f, -4.91833597e-01f, 6.88599229e-01f, 2.97616608e-03f, 8.55484664e-01f,
  -1.24695018e-01f, 9.04288208e-06f, 6.92394853e-01f, -3.66635829e-01f, 1.92010794e-02f, 5.43791234e-01f, -8.29621255e-02f, 8.15986633e-01f, -4.21050698e-01f, 5.80302238e-01f,
  -3.96071017e-01f, 9.64248300e-01f, 4.74151045e-01f, 2.52297539e-02f, 8.99035275e-01f, -1.05950326e-01f, 9.58009422e-01f, 8.95530641e-01f, 4.43994701e-02f, -5.31107187e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  3.87397334e-02f, 4.04859960e-01f, 1.85291275e-01f, -1.63797557e-01f, 1.15118504e-01f, 4.14546043e-01f, -6.34072497e-02f, 3.31597835e-01f, 4.18575495e-01f, 3.11280608e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  4.13547367e-01f, -2.51651824e-01f, 5.47015607e-01f, -4.08412397e-01f, 6.65182829e-01f, -1.55783281e-01f, -6.22643471e-01f, 5.32773554e-01f, 7.94157743e-01f, -1.05477023e+00f,
  -2.79069275e-01f, -7.97495365e-01f, -1.81215003e-01f, -4.69302505e-01f, 2.78160632e-01f, -8.15633893e-01f, -8.31704676e-01f, 2.32565954e-01f, -3.33783031e-01f, 5.09997249e-01f,
  -5.78499198e-01f, 4.73520577e-01f, 2.80431509e-01f, -1.23783052e+00f, -1.11158812e+00f, -3.81662220e-01f, 3.85618627e-01f, 4.10503805e-01f, 2.41437092e-01f, 1.92498699e-01f,
  1.08955488e-01f, 1.53701901e-01f, 1.87909842e-01f, 2.20501572e-01f, -1.10998847e-01f, -5.03605485e-01f, -1.30357176e-01f, 5.98997772e-01f, -4.44659024e-01f, -1.38631491e-02f,
  -6.54400826e-01f, 4.37446743e-01f, 4.96641636e-01f, 7.21213641e-03f, 2.01713189e-01f, -7.69966319e-02f, -1.41425681e+00f, 4.04683739e-01f, 1.82592660e-01f, -2.38866061e-01f,
  -5.72356999e-01f, -6.25344098e-01f, -1.30074292e-01f, 2.46586844e-01f, 5.07369079e-02f, -2.04070181e-01f, 3.09635609e-01f, 4.30539191e-01f, -3.55463743e-01f, 1.06044076e-01f,
  -4.46051836e-01f, -1.14629793e+00f, 4.84043926e-01f, 1.32090166e-01f, -2.84821332e-01f, 3.98099720e-01f, -8.40226263e-02f, -3.03533852e-01f, 5.64899564e-01f, -7.75314450e-01f,
  2.59352386e-01f, 5.62272370e-01f, 1.11292027e-01f, 1.18490517e-01f, -1.24388742e+00f, -9.20942843e-01f, -4.69124347e-01f, -2.38737002e-01f, -3.76010507e-01f, 3.29833359e-01f,
  1.52088434e-01f, 3.28717530e-01f, -1.85460865e-01f, 7.85039365e-01f, 4.85805273e-01f, 6.96089864e-01f, 1.63530990e-01f, 5.44517897e-02f, 1.47448093e-01f, -7.43577719e-01f,
  -6.96648061e-01f, -2.39929825e-01f, 2.35698789e-01f, 5.54606378e-01f, 1.61683917e-01f, -6.43915117e-01f, 5.40715516e-01f, 5.28655807e-03f, -4.22580659e-01f, 2.96232015e-01f,
  -5.55500209e-01f, 5.02166674e-02f, -7.29832590e-01f, -1.20166445e+00f, 3.86613041e-01f, -3.27973247e-01f, -4.20224577e-01f, 7.53961742e-01f, 4.15708393e-01f, 4.67672080e-01f,
  -9.34354365e-01f, -8.13467741e-01f, -3.53030980e-01f, -2.45590702e-01f, 1.64088935e-01f, 4.73796129e-01f, -2.10567191e-01f, -2.39489283e-02f, 2.91093379e-01f, 1.89931206e-02f,
  -6.96685374e-01f, 4.63191092e-01f, 6.02907181e-01f, -4.91862506e-01f, -7.28122294e-01f, -2.63727069e-01f, -2.77128369e-01f, 2.25969806e-01f, -8.32163617e-02f, -4.47615027e-01f,
  3.66130948e-01f, 3.68417233e-01f, -5.14330268e-01f, -4.65617865e-01f, 4.60560203e-01f, -5.29974759e-01f, -5.73334873e-01f, 1.16617903e-01f, -4.98264462e-01f, -8.35266411e-01f,
  3.03777426e-01f, -1.19625521e+00f, -5.15487671e-01f, 6.68521702e-01f, 6.77846447e-02f, 1.37722835e-01f, -8.73186588e-02f, -8.84486318e-01f, -5.19623756e-01f, 7.86079824e-01f,
  -8.09388459e-01f, 5.58734715e-01f, 1.39069960e-01f, -7.25751102e-01f, -2.99863458e-01f, 5.00027776e-01f, -1.10674012e+00f, 6.17624283e-01f, -1.04192722e+00f, 1.38082281e-01f,
  1.21419095e-02f, -4.91915597e-03f, 2.76291937e-01f, 2.02229112e-01f, 8.23165178e-01f, -4.56537157e-01f, -5.48109591e-01f, -7.51109481e-01f, -2.39400104e-01f, 6.09750330e-01f,
  5.80743313e-01f, 1.24237530e-01f, -4.06103954e-02f, 3.14697921e-01f, 3.52275223e-01f, -1.91919416e-01f, 4.18918431e-01f, -3.16626787e-01f, 1.52681358e-02f, -2.49435425e-01f,
  5.04178345e-01f, -4.35526937e-01f, 3.73817086e-01f, 1.16763666e-01f, -5.00622869e-01f, -3.53579402e-01f, -6.23893976e-01f, -1.17818224e+00f, 7.54869401e-01f, -1.23219788e+00f,
  3.76113176e-01f, -5.29540896e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  2.58549511e-01f, 1.37181878e-01f, 8.87058675e-02f, -2.20726281e-01f, 9.36242044e-02f, -9.42262039e-02f, 9.57526043e-02f, -2.44286358e-01f, -4.67004590e-02f, 3.57296705e-01f,
  -3.91510464e-02f, 1.10745274e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    