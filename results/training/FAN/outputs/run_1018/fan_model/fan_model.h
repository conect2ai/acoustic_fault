/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.04141164e-01f, 1.54075474e-01f, 2.98820883e-01f, 8.70762691e-02f, -2.57001370e-01f, -2.33443961e-01f, -4.30180430e-01f, -1.46169379e-01f, -2.14819498e-02f, -4.71121967e-02f,
  1.11158259e-01f, 1.92819387e-02f, -5.12440503e-02f, -3.76362726e-02f, -2.03321185e-02f, -1.86567575e-01f, -9.21841189e-02f, 1.23597071e-01f, -1.50811225e-01f, -1.19811691e-01f,
  -1.70222074e-01f, 1.17699035e-01f, 3.15174490e-01f, 3.68241742e-02f, 9.72855315e-02f, -1.93026252e-02f, 2.12295130e-01f, 1.71418935e-01f, 8.32513645e-02f, 2.74603009e-01f,
  3.11712772e-01f, 3.49242955e-01f, -2.67546117e-01f, -6.01691827e-02f, 1.04050964e-01f, 7.74282515e-02f, -3.50246951e-02f, 1.19096801e-01f, -7.17979968e-02f, 1.23908613e-02f,
  1.53455600e-01f, 1.13849089e-01f, 1.34829404e-02f, 4.18561697e-02f, 5.81929348e-02f, 1.01423733e-01f, 2.03963622e-01f, 6.68227077e-02f, 2.25643074e-04f, 1.66217953e-01f,
  -1.03171580e-01f, 7.19781294e-02f, 1.41505271e-01f, -3.41857262e-02f, 1.57502871e-02f, -1.20331697e-01f, 4.92516235e-02f, 1.05724044e-01f, 8.02228451e-02f, 1.64556444e-01f,
  5.16849123e-02f, -1.26974890e-03f, 5.97426370e-02f, 3.62797789e-02f, -3.23525779e-02f, -7.71284997e-02f, -1.80554464e-02f, -5.71885481e-02f, -4.95771244e-02f, 5.78325167e-02f,
  1.28272511e-02f, 6.23053592e-03f, -1.85363404e-02f, 5.03231585e-03f, -5.58685884e-02f, 1.82579923e-02f, 2.58771274e-02f, 2.12918874e-02f, 4.45925631e-02f, 7.30346888e-02f,
  3.38429734e-02f, -6.44928729e-03f, 5.81364855e-02f, 4.39555906e-02f, 9.22137965e-03f, 2.33820044e-02f, 3.27039361e-02f, 7.72939622e-03f, -3.87025177e-02f, -6.17358163e-02f,
  -3.46400142e-02f, -1.11421645e-01f, 4.15823795e-02f, 9.68388990e-02f, 3.55100557e-02f, 4.82782125e-02f, 2.28431355e-02f, -2.77584661e-02f, -2.58758967e-03f, -5.20234555e-03f,
  -2.84499936e-02f, 2.66748685e-02f, 1.05278797e-01f, 2.35959440e-02f, -4.95803878e-02f, -6.74497634e-02f, -3.69318239e-02f, 2.31930297e-02f, -6.41032606e-02f, 6.63819015e-02f,
  -2.52247434e-02f, -2.17836082e-01f, -2.07341298e-01f, -2.32107401e-01f, -1.71272699e-02f, -1.95664942e-01f, -8.57493430e-02f, -1.13525443e-01f, -2.58960009e-01f, -2.60271460e-01f,
  -5.37750125e-01f, -4.11837548e-02f, 6.65057421e-01f, 8.32381248e-02f, 1.41249329e-01f, -2.75135739e-03f, -1.50098428e-01f, -8.31983685e-02f, 8.07900876e-02f, -1.84260402e-02f,
  -1.44204706e-01f, -3.13880026e-01f, 5.29918298e-02f, -5.87513074e-02f, -5.64572029e-02f, 2.56979167e-01f, 4.53943163e-01f, 1.79580063e-01f, -8.98168981e-02f, -2.77210832e-01f,
  -1.73826203e-01f, -1.28369793e-01f, -1.20791167e-01f, -7.04373270e-02f, 1.35187477e-01f, -4.39654626e-02f, 3.39563131e-01f, 9.92492363e-02f, 6.93909973e-02f, 3.76135081e-01f,
  1.42781287e-01f, 6.64944872e-02f, 4.40789275e-02f, -5.68958819e-02f, 1.57689124e-01f, -5.51923085e-03f, -6.15841225e-02f, 7.63796717e-02f, 8.73105004e-02f, -1.18725784e-02f,
  3.60230356e-02f, -1.75315328e-02f, 2.31288057e-02f, 7.25976825e-02f, 2.44599301e-02f, -3.10230497e-02f, 1.54414520e-01f, 1.01212896e-01f, 2.30301112e-01f, -7.37615721e-03f,
  1.21822342e-01f, -3.60547118e-02f, 1.18864901e-01f, 1.65932491e-01f, 2.10773811e-01f, 2.14882791e-01f, 4.76214215e-02f, 5.97571023e-02f, 9.37965289e-02f, -3.84337865e-02f,
  -1.01904817e-01f, 6.17133901e-02f, 1.69403069e-02f, -7.17807040e-02f, -1.47646129e-01f, -1.23789930e-03f, -5.22244163e-03f, -9.71610174e-02f, -7.39308372e-02f, -1.37383983e-01f,
  9.31577105e-03f, -2.62120105e-02f, -4.78666909e-02f, -5.97396232e-02f, -1.88669320e-02f, 9.03441012e-03f, 4.50595282e-03f, -1.62562262e-02f, -1.18333444e-01f, -2.68756622e-03f,
  -4.40903641e-02f, -1.62983835e-02f, -2.05074288e-02f, 8.53548571e-03f, -2.29521040e-02f, 4.16871980e-02f, -2.66312882e-02f, -9.17715803e-02f, -2.55468413e-02f, -1.43173141e-02f,
  -1.92678601e-01f, 2.19760060e-01f, 1.37725808e-02f, -4.20889333e-02f, 1.50129005e-01f, 1.25209302e-01f, 1.19962990e-01f, 1.02388851e-01f, 7.90977553e-02f, 3.95454653e-02f,
  -2.92081013e-03f, -1.08092325e-02f, 1.07331492e-01f, 9.54539925e-02f, -1.06702382e-02f, -2.48806980e-02f, -3.93733606e-02f, 2.86269151e-02f, 8.25253800e-02f, 1.09539151e-01f,
  4.86898236e-02f, -1.04934834e-02f, -2.05426708e-01f, -3.33952717e-02f, 5.97792529e-02f, -8.13201666e-02f, 1.07951887e-01f, -2.91069020e-02f, -1.32354107e-02f, -1.97662279e-01f,
  7.39415765e-01f, 4.48767781e-01f, 1.76448822e-01f, 3.06832582e-01f, -2.33082071e-01f, -5.68101220e-02f, 3.86291742e-01f, 3.96324486e-01f, 1.87833339e-01f, 2.70510048e-01f,
  -2.47577295e-01f, -3.94216806e-01f, -1.23792171e-01f, -1.81468263e-01f, 1.82267308e-01f, 2.54733413e-01f, 2.36523330e-01f, 1.80464476e-01f, -1.06695563e-01f, -2.63521343e-01f,
  -2.93493927e-01f, 1.22920074e-01f, 2.57032126e-01f, 8.18194672e-02f, -6.41936213e-02f, -2.41446525e-01f, 5.84121123e-02f, -2.18423866e-02f, -1.18636973e-01f, 3.24396007e-02f,
  -1.78951144e-01f, 3.39753509e-01f, -7.57750645e-02f, -7.54349604e-02f, -1.78613871e-01f, 5.98861650e-02f, 5.95066361e-02f, -2.12053582e-02f, 7.98010901e-02f, 6.57658949e-02f,
  -8.35978016e-02f, -4.88257855e-02f, -8.46897140e-02f, -9.45953950e-02f, 3.38272490e-02f, 4.88942415e-02f, 8.20228159e-02f, 1.85425743e-01f, 4.06493954e-02f, -1.92461256e-02f,
  -9.94585752e-02f, -5.34063838e-02f, 9.60401371e-02f, -1.60250254e-02f, 7.26531073e-02f, -7.64307603e-02f, -9.32898559e-03f, 6.62586764e-02f, 3.12086963e-03f, 1.18396953e-01f,
  -5.49262241e-02f, 4.49052788e-02f, -5.09160832e-02f, 2.42509488e-02f, 1.17157195e-02f, 1.38783939e-02f, -7.70713855e-03f, 6.20784871e-02f, 4.82825376e-03f, 5.18870465e-02f,
  -2.90027689e-02f, -2.91355755e-02f, 1.88985802e-02f, 1.54508129e-01f, -1.77553743e-02f, 6.15157634e-02f, 9.04555544e-02f, 6.33205995e-02f, -2.95147533e-03f, 7.37444311e-02f,
  5.88163026e-02f, 4.12828401e-02f, 9.64594558e-02f, -5.30596301e-02f, 5.57802320e-02f, 1.42876003e-02f, 4.81655784e-02f, -7.88840204e-02f, -2.44558733e-02f, 8.38922113e-02f,
  1.67543381e-01f, -5.43999039e-02f, 1.14671454e-01f, 1.00657396e-01f, 6.10249527e-02f, 1.33166742e-02f, 1.44667365e-02f, 6.18262440e-02f, 1.32591501e-02f, 1.43808365e-01f,
  2.80872732e-02f, 1.04499258e-01f, 1.18424527e-01f, 6.61629206e-03f, -8.74733254e-02f, 4.19105813e-02f, 3.65511165e-03f, 1.84545554e-02f, 8.29132721e-02f, 3.32151055e-02f,
  9.35573429e-02f, 1.75120622e-01f, 7.94284269e-02f, 1.07745923e-01f, 4.72965948e-02f, 1.05243176e-01f, -2.46493667e-02f, 1.82651374e-02f, 1.09963730e-01f, 2.69403577e-01f,
  1.77439570e-01f, -1.98575541e-01f, 5.23485094e-02f, 3.89423639e-01f, 7.44904950e-02f, -3.64840925e-01f, -5.63445866e-01f, -1.78974241e-01f, 3.60088587e-01f, -2.56743748e-02f,
  1.82206556e-01f, 3.52644652e-01f, 2.69297779e-01f, 1.03372559e-01f, -2.16798484e-01f, -4.57286388e-01f, -1.38032809e-01f, 1.76518187e-01f, -3.88640026e-03f, -1.33263245e-01f,
  -7.64496475e-02f, 3.10514942e-02f, 7.02374205e-02f, 3.58528830e-02f, 2.42232338e-01f, 2.32235298e-01f, -1.51615022e-02f, 1.40035719e-01f, -1.35708913e-01f, 3.58151674e-01f,
  2.55528033e-01f, 3.73050869e-01f, 8.70693997e-02f, 2.71518648e-01f, 3.11142147e-01f, 1.01961426e-01f, 1.22854166e-01f, 2.61941522e-01f, 2.27374569e-01f, 1.11893937e-01f,
  2.90489048e-01f, 1.89616650e-01f, 3.56819212e-01f, 7.29906783e-02f, 1.43328309e-01f, 2.53151376e-02f, 1.43621787e-01f, 1.18804350e-01f, 1.09458148e-01f, 1.61817074e-01f,
  1.21965557e-01f, 5.70369847e-02f, -3.56273842e-03f, -7.65653253e-02f, 1.41595840e-01f, 1.65617198e-01f, 5.15918657e-02f, 2.05709621e-01f, -2.12711897e-02f, 1.24296196e-01f,
  6.90310495e-04f, -3.20905782e-02f, -8.27510357e-02f, -1.04299411e-01f, -1.64288297e-01f, -7.40126297e-02f, -3.48998494e-02f, -1.89841613e-01f, -9.44337621e-02f, -6.38357475e-02f,
  3.88671160e-02f, -4.42027859e-02f, 8.18744581e-03f, -1.17723625e-02f, -1.37610314e-02f, -2.72424314e-02f, -4.84485552e-02f, -4.78681438e-02f, -2.42227297e-02f, -3.79851982e-02f,
  -1.47008337e-02f, -1.04439475e-01f, 7.53856031e-03f, -6.18401654e-02f, -5.85372187e-02f, 2.48058569e-02f, -2.35529058e-02f, -5.88496625e-02f, 9.98779759e-03f, -2.90898583e-03f,
  6.13005608e-02f, 3.73290069e-02f, 2.01644838e-01f, 1.27416939e-01f, 1.61853537e-01f, 1.57073736e-01f, 2.00948685e-01f, 1.29928738e-01f, 1.98412359e-01f, 2.76700538e-02f,
  6.80368394e-02f, 7.15906397e-02f, 8.39827061e-02f, 1.85893364e-02f, -2.24250518e-02f, 3.44278403e-02f, -6.39596656e-02f, 8.71100724e-02f, -1.57753341e-02f, 5.75309433e-03f,
  -7.85533637e-02f, -1.92169800e-01f, -1.65172860e-01f, -8.57224315e-02f, 1.45719141e-01f, -1.59426350e-02f, -3.10578402e-02f, -5.29754162e-02f, -1.31080672e-01f, -3.66873890e-01f,
  5.01167867e-03f, 6.42588884e-02f, -1.87502839e-02f, 1.17376432e-01f, -5.36840320e-01f, -2.00450927e-01f, -1.56321004e-01f, 2.19054148e-01f, 1.69040889e-01f, -4.97961901e-02f,
  -2.55364060e-01f, -3.09957570e-04f, 2.71320015e-01f, 2.58746207e-01f, 5.52912593e-01f, 3.28458309e-01f, 3.63520563e-01f, 4.43643272e-01f, 2.16182142e-01f, -2.83159256e-01f,
  -1.05284691e-01f, 7.48776421e-02f, 2.29968503e-01f, 7.45160431e-02f, -1.68409154e-01f, -4.03914042e-02f, -1.12850554e-01f, -2.37328231e-01f, -3.07222962e-01f, -1.59532025e-01f,
  -2.62874901e-01f, -1.34753779e-01f, 2.96414383e-02f, -9.84744877e-02f, -1.94385484e-01f, 7.42537230e-02f, -9.11808982e-02f, 3.68968435e-02f, -6.10585809e-02f, -6.28737584e-02f,
  -1.92648888e-01f, -6.33352175e-02f, -8.84562284e-02f, 8.26974679e-03f, -8.51152614e-02f, -3.67051736e-02f, 1.46971662e-02f, 1.33942798e-01f, 5.05611114e-02f, -1.22554921e-01f,
  -1.28662810e-01f, -4.03488785e-01f, -1.73788637e-01f, 1.22465733e-02f, -6.44830614e-02f, -1.24022819e-01f, -2.44542152e-01f, -9.93201211e-02f, -1.14318937e-01f, -8.18102062e-02f,
  -1.75699219e-02f, -1.16253700e-02f, -4.52136584e-02f, 5.70182428e-02f, 1.81759913e-02f, -3.09937540e-02f, 1.34057263e-02f, -3.36210281e-02f, -1.55098562e-03f, 6.57809079e-02f,
  3.26718614e-02f, -1.36152105e-02f, 2.24207435e-02f, 7.80285224e-02f, 4.49639298e-02f, 4.47027944e-02f, -4.00881022e-02f, 1.98422149e-02f, 3.11554708e-02f, -4.97302748e-02f,
  8.75582639e-03f, -1.21213280e-01f, 6.90070959e-03f, 5.50856330e-02f, 3.20072137e-02f, 3.50770243e-02f, 1.10781407e-02f, 1.02919759e-03f, 7.62695149e-02f, 3.95187885e-02f,
  1.79907590e-01f, 2.02732775e-02f, 1.05256550e-02f, 7.88252428e-02f, -3.82693596e-02f, -2.47494243e-02f, 3.71644460e-02f, 2.00835709e-02f, -6.44252598e-02f, -1.98102854e-02f,
  -1.01971209e-01f, 4.10432229e-03f, 1.34153329e-02f, -5.42498641e-02f, -1.87667534e-01f, -1.10423811e-01f, 1.15297578e-01f, 5.88074001e-03f, -2.95300242e-02f, -5.39349951e-02f,
  -1.24389213e-02f, -9.69037600e-03f, 9.82512627e-03f, 1.28634036e-01f, -9.38947275e-02f, 8.79710391e-02f, 6.41339198e-02f, -6.02949224e-02f, 9.05137807e-02f, 1.78644776e-01f,
  7.72594750e-01f, -9.54638720e-02f, -5.09261414e-02f, 5.46286814e-02f, 1.68285310e-01f, 1.19156256e-01f, 1.87590048e-02f, -6.32822886e-02f, 6.42147735e-02f, 9.08351392e-02f,
  2.19202831e-01f, 1.35717943e-01f, 7.34946206e-02f, 8.21993276e-02f, 1.69704676e-01f, 3.12319584e-02f, -5.42189442e-02f, 6.65501058e-02f, 3.23958546e-01f, 2.37118036e-01f,
  -5.84119745e-03f, -3.54666635e-02f, 2.12736487e-01f, -3.47690284e-02f, -1.57584906e-01f, -4.17968780e-02f, -1.89398333e-01f, 1.05593971e-03f, -2.34586261e-02f, -1.86985195e-01f,
  2.13143557e-01f, -1.43767506e-01f, 1.06479086e-01f, 1.27677053e-01f, 6.39243051e-02f, 1.77374333e-02f, 8.27475563e-02f, -1.65759530e-02f, 5.68442196e-02f, -4.82784919e-02f,
  5.48878312e-02f, -4.53717448e-02f, -5.32602854e-02f, -2.27905437e-03f, -3.42521705e-02f, 6.31217360e-02f, 7.99091980e-02f, 9.49727930e-03f, 6.83455542e-02f, -2.95072664e-02f,
  5.05294651e-02f, 2.01740861e-01f, 3.19648117e-01f, 8.37946013e-02f, -1.21837715e-02f, 2.42776975e-01f, 1.91183444e-02f, -3.98311839e-02f, 1.41154781e-01f, 7.10136369e-02f,
  8.53542089e-02f, 3.67732346e-02f, -5.11471294e-02f, -4.14760150e-02f, 3.09447907e-02f, -6.31029084e-02f, -1.62339449e-01f, 4.85555343e-02f, -5.81896193e-02f, -5.29012084e-02f,
  -9.18850601e-02f, 4.15419415e-03f, -1.36326924e-01f, -8.51219073e-02f, -1.45174131e-01f, -7.15019628e-02f, -6.98821479e-03f, -8.49141702e-02f, -7.47986808e-02f, -1.66265041e-01f,
  -8.93272012e-02f, 2.57829800e-02f, -1.27293512e-01f, -1.89113826e-01f, -9.25672576e-02f, -1.02749869e-01f, -4.47318703e-02f, -2.15669703e-02f, -9.00787041e-02f, -6.27072081e-02f,
  6.89382702e-02f, 1.01289436e-01f, 9.84099731e-02f, 5.62104732e-02f, 3.18286605e-02f, 4.10459423e-03f, 4.67131734e-02f, 4.07519639e-02f, -2.03559566e-02f, 3.91481817e-02f,
  4.60453564e-03f, 5.57911210e-02f, 8.69095698e-03f, -1.25334291e-02f, 1.31520584e-01f, 1.03016198e-02f, 1.51581988e-01f, 1.46015838e-01f, 4.51901145e-02f, 6.07332811e-02f,
  8.95251408e-02f, 2.08537295e-01f, 4.17626917e-01f, 1.73045635e-01f, 8.83251503e-02f, 2.63963461e-01f, 1.22067995e-01f, 1.27704918e-01f, 3.00864577e-01f, 3.02281350e-01f,
  7.95392334e-01f, -3.21287699e-02f, -4.08492833e-01f, 1.42802671e-01f, -2.65003204e-01f, -2.54572093e-01f, -3.15841526e-01f, -1.12371676e-01f, -5.01424037e-02f, -9.57745314e-02f,
  -1.00620933e-01f, -1.63424518e-02f, -5.07750958e-02f, -9.47294235e-02f, 7.23626092e-02f, -4.32513952e-01f, -4.75087523e-01f, -4.83069941e-03f, -2.08326019e-02f, -4.74468321e-02f,
  -2.49433890e-01f, 5.38170002e-02f, 3.50092202e-01f, 9.03540179e-02f, -2.89925635e-01f, -4.09083098e-01f, -3.83003771e-01f, 7.22985491e-02f, -2.38946542e-01f, -3.77078742e-01f,
  -5.94414212e-02f, 3.19681853e-01f, -2.36078754e-01f, -8.04956555e-02f, -1.39599234e-01f, -6.65929466e-02f, -1.76641032e-01f, -1.30874887e-01f, -1.64422512e-01f, -1.32794976e-01f,
  -9.92873535e-02f, -3.53930853e-02f, -9.66392532e-02f, -1.64435923e-01f, -9.45622921e-02f, -1.14679746e-01f, -7.97720030e-02f, -9.20231044e-02f, -8.79397467e-02f, -1.70377031e-01f,
  -1.59545392e-01f, -1.98713746e-02f, -8.36254731e-02f, -2.30700806e-01f, -1.35287210e-01f, -1.82653844e-01f, -1.80704132e-01f, -6.91586882e-02f, -1.46478400e-01f, -1.09504826e-01f,
  3.71156633e-02f, 1.29959941e-01f, 1.22431137e-01f, 1.54193640e-01f, 5.83725423e-02f, 6.96812943e-02f, 9.92392227e-02f, 2.36492623e-02f, 1.17171250e-01f, 6.96290731e-02f,
  5.54558709e-02f, 4.59475257e-02f, 2.39467584e-02f, 8.01130012e-02f, -1.00990955e-03f, 2.25448068e-02f, 2.56952457e-02f, 3.84964794e-02f, 7.13991299e-02f, 6.10450879e-02f,
  6.55259192e-02f, 4.92348075e-02f, 6.01687990e-02f, 3.69821601e-02f, 4.39327769e-02f, 5.87423407e-02f, 2.31592320e-02f, 1.03036441e-01f, 7.12552667e-02f, 1.46549836e-01f,
  -1.59172952e-01f, -1.21410176e-01f, -2.21994013e-01f, -7.53803253e-02f, -1.23887554e-01f, -1.41873807e-01f, -1.34523213e-01f, -4.29360084e-02f, -1.51330099e-01f, -1.27509594e-01f,
  -1.05863422e-01f, -1.33084655e-02f, -1.08893298e-01f, -1.09090216e-01f, -1.88572139e-01f, -2.06717446e-01f, -1.13796189e-01f, -2.15235174e-01f, -1.88872874e-01f, -1.05792217e-01f,
  -1.68844625e-01f, -2.79461890e-01f, -1.55051500e-01f, -2.71129191e-01f, -2.07148641e-01f, -2.19788656e-01f, -3.17617506e-01f, -3.07071120e-01f, -2.74227917e-01f, -4.19770628e-01f,
  2.40045115e-01f, -1.69241518e-01f, -6.27041981e-02f, 1.24380395e-01f, -9.62857604e-02f, -1.46113917e-01f, -5.21403313e-01f, -1.31733075e-01f, 1.17126182e-01f, -1.02919295e-01f,
  1.32662833e-01f, 3.57233405e-01f, 3.14099133e-01f, 1.41431779e-01f, -2.51253247e-02f, -3.00841451e-01f, -2.77266979e-01f, -5.19674085e-02f, 1.83065720e-02f, -1.60269681e-02f,
  -9.30027589e-02f, 3.07672229e-02f, 1.74460545e-01f, 6.33029267e-03f, -1.68622270e-01f, -4.89293784e-03f, -1.46041408e-01f, -1.02955021e-01f, -1.79696098e-01f, -4.44380462e-01f,
  -4.99411635e-02f, 3.33999004e-03f, 4.66833897e-02f, 1.95379891e-02f, 4.10959162e-02f, -5.80826327e-02f, -6.22858591e-02f, -5.76638952e-02f, 5.42296190e-03f, 7.52917677e-03f,
  4.90195192e-02f, 1.66782015e-03f, -2.09268481e-02f, 2.05444917e-02f, -5.83659858e-02f, 2.14397237e-02f, 3.34859192e-02f, -7.92762041e-02f, -9.43272859e-02f, 2.07973346e-02f,
  -4.69044521e-02f, -3.66658196e-02f, -8.44901800e-02f, -6.81075603e-02f, 2.45137829e-02f, 5.74093126e-02f, -7.43742958e-02f, -5.78477383e-02f, -1.00905485e-01f, -1.90722972e-01f,
  -9.60098132e-02f, 4.06315476e-02f, 2.08804235e-02f, 6.04664497e-02f, 3.11809331e-02f, 1.41979739e-01f, 4.57765386e-02f, 2.03370806e-02f, 1.52606871e-02f, -3.75905670e-02f,
  8.45352709e-02f, 5.51321916e-02f, 2.59551760e-02f, 4.81590861e-03f, -3.60441729e-02f, -4.83688712e-03f, 6.09769765e-03f, -2.57805735e-03f, -2.54603885e-02f, -3.84085104e-02f,
  -2.22696830e-02f, 1.85166821e-02f, 4.01366465e-02f, -2.74455757e-04f, 6.19420335e-02f, 9.12697520e-03f, -2.52373125e-02f, 5.67754358e-02f, 5.53083643e-02f, 7.42362812e-02f,
  3.01316291e-01f, 2.99169958e-01f, 2.38425266e-02f, -7.13887885e-02f, -9.12189782e-02f, -2.28594914e-02f, -1.52389389e-02f, -6.03126474e-02f, 2.73869652e-02f, -1.06710449e-01f,
  5.16308881e-02f, 2.60489602e-02f, 4.19861339e-02f, -8.03695321e-02f, -6.71214238e-02f, -7.01224431e-02f, -1.15615293e-01f, -8.43842700e-03f, -5.50741404e-02f, -2.77671199e-02f,
  3.40592861e-02f, -1.11540064e-01f, 5.12479432e-02f, 7.97859568e-04f, 3.62273715e-02f, 4.09637615e-02f, -7.12012425e-02f, -1.10386703e-02f, -1.00243904e-01f, -1.16391897e-01f,
  3.19438607e-01f, 1.02096759e-01f, 3.85571033e-01f, 4.28138107e-01f, -1.30405411e-01f, -2.42449075e-01f, 7.08521809e-03f, -4.21122601e-03f, -4.60426062e-02f, -9.06647835e-03f,
  -3.03985924e-01f, -3.44974220e-01f, -9.85231251e-02f, -6.70827255e-02f, 4.68035229e-03f, 1.75706878e-01f, 4.39943165e-01f, 2.79989868e-01f, -4.31584776e-04f, -3.15886468e-01f,
  -9.60282683e-02f, 4.51047212e-01f, 3.89430404e-01f, 2.51624584e-01f, -1.77036561e-02f, -1.86304808e-01f, 1.66395709e-01f, 6.55106381e-02f, -2.15522885e-01f, 7.95941204e-02f,
  -4.59324598e-01f, -1.82441890e-01f, -2.42260806e-02f, -4.22272198e-02f, 1.17486417e-02f, -6.02945164e-02f, -9.81116369e-02f, 2.44849008e-02f, -3.42080407e-02f, 1.81357153e-02f,
  7.85953645e-03f, -1.40530065e-01f, 9.20748115e-02f, -6.98727444e-02f, 7.13015124e-02f, -2.32519936e-02f, 1.20072149e-01f, 1.18305147e-01f, -1.69941224e-02f, -2.34747320e-01f,
  -1.49090916e-01f, -1.57371640e-01f, 5.38043082e-02f, -6.41120970e-02f, -1.33731157e-01f, 1.34822205e-02f, -4.36737761e-02f, -7.51843378e-02f, -8.33390355e-02f, -2.36851815e-02f,
  1.16228620e-02f, 1.47211507e-01f, -4.27376665e-03f, 7.67367631e-02f, 2.09550299e-02f, 5.92093822e-03f, 4.55706194e-03f, 1.76440366e-02f, 5.07282279e-02f, 1.05791152e-01f,
  7.58721530e-02f, -9.99906566e-03f, 1.52015267e-02f, 9.71471518e-02f, -2.16952581e-02f, 3.52595858e-02f, -5.80261042e-03f, 2.00459920e-02f, -5.08890040e-02f, 5.07527478e-02f,
  1.21849235e-02f, -1.55653358e-02f, 7.13637769e-02f, 2.63729431e-02f, -2.26590447e-02f, 2.85570715e-02f, -3.32401767e-02f, -2.67572626e-02f, -5.98117243e-03f, 4.03470807e-02f,
  6.75586089e-02f, -1.90957695e-01f, -1.12205900e-01f, 2.35369895e-02f, -4.62000743e-02f, 2.76994891e-03f, -1.58221990e-01f, 8.53727665e-03f, -4.75635193e-02f, -1.68096367e-02f,
  -1.15543351e-01f, 7.79083893e-02f, 1.02107739e-02f, 1.97538063e-02f, 5.60819283e-02f, -7.41142258e-02f, -1.62023911e-03f, -6.30662031e-03f, -2.40955669e-02f, -7.95062482e-02f,
  1.49670675e-01f, 5.27817160e-02f, -2.97584757e-02f, -7.43797794e-03f, -7.09090829e-02f, -8.16659704e-02f, 2.68269405e-02f, -1.36379302e-01f, -4.33298051e-02f, 2.52769470e-01f,
  1.96052000e-01f, 1.82489127e-01f, 6.50378168e-01f, 5.19605204e-02f, 8.14556777e-02f, 8.54369923e-02f, 1.15664117e-01f, -3.19584310e-02f, -1.40281305e-01f, -3.49845700e-02f,
  -1.23344988e-01f, -3.56393367e-01f, -1.55391216e-01f, -2.40622267e-01f, -8.07523727e-02f, 5.50411120e-02f, 1.02975816e-01f, 1.51690170e-01f, 6.54367208e-02f, 2.92676198e-03f,
  -1.55090481e-01f, -1.50003843e-02f, 2.14835033e-02f, -1.43296629e-01f, -3.97348590e-02f, -1.67953148e-01f, 1.21657260e-01f, 1.51975483e-01f, -3.51443365e-02f, 1.60459861e-01f,
  4.99949157e-01f, 3.71742725e-01f, 3.93630601e-02f, -1.36147857e-01f, 1.02988474e-01f, 5.33750542e-02f, 6.35806471e-02f, 1.15537709e-02f, -4.19800691e-02f, 5.85772395e-02f,
  5.01388907e-02f, -9.21007246e-02f, -3.92753221e-02f, 7.65254423e-02f, 1.64961896e-03f, 6.82138801e-02f, -1.15142591e-01f, 1.04781263e-01f, 3.81800160e-02f, 3.18018384e-02f,
  -2.90722866e-02f, 9.13036428e-03f, 2.08362177e-01f, 9.29624587e-02f, 1.01229750e-01f, -3.81314978e-02f, 1.44157007e-01f, 4.75688651e-02f, 1.32038984e-02f, 1.64757326e-01f,
  4.11127247e-02f, 6.01915969e-03f, -5.12726046e-02f, 1.13701997e-02f, -1.05386198e-01f, 6.51644766e-02f, 1.60485171e-02f, -1.03493065e-01f, 4.19727415e-02f, 4.13808376e-02f,
  -3.71179767e-02f, 7.35053420e-02f, -2.67542265e-02f, 4.41782326e-02f, -4.92855571e-02f, 7.40107223e-02f, 3.15536447e-02f, -6.24194108e-02f, -5.40894158e-02f, -9.10209119e-02f,
  -1.53406095e-02f, -3.02606914e-03f, -3.56082208e-02f, -6.93037733e-02f, -4.58253734e-02f, -3.03438632e-03f, 2.19689310e-02f, -9.39010307e-02f, 5.39338812e-02f, -3.13495612e-03f,
  2.91669518e-02f, -1.95471123e-01f, 1.85097113e-01f, -2.34898124e-02f, 7.40759894e-02f, 3.58204730e-02f, 7.00732768e-02f, 7.12988079e-02f, 1.01965383e-01f, 1.57024577e-01f,
  2.78574806e-02f, 7.69989640e-02f, 1.65797397e-03f, -2.20392346e-02f, -3.53442989e-02f, 7.30412900e-02f, 6.79102493e-03f, 2.33684983e-02f, 3.58747542e-02f, 1.35897860e-01f,
  2.98768096e-02f, 3.67805734e-02f, 8.07496458e-02f, 1.25035584e-01f, 2.03902587e-01f, 1.19878417e-02f, 1.71250403e-01f, 1.48406953e-01f, 8.99450555e-02f, 1.77731425e-01f,
  -6.74698710e-01f, 3.06405038e-01f, 6.00196183e-01f, 1.35813132e-01f, 3.32407534e-01f, 2.73985445e-01f, 3.16252202e-01f, -4.82798703e-02f, -1.24664314e-01f, 3.37445855e-01f,
  1.52491048e-01f, -1.15891369e-02f, 2.51556151e-02f, 6.82658702e-02f, -1.33626107e-02f, 2.82900751e-01f, 3.10866028e-01f, 9.20485184e-02f, -5.21342978e-02f, -1.09314874e-01f,
  3.14479731e-02f, -1.48723632e-01f, -2.58616775e-01f, -1.17323242e-01f, 2.18249947e-01f, 7.03526065e-02f, 2.23111346e-01f, 6.90294337e-03f, 1.06206030e-01f, 4.42262232e-01f,
  5.29951274e-01f, 1.17697276e-01f, 7.69858509e-02f, 2.90722717e-02f, 1.17875807e-01f, 7.23491469e-03f, 9.14286003e-02f, 3.31516005e-02f, -1.88920684e-02f, 7.02541694e-02f,
  1.60319358e-01f, 1.13592498e-01f, 4.91629615e-02f, 8.32739696e-02f, 5.56630194e-02f, 1.09896008e-02f, -2.34368443e-02f, 9.56733152e-02f, 8.59517381e-02f, 7.52359703e-02f,
  1.18970357e-01f, 7.74454623e-02f, -2.87359953e-02f, -2.61155125e-02f, 8.20140392e-02f, 4.65806127e-02f, 1.44861758e-01f, 1.10126987e-01f, 5.55285700e-02f, 6.65775910e-02f,
  -2.73055397e-02f, -3.63102704e-02f, -1.35386214e-02f, -9.66386944e-02f, -1.30382791e-01f, 3.04310583e-02f, 9.27736461e-02f, 4.88017164e-02f, 1.34661188e-02f, -1.35023385e-01f,
  3.76460478e-02f, 9.80986729e-02f, 9.25821960e-02f, 3.33090425e-02f, 8.34656283e-02f, 1.27547728e-02f, -3.84668075e-02f, 6.06783815e-02f, -1.30881459e-01f, -1.06306724e-01f,
  -3.16575915e-02f, -1.21812105e-01f, 4.64886352e-02f, -7.86289200e-02f, 9.08619240e-02f, 2.54445281e-02f, -3.45507488e-02f, -2.72811484e-02f, -8.36997628e-02f, -6.75341189e-02f,
  -1.00738868e-01f, 4.17532250e-02f, 2.14359425e-02f, -2.76157446e-02f, 7.89326206e-02f, -9.61801969e-03f, 2.27434374e-02f, 1.85533967e-02f, 9.80217382e-02f, 8.61448720e-02f,
  7.46172965e-02f, -9.01945215e-03f, 9.67349932e-02f, 1.57341193e-02f, -5.48099820e-03f, 2.06823777e-02f, -1.80622656e-02f, 6.58857301e-02f, 4.79509356e-03f, 2.69779433e-02f,
  9.19498689e-03f, -1.38681114e-01f, -1.72864169e-01f, -3.21951248e-02f, 4.77771536e-02f, -7.71408305e-02f, 3.95238139e-02f, -7.73254037e-02f, -2.81193256e-02f, -1.01932004e-01f,
  1.00650406e+00f, -2.45267838e-01f, -1.33352995e-01f, 4.81428504e-01f, -1.86618164e-01f, -2.45062768e-01f, -4.82331872e-01f, -1.11042894e-02f, 4.21973258e-01f, 9.05379876e-02f,
  -1.78403348e-01f, 1.10736927e-02f, -5.24004102e-02f, -2.89973170e-02f, -2.14447260e-01f, -4.82565425e-02f, 1.54323159e-02f, 1.59108654e-01f, -1.21544534e-02f, -1.27713978e-01f,
  -1.48442045e-01f, 8.92295837e-02f, 2.65781730e-01f, 8.34625214e-02f, 1.23004979e-02f, -1.21865980e-03f, 2.75249835e-02f, -6.29810616e-03f, -1.56213462e-01f, 1.69387653e-01f,
  1.49964169e-02f, 1.12941146e-01f, -4.97224443e-02f, 1.03797868e-01f, 4.45805863e-03f, 2.16253042e-01f, 4.90909442e-02f, 1.34267926e-01f, 8.10076669e-02f, 7.60836005e-02f,
  1.11561334e-02f, 9.11932066e-02f, 6.46414887e-03f, -2.04527173e-02f, -4.56331372e-02f, 5.47179915e-02f, 2.42764503e-02f, 1.38782054e-01f, -2.26198882e-02f, 2.29944568e-02f,
  -1.03356846e-01f, -2.34215707e-02f, -8.53862539e-02f, -1.64814442e-01f, -9.65459570e-02f, 4.40689623e-02f, -1.62338421e-01f, 2.05025338e-02f, -2.36006062e-02f, 1.36366040e-01f,
  8.13482180e-02f, -4.07587271e-03f, -1.21527873e-01f, -6.53736889e-02f, -1.45026848e-01f, -5.14696017e-02f, 7.00615346e-02f, -1.14064276e-01f, -5.98854944e-02f, 1.06640058e-02f,
  -3.43645774e-02f, -6.07768409e-02f, -6.28249068e-03f, -1.78888384e-02f, 1.48761887e-02f, 4.05095927e-02f, -2.77363472e-02f, 2.14572530e-02f, -3.34340930e-02f, 5.69646880e-02f,
  -1.92710962e-02f, -6.84054755e-03f, 7.13698566e-02f, -8.76995027e-02f, -1.40818572e-02f, 2.96286549e-02f, 9.93656889e-02f, -8.69434606e-03f, 2.66343402e-03f, 7.68751204e-02f,
  2.48931870e-01f, -1.61578178e-01f, 1.35270640e-01f, 3.18396874e-02f, 2.44251899e-02f, 8.45860690e-02f, 3.61684826e-04f, 3.42209451e-02f, -1.42801832e-02f, 1.87519249e-02f,
  2.16464326e-03f, 2.15060897e-02f, -3.13564204e-02f, -1.63540896e-02f, -3.16966400e-02f, -4.30987887e-02f, -7.69183505e-03f, 7.06613529e-03f, -2.67502740e-02f, 2.80186404e-02f,
  1.27382828e-02f, 4.35300507e-02f, 2.80570593e-02f, 4.75977408e-03f, -4.13272455e-02f, 2.22693291e-02f, -1.18946165e-01f, -1.25793349e-02f, -7.40835816e-02f, 2.90706474e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.97726703e-01f, 3.44730914e-01f, -3.10353607e-01f, 2.41317794e-01f, -4.38048482e-01f, -1.07372665e+00f, -6.09500706e-01f, -6.79438472e-01f, -2.46526822e-01f, 3.53107899e-01f,
  2.91659117e-01f, 4.90412772e-01f, 8.35715055e-01f, -1.34855434e-01f, -7.59221435e-01f, -1.35780111e-01f, -3.25839579e-01f, -7.35373080e-01f, -1.20018291e+00f, -9.59033608e-01f,
  -3.61540556e-01f, 2.30094399e-02f, -3.52114409e-01f, -3.76514077e-01f, 2.66164422e-01f, 3.77269834e-01f, 6.71546042e-01f, 4.23800424e-02f, -1.33553252e-01f, 3.35838437e-01f,
  6.23490691e-01f, -5.37095368e-01f, -3.38973433e-01f, -1.07689969e-01f, 1.87541753e-01f, -1.57688037e-01f, -1.39500439e-01f, -2.21084766e-02f, 1.36732966e-01f, 1.55529276e-01f,
  7.60921836e-02f, -1.84350714e-01f, -4.55388539e-02f, 2.39416976e-02f, -1.08241834e-01f, -2.01798469e-01f, 5.23172319e-02f, -2.50865519e-01f, -2.14099735e-01f, 1.73066020e-01f,
  2.10357249e-01f, -2.36476049e-01f, 4.81442511e-02f, 5.95468283e-02f, -2.86846429e-01f, -5.60130402e-02f, 1.03327692e-01f, -4.13200706e-01f, -4.71354902e-01f, 3.82128716e-01f,
  1.08285517e-01f, 5.33851646e-02f, -2.13401318e-01f, 1.18012741e-01f, 1.49372756e-01f, 2.49600187e-01f, 1.53532341e-01f, 1.17071606e-01f, -4.82962318e-02f, 3.10025513e-01f,
  3.57494801e-02f, -1.20418876e-01f, -9.15046707e-02f, 1.69438705e-01f, 9.23906416e-02f, -5.46853878e-02f, -7.81255811e-02f, 8.21481273e-03f, -1.98757071e-02f, 1.42810652e-02f,
  -1.97526380e-01f, -1.52778745e-01f, 6.74131513e-02f, 1.74340624e-02f, -3.31373096e-01f, -8.40723440e-02f, -6.89953715e-02f, -1.07892223e-01f, 4.56648320e-02f, -1.18597075e-01f,
  8.69920611e-01f, -7.97607601e-01f, 7.28559196e-01f, -1.58314466e-01f, -1.74216111e-03f, 4.21629585e-02f, 2.40651697e-01f, -1.69192046e-01f, 1.27335504e-01f, -6.82373121e-02f,
  -4.53141212e-01f, -9.87852812e-02f, 1.70614630e-01f, 2.43569836e-02f, -3.42230909e-02f, -1.50983706e-01f, 5.06903864e-02f, 3.28681953e-02f, -3.51368189e-01f, 3.02774161e-02f,
  1.50740696e-02f, 8.93232133e-03f, 3.74568433e-01f, 3.74857396e-01f, 8.95055830e-02f, 4.34733815e-02f, 3.29782456e-01f, 1.41049847e-01f, -1.03635319e-01f, 7.00984538e-01f,
  1.57738543e+00f, -7.85064876e-01f, -1.87459990e-01f, 3.14122051e-01f, 1.59285292e-01f, 1.06920451e-01f, -1.20186783e-01f, 1.71379782e-02f, 2.79813707e-01f, 6.96577057e-02f,
  -1.04237609e-01f, 5.12242578e-02f, 2.71114521e-03f, -1.28808096e-01f, 1.05746202e-02f, -3.98120508e-02f, -1.22411601e-01f, 3.03952515e-01f, 3.70491505e-01f, 2.73960661e-02f,
  -5.37302927e-04f, -1.96328998e-01f, 1.41452983e-01f, -2.74129733e-02f, -4.25948948e-01f, 4.92766798e-02f, -3.36740315e-01f, -3.32559198e-01f, -3.19604784e-01f, -4.88051564e-01f,
  -3.81648153e-01f, -1.47212088e-01f, 1.87602580e-01f, -4.24244031e-02f, -2.58835644e-01f, -2.70416345e-02f, 1.66816339e-01f, -1.31276667e-01f, -5.96751720e-02f, -1.01443939e-01f,
  -7.67868832e-02f, -6.30041882e-02f, -4.60834056e-02f, -1.97385952e-01f, 1.01594711e-02f, -2.01090164e-02f, -7.55205452e-02f, -8.93269703e-02f, -2.75083501e-02f, -1.20994247e-01f,
  -1.70810908e-01f, 1.13692552e-01f, 1.54926814e-02f, 1.61117651e-02f, 3.52998562e-02f, 9.22978073e-02f, -1.58292919e-01f, -9.70206931e-02f, 2.22504977e-02f, 2.85568330e-02f,
  -4.06124108e-02f, 8.28674734e-02f, 8.43902230e-02f, 1.22974567e-01f, 2.40512416e-01f, 9.66981128e-02f, -1.45956315e-02f, 2.88537815e-02f, 8.49150494e-02f, -1.30985212e-02f,
  5.34787253e-02f, 2.09980652e-01f, 1.22950204e-01f, 1.48239389e-01f, -3.49424183e-02f, -8.06676969e-02f, -2.20790319e-02f, 2.19851587e-04f, 4.55795974e-02f, 2.52085086e-02f,
  1.26947373e-01f, -6.86002374e-02f, -7.47421235e-02f, -1.81154773e-01f, -4.28682454e-02f, -3.64791788e-02f, -1.96391977e-02f, -8.81139114e-02f, -6.70888498e-02f, -9.18466672e-02f,
  -3.91845316e-01f, 4.05691385e-01f, 1.80827975e-01f, -9.60078239e-02f, -4.69371565e-02f, -1.08334459e-01f, 3.51919048e-02f, -1.21599309e-01f, -1.72493234e-01f, -1.62450969e-01f,
  -1.78868458e-01f, -1.29767703e-02f, -9.25137699e-02f, -6.33824393e-02f, 2.19638646e-01f, 8.69834796e-02f, -8.70249271e-02f, 9.00409296e-02f, 1.33887799e-02f, -2.17932075e-01f,
  -1.41441435e-01f, 3.86796445e-01f, 3.06988567e-01f, 2.37352565e-01f, 1.53944716e-01f, 3.97003710e-01f, 1.13174595e-01f, -5.88893555e-02f, 2.28531659e-01f, 3.80996019e-01f,
  1.30059612e+00f, 9.20093954e-01f, -4.54112813e-02f, 8.86270478e-02f, -3.33606482e-01f, -5.77422619e-01f, 2.28747681e-01f, 1.45228967e-01f, 8.09072405e-02f, 7.99159408e-01f,
  3.20551634e-01f, -1.01729083e+00f, -2.91326046e-01f, -7.10450649e-01f, -5.69419801e-01f, 3.93036872e-01f, 1.44621313e-01f, -5.31649590e-01f, -1.43499756e+00f, -8.55067909e-01f,
  -2.36493677e-01f, 2.33293131e-01f, 3.76577646e-01f, -1.13985920e-02f, 4.17041630e-01f, -4.89678323e-01f, 7.57051408e-01f, 3.97779703e-01f, 4.13887769e-01f, 6.11825645e-01f,
  -5.75656863e-03f, 1.06287134e+00f, -8.19224536e-01f, -3.68937515e-02f, -4.18720394e-02f, 1.08270124e-01f, -1.29138350e-01f, 3.43880206e-02f, 7.67617151e-02f, 7.90350437e-02f,
  -1.04686581e-01f, 1.07334241e-01f, -2.98130125e-01f, -6.39241859e-02f, 9.11529660e-02f, -1.91122338e-01f, 2.33798996e-01f, -7.17673004e-02f, -2.16972604e-01f, 6.83545545e-02f,
  -2.90233999e-01f, 5.77371009e-02f, 1.08613603e-01f, -6.13804869e-02f, -2.99904794e-01f, -4.59054291e-01f, 7.07612233e-03f, -8.68371949e-02f, -6.72248080e-02f, 8.76370907e-01f,
  -6.62190169e-02f, 3.60481702e-02f, 1.00321416e-02f, 1.24487430e-01f, -1.36634465e-02f, -8.61649588e-02f, 1.41315296e-01f, -6.91501722e-02f, -3.83915827e-02f, 5.50909750e-02f,
  -1.81462690e-01f, 4.09188084e-02f, 3.68156843e-02f, 1.32309884e-01f, -7.35850185e-02f, 1.30242229e-01f, -1.23859204e-01f, 2.08462417e-01f, 2.84398952e-03f, -4.70394306e-02f,
  -2.00723007e-01f, -6.46667928e-02f, -7.61025473e-02f, -2.17292324e-01f, 1.80087239e-01f, -5.80320172e-02f, -2.78614997e-03f, -5.60470186e-02f, 1.00793177e-02f, 1.72165602e-01f,
  2.75998991e-02f, -5.18576324e-01f, 2.33668894e-01f, -2.83605903e-01f, 1.61568522e-01f, -2.78203823e-02f, 4.10233170e-01f, 3.65014449e-02f, 1.05626777e-01f, -1.18446246e-01f,
  -1.66983962e-01f, -1.43280238e-01f, 3.87470126e-01f, -4.94701192e-02f, -1.79564819e-01f, -9.40638110e-02f, 1.15228876e-01f, -3.55510533e-01f, -2.66899347e-01f, 1.23906052e-02f,
  1.07382007e-01f, -2.22976327e-01f, -1.87454015e-01f, -2.82199562e-01f, -2.07772534e-02f, -3.28174263e-01f, 3.53605784e-02f, -4.35214669e-01f, -6.68802679e-01f, 3.02108973e-01f,
  -1.17055583e+00f, -7.20835924e-02f, -1.34102416e+00f, -7.66196728e-01f, -5.82720876e-01f, -2.03539103e-01f, 2.70145386e-01f, 7.76061654e-01f, 4.65595007e-01f, 2.84437895e-01f,
  8.19904953e-02f, -5.77334046e-01f, -9.20923591e-01f, -3.50436956e-01f, -4.66363549e-01f, -4.27161813e-01f, -1.05151832e+00f, -1.33658099e+00f, -9.87070262e-01f, 2.80582666e-01f,
  2.35074013e-01f, -5.63328445e-01f, -6.54011250e-01f, -2.87063047e-02f, -4.99666892e-02f, -7.05507040e-01f, -7.70146251e-01f, -9.01636422e-01f, -5.10131478e-01f, -1.39221215e+00f,
  -1.00743484e+00f, -1.56012535e-01f, -5.16825765e-02f, -9.66667682e-02f, -9.27347764e-02f, 1.47682726e-01f, 7.87795559e-02f, -5.57102710e-02f, 1.81468785e-01f, 8.79400000e-02f,
  -2.16088772e-01f, 1.82220250e-01f, -2.91196793e-01f, 3.98788042e-02f, -1.00087158e-01f, 2.44089201e-01f, -1.25142843e-01f, -1.96491063e-01f, -1.94161534e-01f, 4.09652054e-01f,
  1.92285135e-01f, -2.96049416e-01f, -2.79574245e-01f, 2.37088293e-01f, 5.04760385e-01f, -3.25442553e-01f, 2.39359751e-01f, 3.07262450e-01f, -1.83658257e-01f, -6.86711743e-02f,
  4.90745187e-01f, 1.46270946e-01f, 3.30408067e-02f, 1.26220286e-01f, 2.12771192e-01f, 6.63562045e-02f, -1.36592299e-01f, 1.37636676e-01f, -4.55724970e-02f, -8.15731063e-02f,
  -2.59960238e-02f, 7.00234994e-02f, 2.09577784e-01f, -1.13240585e-01f, -1.84443563e-01f, -1.40633345e-01f, -1.08760379e-01f, 1.10988043e-01f, 8.84698480e-02f, -9.77255553e-02f,
  8.26910418e-03f, -2.67611235e-01f, 8.22025468e-04f, 2.27572948e-01f, 1.98685545e-02f, -7.03365281e-02f, -5.17771021e-02f, 7.52247348e-02f, 5.84737584e-02f, 5.60823642e-02f,
  -2.69801527e-01f, -3.63984406e-01f, -4.64182459e-02f, 3.84705849e-02f, -1.22488253e-01f, 1.15019724e-01f, -2.81283677e-01f, 2.12093428e-01f, -1.55067325e-01f, 1.79459810e-01f,
  1.36371478e-01f, 5.10504581e-02f, -1.82322606e-01f, -4.94434591e-03f, -1.08709767e-01f, 1.70872971e-01f, 2.96360791e-01f, -4.47133958e-01f, -1.30768046e-01f, 4.10104156e-01f,
  2.91904122e-01f, 1.29064560e-01f, -2.44020179e-01f, -1.04357645e-01f, 1.13100447e-01f, -3.46910149e-01f, -2.29077265e-01f, -5.67613915e-02f, -2.86278933e-01f, 4.91591007e-01f,
  -1.85090375e+00f, 7.28175759e-01f, 4.16345626e-01f, -5.35339952e-01f, 1.12341714e+00f, 5.05321383e-01f, 7.88463712e-01f, -4.86744612e-01f, -4.90881860e-01f, 4.33574319e-01f,
  9.96868372e-01f, -3.00564855e-01f, -2.93878853e-01f, -9.16856676e-02f, -4.66437459e-01f, 6.39616132e-01f, 7.19508410e-01f, -4.20251042e-01f, -9.98668373e-01f, -4.80571657e-01f,
  2.70428151e-01f, -5.20259202e-01f, -1.06224513e+00f, -3.75146866e-01f, 1.27105117e-01f, -2.33938903e-01f, 3.36551309e-01f, 1.28581107e-01f, 6.55296504e-01f, 5.86331487e-01f,
  -2.67860889e-02f, -1.59452006e-01f, 1.71423256e-01f, -1.16537504e-01f, 2.28273973e-01f, -3.07940662e-01f, -3.53148341e-01f, -1.87958524e-01f, 2.01225847e-01f, -8.12409818e-02f,
  2.37707391e-01f, 2.07362771e-02f, 1.13017000e-01f, -1.02510676e-02f, -1.61791533e-01f, -8.44550207e-02f, -2.87577391e-01f, -7.55837262e-01f, -5.09146273e-01f, -2.40665346e-01f,
  8.43406737e-01f, 7.04528809e-01f, -7.94179142e-02f, 3.88023853e-01f, -1.22583494e-01f, -2.02280879e-01f, -9.18636099e-02f, -5.99441588e-01f, -4.83174473e-01f, -7.34504580e-01f,
  6.35730401e-02f, 1.06947847e-01f, 2.98671901e-01f, 3.18714865e-02f, 8.92647207e-02f, 8.99472460e-03f, 1.23484448e-01f, 1.45063758e-01f, 4.15025726e-02f, -6.38120621e-02f,
  5.46350069e-02f, 9.11852047e-02f, -8.31695050e-02f, -7.35735446e-02f, -9.23329815e-02f, 6.65847659e-02f, 3.56332287e-02f, -1.89124569e-02f, -1.02165721e-01f, -5.39577231e-02f,
  -2.43101373e-01f, 7.57551715e-02f, 9.31410044e-02f, -3.12805742e-01f, 3.93153876e-01f, 3.36213154e-03f, 9.31939632e-02f, 8.07458386e-02f, -2.04277441e-01f, 1.68354198e-01f,
  -7.96993673e-01f, 6.97985411e-01f, -3.09648186e-01f, -2.16094077e-01f, 8.20987225e-02f, -7.93627948e-02f, 3.48198384e-01f, 4.95115877e-04f, 1.44642159e-01f, -2.69031554e-01f,
  -1.55782416e-01f, -6.72693998e-02f, 1.01457924e-01f, -8.19030963e-03f, -1.93756208e-01f, -2.14575008e-01f, 2.58684248e-01f, 1.45836383e-01f, -7.57003576e-02f, -3.49416323e-02f,
  -1.36630505e-01f, -1.71931088e-01f, -7.82324076e-01f, -1.89261511e-01f, -3.67105365e-01f, -3.93494189e-01f, -2.88200647e-01f, -6.47207260e-01f, -2.94503540e-01f, -7.57852852e-01f,
  1.27668869e+00f, 7.56358624e-01f, 3.14428508e-01f, 3.19195479e-01f, 2.05187678e-01f, 4.69482929e-01f, 8.84846985e-01f, 5.03902256e-01f, 2.11584285e-01f, 1.45591542e-01f,
  3.21614563e-01f, 6.29158616e-02f, 7.88041055e-02f, -1.80054847e-02f, 1.45715892e-01f, -7.70416930e-02f, -3.86530221e-01f, -1.06363147e-01f, -5.39531782e-02f, -1.00723349e-01f,
  -4.08109814e-01f, -2.63232529e-01f, 2.25876048e-02f, -9.06626806e-02f, -1.59108132e-01f, -2.27932796e-01f, 1.47740647e-01f, 1.68711334e-01f, 1.30535364e-02f, -6.01796031e-01f,
  -4.20524836e-01f, 7.53119528e-01f, -3.09356272e-01f, -1.52029127e-01f, -2.94358153e-02f, -6.32747822e-03f, -1.29701197e-01f, -2.63033956e-01f, -3.39759253e-02f, -2.14575261e-01f,
  -4.84681614e-02f, 3.86535525e-02f, 2.03579426e-01f, 1.01128303e-01f, 5.12385778e-02f, 4.02446948e-02f, 6.09396696e-02f, 1.13103837e-01f, 1.64421260e-01f, 7.14028627e-02f,
  -1.06038168e-01f, -3.70561741e-02f, 1.24399923e-01f, 1.32130697e-01f, 1.71073318e-01f, 8.53940099e-02f, 1.42481744e-01f, 1.47828862e-01f, 1.59853980e-01f, 3.89836878e-02f,
  -2.98868082e-02f, 8.13748538e-02f, 2.10181624e-01f, -2.53198855e-02f, 1.22472644e-01f, -6.08271696e-02f, -1.06168993e-01f, -5.26715815e-02f, 1.02861352e-01f, 6.53121099e-02f,
  -9.81613174e-02f, -1.62717793e-02f, -9.49707627e-03f, 3.71038020e-02f, -1.03908904e-01f, 7.24572912e-02f, -4.08607088e-02f, -4.63638380e-02f, 1.29394025e-01f, -4.98451963e-02f,
  3.75362784e-02f, 2.52049398e-02f, 5.42221442e-02f, 1.58084333e-01f, -4.79391031e-02f, 1.61107108e-02f, -9.11512300e-02f, 9.85691622e-02f, 4.20265608e-02f, -1.84875242e-02f,
  -3.56562048e-01f, 4.35661554e-01f, -2.69827962e-01f, -1.41775981e-01f, 7.98901990e-02f, 1.83317140e-02f, 1.56430274e-01f, -1.70283556e-01f, -2.60077715e-01f, -2.79465020e-01f,
  -1.31238684e-01f, -4.91945930e-02f, 2.25932345e-01f, -9.49068442e-02f, -2.35363960e-01f, -2.01824322e-01f, -1.27954453e-01f, 6.96615204e-02f, -1.53477818e-01f, -1.78878620e-01f,
  -1.31796464e-01f, -1.95257783e-01f, -7.82849416e-02f, -1.08775385e-01f, -1.05351247e-01f, -2.04120070e-01f, -1.89792126e-01f, -6.03751391e-02f, 6.93086460e-02f, -1.09758936e-01f,
  9.53079700e-01f, 2.32466102e-01f, -5.12617350e-01f, 5.80666304e-01f, -1.30739138e-01f, -5.73804379e-01f, -5.35511851e-01f, -3.33776951e-01f, 3.73584151e-01f, 3.72306645e-01f,
  2.32362822e-01f, 7.13998377e-01f, 2.56508023e-01f, 2.62103170e-01f, -7.63823166e-02f, -5.42720295e-02f, 2.77805597e-01f, 1.19669601e-01f, -4.50053252e-02f, 2.95844615e-01f,
  5.62380135e-01f, 2.01301396e-01f, 1.62935704e-01f, 1.32388383e-01f, 5.19180775e-01f, 4.86369729e-01f, -7.08458796e-02f, -9.59123485e-03f, 2.62729138e-01f, 8.93676639e-01f,
  3.92324150e-01f, -1.54328323e-03f, 2.64927093e-02f, 2.77330130e-01f, -1.08142711e-01f, 5.52977398e-02f, 1.05328277e-01f, -5.57254665e-02f, -1.35719189e-02f, -8.51908326e-02f,
  2.49403920e-02f, 6.99300542e-02f, 9.82342064e-02f, 4.89959270e-02f, -1.52519405e-01f, -1.82777405e-01f, -3.31685245e-02f, -1.68295391e-02f, 6.34055678e-03f, 7.20785856e-02f,
  2.42127195e-01f, 5.18802032e-02f, -4.12240833e-01f, -3.59041929e-01f, -8.64287466e-02f, 7.40229413e-02f, -1.78723767e-01f, 1.37438821e-02f, -3.00518960e-01f, 8.38363096e-02f,
  4.04768616e-01f, -2.37313309e-03f, -7.45945144e-03f, 1.89714462e-01f, 3.33328843e-01f, 4.48958278e-02f, -4.62716334e-02f, -1.13427512e-01f, 2.21416831e-01f, 4.08641137e-02f,
  9.59768146e-02f, -1.28597133e-02f, -1.11748978e-01f, 5.71233891e-02f, 9.32909846e-02f, 4.25310805e-02f, -5.96621074e-02f, -4.75933403e-02f, -6.85511604e-02f, -1.51465669e-01f,
  4.45609242e-02f, -1.40187055e-01f, -7.79307112e-02f, -1.33265108e-01f, -4.11985032e-02f, 6.83210343e-02f, 2.27089956e-01f, 3.76270115e-02f, 9.31947529e-02f, 8.40032026e-02f,
  -4.87086654e-01f, -4.39138860e-01f, 5.86761296e-01f, -4.34892112e-03f, -1.47581287e-02f, -1.31221026e-01f, 2.88551629e-01f, -6.24264404e-02f, -2.86559947e-02f, -6.35944158e-02f,
  -2.03978807e-01f, 5.26856966e-02f, 5.32493219e-02f, -4.06595767e-02f, -2.40436122e-01f, -1.57526672e-01f, 1.61461920e-01f, 7.30424002e-02f, -2.00059026e-01f, -1.56596527e-01f,
  -2.32276209e-02f, -3.39333683e-01f, -3.92152578e-01f, -2.69647390e-01f, -1.00416541e-01f, -3.34352665e-02f, -2.54537582e-01f, -2.30820268e-01f, -4.22969401e-01f, -2.49830469e-01f,
  4.44811672e-01f, -1.32697177e+00f, -2.31632307e-01f, -4.07120623e-02f, -2.23741964e-01f, -5.63421726e-01f, -1.87111759e+00f, -7.29686022e-01f, 3.64892364e-01f, -1.63188231e+00f,
  -5.14728010e-01f, 9.93846834e-01f, 5.03165007e-01f, 3.05226415e-01f, -4.84226674e-01f, -2.00240993e+00f, -1.01506329e+00f, 2.09449440e-01f, 5.90048134e-01f, -5.17362654e-01f,
  -4.77434099e-01f, 2.91242525e-02f, 8.04022312e-01f, 1.20908663e-01f, -8.55071843e-01f, 1.89735927e-02f, -4.31809664e-01f, -8.81263018e-02f, -7.75316775e-01f, -1.00319993e+00f,
  -6.49600565e-01f, -2.20401838e-01f, 3.95954639e-01f, 3.51669103e-01f, -3.75834256e-02f, -8.75170678e-02f, -1.07651465e-01f, 1.74025130e-02f, 1.27481585e-02f, -1.81497499e-01f,
  7.30045512e-02f, 1.43966317e-01f, 3.10096651e-01f, 1.44255623e-01f, -4.99407023e-01f, -1.52755171e-01f, -2.76311617e-02f, 3.33699375e-01f, -1.61235869e-01f, -5.98899603e-01f,
  -3.11628550e-01f, -3.67438793e-01f, 1.17077731e-01f, -1.60394218e-02f, -4.12782989e-02f, 6.44620538e-01f, 2.14418277e-01f, -4.37799469e-02f, -6.90173358e-02f, -9.68278289e-01f,
  -2.12105095e-01f, 1.90110177e-01f, -7.80520886e-02f, 6.10887110e-02f, 9.76880714e-02f, 6.99543208e-03f, 6.43585473e-02f, -2.25898013e-01f, 3.70451957e-01f, -1.59846276e-01f,
  -1.24262616e-01f, 4.11367193e-02f, 2.37591609e-01f, -2.76077315e-02f, 2.93669373e-01f, 5.98135637e-03f, -2.37094820e-01f, -1.15069076e-01f, 7.17958361e-02f, 9.86218229e-02f,
  -4.17367518e-02f, 1.35292009e-01f, -3.20284694e-01f, -8.79348442e-02f, 6.98735414e-04f, 8.98999721e-03f, 1.74759597e-01f, 1.50951549e-01f, 1.14686266e-01f, -4.63018864e-02f,
  -1.98085442e-01f, 6.15237355e-01f, -4.25645739e-01f, -2.76604341e-03f, -1.23741321e-01f, 1.63519323e-01f, 2.77628809e-01f, 1.83658719e-01f, 4.67469543e-01f, -5.92288077e-02f,
  -5.50067425e-02f, -1.54443309e-01f, -3.56270522e-01f, 1.27959987e-02f, 5.31988814e-02f, -1.36754408e-01f, -5.04050493e-01f, -8.35217070e-03f, -2.40467384e-01f, -6.74449876e-02f,
  -6.36440217e-02f, -5.19018590e-01f, -3.58263522e-01f, -9.80338901e-02f, -8.79289061e-02f, 1.06728464e-01f, -3.24433029e-01f, -6.93049192e-01f, -4.89543289e-01f, -1.21542978e+00f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  8.89050663e-01f, 1.39748538e+00f, 1.33688426e+00f, 3.19443524e-01f, 1.14857519e+00f, 4.86538082e-01f, 6.61112249e-01f, 6.27872467e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -5.63084567e-03f, -6.76172197e-01f, -6.82152450e-01f, 1.93645686e-01f, -2.99937092e-02f, 1.39779806e-01f, -2.54905056e-02f, -3.24112058e-01f, -4.55180347e-01f, -2.10263491e-01f,
  -7.29118466e-01f, 3.72773826e-01f, -1.32625237e-01f, -6.24853253e-01f, -1.39294416e-01f, 4.07073200e-01f, -4.21309859e-01f, -4.09942746e-01f, 1.47370160e-01f, -3.52295041e-02f,
  -2.03489482e-01f, -1.71147659e-01f, -2.66475901e-02f, -5.07959053e-02f, -1.03927207e+00f, -7.39421546e-01f, -1.49002969e+00f, 4.25176442e-01f, -1.26654422e+00f, -5.25382102e-01f,
  -1.95775747e-01f, 6.99442506e-01f, 3.24525565e-01f, -3.68242711e-01f, 3.98573816e-01f, 1.15095101e-01f, -1.20933101e-01f, -1.55625910e-01f, 4.34016921e-02f, -1.87751167e-02f,
  1.55872062e-01f, 3.10783327e-01f, -4.87839758e-01f, -2.73717463e-01f, -1.26353726e-01f, -3.29469979e-01f, 2.79598951e-01f, 9.27624851e-02f, 3.75920326e-01f, 3.93858045e-01f,
  1.66183367e-01f, 6.19032800e-01f, -4.86414582e-01f, -2.24790648e-01f, 2.83673316e-01f, 1.91036448e-01f, -2.31473342e-01f, 7.82467544e-01f, -2.38368964e+00f, -6.74542427e-01f,
  -1.86198330e+00f, 2.99414188e-01f, 2.60960788e-01f, 8.81846070e-01f, 3.88830662e-01f, 3.49143185e-02f, 2.35454068e-01f, 1.94416955e-01f, -1.77057326e-01f, 3.36950511e-01f,
  4.84306484e-01f, 2.22614676e-01f, 4.75156009e-02f, 1.05191454e-01f, 5.26054204e-01f, 4.33263183e-01f, 5.05452394e-01f, 9.54747617e-01f, -4.57869887e-01f, 3.59460920e-01f,
  8.70251417e-01f, -3.64239872e-01f, 3.09629083e-01f, 5.84067583e-01f, 6.68485224e-01f, -4.73035187e-01f, -2.54405260e-01f, 2.45149419e-01f, -1.17085350e+00f, -1.80032492e-01f,
  -1.55517113e+00f, -2.11924410e+00f, -5.47163859e-02f, -7.69827306e-01f, -2.27869108e-01f, 1.39634633e+00f, -1.43792003e-01f, 4.00145240e-02f, -1.40951142e-01f, -1.21657498e-01f,
  -7.63132572e-01f, -1.92186996e-01f, 2.74114579e-01f, 3.25286478e-01f, -8.78704667e-01f, -2.96095759e-01f, 8.46876144e-01f, -1.23958743e+00f, -7.19075859e-01f, 4.25096244e-01f,
  -2.40440026e-01f, -4.98704642e-01f, -4.17521328e-01f, -2.37619475e-01f, -2.74671137e-01f, -1.14830449e-01f, -3.42589647e-01f, -1.18668579e-01f, 3.85079145e-01f, -9.46665764e-01f,
  -7.41070926e-01f, -3.84577155e-01f, -1.94263861e-01f, 5.20742714e-01f, 9.75129604e-01f, -1.10053861e+00f, -1.64322269e+00f, -6.29075468e-01f, -1.36983454e-01f, 4.35585052e-01f,
  -1.13826938e-01f, 6.39890612e-04f, -2.01449350e-01f, -5.00720441e-01f, 3.71713303e-02f, -6.40162289e-01f, 1.26211017e-01f, 2.54578888e-02f, 4.60677326e-01f, 6.64392948e-01f,
  5.23040116e-01f, 6.09817028e-01f, -9.84628052e-02f, 7.31967330e-01f, -2.81964242e-01f, -1.71490565e-01f, -1.68733403e-01f, -2.30329350e-01f, -5.39197385e-01f, -2.44954154e-01f,
  -3.19693863e-01f, -7.89846778e-02f, 3.81602615e-01f, -1.64466608e+00f, 6.56552255e-01f, 5.08935656e-03f, -2.01857641e-01f, 3.18544328e-01f, -8.21299851e-01f, 6.97942451e-02f,
  4.99640167e-01f, -4.37427580e-01f, -1.10602222e-01f, 2.46550161e-02f, 4.98843491e-02f, 5.20762146e-01f, 3.50764811e-01f, 2.50338018e-01f, 4.35234636e-01f, 6.42110109e-02f,
  -7.18810856e-01f, -2.20329873e-02f, -3.84334773e-01f, -5.64671159e-01f, 3.40198398e-01f, -4.56611425e-01f, 4.48778033e-01f, 3.14181745e-01f, 1.16363376e-01f, 6.25506282e-01f,
  5.71726382e-01f, -4.07434642e-01f, -5.77947021e-01f, 6.70232594e-01f, 4.11690772e-01f, -9.67000499e-02f, 4.27810311e-01f, 1.95189431e-01f, -1.46154869e+00f, -8.50578323e-02f,
  7.13050291e-02f, -6.39692545e-01f, -9.52517509e-01f, 1.42488450e-01f, -2.62989551e-01f, 2.34082222e-01f, 4.11261141e-01f, -6.82220832e-02f, -4.07052368e-01f, -7.84146339e-02f,
  -5.71418047e-01f, -2.51754910e-01f, 2.78945327e-01f, -1.47190347e-01f, 4.92536336e-01f, 3.15961003e-01f, 8.59367967e-01f, 4.29790735e-01f, 7.81249166e-01f, -1.98122203e-01f,
  3.49016666e-01f, -7.41864920e-01f, 6.69725955e-01f, 6.81281388e-01f, 9.61882919e-02f, 8.31826568e-01f, -1.21305835e+00f, -1.33085847e+00f, 1.29637480e+00f, -8.16747010e-01f,
  -1.49141574e+00f, -4.52491343e-01f, 3.77394408e-01f, -7.62003005e-01f, -3.10389727e-01f, -2.84450710e-01f, 3.40630859e-02f, 2.01246575e-01f, -9.54844728e-02f, -5.89336157e-01f,
  -2.21732371e-02f, -5.93063593e-01f, -8.46236348e-02f, -1.54911041e-01f, -3.94301176e-01f, -5.66807091e-01f, -8.93985152e-01f, 8.81444737e-02f, -2.47373223e-01f, -4.19804484e-01f,
  6.46861732e-01f, -2.72702157e-01f, -5.04283309e-01f, -1.62171572e-01f, 1.77014932e-01f, -5.39948583e-01f, -1.36131898e-01f, -6.20858133e-01f, -5.45779109e-01f, -6.06123507e-01f,
  -5.96773684e-01f, -8.88297081e-01f, 1.19794619e+00f, -2.20231205e-01f, 1.79664239e-01f, -1.59229982e+00f, -2.35025868e-01f, 4.73769516e-01f, -2.18493566e-01f, 2.89671957e-01f,
  5.65189421e-01f, -8.90092775e-02f, -9.74378586e-02f, -3.55173737e-01f, 3.74487072e-01f, -3.24265450e-01f, 3.09191465e-01f, 7.26894319e-01f, -7.14492321e-01f, 1.00240968e-02f,
  6.30010009e-01f, -5.00795305e-01f, -1.17526531e-01f, 2.55503058e-01f, -3.04126114e-01f, -9.25404489e-01f, 3.71715128e-01f, 6.27601802e-01f, 3.17172636e-03f, 9.10801172e-01f,
  -3.24693888e-01f, 9.70315158e-01f, -1.09062886e+00f, -1.49887443e+00f, 5.48669934e-01f, -2.83814490e-01f, -4.97281700e-01f, -1.04442024e+00f, -3.71594727e-01f, -1.80828441e-02f,
  2.72619039e-01f, -6.00596547e-01f, -4.42317188e-01f, 4.40383643e-01f, -4.81647290e-02f, 2.47542322e-01f, 5.36836267e-01f, 8.49837661e-02f, -1.17848679e-01f, 2.01134250e-01f,
  1.19445157e+00f, 1.44376785e-01f, -8.11949492e-01f, 5.90854585e-01f, -1.03361917e+00f, -9.13728550e-02f, 4.51211303e-01f, 2.87339866e-01f, -3.58359843e-01f, -5.00170887e-01f,
  6.17891848e-02f, 6.89799607e-01f, 1.14627212e-01f, -9.81205404e-01f, 3.81981999e-01f, -1.36367571e+00f, 4.43687916e-01f, -1.45294809e+00f, 7.70782351e-01f, 2.28469148e-01f,
  2.42116988e-01f, 2.60813296e-01f, 9.73866805e-02f, 5.33400811e-02f, 1.64217949e-01f, 1.80402368e-01f, -7.61653930e-02f, 4.42444891e-01f, -8.60519931e-02f, 1.94829866e-01f,
  3.18165451e-01f, 1.29265904e-01f, -3.69748741e-01f, -1.84512153e-01f, -7.62713373e-01f, -2.82870978e-01f, 3.40837121e-01f, 2.13452160e-01f, -9.31818783e-02f, 3.06045651e-01f,
  -6.15332782e-01f, 4.40630555e-01f, 3.64650071e-01f, -1.10176206e+00f, 1.54648030e+00f, -1.01287842e+00f, -1.88985360e+00f, -4.85450357e-01f, -5.48892975e-01f, -1.01660872e+00f,
  -6.17458701e-01f, -9.56038535e-01f, 3.79621267e-01f, 2.74721622e-01f, -7.43788257e-02f, 2.58028865e-01f, -2.47906461e-01f, -2.89341286e-02f, 1.13145627e-01f, 3.60969715e-02f,
  3.93109024e-02f, -2.10161597e-01f, -1.63951412e-01f, 2.23745510e-01f, 6.82005048e-01f, -1.09478757e-02f, 3.44765484e-01f, -1.97244436e-01f, -2.37366840e-01f, 3.43918473e-01f,
  4.59144264e-01f, -1.16041608e-01f, 1.05265722e-01f, 2.77340740e-01f, 2.71534979e-01f, -4.93751377e-01f, -1.44333041e+00f, -1.18036163e+00f, 1.13748085e+00f, -9.32627797e-01f,
  4.80553508e-01f, 8.25803816e-01f, -9.71933961e-01f, -9.77330923e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.98890173e-01f, -1.78580776e-01f, 4.35806543e-01f, -7.54317701e-01f, 7.99187273e-02f, 2.60808975e-01f, 2.80657351e-01f, 6.78809941e-01f, -2.90243536e-01f, -2.43494287e-01f,
  -5.87230742e-01f, -3.55245292e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    