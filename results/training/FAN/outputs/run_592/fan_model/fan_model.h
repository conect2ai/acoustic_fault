/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.53466809e-01f, -3.57265532e-01f, -2.30417758e-01f, -1.26263410e-01f, 1.50481490e-02f, -5.75109236e-02f, -2.61858940e-01f, 3.68713476e-02f, 1.15121581e-01f, -1.18738726e-01f,
  2.19522435e-02f, 2.84621775e-01f, 1.94881901e-01f, 2.33133778e-01f, 1.18959494e-01f, -1.87052578e-01f, 1.51029527e-02f, 8.27186108e-02f, 1.21054687e-01f, 1.08071588e-01f,
  2.77832478e-01f, 4.45712358e-02f, -1.59153957e-02f, 9.08519030e-02f, -9.08494517e-02f, 1.18371673e-01f, -1.96394682e-01f, -1.21956095e-01f, -1.37222439e-01f, -1.95942298e-01f,
  -3.37734938e-01f, -1.65648997e-01f, 1.68299705e-01f, 1.48332611e-01f, 7.06220195e-02f, -1.68023538e-02f, -3.88782546e-02f, 1.45116858e-02f, 7.39096776e-02f, -8.63602161e-02f,
  9.59791839e-02f, 2.55533047e-02f, 5.45927361e-02f, 7.78144598e-02f, -2.50634309e-02f, 5.31414931e-04f, 9.58081260e-02f, 1.21059371e-02f, -9.92776547e-03f, -7.48623013e-02f,
  6.21881336e-02f, -1.38630822e-01f, -2.40488082e-01f, -9.57535021e-03f, -2.78848293e-03f, 5.33593409e-02f, -1.31400034e-01f, -8.71976838e-02f, -3.82026955e-02f, -2.02773303e-01f,
  1.09651349e-01f, -4.69716229e-02f, 7.91883320e-02f, -8.72586817e-02f, -1.08412616e-02f, -6.63809553e-02f, -4.89675552e-02f, -7.63354897e-02f, -2.05683652e-02f, -1.05020866e-01f,
  -2.47347690e-02f, -7.97955096e-02f, -1.01426117e-01f, -4.40602079e-02f, -7.88131207e-02f, -5.53680062e-02f, -5.59110455e-02f, -3.67377363e-02f, -1.18332453e-01f, -6.12631403e-02f,
  -1.47334740e-01f, -2.37275884e-02f, -7.57915750e-02f, 2.51570120e-02f, -2.71073841e-02f, 1.32009080e-02f, -1.98482070e-02f, -1.82369649e-02f, 1.93962920e-02f, -4.77854237e-02f,
  2.53980625e-02f, 2.43787169e-01f, -1.25733510e-01f, 1.10435650e-01f, -2.20410768e-02f, 9.17382985e-02f, 2.74300221e-02f, 5.14410697e-02f, 5.26796468e-02f, -1.24775805e-02f,
  -4.84156758e-02f, 3.41343204e-03f, -1.31646320e-02f, 2.61606239e-02f, 9.24143419e-02f, 3.88236088e-03f, 1.15749419e-01f, 7.34614134e-02f, 6.47191405e-02f, -9.07889102e-03f,
  1.45130251e-02f, -9.08769965e-02f, -9.69682634e-02f, 2.30456702e-02f, -3.33081000e-02f, 7.71964118e-02f, -8.38404298e-02f, -7.59071857e-02f, -1.76257528e-02f, -1.51665106e-01f,
  2.55954444e-01f, 3.48543584e-01f, 3.31122249e-01f, 4.65007126e-01f, 2.42628232e-01f, -1.36584090e-02f, 1.78992093e-01f, 1.18321390e-03f, 5.74047305e-02f, 2.83150345e-01f,
  8.21309164e-02f, -5.04575148e-02f, 4.83891144e-02f, -1.35201603e-01f, 8.89606308e-03f, 3.24002981e-01f, 4.27205890e-01f, 1.00516319e-01f, -7.69850984e-02f, -1.73314035e-01f,
  4.17372435e-02f, 6.36323839e-02f, -1.14061952e-01f, -8.27241316e-02f, 1.36500522e-01f, 7.68388137e-02f, 1.90564364e-01f, 9.62072015e-02f, -7.85406679e-02f, 4.04127151e-01f,
  3.44584912e-01f, -2.64896061e-02f, -9.35167298e-02f, -9.24563482e-02f, -3.73724289e-02f, -4.52639163e-02f, 4.17967066e-02f, -1.80380307e-02f, 2.35741655e-03f, 3.63787785e-02f,
  -1.61239412e-02f, -2.56710351e-02f, 5.50312512e-02f, -3.41503099e-02f, -6.55955970e-02f, -6.63200319e-02f, -4.41728644e-02f, -6.08404689e-02f, -9.75201130e-02f, -1.45211071e-02f,
  6.87018037e-02f, 8.44950043e-03f, 7.80872777e-02f, -3.33417160e-03f, -9.08773318e-02f, -7.17619434e-02f, -5.22566177e-02f, -8.35416093e-02f, -1.62680164e-01f, 1.45260960e-01f,
  4.09062840e-02f, 9.11337137e-03f, 4.51828353e-02f, -1.68783050e-02f, 6.79414049e-02f, 1.86988954e-02f, 8.56198519e-02f, -1.09710675e-02f, -4.50502746e-02f, -1.66272148e-02f,
  2.65795514e-02f, -6.42868355e-02f, -7.21741514e-03f, 2.10118052e-02f, 1.22234272e-02f, -1.02845337e-02f, -8.64418671e-02f, -5.07852994e-02f, -1.50075793e-01f, -4.60681506e-02f,
  -6.97504729e-02f, -7.49272034e-02f, -3.80019806e-02f, -1.07063554e-01f, -2.22667530e-02f, 5.79225868e-02f, -1.38588622e-01f, -6.65526316e-02f, 5.14348447e-02f, 2.07452988e-03f,
  2.63138469e-02f, -2.57189482e-01f, 1.44313157e-01f, 2.45727114e-02f, 6.34646341e-02f, -2.14712247e-02f, 7.33623058e-02f, 9.86821856e-03f, -3.48978601e-02f, 3.24589200e-02f,
  -1.00307651e-02f, 5.25770038e-02f, 9.19481441e-02f, -7.17480406e-02f, 1.82338040e-02f, -3.65176313e-02f, 8.19852650e-02f, 8.57326984e-02f, -1.47493362e-01f, 5.45814261e-02f,
  1.17021978e-01f, 3.28335986e-02f, 1.96650535e-01f, 7.30958506e-02f, -1.28074829e-02f, 8.14345405e-02f, 1.26370057e-01f, 7.42611066e-02f, -8.85863416e-03f, 2.94613332e-01f,
  -4.17274892e-01f, 2.44052768e-01f, 3.67395699e-01f, -1.50317922e-01f, 1.18357465e-01f, 2.42804602e-01f, 4.32363451e-01f, 3.92100997e-02f, 6.07759506e-03f, 2.02525437e-01f,
  -9.20404773e-03f, -3.62479612e-02f, 7.42620304e-02f, 7.80287236e-02f, 1.94507521e-02f, 4.44050193e-01f, 5.62267542e-01f, 3.17833036e-01f, 1.04598403e-01f, 1.56229943e-01f,
  2.95929700e-01f, 8.69266912e-02f, -5.39437532e-02f, 6.44659549e-02f, 2.23082751e-01f, -1.93955423e-03f, 1.59180313e-02f, -3.28848734e-02f, 1.78751066e-01f, 5.70743680e-01f,
  3.46416205e-01f, -6.10212050e-02f, 7.78068881e-03f, 7.72023946e-02f, 1.24687903e-01f, 1.10969804e-01f, 1.06787689e-01f, 6.28110319e-02f, 1.43305421e-01f, 2.20235392e-01f,
  1.06557697e-01f, 1.12829879e-01f, 1.69643555e-02f, 1.57642990e-01f, 3.56351621e-02f, 1.48879975e-01f, 5.66110983e-02f, 9.66314301e-02f, 1.03102624e-01f, 1.60906464e-01f,
  2.17908248e-01f, 1.39870241e-01f, 6.13156930e-02f, 4.35302816e-02f, 9.65514928e-02f, 1.02614701e-01f, 9.58995596e-02f, 4.21423428e-02f, -2.91628484e-03f, 1.14566438e-01f,
  8.38925913e-02f, -1.78271458e-01f, -1.58411056e-01f, -1.00266077e-01f, -5.01588918e-02f, -8.39212313e-02f, -4.40612398e-02f, -2.01088395e-02f, -7.64805824e-02f, -5.38800359e-02f,
  -4.63335514e-02f, -6.05917946e-02f, -3.78283747e-02f, -1.12943739e-01f, -6.89928681e-02f, -6.63196370e-02f, -6.00694865e-02f, -4.57588919e-02f, -1.09152369e-01f, -1.13823622e-01f,
  -6.21152148e-02f, -1.02425031e-01f, -1.57503456e-01f, -5.92300929e-02f, -9.39060450e-02f, 1.77686997e-02f, -8.83535519e-02f, -9.84565094e-02f, -1.75129950e-01f, -1.11398503e-01f,
  -1.35443211e-01f, -2.34171674e-01f, 2.27257907e-01f, 8.50252733e-02f, 1.38895780e-01f, 1.27556249e-01f, 1.59252733e-01f, 1.61940217e-01f, 5.89475185e-02f, 1.07565604e-01f,
  8.64251256e-02f, 3.97312269e-02f, 5.40821254e-02f, 1.46426648e-01f, 1.17151216e-01f, 7.26286024e-02f, 1.61958441e-01f, 1.47351608e-01f, 1.02466442e-01f, 1.71872094e-01f,
  1.97662711e-01f, 1.51466474e-01f, 9.64635387e-02f, 2.45138407e-01f, 7.05731437e-02f, 6.95656836e-02f, 2.42915288e-01f, 2.12191701e-01f, 7.59010203e-03f, 2.89143294e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.71582355e-02f, -1.45034969e-01f, 7.09663704e-02f, 6.77195251e-01f, 5.00944972e-01f, 4.10115600e-01f, 2.11299390e-01f, 2.19410479e-01f, 4.25150186e-01f, 2.63257712e-01f,
  2.40704536e-01f, 3.76339644e-01f, 2.53696293e-01f, 2.80931860e-01f, 1.71984047e-01f, 2.12739885e-01f, 3.36991429e-01f, 9.21167731e-02f, 2.06760988e-01f, 3.24889332e-01f,
  3.58557701e-01f, 1.13253906e-01f, -5.19836061e-02f, 1.88592732e-01f, 5.35726622e-02f, 3.80467862e-01f, 1.22364819e-01f, -8.50942880e-02f, 1.03289060e-01f, 1.42755702e-01f,
  -2.11934134e-01f, -1.66287854e-01f, 1.96393892e-01f, 6.17103837e-02f, -1.34217530e-01f, -2.13729590e-01f, 2.94770952e-02f, -1.99708745e-01f, -1.92261070e-01f, -1.16591863e-01f,
  -8.69669020e-02f, -8.46003443e-02f, -4.57384922e-02f, -1.48515731e-01f, -8.56265798e-02f, -8.21616054e-02f, -1.29757077e-02f, 8.24762359e-02f, 1.44602776e-01f, -2.33015418e-02f,
  6.48103803e-02f, 4.45801318e-02f, 1.11804508e-01f, 5.58664389e-02f, 5.39770275e-02f, 1.02062002e-01f, -2.19570458e-01f, -7.32751563e-02f, -3.13023329e-02f, -3.01240236e-02f,
  3.50984037e-01f, 1.91697583e-01f, 1.24175481e-01f, 5.04267439e-02f, 5.14917299e-02f, -1.93860419e-02f, -5.29936105e-02f, 9.82750356e-02f, 1.21846750e-01f, -2.99719069e-02f,
  3.49674523e-02f, 1.83428362e-01f, 9.27623436e-02f, 6.40815943e-02f, 1.05799936e-01f, -5.53034395e-02f, -1.11340292e-01f, -2.24992428e-02f, -1.21252745e-01f, -1.68812022e-01f,
  1.60429589e-02f, -4.15947102e-02f, -1.55090198e-01f, -4.02217433e-02f, -5.35527878e-02f, 9.95953903e-02f, -3.83769646e-02f, -2.93232445e-02f, -9.43453386e-02f, 3.85667346e-02f,
  2.03988329e-01f, 1.27788797e-01f, 6.33493811e-02f, -8.91226903e-02f, -8.64285380e-02f, -2.10715905e-01f, 1.38055295e-01f, -5.50966747e-02f, -2.85374939e-01f, -9.44371298e-02f,
  -1.64268434e-01f, -2.82142162e-01f, -1.73230559e-01f, -7.67157525e-02f, -1.36132732e-01f, -1.14942156e-01f, -1.32147551e-01f, 1.18377633e-01f, 6.64011762e-02f, -2.10934192e-01f,
  -1.53773889e-01f, 1.56021133e-01f, 8.93700682e-03f, 1.58344865e-01f, 3.53102051e-02f, 1.37086496e-01f, -2.30401650e-01f, -8.81671235e-02f, -3.00221946e-02f, -1.41410619e-01f,
  -1.20814490e+00f, -1.36597484e-01f, 9.24833298e-01f, -7.54647255e-01f, -3.95099610e-01f, -4.50357914e-01f, -7.81532347e-01f, -2.98024893e-01f, -1.84692353e-01f, 1.31035194e-01f,
  -1.08775601e-01f, -3.09397668e-01f, 3.98301154e-01f, 2.44360134e-01f, -1.51938042e-02f, 4.02847797e-01f, 5.14530659e-01f, 5.77212095e-01f, -2.73092359e-01f, -1.04009008e+00f,
  -4.88455504e-01f, -3.54398787e-01f, -2.95153975e-01f, -9.19779483e-03f, -2.39014477e-01f, -7.33084083e-02f, 3.59844357e-01f, -1.16611116e-01f, 8.43735188e-02f, 8.58471841e-02f,
  3.58532280e-01f, -3.85995328e-01f, 8.91559795e-02f, -2.38032505e-01f, -3.83843482e-02f, -2.71162093e-02f, -1.17434576e-01f, 1.28373921e-01f, 4.88698408e-02f, -8.25066958e-03f,
  -1.70331404e-01f, -1.30581304e-01f, -1.50840044e-01f, -7.75486529e-02f, -2.74495453e-01f, -5.15611507e-02f, 1.47146374e-01f, 1.07953601e-01f, 1.68712795e-01f, 4.20518517e-02f,
  -1.88553050e-01f, -7.73358941e-02f, 1.91596881e-01f, 1.57208055e-01f, 7.68528432e-02f, 1.07786968e-01f, -1.60164442e-02f, -3.53255868e-02f, 2.93893576e-01f, 4.00978513e-02f,
  2.56301340e-04f, 2.21352100e-01f, 2.73783953e-04f, 7.95663670e-02f, -3.32254618e-02f, 4.39278707e-02f, -5.54575846e-02f, -7.51965567e-02f, 2.50176676e-02f, -8.06557238e-02f,
  1.39170617e-01f, -9.79218073e-03f, 1.61831360e-02f, -9.14174467e-02f, 5.64800464e-02f, -9.31939632e-02f, 2.09883880e-03f, 8.63538459e-02f, 7.68214092e-02f, -1.26748860e-01f,
  -3.19328755e-02f, 4.97632623e-02f, 7.05834404e-02f, 1.31284061e-03f, 1.08006643e-02f, 9.14345905e-02f, -6.68891473e-03f, -6.62267860e-03f, -4.96200509e-02f, -2.51209773e-02f,
  -2.69665986e-01f, 4.26705688e-01f, -9.04522464e-02f, -8.16165134e-02f, -1.95715219e-01f, 6.30650818e-02f, -1.27855055e-02f, 1.37395458e-02f, -2.39230972e-02f, -7.28336647e-02f,
  -1.14011601e-01f, -7.22798109e-02f, 1.62433684e-01f, 6.45443425e-02f, -1.99695408e-01f, -8.81067812e-02f, -7.17618018e-02f, -9.95265916e-02f, -6.01687431e-02f, 1.27426898e-02f,
  1.22665286e-01f, 1.09975174e-01f, -1.32051006e-01f, 5.11544235e-02f, -2.16254704e-02f, -4.86204065e-02f, 1.03694938e-01f, -9.65669602e-02f, 1.68404669e-01f, -1.17864735e-01f,
  1.03973842e+00f, -1.67532039e+00f, 4.22400177e-01f, 6.23536706e-02f, 3.14188898e-01f, 5.49084723e-01f, -2.85898477e-01f, -3.73419136e-01f, -3.67958881e-02f, -4.03927028e-01f,
  -7.42055297e-01f, -2.17778549e-01f, -2.28918880e-01f, -3.12323153e-01f, -3.25757340e-02f, -1.06306024e-01f, 1.75789580e-01f, 7.33487368e-01f, 1.01347899e+00f, 7.45587200e-02f,
  -4.91517663e-01f, -1.02098703e-01f, 2.63412952e-01f, 1.45353097e-02f, -4.38918114e-01f, 6.07159026e-02f, -3.23397368e-01f, -1.26079366e-01f, -4.08455670e-01f, -4.53155905e-01f,
  -5.14428876e-02f, -3.85173589e-01f, 2.88815469e-01f, -1.49327934e-01f, -1.82391733e-01f, -8.21605846e-02f, 6.87954351e-02f, 8.81236866e-02f, -4.63874592e-03f, 2.36295797e-02f,
  -4.60773632e-02f, -6.36199936e-02f, 2.78698113e-02f, -8.35314095e-02f, 7.93146491e-02f, -6.25477582e-02f, -8.07963312e-02f, -1.70822471e-01f, -9.51395556e-02f, -2.42987022e-01f,
  -4.65149403e-01f, -7.35089197e-05f, 1.99331239e-01f, -1.13656670e-01f, -1.78409815e-01f, 2.97207206e-01f, -2.80775487e-01f, -5.89944571e-02f, 4.90799360e-02f, -2.25588724e-01f,
  -7.08752126e-02f, 7.32049495e-02f, -2.57179253e-02f, -4.49237004e-02f, -5.90157099e-02f, 8.67389217e-02f, 8.03542063e-02f, -2.43148599e-02f, 3.68722714e-02f, 1.48309506e-02f,
  1.10986102e-02f, -3.56849320e-02f, -5.79511467e-03f, -2.54530609e-02f, -1.16827168e-01f, 6.48004282e-03f, 8.49737227e-02f, -2.14762390e-01f, -5.75547665e-02f, 3.42477188e-02f,
  3.57384123e-02f, -7.43988808e-03f, 2.46372055e-02f, -6.28643632e-02f, -7.24829957e-02f, 2.54698545e-02f, -1.90984402e-02f, -1.60884738e-01f, 3.91931320e-03f, 1.23756751e-01f,
  -1.16078936e-01f, 1.90595999e-01f, 9.14194584e-02f, -1.89493746e-01f, 1.05966888e-01f, -1.23678312e-01f, -1.20636597e-01f, 2.12514549e-02f, 2.97967121e-02f, -1.91572681e-02f,
  -4.79866341e-02f, 1.13413416e-01f, -7.48518780e-02f, -1.35145243e-02f, 1.15045264e-01f, 2.53267051e-03f, -1.99292794e-01f, 2.74778366e-01f, 3.89402620e-02f, 3.15122865e-02f,
  -1.46292686e-01f, 1.66047096e-01f, 3.14084560e-01f, 1.84471563e-01f, -4.85073868e-03f, 5.07856488e-01f, 3.93770523e-02f, 1.26757205e-01f, 4.19000596e-01f, 8.24787393e-02f,
  -4.38891709e-01f, -4.33995456e-01f, -1.07832897e+00f, -4.01282132e-01f, -8.55076909e-01f, -5.43148577e-01f, -2.17605978e-01f, -1.08506568e-01f, -3.06703895e-01f, -4.76013452e-01f,
  -2.78350376e-02f, 6.77597344e-01f, 3.06444168e-01f, 1.88348889e-01f, 4.36456591e-01f, -6.14028752e-01f, -8.97508979e-01f, -3.20968360e-01f, 5.75183809e-01f, 5.25593400e-01f,
  1.53256580e-01f, 2.47359768e-01f, 1.54331878e-01f, 9.60934162e-02f, -2.19326392e-01f, 1.49314150e-01f, -4.68537569e-01f, -3.38677347e-01f, -2.48693585e-01f, -7.20752060e-01f,
  3.00120831e-01f, -7.29685307e-01f, 7.88732916e-02f, 4.20610383e-02f, -1.80208415e-01f, 9.78689715e-02f, 1.48609608e-01f, -1.39282465e-01f, 4.74902093e-02f, -3.46733421e-01f,
  -1.44540638e-01f, -2.72118151e-02f, 6.73213899e-02f, 1.76734820e-01f, -1.26911944e-03f, -5.89576140e-02f, -1.56796634e-01f, -2.36972347e-02f, -4.70498681e-01f, -1.31790519e-01f,
  -6.62693009e-02f, -3.54097813e-01f, -3.41162056e-01f, -5.03146015e-02f, -9.98025313e-02f, -1.15973815e-01f, 1.45220712e-01f, -7.01371161e-03f, -2.61627913e-01f, -1.68985571e-03f,
  -5.56352623e-02f, -1.46275582e-02f, -2.51798816e-02f, -6.34371955e-03f, 5.23054563e-02f, -7.73664936e-02f, 6.23451471e-02f, 1.04801916e-01f, 2.53205188e-02f, 3.17227989e-01f,
  -5.07426038e-02f, -7.60068968e-02f, 6.23612106e-03f, -1.13164492e-01f, 7.39612356e-02f, 7.06503093e-02f, 5.07349789e-04f, 2.24171042e-01f, -6.08998910e-02f, -2.16395482e-01f,
  4.36283797e-02f, -1.59176096e-01f, -2.24800762e-02f, 2.38772139e-01f, -3.26835394e-01f, 2.72712223e-02f, 2.40237266e-03f, 7.42277205e-02f, -4.58577834e-02f, -5.30708805e-02f,
  8.43245089e-01f, -3.79694283e-01f, 1.90554529e-01f, 2.54740030e-01f, -1.94327682e-01f, -1.14117965e-01f, -7.00716227e-02f, 1.27040476e-01f, 7.36941025e-02f, 1.17378369e-01f,
  -9.56883952e-02f, 1.13161631e-01f, -6.16512634e-02f, -3.48018147e-02f, 9.05887187e-02f, 1.37363560e-02f, -7.43848011e-02f, -2.64054886e-03f, -1.11822002e-01f, -1.62681751e-02f,
  -6.35586753e-02f, 3.80670116e-03f, 1.81736812e-01f, 2.28671789e-01f, 8.55832472e-02f, 9.72711965e-02f, 2.68083364e-01f, 2.69340932e-01f, 9.84174088e-02f, 4.36374813e-01f,
  8.40585887e-01f, 9.06146705e-01f, -1.14288211e+00f, 6.73461556e-01f, -4.32044715e-01f, -6.06208026e-01f, -7.45552927e-02f, 4.58165914e-01f, 4.30531234e-01f, 2.04953298e-01f,
  1.08059287e-01f, -4.71686751e-01f, -4.02517617e-01f, -3.22742015e-01f, -6.89336002e-01f, -1.68776989e-01f, -3.46542358e-01f, -9.66814518e-01f, -1.26836896e+00f, -9.07805741e-01f,
  -4.80970025e-01f, -1.05056040e-01f, -4.40229056e-03f, -1.64095432e-01f, -2.50427816e-02f, -1.98381722e-01f, 1.56688035e-01f, -2.41545543e-01f, -4.69901323e-01f, -1.45521775e-01f,
  -8.56627703e-01f, 1.58640578e-01f, -3.20943892e-01f, 1.02820843e-01f, -2.89143994e-04f, 1.35069549e-01f, -1.64431974e-01f, -2.50097062e-03f, 1.18386008e-01f, 8.01155493e-02f,
  -1.58249199e-01f, -1.70558706e-01f, -1.96824208e-01f, -3.37389380e-01f, -1.14584208e-01f, -2.50153631e-01f, 6.94519132e-02f, -1.65161476e-01f, -1.78255707e-01f, -1.86984956e-01f,
  -9.38199311e-02f, -3.91965479e-01f, -2.51568168e-01f, 1.56896561e-01f, -3.91311675e-01f, -4.16138798e-01f, -1.98955312e-01f, -1.60681650e-01f, -2.61722744e-01f, 5.05812645e-01f,
  5.99351806e-05f, 1.13678478e-01f, 1.25252604e-01f, 2.37686023e-01f, 1.66689098e-01f, 9.76397321e-02f, -6.76384196e-03f, 2.03445077e-01f, -4.60087098e-02f, -8.16900842e-03f,
  -2.19311472e-02f, 6.56376779e-02f, -4.51231971e-02f, 1.51865408e-01f, -1.25743121e-01f, -7.59282634e-02f, -3.60557176e-02f, 1.02342300e-01f, -8.50097910e-02f, 1.59534946e-01f,
  -1.38263255e-01f, -1.52523816e-01f, 3.76154892e-02f, 2.88022519e-03f, 4.14872319e-02f, -1.05079198e-02f, -3.29750389e-01f, 7.98731763e-03f, -2.89640418e-04f, -1.57003209e-01f,
  4.71382350e-01f, -3.05061191e-02f, 1.67724285e-02f, -1.13275811e-01f, -1.06845289e-01f, 3.04723550e-02f, 1.33746415e-01f, 1.01518102e-01f, 1.51242316e-01f, 3.46401595e-02f,
  -1.14954300e-01f, -2.01470815e-02f, 7.91569576e-02f, 3.28214616e-02f, -1.16738901e-01f, -6.74478263e-02f, 1.90626368e-01f, -2.05624592e-03f, -2.73616295e-02f, 9.72398520e-02f,
  2.49714941e-01f, 3.78381848e-01f, 3.27818155e-01f, 3.45234871e-01f, -9.03022215e-02f, -9.06456355e-03f, 4.31844443e-02f, -2.62330230e-02f, 4.63712066e-02f, 8.86493206e-01f,
  6.09102368e-01f, -1.76449239e-01f, 4.47773010e-01f, 4.51155275e-01f, -2.86921859e-01f, -1.01193857e+00f, -1.66628528e+00f, -9.68388975e-01f, 1.46904131e-02f, -1.96345188e-02f,
  -1.97462767e-01f, 1.44368261e-01f, 1.03546873e-01f, -1.66974604e-01f, -5.05533338e-01f, -3.12675804e-01f, 1.56454101e-01f, 2.69414812e-01f, -2.51475632e-01f, -3.36046368e-01f,
  -6.66463375e-02f, 3.65748137e-01f, 3.84404540e-01f, 1.68354839e-01f, 6.03787720e-01f, 1.14817247e-01f, 5.08529007e-01f, 6.24553025e-01f, 9.70958080e-03f, 9.51215327e-01f,
  6.58671260e-01f, 8.55510086e-02f, -4.62793350e-01f, 2.82940060e-01f, 3.94380987e-01f, 1.48662090e-01f, 1.00512728e-01f, 3.86450946e-01f, -5.71313240e-02f, 2.08651215e-01f,
  3.07865769e-01f, 1.26769811e-01f, 1.00242987e-01f, 1.07479274e-01f, -1.33095765e-02f, -1.41921803e-01f, 1.39929160e-01f, -2.96298843e-02f, 5.70061952e-02f, -2.93633882e-02f,
  -4.40324172e-02f, -1.69071387e-02f, -3.46668422e-01f, -5.69521606e-01f, -1.66088209e-01f, 1.86658517e-01f, -1.43548965e-01f, 1.01525269e-01f, -1.68697610e-01f, 2.92094648e-01f,
  -1.47309765e-01f, 2.92491335e-02f, 7.54938871e-02f, 4.50869761e-02f, -3.86478789e-02f, -1.73887443e-02f, 1.39649868e-01f, -1.11238286e-01f, -5.44920266e-02f, -4.58295792e-02f,
  -2.23061904e-01f, 6.51164353e-02f, 7.97521695e-02f, 1.38119519e-01f, -9.42966491e-02f, 1.97154164e-01f, 8.47847108e-03f, 5.26212864e-02f, 9.62708984e-03f, -4.92711104e-02f,
  -9.33621675e-02f, -9.47519615e-02f, 2.76516616e-01f, -7.45305866e-02f, -9.76993889e-02f, 6.64825514e-02f, 1.95309356e-01f, 1.66492742e-02f, 7.53617510e-02f, 1.43471971e-01f,
  6.82762340e-02f, -6.45908415e-01f, 3.22056830e-01f, 7.44112879e-02f, 1.30165190e-01f, -8.65473226e-03f, 1.18269689e-01f, 9.57778073e-04f, 1.98866367e-01f, -1.98348671e-01f,
  -6.76990077e-02f, -2.05635652e-01f, -5.46400435e-02f, -2.92053930e-02f, -2.04259381e-01f, -2.58379825e-03f, -1.07615791e-01f, -1.98428392e-01f, -1.32032275e-01f, 8.96053165e-02f,
  -8.60343277e-02f, -5.08056164e-01f, -6.84218585e-01f, -5.52203298e-01f, -1.89911991e-01f, -5.67406416e-01f, -3.09196442e-01f, -1.78258672e-01f, -6.15706384e-01f, -6.64783776e-01f,
  -1.12884986e+00f, 3.90504956e-01f, 3.33338901e-02f, -3.08909386e-01f, 8.65341842e-01f, 4.26633358e-01f, 5.74504316e-01f, -1.23102188e-01f, -2.54992038e-01f, 1.08724833e-01f,
  3.67534786e-01f, 2.80951578e-02f, -5.49691133e-02f, 1.16580151e-01f, -3.72810423e-01f, 2.63333887e-01f, 3.76398623e-01f, -2.45874465e-01f, -4.61736351e-01f, -8.77798274e-02f,
  3.92396003e-01f, -3.42913777e-01f, -7.34546542e-01f, -2.05748454e-01f, 1.79834425e-01f, -1.81139335e-01f, 2.17817798e-02f, 1.50235236e-01f, 4.28051114e-01f, 4.64169413e-01f,
  4.22721133e-02f, -2.03282893e-01f, -2.74416525e-02f, 4.58060354e-02f, 1.40397921e-01f, -3.91245216e-01f, -1.10391341e-01f, -6.99379370e-02f, 1.35997564e-01f, -2.32315302e-01f,
  1.68480486e-01f, 9.94010270e-02f, 3.10938984e-01f, 1.27929002e-02f, -1.66857347e-01f, -9.76308435e-02f, -2.38841847e-01f, -3.90609682e-01f, -6.37021542e-01f, -2.39746138e-01f,
  5.05391002e-01f, 5.50537527e-01f, -8.94833282e-02f, 1.49024382e-01f, -2.67740935e-01f, -1.31625593e-01f, -1.50128722e-01f, -3.32273483e-01f, -5.59019089e-01f, -6.23856544e-01f,
  9.10413079e-03f, 6.51529506e-02f, 1.44826353e-01f, -2.78736334e-02f, -5.67724817e-02f, 1.50183186e-01f, 1.49586931e-01f, 1.13409683e-01f, 8.65507871e-02f, -9.07990187e-02f,
  7.21307099e-02f, -2.38815807e-02f, 1.34288147e-02f, -1.78080760e-02f, -1.60575602e-02f, 1.41928852e-01f, 2.84975559e-01f, 2.48536356e-02f, -1.42239988e-01f, -1.04809940e-01f,
  -5.30721024e-02f, -4.21762764e-02f, -1.26057625e-01f, -8.79720077e-02f, 1.62047312e-01f, -6.36337027e-02f, 8.11910443e-03f, -1.55885136e-02f, -9.06225368e-02f, -1.79232195e-01f,
  -4.30834830e-01f, 1.10324830e-01f, -2.84380257e-01f, 1.86334252e-02f, 5.52073158e-02f, -1.73557743e-01f, 1.94831993e-02f, 4.10797633e-02f, -9.54671670e-03f, -1.84361443e-01f,
  -2.70034194e-01f, -1.83028713e-01f, -1.52418107e-01f, -2.85442658e-02f, -1.13068469e-01f, -1.28725797e-01f, 1.34148389e-01f, 8.63979831e-02f, -5.48522137e-02f, -1.30611748e-01f,
  3.66018265e-02f, -2.80995667e-01f, -3.91299874e-01f, -8.02963227e-02f, -2.28096709e-01f, -2.16227248e-01f, -2.88353711e-01f, -4.25706238e-01f, -3.15747321e-01f, -7.45348573e-01f,
  -9.34798896e-01f, -1.02468707e-01f, -1.03684723e-01f, -4.36438620e-01f, 4.37142313e-01f, 3.23483676e-01f, -5.20588793e-02f, -1.02683187e-01f, -5.56779280e-02f, -2.02882856e-01f,
  3.23535740e-01f, -6.02950454e-02f, -3.08203578e-01f, -5.51500976e-01f, -1.18568349e+00f, -5.99004209e-01f, -8.40096831e-01f, -9.97234166e-01f, -4.12823439e-01f, 3.21715444e-01f,
  3.05944115e-01f, -3.72166216e-01f, -6.92489207e-01f, -1.63562924e-01f, 2.53181666e-01f, 4.35411930e-02f, 5.89669608e-02f, 1.74521154e-03f, 3.47897947e-01f, -2.78002881e-02f,
  1.62925735e-01f, 4.69299138e-01f, 6.75392598e-02f, -2.51958370e-01f, 1.36155277e-01f, -3.93342599e-03f, 3.71342301e-02f, -8.37420594e-05f, 1.27634883e-01f, -8.43363404e-02f,
  1.55940086e-01f, 1.30526409e-01f, 6.75791129e-02f, 1.03172392e-01f, -2.26250738e-02f, -3.74033563e-02f, -1.58969194e-01f, -2.58842647e-01f, -2.77049124e-01f, 3.27642053e-01f,
  1.30746216e-01f, 1.22905299e-01f, -1.68382257e-01f, 1.56795159e-01f, 3.06813568e-01f, 1.02214389e-01f, 4.52101886e-01f, 3.80611360e-01f, 2.25930393e-01f, -1.59914389e-01f,
  -5.28233051e-02f, 9.53140408e-02f, 1.34056330e-01f, -7.74060339e-02f, -9.60820466e-02f, 8.41689184e-02f, -9.56484377e-02f, -1.91392660e-01f, 1.92177873e-02f, -1.03900447e-01f,
  -2.32367292e-02f, 5.26893921e-02f, -1.50070414e-02f, -2.26230308e-01f, 5.17974049e-02f, -3.90658006e-02f, -2.88187005e-02f, -1.43195674e-01f, -3.98882143e-02f, 9.70262140e-02f,
  -1.68930814e-01f, 2.27241978e-01f, 1.94662046e-02f, -3.20855789e-02f, -4.44723200e-03f, -7.89084285e-02f, 1.09425828e-01f, 5.07406481e-02f, 5.34314513e-02f, 8.73427913e-02f,
  -6.19655669e-01f, -6.50469214e-02f, -1.36191949e-01f, -3.73755246e-02f, -9.46421474e-02f, -4.93742786e-02f, -1.58158496e-01f, -6.88736662e-02f, 1.55935571e-01f, -1.17016390e-01f,
  1.67690605e-01f, -2.34686181e-01f, -4.62323911e-02f, -2.52526775e-02f, 8.78074914e-02f, -4.59329002e-02f, -1.67525649e-01f, -3.27225626e-01f, -4.41874517e-03f, 3.12978625e-01f,
  -1.05037808e-01f, -3.82709205e-01f, -6.05339706e-01f, -2.32073411e-01f, 1.08679175e-01f, -2.77551204e-01f, -4.51110788e-02f, 2.17295121e-02f, -3.06692421e-01f, -7.91135550e-01f,
  1.42745340e+00f, -6.21901989e-01f, -3.20052624e-01f, 2.88207233e-01f, -3.05970311e-01f, -1.40731364e-01f, -5.08275151e-01f, -4.49397750e-02f, 1.95613816e-01f, -2.08720013e-01f,
  9.20998007e-02f, 3.97640079e-01f, 3.28801662e-01f, 2.80939221e-01f, 3.82594109e-01f, -3.04564446e-01f, -3.34145308e-01f, 9.17046368e-02f, 4.94856507e-01f, 3.81401442e-02f,
  -1.86742425e-01f, -2.02460125e-01f, 1.88354790e-01f, 2.67477762e-02f, -3.47159654e-01f, 1.01648331e-01f, -3.57525080e-01f, -1.96635857e-01f, -1.91934213e-01f, -4.63293523e-01f,
  -1.11037225e-01f, 4.15850356e-02f, 5.75575754e-02f, 1.11774854e-01f, -1.40082166e-01f, 1.14252508e-01f, 8.62430260e-02f, -1.10573284e-01f, 8.70725363e-02f, -5.67488037e-02f,
  -3.13898213e-02f, 3.57050896e-02f, 4.42252383e-02f, -1.30182996e-01f, -1.97426647e-01f, -2.68502049e-02f, 5.92488535e-02f, 1.24595150e-01f, -4.30743955e-03f, -2.85911765e-02f,
  -7.98677728e-02f, -9.80604962e-02f, -2.34492850e-02f, 1.55487731e-01f, 1.74550682e-01f, 2.28880778e-01f, -1.68498427e-01f, 3.45375277e-02f, 1.82582214e-01f, -5.08708581e-02f,
  2.91863512e-02f, -5.39787374e-02f, 2.07434863e-01f, 9.22254547e-02f, 1.73662260e-01f, 7.18737766e-02f, -1.96579155e-02f, -2.10173409e-02f, 1.70857549e-01f, -1.98082756e-02f,
  -1.47745237e-01f, 1.53763637e-01f, 1.37840241e-01f, -1.53519344e-02f, -3.38567682e-02f, -1.07364006e-01f, 5.70941567e-02f, 5.62151559e-02f, -2.83957459e-02f, -5.43070100e-02f,
  1.85752288e-01f, -7.61320293e-02f, -1.04682423e-01f, -6.39154166e-02f, -6.44759685e-02f, 9.54435952e-03f, -1.00336336e-02f, -1.08480686e-03f, -8.05167258e-02f, -1.29372686e-01f,
  -1.68521777e-01f, 2.93056995e-01f, 3.46970670e-02f, 9.44195017e-02f, -2.44105235e-02f, -6.31687269e-02f, 6.96205124e-02f, -7.08839074e-02f, -9.62466151e-02f, -8.03805664e-02f,
  -1.56820714e-02f, 1.04076788e-01f, -1.16247296e-01f, -4.47636098e-02f, 1.98361333e-02f, 5.42419311e-03f, 5.41433506e-02f, 9.44031104e-02f, -1.97145343e-02f, -1.37449831e-01f,
  -1.56367645e-01f, 1.96730252e-02f, 2.21389949e-01f, 9.30991769e-02f, 3.63820046e-02f, 2.42242455e-01f, -9.77062732e-02f, -4.05448861e-02f, 8.56991932e-02f, -4.05919552e-02f,
  1.11212206e+00f, 5.21474063e-01f, 4.32741225e-01f, 4.21634242e-02f, 1.43732131e-01f, 3.06721240e-01f, 7.17922211e-01f, 4.97176081e-01f, -8.04426428e-03f, 2.37549961e-01f,
  2.10673548e-02f, -5.71707547e-01f, -4.56282526e-01f, -4.48557466e-01f, 2.08364949e-01f, 2.59311914e-01f, 8.33158493e-02f, 2.19251618e-01f, 3.18931527e-02f, 8.54366496e-02f,
  -2.28200614e-01f, 3.32596451e-01f, 4.42902505e-01f, 3.75417410e-03f, -1.12169338e-02f, -4.24896508e-01f, 1.26835331e-01f, 2.15053588e-01f, -7.66110420e-02f, -2.66317904e-01f,
  -7.97263160e-02f, 5.41966558e-01f, -4.19053942e-01f, -3.05605918e-01f, 6.95851520e-02f, 8.65017064e-03f, -2.22529378e-02f, 6.08134791e-02f, -1.78597739e-03f, -2.19191108e-02f,
  -1.32785439e-01f, 9.45329815e-02f, -7.83299282e-03f, 1.87083147e-02f, 1.62509054e-01f, -1.82576925e-02f, 1.37766317e-01f, 1.31690472e-01f, -5.64601757e-02f, -1.41891599e-01f,
  -2.92502135e-01f, 5.59134632e-02f, 2.70880342e-01f, -4.39993292e-02f, 3.60103510e-02f, -1.60352245e-01f, 1.36805490e-01f, -5.60654365e-02f, 6.58944175e-02f, 1.62829608e-01f,
  -6.37059240e-03f, 1.83274716e-01f, 3.27457152e-02f, 1.79541320e-01f, 1.00043960e-01f, -9.46372822e-02f, -4.37677205e-02f, 6.57077730e-02f, 4.38572466e-02f, 2.02216119e-01f,
  -1.16298184e-01f, -4.29784916e-02f, 7.59800598e-02f, -3.46073732e-02f, -1.42407775e-01f, 6.53329641e-02f, -5.05818166e-02f, -5.70382643e-03f, 2.95532551e-02f, -5.61351962e-02f,
  7.30636939e-02f, -2.71585714e-02f, -9.25976858e-02f, 1.77750066e-02f, 3.16351876e-02f, 2.49065403e-02f, -4.11692001e-02f, -8.66931956e-03f, -2.66700070e-02f, 4.40869927e-02f,
  -3.07345510e-01f, -2.64183283e-01f, -1.00272834e-01f, -5.45807788e-03f, 2.19325081e-01f, -1.44324496e-01f, -2.26261735e-01f, -1.19345412e-01f, -1.32996291e-01f, -4.45155352e-02f,
  -8.94398689e-02f, -1.52499437e-01f, 3.11651137e-02f, 4.11375090e-02f, -5.76492818e-03f, -5.44891134e-02f, -7.97884315e-02f, -1.22731484e-01f, -9.00591165e-02f, -5.16207777e-02f,
  -1.50656536e-01f, 5.27039766e-02f, -6.83194622e-02f, -1.52407765e-01f, -1.12324946e-01f, -3.17930639e-01f, -1.13173261e-01f, -5.68627156e-02f, 1.64714485e-01f, 2.38088369e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  4.04374987e-01f, 9.76498842e-01f, 6.02506697e-01f, 7.94605315e-01f, 1.15927315e+00f, 9.40458953e-01f, 3.01674962e-01f, 5.85083425e-01f, 4.34832543e-01f, 7.78559327e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -6.17811270e-02f, 1.17650233e-01f, -3.44620980e-02f, 6.24740906e-02f, 7.89524913e-02f, -4.35617566e-02f, -2.31256917e-01f, -3.94620985e-01f, 3.09077680e-01f, -2.68852949e-01f,
  -1.85321212e-01f, 3.61409158e-01f, 2.49046803e-01f, -2.60370195e-01f, -1.40618291e-02f, 2.90936708e-01f, 9.92611633e-04f, -3.12691703e-02f, 9.10902768e-02f, -2.40700915e-01f,
  -8.21228027e-02f, 6.81645498e-02f, -2.15032935e-01f, 6.40545547e-01f, 3.85528505e-01f, 1.73424128e-02f, -4.59092259e-01f, -1.45558253e-01f, -6.42966628e-02f, -3.95941496e-01f,
  2.93309808e-01f, 5.25283158e-01f, -4.63444926e-02f, 3.19410843e-04f, 1.98661853e-02f, 2.49605980e-02f, -9.38577019e-03f, -1.07992016e-01f, -3.60371351e-01f, 1.14943579e-01f,
  -2.32616425e-01f, -1.49844751e-01f, -6.28804490e-02f, 2.78712898e-01f, -1.88855350e-01f, 2.71598130e-01f, -2.51390308e-01f, 5.06306648e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.98251891e-01f, 2.50044674e-01f, 1.64167240e-01f, 3.87653500e-01f, -3.68084133e-01f, -2.21770182e-01f, 2.35263318e-01f, 8.34149063e-01f, -3.99522096e-01f, 1.37877250e+00f,
  3.91584486e-01f, 7.57053137e-01f, -5.73645234e-01f, 3.06056529e-01f, 8.88809919e-01f, 3.49236615e-02f, -2.21614450e-01f, 2.53575087e-01f, 2.29340404e-01f, 1.78708911e-01f,
  5.28965235e-01f, -3.36095750e-01f, -2.39974773e-03f, -5.45823038e-01f, -9.38295722e-01f, 4.31268513e-01f, 9.47890937e-01f, 4.05910522e-01f, -6.40050232e-01f, -2.76654780e-01f,
  3.90630215e-01f, 8.84568274e-01f, 1.39479771e-01f, 2.98728734e-01f, 1.19912364e-01f, 1.45153910e-01f, -5.31045767e-03f, -4.94290590e-01f, 6.57572925e-01f, -4.46210831e-01f,
  1.26423514e+00f, 1.44751698e-01f, 1.04242158e+00f, -6.46704793e-01f, 3.23221982e-01f, -4.41226572e-01f, 3.61212075e-01f, 9.61682081e-01f, -3.10968131e-01f, -5.86866975e-01f,
  -2.95281768e-01f, 1.69798687e-01f, 4.12624687e-01f, -2.95371958e-03f, 4.46917981e-01f, -9.13801074e-01f, 2.54891366e-01f, 3.61963689e-01f, -1.34203359e-01f, 1.90984219e-01f,
  1.18121386e+00f, 5.20214319e-01f, 6.55414522e-01f, -1.03069521e-01f, 4.56851780e-01f, 3.18840116e-01f, 8.84275138e-02f, -4.75465357e-01f, -9.95920878e-03f, -8.97852927e-02f,
  2.20430523e-01f, 1.80762544e-01f, -1.13949263e+00f, -1.94650739e-01f, 9.28286135e-01f, 3.80176634e-01f, 1.99526653e-01f, 3.54356885e-01f, -5.30393183e-01f, 2.79226542e-01f,
  1.62864611e-01f, 2.66823024e-01f, 1.85046077e-01f, -1.05732173e-01f, -4.48837690e-02f, -4.26498979e-01f, 5.02579920e-02f, -2.70431429e-01f, 2.92878628e-01f, -3.46704960e-01f,
  2.87218750e-01f, 1.94176793e+00f, -3.85149926e-01f, 1.07325017e-01f, 4.69496161e-01f, 6.21627033e-01f, 3.60642225e-01f, -8.95169303e-02f, 5.58282495e-01f, 1.58957869e-01f,
  -2.45841220e-01f, -2.64941603e-01f, -2.06252217e-01f, -8.82718503e-01f, -3.19619328e-01f, 1.23841269e-02f, 1.05281556e+00f, 7.09000766e-01f, 3.38149548e-01f, 9.90179718e-01f,
  2.42680520e-01f, -1.13054848e+00f, -2.29727209e-01f, 3.92347090e-02f, 3.31733197e-01f, -7.45840371e-02f, 4.39578861e-01f, -3.75507832e-01f, -2.73382843e-01f, 1.69953957e-01f,
  -6.64790988e-01f, 7.48749018e-01f, 4.73027319e-01f, -6.58491790e-01f, 1.03145802e+00f, 1.50836122e+00f, -7.49442279e-01f, 5.99320889e-01f, 3.83638442e-01f, 3.86079669e-01f,
  4.81506139e-01f, -2.71046400e-01f, 8.50340962e-01f, 6.38071477e-01f, 1.37106642e-01f, -4.18898642e-01f, 6.26720786e-01f, 1.06773889e+00f, 3.24308693e-01f, 9.50263023e-01f,
  -4.96764541e-01f, -2.35645115e-01f, -4.23874736e-01f, 3.50083947e-01f, 3.12765211e-01f, 5.35391033e-01f, 5.06326616e-01f, 6.93384469e-01f, -3.85346830e-01f, -1.19268950e-02f,
  4.46721166e-01f, 1.37449694e+00f, -2.39686556e-02f, -5.92194021e-01f, 3.85425240e-02f, 6.45429313e-01f, 9.52011824e-01f, 2.97249466e-01f, -8.04979920e-01f, -8.53514731e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  2.02760056e-01f, 6.35116249e-02f, -2.47302960e-04f, -1.89470962e-01f, 6.94472492e-01f, 8.10309947e-01f, 4.92728390e-02f, 3.25029284e-01f, 4.59042966e-01f, 1.29692346e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  8.78605321e-02f, -1.80975765e-01f, 1.44410178e-01f, 2.17544317e-01f, 1.09944612e-01f, -3.46236043e-02f, 3.24131280e-01f, -7.23069115e-03f, -2.92027831e-01f, 8.29847872e-01f,
  -4.24308419e-01f, -3.35851580e-01f, 2.99337238e-01f, 2.96977550e-01f, -3.75711501e-01f, -1.56833291e+00f, -5.71849763e-01f, 3.96694183e-01f, -1.37373161e+00f, -7.26924837e-01f,
  8.78462434e-01f, -7.69211948e-02f, 5.85316360e-01f, 1.00990936e-01f, 5.93678415e-01f, 2.16421440e-01f, -6.65694773e-01f, -3.44134957e-01f, -2.34746084e-01f, -1.15748727e+00f,
  -2.62840390e-01f, -9.12018359e-01f, 5.10259271e-01f, 5.24454117e-01f, -9.74086449e-02f, 1.15947509e+00f, 3.45874161e-01f, 2.45849729e-01f, 6.55173898e-01f, -6.39149249e-01f,
  -2.08477989e-01f, -5.51534712e-01f, -1.24872017e+00f, 3.73727441e-01f, -3.30320299e-02f, -1.25966549e+00f, -4.14191723e-01f, 5.53063989e-01f, -1.46703899e-01f, -6.87539816e-01f,
  6.34167850e-01f, -2.95639575e-01f, -5.29206276e-01f, 1.14346191e-01f, -1.19928680e-01f, -1.18093014e+00f, -7.02354431e-01f, -4.89413798e-01f, 2.52156377e-01f, -2.11294532e+00f,
  3.08055818e-01f, 5.73023319e-01f, -1.54534996e+00f, 7.14697897e-01f, 2.78968304e-01f, -2.77908534e-01f, -3.21259797e-01f, -1.08754957e+00f, 5.57988584e-01f, 8.28940511e-01f,
  2.86691219e-01f, -1.77375272e-01f, -6.50386661e-02f, -2.29917899e-01f, 3.99016261e-01f, -1.32935688e-01f, 1.31275788e-01f, -3.12550068e-02f, -6.71306670e-01f, 2.30472818e-01f,
  2.91843235e-01f, 2.46366844e-01f, 5.51307917e-01f, -7.15712070e-01f, -1.62852716e+00f, -1.04402423e+00f, 1.39159590e-01f, 8.80982816e-01f, 1.20854221e-01f, -6.41950846e-01f,
  5.60492650e-02f, -4.39150959e-01f, 1.56770311e-02f, -2.72391528e-01f, 1.32284433e-01f, -5.37851095e-01f, 1.51092857e-01f, 5.17653704e-01f, -1.83553621e-02f, 3.19451958e-01f,
  1.06373930e+00f, 4.17553186e-01f, -2.13477045e-01f, 4.53538656e-01f, -7.72490799e-01f, -4.95106876e-01f, -2.32527312e-02f, 5.66523671e-01f, -8.42299402e-01f, -1.25350666e+00f,
  4.82412368e-01f, -6.72938704e-01f, 1.44310936e-01f, -1.83292925e-01f, -7.79012680e-01f, 1.16407827e-01f, -7.42867649e-01f, -8.30447316e-01f, -6.66349113e-01f, -4.35858458e-01f,
  8.16818606e-03f, 5.09178996e-01f, 2.30174631e-01f, -5.20457387e-01f, -9.77195084e-01f, 3.47142845e-01f, -7.31930315e-01f, 4.05064464e-01f, -2.87606031e-01f, -6.48149550e-01f,
  -6.11576112e-03f, 1.43723869e+00f, 7.13655770e-01f, -3.08275491e-01f, -7.47377753e-01f, -1.44091642e+00f, 7.98957288e-01f, -5.66190146e-02f, -6.96169436e-01f, -1.34631515e-01f,
  -6.91797197e-01f, -7.36465693e-01f, 4.99011010e-01f, -4.60670054e-01f, 1.85045272e-01f, 3.90492715e-02f, 2.67322868e-01f, 1.01835775e+00f, -1.70042145e+00f, 6.55993700e-01f,
  -5.75398982e-01f, -3.86416614e-01f, -8.45636845e-01f, 2.58060306e-01f, 1.63724750e-01f, 4.52295631e-01f, 6.61152124e-01f, -9.45897579e-01f, 6.11233711e-02f, 1.36771709e-01f,
  -6.97540879e-01f, -4.43018645e-01f, -1.07219599e-01f, -4.36940581e-01f, 6.61282063e-01f, -1.89143449e-01f, 7.86947489e-01f, -7.19527125e-01f, -8.67197692e-01f, -1.18873894e+00f,
  -5.43282926e-01f, -1.63160467e+00f, -8.20274711e-01f, 4.13176000e-01f, 9.57111299e-01f, -4.01884019e-01f, -1.80020392e-01f, -1.13513105e-01f, -2.57074356e-01f, 8.07006001e-01f,
  4.42925811e-01f, 9.23158467e-01f, -1.03787374e+00f, 6.08649731e-01f, 8.78691394e-03f, -5.28070211e-01f, 3.12031716e-01f, 9.03574154e-02f, -1.03944588e+00f, 1.10986924e+00f,
  7.99023919e-03f, -1.05432916e+00f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.76013368e-02f, -3.60253632e-01f, -1.85960799e-01f, -4.28611748e-02f, 1.78738050e-02f, -1.60068110e-01f, 2.78858811e-01f, -1.02655880e-01f, -6.41779974e-02f, -1.38288558e-01f,
  -3.63820195e-01f, 2.57317841e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    