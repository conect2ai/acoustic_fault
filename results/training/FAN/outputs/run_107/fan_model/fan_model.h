/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.57172930e-01f, 3.62477899e-01f, 1.86378770e-02f, 1.54386371e-01f, 1.93571731e-01f, 3.24739754e-01f, -5.02406433e-02f, 3.09183419e-01f, 2.73738921e-01f, 7.36125261e-02f,
  1.23098277e-01f, -1.56429067e-01f, -1.36357518e-02f, -6.00443520e-02f, -1.47740287e-03f, -1.05897747e-01f, 2.64320582e-01f, 3.19881029e-02f, 1.37998864e-01f, 9.95449796e-02f,
  1.03089392e-01f, -1.17461100e-01f, -1.39414445e-01f, -3.36739272e-02f, 1.59404531e-01f, 1.23935632e-01f, -7.35658854e-02f, -2.67218817e-02f, -1.09090544e-01f, -6.83503523e-02f,
  1.22881599e-01f, 1.44695580e-01f, -7.43607711e-03f, 8.24887604e-02f, 7.35491142e-02f, -3.93257551e-02f, -2.04244852e-02f, -1.45667851e-01f, -5.79591431e-02f, 1.59546398e-02f,
  -8.49084780e-02f, -9.32533517e-02f, -5.20283356e-02f, 2.43013073e-03f, 1.37307718e-01f, 1.02156840e-01f, 8.17702860e-02f, 8.13724399e-02f, 4.22529615e-02f, 4.61506434e-02f,
  6.68180287e-02f, 4.44048941e-02f, 5.10618873e-02f, 7.05743432e-02f, 5.01786582e-02f, 1.40970156e-01f, -2.68298481e-03f, -1.43508641e-02f, 1.16470002e-01f, 4.68981750e-02f,
  -5.94270835e-03f, 7.11891502e-02f, 7.73540214e-02f, 6.10687491e-03f, 9.67738871e-03f, 5.51108383e-02f, -1.85196195e-02f, -1.16199359e-01f, 4.14301828e-02f, 2.94646192e-02f,
  -8.93976260e-03f, 6.82619736e-02f, 4.75444943e-02f, 5.91808818e-02f, -3.29884514e-02f, 5.29702194e-02f, 9.11845081e-03f, 9.55577567e-02f, 2.60596909e-02f, 5.63112013e-02f,
  8.33416507e-02f, -3.94951664e-02f, -7.22163320e-02f, -7.33393505e-02f, 4.09115106e-02f, 7.64423935e-03f, 4.47728373e-02f, 8.26759487e-02f, 2.33213231e-02f, -4.95575480e-02f,
  3.57751876e-01f, 4.82953042e-01f, 6.34398609e-02f, -8.13457221e-02f, 2.40312424e-02f, -4.80407104e-02f, -5.91591261e-02f, 9.56758782e-02f, 2.19216630e-01f, 1.65244751e-02f,
  1.50862724e-01f, -6.79926872e-02f, -9.27830413e-02f, -6.05646633e-02f, -9.14942250e-02f, 4.00332622e-02f, 4.47430573e-02f, 8.92982930e-02f, 2.55231522e-02f, 2.14543585e-02f,
  -3.44168916e-02f, -3.11484504e-02f, -5.42921796e-02f, 3.67894731e-02f, -5.19232303e-02f, -1.64911728e-02f, 3.85274664e-02f, -5.85376145e-03f, 4.77438495e-02f, -4.58855480e-02f,
  -6.03412926e-01f, 4.97705162e-01f, -1.09147854e-01f, 2.28705183e-01f, -1.94079608e-01f, 2.25952446e-01f, -1.48368264e-02f, 1.09306358e-01f, -1.12702455e-02f, 1.40166759e-01f,
  -2.97999494e-02f, -1.49715155e-01f, -4.43019383e-02f, 2.55074501e-01f, 2.22037479e-01f, 2.11734533e-01f, 3.51562887e-01f, -1.54482117e-02f, 2.87994500e-02f, -3.88695188e-02f,
  1.70854088e-02f, 2.41071790e-01f, 6.19350336e-02f, 1.59197450e-01f, -1.70807183e-01f, -8.28646570e-02f, -5.13241999e-02f, -8.84104446e-02f, 8.32189694e-02f, -1.40216872e-02f,
  -7.06915408e-02f, -1.15144134e-01f, -1.09504804e-01f, -6.23359941e-02f, -3.18426080e-02f, -1.19661406e-01f, -8.14171806e-02f, 1.59142036e-02f, -2.09992565e-02f, 6.47373945e-02f,
  -9.89968628e-02f, -2.53112633e-02f, 6.05366863e-02f, 2.81219203e-02f, -3.56436633e-02f, 2.34024059e-02f, 6.29111975e-02f, 3.54857258e-02f, 9.11304262e-03f, 1.32005541e-02f,
  8.33579823e-02f, 7.87499622e-02f, 1.79168824e-02f, 5.56160621e-02f, -3.76005247e-02f, 5.70356697e-02f, -7.48769846e-03f, -1.17108159e-01f, -1.19669233e-02f, -2.07178686e-02f,
  1.80363171e-02f, -1.02208085e-01f, -7.03043072e-03f, -3.46138105e-02f, 1.60055347e-02f, -5.41747697e-02f, 3.48259620e-02f, 1.24946376e-02f, -3.80850919e-02f, 4.47475202e-02f,
  9.64501873e-03f, 2.66064843e-03f, -1.45158377e-02f, -3.20740305e-02f, 5.10522118e-03f, -5.61402068e-02f, -2.75224596e-02f, -5.62485531e-02f, 4.64699743e-03f, -2.22267266e-02f,
  -3.71311679e-02f, 1.32210960e-04f, -1.67201348e-02f, -3.33379135e-02f, 4.58978415e-02f, 3.90051678e-02f, 2.42756028e-02f, 4.45697866e-02f, -6.26444072e-02f, 1.30876405e-02f,
  8.59809369e-02f, 1.68970093e-01f, -3.65388783e-04f, 7.71157956e-03f, 3.07771415e-02f, 2.39671152e-02f, 6.77755103e-02f, 2.85787024e-02f, 3.98862772e-02f, -6.31979704e-02f,
  -2.45275218e-02f, -4.76890318e-02f, -3.73487212e-02f, -1.50496121e-02f, 7.42102787e-02f, 2.46122573e-02f, -6.22487850e-02f, 3.44524183e-03f, -4.70267721e-02f, 1.52729871e-02f,
  -6.92574382e-02f, -3.81445810e-02f, 5.44023067e-02f, -1.16698425e-02f, -2.90482976e-02f, -7.01915771e-02f, -1.69789419e-02f, 6.82459176e-02f, -1.61461961e-02f, 3.84315774e-02f,
  1.18173748e-01f, -8.30338299e-02f, -2.12971374e-01f, -3.45943831e-02f, 2.41270140e-01f, -3.19989249e-02f, -1.71947315e-01f, -6.23071082e-02f, -1.81980953e-01f, -7.40507692e-02f,
  -8.67803544e-02f, 7.76141733e-02f, -2.56744176e-01f, -2.21652109e-02f, 1.07567325e-01f, -1.87078506e-01f, 2.53621370e-01f, 1.63781092e-01f, 1.47910506e-01f, 2.22711846e-01f,
  1.68278217e-01f, 3.96439552e-01f, 1.24489218e-01f, 3.38890880e-01f, 2.03524455e-01f, 5.92796132e-02f, 2.11857200e-01f, 7.20443483e-03f, 1.05390400e-01f, 6.23970442e-02f,
  2.59056836e-02f, -9.67033803e-02f, -1.30770043e-01f, -4.82388251e-02f, 7.61045590e-02f, -8.75462592e-02f, 9.28596333e-02f, -5.07159643e-02f, -3.41752497e-03f, -3.83442752e-02f,
  3.98466252e-02f, 8.74402151e-02f, 3.97075936e-02f, -7.78103098e-02f, -1.32750019e-01f, -1.05185352e-01f, 4.13015904e-03f, 1.53629649e-02f, -3.67021486e-02f, -8.70566666e-02f,
  -8.60667974e-02f, -1.42528843e-02f, -6.22288659e-02f, -3.71187404e-02f, -8.95191953e-02f, -9.93832797e-02f, -9.78468731e-02f, -5.12372777e-02f, 6.76827729e-02f, -1.22919969e-01f,
  4.39495631e-02f, 5.54789230e-02f, 1.80515088e-02f, 5.47303399e-03f, 1.46072041e-02f, -3.63584869e-02f, 1.09342355e-02f, -2.65967268e-02f, 5.67356646e-02f, 4.06837277e-03f,
  -4.23837863e-02f, -1.36963027e-02f, -9.52606206e-05f, -9.19080377e-02f, 6.59637451e-02f, -2.24415911e-03f, 9.19906721e-02f, -1.82165969e-02f, 8.74237493e-02f, -1.59761067e-02f,
  -4.72338870e-02f, 1.99153926e-03f, -4.03624810e-02f, 6.14817850e-02f, 5.64377308e-02f, -7.18122944e-02f, -6.85858354e-03f, -6.46229237e-02f, 4.11427394e-02f, 6.27708212e-02f,
  1.92038998e-01f, 2.37575427e-01f, -1.42615288e-02f, 1.73452571e-02f, -1.18742734e-02f, 3.11265066e-02f, 9.83330682e-02f, -2.42462326e-02f, 7.02597722e-02f, 5.98228909e-03f,
  4.95122597e-02f, 8.53740349e-02f, 6.33687153e-02f, -1.25812620e-01f, 6.43304437e-02f, -4.35402915e-02f, 8.04229528e-02f, 7.06261098e-02f, 9.11813378e-02f, 8.84305835e-02f,
  6.61951676e-02f, 1.11523166e-01f, 4.88674901e-02f, 1.34351537e-01f, 2.54169684e-02f, 2.02306788e-02f, 1.05814032e-01f, 1.78944226e-02f, 3.15405056e-02f, 1.97770190e-03f,
  1.54673070e-01f, -6.19422756e-02f, 1.28562404e-02f, -2.10792407e-01f, 1.38105884e-01f, -3.00985575e-01f, -3.08703363e-01f, 3.97853293e-02f, -1.96885556e-01f, -5.03524840e-02f,
  -2.09053636e-01f, 1.19445696e-01f, -2.15149999e-01f, -4.64029521e-01f, -3.14264476e-01f, -3.78581762e-01f, -2.79763937e-01f, -2.11411923e-01f, -2.29293350e-02f, 3.98762077e-02f,
  6.22355528e-02f, -1.80200502e-01f, -6.55958578e-02f, 2.01960832e-01f, -2.77709998e-02f, 3.77747208e-01f, 7.54927918e-02f, 1.39763072e-01f, 1.09631531e-01f, -6.91504031e-03f,
  -1.92775011e-01f, -1.29383475e-01f, 8.51445496e-02f, -2.34238021e-02f, 4.87314053e-02f, 2.59808283e-02f, -2.20635831e-02f, -1.07880654e-02f, 6.68867771e-03f, 4.75308625e-03f,
  -3.07266545e-02f, 9.80998110e-03f, 1.85564300e-03f, 7.58383051e-02f, 8.15750007e-03f, -7.80092087e-03f, -9.08869132e-03f, -5.72093166e-02f, 2.47414317e-02f, -3.14417481e-02f,
  3.54808979e-02f, 2.70755626e-02f, -1.04230661e-02f, 5.42824576e-03f, 4.37331498e-02f, -5.33012189e-02f, -8.83826241e-03f, 1.99408069e-01f, -5.05070481e-03f, 3.70786265e-02f,
  4.73827273e-02f, 2.88624503e-02f, 4.67910953e-02f, -3.80333029e-02f, 4.45409631e-03f, -1.35719832e-02f, -8.24847743e-02f, 8.49367026e-03f, 2.21904721e-02f, -6.33877218e-02f,
  4.68243137e-02f, -1.48878694e-02f, -7.33455643e-02f, 3.38926353e-02f, 6.10570535e-02f, 4.46839724e-03f, 1.44920750e-02f, 4.75892350e-02f, 2.64133327e-02f, -1.29377069e-02f,
  -9.09957588e-02f, -4.58083041e-02f, 1.04660235e-01f, 4.50343564e-02f, -1.07634291e-01f, 1.05162248e-01f, 3.83867044e-03f, -2.19060164e-02f, -3.50016169e-02f, 2.50556003e-02f,
  -8.67730826e-02f, 1.17709421e-01f, 2.14274209e-02f, 3.95614356e-02f, -7.08972812e-02f, 1.14905164e-02f, -1.20874383e-01f, 1.97725650e-02f, 1.02690578e-01f, -5.94723374e-02f,
  1.10649467e-01f, 5.22892959e-02f, 6.66708425e-02f, 9.44251567e-03f, -2.72817332e-02f, -3.66381207e-03f, -3.42463441e-02f, 8.04969519e-02f, 2.92932037e-02f, 4.82085347e-02f,
  4.78031300e-02f, 1.72523018e-02f, -7.81767827e-04f, 8.53616297e-02f, 3.90612590e-03f, 4.68993299e-02f, 6.28385618e-02f, 2.47543082e-02f, 6.15390949e-03f, -6.50835857e-02f,
  8.59070420e-02f, 1.48967326e-01f, -2.17896208e-01f, 2.10604593e-01f, -2.38856211e-01f, -1.81104511e-01f, 2.84632053e-02f, -7.83883780e-02f, -2.00722679e-01f, 4.19154942e-01f,
  1.89568982e-01f, 2.41854742e-01f, 1.80424064e-01f, 3.77582937e-01f, -1.23479374e-01f, 8.74109566e-02f, 2.50082184e-02f, 1.40873477e-01f, -2.50894189e-01f, 7.15269148e-02f,
  -1.54184058e-01f, 3.04358274e-01f, 1.21593706e-01f, -6.73342347e-02f, 1.54881954e-01f, -1.25375047e-01f, 9.17715430e-02f, -1.63888276e-01f, 1.96920395e-01f, -7.19586387e-02f,
  1.16203697e-02f, 2.38109306e-01f, -1.28963031e-02f, -7.82862306e-02f, 5.79687543e-02f, 5.71290962e-02f, 4.59320992e-02f, -8.34156498e-02f, -7.66041651e-02f, -3.43855936e-03f,
  1.11413263e-01f, 7.54636377e-02f, 1.05329655e-01f, 2.34525129e-02f, -3.88750732e-02f, 3.53441536e-02f, -1.34543236e-03f, -8.12619925e-02f, 7.47478306e-02f, -4.06096205e-02f,
  3.71490046e-02f, 2.46599177e-03f, 2.74725389e-02f, 3.66282873e-02f, -1.35230824e-01f, -7.61103928e-02f, -1.34325221e-01f, -2.54799351e-02f, -1.87076684e-02f, -6.43699616e-02f,
  -4.75948863e-02f, -1.45380139e-01f, 5.43665476e-02f, 6.16358668e-02f, 7.03665940e-03f, -2.38947719e-02f, 3.77227478e-02f, 3.66940014e-02f, -1.61620975e-01f, -3.84125821e-02f,
  2.70010233e-02f, 1.70534737e-02f, 2.33984203e-03f, 5.32609522e-02f, -3.50088589e-02f, 1.31510869e-01f, 6.32445514e-02f, 2.36043911e-02f, -1.70172360e-02f, -5.48713095e-02f,
  4.74129021e-02f, -7.48145804e-02f, 3.35164890e-02f, 9.28934216e-02f, -4.16697524e-02f, 1.06429467e-02f, 7.66747296e-02f, 4.92369123e-02f, 9.14917700e-03f, -3.43062989e-02f,
  -9.50191915e-02f, -1.47468582e-01f, -7.81178623e-02f, 2.88082212e-02f, -3.26702073e-02f, 4.35024872e-02f, 2.49792617e-02f, -1.49181470e-01f, -9.59187597e-02f, 4.43144403e-02f,
  -1.36409933e-02f, 3.68659981e-02f, -3.56074572e-02f, -4.08615805e-02f, 2.65437085e-02f, 8.39785635e-02f, 2.43936814e-02f, -8.84511918e-02f, 6.71173446e-03f, -7.51811787e-02f,
  -2.71884277e-02f, 9.91661218e-04f, -1.20605221e-02f, 1.20081916e-01f, 5.66548742e-02f, 5.20437919e-02f, 2.54865102e-02f, -7.02165738e-02f, 1.39387539e-02f, -1.84478182e-02f,
  4.64236468e-01f, -1.42747149e-01f, 2.39942938e-01f, 3.80116820e-01f, 1.15528032e-01f, -1.89613849e-01f, -1.09649882e-01f, 1.41357556e-01f, 2.43997827e-01f, -1.60866275e-01f,
  -5.14888428e-02f, -1.40038645e-02f, -2.66400605e-01f, 9.80785489e-02f, -1.09558322e-01f, -2.97808588e-01f, 1.60588473e-01f, -9.26649477e-03f, 1.38379168e-03f, 1.96936294e-01f,
  1.80536181e-01f, -1.35670081e-01f, 6.38467595e-02f, -2.86706947e-02f, 1.91431507e-01f, 1.89961001e-01f, -8.55326653e-02f, -5.55095449e-02f, 8.95606130e-02f, -1.24130607e-01f,
  -9.30563658e-02f, 6.08693138e-02f, 8.72579068e-02f, -3.72566357e-02f, 1.22021250e-01f, 6.18491462e-03f, 2.63294540e-02f, -8.84881094e-02f, 4.50754836e-02f, 5.41487485e-02f,
  -2.76356507e-02f, 8.45109299e-02f, 3.11844591e-02f, 1.12535199e-02f, 1.16371820e-02f, 5.99042773e-02f, -1.49294408e-02f, 6.16901852e-02f, 4.89017442e-02f, 8.04812238e-02f,
  2.47646943e-02f, 5.78445084e-02f, 2.73125581e-02f, -3.51294167e-02f, 5.19519784e-02f, 1.03114478e-01f, 8.01557079e-02f, 9.35715344e-03f, 1.23677133e-02f, 7.00819865e-02f,
  -2.91847158e-02f, 2.73722354e-02f, -1.39481816e-02f, 5.10554900e-03f, 3.77054214e-02f, 7.97477439e-02f, -2.46818946e-03f, -8.90127383e-03f, 7.00524375e-02f, 1.42662041e-02f,
  2.04663277e-02f, 3.60433981e-02f, -4.37114686e-02f, 6.32186756e-02f, 1.40538486e-02f, 6.24057353e-02f, 1.66234113e-02f, 2.51828004e-02f, 6.20130040e-02f, 1.59883387e-02f,
  -6.18124418e-02f, 9.11263376e-03f, -5.61905801e-02f, 6.38220534e-02f, -2.80401781e-02f, -7.94966295e-02f, 8.74442756e-02f, 3.65749449e-02f, -3.72839067e-03f, -4.34677340e-02f,
  -2.48258471e-01f, -8.06339458e-02f, -8.85302126e-02f, -1.44780241e-02f, -1.01128474e-01f, -4.95382287e-02f, 4.12493609e-02f, 3.58737484e-02f, -1.51682556e-01f, 2.09302865e-02f,
  4.21231054e-02f, 4.09373008e-02f, 1.15493601e-02f, -2.02290360e-02f, -9.06331092e-02f, 3.45659554e-02f, 7.45770857e-02f, -9.31069255e-02f, -6.76973686e-02f, 9.65560321e-03f,
  2.00871769e-02f, -2.13407185e-02f, 2.53138859e-02f, 2.10964922e-02f, 6.18942198e-04f, -2.99912225e-02f, 3.75790074e-02f, 1.07159046e-02f, -1.24281086e-02f, -4.86523360e-02f,
  -2.11525887e-01f, -2.29320928e-01f, -1.40070677e-01f, -1.68400198e-01f, -1.55783445e-01f, 7.15439171e-02f, 3.56672555e-01f, -2.82361537e-01f, 1.26495898e-01f, -4.23080474e-02f,
  -1.66051108e-02f, -1.14212066e-01f, 1.83747664e-01f, -1.07526295e-01f, 1.99875757e-01f, 3.13549161e-01f, -1.00839864e-02f, 3.19027118e-02f, 5.07137552e-02f, -2.25864470e-01f,
  -6.40823618e-02f, -2.07223594e-02f, 1.27069214e-02f, -1.16261341e-01f, -1.83802098e-01f, -2.55211413e-01f, -8.54871869e-02f, -4.27778177e-02f, -2.58068413e-01f, 6.70152679e-02f,
  1.18664876e-02f, -2.02016253e-02f, -3.96352820e-02f, 2.40821131e-02f, -1.26042157e-01f, 8.11287314e-02f, -2.42956113e-02f, 1.06209561e-01f, 5.44637069e-02f, -1.25022009e-01f,
  5.46024814e-02f, -5.97507283e-02f, -9.50311050e-02f, 8.52406323e-02f, -5.12292385e-02f, -4.11816463e-02f, -3.03950012e-02f, -5.48803471e-02f, -4.39250879e-02f, 5.78258745e-02f,
  1.15503604e-02f, -9.57984999e-02f, 3.00010946e-02f, -1.06072575e-02f, -6.82720020e-02f, -1.03320302e-02f, 7.57318512e-02f, -9.73237753e-02f, -9.31179002e-02f, -1.81956310e-02f,
  5.97651303e-02f, 7.72896633e-02f, 2.74224635e-02f, -3.14188749e-02f, 1.87319107e-02f, 1.49846999e-02f, 7.13758692e-02f, -2.82528140e-02f, 5.49272224e-02f, -3.59221809e-02f,
  -5.00916503e-02f, -3.90807651e-02f, -1.96745410e-03f, 5.46074249e-02f, 3.42260115e-02f, 3.58917974e-02f, 8.17832574e-02f, -5.90426568e-03f, -1.76168478e-03f, -1.26712108e-02f,
  4.94268611e-02f, 6.27669469e-02f, -3.92694585e-02f, -1.31199788e-02f, 5.47166951e-02f, -1.73792187e-02f, -4.72668819e-02f, 3.08812540e-02f, 2.69554835e-02f, -2.88616177e-02f,
  -1.38821438e-01f, -2.05022469e-01f, 3.10335718e-02f, 2.49175634e-02f, 3.67641286e-03f, -5.98858809e-03f, 4.75606695e-02f, -5.86776659e-02f, -5.30762039e-02f, 1.08538084e-02f,
  -7.46947825e-02f, 4.17470187e-02f, -6.00308068e-02f, 1.41493846e-02f, 6.02499731e-02f, 3.55775058e-02f, 2.79565575e-03f, -4.73530553e-02f, -7.87858292e-02f, -8.62238482e-02f,
  -8.16583633e-02f, 1.34255746e-02f, 9.04692560e-02f, -2.37029511e-03f, 2.45119557e-02f, -7.35284993e-03f, 3.49964504e-03f, 2.88979542e-02f, -6.07653297e-02f, 6.10672077e-03f,
  5.60037494e-02f, 1.52274802e-01f, -1.02544472e-01f, -2.18466386e-01f, 3.88956934e-01f, -1.61642246e-02f, -2.81122029e-01f, 3.80467206e-01f, -1.43714294e-01f, -3.48153040e-02f,
  1.40192136e-01f, -3.20219815e-01f, 6.72717094e-02f, -1.20103478e-01f, -2.22749934e-01f, -1.98502466e-01f, -2.96716452e-01f, -2.10972205e-01f, 2.83055790e-02f, 6.96570501e-02f,
  1.54664172e-02f, 1.86844170e-01f, -9.68447998e-02f, 2.98940629e-01f, 1.82945192e-01f, 9.74190161e-02f, 1.77029237e-01f, 1.17835462e-01f, -2.74637509e-02f, -9.91506353e-02f,
  8.06498155e-02f, 8.68397206e-02f, -1.22888125e-02f, -9.29333866e-02f, 5.74647859e-02f, -8.43533278e-02f, -5.66896498e-02f, 2.58939266e-02f, -5.84294647e-02f, 2.86267959e-02f,
  -2.61369050e-02f, 8.45369771e-02f, -3.03106252e-02f, -6.42116144e-02f, 1.59384310e-02f, -8.17053244e-02f, 2.86644734e-02f, -4.47688177e-02f, 5.37076592e-02f, 1.19563509e-02f,
  -3.44160013e-02f, -1.08961485e-01f, -8.14975277e-02f, -1.05875852e-02f, 3.19158919e-02f, -4.35922407e-02f, -1.33862853e-01f, -1.36527538e-01f, 1.01498358e-01f, 2.90469732e-02f,
  2.89644133e-02f, -1.35716572e-01f, -3.61592956e-02f, 4.81158532e-02f, 3.77481170e-02f, 1.25274196e-01f, -7.51598254e-02f, 1.05419392e-02f, -6.61280900e-02f, 6.96054921e-02f,
  4.61315401e-02f, -2.73238271e-02f, 1.37779750e-02f, -6.15815669e-02f, -8.29854310e-02f, -6.14008158e-02f, 5.68614854e-03f, 9.77703705e-02f, -1.09716300e-02f, 9.34237018e-02f,
  -8.43257010e-02f, -5.59256151e-02f, -1.85319986e-02f, -3.86086814e-02f, -3.60069349e-02f, 5.90608513e-04f, 1.84507985e-02f, 2.56091380e-03f, -9.58259217e-03f, 4.27948311e-03f,
  1.63374975e-01f, 9.64091346e-02f, 2.77193841e-02f, 8.58641639e-02f, 4.39715236e-02f, 7.07106441e-02f, -9.51170698e-02f, 3.96990739e-02f, 2.47195438e-02f, 1.41118811e-02f,
  3.37323248e-02f, -6.29262775e-02f, -1.30139356e-02f, -1.52912987e-02f, -1.29581485e-02f, 1.04966968e-01f, -9.17053148e-02f, -2.16934346e-02f, 1.87379010e-02f, 1.05620489e-01f,
  3.69709246e-02f, 1.93971079e-02f, 1.67841092e-02f, 5.68564199e-02f, 3.61663811e-02f, -3.40913348e-02f, 1.76661499e-02f, -6.55553862e-02f, -8.88056681e-03f, -1.05853612e-02f,
  1.14409171e-01f, 2.34606639e-01f, -2.98056513e-01f, 4.27950054e-01f, 1.54945413e-02f, -1.70203601e-03f, 8.52503814e-03f, 1.21682927e-01f, 3.67326468e-01f, 2.42749333e-01f,
  9.39981267e-02f, 9.11294147e-02f, -1.62090793e-01f, 2.86584884e-01f, -1.89736515e-01f, -4.58258130e-02f, 1.33040443e-01f, 1.61319822e-01f, 7.79370591e-02f, -7.68013671e-02f,
  6.07365444e-02f, 1.87763661e-01f, -2.06508517e-01f, 1.20582785e-02f, 1.68227125e-02f, 6.46929666e-02f, -1.69538870e-01f, -1.56616494e-01f, 3.14443707e-02f, 1.05004832e-02f,
  -1.51260704e-01f, 2.94232760e-02f, -1.63489040e-02f, -1.10138021e-02f, -1.43587291e-02f, -1.31443530e-01f, -8.11587349e-02f, -1.58470616e-01f, -1.23936636e-02f, -1.53059289e-02f,
  -1.04180731e-01f, 4.77195792e-02f, 7.97302946e-02f, 6.69528246e-02f, 1.39306143e-01f, 6.79802373e-02f, 2.39649555e-03f, -5.55830076e-02f, 3.67063172e-02f, 5.30374050e-02f,
  1.40092606e-02f, 2.25635730e-02f, -1.70450509e-02f, 1.01333931e-01f, -2.51801349e-02f, 1.49641201e-01f, 1.80934053e-02f, -7.36267567e-02f, 6.58761859e-02f, 1.89181149e-01f,
  5.73234493e-03f, -5.97733371e-02f, 2.50354931e-02f, 1.27805531e-01f, -6.29139841e-02f, 1.95943192e-02f, -9.19917375e-02f, -4.43626456e-02f, -5.10220192e-02f, -3.69097702e-02f,
  8.46004784e-02f, 4.84135039e-02f, 7.48832822e-02f, -4.08531949e-02f, 5.90797439e-02f, 4.70447391e-02f, -1.14474267e-01f, -2.17476375e-02f, 5.44445179e-02f, -1.72704868e-02f,
  -1.42683908e-02f, 5.41433878e-02f, 6.60904050e-02f, -4.09379303e-02f, 3.91289331e-02f, -2.65166592e-02f, 1.59824546e-02f, 9.20914765e-03f, -9.15085450e-02f, -1.56975552e-01f,
  -1.92304030e-01f, -8.81997719e-02f, 8.49694572e-03f, 7.42938071e-02f, -6.15658835e-02f, 3.83291282e-02f, -3.56046967e-02f, 8.98646116e-02f, -9.59009081e-02f, -2.34505627e-03f,
  2.50393935e-02f, -7.21110106e-02f, -6.15918674e-02f, 2.53372919e-02f, -9.24926996e-02f, 5.94448075e-02f, -6.53917715e-02f, -5.43245487e-03f, -7.87410885e-02f, 2.69338209e-02f,
  -3.71043384e-02f, -7.43412226e-02f, -6.60659224e-02f, -7.34481076e-03f, -5.21960482e-02f, 5.20728566e-02f, 5.14008515e-02f, 9.84967276e-02f, -6.16658665e-03f, -2.96504721e-02f,
  -1.72148794e-01f, 5.85436001e-02f, -1.05777279e-01f, -2.00430274e-01f, -1.12911351e-01f, 1.37628391e-01f, 1.91568926e-01f, -1.56782731e-01f, -1.03547394e-01f, 3.03334475e-01f,
  1.37419224e-01f, -5.92009388e-02f, 2.95393318e-01f, -1.31022915e-01f, 5.02848774e-02f, 2.31979430e-01f, -1.35116160e-01f, -8.79249051e-02f, -1.11207522e-01f, -2.52771378e-01f,
  -1.95354596e-01f, -7.61612877e-02f, -1.82890072e-01f, -1.78312376e-01f, -2.57360429e-01f, -1.98413268e-01f, 1.02525279e-02f, -5.66383302e-02f, -1.86776131e-01f, 5.95268188e-03f,
  6.34397715e-02f, -1.78662948e-02f, -7.83141330e-02f, -8.44539553e-02f, -2.66564824e-02f, -7.08492007e-03f, -6.42021596e-02f, 4.68877330e-02f, -5.01599982e-02f, 5.68510219e-02f,
  3.26773040e-02f, -5.91956675e-02f, -1.00515850e-01f, 1.09508839e-02f, -1.11437283e-01f, -7.24675357e-02f, -4.93157730e-02f, -2.08582208e-02f, -3.04988679e-03f, -6.34068921e-02f,
  -1.01769473e-02f, -5.31712733e-03f, 1.24818776e-02f, 2.94426698e-02f, -8.92389845e-03f, -3.79067734e-02f, 5.56530282e-02f, -8.76827389e-02f, -4.29788120e-02f, 3.55418818e-03f,
  -3.55631206e-03f, 2.49454081e-02f, 4.26766761e-02f, 4.07269932e-02f, 1.01017915e-01f, 1.81849468e-02f, 8.14315230e-02f, -2.57385988e-02f, -1.67302918e-02f, 5.96185438e-02f,
  -2.10837945e-02f, -4.08252180e-02f, -2.88703497e-02f, -2.85681188e-02f, -9.23281442e-03f, -1.76343061e-02f, -4.68712784e-02f, 4.48442809e-02f, -1.16206661e-01f, -1.93085615e-02f,
  6.09645769e-02f, -6.01664595e-02f, 4.92527448e-02f, -9.62850079e-03f, 8.28880966e-02f, 2.00923216e-02f, -8.42841268e-02f, 2.83266976e-02f, -5.48738800e-02f, 5.98342577e-03f,
  5.61852269e-02f, 4.79987934e-02f, 4.18344215e-02f, 2.04189218e-05f, 1.52148798e-01f, -1.94209330e-02f, -2.16672439e-02f, -1.01341248e-01f, 7.29811713e-02f, -1.06978475e-03f,
  -1.15792096e-01f, -4.70801145e-02f, 8.52959976e-02f, 6.77967537e-03f, -9.77754313e-03f, 3.01648621e-02f, -4.71637994e-02f, -9.55292780e-04f, -7.59285316e-02f, -2.33452246e-02f,
  -1.82225965e-02f, 8.97250250e-02f, -3.14817466e-02f, -1.30883276e-01f, -5.46364188e-02f, 6.63078204e-02f, -3.57072391e-02f, 3.21557038e-02f, 3.37651782e-02f, 4.22687270e-02f,
  -1.54937357e-01f, 1.99040100e-01f, 3.19039941e-01f, 2.80466527e-01f, -1.66180491e-01f, -4.28666741e-01f, -4.04013455e-01f, 1.96271539e-01f, 9.10794064e-02f, -6.79137632e-02f,
  -1.63799837e-01f, -1.46395326e-01f, -1.26019448e-01f, 2.11369127e-01f, -4.10432398e-01f, -1.43519565e-01f, 1.96516037e-01f, 9.80417058e-03f, 1.58450916e-01f, 7.16532245e-02f,
  1.93784703e-02f, -6.89160526e-02f, 6.13390915e-02f, 1.47611260e-01f, 2.90805474e-02f, 1.74120605e-01f, 2.50579286e-02f, -1.51685491e-01f, 1.70064345e-01f, -1.48598298e-01f,
  6.59880862e-02f, 2.67410040e-01f, 1.37777120e-01f, -1.73873715e-02f, 3.85571122e-02f, -2.99751665e-02f, -6.22769743e-02f, -1.64386690e-01f, -4.77496944e-02f, -2.17941068e-02f,
  -6.33649155e-02f, -3.64277102e-02f, 4.18612473e-02f, -2.97264438e-02f, 7.27955159e-03f, 1.26720294e-01f, 9.45489928e-02f, 4.92617302e-02f, 4.83354367e-02f, -4.69114026e-03f,
  6.13401586e-04f, 8.31034333e-02f, 9.14834812e-03f, 5.09923734e-02f, -1.23402327e-02f, 4.74992394e-02f, 1.35754645e-02f, -8.39656442e-02f, 4.47853096e-02f, 4.36884277e-02f,
  -3.68963666e-02f, -8.79777595e-02f, -2.62050852e-02f, 8.61418173e-02f, -3.83138843e-02f, 6.08781613e-02f, -4.37059700e-02f, -2.67727766e-02f, -2.92367116e-02f, -3.47409062e-02f,
  -1.63953118e-02f, 1.13218138e-02f, 4.18240465e-02f, -3.58955599e-02f, -1.55270258e-02f, 2.08122823e-02f, -8.88490379e-02f, -7.77386650e-02f, -4.78692912e-02f, -2.68817991e-02f,
  -5.56099862e-02f, -4.21022885e-02f, -1.19140945e-01f, 5.29890433e-02f, -1.03233960e-02f, -8.70257244e-02f, 4.07564603e-02f, -2.81679654e-03f, 5.12505472e-02f, -7.18082190e-02f,
  -9.06612799e-02f, -1.01228699e-01f, 2.63709202e-02f, 1.16809318e-03f, -2.36101747e-02f, -1.96911935e-02f, 9.41132940e-03f, 1.13419734e-01f, -3.75433713e-02f, -8.02335963e-02f,
  -3.43126617e-03f, 4.17625904e-03f, -8.10289464e-04f, -2.20790002e-02f, 7.40366429e-03f, -2.76142694e-02f, -1.01047559e-02f, -2.37137843e-02f, 3.66477259e-02f, 5.11368811e-02f,
  -1.15166176e-02f, -2.52169371e-02f, -3.16044725e-02f, 1.03658177e-02f, 5.00711091e-02f, -1.05930202e-01f, -2.84437090e-02f, -4.23552915e-02f, -5.70951477e-02f, -1.66192111e-02f,
  6.14888631e-02f, -1.48105502e-01f, -2.27553412e-01f, 1.17563894e-02f, -2.52733558e-01f, 3.71733636e-01f, 4.45850700e-01f, -8.05867016e-02f, -2.56639104e-02f, 3.27489257e-01f,
  2.63797313e-01f, 3.52517329e-02f, 3.28436404e-01f, 2.90648311e-01f, 1.51859745e-01f, 2.36357421e-01f, 1.19224086e-01f, 1.23108402e-01f, -1.06980382e-02f, -1.37088269e-01f,
  -1.08248338e-01f, 1.88775212e-01f, -4.24891636e-02f, -2.10898370e-01f, 5.06771430e-02f, -2.06499547e-01f, -7.89701845e-03f, 1.65440012e-02f, 2.65840702e-02f, 2.61476431e-02f,
  9.82029215e-02f, -1.06909908e-01f, -1.10303767e-01f, -1.33582111e-03f, -6.75168410e-02f, -2.34440584e-02f, 2.33601853e-02f, 4.62085195e-02f, 1.31302355e-02f, -5.62878931e-03f,
  4.25289050e-02f, -7.55318105e-02f, 3.97735566e-04f, 7.70813832e-03f, -6.60257638e-02f, -9.82344225e-02f, -4.61696498e-02f, 3.01629063e-02f, -2.90986151e-02f, -2.12447066e-02f,
  7.05617666e-02f, 2.83657350e-02f, 4.46590502e-03f, 1.16411597e-02f, -8.35214369e-03f, -1.75089645e-03f, -6.07357686e-03f, 3.19733657e-02f, 3.50590199e-02f, -1.04002610e-01f,
  4.44289856e-03f, 4.14996222e-02f, 4.78718095e-02f, -6.23477669e-03f, -4.61080559e-02f, -5.39931767e-02f, 5.22950366e-02f, 8.54931585e-03f, -4.04595286e-02f, 3.58209349e-02f,
  1.79397706e-02f, -8.48662928e-02f, 4.77906838e-02f, 6.07972629e-02f, 5.81851713e-02f, -1.32925902e-02f, 6.41191602e-02f, 1.29245743e-01f, 2.54132343e-03f, 5.28894402e-02f,
  -2.09919848e-02f, 7.12434724e-02f, 8.43432248e-02f, 1.64907891e-02f, 4.53962311e-02f, 6.96156025e-02f, 3.96807231e-02f, -7.52439350e-03f, -4.29276265e-02f, 2.12432146e-02f,
  9.11978930e-02f, 7.93657750e-02f, 2.05306299e-02f, -4.49016206e-02f, -3.74505227e-03f, -4.90277186e-02f, -6.65977458e-03f, -7.31819347e-02f, -8.14692862e-03f, 1.05654538e-01f,
  -6.40376806e-02f, -1.92670096e-02f, -5.83185405e-02f, 1.15014575e-02f, 9.06991400e-03f, 1.55282710e-02f, 1.13487110e-01f, -8.63539651e-02f, -2.57946718e-02f, 6.65136566e-03f,
  -3.30934264e-02f, 1.26638049e-02f, -1.01232193e-01f, -5.35271131e-02f, -6.26534820e-02f, 2.13638023e-02f, -2.29955129e-02f, -7.52811208e-02f, 8.72159284e-03f, 1.17230844e-02f,
  -4.41731513e-01f, 3.87505412e-01f, 2.99976975e-01f, -1.30274966e-01f, -1.45426199e-01f, -2.66238600e-01f, -2.25012437e-01f, 6.66950867e-02f, -8.83403346e-02f, 2.07636476e-01f,
  -9.34416279e-02f, 1.13022961e-01f, 1.31035537e-01f, 5.16961887e-02f, -4.80573237e-01f, 8.76275152e-02f, -2.11297765e-01f, -5.06171845e-02f, 4.37261462e-02f, -6.04822598e-02f,
  -7.95961320e-02f, -7.18368366e-02f, 1.45328060e-01f, 1.76687002e-01f, 5.99794686e-02f, 9.94627103e-02f, -8.24565217e-02f, 2.13378370e-01f, -1.11223228e-01f, -5.12189902e-02f,
  -1.47276625e-01f, 1.46830633e-01f, 1.00686550e-01f, 1.07384034e-01f, -1.27128676e-01f, -1.55856609e-02f, -4.00621928e-02f, 6.19356474e-03f, -1.07450853e-03f, -9.05384216e-03f,
  -1.29164485e-02f, -8.88171699e-03f, -7.17898160e-02f, 9.61141661e-02f, 3.38850617e-02f, 1.23180948e-01f, 9.01343077e-02f, 1.95529908e-02f, 8.44935924e-02f, 3.72765623e-02f,
  7.74197727e-02f, 9.52568464e-03f, 3.47412825e-02f, 3.01406626e-02f, 1.25239640e-02f, 8.96718279e-02f, 1.58550199e-02f, -4.91245613e-02f, -5.81716225e-02f, -6.76968619e-02f,
  7.19856396e-02f, 2.20331214e-02f, 7.05366815e-03f, 4.47257757e-02f, -3.86812026e-03f, 2.73202383e-03f, 6.76226243e-02f, -2.14763861e-02f, 4.48545255e-02f, -3.68913114e-02f,
  -5.01979403e-02f, -7.39478543e-02f, -1.45499567e-02f, 4.33485806e-02f, -1.88754369e-02f, 3.11684720e-02f, -9.38708428e-03f, 1.75990555e-02f, -7.73910135e-02f, -3.10422983e-02f,
  8.62411261e-02f, -8.38985071e-02f, 3.05758300e-03f, -1.33395400e-02f, -3.64200212e-03f, 6.59528151e-02f, 3.97430696e-02f, 8.31313580e-02f, -3.75284143e-02f, -1.00470081e-01f,
  -1.82866022e-01f, 1.55421090e-03f, 3.55999693e-02f, -5.96946590e-02f, 4.88001369e-02f, -4.48969454e-02f, 5.66717386e-02f, -6.41002059e-02f, 7.04692230e-02f, -5.28753474e-02f,
  -3.23218182e-02f, 1.45978518e-02f, -5.14382124e-02f, -7.67614786e-03f, -6.79819211e-02f, -5.30732572e-02f, -8.56836364e-02f, -5.52117750e-02f, -1.38356179e-01f, -8.97000283e-02f,
  5.38223702e-03f, -3.92672271e-02f, -4.07683328e-02f, 8.01910926e-03f, -1.11381963e-01f, -3.90264094e-02f, -4.28068228e-02f, 2.40259133e-02f, -1.89955607e-02f, 8.25641118e-03f,
  1.16421998e-01f, -3.80225689e-03f, -4.01549369e-01f, -4.94832955e-02f, 2.09418207e-01f, -6.28125444e-02f, 1.79503068e-01f, 4.12890650e-02f, 3.08391780e-01f, 1.07284598e-01f,
  2.58310854e-01f, -1.30952805e-01f, 3.14376026e-01f, 4.91873808e-02f, -2.12750331e-01f, 2.36516029e-01f, -5.78034148e-02f, 4.39975634e-02f, 1.68474972e-01f, -3.46014090e-02f,
  3.36916395e-03f, 1.72616899e-01f, -1.30910382e-01f, 9.50905308e-03f, -6.39523342e-02f, -2.40187421e-01f, -1.17731251e-01f, -8.58755782e-02f, -3.17327589e-01f, -9.26801786e-02f,
  3.86585156e-03f, 2.72474408e-01f, -5.90669364e-02f, -7.49255493e-02f, -6.08629584e-02f, 2.98461262e-02f, -1.23841636e-01f, -5.87848648e-02f, 2.23680716e-02f, 1.99243370e-02f,
  4.81526256e-02f, 2.80342158e-02f, 3.73939462e-02f, 4.21451852e-02f, 4.16564681e-02f, -5.81526496e-02f, -1.87218208e-02f, -1.95705071e-02f, 2.19946224e-02f, 3.91107537e-02f,
  1.34623609e-02f, -8.91135447e-03f, -8.42798799e-02f, -5.95992990e-02f, -6.69535100e-02f, 5.64053841e-02f, -5.01241796e-02f, -1.36550635e-01f, -2.10306831e-02f, -8.66633933e-03f,
  4.07399982e-02f, 4.25066203e-02f, 5.40882200e-02f, 4.15845029e-02f, 6.15058728e-02f, -7.14628678e-03f, 4.48424891e-02f, 1.72738172e-02f, -3.14485729e-02f, 9.51366499e-02f,
  4.02262844e-02f, 2.13414021e-02f, 6.86410666e-02f, 5.11626229e-02f, 6.74983859e-02f, 6.23966567e-02f, -4.44807298e-02f, -1.69620030e-02f, 1.70313641e-02f, -7.64680132e-02f,
  7.44600892e-02f, -6.99391663e-02f, -3.94261442e-03f, -3.78613807e-02f, 3.10618933e-02f, -3.29496432e-03f, -1.68650635e-02f, -1.96674410e-02f, 5.06933890e-02f, -4.77919504e-02f,
  -7.28014037e-02f, -1.50508851e-01f, 1.66838728e-02f, 3.59018520e-02f, -5.78381233e-02f, -2.86276676e-02f, 1.03826995e-03f, -3.05432715e-02f, -6.75959066e-02f, 7.29220733e-02f,
  -9.88252610e-02f, 2.15515122e-02f, -5.40473573e-02f, -5.83335152e-03f, -5.48399352e-02f, -3.24540138e-02f, -1.35661745e-02f, 3.28542553e-02f, -5.34596778e-02f, -2.81942002e-02f,
  -2.57189535e-02f, 6.13179393e-02f, 1.25433356e-02f, -1.78645179e-02f, -3.47902849e-02f, -7.55687356e-02f, -1.00799538e-01f, 3.53501439e-02f, -9.78369638e-02f, -5.67804873e-02f,
  -3.22072245e-02f, -1.11102229e-02f, 6.48491681e-02f, -1.10189497e-01f, 1.88765973e-01f, 1.26618966e-01f, 6.68428391e-02f, 1.23441532e-01f, 4.04490829e-01f, -2.29657233e-01f,
  1.12028653e-02f, -3.49816471e-01f, 1.65592536e-01f, -3.27656388e-01f, -2.82106996e-02f, 2.68093169e-01f, -7.81503469e-02f, -1.08311705e-01f, 2.90972054e-01f, 9.90823749e-03f,
  9.74664558e-03f, -2.07075804e-01f, 1.86645314e-02f, -7.51178563e-02f, -9.72420946e-02f, -1.97628215e-02f, -3.83277327e-01f, 6.12770133e-02f, -3.77371103e-01f, -6.06958158e-02f,
  1.31972119e-01f, 1.13383062e-01f, -6.49905717e-03f, -6.05763383e-02f, 2.12069154e-02f, -9.98359174e-03f, -7.66895339e-02f, -4.24902178e-02f, 1.25916302e-01f, 5.06820232e-02f,
  -1.07089899e-01f, -8.32668841e-02f, -3.70123759e-02f, -1.73909310e-02f, 2.70641185e-02f, -6.69325367e-02f, -8.54280032e-03f, 4.61646467e-02f, -1.02458611e-01f, 3.07708196e-02f,
  6.29285872e-02f, 3.07397079e-02f, -9.06911939e-02f, -8.38632286e-02f, 9.40498244e-03f, 1.20574553e-02f, -2.34686211e-02f, 5.45462072e-02f, -7.02675432e-02f, 5.47171868e-02f,
  7.40900170e-04f, 1.90745946e-02f, 7.92833567e-02f, 5.47636673e-03f, 4.50200625e-02f, 5.92837147e-02f, -3.80979404e-02f, -3.88912484e-02f, -6.48752227e-02f, 3.12082209e-02f,
  -5.51474765e-02f, -1.26598664e-02f, -4.60070409e-02f, 4.36671935e-02f, 4.10827883e-02f, 6.33404553e-02f, 2.17388552e-02f, -5.71266003e-02f, 8.43567625e-02f, 1.66692119e-02f,
  -1.28298011e-02f, -2.07649358e-02f, -4.57468219e-02f, -2.37657391e-02f, 1.03894129e-01f, -5.66292368e-03f, -1.01204723e-01f, 2.29578204e-02f, 6.82133064e-02f, -2.52481997e-02f,
  -1.31665275e-01f, -1.88081086e-01f, 2.05883160e-02f, -1.49346413e-02f, -3.74333449e-02f, -7.03682527e-02f, 7.01858476e-02f, -6.17724247e-02f, -5.08751720e-03f, -4.23330069e-03f,
  -7.84834474e-02f, 2.81284861e-02f, -1.25378206e-01f, 1.06028048e-02f, 2.75506973e-02f, 9.47461799e-02f, 2.91445777e-02f, -2.09575519e-02f, -4.35795709e-02f, -9.88330320e-02f,
  -1.50540665e-01f, -4.28935215e-02f, -3.22874151e-02f, 1.36442725e-02f, -1.18617481e-03f, -9.04712752e-02f, -1.42800072e-02f, 5.83652733e-03f, -2.91064978e-02f, -8.99771452e-02f,
  8.76299664e-02f, 2.49247439e-02f, 2.93284655e-01f, 1.33310601e-01f, -4.58346277e-01f, 1.59853742e-01f, -5.00345565e-02f, -2.56305903e-01f, 1.77031621e-01f, -2.55246069e-02f,
  -1.26972035e-01f, 3.41150105e-01f, 1.30229771e-01f, 8.62236470e-02f, 3.25741708e-01f, 4.67105478e-01f, 2.51319140e-01f, 1.06346138e-01f, 1.26989767e-01f, -1.43189490e-01f,
  1.12876967e-01f, -3.28463644e-01f, -1.66564696e-02f, -3.61736834e-01f, -2.92177051e-01f, -1.13280542e-01f, -2.83744693e-01f, -8.58718529e-02f, -1.83142647e-01f, 6.56535178e-02f,
  -5.21423891e-02f, -9.92600247e-03f, -1.81277078e-02f, 1.26837850e-01f, -1.33456483e-01f, 9.87899676e-03f, 2.81941928e-02f, 1.64150670e-02f, 1.88965835e-02f, 3.23682874e-02f,
  7.89990928e-03f, 2.09276285e-02f, 6.37823716e-02f, -2.96342210e-03f, 1.69390757e-02f, 6.33546710e-02f, 1.39097683e-02f, -1.49698462e-02f, -1.74654666e-02f, 1.49099812e-01f,
  8.50414857e-02f, 9.91815105e-02f, 1.24910221e-01f, 2.28662081e-02f, 5.35812527e-02f, 5.57944030e-02f, 2.48492751e-02f, 9.18270927e-03f, 1.55943050e-03f, -5.26684858e-02f,
  3.68644221e-04f, 1.55026587e-02f, -5.54206856e-02f, 5.71786314e-02f, -6.09218068e-02f, 6.51584938e-03f, 8.52981359e-02f, -8.62501636e-02f, 4.94598746e-02f, 2.22897809e-03f,
  3.02632619e-02f, -2.25206558e-02f, 5.67616187e-02f, -8.71518720e-03f, -3.66299301e-02f, 2.56700106e-02f, -1.70090806e-03f, 1.96655989e-02f, -2.21175924e-02f, -4.64084037e-02f,
  6.02024719e-02f, 1.10705066e-02f, -7.34877735e-02f, 5.49175637e-03f, 3.23284008e-02f, -4.72530425e-02f, 1.12232924e-01f, 4.98001873e-02f, -3.13722380e-02f, -1.46494182e-02f,
  -1.64694980e-01f, -3.96215990e-02f, -1.05240308e-01f, -1.06660336e-01f, -2.28070430e-02f, -2.14526895e-02f, 7.22761825e-02f, 3.52562102e-03f, 2.90064383e-02f, -1.57966334e-02f,
  -9.84367281e-02f, -1.14509672e-01f, 3.18427011e-02f, -5.85667929e-03f, -9.57004540e-03f, -7.02689588e-02f, 1.50985280e-02f, -3.74504179e-02f, -7.22054318e-02f, -9.52306315e-02f,
  -1.81251377e-01f, -1.03277378e-01f, -2.72517297e-02f, -1.10235840e-01f, -7.78997019e-02f, -4.35385369e-02f, -6.66894540e-02f, -2.49068737e-02f, 3.62348482e-02f, 1.67930461e-02f,
  -4.66225028e-01f, -2.05647901e-01f, -4.05199707e-01f, -1.16617180e-01f, 4.45939228e-02f, -2.41441160e-01f, -1.91508412e-01f, -1.91306695e-02f, -1.91748291e-01f, 3.61605227e-01f,
  2.39728704e-01f, -2.60979086e-01f, 7.60330111e-02f, 9.43929702e-02f, -2.43566468e-01f, 9.65019464e-02f, -5.10560209e-03f, 2.64070779e-02f, -1.33251980e-01f, -1.55760780e-01f,
  -6.44924641e-02f, 2.24751949e-01f, -6.24573454e-02f, 5.26859239e-02f, -9.05046836e-02f, -1.33564025e-01f, 3.53739083e-01f, -9.76527035e-02f, 1.45208865e-01f, -6.18559867e-03f,
  5.01006376e-03f, 1.28723634e-03f, -8.24055672e-02f, -6.92984983e-02f, -2.08317656e-02f, 5.83880162e-03f, 2.34032646e-02f, -4.22216058e-02f, -1.62328016e-02f, -2.13588942e-02f,
  -7.91302603e-03f, 2.35926136e-02f, -2.81612631e-02f, -3.46468464e-02f, 5.33512747e-03f, -5.49603924e-02f, -5.20276166e-02f, 1.40517578e-03f, -5.18779904e-02f, -4.08204421e-02f,
  -9.66185778e-02f, 8.52563046e-03f, -2.15418749e-02f, 2.81229094e-02f, -6.19995669e-02f, -7.41385669e-02f, -7.21427612e-03f, -4.72743250e-02f, -1.21474955e-02f, -4.19087186e-02f,
  6.97938427e-02f, -7.22419983e-03f, -2.66616093e-03f, 1.50472587e-02f, -6.88888282e-02f, 4.30420786e-02f, 1.22782132e-02f, 9.44475681e-02f, -7.44383559e-02f, 4.84679304e-02f,
  3.92396282e-03f, -5.37811667e-02f, 8.23126882e-02f, 5.56579866e-02f, 2.19753869e-02f, 3.08508473e-03f, 1.72694586e-03f, 1.23540014e-02f, -2.02187262e-02f, -8.78559146e-03f,
  1.74008682e-02f, -1.95087753e-02f, -9.45161446e-04f, 8.09238777e-02f, 1.75646693e-02f, -3.42184938e-02f, 6.54220805e-02f, -1.72467958e-02f, 8.13264120e-03f, -4.72938791e-02f,
  3.65767702e-02f, 9.01315454e-03f, 2.23214403e-02f, 5.84003143e-02f, 2.89209057e-02f, 2.03957167e-02f, -8.74336250e-03f, -4.74582352e-02f, -3.74643207e-02f, -7.20343962e-02f,
  5.79412095e-02f, 3.90935317e-02f, -4.31052037e-03f, 4.04550359e-02f, -2.66599767e-02f, 5.60640134e-02f, 7.02701807e-02f, 1.51715791e-02f, 4.07434516e-02f, 3.34848575e-02f,
  7.24415407e-02f, 3.78576145e-02f, -9.58328322e-02f, 1.59722567e-02f, 7.79987574e-02f, 6.93261400e-02f, -1.16360206e-02f, -6.82787644e-03f, 8.16674232e-02f, 4.14061211e-02f,
  -1.51783228e-01f, -8.26693028e-02f, -3.57041836e-01f, -2.11665243e-01f, -6.67083487e-02f, 3.77902180e-01f, 1.37826219e-01f, -1.42480224e-01f, -3.68687242e-01f, 3.00944775e-01f,
  4.41784970e-02f, -2.01779902e-01f, -1.33730486e-01f, 7.33826831e-02f, -3.52637738e-01f, -5.18076420e-02f, 3.13176960e-01f, 1.47167683e-01f, -1.65775910e-01f, -1.08797595e-01f,
  -1.25050977e-01f, 8.77202228e-02f, -1.56000659e-01f, 1.04260787e-01f, -7.10577741e-02f, -1.25816008e-02f, 1.31425455e-01f, -1.59347251e-01f, 1.58575132e-01f, 1.81779936e-02f,
  2.42652316e-02f, -1.52249470e-01f, -9.84447002e-02f, 2.24759802e-02f, -1.96451787e-02f, 1.14410393e-01f, 1.12416774e-01f, -2.27945503e-02f, -8.01555738e-02f, 1.47753926e-02f,
  4.23823558e-02f, 5.55392215e-03f, -3.87194566e-02f, -7.55114257e-02f, 9.87875275e-03f, -9.47434679e-02f, -1.59305662e-01f, -1.58848278e-02f, -1.51178032e-01f, -9.15071517e-02f,
  -1.53825343e-01f, 4.19224277e-02f, 2.34769024e-02f, 1.62394315e-01f, -5.86837977e-02f, -1.94888804e-02f, 1.05479874e-01f, 4.11796048e-02f, 1.15101323e-01f, 1.41376909e-02f,
  1.11581713e-01f, 4.75882478e-02f, 5.58565408e-02f, -4.41553444e-02f, -8.02997276e-02f, -3.86912748e-02f, -1.39238569e-03f, 2.97267325e-02f, -1.41215920e-02f, -4.32062820e-02f,
  6.69295713e-02f, -5.03499843e-02f, 1.86384879e-02f, 2.81968042e-02f, 2.92247999e-02f, 2.93722861e-02f, 3.08864005e-02f, 5.16302995e-02f, -6.30117357e-02f, -4.49698456e-02f,
  -3.95308249e-02f, 4.56115007e-02f, -5.68396449e-02f, 7.25054070e-02f, 9.45905894e-02f, -1.16907097e-01f, 1.20616183e-02f, -2.26663034e-02f, -5.43306433e-02f, -6.80302130e-03f,
  1.29501164e-01f, 7.18545914e-02f, -6.82360604e-02f, -5.76787337e-04f, -3.93902287e-02f, -9.91316736e-02f, -4.77646291e-02f, -2.46264413e-02f, -2.64192615e-02f, -3.73861715e-02f,
  6.17227145e-02f, 2.00816374e-02f, 1.14477605e-01f, -1.77342317e-03f, 2.83428915e-02f, 5.26480153e-02f, 1.39711261e-01f, 4.43332866e-02f, 5.38128801e-02f, 6.93743452e-02f,
  4.76043299e-02f, 5.34000099e-02f, -1.10737365e-02f, 2.79616122e-03f, 5.61650209e-02f, 9.90692992e-03f, 1.21953906e-02f, 7.26254731e-02f, 7.80948102e-02f, -2.26953886e-02f,
  -6.36510730e-01f, 2.28844300e-01f, -1.38016671e-01f, 1.14115380e-01f, 5.19632995e-02f, -1.74305782e-01f, -5.37425838e-02f, 1.04345329e-01f, -2.01859728e-01f, 2.18391985e-01f,
  2.97782451e-01f, -7.81539977e-02f, 5.52224554e-02f, 2.73366272e-01f, -1.75976172e-01f, 8.57653916e-02f, -1.23598799e-01f, -6.78229257e-02f, 5.16321622e-02f, -1.25899196e-01f,
  -1.38521850e-01f, 2.16422439e-01f, 8.53549242e-02f, 1.89691588e-01f, -3.64604443e-02f, -2.02590358e-02f, 1.18431203e-01f, 1.71671718e-01f, 6.55992404e-02f, 5.09583727e-02f,
  1.03258044e-01f, 1.32569253e-01f, -1.26993060e-01f, -1.03290610e-01f, -7.51597136e-02f, -1.02757521e-01f, -1.63804516e-01f, 1.27901593e-02f, 4.59752753e-02f, -1.35067888e-02f,
  -2.29848456e-03f, 6.39138371e-02f, -3.73407803e-03f, 1.07657947e-02f, -1.04091838e-01f, 3.71404588e-02f, 1.96118001e-02f, -6.22846447e-02f, -3.22741605e-02f, -3.12068462e-02f,
  1.11399312e-02f, -1.01694740e-01f, -5.79493381e-02f, -4.87330407e-02f, -1.38187129e-02f, 7.18108565e-02f, -1.74922515e-02f, -8.51466209e-02f, -7.07375705e-02f, -5.96672110e-02f,
  -4.82568927e-02f, 5.58191584e-03f, -2.56685782e-02f, -1.09518471e-03f, 7.06248805e-02f, 6.89921994e-03f, -6.33242205e-02f, 5.89985438e-02f, -8.51103384e-03f, 5.61971180e-02f,
  4.38684076e-02f, -4.36206311e-02f, 4.86114472e-02f, -3.18989195e-02f, 3.89312282e-02f, -5.34493178e-02f, 2.74388064e-02f, 1.19967021e-01f, -1.75935298e-01f, 7.31434897e-02f,
  6.61131665e-02f, 5.18132038e-02f, -2.19309218e-02f, -6.18222393e-02f, -2.40119621e-02f, -6.08319938e-02f, 2.68498044e-02f, -3.48597043e-03f, 7.35371634e-02f, -3.78484167e-02f,
  3.37306969e-02f, 1.05411097e-01f, 1.09159559e-01f, 4.74962518e-02f, 2.17820834e-02f, -5.91978244e-02f, 5.98666146e-02f, -3.73700168e-03f, 2.00171638e-02f, 9.71502904e-03f,
  -4.17691916e-02f, -9.09774005e-02f, -9.09150578e-03f, -2.51548495e-02f, -8.78114626e-03f, 3.92097384e-02f, 5.41258790e-02f, 9.62259248e-04f, -1.88972205e-02f, 2.06992775e-02f,
  2.70244610e-02f, -1.16626658e-02f, -8.76132697e-02f, 9.34756070e-04f, -8.58929604e-02f, 1.10102631e-03f, -6.45669596e-03f, -8.67406931e-03f, 1.53554315e-02f, 1.20180249e-02f,
  -4.16399121e-01f, 5.57143807e-01f, 1.65785789e-01f, -1.88270077e-01f, 1.11530446e-01f, 1.10208042e-01f, -2.61429965e-01f, 3.06136787e-01f, -1.95207819e-01f, 2.39536330e-01f,
  4.92845895e-03f, -1.76842824e-01f, -6.26365691e-02f, 3.06290954e-01f, -3.82409662e-01f, -1.53574064e-01f, -3.62836979e-02f, -6.53631240e-02f, -2.01178432e-01f, 1.78330421e-01f,
  -1.44517124e-02f, 3.57779860e-02f, 1.78237304e-01f, 2.56539613e-01f, 1.66404381e-01f, 4.80219088e-02f, 1.19914263e-02f, -1.03418216e-01f, 2.44816631e-01f, -5.97170219e-02f,
  1.07928157e-01f, 1.54838294e-01f, 3.13856900e-02f, -3.06804646e-02f, 3.62637974e-02f, 6.50005043e-02f, -6.65362775e-02f, -9.44823697e-02f, -7.08164871e-02f, 3.57205160e-02f,
  -3.18881795e-02f, -2.96284221e-02f, -4.53179255e-02f, -6.63250014e-02f, 8.07349235e-02f, 1.75380390e-02f, 5.71408048e-02f, 7.57636800e-02f, 3.55419293e-02f, 5.96730486e-02f,
  -4.33926210e-02f, 4.94270772e-02f, 2.80982554e-02f, -5.49355559e-02f, -2.17409972e-02f, -8.78896266e-02f, -1.27981100e-02f, -3.91482376e-03f, -4.22684290e-02f, 1.72252283e-02f,
  -4.34787944e-02f, -5.28349653e-02f, 5.00806142e-03f, 3.37189808e-03f, -4.78312485e-02f, 8.79263580e-02f, -3.19310278e-02f, 3.95010114e-02f, -1.06880851e-01f, -3.83757101e-03f,
  3.30253541e-02f, 1.13550732e-02f, -3.00022773e-03f, 5.24878465e-02f, -4.93544564e-02f, 5.22457808e-02f, -4.07211967e-02f, 1.63136218e-02f, -1.38501311e-02f, 1.17848650e-01f,
  -9.04981606e-03f, -3.80429998e-02f, -4.35613766e-02f, 5.55970380e-03f, 2.78762504e-02f, -5.20877466e-02f, 3.49795632e-02f, 7.79083744e-02f, -1.35946451e-02f, -2.00397652e-02f,
  2.36444715e-02f, 2.09154114e-02f, 3.65076438e-02f, 3.48542519e-02f, -4.72627841e-02f, 6.53754845e-02f, -6.15481399e-02f, 6.46006390e-02f, -3.36951241e-02f, 4.88413386e-02f,
  -1.21686347e-02f, -3.28973718e-02f, -1.15121016e-02f, -2.31969990e-02f, -4.36521284e-02f, 1.36701420e-01f, -5.76396137e-02f, -7.40091503e-02f, -9.21476111e-02f, 5.04628569e-02f,
  6.97256848e-02f, 9.81008634e-04f, -1.16344236e-01f, 5.29237166e-02f, 3.12123392e-02f, -7.03712106e-02f, -2.22264957e-02f, 1.43734552e-03f, -2.33834460e-02f, -6.79103434e-02f,
  4.21472639e-01f, -1.71994593e-03f, -3.08407068e-01f, 1.71076268e-01f, -2.98489723e-03f, 2.03302801e-01f, 4.40656930e-01f, 1.56898722e-01f, 3.31322223e-01f, 2.78373063e-01f,
  2.03020126e-01f, 1.35365844e-01f, 4.56826724e-02f, 3.32098901e-01f, -2.66561836e-01f, -1.19039193e-01f, 2.18697175e-01f, 1.38307348e-01f, 1.68269262e-01f, 1.22719169e-01f,
  -3.75627950e-02f, 1.80659547e-01f, -2.04261541e-01f, -4.10025902e-02f, 1.78346604e-01f, -2.97014397e-02f, -1.75672993e-01f, -1.89694874e-02f, 8.23956216e-04f, 1.12365866e-02f,
  -3.31558883e-02f, 4.06859815e-02f, 2.50419732e-02f, -2.77408771e-03f, 2.92589050e-03f, -2.85005774e-02f, -1.98894516e-02f, -4.41104695e-02f, -7.94064626e-02f, 4.95725684e-03f,
  4.02387930e-03f, -7.22260773e-02f, 6.63546398e-02f, -9.34509281e-03f, 1.44537076e-01f, -5.14380299e-02f, 6.49929652e-03f, 1.66123305e-02f, 4.68453877e-02f, -9.63212736e-03f,
  7.44393691e-02f, -6.23499304e-02f, 3.77605855e-02f, -2.21351516e-02f, -6.94085751e-03f, 7.91777521e-02f, -2.66859047e-02f, -8.18900913e-02f, 6.62410771e-03f, 2.53871875e-03f,
  -1.00963935e-02f, -2.38341521e-02f, -2.19208281e-02f, 5.27810119e-02f, -2.25639180e-03f, -2.87469085e-02f, 9.77641419e-02f, -6.08564280e-02f, -5.45908231e-03f, -2.89666932e-02f,
  2.52465121e-02f, 1.56369973e-02f, 5.02413400e-02f, 5.49311973e-02f, 6.85392469e-02f, 1.21454924e-01f, -1.84730105e-02f, 1.93222109e-02f, 3.48918848e-02f, 3.40805836e-02f,
  9.52402689e-03f, 4.08569500e-02f, 3.04076225e-02f, 2.32596532e-04f, 5.30353859e-02f, -4.92764264e-02f, 7.23687187e-02f, 3.95145128e-03f, 2.45566312e-02f, -4.08728421e-02f,
  5.65109663e-02f, -2.06491514e-03f, 3.65483277e-02f, 5.85692609e-03f, -4.05946486e-02f, -6.67163506e-02f, -2.16927808e-02f, -2.69771870e-02f, -1.84641350e-02f, 2.93815807e-02f,
  -1.50561603e-02f, 7.79347420e-02f, -5.97992912e-02f, 1.70416832e-02f, -7.18847513e-02f, 1.78954508e-02f, -2.01069955e-02f, 1.35979448e-02f, -7.94028416e-02f, -2.01653782e-03f,
  -1.02605209e-01f, -1.31880236e-03f, -8.50472152e-02f, 8.42119157e-02f, -2.21914407e-02f, 5.39129600e-02f, 4.67874184e-02f, 4.73893769e-02f, -8.12709183e-02f, -2.76450161e-02f,
  -3.96569788e-01f, 3.96609753e-01f, -9.80715752e-02f, -3.56185257e-01f, 2.88739860e-01f, 3.04883957e-01f, -3.48664261e-02f, 2.18785703e-01f, 7.23281428e-02f, 1.59476489e-01f,
  1.35258779e-01f, -8.23890045e-02f, 2.82269895e-01f, 1.04824238e-01f, -1.63727626e-01f, 3.29946548e-01f, -1.34200931e-01f, 3.47490236e-02f, 1.45231977e-01f, 9.62693244e-02f,
  -8.41082558e-02f, 2.67997291e-02f, -1.01840422e-01f, 2.41873011e-01f, -4.28117476e-02f, -8.69624615e-02f, -2.30664477e-01f, 1.76378395e-02f, -1.96086392e-01f, 2.71621644e-02f,
  -2.93847229e-02f, 1.11168183e-01f, -7.73482472e-02f, -8.72903224e-03f, -2.56851371e-02f, 1.60026103e-02f, -1.21564060e-01f, -5.99814244e-02f, -2.74524558e-03f, -7.10401102e-04f,
  2.82257479e-02f, -4.34839092e-02f, -2.52560452e-02f, 4.94630039e-02f, 3.29122469e-02f, -3.57765891e-02f, -1.11343293e-02f, 9.95078590e-03f, 5.54200634e-02f, 4.90418002e-02f,
  -5.70169352e-02f, 1.22131605e-03f, -5.97951822e-02f, -1.56465992e-02f, -6.59304559e-02f, 1.09149897e-02f, 3.38038336e-03f, -1.68101471e-02f, -3.22701186e-02f, -4.25320826e-02f,
  4.12020385e-02f, 8.07798281e-02f, -1.79609526e-02f, 3.41293663e-02f, 8.02199319e-02f, 3.43076289e-02f, -5.06759472e-02f, -4.24929932e-02f, -7.00537562e-02f, 7.29223713e-02f,
  -4.26399931e-02f, -1.71808917e-02f, 7.13202953e-02f, -1.62123982e-02f, -1.30296098e-02f, 2.44019404e-02f, -3.35439807e-03f, 9.59259085e-03f, -8.01072419e-02f, -5.50905354e-02f,
  -1.93484481e-02f, 1.85440555e-02f, -1.02184024e-02f, 1.64555367e-02f, 3.60916145e-02f, -3.83460075e-02f, 6.16676360e-02f, -3.68976258e-02f, 3.67231891e-02f, -3.78540978e-02f,
  2.22448930e-01f, 6.73459992e-02f, 7.04904720e-02f, -8.38681683e-02f, -7.24907070e-02f, 2.25553568e-02f, 5.65735251e-02f, 1.07250502e-02f, -4.33340110e-02f, 1.78924352e-02f,
  -6.48633018e-02f, 1.01923812e-02f, -4.86934761e-04f, 3.90819833e-02f, -6.01044595e-02f, -1.01790912e-02f, 2.13694642e-03f, -4.25733998e-02f, -8.99110064e-02f, -9.29476600e-03f,
  -1.12155326e-01f, -2.18713656e-02f, -1.05512232e-01f, -4.27593961e-02f, 1.28799109e-02f, -4.67200615e-02f, 5.18609397e-02f, -4.19210196e-02f, -4.76475768e-02f, 1.76159590e-02f,
  -3.82129848e-02f, -2.33709991e-01f, -1.05276749e-01f, -2.35920757e-01f, 2.31089234e-01f, 3.94406676e-01f, -1.80345714e-01f, 1.70319140e-01f, -2.25772068e-01f, -3.32755111e-02f,
  1.20366067e-01f, -3.64328533e-01f, -1.69802636e-01f, 1.19345114e-01f, 2.25781739e-01f, -1.35510281e-01f, 2.76114970e-01f, -1.09357454e-01f, -1.20768249e-02f, 7.09633604e-02f,
  -5.43341553e-03f, 2.66070873e-01f, -3.30279842e-02f, 2.56897300e-01f, 7.41546601e-02f, -4.21799459e-02f, 1.63113609e-01f, -1.57968014e-01f, 2.59562105e-01f, 5.38299941e-02f,
  1.73232704e-01f, -1.65185347e-01f, -1.18920721e-01f, -4.41937484e-02f, 1.47714823e-01f, 3.26467818e-03f, -5.21593317e-02f, -1.57565519e-01f, -3.52440700e-02f, -1.57143734e-02f,
  -8.16892013e-02f, 3.82109620e-02f, 2.70894859e-02f, -6.38905093e-02f, -2.60403380e-02f, 1.19163664e-02f, -1.26988813e-02f, 9.02944505e-02f, -1.54819801e-01f, -3.51332244e-03f,
  -5.09852208e-02f, -3.13215144e-03f, 1.19494367e-02f, 1.79911852e-02f, -3.10830213e-02f, 4.81351838e-02f, 2.84461323e-02f, -6.60129711e-02f, 6.88635036e-02f, 6.45947382e-02f,
  -6.16419949e-02f, -4.33034040e-02f, 1.93803627e-02f, 3.49331349e-02f, -4.78072576e-02f, 6.72156215e-02f, -1.73489414e-02f, 3.21476646e-02f, 2.52748523e-02f, 3.14605460e-02f,
  1.22252315e-01f, -5.42798825e-02f, -1.45697873e-02f, -5.49721671e-03f, 3.26200463e-02f, -2.50346847e-02f, 4.69251424e-02f, 1.36301052e-02f, 9.90721881e-02f, 4.03433554e-02f,
  -4.69460972e-02f, 7.40934536e-02f, -7.03533553e-03f, -1.83216669e-02f, 9.57398769e-03f, -1.19330607e-01f, -1.83460433e-02f, 2.40408722e-03f, -4.29151505e-02f, -1.88975339e-03f,
  3.11115324e-01f, 2.53794901e-02f, 1.62077490e-02f, 3.72557715e-02f, 8.44007358e-03f, 4.66209911e-02f, -4.55741574e-05f, 4.72829901e-02f, 1.17496327e-02f, 1.69048179e-02f,
  5.46321757e-02f, 8.31208751e-03f, 6.92607686e-02f, 4.14543785e-02f, 5.34358174e-02f, 6.82733627e-03f, -2.32098680e-02f, -2.93952283e-02f, 9.45258141e-02f, 8.19236189e-02f,
  3.08144540e-02f, 3.57820913e-02f, 6.88690692e-03f, 6.68713972e-02f, 3.35550047e-02f, 2.08244640e-02f, 1.55025749e-02f, -2.04364695e-02f, 6.20528422e-02f, -1.81946587e-02f,
  -3.90389174e-01f, 3.59737486e-01f, -6.49637356e-02f, -4.44081932e-01f, -2.01853469e-01f, -1.60052925e-02f, -1.50487483e-01f, -1.50175437e-01f, 1.02427877e-01f, 2.38771603e-01f,
  -2.21408054e-01f, 1.00150965e-01f, 1.36286259e-01f, -8.67461711e-02f, -3.89112473e-01f, 3.87930453e-01f, -2.64778227e-01f, 6.24820851e-02f, 4.84558642e-02f, -1.46958500e-01f,
  -1.55539781e-01f, -1.29448414e-01f, -1.63554162e-01f, 5.91985621e-02f, -1.47461653e-01f, -5.38890846e-02f, -1.94929779e-01f, 1.01616219e-01f, -1.49021283e-01f, 5.53035364e-02f,
  2.78187599e-02f, 1.02780469e-01f, 1.18644843e-02f, 1.24142796e-01f, -1.44345492e-01f, -5.63643463e-02f, -5.29568903e-02f, 7.62786891e-04f, -7.63879642e-02f, -4.36007641e-02f,
  1.74863059e-02f, -3.73194814e-02f, -2.51432620e-02f, 4.16819789e-02f, -7.30683059e-02f, 5.88628463e-03f, 1.79285221e-02f, -1.16263377e-02f, 4.99368459e-02f, -6.36267513e-02f,
  -2.00593800e-04f, 5.35751088e-03f, -8.04420114e-02f, 5.78235574e-02f, -4.25522327e-02f, -5.67744970e-02f, -8.40806216e-03f, -2.41818968e-02f, 5.63403852e-02f, -2.06987821e-02f,
  2.08885428e-02f, -7.78296366e-02f, 1.68561097e-02f, -5.81221059e-02f, 1.69768359e-03f, -4.68833074e-02f, 2.61000190e-02f, -5.80393849e-03f, 1.74265057e-02f, -2.63064466e-02f,
  -7.48843998e-02f, -7.31382445e-02f, -2.24747006e-02f, -2.48537958e-02f, -1.14788964e-01f, -1.32950312e-02f, -4.74167056e-02f, 2.35661380e-02f, -8.73067081e-02f, -8.59432817e-02f,
  3.70783098e-02f, 4.99869809e-02f, 5.07780910e-03f, 2.57969145e-02f, 1.03618326e-02f, -6.16218522e-02f, 3.09208594e-03f, 2.14731768e-02f, -1.93506405e-02f, -8.43040794e-02f,
  4.40540798e-02f, 5.25632724e-02f, 1.46483217e-04f, 5.32991719e-03f, 1.21631414e-01f, -1.42134111e-02f, 9.79428217e-02f, -5.22612187e-04f, 6.12895451e-02f, -4.72307354e-02f,
  -5.84773943e-02f, 2.88273674e-04f, 8.08095708e-02f, -1.54754864e-02f, -5.64896651e-02f, -3.81315462e-02f, 3.35499150e-04f, -2.08699144e-02f, -6.98339269e-02f, -9.09876749e-02f,
  -8.91913101e-02f, -4.81997281e-02f, 5.08593470e-02f, -2.62262262e-02f, -6.13933057e-02f, -3.50133888e-03f, 6.35541230e-03f, -4.24463907e-03f, 1.00798063e-01f, 7.16000646e-02f,
  6.71689749e-01f, -3.20176005e-01f, -4.82403666e-01f, 2.88766772e-01f, 1.86425418e-01f, -2.23730415e-01f, -3.79092805e-02f, 5.93494810e-02f, 1.92975745e-01f, -8.64836872e-02f,
  3.08611337e-02f, -6.50184974e-02f, 3.54334153e-02f, 1.68108180e-01f, 3.46002787e-01f, 1.42960185e-02f, 1.40331894e-01f, -3.44003960e-02f, -2.19630629e-01f, 1.36056975e-01f,
  -7.20663415e-03f, 2.33765543e-01f, -3.19535360e-02f, -1.13919266e-01f, 5.10150790e-02f, -2.29724437e-01f, 8.08230415e-02f, -2.59926975e-01f, 1.08363386e-02f, 8.97250138e-03f,
  -5.38343452e-02f, 1.13803610e-01f, 2.46615820e-02f, -1.49117067e-01f, -1.81411505e-02f, -7.62889814e-03f, -6.16740249e-02f, -5.85566610e-02f, 1.46749001e-02f, 1.61962975e-02f,
  -1.43485109e-03f, -5.27052879e-02f, -4.68540713e-02f, 4.82686795e-02f, 4.52165604e-02f, 1.84476990e-02f, -1.60890073e-02f, -1.84165072e-02f, -6.42394423e-02f, -6.16790587e-03f,
  -2.77222563e-02f, -8.97827446e-02f, 1.21449120e-02f, 3.69510567e-03f, -7.82118440e-02f, -2.33367682e-02f, -3.89537029e-02f, 1.26988310e-02f, -7.24557647e-03f, 5.23146428e-03f,
  1.28559321e-01f, -8.63135308e-02f, -7.62804151e-02f, -1.30869187e-02f, -1.19532747e-02f, -6.69413507e-02f, 2.82847900e-02f, -2.26246677e-02f, -7.01147467e-02f, -4.93682502e-03f,
  4.92521636e-02f, 1.80487707e-02f, 2.39857193e-02f, -4.14895341e-02f, 1.49724977e-02f, 3.76665071e-02f, 1.84843410e-02f, -2.13890541e-02f, -9.27169472e-02f, -8.70849863e-02f,
  -2.64127590e-02f, -4.68567573e-02f, -1.15833081e-01f, -2.23248303e-02f, -4.36665937e-02f, 2.33399440e-02f, -6.69170246e-02f, -1.70942135e-02f, -3.66753601e-02f, 5.50765125e-03f,
  -6.59465732e-05f, 1.58297624e-02f, -4.98833358e-02f, -2.67803892e-02f, -1.55779468e-02f, 4.36646715e-02f, -6.07040226e-02f, -2.99256258e-02f, 6.23531751e-02f, 1.36659116e-01f,
  -5.60863465e-02f, 4.66342159e-02f, -9.19305235e-02f, -6.66591385e-03f, -1.22212641e-01f, -1.11305222e-01f, 2.27295086e-02f, -1.80185027e-02f, 6.29642084e-02f, -5.90421446e-02f,
  1.03266137e-02f, -1.57632958e-03f, -4.59725633e-02f, 3.26602231e-03f, 4.27982509e-02f, -2.49881931e-02f, 1.26163155e-01f, -8.60566646e-02f, -3.65341008e-02f, -8.13686997e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.02503307e-01f, -5.46216704e-02f, -5.15852332e-01f, -5.32017529e-01f, 1.99006334e-01f, 6.22044206e-01f, 1.36725008e-01f, 2.13979296e-02f, -4.41745996e-01f, 5.68320334e-01f,
  5.84784687e-01f, -6.43122435e-01f, 2.32276544e-01f, -7.67544508e-02f, -4.89167422e-01f, -6.96572661e-02f, 1.65467337e-01f, 1.30905226e-01f, -2.39195049e-01f, 1.40865073e-01f,
  -2.27998629e-01f, 2.53416002e-01f, -3.44690889e-01f, 2.28043303e-01f, 2.14655548e-01f, -1.83247119e-01f, 3.14294904e-01f, -2.00098887e-01f, 9.81566682e-02f, -1.90490633e-01f,
  5.40321358e-02f, -5.41239679e-02f, 4.58754003e-02f, -8.33110884e-02f, 2.92936414e-01f, 2.75469124e-01f, 1.12735666e-01f, -1.41047150e-01f, -1.76123545e-01f, -1.13801934e-01f,
  3.65309045e-02f, -1.45041585e-01f, -1.07104592e-01f, -1.09168977e-01f, 2.10835543e-02f, -3.64864767e-02f, -8.40109959e-02f, 5.69485985e-02f, -1.02693044e-01f, -1.90420840e-02f,
  -4.84842695e-02f, -9.62979496e-02f, 1.07239142e-01f, -1.23645738e-01f, -7.75005743e-02f, -2.93824822e-02f, 3.21947038e-02f, 3.62014235e-03f, 3.29242796e-02f, -7.40148798e-02f,
  3.94335054e-02f, 1.38465300e-01f, 1.16881832e-01f, -1.76291410e-02f, 7.60323741e-03f, 1.32052720e-01f, -1.65897813e-02f, -1.98084731e-02f, -8.85267109e-02f, 5.37531860e-02f,
  1.26423240e-02f, -1.06679007e-01f, -2.11436544e-02f, 5.08613326e-02f, 9.12982821e-02f, -8.29299986e-02f, 4.16023731e-02f, -6.67522252e-02f, 9.26202163e-02f, -4.65897620e-02f,
  -6.24154247e-02f, 5.92731051e-02f, -8.48846212e-02f, 9.07302126e-02f, 4.93526496e-02f, -8.62281621e-02f, 8.57944638e-02f, 4.72739637e-02f, 3.66106071e-02f, 5.14606051e-02f,
  1.68046474e-01f, 1.58030301e-01f, 7.79267475e-02f, -8.45362991e-02f, 7.82323256e-02f, 2.50689059e-01f, 7.73892878e-03f, -9.98092741e-02f, -6.52759522e-02f, 9.70755890e-02f,
  1.33165419e-01f, 8.16255137e-02f, 2.64268875e-01f, -3.40415500e-02f, -1.31497562e-01f, 2.34255970e-01f, 5.30227087e-02f, -1.04974978e-01f, 1.03383057e-01f, 1.12258963e-01f,
  1.30214438e-01f, 1.32286355e-01f, 8.97120591e-03f, -7.75160417e-02f, -1.16715003e-02f, 1.08130060e-01f, 3.06053013e-02f, -1.29294753e-01f, 3.67207490e-02f, -6.43230379e-02f,
  5.26808560e-01f, 6.74325883e-01f, 2.20327079e-01f, 3.63275528e-01f, 2.03652814e-01f, 5.95097780e-01f, 4.38443989e-01f, 1.86331436e-01f, 4.98709947e-01f, 2.05226421e-01f,
  -2.40744174e-01f, 5.97548902e-01f, -3.25595289e-01f, 4.27939087e-01f, 2.89369025e-03f, -1.13159701e-01f, 4.20234174e-01f, 4.10418451e-01f, 9.87888649e-02f, 1.88521966e-01f,
  -2.76775192e-02f, 3.43597159e-02f, -4.05169189e-01f, -3.08124542e-01f, 6.93812966e-02f, -1.83479577e-01f, -6.94024563e-01f, -3.12709868e-01f, -5.00753187e-02f, 9.91152972e-02f,
  6.31906018e-02f, 1.52111962e-01f, 8.12599286e-02f, -1.45686707e-02f, 1.74391679e-02f, 8.84383246e-02f, -2.42913477e-02f, -1.59356538e-02f, -6.91283047e-02f, 5.71046993e-02f,
  5.31704500e-02f, 2.12976569e-03f, 1.73224702e-01f, 2.05314569e-02f, 1.43395364e-01f, 8.40326175e-02f, 3.39884162e-02f, -1.95029397e-02f, 8.98074359e-02f, -2.27395575e-02f,
  1.19577445e-01f, 3.24569084e-02f, 1.79944036e-03f, 3.34577821e-02f, -7.87841976e-02f, -2.73566358e-02f, 5.75598180e-02f, -1.64146498e-02f, 2.32188646e-02f, 2.18594015e-01f,
  2.72470023e-02f, 1.20814025e-01f, 3.71154733e-02f, -8.50652382e-02f, 5.60451187e-02f, -9.57154483e-02f, 2.60260068e-02f, 6.17155619e-03f, 1.29265375e-02f, 8.93708691e-02f,
  -4.87542413e-02f, 1.82478223e-02f, -7.27476133e-03f, 2.15124171e-02f, 4.31695692e-02f, 8.86433348e-02f, -5.78294322e-02f, -1.20941186e-02f, 4.16162647e-02f, -2.18176823e-02f,
  -3.83136980e-02f, 9.55091417e-02f, 2.18953025e-02f, -1.43426999e-01f, -5.66032045e-02f, 1.91073902e-02f, 3.37740220e-02f, 6.03663102e-02f, -1.05932295e-01f, -5.56672141e-02f,
  1.94515258e-01f, 4.22259748e-01f, 6.35944633e-03f, 2.48607900e-02f, -4.48480211e-02f, 1.56817362e-01f, 4.21015285e-02f, 2.48934120e-01f, 1.08778447e-01f, 1.14607461e-01f,
  6.14015087e-02f, 1.62194055e-02f, 5.08392788e-02f, -1.28350392e-01f, -7.04992861e-02f, 1.39870107e-01f, -8.82456154e-02f, 8.27451982e-03f, 1.54200587e-02f, -1.98214296e-02f,
  -3.73850837e-02f, 1.43474728e-01f, 7.61711746e-02f, 7.04555288e-02f, 8.18320736e-02f, -7.57054314e-02f, 1.77371949e-01f, -1.12629913e-01f, -8.77121016e-02f, 3.10607087e-02f,
  -7.70707130e-01f, -3.41418654e-01f, -3.60863984e-01f, -2.33712122e-02f, 1.93128198e-01f, 3.75491917e-01f, 3.91830415e-01f, -1.03179790e-01f, -4.08412755e-01f, 1.39630035e-01f,
  4.61952448e-01f, -2.21292973e-01f, 1.31729260e-01f, 5.31115294e-01f, 3.90979618e-01f, 3.11786503e-01f, 3.68171096e-01f, 1.35475039e-01f, -1.19695470e-01f, -1.74463511e-01f,
  -2.80321296e-02f, 3.68525147e-01f, 3.52211416e-01f, -1.01032117e-02f, 2.10487992e-01f, -3.17722917e-01f, 1.15233995e-01f, -2.12121189e-01f, 2.88134754e-01f, 2.28383392e-01f,
  -1.34918660e-01f, -3.73144150e-01f, -1.47780925e-02f, -2.54994363e-01f, -2.72527784e-02f, 1.30060213e-02f, -5.93634918e-02f, 5.56819551e-02f, -1.31606972e-02f, -4.26527895e-02f,
  -7.43551701e-02f, -6.80147111e-02f, 7.13169873e-02f, -8.38251635e-02f, -1.73972279e-01f, -6.56313375e-02f, 1.69730619e-01f, 1.40874922e-01f, 3.80896479e-02f, 9.13291723e-02f,
  4.84948270e-02f, 1.00172207e-01f, 1.41417816e-01f, 1.38957784e-01f, 9.83676240e-02f, -1.23994034e-02f, 7.24647865e-02f, 3.64703275e-02f, 3.66243422e-02f, -1.87364165e-02f,
  1.37718450e-02f, -7.94311911e-02f, 1.33884314e-03f, -4.01961096e-02f, 1.37720918e-02f, 1.16917700e-01f, 1.20756868e-02f, 1.28902808e-01f, -4.92707156e-02f, 8.38050321e-02f,
  5.30335754e-02f, 2.56203655e-02f, -8.03358927e-02f, 4.80907485e-02f, 2.06361096e-02f, -1.09472536e-02f, -9.44934413e-02f, -1.49802780e-02f, 6.11000992e-02f, 1.27967238e-01f,
  -4.93912436e-02f, -4.37988751e-02f, 2.32091118e-02f, 2.79711764e-02f, -2.43839920e-02f, 2.53115594e-02f, -5.32147959e-02f, -1.85186267e-02f, 7.85380006e-02f, 4.46985336e-03f,
  -6.12058997e-01f, -6.18798494e-01f, -4.03722338e-02f, 8.71949177e-03f, -7.73084760e-02f, 5.79239018e-02f, -6.25973716e-02f, 4.77664964e-03f, -5.71102463e-02f, -8.10937490e-03f,
  -8.41212198e-02f, 1.50865130e-03f, -2.20617205e-01f, -3.44094192e-03f, -5.05248122e-02f, 1.69724803e-02f, -1.10945866e-01f, -8.04476067e-02f, 5.54530174e-02f, -1.32687315e-01f,
  -1.97960599e-03f, 1.12764789e-02f, 2.92029064e-02f, 6.30400255e-02f, 1.11316577e-01f, 5.82317300e-02f, -1.94799215e-01f, -1.22720525e-01f, 9.70820338e-02f, 1.04658097e-01f,
  -8.55691493e-01f, 9.60712612e-01f, 3.87874931e-01f, 3.04074176e-02f, -3.98523241e-01f, 1.05162598e-01f, 1.56894207e-01f, 1.69316471e-01f, 6.14809506e-02f, 5.30370057e-01f,
  -1.41833887e-01f, 3.52871954e-01f, 6.98804408e-02f, 4.02120233e-01f, -7.82985032e-01f, 1.76701337e-01f, 9.71166641e-02f, 1.97299764e-01f, -8.55185911e-02f, -6.89585041e-03f,
  -1.72123566e-01f, -3.00051957e-01f, 1.69109061e-01f, -2.61201579e-02f, 6.15909882e-02f, 4.43088450e-02f, -5.08091867e-01f, -2.20425695e-01f, 3.31396423e-02f, -1.26288965e-01f,
  -3.38498533e-01f, -2.26429492e-01f, 1.81501955e-01f, -3.52063552e-02f, -5.75298332e-02f, -3.71585414e-02f, -4.38689068e-02f, -1.20005392e-01f, -1.05675504e-01f, 8.82177427e-02f,
  1.11682773e-01f, 1.86562762e-02f, -2.55547231e-03f, -3.71504948e-02f, -3.00609469e-02f, 5.04178517e-02f, 1.25098377e-01f, 1.15717374e-01f, 1.22814223e-01f, 1.86016381e-01f,
  3.02280158e-01f, 1.00341722e-01f, 3.36753810e-03f, 4.99857403e-02f, -7.24159777e-02f, -9.30917915e-03f, 4.15302366e-02f, -9.99288168e-03f, 9.63025168e-02f, -8.68179053e-02f,
  9.23715415e-04f, -9.58172381e-02f, 7.85614625e-02f, -6.32051378e-02f, 4.47062291e-02f, -3.99519205e-02f, 4.33210954e-02f, -1.86738595e-01f, 4.97132130e-02f, -1.05165765e-01f,
  -5.08484319e-02f, 4.20880951e-02f, -9.83949304e-02f, -1.69721048e-03f, 3.32380347e-02f, 5.92832677e-02f, 5.09614907e-02f, -3.07440031e-02f, 5.23620248e-02f, 1.12514524e-02f,
  -7.95353428e-02f, -9.12535712e-02f, 6.74137473e-02f, -1.41129829e-02f, -1.25801470e-02f, -9.37080949e-06f, -6.78765178e-02f, 1.72606900e-01f, 2.63736546e-02f, -2.03558147e-01f,
  -7.18726575e-01f, -6.80174530e-01f, -1.33137517e-02f, -2.77647581e-02f, 1.85133866e-03f, 1.06262637e-03f, -6.79084510e-02f, 4.71301936e-03f, -1.66585118e-01f, -2.22770311e-02f,
  -5.88080399e-02f, 5.60534745e-02f, -1.47767603e-01f, -3.19208093e-02f, 8.64098687e-03f, -1.06577426e-01f, -1.39031291e-01f, -5.33041395e-02f, -1.81006968e-01f, -7.46064484e-02f,
  3.89897339e-02f, -7.23177195e-02f, 1.65366698e-02f, -9.65508446e-03f, 9.68305860e-03f, -1.13314852e-01f, -1.03280522e-01f, 1.09331682e-01f, -1.63837194e-01f, 6.61907494e-02f,
  7.28525743e-02f, -3.55940275e-02f, -3.10107619e-01f, -4.27886248e-01f, -3.26115012e-01f, -2.16844410e-01f, -4.05796438e-01f, -1.27131000e-01f, -6.31703287e-02f, -1.30984083e-01f,
  -3.57063651e-01f, 1.47611499e-01f, 2.17530385e-01f, -4.29217547e-01f, 4.81486261e-01f, 4.35968280e-01f, -2.70088851e-01f, -1.45294771e-01f, 1.71431452e-01f, -2.55479187e-01f,
  3.64101194e-02f, -2.72273898e-01f, 4.93317544e-02f, -1.15484007e-01f, -5.41172802e-01f, -2.94816643e-01f, -7.61335567e-02f, -4.04409170e-01f, -3.84765238e-01f, -1.64830610e-01f,
  -1.46207139e-01f, -6.73886016e-02f, -1.21195890e-01f, 1.39771551e-01f, -5.82455024e-02f, -6.63050413e-02f, -1.64044127e-01f, -9.03020203e-02f, 7.50000030e-02f, 3.56020257e-02f,
  8.17682967e-02f, 2.45872408e-01f, -1.42064020e-02f, 3.57840881e-02f, -2.23811582e-01f, -4.99572009e-02f, 5.24294376e-02f, -5.87771200e-02f, -3.61958034e-02f, -2.81575918e-02f,
  -9.07049179e-02f, 8.07576464e-04f, -1.79730475e-01f, 1.12022579e-01f, -8.22809935e-02f, -2.20175296e-01f, 4.46597189e-02f, -8.81155208e-02f, 1.15703093e-03f, -2.91738636e-03f,
  -7.80805647e-02f, 1.02285102e-01f, 6.15540221e-02f, -7.77820051e-02f, 1.02529014e-02f, -8.08909386e-02f, 4.25123796e-02f, 3.36424708e-02f, 2.12037843e-02f, -9.29477438e-03f,
  3.90429236e-03f, -7.67491162e-02f, 4.04294655e-02f, 1.12440608e-01f, -3.77207734e-02f, 6.23270273e-02f, 3.74902925e-03f, 4.86148102e-03f, -1.17290420e-02f, 1.01580538e-01f,
  -2.62170229e-02f, -1.80460494e-02f, 2.26574093e-02f, -1.35202650e-02f, -2.98992693e-02f, 1.06618935e-02f, 1.20974565e-02f, 4.60053384e-02f, 4.46953140e-02f, 1.85334347e-02f,
  1.63688883e-02f, -2.65998617e-02f, 3.24821249e-02f, 1.07500806e-01f, 8.39418173e-02f, 1.17479585e-01f, 1.52755352e-02f, -7.75289088e-02f, -7.56716281e-02f, -5.59027540e-03f,
  -1.74770597e-02f, -1.00858174e-02f, -1.26906894e-02f, -2.40691025e-02f, 1.11493349e-01f, 3.53057422e-02f, -2.10355911e-02f, 7.56998807e-02f, -3.56632657e-02f, -4.11375798e-02f,
  1.48019055e-03f, 4.51744944e-02f, 1.76914155e-01f, 2.41869837e-02f, -1.06936274e-02f, -7.62750730e-02f, 9.53465998e-02f, 1.35258660e-02f, -2.46784184e-02f, -5.91382990e-03f,
  -6.25190794e-01f, -1.59754723e-01f, 5.87930918e-01f, -5.03199100e-01f, 3.90264913e-02f, 5.07981718e-01f, 3.55513901e-01f, -2.50824779e-01f, -7.24952042e-01f, -3.14206153e-01f,
  -1.14463188e-01f, 2.03573890e-02f, 4.40441281e-01f, -1.45132691e-02f, 8.26571524e-01f, 3.35983664e-01f, -6.31655157e-02f, 3.46843340e-02f, 5.60529865e-02f, -2.66986694e-02f,
  -5.48788905e-02f, -6.21873252e-02f, 4.52427149e-01f, -1.50214471e-02f, -1.28007874e-01f, -1.78136960e-01f, -4.44610752e-02f, 4.43753570e-01f, 4.47340533e-02f, 2.99563050e-01f,
  2.08243743e-01f, -3.79941702e-01f, 1.39521137e-02f, 1.42128274e-01f, -1.71546713e-02f, -1.07435184e-02f, 1.81641147e-01f, 2.48806372e-01f, -1.26893610e-01f, -5.25561683e-02f,
  -9.69713461e-03f, 7.70564601e-02f, -1.99217007e-01f, 1.63036689e-01f, -2.13808581e-01f, -1.82929561e-01f, -1.05319202e-01f, -8.34260732e-02f, 1.74946655e-02f, 8.70811343e-02f,
  4.03844193e-02f, -2.78317444e-02f, -1.60028920e-01f, -4.56257425e-02f, -2.32536662e-02f, -1.57148868e-01f, 7.60101378e-02f, 1.89205155e-01f, -4.50522527e-02f, -1.68127283e-01f,
  -3.96290049e-02f, 3.50248590e-02f, 6.62576035e-02f, 2.87096319e-03f, -2.39463896e-03f, -3.12374216e-02f, -3.58451977e-02f, 9.83774066e-02f, -9.43480581e-02f, -9.64733958e-02f,
  -5.00772893e-02f, 3.74850333e-02f, -1.31388977e-01f, -1.14958160e-01f, -6.80034086e-02f, -1.10813782e-01f, 1.56744987e-01f, 4.11996618e-02f, -1.36902750e-01f, 5.70228659e-02f,
  -4.99059670e-02f, 7.06700906e-02f, 2.48083938e-02f, 1.73113029e-02f, -1.10830702e-02f, 3.15194987e-02f, -1.13085926e-01f, -3.01215444e-02f, -1.70417968e-02f, 2.27548182e-01f,
  2.22666427e-01f, -3.97522226e-02f, 1.18501298e-01f, -9.29208919e-02f, 9.66610089e-02f, 1.99482702e-02f, 8.69296417e-02f, -1.04955822e-01f, 3.00478246e-02f, 5.81046939e-02f,
  -5.38685806e-02f, -3.28077599e-02f, -9.48285013e-02f, -1.20137669e-02f, 1.13169760e-01f, 1.23475399e-02f, 1.29718706e-01f, -2.96925418e-02f, 6.65823668e-02f, -6.86294138e-02f,
  -1.03052169e-01f, -8.06261972e-02f, -8.91462993e-03f, -1.17517024e-01f, -8.78676027e-02f, 4.93269973e-03f, 3.75475385e-03f, -1.14656761e-01f, 1.18876897e-01f, -5.11276163e-02f,
  -5.97275235e-02f, 2.91526824e-01f, 2.85285655e-02f, -2.85096496e-01f, 9.38983336e-02f, -6.36488795e-01f, -3.61983925e-01f, -2.20082209e-01f, -1.67296361e-02f, 1.79572493e-01f,
  -3.35610807e-02f, 4.30485904e-01f, 1.85511455e-01f, -3.67966354e-01f, -4.17546630e-01f, -8.60837922e-02f, -6.03117108e-01f, -1.76109806e-01f, 2.26257294e-02f, -2.98670471e-01f,
  -2.60347009e-01f, -4.11939085e-01f, -3.29376310e-01f, -1.91968113e-01f, -1.93025842e-01f, 8.45220685e-02f, -1.21647805e-01f, 3.07834119e-01f, -2.74922907e-01f, -2.26935535e-03f,
  -1.01476885e-01f, -3.24059241e-02f, 1.58089131e-01f, -4.10447754e-02f, -2.06468359e-01f, -2.11685393e-02f, 1.11326411e-01f, 1.44161239e-01f, 2.05076765e-02f, -1.25455428e-02f,
  9.71273780e-02f, 9.74418670e-02f, 1.79601405e-02f, 1.02772169e-01f, 3.39584425e-03f, 9.98834297e-02f, 9.75388885e-02f, -1.15832537e-02f, -2.26576719e-02f, 1.13187812e-01f,
  5.03860861e-02f, 8.79404843e-02f, -9.19715017e-02f, -4.89466116e-02f, 7.75577826e-03f, 7.37183169e-02f, -1.53171837e-01f, 1.66047648e-01f, -5.61266914e-02f, -7.64556304e-02f,
  -1.07312247e-01f, -1.16211005e-01f, 4.85333428e-03f, 3.52878422e-02f, -1.67488027e-02f, -2.31593512e-02f, -2.35987641e-02f, 8.86923149e-02f, 7.51701742e-02f, 5.96940555e-02f,
  3.66819687e-02f, 6.99415579e-02f, -2.63708811e-02f, -1.87319174e-01f, -1.65027864e-02f, -2.33881436e-02f, -1.61664430e-02f, 2.96358075e-02f, -9.28656533e-02f, -1.32746696e-02f,
  5.40168025e-02f, -6.14344664e-02f, 3.35725136e-02f, -1.33749768e-01f, -1.03891544e-01f, 4.90873121e-02f, 1.54822366e-03f, -1.69348344e-02f, -6.21286184e-02f, 5.32296002e-02f,
  -4.69620079e-01f, -4.15571481e-01f, 5.12646139e-02f, 8.94249827e-02f, 4.43490557e-02f, -3.73800099e-02f, 5.95598074e-04f, -8.05068668e-03f, -7.38398060e-02f, -1.45864025e-01f,
  -8.23011920e-02f, -9.86228213e-02f, -1.56615332e-01f, -3.22655812e-02f, -6.39555883e-03f, -8.14578831e-02f, 2.18459982e-02f, 9.92783979e-02f, -1.54800460e-01f, 4.27020900e-02f,
  3.06385546e-03f, 5.21388873e-02f, 2.00186986e-02f, -1.14462622e-01f, -9.40936035e-04f, 2.12918278e-02f, 4.20493670e-02f, 1.49490476e-01f, 1.69469379e-02f, 7.45223602e-03f,
  6.67645454e-01f, -8.51370931e-01f, -6.09202161e-02f, 5.36817431e-01f, 4.54334080e-01f, 1.76886350e-01f, 2.19298139e-01f, -9.49101597e-02f, -5.23631647e-02f, -7.42175162e-01f,
  2.09053885e-02f, -4.18788373e-01f, -4.35782015e-01f, 7.11127520e-02f, 4.61802483e-01f, -3.63881081e-01f, 1.47082746e-01f, -3.79419373e-03f, 9.07448307e-02f, 2.06581298e-02f,
  3.30855429e-01f, 2.44267374e-01f, 6.08664788e-02f, -1.54775128e-01f, 1.15958951e-01f, -4.42493893e-03f, -4.15276736e-02f, -1.21349700e-01f, -4.52311300e-02f, 1.07687311e-02f,
  1.89264089e-01f, 2.50203460e-02f, 1.21590070e-01f, -7.62986690e-02f, -2.73201987e-02f, 2.61702538e-02f, 1.44827077e-02f, 4.93970234e-03f, 2.54563332e-01f, -2.13667750e-03f,
  -5.03536500e-02f, 4.68787588e-02f, 1.97372609e-03f, -9.94413346e-03f, 1.14199556e-01f, 5.62662855e-02f, 7.60731697e-02f, -6.69728965e-03f, -1.01215519e-01f, -5.89601509e-02f,
  -1.17441621e-02f, -8.19458216e-02f, 1.44824237e-01f, -6.04676865e-02f, -5.76010980e-02f, 1.64499506e-02f, -2.69956123e-02f, -1.62145719e-01f, -2.77698394e-02f, -8.94156098e-02f,
  -1.66473225e-01f, -2.75029056e-02f, -9.09763668e-03f, 8.43327492e-02f, 2.32442953e-02f, 6.24196790e-02f, 7.13481456e-02f, -1.14722084e-03f, -2.68100738e-03f, -3.32013853e-02f,
  5.83648197e-02f, 2.52233185e-02f, 3.46101485e-02f, 5.69712482e-02f, 5.01548871e-02f, 3.33968773e-02f, 6.77951276e-02f, -6.11710548e-02f, -5.08610066e-03f, 1.07340597e-01f,
  2.49757152e-02f, 1.44386915e-02f, -7.13470280e-02f, -3.76333706e-02f, 5.31753041e-02f, -1.05814256e-01f, -8.63715112e-02f, -7.39559084e-02f, -2.27566157e-03f, 3.56845669e-02f,
  -1.50861144e-01f, -6.87195480e-01f, -6.00705594e-02f, 5.93071245e-02f, -6.44308180e-02f, -9.69353095e-02f, -2.07500961e-02f, -5.05085588e-02f, -8.65765586e-02f, -2.81542111e-02f,
  -2.77793151e-04f, 7.01642707e-02f, -9.09676775e-02f, 7.01844990e-02f, 6.88721389e-02f, -9.40981731e-02f, -8.35253000e-02f, -6.03833012e-02f, -2.05437969e-02f, -8.86391997e-02f,
  -6.15058132e-02f, -1.66525785e-02f, 1.55812129e-02f, 6.78108037e-02f, -6.06869385e-02f, -1.02069631e-01f, -6.98473901e-02f, -5.20481355e-02f, -4.53357212e-02f, -2.92739701e-02f,
  3.83526742e-01f, -3.65730196e-01f, -5.96570373e-01f, -2.46966816e-03f, 2.73106426e-01f, 3.30932736e-01f, -1.19696900e-01f, 7.13959858e-02f, -3.28680664e-01f, -2.62765251e-02f,
  3.14597458e-01f, -2.58793472e-03f, -3.49927425e-01f, 5.68817556e-01f, 5.66517234e-01f, -2.20271736e-01f, 4.26048160e-01f, 2.73496002e-01f, -1.96464688e-01f, 1.85836598e-01f,
  2.34752297e-01f, 6.86715484e-01f, 8.65992829e-02f, 3.83071750e-01f, 4.11915064e-01f, -2.06950843e-01f, 1.19764589e-01f, -1.81052312e-01f, 4.06260967e-01f, 4.16262627e-01f,
  1.49764895e-01f, -2.94047967e-02f, -6.58849180e-02f, 1.84735004e-02f, -3.75500917e-02f, 7.78123364e-02f, -2.18319055e-02f, 7.00141713e-02f, -7.12266862e-02f, -1.17913105e-01f,
  -6.53288066e-02f, 7.83369318e-02f, 1.55526385e-01f, -1.49273034e-02f, 7.58624449e-02f, -2.19458737e-03f, -1.53544560e-01f, -1.52465805e-01f, -1.68156683e-01f, 6.87110499e-02f,
  -2.41629228e-01f, -5.36491051e-02f, 7.49111474e-02f, -4.66852151e-02f, -1.16959833e-01f, -5.47128469e-02f, -8.57140794e-02f, -1.29263729e-01f, -5.48893735e-02f, 1.16550643e-02f,
  1.31971031e-01f, -2.77342531e-03f, 3.33701409e-02f, 1.00680463e-01f, -3.59726287e-02f, 7.80612901e-02f, 4.03367728e-02f, -1.46901868e-02f, -8.39825943e-02f, 4.01692651e-02f,
  1.10959336e-02f, -1.40031893e-02f, 3.66128907e-02f, -2.89730914e-02f, 1.26847908e-01f, -3.39938626e-02f, -6.27051070e-02f, 1.00467719e-01f, -1.36442706e-01f, -3.92114297e-02f,
  3.82130928e-02f, -5.87296253e-03f, -4.03483510e-02f, -5.11694886e-02f, 1.10085547e-01f, -3.09441779e-02f, 1.42699629e-01f, 3.53677571e-03f, -1.35445613e-02f, 8.44163150e-02f,
  -4.62366119e-02f, -7.14803413e-02f, -1.60940662e-02f, 2.72463840e-02f, -7.51371980e-02f, 9.16761085e-02f, 4.98740841e-03f, 9.06541124e-02f, 4.87713702e-02f, -2.17532925e-03f,
  7.24323913e-02f, -1.05386540e-01f, 5.32207303e-02f, 1.10515542e-01f, 2.49044616e-02f, -1.42257353e-02f, -1.21538364e-03f, -6.39946982e-02f, 7.88081437e-02f, -5.80266491e-03f,
  -6.27603978e-02f, -1.62557587e-01f, 5.55044338e-02f, -1.05295174e-01f, 2.02806741e-02f, 2.95762103e-02f, 7.03657931e-03f, -4.81693260e-02f, 3.15851234e-02f, -1.07070900e-01f,
  -4.95670438e-01f, 4.93093520e-01f, 1.68399826e-01f, 7.86292732e-01f, -4.60907489e-01f, -1.61305428e-01f, 1.58360854e-01f, 3.60144787e-02f, 3.15657943e-01f, 2.93322861e-01f,
  1.60993293e-01f, -8.04031640e-02f, 2.04001829e-01f, 6.04799449e-01f, 3.06513578e-01f, 5.02700388e-01f, 6.69030428e-01f, 2.69754559e-01f, 1.43780679e-01f, 2.67975748e-01f,
  2.11929694e-01f, 2.89452195e-01f, 3.18638802e-01f, -5.69492653e-02f, -2.38987803e-01f, -8.13561399e-03f, 2.85016000e-01f, -1.77878290e-01f, 1.97794691e-01f, -1.60203248e-01f,
  -8.80243257e-03f, 5.66700846e-02f, 6.75445981e-03f, 1.87212173e-02f, 6.19296990e-02f, -1.67159632e-01f, -1.57715343e-02f, -1.08070716e-01f, -6.25769421e-02f, 5.99613301e-02f,
  -1.16720740e-02f, -1.46672679e-02f, 1.00272156e-01f, 2.86254361e-02f, -2.04327390e-01f, 5.00987768e-02f, -7.54256919e-02f, -1.23032019e-01f, -1.01840841e-02f, -1.96089536e-01f,
  2.82164421e-02f, 2.01650942e-03f, -7.13621825e-02f, 1.23525523e-01f, 3.08728646e-02f, 9.29606333e-03f, 7.54193217e-02f, -5.43973856e-02f, -4.92741503e-02f, 1.10566504e-02f,
  -7.84803554e-02f, 1.01853848e-01f, 3.73192504e-02f, -3.19990271e-04f, 7.63719305e-02f, 7.66782090e-02f, 8.01928192e-02f, -4.27139848e-02f, -1.33418711e-04f, 9.14140716e-02f,
  4.95522693e-02f, -4.55548689e-02f, 5.32448627e-02f, 2.29795687e-02f, 8.55856538e-02f, 7.07411254e-03f, -9.46671218e-02f, -8.62782355e-03f, 5.43296039e-02f, 1.92111395e-02f,
  6.83438927e-02f, 4.81666960e-02f, 5.17414324e-02f, -9.41869766e-02f, 6.86026439e-02f, -5.04008234e-02f, 6.00934885e-02f, -4.99367043e-02f, 1.60690062e-02f, -5.73304892e-02f,
  2.08594143e-01f, 4.64203298e-01f, 1.30844295e-01f, -6.24315552e-02f, 1.08438186e-01f, -5.38866483e-02f, 1.04870595e-01f, 4.30504158e-02f, 1.49342760e-01f, 7.39135444e-02f,
  -2.51851175e-02f, 3.33659835e-02f, -5.02897613e-02f, -6.30547032e-02f, 2.16947049e-02f, 1.34853005e-01f, 2.11877316e-01f, 1.33832946e-01f, 8.82370099e-02f, 1.05152793e-01f,
  1.39867328e-02f, -6.38265461e-02f, 2.48090178e-03f, -5.11545949e-02f, -3.54140881e-04f, -4.88449000e-02f, -4.30219844e-02f, -7.07454011e-02f, -7.31473640e-02f, 1.92501366e-01f,
  6.42954588e-01f, 2.44541064e-01f, -8.10799673e-02f, -4.40235697e-02f, -2.46746838e-01f, -6.87745333e-01f, -6.33209229e-01f, -1.08516775e-01f, -3.81947219e-01f, -2.04695553e-01f,
  -1.40271127e-01f, -1.71994358e-01f, 2.67521769e-01f, 6.92812428e-02f, 3.33437055e-01f, 3.72064084e-01f, -4.14763810e-03f, -2.26202220e-01f, 2.45561123e-01f, 3.11357707e-01f,
  2.60050565e-01f, 1.41419142e-01f, 4.93848711e-01f, 1.07213147e-01f, 1.95672348e-01f, 1.70485020e-01f, 3.71491700e-01f, 4.07479666e-02f, -2.12993413e-01f, -1.48210183e-01f,
  -1.66170165e-01f, 2.16161862e-01f, -1.02376334e-01f, -1.48541540e-01f, 5.72508983e-02f, -8.98329839e-02f, -1.26934141e-01f, 9.26910900e-03f, -1.40506178e-02f, -3.78165245e-02f,
  9.28809587e-03f, 1.31730447e-02f, -7.79137909e-02f, -5.79866357e-02f, -4.53192480e-02f, -9.71638933e-02f, 3.19789983e-02f, -1.03906155e-01f, -8.93332437e-03f, 1.86770111e-01f,
  3.90546583e-02f, 5.90279931e-03f, 5.02970815e-02f, 1.98582374e-02f, 7.12889284e-02f, -1.19865522e-01f, -3.78087386e-02f, -1.66232325e-02f, -3.07329874e-02f, -5.07139340e-02f,
  1.88573495e-01f, -6.14282005e-02f, 1.26303986e-01f, -9.08465907e-02f, 2.84187850e-02f, -1.25367483e-02f, 2.57135406e-02f, -5.18219322e-02f, 1.09143415e-02f, 1.36731137e-02f,
  -1.01707533e-01f, 9.44389775e-02f, 3.32678035e-02f, -8.45357850e-02f, 1.09045364e-01f, 1.06619626e-01f, -1.66507496e-03f, -4.90398370e-02f, -9.47615951e-02f, -8.22766870e-02f,
  -6.84726462e-02f, 4.93544266e-02f, -7.05964640e-02f, -1.39596919e-02f, -1.40117735e-01f, 5.57130377e-04f, -1.64689589e-02f, 8.37770775e-02f, -1.04543171e-03f, 7.74668232e-02f,
  1.09130234e-01f, 4.03652847e-01f, -6.46735057e-02f, -2.28888899e-01f, 2.66591646e-02f, -5.91240916e-03f, 2.31260564e-02f, -9.77070257e-02f, 5.50743155e-02f, 6.48365170e-02f,
  -7.84142688e-02f, -1.50800645e-01f, -1.06098905e-01f, -5.99223077e-02f, -9.55277979e-02f, -6.06715158e-02f, 3.36946175e-02f, -1.49009064e-01f, -1.20140268e-02f, 1.01704970e-01f,
  8.79390631e-03f, 7.00820014e-02f, 4.28774394e-02f, -1.38401568e-01f, -1.22638501e-01f, -3.03002819e-02f, -2.85673775e-02f, -1.10750273e-01f, 1.84278309e-01f, -4.18931320e-02f,
  -5.15479207e-01f, 7.32542500e-02f, -2.99985528e-01f, 1.26022488e-01f, -8.88349712e-02f, -1.05264634e-01f, 3.67390931e-01f, 9.87851098e-02f, 4.12424117e-01f, 3.48202229e-01f,
  -2.80441605e-02f, -2.57099628e-01f, 1.58671498e-01f, -1.58332407e-01f, -5.48934579e-01f, 2.45044436e-02f, -1.13295548e-01f, 2.83373222e-02f, 8.73144865e-02f, 1.17360577e-01f,
  -1.80708561e-02f, 3.72686833e-02f, -3.20445865e-01f, 1.95501238e-01f, -3.74493390e-01f, 1.01294339e-01f, -1.08837023e-01f, 1.29429892e-01f, -3.25280786e-01f, -1.52416646e-01f,
  -5.57166263e-02f, 2.16890842e-01f, -1.94886580e-01f, -5.28089702e-03f, 3.56783130e-04f, -4.76675574e-03f, -2.46530231e-02f, -3.79267149e-02f, 1.46212559e-02f, -1.22344522e-02f,
  2.98745204e-02f, -9.40531790e-02f, 9.70035195e-02f, -5.91743411e-03f, 2.95224227e-02f, -1.93532810e-01f, -1.41037121e-01f, -1.64914951e-01f, -1.30707156e-02f, -2.06021547e-01f,
  -2.18089983e-01f, -1.07295699e-01f, 8.24025199e-02f, 1.19749397e-01f, -7.81508759e-02f, 2.45868191e-02f, 1.27859395e-02f, -1.36090949e-01f, -9.73758399e-02f, -1.72504276e-01f,
  -6.97588315e-03f, 8.89858454e-02f, -1.11893713e-02f, 7.56950006e-02f, -5.61451241e-02f, -2.56895274e-02f, 1.42806275e-02f, 3.01507395e-02f, 1.44549876e-01f, -8.87862518e-02f,
  1.13350853e-01f, -7.37139136e-02f, 8.91059786e-02f, -1.78037152e-01f, 6.90862089e-02f, 8.52068067e-02f, 2.29387954e-02f, 3.48906405e-02f, 9.65464935e-02f, -1.73179820e-01f,
  9.23376530e-02f, -2.21757665e-02f, -8.39615688e-02f, 8.49101227e-03f, -8.25152323e-02f, -5.82363419e-02f, -7.12766824e-03f, -4.61669751e-02f, -3.68938148e-02f, 9.59288478e-02f,
  1.46321669e-01f, 4.47070360e-01f, 7.37209916e-02f, 2.25878693e-02f, 8.29959884e-02f, -2.94041503e-02f, -4.85965982e-02f, -1.13740869e-01f, 1.03674054e-01f, 8.86093304e-02f,
  1.41146392e-01f, 7.71023631e-02f, -4.03870940e-02f, -5.63052818e-02f, 1.04619347e-01f, -1.18700862e-01f, 1.61650598e-01f, 6.91651627e-02f, 2.13015810e-01f, -1.24289691e-01f,
  -1.62616104e-01f, 1.67977035e-01f, 1.84788406e-01f, 1.11938640e-01f, 1.46882221e-01f, 8.32859650e-02f, -1.06513284e-01f, -2.20553260e-02f, -7.03673959e-02f, 3.78722511e-02f,
  -9.17117655e-01f, 4.64042127e-01f, -2.07056731e-01f, -5.78665495e-01f, 2.85347134e-01f, -8.31587985e-02f, -3.14134181e-01f, 2.27042973e-01f, -2.47696295e-01f, 7.56150410e-02f,
  -1.42414412e-02f, -4.63595659e-01f, 2.79934824e-01f, -3.95488501e-01f, -4.56006467e-01f, -2.38675997e-02f, -4.23586786e-01f, -4.98641312e-01f, 4.30126339e-02f, -2.42044374e-01f,
  -1.12384409e-01f, -4.77849469e-02f, -1.88774988e-01f, 5.50133467e-01f, -1.62753567e-01f, 1.74939521e-02f, -8.88148993e-02f, 4.80495423e-01f, -1.48373634e-01f, 2.05064371e-01f,
  -2.43648276e-01f, -1.29870474e-01f, -1.84783444e-01f, -3.23945992e-02f, -1.51515722e-01f, -7.84188285e-02f, -1.19887531e-01f, 6.43400773e-02f, -4.42198999e-02f, 3.03994492e-02f,
  -1.47063881e-01f, 5.80759905e-02f, -2.11593192e-02f, 1.45122170e-01f, -2.35739648e-02f, 9.20700803e-02f, -2.26277262e-02f, -5.47611490e-02f, 3.91277224e-02f, 9.13098082e-03f,
  3.70282233e-02f, -1.00589055e-03f, -1.32626891e-01f, -6.29882142e-02f, -3.01942732e-02f, 3.33270803e-02f, -9.94187221e-02f, -5.75218722e-02f, -1.26280412e-02f, 2.57815380e-04f,
  -1.97842554e-03f, -8.41581896e-02f, -4.87014800e-02f, 3.35767977e-02f, -3.61645594e-02f, 4.22598124e-02f, 2.20788158e-02f, 4.27397387e-03f, 3.43381204e-02f, -5.76952547e-02f,
  -6.58683255e-02f, 5.04846498e-02f, 5.87659664e-02f, -5.64389303e-02f, -9.20364261e-02f, -1.05774388e-01f, -3.96519415e-02f, 3.34435478e-02f, -4.39454168e-02f, -1.05992164e-02f,
  -3.64366919e-02f, -2.29554600e-03f, 8.63830596e-02f, 8.77839625e-02f, 1.91801582e-02f, 2.82837600e-02f, 5.81936762e-02f, -3.96653712e-02f, -4.69149500e-02f, -3.56222391e-02f,
  -3.64545077e-01f, -1.68544441e-01f, -7.90994838e-02f, 7.25059137e-02f, -2.23819036e-02f, -1.11883506e-02f, 5.34806214e-03f, -1.62912421e-02f, -5.71551546e-02f, 4.72669443e-03f,
  -6.93136901e-02f, -1.96322948e-02f, -2.76984926e-02f, -3.54121625e-02f, -2.31447406e-02f, 1.30246961e-02f, -1.84437588e-01f, -4.60800342e-02f, -9.03678089e-02f, 1.48720061e-02f,
  -2.98383515e-02f, -1.69313618e-03f, -4.90651168e-02f, 5.55443801e-02f, -7.64711797e-02f, -6.09895773e-02f, -7.17255026e-02f, 4.59747426e-02f, 5.33250645e-02f, -1.47664053e-02f,
  2.89607704e-01f, -5.15328765e-01f, 6.42841458e-01f, -5.09059466e-02f, 4.47506577e-01f, 6.03817999e-01f, 4.57798779e-01f, 2.39611059e-01f, 4.80425745e-01f, -4.57566023e-01f,
  -1.81911394e-01f, -4.05862480e-01f, 2.85215765e-01f, -3.53588432e-01f, 5.81374288e-01f, 3.46697956e-01f, -8.93622451e-03f, -1.43955827e-01f, 1.18159197e-01f, -2.24969819e-01f,
  5.71810044e-02f, -4.46994156e-01f, 8.23888332e-02f, -5.02247453e-01f, -1.73932076e-01f, -1.83994025e-01f, -5.06518722e-01f, 6.47966936e-02f, -4.57413673e-01f, -9.58102103e-03f,
  -1.87685624e-01f, -1.22297406e-01f, -1.71980426e-01f, -7.52286538e-02f, 4.82901298e-02f, -9.95113142e-03f, 5.16546071e-02f, 2.37573273e-02f, 4.43048924e-02f, 3.16504538e-02f,
  -7.98463896e-02f, 6.06170110e-02f, -1.09283634e-01f, -1.25345707e-01f, 5.92721887e-02f, -9.77915060e-03f, 8.53467360e-02f, 9.85373184e-02f, 1.73394419e-02f, 2.77556807e-01f,
  1.65321156e-01f, 1.02211274e-01f, 8.27694312e-02f, -3.30095664e-02f, 9.59418267e-02f, -4.14235331e-02f, 6.65991977e-02f, 1.05049849e-01f, -5.69707267e-02f, -2.55180076e-02f,
  3.41950431e-02f, 2.52587032e-02f, 7.10564293e-03f, 1.66790339e-03f, -4.76003066e-02f, 2.14937441e-02f, -5.83339818e-02f, -5.86677752e-02f, 2.77472679e-02f, 3.24066952e-02f,
  7.20817149e-02f, -1.08997211e-01f, 6.04306683e-02f, 5.60707413e-02f, -7.96430781e-02f, 3.38884001e-03f, -7.95070007e-02f, 1.64010413e-02f, 3.50212492e-02f, 2.56042033e-02f,
  1.57591450e-04f, 2.08154204e-03f, -1.40295802e-02f, 5.60752265e-02f, 1.56782698e-02f, 9.70238671e-02f, -9.64444131e-02f, 1.69061199e-01f, 4.85048145e-02f, -6.09095506e-02f,
  -3.37360710e-01f, -4.99622732e-01f, -1.85385644e-01f, -1.66869268e-01f, -1.54546931e-01f, -1.52792573e-01f, -3.44940089e-02f, 2.54991651e-02f, -3.20308656e-02f, 9.11335871e-02f,
  -6.93959072e-02f, -9.44541022e-02f, -6.25621080e-02f, 2.27347557e-02f, -1.25322416e-01f, 7.97103792e-02f, -1.14966027e-01f, -1.62838161e-01f, -1.59931839e-01f, -1.79548383e-01f,
  -6.40187562e-02f, -1.64858717e-03f, -1.00174583e-02f, -8.80916119e-02f, -1.52063996e-01f, 9.23714787e-03f, -1.37773246e-01f, -3.57706212e-02f, 4.79848050e-02f, -1.91375602e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.78270340e-01f, 5.11398494e-01f, 4.50265646e-01f, 5.53306401e-01f, 2.00192064e-01f, 5.51942348e-01f, 5.81806242e-01f, 4.09005076e-01f, 1.86759368e-01f, 5.95033407e-01f,
  1.96411178e-01f, 5.45807242e-01f, 5.55798769e-01f, 6.52866781e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -1.01917475e-01f, -4.61037755e-01f, -1.36963325e-02f, -4.94314760e-01f, -5.05713880e-01f, -2.83072531e-01f, -3.92634302e-01f, -2.92441994e-01f, -5.50642386e-02f, -1.98364601e-01f,
  1.12413742e-01f, -5.95710456e-01f, 4.79510464e-02f, -1.50706857e-01f, 2.55187094e-01f, -1.77607104e-01f, -4.31103170e-01f, -3.96235138e-01f, -2.55641758e-01f, -1.12176806e-01f,
  2.03800872e-02f, 3.38306911e-02f, 1.18805245e-01f, -1.22807913e-01f, 2.72090435e-01f, -5.40572524e-01f, 2.16705993e-01f, -4.70724732e-01f, -2.53244579e-01f, 5.09371221e-01f,
  -1.99309498e-01f, 3.78882587e-01f, -5.04777431e-01f, 1.80779651e-01f, 3.57990056e-01f, 1.35510489e-01f, 1.72707587e-01f, 3.15773457e-01f, 2.33812451e-01f, -1.75633520e-01f,
  2.06729352e-01f, 4.99396890e-01f, 4.33014393e-01f, 3.75402421e-01f, 2.11318418e-01f, 2.43135840e-01f, 1.18405707e-01f, -4.15561534e-02f, 1.83107629e-01f, -2.28621840e-01f,
  3.06794435e-01f, -5.84246695e-01f, 6.35496318e-01f, 6.38165355e-01f, -2.47498587e-01f, 8.48715380e-02f, -3.98697138e-01f, -2.47962788e-01f, -3.13835472e-01f, 6.24148011e-01f,
  -3.56372505e-01f, 1.76789716e-01f, -2.74974525e-01f, -4.81228441e-01f, 6.70671985e-02f, 3.01527604e-02f, -1.55787066e-01f, -9.03135538e-02f, -1.84939370e-01f, 2.42209658e-01f,
  3.78009826e-01f, 1.00893443e-02f, -3.00702870e-01f, 3.89579415e-01f, -1.87320426e-01f, -5.80984950e-01f, -3.31184804e-01f, 2.58305848e-01f, 1.62233040e-02f, 2.66121507e-01f,
  9.32991654e-02f, -6.90537989e-02f, 1.29752830e-01f, 4.73966338e-02f, -5.64900815e-01f, 1.94574997e-01f, -3.15327287e-01f, 2.88051158e-01f, -3.23088259e-01f, 6.65877223e-01f,
  1.77536905e-01f, 4.31048155e-01f, -4.08667922e-01f, 5.93336403e-01f, -4.03916627e-01f, -1.24409862e-01f, 5.39882243e-01f, 2.38527656e-01f, 2.01075837e-01f, -4.79100585e-01f,
  4.92692560e-01f, -4.30045038e-01f, 5.70997059e-01f, -5.25364995e-01f, -5.68842888e-01f, 2.26894855e-01f, 4.81848687e-01f, 8.80318359e-02f, 4.02839363e-01f, 4.04086590e-01f,
  6.63586378e-01f, 5.86630225e-01f, -3.58154178e-01f, 4.22698945e-01f, 3.81869972e-01f, 5.00240445e-01f, 2.78144747e-01f, -5.93075335e-01f, -1.71118245e-01f, -1.64727747e-01f,
  -3.73917460e-01f, -2.26177081e-01f, 6.96978271e-01f, -1.73629373e-01f, 3.50644976e-01f, -5.00793338e-01f, -5.27983248e-01f, -6.06023669e-01f, 6.00538328e-02f, 1.20209157e-01f,
  -4.42728311e-01f, 5.67885339e-02f, 1.34751141e-01f, -6.98893098e-03f, 8.73922408e-02f, -6.09440841e-02f, 6.00112267e-02f, -3.70977014e-01f, 2.81566024e-01f, 8.06308314e-02f,
  -2.21151903e-01f, -2.86836624e-01f, -2.32952222e-01f, -7.05560148e-02f, 1.20963134e-01f, 1.56013146e-01f, 1.18349567e-01f, -7.06098899e-02f, 1.95086867e-01f, -4.01886940e-01f,
  -5.14446616e-01f, -4.01103973e-01f, -1.70265771e-02f, -5.41306436e-01f, 5.14967889e-02f, 2.68593103e-01f, 2.10322574e-01f, -4.07030135e-02f, 3.28309447e-01f, -1.42331004e-01f,
  -2.91495711e-01f, 2.39560232e-01f, -1.91284180e-01f, 2.08081588e-01f, -3.18566263e-01f, -2.74007559e-01f, -4.02642488e-01f, -3.56430173e-01f, 8.89747497e-03f, 2.12602958e-01f,
  2.65572071e-01f, 6.95324615e-02f, -2.64418740e-02f, -1.20368399e-01f, -4.20070022e-01f, 2.66255766e-01f, -1.98673010e-01f, 2.23694190e-01f, -7.13627160e-01f, -4.66985852e-01f,
  5.22879124e-01f, -3.54670167e-01f, -2.47777030e-01f, 1.65973559e-01f, -2.10324690e-01f, 7.98227787e-01f, 7.73080826e-01f, -2.18277514e-01f, -6.90853119e-01f, -3.04411471e-01f,
  -3.42936143e-02f, -9.12401497e-01f, -2.06361324e-01f, 1.95306584e-01f, 6.12470880e-02f, 2.54813105e-01f, -1.80339754e-01f, -1.44472837e-01f, 2.31442392e-01f, -3.25967014e-01f,
  -1.43539026e-01f, 4.22842130e-02f, 6.31283745e-02f, -1.61993101e-01f, -7.02190757e-01f, -2.36758843e-01f, 1.69769213e-01f, -1.43457830e-01f, -5.39944321e-02f, 2.61550486e-01f,
  -6.17023706e-01f, -2.56469939e-02f, -1.19470224e-01f, -4.75240648e-01f, -1.31875649e-01f, -5.18541694e-01f, -7.71513805e-02f, -5.23657262e-01f, -2.10970566e-01f, -5.81300855e-01f,
  4.86229479e-01f, 2.71355569e-01f, -1.23850279e-01f, 5.79403192e-02f, 2.96316803e-01f, 1.19769916e-01f, 2.90744811e-01f, 2.74042606e-01f, -1.49161831e-01f, 2.25266889e-01f,
  6.24063194e-01f, 2.29675844e-01f, -7.27905095e-01f, 2.08006382e-01f, -2.44019791e-01f, 4.79412526e-01f, 5.93637899e-02f, 6.56406805e-02f, 3.31831098e-01f, -5.74547112e-01f,
  2.26710632e-01f, -3.38608213e-02f, -3.04789841e-02f, -5.01052499e-01f, -3.69934440e-01f, 2.01758042e-01f, -2.45557457e-01f, -3.62648100e-01f, 5.98423600e-01f, -2.59892672e-01f,
  -2.86278516e-01f, -3.72957528e-01f, -1.34800419e-01f, 5.14846504e-01f, 7.40107119e-01f, -8.80156398e-01f, 5.40282112e-03f, -1.51174724e-01f, -6.41705990e-01f, 7.41551399e-01f,
  2.67072972e-02f, 6.18948638e-02f, 2.71671385e-01f, 4.06267345e-01f, -2.07444206e-01f, -2.22960070e-01f, 3.04863244e-01f, 3.33412409e-01f, 1.36402309e-01f, 3.28143507e-01f,
  -6.02151342e-02f, 2.00514063e-01f, 2.11373925e-01f, 1.97255258e-02f, 1.88269168e-01f, 2.13001192e-01f, 6.86985999e-02f, -1.79329976e-01f, 7.94163123e-02f, -3.67114623e-03f,
  -4.26728308e-01f, 8.27502534e-02f, 8.30415547e-01f, 3.08313936e-01f, -3.66469979e-01f, -5.41446567e-01f, -2.08674327e-01f, 1.53600618e-01f, 1.65245220e-01f, -1.85627282e-01f,
  -1.08929314e-01f, -8.38601030e-03f, -7.42513239e-02f, 6.52379811e-01f, -2.02619776e-01f, 5.70483625e-01f, 4.44717139e-01f, -3.42382789e-01f, -2.21642449e-01f, 2.75660545e-01f,
  7.29005218e-01f, -5.13053179e-01f, 6.63025022e-01f, 2.45329201e-01f, 5.37527323e-01f, -6.65732145e-01f, 8.42214841e-03f, -4.10118878e-01f, 1.83568299e-01f, 3.39106858e-01f,
  5.31307645e-02f, 7.15823352e-01f, -2.16793820e-01f, -3.34775746e-01f, -2.41664305e-01f, -5.72584450e-01f, 8.24616775e-02f, -4.42201853e-01f, 3.24172646e-01f, 4.17411029e-01f,
  -2.92377323e-01f, 1.66627422e-01f, 2.72872210e-01f, 1.60679910e-02f, 1.82428211e-01f, 4.42823410e-01f, 1.27320275e-01f, -9.39408913e-02f, 1.30347058e-01f, 3.02432299e-01f,
  2.42103338e-01f, 1.04530044e-01f, 4.03111994e-01f, -2.22343709e-02f, 6.15805797e-02f, -2.53174931e-01f, 1.92644387e-01f, 5.06209612e-01f, 1.43858984e-01f, 2.99333155e-01f,
  -4.53448445e-02f, -2.37200081e-01f, 2.62510657e-01f, 3.99665445e-01f, 2.96694428e-01f, 3.37621242e-01f, 5.66222429e-01f, -4.61049043e-02f, -3.16485047e-01f, -5.82087159e-01f,
  -2.05508992e-01f, 3.54998648e-01f, -5.93621194e-01f, 3.38553786e-01f, 1.97867200e-01f, -3.90843660e-01f, 5.64052165e-01f, -4.95571256e-01f, -7.39283785e-02f, 1.23382278e-01f,
  6.04298651e-01f, -6.00821793e-01f, 1.62597328e-01f, -3.90833467e-01f, -7.84850359e-01f, 3.46441418e-01f, 1.21548951e-01f, -8.74883533e-02f, 4.01984185e-01f, -1.00037623e-02f,
  -3.11841518e-01f, 6.37545288e-01f, -9.37714159e-01f, -3.24538946e-02f, 3.65045637e-01f, -7.09433034e-02f, -7.69873619e-01f, -7.55787730e-01f, -6.41139925e-01f, 4.93870914e-01f,
  -3.86807263e-01f, 6.46435618e-01f, -6.40943766e-01f, 3.53895761e-02f, 1.51300520e-01f, 7.95857906e-02f, 2.41729334e-01f, -2.46633533e-02f, -1.51335865e-01f, -5.94725847e-01f,
  4.13819879e-01f, -1.38493888e-02f, 1.95449993e-01f, 2.11279094e-02f, 2.90481806e-01f, 1.90546475e-02f, -3.41972746e-02f, 9.05536488e-02f, -1.87900111e-01f, 1.62235424e-02f,
  -2.12424532e-01f, -1.25953361e-01f, -7.01747835e-02f, 7.25240260e-02f, 6.74925968e-02f, 1.02601461e-01f, 1.77233517e-01f, -3.87826353e-01f, -2.05685887e-02f, 4.57719594e-01f,
  -4.38034624e-01f, -5.04860170e-02f, -5.95200360e-02f, -2.35917211e-01f, 5.16767144e-01f, 2.02219039e-01f, 2.41086468e-01f, 4.18079138e-01f, -4.65364754e-01f, 1.99217871e-01f,
  -3.03610831e-01f, -1.85501143e-01f, 5.88102639e-01f, 6.83617055e-01f, -4.15006697e-01f, -3.78431767e-01f, -5.66741288e-01f, -6.05437517e-01f, -2.39668220e-01f, 6.18706048e-01f,
  -3.45355719e-01f, -9.17875022e-02f, -4.63637143e-01f, 6.06110692e-01f, -1.89210363e-02f, 2.38112789e-02f, -1.50840804e-01f, -5.38632691e-01f, -4.23637182e-01f, -1.18482244e+00f,
  -6.29764438e-01f, 8.09223711e-01f, -3.37953687e-01f, -2.68127143e-01f, -2.55331248e-01f, 8.18404034e-02f, -1.49986953e-01f, 6.82707071e-01f, -1.84318990e-01f, -7.39694908e-02f,
  -1.31740689e-01f, 4.34061140e-02f, -1.82284135e-02f, -1.01144195e-01f, -7.71319270e-02f, 2.78231297e-02f, -7.59520382e-02f, -2.71933973e-01f, 1.45125045e-02f, -1.86381899e-02f,
  2.67240375e-01f, -2.01982006e-01f, -7.21819848e-02f, -4.21659797e-02f, 2.69797910e-03f, -1.00099437e-01f, -1.03860550e-01f, -4.80876833e-01f, -2.88232148e-01f, -4.05541854e-03f,
  -2.63070256e-01f, -2.93525994e-01f, 7.24321902e-02f, -1.17850028e-01f, -4.27580655e-01f, 2.82415509e-01f, 2.35403836e-01f, -4.69971932e-02f, -3.01521242e-01f, 1.86485097e-01f,
  -1.72477275e-01f, 8.33890140e-02f, 6.57908395e-02f, -6.52044490e-02f, -1.69838116e-01f, -8.81874487e-02f, 1.98987305e-01f, -1.85535327e-01f, 2.29257405e-01f, 3.24536532e-01f,
  -2.10132346e-01f, -4.17608023e-01f, -3.56318980e-01f, -2.71176100e-01f, -1.41041905e-01f, -2.31890067e-01f, 2.69088715e-01f, 3.07657659e-01f, -3.00145060e-01f, -2.86173522e-01f,
  -3.32069069e-01f, -5.68962336e-01f, 8.30478787e-01f, -3.36235315e-01f, 4.74845946e-01f, -4.33927417e-01f, -2.89178044e-01f, -3.60628247e-01f, 3.52437019e-01f, -1.63019344e-01f,
  1.80040464e-01f, 3.02538037e-01f, -1.29756592e-02f, -9.87489969e-02f, -1.95156515e-01f, 6.33558854e-02f, 1.09247230e-01f, 6.20932728e-02f, -5.18353760e-01f, 1.49538025e-01f,
  1.87465996e-01f, -2.82939017e-01f, -4.30516839e-01f, 1.17214464e-01f, 1.87429249e-01f, -2.26084739e-01f, -3.21693420e-01f, -4.58554253e-02f, 8.45744610e-02f, -1.91122934e-01f,
  -7.89191946e-03f, -6.30545393e-02f, 9.82071310e-02f, -1.06239118e-01f, 1.98794633e-01f, -1.73776627e-01f, 1.59772754e-01f, 2.42834419e-01f, 3.12354475e-01f, 1.74677193e-01f,
  2.83609539e-01f, 3.22245121e-01f, 2.65934289e-01f, -3.01423192e-01f, 3.15114200e-01f, -2.25125805e-01f, -2.06786945e-01f, 3.63490462e-01f, -3.48795503e-01f, 2.74017572e-01f,
  -3.58537555e-01f, -1.28804028e-01f, -5.44668473e-02f, 3.74607407e-02f, -4.88310158e-01f, 3.19584250e-01f, 1.11255445e-01f, -3.59666705e-01f, -3.94709587e-01f, 2.90623065e-02f,
  -3.57041657e-01f, 3.21396053e-01f, -4.30375278e-01f, -2.35331833e-01f, -4.30367798e-01f, -4.03324783e-01f, -3.66172373e-01f, 6.88823313e-02f, -3.13904703e-01f, -4.55036908e-01f,
  1.72096357e-01f, 8.36140931e-01f, 7.19828725e-01f, -1.11416414e-01f, -3.07448030e-01f, -2.33389348e-01f, -1.40683979e-01f, 8.62507597e-02f, 3.16627204e-01f, 1.56597361e-01f,
  -2.74383482e-02f, 3.30384195e-01f, -2.86229879e-01f, -1.89663708e-01f, -1.15749806e-01f, 2.69250244e-01f, -5.62208712e-01f, 1.42891884e-01f, 7.75428116e-02f, 1.86430067e-01f,
  2.42519513e-01f, -1.22808956e-01f, -1.02308117e-01f, 1.44389868e-01f, -8.86046290e-02f, -5.19573271e-01f, 2.32874304e-01f, 1.39666587e-01f, 1.56694487e-01f, 1.00980341e-01f,
  3.24297845e-02f, -6.09470308e-01f, -7.06077218e-01f, -3.18903595e-01f, -2.32145980e-01f, -9.94136781e-02f, -1.16878919e-01f, 3.65719289e-01f, -3.76874954e-01f, -8.11778903e-01f,
  3.25073004e-01f, -6.19984746e-01f, 6.02214575e-01f, -3.53834331e-01f, -8.77390206e-02f, -1.03946701e-02f, 3.58030319e-01f, -2.47845367e-01f, -2.48939872e-01f, 5.37790209e-02f,
  -5.76702714e-01f, -3.83961707e-01f, -4.74360377e-01f, -4.17340636e-01f, -2.59019613e-01f, -3.02626163e-01f, -4.96727437e-01f, -6.61122203e-01f, 2.94794858e-01f, -4.52241242e-01f,
  -1.50712818e-01f, 8.76682460e-01f, 1.03234500e-01f, 2.72446424e-01f, -1.62998423e-01f, -6.33437693e-01f, -1.97314750e-02f, -4.76578832e-01f, -7.99797177e-01f, 4.56667006e-01f,
  1.62998646e-01f, 4.71085943e-02f, 3.13209444e-01f, -5.26215613e-01f, 3.46269995e-01f, 3.59032482e-01f, 1.08260058e-01f, -1.53737098e-01f, 1.33135855e-01f, 2.25021183e-01f,
  -1.67321153e-02f, 2.65128076e-01f, 5.05001366e-01f, 2.50308096e-01f, 1.24650687e-01f, -5.28071582e-01f, -1.33122712e-01f, -3.82597923e-01f, 4.05841470e-01f, 1.41922161e-01f,
  3.62381160e-01f, 4.01090741e-01f, 2.80301750e-01f, 3.24594796e-01f, 5.99356554e-02f, 3.20905805e-01f, -4.52216864e-01f, 4.96610969e-01f, 2.60402739e-01f, -5.59763536e-02f,
  -1.55657426e-01f, -3.57662767e-01f, 4.85332310e-01f, -5.73981464e-01f, -1.63925774e-02f, -2.44113669e-01f, -3.92392516e-01f, 3.18420678e-02f, -3.75423521e-01f, -4.44828719e-01f,
  -1.07383505e-01f, 5.57928264e-01f, 5.72513223e-01f, 2.18798563e-01f, 2.22678870e-01f, -1.58127964e-01f, 6.72635734e-02f, 6.26366615e-01f, -9.98007432e-02f, -3.03719223e-01f,
  9.30379987e-01f, -4.80785966e-01f, -4.53426391e-01f, -8.77834618e-01f, -4.76025134e-01f, -3.04503381e-01f, -1.09674096e-01f, -3.54781121e-01f, -3.44142646e-01f, -4.57930684e-01f,
  -5.62016249e-01f, 3.11721116e-01f, 2.57621616e-01f, -4.20623064e-01f, 2.04878703e-01f, -2.05427576e-02f, 2.34279975e-01f, -5.92516847e-02f, 2.74615616e-01f, -1.05599523e-01f,
  -1.89741001e-01f, 2.46448517e-01f, 1.08315028e-01f, 9.08776596e-02f, -2.76680201e-01f, -1.61103718e-02f, -5.02508553e-03f, -3.75184715e-02f, 2.11300313e-01f, 1.89122707e-01f,
  -1.11311972e-01f, 1.68326929e-01f, -4.14540656e-02f, 5.57869896e-02f, 2.10172281e-01f, 2.32025549e-01f, -3.08124512e-01f, 1.51672065e-01f, 9.69174802e-02f, 1.99166805e-01f,
  -5.08404911e-01f, -3.88792217e-01f, 5.48317134e-01f, 2.57985234e-01f, 5.77420712e-01f, -5.46113253e-01f, -2.90767610e-01f, 1.87693655e-01f, -4.99863058e-01f, 4.31606114e-01f,
  -4.39579517e-01f, 3.55232894e-01f, -5.30662835e-01f, -3.14044565e-01f, 3.43895495e-01f, -4.69310731e-01f, -1.60575241e-01f, -4.61420029e-01f, 4.28922534e-01f, 1.42066836e-01f,
  -4.38491762e-01f, -4.47018147e-01f, 2.47485220e-01f, -3.46226305e-01f, -3.74288350e-01f, 5.71882248e-01f, -4.02129501e-01f, 8.17822993e-01f, -3.12963367e-01f, -4.04053688e-01f,
  4.33609366e-01f, -3.24540228e-01f, -2.60188222e-01f, -4.38200951e-01f, -3.44962984e-01f, -3.16048414e-01f, -5.89254498e-01f, -4.50655252e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.10235226e-02f, -1.55250892e-01f, -7.42971376e-02f, -2.15998981e-02f, 2.69828178e-02f, 1.29279550e-02f, -8.20311438e-03f, 2.34898925e-02f, 9.75436121e-02f, -5.32463603e-02f,
  1.41113281e-01f, 1.85512319e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    