/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.85380948e-01f, -3.02327991e-01f, -1.94659173e-01f, -3.53951037e-01f, 5.82561158e-02f, -1.97023049e-01f, -2.82944232e-01f, -1.46753579e-01f, -1.64876208e-01f, -4.71826307e-02f,
  3.31603736e-02f, -1.70051202e-01f, 1.31319568e-01f, -2.19692409e-01f, 1.37584791e-01f, 1.56325966e-01f, -2.71197945e-01f, -1.55335069e-01f, 9.19295009e-03f, -1.98136702e-01f,
  -4.33270223e-02f, -1.57284573e-01f, -2.11596359e-02f, 3.52378301e-02f, -1.73220307e-01f, -1.08355433e-01f, 9.06259045e-02f, -7.64821307e-04f, -1.82182975e-02f, 1.76366884e-02f,
  4.23019305e-02f, 2.78356043e-03f, -4.31209914e-02f, 1.61039326e-02f, -3.52884121e-02f, 6.73113391e-03f, -3.87637988e-02f, 5.78377359e-02f, 4.39768322e-02f, 4.19591507e-03f,
  -3.70028652e-02f, 6.08933568e-02f, -4.44880761e-02f, 1.47956638e-02f, -5.69886677e-02f, -1.46689164e-02f, 5.80604486e-02f, 2.32336055e-02f, -1.81771256e-02f, 1.70362759e-02f,
  -7.07510859e-02f, 1.27696740e-02f, -8.13080147e-02f, -2.64744274e-03f, 4.18637507e-02f, -1.24523183e-02f, 2.76498441e-02f, 4.08648103e-02f, -1.70910209e-02f, 2.64012404e-02f,
  -2.18055937e-02f, -4.58548181e-02f, -8.70481879e-03f, 1.31968157e-02f, -5.27945273e-02f, 1.83175728e-02f, -3.25735137e-02f, 9.71945841e-03f, -1.21644577e-02f, 4.06343164e-03f,
  3.12333554e-02f, 1.76538737e-03f, -3.16217430e-02f, 1.44037427e-02f, -7.61809722e-02f, 1.08698094e-02f, 1.20861176e-02f, 3.93211655e-03f, -4.70605381e-02f, -3.54385525e-02f,
  4.64956053e-02f, -3.62404026e-02f, 2.53082737e-02f, -1.74455661e-02f, 2.38531809e-02f, -7.60754338e-03f, -3.29987332e-02f, 1.31422495e-02f, 3.35185020e-03f, -4.84438166e-02f,
  -2.28617787e-02f, -1.53327748e-01f, 6.12073112e-03f, 3.52911986e-02f, 4.42426326e-03f, -3.09589668e-03f, -2.52526999e-02f, -3.05940602e-02f, -7.68162683e-02f, 1.75953731e-02f,
  -7.60169774e-02f, -2.74145845e-02f, 1.44593343e-02f, -2.78183296e-02f, 1.43672423e-02f, -1.96870137e-03f, -6.93569928e-02f, -5.74601814e-03f, -3.64748687e-02f, 3.60611640e-02f,
  6.01311736e-02f, -2.69113239e-02f, 4.56401445e-02f, 2.38013249e-02f, 2.21449789e-02f, -8.14987998e-03f, -7.14152306e-02f, 2.33624969e-03f, 5.43914586e-02f, 1.59177966e-02f,
  5.07066905e-01f, -1.55252874e-01f, 5.23595288e-02f, 2.33361036e-01f, 9.82504711e-02f, -2.23846197e-01f, -1.98289335e-01f, -2.58624218e-02f, 7.72930831e-02f, -1.76212430e-01f,
  -1.44335106e-02f, 3.65264006e-02f, -2.18566552e-01f, 1.33864745e-01f, -2.14978248e-01f, -1.73631683e-01f, 5.56148440e-02f, 3.24603263e-03f, -8.28725472e-03f, 5.39745465e-02f,
  1.09660707e-01f, -5.42318933e-02f, 3.90697010e-02f, -1.53021375e-02f, 1.38793722e-01f, 1.41475052e-01f, -5.40140234e-02f, -7.51621649e-02f, 9.98265743e-02f, -2.66583380e-03f,
  -2.21826956e-02f, 1.22256186e-02f, 5.40941693e-02f, -1.63327530e-02f, -4.16696183e-02f, 4.39736173e-02f, 4.90290113e-02f, -8.69966298e-02f, 4.78082299e-02f, -3.17567773e-02f,
  -2.27433350e-02f, 4.34635067e-03f, -2.74376459e-02f, -8.29942466e-04f, 4.65788841e-02f, 5.16964383e-02f, 1.01674926e-02f, 2.63444260e-02f, 3.33625339e-02f, 3.42068635e-02f,
  5.90815879e-02f, 3.00012119e-02f, 4.13233414e-02f, 2.42109690e-03f, 4.02158089e-02f, 3.01752090e-02f, -1.09292092e-02f, -1.07550491e-02f, 1.71674844e-02f, 2.84550879e-02f,
  -1.36084352e-02f, 1.88735481e-02f, -1.80577161e-03f, 4.05069217e-02f, -2.19297856e-02f, 2.25620475e-02f, -7.23372260e-03f, -3.43178697e-02f, 3.13432477e-02f, -2.33434569e-02f,
  1.81312382e-03f, 4.07584384e-02f, 3.69865000e-02f, 4.06941958e-02f, 1.54521167e-02f, 3.31275724e-02f, 2.95796636e-02f, 4.38588439e-03f, 5.64165041e-02f, -8.29005148e-03f,
  -6.24988340e-02f, 4.19602469e-02f, -5.89727722e-02f, -1.53300650e-02f, -3.97956297e-02f, -3.38347778e-02f, 4.20355164e-02f, 5.08649647e-02f, 2.71456446e-02f, -1.26043819e-02f,
  -9.06175226e-02f, -2.15372652e-01f, -6.51443824e-02f, 2.79524233e-02f, -4.13369760e-02f, 4.34089545e-03f, -2.93319952e-02f, 2.46992167e-02f, -6.90415800e-02f, -2.43740622e-02f,
  2.46835165e-02f, 2.71328148e-02f, 9.42919590e-03f, 1.64378267e-02f, -3.18441615e-02f, -4.23492081e-02f, -1.04612065e-02f, 4.57868353e-02f, -6.27751052e-02f, -1.58846248e-02f,
  3.89615842e-03f, -6.43696859e-02f, -4.94955443e-02f, 4.02520709e-02f, -1.43465148e-02f, 1.89358331e-02f, 3.20610106e-02f, 2.06951778e-02f, -6.25254819e-03f, -2.07653809e-02f,
  -3.73206288e-01f, 3.19151729e-01f, 2.72034556e-01f, 5.17604575e-02f, -2.28260249e-01f, -1.52559251e-01f, -1.66279376e-01f, 4.51180106e-03f, -1.40714958e-01f, 1.03675619e-01f,
  -9.17252153e-02f, 2.08468854e-01f, 1.36416912e-01f, 3.46873552e-02f, -1.78486601e-01f, 1.35685831e-01f, -1.13523103e-01f, 6.09955676e-02f, -2.38147303e-02f, -3.40028107e-02f,
  -1.56985354e-02f, -1.88379213e-01f, 1.18898358e-02f, -1.42334290e-02f, -7.93344527e-02f, 9.01937708e-02f, 5.32116834e-03f, 8.68723392e-02f, 6.35195896e-02f, 2.15349477e-02f,
  -8.74896049e-02f, 6.20471314e-03f, 3.35174687e-02f, 7.43289962e-02f, -4.48581167e-02f, -2.31305733e-02f, 3.54716741e-02f, -1.49040855e-02f, 2.05393862e-02f, -3.01095570e-04f,
  3.73714557e-03f, -2.05061361e-02f, 2.09480394e-02f, -3.39673311e-02f, 5.34213670e-02f, 1.19639486e-02f, -2.53401548e-02f, 2.67413707e-04f, 2.81673465e-02f, 3.44465151e-02f,
  1.47031117e-02f, 4.69359383e-02f, 2.85171736e-02f, 9.11423936e-03f, -2.07808129e-02f, 5.47430553e-02f, 1.94530003e-02f, 1.16358392e-01f, -2.74898633e-02f, 1.85956284e-02f,
  -2.80219093e-02f, 3.70897800e-02f, 1.82642732e-02f, -1.43230204e-02f, -1.72128603e-02f, -1.20537162e-01f, 1.61291547e-02f, -9.25208032e-02f, 3.04327123e-02f, -1.13280341e-01f,
  2.12286040e-02f, 2.74236109e-02f, 3.02813412e-03f, 4.71960902e-02f, 4.31476906e-02f, -5.62003814e-02f, -3.34695280e-02f, -1.50388665e-02f, 4.36603054e-02f, -2.55408157e-02f,
  -3.99493016e-02f, -2.49753315e-02f, -1.85288284e-02f, -4.82459143e-02f, -3.14857662e-02f, -1.24083553e-02f, -3.14113386e-02f, -4.57286788e-03f, -1.61243659e-02f, 5.68674095e-02f,
  4.56752591e-02f, -7.03870580e-02f, -4.50654887e-02f, -8.95776972e-03f, 2.30622683e-02f, 8.86442587e-02f, -3.58318631e-03f, -4.64724042e-02f, 1.46023175e-02f, 1.54791815e-05f,
  -3.07025239e-02f, 6.49559125e-02f, -7.42068887e-02f, 1.58236139e-02f, 8.04717466e-03f, 1.83576457e-02f, -2.58478001e-02f, 2.64191311e-02f, -5.77191189e-02f, -1.78085919e-02f,
  -7.64336495e-04f, -3.07632927e-02f, -1.00298403e-02f, -3.60295326e-02f, -2.56699715e-02f, -3.42870094e-02f, 1.75905954e-02f, 6.26638085e-02f, -6.81384429e-02f, 2.74089351e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.54034349e-02f, 4.64279920e-01f, 3.61643344e-01f, 2.71409512e-01f, -2.46614069e-01f, -5.38920105e-01f, -3.07526737e-01f, 5.29317856e-02f, 5.65841123e-02f, -1.14505082e-01f,
  -1.48534283e-01f, 2.86355138e-01f, -6.27995515e-03f, 3.83790195e-01f, -1.63740546e-01f, -1.41865879e-01f, -1.63322948e-02f, -9.75019336e-02f, -5.45529351e-02f, 1.50956795e-01f,
  -3.16075161e-02f, -1.88599840e-01f, 2.52256840e-01f, -1.58660159e-01f, 5.17732240e-02f, 1.89186603e-01f, -8.79285682e-04f, -3.38555723e-02f, 7.36143142e-02f, -1.29748866e-01f,
  1.44449964e-01f, 7.34401420e-02f, 1.70412868e-01f, 2.72594169e-02f, -1.79609749e-02f, -1.36307403e-01f, 8.46459866e-02f, -1.29303923e-02f, -1.50867207e-02f, 7.22758025e-02f,
  -1.28542911e-02f, -1.28531754e-01f, 4.28831913e-02f, 1.99717768e-02f, -4.89219911e-02f, 9.94952992e-02f, 1.92557126e-01f, 4.84576565e-04f, -5.19823190e-03f, -6.68602390e-03f,
  6.07363470e-02f, -3.76685895e-02f, 3.24616469e-02f, -5.63230403e-02f, 5.65483570e-02f, 2.41961461e-02f, -1.95604622e-01f, 6.55879229e-02f, -5.02426550e-02f, 4.53234091e-03f,
  -1.91995297e-02f, -2.80930120e-02f, -2.17452701e-02f, 9.62212458e-02f, -2.17154585e-02f, 1.60529781e-02f, 3.39195468e-02f, -4.73844931e-02f, 8.79445001e-02f, -2.94939168e-02f,
  -4.25069444e-02f, 3.50317992e-02f, -2.78860591e-02f, -7.75500163e-02f, -8.67765620e-02f, 7.07707480e-02f, -5.74671701e-02f, -1.22138374e-01f, -3.53985541e-02f, -3.58983018e-02f,
  -2.24047080e-02f, -4.43840362e-02f, 7.84124136e-02f, -2.64269329e-04f, 2.67518945e-02f, 2.14121312e-01f, -5.95308281e-02f, 7.84102231e-02f, 4.90123667e-02f, -8.47644806e-02f,
  1.14419110e-01f, 1.95521444e-01f, 8.76929704e-03f, 3.30588892e-02f, 1.51772290e-01f, -2.36135200e-02f, -9.45423916e-02f, 8.20340291e-02f, 5.32070324e-02f, -6.98201358e-02f,
  5.51034436e-02f, -6.79244176e-02f, 1.55936554e-02f, 7.94379935e-02f, 1.17674194e-01f, -1.12219013e-01f, -5.39785251e-02f, 1.01602204e-01f, 1.02087684e-01f, 2.02740524e-02f,
  8.44712555e-02f, -2.47745421e-02f, -6.72935620e-02f, -3.90014797e-02f, -4.82562818e-02f, 1.04500130e-02f, -5.44645339e-02f, 4.87154676e-03f, 2.87345853e-02f, -3.17760296e-02f,
  -3.53124470e-01f, -1.95534855e-01f, -2.64120638e-01f, 4.17944938e-01f, -2.46500194e-01f, -2.08514243e-01f, -1.83663890e-01f, 2.63060238e-02f, -1.15176030e-01f, 1.72532216e-01f,
  1.63674235e-01f, -2.04704134e-04f, -2.77281791e-01f, 4.77891862e-01f, 1.53704152e-01f, -5.06405905e-02f, 3.78161013e-01f, 1.91106766e-01f, 1.48989018e-02f, -6.60359934e-02f,
  6.60077333e-02f, 3.81323159e-01f, 4.61959988e-02f, 2.03532606e-01f, -2.66452301e-02f, -1.00906171e-01f, 1.60669327e-01f, -2.68327832e-01f, 3.09799761e-01f, 1.83567092e-01f,
  -1.75668914e-02f, 4.11957726e-02f, -6.97749332e-02f, -4.81243096e-02f, -8.37689713e-02f, -1.57550707e-01f, -1.46902278e-01f, -1.40561834e-02f, 1.47566712e-02f, -1.92005504e-02f,
  -1.37958273e-01f, 1.19871013e-02f, 1.33339822e-01f, -2.55708601e-02f, -1.35413399e-02f, -5.87052479e-03f, 4.24269810e-02f, -4.23125960e-02f, -1.49388621e-02f, -2.30945237e-02f,
  -7.77201131e-02f, 7.56101776e-03f, -5.62933227e-03f, 4.13027219e-02f, -4.45958301e-02f, 7.84615353e-02f, 5.53220958e-02f, -1.73305478e-02f, 6.86130971e-02f, 3.59184816e-02f,
  2.53127124e-02f, -3.33340801e-02f, -9.79117230e-02f, -1.62655711e-02f, -6.23960495e-02f, -7.20178988e-03f, 1.49685428e-01f, 4.87609170e-02f, 3.42222191e-02f, 2.19390541e-02f,
  3.82179841e-02f, 8.72032065e-03f, 9.42917541e-02f, -3.16838212e-02f, -2.88244914e-02f, 2.47778744e-03f, -3.95023823e-02f, -3.54357786e-03f, 2.98813193e-05f, 2.31609195e-02f,
  -1.19813077e-01f, -5.29677197e-02f, -5.04866764e-02f, -1.17422566e-02f, 1.08124629e-01f, -6.78707734e-02f, -7.42386505e-02f, -2.10498556e-01f, -1.00761436e-01f, -3.49525847e-02f,
  -3.47768009e-01f, -1.91083089e-01f, -7.25115836e-02f, 5.99069521e-02f, 6.12709112e-02f, 1.82775097e-04f, 2.74071973e-02f, 3.87831703e-02f, -1.73009299e-02f, -2.75675040e-02f,
  -9.24976245e-02f, 6.85394183e-02f, -8.85069892e-02f, -1.67458281e-02f, 8.83540809e-02f, -1.05752096e-01f, 2.42825355e-02f, 1.18692184e-03f, 2.14497130e-02f, 1.01137973e-01f,
  -9.31736734e-03f, 9.52445529e-03f, 3.26172560e-02f, -5.44582792e-02f, 8.50514323e-02f, -4.58089709e-02f, -7.70714357e-02f, 2.00678334e-02f, 6.44074678e-02f, 8.48112255e-02f,
  -3.28263164e-01f, -7.57827908e-02f, -2.93191466e-02f, 2.05889821e-01f, -5.65961525e-02f, -1.97777167e-01f, -2.25353032e-01f, 1.61772653e-01f, -4.19875562e-01f, 1.32768955e-02f,
  8.92217830e-02f, -1.66909888e-01f, -8.20901990e-02f, -6.50961176e-02f, 1.00670785e-01f, -2.38344803e-01f, 1.67810783e-01f, -1.90749560e-02f, -1.71214893e-01f, 1.94790989e-01f,
  2.74852645e-02f, 2.60920465e-01f, 1.63156614e-01f, 3.48160386e-01f, -2.65490059e-02f, 2.69677222e-01f, 5.65172672e-01f, 7.18524083e-02f, 4.81594175e-01f, 4.67358194e-02f,
  -1.28183067e-01f, -1.30530342e-01f, 3.63598503e-02f, -3.77949588e-02f, 1.27953306e-01f, 1.04723617e-01f, 3.40843238e-02f, 5.82622364e-02f, 3.80214155e-02f, 3.73329595e-02f,
  -1.03438068e-02f, 3.25731486e-02f, -6.80168793e-02f, 9.09407251e-03f, -1.18237667e-01f, 2.37983186e-02f, -5.11487536e-02f, -5.55244274e-02f, -1.00948282e-01f, -1.01773389e-01f,
  -4.39226627e-02f, -3.64342593e-02f, 4.89790598e-03f, 4.76792939e-02f, 2.09453162e-02f, -1.15870632e-01f, 9.58994403e-03f, 7.08904341e-02f, 3.79340686e-02f, 6.14309274e-02f,
  4.11799997e-02f, -6.12821169e-02f, -7.18465075e-02f, -5.62727042e-02f, -3.42797935e-02f, -4.36350890e-02f, -1.18051216e-01f, -1.19823096e-02f, -5.24951331e-02f, -4.79014814e-02f,
  2.74369773e-02f, -3.12024802e-02f, -1.36377499e-01f, 1.06390519e-02f, -3.67893912e-02f, -9.71024483e-02f, -1.03644142e-02f, 5.63224824e-03f, 6.68703243e-02f, 1.03432946e-02f,
  1.93052720e-02f, -4.74720187e-02f, 2.92802397e-02f, -3.57862264e-02f, -6.27197623e-02f, 9.57579985e-02f, 1.60291023e-03f, -5.70178330e-02f, 3.45073417e-02f, 6.48921952e-02f,
  8.70601907e-02f, 3.95273834e-01f, 6.73141843e-03f, 4.62976657e-02f, -2.69161873e-02f, -3.74742746e-02f, -1.76842511e-02f, -7.02026337e-02f, 1.33401036e-01f, -7.47996569e-02f,
  1.34538978e-01f, 8.38279724e-02f, 2.51938473e-03f, -2.70913076e-03f, 1.28475606e-01f, 1.79985017e-02f, 3.52635011e-02f, 4.21563014e-02f, 1.36719748e-01f, 1.01610042e-01f,
  1.25405043e-01f, -8.89768004e-02f, -3.99643891e-02f, -4.15536910e-02f, 3.07541974e-02f, 4.26424816e-02f, 8.33474472e-02f, 8.57633129e-02f, 3.14168050e-03f, 1.22843068e-02f,
  3.63747299e-01f, -1.71314552e-01f, -1.89838469e-01f, -1.52308708e-02f, 2.24702552e-01f, 4.14298922e-02f, 3.02047223e-01f, -2.32274562e-01f, -3.12412143e-01f, -1.83636844e-01f,
  7.96887502e-02f, -5.41448109e-02f, 1.25150397e-01f, -2.19607562e-01f, 1.83255896e-01f, -2.36566797e-01f, -1.41237035e-01f, 8.52727443e-02f, -8.45783278e-02f, 5.36894165e-02f,
  -1.11543879e-01f, 8.94294605e-02f, -5.87108657e-02f, -3.91943529e-02f, 1.83013588e-01f, -1.20687336e-02f, 2.26025686e-01f, 1.29244849e-01f, -2.55261716e-02f, 3.40425596e-02f,
  4.58326563e-02f, -1.64113820e-01f, 6.11933321e-02f, -1.29787147e-01f, 5.12783714e-02f, 3.23113650e-02f, 6.25742674e-02f, 6.36203066e-02f, 3.96792293e-02f, -3.33808661e-02f,
  2.36112326e-02f, -2.67371722e-02f, -1.29417866e-01f, 8.56742263e-02f, 7.25549012e-02f, -5.77575304e-02f, -5.59000075e-02f, -2.46666316e-02f, -9.34706405e-02f, -2.87965629e-02f,
  2.20110845e-02f, 1.64578278e-02f, 4.37422879e-02f, -6.28071427e-02f, 7.78794736e-02f, 6.23365026e-03f, 2.01688558e-02f, 1.30303591e-01f, -4.50660698e-02f, -5.55404536e-02f,
  2.59213094e-02f, 2.86653489e-02f, 6.62640408e-02f, -9.71249305e-04f, 5.79580851e-02f, -7.57373273e-02f, 1.21259198e-01f, -7.81866780e-04f, 6.77524656e-02f, -1.05791807e-01f,
  3.62196863e-02f, -3.33260708e-02f, -6.90366849e-02f, 4.02785130e-02f, 1.10983834e-01f, -1.69053162e-03f, 1.15453839e-01f, 4.56170924e-02f, -1.40835166e-01f, 8.68544653e-02f,
  -4.85290512e-02f, -9.79501605e-02f, -6.86946465e-03f, 1.48008978e-02f, -2.74446551e-02f, -9.28722098e-02f, -1.42404005e-01f, -3.82629894e-02f, 3.67516354e-02f, -1.63698550e-02f,
  2.14868467e-02f, 8.70943293e-02f, -1.16328202e-01f, -3.00408788e-02f, -1.91324335e-02f, 4.99520190e-02f, -5.90678751e-02f, 1.23861078e-02f, -4.43345644e-02f, -3.73399332e-02f,
  -2.75422130e-02f, 2.76348908e-02f, 1.54202238e-01f, -4.73969914e-02f, 5.01128361e-02f, -5.90561517e-02f, -1.14065722e-01f, -1.03046009e-02f, -1.10418778e-02f, -4.45912853e-02f,
  2.80342158e-02f, 1.53756127e-01f, 4.39061364e-03f, 8.02527517e-02f, -8.33390728e-02f, 5.66448756e-02f, 1.55466691e-01f, -4.85614277e-02f, 2.12203488e-02f, -9.68038812e-02f,
  2.02989787e-01f, 2.11253520e-02f, -1.10098906e-01f, 3.19292217e-01f, -3.26941222e-01f, -3.78854513e-01f, -2.11502433e-01f, -3.08827788e-01f, 3.38188589e-01f, -5.90847880e-02f,
  -3.18623424e-01f, 4.68304425e-01f, -1.95552614e-02f, -2.63980031e-01f, 5.59693277e-02f, 2.18850061e-01f, -2.56499927e-02f, 2.00421557e-01f, 5.38415723e-02f, -1.00123234e-01f,
  2.79215463e-02f, -3.41223270e-01f, -1.81369841e-01f, -2.85067558e-01f, -2.40565181e-01f, -7.28089130e-03f, -2.48050336e-02f, -2.02446878e-01f, -6.10389896e-02f, -6.22739717e-02f,
  -7.19637200e-02f, 1.47087082e-01f, -6.01828061e-02f, 9.81373060e-03f, -1.98049381e-01f, -6.05311245e-02f, -9.67768114e-03f, 1.92989931e-02f, 5.65682352e-02f, 2.59762127e-02f,
  1.32716686e-01f, 1.24438815e-01f, -1.36134848e-01f, 5.78905083e-03f, 8.00505746e-04f, -2.09544916e-02f, 7.39801675e-02f, -5.10360999e-03f, -2.31382139e-02f, 4.07130318e-03f,
  2.31064856e-02f, -3.88542302e-02f, -1.04668126e-01f, 1.87675953e-01f, 3.20473760e-02f, 4.19391925e-03f, -1.46370707e-02f, -7.30929710e-03f, 3.85184996e-02f, 1.06196061e-01f,
  -7.28061199e-02f, -1.43182641e-02f, 1.51523491e-02f, 2.65970305e-02f, -2.82110274e-02f, -7.52485171e-02f, 9.78144333e-02f, -7.45068165e-03f, 9.99194086e-02f, -2.93830298e-02f,
  1.23634208e-02f, -4.48988639e-02f, -9.52916667e-02f, 4.15493399e-02f, -2.65224706e-02f, -2.58470252e-02f, 4.21545208e-02f, -3.18319052e-02f, 6.63293526e-02f, -5.44028208e-02f,
  -2.77058445e-02f, -4.78445701e-02f, 9.35931802e-02f, -4.67390232e-02f, -4.89703380e-02f, -3.46001908e-02f, -2.25319955e-02f, 6.29749224e-02f, -8.72543082e-02f, -1.52054951e-01f,
  6.95064897e-03f, 3.90888155e-02f, 7.90863205e-03f, -2.88383532e-02f, 9.06545073e-02f, -1.10295806e-02f, 4.54107812e-03f, -1.28250141e-02f, 7.05823451e-02f, -2.28799395e-02f,
  -1.07830778e-01f, -3.71243097e-02f, 1.06104143e-01f, 4.84350920e-02f, -4.21116650e-02f, -3.20349410e-02f, -4.91955578e-02f, 6.83500022e-02f, -2.24701427e-02f, -3.59977819e-02f,
  -7.65364394e-02f, 9.27461535e-02f, 3.64277624e-02f, -6.85335975e-03f, 3.44628990e-02f, -2.67376304e-02f, 4.69211265e-02f, 7.21782669e-02f, 2.50821523e-02f, 4.85962667e-02f,
  2.94256330e-01f, -1.14713073e-01f, 9.52922404e-02f, -4.40590046e-02f, 4.88534272e-02f, 6.74806684e-02f, 4.17624384e-01f, -3.48937303e-01f, -2.99758255e-01f, -4.33376990e-02f,
  1.47162512e-01f, 3.88356924e-01f, 3.97199363e-01f, -1.11342417e-02f, 3.57686877e-01f, 1.69425100e-01f, -1.26663923e-01f, 3.81674990e-02f, -8.37696269e-02f, 7.41686150e-02f,
  -3.41825522e-02f, 3.56428437e-02f, 2.85974115e-01f, -2.50482202e-01f, 1.38017595e-01f, -1.65706739e-01f, 6.36125356e-02f, 9.90447551e-02f, -4.36758511e-02f, 1.05033278e-01f,
  -1.37169175e-02f, -1.14071757e-01f, -2.74933632e-02f, -6.16611727e-02f, -9.66834128e-02f, -3.74206416e-02f, 9.20331851e-03f, 1.39725372e-01f, 3.06285750e-02f, -3.83160263e-02f,
  -3.43395174e-02f, 1.32708913e-02f, -9.00472477e-02f, -1.84965301e-02f, -4.45385799e-02f, -1.34671554e-01f, 5.30592538e-02f, 1.69110876e-02f, 2.22034361e-02f, 4.17692736e-02f,
  5.35809295e-03f, -4.57204655e-02f, 6.02741307e-03f, -1.19723706e-02f, 3.98221835e-02f, 5.68696707e-02f, -4.83118333e-02f, 1.43739715e-01f, -4.32443693e-02f, 7.15277418e-02f,
  3.80228423e-02f, -3.60812359e-02f, -8.59199651e-03f, -4.73157950e-02f, -1.50431052e-03f, -5.71442917e-02f, 6.96787192e-03f, 9.42092668e-03f, -3.95437181e-02f, 9.05140340e-02f,
  1.23765301e-02f, 2.16210503e-02f, -4.96965586e-05f, -6.66749384e-03f, -1.70521010e-02f, -1.23013385e-01f, 2.46215779e-02f, 1.76305380e-02f, 2.36172555e-03f, -8.04504752e-02f,
  1.99011629e-04f, -4.12697382e-02f, 1.24171093e-01f, -4.11123484e-02f, 1.52691202e-02f, 1.03583708e-01f, -2.51119472e-02f, 1.27804223e-02f, -3.98629531e-02f, 8.55112597e-02f,
  -6.47273883e-02f, -1.66918755e-01f, -6.36232048e-02f, 3.81276272e-02f, 6.12124475e-03f, -1.17699459e-01f, -5.51921427e-02f, -1.31153613e-01f, -2.54120789e-02f, -4.50796112e-02f,
  -1.13193952e-02f, 2.49287821e-02f, -7.79197142e-02f, 5.58214188e-02f, 2.43446101e-02f, -7.83503521e-03f, 1.06743760e-01f, -2.49454807e-02f, 5.62833026e-02f, -6.50012866e-02f,
  1.99447982e-02f, -1.32801577e-01f, -1.74645502e-02f, -1.11431852e-01f, -2.31243707e-02f, -5.47797643e-02f, -8.64287019e-02f, 2.62250826e-02f, 2.54803393e-02f, -3.64764072e-02f,
  -5.43274879e-01f, 1.91649348e-01f, -3.00849140e-01f, 4.15044785e-01f, -5.64776501e-03f, 3.59956563e-01f, 2.61826336e-01f, -3.72460708e-02f, -4.07836884e-02f, 3.27417672e-01f,
  1.86254874e-01f, -3.12307104e-02f, -3.31942067e-02f, 4.42623049e-01f, -2.55760066e-02f, 1.53693855e-01f, 2.57255703e-01f, 9.75237414e-02f, -1.19483516e-01f, 5.93876541e-02f,
  -8.11475664e-02f, 3.13110113e-01f, -1.21463658e-02f, 1.24497987e-01f, 1.34126827e-01f, -5.92854582e-02f, 1.47953972e-01f, -1.22686930e-01f, 2.84229070e-01f, 1.52826041e-01f,
  -1.81319173e-02f, -1.44363418e-01f, -1.77737400e-02f, -1.06570177e-01f, -5.54263080e-03f, 3.62334214e-02f, 3.82335372e-02f, -5.60761914e-02f, -6.42318353e-02f, -1.78242140e-02f,
  -2.57316884e-02f, -2.73423102e-02f, 8.04221183e-02f, -1.66032948e-02f, -3.37579995e-02f, -3.06025497e-03f, 2.39666533e-02f, 4.32978384e-02f, -8.32843184e-02f, -5.88967055e-02f,
  -6.14282303e-02f, -1.18659278e-02f, -7.53417099e-03f, 1.09521769e-01f, -6.50599003e-02f, 1.40198192e-03f, -2.56869067e-02f, -8.23644251e-02f, -4.36635166e-02f, 1.67374071e-02f,
  -3.35452966e-02f, -1.20506613e-02f, 4.54078382e-03f, 8.86044651e-02f, -2.76623573e-02f, -2.04656124e-02f, -8.77351034e-03f, 2.65449788e-02f, -3.49386223e-02f, 7.88185745e-02f,
  2.07304358e-02f, 1.09694889e-02f, -1.49998097e-02f, 6.30519316e-02f, -5.32162078e-02f, -2.06337087e-02f, -2.19281577e-02f, 2.73322836e-02f, 7.77977705e-02f, -8.32543150e-02f,
  2.67740041e-02f, -4.38148007e-02f, 6.15251400e-02f, -3.27718258e-02f, -8.91454816e-02f, 4.50671874e-02f, 1.69921115e-01f, 7.73980990e-02f, 7.73533732e-02f, -4.28650826e-02f,
  2.19097082e-02f, -1.46140680e-01f, 7.74641037e-02f, 7.10009784e-02f, 4.31910604e-02f, 1.02888197e-01f, -2.84785237e-02f, -3.17620113e-02f, -7.60691823e-04f, -3.46391201e-02f,
  1.21603981e-01f, -5.45406826e-02f, 4.35341261e-02f, 1.80151202e-02f, 2.56846305e-02f, 1.07303202e-01f, 6.62359744e-02f, 7.57195579e-04f, 3.41180004e-02f, -1.96273881e-03f,
  9.88339484e-02f, -2.51002964e-02f, -3.83232757e-02f, -9.76611208e-03f, 7.36794434e-03f, -4.12289947e-02f, 2.46207472e-02f, 1.42159015e-02f, 9.92007554e-03f, 3.39813717e-02f,
  -8.15437913e-01f, 3.92960459e-01f, 8.91804844e-02f, 9.97168571e-02f, -1.36952996e-01f, -4.80596602e-01f, -1.45729527e-01f, 8.46069232e-02f, -2.51544625e-01f, -4.24464699e-03f,
  -5.69671579e-03f, -1.07971551e-02f, 1.91090599e-01f, 2.43397132e-01f, -3.90162393e-02f, 2.23047972e-01f, 7.57944882e-02f, -3.27562243e-02f, 9.67022032e-02f, 1.85744464e-01f,
  1.91820506e-02f, 2.03031734e-01f, 3.14084351e-01f, 1.97038040e-01f, 3.03662345e-02f, 5.83295599e-02f, 7.52827749e-02f, 2.33422816e-01f, -6.47391528e-02f, -9.99784768e-02f,
  -3.13701570e-01f, 4.65198122e-02f, -1.38933295e-02f, -1.31959915e-01f, -1.21882394e-01f, -8.36583897e-02f, -7.02463314e-02f, -6.56777769e-02f, 1.08043170e-02f, -5.42647690e-02f,
  6.56261249e-03f, 3.52750048e-02f, -3.78060564e-02f, 1.33268654e-01f, -1.27294585e-01f, 1.59765631e-02f, 2.43687648e-02f, -5.83716556e-02f, 6.72091916e-02f, 2.11824216e-02f,
  1.11434676e-01f, 1.98018383e-02f, -4.02662642e-02f, -7.77144777e-03f, 7.06756487e-02f, -6.17205538e-03f, -4.71986532e-02f, 1.99310780e-02f, -1.86929964e-02f, -1.72534049e-01f,
  -1.31640956e-02f, -6.70974255e-02f, 4.08899970e-02f, 4.98133106e-03f, -1.02236085e-02f, 3.84461582e-02f, -1.20076502e-03f, 1.67967658e-02f, -8.86502415e-02f, -1.37061924e-02f,
  -7.54890144e-02f, -6.36633113e-02f, -3.20789739e-02f, 1.95366815e-02f, -4.45958562e-02f, -7.27979466e-03f, 4.22461852e-02f, -3.66940759e-02f, -1.00426346e-01f, -1.63089838e-02f,
  3.81690525e-02f, -3.16457897e-02f, 1.70816611e-02f, 7.72219896e-03f, -3.21515985e-02f, 6.67454600e-02f, 3.27719264e-02f, 7.65693709e-02f, 3.58389914e-02f, 2.86845155e-02f,
  -3.41250300e-01f, 1.08241126e-01f, -1.06480420e-02f, -1.70450032e-01f, 5.46327271e-02f, -4.86391298e-02f, 7.39469007e-02f, -1.48282787e-02f, 3.07465326e-02f, -4.06571152e-03f,
  -6.82046488e-02f, -1.02241203e-01f, -3.99795249e-02f, -7.19443411e-02f, 9.49394554e-02f, -5.78502491e-02f, 2.83429194e-02f, -4.79971580e-02f, 3.51771414e-02f, -2.70554889e-03f,
  7.59621486e-02f, -1.11058846e-01f, 2.25013569e-02f, 1.80979501e-02f, -3.96154039e-02f, -9.12220869e-03f, -2.28769053e-02f, -6.49765208e-02f, -5.88204805e-03f, 1.63496211e-02f,
  -1.67494893e-01f, 1.85117736e-01f, -2.18786150e-01f, -2.07248434e-01f, 4.16866206e-02f, -3.57464522e-01f, -1.66985244e-01f, -3.61366663e-03f, -1.93075776e-01f, 4.16363269e-01f,
  -1.04411960e-01f, 1.56047821e-01f, 5.79228438e-02f, -3.38307589e-01f, -8.26309562e-01f, -3.27342600e-01f, -5.07784545e-01f, -1.66967273e-01f, -1.46163180e-01f, -4.58359160e-02f,
  -2.57777721e-01f, -5.93068562e-02f, -4.24069136e-01f, 1.74538478e-01f, 4.54696231e-02f, 2.22792685e-01f, 5.75748980e-02f, 1.73050374e-01f, -3.73971765e-03f, -5.70179597e-02f,
  -1.08509071e-01f, 9.07040164e-02f, 1.06539093e-01f, -8.57586712e-02f, -1.08415671e-01f, 1.50126413e-01f, 1.87252034e-02f, 1.37051772e-02f, -8.59032795e-02f, -4.93156537e-02f,
  1.46326482e-01f, -3.18099596e-02f, -6.68542087e-02f, 6.98849633e-02f, 4.81458455e-02f, 6.38876259e-02f, -6.79465160e-02f, -1.05188303e-02f, 3.59352375e-03f, -4.72143516e-02f,
  -5.56741953e-02f, 3.36208120e-02f, 3.86851281e-02f, 5.01736179e-02f, -9.35332254e-02f, -1.25156874e-02f, -1.93097128e-03f, -8.11796114e-02f, 2.02479726e-03f, 3.49557325e-02f,
  2.17238106e-04f, -6.67265058e-02f, -6.64412230e-02f, 1.63199306e-02f, 3.45126018e-02f, -1.34501187e-02f, 7.35102147e-02f, 7.40162469e-03f, 3.39508839e-02f, 2.55540330e-02f,
  4.82420400e-02f, -3.32361879e-03f, -1.18829217e-02f, -6.44054562e-02f, -1.25237368e-02f, -7.27558462e-03f, 1.08102471e-01f, 6.62999600e-02f, -6.45826384e-02f, -1.45108474e-03f,
  6.34016767e-02f, -1.49612864e-02f, 1.40821412e-01f, 7.01437965e-02f, -8.49264562e-02f, -3.98202464e-02f, -1.12152388e-02f, 1.22820614e-02f, -5.70419841e-02f, -5.07382490e-02f,
  -2.44214669e-01f, -9.80056897e-02f, 8.03112984e-03f, 2.31469311e-02f, 8.80171880e-02f, -2.55267434e-02f, -1.54537976e-01f, 3.42542795e-03f, 8.20946880e-03f, -1.37526048e-02f,
  -7.83792809e-02f, 7.19884038e-02f, -1.77710212e-03f, 1.85706411e-02f, -7.62891322e-02f, -3.19198333e-02f, 6.36430681e-02f, 2.30797548e-02f, -2.09094863e-02f, -3.34710181e-02f,
  5.51780425e-02f, 4.33575809e-02f, 2.64981277e-02f, 5.71327806e-02f, -3.54112163e-02f, 2.40864661e-02f, 7.95914158e-02f, 4.73555643e-03f, 4.11557071e-02f, -7.71194547e-02f,
  2.17675284e-01f, 1.12298623e-01f, -2.80795395e-01f, -7.54115805e-02f, -5.08185863e-01f, -2.03331694e-01f, -6.65425435e-02f, -2.29521811e-01f, -2.59663552e-01f, 1.35306478e-01f,
  1.01561427e-01f, -4.07350510e-02f, 2.73209095e-01f, 1.72562554e-01f, -7.66419545e-02f, 3.42020541e-01f, -8.28395784e-02f, 4.05063517e-02f, -2.92927586e-02f, 2.17010230e-02f,
  -1.12351678e-01f, 2.48170979e-02f, 2.05540687e-01f, -1.63720459e-01f, -8.32430497e-02f, -8.12751204e-02f, 4.89234179e-02f, -1.22369498e-01f, -1.50075704e-01f, -5.38019426e-02f,
  2.18008310e-01f, 8.30700323e-02f, -5.12314402e-02f, 3.13358121e-02f, -7.65065709e-03f, -1.91786382e-02f, 3.68787558e-04f, 5.72760999e-02f, 1.86835378e-02f, -2.98946146e-02f,
  5.05336821e-02f, -7.51631111e-02f, 5.35210455e-03f, -5.53171039e-02f, -1.27769709e-01f, -1.11006312e-01f, -1.56707525e-01f, 8.38798285e-02f, 8.51349905e-02f, 3.23958620e-02f,
  -1.04206742e-03f, 1.77705009e-02f, -1.37278959e-01f, 2.40656007e-02f, -1.04582570e-01f, -2.76140496e-02f, 1.03392161e-01f, -2.01445464e-02f, 3.28387804e-02f, -4.37732115e-02f,
  -2.38560997e-02f, -1.40605336e-02f, -2.28203852e-02f, 6.99615330e-02f, 2.11866591e-02f, 5.15130572e-02f, -6.31582215e-02f, 2.41041426e-02f, -8.88445452e-02f, 1.62015501e-02f,
  -5.98062612e-02f, -2.77562570e-02f, -4.40281779e-02f, -5.88135384e-02f, 7.72894593e-04f, 1.08832851e-01f, 9.25099030e-02f, 4.35660444e-02f, -7.01364204e-02f, 1.19385719e-01f,
  4.42619585e-02f, 8.95852670e-02f, -5.08400500e-02f, 7.78172091e-02f, 2.67103612e-02f, -1.14324644e-01f, -1.52927607e-01f, -9.13610309e-02f, 3.75877470e-02f, 6.83112517e-02f,
  -6.30412949e-03f, -1.56591475e-01f, -3.37599516e-02f, 1.71270370e-02f, 4.06231694e-02f, 1.29624316e-02f, -2.94691902e-02f, -9.37797502e-02f, -1.46252483e-01f, -4.21831720e-02f,
  -7.37301633e-02f, 8.19267705e-02f, -1.40527979e-01f, 5.20699769e-02f, -9.43936780e-02f, 5.39657734e-02f, 6.84582070e-02f, -6.33920953e-02f, -6.79762736e-02f, 4.66189124e-02f,
  9.07387584e-03f, -1.97178405e-02f, -1.85444835e-04f, 2.50478424e-02f, -4.04916778e-02f, 7.75357261e-02f, -4.00799997e-02f, 1.12379715e-02f, -7.48340487e-02f, -9.69598517e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  -4.76891026e-02f, -3.51985656e-02f, 5.45682609e-02f, 2.38016039e-01f, 2.57279187e-01f, -1.41840294e-01f, -9.83139798e-02f, 1.89605832e-01f, 4.44136292e-01f, -1.00659944e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -8.11648667e-02f, 5.56853078e-02f, -2.14945421e-01f, 6.73234642e-01f, 2.33425155e-01f, -1.35770917e-01f, 3.69343698e-01f, 1.27046347e-01f, 6.79543987e-02f, -6.10570759e-02f,
  -2.33432040e-01f, -3.18723619e-01f, -2.20120579e-01f, 1.56356037e-01f, 8.35618377e-02f, -1.59368664e-01f, -5.44386864e-01f, -1.14344858e-01f, 1.63375586e-02f, -4.50419150e-02f,
  5.77949993e-02f, 2.28265598e-01f, -9.29278438e-04f, -1.65225506e-01f, -2.44728640e-01f, -3.66509378e-01f, 5.24630606e-01f, -3.38537879e-02f, -4.22964215e-01f, -3.60485055e-02f,
  3.60480338e-01f, -3.81423682e-01f, 9.11417380e-02f, -4.12014097e-01f, -3.79342675e-01f, -2.37637028e-01f, 8.84875059e-01f, -1.35044515e-01f, -1.25361726e-01f, 2.90554404e-01f,
  1.92085460e-01f, -1.36132404e-01f, -9.99605432e-02f, -1.24294266e-01f, -3.45949322e-01f, -4.50290330e-02f, 4.50631082e-01f, -2.62594432e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.97663975e-01f, 5.18451273e-01f, 5.45371175e-01f, 1.01004577e+00f, -2.93550193e-01f, 1.99606314e-01f, -7.41934702e-02f, -5.04413366e-01f, 3.36633563e-01f, -9.53976959e-02f,
  -6.15037858e-01f, -2.17128545e-01f, -3.40029985e-01f, 2.92796731e-01f, 5.74898720e-01f, -3.98381412e-01f, 2.10731477e-01f, -2.26787835e-01f, 1.75433084e-01f, -9.40302461e-02f,
  2.17859000e-01f, 3.85404199e-01f, 1.90814003e-01f, 5.90569675e-01f, 2.19004869e-01f, -1.21078886e-01f, 1.81685880e-01f, -1.06242940e-01f, 5.87366641e-01f, 7.02928424e-01f,
  3.51880193e-01f, 2.89922684e-01f, 5.36515951e-01f, 6.62149370e-01f, 9.23486575e-02f, 1.87838338e-02f, 3.57206404e-01f, -5.16939998e-01f, -2.83341259e-01f, -1.20302765e-02f,
  8.98268074e-02f, 6.01737738e-01f, 1.83206469e-01f, 7.71297395e-01f, -2.02664509e-02f, -5.36444187e-01f, 2.14826226e-01f, -1.81316733e-01f, 3.17548603e-01f, 3.87109160e-01f,
  1.93529755e-01f, 3.91556889e-01f, 1.16132209e-02f, 5.09907663e-01f, 4.46186990e-01f, -2.12071668e-02f, 5.17340899e-01f, 5.57715558e-02f, -2.81103879e-01f, -3.96358162e-01f,
  -3.26149017e-01f, 6.46882355e-01f, 4.42084700e-01f, -5.97139716e-01f, 5.80938458e-01f, 8.70525539e-02f, 2.29149908e-01f, -9.58509624e-01f, 8.21957469e-01f, -6.75053775e-01f,
  3.75701070e-01f, 8.00587237e-01f, 7.95565248e-01f, 1.46965176e-01f, 1.46007553e-01f, -3.63403559e-01f, 8.92309025e-02f, -1.82225570e-01f, 6.73367381e-01f, -4.55332845e-01f,
  -1.77801233e-02f, 3.10222685e-01f, 5.11530995e-01f, -1.14384718e-01f, -8.48815620e-01f, 4.50153083e-01f, -1.31670669e-01f, 1.09100223e-01f, -5.92121124e-01f, -4.65654910e-01f,
  3.54949981e-01f, -4.82899994e-01f, 5.14882743e-01f, 6.15614235e-01f, 3.29340786e-01f, 4.63114232e-01f, -3.07853878e-01f, 1.01179741e-01f, 4.74782407e-01f, -6.34777606e-01f,
  7.72411883e-01f, -2.58887798e-01f, 9.94325057e-02f, -3.43765587e-01f, -5.57928979e-01f, 1.37440220e-01f, 5.19036651e-01f, 4.04357105e-01f, -5.86491764e-01f, 3.98770981e-02f,
  7.11520910e-01f, -5.04508801e-02f, 8.94530267e-02f, 2.85466552e-01f, 3.95141125e-01f, -6.20097041e-01f, 4.02169414e-02f, 3.14764142e-01f, 4.44572240e-01f, -4.61421818e-01f,
  4.40225601e-01f, 5.42126317e-03f, 3.59823018e-01f, -4.20587540e-01f, -3.36753488e-01f, 3.23765457e-01f, 4.99408305e-01f, -2.13490039e-01f, -7.88232684e-01f, 3.83459032e-02f,
  1.79954693e-02f, 4.77393419e-01f, -1.93881989e-01f, 2.24223092e-01f, -5.13176806e-02f, 2.13763401e-01f, -4.14531767e-01f, -2.40028650e-01f, 3.32281530e-01f, -1.24594253e-02f,
  2.99691617e-01f, 1.97506666e-01f, 4.31422591e-01f, 1.06030762e-01f, -7.29392469e-01f, -1.15567662e-01f, 9.83587503e-02f, -6.56451937e-03f, 4.72677320e-01f, 5.06236851e-01f,
  2.14515328e-01f, 1.45829663e-01f, -3.71237308e-01f, -5.06085381e-02f, 5.29629111e-01f, 6.89228699e-02f, 4.38508876e-02f, 1.22713000e-01f, 4.87071514e-01f, -1.09723382e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  2.78287917e-01f, 4.42110658e-01f, 6.50452554e-01f, 3.10296237e-01f, 6.61681950e-01f, 3.71564656e-01f, 4.25331801e-01f, 2.76714534e-01f, 1.31219432e-01f, -1.48813263e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  2.64790505e-01f, 5.51921785e-01f, -7.93683529e-02f, 6.89190686e-01f, 4.29529846e-01f, 7.03487933e-01f, 2.81303138e-01f, -5.74114434e-02f, -9.62774605e-02f, 1.27096638e-01f,
  1.94635108e-01f, -1.08890556e-01f, 1.06481230e-02f, 1.20389245e-01f, -8.18536710e-03f, 1.41271323e-01f, -8.41627046e-02f, 8.58321130e-01f, 8.50960463e-02f, -1.34869352e-01f,
  -3.49986821e-01f, -3.91936064e-01f, 4.49814677e-01f, -3.57453763e-01f, 5.56241989e-01f, 4.26431149e-02f, -1.50171205e-01f, 1.10222111e-02f, -2.27199033e-01f, 2.07772888e-02f,
  -4.45194215e-01f, -1.65885426e-02f, -1.01034276e-01f, 7.78245747e-01f, -2.92131215e-01f, 3.28089148e-01f, 4.44207788e-01f, 3.48818898e-01f, 3.13438654e-01f, -6.63435087e-02f,
  7.81135932e-02f, 1.60104915e-01f, 7.89984167e-02f, -1.49539962e-01f, 1.69523120e-01f, 3.09773773e-01f, 6.59098104e-02f, 2.82986879e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.05815671e-01f, -1.00451183e+00f, 4.83936816e-01f, -6.81046128e-01f, -1.45378619e-01f, -9.63604391e-01f, -5.84809124e-01f, 7.37583339e-01f, -4.48847651e-01f, -4.04169187e-02f,
  3.11090082e-01f, 6.86446965e-01f, -1.01558045e-02f, 2.53147125e-01f, 7.17639506e-01f, 2.97423124e-01f, -2.48255190e-02f, -7.44376898e-01f, 3.63188833e-01f, 6.09100044e-01f,
  -3.23388100e-01f, 3.78863186e-01f, -1.41636105e-02f, 6.20915174e-01f, -1.48404539e-02f, 5.94543159e-01f, 3.76646042e-01f, -2.11532906e-01f, -5.42976797e-01f, 3.74277472e-01f,
  -1.99521005e-01f, -2.40510236e-02f, 6.18296564e-01f, 4.44318086e-01f, 4.47399884e-01f, -1.46006018e-01f, -3.03854436e-01f, 2.12550461e-02f, 5.94662726e-02f, 8.33379686e-01f,
  -1.27726018e-01f, 3.55413705e-01f, 6.64801717e-01f, 6.77654386e-01f, -5.32042623e-01f, 1.35400951e-01f, -5.41115284e-01f, -7.25323975e-01f, 1.53590888e-01f, -6.88473046e-01f,
  3.83356422e-01f, -3.59759241e-01f, -4.44391727e-01f, 8.27514604e-02f, 1.13077804e-01f, -2.23162957e-02f, 8.81862402e-01f, -2.49803856e-01f, 4.64370459e-01f, -3.91885400e-01f,
  1.77135512e-01f, -4.38395262e-01f, -4.14355546e-01f, -5.24858475e-01f, 4.60747480e-01f, 2.67806739e-01f, -1.00354487e-02f, 2.00503692e-01f, 1.24288358e-01f, -4.14327532e-01f,
  6.65310800e-01f, 6.59464955e-01f, 4.90935780e-02f, 3.40749890e-01f, -1.12264358e-01f, 7.84346938e-01f, -6.11275434e-01f, 8.20716470e-02f, 4.61472303e-01f, -5.58866620e-01f,
  1.96080327e-01f, 6.36989951e-01f, 2.00588107e-01f, -9.21021625e-02f, -6.98219419e-01f, -2.49597788e-01f, 6.12039387e-01f, -3.14780772e-01f, 8.49713862e-01f, 3.29770297e-01f,
  3.66893381e-01f, -1.51894569e-01f, 2.30095848e-01f, 3.55390102e-01f, -1.80607840e-01f, -7.17431247e-01f, 4.31591451e-01f, 5.46627760e-01f, -2.44870614e-02f, 4.89361048e-01f,
  -1.94218650e-01f, -2.33915493e-01f, 1.04976189e+00f, 1.55181929e-01f, 7.56861195e-02f, 8.71754229e-01f, -1.83373854e-01f, 1.98598087e-01f, -7.76990712e-01f, 2.47436389e-01f,
  2.72731930e-01f, -6.71628416e-01f, 6.38629193e-04f, 1.25649631e-01f, 3.00499588e-01f, 4.73771930e-01f, -8.31338614e-02f, 1.40258515e+00f, -1.56168744e-01f, 3.99652719e-01f,
  1.48302734e-01f, 3.48663896e-01f, 9.17672694e-01f, -5.87616086e-01f, 1.62465349e-01f, 6.27008379e-01f, -2.05576450e-01f, 5.48188165e-02f, 7.25466684e-02f, 7.18155682e-01f,
  4.73291576e-01f, -3.53531629e-01f, 3.98548156e-01f, 7.60256574e-02f, 4.99556452e-01f, 4.07785207e-01f, -1.72649715e-02f, 2.85488725e-01f, 4.99464482e-01f, 8.03619862e-01f,
  5.99527061e-01f, 3.12329292e-01f, 9.71284389e-01f, 1.17653513e+00f, 2.64747798e-01f, -7.13222846e-03f, 4.61438954e-01f, -1.01432371e+00f, -3.59634191e-01f, -8.26043665e-01f,
  -1.41824380e-01f, -6.88828155e-03f, 7.57745385e-01f, -2.69264728e-01f, 3.70634586e-01f, -1.22789994e-01f, 1.08254515e-01f, 3.06250095e-01f, -7.51666605e-01f, -8.60801101e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  4.78166819e-01f, 3.60137463e-01f, 4.72380370e-01f, 5.32749712e-01f, 6.20947719e-01f, 6.06642008e-01f, 7.48229697e-02f, -7.75830746e-02f, 8.54978189e-02f, 5.56564331e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  5.17590344e-01f, 1.70705259e-01f, 4.34249789e-01f, 3.19644362e-01f, 2.73263186e-01f, 7.79172897e-01f, -1.38556138e-02f, 1.24819547e-01f, 2.08299920e-01f, -3.24145496e-01f,
  2.29877997e-02f, -2.10582897e-01f, 1.02867596e-01f, 3.97032760e-02f, -1.34582203e-02f, -3.41900215e-02f, 1.76118076e-01f, -3.40299219e-01f, 4.59528595e-01f, 1.44687057e-01f,
  4.57264967e-02f, 6.39880359e-01f, 1.96030959e-01f, -2.27072716e-01f, -7.01105893e-02f, -1.55288540e-02f, -1.45913854e-01f, 2.85287648e-01f, 1.14465319e-01f, -2.74191797e-01f,
  -1.19150961e-02f, 1.18887469e-01f, -3.29132974e-01f, 8.95770341e-02f, -4.98854458e-01f, -5.41598558e-01f, -1.03810847e-01f, -3.86500955e-01f, 2.49929130e-01f, 4.10635740e-01f,
  -4.23171483e-02f, 1.82592064e-01f, -3.31899256e-01f, -1.91242117e-02f, 7.06150830e-02f, -1.12187922e-01f, -2.36645803e-01f, 2.88102359e-01f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  4.74666208e-01f, 4.58936095e-01f, 3.96157891e-01f, 1.77112184e-02f, 6.27509773e-01f, 1.05657250e-01f, -5.41236810e-02f, -5.14728785e-01f, 4.13589031e-01f, 7.65866756e-01f,
  -3.50825369e-01f, 3.44462901e-01f, -5.28161943e-01f, 3.84805173e-01f, 8.70765224e-02f, 9.42526996e-01f, 2.35578597e-01f, 2.68369883e-01f, -8.48157629e-02f, 3.77820849e-01f,
  -4.50424522e-01f, -3.87388021e-02f, 6.54184580e-01f, 5.15731037e-01f, 1.78649798e-01f, 4.31442171e-01f, -1.09033734e-01f, -4.46765244e-01f, -9.88155365e-01f, 6.44520819e-01f,
  5.18148720e-01f, -2.12173969e-01f, 1.96345240e-01f, 3.67701739e-01f, 1.14654392e-01f, 8.87957275e-01f, 7.57226408e-01f, 6.65294230e-01f, -5.80042124e-01f, 1.46164849e-01f,
  6.70536280e-01f, -5.13717771e-01f, 8.20336401e-01f, 3.30385864e-01f, 1.04763794e+00f, 1.22229345e-01f, 3.14793378e-01f, -1.50250167e-01f, 2.25956902e-01f, -6.80271443e-03f,
  3.36743057e-01f, -7.77303159e-01f, 3.96196723e-01f, -8.25993121e-01f, -1.75384223e-01f, -1.62068933e-01f, 1.97240114e-01f, 1.19726336e+00f, -4.15702462e-02f, 6.69746161e-01f,
  -4.20197159e-01f, 3.89213189e-02f, 9.53169763e-02f, 8.93262863e-01f, -2.06286445e-01f, 8.44148576e-01f, -9.81878582e-03f, -4.53952491e-01f, -3.24167013e-01f, -8.94334435e-01f,
  1.00778759e+00f, 1.13594961e+00f, 5.33940554e-01f, 5.16252697e-01f, 1.22568622e-01f, -4.54188734e-01f, -4.28554326e-01f, 1.63808465e-01f, -7.26633787e-01f, 2.61354119e-01f,
  -9.81363297e-01f, -9.49047729e-02f, -6.70449793e-01f, 5.74322231e-02f, -4.61751401e-01f, -7.30520725e-01f, -1.92155406e-01f, 1.22218668e+00f, 2.71517128e-01f, -4.00568515e-01f,
  3.58522385e-01f, 3.52957211e-02f, 4.80411947e-01f, 6.27107382e-01f, 4.13882732e-01f, -6.09170914e-01f, 3.29957038e-01f, 7.55761325e-01f, -1.79470070e-02f, 7.18754888e-01f,
  4.88068789e-01f, 3.71142358e-01f, -6.96006417e-02f, 6.08616889e-01f, 3.81511718e-01f, 8.93543959e-02f, -4.57694113e-01f, 4.69649285e-01f, -3.07993472e-01f, 1.22758365e+00f,
  4.03304130e-01f, 8.04459453e-02f, 3.91493924e-02f, -8.09482336e-01f, -1.65640131e-01f, 1.43348560e-01f, 1.85495988e-01f, 3.74821007e-01f, -8.73515606e-01f, 4.09168035e-01f,
  -1.13823205e-01f, 6.86258852e-01f, -7.80963674e-02f, 8.49330425e-01f, 6.42595828e-01f, 1.97038487e-01f, -2.66006678e-01f, 5.07874012e-01f, 7.19374359e-01f, -1.82504784e-02f,
  5.34360468e-01f, 1.22348511e+00f, 7.09515631e-01f, 1.31753325e+00f, -3.41945559e-01f, 2.78592855e-01f, 6.99545205e-01f, 9.74478498e-02f, 4.24273282e-01f, 4.03359681e-01f,
  8.03008020e-01f, -4.98030223e-02f, -2.94141322e-01f, -3.41273606e-01f, 7.85555184e-01f, 1.83868915e-01f, 5.36517859e-01f, -8.89575839e-01f, 2.87415147e-01f, -2.41424218e-01f,
  9.17635500e-01f, -5.33232987e-01f, 4.37210798e-01f, -8.09915811e-02f, 8.31994534e-01f, -4.60853949e-02f, 3.08546722e-01f, -9.79045689e-01f, 4.87603188e-01f, 3.71414661e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  4.83032256e-01f, 2.92202532e-01f, 2.93169707e-01f, 3.61030608e-01f, 1.81242794e-01f, -2.11410522e-01f, 9.65402648e-02f, -2.12556366e-02f, 2.00134426e-01f, 5.06465197e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  3.76351252e-02f, 3.93592380e-02f, 4.95051533e-01f, 2.65815593e-02f, -7.43441343e-01f, 3.70209068e-01f, -5.55087090e-01f, 3.28496215e-03f, -1.71157390e-01f, -2.68034995e-01f,
  4.35717314e-01f, 1.64784744e-01f, -1.04212797e+00f, -2.32233927e-01f, -5.17592251e-01f, 5.01460195e-01f, -1.37380421e-01f, 4.78603989e-01f, -5.94063640e-01f, -7.59295881e-01f,
  7.92814326e-03f, 6.47143781e-01f, 8.55279043e-02f, -1.13571525e-01f, -1.10553503e+00f, 5.34988523e-01f, 6.72351956e-01f, -4.92725819e-01f, -1.27430469e-01f, -3.45837712e-01f,
  -5.85062623e-01f, 2.93086141e-01f, 1.19380184e-01f, -6.98794425e-02f, -2.42310703e-01f, 1.79487407e-01f, -5.62520862e-01f, 6.22329831e-01f, 1.07672870e-01f, 1.00370996e-01f,
  -3.33870322e-01f, 9.19591784e-02f, 3.66184831e-01f, -1.66265786e-01f, 1.43712848e-01f, -3.17921303e-02f, 4.18830812e-02f, -7.94914126e-01f, 2.77686357e-01f, -3.59636486e-01f,
  -3.32219899e-01f, 1.92792580e-01f, -4.40109372e-01f, -8.19232538e-02f, -9.60211754e-01f, -2.71732330e-01f, 2.64467180e-01f, -3.67136776e-01f, -1.03371847e+00f, 5.60518861e-01f,
  6.47773072e-02f, -7.37527609e-01f, -4.34500396e-01f, 1.55027598e-01f, -2.46767148e-01f, 1.92865327e-01f, -4.73528266e-01f, 4.43543732e-01f, 6.68988645e-01f, -3.46644849e-01f,
  -5.30949354e-01f, -4.07494217e-01f, 5.04204452e-01f, -5.28963327e-01f, -2.66404361e-01f, -4.77483690e-01f, -9.35250446e-02f, 1.52430255e-02f, 5.86316228e-01f, 1.46765977e-01f,
  1.80747032e-01f, 9.26026478e-02f, 6.37427270e-01f, 5.94733238e-01f, 4.73572940e-01f, -5.33329546e-01f, 4.09956008e-01f, -5.14352143e-01f, 1.80971369e-01f, 1.65196151e-01f,
  -4.25471544e-01f, -1.21996582e+00f, 7.56228566e-02f, -5.60098588e-01f, -1.21376857e-01f, 6.97168231e-01f, 2.36477092e-01f, 5.56584775e-01f, 4.60754365e-01f, -2.78113842e-01f,
  5.19737065e-01f, -2.00336948e-01f, 4.32839155e-01f, -1.77952036e-01f, -2.57980600e-02f, 1.54252157e-01f, -7.17244864e-01f, -1.08734632e+00f, 6.19513631e-01f, 4.29727696e-02f,
  1.90227896e-01f, -9.81785715e-01f, 2.23246291e-01f, 1.42148752e-02f, -5.06070793e-01f, 3.01601529e-01f, 5.18601060e-01f, -5.05027533e-01f, -6.33795440e-01f, 5.11861265e-01f,
  -6.41611159e-01f, -8.42132390e-01f, -6.93960488e-01f, -3.57506901e-01f, -2.61380523e-02f, -3.87989789e-01f, -8.86577904e-01f, 7.64389575e-01f, -5.66838622e-01f, -1.94470257e-01f,
  2.26275045e-02f, -1.26560647e-02f, 7.24831447e-02f, 1.93075225e-01f, -6.35203958e-01f, -1.57408938e-01f, 1.74898967e-01f, -8.47751498e-01f, 5.03135264e-01f, 1.34159878e-01f,
  2.74149835e-01f, 1.90906599e-02f, 9.23731178e-02f, -5.12365699e-01f, -6.44866884e-01f, -4.40733671e-01f, -8.92015174e-03f, -4.46354181e-01f, 2.11970732e-01f, 5.01477480e-01f,
  2.53420979e-01f, -1.09189534e+00f, -7.70814836e-01f, 5.62351465e-01f, -4.52385604e-01f, -2.61247903e-01f, -2.65015274e-01f, 6.08482659e-01f, -2.88326114e-01f, -1.91634726e-02f,
  3.39204073e-02f, -1.51547924e-01f, -1.49470001e-01f, -2.81811506e-01f, -8.13057870e-02f, -1.15170749e-02f, -3.96114856e-01f, -6.54871404e-01f, 2.77253151e-01f, 1.08600244e-01f,
  -8.64558756e-01f, 8.18355605e-02f, 2.97473162e-01f, 4.40080673e-01f, 8.25018659e-02f, -6.82002485e-01f, 2.60658532e-01f, -3.82072628e-01f, 4.35401738e-01f, 3.51912677e-01f,
  -6.14867210e-01f, -3.77266109e-01f, -1.08268782e-01f, 4.13380682e-01f, -5.88269234e-02f, -3.57065737e-01f, -3.82806152e-01f, 2.93799013e-01f, 4.22989845e-01f, -6.48369074e-01f,
  -7.84539640e-01f, -7.72691667e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.04524083e-01f, -1.45304725e-01f, -3.40638071e-01f, 9.62668583e-02f, 3.93245339e-01f, -8.18726867e-02f, -4.16115150e-02f, 2.00987533e-01f, -3.06331694e-01f, 9.58816409e-02f,
  -3.61466072e-02f, 1.28706977e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    