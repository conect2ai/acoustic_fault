/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.46619031e-01f, 2.17166170e-01f, 2.32710037e-02f, -1.25408471e-02f, -8.88843387e-02f, -1.18475117e-01f, 1.27652228e-01f, 5.28701246e-02f, -9.31727812e-02f, 9.96746421e-02f,
  7.62958080e-03f, -2.41267011e-01f, -2.43736342e-01f, -1.18131734e-01f, -2.01465152e-02f, 4.25948426e-02f, 7.92551413e-02f, -8.21051523e-02f, -2.74042070e-01f, -1.73919812e-01f,
  -4.81814891e-02f, 8.22479948e-02f, -4.02099267e-02f, -3.77461538e-02f, -1.77434776e-02f, -9.29057822e-02f, 3.52001972e-02f, 3.61562259e-02f, -3.92236223e-04f, 1.78704336e-01f,
  -9.26972479e-02f, 2.75383025e-01f, -8.64603370e-02f, -1.49720520e-01f, -6.96031898e-02f, -9.91328061e-03f, 7.70067517e-03f, -6.57695159e-02f, 2.71035861e-02f, -3.57587896e-02f,
  -8.58561099e-02f, 2.00811140e-02f, -4.89907749e-02f, 7.49212652e-02f, 2.02127751e-02f, -2.90232841e-02f, 8.25173706e-02f, 4.70613549e-03f, 2.04614960e-02f, 2.48939265e-02f,
  5.22031039e-02f, 1.23207085e-01f, 1.07471056e-01f, -7.63818473e-02f, -3.25211547e-02f, -7.52673820e-02f, 7.15994462e-02f, 1.23099037e-01f, -3.48804854e-02f, 1.64239660e-01f,
  -7.07113668e-02f, -2.71298494e-02f, -6.91272095e-02f, 9.97475982e-02f, -2.91881636e-02f, -1.94758046e-02f, -4.77352515e-02f, -7.28293881e-02f, -1.85829420e-02f, 3.23162638e-02f,
  -3.16475751e-03f, 7.09299296e-02f, 5.65705150e-02f, 4.19731718e-03f, -3.05716880e-02f, -4.20081131e-02f, -2.75654867e-02f, 4.25870270e-02f, -2.74749752e-02f, 5.55271544e-02f,
  -9.18885171e-02f, -7.40241185e-02f, -4.65895161e-02f, -1.39412435e-03f, 6.39646873e-03f, -5.05691245e-02f, -5.31553179e-02f, -5.29648550e-02f, -1.21042714e-01f, -5.76190799e-02f,
  -1.65785238e-01f, -1.70200262e-02f, -2.02833600e-02f, -7.46757956e-03f, 2.83896755e-02f, -7.06529245e-02f, 2.64502317e-02f, -6.78985845e-03f, 3.11760828e-02f, 7.09867626e-02f,
  5.34030236e-02f, -2.01490875e-02f, 7.04736263e-02f, -4.29074056e-02f, 1.07459780e-02f, 4.85015661e-02f, 9.37244371e-02f, 6.41288534e-02f, 1.59944557e-02f, 1.30102769e-01f,
  -2.86131888e-03f, 2.78224219e-02f, 6.08121790e-03f, -4.33188640e-02f, -6.10743538e-02f, -2.04051301e-01f, -9.07165259e-02f, -1.13790922e-01f, -7.48388618e-02f, 2.41482165e-04f,
  -2.65280813e-01f, -1.01853870e-01f, -1.45895302e-01f, -1.07907690e-01f, -8.19560289e-02f, -4.49637435e-02f, -8.29273686e-02f, -2.28633836e-01f, -1.20929427e-01f, -5.54351658e-02f,
  4.09649452e-03f, -2.24827081e-02f, -1.86475292e-01f, -2.06090994e-02f, -9.46835876e-02f, -1.21045411e-01f, -1.21281765e-01f, -5.64786084e-02f, -2.48228833e-01f, -3.76973413e-02f,
  -7.89977089e-02f, -6.63830638e-02f, -1.68474108e-01f, -3.26417536e-02f, -3.00678331e-03f, -1.73842296e-01f, -9.73652974e-02f, -5.78985028e-02f, -6.71554357e-02f, 9.45225507e-02f,
  -1.65008873e-01f, -7.31423125e-02f, -2.25255921e-01f, -8.01924020e-02f, -9.07446910e-03f, -2.45701104e-01f, -1.18341677e-01f, -8.45816508e-02f, -1.82371274e-01f, -5.02280109e-02f,
  -1.25345811e-01f, -9.70096886e-02f, -1.04766697e-01f, -2.11155321e-02f, -1.67364076e-01f, -1.28022864e-01f, -1.81056783e-01f, -9.50004384e-02f, -6.47189468e-02f, -9.29113925e-02f,
  -6.45816773e-02f, -1.07175231e-01f, -2.21256837e-02f, -1.25475660e-01f, -9.42926928e-02f, -8.39145333e-02f, -1.91475376e-01f, -1.92258015e-01f, -1.37756020e-01f, -2.42534205e-01f,
  -5.97810699e-03f, 2.01074198e-01f, 1.52847841e-01f, 1.01289265e-01f, 1.47429422e-01f, 3.64649631e-02f, 1.93268403e-01f, 1.04778387e-01f, 1.79992318e-01f, 9.20976624e-02f,
  1.37811244e-01f, 1.10117264e-01f, 1.16023451e-01f, 4.72383797e-02f, 1.30638823e-01f, 8.41940045e-02f, 5.05924299e-02f, 1.43683106e-01f, 1.15496777e-01f, 1.14284612e-01f,
  1.95063815e-01f, 3.90802659e-02f, 8.42623785e-02f, 1.06129900e-01f, 1.31555110e-01f, 1.66253313e-01f, 1.00287616e-01f, 1.00488164e-01f, -8.92329589e-03f, 1.23986885e-01f,
  -2.32546151e-01f, -9.94425863e-02f, -2.53589034e-01f, -1.79675877e-01f, -2.38589346e-01f, -9.52844769e-02f, -2.23316878e-01f, -1.14634968e-01f, -2.16089524e-02f, -1.83506832e-01f,
  -1.49195030e-01f, -2.10477382e-01f, -8.69564489e-02f, -5.04709296e-02f, -1.78212240e-01f, -2.19188005e-01f, -1.87193409e-01f, -1.90130368e-01f, -9.89311486e-02f, -1.69136882e-01f,
  -1.28919795e-01f, -1.59028754e-01f, -2.79986680e-01f, -2.08652556e-01f, -2.41812333e-01f, -1.55570641e-01f, -2.28421479e-01f, -2.87455797e-01f, -3.32362771e-01f, -3.21651608e-01f,
  4.64478105e-01f, 4.07137126e-01f, 1.78444311e-01f, 4.01221424e-01f, 2.94964880e-01f, 2.26804048e-01f, 2.22807124e-01f, 2.46844545e-01f, 2.60617256e-01f, 1.83321103e-01f,
  1.90061629e-01f, -1.74708955e-03f, 1.65795684e-01f, -2.67391279e-02f, 4.18656506e-02f, 1.16966225e-01f, 1.36906341e-01f, 1.04436874e-01f, 2.51031555e-02f, 9.74994376e-02f,
  1.34007663e-01f, 1.74763173e-01f, 1.73818618e-01f, 1.10905096e-02f, 1.60707057e-01f, 1.19900964e-02f, 2.00771719e-01f, 7.59000629e-02f, 5.20290472e-02f, 1.34114817e-01f,
  8.46105590e-02f, 3.27672809e-01f, 1.05891563e-01f, 1.33010134e-01f, 2.05979392e-01f, 2.08501860e-01f, 1.67379543e-01f, 1.53244749e-01f, 1.14589058e-01f, 2.23962039e-01f,
  2.75161922e-01f, 2.10213408e-01f, 1.27987862e-01f, 1.60236582e-01f, 2.02403232e-01f, 1.57278046e-01f, 1.78008556e-01f, 2.34763280e-01f, 1.77093431e-01f, 1.03496738e-01f,
  1.40778095e-01f, 1.52284637e-01f, 1.38239324e-01f, 1.65174827e-01f, 1.27119154e-01f, 1.73890337e-01f, 2.30815873e-01f, 1.33072302e-01f, 2.87743248e-02f, 2.09468454e-01f,
  -5.85941449e-02f, -2.74530977e-01f, -2.18218595e-01f, -6.80902377e-02f, -1.90898180e-01f, -1.60166532e-01f, -1.26676455e-01f, -1.10810384e-01f, -1.01434216e-01f, -1.53820604e-01f,
  -1.59232661e-01f, -1.39329866e-01f, -1.19689666e-01f, -1.41283916e-02f, -1.49205521e-01f, -1.30457163e-01f, -1.84423327e-01f, -1.36757478e-01f, -1.82681009e-01f, -6.38536587e-02f,
  -5.12635224e-02f, -1.17140815e-01f, -1.44720659e-01f, -2.21878961e-01f, -9.60125253e-02f, -1.11616865e-01f, -1.90691024e-01f, -1.71636537e-01f, -1.03335604e-01f, -9.71660763e-02f,
  1.26434058e-01f, 1.70620158e-01f, 2.05302149e-01f, 1.55826226e-01f, 2.40668833e-01f, 1.19317956e-01f, 2.66495824e-01f, 1.47260487e-01f, 1.96106315e-01f, 2.35071555e-01f,
  1.49956137e-01f, 1.90170467e-01f, 1.76728413e-01f, 6.06383644e-02f, 1.89953908e-01f, 9.50608477e-02f, 1.17448084e-01f, 2.40539819e-01f, 1.56222954e-01f, 1.90184787e-01f,
  1.18530273e-01f, 9.65787247e-02f, 1.65734261e-01f, 1.20678663e-01f, 1.33628175e-01f, 2.25328013e-01f, 1.40005633e-01f, 1.28952146e-01f, 5.55891506e-02f, 2.61895061e-01f,
  2.69208759e-01f, 1.37286514e-01f, 2.38371909e-01f, -9.34767798e-02f, -1.22831233e-01f, 6.71135709e-02f, 2.39547923e-01f, 4.81580123e-02f, -9.08879265e-02f, -9.67111588e-02f,
  -5.23064919e-02f, -1.83682114e-01f, -5.24293035e-02f, -4.26313579e-02f, 1.56519145e-01f, 2.01727152e-01f, 4.46787551e-02f, 1.96126878e-01f, 5.39851896e-02f, -5.87903336e-02f,
  -1.74236923e-01f, 5.12052774e-02f, 1.10797184e-02f, 5.43026254e-02f, -9.42227058e-03f, -1.32681295e-01f, 3.14112529e-02f, 3.64981219e-02f, -3.58694717e-02f, -2.98875682e-02f,
  -1.04667746e-01f, 1.70870975e-01f, -8.71517733e-02f, -1.40145585e-01f, -7.98368677e-02f, 7.67092928e-02f, 4.53808457e-02f, 7.78442295e-03f, -6.41335919e-02f, 4.84619662e-02f,
  -5.56976311e-02f, -1.77451671e-04f, -1.28861200e-02f, -1.32602332e-02f, -1.90011598e-02f, -5.84576651e-02f, -1.96448918e-02f, 1.54848754e-01f, 7.78128877e-02f, -6.54011173e-03f,
  -1.07529528e-01f, 2.77189910e-02f, 5.09055592e-02f, -1.44737624e-02f, 3.29274237e-02f, -8.45701713e-03f, 3.92080620e-02f, 1.25804842e-02f, 1.04642091e-02f, -6.32553473e-02f,
  4.74022627e-02f, 4.24693041e-02f, 4.32310663e-02f, 2.38688812e-02f, -4.95809168e-02f, -5.87443560e-02f, 1.39784822e-02f, 1.68331787e-02f, -7.23728538e-02f, 3.18301730e-02f,
  4.84320298e-02f, -3.27116400e-02f, 6.24989495e-02f, 1.96479727e-02f, -5.90884965e-03f, 3.79741751e-02f, 4.30731252e-02f, 9.42840427e-02f, 5.15573584e-02f, 6.67890236e-02f,
  -5.74700683e-02f, -2.05619936e-03f, -9.60227773e-02f, -3.26129198e-02f, 1.08230904e-01f, 3.07629001e-03f, -2.86591928e-02f, 6.94546923e-02f, 5.44658601e-02f, 5.31445667e-02f,
  -2.52647340e-01f, 4.71378081e-02f, -1.73959620e-02f, 3.29088457e-02f, 2.29370990e-03f, 6.61514187e-03f, -8.12500939e-02f, 6.40790015e-02f, 1.18488502e-02f, -4.98840250e-02f,
  3.93574238e-02f, -3.54576521e-02f, 2.31692176e-02f, 4.11272496e-02f, -6.37637964e-03f, 5.51579557e-02f, -5.41809648e-02f, 7.31124803e-02f, 1.04659304e-01f, 9.73465368e-02f,
  -7.19279703e-03f, 4.85023931e-02f, -1.44195529e-02f, 5.44015728e-02f, 7.72615150e-02f, -7.57165030e-02f, 1.40530104e-03f, -4.18815762e-02f, 1.10766822e-02f, -3.09101716e-02f,
  -9.20419395e-02f, -1.20540157e-01f, 1.52387545e-01f, -1.85718015e-02f, -1.75154328e-01f, -4.63951714e-02f, -5.72003946e-02f, -1.60812095e-01f, -8.79234076e-02f, -5.35793267e-02f,
  -3.67437661e-01f, -1.76337749e-01f, -4.68131304e-02f, -9.90024284e-02f, 9.92156342e-02f, 2.36217558e-01f, 2.32259542e-01f, 1.14383705e-01f, -5.92128979e-03f, -1.36384979e-01f,
  -1.37534395e-01f, 3.41012776e-02f, -3.30670737e-02f, -4.39353995e-02f, -3.49333659e-02f, -7.54546300e-02f, -9.06019211e-02f, -1.25033990e-01f, -1.08113494e-02f, 1.57264084e-01f,
  -2.59690080e-03f, -1.06708623e-01f, 3.34748439e-02f, -3.18705887e-02f, -1.08500049e-01f, 1.21666146e-02f, -1.51720969e-02f, 1.43123586e-02f, -1.46176621e-01f, -5.01895845e-02f,
  -7.63120055e-02f, -9.60310772e-02f, -8.48900005e-02f, -1.11943617e-01f, 4.65668552e-02f, -3.54034863e-02f, 3.81827727e-02f, -3.04805655e-02f, -1.90194231e-02f, -1.16979212e-01f,
  -9.77941677e-02f, -1.26576394e-01f, -5.07319905e-02f, -3.64732966e-02f, -1.44176900e-01f, -4.52230237e-02f, -1.36757225e-01f, -6.75981566e-02f, -8.38528574e-02f, 5.09739891e-02f,
  1.96329039e-02f, -1.45227704e-02f, 9.66545753e-03f, 7.48817297e-03f, -1.36033883e-02f, -4.14499044e-02f, -8.52323845e-02f, -5.99874444e-02f, 6.13735169e-02f, 4.08662409e-02f,
  -3.44483778e-02f, -2.01273840e-02f, -7.21933618e-02f, 2.90719997e-02f, 8.02397914e-03f, 5.04972879e-03f, -6.52822554e-02f, -8.10098425e-02f, -8.22069049e-02f, 3.06032151e-02f,
  -4.38029841e-02f, 9.20478161e-03f, -1.72479134e-02f, -6.17199987e-02f, 3.94568555e-02f, -8.19492340e-02f, -1.81770492e-02f, -8.56900066e-02f, 1.36531200e-02f, 3.30614634e-02f,
  -9.21522640e-03f, -1.09830670e-01f, 3.82460020e-02f, -8.65281373e-02f, -1.14188403e-01f, -9.53934714e-02f, -9.31834579e-02f, -7.37349540e-02f, -1.45637482e-01f, -9.88935158e-02f,
  -1.16498262e-01f, -4.94510122e-02f, -9.74201187e-02f, -6.80826530e-02f, 5.36667854e-02f, -1.12142656e-02f, -1.15878105e-01f, 1.53546240e-02f, -6.74356744e-02f, -4.43911068e-02f,
  1.74159440e-03f, -4.62676138e-02f, 7.29512563e-03f, -6.20406196e-02f, -8.66213217e-02f, -1.88398249e-02f, -1.60965305e-02f, 1.26275485e-02f, -1.79229975e-02f, 1.18788794e-01f,
  -1.96201101e-01f, 2.97610283e-01f, -3.73289078e-01f, 7.72747546e-02f, -1.30124167e-02f, -2.84239948e-01f, -1.46817774e-01f, -2.76697129e-02f, 7.46868178e-02f, 1.07742094e-01f,
  1.03326254e-01f, 8.31703618e-02f, 2.04674434e-02f, -7.40752444e-02f, -2.14822680e-01f, -7.43631199e-02f, -2.09194943e-01f, -2.46091545e-01f, -2.73027420e-01f, -4.92769517e-02f,
  1.46925405e-01f, 1.48472056e-01f, -9.05447304e-02f, -1.54514040e-03f, 2.56741792e-01f, 1.51853308e-01f, -7.70132616e-02f, 5.45317121e-02f, -1.07049663e-02f, 1.63100153e-01f,
  8.37149769e-02f, -1.69697367e-02f, -1.60147380e-02f, 1.45914406e-01f, 3.99715751e-02f, 3.50973047e-02f, 4.58977371e-02f, 1.01980798e-01f, -4.55553941e-02f, -1.74647868e-02f,
  1.00889310e-01f, -1.00883294e-03f, 7.65346289e-02f, 1.09909818e-01f, -3.87575962e-02f, 4.74268533e-02f, 1.29199354e-02f, -8.48117396e-02f, -6.30666241e-02f, 8.12618360e-02f,
  9.81489345e-02f, 3.70175317e-02f, -4.54340130e-02f, -8.93031135e-02f, -1.85281113e-01f, -6.62585273e-02f, 8.88559129e-03f, -4.92281690e-02f, -1.71457544e-01f, 1.63940012e-01f,
  1.28983617e-01f, -1.86229832e-02f, 1.51217291e-02f, 3.98454703e-02f, -4.18080902e-03f, 2.32627690e-02f, -8.37226957e-03f, -2.82754153e-02f, -4.53059375e-02f, 1.54995158e-01f,
  -1.27074746e-02f, -9.70262811e-02f, -1.11627160e-02f, -5.10391667e-02f, 5.28764911e-02f, -4.58987057e-02f, -2.03141868e-02f, 5.04283533e-02f, -1.28622297e-02f, -7.11841369e-03f,
  5.34765348e-02f, -1.39432937e-01f, 4.34586443e-02f, -3.28410380e-02f, 1.63153280e-02f, -9.13405791e-02f, 1.97695591e-03f, 4.99817841e-02f, 2.70762406e-02f, 4.27445024e-02f,
  2.18363911e-01f, -2.25689963e-01f, 1.00061685e-01f, 1.72743220e-02f, -2.95303538e-02f, -1.10910628e-02f, 2.34536361e-02f, -6.13687485e-02f, 4.03979681e-02f, 6.88956352e-03f,
  -7.92951062e-02f, -1.13448240e-02f, -2.60127354e-02f, -2.34956648e-02f, 2.22647772e-03f, 5.48547432e-02f, 6.31183982e-02f, -9.08009533e-04f, -8.35729539e-02f, 5.28238108e-03f,
  -2.94624958e-02f, 4.84319963e-02f, -8.38819612e-03f, -4.16025966e-02f, 8.81236494e-02f, -8.67855400e-02f, 5.65302558e-02f, 3.13915871e-02f, -7.79994875e-02f, 9.70446467e-02f,
  -2.19440877e-01f, -4.85421903e-02f, -2.14405164e-01f, -9.85145718e-02f, -1.22029133e-01f, -2.31915608e-01f, -1.43801928e-01f, -2.99159102e-02f, -1.13293692e-01f, -1.46369129e-01f,
  -2.46369466e-02f, -1.20470382e-01f, -1.95030510e-01f, -2.86585838e-01f, -3.44486952e-01f, -3.05944055e-01f, -3.56947690e-01f, -3.68784308e-01f, -2.97132194e-01f, -1.12374574e-01f,
  -1.48820162e-01f, -1.94065720e-02f, -1.56940296e-01f, -7.03958943e-02f, -9.18673631e-03f, -1.02917053e-01f, -2.03001760e-02f, -3.05467378e-02f, -1.45151570e-01f, -6.66032359e-02f,
  -3.67578149e-01f, -6.76016062e-02f, -5.51935881e-02f, -1.81026489e-01f, -1.08133569e-01f, -5.95768169e-02f, -5.04415259e-02f, 5.12880944e-02f, 2.72920877e-02f, -1.05223298e-01f,
  -7.42286369e-02f, -4.54223864e-02f, -1.03062987e-02f, -9.64013413e-02f, -1.86493702e-03f, -1.22944340e-01f, -1.13289006e-01f, -4.77335267e-02f, -5.47250137e-02f, -1.29002288e-01f,
  -9.23962072e-02f, -4.51329090e-02f, -1.44326404e-01f, -2.34911423e-02f, -7.60096759e-02f, -1.15797371e-01f, -1.08846076e-01f, -1.15455955e-01f, -5.56147378e-03f, -3.58103663e-02f,
  -7.98820853e-02f, 8.67058709e-02f, 3.07470020e-02f, 1.59101874e-01f, 1.32375378e-02f, 1.43490031e-01f, 6.52466640e-02f, 6.29936084e-02f, 7.54334182e-02f, 1.44921705e-01f,
  1.02934822e-01f, 4.61724438e-02f, 5.60662150e-02f, 9.87782776e-02f, 1.67086080e-01f, 1.39854297e-01f, -9.04526375e-03f, 1.53616562e-01f, 1.28120899e-01f, 1.03499569e-01f,
  1.10717900e-01f, 1.16159558e-01f, 2.01956049e-01f, 1.08061947e-01f, 9.75511670e-02f, 5.10363169e-02f, 3.06260139e-02f, 1.23217419e-01f, 4.76560369e-02f, 1.68946102e-01f,
  -4.48227674e-02f, 2.78673274e-03f, -1.51177913e-01f, -6.46573827e-02f, -6.87177852e-02f, -3.87534295e-04f, -1.22944992e-02f, -9.26483348e-02f, -1.23708835e-02f, -9.40933004e-02f,
  -2.77368799e-02f, -1.26907928e-02f, -8.95779282e-02f, 5.25161885e-02f, -1.35655925e-01f, -1.12777971e-01f, -5.89684136e-02f, -8.23328793e-02f, -3.84770893e-02f, -9.55146700e-02f,
  -5.54295033e-02f, -1.90826252e-01f, -1.97321951e-01f, -1.49402216e-01f, -1.57681406e-01f, -2.07314476e-01f, -1.41556978e-01f, -1.56372175e-01f, -1.82237282e-01f, -8.72476250e-02f,
  2.00908214e-01f, -1.86711803e-01f, -1.40703395e-01f, -1.77543685e-02f, -6.66344687e-02f, 1.83241982e-02f, -1.26016393e-01f, 8.57130140e-02f, 3.09899356e-02f, -1.42502949e-01f,
  -8.26896504e-02f, 6.42033368e-02f, -4.64788824e-02f, 8.38318933e-03f, 9.10245478e-02f, -7.25321993e-02f, -1.22257791e-01f, -5.64189553e-02f, 2.13649750e-01f, -3.05413958e-02f,
  -4.55127321e-02f, 1.12777501e-02f, -2.21908018e-02f, 4.17280532e-02f, -2.70146728e-01f, -2.63176952e-02f, -2.48305067e-01f, -1.36337250e-01f, -1.88119665e-01f, -2.74311930e-01f,
  -2.66745567e-01f, -5.59669957e-02f, 1.41780913e-01f, 9.15005580e-02f, -7.21349195e-02f, 1.09164700e-01f, 3.18000019e-02f, 1.55959859e-01f, -1.33447498e-02f, -6.25192225e-02f,
  -2.06644200e-02f, 4.92306128e-02f, 4.53569517e-02f, -1.74671877e-03f, 7.05970451e-02f, 1.68412216e-02f, 9.84788910e-02f, -4.62434441e-02f, 2.47635636e-02f, -1.00630753e-01f,
  -6.35392517e-02f, 8.22705179e-02f, 1.05888741e-02f, 8.85333568e-02f, -1.11214463e-02f, 7.69560710e-02f, -1.02077164e-01f, -5.65933250e-02f, 1.02826752e-01f, -4.73031178e-02f,
  6.84285909e-02f, 1.01157101e-02f, -8.53637308e-02f, 2.58234665e-02f, -6.88114911e-02f, -2.84391176e-03f, -6.00622036e-02f, -2.95193493e-02f, -1.21566025e-03f, -3.31500918e-02f,
  -1.04181476e-01f, -1.85906868e-02f, 4.04792838e-02f, -7.84072354e-02f, 4.64803539e-03f, 4.08378392e-02f, -1.35929650e-02f, -2.01216470e-02f, 2.22694539e-02f, 3.35562192e-02f,
  3.46068176e-03f, -3.73216309e-02f, -2.88057365e-02f, 6.00318722e-02f, -2.99421977e-02f, 8.38749576e-03f, 5.50244711e-02f, -5.51750064e-02f, -1.63311958e-02f, -6.83867261e-02f,
  9.26022753e-02f, 1.42231494e-01f, -1.01009030e-02f, -2.75851879e-03f, 3.00451666e-02f, 1.00008018e-01f, 2.89231595e-02f, 4.64221835e-02f, 8.90520960e-02f, -3.98616306e-02f,
  -4.46633697e-02f, 1.09928206e-01f, -3.59536484e-02f, -6.59854524e-03f, 8.37174580e-02f, 9.31803584e-02f, 8.84379297e-02f, 5.18209450e-02f, 1.38044939e-03f, -5.14662042e-02f,
  1.07884727e-01f, 8.20132717e-02f, 1.20245308e-01f, 1.89006887e-02f, -3.42453755e-02f, 6.00082017e-02f, -1.06232129e-01f, 7.48911053e-02f, 1.52093738e-01f, 6.85336068e-02f,
  -5.41660786e-01f, -6.35159388e-02f, 3.36591303e-01f, -2.12795377e-01f, 1.21975109e-01f, 2.31336460e-01f, 2.22893968e-01f, 1.54071599e-01f, -1.31235803e-02f, 5.60676344e-02f,
  -1.11634314e-01f, -2.15849116e-01f, -7.34059140e-03f, -7.07796589e-02f, 3.90656777e-02f, 2.71995962e-01f, 1.57068014e-01f, 5.45785055e-02f, 3.36641222e-02f, -2.34542321e-02f,
  -1.05272196e-01f, -1.43573433e-01f, -1.57775730e-01f, -9.29334201e-03f, 6.38862373e-03f, -4.14770059e-02f, 1.57994777e-01f, 7.46390447e-02f, -8.56926478e-03f, 2.68911961e-02f,
  1.57639623e-01f, -1.82216223e-02f, 1.07833706e-01f, -1.44339219e-01f, 1.15140371e-01f, -5.85776009e-02f, -1.32068638e-02f, 1.04744747e-01f, -3.40412445e-02f, -7.49446126e-03f,
  -7.65223056e-02f, -6.16518408e-03f, -9.20849368e-02f, -1.72004346e-02f, 5.00335246e-02f, 9.55695694e-04f, 8.88352469e-03f, -6.45086728e-03f, 1.90020781e-02f, 8.02461430e-02f,
  -2.48412825e-02f, -6.54515438e-03f, 1.17457688e-01f, 1.27055898e-01f, 1.52666852e-01f, -1.55457724e-02f, 1.52302906e-01f, 6.44746702e-03f, 6.04372062e-02f, 1.13009602e-01f,
  -1.83998514e-02f, -5.00548035e-02f, 5.34316860e-02f, 5.35624437e-02f, 1.61341168e-02f, -2.44227350e-02f, -3.39055359e-02f, -2.81300750e-02f, -2.22259620e-03f, 4.60064076e-02f,
  6.01005554e-02f, 3.85356918e-02f, 2.49146577e-02f, 2.79473513e-02f, -8.00528470e-03f, 2.99346801e-02f, 4.23927903e-02f, 2.84785852e-02f, 1.47501361e-02f, -4.47591767e-02f,
  -3.12628113e-02f, 1.01426439e-02f, 9.20804497e-03f, 1.75802466e-02f, -1.52606936e-02f, 7.59895444e-02f, 5.69232255e-02f, -1.62583441e-02f, -9.76507142e-02f, -6.55850321e-02f,
  2.46528778e-02f, 6.13278598e-02f, 2.25908961e-03f, -6.43711835e-02f, 5.78151494e-02f, 3.45635936e-02f, -1.53252007e-02f, 2.10105255e-02f, 3.08943037e-02f, 3.36337537e-02f,
  2.25342321e-03f, 2.74206372e-03f, -2.34944988e-02f, 3.16180885e-02f, 8.08596669e-04f, -4.78473939e-02f, 1.08247194e-02f, 4.02811952e-02f, 7.00251162e-02f, -2.98983138e-02f,
  2.62065902e-02f, -9.76386108e-03f, -7.04678297e-02f, 1.52467713e-01f, 4.74479934e-03f, 1.15413759e-02f, 1.73144519e-01f, 1.15608044e-01f, -1.82807702e-03f, 1.34884089e-01f,
  -4.42645997e-01f, 8.80720541e-02f, 2.35110335e-03f, -1.38449952e-01f, -8.21993221e-03f, -1.64137647e-01f, -1.27482027e-01f, -2.58424878e-01f, -6.05792291e-02f, -8.41729194e-02f,
  8.85973349e-02f, 1.52400471e-02f, -6.73533306e-02f, 6.06206320e-02f, -2.50207514e-01f, -1.06380126e-02f, 1.13056123e-01f, -1.44218177e-01f, -2.44801044e-01f, -1.99098766e-01f,
  6.68407157e-02f, -9.15693045e-02f, -2.59299845e-01f, -3.86259072e-02f, 1.39151275e-01f, -4.32918034e-02f, 1.75957028e-02f, 1.16866127e-01f, 1.72077477e-01f, 2.66622126e-01f,
  3.96601018e-03f, -3.17673087e-02f, 4.68462445e-02f, 1.81796756e-02f, 8.47990438e-02f, -1.58201650e-01f, -1.80991869e-02f, -2.40288116e-02f, -8.92799124e-02f, -5.64481132e-03f,
  -1.81350969e-02f, 5.65875731e-02f, -1.39338776e-01f, -4.30712663e-02f, -6.76938370e-02f, -1.22788884e-01f, -1.01983242e-01f, -7.82548785e-02f, 4.04565297e-02f, 6.69780150e-02f,
  1.26487508e-01f, 3.05393785e-02f, -1.07186958e-01f, -1.02075920e-01f, -9.40375179e-02f, 4.40952703e-02f, 6.13266882e-03f, -1.96755398e-02f, -4.62281033e-02f, -9.28528830e-02f,
  -4.26626354e-02f, 6.10290058e-02f, 1.07335478e-01f, -4.12581041e-02f, 2.98667569e-02f, 9.63648111e-02f, 1.35532334e-01f, 4.77440432e-02f, 3.18005532e-02f, 4.61472496e-02f,
  6.93778470e-02f, 2.67891766e-04f, 8.12506303e-02f, 1.25530120e-02f, 1.08111441e-01f, 8.53968412e-02f, 3.78317647e-02f, 9.22352821e-03f, 6.13714308e-02f, -3.75695638e-02f,
  2.63743866e-02f, 1.12090573e-01f, 2.27492955e-02f, -1.98895391e-03f, 1.68436378e-01f, 1.31972432e-01f, -2.10963320e-02f, 6.97417650e-03f, 6.80356622e-02f, 3.88961099e-02f,
  -2.10268989e-01f, -3.93985026e-02f, -6.58654422e-02f, -1.59214437e-02f, -7.58610293e-02f, 8.24331716e-02f, 1.49567779e-02f, 3.34301628e-02f, 4.58395854e-02f, -1.02650188e-01f,
  6.29985183e-02f, -1.44032240e-01f, -1.03372097e-01f, 6.19354285e-02f, -5.03136627e-02f, 2.55317381e-03f, -2.74283113e-03f, -3.59516665e-02f, 4.17555533e-02f, -4.08020243e-02f,
  -4.68669049e-02f, -6.36293963e-02f, -1.13863282e-01f, -4.84081246e-02f, -3.42419706e-02f, -1.43984914e-01f, -7.48608708e-02f, -1.02883250e-01f, -1.51872516e-01f, -1.28116861e-01f,
  1.53901652e-01f, 1.28390014e-01f, 6.26520514e-02f, 1.78270400e-01f, 1.00302726e-01f, 9.47259739e-02f, 1.58877388e-01f, 1.47771254e-01f, 2.12793812e-01f, 1.28785461e-01f,
  4.64907549e-02f, 1.55677721e-01f, 1.48495540e-01f, 1.05026886e-01f, 2.19896287e-01f, 2.53751904e-01f, 2.22387537e-01f, 3.65033746e-01f, 2.95046747e-01f, 2.40742549e-01f,
  1.14918843e-01f, 1.44222423e-01f, 1.57858357e-01f, 2.17509940e-01f, 8.17051455e-02f, 2.18350470e-01f, 8.05088580e-02f, 1.29881918e-01f, 5.61403334e-02f, 1.65245235e-01f,
  1.30935451e-02f, 1.05063684e-01f, 2.08115950e-01f, 3.41220409e-01f, 1.15942709e-01f, 1.85168207e-01f, 1.44977927e-01f, 2.35500231e-01f, 2.71415532e-01f, 1.88469917e-01f,
  2.41140664e-01f, 2.14798659e-01f, 2.93635488e-01f, 1.27432555e-01f, 1.47366807e-01f, 2.48095065e-01f, 2.60463715e-01f, 2.48102099e-01f, 1.42741874e-01f, 2.38141760e-01f,
  1.68657809e-01f, 1.12229742e-01f, 1.91845089e-01f, 1.37022585e-01f, 2.07853317e-01f, 1.94471240e-01f, 1.96072727e-01f, 2.19911456e-01f, 1.22014098e-01f, 1.23937741e-01f,
  -8.87329653e-02f, -1.22960620e-01f, -1.03273287e-01f, -2.39506483e-01f, -1.79117948e-01f, -2.11623117e-01f, -1.92519456e-01f, -1.39398411e-01f, -1.14760496e-01f, -1.20913312e-01f,
  -1.33794576e-01f, -1.30321681e-01f, -2.35670850e-01f, -1.03044137e-01f, -1.36014014e-01f, -4.60635163e-02f, -1.24231376e-01f, -7.03195706e-02f, -6.41946867e-02f, -5.23341522e-02f,
  -1.28784299e-01f, -4.19518463e-02f, -9.70475525e-02f, -3.43542993e-02f, -1.42017245e-01f, -1.67350292e-01f, -1.69608831e-01f, -9.39954445e-02f, -1.95799060e-02f, -9.00124088e-02f,
  2.06089839e-01f, 3.04056764e-01f, 2.81250507e-01f, 2.73432642e-01f, 3.16347986e-01f, 3.24008793e-01f, 2.62081802e-01f, 2.31911555e-01f, 2.61052489e-01f, 2.39833400e-01f,
  2.16585547e-01f, 2.57780373e-01f, 1.58637375e-01f, 1.72992736e-01f, 3.14029306e-01f, 2.87140220e-01f, 2.38854408e-01f, 2.71591216e-01f, 2.81686127e-01f, 1.10742636e-01f,
  3.15243423e-01f, 3.48093927e-01f, 3.60361606e-01f, 1.73053458e-01f, 1.65049329e-01f, 3.74155879e-01f, 3.33378077e-01f, 2.37024128e-01f, 2.16930613e-01f, 2.94156253e-01f,
  3.88632476e-01f, -3.30020547e-01f, -5.83398417e-02f, 2.45076463e-01f, -2.38928087e-02f, -1.92432359e-01f, -2.11267978e-01f, -1.60027444e-02f, -3.05244438e-02f, -8.32593590e-02f,
  -1.45879343e-01f, 1.43488534e-02f, -8.08897540e-02f, -5.29910438e-02f, -5.15572466e-02f, -5.99252693e-02f, -1.39979526e-01f, 1.03332587e-01f, 8.83029178e-02f, 9.17173699e-02f,
  2.17375681e-02f, 2.06334621e-01f, 2.08648726e-01f, -2.95521319e-02f, -5.71448766e-02f, 3.10274120e-02f, -1.12385191e-01f, 3.13849114e-02f, -1.56312212e-01f, 5.94857819e-02f,
  6.56890422e-02f, 7.11452290e-02f, 1.07600413e-01f, 1.76611077e-02f, 2.62787882e-02f, -1.25137083e-02f, -5.82066551e-02f, 1.67804435e-01f, 1.26140974e-02f, 3.05598769e-02f,
  -5.62870279e-02f, 3.86778302e-02f, -1.54239638e-02f, -1.22560589e-02f, 7.06950426e-02f, 4.65007834e-02f, -3.36456560e-02f, 1.00200012e-01f, 3.91930826e-02f, 2.06892043e-02f,
  -1.65375769e-01f, -9.68637094e-02f, 4.25114222e-02f, -1.69621229e-01f, -1.52594540e-02f, -6.67409450e-02f, -8.67014229e-02f, 1.58181656e-02f, -1.37599796e-01f, 1.11159049e-01f,
  -6.42780662e-02f, -1.12300158e-01f, -1.17743365e-01f, 1.06898032e-01f, 2.48378683e-02f, 5.47119789e-02f, -1.70748103e-02f, 2.02643760e-02f, -7.66426846e-02f, 8.94805975e-03f,
  3.86097394e-02f, 1.88848544e-02f, -5.54435179e-02f, 1.23334508e-02f, -4.56043296e-02f, -6.26151860e-02f, -2.56444477e-02f, -6.14397004e-02f, -2.84360107e-02f, 5.80613799e-02f,
  -2.40574609e-02f, -5.55071328e-03f, -2.88816690e-02f, 4.46482515e-03f, -1.21553101e-01f, 3.79689261e-02f, -9.52351198e-04f, -9.73739848e-02f, 4.79789488e-02f, -1.63950976e-02f,
  5.50301597e-02f, -2.01018363e-01f, 4.01458442e-02f, -3.78021523e-02f, -4.11933325e-02f, -9.66945942e-03f, -1.55823305e-02f, -5.28666414e-02f, -2.93491445e-02f, 5.15469685e-02f,
  -8.16413760e-02f, 1.68913249e-02f, -1.31340370e-01f, 2.64638085e-02f, -1.78579204e-02f, 4.48469669e-02f, -9.77629647e-02f, -5.42617626e-02f, -4.24564220e-02f, 4.61923182e-02f,
  -5.80559624e-03f, 5.67163303e-02f, 1.15903713e-01f, 4.14457358e-03f, -7.68556446e-02f, -7.92729557e-02f, -3.37916128e-02f, 1.53944092e-02f, -4.33639577e-03f, 1.11857407e-01f,
  -1.84748143e-01f, 2.18451783e-01f, 1.56420365e-01f, -1.08300827e-01f, -4.39405181e-02f, -9.98886600e-02f, -1.51815951e-01f, -2.09809989e-01f, -1.79860100e-01f, 1.17102601e-01f,
  7.74597898e-02f, 6.04440346e-02f, 3.43900882e-02f, 7.93367848e-02f, -1.56139582e-01f, 3.34488526e-02f, 1.11544142e-02f, -9.66080949e-02f, -1.03573062e-01f, -1.17163524e-01f,
  2.29523592e-02f, -5.84231094e-02f, -1.64287668e-02f, -5.44817448e-02f, 1.03751615e-01f, -8.42408761e-02f, 4.95078936e-02f, 6.88190609e-02f, 4.99850847e-02f, 7.68423378e-02f,
  2.04390734e-01f, -2.99305972e-02f, -1.23197287e-01f, 1.71153918e-02f, 1.13138445e-02f, 8.33730213e-04f, -4.10873909e-04f, 4.51461505e-03f, -5.91584994e-03f, -7.94802532e-02f,
  6.10235333e-02f, -4.78816368e-02f, -4.19904105e-02f, 4.60039116e-02f, 5.64249121e-02f, -9.09314975e-02f, -9.20493528e-03f, -6.04181550e-02f, -6.92255199e-02f, -7.15018949e-04f,
  1.26230232e-02f, 8.35588016e-03f, 3.47015895e-02f, -1.94892883e-02f, -8.90231356e-02f, -1.08599544e-01f, -4.80524078e-02f, -8.66726860e-02f, -1.89482030e-02f, 3.06239817e-02f,
  7.83124492e-02f, 1.87118221e-02f, -8.15062746e-02f, -1.24292914e-03f, -1.82411894e-02f, -1.35568276e-01f, 4.77808639e-02f, -5.09656444e-02f, 5.14249764e-02f, -6.26300350e-02f,
  5.49340695e-02f, 7.75831379e-03f, 7.85761178e-02f, 6.24439958e-03f, 7.29931667e-02f, -5.26251718e-02f, 2.50395276e-02f, 2.38023000e-03f, 1.07134017e-03f, -9.71388966e-02f,
  -3.21635865e-02f, -9.60682482e-02f, -1.25251740e-01f, 4.10145484e-02f, -6.01849221e-02f, -2.64649093e-03f, 2.55224365e-03f, -8.03131331e-03f, -1.97035931e-02f, -3.38497311e-02f,
  7.87919536e-02f, -1.14498697e-01f, -5.91215901e-02f, -5.86066730e-02f, -3.96722257e-02f, -5.62466159e-02f, -2.17176694e-02f, 6.15301132e-02f, -8.05404224e-03f, -2.29185652e-02f,
  -1.11234207e-02f, -9.21357330e-03f, 6.51988536e-02f, -1.47287047e-03f, -4.97823320e-02f, -7.14639649e-02f, -1.17234923e-01f, 2.40961239e-02f, -9.90223959e-02f, 1.13616344e-02f,
  -4.38582674e-02f, -8.65290985e-02f, -2.04170514e-02f, 5.05323848e-03f, -1.11800551e-01f, -1.43643752e-01f, -1.73701271e-02f, 1.49731282e-02f, -1.42422274e-01f, -8.18290114e-02f,
  -3.35442007e-01f, -1.10439494e-01f, 4.40454930e-02f, -1.22585312e-01f, 1.42155677e-01f, 1.62868157e-01f, 7.80256614e-02f, -4.21173386e-02f, 1.44647751e-02f, -1.90028064e-02f,
  -1.18211031e-01f, 3.76036838e-02f, -6.05336875e-02f, 7.60596432e-03f, 7.96140507e-02f, 2.07813438e-02f, 6.06065094e-02f, 1.67323560e-01f, 2.35083804e-01f, 1.27019033e-01f,
  -3.85156907e-02f, -1.16654083e-01f, -1.91746727e-01f, -5.11324666e-02f, -1.00838400e-01f, 8.97878706e-02f, -2.72927945e-03f, -1.82005391e-01f, -5.41267879e-02f, -1.57711893e-01f,
  -1.95722312e-01f, -8.67987201e-02f, 1.50910467e-01f, 6.29873052e-02f, 2.91322116e-02f, -4.95914072e-02f, -1.72396302e-02f, -2.28135381e-02f, -1.11298729e-02f, 1.02990158e-02f,
  9.61848814e-03f, -3.90991382e-02f, 9.53595117e-02f, 5.96675165e-02f, 4.70363684e-02f, 3.04529816e-02f, -8.73378143e-02f, 1.21028041e-02f, 9.85256433e-02f, -5.51149771e-02f,
  2.58156657e-02f, -3.49298269e-02f, 1.31137008e-02f, 1.22370735e-01f, 1.04307249e-01f, 9.69352797e-02f, -6.77031651e-02f, -6.99650422e-02f, 9.52448174e-02f, -2.11226746e-01f,
  -1.19924615e-03f, -8.37693363e-02f, -1.52952981e-03f, -7.09788278e-02f, 4.45513055e-02f, 2.65615135e-02f, -3.33312675e-02f, -7.08657652e-02f, -3.83708328e-02f, -7.90556073e-02f,
  -4.24709497e-03f, -5.05605265e-02f, 6.86300453e-03f, -8.02728906e-02f, -1.07850775e-01f, 1.42278308e-02f, -9.54302251e-02f, -3.50501090e-02f, 4.77377214e-02f, -7.69829378e-02f,
  -4.33504581e-02f, 3.98004567e-03f, -7.78725147e-02f, -2.28042156e-02f, -2.43012514e-02f, 1.79743953e-03f, -2.86084954e-02f, -5.16534038e-02f, -1.77552048e-02f, 2.71265730e-02f,
  -1.17158547e-01f, 1.58158660e-01f, 2.37297360e-02f, 7.08263144e-02f, -1.58583820e-02f, 6.98627084e-02f, -3.97286415e-02f, 3.65604162e-02f, 4.35731523e-02f, -5.89317866e-02f,
  2.90806941e-03f, -1.43778080e-03f, -1.63374692e-02f, 4.47001383e-02f, -8.92922748e-03f, -2.23405920e-02f, -1.41087305e-02f, -3.00929677e-02f, -6.88116066e-03f, 5.98295964e-02f,
  8.64942968e-02f, 7.67755732e-02f, 7.41474926e-02f, 9.36758965e-02f, 6.65960908e-02f, 1.71559155e-01f, 3.17242891e-02f, -1.58021320e-02f, 4.29680273e-02f, -1.69027701e-01f,
  -4.43362035e-02f, -2.91291356e-01f, 1.07134961e-01f, 3.77990343e-02f, -3.66916484e-03f, 1.85756758e-02f, -6.70812279e-02f, 2.39884271e-03f, -1.15267932e-02f, 4.56485897e-02f,
  -1.71798885e-01f, -1.00404926e-01f, 5.95218092e-02f, -6.41023144e-02f, -5.52109443e-02f, -6.20806217e-02f, -1.42956786e-02f, -6.01851419e-02f, 3.78780812e-02f, -1.88916095e-03f,
  6.08026609e-02f, -3.20815966e-02f, -3.38773578e-02f, 3.58327031e-02f, 5.66998087e-02f, 1.91209629e-01f, 1.80295467e-01f, 1.60003696e-02f, 7.36386105e-02f, -1.20923087e-01f,
  1.29075095e-01f, -1.99601725e-01f, 9.79806930e-02f, -1.25031099e-02f, -8.63013193e-02f, -9.02022123e-02f, -8.74931291e-02f, -1.68950465e-02f, -1.86962634e-02f, -7.72302002e-02f,
  -9.42649543e-02f, 1.62116077e-04f, -4.44616601e-02f, 1.17071858e-02f, 1.09403618e-02f, -1.70263108e-02f, -2.41544825e-04f, -4.25290205e-02f, 5.79391830e-02f, 3.43217514e-02f,
  -1.13950342e-01f, -1.21385030e-01f, -1.73057355e-02f, 7.46708885e-02f, -2.58546099e-02f, 3.88321504e-02f, 3.21611054e-02f, 8.69020745e-02f, 8.69674186e-05f, 1.88950866e-01f,
  4.12182463e-03f, -3.08713894e-02f, -1.47539843e-02f, 7.08409324e-02f, 1.25804946e-01f, 2.40793247e-02f, 9.49147269e-02f, 2.61955373e-02f, 1.99527182e-02f, -5.64562455e-02f,
  -2.09337976e-02f, 2.90691457e-03f, 6.41649365e-02f, 3.25512816e-03f, 1.78205222e-02f, -1.07089989e-01f, -1.91365257e-02f, 1.66916642e-02f, 1.98942125e-02f, -2.10850649e-02f,
  2.14019492e-02f, -6.69121966e-02f, -7.03300983e-02f, -1.03184491e-01f, 1.56955086e-02f, 4.61023040e-02f, 4.78473213e-03f, 9.04758461e-03f, -2.28292402e-02f, -3.49995829e-02f,
  6.87279031e-02f, -1.65891589e-03f, 2.04343293e-02f, -5.30626588e-02f, 7.37126991e-02f, 6.07195906e-02f, 5.59876971e-02f, -2.19219644e-02f, 2.89618634e-02f, 3.71664134e-03f,
  8.70219246e-02f, -1.32333031e-02f, 8.85790810e-02f, 8.36984441e-02f, 1.52991757e-01f, 5.37598357e-02f, -1.03859603e-02f, 9.50252861e-02f, -9.05721821e-03f, 4.14673164e-02f,
  9.92461890e-02f, 1.23737708e-01f, 9.95967537e-02f, 1.80892155e-01f, 3.75162177e-02f, 1.16237789e-01f, 2.06359297e-01f, 8.56178850e-02f, 2.03841940e-01f, 2.68360227e-01f,
  -2.04552487e-01f, 9.12541002e-02f, -3.72412242e-02f, 5.41647263e-02f, 1.93936080e-01f, -3.24913487e-02f, 3.53800058e-02f, -2.54229214e-02f, 2.72528380e-02f, 8.70820656e-02f,
  6.60181195e-02f, -8.93244669e-02f, -4.92121372e-03f, -1.10821396e-01f, -2.71090180e-01f, -3.41065079e-02f, 5.21324053e-02f, -1.98492363e-01f, -2.73166865e-01f, -3.25815752e-02f,
  1.04088917e-01f, 1.18839685e-02f, -1.00241983e-02f, -1.57692097e-02f, 1.64184466e-01f, 2.31225342e-02f, 1.46672189e-01f, 1.93617433e-01f, 1.33111119e-01f, 2.18976125e-01f,
  -1.02405958e-01f, -2.46988907e-02f, -4.60195541e-02f, -8.83164704e-02f, -6.10590316e-02f, -1.24085926e-01f, -9.80213806e-02f, -1.18420452e-01f, 6.36047497e-02f, -6.43705204e-03f,
  1.14576571e-01f, -2.71937530e-02f, 7.52239525e-02f, 4.12725508e-02f, 7.20890537e-02f, 5.64070381e-02f, -2.47196946e-02f, -6.50507659e-02f, -1.42576367e-01f, -1.90611873e-02f,
  1.96918368e-01f, 9.38661024e-02f, 6.20786939e-03f, -1.19491495e-01f, -2.68500391e-02f, -1.46843139e-02f, 3.86617631e-02f, -6.57674074e-02f, -1.52390510e-01f, 3.66846435e-02f,
  -5.09963408e-02f, -3.77585553e-02f, 2.99317744e-02f, -4.68251072e-02f, -1.41762234e-02f, 3.71190198e-02f, -4.14516591e-02f, -6.19128160e-02f, -5.83035015e-02f, 8.36431533e-02f,
  -5.96904270e-02f, -6.00913502e-02f, -1.01078808e-01f, -5.59808537e-02f, -1.02214962e-01f, -3.91865708e-02f, -7.74548128e-02f, -1.04330011e-01f, -2.70104278e-02f, 3.94103937e-02f,
  -2.16403976e-02f, -1.21583566e-01f, 8.25060159e-03f, -1.06288224e-01f, -1.07540399e-01f, -4.50795926e-02f, 1.70789063e-02f, -1.31437093e-01f, -1.46394566e-01f, 3.05974334e-02f,
  -1.01944797e-01f, -1.83599174e-01f, -2.69583296e-02f, -3.35278250e-02f, 9.33823735e-03f, -7.69278333e-02f, -5.05723581e-02f, -1.22418910e-01f, -1.23023786e-01f, -1.20158121e-01f,
  -2.17859726e-02f, -5.73717989e-02f, 2.37522405e-02f, 9.04145837e-02f, -3.31972577e-02f, -4.78908047e-02f, -3.42653394e-02f, 3.91531996e-02f, -1.03571609e-01f, -1.07100112e-02f,
  3.55545692e-02f, -5.99170774e-02f, -6.46799207e-02f, -1.22298285e-01f, -3.98979820e-02f, -1.19758449e-01f, -5.51354587e-02f, -1.18597664e-01f, -2.12880477e-01f, -1.18061706e-01f,
  -1.40808940e-01f, -1.75149307e-01f, 1.84090480e-01f, -2.36918509e-01f, 6.13008440e-02f, 2.76608616e-01f, 1.23744555e-01f, -5.02084866e-02f, -9.24420878e-02f, -1.35073736e-01f,
  -3.99342068e-02f, 9.89122242e-02f, -2.94399057e-02f, 8.06579925e-03f, 6.60272986e-02f, 9.07170847e-02f, -1.44637544e-02f, 2.27960661e-01f, 2.19277233e-01f, 9.13027301e-02f,
  -5.11592701e-02f, -2.02922404e-01f, -2.91953105e-02f, -5.91617189e-02f, -7.15162382e-02f, -3.35532799e-02f, -1.61981523e-01f, -2.34969817e-02f, -6.03019148e-02f, -1.26297623e-01f,
  2.65676707e-01f, 5.22393212e-02f, 8.17584097e-02f, -9.65394527e-02f, -3.19394772e-03f, -1.28972093e-02f, 1.24259010e-01f, 5.80455735e-03f, 7.64895082e-02f, -6.23728931e-02f,
  4.41319384e-02f, 1.03757055e-02f, 5.54458983e-02f, -7.42725050e-03f, 4.09776308e-02f, 6.35514185e-02f, 4.47317176e-02f, -1.91249279e-03f, 9.12629515e-02f, 2.78590713e-02f,
  3.06666959e-02f, -7.69610107e-02f, 1.79661095e-01f, 4.36939386e-04f, 4.45017293e-02f, 2.61632111e-02f, 2.94531807e-02f, 1.64514687e-02f, 1.30555600e-01f, -1.37981117e-01f,
  5.35829701e-02f, -2.85308119e-02f, 8.68795887e-02f, -7.99178034e-02f, -5.04435301e-02f, -2.67224219e-02f, 1.13222957e-01f, 7.69981509e-03f, 8.96201953e-02f, 1.14275143e-02f,
  5.92021160e-02f, -4.47474159e-02f, 3.15388367e-02f, 4.30616271e-03f, -4.70692962e-02f, -2.55824830e-02f, 5.26884431e-03f, -2.24098731e-02f, 1.21244021e-01f, -3.42351198e-02f,
  5.31465970e-02f, 5.41746281e-02f, 3.37809138e-03f, 8.89390633e-02f, 7.32631534e-02f, -9.28957108e-03f, -2.01728530e-02f, 3.72998938e-02f, -7.23952129e-02f, -4.12319303e-02f,
  -3.24507765e-02f, 9.23033878e-02f, 4.34369110e-02f, 1.34046093e-01f, 5.57766072e-02f, -2.63327658e-02f, 4.71369848e-02f, 2.83878017e-02f, -2.61138268e-02f, 2.47004349e-02f,
  2.81422380e-02f, 1.41383111e-01f, 5.58157638e-02f, 4.54987846e-02f, 1.26342222e-01f, 5.18183373e-02f, -7.96234794e-03f, 2.45241281e-02f, 6.57930672e-02f, 8.00106823e-02f,
  -1.03979018e-02f, 4.59179468e-02f, 1.75467536e-01f, 1.39554456e-01f, 2.70542828e-03f, 4.21787205e-04f, 1.34292305e-01f, 1.09398134e-01f, 1.12473235e-01f, 2.40337104e-02f,
  -2.23978698e-01f, -2.00072035e-01f, -2.02816263e-01f, 2.37701591e-02f, 2.57833507e-02f, 4.80729789e-02f, -1.56141222e-01f, -6.68052733e-02f, 1.34648224e-02f, -3.77545357e-02f,
  1.50474548e-01f, 2.10215986e-01f, 1.84694454e-01f, 1.32841513e-01f, -3.31779979e-02f, -2.19274476e-01f, -2.33145207e-01f, -4.53358702e-02f, 1.49854450e-02f, 6.43893927e-02f,
  7.96840806e-03f, 3.74591351e-02f, -5.23472019e-02f, -9.24036130e-02f, 4.79878634e-02f, 1.66807830e-01f, -7.23782554e-02f, -8.42665657e-02f, -7.76531920e-03f, -6.24967478e-02f,
  7.14142574e-03f, -1.57697782e-01f, 1.06774084e-01f, 7.93722048e-02f, 7.00596860e-03f, -5.44553176e-02f, -3.22788879e-02f, -1.38112912e-02f, 3.79302688e-02f, -3.80525067e-02f,
  1.38624862e-01f, -7.37313228e-03f, 1.18937351e-01f, 6.91665523e-03f, -3.46675701e-02f, -5.65744005e-02f, -6.12342432e-02f, -1.24997683e-01f, 2.39042975e-02f, 1.78903639e-02f,
  6.00739568e-02f, 6.42523244e-02f, -6.51877075e-02f, -1.40265860e-02f, -1.57505739e-02f, 1.15039796e-01f, -5.51109686e-02f, -1.28184482e-02f, -1.08947391e-02f, -1.62485212e-01f,
  7.46104419e-02f, 4.02290188e-02f, 1.61053129e-02f, -7.88557678e-02f, 8.80856253e-03f, -2.78068911e-02f, -6.02629371e-02f, -5.45420730e-03f, 5.33230901e-02f, -8.08174387e-02f,
  -5.50431646e-02f, 7.92345963e-03f, -1.80170946e-02f, 1.98977580e-03f, 6.56541213e-02f, -2.94647366e-02f, 7.50550255e-02f, -9.74996239e-02f, -5.85109787e-03f, 2.42591538e-02f,
  4.30769995e-02f, 5.72229885e-02f, -1.36412904e-01f, -2.64355149e-02f, -9.94501486e-02f, 5.18763252e-03f, -5.93225248e-02f, -1.98636148e-02f, -9.12969187e-02f, -3.04556433e-02f,
  4.06584330e-02f, 1.66379467e-01f, -1.15806036e-01f, -6.48016483e-02f, 8.78242031e-02f, 2.89629549e-02f, 4.81340326e-02f, 2.50798669e-02f, 1.43437432e-02f, -1.46580730e-02f,
  -6.76976144e-02f, 1.16674034e-02f, 3.71902585e-02f, 2.46405858e-03f, 7.46700317e-02f, -4.42556664e-02f, 5.72385490e-02f, 1.16727315e-01f, 1.70966703e-02f, -5.80467395e-02f,
  4.12511751e-02f, -8.19994435e-02f, 5.64249232e-02f, -3.67238075e-02f, -6.52885884e-02f, 1.25911981e-01f, -5.65747265e-03f, 6.94727302e-02f, 4.80687320e-02f, -1.11646406e-01f,
  5.85595518e-02f, -1.39553323e-01f, 1.05332501e-01f, 6.42450154e-02f, 1.67204127e-01f, -1.00643253e-02f, -2.01633841e-01f, 8.28026086e-02f, 1.05363868e-01f, 7.42098689e-02f,
  1.52165636e-01f, 4.44557846e-01f, 4.11819190e-01f, 3.21103871e-01f, 2.31941283e-01f, -1.07626833e-01f, 5.98642267e-02f, 2.14769825e-01f, 3.99609745e-01f, 1.56057015e-01f,
  1.87923133e-01f, 1.46031186e-01f, 1.75211459e-01f, 1.03792809e-01f, -1.71943940e-02f, 1.80459425e-01f, -1.61398239e-02f, 2.90155616e-02f, -2.87526846e-03f, 1.09201844e-03f,
  2.10857183e-01f, -5.03432043e-02f, 2.97058016e-01f, 8.75492617e-02f, 1.35752633e-01f, 7.97019526e-03f, 1.39971450e-01f, 6.88018203e-02f, 8.45184550e-02f, 6.25870228e-02f,
  7.71573707e-02f, 1.70860544e-01f, 5.49174994e-02f, 1.05662674e-01f, 1.99764576e-02f, 5.64713068e-02f, 9.28986818e-02f, 1.69302404e-01f, 1.20948121e-01f, 4.76135574e-02f,
  6.82736337e-02f, 6.05127250e-04f, 9.54672098e-02f, 9.16182697e-02f, 1.64344251e-01f, 1.57087207e-01f, 1.15577690e-01f, -2.17709541e-02f, 7.76426420e-02f, 1.77030992e-02f,
  -1.31415978e-01f, -8.54699239e-02f, -3.40302698e-02f, -1.35491908e-01f, -1.70448184e-01f, -9.54800546e-02f, -1.03295565e-01f, -1.47709638e-01f, -2.39279177e-02f, -1.29290298e-01f,
  -1.11909300e-01f, -8.17649290e-02f, -8.81610811e-02f, -9.26717669e-02f, -5.22370860e-02f, -1.77309394e-01f, -1.61740571e-01f, -1.12363264e-01f, -1.00141235e-01f, -1.61665663e-01f,
  -9.60216373e-02f, -1.26858070e-01f, -7.36335814e-02f, -8.12255368e-02f, -1.76932946e-01f, -1.02147967e-01f, -1.19928420e-01f, -4.86989357e-02f, -9.48766097e-02f, -9.89193320e-02f,
  1.91722497e-01f, 2.05562428e-01f, 8.86498392e-02f, 1.18829668e-01f, 5.48372716e-02f, 8.25316459e-02f, 1.79195285e-01f, 7.34900534e-02f, 1.24908179e-01f, 8.67666751e-02f,
  1.66935340e-01f, 7.14647248e-02f, 1.86868817e-01f, 1.58269587e-03f, 1.53608993e-01f, 1.90273121e-01f, 6.26049563e-02f, 1.02495991e-01f, 1.50749356e-01f, 5.34955040e-02f,
  5.34200892e-02f, 4.26880307e-02f, 2.07625464e-01f, 1.00248724e-01f, 7.25676268e-02f, 1.36478245e-01f, 1.27606854e-01f, 3.91991362e-02f, 7.88006559e-02f, -1.60119221e-01f,
  -4.45054203e-01f, 1.44104630e-01f, -4.23101895e-02f, -1.93879858e-01f, 5.28497361e-02f, -6.53509330e-03f, 1.79343313e-01f, -1.26714930e-01f, -1.65364116e-01f, -2.46306718e-03f,
  -8.86663795e-02f, -1.10103771e-01f, -1.49441212e-01f, -1.69260964e-01f, -2.53003865e-01f, 5.29948361e-02f, 9.65678170e-02f, -2.90042102e-01f, -3.59586835e-01f, -8.79981145e-02f,
  6.69637322e-02f, -1.89907942e-02f, -2.60959387e-01f, -1.06098086e-01f, 1.47484392e-01f, -3.20876166e-02f, 1.26158491e-01f, 6.69653788e-02f, 6.77049756e-02f, 1.84910059e-01f,
  2.49939077e-02f, -2.02675939e-01f, -1.40863389e-01f, -1.32430375e-01f, -9.66584906e-02f, -1.19442068e-01f, -1.23188362e-01f, -7.71413893e-02f, -1.85306177e-01f, -2.78569702e-02f,
  -1.70564473e-01f, -1.34395808e-01f, -1.81436464e-01f, -1.36058167e-01f, -1.77240983e-01f, -2.02987045e-01f, -5.68385683e-02f, -1.58571199e-01f, -2.02237919e-01f, -6.02584183e-02f,
  3.54191922e-02f, -9.53084454e-02f, -1.19561963e-01f, -1.05907679e-01f, -3.66368070e-02f, -1.86378926e-01f, -4.59427722e-02f, -1.48260683e-01f, -1.32407993e-01f, 6.65924028e-02f,
  5.16444519e-02f, 4.24369648e-02f, 3.69347744e-02f, 8.12318251e-02f, 7.36093596e-02f, 1.47970453e-01f, 4.04430255e-02f, 3.51599567e-02f, 9.13673118e-02f, 1.10343166e-01f,
  -9.77568794e-03f, 1.15260176e-01f, 1.51499026e-02f, 4.92166169e-02f, 1.44165397e-01f, 3.25678959e-02f, 3.55337523e-02f, 1.02848776e-01f, 3.94368358e-02f, 7.34540001e-02f,
  -1.77770462e-02f, 8.61807987e-02f, 1.93360597e-01f, 1.26845524e-01f, 4.78959046e-02f, 5.82174361e-02f, 5.76700233e-02f, 5.27210124e-02f, 9.29293334e-02f, 1.30396456e-01f,
  -2.45249327e-02f, -9.99218971e-02f, -8.39235410e-02f, -2.19911858e-01f, -2.77977660e-02f, -1.31254837e-01f, -9.93957072e-02f, -1.20545879e-01f, -1.76784366e-01f, -1.81009352e-01f,
  -1.48160800e-01f, -1.32427052e-01f, -1.41471662e-02f, -9.01825204e-02f, -8.68756995e-02f, -6.34205714e-02f, -1.70954578e-02f, -3.87932882e-02f, -1.55070886e-01f, -1.82804111e-02f,
  -2.79441923e-02f, -6.47491515e-02f, -1.46805778e-01f, -9.66099352e-02f, -1.67539164e-01f, -2.29464710e-01f, -5.84842265e-02f, -5.48404828e-02f, -1.89236134e-01f, 1.57381240e-02f,
  -4.55185205e-01f, -7.65620917e-02f, -1.25370860e-01f, -1.66310728e-01f, 9.22783539e-02f, 2.63384819e-01f, 2.13977218e-01f, 1.50079191e-01f, -1.85326803e-02f, 2.10453421e-02f,
  6.92695454e-02f, -9.29763913e-02f, -6.83662295e-02f, -7.96332303e-03f, -1.91252343e-02f, -3.06305569e-02f, -3.08670048e-02f, -2.22553626e-01f, 4.11191732e-02f, 2.45138798e-02f,
  1.11355737e-01f, -1.30256891e-01f, -1.00480944e-01f, 4.15635966e-02f, -1.19123735e-01f, 2.42015682e-02f, -3.75749208e-02f, -6.58421889e-02f, 9.96269882e-02f, -2.14409530e-01f,
  -1.75954327e-01f, -2.40464777e-01f, 7.91520905e-03f, -2.19237097e-02f, -1.67401269e-01f, -1.08419754e-01f, -2.62413099e-02f, -6.77546263e-02f, 1.48456087e-02f, -1.22861847e-01f,
  -1.49861202e-01f, -1.43659055e-01f, -1.19947255e-01f, -1.03604980e-01f, -2.85889469e-02f, -1.76765881e-02f, -1.29249036e-01f, -1.37639791e-01f, -9.93693471e-02f, -9.15315077e-02f,
  1.31102391e-02f, -1.29855052e-01f, -5.73087223e-02f, 1.01834759e-02f, -1.16664201e-01f, -6.77359998e-02f, 5.73426485e-03f, -6.71784654e-02f, -9.01881456e-02f, -4.51412797e-02f,
  1.37361348e-01f, 7.55190551e-02f, 1.49139017e-01f, 7.08201751e-02f, 1.51519760e-01f, 3.26892696e-02f, 1.64490957e-02f, 1.13257214e-01f, 1.02558739e-01f, 2.94858459e-02f,
  8.35826397e-02f, 1.50293403e-03f, 1.43456951e-01f, 4.05565463e-03f, 1.08066708e-01f, -3.35691385e-02f, 5.21445870e-02f, 6.66874126e-02f, -6.11375272e-03f, 1.22118846e-01f,
  -2.07418185e-02f, -5.86156501e-03f, 4.03031195e-03f, 1.15087345e-01f, 7.69510120e-02f, 5.62125631e-02f, -5.00603504e-02f, 7.80889392e-02f, 9.29419547e-02f, 5.03918864e-02f,
  2.61236075e-02f, 3.68588082e-02f, -5.55445515e-02f, -2.84982622e-02f, -3.43135446e-02f, -7.54856691e-02f, -9.21418071e-02f, -1.26709834e-01f, -9.07986388e-02f, -4.59430330e-02f,
  -9.64413285e-02f, -2.70393621e-02f, 3.12136509e-03f, -7.18465820e-02f, 1.12379566e-02f, -6.73439354e-02f, -3.59974131e-02f, 8.23282171e-03f, 5.07527664e-02f, -4.78969067e-02f,
  -3.98670994e-02f, -3.64853209e-03f, -6.20933287e-02f, 1.08852707e-01f, 8.40473697e-02f, -7.41940811e-02f, 7.89782554e-02f, -8.78397375e-02f, -4.99448366e-02f, 1.11299008e-01f,
  -1.36912987e-01f, -7.30355754e-02f, -1.11120187e-01f, 1.06565945e-01f, 4.71587852e-02f, -1.61518335e-01f, -2.85302788e-01f, -1.17813170e-01f, 1.30981341e-01f, -6.68587163e-02f,
  -4.40675579e-03f, -2.64148731e-02f, 2.98708659e-02f, 1.88648775e-02f, -1.32767826e-01f, -1.19220339e-01f, -1.25541985e-02f, -6.61171600e-02f, -2.45891929e-01f, -1.16219036e-01f,
  1.08191729e-01f, 3.11281886e-02f, -6.65521435e-03f, 4.03195284e-02f, 1.70500323e-01f, -1.19920252e-02f, 2.24218853e-02f, 6.68556839e-02f, -3.85299921e-02f, 1.18536979e-01f,
  -1.13358177e-01f, 5.44559443e-03f, -1.00529119e-01f, 5.06831100e-03f, -1.07653691e-02f, 2.11586542e-02f, -6.38650060e-02f, 6.42401278e-02f, -1.03082828e-01f, -7.78612867e-02f,
  -4.63009849e-02f, -2.39178613e-02f, -2.17477195e-02f, -6.12185039e-02f, -6.15887791e-02f, -1.59741372e-01f, -2.00039387e-01f, -6.46000057e-02f, 2.57307403e-02f, -1.40339941e-01f,
  8.93722251e-02f, 7.61055481e-03f, -1.92014918e-01f, -7.95401558e-02f, -1.04115956e-01f, -6.45189285e-02f, -4.47231233e-02f, -8.28822702e-02f, -1.08323306e-01f, -6.15678616e-02f,
  -3.84297259e-02f, -7.62433410e-02f, -7.54003152e-02f, -1.09664593e-02f, -7.06165880e-02f, -4.10881750e-02f, 9.58840735e-03f, 4.09564897e-02f, -5.98202050e-02f, -4.74743545e-02f,
  -3.68620604e-02f, -3.10854875e-02f, 1.56210259e-01f, 1.39526188e-01f, 1.87394880e-02f, -7.14602843e-02f, 2.67903414e-02f, 4.68059592e-02f, 2.91006379e-02f, 4.06879000e-03f,
  9.36422423e-02f, 9.58424807e-03f, -2.19842382e-02f, 6.04824051e-02f, 1.83363426e-02f, 7.62990937e-02f, -1.08855627e-02f, -1.87589729e-03f, -5.69224358e-02f, 6.43200502e-02f,
  -1.26794383e-01f, 1.13009930e-01f, -1.27665848e-01f, -6.24551885e-02f, 6.60443306e-02f, 4.52729315e-02f, 1.20712318e-01f, 1.09987669e-02f, 8.57800841e-02f, -2.49197762e-02f,
  3.00269350e-02f, -9.46614295e-02f, -7.98220411e-02f, -1.51914179e-01f, 1.03299031e-02f, -7.19984919e-02f, -1.18744299e-01f, -2.24927031e-02f, 6.21090829e-02f, 1.70382112e-02f,
  -1.33165624e-02f, -1.00269191e-01f, -6.18696213e-02f, -1.58534035e-01f, -1.06855677e-02f, -1.00759499e-01f, -1.25371367e-01f, -8.83666873e-02f, -1.89988554e-01f, -2.19748184e-01f,
  2.00495631e-01f, -1.54412732e-01f, 1.39500812e-01f, 5.05507179e-02f, -1.96817189e-01f, -8.35737884e-02f, -1.19255014e-01f, -5.71077168e-02f, -6.48873821e-02f, -9.70100015e-02f,
  -1.77453607e-01f, -1.33852452e-01f, -1.32831916e-01f, -1.11975893e-01f, -1.90060642e-02f, 1.06548615e-01f, 1.32361665e-01f, 4.88231629e-02f, 8.22011847e-03f, -1.83865026e-01f,
  -2.80548006e-01f, -1.50013179e-01f, 4.47562821e-02f, -8.14820826e-02f, -1.56858608e-01f, -1.23690069e-01f, -2.07894951e-01f, -1.26703218e-01f, -1.33160740e-01f, 2.26903297e-02f,
  -1.07891150e-01f, -8.60746652e-02f, -1.85311228e-01f, -2.46350020e-01f, -1.42136127e-01f, -1.17227904e-01f, -1.52471200e-01f, -1.59271508e-01f, -1.64533257e-01f, -5.18173762e-02f,
  -1.46034032e-01f, -1.81583166e-01f, -1.85002282e-01f, -2.44412690e-01f, -8.81187245e-02f, -9.02470574e-02f, 2.05103606e-02f, -6.03979826e-02f, -4.19880673e-02f, -6.50901794e-02f,
  -9.98487622e-02f, -1.96270227e-01f, -1.04450159e-01f, -1.93716124e-01f, -1.50526732e-01f, -8.13225657e-02f, -2.80457735e-01f, -1.78139538e-01f, -2.36073941e-01f, -1.20779209e-01f,
  1.30768448e-01f, 1.85060024e-01f, 2.11885363e-01f, 1.50899783e-01f, 2.35045210e-01f, 1.38079748e-01f, 1.93235591e-01f, 1.57286912e-01f, 1.39810115e-01f, 1.83185488e-01f,
  1.56950787e-01f, 1.57320112e-01f, 2.30913147e-01f, 9.69573557e-02f, 2.35260516e-01f, 2.80207306e-01f, 1.60872102e-01f, 1.69145882e-01f, 1.12869866e-01f, 1.59315988e-01f,
  2.09741384e-01f, 2.06143305e-01f, 1.88097447e-01f, 1.34838551e-01f, 1.43654063e-01f, 1.89362347e-01f, 1.31893575e-01f, 7.73624629e-02f, 2.35934570e-01f, 1.84410572e-01f,
  -1.96987376e-01f, -1.66365638e-01f, -9.42248106e-02f, -9.96898264e-02f, -8.79965425e-02f, -2.39129022e-01f, -1.32714644e-01f, -2.14318961e-01f, -7.93595687e-02f, -1.09524712e-01f,
  -2.11169928e-01f, -1.04852445e-01f, -1.62101761e-01f, -8.72490630e-02f, -9.74592194e-02f, -7.06160590e-02f, -6.10095114e-02f, -6.35101944e-02f, -1.87941894e-01f, -1.74358517e-01f,
  -1.30413249e-01f, -1.63344275e-02f, -1.29524223e-03f, -1.06038362e-01f, -1.54570296e-01f, -1.01936050e-01f, -2.42719695e-01f, -1.51666194e-01f, -1.12631105e-01f, -2.00293183e-01f,
  3.18753928e-01f, -1.86006054e-01f, 2.02570051e-01f, -4.43071127e-02f, 2.03454625e-02f, 5.23927510e-02f, 1.32371217e-01f, 9.65131670e-02f, -1.60450950e-01f, -6.93225339e-02f,
  -4.76263128e-02f, 4.40544114e-02f, 5.50202793e-03f, 5.56240343e-02f, 2.21486747e-01f, -7.83660561e-02f, -1.14330992e-01f, 1.37042597e-01f, 2.73523808e-01f, 7.64626935e-02f,
  -1.11417934e-01f, -2.18806788e-02f, 5.20412773e-02f, 8.16620439e-02f, -2.11751029e-01f, -1.14414655e-02f, -2.12472826e-01f, -5.25757335e-02f, -5.52537758e-03f, -2.62953252e-01f,
  6.17500246e-02f, 1.35783866e-01f, 5.20871878e-02f, 9.60678533e-02f, 7.52340630e-02f, -2.91473009e-02f, 4.38782312e-02f, 6.38609156e-02f, -7.68496189e-03f, -4.56709927e-03f,
  -1.02764919e-01f, 3.89943086e-02f, 1.39124781e-01f, -5.38315531e-03f, -3.58809233e-02f, 1.27921522e-01f, -2.67920587e-02f, 1.02534018e-01f, 1.43368706e-01f, 7.58824274e-02f,
  5.23157828e-02f, 1.46964505e-01f, 1.77246302e-01f, 1.70176048e-02f, 2.77376808e-02f, 3.04726325e-02f, 1.31539643e-01f, -2.24921275e-02f, 1.96718663e-01f, -1.07039906e-01f,
  -9.35102254e-02f, -6.14039786e-02f, 7.09868968e-02f, 5.55227995e-02f, -4.46680747e-02f, -3.97511721e-02f, 2.19131894e-02f, -4.92952093e-02f, -3.68871652e-02f, -1.58591978e-02f,
  6.56788051e-02f, 4.25204838e-04f, -6.87577948e-02f, 4.18241769e-02f, -1.02731220e-01f, -7.27723585e-03f, -4.54382040e-03f, 4.43407632e-02f, -1.94081143e-02f, 7.07543343e-02f,
  1.06329426e-01f, -1.63179170e-02f, -2.34181359e-02f, 7.02975541e-02f, 4.73348424e-02f, 1.16778342e-02f, -1.82042795e-03f, -3.79182422e-03f, 1.44596193e-02f, 4.15723957e-02f,
  -2.24024013e-01f, 2.60385782e-01f, 1.19143333e-02f, -4.85973526e-03f, -4.77405712e-02f, -3.02341450e-02f, -2.70517692e-02f, 7.37180784e-02f, -2.69235726e-02f, 1.48146953e-02f,
  1.35571077e-01f, 1.67217050e-02f, 3.17283161e-02f, 6.40380755e-02f, -1.26875890e-02f, -4.61054184e-02f, -5.31096905e-02f, 4.38615978e-02f, -3.54349278e-02f, -3.23375575e-02f,
  -4.41708751e-02f, -1.49255563e-02f, 3.26463878e-02f, -6.88746572e-02f, 2.83934996e-02f, 9.10068974e-02f, 2.25889799e-03f, -9.55123529e-02f, 1.19118318e-01f, -1.67394042e-01f,
  -1.26533404e-01f, -1.40329695e-03f, -7.57794455e-02f, -1.15297347e-01f, -1.14764877e-01f, -2.06175715e-01f, -3.15629721e-01f, -3.24281678e-02f, -6.92038164e-02f, -1.67816937e-01f,
  -9.47187543e-02f, -6.29669353e-02f, -1.09270543e-01f, -1.84734240e-02f, 2.62096599e-02f, -1.73660457e-01f, -1.22451290e-01f, 6.51711598e-02f, -1.25138136e-02f, -1.14259459e-01f,
  -1.75280377e-01f, 6.71694577e-02f, 8.92574936e-02f, 1.65750280e-01f, 8.39313567e-02f, -1.17748424e-01f, 5.59352078e-02f, -2.97275148e-02f, -7.87439868e-02f, -2.82470845e-02f,
  -1.63428664e-01f, 3.81253138e-02f, -3.99384610e-02f, -5.12045175e-02f, -2.38406826e-02f, 4.70883325e-02f, 3.15931663e-02f, 6.75109699e-02f, -5.42699285e-02f, 7.47620761e-02f,
  -2.64896657e-02f, 2.08545458e-02f, -7.77751431e-02f, 6.23396635e-02f, 1.76472627e-02f, 8.57132673e-02f, 1.37646630e-01f, 3.20570730e-02f, 7.55320415e-02f, 3.35166641e-02f,
  4.14089821e-02f, 1.07971160e-02f, -5.72131872e-02f, 5.76407788e-03f, 3.29396427e-02f, -6.03443682e-02f, -2.17641275e-02f, 2.56034266e-02f, 5.66163063e-02f, 1.18903399e-01f,
  -2.89860759e-02f, 5.15718050e-02f, -3.69715877e-02f, 8.53925198e-02f, 3.84763232e-03f, -3.84979025e-02f, 3.51480581e-02f, 1.16013400e-02f, 9.96832829e-03f, 3.71572077e-02f,
  -1.43267540e-02f, 6.20373152e-02f, 7.31086582e-02f, 3.61050367e-02f, 8.85927230e-02f, -3.48786078e-02f, 3.60314175e-02f, -1.43122077e-02f, 8.05095881e-02f, -7.78972283e-02f,
  -1.51238414e-02f, 5.84751088e-03f, 5.38753122e-02f, 4.39906120e-02f, 8.35106000e-02f, 3.22930329e-02f, 1.35704070e-01f, 9.04707462e-02f, 1.93108879e-02f, 1.32567719e-01f,
  -1.96465909e-01f, 4.34849896e-02f, -1.47587910e-01f, 6.47631809e-02f, 3.01979743e-02f, -2.22404581e-02f, -1.00889340e-01f, 6.33667856e-02f, -1.89099628e-02f, -7.78503120e-02f,
  3.47857252e-02f, 2.74302019e-03f, -1.27330884e-01f, 3.94856445e-02f, -7.89748132e-02f, -6.31653741e-02f, -7.63957128e-02f, -7.48762414e-02f, 2.60747969e-02f, -9.89278182e-02f,
  -5.54491207e-02f, -1.26315162e-01f, -2.11219698e-01f, -1.69276550e-01f, -6.64759502e-02f, -1.48584679e-01f, -1.36712223e-01f, 3.16071301e-03f, -8.75804871e-02f, -1.62342265e-01f,
  -6.38061687e-02f, 1.76566392e-01f, -1.21042039e-02f, 1.58566788e-01f, 1.43726155e-01f, -2.05795895e-02f, 1.18317530e-01f, -3.78841199e-02f, -9.77807026e-03f, 1.54405698e-01f,
  2.93664746e-02f, -6.39187098e-02f, -1.29801378e-01f, -9.68049318e-02f, -1.72962859e-01f, 5.97998984e-02f, -4.27845828e-02f, -5.38515449e-02f, -2.00328037e-01f, -4.86244028e-03f,
  1.53326681e-02f, -2.20346451e-02f, -1.74182221e-01f, -7.29145557e-02f, -1.06263570e-01f, -8.32073539e-02f, -1.06483303e-01f, 5.19115105e-03f, -7.44832307e-02f, 6.37828410e-02f,
  1.26289472e-01f, -7.62355551e-02f, -1.52846575e-01f, -2.26238832e-01f, -5.05779199e-02f, -1.70065448e-01f, -1.12995833e-01f, -2.01311946e-01f, -1.71005026e-01f, -1.15343839e-01f,
  -1.02674335e-01f, -1.00871153e-01f, -1.35521777e-02f, -8.41011852e-02f, 2.12931097e-03f, -5.42582013e-03f, -1.18724950e-01f, -1.49059817e-01f, -5.47727197e-02f, -7.36171156e-02f,
  -7.91657425e-04f, -1.07913122e-01f, -8.14883858e-02f, -1.21966675e-01f, -1.71277046e-01f, -1.17792726e-01f, -4.52874079e-02f, -2.12903112e-01f, -2.16448486e-01f, -3.17721777e-02f,
  2.00163290e-01f, 1.28561229e-01f, 1.14878882e-02f, 4.65787947e-02f, 8.19474757e-02f, 1.05390601e-01f, 2.85175629e-02f, 5.87022044e-02f, 4.48384248e-02f, 8.05912167e-02f,
  7.41348863e-02f, 2.76121311e-02f, 4.27251570e-02f, 1.24542251e-01f, -2.86447001e-03f, 1.03465751e-01f, 7.17622191e-02f, 1.45940939e-02f, 6.95393905e-02f, -7.92170390e-02f,
  -1.49947153e-02f, 4.22799736e-02f, 1.42148938e-02f, 3.30557004e-02f, -2.35249735e-02f, -4.97673415e-02f, 6.53056130e-02f, -6.20490722e-02f, -1.00662224e-02f, -4.07322533e-02f,
  1.22411676e-01f, -2.57112324e-01f, -8.69218707e-02f, -9.16378349e-02f, -1.95856288e-01f, -1.69475630e-01f, -5.21977730e-02f, -9.89030227e-02f, -1.88710704e-01f, -1.52328059e-01f,
  -3.72538306e-02f, -5.54002598e-02f, -3.79917994e-02f, -8.47320631e-02f, -2.02535167e-02f, -1.32797897e-01f, -1.37982182e-02f, -3.88949178e-02f, -8.18140283e-02f, -6.18424825e-02f,
  -2.67574508e-02f, -1.05672650e-01f, -2.08876212e-03f, -1.58449560e-01f, -1.61486998e-01f, -7.31161460e-02f, -1.19863376e-01f, -1.67359516e-01f, -1.39907494e-01f, -8.21608454e-02f,
  -4.31628644e-01f, -1.57092050e-01f, 1.96841419e-01f, -1.16982125e-01f, 1.28397420e-01f, 2.71762848e-01f, 2.97777146e-01f, 7.97059014e-02f, -1.08110517e-01f, 6.98397234e-02f,
  -1.66108847e-01f, -1.12815298e-01f, -5.21447733e-02f, -8.16607103e-02f, 1.31624624e-01f, 1.26370221e-01f, 1.94330812e-01f, 1.86107866e-03f, 1.88649252e-01f, 1.38262242e-01f,
  2.38067806e-02f, -8.23196843e-02f, -1.98731750e-01f, -1.01664048e-02f, -7.36275911e-02f, 6.38670847e-02f, -3.96155054e-03f, -1.38001308e-01f, -5.88937243e-03f, -5.13835438e-02f,
  1.71565004e-02f, -2.65753001e-01f, -1.94572527e-02f, -1.29551694e-01f, -1.16542965e-01f, -4.17503864e-02f, -2.12759487e-02f, -1.50043830e-01f, -4.51977253e-02f, -6.29537851e-02f,
  -9.23133567e-02f, -5.67520484e-02f, 9.79908556e-03f, -1.57059245e-02f, -1.96721703e-02f, -8.13221782e-02f, -7.96355382e-02f, -1.13599874e-01f, -6.65912330e-02f, -2.26220731e-02f,
  -7.42525831e-02f, 3.23542603e-03f, -1.62499622e-02f, 9.13498178e-02f, 2.70679425e-02f, -1.34345721e-02f, 1.56115340e-02f, -1.34813711e-01f, -3.96300964e-02f, -1.62525669e-01f,
  -4.48719785e-02f, 1.43124580e-01f, 1.27279207e-01f, -2.24039350e-02f, 4.43576388e-02f, 3.13057937e-02f, 3.44817303e-02f, 9.79479253e-02f, 3.25466655e-02f, 4.05003875e-02f,
  -1.30734658e-02f, 6.16500005e-02f, -2.02695783e-02f, -1.66745298e-02f, 4.45936806e-02f, 2.57204119e-02f, 7.60889053e-02f, -5.63624650e-02f, 9.67578497e-03f, -1.59897003e-02f,
  6.95947781e-02f, 1.84932991e-03f, 2.02799886e-02f, -4.83274087e-03f, 2.76512057e-02f, -9.11288261e-02f, 4.79618348e-02f, 3.12727876e-02f, 9.25375521e-02f, -3.30055654e-02f,
  1.24528864e-02f, -5.27271479e-02f, -1.36729419e-01f, -7.56095499e-02f, -6.52563423e-02f, -1.06104366e-01f, -7.67550990e-02f, -8.76753107e-02f, -1.84736177e-01f, 1.77049022e-02f,
  -1.28801167e-02f, -9.06778406e-03f, -9.13525522e-02f, -2.86958404e-02f, 9.27480496e-03f, 1.87718496e-02f, -8.00985321e-02f, 1.06898397e-02f, 7.56875379e-04f, -3.81034352e-02f,
  -6.38991669e-02f, 1.65529996e-02f, 1.33312494e-01f, -1.90761052e-02f, -7.97915682e-02f, 1.51575822e-02f, 7.92609379e-02f, 7.06625953e-02f, -6.11901423e-03f, 1.18910633e-01f,
  -4.42129254e-01f, -3.84858460e-03f, 1.27022699e-01f, -1.76326275e-01f, 4.29045036e-03f, 8.32787380e-02f, 7.57255256e-02f, -1.24527976e-01f, -1.90449223e-01f, 1.87255591e-02f,
  2.32809819e-02f, -7.51329884e-02f, 4.62926105e-02f, 9.84255075e-02f, 1.06341802e-01f, 1.48238018e-01f, 1.96272537e-01f, 1.89891547e-01f, 3.13080586e-02f, -4.37432900e-02f,
  5.98448887e-02f, -1.00271344e-01f, -1.85502097e-01f, -9.26035866e-02f, 3.88151519e-02f, 5.68265319e-02f, 2.67214440e-02f, 4.39229757e-02f, 1.22113965e-01f, 1.27958938e-01f,
  1.41884744e-01f, -6.52282536e-02f, 1.01195917e-01f, 1.28827589e-02f, 4.75425571e-02f, -5.88156432e-02f, -2.61873845e-02f, -3.48679945e-02f, -6.20139241e-02f, 2.88944878e-02f,
  9.33409482e-02f, -4.17377204e-02f, 1.39425203e-01f, 1.22840308e-01f, -5.41169792e-02f, -1.56333088e-03f, 2.31531207e-02f, -5.83557002e-02f, -2.95060594e-03f, 8.00493825e-03f,
  1.33087501e-01f, 5.40290885e-02f, 1.27326906e-01f, 1.17461503e-01f, 8.12468752e-02f, 1.26909822e-01f, 1.57418072e-01f, 1.44239321e-01f, 1.08461440e-01f, 4.86086980e-02f,
  -1.86994318e-02f, 3.31316777e-02f, 7.07169771e-02f, 2.39611566e-02f, -8.45554322e-02f, -1.37148863e-02f, 9.72086564e-02f, 8.78059492e-02f, 1.93427801e-02f, 1.44421896e-02f,
  1.34536589e-03f, -2.26585455e-02f, 1.19113885e-02f, 5.52290156e-02f, -3.33634345e-03f, 4.91663516e-02f, 6.30754000e-03f, 1.80798303e-02f, 9.88237280e-03f, 3.88084985e-02f,
  3.87485474e-02f, 7.09750131e-02f, -4.69332561e-02f, 7.87632614e-02f, 2.03705970e-02f, 4.10527065e-02f, 3.40963192e-02f, -1.50072575e-02f, -4.13626917e-02f, -3.24318893e-02f,
  -2.63933778e-01f, 1.21050879e-01f, 4.07161824e-02f, 5.61050214e-02f, 4.01291735e-02f, -3.96681763e-03f, 1.31565094e-01f, 7.58357793e-02f, 1.09880447e-01f, 3.86951379e-02f,
  5.65855838e-02f, 5.51429503e-02f, 1.19207706e-02f, 1.02566458e-01f, 2.97874454e-02f, -2.15803552e-02f, 2.44091675e-02f, 6.03486821e-02f, 5.45320325e-02f, 5.44867665e-02f,
  4.31721192e-03f, 6.24915883e-02f, -8.77997205e-02f, 5.90682030e-02f, -4.25463244e-02f, 2.63807327e-02f, -2.67922902e-03f, 7.72121176e-02f, 8.34649503e-02f, -1.45702407e-01f,
  -1.65107906e-01f, 1.73298985e-01f, 1.02740675e-01f, 1.59865677e-01f, 1.38341472e-01f, 2.56762118e-03f, 1.03630327e-01f, -8.79371315e-02f, -7.66540691e-02f, -1.28535628e-02f,
  7.17479512e-02f, -1.99705973e-01f, -1.09893486e-01f, -1.22279584e-01f, -1.69697806e-01f, 1.36959478e-01f, 2.00380012e-01f, -9.61826295e-02f, -2.36416742e-01f, -8.71384665e-02f,
  -2.34246142e-02f, 3.83164845e-02f, 4.74268477e-03f, 1.70016661e-02f, 8.46596286e-02f, -7.13345259e-02f, 1.67976961e-01f, 1.87131017e-01f, 1.00228295e-01f, 2.71941394e-01f,
  -1.54437706e-01f, 4.69815396e-02f, -1.14432633e-01f, -1.94225356e-01f, -3.63283008e-02f, -1.66940629e-01f, -9.43895131e-02f, -9.54902172e-02f, -5.66785783e-02f, -4.27633375e-02f,
  -8.77824500e-02f, -8.07126835e-02f, -1.44164518e-01f, -6.72608018e-02f, -1.24156237e-01f, -1.46638975e-01f, -1.05621666e-01f, -1.92997858e-01f, -1.59718812e-01f, -3.99824679e-02f,
  5.28849959e-02f, -1.19597763e-02f, -6.05677105e-02f, -7.83344358e-02f, -1.18209571e-01f, -1.23304978e-01f, -1.50981128e-01f, -7.00194389e-02f, -1.41723439e-01f, -4.71146852e-02f,
  3.04600596e-02f, 5.36296628e-02f, 1.74870431e-01f, 1.62998468e-01f, 3.83913107e-02f, 1.47524834e-01f, 7.15528205e-02f, 2.09561363e-01f, 6.75495714e-02f, 1.10663801e-01f,
  1.34048194e-01f, 1.12609148e-01f, 1.08365983e-01f, 1.24931701e-01f, 1.21958397e-01f, 2.08045453e-01f, 9.98217836e-02f, 6.02770001e-02f, 1.75539523e-01f, 1.55258328e-01f,
  1.71532989e-01f, 9.45036337e-02f, 1.34249777e-01f, 1.27200529e-01f, 1.27354324e-01f, 6.68527856e-02f, 1.21910311e-01f, 1.47517875e-01f, 1.87488183e-01f, 2.01752976e-01f,
  -2.82946765e-01f, -1.23058394e-01f, -1.61330611e-01f, -1.64820790e-01f, -9.42196548e-02f, -8.55701938e-02f, -4.12794836e-02f, -1.18856050e-01f, -1.53382227e-01f, -1.63574040e-01f,
  1.39020814e-03f, -1.54041067e-01f, -1.78284273e-02f, -1.34135514e-01f, -1.84774131e-01f, -7.58922771e-02f, -3.28719653e-02f, -4.41356078e-02f, -1.39213204e-01f, -1.36549726e-01f,
  -8.32656696e-02f, -1.90935895e-01f, -9.23953876e-02f, -1.76220253e-01f, -1.32878542e-01f, -8.67113024e-02f, -1.54312924e-01f, -9.56373587e-02f, -1.71829894e-01f, -2.07043186e-01f,
  1.22522444e-01f, -3.40784341e-01f, -1.48810372e-01f, 1.02097258e-01f, -9.92310122e-02f, 3.09217591e-02f, -2.23624840e-01f, 1.08474329e-01f, 1.16952606e-01f, -1.82544068e-01f,
  -8.07332844e-02f, 2.27879420e-01f, 1.42327517e-01f, 2.48284280e-01f, 2.99092054e-01f, -1.81489885e-01f, -4.16173600e-02f, 2.15929627e-01f, 3.81908804e-01f, 9.62652192e-02f,
  -3.67441289e-02f, 3.51121277e-02f, 2.05117270e-01f, 9.03941467e-02f, -1.81940824e-01f, 1.43805474e-01f, -2.19887584e-01f, -8.31751749e-02f, -3.66678201e-02f, -3.27974200e-01f,
  -9.05730873e-02f, -1.96414530e-01f, 1.72976151e-01f, 7.59755215e-03f, -1.03023455e-01f, 7.18339831e-02f, 4.98965830e-02f, -9.05610844e-02f, 2.47650556e-02f, -7.22755119e-02f,
  -2.03604177e-02f, 7.76214674e-02f, -2.77468860e-02f, -4.70394008e-02f, -7.09730983e-02f, 5.02217337e-02f, -5.13826497e-02f, 6.95336685e-02f, 7.49126151e-02f, 1.56377200e-02f,
  -1.71197318e-02f, -1.46241337e-01f, -5.65703027e-02f, 5.40679395e-02f, 8.73803794e-02f, 1.68738440e-01f, 4.25805943e-03f, -1.06201619e-01f, 2.92509068e-02f, -1.00361370e-01f,
  -4.60992306e-02f, -2.66960151e-02f, -6.11690991e-02f, -7.11707473e-02f, -2.72183064e-02f, -3.99159715e-02f, -5.77729233e-02f, 3.70833725e-02f, -3.08418702e-02f, -6.39727013e-03f,
  4.73649334e-03f, -7.91672319e-02f, 2.52913181e-02f, -2.36970205e-02f, 7.28145763e-02f, -1.07740417e-01f, -3.65205184e-02f, 3.24864150e-03f, 8.08474142e-03f, -5.29822260e-02f,
  -2.31714379e-02f, -6.69947788e-02f, -3.40926498e-02f, 9.54519212e-03f, -4.16246206e-02f, 2.07710844e-02f, 9.17165633e-03f, -6.00583553e-02f, 2.66856775e-02f, 1.18185729e-02f,
  2.03625970e-02f, 1.79073617e-01f, -6.47557080e-02f, 4.72882614e-02f, -2.89163683e-02f, -3.75858396e-02f, 3.99968354e-03f, 1.73053555e-02f, -1.46145998e-02f, -2.72080302e-02f,
  3.36606763e-02f, 5.54758357e-03f, 3.96103039e-02f, -1.74118934e-04f, 1.24060018e-02f, 4.61707152e-02f, -3.23860496e-02f, 6.57904595e-02f, 1.10056385e-01f, -3.73893939e-02f,
  1.34661524e-02f, 7.60600865e-02f, 1.12659410e-01f, 1.98468789e-02f, -1.37017528e-02f, 1.24263704e-01f, 4.65765260e-02f, 4.01950926e-02f, 1.86729610e-01f, -4.24824506e-02f,
  6.39667958e-02f, -8.04789588e-02f, -3.55487727e-02f, 3.96452174e-02f, -8.76084268e-02f, -2.26583049e-01f, -1.74185529e-01f, 1.04101384e-02f, 1.44716024e-01f, 1.80344153e-02f,
  6.95442036e-02f, 1.89768702e-01f, 1.58461750e-01f, 6.57314211e-02f, 7.62704238e-02f, 4.37624454e-02f, 9.54466462e-02f, 4.32878099e-02f, -3.50768194e-02f, -3.73125933e-02f,
  -2.75311731e-02f, -1.06534092e-02f, -9.33138281e-02f, 1.15202647e-02f, 2.32068256e-01f, 2.52595514e-01f, 6.29496351e-02f, -7.39567727e-02f, -1.99507698e-02f, 2.48028874e-01f,
  1.83535561e-01f, 3.68292481e-02f, 4.17305157e-02f, 1.31274119e-01f, 9.49274525e-02f, 2.10559919e-01f, 9.22141522e-02f, 1.96975842e-01f, 8.94336998e-02f, 1.72701210e-01f,
  5.50899319e-02f, 7.15408996e-02f, 4.19404060e-02f, 5.06139472e-02f, 4.70751114e-02f, 1.43046916e-01f, -6.23504212e-03f, 7.03422129e-02f, -1.20935985e-03f, 1.51153430e-01f,
  1.06196061e-01f, -1.21308066e-01f, -1.18288122e-01f, -3.12013663e-02f, 1.39507614e-02f, 2.03938894e-02f, -3.18245515e-02f, 6.26999587e-02f, 4.49558310e-02f, 2.25111470e-01f,
  7.73517415e-02f, 3.35725546e-02f, -4.96119522e-02f, 7.07080662e-02f, 4.85955961e-02f, 4.12246622e-02f, 5.88519871e-02f, -5.14968634e-02f, 4.25108373e-02f, 6.36417046e-02f,
  1.18897885e-01f, -5.46279848e-02f, 2.67052669e-02f, 5.56830987e-02f, 4.29815501e-02f, -5.70490547e-02f, -5.38810380e-02f, 2.34473888e-02f, 2.29534153e-02f, -5.03898561e-02f,
  3.26224677e-02f, -2.58958265e-02f, -6.52141273e-02f, 5.97031899e-02f, 8.15553740e-02f, -2.14970857e-02f, 5.71570508e-02f, 4.33295965e-02f, 3.93499620e-02f, -6.52108267e-02f,
  1.53239161e-01f, -4.03255187e-02f, 3.21419507e-01f, 1.17444560e-01f, -3.63013521e-02f, 9.45257023e-02f, 7.14997575e-02f, 1.26831025e-01f, 1.56902045e-01f, 8.85097086e-02f,
  3.45491096e-02f, 6.90976530e-02f, 1.55466318e-01f, 1.04202770e-01f, 2.55583972e-02f, 6.39199913e-02f, -1.96641125e-02f, 1.47225842e-01f, -2.51335725e-02f, 7.11321756e-02f,
  -2.48496234e-02f, 1.14570847e-02f, -6.00635074e-02f, 1.40959561e-01f, 8.16293135e-02f, 1.10050105e-01f, 1.11405693e-01f, 3.50623950e-02f, 8.61477852e-02f, 1.67462260e-01f,
  6.48829713e-02f, 3.74618381e-01f, 2.75805116e-01f, 2.42196754e-01f, 2.59744912e-01f, 2.34471694e-01f, 3.66169602e-01f, 1.77419856e-01f, 1.70043647e-01f, 2.65813798e-01f,
  2.56014407e-01f, 4.39894907e-02f, 1.32051378e-01f, 2.22421199e-01f, 1.21518463e-01f, 3.51929188e-01f, 2.84017324e-01f, 1.17898934e-01f, 1.06376253e-01f, 7.29679838e-02f,
  9.31484923e-02f, 1.92493558e-01f, 1.08566813e-01f, 1.68832481e-01f, 2.88038254e-01f, 1.63311079e-01f, 2.32282117e-01f, 1.15874030e-01f, 2.66729146e-01f, 2.89966434e-01f,
  2.90123016e-01f, 3.79393488e-01f, 1.18026450e-01f, 9.93067250e-02f, 1.85930461e-01f, 2.89408773e-01f, 3.03950161e-01f, 3.16968530e-01f, 1.52388468e-01f, 3.15539181e-01f,
  2.35023856e-01f, 2.95336992e-01f, 1.76332176e-01f, 2.42920324e-01f, 2.79362381e-01f, 1.77850455e-01f, 2.30964497e-01f, 1.79912582e-01f, 2.19499350e-01f, 3.49139273e-01f,
  2.57332593e-01f, 2.23028511e-01f, 1.65612236e-01f, 3.18986416e-01f, 2.84719050e-01f, 1.74575716e-01f, 3.23206723e-01f, 3.17130566e-01f, 3.45482051e-01f, 4.46299732e-01f,
  -8.18620026e-02f, -8.04937556e-02f, -1.52716875e-01f, -1.09904602e-01f, -2.38029972e-01f, -2.74264902e-01f, -1.55294821e-01f, -7.42810145e-02f, -1.32980943e-01f, -1.81365401e-01f,
  -2.10499376e-01f, -1.40793696e-01f, -1.23632275e-01f, -3.37202102e-02f, -7.87847713e-02f, -1.66450888e-01f, -1.74727395e-01f, -5.57377823e-02f, -1.02458917e-01f, -1.06221169e-01f,
  -1.82765648e-01f, -2.13303655e-01f, -1.13446683e-01f, -1.58551693e-01f, -1.70552894e-01f, -4.63900976e-02f, -7.57297128e-02f, -1.39381662e-01f, -7.31024817e-02f, -9.50040445e-02f,
  1.00960538e-01f, 1.04657315e-01f, 2.88696945e-01f, 2.86281079e-01f, 2.18152925e-01f, 2.90183097e-01f, 2.89925992e-01f, 2.74871916e-01f, 2.27532998e-01f, 2.71347940e-01f,
  1.92072913e-01f, 2.00032294e-01f, 2.99880832e-01f, 2.36797661e-01f, 1.78414956e-01f, 2.35515088e-01f, 2.02656463e-01f, 2.48297513e-01f, 1.59743786e-01f, 3.08921039e-01f,
  2.89845347e-01f, 2.24180207e-01f, 1.70599341e-01f, 1.80656984e-01f, 1.49862692e-01f, 1.98453411e-01f, 2.77036309e-01f, 1.89270318e-01f, 2.24984571e-01f, 3.98980319e-01f,
  6.79457746e-03f, 9.63130500e-03f, 4.41399701e-02f, 2.12162212e-01f, -6.99415356e-02f, -1.42503873e-01f, -7.34061748e-02f, 1.97579302e-02f, 4.84597497e-02f, -9.24850404e-02f,
  1.54143404e-02f, 1.00368544e-01f, 2.26337984e-01f, 2.00202003e-01f, 1.27642989e-01f, -4.69458327e-02f, 1.85325205e-01f, 3.06742787e-01f, 1.68414876e-01f, 1.07919827e-01f,
  3.26198563e-02f, 1.89424574e-01f, 2.58428395e-01f, 2.63034552e-01f, 1.26010433e-01f, -3.39394622e-02f, -3.81182134e-02f, -1.56171955e-02f, 8.23336020e-02f, 2.23876595e-01f,
  -1.04842983e-01f, 1.12218328e-01f, 1.71019018e-01f, 2.12565705e-01f, 5.73422834e-02f, 1.65801689e-01f, 6.15206249e-02f, 2.11183459e-01f, 6.49759546e-02f, 9.23196599e-02f,
  1.22936204e-01f, 1.13828033e-01f, 1.29971817e-01f, 3.38527821e-02f, 1.02223635e-01f, 5.41642644e-02f, 1.18541680e-01f, 1.74314603e-01f, 2.21439689e-01f, 1.14643954e-01f,
  2.22484425e-01f, 1.34649530e-01f, -4.94799949e-02f, 8.93564671e-02f, 1.14941038e-02f, 1.45982325e-01f, -2.44380091e-03f, 1.27567723e-01f, 9.76935327e-02f, 8.19306299e-02f,
  1.79433841e-02f, -1.12449557e-01f, -9.78099182e-02f, -7.02313259e-02f, -1.63492948e-01f, -1.82959020e-01f, -1.18884016e-02f, -4.87535968e-02f, -1.13843590e-01f, -6.91725761e-02f,
  -6.26382753e-02f, -1.06947184e-01f, -6.42179772e-02f, -1.17812097e-01f, -9.21966583e-02f, -8.91754497e-03f, -2.38325857e-02f, -3.59432511e-02f, -1.29334062e-01f, -3.95936072e-02f,
  -1.50349557e-01f, -1.14018187e-01f, -1.21076226e-01f, -1.24094255e-01f, -1.67251378e-02f, -6.14241064e-02f, -7.07082823e-02f, 1.61931687e-03f, -5.99519610e-02f, -1.58876002e-01f,
  1.15867574e-02f, 1.37334034e-01f, -8.92235525e-03f, 1.07402831e-01f, 1.05510376e-01f, 2.08559316e-02f, 9.31794420e-02f, 9.67406705e-02f, 1.50185257e-01f, 2.59234738e-02f,
  1.42005309e-01f, -9.08187032e-03f, -3.10890912e-03f, 6.61551356e-02f, 2.55703069e-02f, -2.97835562e-02f, 5.82685741e-03f, 1.31770000e-01f, 9.65579599e-02f, 1.33829936e-01f,
  1.60714701e-01f, -1.53009323e-02f, -4.38692421e-02f, -2.59759948e-02f, 7.77938813e-02f, -6.13496043e-02f, 2.65457407e-02f, 5.75640798e-02f, -1.07825488e-01f, 1.11589711e-02f,
  -2.54015267e-01f, 8.26114342e-02f, -1.28179323e-02f, 1.06968783e-01f, 5.08066490e-02f, -8.04656893e-02f, -2.00646415e-01f, -1.16134509e-01f, 8.00977945e-02f, -2.53266096e-02f,
  1.08036377e-01f, 7.43128210e-02f, 1.05301380e-01f, -3.97404805e-02f, -1.56814963e-01f, -3.36448587e-02f, 5.15631177e-02f, -1.02465175e-01f, -2.26175562e-01f, -1.48465648e-01f,
  4.50517423e-03f, 1.65917948e-02f, 4.87827510e-02f, 6.93219751e-02f, -1.16899973e-02f, -4.99098673e-02f, 8.07373896e-02f, 3.85276601e-02f, -5.69402985e-02f, 1.08282939e-01f,
  -3.91917340e-02f, 6.88644424e-02f, 4.41971458e-02f, 7.56702051e-02f, 5.28642498e-02f, -1.12789564e-01f, 2.50600241e-02f, 1.57435089e-02f, 1.03120208e-01f, 7.68843591e-02f,
  9.09053534e-02f, 4.97589037e-02f, 1.12113252e-01f, 1.76880769e-02f, 1.25505418e-01f, 1.69043299e-02f, 3.55998650e-02f, -4.03045164e-03f, -7.42273256e-02f, 2.89855432e-02f,
  1.47251129e-01f, 3.99850458e-02f, -7.23915771e-02f, 4.49927114e-02f, -5.73060289e-02f, -2.63292603e-02f, 4.55036014e-02f, -1.01124249e-01f, -6.75898492e-02f, -5.69199324e-02f,
  -8.18220228e-02f, -8.68383199e-02f, -7.30692297e-02f, -7.33043533e-03f, -1.09701656e-01f, -6.12896755e-02f, -4.40082327e-02f, 4.66697477e-03f, -3.61787267e-02f, -1.08982645e-01f,
  -5.96803753e-03f, -7.29679167e-02f, -7.95186237e-02f, -3.21429148e-02f, 1.16329733e-02f, -6.01605400e-02f, -5.94907440e-02f, -2.22539678e-02f, -8.17112178e-02f, 1.16648218e-02f,
  -1.07210718e-01f, -1.09707102e-01f, -5.78507083e-03f, -8.26969296e-02f, -2.72840373e-02f, -7.29246661e-02f, -4.94104140e-02f, -9.13650468e-02f, -3.64790758e-04f, -8.60232189e-02f,
  5.81248514e-02f, 2.71606058e-01f, 4.66196015e-02f, -1.27948413e-03f, 8.64461511e-02f, 4.67104046e-03f, 5.19971959e-02f, 1.18712857e-01f, 5.92912063e-02f, 2.02087983e-02f,
  -5.03261834e-02f, -8.29066113e-02f, 9.33405608e-02f, -3.00188251e-02f, -2.51320265e-02f, 2.14560144e-02f, 6.01963811e-02f, -1.12308459e-02f, 2.21063364e-02f, -4.57021184e-02f,
  8.27974677e-02f, -4.13682051e-02f, -1.33684471e-01f, 1.62921194e-02f, -2.35103667e-02f, -3.49014550e-02f, -1.36052623e-01f, -1.08535714e-01f, -1.22426264e-01f, -6.25281483e-02f,
  -4.69218791e-01f, 1.05653284e-02f, 1.47569105e-01f, -1.66727260e-01f, 1.75458398e-02f, -1.33036217e-02f, 2.39906773e-01f, 9.20610949e-02f, -1.47009030e-01f, -2.27641277e-02f,
  -2.16553435e-01f, -3.53069991e-01f, -1.08640276e-01f, -1.79685220e-01f, -7.08603710e-02f, 2.33051300e-01f, 1.94331408e-01f, -7.65574947e-02f, -1.20312341e-01f, -8.67241994e-02f,
  -8.38905573e-02f, -5.73370345e-02f, -1.42095536e-01f, 1.74573790e-02f, 4.23760377e-02f, -3.78699824e-02f, 1.83106706e-01f, -1.93509422e-02f, 1.68888532e-02f, 1.18543990e-01f,
  -2.83358783e-01f, 2.37544738e-02f, -7.73977488e-02f, -1.68688253e-01f, -7.34946728e-02f, -1.46258205e-01f, -1.32022619e-01f, -1.47271529e-01f, -6.37773871e-02f, 3.83761886e-04f,
  -1.32801831e-01f, -8.13299883e-03f, -6.70879036e-02f, -1.26141667e-01f, -4.91497153e-03f, 8.28008633e-03f, -2.87226699e-02f, -3.95636000e-02f, -1.11076556e-01f, -2.58538295e-02f,
  -5.18417396e-02f, -1.02554008e-01f, -1.80112466e-03f, -6.97073061e-03f, 2.43070448e-04f, -1.59207121e-01f, -9.22720134e-02f, -4.42647412e-02f, 1.09017396e-03f, -1.26682729e-01f,
  -6.93360344e-02f, -7.94690661e-03f, -1.80395488e-02f, 9.83329769e-03f, -6.96986690e-02f, -3.04827504e-02f, -4.08548228e-02f, 2.09884830e-02f, 2.01793457e-03f, -3.93116660e-02f,
  -3.47863920e-02f, -3.96041162e-02f, -1.05868112e-02f, 4.39384505e-02f, 1.66345369e-02f, 1.46587258e-02f, 1.92220416e-02f, -1.08748060e-02f, 8.85326508e-03f, 1.63237154e-02f,
  -6.83456063e-02f, 6.37824088e-02f, -2.68165618e-02f, 1.12420972e-02f, -2.27006711e-02f, -3.21647674e-02f, -3.90089154e-02f, 6.97874697e-03f, 1.13509418e-02f, 2.10703742e-02f,
  -2.58072406e-01f, -7.67723024e-02f, -1.27113387e-01f, -1.58594106e-03f, -1.20212421e-01f, -2.18202285e-02f, -5.11949062e-02f, -7.08376318e-02f, -1.65262818e-02f, -5.20337932e-02f,
  -8.87260307e-03f, -5.57215437e-02f, 3.33199054e-02f, -6.36257138e-03f, -1.25610784e-01f, -4.07776758e-02f, -8.34063441e-02f, -1.22875817e-01f, 3.40033509e-02f, -1.11560069e-01f,
  3.14054340e-02f, -7.27114826e-02f, -2.55621284e-01f, -1.30939677e-01f, -7.28277564e-02f, -1.72189623e-01f, -1.70637503e-01f, -9.44613665e-02f, -1.55938461e-01f, -1.19622529e-01f,
  -3.44187349e-01f, 2.23108992e-01f, 2.35978097e-01f, -2.32617438e-01f, 6.43866360e-02f, 3.55578251e-02f, -7.11817294e-02f, -2.17500166e-03f, -1.89850926e-01f, -2.37706844e-02f,
  1.30728126e-01f, -5.52059188e-02f, -5.42808361e-02f, -7.50837252e-02f, -1.34276092e-01f, 1.20820247e-01f, 1.17901921e-01f, 3.53740975e-02f, -7.51854926e-02f, -1.06705405e-01f,
  -3.93349007e-02f, -1.34847865e-01f, -1.37873664e-01f, -5.38608395e-02f, -2.75442731e-02f, -1.37422144e-01f, 1.39939114e-01f, 1.92023255e-02f, 1.12661600e-01f, 1.49574384e-01f,
  1.36300594e-01f, 2.58699834e-01f, -9.64850187e-02f, -7.14721233e-02f, 7.89088160e-02f, -7.18220323e-02f, 4.23059240e-02f, 4.60856594e-02f, 2.07101479e-02f, 4.33437116e-02f,
  -8.43524584e-04f, 2.54371727e-04f, -5.68060726e-02f, 2.23237891e-02f, 5.02039604e-02f, 3.34475338e-02f, 6.79405555e-02f, 2.40632929e-02f, 3.40805463e-02f, 8.23249444e-02f,
  7.38044530e-02f, 6.13422208e-02f, 1.67606577e-01f, 1.06348403e-01f, 7.55449533e-02f, -3.37955318e-02f, 1.28210545e-01f, 1.54446512e-01f, 1.42979354e-01f, -7.49571025e-02f,
  -6.80741062e-03f, 6.33360520e-02f, -9.22082886e-02f, -4.47992124e-02f, -5.26767224e-02f, -6.12139702e-02f, -2.74962913e-02f, -7.93180838e-02f, -1.24268970e-02f, -8.90418217e-02f,
  1.63870063e-02f, -2.07652263e-02f, 2.04298906e-02f, -7.19190985e-02f, 7.46745383e-04f, -4.34102677e-02f, -1.03943519e-01f, -6.15823194e-02f, -1.88759696e-02f, -1.00788541e-01f,
  -5.63485324e-02f, 3.65958437e-02f, -8.11618641e-02f, -5.25818504e-02f, -6.98080733e-02f, -3.14887166e-02f, -1.43472543e-02f, -7.93234929e-02f, 3.66684310e-02f, -5.89573057e-03f,
  -2.38069355e-01f, 2.71389354e-02f, -1.28450602e-01f, -6.25619665e-02f, 7.88171664e-02f, 5.25116660e-02f, 3.10328454e-02f, -1.05080344e-02f, 5.64219281e-02f, -1.22540481e-02f,
  -3.18269208e-02f, 3.19210328e-02f, 7.00568333e-02f, 4.83014248e-03f, -7.55977482e-02f, -8.34563449e-02f, 3.94559428e-02f, -8.47565532e-02f, -2.57564634e-02f, 4.17817272e-02f,
  -7.73968175e-02f, -6.86998367e-02f, -1.09580874e-01f, -3.83859947e-02f, -8.66253003e-02f, -1.48431733e-01f, -1.01700053e-02f, -3.26654725e-02f, -5.54538041e-04f, -2.16015086e-01f,
  3.17317486e-01f, 5.12131639e-02f, 4.16009903e-01f, 1.45661250e-01f, 1.04710370e-01f, 2.00415403e-01f, 2.80435264e-01f, 1.29225791e-01f, -7.28963539e-02f, 1.48358598e-01f,
  -6.26525953e-02f, -1.43847942e-01f, -6.41456097e-02f, 1.86610986e-02f, 5.68150776e-03f, 1.22134686e-01f, 2.25584969e-01f, 1.98815763e-01f, 1.90170601e-01f, 1.75457090e-01f,
  -1.09033316e-01f, 6.84418157e-02f, 1.49020448e-01f, 9.86568909e-03f, 9.67865735e-02f, -2.81364620e-02f, 5.04218824e-02f, 1.29433602e-01f, 1.21462196e-01f, 1.96175992e-01f,
  3.38705122e-01f, 3.77968252e-01f, 2.05109362e-02f, 5.16110957e-02f, 1.47237211e-01f, 8.93941075e-02f, 4.78025265e-02f, 3.38271558e-02f, -5.97179122e-02f, 1.35983136e-02f,
  2.73326412e-02f, 8.31114277e-02f, 1.01351567e-01f, -1.92070119e-02f, 9.16468576e-02f, 7.31402338e-02f, -9.04555898e-03f, 8.03322420e-02f, 5.10621108e-02f, 7.38076940e-02f,
  2.26616883e-03f, 9.88291204e-02f, 6.20789565e-02f, 4.21488248e-02f, -9.48201458e-04f, 2.53637098e-02f, 3.86645496e-02f, 5.90294711e-02f, 6.92246258e-02f, -3.76431569e-02f,
  -5.55436686e-03f, -7.19516501e-02f, -3.91245000e-02f, -1.25339597e-01f, -1.70322359e-01f, -1.64538115e-01f, -3.29345390e-02f, -1.05434135e-01f, -1.54657453e-01f, -8.03401023e-02f,
  -1.35354981e-01f, 3.82544883e-02f, -1.23573288e-01f, 9.16176066e-02f, -7.67991543e-02f, -5.74436560e-02f, -5.87262809e-02f, -5.64811118e-02f, -6.86261356e-02f, -1.63887218e-01f,
  -1.16770767e-01f, -6.06035814e-03f, -4.06335201e-03f, -1.27765924e-01f, -7.64947161e-02f, -1.29835494e-03f, -7.61544332e-02f, -7.87595883e-02f, -7.61410370e-02f, -3.03350966e-02f,
  -3.99150625e-02f, 1.07083119e-01f, 1.69579946e-02f, 6.28858581e-02f, 1.05910972e-01f, 8.55650827e-02f, 1.18907511e-01f, 4.65582497e-02f, 1.24235094e-01f, 1.45877764e-01f,
  7.82525390e-02f, 1.15129098e-01f, 2.31337361e-02f, -2.74370927e-02f, 6.84511438e-02f, 1.89501084e-02f, -1.02805875e-01f, -3.90804410e-02f, 3.02355997e-02f, -3.83200198e-02f,
  -4.53606881e-02f, -5.39068542e-02f, -5.27734635e-03f, 2.57247481e-02f, -5.00842743e-02f, 6.31403327e-02f, 1.06725521e-01f, 1.11717299e-01f, 8.27179551e-02f, -9.57649574e-03f,
  3.02217245e-01f, 1.79797545e-01f, 2.23539829e-01f, 2.27532864e-01f, 1.11177571e-01f, 2.95529235e-02f, 1.63501576e-01f, 7.11890832e-02f, -1.06859311e-01f, 9.28478688e-02f,
  -5.77261038e-02f, -1.76942825e-01f, -3.69650722e-02f, -1.06524520e-01f, 6.14015311e-02f, 6.42686933e-02f, 2.12861866e-01f, 6.00178242e-02f, -2.05522582e-01f, -1.76181778e-01f,
  9.00314655e-03f, 8.19219202e-02f, -5.13414256e-02f, -1.83900595e-02f, -7.83056319e-02f, -1.02273889e-01f, 3.24090309e-02f, -7.31822103e-02f, -3.74581367e-02f, -7.41209537e-02f,
  -6.09411150e-02f, 2.40780756e-01f, -4.82292362e-02f, -5.82250617e-02f, 1.18699074e-02f, -8.32391530e-02f, -5.87178320e-02f, -1.64602958e-02f, 5.20275496e-02f, 2.35572137e-04f,
  2.23884396e-02f, -8.54545906e-02f, 7.30732009e-02f, -1.11697009e-02f, 1.10249080e-01f, -8.43806490e-02f, 1.60407089e-02f, 3.18100750e-02f, 4.10883799e-02f, 2.03913562e-02f,
  -4.46393788e-02f, 3.32653522e-02f, 3.32248746e-03f, -3.63157652e-02f, -4.89265770e-02f, -4.16966751e-02f, -2.09790487e-02f, -2.36237627e-02f, -1.39717430e-01f, -1.52117070e-02f,
  1.11100152e-02f, 3.82250622e-02f, 5.67466430e-02f, -1.57965049e-02f, -5.55184670e-02f, -9.26543176e-02f, 2.19660047e-02f, -4.39808331e-03f, 1.14265000e-02f, 3.02320649e-03f,
  2.38660462e-02f, 6.63123140e-03f, -1.55258849e-02f, -1.57258697e-02f, -9.51177813e-03f, 9.83754173e-03f, -4.72326949e-02f, 4.07631472e-02f, -1.01166226e-01f, 9.83735267e-03f,
  4.31503728e-02f, -5.56535274e-02f, -3.94485220e-02f, -1.93774346e-02f, -7.68283829e-02f, 1.42029822e-02f, 8.05645809e-03f, -5.93061820e-02f, -2.19405796e-02f, -2.33544549e-03f,
  -7.89409950e-02f, 7.39743188e-02f, 2.86391173e-02f, 3.30111384e-02f, 2.18003262e-02f, 9.52313468e-03f, 1.18016995e-01f, 3.73990200e-02f, 3.26364450e-02f, -3.20520289e-02f,
  4.80036326e-02f, 1.17123336e-01f, 1.85190588e-02f, 3.35778892e-02f, 2.19971873e-03f, -5.65965027e-02f, 8.23310316e-02f, -1.78867560e-02f, -4.17107157e-02f, -8.11474398e-02f,
  -5.31925932e-02f, 4.40398343e-02f, 7.43352324e-02f, -4.96930741e-02f, -1.00471564e-02f, 8.04988667e-03f, -7.80213773e-02f, 3.08933388e-02f, 5.92185184e-02f, 1.32838711e-01f,
  -3.07573617e-01f, 7.34098330e-02f, 6.69733211e-02f, -6.93775937e-02f, 7.00704753e-02f, 1.38705090e-01f, 3.49278301e-01f, 9.35002416e-02f, -1.23364128e-01f, 1.21314898e-01f,
  -1.29357830e-01f, -2.09612206e-01f, -1.39221683e-01f, 1.96025018e-02f, 5.72483195e-03f, 3.00037146e-01f, 2.98736125e-01f, 1.20299133e-02f, -6.53855205e-02f, 1.89843345e-02f,
  1.22672291e-02f, 4.37296480e-02f, -1.55151293e-01f, 6.58314005e-02f, 2.59678513e-02f, -3.93488780e-02f, 8.09496716e-02f, 1.00064270e-01f, 1.27858862e-01f, 8.14687610e-02f,
  -3.44499722e-02f, -8.52969363e-02f, 3.46320868e-02f, 2.12413445e-02f, 2.62469929e-02f, -5.10560870e-02f, 8.29389878e-03f, -8.19235854e-03f, -3.40165719e-02f, -1.21592376e-02f,
  3.19187716e-03f, -4.28702421e-02f, -4.11521550e-03f, -1.27009563e-02f, 1.12302499e-02f, 8.57890099e-02f, 8.39812979e-02f, 7.61949345e-02f, 7.67792091e-02f, -3.59041430e-03f,
  2.23057251e-02f, 1.17286898e-01f, 1.13253325e-01f, 5.09777330e-02f, 5.23996912e-02f, 9.29969642e-03f, 2.43575289e-03f, 8.82166438e-03f, 8.69983584e-02f, -6.47845492e-02f,
  -3.70319039e-02f, -7.36750439e-02f, -5.26218116e-02f, 1.24750519e-02f, -3.62669043e-02f, -1.03993759e-01f, -8.97371117e-03f, -6.68569580e-02f, -3.23190577e-02f, -1.88349541e-02f,
  -4.09159586e-02f, 2.10510474e-03f, -1.19544685e-01f, 1.67022794e-02f, -4.92381155e-02f, -1.06254645e-01f, -5.27096689e-02f, 9.46684624e-04f, 3.39369476e-02f, -5.74129447e-02f,
  -7.02879354e-02f, -5.61872032e-03f, 1.00867255e-02f, -1.06855020e-01f, -3.22565846e-02f, -1.49214447e-01f, -7.98860490e-02f, -1.64111435e-01f, -7.07539320e-02f, -1.14751592e-01f,
  -4.28456627e-02f, 2.98562497e-02f, 1.34117752e-02f, 6.35816976e-02f, 5.48139103e-02f, 8.59980565e-03f, 8.45311768e-03f, 6.70692623e-02f, -1.84325073e-02f, -3.48853841e-02f,
  2.42229328e-02f, -8.83226842e-02f, 7.99538940e-02f, 6.70532286e-02f, 1.01794817e-01f, -5.58750657e-03f, 1.63654953e-01f, 3.26621011e-02f, 2.21207030e-02f, 9.15021002e-02f,
  8.48673880e-02f, 1.57354012e-01f, -2.04743277e-02f, 7.23716319e-02f, 6.92365468e-02f, 3.16952206e-02f, 1.02000639e-01f, 8.53600502e-02f, 7.76391625e-02f, 5.30307293e-02f,
  1.08251356e-01f, -4.90093231e-02f, 1.63337886e-02f, -1.82474419e-01f, 4.43517752e-02f, 2.95756221e-01f, 3.36850345e-01f, 2.38062203e-01f, 3.09597813e-02f, -2.65519042e-02f,
  4.69486825e-02f, -1.34701267e-01f, -9.31130126e-02f, -1.26484074e-02f, 2.04438835e-01f, -1.01433821e-01f, -2.00571314e-01f, -4.16500084e-02f, 1.92294121e-01f, 8.77954215e-02f,
  -8.92266780e-02f, -7.03650936e-02f, -1.25088379e-01f, 2.84031648e-02f, -2.61331111e-01f, -8.39514062e-02f, -1.54786199e-01f, -2.96276566e-02f, -1.18770421e-01f, -3.50947648e-01f,
  -3.58207226e-01f, 1.27207607e-01f, 2.33446504e-03f, -1.17743686e-01f, -1.25923201e-01f, 2.16143634e-02f, -3.15145366e-02f, -1.62018016e-01f, -1.21742440e-02f, -8.76126960e-02f,
  -4.81323451e-02f, -7.80427977e-02f, 1.88164599e-02f, -1.34359494e-01f, 4.93474863e-02f, -2.29668282e-02f, -7.30639249e-02f, -1.07074663e-01f, -2.72845980e-02f, 7.21007679e-03f,
  -3.55915800e-02f, 3.50540364e-03f, 7.81936869e-02f, 5.23420759e-02f, -1.24136414e-02f, -8.04143324e-02f, -2.93410625e-02f, 2.53767092e-02f, 9.59052145e-02f, -8.54328051e-02f,
  2.64673494e-02f, 6.57054260e-02f, 5.04172966e-02f, -7.09278649e-03f, -9.38318484e-03f, 6.35503531e-02f, 2.02293694e-02f, 1.13227153e-02f, -2.50918549e-02f, -3.91406417e-02f,
  5.63073717e-02f, -1.07420590e-02f, 3.68972197e-02f, -3.90783977e-03f, -3.23756747e-02f, -6.63919374e-02f, 9.22580585e-02f, -6.17435500e-02f, 3.98495123e-02f, -2.28413194e-02f,
  -7.35214353e-02f, 2.88461465e-02f, -1.24384291e-01f, -5.22525087e-02f, -7.31850788e-02f, -7.35461293e-03f, 2.45130475e-04f, 6.32960862e-03f, 3.76745723e-02f, 9.90051925e-02f,
  -1.39600262e-01f, 2.32928559e-01f, -2.11707070e-01f, -5.19766705e-03f, -4.78274785e-02f, -3.88916209e-02f, -5.17707653e-02f, 4.04924899e-02f, -6.68228120e-02f, -1.04312375e-01f,
  3.81389745e-02f, -1.26279553e-03f, -7.17029348e-02f, -9.40513536e-02f, 6.36234973e-03f, 6.76781684e-03f, -4.43264097e-02f, -5.61700314e-02f, -6.18777275e-02f, -3.00261416e-02f,
  -6.56540245e-02f, 1.02645919e-01f, 9.00312588e-02f, 2.05444936e-02f, -1.57402288e-02f, 3.09091317e-03f, -6.51391363e-03f, -2.49246191e-02f, 1.47125736e-01f, 3.28129046e-02f,
  -2.40621284e-01f, 1.91257969e-01f, -3.46542418e-01f, -8.85223895e-02f, 6.82001710e-02f, 4.93130274e-02f, 1.97313577e-01f, 5.93446754e-02f, 1.17495973e-02f, 3.22646610e-02f,
  4.06727679e-02f, 9.24009606e-02f, 6.51467824e-03f, 9.21570212e-02f, -8.88784304e-02f, -2.08855458e-02f, -1.16434596e-01f, -2.62944341e-01f, -1.58839613e-01f, 1.11358166e-01f,
  2.67458647e-01f, -1.21852569e-01f, -2.86383092e-01f, -1.78351939e-01f, 6.66645765e-02f, 7.12456405e-02f, -7.01802969e-02f, -1.54777253e-02f, 4.50028814e-02f, 8.74099508e-03f,
  -2.47411594e-01f, -1.57177553e-01f, -5.71296737e-02f, -9.23972949e-02f, -1.41879618e-02f, -1.52054861e-01f, -1.26348972e-01f, -9.75609720e-02f, -4.00303975e-02f, -4.06356119e-02f,
  -7.34459385e-02f, -9.56865400e-02f, -6.62234724e-02f, 4.57144417e-02f, 3.97014944e-03f, -7.37923011e-02f, -2.93607507e-02f, -1.85076728e-01f, -2.01515183e-01f, -1.17893495e-01f,
  1.30621225e-01f, -6.20610118e-02f, -9.09689218e-02f, 4.10769647e-03f, -1.24540411e-01f, -1.96053088e-01f, -1.08263120e-01f, -1.15597777e-01f, -2.14049995e-01f, -1.10726386e-01f,
  -8.61811042e-02f, 5.89570887e-02f, 2.18104534e-02f, 2.06292849e-02f, 1.30883187e-01f, 5.18311448e-02f, 3.42427790e-02f, 1.21440321e-01f, 6.30431324e-02f, -1.11663947e-03f,
  1.05200239e-01f, -2.66062543e-02f, 4.54179794e-02f, 6.48581311e-02f, 1.10468686e-01f, -1.99636463e-02f, 6.80388825e-04f, 2.72013564e-02f, -3.40325981e-02f, 6.05807677e-02f,
  1.35991359e-02f, 2.19669025e-02f, -4.15058956e-02f, 3.33372727e-02f, 5.54176830e-02f, -5.27958050e-02f, -3.70952189e-02f, 6.10727556e-02f, 3.25806141e-02f, -2.02460662e-02f,
  8.52807611e-02f, -2.71986514e-01f, -1.43144742e-01f, -1.38915196e-01f, -9.08668190e-02f, -2.50243284e-02f, -9.10334885e-02f, -1.32695824e-01f, -8.54984224e-02f, -4.03729416e-02f,
  -7.62263164e-02f, -1.49092630e-01f, -6.39566332e-02f, -2.75173225e-02f, -1.73506923e-02f, -1.43381506e-02f, 4.71505523e-02f, -6.33202046e-02f, 4.42784745e-03f, 3.33245769e-02f,
  -8.17108676e-02f, -8.37096125e-02f, -1.71160605e-02f, 1.57395098e-02f, -1.12905286e-01f, -9.95826125e-02f, -7.30853900e-02f, 6.66126085e-04f, -8.06787983e-02f, -1.19250953e-01f,
  9.89434030e-03f, 3.18189830e-01f, 2.42489390e-02f, -2.28287820e-02f, 7.97221661e-02f, -1.92909032e-01f, -1.84455551e-02f, -2.40750681e-03f, 5.91049977e-02f, 1.55226797e-01f,
  2.02444755e-02f, -1.19557068e-01f, -2.18301630e-05f, -4.28040177e-02f, -1.15286291e-01f, 1.01833949e-02f, 5.35679944e-02f, 7.50131682e-02f, -2.02291399e-01f, -1.36485383e-01f,
  9.18337051e-03f, 1.04177132e-01f, -5.44565022e-02f, 6.71771318e-02f, 1.87635139e-01f, -7.89928511e-02f, 2.71055344e-02f, 1.37039915e-01f, 1.91156082e-02f, 2.49612898e-01f,
  -4.22615223e-02f, 2.07327545e-01f, -9.48775262e-02f, 5.34764417e-02f, 1.85542684e-02f, 4.27908562e-02f, -7.13182613e-02f, 1.33625492e-01f, 4.60431352e-02f, 7.49161234e-03f,
  1.32686086e-02f, 3.76527719e-02f, 8.62224102e-02f, 3.67396511e-02f, 9.61731188e-03f, -1.76713448e-02f, 9.58032385e-02f, 1.52769610e-01f, -4.09321021e-03f, -5.68711990e-03f,
  8.98233056e-02f, 2.79003959e-02f, 5.93764149e-02f, -7.18800630e-03f, 6.74490333e-02f, -1.46956146e-02f, 2.20277421e-02f, 1.27291724e-01f, 4.98254132e-03f, 1.70484528e-01f,
  1.06577063e-02f, 6.99680895e-02f, -1.57424435e-02f, -2.71818112e-03f, 6.29549474e-02f, 1.71552114e-02f, -2.84958445e-02f, -1.08125433e-02f, -2.54423209e-02f, 3.93675221e-03f,
  -4.94403988e-02f, -3.82839590e-02f, 2.51315068e-02f, -6.06360771e-02f, 7.97437057e-02f, 9.34685469e-02f, -1.60502903e-02f, 3.90289240e-02f, 5.18938377e-02f, -4.67278510e-02f,
  -3.79950851e-02f, -1.58894975e-02f, -1.04210675e-01f, 2.85241324e-02f, 1.01276159e-01f, 6.76195323e-02f, 5.89423105e-02f, 4.05672900e-02f, 3.22883911e-02f, 1.93807501e-02f,
  -2.21292689e-01f, -5.31472266e-02f, -7.50933662e-02f, 4.35833260e-02f, 4.55632918e-02f, 5.27836271e-02f, -1.73175265e-03f, -5.39419353e-02f, -3.93949710e-02f, -4.84069288e-02f,
  -2.35279687e-02f, 4.96541858e-02f, 7.44166747e-02f, -5.05053299e-03f, -9.45090503e-02f, -2.76991110e-02f, -2.69958172e-02f, 4.66489866e-02f, -7.90809095e-02f, 6.11377275e-03f,
  -1.28298076e-02f, -5.44280410e-02f, -1.15273461e-01f, -1.74341798e-02f, -1.49032637e-01f, -1.68004707e-01f, -3.84615026e-02f, -1.20308898e-01f, -1.43574774e-01f, -9.80047658e-02f,
  3.26741338e-02f, -2.86707319e-02f, 1.07051484e-01f, -9.79136676e-02f, -8.67133513e-02f, -3.52862589e-02f, -4.44478206e-02f, -6.21323399e-02f, 1.22954957e-01f, 5.95981479e-02f,
  -6.29999712e-02f, -1.66563857e-02f, 7.98923820e-02f, -8.33407715e-02f, -1.52697891e-01f, -1.53066278e-01f, -1.74077824e-01f, -1.14445247e-01f, -6.32308349e-02f, -1.17338009e-01f,
  -1.29069671e-01f, -4.04871032e-02f, -1.25270665e-01f, -1.51365378e-03f, 4.37755547e-02f, 4.95548919e-02f, 3.49553749e-02f, -5.04973009e-02f, 1.55032882e-02f, 5.27449101e-02f,
  1.20266616e-01f, 4.93873991e-02f, 8.07707310e-02f, -1.18063562e-01f, 3.61385494e-02f, -2.81098783e-02f, 1.29756879e-03f, 1.05437383e-01f, -1.45979933e-02f, 9.05427369e-05f,
  -4.96922247e-03f, -5.92012815e-02f, 2.05378141e-02f, 1.34826489e-02f, -2.05566399e-02f, 2.06191689e-02f, -8.31786916e-02f, -4.27193455e-02f, 6.23217374e-02f, -6.22117594e-02f,
  4.70460486e-03f, -4.03012820e-02f, 2.76652677e-03f, 2.07638219e-02f, 3.16574574e-02f, 3.60194594e-02f, 2.21005771e-02f, 5.14995344e-02f, -4.71914075e-02f, 1.39860868e-01f,
  2.54340041e-02f, 5.39761921e-03f, -1.85649898e-02f, 1.33618983e-02f, -2.34071016e-02f, -5.65078370e-02f, -6.03890084e-02f, -8.83965939e-02f, -6.57971725e-02f, 1.05584525e-01f,
  -1.99865215e-02f, 1.13618020e-02f, -9.46034938e-02f, -9.09229927e-03f, 1.15438933e-02f, -1.58846416e-02f, -8.63464847e-02f, -3.00981943e-02f, -5.45207076e-02f, -5.24372905e-02f,
  -5.80265839e-03f, -2.86645349e-02f, -5.60925640e-02f, -5.55765107e-02f, -8.71864110e-02f, -1.02959760e-01f, -1.19536325e-01f, 5.41421846e-02f, -4.57607582e-02f, -4.58677486e-02f,
  1.71536744e-01f, -9.54873711e-02f, 5.60708251e-03f, -2.90704202e-02f, -8.78081694e-02f, -7.34084919e-02f, -6.35236502e-02f, -1.28989920e-01f, -5.10334447e-02f, -7.89371226e-03f,
  -8.98086950e-02f, -1.14545412e-01f, -4.66465205e-02f, 1.41714681e-02f, -7.41588250e-02f, 3.16036083e-02f, -1.99465185e-01f, -2.49057543e-03f, -5.95601909e-02f, 3.28864111e-03f,
  -1.42932877e-01f, 3.50329839e-03f, -5.97455651e-02f, -3.55694704e-02f, 3.81141528e-02f, -8.44588280e-02f, -2.43116673e-02f, 7.70520121e-02f, -1.12030827e-01f, 8.82727131e-02f,
  -1.26242369e-01f, 1.41969204e-01f, 2.80961931e-01f, 1.25763953e-01f, 9.14890319e-02f, -8.02484825e-02f, -5.31296581e-02f, -8.34116191e-02f, -8.37162882e-02f, -5.68816904e-03f,
  1.22925609e-01f, 2.02499747e-01f, 1.04738764e-01f, 1.43458694e-01f, 1.78323835e-01f, -4.35167961e-02f, 9.10338238e-02f, 2.63085455e-01f, 7.59147182e-02f, 7.76237324e-02f,
  4.36197482e-02f, 1.02240145e-01f, 1.38338462e-01f, 8.20809826e-02f, 8.15661103e-02f, 1.09240174e-01f, 9.23086852e-02f, 1.21132813e-01f, 3.42972465e-02f, 1.18100099e-01f,
  2.32996061e-01f, 1.46204725e-01f, 6.26679063e-02f, 1.88289687e-01f, 8.11741576e-02f, 1.42953247e-01f, 8.06005597e-02f, 9.47231278e-02f, 1.00198224e-01f, 6.84943572e-02f,
  2.27033839e-01f, 9.58855674e-02f, 2.36128464e-01f, 5.48141561e-02f, 6.79535642e-02f, 6.30227178e-02f, 1.54659137e-01f, 1.51107326e-01f, 1.47791594e-01f, 7.18463510e-02f,
  2.84166276e-01f, 2.69290745e-01f, 3.37877348e-02f, 4.97591235e-02f, 3.38153318e-02f, 1.21783428e-01f, 5.84792383e-02f, 1.60367876e-01f, 1.27962351e-01f, -3.18125859e-02f,
  1.53330388e-02f, -4.38875183e-02f, -1.01575881e-01f, -1.30623236e-01f, -3.86416055e-02f, -4.38249186e-02f, 6.76647574e-02f, -5.17320447e-02f, -7.56528452e-02f, -9.30523202e-02f,
  4.53851484e-02f, -7.66540691e-02f, 3.71224768e-02f, -8.46076980e-02f, 3.45531367e-02f, -8.42079297e-02f, 4.15165015e-02f, -1.04616046e-01f, -9.36492160e-02f, -1.12756677e-01f,
  -3.22844014e-02f, -7.39976391e-02f, -3.17954645e-02f, -2.82604247e-02f, -5.79238348e-02f, 4.90238555e-02f, -1.01838708e-02f, -9.07150656e-02f, -4.16054614e-02f, 3.34656681e-03f,
  -2.65049655e-02f, 2.01430440e-01f, -2.94863489e-02f, 5.97179309e-03f, 5.99915534e-02f, 9.15382281e-02f, 5.83105311e-02f, 9.64800641e-02f, 1.17227770e-01f, 1.57878578e-01f,
  2.15338711e-02f, 5.14371321e-02f, 1.08051069e-01f, 9.90013108e-02f, 1.07550912e-01f, 1.22615859e-01f, -7.64224213e-03f, 3.75810973e-02f, 7.18870983e-02f, 1.37785584e-01f,
  -2.78262552e-02f, -5.06693758e-02f, 2.19925344e-02f, -1.02386088e-03f, -5.08446582e-02f, -6.05214871e-02f, -8.99458006e-02f, 1.36179412e-02f, 5.31701893e-02f, -1.36853576e-01f,
  1.34404153e-02f, 1.41306873e-02f, -3.43840599e-01f, -1.84055883e-02f, 6.87042624e-02f, 2.43321806e-01f, 2.94010758e-01f, 1.88023612e-01f, 1.04950368e-01f, -1.57362204e-02f,
  2.15646639e-01f, 5.81447370e-02f, -9.12524983e-02f, -9.69037414e-03f, -1.05337240e-01f, -3.73233035e-02f, -2.02574983e-01f, -2.18539491e-01f, -3.81295681e-02f, 1.95193544e-01f,
  3.00236166e-01f, 1.51866317e-01f, 2.64482759e-02f, -5.62199131e-02f, -2.76940707e-02f, -6.50508925e-02f, -1.69728324e-01f, -5.66947013e-02f, 4.15422767e-02f, -2.44957849e-01f,
  -2.69839227e-01f, -2.04275064e-02f, -4.86124270e-02f, 9.34800953e-02f, 7.75029361e-02f, 6.12063408e-02f, 4.30160761e-02f, -6.58457726e-02f, 4.37238850e-02f, 6.03930280e-02f,
  -5.96692227e-02f, 2.46403925e-02f, -1.00346692e-01f, -8.02504867e-02f, -2.12189443e-02f, 4.87123430e-02f, -1.41765669e-01f, -7.96031877e-02f, -1.85849920e-01f, -6.89161941e-02f,
  8.49199444e-02f, -2.54428498e-02f, -1.32290021e-01f, -3.87282297e-02f, -6.52340651e-02f, -7.24825040e-02f, -4.19825055e-02f, -9.70690623e-02f, -8.64706263e-02f, -4.15616222e-02f,
  4.03325483e-02f, 5.58279045e-02f, 9.10594389e-02f, 5.32273538e-02f, 4.53924276e-02f, -6.38794750e-02f, -3.91074875e-03f, -2.05973703e-02f, 1.21944666e-01f, 7.39112645e-02f,
  8.91642459e-03f, 6.00180812e-02f, 3.94759551e-02f, 6.79076230e-03f, 1.03627622e-01f, -2.85046957e-02f, 1.05454616e-01f, 7.39090666e-02f, 1.16612419e-01f, -4.26361971e-02f,
  3.64603475e-02f, 2.79644374e-02f, 2.63828062e-03f, 5.13254106e-02f, -4.80570644e-03f, 3.75484750e-02f, 3.01785972e-02f, 1.41659424e-01f, 1.07900850e-01f, 9.27767605e-02f,
  9.77378711e-02f, 5.33471741e-02f, -1.33212879e-01f, -7.19607472e-02f, -3.32781076e-02f, -8.13087225e-02f, 4.57175600e-04f, 2.33063027e-02f, 1.75994053e-03f, -2.59235804e-03f,
  8.95933360e-02f, 1.54343853e-02f, -3.90387550e-02f, 4.70432229e-02f, 8.50386247e-02f, 6.56776503e-02f, 1.04723245e-01f, -9.13146138e-03f, 1.57053582e-02f, 3.76479775e-02f,
  -4.32448313e-02f, 4.93142083e-02f, 5.86230829e-02f, -4.60777320e-02f, -3.70223410e-02f, 2.35022772e-02f, 5.71735352e-02f, 5.60039766e-02f, -2.64052935e-02f, 1.95976332e-01f,
  3.05513322e-01f, -3.01470429e-01f, 1.31673431e-02f, 6.59688190e-02f, 1.05088443e-01f, 9.96333361e-02f, 6.83396459e-02f, 1.53719336e-01f, 1.18284658e-01f, -1.55544132e-01f,
  -3.86673957e-02f, 3.87906395e-02f, -5.41865677e-02f, -2.24196147e-02f, 2.12831721e-02f, -3.69010195e-02f, -8.09907466e-02f, 1.24628559e-01f, 3.02609921e-01f, 1.29289314e-01f,
  4.09373976e-02f, 1.09788708e-01f, 1.05521694e-01f, 1.41507715e-01f, -1.34674581e-02f, -2.36696154e-02f, -2.05104560e-01f, -4.58973721e-02f, 4.46827374e-02f, -2.30062112e-01f,
  -4.36523966e-02f, -7.11557120e-02f, 1.03057079e-01f, 6.35084957e-02f, -9.38422307e-02f, 8.33096355e-02f, 7.56743699e-02f, 2.44141743e-02f, -5.40613150e-03f, 3.67906950e-02f,
  1.73278842e-02f, 5.32536954e-02f, 1.10784598e-01f, 3.23533081e-02f, 3.64937559e-02f, 9.91648287e-02f, -1.42913610e-02f, 8.56630877e-02f, -3.79723571e-02f, -6.42281696e-02f,
  -8.70381221e-02f, 3.86812650e-02f, -8.37051310e-03f, -3.06812786e-02f, -3.93020697e-02f, 1.32881477e-01f, 4.66809561e-03f, 3.84892933e-02f, 5.96221313e-02f, 2.71550324e-02f,
  2.00006422e-02f, -5.24206497e-02f, -6.01757094e-02f, 3.43588670e-03f, -3.34176719e-02f, 4.08412516e-03f, -3.63948122e-02f, -2.22627353e-02f, 3.79648320e-02f, 2.49845553e-02f,
  -5.71769439e-02f, -6.78557232e-02f, 1.03197414e-02f, 7.50221685e-02f, -3.71466763e-02f, 2.65314057e-02f, 1.18354604e-01f, -9.18109491e-02f, -3.93051207e-02f, -2.58821249e-03f,
  3.80861647e-02f, 9.20098126e-02f, -5.99743687e-02f, -1.57979056e-02f, -2.90449280e-02f, 5.74397780e-02f, 4.69474047e-02f, 4.84819375e-02f, -3.03664338e-02f, 1.12492051e-02f,
  -1.23899274e-01f, 1.18578322e-01f, 8.10117368e-03f, 1.00083522e-01f, 1.46719888e-01f, 5.25482483e-02f, 5.02759889e-02f, 9.07441527e-02f, 8.76181796e-02f, 8.15521032e-02f,
  4.90872003e-02f, 1.19950384e-01f, -2.67535057e-02f, 4.76163365e-02f, 1.51226014e-01f, 5.70566915e-02f, 3.36859562e-02f, 9.44423825e-02f, 8.36505070e-02f, 3.70371640e-02f,
  2.65022623e-03f, 1.55635297e-01f, 2.02694491e-01f, 7.15416111e-03f, 6.40013739e-02f, 1.91065416e-01f, -1.81520861e-02f, 1.22207746e-01f, 4.81314585e-02f, 6.38391525e-02f,
  3.14169675e-02f, 2.81090319e-01f, 6.29252344e-02f, -3.72110531e-02f, 5.41234128e-02f, 1.48953542e-01f, 3.00304621e-01f, 6.55515715e-02f, -8.06339905e-02f, 1.23622097e-01f,
  3.18406634e-02f, -1.99480832e-01f, -1.55560479e-01f, -3.74607965e-02f, -4.19396302e-03f, 1.46666586e-01f, 1.70748010e-01f, -1.68803751e-01f, -1.32491931e-01f, 1.23572657e-02f,
  -4.30882350e-02f, -3.96194309e-02f, -1.96048077e-02f, -1.49132490e-01f, 1.52430877e-01f, -4.22774963e-02f, 1.08214222e-01f, 1.29919022e-01f, 9.33699161e-02f, 4.47360091e-02f,
  1.04474559e-01f, 1.10699609e-01f, -4.90933023e-02f, -1.20743111e-01f, 1.79178566e-02f, -4.57970314e-02f, 1.99405681e-02f, 5.57699129e-02f, -8.94931033e-02f, 3.41719091e-02f,
  -3.75884809e-02f, -1.08260907e-01f, 3.46361287e-02f, -7.44436011e-02f, 9.72188562e-02f, -2.70709246e-02f, -3.92597988e-02f, -4.96760309e-02f, -8.17448720e-02f, 4.20634225e-02f,
  -8.00515637e-02f, 2.06751842e-02f, -4.81349379e-02f, -2.42729243e-02f, 4.80145104e-02f, -1.04919277e-01f, 1.44766141e-02f, -5.40013798e-02f, 1.77972596e-02f, 3.89714465e-02f,
  1.37203159e-02f, -2.72400342e-02f, -2.18735915e-02f, 6.15974292e-02f, 7.02568814e-02f, 7.28222504e-02f, -1.74662210e-02f, 9.75208078e-03f, 6.06849231e-03f, 5.02810534e-03f,
  -2.01751292e-02f, -1.48329893e-02f, 4.88105603e-02f, 4.56547998e-02f, 6.66822195e-02f, 2.55704112e-02f, 7.25193098e-02f, 8.22810531e-02f, -7.87887797e-02f, 4.43219505e-02f,
  2.54452769e-02f, -8.46035928e-02f, 9.22823474e-02f, 7.45749986e-03f, 1.48102054e-02f, -2.47115586e-02f, 5.91371767e-02f, -2.53108311e-02f, -4.95654903e-02f, -2.38805879e-02f,
  1.09430529e-01f, -9.02685672e-02f, 8.04976597e-02f, 1.41047323e-02f, -2.14711390e-02f, -4.80696522e-02f, 7.15655237e-02f, -1.09012676e-02f, 1.09824911e-01f, 7.56251365e-02f,
  -6.92499503e-02f, 3.58192832e-03f, -2.55442178e-03f, 4.82629128e-02f, -2.88118776e-02f, 1.08011782e-01f, 1.08177528e-01f, 1.01816747e-02f, 7.05080479e-02f, 8.35024379e-03f,
  6.89301714e-02f, 1.00004524e-01f, 9.15496945e-02f, 1.30752623e-01f, 1.21688649e-01f, -1.23266159e-02f, 7.04453662e-02f, 2.65738331e-02f, 1.46537468e-01f, 1.69689983e-01f,
  -2.24220634e-01f, -1.90115407e-01f, -1.18172117e-01f, -2.73769528e-01f, -3.86866070e-02f, 1.46448851e-01f, 1.65409632e-02f, -7.07665458e-02f, 1.13574164e-02f, -1.60896823e-01f,
  -2.69630197e-02f, -1.15445191e-02f, -3.69506236e-03f, -1.90637745e-02f, -9.60829481e-02f, -2.07074329e-01f, -1.13891497e-01f, -9.41324681e-02f, 8.84090960e-02f, 1.00520782e-01f,
  -7.47586340e-02f, 2.71447394e-02f, -4.48651314e-02f, 4.80636619e-02f, -1.02908701e-01f, 6.14804104e-02f, -7.78154433e-02f, 3.16611305e-02f, 1.46494294e-02f, -2.31830776e-01f,
  -1.01173900e-01f, 8.08995590e-02f, 1.83452815e-01f, -1.93578079e-02f, 4.90862243e-02f, 4.84012030e-02f, 3.73904333e-02f, -2.42862999e-02f, 2.74109598e-02f, 1.52112506e-02f,
  -7.01014977e-03f, -2.42062546e-02f, 3.17336316e-03f, 3.28507647e-02f, 3.47633772e-02f, -2.19211150e-02f, 4.55210991e-02f, 2.45623477e-02f, -1.08376127e-02f, 7.09215775e-02f,
  -5.13983667e-02f, 2.31871717e-02f, 1.62196845e-01f, -2.06330721e-03f, 1.10564366e-01f, 1.05882041e-01f, 7.50397593e-02f, 3.21593694e-02f, 4.78766002e-02f, -6.44060522e-02f,
  -5.23897372e-02f, 1.80537514e-02f, 1.22740105e-01f, 5.27608907e-03f, 4.39166240e-02f, -5.41054793e-02f, 3.29099335e-02f, -3.33627313e-02f, -1.61228105e-02f, -9.56343859e-03f,
  -3.05592008e-02f, 5.94037548e-02f, 1.98909640e-03f, 2.02013236e-02f, 1.97068509e-02f, 5.45783006e-02f, 1.12571187e-01f, -1.74790509e-02f, 9.68992934e-02f, 7.20125586e-02f,
  -3.07642389e-02f, 9.69287306e-02f, 3.11666671e-02f, -3.09563777e-03f, 5.86138554e-02f, -1.88984834e-02f, 8.14379975e-02f, 1.27747163e-01f, -5.93618602e-02f, 6.55070925e-03f,
  -1.05900997e-02f, 1.23648159e-01f, -1.16925947e-01f, -2.94076744e-02f, 1.00062648e-02f, 2.32296847e-02f, 6.62516616e-03f, 8.60187318e-03f, 2.08667554e-02f, 4.99266870e-02f,
  5.93869127e-02f, -9.55005959e-02f, 3.33911479e-02f, -4.08457518e-02f, 7.08195474e-03f, 3.64871211e-02f, -1.65918484e-01f, -1.94586255e-02f, 1.44777987e-02f, 3.11172847e-02f,
  -9.14599895e-02f, 1.00929745e-01f, 7.79597610e-02f, -7.12807328e-02f, -2.99311411e-02f, -6.67228401e-02f, -5.34959249e-02f, 1.77975893e-02f, 2.95648677e-03f, -3.63529883e-02f,
  -9.84423310e-02f, 1.34273339e-02f, 1.31736159e-01f, 7.52245635e-02f, 1.01640701e-01f, 3.56029905e-02f, -1.65632993e-01f, -1.49697930e-01f, 7.29764253e-02f, 4.58959639e-02f,
  1.34530097e-01f, 1.62869930e-01f, 1.78905338e-01f, 2.33159304e-01f, 1.24858402e-01f, 1.10813221e-02f, 2.34191820e-01f, 2.20915005e-01f, 1.07275397e-01f, 6.97284425e-03f,
  2.08995745e-01f, 1.06099859e-01f, 1.38579831e-01f, 1.04002118e-01f, 1.08006112e-01f, 1.03518650e-01f, 3.93043533e-02f, 2.04378694e-01f, 1.80451259e-01f, 3.68420720e-01f,
  1.44658625e-01f, 7.79338107e-02f, 3.84385698e-02f, 1.63276464e-01f, 1.79593548e-01f, 2.90099494e-02f, 1.60171270e-01f, 1.29539341e-01f, 2.13354662e-01f, 9.01338160e-02f,
  2.61002451e-01f, 1.65578932e-01f, 1.81941673e-01f, 9.00312439e-02f, 1.13473386e-01f, 1.98777571e-01f, 1.79462180e-01f, 1.71288177e-01f, 8.05547908e-02f, 2.08247826e-01f,
  2.68951833e-01f, 2.05120564e-01f, 1.08904712e-01f, 6.17102720e-02f, 1.29016578e-01f, 2.54677862e-01f, 2.37670079e-01f, 2.03475788e-01f, 8.05274770e-02f, 1.15766555e-01f,
  -6.36816248e-02f, 6.79737004e-03f, 2.22440884e-02f, -3.51839401e-02f, -1.17753915e-01f, -8.98568891e-03f, 9.17283352e-03f, -2.36044964e-03f, -5.84480762e-02f, -9.57170799e-02f,
  -6.85916319e-02f, 3.03976256e-02f, -7.94341862e-02f, -2.11001206e-02f, 2.62565445e-02f, -5.75780720e-02f, 5.01723811e-02f, -3.71555015e-02f, 2.94941049e-02f, -1.52556092e-01f,
  -1.76580958e-02f, -7.81912431e-02f, -1.13874301e-01f, -1.18189044e-01f, -4.06368114e-02f, -3.91370207e-02f, 3.23423557e-02f, -1.52420225e-02f, -8.98758844e-02f, -7.94158429e-02f,
  2.28827316e-02f, 8.36772844e-02f, 1.01540342e-01f, 9.36446190e-02f, 7.06946626e-02f, 1.73563004e-01f, 1.74875125e-01f, 4.94280569e-02f, 1.08623445e-01f, 1.83997363e-01f,
  2.13247716e-01f, 1.11907497e-01f, 7.59818405e-02f, 4.78309728e-02f, 3.85223702e-02f, 1.15358233e-01f, 6.39532804e-02f, 1.84998110e-01f, 5.72718494e-02f, 1.41967744e-01f,
  1.77612245e-01f, 8.54877606e-02f, 9.40948203e-02f, 1.05729364e-01f, 8.80857632e-02f, 4.98905629e-02f, 1.60235643e-01f, 2.52386350e-02f, -9.96723538e-05f, 7.85364360e-02f,
  1.92447364e-01f, -2.42003918e-01f, 1.35738924e-01f, 2.84002423e-02f, -4.41742912e-02f, 1.55434325e-01f, -1.23565905e-01f, 7.48187825e-02f, 7.57535547e-02f, -8.57765600e-02f,
  -1.67052388e-01f, 1.45223156e-01f, 2.15077370e-01f, 2.29056746e-01f, 2.64425576e-01f, 2.19571307e-01f, 3.31557691e-01f, 3.27489585e-01f, 4.22863930e-01f, 2.55051553e-01f,
  1.35280445e-01f, 1.11901924e-01f, 2.84562856e-01f, 2.37924486e-01f, 1.28183505e-02f, 1.64448321e-01f, 1.06855094e-01f, 1.53887361e-01f, 9.75457132e-02f, 1.44139174e-02f,
  1.77835718e-01f, 9.94054154e-02f, 1.02331758e-01f, 1.41080603e-01f, -2.40707435e-02f, 1.18782362e-02f, 2.16002241e-02f, 1.81542173e-01f, 7.35771060e-02f, 5.59448861e-02f,
  4.92886826e-02f, 2.40468439e-02f, 9.99509841e-02f, 1.58072695e-01f, 6.18087202e-02f, 6.63329437e-02f, 5.96162640e-02f, 2.18593776e-01f, 1.11307479e-01f, 3.28362063e-02f,
  -1.28040249e-02f, 8.81496817e-02f, 1.47434205e-01f, 1.07645005e-01f, 1.12046219e-01f, 1.71818912e-01f, -3.58439796e-02f, -2.32258476e-02f, 1.70857817e-01f, -2.95038261e-02f,
  -2.02906623e-01f, 8.27841461e-04f, -3.42534184e-02f, -2.85503194e-02f, -1.23231374e-01f, -3.27065326e-02f, -1.88158092e-03f, -6.34591747e-03f, -6.07061796e-02f, -3.60072367e-02f,
  -9.07310694e-02f, -3.01292795e-03f, -6.40635416e-02f, -6.25589341e-02f, -5.50765693e-02f, 5.93578182e-02f, -3.47837806e-02f, -1.50478363e-01f, -8.64663720e-03f, -4.42705071e-03f,
  -3.90636697e-02f, -5.28535731e-02f, -6.75488934e-02f, -5.12881465e-02f, -3.09029128e-02f, -2.78468756e-03f, 9.81504470e-02f, -3.85679044e-02f, 9.24441516e-02f, 1.04114018e-01f,
  9.68396291e-02f, 1.45975441e-01f, 6.52656704e-02f, 1.14214659e-01f, 1.46259069e-01f, 6.35994552e-03f, -4.65437472e-02f, 7.04374835e-02f, 1.16148591e-01f, 1.15385748e-01f,
  -1.37510244e-02f, 1.26629457e-01f, 2.09217090e-02f, 8.91106352e-02f, 9.27312225e-02f, 1.40437782e-01f, 7.90711492e-02f, 8.22695866e-02f, 1.40549511e-01f, -8.37872475e-02f,
  -2.66521033e-02f, 8.36496279e-02f, 1.60350367e-01f, 7.38822222e-02f, 5.23003116e-02f, 1.38080582e-01f, 4.48171794e-02f, 1.17712609e-01f, 1.29109010e-01f, 5.58467284e-02f,
  -2.27910772e-01f, -6.60319552e-02f, -4.48282063e-02f, -2.16562934e-02f, -5.61099052e-02f, -1.85005471e-01f, -3.54629666e-01f, -1.85880676e-01f, -1.15268089e-01f, -1.06206164e-01f,
  1.18513852e-01f, 1.72758892e-01f, 5.29291667e-02f, 7.31844902e-02f, -1.93677679e-01f, -1.92998126e-01f, -1.40367821e-01f, -1.75788224e-01f, -5.13192788e-02f, -1.03912607e-01f,
  -8.75836909e-02f, -1.29360378e-01f, -1.38033256e-01f, -6.27909303e-02f, 2.70976275e-02f, 3.63029428e-02f, 6.42692447e-02f, -5.38454913e-02f, 6.13733334e-03f, -1.00611530e-01f,
  1.73846439e-01f, -5.60886785e-02f, 6.86219558e-02f, 7.68094286e-02f, 9.81642306e-02f, -7.07309023e-02f, 4.41866927e-02f, -2.48540975e-02f, -1.43681858e-02f, -8.56197551e-02f,
  8.23957697e-02f, -4.42187041e-02f, -1.22185983e-02f, -3.76005820e-03f, -1.55519247e-02f, 8.36257299e-04f, -5.93993329e-02f, -5.82253048e-03f, -8.08897167e-02f, -8.02144185e-02f,
  -3.63853984e-02f, -1.75338294e-02f, -6.47519827e-02f, 2.64995955e-02f, 2.75255559e-04f, 4.72964020e-03f, -6.27543107e-02f, -4.33218293e-02f, -1.85766593e-02f, -4.93727848e-02f,
  -1.37934443e-02f, 8.15096945e-02f, 1.07072964e-02f, 5.95014617e-02f, 9.84959379e-02f, 3.30996811e-02f, 1.95040572e-02f, 4.86868359e-02f, 1.38615854e-02f, 7.86123574e-02f,
  1.45441562e-01f, 3.67146097e-02f, 4.22606058e-02f, 3.01270168e-02f, 1.15519859e-01f, 4.37389612e-02f, 2.70111114e-02f, 7.24293664e-02f, 3.59725505e-02f, 1.35380954e-01f,
  5.16589694e-02f, -3.27202976e-02f, 5.07089607e-02f, 3.34106646e-02f, 1.69328470e-02f, 7.84844160e-02f, 9.38366503e-02f, 1.08067490e-01f, 5.29711060e-02f, -4.29747961e-02f,
  1.45927206e-01f, 6.96072280e-02f, -4.99743186e-02f, -3.80376987e-02f, -1.22292992e-02f, 2.17955839e-02f, -1.40724620e-02f, 1.71151180e-02f, -5.52956834e-02f, -8.03764760e-02f,
  4.95849550e-02f, -4.87539098e-02f, 2.12231595e-02f, 2.10255999e-02f, -9.44049507e-02f, -2.33408138e-02f, -3.20901535e-02f, -5.06191365e-02f, -6.09397946e-04f, 4.14545648e-02f,
  -3.93217504e-02f, -1.16051525e-01f, -6.45590052e-02f, -1.41681165e-01f, 7.63699552e-03f, -3.45183946e-02f, -2.55715027e-02f, 2.82838866e-02f, -3.98342423e-02f, -9.60929617e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.87781304e-01f, -3.57623309e-01f, 2.74045002e-02f, 2.64438182e-01f, 2.31417060e-01f, 2.03083366e-01f, 1.88519642e-01f, 9.79920626e-02f, 2.43003756e-01f, -4.13071178e-02f,
  -1.57007843e-01f, 7.18843937e-02f, -2.40963381e-02f, 2.61252578e-02f, 5.18666506e-02f, 2.75597632e-01f, 3.21913153e-01f, 1.38252333e-01f, 1.97550774e-01f, 1.19917236e-01f,
  1.70323402e-01f, 1.08440399e-01f, -6.40030429e-02f, 1.34689167e-01f, -3.90675338e-03f, 1.79704443e-01f, 4.63817380e-02f, -1.14407472e-01f, -3.19006247e-03f, 1.52148098e-01f,
  -1.61278903e-01f, -2.23682210e-01f, 1.32309824e-01f, -2.36246631e-01f, -1.86552107e-01f, -2.88547367e-01f, -9.46330205e-02f, -4.82783355e-02f, -1.53618187e-01f, 1.32385287e-02f,
  -9.93798375e-02f, -8.46682638e-02f, -3.01876739e-02f, -1.30475149e-01f, -8.74541253e-02f, -4.55190055e-02f, -1.57645807e-01f, 7.00243609e-03f, 4.76353280e-02f, 6.09976333e-03f,
  2.14029942e-02f, -1.07551143e-02f, 3.52664590e-02f, 1.31098628e-01f, 1.05258189e-01f, 7.22350776e-02f, -1.19352005e-01f, -8.58808532e-02f, 3.01315244e-02f, -1.65392347e-02f,
  1.27305627e-01f, 3.49057578e-02f, -8.34657997e-02f, 1.43870875e-01f, 1.64043203e-01f, 1.06252380e-01f, 8.54860842e-02f, 6.84055826e-03f, 1.72873765e-01f, 3.31972260e-03f,
  -7.91418180e-03f, 1.10327676e-01f, 5.16100265e-02f, 9.60170478e-02f, 7.08356360e-03f, -5.30278385e-02f, -4.23069985e-04f, -6.33399859e-02f, -1.49013132e-01f, -5.55879809e-02f,
  6.81970417e-02f, 1.87748130e-02f, -1.78552687e-01f, -5.35375066e-02f, -5.51913306e-02f, 4.66146367e-03f, -4.11768705e-02f, -1.18171349e-01f, -4.71889600e-02f, -7.68825188e-02f,
  8.34985003e-02f, 7.30290264e-02f, 1.09994732e-01f, 2.46598311e-02f, -4.98869345e-02f, -2.48907104e-01f, 7.72775859e-02f, -8.63481686e-02f, -6.84441254e-02f, 2.77155917e-02f,
  -4.34293561e-02f, 1.02252178e-02f, -7.21759498e-02f, 9.81508642e-02f, 2.18423858e-01f, 3.10384072e-02f, -1.14291795e-01f, 4.89309756e-03f, 1.32951528e-01f, -2.07971916e-05f,
  -4.12053242e-02f, 2.41710156e-01f, 1.43947452e-01f, 2.49889299e-01f, 1.99973792e-01f, 1.60196915e-01f, 5.47474325e-02f, 1.19607501e-01f, 6.28771866e-03f, 1.25846177e-01f,
  -5.83938241e-01f, -3.05118829e-01f, 4.28645825e-03f, -3.29435349e-01f, -2.98900217e-01f, -7.27898031e-02f, -2.93989867e-01f, -1.03765771e-01f, -2.26144269e-01f, -3.09720099e-01f,
  1.01018675e-01f, 2.62165219e-01f, 1.85826883e-01f, 1.53030202e-01f, 1.52267754e-01f, -2.69635648e-01f, -3.26710403e-01f, 1.43083895e-03f, 2.40015134e-01f, 3.76924500e-02f,
  -4.03597765e-02f, -3.08809072e-01f, -1.60426363e-01f, -1.56028658e-01f, -1.69922993e-01f, -1.08606696e-01f, -2.48132110e-01f, -5.90345897e-02f, -9.68858749e-02f, -3.29732329e-01f,
  3.20875496e-02f, 4.78731133e-02f, 1.35278448e-01f, -2.86890361e-02f, -7.52549395e-02f, -2.11270470e-02f, -1.19542137e-01f, -8.74372050e-02f, -3.32668535e-02f, 3.76070887e-02f,
  -9.84662473e-02f, -3.47026698e-02f, 9.89564322e-03f, 2.91202180e-02f, -1.71570837e-01f, 3.34038138e-02f, 4.60818484e-02f, 8.67818445e-02f, 1.86131820e-02f, 1.26172647e-01f,
  1.27255619e-01f, 8.13521668e-02f, 6.07059076e-02f, 4.74588014e-02f, 2.44670421e-01f, 1.68256193e-01f, 6.08517788e-02f, 5.57210371e-02f, 1.04772784e-01f, -1.58214509e-01f,
  -1.01373710e-01f, -2.62902472e-02f, 8.35722964e-03f, 9.51679796e-02f, 8.42170790e-02f, -9.28136855e-02f, -2.26504914e-02f, -2.37644706e-02f, 9.40923914e-02f, -4.58831713e-02f,
  -5.35359830e-02f, 6.39644563e-02f, 1.07489929e-01f, -6.43868372e-02f, -2.60012411e-03f, -4.32704277e-02f, -1.72267586e-01f, -7.26111084e-02f, 2.64665112e-02f, -1.99899860e-02f,
  1.31554112e-01f, 2.80900858e-02f, -7.92699903e-02f, -1.06377468e-01f, -3.07587627e-02f, -9.41222012e-02f, 1.05145402e-01f, 4.15703095e-02f, -9.17339325e-02f, 3.54022123e-02f,
  1.14850402e-01f, 2.23404124e-01f, -1.15605868e-01f, -4.03576605e-02f, -3.98322754e-02f, -1.56516600e-02f, 1.31742014e-02f, -1.03733107e-01f, -7.34098628e-02f, 1.30144730e-02f,
  6.54723793e-02f, -4.99562174e-02f, -9.76555198e-02f, -4.69671860e-02f, 1.73475370e-02f, 4.68863025e-02f, -4.11578827e-02f, 2.93188659e-03f, 8.33497867e-02f, -3.59814167e-02f,
  -7.04978332e-02f, 4.64747921e-02f, -1.10559547e-02f, 1.61441594e-01f, 1.15356147e-01f, 8.62407982e-02f, 9.57369655e-02f, 5.97429834e-02f, -4.48396653e-02f, -2.46402115e-01f,
  -8.94808054e-01f, -2.00097695e-01f, 7.02895075e-02f, -3.58733594e-01f, -2.14488998e-01f, -1.95352025e-02f, 2.81958170e-02f, -2.01639369e-01f, -3.55949789e-01f, -6.60366267e-02f,
  -6.39710799e-02f, 3.28268968e-02f, 5.95185496e-02f, 1.25896588e-01f, -6.22858992e-03f, 1.64776921e-01f, -3.67075838e-02f, -6.68604597e-02f, -4.40837331e-02f, -9.83460173e-02f,
  -9.58157703e-02f, -2.19008043e-01f, -3.44174534e-01f, -1.85305595e-01f, -1.93176612e-01f, -5.49792731e-03f, 5.56506440e-02f, -5.77896200e-02f, 6.89223930e-02f, -1.11150518e-02f,
  5.11719525e-01f, -1.26486465e-01f, 3.25103998e-02f, -2.17798561e-01f, -8.24390054e-02f, -9.27308649e-02f, -1.61240712e-01f, -1.16670594e-01f, -5.58967106e-02f, -1.22887991e-01f,
  -7.61989206e-02f, -5.21758907e-02f, -7.99107850e-02f, -1.33563623e-01f, -3.37845236e-02f, -9.90108624e-02f, -1.74590155e-01f, -1.22772641e-01f, 6.54381467e-03f, 1.15205526e-01f,
  -4.83295321e-02f, -1.06142230e-01f, -5.87673634e-02f, 1.61111001e-02f, 8.37221071e-02f, -6.21101214e-03f, 2.91303322e-02f, -8.96929577e-02f, 6.36924207e-02f, -1.63652152e-01f,
  6.80082068e-02f, -7.96454623e-02f, -2.11989582e-02f, -1.72417816e-02f, -7.41702551e-03f, 2.52647847e-02f, 1.38918906e-02f, 1.18346829e-02f, -7.64407171e-03f, -9.00916159e-02f,
  2.53697131e-02f, 9.69183818e-02f, -5.08470759e-02f, -2.46691220e-02f, -1.13970846e-01f, -1.00793563e-01f, -1.04794472e-01f, 3.83580215e-02f, -2.80950479e-02f, -1.54482841e-01f,
  -1.09936751e-01f, 3.92071716e-02f, -9.06999856e-02f, -1.55056551e-01f, -1.06116436e-01f, -7.34060630e-02f, -1.33889034e-01f, 3.39151658e-02f, -1.26219764e-01f, -1.21986434e-01f,
  1.52659342e-01f, 1.08219102e-01f, 1.64029852e-01f, 2.99428962e-02f, 6.11412637e-02f, -1.85674448e-02f, -2.67822314e-02f, 7.06895888e-02f, -2.47334503e-02f, 1.20186016e-01f,
  1.17908143e-01f, -3.63202952e-02f, 1.18220672e-01f, 2.90932376e-02f, 8.55189934e-02f, -4.80823368e-02f, -5.83952591e-02f, -2.28281114e-02f, 1.44175127e-01f, 4.83033247e-02f,
  -2.85662012e-03f, -4.19326685e-02f, 1.47017941e-01f, 9.69755948e-02f, 7.81887695e-02f, 2.49083742e-01f, 2.15582490e-01f, 1.57347456e-01f, 2.41271317e-01f, 3.69372405e-02f,
  -6.57267749e-01f, 1.04819797e-01f, 9.98780653e-02f, -1.16576627e-01f, -3.50558907e-02f, -2.56984252e-02f, 6.82676360e-02f, 4.50594947e-02f, -2.30866205e-02f, 7.13039413e-02f,
  7.31445774e-02f, -6.47496283e-02f, -1.88323185e-01f, -1.46565959e-01f, -1.66395709e-01f, 1.46665573e-02f, -1.58839017e-01f, -3.18539619e-01f, -2.82701641e-01f, -1.47698388e-01f,
  -6.60823658e-02f, -2.98396915e-01f, -4.28938866e-01f, -2.75724351e-01f, 1.45345018e-03f, -3.16459239e-01f, -1.35260627e-01f, -1.90383181e-01f, -1.64575249e-01f, -1.54688746e-01f,
  1.93355799e-01f, -4.73446772e-02f, -1.44634247e-02f, -1.56120330e-01f, 2.73590945e-02f, 7.95993358e-02f, -6.77721128e-02f, -3.26457135e-02f, 5.66921830e-02f, 1.30376622e-01f,
  1.30463183e-01f, 1.23682708e-01f, 3.90971005e-02f, 1.51484028e-01f, 9.43547413e-02f, 1.58628315e-01f, 1.85982168e-01f, 5.17028850e-03f, -2.76503097e-02f, 2.42263749e-01f,
  9.54760090e-02f, 4.51882407e-02f, 2.22332049e-02f, 8.79365131e-02f, 1.51801556e-01f, 8.14912394e-02f, 5.19514121e-02f, -1.10677695e-02f, 7.39561617e-02f, -1.71051454e-02f,
  -1.14979893e-01f, -1.04111999e-01f, -1.86263919e-02f, -6.51678443e-02f, 5.92948124e-02f, 1.07454704e-02f, -6.22259192e-02f, -1.47443973e-02f, -7.00171068e-02f, 7.20663443e-02f,
  1.36751786e-01f, 3.85529548e-02f, 8.69738460e-02f, -1.80411991e-02f, 9.49940737e-03f, -8.08764324e-02f, -9.40064490e-02f, -2.76552956e-03f, 9.64845642e-02f, 8.20085779e-02f,
  5.11567257e-02f, 8.93406197e-02f, 1.00672267e-01f, 1.06357872e-01f, 1.42300516e-01f, 9.21374634e-02f, 1.94206849e-01f, 5.07261008e-02f, 1.13814756e-01f, 9.53907706e-03f,
  -5.59968390e-02f, -1.37105584e-01f, -3.10251135e-02f, -1.33209243e-01f, -8.71312805e-03f, 1.44526675e-01f, 4.60814917e-03f, 6.18833415e-02f, 6.68808669e-02f, 1.01329274e-01f,
  1.31197751e-01f, 5.71591891e-02f, -1.59273930e-02f, 1.63446039e-01f, -1.74993686e-02f, 1.03526101e-01f, 2.55859317e-03f, -6.86713308e-02f, 4.80465516e-02f, 1.56337589e-01f,
  2.09887236e-01f, -6.56662583e-02f, -5.35312705e-02f, 5.18192500e-02f, 5.24597168e-02f, -6.83583915e-02f, -4.67820466e-02f, 6.40609711e-02f, -7.86580220e-02f, 2.46025790e-02f,
  -2.09670976e-01f, -8.49394724e-02f, -2.42426872e-01f, -7.56066144e-02f, 2.93484777e-02f, 1.43386066e-01f, 1.34043962e-01f, 1.26237363e-01f, 8.40584710e-02f, -2.17949212e-01f,
  1.20999336e-01f, 7.07841590e-02f, -4.86406498e-02f, 4.98124622e-02f, 2.89618075e-02f, -2.46708035e-01f, -3.44964415e-01f, -7.25437552e-02f, 1.63903907e-01f, 2.60399371e-01f,
  1.89758807e-01f, -2.06504436e-03f, -4.16664109e-02f, -2.34382581e-02f, -2.30474219e-01f, -1.54065281e-01f, -3.68113846e-01f, -1.94871649e-01f, -1.62026182e-01f, -5.22951066e-01f,
  -9.59055424e-02f, 6.02906533e-02f, 1.55555442e-01f, -3.72641459e-02f, -3.19757015e-02f, 1.78892657e-01f, 1.69518083e-01f, -5.26035354e-02f, 8.93432647e-02f, -3.12592499e-02f,
  -6.80092201e-02f, 1.22355215e-01f, -1.30532607e-01f, 1.39814928e-01f, -5.78254387e-02f, 7.52177909e-02f, 3.91869893e-04f, -7.15222955e-02f, -1.15831783e-02f, 1.62266850e-01f,
  1.06902324e-01f, -1.00362502e-01f, -8.70679170e-02f, 1.95488650e-02f, -1.79403126e-02f, -1.26926288e-01f, -6.84332103e-02f, -3.09181381e-02f, -1.06729999e-01f, -2.03800157e-01f,
  6.07169755e-02f, -1.51992723e-01f, -1.25500575e-01f, 9.91747677e-02f, -3.84520069e-02f, -6.16187379e-02f, -9.88501310e-02f, -1.90988835e-02f, -1.24158487e-01f, -1.13557458e-01f,
  -8.13179463e-02f, -5.28235361e-03f, -1.83421429e-02f, -1.27890497e-01f, -2.05217987e-01f, -3.41154821e-03f, -6.60548955e-02f, -1.31641626e-01f, -8.71800855e-02f, -4.32860889e-02f,
  8.69703386e-03f, -4.46216762e-02f, -5.86562976e-02f, -9.97193456e-02f, -1.06503986e-01f, -1.58661380e-01f, -4.64140289e-02f, 4.86380644e-02f, 1.91114724e-01f, 3.45974192e-02f,
  1.35521935e-02f, -1.10177219e-01f, -1.58763409e-01f, 1.55444862e-02f, -1.49131134e-01f, -1.86903164e-01f, 3.34743150e-02f, -4.55775484e-02f, -6.39026240e-02f, 7.25525841e-02f,
  -1.50005920e-02f, -4.85127158e-02f, -2.58168757e-01f, 3.34118977e-02f, 7.57537410e-02f, -4.47917059e-02f, -3.13322730e-02f, -8.05027038e-02f, -6.13913545e-03f, -5.47267348e-02f,
  -1.41960800e-01f, -8.57867301e-02f, -5.78432679e-02f, -1.19608156e-01f, -6.86453655e-02f, 1.41886491e-02f, -1.29920259e-01f, -4.03174534e-02f, -7.02013224e-02f, -1.45287007e-01f,
  3.09079438e-01f, -3.30403090e-01f, 9.03495699e-02f, 2.36568034e-01f, 2.37860769e-01f, 2.88492739e-01f, 2.49372497e-01f, 1.57643512e-01f, 2.70319521e-01f, -5.49621619e-02f,
  -2.22695023e-01f, -8.39875489e-02f, -2.23786920e-01f, -1.75472274e-01f, -1.92521028e-02f, 2.11197197e-01f, 2.05944136e-01f, 2.31305808e-01f, 2.18154028e-01f, 2.30333060e-01f,
  1.28702283e-01f, 2.68493555e-02f, 9.03874561e-02f, 1.45401329e-01f, -2.26222370e-02f, -9.59986076e-02f, -6.45859614e-02f, -1.30981142e-02f, -1.47738591e-01f, 2.82063838e-02f,
  -2.19933733e-01f, -1.77020684e-01f, -3.05961911e-02f, -1.03371508e-01f, -1.68515667e-01f, -1.33356825e-01f, 1.37439491e-02f, -9.23871621e-02f, -6.05741926e-02f, 4.79368977e-02f,
  -1.06660284e-01f, -1.97372749e-01f, -9.23272520e-02f, -1.01942822e-01f, 9.08611156e-03f, -2.65719518e-02f, -9.69936326e-02f, -7.39226525e-04f, -9.31796283e-02f, -1.12599507e-01f,
  -7.88250938e-02f, 4.92790341e-03f, -4.19078432e-02f, 2.17084810e-02f, -2.52585877e-02f, 2.99138413e-03f, 2.21895939e-03f, -4.53702509e-02f, -2.58708019e-02f, 4.00864035e-02f,
  2.81530619e-01f, 5.38320132e-02f, -1.74103409e-01f, 4.74134041e-03f, 1.48392450e-02f, 7.36459494e-02f, -1.48667712e-02f, -4.97694463e-02f, 4.57052849e-02f, -3.71069461e-02f,
  -1.02263592e-01f, -1.11737244e-01f, 2.56210193e-03f, -5.73514476e-02f, -5.78438938e-02f, -4.92132865e-02f, 3.86733152e-02f, -1.16242833e-01f, -2.73910612e-01f, -1.44519612e-01f,
  -2.18534887e-01f, -3.74416187e-02f, -1.03771418e-01f, -3.81281637e-02f, -4.65146564e-02f, -5.39441742e-02f, -8.46522525e-02f, -1.57695666e-01f, 2.76714712e-02f, -7.67967924e-02f,
  -1.40008777e-01f, -2.15206861e-01f, -6.75144345e-02f, -1.22014433e-01f, -9.23267007e-02f, -1.26850575e-01f, -1.52342185e-01f, -1.43532276e-01f, 4.81010042e-02f, 9.90246143e-03f,
  4.29006927e-02f, -5.92418499e-02f, -1.19757719e-01f, -8.57402980e-02f, 1.64960355e-01f, 1.46221861e-01f, -6.67274056e-04f, 2.24806499e-02f, 9.39229578e-02f, -4.74588946e-03f,
  -4.32670531e-05f, 1.41956240e-01f, 1.13770805e-01f, 8.49639401e-02f, 9.30751637e-02f, 1.25846073e-01f, 5.09426780e-02f, 1.39469981e-01f, 1.70944631e-01f, 1.76682010e-01f,
  1.79545432e-01f, -2.91114688e-01f, 4.40977454e-01f, -1.44374352e-02f, -3.06053013e-01f, -3.71199936e-01f, -5.53905010e-01f, -3.23561490e-01f, -3.28555964e-02f, -9.65782925e-02f,
  -1.74639747e-01f, 1.21222418e-02f, 2.22466975e-01f, 3.19228470e-01f, 1.84056029e-01f, -3.13325636e-02f, 2.95498103e-01f, 5.16864061e-01f, 4.02398437e-01f, 1.00926198e-01f,
  -1.72091722e-01f, 1.50692880e-01f, 3.71106327e-01f, 2.11556554e-01f, -9.48136672e-02f, -8.48590583e-03f, 6.09647818e-02f, -3.90009116e-03f, 1.64117496e-02f, 3.78333062e-01f,
  2.75005668e-01f, -1.38994783e-01f, 1.15404949e-01f, 1.09033123e-01f, 5.07063605e-02f, 1.30895138e-01f, -2.31489204e-02f, 1.08199485e-01f, -2.79695205e-02f, 1.48063272e-01f,
  -6.77195489e-02f, -6.87053427e-02f, -7.71781206e-02f, 2.56987959e-02f, -2.10756883e-02f, -1.31836850e-02f, 1.34151801e-01f, 2.56799430e-01f, 1.05669223e-01f, 1.38543313e-02f,
  -8.11498836e-02f, -2.79999882e-01f, -1.37902841e-01f, -1.65532485e-01f, -2.92287227e-02f, -3.59651691e-04f, -5.37745170e-02f, 7.11970851e-02f, -7.46433111e-03f, 1.15018770e-01f,
  3.69695984e-02f, 5.34392297e-02f, 5.23291454e-02f, 1.02769122e-01f, 3.78318056e-02f, -2.25761365e-02f, 6.54469579e-02f, -7.85220414e-02f, 1.00807451e-01f, 8.92970338e-02f,
  1.10951504e-02f, 1.23640358e-01f, 3.50545421e-02f, 3.20335142e-02f, 4.67314348e-02f, 8.01143125e-02f, 3.67225311e-03f, 7.81476647e-02f, -2.78472193e-02f, 8.55448321e-02f,
  1.07526213e-01f, 6.68251887e-02f, 8.46180245e-02f, 1.24596402e-01f, 2.07564123e-02f, 4.76176143e-02f, -2.85421796e-02f, -4.05074917e-02f, 6.72402186e-03f, -5.96070290e-02f,
  -2.00954318e-01f, -9.61613208e-02f, 9.08818245e-02f, 1.87318802e-01f, -1.89122081e-01f, -1.43475011e-01f, 3.92531604e-02f, -3.71671431e-02f, -1.33217275e-01f, -1.53163178e-02f,
  -7.87578747e-02f, -6.31299429e-03f, -1.14117116e-01f, -1.21152297e-01f, -7.02283159e-02f, -1.32053241e-01f, -5.09804338e-02f, 6.00836426e-02f, -3.55583690e-02f, -1.38966702e-02f,
  6.33300468e-02f, -1.98178023e-01f, -1.88655943e-01f, -1.95375964e-01f, -2.06763461e-01f, -1.84460238e-01f, -1.74508393e-01f, -1.42262906e-01f, -2.17375383e-01f, -2.49111757e-01f,
  5.52720070e-01f, 3.09133798e-01f, -1.42151967e-01f, 1.93949327e-01f, 2.00823590e-01f, 1.82010338e-01f, 3.17779630e-01f, 3.26911330e-01f, 2.17788175e-01f, 1.06707700e-01f,
  2.84602195e-01f, 1.65230200e-01f, -7.20235184e-02f, -9.62164029e-02f, -2.59321034e-02f, -1.69959232e-01f, -3.96079242e-01f, -2.60130227e-01f, 5.94860129e-02f, 1.70790255e-01f,
  1.78964525e-01f, 2.44049057e-01f, 2.43893147e-01f, -7.08248559e-03f, 8.11910108e-02f, -1.68953225e-01f, -1.35406241e-01f, 1.38173684e-01f, 8.30344111e-02f, -3.02371204e-01f,
  -7.71737024e-02f, 4.05264974e-01f, -3.04405093e-01f, 2.46495027e-02f, 1.69976577e-01f, -3.72207649e-02f, 5.39131742e-03f, -2.06131078e-02f, -1.85281001e-02f, -1.00131102e-01f,
  -1.88875478e-02f, -1.51310405e-02f, 1.05520666e-01f, 1.34202555e-01f, 1.33042857e-01f, 1.26149263e-02f, -2.84737982e-02f, -6.15241900e-02f, -4.29331400e-02f, 9.23976824e-02f,
  -4.83892560e-02f, 9.58285120e-04f, 3.30245011e-02f, -9.51069519e-02f, 8.81288573e-02f, -1.21449865e-01f, -1.18048918e-02f, 8.92133936e-02f, -6.74297139e-02f, -9.92083922e-02f,
  -1.86069325e-01f, -1.27383724e-01f, 2.19373517e-02f, 6.33826032e-02f, -1.77275494e-03f, -1.40569985e-01f, -6.23648316e-02f, -6.39545918e-02f, 6.61930814e-02f, 1.21822931e-01f,
  2.46711709e-02f, -1.62992954e-01f, -5.72984256e-02f, -7.29867145e-02f, -1.74185798e-01f, 3.82441953e-02f, 6.49986416e-02f, -4.89839800e-02f, -1.83469206e-02f, 1.07837163e-01f,
  5.65349832e-02f, -1.18181229e-01f, 1.48323491e-01f, 2.27393787e-02f, -5.38082123e-02f, -9.04973373e-02f, -1.46292508e-01f, 1.53512523e-01f, 1.02328062e-02f, -6.01627193e-02f,
  2.60472447e-01f, 3.21755745e-02f, -2.79754698e-01f, 5.97193018e-02f, 3.17850187e-02f, 3.95993516e-02f, -6.77164271e-02f, -2.53556184e-02f, 1.24351904e-02f, -3.88142057e-02f,
  6.80280179e-02f, -6.00543059e-02f, 6.43646419e-02f, 3.75268944e-02f, -1.10867068e-01f, -7.73900822e-02f, -3.15923356e-02f, -9.94418710e-02f, -7.05975145e-02f, 2.57848985e-02f,
  3.22542265e-02f, -1.34822413e-01f, -1.54736936e-01f, -2.46020079e-01f, -1.44083023e-01f, -2.24331498e-01f, -9.20349509e-02f, -7.52989799e-02f, -1.57580659e-01f, -3.71908545e-01f,
  6.58205986e-01f, -4.70835716e-02f, -7.99715877e-01f, 1.86002165e-01f, -5.29930770e-01f, -4.69564319e-01f, -4.36449081e-01f, 2.16663450e-01f, 3.52540940e-01f, -2.56465167e-01f,
  -1.95006400e-01f, 4.16293219e-02f, -2.06136778e-01f, -1.02718428e-01f, -9.04568657e-02f, -4.15532082e-01f, -4.83337224e-01f, -2.70429611e-01f, -1.31555945e-01f, 1.09111834e-02f,
  3.01575791e-02f, 1.10743150e-01f, 1.85825497e-01f, 5.81720285e-02f, -1.31378308e-01f, -1.25053138e-01f, -4.35473114e-01f, -9.14650485e-02f, -3.82557839e-01f, -3.73227358e-01f,
  -4.67259616e-01f, -1.83955431e-01f, -2.01448724e-01f, 1.02573030e-01f, -1.67550057e-01f, 4.24139909e-02f, -6.43263832e-02f, -1.53858634e-02f, -3.32453996e-02f, -4.64704521e-02f,
  -6.72890991e-02f, -6.93969056e-02f, -9.11835209e-02f, -7.65729249e-02f, -1.02511190e-01f, -6.44061491e-02f, 4.70368862e-02f, -1.04719788e-01f, -9.15825292e-02f, -1.00073755e-01f,
  -2.16470994e-02f, -1.61096990e-01f, -2.49524966e-01f, -1.36978626e-01f, -1.99429497e-01f, -1.75121397e-01f, -1.45383865e-01f, -2.78074861e-01f, -4.04977947e-01f, 1.32023087e-02f,
  6.65537044e-02f, -6.05806559e-02f, -7.45636970e-02f, 6.62362203e-02f, 1.77829280e-01f, -5.82798235e-02f, 4.39212695e-02f, 6.17717244e-02f, 2.66229324e-02f, 1.12480499e-01f,
  9.79568227e-04f, -4.89149094e-02f, 5.09560741e-02f, -1.81290898e-02f, -9.99976769e-02f, -1.52248023e-02f, -1.39203936e-01f, -4.89143133e-02f, -1.61740966e-02f, -1.14327479e-04f,
  -1.00561297e-02f, 4.19060662e-02f, 6.96226070e-03f, -6.31683022e-02f, -1.09158933e-01f, 2.21351702e-02f, -3.47308777e-02f, 3.32773291e-02f, 5.05499244e-02f, -7.74963200e-02f,
  2.60059446e-01f, -1.14478320e-01f, 5.74526824e-02f, 6.97103590e-02f, -7.42887631e-02f, 5.49549311e-02f, 4.03573774e-02f, 5.58628142e-02f, 1.21787414e-01f, 2.49013435e-02f,
  -1.15810074e-01f, 4.60077403e-03f, -9.22905654e-02f, 1.55636281e-01f, -3.03527620e-02f, -8.26048627e-02f, 1.02396935e-01f, 4.64825518e-02f, 1.07780457e-01f, 4.11570407e-02f,
  7.55558088e-02f, 4.50871699e-02f, 1.06802240e-01f, 8.39142725e-02f, 7.98590556e-02f, 8.43386203e-02f, 1.94120482e-02f, -1.08548990e-02f, 2.63356604e-02f, 3.02167803e-01f,
  -4.58526343e-01f, 4.35905874e-01f, -1.86185151e-01f, -2.93887053e-02f, 2.93434530e-01f, 2.14062974e-01f, 3.91991615e-01f, 2.36016605e-02f, -1.10840555e-02f, 9.50924754e-02f,
  -1.53213525e-02f, -1.75117135e-01f, 8.42956454e-03f, 1.06738031e-01f, -7.25780800e-02f, 2.84928083e-01f, 3.95646095e-01f, 1.94806512e-02f, -2.38560334e-01f, -2.07111210e-01f,
  7.84136280e-02f, -1.40299648e-01f, -4.16896552e-01f, -5.50821498e-02f, 1.05909668e-01f, 8.96007717e-02f, 1.59736693e-01f, 1.74751959e-03f, 2.18375251e-01f, 3.03928643e-01f,
  -3.34400415e-01f, -2.96907634e-01f, 7.79720843e-02f, 3.13387588e-02f, -1.33970574e-01f, -1.87327936e-01f, 2.18096226e-02f, -1.25366464e-01f, 1.70360170e-02f, -2.60915589e-02f,
  -8.51423219e-02f, -4.40878123e-02f, 6.06339984e-02f, -6.06438443e-02f, -8.00598338e-02f, -2.03160062e-01f, -5.31181432e-02f, -1.58814177e-01f, -2.17685968e-01f, -3.28119457e-01f,
  4.15458113e-01f, -1.31101817e-01f, -3.32565457e-01f, 3.26141119e-02f, -2.25468621e-01f, -1.60586029e-01f, -2.55483687e-01f, -1.14341281e-01f, -2.52604872e-01f, -1.03478648e-01f,
  -3.57340127e-02f, -1.89513713e-01f, 3.96483876e-02f, 4.02122550e-02f, -2.34906238e-05f, 2.19557155e-02f, 1.78814739e-01f, 5.40359765e-02f, 1.48684353e-01f, -1.35757634e-03f,
  -9.52822492e-02f, -1.33651286e-01f, -2.13561028e-01f, -1.45667806e-01f, -8.81831199e-02f, -9.56207737e-02f, 7.69793615e-02f, 1.08518802e-01f, 6.17589569e-03f, 2.34545469e-02f,
  -5.25441244e-02f, -9.34079513e-02f, 1.25522390e-02f, -6.88058063e-02f, 4.36267368e-02f, 4.74606752e-02f, 3.23890559e-02f, 4.42740060e-02f, -1.93089128e-01f, -2.91364472e-02f,
  -1.65370867e-01f, 3.00359279e-02f, 2.21985113e-02f, 6.66573793e-02f, -7.98475593e-02f, -8.05205777e-02f, -9.27664042e-02f, -5.98673373e-02f, -7.49990940e-02f, -1.76118195e-01f,
  -8.60134587e-02f, -2.01839536e-01f, -3.22306529e-02f, 8.58578980e-02f, -8.23393241e-02f, -1.09126866e-01f, 1.81995079e-01f, 7.06351846e-02f, 3.13150026e-02f, -1.39563978e-01f,
  2.30142981e-01f, -2.39728149e-02f, -9.90272686e-02f, -6.62003011e-02f, -6.49141595e-02f, -5.20746037e-02f, -1.83297426e-01f, -9.05392691e-02f, -1.41086459e-01f, 5.22741377e-02f,
  -3.47936511e-01f, -5.94460741e-02f, -1.84313700e-01f, 2.71730959e-01f, 2.91058540e-01f, 1.45865738e-01f, -8.19617882e-03f, -6.04740456e-02f, 9.97653604e-02f, 1.30555093e-01f,
  1.94936395e-01f, 2.24159881e-01f, 2.53380924e-01f, 2.00056344e-01f, 8.78040045e-02f, 4.89607900e-02f, 4.51291166e-02f, -4.52615395e-02f, -1.02818921e-01f, 2.90751904e-02f,
  2.29835972e-01f, -3.10975797e-02f, -1.89353377e-01f, -3.95910628e-02f, 1.84712574e-01f, 2.81367511e-01f, 7.92373642e-02f, 6.96352869e-02f, 7.22922683e-02f, 2.47442558e-01f,
  3.12339932e-01f, -2.63680387e-02f, 2.06515081e-02f, 1.09042712e-02f, -9.59556252e-02f, -2.38821268e-01f, -1.11536801e-01f, -2.21526667e-01f, -1.98498517e-01f, -1.40744835e-01f,
  -6.86461255e-02f, -6.02196306e-02f, 1.06438689e-01f, -5.91663085e-02f, -1.86631680e-01f, -1.81659237e-01f, -1.58778369e-01f, -1.00178093e-01f, 6.34782091e-02f, 6.94008777e-03f,
  2.81006157e-01f, 3.88357416e-02f, -9.77565944e-02f, 5.25907334e-03f, -4.06029038e-02f, 2.43560486e-02f, -1.34346783e-01f, -1.83017656e-01f, -2.03114003e-01f, -1.95583925e-01f,
  1.38397694e-01f, -1.35384321e-01f, 5.00231348e-02f, -1.77172981e-02f, 8.75971168e-02f, 4.54708524e-02f, 2.40161400e-02f, 1.34645402e-02f, -4.49797735e-02f, -3.74670960e-02f,
  1.15407072e-02f, 1.66348219e-01f, 3.99929956e-02f, -5.53302467e-02f, 1.06892116e-01f, -4.99540381e-02f, -9.14177224e-02f, -4.59251320e-03f, -5.12621142e-02f, -3.26060131e-02f,
  1.21089078e-01f, -9.72378775e-02f, -6.87428191e-02f, 4.03095707e-02f, -1.11011893e-01f, -9.14368108e-02f, -1.04913987e-01f, -3.36880311e-02f, -9.55427065e-02f, -1.72147322e-02f,
  2.99200326e-01f, 2.27955148e-01f, 2.46332109e-01f, 1.08228870e-01f, 7.53969923e-02f, -7.61454850e-02f, 1.33780047e-01f, 8.04663152e-02f, 1.37969404e-01f, 6.91733956e-02f,
  -1.95577871e-02f, -6.27785102e-02f, -4.58153300e-02f, -2.85677612e-02f, -7.46874362e-02f, -1.33324810e-03f, -1.58697460e-02f, 1.81204677e-01f, 1.23943701e-01f, 1.21057741e-01f,
  -3.92214432e-02f, -1.48746353e-02f, 3.04528233e-02f, 4.90960516e-02f, 9.16288197e-02f, 8.88896212e-02f, -1.19639479e-01f, -1.44327283e-02f, -1.59915164e-01f, -2.60477930e-01f,
  4.33947712e-01f, 6.94797337e-02f, 1.82486638e-01f, 5.17451577e-02f, -2.24275470e-01f, -7.81769454e-02f, -1.00538008e-01f, 1.05125800e-01f, -2.16051824e-02f, 6.27067015e-02f,
  -1.77482411e-01f, 2.60190456e-03f, -2.07373779e-02f, 7.98299834e-02f, 2.09957615e-01f, 1.73092872e-01f, 2.86116242e-01f, 3.41170579e-01f, 2.82694399e-01f, 7.00016096e-02f,
  5.15303984e-02f, 6.91397712e-02f, 2.97705561e-01f, 2.04254702e-01f, 1.70610651e-01f, -4.04662825e-02f, 6.01789318e-02f, 1.45880967e-01f, 5.62532693e-02f, 1.69348553e-01f,
  -3.07360739e-01f, 2.65973300e-01f, -1.79870334e-02f, -5.19040413e-03f, -1.07299514e-01f, 4.52368222e-02f, 1.85766239e-02f, 2.68731359e-02f, -1.20630831e-01f, -1.57980964e-01f,
  -8.53198692e-02f, 9.12390426e-02f, -3.10167391e-02f, -4.36839275e-02f, -1.15772942e-02f, -3.37001570e-02f, 2.23178849e-01f, 2.45418727e-01f, 1.40905362e-02f, -1.00432105e-01f,
  -2.07433477e-02f, -4.37535085e-02f, -5.43370917e-02f, -9.28362384e-02f, 4.13103402e-02f, -3.98162641e-02f, 8.56814682e-02f, 3.88040766e-02f, 1.02082103e-01f, 1.29099250e-01f,
  4.26104367e-02f, 9.40939337e-02f, 1.28951833e-01f, 2.28220463e-01f, 1.24283791e-01f, 6.70349002e-02f, 4.17393297e-02f, 4.65514325e-02f, 1.21276625e-01f, 1.67694241e-01f,
  1.21186309e-01f, -7.89918378e-02f, -3.11401896e-02f, -1.30013190e-02f, -9.20154974e-02f, -1.44916043e-01f, -1.20265305e-01f, -1.27529651e-02f, -1.13921411e-01f, -9.26112682e-02f,
  -7.85223991e-02f, 5.16079031e-02f, 6.64956197e-02f, 9.37175006e-02f, 4.72402275e-02f, 7.22975330e-03f, -4.35526557e-02f, -9.86723416e-03f, -9.38978121e-02f, -4.82086018e-02f,
  -6.90874636e-01f, -6.23161346e-02f, 6.98241889e-02f, 1.14615716e-01f, 2.58863671e-03f, 2.20046882e-02f, -9.06627551e-02f, -1.31399035e-01f, -2.87941158e-01f, -7.31041580e-02f,
  -1.21585526e-01f, 3.71650495e-02f, -1.00774597e-03f, 9.56824422e-02f, -1.55286834e-01f, -8.17542821e-02f, -7.94755891e-02f, -9.05462205e-02f, -1.20353341e-01f, -1.18393131e-01f,
  -5.33166043e-02f, -1.44185603e-01f, -2.58590907e-01f, -5.54797165e-02f, -8.96593481e-02f, -1.00948438e-01f, -1.22525975e-01f, -9.50194821e-02f, -1.12884253e-01f, 1.73414331e-02f,
  -3.15365374e-01f, -3.88110340e-01f, 1.17183961e-02f, -2.13317022e-01f, -1.66316763e-01f, -4.07188609e-02f, -6.48139536e-01f, -1.14685729e-01f, 6.69886470e-02f, -6.41425192e-01f,
  -2.46282667e-01f, 1.13363765e-01f, -9.13498253e-02f, 1.18508050e-02f, -1.75896034e-01f, -5.41905284e-01f, -4.57086325e-01f, 3.51165719e-02f, 3.75935733e-01f, 8.27361457e-03f,
  -2.64845848e-01f, -2.33099863e-01f, 2.05477968e-01f, 2.06083670e-01f, -3.97085175e-02f, 2.04906568e-01f, -1.13375187e-01f, 2.00971086e-02f, 9.76432934e-02f, -2.48044416e-01f,
  -4.21769470e-01f, -6.14608265e-02f, 1.26249194e-01f, 5.95855862e-02f, -2.36812100e-01f, 1.61767006e-02f, -1.53852597e-01f, 4.80493307e-02f, 3.52605507e-02f, -1.37283146e-01f,
  6.33048862e-02f, 1.26727998e-01f, 1.99633420e-01f, -2.55119000e-02f, -1.10453181e-01f, -1.26327828e-01f, 4.37309816e-02f, -2.37775669e-02f, 1.20264776e-01f, -2.59255052e-01f,
  -3.00809264e-01f, -8.56212899e-02f, 8.95226523e-02f, 1.64957330e-01f, 3.15282755e-02f, 1.13402031e-01f, 1.69709072e-01f, 2.40108192e-01f, 2.85362005e-01f, -2.45276198e-01f,
  -7.67593235e-02f, 2.49013654e-03f, 8.68220255e-03f, 2.24692132e-02f, -4.93896492e-02f, 1.06088914e-01f, 1.99312307e-02f, -6.71693385e-02f, 1.12225123e-01f, 6.40057102e-02f,
  7.81162158e-02f, -2.00205162e-01f, -6.22207820e-02f, -1.72253937e-01f, -2.25313716e-02f, 4.43733186e-02f, -8.57276767e-02f, 5.68117574e-02f, -2.88587045e-02f, -3.89026590e-02f,
  3.60045396e-02f, 1.86136141e-02f, -4.40120474e-02f, 1.23147175e-01f, -2.50891242e-02f, -8.30989853e-02f, 1.65464412e-02f, 2.80526299e-02f, -1.94328167e-02f, -8.07133690e-03f,
  -3.88858281e-02f, 2.73690939e-01f, -2.45719239e-01f, 1.80996221e-03f, -1.39623851e-01f, -3.33424509e-02f, -9.71381515e-02f, 1.69257112e-02f, 1.97878182e-02f, -1.26849234e-01f,
  -1.44248875e-02f, -1.13900326e-01f, 4.38953266e-02f, -4.62220870e-02f, -3.54202315e-02f, 7.69191012e-02f, -1.67470321e-01f, -1.77476466e-01f, 7.92637840e-02f, -3.33150215e-02f,
  -6.09111488e-02f, -1.76320404e-01f, -1.16239026e-01f, -2.44178604e-02f, -8.43864083e-02f, -8.14393461e-02f, -1.11713804e-01f, -9.39108282e-02f, 6.18816295e-04f, -5.46445310e-01f,
  -3.49349201e-01f, 1.82922244e-01f, -4.40121256e-02f, -2.45347813e-01f, 1.62487756e-02f, 2.29061514e-01f, 2.04992533e-01f, 1.98034674e-01f, 9.43407640e-02f, 1.16526492e-01f,
  1.66265294e-01f, -1.01923078e-01f, -1.89060941e-01f, -1.35981157e-01f, -1.73020493e-02f, -5.84131815e-02f, -3.36757213e-01f, -2.63473660e-01f, 1.28340319e-01f, 2.96747684e-01f,
  -1.89670268e-02f, -1.81250870e-01f, -1.09263316e-01f, -9.24314186e-02f, -2.16934130e-01f, -3.43254834e-01f, -3.82872880e-01f, -2.92972118e-01f, -1.52895436e-01f, -4.10177231e-01f,
  -8.10475573e-02f, 1.73083648e-01f, 3.28209639e-01f, -1.89237356e-01f, -1.90319240e-01f, -2.29562316e-02f, 1.89419031e-01f, -1.57829911e-01f, 1.61177516e-01f, 1.99254915e-01f,
  -7.38938223e-04f, 2.01472834e-01f, -9.53008980e-02f, 2.65917368e-02f, 4.04652134e-02f, 6.28580526e-02f, -5.66396862e-02f, 8.07007402e-02f, -9.16885361e-02f, 1.99618310e-01f,
  -3.46006714e-02f, -1.99618414e-01f, -1.54019475e-01f, 6.13676533e-02f, 1.40506476e-01f, -2.09884286e-01f, 1.58330232e-01f, -6.50231447e-03f, -7.22138509e-02f, -2.01213315e-01f,
  1.03182986e-01f, 1.87488228e-01f, 1.28604293e-01f, 3.00003234e-02f, 3.80569100e-02f, 1.08374670e-01f, -7.59283081e-02f, -3.99075188e-02f, 9.20916125e-02f, -1.43747136e-01f,
  -3.00791790e-03f, 1.95799326e-03f, 2.22661998e-02f, -7.62067810e-02f, -9.25818011e-02f, -2.39820238e-02f, -8.52578729e-02f, -1.69516236e-01f, -1.72184348e-01f, -4.62169349e-02f,
  -1.27100777e-02f, 8.14199671e-02f, 2.19339594e-01f, 2.30370611e-02f, -9.46315750e-03f, -1.63138404e-01f, 4.17600386e-02f, 1.37811899e-01f, 4.28571925e-02f, 1.32223859e-01f,
  -1.79951981e-01f, 4.73094247e-02f, -3.30079868e-02f, 5.89314476e-02f, -1.35937661e-01f, 1.88900065e-02f, -1.89847112e-01f, 4.96999063e-02f, 5.82165830e-02f, 1.36794761e-01f,
  1.87876150e-01f, 8.86273906e-02f, 4.36085127e-02f, 1.24730766e-01f, 1.22708805e-01f, 4.87139225e-02f, -2.49623805e-02f, -2.93003738e-01f, -5.43337269e-03f, 1.67258933e-01f,
  -3.13749257e-03f, -1.93030834e-01f, -2.46092066e-01f, -2.41579458e-01f, -5.51747233e-02f, -4.37099785e-01f, -1.43356323e-01f, -2.38586947e-01f, -2.47268692e-01f, -4.18106765e-01f,
  -5.42775542e-03f, 1.63987681e-01f, 2.32422292e-01f, 1.76364720e-01f, 2.83035308e-01f, 3.47194880e-01f, 3.61481100e-01f, 1.26446739e-01f, 4.93185073e-02f, 6.93290457e-02f,
  9.13354903e-02f, -2.32284274e-02f, -2.91062146e-03f, 5.53821512e-02f, 4.44505587e-02f, 1.42102689e-01f, 1.85357437e-01f, 7.71198496e-02f, 5.08757122e-02f, 8.92820731e-02f,
  -8.96421149e-02f, -1.35907054e-01f, -2.27447003e-01f, -1.30300939e-01f, -8.96573812e-02f, -9.43480507e-02f, 6.37801513e-02f, -3.32437344e-02f, 8.48611370e-02f, -1.77557394e-01f,
  8.48015025e-02f, 1.51823238e-01f, -1.34317592e-01f, -7.16023520e-02f, -5.70793524e-02f, -5.44823520e-02f, -1.15036443e-02f, -2.19540894e-02f, 1.83022283e-02f, -6.96032718e-02f,
  -8.56243968e-02f, -2.01607794e-02f, -5.28388880e-02f, 4.51542772e-02f, 2.21625827e-02f, -7.19475374e-02f, 7.17646107e-02f, 1.79774493e-01f, 1.23271622e-01f, 1.16840869e-01f,
  8.19616392e-02f, 2.05635443e-01f, 2.06132978e-01f, 7.17397481e-02f, 2.01295927e-01f, 1.13653131e-01f, 1.32139638e-01f, 9.10149440e-02f, 3.52517664e-02f, -1.54537996e-02f,
  1.19374700e-01f, 6.87384978e-02f, 1.02961473e-01f, 7.26455525e-02f, -5.61804324e-02f, 5.46197742e-02f, 1.25676161e-02f, 7.59213939e-02f, 1.21720038e-01f, -8.12156275e-02f,
  9.22788531e-02f, 1.10159427e-01f, 1.44991323e-01f, -6.81963712e-02f, 1.47432322e-02f, 1.28203794e-01f, 7.14108944e-02f, -3.95887159e-02f, -3.66138965e-02f, 1.71335191e-02f,
  8.92699603e-03f, 6.41534328e-02f, -4.69979830e-02f, 9.77571979e-02f, 9.70815644e-02f, 1.30562142e-01f, 1.10055722e-01f, -5.47240078e-02f, -5.56130596e-02f, -1.33552149e-01f,
  3.20947021e-01f, 1.93000972e-01f, -1.62157997e-01f, -1.13968648e-01f, 1.50291501e-02f, -1.89497903e-01f, -2.72164401e-02f, -7.20869675e-02f, -9.11330432e-02f, 7.62239322e-02f,
  -7.92429224e-02f, -1.60954937e-01f, -3.13204760e-03f, -5.11294082e-02f, -1.67611595e-02f, 1.74243040e-02f, -1.72721576e-02f, 1.47209197e-01f, 5.52379973e-02f, 3.00397966e-02f,
  -5.78850843e-02f, 1.06984384e-01f, 1.53043687e-01f, 9.15556327e-02f, 2.27877032e-02f, -1.22760378e-01f, -1.15161911e-01f, 7.25533590e-02f, 7.02217296e-02f, -2.01250911e-01f,
  4.15272146e-01f, -2.12185201e-03f, 1.04746029e-01f, 2.95271903e-01f, 1.96964785e-01f, 9.59024057e-02f, 2.74443310e-02f, 5.92694692e-02f, 1.44578055e-01f, 8.62049088e-02f,
  2.45714262e-01f, 2.39233285e-01f, 2.56801158e-01f, 1.37743905e-01f, 1.37404865e-02f, -2.97186673e-02f, -4.58436385e-02f, 6.57448843e-02f, 8.16249400e-02f, 5.53606190e-02f,
  1.79088160e-01f, 3.44701521e-02f, 9.49532315e-02f, -2.69674584e-02f, -9.36497189e-03f, 1.11261658e-01f, 3.49125750e-02f, -6.67578802e-02f, 8.75836611e-02f, -8.86880234e-02f,
  -2.09227964e-01f, 1.20167837e-01f, 1.85643524e-01f, 6.94057718e-02f, -8.92273560e-02f, -1.15291536e-01f, 7.69190341e-02f, -3.69316824e-02f, -1.61043897e-01f, -1.32378533e-01f,
  -2.16809027e-02f, -1.10429674e-01f, 9.82657894e-02f, 1.35952057e-02f, -6.10194281e-02f, -1.07846230e-01f, -4.30390351e-02f, -2.74262915e-04f, -1.09818103e-02f, -9.36542228e-02f,
  3.09683997e-02f, 7.44778067e-02f, -7.80081451e-02f, 2.41411068e-02f, 1.27196750e-02f, 1.04283042e-01f, 3.70172486e-02f, -6.57082722e-02f, 4.50419039e-02f, -3.74833196e-02f,
  2.02221543e-01f, -3.93799208e-02f, 1.22554772e-01f, -3.55700664e-02f, 5.27461283e-02f, 3.33250985e-02f, -3.44820879e-03f, -6.94801584e-02f, 7.98724815e-02f, -3.58059071e-02f,
  6.04661740e-02f, 7.47695267e-02f, -6.12908788e-02f, 1.59784853e-01f, 2.59530097e-01f, -8.41047019e-02f, -1.42348140e-01f, -9.43242237e-02f, -2.85868067e-02f, -8.17086473e-02f,
  1.32014565e-02f, -1.60459355e-01f, 9.62722227e-02f, 2.70892940e-02f, -1.26643285e-01f, 1.49319068e-01f, 6.92964345e-03f, 7.47443363e-02f, 7.01159760e-02f, -1.68430768e-02f,
  -5.38519740e-01f, 1.80795267e-01f, 8.13981742e-02f, -3.41182575e-02f, -4.48212726e-03f, 1.98523551e-02f, 2.89066415e-02f, -7.60380775e-02f, -1.05054818e-01f, -1.17478728e-01f,
  -4.32430208e-02f, 5.26777655e-02f, -5.20829372e-02f, 2.23090337e-03f, -4.24005799e-02f, -1.38484254e-01f, -8.70758891e-02f, -1.11049786e-01f, -6.45616576e-02f, -7.22859502e-02f,
  -2.62592547e-03f, 4.56357561e-02f, -1.14812315e-01f, 7.47527182e-02f, 2.08874363e-02f, -7.53993215e-03f, -8.33890140e-02f, -3.86426449e-02f, -8.98723304e-02f, -5.94488271e-02f,
  -4.02760118e-01f, 3.84184301e-01f, 2.81398356e-01f, -4.84819561e-01f, 1.23127796e-01f, 4.24915224e-01f, 5.41449249e-01f, 2.68931627e-01f, -2.43605033e-01f, 7.42646605e-02f,
  1.03472061e-01f, -3.38372231e-01f, -2.53296465e-01f, 3.93648706e-02f, 1.14789337e-01f, 1.51818007e-01f, 9.99828503e-02f, -5.29304221e-02f, -3.64221781e-02f, 2.12612450e-02f,
  -5.67780957e-02f, -4.09695357e-02f, -1.81002840e-01f, -2.24165276e-01f, -2.98059165e-01f, -3.39010656e-01f, 3.90855223e-02f, 8.70176181e-02f, 2.32349515e-01f, -2.09111109e-01f,
  -5.88882975e-02f, 4.87511419e-02f, -1.53263375e-01f, 1.06674535e-02f, 2.51386804e-03f, -1.88930199e-01f, -2.16691326e-02f, -1.30245253e-01f, -9.95738059e-02f, -6.37075081e-02f,
  -2.43173130e-02f, 6.71283677e-02f, -1.25345662e-01f, 6.64855167e-02f, -9.69411712e-03f, 4.98033538e-02f, 7.94112831e-02f, 1.94161423e-02f, 1.21462636e-01f, 8.02127421e-02f,
  4.04440574e-02f, 1.19816348e-01f, 1.53490096e-01f, 2.10735038e-01f, 1.66103542e-01f, -8.01781937e-02f, 1.70489043e-01f, -5.48341814e-05f, 2.38329560e-01f, -1.57704145e-01f,
  -2.05306653e-02f, -4.09662500e-02f, 1.08291004e-02f, -6.18460067e-02f, 1.54935522e-02f, -1.98440142e-02f, -8.88801366e-02f, -6.12561591e-02f, 1.08067796e-01f, -1.32925605e-04f,
  -1.16940942e-02f, -3.23700830e-02f, 6.61371276e-02f, 8.76547303e-03f, -1.31464228e-01f, 3.89761627e-02f, 1.16802543e-01f, 3.25652286e-02f, 3.39462385e-02f, 4.49126866e-03f,
  1.54708531e-02f, 1.41223231e-02f, -2.06448436e-02f, 4.84871678e-02f, 5.31911701e-02f, -3.47793824e-03f, -2.83757113e-02f, 2.51231492e-02f, -5.79090789e-02f, -2.11890899e-02f,
  -3.46780449e-01f, 3.27162862e-01f, -4.50945109e-01f, -1.14245014e-03f, 2.22464651e-02f, 1.29747257e-01f, -9.48063433e-02f, -3.50671411e-02f, 7.67842308e-02f, 2.17279401e-02f,
  1.01175316e-01f, 3.00461669e-02f, -1.30053638e-02f, 6.25484139e-02f, -1.10327326e-01f, 9.67552606e-03f, 6.63546845e-02f, -4.67567816e-02f, -3.54125202e-02f, -8.66231844e-02f,
  9.66541618e-02f, -8.37952271e-03f, -1.99217975e-01f, -6.73361719e-02f, -1.11539714e-01f, -2.09934741e-01f, -9.12942365e-02f, 3.85913358e-04f, 8.49792883e-02f, -2.21200988e-01f,
  4.69554871e-01f, -6.40279576e-02f, 2.52590403e-02f, 1.74238652e-01f, 2.27584541e-02f, 5.81389852e-02f, -1.81372657e-01f, -1.59401715e-01f, 5.93748130e-02f, 3.38931121e-02f,
  1.50225803e-01f, 2.66075790e-01f, 1.94994405e-01f, 7.24305287e-02f, 8.30449443e-03f, -2.59918690e-01f, -1.71080500e-01f, 1.40042990e-01f, 9.47364494e-02f, 4.95011779e-03f,
  -1.90870255e-01f, -8.26651901e-02f, 4.87591326e-02f, -1.45545006e-01f, -1.62731275e-01f, 1.29098311e-01f, -3.45083773e-02f, -1.00250930e-01f, 1.18214702e-02f, -8.56864452e-02f,
  2.23622471e-01f, 2.46763408e-01f, 9.35773998e-02f, 8.00509602e-02f, -2.56905854e-02f, 1.16631361e-02f, 7.58854225e-02f, -7.34027997e-02f, -1.94217116e-02f, 7.58672319e-03f,
  1.16730090e-02f, -4.96632010e-02f, 2.28635571e-03f, 1.95928086e-02f, 1.35939848e-02f, -1.81805789e-02f, -4.47389595e-02f, 8.17641150e-03f, 9.28308889e-02f, -3.22678573e-02f,
  -7.71545246e-02f, 1.34817168e-01f, 6.26730472e-02f, -2.87289917e-02f, 7.40415901e-02f, 1.72681525e-01f, 1.00288399e-01f, 9.04325023e-02f, 1.01292275e-01f, -6.57063648e-02f,
  -4.01563346e-02f, -1.43663004e-01f, 1.94534793e-01f, 1.54726893e-01f, 1.19549178e-01f, -5.25023006e-02f, 7.77627379e-02f, -9.07714143e-02f, 2.97624618e-02f, -1.18065767e-01f,
  1.31854579e-01f, 1.28819987e-01f, 1.71184599e-01f, 4.15538531e-03f, 9.12727639e-02f, 8.24307576e-02f, 4.84231152e-02f, 1.15382232e-01f, 2.07703244e-02f, 1.88921869e-01f,
  2.12523490e-01f, -1.51316911e-01f, -7.74993598e-02f, -5.92713580e-02f, 1.41696304e-01f, 9.19228271e-02f, -1.80691592e-02f, -1.23084038e-02f, -1.35665894e-01f, -2.53553689e-02f,
  9.00583491e-02f, 5.24415851e-01f, 8.66712332e-02f, 7.99636617e-02f, -8.48650783e-02f, -6.87177777e-02f, 2.41810933e-01f, 5.50187081e-02f, -6.86614215e-02f, 4.11602631e-02f,
  7.99595192e-02f, -7.40490332e-02f, -4.95846868e-02f, -5.17760627e-02f, -1.13118760e-01f, 3.29416730e-02f, 3.85304503e-02f, 1.10955335e-01f, 3.42011228e-02f, -6.77368566e-02f,
  -1.23443179e-01f, -3.91279049e-02f, 1.51120164e-02f, 6.90334439e-02f, -9.63002667e-02f, 1.14357896e-01f, -1.58601999e-02f, 4.37934361e-02f, 2.37726569e-02f, -1.21991128e-01f,
  -8.02758098e-01f, 1.90905839e-01f, -1.72061384e-01f, -4.63471293e-01f, -1.15674295e-01f, -4.47023101e-02f, 5.55813201e-02f, 1.21893911e-02f, -1.26958355e-01f, 6.53334633e-02f,
  -2.03251075e-02f, -1.19017161e-01f, -1.33948192e-01f, -1.61808103e-01f, -1.26450524e-01f, -7.71787986e-02f, -1.70900032e-01f, -4.15277153e-01f, -4.77328718e-01f, -1.36136353e-01f,
  -1.95547715e-01f, -4.00576562e-01f, -4.27877128e-01f, -1.09330446e-01f, 9.77002606e-02f, -1.66840311e-02f, -7.57418051e-02f, -1.89965256e-02f, 1.67388380e-01f, -6.67543933e-02f,
  -7.60406256e-02f, -1.27345994e-01f, -2.18872167e-02f, -1.44022286e-01f, -7.01744258e-02f, -2.76158843e-02f, 4.44337688e-02f, 3.89069840e-02f, 9.48454663e-02f, -3.33072767e-02f,
  -6.87545165e-02f, 5.79966530e-02f, -2.31805474e-01f, -1.07430452e-02f, -1.09220162e-01f, -5.35918847e-02f, 1.62943988e-03f, -9.70978513e-02f, -7.01725408e-02f, 2.85492241e-01f,
  3.65300626e-02f, -5.07112332e-02f, -5.98759577e-02f, 1.46244138e-01f, 8.83942246e-02f, -2.32106186e-02f, 1.73225254e-01f, 1.16961196e-01f, 1.38643324e-01f, 1.80215523e-01f,
  5.43119647e-02f, 1.59530357e-01f, -4.16725874e-02f, 4.30675186e-02f, -4.76040132e-03f, -1.20057717e-01f, -8.74703676e-02f, -4.03068624e-02f, -8.25265422e-02f, -9.47817862e-02f,
  -4.41421336e-03f, 4.46497053e-02f, 7.80727118e-02f, 1.44408718e-02f, -1.65660921e-02f, -3.83586474e-02f, -6.00879453e-02f, 1.01582535e-01f, 7.66879916e-02f, -6.34494498e-02f,
  -1.47506610e-01f, 5.02312835e-03f, -1.08816244e-01f, 6.30984455e-02f, 4.28576767e-02f, -1.10161873e-02f, -4.52255905e-02f, -5.47496639e-02f, -8.48586112e-02f, 1.15406038e-02f,
  -1.84652284e-01f, -1.99148878e-01f, -1.31730884e-01f, 1.17704652e-01f, -1.07502714e-02f, 1.13521218e-01f, -1.14551215e-02f, 1.86578166e-02f, -4.32899334e-02f, 8.98058042e-02f,
  3.23511176e-02f, -5.14779612e-02f, -1.58545196e-01f, 8.11934657e-03f, -6.71670586e-02f, -6.74816519e-02f, -3.84816974e-02f, -5.26445098e-02f, 6.40555546e-02f, 8.36108625e-02f,
  1.13678277e-01f, 4.89105172e-02f, -1.42020091e-01f, 2.25957818e-02f, 4.75703031e-02f, -1.17647015e-01f, -1.47236616e-03f, 1.18544713e-01f, 9.14112758e-03f, 9.63071138e-02f,
  4.99896079e-01f, -2.13818997e-01f, -4.17302251e-01f, -9.83055681e-02f, -1.27777085e-01f, -1.98242411e-01f, -1.77907914e-01f, 7.14477003e-02f, 3.91549766e-02f, -2.31412202e-01f,
  4.54712920e-02f, 1.80388838e-01f, 3.44771631e-02f, -6.84744045e-02f, -7.70156011e-02f, -3.27934295e-01f, -3.98165435e-01f, -2.07242668e-01f, 4.28537615e-02f, -1.05363512e-02f,
  -9.48969051e-02f, -2.18195282e-02f, 7.46122748e-02f, 4.01815996e-02f, -1.48265615e-01f, -7.07213581e-02f, -2.94951558e-01f, -1.48438707e-01f, -3.00620347e-01f, -5.09439826e-01f,
  -5.14869094e-01f, 1.04900368e-01f, 2.62661874e-01f, 2.33870357e-01f, 1.89895798e-02f, 1.84965491e-01f, 1.86229255e-02f, 1.71459153e-01f, 1.34917632e-01f, -3.37205268e-02f,
  5.51776215e-02f, 7.24169984e-02f, 4.44089174e-02f, -5.92307933e-03f, 6.99903071e-02f, 1.23859040e-01f, 1.43070981e-01f, 1.27808258e-01f, 3.52071747e-02f, -4.64593954e-02f,
  2.00853609e-02f, -2.88461838e-02f, 3.78864557e-02f, 2.05364674e-01f, 1.38988703e-01f, 8.64326358e-02f, 1.27321646e-01f, 2.07802951e-01f, 1.66264072e-01f, 3.01636849e-02f,
  -2.28672296e-01f, -1.64738357e-01f, -3.04954574e-02f, 7.81441554e-02f, 9.50505733e-02f, 1.98990867e-01f, -5.10757156e-02f, -8.96579847e-02f, 4.39091250e-02f, 2.93460209e-02f,
  5.68031706e-02f, -9.48881134e-02f, 7.18230903e-02f, -1.76640460e-03f, -4.23960909e-02f, -7.40399910e-03f, -3.37378420e-02f, -5.99497631e-02f, 7.90514946e-02f, 8.77438039e-02f,
  6.58786818e-02f, -8.28676298e-02f, -1.00285754e-01f, 1.36490827e-02f, -1.29160777e-01f, 3.05464165e-03f, -3.56495641e-02f, -1.03691183e-02f, 1.83565319e-02f, -1.10602174e-02f,
  -1.64272562e-01f, 3.36488569e-03f, 3.14561836e-02f, 2.55580023e-02f, -2.32787021e-02f, -2.39009578e-02f, -2.01317236e-01f, 2.84605054e-03f, -7.94507861e-02f, -1.25088636e-02f,
  1.42066265e-02f, -1.89976040e-02f, -3.13585699e-02f, -4.48066089e-03f, 6.50981516e-02f, -2.67030019e-02f, 9.82027277e-02f, -3.58300693e-02f, -1.36007547e-01f, -1.21016942e-01f,
  -1.02693103e-02f, 4.08866741e-02f, 9.36385617e-02f, 4.00376767e-02f, 3.50261442e-02f, 6.30101487e-02f, -2.76865549e-02f, 1.83628220e-02f, -4.19693068e-02f, 9.96261612e-02f,
  6.58819199e-01f, 3.96176517e-01f, 2.94159383e-01f, 2.16520265e-01f, 1.56643227e-01f, 2.42209598e-01f, 3.20945084e-01f, 2.14102209e-01f, 9.24873799e-02f, 1.12899445e-01f,
  2.45545506e-01f, 1.23281188e-01f, 1.39935702e-01f, 1.04183584e-01f, 6.20740354e-02f, 4.56584021e-02f, -8.82480368e-02f, 1.03886113e-01f, 1.06177256e-01f, 5.38895316e-02f,
  2.90651619e-02f, -8.07418302e-02f, 3.55007611e-02f, 5.80331087e-02f, -1.26635149e-01f, 4.35138233e-02f, 1.78123862e-02f, 4.05053422e-03f, 6.01552501e-02f, -5.88621795e-02f,
  9.10871327e-02f, 2.02316016e-01f, -1.07516125e-01f, -3.29119083e-03f, 4.45461944e-02f, -9.96317863e-02f, 2.40379348e-02f, -9.02899057e-02f, -3.63417454e-02f, -9.07404125e-02f,
  -1.86985843e-02f, -1.18769765e-01f, 5.92713915e-02f, 6.10723831e-02f, -1.20122209e-01f, -2.97030825e-02f, -9.67349932e-02f, -3.76301855e-02f, 2.41303388e-02f, 8.32316931e-03f,
  -5.95167316e-02f, -7.36174136e-02f, 9.19171348e-02f, -5.64301573e-03f, 3.62126343e-02f, -5.36908694e-02f, 6.89037666e-02f, 7.91894197e-02f, -4.54978878e-03f, 7.06529245e-02f,
  1.22085072e-01f, 3.98269594e-02f, 7.21807927e-02f, 5.05723543e-02f, 7.31727406e-02f, 4.67526950e-02f, -6.22265115e-02f, 7.97017943e-03f, 3.03932838e-02f, -8.47541690e-02f,
  -5.13538485e-04f, 4.59468327e-02f, 2.00716294e-02f, 1.44884093e-02f, -6.37991354e-02f, 1.16764888e-01f, -3.94272804e-02f, -4.13734354e-02f, 4.06500660e-02f, 2.21530348e-02f,
  1.44017872e-03f, 6.21153088e-03f, -1.91907957e-02f, -5.37690781e-02f, -5.08207083e-02f, 5.47137596e-02f, -1.39421493e-01f, -5.44441901e-02f, -1.02294207e-01f, -1.27009079e-01f,
  -2.63925523e-01f, 1.88121602e-01f, -4.99818102e-02f, -1.27741739e-01f, -3.77494730e-02f, -1.41862392e-01f, 1.01885401e-01f, -1.58327222e-01f, -5.43117300e-02f, -1.25232309e-01f,
  -7.12069869e-02f, -4.46190760e-02f, -2.04335973e-02f, -1.15734272e-01f, -3.53631414e-02f, -1.20340213e-01f, 9.66598615e-02f, 3.57888117e-02f, 7.08169863e-02f, -6.08927831e-02f,
  -2.78724413e-02f, 5.85585870e-02f, 9.24930498e-02f, 9.51796770e-03f, 3.91161963e-02f, 6.35678545e-02f, -4.49486487e-02f, -6.16750754e-02f, -6.63720211e-03f, -1.67217240e-01f,
  -5.02750278e-01f, 1.15348488e-01f, 4.95960087e-01f, -7.74438009e-02f, 2.16193482e-01f, 4.86922786e-02f, -5.73986918e-02f, -1.85623139e-01f, -2.44018957e-02f, 6.50563911e-02f,
  5.54388352e-02f, -1.20349474e-01f, 1.02115363e-01f, 5.45945838e-02f, -2.52896786e-01f, 1.45772800e-01f, 9.56602618e-02f, -1.70163572e-01f, -4.22002077e-01f, -3.99790049e-01f,
  -3.12290609e-01f, -2.18013287e-01f, -2.85948008e-01f, -1.99802294e-01f, -6.39519766e-02f, -9.17369500e-02f, 2.56009817e-01f, 1.08714774e-02f, -1.96939744e-02f, -1.31136347e-02f,
  -4.98897284e-02f, 1.13552086e-01f, -3.26094497e-03f, -4.45885397e-02f, 2.32888967e-01f, -1.65887535e-01f, -1.11181483e-01f, 2.76845247e-01f, 7.08655193e-02f, 7.61234239e-02f,
  2.22052410e-01f, 5.89580312e-02f, -8.82239342e-02f, -7.12083429e-02f, -2.06437752e-01f, -1.58343881e-01f, 8.08471441e-02f, -5.64855523e-02f, 2.76081264e-02f, -2.99798194e-02f,
  -1.68122470e-01f, -1.71012670e-01f, -3.39129269e-02f, 6.77875802e-03f, 5.74979372e-02f, -1.28921837e-01f, -2.36972328e-02f, -1.01345010e-01f, -4.95566893e-03f, -1.76068798e-01f,
  3.20793875e-02f, 5.13978638e-02f, 9.47946832e-02f, 1.01747535e-01f, -1.64723173e-01f, 1.02030694e-01f, 1.78722158e-01f, -5.02795205e-02f, -1.00459665e-01f, -6.58672079e-02f,
  1.49471864e-01f, 5.90690263e-02f, -7.68797100e-02f, 2.94290520e-02f, 3.42275426e-02f, -7.55060650e-03f, -1.12783536e-01f, -1.24800436e-01f, 3.85867134e-02f, 8.38217605e-03f,
  -1.08266018e-01f, 2.87996866e-02f, 3.74360457e-02f, -7.17211962e-02f, 1.19394772e-01f, 2.68490799e-03f, -7.54315481e-02f, -6.02013543e-02f, 5.98093309e-03f, -3.24724987e-02f,
  -2.75226325e-01f, 1.65511131e-01f, 1.53011540e-02f, -8.98368880e-02f, 6.69792444e-02f, 1.08486600e-01f, 2.16872990e-01f, 6.77763373e-02f, 1.16597235e-01f, -1.99396178e-01f,
  1.19469939e-02f, -1.88670322e-01f, 3.12941112e-02f, 4.84583937e-02f, -1.70143142e-01f, -9.56850424e-02f, -2.07872659e-01f, -8.03890824e-02f, -8.81719589e-02f, -3.58957238e-02f,
  -2.45293796e-01f, -3.85180265e-01f, -4.10417348e-01f, -2.31108576e-01f, -3.40764552e-01f, -3.75536084e-01f, -1.11604340e-01f, -2.01250628e-01f, -1.99034780e-01f, -3.61596048e-01f,
  -2.01630577e-01f, 1.01210713e-01f, 7.61938170e-02f, 1.77102536e-02f, 1.51566043e-01f, 1.91550061e-01f, 2.25483343e-01f, 9.54872668e-02f, -6.94972500e-02f, -3.73698510e-02f,
  9.97762457e-02f, -4.72052135e-02f, -4.13002893e-02f, -5.71034141e-02f, 1.67695299e-01f, 8.36689323e-02f, 7.33722970e-02f, -1.23112584e-02f, -5.51411398e-02f, -2.04972159e-02f,
  1.52977640e-02f, -1.28523678e-01f, -5.08759208e-02f, -1.39195681e-01f, -1.34284467e-01f, -1.84469216e-03f, -7.70751536e-02f, 2.20589265e-02f, 4.99017090e-02f, -1.67873934e-01f,
  2.89314568e-01f, 2.02377319e-01f, -1.75913516e-02f, 1.97224561e-02f, -1.08418673e-01f, -1.88398406e-01f, -7.41019547e-02f, -5.02779968e-02f, -4.34271432e-02f, 2.85910349e-02f,
  6.53858185e-02f, -7.34963175e-03f, -7.64819654e-03f, -8.03141743e-02f, 6.09851368e-02f, -2.95893736e-02f, -1.60492525e-01f, -3.96752544e-02f, 1.11047938e-01f, -2.52783094e-02f,
  6.74041137e-02f, 7.37813413e-02f, 1.36035129e-01f, 6.85639083e-02f, 9.26031694e-02f, 3.05810962e-02f, 6.98351935e-02f, -7.16473907e-03f, -6.40402883e-02f, -1.67074278e-01f,
  -1.95697811e-03f, -1.30792752e-01f, -8.61486495e-02f, 9.09619182e-02f, 1.00954734e-02f, 9.55906361e-02f, -9.56038421e-04f, 1.80127069e-01f, 6.43739626e-02f, -1.93517376e-02f,
  2.08818704e-01f, 1.83584318e-01f, 9.44511071e-02f, 1.49737611e-01f, -3.97832356e-02f, 1.83155254e-01f, 3.46462503e-02f, 1.24477372e-01f, 1.67160720e-01f, 1.23135485e-02f,
  4.58206795e-02f, 1.29966348e-01f, 1.04386680e-01f, 6.20048754e-02f, 1.50354698e-01f, 1.59304604e-01f, 8.28730315e-02f, -5.18376417e-02f, 3.17573324e-02f, 7.05373660e-02f,
  1.42891174e-02f, 2.50470638e-01f, -1.73137020e-02f, 7.08415732e-02f, -1.19172625e-01f, -1.39375255e-01f, -2.55300920e-03f, 3.51939612e-04f, 1.09574601e-01f, 2.56066490e-02f,
  1.48805842e-01f, -2.25235447e-02f, -2.95504276e-02f, -5.01859039e-02f, -1.63380392e-02f, -4.53938246e-02f, -9.32932496e-02f, 1.93937449e-03f, -3.25723588e-02f, -3.40293236e-02f,
  -8.51916820e-02f, 4.68721613e-02f, 9.70616117e-02f, 1.10962920e-01f, 1.26564622e-01f, -8.33709165e-02f, -1.06286235e-01f, -1.49331763e-01f, 5.66747338e-02f, -1.62147194e-01f,
  2.80962378e-01f, 4.61538017e-01f, 2.78270066e-01f, -4.10006121e-02f, 4.29896861e-02f, -3.54560763e-02f, 1.16784804e-01f, 2.15676799e-02f, 1.15444856e-02f, 1.99573450e-02f,
  2.08441168e-02f, -4.37545106e-02f, -7.97519535e-02f, 5.36953770e-02f, -9.07255709e-03f, 1.00828320e-01f, 9.01000053e-02f, 1.08503193e-01f, -3.98982875e-02f, 5.58850914e-02f,
  -7.83185810e-02f, 3.72227430e-02f, 1.06290169e-02f, -1.57018472e-02f, 1.80232748e-02f, -3.83611657e-02f, 8.14996734e-02f, 1.46174327e-01f, 1.08348787e-01f, 6.93588629e-02f,
  3.50182921e-01f, 2.25448579e-01f, -1.84705123e-01f, -1.34769836e-02f, 6.23908192e-02f, 3.49021628e-02f, -1.14228427e-02f, 1.57862216e-01f, 1.70357183e-01f, -8.58645141e-03f,
  8.52897987e-02f, -4.40448966e-05f, -5.32279611e-02f, -5.83750792e-02f, 6.83283433e-03f, 7.00986907e-02f, -7.13098869e-02f, -6.53582588e-02f, 1.54404253e-01f, 6.99980408e-02f,
  -5.47358729e-02f, -3.62580754e-02f, -4.12169620e-02f, -4.31917273e-02f, -2.96939109e-02f, -2.91691963e-02f, 4.37511429e-02f, -5.56674786e-02f, 2.74436418e-02f, -7.67029682e-03f,
  -1.01125821e-01f, 1.07348580e-02f, 3.68287340e-02f, -1.04904704e-01f, -2.13193938e-01f, -1.41088411e-01f, -9.17856619e-02f, -2.98187193e-02f, -8.91958028e-02f, -2.58343220e-01f,
  -2.51188695e-01f, -2.50650030e-02f, 1.47206550e-02f, -1.42494187e-01f, -1.61509942e-02f, -1.02135083e-02f, 1.66930988e-01f, 7.19473809e-02f, -1.00165024e-01f, 9.40922871e-02f,
  -6.07115962e-02f, 1.00293785e-01f, -5.49773173e-03f, -7.20598130e-03f, -2.37210393e-02f, -8.04010779e-02f, 8.56192596e-03f, -5.34921102e-02f, 8.00587144e-03f, -1.02233775e-02f,
  1.21405490e-01f, -1.07301585e-01f, -1.44610643e-01f, 8.57444182e-02f, 1.97528869e-01f, 1.08623207e-01f, 1.84523925e-01f, 9.43832472e-02f, 2.70915449e-01f, 1.86782762e-01f,
  2.43833780e-01f, -9.82573722e-04f, -9.12358463e-02f, -1.25192270e-01f, -1.32294923e-01f, -6.23643696e-02f, 6.79934174e-02f, 1.10425271e-01f, 3.11306342e-02f, 1.47999376e-01f,
  7.94640481e-02f, -8.61654207e-02f, -3.53058204e-02f, -8.90775993e-02f, -1.58511162e-01f, -1.73901990e-01f, -1.45718217e-01f, 1.57516394e-02f, -7.61476606e-02f, -1.52491927e-01f,
  2.69871712e-01f, 1.01599514e-01f, -4.47211228e-03f, -9.57869217e-02f, -1.79020777e-01f, -2.24089548e-01f, -2.80009151e-01f, -1.86271086e-01f, -8.14041793e-02f, -1.41533554e-01f,
  3.02736778e-02f, -5.70911318e-02f, 7.82085210e-02f, -2.22745463e-02f, 1.43330440e-01f, -3.86166275e-02f, 1.38399899e-02f, 1.22910976e-01f, 5.98095208e-02f, -1.79288581e-01f,
  -1.81603134e-01f, 5.71725145e-02f, 4.90394607e-02f, -2.37107873e-02f, -5.65852970e-02f, -1.90098435e-02f, -1.20421246e-01f, 3.81894782e-03f, -3.43385339e-02f, -6.26030320e-04f,
  2.65962034e-02f, 1.90076798e-01f, 1.03339925e-01f, 1.02249041e-01f, 5.62150404e-02f, -1.27173867e-02f, -3.34558368e-04f, -1.59503333e-02f, 7.75352269e-02f, 2.39684768e-02f,
  8.49305070e-04f, -1.56145617e-01f, -1.15802400e-02f, -1.32271186e-01f, -1.41087472e-01f, -1.06956817e-01f, -4.27866690e-02f, -4.41876017e-02f, -2.34706439e-02f, -8.64941180e-02f,
  -5.29255085e-02f, -1.63538292e-01f, -1.63046762e-01f, -7.93516859e-02f, -9.71631482e-02f, -1.35714132e-02f, -9.35338959e-02f, -1.11069806e-01f, 2.92011667e-02f, -9.80448052e-02f,
  -1.08729675e-01f, 1.36361578e-02f, -1.37642846e-01f, -6.20752797e-02f, -1.72772124e-01f, -1.43773422e-01f, -8.49937499e-02f, -1.09774016e-01f, -8.03927258e-02f, -1.55010432e-01f,
  -2.14626789e-01f, 2.20755860e-02f, -2.99773198e-02f, -3.29117216e-02f, 7.90791437e-02f, -2.35385764e-02f, -8.43775738e-03f, -1.93443559e-02f, -1.41148241e-02f, 5.55509701e-02f,
  -4.32559364e-02f, -9.40225869e-02f, -5.23170792e-02f, -4.63273712e-02f, -6.28626943e-02f, -4.94373553e-02f, -1.23907560e-02f, -1.32694334e-01f, -6.19855225e-02f, -5.91376796e-02f,
  8.15902501e-02f, 1.99031785e-01f, 1.27514645e-01f, 1.53831765e-01f, 1.06346488e-01f, 1.22302361e-01f, 1.34414509e-01f, 1.15678921e-01f, 1.17175274e-01f, 7.87190422e-02f,
  1.23676129e-01f, 7.84173310e-02f, 4.26874794e-02f, -4.04339619e-02f, -1.56061992e-01f, -6.08296022e-02f, 4.39448394e-02f, 1.14914805e-01f, 9.90947634e-02f, -8.34398810e-03f,
  2.51402687e-02f, 9.75662656e-03f, 4.16856632e-02f, 3.59164402e-02f, 8.69444162e-02f, 1.18046887e-01f, -7.88583383e-02f, -6.12866655e-02f, -5.59433643e-03f, -1.89264148e-01f,
  -6.57931864e-01f, -3.51703286e-01f, -4.03469354e-01f, -3.27038199e-01f, 1.02530278e-01f, 1.66957274e-01f, 1.78894266e-01f, -1.96850263e-02f, -1.26717597e-01f, -1.74666211e-01f,
  1.08792610e-01f, 2.22872317e-01f, -2.34880429e-02f, 2.12305650e-01f, 2.27606028e-01f, -5.49902618e-02f, 5.96138649e-02f, -5.85294887e-03f, 2.75137037e-01f, 4.79885578e-01f,
  4.21192437e-01f, 2.78592110e-02f, -2.00128462e-02f, 5.79158738e-02f, -4.01529111e-02f, 2.02877864e-01f, -2.66663969e-01f, -9.84211192e-02f, 1.53545216e-01f, -1.31634519e-01f,
  -1.66296571e-01f, -3.95311922e-01f, 2.02628970e-01f, 2.41428748e-01f, -1.77340787e-02f, -1.63846999e-01f, -1.16354391e-01f, -1.98817685e-01f, -9.71306786e-02f, -1.77716330e-01f,
  -1.32468253e-01f, 5.52421398e-02f, 2.62646936e-02f, 5.76082803e-02f, 9.62873641e-03f, -1.75111946e-02f, -1.07779942e-01f, -1.92929611e-01f, -2.92985320e-01f, -4.55014780e-02f,
  2.50414193e-01f, 5.98368160e-02f, -9.37387943e-02f, -1.64526552e-01f, -2.93751299e-01f, -5.92032373e-02f, -1.64275602e-01f, -2.32104026e-03f, -3.08094472e-01f, -4.20526564e-01f,
  4.00961526e-02f, -3.65056954e-02f, -5.79231232e-02f, -9.31120589e-02f, 2.15306044e-01f, -7.87662938e-02f, -3.12159695e-02f, 1.91300213e-01f, 7.72215575e-02f, -1.38936490e-01f,
  4.54890030e-03f, -2.02011615e-02f, 1.86197281e-01f, -5.28661758e-02f, -7.01141730e-03f, -6.83575496e-02f, 3.58935148e-02f, -3.58292018e-03f, -3.23442109e-02f, 7.54929706e-02f,
  -1.45409703e-02f, 6.40785024e-02f, -1.98087737e-01f, 9.47327912e-02f, -8.06924049e-03f, -1.83862355e-02f, -5.26933782e-02f, 5.81584647e-02f, -7.21580088e-02f, -5.57637475e-02f,
  -2.64037371e-01f, -3.59788612e-02f, -1.54952541e-01f, 2.90483404e-02f, -1.09493546e-01f, 1.28562376e-02f, -9.33808014e-02f, 7.06868665e-03f, -5.71873449e-02f, -2.69639008e-02f,
  -1.95848700e-02f, -9.92952809e-02f, -2.21271455e-01f, 3.80365700e-02f, 7.24262297e-02f, -2.02651899e-02f, 6.00026026e-02f, 2.37276107e-01f, 3.77278179e-02f, 2.02836599e-02f,
  -1.54834151e-01f, 8.27552676e-02f, -4.75834794e-02f, -1.71918750e-01f, -4.52401750e-02f, 6.34037927e-02f, -1.59436613e-01f, -1.11615695e-01f, -1.63226783e-01f, -3.73432487e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.39367816e-02f, 1.88796535e-01f, 2.39401951e-01f, -1.05447052e-02f, -9.87570360e-03f, 1.44695431e-01f, 4.36437964e-01f, 3.50042015e-01f, 2.71991402e-01f, 2.08936036e-01f,
  5.71511276e-02f, 2.76977241e-01f, 2.77921796e-01f, -1.01131991e-01f, -3.22325416e-02f, 1.21545628e-01f, 4.02271450e-01f, 2.69533936e-02f, 1.35885537e-01f, -1.11286767e-01f,
  -1.36641832e-02f, 1.58785790e-01f, 4.67642657e-02f, -1.95554733e-01f, -1.83755010e-01f, 2.07938820e-01f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  -5.07851802e-02f, -1.20750712e-02f, 3.68040130e-02f, -6.32712850e-03f, 1.12196848e-01f, -3.60172428e-02f, 2.01559290e-01f, -2.08456561e-01f, -1.24941543e-01f, -3.76160070e-02f,
  -3.19130048e-02f, -7.25726560e-02f, 9.37117636e-03f, 9.18956250e-02f, -4.61611012e-03f, -6.50429204e-02f, 6.37085661e-02f, 1.29454330e-01f, -3.34738865e-02f, 4.37197126e-02f,
  -6.21597730e-02f, -1.29697308e-01f, 1.39511555e-01f, -2.00877320e-02f, 8.82387832e-02f, 9.52589661e-02f, -6.43785670e-02f, -5.96871376e-02f, 1.29706517e-01f, -5.73452488e-02f,
  -1.27774552e-01f, -1.02344558e-01f, -4.01218832e-02f, -3.51458825e-02f, -2.95492262e-02f, -3.55045423e-02f, -3.60295922e-02f, 3.13495174e-02f, 5.58076007e-03f, -4.00298275e-02f,
  7.50042172e-03f, -9.44149718e-02f, 2.96844151e-02f, 5.50968014e-02f, 8.30026716e-02f, -6.20724373e-02f, 1.03550851e-01f, 9.93028954e-02f, 5.95689155e-02f, -6.99433535e-02f,
  -8.83947536e-02f, 5.79373650e-02f, -1.86879590e-01f, -7.43286982e-02f, -8.60195011e-02f, -1.04090780e-01f, 1.94293037e-01f, 1.32153928e-01f, 2.36993372e-01f, -4.87760529e-02f,
  2.79473048e-02f, -5.44929430e-02f, -1.39723018e-01f, -1.09789856e-01f, 2.43713316e-02f, 6.06233291e-02f, 2.20824033e-01f, 5.54365218e-02f, 1.60124544e-02f, 1.72768906e-02f,
  1.81269899e-01f, -3.76572683e-02f, 3.10709886e-02f, -5.33820912e-02f, 1.41601488e-01f, 7.29065612e-02f, -6.90484792e-02f, -1.15471594e-01f, 2.86284145e-02f, -1.20361149e-01f,
  -2.41186798e-01f, 7.06861541e-02f, -6.12804554e-02f, -4.83886488e-02f, -5.15249325e-03f, -9.17251483e-02f, 4.71523963e-03f, -1.42422736e-01f, -1.73528865e-01f, -4.25270684e-02f,
  2.75447257e-02f, 4.26336676e-02f, 4.57160063e-02f, 1.03163227e-01f, 5.75283030e-03f, 1.64949358e-01f, -5.14568835e-02f, -8.63152817e-02f, 1.32186130e-01f, -1.45382196e-01f,
  -1.29443794e-01f, 4.13386449e-02f, -1.56834945e-01f, 6.81293607e-02f, 1.24716751e-01f, 1.22418195e-01f, 1.39482409e-01f, -1.41510874e-01f, -2.47929379e-01f, 1.60265088e-01f,
  2.12268502e-01f, -6.46389574e-02f, 4.83516604e-02f, -1.14085615e-01f, 2.16639265e-01f, 8.52634907e-02f, -2.31318995e-01f, -7.29240179e-02f, 4.86986618e-03f, -1.51165640e-02f,
  2.51930684e-01f, 1.05146013e-01f, 2.12798826e-02f, 4.67044897e-02f, -2.06868760e-02f, -7.45741129e-02f, -4.02628593e-02f, -1.07398450e-01f, 1.40594900e-01f, 3.53536755e-03f,
  1.13220118e-01f, -5.50958514e-02f, 3.52936285e-03f, -7.12319985e-02f, -2.93734502e-02f, -1.27823398e-01f, 7.25354850e-02f, -2.93411128e-02f, 8.44192281e-02f, -6.37161136e-02f,
  1.10916304e-03f, -2.78956853e-02f, -9.73399670e-04f, 9.47307795e-03f, 1.45106595e-02f, 1.34074450e-01f, -1.39249474e-01f, 3.04240454e-02f, 3.18038054e-02f, 5.85723445e-02f,
  5.88465668e-02f, 1.04721822e-02f, -2.04383507e-02f, -6.99915662e-02f, 6.99916855e-02f, -6.50956482e-02f, 4.41281945e-02f, -1.38494104e-01f, 3.08642890e-02f, -3.92562263e-02f,
  4.69837710e-02f, -6.10325933e-02f, 4.89016995e-02f, -5.68624102e-02f, -1.16560310e-02f, -7.78165236e-02f, -2.52513215e-02f, 5.86442910e-02f, -3.02862711e-02f, -3.39630768e-02f,
  -7.11015388e-02f, 6.72501400e-02f, 7.73662031e-02f, 1.11194691e-02f, 4.41067200e-03f, 3.62553075e-02f, 3.58056687e-02f, 1.37745768e-01f, 6.17175996e-02f, -2.15714681e-03f,
  2.76952963e-02f, 2.73055192e-02f, -7.39260763e-02f, -1.27706259e-01f, -1.79704532e-01f, 6.72619715e-02f, -5.41963838e-02f, 1.22726932e-01f, -1.95231941e-02f, -4.79667373e-02f,
  2.02342644e-02f, 1.89617593e-02f, 1.46925956e-01f, -1.05603749e-03f, -6.45509884e-02f, 1.45753682e-01f, 8.42346698e-02f, 5.28256744e-02f, -4.03607152e-02f, 3.30194086e-02f,
  -1.12160563e-01f, -4.84404080e-02f, 4.65538912e-03f, -3.79558019e-02f, -3.80942151e-02f, 8.83114785e-02f, 7.26269037e-02f, -3.98005620e-02f, -2.39434987e-02f, 4.67002392e-02f,
  -5.85255884e-02f, 4.76305857e-02f, 1.36476532e-02f, 1.58600852e-01f, 1.04238793e-01f, -1.96224302e-02f, -9.81112272e-02f, 1.21720597e-01f, 2.05191031e-01f, -7.32345283e-02f,
  4.37299795e-02f, -4.25526984e-02f, -5.44442348e-02f, 8.86326805e-02f, 9.01962891e-02f, -9.92200337e-03f, 8.07391852e-02f, -2.00321123e-01f, -5.78042455e-02f, 1.15441427e-01f,
  2.65134517e-02f, 7.63294473e-02f, -5.04374737e-03f, -4.11927812e-02f, 8.29751492e-02f, -5.59164397e-02f, -3.86121899e-01f, -1.25763863e-01f, -2.32486486e-01f, 3.59447859e-02f,
  8.81575942e-02f, -9.41191521e-03f, 1.49808213e-01f, 1.39583841e-01f, 1.51172668e-01f, 2.67231204e-02f, 4.78037417e-01f, -1.42399110e-02f, 2.10949197e-01f, -1.89276829e-01f,
  1.11171573e-01f, 2.40054116e-01f, 2.18183726e-01f, -2.20315419e-02f, -1.52739987e-01f, 1.59332186e-01f, 1.60753801e-02f, -3.83007228e-02f, 6.18893234e-03f, 2.34340392e-02f,
  -5.96582890e-03f, 4.09487858e-02f, -1.02980174e-01f, 8.18055943e-02f, 1.36920035e-01f, 5.86272627e-02f, 6.47018924e-02f, 3.60599570e-02f, 6.01013303e-02f, 5.83195053e-02f,
  7.46055245e-02f, 3.46798101e-03f, 3.11521217e-02f, 6.13976642e-02f, -8.07549208e-02f, -1.12934418e-01f, 8.72548148e-02f, 5.85940517e-02f, -9.43938792e-02f, -3.67965624e-02f,
  5.88880293e-02f, -4.77969944e-02f, -2.55133156e-02f, -3.40099931e-02f, -1.12757705e-01f, -1.92178652e-01f, -1.28146216e-01f, -9.63265225e-02f, 1.66487187e-01f, -2.91840080e-02f,
  2.02005580e-02f, 7.65368789e-02f, -6.54859170e-02f, -6.17808178e-02f, -1.90563828e-01f, 1.11514300e-01f, -1.31834457e-02f, 5.77852167e-02f, -1.13826044e-01f, -1.03109367e-01f,
  -2.48354450e-02f, -7.22750574e-02f, -1.24740653e-01f, -1.24871477e-01f, 1.13419726e-01f, 1.57749392e-02f, 3.86142805e-02f, -1.42362356e-01f, -1.68020464e-02f, 1.91109553e-01f,
  -9.05192494e-02f, -1.47993132e-01f, -5.04635610e-02f, 2.07427833e-02f, 9.05771106e-02f, -1.03496924e-01f, -8.53339583e-02f, -5.26530556e-02f, -1.81067452e-01f, -4.56450656e-02f,
  1.27160400e-01f, -1.69946223e-01f, -1.10134803e-01f, 6.17305934e-02f, 9.64862630e-02f, 1.31070435e-01f, -1.07942307e-02f, 5.25242016e-02f, -5.14030382e-02f, 2.76386794e-02f,
  1.12562753e-01f, 8.51641968e-02f, 4.71725874e-02f, -1.87715158e-01f, -6.70553520e-02f, -4.46692407e-02f, 2.05688208e-01f, -1.89493582e-01f, -9.71381664e-02f, -5.61498920e-04f,
  1.91664293e-01f, 9.10140499e-02f, 5.62440977e-02f, -1.34175509e-01f, -4.57986891e-02f, -2.61777520e-01f, 7.20916130e-03f, -1.82890166e-02f, -7.68537000e-02f, 1.88837368e-02f,
  1.52478382e-01f, 8.19795355e-02f, 5.37171513e-02f, -8.41671824e-02f, 5.50077297e-02f, 1.39736950e-01f, 4.85312678e-02f, 1.90362468e-01f, -2.06819084e-02f, 1.51619360e-01f,
  -2.40041852e-01f, -3.55291553e-02f, 7.74838626e-02f, -1.16772406e-01f, -2.25996345e-01f, 1.58982486e-01f, 1.08367354e-02f, -1.87440768e-01f, 1.51765823e-01f, -6.91979676e-02f,
  3.32858503e-01f, 2.80724317e-02f, 1.56233355e-01f, 1.03120603e-01f, 1.04092024e-01f, 1.09479614e-01f, -5.85720167e-02f, 9.38143805e-02f, 8.43809023e-02f, 1.49562195e-01f,
  -8.21585879e-02f, -1.21339463e-01f, -6.71508312e-02f, 3.52588326e-01f, 2.23157108e-02f, -3.72314379e-02f, 2.16289666e-02f, 7.88596645e-02f, -3.76975611e-02f, -2.93642748e-02f,
  -5.37639707e-02f, -4.29666936e-02f, -6.52710423e-02f, 6.67768568e-02f, 2.11751699e-01f, -7.77251273e-02f, 7.62864351e-02f, -7.98711181e-02f, -1.49580717e-01f, -5.94458878e-02f,
  2.13207100e-02f, 5.59096262e-02f, 7.31645748e-02f, -6.67139664e-02f, -2.28821605e-01f, -2.36025415e-02f, 2.82541253e-02f, 7.30337426e-02f, -1.32613987e-01f, 6.47414625e-02f,
  -8.12868997e-02f, 1.61871687e-02f, 1.07747681e-01f, 1.07333437e-03f, 1.82418316e-03f, -1.00527689e-01f, 3.75233740e-02f, -1.74896363e-02f, -2.55668815e-02f, 1.06156111e-01f,
  2.95520760e-02f, 1.40774339e-01f, 2.24413797e-02f, -2.43927062e-01f, -2.61951797e-02f, 2.89122816e-02f, 5.92010170e-02f, 3.21098603e-02f, 1.03339069e-02f, 6.92265332e-02f,
  -2.09703207e-01f, 1.93643235e-02f, -3.89096439e-02f, 7.52643794e-02f, 3.35899852e-02f, -6.75076544e-02f, 1.02689050e-01f, -8.84713023e-04f, -1.08935297e-01f, -1.61272660e-01f,
  1.92024246e-01f, 8.84540007e-02f, -7.45672360e-02f, 1.35976833e-03f, 1.17103964e-01f, 2.77392082e-02f, -9.81999785e-02f, 4.27564494e-02f, 5.35018444e-02f, -2.52478709e-03f,
  1.42092973e-01f, 7.02676401e-02f, 6.03461005e-02f, 5.52519336e-02f, -2.13342700e-02f, 1.02604151e-01f, 2.88447499e-01f, 7.72524849e-02f, 4.49697673e-02f, -6.11575507e-02f,
  5.43679707e-02f, -6.08146861e-02f, 1.49349287e-01f, 1.79740507e-02f, -2.41154641e-01f, 6.99589550e-02f, -1.00605346e-01f, -3.45730521e-02f, 2.93370653e-02f, 7.79124424e-02f,
  7.58590698e-02f, -1.27811432e-01f, -9.77276862e-02f, 2.57543772e-01f, -6.20957054e-02f, 1.79492198e-02f, 1.14922725e-01f, -4.43637967e-02f, 2.14401126e-01f, -1.85018945e-02f,
  -9.19914059e-03f, 8.44990388e-02f, 1.52963519e-01f, 2.03917518e-01f, -3.83166410e-02f, -1.14406765e-01f, 2.30366904e-02f, 7.93248489e-02f, 2.39780843e-01f, 4.76609841e-02f,
  1.15010561e-03f, -5.15953861e-02f, -1.49904132e-01f, -3.56006101e-02f, -2.62211680e-01f, 3.08624417e-01f, 3.00052166e-01f, -3.63927335e-02f, -5.30086979e-02f, 1.28655568e-01f,
  -6.89582229e-02f, -3.92423458e-02f, 3.41492474e-01f, 2.18807068e-03f, 1.65697485e-01f, -1.91709518e-01f, -1.00875475e-01f, 6.21466041e-02f, -6.22910820e-02f, -1.42764032e-01f,
  1.75855886e-02f, 3.20031643e-01f, 1.72401622e-01f, 1.17753714e-01f, -5.28197140e-02f, -2.10668123e-03f, 1.69571862e-01f, 2.92173028e-01f, 5.94463497e-02f, 3.50077115e-02f,
  8.52435455e-02f, 1.87766165e-01f, -1.32406682e-01f, 7.25465268e-02f, -2.14909632e-02f, 1.38877920e-04f, 7.98785090e-02f, -9.76755843e-02f, -9.30749699e-02f, -1.34997126e-02f,
  1.56433553e-01f, -9.59807783e-02f, 1.55029848e-01f, -3.84262688e-02f, -6.83183176e-03f, 1.12076737e-01f, -5.91293685e-02f, -3.42825353e-02f, 2.54473109e-02f, 6.00949936e-02f,
  -1.04301438e-01f, 8.19969848e-02f, -1.45592615e-02f, -3.41328308e-02f, -1.75077558e-01f, 4.45126221e-02f, 7.09688105e-03f, -1.03079222e-01f, 1.20494895e-01f, 1.45053968e-01f,
  -1.04487045e-02f, 3.00951190e-02f, 2.61754617e-02f, 3.68242860e-02f, 1.33045137e-01f, -6.95916787e-02f, -3.63151208e-02f, 1.31160080e-01f, 7.43268356e-02f, -1.21492714e-01f,
  1.29142359e-01f, 1.25641033e-01f, -2.03058720e-02f, -1.10754617e-01f, 1.16654322e-01f, -1.40048444e-01f, -4.05178666e-02f, 1.25899121e-01f, -1.53317332e-01f, -2.95020118e-02f,
  1.94453180e-01f, 6.03060387e-02f, -4.11167592e-02f, -9.17875022e-02f, -1.98488645e-02f, -1.17067017e-01f, 4.79420647e-02f, 4.44422662e-02f, -2.45290846e-01f, 2.16739446e-01f,
  6.98945597e-02f, -3.38689685e-02f, -1.31069481e-01f, 2.33942866e-01f, -1.55160695e-01f, 1.21051535e-01f, 1.64731607e-01f, -5.03061637e-02f, -1.38405636e-01f, 2.00113952e-01f,
  9.22913700e-02f, -1.45321153e-02f, 1.70313165e-01f, -9.60964859e-02f, 4.24363725e-02f, -1.07974134e-01f, -9.30626765e-02f, -6.25650957e-02f, 1.22479305e-01f, -2.87873391e-02f,
  -8.80890340e-02f, -4.24094982e-02f, 1.46271929e-01f, -1.75903052e-01f, -7.30282366e-02f, -8.07432979e-02f, -3.88839059e-02f, -1.56165019e-01f, -9.76276621e-02f, 8.70868042e-02f,
  -1.42003577e-02f, -1.73781618e-01f, 2.26817101e-01f, -1.10980704e-01f, 1.55760124e-01f, 8.95321518e-02f, 1.61628291e-01f, -1.28801003e-01f, 1.52851179e-01f, 1.89783648e-01f,
  1.89759910e-01f, -3.09447140e-01f, -9.35427397e-02f, 1.96518913e-01f, 7.27535784e-02f, 1.13717861e-01f, -1.07445277e-01f, -4.38316315e-02f, -6.80687428e-02f, 1.25781313e-01f,
  7.36665055e-02f, -2.51358259e-03f, -1.11238798e-03f, -2.35447899e-01f, 8.93759727e-02f, -1.20171152e-01f, -4.94670309e-03f, -9.18830484e-02f, -1.12643987e-01f, 1.84143513e-01f,
  -2.77203973e-03f, -2.22153799e-03f, -3.10410117e-03f, 2.73496006e-02f, -6.12930544e-02f, -6.35726079e-02f, -9.08201486e-02f, -3.06235830e-04f, -1.67553067e-01f, 3.31476182e-02f,
  4.84183542e-02f, -5.67272566e-02f, 5.90371527e-02f, 1.18435975e-02f, 2.15149578e-02f, -2.97385398e-02f, -3.86504792e-02f, 8.94343406e-02f, 8.58218744e-02f, 3.08753345e-02f,
  1.51306435e-01f, -3.93022150e-02f, 7.44434148e-02f, 2.92157643e-02f, 7.26090297e-02f, 2.77432799e-02f, 3.05367447e-02f, -9.54814032e-02f, -1.04620397e-01f, 2.05708638e-01f,
  4.61669154e-02f, -3.61329429e-02f, 6.55371472e-02f, 2.50600614e-02f, -1.25483483e-01f, 9.79064107e-02f, 3.04262936e-02f, -3.68482135e-02f, 8.24469402e-02f, -8.91240463e-02f,
  -8.58038664e-02f, -3.00539583e-02f, -6.78255185e-02f, -8.35806802e-02f, -3.41095123e-03f, 1.46284357e-01f, 1.17244452e-01f, -4.46488746e-02f, 1.99684128e-03f, -2.97790822e-02f,
  -2.00484663e-01f, 6.36685789e-02f, -3.26842070e-02f, 1.27901495e-01f, 1.26485199e-01f, 1.10949688e-01f, 1.23805135e-01f, 7.62156723e-03f, 1.84052996e-02f, 1.61984816e-01f,
  -8.41252804e-02f, 1.40174432e-02f, 1.70647591e-01f, 3.03914258e-03f, -1.41297057e-01f, 4.61420976e-02f, 1.19381845e-01f, -8.56283214e-03f, -6.46068826e-02f, -1.65805072e-01f,
  -2.65895482e-02f, 2.32471868e-01f, -5.59510402e-02f, 1.00294255e-01f, -2.11523190e-01f, -1.25119179e-01f, -7.42732212e-02f, 7.17339888e-02f, -2.55958438e-02f, -6.42761439e-02f,
  -7.34511390e-02f, 1.14728369e-01f, 1.48956448e-01f, -9.20475349e-02f, -2.20347159e-02f, -9.11323577e-02f, -7.44746476e-02f, 1.02955177e-01f, 4.12845798e-02f, 5.56217469e-02f,
  -1.26751736e-01f, 4.18328531e-02f, -1.05004624e-01f, -6.91746399e-02f, -1.43739209e-01f, 1.91281825e-01f, -6.12277687e-02f, 1.88250288e-01f, -1.25633180e-01f, -3.79691944e-02f,
  -8.10685456e-02f, -2.40141824e-02f, 1.05121426e-01f, -7.66021237e-02f, 1.02800846e-01f, -7.15667084e-02f, 2.50470899e-02f, 5.10160550e-02f, -1.58353150e-01f, -1.05791382e-01f,
  3.15588057e-01f, 2.39010364e-01f, 1.11160383e-01f, -8.30758214e-02f, -3.80522311e-01f, -7.83089474e-02f, -6.61124140e-02f, 5.59318215e-02f, -2.88292557e-01f, -1.36412904e-01f,
  -9.93380547e-02f, 1.34279355e-01f, -8.67952108e-02f, -8.94501805e-02f, -1.20870238e-02f, -1.62660360e-01f, -5.43591939e-02f, -1.45662263e-01f, -7.44388402e-02f, 6.26008883e-02f,
  -7.02105984e-02f, 7.36013278e-02f, 9.98134911e-02f, -2.57198736e-02f, 6.80262521e-02f, -4.68362384e-02f, -7.35273287e-02f, -4.73501422e-02f, -2.26503261e-03f, -6.41069338e-02f,
  1.18676350e-01f, -9.21642967e-03f, 9.39126536e-02f, -1.50135588e-02f, -2.01710742e-02f, 7.85132423e-02f, -1.08354934e-01f, -5.50315306e-02f, -1.27476916e-01f, 1.64765477e-01f,
  1.47541631e-02f, -8.08642954e-02f, -2.47106981e-02f, -7.51681672e-03f, 5.75029701e-02f, -8.95767380e-03f, -1.15920454e-01f, -2.11869001e-01f, -1.72828510e-02f, -9.29097161e-02f,
  4.77207415e-02f, -3.33084096e-03f, 1.55363828e-02f, 1.58279449e-01f, -7.30986893e-03f, -1.23492844e-01f, -1.04096392e-03f, 4.46073748e-02f, -2.08469126e-02f, -9.23642740e-02f,
  4.96034175e-02f, 1.17086479e-02f, 2.93890350e-02f, -4.04374301e-02f, 2.89993100e-02f, -2.57189060e-03f, -5.54354340e-02f, 5.07622818e-03f, -9.18308496e-02f, -2.20498949e-01f,
  -7.40037858e-02f, 2.17753649e-02f, 1.39927804e-01f, -2.39937585e-02f, -4.05210912e-01f, -1.64842047e-02f, 4.56886329e-02f, -1.27318159e-01f, 3.88072021e-02f, -1.64766032e-02f,
  -1.91319048e-01f, -5.68879172e-02f, 1.66227221e-01f, -5.62870130e-02f, -1.49097607e-01f, 8.03271756e-02f, 2.56359547e-01f, -8.28482509e-02f, -1.57240778e-01f, 1.12811781e-01f,
  5.28379828e-02f, -7.17990547e-02f, 3.50752115e-01f, 7.24247769e-02f, -6.85972273e-02f, 1.89158261e-01f, 1.62446901e-01f, 8.49846229e-02f, 2.09071249e-01f, -2.10046954e-02f,
  1.62293320e-03f, 1.18738540e-01f, 1.19992293e-01f, 2.86491401e-02f, 4.58402000e-02f, -2.62531312e-03f, 1.45983219e-01f, 1.60666734e-01f, 3.62801582e-01f, 9.91319045e-02f,
  -9.96127203e-02f, -1.13252260e-01f, -5.35224825e-02f, 1.08730219e-01f, 2.64341801e-01f, -4.60545756e-02f, 2.36111730e-01f, 1.82015017e-01f, 2.95549259e-02f, -2.68219095e-02f,
  7.85948038e-02f, -9.63944383e-03f, -5.65007664e-02f, -1.84596509e-01f, 1.70711502e-02f, 1.40036404e-01f, -1.74541457e-03f, -1.25929520e-01f, -1.43011883e-01f, 1.58492029e-01f,
  2.30094604e-02f, -9.82647091e-02f, 6.61444589e-02f, -1.29164895e-02f, 2.63312478e-02f, -3.76457460e-02f, 1.82777539e-01f, 6.77123815e-02f, -5.02845086e-02f, 1.09443322e-01f,
  -4.29833382e-02f, -5.15685901e-02f, 5.26299477e-02f, 4.46456559e-02f, 7.67974854e-02f, 4.47937876e-01f, 1.12804379e-02f, -1.03514984e-01f, 1.69973448e-01f, -4.72293049e-02f,
  5.89546971e-02f, -4.19610925e-03f, 7.11959824e-02f, -2.32286286e-02f, 1.86718091e-01f, -4.31347527e-02f, 1.61008522e-01f, -4.22569625e-02f, 1.04908355e-01f, -3.91009599e-02f,
  8.57231319e-02f, -2.27467921e-02f, 4.57634926e-02f, 6.91002794e-03f, 9.59742218e-02f, -9.21878964e-02f, 5.66810556e-03f, 4.48777005e-02f, 1.43702418e-01f, 2.22999807e-02f,
  4.15081047e-02f, 1.09062344e-01f, -7.03679994e-02f, 9.28796902e-02f, 2.17165127e-01f, -1.80175111e-01f, 4.52993438e-02f, -4.50197943e-02f, -3.29670310e-02f, 2.34492566e-03f,
  -2.12299615e-01f, -4.32700291e-02f, -2.59117633e-02f, 7.06772506e-02f, -1.63676292e-01f, -6.01049028e-02f, -1.75447240e-02f, 9.90369469e-02f, 5.98382913e-02f, 1.04293071e-01f,
  -6.98673585e-03f, -1.26410116e-04f, -1.86691865e-01f, -7.69179985e-02f, 1.19671062e-01f, 1.43500259e-02f, 5.35596199e-02f, -1.18691526e-01f, 1.31408215e-01f, -9.24474932e-03f,
  6.75931647e-02f, -2.69841105e-02f, -2.71008849e-01f, -7.01302588e-02f, 1.56748407e-02f, -9.17860568e-02f, 1.25919131e-03f, 8.75195786e-02f, 3.47521827e-02f, -1.56660363e-01f,
  2.15955805e-02f, -5.54412939e-02f, -9.92429629e-02f, 1.23898059e-01f, -1.65152371e-01f, -3.34360637e-02f, 1.64068788e-01f, -4.13021073e-02f, 6.63257241e-02f, -4.62315492e-02f,
  -1.32874086e-01f, 4.79967184e-02f, -4.49457280e-02f, 8.49372000e-02f, 5.33626266e-02f, -7.88107589e-02f, 2.56352723e-01f, -2.77284980e-02f, 4.57283780e-02f, 1.19883507e-01f,
  1.17109992e-01f, 1.69650763e-01f, 5.32104559e-02f, -2.53829509e-01f, 8.81870836e-02f, -4.85444143e-02f, 1.66018248e-01f, -5.24859428e-02f, 1.58160478e-01f, -1.28681511e-01f,
  1.06234461e-01f, -1.49618521e-01f, 3.81897502e-02f, -3.41988325e-01f, -3.41533273e-02f, -1.54813388e-02f, 1.47383794e-01f, -3.98281701e-02f, 5.86004034e-02f, -1.70019101e-02f,
  -3.51946764e-02f, 5.07943192e-03f, 3.99826206e-02f, 1.76544848e-03f, 1.98480293e-01f, -1.29838765e-01f, -1.28780738e-01f, 1.85448110e-01f, -4.14655777e-03f, 2.41373673e-01f,
  1.51987955e-01f, 3.21695842e-02f, -6.43694177e-02f, 8.04357976e-02f, 1.97664455e-01f, -5.18610701e-03f, 3.43245417e-02f, 1.55138085e-02f, 1.23925479e-02f, 2.00158954e-02f,
  -3.73515338e-02f, -1.41734377e-01f, -1.40199286e-03f, 2.21791863e-01f, -1.94738150e-01f, -7.76242092e-02f, 2.10301988e-02f, 6.13456555e-02f, -4.01019789e-02f, 8.40193778e-02f,
  8.05610865e-02f, 1.71974301e-02f, 1.23767547e-01f, 2.99037248e-02f, 3.50323655e-02f, -1.73109006e-02f, 1.42399576e-02f, -1.86773017e-02f, 5.65252863e-02f, 4.03240835e-03f,
  4.67126779e-02f, -9.86533687e-02f, -4.09340635e-02f, -9.12439227e-02f, 1.04530454e-01f, -8.62539560e-02f, 9.33116600e-02f, 6.00623675e-02f, 8.49961117e-02f, -2.38826461e-02f,
  5.40496921e-03f, -1.21197768e-01f, 5.66586629e-02f, -1.30963936e-01f, 2.42740046e-02f, -8.25204253e-02f, 2.11436711e-02f, 6.58874214e-02f, 3.28251347e-02f, 1.10051624e-01f,
  -6.17212392e-02f, 8.16557705e-02f, -1.48517311e-01f, 2.18556765e-02f, 3.89089473e-02f, -1.65783465e-01f, -6.41448349e-02f, -6.56998828e-02f, 2.40662768e-01f, -2.91360151e-02f,
  -2.04098150e-02f, -4.94269328e-03f, 1.14244327e-01f, -8.96940753e-02f, 1.46636423e-02f, -6.30095676e-02f, 7.06603304e-02f, 3.69853154e-02f, 5.29307947e-02f, -2.59854168e-01f,
  -9.83422026e-02f, 9.86857805e-03f, -8.46013352e-02f, -2.06684172e-01f, -3.42733518e-04f, 6.95578754e-02f, 5.21207750e-02f, 4.61520962e-02f, -1.47915348e-01f, -9.82619748e-02f,
  -1.28510203e-02f, -1.44624114e-01f, -7.61783170e-03f, 1.00204587e-01f, -1.74240783e-01f, -2.26191312e-01f, 5.95066845e-02f, 9.51482728e-02f, -1.29487105e-02f, 1.70315370e-01f,
  1.25336185e-01f, -1.44257307e-01f, -1.57537013e-01f, -5.29430509e-02f, 5.00852801e-02f, -1.42253235e-01f, -2.38108765e-02f, 1.21372111e-01f, 1.32464737e-01f, 5.99610247e-02f,
  3.64465453e-02f, 1.67281181e-01f, -4.54505496e-02f, 1.46299899e-02f, 3.76026034e-02f, -3.46471928e-02f, 2.52598166e-01f, 5.95325455e-02f, 3.17366719e-02f, -1.98052645e-01f,
  1.38177827e-01f, -2.20326602e-01f, -4.97626700e-02f, 8.22860189e-03f, 9.79250073e-02f, -2.13416503e-03f, -2.41103098e-01f, 1.09772068e-02f, -6.17209859e-02f, -9.70649160e-03f,
  -5.91020808e-02f, -4.16807942e-02f, 2.87717074e-01f, 3.26079637e-01f, 1.51163429e-01f, -3.45311999e-01f, -1.37405306e-01f, 1.76823333e-01f, 1.85636446e-01f, -1.15579203e-01f,
  -1.18056506e-01f, -5.44676073e-02f, -1.29817119e-02f, 9.70440656e-02f, -6.53484836e-02f, 2.25832388e-01f, 1.85403571e-01f, 4.50797565e-02f, -1.09892353e-01f, 1.29096415e-02f,
  1.55527934e-01f, -1.80409953e-01f, -2.31814697e-01f, -1.58765763e-01f, 6.66799098e-02f, -1.25383675e-01f, -2.92002745e-02f, -1.05410874e-01f, -1.51261389e-01f, -2.14323640e-01f,
  -6.22698013e-03f, 1.27042696e-01f, 1.02557696e-01f, -1.03420325e-01f, -8.12714361e-03f, 8.48339219e-03f, -1.02265701e-01f, -1.38096124e-01f, -4.67500426e-02f, 1.69153661e-02f,
  4.70953882e-02f, -1.91090081e-03f, -1.98013969e-02f, 1.28680393e-01f, -1.47078440e-01f, -7.42578059e-02f, -6.77458197e-02f, -4.29009758e-02f, 6.79524541e-02f, -3.53039503e-02f,
  -7.35575259e-02f, -1.19118713e-01f, 1.17560349e-01f, -9.10473689e-02f, -3.13708447e-02f, 4.39136997e-02f, -2.62368955e-02f, 7.63724595e-02f, -1.53865374e-03f, -1.01686262e-01f,
  5.87248132e-02f, -1.40962765e-01f, -1.01240054e-01f, -1.90782219e-01f, -1.84263498e-01f, 2.84138452e-02f, 5.93316592e-02f, -1.03977330e-01f, 4.18613069e-02f, -1.82467282e-01f,
  -3.80326733e-02f, 5.91513887e-02f, -8.06860477e-02f, -1.02153279e-01f, -6.64228648e-02f, -6.54726326e-02f, 1.73721313e-02f, 1.75653636e-01f, -1.86433107e-01f, -6.29749522e-02f,
  1.08073056e-02f, 2.23700777e-02f, -3.87721956e-02f, -6.13082387e-03f, -7.31690153e-02f, 7.05185980e-02f, 1.30933747e-01f, -1.11837298e-01f, 1.56831034e-02f, 1.90837905e-01f,
  -8.89165998e-02f, 1.69391096e-01f, 1.24497347e-01f, -4.21469994e-02f, -2.14570820e-01f, 5.10840788e-02f, 9.16248783e-02f, -9.71558094e-02f, -5.07924631e-02f, 3.06583289e-02f,
  6.91913292e-02f, -3.81309427e-02f, 8.40408653e-02f, -5.85407577e-02f, 1.45921201e-01f, -9.72673744e-02f, -1.74152359e-01f, 1.03078194e-01f, 1.40599698e-01f, 1.75606832e-01f,
  -3.78579199e-02f, 7.05822632e-02f, 1.96924973e-02f, -8.32607895e-02f, -8.04888904e-02f, 1.00799076e-01f, 1.47691858e-03f, -2.09491983e-01f, 3.20735797e-02f, 9.80624631e-02f,
  2.43444592e-02f, -1.86482355e-01f, 2.67351925e-01f, 3.57617810e-02f, -1.07639313e-01f, -3.91707569e-02f, 1.07067920e-01f, -5.82408793e-02f, -1.22768626e-01f, -6.21795617e-02f,
  2.54089743e-01f, -1.92689151e-01f, -3.30340713e-01f, 2.96807028e-02f, 4.55477238e-02f, 1.01911888e-01f, -1.12467162e-01f, -2.25106597e-01f, 4.12298851e-02f, -3.73037010e-02f,
  1.15350358e-01f, 1.34316953e-02f, -1.03304043e-01f, -3.54463863e-03f, 8.59753639e-02f, -5.93485944e-02f, 2.16166437e-01f, -1.67007186e-02f, 3.95901501e-02f, 1.39316708e-01f,
  -1.47015288e-01f, -1.73874944e-02f, -1.01188749e-01f, 6.07781187e-02f, -3.28804851e-02f, 1.15248561e-02f, 2.75770389e-02f, 1.06483318e-01f, -4.01519686e-02f, 4.32898626e-02f,
  -9.66061056e-02f, -1.62493307e-02f, -8.32801908e-02f, -1.81970760e-01f, -8.35214481e-02f, -1.72309682e-01f, -6.40831888e-02f, -1.07511720e-02f, 1.10534705e-01f, -1.19635001e-01f,
  -6.22228719e-02f, -3.52811180e-02f, 6.46727830e-02f, 7.20746443e-02f, -5.94156273e-02f, 3.27927060e-02f, -2.20764503e-02f, -7.69276991e-02f, -9.31921415e-03f, -8.74137878e-02f,
  -7.61738196e-02f, -7.53821209e-02f, 5.43885976e-02f, 7.90961366e-03f, -1.48337930e-01f, 5.13363034e-02f, 1.69967979e-01f, -2.53222752e-02f, -1.98031701e-02f, -1.02373948e-02f,
  1.61219910e-02f, 1.18243784e-01f, -4.74873036e-02f, 2.42926879e-03f, 2.01459415e-02f, -2.43198033e-03f, -1.96305700e-02f, -6.08102232e-02f, 1.07579015e-01f, -1.92295372e-01f,
  -6.22301474e-02f, 6.48551956e-02f, 9.60159004e-02f, 5.92594631e-02f, -1.30241169e-02f, -1.46611378e-01f, 9.70183313e-02f, 2.43139435e-02f, -4.89865318e-02f, 6.72436203e-04f,
  6.33439571e-02f, 5.55538163e-02f, -5.72332647e-03f, -1.97303258e-02f, 9.07540023e-02f, -1.16945766e-01f, 1.50336966e-01f, 1.32770007e-02f, -1.65152341e-01f, -6.94576278e-02f,
  9.50859115e-02f, 8.97441879e-02f, 1.11597493e-01f, -2.58102566e-02f, -1.83566675e-01f, 6.40765950e-02f, 3.47186369e-03f, -3.91250104e-02f, 1.86052527e-02f, -1.15304696e-03f,
  -1.75640061e-01f, 1.11836433e-01f, 2.43442915e-02f, 1.39229625e-01f, 4.23296215e-03f, 1.34065062e-01f, 8.55212733e-02f, -1.38007760e-01f, 9.37767699e-02f, 5.70475459e-02f,
  1.18212089e-01f, 6.87279403e-02f, 2.33313888e-01f, -3.41498591e-02f, 4.30756509e-02f, 1.61477834e-01f, -4.60100584e-02f, 4.93659312e-03f, 7.33398795e-02f, 1.35958910e-01f,
  -5.91950342e-02f, -1.91713512e-01f, -5.62250577e-02f, 4.44288291e-02f, -9.19912979e-02f, -3.97079950e-03f, -3.50047424e-02f, -2.09253263e-02f, -2.86266148e-01f, 2.68227421e-02f,
  -5.84121533e-02f, 1.44881010e-01f, 1.22365378e-01f, 1.22426376e-01f, -1.56039642e-02f, 1.39465317e-01f, 1.05671495e-01f, -2.72318311e-02f, 1.06022678e-01f, 9.12660211e-02f,
  9.44138598e-03f, 2.50573188e-01f, 1.14658577e-02f, 3.73628773e-02f, -2.44063064e-02f, 7.20361471e-02f, -1.12666590e-02f, 2.04578206e-01f, -1.64516672e-01f, -5.40396757e-03f,
  3.89795229e-02f, -6.82251994e-03f, 2.32910197e-02f, -4.50531393e-02f, 1.24449972e-02f, -5.74265830e-02f, -6.78154733e-03f, 5.51237948e-02f, -3.74635756e-02f, 7.97030479e-02f,
  -8.95188935e-03f, 7.04305321e-02f, 1.24126881e-01f, 1.98508594e-02f, 1.06720999e-01f, -1.28115222e-01f, 6.37036413e-02f, 7.60480389e-02f, -1.11428811e-03f, 7.55928159e-02f,
  4.43746932e-02f, 8.01058544e-04f, 1.38555467e-01f, -4.72376868e-02f, 1.07087947e-01f, -3.38923186e-02f, 2.80377008e-02f, -4.73338775e-02f, 4.60305810e-02f, -5.97391464e-03f,
  -1.16789322e-02f, -1.05105098e-02f, 7.14233667e-02f, -1.32762026e-02f, 1.44840088e-02f, 1.10904284e-01f, 4.32847813e-02f, 2.39912793e-02f, 2.00343318e-02f, -8.90032053e-02f,
  6.10269159e-02f, -1.06806874e-01f, 1.15042336e-01f, -7.87887573e-02f, 1.31305888e-01f, 7.77999386e-02f, -6.20021075e-02f, 3.55176963e-02f, -2.60382537e-02f, 1.11301340e-01f,
  6.63515553e-02f, -9.56406991e-04f, 3.75306532e-02f, -4.56023030e-02f, -7.51167089e-02f, -6.02929369e-02f, 2.80685741e-02f, -1.15446210e-01f, -8.55207909e-03f, 7.15594813e-02f,
  5.89385927e-02f, -2.49979571e-02f, 1.34771783e-02f, 1.84735097e-02f, 5.08781448e-02f, -5.74568734e-02f, -6.40880615e-02f, -2.76686512e-02f, -8.78704339e-02f, -1.74479619e-01f,
  -1.95936978e-01f, -7.46495835e-03f, 3.62796895e-02f, 4.18049917e-02f, -3.72618325e-02f, -1.30581418e-02f, -1.25124216e-01f, 5.53713590e-02f, -2.23950028e-01f, -7.67845288e-02f,
  -4.44971360e-02f, 1.90505713e-01f, -6.00833297e-02f, -4.15650271e-02f, -5.82393296e-02f, 1.39565900e-01f, 3.45710330e-02f, -1.14466600e-01f, -6.49834722e-02f, -1.39941769e-02f,
  1.50481183e-02f, -7.65823647e-02f, 1.29296333e-01f, -1.83843600e-03f, 1.26551047e-01f, -3.58131155e-02f, -4.45655994e-02f, -6.93407133e-02f, 1.06968796e-02f, 3.91938128e-02f,
  -1.30751953e-02f, -7.42040202e-02f, -1.84826449e-01f, -7.52570182e-02f, -6.51777312e-02f, 6.43443912e-02f, 7.38665760e-02f, 1.27423659e-01f, 4.04964596e-01f, -2.21973494e-01f,
  6.52768314e-02f, -3.48471254e-02f, -1.06073663e-01f, -2.49623865e-01f, 6.37817085e-02f, 4.75470461e-02f, -8.00530612e-02f, 1.88114554e-01f, -8.84581357e-02f, 9.66843069e-02f,
  1.33880898e-01f, -1.35610044e-01f, 8.62528309e-02f, 8.17769915e-02f, -2.12257938e-03f, -2.84571350e-01f, 3.72959562e-02f, 1.14946790e-01f, -8.72391760e-02f, 1.64498314e-01f,
  -7.31253996e-02f, -4.01449911e-02f, -2.78309267e-02f, -1.63587645e-01f, -4.07577790e-02f, 4.51804604e-03f, 5.76386116e-02f, -1.01608291e-01f, -5.07834181e-02f, -1.37420550e-01f,
  5.73831759e-02f, -7.31345266e-02f, -1.57731861e-01f, 5.22298366e-03f, 2.97192894e-02f, 3.67739014e-02f, 2.26433724e-02f, 1.53514758e-01f, 2.63167694e-02f, -7.08330283e-03f,
  -1.82791770e-01f, -4.13390324e-02f, -7.75796920e-02f, -6.61111549e-02f, 1.10342614e-02f, 1.24175861e-01f, -3.81749310e-02f, 2.08255406e-02f, -7.18183517e-02f, -7.98457414e-02f,
  -9.07912180e-02f, -3.58504355e-02f, -5.16430996e-02f, -8.40268843e-03f, 6.09159134e-02f, -4.75675054e-02f, 1.48690762e-02f, 2.01453418e-02f, 4.01703678e-02f, 1.36441726e-03f,
  -5.69727346e-02f, -5.29922694e-02f, 1.87233597e-01f, 1.27709759e-02f, -1.22983918e-01f, -9.48288441e-02f, 4.41042781e-02f, 1.04644686e-01f, 5.56315370e-02f, -8.43653530e-02f,
  5.60693145e-02f, 2.12057725e-01f, 2.75064427e-02f, -6.26767203e-02f, 5.12057450e-03f, 1.28186464e-01f, -3.01752053e-02f, -2.21098103e-02f, 1.68024600e-02f, -1.22879051e-01f,
  -1.35553405e-02f, 6.01823954e-03f, 2.67167483e-02f, -3.32664102e-02f, -4.35055681e-02f, -8.37462544e-02f, 1.05438819e-02f, 1.68582812e-01f, -8.93904716e-02f, 2.96084508e-02f,
  -1.21935673e-01f, -6.63798824e-02f, -2.87934132e-02f, 1.46924317e-01f, 9.96807888e-02f, -5.33937328e-02f, -6.98631704e-02f, 1.82551257e-02f, 1.46657512e-01f, -1.47447869e-01f,
  -7.44293481e-02f, -5.52200489e-02f, 8.50523934e-02f, 7.52992108e-02f, 8.58025178e-02f, 3.90972979e-02f, 8.78753364e-02f, 5.63821048e-02f, -2.37399284e-02f, -1.06479451e-01f,
  -9.66376513e-02f, 1.12631917e-01f, -2.13523582e-02f, 2.86635190e-01f, 1.15565294e-02f, 7.29387179e-02f, -5.35986833e-02f, -7.33305141e-02f, 2.05769107e-01f, 6.72954768e-02f,
  1.49221912e-01f, 7.17469230e-02f, 3.73551063e-02f, 5.74664138e-02f, -2.28503108e-01f, -2.99839675e-01f, -2.11900920e-01f, 3.02954674e-01f, -1.90296432e-03f, -9.46692154e-02f,
  -2.64220268e-01f, -5.66300750e-02f, 4.60505523e-02f, -1.71339229e-01f, 1.16004646e-01f, 1.20834401e-02f, 1.17340367e-02f, 7.54878297e-02f, -1.38097703e-02f, 4.44086678e-02f,
  2.31999066e-03f, -9.07479152e-02f, 4.28586127e-03f, -1.61520481e-01f, -3.64915207e-02f, 1.00176334e-01f, 1.23549432e-01f, 6.06221445e-02f, -5.52388513e-03f, -4.20327066e-03f,
  3.07622775e-02f, 5.87503053e-02f, 2.82842107e-02f, 7.79244006e-02f, -1.17190108e-01f, -5.59762083e-02f, -3.98125090e-02f, 6.18923828e-02f, 4.87097837e-02f, 1.74105182e-01f,
  -7.24915043e-02f, 2.58292351e-03f, -1.47643402e-01f, 2.78726164e-02f, 4.64391522e-02f, 2.61384934e-01f, 1.28128221e-02f, 2.58557629e-02f, -3.69361080e-02f, 1.34545583e-02f,
  -1.04354829e-01f, -8.70813131e-02f, -2.62326449e-02f, -6.36996403e-02f, -1.11244835e-01f, -1.82978027e-02f, 1.79595351e-01f, 2.08097678e-02f, -3.11746895e-02f, -9.25405174e-02f,
  -2.35782892e-01f, -8.47841352e-02f, 3.47415693e-02f, 9.11975931e-03f, -6.10718541e-02f, -9.77958068e-02f, 3.12162060e-02f, 8.72191228e-03f, -1.58447117e-01f, -2.62555219e-02f,
  -2.98936069e-02f, 6.08631053e-05f, -1.59588099e-01f, -1.37037277e-01f, 3.30377631e-02f, -3.43340226e-02f, -4.76383325e-03f, 1.58764776e-02f, 9.79823917e-02f, 1.01283871e-01f,
  -5.68897501e-02f, 6.99343765e-03f, 6.89353049e-02f, 1.23665400e-01f, -6.08996442e-03f, -9.16526839e-02f, 8.85056257e-02f, -1.29754961e-01f, 9.18231234e-02f, 2.16287430e-02f,
  -1.44635782e-01f, -1.56758390e-02f, 9.68336239e-02f, 4.95301047e-03f, -1.53465167e-01f, 1.00310899e-01f, 9.32919234e-02f, -6.11993484e-02f, 1.89777792e-01f, 9.22764391e-02f,
  -5.25845550e-02f, 3.00215115e-03f, 4.23969105e-02f, 5.61445951e-02f, 2.43763298e-01f, -2.47192685e-03f, -6.44364720e-03f, -4.77193557e-02f, 3.77060310e-03f, 1.60051256e-01f,
  -3.15050445e-02f, -5.91052547e-02f, -8.97644013e-02f, -7.40123391e-02f, 1.03752345e-01f, -2.21230015e-02f, -2.28104398e-01f, -3.23880091e-02f, -1.16274387e-01f, 6.86918125e-02f,
  1.63972452e-01f, 8.52562636e-02f, 9.96036008e-02f, 6.25894964e-02f, 1.79044574e-01f, -1.53984139e-02f, 3.49983990e-01f, 1.00430667e-01f, 1.27692863e-01f, 3.46165486e-02f,
  5.92342466e-02f, 1.94789231e-01f, -1.55448467e-01f, -2.71505445e-01f, -2.29883984e-01f, -1.70573797e-02f, -7.32588917e-02f, -1.53800929e-02f, 2.69649744e-01f, 2.38282591e-01f,
  1.51278436e-01f, -7.37868696e-02f, 1.57069087e-01f, -1.43591408e-02f, 1.12991564e-01f, -1.04828708e-01f, -4.30769809e-02f, -1.52884629e-02f, -2.43043508e-02f, 1.81768218e-03f,
  -1.96950305e-02f, 2.41443098e-01f, -1.52265474e-01f, -7.82266185e-02f, -8.73094946e-02f, 9.33967624e-03f, 1.00627616e-02f, -2.65527405e-02f, -1.00530148e-01f, -8.87477100e-02f,
  -6.47957250e-02f, 5.23035191e-02f, 8.95771757e-02f, 3.21750604e-02f, 1.25520498e-01f, 3.39009836e-02f, 4.45827469e-02f, -1.63406208e-01f, 6.51416108e-02f, 6.57339692e-02f,
  -1.07863583e-01f, -6.66941181e-02f, 5.60649335e-02f, 1.34143949e-01f, 2.35243272e-02f, 3.38996872e-02f, 7.95052573e-02f, 3.74803785e-03f, -3.17651220e-02f, -4.68020402e-02f,
  -2.29784176e-01f, -4.89478484e-02f, -4.05023806e-02f, -3.22032571e-02f, -4.31634765e-03f, 9.99508128e-02f, -1.07655011e-01f, 8.63066912e-02f, -4.21759449e-02f, 2.23597023e-03f,
  -1.38699384e-02f, 1.73877161e-02f, 1.95021071e-02f, -3.86366046e-05f, -7.74136484e-02f, -8.64761323e-02f, 3.33929397e-02f, 3.24964672e-02f, -1.48294017e-01f, -1.24391392e-01f,
  3.86428311e-02f, 2.40519673e-01f, -4.99453396e-02f, -2.88456883e-02f, -1.93600133e-02f, -5.60676940e-02f, -1.26851872e-01f, -2.26345792e-01f, 3.91790867e-02f, -4.29579355e-02f,
  2.17584558e-02f, -1.28927767e-01f, -4.45547923e-02f, -1.62881106e-01f, -4.27347794e-02f, 1.36040263e-02f, -5.51386662e-02f, -4.62645292e-02f, -7.63636827e-02f, 1.99373916e-01f,
  1.02585159e-01f, -4.14177477e-02f, -4.28591557e-02f, 1.78941116e-01f, -6.09816425e-02f, -5.95250949e-02f, 2.11004525e-01f, -1.10843852e-01f, 1.21970974e-01f, 7.26231262e-02f,
  5.70134819e-02f, 5.75886434e-03f, 2.36276761e-01f, 1.07221194e-02f, 8.63238424e-02f, -1.63529322e-01f, -8.68418515e-02f, -1.06772788e-01f, -1.38034970e-01f, 7.27391690e-02f,
  6.26990870e-02f, -1.40272841e-01f, 2.40202203e-01f, 1.02677882e-01f, -1.30488247e-01f, -1.11795157e-01f, 7.22720847e-02f, 2.02036425e-01f, 2.40868092e-01f, -5.96432127e-02f,
  -4.50177938e-02f, -4.18952107e-02f, -1.50261968e-01f, 3.76386344e-02f, -3.07301935e-02f, 1.34204319e-02f, 3.35500985e-02f, -1.56586096e-01f, 1.26178995e-01f, -6.27893358e-02f,
  -3.05982441e-01f, 1.71235725e-01f, 8.80508572e-02f, -3.95148546e-02f, 1.96037024e-01f, -2.65026063e-01f, 2.62856577e-02f, 5.56187192e-03f, -3.25032622e-02f, 1.62666410e-01f,
  9.04142335e-02f, -9.05417129e-02f, -2.60731224e-02f, 8.37605968e-02f, 8.19468275e-02f, -3.20336252e-01f, 1.67660341e-01f, -5.73590323e-02f, -1.11774094e-01f, 3.91105771e-01f,
  -1.06236719e-01f, 4.87876795e-02f, 8.02182928e-02f, -5.90151958e-02f, 2.27324236e-02f, -5.52657247e-03f, 6.97844476e-02f, 1.16014212e-01f, 5.19171134e-02f, 3.64963375e-02f,
  3.06406301e-02f, -6.80918023e-02f, -8.09332132e-02f, 6.30665645e-02f, -1.56709835e-01f, 8.90258029e-02f, 4.43581343e-02f, 1.45667847e-02f, -1.21436626e-01f, 1.50799155e-01f,
  2.85646021e-02f, -1.28440663e-01f, -4.13286574e-02f, -6.04216084e-02f, -1.11018568e-01f, 5.91462366e-02f, 1.72504112e-02f, 4.39322134e-03f, -3.59108634e-02f, 2.07050264e-01f,
  -5.07451631e-02f, -4.36510369e-02f, 4.32139859e-02f, 8.45175311e-02f, -2.84029115e-02f, -1.46894470e-01f, -8.04094002e-02f, -1.75189674e-02f, -5.35109965e-03f, -1.01241812e-01f,
  1.03453495e-01f, -1.55096024e-01f, 2.27525532e-02f, 8.29365253e-02f, 4.58736308e-02f, 2.51394417e-02f, 9.29505751e-02f, 4.60602492e-02f, -1.29142404e-01f, -2.19021574e-01f,
  3.34585388e-03f, 1.02398910e-01f, -8.87802169e-02f, -6.62535951e-02f, 1.22819282e-03f, 5.35096824e-02f, 2.34075353e-01f, 1.10853255e-01f, 4.72070053e-02f, 6.72170594e-02f,
  -1.51359275e-01f, -5.94033971e-02f, 5.32667339e-02f, -1.28337875e-01f, -2.28087038e-01f, -7.04253884e-03f, 1.12439893e-01f, -1.30784497e-01f, -3.00695412e-02f, -7.42692128e-02f,
  5.45520149e-02f, 1.37780244e-02f, 1.17435969e-01f, -5.67060634e-02f, -1.58674181e-01f, -4.34654132e-02f, 3.35112549e-02f, -1.49343252e-01f, -2.53416538e-01f, -1.06924184e-01f,
  -2.55190045e-01f, 3.19634713e-02f, -5.32260910e-02f, 5.41558266e-02f, 2.86685349e-03f, -9.80308428e-02f, -7.43174255e-02f, -7.12862238e-03f, 5.09810857e-02f, -7.24729225e-02f,
  -1.06966279e-01f, 6.04347698e-02f, 3.05178873e-02f, 7.46128410e-02f, -6.58581257e-02f, 1.77617341e-01f, 1.40818149e-01f, -2.35278159e-02f, -8.34057927e-02f, -9.32988748e-02f,
  -6.37495592e-02f, -8.73569846e-02f, -3.75269614e-02f, -1.33825928e-01f, -1.28382325e-01f, 1.32465735e-01f, -8.19700360e-02f, -5.02013899e-02f, -3.44790846e-01f, 1.45253479e-01f,
  1.83399871e-01f, -1.04693286e-01f, 2.91275922e-02f, -4.73081656e-02f, -1.43935964e-01f, 1.53822407e-01f, -1.30671427e-01f, -5.62708965e-03f, -3.38582933e-01f, -2.31760927e-02f,
  6.18900098e-02f, 2.06889480e-01f, 3.49332355e-02f, 3.47532667e-02f, -1.34492069e-01f, 8.77891704e-02f, 2.92504523e-02f, -2.49267116e-01f, -7.08934814e-02f, -2.07860358e-02f,
  -5.49927913e-02f, -1.20162801e-03f, 2.77884509e-02f, -1.29436448e-01f, -8.25457796e-02f, -1.62668481e-01f, 1.38682917e-01f, -5.08604608e-02f, 1.15867779e-01f, 6.74590543e-02f,
  -8.13599005e-02f, -9.06350017e-02f, 1.00484200e-01f, 1.65737178e-02f, 6.80089220e-02f, 1.11325001e-02f, 7.05235153e-02f, 4.05236818e-02f, 4.91183698e-02f, -1.96101218e-01f,
  5.19679859e-02f, -2.36181021e-02f, -6.25644326e-02f, 1.98166203e-02f, 5.48394322e-02f, -2.32065879e-02f, 1.06476732e-01f, -7.07653491e-03f, 7.40879923e-02f, -8.27711523e-02f,
  -1.54750243e-01f, -4.80081476e-02f, -9.27383676e-02f, 7.28094131e-02f, 1.99916773e-03f, 1.11845307e-01f, 5.68080619e-02f, 1.25901168e-02f, 6.27640635e-02f, 2.84070466e-02f,
  1.88345194e-01f, 6.53449744e-02f, -1.17601395e-01f, -4.92193103e-02f, -1.97592363e-01f, -4.91857305e-02f, 1.42703474e-01f, 1.09923566e-02f, -8.43450651e-02f, -2.78798165e-03f,
  3.06487083e-02f, -8.86999220e-02f, 1.88648999e-01f, 2.10393459e-01f, -2.36710131e-01f, 1.31948451e-02f, 9.66784805e-02f, 3.24793532e-02f, -1.70257419e-01f, 3.14598670e-03f,
  1.78549588e-01f, -8.39819163e-02f, 1.04641177e-01f, -4.52592932e-02f, -1.37499705e-01f, 9.69299823e-02f, -1.05761774e-01f, -1.41027570e-01f, -8.29935223e-02f, -6.01895973e-02f,
  -2.05718111e-02f, 1.05736405e-01f, -7.83746364e-05f, 1.05857141e-01f, -7.60544315e-02f, 5.04051931e-02f, 1.61199402e-02f, -8.25630650e-02f, 1.92316860e-01f, 6.51504546e-02f,
  -1.33706932e-03f, -3.24144214e-02f, -3.69189605e-02f, 1.22597337e-01f, -2.41134409e-02f, 1.45039279e-02f, -4.87540700e-02f, 3.88342701e-02f, -8.96482617e-02f, -1.93493769e-01f,
  -8.72836933e-02f, -1.43468633e-01f, -9.14354250e-02f, -2.37136245e-01f, 6.89826161e-02f, -1.28976498e-02f, 1.98398456e-02f, 3.72838601e-02f, 8.40848163e-02f, -1.69402555e-01f,
  2.24283691e-02f, 2.88698543e-03f, -2.21317291e-01f, -8.78337547e-02f, -1.00053743e-01f, 8.71381983e-02f, 3.35060716e-01f, -1.83745459e-01f, -6.46319762e-02f, -1.21547267e-01f,
  -1.66801006e-01f, 1.91951230e-01f, 1.07544608e-01f, -1.18585065e-01f, -8.00438076e-02f, -8.60890821e-02f, -1.63418740e-01f, -5.03883883e-02f, -1.67890176e-01f, -5.63846566e-02f,
  1.35740489e-02f, -1.31408662e-01f, -2.45032851e-02f, -1.37859419e-01f, 8.48446414e-03f, -2.69423842e-01f, -2.82822438e-02f, 8.44582841e-02f, -4.43692878e-02f, -1.53409531e-02f,
  2.55256295e-02f, 1.86747566e-01f, -1.31418947e-02f, 4.02036980e-02f, 5.28602339e-02f, -7.52439126e-02f, 9.27136838e-02f, -3.13680395e-02f, 8.74508247e-02f, 1.19332813e-01f,
  2.42982544e-02f, -1.12795364e-02f, -6.17431253e-02f, 1.55545427e-02f, 1.20516114e-01f, -4.11177687e-02f, -2.27404069e-02f, 5.81527613e-02f, 4.75058630e-02f, 1.00597374e-01f,
  1.37378633e-01f, 1.34538174e-01f, -4.31409068e-02f, 1.18946351e-01f, -6.57005236e-02f, -7.37931207e-03f, -2.60016657e-02f, 7.18033910e-02f, -6.85270429e-02f, 2.40257024e-04f,
  -1.11838421e-02f, 1.32030040e-01f, 1.55176092e-02f, 1.64829586e-02f, 1.42437935e-01f, -1.32635325e-01f, 1.00904042e-02f, -1.26106128e-01f, 7.40909576e-02f, -8.99806768e-02f,
  -3.46614383e-02f, -1.09490812e-01f, -8.14442113e-02f, 1.17597617e-01f, 3.38181630e-02f, 3.80912842e-03f, -1.61012895e-02f, 1.11421265e-01f, 3.86971124e-02f, -6.43651113e-02f,
  1.16166115e-01f, 2.14538902e-01f, -1.64508983e-01f, 1.18072949e-01f, -1.59735933e-01f, 1.07975841e-01f, 1.14720769e-01f, -3.96990180e-02f, 1.45062864e-01f, 3.19393957e-03f,
  4.99313287e-02f, 3.68400328e-02f, 5.00454567e-02f, 9.09761563e-02f, 3.58969271e-02f, -1.49278879e-01f, -6.97524846e-03f, 9.61866081e-02f, -8.12104791e-02f, 4.81469184e-02f,
  1.29293516e-01f, 1.25805110e-01f, -4.06779861e-03f, 4.51190993e-02f, 9.14226398e-02f, 1.02334619e-01f, 6.10267632e-02f, -5.44795468e-02f, 1.30903527e-01f, -2.54207384e-02f,
  -5.40479384e-02f, 4.81815487e-02f, 1.17814854e-01f, 6.83539435e-02f, 6.65375143e-02f, 1.08663090e-01f, -1.34639032e-02f, -1.70220673e-01f, -1.15024403e-01f, 5.14773689e-02f,
  -6.85209632e-02f, -5.99189997e-02f, 5.45348451e-02f, -4.53354865e-02f, -4.75975685e-02f, -4.23039272e-02f, 6.63451999e-02f, 6.01966307e-03f, 1.24172799e-01f, 9.61487144e-02f,
  2.88144261e-01f, -1.53643871e-02f, -9.02348608e-02f, 2.25221917e-01f, 3.27413529e-01f, -1.86479881e-01f, -4.73557949e-01f, 1.39729877e-03f, -1.33036628e-01f, 3.35552394e-01f,
  5.73635474e-02f, -9.90021974e-02f, -4.75634821e-02f, -9.09849703e-02f, 3.61482769e-01f, -1.00179188e-01f, 2.21470091e-03f, -9.14220884e-02f, -1.09118164e-01f, -3.02614346e-02f,
  -6.98932260e-02f, -8.22963119e-02f, -3.59904170e-02f, -3.54767870e-03f, 1.83062509e-01f, 1.69975515e-02f, -3.20036113e-02f, 6.00914359e-02f, 1.91127211e-02f, 6.25181571e-02f,
  5.77608589e-03f, -1.69393629e-01f, 3.86383682e-02f, 5.34354635e-02f, -9.56474841e-02f, -2.94289123e-02f, -9.01316702e-02f, -3.67495939e-02f, -6.10431237e-03f, 1.49431124e-01f,
  -6.60523996e-02f, 1.43270055e-02f, -2.63753291e-02f, 1.71300411e-01f, 1.87962875e-02f, -1.39227554e-01f, -1.14025414e-01f, 9.64405239e-02f, 3.13093066e-02f, -7.68927857e-03f,
  2.26127319e-02f, -7.08809197e-02f, 5.13857082e-02f, 1.43945962e-01f, 5.09097474e-03f, 4.48124446e-02f, 1.16377631e-02f, -6.97426349e-02f, 2.44865548e-02f, 5.48113771e-02f,
  -2.61071306e-02f, 5.60810938e-02f, 3.59617844e-02f, 9.06363036e-03f, -5.45759536e-02f, -1.58778772e-01f, -5.27773425e-02f, -4.95811664e-02f, -2.01523257e-03f, -8.58747866e-03f,
  1.24500848e-01f, 1.33157015e-01f, 6.20483793e-02f, -1.86906308e-02f, -9.01309848e-02f, -9.21253487e-02f, -1.76961664e-02f, 7.02583836e-03f, 4.75070402e-02f, 1.73606142e-01f,
  -5.20275943e-02f, -1.17977876e-02f, 1.06963500e-01f, -2.03174185e-02f, 1.13968082e-01f, 1.70885697e-01f, 6.57754764e-02f, -4.09460403e-02f, -1.18679695e-01f, 1.42393231e-01f,
  -2.71863732e-02f, -1.12877734e-01f, -2.28126094e-01f, -3.80728394e-02f, -1.80784300e-01f, -6.19767010e-02f, -3.39112915e-02f, -3.79977860e-02f, -2.95969266e-02f, -5.73164225e-02f,
  -7.21189752e-02f, 1.14702918e-02f, 4.91291545e-02f, -1.05062090e-02f, -7.51510933e-02f, -5.81076667e-02f, -1.38783632e-02f, 1.48344234e-01f, -2.77904812e-02f, -1.06561080e-01f,
  -8.59540477e-02f, 3.00056860e-02f, -2.87105097e-03f, 9.21858009e-03f, -2.35874906e-01f, -1.52514726e-01f, 3.49901319e-02f, -3.42239700e-02f, -5.87222800e-02f, -6.75962567e-02f,
  -4.47951145e-02f, 1.12755217e-01f, 6.78159297e-02f, 7.72418827e-02f, 7.89345056e-03f, -2.96672564e-02f, 2.01965608e-02f, -2.41326243e-01f, -1.75891444e-01f, -6.30156398e-02f,
  -1.01411499e-01f, -6.46089241e-02f, 2.44063959e-01f, -3.04398257e-02f, 2.20356435e-01f, 3.29976767e-01f, -6.39501363e-02f, 1.77716732e-01f, -1.50071904e-01f, 4.56056185e-02f,
  -5.68155646e-02f, 1.47451637e-02f, -4.69655059e-02f, -1.09404594e-01f, 6.26357133e-03f, -1.60776868e-01f, -2.61524636e-02f, 6.78220615e-02f, -1.15984147e-02f, -1.45550936e-01f,
  -9.78887305e-02f, -4.58642632e-01f, -3.73123437e-02f, 1.37630999e-01f, 6.03878349e-02f, -3.18797305e-02f, -8.28438401e-02f, 2.62992326e-02f, -2.24354379e-02f, 1.29200518e-01f,
  -8.54279324e-02f, 5.82407881e-03f, 9.80642508e-05f, -2.72109304e-02f, 2.02499256e-02f, -1.20061180e-02f, 8.37352872e-02f, 7.37918317e-02f, -1.35138497e-01f, 3.06729693e-02f,
  2.85712047e-03f, -9.20033976e-02f, -3.76876667e-02f, -7.63301626e-02f, -7.17644929e-04f, 2.31843274e-02f, 3.14351614e-03f, 5.80127584e-03f, -4.61311191e-02f, 9.59728435e-02f,
  7.61191547e-02f, 1.41328350e-01f, -1.66321341e-02f, 1.52066909e-02f, -2.19891425e-02f, -1.33147240e-01f, 2.36376598e-02f, -1.01297960e-01f, -7.60975853e-02f, -2.06673052e-02f,
  -2.06811144e-03f, -7.20408279e-03f, 4.82943356e-02f, 9.82412770e-02f, -3.85705084e-02f, 3.28793712e-02f, 4.24756184e-02f, -9.62624773e-02f, -1.24130927e-01f, 2.32036561e-02f,
  1.22218393e-02f, -1.89237311e-01f, 1.10169902e-01f, 1.35814592e-01f, 9.66036171e-02f, -6.20864742e-02f, -7.37687424e-02f, -3.40824537e-02f, -2.81764939e-02f, -1.73561141e-01f,
  -9.15529877e-02f, -1.31036401e-01f, 2.01020181e-01f, 6.28225878e-02f, 1.16029449e-01f, 2.66562160e-02f, -6.28060997e-02f, -3.97923328e-02f, 1.10241100e-02f, -5.80455065e-02f,
  -1.40134571e-02f, -9.61768031e-02f, 9.74358320e-02f, -5.86174019e-02f, 5.95596321e-02f, 6.56941533e-02f, -2.03515097e-01f, 2.83749420e-02f, 6.79796934e-02f, 9.43285823e-02f,
  -1.60739943e-03f, 3.93092744e-02f, -2.46382907e-01f, 9.91966762e-03f, 4.26303446e-02f, -4.32185233e-02f, 6.32622913e-02f, 2.30469983e-02f, -6.91859275e-02f, 9.58558843e-02f,
  1.75108269e-01f, 2.01817825e-02f, -6.30964860e-02f, 8.36932100e-03f, 6.12364002e-02f, 1.28179379e-02f, -4.12625708e-02f, -6.49912357e-02f, 2.29249545e-03f, 1.29462212e-01f,
  -1.34214628e-02f, -7.83935189e-03f, 1.76818352e-02f, 1.57614313e-02f, 2.21614778e-01f, -2.21386194e-01f, 1.02647446e-01f, -3.63847129e-02f, -1.45981252e-01f, 2.07849368e-01f,
  4.44527715e-02f, -4.31365818e-02f, -5.85843660e-02f, 8.21976438e-02f, 1.47107437e-01f, 4.44426797e-02f, -1.87861323e-01f, -5.44606224e-02f, 1.21850021e-01f, 2.18613800e-02f,
  -3.64741355e-01f, 8.28005373e-03f, -1.62748009e-01f, -2.09219858e-01f, 1.20233081e-01f, 9.12569761e-02f, 9.71918553e-02f, 4.63958550e-03f, -1.88940521e-02f, -3.60539347e-01f,
  -1.21324666e-01f, -7.44672641e-02f, 1.44057125e-01f, 1.01812005e-01f, -4.14581690e-03f, -2.91705225e-03f, 1.47270694e-01f, 1.06472343e-01f, -4.04047668e-02f, 1.63892627e-01f,
  5.18726408e-02f, 3.97261158e-02f, 4.59279306e-02f, 1.13025472e-01f, 3.17871716e-04f, -1.33314416e-01f, -2.43129507e-02f, 3.49858105e-02f, 3.88422869e-02f, 1.48956507e-01f,
  -6.80297986e-02f, -1.98586166e-01f, -2.95335264e-03f, -2.60185730e-02f, 9.05149505e-02f, -3.13273482e-02f, 9.97265205e-02f, -1.31724611e-01f, -4.65695113e-02f, 1.50392205e-01f,
  1.13271505e-01f, 5.33619002e-02f, -6.85772672e-02f, 1.08645968e-01f, 3.75803411e-02f, 7.06973001e-02f, 7.95625076e-02f, 1.05877697e-01f, -6.24454953e-02f, -9.27250087e-02f,
  -4.33123112e-02f, 5.60850650e-02f, -1.25598550e-01f, -1.33296758e-01f, 2.64276359e-02f, 6.85840324e-02f, 1.41344562e-01f, 1.64427891e-01f, 1.52397994e-02f, 2.02791896e-04f,
  3.59931588e-02f, 1.86627626e-01f, -4.42731340e-04f, 7.04854876e-02f, 4.46794815e-02f, -4.67683077e-02f, 2.36096248e-01f, 1.10907793e-01f, -1.65816367e-01f, -1.23278573e-01f,
  1.59364811e-03f, -6.47208020e-02f, 1.28169253e-01f, 1.81876078e-01f, -1.44631714e-01f, 1.32385597e-01f, 2.54145235e-01f, -1.38151139e-01f, -8.48817676e-02f, -9.84078273e-02f,
  3.58744413e-02f, -1.43430177e-02f, 5.67079969e-02f, 1.28164947e-01f, -2.54247814e-01f, -3.97929773e-02f, -1.18235938e-01f, -1.37134761e-01f, -7.30856434e-02f, 2.51906663e-01f,
  -1.68942496e-01f, 5.05361930e-02f, 2.77385246e-02f, 1.42139509e-01f, 1.67961568e-01f, 1.55822560e-01f, 8.47924093e-04f, -5.86778261e-02f, 3.20517980e-02f, 8.45850818e-03f,
  -1.95305765e-01f, -1.85251776e-02f, 2.98961252e-01f, 4.16365229e-02f, -9.50274840e-02f, -5.30398227e-02f, -1.22936862e-02f, 7.66171366e-02f, -1.83128640e-01f, -3.65814231e-02f,
  -1.14527389e-01f, -2.50946637e-02f, -1.69553116e-01f, -2.60975689e-01f, 3.19162197e-02f, 1.30745441e-01f, -7.79800415e-02f, -9.80309471e-02f, 1.25939459e-01f, 2.63695806e-01f,
  9.76022109e-02f, 2.04111740e-01f, 8.02258924e-02f, 4.82327044e-02f, -2.02447936e-01f, -2.32149791e-02f, -1.20237377e-02f, 3.88282239e-02f, -1.48715064e-01f, -3.29997428e-02f,
  1.05894893e-01f, 1.41300494e-02f, -1.60968438e-01f, 7.04837665e-02f, 6.98925927e-02f, 8.05325955e-02f, 1.16066761e-01f, -3.06228399e-01f, -1.82638951e-02f, 9.31139588e-02f,
  9.48019326e-03f, 6.67821914e-02f, 7.70026119e-03f, 3.89908589e-02f, -7.12760314e-02f, -5.92453517e-02f, 9.08896979e-03f, -1.01301290e-01f, -2.91222055e-02f, -2.18469948e-02f,
  7.22419992e-02f, -1.58022065e-02f, -6.43834099e-02f, -1.11496091e-01f, 1.54230017e-02f, -2.29907408e-02f, 8.28665122e-02f, 9.26302746e-03f, -8.47332925e-02f, -7.63090849e-02f,
  -7.75269885e-03f, -6.94655702e-02f, 9.92771983e-02f, 2.90932395e-02f, 2.42933109e-02f, -6.49441080e-03f, 8.32932889e-02f, -1.44178241e-01f, -2.95721330e-02f, 3.24278176e-02f,
  -9.40997377e-02f, -1.90767169e-04f, -1.22215733e-01f, 1.55013520e-02f, 3.99710089e-02f, -1.15512460e-01f, -1.07069746e-01f, 2.59856526e-02f, 6.66524321e-02f, 1.52255064e-02f,
  -9.38656777e-02f, 1.10920131e-01f, 1.30724192e-01f, 2.48841885e-02f, -1.21149477e-02f, -1.00801654e-01f, 6.65490851e-02f, -4.07545120e-02f, 9.29230917e-03f, -8.47063437e-02f,
  1.89545024e-02f, -1.40923755e-02f, 5.78928627e-02f, 6.02263957e-02f, 2.62146275e-02f, 8.38512108e-02f, -1.87418222e-01f, 1.07750773e-01f, 2.17982620e-01f, 6.06426671e-02f,
  -1.03608623e-01f, 2.20292062e-01f, 3.27063166e-02f, -1.87572405e-01f, 1.13208182e-02f, 8.33604708e-02f, -2.86150742e-02f, -1.03457764e-01f, 1.32209450e-01f, -1.35416701e-01f,
  1.63008496e-01f, 6.07025512e-02f, 3.86430398e-02f, 9.23811346e-02f, 6.59809485e-02f, -1.83480475e-02f, 1.85706079e-01f, 5.83469793e-02f, -2.21550867e-01f, 1.40576437e-01f,
  9.42885056e-02f, 1.29935145e-01f, -2.51615723e-03f, 7.35573173e-02f, 1.48486108e-01f, -1.53008113e-02f, -7.04892278e-02f, 9.65292826e-02f, -2.86795288e-01f, -3.22023071e-02f,
  3.02835405e-01f, 8.96995664e-02f, -4.28214222e-02f, -1.23048447e-01f, -1.40259966e-01f, -2.78270125e-01f, -9.00362134e-02f, 3.32649834e-02f, 1.89987227e-01f, 4.56669321e-03f,
  7.99777210e-02f, 8.18089768e-02f, 1.41763583e-01f, 1.30854279e-01f, -2.17459947e-01f, 1.80129725e-02f, 3.20328414e-01f, -2.69387841e-01f, -2.56528974e-01f, 2.09737882e-01f,
  -2.75085345e-02f, 9.26498771e-02f, 1.37665555e-01f, -4.74738255e-02f, 1.44379924e-03f, -1.77551091e-01f, 4.90920469e-02f, 8.24884102e-02f, -1.10772170e-01f, 1.30154520e-01f,
  -1.27903998e-01f, 2.98883915e-01f, 2.03431845e-02f, 5.16995490e-02f, 3.48073542e-02f, -1.89041346e-02f, 4.75140773e-02f, -6.31198287e-03f, 1.00123368e-01f, -9.62892994e-02f,
  -3.61270234e-02f, 1.10063545e-01f, -3.14308889e-02f, 1.01395823e-01f, 5.53177632e-02f, 4.42420430e-02f, -4.26284783e-02f, -4.05701883e-02f, 1.45716414e-01f, 1.32625466e-02f,
  -9.69307090e-04f, 1.09730750e-01f, 5.33973351e-02f, -8.81081540e-03f, -2.66522914e-03f, -4.15344760e-02f, -2.72679757e-02f, 6.49389112e-03f, 4.21973281e-02f, 2.37311926e-02f,
  5.81826009e-02f, -1.57055378e-01f, -3.64479888e-03f, 1.20645769e-01f, -3.59362438e-02f, 1.84146576e-02f, 1.29411155e-02f, 5.82328066e-02f, 2.55656894e-02f, 6.93815053e-02f,
  -4.62624505e-02f, 9.69120190e-02f, -3.88109460e-02f, 3.32205854e-02f, -4.23314981e-02f, -8.56761709e-02f, -1.16282165e-01f, 4.97032842e-03f, -6.57438636e-02f, -1.22030944e-01f,
  -1.30731752e-02f, -7.07424581e-02f, -2.39856113e-02f, -1.03120320e-01f, -2.65524015e-02f, -1.08235970e-01f, -9.89346113e-03f, -1.07065933e-02f, -3.70653858e-03f, 6.03126064e-02f,
  1.82344005e-01f, -2.74592955e-02f, -3.15195583e-02f, 7.80012738e-03f, -2.26225659e-01f, 1.36556223e-01f, 2.38270536e-01f, -1.82146095e-02f, -4.39752415e-02f, 5.16225994e-02f,
  -1.54096499e-01f, -1.98675860e-02f, 2.86089946e-02f, 4.11217958e-02f, -1.34274140e-01f, -5.53796105e-02f, 1.07967168e-01f, -1.13777488e-01f, 1.01174079e-01f, 2.84982976e-02f,
  2.64914222e-02f, 1.09983630e-01f, 6.39232993e-02f, -2.06995141e-02f, 7.64243156e-02f, 9.45875645e-02f, -1.97611451e-01f, -9.45008546e-02f, 4.66064364e-02f, 1.55663237e-01f,
  1.29296601e-01f, 1.62913054e-01f, 1.88098729e-01f, 1.05113015e-01f, 2.46716157e-01f, 8.02449659e-02f, 4.01506349e-02f, -1.34127602e-01f, 1.20638296e-01f, -1.00323759e-01f,
  8.37320983e-02f, -1.85558423e-01f, -3.37858498e-02f, -7.40861371e-02f, -2.14864011e-03f, 8.37777629e-02f, 2.63021328e-02f, 3.32813594e-04f, -7.91371837e-02f, 2.70254351e-02f,
  2.13805705e-01f, 1.08100539e-02f, -7.90835917e-02f, -7.90192187e-02f, 1.15492076e-01f, -4.49946560e-02f, -4.56632107e-01f, 1.97242185e-01f, -4.66049276e-03f, 1.02580398e-01f,
  -1.12129517e-01f, 1.02351431e-03f, -1.38498455e-01f, 1.51401358e-02f, 4.14671510e-01f, -1.33280829e-01f, 1.04791902e-01f, -2.19993383e-01f, -1.42642900e-01f, 1.75575420e-01f,
  -6.02637492e-02f, 2.86218361e-03f, 1.12970456e-01f, -4.13262583e-02f, 5.67421243e-02f, -1.96140129e-02f, -8.72175917e-02f, 1.20946214e-01f, -2.13217270e-02f, -2.51013576e-03f,
  -1.55745581e-01f, -4.38612252e-02f, 3.46678644e-02f, -3.50894593e-02f, 5.61588481e-02f, 5.93338124e-02f, 1.06009245e-01f, 7.19136139e-03f, -7.18662590e-02f, -2.18755882e-02f,
  -7.02378079e-02f, 4.19512065e-03f, -1.20008774e-02f, 5.08495755e-02f, 6.66260486e-03f, -3.38893682e-01f, 2.56740190e-02f, -6.35766331e-03f, -2.38262918e-02f, 4.64669801e-02f,
  -1.01092525e-01f, 1.79267481e-01f, 1.11246213e-01f, 5.46636395e-02f, 1.04256295e-01f, 1.86525099e-02f, 2.80943383e-02f, -6.93844929e-02f, -1.14833891e-01f, 9.12075415e-02f,
  2.16010987e-04f, 1.31867096e-01f, -4.86931577e-02f, -1.72585174e-01f, 4.08526100e-02f, 2.64546592e-02f, -3.76137830e-02f, -8.47471580e-02f, -8.17428306e-02f, -2.54114661e-02f,
  -5.94853722e-02f, 9.45501849e-02f, -1.67150714e-03f, 1.78996455e-02f, -1.68102812e-02f, -8.72999504e-02f, -3.32759544e-02f, 9.56940949e-02f, 4.04853486e-02f, 4.18704264e-02f,
  2.33868793e-01f, 2.47123484e-02f, -9.20882672e-02f, -3.54856960e-02f, -5.53114861e-02f, -5.00784144e-02f, 1.46753252e-01f, -7.08844215e-02f, 6.24244325e-02f, 8.09412263e-03f,
  -5.68228215e-02f, -3.35640460e-02f, 4.83454689e-02f, -1.59927174e-01f, -9.19547155e-02f, 1.61087513e-01f, 1.03527375e-01f, -1.90500114e-02f, -2.48132065e-01f, -4.93808836e-02f,
  7.48418048e-02f, 3.70958149e-02f, -1.03018306e-01f, 1.46508098e-01f, -1.39828986e-02f, 1.00430280e-01f, -1.55924797e-01f, -8.69590193e-02f, 1.78696007e-01f, -7.38274232e-02f,
  2.68143835e-03f, 9.79118943e-02f, 1.22970805e-01f, 2.82215744e-01f, -5.26319668e-02f, 1.44238556e-02f, -4.95479326e-04f, -1.08175337e-01f, -3.94977555e-02f, 1.98671162e-01f,
  -9.18064043e-02f, 1.07499868e-01f, -4.88074981e-02f, 1.37018830e-01f, 2.53959596e-02f, -5.25035523e-03f, -4.45853453e-03f, 4.81481776e-02f, 2.16523468e-01f, 1.23275943e-01f,
  5.36048673e-02f, 1.32227749e-01f, -1.52457297e-01f, -6.75894395e-02f, -1.81107987e-02f, 4.69413668e-01f, 7.10804984e-02f, -1.54762000e-01f, -3.68274212e-01f, 8.26260075e-02f,
  -1.04910903e-01f, -1.05757520e-01f, -9.27344784e-02f, -1.15524486e-01f, 2.16914434e-02f, 6.04861863e-02f, -1.20447189e-01f, 1.35152325e-01f, -9.79871973e-02f, -9.83837619e-02f,
  2.56554801e-02f, -4.74950299e-02f, -4.92644757e-02f, 8.50406215e-02f, -4.47673025e-03f, 6.55170009e-02f, -4.54700878e-03f, -1.24119438e-01f, -1.35874320e-02f, 7.71785900e-02f,
  5.68013601e-02f, -1.93564240e-02f, 6.99954256e-02f, 2.41398625e-02f, -7.08299270e-03f, 3.72012369e-02f, 2.49257591e-02f, 1.76982507e-02f, 4.35216464e-02f, 2.73368154e-02f,
  -2.72706267e-04f, 9.73769277e-02f, 6.59624189e-02f, 1.77358061e-01f, 1.03397436e-01f, -9.71997306e-02f, -4.15779874e-02f, -4.79481593e-02f, 2.12233849e-02f, -1.39581516e-01f,
  5.89318387e-02f, 9.24564525e-03f, 4.43407893e-02f, -1.19939391e-02f, -8.55453536e-02f, 4.07314971e-02f, -4.56239395e-02f, -5.62005341e-02f, -9.66821536e-02f, 3.17125656e-02f,
  -6.77722692e-02f, 2.44280901e-02f, 8.25572908e-02f, 1.56327561e-01f, -1.69206232e-01f, -4.67662252e-02f, 7.12359026e-02f, -8.09739009e-02f, 3.31565961e-02f, -1.49232551e-01f,
  -1.17912581e-02f, -9.80234593e-02f, 2.14387774e-02f, -1.09697215e-01f, -6.07409663e-02f, -7.30415210e-02f, -1.00092240e-01f, -1.87599599e-01f, 1.68366745e-01f, -3.28096189e-03f,
  -1.49451867e-01f, -1.57371223e-01f, 2.19010077e-02f, 3.37708145e-02f, -1.66612849e-01f, 4.71308157e-02f, -2.49936543e-02f, -1.09026805e-02f, 4.69459221e-02f, -1.08690843e-01f,
  -5.05131595e-02f, -1.27285048e-02f, 1.66230157e-01f, 6.11049347e-02f, 1.00978471e-01f, -7.70751163e-02f, -1.26563624e-01f, -9.80575802e-04f, 1.06057473e-01f, -9.62659270e-02f,
  -1.85341865e-01f, -1.81335099e-02f, 2.34085768e-01f, -5.71758710e-02f, -2.10251641e-02f, -1.68452397e-01f, 9.11735520e-02f, -3.21203992e-02f, -9.35396645e-03f, -3.94834839e-02f,
  -8.31069127e-02f, -1.39497221e-01f, -6.78510740e-02f, 2.55456448e-01f, -3.87411341e-02f, 1.37343541e-01f, 4.94548716e-02f, 6.33967519e-02f, -5.37453704e-02f, -3.08993291e-02f,
  -3.46280932e-02f, 8.58146977e-03f, -5.86246960e-02f, -5.66401184e-02f, -3.46372090e-03f, 2.43750382e-02f, 1.64282829e-01f, 1.19658642e-01f, -5.77506833e-02f, -3.15815769e-02f,
  -2.49715626e-01f, -1.93810403e-01f, -3.54414620e-02f, -2.47191414e-01f, 1.44566074e-01f, -2.03280792e-01f, 5.53738559e-03f, 1.11512445e-01f, 4.11733836e-02f, -3.33815962e-02f,
  -1.51434585e-01f, 1.25360787e-01f, 4.15106863e-02f, 9.27840248e-02f, -8.05962682e-02f, 2.22197399e-01f, -3.62722687e-02f, 1.71020120e-01f, 1.66746780e-01f, 1.05851553e-01f,
  -1.71816777e-02f, -5.65771013e-02f, -4.20995522e-03f, 5.12254164e-02f, -1.06320471e-01f, 9.44496393e-02f, -1.83678195e-01f, -2.97669768e-02f, 1.05211129e-02f, 1.07639804e-01f,
  -1.24209270e-01f, 3.51952091e-02f, -9.46869422e-03f, 1.10022567e-01f, 1.00934431e-01f, -9.28953197e-03f, -2.38255728e-02f, 2.92740129e-02f, 1.54390752e-01f, -1.34361014e-01f,
  6.99413568e-02f, 1.20308325e-01f, 4.21164222e-02f, 1.18511459e-02f, 5.01980446e-02f, -1.77146167e-01f, 5.67341223e-02f, 1.26256356e-02f, -1.92530509e-02f, -1.07023433e-01f,
  4.84659187e-02f, -8.54168162e-02f, 8.82098228e-02f, -2.52527427e-02f, -1.22805119e-01f, 5.29517494e-02f, -1.21055782e-01f, -3.78115214e-02f, 4.61141989e-02f, 1.66295506e-02f,
  1.35687680e-03f, -3.14704999e-02f, 3.46882828e-02f, 1.38052911e-01f, 7.95862079e-02f, -3.43383779e-03f, 8.07410851e-02f, 1.27305776e-01f, 9.20015667e-03f, -8.81760269e-02f,
  -1.54754609e-01f, 1.43898442e-01f, -4.13604416e-02f, 7.04909489e-02f, 4.64522839e-03f, -1.57404505e-02f, -1.92308128e-01f, 5.11840582e-02f, -1.79890748e-02f, -5.02852984e-02f,
  -1.66003019e-01f, 1.11666009e-01f, 7.55146518e-02f, -1.78591952e-01f, -1.14932142e-01f, -3.80315334e-02f, -1.32623717e-01f, 1.87519833e-01f, -1.94411606e-01f, -3.45400497e-02f,
  -1.49712682e-01f, -1.09572627e-01f, -6.61006644e-02f, 5.28238602e-02f, 9.99899730e-02f, 2.40751819e-04f, -9.29317474e-02f, -8.80869571e-03f, -1.15890540e-01f, -6.30657747e-02f,
  1.03569133e-02f, -3.68013121e-02f, -1.26752434e-02f, -1.61727235e-01f, -1.16010815e-01f, -9.70954746e-02f, 5.28558064e-03f, 3.66266593e-02f, 4.42495160e-02f, -2.13918891e-02f,
  1.65160596e-01f, -1.90314949e-01f, -1.06493861e-03f, -5.07851541e-02f, -7.24799884e-03f, -1.66833058e-01f, -1.22912459e-01f, 2.59383768e-02f, 7.57052144e-03f, -4.98114936e-02f,
  2.61562746e-02f, -9.73481089e-02f, -3.94792370e-02f, -2.76851542e-02f, -2.75185317e-01f, -4.89764102e-03f, -1.79147497e-01f, -1.80128086e-02f, 1.63834784e-02f, -3.27275768e-02f,
  -1.75190978e-02f, -7.97130540e-02f, -5.90142012e-02f, 1.51921451e-01f, 6.88636228e-02f, -1.88548818e-01f, 5.56536019e-02f, 7.64150247e-02f, 4.46372107e-03f, 5.19679300e-02f,
  -4.92248014e-02f, -4.91461605e-02f, 3.79005857e-02f, 1.60816774e-01f, 1.08711552e-02f, -1.13379560e-01f, -1.33352011e-01f, -3.03862840e-01f, -1.14105560e-01f, 2.02716365e-02f,
  4.26825657e-02f, -5.02915978e-02f, -2.06389949e-02f, -3.65157723e-02f, -1.77720249e-01f, 9.27676633e-02f, -3.98800932e-02f, -6.24768585e-02f, -6.10905364e-02f, -4.62209173e-02f,
  -9.35788080e-02f, 4.61773835e-02f, -9.75023769e-03f, 6.58143535e-02f, 7.07741231e-02f, -4.56419513e-02f, 8.37719589e-02f, -5.57995737e-02f, 6.67460309e-03f, -1.10351697e-01f,
  -6.37804270e-02f, -1.17796086e-01f, -1.65061688e-03f, 2.47989986e-02f, 5.65334409e-03f, -2.85091661e-02f, 8.46731588e-02f, 2.89770123e-02f, -1.66868404e-01f, -2.99710780e-02f,
  2.37068627e-02f, -4.85040806e-02f, 5.33389524e-02f, -2.74669938e-02f, -4.42625247e-02f, -1.34271011e-02f, 5.38802557e-02f, 1.60234664e-02f, 7.65353963e-02f, -2.39113695e-03f,
  -1.88979983e-01f, 4.81049977e-02f, -1.33892402e-01f, 5.84229976e-02f, -5.38586341e-02f, 5.79045266e-02f, 1.00464016e-01f, -1.80959791e-01f, -1.02103557e-02f, -3.43727991e-02f,
  -8.24963823e-02f, 1.62155144e-02f, -1.03418762e-02f, -6.66555315e-02f, 1.28844917e-01f, 1.32588483e-02f, 2.36412629e-01f, 1.09757915e-01f, -6.74130246e-02f, -1.44185293e-02f,
  5.47263324e-02f, 3.99278328e-02f, 4.32021990e-02f, 1.55211225e-01f, 5.68825081e-02f, -1.12579733e-01f, -7.65743032e-02f, 1.15917601e-01f, -9.21690241e-02f, 1.84574369e-02f,
  8.69199410e-02f, -1.65618524e-01f, -1.45801231e-01f, 7.96683803e-02f, 7.10109249e-02f, -1.48879111e-01f, -3.11246037e-01f, -7.26113468e-02f, 1.10759273e-01f, 6.95531741e-02f,
  1.20912846e-02f, 9.96911749e-02f, 8.91448371e-03f, -4.28981632e-02f, -1.48512766e-01f, -1.26799256e-01f, 2.64801979e-02f, -2.41359845e-01f, -2.35353515e-01f, 4.37977426e-02f,
  1.49866104e-01f, 6.92928731e-02f, -7.82772452e-02f, -4.31850515e-02f, -3.59182879e-02f, -3.18835862e-02f, -8.07581563e-03f, 4.65550041e-03f, -1.47315994e-01f, 7.50655085e-02f,
  4.99224802e-03f, -6.86702458e-03f, -2.13322237e-01f, -5.95395900e-02f, 4.51073535e-02f, -1.17330924e-01f, 1.90980464e-01f, 8.65656957e-02f, 2.19411239e-01f, -2.34041363e-01f,
  3.04032173e-02f, -6.41811192e-02f, 2.52926141e-01f, 1.07849568e-01f, -6.99567571e-02f, 3.54530886e-02f, -4.40983444e-01f, -8.13668668e-02f, -1.54535966e-02f, 1.38470873e-01f,
  -5.62904179e-02f, 2.42730649e-03f, -1.47351637e-01f, -1.74347147e-01f, -4.93953526e-02f, -1.58456668e-01f, -3.82064506e-02f, -5.98563440e-02f, 3.24699432e-02f, 2.53074449e-02f,
  -2.85997149e-03f, 1.72776148e-01f, -5.30466437e-02f, 1.52054116e-01f, 4.07685386e-03f, -6.95001408e-02f, -3.30692879e-03f, -3.79480906e-02f, 6.77872002e-02f, 5.45768477e-02f,
  -4.23711650e-02f, 1.53633486e-02f, -9.57466140e-02f, 1.42125458e-01f, 5.65083697e-02f, 1.47560658e-02f, 1.48343237e-03f, 2.14642342e-02f, -9.66482386e-02f, 2.24897964e-03f,
  1.82659496e-02f, 5.99096455e-02f, 1.92333926e-02f, -8.52713548e-03f, 1.47126606e-02f, -7.61231547e-03f, 3.25116292e-02f, 1.25533670e-01f, 1.11685500e-01f, -1.64827570e-01f,
  1.36655658e-01f, 4.05691601e-02f, 1.17794842e-01f, 2.27217879e-02f, -9.56871882e-02f, 3.00181843e-02f, -8.97518173e-02f, 8.77815038e-02f, -1.54993236e-01f, 4.96007465e-02f,
  1.65118173e-01f, -9.94281396e-02f, 7.86297396e-02f, -9.82985739e-03f, 6.02016635e-02f, -4.53626290e-02f, 1.21860942e-02f, -1.10531136e-01f, 8.43289569e-02f, 9.06713828e-02f,
  -1.13174610e-01f, -9.45693329e-02f, 1.80057943e-01f, -3.46863978e-02f, -4.52746861e-02f, 1.13245174e-01f, 1.59190953e-01f, 4.19191942e-02f, -1.62860632e-01f, 1.42775670e-01f,
  8.76725540e-02f, 5.35839461e-02f, 6.19472601e-02f, 8.97283927e-02f, 1.51731223e-01f, 1.03050940e-01f, 2.25410257e-02f, -1.99420396e-02f, 1.23662330e-01f, -2.57741734e-02f,
  -7.92691484e-03f, 3.83231901e-02f, -1.66737288e-01f, 2.24679902e-01f, 2.08271652e-01f, -3.01585272e-02f, -1.49648026e-01f, -1.15703039e-01f, -6.52724644e-03f, 1.73167810e-01f,
  1.37901396e-01f, 7.90739432e-02f, 4.15835530e-02f, -1.93975255e-01f, -3.29158753e-02f, 1.10187598e-01f, -4.54024151e-02f, 7.90388063e-02f, 1.14535086e-01f, 8.38145614e-02f,
  9.29004103e-02f, -1.47531167e-01f, -5.74391820e-02f, -1.34201661e-01f, 1.95470035e-01f, 8.11890215e-02f, -9.34904665e-02f, 1.33194521e-01f, -2.52042133e-02f, 3.58012342e-03f,
  1.15618765e-01f, -3.74105223e-03f, -5.28441072e-02f, -6.94647133e-02f, -3.40861753e-02f, -6.95160031e-02f, -2.95476109e-01f, 2.05708832e-01f, -5.44557199e-02f, -5.30457450e-03f,
  1.63299680e-01f, 1.58339933e-01f, 6.11351356e-02f, 5.08380979e-02f, 3.06361794e-01f, -1.27946481e-01f, 2.65902337e-02f, -1.34063110e-01f, -1.53938225e-02f, 2.61652321e-01f,
  1.37614086e-02f, -1.77975133e-01f, -1.22141004e-01f, 2.11878434e-01f, -4.43733595e-02f, -4.97386828e-02f, -6.19026944e-02f, -7.06642941e-02f, 3.67020294e-02f, 2.98714526e-02f,
  -5.91608547e-02f, -5.14283553e-02f, 2.37281434e-02f, -1.39075711e-01f, 5.71951680e-02f, 7.90594593e-02f, -1.18271681e-02f, 6.67086095e-02f, 7.04992190e-02f, -1.97658017e-02f,
  -6.33422984e-03f, -1.40409917e-01f, -2.37099249e-02f, -1.88662633e-02f, 1.66816100e-01f, 4.27894443e-02f, 5.77844717e-02f, -1.04036015e-02f, 3.02713122e-02f, -1.37213677e-01f,
  -9.65537578e-02f, -4.98307087e-02f, -8.05481374e-02f, -1.79225862e-01f, -6.97239041e-02f, 2.85978965e-03f, -2.13656314e-02f, 7.77111873e-02f, 5.28579541e-02f, 3.01817209e-02f,
  -8.24868158e-02f, -4.87385131e-02f, -2.51053181e-02f, -6.79204357e-04f, -7.44729023e-03f, 9.82049406e-02f, -2.77928286e-03f, 2.30632983e-02f, 1.40975282e-01f, -9.84495059e-02f,
  -9.91393253e-02f, -1.28259763e-01f, 9.00468007e-02f, 8.69798139e-02f, -6.89214915e-02f, -1.32439062e-01f, -2.29892191e-02f, 3.20798382e-02f, -1.48489609e-01f, -2.81059861e-01f,
  -4.97001642e-03f, -8.07276666e-02f, -1.20099738e-01f, -1.26478579e-02f, -1.49145097e-01f, 1.18711758e-02f, 1.53685026e-02f, 1.31047696e-01f, -1.03479326e-01f, -1.91085916e-02f,
  -4.85654026e-02f, 1.09955437e-01f, 1.56400219e-01f, 1.61338851e-01f, -1.35592148e-01f, -2.93202028e-02f, -5.26694171e-02f, -4.49801832e-02f, 1.72477543e-01f, -2.17003167e-01f,
  -1.67738483e-03f, 4.07455079e-02f, -5.22064231e-02f, -1.09780237e-01f, 1.45692632e-01f, 6.54952303e-02f, -7.57562220e-02f, -1.03780396e-01f, -5.67760915e-02f, -1.47472456e-01f,
  -9.88071412e-02f, -3.39671187e-02f, -1.71675920e-01f, 1.66602116e-02f, -7.97421485e-03f, 4.41769995e-02f, -1.72220111e-01f, 9.66012105e-02f, -5.37381843e-02f, 1.02193445e-01f,
  5.88245355e-02f, -1.49062365e-01f, 2.27462992e-01f, -5.16178496e-02f, 5.05783260e-02f, -1.64783429e-02f, 1.27867177e-01f, 8.57238248e-02f, 1.46591559e-01f, -8.96227956e-02f,
  8.61199796e-02f, 1.79012552e-01f, -1.60967469e-01f, 1.06554300e-01f, 5.39692380e-02f, -3.83238971e-01f, 1.32852331e-01f, -2.80814677e-01f, 2.64986277e-01f, 6.47297362e-03f,
  1.19745769e-01f, 6.46197721e-02f, -3.30966294e-01f, 5.22173345e-02f, -4.14124168e-02f, -1.09814078e-01f, 1.02368698e-01f, -1.35684311e-01f, 1.11108579e-01f, 1.60999313e-01f,
  1.63734540e-01f, 1.32271573e-01f, -9.68323946e-02f, -1.63276359e-01f, 3.13859992e-02f, -1.00800477e-01f, 6.06867447e-02f, 6.14247397e-02f, 9.49859917e-02f, 6.21869974e-02f,
  -1.10095665e-01f, 1.94082260e-01f, -2.14494783e-02f, -3.52401622e-02f, 2.82169618e-02f, 1.05083592e-01f, 1.03258245e-01f, -1.20823465e-01f, -9.45740119e-02f, 2.87932577e-03f,
  1.84352994e-01f, 1.78504456e-02f, 3.33588943e-02f, 9.91390944e-02f, 8.34966823e-02f, 4.59277406e-02f, 6.25074259e-04f, 6.58821166e-02f, 1.10180944e-01f, -1.34399990e-02f,
  6.48782635e-03f, -1.20464787e-01f, 1.49707451e-01f, -1.30852242e-03f, 1.59089211e-02f, 6.10420629e-02f, -1.52714580e-01f, 4.10729572e-02f, -9.11553055e-02f, 5.31463735e-02f,
  1.19244777e-01f, 2.68119834e-02f, 1.26391724e-02f, -6.68764785e-02f, 8.78200158e-02f, -8.71947110e-02f, -2.49950797e-03f, -1.31370518e-02f, -3.09792515e-02f, 9.71546471e-02f,
  3.83389592e-02f, 7.25317048e-03f, -3.72818974e-03f, -2.33668108e-02f, 4.94535081e-02f, -4.04524840e-02f, 1.56243145e-01f, 2.97244675e-02f, -1.41679406e-01f, -1.46747261e-01f,
  -1.01010017e-01f, -1.08671775e-02f, -1.29623428e-01f, 2.85925868e-04f, 1.96717624e-02f, 2.79185064e-02f, 5.22178644e-03f, -9.41587985e-02f, -1.15672566e-01f, 4.14526314e-02f,
  -1.98208839e-02f, -6.68162247e-03f, 8.66118371e-02f, -9.07243192e-02f, -2.67705679e-01f, 9.31160301e-02f, 9.96759683e-02f, 6.43557459e-02f, 1.88741796e-02f, 4.79278229e-02f,
  2.31436212e-02f, 1.42281860e-01f, 3.68919745e-02f, -1.21604149e-04f, -6.85488284e-02f, -1.02580488e-01f, -6.13018461e-02f, 1.92266311e-02f, -1.35803793e-03f, -4.17853445e-02f,
  4.71570380e-02f, -7.42750987e-02f, -3.62044759e-02f, -4.62326668e-02f, -5.46401478e-02f, -7.53563643e-02f, -8.30853358e-03f, -2.17152894e-01f, 1.66980520e-01f, -4.11004126e-02f,
  -1.22226160e-02f, -7.92870447e-02f, 4.34559099e-02f, 2.19221022e-02f, -1.32444918e-01f, 2.27847442e-01f, 1.77076589e-02f, -2.84516830e-02f, -1.19778037e-01f, 3.05432193e-02f,
  2.69455612e-01f, -6.17971178e-03f, -4.77889460e-03f, -2.99170971e-01f, -5.59149571e-02f, 9.37862992e-02f, 2.15248406e-01f, -2.95612574e-01f, 1.77068204e-01f, 4.83880332e-03f,
  -8.55222717e-03f, 3.20040621e-02f, -2.25784436e-01f, -1.20889366e-01f, 7.08345994e-02f, 6.63950145e-02f, 3.58361602e-02f, 1.94539815e-01f, 4.32169922e-02f, -1.92536339e-01f,
  -6.29315004e-02f, 3.16520296e-02f, -1.98120940e-02f, -9.14595872e-02f, 2.98753083e-02f, -2.17071623e-02f, -6.49156198e-02f, -2.12737620e-02f, 9.63409320e-02f, 8.44056904e-03f,
  -5.66095337e-02f, -7.98487291e-02f, -5.43466620e-02f, 2.86433306e-02f, 5.64624742e-02f, 6.72591776e-02f, -8.57865587e-02f, 1.24013694e-02f, 4.55591939e-02f, -2.57689338e-02f,
  3.21346074e-02f, -2.28138398e-02f, -9.43569615e-02f, 2.10775435e-02f, -7.49046728e-02f, -1.83993112e-02f, -6.54508993e-02f, 9.60975066e-02f, -6.03795536e-02f, 1.54731572e-01f,
  -7.00274780e-02f, 9.61702839e-02f, 1.58434827e-02f, 5.76328374e-02f, -6.84099570e-02f, -1.05723813e-01f, -9.68121365e-03f, -1.13328290e-03f, 1.97567746e-01f, 6.00989349e-02f,
  1.27087027e-01f, -6.01873733e-02f, 4.30602282e-02f, 1.34854589e-03f, -3.16152088e-02f, -6.53153807e-02f, 1.54266372e-01f, 1.30508067e-02f, 7.21070841e-02f, 4.02321370e-04f,
  1.85246587e-01f, 1.74213246e-01f, 1.04189448e-01f, 4.30451147e-02f, 1.53293803e-01f, 1.83113143e-01f, -4.37328331e-02f, -1.10356823e-01f, 7.46018365e-02f, 1.34637550e-01f,
  5.73158972e-02f, 1.13557605e-02f, -6.94719627e-02f, 6.01921976e-02f, -6.19362108e-02f, 1.18265703e-01f, -3.57672852e-03f, -4.41126525e-03f, -1.39247030e-01f, -8.50722864e-02f,
  4.06296030e-02f, 1.17186815e-01f, -2.83075273e-01f, -6.54411763e-02f, -1.41897678e-01f, -5.09265177e-02f, 3.25687719e-03f, 6.52465597e-02f, -2.60801781e-02f, -5.17825335e-02f,
  -1.25352532e-01f, 1.10073620e-02f, 8.56971517e-02f, -1.80712730e-01f, -1.53160721e-01f, 1.08966798e-01f, 1.40999258e-01f, 1.23806477e-01f, 1.86280087e-02f, 2.46359318e-01f,
  3.85996625e-02f, -1.05147483e-02f, -3.70501056e-02f, -1.12186946e-01f, -5.39183896e-03f, 5.30430712e-02f, -5.38621694e-02f, 1.56524792e-01f, 1.39568746e-02f, -9.98110510e-03f,
  2.99664158e-02f, -7.01365024e-02f, 1.94792598e-02f, -6.81717768e-02f, 1.67128786e-01f, 1.46117145e-02f, -1.01913296e-01f, 1.72146633e-01f, -2.17596292e-02f, -6.84937239e-02f,
  -1.70675099e-01f, 2.19344750e-01f, -1.95989117e-01f, 1.86802387e-01f, -3.47877532e-01f, 1.04736201e-01f, -1.22176863e-01f, -4.01910730e-02f, 1.80781841e-01f, -2.69427299e-01f,
  7.63078481e-02f, -4.24978249e-02f, -5.93405440e-02f, -4.10827659e-02f, -1.96631297e-01f, -6.36558756e-02f, -3.66060622e-02f, -2.99142361e-01f, -1.24063961e-01f, 1.23355426e-01f,
  -5.94120547e-02f, -1.76082581e-01f, 1.32920444e-01f, 5.68123385e-02f, -7.33445510e-02f, 1.36934996e-01f, 9.23834294e-02f, 4.92764413e-02f, -1.62136070e-02f, 3.09865624e-02f,
  1.22781664e-01f, 1.74409244e-02f, -1.13766238e-01f, -1.87360328e-02f, -5.36488034e-02f, 9.31409672e-02f, -9.68290915e-05f, -5.41199297e-02f, -6.10307381e-02f, 1.08696304e-01f,
  7.96455368e-02f, -1.15231215e-03f, 7.47643113e-02f, 1.24691173e-01f, -1.06240518e-01f, 2.52497122e-02f, 4.78124283e-02f, 8.94979015e-02f, -3.82832773e-02f, 7.18097910e-02f,
  5.99140897e-02f, -9.35750082e-02f, 2.52684429e-02f, -9.57682431e-02f, -9.34409425e-02f, -5.07703498e-02f, 6.89331517e-02f, -5.35062626e-02f, -1.41042054e-01f, -5.51962061e-03f,
  -1.00695834e-01f, 6.94800764e-02f, -5.68250194e-02f, 3.72516178e-02f, -4.15405706e-02f, -6.21711686e-02f, 2.43125111e-02f, -5.38966171e-02f, 8.97961035e-02f, -2.33040843e-03f,
  3.04047088e-03f, 5.67782251e-03f, 3.92441079e-02f, -6.90384060e-02f, 7.13092908e-02f, 8.22717603e-03f, 3.18762809e-02f, 1.56070471e-01f, 3.67385969e-02f, -3.04030795e-02f,
  -4.86115925e-02f, -2.20432088e-01f, 5.82147650e-02f, -2.51838602e-02f, 3.83185484e-02f, 1.21469311e-01f, -1.38688177e-01f, -1.53556839e-01f, 3.63812149e-02f, 1.99312747e-01f,
  -1.26164556e-02f, -1.16389684e-01f, -5.50223663e-02f, -1.28434896e-01f, 2.49730185e-01f, 6.82358518e-02f, 9.31505188e-02f, -3.64403501e-02f, -2.79522650e-02f, -5.82472086e-02f,
  1.00705504e-01f, -2.75419861e-01f, -5.77552207e-02f, 1.32551670e-01f, 1.15750447e-01f, -6.98190480e-02f, 4.49331589e-02f, 1.21311061e-01f, 2.08990321e-01f, 5.44174016e-02f,
  3.07760891e-02f, 1.18948603e-02f, 4.52259369e-02f, 2.26323873e-01f, -8.02694783e-02f, 2.53855824e-01f, -5.04378751e-02f, 5.58259040e-02f, -1.41316816e-01f, -9.37947854e-02f,
  -8.26817751e-02f, 1.32877126e-01f, -1.99949387e-02f, 1.20228536e-01f, 9.11297351e-02f, -2.98931487e-02f, -2.80636162e-01f, 8.79536569e-02f, -2.20739275e-01f, 1.94340602e-01f,
  -1.18853569e-01f, 1.31946966e-01f, -3.98176648e-02f, 2.45477661e-01f, -4.24531363e-02f, 3.81351486e-02f, 3.84660602e-01f, -1.60653397e-01f, 1.50768444e-01f, 3.03376224e-02f,
  -4.80188541e-02f, 1.23871021e-01f, 7.70671517e-02f, -1.28676742e-01f, -1.02263957e-01f, 7.93825462e-02f, -8.80974978e-02f, 6.68019429e-02f, 7.04439878e-02f, 6.66672131e-03f,
  -1.47530213e-01f, -5.45585044e-02f, 2.73641348e-02f, -8.68708938e-02f, -4.69032750e-02f, 1.67507157e-02f, -1.67476814e-02f, 2.63254773e-02f, -1.99209005e-02f, -4.13781255e-02f,
  -6.21762611e-02f, -3.17270122e-02f, 3.63399312e-02f, -3.71527225e-02f, -1.44679267e-02f, -2.59991717e-02f, -4.48554195e-02f, -1.77873783e-02f, 4.55130674e-02f, -2.49437168e-02f,
  4.33947556e-02f, -6.28322810e-02f, -2.82824431e-02f, 3.79310399e-02f, 7.71132931e-02f, 2.00196296e-01f, -1.55895818e-02f, -3.63482870e-02f, -2.61249263e-02f, -2.29737729e-01f,
  7.36372247e-02f, -1.55628379e-02f, -6.73649181e-03f, -1.39684066e-01f, -1.27888903e-01f, -6.39920458e-02f, 1.00262482e-02f, 3.24017033e-02f, -5.56865148e-02f, 1.59532987e-02f,
  8.46716687e-02f, 1.34063633e-02f, 5.77372089e-02f, 4.13911454e-02f, 1.70333952e-01f, -1.24927901e-01f, -7.10150301e-02f, 6.86613247e-02f, -5.95802022e-03f, -7.13988091e-04f,
  -6.94947541e-02f, -3.99855785e-02f, 7.78415352e-02f, -3.25744376e-02f, -1.04990222e-01f, 8.11428651e-02f, 1.85232460e-01f, -6.04489120e-03f, -1.26662269e-01f, -4.55763042e-02f,
  3.03679742e-02f, 9.82479379e-02f, 1.40954524e-01f, 6.72722049e-03f, -1.40987694e-01f, -9.36437324e-02f, 1.31623030e-01f, 1.16130218e-01f, 1.37417957e-01f, -1.19881541e-01f,
  -6.31428659e-02f, 1.05025746e-01f, -1.84066836e-02f, 7.05787539e-02f, 6.07336573e-02f, 3.18387076e-02f, -1.60198048e-01f, 8.31093546e-03f, -5.24912253e-02f, 1.78180709e-02f,
  1.48129448e-01f, 7.24008679e-02f, 1.62825882e-01f, -4.81197946e-02f, -1.08583691e-02f, 3.12268585e-01f, 8.39953718e-04f, -5.10152839e-02f, 1.44546941e-01f, -5.33797443e-02f,
  -5.67977726e-02f, -6.49636090e-02f, -4.76278625e-02f, 3.04770172e-02f, 9.21126455e-02f, 1.62411779e-02f, -6.88356683e-02f, -1.04337431e-01f, 2.19897568e-01f, 3.81517112e-02f,
  1.33659318e-01f, 1.85969412e-01f, -4.98742759e-02f, -1.70034003e-02f, -3.43129963e-01f, -8.60069618e-02f, -2.72876710e-01f, 2.71826595e-01f, 7.89023470e-03f, -9.68209133e-02f,
  -1.49032548e-01f, 1.28450930e-01f, 1.45957813e-01f, 9.80472472e-03f, 1.60530642e-01f, 4.99644838e-02f, 1.42293587e-01f, -1.95584655e-01f, -3.59645933e-02f, 3.43670964e-01f,
  2.75681615e-02f, -8.26054439e-02f, -1.12870164e-01f, -8.85114148e-02f, -4.33869995e-02f, 5.40269352e-02f, -7.87322447e-02f, -5.25376387e-03f, 1.82399943e-01f, -6.27133846e-02f,
  -4.78966571e-02f, -9.30969976e-03f, -1.16599403e-01f, 2.77688745e-02f, -3.09553463e-02f, 2.38492005e-02f, 2.36289985e-02f, 7.14150891e-02f, 7.74517655e-02f, 1.31913111e-01f,
  -7.92772695e-02f, 3.80875058e-02f, -9.53008309e-02f, 6.96485266e-02f, 4.47611511e-02f, 4.77013253e-02f, 8.86982232e-02f, 4.68947403e-02f, 6.76522823e-03f, -9.77179408e-02f,
  -1.20236740e-01f, 7.00568408e-02f, -6.51195124e-02f, 1.27323464e-01f, 1.57546073e-01f, 1.45151317e-01f, -2.76789814e-03f, 5.31879999e-02f, 7.53013641e-02f, -5.02563566e-02f,
  -4.22951952e-02f, -3.78359146e-02f, 8.62452090e-02f, 7.85267502e-02f, -4.80317995e-02f, -7.50024840e-02f, -5.74908108e-02f, -3.83268856e-02f, -3.25812474e-02f, -7.23880678e-02f,
  1.66665211e-01f, 1.34570494e-01f, 1.08515374e-01f, -5.11252657e-02f, 4.43559811e-02f, 7.06883669e-02f, -7.57546946e-02f, 3.93120088e-02f, 1.14645287e-01f, 7.85148144e-02f,
  -1.91367552e-01f, -1.12735726e-01f, -6.23252504e-02f, 8.32276195e-02f, -2.20880315e-01f, 4.83969077e-02f, 1.25396103e-01f, -2.69121048e-03f, -1.67346016e-01f, 2.52640784e-01f,
  -9.20931995e-02f, -6.80128410e-02f, -8.64750445e-02f, -5.95250763e-02f, 8.15781672e-03f, 3.26429270e-02f, -9.19292718e-02f, 1.06066510e-01f, 2.03648388e-01f, -2.09400952e-01f,
  -4.12642099e-02f, 2.24267781e-01f, 9.95125808e-03f, -5.89719340e-02f, -2.25024581e-01f, -4.63853180e-02f, 4.36472483e-02f, -1.52719989e-01f, -1.47495434e-01f, -8.04865286e-02f,
  -2.12329607e-02f, 2.14551553e-01f, 5.22871725e-02f, -1.67564303e-01f, 1.26808509e-01f, -1.15877530e-02f, -6.56175464e-02f, 1.19239375e-01f, -8.08161646e-02f, 4.27460633e-02f,
  4.51154970e-02f, 4.48474400e-02f, 1.52744884e-02f, -9.60656404e-02f, 1.12660199e-01f, -4.88941520e-02f, -4.20342796e-02f, -1.63505167e-01f, 7.23271444e-02f, 2.71400418e-02f,
  3.57848518e-02f, 8.59361216e-02f, 5.86188026e-02f, 1.16518941e-02f, -7.08250329e-02f, -7.46997669e-02f, 1.32974073e-05f, 1.57955304e-01f, -2.49962851e-01f, -8.29030424e-02f,
  -1.89968292e-02f, -9.29574594e-02f, -2.53999941e-02f, -1.77365214e-01f, 1.22854799e-01f, -1.48560598e-01f, 8.06242004e-02f, -4.94713336e-03f, -4.63173576e-02f, 9.27249789e-02f,
  1.06136248e-01f, -4.06565458e-01f, -2.65133157e-02f, -7.24955201e-02f, 8.61320645e-02f, -6.97391927e-02f, 9.01827067e-02f, -6.98660165e-02f, 9.60661657e-03f, -2.02877104e-01f,
  1.43406522e-02f, -2.70629600e-02f, -8.67845044e-02f, 2.18473226e-02f, -7.01324716e-02f, -7.00290874e-03f, -1.44526521e-02f, -5.10687418e-02f, 3.77774425e-02f, 2.17804243e-03f,
  -6.92721736e-03f, -1.23301800e-02f, -3.46373417e-03f, -9.94550511e-02f, -5.60056306e-02f, -2.72361632e-03f, -6.10281564e-02f, 2.08527874e-02f, -4.16923165e-02f, 4.19417098e-02f,
  -2.18772572e-02f, -4.65887040e-02f, 9.42925736e-02f, 1.15821086e-01f, -1.13053121e-01f, -4.32693250e-02f, 1.29646799e-02f, 1.82892337e-01f, -1.61945522e-02f, 1.43235669e-01f,
  4.07852121e-02f, -1.78974137e-01f, 1.17222648e-02f, 3.31818983e-02f, 4.85103764e-02f, -7.68697355e-03f, 3.07786241e-02f, -8.32068026e-02f, -8.57064798e-02f, 6.19480014e-03f,
  -8.28578025e-02f, 1.67505313e-02f, -5.87784797e-02f, 1.10897422e-01f, 3.05352476e-03f, -3.34697776e-02f, 1.31671757e-01f, 1.01038411e-01f, -1.26836747e-01f, -1.12429447e-01f,
  -3.16147804e-02f, -6.92921355e-02f, 1.13263950e-01f, 7.17934966e-02f, 2.36025732e-02f, 6.80537745e-02f, 2.37535983e-02f, -8.07417780e-02f, 8.89902413e-02f, -8.36181175e-03f,
  1.79760810e-02f, -3.58978249e-02f, -5.78598538e-03f, -2.43657529e-01f, 3.60751562e-02f, 1.04876786e-01f, 6.79410994e-02f, 1.05746359e-01f, -7.63789117e-02f, -4.65489030e-02f,
  4.68005054e-02f, 1.29734531e-01f, 6.12087268e-03f, -1.29023090e-01f, 3.05637531e-02f, 8.40644166e-02f, -1.43978540e-02f, 1.43378600e-01f, 6.31054416e-02f, 1.61981478e-01f,
  1.15653343e-01f, 3.18222418e-02f, -1.01032957e-01f, -4.67610061e-02f, 5.51775768e-02f, -1.03784874e-01f, -1.35514319e-01f, -1.59580618e-01f, -4.22864705e-02f, 1.04360562e-02f,
  -5.17680235e-02f, 3.51521820e-02f, 2.02237755e-01f, -1.16624072e-01f, 1.18098898e-04f, -2.37222373e-01f, -9.43704322e-02f, -1.18518442e-01f, -2.90353626e-01f, 1.11866318e-01f,
  2.17983201e-01f, 1.93665605e-02f, -1.26479836e-02f, -2.03559935e-01f, -1.30665436e-01f, 3.89100373e-01f, 3.26171741e-02f, -2.35253662e-01f, 1.68962255e-01f, -2.11139284e-02f,
  6.12023547e-02f, 1.82453857e-03f, -1.46904096e-01f, 2.76691243e-02f, 3.98141891e-02f, 2.27919906e-01f, 1.23246938e-01f, 1.38608471e-01f, 9.17756930e-02f, -3.67300570e-01f,
  -6.70494884e-02f, 5.21003343e-02f, 1.12852501e-02f, -6.43263385e-02f, -6.15344606e-02f, 1.38214692e-01f, -8.28174949e-02f, 1.14374712e-01f, 1.47129416e-01f, 8.52525830e-02f,
  -6.47766516e-02f, 3.27940024e-02f, 1.07230637e-02f, -9.31877866e-02f, 6.53283251e-03f, 6.79086894e-02f, 2.26757023e-02f, 9.76092517e-02f, 7.29437172e-02f, 2.03557879e-01f,
  -8.40919763e-02f, -2.92440027e-01f, -5.83442301e-02f, 2.43354868e-02f, 8.14454257e-02f, -2.74082143e-02f, 5.92876077e-02f, -2.00133938e-02f, 4.53719981e-02f, 1.17985003e-01f,
  -6.58018962e-02f, 7.36135319e-02f, -4.38392609e-02f, -1.79878976e-02f, 8.81343558e-02f, 1.26032650e-01f, 1.48711756e-01f, 9.89276916e-02f, 7.94176536e-04f, -9.37470794e-02f,
  1.51289523e-01f, 3.14978994e-02f, -8.37739855e-02f, -2.49969913e-03f, 1.15935449e-02f, 1.04701534e-01f, 1.14482725e-02f, 1.40707523e-01f, 9.85872000e-02f, -4.30648364e-02f,
  -3.57029140e-02f, 3.10281038e-01f, 4.02715318e-02f, 1.31782554e-02f, 2.29166865e-01f, -5.52316522e-03f, 1.76317364e-01f, 7.04989955e-02f, 5.21158129e-02f, 2.97271647e-02f,
  1.79215714e-01f, -6.61878511e-02f, -2.84216795e-02f, 6.59409910e-02f, -1.71232402e-01f, 2.48523485e-02f, 2.14209899e-01f, -7.45295659e-02f, -4.07847948e-02f, -9.71651971e-02f,
  4.64015156e-02f, 4.11336869e-02f, 1.45564675e-01f, -3.46360467e-02f, -2.12864429e-01f, 1.15509629e-01f, 1.13781288e-01f, -2.76893705e-01f, -2.53855027e-02f, 2.87797153e-02f,
  -2.12556377e-01f, 1.33299127e-01f, -9.49689597e-02f, 1.01338319e-01f, 7.66140223e-02f, 2.11060256e-01f, 5.28174676e-02f, 1.08936215e-02f, 1.18109405e-01f, 6.29918873e-02f,
  -2.75664389e-01f, -1.27714336e-01f, 2.03172177e-01f, -1.34480074e-01f, 5.62136644e-04f, -6.56303167e-02f, -7.94652477e-02f, 4.92303595e-02f, -4.59667332e-02f, 6.83259219e-02f,
  -2.20444366e-01f, 1.25512332e-02f, 8.89537185e-02f, -1.70652553e-01f, -1.53509766e-01f, 2.36269198e-02f, -3.67984883e-02f, 1.13548979e-01f, 1.87884986e-01f, 6.42009825e-02f,
  1.03974484e-01f, 1.22759148e-01f, -1.39767975e-01f, 2.00903118e-01f, 2.81810928e-02f, 1.00701138e-01f, -1.23649120e-01f, 8.50246400e-02f, -1.06044590e-01f, -6.49823621e-02f,
  -5.11405431e-02f, 1.25493541e-01f, -1.41311169e-01f, 2.48436198e-01f, -1.30333573e-01f, -6.09774850e-02f, -5.43586388e-02f, -1.67246327e-01f, -7.06749782e-02f, 3.35363783e-02f,
  -9.01973527e-03f, 3.70418094e-02f, 1.34144217e-01f, -6.33943379e-02f, 4.32497188e-02f, -1.70134187e-01f, -8.59867185e-02f, -1.84922796e-02f, -1.53133675e-01f, -1.69410966e-02f,
  -1.31288663e-01f, -8.34402144e-02f, -1.86489504e-02f, -2.01600596e-01f, -2.49872487e-02f, -1.23678660e-02f, -1.55628053e-02f, -7.72332326e-02f, -1.19460434e-01f, 1.30434632e-01f,
  1.40543938e-01f, 4.75084782e-02f, -8.27951431e-02f, -1.79569274e-02f, 6.99974597e-02f, -3.64641063e-02f, -1.75877124e-01f, -2.28097245e-01f, 8.80996957e-02f, 1.51630685e-01f,
  -6.02314435e-02f, -2.47601364e-02f, -4.09905389e-02f, -1.17560729e-01f, -4.36814614e-02f, -1.14201672e-01f, -1.53776444e-02f, 2.45612878e-02f, -4.24032547e-02f, 7.88274929e-02f,
  -5.84669001e-02f, -9.43102017e-02f, 2.11370021e-01f, -1.40819162e-01f, 1.90056294e-01f, 1.20878071e-02f, -6.85932189e-02f, 1.43037057e-02f, 6.83706207e-03f, 1.03960879e-01f,
  -1.77981681e-03f, 9.42350551e-02f, 8.17084312e-03f, -1.73215121e-01f, -2.69503117e-01f, 2.47817044e-03f, -1.27430603e-01f, -2.52073929e-02f, 1.54430658e-01f, 1.16696090e-01f,
  -1.73273578e-01f, 5.35804182e-02f, 1.34983912e-01f, -1.55457184e-01f, 4.39503901e-02f, 1.51482537e-01f, -6.66514784e-02f, 9.79671776e-02f, 5.58003709e-02f, -3.21410686e-01f,
  -5.67845628e-02f, -5.60687706e-02f, 4.96110022e-02f, -8.61234590e-02f, -5.93176531e-03f, 5.57330698e-02f, 1.00083023e-01f, 5.37682809e-02f, -2.63171136e-01f, 2.52183247e-02f,
  -1.34270400e-01f, -3.74490656e-02f, -1.01276271e-01f, -7.34119266e-02f, 1.43707722e-01f, 5.21854572e-02f, -1.17917471e-01f, 4.15691473e-02f, 1.80726964e-02f, 4.81110439e-02f,
  1.48638129e-01f, 2.84110960e-02f, -6.21965826e-02f, -9.79949981e-02f, 8.54077190e-03f, -9.36929435e-02f, 1.52340323e-01f, -1.01988070e-01f, 9.87620503e-02f, 5.50616160e-02f,
  -7.98434839e-02f, 4.62151878e-02f, 1.56103402e-01f, -1.64036021e-01f, -1.87304750e-01f, -1.16322942e-01f, -2.69206792e-01f, -9.89383832e-02f, -1.22784831e-01f, 5.75980991e-02f,
  1.45644695e-01f, -1.38918757e-01f, 6.25843778e-02f, -1.66532636e-01f, 5.27559370e-02f, -2.14307666e-01f, 1.10991225e-01f, 5.99863715e-02f, -1.86022505e-01f, -3.91805582e-02f,
  1.13080606e-01f, 2.84868568e-01f, 1.05062038e-01f, 4.08088341e-02f, 7.00322613e-02f, -1.11368090e-01f, 5.85843511e-02f, -7.69206211e-02f, -3.69823538e-02f, 2.47856472e-02f,
  8.48189648e-03f, -4.26302664e-03f, -5.08775823e-02f, 5.58729917e-02f, -4.25626058e-04f, 8.82634297e-02f, 2.00035833e-02f, 5.44986725e-02f, 3.02379578e-02f, 7.61011243e-02f,
  6.58272579e-02f, -8.66000205e-02f, 7.15497211e-02f, -9.88895297e-02f, 2.57538352e-02f, -1.50521323e-01f, 4.66372706e-02f, 1.17379665e-01f, 3.72540317e-02f, 9.38209593e-02f,
  -8.24985653e-02f, 9.70875286e-03f, 6.47342578e-02f, 2.60047894e-02f, 1.68001391e-02f, -1.93532147e-02f, 2.43741199e-02f, -4.78560850e-02f, 1.27688453e-01f, 1.08319551e-01f,
  -1.49703249e-02f, 1.78427175e-01f, 1.56379938e-02f, -2.49736309e-02f, 2.85419598e-02f, -2.74209343e-02f, 1.94938257e-02f, 1.00264177e-01f, 1.76041901e-01f, -4.46113497e-02f,
  -7.36482488e-03f, -5.09284511e-02f, 1.36292487e-01f, 8.25634077e-02f, -2.58863550e-02f, 6.20884858e-02f, -1.31586818e-02f, -4.11530063e-02f, 1.22289464e-01f, 5.98099306e-02f,
  -7.97289424e-03f, 1.32467613e-01f, -1.08612236e-02f, -6.45770179e-03f, 1.80780709e-01f, -1.77213117e-01f, -5.61978929e-02f, -1.96505710e-02f, 1.34453923e-01f, -1.80055484e-01f,
  1.05637789e-03f, 8.18565339e-02f, -5.37820999e-03f, -3.39725390e-02f, 4.71275933e-02f, 3.00203473e-03f, 1.24260716e-01f, 5.09882206e-03f, -2.75588557e-02f, 9.06218141e-02f,
  1.62941441e-01f, -1.85534488e-02f, -2.23215576e-02f, -2.12935023e-02f, 1.09486626e-02f, 1.38324322e-02f, 4.46388796e-02f, -1.64170355e-01f, -1.00389935e-01f, -1.16643636e-02f,
  5.48661547e-03f, -7.25020021e-02f, -4.10573296e-02f, 1.11970738e-01f, 1.39716104e-01f, -1.07376806e-01f, 1.42945647e-01f, -1.11750305e-01f, -1.38247788e-01f, -2.36293480e-01f,
  5.24129197e-02f, 3.39363106e-02f, 9.93859246e-02f, -1.07979206e-02f, 6.17431924e-02f, 4.29058336e-02f, 1.07785709e-01f, -1.11545622e-01f, 1.66421279e-01f, -1.90102533e-01f,
  -1.52363405e-01f, -1.06258444e-01f, -9.50090513e-02f, 8.25975239e-02f, -1.09029673e-01f, -1.73929274e-01f, 2.29974195e-01f, 5.11353463e-03f, 4.27117795e-02f, -5.64398132e-02f,
  -4.21644421e-04f, -2.74477601e-01f, 1.16256379e-01f, 1.27072603e-01f, -1.66974261e-01f, 1.09465033e-01f, -2.29909316e-01f, -6.64707720e-02f, 1.14542276e-01f, -2.89583534e-01f,
  -1.94233600e-02f, -9.53005925e-02f, -1.01516053e-01f, -1.69545993e-01f, 9.71250385e-02f, 3.97378467e-02f, -1.95873231e-02f, 4.83079031e-02f, 1.11956187e-01f, -6.39035404e-02f,
  8.28112364e-02f, 4.08352800e-02f, 3.41320485e-02f, -2.77580842e-02f, 2.97646224e-02f, -4.94210236e-02f, -8.96297246e-02f, 1.34435762e-02f, 9.95360017e-02f, 1.11953892e-01f,
  1.02125660e-01f, -2.56418157e-02f, -2.30075233e-02f, -9.57789272e-02f, 1.04694664e-01f, -7.29304599e-03f, 2.14750525e-02f, -8.38387832e-02f, -1.81168057e-02f, 5.73495217e-02f,
  6.76388517e-02f, -9.34132263e-02f, 1.23219125e-01f, 1.43314302e-01f, -5.57093509e-02f, 1.43253118e-01f, 5.09857647e-02f, 1.01417974e-01f, -6.58232868e-02f, -1.60655398e-02f,
  1.19887643e-01f, 1.92366555e-01f, -1.67543188e-01f, 1.41144171e-01f, -2.61922088e-02f, 5.58065102e-02f, -1.54721722e-01f, -3.55044268e-02f, -3.43562178e-02f, 6.55380711e-02f,
  -3.19346460e-03f, 1.39147416e-01f, 1.85075533e-02f, -9.52234194e-02f, 6.40846416e-02f, -1.85043469e-01f, 6.89425245e-02f, -2.56990809e-02f, -1.74205825e-01f, 2.66910009e-02f,
  6.72868565e-02f, 1.72744878e-02f, -1.39788231e-02f, 1.35343954e-01f, 1.99386477e-01f, -4.73979302e-02f, -1.29651399e-02f, 4.93686311e-02f, 3.23740691e-02f, 1.94186062e-01f,
  5.82322627e-02f, 6.42315811e-03f, 2.27829739e-01f, 6.69166967e-02f, 8.11077654e-02f, 1.15691885e-01f, 2.61472940e-01f, -1.00235179e-01f, -1.59269512e-01f, 4.67304438e-02f,
  -1.05462089e-01f, 1.09009586e-01f, -3.13384831e-02f, 7.59178177e-02f, 6.00549132e-02f, 5.29589020e-02f, -4.65572998e-02f, -3.95544358e-02f, 2.43308589e-01f, -6.41378462e-02f,
  -1.96508672e-02f, -8.77497345e-02f, -1.65807649e-01f, -1.93501525e-02f, -1.76029891e-01f, -6.69907173e-03f, -1.08716078e-02f, -3.86038423e-02f, 9.94796026e-03f, 1.31053165e-01f,
  -2.47510180e-01f, -8.65050629e-02f, -1.69420898e-01f, 3.04525159e-03f, 1.93681121e-02f, 1.12590589e-01f, -1.62741572e-01f, -1.43833011e-01f, -8.45090970e-02f, 3.28794330e-01f,
  -1.75923243e-01f, -1.41555086e-01f, 1.69764563e-01f, -1.26497760e-01f, 6.29877904e-03f, 9.18863416e-02f, 3.02273966e-02f, 1.27445040e-02f, -1.04570121e-01f, -5.25623150e-02f,
  -1.75373033e-01f, 7.54167810e-02f, -3.46291691e-01f, 7.99247622e-02f, -6.48738146e-02f, 6.45770878e-02f, -2.78420657e-01f, 2.02330023e-01f, 4.76019569e-02f, -3.56707759e-02f,
  3.20296325e-02f, -2.39842817e-01f, 3.11066564e-02f, 5.24802431e-02f, 1.09254137e-01f, 1.99727658e-02f, -5.31391986e-02f, -1.71309188e-02f, -4.49502887e-03f, 9.49593261e-02f,
  4.13553603e-02f, 3.18664052e-02f, -1.63127128e-02f, 6.48711203e-03f, -8.26224238e-02f, 3.24858651e-02f, -3.87004092e-02f, 1.46565422e-01f, 8.72098207e-02f, 5.55923432e-02f,
  -1.60717577e-01f, 1.00358412e-01f, 1.47868335e-01f, -1.43979210e-02f, -4.59598601e-02f, 4.07903008e-02f, -5.21822684e-02f, 4.89385612e-02f, 5.18922657e-02f, -1.01351738e-01f,
  1.31846471e-02f, 9.81677100e-02f, 9.29017086e-03f, 1.36001021e-01f, 8.45984668e-02f, -3.28815803e-02f, 1.70506731e-01f, -1.13790724e-02f, -1.98206499e-01f, 4.66736890e-02f,
  2.98661198e-02f, 4.24535014e-02f, -2.57152766e-02f, 4.80873324e-02f, -9.17654186e-02f, -4.25386056e-02f, 6.34695888e-02f, -4.20194678e-02f, -6.57921061e-02f, 2.29555041e-01f,
  1.01788379e-01f, -1.50709972e-02f, -1.10110315e-02f, -6.65287524e-02f, -1.24115888e-02f, 1.51656896e-01f, 4.87037748e-02f, 1.20355263e-01f, -1.60705358e-01f, -3.63417640e-02f,
  -1.52691841e-01f, 3.02390128e-01f, -2.19396241e-02f, -8.86069685e-02f, 1.07178852e-01f, 1.90659007e-03f, 4.54563983e-02f, -8.62625465e-02f, 4.69767749e-02f, 8.52182284e-02f,
  -4.84562665e-02f, -5.59785627e-02f, 3.23153362e-02f, 1.67931572e-01f, 8.24226663e-02f, -1.92191787e-02f, -7.80163482e-02f, 6.72196075e-02f, -2.66572628e-02f, 2.19834939e-01f,
  1.31179139e-01f, -7.63840647e-03f, -9.31894258e-02f, -1.10113904e-01f, -8.94777849e-02f, -2.24966630e-02f, 1.58232525e-01f, 5.88625483e-02f, -6.38336241e-02f, 3.74298223e-04f,
  2.39184555e-02f, 1.03761293e-01f, 1.08257875e-01f, -8.94256607e-02f, -2.39542816e-02f, -2.34222766e-02f, 8.93994421e-02f, -8.36366415e-02f, -5.18185943e-02f, 5.49660623e-02f,
  1.93191189e-02f, -5.19228019e-02f, 1.53895482e-01f, 1.17511511e-01f, -1.39708385e-01f, -4.75381836e-02f, 9.36558098e-02f, 1.05160274e-01f, -8.67193416e-02f, 1.41081542e-01f,
  1.88754112e-01f, 7.44573623e-02f, -3.49781871e-01f, -9.72261503e-02f, -1.73915431e-01f, -4.19341251e-02f, 3.16181919e-03f, 1.29766420e-01f, -2.67606061e-02f, -1.40736103e-01f,
  4.07801777e-01f, -2.12377712e-01f, 2.06652492e-01f, -3.28554176e-02f, -6.41305447e-02f, 3.29008639e-01f, -7.54754916e-02f, 4.48392108e-02f, -2.41208058e-02f, -2.64462769e-01f,
  -1.53228924e-01f, -9.82553810e-02f, 4.10998948e-02f, 4.73817959e-02f, -6.00417554e-02f, -6.02286011e-02f, -5.77071905e-02f, 5.40864281e-02f, -5.95544018e-02f, -1.96988229e-02f,
  1.17454231e-01f, -1.23112962e-01f, 6.08040243e-02f, 5.73538914e-02f, -1.52207419e-01f, 1.69326499e-01f, -2.48732157e-02f, -1.28663316e-01f, 8.77151266e-03f, 1.36465102e-01f,
  4.32372503e-02f, -5.30799292e-02f, -5.78501709e-02f, -9.82031673e-02f, 1.19789191e-01f, -7.75925964e-02f, 1.42397052e-02f, 8.41149241e-02f, 8.52885693e-02f, 6.00768216e-02f,
  -6.02859594e-02f, 9.49070882e-03f, -2.47764848e-02f, -6.30498677e-02f, -1.51101500e-01f, -5.64809702e-02f, -3.17786299e-02f, -8.22038278e-02f, 1.43747017e-01f, 2.54606083e-02f,
  2.54370030e-02f, 2.31684744e-02f, 1.19199092e-02f, 1.34726048e-01f, -1.28055245e-01f, -9.48102563e-04f, -8.47185031e-03f, -1.10115722e-01f, -1.36929289e-01f, -1.35851070e-01f,
  -6.09901883e-02f, 1.50312096e-01f, -5.66954166e-02f, -2.25210693e-02f, 9.27035138e-02f, 1.97057322e-01f, -2.19702736e-01f, 1.42553039e-02f, -1.21354043e-01f, 1.03677027e-01f,
  -9.90397409e-02f, -1.97430044e-01f, -6.80994093e-02f, 1.41014889e-01f, -1.02565847e-01f, -6.00293577e-02f, -2.17066333e-02f, 1.28699467e-01f, -1.99907005e-01f, -1.83833405e-01f,
  7.27584809e-02f, 3.74529362e-02f, -4.19308096e-02f, -2.31110789e-02f, -7.93000832e-02f, 2.55308524e-02f, 6.06579445e-02f, 1.29247844e-01f, 9.57917199e-02f, -5.04054390e-02f,
  -3.16354126e-01f, 7.12667033e-02f, 1.70547500e-01f, 3.78913209e-02f, -1.06673017e-01f, 2.64705122e-01f, 3.94212529e-02f, 1.41380683e-01f, 1.02139801e-01f, 1.33345813e-01f,
  5.33153638e-02f, -2.54125893e-02f, 3.01118214e-02f, 7.06398562e-02f, -7.87134469e-03f, -1.28357396e-01f, -4.27155429e-03f, 6.90199435e-02f, -8.91086012e-02f, -1.17440015e-01f,
  8.83110538e-02f, -1.30946711e-01f, 1.55705824e-01f, 1.06674947e-01f, 1.73341289e-01f, 1.21622436e-01f, -2.65183687e-01f, 6.42282888e-02f, -7.76644573e-02f, -3.06987703e-01f,
  -2.56860077e-01f, 1.31755173e-01f, -2.73991883e-01f, 1.34320349e-01f, -1.92630440e-01f, -4.62485477e-02f, 2.99720973e-01f, 1.67503627e-03f, -2.24044025e-02f, 3.27362239e-01f,
  4.08067927e-02f, -1.08159602e-01f, 1.02666222e-01f, 1.31630152e-01f, 1.74027532e-01f, 9.74426717e-02f, 2.99765784e-02f, -4.39845026e-01f, -1.43065929e-01f, -6.40504807e-02f,
  -6.42420873e-02f, -1.24263331e-01f, 8.43435898e-02f, 1.70498073e-01f, -1.24334589e-01f, 5.46030747e-03f, 4.50731348e-03f, 1.53436765e-01f, -9.28632636e-03f, -1.83385193e-01f,
  -4.09592539e-02f, -7.17537478e-02f, -2.58869808e-02f, 3.61529365e-02f, 2.50510555e-02f, -9.35349911e-02f, -2.67182291e-02f, 1.26779452e-01f, -9.03225914e-02f, 5.33760041e-02f,
  5.75685836e-02f, 1.54730543e-01f, -1.43896360e-02f, -2.12535616e-02f, -1.99313108e-02f, 1.04712017e-01f, -2.50364449e-02f, -4.05925177e-02f, -2.86175199e-02f, -3.09777632e-02f,
  -6.42372435e-03f, 1.47259347e-02f, -1.17087796e-01f, 3.85523848e-02f, 8.07029754e-02f, 3.00226621e-02f, 9.91611853e-02f, 5.33711128e-02f, 2.84011979e-02f, -1.80538327e-01f,
  2.05175802e-01f, 1.43033061e-02f, -1.09345891e-01f, 3.26700024e-02f, -6.41881675e-02f, 2.29437873e-02f, 8.07883888e-02f, 2.33868808e-01f, -1.18959174e-01f, 1.70311972e-01f,
  6.40856382e-03f, 1.53993562e-01f, 9.65271667e-02f, 3.32755153e-03f, -4.36814539e-02f, -3.16822268e-02f, -5.36186397e-02f, -3.07582796e-01f, 1.34940177e-01f, -1.35613069e-01f,
  -9.95165035e-02f, 5.56700751e-02f, -7.45572224e-02f, -1.99264929e-01f, -5.17534278e-02f, 7.24686161e-02f, -2.18112413e-02f, -3.01858466e-02f, -1.15256935e-01f, -4.17806022e-02f,
  3.61633375e-02f, 4.89054881e-02f, 1.05572134e-01f, 8.05980861e-02f, -4.21574712e-02f, -1.28708094e-01f, 1.46128878e-01f, 4.03802134e-02f, -1.65633131e-02f, -5.54890372e-02f,
  -1.62347525e-01f, -2.89324601e-03f, 8.74710381e-02f, 5.79867885e-02f, 2.10457534e-01f, 1.07002795e-01f, -1.12152584e-01f, -1.93766560e-02f, -5.63518219e-02f, -3.40270326e-02f,
  1.31745055e-01f, 4.54058945e-02f, 1.97805494e-01f, -1.41440794e-01f, 9.68759239e-04f, -4.71217819e-02f, -1.27060235e-01f, 1.38984784e-01f, -9.25702825e-02f, -2.02306788e-02f,
  -1.66753888e-01f, 1.27145752e-01f, -1.96624212e-02f, 3.31211425e-02f, 1.41906273e-02f, -1.89867586e-01f, 3.26870412e-01f, 1.99168369e-01f, -1.37895063e-01f, -2.35330984e-01f,
  -6.23686910e-02f, 9.99673679e-02f, 3.05244207e-01f, 5.05890511e-02f, 1.03148244e-01f, -9.85304010e-04f, 4.26503569e-01f, 1.49383038e-01f, -5.76704275e-03f, 4.68992367e-02f,
  7.72964731e-02f, -2.90523265e-02f, -5.52071817e-02f, -4.10921350e-02f, -4.40517142e-02f, 1.65075406e-01f, -6.32351264e-03f, 3.31427418e-02f, -4.53098826e-02f, -1.77646086e-01f,
  -5.09991758e-02f, -3.46432701e-02f, -2.71180179e-02f, -7.37171471e-02f, -1.17570870e-01f, 5.25191016e-02f, 1.09152034e-01f, -2.26483606e-02f, 1.87207328e-03f, 4.61881645e-02f,
  7.21868426e-02f, -5.96851632e-02f, -1.48361981e-01f, 4.88609783e-02f, 1.15040559e-02f, 4.49402221e-02f, 4.06501405e-02f, 1.30128950e-01f, 1.64890364e-01f, -5.53328954e-02f,
  3.45907845e-02f, 8.15414116e-02f, 1.49113545e-02f, 5.32274619e-02f, -2.36140843e-02f, -3.80603224e-03f, -6.71412647e-02f, 1.66195240e-02f, 1.38406590e-01f, -6.96054474e-02f,
  -1.55145545e-02f, 9.39988270e-02f, -4.81147692e-02f, -1.58099636e-01f, -1.09056281e-02f, -6.44484088e-02f, -2.53793374e-02f, -7.61541575e-02f, 1.63343757e-01f, 7.76994228e-02f,
  -1.14466302e-01f, 4.70113605e-02f, -4.69768085e-02f, 1.04976460e-01f, 6.17892817e-02f, 4.20247316e-02f, 3.15144137e-02f, -1.45987600e-01f, -2.13757962e-01f, 1.04016386e-01f,
  -2.11247742e-01f, -8.34200606e-02f, 1.40466392e-01f, -9.55352094e-03f, -8.49677250e-02f, 5.32703847e-02f, -1.11935593e-01f, -8.23594704e-02f, 4.51470241e-02f, -1.04605049e-01f,
  -1.36121642e-02f, 1.76519141e-01f, -1.32935107e-01f, -7.55024031e-02f, 8.50926042e-02f, -1.72335338e-02f, -1.09134413e-01f, 7.21320957e-02f, -2.03355685e-01f, -1.93473235e-01f,
  5.36458567e-02f, -2.07094923e-01f, -2.77659744e-02f, -1.06249126e-02f, 1.49675533e-02f, -4.60583344e-02f, 1.38470471e-01f, -6.28848672e-02f, 9.23882648e-02f, -8.81740898e-02f,
  -1.12274788e-01f, 2.26433054e-02f, 8.60612560e-03f, 1.02576248e-01f, 1.75952520e-02f, -1.68096274e-01f, 2.19529867e-01f, 9.43385661e-02f, -2.44576573e-01f, -1.30109638e-01f,
  2.84691639e-02f, 1.24459907e-01f, 1.49750546e-01f, 1.45419478e-01f, 4.78667282e-02f, -2.68427264e-02f, -1.31960854e-01f, -6.58092946e-02f, -2.40058023e-02f, -9.35005918e-02f,
  -2.21403256e-01f, -1.42860869e-02f, 2.70877540e-01f, -7.63269141e-02f, -3.54253173e-01f, 2.06452981e-01f, 3.02504510e-01f, -2.36775637e-01f, -2.28196979e-02f, -2.34184433e-02f,
  -1.79547034e-02f, 6.84942752e-02f, 7.86102340e-02f, 4.02138382e-03f, -7.98701122e-02f, -4.28216206e-03f, 1.04537524e-01f, -6.57418445e-02f, 7.53766298e-02f, -3.31431001e-01f,
  2.56359577e-02f, -1.44604549e-01f, -1.79977626e-01f, 1.83052510e-01f, 1.97683293e-02f, -3.18416990e-02f, 7.39979222e-02f, -4.93193530e-02f, 1.16979130e-01f, -2.82698441e-02f,
  3.44782658e-02f, 3.91701907e-02f, -1.20158777e-01f, 3.79694463e-03f, -1.24879146e-03f, 7.79990572e-03f, 8.13679025e-02f, -1.25502855e-01f, -4.50321622e-02f, -1.51920646e-01f,
  1.52394949e-02f, 3.17485444e-02f, 1.64066732e-01f, -1.58855617e-01f, -5.05099539e-03f, 4.67586257e-02f, 7.31386542e-02f, -2.33960766e-02f, -5.09822257e-02f, -2.76472955e-03f,
  -7.15311989e-02f, -5.23785800e-02f, 8.07317644e-02f, 9.42086279e-02f, 2.84329019e-02f, -4.99026738e-02f, -4.41541262e-02f, -1.21813118e-02f, -1.18401624e-01f, -6.51598349e-02f,
  2.93278992e-02f, 5.52653000e-02f, -1.83529064e-01f, 3.22204046e-02f, -7.91367590e-02f, 6.31002896e-03f, -9.30233151e-02f, -2.12648317e-01f, -9.68038756e-03f, -1.47029255e-02f,
  7.88372010e-03f, -6.21957444e-02f, -4.14335057e-02f, -1.33695066e-01f, 1.11161098e-01f, 1.57812208e-01f, 3.75033356e-02f, -9.06517580e-02f, 4.36430089e-02f, 4.72046509e-02f,
  -3.28377411e-02f, -9.50314179e-02f, -1.10015921e-01f, -1.37275890e-01f, 1.24742538e-01f, 1.29343852e-01f, 1.11435562e-01f, 6.59429207e-02f, -1.66482419e-01f, -1.04609281e-01f,
  3.11765689e-02f, -2.52299681e-02f, -8.29065293e-02f, 7.42482813e-03f, 4.93168868e-02f, -9.28109959e-02f, -7.16423541e-02f, 6.56552687e-02f, -1.16237789e-01f, 9.47970711e-03f,
  7.09707811e-02f, 6.18508719e-02f, 1.36205507e-02f, 9.03934464e-02f, -9.34095308e-02f, -4.81892079e-02f, 4.95556258e-02f, -9.07447338e-02f, 1.36470065e-01f, 3.64079997e-02f,
  -4.19487543e-02f, 4.18568887e-02f, 2.77544204e-02f, 1.19187899e-01f, -1.01880625e-01f, -1.06694005e-01f, 7.14776069e-02f, -2.32612137e-02f, 4.21767756e-02f, 7.64451623e-02f,
  -3.88519131e-02f, -9.90289450e-02f, -2.50366002e-01f, 7.57432589e-03f, 4.92916070e-02f, -1.38082787e-01f, 1.92587893e-03f, -2.27806166e-01f, -1.29538760e-01f, -2.03680441e-01f,
  -1.54511362e-01f, 6.28851205e-02f, 7.88214356e-02f, -2.30700180e-01f, -6.98309615e-02f, 1.35087103e-01f, -7.12711886e-02f, 1.01426095e-01f, -1.34841576e-01f, -8.05639029e-02f,
  2.45648906e-01f, 6.95543885e-02f, -5.59123717e-02f, 1.82618260e-01f, -8.44805464e-02f, -5.44565953e-02f, 2.65079856e-01f, 2.33104415e-02f, -4.53980751e-02f, 1.09150991e-01f,
  1.28313759e-02f, -3.23427767e-01f, 1.89241245e-01f, 4.20572050e-02f, -1.18277250e-02f, 4.65144776e-02f, 2.57013761e-03f, -1.16798347e-02f, 6.82238564e-02f, 2.18499433e-02f,
  1.59198761e-01f, 3.77117726e-03f, -1.38162076e-01f, 1.12201897e-02f, 3.00926752e-02f, -2.36769300e-02f, 1.35228438e-02f, -5.05686924e-03f, 3.44445445e-02f, -1.07515557e-02f,
  1.56751424e-01f, -8.61038193e-02f, -2.28606597e-01f, 8.55423585e-02f, 4.11528312e-02f, 2.45908886e-04f, -7.46831745e-02f, -5.95654361e-02f, -1.10049456e-01f, 4.32351120e-02f,
  1.55314922e-01f, 6.35437667e-02f, -1.04563251e-01f, 3.01826466e-02f, -3.77397835e-02f, -9.66825113e-02f, -3.09187658e-02f, 6.67417748e-03f, 1.25239506e-01f, 2.46763587e-01f,
  -1.21777374e-02f, -1.11827590e-01f, -2.21927930e-02f, 1.81744382e-01f, -8.87078270e-02f, 7.25461021e-02f, 2.50284337e-02f, -8.08669552e-02f, -9.82726067e-02f, 7.62025341e-02f,
  1.05373859e-01f, -1.37792304e-01f, -1.81711912e-02f, 7.66986161e-02f, 2.57223565e-02f, 2.81563867e-02f, 7.31917843e-02f, -3.80224921e-02f, -1.48654163e-01f, 7.62108564e-02f,
  -1.10936292e-01f, 5.85164204e-02f, 1.26088113e-01f, 6.25524968e-02f, 5.99377789e-02f, 2.78170686e-02f, 1.47321790e-01f, -8.01988766e-02f, -4.67314804e-03f, -1.59945160e-01f,
  -2.95410901e-02f, -2.64638308e-02f, 1.62066460e-01f, 5.07631199e-03f, 4.94453534e-02f, 7.37358704e-02f, -1.09872602e-01f, 1.19068377e-01f, -1.29591376e-01f, 1.21697143e-01f,
  1.32467195e-01f, 3.34251113e-02f, -3.17966677e-02f, 2.58626742e-03f, -1.27242267e-01f, 4.03441004e-02f, 9.55394134e-02f, 1.29942134e-01f, 4.02719080e-02f, -1.30281016e-01f,
  -1.01668835e-01f, 3.08835842e-02f, -1.51771367e-01f, 5.62088899e-02f, 1.05845153e-01f, -1.07537113e-01f, 4.28538807e-02f, -1.47993311e-01f, 2.86350287e-02f, -5.22857066e-03f,
  -4.26839963e-02f, 1.20805137e-01f, -5.16546741e-02f, -4.56238687e-02f, 1.19074546e-01f, -1.74052119e-01f, -1.24891713e-01f, -1.07961692e-01f, -1.08558327e-01f, -8.82001221e-03f,
  1.61760837e-01f, -3.13075215e-01f, -2.33577073e-01f, 3.32511246e-01f, 1.39491722e-01f, -1.58618674e-01f, -1.32817641e-01f, -1.02895088e-01f, 2.52515003e-02f, -1.05332313e-02f,
  8.19694027e-02f, 1.26640588e-01f, 3.65978032e-02f, -4.01751585e-02f, -4.39369529e-02f, 3.28798532e-01f, 3.19593325e-02f, 1.30015448e-01f, 7.07506239e-02f, 5.77800423e-02f,
  1.20337054e-01f, 7.42476294e-03f, 1.11995237e-02f, -2.62138993e-02f, 8.06592107e-02f, -1.29348487e-01f, -1.40874563e-02f, 8.59781504e-02f, 1.66835383e-01f, 4.94451001e-02f,
  6.03574440e-02f, 2.96595134e-02f, -8.70973691e-02f, 5.60689420e-02f, -2.24567782e-02f, 6.96452036e-02f, 2.50258714e-01f, -6.89192712e-02f, -7.29357451e-02f, -5.08923307e-02f,
  5.92381954e-02f, -1.59077168e-01f, -4.53616008e-02f, 1.03622988e-01f, -2.32855901e-02f, -5.15208431e-02f, 3.66808996e-02f, 1.02555960e-01f, 9.43017676e-02f, 3.95667031e-02f,
  9.12015606e-03f, -2.66170762e-02f, 2.14734226e-02f, 1.21606760e-01f, -8.34026262e-02f, -7.96288922e-02f, -3.77252474e-02f, 1.85685679e-01f, 1.22357540e-01f, 1.58414617e-03f,
  7.19936267e-02f, 3.39410640e-02f, 1.28212258e-01f, -3.13628241e-02f, 6.79943040e-02f, -4.73326854e-02f, -1.13183402e-01f, 4.62126620e-02f, 1.27525389e-01f, -1.46948993e-01f,
  8.90479535e-02f, 3.51940244e-01f, -1.08719602e-01f, 8.94438252e-02f, 1.42236531e-01f, -6.57432945e-03f, -1.77210674e-01f, 4.61765565e-02f, -8.98726955e-02f, -6.36604205e-02f,
  -6.45178482e-02f, 9.28860456e-02f, -5.08028008e-02f, 1.99137688e-01f, -7.32790232e-02f, -4.31738347e-02f, -1.24191768e-01f, -1.12985410e-01f, -1.57543957e-01f, -1.27253056e-01f,
  6.55595958e-03f, -1.02470927e-02f, 1.19061224e-01f, 4.89752814e-02f, -1.45245269e-02f, -3.40796225e-02f, -1.14212744e-01f, 2.03626584e-02f, 2.14815736e-02f, 1.51125833e-01f,
  -9.89964679e-02f, -1.54590935e-01f, -6.62316978e-02f, 1.74702048e-01f, 5.70714064e-02f, -9.85163003e-02f, 8.52189064e-02f, 2.75186896e-02f, 1.19288880e-02f, 6.29177094e-02f,
  -5.90196215e-02f, -1.80441663e-01f, 1.28890961e-01f, -7.36023393e-03f, 7.57491365e-02f, -7.72890076e-02f, -1.09389715e-01f, 9.69288200e-02f, 6.04500659e-02f, -1.11717440e-01f,
  -7.48234568e-03f, 6.42005354e-02f, -1.23539530e-01f, -1.15048610e-01f, 1.07120804e-01f, 4.88723890e-05f, -2.16533363e-01f, 6.15427718e-02f, 2.30397090e-01f, 1.58012465e-01f,
  -4.13257964e-02f, -2.79539432e-02f, -1.80814698e-01f, 5.41341119e-02f, -1.44944459e-01f, -4.75594923e-02f, -1.38113454e-01f, -2.46058390e-01f, 2.06073254e-01f, -1.16285563e-01f,
  6.60582408e-02f, -7.09290132e-02f, 3.13928686e-02f, 6.90881237e-02f, 6.24364475e-05f, 6.22600541e-02f, 4.53080842e-03f, -3.54371697e-01f, 2.37697333e-01f, -7.06533939e-02f,
  5.68916015e-02f, 1.03726663e-01f, 8.41489360e-02f, -5.32425605e-02f, 2.21539419e-02f, 1.68868974e-01f, -3.82163655e-03f, 7.62470216e-02f, 8.17544907e-02f, -3.59371677e-02f,
  7.21231177e-02f, -6.22745790e-02f, -1.09102838e-02f, -8.83796290e-02f, 1.26142398e-01f, -8.98270980e-02f, 2.30629276e-03f, -9.75984633e-02f, -7.33200759e-02f, 7.42656887e-02f,
  2.96453647e-02f, 1.31349815e-02f, -7.77393803e-02f, -6.77583888e-02f, -1.36509389e-01f, -5.62991612e-02f, 5.19161299e-02f, 2.65296787e-01f, 3.81540358e-02f, 4.54862528e-02f,
  1.13125905e-01f, -4.52568866e-02f, 2.80177873e-02f, -4.70382012e-02f, -5.64264841e-02f, 2.38123257e-02f, -4.70982641e-02f, -1.12557933e-01f, -2.82178093e-02f, 7.59007633e-02f,
  2.15540379e-02f, -7.95046985e-02f, -1.85182020e-02f, -8.30062553e-02f, -1.04754448e-01f, -7.41893006e-03f, 7.77558098e-03f, 5.16296178e-02f, 4.79819626e-02f, -1.99199423e-01f,
  -3.23841758e-02f, -2.78076399e-02f, -3.84566113e-02f, 6.37475327e-02f, -6.13308065e-02f, -2.81218328e-02f, -1.62384406e-01f, 2.30994627e-01f, 6.68819547e-02f, -1.09486226e-02f,
  -6.93331510e-02f, 1.55852452e-01f, -7.58749526e-03f, 1.18461154e-01f, -8.63508061e-02f, 2.60410458e-02f, 7.87046030e-02f, 1.65769123e-02f, 2.07638413e-01f, 1.37186408e-01f,
  1.43144727e-02f, -9.69417393e-02f, -3.33488658e-02f, -1.03688657e-01f, -1.11364517e-02f, 1.30810905e-02f, 1.42532378e-01f, 1.05749140e-03f, 5.35742976e-02f, -2.87663564e-02f,
  -1.79248273e-01f, 3.18315253e-03f, 7.86473379e-02f, -1.20131299e-02f, 1.61795393e-01f, -1.65903598e-01f, -1.37912810e-01f, 4.91985008e-02f, 5.39479181e-02f, -1.50978297e-01f,
  -4.38287817e-02f, -2.05105525e-02f, 5.18109603e-03f, -1.08367912e-01f, 6.97175413e-02f, -1.45455688e-01f, -2.67822091e-02f, 5.36096506e-02f, 4.04293202e-02f, 7.58432150e-02f,
  -2.97101643e-02f, 1.43570304e-01f, 1.77960813e-01f, 1.00486606e-01f, 2.37502102e-02f, 3.30347801e-03f, 2.62096468e-02f, -1.12870783e-01f, -5.10899663e-01f, 1.33105949e-01f,
  -1.00001119e-01f, -6.87072799e-02f, -2.08952669e-02f, 1.28935128e-01f, -1.28228217e-01f, -9.66679528e-02f, 2.71218270e-01f, -1.11588739e-01f, 1.44151062e-01f, -1.73678383e-01f,
  -8.21408629e-02f, 3.25435579e-01f, -5.93997501e-02f, -1.75456482e-03f, -8.86191055e-03f, 3.33757192e-01f, 3.58595066e-02f, -7.97267910e-03f, -9.94448438e-02f, -5.48819453e-02f,
  -4.86868806e-02f, -1.71789210e-02f, 9.14025828e-02f, -5.83190285e-02f, -4.20966186e-02f, 5.77781303e-03f, 8.81700143e-02f, 4.45043556e-02f, -4.05171812e-02f, 8.28241855e-02f,
  1.63694710e-01f, 4.07155901e-02f, -1.68711971e-02f, -1.88449339e-03f, 8.13775882e-02f, 4.68368754e-02f, 9.39240232e-02f, 1.09779932e-01f, 2.67591048e-02f, -1.69047881e-02f,
  -2.74654496e-02f, 2.68353168e-02f, 8.72412398e-02f, -1.51419677e-02f, -6.41238759e-04f, -8.91023874e-02f, 8.07935148e-02f, 5.10121919e-02f, -3.69091667e-02f, 4.30696718e-02f,
  -2.85187121e-02f, 8.84424299e-02f, -6.95754141e-02f, -4.81262468e-02f, 2.35706475e-02f, 9.04056951e-02f, 8.94112512e-02f, 2.58934218e-02f, 4.98919701e-03f, -1.11283764e-01f,
  5.22115342e-02f, -1.10216729e-01f, 4.61745188e-02f, -1.11806296e-01f, -5.56434877e-02f, -8.27684626e-02f, -2.32624710e-02f, -1.85493410e-01f, -3.93958203e-02f, -6.09037429e-02f,
  1.36857405e-01f, 1.98978812e-01f, -1.54555827e-01f, -1.70146972e-01f, 4.44894843e-02f, -7.23506063e-02f, -1.77172914e-01f, -7.71424845e-02f, 7.20796064e-02f, 1.11411251e-02f,
  5.23465872e-02f, 1.02235883e-01f, -1.18616313e-01f, 2.92363297e-03f, -6.92163110e-02f, -8.51297900e-02f, -4.43942137e-02f, 3.09978854e-02f, -8.76215696e-02f, 3.16789113e-02f,
  2.29302764e-01f, 6.03360459e-02f, -9.75786522e-02f, 7.18886480e-02f, -3.16260941e-02f, -6.77478313e-02f, 1.76325500e-01f, 6.95641264e-02f, -3.08067445e-03f, -1.77019209e-01f,
  -1.38580978e-01f, -3.56074050e-02f, -9.46374834e-02f, 1.05505325e-01f, 3.36809382e-02f, -1.41121745e-02f, 5.77132264e-03f, -5.55297807e-02f, -1.36697084e-01f, 3.97623368e-02f,
  -2.14443877e-02f, -2.50371657e-02f, 1.76093966e-01f, -1.55931488e-02f, 3.91541310e-02f, -1.33613721e-01f, 1.10660188e-01f, -1.73594400e-01f, 2.46786252e-02f, -3.30534503e-02f,
  9.01782289e-02f, -1.62124678e-01f, -4.66233939e-02f, 7.49364570e-02f, 1.87291101e-01f, -1.93344384e-01f, 6.46497309e-02f, -9.53089669e-02f, 5.09944223e-02f, -7.98083395e-02f,
  -3.99675220e-02f, -1.75920919e-01f, 7.14782923e-02f, -6.37271032e-02f, -1.36052743e-01f, 1.20685004e-01f, -2.56235063e-01f, -1.29621010e-02f, 1.54094095e-03f, -1.50949761e-01f,
  1.40477298e-02f, 1.68406352e-01f, 6.27332404e-02f, -2.28720978e-01f, 1.48092207e-04f, -6.34995699e-02f, 7.84735233e-02f, -6.53067231e-03f, 8.14204663e-03f, 4.59389016e-02f,
  -3.48126628e-02f, 1.60714850e-01f, 3.78738227e-03f, -4.98945266e-02f, -1.10160530e-01f, 1.73907261e-02f, 8.92502740e-02f, 7.80607983e-02f, 3.64617109e-02f, -3.98180708e-02f,
  1.93575174e-02f, 5.53315431e-02f, -5.92671074e-02f, 4.43013161e-02f, 8.17984045e-02f, -4.95056622e-02f, 1.21626310e-01f, 2.22460106e-02f, -4.93855216e-02f, -9.34443846e-02f,
  2.80089267e-02f, -5.88904135e-02f, -4.92848195e-02f, -1.23796441e-01f, -5.03105558e-02f, -1.21668451e-01f, -4.00246382e-02f, -5.73525857e-03f, 6.14524558e-02f, -2.78207026e-02f,
  -2.27681082e-02f, -1.75651282e-01f, -2.91046388e-02f, 4.65743169e-02f, 5.91491796e-02f, -4.64052111e-02f, -3.76034975e-02f, -3.88010107e-02f, 2.30671559e-02f, 1.00830443e-01f,
  -4.79178056e-02f, 7.91205317e-02f, 9.08313692e-02f, -2.70437784e-02f, 1.31419124e-02f, -2.83787817e-01f, -5.92802763e-02f, -1.12128956e-02f, -1.55750718e-02f, -1.24934269e-02f,
  2.12257475e-01f, 9.48495269e-02f, 1.91925630e-01f, -3.38944420e-02f, -4.85662147e-02f, -1.44025572e-02f, -1.04739092e-01f, -1.28653869e-02f, -7.15470826e-03f, 9.30493996e-02f,
  -8.39950740e-02f, 4.49401401e-02f, 1.18440695e-01f, 6.79069832e-02f, -1.17838077e-01f, 3.42406183e-02f, -8.30279663e-02f, 4.20173034e-02f, -3.95705700e-02f, -1.98179752e-01f,
  1.56439021e-01f, -8.38934779e-02f, -1.64628103e-02f, -1.00094162e-01f, 1.75115362e-01f, 1.45967556e-02f, 4.32313129e-04f, -3.53796184e-02f, 2.13810503e-02f, -5.55538647e-02f,
  -6.68369234e-02f, -1.14901163e-01f, -1.07780382e-01f, 4.10654880e-02f, -2.07181741e-02f, 2.70318110e-02f, -8.85264426e-02f, 9.06990245e-02f, -4.81680082e-03f, 1.12685421e-02f,
  -4.09789234e-02f, -1.61164969e-01f, 1.60861611e-02f, 4.03850302e-02f, -9.05527920e-02f, 3.44218710e-03f, -1.97771072e-01f, 7.83975422e-02f, 2.07183771e-02f, 6.44261837e-02f,
  2.22356558e-01f, -1.97166234e-01f, -3.94496368e-03f, 1.27055675e-01f, 2.74465799e-01f, -1.74076557e-01f, 4.12807874e-02f, -1.38220072e-01f, 1.34607524e-01f, -5.58584882e-03f,
  -1.60325125e-01f, 8.56539458e-02f, -2.83923119e-01f, 2.34020571e-03f, 3.21055055e-02f, 2.42852524e-01f, -2.57482175e-02f, -2.36180604e-01f, -4.13811654e-02f, -1.52503595e-01f,
  -3.32592577e-02f, 1.72045782e-01f, -1.73659474e-02f, 1.51595131e-01f, -2.45959293e-02f, -1.50889635e-01f, -6.10481575e-02f, -8.66031647e-02f, 1.61755495e-02f, -5.12934523e-03f,
  8.24453831e-02f, 1.46908507e-01f, 6.83551952e-02f, 9.34373066e-02f, -8.54772106e-02f, -1.64605409e-01f, 1.89241450e-02f, 5.96488304e-02f, -2.70737782e-02f, 7.14355409e-02f,
  -2.88398005e-03f, 7.85110742e-02f, -7.47022331e-02f, -5.25873601e-02f, -2.58091427e-02f, -1.04013927e-01f, 2.27901693e-02f, -2.35718302e-02f, 1.39559200e-02f, -3.40321884e-02f,
  -5.41325891e-03f, 3.28941345e-02f, -1.69959068e-01f, -1.12928540e-01f, 8.24168175e-02f, -9.05913264e-02f, -3.73647697e-02f, 2.75411382e-02f, -3.83632667e-02f, -8.21847394e-02f,
  -3.74917686e-02f, 8.30319822e-02f, 5.55171147e-02f, -1.01070888e-01f, -5.49364872e-02f, 9.12115648e-02f, -4.89959233e-02f, -1.10612428e-02f, -1.64141301e-02f, -3.02473139e-02f,
  -7.32642636e-02f, -1.44670323e-01f, 6.27299696e-02f, 2.04692528e-01f, 5.69360144e-02f, 4.35499884e-02f, 2.76520066e-02f, -9.32543278e-02f, 1.67201281e-01f, 2.41304599e-02f,
  -3.78562547e-02f, 5.67517206e-02f, -8.63747820e-02f, 3.62675712e-02f, 7.50027373e-02f, -9.51102749e-02f, -1.28937870e-01f, -1.86212316e-01f, 6.83953166e-02f, -2.23239869e-01f,
  -1.49615288e-01f, -2.20946938e-01f, 1.51914492e-01f, 1.06927879e-01f, 2.94537633e-03f, -1.06541954e-01f, -1.31216183e-01f, 1.69603582e-02f, -2.51865406e-02f, -2.58818418e-01f,
  -5.69537431e-02f, -1.41501382e-01f, -1.21345475e-01f, -1.23690225e-01f, 1.64854482e-01f, 9.79777351e-02f, -6.27733171e-02f, 1.11635901e-01f, -8.36570039e-02f, 6.60308963e-03f,
  1.42262131e-01f, 1.21083722e-01f, 9.24699306e-02f, 4.83864509e-02f, 2.20410556e-01f, 8.15656558e-02f, -1.08445734e-01f, 1.50231570e-01f, -3.81187350e-02f, 2.70425886e-01f,
  4.61921543e-02f, -7.27562513e-03f, -1.91799536e-01f, -1.26966625e-01f, 1.86308756e-01f, -2.18379661e-01f, -1.21862799e-01f, 2.23678555e-02f, -2.23814264e-01f, 1.81772053e-01f,
  -3.17745417e-01f, 3.52931814e-03f, 2.23054081e-01f, 2.25877836e-01f, -1.16992749e-01f, 2.35022977e-02f, -3.16696852e-01f, 1.82643041e-01f, 4.22939360e-02f, 5.56782000e-02f,
  -2.08954494e-02f, 5.68839833e-02f, 6.12006523e-02f, 1.74130164e-02f, 9.46871638e-02f, -1.48816705e-01f, -1.83378551e-02f, 2.08943725e-01f, -6.93596667e-03f, -4.41876799e-01f,
  -1.45679936e-02f, 1.28812671e-01f, 9.68304276e-02f, 3.52874734e-02f, -1.33034080e-01f, 5.46175009e-03f, -6.90535456e-02f, 1.63020611e-01f, 6.90305308e-02f, -3.84313241e-03f,
  -7.61147290e-02f, 7.30985999e-02f, 9.28283259e-02f, -4.94391955e-02f, 5.31230420e-02f, 8.51429775e-02f, 1.01847209e-01f, -7.37883374e-02f, -1.32378697e-01f, 7.98158720e-02f,
  1.18761733e-01f, -1.80890173e-01f, -2.32386906e-02f, 2.33572964e-02f, 9.04841051e-02f, -2.16986444e-02f, -4.45054732e-02f, -6.71138689e-02f, 8.78956988e-02f, -1.58523113e-01f,
  -9.40150321e-02f, 5.36701232e-02f, -4.16391809e-03f, -4.15371470e-02f, -3.71590033e-02f, -3.51138748e-02f, 1.76806503e-03f, 1.56720970e-02f, -1.38881296e-01f, -2.23782994e-02f,
  9.57801566e-02f, 3.86081897e-02f, -2.96578795e-01f, 1.27306674e-02f, 6.31893352e-02f, -1.29891828e-01f, -1.18140973e-01f, 4.45533060e-02f, 5.04345726e-03f, -1.66067053e-02f,
  -3.48879062e-02f, -1.27655596e-01f, 8.45737457e-02f, -4.82312404e-02f, -1.08049303e-01f, -1.05448954e-01f, 9.55740064e-02f, 7.44903758e-02f, -8.57423171e-02f, 5.62710725e-02f,
  1.56932250e-02f, -4.33472544e-02f, -5.24601750e-02f, 3.13459672e-02f, -1.88658219e-02f, 3.24826054e-02f, 4.65223677e-02f, 6.25384897e-02f, 7.36078806e-03f, 5.87182567e-02f,
  7.05264509e-02f, -3.85304987e-02f, 1.85384840e-01f, -2.14038100e-02f, 2.20248625e-02f, 5.14033586e-02f, 6.11468963e-02f, -8.96833912e-02f, 1.21664377e-02f, -1.06650762e-01f,
  1.86872929e-02f, 3.47597487e-02f, -1.46529973e-01f, 2.87827440e-02f, 9.08921808e-02f, 6.09558001e-02f, -7.20455125e-02f, -8.51485729e-02f, -3.47468816e-02f, 9.97890532e-02f,
  2.77774110e-02f, -6.57130405e-02f, 3.31048369e-01f, 2.78034769e-02f, -6.61143009e-03f, 5.98505251e-02f, -1.74287632e-01f, -1.72958985e-01f, -1.92585383e-02f, 1.44649753e-02f,
  -3.81095521e-02f, -5.77192754e-02f, -1.00130357e-01f, 6.04181588e-02f, -6.52734283e-03f, 2.61895865e-01f, 3.14189796e-03f, -1.90144926e-01f, -3.28511633e-02f, 1.99316386e-02f,
  -2.06747398e-01f, -7.29920715e-02f, -9.26972181e-03f, -2.08212197e-01f, 2.58162558e-01f, 1.59762666e-01f, -2.11020447e-02f, 1.20162904e-01f, -2.32036728e-02f, -2.33579762e-02f,
  2.92938530e-01f, 3.09873726e-02f, -1.62614897e-01f, 3.48994344e-01f, 5.66620147e-03f, -3.67922559e-02f, -1.93770900e-02f, -3.17428471e-03f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  1.08237632e-01f, 6.32124841e-02f, 8.68333951e-02f, 1.11845043e-02f, 1.67218029e-01f, 1.28180876e-01f, 4.44733836e-02f, 1.50332958e-01f, -2.43574521e-03f, 1.19201988e-01f,
  -3.40439118e-02f, -5.47120720e-02f, 1.42131016e-01f, -7.56254047e-02f, 4.19455953e-02f, 2.25139067e-01f, 5.54650351e-02f, 9.03645381e-02f, 5.93650304e-02f, 1.33031353e-01f,
  4.13316153e-02f, 1.29714444e-01f, 1.53357342e-01f, 1.83764294e-01f, 1.80138588e-01f, 7.73734227e-02f, 8.82181153e-02f, 2.31954545e-01f, 1.32265165e-01f, 1.78206787e-01f,
  1.12664275e-01f, 1.50923312e-01f, 1.48826972e-01f, 6.58474863e-02f, -1.28709033e-01f, -1.36631532e-02f, 5.47804162e-02f, 1.67343676e-01f, 3.28527153e-01f, 1.93366170e-01f,
  2.44224742e-02f, 1.32117078e-01f, 2.76518375e-01f, 2.70179752e-02f, 4.14767042e-02f, 1.17864341e-01f, 2.39950001e-01f, 6.40390068e-02f, 1.69310927e-01f, -9.09901783e-02f,
  2.45223604e-02f, 2.11403936e-01f, -1.60532787e-01f, 3.82555462e-02f, 3.62244993e-02f, 2.15411544e-01f, 1.05253041e-01f, -7.22432509e-02f, -4.26983908e-02f, 2.69982517e-01f,
  -1.44122660e-01f, 5.29697239e-02f, -1.36612579e-01f, -4.09487933e-02f, -7.71189108e-02f, 1.03573263e-01f, -1.08329684e-01f, 2.42757201e-02f, -2.56748021e-01f, -1.69028625e-01f,
  1.18868075e-01f, 2.43411466e-01f, -2.24982738e-01f, -3.62572558e-02f, -2.49165118e-01f, -7.13677555e-02f, -8.95839706e-02f, 2.35620171e-01f, 1.66156807e-03f, 4.60949987e-02f,
  -1.88011363e-01f, 5.19360155e-02f, 1.66470855e-02f, -6.36961088e-02f, -1.98765084e-01f, 1.29944626e-02f, 3.50564755e-02f, 1.24147080e-01f, -4.69181389e-02f, 1.32741883e-01f,
  1.15460828e-01f, 4.14816961e-02f, -6.16770471e-03f, 5.13755269e-02f, -1.64830804e-01f, 9.09477174e-02f, -9.68236551e-02f, 4.68584925e-01f, 2.26015132e-02f, -8.11618418e-02f,
  -1.33250833e-01f, -1.42180279e-01f, 1.05142884e-01f, -8.85465220e-02f, 8.63132179e-02f, 8.38140249e-02f, -3.42547223e-02f, 1.80814534e-01f, -4.43082117e-02f, -7.06978142e-02f,
  1.28044039e-01f, 3.41790259e-01f, -2.17692181e-01f, 1.23140790e-01f, -2.96792597e-01f, 1.84610233e-01f, -6.60357997e-02f, -2.41699263e-01f, 2.31234446e-01f, -3.20087790e-01f,
  2.41012737e-01f, -1.72957391e-01f, 1.89071447e-02f, 9.52779725e-02f, 5.57604805e-02f, 2.06209756e-02f, -3.44736166e-02f, -2.46292979e-01f, 2.27925569e-01f, 6.80284798e-02f,
  1.12206936e-01f, 1.83154389e-01f, 2.27803171e-01f, 5.92420772e-02f, -6.18250556e-02f, 1.42459974e-01f, 1.89787522e-02f, 1.87393010e-01f, 4.99363951e-02f, 5.89186151e-04f,
  1.03802450e-01f, 2.14480549e-01f, 8.49482566e-02f, 1.35782912e-01f, -1.81072373e-02f, 1.67331114e-01f, -2.78945416e-02f, 8.98166150e-02f, 3.69277857e-02f, 5.31604141e-02f,
  9.54470262e-02f, 1.33853048e-01f, 6.38386160e-02f, 1.60181358e-01f, 1.20082395e-02f, 1.50682136e-01f, 6.53873459e-02f, 1.99020356e-01f, 1.89403445e-01f, 1.55445546e-01f,
  4.92601357e-02f, 3.32002431e-01f, 2.54491419e-01f, 8.92192312e-03f, 1.26019925e-01f, 1.97891027e-01f, 2.11249888e-01f, 7.89296180e-02f, 9.34473127e-02f, 5.68916760e-02f,
  1.47362471e-01f, 6.74107224e-02f, 1.03992425e-01f, 2.29119331e-01f, 4.74068262e-02f, 5.43564707e-02f, 1.21519342e-02f, -1.03126220e-01f, 1.78060845e-01f, -7.90637825e-03f,
  -5.96661270e-02f, -5.04943468e-02f, -3.26279067e-02f, 2.48872563e-01f, 6.86614262e-03f, -1.95651446e-02f, 1.86400950e-01f, -1.39833897e-01f, -7.24815428e-02f, 7.47818053e-02f,
  2.26378769e-01f, -4.18455452e-02f, 3.86127941e-02f, 2.95134366e-01f, -5.79033904e-02f, -2.86105692e-01f, -5.08352928e-02f, 1.49326324e-02f, -6.47698119e-02f, -6.76041543e-02f,
  -2.66424846e-03f, 1.62583366e-01f, -1.07748479e-01f, -1.03132829e-01f, 2.22554780e-03f, -1.75882921e-01f, -2.09802315e-01f, -1.93468720e-01f, 1.83758438e-01f, 4.20231745e-02f,
  -1.17111176e-01f, 9.46692973e-02f, -1.11262739e-01f, -2.46073138e-02f, -1.38929129e-01f, 7.59993047e-02f, 1.22930214e-01f, 1.48979500e-02f, -1.30844712e-01f, -1.83550343e-01f,
  -1.55630827e-01f, 6.39471486e-02f, 1.36367036e-02f, -2.19135862e-02f, 6.56315014e-02f, -1.17250413e-01f, -5.85211553e-02f, 5.60343936e-02f, 2.63457410e-02f, 6.44468218e-02f,
  9.54678580e-02f, -3.49194437e-01f, 7.22710341e-02f, -2.36996841e-02f, 3.98237556e-02f, 2.44103596e-01f, 6.86817408e-01f, 1.95821319e-02f, 4.98971075e-01f, -7.40905032e-02f,
  -3.31629366e-02f, 2.62581497e-01f, -1.29494965e-01f, -6.03068694e-02f, -2.26783782e-01f, 8.11223537e-02f, -3.07824790e-01f, -7.76039287e-02f, -1.66585311e-01f, 3.32145840e-01f,
  4.96529490e-02f, -3.65607828e-01f, -1.96676716e-01f, 1.89553536e-02f, 1.23827472e-01f, -1.94656953e-01f, 6.65365383e-02f, 3.82953398e-02f, -1.95332319e-02f, -1.66436806e-01f,
  -4.22957502e-02f, -5.00719622e-02f, -4.84827645e-02f, 1.54391944e-01f, 6.00039288e-02f, 5.40000312e-02f, 9.49258078e-03f, 5.97030856e-04f, -7.87919573e-03f, 1.73520818e-01f,
  -3.37885804e-02f, 2.25750402e-01f, -7.23910704e-02f, 8.03646594e-02f, -1.47140607e-01f, 1.56286180e-01f, 1.00692280e-01f, -1.38771862e-01f, 3.38399713e-03f, 1.32799581e-01f,
  1.13107994e-01f, 2.88087036e-02f, 1.31844774e-01f, 1.12396523e-01f, 7.25522414e-02f, 1.60858810e-01f, 1.35086432e-01f, 1.64489985e-01f, 5.79581782e-02f, 1.06858701e-01f,
  1.11031299e-02f, 2.34906211e-01f, 4.51675653e-02f, 7.85544962e-02f, 1.40167207e-01f, 1.16862334e-01f, 7.88561851e-02f, 2.58755118e-01f, 4.02877219e-02f, 1.04378261e-01f,
  1.56697594e-02f, -4.01314348e-02f, -8.83724913e-02f, 1.39200047e-01f, 6.74321055e-02f, -1.90165624e-01f, -3.48249301e-02f, -9.21631455e-02f, -1.76534187e-02f, -1.06901966e-01f,
  -8.12842846e-02f, 9.63363145e-03f, 9.23770890e-02f, 4.66897478e-03f, 3.66748124e-02f, 1.06304228e-01f, 8.10764208e-02f, -1.40267253e-01f, -1.22624692e-02f, 1.16935827e-01f,
  -1.24410138e-01f, 8.42680484e-02f, 1.18610732e-01f, -7.25679472e-02f, 3.37145920e-03f, -8.79674498e-03f, 1.01150043e-01f, 3.75835598e-02f, 2.30808556e-01f, -9.66779739e-02f,
  3.47634554e-02f, -7.85730854e-02f, 3.12125888e-02f, 1.36367992e-01f, -1.03366328e-02f, -4.74710986e-02f, -1.61004499e-01f, -8.93172845e-02f, 1.19250558e-01f, 9.75586846e-02f,
  6.01361915e-02f, -3.99249718e-02f, 7.21465871e-02f, -6.97542503e-02f, -1.56911016e-01f, 4.18785140e-02f, 3.70621346e-02f, 8.27977657e-02f, 5.33639453e-02f, 2.05016844e-02f,
  9.30907112e-03f, 1.27116174e-01f, -3.15372907e-02f, 1.44259274e-01f, 1.72960088e-01f, 5.41140176e-02f, -2.39565894e-02f, 9.31581762e-03f, -8.08699206e-02f, -5.89335896e-02f,
  -5.20785637e-02f, 3.94649565e-01f, 4.81331982e-02f, 4.19277959e-02f, -2.98622578e-01f, 3.21883619e-01f, 7.20439702e-02f, -1.06037125e-01f, -2.38208681e-01f, -1.63026899e-01f,
  1.06403202e-01f, 6.14242673e-01f, 8.05290118e-02f, -6.44744560e-02f, 1.43213540e-01f, -2.35933792e-02f, 2.54613698e-01f, 7.58390203e-02f, -8.63172580e-03f, 3.74565601e-01f,
  1.05642065e-01f, 5.99048436e-02f, -1.93251953e-01f, -8.36371258e-02f, -4.18341793e-02f, 1.74781635e-01f, -3.20100375e-02f, 4.94205207e-02f, 9.94007289e-02f, 2.57780373e-01f,
  7.69843906e-02f, 1.58148393e-01f, 1.38386309e-01f, 1.46986052e-01f, -6.01787157e-02f, 1.15863882e-01f, 1.97089061e-01f, 1.64709970e-01f, 2.08663926e-01f, 2.46540740e-01f,
  5.34116253e-02f, 1.20470352e-01f, -7.15489760e-02f, 3.74508612e-02f, 4.41414341e-02f, 5.78460805e-02f, 4.37305681e-02f, -7.03176484e-03f, 8.60841349e-02f, 6.71749637e-02f,
  1.21256195e-01f, 4.05897154e-03f, 1.30721688e-01f, -1.08960800e-01f, -7.81620666e-02f, 1.92123488e-01f, 2.30530985e-02f, 1.21416517e-01f, -2.00693868e-02f, 1.58102468e-01f,
  1.12051226e-01f, 1.41646247e-03f, 8.91330764e-02f, 8.69729146e-02f, -3.21178213e-02f, 5.51775433e-02f, 9.07201041e-03f, -1.19690992e-01f, 4.85597849e-02f, 1.25047997e-01f,
  6.19450621e-02f, 1.15622066e-01f, 2.90196743e-02f, -1.33972466e-02f, 6.48269430e-02f, 1.48877665e-01f, 2.43333206e-02f, 7.60422423e-02f, 2.20580637e-01f, -1.43094555e-01f,
  -2.60056466e-01f, 1.62672773e-01f, -6.44827783e-02f, 2.25404911e-02f, -7.48489052e-02f, -1.12336993e-01f, -5.39089069e-02f, -4.83663119e-02f, 1.97560370e-01f, -1.39245361e-01f,
  -1.08935356e-01f, 3.57354842e-02f, -1.20257258e-01f, -6.10147715e-02f, -8.56103674e-02f, -1.87547103e-01f, 1.32872134e-01f, -9.30548273e-03f, 2.38457516e-01f, 1.44570187e-01f,
  4.42627631e-02f, -2.41860792e-01f, -1.71503574e-01f, 9.12683457e-03f, 8.98051932e-02f, -4.93964031e-02f, -1.54014602e-01f, -7.16733485e-02f, -2.09729169e-02f, 3.57583240e-02f,
  1.81259319e-01f, -7.33139366e-02f, 9.79509428e-02f, 1.08564021e-02f, 2.34411031e-01f, -1.26988679e-01f, 1.92260042e-01f, 6.87752515e-02f, 7.35439453e-03f, -1.36895195e-01f,
  -6.58769831e-02f, -1.96361654e-02f, -1.50907869e-02f, 1.23920545e-01f, 5.73437512e-02f, -5.77636994e-02f, -3.05080175e-01f, 2.95799911e-01f, -2.97806740e-01f, -1.72426589e-02f,
  -9.64637175e-02f, -2.00772554e-01f, 1.96418449e-01f, 3.46367180e-01f, -4.31963317e-02f, -4.66172040e-01f, -1.64766490e-01f, 4.13666189e-01f, 7.93298364e-01f, 8.39416087e-02f,
  1.19442336e-01f, 6.61184117e-02f, 5.29413104e-01f, 5.54440822e-03f, 3.45479175e-02f, 1.86120644e-01f, 1.51445165e-01f, 3.85158449e-01f, 1.59127951e-01f, -6.95231035e-02f,
  -5.09707034e-02f, -1.03459552e-01f, 7.50651434e-02f, -6.69645816e-02f, 1.86764434e-01f, 1.64489821e-01f, -3.96089330e-02f, -7.27279261e-02f, -9.25582275e-02f, -1.26794487e-01f,
  -2.62164455e-02f, 3.24188732e-02f, -6.62496686e-02f, -9.34724044e-03f, -7.09492043e-02f, -1.05591593e-02f, -8.51445198e-02f, -7.01693296e-02f, 5.21122403e-02f, 4.66605425e-02f,
  1.08144522e-01f, -1.39728934e-01f, -1.20520331e-01f, -3.89684699e-02f, 1.08709128e-03f, -1.00697234e-01f, -2.69300994e-02f, 1.81067109e-01f, -2.34132454e-01f, -6.34149015e-02f,
  -2.93784961e-02f, 1.12356752e-01f, -5.28153107e-02f, 7.52685443e-02f, 3.08088027e-02f, -3.39792147e-02f, -1.04321111e-02f, -9.27674249e-02f, 4.26624678e-02f, 9.26295072e-02f,
  -1.10147232e-02f, -1.13747284e-01f, -2.06109121e-01f, -3.94593626e-02f, -1.43485591e-01f, -1.27550691e-01f, 1.90549158e-02f, -1.93233773e-01f, 6.70811087e-02f, -1.57221764e-01f,
  -3.72797549e-02f, -2.39490345e-01f, -4.87425216e-02f, 1.36699378e-01f, 1.41082585e-01f, 1.29051907e-02f, -3.13034989e-02f, 8.78051971e-04f, 2.83533543e-01f, -1.57268289e-02f,
  -1.46334872e-01f, -1.01863317e-01f, 3.08731794e-01f, -7.45235085e-02f, 6.56208843e-02f, 8.13577622e-02f, -1.82532772e-01f, -2.64149392e-03f, 1.94531143e-01f, 5.57653792e-02f,
  8.39845538e-02f, -2.56289274e-01f, 2.00171858e-01f, -1.00867026e-01f, 8.34357589e-02f, 5.29936776e-02f, -7.16829672e-02f, -1.47057116e-01f, 7.60363340e-02f, -1.35881126e-01f,
  4.68857260e-03f, 1.51046857e-01f, -1.97547913e-01f, 1.49830490e-01f, 4.25176211e-02f, -2.10435074e-02f, -1.14188315e-02f, -1.89222187e-01f, 5.50478920e-02f, 5.35755344e-02f,
  9.09831002e-02f, -1.06348004e-02f, -3.52808803e-01f, 1.69745088e-02f, 1.49320200e-01f, 5.42424386e-03f, 1.91762671e-01f, -9.04474705e-02f, -4.46794666e-02f, 7.12686917e-03f,
  -1.24949366e-01f, 2.11482733e-01f, -9.83749554e-02f, -7.80452341e-02f, 2.78943390e-01f, -4.02209647e-02f, 4.16613407e-02f, -2.83661276e-01f, 1.11245036e-01f, -9.49161220e-03f,
  8.65515396e-02f, -3.17072719e-02f, 1.68473586e-01f, 2.08528295e-01f, 4.13815111e-01f, 3.82828146e-01f, -5.87506816e-02f, -4.67355922e-02f, 2.29385093e-01f, 4.47406441e-01f,
  -4.10955280e-01f, 1.32810012e-01f, 4.36561331e-02f, -8.98972601e-02f, 2.87568480e-01f, 7.66283795e-02f, -1.03574090e-01f, -6.25549704e-02f, -1.01154484e-02f, 2.07119122e-01f,
  2.48350456e-01f, 5.91891743e-02f, -5.20736165e-02f, 4.84315902e-02f, 6.72897696e-02f, 2.50048816e-01f, 8.39563645e-03f, 2.45449767e-01f, 3.15293819e-01f, 7.55630955e-02f,
  9.16644558e-02f, 1.96371377e-01f, 1.07773021e-01f, 1.89995512e-01f, 2.51712322e-01f, 1.67620257e-01f, 1.47621930e-01f, 1.09671457e-02f, -5.07958271e-02f, 1.62699714e-01f,
  2.63945013e-01f, 9.43402052e-02f, 1.13847993e-01f, 1.14710763e-01f, 2.54994392e-01f, -3.41187231e-02f, 1.61973417e-01f, 6.37214109e-02f, 1.86950341e-01f, 5.77779859e-03f,
  1.88277513e-02f, 7.91800544e-02f, 2.63822321e-02f, 2.62251854e-01f, -5.19659221e-02f, 1.10533386e-01f, 7.84417242e-02f, 1.04783379e-01f, 1.45096898e-01f, 1.36546493e-01f,
  2.20829651e-01f, 2.69802362e-01f, -1.89349905e-01f, -1.24196603e-03f, -1.12739066e-03f, 1.37506574e-01f, 1.69613540e-01f, 2.24039003e-01f, 1.34690940e-01f, -5.56305833e-02f,
  -5.93341477e-02f, -1.41575813e-01f, -1.33352891e-01f, -6.84787333e-02f, -1.08613417e-01f, -1.66186795e-01f, 3.45069557e-01f, 1.43107608e-01f, 2.24017024e-01f, -1.29677862e-01f,
  -7.23934025e-02f, -1.14416610e-02f, -8.95332396e-02f, -1.44255385e-02f, -1.33973183e-02f, 2.90100370e-02f, 8.32006633e-02f, -1.03234880e-01f, 1.11067668e-01f, 1.35814145e-01f,
  -1.88031718e-02f, -1.05173532e-02f, 9.69636068e-02f, -2.55350377e-02f, -9.23504382e-02f, 1.05478361e-01f, -2.62042731e-02f, -2.67754197e-01f, -1.43201649e-01f, -2.61563838e-01f,
  1.14453003e-01f, -5.63341714e-02f, -1.63719773e-01f, -1.03035577e-01f, 1.83114693e-01f, -2.18404293e-01f, -7.91144297e-02f, -1.57176107e-01f, -1.52213454e-01f, -9.69757438e-02f,
  1.54845014e-01f, 5.89706115e-02f, -8.14270899e-02f, 3.20466645e-02f, -4.73984592e-02f, 1.51816994e-01f, -2.82284059e-02f, -1.04642592e-01f, 8.94767940e-02f, -1.95029959e-01f,
  -2.69196391e-01f, 6.36762157e-02f, -2.01465994e-01f, 2.76778460e-01f, -2.57543405e-03f, 2.69583941e-01f, 3.97319317e-01f, -1.70555353e-01f, -1.79601952e-01f, 2.24212855e-01f,
  9.91897821e-01f, -1.58934399e-01f, 1.43405810e-01f, -2.63779938e-01f, 4.13584620e-01f, 4.08320338e-01f, -4.60561439e-02f, 1.96599618e-01f, -2.00150385e-01f, -1.20076478e-01f,
  4.72024292e-01f, 2.90298462e-01f, -4.48482297e-02f, 2.43822336e-01f, -7.75996149e-02f, -1.90048844e-01f, -3.34382243e-02f, 2.61403382e-01f, 6.45407066e-02f, -9.93698910e-02f,
  7.03756511e-02f, 1.03941582e-01f, 2.54347771e-02f, 1.96985528e-01f, 1.49646744e-01f, -6.75413907e-02f, 4.69670892e-02f, 8.51898417e-02f, 2.94273738e-02f, 5.06011844e-02f,
  1.58845291e-01f, 5.72493002e-02f, 4.71325777e-02f, 4.32510637e-02f, 1.63800105e-01f, 2.05104910e-02f, 8.28415826e-02f, 1.19669028e-01f, 2.10740473e-02f, -8.09497237e-02f,
  -1.58391241e-02f, 1.15792744e-01f, 7.82160833e-02f, -3.74912843e-02f, -3.51828448e-02f, 6.40718639e-02f, 9.13413167e-02f, 6.82896376e-02f, 1.24633320e-01f, -1.93375777e-02f,
  -5.10680713e-02f, -1.70257390e-01f, 1.74160689e-01f, 1.30882159e-01f, 5.83538860e-02f, 1.33000791e-01f, -3.07363421e-02f, -6.36567026e-02f, 5.03422543e-02f, 9.02660936e-03f,
  6.54161125e-02f, 6.31509274e-02f, 9.14790556e-02f, 6.99094832e-02f, 1.72486007e-01f, 1.59521341e-01f, 5.91114312e-02f, -5.82242347e-02f, 5.61945289e-02f, 9.33398977e-02f,
  1.88449621e-01f, -3.37508395e-02f, 7.01438561e-02f, -1.67948157e-01f, 1.43112158e-02f, 1.37224989e-02f, -9.87865403e-02f, -1.41895562e-01f, 2.36609176e-01f, 2.41107773e-02f,
  1.11188136e-01f, 1.67516217e-01f, -1.42256469e-01f, 3.59836221e-02f, 8.30804557e-02f, -9.70612317e-02f, 6.27566576e-02f, 4.95579988e-02f, -1.65475413e-01f, -3.23608816e-01f,
  2.48587698e-01f, 1.11929402e-01f, -1.58561282e-02f, 2.35396206e-01f, -6.15901966e-03f, -1.58401638e-01f, 6.29444569e-02f, 1.86909497e-01f, -6.76036254e-02f, 1.10520303e-01f,
  -1.02320924e-01f, 2.74134487e-01f, 2.87387997e-01f, 1.95069805e-01f, 3.20503637e-02f, 3.15469056e-02f, -1.21061122e-02f, -9.08880010e-02f, -2.75150836e-01f, -6.88773766e-02f,
  3.59707505e-01f, -7.78276771e-02f, 1.70308292e-01f, -1.08701482e-01f, 2.14063138e-01f, -2.21738964e-01f, 1.91396177e-02f, 1.53073901e-02f, 1.37099653e-01f, 2.02093333e-01f,
  1.41658699e-02f, -1.22001715e-01f, -2.28412393e-02f, -7.33347908e-02f, -8.13775659e-02f, -1.95473898e-02f, 5.08122265e-01f, -1.95356575e-03f, 4.24809828e-02f, 2.06123921e-03f,
  1.73831597e-01f, 1.61383092e-01f, 3.03222477e-01f, -9.88619253e-02f, -4.85330485e-02f, -1.29933864e-01f, -2.92761505e-01f, 1.11914098e-01f, -2.71337945e-02f, -1.70086160e-01f,
  -7.37981200e-02f, 2.25434721e-01f, 4.57241945e-02f, 1.88103259e-01f, 1.72792152e-01f, 7.28699267e-02f, 2.24474329e-03f, -1.92550046e-03f, -1.62797188e-03f, -2.42786352e-02f,
  1.80184525e-02f, 8.35526660e-02f, 1.19659141e-01f, -2.37613156e-01f, -1.17564211e-02f, -3.26074697e-02f, 2.89807972e-02f, 1.19726375e-01f, 1.56593353e-01f, -4.09579165e-02f,
  1.48853928e-01f, -1.35248685e-02f, 1.89780101e-01f, -7.37567320e-02f, 1.38465509e-01f, 9.55218747e-02f, 7.06157759e-02f, 4.75854566e-03f, 9.32766348e-02f, 6.13727532e-02f,
  6.18712232e-02f, -1.18091315e-01f, -7.30989650e-02f, 1.56671461e-02f, -5.72102070e-02f, -2.06843801e-02f, -2.10421830e-01f, 5.87476045e-02f, -5.69105893e-02f, 7.82650560e-02f,
  -1.88296568e-02f, 6.88073114e-02f, -1.25796264e-02f, 5.46169393e-02f, 3.16106677e-02f, -2.13965792e-02f, 8.71304702e-03f, 1.73052715e-03f, 2.99032824e-03f, 4.11251932e-02f,
  1.73382208e-01f, 7.86174461e-02f, 8.53948593e-02f, -2.96407882e-02f, 6.24649078e-02f, -1.17424347e-01f, 6.92394599e-02f, 2.23476350e-01f, 1.39064640e-01f, 1.91639867e-02f,
  2.22171307e-01f, -7.26572424e-02f, -9.85996947e-02f, -2.12398022e-01f, -1.13764502e-01f, -4.37922552e-02f, -4.71092537e-02f, 6.73526078e-02f, 1.48012161e-01f, 1.49852127e-01f,
  -1.40841886e-01f, 9.91311222e-02f, 5.34330308e-02f, 8.65567476e-02f, -7.66155198e-02f, -2.82942772e-01f, -4.83304411e-02f, -8.24448243e-02f, -2.02281952e-01f, 4.42465302e-03f,
  1.08294658e-01f, 1.14764944e-02f, 2.13860244e-01f, -9.72907171e-02f, 1.02612339e-01f, 1.82623360e-02f, -2.19114438e-01f, -5.74022420e-02f, 1.13295004e-01f, -8.94496590e-02f,
  -2.84410603e-02f, 1.12750553e-01f, -9.88998488e-02f, 6.64035380e-02f, 1.89195260e-01f, 1.37496501e-01f, 1.36210144e-01f, -1.94687590e-01f, 1.15831427e-01f, -2.07926527e-01f,
  6.34730831e-02f, 1.34509467e-02f, 1.65683664e-02f, 2.75541157e-01f, 4.51543964e-02f, -5.04896566e-02f, 2.40341917e-01f, -2.03490704e-01f, 1.29117012e-01f, -9.89718884e-02f,
  -1.80446059e-01f, 4.15008403e-02f, -1.60298124e-01f, -9.61226076e-02f, 5.89064397e-02f, 3.00532937e-01f, -4.16350305e-01f, 2.73400098e-01f, 3.56928796e-01f, 2.20050171e-01f,
  -5.23948848e-01f, -2.14170322e-01f, 2.09247723e-01f, -9.66851264e-02f, 3.31889004e-01f, 1.39267460e-01f, -3.50786299e-01f, -3.33406150e-01f, 2.08779886e-01f, 1.90654155e-02f,
  2.95739651e-01f, 2.85234153e-02f, -1.82348847e-01f, 1.82675213e-01f, -9.06184539e-02f, 1.70664191e-02f, -1.05489187e-01f, -2.36578528e-02f, -6.05305433e-02f, 6.21352494e-02f,
  -1.16918430e-01f, 9.36117172e-02f, 1.00335911e-01f, 3.60695720e-02f, -3.44859660e-02f, -3.44617628e-02f, 4.31018285e-02f, 8.81327223e-03f, 5.75208478e-02f, -2.60908194e-02f,
  -1.37023389e-01f, 1.73936486e-02f, 4.51909788e-02f, 5.97281978e-02f, 9.95691121e-02f, 1.16321452e-01f, -3.06321103e-02f, -5.23870625e-02f, 3.61780822e-02f, -3.83051410e-02f,
  1.20473236e-01f, 1.17255589e-02f, 1.47129735e-02f, -1.63609192e-01f, 6.90464452e-02f, 7.66356438e-02f, 1.96948107e-02f, 1.81386486e-01f, -6.15414791e-02f, -2.87135597e-02f,
  8.61004442e-02f, -7.74500668e-02f, -5.02926409e-02f, -6.47213459e-02f, -1.09954447e-01f, 1.66930743e-02f, -9.60276276e-02f, 1.21287726e-01f, 5.26425019e-02f, 8.99072662e-02f,
  4.92923297e-02f, -2.22415738e-02f, 1.73378401e-02f, -2.34493054e-02f, -8.99979696e-02f, 1.03257872e-01f, 3.53528969e-02f, 6.09662384e-02f, -2.69536134e-02f, -1.12134010e-01f,
  -1.41205877e-01f, 1.84569269e-01f, 1.00127980e-02f, -1.03345394e-01f, -4.30516154e-02f, -6.01677001e-02f, -3.90960723e-02f, -1.60633624e-01f, 9.30733681e-02f, -8.17887187e-02f,
  -1.10070989e-01f, 4.53756489e-02f, 7.34535009e-02f, 1.99683048e-02f, -9.58369747e-02f, -1.20979687e-02f, 2.73768120e-02f, 1.48363531e-01f, 1.16514049e-01f, -6.12343773e-02f,
  -1.26603931e-01f, -1.81816459e-01f, -5.71565293e-02f, -7.45596513e-02f, 5.05913869e-02f, -1.47920236e-01f, -7.09659755e-02f, -5.66359535e-02f, -1.30707160e-01f, -1.58672109e-02f,
  7.29554668e-02f, -1.10473521e-01f, -5.14702946e-02f, 3.18518691e-02f, 2.46029258e-01f, -4.55645695e-02f, -1.22697197e-01f, 9.70593095e-02f, -5.06977811e-02f, -6.44554421e-02f,
  1.04287276e-02f, -1.56266287e-01f, -1.51157156e-02f, -9.53383073e-02f, -4.19010557e-02f, -1.50988638e-01f, -2.58923080e-02f, 3.34116429e-01f, -1.52110651e-01f, -2.07554661e-02f,
  1.47903204e-01f, -3.30875330e-02f, -6.61421865e-02f, 1.03821903e-01f, 2.87143379e-01f, -4.17865902e-01f, -8.35238770e-02f, 1.51118606e-01f, 5.03930807e-01f, 1.77938461e-01f,
  9.18849185e-02f, 2.23173693e-01f, 2.97267169e-01f, 6.43279031e-02f, 1.42263561e-01f, 2.13934973e-01f, 2.63274699e-01f, 3.69983166e-01f, -2.68483814e-02f, 3.78945172e-02f,
  -3.01647969e-02f, -4.05618586e-02f, 1.53605610e-01f, 3.24299224e-02f, 2.00906724e-01f, 2.30438814e-01f, 1.04197860e-01f, 1.65410265e-01f, 1.84728757e-01f, 1.32050142e-01f,
  7.72498325e-02f, 1.11304089e-01f, -3.98546234e-02f, 4.91816029e-02f, -2.42549088e-02f, 7.17514008e-02f, -1.41487680e-02f, 1.18096080e-02f, 9.94956493e-02f, 6.41549602e-02f,
  1.20873146e-01f, 1.92085221e-01f, 3.65203880e-02f, -8.76827687e-02f, 1.34903304e-02f, 1.14810921e-01f, 1.28277168e-01f, -1.08710051e-01f, 1.27404511e-01f, 2.55171712e-02f,
  3.69535759e-02f, 1.93128526e-01f, 1.85922831e-01f, 2.68522333e-02f, -8.31463858e-02f, -3.25050727e-02f, 8.61720368e-02f, 1.46339864e-01f, 2.61904508e-01f, 2.09860295e-01f,
  1.57837093e-01f, -6.03646860e-02f, 2.37176828e-02f, 9.47345123e-02f, -8.43197778e-02f, 1.30564943e-01f, 8.69192183e-02f, 7.31705576e-02f, 8.24713707e-02f, 1.97161824e-01f,
  9.64999944e-02f, -2.92116981e-02f, 1.82614997e-02f, 6.37112632e-02f, 1.45479187e-01f, -8.19330439e-02f, -9.28089768e-02f, 1.26594588e-01f, -1.52514977e-02f, -2.54515968e-02f,
  -1.21673770e-01f, 1.08404882e-01f, 2.57512689e-01f, -3.65245081e-02f, -5.02251387e-02f, 2.96823651e-01f, 4.07885350e-02f, -4.38192151e-02f, 3.34947646e-01f, -8.84099901e-02f,
  -2.60800011e-02f, -4.94801141e-02f, 8.50103330e-03f, -2.21020654e-01f, 3.77969384e-01f, 1.26947016e-01f, -2.34204292e-01f, 1.46891770e-03f, -2.59563532e-02f, 1.47614442e-02f,
  1.80387124e-01f, 1.89852454e-02f, -3.62364054e-01f, 6.21645115e-02f, 3.79562639e-02f, 2.74724483e-01f, 2.82955229e-01f, 1.69486731e-01f, 6.94577694e-02f, -1.22551598e-01f,
  -1.01605020e-01f, 5.27801923e-03f, -4.37840611e-01f, 8.51112828e-02f, 2.98736334e-01f, 1.56084657e-01f, 1.98441781e-02f, -1.90296426e-01f, -2.28081971e-01f, -1.03408530e-01f,
  -4.44898941e-02f, 6.42139837e-02f, -4.20186669e-02f, 1.80197746e-01f, 6.38077185e-02f, 7.28886276e-02f, 2.99460560e-01f, 1.79088876e-01f, -1.93638027e-01f, -1.72301590e-01f,
  5.28520525e-01f, -1.67058706e-01f, -1.54985905e-01f, 4.12223160e-01f, 3.22231352e-01f, 1.01670228e-01f, 1.09186597e-01f, -1.40980542e-01f, -1.13073856e-01f, -9.92748216e-02f,
  -1.23443805e-01f, -4.15757820e-02f, 4.87458073e-02f, -3.15450698e-01f, -3.28322202e-01f, 3.78787905e-01f, -1.73348337e-02f, -8.67154449e-02f, 1.49033502e-01f, 2.34714761e-01f,
  -4.67004552e-02f, 5.42260846e-03f, -2.61928122e-02f, 1.15884272e-02f, 1.15330838e-01f, 1.06472991e-01f, 3.21040303e-02f, 1.57833055e-01f, 6.56494647e-02f, 7.15483800e-02f,
  -5.76165244e-02f, -7.73659274e-02f, 2.31597513e-01f, 1.73821691e-02f, 2.17737824e-01f, 3.24521139e-02f, 4.98622023e-02f, 1.65886775e-01f, 1.82968512e-01f, 4.08691652e-02f,
  1.10103879e-02f, 3.38023275e-01f, 6.25773743e-02f, 5.42839728e-02f, 1.55260175e-01f, 1.49006888e-01f, -2.11937651e-02f, 6.00818135e-02f, -7.28131086e-02f, 7.39501864e-02f,
  -7.68954754e-02f, 1.01153657e-01f, 5.41571565e-02f, 2.30993815e-02f, -5.59498295e-02f, -1.15426943e-01f, 5.97135106e-04f, 7.63638169e-02f, 2.54019722e-02f, -2.65017934e-02f,
  4.63246591e-02f, 6.10005111e-02f, 2.22295094e-02f, -2.28938870e-02f, 2.23355725e-01f, 8.57485682e-02f, 1.11785501e-01f, 1.84804022e-01f, 2.08368734e-01f, 1.50671571e-01f,
  5.38378507e-02f, 1.63520858e-01f, 2.63633966e-01f, 2.52436101e-01f, 1.30405396e-01f, 1.00617722e-01f, -2.31319368e-01f, -8.56695399e-02f, -2.38834575e-01f, -2.63712332e-02f,
  1.99989706e-01f, -2.45026760e-02f, -4.81268130e-02f, 1.32544398e-01f, 7.31624812e-02f, -2.18028501e-01f, 1.93140611e-01f, 1.06808983e-01f, -9.21017118e-03f, -1.37353567e-02f,
  1.31803215e-01f, -7.96777084e-02f, 4.26789820e-02f, -1.45463884e-01f, 9.17883217e-02f, -1.71338990e-01f, 2.61737168e-01f, 6.53408915e-02f, 8.06958377e-02f, 7.30121089e-03f,
  -3.84900481e-01f, -1.41350791e-01f, 8.66086259e-02f, 2.10778974e-02f, 3.08125764e-02f, -3.23036239e-02f, 1.22421190e-01f, 3.17265362e-01f, 2.36880898e-01f, 5.78354783e-02f,
  3.47993374e-01f, 9.23069939e-03f, 1.99140489e-01f, -1.36454061e-01f, 2.56381929e-01f, 4.46627056e-03f, -3.84604372e-02f, 6.85424656e-02f, -1.87491521e-01f, 7.95070007e-02f,
  1.53560983e-02f, -5.82295358e-02f, -7.16800615e-02f, 1.42230824e-01f, -7.74224624e-02f, 8.45259503e-02f, -8.45255479e-02f, 4.70471941e-03f, 8.64998922e-02f, 3.35047603e-01f,
  -4.45314109e-01f, 2.19763845e-01f, 3.42397481e-01f, 1.89522251e-01f, -1.91182926e-01f, -3.02514359e-02f, 4.74554300e-02f, 1.07940242e-01f, 6.05675161e-01f, -1.03726842e-01f,
  -7.20509365e-02f, -3.73658657e-01f, 1.62475780e-01f, 2.33470097e-01f, 7.19786659e-02f, -7.92556629e-02f, -1.22132741e-01f, 3.63037407e-01f, 2.55975187e-01f, 1.70528181e-02f,
  1.23913951e-01f, -4.74996902e-02f, 1.13966599e-01f, -3.78048085e-02f, 7.90130720e-02f, 3.74366567e-02f, -7.24908412e-02f, 1.61796287e-01f, -2.54676580e-01f, 9.95369032e-02f,
  -3.74669060e-02f, 1.97836399e-01f, -3.54174189e-02f, -2.66649127e-01f, -8.58665183e-02f, 5.51188178e-02f, 1.62659049e-01f, 7.61297271e-02f, -8.40213299e-02f, -1.53569758e-01f,
  -1.86116584e-02f, 1.64833859e-01f, 1.01468019e-01f, -5.37395403e-02f, 9.92433578e-02f, -2.71954127e-02f, -1.45860983e-03f, 1.29512101e-01f, -2.74227168e-02f, 1.04864463e-02f,
  -1.00150652e-01f, -2.09820703e-01f, 3.56837250e-02f, 6.33449107e-03f, -9.48830396e-02f, 1.24366386e-02f, -2.30995961e-03f, -3.32075238e-01f, -1.15861110e-01f, 4.91562597e-02f,
  -1.82819247e-01f, -9.42754745e-02f, 1.21195301e-01f, -5.94280660e-02f, -7.06761098e-03f, 2.40710191e-02f, 1.28258504e-02f, 4.75445297e-03f, -1.06821515e-01f, 8.52976814e-02f,
  -2.46730193e-01f, -2.65475214e-02f, -6.29139021e-02f, -1.41618147e-01f, 3.98256630e-01f, -1.24314040e-01f, -8.18159152e-03f, -3.21004570e-01f, 4.98864166e-02f, 5.61288334e-02f,
  -7.46347904e-02f, 2.99451858e-01f, -1.60970569e-01f, -1.75315723e-01f, 1.56020656e-01f, -1.81034461e-01f, -1.19140327e-01f, -1.39881998e-01f, 7.12897852e-02f, -4.00054812e-01f,
  1.36464924e-01f, 2.58731302e-02f, 4.09628376e-02f, -5.38870767e-02f, -6.02681637e-02f, 1.27554759e-01f, 9.19125527e-02f, 1.98850371e-02f, -3.17162693e-01f, 1.38303593e-01f,
  -1.06323160e-01f, 1.73354551e-01f, 1.26054600e-01f, -1.66115522e-01f, -6.91251010e-02f, -6.17965311e-02f, -8.70574489e-02f, -2.36156613e-01f, -8.37929547e-02f, 1.34478778e-01f,
  1.34872332e-01f, 1.45144796e-03f, -5.53621054e-02f, -4.02722284e-02f, 6.53627291e-02f, -3.25326055e-01f, 1.90039471e-01f, 1.27664238e-01f, -3.85677248e-01f, -1.94073990e-01f,
  6.76883459e-02f, 8.87186639e-03f, 4.11261469e-02f, 9.37716216e-02f, 8.98487028e-03f, -1.40570730e-01f, 3.73787358e-02f, 7.72990435e-02f, 9.30393785e-02f, -1.61457181e-01f,
  -1.29582733e-01f, 2.00784832e-01f, 2.71278203e-01f, -3.01309675e-01f, 9.17888731e-02f, 7.68068954e-02f, 1.25511318e-01f, 1.92589864e-01f, -4.28670526e-01f, -1.37730949e-02f,
  -9.85657331e-03f, 1.00620411e-01f, 2.91368842e-01f, -1.66580766e-01f, -8.41739327e-02f, 4.55415159e-01f, 5.82053140e-02f, 6.13667145e-02f, -7.84666985e-02f, 5.85712194e-02f,
  -4.24174815e-02f, 1.02909625e-01f, -1.13724485e-01f, 1.73686162e-01f, 2.40504630e-02f, 2.93592159e-02f, -9.18773487e-02f, 9.70057473e-02f, 1.19557558e-02f, 1.51249230e-01f,
  1.02785088e-01f, 8.03073198e-02f, -4.00624312e-02f, 1.60232067e-01f, 1.09754987e-01f, 6.16020113e-02f, 1.01174265e-01f, -9.54672601e-03f, 1.47869503e-02f, 2.61434074e-02f,
  -8.88778046e-02f, 5.29375672e-02f, 1.54451057e-01f, 1.02862351e-01f, -2.08699480e-02f, -4.24216315e-02f, 3.33590806e-02f, -4.17890213e-02f, 6.25267066e-03f, 1.93623260e-01f,
  1.25983283e-01f, 7.13858381e-02f, 1.03214923e-02f, -9.34942737e-02f, 1.10699600e-02f, 1.25228286e-01f, -5.73561601e-02f, 4.41757701e-02f, 5.44795021e-02f, 7.09620640e-02f,
  -3.54291759e-02f, 6.81216046e-02f, 1.25273883e-01f, 2.92622019e-02f, 3.31023596e-02f, 9.31601692e-03f, 4.62580472e-02f, -5.79346679e-02f, -7.67406076e-02f, 2.29771920e-02f,
  -1.47501886e-01f, 7.39110708e-02f, -5.87724969e-02f, -1.22384295e-01f, 1.66027233e-01f, -1.83750853e-01f, -1.18315846e-01f, 7.22297728e-02f, 9.57817659e-02f, -2.74472218e-02f,
  -3.10787801e-02f, 9.33567062e-02f, -1.22637048e-01f, 4.39692028e-02f, 7.92897940e-02f, -1.80072300e-02f, -5.38892895e-02f, -4.23367955e-02f, 2.65770182e-02f, 9.57123935e-02f,
  4.58183810e-02f, -9.38283186e-03f, 2.95416750e-02f, -8.76671225e-02f, -1.02395341e-01f, -1.76262259e-01f, 3.02854121e-01f, 2.86291596e-02f, 3.09767406e-02f, -4.58628275e-02f,
  -1.45997524e-01f, -3.84019613e-02f, 1.32080046e-02f, -1.35749176e-01f, 1.23799369e-02f, -2.31364340e-01f, -8.88331756e-02f, 4.67200913e-02f, -2.75413960e-01f, 7.90843442e-02f,
  -7.90973902e-02f, 1.37286708e-01f, 1.07632309e-01f, -1.30870938e-01f, 2.54670661e-02f, -3.39934975e-02f, 3.21109034e-02f, 1.70111552e-01f, 7.50832707e-02f, 8.03135186e-02f,
  -6.53576255e-02f, -4.81804311e-02f, 1.11364521e-01f, 1.20091662e-01f, 3.33626628e-01f, 3.33779268e-02f, 5.44089973e-01f, -2.53083706e-01f, -3.85862626e-02f, 3.62350434e-01f,
  2.91196167e-01f, -2.66491678e-02f, 2.76365820e-02f, 2.76492238e-01f, -4.03910935e-01f, 7.03907162e-02f, -9.98053029e-02f, 4.55665320e-01f, 3.73227596e-02f, -1.01600878e-01f,
  -3.82532142e-02f, 9.62292925e-02f, 1.04280144e-01f, -3.49372305e-04f, 6.96657458e-03f, -8.33836794e-02f, -7.84492269e-02f, -2.11954147e-01f, 8.19860101e-02f, 4.24111709e-02f,
  4.81427424e-02f, 1.63620532e-01f, 2.84072589e-02f, 5.86617850e-02f, 7.52528235e-02f, 1.05481863e-01f, 9.99982208e-02f, 4.91971383e-03f, 7.86302686e-02f, -1.08191721e-01f,
  1.28062770e-01f, -3.03431172e-02f, 7.79085532e-02f, -7.69903362e-02f, -4.14966792e-02f, 3.46405387e-01f, 9.77742746e-02f, -1.29028380e-01f, 1.48958683e-01f, -3.91118377e-02f,
  -4.41059358e-02f, 1.01904199e-01f, -3.80015224e-02f, -5.96389920e-02f, -6.10808805e-02f, 5.43798059e-02f, 5.83323725e-02f, 1.50418624e-01f, -8.46848488e-02f, 3.02342325e-02f,
  -2.24557184e-02f, 7.31386021e-02f, -4.65338044e-02f, 8.31227228e-02f, -9.85375419e-02f, 7.16094300e-02f, -6.61465451e-02f, -9.14497823e-02f, 1.44862965e-01f, 7.16910213e-02f,
  -5.34608178e-02f, -6.80328608e-02f, 1.24091305e-01f, 1.29815906e-01f, -1.19659059e-01f, 9.50402990e-02f, 1.01224102e-01f, 3.45796905e-02f, 1.33417144e-01f, -1.39905185e-01f,
  -2.23770306e-01f, -7.02901259e-02f, -1.86027493e-02f, 9.35721546e-02f, 6.07319437e-02f, -4.86156605e-02f, -3.46054763e-01f, -3.61921191e-02f, 1.22910306e-01f, -2.31032804e-01f,
  -6.60227165e-02f, 5.81345707e-02f, -4.53769676e-02f, 8.05065408e-03f, 1.25544190e-01f, 1.90809458e-01f, -6.12162128e-02f, -1.00466058e-01f, 1.87821537e-01f, 5.03208786e-02f,
  2.03850731e-01f, 3.31902690e-02f, 2.76194680e-02f, 1.14277028e-01f, -1.41728595e-01f, -1.25968261e-02f, -8.04279298e-02f, -7.27260262e-02f, 8.98718089e-02f, 9.80611518e-02f,
  1.64828032e-01f, 9.58045945e-02f, 1.10294238e-01f, 2.71819711e-01f, 5.21547914e-01f, 1.41491517e-02f, 2.65014414e-02f, 1.48920314e-02f, 5.93342222e-02f, 1.20998517e-01f,
  -9.27606672e-02f, 1.22388288e-01f, -7.09235761e-03f, 8.63794610e-02f, -1.03026778e-02f, -2.32331023e-01f, -2.87230372e-01f, 1.29696473e-01f, -8.52642357e-02f, 9.08401757e-02f,
  -6.19554985e-03f, -1.48645595e-01f, -3.57876480e-01f, 3.18894833e-01f, -2.36822292e-01f, 2.73786753e-01f, 5.32676913e-02f, 3.39490697e-02f, -1.10949032e-01f, 2.39937067e-01f,
  1.11924864e-01f, -1.54015601e-01f, 7.25815833e-01f, -1.92512020e-01f, 1.36230335e-01f, -8.76444764e-03f, 8.13187957e-02f, 2.28062987e-01f, 1.72890455e-01f, -1.29120961e-01f,
  -2.13252187e-01f, 4.69473302e-01f, 1.38994411e-01f, 1.50426924e-01f, -1.95404533e-02f, -7.49915689e-02f, 9.45186391e-02f, 9.80608761e-02f, 7.92660415e-02f, 2.10703865e-01f,
  1.44862324e-01f, -1.54244807e-02f, 5.82084097e-02f, 1.18774101e-01f, 1.26729399e-01f, 1.02344215e-01f, 1.20483339e-02f, 2.12069631e-01f, 1.59208387e-01f, 9.86533463e-02f,
  7.03566596e-02f, 1.81393445e-01f, 1.46664053e-01f, 1.46659650e-02f, 6.64367750e-02f, 1.61965683e-01f, 1.03544205e-01f, 9.82912630e-02f, 2.24312276e-01f, 1.89625975e-02f,
  7.39747956e-02f, 1.51923165e-01f, 1.72668681e-01f, 1.81988418e-01f, 2.61982709e-01f, 8.92413333e-02f, 3.98484543e-02f, 1.62079960e-01f, -6.42372817e-02f, -4.63241804e-03f,
  1.38974488e-01f, 3.52352858e-01f, 1.02022782e-01f, 1.74042434e-01f, 4.83717620e-02f, 1.94567069e-01f, 2.35191826e-02f, 4.76011634e-02f, 1.46462964e-02f, 2.42051445e-02f,
  1.21208593e-01f, -4.83646542e-02f, -9.39863548e-02f, 6.62627146e-02f, -1.42602772e-02f, -2.03894973e-01f, -6.12520799e-02f, -7.42832273e-02f, 1.30154178e-01f, 5.23725301e-02f,
  -3.62417027e-02f, 2.48825893e-01f, 5.47434390e-02f, -6.89056814e-02f, -2.05666959e-01f, -1.59234464e-01f, 1.52559340e-01f, 1.66189782e-02f, 3.36392857e-02f, 3.43052186e-02f,
  2.94405278e-02f, -1.27821535e-01f, 2.12576956e-01f, 3.16662133e-01f, -3.61876078e-02f, -2.59287983e-01f, -1.72116041e-01f, -8.89219344e-02f, 1.25805780e-01f, 1.43658474e-01f,
  1.46082789e-01f, 1.58462990e-02f, -2.12005213e-01f, -1.09430030e-01f, 8.89232941e-03f, -8.02831277e-02f, 2.30835415e-02f, 8.96599442e-02f, 1.62332118e-01f, 8.88083503e-03f,
  -6.75230771e-02f, 2.13279456e-01f, 1.74457505e-01f, -3.15026976e-02f, 1.25951812e-01f, 2.38375347e-02f, -4.26860601e-02f, 1.87767893e-01f, -9.61061865e-02f, 2.04421118e-01f,
  2.02741101e-01f, 3.61128710e-02f, 8.88205096e-02f, -4.28604297e-02f, 7.60979131e-02f, 1.67113394e-01f, 4.37708013e-02f, 2.98131913e-01f, 2.50202775e-01f, -3.89613817e-03f,
  -5.51191211e-01f, 2.24898100e-01f, 1.07369192e-01f, 5.87671340e-01f, 5.92413098e-02f, -2.16551006e-01f, 2.20812447e-02f, 5.98164976e-01f, 2.77162701e-01f, -4.00518440e-02f,
  4.75064009e-01f, -1.61631435e-01f, 3.94044191e-01f, -3.38450484e-02f, 1.10828109e-01f, 3.54490817e-01f, 9.37599167e-02f, 4.62106913e-02f, -2.29322910e-01f, 1.48683399e-01f,
  -2.64622159e-02f, -8.96224231e-02f, 6.72219470e-02f, 4.43019457e-02f, 5.64867817e-02f, 2.25947618e-01f, -3.44333313e-02f, 1.68532163e-01f, -4.46185656e-03f, 1.04429923e-01f,
  3.47972512e-02f, 2.31980197e-02f, 1.10128880e-01f, 1.10116109e-01f, 7.68905506e-02f, 8.54313374e-02f, -1.71395302e-01f, 2.98004807e-03f, 7.65229017e-02f, 9.34998095e-02f,
  8.07833150e-02f, -6.43349951e-03f, 2.06739500e-01f, 3.32884490e-02f, -3.45124640e-02f, -7.78607950e-02f, -4.08412569e-04f, 1.24918051e-01f, 2.44653285e-01f, 1.53952777e-01f,
  3.51791643e-02f, 5.78934178e-02f, 9.84494109e-03f, -1.86732598e-02f, 1.93440057e-02f, 1.56666070e-01f, 9.50584263e-02f, 1.55245392e-02f, 1.98981017e-01f, 8.09456930e-02f,
  1.56015247e-01f, -7.52253532e-02f, -1.28499299e-01f, -3.32754552e-02f, 1.49169236e-01f, 1.02182873e-01f, 3.06558996e-01f, 9.77757275e-02f, 3.34985331e-02f, 4.69453167e-03f,
  1.90573111e-01f, -1.58113483e-02f, 2.47998964e-02f, 7.55379125e-02f, 2.11268961e-02f, -8.32289085e-02f, 2.06792951e-01f, 4.36889529e-02f, -2.22963601e-01f, 4.22484465e-02f,
  -1.08656790e-02f, -2.61815321e-02f, -4.79915403e-02f, 2.34285280e-01f, -1.44274011e-01f, 6.50569238e-03f, 8.32851157e-02f, 6.24468587e-02f, -8.04539695e-02f, 7.42404535e-02f,
  -5.73912971e-02f, -2.01803714e-01f, 8.30812939e-03f, 4.77990732e-02f, -3.53199840e-02f, -1.00485191e-01f, 7.31468871e-02f, 1.69811863e-02f, -1.57068253e-01f, 1.50334895e-01f,
  -1.03217438e-01f, 1.98139891e-01f, 2.77182199e-02f, -1.35011345e-01f, -4.65124734e-02f, -3.03479303e-02f, 1.27731651e-01f, 1.58362880e-01f, -8.47621709e-02f, -1.16101481e-01f,
  -1.43904507e-01f, -2.92559825e-02f, 6.82241991e-02f, 1.00772545e-01f, 1.69202387e-01f, -1.44851968e-01f, -1.62618652e-01f, 8.91150162e-02f, -3.89690511e-02f, -9.09406245e-02f,
  5.42505756e-02f, 1.10580884e-01f, -2.06080765e-01f, 2.63076961e-01f, 2.62765735e-01f, 1.40431553e-01f, 3.46202254e-02f, -1.94966778e-01f, 5.39392114e-01f, 2.77994305e-01f,
  -1.51069745e-01f, -3.54844719e-01f, 1.33661613e-01f, 3.17711294e-01f, 2.48037260e-02f, -1.22697890e-01f, -3.43195736e-01f, 1.53934546e-02f, -3.05694491e-01f, 1.03987316e-02f,
  1.72606871e-01f, -1.13205105e-01f, 1.11753300e-01f, 1.64518461e-01f, 6.64203241e-02f, 1.48454830e-01f, 1.70754090e-01f, -3.31025451e-01f, 1.29697137e-02f, 4.67527006e-03f,
  7.80640468e-02f, 2.23633498e-01f, 1.35570407e-01f, 1.07487403e-01f, 2.38009870e-01f, 9.21464525e-03f, 2.12985724e-02f, 5.45089059e-02f, 4.85343998e-03f, 1.16970770e-01f,
  1.01152770e-01f, 1.29422486e-01f, 4.41597067e-02f, 2.97628213e-02f, 1.99362367e-01f, -8.74708667e-02f, 7.37553388e-02f, 5.66966692e-03f, -4.89429608e-02f, 1.25344321e-01f,
  1.83374420e-01f, 1.07295543e-01f, 1.26935303e-01f, 6.47397116e-02f, -3.51381116e-02f, 6.12394102e-02f, -4.32063267e-02f, 4.74336669e-02f, 9.02579129e-02f, -2.10033655e-02f,
  -9.99413878e-02f, -8.52994174e-02f, 2.01083291e-02f, -1.34606585e-01f, 1.23375446e-01f, 1.41055718e-01f, -1.69652030e-02f, -3.66736931e-04f, 6.47952780e-02f, 5.14547266e-02f,
  -2.77609676e-02f, -1.19153425e-01f, 1.79710642e-01f, 1.29061670e-03f, 2.36098990e-02f, -1.96026973e-02f, -1.34686020e-03f, 1.14277579e-01f, 7.63005614e-02f, -1.65401042e-01f,
  -3.71470414e-02f, -1.26376018e-01f, -1.16675161e-02f, 8.87524560e-02f, -2.20092118e-01f, 3.95490229e-02f, -1.93332851e-01f, 7.11375698e-02f, 9.08894762e-02f, 2.16120505e-03f,
  -7.73035139e-02f, 1.83731377e-01f, 1.81402057e-01f, 1.20501511e-01f, -1.15229577e-01f, 9.11659598e-02f, 4.47754115e-02f, 1.93475083e-01f, 8.00181180e-02f, 1.51619330e-01f,
  7.91095421e-02f, 3.51436064e-02f, -1.91225469e-01f, 3.88386822e-03f, -1.29456431e-01f, 1.35004953e-01f, 4.34172079e-02f, 4.13525440e-02f, 1.17341973e-01f, 1.28633022e-01f,
  -1.45489611e-02f, 4.30586115e-02f, 2.40439773e-01f, 6.18303828e-02f, 9.85451862e-02f, -6.51208609e-02f, -2.36967299e-02f, -3.82505618e-02f, -1.98695600e-01f, -9.05975848e-02f,
  1.11788206e-01f, 1.12055428e-01f, 5.80296814e-02f, -1.97904319e-01f, -4.14946489e-02f, -1.89986795e-01f, -1.52399123e-01f, -6.87697381e-02f, -3.66556197e-02f, 1.46624610e-01f,
  1.96503431e-01f, 1.53346330e-01f, 1.83074668e-01f, -6.25713319e-02f, -3.30355810e-03f, 3.39557789e-02f, 2.42316604e-01f, -3.59226018e-01f, -1.50272638e-01f, 3.62349451e-01f,
  3.37654591e-01f, -4.87870239e-02f, 3.86832356e-02f, -1.47925273e-01f, 4.78456132e-02f, 2.53637116e-02f, 1.01583228e-01f, 2.55474206e-02f, 3.82515341e-02f, -2.75892943e-01f,
  6.00945018e-03f, 3.44553381e-01f, 8.04985464e-02f, -3.14872079e-02f, 8.55408460e-02f, 3.66266929e-02f, 8.57727304e-02f, 1.02868415e-01f, 5.66041693e-02f, -2.26764530e-02f,
  1.50054932e-01f, 3.72443646e-02f, 1.26555488e-01f, 2.05013022e-01f, 1.61837623e-01f, 1.09929577e-01f, 2.22828276e-02f, 2.26337403e-01f, 4.66632843e-02f, 9.62999910e-02f,
  1.93026010e-03f, 1.28624007e-01f, 1.88760594e-01f, 2.73970872e-01f, 9.64662060e-02f, 2.10100681e-01f, 8.20539594e-02f, -3.36583823e-01f, 6.51978776e-02f, 1.08924061e-01f,
  1.03581861e-01f, -1.43236909e-02f, 1.08953401e-01f, 8.56434852e-02f, -9.95185375e-02f, 3.06080043e-01f, 1.57585949e-01f, 1.61981180e-01f, 1.89630702e-01f, 2.68719308e-02f,
  1.48667559e-01f, 3.40521514e-01f, 3.14940274e-01f, 9.69595462e-02f, 9.70266908e-02f, -1.16091166e-02f, 1.09166570e-01f, 1.45963326e-01f, 1.58196222e-02f, 1.73311904e-01f,
  1.12552263e-01f, 1.75153628e-01f, -6.54975127e-04f, 3.12409997e-02f, 1.66425616e-01f, 1.00654081e-01f, -1.10031545e-01f, -4.72396947e-02f, 9.30273533e-03f, 5.53165153e-02f,
  -1.96809992e-01f, -9.69650075e-02f, 6.26894593e-01f, 4.74009104e-02f, -8.98339823e-02f, -6.87700510e-02f, 1.81514099e-01f, 1.72983035e-02f, -1.52091831e-01f, -8.01139623e-02f,
  -1.85797438e-01f, 6.48977384e-02f, 4.08608794e-01f, -1.33391857e-01f, -2.53207535e-02f, 1.13060072e-01f, 2.95339972e-02f, 2.10408289e-02f, 4.18393999e-01f, -1.36079371e-01f,
  -4.25663292e-01f, -1.50831506e-01f, 1.43139288e-01f, -1.13171443e-01f, 9.81761888e-02f, 1.46020174e-01f, -3.94563019e-01f, -1.67224094e-01f, -5.34979859e-03f, 2.67517179e-01f,
  2.02979654e-01f, 8.87884647e-02f, -1.91119639e-03f, -1.71787769e-01f, -1.37353152e-01f, 1.63294598e-01f, -1.80352286e-01f, 2.29103684e-01f, 2.65338600e-01f, 1.84593312e-02f,
  6.66940957e-02f, 3.51177454e-01f, -2.82931402e-02f, 5.31950444e-02f, -1.12255260e-01f, 1.26535982e-01f, -2.13133574e-01f, -1.02139898e-01f, -9.24256444e-02f, -5.07526159e-01f,
  -6.87032938e-02f, 1.70424998e-01f, 1.82035580e-01f, -5.46831898e-02f, -2.16794223e-01f, 4.76428032e-01f, 4.91191804e-01f, 5.00946403e-01f, 5.41421212e-02f, 2.42336076e-02f,
  -1.85025632e-01f, 4.82685894e-01f, -4.66915034e-02f, 7.12522715e-02f, 1.43760547e-01f, -1.85205147e-01f, 2.23002374e-01f, 8.90536383e-02f, -1.17432490e-01f, 3.19551617e-01f,
  8.77087638e-02f, -1.74594000e-01f, -1.57812566e-01f, 4.86328274e-01f, 1.90445453e-01f, -1.48038998e-01f, 1.17568605e-01f, 1.20344326e-01f, 1.17431656e-01f, 1.85497805e-01f,
  -1.97941586e-02f, -4.39779982e-02f, 4.53279428e-02f, 8.30910355e-02f, -2.59183403e-02f, 6.85728490e-02f, -9.72566381e-03f, 3.74554582e-02f, 1.91627011e-01f, 9.22959149e-02f,
  1.53789595e-02f, 1.00067906e-01f, 7.67975897e-02f, 9.29144248e-02f, 9.67651755e-02f, 1.71162963e-01f, 7.77089149e-02f, 2.67921001e-01f, -5.34229241e-02f, 2.42273603e-03f,
  1.00092456e-01f, 1.98828235e-01f, 2.05816552e-01f, -3.57650593e-02f, 1.86458211e-02f, -4.78613116e-02f, 8.30354095e-02f, -4.10190001e-02f, -4.28491049e-02f, 7.71557391e-02f,
  -9.48998630e-02f, 1.29751703e-02f, 1.48429692e-01f, -1.09318845e-01f, -3.90376709e-02f, -4.76460047e-02f, 2.98680097e-01f, 1.15108460e-01f, 1.59506083e-01f, -2.22676713e-02f,
  4.04295698e-02f, 2.58300155e-01f, 9.08515826e-02f, 6.90290034e-02f, 3.54480520e-02f, -1.99879467e-01f, 1.07462332e-01f, 9.81130600e-02f, 1.47967935e-01f, 9.70207602e-02f,
  -5.81967354e-01f, 1.04425199e-01f, 5.00303693e-02f, 1.39962807e-01f, -8.95251408e-02f, -2.94404533e-02f, 2.01360270e-01f, -1.40323654e-01f, 2.69891560e-01f, 3.95085402e-02f,
  -2.39204913e-01f, 2.41288096e-01f, 1.15829349e-01f, -1.07087120e-01f, -9.26564336e-02f, 1.09594345e-01f, -1.60162494e-01f, 9.48217139e-02f, 4.05707747e-01f, -1.13357209e-01f,
  1.02057621e-01f, 2.06141070e-01f, 2.70762723e-02f, -1.30981609e-01f, 4.44703400e-01f, -6.32326901e-02f, 1.37217781e-02f, -8.45809206e-02f, -6.04095832e-02f, 4.02644388e-02f,
  4.38786671e-02f, 1.02867126e-01f, -1.96959645e-01f, -1.09535716e-02f, 2.60313451e-01f, -2.48604059e-01f, -3.28432679e-01f, -1.84599817e-01f, 1.48535579e-01f, -1.22286715e-01f,
  3.53210121e-01f, -1.60242766e-02f, 3.25839341e-01f, 3.68986502e-02f, 4.13782626e-01f, -4.07733135e-02f, 1.79267555e-01f, 2.39167199e-01f, -1.32205322e-01f, 6.04852326e-02f,
  1.61531389e-01f, -5.83127141e-02f, 2.35561505e-01f, -2.40901291e-01f, -2.11529359e-01f, -2.85495799e-02f, -3.93069565e-01f, 1.92863047e-01f, 5.85098386e-01f, 9.36606675e-02f,
  1.76858932e-01f, -1.08760566e-01f, 4.64908093e-01f, -5.81656843e-02f, 6.73053637e-02f, -7.86277056e-02f, -7.38762766e-02f, 1.62196204e-01f, 1.77981228e-01f, -2.35631138e-01f,
  -1.13859624e-01f, 1.56770110e-01f, 8.75470489e-02f, 3.22587639e-02f, -7.43182674e-02f, 1.79807216e-01f, 1.28498703e-01f, 5.77742979e-02f, -2.40816530e-02f, 1.83941379e-01f,
  6.34844974e-02f, 7.84564316e-02f, 1.09640643e-01f, 1.46240845e-01f, 4.17983420e-02f, 7.62460828e-02f, 6.95437267e-02f, 1.06234267e-01f, 5.86291216e-03f, 1.79048568e-01f,
  8.07320848e-02f, 5.41037768e-02f, 1.57947585e-01f, 3.03700000e-01f, 4.91381697e-02f, -2.43352912e-03f, -7.08433837e-02f, 7.35755712e-02f, 1.28649235e-01f, 1.43981248e-01f,
  -7.02662840e-02f, -1.97637477e-03f, 8.25377554e-02f, -3.99769610e-03f, 1.47930980e-01f, -2.34880447e-02f, 7.79143050e-02f, 5.44454530e-02f, -1.25831842e-01f, -1.17438518e-01f,
  7.33973533e-02f, 8.32578465e-02f, -1.93897411e-02f, 3.28972228e-02f, 1.33613795e-01f, -9.55836475e-02f, -2.94985413e-03f, 7.60913342e-02f, 1.19425161e-02f, 1.98942609e-02f,
  -1.24430977e-01f, 2.79850692e-01f, 2.20204622e-01f, -1.85046792e-01f, -3.86387445e-02f, -4.14658599e-02f, 7.95460423e-04f, 1.93745166e-01f, -2.50001580e-01f, -3.30457278e-02f,
  1.63436502e-01f, 1.00100979e-01f, -6.41064048e-02f, 2.06977148e-02f, 3.07248253e-02f, -1.75559431e-01f, 1.83343083e-01f, 1.01373322e-01f, -9.40164030e-02f, 3.04913558e-02f,
  1.86750084e-01f, 9.95022207e-02f, -1.12199321e-01f, 1.47095636e-01f, -3.15910876e-02f, -6.55240864e-02f, 6.66625127e-02f, -1.22429185e-01f, 7.96416122e-03f, 1.03507102e-01f,
  8.67788717e-02f, -1.09074377e-01f, 3.55102509e-01f, 7.38914236e-02f, 5.22417314e-02f, -1.92074396e-03f, -1.00333109e-01f, 4.16738167e-02f, 2.66058184e-02f, -2.95654945e-02f,
  5.88692129e-02f, -1.88494120e-02f, 2.08909467e-01f, -3.71753946e-02f, -3.84956032e-01f, 1.94805525e-02f, -4.28197719e-03f, 7.02604800e-02f, 1.88973859e-01f, -2.39635617e-01f,
  1.28546044e-01f, -8.75602141e-02f, 1.36643991e-01f, 1.20437346e-01f, 2.01602921e-01f, 3.35448235e-01f, 2.16123566e-01f, 4.66989130e-02f, 1.64398849e-01f, 5.48654646e-02f,
  7.73566961e-02f, -1.64405003e-01f, 8.29359442e-02f, 6.19878806e-02f, 3.54062133e-02f, 1.38631493e-01f, 2.20129058e-01f, -4.37779119e-03f, -2.91087162e-02f, 1.69041991e-01f,
  7.88773671e-02f, 1.28546521e-01f, -1.26884580e-01f, 2.09814832e-01f, 2.29758881e-02f, -1.20264120e-01f, 7.37582222e-02f, -1.60442680e-01f, 1.57735087e-02f, 5.96763015e-01f,
  2.03578323e-01f, -5.59644662e-02f, 6.37235120e-02f, -9.85405445e-02f, 1.56606331e-01f, 9.53720585e-02f, -5.38451821e-02f, -2.13686693e-02f, 2.49385431e-01f, 1.55869827e-01f,
  4.09195162e-02f, 1.21559054e-02f, 6.70870692e-02f, -4.08277772e-02f, -3.19333971e-02f, 1.56183690e-01f, 1.36677086e-01f, -3.22690886e-03f, -8.44765231e-02f, 2.17088178e-01f,
  2.77246907e-02f, 3.23658660e-02f, 1.05389003e-02f, 4.40041013e-02f, 1.40477985e-01f, 7.29811564e-02f, 7.46106356e-02f, 5.95708229e-02f, 2.27451231e-02f, 5.18207923e-02f,
  7.78276250e-02f, 1.47641301e-01f, 4.13393155e-02f, 6.18100911e-02f, 7.31154252e-03f, 3.23524252e-02f, 1.24068499e-01f, 1.16477765e-01f, -1.46109583e-02f, 1.57766163e-01f,
  1.01915404e-01f, 5.37749678e-02f, 5.57375625e-02f, 9.96573567e-02f, 6.01852387e-02f, 1.72895752e-02f, 2.48442084e-01f, 7.51637146e-02f, 2.15554625e-01f, -1.66284800e-01f,
  6.59531960e-03f, 1.98802263e-01f, 3.92547809e-02f, 1.47206457e-02f, 1.08405873e-01f, 2.49230161e-01f, -1.19676635e-01f, -1.20234586e-01f, 1.97610244e-01f, 1.36996582e-01f,
  -2.28483155e-02f, 1.18001170e-01f, -1.20964367e-02f, -1.52169123e-01f, 1.12824798e-01f, -2.97655389e-02f, -8.93032998e-02f, -1.69364899e-01f, -3.00890595e-01f, -8.64224881e-02f,
  1.77973047e-01f, 1.27234623e-01f, 5.44244125e-02f, 7.45021626e-02f, 1.52189061e-02f, 1.54604793e-01f, -9.18012336e-02f, -8.86391965e-04f, 1.17974244e-02f, 1.05574749e-01f,
  -1.30733266e-01f, -1.91575527e-01f, -1.18889771e-01f, 1.43964723e-01f, 1.43617198e-01f, 2.10779876e-01f, 5.51149361e-02f, -6.68078884e-02f, -7.25606903e-02f, 9.08457562e-02f,
  1.83117967e-02f, -1.11185044e-01f, 2.04902723e-01f, -1.32115692e-01f, -1.24152847e-01f, -9.53572243e-02f, -1.30693719e-01f, 2.53169596e-01f, -1.21206953e-03f, 9.21635926e-02f,
  9.99005586e-02f, -1.52378092e-02f, -9.52838629e-04f, -1.98399663e-01f, -1.47051722e-01f, 1.74832679e-02f, -1.01088054e-01f, 1.10680707e-01f, 1.06376529e-01f, 8.12781304e-02f,
  1.00054443e-01f, 3.30010056e-01f, -1.45513475e-01f, 6.18368424e-02f, -5.87969236e-02f, 6.53509051e-02f, 7.90155679e-02f, -2.67103374e-01f, 2.64828295e-01f, -2.46231660e-01f,
  9.86510292e-02f, -9.20894966e-02f, -8.02204311e-02f, 3.15669239e-01f, 1.59342185e-01f, 3.29570882e-02f, 8.95996839e-02f, -3.37082982e-01f, 2.15102926e-01f, 9.74700134e-03f,
  1.16209246e-01f, 1.47033334e-01f, 1.06015757e-01f, 1.38488129e-01f, 6.02492988e-02f, 6.53732270e-02f, -5.46459965e-02f, 7.90019333e-02f, -1.06259488e-01f, 6.20024800e-02f,
  4.72149029e-02f, 1.13102324e-01f, -8.29654653e-03f, 1.12460993e-01f, 1.29283622e-01f, 7.15823397e-02f, 1.49299920e-01f, 2.97848970e-01f, -8.95170681e-03f, -6.54768897e-03f,
  7.67634585e-02f, 2.38943160e-01f, 1.92898676e-01f, -1.52292415e-01f, -4.23234627e-02f, 2.78868303e-02f, 2.77370363e-01f, 1.98007986e-01f, 8.38185623e-02f, 4.42816094e-02f,
  -5.40789403e-02f, 9.66285616e-02f, -4.20574695e-02f, 1.15487568e-01f, 9.80692655e-02f, 6.63113892e-02f, 1.79798678e-01f, 1.15723163e-02f, 1.09547243e-01f, 1.61469430e-02f,
  -2.41375472e-02f, 2.03374431e-01f, -1.70522574e-02f, -5.14920577e-02f, 3.13752532e-01f, 1.41002432e-01f, 1.62017047e-01f, 8.81813467e-02f, 9.75536481e-02f, 1.99959934e-01f,
  -2.58622635e-02f, 8.06216076e-02f, 2.11093649e-01f, 5.76310642e-02f, 2.64562547e-01f, 1.04479631e-02f, -3.62697035e-01f, 1.92679673e-01f, 3.09422463e-01f, -7.07106069e-02f,
  -1.55142218e-01f, 1.70182914e-01f, -9.81416404e-02f, -4.73974235e-02f, 1.32838741e-01f, 2.71183122e-02f, -1.14976592e-01f, -1.45284325e-01f, 6.23723529e-02f, -5.04525714e-02f,
  1.65867090e-01f, 7.58227706e-02f, -1.58609867e-01f, 2.43419055e-02f, -6.22802926e-03f, -1.95143111e-02f, 7.91886225e-02f, 1.15063094e-01f, -4.34138536e-01f, 1.71407312e-01f,
  5.19149750e-02f, 3.15412953e-02f, -3.81115004e-02f, -1.29439980e-02f, 2.26689428e-01f, -1.13968616e-02f, -1.04644604e-01f, 1.00927763e-02f, -2.92910308e-01f, -3.38343494e-02f,
  2.74883240e-01f, 5.90513684e-02f, 6.67308569e-02f, -2.33270779e-01f, -4.29859996e-01f, 1.87357441e-01f, -1.24181591e-01f, -2.12930888e-03f, 5.84079586e-02f, 8.91831890e-02f,
  -1.83465645e-01f, 2.59000123e-01f, 2.79223353e-01f, 2.96576023e-01f, -1.15098665e-02f, -6.40572160e-02f, 4.03522104e-01f, -4.07567620e-02f, -2.59698331e-01f, 7.19476491e-02f,
  -5.26372306e-02f, 3.93246353e-01f, 8.04789215e-02f, 2.77302731e-02f, -1.18852414e-01f, -1.24840602e-01f, 1.62185043e-01f, -1.02700710e-01f, 2.41572991e-01f, -2.80424237e-01f,
  -9.44493636e-02f, 3.76212299e-01f, 1.72886893e-01f, 8.28337222e-02f, -4.87594260e-03f, -2.92033911e-01f, -4.67462167e-02f, -2.07741149e-02f, -1.58123344e-01f, -6.12650886e-02f,
  9.61350054e-02f, 5.04626334e-02f, -5.47690839e-02f, 1.39034376e-01f, 5.15797958e-02f, 1.14538051e-01f, -1.20194674e-01f, -1.48052633e-01f, 7.98178241e-02f, -7.46909305e-02f,
  -2.39222590e-03f, 4.14257944e-02f, 1.63030308e-02f, -2.89774835e-02f, -4.35449928e-02f, 7.96063095e-02f, -4.54107933e-02f, 1.56679288e-01f, 1.38874911e-02f, 4.32821475e-02f,
  4.93426509e-02f, -1.20751504e-02f, 1.56131964e-02f, 1.62956081e-02f, 3.65250721e-03f, -1.46077797e-01f, 3.07528581e-02f, 5.15300371e-02f, 7.40468875e-02f, 2.53053188e-01f,
  -1.05357632e-01f, 3.62842642e-02f, 2.68042982e-01f, -1.12500496e-01f, 9.51303840e-02f, 6.58590272e-02f, 5.46388188e-03f, -5.28514236e-02f, 3.31436284e-02f, 5.11972681e-02f,
  2.63632685e-02f, 5.25827706e-02f, 2.55698413e-02f, 5.76876663e-03f, 1.27818629e-01f, -1.74210500e-02f, -7.06824809e-02f, -1.13807386e-02f, 9.72169917e-03f, 2.58630309e-02f,
  2.69375499e-02f, -1.54638901e-01f, -1.08611338e-01f, 2.28744447e-02f, 2.22171783e-01f, -1.50244772e-01f, 1.06297351e-01f, 6.65214956e-02f, -8.11935812e-02f, -5.18507175e-02f,
  5.25681786e-02f, -1.72021359e-01f, -1.92113250e-01f, -2.69162580e-02f, -7.31543377e-02f, -5.65480664e-02f, -1.66171454e-02f, 1.26484498e-01f, 1.12721652e-01f, -7.11339433e-03f,
  5.16106598e-02f, 1.66845784e-01f, -9.21802074e-02f, -1.26129631e-02f, -6.61450550e-02f, -8.08662847e-02f, 2.05973357e-01f, -1.56501189e-01f, -3.32132950e-02f, 1.64997876e-01f,
  -8.89053941e-02f, 1.34920493e-01f, 5.12551069e-02f, -1.20877726e-02f, -1.20341465e-01f, 1.42957613e-01f, 2.65434146e-01f, 6.56012818e-02f, -1.04268873e-02f, 1.19405590e-01f,
  -1.48060784e-01f, 2.40711182e-01f, 2.23710425e-02f, -2.05123350e-01f, 1.97866093e-02f, -7.14012980e-02f, -5.08029200e-03f, -9.89641175e-02f, -1.24707967e-01f, 1.01896718e-01f,
  -1.86890617e-01f, 1.46242097e-01f, 1.21838577e-01f, 3.79151255e-02f, 7.36915842e-02f, 2.09237486e-01f, 3.29247355e-01f, -5.56663759e-02f, -8.09189677e-02f, 2.46038929e-01f,
  3.66948247e-01f, 3.46856862e-01f, 2.48199180e-02f, 2.84431577e-01f, 4.72564101e-01f, 2.55125053e-02f, 1.85988292e-01f, 3.70873451e-01f, 1.72245860e-01f, 9.45714638e-02f,
  -1.24209255e-01f, 1.17136598e-01f, 1.77811552e-03f, 3.04966599e-01f, 2.38207266e-01f, 4.18099575e-02f, 3.44590694e-02f, 1.84994310e-01f, 1.40303019e-02f, 1.75875381e-01f,
  2.52235472e-01f, -5.80669083e-02f, 2.42947917e-02f, 1.66814625e-02f, 2.09263995e-01f, 2.22916484e-01f, 1.13048613e-01f, 6.45654052e-02f, 5.62658207e-03f, -8.43036845e-02f,
  2.12666139e-01f, 4.84895855e-02f, 2.37789191e-02f, 4.15220037e-02f, 1.10895701e-01f, -3.55188288e-02f, 3.56805399e-02f, 1.24268867e-01f, 2.09969431e-01f, 5.09366803e-02f,
  2.46674605e-02f, -2.70009320e-03f, -2.60713212e-02f, 2.29039103e-01f, 6.41098693e-02f, 7.60507807e-02f, 3.42714936e-02f, -8.80278926e-03f, 1.29386395e-01f, -2.22357418e-02f,
  7.83511698e-02f, 1.10856101e-01f, -1.84421486e-03f, 9.85781383e-03f, 8.86462703e-02f, 2.81475991e-01f, 5.08618075e-03f, 4.67300555e-03f, 1.97830170e-01f, 1.27082542e-01f,
  7.60138631e-02f, 1.30163848e-01f, -6.10203333e-02f, 1.88549176e-01f, 1.49592860e-02f, -2.08081692e-01f, -9.68639106e-02f, 7.58311078e-02f, -1.19793653e-01f, -7.62059093e-02f,
  4.29467440e-01f, -1.14243306e-01f, 3.32567915e-02f, -1.82203978e-01f, 1.27822250e-01f, 3.74427624e-02f, -1.84455030e-02f, 2.00540945e-01f, 3.78693268e-02f, -1.64573357e-01f,
  1.90712988e-01f, -1.35702714e-01f, 1.30869031e-01f, 1.63838074e-01f, -1.07947275e-01f, -3.09681781e-02f, 2.35845163e-01f, -5.46394810e-02f, -2.71213889e-01f, -2.35082597e-01f,
  1.88102812e-01f, -1.95755064e-01f, -6.78880364e-02f, -1.32819891e-01f, -1.73065215e-01f, 6.43719211e-02f, -1.05617963e-01f, -1.49489492e-01f, 1.60204858e-01f, -2.49587178e-01f,
  -2.76105791e-01f, -2.74003036e-02f, 4.20195907e-02f, -5.94795980e-02f, -1.52714998e-01f, 1.61202997e-01f, 1.78753268e-02f, -4.47038412e-02f, 1.01819970e-01f, 2.27150932e-01f,
  -8.72634426e-02f, -8.20790902e-02f, -1.58549756e-01f, 9.96438712e-02f, -2.70875663e-01f, 1.15577616e-01f, 1.67969808e-01f, 8.04739818e-02f, 1.25896245e-01f, -1.82001412e-01f,
  -1.80604964e-01f, -8.22630823e-02f, -1.39863491e-01f, -1.05575956e-01f, 5.45701325e-01f, 4.00211871e-01f, 3.08151573e-01f, -2.01773882e-01f, -4.26758289e-01f, -4.07515407e-01f,
  4.97167520e-02f, -4.26123776e-02f, -4.50375229e-01f, -9.83705092e-03f, -1.88445952e-02f, -2.24941283e-01f, 7.69483903e-03f, -1.89958647e-01f, -5.33335991e-02f, 1.36110978e-02f,
  -6.39240146e-02f, 4.62910146e-01f, 8.32378641e-02f, 1.09343879e-01f, 1.29361600e-01f, 9.73999649e-02f, 1.21727183e-01f, 3.45121436e-02f, -3.75014283e-02f, 1.23941943e-01f,
  1.36058971e-01f, 4.98897769e-02f, 1.03868589e-01f, 1.86850980e-01f, 1.01637416e-01f, -3.52262296e-02f, 3.93002145e-02f, 3.82851511e-02f, 6.01154566e-02f, 1.48700606e-02f,
  -6.50667027e-02f, 1.41477332e-01f, 5.95482364e-02f, 1.24075906e-02f, 8.35445002e-02f, 2.64502447e-02f, 3.60171273e-02f, -4.29419130e-02f, 2.60774363e-02f, 6.18963614e-02f,
  -5.53265354e-03f, 1.34954795e-01f, 1.38173506e-01f, 8.06907415e-02f, 5.42837642e-02f, 2.39265680e-01f, -8.24630633e-02f, 1.27848566e-01f, 1.03459088e-02f, 1.94599573e-02f,
  7.97628835e-02f, 1.65085435e-01f, 8.13318864e-02f, 5.73141966e-03f, 8.70484039e-02f, -8.48759525e-03f, 9.30379778e-02f, 1.99121296e-01f, 2.02103049e-01f, 4.22919728e-02f,
  1.26443893e-01f, 3.16157080e-02f, 1.43537611e-01f, 2.27570191e-01f, 2.86751203e-02f, 1.20518722e-01f, 4.73028310e-02f, -6.53577968e-02f, 2.75131255e-01f, -1.74156912e-02f,
  2.40638722e-02f, -2.31396809e-01f, 1.09600890e-02f, 4.34750840e-02f, -1.16174676e-01f, -2.43548639e-02f, -1.52870283e-01f, -1.35397762e-01f, 2.72308230e-01f, -2.46921942e-01f,
  -5.13440892e-02f, -1.40362263e-01f, 3.16288881e-02f, -1.57601997e-01f, -1.86638888e-02f, 1.22529067e-01f, 4.22629388e-03f, -1.11057200e-01f, 1.21014774e-01f, -2.04738647e-01f,
  -1.84615657e-01f, 1.08415224e-01f, -3.24614465e-01f, -1.68786660e-01f, -1.53292092e-02f, -2.34127622e-02f, -1.08777851e-01f, 7.62186125e-02f, -7.95646906e-02f, 1.65908113e-01f,
  6.93025142e-02f, -8.36716816e-02f, 8.64463451e-04f, -1.25378713e-01f, 2.87283033e-01f, 5.62212430e-02f, 1.04170874e-01f, 5.35692759e-02f, -2.04575464e-01f, 2.37668857e-01f,
  -2.02348500e-01f, 7.95841869e-03f, -8.82099792e-02f, -2.81436652e-01f, 9.55498517e-02f, -2.88644671e-01f, -2.48200342e-01f, -2.43383840e-01f, -3.93625461e-02f, 1.42024785e-01f,
  -1.52622834e-01f, 4.03717130e-01f, 4.81618673e-01f, 2.29016021e-01f, 2.25203633e-01f, 1.93374917e-01f, -1.91476107e-01f, -1.56058325e-02f, 3.42852063e-02f, 8.50573331e-02f,
  9.53146163e-03f, -1.37172520e-01f, -8.83576833e-03f, -8.48320723e-02f, 2.10195631e-01f, 2.37289742e-02f, -4.34485450e-02f, 1.98815152e-01f, 4.98549640e-02f, -5.53205967e-01f,
  6.02505505e-02f, 1.67442277e-01f, 1.99021189e-03f, 1.71733096e-01f, 7.91391954e-02f, 1.89373776e-01f, 8.88355896e-02f, -3.68201956e-02f, 5.86010441e-02f, 1.03760034e-01f,
  8.32179710e-02f, 1.65686049e-02f, 1.85120441e-02f, -2.03916822e-02f, 5.93056865e-02f, -3.56150903e-02f, 1.01490229e-01f, 3.91494408e-02f, 1.30203947e-01f, 7.24269748e-02f,
  2.73295492e-02f, 2.46168688e-01f, -3.71100544e-03f, 2.10475158e-02f, 4.71570753e-02f, 1.25856996e-01f, 6.02660403e-02f, 1.72050014e-01f, -4.74071577e-02f, 7.42285028e-02f,
  6.80099707e-03f, 5.15943952e-02f, 1.24132283e-01f, 2.06012294e-01f, 8.99558961e-02f, -1.04166858e-01f, -2.72976365e-02f, -3.25798579e-02f, 1.81097239e-01f, 1.63510337e-01f,
  4.57339622e-02f, 5.19089215e-02f, 2.23533109e-01f, -1.56899080e-01f, 1.70391817e-02f, 1.38775200e-01f, 8.14389810e-02f, -3.00412085e-02f, 2.04412695e-02f, 8.08857828e-02f,
  1.60082966e-01f, -1.44617423e-01f, -7.05611855e-02f, 3.26077975e-02f, -5.76836802e-02f, 1.81985363e-01f, 6.91101560e-03f, -7.25025162e-02f, 2.09236190e-01f, 1.34578168e-01f,
  -8.00340399e-02f, -1.19726069e-01f, -2.38751713e-02f, -1.09150819e-01f, 2.31809974e-01f, 3.14372182e-02f, -3.12344164e-01f, 2.30375957e-03f, -3.17656510e-02f, -2.11657777e-01f,
  -3.27420272e-02f, 2.61233360e-01f, -1.93286717e-01f, -5.42756170e-02f, -1.64444968e-01f, -1.99907050e-01f, -8.20511654e-02f, 1.57428250e-01f, 5.28538339e-02f, -2.52591133e-01f,
  2.79017657e-01f, -1.47590367e-02f, -6.54922798e-02f, -1.15624107e-01f, -1.20629802e-01f, -1.16476759e-01f, -1.90063387e-01f, -6.15542755e-02f, 3.48489508e-02f, 3.43838893e-02f,
  2.72512019e-01f, 1.14719886e-02f, -3.46618384e-01f, -8.06306601e-02f, -5.19771799e-02f, 1.31754950e-01f, 6.61694026e-03f, 1.48008689e-01f, 3.89007889e-02f, -1.90804705e-01f,
  -9.59186181e-02f, 2.37126872e-02f, 3.78925830e-01f, 1.23334788e-01f, 1.84470296e-01f, -9.74895954e-02f, 9.60491970e-02f, 2.22424284e-01f, -1.49238989e-01f, -1.47241339e-01f,
  4.19347018e-01f, 3.66633207e-01f, 1.13603003e-01f, 2.90743280e-02f, -8.42673853e-02f, 2.61012428e-02f, 4.80336584e-02f, 1.49952009e-01f, -3.72744538e-02f, -5.64217679e-02f,
  5.91093069e-03f, -3.63520259e-04f, 2.87843868e-02f, -1.95079505e-01f, 6.21098280e-02f, -1.67408839e-01f, 1.20001864e-02f, 2.61520445e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  9.45565552e-02f, 2.72448510e-01f, -4.92628440e-02f, 2.46228073e-02f, 7.90445134e-02f, 1.40973087e-02f, 9.63823721e-02f, 1.50510997e-01f, 9.19212773e-03f, 2.57035524e-01f,
  1.24595039e-01f, 1.40034944e-01f, 1.24316365e-01f, -3.41183431e-02f, 5.21453954e-02f, 1.73443004e-01f, 2.03906447e-01f, 2.22607195e-01f, 8.23155940e-02f, 1.50960665e-02f,
  1.00529417e-01f, 2.96805918e-01f, -1.27999127e-01f, 1.73002005e-01f, 1.84550628e-01f, 1.74507678e-01f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  6.97621107e-02f, -8.65294635e-02f, -1.88315675e-01f, 1.46911159e-01f, 9.38109383e-02f, -5.03398031e-02f, 1.00621961e-01f, -2.48773862e-02f, 6.77366853e-02f, -3.70558202e-02f,
  1.24489374e-01f, 2.15423927e-02f, -2.33769685e-01f, -2.05083072e-01f, -1.33229783e-02f, 8.07963908e-02f, 2.20741794e-01f, -1.71021581e-01f, -3.35082680e-01f, -3.10452312e-01f,
  -7.05238953e-02f, 2.82088697e-01f, -1.19731631e-02f, 2.91622020e-02f, -1.24378063e-01f, -2.60448813e-01f, -3.30222994e-02f, 2.28179500e-01f, -2.14563623e-01f, -6.40063360e-02f,
  -1.77064270e-01f, -5.36538800e-03f, -5.68079110e-03f, -2.43713766e-01f, -2.13703707e-01f, 1.68000266e-01f, -3.44067395e-01f, -1.17661633e-01f, 8.44412223e-02f, 3.37647051e-02f,
  -1.29608884e-01f, -2.11611256e-01f, 1.80952493e-02f, -4.98632118e-02f, -3.37248594e-01f, -4.45704639e-01f, 1.09653056e-01f, -1.13848194e-01f, -2.23596022e-01f, 8.11969638e-02f,
  -3.20543468e-01f, 3.55042145e-02f, 1.23018503e-01f, -1.75434873e-01f, 1.97820768e-01f, -1.51406422e-01f, -1.01559155e-01f, 1.03354536e-01f, 9.26471800e-02f, -3.41505930e-02f,
  1.76903307e-01f, 3.04143101e-01f, -2.19775900e-01f, 1.31765157e-01f, 1.01118259e-01f, 4.42608893e-01f, -5.48481904e-02f, -4.11932729e-02f, -1.58367380e-01f, -1.44391686e-01f,
  9.75945443e-02f, -3.53433013e-01f, -2.86542624e-01f, -5.59802875e-02f, -1.88297749e-01f, 1.27354473e-01f, 4.83015105e-02f, 2.61445940e-01f, 1.30466744e-01f, 4.14380431e-02f,
  -2.64963329e-01f, 1.88531652e-01f, 1.10075362e-01f, -3.79206747e-01f, 9.78356898e-02f, -4.69074119e-03f, 7.75601193e-02f, 7.50770420e-02f, -1.74542651e-01f, -1.55665025e-01f,
  -1.53264493e-01f, 1.13841049e-01f, 9.63046327e-02f, 5.02466857e-01f, 3.52724761e-01f, -3.69970948e-02f, -1.66374028e-01f, 1.15782589e-01f, -1.48802027e-01f, -7.97420368e-02f,
  1.77559070e-02f, 1.27007842e-01f, -3.46484423e-01f, -1.61649510e-01f, 1.81494847e-01f, 1.49887770e-01f, -4.12987351e-01f, 1.33170530e-01f, -7.75185972e-02f, -5.43339431e-01f,
  1.09805554e-01f, -2.75152534e-01f, -6.95150971e-01f, -2.05357611e-01f, 1.23995133e-01f, -4.09949757e-02f, 4.13554758e-02f, -1.97290495e-01f, -3.72509778e-01f, 1.19716361e-01f,
  -1.13802746e-01f, 1.40939161e-01f, -2.72042751e-01f, -4.99252051e-01f, 2.44918227e-01f, -1.96659997e-01f, -4.73422468e-01f, -1.51740924e-01f, -1.93915054e-01f, 1.52383193e-01f,
  -1.49872869e-01f, -3.94264497e-02f, 1.20207012e-01f, 1.55900642e-01f, -4.15319623e-03f, 2.09794670e-01f, 2.01990027e-02f, 5.07336408e-02f, 3.75008509e-02f, -1.97065979e-01f,
  4.21926118e-02f, 1.18919723e-01f, -6.15828345e-03f, 5.49584068e-02f, 8.38343203e-02f, 3.30249220e-01f, -4.20732163e-02f, -3.84266555e-01f, 1.34720653e-01f, 3.49484980e-02f,
  -3.14082563e-01f, -5.95505722e-02f, 3.05127054e-01f, 1.32532030e-01f, 3.18639800e-02f, -5.92310959e-03f, -2.10295141e-01f, -6.03359900e-02f, -3.33752066e-01f, 1.86103910e-01f,
  -3.33567172e-01f, 3.73852924e-02f, 7.05450922e-02f, 7.45010981e-03f, 2.14884922e-01f, -2.16993704e-01f, 6.98286071e-02f, -1.76571339e-01f, -2.16243178e-01f, 2.13919699e-01f,
  1.58449799e-01f, -2.74557546e-02f, -2.72082388e-01f, -1.25850707e-01f, -1.44802302e-01f, 7.47348294e-02f, -2.41899729e-01f, -2.41133496e-01f, 2.63300017e-02f, 7.70272538e-02f,
  -6.80818632e-02f, 2.79774606e-01f, -1.73089564e-01f, 1.54740244e-01f, -7.95077384e-02f, 2.79761374e-01f, 8.60073864e-02f, -1.61262434e-02f, -1.38257211e-02f, -1.24689832e-01f,
  2.47560650e-01f, -2.12382466e-01f, 1.07237212e-01f, 1.63753316e-01f, -1.80245519e-01f, -3.74507606e-02f, -3.55983466e-01f, -4.35308725e-01f, 1.18060112e-01f, -2.53307730e-01f,
  -1.40588418e-01f, -5.78522235e-02f, -2.35029235e-01f, 3.68366599e-01f, 3.30923915e-01f, -4.11920473e-02f, -2.78883427e-01f, 2.75970966e-01f, 1.99708015e-01f, -3.88606131e-01f,
  -3.58273387e-01f, 2.20661670e-01f, -2.82335311e-01f, -1.50548562e-01f, -3.38838249e-01f, 9.73548368e-02f, 3.38023841e-01f, -3.13683189e-02f, -2.31904194e-01f, -1.27499148e-01f,
  1.82614356e-01f, 1.56826437e-01f, -5.59142083e-02f, 6.71570227e-02f, -1.63587913e-01f, -1.24592140e-01f, 3.58908534e-01f, 4.25771698e-02f, -4.04204637e-01f, -4.87496704e-02f,
  -1.79936111e-01f, 6.95164055e-02f, -1.68932661e-01f, 1.00470662e-01f, 1.67087093e-01f, 1.32825166e-01f, -7.96809942e-02f, 1.70883425e-02f, 1.59673825e-01f, -5.20658016e-01f,
  1.85302928e-01f, 2.44013164e-02f, 1.29780620e-01f, -8.61759186e-02f, -2.71525204e-01f, -1.80732161e-02f, -2.37571169e-02f, -7.86117792e-01f, 4.91247280e-03f, 2.07546324e-01f,
  -1.59784913e-01f, -6.20011330e-01f, 1.10992916e-01f, 1.88610088e-02f, -2.23354530e-02f, 1.61943674e-01f, 1.33743942e-01f, 1.26791805e-01f, -1.33233860e-01f, 9.34155844e-03f,
  -1.96360424e-01f, -1.55193567e-01f, 2.42255870e-02f, -4.08444583e-01f, -3.91251780e-02f, 8.56959522e-02f, -1.69667378e-01f, 6.89628646e-02f, -2.26605073e-01f, 1.02907792e-01f,
  -2.27946490e-01f, -3.87440443e-01f, -3.08808368e-02f, -2.80902237e-01f, 2.10690364e-01f, 9.67062563e-02f, 5.90871908e-02f, -4.28732522e-02f, 1.22428864e-01f, -1.06127068e-01f,
  8.99332166e-02f, 2.42614120e-01f, -1.25387892e-01f, -8.42819661e-02f, 7.51923472e-02f, -5.13255410e-02f, -1.08370863e-01f, -8.54646713e-02f, -6.54905885e-02f, -9.01223160e-03f,
  -4.73214593e-03f, -4.56179045e-02f, -1.67785794e-01f, 6.16940558e-02f, 1.01858843e-03f, -3.55915911e-02f, -1.30413115e-01f, -2.01668009e-01f, -2.71785587e-01f, 1.46134999e-02f,
  -3.15837085e-01f, 1.24299871e-02f, 6.06796853e-02f, 4.41415720e-02f, 2.78268009e-01f, -3.49321663e-01f, 6.80438057e-02f, -2.44396299e-01f, -2.26906434e-01f, 2.43575796e-01f,
  -2.12834869e-02f, 2.79432207e-01f, -1.75318420e-01f, 1.37751833e-01f, 1.12861387e-01f, 1.69324398e-01f, -1.12977050e-01f, -3.95760715e-01f, -3.23307849e-02f, 9.59783699e-03f,
  1.25781506e-01f, -3.41109261e-02f, -1.61514748e-02f, 4.52459604e-01f, 3.95371914e-01f, 1.56663597e-01f, -4.17266071e-01f, 8.72359276e-02f, -3.80642526e-02f, 8.49792883e-02f,
  -2.22994655e-01f, 6.96823234e-03f, -1.09407693e-01f, -4.37422581e-02f, 3.52243036e-01f, -1.15040846e-01f, 3.43017429e-02f, -1.05912000e-01f, -2.55450368e-01f, -2.12977678e-01f,
  -4.39727530e-02f, 3.05551797e-01f, 1.65734842e-01f, -6.19197972e-02f, 1.19820282e-01f, 1.30453438e-01f, 1.80186152e-01f, -2.69009233e-01f, 7.67832622e-02f, -3.54256541e-01f,
  -1.08318947e-01f, 2.88972050e-01f, 1.49529234e-01f, 2.19328448e-01f, 6.46657199e-02f, 6.92025796e-02f, -7.79212788e-02f, 3.54194999e-01f, -3.00739169e-01f, 7.46796727e-02f,
  4.61925156e-02f, 1.89665303e-01f, -5.89960992e-01f, -8.51442814e-02f, 1.04825728e-01f, -2.40281180e-01f, 5.39613254e-02f, 2.77477741e-01f, -8.72342587e-02f, -6.27978370e-02f,
  4.24169600e-02f, -3.45846772e-01f, -2.98237622e-01f, -1.87546629e-02f, 1.39519349e-01f, -1.90353811e-01f, 2.29957417e-01f, 1.42147854e-01f, 1.80421341e-02f, -9.89044458e-02f,
  1.19180895e-01f, -2.41385072e-01f, -3.24970841e-01f, -1.69766814e-01f, -6.22305647e-02f, -3.58501673e-01f, -2.29580868e-02f, -5.12494981e-01f, 4.93549090e-03f, -2.32553616e-01f,
  6.30084984e-03f, -5.76162599e-02f, 1.55728310e-02f, -2.86949843e-01f, 8.85822922e-02f, -2.27057159e-01f, 2.79194638e-02f, -3.87497902e-01f, 8.16840455e-02f, -2.26038904e-03f,
  7.11064339e-02f, -2.31883787e-02f, -2.52319247e-01f, -2.41906911e-01f, -2.88195349e-02f, -2.00454015e-02f, 4.92848232e-02f, -9.51798260e-02f, -1.27123725e-02f, -1.93097115e-01f,
  -1.39525503e-01f, -3.19314480e-01f, 1.77660584e-01f, -5.18420432e-03f, 2.46368632e-01f, -3.92520398e-01f, -2.85528094e-01f, 3.51223648e-02f, -1.92777351e-01f, 9.98068601e-02f,
  1.43477693e-01f, 1.67653523e-02f, -1.61871649e-02f, -2.05731481e-01f, 1.55887166e-02f, -2.08179548e-01f, -4.73277196e-02f, -1.67806357e-01f, 7.57890120e-02f, 5.86657710e-02f,
  -3.82289976e-01f, -1.65626511e-01f, 2.21435055e-01f, -3.73492539e-02f, 4.59569767e-02f, 1.08505033e-01f, -1.66840866e-01f, 1.75070211e-01f, -1.14347331e-01f, 2.38354817e-01f,
  -1.55895725e-01f, 3.70671213e-01f, 2.79345244e-01f, -5.27658880e-01f, -1.80961788e-01f, 1.74999580e-01f, -4.91539128e-02f, 2.74331719e-01f, -2.17153300e-02f, -1.19653948e-01f,
  -2.39408031e-01f, 1.28021181e-01f, 5.12025237e-01f, -4.70488630e-02f, 5.98635077e-02f, -1.20845936e-01f, 9.29328054e-02f, 3.85991365e-01f, 5.37013263e-02f, 1.29694581e-01f,
  -1.97251122e-02f, -3.02700967e-01f, -5.07894158e-02f, -1.64501712e-01f, -1.60987124e-01f, 1.49399951e-01f, -1.17101535e-01f, 2.12399028e-02f, -2.38218591e-01f, -4.67125559e-03f,
  -6.95237815e-02f, -6.85385317e-02f, -1.38678616e-02f, -2.01681763e-01f, 1.05063498e-01f, -7.98912719e-02f, 9.65881124e-02f, -8.84682760e-02f, -7.79108480e-02f, 2.62473196e-01f,
  -5.56315482e-03f, -6.14635497e-02f, 2.66103842e-03f, -2.83817165e-02f, -1.04853168e-01f, 1.68823957e-01f, 2.33971789e-01f, -4.30293411e-01f, 4.59513478e-02f, -1.55904598e-03f,
  -6.57808959e-01f, 1.61108263e-02f, -6.01749361e-01f, -6.24424338e-01f, 2.54410133e-03f, -1.17015772e-01f, 1.74789242e-02f, -2.97141284e-01f, -7.03921854e-01f, 3.70155364e-01f,
  2.00743347e-01f, -3.22163165e-01f, 6.37102947e-02f, -1.11230135e-01f, 1.81744918e-01f, 3.00030317e-02f, 4.85602766e-02f, 1.25324130e-01f, 1.39190361e-01f, -5.12887418e-01f,
  -6.43679619e-01f, 7.32252970e-02f, -1.58676639e-01f, 1.15145497e-01f, -1.12122245e-01f, 8.61577615e-02f, 1.70576982e-02f, 4.32615541e-02f, -9.24625322e-02f, -6.30352944e-02f,
  1.76476687e-01f, -3.79582681e-02f, 5.92840947e-02f, 1.72093228e-01f, 9.91927646e-03f, 2.94648796e-01f, -1.18304469e-01f, 5.10668047e-02f, -2.37434939e-01f, 7.24427029e-03f,
  1.99712068e-01f, -1.02016352e-01f, -7.43184835e-02f, -9.38105658e-02f, 3.26090813e-01f, -6.34977147e-02f, -6.58711568e-02f, 2.01828834e-02f, 1.05298854e-01f, -1.21184528e-01f,
  1.51079103e-01f, 1.43830329e-01f, -1.35133326e-01f, 6.35444745e-02f, 1.43938586e-01f, 8.54015276e-02f, 1.70530364e-01f, -1.93384394e-01f, 8.09198618e-02f, -3.57506692e-01f,
  -1.05814189e-01f, -1.77250966e-01f, 5.40060699e-02f, 7.49146119e-02f, -2.36411855e-01f, -3.41060609e-01f, 3.08962226e-01f, 4.99547236e-02f, 8.75978470e-02f, -1.93745136e-01f,
  1.13068245e-01f, 1.16922952e-01f, -5.07240355e-01f, 1.49022147e-01f, 3.93481463e-01f, 2.18392342e-01f, 2.73511827e-01f, -3.11408579e-01f, -6.89461157e-02f, -3.64000320e-01f,
  -3.05728670e-02f, 1.70960546e-01f, 1.04924120e-01f, 7.50185400e-02f, -2.25623846e-01f, -9.01736319e-02f, 1.98751852e-01f, -3.38569224e-01f, 2.26343215e-01f, 1.69040281e-02f,
  -1.36388987e-01f, 9.42119732e-02f, -4.34518188e-01f, 2.24162921e-01f, 3.25293243e-01f, 1.24018416e-02f, 2.09632829e-01f, -1.65593699e-01f, -1.18650630e-01f, 2.32535318e-01f,
  2.17170089e-01f, -2.93844696e-02f, -2.56589592e-01f, -1.72833368e-01f, 3.00582767e-01f, 5.59364498e-01f, -1.64147764e-01f, -5.13184667e-01f, 2.29118258e-01f, -2.12007351e-02f,
  5.10813743e-02f, 2.80196905e-01f, 2.79417753e-01f, -1.99802205e-01f, 6.62275478e-02f, -1.69802964e-01f, -1.14592090e-01f, -2.87353635e-01f, 7.44272396e-02f, 3.35595220e-01f,
  -1.99609175e-01f, 4.03407067e-01f, 2.70857483e-01f, -1.09569207e-01f, -4.09023501e-02f, -5.43808341e-01f, 9.11706686e-02f, 3.24138999e-02f, 8.97031352e-02f, 1.18759342e-01f,
  3.67233716e-02f, 5.62147796e-02f, 1.16181634e-01f, 1.24807231e-01f, -5.57141006e-01f, -1.87855065e-01f, -5.66509031e-02f, -2.79739946e-01f, 3.04683205e-02f, 1.05708070e-01f,
  -2.06271000e-02f, 5.34910150e-02f, -2.44879916e-01f, -2.23266453e-01f, 9.02790651e-02f, 2.36167476e-01f, 1.82550494e-02f, -1.25922889e-01f, 6.65309429e-02f, -2.50644475e-01f,
  2.65311939e-03f, -4.34129499e-02f, 1.63910016e-01f, 9.38989297e-02f, -6.09035157e-02f, -6.92284256e-02f, -2.63301190e-03f, 1.18175931e-01f, 1.92617670e-01f, -2.31601670e-01f,
  -1.54490158e-01f, -2.19853707e-02f, 1.15936562e-01f, 1.25668794e-01f, 1.28167540e-01f, -9.27104577e-02f, 4.78297621e-02f, 4.10969416e-03f, 2.19329551e-01f, 1.41700536e-01f,
  5.82926609e-02f, -2.88992584e-01f, -3.11557740e-01f, 1.04866095e-01f, 2.98732053e-02f, 2.13071890e-02f, 2.36996710e-01f, 1.35799527e-01f, 2.23423421e-01f, 1.72657520e-01f,
  2.41491944e-01f, 1.08138040e-01f, 2.10627943e-01f, 1.79522395e-01f, 1.47360831e-01f, 2.88527906e-01f, -1.99887484e-01f, 2.66106933e-01f, -1.06017970e-01f, 1.94790795e-01f,
  1.44141853e-01f, 8.34855810e-02f, 1.32534802e-01f, 6.84598386e-02f, 1.10440232e-01f, 2.45434910e-01f, -4.26725186e-02f, 2.89006442e-01f, -1.70373041e-02f, 2.37676144e-01f,
  1.14862576e-01f, 2.08705351e-01f, -3.52009475e-01f, 7.65016526e-02f, -1.68189213e-01f, -3.79803628e-02f, 2.79010832e-01f, -4.57188450e-02f, -7.33610019e-02f, -5.58746196e-02f,
  -7.07064196e-02f, -2.63669938e-02f, 1.51722148e-01f, -9.57059935e-02f, -1.80976719e-01f, -6.06508031e-02f, 4.71569449e-01f, -2.65999138e-01f, -4.63508248e-01f, 2.51320243e-01f,
  -2.00853005e-01f, 3.39401484e-01f, -2.00586274e-01f, -2.60835320e-01f, 1.53721392e-01f, -3.74408774e-02f, -7.54843978e-03f, 7.17160031e-02f, -2.08705440e-01f, -8.29435214e-02f,
  -2.90778339e-01f, -1.62502438e-01f, 7.90441409e-02f, -2.25852057e-01f, 1.47781242e-02f, -2.66059160e-01f, 2.40248650e-01f, -7.24318624e-02f, 3.61497439e-02f, 9.32659730e-02f,
  -1.60708070e-01f, -1.53533161e-01f, -1.64800495e-01f, 4.44349766e-01f, -2.94226915e-01f, -3.14932436e-01f, 1.26143277e-01f, -3.33026379e-01f, -1.86010391e-01f, 2.92764992e-01f,
  4.05888647e-01f, -8.23505521e-02f, 2.23799035e-01f, 2.24712074e-01f, 1.03876285e-01f, -2.56045640e-01f, -1.37472764e-01f, 1.00969166e-01f, -1.26951993e-01f, -2.92551160e-01f,
  -3.98994163e-02f, -3.08047235e-01f, -1.84400946e-01f, -5.69979906e-01f, 2.38400195e-02f, -2.21669152e-01f, 2.02525537e-02f, -3.08964878e-01f, -1.48095995e-01f, 3.12501281e-01f,
  -6.65780842e-01f, -1.25275642e-01f, 1.89641610e-01f, -5.93581438e-01f, 6.46594092e-02f, 1.15352392e-01f, 2.32324347e-01f, 9.21715572e-02f, -1.29807815e-01f, -2.15361580e-01f,
  8.89341757e-02f, 2.08094046e-02f, 1.68329760e-01f, 1.02395833e-01f, 6.66028112e-02f, -5.99026009e-02f, -1.81286514e-01f, 6.98786303e-02f, 1.39941931e-01f, -6.75996318e-02f,
  -1.89143166e-01f, 4.42517437e-02f, -1.28904030e-01f, 6.81507587e-02f, 1.28390715e-01f, -2.41571039e-01f, -2.19945401e-01f, 7.53112733e-02f, -2.85327822e-01f, -3.67939584e-02f,
  6.63964674e-02f, 1.94518194e-02f, -2.36479953e-01f, -1.10291541e-01f, 6.70293197e-02f, -2.95522958e-02f, -2.49820173e-01f, -1.90523475e-01f, 1.64908603e-01f, 1.71092786e-02f,
  -1.36665195e-01f, 4.52876687e-02f, -2.75792092e-01f, -1.19593322e-01f, -1.47744074e-01f, 1.03357702e-01f, 2.85786957e-01f, 1.23453617e-01f, 1.55026436e-01f, -1.52977863e-02f,
  -2.22270891e-01f, -1.50254574e-02f, 1.52901664e-01f, -9.59229469e-02f, -4.06323932e-02f, 1.55376717e-01f, -8.71380791e-02f, 1.19139358e-01f, 6.35949001e-02f, -2.98250675e-01f,
  -3.41271698e-01f, -4.80378270e-01f, -2.41231307e-01f, 7.40559623e-02f, -1.27384320e-01f, -2.84799755e-01f, -6.37379214e-02f, -3.01112141e-02f, 1.27090022e-01f, 6.44351647e-04f,
  3.33792306e-02f, -1.04890555e-01f, -2.73015559e-01f, -2.04925418e-01f, 2.69826483e-02f, 2.40394458e-01f, -7.36848935e-02f, -1.25141302e-02f, 8.34592134e-02f, 1.21675760e-01f,
  2.73243040e-01f, 1.01854593e-01f, -2.84418881e-01f, 4.64348607e-02f, 9.87514555e-02f, -9.51643661e-02f, -5.50162673e-01f, -1.05869295e-02f, 1.91948622e-01f, 1.63582161e-01f,
  -2.25389645e-01f, -5.07569909e-01f, 4.00995880e-01f, 3.59028503e-02f, -4.98744240e-03f, 3.27878855e-02f, -2.03701541e-01f, -1.38014302e-01f, -4.39262874e-02f, 4.27685678e-01f,
  -1.39342144e-01f, 2.01789308e-02f, 1.20855838e-01f, -4.82250676e-02f, 2.36351892e-01f, -1.70083657e-01f, 5.97172789e-02f, -2.66607434e-01f, 3.44182625e-02f, -2.71460086e-01f,
  2.68203206e-02f, 1.83804929e-01f, -2.61801153e-01f, 3.13310511e-02f, -1.30599707e-01f, -6.57861054e-01f, 2.06826225e-01f, 9.99812130e-03f, -1.44964188e-01f, 2.85820700e-02f,
  1.95683278e-02f, -3.76360208e-01f, 9.75691527e-03f, -4.34138864e-01f, -7.04040051e-01f, 2.91182101e-01f, -9.43247154e-02f, -2.94170290e-01f, -2.29151905e-01f, -4.52440888e-01f,
  1.54940292e-01f, 3.32732916e-01f, 5.07170111e-02f, -1.75965264e-01f, 1.87927365e-01f, -3.35562915e-01f, -1.97253004e-01f, -1.01813041e-01f, 6.57476708e-02f, -1.63197935e-01f,
  -8.40156674e-02f, -6.33345619e-02f, -1.72025278e-01f, -2.14378685e-01f, -1.16290048e-01f, -4.15922739e-02f, -2.62067884e-01f, -6.91310763e-02f, -1.67953931e-02f, 2.09034421e-02f,
  -1.59558549e-04f, -1.68620441e-02f, -1.51582971e-01f, 8.97013620e-02f, -1.99441209e-01f, -1.23075150e-01f, -1.18243857e-03f, -2.02981740e-01f, -6.65711835e-02f, -1.00902647e-01f,
  -2.06199631e-01f, -3.63935195e-02f, -6.16916157e-02f, -1.45757973e-01f, -4.87302169e-02f, 1.00440517e-01f, 3.55554186e-02f, -1.76506028e-01f, -1.83899030e-01f, 5.01640961e-02f,
  -1.83229614e-02f, -2.05180272e-01f, -4.02977206e-02f, 1.33547023e-01f, 1.20798789e-01f, -2.79302388e-01f, 3.88270505e-02f, 2.01901942e-01f, -1.29216760e-01f, 2.44851466e-02f,
  -2.21940726e-01f, 1.34812184e-02f, -2.49389019e-02f, -2.01091513e-01f, -2.83551633e-01f, -9.42042619e-02f, 1.44879520e-01f, -2.87222952e-01f, 3.88734728e-01f, 6.92936704e-02f,
  -4.76688705e-02f, 6.67571649e-02f, 1.58532977e-01f, 1.34228587e-01f, -1.18468165e-01f, -1.22873053e-01f, -1.00373045e-01f, 1.52336672e-01f, -1.53617054e-01f, 7.03657344e-02f,
  1.07696980e-01f, 1.98586717e-01f, -2.16182284e-02f, -9.86305848e-02f, -8.26670825e-02f, 9.11235958e-02f, 2.20312774e-01f, 1.71918392e-01f, 2.14968473e-01f, 2.23178212e-02f,
  2.44502649e-01f, -1.27624318e-01f, -2.25507349e-01f, 2.28503674e-01f, 1.08386308e-01f, -2.12301418e-01f, -7.38965496e-02f, 1.17953449e-01f, 1.85346320e-01f, 2.41602615e-01f,
  -2.10282415e-01f, -1.24680959e-02f, 8.88061374e-02f, 8.16260651e-02f, 1.48262158e-01f, -1.78712055e-01f, -9.62072164e-02f, -1.09907314e-02f, -1.21857546e-01f, -3.39303583e-01f,
  7.15281963e-02f, -4.13978845e-02f, -2.07939252e-01f, -9.20398459e-02f, -5.02064712e-02f, -1.03361815e-01f, 6.11011945e-02f, -1.41157061e-01f, -8.10585096e-02f, -4.49175984e-01f,
  -2.46429443e-01f, -3.55330706e-01f, 8.00151676e-02f, -5.48423588e-01f, 6.49890155e-02f, 1.82092071e-01f, -1.25135601e-01f, 2.38250464e-01f, 1.00800373e-01f, -1.01075262e-01f,
  -1.60982430e-01f, 2.64356226e-01f, -1.61691178e-02f, -4.15257275e-01f, 2.24529535e-01f, 2.58887380e-01f, -2.06774622e-01f, -1.87852373e-03f, 4.60214680e-03f, -2.32588366e-01f,
  -1.27340987e-01f, 2.86023259e-01f, 1.35735692e-02f, 7.66519755e-02f, 5.15363179e-02f, 6.02018200e-02f, 1.31494015e-01f, 1.91144392e-01f, -1.33009791e-01f, 5.62984571e-02f,
  -1.43970132e-01f, 1.57613441e-01f, 2.62786262e-02f, 2.26714909e-01f, 1.38252437e-01f, 2.84145474e-01f, 1.24073185e-01f, -3.05472374e-01f, 1.17834151e-01f, 1.55211061e-01f,
  1.88026041e-01f, -2.43459150e-01f, 1.69502899e-01f, -3.75806987e-02f, 8.11590999e-03f, 1.24793813e-01f, 1.40713200e-01f, -1.63942599e-03f, -5.23274988e-02f, 1.06709488e-01f,
  -4.85426523e-02f, -7.22629204e-02f, -4.83820289e-02f, 1.91801190e-01f, 3.02192532e-02f, 8.25009644e-02f, 3.12460095e-01f, 1.51903098e-02f, 1.30436942e-01f, 2.03365963e-02f,
  4.60156091e-02f, -1.27565593e-01f, 4.95811850e-02f, 2.20969796e-01f, -1.02846690e-01f, -1.28824517e-01f, 1.93231076e-01f, 3.10449868e-01f, 2.50443339e-01f, 2.83286214e-01f,
  3.75435382e-01f, -1.80733670e-02f, -5.73990820e-03f, 4.59267981e-02f, -2.00450689e-01f, -2.73987263e-01f, -1.21771805e-01f, -2.96440989e-01f, 4.94794035e-03f, -3.84461023e-02f,
  5.35840392e-01f, 2.88530022e-01f, -1.62363313e-02f, -3.62490982e-01f, -3.39582786e-02f, -5.67336418e-02f, 3.26645896e-02f, 4.75945711e-01f, 4.94332999e-01f, -8.00513998e-02f,
  -9.71913338e-02f, 4.36426312e-01f, 3.17170352e-01f, 3.48591030e-01f, 4.71148193e-01f, -1.17773011e-01f, -2.39644408e-01f, -3.66703212e-01f, 4.21644628e-01f, -3.93824041e-01f,
  2.36678839e-01f, 1.23456167e-02f, -2.11651638e-01f, 7.70150423e-02f, 3.86009701e-02f, 4.57085460e-01f, -1.24318011e-01f, 2.12154105e-01f, 1.85771972e-01f, 2.00405940e-01f,
  1.01327291e-02f, -1.35004610e-01f, 2.16407880e-01f, -2.88468182e-01f, 3.03460568e-01f, 3.05297494e-01f, -4.81903583e-01f, 2.36778036e-01f, 6.71595410e-02f, 6.66841343e-02f,
  2.30317280e-01f, 3.79133783e-02f, 2.54709333e-01f, -4.34511095e-01f, 1.36900097e-01f, -3.84691566e-01f, 1.41766906e-01f, 2.52761066e-01f, -4.85438295e-03f, -2.37930596e-01f,
  -1.90755904e-01f, -5.47929704e-01f, -3.90142612e-02f, 7.07730651e-02f, -2.87867427e-01f, -1.93841651e-01f, -2.90213041e-02f, 1.40291885e-01f, 4.71240981e-03f, -2.01817289e-01f,
  -1.06707141e-01f, -3.11839223e-01f, -8.93251151e-02f, -1.54096723e-01f, 4.23652112e-01f, 2.29887694e-01f, 7.41737112e-02f, -4.10492748e-01f, -3.62891227e-01f, -2.47844130e-01f,
  -2.14063257e-01f, 2.61567742e-01f, 2.61736810e-01f, -5.92301860e-02f, 3.21699649e-01f, 1.44214168e-01f, 1.50610775e-01f, 1.28809571e-01f, -5.59665710e-02f, 2.34240472e-01f,
  1.91723704e-02f, -1.95517063e-01f, 4.46235463e-02f, 2.53586173e-01f, -5.48620448e-02f, -1.56852469e-01f, 1.59597680e-01f, 2.86698937e-01f, 1.17046729e-01f, 5.17036200e-01f,
  2.77968526e-01f, 2.38855943e-01f, -1.46510363e-01f, -8.32903683e-02f, 2.72791922e-01f, 1.64552867e-01f, 3.73771667e-01f, -6.05079308e-02f, 6.79763779e-02f, 1.40685380e-01f,
  2.00602219e-01f, 2.24746659e-01f, -2.75846928e-01f, 5.93785234e-02f, 1.91229001e-01f, 2.26585120e-01f, 3.24053913e-01f, -2.56753564e-01f, -2.35247929e-02f, 2.69240767e-01f,
  1.34507734e-02f, 1.25560269e-01f, -3.82658511e-01f, -6.07431717e-02f, -1.08316243e-01f, 3.09827000e-01f, -4.39277887e-02f, 2.94522822e-01f, 2.27540523e-01f, -2.18434289e-01f,
  3.26211035e-01f, 5.11647239e-02f, 1.94557562e-01f, 1.49921477e-01f, -3.46004874e-01f, -1.80750459e-01f, 2.67207026e-01f, -3.37734878e-01f, -1.95795670e-01f, -1.76167861e-01f,
  -2.42553931e-03f, 2.76640803e-01f, 9.67170596e-02f, 1.63501948e-01f, 3.37640494e-01f, -5.80528565e-02f, -1.59905002e-01f, -1.91982552e-01f, 2.69496758e-02f, -4.10910785e-01f,
  5.69117777e-02f, 3.49991947e-01f, 2.83983976e-01f, 8.13715458e-02f, 3.87076944e-01f, 5.72340116e-02f, 4.98668738e-02f, -1.05371110e-01f, -1.20342553e-01f, -4.19899337e-02f,
  3.88210237e-01f, -1.58036143e-01f, 9.65471491e-02f, -3.36538613e-01f, -3.19229841e-01f, 1.54137788e-02f, -3.54806602e-01f, 4.11353201e-01f, 6.46655709e-02f, -4.03301939e-02f,
  -1.47430897e-01f, 8.71491432e-02f, -3.80650908e-01f, -3.42452854e-01f, 2.63536185e-01f, -2.04270929e-01f, 2.01212958e-01f, 2.78279036e-01f, 1.08173892e-01f, -1.30468607e-01f,
  -1.88510984e-01f, 7.79572316e-03f, -1.26471758e-01f, 2.27922097e-01f, -4.94063050e-01f, -6.30558804e-02f, -2.45268010e-02f, -2.18298972e-01f, 1.45560667e-01f, -6.53074607e-02f,
  1.63878232e-01f, -1.76187009e-01f, -2.73727030e-01f, 2.39882529e-01f, -4.37088721e-02f, 5.41206598e-01f, -1.29407555e-01f, -3.68694514e-01f, -7.17060328e-01f, 1.62887782e-01f,
  8.29008520e-02f, 3.04444909e-01f, -6.20222926e-01f, -2.05299035e-01f, -2.44219422e-01f, 4.29292470e-02f, -2.24135205e-01f, 3.59595180e-01f, -8.69086683e-02f, -3.91359240e-01f,
  1.04448579e-01f, 1.82466701e-01f, 3.63106877e-02f, -1.47489496e-02f, -1.50418982e-01f, 1.21987529e-01f, 2.27612369e-02f, 7.29876608e-02f, -2.21848592e-01f, 3.64676058e-01f,
  -2.95451912e-03f, -7.61584863e-02f, 5.10072745e-02f, 3.24788503e-02f, 1.54000819e-01f, 2.72172373e-02f, -2.22076431e-01f, 1.79453138e-02f, -1.32980675e-01f, 2.38081291e-01f,
  2.68644899e-01f, 1.80988267e-01f, 5.75100221e-02f, 2.01908275e-02f, -9.84018967e-02f, -1.70010954e-01f, -5.80068491e-02f, 2.12875843e-01f, -8.95243809e-02f, 4.50807214e-02f,
  9.16878227e-03f, -9.95202512e-02f, -3.45070846e-02f, 9.23098847e-02f, -3.50486070e-01f, -2.01556385e-01f, 1.66631579e-01f, 1.25739917e-01f, 4.75525372e-02f, 1.09404773e-01f,
  1.20436616e-01f, 6.34247959e-02f, 1.98089585e-01f, -2.87221968e-01f, -4.83375527e-02f, -9.32361186e-02f, -2.50112087e-01f, 2.33652815e-01f, 1.40594929e-01f, -2.01666102e-01f,
  2.14990392e-01f, 3.90968025e-01f, 2.39449635e-01f, -4.10443187e-01f, 2.06740826e-01f, 2.75039405e-01f, 3.28340083e-01f, -3.46393436e-01f, -2.47458473e-01f, -2.70343572e-01f,
  -1.41063761e-02f, -3.61980617e-01f, -4.51789767e-01f, 2.78467000e-01f, 4.38087024e-02f, 1.16526201e-01f, -2.77445465e-01f, -3.39036614e-01f, 3.02030474e-01f, -3.48571599e-01f,
  -2.55988926e-01f, -1.13147266e-01f, 1.16509624e-01f, 6.28384724e-02f, 2.86690980e-01f, 4.44675595e-01f, -3.38716835e-01f, -1.88532889e-01f, 4.00019050e-01f, 3.14549506e-01f,
  3.86902869e-01f, 2.86390513e-01f, 3.02684426e-01f, 6.89349249e-02f, 3.07562649e-01f, -3.48363578e-01f, -3.87967676e-01f, 3.73139642e-02f, -4.54198837e-01f, 8.49389955e-02f,
  2.40291119e-01f, 6.08238764e-02f, -2.59573221e-01f, -2.30238631e-01f, -3.21786195e-01f, -3.97426873e-01f, -1.47541687e-01f, 3.29864144e-01f, 1.64960101e-01f, 3.05749327e-01f,
  -3.41957092e-01f, 1.70525283e-01f, 1.38825879e-01f, -1.62072167e-01f, -6.99706823e-02f, -5.60882449e-01f, -3.13686192e-01f, -3.42239887e-02f, -4.08767700e-01f, -3.30666900e-01f,
  -3.93738925e-01f, 2.47549772e-01f, -2.20688894e-01f, 2.31781173e-02f, -3.18354130e-01f, -3.87065411e-01f, 4.05974984e-02f, 3.98174107e-01f, 2.51981348e-01f, -2.48842463e-01f,
  -7.91622475e-02f, 1.49790451e-01f, -4.99208868e-01f, 3.43688905e-01f, -6.13140345e-01f, 2.19737917e-01f, -4.91934061e-01f, 8.43432024e-02f, 1.19885569e-02f, 7.56764039e-02f,
  3.05716749e-02f, 1.49970323e-01f, -8.12724903e-02f, -3.03242896e-02f, 2.41258785e-01f, 6.78852871e-02f, 1.48823606e-02f, -7.63424532e-03f, -1.29716843e-01f, -1.54107898e-01f,
  -5.83874807e-02f, 7.99473152e-02f, -3.99632659e-03f, 8.12786892e-02f, -5.30316047e-02f, 4.53874655e-02f, 2.36661006e-02f, 1.81202307e-01f, -3.51251066e-02f, 1.09092414e-01f,
  -1.09942323e-02f, -1.17690071e-01f, -1.10010400e-01f, -6.45170510e-02f, -3.62941861e-01f, 1.63921341e-01f, 9.96779278e-02f, -7.18415678e-02f, 1.62465677e-01f, -1.43986121e-02f,
  1.16821490e-02f, -9.88840610e-02f, -2.31423587e-01f, 1.37008518e-01f, 2.17274025e-01f, 9.52142924e-02f, -3.12226146e-01f, 5.22451184e-04f, 2.36434001e-03f, -3.86077315e-01f,
  2.00285330e-01f, -2.00156923e-02f, 2.26939365e-01f, -1.53974429e-01f, 3.60905565e-02f, 1.70717269e-01f, -2.13795379e-01f, 5.18030412e-02f, -5.67824468e-02f, -2.78003365e-01f,
  3.94286126e-01f, 2.22995535e-01f, 1.38934376e-02f, 2.11881567e-02f, -2.96494842e-01f, 1.12367824e-01f, -1.49948016e-01f, 1.79360539e-01f, 1.96254048e-02f, 2.16237247e-01f,
  2.54406333e-01f, -1.02035433e-01f, -2.16723293e-01f, 2.77890235e-01f, -5.91409504e-02f, -3.44142795e-01f, 3.04944888e-02f, -2.37283826e-01f, 8.97234157e-02f, 1.78002506e-01f,
  -4.20043349e-01f, 3.06203961e-01f, -1.91084698e-01f, -1.39373869e-01f, 2.37587512e-01f, -4.58279178e-02f, -3.17334607e-02f, -1.54075369e-01f, 3.63121480e-01f, 6.52289912e-02f,
  3.71728450e-01f, -2.03307578e-03f, 3.51815224e-01f, 2.80466706e-01f, 2.59852391e-02f, 2.30833113e-01f, 2.74556708e-02f, -2.70094931e-01f, 9.18011144e-02f, 1.59395665e-01f,
  1.77441109e-02f, 1.79517806e-01f, 3.30967516e-01f, -1.82915553e-01f, 3.31751823e-01f, -2.75700808e-01f, -1.66872576e-01f, -1.29535154e-01f, 1.05313599e-01f, -1.10283740e-01f,
  1.11579830e-02f, -3.55943441e-01f, 6.71734139e-02f, 3.40410650e-01f, -4.26729500e-01f, -1.70893908e-01f, -1.76129237e-01f, 1.81165621e-01f, -3.39925922e-02f, -2.07284123e-01f,
  2.62393177e-01f, 7.72535950e-02f, -3.47797215e-01f, 3.85024130e-01f, 2.45053601e-03f, -5.25406711e-02f, -3.45907420e-01f, 1.02467269e-01f, -1.08887963e-01f, -2.45345727e-01f,
  8.95354822e-02f, -1.30861357e-01f, -6.98184222e-02f, -2.02319920e-01f, 1.36031911e-01f, -4.04499918e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.00187019e-01f, 4.20668907e-02f, 3.59350555e-02f, -1.42514661e-01f, 1.14380494e-02f, -2.44444050e-02f, 5.99224307e-02f, 4.47356477e-02f, -4.78379894e-03f, 4.29959148e-02f,
  -5.21576740e-02f, -3.14455852e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    