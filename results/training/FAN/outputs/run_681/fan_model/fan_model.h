/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.45555615e-01f, -2.41863832e-01f, -6.27828166e-02f, -2.34482184e-01f, 7.72391856e-02f, -7.07952976e-02f, -3.54238331e-01f, -2.02088952e-01f, -6.02768175e-02f, 1.33627942e-02f,
  1.07494771e-01f, 2.49848932e-01f, 8.79144594e-02f, 1.16602354e-01f, -1.38936505e-01f, -9.16620865e-02f, -7.19423667e-02f, -5.90368435e-02f, 7.57944435e-02f, 7.48595670e-02f,
  1.36408508e-01f, -1.78048909e-01f, -8.85668769e-02f, -9.21342224e-02f, 8.50238502e-02f, 2.07152545e-01f, -9.01713371e-02f, 5.48360050e-02f, 5.95335141e-02f, 3.53628173e-02f,
  3.02880585e-01f, -1.75380573e-01f, 4.09057178e-02f, -4.88178357e-02f, 2.15615898e-01f, -4.90414873e-02f, -1.50793651e-02f, 1.06703915e-01f, 7.10832700e-03f, -4.56037186e-03f,
  1.14679582e-01f, 4.41330075e-02f, 8.36301520e-02f, 8.62352666e-04f, 1.02208309e-01f, 2.72400561e-03f, 9.54955518e-02f, -5.90431727e-02f, -3.91658433e-02f, 7.41079226e-02f,
  1.45511881e-01f, 2.72187451e-03f, -7.42150396e-02f, -9.61128715e-03f, 9.56644416e-02f, 3.83255742e-02f, 6.28051013e-02f, 1.44890333e-02f, -8.24143291e-02f, -1.31204510e-02f,
  1.11698009e-01f, 5.57001121e-02f, 4.70844135e-02f, -9.92884338e-02f, -6.88531697e-02f, 3.81237417e-02f, -4.28721383e-02f, -4.61230427e-02f, -1.10048130e-02f, -4.89098504e-02f,
  2.60395706e-02f, -3.80718820e-02f, -2.81082597e-02f, -1.53399602e-01f, 3.84272859e-02f, -3.76982503e-02f, -7.41448104e-02f, -2.25620940e-02f, -6.25824556e-02f, -1.13450311e-01f,
  -7.11949915e-02f, 4.82366532e-02f, -3.89526412e-02f, -4.07853313e-02f, -2.85491887e-02f, -9.26947687e-04f, 1.70535799e-02f, 2.45533069e-03f, -7.22027570e-02f, -7.13015720e-02f,
  9.50755700e-02f, -3.64680290e-02f, -1.49549516e-02f, 2.33533252e-02f, 3.70824821e-02f, 2.04803888e-02f, 3.73020135e-02f, -3.35554369e-02f, -1.57115236e-02f, -6.52736947e-02f,
  2.20777690e-02f, -3.48917283e-02f, 3.93626057e-02f, 1.19685255e-01f, 6.11989014e-02f, 5.47490567e-02f, -5.74597740e-04f, 4.16478664e-02f, 5.58110364e-02f, 2.50393711e-02f,
  -6.06854856e-02f, -1.68213293e-01f, -8.67644623e-02f, -7.08405301e-02f, 7.54895154e-03f, -5.60208224e-02f, 4.75420570e-03f, -8.14274885e-03f, -6.50414452e-02f, -2.57163972e-01f,
  -3.46478492e-01f, -2.31077354e-02f, -5.13022840e-01f, -9.61306989e-02f, -5.12979552e-02f, 1.45261168e-01f, 2.75920689e-01f, 1.96589276e-01f, -4.34761010e-02f, -8.01234767e-02f,
  6.00815453e-02f, 2.33738899e-01f, 8.94793347e-02f, 2.24706233e-01f, 1.36976227e-01f, 7.23676085e-02f, -1.15486756e-01f, -1.09931938e-01f, 1.16521493e-01f, 1.62759140e-01f,
  3.49907398e-01f, 6.89407587e-02f, -6.83987737e-02f, -3.17418166e-02f, 1.63054168e-02f, 4.72746342e-02f, -1.77051142e-01f, -1.59932286e-01f, 6.34192079e-02f, -2.16091365e-01f,
  -1.73679054e-01f, -1.97558522e-01f, 9.84235853e-02f, 1.46179318e-01f, -3.34811211e-02f, 9.51735768e-03f, 2.66654510e-02f, -1.03101537e-01f, 7.92649314e-02f, 5.08939512e-02f,
  1.35665508e-02f, 1.16199300e-01f, 9.37917009e-02f, 5.09215407e-02f, 8.01982731e-02f, 2.08900943e-02f, 8.36461559e-02f, 2.42254343e-02f, 5.25364131e-02f, 4.10622917e-02f,
  2.45884329e-01f, -1.76604614e-02f, 1.26642343e-02f, 4.02246192e-02f, 6.44532964e-02f, 2.69549415e-02f, 1.31704016e-02f, 3.60954329e-02f, 4.03910168e-02f, -2.72301547e-02f,
  9.77285132e-02f, -1.35327011e-01f, -8.08656886e-02f, -4.36290763e-02f, 6.81878701e-02f, -9.12946463e-02f, -6.99535534e-02f, -1.85634848e-02f, 9.68354270e-02f, -3.91996615e-02f,
  -4.06625941e-02f, -1.07914425e-01f, -2.44905297e-02f, -6.57692626e-02f, 4.22693603e-03f, -8.68888944e-02f, -1.03330314e-02f, -6.59151152e-02f, -6.21041059e-02f, -1.17648125e-01f,
  -6.62016720e-02f, -5.48296981e-02f, -9.60662588e-02f, 4.24027517e-02f, -4.48094010e-02f, -3.88185158e-02f, 1.93314124e-02f, -7.18142390e-02f, -1.18835993e-01f, -1.70516267e-01f,
  1.71503350e-01f, 1.83567852e-01f, 4.65003848e-02f, 9.70334560e-02f, 2.94822529e-02f, 4.27283794e-02f, 4.48018797e-02f, 5.56621142e-02f, -6.08091755e-03f, 5.01833595e-02f,
  1.77664831e-02f, -6.81421487e-03f, 9.77649633e-03f, 9.10781249e-02f, 1.47323087e-01f, 1.20940715e-01f, 1.30917341e-01f, -1.65185072e-02f, 1.46713495e-01f, -5.72098233e-02f,
  6.35604933e-02f, 1.17199406e-01f, 4.24867831e-02f, 1.51054129e-01f, 5.90290036e-03f, 1.64112374e-01f, 9.26662982e-02f, 5.43395132e-02f, 2.65682098e-02f, 1.93924069e-01f,
  5.05443692e-01f, -1.79402322e-01f, -9.73471850e-02f, 1.85008928e-01f, 1.75304785e-01f, 1.86329827e-01f, 1.95560887e-01f, 2.09793076e-01f, 7.04344809e-02f, 5.44293821e-02f,
  9.93807837e-02f, 3.11276972e-01f, 1.59821779e-01f, 1.57761902e-01f, 9.80966091e-02f, -1.96852863e-01f, -1.51932403e-01f, 1.55244082e-01f, 4.91331100e-01f, 4.47796077e-01f,
  1.12447292e-01f, 2.90861964e-01f, 2.13341132e-01f, 1.30972460e-01f, -6.32271590e-03f, 1.56376168e-01f, -2.08673462e-01f, -8.38675648e-02f, -3.10141053e-02f, -2.99303442e-01f,
  2.38020420e-01f, 1.83803290e-01f, 2.56975293e-01f, 1.37611553e-01f, 9.52158496e-02f, 1.42393619e-01f, 1.08658545e-01f, 5.84956035e-02f, 8.15333948e-02f, 3.69965844e-02f,
  2.18132734e-01f, 4.17490043e-02f, 1.61834270e-01f, 1.20450161e-01f, 2.18962327e-01f, 2.61337966e-01f, 9.26248431e-02f, 9.79364142e-02f, 8.51828158e-02f, 1.21843427e-01f,
  -3.33638266e-02f, 2.67043591e-01f, 2.52465516e-01f, 1.76332951e-01f, 7.45445862e-02f, 1.39679745e-01f, 2.16789082e-01f, 1.82435423e-01f, 1.13185748e-01f, -7.17137475e-03f,
  -1.75769292e-02f, -4.48704585e-02f, -3.00910864e-02f, -6.85821399e-02f, 7.93316576e-04f, -3.65372747e-02f, -5.03896028e-02f, 2.86987592e-02f, -6.04336485e-02f, 3.15373130e-02f,
  -1.22889094e-02f, -3.12294494e-02f, -2.98735918e-03f, -1.87079962e-02f, -8.87644589e-02f, -2.82278303e-02f, 1.09318206e-02f, -1.30780041e-01f, 6.42235652e-02f, 2.61926726e-02f,
  7.22055286e-02f, -2.85264440e-02f, -1.59783289e-02f, -3.34928818e-02f, -7.24128112e-02f, 2.16255360e-03f, -8.98487195e-02f, -7.99131542e-02f, -3.70630226e-03f, -7.97637179e-02f,
  1.13625191e-01f, 1.08276114e-01f, 1.62767589e-01f, 2.01993376e-01f, 8.80334005e-02f, 2.74954420e-02f, 4.88461964e-02f, 1.20199777e-01f, 4.64975573e-02f, 1.41943634e-01f,
  1.19864374e-01f, 2.29861856e-01f, 1.01767235e-01f, 9.15220082e-02f, 1.37890950e-01f, 1.26242891e-01f, 8.53126030e-03f, 1.11108385e-01f, 1.73735142e-01f, 9.45674628e-02f,
  2.91553568e-02f, 2.14313850e-01f, 3.46145183e-01f, 1.38218760e-01f, 1.45702958e-01f, 3.33677888e-01f, 2.43528754e-01f, 1.71902552e-01f, 1.31527066e-01f, 1.35464206e-01f,
  -5.79511642e-01f, -2.30894294e-02f, 3.64014842e-02f, -1.51039297e-02f, 1.19195223e-01f, -2.31135994e-01f, -2.86367685e-01f, -1.39078408e-01f, -2.11319812e-02f, 5.87171838e-02f,
  1.95745453e-01f, 3.61685902e-01f, 2.55866021e-01f, 2.92006284e-01f, -1.85980257e-02f, -7.28741363e-02f, 1.23795465e-01f, -9.15860117e-04f, -4.71649803e-02f, -8.66878703e-02f,
  2.87568346e-02f, -2.45524108e-01f, -2.42623731e-01f, 1.64232135e-03f, 1.65491730e-01f, 2.15749174e-01f, 7.96256661e-02f, -1.91467777e-02f, 1.31752908e-01f, 2.27874473e-01f,
  1.50864810e-01f, -2.31530622e-01f, 7.99689516e-02f, 1.49344891e-01f, 1.21774986e-01f, -6.52363226e-02f, 1.08909115e-01f, 7.20127625e-03f, 2.90009845e-02f, 1.18843734e-01f,
  1.37985229e-01f, 3.96243632e-02f, 1.19243607e-01f, 1.07183352e-01f, -1.31664593e-02f, 6.34273365e-02f, -5.34801260e-02f, -7.49672810e-03f, -1.73930656e-02f, 4.46521007e-02f,
  2.43912175e-01f, 8.51922482e-02f, 2.80318689e-03f, 2.54703891e-02f, -3.26331258e-02f, 1.76714376e-01f, -7.08598942e-02f, 9.74368230e-02f, 6.03803955e-02f, 4.54735383e-02f,
  -1.55331399e-02f, 7.32719852e-03f, -7.58829862e-02f, -1.26487330e-01f, 1.08003197e-02f, 5.88121600e-02f, -3.67813520e-02f, -4.78698593e-03f, -8.69290717e-03f, -6.36561513e-02f,
  5.07873334e-02f, 3.03426906e-02f, -7.11178109e-02f, -9.03579518e-02f, 1.03905126e-01f, -6.45932704e-02f, -3.27707902e-02f, 2.01848876e-02f, 9.07043181e-03f, -4.69710380e-02f,
  9.52111557e-02f, -1.62513461e-02f, -3.64284553e-02f, 3.55911329e-02f, -2.76241731e-02f, -4.43358719e-02f, 1.30230580e-02f, 2.46918071e-02f, -3.54424194e-02f, -9.47550610e-02f,
  -3.80421057e-02f, 2.96628475e-02f, 1.68966293e-01f, 1.45295030e-02f, -2.00440288e-02f, 4.48433906e-02f, 4.64638993e-02f, 4.11645137e-02f, 1.55884236e-01f, -1.66755896e-02f,
  2.55227741e-02f, -9.73098166e-03f, 6.71636686e-02f, 2.44957451e-02f, -6.97399825e-02f, 5.23999482e-02f, -2.55128574e-02f, 1.07093699e-01f, 1.63886264e-01f, 5.43900058e-02f,
  5.19466065e-02f, -6.61207065e-02f, 1.13130987e-01f, 2.43631992e-02f, 7.94699341e-02f, 8.05423483e-02f, 4.56306972e-02f, 6.94949776e-02f, -3.62391351e-03f, -2.07801864e-01f,
  -6.75112188e-01f, -2.79726744e-01f, -3.01563144e-02f, -1.62427962e-01f, 4.64722887e-03f, -1.36699438e-01f, -2.41484180e-01f, -3.38770270e-01f, -2.82526135e-01f, -1.39299169e-01f,
  -3.34697276e-01f, -3.57381344e-01f, -3.63150895e-01f, -3.33806217e-01f, -3.04389179e-01f, -4.39460613e-02f, 1.46184444e-01f, 2.45796312e-02f, -1.81275886e-02f, 7.95482285e-03f,
  3.67613807e-02f, -2.18389947e-02f, -1.65994301e-01f, -2.90659945e-02f, 3.64930257e-02f, 6.13614880e-02f, -5.68408705e-03f, -1.04183346e-01f, -1.54934563e-02f, 8.43660980e-02f,
  -1.00626558e-01f, -4.69640762e-01f, -1.04246661e-01f, -2.12024957e-01f, -1.85591519e-01f, -2.33749852e-01f, -1.76754147e-01f, -1.71514839e-01f, -3.13481987e-01f, -2.37854570e-01f,
  -2.81464040e-01f, -2.69330382e-01f, -2.02785820e-01f, -2.32125148e-01f, -2.28105396e-01f, -1.30423650e-01f, -2.05935940e-01f, -2.69233108e-01f, -1.66295499e-01f, -2.14662418e-01f,
  -2.92738508e-02f, -4.13694121e-02f, -2.60210663e-01f, -1.95124015e-01f, -2.87669063e-01f, -2.19926059e-01f, -1.45241499e-01f, -8.96103457e-02f, -1.76863611e-01f, 2.66696811e-02f,
  1.75610095e-01f, -1.16804121e-02f, -2.64766794e-02f, 3.73103097e-02f, 6.69313371e-02f, -4.42268364e-02f, 9.23794582e-02f, -9.96077340e-03f, 1.27153561e-01f, 1.18075214e-01f,
  -3.72852548e-03f, 2.53026858e-02f, 4.11437638e-03f, 2.49094348e-02f, 7.16877207e-02f, 2.83962600e-02f, 5.34341633e-02f, 9.11665186e-02f, 1.32049605e-01f, 1.20048830e-02f,
  4.00654972e-02f, 5.55716045e-02f, 2.50266623e-02f, 4.96010855e-02f, 1.34214446e-01f, 1.17369927e-01f, -3.38117778e-03f, 6.25143275e-02f, -1.76349224e-03f, -4.51621972e-02f,
  -2.18840674e-01f, -2.45265484e-01f, -1.38049737e-01f, -6.42050430e-02f, -1.12889431e-01f, -5.06630205e-02f, -1.06730111e-01f, -7.46967122e-02f, -2.04254732e-01f, -1.32783577e-01f,
  -1.88375697e-01f, -2.03814775e-01f, -2.91469038e-01f, -1.05626225e-01f, -1.62105456e-01f, -1.17462181e-01f, -2.12361947e-01f, -2.80994121e-02f, -1.56405181e-01f, -8.66917372e-02f,
  -8.93727019e-02f, -1.13954812e-01f, -1.85228929e-01f, -1.92488015e-01f, -2.13866040e-01f, -2.31475174e-01f, -3.40700448e-02f, -1.18768364e-02f, -2.56943554e-01f, 7.09766299e-02f,
  -2.15138391e-01f, 3.25060487e-01f, 2.09788084e-01f, 4.78420854e-02f, 2.93707967e-01f, 3.94134194e-01f, 5.26028812e-01f, 2.83592254e-01f, 3.92247736e-02f, 2.21567422e-01f,
  1.52516499e-01f, -1.51335701e-01f, -1.66718766e-01f, -1.52092710e-01f, -5.62536879e-04f, 2.85182834e-01f, 1.57106787e-01f, -1.04127288e-01f, -1.73151672e-01f, -8.97717848e-03f,
  -7.81046450e-02f, 4.09484990e-02f, -1.39832541e-01f, -3.97201180e-02f, 1.51400790e-02f, -5.10696173e-02f, 2.64843047e-01f, 9.78514627e-02f, 1.97891265e-01f, -1.30181722e-02f,
  4.52956222e-02f, -1.31864503e-01f, -6.79629594e-02f, -1.31664380e-01f, 6.06934577e-02f, -2.77621001e-02f, 9.65629425e-03f, 2.13432703e-02f, -8.47434402e-02f, 7.17734396e-02f,
  2.23756693e-02f, -7.45896697e-02f, -1.34434942e-02f, 5.52569628e-02f, 3.05731539e-02f, 7.88092464e-02f, 1.46993548e-02f, 6.13505803e-02f, 7.99837038e-02f, 9.89668593e-02f,
  -6.28538877e-02f, -2.08303947e-02f, 1.50224373e-01f, 1.86772972e-01f, -6.26577139e-02f, -2.66344063e-02f, 7.74274692e-02f, 7.29559585e-02f, 5.69568239e-02f, 1.89302713e-01f,
  2.41436567e-02f, 2.41542794e-02f, 2.46058144e-02f, 6.23875931e-02f, 5.05044535e-02f, 1.77405626e-02f, 1.54990461e-02f, 3.89793962e-02f, -1.27144698e-02f, -1.38288662e-02f,
  -4.13679611e-03f, 9.67032686e-02f, 4.39005606e-02f, 1.14832319e-01f, 2.73203459e-02f, 6.86111301e-02f, 7.05527887e-02f, 1.28694072e-01f, 6.86208392e-03f, 4.46349978e-02f,
  5.85598126e-02f, -2.14126185e-02f, 7.08913580e-02f, -4.17354666e-02f, 7.24065900e-02f, 7.83225894e-02f, -2.11336371e-02f, 6.12177551e-02f, 6.56226045e-03f, -1.29099062e-03f,
  1.91548854e-01f, -9.70251635e-02f, 1.32473245e-01f, -1.03803091e-01f, 6.30734265e-02f, 7.54199028e-02f, 1.00104302e-01f, 6.81171119e-02f, 6.66021258e-02f, 4.96417694e-02f,
  6.12785630e-02f, 8.66062716e-02f, 1.12090997e-01f, 1.24899536e-01f, 1.39685482e-01f, 9.27207097e-02f, 2.03702509e-01f, 3.11330073e-02f, 3.92738394e-02f, 1.95190296e-01f,
  2.16270760e-01f, 2.40175441e-01f, 1.69614568e-01f, 2.10918471e-01f, 8.95461515e-02f, 1.69242844e-02f, 2.56682813e-01f, 2.32260510e-01f, 1.60421282e-01f, 4.38813329e-01f,
  8.90926719e-02f, -1.52944839e-02f, -3.62294078e-01f, 2.26177365e-01f, 7.68636018e-02f, -1.32006943e-01f, -3.32199186e-01f, -7.66546503e-02f, 1.51065275e-01f, -7.75383264e-02f,
  2.03606606e-01f, 2.20378324e-01f, -7.81429373e-03f, 2.31507402e-02f, -2.22673804e-01f, -4.10609573e-01f, -4.72476304e-01f, -3.70473117e-01f, -2.21884519e-01f, -1.23869568e-01f,
  1.16716966e-01f, 1.53948620e-01f, 5.82473241e-02f, -2.23240759e-02f, -1.39427140e-01f, -4.83532771e-02f, -2.10967317e-01f, -1.54271767e-01f, -3.16333503e-01f, -4.22714382e-01f,
  -3.04517150e-01f, -3.97484237e-03f, 5.25868684e-02f, 2.00510308e-01f, 3.78794479e-03f, -6.20234851e-03f, -3.20594572e-02f, 1.57874506e-02f, 7.90911075e-03f, -1.69779379e-02f,
  4.98553440e-02f, 8.72312710e-02f, -3.14656808e-03f, -2.78882980e-02f, -4.32853177e-02f, -6.83818758e-02f, 4.39846190e-03f, -3.38220261e-02f, 1.52721754e-04f, -7.15439841e-02f,
  2.02924058e-01f, 1.01733051e-01f, -7.58592635e-02f, -7.60500059e-02f, -1.75462186e-01f, 6.01155199e-02f, -1.36855930e-01f, -1.35628164e-01f, -1.31986633e-01f, -1.70263603e-01f,
  4.05335613e-02f, 5.45622893e-02f, -1.93745606e-02f, -6.31618872e-02f, -5.94709255e-02f, 5.28755551e-03f, -1.37808681e-01f, -8.69318377e-03f, -3.40372883e-02f, -1.40081838e-01f,
  -8.56638178e-02f, -9.70430151e-02f, -1.80618782e-02f, -1.51902094e-01f, -5.48166707e-02f, -4.42189798e-02f, -4.49777879e-02f, -1.56502262e-01f, -1.05193287e-01f, -2.35147607e-02f,
  -1.07781604e-01f, -3.64385433e-02f, -9.92034376e-03f, -1.96482539e-02f, -1.32815182e-01f, -1.99040577e-01f, -5.35094440e-02f, 1.33272698e-02f, 4.22092229e-02f, -3.62780467e-02f,
  3.56364667e-01f, 8.97747874e-02f, -1.01980641e-01f, -2.64136475e-02f, 8.22223127e-02f, 1.26226451e-02f, 6.47333488e-02f, -1.53173404e-02f, 9.99355167e-02f, -5.36800548e-02f,
  -6.75277561e-02f, -3.46964016e-03f, 2.95940358e-02f, 7.00153708e-02f, -2.90941261e-02f, -2.03650594e-02f, 1.47437826e-02f, 4.90672886e-02f, 2.35317554e-02f, 1.54615790e-01f,
  8.34941640e-02f, -9.29869562e-02f, -1.32126724e-02f, 4.15594392e-02f, -1.36351306e-03f, -6.07457794e-02f, -1.93125248e-01f, -1.14803510e-02f, -1.87646747e-01f, -7.32106343e-02f,
  -2.86744118e-01f, 1.29865244e-01f, 1.04095645e-01f, 7.76220784e-02f, 2.86501884e-01f, 1.59184203e-01f, 1.70575425e-01f, -7.08535314e-02f, -7.16097057e-02f, 7.00662211e-02f,
  7.82129448e-03f, -1.96165249e-01f, -2.04001203e-01f, -2.39076048e-01f, -2.45911330e-01f, 4.18212302e-02f, 6.56945109e-02f, -2.51037091e-01f, -2.98171192e-01f, -1.13052867e-01f,
  -7.83492029e-02f, -8.93256515e-02f, -4.54478323e-01f, -2.30306014e-01f, 1.26370545e-02f, -1.07501298e-01f, -1.84323683e-01f, -8.40331912e-02f, -9.61745083e-02f, 6.56354055e-02f,
  1.55624345e-01f, -1.58242986e-01f, -9.31752622e-02f, -2.17881471e-01f, 2.71542948e-02f, -1.15777224e-01f, -1.03613980e-01f, -2.18302310e-01f, -1.84132680e-01f, -1.33896202e-01f,
  -2.85709128e-02f, -1.14511363e-01f, -1.61850616e-01f, -9.97054353e-02f, -1.41137734e-01f, -1.57863006e-01f, -1.62429214e-01f, -3.48813713e-01f, -1.66350052e-01f, -2.76986919e-02f,
  -6.38176315e-03f, -1.30726732e-02f, -1.09284073e-01f, -1.70946389e-01f, -1.73672065e-01f, -1.02739051e-01f, -1.64350688e-01f, -2.05362394e-01f, -2.22191855e-01f, -2.13397220e-01f,
  5.59968874e-03f, 7.45623186e-02f, 6.64358065e-02f, 6.32429644e-02f, 2.67850775e-02f, 9.54377577e-02f, 4.44104038e-02f, 1.41479999e-01f, -9.43276566e-03f, 6.81608617e-02f,
  4.96858135e-02f, 1.03141911e-01f, -1.45319235e-02f, 3.03284116e-02f, -3.65299336e-03f, 7.22047761e-02f, -5.52049838e-03f, -2.50779931e-03f, -9.26797371e-03f, 8.90655443e-04f,
  1.80554558e-02f, 3.04218102e-02f, 7.01947734e-02f, -9.60651692e-03f, -9.71356779e-03f, 5.79504780e-02f, 5.88736162e-02f, 3.57668810e-02f, 6.23951145e-02f, 3.84923583e-03f,
  -3.34186435e-01f, -3.27039391e-01f, -5.93860522e-02f, -2.53613770e-01f, -1.12567497e-02f, -2.11763605e-01f, -4.78423573e-02f, -2.14407995e-01f, -7.59022832e-02f, -5.34496754e-02f,
  -1.38409570e-01f, -1.48165911e-01f, -1.69761568e-01f, -1.44206494e-01f, -8.49556029e-02f, -1.21449895e-01f, -1.61546081e-01f, -1.18916929e-01f, -1.96089730e-01f, -9.07993391e-02f,
  -1.18239641e-01f, -9.75510627e-02f, -2.53179520e-01f, -1.29045025e-01f, -2.38958746e-01f, -1.87853545e-01f, -9.43909064e-02f, -1.83665380e-01f, -2.57219404e-01f, -1.45321622e-01f,
  -3.16281050e-01f, -3.93019766e-01f, -4.68837023e-01f, -3.01383376e-01f, -1.48425236e-01f, -2.94666618e-01f, -3.28868449e-01f, -2.10532174e-01f, -2.20431779e-02f, -2.40190506e-01f,
  -2.82623380e-01f, -3.41179848e-01f, -3.87587667e-01f, -2.59982765e-01f, -3.58972818e-01f, -4.88662541e-01f, -4.04239386e-01f, -3.38062763e-01f, -2.20099702e-01f, -2.05020323e-01f,
  -2.21314430e-01f, -2.88586646e-01f, -1.83152378e-01f, -7.17396364e-02f, -1.49777994e-01f, -2.42979214e-01f, -1.92043364e-01f, -2.13517293e-01f, -2.56786764e-01f, -3.91464978e-01f,
  -6.34033322e-01f, -3.09884727e-01f, -1.56069532e-01f, -8.76283348e-02f, -2.15991989e-01f, -1.95289120e-01f, -3.25842828e-01f, -2.35103399e-01f, -1.79652035e-01f, -2.23615140e-01f,
  -2.23808751e-01f, -2.34881476e-01f, -2.93807030e-01f, -2.17523158e-01f, -2.32667834e-01f, -1.78858563e-01f, -1.83952227e-01f, -1.73832849e-01f, -2.01460227e-01f, -1.81193352e-01f,
  -3.14093739e-01f, -1.93571672e-01f, -2.60275751e-01f, -1.34870514e-01f, -2.28802189e-01f, -2.69902349e-01f, -2.61143088e-01f, -1.66823402e-01f, -2.46793494e-01f, -1.94915295e-01f,
  3.29412282e-01f, 2.35043541e-01f, 2.71836400e-01f, 2.67714530e-01f, 1.76392764e-01f, 2.01297686e-01f, 1.43651798e-01f, 1.23373128e-01f, 1.92591548e-01f, 2.09899768e-01f,
  1.83118582e-01f, 2.45461628e-01f, 2.15749845e-01f, 2.76243314e-02f, 2.03004852e-01f, 2.06306800e-01f, 2.28188738e-01f, 1.71649143e-01f, 2.36129090e-01f, 3.00446123e-01f,
  1.68461531e-01f, 2.54878700e-01f, 2.45321557e-01f, 2.94454843e-01f, 2.79050201e-01f, 2.80320406e-01f, 1.77068397e-01f, 2.37052962e-01f, 1.73539400e-01f, 1.78766012e-01f,
  -3.38888317e-01f, -8.95852894e-02f, -2.88451552e-01f, -3.02261800e-01f, -2.04996720e-01f, -1.66224599e-01f, -1.62332296e-01f, -2.60618865e-01f, -1.63414970e-01f, -2.51861781e-01f,
  -2.74867892e-01f, -2.43515119e-01f, -3.84463459e-01f, -1.98373362e-01f, -3.50938857e-01f, -2.46137306e-01f, -1.92384824e-01f, -2.96246648e-01f, -2.17980817e-01f, -1.65163428e-01f,
  -9.22529399e-02f, -2.23233610e-01f, -2.97177017e-01f, -2.01642230e-01f, -1.57224417e-01f, -2.40793362e-01f, -3.02331507e-01f, -2.22671807e-01f, -2.88835347e-01f, -2.20890865e-01f,
  1.94064751e-02f, -3.75610918e-01f, -7.54968747e-02f, 4.19798978e-02f, -9.31705628e-03f, -2.60246485e-01f, -4.72393960e-01f, -1.50613859e-01f, 9.77692008e-02f, -1.44928545e-01f,
  6.91287667e-02f, 1.34544685e-01f, 1.32078454e-01f, 1.09631665e-01f, 6.72915671e-03f, -3.62380475e-01f, -2.03232855e-01f, 1.00248493e-01f, 2.71621138e-01f, 2.53841847e-01f,
  1.84295133e-01f, 1.10100277e-01f, 1.94539070e-01f, 1.38447121e-01f, 2.24125609e-02f, 1.09337963e-01f, -1.39655555e-02f, 1.57915309e-01f, 1.57839376e-02f, 9.31138471e-02f,
  3.43211353e-01f, 1.55801922e-01f, 6.69541359e-02f, 1.13867730e-01f, -5.54525387e-03f, 5.09005859e-02f, 1.66075099e-02f, 9.37693790e-02f, 5.06873764e-02f, -1.84906870e-02f,
  7.53943473e-02f, 9.62112546e-02f, 1.47455409e-01f, 7.45719373e-02f, 3.35857533e-02f, 6.03808351e-02f, 4.85080369e-02f, 4.90398481e-02f, 2.42740326e-02f, 2.87233591e-02f,
  4.66583744e-02f, -4.58824709e-02f, 3.13678719e-02f, -6.02724366e-02f, 1.93812754e-02f, 1.39241368e-01f, -3.19312289e-02f, 1.33435294e-01f, -1.40296128e-02f, 9.77391154e-02f,
  -4.80647013e-02f, -5.13730198e-02f, 3.54494937e-02f, -9.15757269e-02f, -1.17098138e-01f, -3.28896418e-02f, 8.76676850e-03f, -4.21741977e-02f, 2.19193771e-02f, -3.79584022e-02f,
  -1.82050578e-02f, -2.85120569e-02f, -2.79845968e-02f, 3.92687395e-02f, 5.69598861e-02f, -7.33681992e-02f, -6.46045953e-02f, 3.44946198e-02f, -1.40967807e-02f, -6.33635148e-02f,
  -4.36974689e-02f, -7.11181685e-02f, 1.02288753e-01f, 9.23420340e-02f, -5.34291088e-04f, -5.39180860e-02f, 5.81623614e-02f, -6.89493492e-02f, -1.45893637e-02f, -1.59051344e-02f,
  8.48512277e-02f, -7.31564499e-03f, 3.28480713e-02f, 7.94753209e-02f, 5.23724072e-02f, 7.95750022e-02f, 7.99562559e-02f, 1.32509872e-01f, -2.97966879e-04f, 3.06423586e-02f,
  1.19664855e-01f, 7.76586160e-02f, 4.92965356e-02f, 1.41479010e-02f, 8.27417448e-02f, -1.03958370e-02f, -5.04223295e-02f, -6.48480058e-02f, -2.72409860e-02f, 1.31429862e-02f,
  -7.42128640e-02f, -8.40223506e-02f, -1.91425055e-01f, -1.60460114e-01f, 2.93174610e-02f, -1.32357851e-01f, 4.68528718e-02f, -6.24807589e-02f, -2.65251882e-02f, -1.58930942e-01f,
  -2.76568085e-01f, 1.71002090e-01f, -3.90155554e-01f, 1.13610394e-01f, 3.77797596e-02f, -1.08478621e-01f, -1.06238052e-01f, -5.50973229e-02f, 1.34419620e-01f, 1.09209865e-01f,
  1.19851403e-01f, 2.36271113e-01f, 5.09404726e-02f, 2.21474096e-02f, -2.37998262e-01f, 8.27314705e-03f, -7.45742172e-02f, -2.70587981e-01f, -3.08590770e-01f, 3.50228176e-02f,
  3.63245904e-01f, 1.72175512e-01f, -9.96413082e-02f, -8.78387019e-02f, 1.38435706e-01f, 1.54390801e-02f, -1.71416178e-01f, -1.90282643e-01f, -9.30723846e-02f, 1.06628731e-01f,
  -2.30991408e-01f, -2.01148748e-01f, 4.35876809e-02f, 1.71951503e-01f, -3.54206227e-02f, 4.84486744e-02f, 4.52159271e-02f, -7.61657730e-02f, 8.82933736e-02f, -2.26114634e-02f,
  7.73995370e-02f, 9.03389081e-02f, -2.84187756e-02f, 4.53026891e-02f, -6.28107712e-02f, 1.22814858e-02f, -6.05017832e-03f, -2.15196341e-01f, -5.36437407e-02f, 4.72034998e-02f,
  2.53266245e-01f, -5.41307405e-03f, -1.62359282e-01f, -1.41158402e-01f, -1.06757164e-01f, -9.37418118e-02f, -8.11460987e-02f, -6.01409674e-02f, -2.81141132e-01f, -9.39719938e-03f,
  -6.28833026e-02f, -3.95236164e-03f, 4.22203429e-02f, -6.89879060e-02f, 3.71891111e-02f, -3.16174701e-02f, -5.11556268e-02f, 3.61141227e-02f, 2.11087447e-02f, 8.50061476e-02f,
  -3.88137661e-02f, -2.70684585e-02f, -2.81398650e-02f, -5.88534549e-02f, 6.53179288e-02f, 9.03552677e-03f, -3.22743915e-02f, 5.80319688e-02f, 3.56010199e-02f, 1.29488081e-01f,
  1.46548715e-04f, -6.05439171e-02f, 1.11040764e-01f, -5.36462180e-02f, 1.15468930e-02f, -6.68289289e-02f, 4.65501659e-02f, 1.01424821e-01f, -8.18216708e-03f, 4.02085558e-02f,
  1.30168423e-01f, -1.01385422e-01f, 2.52886228e-02f, 4.93559279e-02f, -1.98352113e-02f, 5.21995649e-02f, -1.34213082e-03f, 5.56973033e-02f, -2.84116287e-02f, -3.17056887e-02f,
  -2.05903389e-02f, -7.63179958e-02f, -1.62459724e-02f, 4.88520898e-02f, 6.09116536e-03f, 2.07198095e-02f, 1.58377394e-01f, 6.56885207e-02f, -1.62840635e-02f, 1.32399395e-01f,
  1.04344845e-01f, -1.01117985e-02f, -7.79944733e-02f, -6.45799041e-02f, -2.36563347e-02f, -3.43124606e-02f, -9.43308473e-02f, -1.15938582e-01f, -1.90385535e-01f, -2.94219702e-02f,
  7.67727852e-01f, -1.15642004e-01f, 3.82297456e-01f, 8.61365870e-02f, -1.83239982e-01f, -1.88890025e-01f, -3.60407174e-01f, -1.97778583e-01f, -1.18235230e-01f, -1.35326013e-01f,
  -1.99849680e-01f, -1.43042624e-01f, -6.33188710e-02f, -1.09955557e-01f, 3.08001209e-02f, -1.72107629e-02f, -9.39659216e-03f, 4.11076307e-01f, 3.18666399e-01f, -1.42888725e-01f,
  -2.45955884e-01f, 9.73823443e-02f, 1.78310007e-01f, 1.20572612e-01f, -1.73037291e-01f, -8.26136097e-02f, 9.87625420e-02f, 1.09668426e-01f, -2.54855677e-02f, 7.77845383e-02f,
  2.44013309e-01f, 1.51455641e-01f, -2.80524828e-02f, -9.27419662e-02f, 6.13738149e-02f, 6.37584776e-02f, -1.23844286e-02f, 1.41704947e-01f, 2.47146729e-02f, 8.18489045e-02f,
  1.05429515e-01f, 5.65450825e-02f, 5.78816459e-02f, 3.33252773e-02f, -5.08093685e-02f, 4.28708307e-02f, 2.28918605e-02f, 1.35923281e-01f, 9.00013223e-02f, 5.88593856e-02f,
  -2.41940856e-01f, 1.13211602e-01f, 1.28802314e-01f, -7.40080103e-02f, -5.50210252e-02f, 1.05057105e-01f, -3.85496616e-02f, 9.29793809e-03f, 1.08666211e-01f, 1.24599472e-01f,
  -5.23079745e-02f, 3.04908492e-02f, -2.77219876e-03f, 5.01975231e-02f, -7.87474439e-02f, 3.64809223e-02f, -9.81999468e-03f, 1.05669811e-01f, -1.76975355e-02f, 4.57111523e-02f,
  2.23124046e-02f, -1.33885397e-02f, 9.33349226e-03f, 2.03398839e-02f, -6.22839294e-02f, 4.65109423e-02f, 3.01805846e-02f, 1.84359066e-02f, 7.64331035e-03f, 5.10658287e-02f,
  1.90962236e-02f, 6.98153973e-02f, 7.28296861e-02f, 4.21496481e-02f, 1.06995776e-02f, 9.46158469e-02f, 6.73580617e-02f, -5.60321733e-02f, -6.93816841e-02f, -7.81390071e-02f,
  -2.95256615e-01f, 4.15114909e-02f, -3.47614773e-02f, -5.77630289e-03f, 1.03240691e-01f, 7.32136518e-02f, 5.11498936e-02f, -3.94252986e-02f, 9.44065489e-03f, 5.76658733e-02f,
  -2.28166617e-02f, 3.15715335e-02f, -5.35643054e-03f, -4.25217971e-02f, 8.15884545e-02f, -1.25510031e-02f, -8.91196281e-02f, 5.08458577e-02f, -2.54537687e-02f, -7.37230256e-02f,
  -1.05825672e-02f, -9.06249955e-02f, 1.07887194e-01f, -1.01869181e-01f, -5.93742169e-02f, -5.19219227e-02f, -9.34732109e-02f, -5.88172786e-02f, -5.53913526e-02f, -1.39046907e-01f,
  -6.65247679e-01f, -5.85789569e-02f, 1.15925089e-01f, -1.18217587e-01f, 8.56688917e-02f, 7.95857832e-02f, 2.27316901e-01f, 1.80289261e-02f, -1.72044545e-01f, -8.53895098e-02f,
  -6.62181228e-02f, -7.07037374e-02f, -1.11868627e-01f, 1.07994772e-01f, 1.24704801e-02f, 1.74959987e-01f, 2.21871361e-01f, 1.06613077e-01f, 7.66176730e-02f, 1.26729190e-01f,
  1.53512970e-01f, 2.98792254e-02f, -1.22113936e-01f, 7.42402151e-02f, 1.07735097e-01f, -3.67114358e-02f, 2.74516102e-02f, 6.43924112e-03f, 2.44672582e-01f, 1.64268687e-01f,
  -1.41055658e-01f, -3.71575318e-02f, 1.83151096e-01f, 1.46880135e-01f, 1.97970122e-02f, 9.99348611e-03f, 8.52528494e-03f, 5.98349981e-02f, -4.97932322e-02f, 3.13018560e-02f,
  1.21150622e-02f, 5.88511257e-03f, 7.39366487e-02f, 5.97762205e-02f, -2.82778852e-02f, -1.15204826e-02f, 1.12365303e-03f, -2.43403446e-02f, 4.92085293e-02f, 9.03733522e-02f,
  2.24877775e-01f, 3.50509360e-02f, -6.98895194e-03f, 7.65216500e-02f, 1.43851712e-02f, 1.51473075e-01f, -1.17690470e-02f, 1.28540859e-01f, -4.93845083e-02f, -1.16470367e-01f,
  -2.09490675e-02f, -3.08900699e-02f, 3.96766700e-02f, 9.85356513e-03f, -1.00706080e-02f, 3.92928459e-02f, 2.87484955e-02f, 3.77998613e-02f, -1.58499666e-02f, -5.11825643e-02f,
  -2.65893899e-02f, -2.48009153e-03f, 1.83779951e-02f, -6.89622536e-02f, -7.32343718e-02f, -1.27362355e-03f, -2.55438667e-02f, -1.46646788e-02f, -7.59493485e-02f, -2.84354668e-02f,
  1.54323289e-02f, -2.47534011e-02f, -4.81017046e-02f, -3.99572402e-02f, 8.64249393e-02f, -8.32085609e-02f, 5.01176454e-02f, 3.71197537e-02f, -2.10889336e-02f, -1.00866914e-01f,
  -3.47990930e-01f, 6.96859285e-02f, -5.30910539e-03f, -2.47641895e-02f, -8.03896189e-02f, -4.71880427e-03f, -3.88671272e-02f, -3.71469744e-02f, -6.57024980e-02f, -5.25302440e-02f,
  4.06809300e-02f, 1.93890817e-02f, -9.34979171e-02f, 8.32323655e-02f, -8.66227597e-02f, 1.24266054e-02f, -8.22929665e-02f, 2.35802904e-02f, 2.33880654e-02f, 1.82045791e-02f,
  6.71358779e-02f, -8.85136500e-02f, -1.16453111e-01f, -1.32648364e-01f, -1.29486835e-02f, -6.84159696e-02f, -1.40723705e-01f, 3.96025367e-02f, -1.30904853e-01f, -2.68693149e-01f,
  2.33857960e-01f, -6.03354335e-01f, -1.64375991e-01f, 9.60115120e-02f, -8.40168074e-02f, -2.46601611e-01f, -5.32028496e-01f, -2.63304055e-01f, 6.88343048e-02f, -2.20005289e-01f,
  1.21971294e-01f, 2.92995334e-01f, 3.25550079e-01f, 1.44487858e-01f, -4.86883074e-02f, -4.01675671e-01f, -3.09171051e-01f, 1.59898520e-01f, 2.43219391e-01f, 2.28786245e-02f,
  -1.41710028e-01f, -5.26260771e-02f, 1.15504593e-01f, -9.77189764e-02f, -1.04304500e-01f, -1.37285329e-02f, -3.14776339e-02f, 2.98210494e-02f, -2.33142123e-01f, -3.05423677e-01f,
  1.70231909e-01f, -3.29265177e-01f, 4.80370782e-02f, -1.21307649e-01f, -5.96306324e-02f, -1.36044934e-01f, -1.94504246e-01f, -1.21792540e-01f, -5.15770242e-02f, -1.74284339e-01f,
  -3.26774605e-02f, -1.27135321e-01f, -7.44214579e-02f, -1.40084565e-01f, -1.37032449e-01f, -9.75204334e-02f, -1.58339292e-01f, -1.65313989e-01f, -2.04232588e-01f, -2.39062771e-01f,
  -2.23858774e-01f, -1.95045337e-01f, -1.30447134e-01f, -1.71697468e-01f, -1.77227706e-01f, 1.14948101e-01f, -1.43101469e-01f, -2.10389182e-01f, -1.46244138e-01f, -2.69196510e-01f,
  9.47573632e-02f, 5.21936640e-02f, 9.27568078e-02f, 1.42066449e-01f, 1.21509701e-01f, 1.04190171e-01f, 1.18316099e-01f, 1.19624726e-01f, 1.50095955e-01f, 1.17998019e-01f,
  1.23734452e-01f, 4.91829813e-02f, 1.13127545e-01f, 1.58994988e-01f, 9.09050032e-02f, 8.43807757e-02f, 1.81517884e-01f, 1.13232486e-01f, 1.69769078e-01f, 7.22386539e-02f,
  1.94669291e-01f, 1.02756381e-01f, 2.21501157e-01f, 6.54430389e-02f, 9.53298733e-02f, 1.82683006e-01f, 1.24373630e-01f, 1.18133910e-01f, 1.51745111e-01f, 1.00050412e-01f,
  1.53836399e-01f, -1.13104908e-02f, -6.76564723e-02f, -1.59969956e-01f, -2.22999156e-01f, -1.60198763e-01f, -1.04677103e-01f, -1.33368924e-01f, -9.29114521e-02f, -1.39487982e-01f,
  -1.89199984e-01f, -4.05670740e-02f, -1.54887021e-01f, -1.38498634e-01f, -3.65799144e-02f, -6.77704513e-02f, -1.40813857e-01f, -4.01757769e-02f, -1.51367560e-01f, -1.78238347e-01f,
  -1.27925023e-01f, -7.72116110e-02f, 1.12667330e-01f, -7.69616365e-02f, -9.61297527e-02f, 1.18625306e-01f, 1.87283121e-02f, -1.20604329e-01f, -6.04037568e-02f, -1.20198935e-01f,
  1.35602802e-01f, -2.76270777e-01f, -2.02076450e-01f, -1.80026703e-02f, -8.85539204e-02f, 1.14312870e-02f, -2.75701229e-02f, 1.89964861e-01f, 6.29442409e-02f, -1.49672031e-01f,
  -4.13679592e-02f, 6.47509843e-03f, 1.76641606e-02f, -2.23483890e-02f, 1.05724826e-01f, 3.04171592e-02f, -1.35410717e-02f, 1.32532250e-02f, 5.31249754e-02f, 9.00617912e-02f,
  4.15108986e-02f, 5.37226675e-03f, 7.51831084e-02f, 2.84981839e-02f, -8.83568078e-02f, -9.71496478e-03f, -1.02874354e-01f, -7.35943168e-02f, -1.21758446e-01f, -2.86594719e-01f,
  -2.27418363e-01f, -2.51355141e-01f, 4.90896069e-02f, 3.63251269e-02f, 1.30415466e-02f, 2.51120348e-02f, -8.45606104e-02f, 5.75151183e-02f, -2.20615324e-02f, -5.17943166e-02f,
  -1.12486415e-01f, -4.14424874e-02f, -6.44201189e-02f, -1.37767538e-01f, -2.03474369e-02f, -9.07288957e-03f, 6.19631670e-02f, 1.95653979e-02f, -4.00534868e-02f, -6.34642765e-02f,
  -1.84757128e-01f, -1.52495250e-01f, -8.33544880e-02f, 2.13495959e-02f, -9.14310589e-02f, 2.99697984e-02f, -1.43429905e-01f, 7.24027923e-04f, -4.11593989e-02f, -7.34533295e-02f,
  -6.19825236e-02f, 5.79476394e-02f, 1.25703409e-01f, 4.65565212e-02f, 1.25283524e-01f, 8.29496309e-02f, 5.97519837e-02f, 4.22457345e-02f, 7.80230016e-02f, 1.83455318e-01f,
  1.66293263e-01f, -1.63535550e-02f, 8.37714076e-02f, 8.12275801e-03f, 8.65419134e-02f, 3.30694541e-02f, 9.56594646e-02f, 8.62443596e-02f, -1.15900096e-02f, 3.65813263e-02f,
  9.55091976e-03f, 1.46083996e-01f, 1.33648023e-01f, 2.40814649e-02f, 5.53679839e-02f, 1.49760395e-01f, 1.27000943e-01f, 6.44007772e-02f, 1.79873526e-01f, 9.38317105e-02f,
  1.06358431e-01f, -1.95823573e-02f, -5.16933836e-02f, -1.34393796e-01f, -1.11711934e-01f, 6.35410994e-02f, -6.26633093e-02f, -9.64526013e-02f, -4.33663987e-02f, -7.01137409e-02f,
  3.47808562e-02f, 3.29489149e-02f, -2.56159101e-02f, 4.07534130e-02f, 8.92158523e-02f, -3.24455462e-02f, -1.45889614e-02f, -4.19179089e-02f, -4.65180539e-03f, -4.22562622e-02f,
  5.97751923e-02f, 5.18963523e-02f, 3.25267129e-02f, 5.41763641e-02f, 1.05760336e-01f, 1.92210153e-02f, -2.41082199e-02f, -3.42201665e-02f, 6.25176579e-02f, 2.42487192e-01f,
  1.40800238e-01f, 3.18594873e-01f, -7.77173648e-03f, 1.30134404e-01f, 1.36191472e-01f, 2.34583557e-01f, 5.39347947e-01f, 3.28113168e-01f, 2.09664345e-01f, 1.17866628e-01f,
  -1.47312492e-01f, -3.53283316e-01f, -1.93989024e-01f, -1.70910954e-01f, -4.20985520e-02f, 1.32123962e-01f, 3.06251626e-02f, -1.33804068e-01f, 4.80194911e-02f, 1.98743433e-01f,
  1.59084424e-01f, 3.01478148e-01f, 3.34439799e-02f, 1.62963122e-01f, 9.22056735e-02f, -8.52958784e-02f, -4.09143424e-04f, 2.16244198e-02f, 6.38747364e-02f, -1.83761671e-01f,
  -2.80069262e-01f, 1.96887419e-01f, 9.31901932e-02f, -5.76169267e-02f, 3.88268195e-02f, 1.28872320e-01f, 1.12435184e-01f, 1.79185718e-01f, 8.78608972e-02f, 1.31173342e-01f,
  4.01981883e-02f, 5.11876084e-02f, 8.28636736e-02f, 1.84688509e-01f, 2.27873161e-01f, 1.07146911e-01f, 2.98294067e-01f, 2.02276915e-01f, 9.04871970e-02f, 1.47320226e-01f,
  1.08464457e-01f, 1.28203973e-01f, 2.09608361e-01f, 1.70478016e-01f, 1.80666104e-01f, -6.24216422e-02f, 2.20955923e-01f, 2.09287375e-01f, 1.48767129e-01f, 9.86243486e-02f,
  5.91499396e-02f, 8.73542763e-03f, 8.45547300e-03f, -4.56516957e-03f, 7.98651204e-02f, 5.08896122e-03f, -3.16859074e-02f, 4.89795282e-02f, -3.48045165e-03f, 1.26398996e-01f,
  -4.33891751e-02f, -2.98015438e-02f, -5.58536500e-02f, -4.70329635e-02f, -1.12295806e-01f, 6.10512681e-02f, 2.36430243e-02f, 3.79062840e-03f, -8.72020349e-02f, 3.75682861e-02f,
  2.57827211e-02f, 8.54887720e-03f, -3.43810767e-02f, -6.09942265e-02f, -7.01410398e-02f, -8.24526772e-02f, -2.36165952e-02f, -7.51447603e-02f, -8.24715793e-02f, -1.42794410e-02f,
  -5.55637777e-02f, -1.30870119e-01f, -1.55530408e-01f, 8.15920457e-02f, 3.67145650e-02f, 3.35071459e-02f, -7.91204944e-02f, -3.24458852e-02f, 7.24909641e-03f, -4.10115831e-02f,
  -5.02797076e-03f, 3.71925980e-02f, -6.16157055e-02f, 8.43245089e-02f, 1.28803745e-01f, 6.50248155e-02f, 2.05576401e-02f, 2.79289461e-03f, 1.08145125e-01f, 1.36787280e-01f,
  1.78764164e-01f, 4.57857251e-02f, -5.60288923e-03f, -4.17792089e-02f, 2.02737916e-02f, -2.02390194e-01f, 4.55100313e-02f, -4.16930392e-02f, -6.92214770e-03f, 4.52140346e-02f,
  1.78062730e-02f, 2.24333480e-01f, 5.85432589e-01f, -4.22426075e-01f, -3.64918858e-01f, 7.80574158e-02f, -2.47019436e-03f, 1.07182851e-02f, -3.14187020e-01f, 1.12931333e-01f,
  1.98210448e-01f, -1.63378999e-01f, -1.24078465e-03f, 1.47412241e-01f, 2.20290020e-01f, 1.63447767e-01f, 1.00013755e-01f, 3.34702432e-01f, 1.28206685e-01f, -2.19085187e-01f,
  -2.33550042e-01f, -1.93176046e-01f, 3.18534113e-02f, 4.19720933e-02f, -1.50949180e-01f, -2.00972408e-01f, 2.42599413e-01f, 1.86886881e-02f, 1.85556799e-01f, 1.33456305e-01f,
  2.96262354e-01f, 2.77716368e-01f, -6.50972947e-02f, 2.46132109e-02f, 4.79293168e-02f, 5.46557270e-02f, -2.14534290e-02f, 1.36293128e-01f, 2.42537800e-02f, 6.60266355e-02f,
  8.10321495e-02f, 3.16927843e-02f, 3.89827453e-02f, 5.52079938e-02f, 1.97379161e-02f, 3.31213474e-02f, 1.95705578e-01f, 1.85141042e-01f, 2.47704595e-01f, 1.17512561e-01f,
  -3.96041083e-04f, 2.60631032e-02f, 1.83072478e-01f, 4.26214710e-02f, 2.58079708e-01f, 9.51007679e-02f, 1.47395104e-01f, 1.88464746e-01f, 1.75081581e-01f, 6.10264279e-02f,
  -1.97532967e-01f, -1.88889336e-02f, -3.42194177e-03f, -1.40659466e-01f, -8.89040828e-02f, -1.30672380e-01f, -1.86979733e-02f, -1.08701602e-01f, -6.74528629e-02f, -1.02949888e-01f,
  -5.84287345e-02f, -6.26424998e-02f, -2.74458993e-02f, -3.08868345e-02f, -1.17480583e-01f, -2.46583670e-02f, -4.25172709e-02f, -5.40248752e-02f, -2.77917162e-02f, -5.57702966e-02f,
  -1.00827985e-01f, 1.78535702e-03f, -3.41580920e-02f, -4.25701998e-02f, -2.05150843e-02f, -1.71832573e-02f, -6.14468046e-02f, -9.35754254e-02f, -1.62970126e-01f, -6.96674809e-02f,
  -3.98043782e-01f, 3.03625405e-01f, -8.57009664e-02f, 8.98790210e-02f, 1.05886817e-01f, 1.40095115e-01f, 7.55207986e-02f, 1.74833909e-02f, -3.87509987e-02f, -1.66337099e-02f,
  9.11411569e-02f, 9.34223458e-02f, 9.08872262e-02f, 6.82460070e-02f, -6.45358637e-02f, 1.66107025e-02f, -6.92547783e-02f, 4.75498848e-02f, 6.97278902e-02f, 1.04068123e-01f,
  4.87336591e-02f, -2.43801586e-02f, -1.45378605e-01f, -3.40478532e-02f, -6.68934435e-02f, -8.58910680e-02f, -8.27788264e-02f, 4.53204028e-02f, -1.38858808e-02f, -1.35079712e-01f,
  -6.85764670e-01f, -4.64165330e-01f, 7.19491169e-02f, -9.03612897e-02f, 9.89672542e-02f, 8.01638048e-03f, -1.10220827e-01f, -1.09226786e-01f, 5.69634186e-03f, -1.86982647e-01f,
  -2.01720983e-01f, 4.01135497e-02f, -9.60395411e-02f, -6.61628917e-02f, -1.77093834e-01f, -8.84193406e-02f, -3.51025694e-04f, 1.25708610e-01f, 2.22930029e-01f, 2.20953062e-01f,
  1.79792598e-01f, 7.11832121e-02f, 4.86227721e-02f, 6.39274716e-02f, 8.64664167e-02f, 1.40683949e-01f, -7.33406246e-02f, 5.51627986e-02f, 7.71448240e-02f, 1.10611156e-01f,
  3.45802680e-02f, -3.19548488e-01f, 2.32295424e-01f, 4.55996096e-02f, 3.33875455e-02f, 3.14854793e-02f, -8.68947133e-02f, 6.21536262e-02f, -4.61696014e-02f, -1.53176347e-02f,
  -8.96228186e-04f, -2.12281626e-02f, -1.34964345e-03f, 8.58056471e-02f, -6.52687624e-02f, 3.44990119e-02f, -8.99592713e-02f, 3.64790261e-02f, 2.06387639e-02f, 3.11023109e-02f,
  2.61447504e-02f, 5.63793965e-02f, -1.03444807e-01f, 3.87492329e-02f, 3.84751707e-02f, -2.07764283e-02f, -2.66930815e-02f, 1.20352522e-01f, -1.16796777e-01f, -2.79222857e-02f,
  5.89872375e-02f, -4.67372360e-03f, -2.97825923e-03f, 6.00458272e-02f, 8.89177695e-02f, 5.01362830e-02f, 2.57218350e-02f, -1.41238496e-02f, 3.34978290e-02f, 1.09427527e-01f,
  4.26454693e-02f, 3.29311602e-02f, 1.57100484e-02f, -1.20321736e-01f, 5.34976274e-02f, 2.79750004e-02f, 8.07508677e-02f, 6.92698807e-02f, 4.67891470e-02f, 1.69889554e-02f,
  6.94373474e-02f, 2.40836031e-04f, 1.99092906e-02f, 6.40630862e-03f, -2.12221071e-02f, -2.50122212e-02f, 8.30146074e-02f, -7.28606526e-03f, 2.51968652e-02f, -1.45944767e-02f,
  -1.72933444e-01f, -1.01655349e-01f, -1.13223329e-01f, -1.49666574e-02f, -5.50206490e-02f, -9.06551778e-02f, -6.30561411e-02f, 2.90378928e-02f, -1.03130415e-01f, -9.25992709e-03f,
  -3.90715711e-02f, -5.93796745e-02f, -8.94055218e-02f, 4.43774238e-02f, 3.74069512e-02f, -3.14606726e-02f, 2.41085701e-02f, -6.29048869e-02f, -1.07810423e-01f, -7.74432300e-03f,
  6.81989342e-02f, -9.36275274e-02f, -3.63760330e-02f, -1.27386481e-01f, 5.58868088e-02f, -1.14615560e-02f, -2.64043771e-02f, -9.44103021e-03f, -1.96769893e-01f, -5.60176112e-02f,
  7.11540431e-02f, 3.76454622e-01f, -1.33774906e-01f, 2.59258360e-01f, 7.72304535e-02f, -1.98586181e-01f, 6.41116202e-02f, 6.09362535e-02f, 9.28432941e-02f, 1.18909463e-01f,
  -3.29883322e-02f, -1.95127860e-01f, -6.76807612e-02f, -2.82302678e-01f, -2.01944977e-01f, 1.93546012e-01f, 1.00404717e-01f, -1.61055475e-01f, -3.11783910e-01f, -1.81242809e-01f,
  2.39670843e-01f, 2.03998297e-01f, 1.64427429e-01f, 1.33490577e-01f, 3.39955956e-01f, -5.00314236e-02f, 1.13339640e-01f, 1.52366579e-01f, 7.76876404e-04f, 4.06384319e-01f,
  -3.44252825e-01f, 2.32923683e-02f, -1.60722628e-01f, 3.96732353e-02f, 6.72789365e-02f, -3.06828655e-02f, -9.34597626e-02f, 2.82301679e-02f, 7.35412491e-03f, 6.63042143e-02f,
  9.52690691e-02f, 5.52078784e-02f, 2.82298744e-04f, 7.03235641e-02f, 1.85873415e-02f, 1.89160975e-03f, -1.97507720e-02f, 5.62615646e-03f, -1.08028717e-01f, -8.40336978e-02f,
  1.53130546e-01f, 8.75791609e-02f, -1.03927806e-01f, -1.04412794e-01f, -5.68624139e-02f, -1.10857643e-01f, 3.52243707e-02f, -1.02955950e-02f, -2.34606892e-01f, 1.23867907e-01f,
  4.15209308e-02f, 2.60020159e-02f, -2.89045647e-02f, 4.60987613e-02f, 5.83244935e-02f, 1.78520847e-02f, 7.06925392e-02f, 1.26916997e-03f, -1.47191696e-02f, 1.18011564e-01f,
  -5.51390275e-03f, 7.12019904e-03f, -4.87303734e-02f, 1.07592337e-01f, 1.51326396e-02f, 3.35438177e-02f, 1.88739859e-02f, 1.79321021e-02f, 4.01499420e-02f, 9.40680504e-03f,
  -5.72009906e-02f, -9.99445915e-02f, 6.29422488e-03f, 3.90704684e-02f, -1.46375978e-02f, 2.57728733e-02f, 6.30965084e-02f, -1.37510421e-02f, 1.00784771e-01f, 1.44930586e-01f,
  7.31597841e-02f, -2.58393943e-01f, 2.06888784e-02f, -7.16230199e-02f, -3.51521894e-02f, -1.02373706e-02f, 5.21746166e-02f, 2.42587202e-03f, 2.12400239e-02f, -7.89483413e-02f,
  -6.30046204e-02f, -2.68786866e-02f, 9.39528868e-02f, 1.44911567e-02f, 4.81531769e-02f, 5.51909674e-03f, 1.61533132e-01f, -7.87975919e-03f, -1.26894098e-03f, -6.41268818e-03f,
  1.17064491e-01f, -9.33957100e-03f, -5.27773872e-02f, 1.41352490e-02f, -5.82898706e-02f, -1.05321169e-01f, -1.47948321e-02f, -3.54425572e-02f, -1.52421385e-01f, 1.73201188e-01f,
  2.41322927e-02f, 4.81175154e-01f, 3.32032442e-01f, 3.86296093e-01f, 2.10355610e-01f, 3.29367742e-02f, 1.36126697e-01f, 4.98084538e-02f, 5.09532392e-02f, 1.90907806e-01f,
  2.55726278e-01f, 8.33934173e-02f, -4.93192812e-03f, 3.20235752e-02f, -1.85330927e-01f, 1.50502175e-01f, 2.52472281e-01f, -2.01570839e-02f, -2.66940594e-01f, -1.84739277e-01f,
  -1.62111619e-03f, 2.80895997e-02f, -8.67065489e-02f, -6.02649413e-02f, 2.28246972e-01f, 8.96884352e-02f, 2.16584951e-01f, 1.27099946e-01f, 1.17881899e-03f, 4.67395633e-01f,
  2.29286388e-01f, 8.78122151e-02f, -5.58121279e-02f, 1.87044051e-02f, 2.20874727e-01f, -4.29752097e-03f, 1.37536570e-01f, 9.29580852e-02f, 9.47220176e-02f, 1.07779332e-01f,
  1.16274118e-01f, 4.13947627e-02f, -8.81917588e-03f, 6.07196949e-02f, 3.14462893e-02f, 5.19892350e-02f, 4.75903824e-02f, 2.11334061e-02f, -3.60614210e-02f, 4.49099317e-02f,
  2.05106512e-01f, 2.37845797e-02f, 4.75874320e-02f, 5.55635244e-03f, 1.45295414e-03f, 4.65040132e-02f, -2.18687765e-02f, -2.18929369e-02f, 1.24256304e-02f, 1.40423447e-01f,
  1.87973171e-01f, 2.77054030e-03f, -1.29595503e-01f, -1.10120796e-01f, -7.51441419e-02f, -1.15455603e-02f, 2.81762872e-02f, -3.46792452e-02f, -1.31325066e-01f, -3.49759758e-02f,
  -8.18709750e-03f, -1.73690468e-02f, -8.98542255e-03f, -3.78959402e-02f, -4.62191366e-02f, -6.12078272e-02f, 7.40668848e-02f, -2.01247763e-02f, 5.28978510e-03f, -3.28876972e-02f,
  -1.84679311e-02f, -2.64667962e-02f, -5.97917214e-02f, -2.46693380e-02f, -5.11804223e-02f, 8.33090320e-02f, -8.75729322e-02f, -1.14872888e-01f, -8.83619338e-02f, -5.36689647e-02f,
  -1.42979205e-01f, -1.06810249e-01f, 1.36766002e-01f, 9.24795773e-03f, 1.05797313e-01f, 6.28388822e-02f, 4.79094423e-02f, 2.16778945e-02f, 1.97306089e-02f, 4.72823195e-02f,
  -1.00542136e-01f, -3.01279575e-02f, 4.38921787e-02f, -3.37904133e-02f, -2.54153218e-02f, -4.44633923e-02f, 1.18252322e-01f, 6.34087324e-02f, -3.23693417e-02f, 1.20615751e-01f,
  1.17930539e-01f, -3.11402734e-02f, -3.04207169e-02f, -1.76920630e-02f, 3.56529132e-02f, -2.22536866e-02f, -4.48395573e-02f, -7.25957379e-02f, -1.60167634e-01f, -1.33451223e-02f,
  -4.59082872e-02f, -5.92547476e-01f, 1.23737333e-02f, 8.93202722e-02f, 2.16408372e-01f, 2.28142470e-01f, -2.56145895e-01f, 3.11034676e-02f, 1.63620979e-01f, -3.28478873e-01f,
  -2.61152506e-01f, -5.12060858e-02f, -7.14686047e-03f, 2.62271557e-02f, 2.63418853e-02f, -1.20797038e-01f, 2.24781446e-02f, 2.65630543e-01f, 4.66158599e-01f, 1.46196634e-01f,
  2.70791110e-02f, -5.21295890e-02f, -2.86562857e-03f, -4.67920618e-04f, -1.81678012e-01f, 8.19308758e-02f, -2.42559418e-01f, -2.45505929e-01f, -1.91263080e-01f, -3.26049447e-01f,
  -1.34195223e-01f, -1.76076710e-01f, 2.89770424e-01f, -5.28384410e-02f, -1.58205941e-01f, 2.38054506e-02f, 6.62554987e-03f, -2.13028230e-02f, -4.01700847e-02f, 7.60744605e-03f,
  -7.99901187e-02f, 7.62248263e-02f, 2.05427967e-02f, -7.98805580e-02f, 9.87916719e-03f, -4.73893918e-02f, -6.03654683e-02f, 4.56344848e-03f, 2.54218802e-02f, -7.30719045e-02f,
  -8.84468332e-02f, -1.67961267e-03f, -6.46553515e-03f, 3.70887518e-02f, 1.00278080e-01f, 9.10670236e-02f, -1.44535899e-01f, -7.39838108e-02f, 1.21947303e-01f, -2.01150924e-01f,
  -4.68531735e-02f, -9.28453282e-02f, 5.42869940e-02f, -3.24904434e-02f, 1.03553711e-02f, 3.91824991e-02f, 3.86890993e-02f, -1.76444221e-02f, -3.46505791e-02f, 6.71457173e-03f,
  8.26529339e-02f, 1.67961158e-02f, 5.33235520e-02f, -4.80472483e-02f, -5.15149115e-03f, -3.01912837e-02f, 8.54275282e-03f, -3.89916934e-02f, 3.71721685e-02f, -7.82388262e-03f,
  9.20432433e-02f, 3.96403298e-02f, -6.63317591e-02f, -9.59683792e-04f, 7.78004825e-02f, 1.16007805e-01f, 9.57389101e-02f, 1.46915745e-02f, -3.74431722e-02f, 5.82830608e-02f,
  -3.27090710e-01f, 2.24863276e-01f, -8.64539519e-02f, 4.56244946e-02f, 2.93763932e-02f, -4.43573557e-02f, -3.51569355e-02f, 6.28117146e-03f, -3.44177559e-02f, -4.04885374e-02f,
  2.73914430e-02f, -1.56080201e-02f, -5.70763759e-02f, -4.56221029e-02f, 5.49548268e-02f, 4.21784930e-02f, -1.09650202e-01f, -6.28548339e-02f, 2.94094738e-02f, -1.13893934e-01f,
  -8.03077817e-02f, 4.70379069e-02f, 9.35110226e-02f, -1.02903940e-01f, 1.00857332e-01f, 1.90321639e-01f, -7.09571838e-02f, 2.15186160e-02f, 1.03421360e-01f, -2.49084488e-01f,
  -6.67056859e-01f, 3.59641731e-01f, 2.04671681e-01f, -3.98773074e-01f, 1.91347077e-01f, 4.30180192e-01f, 4.77776110e-01f, 2.38862857e-01f, -7.03408122e-02f, 1.89458415e-01f,
  2.00235367e-01f, -2.52318829e-01f, -2.25149896e-02f, -5.02639748e-02f, 7.05050752e-02f, 4.27586108e-01f, 3.03445995e-01f, -8.41965377e-02f, -2.31490985e-01f, 4.45671901e-02f,
  7.58623108e-02f, -2.23755494e-01f, -3.48233849e-01f, -1.83354869e-01f, -4.00952399e-02f, -5.03903925e-02f, 2.42146298e-01f, -7.11308345e-02f, 1.81703001e-01f, 2.38194261e-02f,
  1.04263492e-01f, -7.29940683e-02f, 3.10170203e-02f, 4.92929062e-03f, 1.14025988e-01f, 4.04908769e-02f, 1.13638841e-01f, 1.87127292e-02f, 7.62057155e-02f, 7.94931352e-02f,
  7.05869729e-03f, 1.61493961e-02f, -4.87492234e-02f, -5.53709827e-03f, 6.58262670e-02f, 1.44938361e-02f, 1.69661175e-02f, -1.81633830e-02f, 9.18757245e-02f, 1.16073042e-01f,
  4.73525859e-02f, -7.71829337e-02f, 1.14854112e-01f, 1.80779457e-01f, 1.22234456e-01f, -2.91816723e-02f, 1.87086701e-01f, 2.07496714e-02f, 1.44277215e-01f, 1.11046858e-01f,
  -6.55810833e-02f, -3.69440131e-02f, -1.09184764e-01f, -1.25739112e-01f, -3.52928191e-02f, -2.66495775e-02f, -2.92734280e-02f, -3.33555453e-02f, -5.97324446e-02f, -5.89049645e-02f,
  -7.62832388e-02f, -1.34618636e-02f, -9.94014814e-02f, -4.19772193e-02f, -1.49666980e-01f, -1.77335069e-01f, -8.78262222e-02f, -8.63508210e-02f, -7.96963423e-02f, -1.72523469e-01f,
  -1.56372845e-01f, -3.88098545e-02f, -1.05602279e-01f, -9.73769873e-02f, -1.34550836e-02f, -1.01408340e-01f, -9.57412124e-02f, -1.20458558e-01f, -1.52154461e-01f, -3.83161381e-02f,
  1.05006602e-02f, 1.67583078e-01f, 1.16236478e-01f, -3.52151953e-02f, 9.01322514e-02f, 1.72082614e-02f, 1.04526311e-01f, 4.12315726e-02f, 5.74840195e-02f, 8.86520967e-02f,
  1.21721268e-01f, 3.71637382e-02f, 1.26666218e-01f, 9.04895961e-02f, 7.55667165e-02f, 9.13277641e-02f, 6.46663159e-02f, -3.85658927e-02f, 1.28677130e-01f, 1.06449820e-01f,
  2.14252740e-01f, 1.68784454e-01f, -8.66686460e-03f, 2.06595451e-01f, 2.05819458e-01f, 5.75961359e-02f, 2.69107550e-01f, 1.80249751e-01f, 1.94061980e-01f, 3.14778924e-01f,
  8.92272964e-02f, -1.44388080e-01f, 4.15049314e-01f, 5.86891882e-02f, 1.48222208e-01f, 1.53393045e-01f, -1.06957048e-01f, -2.31554791e-01f, -1.70172930e-01f, -5.49673401e-02f,
  1.86774116e-02f, -1.85866170e-02f, 2.66936445e-03f, 4.53829095e-02f, -1.77791659e-02f, 3.44434381e-02f, 1.63810164e-01f, 1.76164076e-01f, 1.73775628e-01f, -8.68191198e-02f,
  5.53114712e-03f, 5.12770936e-02f, 1.20806366e-01f, 5.34748174e-02f, -6.47568777e-02f, -2.54637208e-02f, 2.18882352e-01f, 1.81033090e-01f, -5.26244678e-02f, -1.05023719e-01f,
  1.25096604e-01f, 8.34533125e-02f, -1.16147704e-01f, -1.23217002e-01f, -5.37237749e-02f, -2.13738322e-01f, -1.09531619e-01f, -1.41622469e-01f, -1.61489338e-01f, -1.50993958e-01f,
  -2.72971764e-02f, -8.65861997e-02f, -1.24853455e-01f, -1.49107918e-01f, -1.08943641e-01f, -1.57444641e-01f, -3.14519815e-02f, -2.15216000e-02f, -7.31293857e-02f, -1.56311840e-01f,
  -8.88774171e-02f, -2.62449067e-02f, 2.48199347e-02f, -7.80645013e-02f, -1.02261513e-01f, 1.22289052e-02f, -1.12200990e-01f, -1.72426671e-01f, -3.40576917e-02f, -1.77199975e-01f,
  -4.63591889e-02f, 1.22427568e-01f, 1.87033996e-01f, 1.73626319e-01f, 1.40230477e-01f, 1.12273529e-01f, 1.99707597e-01f, 1.37505531e-01f, 1.52591720e-01f, 9.17010531e-02f,
  1.62229881e-01f, 7.79834166e-02f, 7.62225613e-02f, 1.48308262e-01f, 2.47843489e-01f, 2.02484325e-01f, 1.65682718e-01f, 1.41935721e-01f, 1.50046036e-01f, 2.24643633e-01f,
  1.53112203e-01f, 1.51129737e-01f, 1.98887199e-01f, 1.02597795e-01f, 2.10409716e-01f, 2.19262898e-01f, 1.58644885e-01f, 1.49761707e-01f, 2.12710574e-01f, 2.11694032e-01f,
  -3.41190398e-02f, 3.51043530e-02f, -1.62797093e-01f, -2.43558690e-01f, -3.49021293e-02f, -1.69607192e-01f, -9.62392241e-02f, -3.47432345e-02f, -9.39272419e-02f, -4.19608019e-02f,
  -1.72118589e-01f, -4.02056016e-02f, -5.90413734e-02f, -7.62095824e-02f, -4.19883840e-02f, -1.02759525e-01f, -1.76942199e-01f, -4.98043038e-02f, -9.47306231e-02f, -1.40532598e-01f,
  -1.87379733e-01f, -2.17816949e-01f, -2.26169482e-01f, -2.14035541e-01f, -1.35499537e-01f, -7.62708560e-02f, -1.15260921e-01f, -2.06702575e-01f, -1.17577374e-01f, -3.13226104e-01f,
  5.93356602e-02f, -4.88744259e-01f, -1.44835800e-01f, 5.29123135e-02f, -2.26182379e-02f, 1.50943026e-01f, -3.72022912e-02f, 8.14448670e-02f, 1.40126988e-01f, -1.60666645e-01f,
  -7.58121908e-02f, 7.30281845e-02f, 1.51329949e-01f, 2.96278577e-02f, 1.13155439e-01f, -1.84871733e-01f, -1.45296916e-01f, 1.19004985e-02f, 3.57863754e-01f, 2.26141527e-01f,
  5.83380535e-02f, -5.19368891e-03f, -2.44885087e-02f, -2.40071770e-03f, -9.09100994e-02f, -1.88406575e-02f, -1.42656103e-01f, -1.80306077e-01f, -2.30168104e-01f, -4.46300894e-01f,
  -1.65402263e-01f, -3.86504322e-01f, 1.58288524e-01f, -5.45262136e-02f, -3.58450301e-02f, -3.28108668e-02f, -2.33838111e-02f, -1.08742945e-01f, -6.99510053e-02f, -7.49098510e-02f,
  -4.23664488e-02f, -1.49119690e-01f, -8.46318305e-02f, -5.25407009e-02f, -2.74386629e-02f, -7.86478221e-02f, -1.46773994e-01f, -4.39390056e-02f, -3.70684564e-02f, -5.38122058e-02f,
  -4.32642996e-02f, -1.30613223e-01f, 1.10749900e-01f, 6.47839457e-02f, -3.38637680e-02f, 1.27398491e-01f, -1.39510915e-01f, -1.20846391e-01f, 4.98472229e-02f, -2.31644243e-01f,
  1.21727005e-01f, 9.49606970e-02f, 3.70184630e-02f, 7.46831903e-03f, 8.11190903e-02f, 7.43317381e-02f, 9.71888006e-02f, 7.11441934e-02f, 8.32537264e-02f, 6.84395954e-02f,
  3.97759192e-02f, 8.12222138e-02f, 3.12872380e-02f, 7.85460621e-02f, 8.16229582e-02f, 7.10919499e-02f, 2.82422025e-02f, 7.39161074e-02f, 1.08561471e-01f, -3.79929249e-03f,
  9.68995467e-02f, 1.88411802e-01f, 3.33400406e-02f, 4.95977178e-02f, 4.70450781e-02f, 1.21931262e-01f, 1.26424149e-01f, 5.20755313e-02f, 1.33312866e-01f, 2.43779439e-02f,
  1.92575365e-01f, 1.11900069e-01f, -3.54439951e-02f, 1.09097712e-01f, -1.71966366e-02f, 5.79430908e-03f, -2.87958551e-02f, -4.81347553e-02f, -1.84274632e-02f, 3.23025472e-02f,
  3.76509838e-02f, 9.87064317e-02f, 9.81007703e-03f, -2.71183420e-02f, 8.99941102e-02f, 1.46472812e-01f, 3.05285454e-02f, 1.11331604e-01f, 5.40314727e-02f, -6.27463311e-02f,
  -1.42856722e-03f, 2.23268136e-01f, 1.36119202e-01f, 1.42074108e-01f, 7.21538067e-02f, 2.90111065e-01f, 1.69293314e-01f, 1.47027999e-01f, 1.81087419e-01f, 7.41117001e-02f,
  1.40678570e-01f, 1.43413365e-01f, 1.16483457e-01f, 2.89540052e-01f, 7.98570961e-02f, -9.33629647e-02f, -2.24172492e-02f, -7.65899345e-02f, 7.81226754e-02f, 6.23380095e-02f,
  -2.02219546e-01f, -2.87493885e-01f, -1.59617290e-01f, -2.22271636e-01f, -2.31071055e-01f, 1.73705652e-01f, 3.07325155e-01f, 7.75111318e-02f, -3.04085314e-01f, -5.89850582e-02f,
  -6.27572462e-02f, 2.15302572e-01f, 7.86521062e-02f, 8.54326338e-02f, 2.13226825e-01f, 1.31529877e-02f, 1.53465793e-01f, 2.79348582e-01f, 1.30210564e-01f, 4.24385011e-01f,
  5.53335361e-02f, 3.07141900e-01f, -9.80391353e-02f, -1.01509459e-01f, 6.21663369e-02f, -4.30691279e-02f, -1.54788950e-02f, 1.09922983e-01f, 5.55882044e-02f, 1.53488025e-01f,
  3.37857604e-02f, -5.31432442e-02f, 6.44429727e-03f, 4.86176535e-02f, 7.47051090e-02f, 9.24786627e-02f, 1.65805429e-01f, 1.24119125e-01f, -5.84343560e-02f, -1.41454628e-02f,
  8.86119157e-03f, 6.07151762e-02f, 5.13442717e-02f, -2.55116820e-02f, -1.28412535e-02f, -9.32759717e-02f, 2.81398091e-02f, 1.25155166e-01f, -2.07666475e-02f, 9.72915962e-02f,
  -4.14088927e-02f, -3.28096077e-02f, -1.13289049e-02f, -2.63636000e-03f, 4.93342467e-02f, -1.76746324e-02f, 3.79583165e-02f, -5.85472547e-02f, -2.78728362e-03f, 6.05736040e-02f,
  1.51130343e-02f, -8.97875987e-03f, -3.37047176e-03f, -5.92780448e-02f, 6.58685947e-03f, -4.86139096e-02f, 3.20286723e-03f, -5.01557551e-02f, -4.60326374e-02f, 1.96019113e-02f,
  -1.17042400e-02f, 4.16036844e-02f, 4.10100408e-02f, -4.94082980e-02f, 5.37246652e-02f, -2.57298164e-02f, -7.57609531e-02f, -7.53302202e-02f, -6.74624220e-02f, 5.95006123e-02f,
  -1.54205278e-01f, -2.68872291e-01f, 9.88608152e-02f, 7.14173242e-02f, 4.12540883e-02f, -6.59009162e-03f, 1.12607982e-02f, 2.91735008e-02f, 3.27215232e-02f, 3.81886284e-03f,
  -3.04139480e-02f, 7.68803619e-03f, 3.39452550e-02f, 7.31542930e-02f, 3.69999893e-02f, 1.54041639e-02f, -1.76158380e-02f, 6.47393018e-02f, -3.55283134e-02f, 1.17335230e-01f,
  7.81386048e-02f, -4.39101346e-02f, -8.16433132e-02f, -1.50868192e-01f, -3.18240607e-03f, -1.33725211e-01f, -1.06574304e-01f, -1.18538491e-01f, -2.40006953e-01f, 6.06650813e-03f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.14033300e-01f, -6.20839119e-01f, -1.47255135e+00f, -1.07343662e+00f, -8.25272441e-01f, -3.51171009e-02f, 1.55435428e-01f, 3.57638776e-01f, -8.66365209e-02f, -3.70572597e-01f,
  -1.05778314e-01f, -7.96793550e-02f, -5.05761504e-01f, 1.24491662e-01f, 6.39077127e-01f, -3.77082765e-01f, -7.17371404e-01f, -2.21433297e-01f, 3.75275254e-01f, 7.24131286e-01f,
  2.84637600e-01f, -3.70963991e-01f, 3.07499580e-02f, -4.83314991e-02f, -6.42482221e-01f, -3.72218579e-01f, -1.06940413e+00f, -6.12203419e-01f, -1.17577016e-01f, -1.03464246e+00f,
  -7.91750431e-01f, -6.04489744e-01f, 6.66591972e-02f, 1.12441897e-01f, -5.27040899e-01f, 1.83689684e-01f, 8.09228164e-04f, -5.10323584e-01f, 1.23121157e-01f, -9.77286994e-02f,
  -2.01609015e-01f, 2.72480935e-01f, -4.66307253e-02f, -1.08981272e-02f, -1.86168268e-01f, 2.17682451e-01f, -1.05692826e-01f, 1.19769829e-04f, -2.32777912e-02f, 2.23268270e-02f,
  1.83360398e-01f, 6.84131458e-02f, -1.39986798e-01f, 1.59578010e-01f, 3.35247666e-01f, -4.99041565e-02f, -4.98395413e-02f, 2.00601116e-01f, 1.35034844e-01f, -4.02733713e-01f,
  -4.08579260e-02f, -2.42062598e-01f, -1.76625013e-01f, 4.83619012e-02f, 3.12734306e-01f, -7.10935146e-02f, -1.61581576e-01f, 8.81566778e-02f, 1.07908614e-01f, -5.43604642e-02f,
  -5.68277128e-02f, 1.40742185e-02f, 1.08999826e-01f, -1.64076388e-01f, -2.58981377e-01f, -8.28918740e-02f, 1.54820001e-02f, -4.33351398e-02f, -5.68981394e-02f, -2.58491701e-03f,
  1.22269914e-01f, 4.48249020e-02f, -1.21526800e-01f, 2.27552339e-01f, 8.23307335e-02f, -4.05099802e-02f, 2.33409237e-02f, 1.47538140e-01f, -3.11682522e-02f, 1.35733232e-01f,
  -4.16744977e-01f, 9.41830426e-02f, -3.60384047e-01f, 1.62245452e-01f, -2.30574638e-01f, -2.18028218e-01f, -5.12478590e-01f, 2.11798921e-02f, -2.17227951e-01f, 9.05654207e-02f,
  1.54836908e-01f, -6.85761496e-02f, -1.98955119e-01f, -2.99832933e-02f, 5.82458973e-02f, 3.16839106e-02f, 1.04073346e-01f, -2.69026488e-01f, 1.53623104e-01f, -2.45647300e-02f,
  4.56129424e-02f, 2.92755991e-01f, 1.94922581e-01f, -3.05568445e-02f, 3.12921256e-01f, 9.84774828e-02f, -2.32604027e-01f, -8.08213255e-04f, 2.98804700e-01f, -2.53054462e-02f,
  -1.49725631e-01f, -1.41053066e-01f, -5.37529051e-01f, 3.97949815e-01f, 4.84260499e-01f, -1.45883992e-01f, -7.15632498e-01f, -4.59273964e-01f, 3.82668376e-01f, -4.33259830e-02f,
  4.31852072e-01f, 1.54574245e-01f, -4.90702480e-01f, -2.59789854e-01f, -9.46626544e-01f, -9.52530801e-01f, -7.58701622e-01f, -1.09065521e+00f, -8.40838969e-01f, -5.80327958e-02f,
  3.12899590e-01f, -4.10389632e-01f, -5.25445521e-01f, -3.22653830e-01f, 5.75897574e-01f, 3.22910435e-02f, 2.13634670e-01f, 4.03352916e-01f, 1.70173481e-01f, 4.65351462e-01f,
  4.55116332e-02f, -4.04007733e-01f, 8.37426353e-03f, -8.15277547e-02f, 1.73412025e-01f, 3.64236557e-03f, -4.04640257e-01f, -2.72642404e-01f, 8.41610953e-02f, -7.43408799e-02f,
  1.65269792e-01f, 2.49595314e-01f, -1.12967953e-01f, 1.58612430e-01f, -3.55055600e-01f, -1.67709559e-01f, -4.45881933e-02f, -2.26302639e-01f, -3.90319735e-01f, 7.53682107e-02f,
  2.74507880e-01f, -5.65706976e-02f, -6.96617186e-01f, -1.91485509e-01f, -2.92116433e-01f, -5.91321895e-03f, 4.60802838e-02f, 2.16722891e-01f, -2.86606491e-01f, -3.14191207e-02f,
  3.98948997e-01f, -1.61449820e-01f, 5.78301363e-02f, 6.69754744e-02f, -8.18548501e-02f, 1.05930544e-01f, 1.00556538e-01f, -8.36298987e-03f, 2.79952940e-02f, 2.21149027e-01f,
  -6.59051165e-02f, 5.28367981e-02f, -1.90292582e-01f, -7.69282039e-03f, -2.79399365e-01f, -3.80298682e-02f, 2.69459367e-01f, -1.53860316e-01f, -2.64770001e-01f, -9.45119113e-02f,
  -7.63765126e-02f, 1.70961529e-01f, 5.79545321e-03f, -1.76871479e-01f, -1.97302010e-02f, 9.64063555e-02f, 1.71874762e-01f, -7.70232752e-02f, -1.27130985e-01f, 7.90251791e-02f,
  2.95363907e-02f, -3.24416548e-01f, 8.53746682e-02f, -2.03911230e-01f, -6.43325597e-02f, 1.65495038e-01f, 1.50884613e-01f, -6.51197210e-02f, 1.48899123e-01f, 4.83257249e-02f,
  -1.44540131e-01f, -1.20407175e-02f, -1.39614344e-01f, -6.51271269e-02f, 1.30093649e-01f, 1.62171990e-01f, 6.59237243e-03f, -1.77627038e-02f, -1.36146322e-01f, 3.66959095e-01f,
  -2.69937143e-02f, -2.47319385e-01f, -2.88049370e-01f, -1.08614892e-01f, 7.85690919e-02f, -3.08000267e-01f, -3.38146657e-01f, 9.99697372e-02f, -4.99791116e-01f, -2.62166679e-01f,
  -2.82852352e-01f, 1.05701730e-01f, -2.00840309e-01f, 4.32100058e-01f, 6.64530158e-01f, -3.41117501e-01f, -1.00201428e+00f, -5.96594453e-01f, 5.83753586e-01f, 2.07424179e-01f,
  4.59220350e-01f, 2.60303199e-01f, 2.31349260e-01f, -1.39663428e-01f, -6.61482871e-01f, -3.37929815e-01f, -9.71154794e-02f, -5.95045805e-01f, -7.15087116e-01f, -5.55042922e-01f,
  -4.38415520e-02f, 8.47335346e-03f, -1.87644422e-01f, -2.92102545e-01f, 6.34014070e-01f, 2.94839829e-01f, 4.49406326e-01f, 4.59582537e-01f, 7.75719956e-02f, 5.18849850e-01f,
  2.60729373e-01f, 1.32526055e-01f, -3.91248584e-01f, 3.28964025e-01f, 4.00994688e-01f, -3.77676845e-01f, -4.07649308e-01f, 1.10800378e-01f, -1.66618809e-01f, -4.89857467e-03f,
  4.20970708e-01f, -9.16376114e-02f, 2.55593508e-01f, -2.12682392e-02f, -1.60900623e-01f, -4.87977505e-01f, -3.95341255e-02f, -3.86719644e-01f, -3.10855508e-01f, -2.76528448e-01f,
  2.88929343e-02f, 4.25669193e-01f, 1.22767001e-01f, -4.62750256e-01f, 1.95841268e-02f, 2.29620636e-01f, -1.38944283e-01f, -1.58030674e-01f, -3.17870140e-01f, 1.08832844e-01f,
  -1.61767617e-01f, 2.87816953e-02f, 6.07044809e-02f, -1.10126421e-01f, -1.15991890e-01f, 9.75979045e-02f, 1.81445718e-01f, -8.39757994e-02f, 2.94453651e-02f, -1.12215482e-01f,
  -1.07380897e-01f, 1.10134490e-01f, -2.16822941e-02f, 8.12211819e-03f, 1.24128141e-01f, 6.48171976e-02f, -1.10323384e-01f, -1.94542706e-01f, 3.82890292e-02f, -4.57666181e-02f,
  -6.07383847e-02f, 3.73258330e-02f, 2.60169715e-01f, -1.58763319e-01f, 8.20647404e-02f, -5.38378023e-03f, 5.73877208e-02f, 1.56536132e-01f, 8.55657086e-03f, 1.06142588e-01f,
  -2.02345610e-01f, -3.26636374e-01f, -2.66397484e-02f, -1.23457678e-01f, 1.53941140e-01f, -4.09658663e-02f, 1.63362220e-01f, -8.16679075e-02f, 2.30146497e-01f, -3.19979876e-01f,
  -9.66869593e-02f, -2.33986840e-01f, 7.68192858e-02f, -1.21305592e-01f, -2.05651030e-01f, 1.14025764e-01f, -1.42206952e-01f, -7.91214406e-02f, -3.78664792e-01f, 1.10619016e-01f,
  -8.81731361e-02f, -4.04143184e-01f, -1.13680765e-01f, -2.35507444e-01f, 2.74125665e-01f, -8.84733945e-02f, -3.49395603e-01f, -3.98385748e-02f, -5.84927917e-01f, -6.40809357e-01f,
  2.43261233e-01f, -1.02813995e+00f, -5.04439235e-01f, -1.03686132e-01f, -6.66205823e-01f, -6.34426177e-01f, -1.30666435e+00f, -4.95805651e-01f, 2.12174013e-01f, -1.19753194e+00f,
  -4.74538386e-01f, 3.18554610e-01f, 5.43785430e-02f, 2.12662935e-01f, -1.66467931e-02f, -1.14619052e+00f, -7.28893459e-01f, 1.97873905e-01f, 5.01733243e-01f, -3.99658859e-01f,
  -5.79338729e-01f, -2.49439165e-01f, 2.84827828e-01f, 1.88989397e-02f, -2.69747645e-01f, 6.57073706e-02f, -4.67474580e-01f, -1.31419495e-01f, -4.96063828e-01f, -7.73867726e-01f,
  -5.71685731e-01f, -3.54286999e-01f, 2.91749477e-01f, 2.47663707e-01f, -4.03151572e-01f, 2.92694390e-01f, -1.28770173e-01f, 1.12348720e-01f, 1.22943677e-01f, -2.36809731e-01f,
  1.58513095e-02f, 4.42712195e-02f, 3.28859538e-01f, 2.17261583e-01f, -4.40458357e-01f, -1.23321585e-01f, -5.86575223e-03f, 5.81770577e-02f, 1.85105890e-01f, -3.94820303e-01f,
  -2.66644061e-01f, -3.05576921e-01f, 3.57332639e-02f, 2.84390509e-01f, 2.62784272e-01f, 3.62121642e-01f, -3.21972072e-02f, 2.63726171e-02f, 1.81851581e-01f, -9.26793933e-01f,
  -1.62849545e-01f, 5.50521202e-02f, 3.46774124e-02f, 1.47006169e-01f, -3.33085805e-02f, -1.25368625e-01f, 1.32714912e-01f, 1.07735768e-02f, -2.78588068e-02f, -1.97278131e-02f,
  -1.54843912e-01f, -3.28113198e-01f, 1.43937290e-01f, 1.01525262e-01f, -1.44622833e-01f, 5.89218959e-02f, -1.34491220e-01f, -9.60455090e-02f, 3.52864452e-02f, -4.76438506e-03f,
  8.70855004e-02f, 3.32178436e-02f, -8.62884894e-02f, 7.58019239e-02f, -2.18827426e-02f, 2.04413623e-01f, 5.86689450e-02f, -2.71364301e-02f, -2.43528560e-02f, -1.00786528e-02f,
  -3.65217924e-02f, 4.27323163e-01f, -1.23076476e-01f, 2.57812291e-01f, -1.71821281e-01f, -6.56216368e-02f, 5.15675545e-02f, 1.04248680e-01f, 2.41222292e-01f, -1.37330249e-01f,
  -2.42702276e-01f, -2.73498386e-01f, -6.13247119e-02f, -6.77667633e-02f, 1.54437140e-01f, -1.72219910e-02f, -3.70485097e-01f, -1.85631275e-01f, -9.12416801e-02f, -3.12933117e-01f,
  -3.07704836e-01f, -4.27017570e-01f, -8.25288221e-02f, 6.27828091e-02f, -1.24805950e-01f, 7.79385641e-02f, -3.07250023e-01f, -2.60233432e-01f, 1.21717611e-02f, -9.08268750e-01f,
  -8.11672032e-01f, -1.16659820e+00f, 7.74974883e-01f, -3.07522446e-01f, 4.22618300e-01f, 4.60915238e-01f, 3.46977204e-01f, -3.97419222e-02f, -1.86394677e-01f, -1.38487414e-01f,
  -4.75036174e-01f, -5.92245817e-01f, -4.66943771e-01f, -3.92333448e-01f, -4.07860607e-01f, 1.44725814e-01f, 3.69723648e-01f, 2.17638269e-01f, 4.84485537e-01f, 2.71953017e-01f,
  -1.27239645e-01f, -1.38755083e-01f, -4.16325450e-01f, -1.83268398e-01f, -1.83671638e-01f, -4.21709344e-02f, 9.98370349e-02f, -1.87446818e-01f, -2.14605242e-01f, -2.33052224e-01f,
  3.14128548e-01f, -4.36159194e-01f, 3.18299010e-02f, -3.81322473e-01f, -6.39322922e-02f, -1.72126234e-01f, 1.54251056e-02f, -1.44327641e-01f, -1.20337702e-01f, 7.67997876e-02f,
  -2.53050089e-01f, -3.40268128e-02f, -1.72021985e-02f, -5.16857877e-02f, 8.02461281e-02f, 1.36629581e-01f, -3.07392199e-02f, -2.67821342e-01f, -2.53177583e-01f, -1.12404421e-01f,
  -8.24441612e-02f, -3.98190785e-03f, 7.48067796e-02f, 5.58416955e-02f, -1.11567572e-01f, -6.78571984e-02f, -5.93575053e-02f, 1.72117036e-02f, -6.03507310e-02f, 1.51384696e-01f,
  5.86493164e-02f, 4.12258916e-02f, -6.35221973e-02f, 7.08941743e-02f, 1.01163462e-01f, 9.15283337e-02f, 4.25947011e-02f, -1.00462921e-01f, 2.81553734e-02f, -5.87817328e-03f,
  -5.78228757e-02f, -2.02259775e-02f, -3.96880209e-02f, 8.80105235e-03f, -8.71542767e-02f, -1.39780477e-01f, -3.43250446e-02f, -1.04697540e-01f, -1.81370378e-02f, -6.48444444e-02f,
  -1.59662485e-01f, -1.07105099e-01f, -3.53731215e-02f, 2.69189272e-02f, -5.24500711e-03f, -2.78669018e-02f, -3.43027189e-02f, -8.56027156e-02f, -3.31308246e-02f, 1.10366596e-02f,
  -2.90766478e-01f, -1.07371032e-01f, 1.05385624e-01f, -1.71145305e-01f, 5.24670407e-02f, -2.85983413e-01f, -4.44250368e-02f, -3.62979099e-02f, -1.04703560e-01f, 1.92869045e-02f,
  -1.62287623e-01f, 6.78361277e-04f, -2.31780782e-02f, -2.56301295e-02f, 2.39020392e-01f, 2.05714688e-01f, -2.32828349e-01f, -3.11064478e-02f, -1.29677668e-01f, -1.32294595e-01f,
  -5.91367558e-02f, 2.63116419e-01f, 2.03700215e-01f, 1.79679528e-01f, 4.38446254e-02f, 2.80491829e-01f, 2.08665028e-01f, 2.62307823e-01f, 2.75193661e-01f, 3.30606908e-01f,
  1.39141333e+00f, -3.79874706e-01f, -1.19200617e-01f, 8.32449347e-02f, -3.33677948e-01f, -6.67431578e-02f, -3.62284452e-01f, 2.61844546e-02f, 1.13676235e-01f, -7.41722016e-03f,
  -1.52485771e-02f, 2.77293384e-01f, 2.04441443e-01f, 9.82823893e-02f, 8.18229243e-02f, -1.75497517e-01f, -2.57792592e-01f, 9.80677903e-02f, 2.58223534e-01f, -7.10795075e-02f,
  -1.62142828e-01f, -2.31944337e-01f, 1.10816501e-01f, -6.23183092e-03f, -3.76946449e-01f, -1.20206460e-01f, -3.58287007e-01f, -3.53913039e-01f, -4.80369210e-01f, -3.52483511e-01f,
  -4.40317631e-01f, 1.37233913e-01f, 2.04008296e-01f, 1.39136717e-01f, -2.50807200e-02f, 2.00371817e-01f, 1.83996901e-01f, 6.01207800e-02f, -2.39081550e-02f, -1.02612779e-01f,
  -6.86533973e-02f, 3.63236926e-02f, 4.65176255e-02f, -9.78132244e-03f, -1.16897449e-01f, -7.67760947e-02f, 9.25755650e-02f, -1.10015653e-01f, -6.80125728e-02f, 6.69374596e-03f,
  -3.08265314e-02f, 2.74226479e-02f, -4.88454243e-03f, -1.38246287e-02f, 1.13586664e-01f, 1.77440107e-01f, 4.98902090e-02f, 8.10901523e-02f, 2.16893986e-01f, 2.03341037e-01f,
  -3.72528285e-02f, 2.74941593e-01f, 7.61832595e-02f, 1.28994167e-01f, 1.18507504e-01f, 1.38409972e-01f, -7.99423307e-02f, -4.46835272e-02f, 1.31171674e-01f, 4.69709523e-02f,
  -1.20349787e-01f, -3.43954563e-03f, 4.76397686e-02f, -4.88007851e-02f, 1.58082753e-01f, -1.82851385e-02f, -1.86109722e-01f, 1.33475764e-02f, 3.61004695e-02f, -1.45232910e-02f,
  -4.50945878e-03f, -6.67623878e-02f, -7.18061179e-02f, -2.52704591e-01f, -1.71740502e-01f, 8.78618360e-02f, -2.45942920e-02f, 9.08000246e-02f, 5.19114919e-02f, -7.90463239e-02f,
  -5.02833605e-01f, 3.21519583e-01f, 8.07128102e-02f, 1.13142185e-01f, 1.82408318e-02f, -3.81922275e-02f, 1.49050996e-01f, -1.35731503e-01f, -2.54086524e-01f, -1.61675930e-01f,
  -1.29919693e-01f, 1.23948187e-01f, -4.91083693e-03f, -1.65413003e-02f, 7.73765668e-02f, 8.34868290e-03f, 8.05434883e-02f, 4.88585830e-02f, -7.41505697e-02f, -2.04073206e-01f,
  -4.23250124e-02f, 1.09273516e-01f, 1.22102425e-01f, 1.54801890e-01f, 2.35914797e-01f, 2.46198699e-01f, 5.46217747e-02f, -2.99998801e-02f, 1.38784230e-01f, 2.23846644e-01f,
  -1.85456622e+00f, -2.53843844e-01f, 2.37996459e-01f, -1.01925313e+00f, -1.31185576e-01f, -4.42680195e-02f, 2.33907580e-01f, 1.37960255e-01f, -2.45267868e-01f, -7.63663575e-02f,
  1.74085304e-01f, 3.54352705e-02f, 1.24948718e-01f, 4.35628518e-02f, -2.46315882e-01f, -9.46046785e-02f, -3.37735236e-01f, -6.62264109e-01f, -3.35791469e-01f, -3.34431641e-02f,
  -2.62130380e-01f, -5.10317206e-01f, -9.14208651e-01f, -3.80026579e-01f, 2.49774739e-01f, 2.12469809e-02f, 1.16910756e-01f, -3.03979933e-01f, -1.27579510e-01f, -1.76145226e-01f,
  5.57740390e-01f, 5.60383834e-02f, 3.94383706e-02f, -3.54060262e-01f, 1.08911574e-01f, -7.20142871e-02f, 7.58936480e-02f, 4.35237437e-02f, -7.30109513e-02f, -5.78491837e-02f,
  -3.50970775e-02f, -4.05099355e-02f, -1.30632743e-01f, 1.45791888e-01f, -2.30182186e-02f, 1.38909626e-03f, 2.13984717e-02f, -1.62738919e-01f, 2.91398894e-02f, 5.64559877e-01f,
  1.27439961e-01f, -1.69594705e-01f, 6.50559962e-02f, 1.31774008e-01f, 2.29274556e-01f, -1.94243297e-01f, 3.75450045e-01f, 2.50691563e-01f, 3.03915720e-02f, 1.47123531e-01f,
  5.44174016e-02f, 1.59767330e-01f, 7.27859363e-02f, 1.24806896e-01f, -3.73266116e-02f, -3.80884521e-02f, -1.17131725e-01f, -9.85803083e-04f, 9.18123499e-02f, 1.42230317e-01f,
  1.01967128e-02f, 5.02196774e-02f, 5.40183187e-02f, -7.03762025e-02f, 6.76438287e-02f, -1.95407525e-01f, -1.58547014e-01f, 6.85262382e-02f, 1.39848385e-02f, -2.23413274e-01f,
  2.45153462e-03f, 1.31576344e-01f, -3.96645851e-02f, 4.04505171e-02f, -1.10305823e-01f, -2.90871337e-02f, 3.20950896e-02f, -2.65449577e-04f, 1.10071404e-02f, -1.58054620e-01f,
  2.50217289e-01f, -4.41161066e-01f, -3.49800736e-02f, -8.97247065e-03f, 7.48517970e-03f, -8.51788893e-02f, 2.51304433e-02f, -8.62683058e-02f, -1.54697701e-01f, 6.38957620e-02f,
  2.41464786e-02f, -2.86223274e-02f, 8.63903165e-02f, 7.28384554e-02f, -1.44456670e-01f, 5.02745099e-02f, -2.72272974e-01f, -1.72708705e-01f, -1.37933895e-01f, 1.89148247e-01f,
  -8.95412937e-02f, -2.68792868e-01f, -3.37600529e-01f, 2.48494130e-02f, 2.95159906e-01f, -2.82062411e-01f, 2.88451016e-01f, 2.53226578e-01f, -1.80531651e-01f, -1.40117526e-01f,
  -3.18680972e-01f, 7.12819576e-01f, -5.74578345e-01f, -3.49861354e-01f, -6.79713190e-01f, -7.21408546e-01f, 5.75956888e-02f, -1.39990360e-01f, -3.35899949e-01f, 1.93812087e-01f,
  2.45196655e-01f, -1.92390800e-01f, 5.62440380e-02f, -1.74667582e-01f, -1.51097864e-01f, 1.58418939e-01f, -2.38703445e-01f, -9.94711101e-01f, -1.11433172e+00f, -8.53932679e-01f,
  -4.16752636e-01f, -5.32641172e-01f, -6.18931293e-01f, -4.54423606e-01f, -1.20196350e-01f, -3.76290500e-01f, 7.83554371e-03f, -4.47903454e-01f, -4.17896479e-01f, -2.87099332e-01f,
  -2.89440919e-02f, -3.67710769e-01f, 2.16036644e-02f, 5.81155792e-02f, 1.60757706e-01f, 1.77765965e-01f, -1.11941263e-01f, 9.80615839e-02f, 1.19612537e-01f, 1.11195900e-01f,
  4.81936038e-02f, -4.52265218e-02f, -4.62603150e-03f, -3.06539256e-02f, -1.20146945e-01f, -2.89231706e-02f, 2.69490704e-02f, -5.42712472e-02f, -1.16077522e-02f, 9.45393890e-02f,
  1.38437852e-01f, 7.28399158e-02f, 1.09210186e-01f, 1.22823253e-01f, -3.74842510e-02f, -1.51576638e-01f, -2.57824026e-02f, -1.87961385e-01f, -1.09957017e-01f, 9.64260697e-02f,
  -1.85034648e-01f, 2.05295682e-01f, 6.92185089e-02f, 3.48645151e-02f, 1.02660753e-01f, 2.14307696e-01f, 8.77532139e-02f, 6.91759884e-02f, -4.64376509e-02f, 1.89637512e-01f,
  1.46917671e-01f, 4.47945856e-02f, -6.39969334e-02f, -9.88609251e-03f, 5.47628514e-02f, -9.57615376e-02f, -7.97868967e-02f, 9.68912020e-02f, 2.27994025e-02f, 5.51201515e-02f,
  1.64173823e-02f, 4.00185809e-02f, 1.28410775e-02f, -1.52525334e-02f, -5.67655712e-02f, -1.68356989e-02f, -1.61022663e-01f, 2.61491630e-02f, -4.19364534e-02f, -1.60678566e-01f,
  3.63849521e-01f, -2.93633938e-01f, 1.34451926e-01f, -3.68249640e-02f, -6.59239888e-02f, 8.39823335e-02f, -1.22869521e-01f, -2.70858575e-02f, 3.75696830e-02f, -1.64938480e-01f,
  -1.71483368e-01f, -6.32986650e-02f, 9.87520292e-02f, 1.11761622e-01f, -8.65165889e-02f, -8.95159468e-02f, 2.65315861e-01f, 1.06533960e-01f, -5.31472564e-02f, 8.55043232e-02f,
  3.05911839e-01f, 1.67918026e-01f, 3.20138693e-01f, 1.68216377e-01f, 3.73356752e-02f, -6.83218017e-02f, 1.32762030e-01f, -3.54933254e-02f, -5.62195703e-02f, 3.88808221e-01f,
  -1.33871305e+00f, -6.44845903e-01f, 4.15683895e-01f, -4.95306730e-01f, 3.54678221e-02f, 4.95108478e-02f, -4.63230669e-01f, -4.71911579e-02f, -3.58696878e-02f, -7.12572455e-01f,
  -3.66898835e-01f, 2.94235349e-01f, 2.36855790e-01f, 6.19239807e-01f, 7.08339140e-02f, -4.69966918e-01f, 4.08831388e-02f, 3.05086017e-01f, 5.38272202e-01f, 6.42780364e-02f,
  -2.60203868e-01f, -2.75556952e-01f, 6.01217500e-04f, 1.42031386e-01f, -3.22928458e-01f, 8.36684480e-02f, 6.82355538e-02f, -2.76567459e-01f, -2.98537791e-01f, -7.15910375e-01f,
  -4.74507391e-01f, -4.07762498e-01f, 4.90836114e-01f, 1.28615960e-01f, 3.71756554e-02f, -1.17814079e-01f, -1.40293866e-01f, 1.49942888e-02f, -1.24023311e-01f, -1.12515755e-01f,
  -2.52075354e-03f, 1.35780439e-01f, -1.09815702e-01f, 7.99546111e-03f, -2.27228906e-02f, -3.04919425e-02f, 1.68363422e-01f, 2.72293836e-01f, 1.24144247e-02f, -1.18575983e-01f,
  1.99257836e-01f, -1.72530830e-01f, 4.51195538e-02f, 2.50239789e-01f, 1.89083889e-02f, 2.64611840e-01f, 2.08025485e-01f, 3.86795737e-02f, 9.62389633e-03f, -9.02538180e-01f,
  -9.00879577e-02f, 1.17827654e-01f, 1.38153374e-01f, 1.23143889e-01f, -9.36087370e-02f, 1.23073451e-01f, -2.96382848e-02f, -3.64243574e-02f, -2.22711870e-03f, 6.68317229e-02f,
  2.07619786e-01f, -7.39004314e-02f, 7.04810470e-02f, -2.11483389e-01f, 1.08675949e-01f, -1.75342277e-01f, -8.69383067e-02f, -2.65371054e-02f, -4.30347919e-02f, -4.51056845e-02f,
  1.19216733e-01f, 5.64096831e-02f, 1.35436114e-02f, 9.89527106e-02f, -5.48383482e-02f, 3.97050008e-02f, -2.91346125e-02f, 2.05554083e-01f, 1.55065432e-02f, -1.09629683e-01f,
  -1.95187420e-01f, 2.89123118e-01f, -4.91872430e-01f, 1.05588987e-01f, -6.93839565e-02f, 1.74960122e-01f, -9.05431360e-02f, 1.25947580e-01f, 8.53484869e-02f, -1.21050864e-01f,
  1.24749444e-01f, 9.42047760e-02f, 2.25017332e-02f, 9.14640725e-02f, 5.45934513e-02f, 8.09488222e-02f, -1.01327658e-01f, 1.40138268e-01f, -1.88639387e-02f, 1.19344667e-02f,
  1.34164631e-01f, -1.92354366e-01f, -4.92388934e-01f, -3.30082513e-02f, -4.23422337e-01f, -1.16622532e-02f, -1.79510027e-01f, -1.89059466e-01f, -2.13314995e-01f, -9.90000367e-01f,
  -5.36251426e-01f, 3.77067357e-01f, 1.09000720e-01f, 7.64565617e-02f, -5.49522519e-01f, -4.58634049e-01f, -1.78731218e-01f, -8.66920799e-02f, 1.05281822e-01f, 2.84456909e-01f,
  -7.83550799e-01f, -6.11809194e-01f, 1.51740700e-01f, 1.63042784e-01f, 1.27865747e-01f, 6.41824484e-01f, 8.32569599e-01f, 2.26186261e-01f, -8.05527806e-01f, -9.78505194e-01f,
  -1.94374532e-01f, -2.59967092e-02f, -1.55626118e-01f, -5.49161397e-02f, 3.95025939e-01f, 2.94818152e-02f, 5.50351858e-01f, 1.47711849e-02f, 2.06868544e-01f, 8.89143586e-01f,
  -4.58022177e-01f, -1.10260777e-01f, -2.02358603e-01f, -3.37245256e-01f, -1.87878788e-01f, 2.40631342e-01f, -8.50862116e-02f, 2.78644025e-01f, -1.33212849e-01f, 1.33452833e-01f,
  -3.65071744e-01f, 1.33827388e-01f, -3.46646756e-01f, 2.41608210e-02f, -3.65110904e-01f, -2.57111937e-01f, 2.55069941e-01f, 4.92293737e-04f, 2.48167485e-01f, -3.56675506e-01f,
  3.28056216e-02f, -5.97920179e-01f, -5.21781266e-01f, 1.17890172e-01f, 4.29261953e-01f, -1.86881214e-01f, -2.21755490e-01f, -8.71464610e-02f, 8.56940225e-02f, 4.88188505e-01f,
  -1.10472465e-04f, -1.53103784e-01f, 4.10186872e-02f, 1.62967190e-01f, 6.59762835e-03f, -1.49039343e-01f, 1.18443370e-01f, 2.01457851e-02f, 5.40838428e-02f, -1.61859155e-01f,
  -9.82083306e-02f, -1.45438850e-01f, 1.42227039e-01f, -1.07674710e-01f, -2.55833697e-02f, -1.84060410e-02f, 8.21420178e-02f, 1.95723459e-01f, -1.25360101e-01f, 6.23271354e-02f,
  -7.18086362e-02f, 9.97656584e-02f, 9.16204322e-03f, 9.67377145e-03f, 2.12768510e-01f, 2.44626477e-01f, 1.35131821e-01f, -7.85574540e-02f, 1.48744345e-01f, 6.44515157e-02f,
  -1.11181132e-01f, 2.07664967e-02f, 1.88296348e-01f, 6.00283742e-02f, -5.79721741e-02f, 2.60630324e-02f, -6.87180534e-02f, -4.60680202e-02f, -5.73501624e-02f, -1.63459688e-01f,
  -3.42564493e-01f, -2.72996183e-02f, 2.46986970e-01f, 1.11629970e-01f, -3.43417436e-01f, 8.09694231e-02f, -3.18233222e-02f, -3.10774207e-01f, -1.32717401e-01f, -3.64380553e-02f,
  1.64010435e-01f, -3.70843053e-01f, -6.34009600e-01f, -8.80489200e-02f, -6.41980916e-02f, -5.91926396e-01f, -3.37030053e-01f, -3.01913232e-01f, -2.46336058e-01f, -8.10203701e-02f,
  1.05936730e+00f, -8.73896927e-02f, 2.22011432e-01f, 3.92438859e-01f, -8.93245563e-02f, -2.73691475e-01f, -3.45810384e-01f, -2.22273152e-02f, 1.44676879e-01f, 2.63159901e-01f,
  7.97107741e-02f, 2.49132961e-01f, 2.49394447e-01f, 2.37936854e-01f, 3.29465210e-01f, 7.37527981e-02f, 2.13573173e-01f, 4.86903518e-01f, 3.57226402e-01f, 3.18873554e-01f,
  2.04597190e-01f, 2.67253011e-01f, 3.59676480e-01f, 2.54022956e-01f, 1.40143067e-01f, 2.83819020e-01f, 1.15582049e-01f, 1.11600250e-01f, 9.32287797e-02f, 2.64238924e-01f,
  3.06409776e-01f, 8.77293572e-02f, 8.30898732e-02f, 7.10437968e-02f, -1.24788629e-02f, -3.66121680e-02f, -7.81727657e-02f, -3.82894278e-02f, -1.53875843e-01f, -5.57101369e-02f,
  -1.98325694e-01f, -2.78485231e-02f, -7.67112747e-02f, -1.05908394e-01f, -9.99975204e-02f, -1.81616265e-02f, 1.22131333e-01f, 1.99558407e-01f, 7.24027772e-03f, 3.10155638e-02f,
  -9.38175991e-02f, -2.34984800e-01f, -2.64102131e-01f, -1.97688237e-01f, 9.32090953e-02f, 6.45584241e-02f, -1.22818880e-01f, 6.77717999e-02f, -1.35752177e-02f, 8.42321888e-02f,
  -4.55396250e-03f, 3.58321071e-02f, 2.94173360e-01f, 2.99154937e-01f, 3.69412392e-01f, 9.66271088e-02f, 7.63718635e-02f, 2.91063357e-02f, 1.65827200e-01f, 4.42626365e-02f,
  6.73408359e-02f, 1.20471239e-01f, -9.83492658e-02f, 9.73390266e-02f, 2.51745582e-01f, 1.12309167e-02f, -1.99564993e-01f, -1.62251115e-01f, -2.15897430e-02f, -6.92853183e-02f,
  7.58837163e-02f, -4.34923321e-02f, 4.05278355e-02f, 3.00779124e-03f, 1.49494428e-02f, 6.31152838e-02f, 1.11693203e-01f, -1.90564757e-03f, -3.90600637e-02f, -6.31562024e-02f,
  -6.17263615e-01f, -3.14136632e-02f, 3.23446780e-01f, 7.21466914e-02f, -1.04390003e-01f, 4.18046582e-03f, 1.63382679e-01f, -1.20468379e-03f, -5.85711151e-02f, -6.65570423e-02f,
  -1.08086511e-01f, 1.45559207e-01f, -1.27926007e-01f, 4.27397573e-03f, -7.24301338e-02f, -2.19035685e-01f, -7.55366087e-02f, 2.36571003e-02f, -1.07884064e-01f, -1.74029052e-01f,
  -2.20579863e-01f, -2.40596682e-01f, -4.21284765e-01f, -1.89698324e-01f, -1.15472399e-01f, -1.55114112e-02f, -2.02118054e-01f, -1.66191965e-01f, -2.39616767e-01f, -2.32532442e-01f,
  -1.86973348e-01f, -4.59698498e-01f, 1.06200926e-01f, 5.03484547e-01f, 6.55628145e-01f, 6.75250709e-01f, 4.87252742e-01f, 2.75928468e-01f, 2.76562601e-01f, 6.30285814e-02f,
  -1.33800790e-01f, 1.54750012e-02f, 1.19681612e-01f, 4.07092012e-02f, -1.74041465e-02f, 4.09647137e-01f, 4.39903468e-01f, 1.40008017e-01f, 1.57374561e-01f, 2.09674120e-01f,
  2.71447062e-01f, 4.41041738e-02f, -1.59606948e-01f, -1.12938704e-02f, 5.62374741e-02f, 1.21363208e-01f, 1.53692052e-01f, 1.37745654e-02f, 1.33356927e-02f, -3.77617329e-02f,
  -1.84740707e-01f, -8.42041299e-02f, 1.36486560e-01f, -1.60721019e-01f, -3.40338111e-01f, -3.26057911e-01f, -6.22934476e-03f, -1.61120310e-01f, -2.64707744e-01f, -2.54307054e-02f,
  -6.93067610e-02f, -1.00737110e-01f, -2.36734599e-02f, -1.11163303e-01f, -9.21041518e-02f, -2.14734562e-02f, -1.35517433e-01f, 1.24141008e-01f, 1.77298397e-01f, -8.76909401e-03f,
  -1.27662746e-02f, 2.00931460e-01f, 3.02421629e-01f, 1.77804932e-01f, 1.18669868e-01f, 1.09347783e-01f, -1.36903137e-01f, -1.35466278e-01f, 6.28248453e-02f, 4.97162864e-02f,
  2.18442485e-01f, -3.32048535e-02f, 1.33904710e-01f, 1.03960358e-01f, -3.29245217e-02f, -4.83061522e-02f, 1.26418889e-01f, 1.38727605e-01f, 2.75857270e-01f, 4.42641135e-03f,
  -7.09763542e-03f, 1.70353130e-01f, 1.07647926e-01f, -2.06995234e-02f, 1.03947774e-01f, 1.77294463e-01f, -1.84004948e-01f, 3.95730734e-02f, 6.70528859e-02f, -4.11369093e-02f,
  2.43847119e-03f, 5.75487576e-02f, -2.09175393e-01f, -8.50826502e-02f, 3.55213396e-02f, 5.98785803e-02f, -5.01011536e-02f, -9.76055581e-03f, -8.57467130e-02f, -2.58720424e-02f,
  3.31322104e-01f, 4.32114840e-01f, 5.58224842e-02f, 6.92284033e-02f, -4.23704833e-02f, -2.23455101e-01f, 9.78971198e-02f, -1.59181967e-01f, -1.95743367e-01f, -9.31912512e-02f,
  -1.30811974e-01f, -2.36542836e-01f, -1.48654789e-01f, -2.32371818e-02f, -6.79166093e-02f, -1.34266308e-02f, -7.77371973e-02f, 2.99216926e-01f, 1.42828271e-01f, -1.15641072e-01f,
  -1.73176438e-01f, 2.14372411e-01f, 2.49919102e-01f, 2.44014785e-01f, 2.04295442e-02f, 7.02143759e-02f, -1.22570544e-01f, 2.16401201e-02f, -2.18029507e-02f, -6.35461435e-02f,
  -3.41095358e-01f, 6.92587793e-01f, 4.88529861e-01f, -6.07247412e-01f, 4.89522666e-01f, 7.60474801e-01f, 6.56521380e-01f, 1.65705964e-01f, -3.08913738e-01f, 8.82824138e-02f,
  4.63416666e-01f, -4.20332849e-01f, -5.33994019e-01f, -4.10003215e-01f, -2.89757460e-01f, -2.20876280e-02f, -2.92491585e-01f, -3.83247286e-01f, -3.26844066e-01f, -1.36830792e-01f,
  -2.58187473e-01f, -4.13354427e-01f, -3.54342282e-01f, -4.57680017e-01f, -3.39755744e-01f, -6.44997001e-01f, 3.40199172e-02f, 1.06003679e-01f, 3.79214942e-01f, -7.07135916e-01f,
  2.23527610e-01f, 5.26019394e-01f, -3.72470856e-01f, -1.49141997e-01f, 1.10499151e-01f, -1.47218615e-01f, -1.29219711e-01f, -1.10561840e-01f, 2.48565397e-04f, -1.44473970e-01f,
  1.15124047e-01f, 5.47371013e-03f, -7.95130506e-02f, 9.17742625e-02f, 1.98660851e-01f, 2.10104242e-01f, 2.73509949e-01f, -6.39789850e-02f, -1.18307760e-02f, 2.50173301e-01f,
  2.44918168e-02f, 3.18002135e-01f, 3.08822125e-01f, 2.03916565e-01f, 1.97661072e-01f, -1.34921521e-01f, 3.92590344e-01f, 9.37786698e-02f, 2.48876855e-01f, -3.89139742e-01f,
  1.96477165e-03f, 6.72138250e-03f, 5.97337075e-03f, -2.42064148e-02f, -2.55071968e-02f, 2.54621431e-02f, -8.12145472e-02f, -9.07624960e-02f, 2.95082666e-03f, -2.59708967e-02f,
  1.02938294e-01f, 9.34617594e-02f, 3.46529819e-02f, -1.04618311e-01f, -1.37944460e-01f, 5.15084788e-02f, 6.15022443e-02f, -6.45981580e-02f, 2.11591661e-01f, -2.93729622e-02f,
  -6.46242732e-03f, -8.03590752e-03f, 1.46485483e-02f, -4.68714461e-02f, 2.63189256e-01f, 1.11157484e-01f, 1.22852966e-01f, -7.36400336e-02f, 4.38348390e-02f, 2.10729986e-01f,
  -3.47782493e-01f, 4.88989741e-01f, -3.58444393e-01f, -1.44774895e-02f, 1.18402384e-01f, 1.39758557e-01f, 9.58998799e-02f, -9.59930883e-04f, 1.37261435e-01f, 2.01820247e-02f,
  2.27237046e-01f, 1.46410093e-02f, 1.66960001e-01f, 8.39456469e-02f, -5.63151836e-02f, 9.42261424e-03f, 7.88588226e-02f, -8.10339302e-02f, 7.46619180e-02f, 1.34340242e-01f,
  -3.02327536e-02f, -2.35164896e-01f, -4.34068620e-01f, -1.05432369e-01f, 2.79708523e-02f, -2.70999819e-01f, -1.25116974e-01f, -7.15541840e-02f, -9.26364809e-02f, -6.20883167e-01f,
  -1.22480881e+00f, 8.49275053e-01f, 3.10638160e-01f, -5.87915719e-01f, 6.90811455e-01f, 5.46402812e-01f, 1.02046180e+00f, -1.56535923e-01f, -8.90696168e-01f, 9.71482396e-02f,
  6.86585963e-01f, -4.42301631e-02f, -8.74676183e-02f, 1.62275419e-01f, 2.16706693e-01f, 5.48524380e-01f, 3.21260571e-01f, -5.32516688e-02f, -3.54606241e-01f, 1.89240247e-01f,
  2.39000186e-01f, -3.90044689e-01f, -5.53849876e-01f, -1.34236738e-01f, -3.06853980e-01f, -1.75491825e-01f, 4.27112319e-02f, 3.76944020e-02f, 5.80339909e-01f, 1.28638566e-01f,
  2.91601624e-02f, -3.69834080e-02f, 2.03711703e-01f, 1.40343588e-02f, 2.40106687e-01f, -4.92572755e-01f, -1.60978183e-01f, -2.91899323e-01f, 2.24603549e-01f, -2.16136217e-01f,
  5.87420203e-02f, -1.32850066e-01f, 7.62243047e-02f, -1.37969041e-02f, -2.03697100e-01f, 1.65281650e-02f, -1.78675905e-01f, -2.43461892e-01f, -4.72346246e-01f, -3.27644050e-02f,
  5.60862362e-01f, 5.08917272e-01f, 1.09456934e-01f, 1.60030842e-01f, -2.00978249e-01f, -2.74644531e-02f, 2.03775063e-01f, -1.60220280e-01f, -2.31976986e-01f, -6.72184646e-01f,
  -6.97203055e-02f, 1.89100236e-01f, 2.89005250e-01f, -1.23724431e-01f, 9.23000947e-02f, 7.40009621e-02f, 7.94949904e-02f, 1.67966574e-01f, 3.59700322e-02f, -1.04535155e-01f,
  3.45254242e-02f, 9.81793404e-02f, -1.33908361e-01f, -8.37832317e-02f, 1.85245693e-01f, 1.86565164e-02f, 5.28051332e-02f, 2.54550017e-02f, 1.02821052e-01f, 1.87179390e-02f,
  -9.11432803e-02f, 1.93495318e-01f, -1.72909632e-01f, -3.05975556e-01f, 1.70845196e-01f, 1.54967159e-01f, -1.91115975e-01f, -3.43931206e-02f, -1.60902649e-01f, 1.16283737e-01f,
  -7.92144299e-01f, 8.88249397e-01f, -4.63709295e-01f, -1.65787607e-01f, -6.08265623e-02f, 1.80342421e-01f, 2.65067965e-02f, 9.27806348e-02f, 1.55183801e-03f, -1.15739502e-01f,
  1.70626476e-01f, -4.84241694e-02f, 6.79849163e-02f, -3.37481592e-03f, -1.37793764e-01f, -1.62835166e-01f, 2.13253975e-01f, -8.83727297e-02f, -1.47148490e-01f, -1.45229667e-01f,
  -1.17447108e-01f, -1.60263613e-01f, -4.41132933e-01f, -9.48954374e-02f, -1.23307154e-01f, -1.52710468e-01f, -2.98570573e-01f, -3.63570601e-01f, -3.08819801e-01f, -5.64157844e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.03713506e-01f, 1.76686376e-01f, 2.57675380e-01f, 2.34363139e-01f, 1.22694612e+00f, 8.53820860e-01f, 4.33470249e-01f, 1.32139993e+00f, 1.02208841e+00f, 1.35163033e+00f,
  9.03828025e-01f, 7.99233615e-01f, 6.69357300e-01f, 3.68209153e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  2.89239790e-02f, 3.68211456e-02f, 2.12463722e-01f, -1.95666224e-01f, -1.70398980e-01f, 4.13336558e-03f, -2.75398433e-01f, -9.31969658e-02f, -1.67019054e-01f, -3.71941894e-01f,
  -2.56375402e-01f, -2.96814233e-01f, 3.47988345e-02f, 2.54534255e-03f, -2.20302969e-01f, 2.05231588e-02f, -3.05763662e-01f, -7.79731013e-03f, -3.57429236e-01f, -7.18514979e-01f,
  -8.88971463e-02f, -2.58945435e-01f, -2.01295421e-01f, 4.33048941e-02f, -1.55816555e-01f, 1.46579370e-01f, 3.75675321e-01f, 2.11625606e-01f, -6.54185489e-02f, -8.15538503e-03f,
  -1.61967412e-01f, -3.83090377e-01f, -5.13475388e-02f, 9.17225778e-02f, 4.86587673e-01f, 2.65119463e-01f, -2.99592435e-01f, 2.03169838e-01f, 2.29375124e-01f, 3.23452130e-02f,
  2.43430451e-01f, -4.26571101e-01f, 3.78198862e-01f, -3.13940853e-01f, 1.02502540e-01f, 3.06574970e-01f, -2.66786844e-01f, -1.50620669e-01f, 4.54786479e-01f, -2.66084731e-01f,
  6.68590546e-01f, 2.22733572e-01f, -4.44907516e-01f, 4.10482675e-01f, -9.33615804e-01f, 2.41835400e-01f, 9.72706303e-02f, -6.09716713e-01f, 4.96175736e-01f, -1.16009283e+00f,
  -4.67784613e-01f, -1.25686169e+00f, 1.49970189e-01f, -1.08941925e+00f, 2.20535249e-01f, 3.78830060e-02f, -2.07036287e-01f, 1.55561417e-01f, -2.85025537e-01f, 4.68650311e-02f,
  8.88345465e-02f, -3.17585796e-01f, -1.95469081e-01f, 2.42144033e-01f, 2.02074379e-01f, 2.28008360e-01f, -1.80294901e-01f, -2.04865843e-01f, -1.67400688e-01f, 1.95581280e-02f,
  2.84616470e-01f, -6.74439296e-02f, -1.67429000e-02f, -1.05959050e-01f, 1.61852673e-01f, 4.65863496e-02f, 5.70574142e-02f, -2.94762254e-01f, -1.68280646e-01f, -1.94710270e-01f,
  1.08614407e-01f, 2.24583745e-01f, 1.24471255e-01f, -3.53562355e-01f, -2.14161932e-01f, 3.36544693e-01f, -1.93978641e-02f, -8.38538408e-02f, 1.23117432e-01f, -3.86400968e-01f,
  1.14906453e-01f, -3.15321773e-01f, 1.80982262e-01f, -1.62807461e-02f, -3.33872080e-01f, -2.66579557e-02f, -3.93687069e-01f, -6.65730774e-01f, -3.63382176e-02f, 3.09152633e-01f,
  -4.37388569e-01f, 1.04868189e-01f, 4.12505001e-01f, -4.11727160e-01f, 7.95324385e-01f, -1.44878376e+00f, -1.46922851e+00f, 9.61840212e-01f, -1.17212141e+00f, 4.23018396e-01f,
  -1.01084709e+00f, -1.41475648e-01f, -8.38557780e-02f, -1.98791826e+00f, 6.62689626e-01f, 8.13272446e-02f, -9.34707165e-01f, -1.26747981e-01f, 5.30418148e-03f, -4.55595879e-03f,
  -1.37450501e-01f, 8.82552490e-02f, 2.62765493e-03f, -6.46706522e-02f, 3.45981032e-01f, -1.75488275e-02f, 8.82291570e-02f, -2.47349907e-02f, 7.99051151e-02f, 3.98941226e-02f,
  8.52583125e-02f, -1.95452794e-01f, 9.96107012e-02f, -3.80363911e-02f, -3.38865891e-02f, -6.45817667e-02f, 8.48448798e-02f, 3.39892320e-02f, -7.05493540e-02f, -6.27385601e-02f,
  1.22845797e-02f, 3.31114233e-02f, 2.28191778e-01f, 1.65088594e-01f, -1.36943430e-01f, 7.81860054e-02f, 1.50046557e-01f, 2.64171571e-01f, -2.09426358e-01f, 2.67559737e-01f,
  -3.34824920e-01f, 4.28244472e-01f, 1.23151034e-01f, -4.20813769e-01f, 3.22861046e-01f, 3.30601394e-01f, 4.24821317e-01f, 1.07526883e-01f, -2.92357177e-01f, 2.82098085e-01f,
  4.92022485e-01f, -2.23437712e-01f, -2.33737960e-01f, 4.95873392e-01f, -3.16714585e-01f, 4.51808959e-01f, 9.87341627e-03f, -5.60907051e-02f, -8.75913799e-01f, -7.92866468e-01f,
  -4.68572527e-01f, 6.89205229e-01f, -2.68780619e-01f, 2.79653072e-01f, -7.64932215e-01f, -7.03115463e-01f, 1.24685264e+00f, 5.06288707e-01f, -2.32692599e-01f, -7.13946462e-01f,
  -2.40472436e-01f, -1.40993297e-01f, -1.58180833e-01f, -1.60501190e-02f, -2.00243995e-01f, 8.40018839e-02f, -1.32165641e-01f, 1.00439286e-03f, 2.56267011e-01f, 1.25859112e-01f,
  -1.26969397e-01f, -1.50103554e-01f, -4.75915372e-02f, -6.27288461e-01f, -1.43867150e-01f, -1.19072556e-01f, 1.18735358e-01f, -1.19524956e-01f, -1.90709174e-01f, 1.62091285e-01f,
  -3.01566958e-01f, 1.61002368e-01f, 1.16058951e-02f, -6.07437253e-01f, -1.69510812e-01f, 7.16286674e-02f, -3.14024150e-01f, 4.44186851e-02f, 2.30617762e-01f, -7.12953806e-02f,
  1.70722157e-01f, 5.10423034e-02f, 1.98090170e-02f, 2.80141324e-01f, 5.73786609e-02f, -9.77839250e-03f, -4.97260183e-01f, 1.30264089e-01f, -4.20478821e-01f, 8.90592217e-01f,
  -4.20727640e-01f, 6.47912025e-02f, 1.34381764e-02f, 7.21393526e-01f, 2.10519791e-01f, -4.91296381e-01f, -3.66005421e-01f, 1.45065740e-01f, 5.60799778e-01f, -7.25846663e-02f,
  -2.10936427e-01f, -3.05173248e-01f, 5.14841735e-01f, -1.68045297e-01f, -1.11925006e+00f, -4.75699872e-01f, 1.84521720e-01f, -8.59414577e-01f, 2.03501001e-01f, 4.86612543e-02f,
  1.54942811e-01f, 2.54289001e-01f, -6.75025046e-01f, -6.56437337e-01f, 3.92980963e-01f, 9.93813813e-01f, 3.22552435e-02f, -1.72534510e-01f, -1.82744324e-01f, -1.41766369e-01f,
  -1.06206663e-01f, 1.43077329e-01f, -5.46887338e-01f, 4.24737521e-02f, -2.26951450e-01f, -1.08055383e-01f, -3.04339498e-01f, 1.96720034e-01f, 3.44791785e-02f, -1.34690166e-01f,
  2.10053567e-02f, 4.54336777e-03f, 1.61059543e-01f, -1.73611045e-01f, -1.25132678e-02f, 9.14966241e-02f, 1.70218199e-01f, 2.88297355e-01f, 1.05609231e-01f, -4.87809628e-02f,
  2.19379872e-01f, 7.78937489e-02f, -4.45238233e-01f, -3.84882867e-01f, 4.51656170e-02f, -1.20870225e-01f, 5.93703426e-02f, 2.37023547e-01f, -1.17860809e-02f, 9.79190767e-02f,
  4.08583432e-02f, 5.02070673e-02f, -9.66897979e-02f, -1.48463100e-01f, 1.31147765e-02f, -5.19592613e-02f, 1.29390389e-01f, 1.36588454e-01f, -7.13541657e-02f, 9.51220691e-02f,
  3.57325114e-02f, -8.52045021e-04f, 6.06567971e-02f, -2.43588895e-01f, -2.32284725e-01f, 4.23001125e-02f, -1.02419591e+00f, 3.03096265e-01f, 7.90356100e-01f, 4.59681153e-02f,
  -5.57475805e-01f, -1.44503146e-01f, 3.84248018e-01f, 4.14028108e-01f, 2.09304824e-01f, 5.38864791e-01f, -8.69536877e-01f, 2.43142605e-01f, 6.40480295e-02f, -1.23332584e+00f,
  -1.40206784e-01f, 1.02380812e-01f, 4.94970709e-01f, -1.11586573e-02f, 3.84208769e-01f, 2.37477615e-01f, 1.70991257e-01f, 2.23730788e-01f, -3.24001536e-02f, -9.28696170e-02f,
  1.21434435e-01f, 2.90290862e-01f, -4.35994007e-02f, 2.60512948e-01f, 6.57963380e-02f, 3.52271438e-01f, -1.94011718e-01f, 2.87189126e-01f, 5.74134886e-01f, 4.03699130e-01f,
  7.90647045e-03f, 4.81621087e-01f, -8.52478072e-02f, 4.64382261e-01f, 6.98632658e-01f, -1.89281672e-01f, 3.81443560e-01f, 1.67498868e-02f, -4.38398093e-01f, -2.56329291e-02f,
  3.76122445e-01f, 6.81464851e-01f, -1.84783027e-01f, 2.11096942e-01f, -3.23376119e-01f, 6.29283071e-01f, -5.97846448e-01f, -4.76859093e-01f, 6.48227260e-02f, 4.61401761e-01f,
  2.25455672e-01f, -6.25625253e-01f, -4.51157629e-01f, 8.03566992e-01f, -2.89992362e-01f, -5.93692780e-01f, -3.77868377e-02f, -1.82157665e-01f, 2.98106164e-01f, -2.47037545e-01f,
  2.35283047e-01f, 2.42555499e-01f, -2.44356513e-01f, -1.15134962e-01f, -4.66530323e-01f, 1.33368924e-01f, -4.67348933e-01f, 7.94871986e-01f, -1.60555756e+00f, 3.66595775e-01f,
  -1.60177037e-01f, -1.47094339e-01f, -1.39180613e+00f, -6.36278450e-01f, 8.66491720e-02f, -2.15477377e-01f, 6.60739690e-02f, 1.60263807e-01f, 7.51429945e-02f, 9.93155241e-02f,
  -1.70775373e-02f, 9.02033672e-02f, 7.60277873e-03f, 4.30221409e-02f, 5.36353774e-02f, -5.15618265e-01f, 1.83826610e-01f, 3.63294363e-01f, 8.06381628e-02f, 6.08484410e-02f,
  -8.94600675e-02f, -3.02837696e-02f, -6.70570880e-02f, 5.35036176e-02f, 9.82852876e-02f, -8.09955150e-02f, 8.14910755e-02f, -5.34299552e-01f, -6.33230388e-01f, -3.84369433e-01f,
  -5.23415267e-01f, -2.62027115e-01f, -4.24843401e-01f, 1.57146789e-02f, -3.77902091e-01f, -9.65895593e-01f, -2.82919663e-03f, -1.62648633e-01f, 4.64182079e-01f, -6.56419277e-01f,
  4.90910262e-01f, -9.09271166e-02f, -2.66145825e-01f, -2.83749461e-01f, 1.70366868e-01f, 6.18310809e-01f, -2.26867437e-01f, 4.16022927e-01f, -3.54474597e-03f, -3.51380318e-01f,
  -2.04973027e-01f, 1.64084390e-01f, -2.66542286e-01f, 2.09089294e-01f, -3.23847592e-01f, -6.85619652e-01f, -4.54219520e-01f, -8.42899859e-01f, -7.02332377e-01f, 1.95281610e-01f,
  -3.03054512e-01f, -8.43424618e-01f, -9.23158169e-01f, 9.21228111e-01f, 6.88619316e-01f, -9.42899227e-01f, -1.18583345e+00f, -1.22317624e+00f, -7.72959888e-02f, -1.82119295e-01f,
  -3.41520071e-01f, 5.54692447e-02f, -3.24130893e-01f, 8.41238648e-02f, 7.63871074e-02f, -1.95221305e-01f, 1.51112735e-01f, -1.37473539e-01f, -2.51370251e-01f, -1.96159869e-01f,
  -3.84613603e-01f, -2.61509448e-01f, -1.50788829e-01f, -3.49197946e-02f, -3.56214084e-02f, -5.22562563e-02f, -3.35242778e-01f, -3.01479250e-01f, -6.80497736e-02f, 2.38876760e-01f,
  2.61893757e-02f, 5.85838817e-02f, -7.05403537e-02f, -2.66900230e-02f, 2.62652159e-01f, -2.82654285e-01f, 3.69629800e-01f, 7.00211450e-02f, 1.02915838e-02f, -8.26327875e-02f,
  -1.23556487e-01f, -2.88581163e-01f, -4.86610532e-01f, 1.91362411e-01f, -4.78259653e-01f, 1.19378969e-01f, -1.31729275e-01f, -8.40136036e-02f, 1.22239642e-01f, -3.45624149e-01f,
  3.78314056e-03f, 1.07621260e-01f, 1.27152786e-01f, 6.39344379e-02f, 2.51682788e-01f, 1.01052694e-01f, -8.63203555e-02f, 1.79868981e-01f, -9.43428397e-01f, -3.29311579e-01f,
  8.99278466e-03f, -7.17827380e-01f, -1.52588382e-01f, -6.50833309e-01f, -1.45714462e-01f, -7.62070775e-01f, 5.59475362e-01f, 8.61117601e-01f, -4.95082855e-01f, 4.12338376e-01f,
  -6.68247700e-01f, 6.46446347e-01f, 1.77069549e-02f, 2.65730739e-01f, -1.28193483e-01f, 2.80495882e-01f, 1.22277141e-01f, -2.91543156e-02f, -2.04841554e-01f, 1.77058466e-02f,
  -7.21023157e-02f, 1.97303087e-01f, -9.11890641e-02f, 2.57904261e-01f, 5.51225021e-02f, 5.85894957e-02f, 1.59199804e-01f, -1.73941195e-01f, 1.62545964e-01f, 2.87951559e-01f,
  5.77500835e-02f, 1.85533807e-01f, 6.49142340e-02f, 1.84958816e-01f, 1.61373660e-01f, -1.71539158e-01f, 6.93620369e-02f, -3.26746464e-01f, -1.43476024e-01f, 8.05271491e-02f,
  -1.71158567e-01f, 1.97385594e-01f, 1.05096608e-01f, -2.29448214e-01f, 2.51251727e-01f, -5.28212497e-03f, -2.36342356e-01f, -3.95015895e-01f, 3.39215934e-01f, -2.82556769e-02f,
  -9.61514264e-02f, 1.44087300e-01f, 3.47621769e-01f, -3.80266517e-01f, 2.41478473e-01f, -1.60153225e-01f, -1.32322649e-03f, 5.97941041e-01f, 1.52255133e-01f, 2.39752948e-01f,
  2.30143338e-01f, 4.68531288e-02f, -6.34649217e-01f, -4.22268748e-01f, -4.11746293e-01f, -3.40299994e-01f, 1.36607730e+00f, -5.22253931e-01f, -7.28407860e-01f, -1.00461280e+00f,
  -7.67367065e-01f, -3.93760681e-01f, -3.56058121e-01f, 3.12887192e-01f, -3.40234846e-01f, -2.18687300e-02f, 5.86229414e-02f, 2.14798242e-01f, 1.79939270e-01f, -3.22885402e-02f,
  4.86123487e-02f, -2.64246404e-01f, -4.14174438e-01f, 1.02338821e-01f, 2.49615639e-01f, -3.79747778e-01f, 1.42288720e-02f, 2.61062026e-01f, -1.25082001e-01f, 7.81864002e-02f,
  -1.98918387e-01f, 9.15800929e-02f, 6.11717761e-01f, 5.81919821e-03f, -1.58331409e-01f, -1.98952675e-01f, 3.48673128e-02f, -6.06600940e-01f, -1.60737053e-01f, -9.91339386e-02f,
  9.35044512e-02f, 3.48628581e-01f, -2.68640846e-01f, -1.21834308e-01f, 6.78259730e-01f, 1.99443400e-01f, -3.29769820e-01f, 7.60061502e-01f, 2.31218114e-01f, 9.16520506e-03f,
  5.44098675e-01f, 9.70577240e-01f, 5.84583521e-01f, 5.65387942e-02f, 8.00161719e-01f, -3.16655755e-01f, -8.31649303e-01f, -5.05747736e-01f, 8.19665492e-01f, 3.99447918e-01f,
  3.30252081e-01f, -1.43011704e-01f, -6.81206882e-01f, -3.02484363e-01f, -5.65552413e-01f, 4.13358212e-01f, -6.54029965e-01f, 1.12005627e+00f, 1.08277726e+00f, -1.07395817e-02f,
  -8.46483469e-01f, -1.99931607e-01f, -8.12720180e-01f, -3.03458005e-01f, -7.61038721e-01f, -5.01622021e-01f, 3.11938792e-01f, -7.65312135e-01f, -1.97875127e-01f, 2.09429041e-01f,
  2.00410068e-01f, 3.40835005e-01f, 1.05254441e-01f, -1.74532216e-02f, 1.03366077e-01f, -8.82151276e-02f, 2.38610268e-01f, 6.59836158e-02f, 7.01704472e-02f, 1.26764566e-01f,
  3.91810030e-01f, -1.74519178e-02f, 2.93895662e-01f, -2.15337668e-02f, 4.76278476e-02f, 1.84169400e-03f, 1.15535721e-01f, 3.05017084e-01f, -1.66422859e-01f, -9.23173651e-02f,
  5.93085289e-02f, -2.47167036e-01f, 1.69679135e-01f, -1.71138838e-01f, -6.26282036e-01f, 3.15429509e-01f, 2.10235834e-01f, 2.34709859e-01f, 5.38359284e-01f, 3.90027702e-01f,
  8.47677663e-02f, -3.54657561e-01f, 6.03377260e-02f, -2.52112865e-01f, -4.46155965e-01f, 2.30090208e-02f, -5.96187055e-01f, -1.82844087e-01f, 4.19276327e-01f, 8.19561481e-02f,
  -4.26687390e-01f, -1.37016311e-01f, 2.22464710e-01f, -6.30303502e-01f, -2.27211252e-01f, -4.39377248e-01f, 5.02988458e-01f, 5.20493872e-02f, 3.16316366e-01f, -5.19826412e-01f,
  -9.47906971e-01f, -9.16939795e-01f, -3.31963450e-01f, -8.71565700e-01f, 7.24200904e-01f, -1.41454160e+00f, 1.22519624e+00f, 4.48260039e-01f, 2.49410808e-01f, -5.36501288e-01f,
  -4.08742607e-01f, -7.07104683e-01f, -9.32619810e-01f, -5.82671940e-01f, -2.49220148e-01f, 4.88620205e-03f, 1.47013247e-01f, -3.65863115e-01f, -1.12931944e-01f, 2.36626804e-01f,
  -1.91741884e-02f, -4.10411395e-02f, -1.39356330e-01f, 4.58884150e-01f, -2.88955867e-01f, 2.48158470e-01f, 3.13425511e-01f, -2.29963809e-01f, 8.10238793e-02f, -2.00211853e-01f,
  -1.70175284e-02f, -3.58111449e-02f, 1.99864775e-01f, 1.37120575e-01f, 1.79314345e-01f, 9.47415605e-02f, -5.25837578e-02f, 3.17707628e-01f, -2.83690766e-02f, -2.63300717e-01f,
  -3.47179919e-01f, 2.01244488e-01f, -3.01132143e-01f, -3.28467876e-01f, -3.95704694e-02f, -2.40390286e-01f, 3.22159320e-01f, -1.75020128e-01f, -1.06317207e-01f, -6.58085048e-01f,
  5.37266791e-01f, 2.20274627e-02f, -3.45529437e-01f, -1.55458659e-01f, 4.47963446e-01f, 6.30331576e-01f, -6.11175895e-01f, 2.28748336e-01f, 1.47127047e-01f, -3.45041782e-01f,
  2.80290872e-01f, 2.17610002e-01f, -2.75006801e-01f, 3.38012576e-01f, -4.97141838e-01f, -3.93261582e-01f, 3.31529409e-01f, -3.32550317e-01f, -9.09809351e-01f, -8.37081254e-01f,
  -4.36857283e-01f, -1.72701478e-01f, -7.91444004e-01f, -7.81636298e-01f, -3.23515773e-01f, 2.94015910e-02f, 1.01366532e+00f, 8.99848223e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.51551038e-01f, -3.60594869e-01f, 1.96057081e-01f, -8.08769107e-01f, -1.20959669e-01f, 3.30086321e-01f, 5.27180433e-01f, -1.10043092e-02f, -5.32522559e-01f, 2.59405345e-01f,
  1.17077446e-03f, 2.91423559e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    