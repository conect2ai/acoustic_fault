/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.35382110e-01f, -1.72148496e-01f, -3.17611694e-01f, 4.45776992e-02f, 5.42119332e-02f, 5.24600409e-02f, -1.72175422e-01f, -8.65664259e-02f, 1.17493205e-01f, 2.29913890e-02f,
  -1.58163998e-02f, -1.10809132e-01f, -1.03256471e-01f, -4.44623157e-02f, -5.87359071e-02f, -1.48724496e-01f, -1.09249894e-02f, -5.65086193e-02f, -2.46335696e-02f, 1.38915807e-01f,
  2.03057840e-01f, 5.93078099e-02f, 1.82045653e-01f, 7.20730722e-02f, 9.46399644e-02f, -7.70925432e-02f, -2.83218343e-02f, 3.21503170e-02f, -5.57090994e-03f, 3.66027886e-03f,
  -2.05489635e-01f, -1.04246259e-01f, -1.48690954e-01f, -2.66999435e-02f, -5.95011227e-02f, -4.03280817e-02f, -7.71397352e-02f, -1.96038242e-02f, -4.44786437e-03f, 3.65398228e-02f,
  -1.14237899e-02f, 3.71663980e-02f, -4.39936668e-02f, -4.00704369e-02f, 4.92705740e-02f, -5.60784265e-02f, -1.01178233e-02f, -1.35474056e-01f, -1.39021724e-01f, 3.53491902e-02f,
  1.15360104e-01f, -8.13559145e-02f, -2.32259125e-01f, -6.66434467e-02f, -3.30695733e-02f, -3.45636457e-02f, -1.81544349e-01f, -8.42829123e-02f, -1.84495017e-01f, -2.33386293e-01f,
  2.95054000e-02f, -6.14289306e-02f, 1.78803969e-02f, -4.11364809e-03f, 1.04532419e-02f, -7.39175901e-02f, 3.64775695e-02f, 7.05556422e-02f, 9.96388029e-03f, 2.00004485e-02f,
  -1.05147678e-02f, 4.51304652e-02f, 3.30801830e-02f, 5.08423932e-02f, 9.32194963e-02f, 1.33819878e-02f, -2.06300505e-02f, 1.60163254e-01f, 7.49233142e-02f, 4.70293127e-02f,
  1.02900425e-02f, -4.08840999e-02f, -6.92898631e-02f, 8.54371041e-02f, 7.14316731e-03f, 1.06597103e-01f, 4.86637913e-02f, 1.10923827e-01f, 6.26112968e-02f, 3.99031006e-02f,
  -1.61993653e-01f, -5.96780814e-02f, -2.69197732e-01f, -7.38238618e-02f, -7.10695237e-02f, -8.17127675e-02f, -1.12367220e-01f, -1.72104895e-01f, -8.59744623e-02f, -1.10047676e-01f,
  -3.75939496e-02f, -5.94978854e-02f, -1.92189291e-01f, 3.52447643e-03f, -9.68866274e-02f, -1.09606311e-01f, -1.27588138e-01f, -9.46864635e-02f, -8.45390037e-02f, -7.29149106e-05f,
  -1.34540588e-01f, -1.92973524e-01f, -3.90443861e-01f, -2.60024518e-01f, -2.62676358e-01f, -2.76864201e-01f, -1.77595764e-01f, -2.88019538e-01f, -4.14492667e-01f, -4.51392204e-01f,
  -1.54891849e-01f, 2.34637052e-01f, 1.10523731e-01f, -9.64301452e-03f, -5.71993738e-02f, -1.02848209e-01f, 1.28924757e-01f, 7.12096840e-02f, -4.08586673e-03f, 6.32438436e-02f,
  2.29064468e-02f, -8.33279416e-02f, -2.70929523e-02f, 3.27263474e-02f, -3.95225808e-02f, 2.37025216e-01f, 2.24763468e-01f, 3.56466770e-02f, -2.61855453e-01f, -2.02946007e-01f,
  7.57774338e-02f, -7.51448721e-02f, 2.68505029e-02f, 8.27024207e-02f, 1.18773468e-01f, -1.75719231e-01f, 1.24999769e-01f, 4.49819863e-02f, -4.09011729e-02f, 2.39513442e-01f,
  -2.77066529e-01f, 5.18372878e-02f, -2.85953563e-02f, 4.93047573e-03f, 5.49964458e-02f, 1.27736345e-01f, 1.42530158e-01f, 1.63347781e-01f, 9.31186080e-02f, 1.61876291e-01f,
  1.93749387e-02f, 9.54127163e-02f, 3.41059901e-02f, 5.68259656e-02f, -8.32046010e-03f, -8.46925527e-02f, 1.20751627e-01f, 8.60763565e-02f, 3.19785587e-02f, 7.51638040e-02f,
  1.95538357e-01f, 3.91862467e-02f, -2.01457758e-02f, 1.35038108e-01f, 5.77380471e-02f, 4.09414060e-02f, 2.26319116e-03f, 5.87653965e-02f, 5.83047140e-03f, 9.56600718e-03f,
  -1.16154537e-01f, 4.78630401e-02f, -1.78358052e-02f, 8.10849294e-02f, -8.34392607e-02f, -1.02335019e-02f, -1.32864207e-01f, -3.24029699e-02f, -3.17655387e-03f, -1.05938777e-01f,
  -5.78177311e-02f, -6.40532821e-02f, -1.00470861e-04f, -2.30058208e-02f, 1.97241902e-02f, 2.14596931e-02f, -4.86229733e-02f, -4.46794257e-02f, -5.43996543e-02f, 3.65184471e-02f,
  -8.84617418e-02f, -1.94295734e-01f, -4.90386039e-02f, -1.11522451e-01f, -2.49903277e-02f, 5.79671189e-03f, -4.51900177e-02f, 4.87618856e-02f, -1.24731451e-01f, -8.33069459e-02f,
  -1.40627086e-01f, 1.53611273e-01f, 5.94762154e-02f, 9.26791038e-03f, -6.45477772e-02f, 2.38044187e-02f, 7.08094090e-02f, 2.58438196e-02f, 1.02843158e-01f, 4.61905636e-02f,
  2.30920669e-02f, 3.96899618e-02f, 5.44926012e-03f, 6.82565495e-02f, 5.21688163e-02f, 5.89758232e-02f, 1.12009749e-01f, -2.64628958e-02f, 7.95428678e-02f, 7.55411834e-02f,
  5.03672063e-02f, -4.96143959e-02f, -1.76531509e-01f, 1.92030594e-02f, -6.05814904e-02f, -9.73080248e-02f, -1.00436009e-01f, -1.02375396e-01f, -1.79094613e-01f, -8.64855945e-02f,
  5.04360676e-01f, 1.18410781e-01f, -2.01306686e-01f, -3.02813742e-02f, -6.71959221e-02f, 2.80978322e-01f, 2.10041702e-01f, 1.86499044e-01f, 4.48893495e-02f, 3.35700251e-02f,
  -1.28470480e-01f, -1.09273463e-01f, -1.23125121e-01f, -1.75493598e-01f, 1.00516602e-02f, -1.02054276e-01f, -6.52107298e-02f, 2.84451321e-02f, 1.02111928e-01f, 9.86766517e-02f,
  -1.15553148e-01f, -3.18439584e-03f, -2.41518929e-03f, 9.75813940e-02f, -1.07432947e-01f, 7.36284405e-02f, -4.50804606e-02f, 5.44376671e-02f, 1.56911034e-02f, -2.89289504e-01f,
  -1.02478258e-01f, 1.04406342e-01f, -6.70038760e-02f, -9.41747278e-02f, -2.43798532e-02f, -4.48645167e-02f, 1.64519567e-02f, -1.47063777e-01f, -1.05052873e-01f, 6.89998455e-03f,
  -6.77297488e-02f, -7.45463371e-02f, -1.13671355e-01f, -8.90500247e-02f, -1.81275308e-02f, -4.90048006e-02f, 1.38837062e-02f, -1.03604741e-01f, -1.45493060e-01f, -7.81800821e-02f,
  -1.50189444e-01f, -2.24795323e-02f, -5.16097003e-04f, 2.83223484e-02f, -2.97047105e-02f, 6.87218225e-03f, 2.00469401e-02f, -2.73547098e-02f, 5.72343394e-02f, 1.48949707e-02f,
  1.24195039e-01f, 8.32291469e-02f, 6.03364920e-03f, 2.92491969e-02f, 9.72712040e-02f, 2.64156125e-02f, -5.70616573e-02f, 9.78907794e-02f, 1.14006676e-01f, 7.74994195e-02f,
  1.13194473e-02f, -2.73137018e-02f, -2.53436938e-02f, 3.04710828e-02f, 3.50859836e-02f, 2.71110367e-02f, 2.25617122e-02f, -4.20963727e-02f, 5.41091990e-03f, 8.06376263e-02f,
  -1.28923785e-02f, -3.75011042e-02f, 5.24697527e-02f, -2.36459486e-02f, 6.47173729e-03f, -7.15141445e-02f, 2.50062589e-02f, 8.55004787e-02f, 8.37536901e-02f, 3.20171043e-02f,
  4.08055121e-03f, -1.63463265e-01f, -9.87966880e-02f, -1.04728058e-01f, -2.25804048e-03f, -4.91537794e-04f, -4.22549956e-02f, -6.93550110e-02f, -7.06729218e-02f, 1.19566426e-01f,
  5.56493513e-02f, 2.06965189e-02f, -9.55327600e-02f, -1.76593307e-02f, 1.90718714e-02f, -2.21847538e-02f, 7.40675703e-02f, 2.30250899e-02f, -1.16212927e-01f, 2.57753916e-02f,
  -4.76585887e-02f, 1.30763426e-01f, 1.67742610e-01f, 3.48815247e-02f, -4.43154015e-02f, 1.04393661e-01f, 1.14411987e-01f, 7.65661476e-03f, 8.47768486e-02f, 1.82654291e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.11436927e-01f, -1.99512601e-01f, -7.14036301e-02f, 5.76549768e-03f, -1.86625961e-02f, -2.08101407e-01f, -7.09379494e-01f, -4.74412948e-01f, -1.29855469e-01f, -1.85641587e-01f,
  -1.02416128e-01f, 2.05587983e-01f, 4.32781056e-02f, 1.66220233e-01f, -5.04609123e-02f, -2.50045776e-01f, 4.11075391e-02f, 3.04901659e-01f, 1.98360384e-02f, 1.38866246e-01f,
  1.65583581e-01f, 2.89154470e-01f, 2.54142165e-01f, 1.49366528e-01f, 2.62241244e-01f, 1.73045069e-01f, 9.24794301e-02f, 1.95318192e-01f, 1.60662591e-01f, 3.33024710e-01f,
  3.07135843e-02f, -1.04151711e-01f, -9.47849676e-02f, 7.64423311e-02f, 1.33288234e-01f, -5.17859124e-04f, 6.06126934e-02f, -8.17679465e-02f, 9.59360134e-03f, 4.15653810e-02f,
  1.21309534e-01f, 1.66629300e-01f, -1.58317849e-01f, -5.93673997e-03f, -1.39502548e-02f, 4.44499254e-02f, 3.99786234e-02f, 7.59573281e-02f, -7.09353834e-02f, -1.49622396e-01f,
  4.12732624e-02f, 1.11876592e-01f, -5.99087551e-02f, -3.68864030e-01f, -2.22781315e-01f, 1.99095562e-01f, -1.41411513e-01f, 4.28141393e-02f, -1.51925921e-01f, 9.18415375e-03f,
  1.24583043e-01f, 1.20671324e-01f, 1.52686372e-01f, 5.52781187e-02f, 1.09547906e-01f, 8.56337324e-02f, 6.25895038e-02f, -1.79252177e-02f, 7.93537125e-02f, -8.67567733e-02f,
  5.58422087e-03f, 1.13046698e-01f, 2.61568017e-02f, -4.23327424e-02f, 1.30652785e-01f, 8.66292790e-03f, 1.18806660e-01f, 2.52910834e-02f, -1.28852297e-02f, 1.00395881e-01f,
  1.25964388e-01f, -8.35816786e-02f, 1.59255773e-01f, 1.70406364e-02f, -1.07809968e-01f, 7.80124068e-02f, 1.29775986e-01f, -2.11850107e-02f, -3.46283540e-02f, 1.25987336e-01f,
  -2.64204144e-01f, -1.00817300e-01f, 1.61086142e-01f, 2.89229620e-02f, 2.24990100e-01f, 2.14736126e-02f, 8.89531747e-02f, -1.40902470e-03f, 6.72939345e-02f, -9.00252312e-02f,
  -1.94712088e-01f, -4.67059165e-02f, -1.35585457e-01f, -9.85057652e-02f, -1.87105183e-02f, -1.14128143e-01f, 1.01137422e-01f, -1.28533905e-02f, -4.31422666e-02f, 5.44180954e-03f,
  -2.43735537e-01f, -1.99218288e-01f, -2.70702809e-01f, -2.62191296e-01f, 8.30097124e-02f, 3.93144712e-02f, 3.76733243e-02f, 9.24440753e-03f, -1.71269596e-01f, -2.91144460e-01f,
  2.15760350e-01f, -9.02978778e-02f, 6.39757156e-01f, 3.40912789e-02f, -3.42764825e-01f, -2.11607859e-01f, -1.55790448e-01f, -1.14982001e-01f, -1.95895150e-01f, -5.38188703e-02f,
  -1.74559355e-01f, -4.51835215e-01f, -5.26622906e-02f, -3.36928330e-02f, 8.06934386e-02f, 2.02517793e-01f, 2.06882775e-01f, 2.33063087e-01f, 3.84804271e-02f, -2.52383173e-01f,
  -3.25222343e-01f, 2.00769529e-01f, 2.28052974e-01f, 1.73538506e-01f, 1.13153838e-01f, -1.98524997e-01f, 2.36771286e-01f, 2.07117945e-01f, -1.29878923e-01f, 1.68620441e-02f,
  2.14306101e-01f, 2.89140612e-01f, -5.06914854e-02f, -1.31194875e-01f, 3.94015536e-02f, -4.35731327e-03f, -6.93033263e-02f, 1.81767911e-01f, -9.23718810e-02f, 1.31018609e-01f,
  -1.22693395e-02f, -6.51906654e-02f, -4.23375629e-02f, -1.21965028e-01f, -1.62524745e-01f, -2.04045057e-01f, 1.89185992e-01f, 3.20137590e-01f, 1.39687985e-01f, -1.05564162e-01f,
  -2.15115935e-01f, -1.71734363e-01f, 6.06219843e-02f, -1.48302078e-01f, 1.24242432e-01f, -2.31253356e-01f, 2.02216916e-02f, 4.71524447e-02f, 1.15208559e-01f, -4.01000679e-02f,
  -1.40114799e-01f, 2.69832998e-03f, 8.60126540e-02f, 8.20521787e-02f, -1.77351013e-02f, -6.78108260e-02f, 1.46163702e-01f, -2.27383934e-02f, -6.15382344e-02f, 2.32653879e-02f,
  4.02951315e-02f, -1.81812383e-02f, -2.92044189e-02f, 1.15767002e-01f, -1.54466659e-01f, -5.70782050e-02f, -7.84166604e-02f, 8.61788020e-02f, -2.56375270e-03f, -1.03312165e-01f,
  -2.19331272e-02f, 9.73189101e-02f, -5.85227311e-02f, 7.43723735e-02f, 5.18227108e-02f, -1.01724695e-02f, -2.60867383e-02f, -7.74331540e-02f, 8.10108781e-02f, -2.10860791e-03f,
  -1.39587522e-01f, -9.03249457e-02f, -6.45446703e-02f, 3.35676298e-02f, 6.70659915e-02f, -9.82652158e-02f, 6.70305546e-03f, -1.76804468e-01f, -1.68122754e-01f, -5.98647594e-02f,
  -5.79117909e-02f, -4.55015935e-02f, 7.09354654e-02f, -6.03357628e-02f, -1.27359852e-01f, -3.04939374e-02f, -2.47375712e-01f, -1.33180529e-01f, -1.50445774e-01f, -1.75171837e-01f,
  -1.01114482e-01f, -1.98224157e-01f, -1.56489104e-01f, -7.20208138e-02f, -1.73594549e-01f, -3.07316244e-01f, -1.60439715e-01f, -1.42801166e-01f, -1.65586025e-01f, -1.23806074e-01f,
  7.51427948e-01f, -5.19056261e-01f, -2.29924187e-01f, 4.30728048e-01f, -5.71166212e-03f, 5.75246178e-02f, -9.03707594e-02f, -6.66030450e-03f, 2.34328210e-01f, -1.58685803e-01f,
  -3.58043760e-01f, -1.26115412e-01f, -6.44240230e-02f, -1.86110273e-01f, 1.27211243e-01f, -6.25929758e-02f, -2.61942334e-02f, 2.45496668e-02f, 7.10417256e-02f, -8.60808343e-02f,
  -1.82083488e-01f, 1.61878794e-01f, 2.14008793e-01f, 1.08030356e-01f, -1.36638835e-01f, -8.46937820e-02f, -7.05510452e-02f, -4.75320593e-02f, -2.98834145e-01f, -2.53701091e-01f,
  -1.11531787e-01f, 1.58555254e-01f, -8.01288784e-02f, -3.66077758e-02f, -5.64259589e-02f, 8.27137232e-02f, 1.15792323e-02f, -1.41551662e-02f, -6.97304085e-02f, -3.16110365e-02f,
  -1.11671418e-01f, -7.80803859e-02f, -6.88659772e-02f, 1.24297719e-02f, 1.85663514e-02f, 1.15920171e-01f, 4.16358113e-02f, -8.78719538e-02f, -9.89930332e-02f, -1.94225721e-02f,
  -1.30195245e-01f, -1.00109145e-01f, -4.08355221e-02f, 5.68503980e-03f, -1.85107198e-02f, -8.94845463e-03f, -6.28133714e-02f, -3.19445394e-02f, -1.71077862e-01f, -2.80880392e-01f,
  -8.30844417e-02f, -4.43413295e-03f, 4.58822073e-03f, -1.11426607e-01f, -4.76809219e-02f, -1.09607175e-01f, -1.06168255e-01f, 1.16284648e-02f, 9.33245718e-02f, 4.66378108e-02f,
  -9.67489108e-02f, 1.45826072e-01f, -1.52282953e-01f, 6.93371892e-02f, 5.24386950e-02f, -9.58129466e-02f, 1.02343038e-01f, -2.64034159e-02f, 2.54379995e-02f, 4.14108075e-02f,
  -2.96874507e-03f, -6.51652291e-02f, -7.94857666e-02f, 3.38673242e-03f, 5.71203642e-02f, 9.00287740e-03f, 1.01759754e-01f, -2.78057735e-02f, -4.61550951e-02f, 2.01020129e-02f,
  6.36849478e-02f, 1.20606773e-01f, 8.55378509e-02f, -1.44649640e-01f, 5.55254668e-02f, -1.34788975e-01f, -8.31678361e-02f, -1.03312105e-01f, 7.00197518e-02f, 6.49528876e-02f,
  -1.88247033e-03f, -1.78477485e-02f, -6.17698580e-02f, -8.16026852e-02f, 9.71900113e-03f, 1.43355310e-01f, -5.06716408e-02f, -7.38257319e-02f, 2.32390836e-02f, -8.35831761e-02f,
  -3.91273573e-02f, 1.68200627e-01f, 1.84610054e-01f, 2.44279485e-02f, -1.62743293e-02f, 1.62789941e-01f, -4.53905249e-03f, 1.24669686e-01f, 4.40528765e-02f, 1.15294538e-01f,
  -5.29809415e-01f, -4.56411764e-02f, -1.42875701e-01f, -1.36864215e-01f, 2.67282903e-01f, 3.19025405e-02f, -1.94053262e-01f, -2.03205749e-01f, 3.40417102e-02f, 2.13150885e-02f,
  9.37248990e-02f, 1.43767774e-01f, 4.47406732e-02f, 1.66784272e-01f, -1.50174975e-01f, 1.40761152e-01f, 1.49746224e-01f, 8.58069807e-02f, -2.15091497e-01f, -1.42143726e-01f,
  2.49576837e-01f, -1.94596332e-02f, -1.75844073e-01f, -2.60883749e-01f, -5.13582267e-02f, -1.64411012e-02f, -6.67424053e-02f, 1.17008515e-01f, 2.17343003e-01f, 2.96594262e-01f,
  9.09405202e-02f, -2.68535525e-01f, 3.94873284e-02f, 2.55088136e-02f, -7.39829093e-02f, -1.78347856e-01f, -1.41314045e-01f, -4.68416139e-02f, 9.26571190e-02f, -3.56453168e-03f,
  -8.87884945e-03f, 7.68335611e-02f, 1.32131949e-01f, -1.15070991e-01f, -1.42968222e-01f, -8.80160853e-02f, -1.85549051e-01f, -2.88801104e-01f, -2.20986933e-01f, -2.37432681e-03f,
  2.03633383e-01f, 2.36805335e-01f, -9.86770093e-02f, -1.89008191e-01f, -1.99987307e-01f, -4.19297908e-03f, -1.32047027e-01f, -2.77381837e-01f, -3.66121650e-01f, -2.12923929e-01f,
  1.08808130e-02f, 3.65761518e-02f, -3.20577398e-02f, -8.08510929e-02f, 2.14646552e-02f, 5.92602082e-02f, 1.29141212e-01f, 7.34607652e-02f, 7.22241327e-02f, -8.11287314e-02f,
  1.29095063e-01f, -6.82031363e-02f, 3.10618598e-02f, -3.60421613e-02f, 4.01612557e-02f, -5.50186709e-02f, -7.88530633e-02f, -9.62234288e-02f, 1.04261087e-02f, 5.29598296e-02f,
  -3.12799141e-02f, -2.72437986e-02f, 1.16047457e-01f, -1.03836276e-01f, -3.04522947e-03f, -8.86000842e-02f, 3.81998010e-02f, -1.26482278e-01f, -1.49233863e-01f, 2.36897022e-02f,
  -1.24989651e-01f, 1.56673491e-01f, -4.08303291e-02f, -1.28119528e-01f, 7.97247291e-02f, 1.98472273e-02f, 3.77000356e-03f, -4.56338786e-02f, 1.42729497e-02f, -1.03891283e-01f,
  -4.35251817e-02f, -2.36431956e-01f, 1.75024364e-02f, -7.31962100e-02f, -4.62563373e-02f, -1.31385103e-01f, -1.19829562e-03f, -6.27046302e-02f, 8.63946527e-02f, -6.74895495e-02f,
  -6.72033206e-02f, -1.28144771e-01f, -3.09793241e-02f, -1.22095034e-01f, -1.21389180e-01f, -2.61834323e-01f, -1.20427601e-01f, -2.45156229e-01f, -2.52904713e-01f, -3.17780674e-01f,
  -7.41134107e-01f, 3.50286104e-02f, 4.99261767e-01f, -3.12062919e-01f, 4.21712138e-02f, -1.83458239e-01f, -2.28304982e-01f, -1.26344562e-01f, -1.50513992e-01f, -8.70407149e-02f,
  -6.64338544e-02f, -1.79923803e-01f, 1.16962492e-01f, 1.37921676e-01f, -8.05078819e-02f, -1.02963798e-01f, -1.69100910e-02f, 8.99337884e-03f, 1.28402725e-01f, -4.19760168e-01f,
  -3.43920499e-01f, -2.18544111e-01f, -8.69188905e-02f, 9.68413576e-02f, -4.74411637e-01f, -2.53377948e-02f, 1.62429914e-01f, -1.12698145e-01f, 6.37382045e-02f, -5.09093761e-01f,
  1.13580659e-01f, -6.20165691e-02f, -7.08497390e-02f, -3.04003149e-01f, 4.17762324e-02f, -1.25086801e-02f, 8.40741098e-02f, 4.43987213e-02f, 7.30320662e-02f, 1.33428583e-02f,
  -1.41173035e-01f, 5.97934611e-02f, -1.12524070e-01f, -1.71697542e-01f, -2.14043334e-02f, -1.59013718e-01f, -5.92789724e-02f, -4.94541079e-02f, -3.68309952e-02f, 1.62642092e-01f,
  -2.15552822e-01f, -2.86068559e-01f, -9.28423628e-02f, 1.02433763e-01f, 1.00190103e-01f, 2.73360908e-01f, 2.01218635e-01f, 9.71802250e-02f, 1.32115945e-01f, -1.98463708e-01f,
  -1.07122153e-01f, -3.00216172e-02f, 7.76897520e-02f, -6.81379586e-02f, -1.49683431e-01f, -8.44951943e-02f, -1.17044888e-01f, -1.14047818e-01f, -3.41278650e-02f, -9.93120447e-02f,
  6.30909503e-02f, -3.29119712e-03f, 7.90740699e-02f, 7.05155656e-02f, -2.30488144e-02f, -2.44841054e-02f, 1.95557252e-01f, 2.76257731e-02f, -3.30348685e-02f, -5.67065589e-02f,
  -1.21504940e-01f, 9.29974765e-03f, -3.32247950e-02f, -5.39384745e-02f, -2.57633865e-01f, -1.96059211e-03f, 8.58654529e-02f, -8.53521228e-02f, -1.15741543e-01f, -1.60194132e-02f,
  9.26887840e-02f, 7.46211559e-02f, -2.49237880e-01f, 8.36571604e-02f, 1.38604939e-02f, 8.48924220e-02f, -8.09699520e-02f, 2.71114763e-02f, -1.31933419e-02f, -1.19079821e-01f,
  -1.13029644e-01f, 5.07381512e-03f, -4.15229686e-02f, 4.40810882e-02f, 7.69781042e-03f, -1.00083336e-01f, -1.95755452e-01f, -2.61071861e-01f, -3.33469920e-02f, -1.65832236e-01f,
  -6.18527979e-02f, -7.85599947e-02f, -3.52501005e-01f, -6.55229390e-03f, -1.43723667e-01f, 2.39551719e-02f, 1.98035687e-01f, 2.25383341e-01f, 5.26420809e-02f, -2.08250940e-01f,
  6.76520884e-01f, 4.00089771e-01f, -1.54706478e-01f, 3.73410136e-01f, -4.99083281e-01f, -3.69154930e-01f, -3.51666152e-01f, -2.25726441e-01f, 8.21358785e-02f, 1.63568854e-01f,
  -4.36818786e-02f, -1.02018863e-01f, 1.37261614e-01f, -2.49205679e-01f, -2.17817381e-01f, 1.19229360e-02f, 1.26559094e-01f, -4.57629524e-02f, -4.80446756e-01f, -3.37459236e-01f,
  2.00639635e-01f, 2.10471720e-01f, 2.06652313e-01f, 9.42572802e-02f, 2.14980394e-01f, -5.96610904e-02f, 4.91986573e-02f, 1.24787008e-02f, -8.79377872e-02f, 2.73339927e-01f,
  1.15974024e-01f, 3.48270118e-01f, -3.69385481e-01f, 7.07988441e-03f, -8.92406702e-02f, 1.05825678e-01f, 3.67542468e-02f, -7.26439953e-02f, -9.26548764e-02f, 2.05056384e-01f,
  -1.30711854e-01f, -9.98872966e-02f, -9.22987461e-02f, 5.19967042e-02f, 2.64716670e-02f, -1.35508001e-01f, 1.07956089e-01f, -1.92224849e-02f, -1.87371876e-02f, 5.06708287e-02f,
  9.81843621e-02f, -5.26892133e-02f, -2.46072620e-01f, -1.11476719e-01f, -7.61344731e-02f, -7.32743591e-02f, -1.14488546e-02f, -3.63970548e-02f, -2.67720014e-01f, 1.13688104e-01f,
  7.84830004e-02f, -1.34234279e-01f, -7.79378489e-02f, 3.44271064e-02f, 1.93330571e-02f, -2.43727844e-02f, -9.06767547e-02f, -1.97092909e-03f, 2.02260520e-02f, -1.51691968e-02f,
  -8.28112811e-02f, 1.38782009e-01f, 2.49170922e-02f, 1.39550999e-01f, 2.10926179e-02f, 9.40737501e-03f, -1.35164142e-01f, 1.14315487e-01f, 2.01630175e-01f, 1.49844989e-01f,
  1.73618440e-02f, -1.53564602e-01f, -2.78615486e-02f, 1.01349847e-02f, 1.10982470e-01f, -5.38579300e-02f, 1.27992570e-01f, -6.91064596e-02f, -9.68576875e-03f, -1.54287359e-02f,
  1.96847171e-01f, -3.58948648e-01f, 3.66167538e-02f, -2.92886514e-02f, 1.39109436e-02f, 2.11802311e-02f, 1.03512444e-01f, 5.16336337e-02f, -5.60198389e-02f, -2.62867846e-02f,
  -1.46351218e-01f, -1.45387039e-01f, 6.67998716e-02f, -2.62493435e-02f, -4.25878540e-02f, -9.57316011e-02f, 1.40542939e-01f, -2.15147838e-01f, 1.42838154e-02f, 1.84361815e-01f,
  1.26479194e-01f, 5.96526749e-02f, 1.75088700e-02f, 6.50006905e-02f, -6.15220796e-03f, -3.72165330e-02f, -1.38250977e-01f, -1.32428467e-01f, -2.57312864e-01f, 2.30137199e-01f,
  2.50754118e-01f, 1.48386165e-01f, -4.02063996e-01f, 2.35492259e-01f, -2.90088654e-01f, -2.09380537e-01f, -2.46977098e-02f, 2.36428499e-01f, 4.35360610e-01f, 4.08044457e-01f,
  5.78448363e-02f, -3.43275905e-01f, -8.90536457e-02f, -2.01588884e-01f, -3.50602895e-01f, 7.42023438e-02f, 7.13004246e-02f, -4.46599364e-01f, -8.10765207e-01f, -4.52008307e-01f,
  -2.57696062e-01f, -3.34515482e-01f, -3.03430706e-01f, -1.34087071e-01f, -3.87762338e-02f, -4.17793661e-01f, 7.31256604e-02f, -1.67331383e-01f, -3.01856369e-01f, -1.26879975e-01f,
  -1.75173685e-01f, -5.47015443e-02f, -2.05928937e-01f, -3.16915333e-01f, -3.34924944e-02f, 7.63032064e-02f, -4.88718785e-02f, -6.35948554e-02f, -3.52973379e-02f, 3.92642058e-02f,
  -5.76485209e-02f, 1.36476323e-01f, -2.80712284e-02f, -2.08431125e-01f, -6.80874959e-02f, -1.34128958e-01f, 8.70914608e-02f, -1.21676646e-01f, -6.61516190e-02f, 3.01350877e-02f,
  7.73310065e-02f, -2.44584188e-01f, -2.01351836e-01f, -5.35022542e-02f, 1.30431890e-01f, -2.88539946e-01f, -8.51379186e-02f, -5.74664026e-02f, -1.47729889e-01f, -2.23273281e-02f,
  6.31611496e-02f, 7.47663155e-02f, -6.08474538e-02f, 1.28884548e-02f, -4.82178815e-02f, 4.09369394e-02f, 2.90377736e-02f, -6.64058998e-02f, 2.15006564e-02f, -4.30436321e-02f,
  1.66395620e-01f, 2.21277662e-02f, 7.32279196e-02f, 1.48324534e-01f, -7.09853266e-05f, -1.40772194e-01f, 1.48698697e-02f, 8.41434821e-02f, -1.36441007e-01f, 5.29253408e-02f,
  -9.33174193e-02f, -1.96126122e-02f, -2.96691079e-02f, -4.20140140e-02f, -9.99922827e-02f, 3.33601125e-02f, -3.85763892e-03f, 4.61748652e-02f, 9.09011811e-02f, 7.18197599e-02f,
  7.49285892e-02f, -2.01512709e-01f, 9.22935605e-02f, -1.29135177e-01f, -1.12897798e-01f, -8.39095712e-02f, 4.95521650e-02f, 9.09954309e-02f, 1.96647923e-02f, -9.94805396e-02f,
  -9.51179862e-02f, 1.90574631e-01f, -1.29100487e-01f, -4.94062975e-02f, -6.62833154e-02f, -5.22536933e-02f, 1.18667640e-01f, -2.05606788e-01f, -7.76573718e-02f, 3.72436494e-02f,
  8.62569064e-02f, -1.02657497e-01f, -1.27823293e-01f, 3.87089439e-02f, -1.28946856e-01f, -1.30103603e-01f, -2.81460971e-01f, -4.01668772e-02f, -2.50246674e-01f, 1.73474848e-01f,
  -3.72897349e-02f, 9.64904204e-02f, -4.38700885e-01f, 5.71350306e-02f, -1.82059869e-01f, -2.10413903e-01f, -1.72029451e-01f, -1.26399398e-01f, 4.00087088e-02f, 1.77859664e-02f,
  1.72446460e-01f, 1.95013449e-01f, 1.15484282e-01f, -1.16230212e-02f, -1.54866785e-01f, -4.02680397e-01f, -5.07657468e-01f, -4.69978243e-01f, -3.05739671e-01f, 3.28009725e-02f,
  -5.48817776e-02f, -2.28713036e-01f, -2.11536735e-01f, -3.61509621e-02f, 2.82180849e-02f, -1.11658268e-01f, -2.03720167e-01f, -2.17832893e-01f, -8.43182802e-02f, -1.80991471e-01f,
  -1.45241514e-01f, -3.87054794e-02f, -2.54113656e-02f, 1.16667233e-01f, 1.08970217e-01f, -7.77092054e-02f, -7.76910111e-02f, 1.06078237e-01f, 6.25798628e-02f, 1.74169183e-01f,
  3.26038658e-04f, 8.41360465e-02f, 7.94410706e-02f, -6.28673588e-04f, -1.68216601e-02f, 4.16540913e-02f, 2.07367420e-01f, -2.39395667e-02f, 6.62108092e-03f, 6.40553683e-02f,
  -5.47293276e-02f, 3.38232219e-02f, 1.11228630e-01f, 1.19402394e-01f, 8.06962401e-02f, -8.68271887e-02f, 7.05050305e-02f, 2.35741050e-03f, -1.44216279e-02f, 1.25868425e-01f,
  -5.47533631e-02f, 1.93130970e-01f, 2.16944307e-01f, 6.44159168e-02f, 7.31411502e-02f, 1.93600610e-01f, 8.96215141e-02f, 1.51484817e-01f, 2.77784504e-02f, 1.57676443e-01f,
  2.29338706e-01f, -1.36190623e-01f, -1.49764150e-01f, -1.49424732e-01f, 6.37305528e-02f, 1.62975401e-01f, -1.29599860e-02f, 1.15597345e-01f, 3.18836197e-02f, 1.06455863e-01f,
  5.93355708e-02f, 1.08024187e-01f, -2.75769904e-02f, 9.80202928e-02f, 6.46624342e-02f, -1.57402121e-02f, -5.84585108e-02f, -1.19845703e-01f, -1.02944955e-01f, -1.27565354e-01f,
  2.30588883e-01f, -2.74698466e-01f, 7.14861155e-02f, 1.37265502e-02f, 2.10409355e-03f, 5.29711954e-02f, 1.09431418e-02f, -2.87948456e-02f, -7.05829710e-02f, -8.63689706e-02f,
  9.63085815e-02f, -3.40726599e-02f, -5.59926666e-02f, 7.88700581e-02f, 3.83137725e-02f, -1.53819710e-01f, 1.11169077e-01f, 7.37961084e-02f, 9.86961797e-02f, 1.99064016e-01f,
  9.76980552e-02f, 6.63812682e-02f, 2.32467622e-01f, 1.97780848e-01f, 2.37296671e-02f, -1.36010990e-01f, 5.59029542e-02f, -6.49274513e-02f, -4.06037048e-02f, -6.86182678e-02f,
  5.02481282e-01f, -2.39265189e-01f, 3.52203757e-01f, 8.54547620e-02f, 2.18625471e-01f, 1.95761979e-01f, 2.36527249e-01f, 1.67296454e-01f, -6.07086271e-02f, 6.24833889e-02f,
  3.96560691e-02f, -1.89953655e-01f, -5.80809303e-02f, -4.61453833e-02f, -2.78542638e-02f, 8.42598150e-04f, 8.51444900e-03f, 3.54622081e-02f, 1.28817707e-01f, 1.65595621e-01f,
  -2.59251386e-01f, 6.30500540e-02f, 1.46100163e-01f, -1.67894724e-03f, -7.84618407e-02f, 1.14091262e-01f, 2.47139245e-01f, 1.06926747e-01f, 1.90383598e-01f, 8.39341655e-02f,
  1.04955211e-01f, -7.61430571e-03f, -7.78325945e-02f, -1.55813143e-01f, -8.12895522e-02f, -7.80362785e-02f, -3.23588327e-02f, 2.60924008e-02f, 6.09024651e-02f, -5.04121697e-03f,
  -1.23422906e-01f, -9.01417732e-02f, -8.96828324e-02f, 1.92216113e-02f, 3.90018001e-02f, -5.38895391e-02f, -1.65594555e-02f, -2.06129104e-02f, 8.06372836e-02f, -7.20150247e-02f,
  -7.95957744e-02f, 1.12381272e-01f, 1.66327894e-01f, 1.28657535e-01f, 1.32974237e-01f, -5.33850715e-02f, 1.48858756e-01f, 9.75239053e-02f, 1.59760848e-01f, 1.16802417e-01f,
  4.34504971e-02f, 7.10522979e-02f, 7.63266673e-03f, 1.13391332e-01f, 9.06702317e-03f, 6.82121739e-02f, -4.68695946e-02f, 6.87030256e-02f, 1.74750552e-01f, -4.00912091e-02f,
  -1.20180726e-01f, 1.77394137e-01f, 1.67662472e-01f, -6.06275015e-02f, -1.12285003e-01f, 3.76844928e-02f, -4.98588243e-03f, -1.17041714e-01f, 6.72528371e-02f, 8.17362890e-02f,
  5.08941300e-02f, 4.03481685e-02f, -8.27891529e-02f, -1.56456262e-01f, -1.09238952e-01f, -2.08604503e-02f, -3.00446302e-02f, -3.75367776e-02f, -1.33176550e-01f, -9.83716920e-02f,
  -1.55308381e-01f, 1.25983045e-01f, -1.34434268e-01f, 4.23015468e-02f, -4.20450903e-02f, -2.52344072e-01f, 1.02545843e-01f, 1.42453136e-02f, -2.65997481e-02f, -3.30981836e-02f,
  5.51322475e-03f, 6.29569544e-03f, -4.99686375e-02f, -6.91568758e-03f, 5.82344048e-02f, 4.06413488e-02f, -1.50712758e-01f, 6.72321650e-04f, 5.27031571e-02f, -7.57599175e-02f,
  -1.24978378e-01f, 1.59071222e-01f, 2.53362983e-01f, 2.17499435e-02f, 8.39683339e-02f, 9.58586335e-02f, 8.24014023e-02f, 9.39594284e-02f, 1.44419134e-01f, 1.13427237e-01f,
  -2.54239082e-01f, 7.15883732e-01f, 2.10116103e-01f, -3.21227968e-01f, 1.67316109e-01f, 3.87407422e-01f, 7.50098646e-01f, 2.70867050e-01f, -1.68784380e-01f, 2.40857512e-01f,
  2.58145243e-01f, -3.44727576e-01f, -2.13009909e-01f, -1.84087664e-01f, -3.25548067e-03f, 1.30827725e-01f, 7.18219206e-02f, -2.60347188e-01f, -3.66872340e-01f, -1.73310339e-01f,
  -1.12150580e-01f, -2.79973835e-01f, -1.84508026e-01f, -2.78628349e-01f, -1.87356204e-01f, -3.03873241e-01f, 1.02763802e-01f, 2.56212447e-02f, 1.80520326e-01f, -3.43561828e-01f,
  7.66150281e-02f, 4.36400622e-01f, -3.72798324e-01f, -1.41064882e-01f, 1.16550185e-01f, -6.34780824e-02f, -5.87162971e-02f, -7.82629624e-02f, 3.36604118e-02f, -9.51102525e-02f,
  -4.73646596e-02f, 6.37629256e-02f, 3.29340734e-02f, -4.14850004e-02f, 6.65729344e-02f, -5.89580499e-02f, 8.16580653e-02f, -4.30884510e-02f, 2.10671164e-02f, 6.90997839e-02f,
  5.13734408e-02f, 1.51519507e-01f, 2.73032784e-01f, 1.56606194e-02f, 1.34671748e-01f, -5.89906834e-02f, 2.19358996e-01f, -7.40242824e-02f, 4.42599989e-02f, -2.28232369e-01f,
  1.48472292e-02f, -3.69159617e-02f, 2.74640508e-02f, -1.00047715e-01f, 1.24271559e-02f, 4.84175282e-03f, -1.18098654e-01f, -4.19339770e-03f, 3.78121645e-03f, 3.98314616e-04f,
  3.54231074e-02f, 7.19617233e-02f, -2.08349209e-02f, 9.38183591e-02f, 3.31807956e-02f, 4.64132801e-02f, 4.74980883e-02f, 3.81282717e-02f, -2.61844750e-02f, 7.96445012e-02f,
  4.69337553e-02f, 9.78589430e-02f, 4.87162098e-02f, -1.64724350e-01f, 2.31312975e-01f, -5.80379739e-02f, 1.94150396e-02f, 6.05738573e-02f, 1.45536996e-02f, 8.99174586e-02f,
  -3.56512845e-01f, 1.57869831e-01f, -2.99691498e-01f, 2.24084202e-02f, 5.86708635e-02f, -8.06916356e-02f, -5.29781207e-02f, -1.12476550e-01f, 2.39040256e-02f, 4.11336347e-02f,
  -5.28899506e-02f, -8.19530431e-03f, 7.00157210e-02f, -5.44278696e-02f, -1.96787715e-01f, -1.40972491e-02f, 8.54071751e-02f, -5.72729111e-02f, 3.10903415e-03f, 2.89633330e-02f,
  1.58062726e-02f, -5.31705059e-02f, -3.19253951e-02f, -5.99117018e-02f, 1.02934249e-01f, -2.44462535e-01f, -2.35199034e-02f, -5.98202161e-02f, -8.64147022e-02f, -1.76072583e-01f,
  1.55853843e-02f, -1.28542423e-01f, -3.91487777e-01f, -2.82188684e-01f, -2.60512084e-01f, -7.59880394e-02f, 6.99535236e-02f, 1.54619887e-01f, 1.54697783e-02f, -2.36284032e-01f,
  4.37055267e-02f, 3.79358143e-01f, 1.65128574e-01f, 3.09797615e-01f, 3.01397443e-01f, -1.05211519e-01f, -4.24837738e-01f, -1.01674125e-01f, 3.27104390e-01f, 2.53589422e-01f,
  3.96658890e-02f, -6.68902099e-02f, -2.41390779e-03f, -1.23966148e-03f, -2.94584244e-01f, -4.33256887e-02f, -5.05415440e-01f, -3.95439446e-01f, -2.32955396e-01f, -5.81780791e-01f,
  -2.93614388e-01f, 2.40747277e-02f, -1.49124414e-01f, 4.96917292e-02f, -1.94228500e-01f, 1.12032123e-01f, 1.87339664e-01f, -1.15177676e-01f, 9.38735157e-03f, -9.26359594e-02f,
  1.43419057e-02f, 6.02084100e-02f, -1.15909725e-01f, 3.32405567e-02f, -1.22337401e-01f, 7.51283243e-02f, -2.15373076e-02f, -9.11088884e-02f, -1.09023690e-01f, -2.26501152e-02f,
  -1.18031092e-01f, 7.29454756e-02f, -1.26613840e-01f, -1.47744030e-01f, 3.02237477e-02f, -1.57859132e-01f, -1.56710550e-01f, 1.17643904e-02f, -1.23057120e-01f, -2.97035545e-01f,
  -1.64131466e-02f, -7.02024475e-02f, -4.23515067e-02f, -1.25318347e-02f, 5.42529039e-02f, 1.35520548e-02f, -7.85021707e-02f, -1.49849504e-01f, 6.69184849e-02f, -1.72374467e-03f,
  4.03237995e-03f, -8.07198416e-03f, 6.26142770e-02f, -9.84815508e-02f, -5.84323592e-02f, 2.57587172e-02f, 1.68196503e-02f, -4.19429541e-02f, -8.62156078e-02f, -5.47297485e-02f,
  5.72974011e-02f, 9.11327600e-02f, -1.34514779e-01f, 1.33488700e-01f, 1.07300170e-01f, -1.11662328e-01f, -1.00201041e-01f, 7.74212629e-02f, 3.87702771e-02f, 1.38179272e-01f,
  -3.74445245e-02f, -1.78893153e-02f, -1.59838632e-01f, 5.25336675e-02f, 1.15766972e-02f, -2.22527608e-02f, 2.38586254e-02f, -2.62900852e-02f, -4.64187153e-02f, 6.66674152e-02f,
  1.33279175e-01f, 1.49588376e-01f, -5.11266254e-02f, 6.81768134e-02f, 2.62647811e-02f, 6.32477254e-02f, -4.10071723e-02f, -5.33767343e-02f, -1.67849734e-02f, 1.86304953e-02f,
  -1.75129086e-01f, 6.98653162e-02f, 9.56954807e-02f, 4.76097409e-03f, 7.08855316e-02f, 1.26370694e-02f, 2.54621226e-02f, 8.90011489e-02f, 1.90866128e-01f, 3.60941663e-02f,
  8.24768662e-01f, -1.66294396e-01f, -5.31201661e-01f, 1.74170807e-01f, -3.06757450e-01f, -4.85863686e-02f, -1.44678146e-01f, 3.87588665e-02f, 1.55667782e-01f, -1.58217266e-01f,
  -1.70908123e-01f, -7.60890916e-02f, 1.02821644e-02f, -9.50094536e-02f, -3.67055200e-02f, -1.67567343e-01f, -2.82374114e-01f, -3.23757753e-02f, -9.65350680e-03f, -2.76338658e-03f,
  1.03000738e-01f, 1.23475395e-01f, 1.44553497e-01f, 2.17815228e-02f, -2.15400890e-01f, -3.72996032e-02f, -2.87601411e-01f, -1.17571205e-01f, -3.06837052e-01f, -3.63321811e-01f,
  -5.18639266e-01f, -9.26107615e-02f, -5.76980338e-02f, 1.19716950e-01f, 3.67427953e-02f, 1.12262532e-01f, 2.29346026e-02f, 1.44254211e-02f, 1.73053190e-01f, -4.79653627e-02f,
  3.72269973e-02f, -1.56670585e-02f, 9.77275819e-02f, -6.52086735e-02f, -3.75198424e-02f, 1.50950104e-02f, 3.68918739e-02f, -3.55426371e-02f, -9.77539364e-03f, -4.41864133e-02f,
  5.17314486e-02f, -1.39914937e-02f, -1.03042975e-01f, -1.03185829e-02f, -2.13355094e-01f, -8.08310583e-02f, -1.76592350e-01f, -2.40113407e-01f, -2.21361220e-01f, -8.39940086e-02f,
  -7.00396523e-02f, 3.93469147e-02f, -9.89909098e-02f, 1.08679190e-01f, 9.88134295e-02f, 1.08397834e-01f, 5.99020347e-02f, -5.68889268e-03f, -8.92894063e-03f, 5.32430746e-02f,
  -9.05488059e-02f, -4.86332253e-02f, -4.64451537e-02f, 3.01194414e-02f, -1.26269370e-01f, 3.69231291e-02f, 1.63703077e-02f, 9.13266242e-02f, 2.89856065e-02f, 1.78560078e-01f,
  1.50376171e-01f, 7.41799697e-02f, -2.12090407e-02f, 3.45789976e-02f, -5.46473823e-02f, -1.03823707e-01f, -5.36066033e-02f, 2.28177793e-02f, 1.99086759e-02f, 1.86445396e-02f,
  2.98294544e-01f, 2.46480131e-03f, 3.39003727e-02f, -2.64158137e-02f, 3.76914144e-02f, 2.68095359e-02f, -1.58973634e-01f, -5.10373600e-02f, 3.69843319e-02f, -3.68830934e-02f,
  -8.85812566e-02f, -7.93845728e-02f, -3.97644751e-02f, 6.55370904e-03f, -7.87955225e-02f, -1.35840997e-01f, 2.28264313e-02f, 9.82206389e-02f, -8.72031972e-02f, -4.26953994e-02f,
  7.33706579e-02f, 1.23170838e-01f, 2.43085250e-01f, 1.51922241e-01f, 4.55810921e-03f, 1.10837340e-01f, 4.75818776e-02f, 1.92769412e-02f, 1.97692499e-01f, 2.56577194e-01f,
  8.92955065e-02f, -1.61190346e-01f, 1.36243880e-01f, 1.19551346e-01f, 1.78804234e-01f, 3.50851595e-01f, 5.88148534e-01f, 2.39747226e-01f, 8.40364024e-02f, 2.89709736e-02f,
  -3.24371129e-01f, -4.21420306e-01f, -2.55684286e-01f, -4.12785739e-01f, -9.47559401e-02f, 1.02966830e-01f, 2.14402929e-01f, 1.92537233e-01f, 1.24570340e-01f, 6.10664450e-02f,
  -2.87099858e-03f, 2.18578354e-01f, 5.65930307e-02f, 1.12156235e-01f, 1.37988508e-01f, -6.47667348e-02f, 1.48681059e-01f, 9.53687280e-02f, -4.32665050e-02f, -2.62909532e-02f,
  -3.88840824e-01f, -4.97487485e-02f, 4.82995324e-02f, -1.10221915e-01f, -1.59580886e-01f, -7.28368759e-02f, -3.56633216e-02f, -1.30275652e-01f, -1.57350123e-01f, 7.90559035e-03f,
  -1.62651092e-01f, -3.28822210e-02f, 1.06155239e-01f, 1.54326046e-02f, 6.32557794e-02f, -1.46997888e-02f, -4.83922213e-02f, -1.67342916e-01f, -1.70071870e-01f, -1.27872095e-01f,
  -1.64537713e-01f, -1.80106133e-01f, 2.82305777e-02f, 4.84259613e-02f, -1.71105176e-01f, -1.26154721e-01f, -2.59977300e-02f, -1.23488354e-02f, 5.01526445e-02f, -1.37548581e-01f,
  4.35561426e-02f, -7.97812827e-04f, -5.97601533e-02f, 1.76781937e-02f, -3.34095508e-02f, 7.62418434e-02f, 1.86738476e-01f, -1.38707636e-02f, 3.79499123e-02f, 1.80580691e-02f,
  -1.11940630e-01f, -8.44306797e-02f, -5.01827374e-02f, -2.57405527e-02f, 9.16792825e-02f, 3.59451175e-02f, 2.67295521e-02f, -8.58477503e-02f, -2.01545328e-01f, 1.18903808e-01f,
  4.73251827e-02f, 1.14004411e-01f, 6.93428963e-02f, -2.14657634e-02f, -1.82369813e-01f, -4.54027280e-02f, 8.08976591e-02f, 2.92875394e-02f, -1.19915485e-01f, 1.71841785e-01f,
  -3.25120264e-03f, -2.03136906e-01f, -6.83262199e-02f, -7.98266828e-02f, -5.46291918e-02f, -9.37969536e-02f, -8.64025857e-03f, -9.64163989e-02f, -9.36524123e-02f, -4.28229645e-02f,
  1.11677006e-01f, -4.45438959e-02f, -7.49264359e-02f, 5.62805198e-02f, 1.16832428e-01f, 3.32159991e-03f, -2.55178839e-01f, 7.68734738e-02f, 9.36005451e-03f, -1.26568392e-01f,
  3.70006151e-02f, 1.76460028e-01f, 1.28323138e-01f, 2.20219586e-02f, -1.18282601e-01f, 1.43255815e-01f, 6.71374947e-02f, 1.24019943e-01f, 1.38009667e-01f, 1.51300341e-01f,
  -2.39759922e-01f, -4.04584855e-02f, -3.11394095e-01f, -5.06535411e-01f, -1.58476204e-01f, 7.16172680e-02f, -2.27086432e-02f, -1.26029216e-02f, -3.74572217e-01f, -4.10927981e-01f,
  -1.83924377e-01f, 1.33931130e-01f, 6.99419994e-03f, 2.20525920e-01f, 1.60409406e-01f, -3.55539739e-01f, -4.03471678e-01f, 6.24446683e-02f, 3.72734815e-01f, 3.72543097e-01f,
  1.17610633e-01f, 3.85448746e-02f, -4.18851115e-02f, 1.28698394e-01f, -1.55224055e-01f, 2.60152332e-02f, -2.62659162e-01f, -1.52347535e-01f, 1.96296170e-01f, -2.09685445e-01f,
  -1.02573179e-01f, -1.30435660e-01f, -1.18319593e-01f, -7.93947279e-02f, -1.76583901e-01f, 1.90616585e-02f, -1.84998233e-02f, -2.17170715e-01f, -5.36380224e-02f, -1.24120645e-01f,
  -8.72255191e-02f, -6.50777221e-02f, -2.50823461e-02f, 2.15350017e-01f, 4.47870642e-02f, -3.26345116e-02f, -2.69104056e-02f, 6.82282820e-02f, -3.46241333e-02f, -5.04496992e-02f,
  1.02834739e-01f, -6.68053553e-02f, -7.75763839e-02f, 1.15023144e-01f, -8.89624096e-03f, 6.33987924e-03f, -5.29532507e-02f, 3.67397852e-02f, -3.90262641e-02f, -8.02566186e-02f,
  1.81517713e-02f, -3.43158692e-02f, -2.05503888e-02f, 5.94264418e-02f, -2.19031617e-01f, -1.38702467e-01f, 5.03632091e-02f, -3.81620266e-02f, 6.12206683e-02f, 4.53866906e-02f,
  -6.00293651e-02f, -2.94019785e-02f, 8.27156380e-02f, -3.64779234e-02f, -1.69089481e-01f, -7.63379037e-02f, -3.09262834e-02f, -2.74264887e-02f, 9.19351801e-02f, -7.23418742e-02f,
  -1.10548846e-01f, 3.26173194e-02f, -2.37760413e-02f, -5.45275286e-02f, -1.55670986e-01f, -3.75818200e-02f, -1.12974423e-03f, 6.09371290e-02f, 2.81913802e-02f, -6.23493940e-02f,
  3.39381173e-02f, 9.09313336e-02f, -1.38171032e-01f, 3.13241221e-02f, -7.56532103e-02f, -1.53481573e-01f, -1.55945376e-01f, -9.74627510e-02f, -1.72177535e-02f, -5.81241697e-02f,
  -3.48571241e-02f, -3.82025577e-02f, -1.78911313e-02f, 2.00803712e-01f, 3.33625562e-02f, -5.78765906e-02f, -1.30975455e-01f, 2.33145826e-03f, -1.65749565e-02f, -1.18135899e-01f,
  -1.44033030e-01f, -1.30370772e-02f, 1.99348815e-02f, 2.65433472e-02f, -4.72349711e-02f, 3.85780223e-02f, -6.31328225e-02f, 6.60685822e-02f, 1.69637296e-02f, -1.36331292e-02f,
  -2.98045218e-01f, 1.61224380e-01f, 1.19662002e-01f, 2.65330851e-01f, -2.90385578e-02f, -2.41096169e-01f, -2.26171583e-01f, -1.43591315e-01f, -1.35572240e-01f, 1.13423150e-02f,
  -9.84776393e-02f, -5.09142727e-02f, 8.25850740e-02f, 9.66585204e-02f, 5.54443859e-02f, 1.46786451e-01f, 2.39828959e-01f, 3.28263640e-01f, 1.16099594e-02f, -1.22081667e-01f,
  -6.85945451e-02f, 1.47358343e-01f, 6.41711280e-02f, 8.84204954e-02f, 1.06037490e-01f, 7.06688613e-02f, 1.04413122e-01f, 4.97177877e-02f, -1.71598569e-02f, 3.94673944e-01f,
  2.79137850e-01f, 1.19407997e-01f, -2.68726330e-02f, 1.10119075e-01f, 7.55828321e-02f, 2.02527661e-02f, -1.44693777e-01f, 1.52805120e-01f, -1.29982783e-02f, -9.25389677e-02f,
  7.90587813e-02f, 3.91855016e-02f, 5.76477870e-02f, -1.75635666e-02f, 3.80492546e-02f, -1.99170485e-02f, -5.41007146e-02f, -5.08030225e-03f, 1.40976444e-01f, 3.39351743e-02f,
  9.63231847e-02f, -4.56167981e-02f, -4.78668734e-02f, -1.08213365e-01f, -2.90246438e-02f, 6.41264394e-02f, -4.07782681e-02f, -7.99070746e-02f, -3.04208957e-02f, -1.90809831e-01f,
  -5.12020104e-03f, 4.07641008e-02f, 5.75505495e-02f, -6.16046637e-02f, -1.13926582e-01f, -1.54707104e-01f, -1.17055967e-01f, -7.11722896e-02f, -7.37345740e-02f, -1.91619489e-02f,
  -1.24687284e-01f, 4.05919477e-02f, -4.47000526e-02f, 1.72276925e-02f, 2.74586435e-02f, 8.64122808e-02f, 1.03346203e-02f, 3.06667946e-02f, 1.79444894e-01f, 1.51270121e-01f,
  6.63320497e-02f, 7.37952860e-03f, 3.72238420e-02f, -1.14972666e-02f, 9.54811797e-02f, 1.22761149e-02f, -2.02374868e-02f, 9.33207124e-02f, -1.15483269e-01f, 8.15538876e-03f,
  4.95043844e-01f, 1.74126312e-01f, -4.95380685e-02f, 1.21144414e-01f, 1.62920654e-01f, 1.48573980e-01f, 8.90641510e-02f, 2.49608271e-02f, 3.03252429e-01f, -3.30378264e-02f,
  1.23293046e-02f, 3.64437103e-02f, 4.97487560e-02f, -1.95420403e-02f, -1.55719861e-01f, -3.27096432e-02f, -2.80121923e-03f, 6.21789247e-02f, 1.99166045e-01f, 1.58917576e-01f,
  1.01864107e-01f, -8.85916427e-02f, -1.34855390e-01f, -1.52583629e-01f, -2.39157200e-01f, -1.22295186e-01f, -7.82230869e-02f, 3.33014019e-02f, 2.94477530e-02f, -3.36101323e-01f,
  -6.44225001e-01f, -7.90488091e-04f, -1.93987876e-01f, -6.57383323e-01f, -1.36615634e-01f, 1.24514535e-01f, 2.60349065e-01f, 6.34028465e-02f, -2.49993548e-01f, -2.32966483e-01f,
  9.37776826e-03f, -1.50052011e-01f, -1.10754229e-01f, 6.66225255e-02f, 4.45559248e-02f, -2.79211670e-01f, -3.88264865e-01f, -3.44668001e-01f, 1.81790441e-01f, 2.24979326e-01f,
  -1.09221518e-01f, -4.00781065e-01f, -3.60454679e-01f, -7.32860789e-02f, -2.42837459e-01f, 7.24739134e-02f, -2.40279317e-01f, -1.34051174e-01f, 1.42239600e-01f, -1.84958518e-01f,
  1.15314037e-01f, 7.86941424e-02f, 1.30609363e-01f, 5.84069788e-02f, -3.23875323e-02f, -1.25810346e-02f, 8.48874971e-02f, 4.26773913e-02f, 2.72544939e-02f, -3.92040573e-02f,
  -1.17137209e-01f, -3.03477626e-02f, 2.78677489e-03f, 9.24609378e-02f, -4.49034981e-02f, 1.72732603e-02f, 1.33948922e-01f, -4.84666154e-02f, 5.08361682e-02f, 1.16948895e-01f,
  1.52071714e-01f, 8.08151066e-02f, 6.34226725e-02f, 2.95427591e-01f, 1.04366422e-01f, 2.38672774e-02f, 2.32589006e-01f, 2.37024575e-01f, 2.26103887e-01f, 2.59430736e-01f,
  -5.58796898e-02f, -2.75364127e-02f, 3.57785150e-02f, 5.47022112e-02f, 4.09246869e-02f, 7.75561258e-02f, -2.61616515e-04f, -5.90814240e-02f, -1.58674251e-02f, 4.20854148e-03f,
  -4.83655371e-02f, -2.52079666e-02f, -5.22682210e-03f, -7.81947300e-02f, 1.03932962e-01f, 7.29514584e-02f, -1.11482218e-01f, 1.12973228e-01f, 1.22362794e-02f, 6.09765314e-02f,
  2.90944055e-02f, 9.53531861e-02f, -5.44060655e-02f, -2.30671931e-03f, 1.36224553e-01f, -1.26691163e-01f, 5.91691621e-02f, 2.49035712e-02f, -3.61516848e-02f, -1.18975982e-01f,
  -8.72963145e-02f, 1.28465086e-01f, -2.40526721e-02f, -1.87819004e-02f, -4.67188396e-02f, -7.24886209e-02f, -9.14640874e-02f, -4.42951024e-02f, -1.72184095e-01f, -3.01083047e-02f,
  3.75043191e-02f, -6.05043992e-02f, -6.15781657e-02f, 1.16022535e-01f, -2.39306949e-02f, 4.20787670e-02f, 1.26499131e-01f, -1.19895197e-01f, 5.69963008e-02f, -3.12782042e-02f,
  -3.14408205e-02f, 6.16289452e-02f, 6.40737116e-02f, 7.14014843e-02f, -3.90394852e-02f, -5.46593964e-02f, -1.82835255e-02f, 4.00969051e-02f, 3.21251824e-02f, 3.63576747e-02f,
  6.89373195e-01f, 6.72778934e-02f, 1.60087213e-01f, 3.10314178e-01f, 1.55793294e-01f, 3.97932865e-02f, 3.93571332e-02f, 4.17641960e-02f, 1.77257210e-01f, 2.38031238e-01f,
  2.38865346e-01f, 1.58403382e-01f, 1.82138488e-01f, 5.10303937e-02f, 8.41027573e-02f, -8.17332193e-02f, -1.23077862e-01f, 1.15086310e-01f, 1.24928094e-01f, 2.25922972e-01f,
  3.74013595e-02f, -9.62475166e-02f, 1.53390253e-02f, -9.11997110e-02f, -7.18848929e-02f, 3.16594355e-02f, 1.11295395e-02f, -2.27769241e-01f, -1.54762819e-01f, -1.37020856e-01f,
  2.24875122e-01f, 1.32510245e-01f, 3.62290978e-01f, -8.73309001e-02f, -1.53376043e-01f, 9.86439660e-02f, 1.64586052e-01f, 1.12449609e-01f, 8.01858772e-03f, -2.27184873e-02f,
  -2.00806484e-01f, -9.83009338e-02f, -1.33570760e-01f, 2.20599808e-02f, 5.22145862e-03f, 6.86435103e-02f, 5.75572625e-02f, 5.34011126e-02f, 1.49894252e-01f, 1.16477795e-01f,
  -1.03230864e-01f, -8.58077258e-02f, -1.80935021e-02f, -1.80809200e-02f, 4.62435931e-03f, -5.82434982e-02f, 2.71546375e-02f, -1.67849943e-01f, -6.96650147e-02f, 6.52881339e-02f,
  2.00922534e-01f, -4.09231856e-02f, -1.52087989e-04f, 1.22762494e-01f, 8.03804696e-02f, 4.70427871e-02f, 4.31055389e-02f, -4.34054732e-02f, -2.41451012e-03f, -6.35490939e-02f,
  -1.12658944e-02f, 7.55536407e-02f, 9.16436315e-03f, 1.21355280e-01f, 3.91011089e-02f, -7.73341879e-02f, -6.17916100e-02f, -1.47347733e-01f, -1.41922653e-01f, 4.11025435e-02f,
  -8.05101693e-02f, -1.37350738e-01f, -1.23175792e-01f, -1.93930715e-01f, -2.00871527e-02f, -7.66257495e-02f, -2.07528636e-01f, -1.71482906e-01f, -1.49615124e-01f, 7.96782598e-02f,
  2.70788763e-02f, 1.10939205e-01f, 2.62187839e-01f, -1.25780672e-01f, -1.47580072e-01f, -1.20583668e-01f, 5.28825372e-02f, 1.61851477e-02f, 1.70158502e-02f, 5.63586988e-02f,
  -5.44649400e-02f, -1.54425889e-01f, -8.34512338e-02f, 1.19740586e-03f, 1.49430588e-01f, -2.06037448e-03f, 4.36442010e-02f, 2.26390406e-01f, 1.10424096e-02f, -5.61950766e-02f,
  -1.05151981e-01f, 1.37743473e-01f, 6.41876906e-02f, 2.15489879e-01f, 1.01639610e-02f, 2.49611393e-01f, 5.15405498e-02f, 1.88039858e-02f, 5.46645597e-02f, 6.22665472e-02f,
  3.01660776e-01f, 5.29841244e-01f, -2.86719445e-02f, 2.81435877e-01f, 3.13266397e-01f, 3.20121050e-01f, 4.03368086e-01f, 1.31465137e-01f, -1.23290969e-02f, 1.18809067e-01f,
  1.13969013e-01f, 1.00690588e-01f, 5.61280549e-02f, 5.30776419e-02f, 1.90301076e-01f, 1.10978238e-01f, 9.64865237e-02f, -7.55860060e-02f, -1.55262217e-01f, 2.51978878e-02f,
  2.19403148e-01f, 1.04249269e-01f, -8.09870735e-02f, 1.35167509e-01f, 1.56136274e-01f, 5.82512021e-02f, -5.51435631e-03f, 1.54981479e-01f, 1.45761371e-01f, 2.20203787e-01f,
  -1.28279433e-01f, 3.64817888e-01f, -2.41240531e-01f, -1.38610289e-01f, -1.24962136e-01f, -1.73940480e-01f, -7.92313218e-02f, -7.09336400e-02f, 1.99260470e-02f, 3.14377174e-02f,
  -7.07491860e-02f, -5.94283193e-02f, 2.04943299e-01f, -4.09365855e-02f, 1.02780787e-02f, -6.56400397e-02f, -1.44737571e-01f, -2.65153237e-02f, 7.24680945e-02f, -8.70797932e-02f,
  2.30567127e-01f, 1.03728354e-01f, -4.38114330e-02f, 1.03626795e-01f, 1.21832006e-01f, -2.02492829e-02f, 4.82653454e-02f, 1.81610882e-02f, -1.30643845e-01f, -4.05733027e-02f,
  3.15252319e-02f, 1.84244402e-02f, 1.01691008e-01f, 4.65763211e-02f, 1.38700157e-01f, -8.07718560e-02f, -9.32018608e-02f, 1.92535352e-02f, 9.41049531e-02f, -2.70984992e-02f,
  -8.18142593e-02f, -8.58234540e-02f, -8.91172811e-02f, -1.08869970e-01f, -4.98667434e-02f, -1.28822878e-01f, -6.41415194e-02f, -1.08887725e-01f, 3.48921679e-02f, -9.78275090e-02f,
  1.52430981e-01f, -1.74065545e-01f, -1.14888266e-01f, 9.85998809e-02f, -1.16910078e-01f, -6.84965476e-02f, 9.39933211e-03f, 9.43823755e-02f, -2.49309000e-02f, 1.50960386e-02f,
  -2.36318082e-01f, 1.86156914e-01f, -5.48011996e-02f, 2.57498901e-02f, -4.12820838e-03f, -1.38150752e-01f, 1.73896700e-01f, -6.88070804e-02f, 1.78302191e-02f, 2.60133278e-02f,
  -2.71073021e-02f, -7.33404011e-02f, 7.69822448e-02f, -5.55302761e-02f, -1.41568422e-01f, 7.12570315e-03f, -9.22223255e-02f, -4.46743965e-02f, -1.54338200e-02f, -1.31344140e-01f,
  -6.12262376e-02f, -2.67744541e-01f, -4.21800733e-01f, -1.02498747e-01f, 6.57796636e-02f, -1.33703902e-01f, -2.37560153e-01f, -1.99898601e-01f, -2.48541310e-01f, -2.56720662e-01f,
  9.69887674e-02f, 1.94350220e-02f, 1.65025041e-01f, -1.66028053e-01f, -3.74462157e-02f, 9.62324366e-02f, 6.41595349e-02f, 1.06444694e-02f, -1.09194599e-01f, -2.39134319e-02f,
  1.60781458e-01f, 3.22897702e-01f, 1.78265333e-01f, 2.67227232e-01f, 1.70303419e-01f, -2.51638405e-02f, -2.35855937e-01f, 1.45223692e-01f, 2.58876920e-01f, 1.43833816e-01f,
  -6.51212335e-02f, -1.33133098e-01f, -1.36181310e-01f, -1.48459747e-01f, -1.20992504e-01f, 1.64102361e-01f, -2.09748209e-01f, -1.62774861e-01f, -1.55260697e-01f, -3.85426790e-01f,
  5.61874747e-01f, -9.77224931e-02f, 5.95383458e-02f, -3.63448448e-02f, -6.85864389e-02f, -8.86650681e-02f, 7.52149448e-02f, -1.59870386e-01f, -2.07826182e-01f, -1.81771904e-01f,
  -1.70532614e-01f, -1.57111213e-01f, 1.16398446e-02f, -1.46159753e-01f, -9.58593339e-02f, -1.83398306e-01f, -4.13696878e-02f, 2.70665735e-02f, 3.71267423e-02f, -5.14874309e-02f,
  -1.67518184e-01f, -1.20768227e-01f, 4.40176316e-02f, -4.37083542e-02f, 5.11607267e-02f, 1.81073211e-02f, -3.29557471e-02f, -8.10488835e-02f, 2.27098614e-02f, -1.87794432e-01f,
  1.24217294e-01f, -8.88242386e-03f, 4.48356867e-02f, 1.35490641e-01f, 1.67662352e-01f, 2.13009994e-02f, -9.23971683e-02f, -5.51722851e-03f, -3.67252193e-02f, 1.17409885e-01f,
  7.75126275e-03f, 1.67261526e-01f, -4.49529439e-02f, -1.18842296e-01f, 5.68960141e-03f, -1.47836916e-02f, -2.32657064e-02f, -5.78872710e-02f, 5.77018037e-02f, 1.05334625e-01f,
  1.64307073e-01f, -4.26417068e-02f, 2.15693302e-02f, 6.99325576e-02f, -4.04790491e-02f, 1.18761174e-02f, -7.52015337e-02f, -5.54796383e-02f, -2.35785246e-01f, -9.91715267e-02f,
  2.41684973e-01f, 1.13088556e-01f, 2.07112268e-01f, -4.43620197e-02f, -7.29979575e-02f, -1.02896489e-01f, 4.63525727e-02f, 7.59246573e-02f, -1.10945530e-01f, 5.75886443e-02f,
  3.45064886e-03f, -1.82562564e-02f, -2.16113478e-02f, -1.30497068e-01f, 1.05613008e-01f, 4.45881946e-04f, -5.61595755e-03f, 1.35606956e-02f, 1.04373515e-01f, 1.00814506e-01f,
  -8.68875235e-02f, -4.87524867e-02f, 1.54211774e-01f, 1.03019550e-01f, 9.15234759e-02f, 1.20262802e-01f, 1.36724964e-01f, 1.14078611e-01f, 1.60994306e-01f, -2.39776056e-02f,
  8.68471146e-01f, -6.32169023e-02f, 5.31043857e-02f, 2.48296648e-01f, 1.87940925e-01f, 2.76216924e-01f, 5.43353744e-02f, 2.36035123e-01f, 5.28079681e-02f, 1.62486538e-01f,
  3.30986649e-01f, 1.35264456e-01f, 9.32986662e-02f, 2.75917817e-03f, 4.08469178e-02f, -1.48792177e-01f, -2.98746139e-01f, -1.96425971e-02f, 5.07576354e-02f, 8.26999024e-02f,
  -5.25390506e-02f, -1.33065740e-02f, 1.21113449e-01f, 7.77415112e-02f, -1.83885843e-01f, 9.25791562e-02f, -1.35493025e-01f, -1.48453653e-01f, 2.67665721e-02f, -3.27442199e-01f,
  -3.63317251e-01f, 3.14462990e-01f, 6.87400252e-02f, 9.55069438e-02f, 1.61151756e-02f, -8.56128484e-02f, 1.93078890e-02f, -7.20621198e-02f, -1.64395094e-01f, -1.50784478e-01f,
  -9.05740038e-02f, -7.22379908e-02f, -6.31219447e-02f, -8.39363858e-02f, -4.13827859e-02f, -2.09176783e-02f, -9.34097543e-03f, 1.26168087e-01f, 4.66481503e-03f, -1.10614344e-01f,
  -1.00190245e-01f, 3.40662226e-02f, 8.55677575e-02f, 9.21195280e-03f, 4.07042466e-02f, 4.23127301e-02f, 3.56113203e-02f, -4.49447669e-02f, 6.00850396e-02f, 8.42293501e-02f,
  3.84417884e-02f, -6.87817391e-03f, 1.55340835e-01f, 8.22231621e-02f, 7.75378346e-02f, 9.17021409e-02f, -2.37251446e-02f, -3.19254585e-02f, 2.33743563e-02f, -4.64039631e-02f,
  -3.65609936e-02f, 1.05884686e-01f, 4.55142967e-02f, 9.44616199e-02f, 1.38222516e-01f, -1.12020820e-01f, -1.28376186e-01f, -1.10117886e-02f, 1.50619775e-01f, 6.54513901e-03f,
  1.80889025e-01f, 1.74241082e-03f, 5.04218861e-02f, -5.59814833e-02f, 1.20037593e-01f, 9.58714709e-02f, -9.85667631e-02f, 3.65509763e-02f, -6.46332651e-03f, 4.73304950e-02f,
  -4.48271513e-01f, 4.51549590e-01f, 2.98793651e-02f, -6.31603077e-02f, -9.57079753e-02f, -1.40046244e-02f, 5.60023934e-02f, -5.46137989e-02f, -1.96648240e-01f, -1.70337975e-01f,
  -4.34633717e-02f, -9.68329087e-02f, 3.54415961e-02f, -1.07826263e-01f, -4.16815747e-03f, -7.47896032e-03f, -2.73194984e-02f, 3.80789489e-02f, -7.05238730e-02f, -1.14598691e-01f,
  -8.39243010e-02f, -7.52845183e-02f, 9.70065370e-02f, 6.59812018e-02f, -4.60772961e-03f, 3.82693438e-03f, -1.05640657e-01f, -5.65709211e-02f, 1.01283841e-01f, 4.84265462e-02f,
  3.06701630e-01f, -7.22289160e-02f, 2.64997572e-01f, 3.22092652e-01f, 2.69334912e-01f, 3.67379487e-01f, 4.45816368e-01f, 2.25007549e-01f, 6.53584749e-02f, -1.65371466e-02f,
  8.22388381e-02f, -1.26270652e-01f, -8.82900879e-02f, -8.05436894e-02f, -2.36037374e-02f, 1.33509755e-01f, 9.27264392e-02f, 1.01651354e-02f, 5.82133122e-02f, 1.86539531e-01f,
  -3.49401347e-02f, -1.31850895e-02f, 9.66478512e-02f, -1.58462562e-02f, -7.58683980e-02f, 1.31155357e-01f, 1.02632061e-01f, 7.54727200e-02f, -8.18758309e-02f, -1.56472743e-01f,
  -3.11180294e-01f, 1.49691790e-01f, 1.03770211e-01f, -1.63773537e-01f, -4.47040051e-02f, -1.49682030e-01f, -2.47980822e-02f, -4.80536744e-02f, -8.76762569e-02f, -1.06688641e-01f,
  -3.01334914e-02f, -1.51952449e-02f, -7.23871961e-03f, 9.97183844e-03f, 6.99719191e-02f, -8.27624276e-02f, 1.48000950e-02f, 7.26543963e-02f, 1.42662659e-01f, -6.69198707e-02f,
  -4.62765712e-03f, 1.51138425e-01f, 1.61736742e-01f, 1.25156194e-01f, 6.32775426e-02f, -3.75894606e-02f, 9.58973467e-02f, -4.13050912e-02f, 3.17993127e-02f, 1.03239939e-01f,
  1.09794706e-01f, 2.14381933e-01f, 1.38466597e-01f, 1.69415668e-01f, 3.52652259e-02f, 8.36381167e-02f, 6.82204068e-02f, 1.92022342e-02f, 2.31240869e-01f, 1.11169815e-01f,
  -5.67627028e-02f, 1.50860101e-01f, 2.86368310e-01f, 1.73260406e-01f, 1.36708200e-01f, 1.23890460e-01f, -2.98710987e-02f, 1.19689979e-01f, -6.99693942e-03f, 1.60349496e-02f,
  5.34509085e-02f, 9.02586877e-02f, -1.25711709e-01f, 1.10860683e-01f, 2.89636515e-02f, 8.02305713e-02f, -4.18566242e-02f, -4.90351161e-03f, -5.60603142e-02f, -1.05707832e-02f,
  -2.40594551e-01f, 1.91938192e-01f, -2.99959909e-02f, -1.86687484e-02f, -1.74343828e-02f, -1.35684684e-01f, 1.70977011e-01f, -2.56465394e-02f, -2.60965317e-01f, -1.03217781e-01f,
  -4.66504358e-02f, -2.05177572e-02f, -3.88265513e-02f, 1.07346632e-01f, 1.10553548e-01f, -1.06856890e-01f, -4.09410112e-02f, 7.14667812e-02f, -9.58645046e-02f, -1.14006937e-01f,
  7.56476223e-02f, 7.72356614e-02f, 1.18455097e-01f, 1.35421306e-01f, -8.53049681e-02f, 4.97166291e-02f, -5.11320382e-02f, -4.09630388e-02f, -9.27553745e-04f, 2.21320475e-03f,
  4.92441535e-01f, -6.67325631e-02f, -4.70514625e-01f, 3.97223264e-01f, -8.02615955e-02f, -2.98016816e-01f, -4.24417645e-01f, -1.41671047e-01f, 3.57468963e-01f, 1.00573897e-02f,
  1.19397141e-01f, 1.58581659e-01f, 1.27292294e-02f, -3.71516317e-01f, -4.61858898e-01f, -2.95325309e-01f, -2.73318291e-01f, -4.90728468e-01f, -6.22155368e-01f, -3.57108027e-01f,
  4.57131974e-02f, 1.07364267e-01f, 2.67559327e-02f, -7.52147138e-02f, 2.74814904e-01f, 4.94159199e-02f, 4.38324064e-02f, -5.14129363e-02f, -1.83867201e-01f, 2.28470787e-02f,
  -2.13853553e-01f, 2.19759624e-02f, -2.90363908e-01f, 1.83779560e-02f, 7.64582157e-02f, -1.14875428e-01f, -2.80947015e-02f, -1.39406219e-01f, -4.37271483e-02f, -6.35509342e-02f,
  4.50082943e-02f, -1.55802043e-02f, 6.93786368e-02f, -1.14878178e-01f, -5.46776839e-02f, -8.15060511e-02f, -4.70958836e-03f, -2.04432487e-01f, -1.06481567e-01f, -1.40085533e-01f,
  -1.11832894e-01f, -2.46524811e-01f, -8.26339647e-02f, -9.78069752e-02f, -1.58723310e-01f, -4.74540181e-02f, 4.74264026e-02f, 3.52683663e-02f, -9.55768749e-02f, 1.83017060e-01f,
  -8.48603025e-02f, 1.43354479e-03f, 5.20385690e-02f, 3.13079320e-02f, 3.82734723e-02f, 8.74400809e-02f, -9.48742256e-02f, 1.00299176e-02f, 3.92599627e-02f, 6.78045079e-02f,
  -2.03570891e-02f, -7.36370981e-02f, -1.29478127e-01f, -1.20223135e-01f, 5.66441342e-02f, 1.29641276e-02f, -3.39405276e-02f, 2.55274512e-02f, -1.58379361e-01f, -5.12086488e-02f,
  -5.58751747e-02f, 2.69915909e-02f, 1.78280234e-01f, -6.15837239e-02f, -1.15213737e-01f, -8.82131308e-02f, -5.89680262e-02f, -2.44320501e-02f, -1.26656676e-02f, 4.11137119e-02f,
  2.71001279e-01f, -1.84478968e-01f, 1.70396850e-01f, -1.08150132e-01f, 9.78354481e-04f, 1.49304926e-01f, 1.22029901e-01f, 1.80030018e-01f, 1.73868433e-01f, -4.31828387e-02f,
  -1.31828904e-01f, 8.46060440e-02f, -5.21834791e-02f, -1.18492506e-01f, -7.45066330e-02f, -1.49800833e-02f, -7.50279427e-02f, -1.97318010e-02f, -1.82039514e-01f, 1.13323852e-01f,
  6.53085411e-02f, -1.90983862e-01f, -5.44079766e-02f, 2.84517836e-02f, 3.83206718e-02f, 1.45436963e-02f, -3.79917468e-03f, 1.07570484e-01f, -2.01454073e-01f, 9.53897387e-02f,
  4.42932434e-02f, 1.55164450e-01f, -2.92717963e-01f, 8.04058369e-03f, 1.45497426e-01f, 2.16425527e-02f, -2.02711701e-01f, -2.92138487e-01f, -2.68551875e-02f, 1.34383723e-01f,
  2.63581157e-01f, 5.42351902e-01f, 3.16908300e-01f, 3.04304689e-01f, 1.04875965e-02f, -1.18156813e-01f, -2.37499401e-01f, -1.21602528e-01f, 1.05778821e-01f, 3.26235741e-01f,
  3.61050993e-01f, 9.44579244e-02f, 7.06492513e-02f, 5.78552894e-02f, 1.97893586e-02f, 3.02250326e-01f, -7.34485835e-02f, 8.41228515e-02f, 2.41728738e-01f, 1.60551667e-01f,
  4.30964768e-01f, -1.55529916e-01f, -1.46951973e-01f, -3.30382842e-04f, 4.34989221e-02f, -1.69505075e-01f, -3.76351140e-02f, -2.99362689e-01f, -1.12600811e-01f, -1.08701825e-01f,
  -3.02072708e-02f, -8.61149430e-02f, 3.05860192e-02f, 6.14826195e-02f, 7.21213920e-03f, -6.57287613e-02f, -3.37428719e-01f, -2.59537160e-01f, -2.19421849e-01f, -5.64574404e-03f,
  1.59252733e-01f, 1.34236559e-01f, -2.04869616e-03f, -1.27659068e-01f, -1.53758734e-01f, 3.98713984e-02f, -2.52490286e-02f, -9.29806158e-02f, -2.75405288e-01f, -1.29432797e-01f,
  -1.47149600e-02f, -1.23870056e-02f, 8.55329074e-03f, -4.17652689e-02f, -2.59823762e-02f, -9.74402130e-02f, 3.18383127e-02f, -1.81449093e-02f, -7.72605911e-02f, -7.32280165e-02f,
  5.18707372e-02f, 1.26744106e-01f, -3.72834355e-02f, 1.66703358e-01f, 6.68997392e-02f, -1.18627332e-01f, 8.53537172e-02f, 1.20280636e-02f, 2.46229209e-02f, -1.06393293e-01f,
  1.59743521e-02f, -3.59970443e-02f, -2.01372504e-02f, 9.32036638e-02f, 1.71371736e-02f, 1.09429508e-02f, 6.56316653e-02f, 1.10842660e-01f, 2.80305166e-02f, -1.61759928e-02f,
  2.06196740e-01f, -1.29922301e-01f, 8.31078738e-02f, -5.05611040e-02f, 1.13784277e-03f, -8.81440192e-02f, 8.89966171e-03f, -3.67441475e-02f, -1.04182594e-01f, -2.43080240e-02f,
  4.07528877e-02f, -3.25618428e-03f, -5.31213991e-02f, -1.63927868e-01f, 4.56723943e-02f, -8.62209201e-02f, -6.07987419e-02f, -1.26870917e-02f, -6.68785125e-02f, -1.46879748e-01f,
  -1.20854795e-01f, 1.43416924e-02f, 2.64781773e-01f, 3.96688692e-02f, 1.72052495e-02f, 1.68053716e-01f, -3.98251787e-03f, -8.04109499e-02f, 7.54070729e-02f, -3.85694094e-02f,
  -5.77859223e-01f, 2.34381795e-01f, -3.94819111e-01f, -4.88960743e-02f, 2.60487795e-01f, 2.93828905e-01f, 4.88015413e-01f, 1.05299152e-01f, 1.14357188e-01f, -6.80975243e-02f,
  -1.10604167e-01f, -1.28646523e-01f, 2.38773860e-02f, 7.93114584e-03f, 2.44005192e-02f, 2.89715022e-01f, 2.75107592e-01f, -1.11919567e-01f, -2.88431734e-01f, -8.47995579e-02f,
  2.37845361e-01f, -2.48792376e-02f, -3.72241884e-01f, -1.71922714e-01f, 1.75366506e-01f, -1.41040504e-01f, -7.76836872e-02f, -5.42962626e-02f, 1.70218777e-02f, 2.10899293e-01f,
  -3.49883825e-01f, -1.94208786e-01f, -2.39158481e-01f, -4.31458615e-02f, -3.40200305e-01f, -2.30156258e-01f, 1.13038737e-02f, -2.34851763e-01f, -7.31798112e-02f, -5.24207056e-02f,
  -5.57805933e-02f, -5.10829911e-02f, -1.73601266e-02f, 8.47771391e-03f, -2.45538384e-01f, -1.35149434e-01f, -1.72360495e-01f, -1.88093018e-02f, -5.96173666e-02f, -2.03772843e-01f,
  4.43398386e-01f, 1.93056494e-01f, -9.27761346e-02f, -2.02371217e-02f, -8.63065347e-02f, -1.10365510e-01f, -3.94759513e-02f, -6.21580845e-03f, -1.66611180e-01f, -2.34922096e-02f,
  -1.24532944e-02f, -8.02562758e-02f, -2.88719907e-02f, 3.36374417e-02f, 1.98197383e-02f, -6.48148507e-02f, -4.34946828e-02f, 1.96414322e-01f, 1.05483137e-01f, -2.43071700e-03f,
  -1.61755774e-02f, -1.32310346e-01f, 1.83255702e-01f, 2.37670001e-02f, -6.35510832e-02f, 4.80985940e-02f, 1.47168431e-02f, -7.51877427e-02f, -2.58994967e-01f, -7.71950483e-02f,
  -9.03395489e-02f, -7.99658671e-02f, -7.39247873e-02f, 4.58637513e-02f, 2.54286211e-02f, -1.31967202e-01f, -5.62006868e-02f, -1.73569396e-02f, 5.34630083e-02f, -1.41921714e-01f,
  -3.11881192e-02f, -2.28569627e-01f, -1.74887460e-02f, 2.21555382e-02f, 6.89728931e-02f, -8.06784481e-02f, 1.36710316e-01f, 5.11189625e-02f, 9.57053304e-02f, 5.80821969e-02f,
  3.29408282e-03f, -1.43523991e-01f, 7.40019530e-02f, 4.67966236e-02f, -2.01936886e-01f, 3.95783894e-02f, 1.56057253e-01f, 2.41623238e-01f, 3.88880111e-02f, 5.90770729e-02f,
  1.36590838e-01f, 2.22909033e-01f, -3.21640223e-02f, 9.88139510e-02f, 3.94074209e-02f, -1.30400866e-01f, 2.90464461e-02f, -1.74773693e-01f, -1.92012712e-01f, -5.87642007e-02f,
  -2.45987818e-01f, -2.45306224e-01f, 3.50181237e-02f, -2.91463584e-01f, 2.94963092e-01f, -5.44876084e-02f, -2.91134566e-01f, -1.85653329e-01f, 6.71715569e-03f, -1.51101395e-01f,
  4.91044670e-02f, 9.60415229e-03f, -2.83616126e-01f, -1.51351482e-01f, -4.82420862e-01f, -4.50367421e-01f, -2.42666259e-01f, -4.37651277e-02f, -5.85604385e-02f, 1.29759818e-01f,
  2.06909090e-01f, 1.37781307e-01f, -1.34555781e-02f, -6.38131145e-03f, -1.94101632e-01f, 2.48396024e-03f, -1.97487980e-01f, -1.63393363e-01f, 5.64903691e-02f, -1.03382155e-01f,
  -2.77272671e-01f, -6.76977858e-02f, 1.24241903e-01f, 1.09400444e-01f, 1.08556993e-01f, 2.35635061e-02f, 3.36117968e-02f, 1.98243447e-02f, 1.78843826e-01f, -4.16518562e-02f,
  2.66475463e-03f, 1.84982792e-02f, -8.78615584e-03f, 2.14827016e-01f, 7.99536146e-03f, -7.73494393e-02f, -9.51117575e-02f, -7.27866367e-02f, -4.49696146e-02f, 1.50246057e-03f,
  -2.11494993e-02f, 1.08810909e-01f, -1.57183379e-01f, -3.59125644e-01f, -2.29341820e-01f, -1.36893755e-03f, -7.72707537e-02f, -5.38928472e-02f, -4.57023457e-02f, -1.88678846e-01f,
  4.09888923e-02f, -2.17556097e-02f, 3.03343777e-02f, -1.27053529e-01f, -3.88838015e-02f, 4.74211238e-02f, -1.37612429e-02f, -3.63318957e-02f, 1.51064573e-02f, -6.71316544e-03f,
  9.76376235e-02f, 7.24553242e-02f, 7.39957318e-02f, -7.66737461e-02f, 1.14076741e-01f, -4.90504168e-02f, -1.62157994e-02f, -1.20105006e-01f, -3.50772799e-03f, 2.91147027e-02f,
  -4.28314283e-02f, -8.00010562e-02f, -1.06487023e-02f, -1.26740132e-02f, 3.40690501e-02f, -6.44754469e-02f, 7.55455494e-02f, 4.13729157e-03f, 2.85234824e-02f, 7.28083402e-02f,
  -3.84593070e-01f, 1.27587825e-01f, -1.90894961e-01f, -9.13999826e-02f, -1.14627458e-01f, -2.10346784e-02f, 5.95665835e-02f, 1.94985010e-02f, 4.83523821e-04f, -4.22978476e-02f,
  8.59355032e-02f, -2.02794194e-01f, -1.38649702e-01f, 9.13384929e-02f, 2.27256352e-03f, -7.99815059e-02f, -4.74117436e-02f, 3.03478334e-02f, -1.22030333e-01f, 7.97565375e-03f,
  -1.30191434e-03f, -1.84141845e-01f, -3.72994512e-01f, -2.82545507e-01f, -1.89827397e-01f, -1.84328273e-01f, -1.51083037e-01f, -2.57528335e-01f, -3.03317338e-01f, -4.90385592e-01f,
  -3.74868333e-01f, -4.93787289e-01f, 7.09233945e-03f, -2.73167461e-01f, -1.52067855e-01f, -2.55765170e-01f, -4.44665253e-01f, -9.53937247e-02f, -1.12367272e-01f, -3.92436743e-01f,
  -1.19883761e-01f, 2.35880584e-01f, 2.89618880e-01f, 3.57827455e-01f, 2.03324199e-01f, -2.37679973e-01f, -1.85204417e-01f, 3.49928886e-01f, 6.60932541e-01f, 2.07539424e-01f,
  -1.37946725e-01f, -1.82848722e-02f, 2.10717514e-01f, 2.33588368e-01f, -5.81141829e-01f, -6.72127232e-02f, -2.94745296e-01f, -1.92795098e-01f, -2.60101944e-01f, -6.08294487e-01f,
  -2.86246598e-01f, 2.33310591e-02f, 1.27724409e-01f, 1.02647059e-01f, -2.89244413e-01f, -1.61980919e-03f, -1.63662303e-02f, 9.43110958e-02f, 4.13124301e-02f, -9.12626553e-03f,
  6.71384530e-03f, 1.55856580e-01f, -5.80976193e-04f, -3.98150347e-02f, -1.92528054e-01f, -4.92456816e-02f, -7.51669258e-02f, 1.91042826e-01f, 1.57411709e-01f, -4.13257517e-02f,
  -3.29041898e-01f, -1.37201607e-01f, -2.65449397e-02f, -7.68789425e-02f, 9.78327692e-02f, 1.38113186e-01f, -1.48094237e-01f, -1.45134524e-01f, 1.29894719e-01f, -5.63805699e-01f,
  -6.82136491e-02f, -1.43408682e-02f, 2.72804201e-02f, 6.17568456e-02f, -7.50099197e-02f, 2.06929650e-02f, -4.21082042e-02f, -8.61989781e-02f, -6.92767184e-03f, -3.30710225e-02f,
  6.01762049e-02f, -2.77479757e-02f, 1.32190853e-01f, -1.22558028e-01f, 6.28072023e-02f, -9.62385088e-02f, -1.00837409e-01f, -1.48423880e-01f, 5.46666943e-02f, 2.68658418e-02f,
  1.65576905e-01f, 6.14210293e-02f, 2.53758449e-02f, 2.01186072e-02f, 3.04896180e-02f, 6.09787256e-02f, 6.98359683e-02f, 1.07047670e-02f, -3.45431678e-02f, -3.78716625e-02f,
  5.15209883e-03f, 2.89192736e-01f, -1.12686023e-01f, 1.03801906e-01f, -2.31236801e-03f, 1.47747874e-01f, -1.44338831e-01f, 1.33976772e-01f, 1.59096733e-01f, -1.53162191e-02f,
  2.31778901e-02f, -5.43088429e-02f, -3.20989825e-02f, 1.55825941e-02f, 3.58685516e-02f, -7.36401156e-02f, -2.31044129e-01f, 4.96313646e-02f, 1.67798236e-01f, 3.73007953e-02f,
  4.98375185e-02f, -3.58205214e-02f, -1.07900053e-01f, -1.07303843e-01f, -4.70045097e-02f, 1.04487007e-02f, -7.13108778e-02f, -1.19113907e-01f, 6.14947565e-02f, -2.34602734e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.54791563e-03f, 2.32907549e-01f, 3.20003599e-01f, 1.59655273e-01f, 5.44330180e-01f, 3.17338526e-01f, 2.59518743e-01f, 1.64703384e-01f, 1.02620907e-01f, 1.83071733e-01f,
  1.76517032e-02f, -1.81793328e-02f, 3.01812533e-02f, 8.89134258e-02f, 1.44892007e-01f, 1.53892646e-02f, 8.36274959e-03f, 5.37104785e-01f, 3.38394105e-01f, 8.19497183e-02f,
  1.58907175e-01f, 2.66140699e-01f, 2.37841457e-01f, 9.90576856e-03f, 8.35374296e-02f, 3.32053602e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -6.26471043e-02f, -7.03952089e-02f, 1.48063794e-01f, -1.17343962e-01f, -1.63495727e-02f, -2.88472269e-02f, -1.08535022e-01f, -5.81812076e-02f, 9.79842618e-02f, -2.22993702e-01f,
  5.66941835e-02f, -4.16146994e-01f, -6.44296482e-02f, -1.17933370e-01f, -2.36411631e-01f, 6.43741861e-02f, 3.96982640e-01f, 5.18370196e-02f, -9.88866463e-02f, 2.31845438e-01f,
  -1.80685431e-01f, 3.30411702e-01f, -1.39139012e-01f, -7.66458968e-03f, 1.62254855e-01f, 1.16908781e-01f, 4.81486283e-02f, -4.55921441e-01f, 2.27587707e-02f, 7.30066597e-02f,
  -2.45693084e-02f, 3.18915784e-01f, 2.68606003e-02f, -8.33642483e-02f, -2.55315125e-01f, 1.63628846e-01f, 5.96237630e-02f, -3.98920402e-02f, -1.96493044e-01f, 3.40965450e-01f,
  9.85680521e-02f, 9.62478891e-02f, 1.03756942e-01f, 4.66268361e-02f, 2.66106993e-01f, 3.03516388e-02f, 1.62424013e-01f, 2.16423869e-01f, -3.50938469e-01f, -5.89471832e-02f,
  3.76170486e-01f, -2.86293894e-01f, 2.63539739e-02f, -1.77356228e-02f, 2.44969577e-02f, 1.14344381e-01f, -1.70750305e-01f, -9.62810293e-02f, 1.74673259e-01f, 2.03472190e-02f,
  -2.80904084e-01f, 2.36868754e-01f, -1.21318437e-01f, -1.00593574e-01f, 8.73850957e-02f, -9.09805521e-02f, 3.07042450e-02f, -1.08091183e-01f, -1.26778275e-01f, 1.62461832e-01f,
  -5.03013909e-01f, -2.65121758e-01f, 2.35656887e-01f, -3.34837735e-01f, 1.39866039e-01f, 2.19288878e-02f, 1.61270779e-02f, 1.26303405e-01f, 7.16505498e-02f, -2.02220470e-01f,
  3.21373791e-02f, 4.07884210e-01f, 1.75029472e-01f, 2.17825500e-03f, -7.68963437e-05f, -1.64496407e-01f, 2.37557054e-01f, -1.89784393e-01f, 1.81905612e-01f, 8.88086036e-02f,
  5.56678735e-02f, 1.71669990e-01f, 4.70838360e-02f, -1.63024738e-01f, -3.42090689e-02f, -1.88469980e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.56369194e-01f, -5.76402806e-02f, 3.21912587e-01f, -1.04081996e-01f, 2.27581546e-01f, 1.12548411e-01f, 1.62127823e-01f, 5.72798967e-01f, 3.48996930e-02f, 5.29818013e-02f,
  -9.26190689e-02f, 1.11467883e-01f, -4.36047137e-01f, -9.19286013e-02f, 2.48089172e-02f, 5.71067154e-01f, -2.68827379e-01f, -2.20265135e-01f, 2.93655824e-02f, 2.63032168e-01f,
  1.43854648e-01f, -7.81979505e-03f, -3.57819587e-01f, 1.98037356e-01f, -1.56535789e-01f, -8.87839943e-02f, 2.79512815e-02f, -5.14492810e-01f, -2.28622705e-01f, 1.29125953e-01f,
  -1.71673015e-01f, 5.01633883e-01f, 9.23612267e-02f, 7.57969022e-02f, 1.18712641e-01f, 3.58462287e-03f, -4.06463444e-02f, -1.04343936e-01f, 9.50284973e-02f, -3.36594105e-01f,
  -1.69915423e-01f, 2.38544837e-01f, -1.97397768e-01f, 3.88618171e-01f, 5.22176623e-01f, 3.39705080e-01f, -1.97096542e-01f, -7.08631650e-02f, 2.00779438e-01f, 2.82518625e-01f,
  -7.44676292e-02f, 5.70285209e-02f, -1.89033486e-02f, -3.05948798e-02f, 1.37718409e-01f, 3.35319728e-01f, -2.41639391e-01f, 1.90205947e-01f, -2.59996384e-01f, 4.75628138e-01f,
  1.22203760e-01f, 4.73640487e-02f, 3.46227288e-01f, -1.87112004e-01f, -2.02038176e-02f, 2.65216738e-01f, -4.68107825e-03f, -9.47188139e-02f, -2.26192817e-01f, -4.58280146e-02f,
  2.92138547e-01f, -2.72602916e-01f, 1.57335937e-01f, 6.97469637e-02f, 1.86519474e-01f, 9.40654799e-02f, 1.99586913e-01f, 2.28987902e-01f, -1.08938396e-01f, -2.13681057e-01f,
  5.39595187e-01f, 9.85810757e-02f, -3.65841955e-01f, 3.12615633e-01f, -1.90762840e-02f, 3.74299645e-01f, -1.29326984e-01f, 2.01698504e-02f, 1.43581465e-01f, 1.43534228e-01f,
  -2.48899683e-01f, 9.34080258e-02f, 3.69735599e-01f, -6.66687936e-02f, 8.55274647e-02f, 2.30232272e-02f, -3.02314796e-02f, 1.40757203e-01f, 1.29128382e-01f, 2.88365632e-01f,
  1.65019810e-01f, -1.43772945e-01f, 4.43060756e-01f, 8.07471454e-01f, -2.25127175e-01f, 1.07152671e-01f, 1.03721321e-01f, 4.11958188e-01f, 1.67737380e-01f, -3.36669743e-01f,
  -2.71061491e-02f, -3.07104558e-01f, -2.14872837e-01f, -3.42805743e-01f, -3.95394117e-01f, -1.61474012e-02f, 3.41648608e-01f, -2.79676169e-01f, -4.20320500e-03f, -8.25536624e-02f,
  -4.70401905e-02f, -3.51831019e-01f, -7.85824731e-02f, 6.28988221e-02f, -5.82892001e-02f, -3.01858872e-01f, 2.58668244e-01f, 2.75727481e-01f, 1.44362465e-01f, 2.71352500e-01f,
  1.33124009e-01f, 9.46425498e-02f, 7.72859976e-02f, -7.82745332e-02f, 1.30468175e-01f, 1.24478534e-01f, -1.36397392e-01f, 9.37038586e-02f, -4.66310233e-03f, 3.18104327e-01f,
  4.20463741e-01f, 2.12154165e-01f, 1.22739933e-01f, -7.42219612e-02f, 1.37072578e-01f, -1.25183836e-01f, -1.53270215e-01f, -7.00130016e-02f, 5.28188199e-02f, 2.49817431e-01f,
  -1.93934053e-01f, -3.74676846e-02f, -3.73163581e-01f, 2.30666008e-02f, -2.14392781e-01f, 5.77711701e-01f, 1.83173432e-03f, -8.49666148e-02f, 3.01741332e-01f, 1.39829069e-01f,
  8.22732151e-02f, -3.69706862e-02f, -1.29614756e-01f, 8.15328211e-02f, -1.02135666e-01f, 2.57434756e-01f, 6.68899864e-02f, -1.64520204e-01f, -1.18400909e-01f, -1.41891616e-03f,
  -1.20701917e-01f, 1.63187161e-01f, 2.43754372e-01f, 1.31370559e-01f, -1.98660582e-01f, 1.17078066e-01f, 3.07208955e-01f, 3.25915031e-02f, -1.33011490e-01f, -1.39791057e-01f,
  -1.62914675e-02f, 9.26973745e-02f, 1.28139101e-03f, 3.98993850e-01f, -3.91452521e-01f, 3.98462623e-01f, 6.84437826e-02f, 4.04036880e-01f, 2.08196983e-01f, -2.31918260e-01f,
  4.66840081e-02f, -5.09573184e-02f, 3.92977178e-01f, 2.13740960e-01f, -2.31511500e-02f, 4.02160212e-02f, -4.91389669e-02f, 8.74320418e-02f, 9.91780609e-02f, -5.94581328e-02f,
  2.28612006e-01f, -3.25518996e-01f, -1.64155915e-01f, 3.26304764e-01f, 1.73096335e-03f, 2.29925945e-01f, -2.56243020e-01f, -2.48468488e-01f, 3.65261614e-01f, 3.05769861e-01f,
  -2.08945930e-01f, 2.47640669e-01f, -8.10701028e-02f, -2.94249028e-01f, 6.20657466e-02f, 5.49087942e-01f, 3.98374423e-02f, 3.08597624e-01f, 1.66609645e-01f, 1.62738916e-02f,
  1.81760654e-01f, -2.34476551e-02f, 2.37761624e-02f, 4.87171188e-02f, 4.91093025e-02f, 1.67930692e-01f, -5.12459036e-03f, 1.15397207e-01f, 5.86879030e-02f, -1.56802721e-02f,
  7.67651200e-02f, 4.87336248e-01f, -1.21667303e-01f, 1.34213775e-01f, 1.53781191e-01f, 1.80736572e-01f, 7.50501901e-02f, 1.02800943e-01f, 2.02812813e-02f, 1.90390944e-01f,
  -2.05721080e-01f, -2.98473001e-01f, -1.04458347e-01f, -2.28830755e-01f, 3.41551334e-01f, -1.29153803e-01f, 1.30461663e-01f, -1.06140129e-01f, -1.31653905e-01f, -6.52227476e-02f,
  -2.87809908e-01f, 7.51739880e-03f, -2.55400956e-01f, -1.91612571e-01f, 3.10563833e-01f, 1.71998397e-01f, 5.81687540e-02f, 2.32292816e-01f, -1.21357769e-01f, -3.13506508e-03f,
  -2.04628054e-02f, 6.83334619e-02f, -9.81354862e-02f, 6.08915329e-01f, 3.43186885e-01f, -2.03200635e-02f, 2.44972453e-01f, 3.58927459e-01f, 2.76908219e-01f, 2.77677238e-01f,
  1.59796283e-01f, -6.99282736e-02f, -1.05331287e-01f, 2.78450221e-01f, 4.11823124e-01f, -2.37208337e-01f, 4.02627233e-03f, -1.71025693e-01f, -3.21888775e-01f, -9.64252949e-02f,
  1.44224927e-01f, 3.35217178e-01f, 2.92045623e-01f, 3.79018337e-01f, -1.73882917e-01f, -2.01043442e-01f, -7.52697960e-02f, 2.14379668e-01f, 5.29286638e-02f, -8.33093151e-02f,
  1.38589650e-01f, -1.38254866e-01f, -7.85404891e-02f, -1.33137375e-01f, 1.51048914e-01f, -3.70205671e-01f, 1.22430205e-01f, 7.88131878e-02f, 1.36122704e-01f, -6.82529733e-02f,
  -2.65636742e-01f, -1.12473302e-01f, 6.26882985e-02f, -5.60805619e-01f, 2.28250727e-01f, 1.34492308e-01f, -2.06071079e-01f, 4.23461199e-01f, 9.18953717e-02f, 1.62822634e-01f,
  1.35426223e-01f, 2.91257381e-01f, 4.77871627e-01f, 2.27903053e-01f, 6.98046982e-02f, -3.77337933e-02f, 3.98219496e-01f, 2.06356477e-02f, 4.52991500e-02f, 2.93597400e-01f,
  1.37258619e-01f, 8.72516632e-02f, 1.27387268e-03f, -1.09435860e-02f, -9.00803972e-03f, -1.44674163e-02f, -3.41074824e-01f, 2.61150986e-01f, 1.45704374e-01f, -3.19692269e-02f,
  -2.25907527e-02f, 5.34520149e-01f, 3.50651473e-01f, -3.95786278e-02f, -9.61450562e-02f, 2.07905561e-01f, 4.13761847e-03f, 3.15034091e-01f, 2.25846112e-01f, -2.09428534e-01f,
  2.71623671e-01f, -5.21886528e-01f, -5.35523631e-02f, 2.93401659e-01f, 9.40365121e-02f, -8.42774753e-03f, 3.71260680e-02f, 2.07869500e-01f, -8.73271525e-02f, 1.27822682e-01f,
  -2.76698470e-01f, -3.18119138e-01f, 2.92368442e-01f, 2.17376068e-01f, 3.60354871e-01f, -6.39623180e-02f, -1.80574909e-01f, -1.81150332e-01f, 2.69682612e-02f, -1.56985119e-01f,
  -5.43447472e-02f, 1.33376624e-02f, 2.71345943e-01f, -1.30546317e-01f, -3.66678997e-03f, 2.10984468e-01f, -9.99317989e-02f, 1.68882236e-02f, 2.59777874e-01f, 8.28199089e-02f,
  3.82421538e-02f, 3.89419556e-01f, -9.62971076e-02f, 1.99836239e-01f, -2.29327708e-01f, 1.35545032e-02f, 1.53975010e-01f, 1.55932814e-01f, 6.72447728e-03f, 4.86502610e-02f,
  4.28094149e-01f, -7.42815807e-02f, 2.70756185e-01f, 2.53240108e-01f, -3.37473080e-02f, 3.35462056e-02f, -8.16852078e-02f, -1.12481266e-01f, 1.01507492e-01f, 2.91657358e-01f,
  2.38965213e-01f, 4.56119776e-01f, -1.71951935e-01f, 1.14037558e-01f, 4.17944193e-02f, 2.58867979e-01f, 3.23909372e-02f, 6.72609955e-02f, -1.43637717e-01f, 2.73703724e-01f,
  1.16022348e-01f, -2.99196541e-01f, -1.54018596e-01f, -2.57664286e-02f, 1.95943132e-01f, 4.36954238e-02f, 6.40127510e-02f, -1.62886176e-02f, -3.03334087e-01f, 1.24667935e-01f,
  -3.74175496e-02f, 1.76953927e-01f, -7.01585785e-02f, -2.78130293e-01f, 4.27842140e-01f, 1.97541803e-01f, -2.83078611e-01f, 2.01683134e-01f, 3.39756250e-01f, 8.61823559e-02f,
  4.81147245e-02f, -2.03115851e-01f, 2.16981694e-01f, 2.52783120e-01f, -2.82463849e-01f, 4.49607491e-01f, 3.58245343e-01f, -2.92081088e-01f, 2.05436811e-01f, -8.45960453e-02f,
  3.98699529e-02f, 7.23297596e-01f, 3.37099396e-02f, -3.91916066e-01f, -2.70899594e-01f, 1.44078493e-01f, -2.84347653e-01f, 2.72377163e-01f, -3.19147855e-01f, -2.07539704e-02f,
  2.43466824e-01f, 7.21253082e-02f, -3.16758528e-02f, 1.88937858e-01f, 8.15077797e-02f, 1.26743808e-01f, 4.75419521e-01f, 9.00847465e-02f, 1.65596288e-02f, 3.28368112e-03f,
  -2.11664394e-01f, 2.58755058e-01f, 2.17272371e-01f, -2.67354667e-01f, 1.93738431e-01f, -4.84690815e-01f, -2.65995681e-01f, 5.43812871e-01f, -3.94732326e-01f, -9.55287591e-02f,
  -1.39818326e-01f, 6.11491278e-02f, -7.20982313e-01f, -1.74346074e-01f, -4.62544054e-01f, 4.19376530e-02f, 2.74347633e-01f, -8.30954406e-03f, 5.49758449e-02f, -1.99201241e-01f,
  -3.56341124e-01f, 1.51856109e-01f, -2.29700461e-01f, -2.61802793e-01f, 1.30273938e-01f, 2.93516457e-01f, 1.73421323e-01f, 5.55674732e-01f, 2.48310611e-01f, -3.94247860e-01f,
  1.92861646e-01f, -2.40717381e-02f, 7.04159811e-02f, -2.79326029e-02f, 3.24246734e-01f, -2.14603841e-01f, 7.08342135e-01f, 2.96979696e-01f, -1.49309546e-01f, 1.70495227e-01f,
  -3.22358102e-01f, 5.40634930e-01f, -3.48916799e-01f, -1.35319337e-01f, -3.62229645e-01f, -7.29210377e-01f, -2.18987986e-01f, 3.44002306e-01f, -4.13473919e-02f, 7.00917095e-02f,
  2.93992847e-01f, -7.19583929e-01f, -1.44716159e-01f, 8.71456712e-02f, -2.54890621e-01f, -3.07285696e-01f, 5.65132184e-04f, 1.47535637e-01f, 2.89021879e-01f, 3.28894317e-01f,
  1.64178178e-01f, -1.42484650e-01f, 1.16410837e-01f, -5.18827066e-02f, 1.46282658e-01f, 1.45580813e-01f, -8.09275359e-03f, 3.91059332e-02f, -1.97382659e-01f, -2.75458515e-01f,
  4.59954113e-01f, -1.54563069e-01f, 2.70458817e-01f, -2.48683274e-01f, -1.77069008e-01f, 2.46044755e-01f, 3.23145688e-02f, -4.89819020e-01f, 2.47137010e-01f, 1.77647337e-01f,
  1.03980646e-01f, 2.64544338e-01f, 3.56287025e-02f, -5.07540330e-02f, 1.98322520e-01f, -1.83120836e-02f, 2.02074245e-01f, 2.88562238e-01f, 1.32899404e-01f, 1.58411369e-01f,
  1.19988531e-01f, -2.61642151e-02f, -3.65208760e-02f, 4.03664678e-01f, -1.40154257e-01f, -8.04191381e-02f, -9.20066703e-03f, -1.65700261e-02f, 4.60727885e-02f, -1.54772326e-01f,
  1.16771050e-02f, 3.28822494e-01f, 4.21153188e-01f, -2.07490064e-02f, -2.26236247e-02f, 4.19153601e-01f, 3.14606987e-02f, 2.28199378e-01f, 2.15721559e-02f, -5.09059310e-01f,
  1.67771131e-01f, 4.21187967e-01f, 2.67499596e-01f, -1.01835057e-01f, -1.74727708e-01f, -1.01301730e-01f, 1.44699976e-01f, -1.17514208e-01f, -2.04608366e-01f, -3.83339562e-02f,
  4.09611575e-02f, 3.42527419e-01f, 1.00741997e-01f, -1.30365834e-01f, 1.00058727e-01f, 4.49799635e-02f, -1.29185230e-01f, -3.01533490e-02f, 1.61807939e-01f, 4.37846109e-02f,
  -2.41001360e-02f, -4.11071442e-02f, -1.40743673e-01f, 2.91266978e-01f, 4.30867553e-01f, -2.29820520e-01f, -3.95001352e-01f, 1.73090160e-01f, -2.58850604e-01f, -1.44638017e-01f,
  1.51678860e-01f, 5.46593368e-01f, -4.23394591e-01f, -5.50960377e-02f, 3.71759295e-01f, -1.19369119e-01f, 3.95417362e-02f, -1.89556494e-01f, 1.52995996e-02f, 3.89880151e-01f,
  4.27708030e-01f, -4.72530127e-02f, 2.79056907e-01f, -1.81141227e-01f, -1.11952946e-01f, 2.23477811e-01f, -3.19116533e-01f, -3.47721487e-01f, -1.73912689e-01f, 2.82067042e-02f,
  7.00586662e-02f, -6.17445074e-03f, 5.56309335e-02f, 2.65339594e-02f, 2.66939197e-02f, -2.71851391e-01f, 1.18002877e-01f, -1.21693008e-01f, -3.06212485e-01f, -1.02927618e-01f,
  -1.59605786e-01f, 1.12710088e-01f, 1.18038155e-01f, 1.45573243e-01f, -1.75951779e-01f, -1.66908666e-01f, 9.15195882e-01f, 9.40549746e-02f, -1.93240583e-01f, 1.97114676e-01f,
  1.67664230e-01f, -3.37366492e-01f, -2.71838546e-01f, -2.55846918e-01f, -4.22187716e-01f, -1.00226521e-01f, 3.24330330e-01f, 1.65156379e-01f, -5.41936338e-01f, 3.52987796e-02f,
  9.55080390e-02f, 2.10530922e-01f, 2.19544381e-01f, 9.20862481e-02f, -5.67930117e-02f, -2.13952512e-01f, 3.60050559e-01f, -1.21910557e-01f, 1.94562078e-01f, 3.33289355e-01f,
  3.86688501e-01f, -2.25682974e-01f, -1.53351232e-01f, 1.48856252e-01f, -1.32040441e-01f, -1.15304060e-01f, 2.44988501e-01f, -6.40096441e-02f, -2.15898603e-01f, 2.81162173e-01f,
  1.08728521e-01f, 3.42388988e-01f, -1.30134514e-02f, 1.29197657e-01f, 2.41570383e-01f, 3.64412487e-01f, -2.05233879e-02f, -1.15373895e-01f, 1.56044796e-01f, 1.19928442e-01f,
  4.11519945e-01f, 4.32454705e-01f, -2.25913506e-02f, 2.93593644e-03f, 3.15688729e-01f, 2.92646997e-02f, -1.34594858e-01f, 3.72085832e-02f, -1.82574671e-02f, -6.41522169e-01f,
  -3.06941926e-01f, 3.25396299e-01f, 1.59068182e-01f, -2.17088774e-01f, 1.54904619e-01f, 1.39900818e-01f, -1.16039090e-01f, 3.26876879e-01f, 8.44514668e-02f, -8.18372145e-02f,
  -3.18533570e-01f, 2.81840235e-01f, -1.17935121e-01f, 2.46102884e-01f, 5.38813919e-02f, 2.91115522e-01f, 4.06318635e-01f, 2.39333227e-01f, -5.92920408e-02f, -3.65062654e-02f,
  3.98396045e-01f, 2.28062734e-01f, 9.48912054e-02f, 5.66156320e-02f, -1.30216321e-02f, 1.11056015e-01f, -2.53431678e-01f, 5.60616367e-02f, 1.76356122e-01f, 1.34586006e-01f,
  -3.58318180e-01f, 1.01416931e-01f, -2.41199762e-01f, 4.16785508e-01f, 1.24732614e-01f, 3.09739053e-01f, 3.29372168e-01f, 2.22757950e-01f, -2.33638063e-01f, 7.51961052e-01f,
  -8.76904204e-02f, -3.27878818e-02f, 1.56279624e-01f, -3.67469806e-03f, 5.21462150e-02f, 2.38978922e-01f, -8.70220885e-02f, 3.53557795e-01f, -8.54219347e-02f, -2.70489067e-01f,
  1.11469980e-02f, -9.90338847e-02f, -1.92133874e-01f, 4.25813019e-01f, -1.01826340e-01f, -1.12647049e-01f, -2.93876790e-02f, 1.00193433e-01f, 4.27249596e-02f, -7.10078143e-03f,
  -1.66416317e-01f, -1.33976256e-02f, 3.77190977e-01f, -3.74849081e-01f, -5.30055687e-02f, 7.34928623e-02f, -6.41155183e-01f, 3.45613986e-01f, 3.28068063e-02f, -1.95720568e-02f,
  -2.42002070e-01f, -2.99515277e-01f, 5.69515042e-02f, 1.75724655e-01f, -1.98034570e-01f, 1.59450546e-01f, 2.36437500e-01f, -3.91885966e-01f, 6.88548833e-02f, 1.01593649e-02f,
  -2.98710708e-02f, -2.36748874e-01f, -8.52439255e-02f, 3.95360023e-01f, 3.20183635e-01f, 2.21500650e-01f, 2.34315813e-01f, -7.20614612e-01f, 6.77438602e-02f, 3.05682629e-01f,
  -3.13063487e-02f, 6.77551627e-02f, -3.18011642e-02f, -1.65031832e-02f, 2.30230875e-02f, -1.03185391e-02f, 6.00747168e-01f, -1.79765835e-01f, -6.89793304e-02f, 4.65386748e-01f,
  2.43268758e-01f, 7.14152008e-02f, -5.27968928e-02f, -5.60615957e-01f, 3.19376945e-01f, 5.53899407e-01f, 4.61913347e-01f, 2.87986755e-01f, -2.85971671e-01f, -2.91917264e-01f,
  1.77709445e-01f, -6.97119460e-02f, -9.86733381e-03f, -2.48178001e-02f, -1.36934146e-01f, 2.10839182e-01f, 2.67521646e-02f, -7.71842152e-02f, -2.11600408e-01f, 8.80346596e-02f,
  -2.24871263e-01f, -2.17008218e-01f, -1.73231170e-01f, -2.46014461e-01f, -2.09194928e-01f, -9.95813217e-03f, 7.43601620e-02f, -4.90700245e-01f, 5.28665073e-02f, -2.67696947e-01f,
  -3.94755788e-02f, -1.92613959e-01f, -3.44148315e-02f, -1.20687768e-01f, 9.59810242e-02f, -4.27358240e-01f, 2.59238988e-01f, 2.82246709e-01f, -1.45306473e-03f, 3.29680741e-01f,
  -1.33276314e-01f, -7.58337080e-02f, -1.44863904e-01f, 1.83704987e-01f, -1.66011408e-01f, 1.85778812e-01f, 1.36250198e-01f, -7.34379236e-03f, -1.44909278e-01f, -3.35249268e-02f,
  1.54745370e-01f, 3.72456849e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  3.63541573e-01f, 6.84868172e-02f, -2.99291387e-02f, 1.98992088e-01f, 2.89520860e-01f, 2.13127539e-01f, 1.23632187e-02f, 2.32791118e-02f, 2.73498893e-01f, -3.44025232e-02f,
  2.65260488e-01f, 1.26285106e-01f, 9.65245068e-02f, 2.06894830e-01f, 1.19825140e-01f, 4.56510127e-01f, 5.47666103e-02f, 2.65141696e-01f, 4.07698713e-02f, -2.03062985e-02f,
  7.56995082e-02f, 1.61137477e-01f, 2.16829389e-01f, 1.68261290e-01f, 3.57323468e-01f, -3.21894675e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -2.10670978e-01f, 2.65311599e-01f, -1.98509410e-01f, 1.54081479e-01f, -2.32442990e-01f, 1.65845957e-02f, 6.92511722e-03f, 1.26122683e-01f, 1.54103860e-01f, -2.10211482e-02f,
  1.14958540e-01f, 2.26672769e-01f, 3.29630494e-01f, -2.85095990e-01f, -7.81007558e-02f, -2.60144889e-01f, -1.98198874e-02f, 1.58240438e-01f, 2.01850049e-02f, -2.78215677e-01f,
  -2.91503429e-01f, 2.35413432e-01f, -1.80064023e-01f, -6.04682751e-02f, -1.67522192e-01f, 4.02422100e-02f, -6.55508190e-02f, -3.22685763e-02f, -1.83366716e-01f, 1.34043783e-01f,
  3.09075892e-01f, -3.09856664e-02f, -4.65980560e-01f, -1.04845837e-01f, 2.61357613e-02f, 2.90169209e-01f, -4.08336043e-01f, -1.71193257e-01f, -1.10486902e-01f, 4.82390039e-02f,
  2.50934452e-01f, -2.91683823e-01f, -2.06910864e-01f, 9.26445588e-04f, 1.16072439e-01f, -3.47719878e-01f, -7.85000175e-02f, 9.45411772e-02f, 5.20040169e-02f, 2.16357842e-01f,
  -1.73694387e-01f, 1.01007953e-01f, 5.37106693e-01f, 1.50029942e-01f, -5.33379950e-02f, -1.55343369e-01f, -2.41142474e-02f, -2.61729568e-01f, 1.03205383e-01f, 1.61648765e-01f,
  -6.38620183e-02f, 2.82162070e-01f, -3.44449002e-03f, 2.52144456e-01f, 1.23642292e-02f, 1.11278862e-01f, -2.85874546e-01f, 2.29188520e-02f, 2.33205840e-01f, 2.44729355e-01f,
  -4.59614769e-02f, -2.76444793e-01f, 3.46163735e-02f, -2.49962986e-01f, -9.32016149e-02f, -1.33657411e-01f, -1.05110183e-01f, -1.78409606e-01f, 2.37010777e-01f, -1.78713262e-01f,
  2.96596020e-01f, 5.15105352e-02f, -2.54079014e-01f, -2.27361806e-02f, 4.14300531e-01f, -9.86798927e-02f, 1.40073985e-01f, 1.90772880e-02f, 1.32812690e-02f, -1.90126568e-01f,
  -3.62128466e-02f, -1.12403676e-01f, 7.74688646e-02f, 3.95179577e-02f, 6.74823299e-02f, -3.20114076e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.04520440e-01f, 1.77961122e-02f, 2.06695840e-01f, -3.36488247e-01f, 2.23273367e-01f, -2.42197305e-01f, 3.88771117e-01f, 1.07046038e-01f, -5.06938159e-01f, -4.78078127e-02f,
  -2.03441363e-03f, 1.80960789e-01f, 1.62893325e-01f, 1.56820029e-01f, -2.38507077e-01f, -1.63051158e-01f, 2.20572248e-01f, -3.06457818e-01f, 1.16213202e-01f, -1.14034884e-01f,
  2.49451902e-02f, 1.11779392e-01f, -3.07102669e-02f, -2.77539045e-01f, 3.12211752e-01f, -2.82277793e-01f, -5.31466566e-02f, -1.41720280e-01f, 4.09909278e-01f, 3.16066071e-02f,
  -2.88620144e-01f, -2.34836578e-01f, -3.93630475e-01f, -1.03960373e-01f, -3.79044563e-02f, 4.45118487e-01f, -4.25029606e-01f, 1.53931677e-02f, -3.07461292e-01f, 2.91479200e-01f,
  3.67022395e-01f, -1.04263894e-01f, 6.83529601e-02f, 8.17421898e-02f, 1.84871387e-02f, 1.24063104e-01f, -2.27457494e-01f, 4.71214280e-02f, 6.53841812e-03f, 6.70183375e-02f,
  2.03236371e-01f, 3.70448798e-01f, -1.44203022e-01f, -2.35401675e-01f, 2.87280589e-01f, 1.04036011e-01f, 1.61944419e-01f, -2.16787741e-01f, 7.53126144e-02f, 1.70944363e-01f,
  -2.22243845e-01f, -3.14810067e-01f, -1.97506651e-01f, 2.19196871e-01f, 3.91994923e-01f, 5.03560364e-01f, -3.06505729e-02f, -5.97855635e-02f, 1.94276929e-01f, -3.23166013e-01f,
  5.79001427e-01f, -7.31890947e-02f, -7.85737112e-02f, 4.09939140e-01f, 9.41786095e-02f, 1.33478967e-02f, -5.40417060e-02f, 2.32708082e-01f, 3.92043451e-03f, 1.18126757e-01f,
  8.71669352e-02f, 2.85628960e-02f, -3.99446934e-02f, -8.58913437e-02f, 5.43254435e-01f, 5.57957590e-01f, 3.15425196e-03f, -1.21726684e-01f, 4.21012081e-02f, -3.24123412e-01f,
  6.83508217e-02f, -1.80841498e-02f, 1.94724426e-01f, 1.69227228e-01f, -1.74574688e-01f, -4.84581023e-01f, -6.60034120e-02f, -6.38526976e-02f, -9.13980417e-03f, 5.13252139e-01f,
  1.71629176e-01f, -2.97783405e-01f, 1.80384427e-01f, 2.49559700e-01f, 1.54592231e-01f, -7.53223710e-03f, 3.30165327e-01f, 1.31313056e-01f, -1.66169390e-01f, 7.23991096e-02f,
  2.15177424e-02f, -2.46109515e-01f, -5.96517809e-02f, 2.32712418e-01f, 2.31557101e-01f, 4.86490756e-01f, 1.07898839e-01f, -3.82308685e-03f, -2.51855105e-01f, -2.25355044e-01f,
  -3.01158684e-03f, 1.45559058e-01f, 2.95674860e-01f, 3.48751396e-01f, 5.44189155e-01f, -5.03248423e-02f, -4.24773753e-01f, -2.83712596e-01f, -3.89519393e-01f, 1.37237608e-01f,
  -1.78745195e-01f, -3.13480765e-01f, 2.60807186e-01f, -2.14952946e-01f, 3.12853307e-01f, 2.63117939e-01f, 1.07458189e-01f, 1.97306782e-01f, 2.68223770e-02f, 2.29751304e-01f,
  3.04857612e-01f, 2.47094378e-01f, -8.79750326e-02f, -5.72897494e-02f, 2.25607455e-01f, -1.26404136e-01f, -8.96821767e-02f, -8.82366672e-03f, 3.63519371e-01f, 4.88375843e-01f,
  -1.16535336e-01f, -3.55911814e-02f, 1.58369362e-01f, -1.91023529e-01f, 6.53888285e-02f, 9.91557539e-02f, 3.03812325e-01f, 3.55940938e-01f, 1.73813164e-01f, -2.22023442e-01f,
  3.91996920e-01f, 3.83102268e-01f, 3.10664564e-01f, -4.47556227e-01f, 2.57496327e-01f, 2.19337091e-01f, 3.50917727e-01f, 5.72898276e-02f, 8.47361237e-03f, 2.92171091e-01f,
  1.01985954e-01f, -4.23498005e-02f, 7.94174373e-02f, 2.31829062e-01f, 2.14503571e-01f, 1.68280125e-01f, 2.70924211e-01f, -5.08582368e-02f, 9.42843780e-02f, -2.06164092e-01f,
  -6.83347404e-01f, -2.23529618e-02f, 2.76377946e-01f, 4.25728083e-01f, 3.34365934e-01f, -6.72002807e-02f, 1.40769497e-01f, -3.65513593e-01f, -1.64046735e-01f, -3.48176032e-01f,
  4.87635404e-01f, -3.17244828e-02f, -6.30959272e-02f, -1.81162730e-01f, 3.73950511e-01f, 9.90760624e-02f, -3.14764738e-01f, 2.27552637e-01f, -3.96083415e-01f, 3.92127007e-01f,
  4.66591597e-01f, -2.56142020e-01f, 3.66283536e-01f, 4.46991265e-01f, 2.65838504e-01f, 7.48489946e-02f, 1.76093832e-01f, -1.02659747e-01f, 2.16808781e-01f, 3.18203300e-01f,
  2.16892958e-01f, 1.40153781e-01f, -4.30370957e-01f, -4.87766385e-01f, 1.10033475e-01f, 5.07214433e-03f, 1.44012108e-01f, 9.43536311e-02f, 9.42268521e-02f, 1.63223371e-01f,
  3.08752172e-02f, -2.60339558e-01f, -3.50772105e-02f, -1.56394001e-02f, 2.25759313e-01f, -7.94117618e-03f, 4.80807632e-01f, -6.36709156e-04f, -5.45208275e-01f, -1.53381795e-01f,
  -5.37813127e-01f, 2.97046900e-01f, 2.06589252e-01f, 1.21890776e-01f, 4.48313624e-01f, 3.26926231e-01f, 1.73128426e-01f, 3.23946625e-01f, 5.12773134e-02f, 1.15509495e-01f,
  -3.47453766e-02f, 2.06886292e-01f, 1.35925978e-01f, 8.31242651e-02f, -1.23299651e-01f, -4.86049987e-02f, 2.92134106e-01f, 3.28394949e-01f, -2.98717827e-01f, -8.95910338e-03f,
  1.25451714e-01f, -5.19722216e-02f, -2.10438937e-01f, -3.65206078e-02f, 1.81300059e-01f, 1.57411411e-01f, 4.18491252e-02f, -5.97329102e-02f, 3.28859925e-01f, -1.77679151e-01f,
  6.11170344e-02f, -3.52818340e-01f, 3.50894570e-01f, 2.80662323e-03f, -4.66994852e-01f, 5.15371524e-02f, -1.06478274e-01f, 1.03862248e-01f, -9.27454978e-02f, 2.30096988e-02f,
  -1.30943969e-01f, 1.82612240e-01f, 2.89278686e-01f, -1.01283453e-01f, 1.11912020e-01f, -1.42913712e-02f, 2.83285379e-01f, 1.32346332e-01f, 4.92641367e-02f, -1.05431363e-01f,
  3.21694076e-01f, -4.31373954e-01f, -7.94346929e-02f, 1.11912200e-02f, 1.64534643e-01f, -1.31488681e-01f, -3.67118061e-01f, -8.33076313e-02f, 7.49799192e-01f, 1.47320986e-01f,
  2.81522036e-01f, -3.50911349e-01f, 1.62888646e-01f, 3.33104610e-01f, 3.66973996e-01f, 9.83332247e-02f, -2.23463564e-03f, -1.17238671e-01f, -1.00093000e-01f, -6.04881607e-02f,
  8.42446163e-02f, -3.18687111e-02f, 4.34525073e-01f, -4.19593751e-02f, 2.12399468e-01f, 1.65524706e-01f, -5.59948804e-03f, -1.73092321e-01f, -3.12072307e-01f, -9.19827223e-02f,
  2.33642951e-01f, 2.48690560e-01f, 3.15230727e-01f, 6.92053884e-02f, -3.85206081e-02f, -1.40366763e-01f, -7.90609233e-03f, -2.25473017e-01f, 3.11325341e-01f, 1.34622261e-01f,
  4.28834438e-01f, 2.60806412e-01f, 1.26914024e-01f, -4.39263403e-01f, 3.32649946e-01f, -2.19399676e-01f, 4.36149746e-01f, 1.18674994e-01f, 8.68185237e-02f, 3.18198889e-01f,
  3.75915319e-02f, 3.72757204e-02f, 4.18438427e-02f, 4.06665914e-02f, 6.70509934e-02f, -2.13193521e-01f, 4.20385540e-01f, -1.95798397e-01f, 1.55919984e-01f, 7.17692226e-02f,
  7.09956512e-02f, 5.65749884e-01f, -1.70969024e-01f, 1.00538127e-01f, 6.76794201e-02f, -2.47677118e-02f, -2.38400474e-01f, -2.03578174e-02f, 3.95095170e-01f, 5.02046108e-01f,
  -9.07361433e-02f, -5.61263859e-01f, -2.77850449e-01f, 2.18438968e-01f, -4.41464365e-01f, -2.42403537e-01f, 1.56079024e-01f, -1.70052983e-02f, -1.19201839e-01f, 2.18521118e-01f,
  1.67715728e-01f, 4.60578620e-01f, 1.61085397e-01f, 9.70555767e-02f, 1.08026661e-01f, 2.08804220e-01f, -1.50432348e-01f, -1.01210877e-01f, 1.14285186e-01f, -2.03259408e-01f,
  2.35929757e-01f, -1.99225247e-01f, 5.13649940e-01f, 6.72108531e-01f, -9.29207355e-02f, 2.10158646e-01f, -2.58278310e-01f, -2.80039221e-01f, 1.19787976e-01f, 1.06208585e-01f,
  -4.01426926e-02f, 6.24527872e-01f, 1.24028333e-01f, -2.35832870e-01f, 2.01978534e-02f, -1.05843998e-01f, 4.58491564e-01f, -7.22119212e-01f, 3.14672500e-01f, 1.68620963e-02f,
  9.86720249e-02f, 2.02797294e-01f, 9.50368345e-02f, 3.39951664e-01f, 6.91496953e-02f, 3.37058842e-01f, 1.22819811e-01f, 2.20586762e-01f, 2.00015634e-01f, -3.15943398e-02f,
  3.53528291e-01f, -6.44948334e-02f, 2.06192151e-01f, 7.99411088e-02f, -5.82050145e-01f, 2.46658787e-01f, 1.78411826e-02f, 1.13834970e-01f, 1.98378101e-01f, -5.05149245e-01f,
  -5.17426170e-02f, -1.89320490e-01f, 6.54388517e-02f, 2.91679829e-01f, -8.29600543e-02f, -1.40078053e-01f, 7.93882087e-03f, 2.11342759e-02f, -5.32363057e-01f, 2.72179484e-01f,
  -1.81665823e-01f, 2.80482024e-01f, -2.12085247e-01f, 5.27235540e-03f, 1.38348266e-01f, -4.39070016e-01f, -9.00549721e-03f, -2.68715583e-02f, 5.14383316e-01f, -4.94224101e-01f,
  1.57399729e-01f, 2.46052980e-01f, 8.43038037e-03f, 2.66881198e-01f, -1.51437998e-01f, -2.50671595e-01f, -2.57763386e-01f, -2.41938829e-02f, 1.13599658e-01f, 1.07359841e-01f,
  -5.45624718e-02f, 3.83869954e-03f, 2.17157435e-02f, 1.68500885e-01f, -5.17730057e-01f, -1.08914606e-01f, 3.30212116e-01f, 6.90286532e-02f, 7.75302714e-03f, 2.03170896e-01f,
  -3.12192917e-01f, -1.00964233e-01f, -2.35381529e-01f, 2.62772560e-01f, -2.78271645e-01f, 3.01921874e-01f, 1.13485061e-01f, -2.75567234e-01f, -5.67402057e-02f, 2.51627535e-01f,
  1.47330627e-01f, -1.92122594e-01f, -1.62080869e-01f, 2.90869564e-01f, 1.81093365e-01f, -8.28202069e-02f, -1.31670013e-01f, -3.61011535e-01f, 7.69629061e-01f, 5.01141131e-01f,
  1.73461407e-01f, 2.89365411e-01f, -1.76331885e-02f, 3.39656949e-01f, 2.67215353e-02f, 5.93893342e-02f, 1.55277327e-01f, 5.73335469e-01f, 5.27931035e-01f, 3.26323994e-02f,
  1.75823942e-01f, 3.52545291e-01f, 5.57034135e-01f, -5.79026580e-01f, 2.15722799e-01f, -1.30813807e-01f, -7.72361010e-02f, -6.31131530e-02f, 1.39424607e-01f, 7.32540432e-03f,
  3.05887461e-01f, 1.64115638e-01f, -5.49623817e-02f, 2.02015019e-03f, -1.13053404e-01f, -1.16146103e-01f, -1.06330901e-01f, 1.17564790e-01f, -2.27101985e-03f, 8.68056044e-02f,
  2.00601414e-01f, 4.57803160e-02f, -8.41878802e-02f, 8.62040296e-02f, -4.00399148e-01f, 3.10817286e-02f, -1.22333974e-01f, -1.60586044e-01f, 8.61360431e-02f, 3.32377940e-01f,
  -4.08713579e-01f, -3.61087292e-01f, 1.16450816e-01f, 2.95081168e-01f, 4.41689879e-01f, 4.11814190e-02f, -9.63984728e-02f, -5.12948513e-01f, 2.62323767e-01f, 1.64063975e-01f,
  4.63987282e-03f, 4.83873516e-01f, 4.55354720e-01f, 9.06797722e-02f, -3.28892283e-02f, 9.68702435e-02f, 2.56742746e-01f, -2.83690333e-01f, -9.17364061e-02f, 1.72771305e-01f,
  3.00793499e-01f, 5.28659523e-01f, -4.62360531e-01f, 2.84483790e-01f, -2.86342502e-01f, -1.74556911e-01f, -3.42606723e-01f, -1.81750700e-01f, 1.54038817e-01f, -8.10899287e-02f,
  8.43965039e-02f, -2.46733986e-02f, -3.20418552e-02f, -9.22688767e-02f, 4.35780823e-01f, 1.63646832e-01f, -1.80968702e-01f, -9.03749764e-02f, 8.53926837e-02f, 8.06756794e-01f,
  -1.98365957e-01f, 2.65253574e-01f, 2.06034243e-01f, -4.31321591e-01f, 6.87569678e-02f, 3.76001708e-02f, 1.92399919e-01f, -3.06966931e-01f, 2.05245897e-01f, -7.93045834e-02f,
  3.74641716e-01f, 4.75873947e-02f, -1.70530125e-01f, -5.03728457e-04f, 3.65707070e-01f, -2.40639776e-01f, 4.59976047e-02f, 8.89527798e-02f, -1.92817170e-02f, 2.05492422e-01f,
  8.29299316e-02f, 8.83327648e-02f, -2.42594033e-02f, -2.36893427e-02f, 4.32481885e-01f, 3.04774567e-02f, -5.39017677e-01f, 7.97434822e-02f, -3.93200576e-01f, 3.02279323e-01f,
  -2.95625836e-01f, 7.22030550e-02f, -5.70366755e-02f, -5.35648875e-02f, -2.00613141e-02f, -8.43293294e-02f, -1.68179452e-01f, 5.66618033e-02f, 2.60282874e-01f, -2.81893685e-02f,
  -1.66382760e-01f, 3.94831151e-01f, -3.02155018e-02f, 2.67504632e-01f, 1.61594495e-01f, -8.84882510e-02f, 1.01574814e+00f, 2.25707501e-01f, 2.42397994e-01f, -1.66190490e-01f,
  1.15071613e-04f, -1.74551994e-01f, 1.80326283e-01f, 1.36567414e-01f, -1.58981591e-01f, 1.86644308e-02f, 3.12719718e-02f, 2.23247752e-01f, 2.28766173e-01f, 1.36674032e-01f,
  -4.79941368e-02f, 7.60833859e-01f, -2.83105403e-01f, 1.20461747e-01f, 1.92636505e-01f, -4.45735455e-02f, 1.42036557e-01f, -9.31350887e-02f, 6.14014678e-02f, -8.16808864e-02f,
  -9.05700102e-02f, -1.72726765e-01f, 2.10546225e-01f, 2.59141594e-01f, -2.72437066e-01f, 2.64037848e-01f, -2.45109573e-03f, 4.77734506e-01f, 2.68054586e-02f, 9.49572772e-02f,
  1.95530146e-01f, 7.54923970e-02f, -2.09624857e-01f, -1.25310808e-01f, 5.58751881e-01f, 3.77771169e-01f, -5.89986704e-02f, -4.26317781e-01f, 1.25790741e-02f, 3.20447564e-01f,
  3.76879871e-02f, -1.68281019e-01f, -2.30371907e-01f, 1.27617002e-01f, -1.29159644e-01f, -1.30412027e-01f, -6.95966780e-02f, 5.17694615e-02f, 7.39300922e-02f, -1.65297598e-01f,
  9.84123945e-02f, -1.51778057e-01f, 1.34429485e-01f, -8.08838531e-02f, -4.55129035e-02f, -1.98858958e-02f, -1.45758316e-01f, -6.49559349e-02f, -2.24306047e-01f, -1.24244295e-01f,
  1.99216500e-01f, 9.25698951e-02f, 7.41540827e-03f, 5.08825071e-02f, -8.99120583e-04f, -9.26304702e-03f, -1.74122930e-01f, -8.23868737e-02f, 9.82441567e-03f, 3.03904992e-02f,
  -1.16395473e-01f, -1.31317243e-01f, 6.70313358e-01f, 4.20903303e-02f, -8.11254978e-03f, -4.33006376e-01f, 3.42825770e-01f, 3.51913691e-01f, 2.14101952e-02f, 2.53519583e-02f,
  -4.52175699e-02f, 1.23633474e-01f, 1.97350994e-01f, 8.69056806e-02f, -3.68613265e-02f, -1.79185450e-01f, 4.23461944e-01f, 2.47944277e-02f, 3.52753788e-01f, -5.55241406e-02f,
  -1.90924034e-01f, -1.86258063e-01f, 2.08022390e-02f, 5.77050559e-02f, 3.43241841e-02f, 4.77144361e-01f, 2.32296005e-01f, 3.00807625e-01f, -4.97139953e-02f, -1.25130281e-01f,
  1.66262299e-01f, -1.23215221e-01f, 5.76340735e-01f, 5.36379106e-02f, 5.01466393e-01f, 2.68714130e-01f, 2.57163554e-01f, -1.62394434e-01f, 4.92143393e-01f, 2.91819096e-01f,
  1.69228196e-01f, -1.17519274e-01f, -1.32424384e-01f, 2.79286981e-01f, -8.14764411e-04f, -9.30881426e-02f, 1.34227619e-01f, 1.14556901e-01f, 2.35889286e-01f, -5.34155034e-02f,
  4.38425951e-02f, 3.13698826e-03f, 2.01159850e-01f, -1.09154340e-02f, -6.78733647e-01f, -7.07987100e-02f, 1.76994056e-01f, 7.31552690e-02f, 3.25029284e-01f, -1.19651578e-01f,
  4.50584553e-02f, -2.10424960e-01f, -1.79732054e-01f, -3.84113431e-01f, 3.52697223e-01f, 1.88550234e-01f, -2.03678399e-01f, -1.69624954e-01f, 4.31657843e-02f, 2.75108367e-01f,
  -3.06610674e-01f, -2.55134534e-02f, -2.60210246e-01f, 1.87410161e-01f, 2.67179370e-01f, -8.48689675e-02f, -4.99023348e-02f, -9.38777775e-02f, -1.30292000e-02f, -1.51388884e-01f,
  -1.69056609e-01f, 2.71655053e-01f, -2.37090483e-01f, 2.59604454e-01f, 2.33445182e-01f, 8.87954310e-02f, 3.85631084e-01f, -3.92655022e-02f, 1.96144536e-01f, 4.24198434e-02f,
  5.26098348e-02f, -1.86957374e-01f, 2.82987267e-01f, 2.93748111e-01f, -8.31594467e-02f, 3.25205564e-01f, -2.13238597e-01f, 2.74586350e-01f, 1.14767797e-01f, -3.61291170e-01f,
  2.60262489e-01f, -2.45699897e-01f, 2.20560148e-01f, 2.46722236e-01f, 2.29448333e-01f, -1.01804018e-01f, -2.66589284e-01f, -2.33212620e-01f, -1.87084958e-01f, 5.47665358e-03f,
  7.73607343e-02f, 3.11760306e-02f, 2.02122971e-01f, -6.83686063e-02f, 3.26494157e-01f, 1.74276412e-01f, -1.01476260e-01f, 3.43342185e-01f, 3.01539898e-01f, -2.56940216e-01f,
  -6.99927881e-02f, -2.02174917e-01f, 2.86401093e-01f, -2.72633433e-02f, 1.48619384e-01f, 3.80836159e-01f, 6.45532906e-01f, -1.13361329e-01f, -5.55066645e-01f, -2.32975036e-01f,
  -5.75170636e-01f, -8.46062526e-02f, -1.87485963e-01f, 4.74870890e-01f, -2.36745119e-01f, 2.99795359e-01f, -1.34104520e-01f, -2.23223910e-01f, 1.36511564e-01f, 7.32317865e-02f,
  1.29122585e-01f, 8.58436599e-02f, -1.70718029e-03f, 3.58027034e-02f, 2.90861335e-02f, 3.67763281e-01f, -2.47640520e-01f, -4.18266468e-02f, 1.33087216e-02f, -4.24153768e-02f,
  -3.74134451e-01f, -3.62507194e-01f, 1.80115268e-01f, 1.70784369e-01f, 6.04678951e-02f, -2.73620874e-01f, 3.01434249e-01f, 2.46653091e-02f, -5.71648479e-01f, -1.91024572e-01f,
  3.55967432e-02f, 4.34934407e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  3.13719213e-02f, 7.76932761e-02f, 4.07998979e-01f, 3.03636521e-01f, 8.39142725e-02f, 2.10506886e-01f, 1.12083726e-01f, 8.15627351e-02f, 8.19021091e-02f, 2.88816035e-01f,
  4.96584140e-02f, 2.03646734e-01f, -9.87821594e-02f, -6.79623708e-03f, 8.30359608e-02f, 1.66551083e-01f, 1.00006044e-01f, 8.64395723e-02f, -1.37932435e-01f, 1.32842213e-01f,
  7.61241242e-02f, 1.44757047e-01f, 7.08685964e-02f, -2.09639184e-02f, 3.85930657e-01f, -1.18504196e-01f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -1.95455253e-01f, -1.84026286e-01f, -3.14078033e-01f, 1.68580905e-01f, -2.68899798e-01f, -1.01848707e-01f, -1.33597046e-01f, 7.60361999e-02f, -5.65263070e-02f, -1.24233857e-01f,
  1.34610698e-01f, 3.32183599e-01f, -1.72948375e-01f, -5.77055588e-02f, 9.02976766e-02f, -8.02596882e-02f, -2.19811931e-01f, -4.96641323e-02f, 4.45039719e-02f, -5.47001287e-02f,
  -7.11279064e-02f, -1.10171840e-01f, -2.55581755e-02f, -7.65911639e-02f, 1.53500527e-01f, 1.68875698e-02f, -3.20084170e-02f, 7.54868835e-02f, 3.25073302e-01f, 2.34949309e-02f,
  -2.65793148e-02f, 2.92097367e-02f, 7.28307441e-02f, 4.18292470e-02f, -2.36419320e-01f, -4.86479670e-01f, -1.68112516e-01f, -5.65583743e-02f, -1.69181317e-01f, 1.53053440e-02f,
  2.28647497e-02f, 2.72768259e-01f, 2.62944043e-01f, -1.43140748e-01f, 2.68184450e-02f, -1.12393722e-01f, -7.78970718e-02f, 5.80740869e-02f, 6.55919686e-02f, 5.24858348e-02f,
  1.33928671e-01f, 1.08733848e-01f, 3.02636493e-02f, -2.41310194e-01f, 6.79472983e-02f, 1.20783873e-01f, -1.42377615e-01f, 3.00590158e-01f, -1.86316501e-02f, 1.60814330e-01f,
  6.19557314e-02f, -2.97152791e-02f, -2.20852289e-02f, -1.48743793e-01f, -1.91738263e-01f, 5.95087670e-02f, 2.64659128e-03f, -4.63869900e-01f, -5.62656224e-01f, 7.52480850e-02f,
  2.01496840e-01f, -1.15918048e-01f, -5.37460223e-02f, 1.62916720e-01f, 2.14139298e-01f, -4.21614870e-02f, -1.29317567e-01f, -2.26968080e-01f, -4.29655574e-02f, -1.88075490e-02f,
  -3.63156833e-02f, 5.10378703e-02f, 4.63877469e-02f, -5.54301403e-02f, -1.22701451e-01f, -4.24554825e-01f, -1.43557921e-01f, -4.66824183e-03f, -1.12277493e-02f, -3.40632983e-02f,
  6.82474524e-02f, 1.41756400e-01f, 6.21952713e-02f, 1.82139464e-02f, 7.52129708e-05f, -2.35622786e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  5.32887876e-01f, 7.93991536e-02f, 5.76554462e-02f, 4.35144380e-02f, -9.83245373e-01f, -3.59666228e-01f, 2.16299027e-01f, -8.94487798e-02f, 4.38207507e-01f, 8.31308514e-02f,
  3.43694426e-02f, 4.22406435e-01f, -1.62877753e-01f, 1.35803863e-01f, 2.46358052e-01f, 2.24537805e-01f, 3.68048966e-01f, 1.89240411e-01f, 2.81725317e-01f, -1.79305360e-01f,
  5.00820093e-02f, 3.67295444e-02f, 3.03746641e-01f, -2.59235114e-01f, -1.18679367e-01f, -9.89691317e-02f, -2.05140896e-02f, 2.57032752e-01f, 3.47403765e-01f, -6.23052530e-02f,
  -1.18866228e-01f, 2.05080286e-01f, -8.35352838e-02f, -1.70580938e-01f, 7.16359615e-02f, -1.31612450e-01f, 3.81555408e-02f, -7.11484700e-02f, 4.81744809e-03f, -1.66450739e-01f,
  -2.61103101e-02f, -4.86428365e-02f, -1.20587207e-01f, 4.55046855e-02f, -2.00201944e-02f, -5.98160699e-02f, 1.61912590e-02f, -1.36491075e-01f, -1.34921044e-01f, -6.98440894e-02f,
  -8.90537631e-03f, -1.29828393e-01f, 6.57590106e-02f, -1.13204494e-01f, 5.61506003e-02f, -1.53454021e-01f, -7.93245584e-02f, -2.94622276e-02f, -5.17462566e-02f, -1.03631236e-01f,
  1.44056659e-02f, 1.58872753e-02f, -3.07991039e-02f, -9.90703818e-04f, -3.41647983e-01f, 2.44157955e-01f, 1.04316823e-01f, 1.33036999e-02f, 4.98480320e-01f, 2.76768774e-01f,
  -1.78385466e-01f, 1.02446694e-02f, -2.86601305e-01f, -2.97538210e-02f, -1.56783000e-01f, -5.85584156e-02f, 3.28989863e-01f, 1.47044539e-01f, -2.03562409e-01f, -4.80967499e-02f,
  4.58412580e-02f, 1.15967937e-01f, 1.30542502e-01f, 5.03985107e-01f, 3.72518927e-01f, 1.66074902e-01f, -1.19322345e-01f, 4.23608154e-01f, -9.95828584e-02f, 6.91480190e-02f,
  1.81850895e-01f, 5.90586066e-02f, 1.26500234e-01f, 7.87576661e-02f, -9.78191867e-02f, -1.81066886e-01f, 3.89407903e-01f, 1.18136883e-01f, 7.92858601e-01f, -6.76499784e-01f,
  8.84818882e-02f, 1.23986132e-01f, 1.05518080e-01f, 8.41256008e-02f, 9.05785412e-02f, -4.74490225e-01f, -2.66830742e-01f, 2.08480462e-01f, 7.65924826e-02f, -1.15337297e-01f,
  2.24682927e-01f, 6.52207236e-04f, -2.70438880e-01f, -1.66105241e-01f, -1.32187694e-01f, 3.07328850e-01f, -1.01839021e-01f, 1.77142531e-01f, -1.64630443e-01f, -9.10027102e-02f,
  2.56544918e-01f, 2.25216329e-01f, -2.15193648e-02f, 3.58417146e-02f, 1.55118391e-01f, -6.72336221e-02f, 4.77775216e-01f, 3.49082470e-01f, -5.18432558e-01f, 2.53569990e-01f,
  -2.15010256e-01f, 3.60251009e-01f, -1.96901068e-01f, -3.72980863e-01f, 2.47635409e-01f, 1.59835413e-01f, 4.57914233e-01f, 2.09028065e-01f, 3.47408354e-01f, 1.88656300e-01f,
  9.18947458e-02f, 2.11583488e-02f, 2.18313381e-01f, -5.57752736e-02f, 2.24659413e-01f, 2.91492134e-01f, 4.83125262e-02f, 3.82561907e-02f, 8.68856609e-02f, -7.39033595e-02f,
  1.86410412e-01f, 4.82372977e-02f, -8.44195262e-02f, -7.51747414e-02f, 1.30629063e-01f, 7.02889040e-02f, -2.57040765e-02f, -2.23736048e-01f, -2.30170367e-03f, -1.69778734e-01f,
  2.63817638e-01f, 2.44420022e-01f, -4.55432475e-01f, 2.85135001e-01f, -4.31862086e-01f, -4.84263837e-01f, -2.88387597e-01f, 8.62177238e-02f, 1.05271481e-01f, 2.24605352e-01f,
  3.55664385e-03f, -5.70024624e-02f, 7.07566515e-02f, 2.85758644e-01f, -3.22659880e-01f, -3.10811907e-01f, 8.98115784e-02f, 4.32349443e-01f, 1.84714407e-01f, -5.56827009e-01f,
  -2.34868258e-01f, 1.99611574e-01f, 5.18168807e-01f, -2.99978822e-01f, -1.05009601e-01f, 1.10056266e-01f, -4.16224338e-02f, -8.17293003e-02f, -6.90473095e-02f, 7.86407590e-02f,
  -3.54689538e-01f, -2.71402538e-01f, -2.49399155e-01f, 3.96203041e-01f, 2.03276664e-01f, 5.23745894e-01f, 6.30294979e-01f, 9.13941339e-02f, -3.55244458e-01f, 2.22551487e-02f,
  -2.06399649e-01f, 3.54857653e-01f, -1.80251300e-02f, -1.52715430e-01f, 3.61420840e-01f, 2.21478611e-01f, -3.30038667e-01f, -7.62623623e-02f, -5.83856553e-02f, 1.56765074e-01f,
  7.83159435e-02f, 1.78589523e-01f, 1.68209627e-01f, 4.75200683e-01f, 7.65076652e-02f, 3.22806120e-01f, -6.02042452e-02f, 4.49092127e-03f, -1.44344091e-01f, 8.14049765e-02f,
  -5.30316770e-01f, 1.13843299e-01f, 2.58486897e-01f, -3.78584504e-01f, -5.54596663e-01f, 9.87642724e-03f, -6.42938465e-02f, 4.90199327e-01f, 7.86629617e-01f, 5.09777904e-01f,
  7.94162527e-02f, 2.57518977e-01f, -3.48020643e-01f, 1.47305846e-01f, -2.96002012e-02f, -2.10023914e-02f, 2.94041127e-01f, 2.65708745e-01f, 1.48783639e-01f, -1.22263998e-01f,
  -2.44191855e-01f, -1.06859170e-01f, 1.32928878e-01f, 2.50762433e-01f, -1.58183221e-02f, -1.68505982e-01f, 1.05958819e-01f, -1.44945839e-02f, 1.63606226e-01f, 2.12069554e-03f,
  1.93001628e-01f, 1.54967988e-02f, 2.34759711e-02f, 1.66041970e-01f, 2.27348983e-01f, 3.83099735e-01f, 4.86986220e-01f, 1.13378070e-01f, 3.17640424e-01f, -2.00715050e-01f,
  -2.09889993e-01f, -2.43203014e-01f, -2.02878922e-01f, -9.49728787e-02f, 3.51515204e-01f, 2.10627541e-01f, -1.97331905e-01f, 6.37327880e-02f, 9.01277363e-02f, 1.31008759e-01f,
  -1.09484576e-01f, 2.58820504e-01f, -4.45107184e-02f, -1.41209871e-01f, -1.16974361e-01f, -5.64859845e-02f, -9.70826223e-02f, 8.91327485e-02f, -1.37186646e-02f, 1.72951862e-01f,
  -2.07893103e-01f, 1.56794727e-01f, -1.64877847e-01f, 2.60153025e-01f, 7.73333386e-02f, -4.10361588e-02f, -2.77081244e-02f, -4.01550442e-01f, -4.36980613e-02f, 2.71458119e-01f,
  2.73698092e-01f, -5.56939065e-01f, -3.24350178e-01f, -1.14373393e-01f, 1.72980711e-01f, -1.59273937e-01f, 2.82716662e-01f, 1.03977479e-01f, 3.86905313e-01f, 3.26877683e-02f,
  -1.36071384e-01f, -3.42960000e-01f, 2.07416385e-01f, -7.94881433e-02f, 3.49661350e-01f, 2.22763389e-01f, 3.55462879e-01f, -3.55238914e-01f, -9.79811475e-02f, -8.70076045e-02f,
  2.85076071e-02f, -2.60232270e-01f, 3.68511975e-02f, -3.47212017e-01f, -1.68870449e-01f, -2.54392505e-01f, 1.44008249e-01f, 1.22965507e-01f, 2.99324542e-01f, 9.13367569e-02f,
  -3.19604635e-01f, 3.98199223e-02f, 1.78189561e-01f, 5.63287139e-01f, 4.15794671e-01f, 4.00855877e-02f, -1.55735284e-01f, 1.36444703e-01f, 2.57941723e-01f, -2.71815687e-01f,
  3.52447659e-01f, 1.10184766e-01f, 2.91760731e-02f, 1.20864496e-01f, -8.15570503e-02f, -9.67942402e-02f, 2.76912153e-01f, 3.77343863e-01f, 1.95524767e-02f, 3.09539109e-01f,
  5.59260130e-01f, 9.25132036e-02f, -2.70995706e-01f, 1.00573130e-01f, 3.57880116e-01f, -3.45645249e-01f, -1.03898332e-01f, 6.68865293e-02f, -1.75474361e-01f, 1.20545670e-01f,
  -2.86225528e-01f, -1.03151724e-01f, -4.39165711e-01f, -1.88899815e-01f, 4.55707133e-01f, -3.43887001e-01f, 5.30739129e-01f, -6.11280501e-01f, -5.47382124e-02f, 3.75172228e-01f,
  1.35709286e-01f, 5.12322009e-01f, -1.21558443e-01f, -8.47918615e-02f, 4.01680499e-01f, 1.78343683e-01f, 3.42857093e-02f, 6.84135361e-03f, -2.00914983e-02f, -1.98415220e-01f,
  -3.35156024e-02f, 1.90650880e-01f, -1.38309356e-02f, -5.52737750e-02f, 3.64618868e-01f, 2.38736004e-01f, 2.59686410e-01f, 5.31096339e-01f, -1.55967057e-01f, -2.78079271e-01f,
  -2.16208830e-01f, 3.11657608e-01f, 2.32460007e-01f, 6.48664460e-02f, -1.48760244e-01f, 8.89857188e-02f, 3.39968614e-02f, 9.17644054e-02f, 5.95556386e-02f, 1.53228924e-01f,
  -3.29678953e-02f, -3.57685000e-01f, 2.33564675e-01f, 1.92539617e-01f, 2.18309805e-01f, -4.70120221e-01f, -3.04944456e-01f, -1.63554728e-01f, 6.72792569e-02f, -3.75810921e-01f,
  1.60213172e-01f, 2.63251692e-01f, -6.69171512e-02f, -1.04717642e-01f, 3.55218381e-01f, 3.28256667e-01f, -1.45096537e-02f, 2.46131986e-01f, 3.75412881e-01f, 1.98429432e-02f,
  -6.67193756e-02f, 9.63788107e-02f, -6.24001741e-01f, 2.33911976e-01f, 3.47212076e-01f, 1.27617359e-01f, -5.43898284e-01f, 1.58088237e-01f, -1.82956487e-01f, 1.43681198e-01f,
  -7.22659230e-01f, -3.67778093e-02f, 1.22251213e-01f, -4.46588546e-02f, 2.81377614e-01f, -2.84592420e-01f, 4.11192656e-01f, 3.32937747e-01f, 1.12187877e-01f, 1.80893064e-01f,
  2.51569208e-02f, 1.74784526e-01f, 2.02645093e-01f, 5.57543695e-01f, 3.52973133e-01f, 1.13501437e-01f, 3.73141617e-01f, -3.01802576e-01f, 7.65290186e-02f, 2.32687131e-01f,
  1.42750502e-01f, -2.40613684e-01f, -3.41013595e-02f, 4.14528638e-01f, 1.32450029e-01f, -1.59867093e-01f, -1.55363187e-01f, 1.29447564e-01f, -9.00587589e-02f, 8.19177702e-02f,
  -2.89567262e-02f, -9.51610208e-02f, 1.53896242e-01f, -5.52914105e-03f, -1.61531672e-01f, 8.66201818e-02f, -8.93841758e-02f, 2.63107033e-03f, 9.50507168e-03f, 1.45521030e-01f,
  -1.51971266e-01f, -1.91589117e-01f, -1.24463454e-01f, -1.47214636e-01f, -2.77288016e-02f, -5.85227273e-02f, -1.80755123e-01f, 2.37615764e-01f, -1.52820453e-01f, -9.21534076e-02f,
  -1.30969375e-01f, 1.68608546e-01f, 1.25196902e-03f, -2.27487832e-02f, -5.52885495e-02f, -9.44007561e-02f, 7.93208331e-02f, -1.28162578e-01f, 1.47429202e-02f, 1.90872774e-02f,
  1.38719589e-01f, -2.03222871e-01f, -1.39887035e-01f, -2.38653243e-01f, 2.74588138e-01f, 2.85310328e-01f, -1.98483884e-01f, 2.09864810e-01f, -3.54150563e-01f, -1.63749829e-01f,
  -1.45815194e-01f, 2.13465944e-01f, 9.86694321e-02f, 1.04137950e-01f, -3.95770133e-01f, 1.56092048e-01f, -3.88987988e-01f, 6.15745522e-02f, -2.18709469e-01f, 5.41631460e-01f,
  3.19084734e-01f, -2.97128201e-01f, -1.26030281e-01f, 2.75527805e-01f, 4.17780548e-01f, 3.33268881e-01f, -1.60199963e-02f, 1.36241436e-01f, 1.13397442e-01f, 4.66849357e-02f,
  -2.68292785e-01f, 4.55306351e-01f, 4.29510623e-02f, -5.99520914e-02f, -2.16543585e-01f, 1.64419860e-02f, -1.39614984e-01f, 1.86202347e-01f, 1.62196115e-01f, -2.64414568e-02f,
  -9.29301232e-02f, 9.61096212e-03f, -8.62439573e-02f, 4.51200679e-02f, 1.31017894e-01f, 7.57164462e-03f, -1.70331419e-01f, -2.26230621e-01f, -2.26106822e-01f, -1.70443639e-01f,
  -1.10744618e-01f, -4.75165900e-03f, -2.07950361e-02f, 3.85734886e-02f, -1.46190226e-01f, -8.50820467e-02f, 1.48329446e-02f, 8.81423578e-02f, 1.21798195e-01f, 6.90670758e-02f,
  -2.45543614e-01f, -6.91658333e-02f, 1.43708527e-01f, -3.80718871e-03f, 3.50385666e-01f, 3.51560801e-01f, 1.66903004e-01f, -2.77715296e-01f, -6.82487369e-01f, 5.09470224e-01f,
  1.87448665e-01f, -3.53832245e-02f, -8.20321813e-02f, 3.69192585e-02f, 5.35454601e-02f, 2.77927011e-01f, 2.37568364e-01f, -2.50805914e-02f, 3.66165072e-01f, 4.69529152e-01f,
  2.14050129e-01f, -2.49749228e-01f, 2.33336344e-01f, -1.53712705e-01f, -2.45696068e-01f, 2.45811105e-01f, -3.25391293e-02f, 3.45394582e-01f, -3.65712464e-01f, -1.66509673e-01f,
  -8.99999961e-02f, 5.28104544e-01f, 4.20961350e-01f, -1.22736350e-01f, 4.79617029e-01f, -1.23173058e-01f, -5.40529080e-02f, -6.31279275e-02f, -1.52851909e-01f, -3.12102083e-02f,
  -1.16662167e-01f, 1.12142339e-01f, 1.17915168e-01f, -2.03511119e-01f, 7.64412954e-02f, -2.93269902e-02f, -1.82461336e-01f, -4.95450012e-02f, 2.33284440e-02f, -1.23091683e-01f,
  -1.19534828e-01f, 1.42561436e-01f, -6.84837028e-02f, -7.89288506e-02f, -9.73772556e-02f, 7.86214992e-02f, -2.65303534e-02f, 1.24473549e-01f, -1.41165093e-01f, -4.35606353e-02f,
  2.07783300e-02f, -1.13491870e-01f, -4.91523482e-02f, -5.14400285e-03f, -1.82219416e-01f, -1.77652821e-01f, -9.53195617e-02f, -1.11884415e-01f, 1.38484731e-01f, 7.27636442e-02f,
  -5.01540780e-01f, 5.08910835e-01f, -2.03308910e-02f, -1.45359099e-01f, 3.25425677e-02f, 8.89977291e-02f, 1.11848988e-01f, -6.63627014e-02f, -2.48512197e-02f, 5.99794388e-02f,
  2.20287129e-01f, 1.91050380e-01f, 5.04589081e-02f, -1.29968777e-01f, 4.09163721e-03f, 2.00469300e-01f, 2.65635431e-01f, -5.16191781e-01f, -4.35051806e-02f, 3.45009595e-01f,
  5.17750144e-01f, -3.30769092e-01f, 4.43967320e-02f, 1.04982533e-01f, 5.25520183e-03f, -5.60239665e-02f, -1.02747865e-01f, 1.78920552e-01f, -4.70854223e-01f, -7.00962357e-03f,
  1.90056697e-01f, -7.06821075e-03f, -6.42886087e-02f, -2.09549531e-01f, 3.26498777e-01f, 4.89043355e-01f, -3.28954421e-02f, -1.06517360e-01f, -2.18739837e-01f, -2.03655064e-01f,
  8.59558303e-03f, 1.39882937e-01f, 1.88886970e-01f, 2.54828054e-02f, -2.29646906e-01f, 1.63738742e-01f, -2.34225899e-01f, -1.67452574e-01f, 7.56662013e-03f, -1.13755986e-02f,
  -7.57947192e-02f, -2.69151896e-01f, -7.28213862e-02f, 2.12700397e-01f, 1.25419423e-01f, -2.43954323e-02f, 1.68746531e-01f, -9.36941430e-03f, -9.04213488e-02f, 2.20408380e-01f,
  2.82813668e-01f, 1.90451339e-01f, -1.63978323e-01f, -2.37117156e-01f, 5.70955217e-01f, 5.45242196e-03f, 4.24981564e-01f, -3.26158345e-01f, -4.62376177e-02f, 3.96021068e-01f,
  1.53672144e-01f, 1.58884153e-01f, -6.70846403e-02f, -7.27396235e-02f, 6.82751164e-02f, 1.68702617e-01f, 1.70912877e-01f, -2.34717820e-02f, -1.56444833e-01f, 1.73577815e-02f,
  -2.17258096e-01f, 8.35125521e-02f, 1.11960303e-02f, 7.79788792e-02f, 2.45107897e-03f, -6.35463148e-02f, 5.39866328e-01f, 3.02338183e-01f, -4.05448023e-03f, -1.55973807e-01f,
  -5.99215664e-02f, 4.25050110e-01f, 3.06966990e-01f, 5.63274026e-01f, 2.13555485e-01f, 5.63660227e-02f, 3.05602491e-01f, 5.52803129e-02f, -4.49965335e-02f, 2.39249811e-01f,
  5.40015996e-01f, -1.12856522e-01f, -8.00253153e-02f, -2.05584168e-01f, -6.65298253e-02f, 1.64918840e-01f, 1.39797136e-01f, 9.01970863e-02f, 4.73843843e-01f, 4.01066810e-01f,
  7.38940611e-02f, -1.21593833e-01f, 1.86752483e-01f, -1.15987942e-01f, 1.34194463e-01f, 1.91434279e-01f, -1.00657173e-01f, 2.16001183e-01f, -9.33875516e-02f, -1.11661144e-01f,
  6.77072629e-02f, 3.14268619e-01f, -8.32063425e-03f, -7.28672296e-02f, 4.50987428e-01f, -9.82236266e-02f, 1.12310110e-03f, 2.22544625e-01f, 5.74327037e-02f, 5.49231648e-01f,
  2.66521096e-01f, 3.44252646e-01f, -1.42360274e-02f, 2.88649112e-01f, -3.63805205e-01f, -3.61277126e-02f, -1.91758499e-01f, 1.49828359e-01f, 2.70450145e-01f, 2.51084745e-01f,
  -2.33312417e-02f, 2.01135889e-01f, -2.33634695e-01f, -8.93638209e-02f, -1.33953495e-02f, 4.40495342e-01f, 1.59444496e-01f, 3.20971757e-02f, -7.12306052e-02f, 3.25278074e-01f,
  -1.69191003e-01f, -3.11982539e-02f, 2.44297415e-01f, 2.25571200e-01f, 2.08486050e-01f, 2.16717184e-01f, -2.16330141e-01f, 4.64425143e-03f, 3.15943450e-01f, 3.79509419e-01f,
  -2.55349785e-01f, -4.26233672e-02f, 1.50274048e-02f, -3.58145684e-01f, 6.23545162e-02f, 2.89138138e-01f, -9.36542973e-02f, 4.82189089e-01f, 3.26697156e-02f, -1.35382950e-01f,
  3.75567496e-01f, 3.05399060e-01f, 1.42877148e-02f, -1.30104303e-01f, 1.92612596e-02f, 2.42670961e-02f, 1.63466603e-01f, -3.25646758e-01f, -2.15004861e-01f, 3.92067134e-01f,
  4.27914560e-01f, -2.39574865e-01f, -4.02693227e-02f, 3.39529552e-02f, 3.17600518e-02f, -9.26451236e-02f, -1.66689605e-01f, 6.14092574e-02f, 7.76552707e-02f, 1.15601167e-01f,
  3.22676659e-01f, 1.37258843e-01f, -2.20631465e-01f, 4.03030366e-01f, -2.21010655e-01f, 2.42582425e-01f, -7.54487738e-02f, -4.98106666e-02f, -3.29203233e-02f, -9.34851840e-02f,
  -5.73410057e-02f, 4.09694165e-01f, -4.75535914e-03f, 1.53250530e-01f, -3.39849591e-01f, 3.18323493e-01f, 8.84059723e-03f, 1.41535819e-01f, -1.28523439e-01f, 2.43365299e-02f,
  2.42395699e-01f, -9.80523881e-03f, 1.77323911e-02f, 3.35857183e-01f, -2.16625690e-01f, 2.14835063e-01f, 8.44647437e-02f, 4.84545857e-01f, 3.38360339e-01f, 4.35907505e-02f,
  -4.44975376e-01f, 5.57952598e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  8.37669596e-02f, -6.19828179e-02f, 1.41855806e-01f, 1.70877159e-01f, -8.29276368e-02f, 7.97259733e-02f, 1.80287972e-01f, -2.78110147e-01f, 1.30392551e-01f, 6.31783009e-02f,
  1.04572490e-01f, 3.67083043e-01f, 1.46249188e-02f, -8.66705999e-02f, -1.54599249e-01f, 1.22909702e-01f, 1.10150687e-01f, -1.25803947e-01f, 1.32641390e-01f, -1.63610443e-01f,
  -8.45088251e-03f, 1.37963742e-01f, -1.66807458e-01f, -2.64003545e-01f, -1.09897897e-01f, 1.34882540e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -7.73062408e-02f, 5.77406585e-02f, 1.81891859e-01f, 9.26959291e-02f, 2.84200102e-01f, -3.97990108e-01f, -2.96939105e-01f, -1.65329605e-01f, 4.34636250e-02f, -5.77958882e-01f,
  -2.19857171e-01f, 1.01096421e-01f, 8.92823189e-02f, 2.13290662e-01f, -2.24929914e-01f, -1.49283499e-01f, -1.23189585e-02f, -2.31241323e-02f, -8.91018882e-02f, -1.86792448e-01f,
  -9.09263641e-02f, 2.23738268e-01f, 8.11526850e-02f, -2.42605329e-01f, 5.35088480e-02f, 2.10874081e-01f, 9.01353657e-02f, 1.03621423e-01f, -5.60621358e-02f, 1.95271656e-01f,
  1.35371193e-01f, 4.16869521e-02f, -1.92125693e-01f, 2.43458495e-01f, -1.77265972e-01f, 6.41326725e-01f, 1.68963134e-01f, 2.77235508e-01f, -2.42218643e-01f, -1.31243005e-01f,
  1.92086741e-01f, 2.97236711e-01f, -1.14827089e-01f, -1.23073265e-01f, -1.38275847e-01f, 5.71577176e-02f, -1.16889447e-01f, 3.44436914e-02f, 7.47138262e-02f, -4.63171378e-02f,
  -3.95206422e-01f, 1.95634328e-02f, 4.99516912e-02f, 1.33693293e-01f, -3.32193971e-02f, -4.39490154e-02f, -1.63422406e-01f, -2.82175064e-01f, 1.39599741e-01f, 2.21077964e-01f,
  1.03420667e-01f, 1.78555489e-01f, -5.20711839e-01f, -5.89081682e-02f, 3.71600129e-02f, 2.09659502e-01f, 4.20296937e-01f, 4.62098539e-01f, -1.09053850e-01f, -4.73737210e-01f,
  2.67728388e-01f, 4.04812694e-02f, -3.59856248e-01f, 6.83230758e-02f, 1.24068841e-01f, 4.11616981e-01f, -9.31280494e-01f, -3.88022631e-01f, 2.05670327e-01f, -2.37405092e-01f,
  -3.44493181e-01f, 1.40973493e-01f, -4.52737659e-01f, 1.25168562e-02f, -1.30107373e-01f, 1.21945769e-01f, -1.14219233e-01f, -2.06884012e-01f, 6.59755291e-03f, 2.80963749e-01f,
  -1.93078592e-01f, 1.07545204e-01f, -4.56304461e-01f, -3.18235338e-01f, 4.10737246e-02f, -5.01763169e-03f, -3.07473183e-01f, -4.52634133e-02f, -9.48975980e-02f, -2.14791577e-02f,
  1.08408853e-01f, -1.64136410e-01f, -3.04385275e-01f, -8.84299055e-02f, -6.59442600e-03f, -2.59790510e-01f, 1.17226355e-01f, 2.46466175e-01f, 2.46633321e-01f, 3.82693186e-02f,
  5.31772152e-02f, -1.17118374e-01f, -1.71092406e-01f, 2.50610858e-01f, -4.87756580e-02f, -5.09846509e-01f, 9.69650000e-02f, -4.27875668e-01f, -1.69428870e-01f, -3.48753393e-01f,
  1.10219210e-01f, -6.63493853e-03f, -1.57214224e-01f, 1.14438623e-01f, -2.97778159e-01f, -2.38674849e-01f, 1.67457178e-01f, -7.84085214e-01f, -6.08473197e-02f, -3.29412878e-01f,
  -4.82517153e-01f, -7.77782977e-01f, -3.70231450e-01f, -1.71887636e-01f, 1.55622602e-01f, -1.65610582e-01f, -3.11226081e-02f, -1.03188613e-02f, 1.22330207e-02f, 2.34175682e-01f,
  8.32355674e-03f, -8.79871622e-02f, 1.24925815e-01f, -3.67938340e-01f, -1.75299615e-01f, -6.98241889e-02f, -3.91950846e-01f, -1.30285263e-01f, -2.14074180e-01f, -1.84556976e-01f,
  -1.64474800e-01f, 1.79654464e-01f, -1.54042006e-01f, 2.16985106e-01f, -9.33560506e-02f, 5.40856458e-02f, 1.36536345e-01f, 7.81292170e-02f, 1.27979413e-01f, -3.48557904e-02f,
  1.08184956e-01f, -2.01176569e-01f, -4.02311794e-02f, 3.95364650e-02f, -4.57334816e-01f, -6.12293243e-01f, -1.76985025e-01f, 2.10710224e-02f, 2.43585050e-01f, -6.19579554e-01f,
  1.98225901e-01f, -2.96973079e-01f, 1.45807371e-01f, -1.72698453e-01f, 1.18683264e-01f, -4.23166454e-01f, 2.50956595e-01f, -1.56159967e-01f, 5.57346232e-02f, 1.39709368e-01f,
  -2.21235365e-01f, -7.77086988e-02f, -1.81605071e-01f, 3.22120637e-02f, -1.90412195e-03f, -1.94020465e-01f, -1.69405580e-01f, -2.02546865e-01f, 1.28414050e-01f, 1.19953617e-01f,
  -3.86429280e-01f, 1.74184456e-01f, 2.29708925e-01f, -8.58326703e-02f, -5.67438044e-02f, 2.80332714e-01f, 4.28742915e-01f, 1.22347876e-01f, 3.20332408e-01f, -1.54645279e-01f,
  -4.01317030e-01f, -4.68937129e-01f, 1.68904334e-01f, 7.96675831e-02f, -5.99030018e-01f, -9.00036171e-02f, -2.66346991e-01f, 2.83015817e-01f, 1.57421425e-01f, -7.77744472e-01f,
  -1.72123332e-02f, 7.78249875e-02f, -1.64432853e-01f, -3.27393055e-01f, -1.75301433e-01f, -7.65376911e-02f, -1.62540227e-01f, 5.06046787e-02f, -3.04140598e-01f, -4.81824309e-01f,
  1.18173912e-01f, -3.31369162e-01f, -3.10083479e-01f, 7.59312361e-02f, -3.27082634e-01f, 5.93608357e-02f, -2.53762722e-01f, -2.97021359e-01f, -4.77220640e-02f, 1.16844125e-01f,
  1.19775832e-01f, -1.95841230e-02f, -5.43549836e-01f, 2.46824712e-01f, 1.09771401e-01f, -6.08407915e-01f, -1.19686492e-01f, 3.41929495e-02f, -2.35105321e-01f, 2.06303790e-01f,
  -1.51427845e-02f, -1.55333489e-01f, 5.74115455e-01f, 1.21242918e-01f, -1.32373810e-01f, -1.26861721e-01f, 3.73425037e-02f, -6.87245727e-02f, 1.32594883e-01f, -4.75557595e-01f,
  -2.48081610e-01f, 1.91713095e-01f, -1.16847372e-02f, -1.36471316e-01f, -4.91526097e-01f, -1.67702243e-01f, 2.15517431e-01f, 4.74307500e-02f, 2.34275848e-01f, 2.94284314e-01f,
  5.21747768e-01f, 4.34975922e-01f, 8.52335989e-02f, -1.45777240e-01f, 4.56451066e-02f, 2.70324260e-01f, -3.56506526e-01f, -3.09700459e-01f, -8.00038993e-01f, -6.40588105e-01f,
  3.15058827e-01f, -2.71843284e-01f, -5.37272513e-01f, -6.64261937e-01f, 7.81975687e-02f, -6.34456351e-02f, 1.98705256e-01f, 1.35523051e-01f, -1.49105266e-01f, 3.45191956e-01f,
  -1.31092072e-01f, -2.59157062e-01f, 9.98726711e-02f, -3.23759198e-01f, 1.29202351e-01f, 7.08066626e-03f, -4.39477533e-01f, 3.43973786e-01f, 3.96289118e-02f, 2.86214679e-01f,
  2.93331623e-01f, 1.45171294e-02f, -1.81932911e-01f, -3.81151177e-02f, -4.70312592e-03f, -9.31896120e-02f, -7.40646645e-02f, 6.18537925e-02f, 6.82619810e-02f, 2.99430132e-01f,
  1.84761822e-01f, -9.56669211e-01f, -2.87102282e-01f, 1.63785756e-01f, 3.14377517e-01f, -2.45602235e-01f, 2.35610321e-01f, 1.31883875e-01f, 1.09191284e-01f, -4.41684350e-02f,
  -3.58374715e-02f, -4.20295089e-01f, 4.50304486e-02f, 4.57582138e-02f, -1.37957454e-01f, -2.96967775e-02f, -4.76285040e-01f, -4.94005382e-01f, 8.97595659e-02f, -1.13949619e-01f,
  3.83847028e-01f, -6.44300133e-02f, -5.22664607e-01f, -7.88290262e-01f, -3.78765523e-01f, -4.25778508e-01f, -7.97005534e-01f, -3.43248993e-02f, 3.40762287e-02f, 2.36144081e-01f,
  -7.64146566e-01f, -2.02181652e-01f, 1.53934315e-01f, -5.77894412e-02f, 2.49334395e-01f, -4.01090711e-01f, -2.86249906e-01f, 3.11484993e-01f, -3.21839094e-01f, -1.16749084e+00f,
  -2.72356812e-02f, 1.88388079e-01f, 1.98094711e-01f, -4.29355681e-01f, -1.41688764e-01f, -1.06581353e-01f, 1.74304955e-02f, 3.44161928e-01f, -3.01776221e-03f, -9.81826684e-04f,
  -1.13008164e-01f, -3.15632559e-02f, 4.54468638e-01f, -1.32783353e-01f, -1.38780266e-01f, -1.63188323e-01f, -2.36257948e-02f, 2.28081793e-01f, -6.92488849e-02f, 5.60633987e-02f,
  -9.39447358e-02f, -8.61503067e-04f, 7.09398016e-02f, -3.82607251e-01f, -1.80758715e-01f, -1.03042841e-01f, -3.13724354e-02f, 2.15375677e-01f, -6.08799219e-01f, 1.59928858e-01f,
  -5.30451119e-01f, -4.01626676e-02f, 1.06890082e-01f, -3.77158374e-01f, -1.20707169e-01f, 4.26691025e-01f, -1.74180865e-01f, -3.55136484e-01f, 1.18752539e-01f, -2.36670703e-01f,
  2.43037879e-01f, -1.63159460e-01f, 2.89392233e-01f, -4.32660371e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -4.50065106e-01f, -4.09746170e-02f, 9.72838700e-02f, 1.33740693e-01f, 1.43170625e-01f, -2.04535469e-01f, -7.80100897e-02f, 1.57263488e-01f, 8.74734446e-02f, 4.19948474e-02f,
  3.12143229e-02f, 2.01194752e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    