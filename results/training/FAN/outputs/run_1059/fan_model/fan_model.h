/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.69456148e-01f, -3.48487735e-01f, 3.29757594e-02f, -1.00923076e-01f, 1.02195375e-01f, 2.27522179e-01f, 6.71844333e-02f, -9.05538723e-02f, -1.33063942e-01f, -1.24240533e-01f,
  -1.66664124e-01f, 2.54481076e-03f, 1.24432191e-01f, 2.06418097e-01f, 2.19859824e-01f, 5.07175475e-02f, 6.30833805e-02f, 2.33217835e-01f, 3.52733910e-01f, 1.15239613e-01f,
  -4.84276708e-04f, -1.68834656e-01f, -1.77017242e-01f, -1.51927963e-01f, -3.78689885e-01f, -7.07366830e-03f, -1.60954386e-01f, -1.14187069e-01f, -7.47214928e-02f, -2.11818889e-01f,
  -1.44969210e-01f, -3.04807633e-01f, 1.60887375e-01f, -4.58065048e-03f, -1.65414825e-01f, -1.04142562e-01f, -6.46939948e-02f, -1.06736012e-01f, -1.83731914e-02f, -9.96855646e-02f,
  -4.65292521e-02f, -1.01047292e-01f, -1.21212676e-01f, -1.16095185e-01f, -1.25124753e-01f, -1.91231389e-02f, -6.07894994e-02f, -4.20986377e-02f, 6.36128709e-02f, -1.80463210e-01f,
  -1.29657060e-01f, -6.54280111e-02f, -5.20924628e-02f, -5.18496037e-02f, 3.13065127e-02f, 9.36214253e-02f, -1.60704672e-01f, -1.11484304e-01f, 9.41318125e-02f, -2.74841130e-01f,
  7.58237615e-02f, 5.89570142e-02f, 7.85976201e-02f, -4.56987880e-02f, 1.80400126e-02f, 7.00749233e-02f, -2.79688966e-02f, -2.79448871e-02f, 8.51934180e-02f, -1.06113806e-01f,
  8.04626718e-02f, 8.60206559e-02f, -5.33435028e-03f, 8.50622915e-03f, 7.17038661e-02f, -3.11007686e-02f, 1.58418827e-02f, -5.02132364e-02f, -1.18182488e-02f, -3.36114205e-02f,
  5.66057339e-02f, 8.12253170e-03f, -2.80164126e-02f, -2.20121816e-02f, -2.45732646e-02f, 1.13285340e-01f, 2.41938606e-02f, 2.49420013e-02f, -4.68179490e-03f, -2.69434042e-02f,
  -2.33082414e-01f, 2.15756357e-01f, -1.09744988e-01f, -1.58473685e-01f, -4.07109000e-02f, -4.75314409e-02f, -1.06365472e-01f, -4.09247801e-02f, -9.86810252e-02f, -8.01599771e-02f,
  -1.01019375e-01f, -2.53166873e-02f, -3.51866521e-02f, -4.77572754e-02f, -1.05363699e-02f, -6.74467012e-02f, -1.24467336e-01f, 3.44734900e-02f, 3.79732139e-02f, -2.04896256e-01f,
  -5.14211655e-02f, 5.96146733e-02f, 7.70435333e-02f, 7.00329915e-02f, -4.88931164e-02f, 1.36953324e-01f, 3.25046815e-02f, -7.12484568e-02f, 1.38613537e-01f, -7.94610530e-02f,
  8.79484564e-02f, -3.49613167e-02f, -6.94618970e-02f, 1.00467473e-01f, 2.73262709e-01f, 2.06328973e-01f, 1.87703837e-02f, 8.23081136e-02f, 1.78811222e-01f, 6.76017553e-02f,
  1.44379199e-01f, 1.03713959e-01f, 5.63195273e-02f, -1.32948041e-01f, -2.37652466e-01f, -1.58489823e-01f, -2.23803923e-01f, -1.49848968e-01f, 7.53333941e-02f, 1.92605734e-01f,
  8.93393978e-02f, 5.94748519e-02f, -1.10416256e-01f, 3.40030086e-03f, 5.92204034e-02f, -1.90644874e-03f, -1.21093608e-01f, 6.18932210e-02f, -2.20227484e-02f, -6.48010103e-03f,
  1.61873192e-01f, 1.38840735e-01f, 1.35425255e-01f, -1.01803308e-02f, 6.62773475e-02f, 8.72851163e-02f, 1.87769353e-01f, 1.24249801e-01f, 1.43226415e-01f, 1.36062980e-01f,
  7.43242800e-02f, 1.35415033e-01f, 2.73962133e-02f, 1.72243372e-01f, 1.05418712e-01f, 5.52593730e-02f, -6.99535944e-03f, 1.07593104e-01f, 6.62611350e-02f, 7.92926773e-02f,
  1.61373213e-01f, 8.28436613e-02f, 7.56893381e-02f, 4.88975756e-02f, -4.05318365e-02f, 9.31484103e-02f, 9.36097801e-02f, -3.11345654e-03f, -5.04257195e-02f, 5.71978018e-02f,
  -1.58001781e-01f, -1.14115611e-01f, 1.50734710e-03f, -2.20118426e-02f, -1.83072146e-02f, -6.37897998e-02f, -6.36664331e-02f, -2.80977972e-02f, -1.23858169e-01f, -7.04478472e-02f,
  -2.10693236e-02f, -4.04405519e-02f, -8.35439339e-02f, -2.62067411e-02f, -4.97295372e-02f, -8.03473964e-02f, -8.60333294e-02f, -1.51326478e-01f, -1.56280756e-01f, -6.61609918e-02f,
  -5.39324731e-02f, -6.11277334e-02f, -1.05730094e-01f, -1.13345385e-02f, -8.91987309e-02f, -7.88554624e-02f, -1.17581785e-01f, -5.61394021e-02f, -1.32996310e-02f, 3.35598853e-03f,
  1.71136141e-01f, -6.27771839e-02f, 1.28924459e-01f, 8.83443430e-02f, 8.51260647e-02f, 1.41219962e-02f, 1.51992008e-01f, 6.34010583e-02f, 1.25033125e-01f, 1.61776036e-01f,
  1.07645184e-01f, 3.26571576e-02f, 5.32526486e-02f, 1.56099215e-01f, 1.60101205e-01f, 2.09619701e-01f, -2.45985165e-02f, 1.38324693e-01f, 7.46204257e-02f, 1.44038379e-01f,
  3.06688361e-02f, 2.53219064e-02f, 1.68690965e-01f, 2.54410580e-02f, 8.32786900e-04f, -5.16832015e-03f, 7.47159049e-02f, 1.80410221e-01f, -4.25983630e-02f, -5.04073314e-02f,
  1.00115746e-01f, 2.38093153e-01f, -1.17035881e-01f, -1.73779905e-01f, -1.78358898e-01f, -1.55103087e-01f, -9.62611511e-02f, -1.38538517e-03f, 3.65652260e-03f, 6.02618232e-02f,
  1.57902464e-01f, 1.88615143e-01f, 2.78643589e-03f, 1.95017830e-02f, -1.76546257e-02f, -1.04975410e-01f, -2.33914033e-01f, -2.21486732e-01f, -1.52897030e-01f, -1.14280097e-01f,
  -3.56535502e-02f, -1.36400655e-01f, -1.53767869e-01f, -1.05642952e-01f, 1.65024959e-03f, -9.67740119e-02f, -1.39102653e-01f, -2.02462643e-01f, -1.31744429e-01f, -1.57667458e-01f,
  -9.32122022e-02f, 1.40426680e-01f, 1.08168058e-01f, 1.94066942e-01f, 2.89999619e-02f, 1.66624621e-01f, 6.10352568e-02f, 9.38113406e-02f, 1.18131883e-01f, 3.78172770e-02f,
  1.76645309e-01f, 2.10104972e-01f, 9.62369144e-02f, 1.27092227e-01f, 1.50249749e-01f, 7.35550076e-02f, 2.66323593e-02f, 7.36213848e-02f, 1.09977037e-01f, 1.79628849e-01f,
  2.10482523e-01f, 1.22185282e-01f, 5.17533757e-02f, 6.48713857e-02f, 9.34784189e-02f, 2.93854084e-02f, 1.70676708e-01f, 1.98699489e-01f, 1.21034235e-01f, 1.61809832e-01f,
  -1.66305110e-01f, -5.26207462e-02f, -4.39088419e-02f, -8.24305937e-02f, -8.15477669e-02f, -6.07709140e-02f, -8.26329738e-02f, -7.56063834e-02f, -1.46225333e-01f, -1.05048865e-02f,
  -6.61383644e-02f, -1.20057501e-01f, -4.20665788e-03f, -1.77246928e-01f, -1.26109257e-01f, -6.87061697e-02f, -6.72208369e-02f, -9.47098434e-02f, -1.54899523e-01f, -8.33163559e-02f,
  -6.19027652e-02f, -1.23006396e-01f, -1.44826680e-01f, -1.34127825e-01f, -1.37046084e-01f, -1.39347196e-01f, -6.30184859e-02f, 9.43859015e-03f, -2.24461015e-02f, -9.70042944e-02f,
  7.23361596e-02f, 1.27372190e-01f, 1.57109246e-01f, 1.69843972e-01f, 5.04918732e-02f, 1.15754604e-01f, 2.20005363e-01f, 9.05664191e-02f, 1.17732041e-01f, 1.06814228e-01f,
  9.61241201e-02f, 1.69778973e-01f, 4.78687324e-02f, 9.27613676e-02f, 1.16407638e-02f, 4.87780385e-02f, 1.40411258e-01f, 2.50563510e-02f, 3.48505080e-02f, 1.35656774e-01f,
  7.62375221e-02f, 6.77129580e-03f, 1.77738175e-01f, 1.34132579e-01f, 7.84858987e-02f, 1.67144775e-01f, 6.09610677e-02f, 7.34818801e-02f, 1.14480220e-01f, 8.61047506e-02f,
  -3.00310194e-01f, -1.19905099e-01f, -1.55164063e-01f, -3.13652247e-01f, -1.85505360e-01f, 1.07849330e-01f, 2.66230196e-01f, 1.83543175e-01f, -1.24328755e-01f, -1.58044145e-01f,
  -1.49215668e-01f, -7.95185715e-02f, -1.86629027e-01f, 1.16396539e-01f, 1.56710565e-01f, 6.85927197e-02f, -3.95501256e-02f, 6.97647855e-02f, 2.49592796e-01f, 3.20667237e-01f,
  4.25686203e-02f, 7.35384412e-03f, -7.21912682e-02f, 2.22885981e-02f, -2.82679379e-01f, -1.24710388e-01f, -2.09894031e-01f, -7.34215602e-02f, -3.73747721e-02f, -3.66533011e-01f,
  -2.11071104e-01f, -1.51421756e-01f, 1.92240581e-01f, -7.31836781e-02f, -7.57167786e-02f, 1.85680836e-02f, -1.75965354e-02f, 6.12231493e-02f, -6.61075041e-02f, 5.25637083e-02f,
  -6.93683550e-02f, 9.24335420e-02f, 2.82017253e-02f, 6.26119524e-02f, 9.72260758e-02f, 1.62636742e-01f, 1.07926048e-01f, 1.29559442e-01f, 8.52919146e-02f, 4.83699739e-02f,
  2.14018505e-02f, 1.94226205e-02f, -3.44843417e-02f, 1.93784252e-01f, 8.36636499e-02f, -8.54858290e-03f, -4.04634885e-03f, 6.62610233e-02f, 1.08064532e-01f, -4.25288128e-03f,
  -2.67869681e-02f, -8.39483291e-02f, -1.75952092e-02f, -8.48796743e-04f, 5.56329228e-02f, -3.63906892e-03f, -4.20353897e-02f, 6.42705038e-02f, 5.92984864e-03f, 1.89815499e-02f,
  -4.90702838e-02f, 7.82781616e-02f, -3.68548706e-02f, 4.68607508e-02f, -6.05737343e-02f, -1.37484968e-02f, 5.16888276e-02f, 4.57773022e-02f, 2.02078875e-02f, 2.93412693e-02f,
  -2.29151491e-02f, 2.05990882e-03f, -1.28345117e-01f, 5.51085919e-02f, 1.14312973e-02f, 1.69730727e-02f, 1.51314624e-02f, -8.44181851e-02f, -3.01544834e-02f, -6.62878454e-02f,
  -5.02956808e-02f, 2.16353968e-01f, 7.18136951e-02f, 1.34266958e-01f, -3.48363332e-02f, 4.62778397e-02f, 8.07454064e-03f, 8.54012296e-02f, -3.17226574e-02f, 2.98493188e-02f,
  8.79453123e-02f, 5.55357784e-02f, -9.12303403e-02f, 1.36143267e-01f, 5.16001992e-02f, 1.45274773e-01f, 1.52920321e-01f, 3.80005650e-02f, 7.20007494e-02f, 5.03626987e-02f,
  1.28938287e-01f, 1.37154400e-01f, 8.89403522e-02f, 5.34038432e-02f, 1.02412231e-01f, -6.64720610e-02f, 1.49249947e-02f, 1.56170994e-01f, 1.08468629e-01f, 1.99514404e-01f,
  3.34008902e-01f, 8.26448873e-02f, -8.41700286e-02f, -1.49345681e-01f, -2.24369153e-01f, -8.91241282e-02f, 1.31442109e-02f, 1.97186116e-02f, 1.92680452e-02f, 3.59513648e-02f,
  -3.60133685e-02f, 1.23398781e-01f, 2.65617054e-02f, 6.15485460e-02f, 1.66833192e-01f, 1.21459708e-01f, -1.29091263e-01f, 9.02173221e-02f, 6.79593831e-02f, -1.03214733e-01f,
  -4.33051810e-02f, 1.22732110e-02f, 7.32591897e-02f, -6.79402873e-02f, -2.04122409e-01f, 2.75402516e-02f, -6.30136430e-02f, -1.27514586e-01f, -5.73416837e-02f, -4.03500199e-02f,
  1.73590824e-01f, 1.02287531e-03f, -6.97552264e-02f, -7.83910826e-02f, -4.33140770e-02f, -2.01350246e-02f, -1.91254925e-03f, -1.34250581e-01f, -3.80275026e-02f, -1.11327365e-01f,
  -9.82699245e-02f, 2.55470444e-02f, -9.07281712e-02f, -8.14111680e-02f, 9.61220544e-03f, 1.49283502e-02f, -1.37917057e-01f, -5.70468418e-03f, -1.41929951e-03f, -1.49083823e-01f,
  -7.60831535e-02f, -3.16743962e-02f, -5.16976640e-02f, -7.19923247e-03f, -4.04179245e-02f, 2.71667670e-02f, -1.00404531e-01f, -2.35272702e-02f, 2.02539377e-02f, 6.28861040e-02f,
  -3.08022462e-02f, -1.14222459e-01f, 8.57859403e-02f, 6.39981776e-02f, 4.33616079e-02f, 4.24995050e-02f, -4.37163003e-02f, -3.10854428e-03f, 4.00610194e-02f, 3.73117849e-02f,
  4.99407426e-02f, -1.12886755e-02f, -2.68169381e-02f, 7.67185539e-02f, -3.54358070e-02f, 4.33200449e-02f, 1.17035825e-02f, -9.02478176e-04f, 8.57008155e-03f, 8.05259198e-02f,
  -2.23566033e-02f, -2.77351532e-02f, 3.53365093e-02f, -8.50415602e-02f, -3.64425629e-02f, -6.74611703e-02f, -2.97466852e-03f, -3.59332040e-02f, 1.22719228e-01f, 2.68404116e-03f,
  1.28499836e-01f, 1.14592314e-01f, -4.76135360e-03f, 6.27164915e-02f, -1.12768218e-01f, -4.68532443e-02f, -1.21586047e-01f, -7.34436288e-02f, -1.25169098e-01f, 6.15358017e-02f,
  1.28318388e-02f, 2.01525595e-02f, 6.04467932e-03f, 2.72343364e-02f, 2.98366174e-02f, -3.53814885e-02f, 2.18454581e-02f, 3.89780104e-02f, -5.74366841e-03f, -9.65698622e-03f,
  -5.06360531e-02f, 6.32731393e-02f, 1.94323048e-01f, 1.02780521e-01f, -6.29372969e-02f, 1.17899694e-01f, 5.54036684e-02f, 1.38762472e-02f, 8.04481134e-02f, 9.75030288e-02f,
  -3.78105551e-01f, 1.39899909e-01f, 3.56293749e-03f, -1.47492394e-01f, 1.04943775e-01f, 1.63386360e-01f, 2.42759168e-01f, -4.47837189e-02f, 4.44171093e-02f, 1.73704535e-01f,
  1.58603996e-01f, 1.61913410e-01f, 1.34045884e-01f, 4.02988829e-02f, -1.08332776e-01f, 2.74897546e-01f, 4.07041311e-02f, -2.41319165e-01f, -3.53770316e-01f, -1.36535048e-01f,
  5.81483729e-02f, -2.60466546e-01f, -3.79090726e-01f, -2.19998151e-01f, 2.96192244e-02f, 1.55991271e-01f, 2.69928146e-02f, -1.79539278e-01f, -2.95837615e-02f, 1.44932242e-02f,
  6.60048053e-02f, -2.58692116e-01f, 4.45739971e-03f, 9.67830494e-02f, 9.02909506e-03f, 3.90564352e-02f, 9.16739926e-02f, -2.73412559e-02f, -1.04961395e-02f, 6.68920875e-02f,
  4.05934192e-02f, 2.60595158e-02f, -6.50843903e-02f, -5.20501360e-02f, -5.21497019e-02f, -5.51726259e-02f, -1.32160485e-01f, -2.00711563e-01f, 2.34266911e-02f, 8.46970640e-03f,
  5.13904393e-02f, -5.38866855e-02f, -8.56627226e-02f, 6.10189280e-03f, 2.76089995e-03f, 6.49016947e-02f, 2.66710948e-02f, -7.66910762e-02f, -7.66671309e-03f, 3.13789546e-02f,
  1.26977369e-01f, 1.02826245e-01f, -2.60404199e-02f, -4.78538238e-02f, 7.15582445e-02f, 6.14810660e-02f, -1.36399660e-02f, 4.58019711e-02f, 3.15087941e-03f, -4.06785719e-02f,
  2.97050532e-02f, 3.29277106e-02f, 3.27410027e-02f, -2.45692730e-02f, -7.69394450e-03f, -6.06049262e-02f, 2.89414432e-02f, -1.50347557e-02f, -5.43917855e-03f, -2.80062202e-02f,
  4.21426073e-03f, -3.26581895e-02f, 2.74461880e-02f, 3.74952890e-03f, 4.58853170e-02f, -1.50363594e-02f, 9.51996446e-03f, 6.40109107e-02f, 3.60225998e-02f, -1.08366255e-02f,
  1.60889700e-01f, -6.52463138e-02f, 1.43605262e-01f, -1.34425238e-02f, -6.12536855e-02f, 1.37544330e-02f, 4.70226305e-03f, -3.52884829e-02f, 1.05478615e-02f, -7.28130564e-02f,
  -2.70512085e-02f, -7.83907622e-02f, 7.27731781e-03f, -6.48963228e-02f, -3.78972813e-02f, 3.18631269e-02f, 1.19555295e-01f, 9.49661154e-03f, 3.39337178e-02f, 4.02195156e-02f,
  2.62068063e-02f, 1.29373923e-01f, 1.04389817e-01f, 1.99650303e-01f, 7.24673569e-02f, 1.54982239e-01f, 9.50261354e-02f, 1.28433466e-01f, 9.56947505e-02f, 2.26962030e-01f,
  1.58206388e-01f, -2.05597281e-01f, 2.01707378e-01f, 6.78755790e-02f, -9.80073120e-03f, 2.22529218e-01f, 2.94848591e-01f, 2.47230768e-01f, -4.12760563e-02f, -1.14996321e-01f,
  -4.00174558e-01f, -4.62711632e-01f, -2.44170442e-01f, -1.33133292e-01f, 6.09887242e-02f, 1.58194333e-01f, 2.48240024e-01f, 3.03523302e-01f, 1.65983170e-01f, -6.30192310e-02f,
  -2.89594755e-02f, 9.55031961e-02f, 1.55147150e-01f, 1.90776080e-01f, -1.47608504e-01f, -2.52647877e-01f, 6.73692152e-02f, -1.53561560e-02f, -1.03759542e-01f, -1.50337487e-01f,
  -3.01794589e-01f, 1.35074675e-01f, -4.14551347e-02f, -1.98661774e-01f, -1.50951371e-01f, 3.22361998e-02f, -5.90353645e-03f, 5.69158942e-02f, -6.89001232e-02f, 4.62184288e-03f,
  -1.44344211e-01f, -7.80856311e-02f, -7.56936744e-02f, -8.16018358e-02f, -1.32902497e-02f, -7.80032426e-02f, 1.18041813e-01f, 1.40508160e-01f, 6.35232776e-02f, -5.81172518e-02f,
  -1.48182899e-01f, 7.66758062e-03f, 1.19437575e-01f, -4.17378545e-03f, 1.71773762e-01f, 1.25148729e-03f, -5.11759631e-02f, -1.17242727e-02f, 7.62454569e-02f, 9.08765644e-02f,
  1.30637869e-01f, -8.21936131e-03f, 4.07746322e-02f, -4.87423968e-03f, 4.63126078e-02f, 8.17776248e-02f, -2.29809270e-03f, 1.19545730e-02f, 6.34597391e-02f, 1.18746899e-01f,
  2.68562064e-02f, 6.12372607e-02f, 4.99047153e-02f, 8.89565423e-02f, 6.29209494e-03f, 6.85568783e-04f, 4.43238616e-02f, 1.67547874e-02f, 7.14685470e-02f, -3.22622340e-03f,
  3.85546722e-02f, 4.69422387e-03f, 1.80117469e-02f, 5.64732887e-02f, 7.00936019e-02f, 4.12652642e-02f, 3.76940928e-02f, -1.43415816e-02f, -2.78954599e-02f, 5.75225055e-03f,
  -2.44307727e-01f, -3.85496467e-02f, -4.69405875e-02f, 2.30908301e-02f, -6.62378594e-02f, -7.79103637e-02f, -1.19045593e-01f, -8.75821039e-02f, -1.21139921e-01f, -4.19188254e-02f,
  -1.08704008e-01f, 3.99602391e-03f, -8.05457234e-02f, -9.82877910e-02f, -2.67962851e-02f, -7.72213489e-02f, -3.74514014e-02f, -1.16496101e-01f, -1.42498598e-01f, -1.49569750e-01f,
  -4.06026505e-02f, -4.01869155e-02f, -1.38681993e-01f, -1.08240411e-01f, -1.56836677e-02f, -9.59509090e-02f, -6.98374510e-02f, -7.51740709e-02f, -5.34803548e-04f, 5.17398901e-02f,
  1.72439069e-01f, 9.02978256e-02f, 2.35514179e-01f, 1.69916674e-02f, -1.28204644e-01f, 1.97117049e-02f, 1.32965297e-01f, 1.15908543e-02f, 3.33545394e-02f, 1.80397779e-02f,
  -2.01317802e-01f, -2.99013048e-01f, -2.13887975e-01f, -1.35522619e-01f, 3.43216397e-02f, 1.06361993e-01f, 1.30033359e-01f, 1.32928222e-01f, -1.29313111e-01f, -2.95718163e-01f,
  -1.74345911e-01f, -1.78702459e-01f, -4.33002487e-02f, -1.06214434e-01f, -9.57695469e-02f, -2.31934607e-01f, 5.82251549e-02f, -3.73616768e-03f, -4.66746129e-02f, -3.37357894e-02f,
  -1.53116053e-02f, -5.46341687e-02f, -1.40933916e-01f, -1.76751211e-01f, -4.32726741e-02f, -3.70740928e-02f, 6.35445863e-02f, 3.16704959e-02f, -1.06935501e-02f, -5.10371551e-02f,
  -7.69014433e-02f, -1.63333669e-01f, -7.37053379e-02f, -1.69645160e-01f, -1.18104190e-01f, -6.29298910e-02f, 3.57262790e-02f, 5.21400769e-04f, -9.09077227e-02f, -5.09181879e-02f,
  -8.31967145e-02f, 1.06976822e-01f, 1.04237482e-01f, 6.96741715e-02f, -1.11537211e-01f, -2.03845445e-02f, 4.77488525e-02f, -1.29238293e-01f, 5.13518862e-02f, 4.09761304e-03f,
  4.19136286e-02f, 9.24384072e-02f, -4.54718657e-02f, -7.79588819e-02f, -7.55443098e-03f, 4.77963686e-02f, -8.66150782e-02f, -4.94103506e-02f, 5.94866723e-02f, 5.91704994e-02f,
  -6.25504693e-03f, -3.16377506e-02f, -5.94654307e-03f, 5.50904684e-02f, -4.92032133e-02f, 8.68829191e-02f, 8.60778033e-04f, 3.21399677e-03f, 4.89201210e-02f, -5.31083904e-03f,
  -8.54830816e-02f, 5.71777746e-02f, -6.27373978e-02f, 1.58275422e-02f, 5.78134283e-02f, 8.91338438e-02f, 3.58162001e-02f, -2.62550786e-02f, -1.85075868e-02f, -9.81018785e-03f,
  -1.19242497e-01f, 5.52079231e-02f, 5.02316728e-02f, -4.80554067e-03f, 4.42725345e-02f, 2.19503534e-03f, -1.16474830e-01f, -6.55400157e-02f, 8.90684221e-03f, 2.74287630e-02f,
  -1.44334897e-01f, -1.51840746e-01f, -6.21380396e-02f, -8.08504671e-02f, 3.69887538e-02f, 2.42249835e-02f, -1.12309214e-03f, 4.30242047e-02f, -3.07844742e-03f, 3.55737284e-02f,
  6.33463860e-02f, 1.53772503e-01f, 8.14569592e-02f, 1.53679401e-01f, -5.29793575e-02f, 8.41233879e-02f, 3.50268334e-02f, 8.81931484e-02f, 4.81198020e-02f, 2.11688206e-01f,
  -7.26276264e-02f, -6.27785921e-02f, 1.41474351e-01f, -7.55592063e-02f, -6.53098971e-02f, -3.28699760e-02f, -2.13187695e-01f, -3.96722227e-01f, -2.23048225e-01f, -2.97499374e-02f,
  -1.30919069e-01f, -8.64957646e-02f, -1.03932254e-01f, -8.86319205e-02f, -1.39477372e-01f, 2.63781175e-02f, 6.03882596e-02f, 6.73709810e-02f, -1.40552819e-01f, -1.89693168e-01f,
  -2.69227009e-02f, 2.25082990e-02f, -2.88891308e-02f, -6.71786964e-02f, -1.12062097e-01f, -1.90213099e-01f, -2.00278386e-02f, 8.09763744e-02f, 3.87695208e-02f, 1.59466907e-01f,
  1.28890291e-01f, -1.56244606e-01f, -9.40561816e-02f, -1.38450652e-01f, -1.66067630e-01f, -1.13448724e-01f, -8.95779505e-02f, -1.45141631e-01f, -2.07781926e-01f, -3.54627706e-02f,
  -9.38450322e-02f, -4.09293026e-02f, -1.29965872e-01f, -3.82198617e-02f, -5.94316646e-02f, -1.41221538e-01f, -1.98208854e-01f, -1.34091854e-01f, -1.54991835e-01f, -1.61693141e-01f,
  -1.66007325e-01f, -5.53584695e-02f, -2.71960441e-03f, -1.53328255e-01f, -2.14943305e-01f, -5.63736632e-02f, -7.09624663e-02f, -2.13713646e-01f, -2.14574620e-01f, -1.64002553e-01f,
  1.56258315e-01f, 1.25195920e-01f, 1.29490152e-01f, 8.20320752e-03f, 3.13504413e-02f, 1.83338940e-01f, 1.23156466e-01f, 1.64362729e-01f, 1.73801884e-01f, 5.49090542e-02f,
  2.12625727e-01f, 9.42976475e-02f, 1.26472682e-01f, 1.28355011e-01f, 1.98197484e-01f, 1.30046815e-01f, 7.43558034e-02f, 9.91557539e-02f, 1.19041316e-01f, 1.13891736e-01f,
  1.36896014e-01f, 1.86713666e-01f, 1.36425629e-01f, 1.24361977e-01f, 1.33797705e-01f, 1.64077371e-01f, 2.21207216e-01f, 1.11911997e-01f, 1.76103413e-01f, 1.61569566e-01f,
  -2.02125311e-01f, -5.80227487e-02f, -2.00358093e-01f, -2.31511503e-01f, -8.45915750e-02f, -1.27371654e-01f, -8.65638703e-02f, -2.19483927e-01f, -1.39255285e-01f, -1.91369623e-01f,
  -2.09878474e-01f, -1.32833853e-01f, -4.60551158e-02f, -1.91069111e-01f, -3.80296558e-02f, -1.82398945e-01f, -2.76985347e-01f, -8.37059692e-02f, -2.30887815e-01f, -1.47397339e-01f,
  -1.96553558e-01f, -2.56001532e-01f, -2.38190904e-01f, -1.99274719e-01f, -2.10754737e-01f, -9.36748758e-02f, -1.31329462e-01f, -2.49666169e-01f, -1.80541039e-01f, -3.05299133e-01f,
  -4.09801066e-01f, 4.00060475e-01f, 3.43462527e-01f, -1.16463087e-01f, -9.13568214e-02f, -5.05386293e-02f, 3.05997461e-01f, -8.97124130e-03f, -4.86578569e-02f, 6.52508214e-02f,
  -1.65571600e-01f, -1.44568324e-01f, 2.70261299e-02f, 1.68573946e-01f, 1.41416654e-01f, 4.77880508e-01f, 4.30187434e-01f, 2.94599235e-01f, -4.93413173e-02f, -8.17988664e-02f,
  7.92566240e-02f, 3.37426551e-02f, 3.85010056e-02f, 6.14851527e-02f, 1.29968330e-01f, 1.54266298e-01f, 1.57354191e-01f, 1.41413182e-01f, 2.02703983e-01f, 3.27632934e-01f,
  1.85627505e-01f, -1.12386122e-01f, 9.87179652e-02f, -6.21964596e-02f, -1.83427911e-02f, 4.58814576e-02f, 3.33219394e-02f, 9.05513987e-02f, 4.92988564e-02f, 1.12521619e-01f,
  2.39302292e-02f, -8.76382291e-02f, -5.74164018e-02f, 3.20334099e-02f, -1.60291530e-02f, -7.60415103e-03f, 1.04770966e-01f, 1.42682284e-01f, 1.31462246e-01f, 1.40241310e-01f,
  1.12298973e-01f, -1.23870462e-01f, -9.19895321e-02f, 2.92723589e-02f, -2.90781539e-02f, -3.88238840e-02f, 3.70805748e-02f, 5.22420667e-02f, 3.88139077e-02f, 1.26719296e-01f,
  -1.36204839e-01f, -7.42682144e-02f, -1.02600865e-01f, -6.01948500e-02f, -8.21865126e-02f, -9.91624370e-02f, -2.66348608e-02f, 3.64008429e-03f, -1.67133227e-01f, -5.55024594e-02f,
  -8.74745026e-02f, -6.72230422e-02f, -9.06610563e-02f, -5.69984689e-02f, -5.75312600e-02f, -2.35348660e-02f, -7.04705790e-02f, 6.33842945e-02f, -5.96836470e-02f, -5.41388318e-02f,
  -1.02226578e-01f, -2.82036345e-02f, -1.31165413e-02f, 9.32262186e-03f, 6.18948601e-02f, -1.94460582e-02f, 4.47329357e-02f, -7.02348351e-02f, 1.38228026e-03f, -5.71917631e-02f,
  1.91700626e-02f, -7.76621029e-02f, 1.10406037e-02f, 4.45863828e-02f, 3.46867703e-02f, 6.86535314e-02f, 4.76550013e-02f, 6.52936324e-02f, -7.36046657e-02f, 1.33260161e-01f,
  -7.22572803e-02f, 1.11837775e-01f, 8.60235617e-02f, 4.68650945e-02f, 6.17519431e-02f, 5.98485060e-02f, 1.05261050e-01f, 9.91401076e-03f, 1.03604548e-01f, 9.60081890e-02f,
  1.47727504e-01f, 7.39501715e-02f, 5.31817898e-02f, 1.10487714e-01f, 2.66133863e-02f, -3.15484852e-02f, 2.02294946e-01f, 1.70430779e-01f, 3.54167633e-02f, 3.20932031e-01f,
  -2.30664238e-01f, 2.41742283e-01f, -2.21797964e-03f, 3.30646820e-02f, -4.36103977e-02f, 1.21877514e-01f, 2.79067665e-01f, 1.25683859e-01f, -3.05455886e-02f, -1.23466579e-02f,
  -8.18850622e-02f, -2.28336722e-01f, -1.52862355e-01f, -2.59897202e-01f, -1.22120313e-01f, 9.85252187e-02f, -6.18608929e-02f, -2.02382311e-01f, -2.95192569e-01f, -1.80663303e-01f,
  -5.69384433e-02f, -3.02003268e-02f, -1.47694662e-01f, -1.62048578e-01f, -7.14748679e-03f, -1.13759778e-01f, 1.01066835e-01f, -2.29318328e-02f, -1.37816727e-01f, -8.42787996e-02f,
  -2.35728800e-01f, -1.14628963e-01f, -2.58062690e-01f, -2.78889179e-01f, -1.67817414e-01f, -1.94677055e-01f, -1.28098294e-01f, -1.30804688e-01f, -2.17352197e-01f, -9.76656079e-02f,
  -7.09237605e-02f, -1.31018192e-01f, -1.18731350e-01f, -8.82727280e-02f, -5.27041666e-02f, -1.66207418e-01f, -2.75571924e-02f, -2.15519547e-01f, -2.36184418e-01f, -2.01287687e-01f,
  -2.04711467e-01f, -9.26549882e-02f, -1.23959966e-01f, -2.06081755e-02f, -1.48332372e-01f, -1.70998141e-01f, -2.34371591e-02f, -8.36465657e-02f, -1.04428858e-01f, -1.91026810e-03f,
  -1.86313607e-03f, 6.52689412e-02f, 7.36328214e-02f, 1.27187058e-01f, 4.60963361e-02f, 9.90464613e-02f, 9.49598923e-02f, 1.49934307e-01f, 8.09701011e-02f, 1.50195971e-01f,
  1.50734171e-01f, 3.75489630e-02f, 9.56080202e-03f, 1.60195798e-01f, 1.15980729e-02f, 1.32274732e-01f, 2.97817457e-02f, 6.27166480e-02f, 8.22472125e-02f, 1.36737943e-01f,
  6.37944490e-02f, 1.18460365e-01f, 9.55546647e-02f, 5.54001257e-02f, 2.29110047e-02f, 8.55708681e-03f, 1.31953537e-01f, 1.40805691e-02f, 1.30182385e-01f, 1.78404804e-02f,
  8.22760537e-03f, -3.12937558e-01f, -1.65516004e-01f, -7.67758787e-02f, -5.83109446e-02f, -9.29945335e-02f, -1.48831248e-01f, -1.00464262e-01f, -1.75077602e-01f, -9.24092904e-02f,
  -1.70623764e-01f, -7.59164095e-02f, -1.23155922e-01f, -1.28960237e-01f, -8.98624435e-02f, -9.71864536e-02f, -8.32329169e-02f, -9.53567028e-02f, -7.70296603e-02f, -1.54540941e-01f,
  -7.94922858e-02f, -7.27176145e-02f, -8.69206488e-02f, -5.17533273e-02f, -7.94210210e-02f, -1.58113599e-01f, -4.92838621e-02f, -4.13861349e-02f, -1.79455146e-01f, 4.21082862e-02f,
  -5.06052896e-02f, -2.92338431e-01f, -3.32602233e-01f, -8.92860368e-02f, 1.34303749e-01f, 2.97841311e-01f, 1.24825977e-01f, 6.58173710e-02f, 2.04240028e-02f, -9.49463248e-02f,
  1.31335661e-01f, 1.35476455e-01f, 5.71655259e-02f, 1.82877585e-01f, 4.83632982e-02f, -7.47585893e-02f, -1.90965876e-01f, -1.33087039e-01f, 2.11125121e-01f, 3.13052148e-01f,
  1.51917666e-01f, -3.47931460e-02f, -8.63222182e-02f, -3.40423360e-02f, -1.69657543e-01f, 2.44134404e-02f, -2.52159655e-01f, -1.90144658e-01f, -9.55231395e-03f, -1.98479548e-01f,
  -1.08103819e-01f, -1.51694849e-01f, 4.03545462e-02f, 7.27732927e-02f, -9.24786925e-02f, -9.80438069e-02f, -2.39887591e-02f, -9.31186527e-02f, -1.61572210e-02f, -3.84190902e-02f,
  1.45656411e-02f, -1.71415005e-02f, -1.22488566e-01f, -1.08166426e-01f, -1.27168953e-01f, -3.77738513e-02f, -6.52721524e-02f, -9.34033096e-02f, -8.80489647e-02f, -3.56069840e-02f,
  1.09105580e-01f, 1.06289096e-01f, -6.73279632e-03f, 3.01715601e-02f, -2.83429082e-02f, 4.38391790e-02f, -1.29782921e-03f, -8.90327170e-02f, -5.34999557e-02f, -1.51617512e-01f,
  -1.79308858e-02f, -8.06785673e-02f, -4.85470183e-02f, -9.03424174e-02f, -1.96503848e-02f, -1.06127121e-01f, -2.83002183e-02f, -1.26558701e-02f, 3.46963182e-02f, -6.85675740e-02f,
  -8.40588510e-02f, -2.04203738e-04f, -8.28367248e-02f, -6.03314079e-02f, 2.21254081e-02f, 3.59878801e-02f, 7.18717510e-03f, 3.77316773e-02f, -2.79214773e-02f, -3.97507213e-02f,
  -4.72147018e-02f, -1.79787371e-02f, -2.03375928e-02f, 2.98149753e-02f, 6.44368306e-02f, -8.57761130e-02f, -2.67030802e-02f, 4.54353690e-02f, -2.36400925e-02f, -2.65322719e-02f,
  3.04680108e-03f, 8.76526684e-02f, 2.91425623e-02f, 1.84021741e-02f, 4.92089875e-02f, -6.54652417e-02f, 8.75173882e-02f, -4.53646220e-02f, -1.24969771e-02f, 4.83931191e-02f,
  3.89788970e-02f, -2.03954149e-02f, 4.12546434e-02f, -2.37620082e-02f, 1.07248567e-01f, 3.43567021e-02f, 1.10406227e-01f, 5.27355587e-03f, 4.20342535e-02f, 2.51694601e-02f,
  -5.14362082e-02f, 2.17268318e-01f, 2.68494278e-01f, 6.38024658e-02f, -3.06141842e-03f, 1.40051693e-01f, 1.31942496e-01f, 3.56530286e-02f, 2.11437881e-01f, 1.32796809e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.64252794e-01f, -4.56617802e-01f, -1.63726509e-01f, -3.19764256e-01f, -1.63468763e-01f, -4.08491850e-01f, -5.94952703e-01f, -1.76472619e-01f, -9.75279883e-02f, -4.98836905e-01f,
  -2.12283403e-01f, 2.63538659e-01f, 5.98549210e-02f, -6.37966022e-02f, -3.45267713e-01f, -7.17628360e-01f, -5.76093733e-01f, -2.64174968e-01f, 3.02856918e-02f, -6.15319200e-02f,
  -1.89967856e-01f, -6.75436407e-02f, -2.29852833e-02f, 3.51896286e-02f, 8.08186308e-02f, 7.68943727e-02f, -1.14822835e-01f, -8.77728462e-02f, -1.43054247e-01f, -2.82541871e-01f,
  2.84427971e-01f, 2.70804204e-02f, 4.00715731e-02f, -3.41303535e-02f, 3.74025889e-02f, -1.42441541e-02f, -6.82404339e-02f, 7.81155974e-02f, 8.20866525e-02f, 5.52329272e-02f,
  -4.39442769e-02f, -1.08412035e-01f, 8.57462808e-02f, 1.26911938e-01f, 2.92434171e-02f, -4.91811074e-02f, -1.80661300e-04f, -3.53846774e-02f, -4.55021262e-02f, -3.98585619e-03f,
  -4.19201590e-02f, -2.26916790e-01f, -9.83829200e-02f, 4.50440422e-02f, 1.11361951e-01f, 2.59742104e-02f, 1.05289519e-01f, 2.18400851e-01f, 7.25766197e-02f, 6.81804121e-02f,
  -6.28381222e-02f, 1.62456527e-01f, 5.31706698e-02f, 2.63728225e-03f, 9.17287469e-02f, 1.47353997e-02f, -7.81381689e-03f, 1.61055669e-01f, 4.33028564e-02f, 4.21891473e-02f,
  5.72433062e-02f, -1.98603254e-02f, 4.12107147e-02f, -5.69725744e-02f, -6.33614510e-02f, -1.23360278e-02f, -1.15892127e-01f, 3.98444310e-02f, 4.39251363e-02f, -5.41699603e-02f,
  2.76530702e-02f, 5.16437404e-02f, -3.10475379e-02f, 1.76228046e-01f, -1.26689702e-01f, 3.23076211e-02f, 6.17623180e-02f, 9.11927372e-02f, 1.23893069e-02f, -2.54607089e-02f,
  3.65107507e-01f, -2.00562060e-01f, -9.15842950e-02f, 1.32240340e-01f, -9.33536217e-02f, 1.55173596e-02f, -5.53617962e-02f, -4.38153408e-02f, 1.11388363e-01f, 4.52406071e-02f,
  2.30903961e-02f, 3.32322307e-02f, 7.95952156e-02f, 3.55685432e-03f, 5.84808029e-02f, 1.34899756e-02f, -1.96062431e-01f, -8.13423842e-02f, -6.86289072e-02f, 6.34789616e-02f,
  -2.00800270e-01f, -2.52759516e-01f, -2.45000377e-01f, 2.47706529e-02f, 1.42853722e-01f, -1.67955551e-02f, 2.23395050e-01f, 6.71795681e-02f, -1.45636136e-02f, -2.61372738e-02f,
  5.43148935e-01f, -2.29147658e-01f, -6.45862937e-01f, 2.91628808e-01f, -7.69097209e-02f, -2.83008456e-01f, -3.05673301e-01f, 6.65053725e-02f, 3.00309479e-01f, 3.01756077e-02f,
  -9.44817960e-02f, 1.73268363e-01f, -8.01524818e-02f, -2.77135849e-01f, -2.01680154e-01f, -3.31028461e-01f, -2.85277963e-01f, -3.97608936e-01f, -1.98465973e-01f, -1.21334828e-01f,
  -1.15604562e-04f, 1.26328081e-01f, 4.22389805e-02f, -2.02321336e-02f, 3.58266607e-02f, -4.44789715e-02f, -1.07671402e-01f, -1.34717911e-01f, -3.22916627e-01f, -3.05099040e-01f,
  -6.39718890e-01f, -1.87816143e-01f, -4.73723421e-03f, -1.85882393e-02f, -1.50106037e-02f, 2.27779448e-02f, -7.40158185e-02f, 1.51267350e-01f, 2.51976192e-01f, 2.11894542e-01f,
  3.89964767e-02f, 8.71032178e-02f, 7.54199252e-02f, 3.38104405e-02f, 1.11936525e-01f, -1.31605822e-03f, 2.08627924e-01f, 1.74084917e-01f, 6.46903887e-02f, -1.09788641e-01f,
  -5.76135181e-02f, 3.20355631e-02f, 1.16602331e-01f, 1.16153099e-01f, -2.87385229e-02f, -4.42067645e-02f, 1.33443829e-02f, -5.21181971e-02f, -7.63243660e-02f, 2.50530988e-01f,
  -1.27925321e-01f, 1.60525069e-01f, -2.27489346e-03f, 9.25524756e-02f, 2.55126834e-01f, 2.44478256e-01f, 1.64025769e-01f, 2.14246988e-01f, 2.35516671e-02f, 6.88874051e-02f,
  1.50905222e-01f, 5.40224984e-02f, 6.32285625e-02f, -3.60924266e-02f, -1.18699349e-01f, -8.31073299e-02f, 3.81855331e-02f, -3.33914310e-02f, -8.36774111e-02f, -7.86966062e-04f,
  -5.48753031e-02f, -2.44413000e-02f, -6.50082827e-02f, -1.46615744e-01f, -9.53841954e-02f, 2.21704803e-02f, -8.87286142e-02f, -1.79028526e-01f, -2.96512675e-02f, -1.49145618e-01f,
  3.00297558e-01f, -5.31836927e-01f, -3.13900337e-02f, -9.83716920e-02f, 8.19142237e-02f, 4.93993759e-02f, -8.83250087e-02f, 6.82230368e-02f, 4.32275757e-02f, 5.29571623e-02f,
  -1.13794178e-01f, -1.23727366e-01f, -1.01473883e-01f, 1.58308186e-02f, 5.86858718e-03f, 1.05847612e-01f, 1.39297932e-01f, -1.76178396e-03f, 2.53001805e-02f, -8.50651339e-02f,
  -1.16809355e-02f, 1.96297899e-01f, 3.04513574e-01f, 2.16517270e-01f, 1.11114360e-01f, 8.53538811e-02f, -3.85391414e-02f, 8.79783034e-02f, -1.09590050e-02f, 2.90932357e-01f,
  5.93589067e-01f, 4.73775446e-01f, 5.53689957e-01f, 6.34202659e-02f, 9.20333415e-02f, -1.41707808e-01f, -4.14755493e-01f, -3.77299517e-01f, -3.87498364e-02f, 2.94252396e-01f,
  4.09710079e-01f, -8.54044780e-02f, -7.70512968e-02f, -3.33075553e-01f, -5.66779196e-01f, -1.66020915e-01f, -5.34879155e-02f, -4.07790720e-01f, -6.22326910e-01f, -6.25028014e-01f,
  -2.85345465e-01f, -1.13736980e-01f, -1.31358489e-01f, -1.42107412e-01f, 5.18214345e-01f, 1.12277240e-01f, 5.14786363e-01f, 4.64943826e-01f, 1.60543069e-01f, 6.18826628e-01f,
  6.06264830e-01f, 7.46874034e-01f, -4.96787608e-01f, -1.32935673e-01f, 7.98808858e-02f, -9.64716673e-02f, -1.44209817e-01f, 5.26388697e-02f, 4.44354676e-02f, 1.19510829e-01f,
  1.99112192e-01f, 1.51738688e-01f, 1.94375496e-02f, -1.01955943e-01f, -2.38863565e-02f, -2.29793236e-01f, -6.23357221e-02f, -1.25956312e-01f, -1.05220303e-01f, 1.44701406e-01f,
  -2.67767847e-01f, 2.40214825e-01f, 3.99255544e-01f, -1.27794519e-01f, 1.20093070e-01f, -1.23966768e-01f, 1.70214906e-01f, 1.65001705e-01f, 8.40733498e-02f, 2.95846313e-01f,
  -8.05755481e-02f, 9.15784482e-03f, -2.88333260e-02f, 8.77874419e-02f, -1.50142536e-01f, 3.95929255e-03f, 8.07953402e-02f, -1.41897490e-02f, -6.13821559e-02f, 4.38148715e-02f,
  -2.12295353e-02f, 4.08087904e-03f, -8.94610956e-02f, 6.87176883e-02f, 4.13392112e-03f, 1.09292440e-01f, -3.93252447e-02f, -5.52170314e-02f, 3.82857174e-02f, 2.55085970e-03f,
  -1.65199816e-01f, -7.06286822e-03f, 8.86064395e-02f, 2.89630773e-03f, 9.97655466e-02f, 1.17253708e-02f, 7.02119395e-02f, 8.74976628e-03f, 1.17218554e-01f, 1.04513325e-01f,
  -3.22608650e-01f, -4.61193800e-01f, 2.18433157e-01f, -1.12275116e-01f, 3.02849221e-03f, 1.31295979e-01f, 1.10912375e-01f, -1.47134557e-01f, 2.33846098e-01f, -4.01109457e-02f,
  4.03923653e-02f, -3.43117081e-02f, 1.92096904e-01f, -1.33743927e-01f, -3.08410913e-01f, 5.13878465e-02f, -1.67793110e-01f, -1.63505509e-01f, -1.00236058e-01f, 3.60120311e-02f,
  -2.29185268e-01f, -5.18605888e-01f, -4.50941592e-01f, -3.39765638e-01f, -3.28385085e-02f, -3.61085743e-01f, -1.79537028e-01f, -1.95780799e-01f, -4.29420888e-01f, -4.93419230e-01f,
  4.74277645e-01f, -3.81868869e-01f, -1.03590637e-01f, 1.17889799e-01f, -8.01722929e-02f, -7.41955712e-02f, -1.49399996e-01f, -8.25367272e-02f, 3.44071239e-02f, -9.39093009e-02f,
  3.14123258e-02f, 1.54971987e-01f, 2.18311101e-01f, 1.30460694e-01f, 1.21527679e-01f, -2.30218187e-01f, -1.21664144e-01f, 5.02782799e-02f, 4.01728265e-02f, -6.52253488e-03f,
  -1.31495923e-01f, -1.59452632e-01f, 3.68253887e-02f, -3.43505503e-03f, -7.77818263e-02f, 6.53812513e-02f, -6.42890409e-02f, -1.56052649e-01f, -1.94049269e-01f, -2.09794149e-01f,
  2.76905566e-01f, 3.40955853e-01f, 1.84312984e-01f, 1.48541987e-01f, 1.58693910e-01f, 4.00571898e-02f, 1.51212871e-01f, -4.71378304e-02f, -4.33732681e-02f, -7.88688809e-02f,
  7.27750957e-02f, 8.18210915e-02f, 1.41798154e-01f, -2.55580200e-03f, 9.46837366e-02f, 1.16991937e-01f, 4.28130627e-02f, 1.19806724e-02f, 9.24010277e-02f, 1.10677540e-01f,
  -1.58171523e-02f, 1.87851153e-02f, 9.53345820e-02f, 7.12675899e-02f, 9.22241360e-02f, 1.18997887e-01f, 1.04355797e-01f, 1.13780439e-01f, 1.74486697e-01f, 1.55708879e-01f,
  4.21423092e-02f, 7.00397566e-02f, 1.36750668e-01f, 2.27611244e-01f, 1.54513329e-01f, -6.70949966e-02f, -1.41003624e-01f, -1.60658620e-02f, 4.54770476e-02f, 1.05352804e-01f,
  -1.58293217e-01f, 4.45525981e-02f, 1.66627392e-02f, -6.23193234e-02f, 1.89638715e-02f, -5.18734269e-02f, -4.25923467e-02f, 2.17719306e-03f, 1.19385585e-01f, 8.04346055e-02f,
  1.48596525e-01f, -2.07706317e-01f, -1.47373304e-01f, -4.77651842e-02f, -1.37927964e-01f, -4.82367724e-02f, 3.74846756e-02f, 8.07777196e-02f, -9.25165340e-02f, -2.35926762e-01f,
  1.95313349e-01f, 4.68841046e-01f, 1.14973165e-01f, 7.45673701e-02f, 3.52575146e-02f, -5.76065807e-03f, 2.09673151e-01f, -7.33010191e-03f, -1.60376012e-01f, -4.86429036e-02f,
  1.24767020e-01f, 1.17257424e-01f, 8.09264928e-02f, -1.53464563e-02f, 6.05008826e-02f, -2.22789850e-02f, 7.84435347e-02f, 5.17254435e-02f, -9.07903686e-02f, 1.70103069e-02f,
  -2.60659736e-02f, -2.16364004e-02f, 1.92463264e-01f, 1.31007805e-01f, 1.05313703e-01f, 7.26608187e-02f, 1.28711555e-02f, 5.97411580e-02f, 3.89225334e-02f, -1.59405157e-01f,
  -5.81319869e-01f, 4.37009335e-01f, -9.06714261e-01f, 4.03549612e-01f, 3.34242851e-01f, -2.80391306e-01f, -3.79866034e-01f, -2.14121848e-01f, 3.84787828e-01f, 1.03279486e-01f,
  1.90906540e-01f, 4.02870804e-01f, 1.94586217e-01f, -7.27168620e-02f, -5.13747334e-01f, 5.45194373e-02f, 2.32086226e-01f, -6.90297544e-01f, -7.91597724e-01f, -1.54383585e-01f,
  5.75110674e-01f, 8.70766118e-02f, -4.72928673e-01f, -2.24696442e-01f, 5.44339657e-01f, 1.19698472e-01f, 2.56980248e-02f, 8.76382664e-02f, -1.24180950e-02f, 3.34063292e-01f,
  -5.39662898e-01f, -2.59485751e-01f, -1.10940307e-01f, 7.19374940e-02f, -6.49798736e-02f, -1.90172583e-01f, -1.54950485e-01f, -2.75698602e-01f, 1.65630922e-01f, -9.53331739e-02f,
  1.60754740e-01f, -7.73362890e-02f, 3.25906605e-01f, 1.91818979e-02f, -1.66228227e-02f, -2.27437809e-01f, -1.05428591e-01f, -4.94220644e-01f, -5.67882419e-01f, -4.17409509e-01f,
  4.58449334e-01f, 7.19689503e-02f, -6.53070092e-01f, -2.10952267e-01f, -2.38341659e-01f, -1.36871621e-01f, -5.82147002e-01f, -3.65092516e-01f, -7.53450572e-01f, -2.83073306e-01f,
  4.99217119e-03f, 1.88586891e-01f, 4.46409471e-02f, 3.58765908e-02f, 9.93502811e-02f, 1.51640385e-01f, 3.84974964e-02f, 1.71766311e-01f, 2.75162701e-02f, 6.04305556e-03f,
  -3.09204254e-02f, -6.21641763e-02f, -5.14471680e-02f, 1.55233676e-02f, 1.39941558e-01f, -7.25229383e-02f, -1.42118007e-01f, -5.06857829e-03f, 4.39909846e-02f, -1.49475753e-01f,
  -4.96604629e-02f, -2.22830668e-01f, 1.23288304e-01f, -1.79913148e-01f, -6.56894743e-02f, -2.25710437e-01f, 2.45399587e-03f, -1.94921330e-01f, -6.02222309e-02f, -6.41310662e-02f,
  1.89954266e-01f, -9.53442007e-02f, 1.34409070e-02f, -1.32057101e-01f, 6.53865114e-02f, 1.67765692e-01f, 2.55360782e-01f, -3.64989750e-02f, 1.52382508e-01f, -2.98084244e-02f,
  -1.17187090e-01f, -3.81961577e-02f, 2.83279568e-01f, -6.09013774e-02f, -3.60372551e-02f, 1.42224535e-01f, 4.08129364e-01f, 7.14415610e-02f, 7.06893355e-02f, 2.84023583e-01f,
  1.96850896e-01f, -9.98523012e-02f, -2.63765931e-01f, -9.36833546e-02f, 1.26182660e-01f, 4.41167876e-02f, -3.21413457e-01f, -1.02151513e-01f, -4.27043974e-01f, -1.26149803e-01f,
  4.37434405e-01f, -1.23051457e-01f, -9.07879472e-01f, 1.75170273e-01f, -5.34312665e-01f, -5.78726709e-01f, -4.02909100e-01f, 6.58510029e-02f, 2.47388020e-01f, 6.85859472e-02f,
  -3.48752767e-01f, 1.67086095e-01f, 9.75036547e-02f, 1.33051440e-01f, 2.54968345e-01f, 3.47081833e-02f, 2.35724181e-01f, 2.97485679e-01f, 1.88278556e-01f, 3.66844922e-01f,
  4.41069186e-01f, 6.52109683e-01f, 5.96743107e-01f, 4.23119158e-01f, 3.06043059e-01f, 2.91777253e-01f, -1.02816448e-02f, -5.76553121e-02f, -5.59008829e-02f, 2.89950162e-01f,
  -2.03557014e-01f, -2.10478842e-01f, -3.24842960e-01f, -5.07305115e-02f, -3.42553943e-01f, 4.18386906e-02f, -4.00714874e-02f, -1.75302885e-02f, 3.01952511e-02f, 1.95888147e-01f,
  -1.99086368e-01f, 4.84995311e-03f, 1.50209978e-01f, -3.15575078e-02f, -2.24876851e-02f, -1.42396584e-01f, 2.97129720e-01f, 1.39558658e-01f, 1.52785391e-01f, -9.03685242e-02f,
  1.88322723e-01f, -2.66075402e-01f, -6.90260828e-01f, -3.19542468e-01f, -1.05561309e-01f, 1.07632324e-01f, -2.21195936e-01f, -8.48925114e-02f, -2.25566313e-01f, 3.44996661e-01f,
  -1.67105168e-01f, -9.38825756e-02f, -2.75746174e-02f, -1.65647537e-01f, 2.38799676e-01f, -8.34758207e-03f, 5.74624091e-02f, 2.37661287e-01f, 3.90385501e-02f, -6.95985109e-02f,
  -9.54824872e-03f, -6.03947341e-02f, 2.59924047e-02f, -1.09189823e-01f, 2.16314852e-01f, -8.41044933e-02f, -1.07104801e-01f, 3.42822880e-01f, 2.33389392e-01f, -1.11104853e-01f,
  6.83659548e-03f, 4.55331132e-02f, -1.41043752e-01f, 2.14475513e-01f, -7.64696300e-02f, -1.30045220e-01f, 1.39763847e-01f, 2.02843234e-01f, 1.46364376e-01f, -1.44515306e-01f,
  2.32121542e-01f, -2.65886396e-01f, 1.71905965e-01f, 1.03775132e-03f, -3.97823304e-02f, 5.93397878e-02f, -4.23407629e-02f, 8.43624696e-02f, -1.62446573e-01f, 2.01237830e-03f,
  -2.74051458e-01f, -2.28964165e-02f, 1.14568979e-01f, 2.30839234e-02f, -9.32487100e-02f, -1.54306367e-01f, 9.95413959e-02f, -5.20226313e-04f, 2.47410133e-01f, -2.36436099e-01f,
  -1.85735654e-02f, -1.75106034e-01f, -3.03127885e-01f, -3.44827712e-01f, -1.51556030e-01f, 8.01199675e-02f, -2.18650296e-01f, -3.69860351e-01f, -4.31081593e-01f, 4.95872553e-03f,
  7.16471791e-01f, 4.10905093e-01f, -1.03623964e-01f, 7.25075379e-02f, -6.11628816e-02f, 3.10374033e-02f, 2.25886747e-01f, 2.41210520e-01f, 7.34641403e-02f, -3.81526090e-02f,
  3.63446921e-02f, -1.41366556e-01f, -8.44992176e-02f, -1.40076071e-01f, 2.31389944e-02f, -1.16500176e-01f, -1.59895435e-01f, -1.26100183e-01f, -1.61644548e-01f, -5.33858277e-02f,
  -5.33895791e-02f, 2.70345002e-01f, 2.54873276e-01f, 7.90763125e-02f, 2.53676567e-02f, -2.34750852e-01f, 1.09528385e-01f, 1.77558690e-01f, -1.92689121e-01f, -3.35010827e-01f,
  -1.48054853e-01f, 4.29642141e-01f, -3.37148130e-01f, 4.15339693e-02f, -1.16565246e-02f, 3.49975564e-02f, 1.26182595e-02f, 9.02970210e-02f, -6.63499981e-02f, 4.34064716e-02f,
  3.14077549e-02f, -4.66215648e-02f, 1.42647266e-01f, 1.28905833e-01f, 1.75712019e-01f, 8.20959359e-02f, 5.86218052e-02f, 3.69659215e-02f, 6.27877489e-02f, 4.41816002e-02f,
  -2.17057422e-01f, -2.32671853e-02f, 6.69993907e-02f, -8.28924626e-02f, -1.00189133e-03f, -1.07776962e-01f, 2.93567441e-02f, -1.84754655e-02f, -9.08034295e-02f, -2.52965074e-02f,
  -2.21918881e-01f, -1.71234190e-01f, -5.07106818e-02f, 4.32151295e-02f, -5.02721481e-02f, -2.38011722e-02f, -7.60945231e-02f, -9.12791789e-02f, -1.04587577e-01f, 2.80031152e-02f,
  -4.84393500e-02f, -5.99558502e-02f, -7.89208487e-02f, 9.07533243e-03f, -1.10934399e-01f, -6.35445863e-02f, 1.09506054e-02f, -2.34264624e-03f, -7.54190013e-02f, 4.51158397e-02f,
  -3.71814370e-02f, -6.42478466e-02f, 7.07383081e-02f, -7.90295452e-02f, -8.06745365e-02f, -6.37616888e-02f, 1.35841211e-02f, -1.00396350e-01f, 7.80842006e-02f, 1.60905242e-01f,
  2.97676504e-01f, 2.83552501e-02f, -1.84493110e-01f, -1.06608607e-01f, -2.34012529e-02f, 7.89727569e-02f, -1.49399871e-02f, -2.27242023e-01f, -2.78529171e-02f, 3.63636715e-03f,
  1.03614666e-02f, -1.19885050e-01f, 9.12872702e-02f, -3.67664099e-02f, -2.70712227e-02f, 2.45648287e-02f, -1.35786245e-02f, -2.51139551e-01f, -1.75562561e-01f, 6.06809184e-02f,
  -1.05460055e-01f, -9.30125415e-02f, -4.10385840e-02f, -2.13096350e-01f, -1.72905803e-01f, -1.93908587e-01f, -1.79386660e-01f, -8.07513446e-02f, -1.07891098e-01f, -3.73719223e-02f,
  -9.52676594e-01f, 2.66644925e-01f, -6.50302410e-01f, -5.28446972e-01f, -2.85958827e-01f, -2.01000229e-01f, 2.59518117e-01f, 4.01447028e-01f, 1.32568985e-01f, 2.60248750e-01f,
  1.19328901e-01f, -4.86424923e-01f, -6.44078910e-01f, -3.49501878e-01f, -1.56152874e-01f, 5.74572831e-02f, -4.17571574e-01f, -7.41145372e-01f, -5.48482001e-01f, 4.60505635e-02f,
  -1.25749528e-01f, -4.53914940e-01f, -5.50879002e-01f, -1.81517184e-01f, -8.48950967e-02f, -4.02245164e-01f, -4.11008954e-01f, -4.91114378e-01f, -2.77716279e-01f, -5.40874958e-01f,
  -7.04374388e-02f, -3.68641764e-01f, -2.27140239e-03f, -3.54934335e-01f, 1.16523176e-01f, 9.38502401e-02f, 3.34947929e-02f, -8.54676217e-02f, -1.23415597e-01f, 7.42945448e-02f,
  -4.38569993e-01f, 1.82045370e-01f, -2.44403958e-01f, -5.68859465e-02f, -9.25447196e-02f, 5.08192834e-03f, -3.09543490e-01f, -2.75083631e-01f, -1.95670307e-01f, 2.09024742e-01f,
  -1.59777299e-01f, -4.82847512e-01f, -3.80727619e-01f, 1.03041910e-01f, 4.10931349e-01f, -2.63136595e-01f, 2.95911878e-01f, 1.67115852e-01f, 9.93263908e-03f, 2.40380511e-01f,
  4.15047884e-01f, 3.40363145e-01f, 1.87802166e-01f, 4.82981242e-02f, 1.25277653e-01f, -1.22417375e-01f, -8.07395130e-02f, 9.93079469e-02f, 1.17133133e-01f, 6.11135848e-02f,
  9.49789062e-02f, 9.65342373e-02f, 8.97227973e-02f, -1.68347761e-01f, -1.94471270e-01f, -1.00554660e-01f, 1.09546863e-01f, 1.77123576e-01f, -2.59005800e-02f, -1.89317288e-05f,
  -8.83284435e-02f, -5.96726760e-02f, -1.76582620e-01f, 2.97095589e-02f, 7.74114057e-02f, 1.26372902e-02f, 4.39873226e-02f, 2.55630851e-01f, -6.27152994e-03f, -2.64281213e-01f,
  2.65969157e-01f, -3.05576921e-01f, 5.89866675e-02f, -2.93204915e-02f, -3.10373977e-02f, 9.30203311e-03f, -2.79179007e-01f, 1.20380454e-01f, -7.34633952e-02f, 2.12480903e-01f,
  1.22189773e-02f, 2.50229120e-01f, -1.76269382e-01f, 6.90728873e-02f, -7.31833279e-02f, 7.60287568e-02f, 1.91431735e-02f, -4.49636132e-01f, -1.51856452e-01f, 2.79593468e-01f,
  9.68636349e-02f, -1.59000188e-01f, -1.93181932e-01f, 4.02487703e-02f, 1.16935223e-01f, -4.52211261e-01f, 1.97524473e-01f, 1.50212109e-01f, -4.17582802e-02f, 6.72631145e-01f,
  8.70990098e-01f, -1.62860915e-01f, -3.84633780e-01f, 5.48452854e-01f, -4.18509245e-01f, -6.84757829e-01f, -8.01052272e-01f, -2.64939815e-01f, 3.72364908e-01f, -2.64043748e-01f,
  -3.59531164e-01f, 8.10526833e-02f, 4.37161386e-01f, -4.77115624e-03f, -2.37311944e-01f, -4.94926184e-01f, -2.87857056e-01f, -1.09816760e-01f, -4.53665525e-01f, -7.09644794e-01f,
  -3.70155275e-01f, 1.61840156e-01f, 1.24608591e-01f, 6.92388415e-02f, 3.35163511e-02f, 8.82970914e-02f, 4.70117014e-03f, 2.15670951e-02f, -4.69858170e-01f, -7.03436509e-03f,
  -4.76554245e-01f, -1.44593090e-01f, -2.47116461e-01f, 2.51515329e-01f, 1.20175488e-01f, 1.69828102e-01f, -1.60240784e-01f, 1.90852359e-01f, 7.88186491e-02f, -5.80447800e-02f,
  1.55047342e-01f, -1.63059711e-01f, 2.21508741e-01f, -1.17186330e-01f, -2.46444687e-01f, -2.26141453e-01f, 2.23794237e-01f, -1.29556745e-01f, 2.17700869e-01f, -2.77239799e-01f,
  -1.95087105e-01f, -1.35641575e-01f, 9.89835430e-03f, -9.73556340e-02f, -2.06415474e-01f, 1.63833767e-01f, -2.22169593e-01f, -3.34729552e-01f, -1.97488979e-01f, 1.23910487e-01f,
  -5.64282164e-02f, 6.11101910e-02f, -1.25069857e-01f, -1.58673882e-01f, 4.63549010e-02f, -1.19536621e-02f, 5.43697327e-02f, -7.44416416e-02f, -8.00058097e-02f, 1.63064357e-02f,
  -6.62728697e-02f, 6.93790466e-02f, -2.73260232e-02f, -2.65749474e-03f, 4.29845676e-02f, 3.02001592e-02f, 6.13323525e-02f, -1.96318068e-02f, 1.62400503e-03f, 1.44343851e-02f,
  -3.91654763e-03f, -1.05697615e-02f, 1.20715402e-01f, 3.73539850e-02f, -2.05874994e-01f, 6.27631843e-02f, 9.10185724e-02f, -6.27581403e-02f, 8.01961124e-02f, -1.43121436e-01f,
  4.48640615e-01f, -3.03083528e-02f, 1.53109625e-01f, -5.17917052e-03f, 4.85610581e-05f, -9.01580509e-03f, 2.62863338e-02f, -6.96573779e-02f, 1.41789511e-01f, -1.83223963e-01f,
  -3.21385503e-01f, -4.79337424e-02f, 3.06690097e-01f, -2.29654741e-02f, -1.92041755e-01f, -1.28012955e-01f, -1.54607639e-01f, -2.15034764e-02f, -1.47332340e-01f, -2.20310073e-02f,
  2.22740456e-01f, -7.83113167e-02f, 1.39116243e-01f, 1.07512534e-01f, -5.99071234e-02f, 1.38197899e-01f, -1.64358601e-01f, -1.78107277e-01f, -1.03786595e-01f, 1.90889776e-01f,
  -3.26067239e-01f, -2.18810022e-01f, 2.50585973e-01f, -1.01744689e-01f, 5.71328163e-01f, -2.85119981e-01f, -8.87166142e-01f, -9.08216059e-01f, -3.43760431e-01f, -1.16135003e-02f,
  5.58247507e-01f, 4.78662312e-01f, 2.34692663e-01f, 1.31243408e-01f, -3.61412585e-01f, -3.10971677e-01f, -1.10437877e-01f, 7.90237561e-02f, 1.73723578e-01f, 1.48083493e-01f,
  1.22266479e-01f, 3.54782015e-01f, 2.70879894e-01f, -1.94394693e-01f, 1.30690351e-01f, 2.32720286e-01f, 1.96109965e-01f, 3.28524053e-01f, 2.35089704e-01f, 1.38028547e-01f,
  2.96261281e-01f, -4.03793097e-01f, -2.44210139e-02f, 4.14116651e-01f, 4.25577492e-01f, -2.08811015e-01f, -3.83642524e-01f, -2.60198385e-01f, -1.76054031e-01f, -3.15742344e-01f,
  4.52255845e-01f, 8.64992589e-02f, 1.42281428e-01f, 1.63534001e-01f, 6.35460839e-02f, -2.47345582e-01f, -8.50008056e-02f, -2.32497975e-01f, -1.73030138e-01f, -3.49091440e-02f,
  3.18316758e-01f, 5.37951350e-01f, -7.87087679e-02f, -2.71800429e-01f, -3.07626963e-01f, 2.72286326e-01f, -4.59521376e-02f, -1.82500452e-01f, -1.79322019e-01f, -2.25113675e-01f,
  -3.89092639e-02f, 1.23547569e-01f, 5.15913852e-02f, -4.28715236e-02f, -7.18068257e-02f, 3.38835269e-03f, -1.49301767e-01f, 1.49953455e-01f, 1.89404160e-01f, -6.45627081e-02f,
  -1.42905444e-01f, 1.09386574e-02f, -2.00610496e-02f, -2.85904467e-01f, 7.96048939e-02f, -3.17354407e-03f, -1.20254003e-01f, -3.09307184e-02f, 9.11931414e-03f, -5.94645739e-02f,
  3.88607718e-02f, -7.72903413e-02f, 1.35362685e-01f, -3.81010056e-01f, -1.17272340e-01f, -1.22946031e-01f, -1.14687175e-01f, 1.65839225e-01f, 1.35453463e-01f, 2.02810168e-02f,
  4.10996526e-02f, 3.35934579e-01f, -2.59193331e-01f, -1.84827521e-01f, 1.29725337e-01f, 9.88392979e-02f, -7.24581480e-02f, -6.48249090e-02f, 5.65269776e-02f, -2.28909642e-01f,
  2.72249803e-02f, -1.37458473e-01f, 2.30026413e-02f, -1.19333312e-01f, 9.50035378e-02f, -1.02583602e-01f, 1.22877553e-01f, 8.36941823e-02f, -1.26077235e-01f, -1.08135588e-01f,
  -2.05714256e-01f, -1.85678229e-01f, -9.92980152e-02f, -2.60319918e-01f, -6.63994551e-02f, 9.47728083e-02f, 1.11248761e-01f, -3.80009897e-02f, -1.96628571e-01f, -3.09100121e-01f,
  -7.93963671e-01f, 2.01851457e-01f, -6.31142199e-01f, -9.99147296e-02f, 3.89228731e-01f, 2.51354575e-01f, 2.23922327e-01f, 8.08627233e-02f, 1.70401067e-01f, -8.81758239e-03f,
  1.10059716e-01f, 3.38630319e-01f, -8.34137052e-02f, 1.30621959e-02f, -3.25989515e-01f, -3.75102833e-02f, 5.65852076e-02f, -4.84802663e-01f, -2.61481136e-01f, 4.49917197e-01f,
  6.21377587e-01f, -3.92488874e-02f, -5.28857052e-01f, -2.11550400e-01f, 1.44721553e-01f, -1.76387150e-02f, -4.04728264e-01f, -1.14969499e-01f, 3.33250389e-02f, -1.26781017e-01f,
  -6.48047090e-01f, -3.44457805e-01f, 1.16137952e-01f, 3.66676860e-02f, -2.00883448e-01f, -3.18218529e-01f, -1.99135616e-01f, -3.47902626e-01f, -4.21683602e-02f, -3.35809350e-01f,
  -1.10536985e-01f, -1.28921971e-01f, 7.01534152e-02f, 7.43607134e-02f, -2.74355952e-02f, -2.82227606e-01f, -2.13896453e-01f, -5.76552272e-01f, -6.97568417e-01f, -4.67487186e-01f,
  7.75050104e-01f, 2.56899655e-01f, -7.55634785e-01f, -2.44121030e-01f, -2.39899337e-01f, -2.57424384e-01f, -3.84039700e-01f, -2.69096822e-01f, -6.58363640e-01f, -7.19604671e-01f,
  1.56094298e-01f, -1.81529485e-02f, 7.09403530e-02f, 5.00531755e-02f, 3.36081758e-02f, 1.54701114e-01f, -4.26805690e-02f, 9.32743847e-02f, 5.09829484e-02f, -9.02583301e-02f,
  1.62026331e-01f, -7.17075616e-02f, -9.11729038e-02f, -2.44938940e-01f, -1.19934306e-01f, 7.12533593e-02f, 6.67997822e-02f, -1.17074527e-01f, -2.27783978e-01f, 5.55336177e-02f,
  3.23501043e-02f, -7.86438584e-02f, 9.05971378e-02f, -5.14840595e-02f, -4.04404439e-02f, -2.09785812e-02f, 1.57758564e-01f, 2.00916737e-01f, 1.28851444e-01f, 1.30034477e-01f,
  -2.21652791e-01f, 1.80439815e-01f, -3.51666540e-01f, 2.36862093e-01f, -1.90299943e-01f, -3.44506651e-02f, -6.56924620e-02f, 1.30968109e-01f, -5.14936559e-02f, -2.17280984e-01f,
  -9.50780213e-02f, -1.31948218e-01f, 7.63711939e-03f, 3.33543979e-02f, -9.10095796e-02f, -6.81318119e-02f, -1.55061642e-02f, -1.41586959e-01f, 1.39487788e-01f, -2.15899915e-01f,
  -2.23523639e-02f, -1.21857010e-01f, -4.31830496e-01f, -3.16871285e-01f, 2.60463767e-02f, -4.62540418e-01f, -5.24676085e-01f, -2.47306079e-01f, -5.02345920e-01f, -4.99301404e-01f,
  -2.50077397e-01f, -2.00956583e-01f, 4.71528411e-01f, 7.41861984e-02f, 1.14382394e-01f, -1.03727035e-01f, -9.66784805e-02f, -3.61380428e-02f, -6.92971945e-02f, -1.76572055e-01f,
  -3.40166688e-01f, -2.65058875e-01f, -2.95291636e-02f, 1.88102480e-02f, 9.07623172e-02f, 1.72520861e-01f, 4.30478930e-01f, 4.64460015e-01f, 2.32720450e-01f, -2.86942329e-02f,
  8.10200069e-03f, 1.59383819e-01f, 8.01163167e-02f, 2.61300117e-01f, 1.49043813e-01f, 1.10638037e-01f, 1.22766882e-01f, 1.17789879e-01f, -9.66231991e-03f, 1.14380553e-01f,
  -5.58139086e-01f, -1.69826418e-01f, 1.06066279e-01f, -1.63064301e-01f, 3.69232222e-02f, -1.32758141e-01f, -1.34719029e-01f, 7.65224099e-02f, -1.37485325e-01f, -6.04742207e-02f,
  -5.46821840e-02f, 2.71049468e-03f, 1.68179832e-02f, 1.95322782e-02f, 3.65044251e-02f, -1.11997992e-01f, 1.08850531e-01f, 2.23052204e-01f, 8.93483125e-03f, -1.19814225e-01f,
  -1.60597730e-02f, -7.66992867e-02f, -4.00723219e-02f, -2.87671518e-02f, 4.47361730e-02f, -7.44880065e-02f, -2.62045022e-02f, 3.96333123e-03f, -9.09682140e-02f, -1.03821315e-01f,
  1.30061843e-02f, 8.55460092e-02f, 9.54266191e-02f, 1.50825188e-01f, 8.40042681e-02f, -8.56253877e-02f, 1.40614688e-01f, -7.78587908e-02f, 1.14271834e-01f, 1.05723098e-01f,
  1.22294277e-01f, -1.19265310e-01f, 5.80494665e-02f, 6.22801716e-03f, -6.68393672e-02f, -8.30839947e-02f, 3.89968641e-02f, -8.13519657e-02f, -4.52525057e-02f, -2.08797231e-02f,
  -4.00802456e-02f, 2.04537008e-02f, -1.89239867e-02f, 1.70706302e-01f, -7.92912319e-02f, 1.38867930e-01f, -4.32853252e-02f, -9.09753218e-02f, -6.18511811e-02f, -9.19210762e-02f,
  -2.51298368e-01f, 6.28899112e-02f, -2.37333268e-01f, -1.46531956e-02f, -7.08790496e-02f, 1.10030230e-02f, -2.57860273e-01f, -1.09091394e-01f, 7.85873979e-02f, -9.43943933e-02f,
  -1.53731629e-01f, -1.86073966e-02f, 1.85321569e-02f, 9.64265838e-02f, 6.62559494e-02f, -4.96300384e-02f, -4.81801331e-02f, 6.74805185e-03f, -7.14751333e-02f, 2.45936564e-04f,
  5.08972593e-02f, -1.06477655e-01f, -2.63830394e-01f, -1.26393251e-02f, -4.22149524e-02f, -1.64898098e-01f, 7.57237244e-03f, -2.61804909e-02f, -2.45802149e-01f, -2.80331284e-01f,
  8.51539731e-01f, -6.37901962e-01f, 5.28065622e-01f, 1.68710724e-01f, -2.72813171e-01f, -1.55422583e-01f, -3.85405749e-01f, -1.59972042e-01f, 1.05239190e-01f, -2.37072930e-01f,
  -4.48089659e-01f, -1.95008963e-01f, 1.52461873e-02f, 1.10142440e-01f, 2.10979044e-01f, -4.25446160e-05f, 2.32097924e-01f, 6.47143483e-01f, 5.60432255e-01f, -3.76860127e-02f,
  -2.83999979e-01f, -2.90851714e-03f, 2.96167672e-01f, 2.78911889e-01f, -2.03435585e-01f, 4.06155810e-02f, -1.20250508e-02f, -1.80665944e-02f, -7.61728287e-02f, 4.54367846e-02f,
  -1.80950865e-01f, -8.76509175e-02f, 2.15296745e-01f, -9.72682536e-02f, -1.02635160e-01f, 4.36572209e-02f, 5.48537076e-02f, 4.80724685e-03f, -5.18962182e-02f, -6.28190115e-02f,
  -1.20941199e-01f, -8.53552520e-02f, -2.46898923e-02f, -4.30895165e-02f, -9.02641118e-02f, -1.85662322e-02f, -6.04935884e-02f, -5.67807909e-03f, -2.88770162e-02f, -2.09448189e-01f,
  -3.54673088e-01f, -9.59165618e-02f, 2.37544309e-02f, -6.36503547e-02f, 3.03698517e-02f, 1.59576908e-01f, -1.05021589e-01f, -3.85427773e-02f, 8.52481946e-02f, -1.08006775e-01f,
  9.05306265e-02f, 1.18939364e-02f, -1.09785691e-01f, 3.10776811e-02f, 3.79347913e-02f, 3.12206615e-02f, 3.65218380e-03f, -6.54883906e-02f, 9.40563008e-02f, -8.90155062e-02f,
  -1.10395819e-01f, -3.10776737e-02f, 3.67106572e-02f, -1.53997898e-01f, -3.42816561e-02f, -1.71922762e-02f, -6.56258538e-02f, -1.13335468e-01f, 1.60324015e-02f, 1.36831068e-02f,
  -5.33493049e-03f, -8.93733054e-02f, -6.10364638e-02f, -9.24383178e-02f, -2.38953441e-01f, -6.55839816e-02f, 7.21232966e-03f, -4.63449657e-02f, -7.33453333e-02f, -2.89220568e-02f,
  -4.35316086e-01f, 3.16453785e-01f, 1.93458334e-01f, 5.48775010e-02f, 4.89696190e-02f, 1.10849710e-02f, 5.80449402e-02f, -2.03321427e-02f, -1.33166369e-03f, 3.21635120e-02f,
  4.30762097e-02f, 9.56062600e-02f, -4.12447229e-02f, -1.27973691e-01f, 3.66307050e-02f, -1.44689260e-02f, -1.22274369e-01f, -3.67704593e-03f, -3.51708336e-03f, -1.73516378e-01f,
  -1.21169962e-01f, 4.41917703e-02f, 2.21323535e-01f, 2.28418373e-02f, 9.26679894e-02f, 2.15613112e-01f, -1.37819978e-03f, -6.73867390e-02f, 1.92991018e-01f, -6.51596785e-02f,
  4.95339930e-01f, 3.90692383e-01f, -3.06424350e-01f, 2.47244492e-01f, 3.07527464e-02f, -2.78960735e-01f, -2.28736207e-01f, -2.99092948e-01f, -1.41139433e-01f, 2.18161102e-03f,
  2.81194169e-02f, 1.47277340e-01f, -1.32643841e-02f, -3.13820578e-02f, 1.17134340e-02f, 4.97959517e-02f, 1.44573718e-01f, 1.65456668e-01f, -7.37215132e-02f, 1.43677160e-01f,
  2.86437839e-01f, 2.17080519e-01f, 1.42707199e-01f, 2.23716915e-01f, 3.73697042e-01f, 7.85776004e-02f, -1.54798016e-01f, 2.21546918e-01f, 1.91776171e-01f, 5.51384628e-01f,
  5.15913188e-01f, -1.36032272e-02f, -4.36178893e-01f, 7.35730156e-02f, 1.91338658e-02f, 1.61436737e-01f, 1.02704018e-02f, 1.09661650e-03f, 9.89557654e-02f, 1.97488904e-01f,
  2.94464707e-01f, 8.25447738e-02f, 5.79969622e-02f, -2.26585213e-02f, -1.16310515e-01f, -1.68695182e-01f, -9.03195143e-02f, -4.77845967e-02f, -1.77602217e-01f, -4.11086641e-02f,
  6.15517378e-01f, 3.02260518e-01f, -1.19190842e-01f, -3.47833693e-01f, -2.43324742e-01f, -1.20169789e-01f, -1.78043157e-01f, 1.05592169e-01f, -3.76332194e-01f, 2.42040515e-01f,
  -2.25339174e-01f, -2.85825245e-02f, -1.82969943e-02f, 2.19275519e-01f, 1.54608816e-01f, 1.46472650e-02f, 1.75921574e-01f, 2.08201990e-01f, 3.10430937e-02f, 8.50861594e-02f,
  -5.36124296e-02f, -1.75977871e-01f, -1.35981947e-01f, -5.72741032e-02f, -7.15572983e-02f, 6.23125024e-02f, 2.04102546e-01f, 1.10766746e-01f, -8.33002031e-02f, -1.63686514e-01f,
  1.07665300e-01f, -3.56174149e-02f, -1.33902505e-01f, 7.90225621e-03f, -6.45809621e-02f, -2.13416889e-01f, 1.18072607e-01f, -3.20770517e-02f, 9.83921438e-02f, 7.17142820e-02f,
  -4.06095415e-01f, -6.13441825e-01f, 7.42762238e-02f, -4.16063406e-02f, -5.35563789e-02f, -2.12132096e-01f, 8.24817568e-02f, -6.75209239e-02f, 1.40765309e-01f, 1.35487139e-01f,
  -1.25547394e-01f, 5.39206155e-02f, -1.31623864e-01f, -7.10959509e-02f, -2.76500046e-01f, -2.12908432e-01f, 2.45908201e-02f, 1.83098614e-01f, -1.90707490e-01f, 2.40990575e-02f,
  9.10150409e-02f, -1.44057468e-01f, -3.07690911e-02f, -2.97962427e-01f, -7.57297128e-02f, -2.86870927e-01f, -1.76735461e-01f, -1.37206689e-01f, -4.54029530e-01f, -3.33597749e-01f,
  -8.45878124e-01f, -5.17303705e-01f, 6.37964964e-01f, -8.60755295e-02f, 2.44986601e-02f, -2.75481761e-01f, -3.77311647e-01f, -1.94294721e-01f, -1.59329042e-01f, -6.16839081e-02f,
  1.70171596e-02f, 2.36310989e-01f, 3.13245416e-01f, 2.22293511e-01f, 1.12495780e-01f, 1.48184553e-01f, 2.91290253e-01f, 2.94938684e-01f, 1.60324976e-01f, -2.61210620e-01f,
  -1.46505460e-01f, 3.74387428e-02f, -1.67342007e-01f, 3.90942544e-02f, 8.72708559e-02f, -1.45597076e-02f, 2.13784277e-01f, 1.17034532e-01f, -9.77547988e-02f, 1.45265654e-01f,
  5.60761333e-01f, -4.39465553e-01f, 5.03323972e-02f, -9.56881419e-02f, -8.65871385e-02f, -1.47584513e-01f, -1.37305379e-01f, -1.87870488e-02f, -7.05104917e-02f, -2.21595857e-02f,
  -5.33301868e-02f, -8.35389718e-02f, 2.98282560e-02f, 5.96549921e-02f, -7.33121261e-02f, -7.47922361e-02f, -1.17707714e-01f, 1.03567414e-01f, -3.46289426e-02f, -3.32739465e-02f,
  -4.25118208e-02f, -2.53187586e-02f, 1.69615597e-01f, 7.14079291e-02f, -1.38524845e-02f, 8.61071944e-02f, 1.89922228e-02f, -2.09232017e-01f, -4.61033508e-02f, -1.89799309e-01f,
  -4.77532968e-02f, 9.75099504e-02f, 5.06773628e-02f, 5.10520078e-02f, 4.47829738e-02f, 3.08900811e-02f, 5.42444959e-02f, 6.82297051e-02f, 1.06818475e-01f, 1.12767681e-01f,
  -9.54920650e-02f, 8.58647078e-02f, 1.18319280e-01f, 1.83380861e-02f, -8.72895122e-03f, 9.33630392e-02f, -3.72895151e-02f, 2.64485721e-02f, -1.03152819e-01f, -2.27268580e-02f,
  -2.98380293e-03f, 5.04400535e-03f, -2.61448491e-02f, -1.71625288e-03f, -6.26685545e-02f, 4.80590872e-02f, -1.10695846e-01f, -8.21230859e-02f, 1.16362676e-01f, -3.22640464e-02f,
  4.31432843e-01f, 7.35498890e-02f, 1.26967967e-01f, -7.18810931e-02f, -5.61660563e-04f, -1.34295449e-01f, -4.47511747e-02f, -8.93525854e-02f, -5.38477637e-02f, -7.28967264e-02f,
  -2.06774965e-01f, -1.02456957e-01f, -2.65722815e-03f, -2.31264811e-02f, -6.62188530e-02f, -1.37792751e-01f, -6.08883649e-02f, 1.94588289e-01f, 3.23172808e-02f, -5.12294993e-02f,
  -7.29352385e-02f, 1.89404108e-03f, 1.15054518e-01f, 1.33056268e-01f, -7.10036531e-02f, 1.67680420e-02f, 1.19097091e-01f, -1.35281449e-02f, 2.77948231e-02f, -9.97654349e-02f,
  4.19132233e-01f, -3.60920459e-01f, -7.61688173e-01f, 3.67062092e-01f, 2.29822621e-01f, 2.50238121e-01f, 4.57848489e-01f, 5.20473480e-01f, 4.28604513e-01f, 2.12581530e-01f,
  -2.90305942e-01f, -5.24890900e-01f, -5.90583026e-01f, -3.24917912e-01f, -2.54563302e-01f, 4.16656397e-02f, -1.22061931e-02f, -2.41349280e-01f, -8.96645430e-03f, 2.97674775e-01f,
  2.01750487e-01f, 2.52294034e-01f, 1.70901448e-01f, -1.26119867e-01f, -2.31188744e-01f, -3.27359378e-01f, -4.44072247e-01f, -2.14463800e-01f, -2.77117163e-01f, -6.09473646e-01f,
  -4.65631783e-01f, -3.03637266e-01f, 1.50856361e-01f, 6.72167167e-02f, -1.14879973e-01f, -1.83199625e-02f, 2.27930229e-02f, 4.14963719e-03f, 3.12207062e-02f, 3.20249088e-02f,
  -1.08340085e-01f, -7.55146518e-02f, 9.04615689e-03f, -1.71425819e-01f, 5.52671440e-02f, -4.44392599e-02f, -7.27108642e-02f, 3.90488841e-02f, -1.68110639e-01f, -6.11236952e-02f,
  -7.35106841e-02f, 7.28184264e-03f, 1.27491131e-01f, 7.47010410e-02f, -3.78076620e-02f, 1.78143866e-02f, -1.30316228e-01f, -1.18430085e-01f, -9.86419097e-02f, 2.04196006e-01f,
  2.16473371e-01f, 4.66859248e-03f, -1.19705454e-01f, 9.35746804e-02f, 1.14231966e-01f, 4.50472385e-02f, -4.06886153e-02f, 1.44014396e-02f, -1.08738430e-01f, -1.03373837e-03f,
  4.32191938e-02f, -9.19028819e-02f, -1.64447501e-01f, 1.95403956e-02f, -1.82125703e-01f, -6.20523170e-02f, 6.53003827e-02f, 3.36264819e-02f, -1.70177057e-01f, 7.81060904e-02f,
  1.54876774e-02f, -4.10503112e-02f, -1.15610778e-01f, -7.70066399e-03f, -9.05874968e-02f, -2.27857754e-02f, -9.44126323e-02f, -1.60645679e-01f, 4.14158478e-02f, 9.29360688e-02f,
  -8.42457563e-02f, -1.08535983e-01f, 2.71728411e-02f, -2.15438418e-02f, -1.18219927e-01f, -4.58906256e-02f, -3.00192505e-01f, -1.06890880e-01f, -3.02380007e-02f, -9.50103849e-02f,
  -1.08172961e-01f, -5.77830710e-02f, -1.75309777e-01f, -4.28620167e-02f, 1.65561378e-01f, -3.45504917e-02f, -4.84866276e-02f, 2.01692861e-02f, -1.68158263e-01f, -2.64451411e-02f,
  -1.87029596e-02f, 2.06083193e-01f, 3.36254507e-01f, 1.77223906e-01f, 2.03720387e-02f, 1.60190299e-01f, 9.14843380e-02f, 1.09599903e-01f, 1.17200375e-01f, 4.64784443e-01f,
  9.09307182e-01f, 5.39725602e-01f, 1.25385836e-01f, 2.05388784e-01f, -1.93749890e-01f, -2.50992835e-01f, 5.72876222e-02f, 1.77711368e-01f, -4.01949650e-03f, 2.76799172e-01f,
  1.19527072e-01f, 1.41316369e-01f, 2.45960634e-02f, 6.40881807e-02f, 1.17651127e-01f, -1.36502489e-01f, -1.47349983e-01f, 3.02324314e-02f, -2.67744847e-02f, 3.31672728e-02f,
  -5.06903157e-02f, 1.58045262e-01f, 3.19279790e-01f, 3.38577144e-02f, 7.97508508e-02f, -1.17680892e-01f, 1.06585734e-01f, 1.12456404e-01f, 3.84753710e-03f, 5.19742854e-02f,
  -1.10000230e-01f, 2.31545895e-01f, -1.72781602e-01f, 2.01660898e-02f, 5.44525087e-02f, 1.31373122e-01f, -7.13209482e-03f, 6.22643493e-02f, 5.10310382e-02f, -1.69085279e-01f,
  -2.62479708e-02f, 5.26892953e-02f, -9.58766192e-02f, -1.03131495e-02f, -3.93569991e-02f, -8.39456245e-02f, -9.77378041e-02f, 3.35123129e-02f, -7.27490261e-02f, -1.17571518e-01f,
  -1.98934344e-03f, -1.10656403e-01f, -1.85586050e-01f, -2.35583350e-01f, -1.16662256e-01f, -1.19482428e-01f, 1.20507646e-03f, 2.83549353e-02f, -1.61855623e-01f, 7.68457726e-02f,
  -4.01923865e-01f, 1.16959639e-01f, -8.58339667e-02f, -1.00573272e-01f, -1.95843682e-01f, -1.72665566e-01f, -6.75291345e-02f, -1.47344038e-01f, 6.24390738e-03f, -4.53173928e-02f,
  -1.21788099e-01f, -9.86363292e-02f, 9.99520719e-03f, -2.01690644e-02f, -7.30856284e-02f, -1.12018948e-02f, -5.08577675e-02f, -1.28814623e-01f, -2.22192049e-01f, -1.16441153e-01f,
  -9.50168818e-02f, -2.07667239e-02f, 2.20815055e-02f, -1.80897992e-02f, -9.66163576e-02f, -1.81698009e-01f, -1.18131168e-01f, -1.11978255e-01f, 6.50532097e-02f, 1.38674170e-01f,
  -3.63973379e-01f, -2.34041139e-01f, -7.12360144e-02f, 1.51089281e-01f, 1.58616349e-01f, 2.39913881e-01f, 3.62842605e-02f, 9.36742201e-02f, 4.43150941e-03f, -1.12962201e-01f,
  -7.65763521e-02f, 1.88298970e-01f, 8.09724480e-02f, 1.30937044e-02f, -1.27872854e-01f, -7.45808333e-02f, 1.62581801e-01f, 1.52502596e-01f, -4.06114757e-02f, -1.23329841e-01f,
  -4.22668308e-02f, -2.13382058e-02f, 4.34563356e-03f, -9.78517234e-02f, -2.51553506e-02f, -7.94220902e-03f, -1.57580167e-01f, -3.10591701e-02f, -1.09032884e-01f, -9.29890200e-02f,
  1.42960012e-01f, -7.52483964e-01f, 6.34682737e-03f, -2.50749201e-01f, -2.36924022e-01f, 7.04759881e-02f, -4.56367344e-01f, -1.10967636e-01f, -8.21444169e-02f, -3.91234577e-01f,
  1.27352789e-01f, 7.46221602e-01f, 6.28097653e-01f, 6.66375220e-01f, 5.61614692e-01f, -6.40734375e-01f, -3.69413316e-01f, 4.60060596e-01f, 8.74555945e-01f, 1.80040821e-01f,
  -2.31373459e-01f, -1.46041080e-01f, 2.09081247e-01f, 5.88699356e-02f, -6.54692888e-01f, 3.83488163e-02f, -5.10606945e-01f, -3.56722534e-01f, -2.41875499e-01f, -5.57037592e-01f,
  5.47960401e-02f, -1.21999405e-01f, 3.35813165e-01f, 2.89380699e-01f, -1.11154512e-01f, -1.14601236e-02f, -6.43101558e-02f, -2.84079127e-02f, 1.24797724e-01f, -1.31118596e-01f,
  7.88845345e-02f, -1.30126793e-02f, -1.01520076e-01f, -2.72925477e-02f, -2.32990712e-01f, -1.06476314e-01f, -1.94109574e-01f, 1.79947019e-01f, 1.14223935e-01f, -1.25278041e-01f,
  -3.69309545e-01f, -3.08983028e-01f, -4.01156470e-02f, -1.07038483e-01f, 6.25368878e-02f, 2.98433691e-01f, -1.42902270e-01f, -2.96727885e-02f, 7.97604397e-02f, -8.34346414e-01f,
  -1.09445482e-01f, -5.08471280e-02f, -8.45828429e-02f, 5.03134821e-03f, 1.45213958e-02f, 1.07942842e-01f, 5.83513752e-02f, 1.68921649e-02f, 2.83283088e-02f, -1.11203417e-01f,
  6.37468472e-02f, -1.45710772e-02f, 1.59117877e-01f, -2.29698271e-01f, 1.00190169e-03f, -1.29100949e-01f, -2.47934659e-04f, -7.44594559e-02f, 1.35782883e-02f, 2.54613850e-02f,
  1.29819646e-01f, -9.71901491e-02f, 1.07251450e-01f, 1.01194791e-01f, 5.41039966e-02f, 4.24908958e-02f, -2.04019342e-03f, 8.75626430e-02f, 4.97616529e-02f, -1.94008976e-01f,
  2.79608695e-03f, 3.99236411e-01f, -7.67171606e-02f, 1.53434008e-01f, -1.61448821e-01f, 2.24731937e-01f, -6.12181313e-02f, 1.05777122e-01f, 2.00465649e-01f, 1.60233095e-01f,
  1.35449007e-01f, 9.75417271e-02f, -1.02189995e-01f, -1.23511977e-01f, -1.30044684e-01f, 7.84810111e-02f, -1.05016962e-01f, 2.10947052e-01f, 1.90606490e-01f, -2.55466163e-01f,
  -2.97925204e-01f, -1.62625755e-03f, 3.51875201e-02f, 4.30640811e-03f, -1.52115077e-01f, 1.87003613e-01f, -4.74065877e-02f, -1.18015902e-02f, 2.31213957e-01f, -5.50773323e-01f,
  -3.77723165e-02f, 5.03674328e-01f, 2.08009839e-01f, 2.25859389e-01f, -6.58860952e-02f, 2.52001882e-01f, 3.30721885e-01f, 4.20736223e-01f, 9.76217911e-02f, 7.85870776e-02f,
  -5.05916774e-02f, -9.78532434e-02f, 2.06048880e-02f, 2.62797568e-02f, 1.40046462e-01f, 2.83925712e-01f, 4.13188964e-01f, 6.73080012e-02f, -4.68258522e-02f, 6.84717372e-02f,
  3.62785012e-02f, 1.35047194e-02f, 8.56269617e-03f, 1.36322975e-01f, 1.53209835e-01f, -4.49362621e-02f, 1.06345631e-01f, 3.90474871e-02f, 1.05930604e-01f, 3.58430684e-01f,
  -2.18105763e-01f, 1.41128246e-02f, -1.02490619e-01f, -2.00335532e-01f, -2.32653797e-01f, -7.34672844e-02f, -1.65139467e-01f, -7.14130048e-03f, 5.08517250e-02f, 1.59824520e-01f,
  2.65189968e-02f, -3.18590067e-02f, -1.97453946e-01f, 2.32651345e-02f, 3.49120679e-03f, -7.22447857e-02f, 4.85647358e-02f, 1.61388233e-01f, 1.77922934e-01f, 5.71523234e-02f,
  6.65643662e-02f, 6.08305410e-02f, 2.32981488e-01f, 2.14663781e-02f, -1.15322918e-01f, -5.02090976e-02f, -1.55426085e-01f, -1.07121117e-01f, -1.03180800e-02f, 9.22923684e-02f,
  -5.94681576e-02f, 1.82954088e-01f, -3.92904840e-02f, -7.67377988e-02f, -6.83523342e-02f, 1.98162589e-02f, 7.08732307e-02f, -1.67034157e-02f, -9.72722694e-02f, -1.76434025e-01f,
  -6.41131252e-02f, -3.89607856e-03f, 1.13448361e-02f, -2.79816657e-01f, -2.47517854e-01f, 1.07354388e-01f, 9.38630477e-02f, -2.44698618e-02f, -1.90497339e-01f, 1.13231204e-01f,
  -1.70259997e-01f, 2.13495955e-01f, -5.34400519e-04f, -1.52418250e-02f, -1.86718572e-02f, 4.79685055e-04f, 8.63244087e-02f, -8.40002820e-02f, 4.56959195e-02f, 2.95191072e-02f,
  -4.42776717e-02f, -4.86635745e-01f, -7.63015077e-02f, 1.95832878e-01f, 1.03484377e-01f, -3.91183272e-02f, -3.10116168e-03f, 7.23713189e-02f, 1.01816664e-02f, 1.71307847e-01f,
  3.41268405e-02f, 5.35933264e-02f, -9.31634456e-02f, 2.88288487e-04f, -2.09757462e-01f, -6.62059635e-02f, -1.34560680e-02f, 1.34323284e-01f, 1.38991117e-01f, 1.70317084e-01f,
  6.27499893e-02f, 9.90710407e-02f, 1.74043760e-01f, -7.01061189e-02f, -9.16386470e-02f, -1.26019061e-01f, -9.90429670e-02f, -4.86971363e-02f, -1.54744267e-01f, -1.96665198e-01f,
  6.63454711e-01f, 1.65479735e-01f, 1.83268130e-01f, 3.19587022e-01f, -1.44242406e-01f, -2.45384306e-01f, -3.21365714e-01f, -2.19418019e-01f, 2.10729949e-02f, 1.92455083e-01f,
  1.35019198e-01f, 7.25854784e-02f, 5.57599738e-02f, 9.72615778e-02f, -4.52433601e-02f, 6.81482852e-02f, -5.40999603e-03f, 3.04429293e-01f, 1.84925273e-01f, 1.37363672e-01f,
  2.36650139e-01f, 2.06565112e-01f, 1.39194638e-01f, 2.16110080e-01f, 2.54725486e-01f, 1.88580960e-01f, 6.59751222e-02f, 1.34553537e-01f, 1.75381437e-01f, 4.61302698e-01f,
  5.71942151e-01f, 1.51252046e-01f, -1.87669441e-01f, 6.70167208e-02f, 4.86673303e-02f, 3.77301499e-02f, 6.36735559e-02f, 8.88170558e-04f, -4.28134724e-02f, -4.74381680e-03f,
  -7.00646639e-02f, 2.66658999e-02f, 2.09933203e-02f, 2.65373830e-02f, -6.65249154e-02f, -7.64153376e-02f, 1.56455897e-02f, 9.08808336e-02f, -5.02384268e-03f, 2.62675621e-02f,
  -2.94662677e-02f, 4.44587134e-03f, -1.52209908e-01f, -1.36725321e-01f, -4.99281399e-02f, 2.83862650e-02f, -9.06952377e-03f, 3.17055210e-02f, -1.20189816e-01f, 1.23336621e-01f,
  1.31436497e-01f, 1.04240678e-01f, 1.66949406e-01f, 1.92546248e-01f, 1.38692960e-01f, 9.14802924e-02f, 1.48144187e-02f, 8.36507529e-02f, -3.27439159e-02f, 7.33541176e-02f,
  1.32626310e-01f, 1.57990739e-01f, -2.09150407e-02f, 1.23282023e-01f, 1.86689630e-01f, -5.83806410e-02f, 4.99022119e-02f, -7.26797655e-02f, 6.11376530e-03f, -6.96353391e-02f,
  1.23049647e-01f, -7.31402040e-02f, -6.18456639e-02f, 2.42897328e-02f, 3.74011658e-02f, 3.40496413e-02f, 1.13506295e-01f, 1.51713286e-02f, -8.92306864e-02f, -4.25152294e-02f,
  -5.72422326e-01f, -4.02170867e-01f, 3.18180531e-01f, 3.60030420e-02f, 2.90947948e-02f, -5.66439442e-02f, -8.45049098e-02f, -3.53131257e-02f, -4.37752791e-02f, -3.71992886e-02f,
  -1.19801313e-01f, -4.93553020e-02f, -1.54914841e-01f, -9.75285172e-02f, 1.05452659e-02f, -5.93234859e-02f, -2.76837982e-02f, -9.86544117e-02f, -1.82947114e-01f, 1.60739254e-02f,
  -1.28063440e-01f, -2.56920904e-01f, -1.59538522e-01f, -1.68660849e-01f, -1.41523808e-01f, -2.22754553e-01f, -1.14397056e-01f, -2.08950326e-01f, -3.16266209e-01f, -8.58535543e-02f,
  -4.23846990e-01f, -7.42219865e-01f, 5.64105451e-01f, -5.27977645e-02f, 5.18849134e-01f, 2.35473603e-01f, -2.72059329e-02f, -2.58289546e-01f, -3.39993052e-02f, -3.36841196e-02f,
  -1.33122176e-01f, -2.40239218e-01f, -1.61073342e-01f, -1.70277387e-01f, -2.43869260e-01f, 7.18830377e-02f, 2.35256508e-01f, 2.70681441e-01f, 3.19229305e-01f, 1.72063589e-01f,
  6.54034913e-02f, 4.53061275e-02f, -3.07655595e-02f, -1.25770435e-01f, 7.70643502e-02f, 7.77175203e-02f, 3.39999013e-02f, 2.42727157e-02f, 7.30951782e-03f, 1.45382077e-01f,
  4.14665520e-01f, -4.25254852e-01f, 1.47517696e-01f, -2.44057864e-01f, -1.63620245e-02f, -2.21603677e-01f, 7.20799565e-02f, -9.80427023e-03f, -2.03080952e-01f, -1.32067269e-02f,
  -4.48272191e-02f, -6.94781495e-03f, -6.16342984e-02f, 9.28870589e-02f, 1.05644070e-01f, 3.99060287e-02f, -1.52540579e-01f, -2.10743219e-01f, -2.69676089e-01f, -1.79569215e-01f,
  -2.00075239e-01f, 8.00165981e-02f, 1.61718309e-01f, -1.06226698e-01f, -1.54503047e-01f, 1.54649481e-01f, 4.14912850e-02f, -2.78853718e-02f, -5.83865382e-02f, -7.19601065e-02f,
  -9.90813784e-03f, 6.46815971e-02f, 2.84015443e-02f, 1.81866381e-02f, 2.33044084e-02f, -7.88158551e-02f, 3.07921953e-02f, -2.24415474e-02f, 7.05320388e-02f, 4.50499915e-02f,
  -2.61759502e-03f, -1.88770518e-02f, -6.62041157e-02f, -7.40477219e-02f, -4.39545587e-02f, -5.60096353e-02f, 7.89112374e-02f, -8.98675099e-02f, 3.78705338e-02f, 5.37628718e-02f,
  -8.06423351e-02f, 7.19393417e-02f, -8.00297856e-02f, -5.29223420e-02f, -3.59195918e-02f, -1.14127345e-01f, -1.31088346e-02f, -1.34817943e-01f, 2.86211595e-02f, -4.73133177e-02f,
  7.31917992e-02f, -3.72679532e-01f, 3.46127823e-02f, -2.20061600e-01f, -5.20970859e-02f, -1.14933424e-01f, -4.24444713e-02f, -1.44791394e-01f, 2.80460939e-02f, -4.91906926e-02f,
  -1.16850890e-01f, -3.59722599e-03f, -3.58791687e-02f, 5.70739172e-02f, 2.32190311e-01f, 2.57626548e-02f, -1.75766528e-01f, -4.15234081e-02f, -7.41917938e-02f, 1.59465745e-02f,
  -1.58216849e-01f, 1.24078080e-01f, 2.26454496e-01f, 1.30955204e-01f, -5.68676321e-03f, 2.49756142e-01f, 1.77268445e-01f, 2.26995558e-01f, 1.67698875e-01f, 1.26595408e-01f,
  -1.06863952e+00f, -2.08263006e-02f, -1.46822944e-01f, -1.07769823e+00f, -5.95030129e-01f, -7.55250081e-02f, 4.18747440e-02f, -3.37599277e-01f, -6.30709827e-01f, -2.91292250e-01f,
  2.53252774e-01f, 4.34782445e-01f, 1.62157342e-01f, 4.07182992e-01f, 3.17802161e-01f, -1.97376296e-01f, -5.19141257e-01f, -1.15195895e-02f, 2.61302948e-01f, 4.06265616e-01f,
  7.66307116e-02f, -5.51051140e-01f, -4.48160678e-01f, -3.41260433e-01f, -4.49172229e-01f, -6.98346421e-02f, -3.74664038e-01f, -4.25061584e-01f, 1.07165560e-01f, -4.59774941e-01f,
  3.41262072e-01f, -4.83539462e-01f, 2.76109185e-02f, -7.22544715e-02f, -1.35756150e-01f, -5.25837429e-02f, -1.07131056e-01f, -2.55978227e-01f, -1.69862062e-01f, -1.80249110e-01f,
  -2.56153286e-01f, -7.80482665e-02f, -9.01540220e-02f, 7.89232180e-03f, -2.66779512e-01f, 9.70170926e-03f, -3.31571773e-02f, -4.53197770e-02f, 7.79171214e-02f, 2.14414984e-01f,
  2.70491898e-01f, -4.50971955e-03f, 1.44398227e-01f, 2.13984251e-01f, 2.44874712e-02f, 1.10236965e-01f, 1.84458137e-01f, 7.96930343e-02f, 1.17338620e-01f, -1.15634054e-01f,
  -1.09097391e-01f, 6.28570616e-02f, 2.28389725e-03f, -5.66703230e-02f, 5.52091524e-02f, 6.21313900e-02f, -1.52370021e-01f, -1.48392662e-01f, 4.11474966e-02f, 1.34901628e-01f,
  -8.84768516e-02f, 5.36762215e-02f, -3.00198910e-03f, -4.86071073e-02f, 7.26769641e-02f, -6.19283877e-03f, 7.41951121e-03f, 8.00219104e-02f, -1.36542052e-01f, -1.68276370e-01f,
  -8.46872944e-03f, 4.78224829e-02f, -1.44440010e-01f, -2.46057250e-02f, 8.34483430e-02f, -1.03455693e-01f, -5.72416596e-02f, 1.20057814e-01f, 3.15796621e-02f, -1.09145255e-03f,
  1.87736619e-02f, 2.41282880e-01f, -1.00200079e-01f, -8.23303908e-02f, -1.27126172e-01f, -2.15846561e-02f, 9.25779622e-03f, -7.85240382e-02f, -2.21127719e-01f, -9.84772444e-02f,
  1.04381911e-01f, -1.71029463e-03f, 2.02210117e-02f, 9.14174840e-02f, -9.69739407e-02f, 2.88423318e-02f, 8.87849331e-02f, -6.67448714e-03f, 1.22012146e-01f, 1.00840375e-01f,
  9.05178860e-02f, 1.45316795e-01f, 1.39413312e-01f, 1.59609124e-01f, 2.12556543e-03f, 7.42675215e-02f, 2.28888139e-01f, 2.80849397e-01f, 1.36417478e-01f, -6.71774000e-02f,
  4.96432275e-01f, -5.65934889e-02f, -2.46789038e-01f, 3.32650214e-01f, -7.30830664e-03f, -3.77495736e-01f, -4.25078161e-02f, -1.17093004e-01f, 4.03211117e-01f, 4.14371133e-01f,
  -8.56586993e-02f, -4.83698517e-01f, 5.44328541e-02f, -1.47240877e-01f, -3.94467771e-01f, 1.15489803e-01f, 1.45614281e-01f, -3.23689103e-01f, -7.33765841e-01f, -6.11827672e-01f,
  -3.72676365e-02f, 9.51220915e-02f, -7.06636384e-02f, -1.49739102e-01f, 3.21870029e-01f, 4.46671620e-02f, 4.49248463e-01f, 1.02409981e-01f, -1.47659525e-01f, 2.68244326e-01f,
  1.73172355e-01f, -1.74185947e-01f, -2.59542257e-01f, -2.74965048e-01f, -1.31056458e-01f, -2.03775130e-02f, -1.81185231e-01f, -8.81362408e-02f, -1.05637580e-01f, -9.44322050e-02f,
  -1.50101125e-01f, -2.04146951e-01f, -2.54011303e-01f, -2.83310600e-02f, -1.84416071e-01f, -8.05843472e-02f, 3.87475081e-02f, -2.02757269e-01f, 2.95761246e-02f, -2.86153764e-01f,
  -1.82902336e-01f, -2.20804647e-01f, -1.07713453e-01f, -6.47254735e-02f, -1.56175211e-01f, -9.66790318e-02f, -7.61599317e-02f, -2.20359594e-01f, -1.40551403e-01f, 2.64706939e-01f,
  -1.68220624e-01f, 1.47127181e-01f, -7.64346868e-03f, 2.18292654e-01f, 1.84461340e-01f, 1.18763968e-02f, 1.23678006e-01f, 2.75271554e-02f, -1.61597401e-01f, -4.73798774e-02f,
  -2.21834347e-01f, -9.29887742e-02f, -4.02471796e-02f, -1.68012269e-02f, 9.40337591e-03f, -2.45138779e-02f, -1.68507606e-01f, 1.01217918e-01f, -5.90230972e-02f, 6.70454428e-02f,
  -9.96520743e-02f, 1.31192356e-01f, 1.11799940e-01f, 4.58702929e-02f, -6.20604493e-03f, -8.65269899e-02f, 1.28349259e-01f, -1.31357864e-01f, 1.24378074e-02f, 1.11873627e-01f,
  4.17260528e-01f, -3.21584642e-01f, 1.67174041e-01f, -1.83317550e-02f, 7.15038851e-02f, -4.85242531e-02f, 6.62470609e-02f, -8.21297690e-02f, -4.23934162e-02f, -1.24838956e-01f,
  -3.64476740e-01f, -2.85459965e-01f, 2.20304839e-02f, -2.07139868e-02f, -1.38891801e-01f, -1.08921506e-01f, -3.12826261e-02f, -7.39558553e-03f, 3.66485789e-02f, 7.84436762e-02f,
  1.21434726e-01f, 1.39146969e-01f, 2.53770888e-01f, 2.51847714e-01f, 8.25028569e-02f, 9.03587192e-02f, 2.08525881e-01f, 6.41801804e-02f, -2.63463371e-02f, 4.70283508e-01f,
  -2.36534640e-01f, 9.11067128e-01f, 5.76947033e-01f, -5.43332398e-01f, 2.12313950e-01f, 4.76662695e-01f, 9.12905395e-01f, 1.50090858e-01f, -5.33976436e-01f, 2.94661373e-01f,
  2.76599646e-01f, -5.09051085e-01f, -3.99976730e-01f, -1.77590489e-01f, 1.75804228e-01f, 5.30336499e-01f, 3.14229727e-01f, -1.91982657e-01f, -4.15369302e-01f, -2.12025493e-01f,
  -1.99598476e-01f, -3.86965364e-01f, -3.61633182e-01f, -2.42248118e-01f, -1.30541757e-01f, -4.62046981e-01f, 2.58387715e-01f, 2.07265586e-01f, 5.85572362e-01f, 7.10467845e-02f,
  2.69794976e-03f, 2.80890316e-01f, -4.32568222e-01f, -2.49745712e-01f, 1.57863840e-01f, -1.85907379e-01f, -4.38092425e-02f, -5.22136651e-02f, 2.05769405e-01f, -2.93807853e-02f,
  9.13234055e-02f, 3.41242254e-02f, 3.18525396e-02f, 9.29879174e-02f, -2.31280662e-02f, -1.41018420e-01f, -2.75934841e-02f, -3.19879726e-02f, 2.72853635e-02f, 1.63855135e-01f,
  1.35294929e-01f, 2.20988952e-02f, 1.27070040e-01f, 1.24265671e-01f, 1.63056359e-01f, -4.01456863e-01f, 4.19069141e-01f, 3.04244254e-02f, 1.65077627e-01f, -2.27301404e-01f,
  -2.84369290e-01f, 1.06458955e-01f, 1.73505947e-01f, -4.52508889e-02f, 8.43460113e-02f, 9.64350533e-03f, 6.99742660e-02f, 1.74483538e-01f, -5.21564111e-02f, -4.36993456e-03f,
  -7.59576112e-02f, -1.68284755e-02f, -3.02689318e-02f, 7.92591423e-02f, -1.93700731e-01f, -6.23143874e-02f, 1.30256349e-02f, -4.44980003e-02f, -2.72674672e-02f, 1.35732114e-01f,
  -9.72930416e-02f, -2.84147207e-02f, 5.09795621e-02f, 4.06848975e-02f, 4.23393734e-02f, -9.06897113e-02f, -2.23213717e-01f, -1.97587222e-01f, -2.46368915e-01f, 3.48098539e-02f,
  -5.32831013e-01f, 2.99694836e-01f, -3.57983202e-01f, -1.30179122e-01f, 2.14423254e-01f, 1.56320080e-01f, -1.21880099e-02f, 1.64602712e-01f, 1.98032409e-01f, 2.15828512e-02f,
  1.88082188e-01f, -1.80109262e-01f, 9.68042389e-02f, -7.58946463e-02f, -2.02882424e-01f, -1.34108990e-01f, -2.79065724e-02f, -7.99617395e-02f, -4.31103483e-02f, -1.15391068e-01f,
  -2.68758982e-02f, -2.89494634e-01f, -5.82791507e-01f, -2.69773066e-01f, -3.25849801e-01f, -6.27919436e-01f, -3.16735923e-01f, -2.48102307e-01f, -4.33589816e-02f, -2.80725539e-01f,
  1.43881425e-01f, -5.07257819e-01f, -4.50724453e-01f, -1.94235638e-01f, -2.31616125e-01f, -2.25743204e-01f, -6.02034986e-01f, 7.38690570e-02f, 2.37372816e-01f, -5.98272383e-01f,
  -2.17616931e-01f, 2.99884260e-01f, -2.45329514e-01f, -1.92528561e-01f, -4.94797319e-01f, -1.03380966e+00f, -8.75353575e-01f, -3.79851192e-01f, 3.81565243e-02f, 4.04229537e-02f,
  -2.05824271e-01f, -1.67585328e-01f, -7.35386461e-03f, 8.20176750e-02f, -1.73670184e-02f, 6.06398210e-02f, -2.20426410e-01f, -6.12614416e-02f, -3.13531429e-01f, -4.13199365e-01f,
  -4.51043874e-01f, 4.97578561e-01f, 1.84727162e-01f, 1.13972478e-01f, -1.68941990e-02f, 1.22236893e-01f, 4.05061245e-02f, 1.58303186e-01f, 9.10314023e-02f, -7.30721513e-03f,
  2.44915083e-01f, 6.34953231e-02f, 8.19229037e-02f, 2.54646852e-03f, -2.77215689e-02f, -4.72240150e-02f, -2.08889142e-01f, 3.86579242e-03f, -1.57976240e-01f, -3.51158231e-02f,
  -1.72301933e-01f, -6.33691251e-02f, 1.92211438e-02f, -5.16401883e-03f, 1.85994595e-01f, 2.25213896e-02f, 1.09922923e-01f, 3.59110475e-01f, 9.52629969e-02f, -1.61950558e-01f,
  -1.92721426e-01f, -1.05492800e-01f, 1.06215477e-02f, 1.73617586e-01f, -4.09846865e-02f, -6.64441511e-02f, -4.23002504e-02f, 3.30630764e-02f, 2.26607680e-01f, -6.24757409e-02f,
  -1.80848300e-01f, -2.33983919e-01f, 9.15969312e-02f, 4.61346321e-02f, 6.51417822e-02f, -7.21860826e-02f, -1.59374505e-01f, -1.76979557e-01f, 1.35923654e-01f, -1.23605318e-01f,
  3.32500190e-02f, 1.03177756e-01f, -3.60694304e-02f, -5.50608616e-03f, -5.21236472e-02f, -1.86235353e-01f, -6.07885011e-02f, 3.35447304e-02f, -3.44893821e-02f, -3.82466018e-02f,
  -7.78985992e-02f, -8.46572965e-02f, -1.09244928e-01f, 9.81548354e-02f, -2.33266111e-02f, -6.72790334e-02f, -2.90361624e-02f, 5.54866809e-03f, 1.51790053e-01f, -1.48880109e-01f,
  -3.44924517e-02f, -1.89186439e-01f, -1.52808905e-01f, 4.15648986e-03f, -6.49864525e-02f, 5.70017919e-02f, -3.58745903e-01f, -3.58195007e-02f, -6.53576106e-02f, -6.04085065e-02f,
  -4.36027259e-01f, -2.10694402e-01f, -2.65602618e-01f, -1.91502035e-01f, -4.07355838e-02f, 1.62333008e-02f, -2.05646276e-01f, -5.64402007e-02f, -1.98665172e-01f, -5.84002376e-01f,
  -7.36547768e-01f, 6.88009679e-01f, 2.82758981e-01f, -4.17668164e-01f, 2.15231702e-01f, 5.64540207e-01f, 6.35228395e-01f, 3.56860459e-01f, -3.68327290e-01f, 2.49458998e-01f,
  1.75727323e-01f, -4.21114028e-01f, -2.96899974e-01f, -1.72532782e-01f, 9.04075205e-02f, 6.06117368e-01f, 3.04961652e-01f, -3.14727217e-01f, -4.30297047e-01f, -2.74334639e-01f,
  -7.42568597e-02f, -3.72841954e-01f, -5.24310708e-01f, -2.44968623e-01f, -1.69717267e-01f, -4.86027449e-01f, 3.71138640e-02f, 2.17113104e-02f, 2.13794485e-01f, -3.51855367e-01f,
  -6.12071343e-02f, 2.42685586e-01f, -3.17848593e-01f, -2.81693727e-01f, -1.47118848e-02f, -4.46581915e-02f, -2.28795074e-02f, -1.59091353e-01f, 1.96518134e-02f, 6.20577745e-02f,
  -6.28610253e-02f, 6.69858679e-02f, -4.31769416e-02f, 9.50907692e-02f, 1.13473624e-01f, 7.50259263e-03f, 6.39597923e-02f, -1.00920361e-03f, 1.95556302e-02f, 1.62178546e-01f,
  2.59915262e-01f, 1.95591792e-01f, 1.40646756e-01f, 1.82238877e-01f, 1.66356534e-01f, -1.25476599e-01f, 2.31080994e-01f, -7.67298713e-02f, 9.00067016e-02f, -2.67835557e-01f,
  3.43816392e-02f, -4.14722860e-02f, -6.19032830e-02f, 6.83947559e-03f, -1.33244917e-02f, 1.21996440e-02f, 1.29853515e-02f, -3.11399996e-02f, 1.30916154e-02f, -2.41624452e-02f,
  1.51025712e-01f, 5.61784618e-02f, 7.70180151e-02f, 8.44572634e-02f, -2.03035288e-02f, 3.11422888e-02f, 1.74832210e-01f, 1.12911180e-01f, 1.52181223e-01f, 4.38536741e-02f,
  -2.11088359e-03f, 1.37201369e-01f, -6.37725070e-02f, -9.75375250e-03f, 1.82106405e-01f, 1.64649397e-01f, 8.33057463e-02f, 7.87761807e-02f, 1.51851058e-01f, 2.47270986e-01f,
  -2.52643645e-01f, 3.42641145e-01f, -1.52054504e-01f, -2.00779140e-02f, 3.85318100e-02f, -6.59786223e-04f, -1.10646382e-01f, -9.43814814e-02f, 3.77665944e-02f, 1.16631456e-01f,
  1.29232094e-01f, -8.23778957e-02f, 1.69400170e-01f, 8.99433717e-02f, -6.55999705e-02f, -3.68462764e-02f, 3.85329798e-02f, -1.85856819e-01f, 1.61226969e-02f, 1.31561264e-01f,
  1.64489955e-01f, -1.20987475e-01f, -1.75510168e-01f, -3.34938727e-02f, 1.27536759e-01f, -2.52363265e-01f, -7.79021904e-02f, -5.48662320e-02f, 6.15469143e-02f, -2.17824399e-01f,
  -5.01590297e-02f, -1.24869369e-01f, -1.09305583e-01f, 4.49205428e-01f, 5.38697839e-01f, 4.45723683e-01f, 5.11290908e-01f, 4.06568438e-01f, 3.28373611e-01f, 1.35313496e-01f,
  7.71854771e-03f, 9.27753225e-02f, 5.66514730e-02f, 8.99528861e-02f, 1.31294474e-01f, 2.70482957e-01f, 3.76458824e-01f, 2.60421652e-02f, 2.99540125e-02f, 2.76858538e-01f,
  2.60395020e-01f, 1.81169882e-01f, -6.71159774e-02f, 1.42643437e-01f, 1.71477988e-01f, 1.42381996e-01f, 2.45052010e-01f, 1.96482703e-01f, 2.26195138e-02f, -4.17142510e-02f,
  -4.81197685e-01f, -1.75354421e-01f, 1.58242416e-02f, -1.08916380e-01f, -2.39040956e-01f, -2.18229860e-01f, -1.22766994e-01f, -1.41004428e-01f, -9.80868265e-02f, 7.96252713e-02f,
  -1.04524218e-01f, -8.85992795e-02f, -1.10417470e-01f, -7.33999684e-02f, -1.93661060e-02f, -1.12812445e-01f, -1.28464282e-01f, -1.17367273e-02f, 1.60059892e-02f, -1.36769220e-01f,
  -1.21500611e-01f, -2.04849392e-02f, 1.14918001e-01f, 1.28684491e-01f, -9.08361282e-03f, 4.19779606e-02f, -1.37895614e-01f, -6.43960088e-02f, -5.25043309e-02f, 1.04268380e-01f,
  -1.35448709e-01f, -8.09963048e-02f, -3.74806859e-02f, 1.18014805e-01f, -1.61302611e-02f, 1.23053715e-01f, 1.11438543e-01f, 8.88779536e-02f, 1.14053786e-01f, 1.41716599e-02f,
  3.70835848e-02f, 1.02197409e-01f, 6.41510710e-02f, -3.66045646e-02f, -1.27523497e-01f, -9.20287147e-02f, -9.63531658e-02f, -6.40325844e-02f, -1.35056913e-01f, -9.64765251e-02f,
  -9.68227684e-02f, -4.48997058e-02f, -2.26816177e-01f, -1.90857977e-01f, 3.07189040e-02f, 8.18324015e-02f, -8.07493273e-03f, -6.64210916e-02f, 6.67648092e-02f, -5.08468598e-02f,
  1.92224801e-01f, -2.77815908e-02f, 5.30900881e-02f, -4.06650081e-02f, -7.00157043e-03f, -2.55452543e-01f, -1.60332471e-01f, -7.16404766e-02f, -1.39153913e-01f, 3.95763107e-02f,
  -6.53753504e-02f, -2.06996247e-01f, -1.15983054e-01f, 2.23972965e-02f, -3.32540683e-02f, 4.12833802e-02f, -5.09824120e-02f, 2.91165356e-02f, 5.99957556e-02f, -4.56666239e-02f,
  4.89014797e-02f, 2.83071816e-01f, 1.78887546e-01f, 1.89655170e-01f, 1.12136804e-01f, 1.32239655e-01f, 9.25781056e-02f, 7.71231856e-03f, 1.89443916e-01f, 3.58826250e-01f,
  -3.91898960e-01f, -2.92675674e-01f, 3.00438792e-01f, 1.40589491e-01f, 3.23862046e-01f, 2.65043408e-01f, 3.40781808e-01f, 1.23215929e-01f, 6.94790408e-02f, 7.17185438e-02f,
  -2.32251614e-01f, -1.24013320e-01f, -1.56104192e-01f, -1.43152103e-01f, -1.10862777e-01f, 2.78599679e-01f, 3.52234989e-01f, 1.56796053e-01f, 2.28245601e-01f, 8.90874490e-02f,
  1.76925004e-01f, 6.77255169e-02f, -1.95634231e-01f, -1.22479431e-01f, 4.36061472e-02f, 1.52935132e-01f, 4.86726500e-02f, -1.64493956e-02f, -1.30205616e-01f, 2.46369392e-01f,
  3.30414087e-01f, -4.00495887e-01f, 1.72090009e-01f, -3.25677067e-01f, -1.35796472e-01f, -2.39765085e-02f, 3.54612395e-02f, -1.22858904e-01f, -1.64306358e-01f, -5.21143340e-02f,
  -1.76418290e-01f, -1.79735094e-01f, -4.48877066e-02f, -5.06317616e-02f, 6.20976835e-02f, -1.36219010e-01f, -1.93793714e-01f, -1.30884856e-01f, -2.29700238e-01f, -2.25070313e-01f,
  -5.34894541e-02f, 3.41131911e-03f, -7.06323609e-02f, -5.18320464e-02f, -2.31875092e-01f, -1.36462644e-01f, -6.64412528e-02f, -1.03354782e-01f, -1.77018791e-01f, -6.06494322e-02f,
  -3.08097322e-02f, -1.33542866e-02f, -4.71119843e-02f, -3.50801311e-02f, -4.01645415e-02f, -1.20918974e-02f, 7.98700750e-02f, 3.35388146e-02f, 1.10710189e-01f, 7.69679397e-02f,
  6.28117770e-02f, 5.84796350e-03f, 1.15116216e-01f, 4.86966409e-02f, 3.02026756e-02f, 2.67274771e-02f, 8.38146135e-02f, -1.60889179e-02f, -1.65419489e-01f, 7.95939192e-03f,
  7.15544447e-02f, 6.87018335e-02f, -9.76284444e-02f, 1.75733231e-02f, -9.68541484e-03f, -6.72547519e-02f, -3.05159371e-02f, 2.35115038e-03f, 2.12836470e-02f, -4.47196290e-02f,
  5.43521464e-01f, -3.20016831e-01f, 3.03786576e-01f, 2.74674669e-02f, 9.65185538e-02f, -8.49603936e-02f, 1.40753081e-02f, 5.83887361e-02f, 8.04807059e-03f, 6.87414929e-02f,
  -5.45350760e-02f, 5.04198298e-02f, 7.37554431e-02f, 7.96891525e-02f, 2.23425314e-01f, 7.77107626e-02f, -1.09789662e-01f, 5.65661080e-02f, 5.41034415e-02f, -1.08862091e-02f,
  -6.05217256e-02f, 3.77907977e-02f, 2.75587142e-01f, 2.82132477e-01f, 1.12402774e-01f, 1.46393120e-01f, 2.03469276e-01f, 1.27634495e-01f, 1.45856589e-01f, 2.57633835e-01f,
  4.37487543e-01f, 3.53474945e-01f, 3.16657759e-02f, 3.11110348e-01f, 3.75368774e-01f, 3.95010799e-01f, 2.83404857e-01f, 1.45963341e-01f, 7.51165748e-02f, 1.66539043e-01f,
  3.21098357e-01f, 2.39576146e-01f, 2.49515221e-01f, 1.39627680e-01f, 1.07546590e-01f, 1.03614576e-01f, -3.97040844e-02f, 7.05692768e-02f, 6.31584451e-02f, 1.35741845e-01f,
  9.38830152e-02f, 2.02391028e-01f, 1.43096358e-01f, 1.12528400e-02f, 1.46397829e-01f, 1.16327465e-01f, 1.84253126e-01f, 5.33781163e-02f, 9.99805480e-02f, -7.64555186e-02f,
  -3.59762847e-01f, 8.69710520e-02f, -6.03738278e-02f, 6.01832196e-02f, -6.36509806e-02f, -7.45543018e-02f, -1.01074213e-02f, -2.41204858e-01f, 2.40266770e-02f, -9.64499265e-02f,
  -2.06411723e-02f, -6.08676784e-02f, -2.72159297e-02f, -1.53228894e-01f, -1.15459850e-02f, -5.53558916e-02f, -1.59483656e-01f, -1.25906736e-01f, -8.68877582e-03f, 4.06026691e-02f,
  3.41971852e-02f, -7.54085407e-02f, -8.57456028e-02f, -2.19067484e-02f, 1.87463820e-01f, 5.89254238e-02f, 6.50759647e-03f, -3.73334042e-03f, 4.30664010e-02f, -5.52658327e-02f,
  9.66631547e-02f, -5.71174659e-02f, 8.24206769e-02f, -3.69452275e-02f, 2.02559277e-01f, -1.02560287e-02f, 2.41984501e-02f, -1.33950477e-02f, -1.16303340e-02f, -5.44642545e-02f,
  -1.32298246e-01f, -6.60422668e-02f, -8.45388994e-02f, -4.76927310e-02f, 2.14259639e-01f, 4.75934297e-02f, -1.25218451e-01f, -1.04034729e-01f, 4.59446795e-02f, -6.59393370e-02f,
  2.49293298e-02f, -1.46121278e-01f, -8.56611654e-02f, -9.91322249e-02f, -1.09357797e-01f, 2.06076596e-02f, 5.22275530e-02f, 2.80710477e-02f, 1.15446709e-01f, 4.59427647e-02f,
  -1.37883916e-01f, 1.51768520e-01f, -1.56026974e-01f, -1.53714135e-01f, -1.47253469e-01f, -1.86980739e-01f, -2.97224391e-02f, -1.37793317e-01f, -6.13308996e-02f, -4.56846766e-02f,
  -9.25668254e-02f, 2.49399729e-02f, -5.42191602e-02f, -3.03021409e-02f, -2.20725104e-01f, -1.67415574e-01f, -9.04186741e-02f, -4.97077741e-02f, -8.91742334e-02f, -9.20871869e-02f,
  -9.26423892e-02f, -1.50924429e-01f, -1.79097578e-01f, 3.01308755e-04f, -5.68780676e-02f, -2.54055802e-02f, -1.80471808e-01f, -1.38676226e-01f, -6.16721027e-02f, -9.04418007e-02f,
  7.51544952e-01f, 5.51299632e-01f, 4.27797616e-01f, 2.74279267e-01f, 1.24887876e-01f, 1.76557988e-01f, 2.93060690e-01f, 1.06970571e-01f, -2.07207743e-02f, 1.83419839e-01f,
  1.22738689e-01f, 6.97894543e-02f, 1.48724064e-01f, 2.65820185e-03f, 1.57701150e-01f, 4.05763797e-02f, -1.73760369e-01f, 1.02409638e-01f, 3.47605743e-03f, 1.69274151e-01f,
  -4.70998930e-03f, 9.58120003e-02f, 2.08201051e-01f, 1.35528818e-01f, -6.26197904e-02f, -7.04466030e-02f, 6.74299225e-02f, 1.39704227e-01f, 5.87885566e-02f, -1.21938244e-01f,
  -3.80297611e-03f, 2.81767219e-01f, -2.91630745e-01f, -8.65956247e-02f, -6.34240583e-02f, -1.85345680e-01f, -9.46019441e-02f, -1.55622318e-01f, -4.50730771e-02f, -1.45407945e-01f,
  -9.63755548e-02f, 2.98497304e-02f, -1.60911363e-02f, -5.36519662e-02f, -9.40896049e-02f, -1.42802969e-02f, 1.36214150e-02f, -8.98972750e-02f, -1.08051307e-01f, 6.63858503e-02f,
  -1.57075524e-01f, 8.44438523e-02f, 1.06860787e-01f, 5.04696295e-02f, 1.40012518e-01f, 2.54184883e-02f, 1.09641120e-01f, -6.00988567e-02f, 2.99701057e-02f, 5.36437221e-02f,
  -6.31702840e-02f, 1.77025616e-01f, 2.17844993e-01f, 5.24061173e-02f, 1.97259244e-02f, -1.02610014e-01f, -4.29322571e-02f, -1.26394620e-02f, 1.51080921e-01f, 1.40231773e-01f,
  -6.21978417e-02f, 4.49963696e-02f, 3.96056771e-02f, -1.42050972e-02f, -8.80440921e-02f, -5.17775072e-03f, -8.75556245e-02f, 4.57815826e-03f, 7.68406491e-04f, -7.37722740e-02f,
  -1.29759731e-02f, -1.48584068e-01f, 5.68747483e-02f, -6.57630488e-02f, -1.46258622e-01f, 6.37169108e-02f, -1.02480449e-01f, 2.28544399e-02f, -6.56812042e-02f, 7.37858471e-03f,
  -2.71443665e-01f, 2.32100502e-01f, -1.19785696e-01f, -3.31138372e-02f, -4.35780473e-02f, 4.96206293e-03f, 1.30484372e-01f, -8.41685943e-03f, -1.95675999e-01f, -1.24337720e-02f,
  8.47895294e-02f, -4.36368659e-02f, 8.16309452e-02f, -3.32027152e-02f, -4.39835303e-02f, -8.02301764e-02f, -4.73964252e-02f, -2.24015430e-01f, -7.76430815e-02f, -9.28392783e-02f,
  -1.08727358e-01f, -1.47998005e-01f, -7.34190196e-02f, -1.42876357e-01f, -1.18451618e-01f, -1.56938404e-01f, -2.76464056e-02f, -1.75585717e-01f, 8.40249285e-02f, -1.19348068e-03f,
  -2.76262045e-01f, -3.98724079e-01f, -2.03653648e-01f, 1.72963008e-01f, 4.05665696e-01f, 1.83509693e-01f, 9.88952816e-02f, -7.45920837e-02f, -1.70092270e-01f, -1.08041577e-01f,
  -2.55481362e-01f, -1.48841679e-01f, -3.37101787e-01f, -2.07683519e-01f, -1.19831465e-01f, 2.88593937e-02f, 1.81396887e-01f, 1.13384230e-02f, 1.62868246e-01f, 3.80469739e-01f,
  3.17650139e-01f, 3.56439441e-01f, 7.38896132e-02f, 7.80598596e-02f, 2.34808952e-01f, 1.31115183e-01f, -5.97068258e-02f, 1.49905100e-01f, 6.07495196e-02f, 1.11261822e-01f,
  -7.70729259e-02f, -1.28479540e-01f, 6.52382448e-02f, 2.02672798e-02f, 9.84893925e-03f, -6.90630749e-02f, -1.08149946e-01f, 8.29039887e-02f, 4.05712873e-02f, 2.27990467e-02f,
  -4.37331758e-02f, 2.23547146e-02f, -6.65083751e-02f, 1.32485700e-03f, 2.12867167e-02f, 7.89645221e-03f, -4.07953141e-03f, -7.18790069e-02f, -1.63502142e-01f, -1.05839483e-01f,
  -1.55425265e-01f, -5.79003133e-02f, -4.69772108e-02f, -1.08028069e-01f, -2.28332207e-01f, -1.39696062e-01f, -1.09704494e-01f, -1.26844710e-02f, -1.82469591e-01f, -1.32137746e-01f,
  -9.14987251e-02f, -1.05171017e-01f, -9.66828912e-02f, -5.72538935e-02f, -2.01187223e-01f, 5.07677831e-02f, 1.44948095e-01f, -1.92403242e-01f, -1.30792812e-01f, 3.92712876e-02f,
  -3.93071584e-03f, -1.70339420e-01f, -3.80934216e-02f, 1.51800826e-01f, -5.61825261e-02f, -9.37062576e-02f, -2.08293404e-02f, -1.11957066e-01f, -1.37006551e-01f, -2.26013839e-01f,
  -1.81105912e-01f, 3.35869603e-02f, 2.03044325e-01f, 5.06939627e-02f, 1.06443884e-02f, 3.93963009e-02f, -2.55888421e-02f, -1.54598638e-01f, -6.40285164e-02f, 1.40674636e-01f,
  1.21041998e-01f, -1.47083506e-01f, 1.35249598e-02f, -1.36303678e-01f, 1.38909906e-01f, -6.26851171e-02f, -2.39451662e-01f, 7.06294626e-02f, 2.27698255e-02f, -1.59874894e-02f,
  3.70133370e-02f, -6.82330877e-02f, 4.71136495e-02f, -7.33371079e-02f, 1.04985029e-01f, 9.76983607e-02f, 6.98948130e-02f, 7.07172826e-02f, 3.36727463e-02f, 4.28512469e-02f,
  -8.00788477e-02f, 1.41155779e-01f, -7.06277117e-02f, -9.35953930e-02f, 5.92889357e-03f, 1.71602517e-01f, 1.95956305e-01f, 1.40691936e-01f, 1.19271711e-01f, 1.69706255e-01f,
  9.21153843e-01f, 4.80719388e-01f, -4.60418135e-01f, -2.83283796e-02f, -5.49412847e-01f, -2.99716353e-01f, 4.08447757e-02f, 1.53553203e-01f, 5.80805866e-03f, 1.41432539e-01f,
  1.52923509e-01f, 1.62960097e-01f, 1.69858083e-01f, 1.87591776e-01f, 2.17646480e-01f, 1.43611124e-02f, -1.45413965e-01f, -5.36327809e-02f, 3.41122784e-02f, 6.58893064e-02f,
  1.15595609e-01f, 2.01351777e-01f, 3.67964685e-01f, 9.62938145e-02f, -8.76966640e-02f, 4.00763787e-02f, -1.83343753e-01f, -2.61114031e-01f, -8.82056281e-02f, -1.71433374e-01f,
  -1.25718310e-01f, -4.27120887e-02f, 3.80092226e-02f, -6.13592798e-03f, -1.26620829e-01f, 1.18614919e-01f, 1.59529448e-01f, 9.49418843e-02f, 3.00175175e-02f, 4.62993123e-02f,
  -4.87192124e-02f, -5.00664897e-02f, -5.12623563e-02f, -1.15776528e-02f, -8.22047070e-02f, -4.73186672e-02f, 3.97846214e-02f, 1.01401381e-01f, -7.36446232e-02f, -2.30137445e-02f,
  -5.61102591e-02f, -2.69607306e-01f, -1.18756689e-01f, -3.57781127e-02f, 8.91908705e-02f, -1.49244860e-01f, -1.32917881e-01f, -1.22831963e-01f, -8.18939805e-02f, 1.78193361e-01f,
  1.95329674e-02f, 1.11916155e-01f, -1.37695208e-01f, -5.71984760e-02f, 4.66046520e-02f, 9.34373364e-02f, -1.13706021e-02f, 1.23428412e-01f, 1.10781819e-01f, 8.74395370e-02f,
  1.29408399e-02f, -1.44791216e-01f, 3.44522223e-02f, 6.41695559e-02f, 9.16504264e-02f, -1.54380649e-01f, -8.63406528e-03f, -5.73970713e-02f, -5.13301194e-02f, -8.78503844e-02f,
  -8.05481300e-02f, -9.41128433e-02f, -8.01928714e-02f, -4.53605130e-02f, -5.87972291e-02f, 2.79271286e-02f, -9.68935266e-02f, 1.00303460e-02f, 8.56513679e-02f, 1.65495589e-01f,
  2.20899940e-01f, -4.54397559e-01f, 1.97409138e-01f, 9.15344357e-02f, -1.09115563e-01f, 3.94480070e-03f, -1.38844237e-01f, -9.86041725e-02f, -7.12697022e-03f, -1.09610930e-01f,
  -6.74033165e-02f, 6.84954301e-02f, 7.58395121e-02f, 7.64891356e-02f, 3.71545292e-02f, -3.40215154e-02f, 7.69004449e-02f, 1.91338230e-02f, -8.78043249e-02f, -1.37681544e-01f,
  -2.78719626e-02f, 6.60986230e-02f, 1.32728323e-01f, 1.00777112e-01f, 1.34264529e-01f, 7.70915821e-02f, 9.23247859e-02f, 5.90893999e-02f, 6.62884116e-02f, 3.74111354e-01f,
  -6.38484538e-01f, -3.60747308e-01f, 5.50827503e-01f, -8.02890360e-02f, -9.42130834e-02f, -5.87211549e-01f, -9.83911693e-01f, -5.42610586e-01f, -1.20236941e-01f, -1.56673685e-01f,
  3.82264964e-02f, 1.89638570e-01f, 1.26656294e-01f, -8.45900998e-02f, -3.48432839e-01f, -1.99887648e-01f, 8.65766332e-02f, 1.81627423e-01f, 5.97692803e-02f, -3.59893739e-01f,
  -1.36619791e-01f, 4.50348109e-02f, 3.08122247e-01f, 1.84520096e-01f, 2.41750553e-01f, 1.57819673e-01f, 3.29930127e-01f, 1.48682043e-01f, -4.34405580e-02f, 3.37776840e-01f,
  1.72015563e-01f, -1.68448865e-01f, 5.76335937e-02f, 3.99997950e-01f, 3.12412262e-01f, -1.68410450e-01f, -9.94100720e-02f, 2.85521835e-01f, 9.29097980e-02f, 1.80533022e-01f,
  9.40950438e-02f, 4.20079865e-02f, -1.48227485e-03f, -2.93010306e-02f, -2.40491763e-01f, -3.39640439e-01f, 1.51508316e-01f, 1.14582971e-01f, 5.35581447e-02f, -3.62432748e-03f,
  -6.85386956e-02f, -7.69263413e-03f, -1.32076591e-01f, -1.23799756e-01f, -1.77058414e-01f, 2.93105632e-01f, -5.39132543e-02f, 5.43280914e-02f, -1.63675740e-01f, -1.84276938e-01f,
  4.05747592e-02f, 1.22949913e-01f, -1.89156439e-02f, -8.98353979e-02f, -1.42484635e-01f, 2.56630573e-02f, 1.14170067e-01f, -2.33905688e-02f, 8.01276490e-02f, -9.52424929e-02f,
  -1.44334566e-02f, 1.51823983e-02f, 3.77727821e-02f, -2.39625387e-02f, 1.32544205e-01f, 7.94356763e-02f, -3.90664265e-02f, 2.48911846e-02f, 1.19681261e-01f, -2.05366351e-02f,
  -7.42387772e-02f, -3.29181813e-02f, 1.30307600e-01f, -3.16352546e-02f, 1.58828482e-01f, 2.24997267e-01f, 6.25030487e-04f, -1.60405580e-02f, 2.64429394e-02f, 5.44594647e-03f,
  -4.18025970e-01f, 2.37221807e-01f, -2.41185486e-01f, -7.44346082e-02f, 1.39169082e-01f, 3.40278506e-01f, 4.68458086e-02f, -1.74339749e-02f, 1.78202186e-02f, -1.17894500e-01f,
  -2.38757759e-01f, -2.08529681e-01f, -9.00462717e-02f, 4.09021005e-02f, -2.08006978e-01f, -2.14847103e-01f, -1.86187372e-01f, -9.85672176e-02f, -1.74118802e-01f, 5.91151090e-03f,
  -2.03629300e-01f, -5.66583335e-01f, -7.05693662e-01f, -5.10282934e-01f, -3.20985049e-01f, -4.57813531e-01f, -3.36155117e-01f, -2.45260701e-01f, -6.49979532e-01f, -9.56690490e-01f,
  8.31189990e-01f, -2.66447097e-01f, -5.84554672e-01f, 2.01407492e-01f, -6.98468089e-02f, -2.19297260e-01f, -3.33659649e-01f, -1.85308322e-01f, 8.92593265e-02f, -7.89163485e-02f,
  1.43217206e-01f, 5.35921633e-01f, 4.78721887e-01f, 1.58015817e-01f, 2.32882455e-01f, -2.86309570e-01f, -4.06727880e-01f, 2.75611319e-02f, 1.77096650e-01f, 6.64717481e-02f,
  -2.91032828e-02f, 2.57064565e-03f, 1.86575219e-01f, -2.09254362e-02f, -1.55016363e-01f, 1.02588430e-01f, -3.97297174e-01f, -1.63478211e-01f, -2.41909757e-01f, -2.37432554e-01f,
  1.45269364e-01f, -3.83683056e-01f, 2.29140501e-02f, 7.84278288e-02f, -2.02737767e-02f, -5.17247207e-02f, -3.53614390e-02f, -1.97992846e-01f, -1.46643251e-01f, -4.27230150e-02f,
  9.79155884e-04f, -9.21785682e-02f, 6.93317410e-03f, -3.08558438e-02f, -4.34491374e-02f, -9.42719281e-02f, -2.34062389e-01f, -9.63988900e-02f, -7.20484853e-02f, -9.47774053e-02f,
  -4.09499332e-02f, -5.40913269e-02f, -1.87405542e-01f, -7.86710680e-02f, -7.01757893e-02f, 1.45771548e-01f, -1.05211176e-01f, -1.29863724e-01f, -7.67910182e-02f, -1.12055443e-01f,
  1.64067984e-01f, 1.84441537e-01f, -5.43099530e-02f, -1.00775123e-01f, 8.06159824e-02f, -3.31612229e-02f, 1.28105199e-02f, -3.78414942e-03f, -6.15037717e-02f, 1.06934465e-01f,
  -6.83670789e-02f, -2.82804910e-02f, -5.44607677e-02f, -1.02287382e-01f, -6.41960651e-02f, 7.44898394e-02f, 4.43108752e-02f, 8.12010393e-02f, -1.49807287e-02f, 1.51007786e-01f,
  1.16985925e-01f, 2.77556814e-02f, 1.58925638e-01f, -5.55338040e-02f, -1.55493457e-04f, 8.78945142e-02f, 2.82357074e-02f, 1.03351057e-01f, 2.28532422e-02f, -3.42867523e-02f,
  3.16476464e-01f, 1.18935324e-01f, 1.20517358e-01f, 9.93898585e-02f, -1.61781088e-01f, -1.69873357e-01f, 1.91371933e-01f, -1.24666598e-02f, 1.59561653e-02f, -1.39556238e-02f,
  -7.99113140e-02f, 5.92066571e-02f, 1.98215973e-02f, -2.30419599e-02f, 5.44093996e-02f, 3.24228182e-02f, 5.74673936e-02f, 1.73219256e-02f, 9.77766234e-03f, -5.16206434e-04f,
  6.85599670e-02f, -4.21658382e-02f, 2.52068281e-01f, 1.82446063e-01f, -7.82128274e-02f, 3.03754538e-01f, 7.45238066e-02f, 3.41709331e-02f, 1.69228792e-01f, 1.41705543e-01f,
  7.59115577e-01f, 7.31560169e-03f, 4.84175496e-02f, 2.74755329e-01f, 3.72065842e-01f, 3.67601693e-01f, 2.80627370e-01f, 1.98429525e-01f, 8.18332508e-02f, 4.11248840e-02f,
  1.15664527e-01f, 9.24272314e-02f, -9.63505432e-02f, -4.79510352e-02f, 8.15631915e-03f, -2.02805772e-01f, -1.43180296e-01f, 4.82095182e-02f, 2.02755734e-01f, 9.50134397e-02f,
  -5.58960810e-02f, 7.40992576e-02f, 1.60827383e-01f, 2.75715790e-03f, -1.33349583e-01f, 1.73105840e-02f, -8.62847567e-02f, 4.76063415e-02f, -1.15274368e-02f, -2.92543858e-01f,
  -2.40744680e-01f, 1.46710366e-01f, 4.47135866e-02f, -5.19306920e-02f, -9.19703171e-02f, -1.83108136e-01f, 8.79194029e-03f, -1.40886113e-01f, 1.15775606e-02f, -4.43266295e-02f,
  4.01732437e-02f, -2.89505888e-02f, 1.63620077e-02f, -6.89855516e-02f, 4.24867775e-03f, 2.86766831e-02f, -1.15444086e-01f, -2.96410695e-02f, -5.86437210e-02f, -1.24635093e-01f,
  -1.56789660e-01f, 7.96450451e-02f, 5.11998199e-02f, 7.32719153e-02f, -9.01619643e-02f, 4.75231558e-02f, -8.20809007e-02f, -6.35971827e-03f, -5.87941706e-02f, -1.28647000e-01f,
  2.06849966e-02f, 1.06555484e-01f, 1.91021353e-01f, 1.92853332e-01f, 1.52705923e-01f, -3.82595994e-02f, 4.40889411e-02f, 1.45645469e-01f, 8.29657167e-02f, 1.30247965e-01f,
  -6.35074824e-02f, 2.08724752e-01f, 1.07777692e-01f, 2.24421129e-01f, 2.87744240e-03f, 1.89615160e-01f, 1.18786760e-01f, -7.29917176e-03f, 1.85199291e-01f, 1.88844413e-01f,
  2.64104158e-01f, 6.41261339e-02f, 3.84421721e-02f, 8.77997023e-04f, -5.98881766e-02f, 2.56113112e-02f, 1.66172445e-01f, 2.25467294e-01f, 1.29584536e-01f, 9.91695002e-02f,
  8.12573209e-02f, 2.69367278e-01f, 1.16200950e-02f, -1.32462338e-01f, 2.17965851e-03f, -9.37121287e-02f, -3.42537574e-02f, -5.51959360e-03f, -7.98884705e-02f, -1.09691195e-01f,
  -6.02934845e-02f, -3.22318561e-02f, 3.12933624e-02f, 5.71684279e-02f, 1.66704729e-01f, 8.93379655e-03f, 4.75005284e-02f, -3.38674858e-02f, -1.92354903e-01f, -1.26537055e-01f,
  -6.01306111e-02f, 7.71112815e-02f, 2.49946326e-01f, -1.64837632e-02f, -3.81029770e-02f, 1.52987197e-01f, 9.40596014e-02f, 2.72264369e-02f, 1.40575901e-01f, 1.06526189e-01f,
  2.54371613e-01f, 3.33050668e-01f, -2.16367260e-01f, 4.82427835e-01f, -1.56704873e-01f, -5.51433861e-01f, -4.80685443e-01f, -2.10979313e-01f, 1.76192462e-01f, 3.83836240e-01f,
  1.74681678e-01f, -3.02922353e-02f, -4.06272113e-02f, -2.27420405e-01f, -4.54368263e-01f, -2.36179717e-02f, 8.68798792e-02f, -4.32900608e-01f, -8.11650395e-01f, -4.56321210e-01f,
  -1.54707536e-01f, 1.66862220e-01f, -4.86733653e-02f, -9.17920470e-02f, 3.13552201e-01f, -7.06649525e-03f, 3.01939428e-01f, 4.29730974e-02f, -7.84802288e-02f, 5.06185174e-01f,
  3.78689989e-02f, -6.29497692e-02f, -3.01099688e-01f, 1.11831717e-01f, 6.89358637e-02f, 1.35467425e-01f, -1.47741899e-01f, 4.78718951e-02f, 6.57489151e-02f, 1.61266580e-01f,
  -1.16674798e-02f, 1.80784445e-02f, -1.35670424e-01f, -3.46539095e-02f, 2.34294999e-02f, -4.78481688e-02f, 1.08298689e-01f, -4.32941020e-02f, 5.69927506e-02f, 9.70850959e-02f,
  1.56471729e-01f, -2.02323377e-01f, -2.58001059e-01f, -1.23528123e-01f, -2.63684511e-01f, -1.22660697e-01f, -6.16893396e-02f, -1.38773337e-01f, -2.12857902e-01f, 3.01459908e-01f,
  1.11323816e-03f, -1.09363355e-01f, 7.98603296e-02f, 1.01277113e-01f, 1.37697741e-01f, 4.13449146e-02f, 1.18093170e-01f, -5.20288534e-02f, -5.66823073e-02f, 1.03763446e-01f,
  2.94253659e-02f, 2.64426954e-02f, -1.79263540e-02f, 2.85295751e-02f, -1.95235305e-03f, 2.69052181e-02f, -6.26604557e-02f, 3.36238071e-02f, -4.18148562e-03f, 1.45514086e-01f,
  3.82964760e-02f, -2.68094707e-02f, 1.12997107e-01f, -6.97431862e-02f, 1.16334613e-02f, 5.78203984e-03f, 5.49429841e-03f, -4.23664227e-02f, -6.75226450e-02f, -1.27803525e-02f,
  2.48654038e-01f, -2.96765924e-01f, 2.47818068e-01f, -3.74310203e-02f, 5.27254976e-02f, 1.19022086e-01f, 2.41883278e-01f, 2.02853054e-01f, 1.45361349e-01f, 3.21561657e-02f,
  -1.07700996e-01f, 4.27861363e-02f, -1.71843488e-02f, -2.77682282e-02f, -1.17128789e-01f, 3.95575687e-02f, 1.92568451e-01f, 7.70179033e-02f, -3.47510464e-02f, 2.62672335e-01f,
  2.17717096e-01f, 8.41173828e-02f, 6.80021644e-02f, 1.02403760e-01f, -5.78142740e-02f, -2.35936418e-01f, 3.96842398e-02f, -9.33721662e-02f, -1.57170266e-01f, 3.81796002e-01f,
  -6.88266575e-01f, 4.59806323e-01f, 4.96347457e-01f, -1.30936071e-01f, 4.79144454e-01f, 1.88107267e-01f, 2.89363414e-01f, -3.95056665e-01f, -1.69813573e-01f, 5.09553969e-01f,
  5.61527669e-01f, -5.42974807e-02f, 2.10903600e-01f, -1.39923364e-01f, -2.68436223e-01f, 3.24207842e-01f, 2.43563667e-01f, -2.58931130e-01f, -7.75926948e-01f, -6.01082265e-01f,
  -7.92399123e-02f, -2.94955432e-01f, -5.96436858e-01f, -3.52956742e-01f, 2.33467475e-01f, -2.58637890e-02f, 3.53783369e-01f, 1.90283999e-01f, 2.31912971e-01f, 4.57969576e-01f,
  3.56289625e-01f, 9.23733935e-02f, -4.23804745e-02f, 1.40603021e-01f, 2.43845224e-01f, -1.82271600e-01f, -1.48768365e-01f, -3.77102606e-02f, 9.64424014e-02f, 4.64615673e-02f,
  2.04557255e-01f, -9.04466584e-02f, 3.04689825e-01f, -9.65388212e-03f, -7.24111646e-02f, -3.20248067e-01f, -3.22188944e-01f, -4.42747891e-01f, -1.93056390e-01f, -1.12978071e-01f,
  3.02462429e-01f, 1.78098097e-01f, 1.06577680e-01f, -5.77978939e-02f, -1.03212751e-01f, -3.11181277e-01f, -4.85060662e-02f, -5.81252217e-01f, -3.64855707e-01f, -4.32139605e-01f,
  -1.28009990e-01f, -1.64490624e-03f, 2.13847663e-02f, -9.44666564e-02f, -1.46973412e-02f, 1.12058491e-01f, 7.19655231e-02f, 8.08725879e-02f, -6.75953925e-02f, -1.38469115e-01f,
  7.31912404e-02f, -2.48251222e-02f, -1.71529204e-01f, 3.68029475e-02f, -1.31183818e-01f, -3.92717756e-02f, -1.36494739e-02f, -1.60406485e-01f, 1.79346241e-02f, -7.84301683e-02f,
  -9.22315717e-02f, 2.66515370e-02f, 2.39681061e-02f, -1.66398719e-01f, 1.09046862e-01f, -1.51436664e-02f, 1.02501370e-01f, -4.76646945e-02f, -9.87580344e-02f, -3.45138349e-02f,
  -3.81696433e-01f, 2.86142100e-02f, 2.45808616e-01f, -1.13129988e-01f, 5.75750023e-02f, 8.47678185e-02f, 9.38081443e-02f, 1.17515512e-01f, 3.25247347e-02f, -1.01865001e-01f,
  -4.45808843e-02f, -2.86354721e-02f, 2.42949903e-01f, -9.30766165e-02f, -1.02632195e-01f, 6.64354265e-02f, 3.24069038e-02f, 4.96320613e-02f, -1.61448449e-01f, -1.30859703e-01f,
  5.80892973e-02f, -5.02631843e-01f, -2.75313586e-01f, -2.72854101e-02f, -5.97186275e-02f, -2.06737235e-01f, -1.95242956e-01f, -4.80731189e-01f, -3.18173975e-01f, -4.31008667e-01f,
  -3.87775511e-01f, -6.34068549e-01f, -4.80014950e-01f, -6.44295394e-01f, -3.70220423e-01f, -2.13911459e-01f, -5.65411627e-01f, -2.42871106e-01f, -4.35997754e-01f, -7.32948959e-01f,
  -2.36618131e-01f, 1.46348879e-01f, -2.78901845e-01f, 9.15452987e-02f, 1.80961434e-02f, -5.46664774e-01f, -4.92835552e-01f, -1.81414057e-02f, 5.07126033e-01f, 2.67601103e-01f,
  -1.54172461e-02f, -3.80082764e-02f, 2.58960426e-01f, -4.61313576e-02f, -5.79628825e-01f, -2.17542380e-01f, -5.49950838e-01f, -3.62841994e-01f, -4.81818020e-02f, -5.74576557e-01f,
  -4.10622835e-01f, -3.13919783e-01f, 3.23112190e-01f, 3.25267196e-01f, -1.41724199e-01f, 6.95899874e-02f, -5.28657250e-02f, -9.00349095e-02f, 1.44818455e-01f, -3.15255493e-01f,
  3.15090753e-02f, 2.22832754e-01f, 5.80114312e-02f, 5.08609898e-02f, -1.12213686e-01f, -1.39198627e-03f, -1.04931630e-01f, 6.82383850e-02f, -1.67445298e-02f, 2.87267100e-02f,
  1.58509482e-02f, 2.51038838e-02f, -1.91822648e-02f, 1.57974213e-01f, 1.10934652e-01f, 1.48551270e-01f, -1.69635877e-01f, 1.82517231e-01f, 2.78402805e-01f, -5.45148194e-01f,
  1.09666444e-01f, -1.75143123e-01f, -4.41372469e-02f, 3.11891343e-02f, 1.57875761e-01f, -2.74670459e-02f, 3.89865749e-02f, -1.36694144e-02f, 7.64718503e-02f, -5.04820421e-02f,
  -9.16227475e-02f, 3.63021195e-02f, 1.05912378e-02f, -1.43321350e-01f, -8.79179984e-02f, -2.11296469e-01f, -1.21574588e-01f, -9.00732949e-02f, 2.98543163e-02f, 8.31407532e-02f,
  1.23399258e-01f, 4.62542772e-02f, -1.09144889e-01f, 1.13030650e-01f, 2.30380390e-02f, -3.15589644e-02f, -6.49451315e-02f, 8.16801190e-02f, -4.98767607e-02f, -8.13307066e-04f,
  -3.78407329e-01f, 3.81183505e-01f, -6.60771728e-01f, 9.02380645e-02f, -1.99767560e-01f, 2.33743265e-02f, -7.59360343e-02f, 1.12325139e-01f, -2.98759062e-02f, -2.33439654e-01f,
  9.28053111e-02f, -2.57581830e-01f, -3.65202099e-01f, 2.03883712e-04f, 4.03062925e-02f, 1.38406120e-02f, 7.91079924e-02f, -2.04553112e-01f, 2.53409714e-01f, 6.31446764e-02f,
  -7.18327798e-03f, 1.18346520e-01f, -7.18455166e-02f, -7.70385116e-02f, -6.47307420e-03f, 5.13841435e-02f, -3.69874448e-01f, -2.05024332e-01f, 7.00669512e-02f, -6.70434713e-01f,
  4.92480665e-01f, -1.24256000e-01f, 2.21405417e-01f, 1.14639156e-01f, 1.47689879e-01f, 2.80904859e-01f, 1.44268483e-01f, 1.75819650e-01f, 7.55571052e-02f, 2.34964211e-02f,
  3.55642699e-02f, 1.58446625e-01f, 5.69269340e-03f, 4.71851230e-02f, 6.41070232e-02f, 1.58789992e-01f, -2.33857823e-03f, 2.22544789e-01f, 2.29736462e-01f, 7.10557252e-02f,
  -1.69336870e-02f, -9.57982764e-02f, -1.20543301e-01f, 2.28158515e-02f, -8.62941742e-02f, 1.78995691e-02f, -8.98995847e-02f, -1.46926597e-01f, 9.52508599e-02f, -5.70613444e-02f,
  -2.39647090e-01f, -1.35205373e-01f, -6.45620227e-02f, -1.20706812e-01f, -9.11475942e-02f, -1.39726967e-01f, 1.26902098e-02f, -1.46148831e-01f, -1.26162335e-01f, -8.15935954e-02f,
  -1.23071931e-01f, -3.31346132e-03f, -3.02171800e-02f, 2.44390387e-02f, -4.21997951e-03f, -4.20343354e-02f, -1.82012059e-02f, 6.36064708e-02f, -6.19187346e-03f, 8.30266923e-02f,
  8.39876458e-02f, 1.31685644e-01f, 1.02274068e-01f, 5.93610927e-02f, 3.08696907e-02f, 1.04752397e-02f, -5.55091202e-02f, 9.57794413e-02f, 1.35589838e-01f, 1.99609064e-02f,
  1.09448738e-01f, 2.34146148e-01f, 2.23694623e-01f, 1.91819593e-02f, 6.95976093e-02f, 1.00803174e-01f, -3.53008471e-02f, -7.56132230e-02f, 1.21597804e-01f, -1.19480873e-02f,
  8.62802044e-02f, 7.59468973e-02f, 5.99898770e-02f, 2.72962041e-02f, 4.03395630e-02f, 1.14177600e-01f, -2.80019362e-03f, -1.29421651e-01f, 7.63692334e-02f, -4.15506884e-02f,
  9.43716392e-02f, -2.27087941e-02f, 2.32352037e-02f, -5.98390438e-02f, 3.85947227e-02f, 1.31647468e-01f, -6.22066297e-02f, 1.96064487e-02f, -4.55376022e-02f, 1.71855986e-02f,
  -4.19662565e-01f, 9.57342014e-02f, 7.36598149e-02f, -1.28775075e-01f, -4.96215522e-02f, -9.42472667e-02f, -1.61854329e-03f, -2.24413320e-01f, -3.37263584e-01f, -2.38431111e-01f,
  -1.02823868e-01f, 7.84743577e-02f, 2.65674200e-02f, -1.07585490e-01f, -1.09081075e-01f, -6.10538051e-02f, -1.21993594e-01f, -2.50586160e-02f, 1.38144810e-02f, -7.13834539e-02f,
  1.02174291e-02f, 1.50040343e-01f, 5.79742119e-02f, 1.35743558e-01f, 3.57491486e-02f, 1.77322492e-01f, -1.94824394e-02f, 2.48164814e-02f, 8.67556557e-02f, -5.74110858e-02f,
  8.59235585e-01f, -3.34641337e-01f, 1.25659421e-01f, 6.06187396e-02f, -1.23179197e-01f, -8.07276815e-02f, -1.87698931e-01f, -8.26539099e-02f, 1.50780305e-01f, 1.03587605e-01f,
  1.05554350e-01f, 2.53510356e-01f, 1.99692756e-01f, 3.65677215e-02f, 1.00533873e-01f, -6.57330975e-02f, 1.97920278e-02f, 3.02092701e-01f, 2.61031091e-01f, 7.13613117e-03f,
  1.00025879e-02f, -6.64934563e-03f, 5.67298383e-02f, 8.91296789e-02f, -1.24978215e-01f, 5.16707152e-02f, -1.09780416e-01f, -1.15339808e-01f, -5.83959706e-02f, 7.25659207e-02f,
  1.03988536e-01f, 1.59564883e-01f, 1.11798942e-01f, 8.32003877e-02f, -9.30635631e-02f, 1.08904786e-01f, 8.79172459e-02f, -1.65281370e-01f, -7.62344003e-02f, -1.48546547e-01f,
  -1.65578052e-02f, -1.61605179e-02f, 9.19613093e-02f, -7.02560821e-04f, -3.08264364e-02f, 1.01434328e-01f, 2.60359533e-02f, -3.90900597e-02f, 3.08698192e-02f, -8.96923915e-02f,
  3.08836736e-02f, 5.23809902e-02f, 7.03535080e-02f, -2.88034976e-02f, 7.57496879e-02f, 1.68567404e-01f, -9.73676294e-02f, 1.04825504e-01f, 8.86383653e-02f, 8.02395865e-02f,
  2.17770055e-01f, 4.41375375e-01f, 2.66619861e-01f, 1.24787368e-01f, 8.20719600e-02f, 1.49183124e-01f, 8.15278143e-02f, -8.14610943e-02f, 9.52563584e-02f, 1.53960794e-01f,
  9.66425762e-02f, 2.54136082e-02f, 1.64502722e-04f, 1.60942338e-02f, 1.50726110e-01f, 2.16449991e-01f, 2.03511208e-01f, -5.78520745e-02f, 1.50489390e-01f, -5.42976670e-02f,
  9.75229666e-02f, -1.06798746e-02f, 2.78108288e-02f, 4.60297428e-02f, 1.24676019e-01f, 1.71407357e-01f, 1.56821653e-01f, -2.59697530e-02f, 9.56899673e-02f, 1.95481598e-01f,
  -3.85430485e-01f, 9.70123261e-02f, 8.89607817e-02f, 7.08431080e-02f, 7.58066773e-02f, 1.03268800e-02f, -1.42426975e-02f, -2.65365064e-01f, -3.08100879e-01f, -1.36166602e-01f,
  -7.74614960e-02f, 1.10230990e-01f, -5.06331623e-02f, 9.37878713e-02f, 4.86061648e-02f, 9.29585099e-03f, 8.98226649e-02f, 2.27217954e-02f, -1.00310944e-01f, -3.91953811e-02f,
  -8.85805488e-02f, 1.07710615e-01f, 2.65176389e-02f, -4.99893017e-02f, 1.56980548e-02f, 1.55972332e-01f, 7.78900608e-02f, -4.62341681e-02f, 9.19507518e-02f, 7.25028589e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.77706644e-01f, 2.87469685e-01f, 4.74891663e-01f, 2.62174934e-01f, 5.13474107e-01f, 8.58136117e-01f, 5.59925556e-01f, 7.65034854e-01f, 4.82969642e-01f, 9.06461924e-02f,
  4.52083319e-01f, 5.92691481e-01f, 7.30386257e-01f, 1.70278683e-01f, 7.04674900e-01f, 6.12056911e-01f, 5.06910324e-01f, 5.81382573e-01f, 1.54296666e-01f, 1.56963184e-01f,
  6.82947755e-01f, 3.96934599e-01f, 5.87587118e-01f, 5.94643772e-01f, 1.86988726e-01f, 8.26402903e-01f, 4.22837108e-01f, 4.71265435e-01f, 2.62965381e-01f, 3.76293719e-01f,
  7.06346452e-01f, 7.03626454e-01f, 5.25108695e-01f, 8.66783500e-01f, 6.17699385e-01f, 7.45240271e-01f, 3.36826801e-01f, 4.32209671e-01f, 4.83814508e-01f, 4.29074287e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -2.18848094e-01f, -3.08358312e-01f, -5.87987751e-02f, -1.10511027e-01f, -1.02429032e-01f, -2.70580590e-01f, 1.58234671e-01f, -8.33157226e-02f, -1.93885580e-01f, -2.78016061e-01f,
  -1.38153464e-01f, -1.08307540e-01f, -9.44575388e-03f, 1.47510976e-01f, -6.41558990e-02f, 1.92116827e-01f, -1.07864544e-01f, -2.51889348e-01f, 6.36056364e-02f, -4.20616001e-01f,
  5.49117997e-02f, -4.77765560e-01f, -1.53102726e-01f, 4.27836180e-01f, 2.85235703e-01f, 2.56846875e-01f, -5.95570624e-01f, 2.05353856e-01f, 6.24798313e-02f, 4.75681812e-01f,
  3.69052030e-02f, 2.64763951e-01f, -1.91510603e-01f, -3.19584280e-01f, 4.30177748e-01f, 1.18945844e-01f, -5.25976002e-01f, -2.44040594e-01f, -8.20447385e-01f, 1.26802176e-01f,
  -3.91909570e-01f, 3.58689159e-01f, 2.07275059e-02f, -6.29248396e-02f, -4.54840481e-01f, 1.10489689e-02f, -6.44176066e-01f, -8.60132217e-01f, 5.79122066e-01f, -4.20495093e-01f,
  -6.98017061e-01f, -4.41505432e-01f, -3.05877179e-01f, 5.61744012e-02f, -4.85025048e-02f, -3.10755968e-01f, -1.00893542e-01f, -7.22326040e-02f, -1.09192170e-01f, -6.35569632e-01f,
  -1.29793835e+00f, 4.93008375e-01f, -2.48225644e-01f, -8.41234922e-01f, -1.12661794e-01f, 2.18363591e-02f, -2.03102902e-01f, -1.37976900e-01f, -1.27032518e-01f, 6.92277998e-02f,
  7.18782097e-02f, -9.83308852e-02f, -3.45634595e-02f, -2.22715378e-01f, -1.26485880e-02f, -1.17002584e-01f, 2.46849522e-01f, 4.51914780e-02f, 1.84224740e-01f, -1.15053937e-01f,
  2.47972384e-01f, 7.46750683e-02f, -3.05477530e-01f, -8.47416231e-04f, 9.91476178e-02f, -3.26057851e-01f, -6.52850717e-02f, 1.25915498e-01f, 8.47032517e-02f, 1.76450551e-01f,
  -7.52407730e-01f, 7.86929950e-02f, -9.34645355e-01f, -1.11046895e-01f, -8.44419450e-02f, -6.58842683e-01f, 5.60963392e-01f, -4.70415652e-01f, -9.47838902e-01f, -1.90871954e-01f,
  4.27683890e-01f, -2.35023841e-01f, -8.70232582e-02f, -2.13558853e-01f, 2.30641253e-02f, 1.10497510e+00f, -2.16802314e-01f, 2.24389195e-01f, -5.38681805e-01f, 9.68285576e-02f,
  -3.20600867e-01f, -7.29720950e-01f, 4.27655101e-01f, -7.85437524e-01f, 8.50644261e-02f, -1.92640364e-01f, 3.22617233e-01f, 4.44506466e-01f, -3.78353745e-01f, 2.53777653e-01f,
  -1.31680572e+00f, 6.23555303e-01f, 2.12356642e-01f, -7.34269619e-01f, -4.52420488e-02f, 5.66436470e-01f, 2.78384745e-01f, 3.71419013e-01f, 7.96802491e-02f, 2.09729597e-01f,
  2.46335447e-01f, 1.63185149e-01f, 1.73187569e-01f, -1.25583604e-01f, 1.67932123e-01f, 1.20130233e-01f, 4.44341041e-02f, 1.41574785e-01f, -6.37287945e-02f, 1.86629463e-02f,
  4.37039375e-01f, -5.02992451e-01f, -3.45524132e-01f, 1.88450962e-02f, -3.46286327e-01f, -3.33936006e-01f, 4.62040812e-01f, -8.96145776e-02f, 2.93282509e-01f, 1.38442129e-01f,
  -1.05453156e-01f, -2.67295241e-01f, -2.71086007e-01f, -3.15309942e-01f, -7.00458586e-01f, 2.45875061e-01f, -5.65112054e-01f, 3.12673360e-01f, -6.37458712e-02f, -6.57537341e-01f,
  2.71819860e-01f, 6.20756328e-01f, -2.96105325e-01f, 7.45122492e-01f, 4.48529571e-01f, -4.93897855e-01f, 3.83154631e-01f, -5.16640544e-01f, -1.63108334e-01f, 5.28034449e-01f,
  -3.21478546e-01f, -3.60738605e-01f, 7.90579394e-02f, -3.67192835e-01f, -3.50411385e-01f, -1.39966175e-01f, -4.24378097e-01f, -4.55531359e-01f, -6.48878753e-01f, -4.61512715e-01f,
  -5.18832922e-01f, -3.72217983e-01f, 1.08283766e-01f, -3.91994298e-01f, 8.29459965e-01f, 4.24019732e-02f, -2.23222539e-01f, -4.24857855e-01f, -4.77441669e-01f, 4.19573456e-01f,
  -2.23336205e-01f, 1.33033812e-01f, -1.55700818e-01f, -1.00055002e-01f, 2.34261919e-02f, -2.23628283e-01f, 3.36314887e-02f, -8.82798398e-04f, -4.63708676e-02f, -5.80400415e-02f,
  5.40224575e-02f, 1.55556440e-01f, 1.52015328e-01f, 1.07992757e-02f, 5.48337579e-01f, 1.11576840e-01f, -1.93781068e-03f, 4.85793233e-01f, -1.56966686e-01f, 4.78930891e-01f,
  4.81507927e-02f, 2.85883129e-01f, -2.22688884e-01f, 4.28526223e-01f, -2.44797736e-01f, 2.69240767e-01f, -2.24908054e-01f, -8.80363464e-01f, -2.66950667e-01f, -7.01876640e-01f,
  -1.40821459e-02f, -3.40599835e-01f, -1.05366778e+00f, 3.71494770e-01f, -1.16246843e+00f, -5.34531474e-01f, 2.66707778e-01f, -3.28738838e-01f, -2.33523890e-01f, -1.44747436e-01f,
  -3.23336422e-01f, -7.59110823e-02f, -5.60516059e-01f, 4.32487279e-02f, -4.41202015e-01f, -2.75385678e-01f, -1.02461599e-01f, 8.11575532e-01f, -4.24878299e-01f, 8.42003286e-01f,
  -1.97131276e-01f, 7.87713408e-01f, -1.18092760e-01f, -5.56126535e-01f, -3.08272570e-01f, -2.84416586e-01f, -3.41691613e-01f, -6.36520922e-01f, -3.58914994e-02f, -1.21228397e+00f,
  -6.22744143e-01f, -7.84213185e-01f, 6.03404641e-01f, 2.38272905e-01f, 3.89572829e-01f, -1.65623069e-01f, -6.75287098e-02f, -2.51861811e-01f, -1.51264578e-01f, 4.72245447e-04f,
  -1.39449758e-03f, -2.61134841e-02f, 1.41068131e-01f, 1.58248618e-01f, 9.66162980e-02f, 6.75926507e-02f, -1.82217687e-01f, -1.74150899e-01f, -3.15184355e-01f, 8.34363848e-02f,
  2.36834764e-01f, -5.90192139e-01f, -2.95364588e-01f, 1.41932517e-01f, -2.31078938e-01f, 3.82534228e-02f, -9.48464051e-02f, -1.43427700e-01f, 8.92731026e-02f, -3.75229686e-01f,
  3.07789773e-01f, 9.93676037e-02f, 7.41306901e-01f, -4.33305167e-02f, 3.37167412e-01f, -1.16304731e+00f, 4.76125181e-02f, 9.38258767e-02f, 4.25582975e-01f, -2.11045504e-01f,
  -1.43248647e-01f, -2.87239671e-01f, -7.51836598e-01f, -1.01544356e+00f, 1.77383929e-01f, -5.02581298e-01f, 1.89449623e-01f, -2.30645508e-01f, 2.76349545e-01f, -5.19844592e-01f,
  -3.06480937e-02f, -1.87943608e-01f, 4.47141737e-01f, -1.99559912e-01f, 2.20131412e-01f, 1.27795294e-01f, 1.40192449e-01f, -4.64722723e-01f, -2.38680914e-01f, -2.50762165e-01f,
  -4.97797787e-01f, -1.91897467e-01f, 3.77121478e-01f, -6.05540812e-01f, -5.02735555e-01f, 6.11772656e-01f, 4.13802385e-01f, -3.51429403e-01f, 7.90044591e-02f, 2.09996179e-02f,
  6.53639063e-02f, 2.39312083e-01f, -4.10556830e-02f, 7.82842375e-03f, 3.46610136e-02f, 2.98317999e-01f, 1.31076291e-01f, -1.18232451e-01f, -1.19767487e-01f, 1.23590879e-01f,
  4.91284579e-02f, 3.18991393e-01f, -2.67178178e-01f, -1.33644968e-01f, 1.48381919e-01f, 2.04749301e-01f, 4.13528264e-01f, 2.33110204e-01f, 1.37275487e-01f, 2.29541630e-01f,
  -2.64450610e-01f, 1.07544817e-01f, 3.75768214e-01f, 1.04539454e-01f, -3.67756993e-01f, 3.66609961e-01f, -1.05814946e+00f, -2.03936011e-01f, 5.15519798e-01f, 6.11241639e-01f,
  2.93349236e-01f, 4.69792932e-01f, 5.44171691e-01f, 1.94134489e-01f, -1.71947107e-02f, -3.24059457e-01f, -5.00653446e-01f, -2.54483193e-01f, -5.68022132e-01f, 7.08627760e-01f,
  1.31561980e-01f, -9.67836559e-01f, 3.90806869e-02f, -5.97345531e-01f, -6.11941814e-01f, -6.62030935e-01f, 7.84792185e-01f, -1.09734559e+00f, -4.66448426e-01f, -2.39412695e-01f,
  1.44529641e-01f, -2.58553118e-01f, 8.15609321e-02f, -1.50287878e-02f, 1.45998269e-01f, 6.10912800e-01f, -7.49055207e-01f, 3.53161991e-01f, 1.96678072e-01f, 5.61309338e-01f,
  -7.84735382e-01f, -2.29195163e-01f, -4.55600262e-01f, -3.96970183e-01f, -1.43273786e-01f, 2.98568066e-02f, -1.44992515e-01f, -1.09877689e-02f, 1.52717695e-01f, -2.68163741e-01f,
  -1.65095814e-02f, 2.14919031e-01f, -1.55960675e-03f, 2.01939698e-02f, 8.11660960e-02f, -3.16694796e-01f, -3.96154672e-01f, -3.61204207e-01f, -2.52310544e-01f, -1.07384786e-01f,
  1.54963881e-01f, -2.36886337e-01f, 5.01288056e-01f, 6.48416206e-02f, 1.38994902e-01f, 2.21446723e-01f, 1.26068136e-02f, -2.35931963e-01f, -4.85629559e-01f, -5.84334791e-01f,
  5.40855944e-01f, -7.56285563e-02f, -1.05315208e+00f, 5.73583484e-01f, 2.54429281e-01f, -3.53268772e-01f, -2.70065218e-01f, -7.03619182e-01f, -1.14558804e+00f, 2.47078180e-01f,
  4.03890669e-01f, 3.77218604e-01f, -1.90248251e-01f, -5.16053796e-01f, 4.86409158e-01f, -7.96304345e-01f, 1.72462389e-01f, 5.55667043e-01f, -5.88860154e-01f, -4.97348696e-01f,
  -6.67882501e-04f, 1.43645136e-02f, -8.57889056e-01f, -8.22707176e-01f, -5.20071030e-01f, -2.21084625e-01f, -3.14055711e-01f, 1.19753495e-01f, -2.03075022e-01f, 4.53464836e-01f,
  8.12041610e-02f, -4.60801631e-01f, -4.59982008e-01f, 1.26127124e-01f, -4.86000866e-01f, -8.04002523e-01f, -2.34942496e-01f, 6.37341887e-02f, -1.75081536e-01f, -1.36741847e-01f,
  -1.31835341e-01f, -1.54855149e-02f, -1.34339218e-03f, -1.04460485e-01f, -8.83892328e-02f, -8.50772709e-02f, -1.12172738e-01f, -1.65142581e-01f, -3.43189865e-01f, -1.55694395e-01f,
  2.19264373e-01f, -6.72694743e-02f, 8.32827110e-03f, -5.13294078e-02f, -5.13180755e-02f, 3.10906500e-01f, -7.26567060e-02f, -1.38147384e-01f, 4.03226987e-02f, 2.99406230e-01f,
  2.50747114e-01f, 6.75596204e-03f, -3.56156468e-01f, -4.96535510e-01f, -6.41622543e-01f, 4.60456067e-04f, 9.66426253e-01f, 1.56849310e-01f, -2.15982050e-01f, -6.92822635e-01f,
  -3.04619759e-01f, -6.56060815e-01f, 6.97538495e-01f, 2.38500670e-01f, -6.53984964e-01f, 1.34121999e-01f, 5.47016263e-01f, -3.63551468e-01f, -4.83317763e-01f, -7.63345063e-01f,
  2.99450129e-01f, -4.04159725e-01f, -1.83218688e-01f, -7.62443423e-01f, -5.95249087e-02f, 2.89589792e-01f, -3.18967640e-01f, 2.41243988e-02f, 3.60199183e-01f, 3.36812168e-01f,
  7.77762011e-02f, -4.00773257e-01f, 6.24236017e-02f, -4.88522828e-01f, -4.79314476e-01f, -1.25943497e-01f, -4.34773982e-01f, -3.04317355e-01f, 4.35044706e-01f, -4.17122632e-01f,
  -3.97791481e-03f, -4.43764836e-01f, -6.05745148e-03f, 2.21513316e-01f, -1.05852909e-01f, 1.24711417e-01f, 2.50215083e-01f, 8.60023648e-02f, -3.11350022e-02f, -4.23640944e-02f,
  -5.65728284e-02f, 9.97205898e-02f, 1.60890803e-01f, 4.57979031e-02f, 2.19194338e-01f, -3.30461338e-02f, -2.01368853e-01f, 2.24339947e-01f, 1.97605025e-02f, 2.79800594e-01f,
  5.43004274e-01f, 3.88409644e-01f, 1.88520774e-01f, -4.96362755e-03f, 1.39933191e-02f, 2.15776607e-01f, -2.61557370e-01f, 1.85702249e-01f, -4.50488120e-01f, -2.98516899e-01f,
  -6.05857074e-01f, -4.74267423e-01f, -1.73499078e-01f, -5.94622910e-01f, -7.03459024e-01f, -3.30283880e-01f, -5.23963094e-01f, 2.79673606e-01f, 8.02632272e-01f, -1.68455184e-01f,
  -1.16238698e-01f, 7.33109474e-01f, -3.19083542e-01f, -6.58455610e-01f, -7.89806843e-02f, -1.40922517e-01f, 7.25607693e-01f, -8.16793919e-01f, 3.79432738e-01f, -2.68730283e-01f,
  -3.98126572e-01f, -1.65851697e-01f, 1.59939587e-01f, 5.09156764e-01f, -2.89576381e-01f, -2.49829143e-01f, 6.12334907e-01f, -4.78990167e-01f, -3.21645409e-01f, 1.31050162e-02f,
  4.21704978e-01f, -7.20724583e-01f, -3.62125523e-02f, -4.45834398e-01f, 1.69668451e-01f, 1.59496441e-01f, 8.19703937e-03f, -3.95291075e-02f, 8.21594968e-02f, -4.13918018e-01f,
  -1.90126389e-01f, 1.91130370e-01f, 1.37053445e-01f, -1.42018601e-01f, -1.71628699e-01f, -1.22141093e-01f, 1.06783539e-01f, 9.28218588e-02f, -3.24713737e-01f, 3.80498081e-01f,
  2.54338712e-01f, -1.59053460e-01f, -1.99003860e-01f, -1.23768307e-01f, -6.91599131e-01f, -3.02195191e-01f, 9.13975462e-02f, -3.67343694e-01f, -2.59791881e-01f, -2.41070271e-01f,
  -3.70970756e-01f, -2.31804818e-01f, 3.26062709e-01f, 6.32885918e-02f, 6.76792622e-01f, 3.35368589e-02f, -5.16908705e-01f, -9.36074853e-01f, 1.36371881e-01f, 9.18068945e-01f,
  3.77942994e-02f, -2.63437450e-01f, -3.00265580e-01f, 3.72838497e-01f, -1.23819951e-02f, -3.58845145e-01f, 2.14588106e-01f, -7.20267415e-01f, -4.81410891e-01f, 3.02596539e-01f,
  1.23035602e-01f, -7.99385309e-01f, 4.68349680e-02f, -6.21903479e-01f, -2.35910416e-02f, -6.38638854e-01f, -2.43392855e-01f, -1.70582116e-01f, -1.83715537e-01f, -4.24941301e-01f,
  5.46023309e-01f, -8.16875577e-01f, 3.64626706e-01f, 2.83766955e-01f, 5.10712042e-02f, 5.40410280e-01f, 3.35065067e-01f, -3.62820059e-01f, -2.32507512e-01f, 2.92779595e-01f,
  2.17768148e-01f, 1.86036110e-01f, 2.54510015e-01f, 2.02524588e-01f, -4.60473597e-02f, -3.44607204e-01f, -2.73675680e-01f, 1.74241439e-01f, 4.69541699e-02f, -1.86873838e-01f,
  -2.21389788e-03f, 1.47875175e-01f, 1.79215185e-02f, 1.57814145e-01f, 2.78894454e-01f, 2.90836394e-01f, 2.03924090e-01f, 2.69070357e-01f, -4.17294204e-01f, 6.67582452e-03f,
  -7.69218430e-02f, 3.60729784e-01f, 2.30569974e-01f, 2.38998279e-01f, 4.64900106e-01f, -2.09594876e-01f, -2.93220133e-01f, -2.85754114e-01f, -7.61994600e-01f, -1.36022553e-01f,
  -3.35550249e-01f, 3.36028934e-01f, -6.93650246e-01f, 3.08998972e-01f, -3.86892736e-01f, -3.18553180e-01f, -5.57414412e-01f, -1.30899772e-01f, 9.47095633e-01f, -6.72989309e-01f,
  -2.44885758e-01f, 2.93479890e-01f, -3.47124159e-01f, -1.38256028e-01f, 5.52733660e-01f, 7.72450566e-01f, 8.99509490e-02f, -5.68661213e-01f, -5.15798986e-01f, -3.99348468e-01f,
  -4.38582391e-01f, 5.27419806e-01f, -3.47949982e-01f, -3.48677307e-01f, 3.54982048e-01f, 4.18663442e-01f, -7.28210330e-01f, 1.76595956e-01f, -3.45606834e-01f, -3.94410521e-01f,
  -2.93343276e-01f, -8.42043400e-01f, -6.08744442e-01f, -6.29944146e-01f, 5.60799278e-02f, -1.20353196e-02f, 1.10877439e-01f, 2.49878481e-01f, 8.36831331e-02f, 9.02949199e-02f,
  5.60933873e-02f, 9.62121412e-04f, 1.41785778e-02f, 2.90879812e-02f, -6.53772578e-02f, 1.31228983e-01f, -3.92371863e-01f, 6.65814336e-03f, 3.41270082e-02f, -2.09933575e-02f,
  8.12049657e-02f, -2.99821109e-01f, 3.45017403e-01f, 3.08511883e-01f, 1.92978546e-01f, -3.41538727e-01f, 2.29078382e-01f, 5.10975532e-02f, -3.40698212e-01f, -4.15742666e-01f,
  6.16232753e-01f, -2.44567513e-01f, -7.17353702e-01f, -8.89032423e-01f, 5.67299485e-01f, -6.37992680e-01f, -5.31298399e-01f, 8.77140090e-02f, -5.11362255e-01f, -1.75357163e-02f,
  -8.19987059e-01f, -1.31407782e-01f, -2.42137164e-01f, -7.52690360e-02f, 3.58540118e-01f, -1.47878259e-01f, -1.80723201e-02f, -3.49716306e-01f, -3.04883748e-01f, -4.38987553e-01f,
  -2.42637232e-01f, 8.73646677e-01f, 1.12966321e-01f, 7.85876870e-01f, -1.82256296e-01f, -6.79310918e-01f, 1.08904131e-01f, 5.98688960e-01f, -1.13125868e-01f, -4.36056525e-01f,
  -5.16970456e-01f, -4.44571018e-01f, 5.24149716e-01f, -5.94716430e-01f, 4.65448201e-01f, -2.87413627e-01f, 5.15036546e-02f, -3.55513282e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.58920839e-01f, -1.37097044e-02f, 2.65245527e-01f, 1.20054014e-01f, 1.86187513e-02f, 6.27446473e-02f, 1.25975892e-01f, -4.42728214e-02f, 8.36956576e-02f, -8.92880559e-03f,
  1.66308992e-02f, 1.09250806e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    