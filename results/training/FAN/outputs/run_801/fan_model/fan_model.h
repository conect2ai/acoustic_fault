/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.56976974e-01f, 3.32529485e-01f, 3.65477085e-01f, -3.29180717e-01f, 2.97182649e-02f, 1.65625848e-02f, 3.06564480e-01f, 3.55134495e-02f, -2.32096434e-01f, 3.22611630e-01f,
  -1.11273065e-01f, -2.34735042e-01f, -1.33146316e-01f, 2.20555700e-02f, -5.99509738e-02f, 3.71596992e-01f, 2.89539605e-01f, 7.30457827e-02f, -2.83017278e-01f, -1.98207483e-01f,
  -8.65188390e-02f, 1.53265949e-02f, -1.82509035e-01f, -1.71490848e-01f, 1.87756315e-01f, -2.57013917e-01f, 2.57463664e-01f, 6.40667006e-02f, 8.46069828e-02f, 6.05906308e-01f,
  9.54995397e-03f, 1.28629461e-01f, -6.47077560e-02f, -1.22196525e-01f, 9.42643881e-02f, -1.98155530e-02f, -1.12842349e-02f, 3.62378135e-02f, -1.16441306e-02f, 2.73019597e-02f,
  -2.99710073e-02f, -5.94379976e-02f, -3.35923769e-02f, 3.45621891e-02f, -3.02990302e-02f, -9.99456085e-03f, 3.46461348e-02f, 3.16474140e-02f, 6.96402267e-02f, 9.53491777e-02f,
  6.62086438e-03f, 2.86115031e-03f, 1.29427209e-01f, 4.38565128e-02f, 1.60044953e-02f, -4.34789285e-02f, 5.90028800e-02f, 1.06434561e-01f, 1.04655318e-01f, 1.89068347e-01f,
  -8.52216315e-03f, -4.98872390e-03f, -8.74145702e-03f, -1.07544372e-02f, -7.74157746e-03f, 1.10733900e-02f, 3.23002189e-02f, -3.15482356e-02f, 5.16015163e-04f, -3.43977078e-03f,
  4.08275053e-03f, 5.89173734e-02f, -2.55603213e-02f, 3.42877395e-02f, -2.98154894e-02f, 5.36420792e-02f, -3.33057456e-02f, 2.28963755e-02f, -4.04244661e-02f, 3.37825157e-02f,
  -2.29099616e-02f, 3.78564708e-02f, -6.96409680e-03f, -1.74711812e-02f, 2.52515003e-02f, -1.27820456e-02f, -2.36739554e-02f, -5.01243258e-03f, -3.77518982e-02f, -1.71343628e-02f,
  -1.11513086e-01f, -1.77749489e-02f, -6.33278862e-03f, 5.53084090e-02f, -4.84229326e-02f, -6.33280352e-03f, -9.33392718e-03f, -2.48193722e-02f, -1.85929313e-02f, 6.20574737e-03f,
  -1.77742820e-02f, -7.68042402e-03f, 3.09813563e-02f, 7.07805762e-03f, -4.99807931e-02f, -8.70315451e-03f, -8.65604356e-03f, -5.40512167e-02f, 2.13207770e-02f, -2.32349169e-02f,
  3.75988819e-02f, 4.09597494e-02f, -1.13854006e-01f, 2.59808712e-02f, -3.76575030e-02f, -8.43268409e-02f, -8.53068829e-02f, -6.34632409e-02f, -1.18155926e-01f, -7.15407506e-02f,
  -4.88274544e-01f, -1.16049312e-01f, -1.50021389e-01f, -2.01193437e-01f, 3.06118149e-02f, 1.68780938e-01f, 7.43315648e-03f, 3.41888517e-02f, -1.15994979e-02f, 7.81393796e-02f,
  2.16049850e-01f, 1.04844332e-01f, -6.39323741e-02f, 5.84557792e-03f, -1.47064477e-01f, -6.23403378e-02f, -1.69657022e-01f, -2.91460663e-01f, -7.17880949e-02f, 9.85411778e-02f,
  1.00785300e-01f, -2.07564607e-01f, -1.90444916e-01f, -6.94094151e-02f, -2.63911821e-02f, 1.54531837e-01f, -4.38671857e-02f, -9.89405364e-02f, 5.29121980e-02f, -1.73664898e-01f,
  -1.49409706e-02f, -9.38754678e-02f, 1.73180457e-02f, -9.09517892e-03f, 6.23254329e-02f, -1.27182994e-02f, -3.19355913e-02f, -2.78689098e-02f, 1.03621028e-01f, -1.38023309e-02f,
  1.17805507e-02f, 1.24366179e-01f, 1.41077461e-02f, -3.82886920e-03f, -9.03045759e-02f, -3.70659158e-02f, -4.41178121e-02f, -1.17739908e-01f, 3.29184383e-02f, 1.67274866e-02f,
  1.47852048e-01f, 3.55170779e-02f, -1.77340060e-01f, 5.19389287e-02f, 2.94231321e-03f, -3.92610990e-02f, -6.37558941e-03f, 2.03912016e-02f, 2.68226699e-03f, -6.68421313e-02f,
  4.47616018e-02f, -9.11233202e-03f, 1.87581182e-02f, 1.03588542e-02f, -3.12460642e-02f, 2.92466488e-02f, -5.27064390e-02f, 3.00445873e-02f, -2.68019792e-02f, -3.00466195e-02f,
  -2.27227734e-04f, 3.63772213e-02f, 6.35438692e-03f, -3.01055852e-02f, 3.44976000e-02f, -2.93537211e-02f, 7.12257158e-03f, -2.30197124e-02f, 9.80891008e-03f, -3.82399820e-02f,
  6.37034280e-03f, -1.80403646e-02f, -1.80999804e-02f, -9.53007024e-03f, 9.95728187e-04f, -2.88267862e-02f, -1.22626107e-02f, 1.34534128e-02f, 4.58621001e-03f, 3.62737291e-02f,
  8.44945163e-02f, -6.22468628e-02f, -5.14331199e-02f, 4.03780676e-02f, 6.45616325e-03f, 3.84628363e-02f, 3.52735743e-02f, 7.17784241e-02f, -1.99235920e-02f, 1.62817314e-02f,
  1.21354954e-02f, -4.50785905e-02f, -2.36999622e-04f, 3.62520441e-02f, -8.07286939e-04f, 1.81507524e-02f, 7.47954547e-02f, 3.51336896e-02f, -4.66790274e-02f, 6.48742765e-02f,
  3.52002978e-02f, -2.82864459e-02f, 2.20793113e-02f, 3.83659080e-02f, 1.88192893e-02f, -7.57918134e-02f, 3.16566005e-02f, 4.14595269e-02f, -6.15286715e-02f, 1.31510064e-01f,
  -1.67357638e-01f, 1.25257403e-01f, 2.83719420e-01f, -8.56923983e-02f, 6.75855875e-02f, -1.77769661e-01f, -3.10697138e-01f, -2.04478383e-01f, -7.75768384e-02f, -3.11119785e-03f,
  5.54377586e-02f, -7.15972930e-02f, 1.20934293e-01f, -1.87957790e-02f, -5.16687892e-02f, -1.68707788e-01f, 1.75225601e-01f, 1.88317493e-01f, -1.08163625e-01f, -2.33179554e-01f,
  -1.85162783e-01f, 1.28189966e-01f, 2.40166485e-01f, 7.60541158e-03f, 9.86137777e-04f, -2.41283551e-01f, 3.12243372e-01f, 2.68548578e-01f, 1.15759410e-01f, 2.99227923e-01f,
  1.64657936e-01f, 2.30242968e-01f, -8.58141631e-02f, 4.30900119e-02f, 1.13571182e-01f, -2.40708403e-02f, -6.15599230e-02f, 1.32615685e-01f, 2.71910857e-02f, 3.24233295e-03f,
  1.06079698e-01f, -2.75792019e-03f, 9.45088118e-02f, -5.22453710e-02f, 7.57077187e-02f, -8.82516503e-02f, 3.34844030e-02f, 6.49120286e-02f, 6.94748312e-02f, -2.36919179e-04f,
  9.29840133e-02f, 1.61178812e-01f, 1.20326854e-01f, 6.54182071e-03f, 1.46253586e-01f, 1.88989788e-01f, 6.23506233e-02f, 8.11728090e-02f, 6.52068853e-02f, 7.43843988e-02f,
  -2.62041334e-02f, 3.08836605e-02f, 3.12834680e-02f, -6.08398812e-03f, 2.11549383e-02f, -1.91119816e-02f, 5.83779961e-02f, -5.96496649e-02f, 1.18970424e-02f, -4.99558486e-02f,
  5.82561530e-02f, -4.29449007e-02f, 3.11248526e-02f, 2.74360161e-02f, -4.56010252e-02f, 3.33743431e-02f, -1.49434209e-02f, 1.34401582e-02f, 4.06976119e-02f, 6.16003480e-03f,
  -3.30514759e-02f, 1.31062046e-02f, 3.10182981e-02f, -6.67270571e-02f, 3.24519314e-02f, -1.21660903e-03f, 2.16277689e-02f, -2.19934061e-02f, -1.59323812e-02f, -2.59449333e-02f,
  -2.89868623e-01f, 2.44048350e-02f, -2.15246864e-02f, -3.33500504e-02f, -7.40709826e-02f, 4.48530130e-02f, 6.39768094e-02f, -8.09364468e-02f, 5.55426590e-02f, -6.03252612e-02f,
  -6.90472126e-02f, 1.91850569e-02f, -2.55565718e-03f, 2.05357336e-02f, -1.04432359e-01f, -3.28869261e-02f, -3.70746851e-02f, -1.10766426e-01f, 5.83519004e-02f, 3.85310012e-03f,
  -3.73495296e-02f, -2.26771861e-01f, -2.84856558e-01f, -1.56894684e-01f, -9.34045315e-02f, -1.30162120e-01f, -2.48334020e-01f, -1.72460616e-01f, -1.56973734e-01f, -6.11307323e-01f,
  6.81288466e-02f, 1.46703929e-01f, -2.92934448e-01f, -3.65855873e-01f, 6.82075508e-03f, 1.67122811e-01f, 2.25499406e-01f, 2.00869963e-01f, -3.41059603e-02f, -2.04224244e-01f,
  1.16094939e-01f, -1.14279814e-01f, -1.57742277e-01f, -1.04903743e-01f, 1.68135002e-01f, -7.26510137e-02f, -2.21241429e-01f, -1.77410424e-01f, -4.60111834e-02f, 1.18342236e-01f,
  -1.48406684e-01f, -3.10819536e-01f, -4.34418842e-02f, 5.91251291e-02f, -2.97554463e-01f, -2.03885183e-01f, -1.11121684e-01f, -6.79915622e-02f, 2.79964775e-01f, -6.73042655e-01f,
  -2.94319153e-01f, 6.66074157e-02f, 1.24761881e-02f, -3.29297110e-02f, 6.90801442e-02f, 5.88494912e-02f, 5.75028881e-02f, -1.99112240e-02f, 5.27109653e-02f, -2.38861982e-02f,
  -5.40110618e-02f, -2.85939258e-02f, -3.06110103e-02f, -8.07676986e-02f, -4.85996762e-03f, -2.00232659e-02f, 1.36307292e-02f, 3.87377962e-02f, -6.50382461e-03f, 3.80001441e-02f,
  -8.85784030e-02f, 3.58010642e-02f, 5.59410639e-02f, 1.11832418e-01f, 7.85636157e-02f, -1.13743417e-01f, 9.77410972e-02f, 3.21876518e-02f, 1.52325019e-01f, -9.92372707e-02f,
  7.66738970e-03f, -4.00724560e-02f, 5.88921644e-02f, -7.66028324e-03f, 2.52954420e-02f, -4.43410641e-03f, -2.06702389e-02f, -1.51779074e-02f, 1.72940064e-02f, 1.19624622e-02f,
  -4.64697555e-03f, 1.95766538e-02f, -5.54136746e-02f, 5.14054112e-02f, -7.46964291e-02f, 2.02360116e-02f, -1.04360515e-02f, -3.22880433e-03f, -5.72412647e-02f, 2.00672019e-02f,
  -2.02044509e-02f, 3.69846486e-02f, -4.10427600e-02f, -2.32918374e-02f, 2.60816161e-02f, -3.83441150e-02f, -8.61627795e-03f, 5.93412519e-02f, -3.01112048e-02f, 3.92241143e-02f,
  1.23161055e-01f, 1.22340187e-01f, -1.20681182e-01f, 4.74877916e-02f, -9.85514894e-02f, 3.02414279e-02f, -3.78190316e-02f, -7.75589189e-03f, 1.41172474e-02f, -8.05007294e-03f,
  4.56076041e-02f, -4.12093988e-03f, -5.53901494e-03f, 6.27239868e-02f, -4.60196927e-04f, 1.09598972e-02f, 1.90566406e-02f, -9.31577384e-02f, 5.11296503e-02f, -3.66968289e-03f,
  5.78258187e-02f, 1.04200467e-01f, 6.49107397e-02f, 2.81266291e-02f, -2.18534563e-02f, -5.09923175e-02f, 6.48505101e-03f, -4.84719351e-02f, 1.74973801e-01f, 1.34474620e-01f,
  1.66486472e-01f, 3.15397084e-02f, 5.21233380e-01f, -1.32147789e-01f, 1.27002031e-01f, 1.00536838e-01f, 1.78685531e-01f, -3.80015448e-02f, 4.80298214e-02f, 1.19682580e-01f,
  1.46118969e-01f, -1.39002576e-01f, -1.35520786e-01f, -1.67512268e-01f, -9.34499130e-02f, 2.79263500e-02f, -8.75074789e-02f, 3.42988595e-02f, -1.27483308e-01f, -1.69876263e-01f,
  -2.41816983e-01f, 1.36010632e-01f, 2.08337512e-02f, -9.12561715e-02f, -4.89659458e-02f, 2.45217588e-02f, 2.63981879e-01f, 1.06393509e-01f, -1.57068789e-01f, -1.54660493e-01f,
  1.35843769e-01f, -2.65422873e-02f, -2.01601870e-02f, -2.35603135e-02f, 7.74179250e-02f, -1.13955505e-01f, 3.27758044e-02f, 1.54707609e-02f, 1.15540307e-02f, -5.26905395e-02f,
  5.97976521e-02f, -8.68885219e-02f, -4.87507246e-02f, -3.84714901e-02f, 2.69281510e-02f, -1.80328041e-02f, -1.16557945e-02f, -8.81370679e-02f, 2.58852411e-02f, -4.12786268e-02f,
  -1.11150809e-01f, 1.26644537e-01f, 1.63908377e-01f, -3.80461700e-02f, 2.76028719e-02f, -1.31337801e-02f, -1.80611312e-02f, -1.55085057e-01f, 5.06851356e-03f, -3.33058299e-03f,
  2.57670414e-02f, 4.12088912e-03f, 1.35297771e-04f, -2.02564541e-02f, 1.49575481e-02f, 1.03176730e-02f, -6.87143654e-02f, -9.69270896e-03f, -3.20776813e-02f, -1.98674873e-02f,
  -3.99914794e-02f, 5.71587309e-02f, -2.70132441e-02f, 1.21638821e-02f, -5.51808476e-02f, 7.36762360e-02f, -3.70922908e-02f, 3.04118209e-02f, -9.51424520e-03f, 5.20604253e-02f,
  -1.69423595e-02f, 6.76223785e-02f, 5.45464046e-02f, -5.66698313e-02f, 4.38951477e-02f, -7.06809834e-02f, -6.66526984e-03f, -3.56933400e-02f, 2.78726500e-03f, 2.90303249e-02f,
  2.42287535e-02f, 6.89349994e-02f, 7.85388201e-02f, -4.53170761e-03f, 2.08079647e-02f, 5.10792583e-02f, 3.96284554e-03f, -4.60044779e-02f, -5.62189892e-03f, 3.65948193e-02f,
  2.17949762e-03f, -2.79616490e-02f, 8.38564932e-02f, -4.06502225e-02f, 9.57519747e-03f, -2.53531821e-02f, 3.84918861e-02f, -2.31558625e-02f, -8.35957080e-02f, 7.39655495e-02f,
  3.59054320e-02f, 5.00288941e-02f, 2.92825624e-02f, 5.23184538e-02f, 3.51060852e-02f, 2.85354513e-03f, 2.61319131e-02f, 9.95159522e-02f, 8.70676711e-02f, 1.46827608e-01f,
  2.32884422e-01f, 4.72161025e-01f, -6.74972951e-01f, 3.53375167e-01f, 2.07576924e-03f, 3.06426752e-02f, 1.69133797e-01f, 1.40452862e-01f, 8.49875435e-02f, 2.60717310e-02f,
  9.27421898e-02f, 1.31927906e-02f, -9.24901888e-02f, -7.60773122e-02f, -6.13939352e-02f, 7.69751370e-02f, -9.09407213e-02f, -3.20911616e-01f, -7.18504310e-01f, -4.35012840e-02f,
  5.75611033e-02f, -1.08390003e-01f, -1.68409675e-01f, 2.84285843e-02f, 1.43839136e-01f, -2.82605588e-01f, 9.44639146e-02f, 1.81664646e-01f, 4.75788154e-02f, -1.29356802e-01f,
  -2.38752782e-01f, 2.65728563e-01f, -2.26745158e-01f, 9.37015340e-02f, 3.88845019e-02f, 5.74717820e-02f, 3.81090455e-02f, 1.55411316e-02f, 8.97353888e-02f, -4.63631153e-02f,
  5.02498001e-02f, -3.05808559e-02f, 8.84756967e-02f, -2.76167560e-02f, 3.56327705e-02f, 2.34484021e-02f, 1.99564658e-02f, -1.48320004e-01f, -4.46234420e-02f, 3.99063379e-02f,
  1.31865472e-01f, 6.71040341e-02f, -7.70701990e-02f, 2.99664475e-02f, 1.19793765e-01f, -1.79642066e-01f, 2.04208568e-02f, 5.17199375e-02f, -1.15312330e-01f, 3.24457288e-02f,
  -2.94903461e-02f, -1.69674531e-02f, -5.88630233e-03f, -2.52614971e-02f, -1.86750805e-03f, 1.47394137e-02f, 3.14392298e-02f, -4.67815213e-02f, 1.20618043e-03f, 3.95097360e-02f,
  -4.41633817e-03f, -2.22916976e-02f, -2.25132592e-02f, 3.01998053e-02f, -7.14957947e-03f, 1.45973475e-03f, 1.74029311e-03f, -1.54920965e-02f, 3.28930505e-02f, -1.62346866e-02f,
  -4.47633825e-02f, -1.16597880e-02f, 6.61355481e-02f, -4.25495431e-02f, 4.59075756e-02f, -1.81180332e-02f, -1.57505479e-02f, -6.24497700e-03f, -1.29979022e-03f, 5.23620173e-02f,
  4.85317782e-02f, -1.06501602e-01f, 8.15853402e-02f, -7.14794472e-02f, 2.18826369e-03f, 3.51195177e-03f, 4.35369164e-02f, -4.15510051e-02f, 3.34333740e-02f, 1.68208648e-02f,
  3.88054666e-03f, 3.35133485e-02f, 2.56147445e-03f, -2.16608550e-02f, -6.70313165e-02f, 2.13145893e-02f, 4.69959155e-02f, -5.83752282e-02f, 2.50789691e-02f, 9.77554079e-03f,
  1.07559927e-01f, -2.58041546e-02f, -6.23660237e-02f, -8.76528919e-02f, -3.60761136e-02f, -5.08617200e-02f, -1.67919531e-01f, -1.24204904e-01f, -8.24232623e-02f, -4.23756205e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.62146950e-01f, 8.96897614e-02f, 4.95929979e-02f, -1.14811771e-02f, -6.55151084e-02f, -1.55576572e-01f, -3.97758791e-03f, -5.01416028e-02f, -1.38478130e-01f, 1.82440653e-01f,
  6.48585260e-02f, -5.06418869e-02f, 3.31728458e-02f, 6.31408840e-02f, -1.34375885e-01f, -7.40954056e-02f, -4.38509993e-02f, -1.31244838e-01f, -1.22316033e-01f, -1.52979657e-01f,
  -1.66615874e-01f, -4.70791832e-02f, -1.83324337e-01f, -6.67365938e-02f, 1.31316558e-01f, 1.41514940e-02f, 1.83892444e-01f, -3.61121967e-02f, 2.82728262e-02f, 1.97493359e-01f,
  9.60845202e-02f, -3.88088562e-02f, -3.95664610e-02f, -1.48156703e-01f, -2.98814778e-03f, 6.01051971e-02f, -4.63484749e-02f, 1.27560467e-01f, 3.93892303e-02f, 3.28720175e-02f,
  -9.59418863e-02f, 1.39129348e-02f, -3.42263579e-02f, -1.28289657e-02f, -7.60871843e-02f, -7.66010433e-02f, 1.56138549e-02f, 3.36265266e-02f, -1.01401985e-01f, 1.04444958e-01f,
  8.70074332e-02f, -3.64498943e-02f, -4.07749079e-02f, -6.26356676e-02f, -4.05963995e-02f, -5.01960218e-02f, 9.54640359e-02f, 9.67573151e-02f, -9.84535962e-02f, 1.86878338e-01f,
  -1.12870047e-02f, -1.10480748e-02f, 9.23017338e-02f, 1.12240955e-01f, -1.59937944e-02f, -3.47906537e-02f, 7.53914714e-02f, 2.72395574e-02f, 9.64202639e-03f, 1.61607377e-02f,
  5.44317961e-02f, 8.84691477e-02f, 5.31237619e-03f, 4.77963947e-02f, 4.43864949e-02f, -3.17393355e-02f, -6.38234094e-02f, 4.73568998e-02f, -8.35127197e-03f, -1.29565047e-02f,
  -3.13509181e-02f, -2.06207838e-02f, -2.50881799e-02f, 4.33330685e-02f, -9.72285941e-02f, 5.66873215e-02f, -2.54523903e-02f, 1.23579865e-02f, -1.33837853e-02f, -8.35016221e-02f,
  1.53262675e-01f, -1.22089721e-01f, 3.43762748e-02f, 2.26617008e-02f, 4.45491113e-02f, -2.66291331e-02f, 8.43198374e-02f, -2.62408685e-02f, 5.50743788e-02f, -3.19072567e-02f,
  -9.25573707e-02f, -3.01368665e-02f, 1.38806095e-02f, 1.48547092e-03f, 7.56587386e-02f, -2.55001150e-02f, 1.21646654e-03f, -3.31469588e-02f, -1.52441682e-02f, -4.15753163e-02f,
  -1.06111713e-01f, 3.08900047e-02f, 2.37172209e-02f, 5.42061962e-02f, 9.18424316e-03f, -2.47364994e-02f, 7.66258016e-02f, 6.85838237e-02f, -1.41867716e-02f, 2.09638193e-01f,
  -1.53976619e-01f, -2.12820351e-01f, -5.01846299e-02f, -4.84374613e-02f, -6.54896162e-03f, -2.18159944e-01f, -3.12889665e-01f, -1.87902629e-01f, 9.38489847e-03f, -8.58065337e-02f,
  -6.05021827e-02f, 4.41206545e-02f, 1.26507699e-01f, 2.20291186e-02f, -1.39500201e-01f, -8.63816440e-02f, -2.42004264e-02f, -1.23307861e-01f, -1.35400787e-01f, -7.93210194e-02f,
  -6.46064878e-02f, 1.30273268e-01f, 1.21141404e-01f, 4.44953293e-02f, 9.06205848e-02f, 1.79071948e-01f, 1.66064069e-01f, 1.04818709e-01f, 9.13397074e-02f, 1.16972066e-02f,
  -2.51028650e-02f, -2.17794236e-02f, 4.92318487e-03f, 3.38994712e-02f, -5.72419493e-03f, -4.55577932e-02f, -7.52320066e-02f, -6.22048192e-02f, -8.00691620e-02f, -2.77695451e-02f,
  4.45529819e-02f, -2.47411635e-02f, -2.37163566e-02f, 8.78863484e-02f, -7.16819465e-02f, -5.72286397e-02f, -1.34083526e-02f, -1.23618372e-01f, -2.51998380e-02f, -2.60421913e-02f,
  -6.24010973e-02f, -6.76824749e-02f, -3.35617289e-02f, -3.20210867e-02f, -1.31268188e-01f, -5.64261638e-02f, -2.10617166e-02f, -7.14878291e-02f, -2.47922409e-02f, -6.20677769e-02f,
  6.34254096e-03f, -2.41511445e-02f, -2.87384409e-02f, -4.88552488e-02f, -4.70556226e-03f, 2.77519394e-02f, -1.66583322e-02f, 3.95244593e-03f, 3.28970775e-02f, -7.35836774e-02f,
  -1.86578371e-02f, 6.42557954e-03f, 1.29429102e-02f, -3.09265777e-02f, 5.24284616e-02f, 7.38147367e-03f, 2.56249644e-02f, -6.36906847e-02f, -1.46817146e-02f, 2.86917258e-02f,
  -5.83713911e-02f, -9.87790246e-03f, 7.33869150e-02f, -6.77890331e-02f, -1.73970759e-02f, 5.06670885e-02f, 4.55871187e-02f, 1.46465600e-02f, 3.23300660e-02f, -2.83305976e-03f,
  -8.64005554e-03f, 4.79769520e-02f, -1.38285514e-02f, 3.92915122e-02f, -1.31596206e-03f, 3.48867737e-02f, -5.01279207e-03f, -8.97445891e-04f, -2.67469715e-02f, 2.77579925e-03f,
  -3.93006951e-02f, -1.33617390e-02f, 6.32206351e-02f, -1.65762343e-02f, -1.44892067e-01f, -7.49530271e-03f, -4.67307083e-02f, 1.39879286e-02f, 3.56204063e-02f, -1.08668758e-02f,
  5.90514578e-02f, -1.02876104e-01f, -8.49408284e-02f, -8.69859233e-02f, -2.83291843e-02f, -8.33440572e-02f, -3.62486728e-02f, -5.33189625e-02f, -1.21495061e-01f, -1.61950082e-01f,
  -3.70197207e-01f, 2.02808991e-01f, 1.15905695e-01f, -1.17213659e-01f, -6.80319220e-02f, -1.28224101e-02f, -6.21208437e-02f, -1.06605850e-01f, 4.37617190e-02f, 8.75007063e-02f,
  1.28725097e-01f, -1.02387220e-02f, 1.29862994e-01f, 1.07060164e-01f, -1.58133451e-02f, -6.84855953e-02f, 8.64143576e-03f, -6.44327477e-02f, -1.05303258e-01f, -1.32398680e-01f,
  -4.29873308e-03f, -6.68756738e-02f, -1.56538993e-01f, 2.21393146e-02f, 9.44947898e-02f, 2.10381532e-03f, 1.77885115e-01f, -2.75149774e-02f, 7.47740418e-02f, 4.91780527e-02f,
  3.41630518e-01f, -1.60008799e-02f, -4.47169691e-02f, -4.35059965e-02f, 8.14168453e-02f, -1.61222578e-03f, -3.87620702e-02f, -1.90498903e-02f, 1.13152899e-03f, 1.29780054e-01f,
  3.14293802e-02f, 1.68417133e-02f, 2.59757191e-02f, 8.59741792e-02f, -4.13491130e-02f, 7.17354659e-03f, -8.89485106e-02f, -6.25157496e-03f, 4.80673723e-02f, 1.00276411e-01f,
  -2.34809294e-02f, -9.41585600e-02f, -2.26553250e-02f, -1.34706181e-02f, -7.59602785e-02f, -6.83872309e-03f, 9.04639363e-02f, -7.48126358e-02f, -2.13431716e-02f, 1.60073545e-02f,
  -5.75201660e-02f, 7.23478124e-02f, 1.03683472e-02f, -7.61664957e-02f, -3.44084017e-02f, -3.92918400e-02f, -2.48997267e-02f, 7.01054651e-03f, -1.34196609e-01f, -6.45443723e-02f,
  1.41770300e-02f, -2.17763148e-02f, 3.74593660e-02f, 2.66835410e-02f, 5.85808791e-02f, -1.44902645e-02f, -1.19094171e-01f, 2.36359728e-03f, -1.00734718e-02f, -1.11982655e-02f,
  2.13599075e-02f, -5.86654805e-02f, 4.20840532e-02f, 1.73999146e-02f, 2.77393069e-02f, -1.58438850e-02f, -3.95019688e-02f, 5.98860048e-02f, -8.61989558e-02f, -8.73281434e-02f,
  2.74495840e-01f, -9.23594311e-02f, 1.69482380e-01f, -8.65603685e-02f, -4.50009741e-02f, -5.54998629e-02f, 7.56077021e-02f, -2.52260789e-02f, 8.74037072e-02f, -1.53415827e-02f,
  9.80522204e-03f, -2.24252827e-02f, 4.84412573e-02f, -2.68035242e-03f, 4.90276106e-02f, -5.97629603e-03f, -1.27038032e-01f, 4.64818478e-02f, -3.51950005e-02f, 1.30799308e-01f,
  3.17740180e-02f, -1.03984900e-01f, 2.19296366e-02f, 6.58539161e-02f, 2.14803591e-02f, -5.64805046e-02f, 1.23490550e-01f, 7.51200393e-02f, -2.81843767e-02f, 6.12619519e-02f,
  6.93961263e-01f, -1.81498006e-01f, -9.54913348e-03f, 3.59110653e-01f, 1.89146966e-01f, 1.05741128e-01f, 2.94033550e-02f, 6.46616742e-02f, 1.48668632e-01f, 4.05212082e-02f,
  1.87648404e-02f, 3.35812308e-02f, 2.23840341e-01f, 2.88653020e-02f, 2.78108120e-02f, -1.53010152e-02f, 1.16205610e-01f, 5.48755750e-02f, 1.51501149e-01f, 2.64868345e-02f,
  -4.56529036e-02f, -9.67032313e-02f, -5.95402122e-02f, -3.32208276e-02f, -1.40684098e-01f, -1.03706438e-02f, -4.97748777e-02f, -5.23362271e-02f, -1.12706512e-01f, -2.49792576e-01f,
  2.15987600e-02f, 3.81488577e-02f, 1.56197324e-01f, 1.30488910e-02f, -1.06543906e-01f, 8.42603296e-03f, 8.09028223e-02f, -5.72740510e-02f, 9.08223093e-02f, -6.16860576e-02f,
  -2.66890228e-02f, -7.71725923e-02f, 5.81833050e-02f, -8.82837549e-02f, -7.85778537e-02f, 7.52439862e-03f, -1.56301886e-01f, 8.00722390e-02f, -5.20304516e-02f, -8.25520232e-02f,
  -7.87323527e-03f, 1.12818116e-02f, 7.04654455e-02f, 7.20738024e-02f, 9.02785286e-02f, 1.11565635e-01f, -6.38046563e-02f, -1.27216130e-01f, -8.63402523e-03f, -4.49903645e-02f,
  -7.13670924e-02f, 2.59950049e-02f, -8.23092684e-02f, 2.70817168e-02f, -2.07966678e-02f, -9.10601206e-03f, 1.71626899e-02f, -1.79972369e-02f, 5.23778126e-02f, -3.17132473e-02f,
  1.84854176e-02f, 4.02300246e-02f, 2.39945557e-02f, 7.80304819e-02f, -1.58296563e-02f, -1.66576356e-03f, -6.69310689e-02f, -5.47395460e-02f, 1.12634458e-01f, 2.12337449e-02f,
  1.46239288e-02f, 1.04501611e-02f, 4.68504094e-02f, -1.16612621e-01f, -3.41485441e-02f, 1.22283241e-02f, -6.96840510e-02f, -1.01357969e-02f, 4.53538895e-02f, -2.01708693e-02f,
  -7.13160411e-02f, 1.72903150e-01f, 9.12473276e-02f, -7.61458091e-03f, -2.02519335e-02f, -7.61293918e-02f, 1.23602608e-02f, -2.21826714e-02f, -7.14592785e-02f, -2.41372716e-02f,
  -6.11482188e-02f, -1.88623779e-02f, -1.21054679e-01f, -8.29177350e-02f, 4.76743579e-02f, 1.05786987e-01f, -4.18524779e-02f, 1.11510582e-01f, -8.36383849e-02f, -1.17259761e-02f,
  -1.33584365e-01f, 1.45952642e-01f, 1.96633756e-01f, 1.62344590e-01f, 6.18495718e-02f, 2.67349482e-01f, -6.32194504e-02f, 4.54678526e-03f, 1.70836613e-01f, 2.68946439e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  7.55318254e-02f, 8.49632695e-02f, -3.36346366e-02f, 2.08334863e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  4.39263359e-02f, -1.93126217e-01f, -1.65976912e-01f, 4.63289805e-02f, 2.04100937e-01f, 1.30710259e-01f, 3.49003106e-01f, 1.11537583e-01f, 2.58116782e-01f, 3.97473186e-01f,
  -2.31649317e-02f, 8.29197526e-01f, 2.70080477e-01f, -1.12404078e-01f, 7.48370364e-02f, -2.32298434e-01f, -9.72575009e-01f, -2.68995494e-01f, 4.13876384e-01f, -5.30240595e-01f,
  -2.90598780e-01f, 4.50681090e-01f, 1.83199719e-01f, -1.16857208e-01f, -4.44829643e-01f, -1.82353586e-01f, -4.83817220e-01f, 2.06720918e-01f, -3.49371314e-01f, -2.50921190e-01f,
  6.02047443e-02f, 2.19913810e-01f, 1.89463124e-01f, -1.13845520e-01f, 2.88697988e-01f, 1.61901578e-01f, 1.40408648e-03f, 1.50101125e-01f, 8.37514102e-01f, -5.53536355e-01f,
  1.75003275e-01f, -2.87081838e-01f, 2.69076556e-01f, 3.57269496e-01f, 1.77096017e-03f, -3.44549745e-01f, 9.54636857e-02f, 1.52966306e-01f, -3.83422047e-01f, 3.01696151e-01f,
  3.54062349e-01f, -4.62924004e-01f, 2.13022023e-01f, 1.82564646e-01f, -2.95810938e-01f, 6.64772928e-01f, -2.53580511e-01f, 4.27170068e-01f, -2.38103583e-01f, 5.31799436e-01f,
  8.56326334e-03f, 1.71242028e-01f, -2.98047494e-02f, 2.34600365e-01f, 2.42070436e-01f, 2.69221902e-01f, -2.34645844e-01f, 1.21008292e-01f, 1.32841945e-01f, -3.01430225e-01f,
  -2.26711365e-03f, 4.05883700e-01f, -5.00556707e-01f, -1.65482894e-01f, 1.84961632e-02f, -1.04637891e-01f, 3.84659886e-01f, -1.74096107e-01f, 2.24675030e-01f, -1.80913627e-01f,
  -1.40506802e-02f, -1.34374112e-01f, 1.25871435e-01f, -2.52634853e-01f, -3.35817754e-01f, 1.85315266e-01f, 4.28437620e-01f, -2.70013094e-01f, 3.84505153e-01f, -2.29746193e-01f,
  -2.34991446e-01f, 2.05316037e-01f, -3.10402542e-01f, -2.06099153e-01f, -9.79900882e-02f, -4.56271559e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -6.83216676e-02f, 4.28826183e-01f, 1.26617640e-01f, 1.94888432e-02f, -6.55214041e-02f, 5.23971468e-02f, -2.45811775e-01f, 7.93173462e-02f, -4.02352035e-01f, -1.63741618e-01f,
  -2.35015944e-01f, -2.98370957e-01f, -1.70912936e-01f, 3.07329595e-02f, -1.70666069e-01f, -1.90116148e-02f, 2.54293293e-01f, 1.55513138e-01f, 5.44557422e-02f, 7.59333074e-01f,
  -1.11985598e-02f, -1.27838179e-01f, 3.95042747e-01f, -4.41869497e-01f, -1.01225026e-01f, 5.03383696e-01f, 8.24267507e-01f, 2.69223154e-01f, -1.48599565e-01f, -3.69407058e-01f,
  -2.60859728e-01f, 4.14172485e-02f, -1.32954359e-01f, -2.64761299e-01f, 2.37842109e-02f, 3.41324322e-02f, -2.49747038e-02f, 4.47022803e-02f, -7.34359473e-02f, 2.23504797e-01f,
  -1.34809598e-01f, 9.89816710e-02f, -4.03373629e-01f, 2.33994290e-01f, -1.79287177e-02f, 1.02372691e-01f, -2.13216886e-01f, -5.07320315e-02f, 7.64520988e-02f, 4.26570654e-01f,
  6.47793561e-02f, -2.13030279e-01f, 3.46922487e-01f, 2.02070594e-01f, -4.46310371e-01f, -1.18921295e-01f, -3.36883992e-01f, 3.29027504e-01f, 3.62778872e-01f, 4.30890881e-02f,
  -2.86804348e-01f, -2.75892913e-01f, -5.54325581e-01f, 6.01937830e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  3.99214864e-01f, 4.54636902e-01f, -1.25306174e-01f, 1.45648852e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -5.17065585e-01f, -4.62842733e-01f, -2.82650944e-02f, 1.75348893e-02f, -5.01826108e-01f, 1.17984796e-02f, 2.42900729e-01f, -1.05444777e+00f, -4.24734592e-01f, -1.37533590e-01f,
  2.02096298e-01f, -6.96091592e-01f, -9.90308747e-02f, 7.95849204e-01f, 9.24221352e-02f, 3.44555341e-02f, -4.02490608e-03f, -5.31865299e-01f, -5.22013195e-02f, 3.90883833e-01f,
  -1.35860488e-01f, 2.33417362e-01f, 1.26228586e-01f, -1.16006041e+00f, -1.54414743e-01f, -1.01950610e+00f, -1.73908681e-01f, 1.58991560e-01f, -3.66951227e-01f, 7.14312792e-02f,
  -3.99529278e-01f, -5.53253412e-01f, -4.03191090e-01f, 6.33716881e-02f, -5.12670219e-01f, -5.13935864e-01f, -1.85739875e-01f, -6.47215098e-02f, -8.11918795e-01f, 3.15681815e-01f,
  -4.37241673e-01f, -6.08884692e-01f, -1.89474076e-02f, -4.94044721e-01f, 2.76496798e-01f, 4.96405751e-01f, 1.05680712e-01f, 3.65157872e-01f, -1.13025405e-01f, -1.18079804e-01f,
  1.92864820e-01f, 5.10951757e-01f, -5.00796854e-01f, -3.02970499e-01f, -1.93048924e-01f, -7.05385149e-01f, -3.31609577e-01f, -1.68318063e-01f, 2.82875985e-01f, -4.93133247e-01f,
  -8.58864635e-02f, 5.87725580e-01f, 5.27004562e-02f, 5.55094518e-02f, 1.25928789e-01f, -3.78254920e-01f, 4.74795908e-01f, 4.69845653e-01f, -3.24153900e-02f, 5.67880310e-02f,
  -6.45925879e-01f, -2.36726463e-01f, 2.23258689e-01f, -1.06500232e+00f, 1.71228141e-01f, 3.98000062e-01f, 2.55214542e-01f, -4.06678379e-01f, -5.96595136e-03f, -2.69286007e-01f,
  5.40568642e-02f, 5.03041804e-01f, 1.89239532e-01f, -2.59248763e-01f, 9.12709117e-01f, 5.81615746e-01f, 6.03316367e-01f, -1.49924651e-01f, 2.34756187e-01f, -1.73032746e-01f,
  -2.79347986e-01f, 6.72476709e-01f, -4.38025415e-01f, 1.57617200e-02f, 2.23070115e-01f, -2.58168370e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  6.21575862e-02f, 3.98362666e-01f, -2.74364263e-01f, -3.06954831e-01f, -1.32601663e-01f, -1.02741644e-01f, 3.21671456e-01f, -2.60668039e-01f, 5.99505067e-01f, -7.04259336e-01f,
  -3.14914316e-01f, 2.83991396e-01f, -2.81116396e-01f, 3.63978267e-01f, -1.92331135e-01f, -2.41477966e-01f, 9.07825828e-02f, 6.90302491e-01f, -7.57972375e-02f, 7.86649227e-01f,
  5.44156551e-01f, 6.24039173e-01f, 3.84767771e-01f, -5.29275276e-02f, 6.92478538e-01f, -7.79823005e-01f, -6.69434011e-01f, 9.93504703e-01f, -3.30587834e-01f, 7.91453779e-01f,
  -1.89777389e-01f, 4.74736653e-03f, -3.10189068e-01f, 2.08299428e-01f, -7.19697624e-02f, 2.16998085e-01f, 3.55472058e-01f, 1.07292935e-01f, -2.07393035e-01f, 3.35351944e-01f,
  3.24143469e-01f, 4.00986701e-01f, 2.00549830e-02f, 1.17442057e-01f, 2.96539247e-01f, -2.18157843e-01f, 1.11601241e-02f, 4.41772550e-01f, -4.23698694e-01f, 5.49699426e-01f,
  6.29007816e-01f, 5.21183789e-01f, 3.59684646e-01f, 1.46154255e-01f, 5.36700249e-01f, -7.20619082e-01f, 2.28925139e-01f, 8.57724965e-01f, 2.53607213e-01f, -5.71055710e-01f,
  -1.76681414e-01f, 1.89073160e-01f, -2.49992922e-01f, 7.86272049e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  5.92766665e-02f, 6.15295947e-01f, 1.43429309e-01f, 2.95875341e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  1.87059939e-01f, -1.10208738e+00f, 8.72192204e-01f, 8.73757973e-02f, -2.81404614e-01f, 3.40697616e-01f, -1.03088391e+00f, -1.03204405e+00f, 5.34839272e-01f, -5.20188570e-01f,
  -8.06563795e-01f, 1.09690225e+00f, -2.16554984e-01f, -6.73475325e-01f, 1.76323764e-02f, -4.33368593e-01f, 4.51392829e-01f, -9.21096385e-01f, -1.00011933e+00f, 4.81744528e-01f,
  -7.77351037e-02f, 3.32992047e-01f, -4.87371862e-01f, 1.63231865e-02f, 1.13320100e+00f, 2.41652563e-01f, -4.94444489e-01f, -1.00756347e+00f, 9.39043537e-02f, -3.54492903e-01f,
  5.33745587e-01f, 4.66698825e-01f, 6.45423532e-01f, -2.61933029e-01f, 9.52700734e-01f, 3.94073546e-01f, -7.89219916e-01f, 8.76106024e-01f, 6.06952012e-01f, 1.11509967e+00f,
  2.45861039e-01f, 4.94961202e-01f, 9.41238999e-01f, 6.98251843e-01f, -2.48490781e-01f, 1.16291076e-01f, -2.05527283e-02f, -5.16525030e-01f, 8.14259052e-01f, 4.44619626e-01f,
  -5.30275464e-01f, 1.20188117e-01f, 6.83059171e-02f, -1.07753551e+00f, -3.61834407e-01f, -1.03482473e+00f, -7.15200007e-01f, -2.10132986e-01f, -7.25416124e-01f, 5.99732459e-01f,
  -2.81132251e-01f, 3.08145043e-02f, 1.63838968e-01f, 5.12187779e-01f, 1.27545729e-01f, 1.04713285e+00f, -1.41390756e-01f, 2.66828001e-01f, 2.80497640e-01f, 8.39379489e-01f,
  7.90171325e-01f, 2.30444387e-01f, -1.05668497e+00f, 3.80055517e-01f, -6.05051339e-01f, 8.32666993e-01f, 6.47734404e-02f, -1.01126432e+00f, -2.26256639e-01f, 5.32449186e-01f,
  9.75409001e-02f, -6.53221011e-01f, 7.86770940e-01f, -4.29939218e-02f, -3.98801029e-01f, 9.26941872e-01f, 6.38171136e-01f, -1.22242546e+00f, 4.32440132e-01f, 6.43449247e-01f,
  -4.36148196e-01f, -6.02140665e-01f, 1.14320301e-01f, -7.83628523e-01f, -3.05341542e-01f, 7.44743347e-01f, -3.78822446e-01f, 2.71050930e-01f, -2.25799829e-01f, -1.71225160e-01f,
  -4.18011665e-01f, -8.09234977e-01f, -1.13575435e+00f, 1.02345860e+00f, -3.47117245e-01f, -8.26063514e-01f, 3.47947806e-01f, -3.11798424e-01f, 7.98360407e-01f, 8.18736136e-01f,
  -1.03498716e-02f, -1.13853133e+00f, -1.39463091e+00f, 1.41958848e-01f, -4.31684762e-01f, -3.04347932e-01f, 3.03456843e-01f, 1.79874673e-01f, -6.40788734e-01f, -1.12603819e+00f,
  -4.90627766e-01f, -8.33020985e-01f, 1.05150186e-01f, 4.61056173e-01f, -5.00133574e-01f, 6.12683475e-01f, 5.49432695e-01f, -6.50976062e-01f, -7.96820104e-01f, 7.53582180e-01f,
  -1.06418037e+00f, -7.22754002e-01f, 4.46550936e-01f, -1.17090955e-01f, 1.95384338e-01f, -5.04435360e-01f, 1.06245685e+00f, 3.60062569e-01f, 5.13435841e-01f, -7.16971636e-01f,
  2.24697459e-02f, 8.72509181e-02f, 1.68187231e-01f, 4.35475051e-01f, 7.23185182e-01f, 1.98482692e-01f, -6.13699973e-01f, 2.75319695e-01f, 6.56088367e-02f, -2.27589011e-01f,
  -8.53838682e-01f, 1.16788411e+00f, -7.98986077e-01f, 1.64944187e-01f, 9.44533288e-01f, 1.01958358e+00f, -5.07611632e-01f, 4.30412173e-01f, -1.73475236e-01f, 9.91196260e-02f,
  -4.01308537e-01f, 3.46074998e-01f, 1.07364583e+00f, -8.43535125e-01f, 1.29266217e-01f, -9.34400335e-02f, 6.50703669e-01f, 1.02206135e+00f, -1.40934527e-01f, 7.32393742e-01f,
  8.71922433e-01f, -1.47991037e+00f, 5.28848544e-02f, -9.52645779e-01f, -3.72776747e-01f, -6.67935645e-04f, -3.26382905e-01f, -2.64292449e-01f, 3.82035524e-02f, 2.75767688e-02f,
  -1.00220824e-02f, -2.31912836e-01f, 8.27020049e-01f, 2.29102731e-01f, 1.06025755e-01f, 2.84963906e-01f, -4.84576255e-01f, 3.80956791e-02f, 5.28673947e-01f, 1.05715835e+00f,
  -1.65435150e-01f, -4.58909243e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  5.27326643e-01f, -5.04029393e-02f, 3.38220417e-01f, -4.34884667e-01f, -4.80410531e-02f, -8.99150670e-02f, -3.54078978e-01f, 2.07868353e-01f, 5.52360564e-02f, -2.00165927e-01f,
  4.29041207e-01f, -5.45845628e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    