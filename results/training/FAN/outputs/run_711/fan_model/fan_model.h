/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.90831228e-02f, -2.14921132e-01f, 3.04474026e-01f, -1.06150642e-01f, -3.08958828e-01f, -2.20973521e-01f, -2.34425128e-01f, -2.45879367e-01f, -1.10310525e-01f, -6.53222576e-02f,
  -6.42794510e-03f, 2.35627100e-01f, 2.14481428e-01f, 2.56725967e-01f, 1.41414031e-01f, -7.88757354e-02f, 1.17827747e-02f, 2.54278272e-01f, 2.41656825e-01f, -1.11600637e-01f,
  -1.38928071e-01f, -5.14283888e-02f, 1.58405136e-02f, -2.94670723e-02f, -1.60506979e-01f, 6.22142814e-02f, 6.88504949e-02f, -1.02401473e-01f, 9.31487083e-02f, 1.20390728e-01f,
  1.37145594e-01f, -2.38119200e-01f, 2.07223315e-02f, -4.17997427e-02f, -2.55149733e-02f, -1.02091283e-01f, -3.81151997e-02f, -2.32456196e-02f, -1.50299385e-01f, -6.15095459e-02f,
  -6.72172308e-02f, -1.33482456e-01f, -1.14239097e-01f, -1.23982847e-01f, -1.77391022e-01f, -4.51869927e-02f, -7.05418736e-02f, -3.67896929e-02f, -2.87558287e-02f, -7.94195980e-02f,
  -3.86010483e-02f, -1.07056201e-01f, -1.52434232e-02f, -1.67826414e-01f, -8.78782794e-02f, -2.43202448e-02f, -1.42488882e-01f, -4.48520035e-02f, -6.45218492e-02f, -2.71432772e-02f,
  6.22468963e-02f, 9.57499221e-02f, 4.03090604e-02f, 3.24743763e-02f, 3.92733663e-02f, 1.09651439e-01f, -3.58233787e-02f, 3.06873005e-02f, 1.19891144e-01f, 5.55001013e-02f,
  -2.16647983e-02f, -3.44259217e-02f, -3.67302867e-03f, 7.70368497e-04f, -1.51252858e-02f, 3.78292762e-02f, 7.53776953e-02f, 2.39662938e-02f, 1.10901694e-03f, -4.92009297e-02f,
  -5.45538366e-02f, 5.22099882e-02f, 7.09441528e-02f, -3.54122967e-02f, 3.31792161e-02f, 3.87750268e-02f, 1.13537639e-01f, -5.84397756e-04f, -1.87000744e-02f, -3.06487866e-02f,
  8.03344324e-02f, -1.64330285e-02f, 6.23312779e-02f, 3.62786022e-03f, -8.37674960e-02f, -9.66644809e-02f, -4.36118208e-02f, -1.47303678e-02f, -1.60990715e-01f, -1.38461888e-02f,
  -1.08144663e-01f, 1.73794329e-02f, 3.09595503e-02f, -1.40673649e-02f, -3.94135900e-02f, -5.68279624e-02f, -2.37522013e-02f, 3.70825119e-02f, -6.35784492e-02f, -8.05086717e-02f,
  -1.09189354e-01f, -7.91080017e-03f, 1.48025379e-01f, -5.37802046e-03f, -6.70727715e-02f, -1.02839489e-02f, -3.74307926e-03f, 2.56767198e-02f, 1.18545450e-01f, -5.84097728e-02f,
  -2.83401310e-01f, 1.08796112e-01f, 2.74648279e-01f, -1.64441695e-03f, 2.90509146e-02f, 5.17417714e-02f, 9.78103094e-03f, -3.98069099e-02f, 4.06092452e-03f, 1.25143588e-01f,
  1.12317786e-01f, 4.29934524e-02f, 1.09806880e-01f, 1.07940659e-01f, -8.60156640e-02f, 2.14913800e-01f, 2.17007682e-01f, 1.20513313e-01f, -8.95932764e-02f, -1.15600854e-01f,
  4.14664997e-03f, 5.26092984e-02f, -6.93383515e-02f, 4.74945754e-02f, 2.59118974e-01f, 1.90121502e-01f, 1.36523724e-01f, 1.51454359e-01f, 1.80034056e-01f, 4.62596357e-01f,
  1.94423661e-01f, 7.25578964e-02f, 1.02929972e-01f, 1.40670538e-01f, 1.21361725e-01f, 1.50396466e-01f, 1.22741036e-01f, 1.67670429e-01f, 4.80284952e-02f, 1.30555570e-01f,
  1.67964295e-01f, 1.11525834e-01f, 4.85895462e-02f, 6.12434298e-02f, 7.36527592e-02f, 5.20163327e-02f, 1.88496321e-01f, 1.96029216e-01f, 2.20598921e-01f, 1.45978242e-01f,
  1.05986789e-01f, 1.15345985e-01f, 7.71247149e-02f, 1.67881891e-01f, 4.12262157e-02f, 3.65325250e-02f, 1.96080968e-01f, 1.95792213e-01f, 7.38832206e-02f, 1.90211281e-01f,
  6.18644767e-02f, -7.43530840e-02f, -5.31628951e-02f, -9.00887921e-02f, -5.92134893e-02f, -4.25097942e-02f, 3.26301940e-02f, -5.53743914e-02f, -8.09556469e-02f, -6.61525279e-02f,
  6.01191400e-03f, 9.72851831e-03f, 3.90333906e-02f, -3.72480415e-02f, -9.75911692e-03f, -3.71757243e-03f, -8.54353458e-02f, 3.88182700e-02f, -2.54618842e-02f, -1.80467926e-02f,
  9.45153646e-03f, -9.26901400e-02f, -4.58864309e-02f, -6.78612962e-02f, -7.44420737e-02f, 2.22832523e-02f, -9.11362842e-02f, -1.03329971e-01f, 3.93626094e-02f, -8.76608044e-02f,
  -1.77723933e-02f, -2.39648800e-02f, 2.09496409e-01f, 1.15728132e-01f, 3.69385034e-02f, 7.76738673e-02f, 1.56908363e-01f, 4.91473870e-03f, 8.63897279e-02f, 7.10265189e-02f,
  1.94945317e-02f, 1.17559269e-01f, 1.34604186e-01f, 9.43156332e-02f, 1.18539944e-01f, -3.25715914e-02f, 8.12385753e-02f, 1.44123361e-01f, 5.28681055e-02f, 1.21367956e-02f,
  1.15198240e-01f, -5.60922511e-02f, -4.64533595e-03f, 7.33787864e-02f, 2.92685498e-02f, -2.22813953e-02f, 1.26082987e-01f, 6.29805177e-02f, 2.32332665e-02f, -3.24678756e-02f,
  -6.05664961e-02f, 1.79647073e-01f, 2.60685198e-02f, -1.07767329e-01f, 1.11477412e-01f, 2.27292459e-02f, 3.51362854e-01f, 1.96209997e-02f, 2.88111344e-02f, 2.30300352e-01f,
  4.99264486e-02f, -2.38576606e-01f, -6.32953867e-02f, -2.52276976e-02f, 6.47559911e-02f, 2.48103395e-01f, 2.26608038e-01f, 6.57734126e-02f, -8.86530280e-02f, -7.09145218e-02f,
  4.83010244e-03f, 2.68950891e-02f, 1.56484991e-02f, -1.96854528e-02f, 8.71001035e-02f, -6.71842843e-02f, 1.49277747e-01f, 1.36389956e-01f, 1.40628710e-01f, 2.22486049e-01f,
  -1.51537299e-01f, 5.87640740e-02f, -6.45031482e-02f, -8.67818743e-02f, 3.77867632e-02f, -1.13381088e-01f, -6.20530732e-02f, 2.51695234e-02f, -2.70767137e-02f, -2.20331196e-02f,
  -5.31726591e-02f, -4.89439890e-02f, 4.69102710e-03f, -6.50767609e-02f, -5.83890490e-02f, 7.69721046e-02f, 1.39578313e-01f, 3.61251123e-02f, 2.45535970e-02f, 2.21413299e-02f,
  -2.77660042e-02f, -6.14029616e-02f, 3.14554162e-02f, 1.24704046e-03f, 5.19147180e-02f, 8.45893472e-02f, 1.20680377e-01f, -2.67560314e-02f, 1.08045824e-01f, 4.12296578e-02f,
  -6.01210631e-02f, -4.51657027e-02f, 2.21526045e-02f, -5.94738359e-03f, -2.56925467e-02f, 3.11989384e-03f, -5.25068305e-02f, 1.15928523e-01f, -5.58925457e-02f, 2.61954423e-02f,
  1.34997321e-02f, -5.00196107e-02f, -1.10096201e-01f, -4.47484702e-02f, 1.79602616e-02f, 6.57064170e-02f, -6.54590279e-02f, -7.75970519e-02f, -2.11898983e-02f, -5.68689145e-02f,
  -3.58743477e-03f, 2.57262103e-02f, 3.57043669e-02f, -6.69908747e-02f, 6.32071495e-02f, -7.66535997e-02f, 3.10977213e-02f, -5.19230515e-02f, 6.38202503e-02f, 1.36953108e-02f,
  6.17955551e-02f, 5.21753617e-02f, -3.78937349e-02f, 2.78923493e-02f, 9.92111862e-02f, -3.52614187e-02f, 1.81892503e-03f, -4.50798050e-02f, 5.16679808e-02f, -6.15428500e-02f,
  -8.97689834e-02f, -7.22639561e-02f, -7.30310706e-03f, 6.27563521e-02f, 1.72517225e-02f, -6.10243902e-02f, -2.46329047e-02f, 3.05030569e-02f, 2.67472956e-03f, -3.66869457e-02f,
  1.05334237e-01f, 8.47985968e-02f, 6.43280074e-02f, 8.07947963e-02f, 2.93932371e-02f, -3.69536206e-02f, 1.36783540e-01f, 7.27685168e-02f, 5.63326515e-02f, 2.45434046e-01f,
  4.59405547e-03f, -1.95740938e-01f, -1.03023849e-01f, -1.78915277e-01f, -1.38580605e-01f, -9.52616427e-03f, -1.09696053e-01f, -1.10194467e-01f, -8.89482629e-03f, -1.64954066e-02f,
  8.34585130e-02f, 3.66219759e-01f, 1.99978501e-01f, 1.72514930e-01f, 1.77626237e-02f, -9.04443637e-02f, -3.32349181e-01f, -8.02355409e-02f, 1.22412227e-01f, 4.56249937e-02f,
  2.48977952e-02f, -1.79695189e-01f, -1.17930844e-01f, -7.23879933e-02f, -2.29677737e-01f, -4.09951806e-02f, -2.48219758e-01f, -1.62382483e-01f, -1.76878467e-01f, -3.64626378e-01f,
  8.71778056e-02f, 2.87441444e-02f, 7.34574199e-02f, -2.54718121e-02f, -9.97860134e-02f, 3.71911898e-02f, -8.03029388e-02f, -1.43240830e-02f, 1.05550094e-03f, 2.60512568e-02f,
  -3.07808965e-02f, 1.32795900e-01f, 6.51606619e-02f, -7.58305639e-02f, -5.54651991e-02f, 2.89608669e-02f, -5.65995164e-02f, -2.58773211e-02f, 3.58691774e-02f, -9.56839547e-02f,
  -2.13949867e-02f, -1.44676447e-01f, -7.86594581e-03f, -3.87092568e-02f, -5.00097163e-02f, -7.23109692e-02f, -1.58088937e-01f, -1.10227302e-01f, -1.58043489e-01f, -2.52273023e-01f,
  -9.55319628e-02f, 3.37856263e-02f, -2.90603153e-02f, -9.79136974e-02f, -6.14390559e-02f, 8.31300952e-03f, 6.94617769e-03f, 2.95558828e-03f, 2.15708148e-02f, -3.24353613e-02f,
  7.67791718e-02f, 6.10428602e-02f, -1.30499499e-02f, -7.74008185e-02f, -4.47460860e-02f, -5.82148470e-02f, -9.41129029e-02f, -6.22770749e-02f, 8.60353634e-02f, 4.96001765e-02f,
  1.17812874e-02f, -3.85330841e-02f, -6.78855330e-02f, 1.12233780e-01f, -5.01782373e-02f, -9.22479406e-02f, 3.47623415e-02f, 1.07332021e-01f, 9.62681249e-02f, 6.39940351e-02f,
  -4.33648638e-02f, 1.54319495e-01f, 4.62185591e-02f, -3.60960439e-02f, -7.12736920e-02f, -3.24354991e-02f, 6.96138619e-03f, -8.00956041e-02f, 4.80798781e-02f, 4.05844972e-02f,
  1.63332727e-02f, 3.70742418e-02f, 8.60186070e-02f, 3.53245214e-02f, 7.37079605e-02f, 1.00561708e-01f, -2.94894241e-02f, -1.07443944e-01f, -8.98024589e-02f, -1.45970374e-01f,
  -1.25508606e-01f, -9.44589823e-02f, 2.46753683e-03f, -1.49465516e-01f, -8.78795162e-02f, -5.97881675e-02f, 3.83066386e-02f, 8.04465171e-03f, -3.57624888e-03f, -1.38894945e-01f,
  -1.79398879e-01f, 9.58284214e-02f, -8.03484470e-02f, -9.70038325e-02f, 1.38823688e-01f, -2.89014243e-02f, -6.21060096e-02f, -2.28493027e-02f, 1.61923133e-02f, -4.39137686e-03f,
  1.51569501e-01f, -1.88544695e-03f, -6.40108213e-02f, -2.50683278e-02f, -2.24479228e-01f, -1.90996498e-01f, -2.48086616e-01f, -2.58129597e-01f, -5.10796197e-02f, 5.13107963e-02f,
  8.29401687e-02f, -2.58391853e-02f, 5.19751869e-02f, 8.02353173e-02f, 9.32733864e-02f, 1.47026986e-01f, -2.25516856e-02f, 1.83818951e-01f, 9.40457061e-02f, -5.87183945e-02f,
  9.87685099e-03f, 2.06691265e-01f, -1.00517180e-02f, 4.18634191e-02f, 1.47506937e-01f, 1.12279095e-01f, 4.70774993e-02f, 1.40615227e-02f, 1.29605308e-01f, 3.88863981e-02f,
  3.92277427e-02f, 1.87500529e-02f, 2.14380268e-02f, 9.64414030e-02f, 1.98196508e-02f, 8.82718191e-02f, 9.54593346e-02f, 9.11382735e-02f, -4.95393798e-02f, 1.81187272e-01f,
  5.62932789e-02f, 1.07481755e-01f, 1.19023420e-01f, 1.69081956e-01f, 4.59230281e-02f, 1.00641169e-01f, 1.17164932e-01f, 1.35797441e-01f, 5.41734733e-02f, 1.90752491e-01f,
  -1.87337235e-01f, -2.92801950e-02f, -1.11211404e-01f, -1.47229955e-01f, -7.21734241e-02f, -1.35788843e-01f, -7.02198967e-02f, -1.19684026e-01f, -4.15137559e-02f, -1.45696923e-01f,
  2.77972575e-02f, -1.92101181e-01f, -5.06720506e-02f, -8.36693794e-02f, -1.68337584e-01f, -5.25611825e-02f, -1.04408428e-01f, -6.15560636e-02f, -1.20729983e-01f, -3.14374492e-02f,
  -2.38792058e-02f, -4.78831269e-02f, -8.25895816e-02f, -4.96629952e-03f, -9.29591507e-02f, -8.68976191e-02f, -5.62426485e-02f, 2.18997076e-02f, -8.02887753e-02f, -4.12131958e-02f,
  5.33733666e-02f, -3.92446630e-02f, 6.32888377e-02f, 3.20251398e-02f, 1.24400355e-01f, 9.03810635e-02f, 1.51421413e-01f, 1.56234458e-01f, 8.03925470e-02f, 1.66902959e-01f,
  2.39013270e-01f, 7.66879320e-02f, 1.29861757e-01f, 1.73486561e-01f, 1.40122250e-01f, 7.96998516e-02f, 9.07990336e-02f, 2.88387854e-02f, 5.15199527e-02f, 1.90927073e-01f,
  6.99515939e-02f, 4.27502207e-02f, -2.26460933e-03f, 2.58465167e-02f, 1.93046063e-01f, 9.39621590e-03f, 1.31121606e-01f, 1.13207325e-01f, -3.22126336e-02f, -2.01943610e-02f,
  6.31329194e-02f, 5.54068200e-02f, -1.80539951e-01f, 1.80778310e-01f, 1.84603631e-02f, -4.45890427e-02f, -2.52212375e-01f, -6.72607124e-02f, 4.43742722e-02f, 1.09222205e-02f,
  2.04585735e-02f, 3.45701277e-02f, 4.59928578e-03f, 2.95643508e-03f, -1.01717778e-01f, -6.24132082e-02f, -1.51800867e-02f, 6.19973941e-03f, -1.23487748e-01f, -9.78849549e-03f,
  6.50445744e-02f, 5.96429072e-02f, 5.84340319e-02f, -1.53565435e-02f, 1.57159746e-01f, 3.49509045e-02f, -2.37464905e-02f, 1.56074148e-02f, 4.81374636e-02f, 1.57912582e-01f,
  -2.45076269e-01f, 5.99724986e-02f, -1.23931848e-01f, -5.49691655e-02f, -4.19633172e-04f, -1.70845389e-01f, -1.19515911e-01f, -2.05492508e-03f, -3.48289907e-02f, -1.31386727e-01f,
  1.14795193e-02f, -4.32250425e-02f, -1.23998724e-01f, -4.89351526e-02f, -3.30792181e-02f, 3.25113647e-02f, 1.42078316e-02f, -1.36109185e-03f, 3.50338616e-03f, -1.44910827e-01f,
  7.59393647e-02f, 3.28520611e-02f, -1.34535749e-02f, -8.76774713e-02f, -9.22469571e-02f, 3.32749076e-02f, -1.12160392e-01f, 3.88398464e-03f, 5.82493190e-03f, -1.08222649e-01f,
  8.43845680e-03f, -4.33270782e-02f, -4.06314945e-03f, 8.66357833e-02f, -3.70300263e-02f, 4.40697074e-02f, 3.98803939e-04f, 9.10559148e-02f, -3.98450010e-02f, 2.70172977e-03f,
  -1.07736234e-02f, 3.99656482e-02f, -5.27440831e-02f, 4.71764943e-03f, 2.60331221e-02f, -4.24230397e-02f, 9.49652400e-03f, 5.91340922e-02f, -7.22370222e-02f, 7.20419288e-02f,
  1.14033772e-02f, -3.83954085e-02f, 8.77217725e-02f, 3.75361964e-02f, 7.01885819e-02f, -2.30689645e-02f, -2.54131965e-02f, 7.94783607e-02f, 1.30781876e-02f, 1.38967648e-01f,
  -2.68847406e-01f, -9.51104164e-02f, -4.69734967e-02f, -5.21201231e-02f, -5.00830188e-02f, 4.74423431e-02f, -4.33313586e-02f, -1.29797747e-02f, -4.33708029e-03f, -6.99711293e-02f,
  -1.12914350e-02f, -7.83916637e-02f, 1.39922583e-02f, -1.71155315e-02f, -5.23274094e-02f, -2.10624002e-02f, 1.12937614e-02f, -7.35159963e-02f, -5.56314141e-02f, -1.38245061e-01f,
  -1.55368358e-01f, -2.20515728e-01f, -1.31697088e-01f, -1.82861373e-01f, -3.95138860e-02f, -1.20237708e-01f, -1.38730898e-01f, -1.64433897e-01f, -2.19271660e-01f, -2.59872079e-01f,
  1.62755966e-01f, 2.42367670e-01f, -9.03824531e-03f, 1.66049659e-01f, -7.98717663e-02f, -2.97634572e-01f, -2.44520009e-01f, -1.59029663e-01f, 2.38820296e-02f, 1.04512043e-01f,
  -1.38686106e-01f, -8.51114318e-02f, -6.17634654e-02f, -1.41175151e-01f, -3.24720472e-01f, 7.45238690e-03f, -8.66464619e-03f, -1.69747159e-01f, -3.28738421e-01f, -2.96192884e-01f,
  -1.45409837e-01f, 1.36635423e-01f, 9.62141454e-02f, -1.24280922e-01f, 1.46077126e-01f, 8.57309066e-03f, 2.67546386e-01f, 2.31149212e-01f, 6.58286139e-02f, 2.61851341e-01f,
  1.63738001e-02f, 7.33758584e-02f, -2.45362952e-01f, -4.81029004e-02f, 9.08144787e-02f, -8.96092430e-02f, -1.27217472e-01f, -1.36486283e-02f, -1.01440802e-01f, -1.74119286e-02f,
  -7.90198147e-02f, -1.64693877e-01f, -7.05465600e-02f, -1.77470520e-02f, -5.04440106e-02f, -1.63761582e-02f, -6.38414845e-02f, -5.93750924e-02f, -1.82978272e-01f, -4.17541452e-02f,
  -1.54219214e-02f, 5.24324737e-02f, -5.11768311e-02f, -1.55668795e-01f, -1.83236584e-01f, -1.06475599e-01f, -8.31067339e-02f, -4.09009457e-02f, -3.12436800e-02f, 1.55233800e-01f,
  -1.69375748e-03f, 8.10563788e-02f, 1.42008476e-02f, 4.95208502e-02f, 3.64501216e-02f, 1.07513461e-02f, 2.61770189e-02f, 1.22881949e-01f, -3.46156284e-02f, -1.15595330e-02f,
  -4.18780670e-02f, 1.04157142e-02f, 7.07789660e-02f, 1.28736785e-02f, 1.37745425e-01f, -2.57492182e-04f, 3.50979418e-02f, -8.46697297e-03f, 5.24072051e-02f, 1.38272820e-02f,
  -2.26039216e-02f, 1.56232296e-03f, 9.53727290e-02f, -1.30494274e-02f, 1.63834691e-02f, 1.07670575e-01f, 9.38378051e-02f, 1.47509025e-02f, 8.65033716e-02f, -1.99348368e-02f,
  3.82848009e-02f, -2.58273184e-01f, 4.97210771e-02f, -7.79472217e-02f, 7.43574928e-03f, -8.41175467e-02f, 1.66311562e-02f, 1.40559981e-02f, -6.01292774e-02f, -1.91049576e-02f,
  -7.31795579e-02f, -3.57483216e-02f, -6.47503212e-02f, -3.60585656e-03f, -1.42792314e-01f, -3.23228091e-02f, -3.92335802e-02f, 3.96306142e-02f, -1.04308210e-01f, 4.44570892e-02f,
  -1.47567149e-02f, -5.58610521e-02f, -4.41513136e-02f, -7.44089708e-02f, -5.83976433e-02f, -7.67022520e-02f, -8.89423639e-02f, -1.79483313e-02f, -1.87732995e-01f, 1.04111833e-02f,
  4.10571843e-01f, -1.24223031e-01f, -2.86752284e-01f, 1.86930910e-01f, -1.98559001e-01f, -2.94323057e-01f, -4.79132861e-01f, 1.86694204e-03f, 1.55041382e-01f, -2.42350966e-01f,
  -5.36825545e-02f, 2.25833267e-01f, -8.56306520e-04f, 6.70880750e-02f, -1.12258695e-01f, -3.71166736e-01f, -1.94613099e-01f, -7.89228231e-02f, -6.32174537e-02f, -1.04227819e-01f,
  -5.38768917e-02f, 4.63877581e-02f, 2.99254507e-01f, 2.00228915e-01f, 6.97768480e-02f, 5.51990420e-03f, -1.64046019e-01f, -8.52132682e-03f, -6.30078316e-02f, -3.78021337e-02f,
  -2.64997870e-01f, 7.92064369e-02f, -3.63722742e-02f, 7.29710236e-02f, -4.77878638e-02f, 5.10681272e-02f, -2.86422614e-02f, 7.64764547e-02f, 3.05374581e-02f, 4.57646325e-02f,
  2.71145497e-02f, 1.14394508e-01f, 9.29016769e-02f, -2.94721080e-03f, 9.84966010e-03f, 9.62288156e-02f, 1.07011206e-01f, 6.18811660e-02f, -4.45993580e-02f, 1.60019137e-02f,
  3.95154729e-02f, -8.79786983e-02f, -3.46062072e-02f, -4.80224527e-02f, -7.37700537e-02f, -1.97400805e-02f, -1.12320393e-01f, 1.75878108e-02f, 5.94968982e-02f, -3.85452062e-02f,
  -4.14265357e-02f, -1.47552565e-02f, -6.06292263e-02f, 4.07338068e-02f, 6.42524734e-02f, 3.63756716e-03f, -3.66764925e-02f, -1.09578989e-01f, 3.59530635e-02f, -2.75107399e-02f,
  -3.19927447e-02f, -4.04683948e-02f, -9.98442527e-03f, 6.89960197e-02f, -5.88371232e-02f, -1.00270491e-02f, -7.57036731e-02f, -1.18640392e-05f, -2.99073048e-02f, -2.82169096e-02f,
  -6.03242917e-03f, 2.88138799e-02f, 2.43006181e-02f, 3.43527719e-02f, 2.49278769e-02f, 5.05142175e-02f, -6.05269745e-02f, 2.16555782e-02f, 1.34203001e-03f, 4.17925008e-02f,
  2.03383282e-01f, -2.86351107e-02f, -1.90597563e-03f, 1.62190292e-02f, -4.90900241e-02f, -5.73144481e-03f, -2.92377155e-02f, -1.18207457e-02f, 4.54657851e-03f, 1.52343241e-02f,
  -6.26944527e-02f, 5.39125539e-02f, -4.28607687e-02f, -5.54493107e-02f, -3.33494097e-02f, -1.94023512e-02f, 3.14514153e-02f, -6.17989786e-02f, -1.33017441e-02f, -3.38836201e-02f,
  -8.50494355e-02f, -2.55779717e-02f, -4.85507101e-02f, -1.21810690e-01f, 4.45682788e-03f, 2.55650701e-03f, -1.52338356e-01f, -1.24825630e-02f, -3.12206931e-02f, -1.07565578e-02f,
  2.01980308e-01f, -2.18569450e-02f, 2.17194155e-01f, 8.23822245e-02f, -2.49068420e-02f, 6.15339316e-02f, 1.43313065e-01f, 1.96074359e-02f, -1.00018106e-01f, 1.85288582e-02f,
  -2.30747163e-01f, -2.94538558e-01f, -3.24412942e-01f, -2.60074884e-01f, -9.91180912e-02f, 2.42700994e-01f, 2.59911746e-01f, 1.54318333e-01f, -9.63801444e-02f, -1.32946789e-01f,
  -4.19332199e-02f, 1.60436764e-01f, 4.00712639e-02f, -5.43491989e-02f, 2.77536679e-02f, -2.07749799e-01f, 9.46743786e-02f, 8.59650299e-02f, -5.66587597e-03f, 4.64437157e-02f,
  1.12133861e-01f, 1.81190623e-03f, -5.40268905e-02f, -4.54573147e-02f, 1.96934659e-02f, -2.81988885e-02f, -7.25826472e-02f, 5.68856671e-02f, -1.11690879e-01f, 3.68866548e-02f,
  -3.69898528e-02f, -6.55949414e-02f, 5.65095851e-03f, -8.55308026e-02f, 3.15136686e-02f, -5.98146021e-02f, -4.36878651e-02f, -4.80643287e-02f, 9.64071304e-02f, -5.39386347e-02f,
  -8.20145980e-02f, -1.76800638e-02f, 4.23546061e-02f, 4.55027260e-02f, 4.37169708e-02f, -1.71853766e-01f, 3.60067300e-02f, 6.20256225e-03f, -1.05531598e-02f, -4.55294689e-03f,
  3.20551917e-02f, -1.67796519e-02f, 5.61747747e-03f, 1.64220706e-02f, -2.61793635e-03f, 1.12319320e-01f, 1.86431054e-02f, 1.24064848e-01f, -4.27407548e-02f, 5.15026227e-02f,
  -4.09722589e-02f, 1.32327929e-01f, 9.23390612e-02f, -3.40340659e-03f, -2.43095309e-02f, 6.10714331e-02f, 2.45567906e-04f, -2.11157035e-02f, 4.26473236e-03f, 9.35314521e-02f,
  2.44189538e-02f, 3.05650327e-02f, 1.17883764e-01f, -1.91044472e-02f, 7.16212615e-02f, 9.67823640e-02f, -2.16217618e-02f, 6.04298338e-02f, -4.95110452e-02f, 8.11468158e-03f,
  -7.04378933e-02f, -5.14198877e-02f, -2.56104823e-02f, -7.27002174e-02f, -1.33688552e-02f, 3.04271355e-02f, -3.87958288e-02f, 5.09185791e-02f, -5.99153712e-02f, -1.91805437e-02f,
  -8.31761062e-02f, 3.29250693e-02f, -5.35212792e-02f, 1.40900500e-02f, -3.84044684e-02f, -4.85955477e-02f, 1.25997886e-02f, 6.01681098e-02f, 2.58791801e-02f, 3.79775651e-02f,
  -8.37954357e-02f, -2.48928815e-02f, -7.56442547e-02f, -1.52194612e-02f, -8.08008909e-02f, -3.08035873e-02f, 1.69597995e-02f, -5.14370576e-02f, 4.20633070e-02f, 1.41778439e-01f,
  -2.34058257e-02f, 3.88819963e-01f, 1.34753123e-01f, -1.17038647e-02f, 1.40558705e-01f, -5.51705398e-02f, 1.52454078e-02f, 4.51815911e-02f, -6.20064093e-03f, 6.90171868e-02f,
  1.46931782e-01f, 2.85520498e-02f, -1.07636370e-01f, 3.20818536e-02f, -7.27702007e-02f, 7.00448826e-02f, 1.22343339e-01f, 6.33073924e-03f, -1.85037300e-01f, 3.96615081e-03f,
  7.45552704e-02f, 1.60058379e-01f, 2.21494678e-02f, 2.07892549e-03f, 6.65894002e-02f, 6.25861436e-02f, 7.93662816e-02f, 1.97206423e-01f, 1.16126530e-01f, 2.88044482e-01f,
  5.22470623e-02f, 1.88810304e-01f, 6.62871376e-02f, 2.15549022e-01f, 1.52245626e-01f, 1.29626840e-01f, 6.59251735e-02f, 2.06887156e-01f, 1.20122261e-01f, 1.77689418e-01f,
  1.22418046e-01f, 1.38052046e-01f, 1.00626975e-01f, 1.20556377e-01f, 1.65447637e-01f, 8.82328227e-02f, 2.22884834e-01f, 1.58296317e-01f, 2.00181723e-01f, 1.37879908e-01f,
  9.32803750e-02f, 1.92124844e-01f, 1.18174724e-01f, 1.39234796e-01f, 1.33910164e-01f, 1.16228037e-01f, 1.44414335e-01f, 5.59115130e-03f, 4.17700447e-02f, 5.46911545e-02f,
  -2.44343933e-02f, -6.89818636e-02f, -1.58427477e-01f, -7.59261698e-02f, -2.04006061e-02f, -8.49238709e-02f, -1.18149079e-01f, 2.07682382e-02f, -1.42620400e-01f, 2.46801563e-02f,
  -2.77916975e-02f, -9.67642814e-02f, -3.60768922e-02f, -2.34240331e-02f, -6.79063275e-02f, 2.14573164e-02f, -7.88264498e-02f, -8.06017127e-03f, 1.51743330e-02f, -4.19169851e-02f,
  1.36318710e-02f, 1.33363307e-02f, -3.32379639e-02f, -8.47359598e-02f, -1.52258752e-02f, 2.29649283e-02f, -4.48041409e-02f, 6.93227649e-02f, -6.01757467e-02f, -8.78423229e-02f,
  -1.36010677e-01f, -5.73134013e-02f, 5.46414778e-02f, 4.28384840e-02f, 8.48927870e-02f, 1.22094221e-01f, 1.46969305e-02f, 9.26433280e-02f, 1.14465632e-01f, 6.85150176e-02f,
  5.80288731e-02f, 8.77524540e-02f, 7.92462677e-02f, 4.29942533e-02f, 1.89656708e-02f, 1.35882869e-01f, 8.31205249e-02f, -1.48523143e-02f, 1.48508407e-03f, 1.18825018e-01f,
  1.58079430e-01f, -2.65834238e-02f, -2.31171232e-02f, -2.28226930e-02f, 1.09659918e-02f, -4.39292192e-02f, -2.76175737e-02f, 8.77642408e-02f, -5.23320474e-02f, 9.29368138e-02f,
  -1.98452502e-01f, -2.55598687e-02f, -1.40416160e-01f, -2.12619901e-01f, -2.10052103e-01f, -2.22226586e-02f, 3.95900272e-02f, 5.55134937e-02f, 1.20504024e-02f, -2.09165871e-01f,
  -1.10956460e-01f, 8.02783221e-02f, -8.76852050e-02f, 1.83166210e-02f, 1.15067758e-01f, -1.12991720e-01f, -9.99044031e-02f, -8.93537775e-02f, 1.30677596e-01f, 9.70437080e-02f,
  -1.08639129e-01f, -1.19092345e-01f, -5.99021427e-02f, 1.28564790e-01f, -2.20219746e-01f, 3.14490534e-02f, -1.49688885e-01f, -1.52394921e-01f, -1.11485071e-01f, -2.17280567e-01f,
  -1.35824114e-01f, -1.59099177e-01f, -7.44812470e-03f, -1.08636199e-02f, -3.53191346e-02f, 1.07130101e-02f, 2.91670021e-03f, 8.29940010e-03f, -3.58325057e-02f, -7.20199943e-02f,
  -1.24006398e-01f, -7.80780986e-02f, 6.84694126e-02f, -3.37936208e-02f, 1.28379995e-02f, 9.62483510e-03f, 5.41263912e-03f, 1.38431396e-02f, -1.03412447e-02f, 4.12192270e-02f,
  -3.49633954e-02f, -5.67270559e-04f, -1.02425970e-01f, -4.34300117e-02f, 9.18718055e-02f, -3.30321305e-02f, 7.26812519e-03f, 8.04196000e-02f, 5.21669574e-02f, 8.84334147e-02f,
  1.34837613e-01f, 1.12153344e-01f, 3.90144922e-02f, 1.05518006e-01f, -5.00570871e-02f, -5.90583086e-02f, -4.03293669e-02f, 4.99576256e-02f, 1.47350542e-02f, -9.05757397e-02f,
  -5.75558692e-02f, -9.53796972e-03f, -5.74881677e-04f, -4.33293879e-02f, -2.92090364e-02f, -1.05307765e-01f, -3.95684354e-02f, 3.95637788e-02f, 2.43911352e-02f, 2.61796266e-02f,
  -1.50050111e-02f, -1.24700554e-01f, -4.94120196e-02f, 3.23674418e-02f, -1.23277694e-01f, 4.11283374e-02f, 3.40193920e-02f, -2.18382515e-02f, -1.90627165e-02f, -1.18601485e-03f,
  5.16368151e-02f, -3.74627858e-02f, -1.31392151e-01f, 4.18279953e-02f, -8.92795995e-02f, 6.17924593e-02f, 2.68156137e-02f, 2.43942793e-02f, -4.95681651e-02f, -1.05071202e-01f,
  -6.86486363e-02f, -6.78668842e-02f, -7.50479549e-02f, -4.97327074e-02f, -7.42452741e-02f, -5.34222797e-02f, -1.44598454e-01f, 2.27931626e-02f, -8.61858428e-02f, 2.02622898e-02f,
  -1.22490514e-03f, 9.76029336e-02f, 5.23164943e-02f, 5.53308008e-03f, -4.79256995e-02f, 2.14280412e-02f, -1.06593827e-02f, -3.33192907e-02f, 7.97643363e-02f, 1.41055182e-01f,
  -1.57738447e-01f, -1.42062798e-01f, -7.39983283e-03f, -7.74164274e-02f, -1.26204893e-01f, -3.98106351e-02f, -2.38814689e-02f, -5.32405339e-02f, 3.74389291e-02f, -2.14547664e-01f,
  -6.97339177e-02f, -9.34237707e-03f, -1.90275088e-02f, 1.69217195e-02f, 1.52612880e-01f, -1.01665325e-01f, -1.29907221e-01f, -1.58871375e-02f, 1.95397466e-01f, 9.56222937e-02f,
  -4.19885144e-02f, -4.76108724e-03f, 5.48527054e-02f, 1.22308001e-01f, -1.22286364e-01f, 4.59897704e-03f, -6.49336874e-02f, -1.29018977e-01f, 5.84548786e-02f, -1.36102289e-01f,
  9.39214602e-03f, -3.06465849e-02f, 1.15352653e-01f, 5.78333437e-03f, 3.03504299e-02f, 5.59212677e-02f, 6.87934384e-02f, -1.31237321e-02f, 1.14011250e-01f, 3.55672576e-02f,
  -7.89709575e-03f, 7.12385923e-02f, -4.12807837e-02f, 7.11632892e-02f, 8.71357620e-02f, 6.75127059e-02f, -3.29120345e-02f, -5.27907051e-02f, 5.50504103e-02f, -4.07284200e-02f,
  7.61887208e-02f, -9.15742069e-02f, -1.02106370e-01f, 4.72757071e-02f, -3.82169662e-03f, 1.92364771e-02f, -9.59200226e-03f, -5.84710091e-02f, 1.68623775e-02f, 2.56345645e-02f,
  -2.00582333e-02f, 1.16193987e-01f, 6.50907010e-02f, -3.27265635e-02f, 1.11260943e-01f, 4.49752249e-02f, 4.82737012e-02f, 3.76143605e-02f, 5.49385510e-02f, 1.96642503e-01f,
  7.71088451e-02f, 3.15572917e-02f, 7.44095370e-02f, -1.44931478e-02f, -1.62121025e-03f, -2.86449827e-02f, 1.30114421e-01f, 7.94973001e-02f, 9.65735242e-02f, 9.86108333e-02f,
  -4.47534211e-02f, 4.01731804e-02f, 1.43539429e-01f, 3.23885754e-02f, 7.99560696e-02f, 2.84340009e-02f, 2.65761907e-03f, 4.14218791e-02f, 1.29827499e-01f, -2.27876864e-02f,
  1.13874838e-01f, 3.85380387e-02f, 7.58783221e-02f, 5.56643941e-02f, 8.17824304e-02f, -2.36914810e-02f, -1.79129541e-02f, -8.13234877e-03f, -6.00862689e-02f, -2.90400181e-02f,
  -3.97755876e-02f, 2.71906815e-02f, -3.51513014e-03f, 7.12677091e-02f, -3.28499638e-02f, 1.12971561e-02f, -3.42787579e-02f, -8.07783753e-02f, 4.81468290e-02f, -6.07354306e-02f,
  4.07893583e-02f, -3.04148626e-02f, -4.79395315e-02f, -3.22253630e-02f, -3.25794183e-02f, 3.53798317e-03f, 5.85881956e-02f, 4.96596284e-02f, 8.71027708e-02f, 8.95435438e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.79971123e-01f, 4.10549223e-01f, -3.31505165e-02f, 1.25428736e-01f, 2.03980580e-01f, -2.27291211e-02f, 1.51624838e-02f, -2.02041656e-01f, -2.23474223e-02f, 3.90492454e-02f,
  2.85238951e-01f, 5.34752123e-02f, -4.01697792e-02f, -1.42786548e-01f, -1.70257881e-01f, -1.33774370e-01f, -7.60011449e-02f, -1.11553945e-01f, -2.59060472e-01f, -8.07559565e-02f,
  1.28043622e-01f, 7.92893320e-02f, -1.36971861e-01f, -8.75062421e-02f, 2.69592464e-01f, 1.07748881e-02f, 2.67095380e-02f, 2.16098517e-01f, 1.13358967e-01f, 1.96975455e-01f,
  -9.38221347e-03f, 1.55866638e-01f, -3.62728775e-01f, 1.72378048e-01f, 4.41837348e-02f, -1.91421077e-01f, -1.21870391e-01f, -1.55045629e-01f, 7.66718462e-02f, -9.32824910e-02f,
  2.57196963e-01f, 1.65041953e-01f, 7.87630901e-02f, 1.47684123e-02f, -1.01813987e-01f, -1.07177280e-01f, -1.14016302e-01f, -1.96164131e-01f, -2.85766900e-01f, -2.88688801e-02f,
  1.60820797e-01f, 2.61416703e-01f, 4.09471989e-02f, -1.04791686e-01f, -1.14263386e-01f, 1.27324313e-01f, 1.57134488e-01f, 7.16054142e-02f, -1.36732116e-01f, 1.31715089e-01f,
  -2.89917365e-02f, -1.08438492e-01f, 5.26384711e-02f, 5.94026111e-02f, 4.63867746e-02f, 1.31224230e-01f, 1.24332905e-02f, -2.92965155e-02f, -3.26985791e-02f, -2.09945790e-03f,
  -7.91063979e-02f, -3.02046221e-02f, -1.65621102e-01f, -1.54630572e-01f, -1.32604256e-01f, 1.16904534e-01f, -1.44818015e-02f, -3.42612453e-02f, -4.18984070e-02f, -2.27474105e-02f,
  4.09978814e-02f, -4.10973653e-03f, -4.99657430e-02f, -8.20727274e-02f, -1.11521110e-02f, 2.85152793e-02f, -5.65726049e-02f, 4.85311821e-03f, -6.30677044e-02f, 2.11411752e-02f,
  -6.39104843e-02f, -1.86618596e-01f, -9.63660330e-02f, -1.32949367e-01f, 7.05704316e-02f, -7.19197318e-02f, 2.63485759e-02f, -7.11373836e-02f, 1.17905261e-02f, -1.07135482e-01f,
  1.12767547e-01f, -9.94275361e-02f, 7.34726861e-02f, -1.26343474e-01f, -7.33663216e-02f, 2.47296169e-02f, -6.16239384e-02f, 4.16644402e-02f, -1.47080913e-01f, 4.61942293e-02f,
  -4.48697107e-03f, -1.60230875e-01f, -1.07843392e-01f, -1.28818944e-01f, -8.93076733e-02f, -1.28464922e-01f, 4.07559201e-02f, 9.74368025e-03f, -1.66199937e-01f, -1.23899966e-01f,
  -3.90611351e-01f, 1.33728579e-01f, -5.48430812e-03f, -1.71357229e-01f, -2.85915315e-01f, -2.86537617e-01f, -2.10884959e-01f, -1.36037037e-01f, -2.36259773e-02f, -9.49814916e-02f,
  -2.92954482e-02f, 1.52514175e-01f, 1.80201322e-01f, 8.08200091e-02f, -4.43412550e-02f, -2.17284605e-01f, -2.85853982e-01f, -2.42010757e-01f, -3.73425484e-01f, -3.58301014e-01f,
  -2.20439792e-01f, -3.41089249e-01f, -3.09615284e-01f, -2.17632622e-01f, 1.04258932e-01f, 7.65264407e-02f, -3.76414508e-02f, -7.12601766e-02f, 3.42410319e-02f, -7.43063465e-02f,
  9.45982337e-02f, -1.53525352e-01f, -1.29309267e-01f, -5.49601652e-02f, -1.19893402e-02f, -1.07232183e-01f, -1.31451413e-01f, -5.44244014e-02f, 4.30660211e-02f, 5.71721010e-02f,
  -6.17529564e-02f, -1.22900836e-01f, 6.48949593e-02f, -8.26729834e-03f, -4.00840528e-02f, -1.17200889e-01f, 4.57312390e-02f, -8.06062520e-02f, 8.23874772e-02f, 6.18227273e-02f,
  5.18823788e-02f, -3.45553644e-02f, 1.34957120e-01f, 1.20271184e-01f, 2.29286570e-02f, 3.50199267e-02f, 1.34915754e-01f, 5.94840571e-02f, 7.07732663e-02f, 1.69401571e-01f,
  3.84906679e-03f, 1.52799934e-01f, 7.13264197e-02f, 4.13812995e-02f, -4.61339131e-02f, 3.13645042e-02f, -4.74088527e-02f, 1.73758715e-02f, -6.61468357e-02f, 5.58425710e-02f,
  3.60185131e-02f, -5.14296778e-02f, -1.58142124e-03f, 3.34557295e-02f, -3.75298411e-02f, 6.90136552e-02f, -1.56890210e-02f, 1.08639099e-01f, -7.46888155e-03f, 2.43197624e-02f,
  -5.91055900e-02f, 6.52363375e-02f, -6.72203600e-02f, 4.80169766e-02f, 3.90076218e-03f, 7.64694363e-02f, -3.27296257e-02f, 6.47827536e-02f, -5.02505079e-02f, -7.84533545e-02f,
  1.10204957e-01f, -1.85053274e-01f, -7.61619508e-02f, 8.14368576e-02f, 1.16584701e-02f, 6.87081227e-03f, 1.92382529e-01f, -4.98329960e-02f, -7.48389661e-02f, -1.16700828e-01f,
  1.33880917e-02f, 1.21526700e-02f, 8.83361623e-02f, 1.05729282e-01f, -7.35046417e-02f, 3.31308730e-02f, 6.94649220e-02f, 6.04323745e-02f, 2.12186091e-02f, 5.10717779e-02f,
  1.21769592e-01f, -7.35312998e-02f, 1.68832898e-01f, 1.94203943e-01f, 7.79451653e-02f, -8.39962885e-02f, 6.14138953e-02f, 1.31036401e-01f, 9.29953057e-06f, 1.26819015e-01f,
  3.01268280e-01f, 6.70300275e-02f, 3.23499113e-01f, 3.05538833e-01f, 2.86369711e-01f, 2.37880111e-01f, 1.94175076e-02f, 1.68227911e-01f, 1.43845960e-01f, 1.91618949e-01f,
  1.99300557e-01f, 1.63046628e-01f, 2.51177728e-01f, 1.63652688e-01f, 1.66403800e-01f, -1.39966412e-02f, 5.43577224e-02f, 2.31628269e-01f, 2.05618382e-01f, 2.47217759e-01f,
  1.46708548e-01f, 2.42617335e-02f, 1.07735805e-01f, 1.53479818e-02f, 1.23075291e-03f, 1.20829105e-01f, 1.38622940e-01f, -4.82676830e-03f, -2.41876189e-02f, 1.95694894e-01f,
  -1.16720460e-02f, 4.65840586e-02f, 1.45685658e-01f, -3.08686923e-02f, -1.02047615e-01f, -4.15673070e-02f, 1.03436578e-02f, 7.09894970e-02f, -5.85762262e-02f, -6.36717752e-02f,
  -1.23575136e-01f, 6.51373994e-03f, 2.12638844e-02f, -6.68128431e-02f, -4.40622084e-02f, 6.61708461e-03f, -1.33630872e-01f, -6.58426136e-02f, 4.93218862e-02f, -6.43063113e-02f,
  -1.07546747e-01f, -9.79231745e-02f, -1.93432331e-01f, 4.40663882e-02f, -4.94249947e-02f, -1.20328655e-02f, 1.05369585e-02f, -6.67218491e-02f, -1.73322931e-02f, -1.14299901e-01f,
  1.80366173e-01f, -9.69834104e-02f, -1.10064141e-01f, -7.13717937e-02f, -1.71099812e-01f, -4.96626943e-02f, -3.88389118e-02f, -4.48039100e-02f, -6.30667582e-02f, -4.63702157e-02f,
  -2.08254419e-02f, -3.75087261e-02f, 6.27702326e-02f, 5.49157001e-02f, 1.37445793e-01f, 6.43821657e-02f, 7.10418746e-02f, -2.05054861e-02f, -8.06079507e-02f, -5.16693220e-02f,
  -1.34147936e-02f, -2.91367583e-02f, -9.58267599e-02f, -1.67191699e-01f, -7.64544904e-02f, 6.74831569e-02f, -5.75462021e-02f, -5.76967420e-03f, -1.83104441e-01f, -1.57416895e-01f,
  -6.26381710e-02f, 6.64254948e-02f, 1.25697935e-02f, -6.65227324e-02f, -4.82348613e-02f, -8.30217171e-03f, 1.20889254e-01f, 5.73518239e-02f, 5.19014895e-03f, 8.45539719e-02f,
  -8.36925879e-02f, 1.34624898e-01f, -5.35524338e-02f, -1.06177114e-01f, -3.01366542e-02f, 2.25205421e-02f, -2.72230264e-02f, 1.81665286e-01f, -6.57785833e-02f, 2.71756342e-03f,
  -2.70153163e-04f, 6.77909404e-02f, 4.83103320e-02f, 8.26354995e-02f, -5.95634654e-02f, -1.37527985e-02f, 3.46443057e-02f, 7.54536614e-02f, -4.51269038e-02f, 5.70019968e-02f,
  -6.07597947e-01f, -1.09769441e-01f, -3.38676512e-01f, -3.05193365e-01f, 1.19020090e-01f, 1.83898225e-01f, -9.24165994e-02f, -1.57594070e-01f, 3.85097042e-02f, -1.44003127e-02f,
  -5.09979986e-02f, 8.82815942e-03f, 4.18249927e-02f, 1.41180351e-01f, -4.07513157e-02f, 3.11534200e-02f, 7.92939737e-02f, -3.72180752e-02f, -2.36171354e-02f, 1.65194318e-01f,
  1.97491705e-01f, -1.14022136e-01f, -1.57414123e-01f, 3.44890058e-02f, 4.20862176e-02f, -3.02501209e-03f, -3.86296660e-02f, 1.11671522e-01f, 1.60248354e-01f, 1.54018998e-01f,
  -1.32374195e-02f, -3.82158816e-01f, -3.09711285e-02f, 4.05675322e-02f, -5.73991798e-02f, -1.20756939e-01f, -2.84320533e-01f, -7.82325864e-02f, -1.04245484e-01f, -1.27758786e-01f,
  -3.36805731e-02f, 7.11714895e-03f, 4.10854165e-03f, 1.38143584e-01f, 6.45942148e-03f, -5.37684523e-02f, 3.59034464e-02f, -6.99399412e-02f, -2.04656959e-01f, 5.71297258e-02f,
  2.25511104e-01f, 1.78396806e-01f, -6.73647821e-02f, 9.20838863e-02f, 9.06429663e-02f, 7.07004890e-02f, 1.47988886e-01f, 2.05449730e-01f, -7.15377256e-02f, 6.58840537e-02f,
  1.61595106e-01f, 1.56303849e-02f, -6.35425672e-02f, 4.20559756e-02f, 1.95744932e-01f, 5.46313785e-02f, -1.56443920e-02f, 1.08640820e-01f, 8.29886794e-02f, -5.12307994e-02f,
  -4.56108339e-02f, -3.14399484e-03f, 5.26999719e-02f, -7.21591786e-02f, 1.59113243e-01f, -7.70486370e-02f, -6.11368157e-02f, -6.18789904e-02f, 1.44167440e-02f, -2.13840660e-02f,
  -1.78890862e-02f, 9.91505161e-02f, 3.26699689e-02f, 6.39878809e-02f, 1.11000769e-01f, 2.29580477e-02f, -4.73751277e-02f, 1.06281839e-01f, 2.88415160e-02f, 6.13251142e-02f,
  -2.36488029e-01f, 5.36539517e-02f, -9.59993806e-03f, 9.29742455e-02f, -7.37336129e-02f, 4.76615466e-02f, -1.51576266e-01f, 5.86514212e-02f, -1.30096734e-01f, -1.50365755e-01f,
  5.06293513e-02f, -1.21798860e-02f, -2.84827165e-02f, 1.33646920e-01f, -9.07032043e-02f, 5.43218143e-02f, 1.13110282e-01f, -1.77119728e-02f, -1.13044970e-03f, 3.01263314e-02f,
  1.39193714e-01f, -5.67560159e-02f, -1.50494143e-01f, -9.71243829e-02f, 5.33835329e-02f, -6.13815011e-03f, 7.54593462e-02f, 1.25751866e-03f, -1.34194806e-01f, -7.98976645e-02f,
  -1.05472729e-01f, -2.94249356e-01f, -1.26835659e-01f, 8.44436660e-02f, 1.84176922e-01f, -1.06705785e-01f, -3.82673353e-01f, -3.22614908e-01f, 1.19820312e-01f, -2.01178983e-01f,
  1.27065092e-01f, 1.61298692e-01f, 1.01805307e-01f, -5.22378162e-02f, -3.65667939e-01f, -2.71188796e-01f, 7.68450275e-02f, -3.94694321e-02f, 7.86221959e-03f, 1.44053116e-01f,
  2.43869215e-01f, 1.36442259e-01f, 5.45976497e-02f, 6.01399764e-02f, 1.11299112e-01f, 1.17636137e-01f, 5.12180030e-02f, 1.48413226e-01f, -3.10845450e-02f, 3.33976448e-02f,
  1.43904379e-02f, -2.11671904e-01f, 6.63367286e-02f, 3.79404835e-02f, 9.86704752e-02f, -8.81058201e-02f, -1.16203658e-01f, -1.51360214e-01f, 1.69668309e-02f, 2.40070373e-02f,
  1.57274172e-01f, 7.76275545e-02f, 2.58884817e-01f, 1.41372859e-01f, 1.38076723e-01f, -6.24455735e-02f, 4.50184755e-02f, -2.25026265e-01f, -2.55694717e-01f, -2.22501174e-01f,
  9.03602690e-02f, 2.77980566e-01f, -1.44282967e-01f, -2.74601161e-01f, -2.01795116e-01f, 1.26664162e-01f, -1.32063538e-01f, -1.49382092e-02f, -2.53426671e-01f, -2.26716980e-01f,
  -1.59633398e-01f, 6.75152689e-02f, 2.12997831e-02f, -1.47033766e-01f, -1.06302902e-01f, -3.65692563e-02f, 5.68095744e-02f, -9.80883911e-02f, 7.03029335e-02f, -1.39071181e-01f,
  7.51454383e-02f, -6.36367276e-02f, 1.15632810e-01f, 3.28799151e-02f, 1.17184274e-01f, 5.55548668e-02f, 1.43369017e-02f, -1.25411034e-01f, 5.07492498e-02f, -1.80496136e-03f,
  -9.14054632e-04f, 4.49642129e-02f, 1.21232443e-01f, -1.37357190e-02f, -1.48141161e-01f, -9.37563702e-02f, 7.22991442e-03f, -1.34665474e-01f, 1.48534058e-02f, 2.34848223e-04f,
  -2.08893698e-02f, -3.56711335e-02f, 3.54477689e-02f, -7.60473087e-02f, -7.74217397e-02f, 7.45432824e-02f, 7.05119297e-02f, -8.62210616e-02f, 1.24195265e-02f, -1.38416633e-01f,
  -1.15847796e-01f, -2.05953240e-01f, -1.45296827e-02f, 9.52727869e-02f, 7.25497305e-02f, -8.29718113e-02f, -9.46973413e-02f, 2.72109751e-02f, -3.72906849e-02f, 8.00749734e-02f,
  -1.76859990e-01f, -1.38130501e-01f, -1.93195567e-01f, -2.92712957e-01f, -5.23736626e-02f, -3.13393772e-02f, -7.47635961e-02f, 7.61477351e-02f, -2.63824850e-01f, -4.21414256e-01f,
  -2.03667700e-01f, -2.60334879e-01f, 3.60218942e-01f, -2.56963670e-01f, -5.70838712e-02f, -1.54008623e-02f, 7.68561140e-02f, -1.48574725e-01f, -1.65504411e-01f, -9.19455141e-02f,
  8.89590941e-03f, 1.06344931e-01f, 2.07173780e-01f, 7.72942007e-02f, 6.21835552e-02f, 6.16143718e-02f, 4.71285917e-02f, 2.67399967e-01f, 3.78793240e-01f, 1.27246276e-01f,
  1.11648096e-02f, -1.42143235e-01f, -1.71074286e-01f, 8.06866400e-03f, 5.82530536e-02f, 3.36107537e-02f, 3.01837027e-02f, -1.98888451e-01f, -1.11758290e-02f, -1.32862842e-02f,
  4.72819895e-01f, -2.45681286e-01f, 3.54546681e-02f, -1.41387925e-01f, -6.13704696e-02f, -9.78425369e-02f, 8.70582461e-02f, -1.64166182e-01f, -4.56382670e-02f, -1.70126766e-01f,
  -1.67317882e-01f, -1.19032763e-01f, -8.64907354e-02f, 2.88823880e-02f, 3.70341055e-02f, 3.95371355e-02f, -1.75992155e-03f, -7.31265098e-02f, -8.64105150e-02f, 9.72045884e-02f,
  7.64773786e-02f, -6.12169206e-02f, 1.49406135e-01f, 2.75097322e-03f, 5.88928023e-03f, 4.84538563e-02f, 1.29065784e-02f, -5.41484915e-02f, -1.89483352e-02f, -4.43025352e-03f,
  4.96033393e-02f, 8.06736946e-03f, 4.25855145e-02f, 3.60255018e-02f, -3.24259065e-02f, -5.10160401e-02f, 3.28265913e-02f, 1.29406527e-01f, 1.24721497e-01f, 6.92683831e-02f,
  -2.59771124e-02f, 3.50345261e-02f, -2.87161283e-02f, -1.90148577e-02f, -2.94553936e-02f, -5.65054901e-02f, -3.55673023e-02f, -8.01504329e-02f, -4.43062782e-02f, -3.71750742e-02f,
  6.51510060e-02f, 3.32429470e-03f, 7.28866234e-02f, 5.25162043e-03f, -7.48159513e-02f, -1.81814823e-02f, 1.29432520e-02f, -1.12506159e-01f, -7.43557885e-02f, -5.34872059e-03f,
  1.11401603e-01f, -2.59428710e-01f, 1.52969494e-01f, 1.20147407e-01f, 8.88145471e-04f, -1.73774973e-01f, 6.56450912e-02f, -1.73666656e-01f, -1.45578593e-01f, 7.75535777e-02f,
  -1.48450315e-01f, 8.73611309e-03f, 8.67565442e-03f, -1.04345232e-01f, 1.06886037e-01f, 8.23678449e-03f, -8.91977251e-02f, -2.27777455e-02f, -8.28431249e-02f, -5.42021692e-02f,
  -1.59182131e-01f, -7.86160901e-02f, 2.27145270e-01f, 1.38085693e-01f, -5.88529222e-02f, 5.49253412e-02f, 1.93607077e-01f, 7.97925144e-02f, 1.42046750e-01f, 3.41548435e-02f,
  -4.92961615e-01f, -3.66049670e-02f, -1.67924762e-01f, -1.73603147e-01f, 1.69580832e-01f, 2.18190864e-01f, 2.71475881e-01f, 3.82353179e-02f, -7.73174539e-02f, -1.20767625e-02f,
  5.74055649e-02f, -1.42875537e-01f, -1.50417924e-01f, 2.71970723e-02f, 1.37398332e-01f, 2.02406809e-01f, 1.63766980e-01f, 6.43408820e-02f, 4.88853529e-02f, 1.98053360e-01f,
  1.35833248e-01f, -8.25821534e-02f, -1.15556903e-01f, -3.35982107e-02f, -4.41736281e-02f, -1.31090228e-02f, -1.04764901e-01f, -6.94111409e-03f, 1.29424766e-01f, -9.65778753e-02f,
  -2.03427941e-01f, -1.25326186e-01f, 2.09509388e-01f, 2.64114719e-02f, -3.16347517e-02f, -4.43151407e-02f, -6.54645264e-02f, -1.55717865e-01f, -5.70156053e-02f, -7.82499313e-02f,
  4.53004502e-02f, -6.68736640e-03f, -7.49109685e-02f, 6.55173464e-03f, -9.64838788e-02f, -3.10512204e-02f, -1.07151959e-02f, -1.38152987e-01f, -1.50463402e-01f, 1.90425757e-02f,
  1.65884987e-01f, 4.19805422e-02f, -1.68105885e-01f, -3.41959186e-02f, 6.46645669e-03f, -1.24747820e-01f, -2.71158274e-02f, -1.01536177e-01f, -9.07799229e-03f, -2.41328299e-01f,
  2.15455573e-02f, 9.47913229e-02f, -3.15397941e-02f, 5.96933924e-02f, 5.73043153e-02f, -7.80896284e-03f, -4.49616201e-02f, 4.16267961e-02f, 1.07670061e-01f, -2.33857371e-02f,
  6.63776770e-02f, 4.63886075e-02f, -3.82526182e-02f, -1.06328771e-01f, 9.99504584e-04f, 2.14653113e-03f, 1.02543414e-01f, 1.50507186e-02f, -8.97710864e-03f, 6.92324787e-02f,
  -2.04575323e-02f, -8.58147144e-02f, -6.57531172e-02f, 2.33633481e-02f, 9.35375392e-02f, 1.95395257e-02f, 5.73866069e-02f, 5.55630261e-03f, -7.93942884e-02f, -1.40533760e-01f,
  -5.15485071e-02f, 1.85750052e-01f, -1.76724523e-01f, -6.83154091e-02f, -1.91594213e-02f, 5.13246544e-02f, -2.03298423e-02f, 6.88626766e-02f, -1.00864649e-01f, -8.95014126e-03f,
  2.93152053e-02f, -1.43230796e-01f, -7.08875954e-02f, 7.02038333e-02f, -4.18941639e-02f, -1.38610415e-02f, -6.55469224e-02f, 3.19391377e-02f, 8.53680223e-02f, 1.79676805e-02f,
  -1.84559301e-02f, 4.88177687e-02f, -1.60449326e-01f, -1.56130597e-01f, -1.86193541e-01f, -1.23945311e-01f, -1.82525501e-01f, -6.30651936e-02f, -1.39472499e-01f, -1.69190973e-01f,
  3.77521127e-01f, 1.89129278e-01f, 2.02197451e-02f, 1.55235067e-01f, -9.36835930e-02f, -1.09825820e-01f, 2.62021393e-01f, 1.30479813e-01f, 1.46290679e-02f, 1.01898380e-01f,
  -2.03732580e-01f, -4.55614567e-01f, -3.69578809e-01f, -2.25397110e-01f, 1.23121634e-01f, 1.22169398e-01f, 1.77735567e-01f, 9.76447240e-02f, -1.55422641e-02f, -1.35108586e-02f,
  -1.11068889e-01f, 1.91805318e-01f, 1.40480295e-01f, 1.40493751e-01f, 1.35204807e-01f, -2.44181812e-01f, 1.55418068e-02f, 9.09575671e-02f, -4.95168716e-02f, 4.52950113e-02f,
  -3.93296629e-02f, 7.21408576e-02f, -1.77457467e-01f, -4.83606495e-02f, -8.11320543e-02f, 6.83955029e-02f, -1.28088370e-01f, -8.00168291e-02f, -1.05610244e-01f, 1.57646406e-02f,
  -6.76684976e-02f, -1.30867148e-02f, -2.36466885e-01f, -2.01961294e-01f, 1.28304232e-02f, -2.65776943e-02f, 9.34106335e-02f, 1.14860892e-01f, -3.25911418e-02f, -1.98016185e-02f,
  -1.29266530e-01f, -3.77194956e-02f, 9.84397158e-02f, 2.60524806e-02f, 6.98064119e-02f, -6.58149421e-02f, -5.94338551e-02f, 3.89000662e-02f, 2.70961020e-02f, 1.17837146e-01f,
  6.65081963e-02f, -2.35931259e-02f, -1.11254126e-01f, 2.69070882e-02f, -2.12073252e-02f, -2.27616401e-03f, -1.14289142e-01f, -2.74339989e-02f, -1.20374821e-01f, 1.35453612e-01f,
  9.46008600e-03f, 3.95408785e-03f, 2.01812177e-03f, 1.22063927e-01f, 1.85012296e-02f, 3.10330316e-02f, 3.77987064e-02f, 5.68896383e-02f, -9.12659392e-02f, 1.07548669e-01f,
  1.62380058e-02f, -3.87230259e-03f, 5.32822832e-02f, -8.57372656e-02f, -2.15307157e-02f, -1.58324335e-02f, -6.65805787e-02f, 5.87497838e-02f, -1.22295776e-02f, 7.99165666e-02f,
  -9.66506749e-02f, -2.12165609e-01f, -2.09573214e-03f, -3.44283395e-02f, 8.09766352e-02f, 9.80947167e-03f, -9.77441296e-02f, -1.47319540e-01f, 3.93837094e-02f, 1.04926169e-01f,
  -8.46239030e-02f, 3.59972268e-02f, -2.56713796e-02f, 2.31980607e-02f, -1.17753327e-01f, 1.84938833e-02f, 1.12746600e-02f, -3.97405215e-02f, -6.49495572e-02f, -3.33096795e-02f,
  -4.81266901e-02f, -3.09181698e-02f, 5.39574288e-02f, 6.96203932e-02f, -3.75803672e-02f, -1.50392562e-01f, -3.81254926e-02f, 5.21352217e-02f, -6.71108365e-02f, 2.79518664e-01f,
  -6.09888993e-02f, 1.09728344e-01f, 1.94679379e-01f, 1.48060635e-01f, 2.61209130e-01f, 2.13973910e-01f, 3.12593877e-01f, 1.72178194e-01f, 4.16279398e-02f, 1.42499864e-01f,
  -4.02298346e-02f, -2.75083929e-02f, 6.80469209e-03f, -1.06806166e-01f, 6.79526180e-02f, 1.57159701e-01f, 9.91100147e-02f, 3.59525047e-02f, 6.26524836e-02f, 1.28111273e-01f,
  3.48562486e-02f, -1.98767148e-02f, 3.61569338e-02f, 9.32938233e-02f, 3.54550444e-02f, 7.08795115e-02f, 3.08781583e-02f, 7.72825778e-02f, 4.69890162e-02f, -1.77908074e-02f,
  -3.40807557e-01f, 9.74381641e-02f, 3.70789506e-03f, -8.18901137e-02f, 1.35823740e-02f, 1.37660215e-02f, -4.15961631e-02f, 6.50599226e-02f, -1.12523315e-02f, -1.03531010e-01f,
  -4.55929637e-02f, 2.65040994e-02f, -7.22119957e-02f, -1.19026087e-01f, -2.77588796e-02f, -7.41956756e-02f, 3.19186151e-02f, -8.87261257e-02f, -6.49657547e-02f, -1.51421502e-01f,
  -1.78905353e-02f, -6.81606978e-02f, 1.17503470e-02f, 8.28982070e-02f, 9.42632183e-03f, -1.02719836e-01f, -3.02963983e-03f, -8.71295780e-02f, -2.65767258e-02f, -7.79194385e-02f,
  1.72614574e-03f, -1.11936323e-01f, -5.96140325e-02f, -1.06025189e-02f, -5.30831516e-02f, -5.74764982e-02f, -5.77800237e-02f, -1.67763397e-01f, -1.20659567e-01f, -3.16080302e-02f,
  -3.49049307e-02f, -1.30538613e-01f, -1.51010036e-01f, 2.07011569e-02f, -5.15203141e-02f, -3.35775018e-02f, 5.09913452e-03f, -1.44114997e-02f, -4.86329272e-02f, 1.00414775e-01f,
  -2.81242747e-02f, 2.77950354e-02f, -8.12609941e-02f, -3.82178389e-02f, -2.33444180e-02f, 6.99830130e-02f, 1.54782971e-02f, -6.47456050e-02f, -8.79056081e-02f, -1.43282050e-02f,
  -1.76619902e-01f, -1.98525041e-02f, -1.74661309e-01f, -1.64012387e-01f, 7.84828737e-02f, -4.78387997e-02f, -1.00680351e-01f, -1.23245955e-01f, 7.17949122e-02f, -1.65371135e-01f,
  -7.52135664e-02f, -8.03377852e-02f, -5.73561266e-02f, 2.76768627e-03f, -9.48180184e-02f, -1.25700328e-02f, -1.24372482e-01f, 1.50873009e-02f, 3.58822313e-03f, -1.67726204e-01f,
  -1.35086745e-01f, -3.31433006e-02f, 3.05267237e-02f, 7.65118226e-02f, 4.50484827e-03f, -6.67896643e-02f, -1.15482301e-01f, 1.96134727e-02f, -4.16383073e-02f, 3.96670178e-02f,
  1.01014584e-01f, -1.27524912e-01f, 2.24485770e-01f, 7.37769231e-02f, -1.41553834e-01f, -3.03558290e-01f, -4.87870008e-01f, -2.20687047e-01f, -2.12367233e-02f, -2.26716716e-02f,
  -1.93433821e-01f, 1.27514228e-01f, 1.25733942e-01f, 1.22216552e-01f, -9.43954512e-02f, -4.16637510e-02f, 1.84052885e-01f, 1.82032883e-01f, 5.44380024e-02f, -8.38089660e-02f,
  1.58692785e-02f, 7.74226114e-02f, 2.04026833e-01f, 3.34443199e-03f, 1.23358130e-01f, -4.70177922e-03f, 5.38251698e-02f, 2.02303529e-01f, 8.36480260e-02f, 4.41084176e-01f,
  1.73886046e-01f, -2.54379958e-02f, 1.59073606e-01f, 2.15424597e-01f, 1.64993122e-01f, 4.99304868e-02f, 1.06440403e-01f, 1.04401037e-01f, 3.70336114e-03f, 1.30753592e-01f,
  5.58679961e-02f, 2.68612802e-02f, -5.29519953e-02f, 3.41670103e-02f, 2.98447721e-02f, 2.21283687e-03f, 2.10454725e-02f, 1.20841280e-01f, -2.06044801e-02f, -1.58997282e-01f,
  1.24381445e-02f, 4.96898256e-02f, -1.47129551e-01f, -1.72907844e-01f, -1.11116603e-01f, 1.10132262e-01f, -1.72958359e-01f, 2.94735283e-02f, -1.16892822e-01f, 2.88444031e-02f,
  6.92180395e-02f, 8.35174620e-02f, 1.55230716e-03f, 8.54382515e-02f, -1.78693309e-02f, 1.48584815e-02f, 8.10315832e-02f, -4.66387672e-03f, 7.89030939e-02f, 8.24819133e-02f,
  2.19147536e-03f, -1.26026049e-02f, 8.25496577e-03f, -2.17247121e-02f, 7.42782578e-02f, 1.04432352e-01f, 8.78000818e-03f, 2.22925581e-02f, -5.80536984e-02f, 2.90101729e-02f,
  2.29804777e-03f, 8.47674161e-02f, 3.86893563e-02f, -6.32224977e-02f, 5.98442890e-02f, -8.69541243e-02f, 8.90615508e-02f, -1.25558436e-01f, 8.29155594e-02f, 7.16456920e-02f,
  -1.22405052e-01f, -9.06096995e-02f, 1.98135972e-01f, 1.62010327e-01f, -4.88409325e-02f, -6.87068254e-02f, 1.22564984e-02f, 5.17136939e-02f, 1.59569215e-02f, -6.64784200e-03f,
  -1.62398040e-01f, -5.84326573e-02f, -5.81240747e-03f, 3.48557606e-02f, 3.96214910e-02f, -7.16829374e-02f, -8.01516697e-04f, -7.27716386e-02f, -6.30934015e-02f, -6.15286939e-02f,
  -7.68100694e-02f, -1.75444633e-01f, -3.08329016e-01f, -2.91497409e-01f, -1.03058770e-01f, -4.59336154e-02f, -1.80719137e-01f, -2.06445679e-01f, -1.74001276e-01f, -4.08556253e-01f,
  -7.36746371e-01f, -5.36561459e-02f, -1.21210001e-01f, 8.69198591e-02f, 1.95438474e-01f, 2.10997149e-01f, 1.18456475e-01f, 8.28434154e-03f, 5.70606925e-02f, 6.20205514e-02f,
  5.88486306e-02f, -1.51213845e-02f, 4.50708382e-02f, 4.77787718e-04f, 1.25464126e-02f, 9.43992510e-02f, 2.04019234e-01f, -6.00907989e-02f, -1.37543887e-01f, 1.02548506e-02f,
  2.12501004e-01f, -1.19679533e-01f, -2.22168133e-01f, 3.45615074e-02f, 1.24881312e-01f, 1.52668357e-01f, 7.98686594e-02f, -1.16016334e-02f, 1.23571098e-01f, 2.88981080e-01f,
  5.17946817e-02f, -1.22459002e-01f, -6.81965575e-02f, 9.35395136e-02f, -1.48355186e-01f, -2.47684970e-01f, -8.68316293e-02f, -3.09387520e-02f, 2.35949475e-02f, 1.08473338e-01f,
  -4.81412672e-02f, -9.80518982e-02f, -7.94663876e-02f, 6.90239808e-03f, -2.65469439e-02f, -7.33132213e-02f, -2.13304050e-02f, 1.47302240e-01f, 1.63786963e-01f, 3.03810798e-02f,
  1.04036592e-01f, -3.91425006e-02f, 1.41722560e-01f, 1.41644299e-01f, 9.03567001e-02f, 6.73026443e-02f, -2.68324418e-03f, -6.84023798e-02f, -4.06396613e-02f, -1.00922108e-01f,
  -6.88654631e-02f, -1.52251497e-01f, -2.55105924e-02f, 7.99563155e-02f, 2.11736187e-02f, -1.31234378e-02f, 5.94447777e-02f, 1.11369006e-01f, -3.96477198e-03f, -1.81217730e-01f,
  7.75501356e-02f, 1.26351610e-01f, 8.32057819e-02f, 9.34142023e-02f, 6.31957650e-02f, 7.57085532e-02f, 1.52545143e-02f, 7.87322596e-02f, -1.11951260e-02f, 5.59849851e-02f,
  5.51277809e-02f, -3.71955778e-03f, -1.14495337e-01f, 2.97959857e-02f, 9.70138311e-02f, 1.30599141e-01f, 9.08308569e-03f, -5.20742796e-02f, -1.91673473e-01f, -3.12679633e-02f,
  3.84873122e-01f, 7.00329393e-02f, -1.54682184e-02f, -1.08108670e-02f, 8.00556969e-03f, -1.27279654e-01f, 7.95119554e-02f, 1.60900295e-01f, 1.68447375e-01f, 1.11705996e-01f,
  4.04618308e-02f, -8.54963437e-02f, -1.07564688e-01f, -3.31298448e-02f, -2.22500384e-01f, 3.86508368e-02f, 8.42160806e-02f, 1.21293277e-01f, 1.39824763e-01f, 1.39288723e-01f,
  -2.57022232e-02f, 2.97428332e-02f, 3.58486548e-02f, 6.79961219e-02f, -1.31037785e-02f, -2.91114170e-02f, 1.73370074e-02f, -7.63442889e-02f, -4.74669086e-03f, -1.57038048e-01f,
  -2.40019113e-01f, 3.32475811e-01f, 2.03431934e-01f, -1.27575323e-01f, 9.59810019e-02f, 9.63994041e-02f, 1.41857117e-01f, -1.33050278e-01f, -2.97049344e-01f, 1.68857902e-01f,
  2.85895854e-01f, -1.09751992e-01f, 1.03956452e-04f, -6.31842911e-02f, -1.60135210e-01f, -1.28906928e-02f, 8.45637114e-04f, -1.28990889e-01f, -3.29326302e-01f, -2.10547507e-01f,
  -1.66097060e-01f, -2.07904443e-01f, -1.98649064e-01f, -1.67822778e-01f, -4.67865206e-02f, -5.72515316e-02f, 1.39177084e-01f, -2.22390182e-02f, 8.87439623e-02f, 1.54458508e-01f,
  3.77378672e-01f, 1.39214218e-01f, -4.41983901e-02f, -2.04299346e-01f, 4.25321124e-02f, 1.39062619e-02f, 4.02937755e-02f, 4.10319380e-02f, 1.24964258e-02f, -4.25963104e-02f,
  -8.95799138e-03f, 2.09404957e-02f, -6.58254279e-03f, -1.62570298e-01f, -1.99304000e-02f, -1.26290292e-01f, -4.22660522e-02f, -1.77570954e-01f, -4.66185696e-02f, 4.20878194e-02f,
  -1.36935890e-01f, 1.06592551e-01f, -3.23915342e-03f, -8.34352449e-02f, 4.86117676e-02f, -2.36646131e-01f, 2.23730970e-02f, -6.90687448e-02f, -5.11506498e-02f, 1.36378825e-01f,
  -4.04464714e-02f, 6.26092628e-02f, 3.76309380e-02f, -2.08853534e-03f, -3.09773423e-02f, 1.32296443e-01f, -4.66640741e-02f, 2.05741096e-02f, -6.45354316e-02f, -6.34685904e-02f,
  -1.99601967e-02f, 3.36815938e-02f, -2.19527399e-03f, 4.29743938e-02f, 4.19446900e-02f, 3.63761485e-02f, -5.15547618e-02f, -1.82437412e-02f, -2.85060797e-02f, -5.66370711e-02f,
  -6.19333051e-02f, 2.41032452e-03f, 6.54369667e-02f, -8.21169019e-02f, 1.38364777e-01f, 3.00471410e-02f, 5.81346862e-02f, -2.72352118e-02f, -1.77321397e-02f, -8.83337930e-02f,
  -1.35697991e-01f, 8.66992399e-02f, 8.20679590e-02f, -1.03067840e-02f, 1.18364003e-02f, -8.07808638e-02f, 1.96124110e-02f, -1.27564613e-02f, 1.81552544e-02f, -1.11364543e-01f,
  -1.21567184e-02f, -6.04145862e-02f, 6.44853786e-02f, -1.07629694e-01f, -1.49304122e-02f, -1.17306493e-01f, -8.48960429e-02f, 3.01520042e-02f, -4.32890616e-02f, 7.63505995e-02f,
  -1.23315521e-01f, -4.83711250e-02f, -2.81141475e-02f, 3.68362628e-02f, 1.01099117e-02f, -5.08286655e-02f, 1.36269093e-01f, -7.94190317e-02f, -8.57656822e-02f, -8.55389982e-02f,
  -3.74424718e-02f, -8.15355182e-02f, -3.04336660e-02f, 9.08286422e-02f, 1.56281963e-01f, 9.76217166e-02f, -1.22545041e-01f, 9.55364928e-02f, 1.57817245e-01f, -2.71899968e-01f,
  -3.34257968e-02f, -6.25326037e-02f, -1.08650096e-01f, -1.15399919e-01f, -2.42432043e-01f, -2.57065922e-01f, -2.56954283e-01f, -1.35351986e-01f, 1.16443112e-01f, 1.47835478e-01f,
  7.52314851e-02f, -6.43809000e-03f, 1.22733079e-02f, -2.80878749e-02f, -3.56461741e-02f, -5.97506724e-02f, -1.85707331e-01f, -1.34481341e-01f, -7.15140477e-02f, -2.82865196e-01f,
  -8.65780190e-02f, 1.54055253e-01f, 1.71061814e-01f, -5.64807579e-02f, -5.56939133e-02f, 2.62965690e-02f, 1.22897260e-01f, 5.61244264e-02f, 3.27076577e-02f, -5.89317754e-02f,
  -2.45020203e-02f, 1.86356381e-02f, 7.38420412e-02f, 9.68970433e-02f, 2.32663751e-02f, 5.91087341e-03f, 1.02069765e-01f, 6.21437468e-02f, 8.91642645e-03f, 5.78243146e-03f,
  -7.52613395e-02f, 1.35309292e-05f, -1.15969777e-01f, -1.11812472e-01f, 1.67926237e-01f, -3.79069010e-03f, -2.50500324e-03f, 7.70966383e-03f, -9.01110545e-02f, -2.10474163e-01f,
  5.29715717e-02f, 1.24010570e-01f, 6.09145388e-02f, 3.41665782e-02f, -1.28238574e-01f, 6.31983802e-02f, -2.19877865e-02f, 3.27092619e-03f, 6.35177642e-02f, 2.73639560e-02f,
  2.78517585e-02f, 1.33775582e-03f, 1.46159623e-02f, -9.89261270e-02f, 1.48112858e-02f, 7.61365816e-02f, -2.37336010e-03f, 3.09003405e-02f, 2.64308210e-02f, -1.30687198e-02f,
  8.81119370e-02f, -4.67970371e-02f, -7.36719221e-02f, 3.24124917e-02f, 3.30246873e-02f, 5.37502803e-02f, 3.97763625e-02f, 1.31652728e-01f, 1.38949826e-01f, 7.66825676e-02f,
  1.27610043e-02f, -2.31503304e-02f, -1.78645134e-01f, -6.91058189e-02f, -1.48377120e-01f, 1.54222827e-02f, -1.49140999e-01f, -2.93159001e-02f, -3.26839574e-02f, -3.01380921e-02f,
  9.34416801e-02f, -6.53000399e-02f, -4.03793119e-02f, 8.14939477e-03f, 7.60709271e-02f, -9.37415808e-02f, -3.61055247e-02f, 6.05174527e-02f, -5.90508385e-03f, 8.25763214e-03f,
  -1.17268458e-01f, -1.76147327e-01f, -1.41131848e-01f, -1.51645660e-01f, 9.11373720e-02f, -1.82514191e-01f, -1.31885961e-01f, -8.09285715e-02f, -7.56997764e-02f, -3.49655658e-01f,
  1.48624688e-01f, -2.72879869e-01f, -1.81532711e-01f, 1.92109510e-01f, 1.38212323e-01f, -2.27214888e-01f, -5.17164767e-01f, 4.83945012e-02f, 2.05043152e-01f, -1.03328250e-01f,
  -6.44964576e-02f, 3.04210801e-02f, 6.24308251e-02f, -1.07102133e-01f, -2.85795569e-01f, -2.20777601e-01f, -1.39017671e-01f, -7.66940042e-02f, 4.76737926e-03f, -1.95161298e-01f,
  -8.64289179e-02f, 1.65023386e-01f, 1.36024013e-01f, -5.24358898e-02f, 1.40808508e-01f, 1.23862974e-01f, 1.73031881e-01f, 3.96347307e-02f, -1.13934174e-01f, -2.81115640e-02f,
  -1.36580899e-01f, 1.40284717e-01f, -9.49249491e-02f, -3.86356078e-02f, 1.83049608e-02f, -1.48643078e-02f, -1.88347131e-01f, 6.91547468e-02f, 4.78950106e-02f, 3.04700080e-02f,
  3.64479348e-02f, -7.98345581e-02f, 1.32799983e-01f, 6.44539371e-02f, -4.40403298e-02f, 6.01581410e-02f, 4.98589985e-02f, 5.50606987e-03f, -5.44017144e-02f, 6.50715679e-02f,
  -9.21537578e-02f, 3.43975276e-02f, -3.81119512e-02f, -1.46325931e-01f, -4.80879657e-02f, 9.27162096e-02f, -3.48209590e-02f, -2.48800032e-02f, -1.04740024e-01f, -5.07582128e-02f,
  6.21041702e-03f, 5.51670901e-02f, 1.09934388e-02f, -1.09328054e-01f, 4.65255938e-02f, 8.19523931e-02f, 8.30622576e-03f, 1.70857925e-02f, -3.34844179e-02f, 3.38560902e-02f,
  -4.39767838e-02f, -3.86722125e-02f, 6.32684082e-02f, -2.73228739e-03f, 4.71494310e-02f, 2.65327040e-02f, -1.15137130e-01f, -1.01544738e-01f, -1.52045920e-01f, 1.29310265e-01f,
  -1.14373110e-01f, 5.19218184e-02f, -1.99659169e-02f, -4.02704962e-02f, -4.39392440e-02f, 2.27282550e-02f, 8.07189941e-02f, -3.32308151e-02f, 5.08442484e-02f, 3.83975953e-02f,
  8.00957456e-02f, -1.86778694e-01f, -1.71170071e-01f, -7.72011951e-02f, 1.06952786e-02f, -8.30897093e-02f, -4.99583110e-02f, 3.13519314e-02f, 4.89490591e-02f, -6.05834536e-02f,
  -8.87671262e-02f, -2.60117892e-02f, -2.17016675e-02f, -1.13021858e-01f, -1.32814676e-01f, -7.88097605e-02f, -1.51458234e-01f, -1.24551900e-01f, -1.90642625e-01f, 9.76610631e-02f,
  -7.73421451e-02f, -1.39051676e-01f, -1.29996389e-01f, -3.84513102e-02f, 1.57498717e-01f, -9.43389684e-02f, -1.32689029e-01f, -1.06032409e-01f, -2.06203133e-01f, -1.07797630e-01f,
  -2.59219795e-01f, 2.23601222e-01f, -6.49143383e-02f, 5.14521189e-02f, 1.95524871e-01f, 3.37225292e-03f, 7.46469721e-02f, -5.73192984e-02f, 9.56191495e-02f, 3.91814820e-02f,
  9.20348912e-02f, -2.41171569e-01f, -2.05663610e-02f, -1.52364329e-01f, -1.99465632e-01f, 1.10672429e-01f, 2.99468428e-01f, -1.65417492e-01f, -3.24901164e-01f, -1.44704878e-01f,
  1.26823530e-01f, -8.99466872e-02f, -9.44162011e-02f, -3.46315019e-02f, 1.99586585e-01f, 4.28452250e-03f, 2.16948286e-01f, 1.87152117e-01f, 2.21099867e-03f, 1.84201583e-01f,
  -2.75103837e-01f, -9.80333015e-02f, 1.34242043e-01f, -2.42847595e-02f, 4.00011279e-02f, -7.85533786e-02f, -2.20307708e-02f, -5.27084759e-03f, 8.92916024e-02f, -1.72876995e-02f,
  3.30683477e-02f, -4.13976572e-02f, -5.29282773e-03f, -1.19061761e-01f, -7.91885480e-02f, -3.45099866e-02f, 3.88441607e-02f, -1.23060018e-01f, -1.48009986e-01f, -1.47522420e-01f,
  7.48354942e-02f, -4.89609726e-02f, -1.79821610e-01f, -1.25190774e-02f, 4.00917605e-02f, 6.62607029e-02f, -3.03705130e-02f, -7.74984658e-02f, -2.34960187e-02f, 1.15456916e-01f,
  1.13589056e-01f, 5.49007170e-02f, -2.61391047e-02f, 5.45645803e-02f, 3.29541378e-02f, -1.57313533e-02f, -4.25740145e-02f, 1.44633517e-01f, 9.14661363e-02f, 3.13137821e-03f,
  5.36039211e-02f, 9.72540453e-02f, -1.24444835e-01f, -9.81744006e-02f, 1.77913636e-03f, 1.04934774e-01f, 7.43041262e-02f, 4.19957973e-02f, -1.14735641e-01f, -1.00746967e-01f,
  1.78862363e-02f, -4.32334021e-02f, 1.52155375e-02f, -1.02693669e-01f, 8.15088004e-02f, 7.22628459e-02f, 6.01740368e-02f, 4.43987697e-02f, 5.42030931e-02f, 4.07249741e-02f,
  -1.05521465e-02f, 1.27633110e-01f, 1.10570244e-01f, 1.15980292e-02f, 4.09890972e-02f, 1.11723319e-01f, 1.14195853e-01f, 2.29679853e-01f, 9.24773961e-02f, -8.76295269e-02f,
  -1.13644199e-02f, 3.96677107e-02f, -1.41013399e-01f, -1.45368293e-01f, -3.14742595e-01f, -1.99620370e-02f, 1.43440247e-01f, -4.73992191e-02f, -2.97430847e-02f, -5.19068465e-02f,
  3.18080932e-02f, -5.41527383e-02f, -9.10475478e-02f, -5.45877498e-04f, -8.24671984e-02f, 1.14001043e-01f, 1.87151581e-02f, 1.46721750e-01f, -4.29778844e-02f, 1.50565756e-02f,
  -1.66346937e-01f, -5.64070679e-02f, 1.71904992e-02f, 3.77306104e-01f, 2.27541059e-01f, 6.07502051e-02f, -1.03664361e-02f, 8.69288519e-02f, 1.49957389e-01f, 2.28708368e-02f,
  1.57791913e-01f, 2.95925468e-01f, 3.00467789e-01f, 2.19876245e-01f, -4.66696313e-03f, 1.93847671e-01f, 1.18111148e-01f, 8.88417999e-04f, -6.42606169e-02f, 7.10995048e-02f,
  2.40993112e-01f, 2.27154531e-02f, -2.24544361e-01f, 8.86466075e-03f, 1.89775284e-02f, 2.72116780e-01f, 6.09658360e-02f, 9.33113173e-02f, 1.27049282e-01f, 1.46858975e-01f,
  5.78414230e-03f, -1.96640193e-02f, 1.20973244e-01f, 3.09403557e-02f, -1.23049095e-01f, -1.63905337e-01f, -7.28864595e-02f, -1.25492021e-01f, -1.09140418e-01f, 1.04708197e-02f,
  4.11630468e-03f, -1.51016146e-01f, 3.74273881e-02f, -5.03397547e-02f, -8.06642547e-02f, -6.21326081e-02f, -1.14543997e-01f, 3.48796770e-02f, 7.59871453e-02f, 3.37804928e-02f,
  1.42838284e-01f, 8.95633698e-02f, 3.79483635e-03f, 3.46037075e-02f, 8.16438496e-02f, 8.81112441e-02f, -7.96402916e-02f, -8.54139999e-02f, 6.91672191e-02f, -6.94757402e-02f,
  2.81848282e-01f, 1.60621375e-01f, 1.07398920e-01f, 6.83192462e-02f, -6.41657971e-04f, 1.28866090e-02f, 7.53492042e-02f, 1.82068124e-02f, 5.37665673e-02f, -2.64684074e-02f,
  7.27495477e-02f, 1.52587056e-01f, 6.33335412e-02f, 4.16629836e-02f, 9.57835838e-02f, -2.00964343e-02f, 3.04018351e-04f, 3.98021415e-02f, -4.20548916e-02f, 8.05918593e-03f,
  -3.24458256e-02f, -5.58979660e-02f, -1.06966831e-01f, -5.68502359e-02f, 6.75743818e-02f, 7.24258721e-02f, 6.22119941e-02f, 9.29586310e-03f, 3.30544114e-02f, -3.28707928e-03f,
  2.04529509e-01f, 2.31889591e-01f, 7.49572366e-02f, 2.79224329e-02f, -2.02031489e-02f, -1.31524444e-01f, 2.26506874e-01f, -7.70286620e-02f, -6.06749579e-02f, -1.87795870e-02f,
  -1.59083232e-02f, -7.58628920e-02f, -1.28043368e-01f, -1.44509599e-01f, -9.45085660e-02f, -1.13605499e-01f, 3.16355526e-02f, 1.35648906e-01f, 1.28839150e-01f, 6.57257885e-02f,
  -2.58729141e-02f, 2.92073633e-03f, -6.98286062e-03f, -4.33745384e-02f, 1.22571371e-01f, 1.47018671e-01f, -1.43388119e-02f, -9.87055749e-02f, 4.01377939e-02f, -1.08342901e-01f,
  -4.15593266e-01f, -1.94231480e-01f, -3.35443467e-01f, -5.37830442e-02f, 1.20176204e-01f, 1.42574161e-01f, 2.16763481e-01f, -9.56168696e-02f, -7.90367424e-02f, 2.08698157e-02f,
  1.11086629e-01f, 1.63442433e-01f, -7.97622353e-02f, 8.45618267e-03f, 3.40619422e-02f, -3.34833600e-02f, -1.06643373e-02f, -7.37445503e-02f, 1.09121963e-01f, 2.86331534e-01f,
  1.86864942e-01f, -1.10693105e-01f, -2.46659175e-01f, 1.12398051e-01f, 1.02251895e-01f, 6.47918433e-02f, -8.21521357e-02f, -5.74166998e-02f, 8.71242508e-02f, 1.85528770e-01f,
  -2.32341737e-01f, -2.40170434e-01f, 1.60024732e-01f, 1.15268409e-01f, 9.84886009e-03f, -6.14958145e-02f, -9.60706174e-02f, -7.19665587e-02f, 1.50302112e-01f, -9.90663543e-02f,
  -8.58513862e-02f, -4.59744856e-02f, 1.39745951e-01f, 7.12565705e-02f, -8.99393559e-02f, 4.65939194e-02f, -1.06890492e-01f, -2.03071475e-01f, -2.06270471e-01f, 3.13472450e-02f,
  2.07726747e-01f, -6.30744081e-03f, -2.17687398e-01f, -5.29070646e-02f, -1.19226247e-01f, -4.38628625e-03f, -5.03785238e-02f, -1.72204003e-02f, -7.46855885e-02f, -9.63482931e-02f,
  -3.68018821e-02f, 3.92846875e-02f, 1.18381553e-03f, -1.95136759e-02f, 1.21957585e-01f, -1.21242981e-02f, 1.31623834e-01f, 5.04697599e-02f, 6.18881285e-02f, -1.85301956e-02f,
  -2.26387735e-02f, -6.86464533e-02f, 2.39551160e-03f, 7.37883674e-04f, 1.91632152e-01f, 4.20954973e-02f, -1.60787869e-02f, 2.73752995e-02f, 2.52642855e-03f, -6.15753978e-02f,
  -7.40506202e-02f, -1.02425843e-01f, 2.00248770e-02f, 4.48720269e-02f, 6.98068216e-02f, 6.47384226e-02f, -1.48797256e-03f, 8.96346942e-02f, -6.57462478e-02f, -1.77293122e-02f,
  -1.47548288e-01f, -1.90542340e-01f, -9.09722969e-02f, -7.05857873e-02f, 3.19941342e-02f, -1.45374034e-02f, 6.77927658e-02f, 2.28999835e-02f, -4.66127656e-02f, 1.67585555e-02f,
  -1.46412596e-01f, -8.74446854e-02f, -5.26763126e-02f, -8.54295790e-02f, 3.35323811e-02f, -5.94830103e-02f, 8.79311264e-02f, 1.91687793e-01f, -1.30358100e-01f, -1.02048092e-01f,
  -2.38794580e-01f, 1.68938041e-02f, -1.74675763e-01f, -2.46960260e-02f, -4.55160923e-02f, -2.84318868e-02f, -1.35147274e-01f, -1.78376529e-02f, -1.56414226e-01f, -1.95919380e-01f,
  -1.74628168e-01f, -1.35746956e-01f, -8.06993246e-02f, -1.94670871e-01f, -5.52683845e-02f, 3.09531335e-02f, 3.75773162e-02f, 2.94578671e-02f, -1.74865812e-01f, -2.21722350e-01f,
  9.53960884e-03f, 1.38249636e-01f, -1.64170608e-01f, 8.55457336e-02f, 9.65088978e-02f, -2.26920754e-01f, -1.70034021e-01f, -7.76482522e-02f, 3.33124787e-01f, 2.96070158e-01f,
  7.90379345e-02f, 1.80234816e-02f, -1.55265713e-02f, -4.14116941e-02f, -1.29624546e-01f, -1.36667266e-01f, -2.86463231e-01f, -3.64576243e-02f, -4.06388380e-02f, -2.15864420e-01f,
  -9.66460183e-02f, 3.00027896e-02f, 9.64593738e-02f, 2.76966915e-02f, -5.73209710e-02f, 1.56809077e-01f, 1.20827714e-02f, -1.45485774e-01f, -3.15512978e-02f, -5.63565381e-02f,
  -2.06768643e-02f, 9.95029658e-02f, -8.70696455e-02f, 1.47211701e-01f, -6.19451441e-02f, 9.39483643e-02f, -1.14226274e-01f, -1.89000294e-02f, -8.40100423e-02f, 5.34330457e-02f,
  -9.61701721e-02f, -1.83767691e-01f, -3.00386772e-02f, -9.17725489e-02f, 5.99715998e-03f, -6.33128211e-02f, 3.24900150e-02f, -3.83195020e-02f, -2.95347925e-02f, -2.61615306e-01f,
  -5.46893217e-02f, -5.77437505e-02f, -7.88889825e-03f, 1.11780822e-01f, -8.02980438e-02f, -1.38538793e-01f, -5.29239997e-02f, 1.15269087e-02f, 2.07655102e-01f, -5.78758679e-02f,
  2.89504509e-02f, -6.23396272e-03f, 1.40655994e-01f, -1.06625304e-01f, -1.67546481e-01f, 1.10686459e-02f, -2.33546756e-02f, -1.57867670e-01f, -2.65625454e-02f, -1.12993844e-01f,
  1.74729489e-02f, -1.04985282e-01f, -9.96900946e-02f, 8.17106292e-02f, -4.42852592e-03f, -6.44483045e-02f, -1.66551284e-02f, 3.81560214e-02f, -1.50771514e-01f, -1.13934979e-01f,
  -7.63599798e-02f, 1.28126860e-01f, -1.11489549e-01f, 7.63792023e-02f, 4.73141298e-03f, -1.30191743e-01f, -1.48027956e-01f, 1.60718504e-02f, 2.65872572e-02f, 2.18643770e-01f,
  6.08322956e-02f, -6.68900907e-02f, -1.34071752e-01f, 7.46798888e-02f, 1.48543149e-01f, -9.55691189e-02f, -6.59297556e-02f, 3.47642065e-03f, -9.99087393e-02f, -1.29114240e-01f,
  -9.09982026e-02f, -7.26940036e-02f, 4.59242091e-02f, -1.00980923e-02f, -1.40623525e-01f, -2.71207225e-02f, -9.42068696e-02f, 3.68919084e-03f, 2.31574755e-02f, -2.27572232e-01f,
  6.45332187e-02f, -1.89088345e-01f, -2.68134147e-01f, -4.17052470e-02f, -3.80118459e-01f, -2.49274284e-01f, -3.57173651e-01f, -1.74807552e-02f, -6.79370239e-02f, -3.97634566e-01f,
  -2.56782681e-01f, 5.40669113e-02f, -1.36203960e-01f, -3.94755974e-02f, 1.27083352e-02f, -3.64266247e-01f, -1.59590542e-01f, 1.23341523e-01f, 2.97752857e-01f, 6.21074401e-02f,
  -3.69758271e-02f, 5.70524996e-03f, 2.23008141e-01f, 1.23809136e-01f, -2.10506365e-01f, -2.61867084e-02f, -2.57295758e-01f, -1.78297028e-01f, -1.51386693e-01f, -3.72210026e-01f,
  -3.31193358e-01f, -1.38380259e-01f, 1.89012568e-02f, 9.41483676e-02f, -1.19429879e-01f, -5.61244935e-02f, -1.04689300e-01f, 4.47302312e-02f, 1.38442427e-01f, -1.75452203e-01f,
  -9.67434421e-02f, 1.53519541e-01f, 1.50419846e-01f, -1.13148682e-01f, -5.51052578e-02f, 1.81124993e-02f, 1.52587518e-01f, 1.32025788e-02f, 1.12354085e-01f, -1.04380369e-01f,
  -3.99267823e-02f, -8.46525207e-02f, -4.86561693e-02f, -8.32237490e-03f, -1.65118705e-02f, -2.34719384e-02f, -8.54030699e-02f, -6.13643490e-02f, 1.23024039e-01f, -2.90923625e-01f,
  1.71927195e-02f, 6.91793114e-02f, -8.31844434e-02f, -5.05014174e-02f, 7.80356815e-03f, 1.93667803e-02f, 2.97957985e-03f, 1.02366686e-01f, 8.85573328e-02f, 5.99346496e-02f,
  2.91905534e-02f, -1.45009151e-02f, 6.75855279e-02f, -2.85927728e-02f, 8.18482563e-02f, 9.40458477e-02f, -6.19463762e-03f, 3.82111333e-02f, 5.15095629e-02f, 5.73667884e-02f,
  3.83902043e-02f, -4.16888762e-03f, 1.38081014e-02f, 3.16603519e-02f, -5.41232014e-03f, 1.39085564e-03f, 4.13215607e-02f, 2.68602222e-02f, -6.89909235e-02f, -1.47513766e-02f,
  -1.24473251e-01f, 1.97591633e-01f, -2.90776879e-01f, 5.07864542e-02f, 1.52637288e-02f, -6.58283979e-02f, -1.09424599e-01f, 1.42232075e-01f, -6.55057095e-03f, -1.30757868e-01f,
  8.03777501e-02f, 1.94618069e-02f, 7.88746551e-02f, 1.14035262e-02f, -2.63828915e-02f, 1.09902667e-02f, 4.55410080e-03f, 1.02357492e-01f, 8.31626430e-02f, -3.13357934e-02f,
  8.67416263e-02f, 8.22081324e-03f, 1.00331157e-01f, -9.39237624e-02f, -7.61080999e-03f, -8.01009592e-03f, 2.84949020e-02f, -8.22321922e-02f, 1.53395683e-01f, -4.97737154e-02f,
  5.18862188e-01f, -2.98431665e-01f, -2.07131177e-01f, -9.37699825e-02f, -3.79990786e-02f, 1.42002359e-01f, -2.64506526e-02f, -5.55401593e-02f, -6.08144365e-02f, -1.22169450e-01f,
  6.74564913e-02f, 2.30726734e-01f, 1.95705146e-02f, -1.29244030e-01f, -3.62196863e-02f, -2.02563331e-01f, -2.75228232e-01f, -1.36581540e-01f, 1.32498816e-01f, 6.13762513e-02f,
  1.74158830e-02f, -1.25307903e-01f, -7.25375488e-03f, -2.27309868e-01f, -3.52157027e-01f, -8.74441341e-02f, -2.85438955e-01f, -2.28885025e-01f, -1.80046752e-01f, -3.24657708e-01f,
  -2.41221160e-01f, 2.80421883e-01f, 5.33478968e-02f, 1.13688573e-01f, -4.62576598e-02f, 9.91643295e-02f, 2.17687245e-02f, -3.24242748e-02f, 2.96872798e-02f, -5.09319566e-02f,
  4.43352014e-02f, -1.16859796e-02f, 2.83619985e-02f, -3.74820307e-02f, 7.59550259e-02f, 1.70656219e-02f, 7.09057152e-02f, 7.85676390e-02f, 9.30877998e-02f, -2.48705726e-02f,
  5.33001050e-02f, 2.21500024e-01f, 2.42826149e-01f, 1.95359334e-01f, 2.13096797e-01f, 1.22452654e-01f, 1.17502436e-01f, 1.69714034e-01f, 9.04530436e-02f, 9.56719220e-02f,
  -1.29084243e-02f, 7.71101415e-02f, 7.56245479e-02f, 2.11604759e-01f, 1.18831694e-01f, 1.03193842e-01f, 4.80723679e-02f, -2.47034617e-03f, 1.02846079e-01f, -7.55190104e-02f,
  -3.23059522e-02f, 8.19361508e-02f, 1.84525639e-01f, -2.70749386e-02f, -3.96290720e-02f, 4.39608848e-04f, -3.23841255e-03f, -2.15082020e-02f, -4.33681086e-02f, -1.90539528e-02f,
  -1.06653450e-02f, 8.02311674e-02f, -1.29417494e-01f, -1.04856066e-01f, -3.71655971e-02f, -2.00682096e-02f, -8.80996138e-02f, 7.42508918e-02f, -9.87845287e-03f, -1.44883946e-01f,
  -1.46274582e-01f, 1.29490897e-01f, -1.61767483e-01f, 2.83628330e-02f, 4.43364820e-03f, -1.31886363e-01f, -5.17621338e-02f, -7.02729970e-02f, -7.72150829e-02f, -5.04888128e-03f,
  6.71896711e-02f, -1.56715035e-01f, -1.25209138e-01f, -4.79029194e-02f, -8.80744681e-02f, 2.71181837e-02f, 1.31811500e-01f, 1.97451741e-01f, 9.74873081e-02f, -1.38124973e-01f,
  -1.27281427e-01f, 1.62571684e-01f, 1.11197993e-01f, 1.75894573e-01f, 2.36203715e-01f, 4.91837412e-02f, -2.37272903e-02f, 8.68507549e-02f, 2.14764383e-02f, 2.68035755e-02f,
  -2.50342548e-01f, 2.88200647e-01f, 1.59752563e-01f, -6.05751649e-02f, 1.61960408e-01f, 4.71528023e-02f, 2.52952248e-01f, -2.38048211e-01f, -2.43630722e-01f, 2.21790984e-01f,
  1.19888462e-01f, -1.98362827e-01f, -8.71019065e-02f, -3.53107043e-02f, -1.73648093e-02f, 1.07925758e-01f, 1.42691582e-01f, -7.15345293e-02f, -2.81794101e-01f, -3.94217484e-02f,
  3.59687991e-02f, -1.71442404e-01f, -2.05169141e-01f, -6.97412565e-02f, -3.29991169e-02f, -2.59755012e-02f, 8.61208141e-03f, 5.50741553e-02f, 1.30062804e-01f, 1.42069250e-01f,
  4.12755013e-02f, -3.89209576e-02f, 7.44792745e-02f, -6.07827418e-02f, -2.79463027e-02f, -9.15338024e-02f, -2.88760513e-02f, -8.36515203e-02f, -7.30558783e-02f, -2.33898889e-02f,
  2.36309737e-01f, -1.73694808e-02f, 3.39592732e-02f, 1.65538583e-02f, -1.21666819e-01f, -4.15233448e-02f, -1.61588088e-01f, -3.34555320e-02f, -5.22464067e-02f, -2.10880339e-02f,
  6.16255589e-02f, 4.83005540e-03f, 6.83129008e-04f, 5.41158840e-02f, -1.41953632e-01f, -4.43873703e-02f, -3.97411101e-02f, -1.23499148e-01f, -4.13606688e-02f, -4.47823592e-02f,
  -1.57595780e-02f, -6.76852241e-02f, 2.72754370e-03f, -6.22712299e-02f, -1.18091345e-01f, -4.90137301e-02f, -7.32188970e-02f, 1.69825591e-02f, -9.86778084e-03f, -3.11056785e-02f,
  1.80093404e-02f, 4.75406833e-02f, -1.89155601e-02f, 2.45726500e-02f, -5.19692674e-02f, 3.98931392e-02f, 1.78299081e-02f, 4.72550690e-02f, 3.83473933e-02f, -1.29486650e-01f,
  -1.96066760e-02f, 3.56646888e-02f, 1.44041419e-01f, -9.32286456e-02f, 2.92676464e-02f, -1.17957396e-02f, -1.22875646e-01f, 1.66000947e-02f, -5.70326187e-02f, 7.08354823e-03f,
  -3.27732384e-01f, 2.23894760e-01f, -9.12952572e-02f, -5.60654514e-02f, -6.06818385e-02f, -1.26864865e-01f, 8.25801492e-02f, 1.13740534e-01f, -5.78667819e-02f, -9.69480164e-03f,
  1.07855976e-01f, -1.97173785e-02f, 7.68888667e-02f, -7.67771378e-02f, -5.95537685e-02f, 1.80879831e-02f, 1.18612304e-01f, 6.45775720e-02f, 1.34415459e-02f, -1.58044130e-01f,
  -3.67948040e-02f, -9.21653956e-02f, -6.64966553e-02f, -1.02294490e-01f, -9.88062695e-02f, -1.71862915e-01f, -1.27675608e-02f, -2.21311823e-01f, -6.96358904e-02f, -1.17633082e-01f,
  -2.78019547e-01f, -1.36935636e-01f, 1.38604462e-01f, 3.93785313e-02f, -1.14923045e-01f, -2.24913225e-01f, -3.98282468e-01f, -3.31176519e-01f, -9.52010788e-03f, -2.42620870e-01f,
  -6.85385838e-02f, 2.92799603e-02f, 3.02688554e-02f, -1.88098010e-02f, -2.14796305e-01f, -2.60005146e-01f, -7.47654885e-02f, 1.58537291e-02f, 3.40742432e-02f, -7.95939192e-02f,
  -7.62292668e-02f, 5.74625619e-02f, 1.53749049e-01f, 1.10114634e-01f, 1.07461631e-01f, 2.28153486e-02f, 1.39881715e-01f, -5.69401160e-02f, -1.79258082e-02f, 9.93914381e-02f,
  2.77287006e-01f, -2.11947225e-02f, 1.09571241e-01f, 1.72386438e-01f, 1.75447330e-01f, 2.83119399e-02f, 9.15848017e-02f, -2.63177184e-03f, 2.10235808e-02f, 1.29255816e-01f,
  1.24874962e-02f, 1.04654729e-01f, -5.88536300e-02f, 7.59181520e-03f, 3.40634957e-02f, 7.76439672e-03f, -2.86686737e-02f, -5.82978688e-02f, 2.73927506e-02f, 1.32963389e-01f,
  6.79239184e-02f, 2.98843011e-02f, -4.19792160e-02f, 7.04821083e-04f, -5.52201979e-02f, -1.68953203e-02f, 3.06809563e-02f, -5.46830744e-02f, 2.48414576e-02f, -1.38797581e-01f,
  -1.53323695e-01f, -1.31931886e-01f, 4.70660217e-02f, -9.95718911e-02f, -1.20900989e-01f, -6.78512529e-02f, -7.80388266e-02f, -1.47860572e-01f, 1.70570780e-02f, -3.15924399e-02f,
  6.02781288e-02f, -9.30663645e-02f, -1.07797407e-01f, -9.46553424e-02f, 1.67066067e-01f, -5.81343658e-03f, -2.27062516e-02f, 3.49135958e-02f, 2.04288602e-01f, 5.74048609e-02f,
  -5.11274487e-02f, -8.96050967e-03f, 1.49994180e-01f, 6.37188554e-03f, 9.32155773e-02f, 6.98887482e-02f, 1.42263146e-02f, 1.56035209e-02f, 1.97198484e-02f, -5.24038337e-02f,
  -1.72226224e-02f, 1.83728993e-01f, 3.42761241e-02f, -6.97553114e-05f, -2.34742556e-02f, 2.00460613e-01f, 1.30858526e-01f, 1.25404164e-01f, 1.82667404e-01f, 1.27786070e-01f,
  6.93544745e-02f, -3.88974324e-02f, 1.44167274e-01f, -4.02620770e-02f, 1.33427558e-02f, 7.98179358e-02f, 1.56251080e-02f, -5.08741774e-02f, 1.02282546e-01f, 2.13835344e-01f,
  1.10592572e-02f, -6.05952516e-02f, -1.50727883e-01f, -6.15779944e-02f, -7.43582398e-02f, -6.09190688e-02f, -5.74948229e-02f, -4.91719767e-02f, -2.33144835e-02f, -2.36535981e-01f,
  1.75406113e-01f, 3.53779234e-02f, 1.35360315e-01f, 2.63446361e-01f, 2.29941234e-01f, 1.62512004e-01f, 1.30617321e-01f, 1.67625889e-01f, 6.67867735e-02f, 1.44901186e-01f,
  1.41270563e-01f, -9.08602029e-02f, 7.47980848e-02f, -8.76876712e-02f, 1.54113341e-02f, 7.56816715e-02f, 1.22627303e-01f, 1.83691829e-02f, 6.67461008e-02f, 1.49175704e-01f,
  1.30806804e-01f, 7.82103166e-02f, 5.66529930e-02f, 1.29505917e-01f, 1.70526937e-01f, 5.77119850e-02f, 5.56662381e-02f, 1.10880909e-02f, 7.41708267e-04f, 6.63951486e-02f,
  -6.95489347e-02f, 1.91651329e-01f, -1.28182694e-01f, -8.59247446e-02f, -4.65177409e-02f, -6.72451407e-02f, 1.99669730e-02f, -2.21508984e-02f, 7.75155844e-03f, -1.04680590e-01f,
  -1.02888681e-01f, -9.82155949e-02f, 1.11228367e-02f, -6.98577687e-02f, 2.31456179e-02f, 9.78755802e-02f, 2.15418488e-02f, -5.14622219e-02f, -5.04161380e-02f, -6.58453405e-02f,
  -2.77301688e-02f, -5.05484045e-02f, 1.27231836e-01f, 7.94173256e-02f, 5.67449778e-02f, 1.08380057e-01f, 3.88300754e-02f, 1.59057211e-02f, -3.60601395e-02f, -3.00100222e-02f,
  -5.58715463e-02f, 1.01940274e-01f, 1.41674295e-01f, 9.25885960e-02f, 6.40665591e-02f, 1.29910260e-01f, 3.05839367e-02f, 2.63446979e-02f, 1.19241789e-01f, -3.86582501e-02f,
  2.15778761e-02f, -3.08716539e-02f, -1.42593294e-01f, 1.08203199e-02f, -3.15455720e-02f, 3.86256464e-02f, -4.42027338e-02f, -5.35943545e-02f, 1.80354372e-01f, 5.31328656e-02f,
  4.87116724e-02f, -4.61510606e-02f, -2.55033094e-02f, 1.01450883e-01f, -2.50644889e-02f, -3.09806149e-02f, -3.51555017e-03f, 3.15741710e-02f, 1.58865154e-02f, -8.94264132e-02f,
  -1.50743097e-01f, 9.56004262e-02f, -1.38547942e-01f, 2.65442710e-02f, -1.60144661e-02f, -1.65509477e-01f, 6.77857697e-02f, -7.78828412e-02f, -4.04376015e-02f, -6.27542809e-02f,
  3.66215920e-03f, 1.92297704e-03f, -1.34266183e-01f, -1.02946915e-01f, -1.68363318e-01f, -1.01457842e-01f, 8.61262251e-03f, 1.18312528e-02f, -1.14566311e-01f, -2.03831464e-01f,
  -4.75020930e-02f, -1.31753474e-01f, -1.34307772e-01f, -6.23863712e-02f, -1.14056831e-02f, -1.21657453e-01f, -9.37441587e-02f, -2.75942646e-02f, -8.87939483e-02f, -9.29460078e-02f,
  -8.51403922e-03f, 9.18826535e-02f, 1.01361208e-01f, 6.35954812e-02f, -2.96522789e-02f, -2.64760442e-02f, -4.75548841e-02f, -2.62812436e-01f, -1.68629155e-01f, 7.43290260e-02f,
  1.52874753e-01f, -4.82516550e-02f, 3.92693467e-02f, -2.01738887e-02f, -1.73482791e-01f, -2.47912090e-02f, 9.58225429e-02f, 3.42153497e-02f, -1.51246607e-01f, -1.27832249e-01f,
  -2.57993974e-02f, 1.37140289e-01f, 5.65268472e-02f, -8.49604532e-02f, 1.80477530e-01f, -1.46765411e-01f, 1.41845539e-01f, 9.44020376e-02f, 1.76418036e-01f, 1.68326125e-01f,
  2.09673986e-01f, 1.66645631e-01f, 2.11015642e-02f, 4.69318554e-02f, 1.56803027e-01f, -1.14977479e-01f, -1.68941975e-01f, 6.23191893e-02f, -1.55702323e-01f, 5.54864295e-02f,
  1.72903314e-01f, -1.65424962e-02f, 3.82417105e-02f, -7.36099929e-02f, -4.87142727e-02f, -1.46092653e-01f, 5.61853945e-02f, -5.37071656e-03f, -5.65182120e-02f, -6.12587370e-02f,
  7.32325613e-02f, 1.30833670e-01f, 1.34091184e-01f, -6.69669509e-02f, 5.58369048e-02f, -9.22273844e-02f, 5.75452745e-02f, -5.38697056e-02f, -9.86163020e-02f, -3.03845443e-02f,
  2.16386300e-02f, 1.16982043e-01f, -1.19613193e-01f, 6.20644055e-02f, 2.49658562e-02f, 2.03825012e-02f, 4.57912832e-02f, -1.86880734e-02f, 2.88081039e-02f, 1.20320149e-01f,
  -8.33217576e-02f, -3.68417352e-02f, -3.21269855e-02f, 4.05978970e-02f, -2.39564832e-02f, 5.66102862e-02f, -4.84894067e-02f, -5.57574481e-02f, 2.71290038e-02f, -2.11473443e-02f,
  -4.33606692e-02f, 7.14212507e-02f, -1.19154891e-02f, -5.36238402e-02f, 2.79546995e-02f, 4.20605727e-02f, -2.19874433e-03f, -4.14708890e-02f, -5.72978817e-02f, 2.19605669e-01f,
  -1.67002380e-01f, 2.10163310e-01f, -5.47392257e-02f, -6.89249933e-02f, 6.44446462e-02f, -1.77782163e-01f, 1.34625332e-02f, -3.63206081e-02f, 5.58672510e-02f, 1.69364046e-02f,
  -6.37220889e-02f, 1.65604837e-02f, 6.19759075e-02f, -4.36831228e-02f, -1.13231607e-01f, 3.56812999e-02f, -8.13551527e-03f, -1.12949394e-01f, -5.20662703e-02f, 2.78206598e-02f,
  -9.97439399e-02f, -1.88747182e-01f, -1.21548519e-01f, -8.71245041e-02f, -6.89608417e-03f, -9.43471044e-02f, -6.87847212e-02f, -3.61174382e-02f, -2.37679631e-01f, -1.24830313e-01f,
  -4.22322363e-01f, -4.18496020e-02f, 1.85255721e-01f, -3.57598327e-02f, 2.68254429e-01f, 2.84958571e-01f, 3.32969517e-01f, 1.22298807e-01f, -6.80634603e-02f, -5.29326797e-02f,
  -6.11949041e-02f, -3.03241163e-01f, -1.40555784e-01f, -7.19078481e-02f, 1.07932560e-01f, 2.34730676e-01f, 1.87846541e-01f, 4.64832075e-02f, -9.06584114e-02f, 2.97683887e-02f,
  8.46606493e-03f, -6.61616325e-02f, -1.06480144e-01f, -1.06987543e-01f, -1.07013971e-01f, -1.02112688e-01f, 4.21241410e-02f, 1.05195016e-01f, -2.54368037e-02f, 6.90048262e-02f,
  1.35794342e-01f, -4.48956713e-02f, -9.90084708e-02f, -1.40770108e-01f, 4.59547378e-02f, -1.37510255e-01f, -8.07510391e-02f, -1.32483795e-01f, -1.09166324e-01f, 2.67319530e-02f,
  2.90455502e-02f, -6.96680695e-02f, 4.31977957e-02f, 1.14218011e-01f, 1.51330680e-01f, -1.18070953e-02f, -8.76050591e-02f, 1.19981110e-01f, 1.40353471e-01f, 1.53483823e-03f,
  7.10797533e-02f, 1.23738199e-01f, 2.03760773e-01f, 1.49882063e-01f, 1.43542945e-01f, 1.21445276e-01f, 4.17382494e-02f, -3.94568555e-02f, 5.35382815e-02f, -3.72655466e-02f,
  2.79517509e-02f, 8.31420440e-03f, -4.49986197e-02f, -5.64180724e-02f, -3.15367579e-02f, -5.84805757e-02f, 1.76129900e-02f, 5.30865565e-02f, 1.73063755e-01f, 6.09241836e-02f,
  -3.10929455e-02f, 2.18852386e-02f, 1.07052699e-01f, -8.58967751e-02f, -1.81729242e-01f, 6.82213902e-02f, 5.60847819e-02f, -1.62478894e-01f, -2.17707325e-02f, -9.07741413e-02f,
  -5.65087236e-02f, 1.17192395e-01f, -4.57630642e-02f, 8.05983916e-02f, 2.18867827e-02f, -1.12515435e-01f, -1.54126780e-02f, 8.17673467e-03f, 8.12686700e-03f, -7.27679506e-02f,
  1.29518688e-01f, -5.26356548e-02f, 1.11806737e-02f, -7.84877911e-02f, -5.83454072e-02f, -1.65096477e-01f, -2.15190798e-01f, -3.11808381e-02f, -1.63342394e-02f, -3.91013287e-02f,
  -7.70419165e-02f, -9.77817327e-02f, 5.83185405e-02f, 6.82839658e-03f, 5.08099534e-02f, -8.65172371e-02f, -1.32687300e-01f, -1.00413971e-02f, 3.28523293e-02f, 9.21949074e-02f,
  -2.31396370e-02f, -1.48977125e-02f, 7.51649635e-03f, -8.52076635e-02f, 1.16801159e-02f, 3.88061032e-02f, -5.79612404e-02f, -4.05010022e-02f, 1.40728548e-01f, -1.20572753e-01f,
  -2.77346577e-02f, 3.66756409e-01f, 1.50582239e-01f, -1.88580900e-01f, 8.54717642e-02f, 1.57235652e-01f, 3.97157103e-01f, 1.34078026e-01f, -1.35485992e-01f, 1.81996480e-01f,
  1.75440207e-01f, -1.15126982e-01f, 1.47558134e-02f, -9.98339131e-02f, 2.38375887e-02f, 7.31430128e-02f, -4.71466733e-03f, -5.21169864e-02f, -2.89223105e-01f, -1.14600837e-01f,
  -4.07647118e-02f, -5.54008335e-02f, -7.91358128e-02f, -2.14391872e-01f, -1.19746581e-01f, -1.20543443e-01f, 9.38913524e-02f, 1.20763838e-01f, 9.41564888e-02f, -3.53777073e-02f,
  1.46493167e-01f, 2.88284421e-01f, -2.75627635e-02f, -4.59812023e-02f, 1.37860875e-03f, -1.53521076e-01f, 1.26671558e-02f, 5.24612516e-02f, 5.19483201e-02f, -7.41033927e-02f,
  1.50369257e-01f, 9.34514105e-02f, 1.16940230e-01f, -3.06006316e-02f, 4.14867513e-02f, 3.53719629e-02f, -4.28148098e-02f, -1.42587021e-01f, -1.36143640e-01f, -4.52749282e-02f,
  4.55074348e-02f, 1.84913224e-03f, 1.95505410e-01f, -3.32897506e-03f, 4.90960479e-03f, -1.38520285e-01f, -3.80162708e-02f, -1.04411341e-01f, -6.47476614e-02f, -1.19535670e-01f,
  5.86412437e-02f, 6.26939088e-02f, -4.41201963e-02f, -2.40899529e-02f, -7.06531554e-02f, 1.01823732e-01f, 6.30044416e-02f, -1.21322855e-01f, -1.08858220e-01f, 1.17652625e-01f,
  1.02911042e-02f, 4.27512303e-02f, 2.67043021e-02f, 6.13388158e-02f, 4.32039052e-02f, -8.62588699e-04f, 5.40395034e-04f, -6.91599995e-02f, 1.01089448e-01f, -1.15670310e-02f,
  -1.26393348e-01f, 6.75569624e-02f, 2.97079124e-02f, -1.71227261e-01f, 5.58109209e-02f, 1.80705078e-02f, -3.39617860e-03f, -5.59598841e-02f, 2.95199221e-03f, 1.33713305e-01f,
  -3.23018461e-01f, 1.44033298e-01f, -9.91042256e-02f, 6.22177459e-02f, 1.36830136e-01f, 3.04626748e-02f, 1.17442183e-01f, 7.45426863e-02f, 3.87855023e-02f, -8.06539655e-02f,
  2.33396143e-02f, 4.01822738e-02f, 1.09017834e-01f, -4.70109656e-02f, -6.57236204e-02f, -6.49512112e-02f, 6.84178546e-02f, -9.65573415e-02f, -4.79839407e-02f, -9.38680768e-02f,
  -9.51481760e-02f, -2.42423877e-01f, -3.04337204e-01f, 4.49739676e-03f, -3.52740623e-02f, -1.75494388e-01f, -3.70133184e-02f, -1.22661337e-01f, -8.55038762e-02f, -2.16640770e-01f,
  -1.53107420e-01f, 2.44110059e-02f, 6.83822557e-02f, 2.51120366e-02f, 7.43180588e-02f, 9.35873613e-02f, 8.94378275e-02f, 5.05609140e-02f, 6.88138232e-02f, 1.94569100e-02f,
  -1.88410237e-01f, -1.41310707e-01f, -9.64570418e-02f, 5.72205558e-02f, -4.25100550e-02f, 2.12206766e-01f, 1.83627158e-01f, 1.15616530e-01f, 1.24464914e-01f, 6.24060305e-03f,
  9.36731547e-02f, 6.57754391e-02f, -5.82910106e-02f, 1.15044098e-02f, 2.04831809e-01f, 8.57720375e-02f, 1.15627848e-01f, 1.66676581e-01f, -1.31825311e-02f, 3.49757552e-01f,
  2.66122460e-01f, 1.17273275e-02f, -1.31797642e-01f, -1.56994283e-01f, -3.21712978e-02f, -2.13847145e-01f, -4.32469398e-02f, -1.27265034e-02f, -6.84921816e-02f, -1.88627198e-01f,
  -2.74755731e-02f, -6.90526664e-02f, 2.25240574e-03f, -1.20399721e-01f, -6.83960691e-02f, -1.37048975e-01f, -1.65678844e-01f, 1.62097663e-02f, 7.37871677e-02f, -4.32120189e-02f,
  -6.34738132e-02f, -1.14797622e-01f, -2.74024364e-02f, -1.34481698e-01f, -7.75617734e-02f, 9.30401962e-03f, 1.45963272e-02f, -3.12814601e-02f, -1.08679697e-01f, -1.06517442e-01f,
  -7.73985311e-02f, -4.76145372e-02f, 9.19679478e-02f, -4.86896075e-02f, -2.11245462e-01f, -8.31842646e-02f, 4.28653248e-02f, -1.50210962e-01f, -9.14985612e-02f, -1.01117708e-01f,
  -9.62710232e-02f, -1.04617447e-01f, -1.13404892e-01f, -4.87644039e-02f, 6.38878066e-03f, 1.33299604e-02f, -4.30870429e-02f, -2.09951177e-02f, -9.41018462e-02f, -7.48062879e-02f,
  5.44501990e-02f, -5.41344881e-02f, -2.00875271e-02f, 3.19016390e-02f, 3.32737491e-02f, 3.15418467e-03f, -1.15296282e-01f, -1.66642174e-01f, -4.90105003e-02f, -7.51635507e-02f,
  1.87604964e-01f, -5.02523817e-02f, -6.14417009e-02f, 1.06081530e-01f, 1.36735022e-01f, -7.75192827e-02f, 9.69088227e-02f, 5.58046512e-02f, 1.21562645e-01f, -5.58936372e-02f,
  1.19873464e-01f, 9.11329407e-03f, -5.95272295e-02f, 3.46375890e-02f, 6.24875985e-02f, 5.88633306e-02f, -7.48688504e-02f, 7.54550621e-02f, 3.66575308e-02f, 7.25703537e-02f,
  -4.10610856e-03f, -1.36514641e-02f, 3.00082825e-02f, -1.06747776e-01f, 3.80532406e-02f, 4.17420350e-04f, 1.12369165e-01f, 6.99734241e-02f, -1.66979397e-03f, -6.36570007e-02f,
  -4.13138926e-01f, -2.70944744e-01f, -3.25877033e-02f, 5.54891825e-02f, 6.03789799e-02f, -4.87474389e-02f, -2.20371142e-01f, -1.43283933e-01f, 1.25151902e-01f, -1.14608198e-01f,
  -1.03718869e-01f, -2.23726798e-02f, -2.73628056e-01f, -1.00882784e-01f, -7.66724944e-02f, -2.63526857e-01f, -2.02191263e-01f, -3.42330076e-02f, 9.36644971e-02f, 1.94548145e-01f,
  5.12919091e-02f, 2.35701595e-02f, 6.79010823e-02f, 1.01698153e-01f, 3.60423103e-02f, -1.74003839e-02f, 2.81424299e-02f, -2.09487230e-02f, 2.03813203e-02f, -2.07611099e-01f,
  -2.63003230e-01f, -1.16216326e-02f, 9.86908972e-02f, -4.66503687e-02f, -8.26991051e-02f, -6.74821660e-02f, -8.84354189e-02f, -2.90870927e-02f, 2.17788219e-02f, -5.94475120e-02f,
  1.84419364e-01f, 2.99298801e-02f, -1.06062204e-01f, 5.26244976e-02f, -7.15818256e-03f, 9.26569328e-02f, 2.19323903e-01f, -2.27131415e-02f, -8.40850398e-02f, 3.90284657e-02f,
  1.31684229e-01f, -2.03739572e-02f, -5.61957285e-02f, -5.85621521e-02f, 1.12188250e-01f, 1.07582264e-01f, 1.71951786e-01f, 1.72964469e-01f, 1.46999151e-01f, -5.31825013e-02f,
  2.08995610e-01f, -6.82167932e-02f, 5.94670661e-02f, 4.61018906e-04f, 2.65130717e-02f, -4.43681516e-02f, -4.07336000e-03f, 1.34751629e-02f, -1.24383960e-02f, 3.84080224e-02f,
  4.75808606e-02f, -8.49632826e-03f, -1.27952574e-02f, -6.85688406e-02f, 3.62475216e-02f, -4.15797457e-02f, 3.55457552e-02f, -3.98379415e-02f, 1.94085296e-02f, 4.28049527e-02f,
  1.18817881e-01f, -2.91002430e-02f, 7.12350234e-02f, 2.44528428e-02f, -8.92216116e-02f, 1.43145978e-01f, 1.48311883e-01f, 1.03583097e-01f, 7.97657743e-02f, 4.61763367e-02f,
  -1.26872227e-01f, -4.64946628e-02f, -1.30001932e-01f, -1.09960757e-01f, 3.14775221e-02f, 1.03092380e-01f, -4.29332070e-02f, 6.67865276e-02f, 4.25939038e-02f, 4.87769321e-02f,
  1.16652541e-01f, -8.01177174e-02f, -6.91617355e-02f, 7.22617134e-02f, -9.63905901e-02f, 1.02931205e-02f, 9.47754607e-02f, -1.37571583e-03f, -3.58075313e-02f, 1.71083659e-01f,
  -7.21641406e-02f, -1.36448130e-01f, -1.38076633e-01f, -1.37315556e-01f, -6.75118193e-02f, -1.57642052e-01f, -1.39028355e-01f, -1.14350609e-01f, -6.87250644e-02f, -2.13995039e-01f,
  6.66254103e-01f, 1.17076784e-01f, 1.94079593e-01f, 1.88632216e-02f, -2.18614161e-01f, -1.40695751e-01f, 4.17950936e-02f, 1.17123649e-01f, -9.46941413e-03f, 2.52866186e-02f,
  1.87434983e-02f, 9.54986811e-02f, -2.60066111e-02f, 2.66788825e-02f, 1.75331607e-01f, 1.40282661e-01f, 5.88253401e-02f, 2.45110720e-01f, 3.46480072e-01f, 2.37761468e-01f,
  2.90864650e-02f, 1.42443687e-01f, 2.71683395e-01f, 2.33993784e-01f, 9.62718204e-02f, -1.11456066e-02f, -1.41804386e-03f, 1.47110999e-01f, 8.15711915e-02f, 1.34962782e-01f,
  1.21063448e-01f, 2.89243370e-01f, -4.48859371e-02f, -6.25909343e-02f, -7.38946870e-02f, 1.34137973e-01f, -1.70200802e-02f, 9.91135370e-03f, -8.44039619e-02f, -1.18866704e-01f,
  -3.36452983e-02f, 7.30378032e-02f, -3.96866351e-02f, 2.21745241e-02f, -9.80895460e-02f, -1.59972943e-02f, -3.77310626e-02f, 1.04895078e-01f, -5.73404739e-03f, -4.61257994e-02f,
  1.51447896e-02f, 4.18571308e-02f, -4.57126871e-02f, 3.10815107e-02f, 7.52747655e-02f, -1.94460098e-02f, 1.98063497e-02f, 1.43595263e-01f, 1.29808366e-01f, 7.62205422e-02f,
  -9.41977929e-03f, 8.38309079e-02f, 6.98497742e-02f, 1.73005983e-01f, 3.19800600e-02f, -7.42824897e-02f, 2.34050229e-02f, -6.15957193e-02f, 3.83251831e-02f, 9.57961902e-02f,
  5.33118621e-02f, 1.11627564e-01f, 7.73696676e-02f, 5.76669015e-02f, 4.74539027e-02f, -1.38232252e-02f, -4.08088341e-02f, -2.76454096e-03f, -4.00776491e-02f, -5.31295687e-02f,
  1.39430180e-01f, 1.41201869e-01f, -7.31632710e-02f, 1.21647799e-02f, 8.80766734e-02f, 3.42161432e-02f, -2.77896952e-02f, 1.64727196e-02f, -6.86610788e-02f, 6.20961450e-02f,
  -5.19043863e-01f, -9.77566615e-02f, 1.62608195e-02f, 4.53597382e-02f, 6.62242845e-02f, 1.72280185e-02f, -8.02206248e-02f, -1.18320771e-01f, -2.72666007e-01f, -1.57213092e-01f,
  -1.00712478e-01f, 3.47904302e-02f, -8.08087662e-02f, 6.34777173e-02f, 3.08126621e-02f, -5.70748337e-02f, -1.75067633e-02f, -4.02405076e-02f, -3.18647660e-02f, -2.13266164e-02f,
  -5.25315404e-02f, -9.40250680e-02f, -1.11041263e-01f, -1.45737052e-01f, -4.71222438e-02f, -5.47656305e-02f, -8.98220912e-02f, 2.57838685e-02f, -1.18284740e-01f, -3.31370495e-02f,
  -8.83124098e-02f, -1.76440120e-01f, 4.49700318e-02f, 8.76148343e-02f, 1.96255878e-01f, 2.87415296e-01f, 1.90022707e-01f, 5.89356087e-02f, -3.31469392e-03f, -2.36168969e-02f,
  -3.41614991e-01f, -2.91940928e-01f, -2.09013507e-01f, -1.34219572e-01f, -1.11989856e-01f, 2.88370967e-01f, 1.36729226e-01f, 7.37469196e-02f, 1.06721275e-01f, 6.47328794e-02f,
  2.99559124e-02f, 4.62919287e-02f, -1.28699630e-01f, -1.34419695e-01f, -5.59782609e-02f, -2.01918818e-02f, 5.13249300e-02f, 5.98280765e-02f, 4.17783707e-02f, -8.73835087e-02f,
  -2.13213727e-01f, -1.36120841e-01f, 2.90122442e-02f, -1.00951940e-01f, -9.50570926e-02f, -1.29144222e-01f, -1.40579104e-01f, -7.93789178e-02f, -5.62553853e-02f, 1.01004437e-01f,
  1.76739141e-01f, -8.80806372e-02f, 8.09688214e-03f, 2.63363924e-02f, 4.36957218e-02f, 2.49664113e-02f, -3.23600285e-02f, -4.84865569e-02f, -1.66391894e-01f, -1.88654572e-01f,
  -5.32294251e-02f, 1.28630087e-01f, 1.48515821e-01f, 1.13900080e-01f, -5.83028942e-02f, -5.06638475e-02f, 1.36591494e-03f, -1.39494678e-02f, 1.29717020e-02f, 1.97278671e-02f,
  2.87077893e-02f, 3.78119573e-02f, 1.46244997e-02f, -2.78477985e-02f, 7.16515332e-02f, 2.35561863e-01f, 1.29201472e-01f, 5.79749048e-02f, 8.94413982e-03f, -4.05145623e-02f,
  -2.11192085e-03f, -2.24183258e-02f, 2.23664418e-02f, 3.20406519e-02f, -8.96599963e-02f, -6.95748255e-03f, -7.38038570e-02f, -5.85310645e-02f, -1.11806095e-01f, -1.14060894e-01f,
  -1.38096496e-01f, 6.53371736e-02f, -1.17348343e-01f, -9.67322811e-02f, -1.07836373e-01f, -4.12490591e-02f, -1.36116058e-01f, -1.83431536e-01f, -1.06538750e-01f, -8.20346922e-03f,
  -3.61021668e-01f, -1.26157239e-01f, 3.60544026e-02f, -1.51939303e-01f, -5.23192659e-02f, -2.31679320e-01f, -2.39288017e-01f, 2.23315153e-02f, 1.16890453e-01f, 9.16901454e-02f,
  4.09034677e-02f, 2.80674379e-02f, -1.00590870e-01f, 4.47790660e-02f, 2.10937604e-01f, 2.96133533e-02f, 1.12611149e-02f, 3.28713879e-02f, 3.04026306e-02f, -1.10902444e-01f,
  -5.33069260e-02f, 9.23012570e-02f, 1.26078859e-01f, 1.64476726e-02f, 1.04843788e-02f, 1.20039046e-01f, 1.05543539e-01f, 1.02208108e-01f, 1.39802188e-01f, 2.28442773e-01f,
  -2.43592188e-01f, -1.17914513e-01f, 2.64584363e-01f, -1.65377036e-02f, -2.08641365e-01f, -2.39174664e-01f, -4.78968978e-01f, -1.43595874e-01f, 5.57060651e-02f, -1.78708076e-01f,
  -7.44891763e-02f, 1.39017761e-01f, 1.65387630e-01f, 8.97433534e-02f, -1.46981224e-01f, -1.61184296e-01f, -6.60880357e-02f, 1.30956143e-01f, 1.28085297e-02f, -2.55275100e-01f,
  -1.13961972e-01f, 8.67311880e-02f, 1.91600263e-01f, 1.22503474e-01f, -4.05910797e-02f, 1.41373798e-01f, 2.64865071e-01f, 1.50997356e-01f, 6.88195825e-02f, 3.57176587e-02f,
  -3.14984731e-02f, -1.77714661e-01f, 1.66969951e-02f, -5.35272285e-02f, 4.25081737e-02f, -1.88496947e-01f, -1.03390940e-01f, 6.55874833e-02f, -8.97486880e-02f, 2.28830855e-02f,
  2.60995757e-02f, -8.97026062e-02f, -6.83873668e-02f, -2.80133002e-02f, 4.03589620e-05f, -1.63233325e-01f, -1.27031654e-01f, 2.97727007e-02f, 9.67359021e-02f, -2.30908722e-01f,
  -1.10321686e-01f, -1.41258061e-01f, -2.36816648e-02f, -2.48444639e-02f, -1.14673059e-02f, 2.76831146e-02f, 3.50097157e-02f, -7.25012943e-02f, 6.34216890e-02f, 9.35295597e-02f,
  -1.24460673e-02f, 5.92825003e-02f, 1.08520724e-01f, -1.12416841e-01f, -3.85814719e-02f, -8.47866610e-02f, -4.61616628e-02f, 1.04921952e-01f, 6.22758493e-02f, 5.31212166e-02f,
  -3.28799933e-02f, -1.00297809e-01f, 1.60568357e-02f, -3.76492292e-02f, 6.91228434e-02f, 7.33829103e-03f, -1.92979530e-01f, 2.07682345e-02f, 3.21394997e-03f, 1.20538566e-02f,
  1.51630118e-02f, 3.33897136e-02f, 2.05821246e-02f, -6.23146407e-02f, 2.51760222e-02f, -2.85439976e-02f, -3.81010734e-02f, -1.14210062e-01f, 1.03963219e-01f, -4.74827476e-02f,
  1.21468320e-01f, 1.50912330e-01f, -8.68891105e-02f, -7.09712878e-02f, -5.46530187e-02f, -7.39637911e-02f, 4.95384894e-02f, -3.05118412e-02f, 8.83900095e-03f, -4.27775010e-02f,
  -1.25015721e-01f, -1.75291479e-01f, -3.29109393e-02f, -2.29988974e-02f, -3.35270949e-02f, -6.06363267e-03f, -2.64226466e-01f, -9.81766172e-03f, -1.61698330e-02f, -6.96943179e-02f,
  -9.77151543e-02f, 6.84508262e-03f, -5.95212877e-02f, 7.50479773e-02f, 4.58677374e-02f, -1.54774770e-01f, 2.71531753e-02f, 4.91994014e-03f, -3.66252325e-02f, -5.12139872e-02f,
  -3.16428035e-01f, -1.70762856e-02f, -1.84555858e-01f, 7.45483264e-02f, 1.37398019e-01f, 9.30214375e-02f, 7.54733831e-02f, -1.80567324e-01f, 3.16881947e-02f, -1.26433641e-01f,
  1.26233861e-01f, 3.83149013e-02f, 6.92431927e-02f, 6.40244931e-02f, -5.77683561e-02f, -7.64002232e-03f, 9.36705023e-02f, 1.98677555e-02f, -9.87928808e-02f, 1.23087026e-01f,
  2.26265550e-01f, 2.04149354e-03f, -2.67800122e-01f, -1.07285850e-01f, 4.64068986e-02f, 1.58631206e-01f, -8.10150728e-02f, -6.32687360e-02f, 7.70232975e-02f, 2.97694772e-01f,
  -3.20521817e-02f, -2.83416092e-01f, 8.59275013e-02f, 1.97304323e-01f, 1.95170064e-02f, -1.91788837e-01f, -1.72160074e-01f, -4.84453700e-02f, 3.46017405e-02f, -8.65828767e-02f,
  6.32713214e-02f, -2.75050011e-02f, 1.51621297e-01f, 1.33537397e-01f, 3.11160982e-02f, -9.53685492e-02f, -8.47178139e-03f, -1.20127082e-01f, -1.52980700e-01f, -1.51194349e-01f,
  1.52827337e-01f, 1.22833356e-01f, -2.10988417e-01f, -1.13545738e-01f, -1.10048324e-01f, 3.52181382e-02f, -7.23277256e-02f, -8.83429796e-02f, -2.89712131e-01f, -2.06451774e-01f,
  2.51211263e-02f, -6.50834292e-02f, 1.06001794e-02f, -6.41805306e-02f, -1.18342293e-02f, -5.82414381e-02f, 1.96278900e-01f, -6.77256519e-03f, 1.13068745e-01f, -5.65693974e-02f,
  1.47812933e-01f, -1.33934513e-01f, 1.71880797e-02f, -6.58074021e-02f, -1.45687191e-02f, 5.02316169e-02f, -3.07237869e-03f, -3.71615179e-02f, 2.24389620e-02f, -1.08760282e-01f,
  3.39385942e-02f, -4.10749763e-03f, -5.24077266e-02f, 1.13592580e-01f, 5.38912416e-02f, -5.05419895e-02f, -1.06147155e-01f, -7.22329617e-02f, -1.58413157e-01f, -1.13586262e-01f,
  -1.55943364e-01f, 1.36445612e-01f, 2.75124243e-04f, 9.94945690e-02f, 2.14484166e-02f, 2.51697395e-02f, 2.89222728e-02f, 1.30110815e-01f, 4.47254628e-02f, 4.86332923e-02f,
  -1.03251189e-02f, 6.13931082e-02f, -7.90365934e-02f, 1.12903856e-01f, 8.31908211e-02f, 4.61894199e-02f, 1.17294513e-01f, 7.81971589e-02f, -3.59141305e-02f, -2.00238988e-01f,
  -8.54217708e-02f, -7.18697533e-02f, -1.71374619e-01f, 4.80171107e-02f, -1.03139974e-01f, 3.98690216e-02f, -5.50489649e-02f, 4.97292988e-02f, -2.27326348e-01f, -3.00568223e-01f,
  5.45147181e-01f, -4.88582999e-01f, -9.23456475e-02f, 7.86326155e-02f, 1.40884325e-01f, 1.32365152e-01f, -5.24617285e-02f, 3.70970033e-02f, 3.77397500e-02f, -1.96150705e-01f,
  -1.56509876e-01f, 1.02272764e-01f, 6.15808591e-02f, -2.42405813e-02f, 1.27866611e-01f, -1.94135860e-01f, 2.32968479e-03f, 2.60959893e-01f, 4.23143774e-01f, 2.16393784e-01f,
  -1.24981277e-01f, 9.14370716e-02f, 8.85135680e-02f, -2.59467904e-02f, -3.10747921e-01f, 5.53820804e-02f, -2.67684311e-01f, -1.98729649e-01f, -2.00736374e-01f, -3.32747072e-01f,
  -1.66629236e-02f, -2.40609664e-02f, 6.79536834e-02f, 6.89435378e-02f, -1.62730709e-01f, 1.00158909e-02f, 1.34379968e-01f, 5.05663734e-03f, 6.95907623e-02f, -9.37021151e-03f,
  -6.28327131e-02f, -8.28504413e-02f, 2.05419846e-02f, 5.79168880e-03f, -1.05243921e-01f, -3.57146934e-02f, -2.48161986e-01f, -8.20216313e-02f, -1.00022696e-01f, -1.83259532e-01f,
  -2.29515553e-01f, -1.10150181e-01f, 3.68455276e-02f, -5.02418205e-02f, -9.47899818e-02f, 2.38588303e-01f, -1.62669122e-01f, -9.46161225e-02f, -1.39732778e-01f, -1.91418529e-01f,
  -5.61508872e-02f, 9.11014713e-03f, -5.54523915e-02f, 5.21284230e-02f, 9.86529142e-03f, -1.30150830e-02f, -3.89933139e-02f, 3.93130705e-02f, 4.02524732e-02f, -6.81323484e-02f,
  -1.25466064e-01f, -3.20925675e-02f, 9.68071911e-03f, 2.36541443e-02f, -5.14623635e-02f, -1.11326883e-02f, 4.20554951e-02f, 2.32336391e-02f, -8.64467025e-03f, 9.96197388e-02f,
  -4.19107080e-02f, 2.21164594e-03f, 9.50945541e-03f, -1.39680877e-03f, -1.80172380e-02f, -6.25478923e-02f, 1.25768766e-01f, 5.14326282e-02f, 1.43094109e-02f, 3.24560665e-02f,
  1.20963909e-01f, 1.52392611e-01f, 7.27841333e-02f, 1.07332706e-01f, 4.96480940e-03f, 1.38443056e-02f, 3.02740671e-02f, 7.40320329e-03f, -3.28872949e-02f, 3.92925069e-02f,
  1.11558795e-01f, 1.36494130e-01f, -3.15415263e-02f, -1.56339649e-02f, 3.54015678e-02f, 3.55334394e-02f, -7.22186342e-02f, 1.18147902e-01f, 1.83115050e-03f, -1.59706667e-01f,
  1.79227442e-02f, 2.61671320e-02f, 1.90456823e-01f, 7.78806880e-02f, 1.07336722e-01f, 2.83535361e-01f, 8.32806528e-02f, 6.55177906e-02f, 1.91642687e-01f, 1.02651753e-02f,
  7.38630071e-02f, -3.00355703e-01f, 2.81596929e-01f, 2.86359131e-01f, 2.18039021e-01f, 2.68217266e-01f, 2.44882986e-01f, 7.87720978e-02f, 5.51234111e-02f, -2.08722632e-02f,
  -1.47269174e-01f, -1.91348772e-02f, -1.41209319e-01f, -1.35281205e-01f, -2.33308021e-02f, -1.11421542e-02f, 1.81271225e-01f, 8.51387754e-02f, 2.86637485e-01f, 1.14195250e-01f,
  1.90853998e-02f, -7.94816315e-02f, -1.08332641e-01f, -3.30162123e-02f, -1.44042075e-02f, -1.05707569e-03f, -4.08752412e-02f, -1.60342619e-01f, -1.28859580e-01f, -1.05349235e-01f,
  -2.08524913e-02f, -1.03186123e-01f, 1.41055167e-01f, -2.30882347e-01f, -1.98101193e-01f, -1.19968832e-01f, -2.64747757e-02f, -7.96511620e-02f, -7.67612234e-02f, -6.62076250e-02f,
  -1.58126801e-01f, -1.29179180e-01f, 6.41570687e-02f, -3.70460376e-02f, -3.00831981e-02f, 4.07316163e-02f, -1.04633540e-01f, -1.37129143e-01f, -1.30205646e-01f, -1.05642423e-01f,
  -1.65379256e-01f, -1.16011025e-02f, 8.28063115e-02f, 6.86184168e-02f, 4.38465402e-02f, -3.34305167e-02f, 2.67205853e-02f, -3.14641669e-02f, -5.30229099e-02f, -1.26788542e-01f,
  -5.68566360e-02f, -1.86155830e-02f, -4.40024100e-02f, 2.97910329e-02f, -5.86753187e-04f, 6.80436715e-02f, 1.37465715e-01f, -1.22114338e-01f, 1.04768284e-01f, 5.59329800e-02f,
  1.87484194e-02f, 2.42585093e-02f, -3.09991278e-02f, -5.83045706e-02f, 5.78918606e-02f, 2.97495369e-02f, 8.68540071e-03f, -6.34293705e-02f, -3.05507164e-02f, 5.19167744e-02f,
  1.20819494e-01f, -1.96314901e-02f, 8.71863440e-02f, 7.17655346e-02f, 3.69231999e-02f, 3.07460856e-02f, 1.29654869e-01f, -6.70791566e-02f, 3.63186374e-02f, 2.85721440e-02f,
  -1.78656906e-01f, -8.99622589e-02f, 1.09579004e-02f, -3.30263823e-02f, -1.22260019e-01f, -1.27734661e-01f, 1.37481034e-01f, -5.01622893e-02f, -7.38432258e-02f, -4.73297425e-02f,
  5.47248535e-02f, -4.43763062e-02f, -6.65836707e-02f, -8.67357254e-02f, 1.29915401e-01f, 8.31617787e-02f, -7.33931661e-02f, -2.47018933e-02f, 1.00094173e-02f, -7.20672160e-02f,
  -9.66988280e-02f, 3.44884954e-02f, 4.16602232e-02f, 1.97204158e-01f, 1.04324065e-01f, 1.22026026e-01f, 1.90083068e-02f, 1.19301133e-01f, 9.27766319e-03f, 2.56650150e-03f,
  3.40787053e-01f, 1.38146859e-02f, 2.85845309e-01f, -1.09918788e-02f, -4.18777943e-01f, -2.32404813e-01f, -1.81469366e-01f, -1.20178215e-01f, 3.53152417e-02f, -1.18635567e-02f,
  -3.40780109e-01f, -2.59548575e-01f, -1.04315720e-01f, -2.65434068e-02f, 3.90905887e-02f, 1.31122395e-01f, 1.07312851e-01f, 2.65570879e-01f, 8.32579806e-02f, -1.88664496e-01f,
  -2.16052398e-01f, 2.36762255e-01f, 2.69385844e-01f, 1.79724351e-01f, 5.88474199e-02f, -5.27369529e-02f, 1.27237678e-01f, 6.63785040e-02f, -1.69967953e-02f, 2.24267811e-01f,
  -1.40789235e-02f, -3.25973816e-02f, -8.08873624e-02f, -5.94408736e-02f, 1.29139340e-02f, 6.94625080e-02f, -5.89571595e-02f, 2.08424851e-01f, -1.43696785e-01f, 4.66860831e-02f,
  -2.02096432e-01f, -1.02539338e-01f, 1.48540875e-02f, -6.27802014e-02f, -5.98672079e-03f, -6.15267195e-02f, 2.07965568e-01f, 1.97423831e-01f, 2.51940936e-01f, 6.90090358e-02f,
  -1.59193844e-01f, -2.06197396e-01f, -9.29277167e-02f, -1.66927502e-01f, 3.20525989e-02f, -1.51640445e-01f, -1.22948445e-01f, -9.35995206e-02f, 4.47883792e-02f, 9.12814289e-02f,
  -1.13835372e-01f, -1.81486793e-02f, 1.52946925e-02f, -4.39255200e-02f, -7.92135224e-02f, -8.91585946e-02f, -5.66016547e-02f, -1.03464194e-01f, -1.45054579e-01f, -4.15419340e-02f,
  -1.14934854e-01f, 1.05186347e-02f, 4.68682311e-02f, 1.18561508e-02f, -7.99811482e-02f, 2.39590816e-02f, -9.27780196e-02f, 6.87254667e-02f, -6.57853559e-02f, -1.49596065e-01f,
  -6.19840547e-02f, -1.00759730e-01f, 1.53604588e-02f, 3.54704825e-04f, -4.28844057e-02f, 3.94618958e-02f, 8.34021643e-02f, -5.86180277e-02f, 1.21509261e-01f, 1.81194041e-02f,
  -1.19552523e-01f, -1.47244617e-01f, -5.18841147e-02f, -2.40153298e-02f, -2.97712404e-02f, -1.18360939e-02f, -9.56249535e-02f, -4.21352088e-02f, 1.48802614e-02f, 8.62863064e-02f,
  1.42746316e-02f, -1.28533244e-02f, -2.02603522e-03f, 6.43358156e-02f, -7.29994923e-02f, -8.78183544e-02f, -7.90897571e-03f, -2.35658735e-02f, 1.90667715e-02f, 7.33596608e-02f,
  7.55099207e-02f, -1.24229185e-01f, -1.99591488e-01f, -2.78839748e-02f, 1.33868903e-02f, -1.99270353e-01f, -1.03443429e-01f, -1.32047623e-01f, -9.08212140e-02f, 4.85768244e-02f,
  -2.82799721e-01f, -1.21620530e-02f, 8.16072449e-02f, -6.47981018e-02f, -7.04891309e-02f, 4.12795395e-02f, -2.21005872e-01f, 9.36534256e-02f, -1.69380126e-03f, -1.06580548e-01f,
  6.69309916e-03f, 1.17542729e-01f, 1.61269277e-01f, 1.67901758e-02f, -1.76869959e-01f, -2.18408391e-01f, -2.33209997e-01f, -7.79804513e-02f, 5.00926888e-03f, 8.82127360e-02f,
  -1.61916688e-02f, -1.02587052e-01f, -1.38947785e-01f, 5.50096110e-02f, 5.49369790e-02f, 6.03587143e-02f, -1.23742662e-01f, 9.27944630e-02f, 2.91499728e-03f, -1.06169850e-01f,
  1.31357789e-01f, 7.40998089e-02f, 1.41444113e-02f, 1.25643210e-02f, -1.10406429e-01f, -9.62209404e-02f, 4.35708351e-02f, -5.22761308e-02f, -8.14750567e-02f, -1.94818515e-03f,
  -4.62484173e-02f, -9.95878205e-02f, -2.58450061e-02f, 3.38407792e-02f, -3.78094465e-02f, -2.51716021e-02f, -3.69222984e-02f, -1.41751722e-01f, -1.93743989e-01f, 1.21275455e-01f,
  -8.93963277e-02f, -8.83966610e-02f, -2.44775061e-02f, 1.13899559e-02f, 5.75347692e-02f, -2.27114968e-02f, 1.17084384e-01f, 1.41316652e-02f, -1.57730449e-02f, -3.50983329e-02f,
  -9.23977345e-02f, 7.54922256e-02f, -8.54787603e-02f, -7.94788972e-02f, -4.02087420e-02f, 7.54638165e-02f, -2.08389405e-02f, -1.71383470e-01f, 7.46473819e-02f, 9.71212015e-02f,
  3.52940545e-03f, 4.35030237e-02f, -9.04985666e-02f, 2.99837701e-02f, -2.38846317e-02f, -4.76782247e-02f, -8.29202905e-02f, -2.07344547e-01f, -8.94844159e-02f, 3.30080688e-02f,
  -4.80071716e-02f, -6.58310950e-02f, -3.70494723e-02f, -8.69390648e-03f, -1.79091066e-01f, 9.54473391e-03f, -2.68496480e-02f, 5.04868701e-02f, 9.54102501e-02f, 1.02529526e-01f,
  3.66242938e-02f, -6.98393881e-02f, 8.53023976e-02f, 6.26142547e-02f, -1.34343743e-01f, -8.90397877e-02f, -4.33628000e-02f, -1.15297943e-01f, -4.69907671e-02f, 5.40209487e-02f,
  9.08511728e-02f, -2.30892189e-02f, -8.17695633e-02f, -1.16607528e-02f, -2.06917860e-02f, -4.62207831e-02f, -1.60394281e-01f, -7.93949217e-02f, -1.38954565e-01f, -3.04190218e-02f,
  -2.02027097e-01f, -1.38604134e-01f, -4.00587618e-02f, -3.42644081e-02f, -2.27506105e-02f, -4.26952802e-02f, 1.12003155e-01f, 1.89897846e-02f, -6.57909596e-03f, -8.87994170e-02f,
  -4.87967014e-01f, 5.73828779e-02f, -1.03722207e-01f, -2.72193581e-01f, 3.83462245e-03f, 1.38685346e-01f, 2.65987158e-01f, 6.26054183e-02f, -1.20895289e-01f, -5.86066283e-02f,
  -7.80366138e-02f, -1.32717013e-01f, -1.48141354e-01f, -2.86877360e-02f, -1.41999023e-02f, -2.58107726e-02f, -6.38790876e-02f, -1.54269725e-01f, 2.59449594e-02f, 1.40162200e-01f,
  2.94216406e-02f, -1.90193683e-01f, -1.17882468e-01f, -1.85641404e-02f, -1.15414307e-01f, -1.01604693e-01f, -2.30587125e-01f, -1.78446516e-01f, 7.67095238e-02f, -2.85869777e-01f,
  -1.72682330e-01f, -1.67589650e-01f, 4.20726202e-02f, -5.54305837e-02f, 2.37638690e-02f, 4.00479063e-02f, 5.31612113e-02f, -5.69925494e-02f, 1.33612499e-01f, -5.28463461e-02f,
  -1.04735315e-01f, 1.28253698e-01f, -8.01881403e-02f, -9.67845544e-02f, -8.39117691e-02f, -2.43824255e-02f, -4.04388532e-02f, -1.09765846e-02f, 9.51734483e-02f, 1.78025946e-01f,
  1.55727059e-01f, -2.41990872e-02f, -1.78123859e-03f, -2.43515838e-02f, 9.22960639e-02f, -4.81783831e-03f, 5.72390743e-02f, 6.31747246e-02f, 5.50029464e-02f, -1.74806118e-01f,
  -3.89395207e-02f, -4.49260250e-02f, -4.38822955e-02f, -2.84915250e-02f, 1.63020231e-02f, -1.26563668e-01f, -1.23651691e-01f, -1.34156987e-01f, -2.93723904e-02f, -5.90759963e-02f,
  1.75206810e-02f, -5.14471531e-03f, -9.49320942e-02f, -1.86907232e-01f, -1.08217947e-01f, -1.95852667e-02f, -3.34345214e-02f, -5.83923794e-03f, 5.10382373e-03f, 1.07445950e-02f,
  -7.66591579e-02f, 8.51578340e-02f, -8.46619010e-02f, 4.27513244e-03f, -1.45111224e-02f, 9.14424378e-03f, 2.54661627e-02f, -6.60960516e-03f, 2.82084495e-02f, -1.06038125e-02f,
  -4.17709112e-01f, -2.36264896e-02f, -7.53894821e-02f, -5.61526464e-03f, 7.24201498e-04f, 1.82049163e-02f, -5.43426350e-02f, 1.62019988e-03f, -2.24220306e-01f, -1.29866973e-02f,
  5.92829995e-02f, -1.53688490e-01f, -5.64074256e-02f, -1.13747912e-02f, -1.25807039e-02f, -4.67992015e-02f, -7.23687559e-02f, -1.45285919e-01f, 1.05621055e-01f, 6.68788701e-02f,
  -3.72074731e-02f, -4.22395132e-02f, -5.61576486e-02f, -6.67330176e-02f, -4.94667282e-03f, -8.29582289e-02f, 7.12203234e-03f, -9.72158983e-02f, -4.37931307e-02f, -9.06975195e-02f,
  3.23361456e-01f, 1.68699786e-01f, -6.62557185e-01f, 1.79852828e-01f, -8.79229158e-02f, -6.63242117e-02f, 4.77657020e-02f, 2.33694583e-01f, 3.00216168e-01f, 1.65799767e-01f,
  -3.44595723e-02f, -7.19168261e-02f, -2.12580234e-01f, -8.13595653e-02f, -1.27612546e-01f, 1.50999920e-02f, -3.32569852e-02f, -4.27155107e-01f, -3.50268275e-01f, 6.59226328e-02f,
  2.63109595e-01f, 2.24131197e-01f, 1.93719864e-01f, 2.16128267e-02f, 5.31345457e-02f, 9.52133967e-04f, -1.13852859e-01f, -7.82212466e-02f, -1.19010143e-01f, -1.81718722e-01f,
  -3.50657463e-01f, -2.12125793e-01f, -1.86259761e-01f, 6.73182961e-03f, -2.44530573e-01f, 7.28379562e-02f, -1.44465119e-01f, -1.62192762e-01f, 3.16007510e-02f, 1.19714305e-01f,
  -1.76616058e-01f, 2.85107605e-02f, -1.26185641e-01f, -8.89481604e-02f, -2.61285566e-02f, -2.94104349e-02f, 3.09519768e-02f, -1.70122579e-01f, -2.30051935e-01f, -1.49069339e-01f,
  -2.94976286e-03f, -2.45840222e-01f, -2.85347402e-01f, -4.93469536e-02f, -1.93271473e-01f, -1.13867722e-01f, -8.59361216e-02f, -2.74769694e-01f, -3.26670855e-01f, 3.70562263e-02f,
  3.36911133e-03f, 4.38292958e-02f, -3.60222273e-02f, 4.82379235e-02f, 5.89219946e-03f, -4.10781763e-02f, -9.57257226e-02f, -7.29479715e-02f, 5.70013709e-02f, -1.93385668e-02f,
  -1.34385407e-01f, 4.76794355e-02f, 3.21801612e-03f, 9.24597830e-02f, 1.50331529e-02f, -5.67099154e-02f, -7.76941851e-02f, -2.43361224e-03f, -1.19793333e-01f, 6.45474792e-02f,
  -1.47029813e-02f, -1.03308670e-01f, 1.75819900e-02f, -2.36382931e-02f, -6.03590943e-02f, -3.03887855e-02f, -8.24816618e-03f, 1.03292458e-01f, 5.77402823e-02f, -4.03430909e-02f,
  3.78825366e-01f, -2.77008325e-01f, 1.51463762e-01f, -1.05176426e-01f, -4.49766293e-02f, -5.21943383e-02f, 4.40839082e-02f, -3.34412679e-02f, 2.60554403e-02f, -1.90729350e-02f,
  -9.57147628e-02f, 1.76149104e-02f, 3.94784473e-02f, 6.25023767e-02f, 1.34310191e-02f, 2.88563706e-02f, 9.77999344e-02f, -8.59586149e-02f, 5.52850664e-02f, 9.14240181e-02f,
  2.81200945e-01f, 1.82919845e-01f, 2.22412515e-02f, -2.76454575e-02f, 4.15660925e-02f, 1.30480975e-02f, 3.97319011e-02f, -6.38564080e-02f, -2.14406196e-02f, 3.43608618e-01f,
  1.02763753e-02f, 2.01442197e-01f, 1.10689878e-01f, 6.31547496e-02f, 1.53758019e-01f, 1.03869312e-01f, 4.02167320e-01f, 1.11297071e-01f, -1.32402837e-01f, 8.46588314e-02f,
  -6.61741644e-02f, -2.90190578e-01f, -2.13635877e-01f, -2.70871311e-01f, -1.06526718e-01f, 1.15172110e-01f, 1.34492919e-01f, -5.21090301e-03f, -2.78218180e-01f, -5.79491742e-02f,
  -1.13202363e-01f, 7.77379051e-02f, -4.85716164e-02f, -8.67643356e-02f, -3.53687219e-02f, -2.86706299e-01f, -5.87536283e-02f, 1.24544404e-01f, 3.47783007e-02f, 8.77465531e-02f,
  6.84135780e-02f, 1.20485745e-01f, -2.77847439e-01f, -1.11262769e-01f, 3.62387337e-02f, 1.47043645e-01f, 1.31412193e-01f, 8.58215615e-03f, 2.52233520e-02f, 8.48733410e-02f,
  -2.26675682e-02f, 4.34965454e-03f, -2.10406799e-02f, -1.29094962e-02f, 1.32311806e-01f, 1.14477508e-01f, 1.48604825e-01f, 4.55460809e-02f, -1.14256196e-01f, -1.94152519e-02f,
  -4.25075181e-02f, 1.26079321e-01f, 2.39749923e-02f, 5.61733358e-02f, 4.93720025e-02f, -1.21541858e-01f, -2.37168744e-02f, -1.03449874e-01f, -5.26846312e-02f, 4.23363261e-02f,
  -5.46594150e-02f, -9.42549333e-02f, -4.31660563e-02f, 9.77313295e-02f, 2.98235212e-02f, -1.40411094e-01f, 7.06852376e-02f, 1.49802536e-01f, 1.65249214e-01f, 1.77450553e-01f,
  1.37083575e-01f, 9.89670530e-02f, 7.89703876e-02f, 3.15273762e-01f, 3.82793844e-02f, 1.65696684e-02f, 1.72838718e-02f, 1.40451744e-01f, 9.36850384e-02f, 1.58201419e-02f,
  1.28559042e-02f, 4.12875563e-02f, 1.92279816e-01f, 1.72550082e-01f, 8.04061070e-02f, -4.63400921e-03f, 2.13599384e-01f, 1.34664893e-01f, 5.21719977e-02f, 1.60730034e-02f,
  -4.19262797e-02f, -3.47527377e-02f, -7.52491578e-02f, 1.23143286e-01f, 5.69589473e-02f, 8.71239603e-02f, 1.41642643e-02f, 8.73043910e-02f, 2.02230383e-02f, 1.50658190e-01f,
  -2.30729841e-02f, 3.10091656e-02f, 9.41578597e-02f, 8.08632374e-02f, 9.51092541e-02f, -4.19572033e-02f, 3.68352160e-02f, 7.05162883e-02f, -9.25558805e-02f, 8.86025354e-02f,
  -6.67061075e-04f, -1.80232882e-01f, 2.09550862e-03f, -7.92587474e-02f, 2.30239760e-02f, -5.83482236e-02f, -2.62292903e-02f, 2.12901533e-02f, -7.40116313e-02f, -1.22700699e-01f,
  -2.85865366e-01f, 2.67959952e-01f, 8.48122984e-02f, -2.36126810e-01f, 1.56557202e-01f, 2.14239493e-01f, 4.61928457e-01f, -1.09669112e-01f, -1.87391728e-01f, 9.01442394e-02f,
  2.00055987e-01f, -2.15946361e-01f, -1.50536925e-01f, -9.83815361e-03f, -2.55312328e-03f, 2.49415368e-01f, 4.67714481e-02f, -1.16824217e-01f, -8.97848085e-02f, 6.10677153e-02f,
  9.40035135e-02f, -1.69186786e-01f, -1.89582556e-01f, -8.13675299e-02f, -4.94228639e-02f, -2.35110894e-01f, 6.02614023e-02f, -8.95408615e-02f, 7.56438673e-02f, -8.23190261e-04f,
  -6.22754693e-02f, -4.52306978e-02f, -4.02738303e-02f, -1.28964826e-01f, -4.62283986e-03f, -8.69856402e-02f, -1.23138070e-01f, -1.96296141e-01f, -1.39395401e-01f, -6.30229563e-02f,
  -9.01109278e-02f, -1.37469962e-01f, -8.97439346e-02f, -8.43243524e-02f, -1.40134349e-01f, -6.57563955e-02f, 6.78367987e-02f, -9.09862965e-02f, -1.86779201e-02f, 5.60891256e-02f,
  1.89850345e-01f, 8.63419548e-02f, -1.75434616e-05f, 1.13865353e-01f, 7.23792389e-02f, -5.86913191e-02f, -1.57960113e-02f, 4.88780662e-02f, 1.21512853e-01f, -6.33582622e-02f,
  9.63808894e-02f, -9.99344978e-03f, -5.80464788e-02f, -4.08831872e-02f, 7.92754348e-03f, -6.62108734e-02f, -8.75979438e-02f, 2.90418267e-02f, 5.01800478e-02f, -1.32374793e-01f,
  -3.65832746e-02f, 8.05007070e-02f, -2.72229426e-02f, 1.73656326e-02f, -2.91478764e-02f, 2.03932673e-02f, 4.16238196e-02f, -2.95366067e-02f, 2.16571633e-02f, 1.35369767e-02f,
  -4.83308323e-02f, 2.76610553e-02f, 1.04186088e-01f, 5.58053069e-02f, 1.43289134e-01f, -5.04505336e-02f, 1.41897397e-02f, -8.69132951e-03f, -8.45697299e-02f, -7.88672790e-02f,
  -4.43152249e-01f, 1.67958796e-01f, -1.43786475e-01f, -5.92506453e-02f, -4.96302731e-03f, -3.74005735e-02f, -4.28419411e-02f, 2.95886584e-02f, 4.28873636e-02f, 1.78599153e-02f,
  -6.13422655e-02f, 2.48274412e-02f, -4.00753394e-02f, -5.08001894e-02f, 7.99365491e-02f, -7.39955157e-02f, 1.27725586e-01f, 4.98110913e-02f, 7.32344240e-02f, 7.30225891e-02f,
  8.56954455e-02f, -4.77177836e-02f, -6.89568594e-02f, 2.58166846e-02f, 2.48865951e-02f, 1.14486791e-01f, -1.22970663e-01f, -1.99657261e-01f, -7.65252262e-02f, -1.52256921e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.61255151e-01f, 1.55702963e-01f, -1.23725303e-01f, 1.07828245e-01f, -4.09420840e-02f, 2.06751585e-01f, 9.72541347e-02f, 1.92803219e-01f, -4.73455749e-02f, 1.09661900e-01f,
  -2.00767249e-01f, 2.27993190e-01f, -3.99000049e-02f, 2.66013090e-02f, 1.35497659e-01f, 5.89442812e-02f, -2.39105076e-02f, -4.93158437e-02f, 1.53612882e-01f, -1.50370635e-02f,
  1.59631614e-02f, -1.15060778e-02f, 8.09571967e-02f, 5.20879254e-02f, 7.26322904e-02f, 1.20800927e-01f, 2.26029262e-01f, 1.35991707e-01f, -1.45466216e-02f, 8.82316008e-02f,
  1.21931426e-01f, 4.68159951e-02f, 2.10561931e-01f, 5.80537915e-02f, 2.12699309e-01f, -3.42159793e-02f, 2.46076453e-02f, 1.40859783e-01f, 9.79502220e-03f, 1.95443094e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  8.51240125e-04f, -5.17793968e-02f, -3.63658890e-02f, -6.18173853e-02f, -1.14463151e-01f, -2.80221164e-01f, -7.93163702e-02f, 2.42321696e-02f, 2.87517607e-02f, 7.01954402e-03f,
  -9.34815854e-02f, 3.30094993e-03f, 1.20971188e-01f, -1.01759192e-02f, -3.57590504e-02f, 1.48209453e-01f, -1.74107198e-02f, -3.34018618e-02f, -1.57816365e-01f, -2.66961545e-01f,
  -1.18581735e-01f, 1.09369524e-01f, 7.74687529e-02f, 3.20843756e-02f, 4.04667594e-02f, 1.26906812e-01f, -9.76319537e-02f, 3.05312097e-01f, -4.93570045e-02f, 2.34962136e-01f,
  1.63046300e-01f, -8.58948082e-02f, -5.21145687e-02f, -1.22750886e-01f, 2.64734209e-01f, 1.06127568e-01f, -6.44984888e-03f, -3.26558799e-01f, 1.83076233e-01f, 1.82670861e-01f,
  2.25739226e-01f, 1.20640188e-01f, -9.94745865e-02f, -7.60449516e-03f, 1.44231930e-01f, -9.24355313e-02f, 2.80570816e-02f, -1.51318714e-01f, 1.21562578e-01f, 7.61782527e-02f,
  5.66597097e-02f, -3.54124606e-02f, -4.15129103e-02f, -5.05660847e-02f, -3.15851271e-01f, 1.22492403e-01f, -1.10740280e-02f, 1.72608286e-01f, -2.78583795e-01f, 1.64245352e-01f,
  5.63891046e-02f, -3.83998871e-01f, -1.81617700e-02f, 1.02455318e-01f, 1.44624695e-01f, -1.12162717e-02f, -1.26363292e-01f, -6.09983429e-02f, -8.95424262e-02f, 2.25115158e-02f,
  7.52840145e-03f, -2.69398801e-02f, -8.75691846e-02f, -4.37481068e-02f, 1.55245094e-02f, 4.54268325e-03f, -2.17123955e-01f, -2.18903329e-02f, 1.32278819e-03f, 3.61501314e-02f,
  1.04586497e-01f, -9.00448784e-02f, -1.62261456e-01f, 1.13126606e-01f, -3.20678465e-02f, 3.65704857e-02f, -1.47395290e-03f, 7.19816471e-03f, -1.45881191e-01f, -2.42389798e-01f,
  8.22726414e-02f, 3.44080739e-02f, -1.63247634e-03f, -2.42737293e-01f, 1.86581954e-01f, -6.87511936e-02f, 4.47261855e-02f, -3.28563601e-01f, 1.33573696e-01f, -1.86151996e-01f,
  1.48037404e-01f, -1.90342471e-01f, -6.34575309e-03f, 6.79202005e-02f, 1.91396326e-01f, 1.32428065e-01f, 2.36837789e-01f, 2.32128486e-01f, -4.95946370e-02f, 9.58424509e-02f,
  3.50508913e-02f, -1.03879541e-01f, -9.71354544e-04f, -9.46161598e-02f, 8.74344558e-02f, 8.54007229e-02f, -1.50872111e-01f, 5.60999848e-02f, -1.40791893e-01f, 1.07329778e-01f,
  3.27056259e-01f, 1.63365200e-01f, -2.54786432e-01f, -7.78235793e-02f, -5.07203303e-02f, 1.50606215e-01f, 9.86232683e-02f, 2.62169875e-02f, 4.45722835e-03f, 7.33638182e-02f,
  4.21730243e-02f, 2.12862268e-02f, -1.51738925e-02f, -2.16513619e-01f, -6.63742721e-02f, -9.59728211e-02f, 3.28074284e-02f, -4.11180444e-02f, -7.79389665e-02f, -1.14851877e-01f,
  2.32249349e-01f, 5.50077669e-02f, -9.09819230e-02f, 6.13632537e-02f, 2.63439082e-02f, -5.98642789e-02f, 1.68860722e-02f, -4.31534611e-02f, 3.34018841e-02f, -7.35258013e-02f,
  -5.73336072e-02f, 2.85514481e-02f, -2.14764610e-01f, 1.35031894e-01f, -6.94307387e-02f, 1.74863026e-01f, -2.78254241e-01f, 2.98006505e-01f, -1.04019463e-01f, -8.21825489e-02f,
  -1.27969801e-01f, 1.63056821e-01f, -1.29435375e-01f, 1.08909793e-01f, -2.76109576e-01f, -2.41843294e-02f, -1.67799711e-01f, 4.81946655e-02f, -1.66256279e-01f, 4.96837171e-03f,
  -2.55626023e-01f, -1.95375994e-01f, -1.06111318e-01f, -3.58251017e-03f, 6.16379641e-02f, -1.59702599e-01f, -4.96733300e-02f, -1.80786937e-01f, -6.73662275e-02f, -2.27145553e-01f,
  2.69180864e-01f, -1.24166660e-01f, -3.55006456e-02f, -6.91480711e-02f, -1.21497668e-01f, 4.25591543e-02f, -1.13634672e-02f, 3.82386371e-02f, -1.60798550e-01f, -3.04819316e-01f,
  -1.05461620e-01f, -2.97112077e-01f, 8.31034854e-02f, -1.01749107e-01f, -6.08148389e-02f, -2.38090064e-02f, -6.26329854e-02f, 1.09673157e-01f, 3.48078050e-02f, 1.02746747e-01f,
  -6.18045777e-02f, -1.24995166e-03f, 7.03815520e-02f, 1.38535738e-01f, 1.10387914e-01f, -1.33451939e-01f, 1.13829240e-01f, -2.51095779e-02f, 4.38728966e-02f, -2.64639519e-02f,
  2.59483028e-02f, 2.22762972e-01f, -8.48050639e-02f, -1.72381893e-01f, 4.79558222e-02f, 8.72064382e-02f, -1.47281408e-01f, 1.01130806e-01f, -1.61286533e-01f, 3.31286080e-02f,
  1.73139036e-01f, 4.41431887e-02f, -8.87323767e-02f, 9.87318680e-02f, -3.42987143e-02f, 9.20803398e-02f, 4.65438440e-02f, -2.02678412e-01f, 1.15614660e-01f, 1.56929538e-01f,
  -2.00257376e-02f, 9.20485184e-02f, -4.55971174e-02f, -3.30438837e-02f, 1.34240910e-01f, -1.62210658e-01f, -2.05245003e-01f, -7.15000480e-02f, 3.95373031e-02f, -7.35178590e-02f,
  -2.25073919e-01f, -9.85373184e-02f, 6.18787445e-02f, 1.14369847e-01f, 1.09795533e-01f, -5.90548068e-02f, 2.24845350e-01f, -2.45572310e-02f, 1.75428838e-01f, -1.69627994e-01f,
  1.55766040e-01f, 5.99618927e-02f, 7.78125152e-02f, 4.41135615e-01f, -1.12793885e-01f, -2.73174822e-01f, -1.55449659e-01f, 3.11211441e-02f, 9.37817171e-02f, -1.56628229e-02f,
  -1.50782287e-01f, -4.70166914e-02f, -4.61966991e-02f, -1.03263827e-02f, 4.45476025e-02f, -3.28321233e-02f, 3.33306333e-03f, -3.41161638e-02f, 6.14677072e-02f, -8.17927793e-02f,
  1.41154472e-02f, 9.21190828e-02f, -5.43331467e-02f, 7.11367875e-02f, 3.29608530e-01f, 1.80054829e-01f, 8.24742168e-02f, 3.28485481e-02f, -7.99151957e-02f, -1.11539783e-02f,
  -3.22647877e-02f, -2.94720139e-02f, 1.93566810e-02f, -2.14512385e-02f, -2.99193382e-01f, 1.18323676e-01f, -1.09152943e-02f, 2.01664567e-01f, 1.57710254e-01f, -1.36284560e-01f,
  8.55591595e-02f, -5.35562560e-02f, -2.15257525e-01f, 1.25375718e-01f, 2.62946598e-02f, 1.11900821e-01f, -6.62244037e-02f, -2.33725831e-01f, -8.34389683e-03f, 1.36061147e-01f,
  -1.24180302e-01f, 3.43575887e-02f, 8.88884142e-02f, -1.34818465e-01f, 2.04428211e-01f, 8.70473217e-03f, 2.80326735e-02f, -2.41374388e-01f, 6.67492812e-03f, 3.34020762e-04f,
  3.05984914e-02f, -1.01795822e-01f, 2.02737600e-01f, 1.39451101e-01f, 6.02031238e-02f, -8.45386907e-02f, -2.76586920e-01f, 2.27131903e-01f, 4.00971584e-02f, -1.95854902e-01f,
  -4.71228361e-02f, -1.07394960e-02f, -5.80664873e-02f, 9.87420827e-02f, 3.62212062e-02f, -8.54495093e-02f, -5.59251793e-02f, -7.26092756e-02f, 3.31459753e-02f, -6.06043963e-03f,
  9.33316797e-02f, -4.52647842e-02f, 2.17713147e-01f, 3.99136283e-02f, -1.74045950e-01f, 8.45690519e-02f, 6.92877322e-02f, 1.85548887e-01f, 1.39266506e-01f, 1.88777313e-01f,
  -1.79926351e-01f, -9.04119983e-02f, -2.49802936e-02f, -1.01111852e-01f, 6.97011203e-02f, 1.60961673e-01f, 1.20703548e-01f, -9.60788727e-02f, 2.66961101e-02f, 1.59948409e-01f,
  -2.97670662e-01f, -2.30480805e-01f, -1.15327291e-01f, 2.94293463e-01f, 1.22807197e-01f, -3.29950973e-02f, 8.59778672e-02f, 2.63055474e-01f, -6.99664503e-02f, 9.43794250e-02f,
  -1.89353600e-01f, 4.92132120e-02f, -6.42240271e-02f, -5.13706692e-02f, -7.71397203e-02f, 1.06605224e-01f, -2.71651983e-01f, 2.92181298e-02f, -1.14402957e-01f, -1.75932199e-01f,
  -1.25144884e-01f, 3.25049274e-02f, 6.62152842e-02f, -2.90142268e-01f, 1.37813300e-01f, -9.17186216e-02f, 1.08774781e-01f, -1.07173296e-02f, -2.99118534e-02f, 5.72122261e-02f,
  -1.98925480e-01f, -3.08281898e-01f, -9.27338004e-02f, -3.59728992e-01f, -1.48777381e-01f, -2.93479506e-02f, -3.95504013e-02f, 9.98668894e-02f, -9.27633867e-02f, -1.14488587e-01f,
  -6.62187412e-02f, 3.58257145e-02f, 7.21086711e-02f, -4.74877693e-02f, -5.60499877e-02f, 4.03380059e-02f, -1.70522869e-01f, -1.11003341e-02f, -1.49698719e-01f, 4.30098809e-02f,
  3.74701470e-02f, 1.63394630e-01f, 1.52455777e-01f, 2.57015288e-01f, -1.37589619e-01f, 6.85201287e-02f, -7.29388744e-02f, -7.45782852e-02f, 1.87664583e-01f, -3.15467827e-02f,
  2.78202947e-02f, 2.08971933e-01f, 2.82589316e-01f, -6.73843082e-03f, -4.15472910e-02f, -1.59110814e-01f, -4.29060645e-02f, 1.25900537e-01f, 1.58674493e-01f, -1.23152025e-01f,
  -5.36338724e-02f, 1.68613866e-01f, -1.49627691e-02f, 7.91282654e-02f, 1.69031575e-01f, -4.44754846e-02f, 5.65705933e-02f, 1.07926451e-01f, -1.21840455e-01f, 1.29081115e-01f,
  -6.73374236e-02f, -1.52058780e-01f, -3.69786695e-02f, -1.40715465e-01f, 3.34139653e-02f, 1.60035729e-01f, -1.88115790e-01f, -1.54757202e-01f, -1.90641627e-01f, 2.34238818e-01f,
  -2.40909860e-01f, 7.00095901e-03f, -1.13532536e-01f, 1.14393316e-01f, -6.03476306e-03f, 8.76562074e-02f, 5.06884605e-03f, -1.08853504e-02f, -2.32906155e-02f, 3.85869704e-02f,
  9.68578383e-02f, 6.31517917e-02f, 1.87897786e-01f, -4.56637442e-02f, 8.20648298e-02f, -5.01453839e-02f, 3.29027288e-02f, -7.59320706e-02f, -7.88742676e-02f, 3.38080265e-02f,
  1.41109005e-01f, -1.07649537e-02f, 4.62280996e-02f, 2.64021486e-01f, -4.95021902e-02f, -2.04695687e-01f, -3.07979316e-01f, -9.56865475e-02f, 3.81544940e-02f, -3.90674435e-02f,
  9.57976654e-02f, 1.42966926e-01f, -7.50511587e-02f, -1.04077972e-01f, 1.69805720e-01f, 2.44725514e-02f, -2.81402022e-01f, 1.20703198e-01f, 1.30208343e-01f, -8.05861726e-02f,
  1.89786598e-01f, -1.03345342e-01f, 2.22241893e-01f, 2.75141932e-02f, -1.36021808e-01f, -2.85521746e-01f, -2.83075031e-02f, -1.71689149e-02f, 5.19082770e-02f, 9.11867525e-03f,
  1.69122323e-01f, -4.82973382e-02f, 1.10656075e-01f, 4.52933758e-02f, 8.24459642e-02f, -9.92757082e-02f, 5.80566190e-02f, 6.84228539e-02f, 1.85439318e-01f, -3.44803520e-02f,
  8.74653645e-03f, 8.79019946e-02f, 9.82684866e-02f, 1.81364976e-02f, 2.67877355e-02f, 1.32677853e-01f, 1.25713363e-01f, -3.81872840e-02f, -3.52308452e-02f, -4.07224983e-01f,
  -1.39797498e-02f, 1.69673771e-01f, 6.01717308e-02f, 2.03521196e-02f, -2.26934906e-02f, 1.29933245e-02f, -4.34660800e-02f, 1.28824010e-01f, 1.21018782e-01f, -3.68317477e-02f,
  2.54023001e-02f, 6.01081364e-02f, 2.03602761e-02f, 5.50672635e-02f, -6.05891421e-02f, -7.81856105e-02f, -2.96937544e-02f, -8.75734910e-02f, -1.20074853e-01f, -7.57691488e-02f,
  -1.05094805e-01f, 3.62083204e-02f, -1.02052674e-01f, 5.13105467e-02f, 2.00247407e-01f, 4.29506451e-02f, -3.97344381e-01f, -1.76736698e-01f, -4.88437014e-03f, 1.92972407e-01f,
  2.66723447e-02f, 2.49203872e-02f, 2.55180776e-01f, 8.99568759e-03f, 1.41356438e-01f, -9.07034129e-02f, -3.99226993e-02f, -2.85847574e-01f, 4.73839678e-02f, -6.87657222e-02f,
  1.29933715e-01f, 2.51332838e-02f, 2.28026167e-01f, -3.88142951e-02f, 2.55297482e-01f, 6.06370382e-02f, -6.45414814e-02f, -1.65363073e-01f, -3.09733357e-02f, -1.90521196e-01f,
  4.59902314e-03f, -1.11632593e-01f, -4.17807400e-02f, 3.37909795e-02f, -3.05499852e-01f, 3.51781666e-01f, 6.29720166e-02f, 3.82649829e-03f, 2.21836105e-01f, 2.13808730e-01f,
  -4.16006669e-02f, -7.41717517e-02f, 2.84451302e-02f, 1.23595402e-01f, -1.80659797e-02f, 1.63060576e-02f, 2.43749365e-01f, -1.40761018e-01f, 8.37933496e-02f, -4.42859828e-02f,
  9.13665965e-02f, -4.70631570e-02f, 4.06736843e-02f, -1.45003926e-02f, 1.66651588e-02f, -6.17503859e-02f, -2.52878051e-02f, 4.07858845e-03f, -3.44590917e-02f, -4.28958610e-02f,
  1.87128961e-01f, -5.62364534e-02f, 4.61119153e-02f, -1.70409992e-01f, 1.23965539e-01f, 1.94859877e-01f, 1.51850224e-01f, 1.13601372e-01f, 2.45677009e-02f, -3.48776206e-02f,
  1.30790204e-01f, -5.76033890e-02f, -8.14174786e-02f, -3.24989945e-01f, -3.25646818e-01f, -2.93000098e-02f, -2.43443042e-01f, 2.49282241e-01f, 1.95265532e-01f, -6.05018400e-02f,
  -8.35476816e-02f, -7.35162795e-02f, -2.54900753e-01f, -1.79939076e-01f, -7.80538023e-02f, -9.92872864e-02f, -4.16338831e-01f, -3.03424120e-01f, 5.51118329e-02f, 6.76467568e-02f,
  -1.25192165e-01f, -1.44330710e-01f, 5.26880659e-02f, -6.07817583e-02f, 1.42714188e-01f, 7.00011179e-02f, -2.69681565e-03f, -2.90616482e-01f, 2.20855087e-01f, 8.33753571e-02f,
  -1.94074720e-01f, -3.65825564e-01f, 5.36389872e-02f, 8.35736692e-02f, 1.76159754e-01f, -1.77113488e-01f, -1.76198035e-01f, 3.66810024e-01f, 2.42364481e-01f, -1.31434947e-01f,
  -7.91969746e-02f, 3.41287516e-02f, 1.80224910e-01f, -2.02210639e-02f, 6.40925169e-02f, 6.94254115e-02f, -2.17352249e-03f, -1.16954200e-01f, -3.93653661e-02f, 6.26472384e-02f,
  1.23949029e-01f, 7.69004524e-02f, 4.66656722e-02f, -5.82161807e-02f, -2.86746304e-02f, 2.13113412e-01f, 1.25535041e-01f, -1.12625673e-01f, -4.09533158e-02f, -6.73653781e-02f,
  1.49736658e-01f, 9.77458581e-02f, -2.41171010e-02f, 1.54173464e-01f, -1.81733891e-01f, 3.37469764e-02f, 1.80856481e-01f, -1.52227506e-01f, -2.53810436e-01f, 3.15042347e-01f,
  -2.06000715e-01f, -9.29088220e-02f, -1.34991974e-01f, -1.61519319e-01f, 1.13710593e-02f, 7.37415850e-02f, -1.20896772e-01f, -1.26910865e-01f, -1.67538136e-01f, 3.90215628e-02f,
  3.27828787e-02f, 6.87585399e-03f, 1.41295448e-01f, 6.10075798e-03f, -1.85440421e-01f, 8.78018886e-02f, -7.86812454e-02f, -1.67262062e-01f, 5.98212481e-02f, -1.35855496e-01f,
  1.39036387e-01f, -1.22205630e-01f, -1.25975281e-01f, 9.06190127e-02f, 2.43333075e-03f, -1.18542090e-01f, 2.20078647e-01f, 7.53733218e-02f, -2.86666267e-02f, -3.20186540e-02f,
  -3.24286222e-01f, 9.00096819e-02f, -7.20507801e-02f, -2.30412513e-01f, 1.54190898e-01f, -1.59822285e-01f, -1.36521399e-01f, 3.46960276e-02f, 4.77087824e-03f, 6.44438863e-02f,
  1.20811485e-01f, -3.52927707e-02f, 6.23842562e-03f, 2.41944641e-02f, -6.12455010e-02f, 5.81715293e-02f, -6.39585704e-02f, -2.10880369e-01f, -1.25451908e-01f, 1.20997883e-01f,
  3.75092924e-02f, -2.15065330e-02f, -2.20715523e-01f, 2.82663237e-02f, -1.74232483e-01f, -1.83701441e-01f, 1.06225371e-01f, 8.59098807e-02f, -2.76116103e-01f, -1.03641100e-01f,
  -6.66260123e-02f, 4.53156866e-02f, 3.23478924e-03f, -1.08868159e-01f, 1.92573979e-01f, -1.35454267e-01f, -3.43269072e-02f, -2.64128268e-01f, -5.03730327e-02f, -2.83492118e-01f,
  -1.78720802e-03f, -9.16516036e-02f, -2.01816604e-01f, 1.48269802e-01f, 1.99609637e-01f, 2.13096634e-01f, 2.69268304e-01f, -1.16172425e-01f, -2.37034857e-01f, -4.13060822e-02f,
  7.63543844e-02f, -1.57074153e-01f, 7.16211449e-04f, -6.39610887e-02f, -1.22573905e-01f, 3.96738388e-02f, -2.09983233e-02f, -8.84256661e-02f, -1.27557054e-01f, 1.19827546e-01f,
  2.40410805e-01f, 2.49785498e-01f, -1.52072966e-01f, -6.51067421e-02f, -7.85706379e-03f, 2.51875669e-01f, -6.34370148e-02f, -1.55784920e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.83805808e-01f, 2.52979934e-01f, 8.49761218e-02f, 1.78441450e-01f, 1.11171998e-01f, 9.45308954e-02f, 1.70988753e-01f, 8.20263475e-02f, 1.35255516e-01f, 2.50375807e-01f,
  1.23931319e-01f, 2.18819171e-01f, 1.63932145e-01f, -1.48367167e-01f, 7.94804022e-02f, 1.56056017e-01f, -1.36947647e-01f, -8.85597989e-02f, -1.39859945e-01f, -4.72775251e-02f,
  4.64811027e-02f, 3.00323707e-03f, 6.88010231e-02f, 1.33668985e-02f, -3.43028992e-01f, 4.80747642e-03f, -3.12625133e-02f, -8.65286887e-02f, 3.07718068e-02f, 9.34302136e-02f,
  1.17194906e-01f, -7.15939179e-02f, 3.10671609e-02f, 6.14816286e-02f, -1.00506684e-02f, -2.71313310e-01f, -1.08400695e-01f, -1.06209382e-01f, -8.54431652e-03f, -2.50876285e-02f,
  1.00467680e-02f, 1.52552053e-01f, 2.02006966e-01f, -2.26054457e-03f, -4.93078455e-02f, -1.67968988e-01f, 7.05552921e-02f, -1.29805818e-01f, 1.33945540e-01f, -2.30375350e-01f,
  1.27766117e-01f, 3.19263525e-02f, -1.68467999e-01f, 7.77153671e-02f, 5.55423871e-02f, 7.49957412e-02f, 3.75286549e-01f, 8.30922350e-02f, 1.29336283e-01f, -8.87766257e-02f,
  -1.27754778e-01f, 6.66230768e-02f, -9.60298851e-02f, 4.36683185e-03f, 2.09705178e-02f, -2.42485963e-02f, -9.93479788e-02f, 4.65563200e-02f, 5.36251441e-02f, 1.33878738e-02f,
  -2.99457572e-02f, 8.08017850e-02f, 6.12643436e-02f, -1.05989248e-01f, 3.74574326e-02f, 1.78842284e-02f, -1.57167464e-01f, -1.17813954e-02f, -1.86477587e-01f, -1.49147913e-01f,
  -3.38257067e-02f, 2.32364032e-02f, 3.46336095e-03f, 5.40077128e-02f, 1.02730073e-01f, 1.51821580e-02f, 4.13894281e-02f, -3.16530786e-04f, -5.31234872e-03f, 1.66076899e-01f,
  1.32964790e-01f, 1.13853820e-01f, 8.31886902e-02f, -9.81747359e-02f, 1.37093812e-01f, 1.08479694e-01f, 1.37823708e-02f, -1.61799684e-01f, -1.44516826e-01f, 2.58532073e-02f,
  1.69314831e-01f, -7.85185397e-02f, 4.16212454e-02f, -2.57084012e-01f, -1.93319526e-02f, 1.82522133e-01f, 2.74104699e-02f, 1.62888877e-02f, 2.00424381e-02f, 4.46468033e-02f,
  -6.09497912e-02f, 6.60140887e-02f, -4.91909757e-02f, 2.13441178e-01f, 2.30920985e-02f, 1.53873906e-01f, -5.75961173e-03f, 1.89118743e-01f, 1.19457813e-02f, -6.23159595e-02f,
  -9.26029235e-02f, -8.34313929e-02f, -2.03743070e-01f, 1.32863611e-01f, 1.22031286e-01f, 2.18504697e-01f, 5.94282448e-02f, 1.34370103e-01f, 2.80620046e-02f, 1.17526807e-01f,
  1.26787856e-01f, 2.13516325e-01f, -2.46507414e-02f, 8.40091705e-02f, 1.18047297e-02f, 6.75842762e-02f, 1.28698321e-02f, 3.71964276e-02f, 5.81536368e-02f, 1.41328588e-01f,
  1.99189782e-01f, 4.49838713e-02f, -1.60190701e-01f, 6.36015907e-02f, -1.37900934e-01f, 2.60580301e-01f, -1.95731267e-01f, 3.59367393e-02f, -3.69085558e-02f, 1.66301936e-01f,
  1.47343606e-01f, 1.13027662e-01f, 8.08977708e-02f, 1.66257754e-01f, -1.54715285e-01f, 8.88150781e-02f, 2.98985332e-01f, 1.65959999e-01f, 3.95735493e-03f, -2.46058702e-01f,
  -1.21605746e-01f, 1.78611845e-01f, 7.08288625e-02f, 1.07135259e-01f, 1.76481128e-01f, 9.82573330e-02f, -1.67267565e-02f, -5.68037629e-02f, -4.56753559e-02f, -1.12048956e-02f,
  2.04289407e-01f, -9.19102505e-02f, 2.39917096e-02f, 3.15306604e-01f, -2.31076524e-01f, 2.32787337e-02f, -1.63027853e-01f, 6.36412427e-02f, -1.97153166e-02f, 1.70651779e-01f,
  -2.18119293e-01f, -5.51793650e-02f, 3.29360515e-01f, 7.01263826e-03f, -4.96039726e-02f, -1.01633258e-01f, 5.67112677e-02f, 5.43841794e-02f, 3.53078917e-02f, -3.18809211e-01f,
  -1.01792790e-01f, -1.31796420e-01f, 7.80485645e-02f, -4.08193320e-02f, 6.21426664e-02f, 5.43745980e-02f, 2.19876673e-02f, 2.15766743e-01f, 4.80278507e-02f, 1.21401399e-01f,
  1.18974701e-01f, 7.70644993e-02f, 4.65239696e-02f, 2.07261339e-01f, 8.07936192e-02f, 4.53691045e-03f, -1.35000318e-01f, 7.95788169e-02f, -1.14797451e-01f, -9.73793641e-02f,
  -1.41231567e-01f, 1.62534773e-01f, -1.37130678e-01f, -4.53082658e-02f, 1.55828953e-01f, 1.27661064e-01f, -9.07249227e-02f, 1.51550114e-01f, -1.34726793e-01f, 6.64729550e-02f,
  -2.44475100e-02f, -5.36817685e-02f, 1.14688821e-01f, -3.15358229e-02f, -4.51241471e-02f, -1.02691926e-01f, -8.69326070e-02f, -4.29804549e-02f, 1.62954032e-01f, 1.19175650e-01f,
  -1.21064089e-01f, -8.99400041e-02f, 1.54740125e-01f, 8.75423029e-02f, 3.23255122e-01f, 2.86744922e-01f, -6.93707215e-03f, 1.45305395e-01f, 1.28073230e-01f, -1.23591036e-01f,
  -1.54435700e-02f, -1.60811573e-01f, -1.88521713e-01f, 1.34395555e-01f, -4.77507375e-02f, -5.51230088e-02f, 2.47161388e-02f, -6.76002353e-02f, 2.68439483e-02f, 1.25194371e-01f,
  -5.07569946e-02f, 2.71755122e-02f, 4.92519327e-02f, 6.18797913e-02f, -1.17841236e-01f, -2.00152040e-01f, 4.38161753e-02f, 2.87646353e-02f, -6.41281679e-02f, 1.31619826e-01f,
  -6.83568940e-02f, 2.25263178e-01f, 1.75737828e-01f, 9.08444375e-02f, 6.48227185e-02f, -2.07779389e-02f, 1.79633662e-01f, 1.12162158e-01f, -1.68535128e-01f, 4.39101122e-02f,
  2.08636776e-01f, -2.06051707e-01f, 2.63981428e-02f, -3.66960466e-02f, 4.94931303e-02f, -1.81207079e-02f, 1.77245747e-04f, -9.54971388e-02f, 7.09448382e-02f, 1.43736415e-02f,
  -2.30717193e-02f, -2.09065661e-01f, 9.54473093e-02f, -2.22854942e-01f, -8.32021385e-02f, -1.19407162e-01f, 1.69396833e-01f, 6.37446940e-02f, 3.02971564e-02f, -1.77578032e-01f,
  1.09919630e-01f, -1.87139690e-01f, -1.85068637e-01f, -8.48624706e-02f, 1.42171323e-01f, 9.35770273e-02f, 4.15332913e-02f, -3.85811538e-01f, -1.72069445e-01f, 3.29412222e-02f,
  9.68306363e-02f, -1.74340948e-01f, -1.07111586e-02f, -8.87660459e-02f, 1.95057675e-01f, 1.29984111e-01f, 6.21231347e-02f, -1.51689619e-01f, -8.76507014e-02f, 2.92752296e-01f,
  -1.49616405e-01f, -4.38735336e-02f, 1.47070453e-01f, 8.49159732e-02f, 1.24191530e-02f, -2.31556207e-01f, -1.40849859e-01f, 3.75357181e-01f, 3.59754674e-02f, -6.61866590e-02f,
  1.57658741e-01f, 1.78057984e-01f, 2.20673218e-01f, 2.44305301e-02f, 1.76586151e-01f, 6.47651479e-02f, 7.18523189e-02f, 3.61290127e-02f, 1.94293991e-01f, 9.23984125e-02f,
  -1.00999232e-02f, 1.40645227e-03f, 2.85501808e-01f, 5.68921585e-03f, 2.52484391e-03f, 8.78451765e-02f, -5.84442206e-02f, -6.10041842e-02f, -7.96962827e-02f, -1.46643132e-01f,
  1.06161170e-01f, -1.95749700e-01f, 7.13002160e-02f, 1.32272229e-01f, -1.60253242e-01f, 1.73738524e-01f, 8.48205537e-02f, -4.41739708e-02f, -4.29929793e-02f, 8.48867819e-02f,
  -1.98131189e-01f, 8.72842818e-02f, -2.45384630e-02f, 2.36730516e-01f, -1.60510167e-01f, -3.65284607e-02f, -1.06722087e-01f, 2.14821696e-02f, -3.33414823e-02f, -3.39259766e-02f,
  -3.37847322e-01f, -1.09215744e-01f, -2.90570669e-02f, -1.25478864e-01f, -1.03217080e-01f, 1.71991885e-01f, -2.91908402e-02f, -2.28778198e-02f, -1.25727251e-01f, 1.02671608e-02f,
  1.89144671e-01f, -1.23373345e-01f, 1.74591273e-01f, 1.11279339e-02f, 1.49221152e-01f, -1.19126782e-01f, 8.61710981e-02f, 7.70011544e-02f, 3.90084416e-01f, 1.10347673e-01f,
  -2.44728908e-01f, -1.15324883e-02f, 2.06204891e-01f, -1.22860886e-01f, 1.80528328e-01f, 1.34626608e-02f, -1.29805030e-02f, 1.62520498e-01f, 9.91134048e-02f, 2.27043688e-01f,
  1.53902352e-01f, 1.98707372e-01f, 1.30737886e-01f, 8.18094760e-02f, 4.58126143e-02f, 7.89859369e-02f, 1.13147564e-01f, -3.68191563e-02f, 4.06583808e-02f, 1.46911591e-02f,
  -1.35853961e-01f, 1.10696204e-01f, 1.45606682e-01f, 3.08421671e-01f, -1.48980379e-01f, -1.41454205e-01f, 6.86044097e-02f, 4.15791981e-02f, -1.21284311e-03f, 6.91880565e-03f,
  -4.48079184e-02f, -1.38447098e-02f, 2.09710374e-01f, -2.75512218e-01f, 1.37317821e-01f, -6.81896731e-02f, -3.37280706e-02f, 4.39909250e-02f, -1.44690514e-01f, -2.39629358e-01f,
  1.36033058e-01f, 1.24266937e-01f, 1.96870312e-01f, 1.66168600e-01f, -3.03883478e-02f, 2.55180188e-02f, 2.76479602e-01f, -1.39217913e-01f, -2.31319427e-01f, 2.13429723e-02f,
  -3.51614840e-02f, -4.76780720e-02f, -3.22417378e-01f, -7.19687492e-02f, -2.40086272e-01f, 2.35604212e-01f, -2.82848388e-01f, -1.41038513e-02f, 3.15466464e-01f, 1.54426368e-02f,
  1.43448532e-01f, -1.64477602e-01f, -9.24928188e-02f, 5.38738854e-02f, 8.33909661e-02f, 4.43701595e-01f, -3.63841169e-02f, -7.45401084e-02f, 7.97406733e-02f, 2.30729990e-02f,
  1.51186679e-02f, 7.05982521e-02f, -7.61225447e-02f, 2.17866171e-02f, -1.75729897e-02f, 8.25563744e-02f, 6.95421845e-02f, -8.38836376e-03f, 1.58399701e-01f, -3.60753275e-02f,
  -1.67078972e-01f, 9.89317428e-03f, -8.79129693e-02f, -1.69032663e-01f, 1.22613572e-01f, -6.40055612e-02f, 2.09233746e-01f, 1.66912436e-01f, 1.05852224e-01f, 8.08771551e-02f,
  -2.18998611e-01f, -2.24209830e-01f, 4.66844648e-01f, -4.06032622e-01f, -5.02936542e-02f, -1.21652015e-01f, 1.19677745e-02f, -8.16950724e-02f, -3.95931780e-01f, 1.20090470e-01f,
  6.83754385e-02f, 9.47948620e-02f, -4.80751954e-02f, 1.19097590e-01f, -7.45313838e-02f, -7.89258778e-02f, -2.00670391e-01f, -1.44178169e-02f, -5.34411296e-02f, -7.16055185e-02f,
  -3.43695343e-01f, 1.39634386e-01f, 2.88602393e-02f, -2.77963668e-01f, 1.80832848e-01f, 1.11348256e-01f, 7.39742592e-02f, 1.96365327e-01f, 6.69484138e-02f, -2.08497182e-01f,
  2.55816579e-01f, -6.02623597e-02f, -1.51376888e-01f, 2.25334838e-02f, 1.87458247e-02f, -2.77620628e-02f, 4.81396802e-02f, 3.44358869e-02f, -3.05836469e-01f, -5.22004999e-02f,
  2.94788212e-01f, 1.21299297e-01f, 2.55210754e-02f, -6.52783513e-02f, -8.36146772e-02f, 6.32500350e-02f, -1.01479739e-01f, 5.05782552e-02f, -2.22225618e-02f, 1.94746796e-02f,
  1.27733618e-01f, -4.28772271e-02f, 7.34384581e-02f, -1.28061278e-02f, 2.78740097e-02f, -1.80632070e-01f, -1.87541381e-01f, 2.15010285e-01f, 1.53764114e-01f, -1.22855030e-01f,
  -5.73923253e-02f, 2.69844383e-01f, -2.37893865e-01f, -1.93088531e-01f, 1.01143271e-01f, 3.92603427e-02f, 3.42845917e-02f, 9.36754495e-02f, -7.83687159e-02f, -5.43384589e-02f,
  6.62996545e-02f, -3.65801066e-01f, -3.22315581e-02f, 8.10020491e-02f, -1.02713235e-01f, -3.23501796e-01f, 2.57047396e-02f, -2.98560292e-01f, 1.04532771e-01f, 9.60035846e-02f,
  -3.47323082e-02f, -2.28015766e-01f, 1.11100916e-02f, 1.81597069e-01f, 2.49049142e-01f, 3.50714505e-01f, -2.18461856e-01f, -2.11275015e-02f, -1.75489306e-01f, 6.70798169e-03f,
  -3.29907507e-01f, -2.56644338e-01f, -2.82851458e-01f, 3.80680040e-02f, -3.76968622e-01f, -1.97528690e-01f, -4.17196788e-02f, -1.68736160e-01f, 1.55700564e-01f, -2.33884215e-01f,
  -9.98430923e-02f, 9.25553590e-02f, -1.69506911e-02f, 2.08231032e-01f, -6.18620068e-02f, -1.47461623e-01f, 2.03908950e-01f, 1.61673278e-01f, 1.63155630e-01f, 1.37561083e-01f,
  1.12501346e-01f, 8.29637423e-03f, 5.03475219e-02f, 1.05784863e-01f, 7.06496323e-03f, 1.12689674e-01f, 3.66012976e-02f, 1.73212111e-01f, 1.57896746e-02f, 1.22673232e-02f,
  1.18684717e-01f, -1.77367367e-02f, -4.97996248e-02f, 1.69522747e-01f, 1.45378456e-01f, -1.96658596e-01f, -7.27719665e-02f, -4.21126559e-02f, -1.05599940e-01f, -8.36138874e-02f,
  2.89518744e-01f, 2.40132511e-02f, -8.42973068e-02f, 7.04490393e-02f, 1.86964855e-01f, 1.63159415e-01f, 1.86221495e-01f, -1.63548991e-01f, -5.08335717e-02f, 3.50562073e-02f,
  2.04250515e-01f, 3.02968919e-01f, 6.61422387e-02f, -1.40612647e-01f, 2.80083418e-01f, 1.35721803e-01f, 1.75491020e-01f, 2.89863143e-02f, -9.51324627e-02f, -1.03572093e-01f,
  2.11468607e-01f, 2.51153037e-02f, 1.87898874e-02f, 2.32840404e-02f, 1.45654410e-01f, 1.59559056e-01f, 1.28324836e-01f, -1.83274448e-02f, -1.65416256e-01f, -5.96891530e-02f,
  -9.72033739e-02f, 1.33053571e-01f, -2.91550428e-01f, 8.56500342e-02f, -1.74286544e-01f, 6.90461993e-02f, 5.76775288e-03f, 1.77664086e-01f, -1.66481957e-01f, 1.12641066e-01f,
  1.60702795e-01f, -4.99297515e-04f, 1.06836073e-01f, -6.55416325e-02f, 7.42451549e-02f, -1.76272616e-02f, 2.82433834e-02f, -3.60524021e-02f, -9.79701336e-03f, 1.09632082e-01f,
  5.31948656e-02f, 1.24202348e-01f, 1.17064975e-01f, 7.53936765e-04f, -5.84239364e-02f, 1.82650119e-01f, -8.67894888e-02f, -1.57270357e-01f, -1.16788723e-01f, -8.96451846e-02f,
  -3.94932739e-02f, -7.95687586e-02f, -1.60555571e-01f, -8.28594193e-02f, -5.87908179e-02f, -8.69977847e-02f, 4.92521711e-02f, -1.45893723e-01f, -3.02918881e-01f, 1.49241775e-01f,
  -1.56568378e-01f, -2.50173900e-02f, 1.19065970e-01f, 2.82464083e-02f, -1.14098869e-01f, -1.42667875e-01f, -1.58920184e-01f, -4.91282605e-02f, -2.24209443e-01f, 2.05739096e-01f,
  4.45072539e-02f, 1.02155216e-01f, 2.37751424e-01f, 1.57608151e-01f, 5.67028336e-02f, -1.53949931e-01f, 5.20334579e-02f, -2.92888612e-01f, -1.30214885e-01f, -2.09646255e-01f,
  -1.69803500e-02f, -2.79520065e-01f, 1.74757451e-01f, 1.80514122e-04f, -1.26304701e-01f, -4.33137044e-02f, 4.19828594e-01f, 1.95385054e-01f, -1.52615502e-01f, 1.17139794e-01f,
  -1.92050621e-01f, -2.30153486e-01f, -1.27565756e-01f, -3.89865190e-01f, -6.31015887e-03f, -1.06076337e-01f, -1.89198643e-01f, 8.45373198e-02f, -9.53045264e-02f, 4.17798124e-02f,
  -1.04465395e-01f, -1.96118742e-01f, -6.35505766e-02f, -1.17944397e-01f, -4.27919365e-02f, -1.34243682e-01f, -8.40351954e-02f, -1.09436460e-01f, -8.08053315e-02f, -7.24647194e-02f,
  4.53874655e-03f, 1.80254057e-02f, -3.38280708e-01f, -1.66398101e-02f, -2.06715509e-01f, -1.93065070e-02f, 1.43490762e-01f, 1.27767429e-01f, -1.91568568e-01f, -1.13570597e-03f,
  8.56210478e-03f, 9.71472263e-02f, 9.58048180e-02f, 4.96266782e-02f, 1.39949203e-01f, 8.52795038e-03f, 6.94684014e-02f, -6.10096939e-02f, -3.61131579e-02f, -2.90655255e-01f,
  9.09824669e-02f, -1.26523999e-02f, -1.77241996e-01f, -5.47289029e-02f, 1.44319743e-01f, 2.36169949e-01f, 2.38985002e-01f, -6.55719489e-02f, -1.32301405e-01f, -1.89436257e-01f,
  -1.44449472e-02f, -4.41924529e-03f, -1.52381480e-01f, -3.47705521e-02f, -8.52635130e-02f, 2.81249341e-02f, -7.06252009e-02f, -9.31933969e-02f, -1.62550107e-01f, 1.07068665e-01f,
  2.17360690e-01f, -9.69635025e-02f, -7.66522884e-02f, 1.56040177e-01f, 1.50513604e-01f, 7.21265525e-02f, -8.66377428e-02f, 6.76611066e-03f, 1.19012989e-01f, 6.35648370e-02f,
  1.41601130e-01f, -7.75423348e-02f, 2.14969680e-01f, 7.91509449e-03f, -3.13125253e-02f, 1.35954088e-02f, -1.24808690e-02f, 3.80875468e-02f, 1.02450058e-01f, 6.56904355e-02f,
  -2.25937009e-01f, -1.65177569e-01f, -2.57350635e-02f, 1.23883525e-04f, -8.39773789e-02f, -6.83281720e-02f, -1.63003892e-01f, -1.57839820e-01f, 1.52868479e-02f, 1.07985353e-02f,
  4.37376387e-02f, -6.78808540e-02f, 1.18527330e-01f, 1.59305975e-01f, -1.65965438e-01f, 1.95837244e-01f, 6.63817003e-02f, 1.16131671e-01f, 1.09648630e-01f, 6.78883865e-02f,
  1.16589233e-01f, -3.48868996e-01f, -2.94522159e-02f, 3.33443850e-01f, 1.53661832e-01f, -1.27005577e-01f, 3.54277156e-03f, -1.68298170e-01f, -3.78906913e-02f, 1.55916035e-01f,
  -9.65535492e-02f, -1.72355901e-02f, 1.52532607e-01f, 3.11119519e-02f, 1.92046404e-01f, -1.03364829e-02f, 2.29382604e-01f, 3.01704228e-01f, 4.65336069e-02f, 9.79599208e-02f,
  5.64892590e-02f, 7.85635691e-03f, 4.01457585e-02f, 4.02564183e-02f, -3.42837602e-01f, -7.12664723e-02f, -2.17796624e-01f, 4.80297059e-02f, 1.72698721e-01f, -9.90970209e-02f,
  1.61473870e-01f, 3.80090028e-01f, 1.93807241e-02f, -9.09489766e-02f, 1.06397957e-01f, -2.35481150e-02f, -2.46014725e-02f, 3.26458253e-02f, 6.35229871e-02f, 9.54224393e-02f,
  8.40834826e-02f, -7.63100684e-02f, 4.01618294e-02f, 6.40667379e-02f, 1.00791924e-01f, 1.43407136e-01f, 1.66652456e-01f, -1.39741227e-01f, -3.31072649e-03f, 1.31512925e-01f,
  -1.79579496e-01f, 9.61023197e-03f, 2.15960264e-01f, -1.21419169e-02f, -3.24629364e-03f, 4.35795449e-02f, -1.75500885e-01f, -3.17108691e-01f, -4.88135032e-02f, 2.79129855e-02f,
  -9.94478390e-02f, 6.24762923e-02f, 6.74427673e-02f, 4.77337418e-03f, -6.13623904e-03f, 1.87117204e-01f, -3.22034806e-02f, -3.77344221e-01f, -2.67071705e-02f, 9.04863700e-02f,
  7.03532323e-02f, 8.46837182e-03f, 9.06266645e-03f, -1.03682645e-01f, 5.87988049e-02f, -1.60885438e-01f, -7.26919770e-02f, 2.51552999e-01f, 1.81457810e-02f, 4.83453162e-02f,
  -7.29744369e-03f, -2.60839731e-01f, 1.86730176e-01f, 5.45805097e-02f, 8.69230628e-02f, 1.65844932e-01f, 1.91956833e-01f, 2.08540902e-01f, 3.33374113e-01f, 1.84538180e-03f,
  3.09492648e-01f, -1.40975222e-01f, -2.02770814e-01f, -4.38781887e-01f, -1.35019377e-01f, 8.88803229e-03f, 1.45289019e-01f, 1.11193977e-01f, 6.64034039e-02f, 9.80210975e-02f,
  1.01146467e-01f, 1.07589416e-01f, 1.49956420e-01f, 1.79999828e-01f, 6.69205142e-03f, 1.43255144e-01f, 2.54893824e-02f, 7.98806995e-02f, -8.63695294e-02f, -4.27241400e-02f,
  1.83872104e-01f, -2.56377101e-01f, -1.31871505e-03f, 1.63195774e-01f, 2.25190088e-01f, 1.65788874e-01f, 9.82774273e-02f, 1.42057523e-01f, -4.76273755e-03f, -1.05075277e-01f,
  9.73249003e-02f, 7.03733712e-02f, -1.05495840e-01f, 3.35245836e-03f, 2.63140589e-01f, -2.30703279e-01f, 7.05778599e-02f, 1.66457519e-01f, -9.94025096e-02f, 3.17722231e-01f,
  3.15504670e-01f, -7.96982124e-02f, -1.74685232e-02f, 2.16768324e-01f, 1.84561118e-01f, 6.09329250e-03f, -5.17587401e-02f, -6.48503453e-02f, 1.13267921e-01f, -1.72520384e-01f,
  5.94897419e-02f, 1.17122166e-01f, 1.52020145e-03f, 2.35550746e-01f, -1.41622379e-01f, -3.84297334e-02f, 3.03837787e-02f, 2.25252345e-01f, 5.23330923e-03f, 8.92440826e-02f,
  1.97298795e-01f, 1.04795337e-01f, -3.00505042e-01f, -9.93951261e-02f, 1.29102185e-01f, -2.43329853e-02f, 1.33429058e-02f, 1.43344253e-01f, 2.64975220e-01f, 3.22926305e-02f,
  1.54511929e-01f, 1.19756227e-02f, 2.93867826e-01f, 2.01517001e-01f, 2.00591132e-01f, 7.46697485e-02f, 1.69932470e-01f, 1.10453688e-01f, -7.47593492e-02f, -3.44613120e-02f,
  6.97107753e-03f, 1.25815898e-01f, 1.61481336e-01f, 7.36338496e-02f, -1.04228571e-01f, 6.12506866e-02f, -1.57832056e-01f, -8.81044790e-02f, -6.24037571e-02f, 1.48398384e-01f,
  -2.81600691e-02f, -8.73214975e-02f, 6.14342950e-02f, 1.69424117e-01f, -2.66590059e-01f, 2.37470288e-02f, -2.62648351e-02f, -2.53267497e-01f, -5.78385592e-02f, 3.42889801e-02f,
  -9.54965129e-02f, 9.98132229e-02f, 2.63086352e-02f, -3.82068790e-02f, -1.12733722e-01f, -1.87142745e-01f, -2.23308608e-01f, 5.37580252e-02f, -8.24322179e-02f, 2.37544719e-02f,
  -1.56635672e-01f, 4.11802679e-02f, 3.04975748e-01f, -2.30655707e-02f, -8.12753737e-02f, -2.75693923e-01f, 9.99857113e-02f, -1.23814251e-02f, -4.43028472e-02f, -2.27192894e-01f,
  -1.14012279e-01f, 5.84122762e-02f, 1.73993349e-01f, 1.37513846e-01f, -9.43511631e-03f, -1.07051164e-01f, 3.34974736e-01f, 1.78914860e-01f, 2.12723792e-01f, -6.81348741e-02f,
  -1.28552735e-01f, 1.20800406e-01f, -3.49379107e-02f, -3.53416026e-01f, 9.08060372e-02f, -6.37124479e-02f, 4.43063714e-02f, 4.65948693e-02f, 1.02100084e-02f, 9.35909152e-02f,
  1.26728294e-02f, 6.58068806e-02f, 2.69676130e-02f, -3.00312489e-02f, 1.67274904e-02f, 1.59671411e-01f, 4.39801030e-02f, 2.20009424e-02f, -3.76372449e-02f, 3.36666266e-03f,
  -2.09320970e-02f, 2.97944620e-02f, -3.25926065e-01f, -1.16091976e-02f, -1.73201099e-01f, 1.69609450e-02f, 1.81855798e-01f, 3.39770988e-02f, -3.03396821e-01f, 1.10819809e-01f,
  -2.00762525e-01f, 2.83135980e-01f, 1.40148804e-01f, -1.11163795e-01f, 1.71680942e-01f, -2.20206767e-01f, 2.60241125e-02f, -1.60244659e-01f, 5.41620664e-02f, 3.42980288e-02f,
  1.79778747e-02f, -1.21080540e-01f, -1.16521642e-01f, -1.78066239e-01f, 2.38422021e-01f, 2.93335885e-01f, 7.66571164e-02f, -1.11932810e-02f, 2.72590052e-02f, 1.66493095e-02f,
  5.56511469e-02f, -4.51078229e-02f, -6.03147596e-02f, -1.78358898e-01f, -1.69551149e-01f, 2.37391219e-01f, 1.30304173e-02f, -1.82792827e-01f, 1.29124776e-01f, 9.61163864e-02f,
  1.99129060e-02f, -5.56533374e-02f, -7.44330287e-02f, 1.20138839e-01f, 1.28228918e-01f, -2.17810571e-01f, -1.54800236e-01f, 1.80113584e-01f, -5.65728135e-02f, 6.02657497e-02f,
  1.02289565e-01f, -7.84563925e-03f, 8.61925706e-02f, 3.63420621e-02f, 4.26492244e-02f, 1.93185359e-01f, -3.40436958e-03f, 8.36978108e-02f, 5.75434715e-02f, 1.79090470e-01f,
  1.01058565e-01f, -6.33686036e-03f, -8.64166468e-02f, 1.08624361e-01f, -2.67065186e-02f, 8.28847587e-02f, 1.12148158e-01f, 2.07532439e-02f, -4.31357697e-02f, 2.83253044e-02f,
  1.13518476e-01f, -7.63509870e-02f, 8.32711309e-02f, 2.44884506e-01f, -1.83974192e-01f, 3.26971337e-02f, 2.19483450e-01f, 2.11179703e-01f, -8.29481985e-03f, -6.02443293e-02f,
  -1.09453052e-01f, 2.62922525e-01f, -9.44046155e-02f, -3.74731310e-02f, 2.92756921e-03f, 2.08232537e-01f, 2.72840321e-01f, 5.89144491e-02f, 1.68176799e-03f, -9.08941701e-02f,
  -4.67901118e-02f, -9.68088284e-02f, 2.61011012e-02f, 1.68760583e-01f, -1.11203581e-01f, 3.88890691e-02f, -2.29235709e-01f, 6.19209297e-02f, 4.60331291e-02f, 4.91036549e-02f,
  4.18217443e-02f, -7.86796957e-02f, 1.32311165e-01f, 1.30856201e-01f, -6.19759001e-02f, -5.63343167e-02f, 9.16908681e-02f, 1.55960426e-01f, -2.81773061e-02f, 1.73976257e-01f,
  -7.46092275e-02f, -2.08310168e-02f, -1.46646677e-02f, 1.36360303e-01f, -5.63211963e-02f, 7.05697984e-02f, 5.67268468e-02f, 6.15421757e-02f, -1.31980702e-01f, -9.85881388e-02f,
  8.62092897e-02f, 1.64086044e-01f, -3.48452516e-02f, 1.12586565e-01f, 6.78599253e-02f, -4.48230952e-02f, 5.15522733e-02f, 1.05184559e-02f, 4.68794368e-02f, 6.68923631e-02f,
  -2.46869233e-02f, -2.85964590e-02f, 7.40206391e-02f, 1.66418627e-01f, 7.05481991e-02f, 4.81021442e-02f, 2.57475436e-01f, -7.35158846e-02f, 4.00541238e-02f, 9.29855555e-03f,
  1.68988541e-01f, 2.57281195e-02f, 4.01611850e-02f, -1.76710516e-01f, -1.25874922e-01f, 8.56009498e-02f, 2.14141116e-01f, 2.24367514e-01f, 6.35926574e-02f, -3.01042870e-02f,
  2.18731329e-01f, 1.00091383e-01f, 7.82098994e-02f, 1.24414831e-01f, -1.40850753e-01f, -1.51534125e-01f, 2.33318344e-01f, 1.66090634e-02f, 9.54179987e-02f, 1.00881964e-01f,
  1.33427724e-01f, 1.77499548e-01f, -4.18349467e-02f, -6.44742027e-02f, -1.47493765e-01f, -2.45234817e-01f, -1.32976938e-02f, 2.35884368e-01f, -2.18555957e-01f, -2.47170087e-02f,
  -8.25505238e-03f, 4.33328785e-02f, 7.58883879e-02f, -2.69814879e-01f, -2.00664684e-01f, 2.50973374e-01f, 2.00879768e-01f, 3.61535549e-02f, 2.26471394e-01f, 1.22994848e-01f,
  1.50253758e-01f, 1.93895604e-02f, 9.90317836e-02f, 1.70427889e-01f, 1.62363365e-01f, 2.02581268e-02f, 2.34738305e-01f, -1.25700887e-02f, -2.57296860e-01f, 5.28823920e-02f,
  7.32187480e-02f, -1.89671412e-01f, -1.38245493e-01f, -1.74147606e-01f, 2.54298717e-01f, 1.68446466e-01f, 1.60557985e-01f, 1.36421800e-01f, 4.76787575e-02f, -4.51620929e-02f,
  1.67761162e-01f, -4.51555215e-02f, -8.98220912e-02f, -1.70926005e-01f, -1.12057298e-01f, -2.28186265e-01f, -1.04682177e-01f, 3.97873372e-01f, 6.31890073e-02f, 3.65777500e-02f,
  -1.71179280e-01f, 6.66501150e-02f, -1.02909125e-01f, 8.99930224e-02f, 5.71400337e-02f, -1.99598148e-01f, -3.55220586e-01f, -1.70442298e-01f, 5.47331311e-02f, -6.39355183e-02f,
  -1.45048827e-01f, -1.93888731e-02f, 8.81471857e-02f, 4.98814322e-02f, -5.02771372e-03f, 1.34236645e-02f, 1.96865480e-03f, 1.28407240e-01f, 1.57588981e-02f, 6.21645432e-03f,
  -5.58538027e-02f, -7.53645673e-02f, -7.99741521e-02f, -2.63631791e-01f, 2.70237744e-01f, -1.46571487e-01f, -1.33265436e-01f, 2.90680438e-01f, 2.67378271e-01f, 7.65861664e-03f,
  1.50936365e-01f, 1.20370038e-01f, 1.50766209e-01f, 1.46818860e-03f, 6.65493235e-02f, 9.05346200e-02f, -1.71210989e-02f, 6.03703819e-02f, 5.90323769e-02f, 8.36604014e-02f,
  6.92717135e-02f, -7.97960237e-02f, -2.18110248e-01f, -6.55474439e-02f, 1.74808711e-01f, -2.54352003e-01f, -1.40395686e-01f, -1.53798610e-01f, -1.68419741e-02f, -4.35871109e-02f,
  3.60002279e-01f, 1.53234094e-01f, 6.37771264e-02f, -6.77064210e-02f, 3.88839319e-02f, -4.40928608e-01f, -1.88373938e-01f, -5.14850199e-01f, -3.45753878e-01f, 1.17660873e-01f,
  -1.18719757e-01f, 3.59396875e-01f, 2.20171064e-02f, -7.63499588e-02f, -8.56047422e-02f, 1.37947813e-01f, -1.81444347e-01f, -1.43518075e-01f, -6.77695647e-02f, -2.20526755e-01f,
  -2.43095189e-01f, -2.35665649e-01f, -2.76697010e-01f, 7.55527690e-02f, 1.31788358e-01f, -2.09669828e-01f, 1.10794365e-01f, 1.69500425e-01f, 3.32090497e-01f, 3.24388444e-01f,
  1.79720208e-01f, -1.64726019e-01f, 1.78810000e-01f, 1.71110570e-01f, -1.78592592e-01f, -3.54088753e-01f, 1.24952860e-01f, 2.31232584e-01f, 3.10107231e-01f, -2.34399065e-01f,
  -3.68436128e-01f, -4.09433097e-01f, 2.31019080e-01f, -4.62799892e-02f, -7.39663467e-02f, 3.31575781e-01f, -2.06502192e-02f, -9.11753345e-03f, 4.26630788e-02f, -6.03281483e-02f,
  -8.51118285e-03f, 1.40050009e-01f, 1.08719662e-01f, 1.56379968e-01f, 9.63269025e-02f, 9.34172720e-02f, -2.26841308e-03f, 6.33783415e-02f, 7.21068680e-02f, 7.63065144e-02f,
  5.88961914e-02f, 8.30903202e-02f, 2.22186163e-01f, -3.39061692e-02f, -6.70161247e-02f, 7.28832111e-02f, -1.27435252e-01f, -1.55301262e-02f, 1.88627854e-01f, 2.07430050e-01f,
  -1.81019112e-01f, 6.19170181e-02f, 3.38108718e-01f, 1.17836088e-01f, -1.20523937e-01f, -5.97338043e-02f, -1.81620136e-01f, 2.00148180e-01f, 4.45193052e-02f, 2.19318986e-01f,
  1.46154016e-01f, 1.86876491e-01f, 1.21785544e-01f, -4.93400544e-02f, -1.22818455e-01f, -8.89478028e-02f, -2.05627847e-02f, -1.48879230e-01f, 4.35574651e-02f, 1.70405164e-01f,
  -1.71997435e-02f, 2.11667404e-01f, -1.73803777e-01f, 5.26003651e-02f, -1.22636259e-01f, 3.93140167e-02f, -1.38772771e-01f, -6.26282841e-02f, 2.89945990e-01f, 3.75396870e-02f,
  -2.81909615e-01f, 7.17759132e-02f, -1.41481072e-01f, 1.65065095e-01f, 1.87743410e-01f, -1.69098541e-01f, 9.17758718e-02f, -2.88980994e-02f, 1.17866419e-01f, 1.34310424e-02f,
  -2.48114509e-03f, 5.32392459e-03f, 2.08586231e-02f, 3.74128446e-02f, 5.09983636e-02f, 5.69182523e-02f, 3.52784544e-02f, 1.45203635e-01f, 1.11793347e-01f, 8.28546137e-02f,
  -1.29878055e-02f, 1.36914387e-01f, -7.61122480e-02f, -1.31381467e-01f, -1.55196071e-01f, 5.18967547e-02f, -6.48256764e-02f, -1.74734578e-01f, 7.12754205e-02f, 1.16900161e-01f,
  -3.05309501e-02f, -5.29161766e-02f, -1.91881042e-02f, -1.92358345e-01f, -1.09654136e-01f, 1.38705388e-01f, 5.63168563e-02f, -1.07795879e-01f, 1.41927689e-01f, 4.55969833e-02f,
  5.86844869e-02f, 2.44698435e-01f, -1.15949064e-01f, -7.68958703e-02f, 5.12833670e-02f, -1.51921704e-01f, 1.42095253e-01f, -1.13657445e-01f, 2.60723561e-01f, 1.20649695e-01f,
  6.25108853e-02f, -1.07453614e-01f, 1.73801690e-01f, -9.21152532e-02f, 9.52089205e-02f, 1.42671794e-01f, 2.12952390e-01f, -1.56087736e-02f, 5.56421652e-02f, 4.95190881e-02f,
  -2.20144372e-02f, 1.36600643e-01f, 2.82050148e-02f, 2.63570726e-01f, -2.17448324e-01f, 6.51887581e-02f, 7.83700794e-02f, -1.31292921e-02f, 1.24368586e-01f, -2.40303725e-01f,
  2.67439056e-02f, 2.01136380e-01f, 2.82971840e-02f, 1.38506949e-01f, 1.29363313e-01f, 1.71120122e-01f, 7.35548139e-02f, 2.53342330e-01f, 5.51852249e-02f, 1.64270893e-01f,
  7.28121325e-02f, 1.54807180e-01f, 6.58622012e-02f, 1.33564383e-01f, 3.15424412e-01f, 5.02385013e-02f, -3.69474068e-02f, 2.57312536e-01f, -7.94354007e-02f, -1.40214479e-02f,
  -2.98341542e-01f, 6.68887049e-02f, -2.48398066e-01f, 5.93457744e-02f, 6.24701865e-02f, 6.09207116e-02f, -3.57798636e-01f, 1.63968518e-01f, -9.50423777e-02f, 1.02099195e-01f,
  2.92348582e-02f, 6.96248561e-02f, 6.16631880e-02f, -1.91527948e-01f, 2.45005321e-02f, -9.57147703e-02f, -9.11182538e-02f, -3.57259661e-02f, 1.72091588e-01f, 2.25331299e-02f,
  -6.63812980e-02f, 8.49154871e-03f, 1.20597985e-02f, 2.30735630e-01f, 3.06303293e-01f, -1.24692485e-01f, -1.56525284e-01f, 3.32181528e-02f, 7.44357556e-02f, -5.31384461e-02f,
  -9.49228629e-02f, 1.55402534e-02f, -1.75504640e-01f, 2.84446031e-01f, -7.83701390e-02f, -1.58181608e-01f, 3.04878324e-01f, -3.08818556e-03f, 2.28679344e-01f, -6.85048699e-02f,
  -5.08719981e-02f, -3.69608663e-02f, 1.27036080e-01f, -2.16524690e-01f, -2.13730663e-01f, -9.58507285e-02f, 4.59262654e-02f, 7.96090811e-02f, 1.89876437e-01f, 8.34086165e-02f,
  -8.51164572e-03f, 5.90573326e-02f, -7.04539269e-02f, 1.06290728e-01f, 8.49226676e-03f, 6.38580173e-02f, 1.75675809e-01f, 5.42489849e-02f, 1.69045702e-01f, 1.69682935e-01f,
  -7.81598017e-02f, 3.11444938e-01f, 1.25503317e-01f, 2.96379030e-02f, -1.18689038e-01f, -8.78460482e-02f, -2.36524314e-01f, 5.94030581e-02f, -8.65917578e-02f, 1.34639695e-01f,
  7.27787316e-02f, 2.35762209e-01f, -1.95194706e-01f, 2.50217557e-01f, 1.09992035e-01f, 2.59145319e-01f, 2.91611552e-02f, -1.25819117e-01f, -5.94517440e-02f, -6.51568547e-02f,
  2.76264939e-02f, 9.24795717e-02f, -6.93736970e-02f, 8.66409093e-02f, -2.04682052e-01f, 9.49131772e-02f, 2.16353446e-01f, 2.06992924e-01f, -7.51555189e-02f, 6.89871376e-03f,
  -8.21466595e-02f, -2.08302751e-01f, 2.48748772e-02f, -7.28646070e-02f, -8.85140970e-02f, 8.43347982e-02f, 3.25059369e-02f, -1.10757947e-01f, 6.68112487e-02f, -1.82690740e-01f,
  5.07205762e-02f, 1.29484221e-01f, 7.51455724e-02f, 1.94743276e-02f, -1.03427060e-01f, 1.70080855e-01f, 8.33669752e-02f, -2.71088600e-01f, -7.00264871e-02f, 3.67018133e-02f,
  -1.57017838e-02f, 1.53605476e-01f, 1.22452743e-01f, 1.30920932e-02f, 1.10007748e-02f, -1.31747881e-02f, 1.79820225e-01f, -2.67859865e-02f, 1.70236398e-02f, 7.04048946e-02f,
  1.93793431e-01f, 1.81417037e-02f, 2.14798778e-01f, -7.72684962e-02f, 6.84693456e-02f, 1.34335356e-02f, -5.91336116e-02f, 1.52469337e-01f, -5.40031232e-02f, 1.67000040e-01f,
  -1.03062816e-01f, 1.22442819e-01f, -3.41879934e-01f, -8.53401423e-02f, 1.62115365e-01f, -3.70906055e-01f, 1.41132891e-01f, 5.87815233e-02f, 4.97536957e-02f, 3.41491029e-02f,
  -9.39091519e-02f, 1.45445928e-01f, 7.44973272e-02f, 3.57718468e-01f, -1.18148603e-01f, -1.20022587e-01f, 6.11717105e-02f, 4.06046882e-02f, -1.06597662e-01f, 2.43226126e-01f,
  1.13733254e-01f, 1.82220876e-01f, -5.57305254e-02f, -1.05944145e-02f, 6.07259758e-02f, -8.16808194e-02f, 1.19946711e-01f, 7.83645138e-02f, 9.65257175e-03f, -1.72097757e-01f,
  -7.50080720e-02f, 5.71233518e-02f, 2.17056036e-01f, -1.50974721e-01f, -1.09007023e-01f, 1.77605405e-01f, 6.88651726e-02f, 1.32162690e-01f, 1.03601858e-01f, -1.74531136e-02f,
  -2.22311094e-01f, -2.73717761e-01f, -7.55955800e-02f, -7.64086321e-02f, -3.89257595e-02f, 8.60415474e-02f, -1.47153195e-02f, 1.34716593e-02f, 7.46329501e-02f, -1.67756621e-02f,
  -4.44122925e-02f, 5.61378822e-02f, -4.31932099e-02f, -1.16881207e-01f, -2.47491896e-02f, 3.78892869e-02f, -1.47902951e-01f, -1.02098249e-01f, -1.71132028e-01f, -3.25687043e-02f,
  -5.01415543e-02f, 5.23717282e-03f, -1.36151537e-01f, 1.40109761e-02f, -1.17354773e-01f, -6.68512508e-02f, -2.02460423e-01f, -1.20475322e-01f, 1.20234184e-01f, -1.59450442e-01f,
  6.46885559e-02f, 5.68159372e-02f, 4.35631238e-02f, -1.90524071e-01f, 2.28102803e-02f, -7.84964710e-02f, 9.17361304e-02f, -1.46473840e-01f, 5.51575422e-02f, 3.98780555e-02f,
  1.38488829e-01f, 9.22577605e-02f, -1.06269412e-01f, 1.26454383e-01f, 2.95371234e-01f, 1.94091484e-01f, -1.65539328e-02f, 2.71035999e-01f, -1.22256383e-01f, -2.89681293e-02f,
  2.03002572e-01f, -7.92241469e-02f, -7.99160749e-02f, -6.99250326e-02f, -8.90483782e-02f, 1.37534097e-01f, 7.67870769e-02f, -4.67609838e-02f, -1.52298734e-01f, 1.96649194e-01f,
  1.52269706e-01f, 2.94005256e-02f, -3.07492584e-01f, 2.11700629e-02f, 7.58510903e-02f, 7.57626966e-02f, -2.96573285e-02f, -2.25303378e-02f, 2.46772155e-01f, 1.33317545e-01f,
  6.55004606e-02f, 1.38818875e-01f, 6.61031983e-04f, 1.25101537e-01f, 1.69516698e-01f, 9.78938024e-03f, 6.00157445e-03f, 9.44868755e-03f, 1.26460373e-01f, 9.16429535e-02f,
  5.40646203e-02f, -7.62632340e-02f, 6.96632266e-02f, 2.43834984e-02f, -1.51382938e-01f, 1.99457109e-02f, 1.45363003e-01f, 7.19080493e-02f, 7.09722610e-03f, 4.27446589e-02f,
  -1.15314133e-01f, -5.86895086e-03f, -5.25934845e-02f, -1.59621939e-01f, -5.91803305e-02f, 5.03642745e-02f, 7.04686493e-02f, -2.43171930e-01f, 1.78598002e-01f, -3.23562212e-02f,
  3.63453105e-02f, 1.07470340e-04f, 8.92914459e-02f, -8.49362165e-02f, -6.46399260e-02f, -2.12127149e-01f, 2.43680894e-01f, 1.93299606e-01f, 1.46479309e-01f, 8.90668184e-02f,
  -3.63641046e-02f, -1.82392925e-01f, 1.58943951e-01f, 1.87711567e-02f, 6.58855885e-02f, 2.85798665e-02f, 2.10107297e-01f, 4.83762426e-03f, 5.51005900e-02f, 4.58886586e-02f,
  -2.38191307e-01f, 2.05850601e-01f, 6.75063431e-02f, 2.15700254e-01f, -1.03118047e-01f, -4.15890571e-03f, -7.89646655e-02f, -2.63802577e-02f, 3.54315192e-02f, 1.23009510e-01f,
  -7.23116100e-02f, 7.34089762e-02f, 1.96555421e-01f, -4.26436365e-02f, 1.06407432e-02f, 2.70546731e-02f, -6.26944229e-02f, 1.43858194e-01f, 4.67838682e-02f, 8.03710669e-02f,
  6.98276460e-02f, 8.77708718e-02f, 2.41102099e-01f, -7.30422884e-02f, -2.45932892e-01f, -1.31975487e-01f, 1.31892785e-01f, -4.78690043e-02f, 1.12918213e-01f, -3.30161527e-02f,
  1.80624500e-01f, 6.54700398e-02f, 4.22036238e-02f, -3.55697758e-02f, 2.14848533e-01f, -8.77885595e-02f, 2.63538569e-01f, 1.01739705e-01f, -6.63734451e-02f, 5.18651754e-02f,
  8.64057392e-02f, -3.89701456e-01f, 9.23810154e-02f, 1.20999880e-01f, 1.82018802e-01f, -2.05049455e-01f, -2.06700951e-01f, 2.42434740e-01f, 1.59394309e-01f, 1.38453394e-01f,
  2.58173943e-01f, 1.93391243e-05f, 9.23300758e-02f, 9.08544287e-03f, 1.75445154e-02f, 2.46181879e-02f, 7.43840933e-02f, -9.29121897e-02f, 1.58568352e-01f, 6.44412339e-02f,
  4.99072149e-02f, 2.83561617e-01f, -5.46532907e-02f, 2.08104141e-02f, -1.39384821e-01f, 5.09376265e-02f, -5.82628585e-02f, 1.22035548e-01f, -2.39957884e-01f, -7.96306804e-02f,
  -1.52429730e-01f, 9.32669044e-02f, 1.17501810e-01f, 3.83414984e-01f, 1.70037419e-01f, 3.45574707e-01f, 5.77291884e-02f, 1.72460899e-01f, 1.93811268e-01f, 2.35539138e-01f,
  -7.20001310e-02f, 1.12265944e-01f, 1.61096919e-02f, 1.09187044e-01f, 1.99298531e-01f, 6.02238439e-02f, 9.58658084e-02f, 6.68898374e-02f, 8.29105303e-02f, -2.99409945e-02f,
  -1.09980747e-01f, -9.11829434e-03f, 3.29285078e-02f, 8.08649659e-02f, 2.06865147e-01f, 1.93395570e-01f, -1.05182022e-01f, -3.16281691e-02f, -2.28660047e-01f, 8.31703767e-02f,
  3.20982546e-01f, 6.61560753e-03f, 1.48094341e-01f, -4.39495407e-02f, 2.78028190e-01f, 3.66655961e-02f, -1.51672557e-01f, 1.18998429e-02f, 1.52516574e-01f, 2.44597390e-01f,
  3.15018669e-02f, -4.18487824e-02f, 3.97357345e-02f, 1.44837052e-01f, -2.22358084e-03f, 9.49269459e-02f, -4.12981585e-03f, -1.56016886e-01f, 5.23821125e-03f, -2.61482924e-01f,
  6.12634383e-02f, 8.80579725e-02f, 1.29683271e-01f, 1.35214433e-01f, -1.48796573e-01f, 1.19921438e-01f, 2.54883319e-01f, 1.23604253e-01f, 9.63186473e-02f, -3.09799880e-01f,
  -5.46393469e-02f, 1.74184620e-01f, -1.50159255e-01f, -1.53579861e-01f, -9.93021857e-03f, -9.60402861e-02f, -1.16062157e-01f, 2.64725178e-01f, 2.71676835e-02f, 6.47398233e-02f,
  5.54299578e-02f, 4.18161564e-02f, 1.49184808e-01f, 1.65595233e-01f, 1.52960971e-01f, -4.26682178e-03f, 2.35308245e-01f, 1.69369698e-01f, 1.55307263e-01f, 1.44061362e-02f,
  5.31997308e-02f, 9.69321206e-02f, 7.30722249e-02f, 2.06143707e-01f, 8.63857865e-02f, 4.94351657e-03f, -6.86953440e-02f, -9.18345675e-02f, 2.31212765e-01f, -8.43954906e-02f,
  1.95053428e-01f, 1.23292826e-01f, 7.93793201e-02f, 7.05518667e-03f, -3.12756561e-02f, 4.80202101e-02f, -3.63392979e-02f, 2.75496356e-02f, -1.44466415e-01f, 1.81901589e-01f,
  -1.30017936e-01f, 2.84178287e-01f, -1.66408554e-01f, 2.00243145e-01f, -2.52110183e-01f, 1.98008657e-01f, 2.38439217e-02f, 6.15116879e-02f, 6.62155971e-02f, -1.10171258e-01f,
  -2.33616665e-01f, -4.16815542e-02f, 1.16213057e-02f, -3.72295767e-01f, -1.47311920e-02f, 3.35725620e-02f, -4.49102484e-02f, 3.39284986e-02f, -2.06417814e-02f, 1.84876680e-01f,
  5.77174798e-02f, -7.55960271e-02f, 1.33662894e-01f, -1.05712146e-01f, 8.56713131e-02f, -1.69814691e-01f, -2.40810644e-02f, -1.47503063e-01f, 3.62527519e-01f, 1.57314524e-01f,
  -2.01267123e-01f, -9.26560387e-02f, 7.85221159e-02f, 4.03412804e-02f, 2.44035885e-01f, 1.79290809e-02f, -1.36861384e-01f, 1.31384745e-01f, 1.84519980e-02f, 8.31511542e-02f,
  1.33566976e-01f, -2.80221459e-03f, 9.33874175e-02f, 1.25013843e-01f, -5.69128171e-02f, 1.08128879e-02f, -2.16493607e-01f, 8.74487385e-02f, -2.74600349e-02f, -1.84181362e-01f,
  1.11991741e-01f, 7.34794065e-02f, -1.61140636e-01f, -8.24374780e-02f, 4.80636694e-02f, 8.96783322e-02f, 1.53382514e-02f, 2.78907232e-02f, -5.81408618e-03f, -1.76526710e-01f,
  -4.71331030e-02f, 2.57646322e-01f, 4.61964943e-02f, -2.93096490e-02f, 2.69895434e-01f, -8.90713111e-02f, -1.19971149e-02f, -1.02698609e-01f, 4.19447683e-02f, -7.53523931e-02f,
  4.50892299e-02f, -1.69328332e-01f, -4.14285474e-02f, 1.29362836e-03f, 3.01726073e-01f, 2.35876292e-01f, 1.16035841e-01f, 8.34699124e-02f, 8.73693824e-02f, 4.84985225e-02f,
  1.44915253e-01f, 5.07483631e-02f, 1.49755374e-01f, -1.05749615e-01f, -1.08231425e-01f, 1.80478185e-01f, -1.52460650e-01f, 1.19475044e-01f, -1.24218211e-01f, 8.20556283e-02f,
  1.51718885e-01f, -7.11893736e-05f, -8.92846286e-02f, -4.07222956e-02f, 1.31976426e-01f, 9.60137025e-02f, -2.80274838e-01f, 2.30953127e-01f, 2.00094461e-01f, 8.45200643e-02f,
  1.65686131e-01f, 2.68020332e-02f, 4.24593650e-02f, 7.01892748e-02f, 1.52783424e-01f, -2.22913623e-02f, 3.69098820e-02f, -3.45030837e-02f, 6.83242083e-02f, 7.87680596e-02f,
  -7.38889650e-02f, -2.48668790e-02f, 1.79738671e-01f, -4.65667993e-02f, 1.03418998e-01f, -7.05877095e-02f, 5.08876108e-02f, -3.03306520e-01f, 2.62370724e-02f, -1.84151903e-02f,
  1.53028846e-01f, 1.39512122e-01f, -9.32995901e-02f, -8.10361877e-02f, -1.25446469e-01f, 1.92153141e-01f, -6.71549141e-02f, 6.15325794e-02f, 2.31395498e-01f, 1.06744478e-02f,
  -4.85207103e-02f, -1.11575723e-01f, 2.22085506e-01f, 8.30055475e-02f, -1.36643171e-01f, -3.26095998e-01f, 7.19955787e-02f, 1.85312673e-01f, 4.45104875e-02f, 2.14133989e-02f,
  -1.00608654e-01f, -7.11288527e-02f, 2.90049255e-01f, -5.84818497e-02f, -1.27081379e-01f, 7.89441168e-02f, 2.56335139e-01f, 2.16498494e-01f, 6.44206330e-02f, 4.44278233e-02f,
  -1.22971177e-01f, 4.48162988e-04f, -1.94970697e-01f, 1.06324583e-01f, -1.19331852e-02f, 1.11098155e-01f, -2.05482379e-01f, -6.51155934e-02f, 1.08200237e-01f, -2.13623010e-02f,
  2.59344965e-01f, 3.22261095e-01f, 9.52556450e-03f, 1.58547819e-01f, 1.95549298e-02f, 5.64435497e-02f, 4.78230305e-02f, 4.48038355e-02f, -9.68123898e-02f, -1.21543393e-01f,
  6.22004159e-02f, 2.17987850e-01f, -2.46022660e-02f, 1.54333919e-01f, 1.63208306e-01f, 9.42519009e-02f, 4.88441028e-02f, -2.11319979e-02f, -9.80682895e-02f, -2.38832757e-01f,
  -6.05240017e-02f, -2.04603836e-01f, -3.27438787e-02f, -5.79137914e-02f, 1.07931517e-01f, 1.28571734e-01f, -1.67267188e-01f, -8.06770548e-02f, -8.24741498e-02f, -2.80744042e-02f,
  -2.98714459e-01f, 3.06476563e-01f, -8.31141248e-02f, -7.73481578e-02f, 3.33948061e-02f, -4.62991633e-02f, -1.63422838e-01f, -9.91340913e-03f, -5.79619892e-02f, 8.70296080e-03f,
  4.02999222e-02f, -2.03957424e-01f, -5.49845546e-02f, -5.02828360e-02f, -9.14816260e-02f, -9.31748971e-02f, -1.16282754e-01f, -5.48583940e-02f, -1.16320373e-02f, 6.61556795e-02f,
  5.01758344e-02f, -2.07263976e-01f, 7.44794384e-02f, -2.16799632e-01f, -1.67406917e-01f, 2.22520903e-01f, -5.29015884e-02f, -1.74976215e-01f, 4.01451200e-01f, 1.17165036e-01f,
  -2.38593239e-02f, 1.72194228e-01f, -3.10943872e-02f, 1.19038476e-02f, 8.76205415e-02f, -1.79506570e-01f, 2.00139195e-01f, 1.53261676e-01f, 1.22157477e-01f, 1.21032991e-01f,
  2.52376705e-01f, 1.79259360e-01f, 9.96779501e-02f, -4.16807942e-02f, 8.15534219e-02f, -1.58617515e-02f, -7.22694993e-02f, 2.93420465e-03f, 2.95461677e-02f, -1.16523974e-01f,
  1.66003421e-01f, -4.84306812e-02f, -6.78752214e-02f, -2.80708134e-01f, -8.71303156e-02f, -3.77766520e-01f, 1.09892398e-01f, -8.75405502e-03f, 1.23546667e-01f, 3.40689681e-02f,
  3.17565091e-02f, 1.82729259e-01f, 4.94285896e-02f, -3.20776994e-03f, -2.65397489e-01f, 1.29754275e-01f, 1.12645335e-01f, 2.24994883e-01f, 1.92746863e-01f, -2.82576531e-01f,
  -1.99319705e-01f, 1.33224323e-01f, -1.20028801e-01f, -2.62915641e-01f, 7.46602938e-02f, -3.11074764e-01f, -1.24553479e-01f, -5.59036657e-02f, -4.68866862e-02f, -2.11453378e-01f,
  1.98225737e-01f, -1.25517920e-01f, 6.73273504e-02f, 1.43871322e-01f, 2.77629077e-01f, 2.13169977e-01f, 1.80888586e-02f, 5.89684844e-02f, -3.33518870e-02f, 2.97964782e-01f,
  -6.41756207e-02f, -2.39254162e-01f, 9.81791178e-04f, 1.21306852e-01f, 9.37051028e-02f, -3.32477055e-02f, 1.56069160e-01f, 1.24862880e-01f, 7.80144110e-02f, 2.14392483e-01f,
  1.28921866e-01f, -6.81573153e-02f, 5.01798131e-02f, 9.27451551e-02f, -2.85797250e-02f, 1.28711993e-02f, 1.44069731e-01f, 1.34217963e-01f, 8.98455009e-02f, -3.56672816e-02f,
  1.05293356e-01f, 1.07772514e-01f, 1.88908309e-01f, 1.92806438e-01f, 1.88472137e-01f, -1.84660614e-01f, -2.21148044e-01f, 4.87793386e-02f, 4.75749038e-02f, -1.06593948e-02f,
  1.73367217e-01f, 3.09932120e-02f, -6.94958121e-02f, 1.57947242e-01f, -3.01433593e-01f, -2.12768197e-01f, -6.25036061e-02f, -3.00696474e-02f, 1.99067220e-02f, 4.45167124e-02f,
  8.80179629e-02f, 1.13727376e-01f, 1.38888940e-01f, 3.68916273e-01f, -9.55154449e-02f, -4.22823131e-01f, -1.37374997e-01f, 1.48013039e-02f, 2.62716025e-01f, 3.89833227e-02f,
  -1.04022093e-01f, 3.30032147e-02f, -1.97522603e-02f, -2.39019185e-01f, -6.99889427e-03f, -4.24436219e-02f, 8.79509151e-02f, 3.00457664e-02f, 1.48982704e-01f, -1.48568168e-01f,
  4.42140251e-02f, 8.49387273e-02f, -7.70687014e-02f, 2.48753250e-01f, 7.85377845e-02f, 4.67860140e-02f, 1.59920812e-01f, 2.38452464e-01f, 2.74097353e-01f, -2.11413190e-01f,
  -1.22286640e-01f, 3.84403542e-02f, -1.30358025e-01f, -2.26040080e-01f, 1.14816673e-01f, -1.33107472e-02f, -8.37657303e-02f, -7.70276859e-02f, -9.95857716e-02f, 5.47748171e-02f,
  1.90955810e-02f, -4.39366475e-02f, -1.63991794e-01f, -8.30888972e-02f, -1.52464867e-01f, 7.49660935e-03f, -2.50388712e-01f, 1.08412720e-01f, -7.71058947e-02f, -1.46842942e-01f,
  4.60917689e-02f, -1.19404146e-03f, -2.17014432e-01f, -9.07934010e-02f, 1.49430737e-01f, 1.86289251e-01f, -7.38391420e-03f, 6.09680489e-02f, 7.35001117e-02f, 2.85096951e-02f,
  -1.74098715e-01f, 1.09071679e-01f, 6.52839839e-02f, -1.28438935e-01f, 1.03246711e-01f, 5.64337410e-02f, -2.95883954e-01f, -1.55430153e-01f, 2.21217468e-01f, 1.87893972e-01f,
  1.92415595e-01f, 7.99411684e-02f, -2.13151649e-01f, -2.07126185e-01f, 5.42441197e-02f, 8.27935860e-02f, 8.93201157e-02f, 7.97040313e-02f, 5.95935248e-02f, 7.29837045e-02f,
  -4.39947359e-02f, -3.21910717e-02f, 4.85757552e-02f, 2.66008209e-02f, -8.95974711e-02f, 1.25043914e-01f, -9.02301222e-02f, -8.06579217e-02f, 8.75581950e-02f, -2.12001652e-01f,
  -1.08500935e-01f, 5.44443205e-02f, 1.33559899e-02f, 1.08950548e-01f, 1.44498199e-01f, -1.30814895e-01f, 1.26678213e-01f, 1.43917412e-01f, -6.77723140e-02f, -3.26824822e-02f,
  3.65272127e-02f, 8.73789862e-02f, 1.40663637e-02f, -3.87588255e-02f, -3.12471054e-02f, -1.77464467e-02f, -1.53983375e-02f, 1.23607352e-01f, -4.14994955e-02f, -5.19818813e-02f,
  1.28580540e-01f, 2.65431590e-02f, 1.51858032e-01f, 3.01462449e-02f, 4.31753732e-02f, 2.11829487e-02f, -3.10683772e-02f, 4.56198268e-02f, -8.57467651e-02f, 3.89680499e-03f,
  -3.32082622e-03f, 6.79288730e-02f, 5.54540940e-02f, -2.85195023e-01f, 6.74393028e-02f, 4.71494757e-02f, 4.61389162e-02f, -6.88502714e-02f, -1.91960705e-03f, 6.62453845e-02f,
  -7.69301224e-03f, -8.76781624e-03f, 2.77882516e-01f, -1.60836559e-02f, -1.05972901e-01f, -1.66526269e-02f, 1.47982419e-01f, 2.67020106e-01f, 2.00392619e-01f, 9.25268084e-02f,
  -1.39504969e-01f, 3.41437645e-02f, 3.40447128e-02f, -1.63221762e-01f, 1.96058676e-02f, 4.01394479e-02f, 1.51446596e-01f, -1.02830485e-01f, 9.22947824e-02f, -1.93352938e-01f,
  -1.17519833e-01f, -4.85798530e-02f, -3.64782631e-01f, 2.28913233e-01f, 2.36255020e-01f, 3.55717563e-03f, -1.23090565e-01f, -6.87494576e-02f, 7.98091572e-03f, -9.58350077e-02f,
  -1.36480987e-01f, 7.16241356e-03f, 1.74804524e-01f, 1.21077403e-01f, 1.15742102e-01f, 2.40791127e-01f, 9.98157188e-02f, 2.76806414e-01f, 1.66826054e-01f, 2.25542828e-01f,
  -1.86996534e-02f, -7.19896406e-02f, 1.41886145e-01f, 1.24149002e-01f, 1.04717180e-01f, 2.96307020e-02f, 3.22016627e-02f, 1.04102753e-01f, -1.34752244e-01f, 2.24298518e-02f,
  -2.13041157e-02f, -1.03493549e-01f, 6.58024009e-03f, -8.99874140e-03f, -2.77263112e-02f, -1.51254207e-01f, -1.98538855e-01f, 6.90009817e-02f, 4.01881486e-02f, 7.35891387e-02f,
  -5.60819246e-02f, -1.92790359e-01f, 7.04859048e-02f, -1.28436945e-02f, 1.78244844e-01f, -2.03781188e-01f, -2.74096519e-01f, -1.44923031e-01f, 1.02050789e-01f, -1.61761604e-03f,
  -3.48363407e-02f, 4.50951532e-02f, -2.33129174e-01f, 1.22316130e-01f, 3.45840156e-01f, 1.62063867e-01f, -4.26673470e-03f, 1.27680344e-03f, 1.46701530e-01f, -1.16657084e-02f,
  3.09190284e-02f, 1.81353748e-01f, -1.80014551e-01f, -9.04249260e-04f, 1.77565679e-01f, -1.65899452e-02f, 3.84557903e-01f, -1.30358607e-01f, 1.49951074e-02f, 5.75145446e-02f,
  3.01279444e-02f, -4.74879257e-02f, 1.29744783e-01f, 1.98888212e-01f, -1.73516586e-01f, 8.73598382e-02f, 5.85366338e-02f, 1.07779421e-01f, 8.09033290e-02f, -5.21089248e-02f,
  1.40490666e-01f, 4.67610322e-02f, -8.43430310e-02f, -7.00565651e-02f, 1.46129787e-01f, 4.93976772e-02f, -3.10137849e-02f, -1.94394216e-02f, -1.50232509e-01f, -2.13028062e-02f,
  1.28051206e-01f, -1.43335164e-01f, 2.63728481e-02f, -1.79159418e-02f, 3.00699901e-02f, -4.22279444e-03f, 7.87203163e-02f, 1.88042164e-01f, -3.66475917e-02f, -9.25213099e-03f,
  1.97957948e-01f, -2.38627762e-01f, -3.49153727e-02f, -5.73060522e-03f, -3.82563584e-02f, -3.77042443e-02f, 7.57490844e-02f, 2.05476269e-01f, -2.67075263e-02f, -5.63311651e-02f,
  1.49791464e-01f, 1.43917575e-01f, 3.11328401e-03f, -2.31695712e-01f, 1.12716421e-01f, 1.08532324e-01f, 7.80959949e-02f, 6.67035952e-02f, -5.06367832e-02f, -1.87138453e-01f,
  1.06861740e-01f, 4.17968109e-02f, 2.86482032e-02f, 6.21905103e-02f, 2.24979430e-01f, 6.35990202e-02f, 1.40715167e-01f, -1.81218073e-01f, 5.48288692e-03f, -7.91784674e-02f,
  -2.50975370e-01f, 1.47897258e-01f, 1.00303080e-03f, 1.06257468e-01f, -6.02969639e-02f, -9.30831134e-02f, 4.63043340e-02f, -1.82190165e-01f, 2.37354249e-01f, 2.03648567e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  8.77173468e-02f, -1.17938422e-01f, 1.54884994e-01f, 5.75706325e-02f, 1.37533128e-01f, 1.55330434e-01f, 1.27473488e-01f, 1.62651077e-01f, 1.30728140e-01f, 3.45442891e-02f,
  3.79920341e-02f, 2.54655071e-02f, 3.21978740e-02f, 2.21621960e-01f, 6.07334487e-02f, 1.60665736e-01f, 4.81563583e-02f, 2.20515534e-01f, 1.74558401e-01f, 6.75125197e-02f,
  6.42137751e-02f, 1.62237421e-01f, 7.21840858e-02f, 1.65765405e-01f, 1.13577046e-01f, 1.48108259e-01f, -2.66002622e-02f, 2.85019297e-02f, 1.36304393e-01f, 1.17071792e-01f,
  1.86907157e-01f, -1.14393219e-01f, 9.31432992e-02f, 2.02162772e-01f, 2.41519824e-01f, 4.60631140e-02f, -3.67840636e-03f, -1.80247333e-02f, 1.44740984e-01f, 3.41789871e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.49425209e-01f, -8.30467492e-02f, -1.63313061e-01f, -1.90099254e-01f, -1.43405959e-01f, -2.44142175e-01f, 2.32422575e-02f, -2.61391044e-01f, -2.11255103e-01f, -6.20856248e-02f,
  -1.11120790e-01f, -1.06714055e-01f, -3.79717387e-02f, 1.19056888e-01f, 1.48485629e-02f, 2.03592088e-02f, -2.10195526e-01f, -9.15998816e-02f, -8.24901313e-02f, 1.94895361e-02f,
  2.66466916e-01f, 2.03218922e-01f, 4.16047461e-02f, 2.72347778e-01f, 9.70408320e-02f, -1.56509325e-01f, 1.96822714e-02f, 1.31583884e-01f, -2.12386493e-02f, -3.87344621e-02f,
  -2.65376596e-03f, 1.18026443e-01f, 1.22053422e-01f, -1.34201229e-01f, 3.33335251e-02f, 1.46250755e-01f, -2.51052916e-01f, -1.08917519e-01f, -6.70746192e-02f, 6.79031536e-02f,
  1.61952063e-01f, -1.69144958e-01f, 2.10513119e-02f, -1.35352999e-01f, -6.13570139e-02f, -7.36809447e-02f, 1.04959249e-01f, 1.22722112e-01f, 7.05676526e-02f, 4.77800854e-02f,
  1.45384014e-01f, -5.03384098e-02f, -7.65144080e-02f, -3.94740477e-02f, -1.71599105e-01f, 4.04220782e-02f, 7.55939707e-02f, -4.22463343e-02f, -1.34125084e-01f, -7.53534734e-02f,
  -4.14772630e-02f, 1.75976604e-01f, -2.62459945e-02f, 1.17899522e-01f, -1.46257669e-01f, -5.04916944e-02f, 1.14693686e-01f, 1.39880985e-01f, -1.89536870e-01f, 2.62669083e-02f,
  -2.02885326e-02f, 6.20528869e-02f, 1.31770447e-01f, 1.01920098e-01f, -7.70646706e-02f, -2.06292957e-01f, 3.01881254e-01f, -7.15664849e-02f, 2.52491236e-01f, 2.35631391e-01f,
  -2.27508843e-01f, 1.28994033e-01f, -1.61522195e-01f, 1.86328337e-01f, 1.26468897e-01f, -2.02901721e-01f, -2.17197719e-03f, 9.47643667e-02f, 1.16610967e-01f, 7.75246844e-02f,
  1.61168903e-01f, -3.08247171e-02f, -9.32064354e-02f, -7.09745474e-03f, 3.15701105e-02f, -3.74447480e-02f, 1.10154875e-01f, -6.24378361e-02f, 1.66495278e-01f, 1.98376909e-01f,
  1.29037853e-02f, 3.56840566e-02f, -9.92306471e-02f, 9.64859407e-03f, 1.66079663e-02f, -2.05916148e-02f, -9.84417871e-02f, -1.78807855e-01f, -2.96706676e-01f, 4.62829992e-02f,
  1.21393502e-01f, 2.23028556e-01f, 2.13829175e-01f, -1.48238679e-02f, -1.61134284e-02f, -1.02241613e-01f, -1.59465462e-01f, -1.86861068e-01f, -1.23990908e-01f, 1.23398811e-01f,
  -6.04876988e-02f, -3.29202265e-02f, -9.70207341e-03f, -2.42193900e-02f, 1.89209327e-01f, -1.18775271e-01f, 9.73963514e-02f, -4.06279303e-02f, -9.43343192e-02f, -6.17303476e-02f,
  1.47240773e-01f, 1.56621754e-01f, -7.34105110e-02f, -1.70131952e-01f, 4.00979118e-03f, -2.14559853e-01f, -1.81026589e-02f, 8.26339573e-02f, 1.27436249e-02f, -3.02137178e-03f,
  3.59616548e-01f, 2.63570637e-01f, 1.75318755e-02f, -1.65933758e-01f, 6.27720878e-02f, -6.00632979e-03f, -1.43105850e-01f, 2.62433290e-01f, -1.39089972e-01f, 2.17663899e-01f,
  1.67808399e-01f, 9.06479359e-02f, -2.68827174e-02f, -1.58265874e-01f, -1.15716644e-01f, 1.56832770e-01f, -9.64186341e-02f, -1.09395616e-01f, -2.25229442e-01f, 2.14935750e-01f,
  5.66921532e-02f, 1.32642969e-01f, -5.67703396e-02f, 3.53482626e-02f, 1.51168898e-01f, -6.59028068e-02f, -5.15392236e-02f, 4.58704531e-02f, -2.54952665e-02f, -1.32504418e-01f,
  -2.30522901e-02f, -2.67799813e-02f, 2.31368810e-01f, -4.31438461e-02f, -4.72575761e-02f, -1.21695526e-01f, 5.42275347e-02f, -1.41952962e-01f, -1.12344064e-01f, -6.11326396e-02f,
  9.07783732e-02f, -1.64900124e-01f, 8.03623274e-02f, -9.19843316e-02f, -7.58167263e-03f, 5.11369444e-02f, 1.79007038e-01f, -4.71091866e-02f, 7.30212852e-02f, -1.32025391e-01f,
  7.24146813e-02f, -1.58439994e-01f, -9.68600586e-02f, -6.49100319e-02f, -1.16284788e-01f, 3.88513282e-02f, 3.89901102e-02f, -3.94760072e-02f, -9.61234644e-02f, -3.15236300e-02f,
  3.64487059e-02f, -3.72653641e-02f, -9.89880040e-02f, 3.02356761e-02f, -9.88242030e-02f, 1.18690178e-01f, -1.21558510e-01f, 7.26680011e-02f, 1.78059325e-01f, -9.74301472e-02f,
  1.08497880e-01f, -3.27014476e-01f, -2.03953963e-02f, 1.99571937e-01f, -3.44804004e-02f, -1.41582727e-01f, -9.81761590e-02f, -1.35857165e-01f, -1.65164068e-01f, -2.05963045e-01f,
  1.12306796e-01f, 1.18849903e-01f, -4.98101721e-03f, 2.05575049e-01f, -1.10287800e-01f, -8.46287310e-02f, 4.26457524e-02f, -7.67396763e-02f, 1.68799721e-02f, -6.15181252e-02f,
  -4.85375412e-02f, -1.70167966e-03f, -1.78100258e-01f, -9.04119238e-02f, 3.82149667e-02f, 1.09041452e-01f, 1.40771106e-01f, -1.18463904e-01f, -7.02121062e-03f, -2.26897374e-01f,
  4.57318611e-02f, 1.67379677e-01f, -4.95313341e-03f, -1.03082597e-01f, 1.01852752e-01f, 2.11497292e-01f, 1.26625121e-01f, -1.06321208e-01f, 3.04716770e-02f, -3.24988440e-02f,
  -1.12185858e-01f, 5.95686957e-02f, -1.31048754e-01f, 1.63420886e-01f, 4.46363427e-02f, -1.44479387e-02f, 3.63448001e-02f, -1.42157316e-01f, 9.16195437e-02f, 7.87632167e-02f,
  1.87750757e-01f, 2.24736169e-01f, 2.50557393e-01f, -1.10386826e-01f, 8.96694884e-02f, 2.53302217e-01f, -6.86829314e-02f, 1.60541058e-01f, -3.91684622e-02f, -1.07699767e-01f,
  4.85633500e-02f, -4.19661291e-02f, 2.34596714e-01f, 1.72567010e-01f, 2.37969495e-02f, 1.62038192e-01f, -6.56776801e-02f, 5.35809658e-02f, 2.00377315e-01f, -2.41458550e-01f,
  2.01777622e-01f, 9.19289980e-03f, -2.42217258e-02f, 9.44924876e-02f, -1.55887514e-01f, 1.92543879e-01f, -1.16865367e-01f, 3.45294811e-02f, -1.03641175e-01f, -7.87660629e-02f,
  2.07225695e-01f, -1.49127170e-01f, -1.63007509e-02f, -2.75982302e-02f, -4.65192273e-02f, 2.31250957e-01f, -1.42559901e-01f, 1.71876803e-01f, -3.20355594e-02f, 3.75358090e-02f,
  1.27346069e-01f, 1.27630234e-01f, -2.06678696e-02f, 1.15571775e-01f, 2.71325149e-02f, 8.05331245e-02f, -1.27648637e-01f, -7.87438154e-02f, -1.33204803e-01f, -1.52362868e-01f,
  7.56257847e-02f, -1.18556969e-01f, -9.50779915e-02f, 9.24869999e-02f, -1.20136663e-02f, 9.99924615e-02f, -1.60188422e-01f, -7.42913485e-02f, 5.44056371e-02f, -1.13578156e-01f,
  -2.03786828e-02f, -1.46975785e-01f, -1.77282006e-01f, -1.75570205e-01f, 5.46263978e-02f, 1.73899710e-01f, -1.39338911e-01f, 1.47385374e-01f, 1.35611743e-01f, 1.42365947e-01f,
  -1.80642381e-01f, 1.64347496e-02f, -6.66998625e-02f, -2.45215461e-01f, 1.92385912e-01f, 2.19166458e-01f, 5.31056225e-02f, 1.20741734e-03f, 1.93751425e-01f, 1.43380091e-01f,
  1.39155105e-01f, -1.18778765e-01f, 1.02113478e-01f, -1.06232882e-01f, 3.02287012e-01f, -1.43643126e-01f, -5.70772737e-02f, -4.44565713e-02f, 9.96671543e-02f, 7.13413432e-02f,
  -1.53167043e-02f, -4.94408160e-02f, -2.78960634e-02f, 7.05117360e-02f, 1.83286667e-01f, -6.23285845e-02f, -1.90826923e-01f, 1.76884353e-01f, -6.92276955e-02f, 7.69858658e-02f,
  -1.81700915e-01f, -2.18484104e-02f, 5.12195602e-02f, 3.74586508e-03f, -6.68651015e-02f, -2.30313707e-02f, 1.32632256e-01f, 4.24962044e-02f, -4.18689735e-02f, 2.08923280e-01f,
  1.32712536e-02f, 7.77711347e-02f, -2.07976267e-01f, 1.76933587e-01f, 1.21378591e-02f, -7.98015157e-04f, 1.96971502e-02f, -8.47802591e-03f, -9.33238789e-02f, 1.25901341e-01f,
  -2.87798673e-01f, 2.16834739e-01f, -8.33391771e-02f, 1.80065185e-01f, 2.21765898e-02f, -8.55368674e-02f, -7.60641694e-02f, -7.66062818e-04f, 1.32231578e-01f, -1.96448271e-03f,
  7.66422898e-02f, -5.34489378e-02f, 1.18531331e-01f, 9.17837620e-02f, 2.90359240e-02f, 1.40624583e-01f, 8.24129060e-02f, -1.34035787e-02f, 1.05361626e-01f, -7.90429637e-02f,
  -2.64959503e-03f, 3.79705452e-03f, 6.35579461e-03f, -4.41256016e-02f, -2.26237342e-01f, 8.08388647e-03f, -4.83465306e-02f, -1.85540780e-01f, -1.69433758e-01f, -1.43487211e-02f,
  -7.20514208e-02f, -2.93286115e-01f, -2.70140767e-02f, -7.36617148e-02f, -6.74768761e-02f, 1.06463231e-01f, -4.73600291e-02f, 4.58956286e-02f, -5.03190234e-02f, -3.09870038e-02f,
  6.31238241e-03f, -1.12024687e-01f, -1.59099102e-02f, -4.76638190e-02f, -9.58713964e-02f, -1.16021864e-01f, 2.03158006e-01f, 1.40817463e-01f, -1.17181763e-01f, 1.65782049e-02f,
  -9.85485315e-02f, -1.65374558e-02f, -4.25702147e-02f, 1.67243734e-01f, 5.51476628e-02f, 5.64422011e-02f, -4.79566343e-02f, 2.08440453e-01f, 3.28619080e-03f, -1.64087415e-01f,
  1.43077910e-01f, -2.05781206e-01f, -1.71174139e-01f, -4.81033102e-02f, 6.86340928e-02f, -2.30650138e-02f, -7.90245607e-02f, 1.66099533e-01f, -1.39217556e-01f, -2.16992840e-01f,
  -8.94557163e-02f, -2.51584113e-01f, -7.03032538e-02f, -6.43961132e-02f, -1.12954542e-01f, -8.08762237e-02f, -4.29688357e-02f, -1.28521308e-01f, 3.33824642e-02f, 6.62435219e-02f,
  -2.34833822e-01f, 7.16442391e-02f, -1.27641678e-01f, -5.71442656e-02f, 2.83488333e-01f, 1.14662927e-02f, -6.10012077e-02f, 1.85901165e-01f, 1.67231172e-01f, -3.83551829e-02f,
  3.97749804e-02f, 2.04763830e-01f, 8.72753039e-02f, 6.34566694e-02f, 1.14459207e-03f, 1.24831319e-01f, 3.49667855e-02f, 8.24141800e-02f, 2.31069494e-02f, -2.28801191e-01f,
  3.06023248e-02f, -7.96360224e-02f, -1.75721958e-01f, 7.64335170e-02f, -3.15231591e-01f, 3.36808532e-01f, 1.15630776e-01f, 8.21999833e-02f, 2.48824283e-02f, -1.65791318e-01f,
  -1.18414313e-01f, 6.01391913e-03f, 2.50831574e-01f, -1.46850318e-01f, 9.57146510e-02f, -1.18605934e-01f, -1.91368788e-01f, 3.66011858e-02f, -4.04012054e-02f, 1.75646693e-01f,
  -2.75319777e-02f, 4.93229255e-02f, 1.01633430e-01f, 2.45314240e-01f, -2.42559299e-01f, 3.83204482e-02f, -1.05660491e-01f, 2.02063009e-01f, -9.78844091e-02f, -7.78441653e-02f,
  7.45734051e-02f, -1.04480825e-01f, 2.82186210e-01f, 5.51409833e-02f, 1.91872656e-01f, 1.28606334e-01f, 9.45936218e-02f, 8.98156688e-02f, -5.07027693e-02f, -2.14355513e-01f,
  -1.69217680e-02f, 1.13192834e-01f, 7.89564326e-02f, -1.84477612e-01f, 6.67206347e-02f, 3.01813066e-01f, 9.39568132e-02f, 4.29142490e-02f, -1.49578899e-01f, 1.28661036e-01f,
  8.70070755e-02f, -3.22901428e-01f, -1.23535544e-01f, -1.64462104e-01f, -2.02241335e-02f, -3.47545296e-02f, 5.74292568e-03f, 1.21126492e-02f, 6.55791089e-02f, -3.55524905e-02f,
  1.33803532e-01f, -2.02884093e-01f, -1.64849218e-02f, 1.74231157e-01f, 8.33234712e-02f, 4.64428356e-03f, 1.18309751e-01f, -4.94718291e-02f, -6.58313110e-02f, -1.14996113e-01f,
  1.14447534e-01f, -1.09218046e-01f, -9.14575681e-02f, 1.05587214e-01f, -8.20514187e-02f, -1.03836045e-01f, -8.33191425e-02f, 1.55913025e-01f, -1.23512611e-01f, -1.79726005e-01f,
  5.49046472e-02f, 2.91011054e-02f, 8.23602155e-02f, 5.87254902e-03f, 1.33467242e-01f, 1.54156074e-01f, -8.11589658e-02f, -7.89249912e-02f, 9.53574553e-02f, -1.77564323e-01f,
  -3.38542074e-01f, -1.00817002e-01f, 1.01083845e-01f, 2.02684805e-01f, -1.39043778e-01f, 1.18439816e-01f, 2.97493720e-03f, -2.32336652e-02f, -3.80437709e-02f, -1.35184005e-01f,
  8.87676794e-03f, 1.12281710e-01f, 3.93169746e-02f, -4.94141094e-02f, -1.14095010e-01f, 1.47699667e-02f, 3.56131829e-02f, -2.96386689e-01f, 6.40155077e-02f, -9.30064544e-03f,
  -1.15400046e-01f, 2.15179518e-01f, -1.21331550e-01f, 7.83216432e-02f, -1.37153149e-01f, -1.57297134e-01f, 6.00252822e-02f, 1.23031989e-01f, -7.68736079e-02f, 1.61734402e-01f,
  -9.61436629e-02f, 1.06192557e-02f, 1.23624941e-02f, 6.97728470e-02f, 1.64260482e-03f, -7.49439299e-02f, 6.31326213e-02f, -2.53790729e-02f, 2.97677308e-01f, 1.09230895e-02f,
  -3.17474008e-02f, 4.43298370e-02f, 6.93008304e-02f, -2.39505261e-01f, -1.48365691e-01f, -7.70853236e-02f, 1.24270711e-02f, -3.40970308e-02f, -4.80715856e-02f, -4.80102301e-02f,
  -1.27760738e-01f, -1.21701814e-01f, -1.04618244e-01f, 1.44424528e-01f, -8.51020738e-02f, -5.81930205e-02f, 9.10333097e-02f, -4.35670465e-02f, 1.47435116e-02f, -1.62702098e-01f,
  -1.09963916e-01f, 2.95836050e-02f, -2.26054043e-01f, -7.81974494e-02f, -2.51261964e-02f, -2.04828992e-01f, -1.85318980e-02f, -1.55726194e-01f, 9.98367295e-02f, -4.49804626e-02f,
  -1.64793923e-01f, -2.78581023e-01f, -1.16770849e-01f, -1.78530619e-01f, 1.25069683e-02f, -1.33822426e-01f, -1.80498317e-01f, -1.29223853e-01f, -6.42676875e-02f, -2.51368042e-02f,
  -2.02094391e-01f, 2.92305592e-02f, -1.41072452e-01f, 5.05569391e-02f, -2.42898583e-01f, -1.43350959e-01f, 6.39138445e-02f, -7.24089518e-02f, 3.34184408e-01f, -6.81788400e-02f,
  9.32711139e-02f, 1.81833061e-03f, -1.19658373e-01f, -1.72426894e-01f, -8.86546634e-03f, -6.31500855e-02f, -7.50544295e-02f, -1.75547779e-01f, -9.54058096e-02f, -3.92994694e-02f,
  -1.01792179e-01f, 1.04594342e-01f, -1.00889094e-01f, 3.91463414e-02f, -7.45972842e-02f, -1.26938269e-01f, -1.18052162e-01f, 1.98040992e-01f, 1.27283856e-01f, -1.64961293e-01f,
  -8.92310664e-02f, -1.46812676e-02f, 2.04941668e-02f, 1.28609881e-01f, -2.52628233e-02f, 3.55942622e-02f, 1.60903856e-01f, -2.78266240e-02f, -1.81093797e-01f, 7.31847733e-02f,
  -1.46145701e-01f, 2.99035534e-02f, -5.81969544e-02f, 4.85306159e-02f, 6.55595511e-02f, 2.74426676e-02f, -1.24796003e-03f, -3.61367203e-02f, -3.33163440e-02f, 2.00448766e-01f,
  -1.06045671e-01f, -5.64167649e-02f, 6.26772409e-03f, 6.03659302e-02f, 1.30456284e-01f, -1.66547447e-01f, -1.76083595e-01f, -1.04074821e-01f, 1.64355472e-01f, -1.39952078e-02f,
  3.53048742e-02f, 8.71783588e-03f, -2.13059112e-02f, -1.37794301e-01f, -1.48104027e-01f, 6.23009875e-02f, 1.65693462e-01f, 2.26653810e-03f, 1.63480550e-01f, -1.79155529e-01f,
  4.46770601e-02f, -6.59054294e-02f, 1.98452413e-01f, -1.82742849e-02f, -1.70114577e-01f, -1.52873889e-01f, 1.20253742e-01f, -2.01326966e-01f, 1.61940847e-02f, -4.44396622e-02f,
  3.52253690e-02f, -1.92050219e-01f, 2.34176591e-01f, -6.15910701e-02f, -1.42792478e-01f, 7.75198080e-03f, -3.29865627e-02f, 4.76347134e-02f, 1.28760681e-01f, 1.10360883e-01f,
  -5.54277077e-02f, 1.29105359e-01f, 5.16848639e-02f, -4.78664227e-02f, -9.48709548e-02f, -1.34185076e-01f, 9.87949744e-02f, -4.20101918e-04f, 1.69618189e-01f, -1.09481744e-01f,
  6.68352917e-02f, -2.16208264e-01f, -1.51787102e-01f, 8.70076269e-02f, 2.75980937e-03f, -7.35386088e-02f, -9.81140360e-02f, 1.79359749e-01f, -2.45925561e-02f, -1.52883446e-02f,
  -5.45661338e-02f, 1.51062354e-01f, 5.78717217e-02f, 1.33730501e-01f, 3.89230736e-02f, 1.17399305e-01f, -2.01490715e-01f, 1.47210374e-01f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  7.36024678e-02f, 3.30112845e-01f, 1.35893747e-02f, 2.55773067e-01f, -1.30415007e-01f, -3.67315188e-02f, 2.24331602e-01f, 4.49471660e-02f, 2.67429680e-01f, 4.27641161e-03f,
  1.18891343e-01f, 9.68946815e-02f, 2.55607348e-02f, 5.64453974e-02f, -2.81796396e-01f, -2.14200169e-02f, -1.56043068e-01f, -7.23693445e-02f, 1.49077903e-02f, 3.08274236e-02f,
  1.22740716e-01f, -8.12728181e-02f, -3.57026696e-01f, 3.20307016e-02f, 8.29757657e-03f, 1.01405621e-01f, 1.67403966e-01f, 1.35828763e-01f, -1.61560491e-01f, -2.16271579e-01f,
  -4.92129149e-03f, -8.78425967e-03f, -3.47777493e-02f, 1.78571060e-01f, -1.28758192e-01f, 1.81505278e-01f, 2.23343655e-01f, -7.54436329e-02f, 1.59840748e-01f, -7.66700357e-02f,
  1.67269170e-01f, 1.22039728e-01f, 8.64416584e-02f, 6.40846863e-02f, -1.53865203e-01f, 2.12342247e-01f, 1.98005751e-01f, 7.60179609e-02f, 1.19074889e-01f, -7.08385557e-02f,
  1.22517105e-02f, 6.10279478e-02f, 2.58357048e-01f, 4.01003063e-02f, -1.02982894e-01f, 6.85748309e-02f, 1.19417198e-01f, 4.21776958e-02f, 1.06478572e-01f, 3.75703117e-03f,
  2.68703490e-01f, -2.02832386e-01f, 2.20362201e-01f, -5.00839092e-02f, 6.02084994e-02f, 1.24488838e-01f, 1.18103195e-02f, 3.77618871e-03f, 1.16595879e-01f, 7.43886679e-02f,
  -8.01183935e-03f, 6.29864857e-02f, 1.35919899e-01f, 1.26821265e-01f, 2.99331903e-01f, -2.31562659e-01f, -1.49523079e-01f, 1.18849695e-01f, -1.94821790e-01f, 1.15987822e-01f,
  -1.27448320e-01f, -1.98985919e-01f, 2.97791734e-02f, -2.58724123e-01f, 1.34476617e-01f, 1.53816581e-01f, 1.09640040e-01f, 1.67466462e-01f, 3.28435712e-02f, 1.71490669e-01f,
  -4.70261946e-02f, 2.52791524e-01f, -1.28379568e-01f, -7.13553131e-02f, 1.89590588e-01f, -5.70852570e-02f, 3.21561038e-01f, -1.98604297e-02f, 1.69361103e-02f, 1.63503423e-01f,
  -3.62313464e-02f, -3.29355389e-01f, 1.05627917e-01f, 1.99683011e-02f, 1.45890310e-01f, 2.77931839e-02f, -2.57860254e-02f, 1.32848531e-01f, 1.62416380e-02f, 5.92273772e-02f,
  -1.09260678e-02f, -3.89948837e-03f, -8.50722101e-03f, -4.86521393e-01f, 1.14619173e-01f, 2.41208021e-02f, 1.15920193e-01f, -1.23591490e-01f, -6.70734048e-02f, 6.25137538e-02f,
  -8.60619321e-02f, -9.45690572e-02f, 4.07536328e-02f, -9.99500379e-02f, -1.18398969e-03f, -1.07972465e-01f, 5.03929742e-02f, 7.90447090e-03f, 4.68895920e-02f, -5.38465939e-02f,
  2.98622966e-01f, 4.14570093e-01f, 1.96555883e-01f, 1.70396447e-01f, 8.27979073e-02f, -5.64816333e-02f, 2.74706751e-01f, 9.16886255e-02f, 1.08954363e-01f, 8.57652575e-02f,
  6.30319566e-02f, -1.14395678e-01f, 1.49502814e-01f, 1.14002526e-01f, -3.94682698e-02f, 2.10895866e-01f, 2.06114411e-01f, -6.27439329e-03f, -4.48933721e-01f, -2.51146704e-01f,
  3.11290324e-02f, -1.50982752e-01f, 4.64168042e-02f, -1.72756568e-01f, 2.44304776e-01f, -7.03987628e-02f, -3.05263937e-01f, 1.14385106e-01f, -3.05118393e-02f, 6.19398654e-02f,
  3.33446525e-02f, 1.14238918e-01f, 9.46435481e-02f, -2.51736432e-01f, -1.15860313e-01f, 9.91648808e-02f, 1.68399721e-01f, 5.04450612e-02f, -1.30473089e-03f, 2.42621720e-01f,
  8.13620090e-02f, 7.95360208e-02f, -5.81312440e-02f, 7.24579915e-02f, -2.71466584e-03f, -8.61826763e-02f, 2.33020365e-01f, 8.39378908e-02f, -1.22572102e-01f, -9.25984979e-02f,
  4.59229052e-02f, 2.17488870e-01f, 2.21396074e-01f, -2.64564991e-01f, -1.94269300e-01f, 1.11584730e-01f, -2.35924259e-01f, 1.55842975e-01f, 1.27975727e-02f, -9.52559561e-02f,
  -1.41818538e-01f, 5.03938906e-02f, 1.16336621e-01f, 1.54983327e-01f, 1.21739209e-02f, -1.04810372e-01f, 5.29975705e-02f, 5.82867898e-02f, 1.70591131e-01f, 1.03635974e-01f,
  2.26681139e-02f, -9.16874502e-03f, 2.99961805e-01f, 5.31184413e-02f, -2.14360267e-01f, 1.33153021e-01f, -3.00085545e-01f, 4.96980920e-02f, -1.00605980e-01f, -2.23237500e-01f,
  2.55239010e-02f, -2.32993737e-01f, 2.16531456e-01f, 5.45303188e-02f, -1.49884179e-01f, 7.97647536e-02f, 6.34212047e-02f, 9.61832926e-02f, 1.27016734e-02f, 7.85272941e-03f,
  1.02806635e-01f, -1.38484344e-01f, 1.25719637e-01f, 3.19085047e-02f, 1.51902020e-01f, 4.54619043e-02f, -1.05690427e-01f, 1.18163548e-01f, 1.43468156e-01f, -1.66618720e-01f,
  1.42236695e-01f, -1.37984738e-01f, 8.14068168e-02f, 5.59595563e-02f, -3.40757817e-02f, 1.79559678e-01f, -1.73887074e-01f, -5.84342033e-02f, -7.55583197e-02f, 7.01898709e-03f,
  -4.92599495e-02f, -2.00290740e-01f, -2.78723147e-02f, -5.03836796e-02f, 2.85302192e-01f, -5.82874380e-02f, -1.17840804e-01f, -4.80045564e-02f, -4.79166992e-02f, -1.33590862e-01f,
  8.08462575e-02f, 8.49263743e-02f, 5.42124733e-02f, -1.70380890e-01f, 2.24935994e-01f, -1.93670224e-02f, 3.44842561e-02f, 1.07717082e-01f, 1.18051820e-01f, 1.70993999e-01f,
  8.18936378e-02f, 1.35322735e-01f, 1.31811932e-01f, 2.32343554e-01f, 1.61250666e-01f, 6.38649687e-02f, 6.75164610e-02f, 7.61425346e-02f, 2.65381724e-01f, -7.46276155e-02f,
  1.32106125e-01f, 1.72224402e-01f, 8.45165700e-02f, -1.10231578e-01f, -2.65128493e-01f, 2.98045516e-01f, 5.32251358e-01f, -1.18823804e-01f, 1.15787499e-01f, 2.95025021e-01f,
  2.66809911e-01f, 8.73027071e-02f, 2.12930679e-01f, 8.51522461e-02f, -7.46102929e-02f, 3.94829325e-02f, 1.17928520e-01f, -3.54242116e-01f, 8.29150081e-02f, -6.17484786e-02f,
  1.33421242e-01f, 1.63230598e-01f, -3.65837768e-04f, 2.50509620e-01f, 7.34008551e-02f, 2.76903719e-01f, 2.77774692e-01f, 5.18347993e-02f, -2.08912306e-02f, -5.95703125e-02f,
  -1.05131626e-01f, -5.26157655e-02f, 1.39191374e-01f, 1.88950986e-01f, 6.11090027e-02f, -6.10038787e-02f, -1.21741913e-01f, 5.96773475e-02f, -2.20921963e-01f, -5.77569418e-02f,
  9.77445953e-03f, 1.40448242e-01f, 1.20972976e-01f, 2.32478395e-01f, 2.79428780e-01f, 1.69848561e-01f, -4.24815342e-02f, 5.74069843e-02f, 3.73192392e-02f, -7.68586546e-02f,
  6.18408397e-02f, 2.56567806e-01f, 1.55993327e-01f, 4.21860674e-03f, 2.34830678e-01f, 2.97037899e-01f, 4.07335699e-01f, 2.58904815e-01f, 3.63606364e-01f, 1.17659159e-01f,
  1.15813278e-01f, 1.41182151e-02f, 6.06108783e-03f, -9.40353647e-02f, 4.43815961e-02f, 1.97477609e-01f, -1.50492847e-01f, -4.13044728e-02f, -1.02241675e-03f, 6.35339646e-03f,
  1.18392050e-01f, -1.35904416e-01f, -3.93270403e-02f, 1.28849700e-01f, 4.47268635e-02f, 1.55627564e-01f, 2.81534880e-01f, 2.79660702e-01f, -2.09202945e-01f, 7.93403387e-02f,
  1.09902509e-01f, -2.37166867e-01f, 2.65308112e-01f, 1.32486656e-01f, 1.08502796e-02f, 1.98737800e-01f, 9.69102532e-02f, -2.26003453e-01f, 1.03747837e-01f, 1.59951508e-01f,
  1.48750022e-01f, 1.63449705e-01f, -1.17281608e-01f, -3.57997008e-02f, -4.26104188e-01f, 2.30052605e-01f, -9.48801711e-02f, 2.27558255e-01f, 2.06951603e-01f, -2.13864133e-01f,
  -1.45202890e-01f, 6.58440739e-02f, 1.25971809e-01f, 1.44247813e-02f, 1.89326227e-01f, -6.35427609e-02f, 6.24474548e-02f, 1.34091988e-01f, 2.45485857e-01f, -5.54368272e-02f,
  1.97924316e-01f, -1.28411680e-01f, 2.56793410e-01f, -5.27153648e-02f, 5.41660041e-02f, 1.14501379e-01f, 2.62600183e-01f, 2.10693985e-01f, 2.61527807e-01f, 1.88095152e-01f,
  1.15660213e-01f, 5.36552444e-02f, 2.99924701e-01f, 2.04714462e-01f, 1.41919315e-01f, 2.05595449e-01f, -2.62572974e-01f, -2.69033033e-02f, -2.00912468e-02f, 1.39611810e-02f,
  1.49685726e-01f, -5.03793955e-02f, 8.26337263e-02f, -3.80111188e-02f, -1.30246818e-01f, 2.05667522e-02f, -9.58033130e-02f, -4.52514589e-02f, 1.30999058e-01f, 4.97395359e-02f,
  -3.52600776e-02f, -1.10180944e-01f, -3.71789634e-02f, 2.10942566e-01f, 6.45074667e-03f, 1.87121406e-01f, -6.30940646e-02f, 2.10652962e-01f, -1.33265525e-01f, -1.15345664e-01f,
  -7.41344541e-02f, -2.29093507e-02f, 1.46795521e-02f, -3.40858288e-02f, -1.73957974e-01f, 1.58482015e-01f, 7.53576756e-02f, 2.40683481e-01f, 1.67758726e-02f, 1.91026703e-01f,
  -8.10710788e-02f, -1.22229360e-01f, 4.34410460e-02f, 1.23105180e-02f, -2.01394141e-01f, 1.22202016e-01f, -3.94087145e-03f, 2.07974032e-01f, 1.39598161e-01f, -2.87739575e-01f,
  -1.67764574e-01f, -8.39993134e-02f, 5.49545772e-02f, 1.07313886e-01f, -1.23696193e-01f, 2.55270326e-03f, 1.15597285e-01f, -1.19786616e-02f, -5.75929061e-02f, 8.28691050e-02f,
  -2.33826250e-01f, 1.90017015e-01f, 6.49432000e-03f, -2.07791448e-01f, 1.21148050e-01f, -3.33475284e-02f, 2.44838223e-01f, 4.49308902e-02f, -2.06802879e-02f, 1.43752724e-01f,
  2.37297952e-01f, 1.59701303e-01f, -7.06117377e-02f, -2.09357187e-01f, 1.45696983e-01f, -1.17386572e-01f, 1.78502187e-01f, 1.80368885e-01f, 8.37864950e-02f, -2.09247082e-01f,
  -1.52072072e-01f, -1.07364520e-01f, -1.04564622e-01f, 1.41118482e-01f, 1.52631342e-01f, -1.24087416e-01f, -9.59384218e-02f, -1.80575386e-01f, -5.30558452e-02f, 1.86397851e-01f,
  -1.81358516e-01f, 1.82962254e-01f, -2.35396057e-01f, -4.97528650e-02f, 3.20518315e-01f, 1.84513740e-02f, 1.23495393e-01f, -2.66186565e-01f, 1.39762804e-01f, -2.76209582e-02f,
  1.41035244e-01f, 4.22366336e-02f, -1.01667956e-01f, 1.95606649e-01f, 1.09232046e-01f, 3.77767980e-02f, 1.20981716e-01f, -1.05330259e-01f, -7.92970210e-02f, 1.50860786e-01f,
  8.67931694e-02f, 9.44770966e-03f, -1.05697596e-02f, 7.64869303e-02f, 1.10472053e-01f, -1.34387195e-01f, 1.23363532e-01f, 6.94808960e-02f, -1.82056203e-02f, -3.42644528e-02f,
  -2.51139347e-02f, -6.73610019e-03f, -4.03432436e-02f, 6.36295080e-02f, -2.27988558e-03f, 1.68550983e-01f, -2.15988368e-01f, -5.28135970e-02f, 3.42425965e-02f, 1.25015853e-02f,
  2.05299020e-01f, -6.38288558e-02f, 3.46135832e-02f, -2.03021064e-01f, 5.49702682e-02f, 3.25647861e-01f, -4.58024628e-02f, 6.43488318e-02f, -2.99998559e-02f, -1.06711172e-01f,
  -3.04178316e-02f, 9.93782207e-02f, 2.66696930e-01f, -7.51635479e-03f, -4.65632193e-02f, 1.14851758e-01f, 2.04075679e-01f, 6.17967034e-03f, -1.66002080e-01f, 8.16479251e-02f,
  3.04458529e-01f, -2.47990504e-01f, 2.22814634e-01f, -7.28488714e-02f, 2.08293065e-01f, 1.44023076e-01f, 1.67396560e-01f, 1.79839656e-01f, -7.57001340e-02f, -8.43085125e-02f,
  -1.56169355e-01f, 1.07495204e-01f, 3.85591830e-03f, 3.43956389e-02f, 6.27643317e-02f, 1.94475595e-02f, -1.74672648e-01f, -9.52545479e-02f, 1.41931310e-01f, 1.35537073e-01f,
  8.89555886e-02f, 1.21611238e-01f, 1.15957692e-01f, 2.14454859e-01f, 1.13380149e-01f, -5.05080037e-02f, -1.81622684e-01f, 1.11783266e-01f, -3.74789052e-02f, -4.85571995e-02f,
  -1.42638654e-01f, 3.71243246e-02f, 6.30080029e-02f, 1.38558134e-01f, 1.47351667e-01f, -2.49838200e-03f, 7.26000965e-02f, 1.12406693e-01f, 5.88932820e-02f, 1.03932217e-01f,
  8.27104524e-02f, -4.04875055e-02f, 1.01747513e-01f, 1.46913871e-01f, -1.16292730e-01f, -8.07310734e-03f, -3.87804806e-02f, 1.05050586e-01f, -1.42292663e-01f, -4.67623025e-02f,
  6.07384974e-03f, 8.37572739e-02f, 3.18612531e-02f, -2.30610698e-01f, -2.18218192e-01f, 1.48172855e-01f, 1.81155846e-01f, 3.55036795e-01f, 1.70761924e-02f, -3.62042263e-02f,
  1.11460760e-01f, -2.73782425e-02f, 4.63689789e-02f, -7.88626000e-02f, -1.15165738e-02f, 3.00544053e-01f, -1.19313426e-01f, 5.83373681e-02f, -3.79283652e-02f, -1.50299221e-01f,
  -1.05839327e-01f, -9.32689905e-02f, -1.07797667e-01f, 2.65601605e-01f, -3.09357438e-02f, 4.86806594e-02f, 2.79682633e-02f, 9.72479880e-02f, -5.66401929e-02f, 1.90457031e-01f,
  1.66151255e-01f, -4.68213558e-02f, -1.66959167e-02f, 6.10313006e-02f, -1.35590984e-02f, 3.00724339e-02f, -3.95355448e-02f, -1.57630946e-02f, -7.58368969e-02f, 2.62691593e-03f,
  1.86574265e-01f, -1.55310482e-01f, 2.64655143e-01f, 3.61106515e-01f, 2.22731486e-01f, 1.58259809e-01f, 3.93946655e-03f, -1.28420874e-01f, 8.85950923e-02f, 1.20290548e-01f,
  -7.34570175e-02f, 1.39658168e-01f, 1.71468910e-02f, 1.15476392e-01f, 1.00701459e-01f, 4.68972847e-02f, 7.83872083e-02f, 9.27523300e-02f, 1.06736727e-01f, 3.40446196e-02f,
  1.57076925e-01f, 1.58070639e-01f, -2.63245493e-01f, -3.00935786e-02f, -2.69816875e-01f, -2.05031887e-01f, -4.16344358e-03f, -1.61513150e-01f, -1.52308913e-02f, 1.84029832e-01f,
  -3.09013426e-01f, 1.18782967e-02f, -1.76516995e-01f, -3.11830521e-01f, -1.32393479e-01f, -1.34293258e-01f, 5.28571159e-02f, -9.77062657e-02f, -4.08914797e-02f, 1.47720501e-01f,
  -3.70634198e-02f, 2.50060141e-01f, -1.66674957e-01f, 5.30178882e-02f, -1.75444290e-01f, -1.46573916e-01f, 3.17859650e-02f, 1.46667093e-01f, 1.50714144e-01f, -1.28199607e-01f,
  -5.61738759e-02f, 1.25152722e-01f, 7.40540773e-02f, 1.72296673e-01f, 2.55076736e-01f, 8.12503174e-02f, 1.75301045e-01f, -1.70979857e-01f, -8.87331665e-02f, 1.12368904e-01f,
  3.55441757e-02f, 1.22982800e-01f, 2.01749355e-01f, 1.04236767e-01f, 1.71751469e-01f, -1.66614115e-01f, -5.95193952e-02f, -4.30265404e-02f, -4.65678796e-02f, -7.07683787e-02f,
  4.76082675e-02f, -3.90626378e-02f, -2.96005383e-02f, 1.11932732e-01f, 4.78945561e-02f, -1.35360166e-01f, 6.18910976e-02f, -1.55214816e-01f, -7.07295313e-02f, 6.58748895e-02f,
  -1.83471829e-01f, -9.38219950e-02f, -2.17521429e-01f, -7.08486214e-02f, -1.26931384e-01f, -1.56461731e-01f, 1.46398515e-01f, 1.04630299e-01f, 6.34270012e-02f, 2.65960574e-01f,
  -6.47371039e-02f, 3.34199280e-01f, -1.39263958e-01f, 1.47904173e-01f, -1.07041523e-02f, 3.24933715e-02f, 6.62108660e-02f, 1.39702171e-01f, 1.15105920e-01f, 1.00100555e-01f,
  1.89098939e-01f, 7.91541710e-02f, -1.27485231e-01f, 4.16738493e-03f, 8.92649405e-03f, 1.05849236e-01f, 1.04986474e-01f, -2.11833492e-01f, 2.41168484e-01f, 1.52922764e-01f,
  -1.40313357e-01f, -7.68551156e-02f, -2.12287337e-01f, 1.30723774e-01f, 1.42005101e-01f, -4.92676049e-02f, -1.10737309e-01f, -2.78808475e-01f, 5.92698231e-02f, 3.21226865e-02f,
  8.74250755e-03f, 1.26365721e-01f, 4.97190207e-02f, 2.10891828e-01f, 1.89774394e-01f, 1.84731763e-02f, -1.63332865e-01f, 2.50280183e-02f, -2.15830728e-01f, 2.93067455e-01f,
  -3.52364331e-01f, 1.31945118e-01f, -1.97641104e-01f, -1.32784814e-01f, 1.27716005e-01f, 8.74876231e-02f, 2.86110118e-02f, -5.35368659e-02f, 1.47218570e-01f, 2.45041996e-01f,
  1.64643094e-01f, 2.17856959e-01f, 3.43185663e-02f, 7.52833784e-02f, 2.65689522e-01f, 2.87284167e-03f, 1.06345816e-02f, 3.75869349e-02f, 9.57220867e-02f, 8.98523815e-03f,
  4.53781150e-03f, -1.12890333e-01f, -6.85508028e-02f, 2.76847839e-01f, -2.24323392e-01f, 1.51100736e-02f, -9.39073041e-02f, 8.57215971e-02f, 2.42029671e-02f, -2.39206836e-01f,
  -1.54824093e-01f, 1.92221984e-01f, 7.10274875e-02f, 4.02608141e-02f, 1.52684778e-01f, 2.33593807e-01f, -1.61460921e-01f, -2.82311495e-02f, 9.59332958e-02f, -1.96686223e-01f,
  1.43125057e-01f, 1.42043158e-01f, -1.33340240e-01f, -2.23556161e-02f, 1.07940257e-01f, -1.68027300e-02f, 1.58707090e-02f, -2.20653508e-02f, 1.91311181e-01f, 2.38504276e-01f,
  2.03335248e-02f, -9.37763751e-02f, -3.08086842e-01f, 2.67503232e-01f, -2.57572904e-03f, 2.04459757e-01f, 1.89131841e-01f, -1.09917790e-01f, 3.50095741e-02f, 1.13170907e-01f,
  8.10899585e-02f, -1.01492859e-01f, 1.56712219e-01f, 7.62232766e-02f, -3.59743051e-02f, 4.05387655e-02f, -5.65694980e-02f, 1.19347766e-01f, 2.76451886e-01f, -1.64306521e-01f,
  1.35326937e-01f, -7.55803138e-02f, 1.31523032e-02f, -3.64928017e-03f, 4.55477126e-02f, -9.02491212e-02f, 3.22994217e-02f, 5.83371557e-02f, -2.84856439e-01f, -6.48215860e-02f,
  -1.26255080e-01f, -2.94562988e-02f, -7.67346397e-02f, -1.87420528e-02f, -8.96941498e-02f, -5.12457080e-02f, -1.51293755e-01f, 1.43006578e-01f, -1.44129440e-01f, 5.62353469e-02f,
  2.19993904e-01f, -2.14099020e-01f, -3.35577518e-01f, -3.20498884e-01f, -1.22394515e-02f, -2.53504664e-01f, -1.32949259e-02f, 1.51189551e-01f, 2.80109435e-01f, 6.06581904e-02f,
  -2.16034666e-01f, 1.54804543e-01f, 3.03823464e-02f, -8.03674236e-02f, 5.15824594e-02f, 1.34333819e-01f, -7.79298767e-02f, 1.24560576e-03f, -1.43479854e-01f, 6.39425367e-02f,
  1.43040717e-01f, -7.62627423e-02f, -9.58202481e-02f, 1.73198730e-01f, 6.52933121e-02f, 3.77852172e-02f, -9.11851376e-02f, 1.82421073e-01f, 2.07328737e-01f, -6.84341267e-02f,
  2.13953387e-02f, -1.08214002e-03f, 1.66816935e-01f, 3.49858180e-02f, 2.09509730e-02f, -7.93443993e-03f, -1.11560905e-02f, 1.23921052e-01f, -2.68854976e-01f, -2.43165165e-01f,
  -4.14412856e-01f, 6.91293925e-02f, 8.35206883e-04f, -8.14740434e-02f, -5.66789731e-02f, -4.91231680e-02f, -1.40228450e-01f, 8.64487067e-02f, 2.57910639e-02f, 1.17498878e-02f,
  -2.82498568e-01f, -2.38857165e-01f, 2.15486526e-01f, 9.38599855e-02f, 9.95761529e-02f, -9.53332186e-02f, 1.40195087e-01f, 1.55837322e-02f, 1.93928942e-01f, 1.91433862e-01f,
  -2.69467980e-01f, -2.16486081e-02f, -8.18861127e-02f, -8.02272037e-02f, -1.31670207e-01f, 4.40997630e-02f, 4.65134308e-02f, -9.18068215e-02f, -1.02658927e-01f, 1.36972293e-01f,
  1.06227100e-01f, 6.23680800e-02f, 1.05778016e-01f, -5.11934096e-03f, 4.69108149e-02f, -2.61848241e-01f, 4.04613502e-02f, -4.94825393e-02f, -1.26455516e-01f, -3.19177657e-03f,
  2.13296693e-02f, 1.38526797e-01f, 1.49230927e-01f, 6.08973727e-02f, -4.72363792e-02f, 1.24506079e-01f, 2.14423407e-02f, -9.81949121e-02f, 1.85367182e-01f, 3.16670388e-02f,
  -1.55928075e-01f, -1.56839937e-01f, 6.51491433e-02f, 3.82386036e-02f, 1.08429447e-01f, 1.69080913e-01f, 1.82206094e-01f, 1.48923233e-01f, 3.68182957e-02f, 9.60546061e-02f,
  -1.39086932e-01f, 1.28508598e-01f, -6.60044700e-03f, -2.23883867e-01f, 3.88976522e-02f, 1.94196720e-02f, -8.85227770e-02f, 1.85596481e-01f, 6.75680414e-02f, 1.11143693e-01f,
  7.79466629e-02f, 1.16076179e-01f, 8.93654823e-02f, -5.34422621e-02f, 1.46363705e-01f, 5.76518802e-03f, 1.23351142e-01f, 2.72459164e-02f, 1.57511353e-01f, 1.52866691e-02f,
  2.31512934e-01f, 1.21504277e-01f, -3.48843962e-01f, -1.22651912e-01f, -1.28877848e-01f, -3.53118218e-02f, 6.01235032e-02f, -6.11576624e-02f, -6.51426613e-02f, -1.57065928e-01f,
  -1.77022919e-01f, 5.08142002e-02f, -1.22966096e-01f, -2.31542841e-01f, -1.00392938e-01f, 8.34689289e-02f, 8.51344690e-02f, -2.14277785e-02f, 4.69111875e-02f, 5.30582629e-02f,
  1.35771632e-01f, 2.74773408e-02f, 3.18900682e-02f, -2.23006234e-02f, -1.36705652e-01f, -2.22369015e-01f, -6.48615509e-02f, -4.24721912e-02f, 1.06266849e-01f, 3.02929562e-02f,
  -3.01200837e-01f, 6.74429089e-02f, -1.66510120e-01f, 1.95577532e-01f, -7.36805722e-02f, 1.18885726e-01f, -2.38912418e-01f, -3.13715078e-02f, -3.70103754e-02f, 1.85466576e-02f,
  -8.35805014e-02f, -3.64043228e-02f, 6.24634214e-02f, 1.55222774e-01f, 1.00662619e-01f, -2.01607287e-01f, -1.68477923e-01f, -1.44378752e-01f, -5.70549490e-03f, -3.81717384e-02f,
  -1.07233547e-01f, -8.64472538e-02f, 1.33910999e-01f, -6.79706484e-02f, -2.24961396e-02f, -2.54475713e-01f, -1.23423096e-02f, -2.47958656e-02f, -8.67242366e-02f, -8.78471211e-02f,
  -1.54911622e-01f, -2.07708448e-01f, -1.56473637e-01f, 1.00650579e-01f, -1.78416580e-01f, 7.45280832e-02f, 8.60483497e-02f, 3.29512954e-01f, -1.14808910e-01f, -1.36098593e-01f,
  -4.28480059e-02f, 2.11454839e-01f, -2.98588108e-02f, 3.02616656e-01f, 2.39967123e-01f, -8.57506916e-02f, 2.35487565e-01f, 5.06632477e-02f, 1.85515940e-01f, -7.52994940e-02f,
  1.17337562e-01f, 1.44776583e-01f, 1.34839833e-01f, -1.80367932e-01f, 4.08710390e-02f, 5.29467613e-02f, 9.22275707e-02f, -1.59326959e-02f, 2.63091087e-01f, 1.37869775e-01f,
  -3.27021003e-01f, 2.39067107e-01f, 1.12528555e-01f, 1.38535380e-01f, 2.58125424e-01f, -1.13397509e-01f, 8.78128782e-02f, -2.44917765e-01f, -2.83359177e-02f, -1.02781288e-01f,
  2.35911474e-01f, 2.13977590e-01f, -8.86834972e-03f, 1.83839783e-01f, 9.46387723e-02f, 1.32057860e-01f, -4.07561995e-02f, -1.08586490e-01f, -1.80660218e-01f, 1.61063254e-01f,
  1.20399266e-01f, 1.21541582e-02f, -1.89002618e-01f, 1.81105122e-01f, -1.47104442e-01f, 1.65408790e-01f, 1.24504775e-01f, 1.47419810e-01f, 1.30799532e-01f, 8.82795826e-02f,
  -1.88635048e-02f, -5.65030389e-02f, -7.14239925e-02f, 4.07800265e-02f, 1.65473804e-01f, 2.63397135e-02f, 4.85627800e-02f, 2.58890480e-01f, 8.97453055e-02f, -3.06112301e-02f,
  -1.74110532e-01f, 3.32059860e-01f, -3.12509835e-01f, -7.17853662e-03f, 2.20465168e-01f, -1.38043374e-01f, -7.81063586e-02f, 2.40085140e-01f, 4.22977298e-01f, 2.44309664e-01f,
  2.10793808e-01f, 1.71651304e-01f, 1.43473536e-01f, 2.54331212e-02f, -2.66044855e-01f, 2.93781254e-02f, 3.81056041e-01f, -9.76835117e-02f, 9.21396688e-02f, 1.27812132e-01f,
  2.14612812e-01f, 7.44350329e-02f, 1.05385125e-01f, 6.48921356e-02f, -6.77632615e-02f, -1.37396500e-01f, -3.71232741e-02f, 4.01919112e-02f, 9.54035968e-02f, -1.41524170e-02f,
  -1.16613619e-01f, -6.31305501e-02f, 5.39230183e-02f, -1.91403270e-01f, -1.04859203e-01f, 2.87173335e-02f, 5.66055365e-02f, -5.33938967e-02f, 1.78248942e-01f, 5.26269674e-02f,
  1.70134470e-01f, 6.34645969e-02f, -1.18778422e-01f, 1.37218609e-01f, 1.32518247e-01f, -1.15885390e-02f, -6.36297558e-03f, 8.79341960e-02f, -1.46373302e-01f, 6.66855946e-02f,
  9.55957919e-02f, 4.06730548e-02f, 6.56889826e-02f, -2.64199954e-02f, 7.81836361e-03f, -4.36551198e-02f, 1.99171484e-01f, 1.85768053e-01f, -1.54476523e-01f, -9.56370607e-02f,
  -9.25687551e-02f, 3.86483669e-02f, 8.75818729e-02f, -2.30967432e-01f, -2.07501486e-01f, 2.90164262e-01f, -1.56587481e-01f, 1.80582300e-01f, 1.23305861e-02f, -1.02601215e-01f,
  -1.92243561e-01f, -1.11085825e-01f, 2.78202415e-01f, 2.53784269e-01f, 2.46163979e-01f, 4.70686823e-01f, 1.80071704e-02f, 5.77782542e-02f, -3.78674716e-02f, 2.53845692e-01f,
  1.13156967e-01f, -1.39201507e-01f, 2.36785978e-01f, -7.07551017e-02f, 3.31633180e-01f, -5.96247502e-02f, -3.21179368e-02f, 1.09564684e-01f, -2.00653076e-01f, -8.51940960e-02f,
  -2.43670549e-02f, 2.21747413e-01f, 1.65681466e-02f, -7.08085150e-02f, -2.32949689e-01f, 2.69003928e-01f, 2.00797915e-01f, -1.54899925e-01f, -2.44708359e-01f, 3.28107588e-02f,
  -1.47266805e-01f, -2.09736392e-01f, 1.93248332e-01f, -8.17108899e-02f, 2.10110284e-02f, -6.61712512e-02f, -1.15383603e-01f, 2.10474968e-01f, -1.35653183e-01f, 5.05830720e-02f,
  -9.71981436e-02f, -1.60792381e-01f, 2.15373281e-02f, 2.75265612e-02f, 1.05036339e-02f, -2.78798938e-01f, -2.32887670e-01f, 5.26226312e-02f, -1.74978375e-01f, 2.30580885e-02f,
  1.32103920e-01f, -2.52154350e-01f, -2.58989371e-02f, 7.12653324e-02f, -1.17390389e-02f, -6.70778155e-02f, -1.20733075e-01f, 1.68361768e-01f, 1.15230933e-01f, 1.44635260e-01f,
  -3.41889895e-02f, -1.96193531e-01f, 2.13461146e-01f, -3.10645014e-01f, 4.17498425e-02f, 2.65302926e-01f, 2.93823123e-01f, -8.36096108e-02f, -5.53985983e-02f, -1.67984650e-01f,
  4.22898345e-02f, -7.74985477e-02f, -3.31106894e-02f, -3.25230658e-02f, 2.62255222e-02f, -2.21666560e-01f, -1.35440424e-01f, -1.27962992e-01f, -2.59832233e-01f, 1.85053661e-01f,
  1.57157574e-02f, 1.32106701e-02f, 8.16582963e-02f, 1.27472043e-01f, -2.23067310e-02f, -9.29448977e-02f, 1.46199122e-01f, 8.98751989e-02f, 5.65313026e-02f, 4.18137200e-02f,
  6.59841001e-02f, -1.37633517e-01f, 1.26708001e-01f, -1.49547150e-02f, 1.20091643e-02f, -8.47928748e-02f, -4.19021025e-02f, 1.37773335e-01f, 2.52648257e-02f, -1.33038133e-01f,
  -7.30454698e-02f, 1.06501475e-01f, 4.21180964e-01f, 2.75998712e-01f, 1.70174569e-01f, 1.95646226e-01f, -1.38558701e-01f, 1.74303681e-01f, -1.16780460e-01f, 1.47881165e-01f,
  1.30028903e-01f, 1.40206978e-01f, -2.55647242e-01f, -1.19923577e-01f, 7.59189576e-02f, -1.11940637e-01f, 1.12116218e-01f, 1.59290314e-01f, -2.28195470e-02f, -8.54878649e-02f,
  1.23000592e-01f, 1.94060579e-01f, 4.82831895e-02f, 1.01557501e-01f, -1.11031637e-01f, -1.95855260e-01f, -1.98463127e-02f, -2.99906105e-01f, -7.02632219e-02f, 6.50724173e-02f,
  3.53625685e-01f, 2.75312126e-01f, -4.10708115e-02f, 1.21306172e-02f, 1.29132032e-01f, 1.85270589e-02f, -1.72779858e-01f, 1.58287548e-02f, 1.90479517e-01f, 3.96823101e-02f,
  -1.17797509e-01f, 9.82204359e-03f, -2.39905193e-02f, 1.28009468e-01f, -1.57361478e-02f, -1.39966026e-01f, 2.03918442e-01f, -4.31094170e-02f, 6.65025041e-02f, -4.14624140e-02f,
  1.75905321e-02f, -1.66664451e-01f, 6.81434944e-02f, 9.63746011e-03f, 2.49674752e-01f, 2.24128049e-02f, -5.16952500e-02f, -1.08483419e-01f, -1.51590809e-01f, -6.65178970e-02f,
  -5.58554605e-02f, 1.36264324e-01f, 2.51203150e-01f, -5.53730465e-02f, -7.87191540e-02f, 9.40770805e-02f, 4.02420312e-01f, 1.77130848e-01f, 3.32888395e-01f, -3.43955904e-02f,
  1.05758198e-01f, -1.17073044e-01f, -6.73351018e-03f, 9.11645517e-02f, 1.69068798e-01f, -1.42583027e-01f, 1.60425842e-01f, 2.90086657e-01f, 3.45587879e-02f, 1.49178669e-01f,
  2.35506684e-01f, -1.62972778e-01f, 2.76807457e-01f, 2.58384943e-01f, -4.57486175e-02f, 1.29465058e-01f, 2.90951461e-01f, -1.75013002e-02f, 1.97983280e-01f, 3.81504819e-02f,
  1.95800692e-01f, 4.16119009e-01f, -9.87606794e-02f, 3.92418325e-01f, -5.44725731e-02f, -2.04906151e-01f, 4.65085953e-01f, 1.02924310e-01f, 6.96019158e-02f, -1.27982304e-01f,
  6.44680187e-02f, 3.70222852e-02f, -1.35509804e-01f, 4.90296222e-02f, 1.37889627e-02f, 1.92095906e-01f, 1.86590895e-01f, 2.27994453e-02f, 3.11882108e-01f, 1.25144169e-01f,
  1.36544228e-01f, -1.72828853e-01f, -4.34488118e-01f, 6.28378615e-02f, 3.60748777e-03f, 2.19053309e-02f, -1.60305694e-01f, -4.21517730e-01f, -1.74412832e-01f, 1.42293368e-02f,
  -3.38238239e-01f, 1.59342915e-01f, 2.76731640e-01f, 1.00562394e-01f, 3.32240909e-02f, -1.78836018e-01f, -2.67623961e-01f, -7.80728012e-02f, -4.94496562e-02f, -2.01479673e-01f,
  -1.34861797e-01f, 9.52596515e-02f, -7.77673349e-02f, -3.65833998e-01f, 5.18871322e-02f, 2.10517440e-02f, 1.52526945e-01f, -5.46772890e-02f, -1.14694118e-01f, -1.05121493e-01f,
  -2.03359708e-01f, -2.17918530e-02f, 2.22906172e-01f, 8.28723889e-03f, -3.22859585e-01f, -2.53819436e-01f, 5.22096530e-02f, 5.65482453e-02f, -2.81933397e-01f, 1.23042203e-01f,
  1.72628343e-01f, 1.02325909e-01f, -1.17052823e-01f, -1.84390873e-01f, 8.56997520e-02f, 1.66185483e-01f, 2.17060342e-01f, -1.14143975e-01f, -4.18737791e-02f, -2.55670309e-01f,
  7.84500316e-02f, -2.46985108e-02f, 6.02123793e-03f, -2.36699075e-01f, 2.15426106e-02f, -2.47891903e-01f, 9.61576849e-02f, -1.73336685e-01f, 1.17874853e-02f, -4.04101238e-02f,
  -1.47861317e-01f, 2.15145096e-01f, -3.84471267e-02f, -1.95002165e-02f, -1.82572380e-01f, 1.13956712e-01f, 1.49977162e-01f, -2.01098621e-01f, -2.35131755e-01f, 1.54494300e-01f,
  2.70949006e-01f, 6.97800517e-02f, -4.08098400e-01f, 7.45972618e-02f, 1.79533005e-01f, -3.48205209e-01f, 2.47265957e-02f, 7.01176049e-03f, -8.70617777e-02f, 2.77163953e-01f,
  7.89557248e-02f, 1.10324092e-01f, -2.29936227e-01f, 7.86762536e-02f, 4.20066481e-03f, -1.60414115e-01f, -4.15767103e-01f, 8.33362639e-02f, -3.44210654e-01f, 1.61724687e-01f,
  -2.85109520e-01f, 1.11769378e-01f, 2.30176657e-01f, 1.55789882e-03f, 9.33907032e-02f, 1.80723950e-01f, 3.22868019e-01f, 6.68052658e-02f, -1.16505645e-01f, -3.05540045e-03f,
  2.44378392e-02f, 2.06809372e-01f, 5.17575108e-02f, 1.19370878e-01f, -1.46544678e-02f, -2.91814536e-01f, -9.19625759e-02f, 1.88414186e-01f, 4.27861921e-02f, 2.79149860e-01f,
  1.25997037e-01f, 1.10516086e-01f, -2.25830004e-01f, -3.67166996e-01f, 4.87172604e-03f, -2.87780255e-01f, 8.66400599e-02f, -1.01425298e-01f, 2.49576032e-01f, -1.24690235e-01f,
  -3.44002962e-01f, 1.78362802e-01f, 1.84512228e-01f, -1.95920154e-01f, -1.68980464e-01f, 1.69523716e-01f, 1.48838079e-02f, -2.23716214e-01f, -1.89606681e-01f, 6.32855222e-02f,
  2.11477786e-01f, 4.81327735e-02f, -1.03671812e-01f, 1.36614412e-01f, 5.10555767e-02f, -6.03989400e-02f, -2.56310940e-01f, 3.08306694e-01f, 2.88924435e-03f, 1.78779796e-01f,
  1.26773447e-01f, -4.35290523e-02f, -7.32302964e-02f, -7.70453066e-02f, -1.17402375e-01f, 1.31515607e-01f, 8.53315219e-02f, -1.68155983e-01f, -2.19447166e-02f, 8.68505910e-02f,
  -7.06598088e-02f, 1.09080017e-01f, -1.05506048e-01f, -4.24436033e-02f, -1.23496428e-01f, -1.62391126e-01f, -1.11004515e-02f, 1.58328384e-01f, 2.06359223e-01f, 6.17340393e-02f,
  2.34685436e-01f, 7.48596638e-02f, 1.70962557e-01f, 6.86145350e-02f, -1.32961601e-01f, 7.77439475e-02f, 1.59622088e-01f, 2.10878909e-01f, -3.85810733e-01f, 1.07089184e-01f,
  -2.72255652e-02f, 1.11388221e-01f, 1.70759693e-01f, -9.99281928e-02f, -9.93580818e-02f, -1.66080717e-03f, 2.87292987e-01f, 4.37014431e-01f, 1.91261977e-01f, 1.06005944e-01f,
  1.83332235e-01f, -1.30473375e-01f, -2.22104993e-02f, 1.00229442e-01f, 2.14203522e-01f, 2.14268297e-01f, 1.58248290e-01f, 4.92462292e-02f, -4.05465402e-02f, -1.73149556e-02f,
  1.82852432e-01f, 3.03432811e-02f, -3.55496943e-01f, 1.57083035e-01f, -3.80586796e-02f, 3.26552927e-01f, -6.67640567e-02f, 1.07395824e-03f, -2.01531112e-01f, 2.75278091e-01f,
  2.90954918e-01f, -2.24321350e-01f, -1.61149241e-02f, 1.78764462e-01f, -1.52943179e-01f, 7.87652507e-02f, -1.34408534e-01f, 4.95101884e-02f, -2.18664277e-02f, -8.85421932e-02f,
  1.84206545e-01f, -1.04376085e-01f, -1.01732336e-01f, 1.22595437e-01f, 2.23889396e-01f, 2.06971601e-01f, -1.97683424e-01f, -1.20987892e-01f, 5.58871441e-02f, -2.56758034e-02f,
  -6.50295913e-02f, 1.36405736e-01f, -3.12082414e-02f, -2.39813462e-01f, -3.83940600e-02f, 2.09960610e-01f, 7.98840374e-02f, 1.80664837e-01f, -2.61538625e-02f, 3.70201431e-02f,
  3.44070166e-01f, 3.29621658e-02f, -3.21564019e-01f, 2.86657959e-02f, -2.60693640e-01f, 1.29638985e-01f, 7.42251938e-03f, -2.22060129e-01f, 6.38024285e-02f, -7.04347715e-02f,
  3.41052741e-01f, 8.53219926e-02f, -9.20234546e-02f, 1.37074500e-01f, 9.93006900e-02f, 8.98521580e-03f, -6.10232577e-02f, 4.42065904e-03f, 2.08815023e-01f, 2.07317565e-02f,
  3.09123546e-01f, -3.05312455e-01f, 6.74932078e-02f, 6.62206188e-02f, -2.05334976e-01f, 8.13809708e-02f, -1.25835210e-01f, -1.42007783e-01f, 1.70880347e-01f, 7.55268112e-02f,
  2.40614992e-02f, 7.64203072e-02f, -1.65011257e-01f, 5.22627532e-02f, -2.68546969e-01f, 6.61308295e-04f, -1.09118596e-01f, -4.77212146e-02f, -1.43770546e-01f, -1.91128969e-01f,
  -7.51594231e-02f, 2.65564978e-01f, 2.13795334e-01f, 4.84792665e-02f, -1.24012053e-01f, -1.01094209e-02f, -1.08201057e-01f, 2.77276691e-02f, 8.04152265e-02f, 1.34341121e-01f,
  -3.24075520e-02f, -1.06884487e-01f, 2.27996200e-01f, -2.32785016e-01f, 1.47801012e-01f, 1.87646285e-01f, 2.84906775e-01f, 9.03594717e-02f, 6.67492971e-02f, 9.42374095e-02f,
  1.31984323e-01f, 1.96413547e-01f, 1.27056196e-01f, 1.61424771e-01f, 1.44823834e-01f, -1.59596324e-01f, -1.86638579e-01f, 1.85237482e-01f, -7.00058695e-03f, 7.84197748e-02f,
  2.42574841e-01f, -1.30915314e-01f, -5.78311505e-03f, 3.17179412e-02f, -2.51929983e-02f, 3.73061597e-01f, -5.94227649e-02f, -2.60332618e-02f, -6.49854690e-02f, 9.43198353e-02f,
  -1.10578045e-01f, -1.17525868e-01f, 1.50338888e-01f, 2.10175663e-01f, -9.31659713e-02f, 2.84811676e-01f, 2.98087467e-02f, -3.81781310e-02f, 9.88245085e-02f, -4.22238652e-03f,
  4.36389856e-02f, -6.98613077e-02f, -1.19501270e-01f, 1.96530744e-01f, -9.30630639e-02f, -5.66540053e-03f, 2.74985489e-02f, 2.51794249e-01f, 2.83607364e-01f, -4.69591394e-02f,
  3.37949321e-02f, -1.14296183e-01f, 1.01349421e-01f, 1.27043307e-01f, 4.19843681e-02f, -1.18448436e-01f, 1.23663448e-01f, 4.24743481e-02f, 2.63955355e-01f, -2.65916526e-01f,
  2.47373626e-01f, 2.05227405e-01f, 5.85412495e-02f, -9.81864855e-02f, -1.36949822e-01f, 4.51699086e-02f, -1.39639273e-01f, 1.53789043e-01f, 1.68201253e-01f, 1.39150470e-01f,
  8.49514455e-02f, -2.34406501e-01f, -1.86859500e-02f, 1.89348847e-01f, 1.07167410e-02f, 1.19567819e-01f, -4.97222207e-02f, 8.99183750e-02f, 1.07545257e-01f, -1.68877497e-01f,
  -3.61357033e-01f, -4.62764539e-02f, -1.98495358e-01f, 3.51611018e-01f, -1.62739471e-01f, 5.84632605e-02f, 1.66224182e-01f, -3.16931844e-01f, 1.04201376e-01f, 6.12350972e-03f,
  1.44681614e-02f, 1.36292905e-01f, 6.97212368e-02f, -2.24187728e-02f, -6.57031639e-03f, 1.77228943e-01f, 2.84028202e-01f, -9.06332806e-02f, 1.49594843e-01f, -2.17811778e-01f,
  3.02912980e-01f, -4.33277637e-02f, -2.69907657e-02f, 1.44364551e-01f, -8.28720778e-02f, -7.25778714e-02f, 5.55898063e-02f, -7.16008544e-02f, -1.22688651e-01f, 1.15533620e-01f,
  -1.89868122e-01f, 1.00750096e-01f, -2.09310502e-01f, 7.30504245e-02f, -1.45305023e-01f, -8.75332393e-03f, -2.12639032e-04f, -3.88767244e-03f, 1.75744057e-01f, -1.86064013e-03f,
  1.53591827e-01f, 1.86567858e-03f, -7.36723915e-02f, -6.54375777e-02f, -1.07966326e-01f, -3.84219773e-02f, -1.11896254e-01f, 8.49933028e-02f, -1.27334222e-02f, 1.07327446e-01f,
  2.20086500e-01f, -1.76087096e-01f, 2.28921250e-01f, 8.32660589e-03f, 2.36327678e-01f, -1.89128127e-02f, 1.42154302e-02f, 8.76282826e-02f, -5.98059893e-02f, -2.18356818e-01f,
  -2.43212834e-01f, -7.84648806e-02f, 5.33782803e-02f, -3.34794194e-01f, -9.88639146e-02f, -3.10451910e-02f, 2.26992443e-01f, 1.66290045e-01f, -2.45364279e-01f, 1.59506917e-01f,
  -3.99558581e-02f, -1.81385502e-01f, -1.06574401e-01f, -6.48978427e-02f, -1.62433863e-01f, 2.13790685e-02f, -1.88611805e-01f, -1.44843999e-02f, -2.04853192e-02f, 1.15427636e-01f,
  -4.27240506e-02f, -8.09821561e-02f, 1.32091921e-02f, 3.88865806e-02f, 1.87189773e-01f, -1.37315720e-01f, -1.48885503e-01f, 2.19351858e-01f, 6.73382804e-02f, -2.75913835e-01f,
  1.68958396e-01f, -3.27137741e-03f, 6.07133992e-02f, -2.26613454e-04f, -2.42451817e-01f, -3.15911286e-02f, -1.02626877e-02f, 1.63039774e-01f, -4.95748892e-02f, 2.04804078e-01f,
  5.57246208e-02f, -3.46363544e-01f, 1.37905017e-01f, -7.16328621e-02f, 9.86809134e-02f, -3.66502777e-02f, 1.16119526e-01f, -3.42100821e-02f, -3.83299083e-01f, 1.12636521e-01f,
  -3.04273576e-01f, -7.24079013e-02f, 1.28143072e-01f, -4.08346616e-02f, 1.01244766e-02f, -1.03529602e-01f, 1.84248149e-01f, 1.94437876e-01f, -1.09712727e-01f, 2.80260239e-02f,
  3.24114002e-02f, 1.62117362e-01f, 2.35847235e-01f, -2.63865795e-02f, 1.14116572e-01f, 1.09446295e-01f, 1.79693013e-01f, 2.34181166e-01f, -3.27750027e-01f, -1.09097660e-01f,
  -1.73836529e-01f, -6.35281503e-02f, 1.38743836e-02f, -2.00094789e-01f, 2.12286100e-01f, -1.15216449e-01f, -2.09912255e-01f, 1.99283630e-01f, -1.20276585e-01f, -1.18956774e-01f,
  -8.64723995e-02f, 5.30146621e-02f, 5.74496761e-02f, -1.22707643e-01f, -6.91851899e-02f, -1.67562366e-02f, 1.83744147e-01f, 2.06496894e-01f, -6.78725392e-02f, 2.24206239e-01f,
  -1.83869541e-01f, -2.02997312e-01f, 8.86343271e-02f, 2.54153609e-02f, 1.04978360e-01f, -1.35092184e-01f, -1.58581972e-01f, 1.87228739e-01f, 1.69567034e-01f, 3.32608312e-01f,
  1.12723343e-01f, 1.43206030e-01f, 1.88738517e-02f, -4.16323058e-02f, -8.57643411e-02f, -1.16883576e-01f, -1.77631319e-01f, 2.31682181e-01f, 1.57334894e-01f, 2.32604533e-01f,
  2.19237521e-01f, -1.17231876e-01f, 3.78700756e-02f, -1.56980172e-01f, 1.66771084e-01f, 2.65291706e-02f, 4.66176495e-02f, -1.50247589e-01f, 1.18193947e-01f, 2.53586993e-02f,
  -9.23546206e-04f, -1.18493453e-01f, 2.06137419e-01f, -3.76907848e-02f, 7.75415227e-02f, 1.68831393e-01f, 1.20358765e-01f, -8.90951753e-02f, 9.74985734e-02f, 2.87644137e-02f,
  2.68949360e-01f, -1.59126834e-03f, -1.77801579e-01f, 3.98719460e-01f, -3.02922845e-01f, 9.39195082e-02f, 1.12206116e-01f, 1.27256336e-02f, 1.21405773e-01f, 1.51160598e-01f,
  7.78649747e-02f, 2.73338467e-01f, 2.20400959e-01f, 8.63712952e-02f, 1.14073008e-01f, -8.56700391e-02f, -1.10308640e-01f, -1.05197333e-01f, 3.21269743e-02f, -4.18582410e-02f,
  6.38669282e-02f, 8.28361735e-02f, 1.26212418e-01f, 1.30261227e-01f, 1.87589616e-01f, -1.54410796e-02f, -3.30115348e-01f, 2.27217838e-01f, -2.45823078e-02f, 2.64900506e-01f,
  -6.24607354e-02f, 4.94926795e-03f, -7.62650296e-02f, 1.96760505e-01f, 2.84699351e-01f, -4.39711101e-02f, 8.63567516e-02f, 1.27574667e-01f, -1.38306040e-02f, 2.01703459e-01f,
  1.13952197e-01f, 2.31221333e-01f, 1.54784769e-01f, 1.48246542e-01f, 4.82871383e-02f, -8.10543522e-02f, -2.46111558e-05f, 1.11082226e-01f, -1.93149433e-01f, 1.64436981e-01f,
  -2.08437949e-01f, 1.31490365e-01f, 3.32146883e-02f, -7.45685920e-02f, -5.64263389e-03f, -1.10168636e-01f, 1.44401580e-01f, 1.76765651e-01f, -2.03782469e-02f, -3.43204625e-02f,
  5.29516712e-02f, -2.54329652e-01f, 2.33288467e-01f, 2.12443113e-01f, 3.91786359e-03f, -9.75573733e-02f, 3.76836360e-01f, 1.11692727e-01f, 1.85456928e-02f, 2.93747662e-03f,
  -2.16818511e-01f, 2.37168282e-01f, -1.11550861e-03f, 1.52470246e-01f, 2.42455807e-02f, -2.15421289e-01f, 2.01184861e-02f, 4.48468141e-02f, 1.84753146e-02f, -2.03666076e-01f,
  8.73833150e-02f, 4.78807986e-02f, -2.06489768e-02f, -7.88895786e-02f, 1.54942900e-01f, 1.17102303e-01f, 1.60781890e-01f, 2.02739313e-01f, 2.25669086e-01f, 1.64188638e-01f,
  2.12086756e-02f, -6.98172152e-02f, -2.31855556e-01f, 9.81685589e-04f, -3.64474836e-03f, 7.29052797e-02f, 1.86973691e-01f, -1.68765053e-01f, -9.21941251e-02f, -5.86994812e-02f,
  -5.80067635e-02f, 8.03570971e-02f, 1.78219810e-01f, 1.76657468e-01f, 7.97026455e-02f, 6.60907626e-02f, 2.19367631e-02f, 6.72655702e-02f, -1.49340242e-01f, 1.22466557e-01f,
  -1.86457932e-01f, -2.10272849e-01f, -1.86025515e-01f, 6.70739338e-02f, 2.15538498e-02f, -5.19326553e-02f, 1.51753768e-01f, -7.18600824e-02f, 2.17670366e-01f, -1.32442161e-01f,
  1.56333029e-01f, 9.49128643e-02f, 1.13472939e-01f, -1.54859871e-02f, 5.04305772e-02f, -1.73940957e-01f, 2.09230766e-01f, 1.66067705e-01f, -6.10228814e-02f, -1.38351386e-02f,
  2.57137641e-02f, 3.08851719e-01f, -1.91767380e-01f, -8.43202695e-02f, 1.98226973e-01f, -3.99124064e-02f, -3.49288248e-02f, 2.38787442e-01f, 1.10920548e-01f, -2.77445046e-03f,
  2.73060292e-01f, -1.61400720e-01f, 1.10983320e-01f, -3.22783202e-01f, -2.76733547e-01f, -1.72340512e-01f, 2.21971929e-01f, -1.17813222e-01f, -8.67099240e-02f, 5.31283058e-02f,
  -1.89229578e-01f, 2.18464568e-01f, 9.04732570e-02f, -9.48602036e-02f, -1.66684583e-01f, 3.90650593e-02f, 1.16722807e-01f, -4.32220362e-02f, -1.44038294e-02f, -1.27827853e-01f,
  -4.16945182e-02f, -5.75283431e-02f, 5.61762229e-02f, -1.79527789e-01f, 1.49444595e-01f, -1.57277554e-01f, 5.41537553e-02f, 2.93222386e-02f, 1.02422200e-01f, 2.15002313e-01f,
  -3.78856659e-02f, -5.52852266e-02f, 1.76730696e-02f, -3.33595872e-02f, 1.40491039e-01f, 7.36501291e-02f, -1.51095673e-01f, 2.33672053e-01f, -2.44101599e-01f, 1.54134125e-01f,
  -1.55939877e-01f, 1.29275933e-01f, -6.77888170e-02f, 6.53175786e-02f, -1.54147416e-01f, 6.81704432e-02f, -5.59875146e-02f, -1.67572573e-01f, 1.03747463e-02f, -4.95814122e-02f,
  1.32661976e-03f, 2.22754758e-02f, -9.16744471e-02f, 2.61568308e-01f, 2.11189628e-01f, 5.12975007e-02f, -1.62768245e-01f, -3.47681224e-01f, 2.00505376e-01f, -2.17741951e-01f,
  -1.89657301e-01f, 3.12418431e-01f, 2.21103311e-01f, 5.25020510e-02f, -1.04602486e-01f, -2.93328948e-02f, 2.05204919e-01f, -1.91421788e-02f, -1.04887970e-01f, -7.01995492e-02f,
  9.00419205e-02f, -1.16044581e-01f, -1.33017406e-01f, -8.39515552e-02f, -2.38799810e-01f, 1.97597489e-01f, -1.26662046e-01f, -4.08992618e-02f, 2.66196012e-01f, -5.29060438e-02f,
  -3.96990739e-02f, -4.14005332e-02f, 2.88539492e-02f, -7.01930672e-02f, 3.53549570e-02f, -6.35215044e-02f, 4.07065339e-02f, -1.76462885e-02f, 1.53283969e-01f, 1.88044794e-02f,
  4.94729951e-02f, -6.30026385e-02f, -1.63407117e-01f, 9.78833362e-02f, 1.17113933e-01f, -6.44567609e-02f, 2.99149416e-02f, -2.50288565e-02f, 3.64478827e-01f, 1.47420704e-01f,
  3.77063155e-01f, 2.43392978e-02f, 2.96135340e-02f, 9.75245163e-02f, -7.62856528e-02f, 8.41964185e-02f, -1.76260937e-02f, -9.16541554e-03f, -4.30254638e-02f, 1.35479659e-01f,
  9.62042809e-02f, 1.65552907e-02f, -3.29327047e-01f, -1.64804459e-02f, -1.25779286e-01f, -5.38189124e-06f, -7.54707009e-02f, -3.07004899e-01f, -2.33216062e-02f, -1.91904023e-01f,
  9.70264489e-04f, 1.18167765e-01f, -1.62015527e-01f, -4.34284694e-02f, 1.68469027e-01f, -5.73512435e-01f, -2.12313548e-01f, -1.43035382e-01f, -3.87243211e-01f, -1.20734625e-01f,
  -1.71316490e-01f, 1.20609783e-01f, 3.30747180e-02f, -1.00431561e-01f, 5.28912619e-02f, -1.14569906e-02f, 9.02798176e-02f, 2.50410944e-01f, -3.10751349e-02f, 1.57278955e-01f,
  -1.12072326e-01f, 2.24340111e-02f, 3.75520508e-03f, -6.17143698e-02f, 1.54421702e-01f, -2.22677708e-01f, -1.30303890e-01f, -4.27208804e-02f, 6.68404400e-02f, 1.66150704e-02f,
  -4.18102443e-01f, 1.00592915e-02f, -9.97265875e-02f, -9.16108415e-02f, 1.65323496e-01f, -9.34643857e-03f, 7.80415237e-02f, 6.11644834e-02f, 1.99756458e-01f, 2.56404847e-01f,
  9.93438531e-04f, -9.72981229e-02f, 5.15180565e-02f, -2.17004959e-02f, -3.13733101e-01f, -1.68143123e-01f, 1.12668149e-01f, -7.92746618e-02f, -2.53704637e-01f, 1.10114694e-01f,
  2.29023889e-01f, 9.23907086e-02f, 2.21049562e-01f, 3.61213237e-02f, -3.67005169e-02f, -3.43906134e-02f, 1.68043181e-01f, 1.90263800e-02f, 8.10923874e-02f, 1.10296726e-01f,
  1.88046381e-01f, -1.79969072e-01f, -2.11130649e-01f, 3.82422566e-01f, -1.18939452e-01f, -4.95586125e-03f, 2.57672668e-01f, -1.38676599e-01f, -1.45175070e-01f, 1.05155200e-01f,
  3.05886209e-01f, 3.34522724e-01f, 1.84610963e-01f, 1.88329652e-01f, -6.14809431e-02f, 1.84837893e-01f, -2.66264051e-01f, 6.47068769e-02f, 2.18204424e-01f, 8.02181810e-02f,
  -4.48547117e-02f, 3.34587216e-01f, 2.07437113e-01f, -7.84912184e-02f, 1.16431683e-01f, 6.15812279e-02f, 8.92059058e-02f, -2.24988405e-02f, 9.07062143e-02f, 1.66738600e-01f,
  -4.67630289e-02f, 3.14461929e-03f, -1.42025799e-01f, 1.22389428e-01f, 3.38621557e-01f, -1.91343147e-02f, 5.42816408e-02f, 9.75192562e-02f, -1.20470576e-01f, 5.46801575e-02f,
  1.11537300e-01f, 8.58966112e-02f, 4.56789136e-02f, -2.97256149e-02f, 2.23821178e-02f, 9.37008858e-02f, 6.54888824e-02f, 1.47101372e-01f, 2.36520573e-01f, 1.15472777e-02f,
  7.67116845e-02f, 5.99523224e-02f, -3.24100186e-03f, 5.78128994e-02f, -8.57935846e-02f, -2.34870780e-02f, 1.69311002e-01f, 1.07037492e-01f, 1.73558995e-01f, 2.66520441e-01f,
  -3.77690457e-02f, -3.57843824e-02f, 2.68804938e-01f, 2.16162622e-01f, -1.11213364e-01f, 1.22677550e-01f, 7.01438040e-02f, -2.63843656e-01f, 1.15750283e-01f, 5.07928543e-02f,
  1.90514296e-01f, 1.65585920e-01f, -7.38942996e-02f, 2.26708174e-01f, 9.13978368e-02f, 1.45818219e-01f, 4.23693657e-01f, 1.68435574e-01f, 1.39979050e-01f, -5.66297621e-02f,
  5.90122258e-03f, 1.55231163e-01f, -1.59854248e-01f, 1.55268788e-01f, -6.69168681e-02f, -2.29682431e-01f, 1.30097046e-01f, 4.22634035e-02f, 1.66720524e-01f, 1.20251942e-02f,
  -1.69902816e-01f, -1.84879433e-02f, -1.25742808e-01f, 2.11962506e-01f, -6.35668030e-03f, 3.15135531e-02f, -1.62853241e-01f, -1.75414994e-01f, 1.92967921e-01f, -7.44829699e-02f,
  -2.79552877e-01f, 1.79543376e-01f, 7.67056718e-02f, -2.02196166e-01f, -2.00160757e-01f, -6.32477924e-02f, -1.54289752e-01f, -1.33043885e-01f, 8.08740184e-02f, -5.03789298e-02f,
  2.02418193e-01f, 4.01080072e-01f, 1.97262198e-01f, -1.02498725e-01f, -1.38456255e-01f, -1.06390104e-01f, 9.21288431e-02f, -6.98964745e-02f, 6.91333935e-02f, 7.27581456e-02f,
  -1.82533003e-02f, 1.10311814e-01f, 1.76881969e-01f, -2.02757925e-01f, -1.02987573e-01f, -3.42731439e-02f, 1.07252248e-01f, 1.75383105e-03f, 1.89155210e-02f, 1.57720834e-01f,
  -1.52943060e-01f, -1.45391032e-01f, 1.07765004e-01f, -2.86942959e-01f, 1.70671903e-02f, -2.40091190e-01f, -1.80119097e-01f, 1.19873755e-01f, -2.53753185e-01f, 2.40692601e-01f,
  -7.91992396e-02f, -2.52581954e-01f, -2.15692874e-02f, -4.30314317e-02f, -7.89676458e-02f, -1.83269024e-01f, -2.13595480e-02f, 1.07399210e-01f, -3.61784101e-01f, 1.75835073e-01f,
  -2.69268960e-01f, 3.78035791e-02f, -8.46759006e-02f, -6.02187142e-02f, 2.86740601e-01f, 1.27860755e-01f, 1.06853895e-01f, -1.00545019e-01f, -8.59626383e-02f, -3.74347791e-02f,
  1.30425274e-01f, 1.57884538e-01f, 3.58805060e-01f, -1.08248547e-01f, -4.10277285e-02f, -1.45980358e-01f, -3.41721624e-02f, -6.22519441e-02f, -1.63183674e-01f, 5.89268515e-04f,
  1.71540529e-01f, 1.21469505e-01f, 3.00590899e-02f, 1.06727161e-01f, 3.07953179e-01f, 1.72600985e-01f, 1.72815144e-01f, -2.56332420e-02f, -1.27763614e-01f, 8.51328447e-02f,
  2.47638002e-02f, 1.25315994e-01f, 1.12158224e-01f, 1.07011318e-01f, -1.05043806e-01f, 4.80454043e-02f, -9.06665623e-02f, 6.75677508e-02f, -1.28943816e-01f, -1.18732415e-01f,
  4.27983478e-02f, -1.14644818e-01f, 5.14972135e-02f, 1.04089640e-01f, -9.46832523e-02f, 6.32909313e-02f, -3.57300609e-01f, 5.90702109e-02f, -2.73500949e-01f, 1.48324966e-01f,
  1.24891959e-01f, -1.67900935e-01f, -5.60117811e-02f, -3.81555945e-01f, -2.51178265e-01f, -1.40260056e-01f, 2.46170998e-01f, 5.06164208e-02f, 8.50346088e-02f, 3.80388163e-02f,
  7.45349899e-02f, -1.55385718e-01f, 1.68582410e-01f, -1.24362409e-01f, -1.27882257e-01f, 1.56517103e-01f, 1.09436564e-01f, -1.43064171e-01f, -1.95836455e-01f, 5.84327355e-02f,
  -3.23042199e-02f, -4.62484509e-02f, 2.00755824e-03f, 1.00050464e-01f, 2.52836257e-01f, -9.88247339e-03f, -3.25363517e-01f, 2.29206681e-01f, 1.78101624e-03f, 1.59259975e-01f,
  -1.94489453e-02f, 9.65775400e-02f, 1.71587929e-01f, 2.06266686e-01f, 1.32331938e-01f, 5.44155203e-02f, -1.14099249e-01f, 5.71537130e-02f, -2.02963457e-01f, -4.88593280e-02f,
  -2.34064698e-01f, 5.80459572e-02f, 2.31530759e-02f, 1.03011258e-01f, 1.83292955e-01f, -9.10472125e-02f, -8.82862285e-02f, -2.96569884e-01f, 1.87106896e-02f, -1.36634111e-01f,
  1.92929298e-01f, 2.34741330e-01f, 1.27616122e-01f, 1.41618714e-01f, -7.16523966e-03f, 6.78400025e-02f, 1.89800695e-01f, 7.00917793e-03f, -3.16975027e-01f, -2.13375613e-01f,
  -1.20667338e-01f, 3.85374576e-01f, 1.97514161e-01f, 8.32023695e-02f, 8.64676461e-02f, 7.96361268e-03f, 1.72503874e-01f, 7.10228533e-02f, 5.89437895e-02f, 1.85415536e-01f,
  1.72482625e-01f, 8.31542686e-02f, 9.78548899e-02f, 1.74863175e-01f, 4.57545407e-02f, 3.36573660e-01f, 1.62546396e-01f, -1.23772435e-01f, 2.15176627e-01f, -1.56735837e-01f,
  1.80934370e-01f, 1.64906925e-03f, -3.32960010e-01f, 2.58962452e-01f, 1.07556179e-01f, 3.54681969e-01f, 8.06529541e-03f, 1.31285429e-01f, -1.17154852e-01f, 2.16783866e-01f,
  -1.15238175e-01f, -8.50173831e-02f, 4.85662557e-02f, 2.30894953e-01f, 5.05412221e-02f, 6.46701977e-02f, -1.27012357e-01f, 6.39371797e-02f, -7.81372935e-03f, 1.71658859e-01f,
  2.87667692e-01f, -1.72024474e-01f, -3.12992632e-01f, 2.30402350e-02f, -7.02745989e-02f, 2.36078054e-01f, -1.65724352e-01f, -1.46062180e-01f, 2.24285260e-01f, -1.45725280e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  -8.28215107e-02f, -6.51739687e-02f, 1.19261503e-01f, 1.73659578e-01f, -8.17803293e-02f, 4.78925370e-02f, 3.37843113e-02f, -2.12297644e-02f, 4.00738306e-02f, 1.67646229e-01f,
  9.86522529e-03f, 5.45432977e-02f, 7.95159265e-02f, -1.36660766e-02f, 3.79553847e-02f, 1.23148829e-01f, 5.60652800e-02f, 4.43056636e-02f, -4.45160344e-02f, 2.90010357e-03f,
  -1.56148942e-02f, 1.80270299e-01f, 6.52792528e-02f, 1.98093534e-01f, 3.11220475e-02f, 6.61276728e-02f, 2.21329540e-01f, 4.95525822e-02f, -7.66941905e-02f, 1.12852767e-01f,
  -2.56689731e-02f, -5.03020473e-02f, 1.72997534e-01f, -2.85681300e-02f, -6.67315945e-02f, -4.19987589e-02f, 4.98479195e-02f, 1.56758830e-01f, 6.56687915e-02f, 1.84533939e-01f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  2.73190252e-02f, 1.58848926e-01f, -1.73481032e-02f, 1.50360435e-01f, -4.53855842e-02f, -1.02289476e-01f, 1.37516871e-01f, 5.77838011e-02f, -4.83296365e-02f, 2.15888664e-01f,
  4.88992445e-02f, 8.39252174e-02f, -1.32155254e-01f, 7.33883306e-02f, 7.61885419e-02f, 1.19953074e-01f, 6.06754199e-02f, -1.59454942e-01f, 1.54265547e-02f, -6.08960167e-02f,
  7.18598589e-02f, -1.35965943e-01f, -2.57187217e-01f, -5.21600060e-02f, 1.49213850e-01f, -4.29733060e-02f, 6.18522242e-02f, 1.15434285e-02f, -3.93646322e-02f, 1.13766804e-01f,
  5.22213336e-03f, -1.36122871e-02f, -1.31752819e-01f, 8.38479027e-02f, -4.96787168e-02f, 6.70387074e-02f, 6.42716512e-02f, 2.24330649e-02f, 4.62540165e-02f, 3.27696055e-02f,
  -1.70472860e-01f, -6.01209179e-02f, -3.67109090e-01f, -1.69858694e-01f, 1.17498813e-02f, 1.19954191e-01f, -1.92837283e-01f, 1.87597483e-01f, -1.18094280e-01f, 7.10573569e-02f,
  -7.76650757e-02f, -1.51912257e-01f, -6.39620721e-02f, -5.94993047e-02f, -1.84077680e-01f, -2.45808065e-02f, -1.57604888e-01f, 1.46597296e-01f, 1.49507508e-01f, 9.59095731e-03f,
  8.83089844e-03f, 6.25947770e-03f, -1.22399263e-01f, -1.47379741e-01f, -1.71252340e-02f, 8.31587240e-02f, -1.08694635e-01f, -9.75051075e-02f, 5.92825525e-02f, -1.93675935e-01f,
  4.45302464e-02f, 1.32582143e-01f, 5.43599762e-02f, 4.78151143e-02f, 8.21928903e-02f, 1.86613038e-01f, 2.89341837e-01f, 2.27321740e-02f, 3.07266936e-02f, 1.57093167e-01f,
  -2.48739615e-01f, -5.58863804e-02f, 1.71820566e-01f, -5.32417111e-02f, 4.04383801e-02f, 4.36851084e-02f, 6.66633174e-02f, 1.16172038e-01f, 4.13622633e-02f, -1.08392850e-01f,
  -1.13935418e-01f, -1.20720856e-01f, -2.11773887e-02f, -1.70914173e-01f, 4.29909118e-02f, 1.58183891e-02f, -7.57859740e-03f, 3.72118130e-02f, -9.88412872e-02f, 2.15254903e-01f,
  -8.50092694e-02f, 6.03840239e-02f, 1.96470410e-01f, -1.22050583e-01f, -3.94288450e-02f, 2.05865219e-01f, 4.55488451e-02f, -2.16133650e-02f, 2.26138338e-01f, -1.03195002e-02f,
  8.03390145e-02f, -1.68676496e-01f, -9.11254883e-02f, -2.79865563e-02f, -9.96614769e-02f, -8.27912167e-02f, -7.66284764e-02f, -4.84805144e-02f, -4.79482561e-02f, 5.89375757e-02f,
  4.21643220e-02f, 1.12358317e-01f, 3.00996512e-01f, -5.39995171e-02f, 7.65794015e-04f, -6.94274753e-02f, 2.08748460e-01f, -4.77556661e-02f, 1.12935305e-01f, -4.61776815e-02f,
  -2.21019804e-01f, -1.65327378e-02f, 4.86535057e-02f, -3.97109762e-02f, -1.87272206e-01f, -1.93042740e-01f, 3.26806121e-02f, -1.63242429e-01f, 8.13285857e-02f, -1.94553360e-01f,
  9.52792913e-02f, 8.25091004e-02f, 1.89547569e-01f, -3.09057176e-01f, 2.92555746e-02f, -1.78687945e-01f, -2.31932461e-01f, 5.04300781e-02f, -2.41495132e-01f, 2.41901144e-01f,
  1.04338326e-01f, -1.57158479e-01f, 5.80440927e-03f, 9.74266753e-02f, -1.61167458e-02f, 8.94147679e-02f, -8.55947137e-02f, 9.85894948e-02f, -1.12899296e-01f, -5.35214767e-02f,
  -3.93808000e-02f, 5.11218160e-02f, 1.61978547e-02f, -5.04238233e-02f, 5.07755391e-02f, 1.07327871e-01f, -3.29720788e-02f, 1.53959226e-02f, 3.43768224e-02f, -2.36180082e-01f,
  5.71075827e-02f, 1.84529841e-01f, -1.06886096e-01f, -2.44628668e-01f, 6.45594448e-02f, -8.44026133e-02f, 9.16518345e-02f, 1.65456429e-01f, -1.50950834e-01f, 4.29263078e-02f,
  6.69952333e-02f, 6.76486418e-02f, -6.66001365e-02f, 4.95894067e-02f, -1.27557755e-01f, 3.23412591e-03f, 2.35888585e-02f, -1.75022632e-01f, 5.64431585e-02f, 1.07947953e-01f,
  -2.09841691e-02f, 1.57474324e-01f, 9.57017466e-02f, 1.35663316e-01f, -3.18952620e-01f, -1.95807695e-01f, 1.53296471e-01f, -9.65542197e-02f, 4.04191092e-02f, -7.22612292e-02f,
  -5.48263416e-02f, 1.25616506e-01f, 5.48319966e-02f, 6.22517839e-02f, -7.10726604e-02f, 8.47974643e-02f, 2.87067533e-01f, 7.67112151e-02f, -2.91174978e-01f, -2.14142561e-01f,
  -1.16485087e-02f, 9.31551494e-03f, -1.55925781e-01f, -4.22964282e-02f, -8.72257575e-02f, -5.70358485e-02f, 3.76280285e-02f, -5.98293655e-02f, -2.20136881e-01f, 3.40548009e-02f,
  8.20015967e-02f, -8.09142441e-02f, 2.36665290e-02f, -7.09416568e-02f, -1.49973072e-02f, -3.70606743e-02f, 1.17221937e-01f, -7.12933987e-02f, 8.87468234e-02f, 4.56223125e-03f,
  1.30656213e-01f, -6.70592263e-02f, -1.38287619e-01f, 6.74007162e-02f, -8.24649408e-02f, -9.26382095e-03f, 2.37193540e-01f, -3.38843226e-01f, -1.15551330e-01f, -1.65432721e-01f,
  1.53314844e-01f, 6.39538616e-02f, 6.05404153e-02f, -9.25838873e-02f, -2.40662232e-01f, 3.39015238e-02f, 4.59362054e-03f, -5.30635938e-02f, -1.67357415e-01f, -8.93360749e-03f,
  2.16164663e-01f, 1.72028765e-01f, -5.42003214e-02f, -9.79351997e-02f, 1.61532074e-01f, -1.08888343e-01f, -3.78370211e-02f, -1.59961313e-01f, 3.89207415e-02f, -8.76745805e-02f,
  -8.06547776e-02f, 6.53254837e-02f, -4.69680242e-02f, -1.90727830e-01f, -5.24608381e-02f, 8.86982158e-02f, 4.99176830e-02f, -2.43970267e-02f, 1.18659809e-01f, 2.12913245e-01f,
  1.66404858e-01f, -2.16109335e-01f, 8.09435323e-02f, 2.99892314e-02f, -1.75408483e-01f, 1.91735402e-01f, -2.86183536e-01f, 2.43210383e-02f, -5.46369441e-02f, -8.46452937e-02f,
  9.08455104e-02f, 1.24486893e-01f, -1.61793113e-01f, -2.20003948e-02f, 7.91373029e-02f, 5.38014807e-02f, -1.01116471e-01f, -8.11830238e-02f, 3.97135057e-02f, 7.03335479e-02f,
  3.56868804e-02f, -1.95459370e-02f, 5.80009772e-03f, -7.27212504e-02f, 5.76912984e-03f, -1.07403547e-01f, 2.37858891e-02f, 3.43664363e-02f, 7.24630356e-02f, 2.25165635e-02f,
  -1.03690485e-02f, 6.28714040e-02f, -2.30971500e-01f, -1.39321476e-01f, 8.44769776e-02f, 1.94508943e-03f, 1.70069695e-01f, 1.36535823e-01f, -1.16169088e-01f, -5.64449392e-02f,
  2.40192357e-02f, -7.97832236e-02f, -1.69034556e-01f, -3.04162428e-02f, -2.73936503e-02f, -4.76929173e-02f, -5.67308394e-03f, -2.79300064e-02f, -1.84178263e-01f, 5.79874627e-02f,
  8.13027248e-02f, 1.04701251e-01f, -6.39057681e-02f, -1.26478570e-02f, 2.78609842e-01f, -7.31885582e-02f, -8.51326361e-02f, 1.06381968e-01f, -7.40516633e-02f, 4.42339145e-02f,
  2.09260415e-02f, 1.44167766e-01f, -1.48955919e-02f, -1.37181759e-01f, -3.12259257e-01f, 7.33469054e-02f, -1.11991212e-01f, -9.20300186e-02f, 1.20785348e-01f, -1.47480786e-01f,
  4.65071909e-02f, 8.47005472e-02f, -1.11847572e-01f, 6.31965324e-02f, 1.17358454e-01f, 3.30040120e-02f, 1.50563307e-02f, 6.43273517e-02f, -1.86747536e-01f, -3.28951180e-02f,
  -4.31421772e-02f, 1.00647412e-01f, -8.40013176e-02f, -1.06821492e-01f, 6.04336597e-02f, 1.34223968e-01f, 1.12209171e-01f, 1.56282842e-01f, 3.30226980e-02f, 4.90657054e-03f,
  8.68625119e-02f, 9.79941338e-02f, 7.44779408e-02f, 5.92262521e-02f, -4.61217836e-02f, -1.03171542e-02f, 6.95136860e-02f, -3.91838700e-02f, -1.97419718e-01f, -1.35223553e-01f,
  9.83114988e-02f, 5.57838939e-03f, 1.27282187e-01f, -8.19385946e-02f, -6.76017702e-02f, 8.59796405e-02f, -5.99755608e-02f, -1.93119422e-02f, -4.47089411e-03f, -9.28139091e-02f,
  -1.05243132e-01f, -4.47496697e-02f, 1.66564658e-01f, -1.59004062e-01f, 2.61138350e-01f, 5.71783632e-02f, 4.80897501e-02f, 1.51994690e-01f, 9.19589922e-02f, -2.22300962e-01f,
  3.94585058e-02f, 2.23083943e-01f, 9.82947499e-02f, 2.01538373e-02f, 2.29701772e-01f, -1.29275516e-01f, -1.19335111e-02f, -9.09088776e-02f, -1.67104647e-01f, 8.82572159e-02f,
  1.26814708e-01f, 2.51231849e-01f, 5.15852794e-02f, 1.85340032e-01f, -1.95982475e-02f, 7.98992515e-02f, 1.45425916e-01f, 2.15978757e-01f, 4.01021633e-03f, 7.83323124e-02f,
  -6.33524135e-02f, -1.68694764e-01f, -4.19764174e-03f, -1.24868833e-01f, -1.29979670e-01f, 3.68401892e-02f, -7.83157200e-02f, 1.05153576e-01f, -9.14009586e-02f, -1.63292587e-01f,
  -1.33471221e-01f, -4.12961515e-03f, -1.22661002e-01f, -2.85049118e-02f, 5.12107462e-02f, 4.44435291e-02f, -6.47147465e-03f, 4.55067270e-02f, 5.22675253e-02f, -1.53403401e-01f,
  1.27707630e-01f, -1.56542987e-01f, 1.60854787e-01f, -3.33126895e-02f, -1.78708896e-01f, -1.22470923e-01f, -1.45742670e-02f, 3.64936963e-02f, 7.25713074e-02f, -1.66500509e-01f,
  1.42804226e-02f, 2.65056361e-03f, -6.82023987e-02f, -1.36344120e-01f, 2.75372099e-02f, 7.54839135e-03f, -8.73579532e-02f, 1.23800717e-01f, 5.75133115e-02f, -2.53431033e-02f,
  1.48672357e-01f, 1.85623556e-01f, 1.37229174e-01f, -7.01624528e-02f, -1.56293511e-02f, 4.66232784e-02f, 9.93583165e-03f, 2.32179202e-02f, -1.88616335e-01f, -6.88416734e-02f,
  1.19747981e-01f, -2.27691252e-02f, -1.65818512e-01f, 1.28050506e-01f, 3.44140828e-02f, -1.11226164e-01f, 1.10686421e-02f, 1.56246275e-01f, 7.25179240e-02f, 3.73835526e-02f,
  1.80066735e-01f, 1.59459785e-01f, 7.53697306e-02f, 1.04969740e-01f, -1.31562397e-01f, 3.46397534e-02f, 3.32193002e-02f, -7.30167925e-02f, -1.26085714e-01f, -1.11570675e-03f,
  -5.44807017e-02f, -8.34615976e-02f, 4.87826802e-02f, -1.59632593e-01f, 2.67068800e-02f, -1.06906325e-01f, -6.52639344e-02f, -1.42813087e-01f, 1.26728132e-01f, 1.33303061e-01f,
  3.20600420e-01f, -5.32313287e-02f, 1.04217693e-01f, -3.64621468e-02f, 5.36439307e-02f, -2.11221918e-01f, 2.51546782e-02f, 1.19441971e-01f, -9.46431458e-02f, -1.01303071e-01f,
  1.74999520e-01f, -2.35752314e-02f, 4.90858816e-02f, -7.17105940e-02f, 9.61509570e-02f, 1.06635951e-01f, -1.66186556e-01f, 1.78526223e-01f, 2.24442612e-02f, 1.16320722e-01f,
  -1.37299359e-01f, -1.30972043e-01f, 9.42973047e-02f, -3.58279608e-02f, -9.45735723e-02f, -1.06722891e-01f, 2.07478721e-02f, 1.84214845e-01f, -3.10561806e-02f, -8.22141767e-02f,
  -8.28898977e-03f, -2.08646487e-02f, 5.95794469e-02f, -1.36950865e-01f, -7.82265067e-02f, -1.43246278e-01f, 1.38433546e-01f, 4.64068465e-02f, -1.02158897e-01f, -2.10476235e-01f,
  9.10899341e-02f, -5.15719950e-02f, 7.49916807e-02f, 4.98882160e-02f, 2.25640282e-01f, 1.24826119e-03f, 1.28992558e-01f, 1.33548491e-02f, 1.41753182e-01f, -4.52033803e-02f,
  -2.08980083e-01f, -1.19022615e-01f, -6.27302676e-02f, 1.28040254e-01f, 2.23326869e-02f, 5.78026138e-02f, 2.27516983e-02f, -1.01206116e-01f, -8.23369771e-02f, 1.50366530e-01f,
  1.88202113e-02f, -2.81367805e-02f, -8.10500886e-03f, -1.44059196e-01f, -1.19698867e-01f, -7.52554387e-02f, -8.75370950e-03f, -1.50158837e-01f, 1.56333759e-01f, 7.16824457e-02f,
  -1.77958772e-01f, -4.50335369e-02f, -1.48596643e-02f, -1.13988146e-01f, -3.90080176e-02f, 1.70298964e-01f, -1.47711754e-01f, -9.91804302e-02f, 3.58925574e-02f, -1.34775728e-01f,
  7.13923422e-04f, -1.40106976e-01f, -1.61095232e-01f, 8.43795985e-02f, -3.44643742e-02f, -1.81610927e-01f, -2.35658884e-02f, -1.81670293e-01f, 2.10700870e-01f, -8.08068663e-02f,
  -2.88710687e-02f, 4.37745005e-02f, 2.64448095e-02f, 2.57030595e-02f, -6.89304918e-02f, -1.53248981e-01f, -1.62678853e-01f, 1.16712116e-01f, 4.41285297e-02f, -5.75417243e-02f,
  -1.79325968e-01f, -8.56300145e-02f, 7.57664666e-02f, 2.97655631e-02f, 1.18702995e-02f, -4.52343710e-02f, -1.75357834e-01f, 4.63194996e-02f, 7.07815811e-02f, 1.21404119e-01f,
  -1.04438022e-01f, -6.38495162e-02f, 2.37320941e-02f, -2.12681904e-01f, -9.45783406e-02f, -1.01652846e-01f, -3.21806148e-02f, 5.90745211e-02f, -6.17554784e-02f, -7.96576217e-02f,
  2.74636243e-02f, 1.72588021e-01f, -1.40331103e-04f, 9.63525325e-02f, 4.85061808e-03f, -9.32058394e-02f, 1.58089086e-01f, 3.36589403e-02f, 7.56460577e-02f, 2.36346722e-02f,
  -3.85730900e-02f, 2.25495949e-01f, -2.29294132e-02f, -3.78454812e-02f, -1.66907615e-03f, -1.76436082e-01f, 2.27052718e-02f, -6.08049631e-02f, -2.23683659e-02f, -9.31566954e-02f,
  1.02745309e-01f, 1.25282750e-01f, 7.56757483e-02f, -5.10085709e-02f, -1.81809530e-01f, 1.28509745e-01f, 1.17800951e-01f, 2.17139199e-01f, -4.19551916e-02f, 7.47179464e-02f,
  3.10424697e-02f, -1.53411373e-01f, 8.97059217e-03f, -1.61023229e-01f, -1.63341179e-01f, 1.31333858e-01f, -1.28883988e-01f, 7.45889693e-02f, 4.40295041e-02f, 4.47299778e-02f,
  8.94268379e-02f, 5.15376143e-02f, -2.09296588e-02f, 1.86069995e-01f, 8.02708194e-02f, -6.54623136e-02f, 4.34072427e-02f, 1.47188231e-01f, -1.07536055e-01f, -5.16027547e-02f,
  7.07383081e-02f, 2.05546439e-01f, -2.71598101e-02f, 4.17823065e-03f, 3.37966941e-02f, 4.11209790e-03f, 9.11561176e-02f, -5.06673604e-02f, -2.36529764e-02f, -1.92077365e-02f,
  6.31332994e-02f, -6.75491691e-02f, -1.18945017e-01f, 2.10931793e-01f, 5.33096716e-02f, 1.89927071e-01f, 1.03299497e-02f, 1.12646498e-01f, -2.97888089e-02f, -1.02188990e-01f,
  -8.55773629e-04f, 5.03687896e-02f, 1.32038221e-01f, -1.16600059e-01f, 9.30164941e-03f, 1.64694130e-01f, -7.42164552e-02f, -5.17451130e-02f, 8.27390030e-02f, 2.99704634e-02f,
  1.22135565e-01f, -1.75805781e-02f, 9.64005515e-02f, 4.90967520e-02f, -3.10015753e-02f, -7.42077306e-02f, 2.30333786e-02f, 6.94097579e-02f, 2.07490087e-01f, 1.25957012e-01f,
  1.12172246e-01f, 1.45016357e-01f, -1.08349785e-01f, 1.80985153e-01f, -2.24313810e-01f, -9.36502442e-02f, 4.23938453e-01f, -6.98801223e-03f, 1.91504419e-01f, 4.95168790e-02f,
  -1.08810373e-01f, -2.14297641e-02f, 1.13112681e-01f, 2.27578487e-02f, -1.13062397e-01f, -1.05550997e-01f, -1.36824965e-01f, -5.29725989e-03f, -1.48647707e-02f, -1.93553001e-01f,
  4.41276699e-01f, -1.76036030e-01f, -8.43275860e-02f, 3.68245766e-02f, -1.70484796e-01f, 1.16915293e-01f, 1.10768182e-02f, -2.53261596e-01f, 1.41127706e-01f, 9.24901888e-02f,
  1.08320564e-01f, 8.94071236e-02f, 1.07222229e-01f, 1.04408637e-01f, -1.07817361e-02f, 4.60456200e-02f, -1.14362575e-01f, -8.61177519e-02f, -4.94727753e-02f, -2.14323744e-01f,
  1.67857751e-01f, -1.07315399e-01f, -2.11355060e-01f, -5.23940697e-02f, -9.91553888e-02f, -5.37476167e-02f, 1.31948620e-01f, 3.45060565e-02f, 8.72408748e-02f, 1.73326671e-01f,
  -6.80967141e-03f, 1.52388420e-02f, -2.50715371e-02f, 3.64938937e-02f, -1.97568268e-01f, -1.23962082e-01f, -1.30019188e-01f, -1.14969440e-01f, -1.20438069e-01f, 6.13989420e-02f,
  -5.86240776e-02f, 1.49424397e-03f, -2.29538798e-01f, -1.05507463e-01f, 1.09719194e-01f, -2.80375499e-03f, -1.55971989e-01f, -7.89813045e-03f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  1.14863254e-01f, -2.92889088e-01f, 6.01130426e-02f, -6.15858398e-02f, -7.19795451e-02f, 1.23134747e-01f, -1.37128115e-01f, 1.52147949e-01f, 1.89018831e-01f, -1.77506246e-02f,
  -3.56906764e-02f, -4.05137911e-02f, -9.99913141e-02f, -1.91456422e-01f, -1.12666443e-01f, 3.88760269e-01f, -3.22221279e-01f, 1.03166383e-02f, 2.16309264e-01f, 1.86857730e-01f,
  2.04193577e-01f, -2.23078758e-01f, 2.86200136e-01f, -1.99536346e-02f, 1.01325877e-01f, 6.71648681e-02f, 9.34378952e-02f, 3.76734957e-02f, 6.62131160e-02f, -6.43385667e-03f,
  4.57096286e-02f, 1.56759128e-01f, 1.02628991e-01f, -6.54833065e-03f, 5.89345060e-02f, -4.12238762e-02f, 8.37124884e-03f, 9.27028432e-02f, 4.54083923e-03f, 1.46164754e-02f,
  -1.41904756e-01f, -5.40530644e-02f, 2.66281456e-01f, 8.66768509e-02f, -6.60536587e-02f, -2.43976101e-01f, 1.96898967e-01f, -1.60832018e-01f, 3.64873745e-02f, 8.57932344e-02f,
  -3.93427685e-02f, 1.37149706e-01f, 5.72264940e-02f, 2.59641051e-01f, 8.82465243e-02f, 3.73365432e-02f, -1.11725062e-01f, -3.19991112e-02f, -1.24817535e-01f, 1.23014197e-01f,
  -2.29153112e-01f, 1.48371905e-01f, -6.73851520e-02f, 7.63982534e-02f, 1.98571160e-02f, 1.24741249e-01f, 2.52600968e-01f, -5.53774589e-04f, 1.39606193e-01f, 1.55661061e-01f,
  2.81607866e-01f, 2.17075437e-01f, 3.04789972e-02f, 2.57195026e-01f, 1.56278566e-01f, 1.60263777e-01f, -2.04391897e-01f, 1.41947612e-01f, 9.53410566e-02f, -9.45317224e-02f,
  1.28063587e-02f, -3.03200513e-01f, -1.12758562e-01f, -4.23218936e-01f, 1.03495844e-01f, -1.01212375e-01f, -2.95326978e-01f, -3.42468428e-03f, 1.55226067e-01f, 1.34021074e-01f,
  -7.09250644e-02f, 5.10328338e-02f, -1.21746525e-01f, 1.99396476e-01f, -1.67166218e-02f, -6.17469475e-03f, -2.47711223e-02f, 4.73390408e-02f, 5.69723547e-02f, -2.91200280e-01f,
  4.16873470e-02f, -7.68282916e-04f, -1.55979916e-01f, 1.88470796e-01f, -2.14476556e-01f, 7.97610506e-02f, -2.54426390e-01f, -4.55942824e-02f, 2.77247429e-01f, 2.47746602e-01f,
  -5.40571153e-01f, 3.36654857e-02f, -1.10046089e-01f, -2.72972174e-02f, 1.57030836e-01f, 5.29589429e-02f, -2.29998445e-03f, 1.72044128e-01f, 1.74668408e-03f, 3.79702039e-02f,
  -4.37173396e-02f, 6.88795447e-02f, 7.47816265e-02f, 9.76353064e-02f, 5.42815216e-02f, 1.44801974e-01f, -1.40912026e-01f, -1.58152103e-01f, -1.72026142e-01f, 7.77622834e-02f,
  -1.57499194e-01f, -3.36341672e-02f, 2.90299386e-01f, -1.18363880e-01f, -5.52128181e-02f, -6.67576566e-02f, -1.49829462e-01f, 7.31208622e-02f, 3.99453044e-02f, -1.59871340e-01f,
  -2.28927508e-02f, 7.76781747e-03f, 1.49601683e-01f, 4.20156393e-05f, -4.39968705e-02f, -4.40822154e-01f, 1.23097224e-03f, -3.18550736e-01f, 1.14316553e-01f, -1.21657759e-01f,
  9.81384609e-03f, -1.47474825e-01f, 2.47027785e-01f, 5.71360104e-02f, 7.39179924e-02f, 2.92051118e-02f, 1.26028523e-01f, 2.47923613e-01f, 1.40059769e-01f, 1.40391603e-01f,
  7.64949247e-02f, -4.58470434e-02f, 7.68409744e-02f, -1.39046550e-01f, 1.73463091e-01f, 1.99324310e-01f, 2.30274536e-02f, 9.28687602e-02f, 4.60749157e-02f, -7.11301491e-02f,
  -2.32915461e-01f, 1.10051155e-01f, -9.60813090e-02f, -2.54399329e-01f, 1.29814759e-01f, 2.69332469e-01f, -9.23675895e-02f, 2.57482201e-01f, -1.67106122e-01f, 2.07181826e-01f,
  -5.40994145e-02f, 7.52201825e-02f, 8.79067406e-02f, 8.16667005e-02f, 1.09577917e-01f, -1.44584104e-02f, 8.86095613e-02f, -1.90667346e-01f, -1.55973554e-01f, -8.59172940e-02f,
  1.34087250e-01f, -1.49368376e-01f, 9.64973643e-02f, -3.46183665e-02f, 1.40962243e-01f, -4.40547206e-02f, -9.06741396e-02f, -2.23283023e-02f, 5.22536784e-02f, -2.15347320e-01f,
  1.63195416e-01f, -1.14611648e-01f, -3.51653583e-02f, 8.11149105e-02f, 4.88452874e-02f, 1.18490376e-01f, -2.09971249e-01f, -7.49031380e-02f, 2.79051036e-01f, 3.68999004e-01f,
  -1.00409798e-01f, -5.19365370e-02f, -2.57838994e-01f, 2.64119767e-02f, 1.01152202e-02f, 1.35855690e-01f, -9.03432369e-02f, -3.40918191e-02f, 8.37564170e-02f, -2.40126371e-01f,
  2.54167467e-01f, 4.35262620e-02f, 2.10207459e-02f, -1.35490149e-01f, 4.99879122e-02f, 1.40534252e-01f, 9.92976502e-02f, 2.38014787e-01f, -3.36881131e-02f, 6.37117326e-02f,
  -9.93283466e-02f, -1.69016540e-01f, 3.29451978e-01f, -6.35755137e-02f, -1.49286881e-01f, 2.20236108e-01f, -1.10008322e-01f, 2.61144251e-01f, 1.95292179e-02f, 2.05002084e-01f,
  1.53416172e-01f, -1.79060668e-01f, -6.56987131e-02f, -1.25702217e-01f, 9.10478085e-02f, 4.02098596e-02f, 1.04246736e-01f, 8.03961903e-02f, 1.25935122e-01f, 1.55993506e-01f,
  3.24111735e-03f, -1.90730784e-02f, 1.66164964e-01f, 3.53483483e-02f, -1.14611700e-01f, 1.48878381e-01f, 1.28881201e-01f, 3.42303813e-01f, 1.78363908e-03f, 2.35383779e-01f,
  2.61699289e-01f, 7.57298619e-02f, 1.24039963e-01f, -2.26987619e-02f, 2.08422944e-01f, 7.53056332e-02f, 7.52346516e-02f, 1.23453520e-01f, -2.29225889e-01f, -2.46446997e-01f,
  -2.66909659e-01f, -1.36308476e-01f, 4.04607020e-02f, 5.05187362e-02f, -5.83982579e-02f, 1.70047641e-01f, -4.95487042e-02f, 7.14463517e-02f, -2.15984434e-02f, -1.49123162e-01f,
  5.91921201e-03f, 3.71367671e-02f, 2.10813563e-02f, -1.43845128e-02f, -3.87291871e-02f, 9.94508266e-02f, 2.06505314e-01f, -9.05972570e-02f, -4.66799773e-02f, 7.13006854e-02f,
  1.21846152e-02f, -3.37747455e-01f, -2.79487371e-02f, 5.80069385e-02f, -1.24766797e-01f, 1.11027583e-01f, -2.08051443e-01f, -6.60869479e-02f, -2.74991766e-02f, -2.09221736e-01f,
  -4.89766663e-03f, -2.08455712e-01f, -6.50441647e-02f, 1.16740957e-01f, 2.26281449e-01f, 1.73453897e-01f, 1.30994290e-01f, 1.12689570e-01f, 9.23418999e-02f, 4.57096137e-02f,
  -2.79266126e-02f, -1.92506254e-01f, -3.80178690e-02f, -2.33848542e-01f, -2.08592445e-01f, 3.13839540e-02f, 1.90064907e-02f, -2.01607689e-01f, 3.96566465e-02f, 2.75915682e-01f,
  -1.02300175e-01f, -1.58016831e-01f, 1.94585919e-01f, 4.27743755e-02f, -7.41444081e-02f, -3.40883527e-03f, -9.19314772e-02f, -2.96965172e-03f, -1.26804382e-01f, -2.48680845e-01f,
  -1.71455115e-01f, -5.36130220e-02f, -2.72847209e-02f, -3.17133516e-02f, -1.74398005e-01f, 2.38292798e-01f, 6.31333366e-02f, 4.49973419e-02f, -2.56512128e-02f, -7.04888701e-02f,
  8.35580900e-02f, 1.42408177e-01f, 1.53515071e-01f, -1.45932540e-01f, -1.20984856e-02f, 9.30387080e-02f, 1.25776278e-02f, -1.11106984e-01f, 1.53651237e-01f, 5.37097193e-02f,
  1.00749649e-01f, 6.89194873e-02f, 1.11616395e-01f, -2.03073323e-01f, -3.35171409e-02f, 6.34651408e-02f, 5.87101690e-02f, 7.65692294e-02f, -2.12720744e-02f, -1.50269270e-01f,
  2.04415858e-01f, 9.35536996e-02f, 2.37768054e-01f, 2.34617516e-01f, 5.58270141e-02f, 3.10225755e-01f, 2.37846240e-01f, 7.44179040e-02f, -1.05455711e-01f, -1.15852237e-01f,
  7.52027258e-02f, 1.72886979e-02f, -1.23815704e-02f, -3.93416323e-02f, -1.70786362e-02f, 1.43877625e-01f, 2.36631811e-01f, 1.60955936e-02f, 1.17912903e-01f, 5.06945364e-02f,
  2.64431208e-01f, -8.45636129e-02f, -8.34655017e-03f, 4.41899411e-02f, 9.35910270e-02f, 3.93158086e-02f, 1.03099942e-01f, -7.87944272e-02f, 8.99838284e-02f, -4.31919284e-02f,
  1.31806340e-02f, 1.72376961e-01f, 1.48289099e-01f, -1.25739828e-01f, -4.02762294e-02f, 1.57715261e-01f, -4.19088528e-02f, -1.57470793e-01f, -3.93101275e-02f, 3.19868803e-01f,
  1.03636086e-01f, 2.45114580e-01f, 3.66239816e-01f, -4.97940630e-02f, 2.18369573e-01f, -1.82423368e-01f, 1.76617458e-01f, 1.48999423e-01f, 5.58652356e-02f, -3.13330203e-01f,
  2.21040905e-01f, -1.15542114e-01f, -1.30477965e-01f, -1.68206096e-01f, 2.67251462e-01f, 5.00226347e-03f, -7.70262182e-02f, 6.83632419e-02f, 2.89535731e-01f, -8.68157744e-02f,
  -5.13820909e-04f, -1.53092425e-02f, 2.25928705e-03f, 1.81634218e-01f, -9.26026925e-02f, -6.98025674e-02f, -1.78255990e-01f, -1.97862864e-01f, -7.69293308e-02f, 2.36282155e-01f,
  3.12750310e-01f, 1.80471063e-01f, 1.24423280e-02f, -2.24576339e-01f, 9.41312164e-02f, -2.68720478e-01f, -1.93322882e-01f, 2.69577593e-01f, 7.26301372e-02f, 1.30875468e-01f,
  2.78260037e-02f, -2.84510273e-02f, -7.31165111e-02f, -8.06918554e-03f, -4.86090034e-02f, 1.74917340e-01f, -8.98624957e-02f, 7.33964657e-03f, 5.11110686e-02f, -3.28100845e-02f,
  5.15541174e-02f, 3.43348943e-02f, -1.09926835e-01f, 1.83260113e-01f, -3.07836775e-02f, -9.15073156e-02f, -7.27234334e-02f, -1.46844849e-01f, -2.17354223e-01f, -8.34171474e-03f,
  1.94714684e-02f, 1.65450916e-01f, 2.13206738e-01f, -3.37300897e-02f, 3.53344642e-02f, 1.86078981e-01f, -1.00616038e-01f, -7.05012456e-02f, -2.06642479e-01f, 1.27345352e-02f,
  -4.43392061e-02f, -6.16277903e-02f, 1.09370790e-01f, -1.97868049e-01f, -6.15302138e-02f, -1.26163796e-01f, 1.00981228e-01f, 1.63963139e-01f, 4.80925478e-02f, 3.45067143e-01f,
  9.19549987e-02f, 1.42911568e-01f, 9.51549113e-02f, -2.02920496e-01f, 4.92145307e-02f, -1.72980934e-01f, 3.28134522e-02f, -1.24346409e-02f, 7.13227242e-02f, -8.83384794e-03f,
  -2.14400113e-01f, 3.91307235e-01f, 2.29884371e-01f, 2.32331932e-01f, 1.26436546e-01f, -5.18045090e-02f, -4.10481580e-02f, -1.90514818e-01f, 8.01888406e-02f, -2.33289763e-01f,
  -2.10861117e-01f, -5.93702085e-02f, 8.90193507e-04f, 5.50821312e-02f, 1.22380316e-01f, 4.82464403e-01f, -3.88699062e-02f, -4.08011712e-02f, 2.22333744e-01f, 2.31391102e-01f,
  -7.73428679e-02f, -3.01155150e-01f, -1.86292812e-01f, -1.15598142e-01f, 4.86031361e-02f, -7.57998377e-02f, -4.75398526e-02f, 2.80414708e-02f, -2.30212379e-02f, -5.99410385e-04f,
  -7.24679902e-02f, -6.32412881e-02f, -4.22111377e-02f, -5.90543486e-02f, -1.23847961e-01f, 3.93284932e-02f, 9.67994519e-03f, 4.46798578e-02f, 1.36625068e-02f, -3.09674710e-01f,
  -7.79523030e-02f, 7.94618949e-02f, -3.58256362e-02f, -1.33011863e-01f, -1.45892903e-01f, -9.12741721e-02f, 2.01966658e-01f, 8.09210464e-02f, 4.58785854e-02f, 7.12111220e-02f,
  1.64258659e-01f, 6.34577423e-02f, 1.34661971e-02f, 2.57208049e-01f, 5.77790253e-02f, -1.50938272e-01f, -3.60014774e-02f, 5.41851744e-02f, 2.67968476e-01f, 9.47357491e-02f,
  4.98551652e-02f, -6.10213615e-02f, -5.62533997e-02f, 1.09703634e-02f, -1.79003773e-03f, -7.03988876e-03f, 7.45777190e-02f, -1.14483990e-01f, -3.91653836e-01f, -1.84465963e-02f,
  -2.57899314e-01f, 4.23186012e-02f, -7.42172822e-02f, 8.09291750e-03f, 1.32220343e-01f, 2.83486154e-02f, -4.02799785e-01f, 2.18185857e-02f, -2.80404359e-01f, 8.47325474e-03f,
  -1.04849644e-01f, 7.31363818e-02f, -1.20647453e-01f, -4.01594676e-02f, 3.24472003e-02f, -2.05898672e-01f, -5.63073121e-02f, 1.89197719e-01f, 2.19006240e-01f, -5.73480539e-02f,
  7.31066167e-02f, -1.68636860e-03f, 1.94838434e-01f, 9.83985141e-02f, 1.26173139e-01f, 3.06308895e-01f, 3.66587862e-02f, 2.62828887e-01f, -5.83979003e-02f, -5.64370118e-02f,
  -2.42274016e-01f, 2.01586634e-01f, 1.55594826e-01f, 8.05760399e-02f, 2.00445116e-01f, -1.42450333e-01f, 9.43662673e-02f, -1.96470972e-02f, -8.07340145e-02f, 1.30933747e-01f,
  -1.14881411e-01f, 1.57924011e-01f, 1.20796762e-01f, 4.48337756e-02f, -7.14514330e-02f, 1.33837670e-01f, 1.97799563e-01f, -2.20303595e-01f, 6.55541196e-02f, 4.72216047e-02f,
  9.81660560e-02f, -1.03179023e-01f, -1.88553825e-01f, -2.45447025e-01f, 7.34157562e-02f, 1.43255398e-01f, -1.69192821e-01f, 1.15282074e-01f, 1.52759567e-01f, -3.54504973e-01f,
  4.76240600e-03f, 2.67545670e-01f, -1.32061183e-01f, -2.66269296e-01f, 1.37282953e-01f, 1.69510111e-01f, 2.25597605e-01f, 3.65580171e-02f, -1.35380879e-01f, 2.17830613e-01f,
  1.98117182e-01f, 1.86170917e-02f, 7.51627237e-03f, -2.48506546e-01f, 5.18496074e-02f, 1.18183009e-01f, -2.10025907e-02f, 1.54830876e-03f, -1.54394329e-01f, 1.54234499e-01f,
  -1.46660833e-02f, 8.29412267e-02f, 6.49315566e-02f, -8.32520574e-02f, 6.48852764e-03f, -6.68094978e-02f, 2.98840664e-02f, 1.62821993e-01f, 6.72420859e-02f, 1.56971067e-01f,
  -2.00840756e-01f, -7.20359609e-02f, -8.45281631e-02f, 3.11929602e-02f, -1.72975585e-01f, 9.75064114e-02f, -3.78254615e-02f, -1.19715258e-01f, -1.05288461e-01f, -1.45763746e-02f,
  3.45552683e-01f, 1.86409503e-01f, -2.05158025e-01f, -4.52041887e-02f, 3.18246521e-02f, 2.47277200e-01f, 9.36899707e-02f, 7.54634291e-02f, 1.51486203e-01f, 1.81971282e-01f,
  -3.70387249e-02f, -2.13081017e-01f, 1.94681421e-01f, -1.51115311e-02f, -2.41136745e-01f, 1.18363671e-01f, 2.43666708e-01f, 7.97224790e-02f, -6.67642280e-02f, 1.21175706e-01f,
  -2.02329978e-01f, 6.80272952e-02f, 3.60786200e-01f, -1.56662494e-01f, -4.12724055e-02f, 1.89719796e-01f, -1.82423785e-01f, -1.66939124e-02f, -7.50815198e-02f, 3.32205780e-02f,
  2.98099089e-02f, 2.97919512e-01f, 2.75945008e-01f, -5.62123768e-02f, -2.30986819e-01f, 2.39443555e-02f, 1.81623995e-01f, -2.34293684e-01f, 2.90115289e-02f, 1.56467125e-01f,
  7.10758567e-02f, 2.39528846e-02f, 5.53718768e-02f, 3.34685966e-02f, -1.13446437e-01f, -2.56324083e-01f, 1.24025390e-01f, -1.49353012e-01f, -1.86425999e-01f, -6.21731542e-02f,
  -1.16702065e-01f, 2.00802609e-02f, -4.77766283e-02f, -2.38328539e-02f, -7.98609257e-02f, -1.83927710e-03f, 1.39201060e-01f, 7.60469958e-02f, 8.59180093e-02f, -2.58577093e-02f,
  2.14307562e-01f, 2.43916884e-01f, 2.04571530e-01f, -2.88783878e-01f, 1.95610374e-02f, -8.20098519e-02f, 4.94665168e-02f, 3.18917692e-01f, -1.06527671e-01f, -2.15653017e-01f,
  -3.28266919e-02f, -2.38518625e-01f, -2.48456979e-03f, 1.45086758e-02f, 3.77974659e-03f, 1.22465281e-04f, 1.62668109e-01f, 1.76699206e-01f, 1.32029757e-01f, 8.75474289e-02f,
  -5.38643971e-02f, -2.65606195e-01f, 1.49544701e-01f, -7.18565062e-02f, 3.46083492e-01f, 7.23983273e-02f, -4.78954427e-02f, 2.44657084e-01f, 1.60966814e-01f, 3.42040747e-01f,
  2.76365713e-03f, -1.24957211e-01f, 1.69210136e-01f, -1.60317019e-01f, 2.35380411e-01f, -1.87627405e-01f, -9.75694358e-02f, -1.34920672e-01f, 2.32868820e-01f, 1.11014217e-01f,
  3.82997006e-01f, 6.66579604e-02f, -4.29369844e-02f, 1.64435610e-01f, 2.08354041e-01f, 2.30984285e-01f, 4.12531346e-02f, 9.41767618e-02f, -6.93710297e-02f, -9.91397202e-02f,
  1.35246336e-01f, -1.74915586e-02f, 7.58730527e-03f, -5.23825269e-03f, -2.15401962e-01f, 1.10211208e-01f, -8.52833912e-02f, -4.20627259e-02f, -1.14389770e-01f, -8.55353773e-02f,
  2.23766029e-01f, 1.62233901e-03f, -3.67550179e-02f, 2.84195542e-01f, -1.04605369e-01f, 1.47698045e-01f, 2.02017382e-01f, -3.93623978e-01f, 3.87031436e-01f, -1.17770143e-01f,
  -8.40020925e-02f, 6.70115352e-02f, -2.99237184e-02f, -7.98671544e-02f, -8.87650624e-03f, 8.83245096e-02f, -3.72766793e-01f, -3.26532751e-01f, 8.70894492e-02f, 7.15846047e-02f,
  9.82256979e-02f, -1.34742245e-01f, 7.49869645e-02f, 1.21697344e-01f, -2.09494203e-01f, -5.02718575e-02f, 2.39537209e-01f, -7.48302042e-02f, 3.99967209e-02f, 1.89477578e-01f,
  -2.50871062e-01f, 9.05636773e-02f, 1.49076611e-01f, 1.29216224e-01f, 1.78155258e-01f, -2.23245800e-01f, -1.42642539e-02f, -4.47240584e-02f, 1.10873289e-01f, 5.87658808e-02f,
  -8.19134247e-03f, 6.88008219e-02f, 1.69179309e-02f, 2.13232353e-01f, 1.87776119e-01f, 1.57846838e-01f, -1.71113059e-01f, 1.34827733e-01f, -1.63202867e-01f, 6.92903176e-02f,
  9.37305167e-02f, -2.21204862e-01f, 2.04873115e-01f, -1.33279875e-01f, -3.91994454e-02f, 1.72391281e-01f, 3.87737229e-02f, 1.87882051e-01f, -1.37919828e-01f, 3.88548411e-02f,
  1.71056062e-01f, -1.41136870e-01f, 1.47282615e-01f, -7.23273158e-02f, -2.55711585e-01f, 9.85163972e-02f, 7.13406876e-02f, 1.05678797e-01f, -1.80034384e-01f, 9.81239155e-02f,
  -1.11359335e-01f, 1.69007361e-01f, -2.02254757e-01f, -2.90042665e-02f, 5.26645668e-02f, -1.00361146e-01f, 1.62640795e-01f, 1.18273132e-01f, -2.37334579e-01f, 1.24476761e-01f,
  1.37238726e-01f, 9.25229341e-02f, -7.45375603e-02f, 3.03257018e-01f, 3.77974063e-02f, 7.30065182e-02f, 1.74758300e-01f, -1.73914552e-01f, -5.64822219e-02f, -1.44072741e-01f,
  1.56446621e-01f, 5.24956826e-03f, 5.80805913e-02f, 1.01259381e-01f, -8.11369866e-02f, 2.48488083e-01f, 4.12414372e-01f, -2.87183583e-01f, 3.76401544e-02f, -2.65655100e-01f,
  5.89901507e-02f, 2.06296533e-01f, -3.26706283e-02f, -2.70783864e-02f, -2.06764132e-01f, 2.17682481e-01f, -3.95243540e-02f, -3.49843726e-02f, -2.04706807e-02f, 3.62411469e-01f,
  -7.57971033e-02f, 1.37718618e-01f, -1.24845289e-01f, 2.14701891e-01f, -1.02899782e-01f, -7.43434653e-02f, 1.98618039e-01f, 6.05874471e-02f, 9.63614807e-02f, 3.65721971e-01f,
  -3.89029644e-02f, -6.36741742e-02f, 1.48505598e-01f, 9.28798169e-02f, 2.38705203e-01f, -2.68571021e-04f, -9.19595361e-02f, 9.81369391e-02f, -4.16847207e-02f, 8.55019018e-02f,
  -7.07594752e-02f, -1.90724954e-01f, 2.29562938e-01f, 3.17247331e-01f, -1.95861846e-01f, 1.04702979e-01f, -9.70353335e-02f, 3.29914689e-02f, 3.33405435e-02f, -2.44459957e-02f,
  -1.34567112e-01f, 2.80506201e-02f, 5.56991212e-02f, 7.14319199e-03f, 2.99003184e-01f, 1.34621292e-01f, 9.02554467e-02f, -2.79147744e-01f, 6.65796027e-02f, 1.20469615e-01f,
  -1.26260638e-01f, 1.61579862e-01f, -2.29518991e-02f, 1.14995800e-02f, 2.91087404e-02f, -1.46002799e-01f, 2.01443449e-01f, 1.53925702e-01f, 2.39358172e-01f, -2.34206822e-02f,
  2.33874992e-02f, 2.21004441e-01f, -2.27931514e-01f, 3.89936939e-02f, 2.72321433e-01f, 2.17901602e-01f, 1.51983174e-02f, 9.89611968e-02f, -3.64753827e-02f, -1.65926248e-01f,
  1.09184787e-01f, -2.85588838e-02f, 5.45911714e-02f, 3.63109522e-02f, -4.63611074e-02f, 2.63149828e-01f, 3.55111867e-01f, 5.40174404e-03f, -2.83158123e-02f, 2.79260576e-01f,
  -1.30463213e-01f, 2.02512965e-01f, 1.15548536e-01f, 1.22556323e-02f, 4.27741557e-02f, 1.23671805e-02f, 2.39185736e-01f, -1.28079936e-01f, 1.35693610e-01f, 1.16699174e-01f,
  9.19294804e-02f, 3.41048166e-02f, -7.56325200e-02f, 1.60590515e-01f, -6.82656169e-02f, -3.35656852e-01f, 6.72831014e-02f, 3.74666378e-02f, -7.36170867e-03f, 7.06292177e-03f,
  3.41672190e-02f, 4.41152090e-03f, -1.23282699e-02f, 1.20724058e-02f, -7.68874660e-02f, -9.37443674e-02f, 3.23405862e-01f, -1.03898987e-01f, 2.83320695e-02f, 1.81892484e-01f,
  2.14887977e-01f, -1.00412942e-01f, -1.45440951e-01f, 1.75136179e-01f, 5.12751825e-02f, 3.71116097e-04f, 1.45223394e-01f, 2.23642424e-01f, -1.53643578e-01f, 1.22092582e-01f,
  -2.17518002e-01f, -4.38971370e-01f, -2.72598088e-01f, -5.93195148e-02f, -9.75909531e-02f, 2.20811769e-01f, -1.47614390e-01f, 3.32462341e-01f, -8.86778235e-02f, 2.98939198e-02f,
  -6.97431490e-02f, -3.48578431e-02f, 4.71751094e-02f, 7.26080537e-02f, -8.41995329e-02f, -5.82596473e-02f, -7.97122419e-02f, -2.50769973e-01f, 6.64640963e-02f, -1.38106883e-01f,
  -3.56670655e-02f, -5.97472824e-02f, 9.45040733e-02f, 2.21170813e-01f, 1.67391464e-01f, 2.26085037e-02f, 6.33409992e-02f, 1.05861202e-01f, -9.30399001e-02f, -9.12787244e-02f,
  5.56259463e-03f, 1.23575136e-01f, 3.38622625e-03f, 1.12257391e-01f, -3.79665494e-02f, 4.94213589e-02f, 2.75882687e-02f, 4.20937967e-03f, -2.05166146e-01f, -2.48265360e-02f,
  -9.31234285e-02f, 1.00439542e-03f, 1.66653663e-01f, 1.57829404e-01f, 1.44383252e-01f, 5.64832427e-03f, -6.35402501e-02f, -8.99998322e-02f, 1.67507738e-01f, 1.36325210e-01f,
  -9.57686827e-03f, 2.19682772e-02f, 1.60576060e-01f, -6.70546517e-02f, 6.96062744e-02f, 8.00726935e-03f, 2.46472940e-01f, -4.95084450e-02f, 2.05982491e-01f, -3.72626819e-03f,
  9.98111665e-02f, 2.24968344e-01f, 1.90730214e-01f, 9.80720371e-02f, 1.10700250e-01f, -1.21026695e-01f, 9.59091708e-02f, 4.69711348e-02f, -6.86637163e-02f, -6.06146827e-02f,
  2.72563279e-01f, 8.82197618e-02f, 3.08831446e-02f, 6.23785630e-02f, -1.12103738e-01f, 1.39589265e-01f, 1.29042670e-01f, 4.75024506e-02f, 1.21933557e-01f, 1.06596507e-01f,
  1.52798042e-01f, -1.74880609e-01f, -9.57410187e-02f, -5.18549457e-02f, -1.49145931e-01f, -1.12697862e-01f, 3.23269576e-01f, 2.43951321e-01f, 4.04115254e-03f, 1.53273702e-01f,
  -7.83000258e-04f, -1.10829649e-02f, 1.65805355e-01f, 2.61158496e-01f, 9.60170701e-02f, 3.59312408e-02f, -9.27529112e-02f, 1.86637521e-01f, -3.39870453e-02f, -3.68858576e-02f,
  -2.41345331e-01f, -4.07771356e-02f, -4.56346124e-02f, -1.73873812e-01f, 1.62463948e-01f, -7.29299858e-02f, -3.78070623e-02f, -1.97296008e-01f, 2.28084892e-01f, -1.90777898e-01f,
  3.29810306e-02f, -1.22549027e-01f, 1.25088274e-01f, 1.33523569e-02f, 3.04005176e-01f, -8.17891136e-02f, 5.69710545e-02f, 1.56909421e-01f, 1.54311642e-01f, 1.48676217e-01f,
  -1.46851316e-01f, 3.25619988e-02f, 2.43240193e-01f, -1.98210835e-01f, 4.62672673e-02f, 9.37003344e-02f, -1.79491907e-01f, 8.87174755e-02f, -3.46006364e-01f, -3.44197989e-01f,
  -1.37068614e-01f, -1.51130289e-01f, -1.35101497e-01f, 9.93312895e-02f, 4.72567640e-02f, 2.49927878e-01f, 2.69130450e-02f, -6.37000725e-02f, 3.21191736e-03f, -1.28025562e-01f,
  -1.28052399e-01f, 2.98421025e-01f, -1.47351027e-01f, -1.88962054e-02f, -7.32160807e-02f, -9.81040224e-02f, 1.53762057e-01f, -1.48708686e-01f, 1.72791958e-01f, 1.51728705e-01f,
  -9.76324268e-03f, 1.60884827e-01f, -4.23501655e-02f, -1.46304399e-01f, 2.86107957e-01f, -1.56394839e-01f, -1.52324602e-01f, -5.13607748e-02f, 1.12523749e-01f, -5.67090511e-02f,
  2.00437963e-01f, -1.70842648e-01f, 7.28781372e-02f, 7.66466856e-02f, -2.05969028e-02f, 3.96993399e-01f, 1.00548916e-01f, -1.50197789e-01f, 2.41830379e-01f, 2.94696271e-01f,
  -8.29411484e-03f, 8.34846050e-02f, -2.43312255e-01f, -2.57682234e-01f, 7.81103373e-02f, 8.34171718e-04f, -4.58154827e-02f, -1.04698665e-01f, 7.58635029e-02f, -8.93682614e-02f,
  1.45686552e-01f, 2.08971292e-01f, -5.72036728e-02f, 1.37091830e-01f, 1.22546591e-02f, 6.76319823e-02f, 1.36828750e-01f, 1.28956661e-01f, 8.59856233e-02f, -7.57461088e-03f,
  2.01425442e-04f, 6.72037387e-03f, 7.59830698e-02f, -5.21651059e-02f, -1.80184826e-01f, 8.98542553e-02f, -1.04851425e-01f, 3.54733706e-01f, -2.76820809e-01f, -3.12426817e-02f,
  1.70716733e-01f, -1.50867626e-01f, -4.15799627e-03f, -2.00206056e-01f, -2.45160371e-01f, -1.49066783e-02f, 2.64721587e-02f, 4.73589003e-02f, 4.82511669e-02f, 4.56848107e-02f,
  -1.87194675e-01f, -8.49406421e-02f, 1.35756925e-01f, 1.96019456e-01f, -5.26112877e-02f, 1.65562242e-01f, 1.21762119e-01f, 2.35680923e-01f, -3.90596986e-02f, -4.47452292e-02f,
  2.09126204e-01f, -2.76891679e-01f, -4.19604778e-02f, 9.62354019e-02f, 3.56801152e-02f, 1.17534555e-01f, 4.83421236e-02f, -2.45418381e-02f, -4.39674705e-02f, -1.51600271e-01f,
  -1.62174538e-01f, 1.13403656e-01f, -1.22343495e-01f, -3.49380285e-01f, 4.72284630e-02f, -1.35824308e-01f, 3.33067268e-01f, -6.25102669e-02f, -1.38385266e-01f, -1.96135491e-01f,
  8.22641402e-02f, 1.41698077e-01f, 1.09791070e-01f, 3.11446846e-01f, -8.42984393e-02f, 2.32085600e-01f, -3.01611070e-02f, 1.51190221e-01f, 3.58427823e-01f, -1.89307749e-01f,
  -7.45019317e-02f, -1.16985023e-01f, 2.10648194e-01f, 1.09833233e-01f, 2.49508396e-01f, 3.51733230e-02f, 1.64224654e-01f, 8.53577182e-02f, 6.22683987e-02f, -3.11264843e-02f,
  -6.07305020e-02f, 7.03151748e-02f, 3.19834113e-01f, -2.37830952e-02f, -3.03906612e-02f, 3.53378057e-01f, 1.21119944e-02f, 2.94881016e-01f, 1.49290740e-01f, 1.07111014e-01f,
  1.29897118e-01f, 1.42017648e-01f, 2.47017685e-02f, -5.96997002e-03f, -9.85656604e-02f, 3.01029906e-03f, -2.23410837e-02f, -2.68350273e-01f, 2.67027348e-01f, 3.98811847e-02f,
  1.99938700e-01f, 3.24211091e-01f, -4.01776582e-02f, 4.49565291e-01f, 3.78521383e-01f, 4.71908376e-02f, 6.31677061e-02f, 1.22565962e-01f, -6.11580722e-02f, 1.17593504e-01f,
  1.73544362e-01f, 9.13867354e-02f, -2.94128526e-02f, -6.43436462e-02f, -2.21770987e-01f, 1.43325515e-02f, 1.66652203e-01f, 1.66001335e-01f, -6.91719726e-02f, 2.58333117e-01f,
  5.77951707e-02f, 2.05518574e-01f, -1.36400729e-01f, 9.20215622e-02f, -1.98310047e-01f, 1.00180142e-01f, -6.13870611e-03f, -4.83277962e-02f, -3.97379883e-02f, -2.24774666e-02f,
  1.19607076e-01f, -3.51600088e-02f, 8.35746601e-02f, 3.66766118e-02f, 5.69426380e-02f, -6.35813624e-02f, -9.21037421e-02f, 5.41884676e-02f, -4.37034033e-02f, -3.37552838e-03f,
  1.65496215e-01f, 2.71901548e-01f, 1.55293614e-01f, -5.90776727e-02f, -5.64148137e-03f, -8.88378918e-02f, 1.67434454e-01f, 1.85041260e-02f, 2.23360196e-01f, 2.04842985e-01f,
  -6.70000240e-02f, 2.03867853e-01f, -1.62828729e-01f, 8.07823315e-02f, 2.28852808e-01f, -2.38786656e-02f, 3.57152196e-03f, -1.32648736e-01f, -8.22511688e-02f, 7.39824434e-04f,
  9.08566341e-02f, -1.61978230e-01f, 1.47411808e-01f, 1.91778377e-01f, 1.99195638e-01f, 1.32635549e-01f, -2.44163937e-04f, -1.27527341e-01f, -8.33147243e-02f, -3.69126081e-01f,
  -4.99499962e-02f, 2.17810333e-01f, 1.98044613e-01f, 2.62334585e-01f, 1.16263375e-01f, 7.64074475e-02f, 1.33952573e-01f, -6.11316785e-02f, -1.06155880e-01f, 2.46443767e-02f,
  -3.67385507e-01f, -1.81393117e-01f, 2.02527970e-01f, 8.64072964e-02f, 1.57485023e-01f, 4.97179739e-02f, -2.90575325e-01f, 3.46001312e-02f, 9.46267918e-02f, 3.46604139e-01f,
  -1.73484594e-01f, 3.09159905e-01f, -2.75511742e-02f, 2.30263233e-01f, -1.41281992e-01f, -1.72524638e-02f, 2.94391721e-01f, -4.94850315e-02f, 2.00807862e-02f, 1.72770858e-01f,
  4.48743030e-02f, 1.00390933e-01f, 2.65435100e-01f, 7.32661262e-02f, 7.81827327e-03f, 7.51236528e-02f, 2.90564507e-01f, -1.19893275e-01f, -3.33652608e-02f, 5.31916879e-02f,
  -2.00088710e-01f, -8.27933028e-02f, -1.02185793e-01f, 2.37968177e-01f, -8.09587911e-02f, 2.40067512e-01f, 2.35253036e-01f, -4.72012348e-02f, -6.13854229e-02f, 1.79775313e-01f,
  -1.38863638e-01f, 6.29978254e-02f, -1.84801444e-02f, 1.53410524e-01f, -1.47342324e-01f, -7.61100724e-02f, 3.56626749e-01f, 2.52096355e-02f, -2.76582073e-02f, -2.90162805e-02f,
  3.64956371e-02f, 1.99021563e-01f, 9.80647877e-02f, 6.93096668e-02f, 1.61453038e-01f, 1.18155718e-01f, 2.08091125e-01f, -3.18335928e-02f, 2.43331701e-01f, -1.29333241e-02f,
  -2.69530147e-01f, -1.47017270e-01f, -1.23841323e-01f, 5.62422574e-02f, 7.34976903e-02f, 1.89057514e-02f, -1.58654377e-01f, 1.43006518e-01f, 2.65042670e-02f, -4.99747135e-02f,
  -5.26334010e-02f, 2.11392760e-01f, -3.05466384e-01f, -2.11744569e-02f, -7.00396448e-02f, -9.71499272e-03f, -2.80235969e-02f, -1.48076713e-01f, 1.68748856e-01f, -2.34667182e-01f,
  -7.48083275e-03f, 1.04301639e-01f, 7.28585869e-02f, -6.45206720e-02f, -2.22001284e-01f, -1.44450724e-01f, -1.03105687e-01f, 1.29383698e-01f, -1.65927872e-01f, 1.86878145e-01f,
  1.11219458e-01f, 5.60594760e-02f, 3.11652452e-01f, -9.34356153e-02f, -2.57198691e-01f, -2.30280876e-01f, 2.95705110e-01f, 9.42739025e-02f, 2.64703333e-01f, -4.89282422e-02f,
  -9.05797780e-02f, 7.18035921e-02f, 9.16394591e-03f, -3.33567321e-01f, -5.09057380e-02f, 1.22649729e-01f, -8.44363198e-02f, 2.67294198e-01f, -1.29566230e-02f, 1.15769096e-01f,
  -2.41772354e-01f, 2.30688244e-01f, -8.04369226e-02f, 2.02538460e-01f, 2.84641415e-01f, -7.29627833e-02f, -1.23992711e-01f, 9.92953628e-02f, 1.89227626e-01f, 7.49275759e-02f,
  4.30626748e-03f, 4.63689677e-02f, 4.90854643e-02f, 1.04025774e-01f, -7.10321665e-02f, 1.17662057e-01f, 5.53879477e-02f, -2.15654194e-01f, 4.89071831e-02f, -8.19793269e-02f,
  1.57197192e-02f, -2.00328603e-01f, -2.51976162e-01f, -2.82488257e-01f, -1.09661520e-01f, -6.19455464e-02f, 2.03372296e-02f, -3.45610231e-02f, 1.52806640e-01f, 7.13646561e-02f,
  1.25013500e-01f, 1.57258302e-01f, -4.25755344e-02f, 2.24201277e-01f, 7.76179656e-02f, 5.11274189e-02f, -3.54161151e-02f, -2.23105654e-01f, 1.44850433e-01f, -7.69891217e-02f,
  -7.76258484e-02f, -8.44452381e-02f, -1.50385678e-01f, 5.23476042e-02f, -3.49240899e-01f, 8.07435736e-02f, 1.63753033e-01f, 2.43662968e-01f, -1.69194564e-01f, 1.92072660e-01f,
  -1.74473777e-01f, -1.89774726e-02f, -1.03120983e-01f, -2.23032400e-01f, -2.77724028e-01f, -7.02265874e-02f, -1.97749689e-01f, 5.26575372e-02f, -2.78517246e-01f, 2.53036231e-01f,
  -1.68545589e-01f, 3.11177932e-02f, 6.60236552e-02f, -8.54197219e-02f, -1.31226301e-01f, -1.14149339e-01f, -9.97851342e-02f, -5.40285170e-01f, 8.65938216e-02f, -1.72863901e-01f,
  -1.37127072e-01f, 1.31067131e-02f, -3.97110730e-01f, 6.21753000e-02f, 1.04116216e-01f, -2.65121073e-01f, -3.33009064e-01f, -2.38880560e-01f, 1.06255859e-01f, -9.96328145e-02f,
  2.03043758e-03f, 1.99716941e-01f, -1.55169189e-01f, -9.05154180e-03f, -6.69803694e-02f, 9.33799446e-02f, 7.08963349e-02f, 5.34776114e-02f, 1.76470846e-01f, -2.72808187e-02f,
  1.60195976e-01f, 7.03135431e-02f, -1.75815985e-01f, 2.56728791e-02f, -1.46457125e-02f, 7.77042061e-02f, -2.14630306e-01f, 9.58100408e-02f, 2.39887703e-02f, -4.73582000e-02f,
  -1.71776135e-02f, 3.69701982e-02f, 1.42103150e-01f, 1.23581290e-01f, 2.02743635e-01f, -1.27212316e-01f, 2.18399584e-01f, 7.76499957e-02f, 2.66817600e-01f, 2.16085643e-01f,
  -6.93488792e-02f, -9.56324413e-02f, 2.42524490e-01f, -1.46425426e-01f, -9.32417586e-02f, 9.63722691e-02f, -8.45145434e-02f, 2.51308121e-02f, 8.29004124e-02f, -1.48971006e-01f,
  -2.05098726e-02f, 2.94777472e-02f, 1.48965232e-02f, 2.01208174e-01f, 4.65043075e-02f, -7.98487216e-02f, -2.59466190e-02f, 1.60472125e-01f, 1.71538685e-02f, -1.78187594e-01f,
  -1.65348247e-01f, -1.53610423e-01f, 1.53217837e-01f, -2.57957608e-01f, -2.39741504e-01f, -8.40588585e-02f, 2.21414911e-03f, 5.84097095e-02f, 4.84312773e-02f, -2.25124210e-01f,
  -2.60070920e-01f, -3.58953737e-02f, -1.51334563e-02f, 2.69256860e-01f, -5.54202497e-02f, -7.96067491e-02f, -6.53040707e-02f, -2.50397567e-02f, -6.71209544e-02f, -2.60373920e-01f,
  2.85160355e-02f, -9.74180475e-02f, -8.01256225e-02f, -1.27638489e-01f, 1.20070502e-01f, 2.17159271e-01f, -1.95349604e-02f, 7.94748068e-02f, 2.06787735e-01f, 2.03873470e-01f,
  -1.15577996e-01f, 1.22900896e-01f, 1.67452335e-01f, -1.72403529e-01f, -6.44197613e-02f, 2.27487892e-01f, 2.68411152e-02f, 4.04169671e-02f, -4.56357002e-02f, -1.41123772e-01f,
  -3.63061465e-02f, -9.90582928e-02f, -2.15040017e-02f, -8.22973028e-02f, -1.17360368e-01f, 2.91269034e-01f, -9.16850939e-02f, 2.64692958e-02f, -6.75417483e-02f, -1.14109151e-01f,
  9.38334092e-02f, 3.91829126e-02f, 1.77477077e-01f, -1.86492339e-01f, -1.65149823e-01f, 2.81529427e-01f, -8.62172619e-02f, 1.45455346e-01f, -6.18861169e-02f, 3.71382870e-02f,
  2.25536928e-01f, 1.36503443e-01f, -1.99271739e-02f, 6.58229738e-03f, -7.86293019e-03f, 1.16913132e-01f, 8.12557042e-02f, -7.89839998e-02f, 1.36012360e-01f, 5.75951412e-02f,
  1.31647870e-01f, 1.19299777e-01f, 4.09647152e-02f, -3.91648933e-02f, 1.04737610e-01f, 1.22521915e-01f, -7.29017332e-02f, -2.68742573e-02f, 2.44114902e-02f, 2.50738621e-01f,
  -1.07111238e-01f, 1.22460365e-01f, 1.27208635e-01f, -1.67363454e-02f, -4.45354432e-02f, -1.55247435e-01f, 1.72812045e-01f, -4.41239774e-02f, 1.88020885e-01f, -9.34017589e-04f,
  1.23996474e-01f, -9.83840004e-02f, 1.90431327e-02f, 3.46919671e-02f, 1.42949209e-01f, 2.84571290e-01f, -6.22176640e-02f, 5.05631194e-02f, 2.39060983e-01f, -1.31755903e-01f,
  -5.35269715e-02f, -4.76790294e-02f, 1.67630762e-01f, -2.72405962e-03f, -7.61541426e-02f, -1.90911219e-01f, -2.06787720e-01f, 2.49471329e-02f, 1.15529709e-01f, -1.43177211e-01f,
  -3.50644663e-02f, -4.82054166e-02f, -7.26868436e-02f, -8.30814689e-02f, -1.57360405e-01f, -9.36372206e-02f, -7.33490512e-02f, 2.09607184e-01f, 4.74456474e-02f, -3.96091584e-03f,
  -6.64185062e-02f, 1.99141890e-01f, -2.91838855e-01f, -1.70638915e-02f, -1.44013017e-01f, 2.18673155e-01f, 1.15287803e-01f, -2.06656113e-01f, 1.42611235e-01f, 2.48788700e-01f,
  -1.06100157e-01f, 2.74105340e-01f, 2.02662647e-01f, 1.24223992e-01f, 2.06774741e-01f, -6.12770319e-02f, -1.02192536e-01f, 8.36370066e-02f, 2.17638284e-01f, 1.89023718e-01f,
  -1.64410412e-01f, -7.62866437e-02f, -1.01545632e-01f, -1.22170746e-01f, 3.15326289e-03f, 9.57460105e-02f, -2.63697982e-01f, 3.38460021e-02f, -9.23546255e-02f, -1.64199919e-01f,
  -8.36323202e-02f, -1.39163688e-01f, 8.48628581e-02f, -1.80077150e-01f, 4.05579172e-02f, 7.28787854e-02f, -1.21811759e-02f, 2.65952181e-02f, -6.30859705e-03f, 1.46252260e-01f,
  -5.54055944e-02f, 1.21934019e-01f, 1.37725562e-01f, -1.54710636e-01f, 1.68970585e-01f, 1.22729667e-01f, -3.48232947e-02f, 1.15185857e-01f, -3.62265408e-02f, -1.19313486e-01f,
  -8.62761810e-02f, -1.08815178e-01f, 1.18220173e-01f, -1.72269166e-01f, 7.36436844e-02f, 3.33117306e-01f, 1.24403521e-01f, 1.06648333e-01f, -3.09568018e-01f, 3.56032550e-02f,
  -7.90894777e-02f, 2.04925641e-01f, 4.29165084e-03f, 6.35273978e-02f, -1.76090792e-01f, -2.09041927e-02f, -7.96348006e-02f, -1.84290230e-01f, -6.32708743e-02f, -2.59664923e-01f,
  1.87295213e-01f, 6.98040128e-02f, -9.38434824e-02f, -4.83465903e-02f, -1.24237962e-01f, 1.11320138e-01f, 1.57767862e-01f, -1.43216308e-02f, 6.78125471e-02f, 5.48257716e-02f,
  -1.63520891e-02f, 4.92434427e-02f, -1.56400934e-01f, 1.62556060e-02f, -2.01739877e-01f, -1.08816072e-01f, -9.99192223e-02f, -1.28105516e-02f, 3.03483978e-02f, -3.21637660e-01f,
  -1.20876968e-01f, -1.36942625e-01f, 2.98606455e-01f, 2.84678135e-02f, 7.54193813e-02f, -4.83800704e-03f, 1.14698514e-01f, 1.72938127e-02f, 1.67217046e-01f, 1.92842677e-01f,
  -1.77639633e-01f, 1.62786067e-01f, 2.13393867e-02f, -3.86882685e-02f, 8.90415162e-02f, -2.65201807e-01f, 4.49530594e-02f, -6.58015087e-02f, 5.57455514e-03f, 2.68072635e-02f,
  -2.29624406e-01f, 4.65338342e-02f, -2.69808650e-01f, -1.78309739e-01f, -3.50094028e-02f, -1.75489694e-01f, -5.07385433e-02f, -1.39029518e-01f, 1.00385778e-01f, 2.17382506e-01f,
  -2.19988167e-01f, 2.40089923e-01f, -1.90285712e-01f, 1.91502571e-01f, 2.12699234e-01f, 1.37038618e-01f, -2.35806912e-01f, 1.28708318e-01f, -3.69708948e-02f, -9.38036069e-02f,
  1.28680259e-01f, -9.25639421e-02f, -5.61289079e-02f, 3.82123329e-02f, 1.62042111e-01f, 9.41099674e-02f, -1.39458403e-01f, 3.00195247e-01f, 1.25509962e-01f, 4.71420698e-02f,
  -2.47650445e-02f, 2.87221279e-02f, 2.33803973e-01f, -4.42515761e-02f, 1.01317696e-01f, 1.10792801e-01f, 5.87631539e-02f, 7.68909696e-03f, -3.45591120e-02f, 1.31484464e-01f,
  4.70031127e-02f, -2.31839061e-01f, 1.23848412e-02f, -2.86728293e-01f, -1.64480269e-01f, -1.46304160e-01f, -1.01140246e-01f, -5.84486686e-03f, -2.63734132e-01f, -3.16002995e-01f,
  8.96913335e-02f, -9.70144495e-02f, 6.48663417e-02f, 2.53964700e-02f, 1.16859205e-01f, 1.84221581e-01f, 1.48253843e-01f, 1.02561459e-01f, 4.50604782e-02f, 1.02230668e-01f,
  5.70267858e-03f, -2.79115111e-01f, 2.17990011e-01f, -3.25680934e-02f, -1.62504651e-02f, 1.07746802e-01f, -2.47144192e-01f, 1.41327064e-02f, -2.86996812e-01f, 4.83004935e-02f,
  1.00501314e-01f, -5.74417301e-02f, -3.15505832e-01f, 3.10449302e-01f, -2.82053053e-02f, 1.40089199e-01f, -4.30483483e-02f, -9.59998369e-02f, -1.23389125e-01f, 2.10373014e-01f,
  -1.91422731e-01f, -7.97308385e-02f, -2.53842831e-01f, 1.21192515e-01f, -1.85275152e-01f, -2.14060601e-02f, 1.52424881e-02f, -1.75050363e-01f, -6.27396405e-02f, 1.50859848e-01f,
  -1.09789662e-01f, -6.93409666e-02f, -1.27291843e-01f, -3.56318504e-02f, 1.12770870e-01f, 2.45028451e-01f, -7.07343742e-02f, -4.48506959e-02f, 8.85458514e-02f, 8.06907490e-02f,
  1.98798418e-01f, -2.44081076e-02f, -5.15872911e-02f, 1.23628579e-01f, 1.40606284e-01f, -5.66278324e-02f, 3.31227146e-02f, 1.41701505e-01f, -6.66331202e-02f, -1.95206806e-01f,
  1.02015920e-01f, -2.05388337e-01f, 6.34814948e-02f, 3.51555385e-02f, 1.36371739e-02f, -9.94044915e-02f, 1.34137049e-01f, 8.17445144e-02f, 9.15242638e-03f, 1.02763735e-02f,
  1.77542865e-01f, 1.46982506e-01f, -1.48846552e-01f, 7.52674639e-02f, 1.66410193e-01f, -1.26227424e-01f, -4.83823903e-02f, 1.05957538e-01f, -1.24063231e-01f, 2.10150421e-01f,
  -2.05301329e-01f, -2.96619147e-01f, -2.90010571e-01f, -1.78260475e-01f, 8.43853354e-02f, -2.56082397e-02f, -1.22698836e-01f, 2.09714040e-01f, -1.09628312e-01f, -9.65318009e-02f,
  1.01488374e-01f, -1.29038282e-02f, -8.13281238e-02f, 1.35213941e-01f, -6.95203096e-02f, 4.75361571e-02f, -1.28160149e-01f, -4.09320891e-02f, -4.51320522e-02f, 8.84112669e-04f,
  -7.56087676e-02f, 2.85489142e-01f, -2.94202175e-02f, 7.67330732e-03f, 2.04637095e-01f, 9.43222195e-02f, 2.23441750e-01f, 2.64551230e-02f, 7.60820955e-02f, 5.59546053e-02f,
  1.70498729e-01f, -7.41631091e-02f, 1.18644699e-01f, -1.28084456e-03f, 1.68372020e-01f, 2.78415859e-01f, -1.45928696e-01f, -2.05856152e-02f, -4.23048474e-02f, -2.31811926e-01f,
  2.21982241e-01f, 3.77493948e-01f, -8.20868388e-02f, 1.64275408e-01f, -3.46292555e-01f, -7.77703002e-02f, -1.08926393e-01f, 2.44920840e-03f, -1.52007982e-01f, -1.35266840e-01f,
  5.67352697e-02f, -1.00198254e-01f, 3.07559758e-01f, 4.44531115e-03f, 8.74006003e-02f, -2.44258106e-01f, -1.67242214e-01f, 1.89571485e-01f, 4.25731391e-02f, -2.83169327e-04f,
  7.54633322e-02f, 3.36072296e-02f, -9.28124413e-03f, 1.38664067e-01f, -1.41809080e-02f, 1.12025276e-01f, 1.42837703e-01f, -1.25068128e-01f, -3.10742278e-02f, 2.42540598e-01f,
  -3.03791195e-01f, 1.89946946e-02f, 3.87727499e-01f, 1.31394207e-01f, 9.15491953e-03f, -2.29666252e-02f, -2.27198198e-01f, -7.72249922e-02f, 1.76166371e-01f, -1.09919265e-01f,
  8.06071982e-02f, -9.57015604e-02f, -3.15746069e-01f, 3.26129757e-02f, 3.06157112e-01f, -3.14147584e-02f, -3.12579423e-02f, 3.86797220e-01f, -4.06685174e-02f, 1.02592871e-01f,
  1.17852643e-01f, 1.51306614e-01f, -3.60920317e-02f, 5.48714697e-02f, 1.02306716e-01f, -9.65963583e-03f, -1.80742249e-01f, -1.33770958e-01f, -1.29918635e-01f, 6.31834194e-02f,
  -3.41324769e-02f, -2.00240105e-01f, -3.61691624e-01f, 2.20959812e-01f, 1.10447787e-01f, 2.66829312e-01f, 8.40787068e-02f, 3.05582602e-02f, 2.16368303e-01f, -9.26416442e-02f,
  1.49008378e-01f, 1.97855592e-01f, -1.90625906e-01f, -1.93609387e-01f, 2.72506297e-01f, -2.50094980e-01f, 4.91873361e-02f, -1.53896600e-01f, 4.68763616e-03f, -1.13055191e-03f,
  1.18365884e-01f, 1.54979929e-01f, 1.71603397e-01f, -1.27574861e-01f, -1.58270746e-01f, 1.05472906e-02f, 1.62356988e-01f, -2.55533401e-02f, 2.01498523e-01f, 3.08192335e-02f,
  -6.59249127e-02f, 2.04532281e-01f, 5.91129772e-02f, 9.32818279e-03f, 2.87123144e-01f, 1.67057559e-01f, 1.11551628e-01f, -1.46562576e-01f, 8.21616650e-02f, -1.64883122e-01f,
  -1.53814964e-02f, -2.49579586e-02f, 2.14694738e-01f, 1.28469929e-01f, 2.55125076e-01f, -3.57480757e-02f, 2.38191471e-01f, -1.92041416e-02f, -1.64987203e-02f, 2.99021453e-02f,
  3.02846897e-02f, -3.71042788e-02f, 1.61198348e-01f, -1.89072818e-01f, 1.35495961e-01f, 1.36873692e-01f, 2.22862549e-02f, 1.38783067e-01f, -3.91868539e-02f, 3.67552377e-02f,
  2.61109501e-01f, 2.03016832e-01f, -1.00454733e-01f, 1.14635855e-01f, -4.90418345e-01f, -2.99107045e-01f, -2.21098308e-02f, -6.07239688e-03f, 7.69039914e-02f, 2.09616460e-02f,
  -1.30239472e-01f, 7.33692348e-02f, -3.69066782e-02f, -3.02722193e-02f, -1.54964074e-01f, 1.46190777e-01f, 9.54920426e-02f, 2.57933557e-01f, -1.01802230e-01f, 2.19061479e-01f,
  -1.27487555e-01f, -2.75600553e-02f, 1.11396752e-01f, -5.16130365e-02f, -2.12345980e-02f, 1.08607702e-01f, 2.11474255e-01f, -4.51729536e-01f, -1.32452875e-01f, -9.04554594e-03f,
  -2.51308270e-02f, 1.50501907e-01f, -2.11951301e-01f, 2.00686008e-01f, 2.08579764e-01f, 1.39588147e-01f, 2.09581360e-01f, -2.06984654e-01f, -4.05211560e-02f, -2.13740006e-01f,
  2.79080898e-01f, 1.39316216e-01f, 1.13872699e-01f, 7.59448707e-02f, -1.87703893e-02f, 2.54565954e-01f, 5.20507731e-02f, -1.64139912e-01f, 1.50835931e-01f, 7.24690035e-02f,
  -8.08194205e-02f, 2.77715027e-01f, 4.47520018e-02f, 1.11591369e-01f, -2.07723320e-01f, 2.08597537e-03f, 8.94478485e-02f, -6.82242289e-02f, 1.32680029e-01f, 8.57980102e-02f,
  -1.30191650e-02f, -6.08179159e-02f, 5.61103551e-03f, 2.67370105e-01f, 2.90196706e-02f, -1.65277883e-01f, -1.81222677e-01f, -2.37985272e-02f, -3.38561200e-02f, -2.18923062e-01f,
  6.82028430e-03f, 3.65255117e-01f, -1.21902086e-01f, 1.44638479e-01f, -7.73848966e-02f, 7.69016817e-02f, 1.74536318e-01f, 5.16841076e-02f, -6.88355938e-02f, 1.77781954e-01f,
  3.04249413e-02f, 1.28189191e-01f, -3.03995889e-02f, 7.18072336e-03f, -3.82205732e-02f, 1.22676641e-01f, 1.26033723e-01f, 2.05386400e-01f, 1.94292009e-01f, 1.68109909e-01f,
  -7.94098899e-02f, -1.10457063e-01f, 4.10782062e-02f, 3.44797075e-02f, -6.57870248e-02f, -1.52160721e-02f, -2.98743062e-02f, 3.08145970e-01f, 1.90354019e-01f, 2.43123427e-01f,
  1.90790325e-01f, -1.17026500e-01f, 1.83769569e-01f, -2.19800755e-01f, 3.32036950e-02f, -1.52750844e-02f, 2.62423724e-01f, 1.28822578e-02f, 2.48949621e-02f, 7.77145475e-02f,
  1.22251131e-01f, 1.07657358e-01f, 2.90076792e-01f, 3.79769981e-01f, 1.86342388e-01f, 7.59615079e-02f, 3.88580896e-02f, 2.12965123e-02f, -3.48250009e-02f, -5.30523621e-02f,
  1.07520878e-01f, 3.37060511e-01f, 2.18049958e-01f, 2.70486534e-01f, 1.99028403e-01f, -1.80657730e-01f, 8.86615813e-02f, 8.69948044e-02f, 1.10364377e-01f, 1.16668537e-01f,
  9.93446633e-03f, 2.49410272e-01f, 4.36852351e-02f, 2.78217912e-01f, -1.94226548e-01f, -3.34898159e-02f, 1.29935354e-01f, 1.50404587e-01f, -5.20887710e-02f, 5.05044498e-03f,
  -5.48516735e-02f, 7.37067685e-02f, -1.73741698e-01f, -2.00950608e-01f, 1.21690184e-01f, 8.18625465e-02f, -1.52819240e-02f, 7.40093738e-02f, 3.43952745e-01f, 2.52710104e-01f,
  -3.35961208e-02f, -1.48915462e-02f, 1.75694495e-01f, 2.81675011e-02f, -1.31551713e-01f, 2.01010242e-01f, 1.67267442e-01f, 2.96908394e-02f, 1.22981071e-01f, -2.67081875e-02f,
  1.51854143e-01f, 2.16322377e-01f, 1.59523502e-01f, -2.72969306e-01f, -1.59648553e-01f, 4.00984585e-01f, -2.55771875e-01f, 1.36426324e-02f, 1.88090846e-01f, 6.17815256e-02f,
  -1.22754797e-01f, 2.89918613e-02f, -3.04333493e-03f, -7.80465901e-02f, 3.42083164e-02f, 3.05114716e-01f, -4.29651365e-02f, -4.48165797e-02f, -3.45723778e-01f, 1.13568410e-01f,
  8.65285769e-02f, -3.55383784e-01f, 4.87738140e-02f, 2.66514301e-01f, 1.68644309e-01f, 1.16349287e-01f, -6.85542300e-02f, 2.59597123e-01f, 2.22869545e-01f, 4.96663116e-02f,
  1.01363085e-01f, -2.91320402e-02f, -8.40252824e-03f, -4.67020720e-02f, 1.88450098e-01f, 3.63050513e-02f, -2.44950354e-01f, -3.50149684e-02f, 2.60777324e-01f, -1.16597690e-01f,
  -2.66283620e-02f, -8.20704103e-02f, -3.16632152e-01f, 2.49849409e-01f, -4.72481102e-01f, -2.12255225e-01f, -3.38004529e-02f, -1.51477978e-01f, 5.70659935e-02f, -6.44168109e-02f,
  -1.33440033e-01f, 4.67079552e-03f, 2.87141562e-01f, 5.87754212e-02f, -7.10850721e-03f, -5.12397662e-02f, 1.17371112e-01f, 2.54697472e-01f, -1.39837503e-01f, -3.02713126e-01f,
  -2.58927625e-02f, -4.03251052e-02f, 1.97558273e-02f, -7.35481381e-02f, -9.43373442e-02f, 1.97414532e-01f, -7.31938258e-02f, 2.33063236e-01f, 2.09209949e-01f, -2.05035627e-01f,
  -1.76104218e-01f, 6.04491644e-02f, 1.48400426e-01f, 2.66713798e-01f, 1.03645667e-01f, -2.96332575e-02f, -3.63677114e-01f, 1.13854662e-01f, 7.80840591e-02f, 1.41028259e-02f,
  5.21356612e-02f, 1.48312181e-01f, -2.55543113e-01f, 2.17986763e-01f, -4.70716832e-03f, -1.49888024e-01f, 3.10225692e-02f, 1.41591236e-01f, 7.43767386e-03f, -1.35616809e-02f,
  1.58374757e-01f, -2.32417658e-01f, 6.54260516e-02f, 1.72121555e-01f, 7.48499529e-03f, 5.21217547e-02f, 1.73623949e-01f, -7.26366416e-02f, 1.62058339e-01f, 1.22153193e-01f,
  -1.45666778e-01f, -1.84650123e-01f, -6.68408349e-02f, 1.09215945e-01f, 3.10372859e-02f, 1.85203940e-01f, 2.92560130e-01f, -1.30972072e-01f, 2.21982330e-01f, -2.08084852e-01f,
  6.11897297e-02f, 2.27716029e-01f, -8.43810514e-02f, -1.34303138e-01f, 2.74747044e-01f, -1.40540987e-01f, -3.12178224e-01f, -1.69426560e-01f, 1.35005891e-01f, 6.53868541e-02f,
  -1.83890328e-01f, 1.89313337e-01f, 1.62611380e-01f, -7.69210756e-02f, -9.11075696e-02f, 8.01532492e-02f, 2.26635057e-02f, 7.51892105e-02f, -2.53355056e-01f, -2.27721810e-01f,
  -2.61953831e-01f, -2.02821672e-01f, -6.23119250e-03f, 1.53108954e-01f, 3.83809768e-02f, -3.79250497e-02f, 2.63569746e-02f, -3.31632048e-01f, 2.50910372e-01f, -1.93632841e-01f,
  -9.29702893e-02f, 2.65883654e-01f, 9.80854407e-02f, 5.40187173e-02f, 3.15824412e-02f, -1.17942154e-01f, 2.23281175e-01f, 1.27429694e-01f, 1.24733910e-01f, 3.19962263e-01f,
  -4.92881797e-02f, -6.64884299e-02f, 9.69533324e-02f, 5.72682805e-02f, -1.41619638e-01f, 3.43706936e-01f, 3.63127351e-01f, -1.18408829e-03f, 1.17206492e-01f, 2.97588781e-02f,
  9.09873843e-02f, -1.26753137e-01f, 2.85618365e-01f, 1.06323138e-01f, -2.30388954e-01f, -2.42984489e-01f, -8.36593360e-02f, 2.40268633e-01f, 2.01316595e-01f, 2.87046313e-01f,
  -1.19131409e-01f, 3.93223792e-01f, -1.52723297e-01f, -9.57072675e-02f, 1.94279164e-01f, 1.47683308e-01f, -8.53873789e-02f, -2.82270968e-01f, 1.42144665e-01f, -1.09745495e-01f,
  2.80222390e-02f, -1.20232359e-01f, -4.07693386e-02f, -1.89216435e-01f, -8.06918368e-02f, 2.20859721e-01f, 1.65693417e-01f, -4.38209437e-03f, -1.42115563e-01f, 3.38597834e-01f,
  -7.37411976e-02f, -1.14167184e-02f, 1.40205666e-01f, -1.36288166e-01f, -1.69148576e-02f, -1.70499414e-01f, 3.26344110e-02f, -4.09395993e-02f, -1.21518292e-01f, 8.98285583e-02f,
  1.62980005e-01f, -3.16701792e-02f, 1.19559206e-01f, -9.43240739e-05f, -6.12425581e-02f, 1.15723141e-01f, 5.59984148e-02f, -1.12925209e-01f, -1.59412567e-02f, -4.58900407e-02f,
  2.87578076e-01f, 1.19659148e-01f, -1.22129982e-02f, -1.51131963e-02f, -2.89373212e-02f, 1.60542548e-01f, 1.19410299e-01f, 1.25451267e-01f, -1.25743507e-03f, 1.28308609e-01f,
  1.36194199e-01f, 6.29445687e-02f, 4.38662339e-03f, 8.42885077e-02f, 2.02257037e-01f, -2.38731112e-02f, 1.86868920e-03f, 1.55341312e-01f, 4.72439080e-02f, -1.36969700e-01f,
  -2.75311410e-01f, 5.02947830e-02f, 1.16530687e-01f, 3.10872525e-01f, -3.26956771e-02f, 4.08391297e-01f, -2.02038258e-01f, -5.88006042e-02f, 2.12154016e-01f, 2.40374394e-02f,
  -1.04010947e-01f, -1.61053658e-01f, 2.64850825e-01f, -4.22623754e-02f, 7.31515214e-02f, -1.35538727e-01f, 3.33007835e-02f, -2.07660019e-01f, 4.13756035e-02f, 9.58725531e-03f,
  6.52691275e-02f, 5.60740344e-02f, -1.05968781e-01f, 2.75596470e-01f, 5.32749034e-02f, 4.45639640e-02f, -7.93943405e-02f, -2.01436594e-01f, 1.92541867e-01f, -2.15363234e-01f,
  -1.56506315e-01f, -1.05025105e-01f, 2.98644871e-01f, 3.21659923e-01f, 2.11698756e-01f, 2.68892288e-01f, -3.89902703e-02f, 1.42258048e-01f, -2.28164211e-01f, 1.36718806e-03f,
  9.03874040e-02f, 2.25261170e-02f, -3.74870524e-02f, -4.15385246e-01f, -1.82912908e-02f, -6.23792447e-02f, 1.83294285e-02f, -8.75816420e-02f, 6.46240041e-02f, 3.36415291e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  3.05846091e-02f, 1.67876482e-01f, -2.00245362e-02f, 4.38981839e-02f, 8.60682502e-02f, -7.45095760e-02f, 1.27431452e-01f, 3.42086330e-02f, -1.23906229e-02f, 1.63723305e-01f,
  6.09944426e-02f, -7.45770941e-03f, -3.57682779e-02f, 5.72112314e-02f, 1.92437068e-01f, 2.24317968e-01f, -1.89468730e-04f, 2.24398389e-01f, 2.43608616e-02f, 1.28149122e-01f,
  -3.99974436e-02f, 1.18452758e-01f, 6.75660744e-02f, 4.35571332e-04f, 1.51004950e-02f, 1.19336456e-01f, 8.43524858e-02f, 2.52115820e-02f, -1.12908430e-01f, 1.37318507e-01f,
  9.58641805e-03f, -2.45784502e-03f, 9.86320525e-03f, 2.04476282e-01f, 1.50397956e-01f, 1.08812377e-01f, -2.38828231e-02f, 1.77308042e-02f, 1.09473027e-01f, 1.18770421e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  2.14011781e-02f, 2.34318599e-02f, -1.01569332e-01f, -7.49410093e-02f, 1.14351613e-02f, -4.58367728e-02f, -1.66578487e-01f, -7.80927017e-02f, -1.01871220e-02f, -1.49249405e-01f,
  -1.21634081e-01f, 1.91840678e-01f, 6.66765571e-02f, 1.46707706e-02f, 4.81841303e-02f, -7.62366876e-02f, 1.64256096e-01f, 4.69370522e-02f, 1.58553850e-02f, 3.01274121e-01f,
  6.30514324e-02f, -1.25703937e-03f, 1.47892967e-01f, -1.04519077e-01f, 1.18478402e-01f, -1.86258286e-01f, 8.15739948e-03f, -1.71513081e-01f, -1.53724000e-01f, 1.43443182e-01f,
  3.94296087e-03f, -1.63002089e-01f, 1.36752963e-01f, -2.79032469e-01f, 1.57441080e-01f, -3.44318092e-01f, -3.18696737e-01f, -5.94973080e-02f, -1.05002280e-02f, -2.15073630e-01f,
  7.50070587e-02f, -2.70731121e-01f, -2.12038472e-01f, 1.12429202e-01f, -1.02075025e-01f, 1.27543211e-01f, -1.93463881e-02f, -2.71726519e-01f, 2.43304431e-01f, 1.69516698e-01f,
  -2.88500458e-01f, -1.54998153e-01f, 7.77074397e-02f, -8.75412747e-02f, -2.01449335e-01f, -2.34866947e-01f, -4.01468873e-01f, -2.76289254e-01f, 1.15603879e-01f, 1.55096784e-01f,
  -2.56924182e-01f, -7.20060393e-02f, -1.19961202e-01f, -1.83006525e-01f, -1.33011803e-01f, -2.88739074e-02f, -2.40981847e-01f, -6.40424490e-02f, -8.19179192e-02f, -3.87646221e-02f,
  1.38017982e-01f, 1.43145859e-01f, -1.75176591e-01f, 3.33932531e-03f, -6.39487430e-02f, -1.85733110e-01f, -2.23875746e-01f, 1.69561543e-02f, 2.48548105e-01f, -1.79806203e-01f,
  -3.17791514e-02f, -2.06524327e-01f, -2.77226359e-01f, 5.13127372e-02f, 1.63175743e-02f, 2.59339243e-01f, -3.91209014e-02f, -1.48734450e-01f, -3.76621425e-01f, -1.24586634e-01f,
  -3.61743718e-01f, 1.27653539e-01f, -9.89526436e-02f, 1.33307010e-01f, 1.25506476e-01f, -4.66679633e-02f, -1.39354035e-01f, 2.14989901e-01f, 5.56817800e-02f, 1.55510142e-01f,
  1.15967676e-01f, -4.11490232e-01f, 1.92773789e-01f, -2.23029390e-01f, 1.23830196e-02f, -3.21195483e-01f, 1.15980886e-01f, 7.26776198e-02f, 1.45380482e-01f, 3.82825881e-02f,
  -1.36920229e-01f, -1.04020879e-01f, -7.08458945e-02f, 7.72159994e-02f, -2.76749190e-02f, -4.38308328e-01f, -2.37991631e-01f, -1.80190265e-01f, -1.44324109e-01f, 9.96453986e-02f,
  1.15451477e-01f, -2.25501120e-01f, 2.70988178e-02f, 2.48729542e-01f, -6.14677146e-02f, 6.05732314e-02f, -1.05535001e-01f, -2.12879162e-02f, 2.28285715e-01f, 3.49315740e-02f,
  -7.25924596e-02f, 7.27533326e-02f, 2.49767318e-01f, -9.09531415e-02f, 1.31694362e-01f, 6.00781664e-03f, 1.18976355e-01f, -2.99595054e-02f, 7.41955265e-02f, 2.78413773e-01f,
  -2.41314963e-01f, 2.01846704e-01f, 2.50781298e-01f, -1.65568218e-01f, -3.07640899e-02f, -1.43102229e-01f, -1.51046515e-01f, 4.34939750e-03f, -2.95131475e-01f, 4.30145115e-02f,
  1.44140616e-01f, -3.80204171e-01f, -3.74894664e-02f, -4.05505598e-01f, 4.58366685e-02f, 1.27607718e-01f, 1.34063751e-01f, -1.70883000e-01f, -7.39655346e-02f, -2.21351147e-01f,
  -1.98873162e-01f, -2.10000098e-01f, -1.43143073e-01f, -2.15978742e-01f, -1.76553860e-01f, -4.64610308e-02f, 7.84168169e-02f, 1.21072434e-01f, 1.19917914e-01f, -6.24756105e-02f,
  5.69386855e-02f, 8.87376536e-03f, 1.66475430e-01f, -6.55342638e-02f, -1.46645308e-01f, -2.01570332e-01f, -3.54445241e-02f, -3.07371289e-01f, 1.33538553e-02f, 2.05827892e-01f,
  -8.80482495e-02f, 1.01204313e-01f, 5.33812195e-02f, 1.56656682e-01f, -1.74747288e-01f, -5.19844472e-01f, -6.06786132e-01f, 2.57882059e-01f, 1.98711410e-01f, -3.91213268e-01f,
  1.12748764e-01f, 2.11304754e-01f, 7.03593949e-03f, 7.72604048e-02f, 6.23375215e-02f, -2.22716451e-01f, 4.84595522e-02f, -4.17098356e-03f, -2.72825919e-02f, 8.86625703e-03f,
  -6.07357398e-02f, -1.24272607e-01f, 6.51299432e-02f, 5.83189614e-02f, 1.18104950e-01f, -7.98236877e-02f, 2.36330196e-01f, 2.49616146e-01f, 1.76376820e-01f, 1.43560529e-01f,
  -4.97297533e-02f, 1.63733616e-01f, 1.04456671e-01f, -1.08434431e-01f, -1.06051333e-01f, 1.87987775e-01f, 7.72210828e-04f, -1.73094701e-02f, 4.98356335e-02f, -2.60123312e-01f,
  -2.74164647e-01f, -4.49508205e-02f, -2.94384480e-01f, 2.50461966e-01f, 1.56079024e-01f, -1.69787556e-01f, -9.04739648e-02f, -2.35695034e-01f, -2.76818275e-01f, 2.47495621e-01f,
  -2.17292011e-01f, -3.47568840e-01f, -2.63109673e-02f, -1.11293077e-01f, 8.77363756e-02f, 7.96978548e-02f, -2.53809959e-01f, 6.81635216e-02f, -2.48283967e-01f, 2.29532987e-01f,
  8.14179778e-02f, 8.51442963e-02f, 1.33924916e-01f, -5.48519008e-03f, -7.99136460e-02f, 1.10825405e-01f, -1.29288673e-01f, -1.94080248e-01f, -4.50858384e-01f, -3.92155312e-02f,
  8.26491043e-02f, 4.10865620e-02f, 2.71762423e-02f, -2.48233974e-01f, -1.71275884e-01f, -8.61800835e-02f, -1.93518605e-02f, -1.32105768e-01f, 2.06297543e-02f, 2.88184211e-02f,
  -5.77245168e-02f, -1.13473669e-01f, -8.94860551e-02f, -5.83337061e-02f, 1.97899207e-01f, 9.79502797e-02f, 1.43949911e-01f, 8.12584758e-02f, 1.74364746e-01f, -3.77395898e-02f,
  -2.58073639e-02f, 1.95352942e-01f, -2.82932937e-01f, 2.90210068e-01f, -1.37507290e-01f, -3.16374987e-01f, 5.73857017e-02f, 2.87117660e-02f, -1.24576829e-01f, 2.82123685e-01f,
  -1.64134219e-01f, 1.42310962e-01f, 1.96605295e-01f, -1.03639722e-01f, 6.55475631e-02f, -7.66127482e-02f, -2.35997692e-01f, -1.11031927e-01f, 6.37727156e-02f, -4.46807109e-02f,
  6.46285191e-02f, 1.25172362e-01f, 1.63931876e-01f, -1.26861379e-01f, -3.32298547e-01f, 2.67733872e-01f, 9.17203501e-02f, 1.83422804e-01f, -1.54199511e-01f, 2.07394630e-01f,
  1.32184401e-02f, 9.17612091e-02f, -1.04437806e-01f, -6.59670010e-02f, -6.90262765e-03f, -5.97453490e-02f, -1.14454836e-01f, 1.15553342e-01f, 2.10995123e-01f, 1.87462568e-01f,
  6.44664392e-02f, -2.96346277e-01f, -4.15873677e-02f, -8.36257264e-02f, -3.90198827e-03f, -5.22538535e-02f, -2.89494991e-01f, -1.58415318e-01f, -2.96968430e-01f, -3.29347461e-01f,
  2.20938027e-01f, -3.53755690e-02f, 1.27999142e-01f, 9.44199506e-03f, 4.25659902e-02f, 1.65580004e-01f, 2.82875806e-01f, 1.99645594e-01f, -3.89192291e-02f, 1.65942445e-01f,
  1.53581306e-01f, -1.83556780e-01f, -6.00313060e-02f, 6.02476746e-02f, -1.67851329e-01f, 1.82257369e-01f, 2.35070083e-02f, -7.13713616e-02f, -1.20109290e-01f, -8.03235322e-02f,
  -1.46190256e-01f, -4.39818412e-01f, 2.62972116e-01f, 2.95932174e-01f, 4.13977467e-02f, 2.15516966e-02f, -5.45533076e-02f, -4.17094886e-01f, 2.46479213e-01f, -8.97030085e-02f,
  -1.33663937e-01f, -2.85038590e-01f, -3.36806744e-01f, 2.38821372e-01f, 1.32228658e-02f, -2.91396141e-01f, -4.88410927e-02f, 8.67994353e-02f, 6.29955605e-02f, -2.01255605e-01f,
  -2.05345340e-02f, -5.15546426e-02f, -3.88904244e-01f, 1.56251371e-01f, 2.22763494e-01f, 5.42756133e-02f, 1.14711732e-01f, -9.80562419e-02f, -3.06216300e-01f, -1.77250817e-01f,
  -2.02950537e-01f, -3.76808308e-02f, 5.69123179e-02f, 4.23768200e-02f, -2.05006346e-01f, 5.05170375e-02f, -1.95069581e-01f, 3.29227030e-01f, 8.96240920e-02f, 5.12268431e-02f,
  1.63919196e-01f, -1.85178071e-01f, -1.91782061e-02f, 4.72823121e-02f, -4.19549346e-02f, -2.82172769e-01f, 1.74492300e-01f, -8.07812884e-02f, 9.62061509e-02f, -1.21207520e-01f,
  1.09703593e-01f, -2.69779235e-01f, 6.31398037e-02f, 9.77946967e-02f, 1.61410585e-01f, -1.15464620e-01f, 2.09456444e-01f, 8.00044313e-02f, -1.55628309e-01f, 1.42453715e-01f,
  -2.38822490e-01f, -2.54176483e-02f, -2.72303913e-02f, -3.42095226e-01f, -3.56851146e-02f, 1.20848939e-01f, 1.94320455e-02f, -7.63620511e-02f, 1.39849231e-01f, -2.56259680e-01f,
  -4.70857590e-01f, 1.47927091e-01f, 1.33371636e-01f, -3.04347575e-01f, 1.64367557e-01f, -4.18030262e-01f, -1.16967522e-01f, 1.70317948e-01f, -1.69251263e-01f, -5.84155731e-02f,
  -3.03732991e-01f, -2.29274496e-01f, -1.33860379e-01f, 1.98629096e-01f, 2.21595988e-02f, 8.39820579e-02f, 8.58702809e-02f, -2.75935978e-01f, -8.86584222e-02f, 1.11672923e-01f,
  1.95740163e-01f, 4.51824032e-02f, 1.64745018e-01f, -1.60232320e-01f, 2.08961628e-02f, -9.70776156e-02f, -4.70223933e-01f, -8.26179087e-02f, 7.64279813e-02f, 1.27904713e-01f,
  1.17506862e-01f, 1.63728610e-01f, -1.38732702e-01f, -3.40573341e-01f, -2.16686293e-01f, 1.94948405e-01f, 1.14090130e-01f, 2.21909925e-01f, -7.48074353e-02f, -1.35051504e-01f,
  -9.30982828e-02f, 1.12886764e-01f, -1.63718969e-01f, 4.75478359e-02f, 6.21522926e-02f, 1.85798071e-02f, -6.84163868e-02f, -6.27552792e-02f, -8.63460228e-02f, 1.52730308e-02f,
  8.28821585e-02f, 1.03685535e-01f, -9.34519470e-02f, -1.26435250e-01f, 6.12964816e-02f, 5.06784990e-02f, 2.94818789e-01f, 1.89804092e-01f, 4.69149873e-02f, 4.34055999e-02f,
  1.01703517e-02f, -7.60123655e-02f, 1.08226769e-01f, -4.97565806e-01f, -9.35348123e-02f, 9.56007466e-02f, -1.93163201e-01f, 9.78874415e-02f, 1.17385597e-03f, 2.38062590e-01f,
  -2.31506929e-01f, -1.97471321e-01f, -3.20864052e-01f, 1.41967937e-01f, 1.78595379e-01f, 1.85204968e-01f, -1.16429210e-01f, -8.57781842e-02f, 9.28609893e-02f, -2.72201806e-01f,
  -4.76156175e-02f, 7.36060143e-02f, 3.32366787e-02f, -8.75893906e-02f, -3.75743330e-01f, -2.32880086e-01f, 2.04545170e-01f, -2.44472474e-01f, 4.69931923e-02f, -1.05977237e-01f,
  -7.13150948e-02f, -4.01607960e-01f, -1.51416570e-01f, -2.82412797e-01f, 5.24145029e-02f, 8.93431157e-02f, 2.05044001e-01f, -3.11803848e-01f, -1.02352373e-01f, -1.46701485e-01f,
  -3.65819186e-01f, -2.60903239e-01f, 4.08594050e-02f, 1.07960247e-01f, -1.88942194e-01f, 3.76297608e-02f, 9.97032821e-02f, -7.80771747e-02f, -2.86389858e-01f, 6.49562851e-02f,
  -1.14429072e-01f, 7.99827725e-02f, -1.44786000e-01f, 2.64080465e-01f, 8.76089334e-02f, 1.15902290e-01f, -1.49300858e-01f, 9.46590304e-02f, 1.81758702e-01f, -6.47000670e-02f,
  3.69917363e-01f, 1.08830109e-01f, -2.12287351e-01f, 1.25407636e-01f, 2.45269039e-03f, -1.35657340e-01f, -2.65752614e-01f, -1.38360485e-01f, -5.72473705e-02f, 1.09658770e-01f,
  -3.66339535e-02f, 6.21859962e-03f, -2.86769301e-01f, 1.15138851e-01f, 1.14190020e-01f, -1.22704320e-01f, -3.74533832e-01f, 1.77663282e-01f, -1.67125762e-01f, 1.00440465e-01f,
  2.04701468e-01f, -1.33731574e-01f, -2.36171290e-01f, -3.38440716e-01f, 4.99989046e-03f, -3.90293509e-01f, 1.34689882e-01f, -3.14074606e-01f, 2.52626747e-01f, -1.30874261e-01f,
  -6.51922300e-02f, -1.19798712e-01f, -1.05448276e-01f, -2.19766319e-01f, 3.13249417e-02f, -3.03330183e-01f, -3.18850547e-01f, 7.34487846e-02f, 1.04464009e-01f, 1.75223872e-01f,
  1.82191327e-01f, -1.43448055e-01f, 1.56283110e-01f, -1.62633687e-01f, 2.78281182e-01f, -2.65962750e-01f, 1.05520509e-01f, 2.47833624e-01f, 1.94580138e-01f, -1.99839637e-01f,
  -2.16247678e-01f, 8.74599814e-02f, -1.96375772e-01f, 2.79057771e-03f, -8.37298259e-02f, -1.03893511e-01f, -2.54756421e-01f, -1.27355903e-01f, -1.59321606e-01f, -1.90178677e-01f,
  -1.76118240e-02f, -2.60489911e-01f, 2.52148211e-01f, 3.66175920e-01f, -6.34494051e-02f, 2.07861140e-01f, 2.08071455e-01f, 3.05687149e-06f, -8.16646516e-02f, -1.90197334e-01f,
  9.34637934e-02f, -3.71145785e-01f, 1.76181704e-01f, -3.66820432e-02f, 5.22989780e-03f, 1.06745973e-01f, 2.34037191e-01f, -4.74961661e-02f, -2.94498384e-01f, -9.37139839e-02f,
  -2.65916795e-01f, -2.18140602e-01f, -1.52592123e-01f, -2.01087415e-01f, -3.65719587e-01f, 6.11165352e-02f, 8.73534232e-02f, 2.12126821e-01f, -3.39136481e-01f, 6.25558719e-02f,
  1.07462265e-01f, -4.98335630e-01f, -3.11729968e-01f, -4.46773678e-01f, -2.72197127e-01f, -1.70002326e-01f, 1.19194455e-01f, 1.32496774e-01f, 1.06159687e-01f, -3.81418131e-02f,
  8.60475674e-02f, -1.83251694e-01f, 1.87877372e-01f, -1.71533987e-01f, -1.08426325e-02f, -2.52837956e-01f, -3.40087771e-01f, 7.41138309e-02f, 1.28761619e-01f, 1.63109273e-01f,
  3.38389426e-02f, -8.32058117e-02f, -6.34240806e-02f, -1.14156976e-01f, -6.58384478e-03f, -1.27345517e-01f, -1.08184732e-01f, -1.73484143e-02f, -3.99839953e-02f, 3.05655580e-02f,
  -1.36633724e-01f, -1.68563098e-01f, 2.46999964e-01f, -1.96161106e-01f, -1.87974006e-01f, -9.81602520e-02f, 1.45252332e-01f, -4.83770743e-02f, -7.83541650e-02f, -2.17283994e-01f,
  -1.37789786e-01f, 2.25999683e-01f, 9.65452492e-02f, 1.70741245e-01f, -2.43608519e-01f, 3.23870815e-02f, -8.79803151e-02f, 1.96926907e-01f, -1.09834783e-01f, 7.27839619e-02f,
  -1.50368646e-01f, 3.82232189e-01f, -1.03917541e-02f, -8.80000070e-02f, -6.37814701e-02f, 7.85968155e-02f, -1.81065291e-01f, -7.96079338e-02f, 9.10178050e-02f, 1.55000702e-01f,
  -4.83785778e-01f, 2.08491042e-01f, 2.09641218e-01f, -2.84808308e-01f, -2.61584431e-01f, -4.57186490e-01f, -1.79892689e-01f, 2.90567666e-01f, -1.33795202e-01f, 2.20924556e-01f,
  -1.39814496e-01f, -1.05324887e-01f, -1.17282443e-01f, 1.83870465e-01f, 9.18682069e-02f, 8.34345371e-02f, -2.13426158e-01f, -1.47776291e-01f, -8.51343349e-02f, 8.72340351e-02f,
  -8.32247827e-03f, -8.22628960e-02f, -2.76214957e-01f, -2.10304454e-01f, 2.94801872e-02f, 6.98384717e-02f, -1.68608308e-01f, 5.78499958e-02f, 3.88999991e-02f, 1.83727160e-01f,
  4.48242873e-02f, 1.27797976e-01f, 4.14809994e-02f, 9.64379236e-02f, 6.81896061e-02f, -1.05492488e-01f, -3.98007520e-02f, -8.57932121e-03f, 2.05973815e-02f, 1.12639315e-01f,
  -1.33088186e-01f, -2.84481272e-02f, -4.62079570e-02f, 2.07931474e-01f, 2.01772287e-01f, -3.61441262e-02f, -2.97054872e-02f, -1.43338218e-01f, 1.46709323e-01f, 1.54528394e-01f,
  -1.41265601e-01f, -2.00234354e-01f, -1.61408469e-01f, -2.68530428e-01f, 1.16104834e-01f, 7.02379495e-02f, 3.78263257e-02f, 1.51280105e-01f, -1.82462856e-01f, 5.85836060e-02f,
  1.91258371e-01f, 2.47098640e-01f, -4.32900280e-01f, -2.93469489e-01f, -1.58131227e-01f, -5.74560352e-02f, 1.70689821e-02f, -3.04930300e-01f, -5.05832508e-02f, -2.95004219e-01f,
  8.44131485e-02f, -1.11761510e-01f, -3.42371404e-01f, -1.09176137e-01f, 1.71558246e-01f, -1.83449298e-01f, -2.16741994e-01f, -1.47577167e-01f, 2.06575945e-01f, -1.31071955e-01f,
  -1.71329707e-01f, 2.62116939e-01f, 3.89570855e-02f, -3.01718563e-01f, -6.51954710e-02f, 1.76997364e-01f, -7.39199854e-03f, -3.22058767e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -4.47527021e-02f, 6.44618645e-02f, 1.33375123e-01f, -7.36921653e-02f, 2.15800881e-01f, 2.05078418e-03f, 9.94204804e-02f, -2.61062868e-02f, 1.02158822e-02f, 8.76848102e-02f,
  2.00495385e-02f, -1.02371871e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    