/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.62101352e-01f, -1.52596280e-01f, -1.52844563e-01f, -1.07196435e-01f, 8.87318105e-02f, 2.19841942e-01f, -1.60353646e-01f, -6.37917295e-02f, -2.60199130e-01f, 6.98673278e-02f,
  6.00212179e-02f, -1.03939243e-01f, -1.10870093e-01f, 7.33182132e-02f, 6.94254264e-02f, -1.49062768e-01f, 1.35515824e-01f, 3.39653827e-02f, -7.10165277e-02f, -3.68753895e-02f,
  -4.90768403e-02f, 1.35103181e-01f, 4.39877100e-02f, 4.44635116e-02f, -5.53825591e-03f, 2.68800706e-02f, 1.84751600e-01f, 2.31562611e-02f, 2.29026645e-01f, 5.42526087e-03f,
  -4.97907065e-02f, -2.04940483e-01f, -1.62211936e-02f, -6.42660931e-02f, 1.02971077e-01f, 7.56912259e-03f, 5.16301021e-02f, 6.80145323e-02f, -8.25924873e-02f, -2.11150502e-03f,
  -2.57967543e-02f, -4.39375751e-02f, 3.18108723e-02f, 1.63061433e-02f, -6.58564195e-02f, -7.89518431e-02f, 1.32649057e-02f, -2.04060730e-02f, -5.23644648e-02f, -8.65555543e-04f,
  -4.08313274e-02f, -1.58168599e-02f, -1.84752848e-02f, 3.16470787e-02f, -3.11290491e-02f, 1.87743623e-02f, -3.89585756e-02f, 4.99134511e-02f, 1.51872439e-02f, 8.77562072e-03f,
  6.25436679e-02f, 2.05714069e-02f, -5.28693423e-02f, -3.43235508e-02f, -4.99896854e-02f, 5.90642616e-02f, 5.31585664e-02f, 5.20336293e-02f, -1.92609988e-02f, 2.41906568e-02f,
  2.29815114e-02f, 3.70504633e-02f, -3.61092091e-02f, 2.71790083e-02f, 1.43033704e-02f, -3.70818153e-02f, 4.33458090e-02f, -3.16540040e-02f, -2.20471118e-02f, 4.14502248e-02f,
  -3.67547832e-02f, -5.06180488e-02f, 2.09574960e-02f, 7.52829539e-04f, -2.52028573e-02f, -7.27663189e-02f, 2.99579520e-02f, 3.51979979e-03f, -1.12984210e-01f, 7.44840205e-02f,
  4.89429533e-02f, 1.85226917e-01f, -7.18967617e-02f, 3.17347087e-02f, 6.00739010e-02f, 4.61327359e-02f, 3.41900550e-02f, -1.27316425e-02f, 4.51652966e-02f, -5.50968945e-03f,
  7.28318840e-02f, 7.00838342e-02f, 5.61177507e-02f, 2.30925828e-02f, 7.69769028e-02f, 6.57798573e-02f, -2.11936012e-02f, 9.69229862e-02f, 8.18542615e-02f, 2.20303629e-02f,
  2.17860732e-02f, 4.45254035e-02f, -1.18454592e-02f, -2.46225931e-02f, 1.14940591e-02f, -5.04092798e-02f, 5.22131845e-02f, -7.30090365e-02f, 1.30768225e-01f, 2.61922181e-02f,
  -2.40014210e-01f, 2.37143427e-01f, -6.05521388e-02f, -1.14829473e-01f, -2.20883831e-01f, -8.97382796e-02f, -1.07085273e-01f, -8.38476121e-02f, -1.28349200e-01f, 1.17492445e-01f,
  -4.96241041e-02f, 2.19061688e-01f, -2.98363566e-02f, 1.11618206e-01f, -2.56747991e-01f, -9.58052501e-02f, 3.65809985e-02f, 1.67472526e-01f, -3.65931727e-02f, 5.23666963e-02f,
  -8.92139375e-02f, 7.55736381e-02f, -1.76095799e-01f, 8.78953561e-02f, 9.52216163e-02f, 9.74854305e-02f, -9.71098766e-02f, -1.21696547e-01f, 1.21836185e-01f, -2.18432192e-02f,
  6.95329234e-02f, 2.17754915e-02f, 4.22212444e-02f, 8.94869794e-04f, -2.70556938e-02f, 3.77890840e-02f, 4.17642221e-02f, 4.49057715e-03f, -7.80281425e-02f, -1.60065033e-02f,
  4.55428325e-02f, -2.38741152e-02f, 1.00734077e-01f, 4.07832704e-04f, -1.73851624e-02f, 2.21871193e-02f, -2.38799099e-02f, 2.09869836e-02f, 4.50332984e-02f, 1.51996333e-02f,
  -3.13100517e-02f, -5.83452964e-03f, -3.39887515e-02f, 8.80717561e-02f, -3.64123620e-02f, -4.43919264e-02f, 6.90832138e-02f, 3.81327346e-02f, 5.70277870e-02f, 2.31165234e-02f,
  3.80706154e-02f, -5.21425642e-02f, 2.67145615e-02f, 4.18543182e-02f, -1.20898020e-02f, 6.07901020e-03f, -4.64242697e-03f, -1.60349905e-02f, -1.93863660e-02f, -1.76942330e-02f,
  -5.97782247e-02f, 4.39560339e-02f, 5.94777940e-03f, 2.34807655e-02f, -1.26769356e-02f, 5.26728109e-02f, -1.09976046e-02f, 7.02806860e-02f, -2.51483619e-02f, -2.47427188e-02f,
  -3.71149927e-02f, -6.20839857e-02f, 1.93127170e-02f, -1.59383379e-02f, -2.60102730e-02f, -1.36755081e-02f, -1.69358347e-02f, -2.73395621e-04f, -5.13944700e-02f, -2.21292805e-02f,
  2.06716806e-02f, 2.76351273e-02f, -1.18417223e-03f, 6.60285354e-03f, 6.60892427e-02f, 7.45169760e-04f, -5.86666875e-02f, 4.71091783e-03f, -2.60811560e-02f, -4.76778410e-02f,
  7.67979696e-02f, 8.80113523e-03f, 1.64036434e-02f, -6.20504096e-02f, -5.99278435e-02f, -2.57475711e-02f, -2.84449793e-02f, -6.14774786e-03f, -4.53009456e-02f, 4.19392847e-02f,
  1.03596216e-02f, 2.39619683e-03f, 9.48591996e-03f, -6.64447099e-02f, 9.69219059e-02f, 3.41386162e-02f, -4.34870869e-02f, -1.01388646e-02f, 4.97892080e-03f, -1.46198310e-02f,
  -3.69223624e-01f, 1.71136037e-01f, 2.21979115e-02f, 1.90778449e-01f, -1.54816896e-01f, -3.16178310e-03f, -4.39631455e-02f, 9.32473913e-02f, -3.78401317e-02f, 1.46200672e-01f,
  7.29714110e-02f, 3.99400480e-03f, -8.50216523e-02f, 2.87374884e-01f, -1.45407468e-01f, 7.93776140e-02f, 9.94220451e-02f, 4.92701903e-02f, 3.38896587e-02f, -1.06755860e-01f,
  -3.01314369e-02f, 1.79819733e-01f, 1.40617087e-01f, 8.86911750e-02f, -2.06157751e-02f, 3.69104408e-02f, -3.85055877e-02f, 2.13862471e-02f, 1.27251282e-01f, -3.28445397e-02f,
  -8.85198917e-03f, -1.05663901e-02f, 5.65797603e-03f, -4.83032651e-02f, -1.37261301e-01f, -1.30285084e-01f, -1.16186887e-01f, 2.91024614e-02f, 4.75324877e-02f, 3.14984359e-02f,
  -4.64365967e-02f, 3.78341749e-02f, 3.26002203e-02f, -1.26080010e-02f, -2.70073190e-02f, 4.50488143e-02f, 1.28231958e-01f, 7.01194331e-02f, 5.46743833e-02f, 4.52201739e-02f,
  5.78116067e-02f, 5.19798622e-02f, 8.46905485e-02f, 2.79122107e-02f, 2.23426172e-03f, 4.83100452e-02f, 6.65204301e-02f, -7.16787651e-02f, -2.73108035e-02f, 9.92337056e-03f,
  -3.75555977e-02f, -7.62853250e-02f, -3.34138125e-02f, -3.91434021e-02f, 5.36267497e-02f, -4.56205308e-02f, 8.56113434e-02f, -4.93022315e-02f, 8.09806511e-02f, -2.94204615e-02f,
  1.64778400e-02f, -9.72056016e-03f, 9.74968541e-03f, 9.83494520e-03f, 3.93290445e-02f, -3.18612047e-02f, -6.45091534e-02f, -1.33153945e-02f, 1.58115849e-02f, 2.59620622e-02f,
  1.52140893e-02f, -4.96326685e-02f, 2.13448075e-03f, -6.55749142e-02f, -3.30747338e-03f, -2.39394102e-02f, 7.35252872e-02f, 4.60035987e-02f, -5.47460331e-05f, -4.88121100e-02f,
  -8.22538435e-02f, -1.22163724e-02f, 6.95856959e-02f, -1.89610466e-03f, -1.41039537e-02f, 1.21515254e-02f, 4.58688065e-02f, -4.87832539e-03f, 7.38879340e-03f, -8.02725106e-02f,
  -3.42666954e-02f, 1.77611243e-02f, -8.41937661e-02f, 1.00872258e-03f, 3.42517421e-02f, -7.30608031e-03f, -1.34385154e-01f, -6.12960868e-02f, -4.30040285e-02f, -6.84018359e-02f,
  1.18515128e-02f, -5.11248782e-02f, 7.20657781e-02f, 8.75090074e-04f, 2.16480289e-02f, 1.48305548e-02f, -1.12229832e-01f, 2.75937822e-02f, 1.09344162e-02f, 6.23852573e-02f,
  4.06754985e-02f, -1.66438431e-01f, -1.22967958e-01f, 5.67948334e-02f, 2.20027804e-01f, 6.59429003e-03f, -6.07211143e-02f, 2.27361605e-01f, -2.64128387e-01f, -7.55124465e-02f,
  1.31962538e-01f, -1.53145611e-01f, -7.91928098e-02f, 7.42708240e-03f, 6.08016923e-02f, -2.47454569e-01f, 6.86041638e-02f, -4.52816971e-02f, -6.64344877e-02f, 1.11411639e-01f,
  8.67544785e-02f, 1.85246632e-01f, 1.04087912e-01f, 1.84989437e-01f, 7.80146047e-02f, 6.28912076e-02f, 1.71373799e-01f, -4.87455539e-02f, 2.24693835e-01f, 5.66457286e-02f,
  -1.41765755e-02f, -4.00559120e-02f, 7.85071105e-02f, -9.83371735e-02f, 1.12912662e-01f, 5.27479686e-02f, -4.19023037e-02f, 1.73197109e-02f, -4.57947433e-04f, -2.52431668e-02f,
  -8.25189278e-02f, 1.01746716e-01f, -4.95020710e-02f, 1.91826560e-02f, 1.12128789e-02f, -1.69789065e-02f, 7.07842689e-03f, -2.86027491e-02f, 1.56197129e-02f, 6.28972054e-02f,
  4.64914404e-02f, 3.08321789e-02f, -7.97841251e-02f, 3.29912384e-03f, 5.61393462e-02f, -2.04518307e-02f, 1.23116104e-02f, 7.59869292e-02f, -8.12667683e-02f, 2.89485659e-02f,
  8.18493888e-02f, -7.88777918e-02f, 5.43343136e-03f, -9.00798216e-02f, -8.79566465e-03f, 7.56303892e-02f, -9.63407978e-02f, 2.17927955e-02f, -1.80298672e-03f, 7.93380141e-02f,
  4.58170380e-03f, 7.24334493e-02f, 1.67706180e-02f, -3.10068647e-03f, 7.24184960e-02f, 1.56970602e-02f, -2.09299456e-02f, 3.59999947e-02f, 1.34850815e-02f, 3.38068232e-02f,
  -5.10415696e-02f, -3.84890363e-02f, 6.49494976e-02f, -4.85452488e-02f, -3.97478007e-02f, 3.92222144e-02f, -6.24185754e-03f, -7.32265711e-02f, -8.08932856e-02f, 2.18388923e-02f,
  -3.07416227e-02f, 6.11320790e-03f, -4.58778739e-02f, -6.86992379e-03f, -1.05650656e-01f, 9.85044148e-03f, -5.35514019e-02f, 3.21411751e-02f, 7.86042213e-03f, 1.46173565e-02f,
  1.11809671e-01f, -9.16155986e-03f, -1.21558562e-01f, 1.04885669e-02f, -3.96670587e-02f, 2.64248252e-02f, -3.53864618e-02f, 3.41480337e-02f, 4.38017435e-02f, 9.93643403e-02f,
  2.06059050e-02f, 1.30786048e-02f, 1.45304045e-02f, 3.01571209e-02f, -6.59133587e-03f, -1.69767234e-02f, -1.56301428e-02f, 3.91477905e-02f, 4.94140759e-02f, -6.78426950e-05f,
  2.86277324e-01f, 4.72593345e-02f, -9.73750576e-02f, -3.00333649e-02f, 2.49894902e-01f, 1.80349454e-01f, 6.46027029e-02f, 1.89283684e-01f, 6.40215427e-02f, -1.44229844e-01f,
  2.98175458e-02f, -1.05490372e-01f, -1.25474915e-01f, 3.73336002e-02f, 8.46283212e-02f, -1.29224226e-01f, 1.59495652e-01f, -3.03762667e-02f, 4.59012203e-02f, 1.79189280e-01f,
  2.02938858e-02f, 6.56476691e-02f, 5.15642315e-02f, 1.48195207e-01f, 2.35988066e-01f, 6.04193211e-02f, -1.83028340e-01f, -1.58395901e-01f, 5.30989021e-02f, 3.66913825e-02f,
  5.78736104e-02f, 1.61333364e-02f, -3.49477050e-03f, 7.16201067e-02f, 1.56276882e-01f, -5.10424674e-02f, 5.25704958e-02f, -1.16175331e-01f, -1.79447588e-02f, 2.77407039e-02f,
  -3.53745334e-02f, 5.53958900e-02f, 3.50410715e-02f, -8.07039514e-02f, 1.31256077e-02f, 3.05122579e-03f, 2.31078230e-02f, 5.11335656e-02f, -1.91480536e-02f, 3.68402265e-02f,
  -1.65940635e-02f, 5.67570738e-02f, -5.65623827e-02f, -1.25357567e-03f, 2.40815934e-02f, -6.92616962e-03f, -4.77905013e-02f, -3.48411575e-02f, 2.61898115e-02f, 8.21328685e-02f,
  -3.82512547e-02f, -1.04418673e-01f, -9.17942822e-03f, 2.96076224e-03f, 1.04929563e-02f, 3.39474939e-02f, -5.26813231e-02f, -6.03849776e-02f, -1.59079116e-02f, -4.98580821e-02f,
  1.28588378e-01f, 1.65526699e-02f, 1.06634023e-02f, -3.78927998e-02f, 2.14123465e-02f, 2.73736659e-02f, -5.02362661e-02f, 6.62080536e-04f, 6.72309250e-02f, -1.40848858e-02f,
  9.80165903e-04f, 3.50726652e-03f, -1.15344021e-02f, -4.34493050e-02f, 1.99128035e-02f, 1.99508248e-03f, -2.55939644e-02f, -7.88244158e-02f, -2.35607773e-02f, -5.07860258e-02f,
  1.41916484e-01f, -2.05321591e-02f, 3.41700390e-02f, -1.86018702e-02f, -8.74085128e-02f, 6.50033541e-03f, -5.58817908e-02f, 3.61704975e-02f, -4.48070327e-03f, 4.92749438e-02f,
  1.48030818e-02f, -8.90359357e-02f, -7.57427374e-03f, -4.00363915e-02f, 9.56117548e-03f, -1.21562388e-02f, 1.36382785e-03f, -1.93551611e-02f, 4.08819653e-02f, -1.14596114e-02f,
  -8.72982107e-03f, 2.05858275e-02f, -2.49916827e-03f, 3.04027442e-02f, -2.07148567e-02f, -6.22752821e-03f, 6.21157102e-02f, -4.17482778e-02f, 6.98945224e-02f, 1.00239124e-02f,
  -3.12358648e-01f, 1.15910001e-01f, -2.23791957e-01f, 9.16223899e-02f, -5.45796230e-02f, 1.41537245e-02f, -6.31361604e-02f, 1.43719465e-01f, 1.25760168e-01f, 2.90796489e-01f,
  1.61363751e-01f, -1.38600126e-01f, 1.50320664e-01f, 2.72809774e-01f, -3.39126438e-01f, 1.08315580e-01f, 1.20093673e-02f, 1.41375409e-02f, 4.55296822e-02f, 8.61531869e-02f,
  -4.31780703e-02f, 2.72209823e-01f, -1.05069689e-01f, 1.01479724e-01f, -8.39179680e-02f, -3.71223800e-02f, 1.08875735e-02f, -1.04310654e-01f, 9.77962017e-02f, -7.31430948e-02f,
  -1.35831192e-01f, 4.83581498e-02f, -6.14644885e-02f, -5.93717359e-02f, -3.20828855e-02f, -7.41341114e-02f, -1.07983071e-02f, -8.26686323e-02f, -1.32972077e-02f, -6.01328015e-02f,
  -5.42293340e-02f, -3.24339280e-03f, 5.51901758e-02f, -3.99127118e-02f, 1.05463170e-01f, -9.23825353e-02f, -5.74172437e-02f, -5.20647429e-02f, 2.49810610e-02f, -5.85758081e-03f,
  -8.61419067e-02f, -6.09310381e-02f, 4.35467064e-02f, 5.35504967e-02f, -1.07092723e-01f, 1.98214129e-02f, -4.59618419e-02f, -1.46252334e-01f, 8.19336157e-03f, 4.45123687e-02f,
  2.48088650e-02f, 1.38787068e-02f, -8.53843018e-02f, 4.85252552e-02f, -4.25840355e-03f, 2.39599477e-02f, 1.00300923e-01f, 1.76858548e-02f, -5.12990868e-03f, 3.59621197e-02f,
  8.21695197e-03f, -2.46704668e-02f, 6.46976158e-02f, 3.20540816e-02f, 2.77170669e-02f, 9.60820764e-02f, -5.70864826e-02f, 2.64963470e-02f, 3.64889950e-02f, 4.20473069e-02f,
  3.48117985e-02f, 3.10177691e-02f, 6.40201792e-02f, -2.02668738e-02f, 3.09232958e-02f, -3.95322442e-02f, 5.11182062e-02f, -4.47134599e-02f, 3.20025012e-02f, -8.61351341e-02f,
  1.15649916e-01f, 1.63276911e-01f, 6.87326416e-02f, 5.58382533e-02f, -2.67043617e-02f, 4.10436206e-02f, 1.70300119e-02f, -2.76921038e-02f, -1.71848647e-02f, 9.30981711e-02f,
  -1.82955656e-02f, 4.47743721e-02f, -8.09410661e-02f, -5.19909291e-03f, 2.62870211e-02f, 7.00266212e-02f, 2.20598020e-02f, -1.27894222e-03f, 1.72161181e-02f, 3.33118066e-02f,
  2.00475771e-02f, 2.74999291e-02f, -5.86325191e-02f, -5.49049163e-03f, 8.42804760e-02f, -7.12792352e-02f, 3.60991172e-02f, -2.63160579e-02f, -6.06444702e-02f, 2.19661854e-02f,
  -8.29119119e-04f, -1.12266921e-01f, 1.08162977e-01f, -2.23601103e-01f, 1.67902842e-01f, 5.87383881e-02f, -4.56588678e-02f, -1.36979697e-02f, -1.69750452e-01f, -1.18400842e-01f,
  3.30742943e-04f, -1.50615901e-01f, 3.22732255e-02f, -2.72117376e-01f, 1.84922235e-03f, -2.57559121e-01f, -1.24738194e-01f, -2.02736408e-01f, -5.95372543e-02f, 1.93766151e-02f,
  -7.08327144e-02f, -1.76727697e-01f, -1.19911857e-01f, -9.14087333e-03f, 1.12418039e-02f, -2.02901941e-02f, -1.57929912e-01f, 1.23268142e-01f, 2.43620221e-02f, 2.05806196e-02f,
  6.59078881e-02f, -3.66668552e-02f, 6.51900694e-02f, 2.24533528e-02f, -1.72724780e-02f, 8.81575346e-02f, 3.58134732e-02f, -6.37813937e-03f, 4.41951193e-02f, -7.55234957e-02f,
  1.97976064e-02f, -2.00353283e-02f, -9.71146375e-02f, -2.85819527e-02f, 4.57008183e-02f, 1.13430163e-02f, 6.90961555e-02f, 7.18438476e-02f, 1.23960068e-02f, 1.35864969e-02f,
  4.11360711e-02f, 6.03904761e-03f, 4.49945219e-02f, -1.11700952e-01f, 8.55172798e-02f, 2.50571780e-02f, 3.26167829e-02f, 9.59352925e-02f, 3.23046185e-02f, -6.50840532e-03f,
  5.60701499e-03f, -3.29539552e-02f, 7.50521358e-05f, 2.90425830e-02f, -7.58791389e-03f, 4.08938751e-02f, 5.44115566e-02f, 6.22299388e-02f, 1.68403983e-02f, -2.50867195e-02f,
  3.85011956e-02f, -3.16947065e-02f, 6.22524843e-02f, 2.09204108e-02f, -2.84109563e-02f, -3.02619375e-02f, 3.59730832e-02f, -4.06431369e-02f, 7.48077333e-02f, 9.35148727e-03f,
  -3.35988239e-04f, -1.35078672e-02f, 1.30345970e-02f, 4.69277985e-02f, -1.17774308e-02f, -3.03122844e-03f, 4.58231103e-03f, 8.53457153e-02f, 5.55995442e-02f, 3.85583080e-02f,
  -9.26857740e-02f, -2.32162520e-01f, -2.49646157e-02f, -5.57892025e-03f, -7.17389286e-02f, 1.00393333e-01f, 5.35679981e-03f, 4.49519344e-02f, -8.96948576e-03f, 2.73411348e-02f,
  -4.68686260e-02f, 2.03119800e-03f, 3.05736605e-02f, 3.84609476e-02f, 2.93388925e-02f, 4.76201326e-02f, -7.58978277e-02f, 2.53431201e-02f, -6.71940669e-02f, -5.22886328e-02f,
  3.90073769e-02f, -7.81357195e-03f, -1.89880244e-02f, 6.89742938e-02f, -6.22016266e-02f, -4.21053618e-02f, 1.06787002e-02f, 3.06382366e-02f, -2.01531798e-02f, -4.12799492e-02f,
  -9.10813883e-02f, 2.37232953e-01f, -1.21440314e-01f, 1.47990793e-01f, -1.64760530e-01f, -2.20355508e-03f, 1.03411168e-01f, 2.75864992e-02f, 2.70052165e-01f, 1.65502310e-01f,
  9.21249464e-02f, -8.83738920e-02f, 1.69172928e-01f, 2.33980373e-01f, -1.22969942e-02f, 1.71055555e-01f, 1.26042411e-01f, 9.58208181e-03f, 5.71436547e-02f, 9.55711603e-02f,
  -4.48582619e-02f, 2.52634466e-01f, -3.51057365e-03f, 1.01312853e-01f, -8.49355981e-02f, -3.82600985e-02f, -1.64756365e-02f, -2.37968238e-03f, -3.40681225e-02f, -1.01221018e-01f,
  -6.07162490e-02f, 2.31306300e-01f, 4.71287519e-02f, 2.96531022e-02f, 1.35165900e-01f, -6.80074319e-02f, -7.81285018e-02f, -4.06749956e-02f, -5.18711917e-02f, -2.33905762e-02f,
  -4.65750061e-02f, -4.84384969e-03f, 3.34153809e-02f, 7.84908980e-02f, -1.44727416e-02f, -1.80791523e-02f, -1.06714964e-01f, -4.99655567e-02f, -1.96321551e-02f, -9.92328022e-03f,
  -4.95582446e-02f, -1.09545521e-01f, -9.41800773e-02f, -5.76599203e-02f, -4.84057516e-02f, -1.59356240e-02f, -3.72878499e-02f, -9.44324434e-02f, -6.99180067e-02f, 4.80888374e-02f,
  5.70991375e-02f, 4.59245667e-02f, 1.50898714e-02f, -5.61356284e-02f, 7.51992166e-02f, -3.64100896e-02f, -1.79778971e-02f, -2.10800469e-02f, -1.21844839e-02f, 8.56639370e-02f,
  -5.93105294e-02f, 2.48821732e-02f, 5.62778823e-02f, 1.05779702e-02f, 1.22436639e-02f, 4.52313125e-02f, -4.58352529e-02f, -2.26619234e-03f, -1.45693952e-02f, -2.63624564e-02f,
  1.32586733e-02f, -5.64433960e-03f, 8.13821107e-02f, -4.15584035e-02f, 1.94313098e-02f, 1.07008843e-02f, -2.54536662e-02f, -2.17803046e-02f, -2.54722927e-02f, -4.53942977e-02f,
  1.32440343e-01f, 2.29055911e-01f, 1.52750518e-02f, -5.54678366e-02f, 2.85654217e-02f, -2.14801077e-02f, 5.29895984e-02f, 1.96268838e-02f, 1.24654593e-02f, 8.90225172e-02f,
  -7.28568286e-02f, -7.80690014e-02f, -2.35372223e-02f, 1.04508065e-02f, -9.58867073e-02f, 3.08467280e-02f, 3.82289290e-02f, 2.12192368e-02f, -5.99368028e-02f, -2.75846813e-02f,
  3.87272574e-02f, 4.15112078e-02f, -3.88305844e-03f, -5.62339264e-04f, -8.71929303e-02f, -9.78336204e-03f, 9.57244076e-03f, 3.96652259e-02f, -1.86969880e-02f, -9.44440905e-03f,
  -4.04904693e-01f, 1.75535858e-01f, -2.16863528e-02f, -3.03323835e-01f, 7.69928610e-03f, 7.21066967e-02f, -6.41850382e-02f, -1.45044858e-02f, -1.29209921e-01f, 1.36310905e-01f,
  -1.70470610e-01f, 1.24392636e-01f, 1.42230401e-02f, -2.82000333e-01f, -2.97988445e-01f, -5.04969582e-02f, -2.45592818e-01f, -8.54244679e-02f, -6.33833185e-02f, -1.03463851e-01f,
  -9.83099490e-02f, -1.82761729e-01f, -1.09428890e-01f, 1.43984109e-01f, 2.95154937e-02f, 2.66931169e-02f, -5.20611703e-02f, 2.05935970e-01f, -1.59120671e-02f, 4.84431349e-02f,
  6.71881139e-02f, -5.31987175e-02f, 3.97193544e-02f, 1.17017739e-01f, -3.21798511e-02f, 1.38105629e-02f, 8.59683156e-02f, 8.74211779e-04f, 3.00186258e-02f, -5.77245019e-02f,
  1.39983036e-02f, 3.21924849e-03f, -5.27824163e-02f, -3.24146487e-02f, -2.04395480e-03f, 4.70707528e-02f, -1.91151500e-02f, 1.14220995e-02f, -1.06799342e-02f, -3.91988717e-02f,
  8.09944540e-05f, -7.79337510e-02f, -3.19617838e-02f, -3.90796550e-03f, -4.79049347e-02f, -6.13649078e-02f, 3.18318576e-04f, 1.03427470e-01f, 6.88131079e-02f, 3.19963098e-02f,
  -7.86941051e-02f, -1.00973956e-02f, -1.35188773e-02f, 9.67336725e-03f, -3.61780822e-02f, -2.96917688e-02f, -2.42051408e-02f, -2.21325327e-02f, 2.59582349e-03f, 6.62609236e-03f,
  -6.21059984e-02f, 3.30458805e-02f, -6.35121092e-02f, -2.52001751e-02f, 1.19063221e-02f, -3.81384939e-02f, 2.72834357e-02f, -3.74126360e-02f, -3.27538699e-02f, -1.81600880e-02f,
  4.22400758e-02f, 3.82195264e-02f, 7.33827055e-02f, 4.52025887e-03f, 5.64411245e-02f, -9.55798198e-03f, -3.23159918e-02f, 2.53591016e-02f, 2.55521219e-02f, -4.16105725e-02f,
  7.91504141e-03f, -7.03463480e-02f, 3.44671346e-02f, 1.89400353e-02f, 2.24860422e-02f, -2.99795344e-03f, -6.62929192e-02f, -3.73374149e-02f, 1.16742589e-01f, 2.93284263e-02f,
  2.20706109e-02f, -1.44234216e-02f, 5.33512868e-02f, -3.61285196e-03f, -6.52095452e-02f, -2.50199251e-02f, -2.59956308e-02f, 5.33608254e-03f, -2.93464609e-03f, -3.47790159e-02f,
  -1.10716950e-02f, 7.14606494e-02f, -4.69665490e-02f, -4.13013659e-02f, -4.31180745e-02f, 3.38308290e-02f, -3.43351178e-02f, -2.42693014e-02f, -8.93579200e-02f, -1.33376813e-03f,
  -3.22087556e-01f, 3.20808530e-01f, -3.34396750e-01f, -5.75569049e-02f, 1.41891584e-01f, 1.69053271e-01f, -1.09932413e-02f, 1.41499951e-01f, -1.55674562e-01f, 1.39099911e-01f,
  4.43039052e-02f, -9.80906934e-02f, -1.41735107e-01f, 2.79249907e-01f, -2.39630148e-01f, 3.32734585e-02f, 1.26858711e-01f, -4.97981235e-02f, -2.26023477e-02f, -1.96975898e-02f,
  -1.67252738e-02f, 1.65937617e-01f, -4.62885597e-04f, 2.08290130e-01f, 8.93375203e-02f, -7.01402426e-02f, -6.59400150e-02f, -6.11850396e-02f, 1.96514800e-01f, 2.77439859e-02f,
  6.11053705e-02f, -2.86036849e-01f, -5.37349358e-02f, -1.39711678e-01f, -1.19735055e-01f, -8.18204880e-02f, -6.36145845e-02f, -1.19513154e-01f, -4.22251150e-02f, 6.58298433e-02f,
  -2.83641834e-02f, 4.03238758e-02f, -8.41087603e-04f, -3.94510143e-02f, -9.33169387e-03f, -6.27082214e-02f, 8.04326683e-02f, 1.62584707e-01f, 4.83018309e-02f, 6.16210178e-02f,
  4.06820886e-02f, 8.18755627e-02f, -2.86805853e-02f, -4.15555909e-02f, 8.61338433e-03f, 9.84389707e-03f, 1.73519421e-02f, 2.23268270e-02f, 2.96467147e-03f, 5.23979366e-02f,
  -3.77947018e-02f, -8.66406187e-02f, 2.57418323e-02f, -2.56489031e-02f, -8.60509053e-02f, -4.86175122e-04f, -1.14763984e-02f, 1.02323378e-02f, -9.90036353e-02f, 4.48674429e-04f,
  1.22750558e-01f, -4.69372608e-02f, 1.98056251e-02f, -2.54222304e-02f, 3.10138520e-02f, -6.63659861e-03f, -4.58138175e-02f, -7.37087661e-03f, 8.12153425e-03f, 3.91582437e-02f,
  2.85633020e-02f, 4.65596328e-04f, 5.77066443e-04f, -6.60454668e-03f, 3.79926711e-02f, -3.47642191e-02f, -3.60323861e-02f, 1.18547246e-01f, -5.62928105e-03f, -7.07969293e-02f,
  -9.03368369e-02f, -2.12035358e-01f, -1.51796476e-03f, 6.31401837e-02f, 1.46000283e-02f, 1.16755761e-01f, 2.22039111e-02f, 5.37580065e-02f, -2.95205228e-02f, -9.89968330e-02f,
  -4.62980047e-02f, -2.16039773e-02f, -1.90081112e-02f, 2.64313594e-02f, 8.43680929e-03f, 3.15231681e-02f, 1.03473794e-02f, -5.11137582e-02f, -3.66778784e-02f, 4.08071727e-02f,
  8.77741259e-03f, -3.28324325e-02f, -2.42075939e-02f, 2.53377389e-02f, -3.60499285e-02f, 6.91893324e-02f, -6.53888062e-02f, 3.74375954e-02f, -1.54610060e-03f, -2.12707184e-03f,
  -3.80944490e-01f, -5.14301546e-02f, 3.29139382e-02f, -8.58966634e-02f, -4.99701984e-02f, -1.49257481e-01f, -1.96877971e-01f, -1.12626821e-01f, -2.57737428e-01f, 8.15116093e-02f,
  -3.31520028e-02f, -5.98755032e-02f, -4.64705899e-02f, -3.54640819e-02f, 2.05214974e-02f, 1.84726462e-01f, -2.51514595e-02f, -6.39464781e-02f, -2.68682055e-02f, -5.64394556e-02f,
  -3.53340209e-02f, -9.60777923e-02f, 1.40909210e-01f, -3.60145643e-02f, -2.02892512e-01f, 5.61271384e-02f, 1.72461256e-01f, 4.36609015e-02f, 1.59161642e-01f, 5.52869495e-03f,
  -1.73712179e-01f, -2.15948924e-01f, -3.33910733e-02f, -6.62863329e-02f, -1.93637609e-02f, 5.56927249e-02f, -2.62265038e-02f, -4.62052785e-02f, 4.60306294e-02f, -8.42773914e-02f,
  -3.96379493e-02f, -8.90642330e-02f, 1.20763648e-02f, 2.23967750e-02f, -6.17226213e-03f, 2.27844976e-02f, 3.37633081e-02f, 2.80416161e-02f, -1.13033615e-01f, -1.52648902e-02f,
  4.52704020e-02f, 2.24024355e-02f, 6.33454770e-02f, 1.62975676e-02f, 9.53307003e-02f, -1.91091318e-02f, 1.04966998e-01f, 2.30100136e-02f, 2.66445242e-02f, -1.72385499e-02f,
  -5.12088761e-02f, -2.93338522e-02f, 4.09335494e-02f, -3.00679659e-03f, -4.55914624e-02f, 5.29955933e-03f, 4.19082791e-02f, -2.05220059e-02f, 7.25127310e-02f, -6.37159124e-02f,
  -2.32450552e-02f, -3.81048806e-02f, -4.96592410e-02f, 3.37942243e-02f, 2.29652282e-02f, -5.09210937e-02f, 5.48345745e-02f, -2.93292310e-02f, -7.60871843e-02f, 3.40486355e-02f,
  -6.56565577e-02f, -9.58044827e-03f, -5.52461483e-02f, -4.37274314e-02f, -5.26921898e-02f, 3.28509100e-02f, 4.07874994e-02f, 4.86969166e-02f, -8.74108225e-02f, 5.80745526e-02f,
  -1.34768542e-02f, 8.03958252e-02f, -6.54891040e-03f, -5.39897159e-02f, 1.22966664e-02f, -9.13515314e-03f, 9.64034200e-02f, 1.32698733e-02f, -2.53158119e-02f, -5.67936432e-03f,
  3.30836922e-02f, 4.18332331e-02f, 4.92316782e-02f, -2.87114382e-02f, -1.05776852e-02f, -3.41144465e-02f, -2.28656027e-02f, -6.51826039e-02f, 1.12619773e-02f, 5.04773520e-02f,
  1.00017497e-02f, -5.66474982e-02f, 3.76736373e-02f, -1.23022273e-02f, -6.21466897e-02f, -3.48777231e-03f, -4.62787561e-02f, -1.38228759e-02f, 8.18690583e-02f, 3.84652130e-02f,
  4.25213486e-01f, -1.65721714e-01f, -1.21590272e-01f, 9.28340256e-02f, 1.55090988e-01f, -1.42202854e-01f, -6.34845346e-02f, 4.49324287e-02f, 2.33238980e-01f, -1.74763232e-01f,
  4.26237434e-02f, -9.26323682e-02f, -1.19836302e-02f, -1.14025943e-01f, 2.44220674e-01f, 6.22839928e-02f, -1.03163151e-02f, -1.41227782e-01f, 9.03132278e-03f, 8.12392011e-02f,
  1.23814739e-01f, 1.34408712e-01f, 4.74520177e-02f, 8.28295127e-02f, -5.55386730e-02f, -1.11118048e-01f, -3.57268490e-02f, -6.47751316e-02f, -9.57524404e-02f, 3.20785046e-02f,
  -4.44248058e-02f, -1.53157264e-02f, -2.38200873e-02f, -1.19020650e-02f, -6.70488030e-02f, -4.84452881e-02f, -9.21614841e-02f, -6.17717952e-02f, 2.27321051e-02f, 1.61966644e-02f,
  -7.67022222e-02f, 4.43150885e-02f, -1.39801046e-02f, -1.63936429e-02f, 4.94480729e-02f, 1.39767528e-02f, 1.29279373e-02f, -2.51849219e-02f, -3.07182111e-02f, 1.85584789e-03f,
  2.16559917e-02f, -5.20742871e-02f, -2.39203256e-02f, -9.61577222e-02f, 3.47255580e-02f, 4.64883596e-02f, -1.70409475e-02f, -4.63717245e-02f, 5.38894848e-04f, -2.55345292e-02f,
  -3.32677811e-02f, -3.41682546e-02f, 2.10146978e-03f, -6.17593005e-02f, 6.65330812e-02f, 2.03568060e-02f, 1.81920687e-03f, -2.86937542e-02f, -4.84382883e-02f, -7.09924102e-02f,
  1.73528567e-02f, -5.55819646e-03f, 3.09059806e-02f, 2.12184321e-02f, 1.22213233e-02f, 3.45318485e-03f, -4.43511875e-03f, -2.79741678e-02f, -5.76680303e-02f, -5.63339032e-02f,
  1.98451593e-03f, 1.18611706e-03f, -4.36464623e-02f, -1.20576449e-01f, 1.00054042e-02f, 7.62680173e-02f, 2.49160603e-02f, 1.13426463e-03f, 1.76774780e-03f, -2.54106000e-02f,
  -1.04054898e-01f, -1.49968211e-02f, 3.34559232e-02f, -2.15400904e-02f, -5.00032455e-02f, 2.59862444e-03f, -1.33269271e-02f, -6.07707212e-03f, 5.80366142e-02f, 1.26863401e-02f,
  7.91274011e-03f, -5.10830916e-02f, -9.29224072e-04f, 4.17811237e-02f, -5.36617152e-02f, 6.00543385e-03f, 4.08129580e-03f, 1.01575134e-02f, 3.91237363e-02f, 2.21395362e-02f,
  6.04049396e-03f, 2.50646956e-02f, -1.48906419e-02f, 7.90803507e-02f, -2.95424480e-02f, -2.79877335e-02f, 3.09381224e-02f, 4.81192907e-03f, -5.75540736e-02f, -6.12642616e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.99190247e-01f, 3.24411482e-01f, 2.74011921e-02f, -2.17495278e-01f, 2.29786158e-01f, -2.84963816e-01f, -6.84026033e-02f, 2.45637834e-01f, -6.34910837e-02f, 1.87423989e-01f,
  -1.37588307e-01f, 8.88196900e-02f, 1.09292008e-01f, -2.25280508e-01f, -3.81131798e-01f, -2.43767977e-01f, -3.41583252e-01f, -1.76939607e-01f, -3.51462476e-02f, -9.00173783e-02f,
  -1.88418746e-01f, -4.40118350e-02f, -1.72471121e-01f, 1.87891334e-01f, 1.79327279e-01f, 2.28063732e-01f, -1.29607394e-01f, 2.85513788e-01f, -2.43780203e-02f, 5.87994196e-02f,
  -2.35021841e-02f, 1.31136090e-01f, 1.90730557e-01f, 1.30388379e-01f, -8.24379623e-02f, 3.16096395e-02f, -6.52108639e-02f, 1.94852557e-02f, -4.34380695e-02f, 2.42110007e-02f,
  7.52849430e-02f, -3.96543965e-02f, -1.40678417e-02f, 1.06562627e-02f, 1.28880531e-01f, 8.17958713e-02f, -4.64397557e-02f, 3.76962572e-02f, 6.26352653e-02f, -3.89125757e-02f,
  -4.41753939e-02f, 1.08346557e-02f, -6.82371929e-02f, -8.20342451e-02f, -4.51556109e-02f, 8.11255649e-02f, 1.16847986e-02f, 4.82623130e-02f, 4.74153645e-03f, -4.85413149e-02f,
  7.90660754e-02f, -6.07979577e-03f, 1.01784796e-01f, 2.20645014e-02f, 1.60633083e-02f, 1.10606670e-01f, 5.77328205e-02f, -7.99572244e-02f, 8.48744959e-02f, 4.84109037e-02f,
  -1.24428138e-01f, 1.03314728e-01f, 4.86870445e-02f, -1.24950960e-01f, -1.06006473e-01f, 4.29784581e-02f, 2.82773804e-02f, 2.08738446e-03f, -8.57568979e-02f, -6.12973142e-03f,
  9.39414203e-02f, -3.10913920e-02f, -6.42869109e-03f, -1.61376428e-02f, -5.11727221e-02f, 2.27198210e-02f, -3.75508256e-02f, -3.07072215e-02f, -1.46973766e-02f, -2.85945851e-02f,
  -2.09209681e-01f, -7.55020157e-02f, -1.45014618e-02f, 1.02675237e-01f, 4.28538322e-02f, -5.02924472e-02f, -4.83053317e-03f, -1.55340070e-02f, -9.20379981e-02f, 1.08213499e-02f,
  -3.42017822e-02f, 6.90437630e-02f, -8.25858414e-02f, -2.98807342e-02f, 1.95397586e-02f, -1.54268160e-01f, -2.94277687e-02f, -3.27621549e-02f, 5.18487617e-02f, -1.28117055e-02f,
  9.51857492e-03f, -1.25701269e-02f, 8.40599984e-02f, 2.22783685e-02f, -2.28072405e-02f, -1.58949811e-02f, 6.26672581e-02f, 1.92626994e-02f, -3.91705856e-02f, 6.80644214e-02f,
  2.94720791e-02f, 2.14261740e-01f, 1.83510900e-01f, 2.79001653e-01f, -6.32845983e-02f, -2.47093588e-01f, -1.89678818e-01f, 2.70514488e-01f, -7.72603303e-02f, -1.46871313e-01f,
  -7.25364760e-02f, 6.02006279e-02f, 4.51399125e-02f, 1.75890043e-01f, -1.94845244e-01f, -2.72147775e-01f, 3.61633562e-02f, -1.91585198e-01f, -1.49364313e-02f, 1.36302516e-01f,
  7.16185570e-02f, 1.25335455e-01f, 3.14866036e-01f, 2.63456404e-01f, 1.37691960e-01f, 2.48939723e-01f, 2.29528949e-01f, 1.39417738e-01f, 1.40668839e-01f, -1.07588142e-01f,
  -1.96577013e-01f, 3.99383642e-02f, 6.93996111e-03f, -8.13110918e-02f, 5.58431372e-02f, -6.85760379e-03f, -1.05667733e-01f, -1.20665401e-01f, -7.24630132e-02f, -3.11106369e-02f,
  -6.22043610e-02f, -4.00265492e-03f, 5.13151251e-02f, -1.19686745e-01f, 1.49870571e-02f, 3.74041237e-02f, 4.08548899e-02f, 2.47890018e-02f, 4.11293842e-02f, 4.08715121e-02f,
  7.07244202e-02f, -5.54177575e-02f, 9.31312889e-02f, -1.69469431e-01f, 6.10596547e-03f, 7.63673708e-02f, -5.51765505e-03f, 3.38828750e-02f, 4.20148745e-02f, 1.24918282e-01f,
  -1.53577852e-03f, 8.17116275e-02f, 6.33313954e-02f, 7.94873461e-02f, 1.40218483e-02f, -3.37325558e-02f, 6.98559079e-03f, 1.34499269e-02f, 2.07740385e-02f, -2.38974541e-02f,
  7.77167082e-02f, 1.00759730e-01f, -9.19006951e-03f, -3.26668508e-02f, 6.53780997e-02f, -4.23107791e-04f, 1.01847343e-01f, -9.86384451e-02f, -4.78762276e-02f, -2.64512300e-02f,
  -6.89486414e-02f, 4.03432036e-03f, 6.79529980e-02f, -4.46245633e-02f, -9.78340507e-02f, -5.76012395e-03f, 6.66946396e-02f, 2.38454249e-02f, 5.37028238e-02f, 3.39357927e-02f,
  1.90107152e-02f, 1.19199552e-01f, 3.36348079e-02f, -1.04711525e-01f, 4.65142243e-02f, 4.17398196e-03f, -1.43979145e-02f, 5.00321239e-02f, -7.15371175e-03f, -6.89104721e-02f,
  8.48882347e-02f, -7.53111541e-02f, -5.20240217e-02f, -5.96170351e-02f, -2.48694420e-02f, -4.77871075e-02f, 6.46511419e-03f, 8.49072784e-02f, 1.37928054e-01f, 4.95863184e-02f,
  4.42103222e-02f, -4.52274904e-02f, 1.41528577e-01f, 5.38554676e-02f, -3.35177518e-02f, -4.97807376e-02f, 6.60885721e-02f, -4.34413319e-03f, 9.47397947e-02f, -8.17601606e-02f,
  -5.16326189e-01f, 3.89636457e-01f, 2.34353259e-01f, -1.63622111e-01f, -6.19109254e-03f, 4.84650165e-01f, 1.61899880e-01f, 2.29614615e-01f, 2.07238615e-01f, 1.68599844e-01f,
  -1.17083505e-01f, 4.29035202e-02f, 8.87716748e-03f, 5.72906137e-02f, -1.30269749e-04f, 1.90267369e-01f, 1.91460684e-01f, 6.31217659e-02f, 3.72213908e-02f, -1.00141630e-01f,
  -1.23186901e-01f, -1.41102657e-01f, -2.15166565e-02f, 4.10770364e-02f, -1.61504611e-01f, -7.47478381e-02f, -3.15049946e-01f, -9.90647450e-02f, -1.02633588e-01f, 2.63903774e-02f,
  5.90866618e-02f, 7.09029473e-03f, 6.12921938e-02f, 1.78571448e-01f, 1.84498560e-02f, 3.74786370e-02f, -3.84172313e-02f, -6.38411790e-02f, -2.84151044e-02f, 6.29868805e-02f,
  -9.25199091e-02f, 1.57507211e-01f, 5.10862619e-02f, -9.16847363e-02f, -5.60204079e-03f, 7.56951272e-02f, 9.99065787e-02f, 2.02725530e-02f, 1.32704556e-01f, 1.13347456e-01f,
  2.88580861e-02f, 9.79522243e-02f, -6.62993640e-02f, 4.29135785e-02f, -3.39566320e-02f, 8.32614154e-02f, 1.12753529e-02f, -7.23295426e-03f, 1.29955038e-01f, 1.45289665e-02f,
  -7.49216154e-02f, 7.77227581e-02f, 6.79068789e-02f, -1.56258103e-02f, -3.74138681e-03f, -9.27159563e-02f, -5.53164221e-02f, -5.25048859e-02f, 2.38974895e-02f, -2.05660220e-02f,
  -2.20461898e-02f, 8.12018961e-02f, 7.83819184e-02f, 6.37086332e-02f, -1.31643295e-01f, -4.39558439e-02f, -1.12587027e-01f, -6.93572164e-02f, -7.90771991e-02f, -1.66451242e-02f,
  -4.15309519e-02f, 3.02133877e-02f, 4.50156257e-02f, -1.13839403e-01f, 1.97422832e-01f, 8.93226918e-03f, 2.91903131e-02f, 4.01830627e-03f, -7.34290108e-02f, -3.36761698e-02f,
  2.36237645e-01f, 2.17309177e-01f, 1.17491908e-01f, 1.39110550e-01f, 7.21551403e-02f, 2.33607972e-03f, 1.03200831e-01f, 8.13031793e-02f, -1.50338216e-02f, 1.06846794e-01f,
  4.87105511e-02f, 2.82605533e-02f, -6.37460575e-02f, -9.13060457e-02f, 2.36368608e-02f, 1.62593126e-01f, -1.31979063e-01f, -1.06968872e-01f, -2.81993225e-02f, 4.30818610e-02f,
  -7.54189715e-02f, -2.00324412e-02f, -3.74502502e-02f, 3.25847678e-02f, 1.59819536e-02f, -5.37105799e-02f, -9.26060323e-03f, 6.25202581e-02f, 2.92178746e-02f, -3.65781225e-02f,
  -6.01169348e-01f, -2.61850562e-02f, 3.44355911e-01f, -3.18848401e-01f, -1.94737971e-01f, 2.55940706e-01f, 2.66388983e-01f, -5.67994220e-03f, -2.93537408e-01f, -8.23528096e-02f,
  -1.90092996e-02f, -1.69673949e-01f, 2.70388097e-01f, -4.80404794e-02f, 2.44562864e-01f, 3.10653955e-01f, 5.69628701e-02f, 4.50605564e-02f, -5.95410280e-02f, -1.10293061e-01f,
  -4.37153876e-02f, -6.42594919e-02f, 2.17988461e-01f, -1.81537956e-01f, -9.70987529e-02f, -1.23398311e-01f, -1.29259616e-01f, -5.03627537e-03f, -1.76414922e-01f, 3.08361016e-02f,
  -8.09170008e-02f, -1.73146859e-01f, 4.52499799e-02f, 1.49979040e-01f, 1.45108206e-03f, 7.88526908e-02f, 9.23841298e-02f, 6.00659549e-02f, -4.18631881e-02f, -9.38776322e-03f,
  -1.83366034e-02f, -4.56698649e-02f, -2.02183172e-01f, 8.42331201e-02f, -1.17461920e-01f, -3.90062779e-02f, -1.69321783e-02f, 8.53877291e-02f, -9.63490363e-03f, 7.86809400e-02f,
  1.77772492e-01f, 1.06198467e-01f, 7.05037778e-03f, -7.02661855e-05f, 3.09215486e-02f, -2.19779238e-02f, 1.22458220e-01f, 1.42944351e-01f, 3.14520933e-02f, -8.26491937e-02f,
  2.75676008e-02f, -5.37973493e-02f, 3.30824591e-02f, -5.53142391e-02f, -7.30203986e-02f, -8.17471594e-02f, -4.94602174e-02f, 3.13882753e-02f, -6.17856868e-02f, 4.33107093e-02f,
  -9.39606503e-02f, 4.45994996e-02f, 3.75237353e-02f, 6.21818230e-02f, -2.75627468e-02f, -1.02538086e-01f, 4.57150526e-02f, -2.44379062e-02f, -6.07000291e-02f, -3.18705365e-02f,
  -9.67749283e-02f, -1.14035970e-02f, -2.91718375e-02f, 7.63204470e-02f, 1.94897465e-02f, 1.21706210e-01f, -9.05191079e-02f, 2.79019624e-02f, -3.13703000e-04f, 1.22280987e-02f,
  -1.21045195e-01f, -3.32902521e-01f, 2.35932674e-02f, -7.52466321e-02f, 5.35998084e-02f, 1.07174113e-01f, 5.87336235e-02f, -2.75251083e-03f, -6.81927949e-02f, 5.27313612e-02f,
  -7.06227049e-02f, 6.18024878e-02f, 4.72730631e-03f, -5.45660928e-02f, -1.12218130e-02f, 4.08034399e-02f, -6.31285086e-02f, -3.21768112e-02f, -4.40383097e-03f, -1.12553686e-01f,
  -7.81244636e-02f, -8.78467634e-02f, 9.35636312e-02f, 1.79867223e-02f, -3.04726331e-04f, -9.76007357e-02f, -1.55762777e-01f, -4.19676956e-03f, -3.18052107e-03f, 9.57429688e-03f,
  2.90905863e-01f, -1.30385518e-01f, -5.45990877e-02f, 2.01702178e-01f, 2.29316264e-01f, 2.79089481e-01f, 4.27183867e-01f, -6.31469814e-03f, 2.35029191e-01f, -7.84066096e-02f,
  6.71309829e-02f, 1.47926897e-01f, 1.92408100e-01f, 8.06090049e-03f, 3.78275335e-01f, 1.70286983e-01f, 2.37042710e-01f, 2.03389540e-01f, 5.55368215e-02f, 7.22466856e-02f,
  6.26910254e-02f, 1.50226122e-02f, -1.39337152e-01f, -2.96356857e-01f, 4.72299755e-02f, -3.13534349e-01f, -2.19199821e-01f, 2.80892625e-02f, -2.13066354e-01f, 1.73088729e-01f,
  4.14889231e-02f, -6.29030913e-02f, 8.77045766e-02f, -6.85931519e-02f, 5.50003722e-02f, 5.07821180e-02f, 6.34205192e-02f, 1.68345273e-02f, 4.00446728e-02f, 1.98899247e-02f,
  -3.22842374e-02f, 8.43745563e-03f, -9.86752585e-02f, -2.93396972e-02f, -1.22532519e-02f, -9.65862423e-02f, -2.86434554e-02f, 2.86222678e-02f, -4.65294756e-02f, -2.23165154e-02f,
  1.00989588e-01f, -7.08377808e-02f, 1.27512664e-01f, -9.77765471e-02f, -2.45950986e-02f, -2.91375048e-03f, -3.90716679e-02f, 1.54149696e-01f, -5.95742017e-02f, -8.70548468e-03f,
  1.03160122e-03f, 1.30835444e-01f, 6.18589781e-02f, -1.89334191e-02f, -4.60316800e-02f, -1.59500584e-01f, 1.11361062e-02f, -9.76337492e-02f, 1.57289118e-01f, 5.04344404e-02f,
  -5.84299676e-02f, -3.13970097e-03f, 4.89182677e-03f, 1.08950194e-02f, 3.51686147e-03f, 6.03838600e-02f, 1.14072315e-01f, -2.08912995e-02f, 5.36857545e-02f, 3.24161015e-02f,
  8.82002432e-03f, 1.27490371e-01f, 5.24243980e-04f, -1.19468145e-01f, 1.94167979e-02f, 1.56296361e-02f, -1.47958428e-01f, 3.05874050e-02f, -1.28105536e-01f, 1.65990129e-01f,
  5.43791540e-02f, 9.39449370e-02f, 7.28729442e-02f, -3.20850909e-02f, -8.97498503e-02f, -5.52432537e-02f, 9.49536338e-02f, 3.90438326e-02f, 3.72924507e-02f, -2.10487400e-03f,
  -8.37260112e-02f, 9.94651467e-02f, -4.26903702e-02f, -1.66413467e-02f, -7.91485906e-02f, -7.11675584e-02f, -3.77318375e-02f, 3.69367376e-02f, -6.79116556e-03f, -8.54443014e-02f,
  2.64530513e-03f, 3.82137634e-02f, 3.97379845e-02f, -5.33896349e-02f, -6.10917285e-02f, 7.69829452e-02f, -3.00378855e-02f, -2.92772730e-03f, 1.29747530e-03f, 1.12836912e-01f,
  1.13019444e-01f, -2.45081246e-01f, 6.15298823e-02f, 3.01618516e-01f, 2.53410727e-01f, 3.11901383e-02f, 2.30537113e-02f, -2.06574634e-01f, -3.30635577e-01f, -1.65411562e-01f,
  7.17705414e-02f, 2.69801378e-01f, -2.67714113e-01f, 1.64341688e-01f, 2.39551023e-01f, -3.52386266e-01f, 1.23043098e-01f, 1.77591905e-01f, -1.95750773e-01f, 1.18932361e-02f,
  -1.37168571e-01f, 1.09988926e-02f, 4.17613843e-03f, -7.31664374e-02f, 2.01594848e-02f, 2.10200727e-01f, 3.41993272e-01f, 1.68683335e-01f, 3.46425831e-01f, 2.00352237e-01f,
  -5.01725897e-02f, -1.41849592e-01f, 4.31535468e-02f, -9.97766387e-03f, -1.23467892e-01f, 7.63108060e-02f, 1.69299155e-01f, 1.90120354e-01f, 2.36808226e-01f, -3.74410003e-02f,
  3.48717086e-02f, 4.79211919e-02f, -9.25368369e-02f, 4.84874249e-02f, 4.00148425e-03f, -4.35351543e-02f, -9.97788981e-02f, -4.89784777e-02f, -2.54412903e-03f, -9.23178717e-02f,
  -5.63111305e-02f, -1.22161739e-01f, -2.63213199e-02f, 4.29556221e-02f, 7.65039772e-02f, 6.13359399e-02f, 4.85169403e-02f, 2.47645639e-02f, 4.90021287e-03f, 3.53876911e-02f,
  -9.32001472e-02f, -5.95115982e-02f, -7.14784190e-02f, 2.72061094e-03f, 1.02232676e-02f, 7.01858327e-02f, -6.18150346e-02f, -3.50306220e-02f, 1.21429302e-02f, -1.38353914e-01f,
  7.72469342e-02f, -3.42218578e-02f, -2.20249500e-02f, 8.35144427e-03f, -8.78448635e-02f, -1.14744417e-01f, 6.04258701e-02f, 1.31737277e-01f, 8.43453873e-03f, -8.60069543e-02f,
  2.74883378e-02f, 7.75186857e-03f, 6.40364662e-02f, 3.95713467e-03f, -5.81267662e-02f, 1.11380778e-01f, 4.28313278e-02f, 3.12277190e-02f, 1.96567681e-02f, -4.15645154e-05f,
  -5.24098799e-02f, -4.47136126e-02f, 3.50785442e-02f, 1.57354653e-01f, 8.88787806e-02f, -5.37210070e-02f, 6.62092073e-03f, -7.22032860e-02f, 9.96008366e-02f, -1.04486912e-01f,
  5.97268976e-02f, 1.13906823e-01f, -4.61725146e-02f, 2.14228988e-01f, 8.34498778e-02f, -1.97507907e-02f, 4.62523475e-02f, 7.23246038e-02f, -2.91553903e-02f, 7.32153580e-02f,
  1.46501914e-01f, 5.40733561e-02f, 3.28923413e-03f, 1.07497061e-02f, 7.17992187e-02f, -9.87648889e-02f, 4.35300618e-02f, 1.10567221e-02f, -2.38367599e-02f, -2.50183418e-03f,
  9.21695903e-02f, -4.44589496e-01f, 1.33895516e-01f, 6.75373450e-02f, 2.45910838e-01f, 2.62318999e-01f, 2.72833884e-01f, -6.31975755e-02f, -1.75744742e-01f, -3.18539888e-01f,
  -8.14465582e-02f, -1.42111583e-02f, -8.89156833e-02f, 1.11352585e-01f, 3.51169467e-01f, -1.64073676e-01f, 5.34846485e-02f, 1.87282842e-02f, -2.69145938e-03f, -6.30370602e-02f,
  1.54770643e-01f, 1.37694582e-01f, 2.35187560e-01f, 3.47632207e-02f, 2.36806110e-01f, 1.58597216e-01f, 2.44864337e-02f, 2.48502135e-01f, 2.21315846e-01f, 1.81446224e-01f,
  -2.70117402e-01f, -3.07046771e-01f, -1.43447593e-01f, 3.48802214e-03f, -2.42876709e-02f, 1.72004253e-02f, -5.26550300e-02f, 1.80505112e-01f, 1.25811202e-02f, -1.14289746e-02f,
  -5.98912686e-02f, 2.66098082e-02f, 6.05738685e-02f, 5.62869534e-02f, -6.96404185e-03f, 6.87143281e-02f, -2.35157125e-02f, -2.72683743e-02f, -7.27461949e-02f, -2.99688522e-02f,
  -4.12473269e-02f, 2.12607207e-03f, -8.99449959e-02f, 9.22721252e-02f, -8.54941681e-02f, -7.87291210e-03f, -1.93556715e-02f, 9.23723448e-03f, 6.98310090e-03f, -8.87048617e-03f,
  1.01470746e-01f, 2.22383738e-02f, -9.40873325e-02f, -4.67960797e-02f, -4.40770574e-02f, 9.69709307e-02f, 3.40067707e-02f, -5.94143271e-02f, 2.79998034e-02f, 4.47605699e-02f,
  -5.36873192e-02f, -4.59194593e-02f, -3.12533863e-02f, -1.20954067e-01f, -4.78475653e-02f, -8.53462368e-02f, 6.96046054e-02f, 2.25072410e-02f, -2.92927716e-02f, -1.45863714e-02f,
  -6.51622638e-02f, 1.34407291e-02f, 5.15794789e-04f, 7.78860450e-02f, 1.07904281e-02f, -8.46199691e-03f, -1.70431808e-01f, 3.33016030e-02f, -4.17347960e-02f, 4.83670346e-02f,
  -5.08203804e-01f, -4.62389529e-01f, -4.31962647e-02f, -7.77688846e-02f, -7.20185116e-02f, -1.12676553e-01f, 4.40020440e-03f, -8.24076906e-02f, -1.50503814e-01f, -4.38663363e-02f,
  -5.38144223e-02f, 1.41057745e-02f, -3.93934250e-02f, 3.10071781e-02f, -9.89357475e-03f, -1.23245127e-01f, -1.45167097e-01f, -1.15910880e-01f, 1.49894264e-02f, -1.23008125e-01f,
  -3.58801782e-02f, -7.52752349e-02f, 4.33469862e-02f, 2.74121147e-02f, 9.39880311e-03f, 1.18637204e-01f, -7.11403787e-02f, 4.73598428e-02f, 1.56206861e-01f, -8.46704990e-02f,
  -4.04457420e-01f, 4.63494390e-01f, -2.38953438e-02f, -3.99131589e-02f, 6.19824678e-02f, 3.02599818e-01f, 2.38376424e-01f, 3.15242231e-01f, 2.96594262e-01f, 5.55942692e-02f,
  -2.09479749e-01f, -6.32086769e-02f, 4.96770479e-02f, -1.12601623e-01f, 1.73610285e-01f, 2.83134758e-01f, 1.86042681e-01f, 1.70946211e-01f, 2.53983468e-01f, -1.85411260e-01f,
  1.10459663e-01f, -2.16899604e-01f, -2.19230622e-01f, -7.98535794e-02f, -2.27675334e-01f, -1.04128800e-01f, -3.33235621e-01f, -2.27940455e-02f, -1.26241654e-01f, 1.06278673e-01f,
  -5.93468286e-02f, -1.40917495e-01f, -3.73426914e-01f, -8.90304074e-02f, -1.47969216e-01f, -5.14949597e-02f, -1.80179849e-02f, -6.67732023e-03f, 2.82498659e-03f, 9.55563933e-02f,
  -5.48578538e-02f, -9.62950438e-02f, -8.18722881e-03f, 6.28077309e-04f, 1.43137798e-01f, -1.26624987e-01f, -7.36090690e-02f, -7.93263465e-02f, -3.21455523e-02f, -5.06914966e-02f,
  -1.43359870e-01f, 7.98712447e-02f, -1.59171358e-01f, 1.30317762e-01f, -1.07129797e-01f, 7.56293396e-03f, 1.26880765e-01f, -2.06214376e-02f, 1.84903741e-02f, 4.11787033e-02f,
  1.96715556e-02f, 5.62121719e-02f, -8.81843716e-02f, -9.51794609e-02f, 7.60096684e-02f, 1.92108359e-02f, -2.93043479e-02f, -4.16070372e-02f, 5.51878428e-03f, -1.11967847e-01f,
  -1.19939439e-01f, -7.47846961e-02f, -6.05159290e-02f, -1.82847623e-02f, -1.68418232e-02f, -2.24423315e-02f, -6.55015856e-02f, 1.10171959e-02f, 7.32829869e-02f, -9.36663300e-02f,
  5.14995195e-02f, 7.23437592e-02f, -1.56435624e-01f, -1.00150101e-01f, -3.16970125e-02f, 2.83954246e-03f, -1.35310173e-01f, 1.25585413e-02f, -1.08473167e-01f, -6.38134032e-02f,
  2.24822208e-01f, 1.83075413e-01f, -1.34397149e-01f, -1.51347980e-01f, -6.67523146e-02f, -4.44972329e-03f, -2.18753722e-02f, -2.86655035e-02f, 8.77825022e-02f, -7.92037100e-02f,
  3.35393362e-02f, -8.50081518e-02f, -1.68829784e-02f, 6.10757247e-02f, 1.22098543e-01f, 9.38815102e-02f, 4.62192297e-02f, 1.39526963e-01f, 5.38996980e-02f, -3.23806703e-02f,
  -2.05375656e-01f, 7.97503367e-02f, -5.26967458e-03f, -9.59352553e-02f, -3.35968509e-02f, -1.99675277e-01f, 9.59371496e-03f, -2.92883664e-02f, 9.45107837e-04f, 9.53836441e-02f,
  -1.12763658e-01f, 1.92550123e-01f, -3.93308520e-01f, -1.73895881e-01f, 2.19110250e-02f, 2.14739054e-01f, 1.17044084e-01f, -6.11073263e-02f, 4.28847671e-02f, 2.67644972e-01f,
  1.00516928e-02f, -2.81732846e-02f, -9.53235105e-02f, 8.31883401e-02f, 4.57111448e-02f, 3.18156630e-02f, 2.42971614e-01f, 9.75604579e-02f, -2.67211329e-02f, 9.23511237e-02f,
  -8.85635763e-02f, 2.70021826e-01f, -2.11595222e-01f, 1.14686497e-01f, 3.31593603e-02f, -2.47700170e-01f, 1.91710308e-01f, -2.23053396e-01f, 3.44522111e-02f, -9.88398790e-02f,
  1.63735449e-02f, 4.19104844e-03f, -1.60224825e-01f, -1.05275288e-01f, -1.50350379e-02f, -5.39014637e-02f, -8.66174549e-02f, -2.02157885e-01f, -1.75912291e-01f, -2.38597859e-02f,
  3.85779552e-02f, -7.86357969e-02f, 6.78060800e-02f, 5.84849063e-03f, 1.03669465e-01f, 1.02242872e-01f, 1.00285634e-02f, -6.72128424e-02f, -3.64044048e-02f, -1.28382549e-01f,
  -3.58918048e-02f, 6.87502930e-03f, -2.98410878e-02f, 7.81744439e-03f, -5.42743653e-02f, 5.75425439e-02f, 5.78844063e-02f, -6.89651594e-02f, 2.51079947e-01f, 1.18476093e-01f,
  3.69245820e-02f, 7.98038468e-02f, 6.35065883e-02f, 3.19917984e-02f, -3.69074382e-02f, -8.88501927e-02f, 8.38169158e-02f, -2.07643732e-02f, -4.16336805e-02f, 1.58300817e-01f,
  5.45001999e-02f, -4.09476385e-02f, 5.89265069e-03f, -4.90200594e-02f, 8.31568539e-02f, -1.67096648e-02f, -1.21601611e-01f, 4.91551049e-02f, 3.42635401e-02f, 2.96139568e-02f,
  -1.37806386e-01f, 1.29094884e-01f, 7.88386352e-03f, 2.95679644e-02f, -9.89081990e-03f, -1.54034272e-02f, 1.15901671e-01f, 3.86266038e-02f, 8.18803906e-02f, -9.58598703e-02f,
  8.34318697e-02f, 3.33188891e-01f, -4.98737060e-02f, 6.41464591e-02f, 1.06787728e-03f, 9.76049677e-02f, 3.45161743e-02f, 1.00730490e-02f, 1.73121765e-02f, 6.39707670e-02f,
  1.97272878e-02f, -1.27995946e-02f, 1.75810218e-01f, 5.14059179e-02f, 1.85812020e-03f, 1.63031891e-01f, 4.40925956e-02f, 7.31851608e-02f, 9.88174900e-02f, 5.17061986e-02f,
  1.50336578e-01f, 1.05333544e-01f, -4.01376970e-02f, 9.78670735e-03f, 1.53220057e-01f, 8.83590579e-02f, 1.31601647e-01f, -2.86609754e-02f, 2.55730972e-02f, -1.88575014e-02f,
  -2.56499380e-01f, 2.59121567e-01f, 1.43119708e-01f, 2.15596467e-01f, -2.02403605e-01f, -2.89754957e-01f, -1.57004982e-01f, 1.75283208e-01f, -1.39572322e-01f, 1.21725000e-01f,
  3.67294103e-02f, -3.06423232e-02f, 1.05114684e-01f, 2.87125349e-01f, 1.55050948e-01f, 1.32387012e-01f, 5.73521145e-02f, -3.57617699e-02f, 3.39838788e-02f, 2.00630367e-01f,
  6.28657565e-02f, 1.29973218e-01f, 1.05621897e-01f, 1.56691179e-01f, 8.88486058e-02f, 4.59009893e-02f, 1.94934860e-01f, -7.27365538e-03f, 1.81769162e-01f, -5.72313964e-02f,
  7.41383433e-02f, 1.83251396e-01f, -4.67339717e-02f, -1.33652659e-02f, 1.10175051e-01f, -5.03654890e-02f, -3.83796841e-02f, -9.79329720e-02f, -1.00665487e-01f, -4.14458811e-02f,
  6.98141987e-03f, 4.89668585e-02f, 7.53106698e-02f, -6.13113008e-02f, -1.21383175e-01f, -8.04077834e-04f, 1.80643443e-02f, -2.52796747e-02f, 3.04505583e-02f, 1.46770235e-02f,
  5.40429316e-02f, 6.26072809e-02f, -1.54829957e-02f, 5.35643287e-02f, -8.54820311e-02f, 3.87582369e-02f, 7.00569199e-03f, 9.27953273e-02f, 1.46584315e-02f, -2.58262120e-02f,
  -2.77943332e-02f, -1.25959918e-01f, 5.60501888e-02f, 1.74609460e-02f, -9.23204329e-03f, 1.02585472e-01f, -1.13150135e-01f, -6.50025532e-02f, -8.60651508e-02f, -2.25540102e-02f,
  3.29744928e-02f, 5.05989306e-02f, 1.75666306e-02f, -3.39964703e-02f, 9.77052823e-02f, 3.03292945e-02f, -5.06114364e-02f, 4.16828580e-02f, 1.01779215e-02f, 4.10492755e-02f,
  4.99395207e-02f, -1.40416091e-02f, -8.52202065e-03f, -1.29908383e-01f, -4.17015366e-02f, -4.47972156e-02f, -3.41107906e-03f, 2.85586715e-02f, 4.90240008e-02f, 1.49238470e-03f,
  1.52524069e-01f, 2.77436018e-01f, 1.55317336e-01f, -4.78252023e-02f, -5.74095873e-03f, -2.06166450e-02f, 1.25043422e-01f, 2.16511749e-02f, 6.78714737e-02f, 9.59810168e-02f,
  1.96688175e-02f, -1.06699169e-01f, 1.00261364e-02f, -3.93787138e-02f, -3.06026172e-02f, 1.04484595e-01f, 1.54357245e-02f, -2.96302754e-02f, 5.54753654e-02f, 1.14366703e-01f,
  1.05930641e-01f, -9.37925056e-02f, -2.93310340e-02f, -4.88448814e-02f, -7.39141852e-02f, 8.08042753e-03f, -1.11455061e-02f, -9.01656821e-02f, 9.25975740e-02f, 7.39079937e-02f,
  9.01158601e-02f, -1.13819376e-01f, -3.65468025e-01f, -1.41214892e-01f, 1.82197139e-01f, 1.93439290e-01f, -5.77878170e-02f, -4.02612835e-02f, -2.82386750e-01f, 7.90187865e-02f,
  6.07889220e-02f, -1.49813116e-01f, -2.90058851e-01f, 1.59996405e-01f, 9.98224840e-02f, -1.89600930e-01f, 2.18106642e-01f, 1.80221483e-01f, -1.37358010e-01f, -1.30773082e-01f,
  4.67150956e-02f, 3.63345236e-01f, -2.86526620e-01f, 2.03162313e-01f, 2.24028096e-01f, -6.26766756e-02f, 1.85776830e-01f, -2.35884562e-01f, 1.84291258e-01f, 2.25823432e-01f,
  4.28733528e-02f, 1.18618617e-02f, -4.35850732e-02f, 4.42124791e-02f, 4.36661616e-02f, 1.36318177e-01f, 5.61512001e-02f, 6.99371193e-03f, -4.71161753e-02f, -2.04091910e-02f,
  1.39744356e-01f, 2.24543642e-02f, 3.50031890e-02f, -6.36352897e-02f, 5.15539609e-02f, -1.12928133e-02f, -8.27819034e-02f, 6.60493039e-03f, -1.26745537e-01f, -1.51339144e-01f,
  -5.64571731e-02f, -5.46976365e-03f, 7.12097585e-02f, 6.67776465e-02f, -8.47621635e-02f, -2.18741205e-02f, 6.87429458e-02f, -2.71674469e-02f, 8.46445188e-02f, 2.56568883e-02f,
  1.17432758e-01f, 8.84314999e-02f, 9.00167674e-02f, 1.29705653e-01f, -3.14657055e-02f, 3.79791781e-02f, 8.66021588e-02f, 1.06512681e-01f, -1.57431319e-01f, -1.92739833e-02f,
  -1.10025093e-01f, -7.40949139e-02f, -2.50963587e-02f, 8.59643444e-02f, 1.09660529e-01f, -3.26080136e-02f, 1.79072991e-02f, 7.88113549e-02f, -1.44298732e-01f, -6.24590442e-02f,
  6.18944392e-02f, 8.89755934e-02f, 8.34497809e-03f, 1.94435343e-02f, 6.21116199e-02f, -8.65027681e-02f, 1.04607016e-01f, -1.61638781e-01f, -7.90131763e-02f, 9.40858945e-02f,
  2.43572369e-02f, -1.05395121e-02f, -9.96741131e-02f, -1.89768709e-02f, -1.65791772e-02f, 5.91997281e-02f, 1.90378707e-02f, 8.25694203e-02f, 4.41743322e-02f, 9.96596888e-02f,
  -2.71497108e-02f, -4.81057987e-02f, 1.49064779e-01f, -1.83123320e-01f, 4.42603268e-02f, -2.40694657e-02f, -3.38429876e-04f, -6.74161911e-02f, -1.27806410e-03f, 2.80816620e-03f,
  -1.56702772e-02f, -5.10680676e-02f, 9.78564695e-02f, -2.51396355e-04f, 1.53868139e-01f, 1.05229653e-01f, 5.63188232e-02f, -1.23105451e-01f, 4.67657484e-02f, -5.44185899e-02f,
  8.94763395e-02f, -1.27833664e-01f, -2.46451303e-01f, 5.44289351e-02f, -9.04757977e-02f, 3.39549601e-01f, 5.28094471e-01f, -2.12299153e-01f, -9.59586501e-02f, 2.45806009e-01f,
  2.24603847e-01f, 1.06497165e-02f, 3.32838565e-01f, 3.87452930e-01f, 3.03337336e-01f, 2.46877894e-01f, 3.20340246e-01f, 2.34297857e-01f, -2.06894785e-01f, 6.38298765e-02f,
  -3.56549770e-02f, 3.74429822e-01f, 4.01143394e-02f, -2.25298136e-01f, 7.52989426e-02f, -2.94801831e-01f, -1.62877411e-01f, -2.39827141e-01f, -7.11908117e-02f, 1.59639925e-01f,
  8.46354365e-02f, -2.43136864e-02f, 2.33022403e-02f, -3.00306696e-02f, -1.23902969e-01f, 5.14918976e-02f, 9.24360380e-03f, 8.37252289e-02f, 1.82145201e-02f, -1.26944259e-02f,
  8.44189748e-02f, -6.13179244e-02f, 9.27675143e-02f, 1.23080118e-02f, -6.17252029e-02f, -1.96727291e-02f, -1.80555123e-03f, -3.88601720e-02f, -6.74809888e-02f, 6.76647201e-02f,
  -1.66281797e-02f, -9.11616459e-02f, -7.04860594e-03f, -5.59176691e-02f, -7.46841133e-02f, 4.01181728e-02f, 2.34088041e-02f, -3.58419120e-02f, 1.38327864e-03f, -5.94463088e-02f,
  -1.64688714e-02f, -6.24694377e-02f, 5.78232333e-02f, -1.66228414e-02f, 9.21997651e-02f, -5.35909720e-02f, 8.78031552e-02f, 1.95673574e-03f, -7.38851354e-02f, 3.06876712e-02f,
  5.52577451e-02f, 4.96316031e-02f, 2.86156014e-02f, 9.26411226e-02f, 5.28661236e-02f, -1.49257416e-02f, -1.98653750e-02f, -8.05080608e-02f, -3.55610624e-02f, -7.20700771e-02f,
  -5.12671247e-02f, -4.77986224e-02f, 1.33538991e-02f, -2.30769999e-02f, 1.63533110e-02f, 2.12437306e-02f, -7.89733157e-02f, -4.96203527e-02f, 1.44950924e-02f, 7.07191378e-02f,
  5.49101271e-02f, -5.05883507e-02f, 4.95105162e-02f, -1.75838675e-02f, -6.86058328e-02f, -6.03425466e-02f, 7.93800130e-02f, -8.48870426e-02f, -8.36554989e-02f, 4.46339101e-02f,
  -3.42668802e-03f, 6.83121532e-02f, -6.62645744e-03f, 1.19164456e-02f, -7.49312043e-02f, 5.55504113e-02f, 1.10075764e-01f, -2.04344988e-02f, 4.06771116e-02f, 1.43628409e-02f,
  -4.31321189e-02f, 8.11180100e-02f, -4.38101776e-02f, 8.21146443e-02f, -8.54242221e-02f, -1.83507316e-02f, -1.47774830e-01f, -1.26350597e-01f, 5.79925478e-02f, -3.33102164e-03f,
  -4.98182505e-01f, -2.21758500e-01f, 4.08132851e-01f, -9.53746289e-02f, 1.23709679e-01f, 3.73129070e-01f, 3.48560065e-01f, -4.47451957e-02f, -1.66209906e-01f, -8.66619423e-02f,
  -1.55848302e-02f, -3.50759104e-02f, 2.49719143e-01f, 1.19347930e-01f, 3.86679798e-01f, 1.28305525e-01f, 5.02557755e-02f, -3.46172377e-02f, -2.38020755e-02f, -1.38295904e-01f,
  -6.50673583e-02f, -1.02463424e-01f, 3.36290777e-01f, -1.49100333e-01f, 2.87600793e-02f, -1.64555088e-01f, -3.29232551e-02f, 2.55422682e-01f, -1.16003767e-01f, 1.23499990e-01f,
  -3.97815794e-01f, -1.37054995e-01f, -1.82401180e-01f, -9.43571702e-03f, -2.22671758e-02f, -4.15978469e-02f, 1.98334113e-01f, 1.40684217e-01f, -8.28056112e-02f, -2.11727023e-02f,
  -1.45053819e-01f, 5.57621941e-02f, -8.10864344e-02f, -2.10426692e-02f, -5.53537756e-02f, -5.54883592e-02f, 5.72487377e-02f, -3.76158452e-04f, 8.90162215e-02f, 1.36704803e-01f,
  1.87175721e-02f, -7.16513395e-02f, -6.83631152e-02f, 3.43708731e-02f, 1.29039705e-01f, -6.86108470e-02f, 9.86961946e-02f, 5.86563572e-02f, -5.02673239e-02f, 1.88335422e-02f,
  6.48303777e-02f, 5.11991791e-02f, -2.09694300e-02f, -1.32331863e-01f, -1.29890209e-02f, -1.25181988e-01f, -9.99865606e-02f, 1.90614648e-02f, 4.21915427e-02f, 5.58577012e-03f,
  -1.93083379e-02f, -3.88881043e-02f, -7.06919357e-02f, -8.55515376e-02f, -2.45910473e-02f, -2.98443213e-02f, 6.81226328e-02f, -8.73455778e-02f, 4.48725820e-02f, 5.55282868e-02f,
  -3.05698849e-02f, -5.44799641e-02f, 2.93687843e-02f, 3.61267738e-02f, -9.44296177e-03f, -8.20400789e-02f, -1.66090224e-02f, -2.25012619e-02f, -1.01319747e-02f, -3.26305232e-03f,
  -4.16385889e-01f, -3.39497447e-01f, -1.49721995e-01f, -1.40519768e-01f, 3.15367468e-02f, -3.60029042e-02f, -1.50767397e-02f, -9.33756754e-02f, -1.82802051e-01f, -9.86848995e-02f,
  -3.50618437e-02f, 2.11516190e-02f, -1.18888333e-01f, 7.32093602e-02f, 4.67380788e-03f, -8.52473266e-03f, 9.45840776e-03f, -1.18718818e-01f, -1.55717120e-01f, -4.67134379e-02f,
  -2.06947816e-03f, -1.91660021e-02f, 1.14630699e-01f, -7.44285285e-02f, 7.13929981e-02f, -3.00740227e-02f, -1.22232094e-01f, 4.29196768e-02f, 4.82521169e-02f, 2.49160687e-03f,
  -6.53562009e-01f, 3.64110768e-01f, 1.74391761e-01f, -2.44904906e-01f, 1.67777881e-01f, -6.20655566e-02f, -1.44852310e-01f, 1.52412087e-01f, -3.60464025e-03f, 1.20055310e-01f,
  2.30944529e-02f, -1.20750748e-01f, 2.37472102e-01f, 1.20316260e-01f, -3.08126926e-01f, 2.57471949e-01f, -7.44592845e-02f, -7.87781999e-02f, 1.10061891e-01f, 6.49464503e-02f,
  -1.19912133e-01f, 1.10283561e-01f, 1.04717791e-01f, 2.78656721e-01f, -3.76258157e-02f, -3.21716256e-02f, -1.75260410e-01f, 1.22335076e-01f, -6.80003390e-02f, 1.38231441e-01f,
  -3.94240201e-01f, 9.88724083e-03f, -9.26425308e-03f, -1.35777459e-01f, -7.55950883e-02f, -4.15627770e-02f, -1.20789409e-01f, -1.85040422e-04f, -6.68869391e-02f, -1.94326490e-02f,
  -7.58314207e-02f, 4.92681339e-02f, 1.34662343e-02f, 8.29671696e-02f, -7.83756822e-02f, -3.66142020e-02f, 4.50935736e-02f, -4.36262786e-03f, 4.86178510e-02f, 3.06413546e-02f,
  1.54928312e-01f, -3.41691710e-02f, -7.69007728e-02f, 8.29986762e-03f, 7.16447532e-02f, 3.63746174e-02f, -4.11444157e-02f, -1.13720812e-01f, -1.92554314e-02f, -5.30255847e-02f,
  2.77871527e-02f, -5.85760213e-02f, 1.00448370e-01f, -1.63631104e-02f, 1.31886648e-02f, 1.72560401e-02f, 9.05037746e-02f, -4.48457785e-02f, -7.31915534e-02f, 3.03159505e-02f,
  -3.70172933e-02f, -8.69249552e-02f, 4.97711496e-03f, -6.19665496e-02f, -4.64388765e-02f, 2.39159167e-03f, 7.63120055e-02f, -4.75949757e-02f, -3.55657637e-02f, -6.50447085e-02f,
  -8.01699758e-02f, -3.00904382e-02f, 6.15040213e-03f, -4.18853853e-03f, -4.17452566e-02f, -4.34338022e-03f, -3.21277529e-02f, 7.93691128e-02f, 3.99668468e-03f, -5.45451604e-02f,
  -4.63883340e-01f, -3.36174130e-01f, -1.12552427e-01f, -1.00696020e-01f, -9.67144519e-02f, -4.99215536e-02f, -8.55637491e-02f, -4.16052938e-02f, -1.00478224e-01f, -9.28693935e-02f,
  -8.41322914e-02f, -6.61658570e-02f, -7.79465288e-02f, -5.82870618e-02f, -2.30108388e-02f, -6.37784973e-02f, 7.80690182e-03f, 4.16756794e-02f, -1.07395969e-01f, -6.87223896e-02f,
  -7.27141276e-02f, -4.76345122e-02f, -1.82665396e-03f, 7.50500755e-03f, -1.17260935e-02f, -3.91106457e-02f, 1.28677646e-02f, 8.69375616e-02f, 2.26957016e-02f, 1.86363366e-02f,
  -4.74211395e-01f, 9.61200073e-02f, -2.93486953e-01f, -1.22351810e-01f, -2.33070612e-01f, -6.15751669e-02f, 1.51248351e-01f, -2.78297495e-02f, 7.85228834e-02f, 2.66860396e-01f,
  2.08863959e-01f, -1.53766662e-01f, 2.50754654e-01f, 1.58944890e-01f, -3.77807200e-01f, 1.63546056e-01f, 3.16703343e-03f, 1.53852543e-02f, 3.72954942e-02f, -1.51484549e-01f,
  -9.09479707e-02f, 1.04218930e-01f, -1.45885155e-01f, 2.33291276e-02f, -1.90764099e-01f, -1.00550070e-01f, 1.29585832e-01f, -5.18041216e-02f, -3.95155884e-02f, -1.65668860e-01f,
  -3.95606428e-01f, -2.54227489e-01f, -1.43239424e-01f, -1.77203193e-01f, -9.91308168e-02f, -2.95536336e-03f, 1.24468086e-02f, 1.62522681e-02f, 1.65554900e-02f, -8.22282881e-02f,
  1.93115827e-02f, -3.25335413e-02f, -3.88284810e-02f, 1.62593033e-02f, -1.53368383e-04f, -1.37808427e-01f, -1.16462916e-01f, -1.03717513e-01f, 2.13639475e-02f, -1.52269796e-01f,
  -9.74726230e-02f, -8.20427909e-02f, 1.65056344e-02f, -6.83765765e-03f, -3.21403779e-02f, 7.91823193e-02f, -2.10568067e-02f, -4.50580660e-03f, -2.04688117e-01f, -1.18774973e-01f,
  -7.99288228e-03f, 4.68571521e-02f, -4.49081920e-02f, -2.88454369e-02f, 7.78245972e-03f, 8.06092694e-02f, -1.39909331e-02f, 4.42405231e-02f, 6.48358464e-02f, -1.88720692e-02f,
  -3.39133367e-02f, -1.92762446e-02f, 1.95476841e-02f, -7.62337644e-04f, -8.18791240e-03f, 4.67764623e-02f, -3.74543220e-02f, -8.47578123e-02f, 4.31796573e-02f, 5.71429096e-02f,
  4.13297378e-02f, -7.80363008e-02f, 1.15663663e-01f, 8.21816176e-02f, -4.78633828e-02f, 3.27791111e-03f, -7.12136254e-02f, -9.34538692e-02f, 6.67961538e-02f, -3.29976203e-04f,
  -2.35395536e-01f, -2.01849863e-01f, 6.02970012e-02f, -1.32225946e-01f, 1.18358908e-02f, -5.78608550e-02f, 1.90146435e-02f, -2.54063103e-02f, -7.65593126e-02f, -8.06849748e-02f,
  -6.23905770e-02f, 7.60855153e-02f, 2.40751877e-02f, 1.20293848e-01f, 1.02470536e-02f, 7.42762238e-02f, 1.22419000e-01f, -4.50445944e-03f, -1.07256494e-01f, -1.14491340e-02f,
  -8.23231041e-02f, -1.44874752e-02f, 3.08869574e-02f, 1.35677338e-01f, 2.64561344e-02f, 5.84716722e-03f, -9.19314623e-02f, 7.75724351e-02f, -9.40945596e-02f, -3.31697389e-02f,
  5.54207563e-01f, -6.05748668e-02f, 2.59898335e-01f, 2.12002307e-01f, 1.78232044e-01f, 6.12663887e-02f, -4.27318066e-02f, 1.38352305e-01f, 4.21149880e-01f, -8.47225860e-02f,
  -6.15210608e-02f, 1.47551954e-01f, -2.87413150e-01f, 1.64286017e-01f, -2.37307519e-01f, -1.66250631e-01f, 1.08427115e-01f, 1.34704575e-01f, -1.00304550e-02f, 2.13338241e-01f,
  1.24586619e-01f, -1.76344097e-01f, -1.94997177e-01f, -2.04650313e-01f, 1.15637042e-01f, 1.42244488e-01f, -3.71921092e-01f, -2.45073065e-01f, 1.20896824e-01f, -2.28372633e-01f,
  3.69450897e-02f, 2.58119926e-02f, -9.60099474e-02f, -5.26623940e-03f, 1.62927672e-01f, 9.52299163e-02f, 1.68096479e-02f, -2.19555944e-01f, 4.80325893e-02f, -6.57226238e-03f,
  1.86794046e-02f, -2.99166758e-02f, 1.68523490e-01f, 1.44991931e-02f, 9.55297053e-02f, 1.14412077e-01f, 1.36144862e-01f, 8.68185610e-02f, -1.81295183e-02f, 1.14406615e-01f,
  8.74814764e-02f, 1.31406024e-01f, 1.08267702e-01f, 2.91679539e-02f, -4.56307195e-02f, 1.33992702e-01f, -4.45785373e-02f, -4.14808057e-02f, 1.16670690e-01f, -1.80583205e-02f,
  -8.34420547e-02f, -6.45572320e-02f, -4.89647500e-02f, 2.79984493e-02f, -7.75641277e-02f, -2.91173290e-02f, 5.08846529e-02f, -7.01379254e-02f, 6.86306208e-02f, -5.32275848e-02f,
  9.04047191e-02f, -6.62951730e-03f, 4.18399600e-03f, 5.55067398e-02f, -1.39552178e-02f, 2.26465091e-02f, -7.54424632e-02f, 1.13974027e-01f, -1.49506489e-02f, 7.07335472e-02f,
  2.89897807e-02f, -2.39269361e-02f, -1.49065301e-01f, -3.35158780e-02f, 1.84181146e-02f, -6.58076033e-02f, 2.40429100e-02f, 1.03932284e-01f, -2.10129861e-02f, -2.69497167e-02f,
  -1.84806421e-01f, -1.93477422e-01f, -4.09502089e-02f, -3.56656662e-03f, 3.55054252e-02f, 5.61731979e-02f, 4.22389209e-02f, 1.25466332e-01f, -1.53725624e-01f, -8.10751244e-02f,
  -3.46774310e-02f, 9.88496095e-02f, 1.26557842e-01f, 6.43616542e-02f, -7.43863955e-02f, -1.77940261e-02f, -4.00651321e-02f, -1.09405644e-01f, -1.04314331e-02f, -6.43316582e-02f,
  -5.74903041e-02f, 7.62452185e-02f, 1.14784695e-01f, 6.70165718e-02f, 9.12150089e-03f, -6.72641248e-02f, 8.73766989e-02f, 7.21686557e-02f, 2.28847354e-03f, -3.65037844e-02f,
  4.11464609e-02f, 7.57109597e-02f, 2.09213659e-01f, 6.14020750e-02f, -1.85656652e-01f, -2.57028282e-01f, -2.81520128e-01f, -1.50843486e-02f, -2.42400952e-02f, -1.26070425e-01f,
  -1.39478624e-01f, 2.37639308e-01f, -3.22274089e-01f, 2.52785206e-01f, 1.80657029e-01f, -2.51361191e-01f, 3.60755116e-01f, 1.07497379e-01f, -1.00972923e-02f, 1.19224913e-01f,
  1.59682423e-01f, 3.22706997e-02f, 2.64902472e-01f, 2.50284582e-01f, 1.23444073e-01f, 2.80303091e-01f, 9.40893888e-02f, 7.02301739e-03f, 3.92553419e-01f, 1.58921048e-01f,
  -3.23339477e-02f, -2.72683855e-02f, 2.12519690e-02f, 6.60918206e-02f, -1.37977954e-02f, -3.10498476e-02f, 6.33633733e-02f, 7.69259855e-02f, -4.63401265e-02f, -6.96024299e-02f,
  -1.02049597e-02f, 2.01550469e-01f, 9.38295200e-02f, 2.43207905e-02f, 1.44288972e-01f, 1.68398663e-01f, 2.32188199e-02f, 6.69678673e-02f, 7.09409043e-02f, -1.19154945e-01f,
  3.69488150e-02f, -9.08314586e-02f, -8.08475539e-03f, 1.93648994e-01f, -3.01424391e-03f, 3.06769647e-02f, 8.62998664e-02f, 1.26728132e-01f, 2.68740137e-03f, 1.61387742e-01f,
  3.59985903e-02f, -1.11358911e-01f, -4.65841219e-02f, -4.66548800e-02f, 3.86944041e-02f, -1.62322655e-01f, 4.63131703e-02f, -4.28748690e-02f, -1.01511851e-02f, -2.30275025e-03f,
  9.24339145e-02f, 8.08152109e-02f, -1.13287732e-01f, 5.76343648e-02f, -5.88334762e-02f, 7.72926658e-02f, -9.33317747e-03f, -3.17185968e-02f, 5.86397350e-02f, 3.56415100e-02f,
  -1.01429626e-01f, 9.79443863e-02f, -5.85562512e-02f, 8.61184224e-02f, 3.28760408e-02f, -1.42172262e-01f, -7.19136521e-02f, -7.36720413e-02f, 6.24530055e-02f, -6.97113201e-02f,
  4.24892493e-02f, 3.55193168e-02f, -1.50373029e-02f, 1.41509399e-01f, 3.25626507e-02f, -7.10088387e-03f, 3.59156020e-02f, 1.11964472e-01f, 8.85332450e-02f, -1.66094545e-02f,
  6.70884699e-02f, 7.07027465e-02f, -1.18867345e-01f, 5.88248260e-02f, 5.29712327e-02f, -2.53066551e-02f, 6.29131123e-03f, 4.52604666e-02f, 5.99705726e-02f, 5.26769161e-02f,
  2.14562993e-02f, -1.91517964e-01f, 2.37381943e-02f, 1.16315261e-01f, 1.02523714e-02f, -2.99958438e-02f, -5.11459708e-02f, 3.79198641e-02f, -1.45126246e-02f, -8.54845569e-02f,
  3.29508305e-01f, -1.96472943e-01f, 3.29416841e-01f, 2.11416960e-01f, 3.12182754e-01f, 2.66779959e-01f, 1.80167884e-01f, 2.69045621e-01f, 3.93127382e-01f, -1.86261177e-01f,
  -2.05494747e-01f, -1.40303448e-01f, -8.99825469e-02f, -5.12113497e-02f, 1.23722151e-01f, 4.52291369e-02f, 1.69848159e-01f, 9.90946814e-02f, 1.87127173e-01f, -4.40867655e-02f,
  8.68355557e-02f, -1.42720699e-01f, -5.70061803e-02f, -1.73620716e-01f, 1.17974900e-01f, -3.33061218e-02f, -2.00170428e-01f, 8.93540233e-02f, -2.88391143e-01f, -6.27837032e-02f,
  -3.51512507e-02f, -2.43552476e-02f, -1.49987340e-01f, -9.46641639e-02f, 4.01520636e-03f, -5.03458939e-02f, -1.87710822e-01f, -1.01866364e-01f, 4.26877849e-02f, -8.82888958e-02f,
  -1.51693657e-01f, -5.64149506e-02f, -8.69478658e-02f, -9.97137744e-03f, 1.48872837e-01f, -3.75932716e-02f, 2.64628399e-02f, -3.75855565e-02f, 5.95713593e-02f, 7.57510960e-02f,
  5.49650230e-02f, 5.16606830e-02f, -8.78201891e-03f, 4.48555797e-02f, -7.40106702e-02f, 5.41182049e-02f, 8.59702677e-02f, 9.55886208e-03f, 1.66701265e-02f, -6.95421966e-03f,
  1.49500385e-01f, 5.75335845e-02f, -1.05048962e-01f, 3.38817537e-02f, 8.09048116e-02f, -1.19546279e-02f, -3.33724432e-02f, -9.99355391e-02f, 6.08597547e-02f, 7.96229094e-02f,
  7.08315074e-02f, 2.10123789e-02f, 9.77354348e-02f, 1.93633109e-01f, -5.08010387e-03f, 4.75528911e-02f, -3.55076976e-02f, -2.63307821e-02f, -1.98992528e-02f, 3.60351913e-02f,
  1.07411025e-02f, -3.05423662e-02f, 1.57681778e-02f, 4.22175936e-02f, 2.78484402e-03f, -1.92231108e-02f, -9.37202945e-02f, 1.31086215e-01f, 9.61683914e-02f, -3.19798850e-02f,
  -3.40115964e-01f, -2.04787225e-01f, -4.26155105e-02f, -9.87397134e-02f, -3.81668210e-02f, -1.97825477e-01f, 3.52877341e-02f, -3.04648243e-02f, -4.25502732e-02f, 1.06552199e-01f,
  -5.88158295e-02f, -9.60750058e-02f, -1.34393722e-01f, 4.24060374e-02f, -1.18519537e-01f, 3.44755240e-02f, -1.36451349e-01f, -1.32574081e-01f, -1.33014411e-01f, -7.89354965e-02f,
  -2.25074845e-03f, -5.28503805e-02f, -1.50409276e-02f, 4.23017479e-02f, -9.37395915e-02f, 1.02079408e-02f, -2.97578913e-03f, 4.12065051e-02f, 1.28210112e-02f, -1.12581355e-02f,
  -1.00644045e-01f, -8.62309262e-02f, 2.41728008e-01f, 3.55142295e-01f, -4.40854765e-02f, -2.91968524e-01f, -2.53879160e-01f, 1.06231691e-02f, 1.12884725e-02f, -2.58576840e-01f,
  -9.04984996e-02f, 9.97599363e-02f, -2.50950843e-01f, 2.18770370e-01f, 2.98368484e-01f, -7.24754035e-02f, 2.79510498e-01f, 1.45582687e-02f, 1.84982851e-01f, 9.29861218e-02f,
  2.93706864e-01f, 2.31649756e-01f, 3.96891415e-01f, 3.55684191e-01f, 1.39362738e-01f, 2.26439223e-01f, 3.60349655e-01f, 9.92105603e-02f, 1.80923894e-01f, 1.19910486e-01f,
  -1.96095452e-01f, -1.61752962e-02f, 4.07489985e-02f, -3.89253981e-02f, -1.01112751e-02f, -4.50677238e-02f, 2.78873667e-02f, 5.76117709e-02f, 2.54500769e-02f, -1.60685531e-03f,
  -1.32500172e-01f, 2.64281463e-02f, 6.92196488e-02f, 7.95268342e-02f, -1.40208587e-01f, 8.22681114e-02f, 5.13413735e-02f, -6.89771548e-02f, -1.33098081e-01f, -4.39705364e-02f,
  1.01767153e-01f, -5.57812043e-02f, -5.41154332e-02f, -2.50843205e-02f, 1.48773178e-01f, 9.08034202e-03f, 7.66875371e-02f, -2.51069218e-02f, 5.72141679e-03f, 3.31579857e-02f,
  -5.17020896e-02f, 1.33330211e-01f, -2.83724349e-02f, 3.91325094e-02f, -5.49272858e-02f, 6.22156374e-02f, 2.22460590e-02f, 9.37293991e-02f, 5.32899722e-02f, 2.37056985e-03f,
  1.08147459e-02f, -2.08213273e-03f, -3.37590799e-02f, -1.06081635e-01f, 1.52448947e-02f, -7.91356489e-02f, -3.37611325e-02f, -1.11365439e-02f, -1.47821028e-02f, 4.39530192e-03f,
  6.87901750e-02f, 1.84719022e-02f, 6.75640181e-02f, 6.87586889e-02f, -1.52927265e-01f, -2.54639685e-02f, -6.51971325e-02f, -3.02133220e-03f, -3.92646827e-02f, 9.74331871e-02f,
  -3.82158160e-02f, 2.02626929e-01f, 1.00089043e-01f, -1.63693488e-01f, 9.57437754e-02f, -8.94368589e-02f, 9.10846666e-02f, -2.12568585e-02f, 5.93890361e-02f, -5.17122261e-02f,
  -1.67295009e-01f, -4.40934747e-02f, -7.53830671e-02f, -5.99401630e-02f, 3.81860696e-02f, -2.64860354e-02f, -1.00343652e-01f, 6.36534840e-02f, 1.27490601e-02f, 9.62230340e-02f,
  -5.74034639e-02f, -5.38800731e-02f, 8.06703940e-02f, 8.35073516e-02f, 3.71329859e-02f, -1.08384201e-02f, -7.54625499e-02f, 2.37218142e-02f, 1.15804017e-01f, 9.61866602e-02f,
  2.11394086e-01f, -3.43540311e-01f, -2.55808502e-01f, -2.13883385e-01f, -1.45625457e-01f, -1.81242913e-01f, -2.13490605e-01f, -2.27778375e-01f, -1.12652235e-01f, -1.94082767e-01f,
  -1.71579599e-01f, 1.46354496e-01f, 6.76255152e-02f, -7.01292534e-04f, 3.74834716e-01f, 1.50461391e-01f, -8.28645304e-02f, -1.27303898e-02f, 5.23318574e-02f, -1.52712092e-01f,
  3.66840288e-02f, 3.90251679e-03f, -9.92420018e-02f, -1.38009131e-01f, -2.58650303e-01f, -2.81241506e-01f, 1.30889595e-01f, -1.73550829e-01f, -9.89936367e-02f, 4.76651359e-03f,
  -7.16525391e-02f, -6.17754161e-02f, -1.28361121e-01f, 4.56196256e-03f, -5.97288795e-02f, -3.15721519e-02f, 1.45604834e-01f, 4.89917472e-02f, 4.18640450e-02f, 9.63691324e-02f,
  1.37192756e-01f, 1.19388871e-01f, 8.98922421e-03f, 1.11631639e-01f, 1.19986758e-01f, -5.96204288e-02f, -8.82717445e-02f, -1.21648178e-01f, -2.12534722e-02f, 4.76254895e-02f,
  -1.54053897e-01f, 1.32408477e-02f, -1.33824363e-01f, 3.09406817e-02f, -1.10032968e-02f, -2.67273467e-02f, 1.37863398e-01f, -1.21419318e-01f, 1.80168271e-01f, -5.10787964e-02f,
  -3.67599055e-02f, 1.32938623e-01f, -3.03486045e-02f, -1.40722971e-02f, 2.47033704e-02f, -4.62500639e-02f, 5.89661126e-04f, 4.79792990e-02f, -4.11195382e-02f, -1.18336231e-02f,
  -2.59372965e-03f, 5.97041361e-02f, 4.03307453e-02f, -6.25217035e-02f, 5.18484041e-03f, 1.67726696e-01f, 5.24109788e-02f, -7.21435063e-04f, -1.19687676e-01f, 3.99495549e-02f,
  3.95545270e-03f, 8.61704201e-02f, -4.06830050e-02f, 3.57922390e-02f, 9.57810599e-03f, -4.47417190e-03f, -5.16012534e-02f, -4.80576344e-02f, -1.22474015e-01f, 2.10725870e-02f,
  -2.46159770e-02f, -1.74316779e-01f, -1.52902648e-01f, -6.56494359e-03f, 4.42082770e-02f, 7.14863464e-02f, -6.21530861e-02f, -2.64169145e-02f, -5.34526370e-02f, -2.32615992e-02f,
  9.95333772e-03f, 1.35854371e-02f, -1.02858223e-01f, 1.06629841e-01f, 9.90374610e-02f, -1.97682381e-01f, 1.46897033e-01f, 9.24672484e-02f, 1.43512592e-01f, -1.13940604e-01f,
  -1.10414244e-01f, 1.75541230e-02f, 7.42228329e-02f, -5.53017668e-02f, 5.90762086e-02f, 3.30901407e-02f, 9.41868424e-02f, -2.11282428e-02f, 7.06778020e-02f, 5.06881103e-02f,
  -3.67473572e-01f, -7.47087747e-02f, -2.42262870e-01f, -3.00383419e-01f, 8.37337077e-02f, -3.07141304e-01f, -2.90151864e-01f, 2.45316536e-03f, -1.06820740e-01f, 2.35206172e-01f,
  -8.06296691e-02f, -2.06847683e-01f, 1.08209245e-01f, -3.61987859e-01f, -3.41318697e-01f, -7.28767440e-02f, -3.87124628e-01f, -1.55722216e-01f, -7.03108907e-02f, -2.20909193e-01f,
  -1.61337271e-01f, -1.83084711e-01f, -3.41796905e-01f, 1.45128369e-01f, -1.69122905e-01f, 1.16662033e-01f, 2.72433221e-01f, -5.19905763e-04f, -1.87690541e-01f, -1.25419572e-01f,
  -2.34765112e-01f, -1.51424944e-01f, 6.81525394e-02f, 9.89757702e-02f, -7.25468099e-02f, 8.07917789e-02f, -1.09702898e-02f, 2.18796842e-02f, -9.71069634e-02f, -8.11693370e-02f,
  1.44837731e-02f, 8.37436095e-02f, -6.49298057e-02f, 5.76296225e-02f, -1.13829318e-03f, -5.48177585e-02f, 1.78182833e-02f, -2.02154294e-02f, -3.37563381e-02f, -1.50529504e-01f,
  -8.84509385e-02f, -1.00961916e-01f, -1.11090438e-03f, 4.73323092e-02f, -3.97321209e-02f, 9.67228878e-03f, -1.22692272e-01f, 3.57467565e-03f, -1.21767493e-02f, -8.45807418e-02f,
  5.27350279e-03f, 5.85132577e-02f, 1.26830395e-02f, -2.00439859e-02f, -3.19645070e-02f, 5.43155856e-02f, 8.88576265e-03f, 9.39445868e-02f, 7.28386268e-02f, -8.30261409e-03f,
  -8.46128725e-03f, -3.54167558e-02f, 6.51101628e-03f, -2.72770524e-02f, -5.55145275e-03f, -6.34134188e-02f, -9.05856676e-03f, 4.26672027e-02f, -9.30148289e-02f, -5.20255491e-02f,
  -3.20720039e-02f, -1.21050447e-01f, 5.08701503e-02f, 7.13113509e-03f, -6.09042943e-02f, 3.80084338e-03f, 1.35503570e-02f, -7.14478418e-02f, 6.61865100e-02f, 9.73971486e-02f,
  -7.49307051e-02f, -4.33095358e-02f, 9.70682502e-03f, -2.89272349e-02f, 3.94521020e-02f, -4.12066393e-02f, 5.48479557e-02f, 3.24608795e-02f, 5.82814589e-02f, -3.94838415e-02f,
  1.16473183e-01f, 9.45665091e-02f, 3.39811817e-02f, -8.23176950e-02f, -4.57002036e-02f, -6.00449927e-02f, 1.93501376e-02f, 6.47817850e-02f, 6.14102334e-02f, 3.35162245e-02f,
  1.06803924e-01f, 6.48490936e-02f, -2.87989695e-02f, 1.50700584e-01f, 6.47346899e-02f, -1.44053968e-02f, -1.93217141e-03f, 3.09132948e-03f, 5.44872656e-02f, 6.77950606e-02f,
  -4.81226355e-01f, 2.71455973e-01f, -3.29460591e-01f, -1.93438217e-01f, 2.11928561e-01f, -3.32342058e-01f, -1.84386611e-01f, 1.04408771e-01f, 5.47832027e-02f, 1.23036928e-01f,
  1.23459317e-01f, 2.13170820e-03f, 2.62525022e-01f, -2.66147166e-01f, -3.14458370e-01f, 4.40739058e-02f, -3.91909868e-01f, -1.83191761e-01f, 6.41227365e-02f, -1.09937221e-01f,
  -9.38033536e-02f, 3.62603962e-02f, -1.93238959e-01f, 2.90149808e-01f, -1.19925313e-01f, -5.26287826e-03f, -1.37250096e-01f, 3.13225985e-01f, -3.53546053e-01f, 1.12689577e-01f,
  -1.80625588e-01f, 9.04352814e-02f, -9.96610746e-02f, -3.63800228e-02f, -2.54231811e-01f, -1.57362357e-01f, -1.17334463e-01f, 5.63160814e-02f, 5.91652244e-02f, 3.64631265e-02f,
  -6.76090345e-02f, 3.97367328e-02f, 4.67975698e-02f, 1.64079964e-01f, 1.16242915e-01f, -4.48496081e-02f, -4.15345430e-02f, -1.68868557e-01f, 9.00774375e-02f, -5.19440928e-03f,
  -8.10812190e-02f, -9.79861990e-02f, -1.60553634e-01f, -2.24124994e-02f, -3.47027555e-02f, -3.90161015e-02f, -1.61382794e-01f, -7.45872557e-02f, -1.03298225e-01f, -9.16888192e-02f,
  -2.17107311e-02f, 7.94545282e-03f, -1.76741183e-02f, 6.08521178e-02f, 6.94170874e-03f, 1.34731364e-02f, -4.80543934e-02f, -3.52258375e-03f, 4.99674007e-02f, 4.71715629e-02f,
  -6.23775907e-02f, 4.36289497e-02f, 9.76184905e-02f, -6.57832846e-02f, 2.54746154e-02f, -1.02654956e-01f, -9.40736756e-02f, 4.28693518e-02f, -9.16330218e-02f, -1.22114852e-01f,
  2.16804016e-02f, -2.66326610e-02f, 8.71942788e-02f, 7.68229514e-02f, -5.46037443e-02f, -4.41235900e-02f, 7.85486847e-02f, -2.07253192e-02f, -1.24736220e-01f, -7.41472989e-02f,
  -3.83857340e-01f, -4.36821133e-02f, 5.05841449e-02f, 1.38268620e-01f, -6.09854162e-02f, -4.05840687e-02f, 5.65022714e-02f, -1.96479680e-03f, 1.22858649e-02f, 8.31514671e-02f,
  -4.66330498e-02f, -6.72790036e-02f, -1.48390904e-01f, 5.70691377e-02f, -1.12540543e-01f, -1.22609310e-01f, -1.67912513e-01f, -6.24743886e-02f, -1.03144586e-01f, -5.12398481e-02f,
  7.36467820e-03f, 3.73818502e-02f, -2.68259067e-02f, 1.59673207e-02f, -6.07549623e-02f, -1.11381344e-01f, 1.06314346e-02f, -5.82234673e-02f, -5.32538556e-02f, -8.48427638e-02f,
  9.67961624e-02f, 2.97574103e-01f, 3.10714543e-01f, 3.18852097e-01f, -1.81246385e-01f, -2.34319225e-01f, -1.89483315e-01f, 1.57771055e-02f, 9.93675441e-02f, 1.69558689e-01f,
  -1.00315489e-01f, 3.23929667e-01f, 3.20449173e-02f, -6.37588510e-03f, -2.16352969e-01f, -3.34700406e-01f, -1.32055879e-01f, -1.48891853e-02f, 1.78380567e-03f, 2.11983085e-01f,
  -1.47094876e-02f, -2.07357764e-01f, -1.43487444e-02f, 2.40896270e-03f, 2.48244807e-01f, 2.26438776e-01f, -4.51247059e-02f, 1.37038380e-01f, 1.30901366e-01f, -1.57957166e-01f,
  -1.05106235e-01f, 1.00645028e-01f, 6.26635626e-02f, -3.19786649e-03f, -3.32590751e-02f, -1.17593324e-02f, -4.51556630e-02f, -1.04218051e-01f, -9.83067695e-03f, 5.90978237e-03f,
  4.72740680e-02f, -2.19247509e-02f, 3.69261056e-02f, -7.35273957e-02f, 2.65050586e-02f, 1.28095627e-01f, 1.07925516e-02f, -1.82856526e-02f, 8.57163966e-02f, 8.07080492e-02f,
  2.05076471e-01f, 8.98596197e-02f, -2.83349156e-02f, 4.13616486e-02f, 1.41329831e-03f, 7.00853765e-02f, 3.70787107e-03f, 2.13090628e-02f, 2.61496473e-02f, 4.02500331e-02f,
  -9.86294672e-02f, 3.25504020e-02f, 3.18400338e-02f, 1.71320997e-02f, -5.87213114e-02f, -4.18067239e-02f, 2.24108156e-03f, -1.00749433e-02f, 4.11565900e-02f, -7.87839368e-02f,
  -9.05285627e-02f, 8.65111686e-03f, -3.48293521e-02f, 8.20656642e-02f, 1.52246237e-01f, -3.74091454e-02f, -2.72310637e-02f, 4.98759747e-02f, 3.35109644e-02f, 7.93454761e-04f,
  3.65596376e-02f, -3.37352715e-02f, 3.21272239e-02f, -4.21206765e-02f, -8.92685205e-02f, 9.10954848e-02f, 1.68305784e-01f, 1.85222011e-02f, -5.03618307e-02f, -5.34034986e-03f,
  -1.96296379e-01f, 8.84443223e-02f, 2.89337952e-02f, -5.63987978e-02f, -6.22626133e-02f, -1.83218345e-02f, 1.34349139e-02f, -4.32742015e-02f, 2.56861635e-02f, -9.69848931e-02f,
  5.13741933e-02f, -8.09801966e-02f, 2.06623692e-02f, -1.22720554e-01f, -3.40312757e-02f, -5.92727289e-02f, -5.72530814e-02f, -6.75611347e-02f, 1.21876225e-02f, 2.26681940e-02f,
  8.94152820e-02f, 8.37903470e-02f, -1.64440759e-02f, -5.04686534e-02f, -1.90312378e-02f, -7.26592019e-02f, -1.05936443e-02f, 1.47174984e-01f, -1.95287878e-03f, -4.30455431e-02f,
  3.34804893e-01f, -1.30505815e-01f, -1.92220276e-03f, 2.67360240e-01f, 1.90913752e-01f, 2.52279937e-01f, 3.62020954e-02f, 2.64285594e-01f, 4.14695203e-01f, -9.96371731e-02f,
  -7.44780377e-02f, -4.02857624e-02f, -3.17544758e-01f, 2.33563706e-01f, 3.27447265e-01f, -1.03020430e-01f, 4.10371006e-01f, 8.21676105e-02f, 1.15265153e-01f, 1.52880475e-01f,
  1.79595903e-01f, 1.53876036e-01f, -3.59910369e-01f, -7.50284456e-03f, -1.13132992e-03f, -6.10581040e-02f, -2.72014946e-01f, -2.64518231e-01f, -6.09694459e-02f, 6.14202349e-03f,
  1.00116923e-01f, 1.15897864e-01f, -6.07782304e-02f, -1.32438540e-01f, -3.27921622e-02f, -8.89707506e-02f, -8.55451897e-02f, 1.42172137e-02f, -5.52487150e-02f, -2.66845617e-02f,
  -2.01147818e-03f, 2.06246264e-02f, 1.69293851e-01f, 4.11135070e-02f, 5.49002811e-02f, 2.53612897e-03f, 3.66511345e-02f, -2.82213483e-02f, 5.25365174e-02f, -6.36406913e-02f,
  -2.25080475e-02f, -5.21938093e-02f, 9.65819880e-02f, -1.26031472e-03f, 7.93229565e-02f, 6.10813946e-02f, -8.05661827e-02f, -7.75453821e-02f, 9.84215271e-03f, 1.44382045e-01f,
  1.43070910e-02f, 5.16027957e-02f, 1.27296997e-02f, -7.92832673e-02f, -4.17176029e-03f, 6.08079806e-02f, 1.66740883e-02f, 1.28006656e-02f, 2.23198477e-02f, 3.44949998e-02f,
  5.65206539e-03f, 2.95672677e-02f, 1.20160401e-01f, -7.51443207e-04f, 8.10563043e-02f, 6.32038480e-03f, 1.03761796e-02f, 4.82164510e-02f, 9.01437029e-02f, 1.03738086e-04f,
  -9.37780924e-03f, -7.19533907e-03f, -5.62151186e-02f, -8.13001990e-02f, -2.56873518e-02f, 3.10052875e-02f, 6.23760335e-02f, -4.46290849e-03f, -7.41830617e-02f, -4.34243195e-02f,
  8.77390429e-02f, 1.42873660e-01f, -8.87182057e-02f, 6.61827922e-02f, -7.13581145e-02f, 9.14194658e-02f, 8.23665187e-02f, 1.30238429e-01f, 2.76658554e-02f, 1.27978340e-01f,
  1.64819118e-02f, 3.64646837e-02f, -1.02535002e-01f, -7.17626587e-02f, -5.28236851e-02f, -5.95731698e-02f, 3.07843816e-02f, -3.91521677e-02f, 7.22292736e-02f, -2.84312423e-02f,
  -8.25501978e-02f, 1.27848759e-01f, -6.58059195e-02f, -6.41837250e-03f, 1.23554878e-01f, -7.83818439e-02f, 3.59662026e-02f, -6.02019876e-02f, -3.93990502e-02f, 8.31100419e-02f,
  -3.63386661e-01f, 1.11468732e-01f, -6.20381758e-02f, 2.72215068e-01f, -8.65795314e-02f, -9.98359993e-02f, -1.76452436e-02f, 9.16581899e-02f, -6.93242699e-02f, 1.99713230e-01f,
  1.63789883e-01f, -1.22277215e-01f, 1.86313599e-01f, 1.63650647e-01f, -1.75988987e-01f, 1.53070912e-01f, 4.34435606e-02f, 6.15182184e-02f, -1.40125126e-01f, 1.56682149e-01f,
  1.20509923e-01f, 2.58176833e-01f, 1.80102348e-01f, 1.03597924e-01f, -6.26845211e-02f, 9.70853493e-02f, 2.82709032e-01f, 5.60439713e-02f, 1.48508638e-01f, -5.94453663e-02f,
  -4.96679870e-03f, 1.96959943e-01f, 1.89754386e-02f, -1.28910437e-01f, 1.18449062e-01f, -3.25158201e-02f, 8.79904106e-02f, -9.94105488e-02f, -2.31709443e-02f, 1.19018920e-01f,
  -7.67987296e-02f, -2.41269544e-02f, 2.49545090e-03f, -1.03203982e-01f, -1.32440403e-01f, -2.12782454e-02f, -6.51167259e-02f, -8.87960270e-02f, 1.66211203e-02f, -7.51744285e-02f,
  1.32602425e-02f, -2.65315622e-02f, -6.56349659e-02f, 4.56890687e-02f, 8.74592811e-02f, -4.02344996e-03f, -7.20163733e-02f, 1.35948965e-02f, -3.50306146e-02f, -3.09663936e-02f,
  -1.03437994e-02f, 4.03780118e-03f, -7.61469454e-03f, 5.69401262e-03f, 5.31131290e-02f, 1.06878303e-01f, -5.48541322e-02f, -3.85463536e-02f, -1.08563207e-01f, 3.50373350e-02f,
  7.73263127e-02f, -3.16533856e-02f, 7.88852125e-02f, 3.96506228e-02f, -4.55918275e-02f, -5.06511070e-02f, -1.00813821e-01f, 8.81296024e-02f, 1.91022344e-02f, -1.40505219e-02f,
  4.77035120e-02f, -1.27744794e-01f, -6.17901459e-02f, -3.15551683e-02f, 1.21362947e-01f, 3.88726890e-02f, 2.77628135e-02f, -7.74901882e-02f, -9.96640418e-03f, -4.84716929e-02f,
  1.47935122e-01f, 1.61031678e-01f, 4.66272831e-02f, 6.27314206e-03f, 7.92791322e-02f, 2.67697424e-02f, -8.26311782e-02f, -6.40140921e-02f, 4.50806916e-02f, 6.38060495e-02f,
  2.49124859e-02f, -9.16616060e-03f, 4.29652780e-02f, 5.03957719e-02f, 4.57876474e-02f, 1.35837361e-01f, 1.00149401e-02f, -8.39873478e-02f, 5.69709204e-02f, 9.66272876e-02f,
  6.42813742e-02f, 2.35963985e-02f, -1.08643286e-01f, -3.76490578e-02f, -1.76125132e-02f, 6.58649877e-02f, -2.06791107e-02f, 4.17158641e-02f, 7.62231350e-02f, 7.08125979e-02f,
  -1.10482126e-01f, -2.22388610e-01f, 9.99899581e-02f, -2.68514663e-01f, -2.51488350e-02f, 2.34226752e-02f, -7.28958771e-02f, -1.59984395e-01f, 1.42054679e-02f, -1.50580615e-01f,
  -1.72773510e-01f, 9.47482232e-03f, 1.95490986e-01f, -3.22721481e-01f, 3.95134658e-01f, 2.63151467e-01f, -2.06331551e-01f, -1.42312601e-01f, -2.24698242e-02f, -1.80301711e-01f,
  -9.28899348e-02f, -2.58378595e-01f, 6.12582900e-02f, -1.75073460e-01f, -2.01969624e-01f, -1.77352205e-01f, -1.58020720e-01f, -4.10507852e-03f, -2.61846602e-01f, -2.16166396e-03f,
  -1.88452467e-01f, -2.54838437e-01f, -1.64698556e-01f, -1.83193579e-01f, -1.83127284e-01f, -8.30668956e-02f, -6.78886473e-02f, 2.95935646e-02f, -1.06421588e-02f, 4.60686795e-02f,
  8.72482955e-02f, -4.77195233e-02f, -7.94026479e-02f, 1.65094197e-01f, -4.88881879e-02f, 8.85641202e-03f, -6.97083399e-02f, -6.43192306e-02f, -3.28232795e-02f, 1.65647864e-01f,
  1.63004920e-01f, -4.21814546e-02f, -8.90498459e-02f, -9.65368599e-02f, -4.38745059e-02f, -7.82336891e-02f, 3.91200334e-02f, 6.84650019e-02f, -8.27602297e-02f, 3.57787646e-02f,
  -3.95294353e-02f, 2.12868582e-02f, -2.01990874e-03f, -1.44341979e-02f, -7.17964396e-02f, -5.24044670e-02f, 9.52385515e-02f, -5.81989102e-02f, 4.09527831e-02f, -8.88267066e-03f,
  -9.80663374e-02f, -7.10809603e-03f, -1.03675788e-02f, -3.70574854e-02f, -2.03527156e-02f, 4.31134598e-03f, -5.02275191e-02f, -1.20435819e-01f, 1.09228998e-01f, 4.84670466e-03f,
  1.44359181e-02f, 7.52435997e-03f, -5.76678775e-02f, -5.08259870e-02f, -5.62968031e-02f, 3.81662957e-02f, -1.30096748e-01f, -5.75716719e-02f, -1.24590108e-02f, 1.00796543e-01f,
  -2.61774957e-01f, -1.79503277e-01f, -1.52133599e-01f, -4.20442298e-02f, -4.93780449e-02f, 7.02040866e-02f, -8.95733908e-02f, -4.34133187e-02f, 7.28514045e-03f, -3.00694015e-02f,
  -3.72643583e-02f, -7.73585960e-02f, -2.34514028e-02f, -2.48385966e-02f, -7.83626214e-02f, -7.73177743e-02f, -1.16315465e-02f, -6.73195645e-02f, -6.19983040e-02f, -9.75478888e-02f,
  -1.49975508e-01f, 1.25661701e-01f, 1.03478678e-01f, -9.64988321e-02f, -9.96863693e-02f, -4.03935909e-02f, 1.84598844e-02f, -1.01952866e-01f, -6.98517337e-02f, 3.54043283e-02f,
  1.76110864e-01f, -1.28836572e-01f, -3.01438570e-01f, 3.40056382e-02f, 9.85271037e-02f, 2.24945098e-01f, -3.19887549e-02f, 5.36323115e-02f, -3.32640082e-01f, 1.72854409e-01f,
  2.37873167e-01f, -8.55081379e-02f, -2.28304580e-01f, 2.98391789e-01f, 4.54328358e-02f, -2.06925109e-01f, 2.71352202e-01f, 1.69913143e-01f, -1.27871931e-01f, 1.00825988e-01f,
  8.11962783e-02f, 4.11085933e-01f, 5.33434451e-02f, 1.68055207e-01f, 2.31886134e-01f, -5.53123057e-02f, 2.66867697e-01f, -3.13983932e-02f, 1.50860757e-01f, 2.20717162e-01f,
  9.37616974e-02f, -2.93147340e-02f, 5.64498408e-03f, -6.41062260e-02f, 1.21482007e-01f, 7.93515444e-02f, -1.19132698e-02f, -5.13003916e-02f, 1.20466936e-03f, -3.56867984e-02f,
  -4.89569530e-02f, -7.46682845e-03f, 4.84613255e-02f, -6.12119772e-02f, 6.04711995e-02f, 6.76668510e-02f, -5.93412928e-02f, -4.88072522e-02f, -8.32739025e-02f, 8.93547724e-04f,
  -1.81992039e-01f, -2.12713387e-02f, -1.07963048e-01f, 3.30545679e-02f, -1.02864206e-01f, -3.93593349e-02f, -1.13528408e-01f, 2.47909129e-02f, -6.39356896e-02f, 4.58704978e-02f,
  9.96343717e-02f, -5.12180291e-02f, 2.12011882e-03f, -5.30369021e-02f, 8.47174749e-02f, -3.73777226e-02f, -4.78386022e-02f, 4.79968078e-02f, -6.07557446e-02f, 8.05520639e-02f,
  -1.13763034e-01f, 3.21148485e-02f, 5.35067506e-02f, -4.75124158e-02f, 3.92521992e-02f, 8.42614993e-02f, -6.55500144e-02f, 4.62087840e-02f, -8.70634690e-02f, -2.18047705e-02f,
  -1.07201576e-01f, -1.29538188e-02f, -4.53985222e-02f, 6.15545288e-02f, -8.35362971e-02f, 1.06105302e-02f, 4.84659299e-02f, 5.72347492e-02f, -3.92123125e-02f, 5.43376952e-02f,
  1.16821751e-01f, -4.08271812e-02f, -4.91166562e-02f, 5.24735786e-02f, 8.19250010e-03f, 9.18671936e-02f, -5.32686338e-02f, 9.46455225e-02f, -7.83219114e-02f, -4.52216947e-03f,
  1.71502888e-01f, -3.64569873e-02f, -1.25182215e-02f, -4.18609045e-02f, -5.10885045e-02f, 9.63717774e-02f, -1.27265397e-02f, -1.16137065e-01f, 1.20014800e-02f, 1.20075859e-01f,
  4.39656675e-02f, 8.78154486e-02f, -8.04115683e-02f, -1.29837871e-01f, 5.27467765e-02f, -5.12672239e-04f, 9.00662690e-02f, 9.82298777e-02f, -6.74912110e-02f, -5.82167208e-02f,
  1.46059006e-01f, -2.91257232e-01f, -1.49779797e-01f, -3.05535585e-01f, -9.29517299e-02f, -1.29100248e-01f, -2.20284015e-01f, -2.17838824e-01f, -1.81065321e-01f, -2.72189081e-01f,
  -1.97762400e-01f, -5.56704998e-02f, 2.40519866e-01f, -3.23748201e-01f, 2.82953769e-01f, 1.21726327e-01f, -3.18552405e-01f, -1.32334948e-01f, -8.90850425e-02f, -1.81425273e-01f,
  -1.21757552e-01f, -1.45188212e-01f, -6.32792562e-02f, -1.64075688e-01f, -2.71396935e-01f, -2.35469773e-01f, 1.12230390e-01f, 3.72839756e-02f, -2.08123043e-01f, -9.60044339e-02f,
  3.67210656e-02f, 6.80781156e-02f, 2.80460604e-02f, 2.80944183e-02f, 9.45993792e-03f, 9.06720608e-02f, -3.22833471e-02f, 1.51650205e-01f, -2.74256337e-02f, -4.46543768e-02f,
  7.46228248e-02f, 8.64610150e-02f, -1.42024830e-01f, -2.82636955e-02f, 1.34849120e-02f, -2.60193609e-02f, -1.09950639e-02f, -1.02422953e-01f, -1.63508058e-01f, 5.10435887e-02f,
  -5.77923842e-02f, 6.67021871e-02f, -1.12519942e-01f, -9.31989867e-03f, -3.12249959e-02f, -1.80641398e-01f, -4.54345066e-03f, 3.21561322e-02f, -4.59981188e-02f, 4.56611924e-02f,
  1.86553076e-02f, -4.61738836e-03f, 1.06286861e-01f, -5.36211282e-02f, 7.17650354e-02f, 3.89491692e-02f, 8.74633086e-04f, 1.84406191e-02f, 2.31377017e-02f, -1.22993905e-02f,
  7.03526137e-04f, -1.94724817e-02f, 4.21525612e-02f, -1.93206128e-02f, 3.98358367e-02f, 1.40149668e-02f, 3.60566676e-02f, -3.02312616e-03f, -7.43716881e-02f, -6.50358871e-02f,
  3.01096272e-02f, -3.24475691e-02f, 3.09137115e-03f, -1.69459153e-02f, 3.21524367e-02f, -2.06814650e-02f, 2.50471924e-02f, -7.20273610e-03f, 1.04310131e-02f, 1.27767101e-01f,
  -9.44690853e-02f, -9.71241072e-02f, -9.69787315e-02f, -2.29753484e-03f, 6.99906349e-02f, -2.53409017e-02f, 4.39586565e-02f, -1.59802243e-01f, -1.42392209e-02f, 1.10377613e-02f,
  -1.83914863e-02f, -1.53666679e-02f, -4.24929662e-03f, -1.41183197e-01f, -1.72087207e-01f, -1.00760527e-01f, 6.66411147e-02f, -4.02220078e-02f, 1.66949220e-02f, -2.09998023e-02f,
  -2.93243527e-02f, 5.13190031e-02f, 1.40229508e-01f, -5.68664782e-02f, -1.55833308e-02f, 1.51782855e-02f, -3.83151276e-03f, 9.80983004e-02f, 1.83659807e-01f, -1.27837747e-01f,
  -7.09486231e-02f, -1.99318856e-01f, -2.85202324e-01f, -2.51703411e-01f, 3.60394597e-01f, 1.87026545e-01f, 2.19966788e-02f, 2.17657149e-01f, -1.53620794e-01f, 1.85840860e-01f,
  4.39006910e-02f, -3.22697103e-01f, -8.69613886e-02f, -4.02520686e-01f, -2.85292923e-01f, -3.56797010e-01f, -2.11564317e-01f, -1.60002932e-01f, -1.32550210e-01f, 1.47712469e-01f,
  -1.16198510e-01f, -6.19220026e-02f, -2.18087569e-01f, 3.38126451e-01f, 1.49083644e-01f, 2.14282423e-01f, 3.27166885e-01f, 1.71779498e-01f, 1.05624743e-01f, -1.52294606e-01f,
  -8.65509883e-02f, -6.93629906e-02f, -5.15689962e-02f, -1.25977397e-01f, 1.29107580e-01f, 1.35565653e-01f, 8.26194808e-02f, -4.29888032e-02f, -3.61136235e-02f, -6.70140237e-02f,
  -5.11308666e-03f, -2.32464895e-02f, -1.37635931e-01f, -7.12599978e-02f, 3.20021994e-02f, 4.31647860e-02f, -1.38000295e-01f, 7.41475150e-02f, -7.80291036e-02f, -1.21856406e-01f,
  -9.75788683e-02f, 4.95640002e-02f, 5.14404923e-02f, 1.84766818e-02f, -6.22283109e-03f, 3.67912091e-02f, 6.92433715e-02f, 3.30453515e-02f, 7.95312971e-02f, -1.32006677e-02f,
  5.84879220e-02f, 1.01540543e-01f, 5.13685755e-02f, -1.06020965e-01f, 1.62574623e-04f, 5.86542999e-03f, -7.37716854e-02f, -1.26860529e-01f, 3.21973115e-02f, -1.37013895e-02f,
  5.86971976e-02f, -1.17472075e-01f, -2.23511495e-02f, 2.31537241e-02f, 2.28264127e-02f, -9.61125642e-02f, 3.38026918e-02f, -4.99738567e-02f, 1.17610738e-01f, -2.64684316e-02f,
  -7.95488954e-02f, 5.90778403e-02f, -3.39336582e-02f, 1.22930594e-01f, -8.29269215e-02f, 3.71889248e-02f, 5.81126325e-02f, -4.24384028e-02f, -4.47660051e-02f, 8.07120278e-02f,
  8.02897662e-02f, 1.23416439e-01f, 1.99161563e-02f, -6.63797706e-02f, -7.42336437e-02f, 1.24269180e-01f, -1.46248215e-03f, -9.65914428e-02f, -2.38288995e-02f, 2.21569892e-02f,
  1.25711396e-01f, 9.47453305e-02f, 1.74712583e-01f, -4.38564420e-02f, -6.16639331e-02f, 1.29871592e-01f, 1.22865535e-01f, 6.39297515e-02f, 1.16759762e-01f, -1.86123382e-02f,
  8.47199261e-02f, 5.19117154e-02f, 8.84112343e-02f, 4.17151973e-02f, -3.39797176e-02f, 1.24299094e-01f, 1.00759998e-01f, -4.33236472e-02f, 1.37617989e-02f, -7.21077959e-04f,
  7.84744918e-02f, -2.33681276e-01f, -2.52405852e-01f, -2.58295536e-01f, 4.25283611e-02f, -1.31383419e-01f, -1.73289135e-01f, -6.97513968e-02f, -2.02470824e-01f, -1.35600343e-01f,
  -6.85508922e-02f, -1.58400327e-01f, 7.48732165e-02f, -3.51866156e-01f, 1.14318905e-02f, -1.03852548e-01f, -1.04133844e-01f, -8.36628750e-02f, -3.77053395e-02f, 9.73268673e-02f,
  1.32909073e-02f, -4.27848585e-02f, 1.00021847e-01f, 1.26353636e-01f, -3.21442820e-02f, 1.95611760e-01f, 2.55686015e-01f, 2.41068348e-01f, 1.22976489e-02f, 7.65295997e-02f,
  -3.44559811e-02f, -5.25254458e-02f, -1.94740947e-02f, 2.36893259e-03f, 1.33242443e-01f, 1.32594615e-01f, 1.00222796e-01f, -9.66729410e-03f, -8.59462321e-02f, 8.47432017e-02f,
  7.01014921e-02f, -1.16160356e-01f, 1.94053184e-02f, 6.79782331e-02f, -9.94013436e-03f, -1.46654055e-01f, 1.77995414e-02f, -8.81641544e-03f, -5.11276908e-02f, -7.47317746e-02f,
  -1.11782677e-01f, -1.20952837e-01f, -1.37890443e-01f, -1.61325499e-01f, -1.22230304e-02f, -9.74599458e-03f, -1.49613647e-02f, 1.01355985e-01f, -8.46262723e-02f, -9.90771409e-03f,
  -2.39778589e-02f, 7.10699707e-02f, -5.40490970e-02f, 1.79110263e-02f, 1.67842079e-02f, 5.09791635e-02f, -5.23474999e-02f, -2.90877167e-02f, 2.52685733e-02f, -2.60690004e-02f,
  4.28340510e-02f, -7.05079222e-03f, -1.09463088e-01f, -2.46307552e-02f, 1.23909965e-01f, -2.49704719e-03f, 1.31093953e-02f, 3.79172713e-02f, -1.52441366e-02f, -7.33767003e-02f,
  1.71805266e-02f, -5.11276769e-03f, 8.92769545e-02f, -5.76869352e-03f, -1.64657921e-01f, -2.08497811e-02f, -7.98187256e-02f, 1.73889585e-02f, 8.66958797e-02f, -6.42139539e-02f,
  1.10493951e-01f, 3.06590479e-02f, 1.01854801e-02f, -1.18576782e-02f, -1.41669735e-02f, 2.09181234e-02f, -1.19621947e-01f, 3.22443880e-02f, 3.27390507e-02f, 2.30288338e-02f,
  5.64200468e-02f, 7.17912689e-02f, 1.36565432e-01f, 5.84597588e-02f, 2.74663661e-02f, -2.90313251e-02f, 8.30711052e-02f, -9.33102053e-03f, 9.53611210e-02f, 3.86624932e-02f,
  5.93543239e-02f, 9.28856581e-02f, -4.77866419e-02f, 2.06634216e-02f, -1.21873263e-02f, -5.45255728e-02f, 1.08143374e-01f, 8.08551833e-02f, -6.21089153e-02f, -1.65247396e-01f,
  2.75826365e-01f, -1.92426443e-01f, -1.26479149e-01f, 1.61933467e-01f, 5.37956282e-02f, -1.09393522e-01f, -2.43863180e-01f, 1.79523960e-01f, 2.88265055e-05f, -1.98148340e-01f,
  1.80718243e-01f, -2.44839400e-01f, -2.54337579e-01f, 3.62128407e-01f, 2.25312084e-01f, -2.07570598e-01f, 2.20340043e-01f, 3.96951474e-02f, 5.31810597e-02f, 1.89958304e-01f,
  2.47346774e-01f, 3.74587834e-01f, 1.29116088e-01f, 1.56915054e-01f, 1.85596451e-01f, 1.96754299e-02f, 8.15005749e-02f, -6.70158193e-02f, 1.90837607e-01f, -4.20338381e-03f,
  -4.35858499e-03f, 8.29472840e-02f, 2.70122420e-02f, -4.39026617e-02f, -4.85773720e-02f, -1.27138505e-02f, -3.44646201e-02f, -1.21358685e-01f, 2.40904316e-02f, -2.69715823e-02f,
  -8.98265094e-02f, 1.12452386e-02f, 7.98147693e-02f, -2.84256767e-02f, 1.33762106e-01f, 4.87484224e-02f, -1.03335958e-02f, -1.33708894e-01f, -2.15472188e-02f, -2.97689950e-03f,
  -9.42754298e-02f, -8.60246271e-02f, 1.30594850e-01f, -9.50996429e-02f, 1.52993686e-02f, -9.51215567e-04f, 3.64057869e-02f, -1.26794456e-02f, -3.00342478e-02f, 3.26833427e-02f,
  1.05236277e-01f, -9.69638303e-02f, -2.42734943e-02f, 1.30931307e-02f, -1.35987727e-02f, 3.42324153e-02f, -6.45522354e-03f, -1.07053049e-01f, 3.10661532e-02f, 3.90367322e-02f,
  -6.08363189e-02f, 6.68489933e-02f, 2.58547962e-02f, 3.70670073e-02f, 6.30449578e-02f, -5.04627591e-03f, 3.54685746e-02f, 1.96725018e-02f, 7.85232559e-02f, -6.58738799e-03f,
  -1.09262923e-02f, 1.59928780e-02f, -8.20064768e-02f, 1.35508925e-02f, 4.97045815e-02f, -1.05914056e-01f, 8.01874921e-02f, -7.04983473e-02f, -3.01006809e-02f, -3.99251580e-02f,
  7.90014490e-02f, -6.93535134e-02f, -3.66543345e-02f, 5.20817451e-02f, -9.19602215e-02f, 9.53893661e-02f, -2.29917411e-02f, 8.19439441e-03f, -6.08425550e-02f, 4.18726094e-02f,
  2.37100497e-02f, 2.43994221e-02f, 4.69746022e-03f, 1.14171460e-01f, 4.52693328e-02f, -6.69722110e-02f, 2.14058738e-02f, -4.74163331e-02f, 1.07607216e-01f, 5.28146029e-02f,
  1.19089354e-02f, 1.31403338e-02f, 8.57212991e-02f, -3.07832398e-02f, -2.05557570e-02f, -1.02107488e-01f, -3.68308797e-02f, -2.42604837e-02f, 1.05431445e-01f, -7.25908726e-02f,
  -4.15718496e-01f, 1.50630370e-01f, -1.12540931e-01f, -6.79100677e-02f, 2.78279465e-02f, 4.38769281e-01f, 3.44171137e-01f, -9.22718346e-02f, -6.16652369e-02f, 2.58534819e-01f,
  2.56623030e-01f, -1.34241268e-01f, 1.88692287e-01f, 3.00963849e-01f, 3.26066405e-01f, 3.37731630e-01f, 1.79530621e-01f, 1.63739011e-01f, -6.49068058e-02f, -9.49900001e-02f,
  -1.20688424e-01f, 2.50944644e-01f, 1.31433100e-01f, -6.93756863e-02f, 9.32727680e-02f, -2.36979812e-01f, -1.30235165e-01f, -1.28161967e-01f, 1.54286027e-01f, 1.70671314e-01f,
  1.79509129e-02f, -3.88644576e-01f, -5.40278144e-02f, -6.79733679e-02f, 8.46475735e-02f, -1.50005147e-01f, -5.23123741e-02f, 7.66769052e-02f, -7.18954355e-02f, -4.91007268e-02f,
  -6.19083941e-02f, -1.14943072e-01f, -5.01638874e-02f, -1.27533954e-02f, -1.69156119e-02f, 2.66683139e-02f, 3.54384519e-02f, 6.02631681e-02f, 1.29707800e-02f, -2.22646724e-02f,
  2.03982741e-03f, 1.87533665e-02f, 2.46063247e-02f, 1.58381388e-01f, -3.67774279e-03f, 9.07162502e-02f, -4.29166965e-02f, 4.38166857e-02f, 1.61803924e-02f, -3.44885439e-02f,
  -9.63013843e-02f, -1.07866198e-01f, -6.22433163e-02f, 9.53833684e-02f, 3.42778787e-02f, 2.55371071e-02f, 1.03146985e-01f, -4.86600271e-04f, 6.02216572e-02f, 1.32583544e-01f,
  7.41553085e-04f, -2.95850425e-03f, -1.53513804e-01f, 5.45873540e-03f, 3.43069397e-02f, -7.93225691e-02f, 8.67511481e-02f, -3.97956446e-02f, -9.44977254e-03f, 9.03020501e-02f,
  6.87523410e-02f, -4.68490086e-03f, -7.11471355e-03f, -4.21833135e-02f, -9.03211460e-02f, -5.22992127e-02f, 4.08867560e-02f, 1.54412035e-02f, 2.63690632e-02f, 5.03715202e-02f,
  1.10109732e-01f, -1.60631359e-01f, 1.44195193e-02f, -3.05452701e-02f, 6.74054772e-03f, -4.19337973e-02f, -5.99161647e-02f, 1.81232970e-02f, 9.96299908e-02f, -9.99682993e-02f,
  -1.48725122e-01f, -8.00001770e-02f, -4.63290401e-02f, -5.72153293e-02f, -6.86975494e-02f, -4.18522172e-02f, 4.02560867e-02f, -1.45299053e-02f, 1.08460195e-01f, 4.03922088e-02f,
  1.33586779e-01f, -4.09438051e-02f, 4.50729765e-02f, -6.19267486e-03f, -1.44560352e-01f, -1.86806638e-02f, -4.56563421e-02f, -6.08086921e-02f, -4.10346650e-02f, 1.03321202e-01f,
  9.13246498e-02f, 2.42950827e-01f, 2.03328311e-01f, 1.67508185e-01f, -3.09702754e-01f, -1.37835115e-01f, 1.09123044e-01f, -8.59859288e-02f, 3.53382230e-01f, 4.07162942e-02f,
  -2.90493935e-01f, 3.53522539e-01f, 3.54189128e-02f, -5.21886498e-02f, 2.96990633e-01f, 1.10993065e-01f, 1.08736515e-01f, -1.96409672e-02f, 1.04540102e-01f, 2.25424066e-01f,
  1.06281251e-01f, -5.25362641e-02f, -3.67267244e-02f, -8.66582915e-02f, -1.75159991e-01f, 1.18246101e-01f, -7.54260942e-02f, -4.38640229e-02f, -1.62641972e-01f, -1.26368999e-01f,
  -2.94184480e-02f, 1.35597005e-01f, -4.77832481e-02f, 9.46482420e-02f, -6.75051659e-02f, -1.15096418e-03f, -1.07153356e-01f, 1.05040306e-02f, 6.09375983e-02f, 5.09749539e-02f,
  1.47526965e-01f, -8.80721807e-02f, 4.83047068e-02f, -6.96715564e-02f, -6.23341426e-02f, -4.84397113e-02f, 2.25904100e-02f, -1.30990565e-01f, 9.65741351e-02f, -1.06757008e-01f,
  -1.71143829e-03f, -2.77438629e-02f, 2.65135709e-03f, 1.61641419e-01f, 6.88154772e-02f, -8.28645006e-03f, 1.49738714e-01f, 2.66502853e-02f, 3.68245840e-02f, 1.56153083e-01f,
  7.52304271e-02f, -8.32650885e-02f, 1.34634215e-03f, -1.56920686e-01f, 3.33174542e-02f, -7.57090375e-02f, 5.76768108e-02f, -7.29015917e-02f, 8.55457410e-02f, -1.14087546e-02f,
  -2.07044333e-02f, -6.20997278e-03f, -8.71646032e-03f, -4.11795191e-02f, 9.36107337e-02f, 1.63466297e-02f, -2.69125756e-02f, -3.90462279e-02f, 1.14738215e-02f, -6.75323755e-02f,
  -3.42109501e-02f, -1.72428566e-03f, -4.91175912e-02f, -7.45542571e-02f, -1.14433981e-01f, 5.94611056e-02f, 2.73629576e-02f, 5.93227260e-02f, -6.94547147e-02f, 2.84436275e-03f,
  1.02528803e-01f, 3.93437177e-01f, 5.79026043e-02f, 3.84943932e-02f, 1.10312715e-01f, 1.68963950e-02f, 9.73140895e-02f, 9.95107964e-02f, 2.61537135e-01f, 1.27823308e-01f,
  2.71882154e-02f, 8.30128714e-02f, 8.17358270e-02f, -1.68877497e-01f, 1.00744322e-01f, 7.35612661e-02f, 1.92671970e-01f, 1.27720699e-01f, 7.13065863e-02f, -3.09772836e-03f,
  -3.51379327e-02f, -2.29859222e-02f, 1.42094806e-01f, -2.50952039e-03f, 1.06848823e-02f, 7.42217945e-03f, -1.74553823e-02f, 3.98619436e-02f, 6.44607842e-03f, 3.39437090e-02f,
  -1.67924494e-01f, 1.93490505e-01f, -2.35342965e-01f, 1.85644493e-01f, -4.47878718e-01f, 2.39321887e-01f, 5.49380958e-01f, -6.94017038e-02f, 1.00135505e-01f, 3.98994923e-01f,
  2.23651409e-01f, 1.74120039e-01f, 1.69598147e-01f, 4.91164804e-01f, -2.68161565e-01f, 2.71553963e-01f, 3.06067377e-01f, 3.00750375e-01f, -1.16411097e-01f, 1.20504335e-01f,
  -2.36583084e-01f, 9.21863168e-02f, 6.38285875e-02f, -7.73697793e-02f, 1.00190528e-01f, -9.85440016e-02f, -1.10793650e-01f, -1.40597478e-01f, 1.10366419e-01f, -7.02613890e-02f,
  6.52280822e-02f, 5.25288321e-02f, -8.90957117e-02f, 5.94762117e-02f, -7.21065179e-02f, 6.21194951e-02f, 1.34511720e-02f, -7.57211149e-02f, -5.33208735e-02f, 6.22812882e-02f,
  4.79270220e-02f, -6.92733303e-02f, -9.07282345e-04f, 2.28000134e-02f, -2.94443336e-03f, -1.50032118e-01f, -1.44568412e-03f, -4.98945173e-03f, 7.30399461e-03f, -1.17337845e-01f,
  2.03680694e-02f, 3.58196422e-02f, 5.77338366e-03f, 6.62871450e-02f, -6.94525465e-02f, 9.62523520e-02f, 5.46570458e-02f, 1.41699761e-02f, -2.56357528e-03f, -8.27116892e-02f,
  -8.32704604e-02f, 8.22050199e-02f, 3.00501976e-02f, -2.10363232e-03f, -7.52186701e-02f, -3.90599370e-02f, 9.73381773e-02f, 2.30445992e-02f, -3.55729684e-02f, 2.48570088e-02f,
  -2.22127549e-02f, -3.18879820e-02f, 1.05634658e-02f, 8.56561214e-02f, 1.86525211e-02f, 6.13880195e-02f, 3.53294052e-02f, 4.32510162e-03f, 6.63111880e-02f, -4.88048196e-02f,
  4.68430519e-02f, -1.71750244e-02f, 5.33236936e-02f, 2.84686107e-02f, 5.58898598e-02f, -7.78568313e-02f, 3.82896401e-02f, -4.87898178e-02f, -1.90571398e-02f, -1.27549559e-01f,
  1.50918797e-01f, 1.53481960e-01f, 1.25129847e-02f, 1.46230245e-02f, -1.88317206e-02f, -5.40247597e-02f, -9.64685716e-03f, -6.45000190e-02f, -5.15420288e-02f, -6.62799254e-02f,
  -1.14518568e-01f, 2.30537429e-02f, -8.19722116e-02f, -4.65107411e-02f, -2.64766905e-02f, -3.52801532e-02f, 1.63431108e-01f, -6.99497610e-02f, 4.40835170e-02f, -1.11409873e-01f,
  -2.42980979e-02f, 3.47891152e-02f, 3.39915156e-02f, 1.03803270e-01f, -5.00214249e-02f, -3.22852843e-02f, -6.35613650e-02f, -7.12262606e-03f, -1.92907229e-01f, -4.20776429e-03f,
  3.80649656e-01f, -2.60855466e-01f, 4.14754711e-02f, 2.49910161e-01f, 2.15410098e-01f, -4.94274050e-02f, 1.12412021e-01f, 1.10892318e-01f, 2.84163773e-01f, -2.75049657e-01f,
  -6.61250427e-02f, -2.56102353e-01f, -2.56179214e-01f, 4.86721238e-03f, -8.77881981e-03f, -1.25488006e-02f, 9.88840535e-02f, -1.88968778e-01f, 1.12829320e-01f, 3.02813686e-02f,
  2.24783480e-01f, 6.08294085e-02f, -7.28543699e-02f, -9.95893702e-02f, 1.07626364e-01f, 3.28750610e-02f, -1.88081354e-01f, -1.59630775e-01f, -2.49838009e-01f, -7.31190965e-02f,
  1.20466962e-01f, 2.29936317e-01f, 9.44381878e-02f, -7.20356265e-03f, 2.99278647e-02f, -1.40068019e-02f, -1.45541593e-01f, -7.25495890e-02f, 1.15816221e-01f, -1.21279079e-02f,
  -1.23948613e-02f, -1.22996919e-01f, -1.27367657e-02f, 2.04841569e-02f, 5.98659404e-02f, 3.31446528e-02f, 6.92724660e-02f, 8.52643400e-02f, -3.44414338e-02f, -9.06205550e-02f,
  6.37707859e-02f, -1.13156617e-01f, -6.43870467e-03f, -8.07097629e-02f, 1.47369225e-02f, 5.71280085e-02f, -1.27261430e-01f, -6.97937235e-02f, -1.47347316e-01f, 2.76440028e-02f,
  -6.49702027e-02f, 7.98593648e-03f, 2.04564389e-02f, 1.12470694e-01f, 1.17647514e-01f, 1.32817551e-01f, 3.64306085e-02f, 1.21643720e-02f, 9.45516378e-02f, -9.09339190e-02f,
  -3.68246436e-02f, 8.78444090e-02f, -2.26945374e-02f, -8.40940233e-03f, -4.08385741e-03f, 4.17563990e-02f, -1.16419800e-01f, -2.92628165e-02f, -4.00101803e-02f, 5.35189286e-02f,
  -8.27511698e-02f, 3.11265327e-02f, 7.08487034e-02f, -3.86447348e-02f, 5.10895364e-02f, -5.72523400e-02f, 8.51338431e-02f, -1.91550441e-02f, 6.06690869e-02f, -1.23336062e-01f,
  -4.38277237e-02f, -8.86154920e-02f, 3.61710563e-02f, 3.23389657e-02f, 6.90668896e-02f, 1.70257259e-02f, 1.44168213e-01f, -4.08718884e-02f, -8.27508643e-02f, -1.57803707e-02f,
  -7.96737447e-02f, 2.48889066e-02f, 5.15090907e-03f, 6.26297435e-03f, -1.29296944e-01f, 6.47919476e-02f, -1.23210706e-01f, 1.82393251e-03f, -1.45780295e-01f, -1.24330364e-01f,
  -1.07693672e-02f, -1.18970178e-01f, -6.37501013e-03f, 6.00379743e-02f, -7.97032043e-02f, -6.59182817e-02f, -7.17032235e-03f, -1.85636543e-02f, -1.23951256e-01f, 2.88629755e-02f,
  1.31298661e-01f, 1.38503596e-01f, 1.18259564e-01f, 2.21665114e-01f, -1.05748788e-01f, -2.76083738e-01f, -1.65198639e-01f, 7.78452083e-02f, 2.27487594e-01f, 8.68401781e-04f,
  -2.15069562e-01f, 3.47582459e-01f, -2.55018175e-01f, -1.88829210e-02f, -3.08255851e-01f, -1.93482190e-01f, -1.94259673e-01f, 6.57425448e-03f, 5.02971858e-02f, 3.15898880e-02f,
  -1.09111659e-01f, -4.08569932e-01f, -1.22425944e-01f, -2.69962609e-01f, -8.37794226e-03f, 2.27863669e-01f, -1.87906131e-01f, -1.56021953e-01f, 3.80901173e-02f, -1.38095334e-01f,
  9.82315019e-02f, 1.27612084e-01f, 1.10513560e-01f, 7.48272464e-02f, -4.80490141e-02f, -1.65422671e-02f, -7.85071179e-02f, -5.41131618e-03f, -1.64495539e-02f, 4.71641943e-02f,
  2.60623209e-02f, 1.75357908e-02f, -5.87512143e-02f, -3.91372591e-02f, -1.87120736e-02f, 7.09367022e-02f, -1.96673162e-02f, 8.17375258e-02f, 6.12511970e-02f, 3.23446607e-03f,
  -1.06842844e-02f, 9.08527374e-02f, 1.82449855e-02f, 5.64440079e-02f, -1.64125171e-02f, -3.19668576e-02f, -1.07553661e-01f, 2.32192539e-02f, 1.90130454e-02f, 6.23489060e-02f,
  -5.51826097e-02f, -1.17212765e-01f, -3.79705690e-02f, 8.96906555e-02f, -9.55202356e-02f, 2.41257418e-02f, -3.58513631e-02f, 1.51909655e-02f, 4.79983389e-02f, 1.87887587e-02f,
  3.99002545e-02f, 1.36558563e-01f, -6.36636540e-02f, -2.92596687e-02f, -3.06465235e-02f, 7.20138997e-02f, 5.76076768e-02f, 3.53997871e-02f, 8.84887129e-02f, 3.24901827e-02f,
  -8.61929804e-02f, -1.61616802e-02f, 1.40109241e-01f, -1.38282997e-03f, -6.49055392e-02f, -3.75821404e-02f, -2.07515862e-02f, 1.13787375e-01f, -4.58438834e-03f, -1.38659701e-01f,
  7.55409226e-02f, -1.16129093e-01f, 1.00193545e-01f, 1.39155969e-01f, -2.33989097e-02f, -4.56931181e-02f, -1.29764766e-01f, 1.05615951e-01f, -1.38003856e-01f, -1.27782300e-01f,
  -1.11356422e-01f, -1.02254394e-02f, -2.06918549e-02f, 1.28447995e-01f, -7.31531605e-02f, -1.50968730e-01f, -6.07402250e-02f, 6.42056242e-02f, -6.97094873e-02f, -1.34826023e-02f,
  2.15905011e-02f, -7.64195025e-02f, -3.45286615e-02f, -5.11455834e-02f, -3.56369503e-02f, -3.82732302e-02f, 1.07441142e-01f, 2.71815378e-02f, -1.13472752e-01f, -4.19154670e-03f,
  1.17089272e-01f, -3.22388485e-02f, -2.25869894e-01f, -1.36588980e-02f, -1.34868845e-01f, -2.51043648e-01f, -1.99303553e-01f, -1.28737643e-01f, -1.55280322e-01f, 1.91787243e-01f,
  1.08124472e-01f, 7.40963966e-02f, 1.14525214e-01f, 2.81526688e-02f, -2.36969262e-01f, -5.15414868e-03f, -1.08743653e-01f, -9.67055038e-02f, -7.14134425e-02f, 9.45816189e-02f,
  -7.49066323e-02f, 1.29168049e-01f, 6.13786653e-02f, 1.20780952e-01f, 6.19859472e-02f, 4.05835882e-02f, 1.35439858e-01f, 1.71659291e-01f, 6.52371868e-02f, -8.03105682e-02f,
  5.36661558e-02f, 2.64394701e-01f, -6.41164035e-02f, -4.64435928e-02f, 5.86944409e-02f, 1.33425714e-02f, -3.68994940e-03f, 2.46382169e-02f, 3.20521146e-02f, 7.59837627e-02f,
  7.85202682e-02f, 7.14101654e-04f, -1.22936584e-01f, -1.19226696e-02f, 1.01148766e-02f, 5.17615192e-02f, -1.38761431e-01f, 2.21928377e-02f, -3.40399495e-03f, 9.25440267e-02f,
  5.03500476e-02f, 1.01611607e-01f, -3.27548385e-02f, 2.96981242e-02f, 3.73763666e-02f, -3.63133289e-02f, 9.33668017e-02f, 1.12774588e-01f, 6.42185984e-03f, -7.33115897e-02f,
  1.31123066e-01f, 8.80718827e-02f, -5.92993433e-03f, -5.53227551e-02f, 6.09164201e-02f, 8.29598233e-02f, -7.87607506e-02f, -1.00364558e-01f, -9.38110352e-02f, 5.17620072e-02f,
  -6.02669828e-02f, -2.90236976e-02f, 1.09152652e-01f, 2.97600161e-02f, 9.96762980e-03f, 9.93221551e-02f, 1.35587929e-02f, -1.46968151e-03f, -1.12922676e-01f, -1.38933688e-01f,
  9.12590623e-02f, -8.14773142e-02f, -1.26631811e-01f, 6.37072623e-02f, -3.96245234e-02f, 1.49852177e-02f, 1.13562688e-01f, 4.33327630e-02f, -5.82787395e-03f, -1.60605028e-01f,
  6.15045130e-02f, 2.08752036e-01f, 1.90397687e-02f, -1.00526012e-01f, 3.94701324e-02f, 9.62242261e-02f, -4.04241048e-02f, -7.25711957e-02f, -1.41876265e-02f, -3.33973914e-02f,
  5.95325138e-03f, -2.38490086e-02f, 4.08644080e-02f, 2.62449794e-02f, -1.43866450e-01f, -8.25827569e-02f, 3.98826227e-02f, -1.34510044e-02f, -2.63684578e-02f, -4.30076122e-02f,
  1.39485806e-01f, 1.15534216e-01f, 1.40166469e-02f, -9.04207379e-02f, 1.48513783e-02f, 1.25001013e-01f, -9.28688645e-02f, 3.84996906e-02f, 7.32377693e-02f, -1.03435516e-01f,
  -6.38728514e-02f, -1.60347223e-01f, -1.51573747e-01f, 9.47587788e-02f, -2.22159866e-02f, -3.37189496e-01f, -4.08179373e-01f, 1.02229416e-02f, -2.62841098e-02f, -1.23360798e-01f,
  -1.26515388e-01f, 2.04624552e-02f, -1.75593033e-01f, -1.58893079e-01f, 2.07565874e-01f, 1.44226942e-02f, -4.95222211e-02f, -3.41769494e-02f, 1.29041776e-01f, -1.01333737e-01f,
  1.43178746e-01f, -4.61681336e-02f, -1.57498717e-02f, 8.72109756e-02f, -1.75699800e-01f, 9.48730260e-02f, 3.38604420e-01f, -5.96414739e-03f, 1.10425241e-01f, 1.49331167e-02f,
  -1.56779587e-01f, 5.64981201e-05f, -2.83816028e-02f, -1.28289843e-02f, 1.02977948e-02f, -5.07246330e-02f, 4.44994047e-02f, -7.57170394e-02f, 9.69433598e-03f, -1.21936746e-01f,
  2.18013115e-02f, 9.42471921e-02f, -8.06499645e-02f, -2.95624766e-03f, -1.02785148e-01f, 1.07460484e-01f, 3.81204970e-02f, 6.10629208e-02f, 1.61659885e-02f, -7.24626184e-02f,
  -4.46002297e-02f, -4.01629843e-02f, 8.74344036e-02f, 1.34143963e-01f, 9.44510028e-02f, -6.53008604e-03f, -2.08604131e-02f, -8.32101926e-02f, -3.23932469e-02f, 2.31318343e-02f,
  8.83281454e-02f, 5.74825238e-03f, -8.47359970e-02f, -1.07217118e-01f, -8.79940093e-02f, -4.08409126e-02f, 1.01848645e-02f, 5.74251041e-02f, 4.90639471e-02f, -5.85276708e-02f,
  -1.78798307e-02f, -5.50442524e-02f, 2.56443527e-02f, 5.81921972e-02f, -5.55394404e-02f, -6.97405264e-02f, -8.75135045e-03f, 8.18605497e-02f, 1.01735696e-01f, 8.60523954e-02f,
  -2.23241076e-02f, -9.77759948e-04f, -6.35007694e-02f, 1.83250215e-02f, -1.52641863e-01f, 4.42208461e-02f, 7.62953386e-02f, -1.01702616e-01f, -3.63870040e-02f, 5.63493278e-03f,
  1.28823861e-01f, 2.31504545e-01f, 8.44963361e-03f, -3.21969669e-03f, -2.02269712e-03f, -6.16330691e-02f, -5.69106117e-02f, -1.59629285e-02f, -4.14930023e-02f, 1.54778464e-02f,
  1.60307083e-02f, 9.10905823e-02f, 1.06498443e-01f, 3.64441681e-03f, 1.63140893e-02f, 7.67692402e-02f, 9.86974984e-02f, 5.45043945e-02f, 2.56812125e-02f, 1.39335439e-01f,
  8.11729655e-02f, -1.39331939e-02f, 1.79353803e-02f, -4.20113765e-02f, 8.02660137e-02f, 1.40436918e-01f, -8.91912542e-03f, 2.75424570e-02f, 9.47152972e-02f, -2.16999743e-02f,
  3.29736382e-01f, 9.81487185e-02f, 2.70669729e-01f, 1.33073404e-01f, 1.06446013e-01f, 1.99835934e-03f, 7.66042918e-02f, -3.97987552e-02f, 1.62365332e-01f, -2.38718778e-01f,
  -1.54800579e-01f, 3.23711812e-01f, 5.01040667e-02f, -1.33234233e-01f, 5.53080672e-03f, -1.53328270e-01f, -1.83945939e-01f, -8.02289546e-02f, 1.82618126e-01f, -1.12253405e-01f,
  -4.98410240e-02f, -3.34334135e-01f, -7.43647246e-03f, -2.15826198e-01f, -8.86889454e-03f, -8.02593380e-02f, -2.32427388e-01f, -1.65482104e-01f, -1.06993042e-01f, 4.89951521e-02f,
  -2.86062807e-02f, 1.04214260e-02f, 1.84187368e-01f, -4.55176570e-02f, 2.74642892e-02f, 1.03616877e-03f, 3.91866416e-02f, 2.59077288e-02f, 3.75984386e-02f, 3.54153686e-03f,
  -2.83971755e-03f, -8.75643492e-02f, -7.07229450e-02f, -8.63469839e-02f, 1.40620068e-01f, -1.64750796e-02f, 1.25751391e-01f, 2.25055337e-01f, 2.46475707e-03f, 2.09674045e-01f,
  1.08426332e-01f, 1.95267394e-01f, 1.31164044e-01f, 4.55726534e-02f, 1.37420997e-01f, 3.08504179e-02f, 8.99220183e-02f, 9.05072466e-02f, 2.55754832e-02f, 1.28933713e-01f,
  -2.28084419e-02f, -1.42915025e-02f, -1.33000920e-02f, -1.25170842e-01f, -5.41589223e-02f, 4.91607450e-02f, 3.53124999e-02f, -1.02716647e-01f, -7.26245940e-02f, -5.14201298e-02f,
  1.25034945e-02f, 1.14756107e-01f, 7.10520819e-02f, 7.99045637e-02f, 4.16777693e-02f, 7.10619688e-02f, -3.70142944e-02f, 2.40457095e-02f, -3.07886191e-02f, 1.05278231e-01f,
  -3.85469496e-02f, -6.64847717e-02f, 4.86513153e-02f, -2.03458332e-02f, -1.96883217e-01f, 1.63154956e-03f, 9.48137138e-04f, -4.04055864e-02f, 2.44198577e-03f, -1.52947232e-01f,
  -1.79905117e-01f, -4.43559617e-01f, 1.94839574e-02f, 7.82868546e-03f, -9.46260691e-02f, -3.17182131e-02f, -2.26966310e-02f, -3.88744362e-02f, -3.72320972e-02f, 2.63224430e-02f,
  -2.85802260e-02f, 2.07425188e-02f, -2.38100458e-02f, -5.00532575e-02f, -6.76194131e-02f, -1.75742302e-02f, -1.40796170e-01f, -5.70806451e-02f, -2.08383948e-02f, 1.85671709e-02f,
  4.17686328e-02f, -4.85367142e-02f, 7.61074014e-03f, -1.43549234e-01f, 6.26653135e-02f, -2.20149197e-03f, 5.24653355e-03f, 1.87924094e-02f, 5.56662269e-02f, 7.77606517e-02f,
  -4.62292433e-01f, 1.98129073e-01f, 1.78483948e-01f, -2.79365301e-01f, 2.36930903e-02f, 3.55707169e-01f, 4.40415554e-02f, 1.37070075e-01f, -4.75117862e-02f, -6.44851848e-02f,
  -1.71782617e-02f, -1.19604252e-01f, 2.88922429e-01f, 5.01816114e-03f, 1.62117586e-01f, 1.90419644e-01f, -4.61395532e-02f, -1.59130394e-01f, 2.22590819e-01f, -5.12004010e-02f,
  -2.81549413e-02f, -3.77776772e-02f, 4.40553166e-02f, 1.48970038e-01f, 9.45806131e-02f, -1.55617297e-01f, -7.52126724e-02f, 2.74267137e-01f, -1.58880115e-01f, 2.27162018e-02f,
  -7.32715279e-02f, -1.00646190e-01f, -3.80696543e-02f, 7.12071806e-02f, 7.41856098e-02f, 3.43023520e-03f, -4.69923206e-02f, 6.94953725e-02f, 2.99292095e-02f, 9.10385326e-02f,
  1.30100638e-01f, 3.02727614e-02f, -3.24991904e-02f, 4.06929664e-02f, 1.22070983e-01f, 5.07605709e-02f, 5.11512347e-02f, -4.61568758e-02f, 1.32410139e-01f, 1.20794550e-01f,
  3.35482955e-02f, 1.53750196e-01f, 3.72500382e-02f, -6.01152740e-02f, 4.92425752e-04f, -4.03946824e-03f, -2.97250543e-02f, -8.30308199e-02f, -8.74741599e-02f, -3.44606899e-02f,
  -3.62561494e-02f, 5.75081632e-02f, -7.50612915e-02f, 8.52477252e-02f, -2.25823596e-02f, -8.73560905e-02f, -3.92867215e-02f, -1.02004863e-01f, 5.48677426e-03f, -8.64782482e-02f,
  -8.71443376e-02f, -2.10808635e-01f, -4.75933142e-02f, -3.98998670e-02f, -1.75586399e-02f, -4.87804450e-02f, 5.37910312e-02f, 9.56664532e-02f, -3.36852223e-02f, -8.74291509e-02f,
  9.05716941e-02f, 2.59613153e-02f, -2.01154977e-01f, -1.47646561e-01f, 3.18326876e-02f, 8.14178064e-02f, 7.34667405e-02f, -3.56192328e-02f, 3.21436077e-02f, 2.47277413e-02f,
  6.85714260e-02f, -2.36471817e-01f, -9.17983241e-03f, 9.41708591e-03f, 6.94989637e-02f, -2.46837875e-03f, 1.15651302e-01f, 3.05629075e-02f, 1.47366539e-01f, -2.27998924e-02f,
  -1.03888977e-02f, -8.64603668e-02f, -1.67581718e-02f, -1.16851144e-02f, 3.83332036e-02f, -6.51468290e-03f, -1.66475680e-02f, 5.25169261e-02f, -2.91885808e-02f, 6.41333163e-02f,
  9.80020873e-03f, -2.01560147e-02f, -2.62920931e-02f, -7.66088143e-02f, -2.25029960e-02f, 4.80916314e-02f, -1.20954432e-01f, 4.33836021e-02f, -7.34496117e-02f, -3.74153182e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  2.73925334e-01f, 1.85232580e-01f, 3.45822155e-01f, 2.75853515e-01f, 2.24455148e-01f, 2.40697131e-01f, 4.03666854e-01f, 3.50977749e-01f, 3.65892589e-01f, 2.42082968e-01f,
  2.11588711e-01f, 2.80383855e-01f, 2.61151880e-01f, 2.18343273e-01f, 2.66653717e-01f, 3.50788623e-01f, 2.32047871e-01f, 1.64941773e-01f, 1.17860615e-01f, 2.36325115e-01f,
  3.40987593e-01f, 2.08776429e-01f, 3.56606245e-01f, 2.65435398e-01f, 2.31873304e-01f, 3.67456675e-01f, 2.71652997e-01f, 2.37725109e-01f, 2.78876245e-01f, 3.03024530e-01f,
  2.65809655e-01f, 2.90533155e-01f, 3.33835274e-01f, 2.71717131e-01f, 1.89363047e-01f, 2.27211237e-01f, 1.14162497e-01f, 9.56998616e-02f, 2.70670086e-01f, 1.21333681e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -4.19447422e-02f, 6.67826012e-02f, -1.16954006e-01f, -1.29523007e-02f, 1.04678988e-01f, -1.60731170e-02f, 1.12940818e-01f, -1.54123709e-01f, -1.30689651e-01f, -3.62216309e-02f,
  -8.83856937e-02f, -6.59873560e-02f, -2.13524848e-02f, 1.23208486e-01f, 1.50153846e-01f, 3.16589400e-02f, -2.80599952e-01f, -5.86168580e-02f, 1.02906302e-01f, -1.55472621e-01f,
  1.28384903e-01f, 8.45037922e-02f, 1.95902407e-01f, -2.55113542e-01f, 2.86533326e-01f, -1.78276114e-02f, 4.96656820e-02f, 1.68729007e-01f, -1.79054648e-01f, -7.71325156e-02f,
  4.94046696e-02f, -1.77078143e-01f, -1.48679823e-01f, 1.42869949e-01f, -1.83213025e-01f, -2.66677905e-02f, 9.66020077e-02f, 2.40548715e-01f, 9.53418016e-02f, -6.61930963e-02f,
  -2.73658097e-01f, -1.59118250e-01f, 1.74251683e-02f, -1.20556198e-01f, 1.18951045e-01f, 1.16574273e-01f, 1.78777382e-01f, -8.72185007e-02f, 1.53724805e-01f, -6.34253174e-02f,
  -1.98742095e-03f, 1.17183207e-02f, -3.42694335e-02f, 8.51683244e-02f, -1.99201763e-01f, 1.45836487e-01f, -1.12151593e-01f, 1.62788387e-02f, -1.83860123e-01f, 9.53502432e-02f,
  9.55768526e-02f, -1.41766712e-01f, -2.58883256e-02f, 1.75058231e-01f, 3.87269668e-02f, -8.89302492e-02f, -1.99170440e-01f, -4.79808040e-02f, -2.06446424e-01f, -1.50729805e-01f,
  -2.00141832e-01f, -5.77995218e-02f, -4.17082496e-02f, -2.41488472e-01f, 2.69070882e-02f, -1.32208586e-01f, 8.48116130e-02f, 1.36213332e-01f, 1.44063577e-01f, -5.74531034e-02f,
  -1.18949257e-01f, 2.24322915e-01f, 3.47477235e-02f, 7.61179850e-02f, 2.50115562e-02f, 1.31377488e-01f, 1.36834145e-01f, -1.06128395e-01f, 1.01609126e-01f, -2.46643528e-01f,
  2.98529472e-02f, -1.68234147e-02f, -3.13656405e-02f, 1.82897095e-02f, -5.31298853e-02f, 1.51510136e-02f, 8.73145834e-02f, -1.28077725e-02f, 2.47803345e-01f, 1.71295434e-01f,
  -1.62382692e-01f, -2.43850462e-02f, 1.35773167e-01f, -2.19500273e-01f, -2.15903416e-01f, -2.24522844e-01f, -1.10291973e-01f, 8.24666694e-02f, 2.04152539e-01f, 1.56327695e-01f,
  -2.58597434e-01f, -4.01382782e-02f, 1.42786011e-01f, -9.36016068e-02f, 7.57086948e-02f, 1.73899323e-01f, -1.82177648e-02f, -9.94045138e-02f, -6.17177039e-02f, 1.93551198e-01f,
  -1.40283167e-01f, 6.86296672e-02f, -1.68765575e-01f, -3.54203172e-02f, 1.32754758e-01f, 6.52888119e-02f, -1.18208550e-01f, -2.27761944e-03f, -1.48763224e-01f, 3.04248761e-02f,
  -1.96844816e-01f, -6.90618381e-02f, -5.88920005e-02f, -1.70318946e-01f, -1.42591074e-01f, -1.25209033e-01f, 7.99954534e-02f, -1.75708607e-01f, 1.21138401e-01f, 4.92320620e-02f,
  1.23590268e-01f, -2.50848792e-02f, -1.10123582e-01f, 2.49500219e-02f, -4.11209650e-02f, 1.72347263e-01f, -7.13833096e-03f, 5.58768446e-03f, -8.42331797e-02f, 9.79845002e-02f,
  2.56216992e-02f, 4.67624515e-03f, -2.44572714e-01f, -7.36315846e-02f, 2.14170874e-03f, 9.66575295e-02f, 6.42383937e-03f, 5.47913946e-02f, 5.93174808e-02f, 4.66322452e-02f,
  1.78194448e-01f, -1.62395984e-01f, 2.53370672e-01f, 2.22065166e-01f, -4.41633677e-03f, -9.01128948e-02f, 1.80830841e-03f, -1.46257952e-01f, 1.33117149e-02f, -1.25413224e-01f,
  -1.32614031e-01f, 1.41415328e-01f, 1.53526664e-01f, -1.69770047e-01f, -2.65784442e-01f, -1.01364799e-01f, 2.32242867e-02f, 6.37417957e-02f, 2.49647811e-01f, 2.53165334e-01f,
  2.49683261e-02f, -1.39188217e-02f, 1.24163620e-01f, 2.81671464e-01f, -1.55516639e-01f, -7.53114372e-02f, -9.02539417e-02f, -9.77515727e-02f, 6.50218725e-02f, 6.20803535e-02f,
  -3.02147716e-02f, -1.11853324e-01f, -5.70853092e-02f, -7.76841119e-02f, -1.17411621e-01f, -8.88127387e-02f, -8.09967890e-02f, 1.31877586e-02f, 1.38066947e-01f, -1.15333222e-01f,
  1.17985487e-01f, 1.91501398e-02f, -1.12903863e-02f, 1.00075066e-01f, -2.69750915e-02f, 1.50658907e-02f, 5.81435896e-02f, 1.43525098e-02f, 1.09661706e-01f, -2.45327115e-01f,
  2.08173379e-01f, -2.22630054e-01f, 2.02772021e-01f, 1.31588057e-01f, -1.28616154e-01f, 8.32911059e-02f, -3.21693458e-02f, -1.54610708e-01f, -3.65957581e-02f, 1.18732736e-01f,
  -7.79743567e-02f, -3.26916203e-02f, 1.60397843e-01f, 3.94031703e-02f, -1.10397935e-01f, -1.68140963e-01f, -8.75914022e-02f, -8.33535343e-02f, 8.00644755e-02f, -5.06048501e-02f,
  -1.77871227e-01f, 1.55302063e-01f, 1.39547303e-01f, 1.63010225e-01f, 7.72277340e-02f, -5.95188001e-03f, -1.88486159e-01f, -1.38619319e-01f, -1.12005711e-01f, 8.47716406e-02f,
  -1.69113263e-01f, 8.78296718e-02f, -1.06797926e-01f, -1.59516200e-01f, -6.77363798e-02f, 5.04234806e-02f, 8.62714797e-02f, -3.45455371e-02f, -9.71201062e-02f, -1.88967153e-01f,
  7.85092637e-02f, 9.95830297e-02f, -1.33813486e-01f, -2.42352430e-02f, 1.55795977e-01f, 9.92371812e-02f, -2.98218392e-02f, 4.00702842e-02f, -1.79659389e-02f, -1.05426218e-02f,
  -1.05953962e-02f, 7.66734481e-02f, -9.29596350e-02f, 1.62688196e-01f, -1.87602602e-02f, -8.36706068e-03f, -2.57626995e-02f, 1.21775344e-02f, 3.93552296e-02f, -2.07758188e-01f,
  3.38881053e-02f, -5.52035496e-03f, -2.24546611e-01f, 1.43394649e-01f, 1.74272686e-01f, -7.92810097e-02f, 7.70744234e-02f, -8.99961144e-02f, 2.55967081e-01f, -5.69762252e-02f,
  1.45277739e-01f, -5.43985032e-02f, 1.88891143e-01f, 9.01827738e-02f, -1.91948086e-01f, 1.15902461e-01f, 1.27254829e-01f, -4.43833210e-02f, 2.93892547e-02f, -1.92000419e-01f,
  8.78811181e-02f, -8.86267275e-02f, -2.60517411e-02f, 1.98091343e-01f, 9.62983668e-02f, -8.50483179e-02f, 8.28222632e-02f, -7.54038664e-03f, 9.27844793e-02f, 2.44704351e-01f,
  1.70029581e-01f, 2.39304766e-01f, -1.68206587e-01f, -9.38484818e-02f, -1.57509148e-01f, 1.73707530e-01f, -1.34551793e-01f, -3.25718825e-03f, -1.27079654e-02f, -1.66370124e-01f,
  1.05999023e-01f, 2.44063362e-02f, -4.23835255e-02f, -2.58732855e-01f, -1.45070821e-01f, -1.24348186e-01f, -2.39388660e-01f, 2.31749445e-01f, -7.11208135e-02f, 4.70254943e-02f,
  -5.65101579e-02f, 1.10673063e-01f, 2.32091127e-03f, 3.41779441e-02f, 1.26296163e-01f, 6.59931377e-02f, -8.04068297e-02f, 1.96627900e-02f, 1.01540640e-01f, 4.36507761e-02f,
  1.84565037e-01f, 1.13158770e-01f, 2.32151523e-01f, -9.30106491e-02f, -6.84222057e-02f, 2.13070028e-02f, 8.63561872e-03f, 6.02394082e-02f, -1.15011550e-01f, -4.90395837e-02f,
  -1.33929342e-01f, -1.40090197e-01f, 1.40343264e-01f, -7.26212934e-02f, -1.81754321e-01f, -2.15415899e-02f, 9.17123705e-02f, -6.12426996e-02f, 1.42374516e-01f, 1.08037576e-01f,
  -2.04283628e-03f, 4.59842309e-02f, 3.03568274e-01f, 1.10255666e-01f, 9.21792835e-02f, 5.15660085e-02f, -1.19769305e-01f, -2.80506760e-01f, 2.22197431e-03f, -2.11166814e-01f,
  6.79517984e-02f, -2.22795159e-01f, 1.16584219e-01f, 8.52637663e-02f, -6.14446448e-03f, -1.77622259e-01f, -4.27490771e-02f, -1.21397609e-02f, 7.14873672e-02f, 3.18311527e-02f,
  9.44394916e-02f, 1.57825008e-01f, 1.99219748e-01f, 1.16106778e-01f, 1.07057495e-02f, 1.04157835e-01f, 9.46864039e-02f, -5.39201908e-02f, -2.78326243e-01f, -2.41019338e-01f,
  -5.68958893e-02f, 1.46532431e-01f, -2.27185011e-01f, -7.31706843e-02f, -7.70281926e-02f, 8.19013566e-02f, 1.80278197e-01f, -4.26490605e-03f, 1.62182480e-01f, 4.78138886e-02f,
  -3.07452306e-03f, 4.91035841e-02f, -1.29365265e-01f, 3.04031800e-02f, 1.23704404e-01f, 1.47088673e-02f, 5.41060008e-02f, 9.77225881e-03f, -1.54850572e-01f, 2.48636588e-01f,
  1.94398701e-01f, -5.29175345e-03f, 2.25016192e-01f, -2.62964845e-01f, 1.09801322e-01f, 1.17371440e-01f, -3.60943154e-02f, 4.23651375e-02f, 2.04069391e-01f, -3.65225747e-02f,
  -1.17807306e-01f, -2.63066947e-01f, 8.98071975e-02f, 3.07429433e-02f, 1.23846941e-01f, -2.89292485e-01f, -4.57880571e-02f, -1.41305253e-01f, 1.95108280e-01f, -9.38407704e-02f,
  1.71714872e-02f, -2.07797959e-01f, -1.63255975e-01f, 2.47663319e-01f, 1.35293761e-02f, 1.34588331e-01f, -1.93634048e-01f, -7.67888618e-04f, -4.67331074e-02f, -5.21381311e-02f,
  3.46580753e-03f, 1.66950017e-01f, -8.76326710e-02f, -1.66512161e-01f, 1.76504254e-01f, -1.59780741e-01f, 1.64954364e-01f, -3.97155210e-02f, 5.10748699e-02f, -2.31195912e-02f,
  -2.72190660e-01f, 5.86473709e-03f, 1.07031651e-01f, 1.41806612e-02f, -1.02486476e-01f, -5.69419041e-02f, 7.85955414e-02f, -2.24742308e-01f, 3.09717339e-02f, -1.36735234e-02f,
  1.76937953e-02f, -3.57684977e-02f, 9.08687338e-02f, -2.01737285e-01f, -2.04319224e-01f, 6.77823648e-02f, 5.99219762e-02f, -1.25921816e-02f, 8.61429721e-02f, 2.67823264e-02f,
  7.92154223e-02f, -1.01144053e-01f, -8.33769068e-02f, -3.50769237e-02f, -6.81294948e-02f, 1.17960759e-02f, -1.08834192e-01f, 1.04391165e-01f, -2.40669250e-01f, -2.47852147e-01f,
  1.74122509e-02f, 2.20611975e-01f, -3.07006001e-01f, 5.48069328e-02f, 3.96404415e-02f, 1.08725660e-01f, 1.91118434e-01f, 2.10947499e-01f, -7.53600523e-02f, 9.36943069e-02f,
  8.31109360e-02f, 1.08500123e-01f, 6.53606802e-02f, 2.61816263e-01f, 2.64308285e-02f, -2.71632373e-01f, 1.91113949e-02f, -1.49096042e-01f, -4.03628163e-02f, 1.02884717e-01f,
  1.33425146e-01f, 1.31178737e-01f, -1.25194043e-01f, -1.62927687e-01f, -1.16874434e-01f, -4.19603549e-02f, 1.49051845e-01f, 9.12711248e-02f, -1.68083739e-02f, 2.28308320e-01f,
  -9.61320624e-02f, 8.38062493e-04f, 1.03476653e-02f, 6.42395988e-02f, 1.82090893e-01f, 2.41981298e-01f, -1.41792580e-01f, -8.57535079e-02f, -6.25813901e-02f, 1.04282349e-01f,
  4.02048156e-02f, -1.41212255e-01f, -4.73328978e-02f, -1.16871946e-01f, -1.47922024e-01f, -5.84323853e-02f, -7.88981244e-02f, -1.44813862e-02f, 3.04097100e-03f, -3.16655487e-02f,
  5.53060286e-02f, -1.46064371e-01f, 2.38947626e-02f, 8.19236562e-02f, -8.40725452e-02f, 1.36255562e-01f, -4.09215242e-02f, -1.58301428e-01f, -6.56852033e-03f, 1.58488110e-01f,
  1.01412326e-01f, 9.65678990e-02f, 4.45856154e-02f, 1.43828928e-01f, 8.00444484e-02f, -1.62210539e-01f, -3.75904106e-02f, -1.05469018e-01f, 1.35801986e-01f, 1.79139271e-01f,
  2.09992379e-02f, -9.67963934e-02f, -1.81743160e-01f, 1.96145521e-03f, 2.48269960e-01f, -1.59238558e-02f, 8.10410455e-02f, 1.64468974e-01f, 9.79497507e-02f, 6.50100112e-02f,
  2.26017401e-01f, -2.10073784e-01f, -2.34341726e-01f, -1.12213567e-01f, -2.72063643e-01f, 1.38572335e-01f, 2.43720815e-01f, 1.18716031e-01f, -2.32665345e-01f, -7.11701065e-02f,
  8.04501623e-02f, -1.25633844e-03f, 1.26982182e-01f, 1.34988189e-01f, 1.33288026e-01f, -3.47515345e-02f, -4.68240269e-02f, 6.19135192e-03f, -7.71223828e-02f, 4.68680635e-02f,
  -1.17499836e-01f, -2.18190476e-01f, 2.11021036e-01f, 3.63906845e-02f, -1.77148968e-01f, 5.48947677e-02f, 1.77873164e-01f, 6.10442385e-02f, 5.51673509e-02f, 1.42393366e-01f,
  2.80062798e-02f, 7.62344971e-02f, 8.54288936e-02f, 9.98617709e-02f, 1.04886770e-01f, 1.20584756e-01f, 2.84136459e-02f, -6.21770695e-02f, 9.19359177e-02f, -5.50610572e-02f,
  9.61127654e-02f, -2.23361677e-03f, -1.65192857e-02f, 7.52042830e-02f, 3.98983359e-02f, -1.66883282e-02f, -7.12346286e-02f, 1.39532238e-01f, 8.95916373e-02f, -2.21917525e-01f,
  -2.51639187e-01f, 3.34843583e-02f, 2.90737957e-01f, 8.65973085e-02f, 7.50111714e-02f, 4.57871370e-02f, 7.00137625e-03f, 1.08010560e-01f, 6.65644854e-02f, 5.98934405e-02f,
  -1.96890667e-01f, 4.34635803e-02f, 1.45392329e-01f, 1.55628189e-01f, 5.02675734e-02f, -6.93898052e-02f, 5.16055562e-02f, -1.95663020e-01f, 2.99704447e-02f, -2.42842808e-02f,
  -2.20285967e-01f, 1.18421274e-03f, -5.63860498e-02f, 1.63802113e-02f, 9.67041124e-03f, 1.15342438e-01f, -2.15773612e-01f, -1.09170124e-01f, -2.25283757e-01f, -1.33465394e-01f,
  -2.24803999e-01f, 1.54281884e-01f, 1.68816134e-01f, 1.53504491e-01f, -2.36556098e-01f, -2.06502825e-01f, -1.18921913e-01f, -2.95673590e-02f, -9.83175486e-02f, 1.90643206e-01f,
  9.14325118e-02f, -2.09590755e-02f, -3.12863328e-02f, -1.00970745e-01f, -9.72017124e-02f, -4.37135510e-02f, 5.18458933e-02f, -1.32846907e-01f, -7.02408254e-02f, -2.62543708e-02f,
  -9.37212184e-02f, -8.19437206e-02f, 2.04430451e-03f, 3.69098573e-03f, 1.79755077e-01f, 3.06946822e-02f, -1.11786788e-02f, 2.26961121e-01f, -2.23166347e-01f, 1.89657971e-01f,
  -7.43336901e-02f, 1.49878159e-01f, -1.27440885e-01f, 1.19771689e-01f, -1.21381551e-01f, 9.41499695e-02f, 6.22722693e-02f, -1.89784557e-01f, 7.59592876e-02f, -7.86815509e-02f,
  -1.52399585e-01f, 1.32265598e-01f, 1.12259686e-01f, 9.25625190e-02f, 4.34371270e-02f, 1.83270305e-01f, -8.42403471e-02f, -2.21806988e-02f, -4.67941798e-02f, 2.42415115e-01f,
  8.73442292e-02f, 1.77010998e-01f, 8.44428837e-02f, -4.73416746e-02f, -1.67892501e-01f, -1.93273321e-01f, 2.65610665e-02f, 2.10468173e-01f, 1.09414622e-01f, -1.72462344e-01f,
  -4.48921323e-02f, -2.29044825e-01f, -2.37347167e-02f, -1.97271347e-01f, 9.05540809e-02f, -5.55419475e-02f, 1.59134939e-01f, 2.85227001e-01f, -2.11516861e-02f, 9.52691138e-02f,
  7.85314515e-02f, -1.11271575e-01f, -1.59271106e-01f, -3.89398485e-02f, 6.98871389e-02f, 5.20043671e-02f, 1.52810123e-02f, -3.30533348e-02f, 4.85235788e-02f, 1.66183501e-01f,
  1.63447365e-01f, -1.47520788e-02f, 4.89856042e-02f, 1.03393011e-01f, -7.95991644e-02f, -1.14550449e-01f, -6.10889494e-03f, 8.43026713e-02f, 2.76284926e-02f, 2.57045683e-02f,
  8.75978693e-02f, -8.74225050e-02f, 6.07765019e-02f, 6.32628500e-02f, 6.44576401e-02f, 3.01920086e-01f, 6.34093210e-02f, -1.63215637e-01f, -9.07218177e-03f, 1.86823234e-01f,
  1.12308197e-01f, -5.91822527e-02f, -1.93700530e-02f, -5.67968264e-02f, -7.80774057e-02f, -9.43805203e-02f, 5.65476194e-02f, 6.50537461e-02f, 2.00019866e-01f, -1.57569587e-01f,
  -1.70755774e-01f, 8.48478749e-02f, -2.49785736e-01f, 2.73876697e-01f, 2.34531403e-01f, 1.32214978e-01f, -5.39473034e-02f, -1.42126933e-01f, -1.07235737e-01f, -2.23743409e-01f,
  1.83548760e-02f, 2.16062486e-01f, 6.55632392e-02f, -1.16469167e-01f, 2.76159406e-01f, -5.98585904e-02f, 4.87351082e-02f, -9.96032208e-02f, 3.22598279e-01f, -4.99970838e-02f,
  -1.98380768e-01f, -4.99958396e-02f, 5.71470745e-02f, 1.88939735e-01f, -5.18623851e-02f, -2.33142108e-01f, 1.67472169e-01f, -1.38522118e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.04393595e-01f, 5.24014831e-02f, 3.19732875e-01f, 6.82319626e-02f, 2.06704050e-01f, 3.07493266e-02f, 2.55818814e-01f, 1.79356471e-01f, 2.61981636e-01f, 6.50240108e-02f,
  8.79326835e-02f, 2.41702229e-01f, 1.28425896e-01f, -2.15057522e-01f, -1.68520570e-01f, 2.05854788e-01f, 2.96329767e-01f, -8.10280889e-02f, 1.35964140e-01f, 4.40616608e-02f,
  -2.80073941e-01f, 8.65927711e-02f, -4.46313679e-01f, 2.13452637e-01f, -2.23620936e-01f, -2.30662882e-01f, 1.20032489e-01f, -1.01542659e-01f, 4.02505159e-01f, 3.26002479e-01f,
  2.48095199e-01f, 9.06114280e-02f, 1.92455456e-01f, -1.48732334e-01f, 2.45587200e-01f, 2.21173644e-01f, 2.78380495e-02f, -3.65811855e-01f, -1.50811717e-01f, -7.27595910e-02f,
  1.55273601e-01f, 2.30202019e-01f, -1.41242996e-01f, 2.61500269e-01f, -1.22668818e-01f, -1.73647795e-02f, -1.39955968e-01f, 2.78034776e-01f, -9.71838757e-02f, -8.02756175e-02f,
  8.85877982e-02f, 2.10766256e-01f, 8.30028057e-02f, 1.69702426e-01f, 1.16689377e-01f, 2.43201688e-01f, -9.02798623e-02f, 9.20475945e-02f, 9.80408564e-02f, -3.09647441e-01f,
  9.48093906e-02f, -2.45676637e-01f, -4.02828455e-02f, -5.85392416e-02f, 2.63076350e-02f, 1.45724654e-01f, 1.52628064e-01f, -5.31013981e-02f, 1.83037385e-01f, 1.16706215e-01f,
  1.71648696e-01f, 5.69746681e-02f, 1.06514201e-01f, -3.15970778e-02f, 2.15281755e-01f, 2.27898121e-01f, 9.22831446e-02f, -7.45076910e-02f, -2.45726243e-01f, -3.11835278e-02f,
  1.86600233e-03f, -1.67847574e-01f, 1.50767893e-01f, -3.08775336e-01f, 1.51475698e-01f, -1.26998201e-01f, 1.89484984e-01f, 1.08185768e-01f, 2.10852399e-01f, -7.01238215e-02f,
  -1.16836175e-01f, 9.03187227e-03f, 1.42700344e-01f, 1.72478393e-01f, 4.25138742e-01f, 6.22010827e-02f, 1.31842703e-01f, -1.67864323e-01f, 2.00617492e-01f, -2.27282003e-01f,
  1.34126559e-01f, -3.77884880e-02f, 1.38983011e-01f, -7.84073994e-02f, -4.79078405e-02f, -1.09742535e-02f, 3.95873375e-02f, 1.88718945e-01f, 4.09213960e-01f, 3.70612264e-01f,
  4.58650142e-02f, 1.09514736e-01f, -1.09591097e-01f, 4.07571733e-01f, -1.03715070e-01f, 2.40297541e-01f, 2.76333332e-01f, 1.70552824e-03f, -1.04419738e-01f, -5.66790253e-02f,
  -4.65557426e-02f, -2.73691505e-01f, 1.15295723e-01f, 5.40744960e-02f, -1.19808521e-02f, 2.44557828e-01f, 7.16949850e-02f, 7.62426034e-02f, 1.02912262e-01f, 1.28951639e-01f,
  1.64302975e-01f, 8.44646767e-02f, 1.92866370e-01f, 1.08411297e-01f, 6.06556386e-02f, 5.88342808e-02f, 4.44732130e-01f, 1.72767833e-01f, 2.95501947e-01f, 2.37243563e-01f,
  7.15422779e-02f, 4.31759134e-02f, -1.09247260e-01f, -3.58379722e-01f, -4.08099145e-01f, -4.25624073e-01f, -4.62074876e-02f, -2.32303768e-01f, 3.04715604e-01f, -3.77606273e-01f,
  3.29099059e-01f, -2.98535913e-01f, -3.64210278e-01f, -2.49438807e-01f, 3.98213953e-01f, 4.63654548e-01f, -2.38200556e-02f, 3.44366699e-01f, 2.21466243e-01f, 4.50706333e-01f,
  -1.27595337e-02f, 4.24007438e-02f, -7.29443878e-02f, 6.39624298e-02f, 3.24578941e-01f, -4.34784591e-02f, 1.46625549e-01f, -2.91280951e-02f, 9.98901725e-02f, -7.19104484e-02f,
  2.20019490e-01f, 2.07901716e-01f, -7.76655525e-02f, -3.45458657e-01f, 1.88403979e-01f, -2.74268210e-01f, -3.15942392e-02f, 4.75091755e-01f, -5.26878284e-03f, 2.79312104e-01f,
  -1.79331094e-01f, 9.94232595e-02f, -1.50570482e-01f, 2.48414442e-01f, 3.02033067e-01f, 1.26199797e-01f, -2.01739475e-01f, 3.53416592e-01f, 3.64537537e-02f, 6.59471825e-02f,
  1.37054771e-01f, 1.34633839e-01f, 9.65080634e-02f, 1.67464957e-01f, 2.13106334e-01f, 1.68110996e-01f, -7.70900305e-03f, 1.88075945e-01f, 1.36057913e-01f, 1.83858827e-01f,
  9.12990421e-02f, 7.42948428e-02f, 3.63028795e-02f, 2.30478287e-01f, -1.97692961e-01f, -1.88883349e-01f, -2.77637750e-01f, -3.52114975e-01f, 1.99586600e-02f, -3.97486202e-02f,
  -2.51010269e-01f, 4.07569170e-01f, 1.60939083e-01f, -2.69127280e-01f, 4.27415557e-02f, 2.19642803e-01f, -1.09859988e-01f, -1.32531106e-01f, 1.63853094e-01f, 8.36676806e-02f,
  1.21387862e-01f, -1.22725412e-01f, -2.17447475e-01f, 3.48287135e-01f, 1.51836947e-01f, 4.43241894e-02f, -1.15433224e-01f, -1.84391260e-01f, -6.21531531e-02f, 1.39921427e-01f,
  1.65094987e-01f, 1.16909258e-01f, 2.29493473e-02f, 2.85540283e-01f, 2.79018193e-01f, 2.23675626e-03f, 2.86244512e-01f, 1.82339549e-01f, -1.36478424e-01f, 6.35434836e-02f,
  -6.33032620e-02f, 3.59970897e-01f, -3.38095009e-01f, 1.20869085e-01f, 2.39561051e-01f, 8.81648660e-02f, -1.27187997e-01f, -1.85995474e-01f, 3.25622350e-01f, 6.54088706e-02f,
  1.86564133e-01f, 1.06833681e-01f, -1.14949100e-01f, 1.82511806e-01f, 5.17560262e-03f, 2.78914779e-01f, 1.19288586e-01f, 2.50389092e-02f, 3.24597745e-03f, 1.17354453e-01f,
  1.28757253e-01f, -1.49890259e-01f, 1.00757666e-01f, 6.07531928e-02f, 8.00833926e-02f, -4.08358797e-02f, 1.42516404e-01f, -3.89157347e-02f, -8.71046707e-02f, 2.33623266e-01f,
  1.21849321e-01f, -5.52702621e-02f, -4.15371478e-01f, 2.23575383e-01f, 1.28014637e-02f, 1.30200749e-02f, -3.43967490e-02f, -9.55136716e-02f, 1.50578931e-01f, -1.54634759e-01f,
  3.96572262e-01f, 4.39385958e-02f, -1.39172375e-01f, -7.15694390e-03f, 1.44951701e-01f, 1.84760615e-01f, 2.01741368e-01f, -1.11509398e-01f, -1.60931498e-01f, -3.11008077e-02f,
  -1.92924663e-01f, 3.13856304e-01f, 1.21461958e-01f, 1.19214445e-01f, 3.97663891e-01f, -7.99366906e-02f, -1.64222732e-01f, -2.42773011e-01f, -2.03584656e-01f, -1.58216581e-02f,
  2.77557343e-01f, 2.52015471e-01f, 3.29807937e-01f, -2.36355782e-01f, 2.84856558e-01f, -4.05214075e-03f, -1.55940369e-01f, -1.17940539e-02f, 3.99372261e-03f, -1.62916273e-01f,
  -7.91203603e-02f, 8.55642930e-02f, -1.36783779e-01f, 4.28400874e-01f, 1.01705104e-01f, 2.54405379e-01f, 2.30895534e-01f, -2.23008767e-01f, 1.24129206e-01f, -1.17843328e-02f,
  1.22950271e-01f, 2.00531527e-01f, 3.23781073e-01f, 2.24262476e-01f, 2.43449852e-01f, 2.00457335e-01f, 6.93291277e-02f, 1.32996127e-01f, 7.24648759e-02f, 5.54502495e-02f,
  2.19509192e-02f, 9.28682089e-02f, 9.83119830e-02f, 9.88218710e-02f, -1.37124330e-01f, 2.63994187e-01f, 3.31855953e-01f, 1.95201397e-01f, 1.93698943e-01f, 2.74664193e-01f,
  -5.84762655e-02f, 2.84870952e-01f, -3.85287553e-01f, 1.93197474e-01f, 2.06742197e-01f, 2.60076765e-02f, 3.24326575e-01f, -1.53058201e-01f, 2.74311215e-01f, -2.85772204e-01f,
  -1.35975495e-01f, 1.77913055e-01f, 1.46201387e-01f, 4.11413377e-03f, 2.66008973e-01f, 1.86063126e-01f, -1.40827477e-01f, 4.85643968e-02f, 3.20043936e-02f, 1.62937745e-01f,
  -2.84246773e-01f, 1.25438288e-01f, -3.80927294e-01f, -1.93317175e-01f, 1.34716436e-01f, 3.57569069e-01f, -8.77991319e-02f, 1.93565786e-01f, -3.51678915e-02f, -3.27197850e-01f,
  1.78378835e-01f, 9.70329866e-02f, 3.81334573e-01f, 1.14230096e-01f, 1.59434751e-01f, 1.76175848e-01f, -1.11322574e-01f, -4.77400422e-02f, 2.88654745e-01f, -1.69639692e-01f,
  7.13639259e-02f, -1.91662848e-01f, 9.74565558e-03f, 2.27731720e-01f, 1.24343470e-01f, 2.62728054e-02f, 2.77630031e-01f, 2.06786677e-01f, 2.79862314e-01f, 1.34335503e-01f,
  2.69205958e-01f, 1.74273238e-01f, 2.64334679e-01f, 2.72998840e-01f, 2.45434776e-01f, 1.50765777e-01f, -2.13079169e-01f, -1.65757239e-02f, -3.48462582e-01f, -3.04134071e-01f,
  -4.18650247e-02f, -1.68945566e-01f, 1.13306038e-01f, -3.44446674e-02f, -9.86658037e-02f, -3.19239080e-01f, -2.09058493e-01f, 1.00065814e-02f, -5.92614000e-04f, 5.94039150e-02f,
  8.32085833e-02f, 3.13191712e-02f, 2.60793418e-01f, 4.11955476e-01f, 2.98746139e-01f, 1.73171103e-01f, -2.51365006e-01f, -1.86334580e-01f, -3.82166415e-01f, 1.17317505e-01f,
  3.07855368e-01f, -6.51292577e-02f, -2.20581189e-01f, 2.80248404e-01f, 9.71208438e-02f, 3.90668929e-01f, 1.49975136e-01f, 6.58986717e-02f, -3.01460505e-01f, -4.81440052e-02f,
  2.81702548e-01f, 5.68167455e-02f, -2.22971246e-01f, 2.45494887e-01f, -3.04686397e-01f, -3.25007364e-02f, -2.45852023e-01f, -8.89875591e-02f, -1.07157595e-01f, -2.16288596e-01f,
  4.74244893e-01f, 3.18365060e-02f, 2.54962057e-01f, 3.18090558e-01f, 3.44771408e-02f, -1.30922318e-01f, 3.89871925e-01f, 1.40208125e-01f, 6.64388314e-02f, 2.43711486e-01f,
  4.53444347e-02f, 2.67718494e-01f, 2.49526203e-01f, 7.12191463e-02f, 6.01588301e-02f, 5.89032993e-02f, -1.07392468e-01f, -5.34351319e-02f, 2.36972630e-01f, 6.92381039e-02f,
  1.83275029e-01f, 1.68898851e-01f, -1.31365629e-02f, 1.51878700e-01f, -1.89685926e-01f, 2.76197404e-01f, 2.69212961e-01f, 9.88937244e-02f, 1.78564608e-01f, 2.17520669e-01f,
  1.09392770e-01f, -7.34515414e-02f, 3.45209569e-01f, -1.22476816e-01f, -2.96626543e-03f, 6.83570057e-02f, -2.33808726e-01f, -2.46618822e-01f, -6.60807788e-02f, 8.90797079e-02f,
  3.20558369e-01f, 1.17896080e-01f, 2.78646648e-01f, 2.38316804e-02f, 1.08499750e-01f, 2.93357044e-01f, 2.75519967e-01f, -2.33736843e-01f, -3.34557086e-01f, -3.45659524e-01f,
  -1.57688692e-01f, -5.92431575e-02f, 4.13738698e-01f, 3.97347152e-01f, -6.37194738e-02f, -1.82722658e-01f, 3.12824607e-01f, 4.46386673e-02f, 1.13573425e-01f, 3.17210674e-01f,
  3.65007490e-01f, 3.05636793e-01f, -4.74586487e-02f, 2.13347033e-01f, -2.32707143e-01f, 2.94099990e-02f, -2.77183782e-02f, -2.88776215e-02f, 2.12155268e-01f, 4.88705039e-02f,
  -1.57916069e-01f, 3.06735724e-01f, 9.14245937e-03f, 1.70341078e-02f, 7.87184909e-02f, 2.08863150e-02f, 2.35450670e-01f, 2.26490289e-01f, 2.45714799e-01f, 1.43080741e-01f,
  1.88805997e-01f, 3.07865441e-01f, 2.09795330e-02f, 1.71501249e-01f, 1.47647724e-01f, 3.26878726e-01f, -1.00410422e-02f, -1.11348145e-02f, 1.54628634e-01f, -1.25311628e-01f,
  2.11978704e-01f, -3.28610599e-01f, 2.17927709e-01f, 2.09734052e-01f, 2.82881130e-02f, -2.06751928e-01f, 2.09095672e-01f, 2.44116783e-01f, -4.15501930e-02f, -3.30507070e-01f,
  -5.74984774e-02f, 3.34133178e-01f, 1.26409635e-01f, -2.27253377e-01f, 5.71970567e-02f, -2.11939469e-01f, 2.59560138e-01f, -1.58245221e-01f, -5.24731502e-02f, -1.10659719e-01f,
  -3.22771519e-02f, 4.30684954e-01f, 3.41287673e-01f, 1.22432955e-01f, 1.78333297e-02f, 4.52618639e-04f, 2.28305101e-01f, -1.84030801e-01f, 2.96001077e-01f, 2.77140792e-02f,
  -1.11066550e-01f, -2.38674417e-01f, 2.44909212e-01f, -3.88832092e-01f, 3.12959909e-01f, 1.52297849e-02f, 1.64639130e-01f, -2.14676991e-01f, -4.43242043e-02f, 4.61304113e-02f,
  -4.84374389e-02f, 3.48464251e-01f, -1.43958062e-01f, -9.57489088e-02f, 2.14095637e-01f, -3.79379749e-01f, -8.44207108e-02f, 1.91212036e-02f, 1.54363483e-01f, 1.14513533e-02f,
  1.07271122e-02f, 1.17922254e-01f, 1.61365345e-01f, 1.85494214e-01f, -1.02528080e-01f, -1.45788535e-01f, 1.43135205e-01f, -5.15910499e-02f, -1.40293613e-01f, -2.50619948e-01f,
  -1.71056360e-01f, 2.90138662e-01f, 3.69175434e-01f, -1.89263344e-01f, 9.82053131e-02f, -3.05131912e-01f, -3.62885565e-01f, -1.05002578e-02f, -3.12130749e-01f, 3.73411417e-01f,
  -6.22911975e-02f, -1.09524943e-01f, -3.49117488e-01f, -1.09328553e-01f, 2.23095253e-01f, 1.48699686e-01f, 3.12639982e-01f, -4.11056206e-02f, 6.14267290e-02f, -1.76838979e-01f,
  2.67960906e-01f, 3.68582964e-01f, 3.98010276e-02f, -3.19960952e-01f, -2.54608388e-03f, 1.07358627e-01f, 9.94646922e-03f, 1.10952899e-01f, 1.32418582e-02f, 3.36175054e-01f,
  2.32144505e-01f, -5.64480908e-02f, -3.40117663e-01f, 2.09579945e-01f, -1.89104632e-01f, 2.37606078e-01f, 3.63045722e-01f, 2.31529012e-01f, -6.95438236e-02f, 2.23794598e-02f,
  4.08793449e-01f, 2.02906191e-01f, -2.84776181e-01f, -1.05299540e-01f, 1.97558776e-01f, 9.84646752e-02f, 6.24111667e-02f, 1.23266511e-01f, 1.58830538e-01f, -1.24290720e-01f,
  8.41688886e-02f, 1.82664707e-01f, 3.27726066e-01f, 6.11059628e-02f, 1.43402934e-01f, 2.89805263e-01f, 2.68441170e-01f, 2.29280129e-01f, 1.14112899e-01f, 2.51653969e-01f,
  9.32131410e-02f, 2.09864333e-01f, -3.32365371e-02f, 4.31962311e-02f, -2.53358483e-02f, 6.32349327e-02f, 3.55802476e-01f, 2.22354040e-01f, -5.83348870e-02f, 3.68864499e-02f,
  2.00954825e-02f, 1.89621985e-01f, -3.35174710e-01f, 1.07683890e-01f, -1.60910934e-02f, -1.07609965e-01f, 3.30008000e-01f, -3.43136549e-01f, 9.63302553e-02f, 1.11922294e-01f,
  1.44819036e-01f, 3.31827462e-01f, 2.97390789e-01f, -1.04088284e-01f, 3.57453376e-01f, -2.36338321e-02f, -2.15415880e-01f, -3.62566262e-01f, -1.48007289e-01f, 4.43669826e-01f,
  1.69715792e-01f, 3.62411737e-01f, -2.53058448e-02f, 7.34426230e-02f, 7.58827254e-02f, -9.77327898e-02f, -1.28354579e-01f, 5.02249420e-01f, -1.27902910e-01f, -2.13736609e-01f,
  1.80425882e-01f, -1.53555542e-01f, 3.84583712e-01f, -8.63196626e-02f, 1.41569093e-01f, -7.19417408e-02f, -2.19451394e-02f, 5.25801443e-03f, 1.56227127e-01f, -3.23187001e-02f,
  -1.86200976e-01f, -7.87513703e-02f, -8.50608349e-02f, -2.04042062e-01f, 2.61780381e-01f, 1.59353837e-01f, -6.63441280e-03f, 2.60739893e-01f, 2.59562694e-02f, -4.37135100e-02f,
  -4.13944535e-02f, 7.16786366e-03f, 1.07939586e-01f, -2.63266653e-01f, 1.71550438e-01f, 2.29830950e-01f, -6.87285364e-02f, -1.33602589e-01f, 1.54387817e-01f, -2.43334174e-01f,
  -2.40000382e-01f, -7.35574812e-02f, -3.94378155e-02f, 4.75018285e-02f, 1.25454605e-01f, 3.25487405e-01f, 3.77052397e-01f, -2.42649376e-01f, -1.54930145e-01f, -3.71956468e-01f,
  3.79625708e-01f, 3.21825475e-01f, -1.46418974e-01f, -2.23355159e-01f, 1.67641714e-01f, 2.01592937e-01f, -3.42159495e-02f, 2.74802238e-01f, 1.37911141e-01f, 2.43941888e-01f,
  5.18302321e-01f, 2.21684232e-01f, 2.13794172e-01f, -3.68522704e-01f, -2.62785196e-01f, 9.06888917e-02f, 1.84169888e-01f, 1.32898524e-01f, 1.47755053e-02f, 1.05493195e-01f,
  -1.08817123e-01f, -3.73666823e-01f, 1.18188471e-01f, 4.14845854e-01f, 6.03711344e-02f, 3.73781830e-01f, -1.77207768e-01f, 1.64792851e-01f, -4.37220447e-02f, 2.16637656e-01f,
  -1.45081654e-01f, 3.00361723e-01f, 1.23946920e-01f, 5.67609966e-02f, 4.75013554e-02f, -1.01745091e-01f, 5.29189110e-02f, 3.99582624e-01f, 1.23981170e-01f, 1.87315643e-01f,
  3.35882217e-01f, 2.49920815e-01f, 2.93448091e-01f, 2.11019933e-01f, 3.20553482e-01f, 3.42390239e-01f, 1.61609165e-02f, 2.54998624e-01f, 4.63557132e-02f, 2.17553750e-01f,
  -2.04194430e-02f, 8.71880651e-02f, 2.36268163e-01f, 2.44262502e-01f, -1.18898042e-02f, -8.46196190e-02f, 4.00642961e-01f, -2.33602867e-01f, 4.20376897e-01f, 4.72030401e-01f,
  1.44796938e-01f, -1.46141902e-01f, 4.71807599e-01f, 3.19037527e-01f, 2.23240882e-01f, 1.45389866e-02f, -2.68471986e-01f, -4.26855683e-01f, 2.11910620e-01f, 4.16789651e-02f,
  -2.19121948e-01f, 2.12632209e-01f, -1.50963575e-01f, -5.01488090e-01f, 1.10948890e-01f, 4.26389158e-01f, 7.91538432e-02f, 2.69094169e-01f, 9.88575816e-02f, -2.42184475e-02f,
  -1.67863276e-02f, -4.76563126e-01f, 1.38490051e-01f, 1.64397851e-01f, 3.85972500e-01f, -2.46906459e-01f, 8.25027749e-02f, 1.48173347e-01f, 5.48492782e-02f, -1.41264930e-01f,
  3.50797743e-01f, 8.19150954e-02f, -1.61945708e-02f, -2.05658466e-01f, -2.17579886e-01f, -3.69871348e-01f, 2.55414903e-01f, 3.80748570e-01f, 6.84217215e-02f, -3.81927975e-02f,
  1.90522060e-01f, 3.05360883e-01f, 8.44397172e-02f, 1.40908256e-01f, 9.51046795e-02f, 2.76829392e-01f, 1.83156446e-01f, 1.82792276e-01f, 7.69122690e-02f, 5.95829152e-02f,
  1.74370959e-01f, -7.38687217e-02f, 2.04421103e-01f, 2.53026456e-01f, 2.89595157e-01f, 2.92857140e-01f, 2.81350642e-01f, -5.28391078e-02f, 4.07183729e-02f, -1.00169890e-01f,
  1.78183213e-01f, -3.08733582e-01f, 1.88169286e-01f, 3.81363720e-01f, 9.13278684e-02f, -3.23833227e-01f, -1.60602890e-02f, -1.84306309e-01f, 3.25599730e-01f, 4.44277376e-01f,
  4.81537022e-02f, 5.16769700e-02f, 3.90906483e-01f, 3.89144532e-02f, 1.09205499e-01f, -1.17963599e-03f, 2.98993230e-01f, 2.86842346e-01f, 4.24913466e-01f, 9.93751138e-02f,
  8.86439830e-02f, 3.59588675e-02f, 3.66765857e-02f, -1.03340909e-01f, 6.62461296e-02f, 1.76316783e-01f, -2.00983673e-01f, -3.53725463e-01f, -1.36331260e-01f, -1.56572506e-01f,
  5.16036600e-02f, 6.94893897e-02f, 4.06998783e-01f, 8.26357082e-02f, -8.87548253e-02f, 2.68885791e-02f, 6.27500862e-02f, 4.73462492e-01f, -3.32047880e-01f, 2.89627314e-01f,
  -6.06220104e-02f, 1.44470632e-02f, 1.86619699e-01f, -3.47101569e-01f, 1.12943903e-01f, 1.54916793e-02f, 1.01308890e-01f, 1.64161190e-01f, 1.07861467e-01f, 2.94315875e-01f,
  1.19620942e-01f, 1.30131856e-01f, 2.65555292e-01f, 1.17969573e-01f, 3.71147335e-01f, 1.89624906e-01f, 9.36609209e-02f, 2.75588363e-01f, -2.31703088e-01f, 3.48682225e-01f,
  1.79282516e-01f, -3.21822554e-01f, -1.85328975e-01f, -1.80098638e-01f, -1.89938948e-01f, 9.57468674e-02f, 1.81715146e-01f, 9.41817276e-03f, 1.24460019e-01f, -3.97765309e-01f,
  1.20248750e-01f, 6.04902618e-02f, 2.57447213e-01f, 3.69688809e-01f, -1.42420471e-01f, -6.59173541e-03f, -5.26266396e-02f, 1.78367496e-01f, -5.86655810e-02f, 1.79616392e-01f,
  -2.92062581e-01f, 2.21349988e-02f, 2.91956574e-01f, 3.27327102e-01f, 2.57204533e-01f, 4.78089564e-02f, 2.23773003e-01f, 1.21562757e-01f, -7.04122409e-02f, 2.19153650e-02f,
  -4.79222983e-02f, 1.52530909e-01f, 2.91538388e-01f, 1.52919227e-02f, -9.68422815e-02f, 1.63915053e-01f, -2.47536317e-01f, 9.58607644e-02f, -3.72230291e-01f, -2.46817097e-01f,
  -4.22971278e-01f, 2.63069659e-01f, 3.45049202e-01f, 4.60994810e-01f, -1.35208547e-01f, 2.03983516e-01f, 5.13438648e-03f, -2.70191252e-01f, 2.63778895e-01f, 3.17840189e-01f,
  6.01551794e-02f, 2.71396965e-01f, 1.05836153e-01f, 1.06584467e-01f, 9.19492543e-02f, 2.20622942e-01f, 1.20711327e-01f, 2.39249557e-01f, -7.78674483e-02f, 4.92570475e-02f,
  1.25865638e-01f, 1.68510586e-01f, -1.51078776e-01f, 4.95247170e-02f, 1.84086159e-01f, -7.75977448e-02f, 2.49941155e-01f, -3.20953429e-01f, 1.15267612e-01f, -2.20636621e-01f,
  3.01583529e-01f, 3.28158349e-01f, 1.70250610e-01f, 1.40729800e-01f, 3.13280135e-01f, 6.13574237e-02f, 3.30704153e-01f, 1.74338356e-01f, -2.98932552e-01f, -1.97139338e-01f,
  3.50187749e-01f, 2.17585832e-01f, -6.21707551e-02f, -1.08001038e-01f, -6.76834807e-02f, -3.39491308e-01f, 9.11384672e-02f, 3.80506635e-01f, -1.24507613e-01f, 2.92342514e-01f,
  4.46386337e-01f, 2.22893164e-01f, 2.76340842e-01f, 1.58470392e-01f, -1.11381948e-01f, 3.05602193e-01f, 1.86272785e-01f, -7.07542058e-03f, -2.44211972e-01f, 2.01898187e-01f,
  2.56305814e-01f, 1.29907593e-01f, -2.94593692e-01f, 1.66734487e-01f, 3.22274894e-01f, -9.04603004e-02f, -4.08649743e-02f, -4.01787877e-01f, 2.99544454e-01f, 3.48687768e-01f,
  -1.53395921e-01f, 1.66575521e-01f, 2.66603798e-01f, 2.10390911e-01f, 8.35833699e-02f, 9.21897441e-02f, 1.35121867e-01f, 1.49690837e-01f, 2.41562963e-01f, 1.73487812e-02f,
  7.80467466e-02f, 1.73089072e-01f, -7.04496279e-02f, 1.75850242e-01f, 8.59946385e-02f, 4.61856425e-02f, -1.37813818e-02f, 1.38521925e-01f, -3.95767726e-02f, 1.25830203e-01f,
  -7.85341635e-02f, 3.03847820e-01f, 6.88940138e-02f, 7.80382156e-02f, 4.97458950e-02f, 2.09490150e-01f, -4.63359430e-02f, -1.58732086e-01f, 2.84249306e-01f, 3.05463940e-01f,
  -9.19277370e-02f, -3.44043255e-01f, -2.19463304e-01f, -9.02898535e-02f, -3.57907951e-01f, -2.71790594e-01f, 1.02154598e-01f, 1.42079696e-01f, 9.76089984e-02f, 5.12509756e-02f,
  -4.51752126e-01f, 2.09432259e-01f, 1.95975214e-01f, 1.06389403e-01f, 1.04615547e-01f, -3.48544210e-01f, -5.62861748e-02f, -3.75065804e-02f, 3.55969429e-01f, 2.81718016e-01f,
  5.22376359e-01f, -3.31954807e-02f, 1.23565286e-01f, -3.78435552e-01f, 1.06247328e-01f, -2.68048383e-02f, 2.37873524e-01f, 3.09771877e-02f, 1.72937229e-01f, -1.34387106e-01f,
  1.62226468e-01f, 1.19260550e-01f, -1.63862079e-01f, 2.37875238e-01f, 2.21371084e-01f, 8.62588137e-02f, 1.34275943e-01f, -1.35832027e-01f, 2.18243733e-01f, 1.97998554e-01f,
  3.15929145e-01f, 2.18942329e-01f, 2.88577199e-01f, 2.14691877e-01f, 1.80296078e-01f, 1.16183117e-01f, 2.27748618e-01f, 1.59991935e-01f, 1.21782340e-01f, 1.31993577e-01f,
  -9.67449248e-02f, 2.64914513e-01f, 3.75903517e-01f, -9.23929960e-02f, -1.07900575e-01f, -2.56105382e-02f, 7.57236555e-02f, 7.81666860e-02f, 4.29404557e-01f, 3.52731854e-01f,
  2.81563908e-01f, -3.18729162e-01f, 3.49296153e-01f, 1.37554049e-01f, 4.84512240e-01f, 2.58290976e-01f, -3.39587271e-01f, -4.26855326e-01f, -3.29956710e-02f, 3.41815531e-01f,
  -1.04628272e-01f, 1.99259534e-01f, -2.08564162e-01f, -3.72435987e-01f, -2.43587214e-02f, 4.62633908e-01f, 1.17950723e-01f, 2.06390962e-01f, 3.26372564e-01f, -1.97387412e-02f,
  1.67925715e-01f, -2.56681412e-01f, 2.32966140e-01f, 1.87534839e-01f, 3.54126126e-01f, -1.45036906e-01f, 1.72204807e-01f, 1.57067046e-01f, -1.40462056e-01f, -2.92592566e-03f,
  -1.36641052e-03f, 1.06742933e-01f, -4.97100577e-02f, 6.91345930e-02f, 1.92342922e-01f, -8.72693658e-02f, 7.81404823e-02f, 3.33733678e-01f, -3.58762927e-02f, -4.45040949e-02f,
  2.35163867e-01f, 2.40765885e-01f, 1.70503035e-01f, 4.14931923e-02f, 4.35651243e-02f, 2.41657361e-01f, 2.00742140e-01f, -5.72565421e-02f, 2.54761189e-01f, -3.79549414e-02f,
  3.26324940e-01f, 1.74875945e-01f, 1.51566669e-01f, 4.95961942e-02f, -6.20023869e-02f, 1.06542490e-01f, 5.40597960e-02f, -3.33928436e-01f, -7.70097300e-02f, 8.49361867e-02f,
  -3.12750876e-01f, 1.68073118e-01f, -1.84815302e-01f, 9.83094051e-03f, -3.75661492e-01f, -1.89185217e-01f, -1.68031484e-01f, -3.18349272e-01f, 2.87392229e-01f, 1.18762299e-01f,
  3.29113632e-01f, 1.74369112e-01f, -4.63791704e-03f, 2.40349159e-01f, 2.30268300e-01f, 2.25241959e-01f, 2.18114510e-01f, 3.69252473e-01f, 4.53233086e-02f, 1.27431974e-01f,
  3.04862767e-01f, -1.54950336e-01f, -1.59565330e-01f, -4.36541848e-02f, -1.21753797e-01f, 8.05453286e-02f, -1.75410941e-01f, 3.56925055e-02f, -7.34324828e-02f, 5.74056767e-02f,
  8.87488052e-02f, -1.04951285e-01f, 1.73984751e-01f, 1.77500188e-01f, -1.91291720e-01f, -4.67961356e-02f, -1.80874556e-01f, 3.31692845e-01f, 1.11701176e-01f, 5.57699442e-01f,
  -9.45814103e-02f, -1.89167157e-01f, 1.22261047e-01f, -3.40832055e-01f, -3.06035995e-01f, -8.89803935e-03f, 1.85464129e-01f, 4.53697070e-02f, 1.45993009e-01f, 1.67250559e-01f,
  9.70910341e-02f, -2.14962587e-02f, 1.87362567e-01f, 4.14387695e-02f, 1.02900639e-01f, -9.27405804e-02f, 3.88184302e-02f, 1.13668598e-01f, -2.35552371e-01f, -3.38249147e-01f,
  -3.47826988e-01f, 6.03268594e-02f, -7.47818574e-02f, -3.50631624e-01f, 2.34120712e-01f, -3.89692277e-01f, -1.83378890e-01f, -3.33196610e-01f, -3.17325555e-02f, 3.32081318e-01f,
  -2.67755419e-01f, -2.35866711e-01f, -3.54698300e-01f, 2.36856744e-01f, 2.67859459e-01f, -6.34387285e-02f, 2.42852420e-01f, -2.66732424e-01f, -3.22815806e-01f, -2.56397039e-01f,
  -1.38860613e-01f, 9.04527977e-02f, 2.26712853e-01f, -1.04067095e-01f, -1.96858019e-01f, -7.11646453e-02f, -3.29200149e-01f, 2.75183469e-01f, -2.68927077e-03f, 3.50350171e-01f,
  1.81592137e-01f, -3.65955941e-02f, -2.18547016e-01f, 7.31724873e-03f, -2.06022486e-01f, 3.80246758e-01f, -6.99075907e-02f, 2.07539335e-01f, -6.53336644e-02f, 2.66063243e-01f,
  -8.52152705e-02f, -1.07984088e-01f, -6.63661957e-02f, -2.26754740e-01f, 3.09006900e-01f, 3.24450843e-02f, 9.77254882e-02f, 5.90095632e-02f, 3.96245837e-01f, 4.67757843e-02f,
  2.29005247e-01f, 1.81951612e-01f, 1.21722832e-01f, 1.30378753e-01f, 5.47753088e-02f, 9.36382264e-02f, 7.98242837e-02f, 1.02750584e-01f, 3.46348554e-01f, 1.66163936e-01f,
  1.59911275e-01f, 2.19713405e-01f, 1.09051488e-01f, -1.87524468e-01f, 1.13363340e-01f, -2.89602339e-01f, -1.67850450e-01f, -3.37403966e-04f, 1.38970539e-02f, 3.06705266e-01f,
  8.66612867e-02f, 2.72630572e-01f, 1.98945999e-01f, -2.75686741e-01f, -1.54004702e-02f, -2.52468348e-01f, 5.03141224e-01f, 4.75010961e-01f, 6.49343207e-02f, -2.13497207e-01f,
  9.24263373e-02f, 4.04003292e-01f, 2.43651018e-01f, 1.55216634e-01f, 5.04464060e-02f, 7.58021697e-02f, 4.15800273e-01f, 2.06079647e-01f, 3.45158041e-01f, -3.55365992e-01f,
  -1.87745988e-01f, 1.10471904e-01f, 1.24603219e-01f, -5.95609583e-02f, -4.09783679e-04f, 2.50818819e-01f, -2.15775236e-01f, -1.01116121e-01f, 3.32581431e-01f, 3.62856656e-01f,
  -1.90263644e-01f, 1.49699196e-01f, -9.75158140e-02f, -1.29249960e-01f, -2.15380266e-01f, 4.01516765e-01f, 1.08478025e-01f, 2.93923140e-01f, -1.22557275e-01f, -2.93664575e-01f,
  -1.34809554e-01f, -1.80286869e-01f, -1.50127664e-01f, 3.89547884e-01f, 1.03053525e-01f, 1.01834916e-01f, 1.29272953e-01f, -1.17264399e-02f, 1.78457335e-01f, 1.82651997e-01f,
  1.03362119e-02f, 1.06184185e-01f, -1.15490958e-01f, 3.49354707e-02f, 1.18966155e-01f, 1.96035221e-01f, 1.95550710e-01f, -2.05929130e-01f, 2.81658083e-01f, 3.38334113e-01f,
  -8.67624488e-03f, -4.79133166e-02f, 2.76339222e-02f, -7.43297264e-02f, -1.85704470e-01f, 5.49144521e-02f, 2.78090507e-01f, 9.96472389e-02f, 3.17280181e-02f, 3.16314548e-01f,
  -2.36951262e-02f, 2.28725210e-01f, -1.00074373e-01f, 2.60160595e-01f, 4.09266829e-01f, -7.01309219e-02f, -8.44071954e-02f, 3.35072309e-01f, -1.31747853e-02f, -2.13020563e-01f,
  4.10795033e-01f, 2.21718431e-01f, 5.84203843e-03f, -1.86106548e-01f, 2.87796348e-01f, 1.24438606e-01f, 4.15227413e-01f, -1.48902044e-01f, -1.50101215e-01f, 8.04286003e-02f,
  1.08207889e-01f, 1.20418109e-01f, 2.09242210e-01f, 5.92591381e-03f, 2.42555216e-01f, 4.58511636e-02f, 4.56820428e-02f, 2.05165371e-01f, 3.49871904e-01f, 4.73890603e-02f,
  -6.05727034e-03f, -4.53703016e-01f, 9.07938406e-02f, -1.04888707e-01f, -8.83883238e-02f, 1.50442585e-01f, -2.09580526e-01f, 2.16057107e-01f, -3.93650793e-02f, 2.56884918e-02f,
  5.15620857e-02f, -6.91681877e-02f, 5.78738637e-02f, 2.46893570e-01f, -1.02916203e-01f, 1.39831528e-01f, -6.98410645e-02f, 1.33221224e-01f, 4.42536399e-02f, 8.32538083e-02f,
  2.51421809e-01f, -8.41195956e-02f, 3.71402688e-02f, 7.25534037e-02f, -1.55366570e-01f, -8.69129673e-02f, -9.86041501e-02f, -2.10573688e-01f, -1.54679760e-01f, -1.76220775e-01f,
  3.13783079e-01f, 1.68554515e-01f, 1.53218076e-01f, 2.49244645e-01f, -2.72592366e-01f, -1.94945931e-01f, -2.02941507e-01f, 4.44602519e-01f, 3.33452493e-01f, -2.72671491e-01f,
  4.19557765e-02f, 1.58204481e-01f, 1.99881673e-01f, -1.13864310e-01f, 6.31131530e-02f, -1.93009764e-01f, -7.27254078e-02f, -4.32038531e-02f, 2.80729860e-01f, -1.83473378e-01f,
  4.74980295e-01f, 2.62331873e-01f, 2.73718536e-01f, 2.47425120e-02f, 4.28954586e-02f, 1.67796358e-01f, 1.65985033e-01f, 2.00983062e-01f, 1.60085410e-02f, -1.07405521e-01f,
  1.56450942e-01f, 1.03102230e-01f, 1.65620074e-01f, -2.41189346e-01f, 1.21039703e-01f, -4.99529868e-01f, -1.45725518e-01f, 9.27218273e-02f, 8.40644445e-03f, 4.45597291e-01f,
  -1.38585269e-01f, -2.99483478e-01f, 2.44320437e-01f, 6.28899634e-02f, 2.62063533e-01f, 1.72124818e-01f, 9.00397673e-02f, 6.74044788e-02f, 8.70115589e-03f, 1.01782516e-01f,
  4.25567776e-02f, -5.18880598e-02f, 1.92877099e-01f, 1.40994832e-01f, -1.17774969e-02f, 1.88144758e-01f, 3.01929206e-01f, 6.09950162e-03f, -4.34834398e-02f, 6.99774027e-02f,
  -1.47395194e-01f, 1.00853860e-01f, -1.69600666e-01f, 2.26570386e-02f, 4.72222567e-02f, 8.75344053e-02f, 3.10852230e-01f, 2.09549502e-01f, 5.03746159e-02f, -1.48506761e-01f,
  -2.66142726e-01f, 4.04675119e-02f, -8.48393068e-02f, 1.26901818e-02f, 9.25692543e-02f, 2.69184977e-01f, -1.54335395e-01f, -2.96967745e-01f, -3.18048149e-01f, 1.54061228e-01f,
  1.22243710e-01f, 6.51583150e-02f, 3.13925415e-01f, -2.36707047e-01f, 2.36467034e-01f, 2.23024771e-01f, 1.77694261e-01f, 4.20300066e-01f, 2.80682206e-01f, -3.33224609e-03f,
  -3.23010795e-02f, 1.43773645e-01f, 3.64214070e-02f, 1.65519416e-01f, -2.62364119e-01f, 4.33505513e-02f, 5.01918681e-02f, -2.20470667e-01f, 3.76518250e-01f, -9.39863622e-02f,
  6.09260518e-04f, 2.84076452e-01f, 2.91870981e-01f, 1.36484563e-01f, 1.24872282e-01f, 1.57201499e-01f, 6.19463399e-02f, 1.49598494e-01f, 4.20281850e-02f, 1.41499445e-01f,
  2.52071917e-01f, 7.47025162e-02f, 2.96280891e-01f, 1.27691433e-01f, -1.31291663e-02f, 1.77256525e-01f, 4.06244434e-02f, 2.49995098e-01f, 3.41569304e-01f, -2.46073768e-01f,
  -1.13449067e-01f, 2.22294912e-01f, 3.37906003e-01f, -5.84171452e-02f, 3.10379148e-01f, -1.01993173e-01f, -7.95658901e-02f, 3.63189936e-01f, -1.08145609e-01f, 1.38313323e-01f,
  1.27439708e-01f, 8.22003279e-03f, 4.83350977e-02f, -8.73505026e-02f, 2.17385754e-01f, 2.23013118e-01f, 2.92040378e-01f, -1.88407451e-01f, 2.00599641e-01f, -2.80940890e-01f,
  4.27418530e-01f, 2.56821394e-01f, 2.35181510e-01f, -4.16417688e-01f, -1.73121914e-01f, 1.15257226e-01f, -3.61267366e-02f, 7.61012509e-02f, -8.18043202e-02f, 2.66293019e-01f,
  1.94650754e-01f, -2.75508404e-01f, -2.89927423e-01f, 2.62040079e-01f, -5.43424077e-02f, -5.23417257e-02f, 3.55607271e-01f, 2.08626315e-02f, 5.00521004e-01f, 1.66580081e-01f,
  2.99783736e-01f, 3.61031830e-01f, -4.14279699e-01f, -7.08196964e-03f, 1.49465531e-01f, -2.19163969e-01f, -7.92862475e-02f, -7.94264376e-02f, -1.15449183e-01f, -7.86200389e-02f,
  1.39888138e-01f, 2.12964743e-01f, 3.50098573e-02f, 4.97063324e-02f, 2.53249615e-01f, -6.87553501e-03f, 1.04519077e-01f, 1.23339698e-01f, 2.69322038e-01f, 2.73956299e-01f,
  2.16872320e-01f, -1.88216474e-02f, 1.35790274e-01f, -4.31114510e-02f, -4.39077675e-01f, 1.22707218e-01f, -8.59384909e-02f, -3.32483411e-01f, 2.66055137e-01f, -4.03071880e-01f,
  1.77123621e-01f, -2.37521842e-01f, 2.55182266e-01f, -1.09048568e-01f, -1.24480249e-02f, -8.07124004e-02f, -2.85275668e-01f, 3.06375176e-01f, 1.65221691e-01f, 2.26851881e-01f,
  1.28369793e-01f, -1.64203495e-01f, 5.23930304e-02f, -4.08461206e-02f, 1.77458040e-02f, 4.76481859e-03f, 7.39255920e-02f, -3.04334968e-01f, -1.19390473e-01f, 1.19565472e-01f,
  -4.75900397e-02f, -1.44000307e-01f, -9.12207812e-02f, 1.66133285e-01f, 2.04750583e-01f, -2.06612587e-01f, 1.78328887e-01f, -3.58983815e-01f, -9.62176397e-02f, 3.00947994e-01f,
  1.21541850e-01f, 3.53598028e-01f, 3.49361658e-01f, 1.20633602e-01f, -2.90169597e-01f, 3.09149586e-02f, -5.06362431e-02f, -2.29385138e-01f, -7.99477622e-02f, 2.50438694e-03f,
  2.92521622e-02f, 1.99809611e-01f, 3.33569884e-01f, -8.65125190e-03f, 1.99450374e-01f, 9.41096712e-03f, 3.12677890e-01f, 1.08989500e-01f, -5.59016578e-02f, 2.17906252e-01f,
  3.82680558e-02f, 1.43896654e-01f, 6.07445203e-02f, 2.26937160e-01f, -4.33403626e-02f, 1.73005924e-01f, -3.15009713e-01f, -7.06643164e-02f, -1.58150241e-01f, -2.97451466e-01f,
  -1.35534212e-01f, 1.31136596e-01f, -1.14162080e-01f, 2.88397491e-01f, -2.16141909e-01f, -3.23242009e-01f, -1.98985726e-01f, 2.58527398e-01f, 1.63043693e-01f, 1.43092558e-01f,
  1.08917736e-01f, -2.33342841e-01f, 1.07919373e-01f, -2.43629619e-01f, -2.54965723e-01f, 2.65929103e-01f, 2.26479188e-01f, -7.97637086e-03f, -8.95153731e-02f, -3.63365561e-02f,
  -2.55014151e-01f, 1.30299747e-01f, 2.06447110e-01f, 3.27503771e-01f, 1.98652297e-01f, 2.25021884e-01f, 2.40424857e-01f, 1.21142901e-01f, 2.77613848e-01f, 4.91577566e-01f,
  1.39154628e-01f, 4.36562747e-01f, 2.46701036e-02f, 2.39680395e-01f, -2.97366172e-01f, 1.47580624e-01f, 3.95002291e-02f, -5.48850149e-02f, 4.68586124e-02f, -3.54025185e-01f,
  3.19047570e-01f, 2.29400732e-02f, 2.92448789e-01f, 1.69087589e-01f, 2.10965037e-01f, 1.45897284e-01f, 2.08690777e-01f, -1.53758312e-02f, 1.06176296e-02f, 1.08545952e-01f,
  1.05598442e-01f, 1.00902945e-01f, 8.59338269e-02f, -4.93584871e-02f, 4.79563549e-02f, 1.36210039e-01f, -4.98308726e-02f, -6.59079198e-03f, 2.27465048e-01f, 2.12892480e-02f,
  4.01342273e-01f, 7.57783726e-02f, 2.02251196e-01f, 4.20987517e-01f, 3.18488657e-01f, 3.97104502e-01f, -8.89094099e-02f, -2.37599597e-03f, -1.52295023e-01f, 5.32264650e-01f,
  -1.32544851e-02f, -1.40012428e-01f, -6.63561523e-02f, 1.21006966e-01f, -9.14055016e-03f, -4.70559485e-02f, 1.13892622e-01f, 4.24486808e-02f, 1.16647705e-01f, -1.22582905e-01f,
  3.03150475e-01f, 1.32649392e-01f, 2.87237674e-01f, 2.11176157e-01f, -5.23987450e-02f, -6.69207200e-02f, 8.50214511e-02f, -1.67891383e-01f, 1.29277751e-01f, -3.44791889e-01f,
  4.16051364e-03f, 1.52790025e-01f, 1.49051070e-01f, -4.80295755e-02f, -1.80311233e-01f, 1.16782106e-01f, 1.52755037e-01f, -3.17455739e-01f, 4.09780383e-01f, 6.75678551e-02f,
  2.93457299e-01f, 2.39703164e-01f, 2.89027303e-01f, 2.64189690e-01f, -3.45477939e-01f, 1.82530418e-01f, -9.60005894e-02f, -3.50951403e-01f, 1.62876308e-01f, 4.91234846e-02f,
  -4.35600698e-01f, -2.35259950e-01f, 2.14994371e-01f, -3.38328513e-03f, 2.37641275e-01f, 2.50548303e-01f, -1.79765206e-02f, 1.46395355e-01f, 1.52620286e-01f, 1.56985283e-01f,
  4.57747914e-02f, -6.76171556e-02f, 1.23166472e-01f, -1.47856828e-02f, -2.66351730e-01f, -3.54007959e-01f, -3.57488036e-01f, 2.63066232e-01f, 2.91303903e-01f, -3.21056992e-01f,
  1.70886755e-01f, -1.41175896e-01f, -2.90440798e-01f, 2.51636058e-02f, -4.03673321e-01f, 2.67689794e-01f, -1.43505305e-01f, -3.61897908e-02f, -2.37585589e-01f, 1.24405742e-01f,
  3.62463415e-01f, -2.01032355e-01f, 1.33205578e-01f, -2.03110948e-01f, 5.03952503e-02f, -1.72786608e-01f, 1.58346623e-01f, 1.99944451e-01f, 2.07476497e-01f, -1.59231275e-01f,
  -1.04105212e-01f, 1.94386512e-01f, -3.82608324e-01f, 2.44418174e-01f, -2.01860368e-01f, -1.19968899e-01f, -3.38401407e-01f, -1.43836871e-01f, -2.31428146e-01f, 1.31952867e-01f,
  -1.02556244e-01f, 2.69355088e-01f, 2.02683553e-01f, 2.05081224e-01f, 1.81044415e-01f, 1.29749089e-01f, 3.28631774e-02f, 7.72996396e-02f, 2.58856732e-02f, -5.67250736e-02f,
  2.20026419e-01f, -1.45342439e-01f, 1.12802535e-01f, -3.24745893e-01f, 2.89933234e-01f, 3.89029458e-02f, 1.47415042e-01f, 1.38256952e-01f, 3.19627911e-01f, 5.51893786e-02f,
  1.12310082e-01f, 3.64087552e-01f, 2.46414721e-01f, 7.09678084e-02f, 1.92756861e-01f, 3.37873995e-01f, 1.47888418e-02f, 1.41270354e-01f, -1.21356554e-01f, -1.46414757e-01f,
  -2.29834527e-01f, -7.45331720e-02f, 1.50178954e-01f, -9.42668989e-02f, 2.63152481e-03f, 2.24663377e-01f, 4.73033031e-03f, 6.66135326e-02f, -2.94397682e-01f, 1.53254718e-01f,
  -4.01038788e-02f, -4.76894081e-02f, 2.33531937e-01f, -8.90764222e-02f, 2.45264098e-01f, -7.49081299e-02f, 1.98022142e-01f, 3.24506253e-01f, -1.88168846e-02f, -2.18278676e-01f,
  -2.30928194e-02f, 1.20201722e-01f, 2.05506861e-01f, -4.42834832e-02f, -2.92817324e-01f, 2.99189866e-01f, 1.39261439e-01f, 3.59190613e-01f, 1.28832042e-01f, -1.34989306e-01f,
  -2.61814564e-01f, -6.68951720e-02f, -2.25319594e-01f, 2.90981263e-01f, -2.76738256e-01f, 1.20758526e-01f, -5.78985140e-02f, -1.57214910e-01f, 2.00883046e-01f, -6.16890825e-02f,
  9.69354585e-02f, 1.48963869e-01f, 2.55769521e-01f, -6.14404716e-02f, 3.54191840e-01f, -1.84585914e-01f, -1.38268799e-01f, -1.17513418e-01f, 1.32184505e-01f, 2.18976110e-01f,
  1.60448939e-01f, 9.87925157e-02f, 4.46931571e-02f, 1.31245524e-01f, 1.76865473e-01f, 1.39945135e-01f, 1.78791553e-01f, 7.78793544e-02f, 1.68074798e-02f, -5.39378729e-03f,
  1.67620435e-01f, 1.23480693e-01f, 2.22974613e-01f, 1.31138965e-01f, -8.40675905e-02f, 8.20402801e-02f, -1.99314743e-01f, 3.76574218e-01f, -9.26448330e-02f, 6.54504001e-02f,
  1.71275780e-01f, 5.83684333e-02f, 1.77883178e-01f, -1.12698339e-01f, 3.15102100e-01f, -1.27757996e-01f, 1.13806948e-02f, 1.64246373e-02f, 9.00448635e-02f, -4.81153131e-02f,
  -3.53673190e-01f, 2.97210574e-01f, 4.01411593e-01f, -6.36975095e-02f, 2.75203258e-01f, 1.49230197e-01f, -5.94559908e-02f, 8.45719278e-02f, 2.38585174e-01f, -6.28809035e-02f,
  -1.64174110e-01f, -1.49962381e-01f, -3.34328443e-01f, 1.80039138e-01f, 5.12532413e-01f, 3.36675286e-01f, -1.39849260e-01f, 1.48971155e-01f, 8.23990405e-02f, 8.85118172e-02f,
  7.30012134e-02f, 1.81068942e-01f, 1.80656433e-01f, 1.84835956e-01f, -1.95371345e-01f, 3.39811593e-02f, -1.76238000e-01f, 2.70184845e-01f, -1.09449193e-01f, -4.22604084e-02f,
  1.81199536e-01f, 1.64554864e-01f, -2.29356930e-01f, 2.98813004e-02f, 1.56209208e-02f, 1.88130498e-01f, 1.11727186e-01f, -4.42527421e-02f, 1.83338434e-01f, 2.02771574e-01f,
  1.03271000e-01f, 1.67149171e-01f, -2.02756915e-02f, 9.32007954e-02f, 1.73479527e-01f, 1.57562837e-01f, 2.94904709e-01f, 5.53850681e-02f, -1.13135763e-01f, 6.83719516e-02f,
  -6.70858845e-02f, 1.28213450e-01f, -1.47233077e-03f, -8.36218223e-02f, 2.59204090e-01f, 1.67578787e-01f, 2.77186871e-01f, -3.07992429e-01f, 2.60854159e-02f, -2.93272566e-02f,
  5.42410910e-02f, 2.77719736e-01f, -4.80888151e-02f, -1.32236496e-01f, -1.75584272e-01f, 7.48219714e-02f, 3.25486869e-01f, 3.26570310e-02f, 1.80047557e-01f, 1.28684923e-01f,
  -1.83142312e-02f, -1.44461676e-01f, 2.23136887e-01f, -1.57766879e-01f, -3.02334607e-01f, -1.84019759e-01f, -3.22110176e-01f, -1.62553206e-01f, 2.65626162e-01f, -2.56877661e-01f,
  -8.03883150e-02f, -1.65434480e-01f, 2.84228593e-01f, -2.65419632e-01f, 2.07788721e-01f, -1.10428818e-01f, 3.04669410e-01f, 2.65714079e-01f, -3.25810611e-02f, 1.90829828e-01f,
  -2.49134094e-01f, 2.72958010e-01f, -9.53756720e-02f, -1.81217313e-01f, 1.93368480e-01f, -5.98864220e-02f, -1.89412251e-01f, -8.71203467e-02f, 2.33123407e-01f, 3.27829868e-02f,
  2.96935350e-01f, 1.08047485e-01f, 7.74755031e-02f, 2.49469727e-01f, 2.42352307e-01f, 9.24723223e-02f, 1.51740253e-01f, 3.20538878e-01f, 2.21791729e-01f, 2.69778520e-01f,
  -2.83913463e-01f, -1.86735913e-01f, -1.31488174e-01f, 7.49902576e-02f, 2.92885810e-01f, 5.63302301e-02f, -2.79393792e-01f, 1.13163099e-01f, -3.65233481e-01f, -4.35093194e-02f,
  -3.74631852e-01f, 3.49804848e-01f, -1.06710173e-01f, 2.32157111e-01f, 1.77572057e-01f, -3.70566934e-01f, 4.07918930e-01f, 2.68600881e-01f, 1.29632652e-01f, 1.35110348e-01f,
  1.47092819e-01f, -1.97094176e-02f, 3.75211798e-02f, 3.16941768e-01f, -1.51467830e-01f, -3.88105214e-01f, -2.19512150e-01f, 4.15956110e-01f, 3.86986494e-01f, 3.33374470e-01f,
  8.28346834e-02f, -9.38307494e-03f, -3.85382414e-01f, -2.03217804e-01f, 1.96049079e-01f, 4.53049898e-01f, -1.11040600e-01f, -1.72408625e-01f, 1.02507450e-01f, -1.86744496e-01f,
  -9.81602520e-02f, -1.10269189e-01f, 1.41779840e-01f, -1.14205817e-03f, 2.54289091e-01f, 3.13462526e-01f, 2.61655807e-01f, 4.21845056e-02f, -1.12116635e-01f, -1.50439501e-01f,
  2.24144772e-01f, -2.12108478e-01f, 1.88723579e-01f, 1.57656446e-01f, 7.39985779e-02f, 8.46864954e-02f, 1.64765999e-01f, -5.47415297e-03f, 1.93082467e-02f, 2.31590167e-01f,
  2.58816600e-01f, 2.53960192e-01f, 2.62396634e-01f, 9.84837338e-02f, 1.39307886e-01f, 3.43574017e-01f, -1.65271148e-01f, -1.37304906e-02f, -2.01779112e-01f, 7.80217201e-02f,
  1.80234909e-02f, -3.07305068e-01f, 1.35402501e-01f, -1.12344377e-01f, 1.85109954e-02f, -1.17718562e-01f, 2.26325959e-01f, -1.07298009e-02f, -5.16835824e-02f, -2.65140831e-01f,
  -8.36462677e-02f, 3.29059929e-01f, -1.11954466e-01f, -2.36003753e-02f, 2.55707055e-01f, -1.09667391e-01f, 2.31588602e-01f, -3.42770368e-02f, -1.81101680e-01f, -2.22129017e-01f,
  6.44099340e-02f, 2.24772379e-01f, 1.09482273e-01f, -2.99553514e-01f, -3.66559237e-01f, 3.45114887e-01f, 2.39660159e-01f, 2.74293602e-01f, 2.11875752e-01f, 2.05733124e-02f,
  -1.87166825e-01f, -7.65030319e-03f, -4.69137281e-02f, 2.15386659e-01f, 1.45704150e-01f, 9.34211016e-02f, -1.26890913e-01f, -2.67337888e-01f, 8.94635096e-02f, 7.00449944e-02f,
  -1.59233138e-01f, 2.18446568e-01f, 1.52582377e-01f, -7.18392478e-03f, 1.43350229e-01f, -1.42997876e-01f, 2.94900499e-02f, 8.51491466e-02f, 3.37251127e-01f, 1.95887700e-01f,
  2.73549184e-02f, 1.09700307e-01f, 3.14108372e-01f, 2.89526612e-01f, -1.81362703e-01f, 1.40515521e-01f, 6.43749759e-02f, 1.38308063e-01f, -2.62164861e-01f, -6.84503093e-02f,
  1.25335485e-01f, 1.88311785e-02f, -2.14595124e-02f, -4.68145013e-02f, 3.57797414e-01f, -9.58281904e-02f, 1.35339096e-01f, 4.34438847e-02f, -1.64813340e-01f, 1.51823321e-03f,
  4.75335985e-01f, 3.74519944e-01f, -1.21740632e-01f, -1.30332246e-01f, -1.76050320e-01f, -8.41594636e-02f, 2.01022714e-01f, -2.34627590e-01f, -1.60247728e-01f, -5.55135868e-02f,
  -1.43422306e-01f, -3.08035970e-01f, -1.84494667e-02f, 2.62451530e-01f, 1.57907873e-01f, 3.10358733e-01f, 2.59927154e-01f, 2.82961756e-01f, 7.65075609e-02f, -3.79021108e-01f,
  2.90583402e-01f, 3.97875458e-01f, 4.59170938e-01f, 3.12005311e-01f, 1.53476775e-01f, -5.20724580e-02f, 5.81939286e-03f, -1.39122933e-01f, 3.10301632e-01f, -2.78137298e-03f,
  3.25576276e-01f, -3.03013086e-01f, -1.48055172e-02f, -1.03888445e-01f, 3.42384040e-01f, 4.47890341e-01f, -7.91893527e-03f, 1.04105808e-01f, 2.65673041e-01f, -9.04112235e-02f,
  2.26125821e-01f, 5.91314919e-02f, 2.46826246e-01f, 8.24752375e-02f, 1.55714139e-01f, 1.64677948e-01f, 1.07567176e-01f, 1.41999498e-01f, 1.19940840e-01f, 3.33749056e-01f,
  2.52972245e-01f, 1.49090603e-01f, 2.30515063e-01f, -4.01014954e-01f, -3.14610630e-01f, 2.77430356e-01f, -1.53391093e-01f, -1.65229186e-01f, 1.10846058e-01f, -1.87143415e-01f,
  -1.28440037e-01f, -5.50375104e-01f, 1.49534941e-01f, 1.90584874e-03f, -6.58607632e-02f, 2.90031642e-01f, -3.65107507e-01f, -7.27738440e-02f, 3.56061250e-01f, 5.61216295e-01f,
  2.86225945e-01f, -1.89674377e-01f, -2.18923707e-02f, 2.32153405e-02f, -1.43677726e-01f, -6.29612282e-02f, 1.91927314e-01f, -3.69525164e-01f, -6.05494082e-02f, 1.13495737e-01f,
  2.65018463e-01f, 2.22573504e-01f, 3.07304710e-01f, -1.73709154e-01f, 2.30352044e-01f, -1.87966064e-01f, 2.30849832e-01f, 1.91468969e-01f, 1.83838025e-01f, 9.15459245e-02f,
  -1.03302673e-02f, -1.04093194e-01f, 4.03783262e-01f, 3.06359202e-01f, 2.48100385e-02f, -1.81718230e-01f, 1.43664524e-01f, -1.84673741e-01f, 5.30216319e-04f, -5.16574383e-02f,
  4.17274721e-02f, 1.84281394e-01f, -2.22494756e-03f, -2.92179167e-01f, 2.42135271e-01f, 4.13559638e-02f, 1.73726663e-01f, 2.64962435e-01f, 8.67458805e-02f, 1.89868957e-01f,
  2.29191810e-01f, 2.29165763e-01f, 2.12450236e-01f, 1.40480235e-01f, 1.03891298e-01f, 2.92514920e-01f, -2.08801374e-01f, -1.48411021e-01f, -1.37108147e-01f, -2.62348682e-01f,
  3.00949030e-02f, -3.61987889e-01f, 2.10155427e-01f, -9.31822285e-02f, -5.89425396e-03f, -3.41355830e-01f, -2.74688989e-01f, 2.64750212e-01f, -2.39004686e-01f, -2.05187455e-01f,
  1.48489833e-01f, 2.23623738e-01f, 3.07478756e-01f, -9.72242951e-02f, 2.40919381e-01f, 2.47210965e-01f, -1.14971958e-01f, -2.10344195e-01f, -1.07156470e-01f, 3.46220694e-02f,
  2.54914671e-01f, -1.80653393e-01f, -5.07079139e-02f, 2.39410982e-01f, -4.88990657e-02f, 3.56043309e-01f, 7.56108984e-02f, 1.72853246e-01f, -7.32089533e-03f, -2.94551179e-02f,
  1.43618658e-01f, -4.43740457e-04f, -2.75182635e-01f, 3.66968870e-01f, -3.39291871e-01f, 3.23042035e-01f, -3.16738859e-02f, 2.33655665e-02f, -2.70381033e-01f, -7.14353323e-02f,
  2.99846202e-01f, -1.74718931e-01f, 1.07646972e-01f, 2.69495100e-01f, -9.48262289e-02f, 1.47009805e-01f, 3.80843073e-01f, 1.68962389e-01f, 2.16399461e-01f, 2.51794577e-01f,
  1.53429255e-01f, 1.27711713e-01f, 1.79224294e-02f, 2.16693152e-03f, 1.55382589e-01f, 6.27003685e-02f, 5.34393191e-02f, -5.12338243e-02f, 1.90455213e-01f, 2.45938912e-01f,
  -2.64027272e-03f, 2.14262724e-01f, 2.17724606e-01f, 2.92740646e-03f, -2.62480117e-02f, 1.95949584e-01f, -3.53112787e-01f, 3.88700843e-01f, -2.30523929e-01f, 6.13164268e-02f,
  9.31369141e-03f, -1.41044736e-01f, 2.43418023e-01f, 2.44909152e-01f, 1.96765959e-01f, -7.20166788e-02f, 1.18054248e-01f, -9.91145521e-02f, -4.31189805e-01f, 2.06484288e-01f,
  3.58389884e-01f, 3.42754751e-01f, -9.00949836e-02f, 2.95123130e-01f, -1.37421235e-01f, 2.45669365e-01f, 3.44203949e-01f, -3.02222103e-01f, 8.25462118e-03f, -1.46943301e-01f,
  9.44679230e-02f, -1.00441121e-01f, 3.95890288e-02f, 2.84276843e-01f, 6.67978823e-02f, 7.71585181e-02f, 3.70509803e-01f, -1.87630221e-01f, 1.81033149e-01f, -6.41858429e-02f,
  -8.48792866e-02f, -9.25420746e-02f, 1.52958333e-01f, 2.91062713e-01f, 2.86297321e-01f, 3.42026263e-01f, 8.04120675e-03f, -1.93704486e-01f, 3.31511766e-01f, 1.08381867e-01f,
  -1.26790717e-01f, -4.43597846e-02f, 8.54268223e-02f, 1.44694149e-01f, 7.15177730e-02f, 1.29725248e-01f, 7.80141801e-02f, 3.22582603e-01f, 1.88883454e-01f, 2.19087437e-01f,
  1.86007634e-01f, 3.28139544e-01f, 6.75720200e-02f, 1.43949062e-01f, 1.95064977e-01f, 2.72038341e-01f, -1.46753520e-01f, -3.32783796e-02f, -2.31914029e-01f, 1.70420229e-01f,
  1.90926298e-01f, -1.57350257e-01f, 1.59149274e-01f, -8.44525620e-02f, 2.26566955e-01f, -2.66277283e-01f, 2.25855410e-01f, -2.21868530e-02f, 3.08492213e-01f, 1.68584101e-03f,
  -5.98581061e-02f, -9.00136009e-02f, -2.44241983e-01f, 2.76695907e-01f, 2.83924729e-01f, 5.63486665e-02f, -2.95116007e-02f, -3.28724265e-01f, -2.46700719e-01f, -3.69604491e-02f,
  1.82760745e-01f, 2.49872148e-01f, -5.10151088e-02f, -1.27127290e-01f, -3.36608171e-01f, 9.83194485e-02f, 2.42749974e-01f, 2.86965836e-02f, 2.74799705e-01f, 6.44845888e-02f,
  3.28749269e-02f, 2.50380665e-01f, 1.69257335e-02f, 1.99763656e-01f, 2.88662374e-01f, 1.62387326e-01f, -2.06831992e-01f, -1.47407576e-01f, 2.18397737e-01f, -6.14886954e-02f,
  -2.54768550e-01f, 3.98720771e-01f, 1.36882067e-01f, 1.89350516e-01f, 2.26638719e-01f, -3.32357250e-02f, 1.42189294e-01f, 1.21894091e-01f, 7.93222785e-02f, 6.89846352e-02f,
  2.88472235e-01f, 2.58466303e-01f, 7.95305744e-02f, 1.89172313e-01f, 1.48384169e-01f, 2.85055190e-01f, 3.06012630e-01f, 1.71813875e-01f, 4.25805390e-01f, 2.45841876e-01f,
  2.63535082e-01f, 3.33056331e-01f, 2.02796102e-01f, 1.37079120e-01f, -1.69537216e-01f, -3.57444584e-02f, -1.03488423e-01f, 2.76339471e-01f, 1.65429100e-01f, -8.04167986e-02f,
  -9.86638069e-02f, 3.35757732e-01f, 1.27320588e-01f, -1.76224515e-01f, 1.21758647e-01f, 1.46796688e-01f, -7.46877119e-03f, 2.18101621e-01f, 2.76682854e-01f, 2.00873077e-01f,
  4.02248114e-01f, 8.91009346e-02f, -2.10538775e-01f, -2.18785748e-01f, -8.70648697e-02f, -8.81799161e-02f, 3.25764298e-01f, -3.31517607e-01f, 4.03111309e-01f, 2.89023131e-01f,
  -8.56831856e-03f, -2.51745164e-01f, 2.92364322e-02f, 2.33871847e-01f, 7.87223354e-02f, -2.65469909e-01f, 3.94072086e-01f, 1.83691546e-01f, 1.52951866e-01f, 2.17090398e-01f,
  3.32753479e-01f, 8.80969986e-02f, 2.01744050e-01f, 2.38668378e-02f, -1.57910630e-01f, -2.28685036e-01f, 1.08890101e-01f, 2.61960894e-01f, -2.99472779e-01f, -1.85913332e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  9.99933258e-02f, 1.24692835e-01f, 1.10084787e-01f, 2.50827223e-01f, 2.35611424e-02f, 9.49301943e-02f, 2.23117098e-01f, 2.29778066e-01f, 1.41973812e-02f, 1.01112254e-01f,
  1.62039563e-01f, 9.18934122e-02f, 2.98150480e-01f, 1.86402380e-01f, 1.48117542e-01f, 1.62450299e-01f, 1.74461603e-01f, 2.73313731e-01f, 1.33137703e-01f, 4.42369953e-02f,
  2.49488086e-01f, 1.97550356e-01f, 7.05489237e-03f, 1.83524445e-01f, 2.60089844e-01f, 1.38501614e-01f, 1.11157082e-01f, 1.69628531e-01f, 1.72319695e-01f, 2.97490209e-01f,
  3.89317013e-02f, 6.57381564e-02f, 1.64141595e-01f, 1.65065616e-01f, 2.16091007e-01f, 1.86354399e-01f, 2.07337275e-01f, 7.05541223e-02f, 2.52595693e-01f, 8.66012946e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  1.04648389e-01f, -1.50035009e-01f, -3.32136862e-02f, -9.96267721e-02f, 3.13753076e-02f, 1.48022830e-01f, -9.83224660e-02f, -2.06839126e-02f, -1.90027192e-01f, -2.33811960e-01f,
  1.29712070e-03f, -4.59204428e-02f, 3.10270220e-01f, 3.08524847e-01f, 2.97965437e-01f, -8.71416107e-02f, 4.53636274e-02f, 7.77027244e-03f, -1.55606598e-01f, 1.83534488e-01f,
  1.15638770e-01f, 5.14876693e-02f, 1.96042135e-01f, -8.43519419e-02f, -2.43636161e-01f, -2.86931306e-01f, 1.01562031e-01f, -1.27731279e-01f, 3.45495850e-01f, -7.94745162e-02f,
  -3.66320610e-01f, 1.30715564e-01f, -2.62767017e-01f, -2.46484846e-01f, -3.18301409e-01f, 3.65771979e-01f, -3.59411061e-01f, 3.43842655e-01f, 2.40432203e-01f, -5.51003754e-01f,
  -2.30486486e-02f, -5.82454689e-02f, 3.03094566e-01f, -2.77955711e-01f, 3.02965999e-01f, -2.90122122e-01f, -1.04809694e-01f, -3.07239056e-01f, -4.30432595e-02f, -3.33343774e-01f,
  -2.33920470e-01f, 1.33175448e-01f, -3.72947067e-01f, -3.56205612e-01f, 1.33221582e-01f, 2.27051273e-01f, -3.27882111e-01f, -2.21797779e-01f, -3.11980098e-01f, -2.07348019e-01f,
  -3.07535261e-01f, 2.47390807e-01f, -1.41669691e-01f, -1.21263064e-01f, -1.05305538e-02f, 1.92623004e-01f, -1.73637494e-01f, -7.43492991e-02f, -3.87800336e-02f, -1.87491160e-02f,
  2.69766927e-01f, 6.75361836e-03f, 1.86358526e-01f, -3.64938751e-02f, -1.26277328e-01f, -2.65096836e-02f, -2.56675631e-01f, 3.06994051e-01f, 2.40025669e-01f, -1.62761003e-01f,
  -3.36863011e-01f, 1.65116400e-01f, 1.14174895e-01f, 5.75733669e-02f, 2.89862871e-01f, 9.35072824e-03f, 1.86798051e-01f, 2.52799839e-01f, 3.54574531e-01f, -9.89380479e-02f,
  -4.22061861e-01f, -5.00061512e-01f, -2.83011138e-01f, 3.75532717e-01f, -5.70563734e-01f, 6.39296770e-02f, -1.64004043e-01f, 2.16033891e-01f, 1.41899228e-01f, -1.22243300e-01f,
  -1.87721342e-01f, 1.72193155e-01f, -2.15180635e-01f, -1.47394732e-01f, 1.42365277e-01f, -5.06218970e-01f, 2.56647497e-01f, -4.81350683e-02f, -2.71966476e-02f, -1.73479542e-01f,
  -3.86227250e-01f, 3.78770311e-03f, 2.48974830e-01f, -3.43609974e-02f, -2.02688470e-01f, 4.06221539e-01f, 2.32167482e-01f, 1.29265711e-02f, 3.91564704e-02f, -2.43496727e-02f,
  1.42272592e-01f, 8.07014108e-02f, -3.18315953e-01f, -4.16460931e-01f, -2.99180299e-01f, 1.44174755e-01f, -2.42927507e-01f, 2.88192332e-01f, -8.26753303e-02f, 6.53986633e-02f,
  -3.08372509e-02f, 8.57227296e-02f, 6.13894761e-02f, -6.23790175e-02f, -2.20447436e-01f, 8.27722698e-02f, 8.77687335e-03f, 6.34943247e-02f, 6.62442148e-02f, -1.35373175e-01f,
  -6.32930605e-04f, -2.31906205e-01f, 3.47238392e-01f, 2.51220196e-01f, 1.58108205e-01f, 2.04702601e-01f, 1.98009491e-01f, -8.87591690e-02f, -2.47454211e-01f, -2.21810073e-01f,
  1.10325450e-02f, -1.22949064e-01f, 1.37769327e-01f, 1.71134457e-01f, -2.65343804e-02f, -3.37266386e-01f, -2.08591431e-01f, -2.88327545e-01f, -1.90382019e-01f, -3.45482141e-01f,
  2.43513837e-01f, 2.87883639e-01f, 2.11326033e-01f, -2.00893000e-01f, -1.27792001e-01f, 1.57097280e-01f, -2.75188088e-01f, 2.10880205e-01f, -3.43443692e-01f, -3.71950299e-01f,
  -2.13020697e-01f, -2.42789283e-01f, -3.71891409e-01f, 1.95807785e-01f, 3.92331392e-01f, -1.94265708e-01f, 3.21543068e-01f, -1.25150040e-01f, -3.93934369e-01f, 1.64237425e-01f,
  -3.43343139e-01f, 6.67188913e-02f, -2.99446762e-01f, -3.60802621e-01f, 8.54867175e-02f, -3.28149647e-02f, -9.77573078e-03f, 1.13068856e-01f, -2.73665547e-01f, -4.59189922e-01f,
  -3.46467912e-01f, 2.40257248e-01f, -1.13694191e-01f, 7.50091746e-02f, -1.49914712e-01f, -1.98911443e-01f, -5.09547852e-02f, -9.96398460e-03f, 1.62630960e-01f, -1.69748619e-01f,
  7.10786358e-02f, 2.55072992e-02f, -1.03586435e-01f, -4.36408818e-02f, 7.75478482e-02f, 2.84228742e-01f, -2.00874165e-01f, -6.78361729e-02f, 1.36240244e-01f, -2.98830152e-01f,
  -2.67895103e-01f, -8.87919217e-02f, 1.06235340e-01f, -1.96762010e-02f, 3.15086660e-03f, -1.99631125e-01f, -4.07505304e-01f, 1.53033376e-01f, -5.41810095e-01f, 5.94827794e-02f,
  3.07989031e-01f, 1.85870662e-01f, -1.79012135e-01f, 3.31379205e-01f, -2.09941775e-01f, -3.01412940e-01f, -3.71646434e-01f, -1.13800824e-01f, 2.09474638e-01f, -5.07345974e-01f,
  3.21449675e-02f, 5.52140083e-03f, 2.90028125e-01f, 2.04802513e-01f, -3.77062000e-02f, -2.06067160e-01f, 4.40405905e-02f, -1.23916060e-01f, -2.16561511e-01f, 2.19971567e-01f,
  -5.35496652e-01f, -4.29744601e-01f, 1.97588757e-01f, -1.50270581e-01f, -1.49238944e-01f, -4.17094529e-01f, 1.76895633e-01f, -1.45634905e-01f, -2.63434201e-01f, 8.07910934e-02f,
  2.80557781e-01f, -3.79213333e-01f, -2.29400694e-01f, 2.15384945e-01f, 5.61908782e-02f, -5.29345930e-01f, -1.37996171e-02f, 1.23270713e-01f, 1.99049294e-01f, 8.35406706e-02f,
  -7.50115588e-02f, 1.12259753e-01f, 9.19043198e-02f, 2.39485353e-01f, 2.08357602e-01f, -2.04734415e-01f, 9.46138725e-02f, 1.04980886e-01f, 2.19723836e-01f, -1.76083639e-01f,
  -1.62957132e-01f, 1.59565404e-01f, 2.23968476e-01f, -2.06699237e-01f, -2.24950761e-01f, -3.74223292e-01f, 5.93267158e-02f, 2.21043736e-01f, -3.80524337e-01f, 1.64217889e-01f,
  -2.11225867e-01f, 4.46819328e-02f, 1.53618693e-01f, 7.64776692e-02f, -3.09539080e-01f, 6.59378171e-02f, -1.91528574e-02f, 9.44382176e-02f, -2.79643208e-01f, -2.70620972e-01f,
  -1.00005232e-01f, 2.85632998e-01f, 3.61611962e-01f, 2.35868633e-01f, 1.67051405e-01f, 4.05988514e-01f, -4.25612837e-01f, 3.73617619e-01f, -1.72926441e-01f, -1.15562342e-01f,
  2.82617629e-01f, 2.12187439e-01f, -1.82932481e-01f, -1.23193689e-01f, -6.51218668e-02f, -9.22677144e-02f, -2.04288557e-01f, -1.31308272e-01f, -3.00524198e-02f, 1.04632325e-01f,
  -1.78199485e-01f, -4.79073822e-02f, -4.66170073e-01f, -2.88714021e-01f, -4.19851318e-02f, -3.91897291e-01f, 6.03739172e-02f, -2.00879082e-01f, 9.74745210e-03f, -4.81664483e-03f,
  -7.38924444e-02f, 1.40822977e-01f, 1.42587483e-01f, 1.73968166e-01f, 1.97024971e-01f, 7.25592002e-02f, -6.46222085e-02f, 1.18149556e-02f, -9.43568628e-03f, -1.70236915e-01f,
  -7.96558261e-02f, 1.62115961e-01f, -2.07523778e-01f, -3.22406590e-01f, -1.40638053e-01f, -8.63759816e-02f, -9.66527238e-02f, 2.31250629e-01f, -2.72396088e-01f, 1.67479977e-01f,
  -2.69621387e-02f, 1.90930188e-01f, 3.71169925e-01f, -1.14656538e-01f, 1.06960192e-01f, -7.96971992e-02f, 2.09439158e-01f, 3.80034834e-01f, -2.94615865e-01f, 5.70490174e-02f,
  2.65937537e-01f, -3.59636813e-01f, -1.81097612e-01f, -4.49698091e-01f, 2.39115894e-01f, -1.03238463e-01f, -4.01027054e-01f, -1.74922079e-01f, 2.80213505e-01f, -1.81098580e-01f,
  -1.79765999e-01f, -5.67161031e-02f, 3.23970765e-01f, -4.67139453e-01f, 1.71323270e-01f, -3.67195576e-01f, -2.27138802e-01f, -6.00121953e-02f, -2.32605755e-01f, -3.27331036e-01f,
  3.03968728e-01f, -4.33969676e-01f, -1.80227458e-01f, 3.43648851e-01f, -6.51288182e-02f, -2.97773927e-01f, 2.52779305e-01f, 6.95945546e-02f, -4.56182420e-01f, 3.87921743e-02f,
  1.41927466e-01f, 5.55936433e-02f, 1.77570339e-02f, 3.70405763e-02f, -1.84450850e-01f, -1.64885864e-01f, -6.88248798e-02f, 4.41347808e-02f, 8.00581351e-02f, -1.28716961e-01f,
  -1.83721945e-01f, 1.34631470e-01f, -8.95741507e-02f, 1.33259252e-01f, 1.25199348e-01f, 1.18861839e-01f, -1.63758516e-01f, 8.77225250e-02f, -2.24662095e-01f, 2.58255333e-01f,
  -9.94384438e-02f, -3.41200501e-01f, 2.42329448e-01f, -6.70640022e-02f, -1.97328389e-01f, -2.51697302e-01f, 2.07577646e-01f, 2.72795737e-01f, 6.30529895e-02f, 7.49043375e-02f,
  -4.22928303e-01f, 1.57408580e-01f, -3.07160020e-01f, 2.12867722e-01f, 2.29166269e-01f, -1.59951657e-01f, -6.91315234e-02f, 2.37379685e-01f, 2.02230856e-01f, -4.53028947e-01f,
  3.22918296e-02f, -3.93518656e-01f, -2.44589061e-01f, 1.12368114e-01f, -2.55682826e-01f, -3.77793312e-01f, -3.18546623e-01f, 1.46116182e-01f, -3.51847678e-01f, -2.11686678e-02f,
  -1.25261351e-01f, -3.33628446e-01f, 1.05717659e-01f, -2.58287370e-01f, 2.76146084e-01f, -3.87611240e-01f, 3.47648293e-01f, 3.03564608e-01f, -2.68476486e-01f, -2.47103199e-01f,
  2.89948195e-01f, -4.12658572e-01f, 3.32835644e-01f, 2.10285172e-01f, 1.60717234e-01f, -3.34731460e-01f, -4.18124437e-01f, -4.80341405e-01f, 3.00041791e-02f, 5.48251867e-02f,
  -1.34874791e-01f, 4.33410555e-02f, -1.36988789e-01f, 3.93157825e-02f, -1.83309838e-01f, -1.79338399e-02f, -1.00626111e-01f, 1.34805486e-01f, -1.86428800e-01f, -7.77847692e-02f,
  -1.20755926e-01f, 1.43835202e-01f, 2.66892523e-01f, -1.72683969e-01f, 2.50508767e-02f, 8.47907215e-02f, -1.93125129e-01f, 1.15749940e-01f, -8.08632597e-02f, -1.53509125e-01f,
  -1.09680898e-01f, -2.39068747e-01f, -2.63225675e-01f, 3.10052335e-01f, 2.61037469e-01f, 2.82759637e-01f, -1.73588172e-01f, -2.93223917e-01f, -7.82074109e-02f, 5.73159195e-02f,
  -3.17982316e-01f, 1.52759418e-01f, -2.09377855e-01f, 9.77927372e-02f, -2.66319543e-01f, -5.05198538e-01f, -2.65455432e-02f, 1.13828808e-01f, -1.01396866e-01f, -5.42188361e-02f,
  -3.42318803e-01f, 2.75965899e-01f, -3.97072472e-02f, -3.07799160e-01f, 2.46340722e-01f, 1.54786557e-01f, -3.71935993e-01f, 2.94560403e-01f, 2.83076108e-01f, -2.86180377e-01f,
  -1.89037591e-01f, -3.55901092e-01f, 1.34749696e-01f, -1.69877708e-01f, -2.52366662e-01f, 2.12378964e-01f, -2.15867311e-01f, -1.60035282e-01f, 2.51482576e-01f, -2.76704401e-01f,
  2.21368477e-01f, -1.11512495e-02f, 1.21453471e-01f, -1.28506422e-01f, -4.00265194e-02f, -1.74880117e-01f, 3.92370448e-02f, -1.81513295e-01f, 5.34899645e-02f, -1.46170273e-01f,
  -7.20906928e-02f, 7.96600729e-02f, -3.38651240e-02f, -5.90520687e-02f, -2.39166226e-02f, -2.11234242e-01f, -1.81805745e-01f, -2.32511669e-01f, -2.04692900e-01f, 1.87143460e-01f,
  -2.91803926e-01f, 1.84736758e-01f, -2.42073417e-01f, -1.73504855e-02f, 2.48383045e-01f, 1.00363716e-01f, -2.37940639e-01f, -2.91316032e-01f, -8.60451609e-02f, -2.61439849e-02f,
  -9.59691331e-02f, -2.63738453e-01f, -6.55384585e-02f, -1.51404813e-01f, -8.18175077e-02f, -1.96073636e-01f, -2.21902832e-01f, -2.35616878e-01f, -7.05674430e-03f, -3.89463067e-01f,
  -1.46157712e-01f, -4.39325385e-02f, 2.19150409e-01f, 4.68280725e-03f, -2.55018264e-01f, -2.43012458e-01f, -2.12995455e-01f, 3.63430232e-01f, 3.53355020e-01f, 2.98431307e-01f,
  -2.65718162e-01f, -8.09768140e-02f, 5.49226366e-02f, 7.24298954e-02f, -2.72867858e-01f, -3.28240722e-01f, -2.89753377e-01f, -1.54942483e-01f, 7.25604743e-02f, -1.63494915e-01f,
  1.29721135e-01f, 3.98701519e-01f, -2.19527975e-01f, 3.30070496e-01f, -1.25955299e-01f, 3.22131723e-01f, 1.32032707e-01f, -8.19830671e-02f, 2.52052844e-02f, 1.22040048e-01f,
  1.14450812e-01f, 1.68717846e-01f, 2.51117330e-02f, -1.97545126e-01f, 1.60894066e-01f, 9.82710645e-02f, -1.42992452e-01f, 1.08407073e-01f, -9.13794413e-02f, -2.65428722e-01f,
  1.28456146e-01f, 6.87400997e-02f, 4.17834744e-02f, 1.17449589e-01f, 1.37059993e-04f, 8.10993612e-02f, -2.47831747e-01f, 9.16988701e-02f, -3.66294146e-01f, -4.54380482e-01f,
  1.96515411e-01f, 1.91421777e-01f, 2.98698992e-01f, -1.23030178e-01f, 1.09565094e-01f, -3.05180043e-01f, 3.11309934e-01f, -2.52573520e-01f, -3.53016198e-01f, 1.00651130e-01f,
  -3.05822939e-01f, 1.00831620e-01f, -3.59630376e-01f, 1.40065029e-01f, 3.62494253e-02f, -1.51885942e-01f, -1.73027679e-01f, -4.95327950e-01f, 1.03369571e-01f, 3.68270963e-01f,
  8.73988867e-02f, -2.72066072e-02f, -6.80513531e-02f, -3.81562829e-01f, 7.21899346e-02f, 4.37948436e-01f, -4.24937308e-01f, -3.00425380e-01f, 2.62620836e-01f, 5.00913411e-02f,
  -3.95392001e-01f, -1.99910134e-01f, -8.90643522e-02f, -3.36948410e-02f, -4.24183697e-01f, 2.76438177e-01f, 2.79376686e-01f, -4.26932305e-01f, -3.29924196e-01f, -3.29386473e-01f,
  1.43489048e-01f, 1.44352838e-01f, 1.63803045e-02f, -7.44936243e-02f, 4.35994603e-02f, -6.53986633e-02f, -4.60693426e-02f, -6.12762291e-04f, 1.27769217e-01f, -9.03650746e-02f,
  -1.20820086e-02f, 1.28687605e-01f, 2.98908830e-01f, 4.95129731e-03f, 1.07585890e-02f, -1.67377919e-01f, 8.51545762e-03f, 3.10799897e-01f, 3.13147485e-01f, -2.98243999e-01f,
  1.39875054e-01f, -2.03389138e-01f, -2.28680506e-01f, 2.08487928e-01f, -2.14703307e-01f, 1.82848185e-01f, -1.51762024e-01f, -4.74185124e-02f, -3.81060131e-02f, 1.48569137e-01f,
  -2.67934203e-01f, 2.74131238e-01f, 1.92552671e-01f, -3.43757182e-01f, 1.74399376e-01f, -4.34882790e-01f, 1.33815348e-01f, -1.22161381e-01f, -4.73682940e-01f, -4.75248367e-01f,
  2.02954262e-01f, -3.97186503e-02f, -3.66074234e-01f, -2.46732682e-01f, -1.91739962e-01f, -7.96590522e-02f, 1.53122947e-01f, -2.00256228e-01f, 1.88989386e-01f, 3.89269352e-01f,
  -1.93470970e-01f, 1.79037049e-01f, -2.14272231e-01f, -2.19251156e-01f, 2.46797130e-01f, 3.34882170e-01f, -3.89005572e-01f, 2.22197190e-01f, 5.01455329e-02f, 3.96233976e-01f,
  -1.94101483e-01f, -1.05277047e-01f, 2.98711926e-01f, 5.99304400e-02f, 8.51338953e-02f, -1.17119066e-01f, -1.81001276e-01f, 8.72224867e-02f, 9.29228589e-02f, 1.90410262e-03f,
  -5.03332838e-02f, 5.42439930e-02f, -8.23287070e-02f, 1.54464215e-01f, 2.23391550e-03f, -1.90931216e-01f, 1.60993621e-01f, -1.08602427e-01f, -1.95302352e-01f, 6.68449700e-02f,
  -2.48244837e-01f, -2.92103320e-01f, 1.23515420e-01f, -2.84104705e-01f, -3.12640160e-01f, 4.29889150e-02f, 9.31244716e-02f, 2.46419027e-01f, -3.79019022e-01f, -4.94154394e-02f,
  1.55914947e-01f, -3.31859440e-01f, 1.76184207e-01f, -2.84233570e-01f, 3.43877226e-01f, -3.77855659e-01f, 3.85223448e-01f, -2.37577125e-01f, -3.96299828e-03f, -4.71859753e-01f,
  2.01838449e-01f, 1.38570860e-01f, 3.70773464e-01f, 1.35127679e-01f, 2.72378653e-01f, 2.30609551e-01f, -1.27925634e-01f, -1.85896635e-01f, -4.67561603e-01f, -3.28804940e-01f,
  -1.91570640e-01f, 1.50387973e-01f, -3.71034235e-01f, 2.17835188e-01f, -7.32621253e-02f, -3.66092563e-01f, -1.70657858e-01f, -1.44630209e-01f, -3.50556493e-01f, -2.01980516e-01f,
  1.26811445e-01f, 2.47294486e-01f, 2.41138309e-01f, -1.38979062e-01f, 7.34547377e-02f, -2.14696854e-01f, 1.85153037e-01f, -2.36803934e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.12795681e-01f, 6.69441605e-03f, -1.73530295e-01f, -1.08555794e-01f, -1.73025802e-02f, -6.95183426e-02f, -2.58013103e-02f, 4.54520434e-02f, -3.31209088e-03f, 1.13885561e-02f,
  -9.01394486e-02f, 7.10983127e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    