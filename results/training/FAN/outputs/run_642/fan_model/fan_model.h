/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.94164908e-01f, -9.73247550e-03f, 2.20716491e-01f, -7.41043836e-02f, 1.37599539e-02f, -1.13823213e-01f, 1.22827247e-01f, -1.04050286e-01f, -1.64069548e-01f, -1.49890319e-01f,
  -2.15249449e-01f, -5.23079753e-01f, -3.42674404e-01f, -3.15817207e-01f, -1.56255856e-01f, 2.00630814e-01f, 2.72100747e-01f, -7.27024749e-02f, -1.75155386e-01f, -2.56022841e-01f,
  -2.51992624e-02f, -1.67281535e-02f, -8.11792091e-02f, -9.39551517e-02f, -8.48637000e-02f, -1.19086690e-01f, 1.48856983e-01f, 2.04998553e-02f, -1.13356590e-01f, 2.34319661e-02f,
  -1.41698465e-01f, -3.23099464e-01f, -1.68624431e-01f, -3.19046050e-01f, -1.26727849e-01f, -2.56301105e-01f, -2.25306526e-01f, -1.57318145e-01f, -1.67688653e-01f, -1.36722893e-01f,
  -1.95636556e-01f, -1.92136496e-01f, -1.96967125e-01f, -1.61626726e-01f, -2.19673842e-01f, -1.72330961e-01f, -5.44699607e-03f, -7.14254454e-02f, -1.07268967e-01f, -1.67039931e-01f,
  -9.60745215e-02f, -1.10315122e-01f, -1.04680859e-01f, -2.05622539e-01f, -2.22787246e-01f, -2.18271539e-01f, -2.12576881e-01f, -3.05234075e-01f, -2.02547222e-01f, -1.46276057e-01f,
  -4.47260179e-02f, 6.66382611e-02f, 2.76459400e-02f, 7.71335214e-02f, 2.13802770e-01f, 6.53917566e-02f, 1.59719065e-01f, 7.95025900e-02f, 9.84223261e-02f, 1.31551623e-01f,
  6.49046600e-02f, 1.58183634e-01f, 6.54125810e-02f, 7.54425377e-02f, 1.31189153e-01f, 1.44844979e-01f, 1.13835253e-01f, 1.34660468e-01f, 9.23324227e-02f, 1.23946346e-01f,
  7.65567645e-02f, 1.41356930e-01f, 1.84312850e-01f, 2.58495007e-02f, 1.33254483e-01f, 1.47723287e-01f, 1.47068322e-01f, 1.56188086e-02f, 1.15059942e-01f, 1.36376381e-01f,
  -1.44617513e-01f, -2.83614218e-01f, -2.58056074e-01f, -1.82118639e-01f, -1.96481675e-01f, -1.54826775e-01f, -2.05130473e-01f, -2.34255314e-01f, -2.21602574e-01f, -1.28691509e-01f,
  -2.46943653e-01f, -2.29049131e-01f, -2.82103211e-01f, -1.62183702e-01f, -1.90147460e-01f, -1.75976306e-01f, -1.20530270e-01f, -1.35111168e-01f, -1.77594438e-01f, -1.82208344e-01f,
  -7.32400268e-02f, -1.48156211e-01f, -2.12871641e-01f, -1.34166107e-01f, -1.81107447e-01f, -1.71496585e-01f, -1.95935234e-01f, -1.55936062e-01f, -2.19351977e-01f, -4.75178659e-02f,
  4.69067663e-01f, -2.44607985e-01f, -4.02662158e-02f, -1.52233377e-01f, -9.65172276e-02f, 2.06808209e-01f, 2.70868391e-01f, 1.18225522e-01f, -1.07422844e-01f, -2.96354294e-02f,
  -1.15950502e-01f, -1.60925731e-01f, -7.62362257e-02f, -6.61487728e-02f, 1.20896205e-01f, 6.14654347e-02f, -1.79086536e-01f, 9.75559279e-02f, 1.50447547e-01f, 1.43828467e-01f,
  -1.86426729e-01f, -6.90292791e-02f, 7.10156858e-02f, -9.98835359e-03f, -2.28290901e-01f, -1.04755037e-01f, -7.44206607e-02f, -1.55887455e-01f, 2.81867478e-02f, -2.37532571e-01f,
  -7.62179792e-02f, -7.56538659e-02f, 4.21161540e-02f, -2.12767422e-01f, -1.52429610e-01f, -7.58882090e-02f, -3.05367429e-02f, -1.42604411e-01f, -2.59402785e-02f, -1.54585615e-01f,
  -1.51191622e-01f, -1.33642003e-01f, -1.71644285e-01f, -1.58281505e-01f, -8.20361823e-02f, -8.40604603e-02f, -1.25391439e-01f, -1.46244094e-01f, -1.61222488e-01f, -9.21235755e-02f,
  -3.14503819e-01f, -8.55872780e-02f, -4.34557870e-02f, -1.01121888e-01f, -7.30850771e-02f, -8.34690332e-02f, -4.80263634e-03f, -1.29508466e-01f, -6.70743436e-02f, 2.64135692e-02f,
  1.98624432e-02f, 2.82586701e-02f, 9.70985517e-02f, 7.73994774e-02f, 8.73997733e-02f, 2.01903775e-01f, 7.84832388e-02f, 1.14943571e-01f, 4.63697277e-02f, 3.44157293e-02f,
  5.17723821e-02f, 1.92815717e-02f, 9.47919115e-03f, 7.27169737e-02f, 6.46876842e-02f, 8.01942125e-02f, 5.55108413e-02f, -3.20586301e-02f, 6.42844811e-02f, 7.74753615e-02f,
  7.98696950e-02f, 3.51561904e-02f, -1.35595156e-02f, -1.26492074e-02f, 7.77377794e-03f, 5.90476878e-02f, 8.45894068e-02f, 5.15049137e-02f, 1.16006970e-01f, 7.87560269e-02f,
  -1.99546255e-02f, 8.84891022e-03f, -3.48689705e-02f, -8.50949660e-02f, -7.04405531e-02f, -1.27155632e-01f, -1.18200451e-01f, -1.03494518e-01f, -1.42918214e-01f, -2.53625168e-03f,
  -1.16067911e-02f, 9.91205499e-03f, -7.64433593e-02f, -4.17735912e-02f, 1.93662699e-02f, -2.10510232e-02f, -3.19620408e-02f, -7.47105330e-02f, -6.92092404e-02f, -3.59886885e-02f,
  -5.51147088e-02f, 4.30700332e-02f, 1.98732212e-01f, 7.04882890e-02f, -1.18251875e-01f, 1.23481818e-01f, 1.06642209e-01f, 6.07968755e-02f, 1.87932551e-01f, 2.13634029e-01f,
  2.24669918e-01f, 5.80381989e-01f, -1.35095090e-01f, -1.50527209e-01f, -2.94241548e-01f, -2.96311617e-01f, -1.77431464e-01f, -2.81568523e-02f, -5.80400899e-02f, 1.68101937e-02f,
  2.77189821e-01f, 1.92464978e-01f, 1.54861793e-01f, 1.19993590e-01f, -7.51023227e-03f, -3.55552703e-01f, -2.87866831e-01f, -2.83237845e-01f, -2.52468348e-01f, -5.63463382e-02f,
  -5.28180376e-02f, 1.19878389e-01f, 1.44526318e-01f, 3.32772583e-02f, 9.67968628e-02f, -1.41119272e-01f, -1.25547096e-01f, 1.46166161e-01f, 3.92730199e-02f, 3.35543565e-02f,
  5.16251922e-02f, 3.70889962e-01f, -9.43792984e-02f, 1.04216307e-01f, 8.92675817e-02f, 6.98365346e-02f, 5.89224696e-02f, 3.93614881e-02f, 3.57045941e-02f, -2.46216194e-03f,
  1.23355761e-01f, 1.89984739e-02f, 4.50521745e-02f, 1.44167453e-01f, 4.48552519e-03f, 1.42293021e-01f, 1.36172816e-01f, 2.14169189e-01f, 8.71601701e-02f, 1.48278624e-01f,
  1.68482095e-01f, 5.09770736e-02f, 2.19774265e-02f, -4.75275051e-03f, -2.07129754e-02f, -5.65865077e-02f, 6.80964068e-02f, 8.43078345e-02f, 8.66607055e-02f, 7.47567490e-02f,
  8.32709298e-02f, -4.92785312e-02f, -7.80022591e-02f, -5.96498838e-04f, -3.69857177e-02f, -3.61245051e-02f, -4.62167663e-03f, -6.19345717e-02f, -5.72568178e-02f, -1.11343013e-02f,
  -2.58869715e-02f, -5.61218187e-02f, -8.09141621e-02f, 1.86933577e-02f, -4.23262939e-02f, -3.66190337e-02f, -6.01039222e-03f, -1.66276935e-02f, -3.49075720e-03f, -6.74044788e-02f,
  -1.23180207e-02f, -1.22879170e-01f, 8.74056853e-03f, 8.91129579e-03f, -4.96118218e-02f, -7.73306517e-03f, -4.68077771e-02f, 3.28851081e-02f, -6.80411905e-02f, -5.41924685e-02f,
  -2.84936465e-02f, -3.07590533e-02f, 3.85483578e-02f, 1.35958061e-01f, -4.19672206e-02f, 2.34761070e-02f, 4.83592153e-02f, 2.69738659e-02f, 8.66921693e-02f, 5.31462058e-02f,
  2.06267852e-02f, 2.22112779e-02f, 2.64271125e-02f, 4.01638821e-02f, -4.99442741e-02f, 1.64026907e-03f, 7.27115721e-02f, -2.60601845e-03f, 2.29512822e-04f, 2.10874900e-02f,
  -1.30370846e-02f, -1.62722185e-01f, -1.17172033e-01f, -1.13550983e-01f, -2.95743812e-02f, -1.32858396e-01f, -9.49889272e-02f, -1.00753382e-02f, -2.25241154e-01f, -1.02791220e-01f,
  -2.03726649e-01f, -4.16458726e-01f, 1.92797512e-01f, 2.83340663e-02f, -6.37115687e-02f, -1.49014339e-01f, -3.56163979e-01f, -1.40868366e-01f, -1.90080367e-02f, -1.42990544e-01f,
  -2.85915405e-01f, -2.02827409e-01f, -2.26163492e-01f, -8.66360590e-02f, -1.86162412e-01f, -1.53317317e-01f, -1.07424267e-01f, 1.51566833e-01f, 2.53991425e-01f, 1.16906308e-01f,
  -5.12320399e-02f, 2.09201589e-01f, 3.29117626e-01f, 1.48483574e-01f, 6.17626682e-02f, -1.18020009e-02f, 1.36611685e-01f, 4.04435992e-02f, -5.98841794e-02f, 7.28594046e-03f,
  5.70597360e-03f, -8.98730084e-02f, 8.35162848e-02f, -1.20881110e-01f, 8.19496214e-02f, -3.96048427e-02f, -1.14279494e-01f, 1.16856433e-01f, -1.18559204e-01f, -1.04639761e-01f,
  -8.13339502e-02f, -3.05287037e-02f, -5.15828393e-02f, -9.60269272e-02f, -1.16515169e-02f, -1.33123323e-01f, 1.05226068e-02f, -6.13231491e-03f, -4.01887186e-02f, -1.28781617e-01f,
  -1.64596647e-01f, -8.25711638e-02f, -1.70271769e-01f, -1.28935814e-01f, -1.15216129e-01f, -8.18898231e-02f, -8.16110373e-02f, -4.73179966e-02f, 2.74923332e-02f, -2.53037829e-02f,
  -4.00501303e-02f, 1.72301829e-02f, 7.56842718e-02f, 4.48135138e-02f, 3.22893448e-03f, -9.31516103e-03f, 6.10035397e-02f, 6.55471289e-04f, 6.38157576e-02f, 6.65982440e-02f,
  3.81490551e-02f, 3.02913245e-02f, 1.40373856e-01f, -8.54336023e-02f, 1.80311315e-02f, 1.03735857e-01f, 3.56454179e-02f, -1.38946595e-02f, -1.98686291e-02f, 1.11101724e-01f,
  8.99021700e-02f, 1.74164157e-02f, 1.19345017e-01f, 1.32054716e-01f, 1.85472574e-02f, 9.38187726e-03f, 5.85096925e-02f, -2.64541283e-02f, 3.90810147e-02f, -2.41272617e-02f,
  1.16404027e-01f, -2.01105103e-01f, -1.94153145e-01f, -1.85800157e-02f, -2.14259904e-02f, -8.86054114e-02f, -4.51205932e-02f, -9.77288038e-02f, -1.19450159e-01f, -1.19548328e-01f,
  -6.54303357e-02f, -1.52249768e-01f, -1.83580950e-01f, 2.01435597e-03f, -1.16915837e-01f, -1.05610073e-01f, -9.06703249e-02f, -9.15438235e-02f, -3.35683301e-02f, -5.77175803e-02f,
  -9.07011405e-02f, -1.98727593e-01f, -1.90694496e-01f, -1.99445754e-01f, -1.37058154e-01f, -3.15351546e-01f, -1.64284825e-01f, -9.21382681e-02f, -1.85425460e-01f, -1.35257274e-01f,
  4.49253052e-01f, -1.90464512e-01f, 2.26405159e-01f, 9.69443247e-02f, -4.04246897e-02f, 1.11686461e-01f, 2.35459264e-02f, 1.11383751e-01f, -2.72887237e-02f, -7.12378323e-02f,
  -2.54767239e-01f, -1.51996583e-01f, 1.05689339e-01f, 3.72607447e-02f, 3.44012260e-01f, 3.27688009e-01f, 4.30956006e-01f, 5.95403016e-01f, 3.22466165e-01f, 5.91506921e-02f,
  -9.66754556e-02f, -3.25783044e-02f, 8.88297781e-02f, 1.27606064e-01f, -8.46902952e-02f, -1.38995484e-01f, -1.59415558e-01f, -1.83442645e-02f, -9.21007097e-02f, 4.56350707e-02f,
  9.06538814e-02f, 7.08961710e-02f, 4.43791375e-02f, -7.39396438e-02f, -9.66270044e-02f, 4.27771965e-03f, -4.53294925e-02f, 1.23627119e-01f, -7.44206458e-03f, -2.23923866e-02f,
  -5.49027100e-02f, 3.63619477e-02f, 9.52775255e-02f, -1.33497417e-01f, -1.79404696e-03f, 1.44210749e-03f, -3.01499236e-02f, 8.48573223e-02f, -1.15039209e-02f, 3.93619165e-02f,
  -9.12759006e-02f, -5.40266000e-03f, 2.17488572e-01f, -7.66629279e-02f, -7.54045248e-02f, 7.33326888e-04f, -4.37707864e-02f, -7.09085241e-02f, 5.09497412e-02f, -5.78645691e-02f,
  1.61113918e-01f, 6.89162761e-02f, -4.09448780e-02f, 1.98813677e-02f, -1.16846368e-01f, -5.39466776e-02f, 6.28327206e-02f, -2.17605587e-02f, -2.14121994e-02f, -2.59327721e-02f,
  6.38312055e-03f, -1.93244740e-02f, 5.79074631e-03f, 9.64455903e-02f, 7.78708654e-03f, 3.10762376e-02f, 5.57378978e-02f, -9.73945856e-02f, 1.39990617e-02f, -4.00675572e-02f,
  -3.47216278e-02f, -2.34566871e-02f, -5.35583198e-02f, -7.89001808e-02f, 2.35826205e-02f, 1.58143658e-02f, 5.26822843e-02f, -6.43002167e-02f, -7.25476295e-02f, -4.46293317e-03f,
  -1.61428288e-01f, -7.08522648e-02f, 1.24283239e-01f, 1.20993569e-01f, -6.86805835e-03f, -1.13847651e-01f, -7.50757903e-02f, -6.34556487e-02f, -5.64406514e-02f, -1.29686818e-01f,
  -8.80014375e-02f, -3.13363746e-02f, -2.66644340e-02f, -4.69583087e-02f, -2.64528915e-02f, -1.79579947e-03f, -8.15683231e-03f, 4.71881628e-02f, 6.30071238e-02f, -1.31240830e-01f,
  -7.84551576e-02f, 4.77013290e-02f, 1.98104918e-01f, 1.23323433e-01f, 9.39357430e-02f, 1.46956265e-01f, 4.87845065e-03f, 5.40430695e-02f, 1.36014670e-01f, 1.54563785e-01f,
  -9.41180512e-02f, -1.70206949e-01f, -3.71224880e-01f, -2.63666540e-01f, -1.51580974e-01f, -7.40792602e-02f, -1.22032039e-01f, 3.66431102e-02f, -4.39361483e-02f, -1.77988410e-01f,
  -1.77715980e-02f, 2.32820585e-02f, -1.13001950e-01f, -1.52269140e-01f, -5.08874319e-02f, -2.43514657e-01f, -3.20797533e-01f, -2.75613129e-01f, -1.55486047e-01f, -2.60439783e-01f,
  -2.04448849e-01f, -2.08838895e-01f, -1.69258580e-01f, -2.09150404e-01f, -2.50135630e-01f, -1.40211478e-01f, -3.10635298e-01f, -1.52242586e-01f, -6.46874085e-02f, -4.12817419e-01f,
  -4.04926658e-01f, -8.01426321e-02f, -8.51784199e-02f, -1.15089929e-02f, -1.51399851e-01f, -1.54325757e-02f, -1.59964398e-01f, -5.07014245e-02f, -1.55657425e-03f, -1.18672609e-01f,
  -1.02809735e-01f, -1.21199086e-01f, -1.04127787e-02f, -1.73302978e-01f, -1.55748069e-01f, -1.12250507e-01f, -6.65642470e-02f, -1.83326587e-01f, -1.42130300e-01f, -9.65346023e-02f,
  -1.61075696e-01f, -1.60003483e-01f, 5.42769730e-02f, 6.04504123e-02f, -1.08030997e-01f, 4.06020172e-02f, -5.34172468e-02f, -1.52106389e-01f, 1.95434713e-03f, -1.95233896e-01f,
  4.44949418e-02f, 4.65722419e-02f, 5.72916977e-02f, 9.81967449e-02f, 1.38300270e-01f, 1.28509089e-01f, -3.66042089e-03f, 9.74566564e-02f, -1.86722018e-02f, 1.63820729e-01f,
  5.08499742e-02f, 4.57427837e-02f, 4.53085378e-02f, 7.41833309e-03f, 1.03164604e-03f, 2.90726703e-02f, 7.06053749e-02f, 7.33183399e-02f, 4.55837511e-02f, 7.50212967e-02f,
  8.13629180e-02f, 5.20079583e-02f, 5.78531846e-02f, 7.76331276e-02f, 1.01346495e-02f, -6.71128882e-03f, -4.57048038e-04f, 1.74960718e-01f, 4.32427488e-02f, 8.73039812e-02f,
  1.25069739e-02f, 9.60412845e-02f, -1.23856217e-01f, -6.39889166e-02f, -8.75029117e-02f, -1.06445737e-01f, -1.01152651e-01f, -6.27736673e-02f, -4.87765968e-02f, -1.05430447e-01f,
  -9.51870531e-02f, -8.64154398e-02f, -1.45083830e-01f, -1.40422717e-01f, -1.68817043e-01f, -1.04222827e-01f, -5.70741966e-02f, -1.08594432e-01f, -2.56060082e-02f, -1.70578510e-01f,
  1.29365064e-02f, 3.30234766e-02f, 3.04692599e-04f, -1.54042579e-02f, -4.06719632e-02f, 7.09270537e-02f, -1.07783834e-02f, -4.32916777e-03f, 9.45703536e-02f, -7.39417970e-02f,
  2.16420785e-01f, -2.10011657e-02f, -5.67039028e-02f, -3.64292085e-01f, -2.89378434e-01f, 8.92112032e-02f, 2.97974706e-01f, 4.60667051e-02f, -2.10090384e-01f, -8.21189284e-02f,
  -2.12712511e-01f, -3.51365328e-01f, -2.40073368e-01f, -2.74264902e-01f, -2.68270858e-02f, -8.85214582e-02f, -1.88815251e-01f, -1.01337530e-01f, 9.44209844e-03f, -1.00648247e-01f,
  -2.33854622e-01f, -2.68238068e-01f, -1.35265693e-01f, -2.89673567e-01f, -3.92879725e-01f, -3.16044122e-01f, -4.11675900e-01f, -3.59046549e-01f, -2.41993636e-01f, -5.85337758e-01f,
  -1.30574450e-01f, -1.70143649e-01f, -1.86584398e-01f, -1.90380096e-01f, -3.00352097e-01f, -1.29645556e-01f, -9.25052986e-02f, -1.97081879e-01f, -1.73008904e-01f, -1.80286199e-01f,
  -2.97156364e-01f, -1.56007946e-01f, -2.73966342e-01f, -1.82743266e-01f, -2.84228146e-01f, -1.04587704e-01f, -2.54233032e-01f, -1.97678983e-01f, -2.25685269e-01f, -1.44355342e-01f,
  -2.69485354e-01f, -2.94868171e-01f, -6.45155609e-02f, -1.80778891e-01f, -2.06139520e-01f, -2.70389497e-01f, -2.04793185e-01f, -3.07736248e-01f, -2.46183425e-01f, -1.68394208e-01f,
  2.97553748e-01f, 2.92807400e-01f, 1.70573786e-01f, 2.12498352e-01f, 1.80207863e-01f, 2.09895775e-01f, 2.23236784e-01f, 1.59929320e-01f, 2.76189148e-01f, 2.35554069e-01f,
  1.80543065e-01f, 1.67763606e-01f, 2.20114812e-01f, 2.56203264e-01f, 1.88329369e-01f, 2.28611454e-01f, 2.12311849e-01f, 1.97898641e-01f, 1.45574093e-01f, 2.08384022e-01f,
  1.28156543e-01f, 2.33198583e-01f, 1.36286050e-01f, 9.29330662e-02f, 1.13781273e-01f, 1.99400663e-01f, 1.94963664e-01f, 1.71633407e-01f, 2.05407023e-01f, 2.23105013e-01f,
  -4.26322185e-02f, -2.12453976e-01f, -2.50613391e-01f, -1.73494890e-01f, -2.34986380e-01f, -1.83483288e-01f, -3.09626102e-01f, -2.56061584e-01f, -2.14917928e-01f, -1.79089248e-01f,
  -1.88362256e-01f, -1.17747806e-01f, -2.02943847e-01f, -2.15033457e-01f, -1.67828962e-01f, -2.08389238e-01f, -2.30565161e-01f, -2.11465403e-01f, -1.87728971e-01f, -2.09069163e-01f,
  -1.59977689e-01f, 1.43483086e-02f, 1.11314617e-02f, -1.38439134e-01f, -2.81313509e-01f, -8.09713900e-02f, -1.42091244e-01f, -1.43876582e-01f, -3.56105193e-02f, 1.49251238e-01f,
  -2.01963976e-01f, 3.86749536e-01f, -3.19741249e-01f, -1.78402707e-01f, -3.62072915e-01f, -1.64067596e-01f, 1.64783761e-01f, 2.74533313e-02f, -8.23983997e-02f, -3.32635380e-02f,
  1.09107122e-01f, 2.90032983e-01f, 3.74282926e-01f, 3.67423773e-01f, 4.11200285e-01f, 7.79862553e-02f, -3.20691057e-02f, 1.04585014e-01f, 1.31502062e-01f, 1.07324369e-01f,
  3.71111631e-02f, -8.71527940e-02f, -2.84018517e-02f, 1.36568338e-01f, 2.95363739e-02f, 1.18136741e-01f, -1.10445060e-02f, -1.23950548e-01f, 1.21973068e-01f, -2.07475230e-01f,
  -1.14813233e-02f, -1.35568440e-01f, 1.36463225e-01f, 2.31747314e-01f, 6.53754026e-02f, 5.22674993e-02f, 9.13874134e-02f, -1.58739835e-02f, 1.25168413e-01f, -3.05585526e-02f,
  -1.00474702e-02f, -6.57717586e-02f, 1.44723803e-02f, 6.69255406e-02f, -4.49032225e-02f, -2.72174571e-02f, 7.11390153e-02f, 8.53058919e-02f, 1.76407516e-01f, 1.13248117e-01f,
  5.46144284e-02f, -1.19930558e-01f, -2.13919301e-02f, 1.10703588e-01f, 5.38381562e-02f, 3.81180905e-02f, 1.06440812e-01f, 5.97481988e-02f, 2.61831395e-02f, 6.00009225e-02f,
  4.17343490e-02f, -9.67746507e-03f, -2.54200902e-02f, -5.11085130e-02f, -3.86236422e-02f, -9.43714231e-02f, -1.74312159e-01f, -5.18071800e-02f, -2.30737478e-05f, -1.55069053e-01f,
  -6.16900399e-02f, -4.84622493e-02f, -6.29910603e-02f, -1.65896341e-01f, -6.99626952e-02f, -1.97275579e-01f, -9.68144834e-02f, -4.00587767e-02f, -4.72544357e-02f, -1.70527071e-01f,
  -3.13732326e-02f, -8.82194936e-02f, -1.63878843e-01f, -3.80710252e-02f, -9.78596583e-02f, -2.22019926e-02f, -1.02435715e-01f, -1.00638233e-01f, -9.34387222e-02f, -2.13372856e-01f,
  2.24530995e-01f, 1.78032741e-01f, 5.64478710e-02f, 8.77713487e-02f, 1.86231155e-02f, 7.66964629e-02f, 2.97415927e-02f, 2.93359701e-02f, -3.13446373e-02f, 6.42032474e-02f,
  5.78304753e-02f, 3.71489674e-02f, -2.48762239e-02f, 5.49834594e-02f, 3.16733718e-02f, 4.63837199e-02f, 2.02442110e-02f, 5.98342977e-02f, 4.85028028e-02f, -4.94546518e-02f,
  9.60415974e-02f, 6.93795457e-02f, 1.56500235e-01f, 1.21796012e-01f, 7.76240602e-02f, 1.08942166e-01f, 4.29437608e-02f, 3.56262922e-02f, 1.54049754e-01f, 2.50342876e-01f,
  5.17474711e-01f, -9.19304788e-02f, 3.81409913e-01f, -8.91476572e-02f, -2.84976482e-01f, -2.27260619e-01f, -1.32911026e-01f, -1.56750619e-01f, -1.57049417e-01f, -1.36271641e-01f,
  -2.08260655e-01f, -1.61626324e-01f, -9.14387852e-02f, -1.43212602e-01f, 1.47763258e-02f, -8.22278038e-02f, -1.02843158e-01f, 7.37725869e-02f, 7.79651552e-02f, -2.00443313e-01f,
  -3.92968923e-01f, -1.50972918e-01f, 4.79147211e-02f, -1.63442895e-01f, -1.03570029e-01f, -6.29541427e-02f, -9.24801640e-03f, 3.12009342e-02f, -4.74964716e-02f, -6.43886346e-03f,
  2.90953249e-01f, 1.06483057e-01f, -1.34416193e-01f, -2.23347649e-01f, -1.07406005e-01f, -1.15324996e-01f, -6.68769926e-02f, -5.52002229e-02f, -1.12802915e-01f, -1.04868062e-01f,
  -1.11405015e-01f, -1.36780053e-01f, -1.50678888e-01f, -8.73757303e-02f, -9.95898768e-02f, -1.21646509e-01f, -1.48351982e-01f, 2.69951262e-02f, -8.09514746e-02f, -8.74576047e-02f,
  -3.36252809e-01f, -1.15831554e-01f, -2.71764155e-02f, -3.84422168e-02f, -2.25711986e-03f, 1.49663975e-02f, -9.13221911e-02f, 3.95377278e-02f, 1.25621468e-01f, 5.56356460e-02f,
  -3.23570184e-02f, 1.26154289e-01f, 1.08832486e-01f, 6.50746152e-02f, 3.77941392e-02f, 8.13824907e-02f, 1.04938798e-01f, 3.74504663e-02f, 1.37160584e-01f, 1.29578829e-01f,
  1.01276658e-01f, 8.18292201e-02f, 9.76460651e-02f, 7.49898180e-02f, 1.14322178e-01f, 1.01851292e-01f, 1.39319628e-01f, 7.87432343e-02f, 9.04706493e-02f, 1.64763987e-01f,
  1.24156833e-01f, 1.53050199e-01f, 1.80433784e-02f, 4.40334231e-02f, 1.01685040e-01f, 1.10813692e-01f, 1.76583424e-01f, 6.94891140e-02f, 1.45056710e-01f, 1.08203143e-01f,
  5.26452437e-02f, -1.09613560e-01f, -6.04347624e-02f, -1.06027871e-01f, -1.40904859e-01f, -1.89190045e-01f, -1.40255362e-01f, -1.33900762e-01f, -3.24727632e-02f, -7.99563453e-02f,
  -1.05258800e-01f, -8.50466415e-02f, -1.36331543e-01f, -1.78009823e-01f, -1.65263459e-01f, -1.64700642e-01f, -2.67765462e-01f, -1.13070786e-01f, -1.29467264e-01f, -1.32599831e-01f,
  -2.60651886e-01f, -6.74377531e-02f, 1.10919084e-02f, -4.20541354e-02f, -1.07429184e-01f, -9.11836699e-02f, 3.36167887e-02f, -1.13650471e-01f, 2.27984264e-02f, -9.89764184e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.61376190e-01f, 4.87035334e-01f, 4.69943672e-01f, 1.63265258e-01f, -4.24862832e-01f, -1.77407160e-01f, 1.31437182e-01f, 1.50463030e-01f, 4.98707294e-02f, 7.29927421e-02f,
  2.16438420e-04f, -1.21848568e-01f, -1.21583631e-02f, 3.92001197e-02f, 3.05071145e-01f, 1.74542516e-01f, 1.15260534e-01f, 4.26854074e-01f, 2.06976861e-01f, 1.50672734e-01f,
  -2.76722703e-02f, 2.29729302e-02f, 2.89700538e-01f, 1.88926667e-01f, 1.23355068e-01f, -1.08884685e-01f, 8.97334423e-03f, 1.28031358e-01f, 1.58453897e-01f, 4.33376163e-01f,
  3.52307975e-01f, 3.89598697e-01f, -2.66878963e-01f, -2.56938666e-01f, -1.46427915e-01f, 6.28635064e-02f, 1.44429933e-02f, -3.18449736e-02f, -1.02085605e-01f, 9.62351114e-02f,
  -1.72678977e-01f, -1.07830659e-01f, -1.34842051e-02f, -5.58458269e-02f, -1.67366192e-02f, -1.29763365e-01f, 5.08193634e-02f, 2.39862680e-01f, 1.09076008e-01f, 1.03954843e-03f,
  -1.32783368e-01f, -6.89705610e-02f, -1.13767013e-01f, -2.15499010e-02f, 1.61791533e-01f, -2.79469583e-02f, 5.12043051e-02f, 1.63476482e-01f, 7.27994293e-02f, 2.19656765e-01f,
  3.98314893e-02f, 8.15820843e-02f, 1.46532446e-01f, 2.90048420e-01f, 2.19325066e-01f, 1.49295986e-01f, 4.08523530e-02f, -1.09055206e-01f, 1.36557326e-01f, 1.09571651e-01f,
  -9.47444886e-02f, 7.31676519e-02f, 1.02635898e-01f, 5.57945222e-02f, -1.45300046e-01f, -1.54247627e-01f, -2.90351436e-02f, -5.06061055e-02f, 1.33327991e-02f, -7.18949512e-02f,
  3.01692672e-02f, -2.61270683e-02f, 5.14346510e-02f, 1.49700984e-01f, -5.18735126e-02f, 1.36349276e-01f, -3.17597110e-03f, -2.20089331e-01f, -9.13327560e-02f, -5.59803173e-02f,
  -6.52447581e-01f, -2.08717927e-01f, 1.42521963e-01f, -1.30719081e-01f, 8.76322668e-03f, -1.13423638e-01f, 3.74910571e-02f, -1.07024975e-01f, -1.61580533e-01f, 7.29489028e-02f,
  -1.12977087e-01f, 1.50489926e-01f, 8.56084079e-02f, 1.05345152e-01f, -1.35027036e-01f, -1.95876703e-01f, -4.61454690e-02f, -3.17036845e-02f, -7.43688866e-02f, -1.68123573e-01f,
  -2.95422133e-02f, -2.68204421e-01f, -2.95301765e-01f, -9.61707011e-02f, 4.81606973e-03f, -2.45740637e-01f, -1.53628051e-01f, -1.91698596e-01f, -1.04616672e-01f, -1.15916319e-01f,
  8.75870287e-01f, 5.73564112e-01f, 4.12268221e-01f, 2.01750979e-01f, -1.51300505e-01f, -3.28376517e-02f, 8.16356670e-03f, -2.34333072e-02f, -1.54548705e-01f, 2.12081403e-01f,
  9.79348272e-02f, -1.16226614e-01f, -1.56062469e-01f, -1.99234724e-01f, -1.18268602e-01f, -4.52251881e-02f, -1.15576945e-01f, 1.19596884e-01f, -1.69532781e-03f, -4.54037264e-02f,
  -1.89831674e-01f, 3.38983834e-02f, 1.30000403e-02f, -1.03260905e-01f, 1.35998428e-01f, -3.10141474e-01f, -1.85443297e-01f, 3.45328301e-02f, 4.89748828e-02f, 3.18779916e-01f,
  6.24002039e-01f, 3.41560215e-01f, -2.68813312e-01f, 5.42156100e-02f, 7.55780488e-02f, 5.48698045e-02f, -5.22203818e-02f, 7.44127342e-03f, -7.15318024e-02f, -1.79442540e-02f,
  1.88751817e-02f, 1.98644791e-02f, 4.35234532e-02f, 1.01124972e-01f, 8.62783492e-02f, 1.17783784e-03f, 1.93089157e-01f, 7.56326690e-02f, -8.54937509e-02f, 1.13822028e-01f,
  1.22764491e-01f, 2.81967521e-01f, 2.19458118e-01f, -6.56051114e-02f, 8.83512720e-02f, 5.49452901e-02f, 1.14111759e-01f, 1.30172625e-01f, 6.42710552e-02f, 2.15995491e-01f,
  1.54393241e-02f, 9.52951014e-02f, 6.72386289e-02f, -6.77592382e-02f, 2.58514807e-02f, 8.55094753e-03f, 6.37746453e-02f, -7.98095542e-04f, -4.04687412e-02f, -2.62944046e-02f,
  -5.71597591e-02f, -3.72400954e-02f, 7.89956450e-02f, -1.09262876e-01f, 3.90934162e-02f, 7.28116110e-02f, 2.00015083e-01f, 1.68474823e-01f, -4.71294485e-02f, 7.38370419e-03f,
  8.49769861e-02f, -2.32321694e-02f, 8.47901974e-04f, 1.01692840e-01f, 1.11617722e-01f, 1.27684429e-01f, 6.37473613e-02f, -9.03303735e-03f, -5.67669570e-02f, -8.66441131e-02f,
  -9.96718258e-02f, -2.97893226e-01f, -5.70889004e-03f, -7.86422268e-02f, 1.03536479e-01f, 7.61345476e-02f, 3.60193215e-02f, -5.05057871e-02f, -9.58147943e-02f, 3.09413187e-02f,
  1.39092848e-01f, 6.16472587e-02f, 1.05111659e-01f, -4.34038974e-02f, -1.47218630e-01f, -1.48969311e-02f, 2.29534775e-01f, 1.05646342e-01f, -2.28490401e-02f, -6.68393448e-03f,
  1.12127125e-01f, -3.24792005e-02f, -7.55641088e-02f, -1.98224336e-01f, -5.78676090e-02f, -1.53203562e-01f, -1.13108933e-01f, 2.39457171e-02f, -7.01290965e-02f, -1.16423935e-01f,
  7.54938781e-01f, 2.30951801e-01f, 3.38551521e-01f, 2.58687466e-01f, 3.62193018e-01f, 5.54146111e-01f, 6.14312232e-01f, 2.64811993e-01f, 6.87330076e-03f, 2.25211516e-01f,
  1.99308604e-01f, -9.50893238e-02f, -1.47682279e-01f, -1.69483513e-01f, -1.90146174e-02f, -6.38550222e-02f, -8.55122805e-02f, -1.43705204e-01f, 2.11105472e-03f, -8.90209973e-02f,
  -1.91280991e-01f, 1.70372948e-02f, 8.35842639e-02f, -9.43182781e-02f, -1.19115673e-01f, -2.14195922e-01f, -1.22280225e-01f, -1.76385865e-02f, -7.73030659e-03f, -3.92180383e-01f,
  -3.02209020e-01f, 3.75095099e-01f, -3.09956163e-01f, -3.60187501e-01f, -8.03353786e-02f, -9.75183547e-02f, -9.11069438e-02f, -3.00873145e-02f, -1.15841538e-01f, -1.33986697e-01f,
  -9.48145539e-02f, -2.37239730e-02f, 3.31729911e-02f, 1.04184829e-01f, 4.43781614e-02f, 6.65324787e-03f, 4.99334373e-02f, 2.96574179e-02f, -1.07235186e-01f, -1.30245328e-01f,
  -1.82375051e-02f, 1.79437056e-01f, 1.76722884e-01f, 4.22293618e-02f, 1.06126390e-01f, 9.98058170e-03f, 1.34017080e-01f, 8.88273790e-02f, 3.78483906e-02f, 6.34402186e-02f,
  5.60780354e-02f, 6.82027414e-02f, 6.11048900e-02f, 1.26406327e-02f, 4.34831791e-02f, -6.99905679e-02f, -1.10563301e-01f, -6.99127093e-02f, 1.13311522e-01f, 2.27786794e-01f,
  -6.95074201e-02f, -6.80751982e-04f, 8.42339620e-02f, 1.05949670e-01f, 1.01006284e-01f, 1.31271586e-01f, -7.06501678e-02f, -6.48287162e-02f, 1.00945784e-02f, -1.28124148e-01f,
  1.25312522e-01f, 1.38755934e-02f, 6.66320249e-02f, 3.67804579e-02f, 2.28112079e-02f, 2.14062799e-02f, -3.86042595e-02f, -4.48740311e-02f, 1.61505774e-01f, -4.70026396e-03f,
  -4.25241470e-01f, 3.00644875e-01f, -1.89140454e-01f, -1.51696384e-01f, -2.03588847e-02f, -3.06895226e-02f, 8.82673636e-02f, -1.05137721e-01f, -1.39338791e-01f, -2.11882725e-01f,
  -1.33186067e-03f, -4.79672700e-02f, 1.83093786e-01f, 4.98363934e-02f, 5.41037135e-02f, 1.00654000e-02f, -3.50414105e-02f, -7.65632791e-03f, -8.40387270e-02f, -1.15827769e-01f,
  -1.16993107e-01f, 2.36391462e-03f, 1.31124826e-02f, 4.87102568e-02f, -7.01097697e-02f, -1.18175037e-01f, -1.95560250e-02f, 3.34307626e-02f, 3.96646447e-02f, 1.67809594e-02f,
  -1.12712944e+00f, 2.54154325e-01f, 2.56810844e-01f, -6.98881984e-01f, 2.47625872e-01f, 2.95405537e-01f, 6.99723780e-01f, 5.11842966e-02f, -2.03379571e-01f, 2.14185461e-01f,
  -4.47325148e-02f, -4.14576948e-01f, -1.87233686e-01f, 5.72995394e-02f, 1.85288489e-01f, 5.79535484e-01f, 4.27872956e-01f, -4.63449098e-02f, -3.86789411e-01f, -2.76107371e-01f,
  1.98832229e-01f, -3.00712824e-01f, -5.73758721e-01f, -1.06843971e-01f, 4.33372741e-04f, -9.50820073e-02f, 1.52867645e-01f, -2.06336483e-01f, 3.31391215e-01f, 6.38216063e-02f,
  1.94278300e-01f, -3.71747166e-01f, 8.91129971e-02f, -2.31108636e-01f, -5.46005443e-02f, -7.68589452e-02f, -7.58085102e-02f, -7.48246014e-02f, -1.05828799e-01f, -8.20437353e-03f,
  -9.97135863e-02f, -1.28248751e-01f, -7.33583421e-02f, -9.68582556e-03f, -7.59885907e-02f, -5.10381386e-02f, -4.97939922e-02f, -1.53308138e-01f, 4.36859094e-02f, 1.56081244e-01f,
  2.35877961e-01f, -6.91618472e-02f, -1.26372933e-01f, 1.99883267e-01f, 1.05958112e-01f, 1.28906779e-02f, -8.19139369e-03f, -1.24761306e-01f, 6.16925992e-02f, -2.67286628e-01f,
  5.25886863e-02f, 3.49654295e-02f, 1.01434194e-01f, -4.31322828e-02f, 1.26361474e-02f, 1.29679833e-02f, 1.33028612e-01f, 9.95376799e-03f, 1.60559520e-01f, -9.49708819e-02f,
  1.22180618e-02f, 7.43616223e-02f, 6.60291389e-02f, -5.76147288e-02f, 1.18765589e-02f, 3.32843978e-04f, 4.48811911e-02f, 2.37636082e-02f, 1.26245422e-02f, -6.73516914e-02f,
  -4.64901775e-02f, 1.68001112e-02f, -1.83449686e-02f, 5.40367365e-02f, 1.31845579e-01f, -3.25637893e-03f, 4.34136726e-02f, -2.63054501e-02f, -2.01303996e-02f, 5.01324832e-02f,
  -1.56366676e-01f, 8.69889036e-02f, -8.09949562e-02f, -1.21360654e-02f, -8.23669061e-02f, 6.80731907e-02f, -5.45160845e-02f, -7.44275525e-02f, 1.15101449e-02f, 1.04001872e-02f,
  5.27023859e-02f, -9.90592167e-02f, -2.07629595e-02f, 4.43073222e-03f, -1.37892947e-01f, -1.15254624e-02f, 7.86689296e-02f, -1.01726227e-01f, 3.42500284e-02f, 1.12947807e-01f,
  1.33884117e-01f, 2.50543989e-02f, -1.52784988e-01f, 6.03411347e-02f, 1.36924356e-01f, -1.09999336e-01f, 2.69868486e-02f, -4.25657630e-03f, 2.98257321e-02f, 8.33664089e-02f,
  1.52575478e-01f, -2.28384100e-02f, 2.39411280e-01f, 1.22056670e-01f, 5.08073010e-02f, -4.70499635e-01f, -1.12978077e+00f, -3.32438290e-01f, 2.48468980e-01f, 4.94751930e-02f,
  6.31819591e-02f, 1.21225536e-01f, 9.71634686e-02f, -6.75984994e-02f, -5.37149251e-01f, -1.95910305e-01f, -1.27284797e-02f, -9.12624449e-02f, -3.02687973e-01f, -4.33669031e-01f,
  -1.11735404e-01f, 4.25677113e-02f, 1.33114085e-01f, -9.56127942e-02f, 4.58377719e-01f, 1.16748273e-01f, 3.76145512e-01f, 4.40064847e-01f, 1.76837459e-01f, 6.32399678e-01f,
  3.72094482e-01f, 1.80675551e-01f, -2.73192495e-01f, -8.96359682e-02f, 2.36670867e-01f, -5.08701168e-02f, -1.74043328e-01f, 2.45168045e-01f, -3.02201174e-02f, 1.20446771e-01f,
  1.70578048e-01f, 2.89956350e-02f, 5.22506535e-02f, 6.88442290e-02f, -8.80912691e-02f, -3.71303439e-01f, 1.02611907e-01f, -2.92619877e-02f, 1.07162617e-01f, 2.70953551e-02f,
  -6.12757243e-02f, 4.38366197e-02f, -2.50556022e-01f, -2.41295815e-01f, -1.15439333e-01f, 7.02686682e-02f, 3.95183340e-02f, 1.19156480e-01f, -1.19686253e-01f, 4.40657139e-01f,
  -1.36029616e-01f, -1.81593578e-02f, 1.04127072e-01f, 1.15089960e-01f, -5.44860885e-02f, 8.17604139e-02f, -3.95609951e-03f, -9.99981612e-02f, 8.29398446e-03f, -2.49890015e-02f,
  -1.63738593e-01f, -1.83136240e-02f, 1.32745519e-01f, 7.59197623e-02f, -1.60581738e-01f, 4.01310399e-02f, 1.93144679e-02f, -1.22679614e-01f, -1.19625323e-01f, 7.92021975e-02f,
  -1.40898928e-01f, -5.12619726e-02f, 1.80441588e-01f, 2.89326888e-02f, 8.99981037e-02f, -1.45792952e-02f, 2.07645372e-01f, -5.17259873e-02f, 9.51995924e-02f, 1.71097875e-01f,
  -1.68823525e-01f, -2.49724075e-01f, -1.76706556e-02f, -1.48100629e-01f, 1.25419334e-01f, -5.84626151e-03f, 3.48900259e-02f, -7.32239289e-03f, 1.64530352e-02f, -1.81422874e-01f,
  -1.30229235e-01f, -1.62921309e-01f, 1.73962802e-01f, -1.64150879e-01f, -2.77988762e-01f, -1.36645392e-01f, -2.60037601e-01f, -1.37470499e-01f, -1.33043990e-01f, 1.26309648e-01f,
  -3.18093538e-01f, -5.50393462e-01f, -4.71208751e-01f, -4.89538133e-01f, 1.09480411e-01f, -3.80145907e-01f, -1.38134882e-01f, -1.45233184e-01f, -6.14549339e-01f, -5.84098697e-01f,
  -7.18115449e-01f, 4.31288809e-01f, -5.54355867e-02f, 1.42750308e-01f, 8.83450031e-01f, 3.52830976e-01f, -2.47079562e-02f, -2.46733248e-01f, 1.44679854e-02f, 1.34426236e-01f,
  4.50944602e-01f, 1.08342908e-01f, 1.05330057e-01f, -2.90337335e-02f, -5.91642499e-01f, 7.21594691e-02f, 2.02176645e-01f, -3.57505471e-01f, -6.64327264e-01f, -3.91157120e-01f,
  2.88873732e-01f, -2.74113178e-01f, -6.46372616e-01f, -2.27938995e-01f, 3.23036224e-01f, 1.02630541e-01f, 7.37713426e-02f, 1.88926846e-01f, 2.79430211e-01f, 5.50218344e-01f,
  -6.20339736e-02f, 6.21047243e-02f, -1.01126730e-01f, -1.14543932e-02f, 1.85970902e-01f, -1.55750722e-01f, -2.25491196e-01f, -1.88705102e-01f, -2.62977555e-03f, -2.07819298e-01f,
  2.45652229e-01f, -1.22777671e-01f, 1.95724964e-01f, -3.80045213e-02f, 4.05355766e-02f, -2.38577142e-01f, -1.39345333e-01f, -4.64950621e-01f, -5.37218869e-01f, -6.85009509e-02f,
  6.65087819e-01f, 4.00524139e-01f, -2.29741961e-01f, -1.33421287e-01f, -3.44374239e-01f, -1.48560733e-01f, -2.37768754e-01f, -2.39318043e-01f, -5.11432409e-01f, -4.77712333e-01f,
  -3.17060091e-02f, -3.58068272e-02f, 5.67102619e-02f, 1.49249271e-01f, 1.18109090e-02f, 4.45531309e-02f, 1.28216133e-01f, 3.85224223e-02f, 5.65381348e-02f, -9.66673419e-02f,
  2.75243428e-02f, 1.22773238e-01f, -1.66761890e-01f, -2.05322243e-02f, 6.95399716e-02f, -6.99964073e-03f, -5.89974634e-02f, -4.80778813e-02f, 5.32691181e-02f, -5.75372912e-02f,
  -2.92657651e-02f, -1.34262936e-02f, 4.93158996e-02f, -2.02822417e-01f, 2.27492496e-01f, -4.71445881e-02f, -4.25942754e-03f, -9.82272029e-02f, -2.68540215e-02f, 3.91349057e-03f,
  -4.29305881e-01f, 3.40135098e-02f, 2.82336362e-02f, -1.12943307e-01f, 1.33960031e-03f, -8.14951025e-03f, 2.70202547e-01f, -4.92027355e-03f, 1.26533583e-01f, -1.47170976e-01f,
  -1.11921355e-01f, -7.24158734e-02f, -1.00949900e-02f, 7.33189750e-03f, -6.58404753e-02f, 1.41246751e-01f, 1.41439170e-01f, 9.80541334e-02f, -9.83961225e-02f, 8.00131857e-02f,
  -4.24575321e-02f, -2.02190146e-01f, -2.99101382e-01f, -1.54566571e-01f, -8.76653008e-03f, -2.97408760e-01f, -2.50178546e-01f, -2.21504793e-01f, -5.31534672e-01f, -4.12856609e-01f,
  4.00243819e-01f, -5.33185489e-02f, -3.43177646e-01f, 7.24893272e-01f, -4.02281508e-02f, -1.48458943e-01f, 2.22486228e-01f, 1.26289204e-01f, 4.17186826e-01f, 2.90550947e-01f,
  -4.92458820e-01f, -7.71888733e-01f, -4.88744766e-01f, -3.90014410e-01f, -3.90219033e-01f, 5.36759853e-01f, 5.41221678e-01f, -2.52482682e-01f, -4.70941782e-01f, -7.33578354e-02f,
  2.12859139e-01f, 4.70653355e-01f, 1.68212190e-01f, -1.29684180e-01f, 2.60820776e-01f, -7.07109198e-02f, 3.30386311e-01f, -6.33826628e-02f, -3.23371321e-01f, 1.36287957e-02f,
  -3.50057095e-01f, -1.41695395e-01f, -1.78212717e-01f, -2.24105686e-01f, -7.14935660e-02f, 9.94905382e-02f, 2.84334049e-02f, -7.96483904e-02f, -1.11328967e-01f, 9.45210736e-03f,
  -1.86478287e-01f, -2.46346191e-01f, -3.26441586e-01f, 4.45573889e-02f, 4.74227965e-02f, 2.62933113e-02f, 8.20588246e-02f, -1.77466184e-01f, -9.14309267e-03f, -1.28265664e-01f,
  -1.22077495e-01f, -2.78403491e-01f, -4.81229752e-01f, -8.46945569e-02f, -1.01754516e-01f, -4.47438627e-01f, -2.65351683e-01f, -4.01399106e-01f, -4.24458563e-01f, 2.04875067e-01f,
  -2.10585594e-02f, 9.39612985e-02f, -1.09051904e-02f, 8.00649226e-02f, 1.89395621e-01f, 3.38266604e-02f, 1.15109384e-01f, 7.08342763e-03f, -6.22261956e-04f, 7.40043726e-03f,
  -1.23810358e-01f, 8.35154057e-02f, -3.03002242e-02f, 1.21110147e-02f, -1.62138361e-02f, -4.58231382e-02f, -1.49138262e-02f, 8.84021968e-02f, -5.20855933e-02f, 1.71120778e-01f,
  -7.84751475e-02f, -2.33729021e-03f, 1.55268431e-01f, -5.11817774e-03f, 8.32869112e-02f, -1.00458652e-01f, 1.04254447e-01f, -1.13717616e-01f, 3.36347856e-02f, 2.08722963e-03f,
  2.82091469e-01f, -5.01672626e-01f, 3.65148991e-01f, 5.63105335e-03f, 1.14371993e-01f, -5.48303314e-02f, 1.70394797e-02f, -1.72510847e-01f, 1.91500373e-02f, -5.53577244e-02f,
  -2.10566089e-01f, -1.11076429e-01f, -3.44937891e-02f, -1.94179956e-02f, -1.40768901e-01f, -4.24809121e-02f, 1.20984919e-01f, -9.28833187e-02f, 7.43069723e-02f, 2.54529655e-01f,
  3.96478862e-01f, 2.54679143e-01f, 1.76800206e-01f, 1.05312653e-02f, 7.43137002e-02f, 7.55771110e-03f, 1.25162154e-01f, 2.25430638e-01f, -1.44676849e-01f, 8.12850416e-01f,
  -7.61489749e-01f, -4.49550658e-01f, -7.79501557e-01f, -3.90416563e-01f, -1.91861510e-01f, 3.05463761e-01f, 3.77369151e-02f, 4.72691417e-01f, 3.05741042e-01f, -4.31199014e-01f,
  -4.36229706e-01f, -3.12865645e-01f, -5.29625118e-01f, -1.73068792e-01f, -8.30363017e-03f, -5.47151148e-01f, -5.22214770e-01f, -4.54286307e-01f, 2.56033123e-01f, 7.02322543e-01f,
  2.32479244e-01f, -1.34335726e-01f, -5.15663400e-02f, -3.87985893e-02f, -2.68292964e-01f, -3.05444390e-01f, -6.33339465e-01f, -3.33160043e-01f, -2.80365556e-01f, -9.66082990e-01f,
  -6.47938430e-01f, -2.89086282e-01f, 3.10757048e-02f, -1.92982703e-01f, -4.69541969e-03f, 1.50286227e-01f, 4.94814068e-02f, -3.08952898e-01f, 6.76437244e-02f, -1.86718538e-01f,
  -2.12297931e-01f, 1.92889661e-01f, 1.62032470e-01f, -1.53256088e-01f, -3.37937251e-02f, 1.77599356e-01f, -9.05106664e-02f, -8.68746117e-02f, -1.63578585e-01f, 2.47002602e-01f,
  1.15536064e-01f, 2.03809422e-02f, -1.85698688e-01f, 1.34879977e-01f, 3.79364073e-01f, -2.15210527e-01f, 1.56720459e-01f, 1.07769579e-01f, -9.24417973e-02f, -5.60800016e-01f,
  2.62047231e-01f, -3.05619687e-02f, 1.43106401e-01f, 5.87951913e-02f, 1.08758442e-01f, 3.86722293e-03f, -8.58799070e-02f, 4.30113897e-02f, 1.91302717e-01f, 1.45042324e-02f,
  3.63522768e-02f, -1.11182056e-01f, 8.65853056e-02f, -1.66434154e-01f, -5.85937165e-02f, -1.32725775e-01f, -1.17366701e-01f, 1.26939923e-01f, -9.72879753e-02f, -4.83186767e-02f,
  -6.34342283e-02f, 2.36243531e-02f, -5.35999946e-02f, 7.69724473e-02f, -8.12204853e-02f, -1.15065902e-01f, -6.12376593e-02f, 1.53666809e-01f, -9.16289762e-02f, -4.24928293e-02f,
  -3.74787450e-01f, 9.15854126e-02f, -4.07780021e-01f, 2.23724414e-02f, -1.36416763e-01f, 4.40981053e-02f, -2.41842330e-01f, 1.48682609e-01f, -1.29207537e-01f, -6.76930323e-03f,
  -1.70395449e-02f, -4.92516048e-02f, -2.27223188e-01f, 9.59105906e-04f, 1.02897268e-02f, 4.55776006e-02f, 5.91757521e-02f, -3.62372786e-01f, 8.52919817e-02f, 2.40125522e-01f,
  1.68579221e-01f, -7.89893139e-03f, -1.76896319e-01f, -2.77331561e-01f, 1.71099588e-01f, -3.31972331e-01f, -2.85234690e-01f, -2.13586256e-01f, -2.15580404e-01f, -3.35572749e-01f,
  -3.88075590e-01f, 2.09572360e-01f, 7.17260182e-01f, -3.78487229e-01f, 2.83179075e-01f, 2.91207194e-01f, 5.13853610e-01f, -7.01443804e-03f, -5.27776897e-01f, 1.19718211e-02f,
  -3.61263053e-03f, -3.69442612e-01f, -2.86127985e-01f, -7.05954758e-03f, 1.25992343e-01f, 1.03188626e-01f, 3.17302436e-01f, 3.66826445e-01f, 3.72526124e-02f, -2.08395198e-01f,
  -3.15496027e-01f, 1.65634751e-01f, 2.77931660e-01f, -2.26574987e-02f, -4.78618652e-01f, -4.67642963e-01f, 3.38433087e-01f, 1.56809375e-01f, 2.66179949e-01f, -1.00815527e-01f,
  -2.60148019e-01f, 9.85917747e-02f, -1.02014281e-01f, -7.65309706e-02f, 1.89810693e-01f, -7.63154179e-02f, -9.97539982e-02f, -5.03095314e-02f, 6.53084666e-02f, -2.98857670e-02f,
  3.84134054e-02f, -6.02596346e-03f, -1.21880481e-02f, 4.45750263e-03f, 3.13836783e-02f, -1.21617585e-01f, 1.70346051e-01f, 4.37628068e-02f, 1.27718821e-01f, 4.33589220e-02f,
  -1.44950569e-01f, 9.94696468e-02f, 2.63480753e-01f, 1.25034243e-01f, -2.97474675e-03f, 1.13616176e-01f, 2.20206931e-01f, -6.85287639e-02f, 2.44579509e-01f, -3.20089161e-01f,
  -2.14568168e-01f, 4.48743924e-02f, 2.56159842e-01f, -9.82106701e-02f, -5.51726073e-02f, -2.88324952e-02f, 1.86365377e-02f, 6.85115680e-02f, 2.89268270e-02f, -3.68037857e-02f,
  4.58783209e-02f, -1.04777105e-01f, -1.71448719e-02f, 1.38938082e-02f, -1.93199515e-01f, 7.27984384e-02f, 1.50850847e-01f, 6.77358657e-02f, 2.24870946e-02f, 6.16603643e-02f,
  -3.88962179e-02f, -1.01484917e-02f, 5.74817248e-02f, 7.24069253e-02f, 4.45949845e-02f, 2.26187427e-02f, -2.23480221e-02f, 9.61405877e-03f, -1.12653442e-01f, -7.32665285e-02f,
  -4.42113459e-01f, 6.05976045e-01f, -4.23951209e-01f, 5.80049492e-03f, 1.53455716e-02f, 1.00533981e-02f, 2.92839706e-02f, 3.18630747e-02f, 6.97226822e-02f, -1.42391488e-01f,
  1.98378757e-01f, -1.44321173e-01f, 1.68398730e-02f, 7.21181482e-02f, -1.67613178e-01f, -1.02250203e-01f, 4.37494665e-02f, -1.94867421e-02f, 5.28698750e-02f, -4.28012293e-03f,
  2.07318030e-02f, -1.67640001e-01f, -3.77479106e-01f, -3.04139912e-01f, -4.53185052e-01f, -4.94761080e-01f, -1.18213877e-01f, -2.68978477e-01f, 8.73737186e-02f, -3.84693116e-01f,
  -4.78935987e-01f, -2.59612739e-01f, 6.87847435e-01f, -3.32441151e-01f, 2.69071102e-01f, 4.34256226e-01f, 6.34508193e-01f, -9.93556008e-02f, -2.76882321e-01f, 5.87311350e-02f,
  -1.26481965e-01f, -3.17434639e-01f, -2.26821661e-01f, -2.77159214e-01f, -2.07658008e-01f, 3.30588251e-01f, -1.06474641e-03f, -1.36809926e-02f, 2.15440318e-01f, 1.46309912e-01f,
  -1.26127526e-01f, 7.03469515e-02f, -3.06253403e-01f, -1.82401210e-01f, -4.84535955e-02f, -9.18353051e-02f, 1.59661710e-01f, -3.97567786e-02f, -3.89991961e-02f, -2.36083001e-01f,
  5.38548291e-01f, -1.09850038e-02f, -1.38088048e-01f, -3.56067985e-01f, 1.47062078e-01f, -2.28690565e-01f, 8.33946913e-02f, -1.54117122e-01f, -1.13466762e-01f, 4.86136153e-02f,
  -7.55882710e-02f, 2.39565759e-03f, 7.02063218e-02f, 6.39056787e-02f, 1.35242283e-01f, 2.24479288e-02f, -5.11582568e-02f, -2.24071309e-01f, -1.54922649e-01f, 7.99832791e-02f,
  -1.18749581e-01f, 7.54812919e-03f, 3.08653861e-01f, -7.97923747e-03f, -9.38170701e-02f, -1.11442544e-01f, 4.72752340e-02f, -1.33977577e-01f, -1.75887391e-01f, -1.42354861e-01f,
  -6.36150837e-02f, 4.85010222e-02f, 3.76146063e-02f, 2.19620652e-02f, -2.69105844e-02f, 5.75890881e-04f, 1.04571395e-02f, -6.25691339e-02f, -2.01719180e-02f, 3.13425884e-02f,
  -4.98531237e-02f, 9.95797850e-03f, -7.77737275e-02f, -1.42526357e-02f, -1.29536361e-01f, -3.48130800e-02f, 4.36805002e-02f, -3.49355452e-02f, -6.27255663e-02f, 2.81351693e-02f,
  -8.36633220e-02f, -5.81240607e-03f, -7.17598498e-02f, 5.21657057e-02f, -2.00782046e-01f, -9.56775174e-02f, -1.19144656e-01f, -1.09859414e-01f, 6.46074116e-02f, -4.47679274e-02f,
  -9.99837667e-02f, -1.04537658e-01f, 6.94893748e-02f, -1.69193387e-01f, 1.20275170e-01f, -1.83835164e-01f, 5.31449690e-02f, -1.89858712e-02f, -5.00655212e-02f, 7.88475201e-03f,
  -3.47877070e-02f, -9.59221087e-03f, 3.88780013e-02f, -5.01626357e-02f, 2.10471898e-01f, 1.04129948e-02f, -1.87798202e-01f, 1.10627757e-02f, -1.49307027e-01f, 6.11449080e-03f,
  -1.64254263e-01f, 1.86128411e-02f, 1.46694213e-01f, 1.06906630e-02f, 6.65314049e-02f, 6.42310306e-02f, 2.47502461e-01f, 1.73682123e-01f, 1.61569223e-01f, 6.55989423e-02f,
  -1.00157523e+00f, -2.45303556e-01f, 4.45345372e-01f, -2.48420537e-01f, -3.41686420e-02f, -1.26384497e-01f, -1.08299725e-01f, -2.73209542e-01f, -2.83601820e-01f, 2.32669953e-02f,
  3.06194481e-02f, 1.24626048e-01f, 2.16504097e-01f, 4.31786217e-02f, -7.82632008e-02f, 8.97352248e-02f, -1.69952169e-01f, -8.59383866e-02f, 8.45330283e-02f, 7.04665389e-03f,
  -6.82981387e-02f, 7.47321397e-02f, -8.57791007e-02f, -7.53192678e-02f, 1.77364007e-01f, 1.99042693e-01f, 3.49231839e-01f, 7.87223428e-02f, 1.66377351e-01f, 1.49968207e-01f,
  5.52883923e-01f, -2.89783388e-01f, -7.65663013e-02f, -2.72254437e-01f, 1.72721893e-01f, -1.76291868e-01f, 4.25760113e-02f, 8.66519660e-02f, 4.38907146e-02f, 1.17486335e-01f,
  -7.25904247e-03f, -9.30586755e-02f, -1.03819676e-01f, 1.35626793e-01f, 5.43476194e-02f, 6.25044405e-02f, -1.05842672e-01f, 3.01615708e-02f, 1.16629489e-01f, 4.74013574e-02f,
  2.83335987e-02f, 1.20374020e-02f, 4.77622151e-02f, 7.06848577e-02f, -5.19959908e-03f, 2.24665496e-02f, 1.31296411e-01f, 4.59103845e-02f, 4.09849770e-02f, 6.55946061e-02f,
  1.22058995e-01f, -5.43940142e-02f, -1.16052836e-01f, 5.65868579e-02f, -4.85182516e-02f, -1.00848051e-02f, 1.45795897e-01f, 1.43175989e-01f, 1.89722311e-02f, 1.33229434e-01f,
  9.30696875e-02f, 4.94302362e-02f, 2.25624412e-01f, 7.49454275e-02f, 8.40483606e-02f, -2.02263035e-02f, 1.45570021e-02f, 8.88643637e-02f, 2.54220515e-02f, -3.60419154e-02f,
  -7.52166938e-03f, 2.91008539e-02f, 4.63189818e-02f, 1.10500403e-01f, 4.83537139e-03f, -5.18378131e-02f, 6.58114254e-02f, 2.35632490e-02f, 2.12379266e-02f, -1.19635952e-03f,
  3.81404996e-01f, -3.98388714e-01f, 8.26415345e-02f, 5.86986840e-02f, -2.64319237e-02f, -5.54942042e-02f, 3.26191746e-02f, -1.10084146e-01f, 9.38289165e-02f, 1.36020675e-01f,
  -7.74128661e-02f, 3.48682851e-02f, 3.58398333e-02f, 4.03475426e-02f, -3.35220173e-02f, 6.57546595e-02f, -2.40577206e-01f, 3.23493406e-02f, -1.12413831e-01f, 2.14013029e-02f,
  -1.43356055e-01f, -1.66882604e-01f, -5.37055582e-02f, -2.94973212e-03f, 5.61114363e-02f, -1.13306284e-01f, 1.71100110e-01f, 6.72667623e-02f, -2.62473393e-02f, 8.70249420e-02f,
  -4.16353017e-01f, 1.42224714e-01f, -1.32767126e-01f, 3.97431403e-01f, 4.17565107e-01f, 4.15113807e-01f, 3.21580559e-01f, 3.23386937e-01f, 2.68048614e-01f, 2.52262354e-01f,
  3.30999404e-01f, 3.17616135e-01f, 3.73001844e-01f, 2.92087406e-01f, 1.67739972e-01f, 2.64438659e-01f, 2.70104289e-01f, -1.03783056e-01f, -9.09124240e-02f, 2.44546562e-01f,
  3.15777391e-01f, 1.31314173e-01f, -7.58554116e-02f, 1.86737888e-02f, 1.34750515e-01f, 3.02659035e-01f, 2.88384646e-01f, 3.58206004e-01f, 2.64687896e-01f, 1.83181778e-01f,
  -1.41036496e-01f, -3.17910910e-02f, 8.69501010e-02f, 8.60650465e-02f, -2.43624598e-01f, -2.85681248e-01f, -1.15718655e-01f, -1.15326561e-01f, -1.11899875e-01f, 1.92340557e-03f,
  -1.01783827e-01f, -1.71437532e-01f, -6.53616637e-02f, -1.05509467e-01f, -1.05310902e-01f, -9.13990065e-02f, -3.59977894e-02f, 1.20633490e-01f, 2.59776324e-01f, 2.80576013e-02f,
  5.73677532e-02f, 5.40238246e-02f, 1.42027304e-01f, 1.49686232e-01f, 1.43380985e-01f, -1.50004141e-02f, 5.28793968e-02f, 8.94524530e-03f, 1.63989011e-02f, 4.74265143e-02f,
  1.34645179e-01f, -5.36634177e-02f, 5.47624938e-02f, 1.49971947e-01f, -5.67055568e-02f, -5.06917350e-02f, 8.78806189e-02f, 2.32135400e-01f, 4.52394225e-02f, -1.82199806e-01f,
  -3.63063216e-02f, 1.35401636e-01f, 9.06090736e-02f, 1.34714037e-01f, -4.51926440e-02f, -2.70631094e-03f, -4.35913540e-02f, -5.35682105e-02f, -1.69237256e-01f, -1.76048338e-01f,
  -1.32609278e-01f, -1.90604501e-03f, -6.33850917e-02f, 4.78540696e-02f, 8.24207589e-02f, 1.18917204e-01f, 1.83679312e-01f, 8.35649148e-02f, 3.80799733e-02f, -1.09448612e-01f,
  2.97721237e-01f, 1.82241127e-01f, -1.65851191e-01f, -1.11077480e-01f, -1.20283894e-01f, -2.51595676e-01f, -4.41073328e-02f, -1.27746895e-01f, -6.65148869e-02f, 6.03089742e-02f,
  -1.49250897e-02f, -1.35970414e-01f, -1.62989095e-01f, -1.18398860e-01f, -2.53041804e-01f, -1.30332008e-01f, -1.26722395e-01f, 1.07933059e-01f, 6.23190999e-02f, -7.88038447e-02f,
  -2.84109614e-03f, -2.91242870e-03f, 4.06413414e-02f, 5.50620146e-02f, -1.55345025e-02f, 4.47946675e-02f, -2.72214301e-02f, 2.39871698e-03f, 4.01856424e-03f, -1.79486692e-01f,
  -4.73588735e-01f, -7.36896634e-01f, -4.63042170e-01f, -7.58939981e-01f, -5.88632345e-01f, -1.17917173e-01f, -4.94618773e-01f, -3.21146436e-02f, -1.87066883e-01f, -8.47727954e-01f,
  -2.46307805e-01f, 2.90163517e-01f, 1.62421837e-01f, 7.13532940e-02f, 5.29198088e-02f, -8.24191451e-01f, -7.07595110e-01f, -1.36721600e-02f, 2.30404109e-01f, -9.12828464e-03f,
  -3.27779263e-01f, -6.53225482e-01f, -2.64395535e-01f, -1.52236000e-01f, -4.46165442e-01f, 9.47045069e-03f, -3.92924905e-01f, -4.19819981e-01f, -2.01290146e-01f, -7.06011951e-01f,
  -1.49902720e-02f, 2.89550573e-02f, 2.56059200e-01f, -7.72571564e-02f, -1.03850484e-01f, 1.38842732e-01f, 1.10450191e-02f, -1.14870526e-01f, -4.09008302e-02f, -7.73462057e-02f,
  -2.26446867e-01f, -1.17077552e-01f, -1.13460414e-01f, 8.78731087e-02f, -1.36705294e-01f, -7.37055838e-02f, -9.19220448e-02f, -6.67605922e-02f, -2.65841875e-02f, 1.13661893e-01f,
  -1.32835984e-01f, -1.91508487e-01f, 1.04359351e-01f, 2.09456399e-01f, 2.38479853e-01f, 1.51954815e-01f, 1.55865952e-01f, 2.98525572e-01f, 2.04553455e-01f, -4.03502494e-01f,
  -2.74394751e-01f, 6.99990541e-02f, 5.52895293e-02f, -3.53542119e-02f, 1.18867103e-02f, 1.28409453e-02f, 5.99055104e-02f, -2.76465081e-02f, 4.65349890e-02f, -9.61243957e-02f,
  -9.02269259e-02f, 1.02333613e-01f, 1.09052874e-01f, -5.57631627e-02f, 1.30243246e-02f, -1.01590902e-01f, 1.68509185e-02f, -5.14629930e-02f, 1.89177375e-02f, -8.55075493e-02f,
  5.53476028e-02f, 1.74098555e-02f, -1.94831789e-02f, -2.11852850e-04f, 1.07016908e-02f, -8.25359374e-02f, 5.36639579e-02f, 2.47456864e-01f, 1.14767766e-02f, -1.36521980e-02f,
  2.18435973e-01f, 9.75651890e-02f, -8.12253132e-02f, 4.96941656e-02f, 3.98747399e-02f, 7.65410950e-03f, 1.25882775e-01f, -2.79074796e-02f, 1.23795360e-01f, 5.59833236e-02f,
  1.27236113e-01f, -2.12593481e-01f, -6.35310262e-02f, 1.33795040e-02f, -1.33565683e-02f, -5.26095405e-02f, -1.18552275e-01f, -1.23800151e-01f, 1.31610781e-01f, 1.06543917e-02f,
  -1.18079536e-01f, -2.02647179e-01f, 1.11721218e-01f, 1.58799499e-01f, -4.28369232e-02f, 2.37224072e-01f, 2.70223945e-01f, 9.45436358e-02f, 1.10585719e-01f, -5.20568073e-01f,
  -8.67055774e-01f, 6.01617634e-01f, -1.51491851e-01f, -4.24190462e-01f, -4.27532077e-01f, -4.43228543e-01f, -1.73630379e-02f, -5.11115454e-02f, -3.73891406e-02f, 3.66205335e-01f,
  2.16018349e-01f, -2.20527515e-01f, 7.94189870e-02f, -2.08313167e-02f, -2.60036737e-01f, 1.49588048e-01f, -1.60398841e-01f, -8.41017783e-01f, -9.29713130e-01f, -7.50041008e-01f,
  -4.55115885e-01f, -5.72935879e-01f, -7.28161156e-01f, -3.74857008e-01f, 1.72034353e-01f, -4.11145762e-02f, 2.70758718e-01f, -3.12859625e-01f, -1.58592328e-01f, -4.75802273e-02f,
  2.53192008e-01f, -2.66897917e-01f, -1.50318757e-01f, -2.34057993e-01f, 6.89528063e-02f, 4.22459096e-02f, -1.29295196e-02f, 1.93740055e-01f, 1.20170020e-01f, 1.06298655e-01f,
  -4.83560115e-02f, 7.82110170e-03f, 2.03398475e-03f, -3.78246792e-02f, -1.37095094e-01f, -7.60675222e-02f, 7.17366338e-02f, 2.30403827e-03f, 1.58701733e-01f, 1.69241428e-01f,
  9.78470445e-02f, -1.84683651e-01f, 1.86936036e-02f, 1.67201594e-01f, -4.50710095e-02f, -2.22667903e-01f, 7.07752332e-02f, -9.06559080e-02f, -3.30984928e-02f, 2.86266983e-01f,
  -1.20189786e-03f, 2.38492578e-01f, 3.57418843e-02f, -3.50877494e-02f, 4.22141552e-02f, -1.42168521e-03f, -6.22829199e-02f, 1.43456250e-01f, -1.09317437e-01f, 5.26901223e-02f,
  1.35666996e-01f, -9.68194231e-02f, 3.81912179e-02f, -2.12034024e-02f, -2.56683063e-02f, 2.06884462e-02f, -9.28970799e-02f, 6.84950352e-02f, 4.82122563e-02f, -3.04376371e-02f,
  -9.67127457e-02f, 5.56826126e-03f, -1.84054777e-03f, -3.83600518e-02f, -1.01547644e-01f, -8.06865171e-02f, -1.20613255e-01f, -6.34803623e-03f, 8.96892101e-02f, -1.31665856e-01f,
  1.39976025e-01f, -3.72270107e-01f, 4.00613025e-02f, -2.17667520e-02f, -3.88108753e-03f, 1.59626648e-01f, -7.56849302e-03f, 1.10088423e-01f, 1.03155023e-03f, -5.34764044e-02f,
  -1.79603562e-01f, 2.40699686e-02f, 3.60566628e-04f, 1.54396027e-01f, -9.74340290e-02f, -1.13921642e-01f, 1.23524591e-01f, 1.45775853e-02f, -1.06319062e-01f, 1.45490468e-01f,
  1.65932104e-01f, -4.89805155e-02f, 1.59297094e-01f, 1.77006140e-01f, 9.10058320e-02f, -1.82513356e-01f, 2.31592253e-01f, 5.49885770e-03f, -8.81744847e-02f, 3.93190593e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.32672584e-01f, 2.24347562e-01f, 3.57706964e-01f, 7.74131596e-01f, 5.31649292e-01f, 2.26488367e-01f, 4.93780047e-01f, 4.99325901e-01f, 8.13065886e-01f, 7.09376991e-01f,
  2.08329484e-01f, -7.09845051e-02f, 5.65986454e-01f, 6.89124227e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -6.66541234e-02f, 4.74359281e-02f, 1.51538715e-01f, 2.04671696e-01f, 1.00987129e-01f, -1.85494125e-01f, 8.94778594e-02f, 1.14439847e-02f, 1.28255785e-01f, -1.91774145e-02f,
  1.63202494e-01f, -2.44961187e-01f, -1.05185986e-01f, 2.23374322e-01f, -1.12263620e-01f, 7.97849000e-02f, 2.66850829e-01f, 8.06669816e-02f, 7.70972371e-02f, -2.19712794e-01f,
  -1.38459012e-01f, -2.31216829e-02f, -3.66528600e-01f, 2.64201641e-01f, -4.05447334e-01f, 4.12775017e-02f, -2.32721120e-01f, 7.53404945e-02f, 2.51525313e-01f, -8.01746249e-02f,
  3.67196500e-01f, -4.55018580e-02f, 9.64507908e-02f, 2.25817174e-01f, 4.54200879e-02f, 3.29845957e-02f, 1.62416920e-01f, 4.02047634e-02f, -5.68799339e-02f, -9.97854769e-03f,
  1.11466110e-01f, 2.00738505e-01f, -1.95370167e-02f, 5.44086508e-02f, 3.56179923e-02f, -3.34421486e-01f, 1.20678164e-01f, -3.16787511e-02f, -6.88634962e-02f, -1.85021147e-01f,
  -1.44539490e-01f, -1.22531682e-01f, 1.41201437e-01f, 2.16171801e-01f, -2.28108212e-01f, 2.87876036e-02f, 6.56623960e-01f, -9.47620124e-02f, 5.69521070e-01f, 3.97206485e-01f,
  1.62403628e-01f, 2.68058944e-02f, -1.51023164e-01f, -2.16968432e-02f, 6.09369501e-02f, 1.52017534e-01f, 2.26190865e-01f, 2.25646213e-01f, 2.44865611e-01f, -1.31594583e-01f,
  9.24461633e-02f, 1.90207452e-01f, -1.43069804e-01f, 4.48534125e-03f, 5.51607125e-02f, 4.95685562e-02f, -7.46942535e-02f, 2.03069910e-01f, -8.93582031e-02f, 8.41005296e-02f,
  6.48875013e-02f, -1.23971127e-01f, -3.39309648e-02f, 1.32090464e-01f, 5.96163571e-02f, -2.22333129e-02f, -7.63045326e-02f, -3.73085439e-01f, 3.95783216e-01f, -9.31591392e-02f,
  4.75295275e-01f, 5.21070182e-01f, -2.49442130e-01f, 3.63128521e-02f, -6.91880435e-02f, -1.90873951e-01f, -2.59619989e-02f, -1.08033575e-01f, 1.10588342e-01f, 3.61556821e-02f,
  -2.33441480e-02f, -4.77497429e-02f, 8.93392563e-02f, -6.45271093e-02f, -1.57552585e-02f, 3.19619961e-02f, 1.02958716e-01f, -3.02716848e-02f, 9.00588110e-02f, -3.20071667e-01f,
  1.35674298e-01f, 1.69691127e-02f, 4.39900495e-02f, -6.28321916e-02f, -3.43102902e-01f, 7.24928454e-02f, -1.53744653e-01f, 6.37142897e-01f, 2.53768981e-01f, 4.68428820e-01f,
  -2.18740016e-01f, -2.61268616e-01f, 4.18693244e-01f, -3.66249859e-01f, 1.38117716e-01f, 8.64497349e-02f, -9.13239419e-02f, 1.76397413e-01f, 1.82667766e-02f, 1.42724708e-01f,
  -9.00093317e-02f, -2.16466077e-02f, -1.22891702e-01f, -1.84607878e-02f, 1.36560559e-01f, 2.04846300e-02f, 9.64935403e-03f, -5.02844974e-02f, 5.72140850e-02f, 4.51432308e-03f,
  2.01080427e-01f, -3.72018330e-02f, 2.64053587e-02f, 1.21173650e-01f, 5.11019900e-02f, 3.50486338e-02f, 1.49214908e-01f, -9.97579768e-02f, -2.20722910e-02f, -1.74385943e-02f,
  5.95749877e-02f, -5.87247968e-01f, 1.22745320e-01f, -3.62777233e-01f, 5.28652251e-01f, 4.15097803e-01f, 1.58401147e-01f, -1.16478726e-01f, -4.63620909e-02f, 1.67637780e-01f,
  1.12743638e-01f, -1.26962513e-02f, -1.25567168e-01f, 2.70088520e-02f, -1.92498714e-01f, 1.29847199e-01f, -1.47707820e-01f, -7.50825629e-02f, 2.78924573e-02f, -3.23879980e-02f,
  2.38192350e-01f, 3.60234827e-02f, -1.67215005e-01f, -1.46750227e-01f, 5.80540486e-02f, 2.37323955e-01f, 1.29939571e-01f, 6.17899820e-02f, -1.53505936e-01f, 6.92709312e-02f,
  9.55264792e-02f, -5.23713410e-01f, -1.03770167e-01f, -2.71188349e-01f, 3.34938705e-01f, 2.19738498e-01f, -5.22798419e-01f, 4.07545567e-01f, 4.25152332e-01f, 3.20170494e-03f,
  -3.01808547e-02f, 1.30020335e-01f, 4.43309434e-02f, 8.11467916e-02f, 1.60840124e-01f, -7.71584362e-02f, 3.89230818e-01f, 3.15662026e-02f, -6.21014386e-02f, -9.33170617e-02f,
  1.76591471e-01f, 2.08546862e-01f, 1.69579864e-01f, -8.50310922e-02f, -1.24883838e-01f, 1.36714354e-01f, 9.00714565e-03f, 6.51450828e-02f, 2.63597518e-01f, 2.12084889e-01f,
  -2.87199318e-01f, -8.47854316e-02f, -1.35673687e-01f, 5.33106744e-01f, -2.10075051e-01f, 2.14085042e-01f, -2.23178398e-02f, -3.01753759e-01f, 1.02607105e-02f, -1.12294301e-01f,
  -7.88192078e-02f, 1.63137123e-01f, -1.35850012e-02f, 2.75457650e-01f, 1.20612971e-01f, 4.94445823e-02f, 7.65432492e-02f, -8.17782059e-02f, 1.51792392e-01f, 7.02039003e-02f,
  -4.57055829e-02f, 7.65846577e-03f, 9.59442370e-03f, 8.01670849e-02f, 2.86549293e-02f, 5.00725470e-02f, 2.52223104e-01f, 1.73375234e-01f, -5.62987104e-02f, 1.63801201e-02f,
  1.29201338e-01f, 8.03643912e-02f, 2.88900554e-01f, 8.53369832e-02f, -1.02757342e-01f, -3.11527699e-01f, -2.67933965e-01f, -5.89182138e-01f, 3.10319245e-01f, 2.81593531e-01f,
  -3.98672342e-01f, 2.30266571e-01f, -1.10334143e-01f, -1.39930427e-01f, 3.83535959e-03f, 8.37826133e-02f, 1.21153310e-01f, 1.40455350e-01f, 3.27470005e-01f, 4.17317338e-02f,
  3.41533422e-01f, 4.81058471e-02f, 4.14532349e-02f, -7.25536747e-03f, 9.57950018e-03f, -3.52847353e-02f, 6.09950125e-02f, -2.93683633e-02f, -8.89781788e-02f, -8.28967169e-02f,
  5.89224230e-03f, 1.41830236e-01f, 1.11749656e-01f, 9.85708013e-02f, -2.37287074e-01f, -3.66054893e-01f, 3.79418582e-01f, -7.89788812e-02f, -1.32449433e-01f, 2.17470136e-02f,
  3.34063500e-01f, -3.99680659e-02f, 4.21343386e-01f, -2.19981670e-02f, 1.98797092e-01f, -5.34979813e-02f, -7.51888528e-02f, 4.15667455e-04f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.92535490e-01f, -1.31003097e-01f, 1.07943900e-01f, 1.91501737e-01f, -1.10122701e-03f, 4.27982420e-01f, -1.85934812e-01f, -2.10251957e-01f, -9.61454138e-02f, -1.27017602e-01f,
  -1.27089620e-01f, 9.85831916e-02f, 2.83208132e-01f, -4.01457846e-01f, 1.23636045e-01f, -2.63583302e-01f, -6.74942648e-03f, -2.01474670e-02f, -4.71838921e-01f, -2.52735585e-01f,
  -1.73363745e-01f, 3.56860876e-01f, 7.14042068e-01f, 5.07763982e-01f, -7.11477339e-01f, -3.80234271e-02f, -9.31917354e-02f, 4.86972123e-01f, 7.81179905e-01f, -3.39764625e-01f,
  4.32317734e-01f, 3.39347661e-01f, 1.67021602e-01f, -8.38299543e-02f, 2.40283728e-01f, 2.59260774e-01f, 2.45744199e-01f, -3.28085005e-01f, 1.92760229e-01f, 1.61675051e-01f,
  4.95090745e-02f, -8.96757096e-02f, 8.00704062e-02f, 1.36579126e-01f, -6.44937754e-02f, 5.60323417e-01f, 1.97979603e-02f, 1.32778317e-01f, 4.57886467e-03f, 3.72066408e-01f,
  1.13749361e+00f, 9.65660140e-02f, 2.50565022e-01f, -7.25933790e-01f, 7.53264368e-01f, -3.04259956e-02f, -9.42141190e-02f, 4.18191031e-02f, -2.39663180e-02f, -1.85877815e-01f,
  -4.23100680e-01f, 2.40930542e-01f, 7.20006824e-01f, -5.10275438e-02f, 2.35555768e-02f, -1.47436425e-01f, -4.04868960e-01f, 6.58030868e-01f, -6.40815556e-01f, -9.17404369e-02f,
  1.50423378e-01f, 4.05427992e-01f, 2.27833226e-01f, 2.20184833e-01f, 3.29730809e-01f, -5.33629119e-01f, 6.75447524e-01f, 5.66627145e-01f, 1.04546182e-01f, 2.60888219e-01f,
  -2.19826743e-01f, -6.28351048e-02f, -9.53347161e-02f, -3.03758681e-01f, 2.05717072e-01f, 7.18896687e-02f, -2.89797157e-01f, -2.30955645e-01f, 1.37117743e+00f, 1.59136191e-01f,
  -2.26565421e-01f, 5.33377469e-01f, 1.73415951e-02f, -6.10785820e-02f, -5.75227857e-01f, 5.46596870e-02f, 4.20051277e-01f, 2.54930019e-01f, 2.52943128e-01f, 3.87751669e-01f,
  5.09613492e-02f, 3.17360640e-01f, 2.01126739e-01f, 1.45937130e-01f, 1.98522300e-01f, -2.02538058e-01f, -1.09243385e-01f, 2.74491489e-01f, 2.05294928e-03f, -3.51806551e-01f,
  -3.42220366e-02f, -6.14902098e-03f, -1.26909390e-01f, -4.49469723e-02f, 8.43396902e-01f, 4.25886899e-01f, 3.94540697e-01f, -1.46710694e-01f, 9.34649348e-01f, 6.94081932e-02f,
  -7.78214872e-01f, 5.08506656e-01f, 1.07171035e+00f, -8.92877057e-02f, 1.85824573e-01f, -6.76439047e-01f, 2.46222496e-01f, -4.26564664e-01f, -4.72940579e-02f, 2.17214614e-01f,
  6.23336792e-01f, 3.51925343e-01f, 6.03245735e-01f, 8.30310732e-02f, -1.01248823e-01f, 8.26569051e-02f, 1.10860154e-01f, -3.99326980e-02f, 4.54039186e-01f, 1.69806734e-01f,
  -7.77698934e-01f, -5.07302321e-02f, 3.10758501e-01f, 3.45893085e-01f, 4.64012563e-01f, 1.75919980e-01f, 1.88366696e-01f, -5.31299472e-01f, -1.51109230e-02f, 4.66923207e-01f,
  -1.80859312e-01f, 1.20698698e-02f, 8.97291452e-02f, 1.45409718e-01f, -7.12668419e-01f, -1.84952125e-01f, 2.10889220e-01f, 1.02404006e-01f, 4.93453413e-01f, 8.86293650e-01f,
  4.26771343e-01f, 4.39481467e-01f, 5.99430680e-01f, -3.39035541e-01f, 1.94558257e-03f, 4.46047843e-01f, 2.13672251e-01f, 2.99048066e-01f, 1.17730238e-01f, 1.86873123e-01f,
  -2.65909106e-01f, 1.50131196e-01f, 1.78207383e-01f, -8.72837126e-01f, 4.94944751e-01f, -1.34961382e-01f, 2.66319573e-01f, -1.14359029e-01f, -1.39156386e-01f, -7.41061866e-01f,
  1.31343171e-01f, 3.40398014e-01f, 1.56078383e-01f, -8.44404936e-01f, 6.56651378e-01f, 3.35364670e-01f, 3.93589258e-01f, -2.71109760e-01f, 4.02537107e-01f, 7.13436976e-02f,
  -3.90710831e-01f, 9.69581664e-01f, 2.63326883e-01f, 1.58375636e-01f, -1.22371115e-01f, 1.47947118e-01f, -5.32924458e-02f, 1.10494316e-01f, 2.18451738e-01f, 8.09478536e-02f,
  2.67945319e-01f, 2.87756678e-02f, 3.87130678e-02f, 4.03292291e-02f, -2.77448177e-01f, 8.98842588e-02f, 1.30377427e-01f, 1.66244179e-01f, -2.06283942e-01f, 1.68623682e-02f,
  -5.70462167e-01f, -7.06214085e-02f, 6.60823941e-01f, 1.63915396e+00f, 1.73412710e-01f, 1.00176573e+00f, 9.10206977e-03f, -4.48386639e-01f, 1.00178730e+00f, 9.33924615e-01f,
  7.10397065e-01f, 1.80904537e-01f, 7.38884583e-02f, 3.97494078e-01f, 1.99817251e-02f, 1.94713429e-01f, 2.64444172e-01f, 1.57264754e-01f, 2.16842487e-01f, 1.90376788e-01f,
  4.95852418e-02f, 2.70560235e-02f, 1.94503829e-01f, -2.97950357e-01f, 1.60793230e-01f, 1.69955179e-01f, -2.30866626e-01f, -1.21504679e-01f, 2.84466352e-02f, 1.58813506e-01f,
  2.41326630e-01f, 3.07475384e-02f, 1.95767149e-01f, 2.37205043e-01f, 6.96703911e-01f, -4.34712946e-01f, -7.85242677e-01f, -3.57318252e-01f, -2.19991863e-01f, 8.46266091e-01f,
  -4.14128117e-02f, 5.29230654e-01f, 7.45346844e-02f, 1.81915879e-01f, 5.45321345e-01f, 1.86987579e-01f, 3.95566314e-01f, 1.05725214e-01f, 2.13281348e-01f, 1.38290569e-01f,
  2.05224901e-01f, 2.41076443e-02f, 1.50395513e-01f, 1.37190744e-01f, 4.22327220e-01f, -1.34963498e-01f, -2.64094859e-01f, 2.74657130e-01f, 2.23213404e-01f, -4.91960317e-01f,
  1.60606101e-01f, -2.87327826e-01f, -1.72150552e-01f, -6.08669780e-02f, -2.45154187e-01f, 2.26868391e-01f, -2.02916279e-01f, -7.18573213e-01f, 1.05452466e+00f, 4.33612227e-01f,
  1.26017511e+00f, -9.98581424e-02f, -7.66150534e-01f, -3.55881810e-01f, 1.11366980e-01f, 2.70630002e-01f, -1.80871263e-01f, 5.46388268e-01f, 3.40617709e-02f, -5.02982235e-04f,
  2.03236669e-01f, 9.93140712e-02f, 6.96733892e-02f, -2.60161422e-02f, 1.24430850e-01f, 2.51641303e-01f, -1.32979024e-02f, 6.75794631e-02f, 5.71446978e-02f, 2.00433359e-01f,
  -2.91733265e-01f, -2.78704494e-01f, 2.83642560e-01f, 1.18521139e-01f, 1.29044771e-01f, -2.91959912e-01f, 8.39432478e-02f, -2.11479276e-01f, 3.62105548e-01f, 3.50929350e-02f,
  -5.88598967e-01f, 1.54108271e-01f, 3.22854042e-01f, 1.13562310e+00f, -5.00006616e-01f, -8.69875073e-01f, -3.62546265e-01f, 7.44576380e-02f, 1.98190704e-01f, 6.19345665e-01f,
  -4.33420651e-02f, 3.53833884e-02f, 4.23888676e-03f, 3.53814065e-01f, 2.36048371e-01f, 1.47535190e-01f, 1.30638644e-01f, 1.72939062e-01f, 2.25298658e-01f, 1.22136988e-01f,
  -1.74762651e-01f, 1.21471547e-01f, -2.43128151e-01f, -2.15160921e-01f, -1.67064086e-01f, -3.43574613e-01f, -8.95384252e-02f, -5.34985512e-02f, 1.31147623e-01f, -4.75280993e-02f,
  1.40820801e-01f, 3.63429248e-01f, 8.94079134e-02f, 1.14748561e+00f, 9.83759314e-02f, -2.78699100e-01f, -1.01563379e-01f, 1.65926099e-01f, 1.86791629e-01f, 4.80788589e-01f,
  -6.95295513e-01f, -6.57395661e-01f, 1.12955928e-01f, 4.03681874e-01f, 5.99006534e-01f, -2.61815172e-02f, 4.14166182e-01f, 1.57178327e-01f, 1.59714803e-01f, 3.04016322e-01f,
  6.08245134e-02f, 6.66899281e-03f, 1.37776509e-01f, -6.29416943e-01f, 2.98201472e-01f, 4.25532550e-01f, 1.67200848e-01f, -2.10470676e-01f, 1.56719014e-02f, -1.94623694e-02f,
  -3.01000953e-01f, -5.84627271e-01f, -5.17109275e-01f, -6.34412169e-01f, 3.32688481e-01f, -6.45506978e-02f, -7.90498793e-01f, 5.16890049e-01f, 8.35695267e-01f, -5.86602747e-01f,
  9.95614380e-02f, -1.07428655e-01f, 7.11387157e-01f, -4.49607186e-02f, -5.34330718e-02f, 2.82754414e-02f, -3.85636501e-02f, 1.19297631e-01f, -3.25476795e-01f, 1.01556048e-01f,
  -1.03739746e-01f, 3.34692001e-01f, 1.35652408e-01f, -1.67027935e-01f, -2.48302594e-01f, 7.33900517e-02f, 1.75971866e-01f, -4.44025487e-01f, 9.69793126e-02f, -2.35000476e-01f,
  -1.90662831e-01f, -2.00203419e-01f, -3.68918836e-01f, -1.77024290e-01f, -3.98115069e-01f, 2.75190592e-01f, 4.82849091e-01f, 1.48158276e+00f, -3.25477719e-01f, 4.33730006e-01f,
  -2.24022925e-01f, -3.70500684e-01f, 5.06548695e-02f, 2.07117319e-01f, -1.44669712e-01f, 1.33651376e-01f, -2.15000123e-01f, 3.32906127e-01f, 1.70709252e-01f, -3.83702189e-01f,
  1.23019777e-01f, 1.39025629e-01f, 2.21793443e-01f, 4.60086852e-01f, -2.05868244e-01f, 2.70517003e-02f, -1.87802389e-01f, -1.88119277e-01f, 2.96727985e-01f, 5.15776835e-02f,
  -4.70963493e-02f, -1.16126962e-01f, 1.82142600e-01f, -1.81159675e-01f, 1.63561895e-01f, -1.57171011e-01f, -5.93810797e-01f, 1.15431774e+00f, -5.99694729e-01f, 1.40715271e-01f,
  -4.25271213e-01f, 5.26112795e-01f, 9.10363138e-01f, -2.90113002e-01f, 5.22038005e-02f, 1.43587261e-01f, 1.53630733e-01f, -3.93794626e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -1.70429468e-01f, 2.06993148e-01f, 5.81775069e-01f, 4.08126831e-01f, 5.46223223e-02f, 4.09075499e-01f, -8.98856968e-02f, 3.20868909e-01f, 4.90361035e-01f, 5.11285245e-01f,
  1.63182721e-01f, 4.37615216e-01f, 7.24457502e-02f, 1.03850715e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -4.44815367e-01f, -5.49696982e-01f, -5.19216418e-01f, 2.91040894e-02f, -4.88677591e-01f, -6.88040733e-01f, -6.65627241e-01f, -3.19560289e-01f, -1.96234584e-01f, 3.30480576e-01f,
  -3.86879504e-01f, -1.49339557e-01f, -5.71862578e-01f, 5.07068746e-02f, 4.48819160e-01f, -6.86632514e-01f, 6.35248721e-01f, -2.07458243e-01f, 8.65325481e-02f, -1.99994266e-01f,
  -2.87505120e-01f, 2.93661088e-01f, -2.33084813e-01f, 1.09383367e-01f, -1.00212741e+00f, 3.21312785e-01f, -1.24397166e-01f, 4.48536813e-01f, -6.84824646e-01f, 2.63063431e-01f,
  2.21861824e-01f, 3.97912413e-01f, -3.65451396e-01f, 8.00800622e-01f, 6.45023644e-01f, 1.13647290e-01f, 4.68508840e-01f, 6.15443528e-01f, 3.08493286e-01f, 1.17344141e-01f,
  1.00259781e-01f, 2.79247105e-01f, -7.57507235e-02f, 4.09751385e-01f, -6.78542197e-01f, -8.91722679e-01f, 4.65030760e-01f, 1.57391623e-01f, 4.34278786e-01f, 1.72875151e-01f,
  -4.36104715e-01f, 4.38894451e-01f, -6.45403326e-01f, -2.40360260e-01f, 4.44359243e-01f, -1.03802419e+00f, -6.07813418e-01f, 4.47111517e-01f, -2.94516981e-01f, 2.69007772e-01f,
  2.46443063e-01f, 4.25504953e-01f, -5.18110693e-01f, -3.54838550e-01f, 4.17764634e-02f, 2.43330136e-01f, 3.49105537e-01f, 3.90476167e-01f, 2.06347834e-02f, -1.78272828e-01f,
  4.32774514e-01f, 3.19895953e-01f, -2.95502037e-01f, -3.07460994e-01f, -6.13613101e-03f, 5.19604862e-01f, 4.41032559e-01f, 1.81708381e-01f, -3.00288558e-01f, -1.08445212e-01f,
  1.17301129e-01f, 4.98177946e-01f, 8.90921503e-02f, -1.37862027e-01f, 1.77249666e-02f, 3.70114148e-01f, -7.86671698e-01f, 3.86974066e-01f, -4.45273548e-01f, -1.68505609e-01f,
  -6.45496277e-03f, -6.55698717e-01f, -6.74438775e-01f, 9.89061534e-01f, -2.83209145e-01f, 5.78293562e-01f, -7.38746002e-02f, -2.02109993e-01f, -1.81593448e-01f, -6.16570771e-01f,
  -2.70366490e-01f, -8.37019980e-02f, -6.36639953e-01f, -2.81229794e-01f, -1.76910684e-01f, 6.96288869e-02f, -8.62107202e-02f, -3.20847362e-01f, -2.32908726e-01f, -5.34065247e-01f,
  -5.70528626e-01f, 5.07656753e-01f, -5.33252180e-01f, -1.76637948e-01f, -5.71102276e-02f, -9.96617258e-01f, -1.96264654e-01f, -1.09934442e-01f, 2.25937858e-01f, 2.05018669e-01f,
  2.86083758e-01f, -4.10157293e-02f, -1.34159446e+00f, 2.94697672e-01f, -6.66211128e-01f, -7.81569071e-03f, 7.82479048e-02f, 7.32228220e-01f, 5.91338873e-01f, 1.19485110e-01f,
  -8.54240477e-01f, -6.11597598e-01f, -2.49030471e-01f, 2.36054674e-01f, 1.89888328e-02f, 2.11059257e-01f, -1.37364389e-02f, 4.15252984e-01f, -3.69589508e-01f, -6.56531215e-01f,
  7.01199293e-01f, 2.68003106e-01f, 4.06171203e-01f, 1.29802614e-01f, -6.33188426e-01f, -2.32500523e-01f, 3.64615142e-01f, 9.10196602e-02f, -8.22049916e-01f, -4.98195678e-01f,
  1.07659407e-01f, 1.53818816e-01f, 1.77648112e-01f, -9.72809270e-02f, 4.40339237e-01f, 9.16285142e-02f, -1.89504966e-01f, 1.25944629e-01f, 1.92803696e-01f, -7.20903516e-01f,
  2.76090980e-01f, -2.94921488e-01f, 6.97148591e-02f, 6.67761803e-01f, 2.55901277e-01f, 2.01642647e-01f, 3.07654321e-01f, -1.49995118e-01f, -4.65725623e-02f, -2.12522969e-01f,
  3.92722130e-01f, 2.27064654e-01f, -1.54862389e-01f, -1.66881531e-01f, 4.12050039e-01f, 3.41543496e-01f, 4.12585557e-01f, 6.48440897e-01f, -5.88336468e-01f, -2.67926514e-01f,
  1.64505690e-01f, -6.77515984e-01f, 1.81640670e-01f, 7.43127286e-01f, -5.33851504e-01f, 9.92944315e-02f, 7.86025524e-01f, 3.94695312e-01f, -2.53718346e-02f, -2.30191201e-01f,
  -2.22767130e-01f, -5.22996306e-01f, -4.53457624e-01f, 7.21939623e-01f, 5.42507768e-02f, 3.49313378e-01f, -7.87568465e-02f, -2.15554401e-01f, -3.10097545e-01f, 4.35309380e-01f,
  -1.49655551e-01f, -3.72992605e-01f, -2.11565886e-02f, 3.86419475e-01f, -1.15941778e-01f, 7.24842489e-01f, 2.03502011e-02f, -3.83452952e-01f, 4.78504086e-03f, -8.21040988e-01f,
  -9.57400978e-01f, 4.38120961e-01f, -1.92548245e-01f, 5.11664987e-01f, -3.74917686e-01f, -5.54167211e-01f, -1.10384011e+00f, -6.30299330e-01f, 1.04180016e-01f, -5.65587938e-01f,
  -3.30307484e-01f, -7.42621005e-01f, -6.63727343e-01f, 1.07540131e-01f, -1.57054707e-01f, -7.75455013e-02f, -1.67427629e-01f, -2.38486081e-01f, -1.02477387e-01f, -1.89132273e-01f,
  -5.29959857e-01f, -2.78468937e-01f, -1.39354188e-02f, -3.10987741e-01f, 9.01103169e-02f, 2.17130572e-01f, 2.18316600e-01f, -3.58527124e-01f, 2.93200284e-01f, 6.41716719e-01f,
  -1.89866737e-01f, 1.82815511e-02f, -2.97606438e-01f, 6.85537830e-02f, -2.09910125e-02f, -1.06922472e+00f, -4.06090856e-01f, -6.70607150e-01f, 1.29288450e-01f, -2.94614971e-01f,
  -1.01293787e-01f, -4.20237631e-02f, 4.94679123e-01f, -5.14955699e-01f, 5.54899275e-01f, 7.86305666e-01f, 4.56885368e-01f, -6.42171681e-01f, -5.74501097e-01f, -1.78135093e-02f,
  -5.77019602e-02f, -1.34101054e-02f, 3.40652794e-01f, 2.11146787e-01f, 2.88960010e-01f, 4.67119031e-02f, 5.01935720e-01f, 4.20948714e-01f, -7.11883843e-01f, 7.09007263e-01f,
  3.48426968e-01f, -4.19777989e-01f, 2.85472274e-01f, 2.30291903e-01f, -1.65917024e-01f, -3.59017223e-01f, 1.09212315e+00f, -9.34900999e-01f, -8.05884421e-01f, -6.00923419e-01f,
  7.06803322e-01f, 7.01177120e-02f, -3.33430208e-02f, -1.04550433e+00f, 4.43478636e-02f, -3.61966580e-01f, -3.85445327e-01f, -7.49100447e-01f, 7.95742214e-01f, 4.81600791e-01f,
  3.47116441e-01f, -2.58510530e-01f, 8.36872339e-01f, 9.08004213e-03f, 2.28052497e-01f, -3.53684723e-01f, 2.30008066e-01f, -4.04489696e-01f, -1.36313751e-01f, -5.91837943e-01f,
  3.21715891e-01f, -4.31592226e-01f, -4.52889532e-01f, -4.58360493e-01f, -6.65556729e-01f, -9.78476286e-01f, 3.47837269e-01f, -2.97877222e-01f, -3.88981104e-01f, 1.51142001e-01f,
  -9.67022657e-01f, -8.77598047e-01f, -3.69442344e-01f, -9.29885626e-01f, 6.29720271e-01f, -5.66776454e-01f, 1.51006743e-01f, -5.58985293e-01f, 8.04090202e-01f, -2.35074624e-01f,
  -7.03088999e-01f, -7.45233297e-01f, 2.37453282e-01f, 4.88473959e-02f, -6.47561252e-01f, -9.81411934e-02f, -5.14697611e-01f, -2.61647999e-01f, -3.12986791e-01f, 5.30704319e-01f,
  1.23277351e-01f, 2.71219611e-01f, 4.94667977e-01f, 5.15980363e-01f, 3.93270314e-01f, 2.31352702e-01f, 2.17651173e-01f, 3.33318442e-01f, 6.89825833e-01f, -9.40075934e-01f,
  -3.34492505e-01f, -8.95135820e-01f, 4.49460357e-01f, 3.34974706e-01f, 4.58785772e-01f, 1.37961105e-01f, -4.36904162e-01f, -1.03838515e+00f, -4.62728709e-01f, -9.33382139e-02f,
  -6.20281696e-01f, -3.41736794e-01f, -3.63768280e-01f, -5.52081943e-01f, -3.28185529e-01f, 8.29571113e-02f, 1.34858042e-01f, -1.07857272e-01f, 1.47039130e-01f, -2.04130754e-01f,
  -1.83028914e-02f, -3.06980193e-01f, 3.50938559e-01f, -2.29102015e-01f, 3.45331281e-01f, 6.25486374e-01f, -5.61417222e-01f, 1.36633188e-01f, -8.53061318e-01f, 4.38726574e-01f,
  -2.66796649e-02f, -8.16529319e-02f, -7.58005857e-01f, 4.86455292e-01f, -5.70258796e-01f, -3.77820849e-01f, 5.28440356e-01f, 2.17065513e-01f, -1.02073050e+00f, -5.97953320e-01f,
  -8.58760253e-02f, -9.24405098e-01f, -3.22754353e-01f, -3.47461104e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.12873095e-01f, 1.58377230e-01f, 3.18009853e-01f, -3.24265331e-01f, -4.98468131e-01f, 2.01069131e-01f, 2.09865078e-01f, 1.05678976e-01f, 1.51064172e-01f, 1.38140097e-01f,
  -1.00714751e-01f, -3.19269955e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    