/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.93760610e-01f, -3.27542633e-01f, -1.75237343e-01f, -2.93104112e-01f, 1.76693052e-01f, -4.93891500e-02f, -2.73315553e-02f, -1.68742090e-01f, 2.45016679e-01f, -2.57250369e-01f,
  -8.10902193e-02f, 6.84784949e-02f, 7.50857517e-02f, -2.78465271e-01f, 4.82293844e-01f, -6.40932992e-02f, -1.44370437e-01f, -9.30668339e-02f, 9.16425809e-02f, -9.29982439e-02f,
  9.70443338e-02f, -6.95044873e-03f, -4.88021933e-02f, -1.03030227e-01f, -1.13142133e-01f, -1.13212921e-01f, -8.67830813e-02f, -1.87915284e-02f, -6.01539798e-02f, 1.05467051e-01f,
  -4.94390056e-02f, -1.34004310e-01f, -3.55895609e-02f, 3.46510634e-02f, -5.19044884e-02f, -9.10502765e-03f, -5.67697641e-03f, 2.77984189e-04f, 3.62974666e-02f, -4.86764545e-03f,
  2.53187101e-02f, 9.72027183e-02f, 2.53570601e-02f, 5.14627323e-02f, 8.24258700e-02f, -9.62824561e-03f, 8.50754753e-02f, -9.57211293e-03f, 6.10494018e-02f, -1.57664791e-02f,
  -3.08957696e-02f, 2.70570926e-02f, -5.25041446e-02f, 4.61832099e-02f, -3.94727737e-02f, -2.67572235e-02f, -3.92049700e-02f, -4.08974253e-02f, -2.90180650e-02f, -5.37639298e-03f,
  3.18290964e-02f, -1.52156493e-02f, 3.58881019e-02f, -3.60121131e-02f, 6.23952523e-02f, -2.35996861e-02f, 9.46818963e-02f, 4.98295240e-02f, -2.97470186e-02f, -4.08765078e-02f,
  4.81347833e-03f, 2.13721916e-02f, -3.76347266e-02f, -2.89069545e-02f, 5.68265542e-02f, -1.38551248e-02f, 1.35581503e-02f, -7.58174434e-02f, 2.79489812e-02f, -5.41533828e-02f,
  1.22337940e-03f, 2.33798698e-02f, -4.08360735e-02f, 1.06394487e-02f, -6.20740689e-02f, 1.45782894e-02f, -4.35445551e-03f, 3.58038172e-02f, 1.33138327e-02f, 5.33099622e-02f,
  -7.62063265e-02f, -1.63836882e-01f, -3.75492644e-04f, 1.46772088e-02f, -6.50720522e-02f, -6.22185692e-02f, 4.28438075e-02f, -8.29591528e-02f, -1.77778248e-02f, -2.60353903e-03f,
  2.89197806e-02f, -3.25387204e-03f, -7.29688033e-02f, -7.53978491e-02f, 2.83323023e-02f, -6.73628971e-02f, -2.59485897e-02f, 2.82951649e-02f, -1.71888769e-02f, -5.66620529e-02f,
  -7.62013253e-03f, 3.40249166e-02f, 1.09952353e-01f, 2.31972579e-02f, 2.58713476e-02f, 6.15588613e-02f, 1.34643940e-02f, 6.48050085e-02f, 6.65308312e-02f, 2.18353719e-02f,
  -3.38839501e-01f, 6.17491603e-02f, 1.80477113e-01f, -1.93456918e-01f, -1.76847309e-01f, 1.16720371e-01f, -1.12051509e-01f, -2.78503180e-01f, -2.92641595e-02f, 3.24454680e-02f,
  -2.11670965e-01f, 1.13664903e-01f, 4.98998798e-02f, -6.02097958e-02f, 1.59895450e-01f, 3.43570322e-01f, -1.05730221e-01f, 4.90615293e-02f, 2.11125508e-01f, -2.36637473e-01f,
  -9.27346125e-02f, -1.74361482e-01f, 1.04287686e-02f, -1.55938566e-01f, -1.63914323e-01f, -1.79295614e-01f, -1.77234396e-01f, 4.73766997e-02f, -1.25598073e-01f, 1.52185038e-01f,
  6.30817655e-03f, -2.55142916e-02f, 2.88966354e-02f, 1.87866762e-01f, -1.77808851e-01f, -1.24616176e-01f, -2.63994141e-03f, 1.12985536e-01f, 2.06811428e-02f, 1.40975922e-01f,
  8.30258615e-03f, -1.07885124e-02f, 1.65943801e-02f, 7.33537152e-02f, 5.16353734e-02f, 7.06084594e-02f, 1.60969988e-01f, 5.56953922e-02f, 3.96598130e-02f, -6.87727630e-02f,
  2.92720105e-02f, 6.05410635e-02f, -5.90660609e-02f, 6.42379671e-02f, -4.76341648e-03f, -1.07066985e-02f, 6.39632344e-02f, 1.72071271e-02f, -3.38053843e-03f, -9.15318169e-03f,
  1.53477848e-01f, 3.86093184e-02f, 1.08947158e-01f, -1.76060759e-02f, 2.93491650e-02f, -5.95943742e-02f, 1.20122828e-01f, -3.43393646e-02f, -3.62101607e-02f, 4.84678857e-02f,
  -1.25521466e-01f, -6.46232292e-02f, 7.36893213e-04f, -2.77078114e-02f, -7.95431584e-02f, -1.76147684e-01f, 1.63218658e-02f, 4.26174365e-02f, -9.67662707e-02f, -8.20255727e-02f,
  1.53810941e-02f, -3.73123288e-02f, -4.33956087e-03f, -1.77576467e-02f, -3.05413213e-02f, 2.15094518e-02f, 4.26586978e-02f, 9.62311178e-02f, 1.22936726e-01f, -7.73632620e-03f,
  -1.58903375e-01f, -2.27497324e-01f, -5.10484278e-02f, -8.50939825e-02f, 1.08542889e-01f, 7.06611276e-02f, 1.54450804e-01f, 5.64765073e-02f, 3.90945263e-02f, -5.51169366e-03f,
  8.48367810e-02f, -3.14532369e-02f, -1.31794065e-01f, 2.52411328e-02f, 3.54934633e-02f, -1.25843316e-01f, -7.86422789e-02f, -7.50464574e-02f, -1.35301813e-01f, -2.37097917e-03f,
  -1.60369366e-01f, 8.67493749e-02f, 6.84261024e-02f, -1.35084718e-01f, -6.17794245e-02f, -2.98345312e-02f, -1.67183295e-01f, 1.06830820e-01f, 6.50494471e-02f, -9.46005154e-03f,
  1.90900231e-03f, 1.71012625e-01f, -4.54155877e-02f, 5.65566588e-03f, 2.09983476e-02f, -5.15783131e-01f, -3.60951394e-01f, 4.51006293e-02f, -5.78108476e-04f, 2.74892990e-02f,
  -1.34494871e-01f, 5.73556870e-02f, 1.12403482e-01f, -3.29765856e-01f, -1.51591212e-01f, -2.70702783e-02f, -2.98893601e-01f, -1.95835039e-01f, 1.12906583e-01f, 6.31892681e-02f,
  4.34260145e-02f, -1.35319635e-01f, -2.97897637e-01f, 4.32739146e-02f, -1.12023845e-01f, 1.68400526e-01f, 1.53197631e-01f, 5.10616601e-02f, -1.43860668e-01f, -1.11592405e-01f,
  -2.62844086e-01f, 1.86343923e-01f, 3.60437855e-02f, 1.40811224e-02f, -6.68657050e-02f, 6.29188195e-02f, -4.90018614e-02f, 1.30320457e-03f, -2.94841193e-02f, -4.43987846e-02f,
  3.35229002e-02f, 4.60219868e-02f, 5.59918135e-02f, 2.47326121e-02f, 4.67145555e-02f, 5.76488525e-02f, 1.11098558e-01f, -1.30019337e-01f, -3.91786024e-02f, -3.43029313e-02f,
  1.04283188e-02f, -7.49567226e-02f, -7.69497156e-02f, 6.88689873e-02f, -5.85648678e-02f, -3.26658562e-02f, -6.72597513e-02f, -1.21818518e-03f, -4.07850090e-03f, 6.55992180e-02f,
  5.23776449e-02f, 1.01584487e-01f, -7.30575249e-03f, -4.88269255e-02f, 1.98071897e-02f, -1.86390784e-02f, 2.18629260e-02f, -9.56877787e-03f, -2.49116104e-02f, 3.49543616e-02f,
  -1.80146210e-02f, -4.40102033e-02f, 2.60244142e-02f, -1.44156367e-02f, -5.88370413e-02f, -8.97560921e-03f, -3.53354216e-02f, 8.77270699e-02f, -7.67194480e-02f, -8.21833014e-02f,
  3.77551243e-02f, -6.03596075e-03f, 5.81916468e-03f, -5.88335097e-03f, -1.27074867e-01f, 3.32801826e-02f, 4.25696783e-02f, -2.40236092e-02f, -3.06445197e-03f, 2.11099777e-02f,
  4.39347811e-02f, 1.09732576e-01f, -2.68878713e-02f, -4.82694618e-02f, 7.50702918e-02f, -1.84638500e-02f, -2.26290524e-02f, -1.22227715e-02f, 4.48981337e-02f, 4.75260019e-02f,
  -2.33683502e-03f, -8.90315685e-04f, -1.07605522e-02f, 1.36277713e-02f, 7.75678270e-03f, -8.97990465e-02f, 8.56057927e-03f, 6.44954219e-02f, -3.35858576e-02f, 5.93037494e-02f,
  3.02620400e-02f, 8.99151489e-02f, 6.24131300e-02f, -4.38585468e-02f, -1.11899236e-02f, -2.05406845e-02f, -3.71156968e-02f, -1.62837133e-02f, 3.73183973e-02f, 2.27148067e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.04603228e-02f, -4.65762883e-01f, -2.10400954e-01f, 3.83037388e-01f, 1.47409290e-01f, -2.86686182e-01f, -2.74380118e-01f, -8.55628327e-02f, -6.33809149e-01f, -2.13565111e-01f,
  1.83914140e-01f, -1.50193973e-02f, -3.41777951e-01f, 2.86161363e-01f, 6.05645597e-01f, -3.20634693e-01f, 2.31453389e-01f, 1.59424335e-01f, -6.06832504e-02f, 3.09245884e-02f,
  1.51674584e-01f, 2.59755135e-01f, 1.56569958e-01f, 1.22012697e-01f, 1.30467534e-01f, 2.03258917e-01f, 4.28662360e-01f, 7.29237795e-02f, 4.85251248e-01f, 1.70661822e-01f,
  9.94975716e-02f, 2.49786954e-02f, -4.40433323e-02f, -1.02162749e-01f, 1.51813440e-02f, 4.45880257e-02f, 1.88854128e-01f, 2.02026561e-01f, 2.42581088e-02f, -1.72348488e-02f,
  1.65954277e-01f, 1.18993893e-01f, 5.82073554e-02f, 8.58040676e-02f, -5.73148616e-02f, -1.24796607e-01f, -5.02209030e-02f, -8.57094452e-02f, -1.17061079e-01f, -7.50564560e-02f,
  -2.35139251e-01f, 1.11002922e-01f, 2.38437038e-02f, 1.37073696e-02f, -1.69093922e-01f, -4.45442125e-02f, 4.62875776e-02f, -4.52641621e-02f, -7.34985173e-02f, -4.56191488e-02f,
  6.68733269e-02f, 5.57714887e-02f, -1.16715945e-01f, -4.11931574e-02f, -1.15394175e-01f, -4.79269922e-02f, -3.88161615e-02f, -5.65491952e-02f, 2.23844647e-02f, 6.31662644e-03f,
  -1.01521268e-01f, 1.47239283e-01f, -3.64383124e-02f, 2.53220983e-02f, -9.51856095e-03f, -4.05373313e-02f, 7.38931373e-02f, 7.57355690e-02f, -1.73831463e-01f, 4.45094109e-02f,
  5.32113686e-02f, 9.53800380e-02f, -4.80701998e-02f, 3.69198062e-02f, 2.24046838e-02f, -3.05069629e-02f, 4.50205654e-02f, -9.96603295e-02f, -1.00870848e-01f, 9.63229910e-02f,
  3.36200707e-02f, 2.09798157e-01f, -1.26427725e-01f, -5.22567444e-02f, -8.34514350e-02f, -3.23591195e-02f, 2.43545249e-02f, -7.79946446e-02f, 4.88942415e-02f, -1.69054538e-01f,
  2.04001188e-01f, 2.22816035e-01f, 5.36661856e-02f, 7.26851374e-02f, 4.39231917e-02f, -6.09595738e-02f, -6.39637560e-02f, 4.53380607e-02f, -1.79648511e-02f, 1.16187394e-01f,
  6.69612288e-02f, 4.19154465e-02f, 5.94227538e-02f, -1.25842452e-01f, 6.43551424e-02f, 6.65885806e-02f, 8.24680477e-02f, 1.85441505e-02f, 2.15236932e-01f, 4.25750948e-02f,
  3.17657590e-01f, -4.24120218e-01f, 8.23710859e-01f, -1.90197393e-01f, 3.59177947e-01f, 4.14690614e-01f, 5.22000909e-01f, -1.15382448e-01f, -1.40243292e-01f, -6.04156792e-01f,
  -1.73261598e-01f, -9.01814201e-04f, 2.46810272e-01f, -3.76774609e-01f, 6.52058363e-01f, 1.83852509e-01f, -1.31861299e-01f, -7.54946098e-02f, 2.87323426e-02f, -1.57941222e-01f,
  1.14591904e-02f, -4.58490551e-01f, 4.50824589e-01f, -4.32715923e-01f, 1.17025450e-01f, -1.47116601e-01f, -4.01266009e-01f, 2.39507169e-01f, -4.74758238e-01f, 1.32207796e-01f,
  2.84720566e-02f, -2.13728547e-01f, -5.14842942e-02f, -3.24245393e-02f, 2.23091841e-02f, 9.11325291e-02f, 1.20287295e-02f, 2.06968084e-01f, 6.01776727e-02f, 2.07352862e-02f,
  -3.21025867e-03f, 8.02288651e-02f, -1.83832079e-01f, 1.11470863e-01f, -3.50262038e-02f, -1.18972640e-03f, 8.93626884e-02f, -7.44883716e-03f, -1.72859114e-02f, 2.54615456e-01f,
  2.50168920e-01f, -4.61337710e-04f, 1.39715094e-02f, -5.71194999e-02f, 9.67755169e-02f, -5.14438329e-03f, 8.52008015e-02f, 2.14900121e-01f, -3.12754400e-02f, 2.03323476e-02f,
  -8.99735745e-03f, 7.05027357e-02f, 2.39920150e-02f, -4.70001474e-02f, 1.45400716e-02f, -6.48767501e-02f, -7.38756955e-02f, -3.32610942e-02f, 4.88580465e-02f, -9.96062811e-03f,
  -8.28376710e-02f, -5.41315880e-03f, 4.46667261e-02f, 7.84331933e-02f, -2.75546554e-02f, -6.61579892e-02f, -6.50499016e-03f, -5.01340292e-02f, -3.00544668e-02f, -1.59661658e-02f,
  5.57105951e-02f, -1.44024240e-02f, 3.98471691e-02f, 6.15429925e-03f, -5.76494448e-03f, -1.97717156e-02f, -1.14561111e-01f, 1.03168301e-01f, 5.18872775e-02f, 7.57937357e-02f,
  -5.64488232e-01f, -6.49374127e-01f, -2.08224371e-01f, -8.83182436e-02f, -1.00763075e-01f, -7.51507506e-02f, -1.00781336e-01f, -9.60076880e-03f, -1.92448884e-01f, 2.03366242e-02f,
  -1.83355555e-01f, -1.01550169e-01f, -4.40436564e-02f, 6.43326417e-02f, -3.65767255e-02f, 3.55369709e-02f, -7.81043395e-02f, -2.87486821e-01f, -9.38997567e-02f, -1.43269822e-01f,
  -3.66282798e-02f, 4.59225699e-02f, 1.27589956e-01f, -1.96186751e-01f, -1.78747341e-01f, -1.29519319e-02f, -6.17304668e-02f, -1.05497554e-01f, 1.35257877e-02f, -8.84335209e-03f,
  5.50379097e-01f, -2.66382337e-01f, -7.33848453e-01f, 1.12442955e-01f, 4.85713452e-01f, 5.82024038e-01f, 1.15107924e-01f, 1.76298190e-02f, -1.69599384e-01f, 2.03232348e-01f,
  3.09373885e-01f, -4.28646266e-01f, -2.80813754e-01f, 6.55060470e-01f, -1.30323201e-01f, -2.41109982e-01f, 2.35072285e-01f, 2.22298056e-01f, -4.03067768e-02f, 2.34935936e-02f,
  8.13574418e-02f, 6.98774099e-01f, -3.25397551e-01f, 1.63520142e-01f, 5.62844217e-01f, -3.24272394e-01f, -7.07570910e-02f, -3.95588070e-01f, 1.52787939e-01f, 1.31512240e-01f,
  1.63722128e-01f, 5.47612272e-02f, -7.11566582e-02f, -2.36691143e-02f, -7.52052106e-03f, 1.27029106e-01f, -1.53763413e-01f, -1.10701390e-01f, -1.43091097e-01f, -6.75158435e-03f,
  -1.61908492e-01f, 5.13475686e-02f, 4.47939485e-02f, -3.35662230e-03f, 2.35423058e-01f, 6.19365424e-02f, 2.56165639e-02f, -2.44589802e-02f, -8.19838643e-02f, 2.59116273e-02f,
  -5.64189404e-02f, -1.51218008e-02f, 9.17948112e-02f, -1.27081558e-01f, -1.02303781e-01f, 1.35765858e-02f, -1.67986006e-02f, -9.41580608e-02f, -1.94380898e-02f, 8.88004154e-02f,
  1.32529065e-01f, -1.36284586e-02f, 5.95942326e-02f, 8.25581327e-02f, 1.16290167e-01f, 9.79922898e-03f, 5.89403026e-02f, 7.69281611e-02f, -1.19209111e-01f, 1.79581508e-01f,
  -4.90433499e-02f, 1.68556590e-02f, 1.57492552e-02f, 1.49565220e-01f, 8.80295709e-02f, 7.50030503e-02f, -1.06219482e-03f, 8.37801844e-02f, -1.49628803e-01f, 5.69818094e-02f,
  4.12844606e-02f, -1.58176981e-02f, 9.28234402e-03f, -6.65214360e-02f, 3.91359366e-02f, -7.45446905e-02f, 9.23231468e-02f, 4.11574580e-02f, -6.26074821e-02f, -6.01488650e-02f,
  -7.05524161e-02f, -3.04097056e-01f, -1.28734738e-01f, -2.71240179e-03f, -8.22784528e-02f, 4.70464751e-02f, -2.47359555e-02f, 8.75955373e-02f, -1.23176627e-01f, 1.13568105e-01f,
  3.23587540e-03f, -1.20278619e-01f, -7.83665702e-02f, 3.80917266e-02f, -5.87187484e-02f, 1.21032877e-03f, -2.07582768e-02f, -8.47978368e-02f, -1.10668279e-02f, -5.76285471e-04f,
  5.23731560e-02f, 1.04090497e-01f, -5.41536808e-02f, -1.04596196e-02f, 7.23444521e-02f, -1.10108607e-01f, -7.04355836e-02f, -7.26567656e-02f, 6.38974011e-02f, -1.46485895e-01f,
  -1.35447478e+00f, -1.80813208e-01f, 8.77936035e-02f, -7.04187155e-01f, 3.67533088e-01f, 3.68573487e-01f, -3.81627649e-01f, 2.22088650e-01f, -4.11057413e-01f, 2.01571003e-01f,
  -1.88353807e-01f, -3.84319633e-01f, -2.10128650e-01f, -4.67663527e-01f, -7.28358924e-01f, -5.89572012e-01f, -3.49200487e-01f, -1.97953999e-01f, -2.15391442e-01f, 1.80518012e-02f,
  -1.64024726e-01f, -1.30059002e-02f, -2.50024557e-01f, 6.87079012e-01f, 2.34980002e-01f, 3.55829597e-01f, 1.04193859e-01f, 4.90464717e-01f, 3.34670395e-02f, 8.35920684e-03f,
  -1.63565218e-01f, -1.99761003e-01f, -6.10810630e-02f, 7.50179365e-02f, 1.26315206e-01f, 1.22115418e-01f, -8.93640220e-02f, -1.10729903e-01f, -1.29968643e-01f, -6.90481532e-03f,
  8.91272277e-02f, -1.02503570e-02f, -1.20086052e-01f, 3.84454839e-02f, 1.10194832e-01f, 2.96858400e-02f, 3.25434618e-02f, -1.31546974e-01f, 6.26635700e-02f, -1.33660331e-01f,
  -3.10157947e-02f, 5.72663248e-02f, 1.52647018e-01f, -6.34120032e-02f, 6.69719204e-02f, 7.00916629e-03f, 6.10394515e-02f, -1.97547302e-02f, 2.45586615e-02f, -3.78572084e-02f,
  -1.33570448e-01f, -3.41245468e-04f, 3.08627319e-02f, -3.83321196e-02f, -9.05101374e-02f, 1.75261095e-01f, -5.75569365e-03f, 1.42608117e-02f, 3.23965214e-02f, 3.89602501e-03f,
  -3.93134877e-02f, -2.13728007e-02f, 3.14505845e-02f, -1.00018485e-02f, 3.86499278e-02f, -6.28784895e-02f, 6.26658574e-02f, 7.36976415e-02f, -8.89168214e-03f, -5.25406823e-02f,
  1.64294690e-02f, -8.81327689e-02f, -9.75074992e-03f, 5.97297437e-02f, -3.91746871e-02f, -4.66190875e-02f, 1.88277692e-01f, 4.67851982e-02f, -1.60899401e-01f, 2.56874748e-02f,
  -4.28704079e-04f, 5.91898337e-02f, 2.32061688e-02f, -4.42155078e-03f, -6.10711761e-02f, -3.75347696e-02f, -3.47519293e-03f, 1.27774581e-01f, 8.14970210e-02f, -8.39218870e-02f,
  1.41067922e-01f, 1.06615983e-01f, 1.40802056e-01f, -7.90999010e-02f, -5.75770065e-02f, -1.37511650e-02f, 1.73541885e-02f, 4.26989757e-02f, 1.02253236e-01f, 1.32656917e-01f,
  1.42983392e-01f, 1.30352333e-01f, -1.70107484e-02f, 1.61618114e-01f, 3.61938104e-02f, 7.29267821e-02f, -3.15505639e-03f, -6.28551692e-02f, 4.61824285e-03f, 6.63352385e-02f,
  -1.86556175e-01f, 7.03826904e-01f, -2.12790087e-01f, 3.53316247e-01f, -4.29924369e-01f, 6.31381154e-01f, 5.49944997e-01f, 4.47477214e-02f, 1.14659160e-01f, 6.96791768e-01f,
  1.47031307e-01f, 1.75125971e-01f, 3.35946709e-01f, 7.32102334e-01f, -2.11508110e-01f, 4.58615959e-01f, 6.69897079e-01f, 4.42292422e-01f, -6.96159378e-02f, 1.93148255e-01f,
  1.23906229e-02f, 3.35027337e-01f, 7.80449063e-02f, 5.89405224e-02f, -4.53854203e-02f, -2.34882221e-01f, -1.76874205e-01f, -3.84316891e-01f, 1.31088153e-01f, -1.46584302e-01f,
  -2.16609836e-02f, -7.34852161e-03f, -9.58223566e-02f, 1.19232638e-02f, 2.79295282e-03f, 8.50464627e-02f, -5.26106283e-02f, -7.56444260e-02f, -2.29370743e-01f, 4.75258790e-02f,
  9.79509950e-03f, 7.03855231e-02f, 7.88043812e-02f, 5.70725575e-02f, -4.26763967e-02f, -1.44415841e-01f, -5.17413914e-02f, -1.48804411e-01f, -2.41789464e-02f, -1.47613361e-01f,
  -5.75420819e-02f, 2.55686784e-04f, -3.80802415e-02f, 6.68926537e-02f, -1.37073547e-01f, 1.17993131e-01f, 1.46157846e-01f, -3.93322930e-02f, 6.40599281e-02f, 6.29263744e-02f,
  4.17751893e-02f, 3.41446139e-02f, 4.46565673e-02f, -1.62640035e-01f, -1.48772979e-02f, -9.33491066e-02f, 2.26896033e-02f, -2.05544159e-01f, -3.86097729e-02f, -2.16798540e-02f,
  -2.44993288e-02f, -7.19642565e-02f, -7.69801438e-02f, 1.22174308e-01f, 1.42782688e-01f, 4.45142500e-02f, -1.24052903e-02f, -5.04472642e-04f, -6.94350526e-02f, -8.13414752e-02f,
  9.07282811e-03f, 8.60649943e-02f, 7.50547722e-02f, -5.68824336e-02f, 8.17175880e-02f, -1.21010616e-01f, 6.61241934e-02f, -7.70679256e-03f, -1.66980922e-01f, -7.97665641e-02f,
  3.61160308e-01f, 6.00545645e-01f, 1.70674212e-02f, 3.94768380e-02f, 5.30167036e-02f, -2.70691570e-02f, -2.39126850e-02f, 1.62422568e-01f, 1.82095706e-01f, 6.74248338e-02f,
  -3.99982603e-03f, -1.65821742e-02f, 8.25317055e-02f, -9.71990973e-02f, 8.91507939e-02f, 1.52697906e-01f, 9.73841175e-02f, -2.21075583e-03f, 8.41220319e-02f, 9.40178521e-03f,
  3.68524007e-02f, 2.03001034e-02f, 4.25425060e-02f, -4.21782136e-02f, 6.50450662e-02f, -4.96049784e-03f, 1.34659279e-02f, -1.00518718e-01f, -4.13743667e-02f, 1.15231141e-01f,
  8.95648450e-02f, 4.10536796e-01f, 4.66496587e-01f, 3.39049548e-02f, 2.33820021e-01f, -6.23349138e-02f, -3.61086354e-02f, 1.88410878e-01f, 4.54482973e-01f, 1.37274250e-01f,
  -2.09323138e-01f, 4.23237562e-01f, -1.28458589e-01f, 1.73488036e-01f, -6.04464889e-01f, -3.71745944e-01f, -3.19054425e-01f, 4.84927893e-02f, 2.08819389e-01f, -1.16155213e-02f,
  -2.19584152e-01f, -4.71725821e-01f, -4.31706645e-02f, -4.18687053e-02f, 3.38710338e-01f, 2.76259094e-01f, -5.07634401e-01f, 1.67333893e-02f, -2.22147871e-02f, 1.69129614e-02f,
  1.39587775e-01f, 3.20034593e-01f, 1.88563615e-01f, 1.52027249e-01f, -3.89820971e-02f, -2.36544628e-02f, -1.06747225e-01f, 3.56027782e-02f, -5.60510829e-02f, 4.46472205e-02f,
  3.10777351e-02f, -2.21325178e-02f, -5.56962900e-02f, -1.32710617e-02f, 2.86311567e-01f, 1.76138982e-01f, 9.13937986e-02f, 1.67456150e-01f, 3.03606838e-01f, 1.74585566e-01f,
  2.39293188e-01f, 1.77251264e-01f, 1.66108366e-02f, 6.30055647e-03f, 1.06932269e-02f, 2.77464092e-01f, -2.72401422e-03f, -6.57299682e-02f, 3.66316810e-02f, 1.65655464e-01f,
  5.57835102e-02f, -1.73563033e-01f, -1.11642284e-02f, 2.21563742e-01f, -5.43335676e-02f, 8.63633379e-02f, -1.01700559e-01f, -2.08011121e-02f, 4.28378582e-02f, -2.07366701e-02f,
  -4.07774933e-02f, 1.17880605e-01f, -1.08366162e-01f, 4.48675863e-02f, -1.34260193e-01f, 6.35150895e-02f, -1.00785516e-01f, 3.90387475e-02f, 1.48992268e-02f, -4.42128107e-02f,
  -3.33821662e-02f, -4.30726632e-03f, -5.02451370e-03f, -2.29749866e-02f, 1.23988777e-01f, 4.88539115e-02f, 5.39553314e-02f, 2.16957316e-01f, 1.20257465e-02f, -1.88229516e-01f,
  -2.51242239e-02f, -1.49015233e-01f, 2.55402327e-02f, 9.93639380e-02f, -3.19614112e-02f, -8.95227864e-02f, 1.78489275e-02f, -2.27880459e-02f, 5.65963648e-02f, -7.55568966e-02f,
  -8.06081519e-02f, 4.52305824e-02f, -2.36467078e-01f, -6.60064816e-02f, -1.61451206e-01f, -1.45609617e-01f, -9.98071730e-02f, -1.06206931e-01f, -1.50612086e-01f, -1.10552289e-01f,
  -7.17252493e-02f, -1.58793889e-02f, 7.29120076e-02f, -9.30725336e-02f, -1.05977476e-01f, -4.08633314e-02f, 7.64328018e-02f, 2.38117963e-01f, -1.03057332e-01f, -1.33938342e-01f,
  4.99822348e-01f, 2.51227289e-01f, 2.37575784e-01f, 6.46046400e-01f, 4.21023428e-01f, 5.27332127e-01f, 3.91642898e-01f, 5.17619491e-01f, 1.01448083e+00f, -2.03086078e-01f,
  -3.19632053e-01f, 4.74538505e-02f, -3.34597170e-01f, 7.44801462e-02f, -1.10600173e-01f, 1.30899891e-01f, 3.10838789e-01f, 1.20673552e-01f, 4.29746032e-01f, 2.71999627e-01f,
  3.18837345e-01f, -6.20601289e-02f, -4.11881477e-01f, -7.41827041e-02f, 3.53138819e-02f, 1.04284331e-01f, -6.70641184e-01f, -5.14028706e-02f, -4.29818541e-01f, 1.81660429e-02f,
  -9.44135524e-03f, 1.07622311e-01f, -1.28625795e-01f, -2.92016566e-02f, 1.39977530e-01f, -6.67591542e-02f, -8.28078203e-03f, -1.20321721e-01f, 3.41457501e-03f, -1.11551061e-02f,
  3.64815220e-02f, -5.59712239e-02f, 4.78607491e-02f, 6.57415166e-02f, 1.84091344e-01f, 1.79701496e-03f, 2.38613430e-02f, 6.67939708e-02f, -3.41182798e-02f, -8.71807802e-03f,
  4.46547754e-02f, 2.28514634e-02f, 3.02895010e-02f, -5.31259552e-02f, 4.24557142e-02f, 1.12712793e-01f, 8.51212889e-02f, -1.19270589e-02f, -6.21880926e-02f, 1.80897832e-01f,
  2.73017511e-02f, 1.49686098e-01f, -8.40526596e-02f, -7.34251887e-02f, -2.04311609e-02f, -1.93586554e-02f, -1.03829894e-02f, -1.33002728e-01f, 1.69376522e-01f, -1.29663453e-01f,
  1.28815234e-01f, 1.11963050e-02f, 1.10960506e-01f, -2.91999299e-02f, 1.28529659e-02f, 7.29887411e-02f, -8.57905820e-02f, 7.33769238e-02f, 1.32066652e-01f, 3.69631611e-02f,
  2.29189880e-02f, 2.48757880e-02f, -1.76577047e-01f, -6.90583885e-02f, -2.17755907e-03f, -6.50368184e-02f, 2.15070304e-02f, 2.75777522e-02f, -2.39892360e-02f, -1.00528404e-01f,
  1.76986113e-01f, 3.50908041e-01f, -4.06544767e-02f, -2.81078797e-02f, -1.02702610e-01f, -1.22122981e-01f, 4.42241319e-02f, 1.16624996e-01f, 4.44182605e-02f, -5.04373398e-04f,
  7.16701820e-02f, 2.68018190e-02f, -1.04061112e-01f, 1.45731922e-02f, -9.74766240e-02f, 5.81299327e-02f, -4.97267358e-02f, 5.87430261e-02f, 3.03595290e-02f, -9.52959955e-02f,
  -2.00651467e-01f, 8.80455151e-02f, 1.07649853e-02f, 1.92801692e-02f, -3.10555995e-02f, -7.24797994e-02f, 7.43703768e-02f, 6.83700573e-03f, -8.43416303e-02f, -9.54506248e-02f,
  -1.30097985e+00f, 2.68186241e-01f, -4.70486790e-01f, -6.82763815e-01f, -4.37521003e-02f, -5.11304379e-01f, -1.99309811e-01f, 1.52293369e-02f, -2.40740459e-02f, 1.29243016e-01f,
  5.46671934e-02f, -1.74356997e-01f, 4.72982198e-01f, -1.82822183e-01f, -3.36224824e-01f, 6.31431580e-01f, -5.21503091e-01f, -1.51885271e-01f, 1.34994268e-01f, -2.81909525e-01f,
  -1.74762458e-01f, 9.97288525e-02f, -1.59106895e-01f, 3.16161066e-01f, -6.21048391e-01f, -2.61935204e-01f, -3.57240349e-01f, 1.62139192e-01f, -6.11589074e-01f, 5.69885923e-03f,
  -5.71953356e-01f, -9.57791060e-02f, -1.99699357e-01f, -1.65150598e-01f, -1.88644677e-01f, -1.64032534e-01f, -2.15398505e-01f, 8.11698847e-03f, -4.80381511e-02f, -8.32002088e-02f,
  -6.46131188e-02f, 7.17663839e-02f, -1.34934913e-02f, 6.02848232e-02f, -6.32352978e-02f, -2.28341818e-02f, 9.53402966e-02f, -1.51023537e-01f, 2.10671742e-02f, 5.10475971e-02f,
  9.54450741e-02f, 3.67868021e-02f, -1.84961095e-01f, -1.38653712e-02f, -5.31242453e-02f, -8.20393562e-02f, 4.20873016e-02f, -8.27974081e-03f, -1.96780682e-01f, -5.85638024e-02f,
  -2.63384301e-02f, -2.02877689e-02f, -5.18584549e-02f, 5.58386147e-02f, 6.36882186e-02f, 1.25145555e-01f, 6.72423989e-02f, 5.81036806e-02f, 2.02727579e-02f, 5.76041304e-02f,
  -4.51441221e-02f, 8.48028436e-02f, 1.12613909e-01f, -6.91946819e-02f, 4.03480195e-02f, 5.98630346e-02f, -5.69948964e-02f, -5.50929196e-02f, -7.81111792e-02f, -2.21814215e-02f,
  9.32249203e-02f, -3.76626663e-02f, 1.03705391e-01f, -3.44198979e-02f, -5.80023229e-02f, -1.21260555e-02f, -1.40193418e-01f, -5.69883548e-02f, -4.94635887e-02f, -1.54593155e-01f,
  -6.96487308e-01f, -4.57846701e-01f, -1.33744394e-02f, 2.24021487e-02f, -4.30749133e-02f, -1.71737164e-01f, -1.91488247e-02f, -1.46389917e-01f, -2.11332813e-01f, -1.02341324e-01f,
  -1.01536632e-01f, -1.35776564e-01f, -2.84840584e-01f, 4.13702242e-03f, 1.40739921e-02f, -1.00501604e-01f, -9.06734094e-02f, -5.67222498e-02f, -1.57203957e-01f, -7.75318593e-02f,
  -2.81335390e-03f, -1.89768374e-02f, 4.10848483e-02f, -1.03813764e-02f, -3.04444544e-02f, -1.40312687e-01f, -1.19894095e-01f, 1.29328594e-02f, -7.70266876e-02f, 3.31496671e-02f,
  2.49081347e-02f, -3.82717550e-02f, 1.08322695e-01f, 7.68344700e-01f, 9.79361683e-02f, -2.23682001e-01f, -2.36556515e-01f, 2.62148559e-01f, 9.33194757e-02f, -1.46773025e-01f,
  1.35237157e-01f, -5.03882878e-02f, -3.37684691e-01f, 5.83288193e-01f, 5.69899440e-01f, -1.83058739e-01f, 4.90663081e-01f, -1.14635073e-01f, -2.14209426e-02f, 1.96521729e-01f,
  4.02420461e-01f, 5.26325524e-01f, 5.28666079e-01f, 5.20789921e-01f, 2.89048076e-01f, 2.80651450e-01f, 3.85603249e-01f, 2.50458438e-02f, 5.00734687e-01f, 1.68297708e-01f,
  -1.06526650e-01f, 5.89570515e-02f, -3.27802077e-02f, -6.56316727e-02f, 5.68018705e-02f, -1.33616865e-01f, -1.34222433e-01f, 7.18542412e-02f, 2.96008158e-02f, 8.74881074e-02f,
  -9.05959979e-02f, 1.97329149e-02f, 1.45991161e-01f, -6.33254722e-02f, -3.44572365e-02f, 8.70429948e-02f, 1.02061979e-01f, 1.38800079e-02f, 4.98726033e-02f, -6.75652782e-03f,
  -5.51774725e-02f, 3.28896493e-02f, -5.71089312e-02f, 8.12977105e-02f, 1.82190046e-01f, 8.18284508e-03f, -9.66165736e-02f, -7.94959813e-02f, -6.05606250e-02f, 1.56739369e-01f,
  9.18846726e-02f, -2.27428243e-01f, -1.78288326e-01f, -7.53072724e-02f, 3.78532670e-02f, 2.17609685e-02f, -1.94819178e-02f, 4.38104756e-03f, -8.67210969e-04f, 5.43670841e-02f,
  5.49316630e-02f, 1.17374353e-01f, -1.36158481e-01f, -9.42252055e-02f, 6.56635612e-02f, -5.94807118e-02f, -5.66779524e-02f, -1.81319937e-02f, -1.02518328e-01f, -3.24289612e-02f,
  -2.13331133e-02f, 1.06255583e-01f, -9.33529735e-02f, 4.51046489e-02f, 1.05023727e-01f, 1.11111797e-01f, 7.65350908e-02f, 4.14868742e-02f, -1.83574319e-01f, -9.65976063e-03f,
  8.38306397e-02f, 3.75970215e-01f, 1.21236742e-01f, -7.24393800e-02f, 3.00987139e-02f, 6.05141185e-02f, 1.46751419e-01f, 1.76672414e-01f, 1.95800364e-01f, 4.65344004e-02f,
  8.73279646e-02f, -3.51561196e-02f, -1.43594414e-01f, -4.60200617e-03f, 2.39860173e-03f, 4.99988124e-02f, 1.00594364e-01f, 5.67842051e-02f, 2.25253895e-01f, 9.71477330e-02f,
  1.17866531e-01f, -5.21284118e-02f, -2.96414271e-02f, -5.76802064e-03f, 1.14063047e-01f, 6.60349429e-02f, -7.18807280e-02f, -2.71270368e-02f, -2.37809215e-02f, 1.09917723e-01f,
  6.89616382e-01f, 4.80368316e-01f, 4.48362619e-01f, 4.55172211e-01f, -4.11851048e-01f, -6.57464206e-01f, -3.18153560e-01f, -1.01769865e-01f, -1.02227859e-01f, 9.09072235e-02f,
  -2.75078118e-01f, 6.52083218e-01f, -7.87540376e-02f, 2.02946931e-01f, -2.22128302e-01f, -2.49505341e-01f, 1.15634941e-01f, -1.27400786e-01f, -1.30885849e-02f, 2.98646361e-01f,
  2.71310687e-01f, -2.49513552e-01f, 3.20024252e-01f, -2.17317656e-01f, 4.01688695e-01f, 4.34984326e-01f, -3.06873815e-03f, 1.23582119e-02f, 2.25561619e-01f, -2.42321730e-01f,
  -5.88286333e-02f, 1.07971393e-01f, 2.01694563e-01f, 5.35360090e-02f, 1.26180038e-01f, -3.63568552e-02f, 6.38247952e-02f, -4.97406907e-02f, -1.38214352e-02f, 9.78120714e-02f,
  1.01425409e-01f, -2.94783227e-02f, -7.00946711e-03f, -2.30595246e-01f, 3.63253877e-02f, 4.78906445e-02f, 5.25207631e-02f, 2.45106384e-01f, 2.78792065e-02f, 7.39838406e-02f,
  6.64419532e-02f, 2.33856320e-01f, 6.51498288e-02f, 1.03389740e-01f, 5.86036369e-02f, -1.06677160e-01f, -1.29892323e-02f, 9.20058936e-02f, 2.02856109e-01f, 3.43860947e-02f,
  7.30965063e-02f, -3.33613120e-02f, 3.39769199e-02f, -1.08855583e-01f, 7.21260458e-02f, 3.03232037e-02f, 1.49277210e-01f, -1.01208081e-02f, -6.31942740e-03f, -2.97314283e-02f,
  -6.77091926e-02f, -5.55424020e-02f, 1.07762609e-02f, -9.65907276e-02f, 4.20268402e-02f, 8.99046063e-02f, 5.88833988e-02f, -4.51043025e-02f, 2.96531967e-03f, 7.47937709e-03f,
  -1.17599823e-01f, -2.16312706e-02f, 1.27368728e-02f, -1.53967291e-02f, -2.60125309e-01f, -1.19961323e-02f, 1.54019549e-01f, 2.16373548e-01f, -1.28812626e-01f, 1.73246991e-02f,
  -1.20166093e-01f, 1.39602631e-01f, 9.76784434e-03f, -3.99325751e-02f, 2.39472790e-03f, -1.49547765e-02f, 7.91965146e-03f, 2.28959182e-03f, 5.25051504e-02f, 1.88433460e-03f,
  1.12793915e-01f, 3.80152725e-02f, -8.47131200e-03f, -9.62296724e-02f, -2.55921502e-02f, -7.19535872e-02f, 6.43781275e-02f, -7.52709731e-02f, 7.20685869e-02f, 8.09216797e-02f,
  5.35935573e-02f, -9.59973084e-04f, 1.90513406e-03f, -7.35962093e-02f, 1.23970732e-02f, 4.44437377e-02f, -5.33311591e-02f, -3.76441479e-02f, -3.28517593e-02f, 9.42584574e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  4.27727163e-01f, 7.66464293e-01f, 3.61134976e-01f, 9.95492399e-01f, 6.52460754e-01f, 4.86146152e-01f, 3.59053910e-01f, 5.31980097e-01f, 3.45273525e-01f, 3.17903489e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.86629325e-01f, -8.27377811e-02f, 9.90764797e-02f, 7.15087235e-01f, -4.98284400e-01f, -1.59030348e-01f, 1.32591933e-01f, 7.82251358e-02f, 5.00379920e-01f, 5.21487631e-02f,
  2.04128437e-02f, -2.32749403e-01f, 2.19720349e-01f, -2.78698564e-01f, -4.10853066e-02f, -2.61074990e-01f, -7.90444687e-02f, -1.08545564e-01f, 3.44523013e-01f, -4.79263455e-01f,
  -6.45530224e-02f, -3.03934962e-01f, -5.94401993e-02f, 3.80378902e-01f, -3.08105260e-01f, -2.70601183e-01f, 3.02880138e-01f, -2.22618043e-01f, -3.26926321e-01f, -1.17708124e-01f,
  -5.79957515e-02f, 3.93573761e-01f, 2.04837203e-01f, -1.84508011e-01f, 5.54571934e-02f, 3.26219723e-02f, -4.28091139e-01f, 6.36142552e-01f, -2.24132985e-02f, -3.02347362e-01f,
  -6.52020216e-01f, 3.12682569e-01f, 8.87232795e-02f, -1.47712544e-01f, 4.40692276e-01f, -5.45633771e-02f, 2.39770208e-02f, 9.32563469e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -2.06723347e-01f, 2.31409192e-01f, -1.56607807e-01f, -4.44560915e-01f, 5.58916330e-01f, 4.70161498e-01f, 2.21003313e-02f, -4.73809600e-01f, -6.92958951e-01f, -3.88026118e-01f,
  1.10839212e+00f, 1.41359001e-01f, 5.84224880e-01f, 1.17624438e+00f, 6.89290702e-01f, 5.78056812e-01f, 1.00407913e-01f, 5.10700703e-01f, -1.61806896e-01f, -9.91563857e-01f,
  -2.48047069e-01f, -2.94072181e-01f, 8.74441087e-01f, -5.09898126e-01f, 1.19635904e+00f, 4.45204943e-01f, 1.08261454e+00f, -9.15027738e-01f, -5.87925375e-01f, -1.21731788e-01f,
  5.56855679e-01f, -1.16828516e-01f, 7.82176793e-01f, 2.43586257e-01f, 1.20641470e+00f, -8.78944248e-02f, 8.02998364e-01f, -4.74898458e-01f, -1.46165401e-01f, 1.14731455e+00f,
  -8.13347518e-01f, -4.13726956e-01f, 6.13814592e-01f, 3.57293695e-01f, 6.96464419e-01f, 8.36756006e-02f, 2.31093943e-01f, 8.96152020e-01f, 7.12451100e-01f, 8.58812630e-02f,
  1.14475238e+00f, 6.87970638e-01f, 4.95245188e-01f, -7.97968268e-01f, 4.76073205e-01f, 9.80938435e-01f, -1.63754553e-01f, 7.49682665e-01f, -5.43996990e-01f, -1.08899638e-01f,
  3.73846084e-01f, 5.80236465e-02f, 4.37204599e-01f, -5.43064356e-01f, -5.58655858e-01f, 2.87509680e-01f, -9.79538441e-01f, 5.92631735e-02f, 6.07396543e-01f, -6.49873316e-02f,
  9.45534885e-01f, 7.00946987e-01f, -1.93542212e-01f, -1.71241239e-01f, -1.16359681e-01f, -8.05136114e-02f, -7.56555378e-01f, 1.08690763e+00f, 9.89194810e-01f, 1.14671625e-01f,
  3.55370700e-01f, 8.16500932e-02f, 4.76993948e-01f, 3.06599975e-01f, -1.00086808e+00f, -9.15383399e-02f, -4.17501330e-01f, -1.36870295e-01f, 8.21624935e-01f, -6.85505390e-01f,
  8.08100879e-01f, 8.12469125e-01f, 1.36526799e+00f, -6.01045966e-01f, 1.28990309e-02f, 9.07316387e-01f, 3.34244311e-01f, 1.24400742e-01f, 1.88837349e-01f, 9.00307000e-01f,
  -1.40309274e+00f, -7.46670887e-02f, 4.37246740e-01f, 6.80203259e-01f, 6.34021997e-01f, 7.84871876e-01f, -8.09737742e-02f, -1.66158348e-01f, 4.92857337e-01f, -7.95721054e-01f,
  8.12717378e-01f, 2.86949068e-01f, -4.86797541e-01f, 3.84430945e-01f, -5.24284065e-01f, -9.55353141e-01f, 2.19510049e-02f, 6.35739863e-01f, 2.15921536e-01f, -1.98830798e-01f,
  -1.02909692e-01f, 1.08743024e+00f, 2.64506228e-02f, 9.33039963e-01f, -4.66502339e-01f, 7.21492589e-01f, -6.53276503e-01f, 4.44131732e-01f, -6.28623366e-01f, -8.14955607e-02f,
  2.19189659e-01f, 1.75290421e-01f, 6.71462655e-01f, 2.84725517e-01f, 2.51542211e-01f, 9.63859558e-01f, 7.24334344e-02f, -2.02674806e-01f, -7.02933192e-01f, 8.57782066e-01f,
  -4.51407470e-02f, 3.75436813e-01f, -3.33205879e-01f, 1.02119911e+00f, 1.12592161e+00f, 3.92636389e-01f, 6.98790491e-01f, -1.04489207e+00f, 6.46916270e-01f, 2.27478936e-01f,
  -2.52220988e-01f, -2.38955811e-01f, 1.73886597e-01f, 1.09241533e+00f, 9.28650558e-01f, 9.46314991e-01f, -4.75473180e-02f, 5.56070268e-01f, -2.78003484e-01f, -3.73657852e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  3.05579633e-01f, 2.98566550e-01f, 1.74115494e-01f, 4.70154494e-01f, 4.86449987e-01f, -2.41853818e-02f, 4.74025369e-01f, 7.80856907e-01f, 7.66907632e-01f, 4.90963846e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  3.45913887e-01f, -1.56454891e-01f, -1.51980758e-01f, 4.04045992e-02f, 7.10763872e-01f, -6.71245754e-01f, 4.87274230e-01f, 5.39037228e-01f, -2.55080909e-01f, -1.35285127e+00f,
  2.20417837e-03f, -5.07231832e-01f, -1.34034741e+00f, 3.57842073e-02f, -9.12538648e-01f, 4.94966954e-01f, -9.11479414e-01f, 5.02424598e-01f, 5.71170002e-02f, 5.93629837e-01f,
  5.70060685e-02f, -8.51901650e-01f, -3.43504220e-01f, 7.39934564e-01f, -5.33311784e-01f, -1.00239587e+00f, -3.17566067e-01f, 4.83908206e-01f, 2.54381746e-01f, -6.84089720e-01f,
  -2.36532226e-01f, -2.17693448e-01f, -5.83809376e-01f, -2.84943014e-01f, -3.16364259e-01f, -2.11233180e-02f, -7.20813394e-01f, -3.73667210e-01f, -8.89895916e-01f, 3.46159995e-01f,
  -7.30173826e-01f, 5.83456874e-01f, 5.58152676e-01f, -8.92772615e-01f, 5.95639169e-01f, -6.23354495e-01f, -1.32889545e+00f, -8.42658639e-01f, -3.26608896e-01f, -8.09919536e-01f,
  5.21316640e-02f, -4.18043137e-01f, -2.86470205e-01f, 6.77494645e-01f, 1.06097624e-01f, -8.55344296e-01f, -1.18227339e+00f, -7.63605177e-01f, 1.10202223e-01f, -4.07469958e-01f,
  -8.55978072e-01f, 8.12579274e-01f, -2.01719850e-01f, 6.58079147e-01f, 2.20429346e-01f, 4.69849646e-01f, 6.40214205e-01f, -3.72495741e-01f, -2.95574516e-01f, -5.79758942e-01f,
  -2.12433338e-01f, -4.60762203e-01f, 3.66685212e-01f, 6.04266465e-01f, -1.59546837e-01f, -9.02977169e-01f, -5.38897216e-01f, -2.32024819e-01f, 2.23510135e-02f, 6.32798314e-01f,
  5.66657066e-01f, 1.23194128e-01f, 5.18232351e-03f, 6.58859611e-01f, -4.19906676e-02f, 8.08349073e-01f, 7.07672954e-01f, -6.87070429e-01f, 6.95364535e-01f, -2.43214220e-01f,
  -8.24465334e-01f, 4.72054332e-01f, -4.68771398e-01f, -1.24495351e+00f, -7.95854092e-01f, 2.15709865e-01f, -5.14711678e-01f, 2.94996947e-01f, 1.00437115e-04f, 2.78588086e-01f,
  -4.10972774e-01f, -3.57882977e-02f, -8.75749350e-01f, -1.04966414e+00f, 9.60564241e-02f, 2.11089492e-01f, -8.76533031e-01f, 8.01952720e-01f, 8.11318338e-01f, -1.04778898e+00f,
  -5.00660986e-02f, -8.14369082e-01f, 3.05919915e-01f, 1.70648158e-01f, 1.83646530e-01f, -5.31729877e-01f, -4.68771815e-01f, -5.06708562e-01f, 4.63308901e-01f, -6.71591282e-01f,
  -5.96627593e-01f, -5.78596234e-01f, 8.10458601e-01f, -5.16517699e-01f, -8.37692738e-01f, 4.62836117e-01f, 7.16862917e-01f, -1.11983287e+00f, 2.10900977e-01f, -5.26687503e-01f,
  -1.58931613e-01f, -3.68852794e-01f, 5.90666652e-01f, 7.69108772e-01f, 6.10560477e-01f, 9.03286189e-02f, 1.82307512e-01f, -6.66423798e-01f, 5.93407691e-01f, -3.45992267e-01f,
  1.45052299e-01f, -5.76400816e-01f, -3.98555309e-01f, -1.08388007e+00f, 1.17560618e-01f, -2.61510909e-01f, -2.25630552e-01f, 4.15753245e-01f, 9.79958117e-01f, -4.11517233e-01f,
  -9.74585831e-01f, -6.14341736e-01f, 4.75652874e-01f, 4.96407181e-01f, 4.89138097e-01f, -1.01461184e+00f, 2.81234205e-01f, -9.85783517e-01f, 2.51027554e-01f, -1.39335072e+00f,
  3.74734551e-01f, 4.94202822e-02f, -1.58055812e-01f, 1.78830758e-01f, -4.98209894e-01f, 6.65921211e-01f, -7.46074975e-01f, 2.01028094e-01f, -8.96211922e-01f, 4.44910415e-02f,
  -1.26264179e+00f, -7.00107098e-01f, 5.17175674e-01f, 6.96124017e-01f, -9.38862026e-01f, 3.78448814e-01f, -3.40492159e-01f, 2.62014326e-02f, -3.41071397e-01f, -6.21693492e-01f,
  4.95185554e-01f, -3.57058533e-02f, -2.54072249e-01f, -8.52782428e-01f, 4.13094133e-01f, -9.47507799e-01f, -1.05957162e+00f, 5.22974014e-01f, -2.80095100e-01f, 2.82016605e-01f,
  6.48453474e-01f, -6.11798167e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.80269796e-02f, -3.39888074e-02f, 1.25024766e-02f, -2.33169734e-01f, 2.56314546e-01f, 1.14047423e-01f, 1.88583687e-01f, 3.56585644e-02f, -1.65150985e-01f, 1.67771295e-01f,
  2.40444735e-01f, -3.26470375e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    