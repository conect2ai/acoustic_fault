/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.25628781e-01f, -2.25169018e-01f, -6.71008155e-02f, 2.96688050e-01f, 4.74671349e-02f, 1.76011622e-01f, 1.80282637e-01f, 3.53133529e-02f, 2.85331517e-01f, -2.14118347e-01f,
  1.34392813e-01f, -8.08713399e-03f, -1.00316793e-01f, 1.03982717e-01f, 4.38482255e-01f, 1.57494005e-02f, 2.04834267e-01f, 5.28215803e-03f, 1.08199865e-01f, 1.01620361e-01f,
  1.38397351e-01f, 2.15120569e-01f, 1.49480077e-02f, -1.20835133e-01f, -1.35698561e-02f, -1.11582190e-01f, -3.44057083e-02f, -1.53293163e-01f, -7.83020556e-02f, 1.15018710e-02f,
  6.23167157e-02f, -2.73388475e-02f, -3.40862833e-02f, -7.42739812e-02f, 7.27914870e-02f, 1.56140071e-03f, 1.36903524e-02f, 3.35891731e-02f, 2.92438436e-02f, 2.00620126e-02f,
  -4.38093729e-02f, 6.24234490e-02f, 9.74737778e-02f, 1.50374835e-02f, 2.22909953e-02f, 1.96621567e-02f, -8.15520659e-02f, -8.08102265e-02f, 6.57868609e-02f, -6.19870313e-02f,
  -4.45215739e-02f, -5.23535497e-02f, -2.36861892e-02f, -3.23116519e-02f, -1.38798896e-02f, 2.96533648e-02f, -3.05267237e-02f, -7.99118429e-02f, 6.23074137e-02f, 8.32173228e-02f,
  1.64272655e-02f, 6.81133987e-03f, -5.25835939e-02f, -1.57696605e-02f, 4.28609066e-02f, -2.52142008e-02f, 2.22621486e-03f, 3.36623341e-02f, -6.47307858e-02f, 2.90708821e-02f,
  4.42251787e-02f, -3.90087292e-02f, 5.23249209e-02f, -2.86478475e-02f, -3.04574501e-02f, 5.87031953e-02f, -4.07265052e-02f, -1.05280295e-01f, 1.62117463e-02f, 2.24937238e-02f,
  -2.30605751e-02f, -9.07637179e-03f, -3.14099826e-02f, -3.88966985e-02f, -9.16757621e-04f, 1.92024801e-02f, 3.89521159e-02f, -8.42128769e-02f, 2.30390187e-02f, 4.65657562e-02f,
  4.41898331e-02f, 7.60843009e-02f, 2.72919796e-02f, -8.14141799e-03f, -9.09380168e-02f, -3.87427807e-02f, 6.71408102e-02f, -5.39690815e-02f, 2.28612293e-02f, -7.34387082e-04f,
  -5.10460325e-02f, -2.30253451e-02f, -1.31644877e-02f, -3.34282070e-02f, 1.68595668e-02f, 1.39313452e-02f, 1.67024806e-02f, -1.01432847e-02f, 7.92030524e-03f, 2.82599926e-02f,
  -2.70323753e-02f, 4.56383303e-02f, 6.37364089e-02f, -1.01935985e-02f, -2.46756570e-03f, -3.32111306e-02f, 4.62791808e-02f, -4.66302084e-03f, -4.56712656e-02f, -4.67547290e-02f,
  5.80859184e-01f, 1.08514518e-01f, 5.54658398e-02f, 5.88992126e-02f, 2.55941242e-01f, 3.33252072e-01f, 1.65872887e-01f, 1.96759701e-02f, 9.53155162e-04f, 4.11198139e-02f,
  4.82634595e-03f, 2.12375894e-02f, -1.36716187e-01f, 3.49679850e-02f, 3.38489786e-02f, -2.18700618e-01f, 1.50632203e-01f, -1.15894442e-02f, -1.13294341e-01f, 9.20858309e-02f,
  3.61797288e-02f, -6.91171661e-02f, -1.12362221e-01f, 1.72118712e-02f, 2.07718313e-01f, 3.02943662e-02f, -1.42509220e-02f, 7.78649300e-02f, 1.22823320e-01f, 6.27788715e-03f,
  -1.31264506e-02f, -9.62696746e-02f, -2.25884281e-02f, -1.12365939e-01f, 8.86787325e-02f, 6.41797930e-02f, 1.17728323e-01f, -1.16557807e-01f, -3.08951177e-02f, -6.88388124e-02f,
  4.74014170e-02f, -4.55930717e-02f, -5.00611924e-02f, -4.66273464e-02f, 7.62947798e-02f, -3.06925867e-02f, 3.81251425e-02f, 2.81183831e-02f, -8.38181898e-02f, 4.28666957e-02f,
  -3.52347493e-02f, -1.00992806e-02f, 6.86002523e-02f, 1.87113006e-02f, -3.48922797e-04f, -3.02873310e-02f, -1.03832528e-01f, 4.90705930e-02f, 1.07976552e-02f, 4.48110290e-02f,
  3.03166825e-02f, 1.78817622e-02f, 1.44556863e-02f, -4.98314155e-03f, -2.67827548e-02f, -1.13060686e-03f, 5.78276403e-02f, -7.88720921e-02f, 5.65107651e-02f, 5.44724911e-02f,
  1.52944103e-02f, 1.33946901e-02f, 5.97565994e-02f, 7.17665777e-02f, 5.44699617e-02f, 2.72406712e-02f, -3.68831605e-02f, -2.43211258e-02f, 7.64542148e-02f, 1.54692177e-02f,
  -3.00485007e-02f, -1.91375315e-02f, -4.99098301e-02f, 2.67919376e-02f, 2.22995151e-02f, 4.33571786e-02f, 4.38400023e-02f, -5.46730310e-03f, -2.29286384e-02f, 1.16745077e-01f,
  -4.80208360e-03f, -3.60300974e-03f, -3.63842063e-02f, 2.15013837e-03f, -7.41636455e-02f, 3.99561487e-02f, -3.21910232e-02f, 4.84336428e-02f, -6.65688068e-02f, 9.99006927e-02f,
  -1.87593251e-02f, 6.19459152e-03f, 3.88676040e-02f, 3.79620865e-02f, -1.62888654e-02f, 7.87212625e-02f, -8.66604820e-02f, -1.47880334e-02f, 2.56961659e-02f, -6.59472048e-02f,
  6.86426088e-02f, 7.64313191e-02f, -4.96231951e-02f, -7.62237534e-02f, -7.83886202e-03f, 3.79424058e-02f, 1.57816380e-01f, 9.44057107e-03f, 1.04772262e-02f, 5.46217384e-03f,
  1.62888646e-01f, -1.95569426e-01f, -2.13658869e-01f, 1.14197165e-01f, -2.25536168e-01f, 6.74424991e-02f, 1.91757262e-01f, -1.54761940e-01f, 8.81976187e-02f, 9.31315962e-03f,
  1.88900039e-01f, -1.06951579e-01f, 3.16724479e-01f, -6.86064214e-02f, 2.48953477e-01f, 2.93648958e-01f, 1.17460243e-01f, 7.89916515e-02f, 3.46987136e-02f, -4.35616523e-02f,
  -4.31460068e-02f, 2.06532627e-01f, -5.47745563e-02f, -2.39688799e-01f, -2.49919131e-01f, -1.47999838e-01f, 1.54760748e-01f, -8.08097273e-02f, -1.28927141e-01f, 7.80883059e-02f,
  -9.31821615e-02f, -5.63580804e-02f, -1.10578239e-01f, -6.71372041e-02f, 2.47460511e-02f, 4.49396968e-02f, -1.09284697e-02f, 5.18520214e-02f, -1.60150118e-02f, -1.49873951e-02f,
  -4.37452272e-02f, -2.93396763e-03f, 8.82539898e-02f, 8.84962305e-02f, -1.42198801e-01f, -1.13591798e-01f, 2.27081403e-03f, -1.70221757e-02f, -1.79434463e-01f, -5.00188358e-02f,
  7.09802331e-03f, -6.68450966e-02f, -7.12153986e-02f, 4.16067988e-02f, -4.04078327e-02f, -9.87933278e-02f, -3.91712151e-02f, -6.45409152e-02f, -1.72858946e-02f, -1.80265103e-02f,
  1.06035821e-01f, -5.00940308e-02f, -2.71734837e-02f, -8.20093974e-02f, 1.07763633e-02f, -1.81466684e-01f, -6.11255467e-02f, -2.50040926e-02f, -4.27376144e-02f, 1.60669144e-02f,
  -3.51343071e-03f, -8.03114921e-02f, -6.19021989e-03f, -2.81254221e-02f, 7.14345649e-03f, -1.27919286e-01f, 1.54926032e-02f, 1.34528214e-02f, -1.33317681e-02f, -4.63978723e-02f,
  -2.18896624e-02f, -4.47059423e-02f, -2.39929184e-02f, -4.97329049e-02f, -6.61671609e-02f, -7.02588186e-02f, -4.10147645e-02f, -7.52525702e-02f, -1.00718932e-02f, 9.58282575e-02f,
  2.31441543e-01f, 2.11821392e-01f, 3.31132114e-02f, 3.14051732e-02f, -3.06767635e-02f, 1.01504780e-01f, -2.40869801e-02f, -3.58897299e-02f, 1.03020169e-01f, 1.08619124e-01f,
  -7.16999397e-02f, -8.94770697e-02f, 4.30870391e-02f, 2.82313097e-02f, 4.68889549e-02f, 1.70820747e-02f, 4.80621122e-02f, -8.08639277e-04f, 3.30463387e-02f, -9.88079328e-03f,
  -1.23108883e-04f, -5.79385227e-03f, 4.97396439e-02f, -1.68695189e-02f, 2.79194433e-02f, 1.34240622e-02f, -7.03455927e-03f, 9.78363445e-04f, 8.02731588e-02f, -2.04724763e-02f,
  6.26837552e-01f, 4.55844291e-02f, 1.47250369e-02f, 4.03119773e-01f, -1.11791119e-01f, -1.67076275e-01f, 1.09137461e-01f, -6.72031567e-03f, 2.67272592e-01f, 4.99569736e-02f,
  -6.88088313e-03f, 1.76277310e-01f, -5.64361960e-02f, 1.53503582e-01f, 1.72946796e-01f, 1.44341871e-01f, 2.52149910e-01f, 2.77294040e-01f, 2.06064638e-02f, -2.22837646e-02f,
  6.93384558e-02f, 7.80158909e-03f, 3.67726386e-02f, -2.25274891e-01f, -3.87572031e-03f, 1.85558088e-02f, 3.15928422e-02f, -2.18156189e-01f, 7.37149715e-02f, -9.42011699e-02f,
  1.18481606e-01f, 6.44338056e-02f, -1.99420354e-03f, 7.68884271e-02f, -5.87999672e-02f, 4.99199517e-02f, -1.66328182e-03f, -3.85295576e-03f, -2.96862293e-02f, -2.27024481e-02f,
  -4.71660076e-03f, -4.05989103e-02f, -2.05561668e-02f, 8.23545922e-03f, 1.29432634e-01f, -2.90367529e-02f, -7.42511377e-02f, 2.00566817e-02f, -4.58393333e-04f, 8.83582979e-02f,
  -8.35015252e-02f, -3.93746309e-02f, 6.08267523e-02f, 2.34327675e-03f, -1.03212535e-01f, -6.99903294e-02f, -3.01665394e-03f, -1.28941923e-01f, 3.56104858e-02f, -6.56666458e-02f,
  -1.38821844e-02f, -3.84857319e-02f, 8.28959607e-03f, 9.71387774e-02f, -3.27119380e-02f, 3.36310156e-02f, -6.85477406e-02f, 4.79110703e-02f, 2.75748260e-02f, -2.21151975e-03f,
  1.69860739e-02f, 1.80613529e-02f, 3.39302085e-02f, 2.96906196e-02f, 1.54795032e-02f, 3.73345576e-02f, 9.73821729e-02f, -7.00599281e-03f, 8.29560757e-02f, 7.07987994e-02f,
  3.05352509e-02f, 2.56902073e-03f, -1.49854133e-02f, 1.17630638e-01f, -8.26539174e-02f, -8.11321437e-02f, -4.82238382e-02f, 1.08792502e-02f, -8.34650174e-02f, 1.84742734e-02f,
  1.34873405e-01f, -1.58527307e-02f, 1.22557832e-02f, -4.45917547e-02f, 3.70921567e-02f, -7.38729909e-03f, 5.44131137e-02f, -1.10558875e-01f, -3.62372100e-02f, -5.11455312e-02f,
  -7.05879228e-03f, 5.25359735e-02f, -5.16584553e-02f, 5.68530448e-02f, -3.59853283e-02f, 4.50559855e-02f, -5.74712688e-03f, -2.91997269e-02f, -6.96194321e-02f, 2.49721911e-02f,
  5.28378785e-02f, -2.25079395e-02f, -7.77785182e-02f, 1.71106309e-02f, 7.04218224e-02f, 2.48563401e-02f, 4.20059413e-02f, -3.41941901e-02f, -3.58255915e-02f, -9.12071206e-03f,
  -1.13909699e-01f, 2.47929886e-01f, 1.70522138e-01f, -5.38115948e-02f, -1.10001549e-01f, -4.98372316e-02f, 1.65171385e-01f, 2.21431982e-02f, 3.48534137e-01f, -1.79032803e-01f,
  -2.43104640e-02f, -1.96550384e-01f, 1.94872767e-01f, -1.34364679e-01f, -9.64167491e-02f, 4.20737386e-01f, -9.45435092e-02f, -1.48891449e-01f, 2.49283552e-01f, -2.76563436e-01f,
  9.09764767e-02f, -2.77688563e-01f, -1.11306822e-02f, -1.12108901e-01f, -6.66219518e-02f, -3.28305066e-02f, -3.59063864e-01f, 1.44814283e-01f, -3.64848047e-01f, 1.44149497e-01f,
  1.31618828e-01f, 1.90581530e-01f, -1.88688224e-03f, 1.28020033e-01f, -7.97737539e-02f, -6.05017617e-02f, -1.55922934e-01f, 1.38147483e-02f, 3.18365805e-02f, 3.41659300e-02f,
  -2.95696761e-02f, -1.12392940e-01f, -4.42862418e-03f, 5.08763716e-02f, -1.85319483e-02f, 6.98853936e-03f, -9.76697821e-03f, 1.16582112e-02f, -5.82958795e-02f, 3.42535935e-02f,
  1.06551684e-01f, -2.31982991e-02f, 1.19603844e-02f, -4.61391956e-02f, -3.65295894e-02f, 4.43968624e-02f, -2.88967453e-02f, -6.03960790e-02f, 5.01959063e-02f, -2.10121907e-02f,
  -1.70249045e-02f, 6.58102334e-02f, -5.13366759e-02f, 1.22378515e-02f, -4.78427149e-02f, 7.27744401e-02f, 2.33547315e-02f, -2.17456408e-02f, 5.98560683e-02f, -5.30780554e-02f,
  -1.00162663e-01f, -2.95928158e-02f, 6.85450211e-02f, -5.61601780e-02f, -1.11796111e-01f, -2.54324675e-02f, -5.88818081e-02f, -9.33456176e-04f, -3.56304497e-02f, -8.87886062e-02f,
  6.12598173e-02f, 6.73764348e-02f, -3.88914011e-02f, 7.95546640e-03f, 1.16867095e-01f, -9.38649103e-02f, 4.54801507e-03f, 1.57877896e-02f, 5.43867648e-02f, -3.83778140e-02f,
  -1.19143941e-01f, -5.36788478e-02f, 3.34020844e-03f, 1.50001161e-02f, 1.22742742e-01f, -5.90808839e-02f, 1.41412228e-01f, -7.87841976e-02f, -7.04678521e-02f, 1.05572175e-02f,
  -1.51714817e-01f, -9.75577384e-02f, 3.39216664e-02f, -3.93887386e-02f, 1.02457805e-02f, -1.66714992e-02f, 5.38315624e-02f, -7.37076402e-02f, -4.89627570e-02f, -5.98717295e-02f,
  -6.18760511e-02f, -9.48336422e-02f, -7.33010322e-02f, -1.06799126e-01f, -6.59336969e-02f, -7.45481625e-02f, -9.06544477e-02f, 1.51733365e-02f, 4.47067246e-02f, 5.02731316e-02f,
  2.76242997e-02f, -9.52637345e-02f, 4.24446851e-01f, -1.65103693e-02f, -1.61154225e-01f, 2.99717456e-01f, 2.72750854e-01f, -1.60993695e-01f, 1.46402359e-01f, -2.48066947e-01f,
  -3.83030549e-02f, -1.26175910e-01f, 3.01320255e-01f, -1.15333162e-01f, 3.73442501e-01f, 2.57945001e-01f, -8.20894353e-03f, -8.28001425e-02f, 1.12386085e-01f, -1.11510433e-01f,
  7.25255609e-02f, -2.92796463e-01f, 4.07682061e-02f, -9.20869336e-02f, -1.68820724e-01f, -2.18624379e-02f, -2.36708984e-01f, 1.49885416e-01f, -2.08649889e-01f, -1.12058101e-02f,
  -1.11037187e-01f, -7.87924305e-02f, -5.93847558e-02f, 2.71432474e-02f, -1.48980930e-01f, 3.48762982e-02f, 2.75456645e-02f, 1.10910609e-01f, 8.82386565e-02f, -1.17417646e-03f,
  -9.63793695e-02f, 9.50911567e-02f, -5.06796176e-04f, -4.68091033e-02f, -5.99229448e-02f, 5.67015894e-02f, -4.23295656e-03f, -1.83130801e-02f, 2.69526243e-03f, -6.88214460e-03f,
  2.51289681e-02f, 1.31664192e-02f, -5.42021655e-02f, -3.88653204e-02f, 1.40144497e-01f, 1.16327733e-01f, 4.31376584e-02f, 1.78562303e-03f, -6.91416264e-02f, -7.27468133e-02f,
  3.88310961e-02f, 7.37570925e-03f, -1.03247550e-03f, -6.11539260e-02f, 4.16044854e-02f, -4.95586209e-02f, -6.35654107e-02f, -1.83239393e-02f, 3.11126746e-02f, -1.17636295e-02f,
  -7.62867332e-02f, -8.63065105e-03f, -5.36004826e-02f, 2.37988811e-02f, -7.51417652e-02f, -4.73302789e-02f, -2.28882115e-02f, -6.32819384e-02f, 5.01239393e-03f, 3.22471373e-02f,
  -2.69822888e-02f, -1.65501982e-02f, -2.33411137e-02f, -2.06807591e-02f, -5.36196567e-02f, 2.62209568e-02f, -5.05179027e-03f, -1.58376116e-02f, 2.49996185e-02f, 1.10036165e-01f,
  -1.98222026e-01f, -2.39438891e-01f, 6.34020790e-02f, -6.44933954e-02f, -3.42226848e-02f, -7.65256956e-02f, 3.66343674e-03f, 1.06041227e-02f, 9.27961320e-02f, -1.84330419e-02f,
  1.23028876e-02f, -5.54187484e-02f, -8.05968791e-02f, -3.48205343e-02f, 3.40185761e-02f, 1.01178128e-03f, -3.86279286e-03f, -3.95521224e-02f, -1.14800431e-01f, -2.20727036e-03f,
  -3.06722578e-02f, -3.07251420e-02f, 1.39412701e-01f, -1.08101759e-02f, -9.38761160e-02f, -8.60256180e-02f, -1.11210145e-01f, 5.64946756e-02f, -2.11672522e-02f, -7.17352377e-03f,
  2.91817516e-01f, -6.60031363e-02f, -9.19598565e-02f, 1.79357771e-02f, 1.79077908e-01f, 2.44351521e-01f, 8.02679639e-03f, 1.94190368e-01f, -6.35599121e-02f, -6.60203695e-02f,
  8.44360813e-02f, -1.02855287e-01f, -6.45544799e-03f, -4.97337990e-02f, 2.25464165e-01f, -7.21111894e-02f, 7.15676770e-02f, -1.50833875e-01f, 5.04408479e-02f, 1.80466279e-01f,
  3.89930233e-02f, 1.66945726e-01f, 4.03347313e-02f, 3.21980380e-02f, 4.33380250e-03f, -8.20320025e-02f, 1.62455879e-04f, 1.64878387e-02f, -2.99298260e-02f, -4.21640053e-02f,
  1.22100301e-01f, 1.46980071e-02f, 2.11950392e-02f, -1.67999655e-01f, 1.00332968e-01f, -6.51176125e-02f, 2.09613256e-02f, -1.19083762e-01f, 4.36483659e-02f, 9.32620242e-02f,
  -2.69487053e-02f, 8.95709768e-02f, 4.96832989e-02f, -7.68196657e-02f, -6.95851147e-02f, 3.26183029e-02f, -1.36253852e-02f, 3.36183310e-02f, -1.44174872e-02f, -5.07184900e-02f,
  -9.80223045e-02f, 1.74354743e-02f, -8.36713091e-02f, -7.32735246e-02f, -2.09199898e-02f, -4.64852452e-02f, -4.33085822e-02f, 8.43567774e-03f, 5.25068454e-02f, 1.07730515e-01f,
  -4.00612354e-02f, -3.41076963e-02f, -5.36545441e-02f, -1.61981732e-02f, -3.57877016e-02f, -2.74537038e-02f, -2.76319701e-02f, -8.58503506e-02f, -1.08169630e-01f, 2.18847953e-03f,
  1.28170401e-01f, -6.38281880e-03f, -1.42260725e-02f, -1.25388131e-02f, -5.64755388e-02f, 1.11330729e-02f, 4.69093919e-02f, -6.38458505e-02f, -3.92091833e-02f, -4.89540473e-02f,
  -6.77997246e-02f, 5.68057119e-04f, -1.71214864e-02f, -7.35510811e-02f, -9.39263438e-04f, -6.64630309e-02f, -1.02932595e-01f, -2.47934870e-02f, 2.40136757e-02f, 1.21685460e-01f,
  1.09980427e-01f, 1.75946847e-01f, -5.25548570e-02f, 1.12032248e-02f, -1.04902171e-01f, -5.20719402e-02f, -3.09700314e-02f, 9.87253059e-03f, 1.16290962e-02f, 9.95045230e-02f,
  1.83520690e-02f, -1.80391744e-02f, 4.27633300e-02f, -4.76179868e-02f, -4.88438793e-02f, -1.97737124e-02f, 4.47226539e-02f, -1.89543907e-02f, 3.87815945e-02f, -8.66252743e-03f,
  1.23129552e-02f, -1.75465420e-02f, 1.47517994e-02f, 4.90723178e-02f, -4.06498788e-03f, 2.15771142e-02f, 1.83651801e-02f, -6.03770763e-02f, 2.18627527e-02f, -8.24050382e-02f,
  -5.43358803e-01f, 1.20831907e-01f, -4.11787368e-02f, -1.10209636e-01f, -2.68580884e-01f, -1.01659395e-01f, -3.55240047e-01f, -3.69912535e-02f, 1.51322186e-01f, 8.56706500e-02f,
  -2.06575036e-01f, -3.15448493e-01f, -1.12928055e-01f, -4.09619361e-02f, -2.76768029e-01f, 2.03043371e-01f, 1.86075762e-01f, 4.45920415e-02f, 1.15836993e-01f, -1.02037229e-01f,
  3.70952627e-03f, -1.54834673e-01f, -1.73026681e-01f, 1.12175241e-01f, -1.60339326e-01f, 7.61197284e-02f, -2.58768778e-02f, -1.09870341e-02f, -2.43690633e-03f, -4.60634306e-02f,
  -3.63451764e-02f, -4.24313731e-02f, -9.80849937e-02f, 1.08297244e-02f, -7.61464834e-02f, -9.06419605e-02f, -6.30604103e-02f, -1.66296348e-01f, -7.08374903e-02f, 1.08333435e-02f,
  8.17114860e-03f, -6.29269704e-02f, -6.83374191e-03f, -5.70573919e-02f, -5.41940741e-02f, 3.90249640e-02f, 6.70773908e-03f, 4.77895848e-02f, -1.88698936e-02f, -1.04290970e-01f,
  -6.15908355e-02f, -1.83641203e-02f, 4.17140201e-02f, -1.56508107e-02f, -5.33427745e-02f, -2.83865780e-02f, -6.49226904e-02f, -2.43357364e-02f, 9.86858532e-02f, -5.70831914e-03f,
  -4.62783799e-02f, 3.54399346e-02f, 2.31877193e-02f, -7.39594996e-02f, 5.11302948e-02f, -2.12526061e-02f, 5.57558946e-02f, -4.11782637e-02f, -5.14771156e-02f, -1.14320643e-01f,
  4.80512083e-02f, -8.92593190e-02f, 1.16176248e-01f, -5.67529500e-02f, 4.06389795e-02f, -1.63986593e-01f, -8.08666646e-02f, -5.96754253e-02f, 3.62159312e-02f, -9.22603458e-02f,
  2.93864794e-02f, 4.09187004e-02f, 5.77124245e-02f, 7.20154345e-02f, 7.52617493e-02f, -3.02887335e-02f, 7.93399103e-03f, 4.16082330e-02f, -6.33680634e-03f, 8.70218687e-03f,
  1.40939042e-01f, 1.89571023e-01f, 8.57256725e-02f, 3.17953676e-02f, 1.40475139e-01f, 1.47580197e-02f, 9.62751731e-02f, 2.59197205e-02f, 1.35885522e-01f, 1.18143409e-01f,
  -1.08063310e-01f, 1.02364324e-01f, 1.11508049e-01f, -4.52937298e-02f, 1.56478863e-02f, -2.95649525e-02f, -3.44713852e-02f, 2.69432496e-02f, 7.16496864e-03f, -8.75609592e-02f,
  -8.65212157e-02f, 5.56186736e-02f, 1.02913119e-02f, -4.60003875e-03f, -7.07427859e-02f, -2.97328364e-02f, 5.46863377e-02f, 1.01847894e-01f, 8.20580646e-02f, -2.83466857e-02f,
  2.72337377e-01f, -3.56883138e-01f, -2.88389921e-02f, -3.32865030e-01f, 1.57382816e-01f, 1.97941214e-01f, -8.11308697e-02f, -4.57915850e-02f, 9.41323712e-02f, -1.93785816e-01f,
  -4.86493781e-02f, -1.49680719e-01f, 7.83212576e-03f, -1.63086995e-01f, 5.13589263e-01f, 1.36084929e-01f, 5.13357148e-02f, -8.91894624e-02f, 4.24472392e-02f, -4.92470227e-02f,
  8.97875130e-02f, -5.23573672e-03f, -2.18637623e-02f, 2.27014162e-02f, -4.23619710e-02f, -1.41080365e-01f, 3.07071283e-02f, -9.83959958e-02f, -7.94465914e-02f, 4.11167070e-02f,
  7.87776858e-02f, -1.74730226e-01f, -8.64953622e-02f, 4.63269576e-02f, 9.27389264e-02f, 4.10500867e-03f, -1.43483747e-02f, -1.51170753e-02f, -5.99330431e-03f, -9.34030488e-02f,
  3.63046341e-02f, 6.72055557e-02f, 7.85701349e-03f, 2.18073896e-04f, -3.43038030e-02f, -2.28829421e-02f, -8.35737493e-03f, 1.12757459e-03f, -1.00182325e-01f, 1.17845815e-02f,
  -4.54850458e-02f, 1.68552622e-02f, -3.52900140e-02f, 3.26649398e-02f, 9.78655666e-02f, -6.72889575e-02f, -4.39158082e-03f, 3.83227579e-02f, 2.40053441e-02f, 7.61378706e-02f,
  4.47382852e-02f, 2.45604739e-02f, -6.91501498e-02f, -5.69119044e-02f, -6.88783452e-02f, 3.07019847e-03f, -3.39972861e-02f, 3.85475717e-02f, -8.25879499e-02f, 8.54069367e-03f,
  3.02612092e-02f, -5.37528656e-02f, -4.01325747e-02f, 1.10261620e-03f, 1.84303857e-02f, -6.17289953e-02f, -1.81714743e-02f, -6.44314513e-02f, 1.40166015e-03f, -1.87506191e-02f,
  -1.87177360e-02f, -2.70164385e-03f, -6.38059452e-02f, 3.73963676e-02f, 1.99396703e-02f, 9.73513499e-02f, -4.95987991e-03f, -3.04057430e-02f, -4.60255854e-02f, -2.04230240e-03f,
  2.10504904e-02f, -1.20070316e-01f, -2.44553238e-02f, 1.30500942e-02f, -5.28793074e-02f, 5.53172454e-02f, 7.66546801e-02f, 4.88624088e-02f, -1.96522456e-02f, 2.59012193e-03f,
  3.67769562e-02f, -4.96594161e-02f, 5.53287119e-02f, -3.40746939e-02f, 3.83877307e-02f, 5.00494651e-02f, -4.05799150e-02f, 5.95515885e-04f, -2.81525496e-02f, -3.60219963e-02f,
  -4.28897366e-02f, 2.23386604e-02f, 5.68264946e-02f, 1.94574054e-02f, 7.11430013e-02f, 6.01531286e-03f, -2.57417504e-02f, -1.42422244e-02f, 7.84029588e-02f, -2.18204670e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.66395694e-01f, -3.34534436e-01f, 7.97242224e-02f, -1.30697697e-01f, -2.04399154e-01f, -1.84256628e-01f, 1.31746948e-01f, -3.84428531e-01f, -5.31588271e-02f, -2.59917349e-01f,
  -2.81623811e-01f, 2.53482789e-01f, 4.30596113e-01f, -5.46918273e-01f, 6.72220170e-01f, 3.10902327e-01f, -2.94509649e-01f, -1.78722385e-02f, -9.51569751e-02f, -2.31958911e-01f,
  -3.68839651e-02f, -5.12190104e-01f, 1.44773304e-01f, -5.83607614e-01f, -3.14820319e-01f, -2.62493044e-01f, 5.13269342e-02f, 1.76291317e-02f, -4.04252440e-01f, -1.14184543e-02f,
  -4.68831062e-02f, -1.65779710e-01f, -1.00482658e-01f, 9.12928768e-03f, -4.59041521e-02f, 5.63126095e-02f, -2.18077283e-02f, 1.99506074e-01f, 8.21895748e-02f, 7.27185397e-04f,
  9.39291492e-02f, -2.49698628e-02f, -2.52983987e-01f, 1.10046476e-01f, -1.15889035e-01f, -7.53372982e-02f, -7.49226147e-03f, -6.96687326e-02f, 4.24165465e-03f, 9.91702974e-02f,
  8.96505732e-03f, -6.04865253e-02f, -3.09006982e-02f, 3.72283496e-02f, 5.33537008e-02f, -1.85360238e-01f, 1.04338042e-01f, 1.47581249e-01f, -1.54614048e-02f, -2.62781437e-02f,
  -8.37845281e-02f, 8.89406130e-02f, 4.19872180e-02f, -8.61405209e-02f, 2.32094273e-04f, -1.06373109e-01f, -2.88025127e-04f, 4.19432931e-02f, -3.56410965e-02f, -4.06855084e-02f,
  -1.27663603e-02f, -2.30249763e-02f, -7.82526210e-02f, 8.18461925e-02f, -3.13405469e-02f, 8.71320534e-03f, 5.59309423e-02f, -4.43122610e-02f, -6.31723627e-02f, -3.78665403e-02f,
  4.09892807e-03f, 6.95937499e-02f, -3.69702727e-02f, 2.46656835e-02f, -1.34111438e-02f, 1.10091813e-01f, -7.97103718e-02f, 7.82668516e-02f, 6.10886747e-03f, 1.41567737e-02f,
  -4.73454967e-02f, -1.09790459e-01f, -2.87185758e-02f, -3.83765325e-02f, 7.10699111e-02f, -7.88848177e-02f, -7.12016076e-02f, -1.63877219e-01f, 5.63907921e-02f, -4.88397479e-02f,
  -1.19208224e-01f, 6.98699579e-02f, 8.73634871e-03f, -1.38516286e-02f, 2.21499763e-02f, -5.60716949e-02f, 1.05307810e-01f, 5.85275963e-02f, 7.43165165e-02f, -1.38340563e-01f,
  8.57016258e-03f, 6.90714791e-02f, 7.74465725e-02f, -9.22251791e-02f, -1.15077473e-01f, 1.71435580e-01f, 3.56904743e-03f, 5.68346120e-02f, 6.22205436e-02f, 3.67083214e-02f,
  5.20853281e-01f, 3.51456925e-02f, -2.47887447e-01f, -2.13953957e-01f, -3.47561575e-02f, 1.21170118e-01f, 3.01252510e-02f, 7.73774087e-03f, -1.75055116e-01f, 6.71902448e-02f,
  1.85644940e-01f, -1.23985238e-01f, 6.56866049e-03f, 1.55484706e-01f, 1.89839721e-01f, -1.23266213e-01f, 1.86534420e-01f, 3.79014201e-02f, -7.05683231e-02f, 2.22874552e-01f,
  1.56584233e-01f, 5.38655102e-01f, -1.06883116e-01f, 1.30718768e-01f, 9.65698957e-02f, -5.27000129e-02f, 2.09814250e-01f, -3.05329353e-01f, 4.00897898e-02f, 8.49448238e-03f,
  2.78938785e-02f, 2.31243037e-02f, -3.91183719e-02f, -8.93685147e-02f, 7.77596934e-03f, 9.11503807e-02f, -7.55770057e-02f, 1.70954280e-02f, -9.50325206e-02f, 5.70912426e-03f,
  5.91812506e-02f, -4.10265923e-02f, 8.20507333e-02f, -3.15183476e-02f, 8.10796171e-02f, -2.21125796e-01f, -6.54210746e-02f, -1.94967568e-01f, -1.27547786e-01f, 1.89739361e-01f,
  -7.92672485e-02f, 6.16191961e-02f, -1.41658187e-02f, -1.12113737e-01f, -3.36284973e-02f, -1.69541035e-02f, -1.08576454e-01f, -5.85435629e-02f, -4.63530757e-02f, -5.82352690e-02f,
  1.39553487e-01f, -1.53228538e-02f, 1.99362472e-01f, -8.78476910e-03f, 3.67781147e-02f, -3.87086570e-02f, 2.51041707e-02f, 1.63393151e-02f, 7.17553198e-02f, -3.03379353e-03f,
  -4.91455980e-02f, 9.78148282e-02f, -4.26481329e-02f, 7.45507479e-02f, 2.04617053e-01f, 3.32409851e-02f, 1.31793264e-02f, 3.79462242e-02f, -8.92478600e-02f, -9.02388096e-02f,
  -6.72977641e-02f, 5.64233996e-02f, 2.72247737e-04f, -1.23706073e-01f, -1.15769334e-01f, 1.30381621e-02f, 1.77482203e-01f, 1.49597405e-02f, -5.03010638e-02f, -2.00903248e-02f,
  2.53178515e-02f, 2.14434460e-01f, -1.66057497e-02f, -2.48411782e-02f, -1.25825644e-01f, 1.03202388e-01f, -9.37773511e-02f, 1.54064238e-01f, 9.10029337e-02f, 1.18234210e-01f,
  1.03634946e-01f, -6.76545501e-02f, 1.26233146e-01f, -9.19698775e-02f, -9.64084491e-02f, 7.14513585e-02f, 1.11063048e-01f, -1.51181638e-01f, -1.13723181e-01f, 1.02607541e-01f,
  4.81784008e-02f, 1.38253734e-01f, -5.89624494e-02f, -1.21045001e-02f, -1.31980497e-02f, -2.50263847e-02f, -7.73673654e-02f, 2.31755320e-02f, 1.96798801e-01f, -7.43911192e-02f,
  7.90224850e-01f, 4.02397186e-01f, 2.90994167e-01f, 5.47331929e-01f, -9.86954421e-02f, 1.14364125e-01f, 3.32536280e-01f, 7.99955949e-02f, 5.03142118e-01f, 7.58210495e-02f,
  -2.53278941e-01f, 5.55404663e-01f, -3.09945703e-01f, 2.66121000e-01f, -1.81566909e-01f, -1.22542612e-01f, 3.95711452e-01f, 3.38027924e-01f, 2.08275020e-01f, 2.32314646e-01f,
  1.55250743e-01f, -2.68925399e-01f, -2.70616025e-01f, -2.61295229e-01f, 7.45267570e-02f, 1.53733909e-01f, -5.09797692e-01f, -2.00358719e-01f, -4.82421815e-02f, -1.21482290e-01f,
  -1.61299352e-02f, 8.19059908e-02f, -8.62354413e-03f, 7.33589679e-02f, 1.75906774e-02f, 1.70057584e-02f, -1.22784963e-02f, -1.38041183e-01f, -1.22071747e-02f, 8.52168202e-02f,
  1.72875389e-01f, -8.73418227e-02f, 9.29210410e-02f, -1.06500193e-01f, 1.03861026e-01f, 1.30827725e-01f, 5.60493432e-02f, 8.62174761e-03f, 9.67488065e-03f, -3.50651853e-02f,
  1.29176006e-01f, 2.68024746e-02f, 1.03342764e-01f, -1.78621411e-02f, -1.24180764e-02f, 5.47384657e-02f, 7.16702268e-02f, -3.38090695e-02f, -1.38161448e-03f, 6.08813539e-02f,
  -3.64661589e-02f, 8.59615393e-03f, -7.22393245e-02f, -2.50198673e-02f, -1.30762309e-02f, -1.15524091e-01f, 7.02646822e-02f, -1.29385263e-01f, 9.19806138e-02f, -5.03701158e-02f,
  1.85529292e-02f, 3.82037573e-02f, -3.45748477e-02f, 4.11485359e-02f, 1.34711429e-01f, 2.52755247e-02f, -3.43459733e-02f, -3.67335938e-02f, 1.15956873e-01f, -7.44561851e-02f,
  -4.12172340e-02f, 4.25758734e-02f, -7.79224634e-02f, -8.51639956e-02f, 2.53228042e-02f, -2.43676268e-02f, -7.07440674e-02f, 5.23137674e-02f, 2.74887383e-02f, 1.31109450e-02f,
  6.93082586e-02f, 6.66233152e-02f, 1.63926035e-02f, -1.69789908e-03f, 2.45239325e-02f, 4.98876199e-02f, 3.92703228e-02f, 1.44124985e-01f, 6.10606074e-02f, -4.99273650e-02f,
  5.65818138e-02f, 9.30965617e-02f, 7.04214675e-03f, -1.08691342e-02f, 3.04590743e-02f, -1.69066757e-01f, -8.11777078e-03f, 6.77321479e-03f, 7.24069476e-02f, -5.74221499e-02f,
  1.06588495e-03f, 1.19835854e-01f, 5.59102297e-02f, 4.64872420e-02f, 5.79904616e-02f, -4.19564955e-02f, 1.31034195e-01f, 1.22790664e-01f, -1.11427240e-01f, -2.58985013e-02f,
  -8.01970124e-01f, 5.83601058e-01f, -1.17173515e-01f, 3.33191127e-01f, -1.57962829e-01f, 8.08056951e-01f, 5.44240832e-01f, 1.87226802e-01f, 3.32899272e-01f, 4.26683068e-01f,
  1.26195163e-01f, -3.48273031e-02f, 1.03797697e-01f, 4.47894424e-01f, 2.37921864e-01f, 4.07593429e-01f, 4.16489333e-01f, 2.13177279e-01f, 8.04928690e-02f, 4.41272855e-02f,
  -4.59502749e-02f, 1.42810121e-01f, -6.94237351e-02f, -4.17664787e-03f, -3.23659092e-01f, -3.32449049e-01f, -1.22438408e-01f, -1.08672813e-01f, 2.32287645e-02f, -9.84450616e-03f,
  -1.56761035e-01f, -2.70476669e-01f, -2.88731158e-01f, -1.31471947e-01f, 1.26918420e-01f, -7.92709738e-02f, -3.99157368e-02f, -9.53921527e-02f, -1.02355242e-01f, -1.01051200e-02f,
  6.07186966e-02f, -1.21714489e-03f, -1.17535917e-02f, 3.27068046e-02f, 2.16133939e-03f, -5.29858768e-02f, -1.15703978e-01f, -6.03084126e-03f, 8.93265083e-02f, -1.96252882e-01f,
  -5.27585596e-02f, -6.34424249e-03f, 1.61761995e-02f, 1.41893491e-01f, -7.39206523e-02f, 1.22924536e-01f, 1.30683973e-01f, -8.51800293e-02f, -9.31370165e-03f, 5.84550127e-02f,
  -5.06778285e-02f, 6.22360148e-02f, -5.54992594e-02f, -6.49026856e-02f, -5.22156246e-02f, -1.29341722e-01f, 5.46331890e-02f, -8.24096873e-02f, -7.20477626e-02f, 2.70005874e-02f,
  7.25593939e-02f, -2.45935656e-02f, -1.36060594e-02f, 4.06093970e-02f, 3.88796926e-02f, 3.55099030e-02f, -5.72853647e-02f, 4.58128471e-03f, 6.68341964e-02f, 1.14286855e-01f,
  -2.04102304e-02f, 5.46320006e-02f, -4.83843274e-02f, -7.72725046e-02f, 9.55134407e-02f, 3.71788591e-02f, 7.56568462e-02f, -5.20125218e-02f, -3.45172100e-02f, -8.89249668e-02f,
  3.93844008e-01f, 3.17018747e-01f, 5.22478707e-02f, 3.83197283e-03f, 4.19338560e-03f, -4.26167250e-03f, 7.50604570e-02f, 1.18998792e-02f, 1.12457439e-01f, 1.24333054e-02f,
  -3.94237265e-02f, 4.99222428e-02f, -2.19971910e-02f, -9.94877238e-03f, 1.09021395e-01f, 1.20903626e-01f, 1.31558150e-01f, 7.27691650e-02f, 1.49650514e-01f, -6.16919771e-02f,
  -3.02446596e-02f, 3.59820612e-02f, 5.14485058e-04f, 2.05383846e-03f, 5.05216159e-02f, 1.63435303e-02f, 1.02345839e-01f, -1.23154819e-01f, -7.75267631e-02f, 1.29568502e-01f,
  -4.53629971e-01f, 1.88661322e-01f, -5.06955147e-01f, -3.85061383e-01f, -3.70814204e-01f, -4.42147553e-01f, -3.47700596e-01f, -2.21258728e-03f, 1.45333096e-01f, 3.22367281e-01f,
  -6.80804476e-02f, 2.98933208e-01f, 4.63119149e-01f, -6.71958923e-02f, -2.84990132e-01f, 4.31880176e-01f, -3.08519602e-01f, -6.52490780e-02f, 7.29445517e-02f, -2.31252164e-01f,
  -2.06779927e-01f, 6.24702172e-03f, -2.67670631e-01f, -1.49941389e-02f, -4.83039796e-01f, -2.06028283e-01f, -6.91108108e-02f, -1.45303145e-01f, -3.02439332e-01f, -8.53679329e-02f,
  -5.30834854e-01f, -6.81053028e-02f, -1.06973760e-01f, -2.07953975e-01f, -2.79433101e-01f, -7.74566457e-02f, -1.81120679e-01f, 1.48224272e-02f, -5.04386351e-02f, 1.22236468e-01f,
  1.00221783e-01f, 3.27405371e-02f, 4.81007919e-02f, 1.17467739e-01f, -3.20424996e-02f, 5.87656861e-03f, -2.12405138e-02f, -2.44477078e-01f, 1.45581481e-03f, -1.50586516e-02f,
  -4.93509136e-02f, -9.93747041e-02f, -1.38366401e-01f, 7.10928738e-02f, -9.51719210e-02f, -1.51301876e-01f, -5.81097491e-02f, -9.34665352e-02f, -1.00627452e-01f, -9.92374197e-02f,
  -1.08789690e-02f, -4.63090017e-02f, 1.08979484e-02f, 8.96680430e-02f, 6.70622811e-02f, -1.33443223e-02f, -7.38176610e-03f, -1.72738731e-02f, -6.14236183e-02f, 1.48324631e-02f,
  -1.06751462e-02f, -1.89883895e-02f, 9.26649943e-03f, -6.94271326e-02f, 6.16146903e-03f, 1.06896609e-01f, 1.14427283e-01f, -1.06335662e-01f, 2.10475698e-02f, -5.71819767e-02f,
  2.82916836e-02f, -6.77725747e-02f, 1.87702980e-02f, -1.68477863e-01f, -1.14384875e-01f, 5.09070531e-02f, 2.88157687e-02f, -1.02199927e-01f, -3.11901085e-02f, -6.32013083e-02f,
  -6.24894083e-01f, -5.08633196e-01f, 1.27868336e-02f, -4.72383313e-02f, -3.54115516e-02f, -6.61771819e-02f, 3.09263561e-02f, -5.36164157e-02f, -1.55361474e-01f, -3.69356461e-02f,
  -7.31261224e-02f, 1.04853055e-02f, -2.27329165e-01f, -1.88007765e-02f, 7.32072666e-02f, -5.82989790e-02f, -8.61115083e-02f, 8.29102248e-02f, -2.06992075e-01f, -2.07046755e-02f,
  -2.58242972e-02f, 1.45297214e-01f, 1.31736264e-01f, 4.56026150e-03f, 5.41964807e-02f, -1.84362565e-04f, -2.57174019e-03f, -3.35199647e-02f, -1.75052121e-01f, -7.99314864e-03f,
  7.00147226e-02f, -2.41077077e-02f, -4.03081477e-02f, 2.39162102e-01f, -1.52850837e-01f, -3.70975494e-01f, -3.63199353e-01f, 5.29520288e-02f, -3.21122676e-01f, -6.06037788e-02f,
  -3.87915596e-02f, -8.55628103e-02f, -2.92350799e-01f, 9.70756784e-02f, 1.40311629e-01f, -2.30149105e-01f, 3.55305761e-01f, 7.63111487e-02f, -9.76349860e-02f, 1.74397931e-01f,
  1.37666136e-01f, 1.28758088e-01f, 6.54122084e-02f, 2.01020941e-01f, 7.90017769e-02f, 2.44826898e-01f, 5.40920854e-01f, -1.34196226e-02f, 4.97736305e-01f, 1.04434714e-01f,
  -1.32008627e-01f, 3.61403115e-02f, 9.61651877e-02f, -1.82625223e-02f, 1.22592323e-01f, -9.99305546e-02f, -1.03163727e-01f, 3.11989114e-02f, -3.05071403e-03f, 1.08361967e-01f,
  -8.01138729e-02f, 8.54130238e-02f, 6.55540684e-03f, 2.55971216e-02f, -1.15631737e-01f, 4.10465747e-02f, -3.37317772e-02f, 5.18592522e-02f, -6.80737793e-02f, 4.64481562e-02f,
  -4.04618122e-02f, -9.01025832e-02f, 1.45288408e-01f, 1.41355991e-01f, 9.90804955e-02f, 7.81794563e-02f, 1.41475154e-02f, -3.76108959e-02f, 1.75214484e-01f, 1.70626432e-01f,
  2.81820237e-03f, 6.82525858e-02f, -1.15194879e-01f, -1.43810567e-02f, 8.11387077e-02f, -9.03358459e-02f, -3.20731737e-02f, 5.22383116e-02f, 7.39376917e-02f, -8.83401930e-03f,
  -1.80209503e-02f, -1.39766395e-01f, -5.56872189e-02f, 6.83928700e-03f, -4.14365083e-02f, -3.31346914e-02f, -1.75455101e-02f, -5.20599559e-02f, -2.03621527e-03f, -1.46167234e-01f,
  -3.32043655e-02f, 1.04796372e-01f, -1.14613622e-01f, -9.70617458e-02f, 7.58281648e-02f, 3.24466079e-03f, -1.84716117e-02f, 5.07398956e-02f, -1.71967596e-02f, -7.29870796e-02f,
  1.20903604e-01f, 2.88268089e-01f, -1.09097309e-01f, -8.37458000e-02f, -4.53849472e-02f, -1.15470596e-01f, 5.70742860e-02f, 3.24722864e-02f, 1.02554053e-01f, -1.09864086e-01f,
  1.24343738e-01f, -1.64901353e-02f, 3.68895195e-02f, 3.76094505e-02f, 1.03015572e-01f, 9.60594714e-02f, 6.90074265e-02f, 7.09677264e-02f, 1.59578338e-01f, 7.82431513e-02f,
  9.77111012e-02f, -1.21168233e-01f, 1.05036780e-01f, -1.59431562e-01f, 1.08322501e-02f, 9.95076634e-03f, 8.50463361e-02f, 8.80507454e-02f, 3.28836665e-02f, 1.09045915e-01f,
  -3.42984140e-01f, -6.08917892e-01f, 4.96593341e-02f, -1.78268805e-01f, 2.23104492e-01f, 1.07369728e-01f, 8.57331082e-02f, -5.40895641e-01f, -6.19716406e-01f, -4.93656665e-01f,
  1.41522037e-02f, 2.95773447e-01f, -9.72017422e-02f, -1.62252620e-01f, 6.02502465e-01f, -4.91873026e-02f, -2.37838283e-01f, 2.75949419e-01f, -8.51109847e-02f, -3.03238869e-01f,
  6.41140714e-02f, 4.05853242e-02f, 2.45609641e-01f, -1.21931575e-01f, -4.27855551e-02f, -9.84171107e-02f, 1.55463457e-01f, 2.71914065e-01f, 1.05973378e-01f, 3.90328199e-01f,
  -2.19526619e-01f, -5.49708784e-01f, -2.64635161e-02f, 9.51111540e-02f, -7.46773705e-02f, 3.54993120e-02f, 2.41366133e-01f, 2.81696558e-01f, 1.96973328e-03f, 5.32854237e-02f,
  1.60740837e-01f, -1.30697805e-02f, -6.02081185e-03f, 1.00845292e-01f, -1.11442797e-01f, -1.57447115e-01f, -2.74453685e-02f, -9.67727154e-02f, -9.74802151e-02f, -1.47758657e-02f,
  -7.78091103e-02f, 9.70381722e-02f, -8.93402547e-02f, -3.85629460e-02f, -6.89813420e-02f, -1.14149593e-01f, 6.62030354e-02f, 1.58802018e-01f, 4.08954471e-02f, -1.35343269e-01f,
  -5.69459284e-03f, 8.65790471e-02f, -8.85955915e-02f, 3.39844683e-03f, -8.90234038e-02f, 4.65543661e-03f, -1.41494712e-02f, 5.28711788e-02f, 4.26864550e-02f, -1.44071683e-01f,
  -2.84301545e-02f, -4.49758507e-02f, -1.56819731e-01f, -1.11981973e-01f, 3.46766710e-02f, -8.99478942e-02f, 1.10591903e-01f, -4.16441122e-03f, -1.45017914e-02f, -1.78201981e-02f,
  3.95262800e-02f, -3.74021865e-02f, -1.08953367e-03f, -3.30949761e-02f, -5.12064397e-02f, 3.22172567e-02f, -6.81796595e-02f, -5.08528389e-02f, 1.92259941e-02f, 2.02962920e-01f,
  -2.47450158e-01f, -4.38258886e-01f, -6.61752149e-02f, -1.24421008e-02f, -3.02685611e-03f, 2.90137883e-02f, 1.82840917e-02f, -1.55131429e-01f, -7.94328526e-02f, -9.61755067e-02f,
  4.38969322e-02f, 9.17096362e-02f, 4.61093560e-02f, -8.78265128e-02f, 1.57961994e-01f, -1.41958773e-01f, -3.30195390e-02f, 7.39833564e-02f, 1.62832551e-02f, -5.76160625e-02f,
  -5.56895845e-02f, -5.21989679e-03f, 1.62342668e-01f, -6.96841478e-02f, -3.35746296e-02f, 1.05776414e-01f, 3.31745856e-02f, -8.54268745e-02f, 5.27508706e-02f, -7.38716265e-03f,
  2.81595141e-01f, 6.17047966e-01f, 4.31472242e-01f, 6.82527363e-01f, -3.26447606e-01f, -1.61478240e-02f, 2.89622784e-01f, -7.25330040e-02f, 1.97772518e-01f, 1.61947906e-01f,
  -1.91407040e-01f, 4.99302745e-01f, 2.02166606e-02f, 2.15473488e-01f, -7.51251727e-02f, 1.14921093e-01f, 2.52302140e-01f, 1.16862103e-01f, 6.29493743e-02f, 2.35658035e-01f,
  1.27858475e-01f, 7.68062174e-02f, 2.39939913e-01f, -1.34734988e-01f, 1.97680026e-01f, 1.91641241e-01f, 4.17784192e-02f, -4.07868102e-02f, 1.21630721e-01f, -1.56620875e-01f,
  -1.69779658e-01f, 1.79641142e-01f, 7.23461881e-02f, 1.33955225e-01f, 2.20805909e-02f, 2.51812544e-02f, 7.24055395e-02f, 4.79684062e-02f, -1.07559465e-01f, 1.21688493e-01f,
  2.22626366e-02f, 4.47470881e-03f, 1.18917353e-01f, -1.56798139e-02f, 3.30643001e-04f, 1.01448655e-01f, -1.06723711e-03f, -4.79526781e-02f, 1.32370606e-01f, -1.00943953e-01f,
  -3.20703611e-02f, -2.45474130e-02f, -1.14560910e-01f, 1.16871290e-01f, 1.76087078e-02f, 5.86258844e-02f, 1.24672562e-01f, 8.92508999e-02f, 1.97370142e-01f, 3.44698913e-02f,
  -1.64341070e-02f, 5.64132817e-02f, 1.01294138e-01f, 1.44271068e-02f, -2.43142303e-02f, 5.10220416e-02f, 7.64467865e-02f, -1.63531587e-01f, 5.35389856e-02f, 1.00031104e-02f,
  1.44881280e-02f, 4.21077088e-02f, -1.75130386e-02f, 1.19598992e-01f, 1.56118935e-02f, 1.12040430e-01f, 2.79779695e-02f, 7.91108832e-02f, 3.93195897e-02f, -1.02512740e-01f,
  4.91592772e-02f, 1.18572600e-02f, 8.24766532e-02f, -1.08940080e-01f, -1.05514470e-02f, -3.87095707e-03f, 1.06431343e-01f, 8.38321727e-03f, -9.16419737e-03f, -6.85834363e-02f,
  1.48858532e-01f, 3.55418712e-01f, 5.41852117e-02f, 2.21327711e-02f, -3.34696770e-02f, 3.58940959e-02f, 8.80462900e-02f, 3.90060395e-02f, 5.67731969e-02f, 9.03846994e-02f,
  1.41607672e-02f, 1.53023237e-02f, 2.36046780e-03f, -7.33355805e-02f, 4.14466253e-03f, 1.04012206e-01f, 1.84524357e-01f, 9.78491455e-02f, 2.32928805e-02f, 4.74816412e-02f,
  6.20580986e-02f, 1.66176587e-01f, 4.45249071e-03f, -1.37892161e-02f, 2.43101493e-02f, 3.92963691e-03f, -2.51703896e-02f, -4.14939187e-02f, -6.14811666e-03f, 1.56005351e-02f,
  4.56191182e-01f, -6.92770004e-01f, -2.08844230e-01f, 6.07985616e-01f, 4.53477949e-01f, -1.29987001e-01f, 7.27151483e-02f, 7.42317364e-03f, 3.48045886e-01f, -4.89549518e-01f,
  1.11195065e-01f, -2.73484617e-01f, -4.56885546e-01f, 3.26343358e-01f, 5.29368281e-01f, -3.78421515e-01f, 2.52663255e-01f, 8.95233974e-02f, 2.64360961e-02f, 1.53003380e-01f,
  4.17210430e-01f, 3.89919281e-01f, 4.68930714e-02f, -6.57443032e-02f, 1.24767199e-01f, -2.01502312e-02f, 1.38847828e-01f, -3.35472763e-01f, 1.15923390e-01f, 8.06462169e-02f,
  5.96975945e-02f, 8.89231786e-02f, 1.33851334e-01f, 1.46674765e-02f, -4.43377607e-02f, -4.41898070e-02f, -4.88849878e-02f, 1.60116740e-02f, 1.87666222e-01f, -1.28064752e-02f,
  -8.43527094e-02f, 2.48926524e-02f, 6.24013692e-02f, 1.74855087e-02f, 2.41757259e-02f, 8.90140533e-02f, 3.36752571e-02f, -2.15383079e-02f, -6.00062832e-02f, -1.18203677e-01f,
  -8.01424980e-02f, -1.05930373e-01f, 1.75919876e-01f, -4.74265218e-02f, 3.28768790e-02f, 1.15094118e-01f, -8.03913325e-02f, -1.41569436e-01f, 7.74586247e-03f, -4.47848402e-02f,
  -5.82959019e-02f, -4.59802151e-02f, -8.02311525e-02f, -2.50949088e-04f, 1.16140768e-02f, 1.29104763e-01f, -2.96684187e-02f, -1.01578377e-01f, -9.25392359e-02f, -6.33994341e-02f,
  9.53775197e-02f, 7.80417025e-02f, 4.51773265e-03f, -4.50060740e-02f, 3.74997519e-02f, 4.42716219e-02f, -2.79211737e-02f, 5.42134605e-02f, -1.85269006e-02f, 3.80729325e-02f,
  5.44932634e-02f, 5.06934896e-02f, -1.90679450e-02f, 1.32281082e-02f, 3.74365859e-02f, 4.13039653e-03f, -1.63776167e-02f, -1.06011391e-01f, 5.47967032e-02f, -1.51921719e-01f,
  -1.86249420e-01f, -4.70697433e-01f, -1.13369256e-01f, 6.43322244e-02f, -7.64633641e-02f, 1.29833063e-02f, -7.87204653e-02f, 1.12586580e-02f, -9.76857319e-02f, -1.13359457e-02f,
  -3.79931331e-02f, 1.05547898e-01f, -1.41415223e-01f, 7.77282789e-02f, 7.67518058e-02f, 1.60041859e-03f, -5.17739169e-02f, 3.98520054e-03f, 9.53509659e-02f, -6.50139153e-02f,
  -5.43297343e-02f, 2.89521683e-02f, -2.16614362e-02f, 2.20662765e-02f, 3.17139439e-02f, -4.17736769e-02f, 2.77508143e-02f, -4.69889641e-02f, -7.99613819e-02f, -5.04563600e-02f,
  7.34743774e-02f, -5.40676489e-02f, -3.72164398e-01f, -1.88245371e-01f, -1.61126003e-01f, 5.37162781e-01f, 4.87929493e-01f, -3.54053140e-01f, -5.07104516e-01f, 2.55082399e-01f,
  4.26022679e-01f, -2.53849268e-01f, 1.53921753e-01f, 6.22328460e-01f, 1.51265740e-01f, 4.18522805e-01f, 5.17823219e-01f, 4.02126670e-01f, -1.77254289e-01f, -3.91198769e-02f,
  -6.01061471e-02f, 5.68554819e-01f, 3.93536121e-01f, -2.17188466e-02f, 3.73645097e-01f, -4.15666133e-01f, -5.47989160e-02f, -2.07573444e-01f, 2.94707060e-01f, 8.85770097e-02f,
  2.16183886e-01f, -1.13270253e-01f, -2.31082514e-02f, -4.79098447e-02f, 6.02763034e-02f, 8.08171332e-02f, 8.63637310e-03f, 1.01138271e-01f, -5.15484959e-02f, -1.31207118e-02f,
  -5.24094049e-03f, -1.20829508e-01f, 1.53252026e-02f, -7.16033131e-02f, -4.65748161e-02f, -5.33809327e-02f, -5.10098189e-02f, -5.23932874e-02f, -7.03049898e-02f, 3.79041061e-02f,
  -2.18673400e-03f, -1.67958196e-02f, -7.81665323e-04f, 6.53893966e-03f, -9.05235559e-02f, -8.53693187e-02f, 1.12752756e-02f, 3.78858559e-02f, -7.13887736e-02f, -3.99272479e-02f,
  -4.97085880e-03f, 3.92862670e-02f, 1.64780244e-02f, 9.77932662e-02f, 4.20651622e-02f, 1.28489345e-01f, 6.31716326e-02f, 5.64110354e-02f, -1.07086241e-01f, 8.92618671e-02f,
  -1.92484688e-02f, -5.40852509e-02f, -1.52924343e-03f, 3.09199430e-02f, 4.91350479e-02f, -2.37061288e-02f, 9.27890241e-02f, -2.09437925e-02f, 2.84533091e-02f, -3.76156718e-02f,
  4.73314673e-02f, -5.27922623e-02f, 4.65025567e-02f, 1.44004896e-01f, 6.90484196e-02f, -9.34537351e-02f, 1.30868331e-02f, -1.74820982e-02f, 4.68774922e-02f, 3.25436629e-02f,
  5.91392778e-02f, -2.80478656e-01f, -7.22456202e-02f, -1.74342317e-03f, -1.04491608e-02f, -3.14624459e-02f, -6.09689616e-02f, -1.92735046e-02f, -5.73604964e-02f, 1.70814712e-02f,
  6.24565594e-02f, 1.49768023e-02f, -8.01511407e-02f, 1.11356387e-02f, -1.02114446e-01f, 1.04090057e-01f, 5.92741072e-02f, -4.48321216e-02f, -1.14026733e-01f, -7.47478753e-02f,
  -4.09679636e-02f, -2.96438914e-02f, 1.35754924e-02f, 2.88983732e-02f, 7.60634523e-03f, 9.33433548e-02f, -1.41473293e-01f, -7.21451864e-02f, 5.84472604e-02f, -4.44699228e-02f,
  -1.28312141e-01f, -7.55805001e-02f, 2.48660073e-01f, 4.83063430e-01f, -2.71158338e-01f, -4.76983190e-01f, -4.22582000e-01f, -1.35289170e-02f, -3.18552613e-01f, -2.85183966e-01f,
  3.22265588e-02f, -4.78979237e-02f, -2.40022689e-01f, 4.54553515e-01f, 6.56284392e-01f, -1.19197384e-01f, 3.34979862e-01f, 5.45919575e-02f, 1.75452661e-02f, 6.36925101e-02f,
  3.05440903e-01f, 2.66609311e-01f, 4.49387372e-01f, 3.25838745e-01f, 1.28375620e-01f, 3.60873759e-01f, 3.97523522e-01f, 7.43755847e-02f, 3.42301518e-01f, 1.22569248e-01f,
  -1.13207489e-01f, -6.22054227e-02f, 1.04397032e-02f, 3.00001656e-03f, -3.32004651e-02f, -1.64151236e-01f, 8.82149413e-02f, 1.13650886e-02f, 4.24956083e-02f, -2.32918076e-02f,
  -9.89164189e-02f, 4.17741649e-02f, 3.12634534e-03f, -2.97423899e-02f, -1.33605048e-01f, 6.99938387e-02f, -2.47561727e-02f, -1.93184406e-01f, 1.90140493e-02f, -5.81578873e-02f,
  -7.82816410e-02f, 4.05757641e-03f, -2.84933466e-02f, 2.19291486e-02f, 2.22751722e-02f, -9.43405479e-02f, -4.02664207e-02f, -6.51061386e-02f, -4.26384620e-02f, -1.11313619e-01f,
  6.64843917e-02f, -1.26575544e-01f, -6.43545836e-02f, -1.80357024e-02f, -5.62947914e-02f, 1.28433883e-01f, 4.49569598e-02f, -7.19127664e-03f, 1.02284715e-01f, 2.48469040e-02f,
  -4.03452590e-02f, 1.50539950e-02f, -7.12045142e-03f, -5.16161360e-02f, -5.38769588e-02f, -8.59282613e-02f, -1.93118677e-02f, -5.67068644e-02f, -4.28411216e-02f, 1.32819293e-02f,
  8.88128132e-02f, 5.86225241e-02f, -4.56985049e-02f, 1.48660183e-01f, -1.68338381e-02f, 8.24069791e-03f, 2.11540964e-02f, -8.87897890e-03f, -2.92898957e-02f, 2.98464093e-02f,
  8.33676234e-02f, 2.97162235e-01f, 2.40684543e-02f, 5.88817464e-04f, 7.03083724e-02f, 1.69896949e-02f, 5.13979085e-02f, 8.10793266e-02f, 2.00437158e-01f, 2.11527501e-03f,
  5.43475002e-02f, -4.53994982e-02f, 3.81473899e-02f, 1.81419104e-02f, 1.07206665e-01f, -6.76306933e-02f, 6.87755719e-02f, 1.48798913e-01f, -5.07509988e-03f, 1.24125957e-01f,
  5.88370673e-02f, -2.13687509e-01f, 2.16558129e-02f, -8.49820971e-02f, 4.00395878e-02f, -1.05363287e-01f, -7.64131323e-02f, -4.66013886e-02f, 1.26386896e-01f, 7.86175355e-02f,
  -5.90076089e-01f, 1.43485516e-01f, -4.66666192e-01f, 1.69415787e-01f, 1.31541444e-02f, -2.00038031e-01f, 3.13679650e-02f, 5.55064194e-02f, -2.89542377e-01f, 3.63327026e-01f,
  3.99965286e-01f, -3.49946320e-01f, 1.91895589e-01f, 1.69727206e-01f, -5.83901048e-01f, -1.49685770e-01f, 1.38445556e-01f, -4.53712046e-02f, -2.51039982e-01f, 2.34199718e-01f,
  -1.36963665e-01f, 4.40086752e-01f, -1.16310917e-01f, 2.89697587e-01f, -1.23083387e-02f, -8.96900296e-02f, 5.12071550e-01f, -2.90663424e-03f, 1.91880688e-01f, -3.58145200e-02f,
  -6.45982027e-02f, 1.38916187e-02f, -1.30881220e-02f, -8.82795975e-02f, -2.50507239e-03f, 1.49391636e-01f, 4.09828685e-03f, -1.30807953e-02f, -8.44013840e-02f, -3.76573913e-02f,
  -2.83406656e-02f, 1.98614299e-02f, -1.03067141e-02f, -1.04195349e-01f, -4.06330749e-02f, -4.22358923e-02f, -1.35760173e-01f, -1.76316753e-01f, 5.90106733e-02f, -1.16590336e-01f,
  -2.35501215e-01f, -3.76091083e-03f, 1.10264570e-01f, 3.28170098e-02f, -8.85706246e-02f, 3.08548994e-02f, -2.61087399e-02f, -5.02170920e-02f, -9.33590066e-03f, -9.62432846e-02f,
  6.31547719e-02f, -6.68999776e-02f, -5.08387461e-02f, -3.27508189e-02f, -9.94966701e-02f, 1.48709133e-01f, 2.63623111e-02f, 1.04865313e-01f, -1.35016158e-01f, 6.06459081e-02f,
  2.57316157e-02f, -2.59349309e-02f, 4.55610044e-02f, 7.37680197e-02f, 2.16252357e-02f, 5.20170927e-02f, 3.04907169e-02f, 2.78732069e-02f, -6.50212392e-02f, -2.53001004e-02f,
  -2.00525131e-02f, -2.69666687e-03f, -1.10892333e-01f, 1.27497807e-01f, -6.83560455e-03f, 3.05611156e-02f, 1.63370818e-01f, -6.17679730e-02f, 7.63898343e-02f, 1.05714500e-01f,
  1.09092936e-01f, 1.99522913e-01f, 4.11610566e-02f, -1.07327374e-02f, 5.16328495e-03f, 7.41032064e-02f, -9.96727943e-02f, -6.67255744e-02f, 6.40541548e-03f, -1.13031775e-01f,
  1.67458877e-02f, 1.03902884e-01f, -4.02517058e-02f, -4.46740650e-02f, 1.38004031e-02f, 6.68199658e-02f, 1.65499181e-01f, 5.31418016e-04f, 9.40850601e-02f, 7.22324401e-02f,
  7.37835839e-02f, 7.69264102e-02f, -6.06488064e-02f, 1.53524801e-02f, 2.23274738e-01f, -6.54937141e-03f, -5.67486025e-02f, -1.59722403e-01f, 3.81901413e-02f, -1.07268631e-01f,
  -5.98329544e-01f, -2.39506125e-01f, -1.61647290e-01f, -4.33270544e-01f, 4.00136203e-01f, 5.39640129e-01f, -1.78841427e-01f, 1.65539294e-01f, -2.02997729e-01f, -1.17505454e-01f,
  -1.96056291e-01f, -6.39027357e-01f, -2.05434635e-01f, -3.28873277e-01f, -2.32258394e-01f, -1.98834315e-01f, -3.69211771e-02f, -1.29103377e-01f, 3.02385595e-02f, -1.14924647e-01f,
  -9.14282054e-02f, 2.97758698e-01f, -1.86372902e-02f, 5.53290188e-01f, 2.13916853e-01f, 2.63507873e-01f, 6.99565336e-02f, 1.23830304e-01f, 2.72245228e-01f, 6.44648522e-02f,
  -9.60665047e-02f, -2.88902164e-01f, -6.84065148e-02f, 7.37110302e-02f, 1.80404171e-01f, 9.71897617e-02f, -2.87144575e-02f, 5.69682792e-02f, -1.29688725e-01f, 1.02957025e-01f,
  -1.36956647e-01f, 9.62934345e-02f, 9.13935602e-02f, 2.23042116e-01f, -5.03074415e-02f, 2.17194542e-01f, 7.58461505e-02f, 6.99333847e-02f, -4.20848727e-02f, -1.19861541e-03f,
  -2.16293633e-02f, -1.41351065e-02f, -2.09583476e-01f, 1.17228203e-01f, -1.16628055e-02f, -1.76658601e-01f, 7.70632625e-02f, -2.63832770e-02f, 4.40655872e-02f, 7.01381173e-03f,
  -5.22216521e-02f, -3.75252962e-02f, 3.04081794e-02f, 3.98253044e-03f, -4.00118046e-02f, 8.72911513e-02f, 8.38191714e-03f, 1.99655630e-02f, -1.09476196e-02f, -7.37525374e-02f,
  -2.35125944e-02f, -1.49863228e-01f, -1.46229146e-02f, 7.76999965e-02f, -1.48328487e-02f, -1.20308558e-02f, -1.19536370e-01f, -6.30813604e-03f, 7.37176314e-02f, 2.57024150e-02f,
  -4.11135256e-02f, -9.55682062e-03f, -5.22415452e-02f, 6.12675883e-02f, -6.99366480e-02f, -9.44829211e-02f, 2.38122605e-02f, 6.78575262e-02f, -4.44444343e-02f, 1.11856677e-01f,
  -6.66610338e-03f, -2.03565836e-01f, -3.27196196e-02f, 7.54614472e-02f, -1.18868575e-02f, 8.30185488e-02f, 1.16015263e-02f, 3.39452759e-03f, -6.77677840e-02f, 8.37950036e-02f,
  4.92545851e-02f, 6.85794353e-02f, 8.29016417e-02f, 1.21239834e-01f, 2.75804326e-02f, -2.36267899e-03f, -5.41797429e-02f, -6.63380921e-02f, -2.79928241e-02f, 6.20464608e-02f,
  1.30427390e-01f, 1.12681307e-01f, -1.07953642e-02f, 1.94559082e-01f, 7.54498318e-02f, 1.45372953e-02f, 8.45753476e-02f, 2.45713517e-02f, 1.32861048e-01f, -8.28512684e-02f,
  1.18129484e-01f, 3.29356700e-01f, 7.82622211e-03f, -8.17030519e-02f, -5.17500611e-03f, -6.60961151e-01f, -4.24540460e-01f, 4.03665006e-02f, -2.03389645e-01f, 3.05354863e-01f,
  -2.75138170e-01f, 1.66014388e-01f, -2.62653045e-02f, -6.49234772e-01f, -6.66170537e-01f, -4.18725371e-01f, -5.85238993e-01f, -2.72674561e-01f, -1.02393232e-01f, 2.22263157e-01f,
  -1.41456246e-01f, -4.22258645e-01f, -2.83935606e-01f, -1.38568608e-02f, -8.05247296e-03f, 3.13996077e-01f, 3.87080908e-01f, 3.79482061e-02f, 2.23377645e-01f, -2.44667783e-01f,
  -2.09354803e-01f, -4.97851446e-02f, 8.48306045e-02f, -9.26789045e-02f, 3.91856134e-02f, 1.50894359e-01f, 1.97395712e-01f, -7.05253631e-02f, -3.38160479e-03f, 9.41515528e-03f,
  1.03928849e-01f, 1.01111606e-02f, -1.83054805e-02f, 1.71351712e-02f, -8.65458162e-04f, -2.04724744e-02f, 5.07805590e-03f, 7.97829479e-02f, -6.91337362e-02f, 2.57424451e-03f,
  -7.06897210e-03f, -1.41444225e-02f, 8.31870809e-02f, 6.43716380e-02f, -5.67470398e-03f, -3.36190574e-02f, 3.40042561e-02f, 2.98281647e-02f, 7.88837969e-02f, -4.17884951e-03f,
  1.07531644e-01f, 5.88617511e-02f, -1.11878656e-01f, 4.64105532e-02f, -7.56534487e-02f, 6.29360089e-03f, 6.11097785e-03f, -3.17001045e-02f, -9.40396730e-03f, -2.30815709e-02f,
  4.53548804e-02f, 2.34390870e-02f, -1.10986061e-01f, 6.00727722e-02f, 6.90488294e-02f, 7.01039732e-02f, 1.01874031e-01f, -2.40556430e-02f, -4.54854891e-02f, -6.42511025e-02f,
  6.03708476e-02f, -7.12066982e-03f, 8.35360661e-02f, 6.66243061e-02f, -1.19965963e-01f, 2.58441493e-02f, 1.70702557e-03f, 1.50208557e-02f, 4.47062142e-02f, 6.65012226e-02f,
  1.08325228e-01f, 2.01667726e-01f, 2.22411081e-02f, -5.44969402e-02f, 4.72792685e-02f, -8.00457895e-02f, -1.64858282e-01f, -3.87081504e-02f, 4.16060984e-02f, -7.69107789e-02f,
  9.00491402e-02f, 1.01708792e-01f, 1.08877443e-01f, -4.56015691e-02f, 4.33102921e-02f, -6.28480315e-02f, 1.07018806e-01f, 1.30110562e-01f, 1.20703086e-01f, 8.93374085e-02f,
  1.12426549e-01f, 6.91305026e-02f, -9.75553766e-02f, -7.45569468e-02f, -1.56908724e-02f, 1.29639745e-01f, 8.98211971e-02f, 3.91926616e-02f, 4.03900705e-02f, 8.58787596e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.84975135e-01f, 1.35295495e-01f, 4.35191512e-01f, 5.94757915e-01f, 3.42763662e-01f, 2.71798968e-01f, 4.32463259e-01f, 3.46219361e-01f, 4.00956661e-01f, 4.35098857e-01f,
  1.77527606e-01f, 4.95629221e-01f, 5.70103824e-01f, 5.10928333e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.89638042e-01f, -1.51487872e-01f, -3.08694363e-01f, -1.66032046e-01f, 1.14782803e-01f, 2.15246931e-01f, 4.59740385e-02f, -6.26809821e-02f, -2.32743964e-01f, -1.53965041e-01f,
  -1.88435525e-01f, 2.81740606e-01f, 2.35952362e-01f, -1.93549871e-01f, -4.10995334e-01f, -1.42881304e-01f, 2.05892637e-01f, 1.47136137e-01f, 4.32360126e-03f, 2.11367935e-01f,
  4.69882786e-02f, 3.61598164e-01f, 8.61803368e-02f, 1.95930555e-01f, -2.91292071e-01f, 2.62549341e-01f, -3.19725841e-01f, 5.50973304e-02f, 6.64614439e-02f, 2.61482209e-01f,
  -1.68128967e-01f, 9.21803713e-02f, 3.19798380e-01f, 8.44263807e-02f, 3.30354199e-02f, -1.23764146e-02f, -3.91811848e-01f, -3.66296291e-01f, -2.40381411e-03f, -7.71939456e-02f,
  2.29946405e-01f, 1.30005404e-02f, 2.86543071e-01f, 1.65287450e-01f, -3.51444542e-01f, -4.34164464e-01f, -3.78243327e-02f, 1.19729213e-01f, -3.91590782e-02f, 1.56625304e-02f,
  5.72655126e-02f, 2.12363154e-01f, -3.42997819e-01f, 4.10303086e-01f, -2.17654541e-01f, 2.82006934e-02f, 8.80289525e-02f, -2.02659428e-01f, 5.93421329e-03f, 3.03121716e-01f,
  1.83907509e-01f, -1.84025571e-01f, 1.16417885e-01f, -1.80870667e-01f, -1.43962607e-01f, 2.21037626e-01f, 1.63315833e-01f, -1.49606794e-01f, -7.69462436e-02f, 1.70836430e-02f,
  1.47524521e-01f, 1.60925731e-01f, 2.49041095e-01f, -2.99624532e-01f, -5.37441596e-02f, -2.59941995e-01f, -1.65031925e-01f, -1.04396688e-02f, 2.49045044e-01f, 1.32414937e-01f,
  2.69611984e-01f, 4.24445212e-01f, -1.18630685e-01f, -1.42893866e-01f, 2.63891965e-01f, -2.86739796e-01f, 2.62665629e-01f, -6.82876632e-02f, -1.70410663e-01f, -1.16169006e-01f,
  1.44891694e-01f, -3.29843372e-01f, 1.25034183e-01f, -1.25611261e-01f, 3.97650182e-01f, 4.37072814e-01f, -1.90858409e-01f, -1.72212154e-01f, -1.39563963e-01f, -4.18014318e-01f,
  -8.34686160e-02f, -1.34195194e-01f, -9.30818543e-02f, 5.06161386e-03f, -1.34368166e-01f, -7.80035928e-02f, -1.47268683e-01f, 1.62093446e-01f, -1.57417461e-01f, -3.09017658e-01f,
  -4.20226336e-01f, -2.18880743e-01f, 1.90352887e-01f, -5.13087250e-02f, -4.15336788e-01f, 1.90959290e-01f, -3.12026083e-01f, 2.34046951e-01f, -1.66336820e-01f, 1.62405938e-01f,
  -3.96394506e-02f, -2.71008372e-01f, -7.73043931e-02f, 2.79208064e-01f, -3.99210125e-01f, 2.28470057e-01f, 2.10463375e-01f, 5.64094223e-02f, -2.67702788e-01f, -3.42083424e-01f,
  -1.41482800e-01f, -1.13230422e-02f, -1.33907154e-01f, 1.98764712e-01f, -1.22429892e-01f, -9.71443877e-02f, -1.38785273e-01f, -1.51572570e-01f, -1.92242235e-01f, 2.85239518e-01f,
  1.21173568e-01f, -3.46399486e-01f, -4.71070349e-01f, -2.45340481e-01f, 1.34255797e-01f, -1.46982327e-01f, -1.69501573e-01f, -8.34737718e-02f, -2.32311204e-01f, 8.90457258e-02f,
  1.75060421e-01f, 2.27236986e-01f, 6.58469200e-02f, 1.37367949e-01f, 1.21340230e-02f, 2.33172588e-02f, 2.62353837e-01f, 4.39945221e-01f, -1.01406060e-01f, 3.35318148e-01f,
  -1.34904021e-02f, -7.34495670e-02f, 2.00586066e-01f, -2.24344924e-01f, 1.38925433e-01f, 2.15167031e-02f, 1.56005278e-01f, 1.37704074e-01f, -1.58713683e-01f, -2.13149101e-01f,
  -1.96055800e-01f, -4.21963930e-01f, -4.48670655e-01f, 4.96895373e-01f, 2.32411727e-01f, -2.73519099e-01f, 1.93861529e-01f, -1.83531329e-01f, -2.39587113e-01f, -2.23718166e-01f,
  -3.10402572e-01f, -1.68143377e-01f, 1.05174132e-01f, -3.00024897e-01f, -7.33314008e-02f, -1.49517179e-01f, 2.25137770e-01f, 1.10179536e-01f, -1.55875962e-02f, 1.27914086e-01f,
  1.77793846e-01f, 3.24343592e-02f, 5.32777887e-03f, -3.20108324e-01f, -8.60588551e-02f, 1.73204646e-01f, 4.97142732e-01f, 8.69855881e-02f, -8.88478309e-02f, -4.79957946e-02f,
  -1.31668493e-01f, 2.14071617e-01f, -3.26218814e-01f, 9.67138261e-02f, 2.05943689e-01f, 5.47687590e-01f, 9.26405489e-02f, -2.82055140e-01f, 6.36724457e-02f, 5.93712553e-02f,
  2.43121400e-01f, -2.73903728e-01f, 1.31256860e-02f, -1.73612878e-01f, 2.85806954e-01f, -3.42680305e-01f, -5.47724403e-02f, 2.32975453e-01f, 1.94035783e-01f, 1.18428476e-01f,
  -1.79988906e-01f, 1.02860369e-01f, -3.97307277e-02f, -7.90095329e-02f, -7.93734267e-02f, -7.26659670e-02f, -4.21794280e-02f, -1.10963009e-01f, -1.24610327e-02f, -1.47856832e-01f,
  -1.24191262e-01f, -7.32316822e-02f, -1.43781841e-01f, -2.68711358e-01f, -6.98417872e-02f, -5.86613007e-02f, -1.72051042e-01f, -3.06835741e-01f, -5.43502748e-01f, 1.14403926e-01f,
  -9.25767869e-02f, -3.08438420e-01f, -2.55993903e-01f, 1.06644414e-01f, -3.37994814e-01f, 1.96805850e-01f, -1.62324607e-02f, -2.11091079e-02f, -6.36469349e-02f, -3.65252085e-02f,
  -2.81292081e-01f, 2.16081291e-01f, 1.41897172e-01f, 3.99069220e-01f, -1.13924935e-01f, 1.38804913e-01f, -4.62036245e-02f, -2.01930851e-01f, 2.36949548e-02f, -1.69140488e-01f,
  5.17346978e-01f, 5.22533283e-02f, -1.98747560e-01f, -1.54935420e-01f, -5.16495168e-01f, -9.10835862e-02f, -5.07284701e-01f, 2.26932451e-01f, 3.92730720e-02f, 3.14181477e-01f,
  1.71709970e-01f, -3.09115887e-01f, 3.74810338e-01f, 1.27707765e-01f, 1.48533002e-01f, -1.39561400e-01f, -2.87517667e-01f, -7.09031373e-02f, 2.97724307e-01f, -4.43693921e-02f,
  7.84911215e-02f, 3.89117375e-02f, -3.68620828e-02f, 7.43942633e-02f, 2.33611371e-02f, 1.32157922e-01f, -1.86501220e-01f, -7.74701163e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.68487483e-01f, 5.19513667e-01f, 4.51840043e-01f, -2.88697064e-01f, 2.71218475e-02f, 8.01222771e-02f, 5.67601025e-01f, 3.17309678e-01f, 3.01918477e-01f, -7.44248688e-01f,
  -4.95829374e-01f, -6.01073086e-01f, -8.61448526e-01f, 7.50778466e-02f, -1.54874235e-01f, -3.46791685e-01f, 7.37565935e-01f, 1.49861291e-01f, 2.83057183e-01f, -5.16311228e-02f,
  -4.67818856e-01f, -2.17961073e-01f, 6.36286736e-01f, 3.46690953e-01f, 5.10558724e-01f, -5.32849193e-01f, 1.67587474e-02f, -5.32697022e-01f, -5.02439067e-02f, 4.25410450e-01f,
  7.99695194e-01f, 8.85592639e-01f, -4.30149376e-01f, -1.95534915e-01f, -8.41818824e-02f, 1.27417773e-01f, -4.72795337e-01f, -1.18880741e-01f, -5.97099215e-02f, -2.53298283e-02f,
  6.02816083e-02f, 4.17896211e-01f, 3.82709324e-01f, 2.21907660e-01f, 1.13838904e-01f, -3.68947417e-01f, 1.18381247e-01f, 4.32248235e-01f, -5.17308474e-01f, 5.59557617e-01f,
  -2.83994153e-02f, -2.32917204e-01f, 3.21161568e-01f, -8.70949775e-02f, -4.94795024e-01f, 1.69578195e-01f, 5.24313927e-01f, -3.98890913e-01f, 7.71646202e-01f, 3.84689867e-01f,
  2.46428803e-01f, -1.43524215e-01f, 4.57987309e-01f, -4.74258900e-01f, 4.04641181e-01f, 6.02964878e-01f, 4.18217152e-01f, -5.79458624e-02f, 1.49781749e-01f, 1.65319562e-01f,
  5.46469033e-01f, 5.49589157e-01f, 2.79127657e-01f, -7.01122046e-01f, -7.44322717e-01f, -6.68896616e-01f, -6.99529648e-01f, 8.77246261e-01f, 8.11039567e-01f, -3.63919675e-01f,
  8.60238969e-01f, -2.36691341e-01f, -3.96502286e-01f, -1.81407765e-01f, -2.76804030e-01f, 1.09824455e+00f, 2.17418045e-01f, -4.42297876e-01f, 3.30540650e-02f, 2.96830907e-02f,
  -5.79725623e-01f, 7.09834516e-01f, 3.36358517e-01f, 2.43731797e-01f, 4.65119779e-01f, -4.20674354e-01f, -1.52750865e-01f, 3.00306678e-01f, 1.92399353e-01f, 3.14024031e-01f,
  -6.36439547e-02f, 1.11894563e-01f, 2.46858194e-01f, 2.17938691e-01f, 6.09758615e-01f, 8.46017540e-01f, 5.39550245e-01f, 5.05653083e-01f, 5.22962272e-01f, 3.53687704e-01f,
  3.78617257e-01f, 6.16557956e-01f, -2.19045773e-01f, 6.68127835e-01f, -4.28435691e-02f, 5.81397891e-01f, 6.86931074e-01f, 3.38566661e-01f, 1.56297348e-02f, 1.18234362e-02f,
  -8.24168980e-01f, 3.55209559e-01f, 5.37769079e-01f, -5.21239042e-01f, -3.88588496e-02f, -2.84419447e-01f, 2.21895278e-02f, -2.04704911e-01f, 3.28007698e-01f, -2.99131013e-02f,
  1.86103508e-01f, 1.77877948e-01f, -1.98817953e-01f, 1.87226608e-01f, 1.44159019e-01f, 2.95708120e-01f, 1.08636186e-01f, 6.87244475e-01f, -2.83487320e-01f, 6.72276855e-01f,
  4.24748927e-01f, -3.62635888e-02f, -9.07472819e-02f, 3.77074540e-01f, 5.94383061e-01f, -3.12631339e-01f, 1.03431337e-01f, 1.47600234e-01f, 3.69837135e-01f, 4.16996598e-01f,
  -1.92120865e-01f, 5.98713517e-01f, -1.36827260e-01f, 7.60280907e-01f, -2.48203054e-01f, -4.81104344e-01f, 8.06960881e-01f, -1.30887359e-01f, -7.64839292e-01f, 3.72146559e-03f,
  1.49402618e-01f, 3.41024190e-01f, 7.49315321e-02f, 2.62518674e-01f, 1.14425331e-01f, 4.26300615e-01f, 2.60990232e-01f, 3.89142007e-01f, 2.59396851e-01f, -1.93802416e-02f,
  5.54241121e-01f, -6.17789924e-01f, 5.76028526e-01f, -2.61483788e-01f, -2.02914417e-01f, -4.13463190e-02f, -6.27438843e-01f, -4.71472740e-01f, -1.98251218e-01f, -2.54115194e-01f,
  6.84088767e-01f, -5.41914940e-01f, -5.12021780e-01f, 5.19904435e-01f, -1.34338900e-01f, 5.15305519e-01f, 5.75608850e-01f, -4.87029672e-01f, 5.61688364e-01f, 1.28037840e-01f,
  3.05787474e-01f, 5.88825941e-01f, -2.16639265e-01f, 2.97970593e-01f, 5.03121503e-02f, 3.43807906e-01f, 4.51048553e-01f, 4.90948170e-01f, 4.42757517e-01f, 1.95730552e-01f,
  2.24603608e-01f, 1.29628599e-01f, 4.54787046e-01f, -1.03738762e-01f, 4.15525854e-01f, -1.19393930e-01f, -3.21369618e-01f, -4.21705581e-02f, 1.49258614e-01f, -4.75599319e-01f,
  -3.39739174e-01f, -3.24276686e-01f, 8.89055014e-01f, 2.88509279e-01f, 1.58720035e-02f, 8.12005922e-02f, -3.98139238e-01f, 5.01691639e-01f, 1.70991436e-01f, 1.13864623e-01f,
  -6.64611936e-01f, 8.05403709e-01f, 9.68913734e-02f, 5.69401503e-01f, 1.70673162e-01f, 4.82892320e-02f, -3.82169425e-01f, 2.16329083e-01f, 3.25139195e-01f, 5.06711900e-01f,
  2.33001724e-01f, 4.46101308e-01f, -1.83122419e-02f, -3.80625890e-04f, 7.58633837e-02f, -2.36029893e-01f, 5.70419192e-01f, 6.68974221e-02f, -4.50270951e-01f, -5.28411329e-01f,
  7.60697527e-03f, -6.19503736e-01f, -2.95464814e-01f, 2.85079867e-01f, 7.19096959e-01f, 3.31089079e-01f, 4.78892624e-01f, 1.36982640e-02f, -3.74869943e-01f, 6.82299733e-01f,
  -3.76733273e-01f, 7.70015955e-01f, -2.11339548e-01f, 4.46803093e-01f, -3.86556655e-01f, 3.40165526e-01f, 2.49117091e-01f, 2.97955841e-01f, 4.88160789e-01f, 4.20048594e-01f,
  1.78331677e-02f, -3.78486931e-01f, 1.69231668e-01f, -1.74289063e-01f, 3.26603234e-01f, 1.87699690e-01f, 5.50454378e-01f, 5.33641398e-01f, -3.26405376e-01f, -8.37819457e-01f,
  -5.36580563e-01f, 3.62762898e-01f, -4.46648628e-01f, -1.05323553e-01f, 3.20510864e-01f, 4.35736507e-01f, -6.57370925e-01f, 1.90361053e-01f, -8.50393951e-01f, 3.86520505e-01f,
  7.03256786e-01f, -1.67366132e-01f, 3.05032462e-01f, 1.49934486e-01f, 5.26921988e-01f, 6.05438471e-01f, 4.48005289e-01f, 3.25836420e-01f, -2.91113891e-02f, 3.39101255e-01f,
  1.40044808e-01f, 7.89769515e-02f, 6.32842677e-03f, -8.21506828e-02f, 3.18341613e-01f, 1.82984754e-01f, 5.04376709e-01f, 5.59682488e-01f, 5.36924303e-01f, 2.41874069e-01f,
  2.54115790e-01f, -3.75190824e-01f, -5.62449574e-01f, 6.51076853e-01f, -1.74828932e-01f, 4.08282638e-01f, -5.49186051e-01f, 6.74907446e-01f, 1.03815436e-01f, 4.70326155e-01f,
  -4.38321799e-01f, 4.95763659e-01f, -6.59227312e-01f, 1.26607999e-01f, 5.60202479e-01f, 2.66239554e-01f, 7.50999600e-02f, 2.94205487e-01f, 5.21073222e-01f, 1.07578538e-01f,
  6.06537938e-01f, -3.46205324e-01f, 2.26684436e-01f, 5.37201464e-01f, 3.17729086e-01f, 9.36133191e-02f, -1.65824577e-01f, 5.06805778e-02f, 1.80019766e-01f, 3.22062910e-01f,
  -5.40765226e-01f, 8.84356499e-01f, 3.36855292e-01f, -5.08351699e-02f, 4.13680710e-02f, -3.30361098e-01f, 5.42300940e-01f, 4.27628964e-01f, 9.14494038e-01f, 2.13785753e-01f,
  -3.75830382e-01f, 5.70211053e-01f, 6.52918458e-01f, 3.84934068e-01f, 7.17074990e-01f, 4.75641221e-01f, -4.41898592e-02f, 5.97129762e-01f, 6.49110377e-01f, 1.43816113e-01f,
  -4.60665554e-01f, -6.81395084e-03f, -7.45085031e-02f, 4.59191017e-02f, -1.68559343e-01f, -4.42065299e-03f, 2.69493293e-02f, -4.10157472e-01f, -6.96046725e-02f, 1.99808389e-01f,
  -3.48502514e-03f, 5.33723593e-01f, 6.08570218e-01f, 1.67729080e-01f, 2.61978328e-01f, -5.30935764e-01f, -6.28017962e-01f, 5.43702126e-01f, -7.02595651e-01f, 5.83355308e-01f,
  1.83222611e-02f, 5.11608779e-01f, -1.63246483e-01f, 7.43536651e-02f, -5.85539579e-01f, 1.57068130e-02f, 3.86622429e-01f, -2.36536816e-01f, 6.56972766e-01f, 6.45058930e-01f,
  -1.24496214e-01f, 6.45673424e-02f, 2.43330821e-01f, -2.51101613e-01f, -4.79105920e-01f, 9.69029367e-02f, 3.02421123e-01f, -1.68180794e-01f, -4.33848858e-01f, 3.14514011e-01f,
  7.56269842e-02f, 1.99446872e-01f, -2.01705158e-01f, 3.05063576e-01f, -7.17335522e-01f, 2.83751994e-01f, -2.94972092e-01f, 2.00799808e-01f, -3.26911122e-01f, 1.27905115e-01f,
  1.66640252e-01f, -3.33428681e-01f, -7.60665417e-01f, -1.97334677e-01f, -1.53234810e-01f, -5.92176802e-03f, 5.71542740e-01f, 5.64121842e-01f, 2.31702954e-01f, 2.41805896e-01f,
  6.17264271e-01f, -5.19237995e-01f, 9.52933311e-01f, 4.48256046e-01f, 3.69654626e-01f, 2.80146539e-01f, 3.58765453e-01f, 6.52990699e-01f, 4.90855634e-01f, 5.29647708e-01f,
  1.33254677e-01f, -1.13616869e-01f, 5.43158412e-01f, 3.07218224e-01f, 7.29249597e-01f, 4.35603321e-01f, 4.18464124e-01f, 1.58090129e-01f, -4.46570009e-01f, 5.33611238e-01f,
  8.09739232e-01f, 3.59659970e-01f, -3.51230055e-01f, 5.68423629e-01f, 5.09025812e-01f, -1.00056916e-01f, 2.51132727e-01f, 4.70682859e-01f, 4.59284596e-02f, -1.87065780e-01f,
  7.18590558e-01f, -8.06137100e-02f, 4.30530727e-01f, 2.11364120e-01f, -9.53244716e-02f, -6.52949035e-01f, 3.42745334e-01f, -5.42642295e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  6.56941831e-01f, 5.43058626e-02f, 4.03679609e-01f, 1.70142904e-01f, -3.42266336e-02f, 2.56971896e-01f, 4.56231743e-01f, 5.02401650e-01f, 3.38274926e-01f, 3.25880587e-01f,
  1.81645706e-01f, 7.80287609e-02f, -6.62288964e-02f, 6.38919890e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -3.09393287e-01f, -8.60971659e-02f, -2.38452837e-01f, -2.67197136e-02f, -1.55080184e-01f, 3.29948604e-01f, -1.16860658e-01f, -2.79587321e-02f, -4.58666570e-02f, 8.15845579e-02f,
  1.09537229e-01f, -4.53702271e-01f, 4.03441489e-01f, 5.41330040e-01f, -1.16985530e-01f, 3.68571252e-01f, 5.83519936e-01f, 5.65381467e-01f, -8.09681952e-01f, -3.07396948e-01f,
  7.04798400e-01f, -9.83260274e-01f, -4.66726422e-01f, -6.73941195e-01f, 1.92847267e-01f, 4.76526529e-01f, -4.21143025e-01f, -8.75422731e-03f, 5.49592435e-01f, -2.51376361e-01f,
  -3.61510962e-01f, -3.13929707e-01f, -1.98200345e-01f, -4.04162854e-01f, -3.45714003e-01f, 2.12714329e-01f, 2.49196172e-01f, -3.06943357e-01f, -8.80322382e-02f, -3.57357636e-02f,
  -2.44449005e-01f, 3.94583970e-01f, 2.75963336e-01f, -3.48116368e-01f, 6.95067525e-01f, 2.21888617e-01f, -3.61900717e-01f, -5.39101660e-01f, 5.73367298e-01f, -2.82702327e-01f,
  -7.27590382e-01f, -7.14832619e-02f, -3.60599011e-01f, 7.48684555e-02f, -7.01495856e-02f, -4.25569385e-01f, 7.78007507e-02f, 2.28659108e-01f, 3.10452223e-01f, 6.18266225e-01f,
  -3.90559547e-02f, 7.51174212e-01f, -6.04418337e-01f, -1.22162603e-01f, -1.36715367e-01f, -4.54143703e-01f, -3.30697559e-02f, 1.29151016e-01f, 4.24695760e-02f, 1.79886948e-02f,
  -9.64893177e-02f, 8.23649764e-02f, -1.54925346e-01f, -3.79675776e-01f, 3.00071687e-01f, -6.17619883e-03f, 1.02327034e-01f, 6.07953250e-01f, 4.42015342e-02f, -3.75353694e-01f,
  -3.53829682e-01f, 3.15511115e-02f, -1.50791124e-01f, 6.63392246e-01f, -6.65018022e-01f, -3.98020864e-01f, -1.82330817e-01f, 6.13980219e-02f, -4.40924346e-01f, -8.69075894e-01f,
  2.25579143e-01f, 1.16504088e-01f, -1.67485163e-01f, 3.79018098e-01f, 6.98787451e-01f, -2.83454265e-02f, 1.86363071e-01f, -6.91004455e-01f, 7.15121403e-02f, 3.10909659e-01f,
  -1.04253188e-01f, -4.85535055e-01f, 2.36571357e-01f, -1.64829800e-03f, -2.83336751e-02f, 9.61166769e-02f, -4.68225688e-01f, 2.15211689e-01f, 3.73476595e-01f, 3.53157431e-01f,
  2.34065771e-01f, 6.20839596e-01f, 4.05175269e-01f, 6.75031662e-01f, 4.75453407e-01f, 4.98192795e-02f, 3.30514461e-01f, -4.32430655e-01f, 4.24011238e-02f, -4.77070153e-01f,
  1.91823766e-01f, 2.32584223e-01f, -8.17946553e-01f, -7.16094792e-01f, -4.23173189e-01f, -2.32630685e-01f, 8.07331860e-01f, -1.04486430e+00f, 3.81009758e-01f, 3.85270178e-01f,
  1.01427287e-01f, 1.82358712e-01f, 3.68744105e-01f, 7.60191157e-02f, 3.26321125e-01f, 3.57216388e-01f, 3.61411899e-01f, -2.66112417e-01f, 3.75759065e-01f, 6.61433995e-01f,
  -2.98679948e-01f, -7.43659914e-01f, 6.53553486e-01f, -4.28335629e-02f, -2.76425898e-01f, -3.43661010e-03f, 3.69620115e-01f, -1.93101808e-01f, 8.55492771e-01f, -3.52869511e-01f,
  -5.20823836e-01f, -4.24613982e-01f, -5.55565894e-01f, -3.04108173e-01f, -1.72972232e-01f, -1.26039147e-01f, -2.51545101e-01f, -2.70264030e-01f, -2.41182163e-01f, 5.14369428e-01f,
  -1.65591627e-01f, 2.71347821e-01f, 2.70443916e-01f, -4.65402640e-02f, 1.73325136e-01f, -2.62456208e-01f, 1.09363168e-01f, -2.25899532e-03f, 2.81705379e-01f, 4.85201031e-01f,
  -4.04861234e-02f, -3.46461207e-01f, -5.67490816e-01f, -1.25638887e-01f, -4.76419121e-01f, 1.06999226e-01f, -6.70777142e-01f, -1.83096528e-01f, -8.45698535e-01f, -4.96092200e-01f,
  5.83303608e-02f, 6.03462040e-01f, 5.82271039e-01f, -4.58320349e-01f, 2.47455627e-01f, 6.07052445e-02f, -7.33603537e-01f, 1.50191486e-01f, 1.88051790e-01f, -8.12929869e-01f,
  9.31004956e-02f, 3.06675822e-01f, -1.35538191e-01f, 3.97144288e-01f, -1.80727914e-02f, -2.70861536e-01f, -2.24433411e-02f, 5.42908050e-02f, 2.08397701e-01f, -4.11942899e-01f,
  2.56012287e-02f, -5.06063402e-01f, -9.09427702e-02f, 3.95208418e-01f, -3.34827095e-01f, -5.35510004e-01f, 2.65590772e-02f, 5.28308690e-01f, -3.30712438e-01f, -4.46220785e-01f,
  -5.18468380e-01f, 4.28324223e-01f, -5.90843797e-01f, 7.66240656e-01f, -8.00788045e-01f, 2.89184570e-01f, 1.77332416e-01f, -5.50475180e-01f, -3.00623566e-01f, 4.06704813e-01f,
  -8.03347111e-01f, 3.38829130e-01f, -3.04385722e-01f, 3.23913217e-01f, 4.75627668e-02f, 1.92136303e-01f, -3.98443788e-02f, -1.35497138e-01f, 2.09914297e-01f, 1.09384641e-01f,
  -2.93015450e-01f, 8.22197422e-02f, -4.36032355e-01f, 5.59322238e-01f, -3.13019544e-01f, 3.59238893e-01f, 2.22747400e-01f, 3.48475903e-01f, -3.31754535e-01f, 1.19223639e-01f,
  -4.93164539e-01f, 2.33811766e-01f, 4.92567092e-01f, -2.65357286e-01f, -5.63358247e-01f, -2.03588307e-01f, 8.78341962e-03f, -4.34997857e-01f, -6.26658618e-01f, -2.18162462e-01f,
  -2.42417037e-01f, -1.45563930e-01f, 7.70305574e-01f, -1.52164742e-01f, -1.75874755e-01f, -3.62253070e-01f, -1.51967525e-01f, 1.19008772e-01f, 5.03363162e-02f, -2.47738972e-01f,
  -3.89962256e-01f, -2.01088190e-01f, -1.97026059e-01f, -1.23844564e-01f, -2.02185586e-02f, 1.64448425e-01f, 2.62393147e-01f, 1.86777171e-02f, -8.51544961e-02f, -9.11987498e-02f,
  -5.21984622e-02f, -1.13681592e-01f, 4.28130835e-01f, -7.55548030e-02f, -5.91012716e-01f, -3.38550299e-01f, -4.98762548e-01f, 1.48457721e-01f, 6.08118534e-01f, 3.52422565e-01f,
  -6.73069283e-02f, -5.10542631e-01f, 3.24201912e-01f, 1.40266195e-01f, 1.40779227e-01f, -5.77911198e-01f, 6.34610832e-01f, -5.52222729e-01f, -4.08735164e-02f, 2.10043609e-01f,
  1.57154486e-01f, -4.75063801e-01f, -1.70176849e-03f, 1.91569269e-01f, 8.20905045e-02f, -1.93226695e-01f, 1.08728260e-01f, -4.56952572e-01f, 4.84809548e-01f, -4.93409365e-01f,
  -1.16623566e-01f, -3.51392001e-01f, -1.79683000e-01f, 5.05049229e-01f, -3.65697354e-01f, 1.83833569e-01f, -5.38985550e-01f, 1.58777386e-01f, -6.19134188e-01f, -2.81710029e-01f,
  -3.49731863e-01f, -5.12038946e-01f, -6.81385458e-01f, -5.58238745e-01f, 5.52565038e-01f, -6.78746045e-01f, 4.68903571e-01f, 2.93172389e-01f, -8.56905699e-01f, 6.62643552e-01f,
  7.81370774e-02f, 3.82112265e-01f, -1.44997939e-01f, -8.14473033e-02f, -8.52148086e-02f, 1.95618615e-01f, -1.81458071e-01f, -2.09733620e-01f, -7.36828968e-02f, 3.21488567e-02f,
  1.25526190e-01f, 3.36103886e-01f, 4.59532082e-01f, 4.34789360e-01f, 1.96863815e-01f, -5.55982471e-01f, 4.19867963e-01f, -6.91967964e-01f, 4.41713631e-01f, -4.76562858e-01f,
  -3.17026645e-01f, -4.93788540e-01f, -6.91832125e-01f, 1.44829601e-01f, 3.19495499e-01f, -3.48257124e-01f, 6.64335132e-01f, 1.95594981e-01f, -6.36799157e-01f, -3.32610518e-01f,
  -1.02010697e-01f, -5.06847501e-01f, 6.35883510e-02f, -5.11947393e-01f, 6.91786557e-02f, -4.73224133e-01f, 1.49204269e-01f, 1.16676308e-01f, 2.55831122e-01f, -5.12642134e-03f,
  5.22408076e-02f, 2.64351755e-01f, -3.39827776e-01f, 3.48633677e-01f, -3.19752723e-01f, 2.28235330e-02f, -4.69018668e-01f, 1.03720929e-02f, -1.34751931e-01f, -2.98941672e-01f,
  -2.17504784e-01f, -3.61649483e-01f, -5.07141948e-01f, -2.00031534e-01f, -3.82638983e-02f, 7.09458292e-01f, 6.18383288e-01f, 7.00456619e-01f, -8.31748605e-01f, -4.51069444e-01f,
  -4.69912499e-01f, -3.23354542e-01f, -5.53936303e-01f, -4.34053391e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.48583531e-01f, -3.43964872e-04f, -2.79926836e-01f, -9.55540501e-03f, 2.31904894e-01f, -2.65188068e-02f, 1.38666287e-01f, 2.05672100e-01f, -2.59059638e-01f, 2.98269019e-02f,
  6.65065786e-03f, -4.89060432e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    