/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.18464160e-02f, -2.60770619e-02f, -3.13629001e-01f, 4.44994867e-02f, 7.75786042e-02f, 8.50697383e-02f, -1.07092731e-01f, -7.24246204e-02f, 8.27735960e-02f, 8.10890272e-02f,
  2.85199046e-01f, 4.26796824e-01f, 2.84725696e-01f, 1.11329623e-01f, 2.90042232e-03f, -2.16259956e-01f, -2.19388738e-01f, -2.42216095e-01f, -1.19329378e-01f, 3.50710526e-02f,
  3.89731722e-03f, -1.35400862e-01f, -9.32255089e-02f, -1.34440720e-01f, 3.84530723e-02f, 5.31098433e-02f, -1.32657349e-01f, -5.17406315e-02f, -1.06800914e-01f, -1.89896002e-01f,
  3.79280671e-02f, -1.08086653e-01f, 7.34955370e-02f, 1.31366387e-01f, 4.28276435e-02f, 2.63951831e-02f, 1.72911417e-02f, 4.32227887e-02f, 2.78377756e-02f, -1.48620278e-01f,
  6.86801448e-02f, -3.10924998e-03f, -1.26674930e-02f, -3.96548174e-02f, -1.46300241e-01f, 1.25678191e-02f, -1.25039712e-01f, -1.45048261e-01f, -1.39520735e-01f, -3.62384245e-02f,
  6.68818951e-02f, 4.33197767e-02f, 4.48954888e-02f, -7.97809362e-02f, -1.03858806e-01f, 7.91120976e-02f, -6.96764067e-02f, -3.99241596e-02f, -1.13229021e-01f, -9.92448702e-02f,
  6.26575276e-02f, 3.84100787e-02f, 1.55991176e-03f, -3.77433933e-02f, 2.47727078e-03f, -2.29369029e-02f, -5.77024221e-02f, 2.87880264e-02f, -2.37092488e-02f, -3.34199145e-02f,
  -3.44019309e-02f, 1.50073105e-02f, -7.40688443e-02f, 1.06276684e-02f, 7.16647059e-02f, -8.49490762e-02f, -4.62235585e-02f, 4.54615243e-02f, 5.28433025e-02f, -5.92386127e-02f,
  -7.54383532e-03f, -2.11081784e-02f, 3.52272429e-02f, -8.54135081e-02f, -2.76808385e-02f, -3.10083907e-02f, -7.01047108e-02f, 2.83140223e-04f, 3.49473990e-02f, -4.96322550e-02f,
  3.49226713e-01f, 3.82400677e-02f, 1.28511742e-01f, -1.47404866e-02f, 1.25272080e-01f, -9.27585959e-02f, 6.63861260e-02f, -1.15281239e-03f, 5.59414215e-02f, 2.79527009e-02f,
  2.14812774e-02f, 3.84938158e-02f, -4.46057275e-05f, -3.23332548e-02f, 6.88664839e-02f, 1.05065644e-01f, 8.89223740e-02f, 5.65452464e-02f, 3.56189832e-02f, -1.52516179e-02f,
  -6.06935844e-02f, 2.05521490e-02f, 1.88936561e-01f, 1.39172450e-01f, 7.35524073e-02f, 2.89713979e-01f, -3.28486599e-03f, 6.21616282e-02f, 2.06511170e-01f, 6.89430460e-02f,
  6.45203114e-01f, -2.36552656e-01f, -3.63765895e-01f, -5.62021956e-02f, -4.05337550e-02f, -4.42059617e-03f, -1.52869314e-01f, 1.48032354e-02f, 1.25271752e-01f, -2.35576227e-01f,
  -1.45909384e-01f, -3.58001888e-02f, -1.53317237e-02f, -1.49453625e-01f, 3.62422429e-02f, -3.07372034e-01f, -3.30187440e-01f, 2.85150874e-02f, 1.65720478e-01f, 2.02614114e-01f,
  -2.02553775e-02f, 1.16693467e-01f, 1.04178593e-01f, 5.26841395e-02f, -1.64902136e-01f, -9.31263715e-02f, -2.70676792e-01f, -6.53551072e-02f, -1.26556233e-01f, -3.02274168e-01f,
  -3.16153169e-01f, 1.07102774e-01f, -6.24137484e-02f, -3.91354784e-02f, -1.01225495e-01f, 9.64352861e-02f, 5.65627478e-02f, -1.98205933e-04f, 1.14768125e-01f, 6.43118024e-02f,
  -9.32063814e-03f, 9.89289358e-02f, 9.88729000e-02f, -3.58045995e-02f, 1.52027339e-01f, 6.64883777e-02f, 2.76530497e-02f, 2.00248286e-02f, -9.86573286e-03f, -8.30758214e-02f,
  -2.69460008e-02f, 8.29453580e-03f, 3.99151258e-02f, -7.37349987e-02f, -3.61992307e-02f, 5.05958088e-02f, 7.80593080e-04f, -7.41454586e-03f, -3.94956805e-02f, -7.65218958e-02f,
  -9.77033749e-02f, -6.56392649e-02f, 1.27978167e-02f, 1.09186545e-02f, -1.89591590e-02f, 2.12140270e-02f, 2.75906920e-02f, -1.69637371e-02f, -3.74663249e-02f, 2.11839024e-02f,
  -7.87960216e-02f, -7.04360381e-02f, -6.85305335e-03f, 2.31068581e-02f, -1.41714573e-01f, 4.57032807e-02f, -2.52088830e-02f, -3.38994004e-02f, -5.70795648e-02f, 1.27655128e-02f,
  3.99141386e-02f, 2.97659338e-02f, 3.91231589e-02f, -5.42965233e-02f, 5.86405047e-04f, -8.71079117e-02f, 9.15943533e-02f, 2.60261409e-02f, -1.67973340e-02f, 9.65682939e-02f,
  1.31344810e-01f, 3.35919298e-03f, -1.17346592e-01f, 6.04299046e-02f, 4.12472002e-02f, 2.27027740e-02f, -1.96553208e-02f, 2.88825855e-02f, 1.19195417e-01f, 4.48221043e-02f,
  5.47215454e-02f, -6.05284944e-02f, -7.15567768e-02f, -1.74048580e-02f, -7.36301346e-03f, 5.73281609e-02f, -1.65391099e-02f, -1.02762930e-01f, 8.02293140e-03f, -2.18435866e-03f,
  -1.45028546e-01f, 2.63204239e-02f, 1.59379914e-02f, -7.02760695e-03f, 3.10223121e-02f, 9.24636051e-02f, 1.51782846e-02f, 6.70410916e-02f, 1.21720955e-01f, -6.53054938e-02f,
  3.42098147e-01f, 7.36205131e-02f, 2.62975633e-01f, 4.40425694e-01f, 3.33086729e-01f, -2.99159233e-02f, -1.26807898e-01f, -1.22467466e-01f, 3.46193872e-02f, 1.57145366e-01f,
  -1.41695067e-01f, 1.38274655e-02f, -5.92053086e-02f, -9.24007371e-02f, -2.10031033e-01f, -1.09944132e-03f, 1.83282986e-01f, 7.30257556e-02f, -9.87090636e-04f, -8.45361268e-04f,
  5.84982894e-02f, 1.60696357e-01f, -6.62515014e-02f, 3.94805819e-02f, 1.89272389e-01f, 1.64641198e-02f, 1.47358283e-01f, 1.03680126e-01f, -4.31040525e-02f, 4.00663286e-01f,
  3.21770430e-01f, 6.34719431e-02f, -2.43490469e-02f, -1.25411004e-01f, -1.68933738e-02f, 3.63888359e-03f, -6.76149968e-03f, 1.13892453e-02f, -1.17734976e-01f, 1.02902777e-01f,
  1.33525860e-02f, 5.72915971e-02f, 1.98369026e-02f, 3.51470560e-02f, 1.50898276e-02f, -3.37773189e-02f, 2.92200241e-02f, 2.52201185e-02f, 4.84723635e-02f, -8.29854012e-02f,
  2.00705556e-03f, 5.49814254e-02f, 1.80898234e-02f, -7.65794367e-02f, -2.21273303e-02f, 4.91749458e-02f, -6.87530860e-02f, -1.10520154e-01f, -1.73467681e-01f, 9.38527137e-02f,
  -3.67898867e-03f, 7.57735446e-02f, 3.52067919e-03f, -3.34558114e-02f, 6.09891629e-03f, 4.14568419e-03f, 4.56765480e-02f, 2.55295681e-03f, 4.15202267e-02f, -4.02105488e-02f,
  -2.83012446e-02f, -4.13271075e-04f, -3.30231749e-02f, -2.61154957e-02f, 9.39948484e-02f, -3.71155851e-02f, 4.29957286e-02f, -5.77561073e-02f, -4.57251891e-02f, 5.68616688e-02f,
  -1.99010852e-03f, -2.15214230e-02f, 7.15144649e-02f, -7.75544941e-02f, -3.57776938e-04f, -8.42375623e-04f, 3.51353511e-02f, -1.14647344e-01f, -2.04465818e-02f, 7.33739883e-02f,
  -6.84514865e-02f, -1.89681813e-01f, 1.93663493e-01f, -4.09059934e-02f, 1.37464032e-01f, -4.35299873e-02f, 1.20657504e-01f, -2.24546809e-02f, 1.35891497e-01f, 9.62206647e-02f,
  -9.13482830e-02f, 1.33987507e-02f, 8.15347657e-02f, -7.63484165e-02f, 1.03333211e-02f, -4.76944074e-03f, 5.69174346e-03f, 5.67305200e-02f, -1.32375136e-01f, -6.48887036e-03f,
  -4.44543362e-02f, 6.11155899e-03f, 2.97036488e-02f, -3.52643356e-02f, -1.39608691e-02f, 1.41190384e-02f, 3.85115552e-03f, -3.06996237e-02f, -8.03116262e-02f, -5.20312712e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.44583082e-01f, -3.68175268e-01f, 6.61819503e-02f, -5.29885471e-01f, -1.58960834e-01f, 1.31196214e-03f, -6.37157187e-02f, -1.10112168e-01f, -1.71513140e-01f, -2.42893070e-01f,
  -1.38770282e-01f, -3.66320610e-02f, -4.17074785e-02f, 8.55370164e-02f, 1.70882061e-01f, -1.73057750e-01f, -1.06737040e-01f, 8.27078298e-02f, 2.60539412e-01f, 1.93651736e-01f,
  -6.23054132e-02f, -7.11691454e-02f, -1.92781668e-02f, -1.84180588e-02f, -2.84220845e-01f, -4.65909764e-03f, -5.73569313e-02f, -1.83622226e-01f, 5.23978136e-02f, -1.96521804e-01f,
  7.20633566e-02f, -2.56674647e-01f, 1.67815194e-01f, 2.54805442e-02f, -5.70611022e-02f, -4.44070622e-02f, 1.61517656e-03f, -1.27331302e-01f, 1.82990674e-02f, -1.44861564e-01f,
  -1.18228337e-02f, 1.03959311e-02f, -3.10262907e-02f, -8.60125348e-02f, -3.94360200e-02f, 5.80793433e-02f, 9.83994221e-04f, 7.19507262e-02f, -2.84642656e-03f, 3.32609490e-02f,
  -3.58261690e-02f, -1.04865998e-01f, -2.77269762e-02f, 1.79742929e-02f, 1.09081477e-01f, 9.03874934e-02f, 8.99708644e-02f, -3.64621207e-02f, 1.52125373e-01f, -2.16426507e-01f,
  9.28341746e-02f, 4.34333682e-02f, -8.34414270e-03f, 3.00996955e-02f, -4.41405512e-02f, -1.14811929e-02f, -5.49792014e-02f, -6.14939677e-03f, 2.84339767e-02f, -9.50747356e-03f,
  -6.81319449e-04f, 3.19920182e-02f, -1.19651742e-02f, -3.75672355e-02f, -4.98926975e-02f, 1.38562247e-02f, 7.43760467e-02f, -6.25456823e-03f, -1.60264950e-02f, -3.91161218e-02f,
  -1.33576486e-02f, 8.54364932e-02f, -5.39817556e-04f, -4.69184965e-02f, 5.51815145e-02f, -4.75325994e-02f, -2.51790509e-03f, 1.27060190e-01f, 1.87325869e-02f, 2.73851976e-02f,
  -8.28762576e-02f, 3.22703391e-01f, -2.25235000e-01f, -7.73056075e-02f, -3.33133228e-02f, 3.82899083e-02f, -7.55473897e-02f, 3.19220155e-04f, -8.91074613e-02f, -3.28286774e-02f,
  3.32007068e-03f, 4.92835836e-03f, -7.52951875e-02f, 8.22408497e-02f, 3.67055647e-02f, 2.31650695e-02f, -2.24884832e-04f, -1.22211002e-01f, 8.18030164e-02f, -7.10422844e-02f,
  2.74759587e-02f, 2.87416554e-03f, -2.86730900e-02f, 8.94573927e-02f, -4.63358387e-02f, 1.08135030e-01f, 1.17981732e-01f, 1.27756931e-02f, 1.56149596e-01f, -1.01139382e-01f,
  -6.53989255e-01f, -3.73740681e-02f, 3.79592441e-02f, -5.31972796e-02f, -3.49925682e-02f, -6.64833635e-02f, 4.61580493e-02f, -1.92904919e-02f, -1.93687789e-02f, -7.54115358e-02f,
  -4.36667129e-02f, 4.03538421e-02f, 1.82824939e-01f, 5.74772395e-02f, 2.02612728e-01f, 1.72975019e-01f, 1.66647404e-01f, 7.29978904e-02f, 1.29326396e-02f, -6.61345199e-02f,
  7.72370175e-02f, -6.04224764e-02f, -5.38341980e-03f, 1.20554604e-01f, 8.84759277e-02f, 1.56895593e-02f, 1.92556247e-01f, 6.99838027e-02f, 3.45349349e-02f, 6.34544715e-02f,
  -2.64990419e-01f, -3.24954242e-01f, -3.14112939e-02f, -6.47363216e-02f, -1.54448841e-02f, 6.07451797e-03f, -6.53159767e-02f, -1.08196363e-01f, -3.17032710e-02f, 4.27853316e-03f,
  -9.33996290e-02f, -6.29298836e-02f, -5.42240068e-02f, -4.82442603e-02f, -1.38288438e-01f, 1.01146782e-02f, 6.56428337e-02f, -6.04523160e-02f, 7.36426711e-02f, -1.27960309e-01f,
  -3.00657842e-02f, -2.53867477e-01f, -1.82753876e-01f, -2.73136310e-02f, 5.54708689e-02f, -4.58081340e-04f, -3.35212313e-02f, -1.12949409e-01f, -4.24051769e-02f, -5.24340086e-02f,
  -4.75082994e-02f, -5.58528379e-02f, -3.79736931e-03f, 2.12594457e-02f, -1.15232654e-02f, 9.11841020e-02f, 1.57526862e-02f, -3.38529423e-02f, 8.46695304e-02f, 7.68131465e-02f,
  -4.08914359e-03f, -9.35197175e-02f, 6.00930937e-02f, 1.59256114e-03f, 2.71945521e-02f, -5.09912968e-02f, -3.16801220e-02f, 6.97858185e-02f, -3.94658148e-02f, -1.38830831e-02f,
  -6.84302896e-02f, 1.86928678e-02f, -9.93980560e-03f, 1.32154580e-02f, 5.23437969e-02f, 1.44993467e-02f, 5.38274786e-03f, 3.84329259e-02f, -1.10426042e-02f, 2.07237974e-02f,
  1.01744294e-01f, 7.45311305e-02f, -1.12933040e-01f, -8.56719166e-02f, -9.40907076e-02f, -5.65575669e-03f, -1.01758940e-02f, -7.60382339e-02f, 6.23772778e-02f, -2.24795304e-02f,
  -7.53146410e-02f, -6.88273162e-02f, -1.43960351e-02f, -8.46690498e-03f, -1.00976139e-01f, -2.33006962e-02f, -5.12419380e-02f, 6.34534061e-02f, 7.53375664e-02f, -5.03933839e-02f,
  -1.09809758e-02f, -5.23786284e-02f, -1.06460452e-01f, 6.53217882e-02f, -5.56510463e-02f, -3.19148190e-02f, -1.05873853e-01f, -9.16354433e-02f, -5.31904288e-02f, -2.13578530e-02f,
  -2.75751599e-03f, 1.22839428e-01f, 1.43970832e-01f, 1.28484726e-01f, 8.49908367e-02f, -1.02993911e-02f, -2.51862526e-01f, -1.70433968e-01f, -1.27249748e-01f, 1.08588874e-01f,
  1.45430937e-01f, 1.14678234e-01f, -1.69951413e-02f, -1.91981405e-01f, -3.05538327e-01f, -1.90720245e-01f, -1.11544013e-01f, -1.01881780e-01f, -2.75618136e-01f, -1.50803104e-01f,
  6.80366755e-02f, 4.77682054e-02f, -8.48807544e-02f, -1.65769842e-03f, 4.81540486e-02f, 1.59073338e-01f, 2.03910261e-01f, 2.23590046e-01f, 1.44067466e-01f, 1.18721463e-01f,
  1.03398606e-01f, -2.04846635e-02f, -5.29326089e-02f, 1.66339017e-02f, 6.84196204e-02f, 9.17094480e-03f, -3.86522487e-02f, -2.84843729e-03f, 4.66848761e-02f, -2.01527756e-02f,
  1.38699129e-01f, 3.64924259e-02f, 8.84091184e-02f, -7.94677287e-02f, -1.58997513e-02f, -1.56482995e-01f, -1.54151663e-01f, -1.72140434e-01f, -1.51714057e-01f, -1.28884628e-01f,
  1.07069217e-01f, 1.53688729e-01f, -7.39906961e-03f, -3.04840133e-02f, -1.31070405e-01f, 1.42608164e-02f, -7.56644905e-02f, -1.13868862e-01f, -3.31705548e-02f, 3.37708108e-02f,
  -1.00597329e-01f, -3.59128565e-02f, 1.85464099e-02f, -8.12282264e-02f, 1.43338442e-02f, 5.13852993e-03f, -3.04768756e-02f, 1.71239395e-02f, -1.06583178e-01f, 5.66850184e-03f,
  -9.92641412e-03f, 5.22643775e-02f, 2.43098699e-02f, 2.97044171e-03f, -3.20440531e-02f, 4.21423763e-02f, 5.39715253e-02f, -6.05446137e-02f, -3.87514271e-02f, -4.69123237e-02f,
  5.92852198e-02f, -1.08788060e-02f, 3.01024932e-02f, -1.12532228e-01f, 6.69695362e-02f, -2.21963655e-02f, 1.83104090e-02f, 2.91053802e-02f, 4.09735031e-02f, 5.76806627e-02f,
  1.71985868e-02f, 4.87300158e-02f, -1.27278119e-01f, -1.71770126e-01f, 1.06782215e-02f, 3.55094969e-02f, 7.66520798e-02f, 2.57228576e-02f, 1.12456672e-01f, -1.46722764e-01f,
  7.36078247e-02f, -5.05326800e-02f, 3.00730504e-02f, -7.89600164e-02f, -1.80607922e-02f, -9.10916179e-02f, -6.40752763e-02f, 2.09001061e-02f, 4.83391667e-03f, -4.26156744e-02f,
  -5.38223004e-03f, -1.92078918e-01f, -1.78200558e-01f, -1.46492422e-01f, -6.51968196e-02f, -2.39838455e-02f, 2.24108770e-02f, 4.89694290e-02f, -6.70091510e-02f, -3.94711196e-02f,
  -1.26146868e-01f, 1.04648888e-01f, -8.70811045e-02f, 6.19315207e-02f, 5.87410666e-02f, 1.50705025e-01f, 1.61219448e-01f, 5.66482991e-02f, 1.36026368e-01f, 4.41491753e-02f,
  1.76921234e-01f, 1.99583948e-01f, 1.00878671e-01f, 8.16920549e-02f, 1.61325336e-01f, 1.85543019e-02f, -8.48255306e-03f, -2.73501333e-02f, -1.64484084e-01f, 3.66311036e-02f,
  5.15801869e-02f, -4.07244638e-03f, -8.09243694e-02f, 1.65456235e-02f, -9.78468284e-02f, 1.02085760e-02f, -2.22818255e-02f, 4.40048501e-02f, -6.57480815e-03f, -4.97474261e-02f,
  4.65815538e-04f, 9.27857757e-02f, 2.38272157e-02f, 7.48040155e-02f, -3.84329334e-02f, -1.15553066e-01f, -8.26818347e-02f, -7.81938657e-02f, -6.84196949e-02f, -6.20885938e-02f,
  -2.10807398e-02f, -3.59251350e-02f, -5.28991222e-03f, -4.52395342e-02f, 5.81318811e-02f, -2.88065337e-02f, 7.32793659e-02f, 2.60530170e-02f, 7.49486638e-03f, 1.20265141e-01f,
  7.78217763e-02f, 2.45240275e-02f, 2.15816554e-02f, 1.95345089e-01f, 1.90458134e-01f, 8.65178704e-02f, 1.30932992e-02f, 1.10509293e-02f, 1.27620652e-01f, 7.58937150e-02f,
  4.56665754e-02f, 6.62400424e-02f, 1.74507797e-02f, 9.29626264e-03f, 8.78068283e-02f, 3.01651959e-03f, -7.32254013e-02f, -1.78326778e-02f, 5.69318347e-02f, -3.31425779e-02f,
  6.87318146e-02f, -4.94275987e-02f, 3.41478847e-02f, -9.54048410e-02f, -7.35422447e-02f, -6.16450682e-02f, -2.29017530e-03f, 7.81896412e-02f, 8.34045559e-02f, 1.90758482e-02f,
  -6.93657547e-02f, 5.50019667e-02f, -1.06711410e-01f, -2.51245722e-02f, 2.41777021e-03f, -2.27022842e-02f, 6.61012083e-02f, -2.02935077e-02f, -6.33516088e-02f, 2.21574605e-02f,
  3.99821289e-02f, 1.47326142e-01f, -6.99622408e-02f, -8.39373618e-02f, -8.90450329e-02f, -5.14667332e-02f, 9.90162268e-02f, -1.15541644e-01f, 1.46460086e-02f, 3.98708135e-02f,
  4.82519381e-02f, -1.19175076e-01f, -6.85227336e-03f, -2.44163792e-03f, -3.45753431e-02f, -1.15160027e-03f, 8.67927819e-02f, 6.83681890e-02f, 1.55589387e-01f, 1.39219463e-02f,
  1.12877935e-01f, 7.99099058e-02f, -2.62226108e-02f, 5.76140136e-02f, 7.82934204e-03f, 9.91390198e-02f, 4.00668904e-02f, -1.78884678e-02f, 6.48221225e-02f, -9.95744020e-02f,
  -6.56590657e-03f, 3.78252238e-01f, 2.60081947e-01f, 8.87417048e-02f, 3.07870626e-01f, 4.17817235e-01f, 5.35276711e-01f, 2.67341584e-01f, -1.95498820e-02f, 1.07333042e-01f,
  2.85668164e-01f, 2.35889070e-02f, 8.13272521e-02f, -4.13954481e-02f, 1.15685903e-01f, 1.40880123e-02f, -1.35244755e-02f, -1.31445467e-01f, 3.65279727e-02f, -1.52558032e-02f,
  1.03459559e-01f, -1.09472312e-02f, 2.60586850e-02f, -5.65236807e-02f, 3.14241759e-02f, -5.43439388e-02f, 2.16825008e-02f, 9.18962359e-02f, 1.68067858e-01f, -2.35978946e-01f,
  -1.65637910e-01f, 2.08918974e-01f, -1.55084848e-01f, -9.93328169e-02f, 1.83296017e-02f, -1.88804820e-01f, 2.50693541e-02f, -6.53623268e-02f, -4.73597720e-02f, -2.56767664e-02f,
  -6.17079921e-02f, -1.27709946e-02f, 4.17813249e-02f, -1.14547119e-01f, 8.77786353e-02f, -1.02275230e-01f, -7.16098174e-02f, -7.34654218e-02f, 1.99808143e-02f, -1.18490316e-01f,
  1.89699326e-02f, 1.54416636e-01f, 3.23691890e-02f, -3.00793312e-02f, 7.11344108e-02f, -8.34196061e-02f, 7.98381791e-02f, -2.15459019e-02f, 2.68909261e-02f, -1.60093844e-01f,
  -7.24105909e-02f, 8.44260026e-03f, 4.81659584e-02f, 1.61391888e-02f, 2.08914727e-02f, -9.94708687e-02f, -4.87896875e-02f, 9.97895822e-02f, -4.63281311e-02f, -4.20492254e-02f,
  3.98426428e-02f, -6.24672994e-02f, -2.72338949e-02f, 6.99691102e-03f, -3.54446918e-02f, -1.89589318e-02f, -3.82153876e-02f, 1.78216845e-02f, -1.34080900e-02f, -2.71852519e-02f,
  2.55426988e-02f, 1.75919197e-02f, 6.09762035e-03f, 2.37504821e-02f, -8.42510462e-02f, -4.47495468e-03f, -3.08816619e-02f, 5.77354953e-02f, -4.31724824e-02f, 1.02915606e-02f,
  -1.06941707e-01f, 2.35416636e-01f, -1.98135912e-01f, -1.22869320e-01f, -8.00093170e-03f, -9.26951617e-02f, -2.73597259e-02f, -4.82215993e-02f, 3.54215764e-02f, -6.82011843e-02f,
  3.68865505e-02f, -7.76238693e-03f, 1.47198901e-01f, -2.57295072e-02f, -2.42395122e-02f, -6.58286735e-02f, 4.19749469e-02f, -9.03588086e-02f, -3.70179899e-02f, -1.37683004e-01f,
  -2.12511495e-02f, -6.52574450e-02f, -8.00028220e-02f, -4.12057303e-02f, -1.17218539e-01f, -1.16987519e-01f, -3.18618119e-02f, -3.45592387e-02f, -5.05038947e-02f, -1.13473132e-01f,
  3.07616562e-01f, 3.60197306e-01f, 1.95882514e-01f, 9.96168330e-02f, 8.91972929e-02f, 3.12238112e-02f, 4.69447859e-02f, -1.31324023e-01f, 1.59820933e-02f, 1.58565715e-01f,
  2.22935468e-01f, -1.23152643e-01f, -1.89552665e-01f, -2.57137090e-01f, -2.98348546e-01f, -1.08259797e-01f, -1.87907398e-01f, -3.24219078e-01f, -3.32235783e-01f, -2.85739779e-01f,
  -8.48909318e-02f, -1.05233088e-01f, -4.23757881e-02f, -2.67488835e-03f, 2.21673906e-01f, -4.84862961e-02f, 2.39417240e-01f, 2.81897396e-01f, 9.25165191e-02f, 1.81007028e-01f,
  1.91886574e-01f, 5.22365212e-01f, -3.48254323e-01f, -6.52386574e-03f, 1.83007643e-01f, -4.81725633e-02f, 6.22647814e-02f, 9.42183509e-02f, 5.21465763e-02f, 1.57211646e-02f,
  9.64427590e-02f, -7.99826011e-02f, -2.99475361e-02f, -3.69172171e-02f, -4.82141078e-02f, -1.30222574e-01f, -2.56460942e-02f, -1.15565069e-01f, -1.72729820e-01f, 1.09754233e-02f,
  4.22978625e-02f, 1.72414109e-01f, 1.90393612e-01f, -5.13697490e-02f, 1.49333375e-02f, -1.41881138e-01f, 1.69618055e-01f, 1.15685306e-01f, 9.68930945e-02f, 4.64134552e-02f,
  -5.94686382e-02f, -2.80713271e-02f, 5.55133335e-02f, -8.29063007e-04f, -9.43812430e-02f, 1.54567063e-02f, 2.22386047e-02f, 2.18816777e-03f, 9.41408973e-04f, 1.99051574e-02f,
  8.20733141e-03f, 7.61249512e-02f, -3.81793007e-02f, -2.41317991e-02f, -5.33070564e-02f, 5.03959842e-02f, -8.08594003e-02f, 1.55326654e-03f, -3.75438854e-02f, 5.63488007e-02f,
  -1.74207182e-03f, -3.55954729e-02f, 1.21899441e-01f, -5.72513714e-02f, -3.23995240e-02f, -1.71704534e-02f, 1.99789386e-02f, 5.02534956e-02f, -1.13130668e-02f, 1.01754703e-01f,
  -1.27631292e-01f, -1.48989245e-01f, -1.00675002e-01f, -5.00908792e-02f, 1.11917831e-01f, 6.24471251e-03f, 5.42655662e-02f, -3.76256779e-02f, 7.38560036e-02f, -1.04436569e-01f,
  6.30896017e-02f, 1.19752213e-02f, 6.10544113e-03f, -9.74142998e-02f, -1.53020352e-01f, -1.87009890e-02f, -4.45378125e-02f, -7.95182660e-02f, -1.14215456e-01f, 2.63300668e-02f,
  -4.12684940e-02f, -2.36284330e-01f, -1.57011360e-01f, -2.03654140e-01f, 6.79827877e-04f, -2.13211834e-01f, -1.08467944e-01f, -1.70623809e-01f, -1.70932963e-01f, -2.38406017e-01f,
  4.60598111e-01f, -3.08467418e-01f, 1.32799968e-01f, 3.25450480e-01f, 2.77321488e-01f, 3.32760185e-01f, 2.40931854e-01f, 1.92425713e-01f, 2.46479660e-01f, -3.61981578e-02f,
  -2.15094194e-01f, -1.75437987e-01f, -9.98724326e-02f, -1.58103183e-01f, -1.45351052e-01f, 4.99248318e-02f, 2.02365220e-01f, 6.48729652e-02f, 2.60459274e-01f, 1.46242857e-01f,
  3.06699965e-02f, 1.59140825e-01f, 4.28544767e-02f, -2.97088325e-02f, -1.05948403e-01f, 5.96901253e-02f, -3.63982990e-02f, -1.48775905e-01f, -7.47803301e-02f, -1.97696283e-01f,
  -4.03087348e-01f, -2.30937749e-01f, 1.12205617e-01f, -6.61511868e-02f, -1.12195678e-01f, -3.96698788e-02f, 3.19790430e-02f, 3.63582782e-02f, 1.47863263e-02f, -1.47412401e-02f,
  -1.05986625e-01f, -1.01172484e-01f, -2.39696559e-02f, -2.59858482e-02f, 2.01274436e-02f, -1.03164930e-02f, -8.49355571e-03f, -6.06701057e-03f, -1.80558473e-01f, -1.74349323e-01f,
  -2.07663834e-01f, -5.39711080e-02f, -6.20286316e-02f, 1.59032457e-02f, -1.76082894e-01f, -3.38605605e-02f, -2.30473146e-01f, -8.48917887e-02f, -3.08431033e-02f, 2.36782413e-02f,
  -1.19861076e-03f, 1.25617385e-02f, -2.17544287e-02f, 4.12443690e-02f, -6.56786114e-02f, 2.85361726e-02f, 3.05510182e-02f, 2.60298997e-02f, 7.81096369e-02f, 1.31621910e-02f,
  2.46197972e-02f, -6.67015696e-03f, 4.45500724e-02f, 9.69578996e-02f, -5.48352972e-02f, -5.66247739e-02f, -3.25278342e-02f, 3.28607634e-02f, -6.12200350e-02f, 5.22381514e-02f,
  1.84007548e-02f, 7.77132660e-02f, 5.23159653e-02f, -1.28185079e-01f, -5.20306192e-02f, -1.30572002e-02f, 3.21824811e-02f, -4.83069122e-02f, 3.05055175e-02f, 6.79537235e-03f,
  7.25285932e-02f, 1.51696742e-01f, 6.14274852e-03f, -1.04227021e-01f, -5.49264401e-02f, -9.32915732e-02f, -9.48301237e-03f, -7.13674054e-02f, -2.59934366e-02f, -3.64177935e-02f,
  -8.01871195e-02f, -3.60436924e-02f, -7.08253533e-02f, 2.99060531e-02f, 2.31907696e-01f, 1.62903994e-01f, -7.43914172e-02f, 5.95222749e-02f, -3.85947414e-02f, -7.56348148e-02f,
  -9.32977870e-02f, 3.01324069e-01f, 1.93474844e-01f, 1.83955893e-01f, 6.90707192e-02f, 2.94091403e-01f, 9.81529132e-02f, 4.36195768e-02f, 2.15213835e-01f, 4.17532325e-01f,
  9.30000562e-03f, 2.32570678e-01f, -3.31104010e-01f, 1.53257385e-01f, -1.06419004e-01f, -2.85436690e-01f, -1.63137596e-02f, 4.72531505e-02f, 4.23739217e-02f, 1.84805751e-01f,
  -4.98989820e-02f, -2.35520959e-01f, -1.42297015e-01f, -2.76737005e-01f, -3.52781147e-01f, -3.89035456e-02f, -1.20815992e-01f, -4.86840248e-01f, -4.75531667e-01f, -2.37712666e-01f,
  -1.39311031e-01f, -3.56150307e-02f, -1.52278587e-01f, -1.25836700e-01f, 1.14226282e-01f, -2.59203501e-02f, -7.10375682e-02f, -8.94026458e-02f, -1.74335301e-01f, 3.19670816e-03f,
  -3.12628716e-01f, -3.46420631e-02f, -1.98420197e-01f, 6.98228180e-02f, -3.43859717e-02f, 6.39498373e-03f, -8.11568499e-02f, -3.99415381e-02f, -8.30237567e-02f, -4.85972613e-02f,
  -2.89550703e-02f, 2.94103324e-02f, -5.43379076e-02f, -1.35683000e-01f, -1.44230854e-02f, -3.02062463e-02f, 1.27505973e-01f, -1.69954628e-01f, -1.88836887e-01f, 4.91518080e-02f,
  -1.83676984e-02f, -1.29117608e-01f, -2.68588215e-01f, 1.15438818e-03f, -1.31147563e-01f, -1.29867584e-01f, -3.33379023e-02f, -9.93326306e-02f, -1.92222178e-01f, 2.16670483e-01f,
  9.52805951e-02f, -6.71776012e-02f, 2.61528641e-02f, 1.65939815e-02f, 9.42291506e-03f, -2.16040909e-02f, -6.32031262e-02f, -4.29129554e-03f, 3.34609225e-02f, -1.21802781e-02f,
  -9.41283442e-03f, -1.79717746e-02f, 5.76325953e-02f, 7.54099786e-02f, -4.33776379e-02f, 1.61748417e-02f, 3.05892210e-02f, 6.32225052e-02f, 1.92862730e-02f, -7.10041821e-02f,
  -6.08809441e-02f, -3.46905291e-02f, -6.32979581e-03f, 2.85883690e-03f, -5.63189648e-02f, 1.67875197e-02f, 1.52233979e-02f, 2.75986027e-02f, 8.32773186e-03f, 3.72888148e-02f,
  2.28481084e-01f, -2.03316376e-01f, 4.18355800e-02f, -4.76021282e-02f, -8.78884345e-02f, 4.87101860e-02f, 8.05234835e-02f, -2.22038534e-02f, -7.06092790e-02f, -6.99910298e-02f,
  -5.82611188e-02f, -7.55576566e-02f, 9.05004293e-02f, 7.50481635e-02f, -3.91690545e-02f, -5.75879179e-02f, 1.17593654e-01f, -6.63670972e-02f, -1.27565950e-01f, 1.28137216e-01f,
  1.89193904e-01f, -7.48018920e-02f, -1.02698654e-01f, 7.62497932e-02f, -8.94716978e-02f, -2.33268544e-01f, -1.06096566e-01f, -4.30860892e-02f, -1.95137501e-01f, 3.50578308e-01f,
  4.26096410e-01f, 4.14842844e-01f, 2.23797292e-01f, 1.26460344e-01f, 6.29503280e-02f, 2.26718664e-01f, 2.26490498e-01f, 6.58018962e-02f, 9.26536135e-03f, 3.02107837e-02f,
  1.48281276e-01f, -1.40953988e-01f, -1.06313147e-01f, 6.70217350e-02f, 1.29312202e-01f, 1.48437425e-01f, 1.01035088e-02f, 1.02677438e-02f, -6.80611730e-02f, 9.25594103e-03f,
  3.63834724e-02f, 3.39716338e-02f, 1.08160205e-01f, -5.78194745e-02f, -4.89271171e-02f, -4.56343740e-02f, 2.83608455e-02f, 3.18620875e-02f, 4.52797636e-02f, -2.11058147e-02f,
  1.52484607e-02f, 4.51432437e-01f, -2.88087040e-01f, -1.67231947e-01f, -1.10988636e-02f, 3.38092931e-02f, 3.39639299e-02f, 8.97743925e-03f, 2.40184944e-02f, 6.82828873e-02f,
  5.25344722e-02f, 1.46202892e-02f, 9.40382704e-02f, 4.58387062e-02f, -1.39212487e-02f, 9.18880850e-02f, 9.94329751e-02f, 1.08922489e-01f, -7.99565241e-02f, 2.93835197e-02f,
  -4.77987975e-02f, 7.71114603e-02f, 2.63083987e-02f, -8.52001905e-02f, 5.95019152e-03f, -9.04087201e-02f, 3.52982879e-02f, -5.33824340e-02f, -1.76784080e-02f, 8.43829289e-02f,
  -6.61077499e-02f, 5.23644015e-02f, -3.05215493e-02f, -5.60549600e-03f, 5.31289950e-02f, -8.17325339e-02f, 7.15079755e-02f, -7.39305243e-02f, 2.79070754e-02f, 2.03181673e-02f,
  -4.55701761e-02f, 7.22134858e-02f, 9.88390967e-02f, -1.66551825e-02f, -4.36855145e-02f, 2.79196780e-02f, 1.02481149e-01f, 4.33337651e-02f, 8.68506730e-02f, -5.46216667e-02f,
  2.64595903e-04f, 3.59365568e-02f, 7.09817857e-02f, 5.07220589e-02f, -7.51517937e-02f, -6.17755949e-03f, -4.26324084e-02f, 7.67601132e-02f, 1.94567384e-03f, 7.08601698e-02f,
  -2.72420257e-01f, -9.10610259e-02f, -9.94087234e-02f, -1.12060942e-01f, 4.38118540e-02f, -9.80727673e-02f, 3.51091027e-02f, -7.80753195e-02f, 2.89540123e-02f, -9.60181747e-03f,
  6.37199804e-02f, -7.37686595e-03f, -3.87993157e-02f, 5.47295362e-02f, -1.08961739e-01f, -6.55237660e-02f, 7.13509833e-03f, -1.15174226e-01f, -5.34489900e-02f, -2.60582864e-02f,
  -9.25549492e-02f, -1.36986598e-01f, -1.85209259e-01f, -5.44284508e-02f, -1.64962914e-02f, -8.62394795e-02f, -1.13453180e-01f, -1.47376925e-01f, -4.59141396e-02f, -7.13155419e-02f,
  3.91032159e-01f, 6.07588217e-02f, 3.09992671e-01f, -6.02949336e-02f, -3.55431169e-01f, -1.42903641e-01f, -1.48897767e-01f, -5.89855053e-02f, -5.07531576e-02f, -5.59524680e-03f,
  -9.28813815e-02f, -1.81155056e-01f, 3.21185887e-02f, 8.34882036e-02f, 1.61518231e-01f, 1.88064143e-01f, 1.17836334e-03f, 1.85901314e-01f, 2.09860563e-01f, 8.62900726e-03f,
  -5.13403974e-02f, 7.52014965e-02f, 2.63718069e-01f, 1.19064152e-01f, -4.31066565e-02f, -2.74527371e-02f, 1.83804780e-01f, 2.68388018e-02f, -1.45848433e-03f, 4.94858762e-03f,
  2.21350968e-01f, -3.31903286e-02f, 1.05454447e-02f, -1.65440321e-01f, -8.72563571e-02f, -1.17762084e-03f, -1.73266511e-02f, 1.39821619e-01f, 1.50701394e-02f, 6.20081909e-02f,
  -9.83081535e-02f, -1.50598094e-01f, -2.68099774e-02f, -6.49583563e-02f, -1.26993842e-02f, -1.38651831e-02f, 1.57126784e-01f, 2.39152983e-01f, -1.84481647e-02f, -1.40311588e-02f,
  -2.75408775e-01f, -1.58907011e-01f, 6.21605702e-02f, -3.13839167e-02f, -9.73563343e-02f, -1.13752589e-01f, -7.65434206e-02f, 2.82967724e-02f, 6.67765811e-02f, 1.64224371e-01f,
  -8.33027959e-02f, -5.76625252e-03f, -1.72778852e-02f, -4.54666764e-02f, 5.53031936e-02f, 4.41611223e-02f, -7.69542083e-02f, -7.75933936e-02f, -5.19260317e-02f, 1.08489312e-01f,
  -2.83720084e-02f, 6.27187863e-02f, 2.07498390e-02f, 8.07404816e-02f, -2.10614977e-04f, -9.50019062e-02f, -1.27489325e-02f, 8.47506300e-02f, 1.53181292e-02f, -7.20745996e-02f,
  2.48606261e-02f, 4.37678881e-02f, 1.78345442e-02f, 3.92708498e-05f, -3.02577186e-02f, -4.68435660e-02f, 4.96076979e-02f, -6.81657568e-02f, 1.52180744e-02f, 7.21315145e-02f,
  1.64126322e-01f, -2.22552702e-01f, 5.42156631e-03f, 6.63437918e-02f, -1.49089828e-01f, -2.73177791e-02f, -1.41244859e-01f, -8.78120735e-02f, -7.44801164e-02f, 8.00901502e-02f,
  -6.84636682e-02f, -6.44927099e-02f, 1.81303918e-02f, 6.23901328e-03f, 6.52112285e-05f, -1.08732857e-01f, -4.03344855e-02f, -2.33929958e-02f, -7.91547820e-02f, -1.38044904e-03f,
  -3.86685953e-02f, -6.96091726e-02f, 2.97522563e-02f, 8.81782174e-02f, -1.11820512e-02f, -1.63760513e-01f, 1.49816990e-01f, -5.59437722e-02f, 5.02617322e-02f, 2.07152843e-01f,
  -2.89688677e-01f, -4.60568309e-01f, -3.58528718e-02f, 1.02061622e-01f, 2.87630320e-01f, -1.44468218e-01f, -3.95520627e-01f, -1.44556955e-01f, 3.05223167e-02f, -1.94701314e-01f,
  -7.92914927e-02f, 1.46456540e-01f, -4.49090637e-02f, 1.23116016e-01f, -8.21616724e-02f, -2.30556369e-01f, 8.64792615e-02f, 2.27014259e-01f, 1.34478047e-01f, 1.92032643e-02f,
  2.17031807e-01f, 2.69643664e-01f, 1.04219280e-01f, 1.15449972e-01f, 8.93638507e-02f, 2.24388480e-01f, 7.25109205e-02f, 1.12904795e-01f, 1.75413601e-02f, -4.68311869e-02f,
  -2.47012019e-01f, -3.00753534e-01f, 1.49831310e-01f, 6.81816712e-02f, 1.85150221e-01f, -8.22924078e-02f, -1.62889704e-01f, 7.64527172e-02f, -1.03581227e-01f, -1.04021810e-01f,
  1.05452001e-01f, -1.64506398e-02f, 9.92880464e-02f, -5.99679574e-02f, 2.24868879e-02f, -1.10585280e-01f, 5.53477928e-02f, -6.11201935e-02f, -6.04876317e-02f, -5.36952093e-02f,
  1.32814825e-01f, 8.61925930e-02f, -1.58153355e-01f, -1.48969755e-01f, -8.01024362e-02f, -1.74978515e-03f, -1.16859101e-01f, -1.42923951e-01f, -1.35866061e-01f, -3.21386516e-01f,
  3.83509439e-03f, 5.39709516e-02f, -3.25628668e-02f, -5.81650585e-02f, -3.03413905e-02f, -7.06203878e-02f, 3.70074878e-03f, 8.20872113e-02f, 5.98724894e-02f, -2.49192603e-02f,
  1.31285284e-02f, -4.03943807e-02f, 2.21685078e-02f, -6.94758967e-02f, -2.42795242e-04f, 1.29208611e-02f, 3.91570665e-03f, -5.22561790e-03f, 6.60419688e-02f, 8.25242884e-03f,
  -4.51241806e-02f, 5.44962548e-02f, 1.19853653e-01f, 2.87869126e-02f, -1.89735070e-02f, -5.33952639e-02f, -2.18908247e-02f, 2.94276532e-02f, 2.69129649e-02f, -1.02625951e-01f,
  -1.34637877e-01f, 2.09731698e-01f, -2.31797963e-01f, -9.93909389e-02f, 5.70492558e-02f, -1.26386695e-02f, -8.20135698e-02f, -4.69960533e-02f, 8.62314738e-03f, -6.83272481e-02f,
  -3.88121754e-02f, -1.18763492e-01f, -8.74814689e-02f, -5.46740182e-02f, -2.89749186e-02f, -2.08036248e-02f, -9.91563350e-02f, -5.25406040e-02f, -8.09224024e-02f, -2.05537304e-02f,
  5.34675494e-02f, -1.78085998e-01f, -2.23555654e-01f, -9.88191515e-02f, -5.78188803e-03f, -9.51138139e-02f, -1.19648173e-01f, -1.25286981e-01f, -1.01096369e-01f, -3.54696572e-01f,
  7.01189578e-01f, -4.07099038e-01f, -6.87161624e-01f, 6.88947961e-02f, -2.46413708e-01f, -4.86596346e-01f, -4.68633145e-01f, -1.85220122e-01f, 4.47402745e-02f, -1.45929977e-01f,
  1.45205250e-02f, 4.03603226e-01f, 3.96933913e-01f, 3.13547432e-01f, 1.60152882e-01f, -4.67529505e-01f, -3.83882225e-01f, 8.08375850e-02f, 3.22475195e-01f, 2.08344266e-01f,
  1.47207186e-01f, 2.47722998e-01f, 3.98544401e-01f, 3.20384745e-03f, -2.03992605e-01f, 4.68492992e-02f, -2.83102810e-01f, -2.04340577e-01f, -1.97883397e-01f, -1.74220234e-01f,
  -1.84641227e-01f, -2.25145951e-01f, 1.03313737e-01f, 2.49582529e-01f, -1.12115882e-01f, -2.35341415e-02f, -3.39506380e-02f, -8.56400505e-02f, -1.19129643e-02f, -1.09650500e-01f,
  3.04336287e-02f, -2.75619775e-02f, 7.32550621e-02f, -1.15947768e-01f, -7.81086013e-02f, -3.48846987e-02f, -4.38013710e-02f, -8.33956599e-02f, -3.73081528e-02f, -1.07854463e-01f,
  -6.94934949e-02f, -8.73041302e-02f, -5.58239929e-02f, -1.46388128e-01f, -2.01046959e-01f, 6.79724365e-02f, -3.09807748e-01f, -1.44788995e-01f, -8.50582346e-02f, -1.93428248e-01f,
  1.95407029e-02f, -2.81853955e-02f, 6.46650617e-04f, 4.10936065e-02f, 5.81888855e-02f, -4.79821824e-02f, -5.70531376e-02f, -5.93287218e-03f, 6.86540306e-02f, -3.92718017e-02f,
  2.56507639e-02f, 3.47609818e-02f, -4.49079610e-02f, 1.45722730e-02f, 3.60710621e-02f, -1.45324722e-01f, -6.12591766e-03f, -2.07795836e-02f, 6.86818212e-02f, -9.27617121e-03f,
  1.40145898e-01f, -4.14653346e-02f, -4.40513566e-02f, 3.14878151e-02f, -8.88196155e-02f, 7.35307299e-03f, -2.99184304e-02f, 1.68210883e-02f, 4.66924645e-02f, -5.09971678e-02f,
  2.54901737e-01f, 1.66717261e-01f, 1.70977339e-02f, 1.39248490e-01f, -1.69651672e-01f, -2.32152808e-02f, -1.40417349e-02f, -3.93351912e-02f, 9.03038215e-03f, -7.05572292e-02f,
  -2.62565669e-02f, 3.25431451e-02f, -1.17351534e-02f, -2.79234070e-02f, 5.84154278e-02f, -6.63049296e-02f, -1.86574440e-02f, 1.01998635e-01f, -1.50289070e-02f, -8.12785104e-02f,
  -3.25035565e-02f, -6.90193549e-02f, 1.59482256e-01f, -9.67609361e-02f, -5.57872234e-03f, 2.50518054e-01f, -4.84793819e-02f, -1.48155719e-01f, -3.80210727e-02f, 1.31449837e-03f,
  3.87253642e-01f, 1.94243327e-01f, -3.81752938e-01f, 2.40001515e-01f, -1.81491613e-01f, -2.85335571e-01f, -2.88795620e-01f, -1.24731446e-02f, 1.84661090e-01f, 1.14798173e-01f,
  1.31152228e-01f, 6.00984991e-02f, -2.86818272e-03f, -9.53049734e-02f, -1.95598289e-01f, -7.45433196e-02f, -1.71623796e-01f, -2.88470000e-01f, -3.62092137e-01f, -3.34138572e-01f,
  4.89767231e-02f, 7.00251982e-02f, -3.18425409e-02f, -8.09363425e-02f, 1.06144972e-01f, 9.30554718e-02f, 2.74271779e-02f, 5.26663475e-03f, -4.56408486e-02f, 6.50516665e-03f,
  -2.08732024e-01f, -1.96317777e-01f, -9.21669155e-02f, 1.01823017e-01f, 5.60517982e-02f, -3.38877328e-02f, -2.19011512e-02f, 7.43052065e-02f, 8.97638723e-02f, -3.08015030e-02f,
  -3.27520706e-02f, 9.79167782e-03f, -5.58742359e-02f, 5.45829758e-02f, 3.66543122e-02f, -8.46778825e-02f, -2.72728931e-02f, -1.48347408e-01f, -4.86426055e-03f, -8.24848711e-02f,
  1.15206745e-03f, -1.77790284e-01f, -1.64137989e-01f, -1.13732703e-01f, -1.83222756e-01f, -4.71983291e-02f, -5.01451679e-02f, -1.91628560e-01f, -1.58715099e-01f, 1.61091074e-01f,
  2.17469428e-02f, 1.14391133e-01f, -5.48203923e-02f, 1.01205744e-01f, 7.52170607e-02f, 6.73343316e-02f, 2.81442106e-02f, 5.80918305e-02f, -1.40153915e-02f, 1.21933967e-02f,
  -4.38548848e-02f, -2.01287307e-02f, 6.09844783e-03f, 5.43459095e-02f, -3.88709642e-02f, -3.95047106e-02f, 1.52301537e-02f, 7.97239244e-02f, -5.40338345e-02f, 6.30249828e-02f,
  -4.94951010e-02f, -8.15535784e-02f, 1.42879933e-01f, -7.52338488e-03f, 2.25695670e-02f, -9.88739543e-03f, -3.11761033e-02f, 2.42851842e-02f, 5.64837083e-02f, -3.25038955e-02f,
  4.09543067e-01f, -2.19461963e-01f, 9.36937332e-02f, -3.73857282e-02f, 1.84464622e-02f, 7.29781315e-02f, 5.53478897e-02f, -2.52357777e-03f, 1.28484711e-01f, 8.60954151e-02f,
  -1.38497353e-01f, 5.28301038e-02f, 1.86818410e-02f, -3.11871227e-02f, -9.34747905e-02f, 1.97419450e-02f, 1.56898677e-01f, -3.57014351e-02f, 1.14856455e-02f, 2.74667162e-02f,
  1.45946637e-01f, 7.07501024e-02f, 8.62255320e-02f, 7.28504807e-02f, 5.18791042e-02f, -2.48408876e-02f, -5.55812055e-03f, 3.12341377e-02f, -5.94442450e-02f, 4.19411689e-01f,
  5.84957302e-01f, 2.43030891e-01f, 1.80259794e-01f, 5.24255866e-03f, -2.82699019e-01f, -2.77858704e-01f, -2.27822006e-01f, 8.61472785e-02f, 4.06873561e-02f, -6.93562478e-02f,
  -2.45256633e-01f, -1.27230406e-01f, 9.37036425e-02f, 1.61099598e-01f, 2.95297474e-01f, 7.31275156e-02f, 1.72922667e-02f, 3.23987365e-01f, 1.35345533e-01f, -1.52405426e-01f,
  -1.56558141e-01f, 3.38711180e-02f, 1.60825178e-01f, 1.55883715e-01f, -1.79997366e-02f, -1.23716436e-01f, 1.24616325e-01f, -5.23457900e-02f, -8.37766901e-02f, 9.09637809e-02f,
  -3.78601961e-02f, 3.64811420e-01f, -1.11916669e-01f, -6.54419186e-03f, -7.73945600e-02f, 1.65078625e-01f, -3.54712605e-02f, 2.94440836e-02f, -4.61244173e-02f, -5.14636077e-02f,
  -1.64984792e-01f, 1.28933983e-02f, -2.65870616e-02f, -8.45518261e-02f, -8.86374190e-02f, -8.80945995e-02f, 7.64153227e-02f, 1.99656948e-01f, 9.51498300e-02f, -4.82065566e-02f,
  -1.67382106e-01f, -1.44255340e-01f, -1.02560729e-01f, -2.04434395e-02f, 1.63725287e-01f, -1.98893528e-02f, 9.08120796e-02f, 2.70631313e-02f, 1.28518030e-01f, 1.24964021e-01f,
  1.38212601e-02f, 7.64545277e-02f, -9.65145137e-03f, -4.36685886e-03f, -9.53012034e-02f, -1.21056810e-01f, -1.08961640e-02f, -3.42130102e-02f, 3.97597030e-02f, -7.17330053e-02f,
  -2.92117987e-02f, -1.50586767e-02f, -2.96680070e-02f, -1.85116082e-02f, -8.42347518e-02f, -1.48501340e-02f, -9.99978036e-02f, 3.66358943e-02f, -7.75633678e-02f, 5.84542714e-02f,
  -4.91043404e-02f, 1.95253231e-02f, -5.60340211e-02f, -1.59131326e-02f, 1.28152920e-02f, 5.76480627e-02f, -8.03602710e-02f, 2.31001875e-03f, -4.43067104e-02f, -6.21954948e-02f,
  -3.47584039e-01f, 1.35821775e-01f, -3.59225236e-02f, 1.40859216e-01f, 4.90557868e-03f, 8.30408111e-02f, -2.05979720e-02f, 1.00265980e-01f, 4.09916267e-02f, -3.06811314e-02f,
  -2.61251088e-02f, 1.54098466e-01f, 1.95539482e-02f, -1.09597752e-02f, -9.57166478e-02f, -1.06225330e-02f, -1.19687930e-01f, -4.13232073e-02f, -1.66987965e-03f, 4.97167930e-02f,
  -9.28502083e-02f, -1.86237961e-01f, -8.81783441e-02f, -9.66732726e-02f, 7.74936425e-03f, 3.19885351e-02f, -7.43855387e-02f, -9.63739294e-04f, -7.94742256e-02f, -2.97694728e-02f,
  2.37608910e-01f, 1.57334045e-01f, 1.48453899e-02f, 3.03392589e-01f, 1.91773370e-01f, 1.66938558e-01f, 8.25539231e-02f, 1.03076436e-01f, 1.39998853e-01f, 2.99196750e-01f,
  1.26626983e-01f, 2.77115196e-01f, 1.20574944e-01f, 1.76704064e-01f, 2.13652402e-02f, 1.85127839e-01f, 1.03553608e-01f, 3.03233564e-02f, 8.27945173e-02f, 1.40097663e-01f,
  3.43203336e-01f, 1.86201289e-01f, 6.06983528e-02f, 1.79664955e-01f, 3.81244093e-01f, 2.17375219e-01f, 1.40707552e-01f, 6.79349899e-02f, 1.47276685e-01f, 4.15207922e-01f,
  1.24656387e-01f, -2.78416798e-02f, -4.23031561e-02f, -5.84796667e-02f, -1.10736728e-01f, -4.44472656e-02f, 5.15890233e-02f, -1.22060969e-01f, 1.20166654e-03f, -4.25535925e-02f,
  -4.15689126e-02f, -9.08273906e-02f, 7.70884156e-02f, 2.31076195e-03f, -1.58245564e-02f, -7.02998191e-02f, -1.21647045e-01f, -7.14083621e-03f, -6.99241087e-02f, -7.25515410e-02f,
  1.44215763e-01f, 3.10912896e-02f, -2.14981586e-01f, -4.06677574e-02f, -3.70439216e-02f, -4.69617806e-02f, -9.40319151e-02f, -5.51011227e-03f, -2.13393614e-01f, 2.26943642e-02f,
  8.90874863e-02f, 6.05877377e-02f, 3.79977077e-02f, 3.33216898e-02f, 1.35334786e-02f, -5.25370277e-02f, 6.93719238e-02f, -4.08409499e-02f, 4.77490239e-02f, 1.43379252e-02f,
  -4.71013896e-02f, -1.49048734e-02f, -5.14148362e-03f, 5.42523041e-02f, -2.04551928e-02f, 2.84410287e-02f, -7.11189758e-04f, -2.75700558e-02f, -1.11471541e-01f, -6.59182295e-02f,
  -3.64838019e-02f, 5.49030723e-03f, -1.46784689e-02f, -7.54371807e-02f, 9.68598761e-03f, -6.22197837e-02f, 6.28424957e-02f, -2.09545083e-02f, 2.33394988e-02f, 3.79081294e-02f,
  -1.58239573e-01f, -3.25789213e-01f, 1.19223505e-01f, -4.26889919e-02f, -4.73852120e-02f, -1.07624240e-01f, 1.92040782e-02f, -1.81155711e-01f, -9.55282748e-02f, -1.74400751e-02f,
  -7.37100765e-02f, -9.12899449e-02f, 9.32913553e-03f, -2.86299679e-02f, -7.68266693e-02f, -9.97764915e-02f, -4.01459262e-02f, -3.53611819e-02f, -4.24570851e-02f, -6.68368360e-04f,
  -5.67909032e-02f, -1.43156722e-01f, -5.58043271e-02f, -1.34585127e-01f, -2.00436506e-02f, -8.67003649e-02f, -1.86263427e-01f, -1.65866077e-01f, -1.35833845e-01f, -7.88145140e-02f,
  -3.60604256e-01f, -3.65883321e-01f, 1.60151646e-02f, -2.37403974e-01f, -1.39973704e-02f, 2.83032954e-02f, -1.52902797e-01f, -1.13142012e-02f, -1.05216831e-01f, -2.07448423e-01f,
  -6.04578331e-02f, -7.90670738e-02f, -1.14171840e-01f, 1.60041340e-02f, -8.50176066e-02f, -2.55206794e-01f, -1.87642962e-01f, -9.08146426e-02f, 1.18876817e-02f, -6.28637522e-03f,
  -1.50589943e-01f, -1.82219595e-01f, -1.96348876e-01f, -1.50869176e-01f, -2.21761078e-01f, -5.44274524e-02f, -7.40451515e-02f, -1.31074265e-01f, -1.44551307e-01f, -2.09069267e-01f,
  -1.63085744e-01f, -3.29229645e-02f, 3.63489091e-02f, -8.20932761e-02f, 6.42083958e-03f, -1.50439776e-02f, -2.30026115e-02f, 4.95943315e-02f, 9.82374698e-02f, -4.97382209e-02f,
  7.10542351e-02f, 1.35013275e-02f, -4.36795428e-02f, 7.47852176e-02f, -7.73845315e-02f, -4.49821837e-02f, 3.88766192e-02f, -9.29147974e-02f, 6.46887496e-02f, 6.42006397e-02f,
  1.95465349e-02f, -2.01933280e-01f, -2.07289696e-01f, -8.22854564e-02f, 6.39629662e-02f, -8.95888135e-02f, -1.15710512e-01f, -1.54571697e-01f, -7.36229420e-02f, -2.30662093e-01f,
  -5.18188393e-03f, 3.84845324e-02f, 1.07707605e-01f, -2.47965306e-02f, 1.50063280e-02f, 9.34909880e-02f, -3.18228081e-02f, -4.42263968e-02f, -2.39129514e-02f, -1.37223564e-02f,
  2.43890528e-02f, 5.90345785e-02f, 1.87055264e-02f, -1.08362436e-01f, -2.94527207e-02f, -6.82587326e-02f, -1.01431482e-01f, -3.71908024e-02f, -9.84142497e-02f, -3.44862714e-02f,
  1.40930461e-02f, 3.89295295e-02f, -3.90847176e-02f, -3.04665174e-02f, 6.91047907e-02f, -3.07252780e-02f, 3.32776941e-02f, 8.93266425e-02f, 7.03265565e-03f, 7.18740150e-02f,
  -2.54338473e-01f, 1.38191000e-01f, -7.51639679e-02f, -2.46032421e-02f, -5.77038750e-02f, -2.15204526e-02f, -2.02144366e-02f, 8.02545995e-02f, 8.66483152e-02f, -3.85969989e-02f,
  -5.95586561e-02f, -4.41528447e-02f, -1.48428768e-01f, 2.12151520e-02f, -1.64017007e-02f, -2.49176510e-02f, -1.88865170e-01f, -3.74328680e-02f, 1.03905415e-02f, 1.28212543e-02f,
  -8.24906379e-02f, -1.69552594e-01f, -3.70314419e-01f, -1.22535713e-01f, -1.72050029e-01f, -2.30958328e-01f, -2.33103067e-01f, -2.61735946e-01f, -2.93141603e-01f, -4.36575979e-01f,
  -5.43184876e-01f, -1.91998690e-01f, 2.70176798e-01f, -1.92827269e-01f, -3.12294811e-03f, 7.70025179e-02f, 1.11953802e-01f, -1.21499762e-01f, -2.43237540e-01f, -4.47922535e-02f,
  -9.24763605e-02f, -9.70336869e-02f, 3.96528766e-02f, -3.26214842e-02f, -1.02595007e-02f, 1.22090243e-01f, 1.95766818e-02f, 1.07894568e-02f, 7.14935064e-02f, -1.32724613e-01f,
  -1.21271223e-01f, -2.28294253e-01f, -2.01248333e-01f, -1.55236706e-01f, -6.11041905e-03f, 4.57072668e-02f, 1.04201309e-01f, -1.17030419e-01f, -8.93202126e-02f, -3.69056948e-02f,
  7.45934606e-01f, -3.34425002e-01f, -1.19534573e-02f, -2.93986648e-01f, 5.55939190e-02f, -1.28484275e-02f, 7.47569883e-03f, -1.37428477e-01f, -4.93600108e-02f, 7.14964196e-02f,
  -6.86966330e-02f, -1.11946296e-02f, 1.36373676e-02f, -4.19370309e-02f, -7.88655058e-02f, -6.30432889e-02f, -1.43689245e-01f, -2.80842427e-02f, -4.87277396e-02f, -1.96863841e-02f,
  -8.88930187e-02f, -9.81425047e-02f, 2.39568688e-02f, -5.99922799e-02f, -1.20865963e-01f, -2.37306021e-02f, -1.54753895e-02f, -2.87565850e-02f, -7.46800005e-02f, 6.19739555e-02f,
  -2.61169635e-02f, 1.44323558e-01f, -4.19298522e-02f, -2.00210009e-02f, -3.70812230e-03f, -1.71976537e-02f, 2.11375188e-02f, 5.97862154e-02f, -1.60264019e-02f, -1.15635048e-03f,
  6.44728169e-02f, 5.08437632e-03f, 4.44688238e-02f, 4.16295007e-02f, 7.06320778e-02f, -7.62395263e-02f, -1.87086575e-02f, 1.59066487e-02f, 9.82597843e-03f, -8.06561559e-02f,
  -6.97581246e-02f, 4.02815342e-02f, -1.77272111e-02f, 6.83667660e-02f, -1.28309622e-01f, -9.99770835e-02f, 1.94759723e-02f, -9.74397510e-02f, 3.96782905e-02f, 2.32120752e-02f,
  3.97435546e-01f, -1.88787758e-01f, 1.75739065e-01f, -7.98935592e-02f, 5.67041850e-03f, -1.12720907e-01f, -3.84362740e-03f, -2.28192937e-02f, -1.31098554e-01f, 4.40840758e-02f,
  -7.76082128e-02f, -1.61447059e-02f, 1.25449464e-01f, 3.66478637e-02f, 8.88990909e-02f, 3.18339989e-02f, -1.37446746e-01f, 3.53597403e-02f, -5.77970855e-02f, -6.41448051e-03f,
  -1.69550329e-02f, 7.18301907e-03f, 1.49612203e-01f, 1.40647128e-01f, -5.28453849e-02f, 1.83681205e-01f, 3.51110965e-01f, 1.51853889e-01f, 1.51533976e-01f, 3.05594534e-01f,
  4.86685932e-01f, -2.65227139e-01f, 1.63329348e-01f, 1.54746905e-01f, 1.35118768e-01f, 8.86361673e-03f, -7.47144446e-02f, -2.31206045e-02f, -5.93086844e-03f, 5.71248680e-02f,
  -3.38341147e-02f, 1.58274233e-01f, 1.12704605e-01f, 5.75918108e-02f, 5.96550619e-03f, 7.65325921e-03f, -1.84740443e-02f, 9.98441651e-02f, 9.56524685e-02f, -1.42878853e-02f,
  -8.22736099e-02f, -2.30434723e-02f, 3.39096338e-02f, -3.11002303e-02f, -8.94079879e-02f, -3.19018178e-02f, -5.77130020e-02f, -2.27705808e-03f, -3.00776283e-03f, -1.49013177e-01f,
  8.40786621e-02f, 1.26125678e-01f, 1.62491977e-01f, -8.60692188e-02f, 5.71735352e-02f, -1.62962656e-02f, 5.78858741e-02f, -9.93007571e-02f, -2.19797045e-02f, -1.35030746e-01f,
  3.84206548e-02f, 6.04089834e-02f, 4.77102622e-02f, -6.05918430e-02f, -4.18031067e-02f, 2.29691435e-03f, -8.03763345e-02f, -7.31355548e-02f, 4.23156358e-02f, -1.51762709e-01f,
  -9.48750153e-02f, -2.12369114e-02f, 6.48618266e-02f, -1.25697954e-02f, 6.90489113e-02f, 2.02670023e-01f, -4.28355969e-02f, 5.54523803e-02f, -5.45691736e-02f, -8.61192644e-02f,
  1.73744150e-02f, 1.69260561e-01f, 9.80569422e-02f, 5.14278747e-02f, 4.57520708e-02f, 2.42130533e-02f, 9.50017348e-02f, 3.98979783e-02f, -3.04121920e-03f, -7.63899311e-02f,
  6.62877634e-02f, 3.55434194e-02f, 2.59043612e-02f, 7.64537826e-02f, -1.45196924e-02f, 6.74335957e-02f, 7.61127025e-02f, -8.56599510e-02f, 6.71035349e-02f, 8.88027437e-03f,
  -2.24715937e-02f, -1.87294502e-02f, 9.46320035e-03f, -5.95334508e-02f, -6.57285303e-02f, 1.10732906e-01f, 7.40061104e-02f, -7.25553632e-02f, -3.81451286e-02f, -1.02766627e-03f,
  -2.69607812e-01f, 3.02899837e-01f, 1.51561841e-01f, -5.64932190e-02f, -3.99452187e-02f, -4.41163890e-02f, 1.07946061e-03f, -1.12553261e-01f, -3.80682796e-02f, -1.50780216e-01f,
  -1.04922429e-01f, -4.98541035e-02f, -5.93201220e-02f, 8.77800491e-03f, 5.74685819e-03f, 5.13747195e-03f, -1.30885124e-01f, 1.06244951e-01f, 7.00722709e-02f, -8.89718235e-02f,
  -1.34283915e-01f, 1.28835797e-01f, 1.67737812e-01f, 1.17971472e-01f, -2.16986202e-02f, 2.55057245e-01f, 5.56612425e-02f, 6.04293719e-02f, 1.71434358e-01f, -8.71767551e-02f,
  -4.24411744e-01f, -1.77967146e-01f, -2.54894704e-01f, -2.49257982e-01f, -1.50051042e-01f, -2.11178526e-01f, -2.76230633e-01f, -5.56770228e-02f, -1.58844531e-01f, -1.67144120e-01f,
  -5.50190881e-02f, 2.43149288e-02f, 1.01810591e-02f, -1.71473727e-01f, -2.14689732e-01f, -3.15426260e-01f, -2.79834121e-01f, -2.88874596e-01f, -2.27054536e-01f, -1.73017994e-01f,
  -1.49289787e-01f, -2.16031149e-01f, -1.59206837e-01f, -1.78821146e-01f, -9.20774415e-03f, -5.38303368e-02f, -7.00572431e-02f, -1.16003394e-01f, -1.69984326e-01f, -6.75099492e-02f,
  1.92825362e-01f, -1.35382544e-02f, 7.61459544e-02f, -1.11533314e-01f, -1.79399438e-02f, -3.87718119e-02f, -9.11244377e-02f, 2.99714617e-02f, -2.73156818e-02f, -1.16727673e-01f,
  -5.33572771e-02f, -5.64043708e-02f, 8.93020909e-03f, -4.37407605e-02f, -1.73019674e-02f, -4.60466146e-02f, -1.04848176e-01f, -8.19460303e-02f, -6.36052433e-03f, -4.93899658e-02f,
  -1.19433075e-01f, -2.27015346e-01f, -1.31262884e-01f, 6.87073246e-02f, 1.22971036e-01f, -4.60058637e-02f, 1.39543101e-01f, 8.81973580e-02f, 1.46132791e-02f, -4.08322513e-02f,
  -7.40688741e-02f, 6.86926916e-02f, 2.34519783e-02f, 8.65750611e-02f, -1.38278287e-02f, 9.96500924e-02f, 7.38280565e-02f, -8.23742077e-02f, 5.70785850e-02f, 1.94429401e-02f,
  4.13272483e-03f, -3.60825919e-02f, 6.48532584e-02f, 5.81883192e-02f, 3.35563645e-02f, -7.38524795e-02f, 3.12279072e-02f, -1.08856402e-01f, -5.62045015e-02f, 3.18401046e-02f,
  -7.53596285e-03f, 1.07339010e-01f, 2.48398650e-02f, -6.91784453e-03f, 3.62391062e-02f, -2.48622801e-02f, -7.73835182e-02f, 5.21083698e-02f, -3.23111266e-02f, -4.76432405e-02f,
  1.98673978e-01f, -1.61799282e-01f, 3.55669931e-02f, 7.11270124e-02f, -2.42790822e-02f, -2.70586275e-02f, -3.61540914e-02f, 2.03283746e-02f, 2.85419896e-02f, -1.69425346e-02f,
  5.75118288e-02f, -6.17282174e-04f, -3.67488600e-02f, -3.79592031e-02f, -1.08179465e-01f, -1.05948476e-02f, -1.11122243e-01f, -3.64507101e-02f, 3.83011438e-02f, -5.08920029e-02f,
  -8.03145468e-02f, -2.18119189e-01f, -1.15550436e-01f, 4.63600904e-02f, 9.07781199e-02f, -1.95312370e-02f, -1.22598410e-02f, 1.02845624e-01f, 4.35538404e-02f, -7.00101778e-02f,
  1.36176571e-01f, -1.90990344e-01f, -1.02014625e-02f, 8.67765024e-02f, 5.61991297e-02f, 1.95390120e-01f, 1.23116948e-01f, 1.86416090e-01f, 1.36443019e-01f, 4.82353978e-02f,
  -9.95349064e-02f, -1.40557349e-01f, -1.98072568e-01f, -1.00893818e-01f, -7.82248080e-02f, -8.11008587e-02f, 6.23319000e-02f, -2.27942187e-02f, 1.16810635e-01f, 4.08422388e-02f,
  9.86736491e-02f, 1.37378126e-01f, 1.04262225e-01f, 7.00213537e-02f, -1.32078156e-01f, -7.48310387e-02f, -6.41899109e-02f, -3.45679782e-02f, -1.38847874e-02f, -9.45323184e-02f,
  -2.48504862e-01f, -2.07543269e-01f, -4.09752317e-03f, -1.17500417e-01f, -1.29957438e-01f, -1.08040333e-01f, 5.42331971e-02f, -4.19143587e-02f, -2.88368147e-02f, 7.83955604e-02f,
  -1.40614629e-01f, 1.14907883e-02f, -4.97285798e-02f, 6.63347170e-03f, 8.70516971e-02f, 3.26730683e-02f, 5.97615615e-02f, -2.77055334e-02f, -2.32073311e-02f, -9.01129767e-02f,
  -1.96257085e-01f, -6.64922819e-02f, 7.96555206e-02f, -7.63431266e-02f, -8.96500051e-02f, -1.00862935e-01f, -1.10407248e-01f, -4.92275432e-02f, 8.71840771e-03f, -3.86759825e-02f,
  1.05449907e-01f, -2.83413250e-02f, 3.00777182e-02f, -3.87128331e-02f, -1.88942887e-02f, 3.85386981e-02f, -2.37897672e-02f, 4.99712711e-04f, -7.13623837e-02f, 3.53440316e-03f,
  2.40549464e-02f, -1.20714769e-01f, -6.12484775e-02f, 6.58241734e-02f, -9.11255255e-02f, -3.75329107e-02f, -3.25352363e-02f, -7.43494257e-02f, -4.95275334e-02f, -2.13080700e-02f,
  2.46517770e-02f, 2.78971829e-02f, 1.65381618e-02f, -7.66401812e-02f, -4.41042930e-02f, -9.16305110e-02f, -3.77741531e-02f, -7.84104839e-02f, -4.68185619e-02f, -2.88521056e-03f,
  4.67199609e-02f, 5.81865162e-02f, 3.16377990e-02f, 1.06953392e-02f, -3.69033627e-02f, 8.58856644e-03f, -1.80397898e-01f, -1.86101859e-03f, -4.33389880e-02f, -9.15751085e-02f,
  -1.07563116e-01f, -9.69846919e-02f, -6.47202954e-02f, -5.91695495e-02f, 5.00415415e-02f, 1.36483133e-01f, -5.75658828e-02f, -2.74710637e-02f, -3.39947753e-02f, 4.59873974e-02f,
  2.79242154e-02f, 2.05534950e-01f, 1.20147422e-01f, -1.12344362e-02f, 6.06199987e-02f, 3.34068574e-02f, 1.28959268e-01f, 7.00114295e-02f, 1.63717940e-01f, 3.31447124e-01f,
  1.14484973e-01f, 3.83830327e-03f, -1.34015143e-01f, -2.59985507e-01f, -1.61194146e-01f, -6.57421350e-02f, -6.44815862e-02f, 2.31973212e-02f, -1.09139666e-01f, -9.22497362e-02f,
  -1.76208556e-01f, -1.88370854e-01f, -4.50072661e-02f, -1.01272002e-01f, -2.27838270e-02f, 6.54218718e-02f, -2.57643033e-02f, 6.48915693e-02f, -7.88451210e-02f, -1.42404929e-01f,
  -9.48666334e-02f, -1.97148040e-01f, -1.15784027e-01f, -1.89371780e-01f, -1.56220317e-01f, -7.37868696e-02f, -1.11676529e-01f, -2.39335030e-01f, -1.40952423e-01f, -1.32686704e-01f,
  -2.40185753e-01f, -2.40069091e-01f, 8.30173939e-02f, 9.50757936e-02f, -6.46314621e-02f, 5.45258820e-02f, -2.37896796e-02f, -1.10872619e-01f, -8.73099044e-02f, -1.41914410e-03f,
  -1.70552395e-02f, -9.24420655e-02f, -9.52990577e-02f, -6.23880588e-02f, -1.34690598e-01f, -2.56040432e-02f, -9.67238620e-02f, 2.74072848e-02f, -6.28512651e-02f, -8.14329535e-02f,
  1.51838334e-02f, -8.64759907e-02f, 1.36704911e-02f, -4.83795069e-02f, -3.42157017e-03f, -5.67742735e-02f, -5.12326099e-02f, 1.01820137e-02f, -4.02615778e-03f, 9.76876095e-02f,
  2.56545059e-02f, -1.94470352e-03f, -1.95464101e-02f, -8.42712894e-02f, 6.24421164e-02f, 6.67281002e-02f, 9.42598581e-02f, -7.13358109e-04f, -3.58307101e-02f, 9.70644504e-02f,
  3.92936915e-02f, 3.77833359e-02f, -4.55809459e-02f, -1.96788963e-02f, -5.93573749e-02f, 2.63942610e-02f, 1.03177942e-01f, 3.02407704e-03f, -9.33888182e-03f, 1.15917221e-01f,
  8.65313336e-02f, 1.07311383e-02f, -1.07646145e-01f, -6.57660514e-02f, 4.28480543e-02f, -3.08315400e-02f, -2.34014913e-02f, -3.95083688e-02f, -1.31225539e-02f, -1.23278406e-02f,
  1.84400789e-02f, 1.42843202e-01f, 8.35481379e-03f, -5.92638515e-02f, 1.39891971e-02f, 4.15063016e-02f, -7.39410371e-02f, -2.17784625e-02f, -1.08643040e-01f, -2.73288786e-02f,
  -1.72147229e-01f, -6.83996677e-02f, 2.59543899e-02f, -3.72492112e-02f, -1.17180413e-02f, -6.59057358e-03f, 1.47891745e-01f, 4.90201972e-02f, 9.16035846e-02f, -4.41100262e-02f,
  8.51786658e-02f, 2.75621474e-01f, 2.42623568e-01f, 2.61548638e-01f, 7.37175941e-02f, 2.57859647e-01f, 2.41315179e-02f, 1.53423652e-01f, 2.57652283e-01f, 2.25015715e-01f,
  -7.79091597e-01f, 3.78198266e-01f, 1.38557613e-01f, -3.61963570e-01f, 1.50729299e-01f, 3.61158282e-01f, 4.91041690e-01f, 9.54053923e-02f, -7.67196016e-03f, 1.47370407e-02f,
  9.32248533e-02f, -2.51417100e-01f, -3.57611999e-02f, 6.93470007e-03f, 1.50116190e-01f, 4.20327723e-01f, 2.05397338e-01f, -8.73769149e-02f, -2.38136232e-01f, -1.16641618e-01f,
  5.51361265e-03f, -2.31906757e-01f, -4.21665490e-01f, -1.70655787e-01f, -3.88961635e-03f, -1.57004088e-01f, -2.26294082e-02f, -1.61284149e-01f, 2.07320482e-01f, 6.48715571e-02f,
  -1.91053286e-01f, -2.05483228e-01f, -1.45576954e-01f, -1.42800927e-01f, -7.45833069e-02f, -1.37800872e-01f, -4.76439036e-02f, -1.30611956e-01f, -8.27247277e-02f, 2.21769903e-02f,
  -5.46927266e-02f, -1.28607586e-01f, 4.03188467e-02f, -8.39882195e-02f, -5.96850589e-02f, -7.53437653e-02f, -4.24066484e-02f, -1.40902579e-01f, -9.86262932e-02f, -2.03851908e-02f,
  1.58998773e-01f, -3.12821157e-02f, -1.73586383e-01f, 7.71004483e-02f, -6.76630661e-02f, -9.76136327e-02f, -8.27243105e-02f, -8.70372280e-02f, -1.22873254e-01f, -2.64511704e-01f,
  5.49230352e-02f, -1.56729873e-02f, 3.51294242e-02f, -6.78612152e-04f, 1.39950383e-02f, -1.73960607e-02f, 6.09696098e-02f, -7.54913827e-03f, 2.31326278e-02f, -8.71290714e-02f,
  -5.92808500e-02f, 2.57695839e-02f, -3.93906347e-02f, -8.42666030e-02f, -3.25985886e-02f, -3.98812294e-02f, 1.25491330e-02f, 5.02090417e-02f, 4.38025258e-02f, -5.12290467e-03f,
  -7.61728287e-02f, -4.12451364e-02f, -7.12030381e-02f, -2.20943671e-02f, 1.04235590e-01f, 4.92808297e-02f, -2.79407240e-02f, -7.80331194e-02f, -9.75197032e-02f, 4.70051020e-02f,
  -3.54512155e-01f, 1.29086941e-01f, -1.29375249e-01f, -8.17228407e-02f, -1.74774639e-02f, -4.57381085e-02f, 3.52293029e-02f, -7.55857900e-02f, 1.46831237e-02f, -9.85187292e-02f,
  1.36669213e-02f, -1.46349475e-01f, -4.00810353e-02f, -2.42064707e-02f, -1.59503073e-01f, -1.24152958e-01f, 9.77978259e-02f, -1.11835182e-01f, 2.36258153e-02f, 4.35253419e-02f,
  6.17786609e-02f, -1.37086883e-01f, -2.49260083e-01f, -1.14592247e-01f, 7.43426476e-03f, -1.87388867e-01f, -8.13737512e-02f, -2.39286602e-01f, -1.57467619e-01f, -2.94687241e-01f,
  -5.28527759e-02f, -3.06133151e-01f, -3.86752635e-01f, -2.15251997e-01f, -1.32502779e-01f, 8.38718843e-03f, 2.06369497e-02f, 4.64114808e-02f, -2.66280733e-02f, -2.08316609e-01f,
  -1.11436881e-01f, -7.02327564e-02f, -1.27859354e-01f, 1.37678171e-02f, 2.40526404e-02f, -9.66869146e-02f, -1.60186931e-01f, -1.87855825e-01f, 1.10889547e-01f, 1.55620471e-01f,
  -9.65239201e-03f, -1.41560808e-01f, -9.17528570e-02f, -6.26455992e-02f, -1.02470286e-01f, -8.60658959e-02f, -3.76007557e-01f, -1.19002782e-01f, -1.87296867e-01f, -1.80107713e-01f,
  -2.93107599e-01f, -4.67020608e-02f, 1.87530462e-03f, 1.09613225e-01f, -1.71787426e-01f, 7.05867857e-02f, 3.36888805e-02f, -2.69845016e-02f, 1.91177905e-03f, -2.89391577e-02f,
  -1.67547781e-02f, 3.99867482e-02f, -7.94839412e-02f, 3.14848423e-02f, -5.56899011e-02f, 7.65664130e-02f, 3.18788029e-02f, -5.11096977e-02f, -1.13937594e-02f, -2.45978814e-02f,
  -1.12477012e-01f, -3.97672355e-02f, -4.23531495e-02f, 3.09192459e-04f, -5.05998768e-02f, -4.06331383e-02f, -6.00777492e-02f, 8.59403312e-02f, -7.10931644e-02f, -1.42072499e-01f,
  -6.94764080e-04f, -6.90770969e-02f, 3.24596316e-02f, 9.14819911e-02f, -3.46498676e-02f, -2.36489829e-02f, 5.08802347e-02f, -2.65804734e-02f, 5.60250133e-02f, -5.76300919e-02f,
  -5.61172515e-02f, -9.43857431e-02f, 2.48582382e-02f, -2.92047076e-02f, -1.77645404e-02f, 6.89251348e-04f, 5.96162602e-02f, -6.44116290e-03f, -6.15642294e-02f, -3.15107927e-02f,
  -6.21059388e-02f, -5.69107868e-02f, -4.52490896e-02f, 6.53811172e-02f, 3.16797718e-02f, 2.54882984e-02f, 9.82423276e-02f, 4.12652381e-02f, 4.24805544e-02f, 3.98792587e-02f,
  -1.35946289e-01f, 4.81137224e-02f, 3.90873104e-02f, 1.00485295e-01f, -4.05514054e-02f, 5.39239589e-03f, -9.67104062e-02f, -2.93341856e-02f, -4.00682762e-02f, 7.03096464e-02f,
  1.07941762e-01f, 2.15036776e-02f, -9.01849866e-02f, -4.52397317e-02f, -1.99562404e-02f, 9.24679413e-02f, 3.30699398e-03f, 1.91858616e-02f, 5.21054827e-02f, -7.13842660e-02f,
  1.64507795e-02f, 1.16944991e-01f, 8.25461000e-02f, 8.72574467e-03f, -1.09009622e-02f, 4.78465296e-02f, -1.16524018e-01f, 6.92818835e-02f, 5.06041273e-02f, 1.35519998e-02f,
  -6.29971363e-03f, -8.03318340e-03f, 1.17161572e-02f, 7.70973340e-02f, -1.52363539e-01f, -2.72775769e-01f, -2.33556971e-01f, -1.09923735e-01f, 4.48220558e-02f, 3.49259414e-02f,
  -9.19778794e-02f, 7.76366442e-02f, 1.05281956e-01f, 1.81691661e-01f, 9.14445147e-02f, 1.09237090e-01f, 2.12603629e-01f, 2.11221874e-01f, -1.41822724e-02f, 5.05434535e-02f,
  6.80861473e-02f, 1.86643690e-01f, 3.47645320e-02f, 1.93465158e-01f, 6.80344701e-02f, 1.57808349e-01f, 9.95028168e-02f, 7.07216933e-03f, 1.42124221e-01f, 4.51282531e-01f,
  8.64704028e-02f, -1.33328512e-01f, -6.24208674e-02f, 6.48470819e-02f, 7.15540126e-02f, 9.08648130e-04f, 4.19707038e-03f, 8.50676000e-02f, -4.23744470e-02f, 1.88723933e-02f,
  5.28573655e-02f, 1.29898578e-01f, -1.63400173e-02f, 7.13705793e-02f, 2.20222287e-02f, -2.14757994e-02f, 1.21631213e-01f, 6.13324903e-02f, 1.28119066e-01f, -5.11137880e-02f,
  4.79297340e-02f, -1.24021687e-01f, -1.72478423e-01f, -1.75151139e-01f, -1.17451452e-01f, 7.35632181e-02f, -7.64501095e-02f, -9.76853594e-02f, -8.40509757e-02f, 5.17175421e-02f,
  -6.70764744e-02f, -6.21873103e-02f, 5.54948635e-02f, 8.88466686e-02f, 1.03481129e-01f, 4.13705669e-02f, 7.14973360e-03f, 7.35329315e-02f, -6.91211373e-02f, -6.40803995e-03f,
  3.34046185e-02f, -1.01176808e-02f, -3.33426036e-02f, 9.29170847e-03f, -3.41944136e-02f, -9.41529404e-04f, 5.52046038e-02f, 5.34290783e-02f, 2.36808751e-02f, -3.00415829e-02f,
  -1.05904937e-02f, 6.33674636e-02f, -2.76949741e-02f, 6.02238774e-02f, -1.68758153e-03f, 6.06618598e-02f, 5.70298508e-02f, 3.91412154e-02f, -9.56801046e-03f, 2.94013117e-02f,
  -1.41940802e-01f, -2.02823088e-01f, -5.49119674e-02f, 3.37889716e-02f, 2.59864870e-02f, -4.25176024e-02f, -1.87186766e-02f, 7.87651092e-02f, 5.62982038e-02f, 1.07693812e-02f,
  -1.50328651e-01f, -6.47847727e-02f, -4.54922318e-02f, -5.81423119e-02f, -5.57872467e-02f, -2.67070290e-02f, -9.23918909e-04f, 9.43660140e-02f, 6.67599263e-03f, -9.28687900e-02f,
  -4.76091392e-02f, -2.39980757e-01f, -2.96796381e-01f, -1.61338180e-01f, -6.23124093e-02f, -8.82528946e-02f, -1.79288939e-01f, -8.42348337e-02f, -2.90711999e-01f, -1.29325420e-01f,
  2.12437645e-01f, -9.44718570e-02f, 1.86275259e-01f, 1.24055408e-01f, -2.01509893e-01f, -4.83445555e-01f, -5.71916640e-01f, -3.69039297e-01f, -9.04843733e-02f, -1.02314144e-01f,
  -5.64826168e-02f, -1.02002043e-02f, 9.41091925e-02f, -4.62712198e-02f, -1.93553463e-01f, -3.42609175e-02f, 3.33484598e-02f, 1.11823574e-01f, 9.08844024e-02f, -8.34947899e-02f,
  1.10915482e-01f, 1.31711870e-01f, 3.22264850e-01f, 8.81594867e-02f, 9.26497355e-02f, 8.49879757e-02f, 2.22094193e-01f, 1.43548831e-01f, 7.40773007e-02f, 2.97602236e-01f,
  2.04324082e-01f, -5.19635677e-02f, -5.98293170e-02f, 3.56592983e-02f, 1.40257195e-01f, -1.93463080e-02f, -2.16574240e-02f, 8.95057619e-02f, -4.87586074e-02f, 6.01016507e-02f,
  8.14183131e-02f, -7.11797699e-02f, -1.29848614e-03f, 3.66202779e-02f, -9.63731334e-02f, -1.07544318e-01f, 2.75741704e-02f, 8.44124705e-02f, 9.67267156e-03f, -7.97554478e-02f,
  6.70204312e-02f, 8.31185430e-02f, -1.24568917e-01f, -1.57097399e-01f, -1.03471531e-02f, 1.49049191e-02f, -1.57060459e-01f, -4.62810732e-02f, -6.13353848e-02f, 6.15950786e-02f,
  5.34726158e-02f, -3.29209864e-02f, -6.05520932e-03f, 6.45397790e-03f, -1.03074372e-01f, -2.51192637e-02f, 7.65117481e-02f, -8.53325874e-02f, 4.69883420e-02f, 2.28912346e-02f,
  -3.60120237e-02f, 2.12281737e-02f, 1.89260591e-03f, -3.81322997e-03f, 5.44398688e-02f, 7.71385059e-02f, -8.74071121e-02f, 4.23725694e-02f, 1.03624053e-02f, 1.97566897e-02f,
  6.00817539e-02f, -3.73414457e-02f, 8.84859487e-02f, -5.70864230e-03f, 6.36363700e-02f, 4.73366007e-02f, -8.70598108e-02f, -1.07117675e-01f, -6.12363704e-02f, -1.74128395e-02f,
  -1.12366907e-01f, -1.37484111e-02f, -1.55875622e-03f, -8.19189940e-03f, 6.61463737e-02f, -2.23697983e-02f, 2.82774735e-02f, 5.66676445e-02f, -5.69496714e-02f, -1.11305781e-01f,
  -1.03914805e-01f, -1.61278509e-02f, 9.44995228e-03f, -6.16974607e-02f, -2.70663798e-02f, -9.32588279e-02f, -2.77468059e-02f, 3.30469199e-03f, -1.33180335e-01f, -9.44398865e-02f,
  -1.32866114e-01f, -2.46425882e-01f, -3.28664720e-01f, -3.21520567e-01f, -1.63844407e-01f, -1.56750262e-01f, -2.65972346e-01f, -1.54525235e-01f, -3.20437551e-01f, -3.93220812e-01f,
  1.23457775e-01f, -5.06608821e-02f, -1.79844722e-01f, 2.18079105e-01f, -1.00391611e-01f, -3.42781961e-01f, -4.36828613e-01f, -1.49826705e-01f, 1.28758922e-01f, -1.46266511e-02f,
  6.32872432e-02f, 1.45244911e-01f, -1.20709725e-01f, -6.18305244e-02f, -2.38370523e-01f, -2.82637924e-01f, -1.32639468e-01f, -1.70918807e-01f, -2.19791383e-01f, -7.49271438e-02f,
  -5.83636202e-02f, -2.86778864e-02f, -8.45672712e-02f, -6.29676655e-02f, 2.64932811e-01f, 1.91891670e-01f, 4.63202260e-02f, 1.14013612e-01f, 1.75848473e-02f, 3.02355647e-01f,
  7.70763680e-02f, 3.22356075e-02f, -5.12960181e-02f, 3.72429676e-02f, 3.35076563e-02f, -4.14928719e-02f, -2.65724957e-02f, -3.73422392e-02f, -3.52722127e-04f, -1.34767890e-02f,
  3.90139334e-02f, 3.94620299e-02f, 9.66355205e-02f, -2.13436950e-02f, -2.41604866e-03f, -4.14383896e-02f, -4.14116569e-02f, -3.73098440e-02f, -7.18785152e-02f, -1.15479594e-02f,
  2.40399726e-02f, -5.58603182e-02f, -7.99091384e-02f, -1.98418319e-01f, 6.05718046e-03f, 4.17059287e-02f, 3.02242232e-03f, 1.03730224e-02f, -1.72036350e-01f, 7.39971474e-02f,
  4.01881374e-02f, -5.84274195e-02f, -4.85758036e-02f, 4.73509729e-02f, 8.67371913e-03f, 4.39546108e-02f, -1.71297248e-02f, -8.61477554e-02f, -8.59503150e-02f, 4.43838425e-02f,
  -7.56519586e-02f, 2.98661031e-02f, 1.83885880e-02f, -7.44170472e-02f, 3.43485214e-02f, -4.25085202e-02f, -7.62738660e-02f, -4.43611741e-02f, -6.89124614e-02f, -1.78071251e-03f,
  -1.79382111e-03f, 2.85248589e-02f, -2.34299023e-02f, 3.22191678e-02f, -1.59141924e-02f, -8.54763240e-02f, 6.08485937e-02f, 4.28721718e-02f, 2.56545916e-02f, 3.07079479e-02f,
  1.32299408e-01f, -3.27596009e-01f, -1.42573903e-03f, 7.19635487e-02f, -4.62438092e-02f, 2.42836289e-02f, 1.17465436e-01f, -8.33494365e-02f, 3.63604985e-02f, -7.87229612e-02f,
  -1.01569898e-01f, -1.04611143e-01f, -5.26258983e-02f, 3.71511467e-02f, -1.55394286e-01f, 1.96522605e-02f, -4.55445088e-02f, -8.67212489e-02f, -1.01280808e-01f, 4.35666032e-02f,
  -1.04974858e-01f, -6.77123591e-02f, -2.46147320e-01f, -1.67026222e-01f, -7.43851364e-02f, -7.59173036e-02f, -1.41771227e-01f, -1.06239066e-01f, -2.27385759e-01f, -1.04805000e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.20829505e-01f, 2.93770134e-01f, 1.30812585e-01f, 1.28326535e-01f, 1.63601294e-01f, 4.11074549e-01f, 5.21490097e-01f, 3.62035334e-01f, 2.45264828e-01f, 4.89627957e-01f,
  2.94863492e-01f, 7.53059864e-01f, 3.31925392e-01f, 2.49134660e-01f, 1.55948445e-01f, 3.15644331e-02f, 2.18533829e-01f, 3.03314120e-01f, 1.37101337e-01f, 2.34071776e-01f,
  2.12910041e-01f, 3.22877318e-01f, 4.10887562e-02f, 1.35500103e-01f, 2.16263011e-01f, 1.02854580e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -4.90905493e-02f, -8.45787823e-01f, -6.23142302e-01f, 1.35156959e-01f, 3.35526735e-01f, 9.29506402e-03f, 3.35533351e-01f, -1.11546025e-01f, -2.59434581e-01f, 2.77524561e-01f,
  -1.62928104e-01f, -2.00674847e-01f, -1.47562772e-01f, 1.42193258e-01f, -1.62909806e-01f, -2.47222185e-01f, 3.13498527e-01f, 6.84754372e-01f, -2.02435330e-01f, -1.60878852e-01f,
  8.72561708e-02f, 6.61490798e-01f, -4.69352454e-01f, -2.66119957e-01f, 4.27646905e-01f, 1.99251827e-02f, -2.65946269e-01f, -3.20194125e-01f, 5.91212034e-01f, -1.84285775e-01f,
  -1.41002119e-01f, 1.71904802e-01f, -3.49626660e-01f, -6.69061959e-01f, -2.57100672e-01f, 6.26020908e-01f, 1.97038218e-01f, -2.87892461e-01f, 1.44410014e-01f, -2.50301749e-01f,
  -2.44789720e-01f, 3.91382240e-02f, 2.63770342e-01f, -4.71409231e-01f, 2.14579791e-01f, -5.54475963e-01f, 1.49972871e-01f, 8.04952011e-02f, -3.16879123e-01f, 1.20380402e+00f,
  1.02495819e-01f, 3.68328422e-01f, 4.35596436e-01f, -1.56368196e-01f, -3.49384159e-01f, 6.92392051e-01f, 1.53627142e-01f, -1.43944308e-01f, 4.53074753e-01f, -5.02044678e-01f,
  4.29579258e-01f, -5.61436936e-02f, -4.30020869e-01f, -1.34174943e-01f, 9.17252968e-04f, 4.10157949e-01f, 3.27718735e-01f, -6.11540973e-01f, -1.94447339e-01f, -1.38078138e-01f,
  4.78719652e-01f, 4.35058147e-01f, 1.05981380e-01f, 6.75496878e-03f, -1.58930883e-01f, -4.32538360e-01f, -7.23121539e-02f, -2.73874909e-01f, -4.61807847e-01f, 2.82312483e-01f,
  7.70112932e-01f, 4.72276539e-01f, -3.07258070e-01f, 3.26074123e-01f, -6.95672929e-01f, 2.60621727e-01f, -2.52138525e-01f, 1.23640582e-01f, -2.86215723e-01f, -5.93338385e-02f,
  -1.10930480e-01f, -9.27732214e-02f, -2.48049214e-01f, 3.37189853e-01f, 6.27203763e-01f, -2.10060567e-01f, 7.14021251e-02f, 4.03939307e-01f, -5.66336632e-01f, -1.96999237e-01f,
  -2.19658539e-01f, -2.51381636e-01f, 6.53409958e-01f, 1.95989057e-01f, -8.66084918e-02f, 7.24864900e-02f, -5.42444848e-02f, -4.12809886e-02f, -2.19453499e-01f, 6.38672709e-02f,
  -4.09794860e-02f, -3.04412752e-01f, -3.13389271e-01f, -7.71854460e-01f, -4.06629086e-01f, -1.45709634e-01f, -4.09719765e-01f, 6.08555496e-01f, 1.13335736e-01f, -2.77389675e-01f,
  1.16732135e-01f, -1.23515233e-01f, 3.66584003e-01f, 1.16084123e+00f, 2.27015570e-01f, -1.08676990e-02f, -3.93230647e-01f, -3.90232950e-01f, 1.23428054e-01f, 5.12049720e-02f,
  2.41589829e-01f, 2.09346533e-01f, 1.34024784e-01f, -4.14282262e-01f, -3.34029824e-01f, 5.08647785e-02f, 3.49123299e-01f, 2.06907108e-01f, -2.68768519e-01f, 6.94150090e-01f,
  -2.86906570e-01f, 5.96049428e-01f, -2.02092037e-01f, 1.92926899e-02f, -1.37296706e-01f, -5.16312063e-01f, 3.27976763e-01f, 7.14649111e-02f, -3.22408289e-01f, 5.02073646e-01f,
  7.93904662e-02f, 1.10206507e-01f, 6.61211789e-01f, -3.77275974e-01f, -2.30745673e-01f, 2.72834720e-03f, -2.91972399e-01f, -8.27091187e-02f, 2.92275876e-01f, 5.79091668e-01f,
  1.60113081e-01f, 2.75176078e-01f, 3.02324891e-01f, 4.63882625e-01f, 5.75025320e-01f, -4.16255713e-01f, -5.17037809e-01f, 1.44151092e-01f, 9.67998803e-03f, 1.24740168e-01f,
  2.14205682e-01f, -2.38800392e-01f, 4.33721751e-01f, 9.14262116e-01f, 4.59925495e-02f, 3.05053383e-01f, -2.46768117e-01f, 4.47964311e-01f, 1.01543641e+00f, -1.09731503e-01f,
  2.36751378e-01f, -4.09704775e-01f, -2.33145460e-01f, -4.70565051e-01f, -1.44140646e-01f, 2.67871499e-01f, 3.77684414e-01f, -1.37808129e-01f, 7.91855007e-02f, -1.51030542e-02f,
  -2.13914394e-01f, 5.01483642e-02f, -7.43611991e-01f, 3.36015075e-01f, -1.45215333e-01f, -5.52874029e-01f, -1.51416302e-01f, 3.48572344e-01f, -3.06567073e-01f, -2.05385178e-01f,
  -2.60201216e-01f, -3.19299728e-01f, -4.57207322e-01f, 1.43594176e-01f, -3.85553181e-01f, -1.46247476e-01f, 3.02965075e-01f, 6.68267727e-01f, -5.54899573e-01f, -2.04866931e-01f,
  -2.16772527e-01f, 8.28840435e-01f, 2.86966115e-01f, -4.15096313e-01f, -2.60632247e-01f, -7.65989488e-03f, -3.59743267e-01f, -2.76365876e-01f, -3.13834965e-01f, -3.18030685e-01f,
  5.42495139e-02f, 5.95857501e-01f, 5.67035258e-01f, 1.59666851e-01f, -1.93624750e-01f, -5.42002320e-01f, -1.36513337e-01f, -1.98151782e-01f, -3.92328463e-02f, 2.78419226e-01f,
  -4.23762053e-02f, 5.97578406e-01f, -4.05856483e-02f, 3.03189307e-01f, 2.28929967e-01f, -3.47334117e-01f, -1.02210427e-02f, 1.86828021e-02f, -2.02738196e-01f, -4.80183065e-01f,
  2.94708461e-01f, -2.96368212e-01f, -4.35967743e-02f, -3.52789223e-01f, 3.63443345e-01f, -2.08859757e-01f, 1.81271266e-02f, -3.49747799e-02f, -1.22620985e-01f, -1.70265555e-01f,
  -2.75550842e-01f, 8.96575749e-01f, -1.13535315e-01f, 3.19377363e-01f, -2.00158492e-01f, -6.49746805e-02f, 4.04018342e-01f, 1.53488055e-01f, 8.95733088e-02f, -3.39782797e-03f,
  3.12565476e-01f, 6.39480054e-01f, 5.80261322e-03f, -2.28142738e-01f, -7.83568174e-02f, -3.71109217e-01f, -8.92715231e-02f, -3.45973641e-01f, 1.15423715e+00f, -4.10801679e-01f,
  -2.02498272e-01f, 2.43594497e-01f, 9.98172536e-02f, -6.56135857e-01f, -2.31377199e-01f, -2.54150212e-01f, 6.75555915e-02f, -1.80824861e-01f, 2.61322856e-01f, 4.02385890e-01f,
  -5.28193593e-01f, 5.56251049e-01f, 2.37787366e-01f, -3.98309976e-01f, 4.00012843e-02f, -3.19668442e-01f, -1.69601619e-01f, -8.59599859e-02f, 3.45021278e-01f, -2.29198068e-01f,
  -3.91668469e-01f, 1.82597861e-02f, 1.85283404e-02f, 4.42287564e-01f, -4.36432838e-01f, -2.53723115e-01f, 6.31652236e-01f, -9.89419445e-02f, -2.07850099e-01f, 3.66889149e-01f,
  -5.05205691e-01f, 2.86262482e-01f, -2.12157771e-01f, -4.45439190e-01f, 4.46187854e-01f, 3.86745036e-01f, 3.02900255e-01f, -5.16684175e-01f, 3.93858135e-01f, -1.03537023e-01f,
  -2.27463678e-01f, 1.53842315e-01f, -2.38264292e-01f, -3.70934844e-01f, -2.90108204e-01f, -2.24045455e-01f, -2.44073570e-01f, 4.57107902e-01f, 7.41210878e-01f, 6.33149505e-01f,
  -1.89992443e-01f, 6.85478374e-02f, 1.84177384e-01f, 1.92208752e-01f, -4.19783920e-01f, -2.20565319e-01f, 3.98593098e-01f, 2.02211514e-01f, -7.14226887e-02f, -9.20899138e-02f,
  -2.75568403e-02f, -1.67274103e-01f, -2.77097076e-01f, -3.22939157e-01f, -1.82650030e-01f, 4.22836214e-01f, -3.74185354e-01f, -1.17797434e-01f, -1.11703739e-01f, -3.27578396e-01f,
  -2.42552251e-01f, -3.10572356e-01f, 1.18341410e+00f, -1.71128526e-01f, 4.36755806e-01f, -1.52418345e-01f, -2.06719786e-02f, -1.46226376e-01f, -1.95726827e-01f, -2.33727843e-01f,
  -3.46773684e-01f, -1.68085486e-01f, 2.67495602e-01f, 4.49149460e-01f, 1.37112543e-01f, -4.02374178e-01f, 7.95653015e-02f, 4.65110838e-02f, -2.18290046e-01f, -3.75062972e-01f,
  2.64968365e-01f, -3.56367454e-02f, 8.58482718e-01f, 7.93197691e-01f, -1.62984297e-01f, -3.81697081e-02f, 7.08035171e-01f, -1.73553191e-02f, -1.21278085e-01f, -4.51311380e-01f,
  -2.94274598e-01f, 5.25794998e-02f, -1.71114653e-01f, -1.78201318e-01f, -2.15545520e-01f, 1.82402611e-01f, -2.88248599e-01f, -1.38193369e-01f, -3.56387556e-01f, 2.90848732e-01f,
  -2.85677671e-01f, -4.57704306e-01f, -1.92559779e-01f, -3.74269933e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.51150692e-01f, 2.07501113e-01f, 8.37928802e-02f, -2.95243207e-02f, -2.90939063e-01f, 2.32816160e-01f, 1.42960288e-02f, -3.54572117e-01f, 7.23153651e-02f, 2.43996214e-02f,
  3.33441086e-02f, 5.00666462e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    