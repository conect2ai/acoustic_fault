/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.70844603e-01f, -9.19862241e-02f, 2.60238796e-01f, -1.30492181e-01f, 1.35942593e-01f, -2.84452111e-01f, -1.92688838e-01f, 3.29067111e-01f, -1.58379585e-01f, -1.58463180e-01f,
  -2.78916627e-01f, 1.27796590e-01f, -1.20837621e-01f, -4.02985871e-01f, 1.72567740e-01f, -3.50296438e-01f, 6.90158978e-02f, -3.42807412e-01f, 1.41749337e-01f, 1.19114578e-01f,
  1.01692192e-01f, 2.08611041e-02f, 2.76705362e-02f, 4.22819734e-01f, -1.94552660e-01f, 3.72568130e-01f, 1.63656950e-01f, 2.74145931e-01f, 1.23362169e-01f, -5.78258671e-02f,
  -1.77577421e-01f, -1.91556841e-01f, 2.05991596e-01f, 8.10449570e-02f, -8.34894478e-02f, -6.93560869e-04f, 5.45727834e-02f, 7.57816210e-02f, 1.48631826e-01f, -8.75195116e-02f,
  7.50190578e-03f, 1.47302682e-02f, -5.40929846e-02f, 1.75143480e-02f, 1.12372572e-02f, 6.44977391e-02f, -1.86563954e-01f, -3.69713791e-02f, 9.28948671e-02f, -1.56545863e-01f,
  -6.32132590e-02f, -2.12702587e-01f, -1.10958591e-01f, -6.49383813e-02f, 4.25163172e-02f, -8.93201977e-02f, 5.66693395e-03f, -3.14427204e-02f, -5.07012121e-02f, -7.14109391e-02f,
  -7.99139887e-02f, 3.12353559e-02f, -1.93213411e-02f, 1.10409660e-02f, -2.95036961e-03f, -7.19798878e-02f, 4.93220687e-02f, -1.56910941e-01f, -3.43844406e-02f, -8.66686702e-02f,
  1.91933697e-03f, 2.34246161e-02f, -1.71195045e-02f, 2.58561820e-02f, -2.16897000e-02f, -3.11775673e-02f, 6.26852810e-02f, 1.65124075e-03f, -3.12519595e-02f, -2.33272202e-02f,
  -1.67143270e-02f, 5.94079643e-02f, 4.85413559e-02f, 8.36341083e-02f, 3.99513217e-03f, 5.19565772e-03f, 8.99005085e-02f, -6.07457012e-02f, -1.73168965e-02f, 7.76293576e-02f,
  -8.66402611e-02f, 2.91069180e-01f, 3.06255911e-02f, 2.25425903e-02f, 1.09835118e-02f, -1.69172827e-02f, -8.43588337e-02f, -2.44869268e-03f, 1.02315016e-01f, -2.38091554e-02f,
  -3.57047878e-02f, 1.63717847e-02f, 1.22389086e-01f, -6.52037263e-02f, 1.18935779e-02f, -4.99623828e-02f, 4.26021963e-03f, 6.37368783e-02f, 1.82678595e-01f, 5.37481532e-02f,
  9.91780087e-02f, -5.21668494e-02f, 6.22758493e-02f, 1.57985181e-01f, -5.03901727e-02f, -2.21865922e-02f, 5.95595911e-02f, -1.24112153e-02f, 1.44024035e-02f, -5.57466894e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.20253503e+00f, -3.42214048e-01f, 8.02175701e-01f, 8.97925496e-01f, 5.07264256e-01f, 1.26760975e-01f, 1.42130464e-01f, 3.97075385e-01f, 8.15716147e-01f, -6.56413198e-01f,
  -5.19303977e-01f, 2.95517653e-01f, -8.95718098e-01f, 3.78550857e-01f, -3.87966603e-01f, -8.88829470e-01f, 1.36782378e-01f, -1.77386805e-01f, 2.46442199e-01f, 1.45852014e-01f,
  3.03197592e-01f, -5.22727489e-01f, -6.22376706e-03f, -3.08287501e-01f, 5.88330030e-01f, 4.22993869e-01f, -6.88022733e-01f, -1.95288524e-01f, 2.93145955e-01f, -3.54131944e-02f,
  1.55159086e-02f, 1.96924463e-01f, 2.43956998e-01f, 6.17570095e-02f, 5.25202453e-02f, 6.58598840e-02f, 7.24932104e-02f, -1.62075043e-01f, 2.33264267e-01f, 8.84018242e-02f,
  -1.12404481e-01f, 6.45022020e-02f, 2.41932616e-01f, 1.97187252e-02f, 3.40049624e-01f, 3.03890556e-01f, 1.71311826e-01f, 2.93223500e-01f, 2.08073214e-01f, 2.35077202e-01f,
  2.65197158e-01f, 2.94453591e-01f, 2.16024607e-01f, -1.27451748e-01f, 1.33292362e-01f, 1.76434204e-01f, 1.50015473e-01f, 2.51133777e-02f, 1.63771853e-01f, 2.10502595e-01f,
  -2.34494761e-01f, -1.45039469e-01f, 3.00175156e-02f, 6.39140904e-02f, 2.29423270e-02f, 8.54696259e-02f, 7.49373017e-03f, -2.06450392e-02f, 9.23843384e-02f, -2.41544638e-02f,
  3.22095002e-03f, -7.93279440e-04f, 1.18994586e-01f, 7.89166614e-02f, -5.44865876e-02f, 2.07465857e-01f, -8.90922248e-02f, -9.18568075e-02f, 6.05782419e-02f, 7.70585537e-02f,
  -3.03016994e-02f, 4.17583957e-02f, -1.72073364e-01f, 1.59451440e-01f, -1.57790348e-01f, -3.70078795e-02f, 6.08877726e-02f, 1.72393829e-01f, 6.97183311e-02f, -2.07961097e-01f,
  -9.91035342e-01f, -1.12969244e+00f, -2.58385211e-01f, -5.40786088e-02f, -1.96590289e-01f, -1.53802231e-01f, -7.72816688e-02f, 1.77852958e-01f, -2.62730151e-01f, -5.05144447e-02f,
  4.16420810e-02f, 1.35287210e-01f, -1.43694207e-01f, 1.39184803e-01f, -2.77885348e-01f, -2.05620930e-01f, -9.59887579e-02f, -2.44022593e-01f, -9.47480947e-02f, -1.58688560e-01f,
  1.49016911e-02f, -1.52123317e-01f, 2.65511237e-02f, 7.16435686e-02f, -2.77848952e-02f, -1.30750954e-01f, 2.79489979e-02f, 1.34091917e-02f, -1.62442788e-01f, -1.54633462e-01f,
  -2.74449378e-01f, 1.29613912e+00f, 4.18958634e-01f, 6.45956337e-01f, -7.95548141e-01f, 4.95371789e-01f, 7.73342252e-01f, -4.55077440e-02f, 4.90345955e-01f, 9.97440040e-01f,
  -4.25828636e-01f, 1.00524187e+00f, 5.12830801e-02f, 7.81181991e-01f, -5.76808393e-01f, 3.16394418e-01f, 5.03167689e-01f, 7.30333865e-01f, -7.92931542e-02f, 2.48873293e-01f,
  -6.86885938e-02f, -8.96493644e-02f, -1.01133972e-01f, -2.85343111e-01f, 1.85373072e-02f, 1.47272706e-01f, -3.84308368e-01f, -4.72335309e-01f, 2.33888671e-01f, -2.47653484e-01f,
  -4.76455800e-02f, 1.19461648e-01f, 2.13212445e-01f, 2.55345821e-01f, 8.80919918e-02f, 5.24326824e-02f, 1.14763841e-01f, -1.53135449e-01f, -2.49924600e-01f, 1.64718285e-01f,
  2.09839463e-01f, -4.28948849e-02f, 1.76890060e-01f, 8.47370848e-02f, 6.18221238e-02f, -4.63276054e-04f, -2.91906446e-02f, -9.30892751e-02f, 1.75852522e-01f, -5.29197864e-02f,
  1.04700699e-01f, 6.28251880e-02f, -2.56298602e-01f, 1.69314325e-01f, -1.57946005e-01f, 1.09156139e-01f, 3.06783020e-01f, 6.24789260e-02f, 2.09346756e-01f, 4.21267152e-02f,
  3.27029228e-02f, 1.27648085e-01f, -8.13521445e-02f, -9.31858793e-02f, 6.51363358e-02f, -2.26857975e-01f, -1.68315675e-02f, -2.38533616e-01f, -1.51458969e-02f, 4.14110459e-02f,
  -5.20394184e-02f, 1.63071215e-01f, -8.97264928e-02f, 1.83227658e-01f, -5.61222667e-04f, 1.30788133e-01f, -6.26162589e-02f, -9.69556626e-03f, 5.95855415e-02f, -1.15992650e-01f,
  -4.88450415e-02f, 9.11206380e-02f, -5.14122518e-03f, -1.40138119e-01f, -1.01416737e-01f, -7.28828833e-02f, 6.86267540e-02f, -7.43690655e-02f, -5.78613579e-02f, -1.66183129e-01f,
  3.30511421e-01f, 9.94147837e-01f, 1.70816630e-01f, 1.06530443e-01f, 1.21155784e-01f, -1.86844300e-02f, 4.80608642e-02f, -3.08994446e-02f, 1.96743146e-01f, 3.35905254e-02f,
  -3.71757671e-02f, 1.47142813e-01f, 2.13203463e-03f, -2.47446686e-01f, 8.96301642e-02f, -1.57898918e-04f, 6.37395903e-02f, 1.06294282e-01f, -4.58323359e-02f, -2.21168082e-02f,
  -3.65597606e-02f, 1.20033711e-01f, -5.72208576e-02f, 1.01731159e-02f, 1.00875109e-01f, -2.63518430e-02f, 1.74860694e-02f, 1.80578381e-02f, -1.38512701e-01f, 1.25494361e-01f,
  -2.18160361e-01f, -4.76865500e-01f, 8.04886103e-01f, -8.69641453e-02f, 1.11452229e-01f, 5.54980516e-01f, 8.87975216e-01f, -1.65875316e-01f, 4.29413944e-01f, -5.75577915e-01f,
  -5.26050091e-01f, -2.98623353e-01f, 3.83574188e-01f, -3.32415849e-01f, 9.49247539e-01f, 6.95373118e-01f, 2.65355110e-01f, 5.42962626e-02f, 1.93572670e-01f, -2.06619993e-01f,
  -2.73783486e-02f, -3.85109365e-01f, 1.02726661e-01f, -5.74583352e-01f, -3.35735172e-01f, -3.86827230e-01f, -4.29583490e-01f, 3.38115215e-01f, -6.50475144e-01f, 2.77218759e-01f,
  -2.54663706e-01f, -2.63800919e-01f, -2.96807289e-01f, 9.66327935e-02f, -9.84002054e-02f, 1.04567349e-01f, 1.77430362e-01f, 2.71437228e-01f, 1.47888511e-01f, -1.54140880e-02f,
  -9.01968926e-02f, 3.65772359e-02f, -2.35565260e-01f, 8.01228285e-02f, 2.37517893e-01f, -1.26178637e-01f, -2.63040084e-02f, -1.31737232e-01f, -9.89472792e-02f, 1.13932177e-01f,
  4.66033630e-03f, 1.31392907e-02f, 6.34040460e-02f, -1.86452359e-01f, 5.34146763e-02f, 2.49499502e-03f, 1.82214633e-01f, 5.93278930e-02f, -5.48719056e-02f, 6.39997572e-02f,
  6.82962909e-02f, 1.94399044e-01f, -8.04828256e-02f, 2.56598331e-02f, 6.10211566e-02f, -5.65854311e-02f, 4.79746312e-02f, -1.35130391e-01f, -1.56463198e-02f, -4.00672257e-02f,
  -1.72443688e-01f, -6.13801442e-02f, 7.78711140e-02f, 1.75497115e-01f, -1.98701620e-01f, -5.09191528e-02f, 1.04746126e-01f, -8.64653755e-03f, -6.08073473e-02f, -5.32569475e-02f,
  -4.33285497e-02f, 1.91995591e-01f, -6.63184226e-02f, 5.49395643e-02f, 6.28800169e-02f, 7.25811496e-02f, -1.23930953e-01f, 1.06696509e-01f, 1.83837172e-02f, 1.75068639e-02f,
  -1.90948233e-01f, -7.96279311e-02f, -2.62987822e-01f, -2.62109667e-01f, 2.44427808e-02f, -3.44425648e-01f, 1.41980802e-03f, -2.16363743e-01f, 1.78730577e-01f, 1.29753016e-02f,
  -1.95056170e-01f, -1.07653528e-01f, 4.49936800e-02f, 1.43101797e-01f, 3.94946337e-02f, -1.20288087e-02f, 1.54232990e-03f, -2.47895584e-01f, -6.99670017e-02f, -2.10047334e-01f,
  -1.77614108e-01f, -6.83622658e-02f, 1.20267145e-01f, -1.77296624e-01f, -2.03860715e-01f, -9.87025127e-02f, -2.58557111e-01f, 2.71001160e-02f, 7.83852637e-02f, 1.72250271e-01f,
  -1.14362788e+00f, 1.40435755e-01f, -4.79518354e-01f, 4.61738974e-01f, -3.67619574e-01f, -6.21187806e-01f, -3.64902578e-02f, 6.67900518e-02f, -2.16405898e-01f, 7.94426560e-01f,
  9.55791712e-01f, -5.53578734e-01f, 6.95530057e-01f, 9.56550956e-01f, -6.64306343e-01f, 7.19011188e-01f, 2.22355306e-01f, 2.24623188e-01f, -2.12571859e-01f, -1.49325533e-02f,
  -1.80910721e-01f, 6.67784095e-01f, 5.21140397e-01f, 1.63320288e-01f, -1.54228685e-02f, -1.50719568e-01f, 5.92976272e-01f, 7.16623217e-02f, 4.95962560e-01f, -1.64976358e-01f,
  7.16025531e-02f, 3.80054712e-01f, -2.51865876e-03f, -1.89797550e-01f, -3.91210094e-02f, -9.32388753e-02f, -1.31028369e-01f, 6.30040020e-02f, -1.43920735e-01f, -4.59284894e-02f,
  -1.81841388e-01f, -5.81259355e-02f, -1.34941950e-01f, 1.69384740e-02f, -2.17130885e-01f, -2.10251138e-01f, -1.45441256e-02f, 1.14701360e-01f, -2.34681694e-03f, -1.20055294e-02f,
  6.32418394e-02f, -1.35085564e-02f, -7.51480386e-02f, 3.96544635e-02f, -8.27399865e-02f, -1.81911513e-02f, -1.31397828e-01f, -6.33364022e-02f, -1.50026292e-01f, -1.04719326e-01f,
  -1.25935748e-01f, 2.94295419e-02f, 5.40209189e-02f, 2.23996684e-01f, -4.86798361e-02f, 7.44384304e-02f, 6.63636997e-02f, -9.47918743e-03f, -2.16346532e-01f, 2.68218629e-02f,
  -8.18676502e-02f, -1.06490396e-01f, 1.54647380e-02f, 2.51509398e-02f, 2.50492152e-03f, 3.63034829e-02f, -1.75450817e-01f, 1.31283095e-02f, -6.48427336e-03f, 7.11473972e-02f,
  1.92774460e-01f, -1.48135081e-01f, 1.24304295e-01f, -2.66241450e-02f, 7.44960383e-02f, 1.11050256e-01f, 1.49642885e-01f, -1.18882824e-02f, 6.78973794e-02f, -1.57183968e-02f,
  1.05457552e-01f, 1.92520618e-01f, 1.81650028e-01f, 5.13560197e-04f, 9.06246975e-02f, -1.89189434e-01f, -8.69167224e-02f, -7.83943683e-02f, 1.77845061e-01f, 2.29243431e-02f,
  -9.00365319e-03f, -1.11137047e-01f, -9.95158255e-02f, 4.88187708e-02f, -9.42776073e-03f, 1.76498786e-01f, 9.38945711e-02f, -1.57857373e-01f, -1.63267002e-01f, -5.27694225e-02f,
  6.05068691e-02f, -2.21577704e-01f, -7.39180148e-02f, -4.86690775e-02f, -9.38164815e-02f, 5.20472117e-02f, -3.08516860e-01f, 9.43611488e-02f, 9.81685612e-03f, -1.30797356e-01f,
  7.41071403e-01f, -6.47023201e-01f, -8.75487924e-01f, 2.76373059e-01f, 5.66663980e-01f, 8.63035083e-01f, 6.45232141e-01f, -1.30700991e-01f, -2.23902270e-01f, -1.19887292e-01f,
  4.95164603e-01f, -4.74427283e-01f, -4.01252538e-01f, 8.36244822e-01f, 9.67578888e-01f, -1.70182750e-01f, 7.38894999e-01f, 3.38304311e-01f, -2.42782637e-01f, -1.60525382e-01f,
  1.80671394e-01f, 9.21396255e-01f, -2.06977710e-01f, -1.19986258e-01f, 4.66728091e-01f, -6.93468571e-01f, -4.05205600e-03f, -5.83378613e-01f, 3.31941932e-01f, 4.44306970e-01f,
  1.20052807e-01f, -5.70182428e-02f, -2.54750494e-02f, 2.41698567e-02f, 4.06034365e-02f, 3.78729869e-03f, -1.59872789e-02f, 7.44054615e-02f, 8.69672671e-02f, -7.59079307e-02f,
  2.19708346e-02f, -3.47219454e-03f, 1.12774529e-01f, 1.54507449e-02f, 3.49941611e-01f, 1.05716221e-01f, -7.70823732e-02f, -1.92033410e-01f, -1.73219189e-01f, -3.74632105e-02f,
  -3.54682058e-02f, -7.73644447e-02f, 8.30542967e-02f, -1.40957996e-01f, -9.38232914e-02f, -2.14691274e-03f, -7.14851767e-02f, -2.04079285e-01f, -7.42270127e-02f, 5.48045970e-02f,
  -3.64699177e-02f, 1.42338187e-01f, 8.73618945e-03f, 2.93539129e-02f, 1.09370746e-01f, 6.59402534e-02f, 2.29969889e-01f, -2.41750181e-02f, -1.84880376e-01f, 1.49541989e-01f,
  5.03850803e-02f, 1.36017755e-01f, -1.39217908e-02f, 1.12053789e-01f, 7.74715990e-02f, -9.70950052e-02f, -3.25485095e-02f, 2.74974089e-02f, -5.34673482e-02f, -1.41028911e-02f,
  -9.59847495e-02f, 7.20604137e-02f, 4.07372527e-02f, -1.85264703e-02f, 5.84750883e-02f, -7.72457942e-02f, 1.10336579e-01f, 1.27711464e-02f, -1.36029586e-01f, -3.75267789e-02f,
  -1.99427530e-02f, -4.68341947e-01f, -1.09435283e-01f, 2.54451148e-02f, -8.86710063e-02f, 5.37685603e-02f, -1.30016804e-01f, -8.84842351e-02f, -5.24161421e-02f, 5.68362139e-02f,
  4.40975800e-02f, -2.03176327e-02f, -1.49195403e-01f, 2.06269324e-02f, -2.45837569e-02f, 5.27924160e-03f, -1.01795137e-01f, -8.24530050e-03f, 3.60181704e-02f, -2.04449877e-01f,
  -6.23821169e-02f, 7.58945420e-02f, 5.33012971e-02f, 9.23061743e-02f, -4.47795354e-03f, 3.62677239e-02f, -1.40466750e-01f, -5.84138706e-02f, 7.04840273e-02f, -1.78883567e-01f,
  -4.90334891e-02f, -7.44913757e-01f, -7.46681765e-02f, -1.16834655e-01f, -1.72393367e-01f, -3.58845145e-01f, 6.39510214e-01f, -9.75880742e-01f, -6.06941104e-01f, -5.25705934e-01f,
  -8.10750797e-02f, 5.36580384e-01f, 8.39049280e-01f, -8.01041603e-01f, 9.67687190e-01f, 4.16142523e-01f, -5.48807621e-01f, 1.51512355e-01f, -1.93780422e-01f, -4.68837440e-01f,
  -7.21275434e-02f, -5.92301250e-01f, 3.62353921e-01f, -9.25878465e-01f, -4.03351605e-01f, -3.41929466e-01f, 3.00047100e-01f, 2.70187825e-01f, -5.14092565e-01f, 2.99595267e-01f,
  -5.60218334e-01f, -6.18153751e-01f, -1.68295249e-01f, -8.50646049e-02f, -2.10454702e-01f, 1.47719800e-01f, 1.61935017e-01f, 6.33800864e-01f, 1.36059016e-01f, 3.29651460e-02f,
  3.32565337e-01f, 1.17522702e-02f, -3.02722901e-01f, 2.73900658e-01f, -2.32416511e-01f, -2.86914170e-01f, -1.23959571e-01f, -1.46362528e-01f, -2.57254004e-01f, 1.02596082e-01f,
  2.66995728e-02f, 6.18673221e-04f, -1.98803529e-01f, 7.44299218e-02f, 1.17075957e-01f, -1.60257146e-01f, 1.11558311e-01f, 2.99371690e-01f, -4.30810712e-02f, -2.18199477e-01f,
  -1.03396177e-01f, 6.91887140e-02f, 1.83920246e-02f, -7.68569559e-02f, -8.40191543e-02f, -1.18762679e-01f, -7.40114152e-02f, 1.45579457e-01f, 1.49441510e-01f, -3.94893773e-02f,
  -1.41018599e-01f, -5.64163327e-02f, -2.11504608e-01f, -4.89434190e-02f, -1.14378268e-02f, -4.15744744e-02f, 3.23017865e-01f, -6.04952835e-02f, -3.54118529e-03f, -4.99484539e-02f,
  3.32418270e-02f, -5.08623719e-02f, 5.54086566e-02f, 6.05915561e-02f, -6.47996143e-02f, 2.56842524e-01f, -1.70334265e-01f, -4.84385155e-03f, -2.71448977e-02f, 2.92836428e-01f,
  -4.64549452e-01f, -7.54049063e-01f, -8.30553996e-04f, -1.41258970e-01f, 3.58199254e-02f, -8.82896706e-02f, -6.34189509e-03f, -2.79514611e-01f, -1.22743472e-01f, -2.04410538e-01f,
  -1.12146690e-01f, 5.30059449e-02f, -1.56324193e-01f, -6.11965396e-02f, -6.48923814e-02f, -7.22029656e-02f, 1.51087970e-01f, 1.19271383e-01f, 5.98470941e-02f, -1.33851305e-01f,
  -2.25399118e-02f, 1.69617787e-01f, 9.03752372e-02f, -2.36770898e-01f, -2.88312677e-02f, 1.50582895e-01f, -7.19764233e-02f, 3.78716178e-03f, -3.50311818e-03f, -1.36872754e-01f,
  -9.94308591e-01f, -4.47567403e-01f, 3.99596244e-01f, -8.61661315e-01f, 1.42594352e-01f, 1.34322023e+00f, 1.25220746e-01f, 1.61050841e-01f, -9.07255590e-01f, 1.87922031e-01f,
  2.47726932e-01f, -8.43993723e-01f, -6.97304457e-02f, -3.27500492e-01f, 1.91353679e-01f, -1.11581199e-01f, 1.78510144e-01f, -7.04031810e-02f, -3.67556095e-01f, 1.19871147e-01f,
  4.57155332e-02f, -1.40269756e-01f, 4.74546462e-01f, 2.05133736e-01f, 2.45661199e-01f, -1.40421314e-03f, 2.92891353e-01f, 2.59106874e-01f, 2.28788957e-01f, -7.56704435e-02f,
  2.39769697e-01f, -3.59893471e-01f, -1.64593756e-02f, 1.50419489e-01f, 4.20675576e-01f, 1.88666239e-01f, 1.60695985e-01f, -7.48244897e-02f, -1.71663597e-01f, -7.06802756e-02f,
  -1.44997075e-01f, -9.60981771e-02f, -2.17744485e-01f, -1.74529999e-01f, -2.67877936e-01f, -1.49696648e-01f, -8.12749118e-02f, 2.29343399e-01f, -7.50517249e-02f, 2.03058943e-02f,
  -4.29410823e-02f, 4.05896455e-02f, 8.78356397e-02f, -5.15824705e-02f, -3.33140232e-02f, -5.28812930e-02f, 1.64119750e-01f, 1.67029008e-01f, -3.74195315e-02f, -1.76559966e-02f,
  -2.13910878e-01f, 8.85651410e-02f, 8.52999240e-02f, -4.49693315e-02f, -9.53820124e-02f, -8.91808197e-02f, -1.73977137e-01f, 1.03676803e-02f, -1.35750091e-02f, 1.95080396e-02f,
  -2.07452662e-02f, -1.20427087e-01f, -2.46319383e-01f, 5.98227642e-02f, -9.75900050e-03f, -2.74386585e-01f, -9.29366145e-03f, 1.27534077e-01f, 4.34219763e-02f, 8.51596519e-02f,
  -1.49408743e-01f, 1.75779350e-02f, 1.32497162e-01f, -6.30831793e-02f, 3.92544037e-03f, 1.00950725e-01f, -6.20163139e-03f, -7.77959675e-02f, 1.72487706e-01f, 4.60995696e-02f,
  4.65327442e-01f, 5.42047285e-02f, 1.27262518e-01f, 4.45717126e-02f, 3.52901444e-02f, 1.08556345e-01f, -1.19363792e-01f, 3.29366401e-02f, 1.37645170e-01f, 2.94288434e-02f,
  1.82700753e-01f, -1.91074330e-02f, 2.66396731e-01f, -1.08360305e-01f, 1.02212310e-01f, 3.51149261e-01f, 1.96698606e-02f, 1.13228917e-01f, 8.59556273e-02f, 8.70635584e-02f,
  1.91009566e-01f, 1.03866473e-01f, -2.68034518e-01f, 4.45955545e-02f, -1.00100689e-01f, 7.21088052e-02f, 5.65204211e-02f, -2.16559060e-02f, -3.12880501e-02f, -7.72200450e-02f,
  -1.55861568e+00f, 1.03100312e+00f, -1.30318657e-01f, -1.37784973e-01f, -3.92240077e-01f, 6.87154472e-01f, 6.54907763e-01f, 1.69194639e-01f, 1.56654030e-01f, 7.46742189e-01f,
  1.54704988e-01f, -8.27036574e-02f, 5.66630781e-01f, 6.31167233e-01f, -3.36177200e-01f, 6.79510772e-01f, 4.06746596e-01f, 2.61740446e-01f, 2.48373479e-01f, -1.78500757e-01f,
  -1.37014061e-01f, 3.16057444e-01f, 1.01610549e-01f, 2.52991945e-01f, -2.60202944e-01f, -1.23245649e-01f, -3.44351262e-01f, 2.74790972e-02f, -2.26165995e-01f, -4.43970831e-03f,
  -8.96654487e-01f, -6.26902759e-01f, -4.77126449e-01f, -2.22907424e-01f, -3.68732572e-01f, -2.19216198e-01f, -1.51381671e-01f, -5.72501076e-03f, -4.94751148e-02f, 1.22616151e-02f,
  -1.13945067e-01f, 6.85832798e-02f, 9.79341716e-02f, 1.11944057e-01f, -1.38287246e-01f, 5.02666607e-02f, 1.52651742e-02f, -1.30441666e-01f, 1.20952696e-01f, 1.85513243e-01f,
  2.00193122e-01f, 1.15210995e-01f, 1.21393658e-01f, 1.50007337e-01f, -7.25294799e-02f, 1.18807800e-01f, 2.11988330e-01f, -6.10377453e-02f, -6.93747848e-02f, -1.05860941e-01f,
  4.36714254e-02f, 1.71209022e-01f, 1.05207935e-01f, -8.31430480e-02f, 6.73644170e-02f, -9.38878953e-02f, 1.51211093e-03f, 1.53910518e-02f, 1.12014569e-01f, 1.40593886e-01f,
  -2.97722518e-02f, -7.71270543e-02f, -1.40795007e-01f, 1.98478214e-02f, -8.85989740e-02f, -7.18133003e-02f, -7.67281279e-02f, -1.05974145e-01f, 4.89139929e-02f, -2.47548372e-01f,
  -4.51230109e-02f, -4.18239832e-02f, 2.70743091e-02f, 2.12051533e-02f, 9.82733890e-02f, -2.72885673e-02f, 1.25890255e-01f, 1.16876930e-01f, -1.21308287e-04f, -1.55220181e-01f,
  -5.53680420e-01f, -4.58050191e-01f, -1.51476145e-01f, -1.33027375e-01f, -6.19514063e-02f, 1.79688893e-02f, -7.71516338e-02f, -1.69393271e-01f, -1.99557506e-02f, 5.08366637e-02f,
  4.94383201e-02f, 2.77181175e-02f, -2.29931742e-01f, -1.20237917e-02f, 9.73595753e-02f, 8.93469229e-02f, -1.52774036e-01f, 6.49530208e-03f, -6.88433871e-02f, -8.99543017e-02f,
  -1.84357777e-01f, 6.40797317e-02f, 1.66840106e-01f, -5.04295640e-02f, 2.13199351e-02f, -1.26833022e-01f, -1.78036034e-01f, 5.71450070e-02f, -2.45028019e-01f, 1.72995701e-01f,
  3.71781319e-01f, 3.90488565e-01f, -5.54695308e-01f, -6.12398624e-01f, 6.92405775e-02f, -2.00723454e-01f, -1.14257112e-01f, 6.80239871e-02f, -6.67114139e-01f, 6.24407113e-01f,
  1.04939491e-01f, -3.44251245e-01f, -5.99652380e-02f, -1.86835811e-01f, -1.02196717e+00f, -7.66715288e-01f, 2.10229486e-01f, 3.59225690e-01f, -2.17483774e-01f, 3.42593074e-01f,
  -2.73074567e-01f, -5.74808829e-02f, -6.12041771e-01f, 1.07554317e-01f, 7.89879620e-01f, 3.32089454e-01f, 5.64682961e-01f, 6.07098117e-02f, 3.13578337e-01f, -2.56529689e-01f,
  -1.40740156e-01f, -6.19257428e-02f, -3.20869870e-02f, -1.69827744e-01f, 8.63808095e-02f, 3.07676345e-01f, 2.33600125e-01f, -1.19778119e-01f, -1.07405402e-01f, 2.15201210e-02f,
  1.80775911e-01f, 8.22473615e-02f, -1.88727394e-01f, -1.60993174e-01f, 4.08864737e-01f, 1.68529794e-01f, -1.79850683e-01f, -3.44412252e-02f, -1.23418026e-01f, 9.47875753e-02f,
  -8.10714737e-02f, 1.91388205e-01f, 2.67883062e-01f, -1.35755584e-01f, -1.56802073e-01f, -4.24956903e-02f, -1.00321420e-01f, 5.18194176e-02f, 9.28036720e-02f, 1.32807106e-01f,
  1.97660506e-01f, 1.57370731e-01f, -5.57721332e-02f, -1.86855588e-02f, -2.36388922e-01f, 5.32164983e-02f, 2.27545984e-02f, 3.13790850e-02f, -4.05624881e-02f, 6.18790612e-02f,
  4.25537042e-02f, 3.24162538e-03f, -7.21386373e-02f, -8.55826802e-05f, 3.39357853e-02f, -5.42953089e-02f, -6.07919656e-02f, 1.09541140e-01f, -1.21000588e-01f, -1.61573842e-01f,
  -1.33752689e-01f, 8.13362896e-02f, -2.06787303e-01f, 3.91177535e-01f, 3.89364385e-03f, -1.01323873e-01f, 1.93775222e-01f, 9.23107415e-02f, -1.08635306e-01f, 1.08409286e-01f,
  3.91268358e-02f, 1.73667952e-01f, -2.03458041e-01f, -2.51116157e-01f, -1.93316773e-01f, 1.31647766e-01f, -1.30203471e-01f, -8.13966393e-02f, 5.06142993e-03f, -1.03366174e-01f,
  1.88230157e-01f, -2.03989614e-02f, 2.75773078e-01f, -1.12247057e-01f, -5.55867143e-02f, 1.03598058e-01f, 2.05457434e-01f, -1.02936015e-01f, 1.43880755e-01f, 1.61555097e-01f,
  1.47953272e-01f, 1.86431408e-01f, 1.30345831e-02f, -9.91950110e-02f, 6.89961016e-02f, 1.12011865e-01f, 1.82450041e-01f, 1.64566748e-02f, 2.98388481e-01f, 7.71737024e-02f,
  -8.28927398e-01f, -2.60992609e-02f, -8.53754461e-01f, -6.72653377e-01f, 6.98974371e-01f, -2.04167992e-01f, -2.79137552e-01f, 9.92461070e-02f, -1.24795243e-01f, 5.92186928e-01f,
  1.94785669e-01f, -1.70388281e-01f, 4.27069902e-01f, -9.40192699e-01f, -1.12792671e+00f, -6.81006551e-01f, -9.15041089e-01f, -5.42546749e-01f, -1.74129367e-01f, -5.22938967e-02f,
  -5.83087742e-01f, 2.53264476e-02f, -8.87324393e-01f, 6.92833304e-01f, -6.20904006e-02f, 1.63753271e-01f, 3.79895478e-01f, 6.30024254e-01f, -1.78799063e-01f, -4.96492162e-02f,
  -2.67080814e-01f, 3.61250788e-01f, -1.33161142e-01f, -4.32068817e-02f, -1.46807944e-02f, 8.11363235e-02f, -3.21270525e-02f, -1.71574399e-01f, 1.20696403e-01f, 1.40612319e-01f,
  5.61654121e-02f, 4.10344265e-02f, 5.77300899e-02f, 2.68275321e-01f, 1.88147485e-01f, 1.33889392e-01f, -1.71207383e-01f, -1.59702912e-01f, 3.00597474e-02f, -2.52232522e-01f,
  -3.61630291e-01f, -3.11873764e-01f, -6.59059510e-02f, 2.00721319e-03f, -8.40741210e-03f, 7.69672915e-02f, -1.04420491e-01f, -6.70085102e-02f, -9.44748670e-02f, -5.69756590e-02f,
  1.51769193e-02f, 2.03084797e-01f, -1.53792098e-01f, -7.97245875e-02f, 6.17997609e-02f, 1.27389124e-02f, 6.71478137e-02f, -2.31125206e-02f, 1.85248494e-01f, 8.68763588e-03f,
  5.22824898e-02f, -2.93954182e-02f, 1.70088321e-01f, 9.32234153e-02f, -5.10742813e-02f, -1.86414510e-01f, -1.52951196e-01f, 6.78061023e-02f, -1.49584129e-01f, -2.82569468e-01f,
  1.57243371e-01f, -2.68430337e-02f, 1.86718494e-01f, 1.10357352e-01f, -2.01356754e-01f, 2.92310745e-01f, 3.00500572e-01f, -4.83855754e-02f, -1.27626015e-02f, 2.48464383e-02f,
  5.90422302e-02f, 2.39656344e-01f, 1.12179823e-01f, 1.46180734e-01f, -1.62535440e-02f, -3.08205876e-02f, -9.28041860e-02f, -3.07174265e-01f, 5.99595867e-02f, 1.45261198e-01f,
  5.75534962e-02f, 8.32489356e-02f, 5.91612943e-02f, -2.89565884e-02f, 7.32865557e-02f, -4.90109213e-02f, 1.57168955e-01f, 1.90019861e-01f, 2.09736153e-02f, -5.03143184e-02f,
  2.12995589e-01f, 2.68054426e-01f, -3.06227710e-02f, 2.35079005e-01f, 3.09677701e-02f, 2.28547733e-02f, 1.30279779e-01f, -5.34467585e-03f, 1.35839488e-02f, 4.09678370e-02f,
  8.98277387e-02f, -3.07551734e-02f, 1.54317066e-01f, 4.82592732e-01f, -3.73297751e-01f, -8.37563992e-01f, -7.27201521e-01f, 1.12124577e-01f, 7.53754318e-01f, -2.75143504e-01f,
  -2.21717596e-01f, 3.24981622e-02f, 2.35077203e-03f, -6.31680608e-01f, 7.29738533e-01f, 2.07229480e-01f, -7.31754676e-02f, -4.38337117e-01f, 2.74956673e-01f, -1.05102010e-01f,
  5.63359797e-01f, -3.96613419e-01f, 6.59277737e-02f, -1.20909967e-01f, -5.38218856e-01f, 2.23619044e-01f, 5.65900683e-01f, -3.18535209e-01f, -2.98790157e-01f, -4.23450619e-01f,
  -1.49492070e-01f, 2.46693283e-01f, 1.29900143e-01f, 5.00027323e-03f, 1.85617805e-01f, -3.05848718e-01f, -2.30677694e-01f, -2.04597086e-01f, 2.15413690e-01f, 4.95950542e-02f,
  1.15725018e-01f, 8.46398324e-02f, -1.69506133e-01f, -2.31130153e-01f, -3.08546629e-02f, 2.23907024e-01f, 7.25741759e-02f, -4.25520279e-02f, -3.99778225e-03f, -1.56969532e-01f,
  3.48255485e-02f, 2.38130644e-01f, 1.26144782e-01f, 3.47751558e-01f, 2.63958901e-01f, 2.26000044e-03f, -1.29511699e-01f, -1.27241731e-01f, 7.16404021e-02f, 1.73462868e-01f,
  -8.26744810e-02f, 1.94937754e-02f, -2.32407823e-01f, -1.21880807e-01f, -1.86743904e-02f, 7.50028864e-02f, 2.60157809e-02f, -9.59382728e-02f, 8.64168704e-02f, 3.66242044e-02f,
  2.36558214e-01f, -8.12881738e-02f, -4.96374480e-02f, -8.94251764e-02f, 4.32892097e-03f, 2.63730101e-02f, -6.62940671e-04f, -4.16326225e-02f, -2.27438267e-02f, 1.12887859e-01f,
  -1.50223821e-01f, -1.63552701e-01f, 1.17602728e-01f, -1.37504816e-01f, -6.62716329e-02f, 3.48233767e-02f, -3.85764427e-02f, -1.53166419e-02f, 4.38179635e-02f, -8.76997039e-03f,
  9.00788233e-02f, 4.58689898e-01f, 1.95196316e-01f, 2.47447751e-02f, 1.13687724e-01f, 7.81037845e-03f, -1.00292996e-01f, 2.72239279e-02f, 2.12300748e-01f, -9.13795382e-02f,
  -8.97362605e-02f, 1.31576836e-01f, 6.93003833e-02f, -1.05651237e-01f, 1.50889739e-01f, 1.79813340e-01f, 5.21534868e-02f, 4.52653766e-01f, 5.36935851e-02f, 1.33147892e-02f,
  -9.33028236e-02f, -1.89517707e-01f, 2.51557499e-01f, 2.11643249e-01f, -1.40303716e-01f, 1.99659064e-01f, 2.52814591e-02f, 9.32847485e-02f, -4.77630906e-02f, 3.83913070e-02f,
  9.43229198e-02f, -1.85108036e-01f, -2.68907189e-01f, 2.26564750e-01f, 3.69187891e-02f, -2.76974053e-03f, -7.89637387e-01f, 2.16619223e-01f, -7.99828410e-01f, -5.25107086e-01f,
  2.36383379e-01f, 1.45549685e-01f, -9.66480076e-01f, 7.09228873e-01f, 1.05802059e+00f, -6.96728230e-01f, 9.30856466e-01f, 4.09196287e-01f, -5.82803115e-02f, 5.73497891e-01f,
  2.76264697e-01f, 9.95145202e-01f, 5.28040051e-01f, 9.25983131e-01f, 3.99687141e-01f, 3.79909545e-01f, 7.44786620e-01f, 1.38427898e-01f, 1.02779138e+00f, 5.83520651e-01f,
  -2.31095329e-02f, 4.19788733e-02f, -1.41754150e-01f, -1.91651866e-01f, 5.49762808e-02f, -6.23565689e-02f, 8.22376052e-04f, 1.41457751e-01f, -2.66766157e-02f, -3.38015822e-03f,
  -4.44178432e-02f, 3.76805812e-01f, 1.53035194e-01f, 9.37574450e-03f, -7.40644559e-02f, 7.35553503e-02f, -9.67881270e-03f, -1.17212877e-01f, -1.77777350e-01f, -8.78333002e-02f,
  -2.64651328e-01f, 6.32290840e-02f, 1.14100873e-01f, -2.35774163e-02f, 9.19589028e-02f, 6.65867627e-02f, -9.54221785e-02f, 1.45205297e-03f, 2.12185875e-01f, 1.22398414e-01f,
  2.74683267e-01f, -1.05270214e-01f, -2.68370807e-02f, -2.15782747e-01f, 5.83189204e-02f, -9.99557376e-02f, 8.05320442e-02f, -3.32730003e-02f, 6.62591960e-03f, -9.28076506e-02f,
  -3.50922383e-02f, 1.15386337e-01f, -1.80913314e-01f, -1.08212672e-01f, 9.69658941e-02f, -1.94027305e-01f, 9.82028469e-02f, 1.07748866e-01f, -2.05596268e-01f, -9.77627039e-02f,
  -5.01418263e-02f, 1.05492003e-01f, -1.41846955e-01f, 7.43214786e-03f, -1.21164717e-01f, -6.60826787e-02f, 1.46037310e-01f, -9.28997621e-02f, -7.93396384e-02f, 1.75731182e-01f,
  1.80228204e-01f, 4.68141735e-01f, -1.38259277e-01f, -7.34339887e-03f, 2.09884369e-03f, 2.46748760e-01f, 1.66504504e-03f, 2.61669368e-01f, 2.44543165e-01f, 5.61048789e-03f,
  1.77289858e-01f, -7.26114064e-02f, -1.49003536e-01f, 9.84737426e-02f, 1.63462371e-01f, 1.10373497e-02f, 8.28707069e-02f, -1.97292909e-01f, 1.45401821e-01f, 4.40423936e-01f,
  -2.11829669e-03f, -1.43464550e-01f, 7.41235316e-02f, -8.60872120e-02f, 6.35040551e-02f, -6.56926408e-02f, 7.79637843e-02f, 3.37562747e-02f, 2.12207153e-01f, -1.31961405e-01f,
  1.00059962e+00f, -4.57800664e-02f, -3.74639243e-01f, 4.11709666e-01f, 2.14577615e-01f, 5.69935679e-01f, 8.01010609e-01f, 3.92630994e-01f, 8.69953632e-01f, 1.48058087e-01f,
  6.30878508e-02f, -1.97267532e-01f, 1.11332580e-01f, 1.21184811e-01f, 4.00184184e-01f, 2.43629485e-01f, 4.55137849e-01f, 1.46463230e-01f, 4.15023506e-01f, 4.08913404e-01f,
  3.51784974e-01f, 4.22636211e-01f, -5.96951902e-01f, -5.73013872e-02f, 1.53820813e-01f, -2.10210994e-01f, -4.01195705e-01f, -2.89793640e-01f, -6.33077919e-01f, -1.30657330e-01f,
  -5.60151935e-02f, 3.90217423e-01f, -2.28249714e-01f, -7.31172115e-02f, 1.65673643e-01f, -1.29301533e-01f, -2.09218994e-01f, -2.01027259e-01f, -1.27714127e-01f, 1.34440586e-01f,
  -2.73461696e-02f, -5.90615608e-02f, 1.10014997e-01f, 6.21101074e-02f, 3.80903147e-02f, -1.75282478e-01f, -5.16288020e-02f, -1.89191997e-01f, -1.51833355e-01f, 8.86973646e-03f,
  1.66141354e-02f, -1.60683975e-01f, 7.60415494e-02f, -9.29161906e-02f, -3.51677253e-03f, 1.00629993e-01f, -9.93836448e-02f, -1.27286673e-01f, -8.72084945e-02f, 2.78047293e-01f,
  1.71232626e-01f, 1.78351119e-01f, 1.38596058e-01f, -2.39826664e-02f, 6.05852343e-02f, -1.79460272e-01f, 9.06862505e-03f, -1.36772126e-01f, 9.87209752e-02f, -5.16125280e-03f,
  -8.81352127e-02f, 4.11299877e-02f, 1.55954987e-01f, 4.17646840e-02f, 2.05135882e-01f, 9.86792073e-02f, -2.37911828e-02f, 1.40306465e-02f, 1.71809331e-01f, -3.40809971e-02f,
  7.10829049e-02f, 8.92963707e-02f, 9.08777863e-02f, -2.13686854e-01f, 7.87966624e-02f, 1.63084269e-01f, 1.78405911e-01f, 4.63700257e-02f, -1.86076146e-02f, -7.06223249e-02f,
  1.93292782e-01f, 6.25060022e-01f, 8.05193260e-02f, -1.24580152e-01f, -2.32959658e-01f, 1.02103435e-01f, 6.72884062e-02f, 1.93337187e-01f, 1.73281431e-01f, 2.84012258e-01f,
  -2.76672095e-02f, -1.77594021e-01f, -5.02166301e-02f, -1.46044672e-01f, -2.52182186e-01f, 2.33791083e-01f, 3.34331393e-02f, -5.74530568e-03f, 1.13879628e-01f, -1.38598189e-01f,
  -2.11438075e-01f, 3.15007210e-01f, -1.16882257e-01f, -6.46201428e-03f, -6.84877187e-02f, -4.04879190e-02f, 1.81500465e-01f, -8.59036073e-02f, -9.22379643e-02f, -1.55021459e-01f,
  -1.17343080e+00f, 1.26249576e+00f, 7.92608038e-03f, -1.02544963e+00f, 1.11824520e-01f, -3.41917306e-01f, -6.87908411e-01f, 7.88630173e-02f, -1.81769311e-01f, -1.76825270e-01f,
  -5.30122221e-01f, 4.28655475e-01f, 5.04074335e-01f, -4.08423841e-01f, -2.40667090e-01f, 3.61894011e-01f, -8.63025069e-01f, -6.28599107e-01f, 4.28961068e-01f, -4.88421798e-01f,
  -2.85502583e-01f, -7.14696050e-01f, -6.76191598e-02f, 2.95318574e-01f, -3.63732457e-01f, -1.82003692e-01f, -5.64404964e-01f, 3.12178135e-01f, -4.67678457e-01f, 3.39617193e-01f,
  -1.99739262e-01f, -2.82991797e-01f, 6.21351153e-02f, -1.19834550e-01f, -4.00999963e-01f, -1.33465946e-01f, -3.19368571e-01f, 5.21192476e-02f, 3.98259424e-02f, 1.20427065e-01f,
  1.42509835e-02f, 2.84975827e-01f, -1.00909121e-01f, 1.53025895e-01f, 2.46384572e-02f, 1.64973497e-01f, 1.59934625e-01f, -8.39344785e-02f, 2.09429190e-01f, 3.18514824e-01f,
  2.44484067e-01f, 3.12469870e-01f, -3.05540264e-01f, -1.21271253e-01f, 7.44079947e-02f, -5.94070591e-02f, -2.77798697e-02f, 5.83336093e-02f, -4.40668687e-02f, -1.05898425e-01f,
  2.86623798e-02f, -1.60691917e-01f, 8.90456215e-02f, -1.29460454e-01f, 8.78008083e-03f, 1.15874792e-02f, 2.53456775e-02f, -4.70859706e-02f, -4.95906286e-02f, -1.33915290e-01f,
  -7.66538898e-04f, 6.15005828e-02f, -6.33133948e-02f, -1.58322260e-01f, -1.49563432e-01f, -2.17061296e-01f, -7.40477666e-02f, -5.29385358e-02f, -9.20493994e-03f, -1.34198209e-02f,
  9.57556441e-03f, -3.03123854e-02f, 2.99129244e-02f, -4.98769358e-02f, -5.56655601e-03f, 5.54794483e-02f, 3.94325890e-02f, 3.00824434e-01f, 2.73808707e-02f, -2.42155939e-01f,
  -6.16981864e-01f, -9.19868052e-01f, -9.56988484e-02f, 8.44711438e-02f, -4.05463204e-02f, 1.30833134e-01f, 4.41066138e-02f, 9.49037522e-02f, -2.41701692e-01f, -2.83637166e-01f,
  -1.56586140e-01f, -2.82640666e-01f, -1.85523242e-01f, -1.26478449e-01f, -4.28413302e-02f, 2.62006093e-02f, -3.83426875e-01f, -2.81481445e-01f, -4.51585144e-01f, -3.32250930e-02f,
  -1.29915357e-01f, -9.17312428e-02f, -8.93674865e-02f, -1.81393445e-01f, -2.27684006e-01f, -1.41302362e-01f, -2.66192049e-01f, 3.24965656e-01f, 6.02354622e-03f, -6.97472990e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.10876429e+00f, 1.05226481e+00f, 1.04924452e+00f, 2.59298533e-01f, 9.71253574e-01f, 4.21550483e-01f, 1.02599156e+00f, 5.67082822e-01f, 8.56292367e-01f, 6.23500705e-01f,
  9.08349097e-01f, 8.75902534e-01f, 9.11523998e-01f, 6.68256760e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -8.23516786e-01f, -5.80774844e-01f, -8.64088118e-01f, 3.71506989e-01f, -5.79873204e-01f, 1.33953583e+00f, -6.89537898e-02f, -2.55635940e-02f, 1.91377133e-01f, 8.69455278e-01f,
  -2.02522963e-01f, -6.13016605e-01f, -7.63894618e-01f, -1.18881428e+00f, -6.54458940e-01f, -7.82412052e-01f, -3.02191257e-01f, -1.45247507e+00f, -1.70717800e+00f, 7.55667537e-02f,
  -1.26247418e+00f, 4.85142088e-03f, 1.06845057e+00f, -4.95451778e-01f, -3.95160615e-01f, -3.11961621e-01f, 6.27039373e-01f, -4.53280151e-01f, -1.19485986e+00f, 2.03094393e-01f,
  7.53431916e-01f, -1.07011461e+00f, 4.20302898e-01f, 8.21976781e-01f, 1.32115796e-01f, -1.04548562e+00f, -6.42332613e-01f, -9.79014993e-01f, 9.19983208e-01f, -3.90243322e-01f,
  -2.14987755e-01f, -1.07145500e+00f, -9.18230236e-01f, -4.27222364e-02f, -6.34172261e-01f, 9.11745012e-01f, -1.10915375e+00f, -6.26534402e-01f, -1.22448824e-01f, 7.01122999e-01f,
  -9.14596856e-01f, -3.59132051e-01f, -1.47166800e+00f, 7.39542663e-01f, -1.08278251e+00f, -4.90315795e-01f, -1.37918830e+00f, 1.84053898e-01f, -2.93611977e-02f, 9.53052640e-01f,
  -1.52141765e-01f, -1.25553274e+00f, -1.02545535e-02f, 7.41871834e-01f, 4.43887681e-01f, 3.65915447e-02f, -1.12599775e-01f, -4.44432884e-01f, 4.40444887e-01f, -4.34349716e-01f,
  -1.34961891e+00f, -5.80234408e-01f, 1.13352454e+00f, 6.36855960e-01f, -7.57728934e-01f, -6.09233260e-01f, -2.02037677e-01f, 1.71277598e-01f, -7.54030347e-01f, 6.95658207e-01f,
  5.47564626e-01f, -2.13427573e-01f, -5.87624371e-01f, 1.14446545e+00f, 5.39531946e-01f, -1.57951689e+00f, -6.13041759e-01f, -5.27419925e-01f, -7.31548369e-01f, 4.09777015e-01f,
  -1.19171989e+00f, -5.00726521e-01f, 2.20824718e-01f, -3.75514209e-01f, 8.03943217e-01f, -8.27574432e-01f, -7.55975485e-01f, 5.81187494e-02f, 1.11674845e+00f, -1.43392849e+00f,
  2.23961696e-01f, -2.89776772e-01f, 5.18948853e-01f, -7.46501029e-01f, -7.65098035e-01f, -1.01225340e+00f, -7.08992302e-01f, -8.30202699e-01f, 3.87395978e-01f, -1.12253106e+00f,
  7.05974698e-01f, -8.21029902e-01f, -2.75812894e-01f, -6.91077769e-01f, -1.16131771e+00f, -9.94866490e-01f, -1.86786994e-01f, -5.79615116e-01f, -8.25836241e-01f, 7.57933378e-01f,
  -7.33870566e-01f, -1.11126626e+00f, -4.94421840e-01f, 5.65266460e-02f, 1.04531693e+00f, -2.95897871e-01f, 2.50993818e-01f, 6.09054804e-01f, -6.26016140e-01f, 1.16676831e+00f,
  -2.31299713e-01f, 4.48484812e-03f, -8.56259465e-01f, 8.06700110e-01f, -1.30456090e+00f, -6.84877872e-01f, -6.64269030e-01f, -8.80278051e-01f, -1.93256140e-01f, -1.05875683e+00f,
  6.82030380e-01f, 8.62161517e-01f, -3.05799562e-02f, -7.33072221e-01f, 6.01116121e-01f, -3.31182271e-01f, -2.94356614e-01f, -1.13062584e+00f, 9.56279874e-01f, -5.73363125e-01f,
  2.43193269e-01f, 1.33599603e+00f, 1.65626645e-01f, -9.33068752e-01f, -4.98418778e-01f, -1.14016438e+00f, -7.12276399e-01f, -5.94349205e-01f, -6.46763146e-01f, -9.70454216e-01f,
  -1.13115042e-01f, 9.84059989e-01f, -1.05761445e+00f, -6.00602150e-01f, -7.52526700e-01f, -2.33281717e-01f, -4.32059646e-01f, -3.25921714e-01f, 5.69282532e-01f, -1.32047188e+00f,
  1.13318992e+00f, 8.00226033e-01f, -6.12997949e-01f, -3.09163779e-01f, -8.38425875e-01f, -8.35050106e-01f, 6.25640094e-01f, -1.75091147e-01f, 1.05867112e+00f, 1.07214534e+00f,
  -1.15404952e+00f, -1.53101891e-01f, -1.48158288e+00f, -3.30361724e-01f, -6.06104612e-01f, -7.82447219e-01f, 5.38221776e-01f, -8.24984670e-01f, -1.70644745e-01f, -5.27290583e-01f,
  -1.26793420e+00f, 2.88528353e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.35341594e-01f, -6.23757206e-02f, -2.90927082e-01f, -3.00177693e-01f, 3.30168158e-01f, 2.76644826e-01f, 7.68654570e-02f, -4.20834757e-02f, -7.77973682e-02f, 2.01021895e-01f,
  -1.15767680e-01f, 2.28706971e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    